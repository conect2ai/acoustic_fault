/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.51657939e-01f, 2.33103007e-01f, -1.39376700e-01f, 1.84013903e-01f, 7.69578591e-02f, -1.22705929e-01f, -5.66848516e-02f, 3.50857042e-02f, 1.64528906e-01f, 1.65860936e-01f,
  5.87873999e-03f, 3.30970846e-02f, -6.21159114e-02f, -1.06599197e-01f, -2.43940592e-01f, -9.19850245e-02f, -9.51870829e-02f, -2.28114292e-01f, -2.03060016e-01f, -6.13131635e-02f,
  2.15161834e-02f, 1.98069178e-02f, -5.77454045e-02f, -2.71418970e-02f, 2.24266157e-01f, 7.33275265e-02f, 1.58138722e-01f, 1.47658974e-01f, -7.15951174e-02f, 3.18822920e-01f,
  1.06900074e-01f, 1.07866332e-01f, -2.00992852e-01f, 1.18320901e-02f, -7.80831208e-04f, -1.22852907e-01f, -1.09206261e-02f, 1.00506633e-03f, -4.06506024e-02f, 6.20448552e-02f,
  -5.77628501e-02f, -3.51242982e-02f, 9.51354653e-02f, -1.72434840e-02f, 8.36498365e-02f, -8.05259496e-02f, 7.31370179e-03f, 2.52914727e-02f, -1.21775992e-01f, 1.30128143e-02f,
  -8.02332908e-02f, -3.29658315e-02f, -7.32131302e-03f, -1.88639145e-02f, -1.08744971e-01f, -1.12515539e-01f, 3.75638008e-02f, 2.09829714e-02f, -2.45342273e-02f, 1.86583817e-01f,
  2.09246408e-02f, 4.68565784e-02f, -3.62500339e-03f, 3.84425670e-02f, 1.14846407e-02f, 3.09232008e-02f, -4.10591625e-02f, 5.57292067e-02f, 5.41343056e-02f, -2.45016422e-02f,
  -1.04205254e-02f, 5.32725779e-03f, 3.30510326e-02f, -4.63883691e-02f, 3.49372923e-02f, 1.95222795e-02f, -3.28869596e-02f, 2.21499670e-02f, -2.71514542e-02f, 1.31402025e-02f,
  -2.45329514e-02f, 2.83276569e-03f, 6.03210665e-02f, -3.11892759e-02f, 1.11890854e-02f, -9.05958638e-02f, 3.50004099e-02f, -3.63132581e-02f, 7.08339661e-02f, -4.03900072e-02f,
  9.04425159e-02f, -2.90793419e-01f, 5.68480231e-02f, -1.25162685e-02f, 4.76751849e-02f, 2.58352514e-03f, 7.51936808e-02f, -1.92665290e-02f, -6.79145008e-03f, -1.43463565e-02f,
  -7.38861710e-02f, 4.41857800e-02f, 2.16452368e-02f, -9.32898298e-02f, -7.51380846e-02f, 1.05332388e-02f, 3.93151939e-02f, -6.43386319e-02f, -8.02327842e-02f, 2.24728361e-02f,
  1.11925982e-01f, 2.54033152e-02f, -4.50785868e-02f, -6.74121901e-02f, 6.22092150e-02f, -7.79870376e-02f, 3.77471149e-02f, -1.31764803e-02f, -1.30653471e-01f, 4.92039807e-02f,
  -2.38713175e-02f, -2.73858756e-02f, 1.02769412e-01f, 1.04866680e-02f, -4.02180143e-02f, -1.07060093e-02f, 2.04213142e-01f, -6.86705336e-02f, -7.04201534e-02f, 8.93770531e-02f,
  -1.97918758e-01f, -2.34625354e-01f, -2.22753152e-01f, -1.14482068e-01f, 1.06476322e-02f, 1.26319468e-01f, 3.13122094e-01f, 1.93082720e-01f, -1.14834309e-01f, -4.30431776e-02f,
  -6.97746351e-02f, 6.08969852e-02f, 5.58105223e-02f, -9.80653316e-02f, 1.29906043e-01f, -1.98348567e-01f, 2.89967563e-02f, 3.64428908e-02f, -1.25843227e-01f, 2.83209950e-01f,
  -3.28320786e-02f, 5.99567816e-02f, -1.61000807e-02f, -9.62464372e-04f, -1.62124075e-02f, 2.34884350e-03f, 2.60907840e-02f, -1.33518651e-02f, -8.73420388e-02f, -1.25052668e-02f,
  -6.11917116e-02f, -5.05149271e-03f, 7.25169107e-02f, -1.60189532e-02f, 5.64312190e-02f, -6.32535592e-02f, -2.94083962e-03f, 9.36677009e-02f, 4.66519259e-02f, -1.54992274e-03f,
  -6.71954304e-02f, -6.08951524e-02f, 6.26517609e-02f, -2.66130567e-02f, 2.84074582e-02f, 2.51632668e-02f, -4.95705940e-02f, -4.16787341e-02f, -7.80806839e-02f, 7.82089382e-02f,
  2.53292080e-02f, -4.61058691e-03f, -2.38337198e-05f, -1.53146917e-02f, -1.81907713e-02f, -5.91516942e-02f, 6.64976239e-02f, -2.61113755e-02f, -4.68309633e-02f, 3.57510149e-02f,
  -1.68647561e-02f, -3.12098581e-02f, 3.88821326e-02f, -1.45094646e-02f, -2.45575067e-02f, 6.53351545e-02f, 7.72209018e-02f, 1.38244312e-02f, -8.61812104e-03f, 1.57155953e-02f,
  -2.50824019e-02f, 4.34708893e-02f, 5.88770136e-02f, -6.57804171e-03f, -4.50466480e-03f, -5.30036502e-02f, -6.19038679e-02f, -2.33020051e-03f, -3.82722579e-02f, 4.19004858e-02f,
  -9.23853144e-02f, -2.35387646e-02f, 3.62268910e-02f, 8.38564932e-02f, 3.47344279e-02f, 1.73868798e-02f, -8.94414485e-02f, 3.30026746e-02f, 4.21586558e-02f, -3.08035058e-03f,
  4.48147170e-02f, 2.89456150e-03f, -7.65730217e-02f, -7.60973338e-03f, 7.57104112e-03f, 3.47167626e-02f, -5.02492301e-02f, 1.14402687e-02f, -4.37603472e-03f, 2.54781209e-02f,
  5.91586642e-02f, 3.06100640e-02f, -7.94349518e-03f, -7.66162621e-03f, -3.23430542e-03f, -2.88519002e-02f, 1.97407557e-03f, -1.99520439e-02f, -4.51595383e-03f, -4.06760946e-02f,
  4.36787426e-01f, -9.40101966e-03f, -1.35183066e-01f, 2.23805472e-01f, 1.07184015e-01f, -1.30743846e-01f, -1.35390416e-01f, -5.67511655e-03f, 1.15952119e-01f, -9.55094621e-02f,
  7.40490779e-02f, 1.58056110e-01f, 9.91497263e-02f, 5.96355125e-02f, 2.60557812e-02f, -2.63345748e-01f, -1.39961749e-01f, -1.42874748e-01f, 5.80539228e-04f, 6.22162223e-02f,
  1.07868724e-02f, 1.49431109e-01f, 1.14937313e-01f, 1.03319556e-01f, -1.95808932e-01f, -3.09024937e-02f, -9.04317051e-02f, -2.88127288e-02f, -1.67058647e-01f, -3.32710207e-01f,
  -1.61118075e-01f, 1.45987287e-01f, -4.09390545e-03f, 1.52679116e-01f, 1.84893201e-03f, -6.64622337e-02f, 2.18340242e-03f, -2.44556442e-02f, 8.66124406e-02f, -3.58294994e-02f,
  1.26686275e-01f, 6.34394437e-02f, 2.35046353e-02f, 6.77207857e-02f, 5.63372225e-02f, -1.73614603e-02f, 2.32682806e-02f, -1.01653123e-02f, -6.21058755e-02f, -4.12788242e-02f,
  2.40048803e-02f, 6.89991787e-02f, -5.90301678e-02f, -1.04515165e-01f, -1.11946985e-02f, 8.32149908e-02f, -1.52136445e-01f, -1.79368287e-01f, -1.85261950e-01f, -2.01291680e-01f,
  1.03924423e-02f, -1.88026833e-03f, 2.58153789e-02f, -1.73519738e-02f, 3.61819565e-03f, -2.17039902e-02f, -1.86070129e-02f, 1.10090915e-02f, -1.03718543e-04f, -4.62838113e-02f,
  4.33986187e-02f, -3.79605703e-02f, -4.74900147e-03f, -5.61291464e-02f, 2.19708458e-02f, 1.64725464e-02f, -1.48613714e-02f, -7.59716406e-02f, 6.90694079e-02f, -2.67919786e-02f,
  4.16005366e-02f, -1.54464990e-02f, -1.67175662e-02f, 1.10853165e-02f, -6.15317747e-02f, 2.90359631e-02f, -4.80264649e-02f, 1.56111047e-02f, 8.76432136e-02f, 6.13829792e-02f,
  8.17836598e-02f, 4.61151674e-02f, -3.96213867e-02f, 6.89372569e-02f, 3.49351168e-02f, 6.23498075e-02f, -7.72991255e-02f, -2.68928483e-02f, 2.09560292e-03f, -4.01980095e-02f,
  4.46780324e-02f, -5.29658794e-02f, 1.57209039e-02f, -7.46219531e-02f, 7.14033544e-02f, -3.07103097e-02f, 9.25534368e-02f, -6.39301213e-03f, 4.50205170e-02f, -6.82035554e-03f,
  4.47249934e-02f, -8.12356919e-02f, 9.33095887e-02f, -6.00044727e-02f, 6.14392683e-02f, 6.36288151e-02f, -8.59499425e-02f, -1.36735901e-01f, 1.61346339e-03f, -1.63396075e-01f,
  -1.51633382e-01f, 4.67143841e-02f, 1.38061563e-03f, -3.18757519e-02f, -4.68494631e-02f, -1.48613691e-01f, -8.57424363e-02f, -6.50784001e-02f, 4.72217724e-02f, 3.50658223e-02f,
  -5.41814044e-02f, 6.34986088e-02f, 5.32878898e-02f, 9.61280763e-02f, 6.86850399e-02f, 8.56616572e-02f, 2.65463591e-01f, 6.24863543e-02f, -1.82115901e-02f, 2.23237108e-02f,
  1.03324883e-01f, 1.11396581e-01f, 5.86797521e-02f, 9.15897451e-03f, 1.78021416e-01f, 6.12856401e-03f, -1.37893511e-02f, 1.28379324e-02f, 8.74113068e-02f, 3.00135851e-01f,
  1.59499850e-02f, -1.38839707e-01f, 3.14780846e-02f, 1.17987171e-01f, -1.91598330e-02f, -7.25659281e-02f, -2.39795409e-02f, 6.38431236e-02f, -6.74264506e-02f, -2.51528854e-03f,
  -2.29178797e-02f, 3.36149707e-02f, -1.89965069e-02f, -4.07998934e-02f, -5.98008595e-02f, -2.05027554e-02f, -3.98850255e-02f, -1.66605338e-02f, -4.61742468e-02f, -7.62877017e-02f,
  1.30893635e-02f, -2.90215686e-02f, -7.41457492e-02f, 8.53306353e-02f, -7.97518045e-02f, 3.66428518e-03f, -4.96445894e-02f, -6.00461923e-02f, 5.00870086e-02f, 8.25352594e-02f,
  4.77608293e-02f, -3.98239009e-02f, -2.25134827e-02f, 4.93685119e-02f, 2.20370758e-02f, 2.54587270e-02f, 6.45944402e-02f, 5.46853989e-02f, 4.95676659e-02f, 1.62244420e-02f,
  -1.36575699e-02f, -5.88893779e-02f, -1.77844632e-02f, -3.51584591e-02f, 1.40057709e-02f, -3.31293680e-02f, -3.33357863e-02f, -1.25758620e-02f, 3.29156704e-02f, 4.00273390e-02f,
  2.80221086e-02f, -8.98309350e-02f, 2.50562299e-02f, 4.43188474e-02f, 8.27172473e-02f, -3.46936239e-03f, -1.28338113e-02f, -9.12471674e-03f, -2.29622312e-02f, -5.40322512e-02f,
  -2.20551297e-01f, -2.24558637e-02f, 8.40614364e-02f, 4.21241522e-02f, -6.40968382e-02f, 3.02199032e-02f, 7.43290083e-03f, 2.63108667e-02f, -1.23849260e-02f, -3.64722800e-03f,
  -3.80387828e-02f, 4.30286787e-02f, -7.50706568e-02f, -3.25555145e-03f, 3.04200500e-03f, 3.93350571e-02f, 8.03053379e-02f, 1.08942479e-01f, 7.36504868e-02f, 3.59352678e-02f,
  3.99294980e-02f, -6.37440309e-02f, -6.53932691e-02f, -4.89327423e-02f, 5.08453920e-02f, 1.31328866e-01f, -1.24987727e-02f, 3.61748450e-02f, -6.99171871e-02f, 3.03469673e-02f,
  -3.41961696e-03f, -4.98439483e-02f, 1.26408279e-01f, 1.30358383e-01f, 4.82550785e-02f, 3.23523879e-02f, -7.93479457e-02f, -4.20814604e-02f, 8.71547163e-02f, -1.25656588e-04f,
  9.88010168e-02f, -8.75276327e-03f, -6.41134679e-02f, -8.52180198e-02f, -6.70888573e-02f, -1.05016224e-01f, -7.85314012e-03f, 1.07500982e-02f, 9.76272598e-02f, 9.14217830e-02f,
  7.37745911e-02f, 1.18241966e-01f, 7.61951879e-02f, 7.73753226e-02f, -3.39127309e-03f, -9.37675126e-03f, -3.69215533e-02f, -7.59263663e-03f, -1.41496118e-03f, -1.00937992e-01f,
  1.97133482e-01f, -5.76801263e-02f, 1.15757016e-02f, -8.12232420e-02f, -3.16277593e-02f, -1.75725818e-02f, 9.06244665e-02f, 1.16598353e-01f, 8.30577463e-02f, 4.20702621e-03f,
  9.93626267e-02f, -3.51657085e-02f, 4.09957431e-02f, 5.55489101e-02f, 9.32018906e-02f, -5.63984849e-02f, -5.18011227e-02f, 6.30740002e-02f, 5.25137968e-02f, 2.81394483e-03f,
  -7.62240887e-02f, 6.32363930e-02f, 4.63948660e-02f, 4.18731347e-02f, 6.77178949e-02f, 2.00219685e-03f, 5.90307191e-02f, -4.80130538e-02f, 4.12478484e-02f, -5.75578725e-03f,
  -9.00425985e-02f, -1.13188904e-02f, 3.46481241e-02f, 6.06542006e-02f, 1.08968029e-02f, 2.52264328e-02f, -8.83504599e-02f, 4.19459678e-02f, -6.32595047e-02f, -7.92114735e-02f,
  -1.31228464e-02f, 2.55869143e-02f, -3.93889546e-02f, 5.13941757e-02f, -4.68286611e-02f, 4.59797233e-02f, -7.14082792e-02f, 3.38300206e-02f, -5.54816984e-02f, -5.06324284e-02f,
  8.07460696e-02f, -3.50687951e-02f, 4.39997623e-03f, -7.64062181e-02f, -2.83749476e-02f, -4.23314162e-02f, 2.29558852e-02f, -6.95511401e-02f, 6.98680282e-02f, 7.41108786e-03f,
  2.35699728e-01f, -1.48411706e-01f, -2.55847089e-02f, 3.66958901e-02f, -3.93359326e-02f, -5.47114946e-02f, 2.78325547e-02f, -3.92231606e-02f, -3.23861241e-02f, 6.42332733e-02f,
  3.62849832e-02f, -3.08316853e-02f, -1.72123816e-02f, 4.14085854e-03f, 2.14838795e-02f, 4.72241640e-02f, -1.73953511e-02f, -6.04229197e-02f, 8.09812099e-02f, 6.35014474e-02f,
  -3.34555507e-02f, 8.14196467e-02f, 2.77271159e-02f, 4.42099459e-02f, 4.88071851e-02f, -2.45716758e-02f, -2.12833453e-02f, -5.58901280e-02f, -1.24145336e-01f, -3.98216434e-02f,
  5.66836417e-01f, 2.59463847e-01f, -4.74860258e-02f, 1.03251919e-01f, 1.94565561e-02f, 4.92207408e-02f, 1.21880561e-01f, 5.00956289e-02f, 1.26418215e-03f, 1.42143533e-01f,
  -7.93072730e-02f, -3.08578908e-01f, -2.81806350e-01f, -2.05801636e-01f, -1.11887045e-01f, 4.14030552e-02f, 1.32010251e-01f, -3.80327702e-02f, -2.66094267e-01f, -7.93813542e-02f,
  -4.47097933e-03f, 1.99604496e-01f, 1.73497066e-01f, -1.36743739e-01f, 1.23370118e-01f, -1.95101023e-01f, 3.66738774e-02f, 4.91270348e-02f, -1.27177432e-01f, 3.65108438e-02f,
  -1.09727621e-01f, 1.70847446e-01f, -1.22219056e-01f, 4.86077964e-02f, 3.14753614e-02f, 1.99625771e-02f, -3.93158905e-02f, 4.43768874e-02f, -6.00607891e-04f, 3.91358137e-02f,
  4.03395258e-02f, 1.04312114e-02f, -9.79028568e-02f, -5.51643856e-02f, 1.40622169e-01f, 1.88245960e-02f, 6.56183809e-02f, 7.17519373e-02f, -5.94991492e-03f, 5.53811379e-02f,
  -6.45002201e-02f, 1.67555828e-02f, 1.20198198e-01f, -2.79351864e-02f, 8.06418434e-03f, -1.07950732e-01f, 8.06004480e-02f, 1.20161518e-01f, -3.93011943e-02f, 2.44691610e-01f,
  -5.10982722e-02f, -2.45057009e-02f, 1.97622273e-02f, 1.82082932e-02f, -1.96283143e-02f, 2.59313323e-02f, -1.93881411e-02f, 4.99881357e-02f, -6.60503805e-02f, 7.01432005e-02f,
  -5.87751344e-02f, 8.99320841e-02f, -2.55993791e-02f, 8.63161609e-02f, -1.07930079e-01f, 3.69015038e-02f, -1.80793535e-02f, 3.74134965e-02f, 2.74915285e-02f, 1.33233108e-02f,
  4.56237532e-02f, -8.41566101e-02f, 8.48981142e-02f, -6.88816682e-02f, 1.59334373e-02f, -7.65343457e-02f, -4.07811478e-02f, -8.05823281e-02f, -2.14583240e-02f, 4.82857861e-02f,
  6.40491322e-02f, -1.31172523e-01f, 4.45360914e-02f, -3.75477187e-02f, -2.66319402e-02f, -2.87351850e-02f, -1.80183034e-02f, -7.88701326e-02f, -4.18381244e-02f, 4.52665351e-02f,
  4.38413769e-02f, 5.91821373e-02f, 5.51222190e-02f, 1.61612052e-02f, -1.19944839e-02f, -8.81233346e-03f, 2.92649046e-02f, -9.86379534e-02f, -3.58355157e-02f, 4.51011658e-02f,
  -1.37972995e-03f, 4.80740555e-02f, -1.62328407e-02f, -3.20013650e-02f, 7.17264265e-02f, -4.77086082e-02f, -1.72937755e-02f, -2.72555053e-02f, -9.14260522e-02f, 6.98366612e-02f,
  -1.95948392e-01f, 2.05122799e-01f, 1.03992581e-01f, -8.38832557e-02f, -1.53689887e-02f, -1.50558636e-01f, -2.68161874e-02f, -4.44982126e-02f, -8.18381906e-02f, 7.67000094e-02f,
  1.07930429e-01f, -4.89418060e-02f, -6.64617196e-02f, -3.10171712e-02f, 3.55469063e-02f, 5.95534872e-03f, 8.99080858e-02f, -1.71660166e-02f, -2.43690565e-01f, -2.61170745e-01f,
  -9.64802504e-02f, -8.53452012e-02f, -1.19335055e-01f, -8.36963113e-03f, 1.09460734e-01f, -1.69665173e-01f, 1.03105605e-01f, 1.76922575e-01f, 1.30623877e-01f, 4.54073161e-01f,
  1.06472470e-01f, 2.73137331e-01f, -1.35870412e-01f, -6.00004680e-02f, 1.18978873e-01f, -2.78986637e-02f, 3.49931270e-02f, -2.19671689e-02f, 5.57864644e-03f, -3.46259363e-02f,
  4.06792685e-02f, 4.88679595e-02f, 4.78423350e-02f, 6.32480672e-03f, 5.03088124e-02f, -1.88584637e-03f, 1.89780369e-01f, -9.91616957e-03f, -1.51872234e-02f, 2.00676322e-02f,
  1.75730288e-01f, 1.72752038e-01f, 7.74292042e-03f, 3.00759133e-02f, 8.29465762e-02f, -2.16051959e-03f, 5.75912148e-02f, 1.64149612e-01f, 9.52809453e-02f, 5.14668189e-02f,
  -4.89910580e-02f, 5.65628055e-03f, 8.10862854e-02f, 4.20592492e-03f, -3.60493734e-02f, -2.24430324e-03f, -4.51827683e-02f, -3.76833230e-03f, -3.43900882e-02f, -2.58820225e-02f,
  1.69164799e-02f, -7.47913308e-03f, -4.19282354e-02f, -3.72465402e-02f, -2.49539502e-02f, 1.67880896e-02f, -1.70509741e-02f, 2.89770812e-02f, -3.23418416e-02f, -3.06141679e-03f,
  -6.11633137e-02f, 4.61044200e-02f, -8.42905953e-04f, 7.15901926e-02f, 5.78365959e-02f, 1.32493526e-02f, -1.68660469e-03f, 2.32227724e-02f, 2.23669335e-02f, -6.64362311e-02f,
  -2.16872260e-01f, 9.66493487e-02f, -3.49878930e-02f, -2.72913557e-03f, 1.77074634e-02f, 1.21474536e-02f, 3.40723246e-02f, -7.07086101e-02f, 8.39671865e-02f, -3.33653539e-02f,
  -4.52467352e-02f, -3.14243250e-02f, -1.35922311e-02f, 8.93452317e-02f, -1.15309797e-01f, -2.27975138e-02f, 4.92029563e-02f, -1.16686570e-02f, 5.29628731e-02f, 4.66490090e-02f,
  -8.45179707e-02f, -1.11396126e-01f, -9.11243334e-02f, -8.93574655e-02f, 2.18619034e-02f, -1.54083475e-01f, -1.10339276e-01f, -1.49077952e-01f, -1.32111520e-01f, -3.39194149e-01f,
  3.24066579e-01f, 5.55386432e-02f, 1.51768968e-01f, 2.65178680e-01f, 2.40585014e-01f, 7.36461505e-02f, 1.10572524e-01f, 6.90636113e-02f, -5.22625856e-02f, 6.31977022e-02f,
  -1.07992008e-01f, -4.39652391e-02f, -1.12966418e-01f, -6.72648326e-02f, 9.51921493e-02f, 1.41248226e-01f, 2.39089087e-01f, 2.95646608e-01f, 1.39504761e-01f, 1.39768422e-01f,
  9.82317477e-02f, 2.37005204e-01f, 1.89684764e-01f, 1.00477031e-02f, 5.16931787e-02f, 2.83817353e-04f, 6.15382753e-02f, 3.74464840e-02f, -7.49003515e-03f, 1.54213637e-01f,
  -8.43172520e-02f, 1.00107431e-01f, 8.88445824e-02f, 1.35549575e-01f, -2.59726513e-02f, 1.50859505e-02f, -9.00046304e-02f, 2.42026206e-02f, -2.68299319e-02f, 3.86451045e-03f,
  6.35118708e-02f, -4.75195460e-02f, 1.31431352e-02f, -7.34043568e-02f, 7.75567889e-02f, 1.12458803e-01f, -3.07262000e-02f, -4.74272184e-02f, 1.04371123e-02f, -5.08938543e-02f,
  -2.91693043e-02f, 3.65610644e-02f, 9.02210549e-02f, 9.49288998e-03f, -1.07161596e-01f, 1.32366434e-01f, -1.40413372e-02f, 6.78755119e-02f, -6.46601096e-02f, -1.12855755e-01f,
  -4.40212414e-02f, -1.13795988e-01f, 6.65503666e-02f, -3.69113917e-03f, 2.46530641e-02f, -4.68896776e-02f, -2.89982520e-02f, 2.82192342e-02f, 2.57431269e-02f, -2.89662946e-02f,
  -1.07325524e-01f, 5.72024994e-02f, -9.19186994e-02f, -2.36675702e-03f, 5.29434578e-03f, 5.31600937e-02f, 2.44346401e-03f, -1.77341215e-02f, 1.02953857e-03f, 4.48926724e-02f,
  5.87824881e-02f, -8.07988569e-02f, 1.72879566e-02f, -2.39230972e-02f, 5.43204807e-02f, 5.32379467e-03f, 4.32375968e-02f, -8.27207044e-03f, 3.33033577e-02f, -7.38737434e-02f,
  -5.97372949e-02f, 1.03179902e-01f, -5.35694100e-02f, 2.23608520e-02f, -4.77907294e-03f, -5.48871197e-02f, -1.68389026e-02f, -5.92159554e-02f, -2.41168402e-02f, -4.92360406e-02f,
  2.99412310e-02f, -7.59256184e-02f, -5.02838641e-02f, -7.75429979e-02f, 2.60633659e-02f, 3.16755734e-02f, -8.90054554e-02f, 2.89819445e-02f, 4.13661040e-02f, -1.39347062e-01f,
  -3.16494182e-02f, 9.01413560e-02f, -2.76235268e-02f, 1.47648668e-02f, -6.69591948e-02f, 4.89443056e-02f, 4.72384179e-03f, 4.56607901e-02f, -5.26846498e-02f, -8.00004825e-02f,
  -1.89700991e-01f, -7.51278475e-02f, 1.00348212e-01f, 1.32730812e-01f, -6.42922148e-02f, -2.34234080e-01f, -1.62958309e-01f, -7.88919926e-02f, -1.10457793e-01f, -1.10488944e-01f,
  -2.05856368e-01f, -5.16921170e-02f, 4.94089946e-02f, -8.69486779e-02f, 1.99109055e-02f, 1.63484477e-02f, 2.22321361e-01f, 1.69684708e-01f, 2.24492829e-02f, -2.86960024e-02f,
  8.88387579e-03f, 2.16050997e-01f, 1.49312615e-01f, -9.24897194e-03f, 9.07399729e-02f, 2.42263079e-02f, 1.99559648e-02f, 2.54480559e-02f, -1.07494541e-01f, 1.99452937e-01f,
  1.08691648e-01f, -1.45656958e-01f, 4.29984145e-02f, -1.14344932e-01f, -5.64799309e-02f, -1.34593481e-02f, -2.58198730e-03f, 1.27143666e-01f, -4.35386002e-02f, -6.52101077e-03f,
  6.40717819e-02f, -8.60128328e-02f, -3.92828323e-02f, 1.13991991e-01f, 4.54323227e-03f, 1.21536434e-01f, -7.92425685e-03f, 1.29313976e-01f, 9.72076729e-02f, -6.68823570e-02f,
  9.89390537e-03f, -3.95272933e-02f, 9.92248505e-02f, -7.91622028e-02f, 2.76754107e-02f, -8.19477369e-04f, -5.58316195e-03f, -6.31543547e-02f, -1.08506724e-01f, 1.98228844e-02f,
  -4.50145677e-02f, -3.60301733e-02f, 1.83095131e-02f, -5.87474629e-02f, 7.18191937e-02f, -6.09280057e-02f, 5.41241746e-03f, -1.24239735e-02f, 2.62890593e-04f, 7.05721155e-02f,
  -1.93787385e-02f, -1.89107899e-02f, 6.34521572e-03f, -1.09265102e-02f, -7.63180181e-02f, 1.06294893e-01f, -4.71582972e-02f, -1.51126934e-02f, -4.16276157e-02f, 2.45081224e-02f,
  1.43049927e-02f, 1.59441549e-02f, 1.74732506e-02f, 8.97140726e-02f, -1.14317149e-01f, 1.31943552e-02f, -3.32790315e-02f, 5.89245223e-02f, 2.21529752e-02f, -9.63852741e-03f,
  -1.25443693e-02f, -1.17146105e-01f, -2.75563933e-02f, 2.73443982e-02f, 1.01184696e-01f, -6.56431168e-02f, -4.72316593e-02f, -3.86760868e-02f, -4.79018502e-02f, 5.21281064e-02f,
  -1.64794102e-01f, 2.83878129e-02f, 9.06181633e-02f, -8.39683879e-03f, 3.80591750e-02f, -7.94615299e-02f, -7.50631094e-02f, 7.81836435e-02f, -7.41478568e-03f, -7.41670653e-02f,
  3.65556367e-02f, -9.17746648e-02f, -1.23226661e-02f, -1.32258050e-02f, -5.13564758e-02f, -1.77501202e-01f, 4.93022129e-02f, 2.83486936e-02f, -3.63940746e-02f, -1.02676682e-01f,
  -2.20775649e-01f, -5.84598444e-02f, -6.21501431e-02f, 1.95702724e-02f, 1.08157761e-01f, 2.76763160e-02f, -1.59171566e-01f, 7.95157999e-03f, 7.91751146e-02f, -5.51587157e-02f,
  3.09227151e-03f, 1.59709677e-01f, 8.92003253e-02f, 1.34789094e-01f, -1.42066807e-01f, -1.36112720e-01f, -5.19599253e-03f, 2.40460373e-02f, 6.84400201e-02f, 1.13867864e-01f,
  1.08739041e-01f, 5.92373200e-02f, -2.97907870e-02f, -4.44704108e-02f, -1.67968147e-03f, 1.58654451e-01f, -1.63541585e-02f, -5.42132184e-02f, 7.25571113e-03f, -1.02710137e-02f,
  3.05810720e-02f, -1.45741804e-02f, -3.08076870e-02f, -7.75790438e-02f, 3.36896740e-02f, -8.04518312e-02f, 1.58315320e-02f, -7.32367337e-02f, -3.59763876e-02f, -8.01313575e-03f,
  1.38118025e-02f, 2.70651672e-02f, 4.42577340e-02f, 1.57585908e-02f, -3.64689864e-02f, 3.60416248e-04f, -1.13545619e-01f, -1.00179873e-01f, -6.22665957e-02f, 3.61952595e-02f,
  5.48860244e-02f, -8.00767094e-02f, -1.29115865e-01f, -6.32520467e-02f, -7.31513724e-02f, 4.34956811e-02f, -4.31421064e-02f, 3.52196023e-02f, -1.91653237e-01f, -1.91561624e-01f,
  3.62694524e-02f, 1.90217141e-02f, -1.27713270e-02f, -2.90018339e-02f, 1.72262136e-02f, -7.59719089e-02f, 5.07281125e-02f, 8.40780511e-02f, 9.52996407e-03f, -1.35316495e-02f,
  -3.17027532e-02f, 6.09962717e-02f, 2.29885373e-02f, 2.67678183e-02f, -5.37748029e-03f, -1.11328989e-01f, 2.89457093e-04f, -5.22408448e-02f, -4.96814810e-02f, 4.11742665e-02f,
  -7.09630176e-02f, -9.07677785e-02f, 7.64453933e-02f, -1.34727107e-02f, -7.19471946e-02f, -4.71421257e-02f, -9.00924429e-02f, -1.05525423e-02f, -7.28496760e-02f, -7.75071159e-02f,
  -1.14051342e-01f, 1.60055161e-01f, 1.00759871e-01f, -1.34829909e-01f, 7.52824619e-02f, -6.79831505e-02f, -4.08370346e-02f, -1.08631160e-02f, 5.56141362e-02f, -1.00886375e-02f,
  -7.31012300e-02f, -6.18187413e-02f, -4.49601226e-02f, 7.15103075e-02f, 9.43746138e-03f, -5.25155626e-02f, -8.91540721e-02f, -5.84940650e-02f, -3.54225114e-02f, -4.42527272e-02f,
  -9.31947157e-02f, -1.04936041e-01f, -8.84182230e-02f, -1.12161309e-01f, -7.54569620e-02f, -5.60831204e-02f, 1.56830046e-02f, -9.46727917e-02f, -7.75861591e-02f, -1.75844043e-01f,
  -8.36793706e-03f, -1.96361810e-01f, -4.00349200e-02f, -5.41760661e-02f, 2.65967590e-03f, -3.45898140e-03f, 4.62265797e-02f, -2.17331247e-03f, -3.99974100e-02f, -8.96983892e-02f,
  -1.91955388e-01f, -2.59437058e-02f, -9.04807001e-02f, -1.32845759e-01f, 8.41144398e-02f, 2.44133435e-02f, 2.05811486e-02f, 5.72216734e-02f, 2.15526953e-01f, 1.61200449e-01f,
  5.96909262e-02f, 6.29015192e-02f, -1.92275476e-02f, 7.85994828e-02f, -1.99664012e-01f, 5.63883223e-02f, -9.13135633e-02f, -1.81292608e-01f, 1.80406421e-02f, -2.00625494e-01f,
  6.66767359e-02f, -1.93945035e-01f, 1.10636979e-01f, 3.26176337e-03f, 3.09014525e-02f, 6.45271987e-02f, 1.00521125e-01f, -1.05063580e-01f, -4.72733304e-02f, -1.38208508e-01f,
  -3.02880201e-02f, 1.27311982e-02f, -5.30367121e-02f, -6.89431727e-02f, 1.40072629e-02f, -5.80220856e-02f, -4.97939251e-02f, 5.75000197e-02f, 1.49527220e-02f, -1.01157933e-01f,
  -4.88013141e-02f, -1.48110121e-01f, -6.54881215e-03f, 2.62277038e-03f, 3.40010375e-02f, -4.43660142e-03f, -9.49907699e-04f, -9.62604135e-02f, 4.61733714e-02f, -6.89223856e-02f,
  1.67740911e-01f, -1.03382938e-01f, 5.14777796e-03f, -4.89101857e-02f, 4.07190472e-02f, -2.03703232e-02f, -8.99562612e-02f, 3.57467644e-02f, -3.07751857e-02f, 2.61606704e-02f,
  -6.71558734e-03f, 3.86245847e-02f, -3.24032307e-02f, 1.56805664e-02f, -4.79300283e-02f, -1.27860783e-02f, 6.43473212e-03f, 1.21360309e-02f, 1.97094232e-02f, -1.17314076e-02f,
  2.67100614e-02f, 2.98972111e-02f, -5.48173860e-03f, 4.13582288e-02f, -5.29764779e-02f, 3.37693654e-03f, 6.11145701e-03f, -8.69433805e-02f, -2.68754922e-03f, -9.88577902e-02f,
  3.66877625e-03f, -4.64905873e-02f, 1.25545010e-01f, 8.46931040e-02f, 8.24116692e-02f, 7.17033073e-03f, -7.58874044e-02f, 3.23951058e-02f, -1.48547422e-02f, 5.47395125e-02f,
  6.84068026e-03f, 1.02406219e-01f, -1.02984622e-01f, 9.75145549e-02f, 3.32092382e-02f, 3.20116580e-02f, 6.10199235e-02f, 1.43913507e-01f, 5.13391532e-02f, 8.46307054e-02f,
  1.42019123e-01f, 9.18169022e-02f, 1.49755538e-01f, -5.47774660e-04f, 1.35123804e-02f, 2.11503580e-01f, 1.09478012e-01f, 7.02155381e-02f, 7.13601336e-02f, 3.09549212e-01f,
  -1.78906024e-01f, -1.03208803e-01f, 2.20736846e-01f, -6.08493239e-02f, 2.08112169e-02f, 7.28755221e-02f, 9.87071991e-02f, -8.60575028e-03f, -1.21370882e-01f, -1.01516150e-01f,
  -1.78200468e-01f, 7.56676570e-02f, 9.52071771e-02f, 1.01730675e-01f, 2.79333442e-01f, 8.87039006e-02f, 1.64663285e-01f, 3.36653560e-01f, 3.45907152e-01f, 1.31297007e-01f,
  6.79834262e-02f, 1.74611509e-01f, -5.59558310e-02f, 9.58434045e-02f, -1.06359366e-02f, 1.02865666e-01f, 1.63821981e-03f, -2.90135443e-02f, 9.18964520e-02f, 6.23311847e-02f,
  2.17359260e-01f, -1.08766876e-01f, 6.47005439e-02f, -3.38789187e-02f, -1.46489292e-02f, -1.00902542e-01f, 3.63028422e-02f, -4.44737934e-02f, -1.53315350e-01f, -5.47574423e-02f,
  -1.30026629e-02f, -1.91775057e-02f, 4.46346775e-02f, 3.95852625e-02f, 3.06736492e-02f, -2.31876317e-02f, -4.32172194e-02f, 5.34613989e-02f, -7.76849091e-02f, -5.22947013e-02f,
  -1.05277017e-01f, -5.09717353e-02f, -4.41099890e-02f, -1.41912654e-01f, -1.76562201e-02f, 8.67112353e-02f, -2.50286311e-02f, -7.90611804e-02f, -8.02832306e-04f, -1.51730403e-01f,
  -8.98193270e-02f, 8.68095458e-02f, 9.52906683e-02f, 4.25747521e-02f, -9.38738361e-02f, -3.31507884e-02f, 7.18280897e-02f, 1.39805134e-02f, 1.68089978e-02f, -2.89950743e-02f,
  1.88955304e-03f, -7.33726695e-02f, 1.45035302e-02f, -2.31421161e-02f, -3.00907586e-02f, -2.24163532e-02f, -3.35876346e-02f, -2.39292160e-02f, -3.06683276e-02f, -3.52695845e-02f,
  -3.55142504e-02f, 2.20286063e-04f, 2.42998172e-02f, 3.44940722e-02f, 5.47781847e-02f, 6.72777323e-03f, 5.21653406e-02f, 9.82391462e-02f, 1.04696332e-02f, 1.48236593e-02f,
  -2.09218692e-02f, 1.28898472e-01f, 2.32516360e-02f, 8.17555636e-02f, 1.07659802e-01f, -6.37702122e-02f, -9.06297490e-02f, -1.75366737e-02f, -1.96576938e-02f, -8.48834589e-03f,
  2.09620260e-02f, -1.50629145e-03f, -4.01658937e-02f, -2.37676222e-02f, 2.33920235e-02f, -5.58936410e-02f, 3.91076393e-02f, 4.43330966e-03f, 2.98138913e-02f, -8.76303539e-02f,
  -1.49952337e-01f, -4.08181138e-02f, 4.53873724e-02f, -5.84541932e-02f, 1.03432685e-01f, 1.08667523e-01f, 7.87042826e-02f, 3.78360637e-02f, 1.60425916e-01f, -7.88657367e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.00717950e-01f, 1.25910714e-01f, 4.79020998e-02f, -1.77509218e-01f, 5.95757514e-02f, 1.18160814e-01f, 2.68290907e-01f, 9.54035744e-02f, -4.06771339e-03f, 1.34014651e-01f,
  -4.00596149e-02f, -1.52407423e-01f, -1.34631008e-01f, -5.11010475e-02f, 3.86154391e-02f, 1.79268092e-01f, 8.12286139e-03f, -1.02225468e-01f, -1.65493712e-01f, -1.01340860e-01f,
  -8.33184868e-02f, -1.14466384e-01f, -2.00383157e-01f, -3.68819982e-02f, -1.48208275e-01f, -1.71225101e-01f, -4.75970879e-02f, 2.58763470e-02f, -8.89129099e-03f, -5.57503477e-03f,
  4.81229462e-02f, -7.88237080e-02f, -6.69648498e-02f, -1.35514528e-01f, 2.02269712e-03f, -9.16274264e-03f, -1.44450357e-02f, 2.21175831e-02f, -3.41830179e-02f, 3.65016013e-02f,
  -6.11312967e-03f, -1.02116354e-02f, -2.51467829e-03f, -8.22027624e-02f, -1.20979123e-01f, -1.60147902e-02f, -5.18132038e-02f, -9.06935986e-03f, 6.63089678e-02f, 6.22069798e-02f,
  1.30010352e-01f, 4.90120091e-02f, 1.34827278e-04f, 2.67110523e-02f, 8.43102708e-02f, -1.15955956e-01f, -2.73530893e-02f, -1.21747896e-01f, 1.30518191e-02f, -1.12987213e-01f,
  -4.84120585e-02f, 3.14713898e-03f, -7.63056204e-02f, -4.00107801e-02f, 1.53102437e-02f, -4.59825657e-02f, -4.89747636e-02f, -4.01187055e-02f, -3.20288725e-03f, -3.52685526e-02f,
  -1.48408953e-02f, -1.25680836e-02f, 5.30896671e-02f, 5.36082722e-02f, -2.93090325e-02f, -1.18711898e-02f, -8.86117667e-02f, 9.40415636e-02f, 5.43213673e-02f, 1.13250790e-02f,
  4.06237170e-02f, 6.61442131e-02f, 5.07106744e-02f, -3.38214450e-02f, -1.24919834e-03f, -3.56318541e-02f, 8.18519741e-02f, -7.07466379e-02f, 7.44784102e-02f, -3.50095406e-02f,
  -2.03970611e-01f, 1.32000774e-01f, -7.49264583e-02f, 2.62167174e-02f, 2.96917814e-03f, -3.98205929e-02f, 8.48104134e-02f, 3.23558189e-02f, -4.53050882e-02f, -1.75307654e-02f,
  5.12969261e-03f, -6.14169948e-02f, -6.54744953e-02f, -6.62821606e-02f, 1.63007267e-02f, 3.60237695e-02f, -1.56760551e-02f, -6.54227883e-02f, 2.79878583e-02f, 3.96216065e-02f,
  -1.02208052e-02f, 5.73686277e-03f, -7.70977959e-02f, -8.44518766e-02f, 4.19699550e-02f, -1.35735452e-01f, -9.81782749e-02f, 1.22495824e-02f, -2.46159043e-02f, -9.85060707e-02f,
  -1.71780542e-01f, -1.22393273e-01f, -1.45657554e-01f, -8.02848190e-02f, -3.51692326e-02f, 8.27912986e-02f, -1.02459103e-01f, 1.88158974e-02f, 2.57166326e-02f, -2.01292075e-02f,
  -1.18759833e-01f, -6.63008690e-02f, -1.47919536e-01f, 8.57203174e-03f, -5.03925793e-02f, -1.61083668e-01f, -1.01002671e-01f, -1.36970967e-01f, 4.01859079e-03f, 3.77081297e-02f,
  6.02509901e-02f, -9.05300975e-02f, 1.54546574e-02f, -5.08492440e-02f, -9.47201252e-02f, -9.73750055e-02f, -2.39263296e-01f, -1.53595015e-01f, -1.22603342e-01f, -1.50175467e-01f,
  -1.93212539e-01f, 6.91094846e-02f, 1.24065783e-02f, 1.40733523e-02f, -4.65620607e-02f, -5.13646938e-02f, -3.71202491e-02f, 2.93288864e-02f, -2.46261545e-02f, 3.73874642e-02f,
  -4.38763201e-02f, 5.11341095e-02f, -1.16575286e-02f, 7.86937252e-02f, 6.82426989e-02f, 3.94711643e-02f, 5.66030592e-02f, 6.67042583e-02f, -5.15041947e-02f, -1.52018331e-02f,
  -2.06799414e-02f, -2.82798037e-02f, 2.50442605e-02f, 1.12710178e-01f, -4.04779203e-02f, -7.57573843e-02f, 3.54871117e-02f, -7.96362571e-03f, -7.55959749e-02f, -1.78793177e-01f,
  1.99249052e-02f, -1.87412975e-03f, 5.83931059e-02f, -2.38033161e-02f, -6.55199885e-02f, 5.58445081e-02f, 6.42605051e-02f, 6.11667074e-02f, -2.09626593e-02f, -5.62272593e-02f,
  2.31379941e-02f, -5.07239886e-02f, 5.13755344e-02f, 5.62170856e-02f, -6.08976297e-02f, 5.50699793e-02f, 5.24079800e-03f, 4.92667072e-02f, -7.57603496e-02f, 3.22616771e-02f,
  -1.33688655e-02f, 7.72165209e-02f, -4.32356745e-02f, 5.41291907e-02f, 7.37432688e-02f, -6.43945038e-02f, 8.34971890e-02f, 1.22467019e-01f, 5.84087446e-02f, 1.55803382e-01f,
  -1.36619344e-01f, -8.79261866e-02f, -4.41758521e-02f, -3.85142863e-02f, -3.82180959e-02f, -3.49337831e-02f, 1.63784157e-02f, -1.62991919e-02f, 8.88427645e-02f, -2.57455977e-03f,
  2.66921753e-03f, 4.55786958e-02f, -3.21376882e-02f, -8.77649710e-03f, -1.27737382e-02f, 1.40726790e-01f, -2.65336875e-02f, 5.00918254e-02f, 3.30046564e-02f, 8.91966671e-02f,
  7.96532109e-02f, 2.47333311e-02f, 9.53386724e-03f, -8.98080915e-02f, -2.88433805e-02f, -6.99995831e-02f, -8.79843011e-02f, -7.28229955e-02f, -1.55649543e-01f, -1.47119746e-01f,
  2.94724405e-01f, -1.83291599e-01f, -6.53472617e-02f, 5.98638952e-02f, 2.18738094e-02f, -2.15758663e-02f, -1.24405608e-01f, 1.67402010e-02f, -3.64445411e-02f, -2.08347179e-02f,
  1.11190034e-02f, 1.79811701e-01f, 2.42152484e-03f, 7.82816708e-02f, -2.21527070e-02f, -1.88433051e-01f, -1.51299223e-01f, 3.08751799e-02f, 5.92188984e-02f, 2.30408106e-02f,
  -4.37017716e-02f, 7.62895262e-03f, 2.98575126e-02f, 1.04000419e-01f, -1.28928617e-01f, -6.36138767e-02f, -9.00027603e-02f, -5.66901639e-02f, -3.41786332e-02f, -1.88527942e-01f,
  -6.66036457e-02f, 1.18753411e-01f, 6.89568445e-02f, 1.02564529e-01f, -1.02098390e-01f, -8.64012912e-03f, 2.92791259e-02f, 2.47299988e-02f, 1.00661971e-01f, -7.03620538e-02f,
  2.07077432e-02f, 1.01001076e-01f, -6.27291724e-02f, -5.80099896e-02f, -4.18176316e-02f, -7.13018775e-02f, -1.91734787e-02f, 5.75351790e-02f, 5.24506345e-02f, -1.31006464e-02f,
  -1.02923974e-01f, 6.52346984e-02f, 1.82874426e-02f, 1.58627215e-03f, -4.70265783e-02f, 8.28526765e-02f, -9.42247286e-02f, -5.94736412e-02f, -2.12744791e-02f, 1.51473228e-02f,
  -9.61009935e-02f, -2.28831768e-02f, 6.22331686e-02f, 3.31925601e-02f, 3.43908044e-03f, 5.87321706e-02f, 1.96509808e-02f, -2.88680457e-02f, -6.18033893e-02f, -4.31688353e-02f,
  2.17600516e-03f, 4.40619327e-03f, 3.20106857e-02f, 5.50615340e-02f, -1.30232871e-01f, 2.34648697e-02f, 5.75065129e-02f, -7.32485875e-02f, 6.81798309e-02f, 4.33557518e-02f,
  -4.72718626e-02f, -3.76724526e-02f, 5.35682067e-02f, 4.57397774e-02f, 1.02286483e-03f, -4.69461754e-02f, -2.32248963e-03f, -9.85904597e-03f, 4.51196730e-02f, 5.55865169e-02f,
  2.26020347e-02f, 1.01861089e-01f, 6.15767241e-02f, 2.45128702e-02f, 6.01138212e-02f, 9.10033733e-02f, 8.14148486e-02f, 8.70269239e-02f, 5.77027500e-02f, -7.32334480e-02f,
  -2.81465407e-02f, 2.23739203e-02f, 1.68979485e-02f, -4.10325602e-02f, 7.16210976e-02f, 2.02419539e-03f, -2.89223995e-02f, 4.21765111e-02f, 1.22616120e-01f, -1.29967675e-01f,
  -1.43696085e-01f, 1.14498392e-01f, 1.18352406e-01f, -4.25868295e-02f, -3.44649665e-02f, -1.08037249e-03f, 7.59387836e-02f, -4.56054695e-02f, 2.39229109e-02f, -8.43153298e-02f,
  -5.19313142e-02f, 1.04672544e-01f, 1.22457920e-02f, -7.79861286e-02f, -1.00936413e-01f, -7.86250308e-02f, -5.66557236e-02f, 9.87772178e-03f, 8.50741751e-03f, 3.97880822e-02f,
  -3.42859365e-02f, -1.23319596e-01f, -7.82835633e-02f, -9.90588665e-02f, -7.49481749e-03f, -5.51465526e-02f, 1.04579665e-01f, 1.07518971e-01f, -9.62275937e-02f, -3.16306739e-03f,
  1.83266178e-02f, 8.49482883e-03f, 1.38961989e-02f, 2.52415147e-02f, 1.45096421e-01f, 2.82411762e-02f, 1.17360288e-02f, 6.91057965e-02f, -2.49222224e-03f, 2.14695066e-01f,
  3.50973867e-02f, 8.43111649e-02f, -2.86306590e-02f, 5.03116585e-02f, -2.35620067e-02f, 1.22758053e-01f, 7.72327408e-02f, -5.79320006e-02f, -3.12212389e-03f, -4.78242002e-02f,
  5.72193861e-02f, -1.75043615e-03f, 9.15223956e-02f, -3.14511694e-02f, -6.45043037e-05f, -4.01349999e-02f, -1.22224735e-02f, -1.97364949e-03f, 5.00575006e-02f, 9.67600867e-02f,
  -4.47512679e-02f, -1.05672024e-01f, 2.82860883e-02f, -4.04116092e-03f, -1.23920210e-01f, 9.98107833e-04f, -7.11818412e-02f, -2.15106905e-02f, -4.91996445e-02f, 9.20730829e-02f,
  -3.98607887e-02f, -6.62680715e-02f, -1.89684127e-02f, -4.59726825e-02f, -4.64355797e-02f, -2.11379975e-02f, 2.41678450e-02f, 1.37547450e-02f, -1.01516813e-01f, 5.54034896e-02f,
  7.86416046e-03f, -3.84113863e-02f, 4.05981094e-02f, 9.45614204e-02f, -3.75576243e-02f, -8.08832273e-02f, 6.57057613e-02f, 6.56862408e-02f, 2.74109337e-02f, -2.23416556e-02f,
  -8.43644589e-02f, 4.44418602e-02f, 6.64984286e-02f, -1.65832397e-02f, 1.14887096e-02f, 3.04669868e-02f, 7.17606321e-02f, 5.79947885e-03f, -1.02956984e-02f, 1.56872496e-02f,
  1.57236472e-01f, -1.46997020e-01f, 9.38007236e-02f, 1.34483144e-01f, 7.78669789e-02f, 8.97475928e-02f, 6.14704788e-02f, -3.92519012e-02f, 7.14682713e-02f, 6.08366914e-02f,
  2.66330969e-02f, -5.97468913e-02f, 1.96652003e-02f, -3.68977971e-02f, 9.07872021e-02f, 1.50282504e-02f, 4.92423736e-02f, 6.11343123e-02f, 7.50082657e-02f, 5.23036905e-02f,
  8.93403217e-02f, -3.27360108e-02f, -4.98731844e-02f, 1.72678344e-02f, -8.74462724e-02f, 4.02862467e-02f, -9.09041017e-02f, -4.93999980e-02f, -2.27878690e-02f, 1.65647659e-02f,
  -5.07860743e-02f, -2.21531335e-02f, -4.78108041e-02f, 7.14761065e-03f, -8.37385207e-02f, -8.23582485e-02f, -6.45003393e-02f, -4.50608730e-02f, 9.50588584e-02f, -9.93459150e-02f,
  2.91060414e-02f, -1.43002078e-03f, 2.73681562e-02f, -7.23795816e-02f, -4.12095860e-02f, 6.93353638e-02f, 5.26728593e-02f, 2.74840575e-02f, -1.23125520e-02f, -4.52663144e-03f,
  9.31173116e-02f, -2.17947289e-02f, 2.42161788e-02f, -1.75035577e-02f, 1.00253329e-01f, 6.15963116e-02f, -1.75220296e-02f, -5.21251522e-02f, -2.08242442e-02f, 1.55332640e-01f,
  2.90596616e-02f, 4.78541944e-03f, -2.10258663e-02f, -5.35418056e-02f, -7.98275173e-02f, -4.30146195e-02f, 8.76315497e-03f, 8.51056501e-02f, -2.52663642e-02f, 2.18651001e-03f,
  3.92962433e-02f, 3.19891572e-02f, 2.82516833e-02f, -6.88166767e-02f, -1.07731782e-01f, -5.41388132e-02f, 4.62201200e-02f, -5.17368913e-02f, 3.27272676e-02f, -1.41292755e-02f,
  6.63794056e-02f, 2.31325924e-02f, -1.12564705e-01f, -8.51993114e-02f, 1.89698040e-02f, -2.49895938e-02f, -9.68576893e-02f, -7.16079399e-02f, -3.04060075e-02f, 9.02586337e-03f,
  8.68791714e-02f, -3.26227248e-02f, -1.78257525e-02f, -7.94299692e-02f, -5.62086608e-03f, 1.12558212e-02f, 5.87691069e-02f, -5.20328544e-02f, -6.02715202e-02f, -4.25867038e-03f,
  -3.06276586e-02f, -1.02858931e-01f, -1.60076115e-02f, 4.20643054e-02f, 1.82907451e-02f, 2.51846742e-02f, -9.13019702e-02f, -3.96530554e-02f, 5.32388734e-03f, 5.81709528e-03f,
  -1.25848651e-02f, 7.54289478e-02f, -4.48119678e-02f, 7.40476400e-02f, 7.56120756e-02f, 7.93984011e-02f, -5.18384054e-02f, -7.91986585e-02f, -5.46845533e-02f, 7.84615334e-03f,
  7.49626085e-02f, -1.88940596e-02f, 9.65133756e-02f, 4.61589433e-02f, -5.60213774e-02f, 4.55867872e-02f, -3.36434804e-02f, -7.61068016e-02f, -5.97120710e-02f, 5.35150617e-02f,
  7.81998709e-02f, -7.76752084e-02f, -1.03537031e-02f, 5.62305264e-02f, 1.71585176e-02f, -5.02880365e-02f, -9.67141464e-02f, 5.82763404e-02f, -9.31200758e-02f, -4.27422300e-02f,
  -5.48168495e-02f, -1.21943302e-01f, -6.84962273e-02f, -9.88338590e-02f, 5.74814575e-03f, -3.04951705e-02f, -7.85535052e-02f, -6.98212907e-02f, -1.45105109e-01f, -1.39983118e-01f,
  2.66415346e-02f, -3.48468274e-02f, -4.60449494e-02f, -9.45220608e-03f, -1.18163906e-01f, 7.09502622e-02f, 7.76241124e-02f, -1.28801782e-02f, -1.36860415e-01f, 5.70016820e-03f,
  -3.05673759e-02f, -1.38205469e-01f, 2.90910453e-02f, -2.76488531e-02f, 4.30751741e-02f, -3.42250876e-02f, 8.34010541e-03f, 1.24607505e-02f, 6.82101399e-02f, -9.89242643e-02f,
  -7.97170177e-02f, 9.39607900e-03f, 2.40082480e-03f, -6.98755682e-02f, -1.31983226e-02f, 4.87262197e-03f, -1.47522865e-02f, 3.64560895e-02f, -3.75457518e-02f, -1.00071682e-02f,
  1.15918316e-01f, 1.97266927e-03f, -7.62404278e-02f, -1.44123770e-02f, -1.01302629e-02f, 7.10325763e-02f, 1.37535008e-02f, -6.24634810e-02f, -8.98915753e-02f, 6.42677099e-02f,
  -7.99828395e-02f, -6.86240557e-04f, 4.96096984e-02f, 2.64196601e-02f, 1.98894832e-02f, -8.13273787e-02f, -1.05765745e-01f, 4.95402105e-02f, -9.82283130e-02f, 1.52565837e-02f,
  2.16609146e-02f, -8.30907077e-02f, 6.33697808e-02f, -3.67824510e-02f, -3.65264080e-02f, 1.95256379e-02f, 8.03315714e-02f, -9.76152867e-02f, -7.30301216e-02f, -7.00402334e-02f,
  -4.41955263e-03f, -2.29111183e-02f, 1.52128534e-02f, -1.47471307e-02f, 2.51043960e-02f, 7.40178376e-02f, -2.11915132e-02f, 3.38106416e-02f, 7.38461614e-02f, 9.73599702e-02f,
  -3.33634391e-02f, 8.96861032e-03f, -2.00696681e-02f, 5.69489226e-02f, -2.53223963e-02f, -9.34470724e-03f, 3.89823467e-02f, -3.77861708e-02f, 3.75799052e-02f, -7.82205164e-02f,
  -1.33149633e-02f, 5.80761768e-02f, -4.71805111e-02f, -6.19598525e-03f, 2.66472753e-02f, -7.17223212e-02f, 7.15490133e-02f, -6.74469098e-02f, 6.21189922e-02f, -6.59804419e-02f,
  8.01416114e-02f, -1.04974948e-01f, -4.41082343e-02f, 9.06659216e-02f, -4.10390683e-02f, 3.01084016e-02f, 7.23287240e-02f, -1.85438972e-02f, 6.27641603e-02f, 1.09775439e-01f,
  -9.02762488e-02f, -5.65442294e-02f, -2.72418205e-02f, -4.59703654e-02f, 4.22315598e-02f, 6.05725162e-02f, -3.58628891e-02f, -3.51809412e-02f, -7.69462213e-02f, -3.04380748e-02f,
  -5.37075708e-03f, 1.23300493e-01f, 1.11370966e-01f, -5.41037321e-02f, 2.86182463e-02f, 1.22869514e-01f, -3.47005129e-02f, 3.34510207e-02f, -2.91433912e-02f, 1.59861982e-01f,
  -2.07931116e-01f, 3.49733084e-02f, 3.39704007e-02f, -2.64763329e-02f, 3.57753634e-02f, 2.24954002e-02f, -1.02437362e-02f, -1.66443599e-04f, 7.75766000e-02f, -9.06796195e-03f,
  -9.89632402e-03f, 5.17842844e-02f, 1.05619334e-01f, 2.33536791e-02f, 1.04507923e-01f, 1.76805735e-01f, 1.43090531e-01f, 3.05476040e-03f, 2.76694726e-02f, -2.24741809e-02f,
  6.41645398e-03f, 8.41462761e-02f, 2.99797393e-02f, 1.13857687e-01f, 5.84596209e-02f, 1.03352174e-01f, -3.78345773e-02f, -8.21471065e-02f, 7.97929317e-02f, 1.62820384e-01f,
  -5.54490015e-02f, -1.15592703e-01f, 6.79445714e-02f, 6.07202053e-02f, -5.79155795e-03f, 5.90688400e-02f, 1.41416574e-02f, -1.56643074e-02f, -4.51402664e-02f, 2.84487661e-02f,
  -3.99197303e-02f, -3.56957242e-02f, 4.21301574e-02f, -1.26799988e-02f, 5.27313240e-02f, 4.38547023e-02f, -7.01580569e-02f, -2.84170713e-02f, 6.59103096e-02f, 7.05467165e-02f,
  -2.08806042e-02f, -5.20274378e-02f, -6.48154989e-02f, 8.12625363e-02f, 7.59224035e-03f, -1.88017562e-02f, -2.93624424e-03f, 2.12629382e-02f, -2.44521294e-02f, 1.25311473e-02f,
  3.14812362e-02f, 2.01640222e-02f, 3.78443450e-02f, 1.30973142e-02f, 1.02521991e-03f, 2.31588334e-02f, 6.50286451e-02f, -3.18879038e-02f, -5.62862940e-02f, -2.33476199e-02f,
  5.65957949e-02f, 2.37598792e-02f, -4.93144132e-02f, -4.38409261e-02f, -4.31867689e-02f, -5.51279671e-02f, 1.34819848e-02f, 8.34027752e-02f, -1.51408873e-02f, -9.80925113e-02f,
  -9.61814970e-02f, -3.31132635e-02f, -1.01041593e-01f, -3.79952863e-02f, -9.28557515e-02f, -4.68340591e-02f, 6.82857782e-02f, 1.69418789e-02f, -3.30879614e-02f, -1.01827063e-01f,
  1.41209485e-02f, -3.57526317e-02f, 1.19607881e-01f, -6.79066544e-03f, 5.28660417e-03f, -3.51672210e-02f, -8.08754098e-03f, -6.41763955e-02f, -9.90824122e-03f, 1.28380414e-02f,
  -1.13825031e-01f, 4.11228184e-03f, -4.18653823e-02f, 4.95827347e-02f, -5.61552867e-02f, -7.34459385e-02f, 4.95255701e-02f, 1.10272057e-01f, 2.58921497e-02f, 3.23371816e-04f,
  5.18392539e-03f, -9.55335796e-02f, 2.99109183e-02f, 8.30895230e-02f, -1.47362296e-02f, -3.89320031e-02f, 3.57241556e-02f, -8.62570852e-02f, -8.45366740e-04f, 5.66803571e-03f,
  5.32908030e-02f, -7.79395998e-02f, 7.73112178e-02f, 9.98089388e-02f, -3.20744812e-02f, -3.12878460e-01f, -4.32480246e-01f, -2.77755171e-01f, 9.23700444e-03f, -9.38558951e-02f,
  -1.42898988e-02f, 1.09230824e-01f, 1.99982803e-02f, -4.46735881e-02f, -5.86781874e-02f, -2.18463242e-01f, 2.42531616e-02f, 6.65230080e-02f, -7.55787864e-02f, 4.02416810e-02f,
  3.41594405e-02f, 7.66697451e-02f, 1.62666067e-01f, 3.12039349e-02f, 8.64786804e-02f, 1.30462989e-01f, 1.61781237e-01f, 1.89887673e-01f, 3.22497673e-02f, 2.75746018e-01f,
  2.25562915e-01f, -2.87451334e-02f, 4.49588522e-03f, 1.18200004e-01f, 6.81583956e-02f, 7.07186088e-02f, -8.62593278e-02f, 3.27595230e-03f, -4.29100916e-02f, -9.72963870e-03f,
  5.52273467e-02f, 5.77852018e-02f, -4.56868298e-02f, 2.38404423e-03f, -4.44567911e-02f, -9.18327123e-02f, -7.72767887e-02f, 4.27201837e-02f, 2.86252294e-02f, -2.79623680e-02f,
  -5.84513471e-02f, -5.59215760e-03f, -1.48815066e-02f, -1.11973368e-01f, 4.84162606e-02f, -3.78552750e-02f, 6.62285164e-02f, 3.42111811e-02f, -7.88394362e-02f, 1.88263226e-02f,
  1.21783234e-01f, -2.38410495e-02f, -4.47639963e-03f, -3.88744511e-02f, -8.86172205e-02f, -1.75357014e-02f, -3.64670693e-03f, -3.11189964e-02f, 2.68370714e-02f, -4.70070057e-02f,
  -2.70781536e-02f, 2.82653626e-02f, 2.15235855e-02f, 2.95754932e-02f, -7.53503479e-03f, 5.68063073e-02f, 6.71268404e-02f, -2.05249283e-02f, -3.57691348e-02f, 4.36271541e-02f,
  -3.07935569e-02f, 5.94981052e-02f, 2.18783449e-02f, 2.04616599e-02f, 1.68341678e-02f, 2.86016129e-02f, 8.65242034e-02f, 7.81108672e-03f, 4.93136048e-02f, -6.03089062e-03f,
  1.45534864e-02f, -7.70589709e-02f, 5.49025051e-02f, 6.67508915e-02f, 5.27150072e-02f, 2.85567939e-02f, -1.78951789e-02f, 2.44163480e-02f, 8.28003958e-02f, -1.11716606e-01f,
  -1.05884805e-01f, -1.03140607e-01f, -4.74464856e-02f, -3.78272645e-02f, -3.16635855e-02f, 3.05759534e-02f, -1.52820731e-02f, 6.67815581e-02f, -6.84906244e-02f, -7.51015246e-02f,
  -5.21497130e-02f, -2.14804813e-01f, -1.55861095e-01f, -9.49404389e-02f, -9.07386914e-02f, -9.36059430e-02f, -1.12229191e-01f, -9.55969542e-02f, -1.65618852e-01f, -1.18299901e-01f,
  -1.00198910e-01f, -1.50193004e-02f, 1.50236830e-01f, 7.56898001e-02f, 5.74731687e-03f, 3.70106809e-02f, 8.49923566e-02f, 5.67391999e-02f, 4.97058406e-02f, -4.60503548e-02f,
  -1.25197366e-01f, -5.79869933e-03f, -9.68288630e-03f, -9.99736935e-02f, 1.06713571e-01f, 5.85701875e-02f, -1.91254597e-02f, 9.85449925e-02f, -3.28470692e-02f, 7.11845756e-02f,
  -3.48255150e-02f, 1.96106303e-02f, 7.22701699e-02f, -4.76188883e-02f, -8.03101882e-02f, 3.89791257e-03f, 4.62666005e-02f, -4.26224852e-03f, -1.07574929e-02f, -5.25872596e-02f,
  3.33638974e-02f, 4.60675582e-02f, 8.64586160e-02f, -4.77585662e-03f, -9.55904275e-02f, 3.25434888e-03f, 2.37170588e-02f, -8.35779216e-03f, -8.10038894e-02f, -9.50387307e-03f,
  2.67204158e-02f, -1.18886888e-01f, 4.31714281e-02f, -7.67391622e-02f, 8.03100690e-02f, -7.11471960e-02f, -4.21506278e-02f, 6.03397489e-02f, 9.55798849e-03f, -2.82283109e-02f,
  -9.76284444e-02f, -5.79605103e-02f, -2.45176051e-02f, 3.87871522e-03f, -1.51243070e-02f, -8.50188509e-02f, 5.39923310e-02f, -1.24138705e-02f, 3.71549884e-03f, 4.60813902e-02f,
  6.33156896e-02f, 3.29313166e-02f, -2.58919746e-02f, -5.64047247e-02f, 2.79366765e-02f, -6.74117878e-02f, -6.27128333e-02f, -4.46374156e-02f, -1.91958603e-02f, -6.81841299e-02f,
  3.85197029e-02f, 9.53970775e-02f, -5.52011915e-02f, -8.71638656e-02f, 2.85036732e-02f, 5.87669350e-02f, 5.91328293e-02f, -1.03360131e-01f, 2.47647166e-02f, 2.04259474e-02f,
  -2.14347020e-02f, 8.37393925e-02f, -5.84405102e-02f, -3.49507891e-02f, 8.65853354e-02f, 1.89550985e-02f, 7.71522820e-02f, 1.79330967e-02f, 3.24014425e-02f, 4.07816246e-02f,
  -1.46896496e-01f, 9.98649821e-02f, -1.07517950e-01f, -8.11152682e-02f, -4.52766232e-02f, 4.24391627e-02f, -4.59974408e-02f, -1.85200907e-02f, 4.54278514e-02f, -1.64467469e-02f,
  -4.31906804e-02f, -3.87140363e-02f, -8.16267431e-02f, -2.90849470e-02f, 4.91691567e-02f, 4.41589728e-02f, 9.40369628e-03f, -7.89235085e-02f, 2.77953251e-04f, 4.36013639e-02f,
  -2.34895628e-02f, 4.93536443e-02f, -5.47449999e-02f, 6.33218363e-02f, -9.84085277e-02f, -7.51938745e-02f, 2.36726962e-02f, -6.98931813e-02f, -2.67103873e-02f, -5.94039373e-02f,
  -1.46460861e-01f, -1.38621479e-01f, -7.97266420e-03f, -1.62295014e-01f, -5.64320348e-02f, 7.73062780e-02f, -4.25423868e-02f, 2.73652319e-02f, 8.91751330e-03f, -5.10450453e-02f,
  4.11841385e-02f, -3.69659662e-02f, -6.56956807e-02f, -4.81559709e-03f, -6.46075513e-03f, 3.33269201e-02f, -2.97960942e-03f, -7.76383728e-02f, -2.90689580e-02f, 8.82160664e-02f,
  -4.73326780e-02f, -1.24044135e-01f, -1.20147221e-01f, -3.51442620e-02f, -1.20374849e-02f, 8.79900083e-02f, 7.69171193e-02f, 1.51642878e-02f, 2.02918164e-02f, 1.89514551e-02f,
  2.02715248e-01f, 1.19268736e-02f, -2.39285582e-04f, -3.83754447e-02f, -8.76525417e-02f, -9.87863317e-02f, 7.46369436e-02f, -3.91808264e-02f, -5.74064106e-02f, -5.93442731e-02f,
  4.55416776e-02f, -8.94160494e-02f, 4.71276455e-02f, 9.08568129e-02f, -2.40435619e-02f, 5.45118377e-02f, 8.11518729e-02f, 3.66869681e-02f, -5.08960895e-02f, 5.16238250e-02f,
  -1.77401286e-02f, -4.99154255e-02f, 6.51066825e-02f, 4.41897139e-02f, 2.77519710e-02f, 8.96935090e-02f, 3.26060923e-03f, 1.46252722e-01f, 1.05435096e-01f, 1.48566395e-01f,
  3.73882577e-02f, 6.10816590e-02f, -2.28401236e-02f, 3.59539688e-02f, -6.17706180e-02f, -1.31817407e-03f, -2.63092648e-02f, -4.06238213e-02f, -4.36407365e-02f, 5.77910952e-02f,
  -3.59559283e-02f, 1.53901381e-02f, -5.05887717e-02f, 1.60129424e-02f, -6.19213767e-02f, -7.94616714e-02f, -9.06490982e-02f, -2.58627180e-02f, 3.95474322e-02f, -5.03845885e-02f,
  5.33741675e-02f, 1.19976439e-01f, 6.19599223e-02f, 6.19421229e-02f, -5.57155423e-02f, 3.03822942e-02f, -6.15003854e-02f, 2.47126129e-02f, -3.71172130e-02f, -2.04591919e-02f,
  8.65810812e-02f, -1.52414650e-01f, -5.72108738e-02f, 7.08833411e-02f, 7.58258179e-02f, -9.13601518e-02f, -6.91186637e-02f, -1.56827439e-02f, 1.48265520e-02f, 9.06569362e-02f,
  -4.59177718e-02f, -6.32239655e-02f, -4.69430424e-02f, 1.27120659e-01f, 9.30476859e-02f, 7.73150772e-02f, -7.96021968e-02f, -1.27368337e-02f, -6.67663515e-02f, 5.87889627e-02f,
  7.54277259e-02f, 4.43259999e-02f, -1.09645985e-02f, 3.83369699e-02f, -3.95201938e-03f, -4.48173632e-05f, 5.09854890e-02f, 1.19244657e-01f, 1.02457024e-01f, 1.03982717e-01f,
  -2.42493525e-01f, -2.21749246e-02f, 1.40032709e-01f, 1.49617437e-02f, 1.27946854e-01f, 1.28045857e-01f, 6.76992908e-02f, 9.43625048e-02f, 1.29855976e-01f, -2.65198667e-02f,
  -1.22645430e-01f, -4.90715429e-02f, 8.16918463e-02f, 6.28333166e-02f, 5.51576391e-02f, 1.31262168e-01f, 8.05090442e-02f, 1.42510593e-01f, 1.33823454e-01f, 8.16359073e-02f,
  4.24269065e-02f, -3.79532836e-02f, -5.35722598e-02f, 2.08986271e-02f, 5.97691350e-02f, 1.31548136e-01f, -1.57223772e-02f, 8.50210804e-03f, -6.57597259e-02f, 5.26520796e-02f,
  -1.29229471e-01f, -1.35999903e-01f, 1.13598853e-01f, -1.02291092e-01f, -1.24962538e-01f, -2.11105198e-02f, 8.58130865e-03f, -1.25540169e-02f, -8.05625543e-02f, -2.04586070e-02f,
  2.38579861e-03f, 1.24427648e-02f, -2.81101698e-03f, 5.12824692e-02f, -1.04140960e-01f, 2.52407906e-03f, -1.14750609e-01f, -5.29780611e-02f, 1.01818308e-01f, -7.71152452e-02f,
  -5.70615605e-02f, -2.57254727e-02f, -3.74010615e-02f, 3.21040861e-02f, 1.15559973e-01f, 1.02516785e-02f, -3.82464528e-02f, -4.13923971e-02f, -7.32837617e-02f, -4.39833589e-02f,
  -6.32470474e-02f, -7.36587495e-02f, 1.09651508e-02f, 7.93277565e-03f, -4.55775559e-02f, -2.12103389e-02f, 2.13586390e-02f, 5.98606244e-02f, 2.76445448e-02f, -2.82166917e-02f,
  3.43534835e-02f, 8.91734585e-02f, 1.11352034e-01f, 3.00201587e-02f, 8.74319822e-02f, 3.81782725e-02f, -1.66679248e-02f, -7.64353797e-02f, -1.08644217e-01f, -1.39744272e-02f,
  5.24740387e-03f, 6.13191240e-02f, -5.80526330e-02f, -2.13452091e-04f, 5.63277155e-02f, 7.49458373e-02f, -8.13471526e-03f, -8.93321633e-02f, -2.93410774e-02f, 1.41562102e-02f,
  -1.07600510e-01f, -8.10266733e-02f, 1.02174748e-02f, -5.27990088e-02f, 5.36121540e-02f, -7.71253332e-02f, 7.15411007e-02f, -5.10672554e-02f, -5.27424039e-03f, 3.77053171e-02f,
  -7.52434507e-02f, -3.38353291e-02f, 2.93770507e-02f, -5.36022428e-03f, 9.11747664e-02f, 1.37092108e-02f, -1.73690487e-02f, 1.32306337e-01f, 4.00210060e-02f, -6.79268986e-02f,
  -1.32231722e-02f, 7.44014978e-02f, 2.15120427e-02f, 1.30452693e-01f, 4.65789996e-02f, -2.19635870e-02f, -4.71927039e-02f, -1.10522769e-02f, 6.49801567e-02f, 4.64734882e-02f,
  1.75648421e-01f, -1.00936346e-01f, -1.00103796e-01f, 1.71556622e-02f, 2.15735361e-02f, 2.29636300e-02f, -1.03243910e-01f, 4.77277450e-02f, -3.92097533e-02f, -8.61301180e-03f,
  -4.07550111e-03f, 2.18042396e-02f, -5.25037721e-02f, -8.09570849e-02f, -9.10977647e-02f, -1.91325918e-01f, -5.05275764e-02f, -2.20368225e-02f, 1.20195627e-01f, 7.05015361e-02f,
  -2.72531342e-02f, -7.43920282e-02f, -4.05461490e-02f, -6.53096512e-02f, -6.28151670e-02f, -7.37942979e-02f, -6.15235828e-02f, -2.96469685e-02f, -5.50271347e-02f, -1.74072340e-01f,
  -1.90996379e-01f, 1.11034453e-01f, -7.36641064e-02f, 7.02728182e-02f, 1.11315139e-02f, 2.84389127e-02f, -3.95571329e-02f, -3.08244862e-02f, -4.42494862e-02f, -6.60610422e-02f,
  2.73565985e-02f, -4.13631722e-02f, 5.18189855e-02f, -2.58895699e-02f, 1.19939502e-02f, 8.42617527e-02f, -2.12884676e-02f, 1.56295300e-02f, 7.58648962e-02f, -4.50901277e-02f,
  -2.99378242e-02f, -1.01072840e-01f, 6.57576472e-02f, -4.03503291e-02f, 1.03653833e-01f, -1.21001499e-02f, -2.58459505e-02f, 2.96826642e-02f, -7.47488812e-02f, -1.04635470e-01f,
  -4.19902354e-02f, -1.48155186e-02f, 3.71500403e-02f, -2.38951985e-02f, 3.10841464e-02f, 5.09293005e-02f, 8.20937604e-02f, -2.92801689e-02f, -3.74807566e-02f, -8.07880517e-03f,
  2.77962498e-02f, -8.84473398e-02f, -4.74892817e-02f, -1.23757403e-02f, 4.60525881e-03f, -5.56553490e-02f, 3.63852419e-02f, -2.09734798e-03f, -8.42082128e-02f, -3.44816339e-03f,
  9.67101287e-03f, -8.46547410e-02f, -1.36264376e-02f, -1.65008958e-02f, -4.47551943e-02f, 4.98481393e-02f, -8.21219981e-02f, -4.26202687e-03f, -7.56937414e-02f, -8.21280479e-02f,
  5.47153093e-02f, 6.54247077e-03f, -5.96258789e-03f, 1.08693436e-01f, -6.01636954e-02f, -5.77083528e-02f, -2.96557695e-02f, -7.06332922e-02f, 8.89912620e-02f, -4.04199436e-02f,
  -7.32629001e-03f, -4.36263643e-02f, 4.74150218e-02f, -6.73405603e-02f, -6.90035298e-02f, 6.74317032e-02f, -7.44704306e-02f, 7.66999349e-02f, -3.63767776e-03f, -4.31461260e-02f,
  7.65277306e-03f, 3.77956629e-02f, 5.58463819e-02f, 2.36964207e-02f, 1.26387641e-01f, 6.76010922e-02f, -7.62730315e-02f, -9.02032387e-03f, -7.69828111e-02f, -1.31536331e-02f,
  -1.04628049e-01f, 1.56038366e-02f, 7.20336288e-03f, -1.21971190e-01f, -7.48583451e-02f, 5.10273241e-02f, -5.28936349e-02f, 6.51459545e-02f, -2.43410505e-02f, -3.72592807e-02f,
  7.57942274e-02f, -1.92219354e-02f, -3.67755480e-02f, -7.60482028e-02f, -5.50637953e-02f, -1.54420640e-02f, -2.77070198e-02f, -1.38670087e-01f, -3.09686419e-02f, 9.73518714e-02f,
  -7.59891719e-02f, 8.62995535e-03f, 3.57413222e-03f, -9.21441317e-02f, -1.22869518e-02f, -1.32559419e-01f, -1.51723444e-01f, -4.24690545e-02f, -8.32007751e-02f, -1.40508294e-01f,
  -1.54109165e-01f, 1.50857091e-01f, -8.74877907e-03f, 2.90469043e-02f, 4.61852737e-02f, -4.14467677e-02f, 5.26709706e-02f, -1.76731672e-03f, 6.88569173e-02f, 7.25463256e-02f,
  7.85833746e-02f, 7.62633234e-02f, -6.33478072e-03f, -2.07500923e-02f, -3.86131275e-03f, -5.46655096e-02f, 7.99076408e-02f, 5.47922030e-02f, -1.95366256e-02f, 9.78536755e-02f,
  8.67562294e-02f, 3.80053706e-02f, -2.56877150e-02f, -1.80124883e-02f, 1.11691989e-01f, -1.68643929e-02f, -1.20773222e-02f, 9.07698348e-02f, -2.97433175e-02f, 4.47692955e-03f,
  2.67396513e-02f, 8.56346916e-03f, 6.98709041e-02f, 5.61598912e-02f, -3.12587284e-02f, -3.23624574e-02f, 3.00397184e-02f, -7.78600797e-02f, 1.83116347e-02f, 1.98980374e-03f,
  9.44300118e-05f, 3.87298614e-02f, 3.96104716e-02f, -5.72752133e-02f, -1.07758567e-01f, 6.88851029e-02f, -6.75688311e-02f, 4.91367616e-02f, -1.29013369e-02f, -2.01720931e-02f,
  5.48882782e-02f, 2.79750451e-02f, -3.14205512e-02f, -3.94052602e-02f, 4.56811041e-02f, -1.02152647e-02f, -1.54811265e-02f, 6.84239268e-02f, 7.68385679e-02f, -4.03423831e-02f,
  -1.10981829e-01f, 1.70199219e-02f, -1.56231620e-03f, 4.49169725e-02f, 4.54927385e-02f, -4.41716313e-02f, -1.03685625e-01f, 2.18401337e-03f, -6.81191683e-02f, 2.33462751e-02f,
  6.35269657e-02f, -9.71128792e-03f, 3.12784873e-02f, 8.16172212e-02f, -3.50481272e-02f, -6.18202277e-02f, -6.39235824e-02f, -9.80761498e-02f, 6.63310885e-02f, 7.25212693e-02f,
  6.81467280e-02f, -5.89894913e-02f, 2.97201909e-02f, 2.39580101e-03f, 6.97567761e-02f, 2.16651224e-02f, 2.00357586e-02f, 1.74602885e-02f, -3.40105337e-03f, -6.03009574e-02f,
  -2.85998553e-01f, -1.44869551e-01f, 5.43411970e-02f, 1.10105656e-01f, -4.76068594e-02f, -4.52976972e-02f, -1.90863341e-01f, -1.07095361e-01f, -4.41827206e-03f, -8.05447903e-03f,
  3.78179038e-03f, 1.25931084e-01f, 1.65225510e-02f, 3.94272059e-02f, -1.15459144e-01f, 3.33392508e-02f, 1.40309799e-02f, -5.84975742e-02f, -1.00923859e-01f, -4.63175736e-02f,
  1.00405782e-01f, 1.03204586e-01f, 4.21974771e-02f, 5.35556488e-02f, 1.14524767e-01f, 1.50109110e-02f, 3.52862179e-02f, 7.30577186e-02f, -5.62961586e-02f, 7.19683245e-02f,
  1.95893958e-01f, -8.64524171e-02f, -1.43951876e-02f, -1.28823621e-02f, 4.05877680e-02f, -4.10003215e-02f, -5.62310889e-02f, 8.91178697e-02f, 2.71882545e-02f, 1.48940934e-02f,
  8.51872861e-02f, -2.10206825e-02f, -2.42578262e-03f, 2.10444815e-03f, 9.54381935e-03f, -6.53398409e-02f, 4.83650044e-02f, 1.28521509e-02f, 8.34220946e-02f, 2.02400945e-02f,
  9.60923210e-02f, -1.01012653e-02f, 1.05736693e-02f, -9.74676311e-02f, 2.12232471e-02f, -3.58406082e-02f, 4.35261093e-02f, 9.33105275e-02f, -1.18610762e-01f, 4.04272974e-02f,
  1.42535977e-02f, 9.77224410e-02f, 4.42259908e-02f, -5.64575866e-02f, 4.96028811e-02f, 3.80857401e-02f, -3.81647870e-02f, -6.86912090e-02f, -6.85180202e-02f, -5.67771215e-03f,
  1.27973314e-02f, -2.53264848e-02f, -7.68833980e-02f, -3.72069888e-02f, 1.02016315e-01f, 8.48182216e-02f, -7.18606114e-02f, -5.19185849e-02f, 4.38720249e-02f, -5.37938774e-02f,
  4.51940186e-02f, -1.35848466e-02f, -1.18221575e-02f, -2.32872088e-02f, -1.02312222e-01f, 2.17651818e-02f, 3.65770608e-02f, -6.41076267e-02f, 5.31669259e-02f, 2.58680321e-02f,
  6.88676387e-02f, -2.77219806e-02f, 1.21208124e-01f, 1.73265114e-02f, -3.66335027e-02f, -2.39357576e-02f, -4.88316566e-02f, -9.35771018e-02f, 4.34508547e-02f, -9.33686271e-02f,
  6.40491396e-02f, 4.29003015e-02f, -3.22939316e-03f, 1.18957646e-01f, -8.14834759e-02f, 5.82629703e-02f, 2.54400703e-03f, -8.60460699e-02f, 8.92744958e-02f, 1.14328243e-01f,
  -2.61523593e-02f, 6.77573904e-02f, -5.23276217e-02f, -3.00402641e-02f, -7.06962794e-02f, -9.02538523e-02f, -6.45397902e-02f, 2.58649345e-02f, -9.10610631e-02f, -1.20656200e-01f,
  -1.56023860e-01f, -2.02241936e-03f, -1.53017595e-01f, -1.88710108e-01f, -1.75914168e-02f, 1.01546802e-01f, 2.79209837e-02f, -6.37114942e-02f, -4.11381461e-02f, -1.77859329e-02f,
  8.03746134e-02f, -7.79799148e-02f, 1.70613732e-02f, 7.25922585e-02f, 2.29017492e-02f, -1.06589496e-01f, -6.63314620e-03f, -6.54900596e-02f, 3.81645076e-02f, 9.33944359e-02f,
  -5.25069386e-02f, -4.48540747e-02f, -7.29219541e-02f, 5.43416999e-02f, 9.77809448e-03f, 5.75998165e-02f, 2.22572638e-03f, -1.26241237e-01f, 3.29257527e-05f, -1.63180642e-02f,
  -2.31131911e-02f, 7.12094735e-03f, -1.94646679e-02f, -8.57227147e-02f, 3.05582359e-02f, -3.59591655e-02f, -3.92375737e-02f, -9.33428407e-02f, 8.02686587e-02f, -8.10523182e-02f,
  -8.59890059e-02f, 5.61895370e-02f, -7.48355463e-02f, 7.49564022e-02f, 5.32383211e-02f, 5.56698851e-02f, -5.79060242e-02f, -9.16074738e-02f, 6.85305670e-02f, -4.03337255e-02f,
  1.29541093e-02f, 2.31758803e-02f, 3.52567481e-03f, 2.43855342e-02f, 5.30615374e-02f, 1.93369277e-02f, -4.71689291e-02f, 3.40244733e-02f, -9.35924724e-02f, -9.23010036e-02f,
  -7.87697807e-02f, 6.31229505e-02f, -6.20916951e-03f, -9.98297855e-02f, -9.76120979e-02f, -1.79579353e-03f, -4.05635275e-02f, 5.56543954e-02f, 8.18965659e-02f, 2.66018175e-02f,
  1.70767307e-03f, 4.99958545e-02f, -1.83702148e-02f, -7.46790245e-02f, 3.67396511e-02f, -4.75295000e-02f, 5.62316515e-02f, -5.61034568e-02f, 5.00488281e-02f, -8.95632897e-03f,
  1.94799881e-02f, -5.73218539e-02f, 3.40933688e-02f, -5.76755814e-02f, -9.71585363e-02f, 8.29645712e-03f, 6.12476133e-02f, 2.59087589e-02f, 5.70017807e-02f, 7.88993016e-02f,
  -5.33905998e-02f, 1.44298645e-02f, 3.69109474e-02f, -3.15768681e-02f, 1.63022224e-02f, 4.92578857e-02f, 2.72494480e-02f, 6.86956346e-02f, 4.63577686e-03f, 6.61989301e-03f,
  -4.94020954e-02f, -6.60676733e-02f, -2.54103262e-02f, 9.58736241e-03f, 7.78267160e-02f, 1.34235970e-03f, -8.73167999e-04f, -1.09145790e-01f, -5.02074435e-02f, -4.81527597e-02f,
  3.46888416e-02f, -3.44032608e-03f, -1.24418080e-01f, 1.83036849e-02f, -3.56506705e-02f, -9.06044021e-02f, 1.81912389e-02f, -4.46385518e-02f, 4.41771299e-02f, -3.74934860e-02f,
  5.17744198e-02f, -4.25450578e-02f, -1.31592318e-01f, -1.19797839e-02f, -5.75435199e-02f, 4.56395000e-02f, 3.67845669e-02f, -2.28071567e-02f, 2.59585283e-03f, -3.86938378e-02f,
  7.07256645e-02f, 4.95525263e-02f, -1.12041190e-01f, 4.72546257e-02f, -6.19113967e-02f, -5.51752187e-02f, 1.08306073e-02f, -7.49580115e-02f, -9.04289037e-02f, -8.37121066e-03f,
  -3.28014791e-02f, -4.05420251e-02f, -1.06124692e-02f, 7.38993958e-02f, 3.51702608e-02f, 2.62719560e-02f, -3.73223275e-02f, -8.70678425e-02f, 7.56658167e-02f, -1.21754907e-01f,
  -4.05310839e-02f, -6.53065220e-02f, 7.14983270e-02f, -5.44090196e-02f, 8.47308785e-02f, 5.32999113e-02f, -2.59027686e-02f, -6.56720996e-02f, -4.75473404e-02f, -7.83538371e-02f,
  -3.29504237e-02f, -3.24884094e-02f, -1.73970442e-02f, 1.30039304e-02f, 4.93301414e-02f, 6.56956658e-02f, -3.93317081e-04f, -3.28511745e-02f, 4.62269671e-02f, 7.11187646e-02f,
  -2.97383256e-02f, 1.14422731e-01f, 3.93077061e-02f, 9.84226689e-02f, 5.52826468e-03f, 3.58050950e-02f, 1.11214958e-01f, 7.53595587e-03f, 2.63560042e-02f, 3.39586213e-02f,
  -2.06069015e-02f, 2.28051282e-02f, -1.77746676e-02f, 7.08828727e-03f, -6.85386956e-02f, 1.69214793e-02f, -3.02085988e-02f, -5.93262613e-02f, -5.28710485e-02f, 3.00207827e-02f,
  4.30362485e-02f, 8.98024626e-03f, 7.72104412e-02f, 2.03423519e-02f, -6.75251409e-02f, 4.17375676e-02f, 6.07512221e-02f, 6.23682663e-02f, 3.62217985e-02f, 2.85670888e-02f,
  3.11537068e-02f, -1.13646155e-02f, 7.64723048e-02f, -5.96885271e-02f, -7.07471669e-02f, 7.55585432e-02f, -3.82380299e-02f, -6.76619187e-02f, 3.54963019e-02f, -6.75340220e-02f,
  -1.87994018e-02f, -3.02107856e-02f, -7.06450269e-02f, 2.77915178e-03f, -1.53979892e-02f, 2.30531897e-02f, -1.06584437e-01f, -9.69506726e-02f, -6.92741051e-02f, 5.71233518e-02f,
  5.66591173e-02f, 4.69268672e-02f, -7.28413463e-02f, 8.96018445e-02f, 1.08762659e-04f, 7.63752460e-02f, -7.81209534e-03f, -4.55348343e-02f, -2.48418842e-03f, 9.65451896e-02f,
  9.26142558e-02f, 9.38671306e-02f, -4.19434085e-02f, 3.17511447e-02f, 2.27006115e-02f, 4.76963595e-02f, 1.12000788e-02f, 8.19635391e-03f, -7.70477504e-02f, 9.87006165e-03f,
  8.32501948e-02f, -1.40746415e-01f, -2.78829962e-01f, -7.84556344e-02f, -1.26012355e-01f, -8.18349272e-02f, -4.30047400e-02f, 8.93106237e-02f, 1.05184503e-01f, -5.91494367e-02f,
  -4.96333018e-02f, 1.50568366e-01f, 8.73547867e-02f, 4.57283258e-02f, -5.39032742e-02f, -1.89079583e-01f, -2.38281250e-01f, -1.27381226e-02f, -1.66332256e-02f, -6.44534174e-03f,
  1.35528378e-03f, 8.56508911e-02f, 6.52314052e-02f, 3.55100562e-03f, 3.09368428e-02f, 1.00378282e-01f, -1.86766684e-02f, -7.25994930e-02f, -3.92987467e-02f, -1.00490995e-01f,
  -7.83831552e-02f, -2.84569431e-03f, 7.13409930e-02f, -9.47188213e-02f, 2.03607138e-02f, -3.58175896e-02f, -1.37486774e-02f, -6.30250424e-02f, -5.42960837e-02f, -9.82500389e-02f,
  -6.47459701e-02f, 5.65248542e-02f, -7.12902397e-02f, -1.44216768e-03f, 2.25678328e-02f, -3.47150974e-02f, -3.99029478e-02f, -9.08068791e-02f, -7.14282617e-02f, 3.35960276e-02f,
  -8.64665732e-02f, -1.37402073e-01f, -6.54904097e-02f, 1.21647306e-01f, 5.52632362e-02f, -7.20836446e-02f, -5.67717217e-02f, 1.20140873e-01f, 1.49407744e-01f, 6.45490736e-02f,
  -6.72240704e-02f, -3.82157192e-02f, 2.21351790e-03f, 9.26233977e-02f, 7.37424940e-02f, 1.18853692e-02f, -1.10908570e-02f, -3.45203653e-02f, 6.40045777e-02f, 2.20390111e-02f,
  1.12990877e-02f, -1.00334687e-02f, 4.84587513e-02f, 2.46665720e-02f, -5.04283346e-02f, -4.07643430e-02f, -7.78314620e-02f, -6.02180790e-03f, 3.19653414e-02f, -1.79625209e-03f,
  2.90692989e-02f, -2.95844283e-02f, 1.73731130e-02f, 1.14384584e-01f, -4.14006300e-02f, -1.26874790e-01f, -1.05835222e-01f, -2.71031708e-02f, 1.13357551e-01f, -8.89445394e-02f,
  1.82083786e-01f, -1.16301045e-01f, -5.80434091e-02f, 7.46243373e-02f, -2.35965569e-02f, -3.25349420e-02f, 2.61391252e-02f, 9.47235432e-03f, -6.99913204e-02f, 6.51665628e-02f,
  6.63705468e-02f, 4.04612795e-02f, -3.32138576e-02f, 1.48411551e-02f, 8.73846337e-02f, 1.70944743e-02f, -3.97102647e-02f, -1.59794316e-02f, -4.16486897e-02f, -1.72380749e-02f,
  -1.24780662e-01f, -7.15147480e-02f, -3.18161286e-02f, 4.30640280e-02f, 1.04359105e-01f, 2.89550126e-02f, 8.90925229e-02f, 8.77433121e-02f, -1.59181841e-02f, -3.60073112e-02f,
  1.45811915e-01f, 2.94145085e-02f, -2.67067514e-02f, 7.52362609e-02f, -4.07001413e-02f, -5.02127074e-02f, 1.87686756e-02f, 9.82204750e-02f, 5.90799451e-02f, 1.52094709e-02f,
  1.44309103e-01f, 8.97099376e-02f, 6.26819059e-02f, 1.26813687e-02f, -2.34010797e-02f, 6.42157048e-02f, -9.09302104e-03f, 2.91849375e-02f, 1.38436824e-01f, 1.22764464e-02f,
  5.55033162e-02f, 8.43333602e-02f, 9.17950198e-02f, 1.32038489e-01f, 3.98466922e-02f, -4.52365950e-02f, 7.33955950e-03f, -9.52541549e-03f, 1.87332407e-02f, 5.59728667e-02f,
  1.49164364e-01f, 9.19915512e-02f, 4.96130586e-02f, -1.26050645e-02f, 1.01526439e-01f, 1.26401195e-03f, 9.16862637e-02f, -3.12518887e-02f, -3.22314799e-02f, -9.23529360e-03f,
  5.01892269e-02f, 8.32983181e-02f, 5.98264076e-02f, 9.04868692e-02f, -3.86903733e-02f, 1.02716483e-01f, 7.27088153e-02f, -6.42510802e-02f, 1.83705911e-02f, -4.36474755e-02f,
  -5.67596667e-02f, 8.00579116e-02f, -5.87613359e-02f, 7.91229606e-02f, -5.56053631e-02f, -7.05031529e-02f, 1.13387397e-02f, 7.88175613e-02f, 3.47943045e-02f, 7.58386776e-02f,
  -7.57519305e-02f, -8.02804306e-02f, -6.43514050e-03f, 2.76568383e-02f, 4.41999882e-02f, -7.23099336e-02f, -9.00985599e-02f, -5.36747463e-02f, 2.28251517e-02f, -5.66059761e-02f,
  4.86248918e-02f, 4.98412512e-02f, -1.48278400e-02f, -6.09828439e-03f, -6.25415668e-02f, -8.76190066e-02f, -7.60595277e-02f, -6.60547838e-02f, 1.11901321e-01f, 5.92134856e-02f,
  5.50235771e-02f, 2.06048302e-02f, -8.35194662e-02f, 6.77166041e-03f, 5.79128340e-02f, -3.73363756e-02f, -3.87885123e-02f, 6.10983893e-02f, 8.38607475e-02f, -6.36485731e-03f,
  -6.24287799e-02f, -1.58596523e-02f, -2.10753847e-02f, 1.01427794e-01f, -3.43673397e-03f, -1.43464247e-03f, 2.54060086e-02f, 7.12821633e-02f, -3.67067941e-02f, -6.20264001e-02f,
  1.53683955e-02f, 7.74355158e-02f, 6.58418462e-02f, -1.75617523e-02f, 7.79500827e-02f, 5.90446927e-02f, 9.91652608e-02f, 6.23497292e-02f, -3.46945785e-02f, 6.81565627e-02f,
  -5.12870587e-02f, -2.37659607e-02f, -8.62545744e-02f, -1.02281921e-01f, -1.47288060e-02f, -7.64939487e-02f, 8.09068456e-02f, -5.56290820e-02f, 6.96928427e-02f, 5.15762195e-02f,
  1.04024962e-01f, -1.74906421e-02f, -5.10094538e-02f, 7.76974857e-02f, -1.42777488e-01f, -1.53619245e-01f, -1.57124311e-01f, 6.33735359e-02f, -2.36690212e-02f, -1.49779364e-01f,
  7.64794974e-03f, 5.71985357e-02f, -1.83512159e-02f, 2.57801320e-02f, -6.89066648e-02f, -3.70964110e-02f, -9.74756777e-02f, -8.98297578e-02f, 3.64306122e-02f, -1.40072675e-02f,
  -2.16668323e-02f, 7.30794966e-02f, 1.69057604e-02f, -5.29131889e-02f, -1.47372605e-02f, 2.47488469e-02f, -8.10586810e-02f, -1.52712902e-02f, 2.35086051e-03f, -1.37948945e-01f,
  -1.96498935e-03f, 1.75808799e-02f, 3.05676386e-02f, -5.63450940e-02f, 9.79403313e-03f, 2.32797191e-02f, -7.83522874e-02f, 4.11357619e-02f, -5.00340499e-02f, -2.66791750e-02f,
  -8.52282941e-02f, 1.89961530e-02f, 7.17294365e-02f, -3.72189507e-02f, -2.55476125e-02f, -1.02521516e-02f, -3.15039009e-02f, 3.21948994e-03f, -1.80987380e-02f, -6.60925284e-02f,
  -8.58634189e-02f, -1.04039729e-01f, 7.79484734e-02f, -4.32587042e-02f, -7.17573147e-03f, -3.42241004e-02f, 7.99353123e-02f, 6.03780113e-02f, -3.47845219e-02f, 2.89371759e-02f,
  2.91488674e-02f, 3.58779170e-02f, 4.49611694e-02f, -9.66513231e-02f, -3.66432592e-02f, -4.45261598e-02f, -7.50244260e-02f, 1.77350696e-02f, 5.73167251e-03f, 5.94915859e-02f,
  2.07787808e-02f, -4.95164543e-02f, -5.34349456e-02f, -8.50378796e-02f, 1.67350154e-02f, 2.06375327e-02f, 6.53558075e-02f, -1.11314841e-01f, 1.20651694e-02f, 2.55168825e-02f,
  6.58785030e-02f, 4.65272516e-02f, 1.02730006e-01f, 6.98230267e-02f, -2.56748553e-02f, -3.29514928e-02f, 6.36352673e-02f, 9.61779151e-03f, 2.58044749e-02f, 5.03472798e-03f,
  8.60532224e-02f, -7.86111653e-02f, 2.40884777e-02f, 6.07723296e-02f, -8.85339379e-02f, -8.21920559e-02f, 3.62265706e-02f, -3.75885479e-02f, 1.06883615e-01f, -8.94984081e-02f,
  1.34362811e-02f, 8.75539184e-02f, -7.12570772e-02f, -1.63544901e-02f, -5.16253188e-02f, 7.62478774e-03f, -2.15183739e-02f, -1.46182822e-02f, 2.35398542e-02f, 8.33146349e-02f,
  -2.86113732e-02f, -7.90267903e-03f, -5.44303320e-02f, 1.77079551e-02f, -1.28547139e-02f, -5.52580208e-02f, 5.32365814e-02f, -8.78431648e-03f, 1.00050494e-01f, -4.49400675e-03f,
  -1.57323435e-01f, -1.56976312e-01f, 6.72170222e-02f, 3.09395064e-02f, 1.08046748e-01f, -1.93198830e-01f, -3.44262630e-01f, -2.14228213e-01f, -1.43964756e-02f, -3.81408967e-02f,
  5.34741692e-02f, 4.06150445e-02f, 1.11572519e-01f, -5.06869927e-02f, -2.02808723e-01f, -8.10874999e-02f, 1.08867399e-02f, -7.36449957e-02f, -3.82771827e-02f, -1.38941109e-01f,
  6.63841292e-02f, 1.77962668e-02f, 8.27075541e-02f, 6.14764355e-02f, 2.74603590e-02f, 2.37745717e-02f, 1.01643570e-01f, 3.04112546e-02f, 1.33257985e-01f, 2.67177463e-01f,
  1.45648882e-01f, 5.77552617e-02f, 7.99309388e-02f, 3.47860679e-02f, 1.17216520e-01f, 1.77281424e-02f, -6.09660745e-02f, -6.58383127e-04f, 1.21577438e-02f, 4.46289107e-02f,
  4.24692854e-02f, -4.08306085e-02f, 1.07016817e-01f, -1.47741325e-02f, -3.71384644e-03f, -6.96153119e-02f, -1.17129371e-01f, -1.24140801e-02f, -4.82299328e-02f, -1.10728614e-01f,
  5.76684214e-02f, 2.46264301e-02f, -8.20207372e-02f, -1.23213030e-01f, -2.05194764e-02f, 2.05405280e-02f, -4.39626314e-02f, 3.88500094e-02f, 1.18199000e-02f, -3.45669761e-02f,
  3.44850086e-02f, -2.26975195e-02f, -3.07777077e-02f, -1.36242611e-02f, -6.97892308e-02f, 6.16373830e-02f, 1.28198713e-01f, -4.06611413e-02f, 3.84223498e-02f, -4.71122079e-02f,
  4.31818627e-02f, -1.67541485e-02f, 8.68304968e-02f, -2.61390265e-02f, 1.11903943e-01f, 2.30080076e-02f, 2.49242075e-02f, -4.30037230e-02f, 7.67281055e-02f, 1.72138419e-02f,
  1.24673136e-02f, 5.28558493e-02f, 8.92102048e-02f, 5.77321230e-03f, 3.60340811e-02f, -3.55006531e-02f, -8.86523128e-02f, -1.14614822e-01f, -9.77775976e-02f, -2.70395894e-02f,
  9.96423885e-03f, -6.09869696e-02f, 5.40013611e-02f, -1.26104578e-01f, 1.14160843e-01f, -1.81107949e-02f, 7.88867772e-02f, 4.24325317e-02f, -6.25451794e-03f, -4.18295898e-02f,
  -1.07451946e-01f, -8.52351915e-03f, -4.81543243e-02f, -4.25687470e-02f, -7.30990842e-02f, 2.34641470e-02f, -4.02586125e-02f, -2.55178586e-02f, -5.29952757e-02f, -7.90650621e-02f,
  2.35278960e-02f, -1.36226937e-01f, -2.85672564e-02f, -3.05513348e-02f, 2.49794666e-02f, 2.95963660e-02f, -1.02270246e-01f, -4.20107469e-02f, -1.18604809e-01f, -2.40750268e-01f,
  -1.35040984e-01f, -4.27289046e-02f, -7.93201402e-02f, 4.01036367e-02f, -2.96852663e-02f, -1.96001157e-02f, -1.89947233e-01f, -9.67485681e-02f, 8.61576647e-02f, -5.09005785e-03f,
  -1.87247973e-02f, 1.28889889e-01f, 8.34211241e-03f, 9.68924984e-02f, -9.67945084e-02f, 6.77653104e-02f, 1.25963077e-01f, 8.91853645e-02f, -9.08791274e-02f, -9.53730270e-02f,
  -9.85151995e-03f, -4.25612703e-02f, 6.44298717e-02f, 3.00008748e-02f, 8.45584795e-02f, 8.79072025e-02f, 1.03135481e-01f, 8.50522444e-02f, -2.13393457e-02f, 1.89295053e-01f,
  5.02442420e-02f, -2.43419763e-02f, -8.50850344e-02f, 3.77052687e-02f, 4.30961438e-02f, 4.61309850e-02f, 1.56349186e-02f, -3.08217444e-02f, -6.75936267e-02f, 2.25911103e-03f,
  1.18193015e-01f, -1.20721515e-02f, -2.81189475e-02f, -8.96741450e-02f, 2.66648289e-02f, -3.86746451e-02f, -1.02308698e-01f, -8.09623078e-02f, 3.12848017e-02f, 2.51590721e-02f,
  -2.77884509e-02f, 1.36127383e-01f, -9.42325443e-02f, -1.13392659e-01f, -1.01135708e-01f, 1.01696439e-01f, 3.14402692e-02f, 7.56993070e-02f, -6.88169897e-02f, 7.44246542e-02f,
  -4.14238172e-03f, 3.89324414e-04f, -3.20260436e-03f, 4.24569920e-02f, 9.89543647e-02f, 8.71980190e-03f, 1.58172131e-01f, 7.40358159e-02f, -6.33986592e-02f, 6.41501322e-02f,
  -4.51493673e-02f, -5.00817560e-02f, -8.46063867e-02f, 6.18200786e-02f, -7.21517876e-02f, 8.57098475e-02f, 4.32336703e-02f, -3.99184376e-02f, -1.53623261e-02f, -5.40938787e-02f,
  7.11690858e-02f, -1.56895909e-02f, 5.71268685e-02f, -8.09804276e-02f, 7.19074383e-02f, 1.26893044e-01f, 1.03269303e-02f, 4.92178798e-02f, -1.46223260e-02f, 7.03510568e-02f,
  -2.28732955e-02f, -3.78257185e-02f, 3.63158770e-02f, -8.53317138e-03f, -1.19954031e-02f, -4.83199470e-02f, -3.89934219e-02f, -4.27731313e-02f, 5.72568625e-02f, -1.35453036e-02f,
  8.93996134e-02f, 4.96664047e-02f, -7.00653791e-02f, -2.69829035e-02f, -5.32645993e-02f, 3.73738036e-02f, 2.49566473e-02f, 2.72345799e-03f, -6.85704350e-02f, -5.98086566e-02f,
  -5.60626313e-02f, -1.46527275e-01f, -9.99468416e-02f, -4.60924283e-02f, -8.70598704e-02f, 4.32190560e-02f, -4.92920280e-02f, 3.56781147e-02f, -8.48496109e-02f, -4.19518277e-02f,
  1.43264934e-01f, -2.89619863e-02f, 4.92947921e-02f, -9.78073198e-03f, 8.65945518e-02f, 1.12065203e-01f, 8.71593282e-02f, -7.76869878e-02f, 3.47310156e-02f, 6.64704433e-03f,
  -1.55081619e-02f, -8.62594172e-02f, -8.11410621e-02f, -4.74990867e-02f, -5.73713966e-02f, 8.05676803e-02f, 7.65787512e-02f, 7.92621300e-02f, 1.49206400e-01f, 1.45401843e-02f,
  -6.54026121e-02f, -5.68595640e-02f, 7.26865456e-02f, -3.27830911e-02f, -1.03438877e-01f, -6.05776384e-02f, -7.30852857e-02f, 1.61642972e-02f, -8.63728672e-02f, -6.43267110e-03f,
  6.32014684e-03f, 8.90031233e-02f, 7.40941316e-02f, -5.32401279e-02f, 4.54763696e-02f, -4.62153330e-02f, -2.09822543e-02f, -1.40686976e-02f, -3.54057811e-02f, 3.50148715e-02f,
  -8.86995718e-02f, 1.71058811e-02f, -5.29671013e-02f, -1.14797149e-02f, -7.04038842e-03f, -1.35378530e-02f, -1.32515997e-01f, -1.13783190e-02f, -6.83002248e-02f, -3.25370617e-02f,
  -3.49608921e-02f, -1.97780156e-03f, 4.87456173e-02f, 7.88037851e-03f, -6.02071062e-02f, -3.01145930e-02f, 5.70580661e-02f, -8.99567083e-03f, 6.77585676e-02f, 4.77016270e-02f,
  -7.73987323e-02f, -2.11099237e-02f, 1.37115372e-02f, -1.04577271e-02f, -6.66680653e-03f, -5.33896610e-02f, 7.33390301e-02f, 2.89253909e-02f, 7.52005056e-02f, -4.93385494e-02f,
  7.15238973e-02f, 5.99784069e-02f, -6.06692024e-02f, 3.93279195e-02f, 4.46120799e-02f, -7.43756518e-02f, 3.35346088e-02f, -6.87496562e-04f, -4.01706854e-03f, 5.38134798e-02f,
  -2.09988672e-02f, 2.08498351e-02f, 1.03437163e-01f, 5.48057370e-02f, 4.39764783e-02f, 6.86632544e-02f, 6.70286864e-02f, 4.29986976e-02f, 2.38088369e-02f, -9.56015941e-03f,
  -7.42657036e-02f, -5.04185632e-02f, 8.38774964e-02f, -1.75172538e-02f, 9.60545391e-02f, 4.72008698e-02f, -5.75668849e-02f, -2.28595436e-02f, -5.80159202e-02f, -7.96258077e-02f,
  -1.88460760e-02f, 1.53170554e-02f, 9.17702317e-02f, -1.41121810e-02f, 6.81906119e-02f, 2.48041516e-03f, -3.06096524e-02f, 6.79126680e-02f, -6.82359487e-02f, 2.72568073e-02f,
  8.16437509e-03f, 1.34993762e-01f, 1.33886620e-01f, -1.98366307e-02f, -1.24169411e-02f, 9.94900800e-03f, 1.75727084e-02f, -6.54415935e-02f, 7.04427361e-02f, 5.36531806e-02f,
  -1.18579172e-01f, -7.55970255e-02f, -5.49069233e-02f, -7.05855936e-02f, -1.24572478e-01f, -9.50283334e-02f, 5.86231016e-02f, 5.40808588e-02f, -1.23418085e-01f, 8.19712430e-02f,
  -5.37398867e-02f, 5.89020271e-03f, -8.00056010e-02f, -5.81392571e-02f, -5.72260804e-02f, -1.01745434e-01f, 2.41161399e-02f, -1.46150384e-02f, -3.76589447e-02f, -3.52632515e-02f,
  -7.63545707e-02f, -8.76494795e-02f, -7.39851892e-02f, -3.82337384e-02f, 1.42426025e-02f, -7.00953603e-02f, 5.80552407e-03f, -4.75323610e-02f, -1.00257769e-01f, -1.08881384e-01f,
  2.71993846e-01f, -5.71904741e-02f, -8.75468329e-02f, -3.33611853e-02f, 4.19590175e-02f, 2.80844886e-02f, 4.91978377e-02f, -1.25686144e-02f, 7.30133709e-03f, -5.45892566e-02f,
  7.95455202e-02f, -6.40396178e-02f, 2.35790703e-02f, 5.30734807e-02f, -7.39580020e-02f, -6.69957772e-02f, -9.27005857e-02f, -1.01339340e-01f, -3.23098563e-02f, -5.07592969e-02f,
  -1.76029690e-02f, 3.95872593e-02f, -1.22696776e-02f, 6.38254434e-02f, 4.77772346e-03f, -3.49608297e-03f, 1.00191191e-01f, -6.54569864e-02f, -2.48659328e-02f, 9.94317457e-02f,
  -2.58610789e-02f, -7.35266460e-03f, 1.97379314e-03f, -2.56817937e-02f, 8.19694400e-02f, -8.21639001e-02f, 1.01025723e-01f, 1.09108994e-02f, 3.26743908e-02f, -5.89228496e-02f,
  9.20834243e-02f, 7.16312677e-02f, 1.10405378e-01f, -2.63858251e-02f, 1.02940798e-01f, 2.42464878e-02f, 4.98847328e-02f, 3.39423195e-02f, -1.58149563e-02f, 7.01255947e-02f,
  -4.08941172e-02f, -5.28177321e-02f, 4.02873494e-02f, -2.35186145e-02f, 4.79076244e-02f, 4.32070121e-02f, -2.33512721e-03f, -2.67270971e-02f, -2.79706176e-02f, 6.70701191e-02f,
  2.03674585e-01f, -8.62811357e-02f, 4.22428064e-02f, 1.77785624e-02f, -7.62248859e-02f, -1.16872832e-01f, 4.38051894e-02f, -4.63439152e-02f, -5.50693497e-02f, 3.47249140e-03f,
  5.46577154e-03f, -1.23642329e-02f, 1.19028062e-01f, -7.67383948e-02f, -8.04538056e-02f, -3.42756771e-02f, 7.70060942e-02f, -1.03698792e-02f, 7.40990564e-02f, -2.87818927e-02f,
  -3.82624231e-02f, 9.71873626e-02f, -5.89663982e-02f, -4.44714315e-02f, 2.99939550e-02f, 7.38012418e-02f, 8.58611986e-02f, 6.61019562e-03f, 2.34326124e-02f, 2.69179773e-02f,
  -1.09080680e-01f, -1.00609571e-01f, -5.31409904e-02f, 4.98806350e-02f, -5.46537563e-02f, -5.98480739e-02f, 4.49032746e-02f, 9.81107429e-02f, 6.71474412e-02f, 5.50585911e-02f,
  -5.86610101e-03f, 1.62000284e-02f, 1.58481877e-02f, -5.98488636e-02f, -5.32106794e-02f, -8.50004852e-02f, -1.43997416e-01f, -7.26056322e-02f, 4.99186963e-02f, 7.67352730e-02f,
  9.02289972e-02f, -7.93716386e-02f, -9.94046032e-02f, 4.60420549e-03f, -3.34082022e-02f, 5.23234420e-02f, 2.02326458e-02f, 2.07913741e-02f, -8.70890170e-03f, -8.79868641e-02f,
  1.37995882e-02f, -7.40983784e-02f, -5.28763719e-02f, 3.82606313e-02f, -5.74131347e-02f, 4.62902896e-02f, 1.86059438e-02f, 3.76103781e-02f, 5.43576367e-02f, -3.23921293e-02f,
  4.12955284e-02f, -3.24400775e-02f, -3.18514220e-02f, -4.35053036e-02f, -5.89394383e-02f, -4.29026913e-05f, -8.75963196e-02f, -5.88865429e-02f, 2.34257877e-02f, -7.34060258e-02f,
  3.29393484e-02f, -8.89736116e-02f, -6.70119599e-02f, 5.84451258e-02f, -2.56453026e-02f, 4.77275020e-03f, 9.30563807e-02f, 7.22001866e-02f, 4.05480266e-02f, -8.90464187e-02f,
  -7.07815215e-02f, -4.57111970e-02f, 6.01618551e-02f, 6.74055517e-02f, -2.85111945e-02f, -2.39989604e-03f, 5.41129299e-02f, -8.50810558e-02f, 2.30970159e-02f, 5.61005808e-02f,
  -2.10894383e-02f, -3.37451398e-02f, 7.12431148e-02f, 9.27124545e-03f, 4.05632257e-02f, -1.26764951e-02f, 3.09651103e-02f, -7.71519244e-02f, -5.78115880e-02f, -7.32865185e-02f,
  -5.02219908e-02f, -1.42563703e-02f, 4.86011840e-02f, -2.32122522e-02f, 3.43701877e-02f, 4.29779254e-02f, -1.58195477e-02f, 4.31793891e-02f, 4.26148921e-02f, -7.86071792e-02f,
  1.34950116e-01f, -1.13000438e-01f, -1.50982849e-02f, -2.93996651e-02f, 4.05448452e-02f, 4.99895550e-02f, 3.73987369e-02f, -9.28312615e-02f, 5.59850503e-03f, 7.77151287e-02f,
  1.53230308e-02f, -5.07336855e-02f, 5.16849272e-02f, 6.59142062e-02f, 1.11402264e-02f, -7.42148384e-02f, -6.27258942e-02f, -3.28097418e-02f, -3.46235819e-02f, 4.59257001e-03f,
  -3.05747427e-02f, -2.44664270e-02f, -6.07047528e-02f, 1.08206775e-02f, 4.69119102e-02f, 1.32690398e-02f, -2.11605784e-02f, -6.83228672e-03f, -5.18858582e-02f, -5.64597249e-02f,
  2.85247624e-01f, 1.15907878e-01f, 2.66920120e-01f, -6.54678186e-03f, 2.68791728e-02f, 1.08563185e-01f, 5.39226048e-02f, 9.08303075e-03f, -1.32793058e-02f, -2.31652940e-03f,
  -1.07863955e-01f, -7.01945201e-02f, -7.88176507e-02f, 2.29280759e-02f, 2.36460231e-02f, 6.57156706e-02f, 1.30140185e-01f, 1.79131374e-01f, 1.08581387e-01f, 1.17415123e-01f,
  5.43775968e-02f, 1.10555939e-01f, 1.23577304e-01f, 8.88184756e-02f, 2.50749383e-02f, -6.84930757e-02f, 5.80282025e-02f, 2.10376829e-03f, 5.79494648e-02f, -6.90295398e-02f,
  4.53516692e-02f, 2.86555916e-01f, -1.36246651e-01f, -9.66072977e-02f, 4.64051254e-02f, 1.07990466e-01f, 3.24841961e-02f, 8.37154388e-02f, -1.86782610e-02f, 3.36019807e-02f,
  -1.06992252e-01f, 7.03127012e-02f, -9.07735229e-02f, 9.02501941e-02f, 5.04257046e-02f, 2.57772170e-02f, 6.30588010e-02f, 4.76404885e-03f, 3.97640429e-02f, 9.59212333e-02f,
  -7.50946328e-02f, 8.12496096e-02f, 1.07688792e-01f, 6.39510676e-02f, 4.46019582e-02f, -1.00280747e-01f, 8.53172466e-02f, -4.80517559e-02f, 3.14115956e-02f, 8.53876919e-02f,
  -8.06294084e-02f, 8.54479447e-02f, -1.00662597e-01f, 2.75109243e-02f, 3.32490690e-02f, -9.57567543e-02f, 4.25916240e-02f, -6.97336532e-03f, 1.06496802e-02f, -3.19906101e-02f,
  -1.62908752e-02f, 5.49337603e-02f, -7.69905522e-02f, 1.71745736e-02f, -8.65363106e-02f, 4.18514870e-02f, 2.31671967e-02f, -7.29068667e-02f, -2.72446424e-02f, 2.11966457e-03f,
  -6.56811073e-02f, 5.25749810e-02f, 2.84698163e-03f, 4.24043722e-02f, -4.64235879e-02f, 7.17467517e-02f, 2.47461125e-02f, 1.59852318e-02f, -4.01544981e-02f, -4.28732485e-02f,
  -1.87802777e-01f, -6.11703135e-02f, -6.42487854e-02f, -1.27936611e-02f, -7.23507488e-03f, -7.24863112e-02f, -7.78898075e-02f, 6.82788938e-02f, -2.64720861e-02f, 2.84162629e-03f,
  -7.05457106e-02f, -4.20592017e-02f, 4.63473611e-02f, 1.93090998e-02f, -4.46378894e-04f, 9.90393907e-02f, -4.08897735e-02f, -4.51275446e-02f, -5.96521348e-02f, -9.70627181e-03f,
  -5.08522615e-02f, -1.38560841e-02f, -9.92343528e-04f, -4.84298356e-02f, 1.41641600e-02f, 1.93526708e-02f, 5.00162654e-02f, -1.79335810e-02f, 8.77741650e-02f, 6.53745160e-02f,
  -1.83304057e-01f, 3.38234031e-03f, -1.37186542e-01f, -9.49979946e-02f, -6.99659511e-02f, -3.47143784e-02f, -5.18338270e-02f, 7.00399950e-02f, -2.22518966e-02f, -1.19562946e-01f,
  -2.41431277e-02f, 3.37598659e-03f, -4.33065444e-02f, 2.39138752e-02f, 3.95686068e-02f, -1.45221680e-01f, -2.78276540e-02f, 1.68023203e-02f, -2.66665202e-02f, 2.32939273e-02f,
  -1.65775791e-02f, -4.63832803e-02f, -9.11559388e-02f, 8.70548934e-02f, 1.37488008e-01f, 3.83168608e-02f, -2.95836888e-02f, -3.18736881e-02f, 2.29902025e-02f, -5.27504273e-02f,
  1.66410916e-02f, -7.96727240e-02f, 4.03678380e-02f, 4.94952872e-03f, -6.40772060e-02f, -2.73953490e-02f, -2.92538814e-02f, -4.59874012e-02f, 1.40937157e-02f, 6.32888228e-02f,
  1.62710005e-03f, 4.25929800e-02f, 5.49713261e-02f, -4.33651656e-02f, 3.32881622e-02f, -3.09935072e-03f, -3.31412815e-02f, 1.42320413e-02f, -4.63323016e-03f, -5.45118889e-03f,
  -5.11909723e-02f, -9.11278650e-02f, -5.98633364e-02f, 2.07974408e-02f, -6.58885315e-02f, -5.13728634e-02f, 1.12965688e-01f, 5.84099554e-02f, -2.52698846e-02f, 1.19877659e-01f,
  -5.77387847e-02f, -4.41600010e-02f, 3.15294950e-03f, 3.87926511e-02f, -4.46085408e-02f, 2.41530295e-02f, -4.96900454e-02f, -4.75536585e-02f, 2.96200253e-02f, 4.96560670e-02f,
  -6.93337545e-02f, -7.59593910e-03f, -5.65935485e-02f, 5.63194826e-02f, 5.86955547e-02f, 3.79730463e-02f, -9.12026316e-02f, 4.11271006e-02f, -3.67870592e-02f, 1.00411884e-01f,
  5.36577106e-02f, 7.03343228e-02f, 3.50915641e-02f, 1.02168068e-01f, -1.34428237e-02f, -7.68455043e-02f, -4.56019528e-02f, 1.05855450e-01f, 1.11932091e-01f, -6.04936443e-02f,
  1.31645039e-01f, -8.13819245e-02f, -4.27597165e-02f, -8.80551562e-02f, -5.01315147e-02f, 6.53980970e-02f, 4.07491177e-02f, -4.36346456e-02f, -1.96134038e-02f, -4.01959047e-02f,
  2.24579568e-03f, -2.55234018e-02f, -7.92430490e-02f, -1.43122701e-02f, 4.97571267e-02f, 4.18037996e-02f, 7.96588883e-03f, 1.13391934e-03f, 4.30755913e-02f, 7.38299266e-03f,
  -8.45196769e-02f, -1.11318871e-01f, -2.66750269e-02f, 4.27724309e-02f, -2.89510377e-02f, -6.40345961e-02f, 8.29038993e-02f, 7.93720484e-02f, -6.70566633e-02f, -1.95221119e-02f,
  -2.12789755e-02f, 1.12930939e-01f, 1.54376552e-02f, 7.15239942e-02f, -1.64177604e-02f, -7.33528193e-03f, 2.22608931e-02f, 8.62722471e-02f, 3.89271416e-02f, 1.04472898e-02f,
  2.25018542e-02f, 3.22368145e-02f, 1.35816366e-03f, 8.17552488e-03f, 8.03786963e-02f, -2.84085777e-02f, -6.68915734e-02f, -3.31301540e-02f, 3.14112529e-02f, -3.93955484e-02f,
  7.34240189e-02f, 4.06527296e-02f, 8.49156305e-02f, 6.03318252e-02f, -7.53432140e-03f, -1.02019444e-01f, -4.24940139e-02f, -2.46507451e-02f, -1.54850194e-02f, 7.00384453e-02f,
  4.07216921e-02f, 1.37327895e-01f, 8.77443701e-03f, -3.13201882e-02f, 9.76822600e-02f, 1.09184630e-01f, 3.53257768e-02f, 9.00850892e-02f, 8.12680721e-02f, 3.25095803e-02f,
  9.67084616e-02f, 7.84066021e-02f, 1.03455469e-01f, -6.13379180e-02f, 1.20425567e-01f, 5.90505078e-03f, -4.71895449e-02f, 4.34443168e-02f, 7.07611293e-02f, 1.73560344e-03f,
  8.12893361e-02f, 7.79476613e-02f, 4.26270589e-02f, -9.32746232e-02f, -5.64662972e-03f, -1.00169048e-01f, 1.66590828e-02f, 3.21894288e-02f, 6.62103072e-02f, -2.96163633e-02f,
  -1.33854285e-01f, 2.03692019e-02f, 3.60842161e-02f, -9.48835239e-02f, -2.28265729e-02f, -4.52051871e-02f, 3.90412211e-02f, -7.95067176e-02f, -9.33343908e-05f, 3.19147967e-02f,
  -3.47653888e-02f, -2.30315942e-02f, 9.21405405e-02f, -4.90306094e-02f, 6.84673488e-02f, 6.49474189e-02f, -3.16287354e-02f, -4.56972755e-02f, 1.94152538e-02f, 8.91719759e-02f,
  -2.23611649e-02f, 7.67891854e-02f, 1.80678386e-02f, -5.18737920e-02f, 9.23121441e-03f, -1.86823821e-03f, -7.28520900e-02f, -4.30796929e-02f, -4.68554758e-02f, -8.34177658e-02f,
  6.51960224e-02f, -9.39553976e-02f, 8.10010508e-02f, -4.28549480e-03f, -5.30737899e-02f, 9.30499360e-02f, 5.00648329e-03f, 9.57712457e-02f, -1.59676354e-02f, 2.27080844e-02f,
  3.22208628e-02f, 3.50458175e-03f, 7.14033246e-02f, -2.33225152e-02f, -2.22966727e-02f, 5.47975153e-02f, -2.92919073e-02f, -4.47436124e-02f, 7.58607090e-02f, 1.19244128e-01f,
  -6.82110786e-02f, -1.63847599e-02f, 6.44657239e-02f, -4.66028415e-02f, -3.44846807e-02f, -3.94576378e-02f, -1.30447298e-01f, -1.07428588e-01f, -9.44962427e-02f, -7.43651614e-02f,
  -9.39098895e-02f, -3.10966261e-02f, 2.84589063e-02f, 3.75612080e-02f, 1.81145668e-01f, 6.54710010e-02f, 1.09763062e-02f, -3.44514735e-02f, 1.45673417e-02f, 1.08666711e-01f,
  1.50330096e-01f, 1.26988009e-01f, 1.24636449e-01f, 1.02575421e-01f, 1.12277985e-01f, -1.70264824e-03f, -1.73705760e-02f, 8.27406868e-02f, 2.71905940e-02f, -4.02863733e-02f,
  2.68818978e-02f, 4.00901288e-02f, -1.35623351e-01f, 7.15622529e-02f, 7.31677115e-02f, 5.77286258e-03f, -5.47028556e-02f, -6.54730126e-02f, -6.57729432e-02f, 5.38361296e-02f,
  4.45344299e-02f, -9.25080478e-02f, 1.05202876e-01f, 1.48015562e-02f, 5.51481508e-02f, 3.76477167e-02f, -2.93077193e-02f, -1.44842356e-01f, 4.60867845e-02f, 5.98824350e-03f,
  -4.47823182e-02f, -1.14601292e-01f, -3.62967327e-02f, -1.12749830e-01f, 2.89599244e-02f, 3.75380330e-02f, -5.38662821e-02f, -7.99089521e-02f, -4.93692979e-02f, -6.05385564e-02f,
  4.23597358e-02f, -7.99699053e-02f, -1.05014443e-01f, 3.87697318e-03f, -8.86166617e-02f, -2.92689670e-02f, 1.22686755e-02f, -1.21916562e-01f, -1.01768270e-01f, -9.62256044e-02f,
  7.50048757e-02f, 2.89821289e-02f, 4.93885763e-02f, -2.96946708e-02f, -8.02502930e-02f, 6.70294091e-02f, -3.03226411e-02f, -1.72299184e-02f, 4.19843979e-02f, -2.94377282e-02f,
  4.57688086e-02f, 4.62194197e-02f, 3.89559306e-02f, -3.11674159e-02f, 9.97885391e-02f, 2.39722747e-02f, -7.70405307e-02f, 1.09114461e-01f, 2.59580910e-02f, -3.04356366e-02f,
  5.05922437e-02f, 8.61254707e-03f, -3.34039070e-02f, 7.20735490e-02f, 6.62557110e-02f, -3.10111009e-02f, 7.10944682e-02f, -2.98788641e-02f, -6.43721297e-02f, -5.37387058e-02f,
  2.78126635e-02f, 6.57409132e-02f, -5.27642258e-02f, 6.77178754e-03f, -8.55193213e-02f, -3.19846696e-03f, -1.46153364e-02f, 2.04302240e-02f, 7.31875934e-03f, 1.81502700e-02f,
  -4.20786440e-02f, 4.90051601e-03f, -1.03920832e-01f, 4.56055850e-02f, -8.57243985e-02f, -1.06044477e-02f, -1.14620067e-01f, -5.65018505e-02f, -3.43856663e-02f, 2.71314867e-02f,
  6.90853223e-02f, 3.29520414e-03f, -1.58147216e-02f, -1.07721820e-01f, 2.85550747e-02f, -6.41993657e-02f, -1.82604715e-02f, -2.41912287e-02f, -8.90365541e-02f, -1.11283720e-01f,
  -3.43041390e-01f, -1.13787182e-01f, -1.10000059e-01f, -7.85456300e-02f, 3.69418524e-02f, 1.84764057e-01f, -8.09030905e-02f, -5.30980490e-02f, 1.28948271e-01f, -9.39397980e-03f,
  -4.41831313e-02f, -8.68117362e-02f, -7.80366436e-02f, -8.09604749e-02f, -2.34167889e-01f, -2.28138179e-01f, -1.25948995e-01f, -2.31122673e-01f, -3.60185690e-02f, 4.36952747e-02f,
  1.19331013e-02f, -1.42776504e-01f, -1.95321515e-01f, 4.67372313e-02f, 9.28556845e-02f, -4.37213741e-02f, -9.41028818e-02f, -1.20760441e-01f, 1.24933124e-01f, -1.15306795e-01f,
  8.05170313e-02f, 4.45797779e-02f, 1.04576163e-01f, -7.33643919e-02f, 1.30178407e-01f, 1.18269026e-01f, 7.44530410e-02f, 8.36152509e-02f, 8.17483142e-02f, -4.13785726e-02f,
  -3.40228342e-02f, 7.80423172e-03f, -3.86680067e-02f, -2.09557600e-02f, -6.94335923e-02f, -7.52968043e-02f, -1.01052642e-01f, -1.06422476e-01f, -7.59292394e-02f, 1.88845191e-02f,
  -2.38994807e-02f, -3.64111066e-02f, -1.16379686e-01f, -1.73262022e-02f, 2.39539091e-02f, 2.45987847e-02f, 7.55697861e-02f, 1.37255758e-01f, 1.40782613e-02f, -4.22381088e-02f,
  -3.66683630e-03f, 5.08174114e-02f, 1.07616112e-02f, -1.16407163e-01f, -2.95316130e-02f, 4.16759402e-02f, 1.90613847e-02f, 1.97053812e-02f, -7.17533156e-02f, 1.75028938e-04f,
  3.10428329e-02f, 8.25704411e-02f, -7.72664100e-02f, -8.34538788e-02f, 8.72317888e-03f, 5.33295423e-02f, 8.66568461e-02f, -9.28292125e-02f, 2.04203697e-03f, -6.22893358e-03f,
  -6.99000433e-02f, 3.71747985e-02f, -6.03749827e-02f, 5.83240613e-02f, 2.33363267e-03f, 2.04381254e-02f, 3.76339220e-02f, -6.01554029e-02f, -5.21850027e-02f, -6.24943487e-02f,
  -1.35383219e-01f, -6.47453368e-02f, -7.83509091e-02f, -4.39137667e-02f, 3.54563142e-03f, -2.98003051e-02f, 8.31980444e-03f, -2.82570557e-03f, -2.28760000e-02f, -3.03721614e-03f,
  5.25945649e-02f, 4.64160703e-02f, 5.95920486e-03f, -3.25468406e-02f, 3.43918651e-02f, -7.97807500e-02f, -1.49988100e-01f, -5.26317060e-02f, -3.02208923e-02f, 1.34032965e-02f,
  -1.01482838e-01f, -1.66064784e-01f, -1.84162915e-01f, 9.00109764e-03f, 4.42766435e-02f, -8.77209306e-02f, -1.14436954e-01f, 2.37709540e-03f, -1.45933941e-01f, -2.17728227e-01f,
  2.54177451e-01f, 1.58124030e-01f, 2.95635730e-01f, 1.92606106e-01f, 3.09845209e-01f, 2.82105565e-01f, 3.18367839e-01f, 2.14274958e-01f, 1.17432952e-01f, 8.54998380e-02f,
  7.46828988e-02f, -1.47137493e-01f, -6.45338297e-02f, -7.14811906e-02f, -1.76713113e-02f, 6.84295893e-02f, 2.64513809e-02f, 1.10794373e-01f, 1.66521624e-01f, 6.93634003e-02f,
  -1.20808959e-01f, -7.68019706e-02f, 6.48778081e-02f, 6.23574555e-02f, -5.12105748e-02f, -1.61558650e-02f, 1.30291015e-01f, 8.44769704e-04f, -8.31798539e-02f, -5.72159253e-02f,
  -2.56727561e-02f, 3.28710020e-01f, -7.87955225e-02f, -7.38284960e-02f, 1.52968857e-02f, -6.13234565e-02f, -4.51904861e-03f, -6.16781935e-02f, 1.31069089e-03f, -1.97089203e-02f,
  1.73628628e-02f, 2.00174339e-02f, -2.82737408e-02f, 1.88138373e-02f, -1.46608176e-02f, 1.25409318e-02f, 3.28607261e-02f, 6.11243881e-02f, -6.19029403e-02f, 4.68549840e-02f,
  -4.40723188e-02f, -4.20287848e-02f, 1.50300190e-01f, 8.67810696e-02f, 1.01652168e-01f, -4.26758640e-02f, 1.23546265e-01f, 2.15833262e-02f, 1.34437516e-01f, -3.24794650e-02f,
  4.93941829e-02f, -2.37404313e-02f, 2.67016739e-02f, -6.04065023e-02f, -4.24742997e-02f, -6.98450208e-02f, 2.84514967e-02f, -1.60981379e-02f, 7.42452964e-02f, 2.30736472e-02f,
  -8.44957903e-02f, 6.70550540e-02f, -7.87550304e-03f, 1.11851748e-02f, 1.70268081e-02f, -9.79359611e-04f, -2.09877361e-02f, 6.66267937e-03f, -9.81494226e-03f, -4.91527319e-02f,
  -3.58606949e-02f, 8.27306733e-02f, 4.24201265e-02f, -1.18705980e-01f, -4.55624685e-02f, 2.39708694e-03f, -6.43574027e-03f, -7.25479200e-02f, 2.85283700e-02f, -6.99655712e-02f,
  -2.57417649e-01f, 1.47750258e-01f, 6.85027987e-03f, -1.29627377e-01f, 5.57492953e-03f, -1.35936484e-01f, 6.07113242e-02f, -7.06621781e-02f, -5.04653864e-02f, -6.33401945e-02f,
  -4.59766993e-03f, -6.73249960e-02f, -4.81267646e-02f, -2.07187608e-03f, 5.02644107e-02f, 6.72480315e-02f, -1.19890526e-01f, 4.18363065e-02f, -3.05718593e-02f, -4.42063175e-02f,
  -2.72834674e-02f, -6.78374916e-02f, 1.90431960e-02f, 1.00647897e-01f, -4.94504310e-02f, -5.47032654e-02f, -1.37669548e-01f, 4.13855352e-02f, -2.61743069e-02f, -5.60346693e-02f,
  2.81234421e-02f, -6.02629632e-02f, 1.02839805e-01f, 1.11411000e-02f, -5.73364347e-02f, 4.13429849e-02f, 5.23130633e-02f, 2.05292460e-02f, 7.95468036e-03f, -2.70357039e-02f,
  4.86561209e-02f, -3.76680270e-02f, 9.82840806e-02f, -4.74850573e-02f, -1.72792301e-02f, -1.38937607e-02f, -5.96326888e-02f, 6.75040334e-02f, 1.98347926e-01f, 6.60164058e-02f,
  -8.42882320e-02f, -8.79415572e-02f, -9.27095935e-02f, 2.37181745e-02f, -6.34730682e-02f, 9.71652046e-02f, -2.91139036e-02f, 1.28471339e-02f, -1.07062645e-02f, -2.64821909e-02f,
  2.25170881e-01f, 4.92256247e-02f, 1.03147916e-01f, -6.97391406e-02f, 4.21845028e-03f, 7.36928685e-03f, 3.13547510e-03f, 7.44065456e-03f, -4.44312319e-02f, 3.77134532e-02f,
  -7.27960393e-02f, -8.59071016e-02f, 8.18215311e-02f, -6.26727343e-02f, 3.52467820e-02f, 7.53708780e-02f, -1.31719941e-02f, -5.72501272e-02f, -4.97667007e-02f, 6.19667731e-02f,
  -6.31642193e-02f, 3.66573296e-02f, 8.38800594e-02f, 5.07393666e-02f, 2.99648624e-02f, 8.11198205e-02f, 1.90469704e-03f, -3.51237953e-02f, -8.63409415e-03f, -5.07056564e-02f,
  1.83991324e-02f, 9.49415043e-02f, 3.54340486e-02f, -4.72411551e-02f, 8.24182928e-02f, -3.62307914e-02f, -1.12580629e-02f, 4.98024821e-02f, -4.21109982e-03f, -6.48947991e-03f,
  -4.67676148e-02f, 4.68510725e-02f, 4.02389355e-02f, -3.63312103e-02f, -6.58450276e-02f, -1.53325899e-02f, 2.08908133e-02f, -3.85430977e-02f, 3.54849435e-02f, 6.97993115e-02f,
  -4.56115324e-03f, -1.34053295e-02f, -1.02869920e-01f, 2.74881516e-02f, -1.35241181e-01f, 4.68601510e-02f, -1.69379786e-02f, -6.75167069e-02f, -7.63721466e-02f, 1.13872010e-02f,
  1.55095890e-01f, 1.04611740e-01f, 1.11219846e-01f, 6.71023875e-02f, 4.85239141e-02f, -7.73922950e-02f, 8.70398805e-03f, -5.83859570e-02f, 1.72474310e-02f, 2.42369343e-02f,
  4.71080244e-02f, 9.08375978e-02f, 1.06733426e-01f, -8.46457332e-02f, 2.53220145e-02f, -8.01172573e-03f, 3.63315232e-02f, 6.34500012e-02f, -4.02837694e-02f, -6.84110448e-02f,
  -2.61478894e-03f, 7.82337785e-02f, 1.60043128e-02f, 1.57785237e-01f, 5.64618558e-02f, 1.70453876e-01f, 1.20015256e-01f, 3.30467299e-02f, 8.00916776e-02f, 1.01906255e-01f,
  -3.05204242e-01f, 7.28498995e-02f, -1.35668635e-01f, 3.76855657e-02f, 1.72554925e-01f, 1.82063639e-01f, 2.05808073e-01f, 1.62244231e-01f, 1.16603054e-01f, -1.99144520e-02f,
  -1.19677735e-02f, 3.17610055e-02f, 2.03154176e-01f, 1.63576663e-01f, 1.43051207e-01f, 1.18254922e-01f, 2.30872437e-01f, 6.60456121e-02f, 3.51689234e-02f, -5.13650775e-02f,
  3.04549765e-02f, 2.13787537e-02f, -2.01213643e-01f, 5.57494126e-02f, 1.79450452e-01f, 1.23026535e-01f, 5.92493191e-02f, -9.93997902e-02f, -3.96192372e-02f, 6.20186962e-02f,
  -1.50476277e-01f, -1.32545829e-01f, 6.24197200e-02f, 6.64250702e-02f, -7.20751956e-02f, -4.74906266e-02f, -6.77848086e-02f, -5.01173958e-02f, 8.81207641e-03f, -1.08763412e-01f,
  -3.59755121e-02f, -7.51467124e-02f, 1.40667871e-01f, 1.99703164e-02f, -4.49390933e-02f, -8.32582861e-02f, 4.42481339e-02f, -3.44281830e-02f, 2.08437070e-02f, 5.01033012e-03f,
  1.33995235e-01f, 5.07572666e-02f, -8.54516551e-02f, 2.11571828e-02f, 1.13037586e-01f, -1.93381645e-02f, -1.12375841e-02f, 1.04417846e-01f, -5.16652986e-02f, 5.20801023e-02f,
  -1.34732090e-02f, -1.95441041e-02f, 3.28417569e-02f, 5.25250807e-02f, 5.89262359e-02f, -5.22767603e-02f, -8.77010357e-03f, 4.42514308e-02f, 4.84324805e-02f, -3.86626162e-02f,
  -3.58968414e-02f, 5.26434220e-02f, 1.16073966e-01f, -2.22301278e-02f, -1.51039818e-02f, 1.01602925e-02f, -3.86319086e-02f, 3.89216617e-02f, -5.92351183e-02f, 2.64997464e-02f,
  5.47847189e-02f, -6.24858662e-02f, 2.45444365e-02f, 7.88794383e-02f, 7.22218379e-02f, 6.12205779e-03f, -3.96288075e-02f, -1.50788401e-03f, -9.57502574e-02f, 4.47059684e-02f,
  -1.06681541e-01f, 6.08847477e-02f, 2.98537891e-02f, 6.50048703e-02f, 5.11476733e-02f, -2.38892827e-02f, 3.54384333e-02f, -7.30486438e-02f, 3.17155384e-02f, -8.10463950e-02f,
  1.54470978e-02f, -3.60566452e-02f, 1.93486195e-02f, -9.90018025e-02f, -8.81453156e-02f, -1.17992625e-01f, 9.61311068e-03f, -4.28919680e-03f, -1.80407800e-02f, 1.51297851e-02f,
  9.07206461e-02f, -6.38642535e-02f, -7.38963559e-02f, 5.70430718e-02f, 2.99730524e-02f, -1.47754848e-02f, 2.32165400e-02f, -1.73452757e-02f, -2.44409963e-02f, -1.68912143e-01f,
  -6.23342544e-02f, 1.29663004e-02f, 7.86438212e-02f, -1.01516254e-01f, -4.46851440e-02f, 1.78487822e-02f, 2.30343407e-03f, 6.82405680e-02f, 6.11051917e-03f, 2.07850784e-02f,
  5.68580329e-02f, 2.06639548e-03f, 7.51216114e-02f, 1.43091390e-02f, 1.49375824e-02f, 1.19041085e-01f, -4.17126603e-02f, -1.84243859e-03f, 8.00795555e-02f, 1.10629769e-02f,
  -1.06099909e-02f, -5.50982617e-02f, -5.02193682e-02f, -4.05626595e-02f, 8.18275511e-02f, 8.84380564e-02f, 5.92481643e-02f, -6.34183139e-02f, -6.53637201e-02f, -1.11927707e-02f,
  5.68305515e-02f, -1.00472085e-01f, 7.29183704e-02f, -1.26424236e-02f, 1.64342746e-02f, 2.47700550e-02f, 2.66997479e-02f, -1.07929837e-02f, 3.45251299e-02f, -2.56754681e-02f,
  -5.74925020e-02f, -3.22778597e-02f, 6.67104423e-02f, 2.65794178e-03f, 4.92487475e-02f, 1.03759788e-01f, -4.38451357e-02f, -1.60149182e-03f, -5.92022128e-02f, 1.04781032e-01f,
  9.56296325e-02f, -2.05698982e-02f, -8.68320558e-03f, -6.15782626e-02f, -1.93745997e-02f, 6.71342686e-02f, 9.00064558e-02f, 5.88353239e-02f, 1.54101746e-02f, 8.00129212e-03f,
  6.07954711e-02f, -8.60292614e-02f, -1.01350695e-01f, -4.47507612e-02f, -3.92423719e-02f, -6.42971098e-02f, 4.82164882e-02f, -3.33544724e-02f, -3.39507051e-02f, 4.36368398e-02f,
  -8.56428817e-02f, 4.71532010e-02f, -2.59482618e-02f, -8.14831033e-02f, 9.49261487e-02f, 5.49357720e-02f, -3.45858629e-03f, 5.62879257e-02f, 1.09426333e-02f, -4.81552035e-02f,
  -9.04292762e-02f, 3.36881168e-02f, 7.15500191e-02f, -3.91275734e-02f, 4.90885451e-02f, -9.56660137e-03f, -8.48848820e-02f, -2.84896288e-02f, 1.87631492e-02f, -7.68656135e-02f,
  7.08794743e-02f, -1.55429374e-02f, -1.14238663e-02f, 1.53210061e-02f, -8.24194774e-02f, -6.55234009e-02f, 3.94121967e-02f, -4.29100953e-02f, -1.42878480e-02f, 8.76719784e-03f,
  -4.50404622e-02f, -1.68065690e-02f, -3.30762304e-02f, -2.84985062e-02f, 2.03712545e-02f, 6.36250377e-02f, -5.10965027e-02f, -2.21095271e-02f, -2.46497728e-02f, 6.41319230e-02f,
  4.35852334e-02f, 4.70255166e-02f, -1.57319326e-02f, 2.43416596e-02f, -1.25923930e-02f, 2.46992148e-02f, 8.88040196e-03f, 8.77904445e-02f, -7.00815469e-02f, 5.56224734e-02f,
  -4.80118871e-01f, -8.68682470e-03f, -5.82462689e-03f, -3.56650800e-01f, -1.60972979e-02f, 6.16342388e-02f, 1.58795714e-01f, 7.06287250e-02f, -1.65579185e-01f, -1.48204584e-02f,
  4.01896089e-02f, -5.04178368e-02f, -1.33555576e-01f, 5.05707823e-02f, 6.41238615e-02f, 2.20710933e-02f, -4.63414518e-03f, -2.88873147e-02f, -8.39051008e-02f, 4.97159734e-02f,
  -2.51034740e-02f, -2.05814630e-01f, -1.43135265e-01f, 1.08033475e-02f, -4.41851616e-02f, -9.70747322e-02f, -1.89615693e-02f, -1.10824957e-01f, 4.70425710e-02f, -4.76344908e-03f,
  -9.13570169e-03f, -1.04243584e-01f, -3.79091091e-02f, -1.01355448e-01f, 3.02287396e-02f, 1.06635771e-03f, -2.62867529e-02f, -6.27034754e-02f, -1.91128291e-02f, -5.95380776e-02f,
  2.21197344e-02f, -8.67704153e-02f, -7.17357099e-02f, 5.64742647e-02f, -9.55668092e-02f, -9.36041474e-02f, 4.84195389e-02f, -2.85971500e-02f, 1.00011364e-01f, 1.52653903e-02f,
  -4.23712598e-04f, 5.60732838e-03f, 7.46763125e-02f, 1.48408681e-01f, 3.76237594e-02f, 7.33591989e-03f, 1.96271203e-02f, 1.16863057e-01f, 1.50977299e-01f, -1.74238868e-02f,
  2.62051616e-02f, 3.58145288e-03f, 3.17116044e-02f, -1.21926535e-02f, -2.18255743e-02f, 4.13575284e-02f, 2.56907195e-02f, -2.10426636e-02f, 2.33162995e-02f, 1.04767811e-02f,
  2.94101611e-03f, 1.63243560e-03f, -3.72246541e-02f, -4.02202681e-02f, -8.19490328e-02f, 4.24015149e-02f, 5.32880984e-02f, -1.70665607e-02f, 5.94978034e-02f, 1.06264483e-02f,
  -7.54256733e-03f, 2.47013150e-03f, -9.23652574e-02f, 3.22472043e-02f, 1.29440784e-01f, -6.79747164e-02f, 5.60719110e-02f, -3.94049212e-02f, -3.18755955e-02f, -4.26516356e-03f,
  -1.23649880e-01f, 7.00421855e-02f, -9.29145515e-03f, -9.35112759e-02f, -1.06603205e-01f, 6.62500113e-02f, -1.81329660e-02f, -8.08191374e-02f, -7.96535611e-02f, -2.68067587e-02f,
  6.13796972e-02f, 5.38819991e-02f, -2.01233942e-02f, 1.00496650e-01f, 2.01371126e-02f, -8.30593184e-02f, 1.46349855e-02f, -5.76666594e-02f, 3.61336954e-02f, -4.78557795e-02f,
  1.17924839e-01f, -3.17365713e-02f, -4.44061719e-02f, 6.35124967e-02f, 2.69043595e-02f, 3.21921222e-02f, 1.25683658e-02f, 4.10178900e-02f, 1.40642617e-02f, 3.29359397e-02f,
  -2.10187942e-01f, -1.72074571e-01f, -7.92682692e-02f, -2.42336243e-01f, -1.66902170e-01f, -5.47483042e-02f, -1.22161850e-01f, 1.62592100e-04f, -4.81517315e-02f, -1.62104562e-01f,
  -5.19874766e-02f, -8.14089086e-03f, 1.10822581e-01f, 1.29827885e-02f, 1.34648249e-01f, -9.47474167e-02f, -7.59538710e-02f, 5.16523644e-02f, 1.36059061e-01f, 7.48875886e-02f,
  -1.92581564e-02f, -1.97826326e-02f, 9.00973752e-02f, 1.03589199e-01f, -2.17826962e-02f, 7.16461465e-02f, -2.71476824e-02f, 2.81451531e-02f, -1.37075444e-03f, -1.37811139e-01f,
  6.41170070e-02f, -1.77041516e-01f, -5.30736856e-02f, 1.23797748e-02f, 2.77070422e-02f, -7.69997314e-02f, -1.96433570e-02f, -2.15469711e-02f, 5.15408553e-02f, 7.21666729e-03f,
  8.21453112e-04f, -1.98314786e-02f, 6.87308684e-02f, -2.68445667e-02f, -6.69844896e-02f, 4.92061023e-04f, -7.63994753e-02f, -5.62896319e-02f, -1.61468536e-02f, 7.35174119e-02f,
  4.49954951e-03f, 4.64637540e-02f, 4.67248820e-02f, -5.49328066e-02f, 7.78059661e-02f, -5.15374243e-02f, 7.81532824e-02f, -6.78329617e-02f, 9.79566127e-02f, 1.28620556e-02f,
  -9.85514093e-03f, 2.08332725e-02f, -2.03487258e-02f, 4.57409583e-02f, 2.75309235e-02f, 5.87370992e-02f, 9.07045007e-02f, -4.28748950e-02f, -8.14000368e-02f, 7.31705055e-02f,
  4.97327149e-02f, -8.92839506e-02f, 8.54251459e-02f, 3.70427072e-02f, 3.96168828e-02f, 7.85943121e-02f, 7.33759603e-04f, 5.63355908e-02f, 3.70350890e-02f, 2.88300887e-02f,
  -5.77777028e-02f, -8.38797819e-03f, -2.93212887e-02f, 1.17123455e-01f, -2.55300310e-02f, -1.03165142e-01f, -7.41814077e-02f, 3.06186508e-02f, -7.21058547e-02f, -3.07350550e-02f,
  1.12012826e-01f, -4.13097739e-02f, -6.86212406e-02f, 4.92484309e-02f, -8.21096599e-02f, 2.58094445e-02f, -8.83669704e-02f, -3.77354361e-02f, -8.18458796e-02f, 4.42125313e-02f,
  -4.76648845e-02f, -3.43993418e-02f, -7.42705762e-02f, -6.47650138e-02f, -1.17297901e-03f, 7.44185224e-02f, 3.50705013e-02f, 6.83289617e-02f, -3.62235419e-02f, 6.66118115e-02f,
  -3.73379253e-02f, -1.12791231e-03f, 3.97241376e-02f, 2.05924306e-02f, -2.08846387e-02f, -7.60851875e-02f, 5.62335141e-02f, -3.67494710e-02f, -3.39839049e-02f, 4.78625372e-02f,
  -1.08176500e-01f, -8.96757394e-02f, -1.48246765e-01f, 4.04883511e-02f, -1.55794099e-01f, -1.95776910e-01f, -2.42776752e-01f, -8.61653537e-02f, 2.18935460e-02f, -8.83124992e-02f,
  8.58917274e-03f, 1.85138248e-02f, -7.96468183e-02f, -2.54262313e-02f, -1.32549450e-01f, -2.28363618e-01f, -1.21160984e-01f, 1.03896400e-02f, -1.16684891e-01f, 3.22704366e-03f,
  -7.77064776e-03f, -1.10815890e-01f, 8.95753056e-02f, 8.60396624e-02f, -7.45366588e-02f, -8.69468674e-02f, -1.07801380e-02f, -1.12889841e-01f, 1.67767033e-02f, 2.84899212e-02f,
  -1.84385315e-01f, 2.15859059e-02f, -4.26651351e-03f, 1.10094801e-01f, -1.16562247e-01f, -5.79677746e-02f, 8.30473471e-03f, 4.17704806e-02f, -8.57409090e-02f, 3.99532728e-02f,
  -2.20301934e-02f, 1.01866592e-02f, 5.34268431e-02f, -6.66217208e-02f, 6.78436132e-03f, 5.91943562e-02f, -1.14073453e-03f, 6.75516427e-02f, 8.99385568e-03f, 7.97009245e-02f,
  9.31520462e-02f, 5.97153455e-02f, 6.64105341e-02f, 3.21860537e-02f, 4.52383943e-02f, 9.97786149e-02f, 3.36982869e-02f, 4.40470576e-02f, 4.42415103e-02f, 3.76828462e-02f,
  -1.04944587e-01f, 9.25097708e-03f, 4.66889888e-02f, -4.62693023e-03f, -5.89405857e-02f, -3.13556870e-04f, 2.79134326e-02f, -3.48874591e-02f, 3.27914692e-02f, -6.97913766e-02f,
  2.56196726e-02f, 1.99482497e-03f, -1.35973524e-02f, 1.22907013e-02f, -5.50017953e-02f, -3.57789956e-02f, -5.90330251e-02f, 1.51186679e-02f, 1.02427848e-01f, 4.03186679e-02f,
  -6.63540885e-03f, 8.89784172e-02f, 9.24996808e-02f, -5.19234762e-02f, 6.88279932e-03f, -5.00572957e-02f, -1.71512309e-02f, 8.72438252e-02f, -1.06742546e-01f, 5.65663800e-02f,
  -1.11056492e-01f, 1.14389889e-01f, -9.49665962e-04f, 6.89627379e-02f, 4.14208025e-02f, 9.97145288e-03f, -6.83049411e-02f, 1.04409046e-01f, -3.44237536e-02f, 8.51573981e-03f,
  -1.30012548e-02f, -6.82117790e-02f, -3.27979289e-02f, -4.37208898e-02f, -6.26605377e-02f, -3.85722853e-02f, -9.54926107e-03f, 8.44431818e-02f, 8.29638690e-02f, 2.63255443e-02f,
  8.49239901e-02f, 9.18432921e-02f, -2.89189280e-03f, -1.28732594e-02f, 2.87212641e-03f, 5.75117022e-02f, 3.23891118e-02f, -2.33059400e-03f, 8.38287175e-02f, -1.12654172e-01f,
  -7.46311666e-03f, -1.28210425e-01f, -1.30742937e-01f, 6.90763071e-02f, 9.54216495e-02f, -9.20504704e-02f, -2.08535209e-01f, 5.08382246e-02f, 5.64739294e-02f, -1.02722429e-01f,
  6.53897002e-02f, 8.50897878e-02f, -5.74686304e-02f, 8.27135444e-02f, -1.37452424e-01f, -1.21780947e-01f, -1.99443489e-01f, -3.90809327e-02f, 7.42153898e-02f, 6.60780370e-02f,
  1.32425681e-01f, -7.41239497e-03f, 1.10383876e-01f, 2.31047906e-03f, -1.52832679e-02f, 1.59169346e-01f, 6.11622930e-02f, 6.27659112e-02f, -1.92249436e-02f, -6.87799556e-03f,
  -1.24557339e-01f, 6.54268339e-02f, 7.34516010e-02f, 9.57202017e-02f, -8.25102478e-02f, 3.10467780e-02f, -1.54490108e-02f, 3.87410484e-02f, -7.59796277e-02f, -1.07795596e-01f,
  5.32694422e-02f, -1.20729329e-02f, 3.86999957e-02f, 3.09481118e-02f, 4.70572747e-02f, -9.93248150e-02f, -7.96411932e-02f, -5.23380339e-02f, -1.20544255e-01f, 2.72082933e-03f,
  1.14953965e-02f, -4.30781953e-02f, -6.81224316e-02f, -2.87623629e-02f, 3.58856842e-02f, 9.63986814e-02f, -1.24200284e-02f, -1.73062040e-03f, -6.94816411e-02f, 7.06843510e-02f,
  -2.89334841e-02f, -8.11150298e-02f, -7.26269037e-02f, 5.97602688e-02f, -3.41650024e-02f, -7.93622956e-02f, 4.60084947e-03f, 5.27860187e-02f, -8.87442380e-03f, -4.96366918e-02f,
  -3.60344462e-02f, -1.05905226e-02f, 5.99552840e-02f, -2.20056511e-02f, -3.93255539e-02f, -1.03873434e-02f, -2.65164347e-03f, 3.59083712e-02f, 5.74234035e-03f, 1.13519691e-02f,
  -9.67791826e-02f, 1.99638978e-02f, -4.56717759e-02f, -3.89392227e-02f, 4.60699759e-02f, -5.43388352e-02f, 9.87849757e-02f, 2.74089165e-02f, -2.64263246e-02f, 6.69777952e-03f,
  4.21938039e-02f, -7.32498989e-02f, 7.97108281e-03f, 5.62846884e-02f, 1.78480484e-02f, -4.68416847e-02f, 4.49895896e-02f, -9.20083001e-02f, -3.51393931e-02f, 6.96642473e-02f,
  -1.87021084e-02f, -7.56275877e-02f, 5.44609427e-02f, -6.02182858e-02f, -6.23294786e-02f, -5.68571277e-02f, -1.33318510e-02f, 2.28062980e-02f, -2.69730147e-02f, 7.00213388e-02f,
  -1.36945188e-01f, -4.02449854e-02f, 4.76909690e-02f, -1.34836644e-01f, 3.43241841e-02f, -5.42543381e-02f, -5.58894910e-02f, -7.65045956e-02f, -3.79840210e-02f, -1.27999461e-04f,
  4.85308245e-02f, 2.60923523e-02f, 8.47278535e-02f, 3.63812372e-02f, 1.28700361e-01f, 1.25610322e-01f, 1.18961155e-01f, 3.53129059e-02f, 9.20910984e-02f, 5.94465062e-02f,
  8.84657633e-03f, -4.00753096e-02f, 6.44564116e-03f, -1.20935708e-01f, 6.25390932e-02f, 1.58183724e-02f, -4.14938852e-03f, 1.34682963e-02f, -1.21469907e-01f, -1.07344262e-01f,
  -1.01933748e-01f, -8.18757936e-02f, -3.36226933e-02f, -3.32030281e-03f, 5.94549961e-02f, -6.94667250e-02f, -2.19844710e-02f, 6.08997121e-02f, -1.02298148e-01f, -5.55456132e-02f,
  -7.15607703e-02f, 9.74919647e-02f, -3.37269902e-02f, -8.84341002e-02f, -5.87972440e-02f, -2.09467602e-03f, -5.00005074e-02f, -2.71657724e-02f, 8.70425329e-02f, 4.81570959e-02f,
  1.73961036e-02f, -2.00286694e-02f, 4.84683104e-02f, 1.82440635e-02f, -5.18516824e-02f, 2.46377615e-03f, 3.70640866e-02f, 1.06985290e-02f, -8.01356807e-02f, -8.22885800e-03f,
  -3.28486692e-03f, -2.20019128e-02f, 1.14742793e-01f, 1.94403548e-02f, -1.03035057e-02f, -5.47290854e-02f, 7.40996450e-02f, 8.03775564e-02f, 2.66973022e-03f, -1.60547886e-02f,
  9.14701521e-02f, 3.47647956e-03f, 9.10086110e-02f, 8.18114029e-04f, 5.02618663e-02f, -2.45664585e-02f, -8.44272077e-02f, -7.44553655e-02f, 7.52936676e-02f, 7.05960691e-02f,
  -7.66056851e-02f, 9.88143682e-02f, 1.45414788e-02f, -8.52111205e-02f, 5.84448874e-02f, 2.20245421e-02f, -3.65905613e-02f, 5.15459850e-03f, 5.94092570e-02f, 8.29994306e-02f,
  -6.78321347e-02f, 1.31181562e-02f, -2.08281237e-03f, 3.16070914e-02f, 5.88469729e-02f, 2.74583828e-02f, -7.51782432e-02f, 8.71255621e-02f, -3.58306617e-02f, 1.13526359e-01f,
  -9.74819064e-02f, -1.07312627e-01f, -8.37772489e-02f, -4.26860861e-02f, 7.07282349e-02f, -6.57810047e-02f, -3.18204276e-02f, -4.28964160e-02f, -2.56527532e-02f, -7.22601116e-02f,
  -7.57749602e-02f, -7.16278851e-02f, 2.08530426e-02f, -6.19140230e-02f, 2.90804282e-02f, -6.14789873e-02f, 5.95702678e-02f, -9.87383258e-03f, -7.67071843e-02f, -5.52540869e-02f,
  -3.14861573e-02f, 2.88886465e-02f, -5.70162162e-02f, 3.16570364e-02f, 5.06089181e-02f, 6.32488951e-02f, -5.23482673e-02f, 2.78534107e-02f, 7.62630776e-02f, 2.38675326e-02f,
  -4.00543772e-03f, 1.17311080e-03f, -1.86889376e-02f, 1.63265448e-02f, -3.14335251e-04f, 7.29375631e-02f, -8.86434019e-02f, 5.73854940e-03f, 5.81833487e-03f, 7.90595114e-02f,
  6.44722357e-02f, -6.97846487e-02f, 6.04185797e-02f, -8.61111656e-02f, -8.34353566e-02f, -5.74878342e-02f, -5.10139279e-02f, -7.43001997e-02f, -1.47496268e-01f, -1.20707512e-01f,
  8.47334415e-03f, -5.47450595e-02f, -8.24585333e-02f, 1.86323207e-02f, 1.20652393e-01f, -8.80295690e-03f, 6.60622939e-02f, -6.79896399e-02f, -2.10738648e-02f, 6.09009452e-02f,
  -3.99467908e-02f, -9.93854087e-03f, -2.30811816e-03f, 1.96875352e-02f, -2.80323569e-02f, -9.26065594e-02f, 5.75890131e-02f, 2.55138669e-02f, -4.53918949e-02f, 5.50254807e-02f,
  -3.77389230e-02f, 5.10558710e-02f, -2.21608067e-03f, -8.83126184e-02f, 7.39110857e-02f, -6.97799623e-02f, 6.88015223e-02f, 2.67224275e-02f, -4.86936830e-02f, 1.66631509e-02f,
  -1.26740243e-02f, -8.20185542e-02f, 8.62470865e-02f, 4.06275317e-02f, 8.43940899e-02f, 4.91665378e-02f, 8.84016454e-02f, -4.86216694e-02f, -2.08655241e-04f, 1.32361099e-01f,
  4.73587029e-02f, -6.96441233e-02f, 9.28414688e-02f, -3.70966978e-02f, 6.66803718e-02f, 2.52987165e-02f, 5.92314042e-02f, -4.86016832e-02f, -3.92774381e-02f, 5.89138409e-03f,
  -6.83210231e-03f, -2.62244768e-03f, -6.06892034e-02f, -2.40797512e-02f, -1.60608497e-02f, 1.03768177e-01f, 7.22056115e-03f, 7.86048770e-02f, -4.99514453e-02f, -4.27245488e-03f,
  6.14516847e-02f, 9.78582948e-02f, -4.29741442e-02f, -1.08412802e-02f, 1.18217081e-01f, -4.10598963e-02f, -7.60333091e-02f, -3.65820378e-02f, -6.55289888e-02f, -5.76718263e-02f,
  1.10973485e-01f, -2.15038322e-02f, -3.58530134e-02f, -3.55185987e-03f, 9.37329158e-02f, 5.07437587e-02f, 5.06644696e-02f, 7.58643150e-02f, -4.20356020e-02f, -2.57185306e-02f,
  -3.20377313e-02f, -1.36740822e-02f, 4.32090051e-02f, -4.48423363e-02f, -1.06149130e-01f, -2.26446856e-02f, 5.48729487e-03f, 9.48487129e-03f, 4.94229002e-03f, 1.27264708e-01f,
  1.27217770e-02f, -2.73350757e-02f, 8.54760334e-02f, -1.23895332e-02f, 1.35282648e-03f, -9.76313576e-02f, 7.59979570e-03f, 9.25164670e-02f, 3.24795507e-02f, 6.22268720e-03f,
  -1.08101154e-02f, 3.55133625e-06f, -1.35445058e-01f, -8.74841064e-02f, -1.24440743e-02f, -9.06611383e-02f, -5.95510751e-02f, -4.84800301e-02f, 9.32588950e-02f, -5.29246740e-02f,
  -4.86081131e-02f, 1.00946516e-01f, -2.50837579e-02f, 7.48993531e-02f, -4.39362675e-02f, -1.39899805e-01f, -2.83645727e-02f, 1.50255242e-03f, 7.24158585e-02f, 5.96923307e-02f,
  -5.31566236e-03f, -1.11550782e-02f, 8.77531692e-02f, 1.73718622e-03f, 3.89924906e-02f, 3.82363400e-03f, -1.09319344e-01f, -2.24581026e-02f, -7.05508515e-02f, -7.93382600e-02f,
  -1.08543046e-01f, 5.24647161e-02f, -5.71325840e-03f, 8.19940045e-02f, 5.10066263e-02f, -3.25302333e-02f, 6.26779348e-02f, -4.78385277e-02f, -3.99520136e-02f, 4.47289757e-02f,
  -3.90965529e-02f, -3.29931639e-02f, -2.46331021e-02f, -7.29668438e-02f, 9.21162814e-02f, 5.27204499e-02f, 7.08847269e-02f, 3.98044847e-03f, -9.61062498e-03f, -6.92982867e-04f,
  -2.68237572e-02f, 7.85745755e-02f, -3.15723680e-02f, 1.87611883e-03f, 1.54996840e-02f, -4.20771912e-02f, 9.88100469e-02f, 6.00146465e-02f, -6.88623115e-02f, 3.47283611e-04f,
  4.98318374e-02f, -1.90855823e-02f, -3.89155112e-02f, 8.48633721e-02f, 2.10185139e-03f, -3.82588208e-02f, 1.84989907e-02f, 8.52410272e-02f, -5.10401279e-03f, 6.41068816e-02f,
  -3.75224650e-02f, -8.42020810e-02f, -2.74055433e-02f, 4.54200655e-02f, -1.54284136e-02f, 8.73812707e-04f, 4.08179760e-02f, 7.03881308e-02f, -1.31628150e-02f, -9.52801332e-02f,
  5.04507013e-02f, 6.50823489e-02f, 4.23353091e-02f, -5.10021262e-02f, -2.39711851e-02f, 5.57866273e-03f, -6.46764860e-02f, 7.36561865e-02f, -5.19198366e-02f, -8.17222372e-02f,
  -4.33731154e-02f, 1.00005716e-01f, -4.45048362e-02f, 6.62229285e-02f, -1.87400281e-02f, 7.00420002e-03f, 4.97634187e-02f, 8.05623084e-02f, 4.85165156e-02f, 5.41786663e-03f,
  9.23409611e-02f, -1.59881599e-02f, -8.57669860e-03f, 9.15735308e-03f, -7.91942775e-02f, -4.48939130e-02f, 7.19507597e-03f, 6.87280297e-02f, -3.08301151e-02f, 7.86112398e-02f,
  -9.29687023e-02f, 5.08042760e-02f, 8.02170783e-02f, 8.43933225e-02f, 9.65196565e-02f, -2.41034441e-02f, -3.46661657e-02f, -5.45564741e-02f, -6.78926334e-02f, 8.61208811e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.55751780e-01f, 5.66166863e-02f, 3.21380422e-02f, 8.57569501e-02f, -1.29583878e-02f, 7.27658048e-02f, 4.76244651e-02f, 1.77427098e-01f, 9.80459228e-02f, 1.59627609e-02f,
  1.24935554e-02f, 2.69573163e-02f, 6.48257583e-02f, 1.94213554e-01f, 2.86963098e-02f, -2.96343789e-02f, 1.09000295e-01f, 9.88443568e-02f, 8.44689086e-02f, 7.89437220e-02f,
  -2.21311022e-03f, -7.85344467e-03f, 5.41290790e-02f, 1.56710178e-01f, 1.29936904e-01f, 1.06787086e-01f, 7.38658085e-02f, -2.68244371e-02f, -3.03777866e-02f, 1.73072726e-01f,
  4.49636206e-02f, -4.74178512e-03f, -7.47030005e-02f, 1.04193978e-01f, 4.73835878e-03f, 1.15855522e-01f, 1.87426478e-01f, -2.04067361e-02f, -2.95028836e-02f, -7.67838284e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.76671743e-01f, -1.33725971e-01f, 7.31387362e-02f, 7.44096339e-02f, 5.08538373e-02f, -1.00489371e-01f, 5.25496490e-02f, 7.21624354e-03f, -8.50750506e-03f, 2.53175080e-01f,
  2.81408411e-02f, 1.20863169e-01f, -1.22781716e-01f, -5.41273579e-02f, -2.58713633e-01f, -8.74434561e-02f, 2.41079610e-02f, -6.65128604e-02f, 1.93523057e-02f, 1.33205652e-01f,
  2.06522837e-01f, 2.08171085e-02f, 7.69998655e-02f, 1.89362690e-01f, -2.37627439e-02f, -2.03271031e-01f, -1.25919551e-01f, -9.34934765e-02f, -8.83338526e-02f, 3.75284441e-02f,
  -3.15327272e-02f, -1.61434650e-01f, 1.62913233e-01f, -5.89982830e-02f, 1.27567604e-01f, 1.30304405e-02f, 3.16234156e-02f, -1.49424702e-01f, 9.99232307e-02f, 8.81185755e-02f,
  -1.47444364e-02f, 5.70922829e-02f, 2.82581914e-02f, -1.02766722e-01f, 7.95896165e-03f, 1.50761351e-01f, 7.09481165e-02f, 1.30970811e-03f, 5.40380664e-02f, 9.75575298e-02f,
  -1.56515576e-02f, -1.11379251e-01f, -3.73743214e-02f, 1.81854174e-01f, 1.62504748e-01f, 1.41271174e-01f, 6.92789108e-02f, 2.73505202e-03f, 1.42697617e-01f, -1.01493806e-01f,
  -1.77311316e-01f, 1.03871107e-01f, -6.17409647e-02f, -1.23921208e-01f, -8.24375451e-02f, -6.58424199e-02f, 2.13418186e-01f, -5.72075369e-03f, 1.13778273e-02f, 6.11493411e-03f,
  1.24817237e-01f, 1.47519097e-01f, -9.68578979e-02f, 8.45321640e-02f, 5.95344752e-02f, -1.28151447e-01f, -6.20490080e-03f, 2.40426049e-01f, 6.87008165e-03f, 2.62503415e-01f,
  -1.01775870e-01f, 1.17187686e-01f, 2.96882987e-01f, 2.46944159e-01f, 1.74135759e-01f, -2.99525801e-02f, -2.16735169e-01f, -1.80553317e-01f, 1.50821522e-01f, 2.46760137e-02f,
  -1.07221559e-01f, 1.05859220e-01f, 1.45436332e-01f, 1.79976132e-02f, 1.04611076e-01f, 7.14858919e-02f, -9.93332863e-02f, -1.80622652e-01f, 5.23560382e-02f, -1.04360595e-01f,
  -1.81001991e-01f, -9.74546000e-02f, -1.48115493e-02f, -9.09190252e-02f, -1.31346151e-01f, 5.43722399e-02f, -2.38339044e-02f, 1.72035336e-01f, 1.41509116e-01f, -1.69135541e-01f,
  -1.47507802e-01f, -1.48630202e-01f, -3.50994468e-02f, -4.87110913e-02f, -8.24680272e-03f, -7.32313991e-02f, 1.14517882e-02f, -2.37111956e-01f, 6.49722368e-02f, 1.20949276e-01f,
  1.71925314e-02f, -4.29820977e-02f, -1.14033476e-01f, 5.80178723e-02f, -1.10037066e-01f, 2.22332422e-02f, 8.19192361e-03f, -2.13592127e-03f, -2.40600910e-02f, -2.32154652e-02f,
  -1.50576979e-01f, -1.84170648e-01f, -1.30460411e-01f, 1.26945511e-01f, 1.33357868e-02f, -5.80555610e-02f, 8.41190144e-02f, -1.51618440e-02f, -5.22080474e-02f, 1.98919997e-02f,
  1.81961700e-01f, -8.74807835e-02f, 2.12999105e-01f, 4.38504107e-02f, 9.92766172e-02f, 5.55723384e-02f, 6.78603202e-02f, -1.04939841e-01f, -8.18551332e-03f, -5.50501123e-02f,
  -2.08637059e-01f, 1.22814495e-02f, -1.84768975e-01f, 1.84982315e-01f, -6.69794902e-02f, 6.77934662e-02f, -5.97434081e-02f, -1.53157219e-01f, 5.80604970e-02f, 1.24078214e-01f,
  -1.02812149e-01f, 4.39872481e-02f, -1.25589281e-01f, 1.00456573e-01f, -5.85444160e-02f, 1.46471515e-01f, 1.03659481e-01f, -6.83536800e-03f, 9.08805653e-02f, 2.90015452e-02f,
  -3.66111770e-02f, 1.26244068e-01f, 1.15682542e-01f, 3.49800922e-02f, 6.92455396e-02f, 2.09484119e-02f, -3.47948559e-02f, 1.20890230e-01f, 9.28441435e-02f, 1.09175675e-01f,
  1.29481539e-01f, -1.70720275e-02f, -7.54987672e-02f, 5.94084039e-02f, -2.26917509e-02f, -4.64802533e-02f, -1.32871959e-02f, 1.24222808e-01f, 5.69907576e-02f, 8.71293619e-02f,
  1.06966935e-01f, -8.97376239e-02f, 2.12326348e-02f, -1.57800820e-02f, -2.07190469e-01f, -2.30862439e-01f, -1.15055405e-01f, -9.57256090e-03f, -9.44420844e-02f, -7.72642866e-02f,
  -1.46524951e-01f, -2.04919688e-02f, 8.31799954e-03f, -1.03392512e-01f, 5.88629022e-02f, -7.18125403e-02f, -1.24876395e-01f, 2.32896209e-01f, 1.30910529e-02f, -6.47382811e-02f,
  9.62688774e-02f, -9.70892683e-02f, 1.77079007e-01f, 1.15903698e-01f, -8.97935107e-02f, -8.30209330e-02f, -1.07722282e-01f, 1.61536559e-01f, -1.17970034e-01f, 1.53613046e-01f,
  1.51031658e-01f, -8.33043680e-02f, 6.08505048e-02f, 1.78336382e-01f, -3.80115770e-02f, 7.10358322e-02f, 1.58234581e-01f, 1.03672251e-01f, -6.26685172e-02f, 1.59747615e-01f,
  8.61076638e-02f, 1.35742843e-01f, 1.11856356e-01f, -4.25223596e-02f, 1.12570979e-01f, -2.30279956e-02f, -5.94329787e-03f, -3.88973467e-02f, -5.95925972e-02f, 1.34855270e-01f,
  -2.02374205e-01f, 1.63728893e-01f, 1.59403775e-03f, -6.46993592e-02f, 1.72712535e-01f, -3.09297085e-01f, -1.61274567e-01f, 8.32880288e-02f, 3.16843973e-03f, 1.52207969e-03f,
  1.42895043e-01f, 2.22105216e-02f, 8.04747939e-02f, -2.72158179e-02f, -1.33196162e-02f, 1.09423630e-01f, 1.30059168e-01f, -6.50366768e-02f, -1.82220995e-01f, -1.63098976e-01f,
  3.98436263e-02f, 5.36241271e-02f, 6.96235672e-02f, -5.41030951e-02f, 3.53281796e-02f, -2.90717222e-02f, 1.21480487e-01f, -1.28442040e-02f, -5.95835736e-03f, -2.08758324e-01f,
  -1.02934897e-01f, -4.19737734e-02f, 2.11284474e-01f, -4.43877906e-01f, -3.98820415e-02f, -3.02126914e-01f, -2.34194100e-03f, 1.99895978e-01f, 7.45433047e-02f, 1.89631626e-01f,
  -9.23392996e-02f, 4.88200001e-02f, 3.41569707e-02f, -9.88047346e-02f, -4.96913865e-03f, -1.00992158e-01f, 1.68739095e-01f, 6.19141422e-02f, -1.00064136e-01f, 1.34785041e-01f,
  1.75780594e-01f, -2.73485947e-02f, 6.54967278e-02f, 2.59956390e-01f, 2.12002378e-02f, -1.08615555e-01f, 1.12804070e-01f, -3.17768380e-02f, -3.59531753e-02f, 2.39162028e-01f,
  -5.00886552e-02f, -4.51264996e-03f, -1.47969127e-02f, 2.72985641e-02f, -2.23880485e-01f, 1.79251492e-01f, -1.67997077e-01f, 1.54147357e-01f, 1.84576601e-01f, -2.07236275e-01f,
  1.42773846e-02f, 1.55661225e-01f, 5.13979271e-02f, 9.81477723e-02f, 1.83680013e-01f, 6.25146031e-02f, 1.25194028e-01f, -6.84631988e-02f, -5.44589348e-02f, -8.04468393e-02f,
  9.84638855e-02f, 1.35030299e-02f, -1.31906897e-01f, 1.11712396e-01f, 6.46239668e-02f, 1.34156987e-01f, 1.35352137e-02f, -9.65827703e-02f, 7.55696297e-02f, -3.29916887e-02f,
  1.00629941e-01f, 5.96567243e-02f, 1.57170538e-02f, -1.69990972e-01f, -9.23395380e-02f, 9.98955965e-03f, 1.18741587e-01f, -5.74490577e-02f, -9.58485901e-03f, -3.10768753e-01f,
  1.73471928e-01f, 1.12313509e-01f, -7.54275993e-02f, 1.23333275e-01f, -1.73732832e-01f, -3.78932692e-02f, -8.02790299e-02f, 3.53746377e-02f, 6.53316081e-02f, 5.67654893e-02f,
  -5.19351438e-02f, 2.03059047e-01f, -9.56709012e-02f, 1.47470355e-01f, -1.27904773e-01f, -1.44542351e-01f, 9.86839458e-03f, 1.15937673e-01f, 1.20543182e-01f, 2.27070153e-02f,
  -4.58272621e-02f, 1.33968577e-01f, -8.43106508e-02f, 6.23407885e-02f, -8.59173108e-03f, -1.92057267e-02f, 6.77897185e-02f, 1.19859405e-01f, -2.07038507e-01f, 2.19930280e-02f,
  6.77274987e-02f, -5.64131588e-02f, 1.54839158e-01f, -2.79606074e-01f, -1.05335779e-01f, -1.26909867e-01f, 1.25599191e-01f, 1.21608190e-01f, 1.48131296e-01f, 6.95275739e-02f,
  5.79438433e-02f, -1.04595803e-01f, -9.35575459e-03f, -3.51548544e-03f, 1.34709120e-01f, -5.54746054e-02f, -1.61035821e-01f, -3.45034339e-02f, 4.92984354e-02f, 5.22621199e-02f,
  1.45380378e-01f, 1.26910983e-02f, 1.26028508e-01f, 4.27731760e-02f, 1.92006171e-01f, 1.79399699e-01f, -2.75511593e-01f, -2.34400287e-01f, 2.57935017e-01f, -1.62737444e-01f,
  -4.63378094e-02f, -2.95077592e-01f, -3.56001318e-01f, -9.24302340e-02f, -1.87448755e-01f, 1.83690004e-02f, 2.50381917e-01f, 8.37849006e-02f, -2.04808801e-01f, 1.89134538e-01f,
  1.98923737e-01f, -2.21890569e-01f, -1.51055334e-02f, -1.21808685e-01f, -5.47810607e-02f, -1.47559494e-02f, 1.31823242e-01f, -1.24269329e-01f, 1.95918959e-02f, 1.45873457e-01f,
  6.24936856e-02f, -1.89466670e-01f, -2.19762251e-02f, 5.60353547e-02f, 1.14264384e-01f, 1.10739395e-01f, 9.46085751e-02f, -1.26522377e-01f, -2.19757393e-01f, 1.00717068e-01f,
  -2.39360631e-01f, 1.38122989e-02f, 9.37870443e-02f, -5.09641655e-02f, 3.44115426e-03f, 2.05871481e-02f, -8.52464959e-02f, 2.02162966e-01f, -9.18677356e-03f, -2.59755492e-01f,
  -1.28582001e-01f, -1.90119803e-01f, 1.23436458e-01f, 1.56162903e-01f, 1.30384013e-01f, -1.02600776e-01f, -8.26223269e-02f, 1.04960203e-01f, 3.23067792e-02f, -4.73445095e-02f,
  -4.09290381e-03f, 1.18381016e-01f, 1.65087301e-02f, 1.21800348e-01f, -3.55125219e-02f, -1.10403642e-01f, 6.17323332e-02f, -7.79725239e-02f, -6.07127622e-02f, -9.39637423e-02f,
  2.85971224e-01f, -6.79258257e-02f, 1.67950630e-01f, -1.50128692e-01f, 6.12264313e-02f, 3.59350055e-01f, 1.02633543e-01f, 8.27296078e-02f, -1.31995842e-01f, -6.25302689e-03f,
  -1.29547581e-01f, -3.44600439e-01f, -3.55676636e-02f, -9.55716614e-03f, -9.82566923e-02f, -1.23722118e-03f, -6.42873207e-03f, -2.51023173e-02f, -4.41126563e-02f, 7.01313317e-02f,
  -5.36035113e-02f, 2.04869248e-02f, -5.41663263e-03f, 1.31875917e-01f, -1.48191666e-02f, 5.10633625e-02f, 1.89921092e-02f, -5.47921956e-02f, 1.23851880e-01f, 7.92625453e-03f,
  7.97994137e-02f, 6.46590814e-02f, -7.20500574e-03f, 9.89352465e-02f, -5.96419275e-02f, 5.17071337e-02f, 1.56773895e-01f, -3.71653065e-02f, 1.46830112e-01f, -5.49470559e-02f,
  -2.93286145e-02f, 1.85601730e-02f, -1.68501556e-01f, -1.64715812e-01f, 6.42576739e-02f, -1.52958497e-01f, -1.46565601e-01f, -1.42147213e-01f, -8.75761360e-02f, 1.28002211e-01f,
  1.10040240e-01f, -5.58707826e-02f, -9.29052159e-02f, -9.32446122e-03f, -6.43234923e-02f, -5.39390091e-03f, 3.85816023e-02f, 2.34992318e-02f, -5.42101450e-02f, 6.47362173e-02f,
  -2.83209868e-02f, -7.12776855e-02f, 7.34868422e-02f, 2.53145024e-02f, 7.48634711e-02f, -3.44702750e-01f, 1.90147907e-01f, -9.97531638e-02f, 1.02513537e-01f, -2.61625260e-01f,
  -9.18037593e-02f, -2.24875242e-01f, -2.19846964e-01f, 2.31070638e-01f, -1.14946805e-01f, -1.11542977e-01f, 4.02314141e-02f, 1.05721824e-01f, 5.16599230e-02f, -5.53235188e-02f,
  -1.22829497e-01f, -1.31452814e-01f, -1.11575611e-01f, -4.28200886e-03f, -6.76607131e-04f, -8.36884975e-02f, 6.62151650e-02f, 2.95233633e-02f, 1.98495341e-03f, -4.71994616e-02f,
  -3.21681313e-02f, 1.61001936e-01f, 1.28418431e-01f, 5.92269609e-03f, 3.47189046e-02f, 1.36870638e-01f, 8.81687999e-02f, -6.36977404e-02f, -1.33090913e-01f, -7.71691836e-03f,
  -1.78232014e-01f, 1.72605366e-02f, 4.77232821e-02f, 1.47268951e-01f, 2.39756986e-01f, -1.49121433e-01f, 1.20819628e-01f, -9.06759948e-02f, -8.01360682e-02f, -3.86898704e-02f,
  1.28879901e-02f, 8.71793255e-02f, 7.93444142e-02f, -3.52855213e-02f, 9.73746404e-02f, -1.77366715e-02f, -5.21823168e-02f, -1.72952205e-01f, -2.22398430e-01f, -5.00950515e-02f,
  -3.25612649e-02f, -1.64785594e-01f, -6.21362440e-02f, -1.21786073e-01f, 1.36399835e-01f, 1.21638522e-01f, -3.55872288e-02f, -1.05236404e-01f, 1.80386841e-01f, -4.43271808e-02f,
  -6.55672327e-02f, -2.19940275e-01f, 7.76502714e-02f, 7.52464607e-02f, -3.10600162e-01f, 3.38495336e-02f, 1.24613084e-01f, -1.28700405e-01f, 1.79600045e-01f, 1.07981175e-01f,
  -2.61491627e-01f, -2.52200011e-02f, 2.43558615e-01f, 1.05447032e-01f, -5.63185588e-02f, 1.33494288e-01f, -8.83611515e-02f, -1.24134056e-01f, -7.44649693e-02f, 7.90465996e-02f,
  1.12109184e-01f, 1.56271979e-01f, 7.09583387e-02f, 3.62572782e-02f, -3.98264937e-02f, 5.52166663e-02f, 2.52743632e-01f, 8.26664269e-02f, 2.11513296e-01f, -1.20938748e-01f,
  -7.79811367e-02f, 4.15193811e-02f, -5.59443273e-02f, 8.91034082e-02f, 5.36172949e-02f, -7.00047463e-02f, 5.41933887e-02f, 6.36282936e-02f, -1.24863766e-01f, 7.40476791e-03f,
  1.30300686e-01f, -3.90920267e-02f, -1.09034315e-01f, -2.92194545e-01f, 8.13802332e-02f, 1.22972861e-01f, 2.25081578e-01f, 1.34273916e-01f, 3.86180952e-02f, -2.61649471e-02f,
  -1.60883352e-01f, 3.00169783e-03f, -9.41946823e-03f, -6.76602200e-02f, 1.02296226e-01f, 1.17063478e-01f, 9.25235152e-02f, -1.39490217e-01f, -6.80309162e-02f, -4.68316972e-02f,
  -1.26424655e-01f, -1.56856000e-01f, 2.82206416e-01f, 1.68991089e-02f, 1.78562209e-01f, 1.16353661e-01f, 9.57636088e-02f, 4.84527312e-02f, 2.36134529e-01f, 3.99643369e-02f,
  -9.36611071e-02f, 1.17929913e-01f, -2.36489534e-01f, -2.31456488e-01f, -1.63857535e-01f, 2.07646638e-01f, -1.39529869e-01f, 8.70282203e-02f, 3.42703350e-02f, -9.29008573e-02f,
  4.41645086e-02f, 8.00605416e-02f, -1.37179330e-01f, 9.65131223e-02f, -5.91739230e-02f, 4.26695086e-02f, -7.58428918e-03f, 7.36956075e-02f, -1.05401643e-01f, 1.21253751e-01f,
  1.56429052e-01f, 2.45669395e-01f, 9.63584334e-02f, 7.84151107e-02f, 1.49350882e-01f, -1.30973592e-01f, -5.38590960e-02f, 1.04711227e-01f, 9.80404094e-02f, 1.39654815e-01f,
  -5.30642271e-03f, -1.05325803e-01f, 2.61674881e-01f, -1.84299946e-02f, 9.86803845e-02f, 6.54151589e-02f, 9.33757871e-02f, -7.08594397e-02f, -1.32528558e-01f, -1.15604132e-01f,
  1.66715771e-01f, 4.83104512e-02f, -1.71760004e-02f, -3.79691571e-02f, 1.71400979e-01f, -1.21169433e-01f, 9.95832160e-02f, -1.33515313e-01f, -3.22516523e-02f, -8.43525305e-03f,
  -2.04631999e-01f, -1.80264682e-01f, -2.81031020e-02f, 4.03583124e-02f, -1.74329937e-01f, -2.31630683e-01f, 2.24470422e-01f, 3.28281730e-01f, -2.35392302e-01f, 1.95558563e-01f,
  -6.83798194e-02f, 2.68106401e-01f, 9.62556750e-02f, 3.80121768e-01f, 6.30253181e-02f, -6.08920008e-02f, -4.35792059e-02f, 1.27741024e-01f, 1.96202457e-01f, -2.94807162e-02f,
  -1.77258909e-01f, -7.37366900e-02f, 1.53239265e-01f, -2.02043988e-02f, 4.76779602e-02f, -1.19416565e-01f, -8.81629437e-02f, 9.63610969e-03f, 1.23460516e-01f, -8.64527747e-02f,
  -2.97646932e-02f, -9.06951949e-02f, -1.02388412e-01f, 1.19083248e-01f, -2.25780174e-01f, 3.33573744e-02f, -2.01450452e-01f, -1.39449894e-01f, -4.38822396e-02f, 9.27070603e-02f,
  -9.47442055e-02f, 8.21865574e-02f, 1.80955589e-01f, -1.28374726e-01f, -1.08706139e-01f, 1.24384396e-01f, -4.73093018e-02f, 2.09184349e-01f, 9.20926556e-02f, 1.85266107e-01f,
  7.34735578e-02f, -9.35681015e-02f, -2.09517404e-01f, -2.75754184e-01f, -9.51372460e-02f, 1.12333700e-01f, -1.39638875e-02f, -4.64053079e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  8.39367807e-02f, 1.79658532e-01f, 1.65725574e-01f, 1.38211489e-01f, 1.91496670e-01f, 5.87040447e-02f, 9.03086066e-02f, 1.26960874e-01f, 2.49143988e-01f, 5.52650951e-02f,
  -4.06184234e-02f, -8.72437730e-02f, 1.40128016e-01f, -2.00646184e-02f, -4.23693322e-02f, -3.19931433e-02f, 1.13071837e-01f, 3.80749434e-01f, -2.04103261e-01f, 1.72064468e-01f,
  -1.15061730e-01f, -1.75286934e-01f, -2.90673197e-04f, -7.02673793e-02f, 8.37844610e-02f, 2.88566686e-02f, -2.47825012e-02f, -1.97167415e-02f, 5.79442792e-02f, 1.59373596e-01f,
  -1.68489635e-01f, 2.22507250e-02f, 4.16454524e-02f, -3.89516843e-03f, 6.42122701e-02f, 1.59001037e-01f, -1.13991298e-01f, -1.47899538e-01f, -9.78070721e-02f, 9.91420522e-02f,
  3.76355015e-02f, 1.76834594e-02f, 1.47173740e-02f, -3.49313356e-02f, -1.53809443e-01f, 1.34573758e-01f, 7.09316880e-02f, -4.95623164e-02f, 4.60969098e-02f, -6.72060018e-03f,
  -7.91460723e-02f, -1.49706095e-01f, -1.47370815e-01f, 2.16618463e-01f, -1.59256812e-02f, -4.82205711e-02f, -7.28025883e-02f, -1.02176994e-01f, -8.49939138e-02f, 5.06725423e-02f,
  9.40405205e-02f, 1.58495486e-01f, 9.98830423e-02f, 1.46135148e-02f, 7.16955513e-02f, 1.89910918e-01f, 3.34727741e-03f, 1.74849764e-01f, 1.33544579e-01f, 1.69703811e-02f,
  -3.68399285e-02f, 3.32426839e-02f, 1.03439786e-01f, -1.02714794e-02f, 1.52969167e-01f, 1.23160571e-01f, -1.68898985e-01f, 4.29679203e-05f, -5.47266379e-02f, -1.09949157e-01f,
  -6.78578839e-02f, -5.88171929e-02f, -3.24350074e-02f, 1.81488290e-01f, -1.25140905e-01f, 8.42717439e-02f, 4.68727527e-03f, 1.71369359e-01f, 9.34560224e-02f, 1.20962031e-01f,
  3.77032496e-02f, -1.15980044e-01f, 3.56863509e-03f, 1.21242024e-01f, -1.73278595e-03f, -1.45644829e-01f, -1.38819907e-02f, -6.35885820e-02f, 1.28171695e-02f, 1.27293961e-02f,
  3.42567749e-02f, -7.50221759e-02f, -4.53759171e-03f, 5.28135709e-02f, -2.90413797e-02f, -9.84954461e-02f, -1.13338880e-01f, -1.28262460e-01f, 9.64405611e-02f, 7.54516125e-02f,
  2.10044198e-02f, -8.20839778e-02f, -3.45617486e-03f, -9.89885330e-02f, -4.89171743e-02f, 1.34194680e-02f, 1.03376143e-01f, 2.06608206e-01f, -7.85813574e-03f, 6.64011762e-02f,
  2.96779145e-02f, 2.10644588e-01f, 1.16911173e-01f, -1.35107916e-02f, 5.22536284e-04f, 1.20132454e-01f, 7.70990271e-03f, -9.87332612e-02f, 1.31941915e-01f, 1.81608215e-01f,
  1.63861588e-01f, -6.85698763e-02f, 4.43604290e-02f, 4.13544755e-03f, 1.93314835e-01f, 1.43186778e-01f, -1.86534859e-02f, 2.39390861e-02f, -6.27820205e-04f, 1.69662461e-01f,
  -1.43725395e-01f, 1.45563632e-01f, -9.37449560e-02f, 1.03741750e-01f, -9.69012454e-03f, -7.93722868e-02f, 1.95495367e-01f, 1.18702158e-01f, 2.24704668e-01f, -3.06926202e-02f,
  6.86425343e-02f, 1.06910728e-01f, -4.91904803e-02f, -4.69948202e-02f, -5.88025562e-02f, -9.10601839e-02f, 8.02795067e-02f, -5.38515151e-02f, -1.34456875e-02f, 7.00200871e-02f,
  1.33006275e-01f, -1.11136146e-01f, 2.40075402e-02f, 6.73931465e-02f, -1.35971323e-01f, 1.01010427e-01f, -4.56718989e-02f, -4.46034484e-02f, -9.37084705e-02f, 2.92865988e-02f,
  -1.17086433e-01f, 3.90594900e-02f, 1.50436163e-01f, 9.03399289e-02f, 1.10232495e-01f, 1.85477138e-02f, -7.87287056e-02f, -7.66066695e-03f, -1.17570631e-01f, 7.64028132e-02f,
  -5.25672622e-02f, -7.16224462e-02f, 8.18916038e-03f, -1.65944430e-03f, -4.20759395e-02f, 5.60827479e-02f, 1.62051078e-02f, 1.42277569e-01f, -3.59111466e-02f, -1.83225353e-03f,
  8.55480600e-03f, -1.08709253e-01f, 7.98344016e-02f, -3.33690494e-02f, 5.43328114e-02f, -5.18094152e-02f, -1.05941363e-01f, 1.31163940e-01f, 7.85805434e-02f, 8.15100223e-03f,
  -4.09691632e-02f, 1.69520755e-03f, 1.09717129e-02f, -5.09144329e-02f, 9.01891142e-02f, 9.65512767e-02f, -1.20419852e-01f, -7.24462420e-02f, -3.82313170e-02f, -7.04043582e-02f,
  6.55664206e-02f, -1.84076615e-02f, -1.10566966e-01f, 6.12820759e-02f, 1.41328415e-02f, 1.12127125e-01f, 2.90827397e-02f, 2.70524877e-03f, 1.06525220e-01f, -9.06763878e-03f,
  3.98056805e-02f, -9.18761641e-02f, 1.08502358e-01f, -5.92384674e-02f, 1.21076945e-02f, 1.08676441e-01f, 9.64298099e-02f, 4.42265011e-02f, 1.02454893e-01f, 1.23047300e-01f,
  -5.07116690e-02f, 5.62612265e-02f, -5.53473607e-02f, -2.66860123e-03f, 5.07342368e-02f, -6.08988851e-02f, 7.85557404e-02f, 3.96429710e-02f, 1.20713644e-01f, -1.62796653e-03f,
  1.19903184e-01f, -8.76772553e-02f, 8.05339813e-02f, 4.26424146e-02f, -5.99099509e-02f, -1.81990098e-02f, 5.69536127e-02f, -1.49555385e-01f, -1.66041609e-02f, 1.27848729e-01f,
  3.79930921e-02f, -3.91291864e-02f, -4.93248999e-02f, 1.90275013e-02f, -9.40245986e-02f, -1.79540571e-02f, 1.79810718e-01f, 1.27334837e-02f, 1.94807380e-01f, 7.99035728e-02f,
  5.16281165e-02f, -1.11437164e-01f, 2.31665242e-02f, 1.39037117e-01f, 9.99632180e-02f, -1.31747136e-02f, 5.19845448e-02f, 1.30904511e-01f, -3.36665884e-02f, 9.74235300e-04f,
  -6.92354590e-02f, -1.69589624e-01f, -8.26876312e-02f, 1.51007652e-01f, 1.76989958e-01f, -6.02141730e-02f, 1.26305344e-02f, -3.89509797e-02f, -1.70845225e-01f, -1.60453528e-01f,
  2.55116373e-01f, 6.32188395e-02f, -1.05221331e-01f, 5.03931642e-02f, 3.04485336e-02f, -4.27658632e-02f, -1.24262437e-01f, -1.60734504e-01f, 1.41548589e-01f, -1.20532632e-01f,
  -7.98515305e-02f, 4.76813614e-02f, 8.06821883e-02f, -1.08159736e-01f, -9.75781493e-03f, 3.91055010e-02f, 8.02325830e-02f, -6.67985305e-02f, -1.17301397e-01f, -1.23180479e-01f,
  -4.83432822e-02f, 1.26143899e-02f, 1.14633337e-01f, 7.55514205e-02f, -7.50300381e-03f, -5.03078289e-02f, 3.59166898e-02f, -3.51201519e-02f, -1.43804951e-02f, 1.02421045e-01f,
  6.11920096e-02f, 3.09890620e-02f, -1.02037229e-01f, 5.97699806e-02f, -2.13642698e-02f, 8.38190466e-02f, -7.90803581e-02f, 8.04251507e-02f, -5.67500889e-02f, -5.90297356e-02f,
  -5.75684197e-02f, 6.59676194e-02f, 2.79350966e-01f, 2.07909986e-01f, 1.26710162e-01f, 9.63556170e-02f, 7.03837210e-03f, 2.84679115e-01f, 1.63101852e-01f, 1.07802391e-01f,
  2.08953097e-01f, 2.31754035e-01f, -1.68155447e-01f, -1.90991119e-01f, 2.79709041e-01f, -1.05188817e-01f, -2.33047634e-01f, 6.34796619e-02f, 1.43067362e-02f, 2.35957280e-03f,
  -2.98112929e-01f, 1.38867483e-01f, 1.02158617e-02f, -1.66046873e-01f, 4.00472172e-02f, 1.67358443e-01f, 1.02735236e-01f, 6.25115111e-02f, -8.36375654e-02f, -1.69415902e-02f,
  -7.13070258e-02f, 2.98529137e-02f, -5.88347279e-02f, -1.38459817e-01f, -1.39077932e-01f, 6.43528476e-02f, 1.35910675e-01f, -1.60941750e-01f, 1.29423708e-01f, 8.53403658e-02f,
  -1.03395805e-01f, -5.57542779e-02f, -8.76141414e-02f, -1.17391326e-01f, 5.34095168e-02f, 9.29956362e-02f, -1.24058239e-01f, 6.72031660e-03f, 6.69783279e-02f, -1.13877192e-01f,
  -1.28813863e-01f, 9.58758071e-02f, 4.48842347e-02f, -1.17582962e-01f, -6.23193607e-02f, -5.39482979e-04f, -2.21720263e-02f, 1.73821136e-01f, 9.15845707e-02f, 1.17868170e-01f,
  4.25297916e-02f, -8.81079584e-02f, -1.13748796e-01f, 8.16043764e-02f, 8.32020715e-02f, -2.05533728e-02f, -7.71394148e-02f, 2.40104944e-02f, -6.02899771e-03f, 1.09944910e-01f,
  1.12875953e-01f, 8.22282061e-02f, 1.09375447e-01f, -1.18205614e-01f, 3.96008044e-03f, -4.79831062e-02f, -9.02128816e-02f, -1.35757327e-01f, -1.25041261e-01f, -4.45567258e-03f,
  -5.88840945e-03f, -9.05581862e-02f, 2.21172526e-01f, -1.90417632e-01f, -9.55431014e-02f, 1.70543477e-01f, -1.63892955e-01f, -1.41118050e-01f, 1.90163195e-01f, 1.19219549e-01f,
  -8.15903023e-02f, -9.80139300e-02f, 1.13776162e-01f, 7.68193081e-02f, -1.26413256e-01f, -3.50916907e-02f, -1.98809225e-02f, 1.79962873e-01f, -6.33626953e-02f, -3.63242403e-02f,
  1.40240565e-01f, 7.74971917e-02f, 1.68012887e-01f, -6.12626486e-02f, 6.05357140e-02f, 1.25277728e-01f, 1.93711240e-02f, 1.35907397e-01f, -8.17806199e-02f, 4.48999228e-03f,
  -8.84555206e-02f, 4.84815426e-02f, -1.06446214e-01f, 1.14260271e-01f, -5.32584377e-02f, 3.55310999e-02f, 1.00906558e-01f, -1.25530764e-01f, 4.42292280e-02f, 5.13331761e-05f,
  -1.15050219e-01f, 2.00378925e-01f, -1.41589399e-02f, 1.07622214e-01f, -2.89621241e-02f, 1.10996187e-01f, 1.04843706e-01f, 1.38652080e-03f, -1.43420115e-01f, -4.29113917e-02f,
  -8.79056845e-03f, -1.58279479e-01f, -3.44847701e-02f, 6.75236341e-04f, -1.04650758e-01f, -6.25922605e-02f, -8.64785761e-02f, -9.38458666e-02f, -1.22986779e-01f, -1.52000394e-02f,
  5.11061437e-02f, 1.64747871e-02f, -9.35053080e-02f, 5.41860014e-02f, 1.22391442e-02f, -9.83488634e-02f, -6.81420043e-02f, -3.27251814e-02f, 3.52540910e-02f, 1.36141041e-02f,
  -4.66103852e-02f, 1.20223686e-01f, -2.78621279e-02f, 1.14696488e-01f, -6.73132166e-02f, 5.68413474e-02f, -9.08244550e-02f, -7.09692901e-03f, 1.23557806e-01f, -6.89748749e-02f,
  4.57866266e-02f, 1.05507366e-01f, -1.20721804e-02f, 8.15366395e-03f, -9.35646333e-03f, 2.75268685e-02f, 8.20545256e-02f, 6.87625706e-02f, 1.41413342e-02f, -6.47323877e-02f,
  6.65343627e-02f, -1.18294738e-01f, 2.56431624e-02f, -3.77989188e-02f, 4.34639417e-02f, -6.82466030e-02f, 1.48541495e-01f, -8.39657187e-02f, 1.04802214e-01f, 7.37748966e-02f,
  -6.71210662e-02f, 7.98759833e-02f, 6.25093356e-02f, 1.80357158e-01f, -1.12088203e-01f, 1.16839416e-01f, -3.71895395e-02f, 1.37330398e-01f, -7.03809410e-02f, -6.54718950e-02f,
  7.61372894e-02f, -6.73128963e-02f, 1.60896890e-02f, 2.23499537e-01f, 1.25492841e-01f, 1.63384899e-01f, 5.46107069e-02f, -3.33409421e-02f, 2.31510207e-01f, -7.65447691e-02f,
  1.49450019e-01f, 8.23515058e-02f, 2.26102412e-01f, 1.36081845e-01f, 2.70879298e-01f, -6.05793893e-02f, 3.35623443e-01f, -1.27402738e-01f, 5.14128879e-02f, 2.76245505e-01f,
  7.57213756e-02f, -2.56833085e-03f, 6.12064935e-02f, -9.11602452e-02f, -2.53802866e-01f, -2.89904147e-01f, -7.27340132e-02f, -2.82096844e-02f, 1.16110615e-01f, -4.92677763e-02f,
  -8.61027092e-02f, 6.13637492e-02f, -1.06684111e-01f, 2.87672937e-01f, -5.00403605e-02f, -1.38763532e-01f, -2.17051238e-01f, -4.34811227e-02f, -7.38102198e-02f, 1.70759764e-02f,
  -5.13400808e-02f, 5.55177592e-03f, 2.18211371e-03f, 1.86991274e-01f, 8.46961811e-02f, 2.02029198e-01f, 9.10666883e-02f, 8.27242956e-02f, 1.37710661e-01f, 6.37375414e-02f,
  1.40327856e-01f, -4.73265126e-02f, 1.29491419e-01f, -1.26598608e-02f, -9.03148800e-02f, 2.97661245e-01f, -2.81073414e-02f, 4.33573127e-02f, -1.19808584e-01f, -1.45256743e-01f,
  -5.81020303e-02f, 1.30695462e-01f, 2.79304478e-03f, 1.70877546e-01f, 1.32320821e-01f, -7.28672519e-02f, -3.87636609e-02f, 1.21892998e-02f, 1.85385197e-02f, -3.16941626e-02f,
  1.24032453e-01f, 1.16852745e-01f, 1.68137357e-01f, -6.12736605e-02f, -2.10154094e-02f, 1.12995371e-01f, 1.41703546e-01f, -1.83939543e-02f, 2.76189856e-02f, 2.15011150e-01f,
  -1.51865318e-01f, 9.52866599e-02f, -6.06899597e-02f, 6.14867583e-02f, 1.79477453e-01f, 2.13064745e-01f, 1.10342689e-01f, 1.06029950e-01f, -8.88542458e-02f, 1.44575695e-02f,
  -8.85695394e-04f, -1.06027961e-01f, -1.11873269e-01f, 6.96278438e-02f, 4.54116575e-02f, -5.82149103e-02f, 1.11038364e-01f, 1.65610269e-01f, -1.06522460e-02f, -3.41566354e-02f,
  1.60067409e-01f, 3.21814902e-02f, -1.12735078e-01f, 5.78958765e-02f, -1.26520380e-01f, -1.57490909e-01f, -1.58262476e-01f, 2.82097608e-02f, -1.08413808e-01f, 1.52367195e-02f,
  5.70139214e-02f, -1.15641557e-01f, -3.99063192e-02f, 2.44355705e-02f, -9.48647633e-02f, -5.28358892e-02f, 9.86766890e-02f, 6.98391572e-02f, -8.22499394e-02f, 4.49923053e-02f,
  9.08368751e-02f, 1.72838360e-01f, -7.77094886e-02f, -8.32149014e-02f, 4.21634018e-02f, -1.68396998e-02f, -2.05849074e-02f, -6.97467253e-02f, -2.14235932e-02f, -4.22980636e-02f,
  5.76903969e-02f, -6.07401393e-02f, -2.45070625e-02f, 3.13787721e-02f, -4.28175367e-02f, 1.33929461e-01f, -7.42802620e-02f, -7.58128837e-02f, -9.23919603e-02f, -6.90551847e-02f,
  9.72677022e-03f, -1.62164066e-02f, -3.23026031e-02f, 1.08263440e-01f, -1.44127775e-02f, -9.90012363e-02f, 1.22241035e-01f, -1.14005916e-02f, 9.24549475e-02f, -3.96856479e-03f,
  1.11716576e-01f, -4.78468835e-02f, 3.34697589e-02f, 9.25819352e-02f, -9.89094004e-02f, 8.16624984e-02f, 5.47185689e-02f, -1.47187440e-02f, 4.04492244e-02f, -2.70824190e-02f,
  1.27401501e-02f, 1.31149620e-01f, -1.12471795e-02f, -1.13534041e-01f, 7.44098751e-03f, 8.02867487e-02f, -1.05402619e-01f, -4.05459926e-02f, -9.15356353e-02f, -5.17275967e-02f,
  -1.57663529e-03f, 6.54242337e-02f, -8.18979666e-02f, 1.41996190e-01f, 9.38693434e-02f, -9.60964411e-02f, 6.86166212e-02f, 3.24124694e-02f, 3.80348265e-02f, -6.06991537e-02f,
  1.07965223e-01f, 1.02146760e-01f, 9.33051296e-03f, -4.56070416e-02f, -4.65601422e-02f, -9.01728496e-02f, -1.00518167e-02f, -9.94390771e-02f, -6.10362180e-02f, 2.18802784e-02f,
  4.28578369e-02f, 1.86870731e-02f, -1.34784058e-02f, -1.02832250e-01f, 1.05372705e-01f, -7.39644095e-02f, -1.51797727e-01f, 3.64966504e-02f, 5.98014966e-02f, -7.64143616e-02f,
  7.88843259e-02f, -9.82252061e-02f, 6.95634931e-02f, 2.37189755e-02f, 1.23828031e-01f, 1.56247407e-01f, 2.88041718e-02f, -1.85819224e-01f, 5.18643484e-02f, -7.32509866e-02f,
  8.66349190e-02f, -2.37202033e-01f, -1.08249888e-01f, -1.66473135e-01f, 5.43892235e-02f, 9.28729773e-02f, 3.59027497e-02f, 1.38566926e-01f, -1.72214985e-01f, 1.36341661e-01f,
  1.56039819e-01f, 6.78914487e-02f, 1.21404134e-01f, -4.30165939e-02f, 2.35715229e-02f, -8.03596154e-03f, -1.06094489e-02f, 1.49390399e-01f, -4.82043847e-02f, 1.47179842e-01f,
  -2.27807835e-02f, 2.99181826e-02f, 6.69590756e-02f, 7.75411502e-02f, 1.06706828e-01f, 5.79337217e-02f, 1.69204623e-01f, -8.28674287e-02f, 1.00158609e-01f, -2.23155301e-02f,
  9.32424068e-02f, 6.64247423e-02f, 4.54724841e-02f, 1.45855024e-01f, -4.65807505e-02f, 7.85920471e-02f, 5.38805947e-02f, -9.74130929e-02f, 1.54003024e-01f, -6.57333881e-02f,
  -8.22640881e-02f, 8.65001604e-02f, -3.00898328e-02f, -4.16750386e-02f, 1.19110428e-01f, -2.20099334e-02f, 1.38623640e-01f, -4.86519886e-03f, 1.33016482e-01f, -4.78967912e-02f,
  -9.52182859e-02f, 1.26843899e-02f, 5.00024529e-03f, -1.07276157e-01f, 1.58295825e-01f, 1.10075697e-01f, 7.10935146e-02f, 1.66650601e-02f, -1.91163924e-02f, 1.37258857e-01f,
  3.50741819e-02f, 3.40028331e-02f, -7.15315416e-02f, 7.92824477e-02f, -1.95284318e-02f, -2.94076763e-02f, 1.99210882e-01f, 3.63147929e-02f, -2.92054266e-02f, 1.37983859e-01f,
  2.44640885e-03f, 7.09719136e-02f, 2.96594370e-02f, -1.10153958e-01f, 3.89349088e-02f, -4.47692610e-02f, 6.13770522e-02f, 1.18283205e-01f, 9.35792401e-02f, 1.93492815e-01f,
  4.82720137e-02f, -5.24628498e-02f, 5.51811159e-02f, -7.24544823e-02f, 8.11870676e-03f, 1.88718215e-02f, -2.52139810e-02f, -1.14552647e-01f, 5.30454284e-03f, 1.02046810e-01f,
  -1.01057157e-01f, -8.05568695e-02f, 3.77483107e-02f, 5.66648096e-02f, -5.82108796e-02f, -9.83136371e-02f, 3.84637453e-02f, -9.15351883e-02f, 7.59543553e-02f, -1.98289361e-02f,
  5.34684621e-02f, 1.45021319e-01f, 1.08347274e-01f, 9.84494612e-02f, -1.16647646e-01f, -1.57110840e-01f, -1.66804884e-02f, -4.13977616e-02f, 1.02266595e-01f, 5.13117649e-02f,
  -3.11018918e-02f, -1.20992400e-01f, 1.74877811e-02f, -1.07183777e-01f, 1.09483682e-01f, -7.42770508e-02f, -8.85814056e-02f, 1.10852778e-01f, 3.93889286e-02f, 1.08248249e-01f,
  -9.25423428e-02f, -4.69001569e-03f, -2.80408021e-02f, -6.22464307e-02f, -3.16813067e-02f, 8.97702873e-02f, 7.37912208e-02f, -8.47443491e-02f, -5.79686975e-03f, -1.18550934e-01f,
  8.65961611e-02f, -2.11681332e-02f, -1.25788465e-01f, 4.34758663e-02f, -4.39892560e-02f, 3.69675010e-02f, -6.26268685e-02f, 1.86416805e-02f, -1.01153694e-01f, 8.58871788e-02f,
  9.01143327e-02f, -1.09703220e-01f, -6.51212856e-02f, -1.65591855e-02f, 4.59383335e-03f, -1.04568712e-03f, -1.02273621e-01f, -3.36470716e-02f, 2.29484122e-02f, -4.68535349e-02f,
  9.88454521e-02f, -5.57577088e-02f, 1.18611895e-01f, -1.02495819e-01f, -5.24957106e-02f, 4.75794859e-02f, -6.18560761e-02f, 3.12066581e-02f, -2.41023246e-02f, 3.00599299e-02f,
  6.02834998e-03f, 4.14153142e-03f, -9.93076488e-02f, 1.15440458e-01f, 8.71934667e-02f, -9.31211188e-02f, -6.49705827e-02f, 8.47463459e-02f, 1.16394103e-01f, -5.65229021e-02f,
  -7.55307078e-02f, 6.16551042e-02f, -1.22728609e-01f, 1.94888562e-02f, 7.22448006e-02f, -2.90914346e-02f, -9.11368150e-03f, -9.56762359e-02f, -5.65472059e-02f, -5.39022274e-02f,
  1.27213061e-01f, 1.10631533e-01f, -4.92660478e-02f, -2.39271745e-02f, -6.68239743e-02f, 8.41446370e-02f, -6.38255775e-02f, -9.96030346e-02f, -2.15706527e-02f, -5.86033054e-02f,
  -1.25419825e-01f, 2.47008726e-02f, 1.24885747e-02f, -7.04054832e-02f, 4.66983765e-02f, -3.98888849e-02f, -1.04937278e-01f, -2.39004958e-02f, -1.09500170e-01f, -7.43098632e-02f,
  5.70184030e-02f, 1.29982522e-02f, -1.32133454e-01f, -7.71413967e-02f, 1.97650176e-02f, -1.11970827e-01f, -6.14913777e-02f, -8.59472975e-02f, 7.80698210e-02f, 1.17791846e-01f,
  -8.35040733e-02f, 3.81378457e-02f, 4.42029610e-02f, -2.48029158e-02f, -8.63436535e-02f, 2.50352290e-03f, -1.01900585e-01f, -3.67160067e-02f, 1.87260974e-02f, 1.43023118e-01f,
  1.40670374e-01f, -9.73318592e-02f, 3.23001668e-02f, 1.24363057e-01f, 5.13525531e-02f, 1.40014082e-01f, 1.21314682e-01f, 2.56269332e-03f, 1.16686700e-02f, -3.47777680e-02f,
  -6.88041970e-02f, 1.92392200e-01f, 4.79480885e-02f, 1.83130026e-01f, 5.27684949e-02f, 3.02032800e-04f, 8.72442126e-02f, 6.76664412e-02f, -4.23243195e-02f, -9.90680084e-02f,
  6.11153319e-02f, -3.45335305e-02f, 3.16009074e-02f, -3.68222445e-02f, -9.70168933e-02f, 1.04542179e-02f, -3.47513445e-02f, -5.04791476e-02f, -7.52818631e-03f, 1.21381870e-02f,
  -3.41375172e-02f, 4.17725109e-02f, -8.75289217e-02f, -7.46509358e-02f, -1.28811404e-01f, -2.55961157e-02f, -7.07474118e-03f, -5.88717349e-02f, -7.45514333e-02f, -7.32837012e-03f,
  5.78959696e-02f, -1.38773024e-01f, -1.08623073e-01f, -2.77288556e-02f, 3.75489220e-02f, -5.10138012e-02f, -6.87735155e-02f, -5.80361532e-03f, 1.55931478e-02f, -8.20074324e-03f,
  1.30308062e-01f, -8.86608511e-02f, -8.86583701e-02f, -5.00203036e-02f, 7.45125487e-02f, 7.01088412e-03f, -1.06140986e-01f, -1.00787498e-01f, -5.98405190e-02f, 6.31910190e-02f,
  -1.77378524e-02f, -8.37331638e-02f, -6.34722039e-02f, -7.93443341e-03f, 1.44289536e-02f, -1.77040882e-02f, -7.37407506e-02f, 9.36052203e-02f, 8.00576285e-02f, 3.48303430e-02f,
  8.45986903e-02f, 2.48379745e-02f, -3.50502171e-02f, -1.38310701e-01f, 6.56203032e-02f, -9.75147113e-02f, 1.20896935e-01f, -9.34962258e-02f, -6.49012402e-02f, 6.82310462e-02f,
  -7.43877143e-02f, 1.25396624e-01f, 1.27553325e-02f, 1.06024802e-01f, 8.55655968e-03f, 2.00225860e-01f, 7.70158768e-02f, 8.05568248e-02f, 1.83750674e-01f, 1.51016623e-01f,
  1.76501751e-01f, 1.07908703e-01f, 4.56291921e-02f, -2.30299179e-02f, 1.76592410e-01f, 2.14387745e-01f, 9.47848335e-02f, 9.47596952e-02f, -1.97232783e-01f, 2.35224858e-01f,
  -1.06814399e-01f, -1.85789227e-01f, 2.13578850e-01f, -6.68608174e-02f, 2.45568216e-01f, 2.14027122e-01f, -2.08133519e-01f, 6.73876181e-02f, 1.99071035e-01f, -7.28400126e-02f,
  -3.65657285e-02f, 1.60697982e-01f, 2.07697332e-01f, -8.06204379e-02f, 1.92659289e-01f, 2.94014156e-01f, -1.67308617e-02f, 9.89785045e-02f, 7.58317336e-02f, -1.52200997e-01f,
  7.79191107e-02f, 2.63586104e-01f, 1.50238082e-01f, -1.15117356e-01f, -1.80018678e-01f, 2.10765041e-02f, -4.23079655e-02f, 2.90245414e-01f, 3.39352600e-02f, -3.52076180e-02f,
  3.47808786e-02f, 1.59439035e-02f, 2.64507327e-02f, -9.20743197e-02f, 1.27086133e-01f, -2.03500707e-02f, 8.07331502e-02f, -2.47704804e-01f, -4.30449396e-02f, 8.50194469e-02f,
  7.12477937e-02f, 2.26591766e-01f, 7.09047122e-03f, 1.67100448e-02f, 1.01108342e-01f, 2.35154070e-02f, -6.60511553e-02f, -5.57322204e-02f, 1.97666213e-02f, 1.03455424e-01f,
  3.59829038e-01f, 3.57031897e-02f, 3.04127395e-01f, 8.43110681e-02f, 1.77169979e-01f, 1.40264481e-01f, 2.27192909e-01f, 2.51929015e-01f, 1.66275889e-01f, 1.30393371e-01f,
  1.05557598e-01f, 2.61505395e-01f, -7.63019025e-02f, 2.56522894e-01f, 7.36205205e-02f, 3.79660726e-01f, 4.82528985e-01f, 3.40769470e-01f, 3.61947715e-01f, 1.41287953e-01f,
  -2.02045292e-01f, -3.54000032e-02f, -6.38501123e-02f, -4.34762761e-02f, 1.79948043e-02f, 1.55067652e-01f, 4.01075743e-02f, -9.96056721e-02f, -1.47305503e-01f, 3.64356250e-01f,
  4.40775938e-02f, -1.67368039e-01f, 3.53877507e-02f, -1.26434369e-02f, -4.40802723e-02f, 1.65982142e-01f, -1.39465302e-01f, -4.13806736e-02f, -3.10623161e-02f, 3.49176936e-02f,
  2.72192843e-02f, 2.79837608e-01f, 2.21317753e-01f, -1.94440428e-02f, 4.46780175e-02f, -1.29082516e-01f, 1.91363603e-01f, -2.46114787e-02f, 1.65808409e-01f, -4.43725251e-02f,
  -7.46552050e-02f, -4.34169360e-02f, -1.30147666e-01f, -5.05509935e-02f, -1.68974668e-01f, -2.03442544e-01f, -1.80612847e-01f, 1.08914770e-01f, 6.58336952e-02f, 9.15230718e-03f,
  -1.13132432e-01f, -4.43562046e-02f, 1.90898955e-01f, 1.83224306e-01f, 1.24145150e-01f, 1.47196278e-01f, 1.00776039e-01f, 3.50883871e-01f, 2.46271849e-01f, 3.73931900e-02f,
  2.09903136e-01f, -2.65660975e-02f, 2.35399663e-01f, 3.98647748e-02f, -5.83003312e-02f, -3.14359665e-01f, 2.52484262e-01f, -1.80621341e-01f, -5.38885705e-02f, -1.97440654e-01f,
  -1.13807067e-01f, -2.86732644e-01f, -1.88858524e-01f, 2.58416951e-01f, 3.65603454e-02f, -2.34578893e-01f, 1.50084272e-01f, 4.27256912e-01f, 8.82333219e-02f, -9.05651972e-02f,
  1.43342659e-01f, -1.41168227e-02f, -2.63874624e-02f, 1.81725770e-01f, 3.48275751e-02f, 3.73370834e-02f, -1.35990888e-01f, 1.51113525e-01f, 2.50033319e-01f, -1.43202757e-02f,
  1.98265940e-01f, 1.69785604e-01f, 2.64715672e-01f, -1.25355003e-02f, -5.65391779e-02f, 1.77962124e-01f, 1.39962211e-01f, -1.14427529e-01f, -8.43883455e-02f, 3.38810161e-02f,
  -1.31274536e-01f, 1.00137159e-01f, 1.47776723e-01f, 9.08859894e-02f, 4.29235876e-01f, -9.36183706e-02f, -1.58234864e-01f, 1.08422481e-01f, -7.83643275e-02f, 1.25526741e-01f,
  -4.81501967e-02f, 2.35619128e-01f, 2.72204101e-01f, -7.40434695e-03f, 1.55609131e-01f, 1.73554048e-01f, -1.01034947e-01f, 1.99709386e-02f, -1.27607763e-01f, 4.91048396e-02f,
  1.56753436e-02f, -5.74563723e-03f, 4.75718454e-02f, -7.00895116e-02f, -3.84786017e-02f, 1.20663261e-02f, 1.37148961e-01f, -1.07198961e-01f, -4.70052473e-02f, 2.46322174e-02f,
  -7.01644793e-02f, 5.19993864e-02f, 7.57544339e-02f, -2.16755252e-02f, 5.35211861e-02f, -4.45920639e-02f, 1.17801584e-01f, -4.15161997e-02f, -1.06753357e-01f, -4.58136909e-02f,
  2.19431706e-02f, -3.85938920e-02f, 7.70130530e-02f, -1.24411486e-01f, -1.29994461e-02f, -9.80276540e-02f, 1.65054709e-01f, -6.89847618e-02f, 1.24063149e-01f, 6.22746386e-02f,
  1.20863773e-01f, -5.83343729e-02f, -2.39044111e-02f, -2.92805713e-02f, 5.85414469e-02f, 8.73167068e-02f, 1.25404134e-01f, 3.99462432e-02f, -1.83097762e-03f, 1.15418069e-01f,
  -8.89095068e-02f, 1.27264321e-01f, 1.94938779e-02f, 8.74161124e-02f, 3.98870483e-02f, 8.42032284e-02f, -2.92074420e-02f, 5.77370077e-02f, 3.14979209e-03f, 1.00901291e-01f,
  4.25006775e-03f, 1.78723127e-01f, 4.23018038e-02f, -4.19290911e-04f, 2.87118298e-03f, -3.16100903e-02f, -4.91283648e-02f, -3.08577735e-02f, -4.42952737e-02f, 3.68989334e-02f,
  4.27504107e-02f, 7.87572414e-02f, 2.65364703e-02f, -3.79965566e-02f, -5.15570566e-02f, 2.14060973e-02f, -5.13372608e-02f, -3.29408273e-02f, -3.31259221e-02f, -7.41725117e-02f,
  -6.37205467e-02f, 4.81661074e-02f, 7.71281198e-02f, -5.25639281e-02f, -1.11188330e-01f, -9.32156965e-02f, 4.84644733e-02f, -1.38307605e-02f, 1.05844289e-01f, 1.07153744e-01f,
  -9.67444703e-02f, 1.18332557e-01f, -1.39308810e-01f, -1.28406689e-01f, 1.46166787e-01f, -1.23884911e-02f, 1.06474543e-02f, -8.67490564e-03f, 1.14469053e-02f, -1.45145254e-02f,
  5.54633290e-02f, 1.20299704e-01f, -3.52509208e-02f, -3.76570709e-02f, -1.24366991e-01f, 5.08436672e-02f, -2.78969519e-02f, -4.59332503e-02f, 9.01343226e-02f, -6.63011670e-02f,
  1.25389621e-01f, 4.45363596e-02f, -1.26985028e-01f, 5.76138273e-02f, 7.72534385e-02f, 8.39857161e-02f, 9.34871733e-02f, -7.01275393e-02f, 3.07018477e-02f, 1.03076227e-01f,
  5.55325896e-02f, 8.16301852e-02f, 1.61051109e-01f, -1.35166913e-01f, -9.55410972e-02f, -1.15631960e-01f, -8.51583108e-03f, 1.35370851e-01f, -1.96314324e-02f, -3.77074257e-02f,
  1.17531978e-01f, -1.40536409e-02f, 5.02158105e-02f, -1.29785299e-01f, -8.80309343e-02f, 7.76396990e-02f, -1.08614817e-01f, 6.88655600e-02f, 4.33196723e-02f, -2.50595771e-02f,
  -8.89179483e-02f, -2.08007470e-02f, -1.12738848e-01f, 5.04291542e-02f, -5.59369884e-02f, -3.87310125e-02f, -7.49044418e-02f, -1.08883329e-01f, 5.63560054e-02f, -1.01642542e-01f,
  -4.35497537e-02f, 3.02012246e-02f, 1.17904820e-01f, -2.84689777e-02f, -1.01606332e-01f, 1.27328977e-01f, -3.72162536e-02f, -5.29189147e-02f, -1.72040462e-02f, -2.65629701e-02f,
  9.44110304e-02f, 1.15968458e-01f, 1.96525622e-02f, -1.04346257e-02f, -5.97920157e-02f, 8.06560218e-02f, -2.01669168e-02f, 1.25299558e-01f, 4.57174592e-02f, 7.89882895e-03f,
  1.55526072e-01f, 2.28883177e-02f, 7.84765631e-02f, 6.39738813e-02f, -4.24556760e-03f, -2.83788983e-02f, 4.34951149e-02f, 9.43365470e-02f, 1.43761663e-02f, -6.97858930e-02f,
  -9.92577299e-02f, -8.04598257e-02f, -1.23249874e-01f, 1.16329819e-01f, 5.87347150e-02f, -1.24399671e-02f, 9.76806600e-03f, -3.17828581e-02f, -5.93759120e-03f, -3.34602222e-02f,
  -5.59458472e-02f, -5.70396110e-02f, 2.30033975e-02f, 8.48000497e-02f, 1.45203784e-01f, -3.74574922e-02f, 4.72502820e-02f, 9.38690901e-02f, -6.95090145e-02f, -4.26563695e-02f,
  2.92958897e-02f, 4.21827249e-02f, -1.05507366e-01f, 9.61813629e-02f, -6.52922541e-02f, 9.72271487e-02f, -2.62246300e-02f, -9.62116048e-02f, 1.35327175e-01f, 1.28131375e-01f,
  -5.71088679e-02f, -2.18812544e-02f, -5.61104529e-02f, -6.05722442e-02f, -6.39177039e-02f, -1.83516711e-01f, 6.89370409e-02f, 2.58460473e-02f, -1.99879467e-01f, -4.96183336e-02f,
  1.82035118e-02f, 4.31494229e-02f, 2.42667854e-01f, 9.92855653e-02f, -1.14707217e-01f, 4.10840362e-02f, 6.81378916e-02f, 2.47578826e-02f, 4.60321829e-02f, -4.67960015e-02f,
  -5.05381599e-02f, 9.37261954e-02f, -1.05953477e-02f, 4.89275791e-02f, 2.98370831e-02f, 3.53935175e-02f, -3.72688696e-02f, 1.49057880e-01f, -1.03045575e-01f, -8.81384015e-02f,
  -5.92270941e-02f, -3.18971463e-02f, -4.87774946e-02f, -1.90789886e-02f, 9.47495773e-02f, -8.02007690e-02f, 9.11559984e-02f, -1.00159049e-01f, -4.72745299e-02f, 4.49582450e-02f,
  2.00535864e-01f, -1.51530132e-01f, 6.43739626e-02f, -2.94568464e-02f, -8.85746479e-02f, 2.77683377e-01f, 7.29023060e-03f, 3.67025234e-04f, -2.06027888e-02f, 4.45378870e-02f,
  -2.43721195e-02f, -7.11137131e-02f, 1.74167886e-01f, -7.55743608e-02f, -8.71990062e-03f, 1.61967456e-01f, -3.23138870e-02f, 6.87216893e-02f, 5.00688665e-02f, 7.73641989e-02f,
  8.84774923e-02f, 2.51925681e-02f, -4.58607972e-02f, -3.29638422e-02f, -2.29008235e-02f, -5.17747067e-02f, 9.68142450e-02f, -9.43887979e-02f, -7.71691278e-02f, -8.26049447e-02f,
  4.78157587e-02f, -1.45680439e-02f, 1.25845924e-01f, -9.78483260e-02f, -7.27786794e-02f, -5.28896637e-02f, 1.74005963e-02f, 1.78075999e-01f, -1.12371735e-01f, -4.46364097e-02f,
  -7.61676952e-02f, 6.69275299e-02f, -5.48796728e-03f, 1.38395846e-01f, 8.11518431e-02f, -2.59864680e-03f, 2.49139871e-02f, -6.04253821e-02f, 8.17717314e-02f, -6.78163115e-03f,
  -2.44716462e-02f, 1.13460451e-01f, -3.14614177e-02f, 9.09612700e-02f, 6.42757937e-02f, -1.20447300e-01f, -9.89959314e-02f, -5.82446456e-02f, -1.80637185e-02f, -5.43112978e-02f,
  1.24390032e-02f, 5.32896742e-02f, -3.44678597e-03f, -1.16225153e-01f, 1.21247910e-01f, 3.73066142e-02f, 3.59026678e-02f, -1.35810018e-01f, 2.91117039e-02f, -9.43576694e-02f,
  1.18723437e-01f, -4.95603792e-02f, 3.60307619e-02f, -3.59628815e-03f, 7.25950748e-02f, -6.97052330e-02f, 3.68773192e-02f, -2.48742215e-02f, -4.71077152e-02f, 8.01501945e-02f,
  1.08462377e-02f, -1.40835315e-01f, 5.64640295e-03f, -3.25328931e-02f, -3.80503722e-02f, -9.18850396e-03f, -9.41115543e-02f, -1.29042253e-01f, 1.08707756e-01f, 1.06259838e-01f,
  -8.68455991e-02f, 8.12352821e-02f, 9.72631276e-02f, 5.50558716e-02f, 8.85465890e-02f, -7.30217844e-02f, -1.16924271e-01f, -4.56443354e-02f, 5.39510287e-02f, 1.00876197e-01f,
  -1.20500945e-01f, 4.20047008e-02f, 2.59902719e-02f, 9.68203768e-02f, -9.89118740e-02f, 5.96283600e-02f, -3.92953306e-02f, 1.13813594e-01f, 1.01583511e-01f, 8.23768228e-02f,
  -1.29975863e-02f, 1.07928619e-01f, 3.05479057e-02f, 7.19832182e-02f, -6.50707632e-02f, -1.75748467e-02f, -4.00327903e-04f, -7.16591030e-02f, -7.57194310e-02f, -2.04386804e-02f,
  -1.21260643e-01f, -5.61519004e-02f, 1.23280525e-01f, 8.61704946e-02f, -4.17925753e-02f, -4.33902778e-02f, 7.59646967e-02f, -3.44121456e-02f, 5.51033840e-02f, 3.68607906e-03f,
  4.27171439e-02f, 1.74201671e-02f, -3.54125015e-02f, 5.57268672e-02f, 4.16737748e-03f, 2.54421141e-02f, -7.63795525e-02f, -6.32883534e-02f, -8.15154091e-02f, -1.84438340e-02f,
  2.10839752e-02f, 3.37699279e-02f, 2.06601739e-01f, 1.69212118e-01f, 5.58966585e-02f, 1.86022982e-01f, 1.33647919e-01f, 1.45885155e-01f, 2.47614440e-02f, 4.22444940e-02f,
  -3.40150632e-02f, 2.08687466e-02f, 1.84233561e-02f, 1.42505363e-01f, 1.35894880e-01f, 1.23488121e-01f, -1.59067422e-01f, 9.43652615e-02f, 1.26093104e-01f, -7.27580562e-02f,
  -4.78383377e-02f, -1.13496654e-01f, -5.91511577e-02f, -1.96264341e-01f, 1.96584128e-02f, -7.26549998e-02f, -1.06240124e-01f, 1.25020847e-01f, 8.67591351e-02f, -7.08065704e-02f,
  8.42516869e-02f, 8.04586709e-02f, 1.95571650e-02f, -3.18320505e-02f, -8.33893269e-02f, 7.32746050e-02f, 8.82344842e-02f, 7.16161877e-02f, -1.00306168e-01f, -8.39709565e-02f,
  -8.12288597e-02f, -1.20985106e-01f, -5.28494343e-02f, -4.70644385e-02f, -8.03241655e-02f, -1.01258799e-01f, 1.40410557e-01f, 1.27816841e-01f, -4.60290052e-02f, -1.97181404e-02f,
  3.61900553e-02f, -3.40711810e-02f, -8.15446954e-03f, 8.12557861e-02f, -1.53658584e-01f, 1.55548140e-01f, -6.61060661e-02f, -1.96953081e-02f, -7.04899132e-02f, -9.05354470e-02f,
  -6.29999265e-02f, 1.28442839e-01f, -8.93970858e-03f, -1.15511671e-01f, -1.07026756e-01f, 3.57391196e-04f, -2.15260033e-02f, -5.04025556e-02f, -3.69491428e-02f, -6.64255247e-02f,
  2.49915961e-02f, -2.14545376e-04f, 1.13687433e-01f, -4.40183282e-02f, 1.46248654e-01f, 1.13498770e-01f, -2.14595512e-01f, -1.84894472e-01f, 1.55453846e-01f, 1.67917798e-03f,
  -8.04876983e-02f, 2.58250367e-02f, -6.93528503e-02f, -1.48205057e-01f, -1.35277390e-01f, -7.64729381e-02f, 1.76949099e-01f, -6.77022338e-02f, 3.03492718e-03f, 2.83203274e-02f,
  6.56003430e-02f, -1.30599707e-01f, -1.81465466e-02f, -1.12829953e-01f, 9.03921500e-02f, -1.26693353e-01f, 9.60357189e-02f, -5.67846447e-02f, 1.22532338e-01f, -3.50360712e-03f,
  6.75007002e-04f, -9.44110751e-02f, 5.45037817e-03f, -3.18507478e-02f, 3.66171375e-02f, 1.15924450e-02f, 1.29465923e-01f, 5.20958602e-02f, -4.72599193e-02f, 1.57115802e-01f,
  -9.23783705e-02f, 1.52137941e-02f, 1.03365459e-01f, 7.67603368e-02f, 1.53479474e-02f, -3.78853194e-02f, -6.85042366e-02f, 1.33408800e-01f, -7.77078606e-03f, 9.76521522e-02f,
  -9.71355736e-02f, 9.69233084e-03f, 4.15962525e-02f, 1.72953829e-01f, 1.08030312e-01f, -1.42669035e-02f, -7.27003813e-02f, -8.96945447e-02f, -5.33147939e-02f, 4.82841842e-02f,
  1.93475544e-01f, 7.30635598e-02f, -3.34643647e-02f, -3.21747735e-02f, -8.18763003e-02f, -3.17268334e-02f, 1.73286751e-01f, 1.32637948e-01f, -1.45468442e-02f, 8.67850259e-02f,
  6.75557703e-02f, 5.77980317e-02f, -6.65808991e-02f, -9.42994952e-02f, 4.68173325e-02f, 1.13925427e-01f, 3.06909308e-02f, -7.73268379e-03f, 6.70801923e-02f, 6.43227994e-02f,
  -5.91794774e-03f, -1.05134338e-01f, 9.62138474e-02f, -3.78137417e-02f, -5.59809469e-02f, 5.30148968e-02f, 1.06713243e-01f, 6.58289492e-02f, 8.87950137e-03f, 9.07193646e-02f,
  -8.63843486e-02f, -1.30978832e-02f, -1.14857383e-01f, -7.26910308e-02f, -6.88416883e-02f, -1.02620006e-01f, -7.69364461e-02f, 6.85098767e-02f, 2.77999863e-02f, -3.39256302e-02f,
  -9.06701013e-02f, -1.21398970e-01f, -7.70160332e-02f, 1.31322354e-01f, -2.31649238e-03f, -6.12025857e-02f, 1.64589092e-01f, -2.55760811e-02f, 7.19712153e-02f, 1.03097502e-02f,
  -3.20076905e-02f, 1.03955284e-01f, -8.99406224e-02f, -1.05143748e-01f, -6.22814447e-02f, -7.60479644e-02f, 4.47331592e-02f, -9.83643159e-03f, -5.24346754e-02f, -4.20083255e-02f,
  -5.81325069e-02f, -1.41053356e-03f, 2.62883604e-01f, 5.80697022e-02f, 8.11439082e-02f, 2.23420382e-01f, 2.75356621e-01f, 1.53522328e-01f, 1.19927421e-01f, 1.01696551e-01f,
  2.21959278e-01f, 2.97643483e-01f, 1.38862342e-01f, 1.22615814e-01f, -7.01385066e-02f, 1.41746551e-01f, -1.45120159e-01f, -1.21519975e-01f, 1.10467643e-01f, 6.53975010e-02f,
  -1.99550018e-01f, -9.35458764e-02f, 2.52822220e-01f, -1.58676192e-01f, 2.43702486e-01f, 4.96361889e-02f, -8.97188187e-02f, -1.02739409e-01f, -8.51817876e-02f, 1.46967292e-01f,
  2.54732836e-02f, 9.67038274e-02f, -3.04560829e-03f, -1.66769587e-02f, 1.80517048e-01f, 1.87080458e-01f, 9.54535976e-02f, 2.74304692e-02f, -7.40823075e-02f, -8.37659165e-02f,
  -2.47304440e-02f, -8.78709629e-02f, 1.86999172e-01f, -1.66307792e-01f, 8.00458714e-03f, 7.97092170e-02f, -1.03912860e-01f, 1.20352119e-01f, 2.73590058e-01f, 6.97637051e-02f,
  2.22270861e-01f, 1.44834384e-01f, -1.17197156e-01f, -1.86640814e-01f, -8.49928707e-02f, -2.19976548e-02f, 2.16401234e-01f, -2.03963101e-01f, -2.77855974e-02f, -3.72864008e-02f,
  1.99181527e-01f, -1.09469973e-01f, -9.22375619e-02f, -9.74699184e-02f, 1.67209152e-02f, -1.05451204e-01f, 2.12408558e-01f, 2.08210483e-01f, 1.44052655e-01f, 1.26345351e-01f,
  1.77508771e-01f, 2.05542237e-01f, 3.57363224e-02f, 1.42433062e-01f, 1.93668604e-01f, 8.27839151e-02f, 2.82425106e-01f, 1.56346783e-01f, -3.38189811e-01f, -1.41575426e-01f,
  9.71542671e-02f, -4.58958521e-02f, -7.72236288e-02f, -3.36853236e-01f, -4.15766448e-01f, -1.05288960e-02f, -6.67852759e-02f, -7.47751519e-02f, 3.56038243e-01f, 3.71593088e-01f,
  -9.26842615e-02f, 1.42293185e-01f, 1.89093858e-01f, -1.34944439e-01f, -7.06972629e-02f, 3.78236324e-02f, 1.53213277e-01f, -9.05646682e-02f, 2.12048534e-02f, 1.51793256e-01f,
  1.38940051e-01f, 4.30468358e-02f, -5.05700521e-02f, -6.93493113e-02f, 1.51970252e-01f, -7.74734989e-02f, 8.53873268e-02f, 4.00450863e-02f, 7.57295787e-02f, -2.14677542e-01f,
  -1.79743379e-01f, 1.47291049e-01f, -4.09814063e-03f, 7.86281526e-02f, -1.47242472e-02f, 1.53538749e-01f, -1.28519773e-01f, 1.50892913e-01f, -8.43744129e-02f, 1.98073804e-01f,
  2.52824038e-01f, 8.49634930e-02f, 4.59263511e-02f, 4.13104072e-02f, 2.16967702e-01f, 2.21965641e-01f, 8.28009769e-02f, -9.31533575e-02f, -1.67528376e-01f, 7.86560923e-02f,
  1.08387642e-01f, 5.98080456e-03f, 5.52267097e-02f, -1.11654632e-01f, -2.57315487e-02f, 3.90646048e-02f, 4.89497483e-02f, 1.00779131e-01f, 1.47254437e-01f, 1.30076975e-01f,
  6.35250211e-02f, -1.51430830e-01f, 2.50878036e-01f, -5.98906055e-02f, 1.16640612e-01f, 6.65454543e-04f, 4.23112400e-02f, 8.66757929e-02f, 1.61479309e-01f, -9.05689448e-02f,
  -1.43728470e-02f, 2.20868504e-03f, -8.15729871e-02f, -1.10534783e-02f, 1.33964531e-02f, 6.46165237e-02f, 6.64018318e-02f, 4.57262322e-02f, 9.49214324e-02f, -1.20538212e-01f,
  -9.87021402e-02f, 2.10403532e-01f, -1.11338601e-01f, -2.04297472e-02f, -8.99878368e-02f, 1.87068328e-01f, -1.08801389e-04f, 4.77614515e-02f, -8.74240398e-02f, -6.30510971e-02f,
  7.32873753e-02f, 9.93491262e-02f, 8.92589837e-02f, 8.90623927e-02f, 9.14836302e-02f, -1.08673543e-01f, 1.50184220e-04f, 1.39418006e-01f, -7.46087506e-02f, -1.09999496e-02f,
  6.48552459e-03f, -1.37969265e-02f, 1.16147980e-01f, -1.36084899e-01f, 7.16682747e-02f, -6.15055338e-02f, -1.13687408e-03f, -1.51265368e-01f, -7.38721713e-02f, 9.70128477e-02f,
  1.08964182e-01f, 2.65176292e-03f, -5.45067824e-02f, 4.69980016e-02f, -1.08458616e-01f, 1.14162616e-01f, -7.93872308e-03f, 1.84575785e-02f, -8.62808824e-02f, -9.48385447e-02f,
  -3.25924419e-02f, 1.08318001e-01f, 7.85065144e-02f, 2.28229612e-02f, 1.43690649e-02f, -2.27990486e-02f, -6.33151904e-02f, -4.60079834e-02f, -3.46362889e-02f, 6.69913962e-02f,
  2.97120661e-02f, 1.69631273e-01f, 1.24822833e-01f, -7.90016055e-02f, -1.71234936e-01f, 3.69040035e-02f, -1.12858608e-01f, -1.27511546e-01f, 7.96952918e-02f, -7.90007487e-02f,
  -4.50642314e-03f, -5.02932519e-02f, -3.81285287e-02f, -1.07588604e-01f, -7.94007108e-02f, -4.10872363e-02f, -8.24774876e-02f, -9.93185770e-03f, 5.94835021e-02f, 9.30405408e-02f,
  -2.23419052e-02f, 1.03418587e-03f, 2.41913814e-02f, 8.83324724e-03f, 1.94994248e-02f, 1.31792068e-01f, -4.50059287e-02f, 1.05848812e-01f, 1.03440136e-01f, 8.87670293e-02f,
  9.07445028e-02f, 6.39315918e-02f, 7.75514990e-02f, -4.36070822e-02f, 2.55533010e-02f, -1.34409800e-01f, -1.09613605e-01f, 5.11851236e-02f, -8.55613966e-03f, 6.07813373e-02f,
  -1.31641433e-01f, -3.76185738e-02f, 2.36184187e-02f, -4.52395789e-02f, 8.85366052e-02f, 6.62481487e-02f, -1.33962050e-01f, -2.68766414e-02f, -2.22509857e-02f, -5.91454320e-02f,
  -1.05625749e-01f, -8.32949504e-02f, -8.12812075e-02f, 8.50931630e-02f, 1.37814984e-01f, -3.84615362e-02f, 2.72620842e-02f, -1.32531941e-01f, -8.21279213e-02f, -3.31046730e-02f,
  2.11623628e-02f, 6.27779365e-02f, -9.56110507e-02f, -9.28917900e-02f, 1.19905598e-01f, 6.67344406e-02f, 5.94827458e-02f, -4.19647880e-02f, -1.24089181e-01f, 1.11103930e-01f,
  -3.43350670e-03f, 1.18116558e-01f, 4.11207862e-02f, -8.83498937e-02f, 1.17212430e-01f, -7.12689236e-02f, -1.18977107e-01f, -5.90770841e-02f, -5.72652593e-02f, 3.89315300e-02f,
  -2.60868315e-02f, -1.38880551e-01f, 1.11851908e-01f, -5.51154427e-02f, 2.91420724e-02f, 3.15656364e-02f, -4.45803963e-02f, -5.01121171e-02f, -1.07885666e-01f, 3.46165635e-02f,
  -9.14014876e-02f, 1.22819833e-01f, 5.23648299e-02f, -1.09053917e-01f, 6.18342198e-02f, -4.27705096e-03f, 8.30919519e-02f, -1.19390942e-01f, -8.83019995e-03f, 1.54442206e-01f,
  -6.55415878e-02f, 1.73572913e-01f, 1.68345526e-01f, 8.66139606e-02f, -5.60170002e-02f, 2.36369297e-02f, -3.55479866e-02f, -6.29584864e-02f, -5.79920895e-02f, -4.68063764e-02f,
  8.41136053e-02f, 1.09773688e-01f, -6.39004335e-02f, 1.19734056e-01f, -5.93722798e-03f, -3.13876681e-02f, -2.35963855e-02f, -3.15742902e-02f, 4.84589152e-02f, 9.13300291e-02f,
  1.24396957e-01f, -3.66539620e-02f, -7.52732251e-03f, 1.34782284e-01f, 3.49178314e-02f, 1.69412911e-01f, -1.98483586e-01f, 1.41820952e-01f, -1.10127874e-01f, -5.78735135e-02f,
  -6.28841594e-02f, 7.64749572e-02f, 4.45696749e-02f, 7.95961022e-02f, 8.34647864e-02f, 1.36851460e-01f, -5.87202273e-02f, -5.41159101e-02f, -8.06992780e-03f, 1.17512047e-01f,
  7.65549913e-02f, -2.46888306e-02f, 8.67605209e-02f, -1.18425287e-01f, 1.00355476e-01f, -1.11913057e-02f, 1.46938905e-01f, 3.17748226e-02f, -1.20058842e-01f, 1.09393716e-01f,
  -1.01085514e-01f, 1.99844390e-02f, 5.65714389e-02f, 4.47188765e-02f, -1.25507414e-01f, -9.64435041e-02f, 7.26556629e-02f, -5.88245019e-02f, 1.48132471e-02f, 6.62713796e-02f,
  -4.07723859e-02f, 2.73808595e-02f, 3.90612544e-03f, -6.46763965e-02f, 1.13075890e-01f, -5.22664972e-02f, -7.89457373e-03f, 2.17758179e-01f, -8.17028731e-02f, 1.51994601e-02f,
  1.19373553e-01f, -8.28006044e-02f, 5.03917634e-02f, -2.77635902e-02f, 8.16450566e-02f, -8.86307657e-02f, 5.50277866e-02f, 5.62598109e-02f, -6.50169328e-03f, -1.08448751e-01f,
  1.02552086e-01f, -4.18039374e-02f, -9.26891640e-02f, -9.90654528e-02f, 1.58024050e-04f, 8.05767924e-02f, -7.57428184e-02f, 5.59212752e-02f, -1.12757847e-01f, 3.35973799e-02f,
  -9.72710177e-02f, -2.97813565e-02f, 1.15792006e-01f, -1.15733989e-01f, 1.38305143e-01f, -4.32010517e-02f, 1.24289123e-02f, -8.38443637e-02f, 5.40645495e-02f, -2.97791082e-02f,
  2.65472345e-02f, -9.62596312e-02f, 4.36420813e-02f, 1.08095869e-01f, -1.52402753e-02f, 1.18098326e-01f, -1.21007368e-01f, -5.08775897e-02f, -2.16570310e-02f, -8.81024674e-02f,
  1.73594803e-02f, -5.55122085e-02f, -3.53326015e-02f, 9.83117670e-02f, 1.19353443e-01f, -8.42363834e-02f, 5.76785468e-02f, 8.86492208e-02f, 4.39988403e-03f, -6.48131669e-02f,
  -1.83859952e-02f, 6.73774034e-02f, 1.17732368e-01f, 4.15801145e-02f, 1.18439741e-01f, 4.62472625e-02f, -1.06162667e-01f, 4.24816944e-02f, -8.70677158e-02f, 2.68591661e-02f,
  -3.20032146e-03f, -6.42558038e-02f, -4.95307371e-02f, 1.14412367e-01f, 6.46908954e-02f, -1.22551210e-01f, -1.31667838e-01f, -3.97854112e-02f, -3.82249020e-02f, 5.15495241e-02f,
  -1.07119106e-01f, -6.27024397e-02f, -5.57101052e-03f, 5.64608537e-02f, 1.45380586e-01f, 1.12007849e-01f, 5.72581328e-02f, 1.25286192e-01f, 2.25290861e-02f, -9.91891921e-02f,
  -1.37575185e-02f, -4.83894944e-02f, -2.19634056e-01f, -1.98285013e-01f, 1.02809079e-01f, -7.96928257e-03f, -1.02980666e-01f, -6.21625669e-02f, -7.11264089e-02f, -1.16869338e-01f,
  -8.39473680e-02f, 8.47824737e-02f, -5.16778082e-02f, 1.45570010e-01f, -1.26718417e-01f, 7.21163228e-02f, 2.14751214e-01f, -1.35728359e-01f, -5.03911935e-02f, -6.16290122e-02f,
  7.63015971e-02f, -2.77914684e-02f, -9.94834229e-02f, -1.13538966e-01f, -5.72418720e-02f, 1.42731041e-01f, 1.58156276e-01f, -3.13773379e-02f, -1.03428110e-01f, -3.23258117e-02f,
  1.32097930e-01f, 8.03498849e-02f, -7.82322721e-04f, -7.90491477e-02f, -5.81012852e-02f, -8.16216245e-02f, -4.71732728e-02f, 7.93098733e-02f, -1.58962200e-03f, -6.69054613e-02f,
  1.40674114e-01f, 5.80889769e-02f, 1.77388489e-02f, 6.06684536e-02f, -5.59866196e-03f, 1.20560400e-01f, -8.48896354e-02f, 1.80933792e-02f, 2.42276471e-02f, 9.95121598e-02f,
  -4.03679870e-02f, -2.50399560e-02f, 1.22760460e-01f, 1.23357154e-01f, 1.69605270e-01f, 7.25385025e-02f, 7.94062838e-02f, -8.14050873e-06f, -5.67997210e-02f, 8.78256001e-03f,
  -2.46274136e-02f, 1.32195890e-01f, -2.89081363e-03f, 3.72874178e-02f, 9.17047169e-03f, 4.92772413e-03f, -6.74031600e-02f, 5.91639280e-02f, 4.62234858e-03f, 3.70434448e-02f,
  8.40352103e-02f, -8.28279927e-02f, -1.50931627e-01f, 3.25430445e-02f, 3.32632214e-02f, -1.91373508e-02f, 8.37340057e-02f, 5.74348271e-02f, 3.80012915e-02f, -2.19967533e-02f,
  -2.29088012e-02f, 7.55527392e-02f, 2.05411650e-02f, -1.95775041e-03f, 9.29619074e-02f, -1.97125282e-02f, -9.17250756e-03f, 9.17557850e-02f, 6.59982907e-03f, -1.79914408e-03f,
  -6.27173707e-02f, -2.52233874e-02f, 6.33690730e-02f, 4.03734706e-02f, -3.53341959e-02f, 3.43694128e-02f, -1.27637554e-02f, 8.34852085e-02f, -1.25860184e-01f, 1.48677662e-01f,
  -8.98726359e-02f, 1.33644029e-01f, 4.45026765e-03f, -7.42954239e-02f, 5.79984393e-03f, -8.95033404e-03f, -7.70378262e-02f, -8.67282152e-02f, 5.33243045e-02f, -1.10664748e-01f,
  -1.89876910e-02f, 5.53977378e-02f, 7.61855096e-02f, -1.13158554e-01f, 7.04068989e-02f, 1.23130612e-01f, -1.39672076e-02f, -9.60051417e-02f, -2.11590659e-02f, 1.14547247e-02f,
  -9.76390839e-02f, -1.37556195e-01f, 4.59242910e-02f, 1.88118652e-01f, 1.64596289e-01f, 3.08734030e-02f, 2.66419295e-02f, 1.33342460e-01f, 1.72748879e-01f, 1.28181025e-01f,
  -1.93787381e-01f, 1.48514047e-01f, 2.86250208e-02f, 7.49884769e-02f, -1.75209239e-01f, -2.14719459e-01f, -1.67971402e-02f, 1.49978697e-01f, -1.86657794e-02f, 1.43649966e-01f,
  1.97362714e-02f, 1.89766094e-01f, 1.47871673e-01f, 7.27341771e-02f, 5.88499978e-02f, -2.46369187e-02f, 2.68079564e-02f, 4.85738255e-02f, 2.66569182e-02f, -1.77741453e-01f,
  8.19998607e-02f, -6.97461888e-02f, 2.41286278e-01f, 5.93266338e-02f, -4.03197557e-02f, -1.17745429e-01f, 1.05370745e-01f, -3.79917212e-02f, -3.81894410e-02f, -8.19848999e-02f,
  -9.07576606e-02f, 3.65977511e-02f, 1.51491910e-01f, -5.40951081e-02f, -1.17956564e-01f, 6.43554106e-02f, -8.38081688e-02f, -7.92390779e-02f, -1.21651655e-02f, 1.66724667e-01f,
  -3.70290615e-02f, 1.59156948e-01f, 5.36137037e-02f, 3.98032159e-01f, 3.97621319e-02f, 9.46054533e-02f, -9.60526764e-02f, -7.90547282e-02f, -6.25794455e-02f, 5.67718819e-02f,
  3.31254373e-03f, -4.40827850e-03f, 5.92107512e-02f, 1.08149506e-01f, 2.66458839e-01f, -3.10821421e-02f, 4.74574789e-02f, 2.60587305e-01f, -2.19552498e-03f, 1.28593206e-01f,
  -8.06976669e-03f, 1.94083780e-01f, 1.09803110e-01f, 4.24615666e-02f, 2.46375605e-01f, 1.40181944e-01f, -7.99721554e-02f, 4.42547575e-02f, 2.80398559e-02f, 2.11277023e-01f,
  6.58676550e-02f, 5.02166450e-02f, 4.09125835e-02f, 4.87359427e-02f, -2.79117897e-02f, -2.45709240e-01f, -1.04860216e-01f, -3.15210074e-02f, -1.53175786e-01f, 1.66356474e-01f,
  6.54230639e-03f, 1.88868996e-02f, 6.96004257e-02f, 2.70538598e-01f, -4.63219509e-02f, -1.01186961e-01f, -1.22500755e-01f, 2.28571211e-04f, -1.55270724e-02f, 5.34213185e-02f,
  -1.86081585e-02f, 1.20192789e-01f, 7.81227201e-02f, 1.84655085e-01f, -4.24894914e-02f, 1.24350660e-01f, 7.37734213e-02f, 4.41664197e-02f, -4.21734005e-02f, -9.64887217e-02f,
  1.81818128e-01f, 1.55338030e-02f, 1.79369345e-01f, -1.36854768e-01f, 2.33988892e-02f, -6.51421696e-02f, -5.47025688e-02f, -1.11071393e-01f, 1.01360373e-01f, 2.44119763e-02f,
  8.61322433e-02f, 8.85604620e-02f, 7.82410279e-02f, -1.25339344e-01f, 1.32979915e-01f, 4.84294854e-02f, -1.19895637e-02f, 1.82432786e-01f, 1.92828134e-01f, 3.25695947e-02f,
  -2.03120839e-02f, 5.15055433e-02f, -4.89434134e-03f, -2.59445757e-02f, 4.40249518e-02f, -6.19882457e-02f, 1.39894173e-01f, -2.38522957e-03f, 3.64708938e-02f, -3.64711545e-02f,
  2.75279321e-02f, 7.17223957e-02f, 6.09051622e-02f, 2.86347084e-02f, 1.06193654e-01f, -1.34868145e-01f, -9.20202285e-02f, 1.39468431e-01f, -1.01417035e-01f, -1.29961908e-01f,
  2.56684184e-01f, -1.64889488e-02f, 2.68409625e-02f, -1.03870124e-01f, -9.01810080e-02f, -2.72629727e-02f, 4.89887930e-02f, 1.06688417e-01f, 1.05984695e-01f, 5.90739101e-02f,
  -1.24904983e-01f, -3.05489786e-02f, 7.02888286e-03f, 3.95437069e-02f, 8.62499997e-02f, 2.78995838e-02f, -1.36450022e-01f, 4.35130158e-03f, -1.15431756e-01f, 5.28953336e-02f,
  -6.45454461e-03f, -7.05424845e-02f, 4.73791920e-02f, 1.27176210e-01f, -1.16809934e-01f, 1.29356042e-01f, -1.01036511e-01f, 6.40422553e-02f, 2.27572769e-01f, -5.81945181e-02f,
  1.63130593e-02f, -9.35452655e-02f, 5.37676588e-02f, 2.08168432e-01f, -9.45855007e-02f, -5.98931387e-02f, -1.11884251e-01f, 5.44654690e-02f, 9.19400528e-02f, -3.50656424e-04f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  2.14729995e-01f, 4.18380052e-02f, -2.01435890e-02f, -6.45540878e-02f, 8.15849602e-02f, 9.63535011e-02f, 8.31833184e-02f, -7.12861568e-02f, 2.40809754e-01f, 1.40014082e-01f,
  -2.43039913e-02f, 1.01189159e-01f, 1.07879527e-01f, -2.70241778e-02f, 1.53545424e-01f, -9.58206803e-02f, 1.33346260e-01f, 2.64491200e-01f, 1.79851130e-01f, 1.15961507e-01f,
  -7.72326365e-02f, 6.53382242e-02f, 5.48086762e-02f, 1.56538382e-01f, 1.97313298e-02f, 9.05556977e-02f, -4.44486141e-02f, 1.53745010e-01f, 6.45256937e-02f, 2.28190184e-01f,
  7.06467181e-02f, 6.17456511e-02f, 8.83928314e-02f, -7.16600120e-02f, -1.10682659e-01f, 1.10500552e-01f, 4.19103205e-02f, 2.19785348e-01f, 4.20691706e-02f, 4.37046997e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -5.63673750e-02f, 3.83130573e-02f, 4.23407368e-02f, -3.57088894e-02f, 8.00498724e-02f, 1.34977102e-01f, -1.17245764e-02f, 1.39850721e-01f, -9.73430574e-02f, 2.03603413e-02f,
  9.50317681e-02f, 5.77888712e-02f, -9.01631638e-03f, 1.70418516e-01f, -1.01733536e-01f, -1.34235218e-01f, -2.23544203e-02f, -1.28223434e-01f, -8.14024955e-02f, -1.45150470e-02f,
  -2.04245165e-01f, -2.36100722e-02f, 8.29965528e-03f, 2.34921783e-01f, -5.40268933e-03f, 1.11852512e-01f, 1.05935104e-01f, 7.35674798e-03f, -1.43068684e-02f, 5.12059182e-02f,
  -2.16788188e-01f, 7.77386203e-02f, 7.30484501e-02f, 2.20176429e-01f, -3.06068044e-02f, -3.10639199e-02f, 1.27759665e-01f, -1.17297128e-01f, -9.93861556e-02f, 1.53555516e-02f,
  -8.20096806e-02f, 2.68720120e-01f, -1.37301356e-01f, 1.31086290e-01f, -2.40666047e-03f, 2.43065041e-02f, -1.94645505e-02f, -3.26784141e-02f, 3.88658270e-02f, 6.86546117e-02f,
  1.20136753e-01f, -1.20495157e-02f, -3.19413915e-02f, -8.02499354e-02f, -1.33077860e-01f, 6.71661785e-03f, 1.43665567e-01f, -2.71178503e-02f, -8.45382586e-02f, 1.55697837e-01f,
  -9.20928195e-02f, 1.92796633e-01f, 6.93757692e-03f, -5.28645031e-02f, -7.96033069e-02f, -2.04034224e-02f, -1.24856718e-02f, -8.57337564e-02f, 5.52786030e-02f, -2.19290666e-02f,
  -2.82481760e-01f, -6.92192316e-02f, -2.42768526e-02f, -1.01549082e-01f, -9.29462239e-02f, -1.42652571e-01f, -1.40573934e-01f, -1.29324704e-01f, 8.87171086e-03f, 1.07698247e-01f,
  1.60442665e-01f, -1.03954911e-01f, 4.58706263e-03f, 4.81228083e-02f, 3.05312663e-01f, 9.46891382e-02f, 7.19309151e-02f, -1.12778530e-01f, -1.79424100e-02f, 2.96524027e-03f,
  -1.73600107e-01f, 1.09850854e-01f, -7.18373433e-02f, 2.22112626e-01f, 9.76256132e-02f, 9.11526289e-03f, -1.35727301e-02f, -6.24011457e-03f, 1.25824464e-02f, -3.35509256e-02f,
  -5.30770682e-02f, 1.05500780e-01f, 8.72324407e-02f, -2.42486466e-02f, -1.60552412e-01f, -3.73844504e-01f, 2.52915055e-01f, 7.03723133e-02f, 1.56854078e-01f, -5.41641787e-02f,
  1.53728694e-01f, -1.07928164e-01f, -1.07281931e-01f, 6.34946302e-02f, 7.27826133e-02f, -6.83275983e-02f, -1.94845691e-01f, 1.29372716e-01f, 3.78274471e-02f, -2.35747099e-02f,
  1.29457861e-01f, -8.28201771e-02f, -7.36056343e-02f, -1.37983123e-02f, 8.19303766e-02f, -8.23033974e-03f, -8.25780630e-02f, -6.14671707e-02f, 1.21731468e-01f, 6.59791380e-02f,
  6.91950843e-02f, 1.01251684e-01f, 1.53633013e-01f, 5.55261038e-02f, -4.72029932e-02f, 3.38342413e-02f, 1.49798049e-02f, 1.83109008e-02f, -1.67447716e-01f, 7.47193471e-02f,
  -1.94861546e-01f, 2.06817687e-01f, 1.25875294e-01f, -3.31812762e-02f, -6.68599159e-02f, 9.67845917e-02f, 6.61666766e-02f, 4.77044806e-02f, 2.50335950e-02f, -1.74475610e-01f,
  2.33806744e-01f, -1.75833300e-01f, -1.12051882e-01f, -1.43292904e-01f, -7.11317807e-02f, -8.55508596e-02f, -1.65872291e-01f, -5.72379073e-03f, 1.05081156e-01f, -8.25665444e-02f,
  -4.45735566e-02f, -1.22301960e-02f, 1.39899671e-01f, -4.85983789e-02f, 9.82688293e-02f, 9.81075093e-02f, 2.74727419e-02f, -3.66635807e-02f, 5.70259392e-02f, 1.37586564e-01f,
  9.45326164e-02f, -6.31674798e-03f, 5.46320975e-02f, 9.99310911e-02f, 6.46990463e-02f, 1.05220906e-01f, -1.13142386e-01f, -8.28301534e-02f, 6.45501986e-02f, -6.05185516e-02f,
  -1.71634302e-01f, -6.44083694e-02f, 1.68982014e-01f, -2.39960547e-03f, 3.33942622e-02f, -8.81715026e-03f, -9.64346901e-02f, 1.50961548e-01f, -4.44700494e-02f, -1.68250740e-01f,
  1.98669732e-01f, 4.94470745e-02f, -6.94424286e-02f, -1.33765653e-01f, 1.52110774e-02f, -2.52956501e-03f, -6.09049632e-04f, 2.10666656e-02f, -4.78927307e-02f, -4.36572284e-02f,
  1.27298892e-01f, -1.20038345e-01f, -6.20986819e-02f, -1.80217028e-01f, 3.04987561e-02f, -1.53414477e-02f, -2.76318975e-02f, 1.69207841e-01f, 3.60226452e-01f, 2.02388078e-01f,
  1.45923281e-02f, -2.15895995e-01f, 1.71861872e-01f, 7.59456754e-02f, 1.09523092e-03f, -1.12243101e-01f, -2.36962527e-01f, -1.06117539e-01f, 5.24992645e-02f, -4.91181202e-02f,
  2.94422843e-02f, 5.59204258e-02f, 2.34390367e-02f, 9.48779508e-02f, -2.19318107e-01f, 5.61467279e-03f, -6.48048893e-02f, 1.73737556e-01f, 9.26414654e-02f, 9.77870822e-03f,
  1.19561076e-01f, -8.89140517e-02f, 1.82446107e-01f, -2.15140238e-01f, 2.35527501e-01f, 7.57890493e-02f, -7.46574476e-02f, -5.77737987e-02f, 9.06805471e-02f, 4.57935035e-02f,
  -8.05306286e-02f, -1.51610270e-01f, 5.25187589e-02f, -1.23292938e-01f, -1.37602121e-01f, 1.36502311e-01f, -4.93168868e-02f, -8.46570954e-02f, -5.02858423e-02f, 1.51275933e-01f,
  1.19240262e-01f, 3.51000577e-02f, -4.20756266e-02f, 2.28670225e-01f, -2.81896573e-02f, 2.35341713e-02f, 3.79020870e-02f, -4.63008285e-02f, 2.29133442e-02f, -5.91772459e-02f,
  7.35485777e-02f, 9.36284065e-02f, -2.74328023e-01f, 1.95230413e-02f, 2.31034812e-02f, 1.42321242e-02f, -1.67626530e-01f, -2.85350475e-02f, -1.82368264e-01f, -1.04393244e-01f,
  1.88418999e-01f, -5.30201867e-02f, -1.98821679e-01f, -9.90471691e-02f, 3.31737916e-03f, 1.79343987e-02f, 2.48606596e-02f, 9.14832577e-02f, 1.29259720e-01f, 2.61789590e-01f,
  -4.25102301e-02f, -1.08325616e-01f, 8.34461488e-03f, 4.72131930e-02f, 1.98647436e-02f, 2.37654194e-01f, -1.08994201e-01f, 3.56237926e-02f, 1.60068855e-01f, 1.09337009e-01f,
  -9.82110351e-02f, 1.07693724e-01f, 6.24913573e-02f, -4.97192629e-02f, -1.43145025e-01f, 4.86313105e-02f, -1.95033088e-01f, -3.17678638e-02f, 1.29925609e-01f, -4.77026701e-02f,
  4.70530577e-02f, 6.42297640e-02f, -4.61058086e-03f, -1.89150553e-02f, 8.99778828e-02f, -1.38997704e-01f, 1.65366083e-01f, 2.34164651e-02f, -8.35199580e-02f, -1.11648664e-01f,
  4.47551385e-02f, 1.50966585e-01f, 1.66024089e-01f, -1.54212683e-01f, -1.89227015e-02f, 1.17428444e-01f, -6.53981119e-02f, -1.55982777e-01f, 4.69262227e-02f, -3.46024260e-02f,
  -1.62898064e-01f, 4.76329736e-02f, -6.51076287e-02f, -2.42753685e-01f, -2.95028478e-01f, -4.66375872e-02f, -1.90755427e-01f, 7.53693804e-02f, 4.79588695e-02f, 1.86940402e-01f,
  -9.88368765e-02f, -2.25804359e-01f, 2.29578726e-02f, -2.68642724e-01f, -1.57343388e-01f, -7.44559616e-03f, -9.34307091e-03f, 9.70699862e-02f, 1.49054602e-01f, -1.24343008e-01f,
  2.37477478e-02f, 3.32282960e-01f, -2.11270958e-01f, 1.38736367e-01f, 1.34337872e-01f, -5.84940799e-02f, -4.93815392e-02f, -4.93100025e-02f, -5.88029921e-02f, -2.15810314e-01f,
  -7.31553286e-02f, -1.25439659e-01f, -1.46856278e-01f, -5.13099656e-02f, -1.04017608e-01f, 2.46371821e-01f, 8.96705221e-03f, -1.77098606e-02f, -1.21826001e-01f, 3.56501900e-02f,
  -1.38653204e-01f, -2.54453897e-01f, 9.54516008e-02f, -2.98985210e-03f, 8.56242422e-03f, 9.38310549e-02f, -1.48746178e-01f, 1.34237781e-01f, 1.81539431e-02f, -1.44035384e-01f,
  1.21619469e-02f, 4.49827015e-02f, 2.31083333e-01f, 2.54295558e-01f, 1.01651631e-01f, 3.25798825e-03f, -1.65945683e-02f, 1.84619203e-02f, 1.21634580e-01f, 1.06354333e-01f,
  4.88070287e-02f, 1.17753886e-01f, -2.39739507e-01f, -1.51315451e-01f, 3.92449349e-02f, 2.51192115e-02f, -1.17076978e-01f, -1.74003839e-01f, -1.02596864e-01f, -7.85219818e-02f,
  -2.13300735e-01f, 1.11656869e-02f, 1.04282625e-01f, 1.11853622e-01f, -1.80726629e-02f, 8.11125934e-02f, -3.81101929e-02f, -1.25502110e-01f, 4.47169393e-02f, -1.12262771e-01f,
  -6.80383248e-03f, -9.34407860e-02f, 3.73012155e-01f, 1.94226086e-01f, 4.18839939e-02f, 1.67975724e-01f, -1.92543939e-01f, -1.58417121e-01f, 2.19841942e-01f, 6.51646182e-02f,
  -1.11704230e-01f, -7.72760361e-02f, 6.50748163e-02f, 2.13322952e-01f, -1.49943024e-01f, 9.61765572e-02f, 1.83767408e-01f, -2.12871403e-01f, -2.70962610e-05f, -2.32440773e-02f,
  -4.32362929e-02f, 8.37199539e-02f, -1.44091845e-01f, 9.37620774e-02f, -2.85761148e-01f, -1.45080268e-01f, 9.97671932e-02f, 5.94218299e-02f, -7.50309378e-02f, 4.55865562e-02f,
  5.75097501e-02f, -6.39454573e-02f, 3.03601921e-02f, -5.25408611e-02f, -5.98596670e-02f, -9.64650437e-02f, -1.33137539e-01f, 2.06302419e-01f, -9.89557654e-02f, 7.49929324e-02f,
  1.32390216e-01f, -1.13418490e-01f, -3.23143490e-02f, 1.58561617e-01f, 6.29923195e-02f, -1.45896241e-01f, -5.77272587e-02f, -3.92143130e-02f, 6.34480566e-02f, -3.54695655e-02f,
  1.35191336e-01f, 1.40098020e-01f, -9.74235386e-02f, 2.29235992e-01f, 2.20951766e-01f, 1.40605435e-01f, -9.74114314e-02f, 1.52703933e-02f, 9.65685993e-02f, 1.47180676e-01f,
  8.42126682e-02f, 2.32167065e-01f, 7.60018080e-02f, -2.24468019e-02f, -2.47095346e-01f, -1.37837246e-01f, -1.51113376e-01f, -1.20617524e-01f, -2.87249863e-01f, 9.90335345e-02f,
  -1.31477006e-02f, 3.09173912e-01f, 1.58897236e-01f, -3.08639891e-02f, 5.75302960e-03f, -5.75594604e-02f, 1.05621718e-01f, -1.61744773e-01f, -1.51166752e-01f, -7.36819729e-02f,
  -6.89817518e-02f, 2.60629561e-02f, 5.75868636e-02f, 2.19930280e-02f, 6.75239861e-02f, 7.76657835e-02f, 2.08418369e-02f, 7.06903711e-02f, 1.86302364e-01f, 3.42009634e-01f,
  -2.90790975e-01f, -1.01624653e-02f, -5.32678291e-02f, 2.66932510e-02f, 1.93144511e-02f, -5.84951863e-02f, 6.81229588e-03f, 1.25478357e-01f, -1.39024809e-01f, 1.15920082e-01f,
  1.65024742e-01f, -9.98342857e-02f, 1.01884045e-01f, 1.11450590e-01f, -7.39887506e-02f, 1.45195082e-01f, 4.24351357e-02f, -1.10054433e-01f, 6.02863543e-02f, -4.61216737e-03f,
  9.43236146e-03f, -1.11298889e-01f, 1.30977511e-01f, 9.33293626e-02f, -1.03196641e-02f, 2.14994699e-01f, 9.11016315e-02f, -8.00343603e-02f, 1.96213666e-02f, 8.08805972e-02f,
  -8.48483667e-03f, -1.48596451e-01f, -1.72421530e-01f, 1.64754048e-01f, -2.80910820e-01f, 3.06438476e-01f, 1.88526824e-01f, 4.08341214e-02f, -9.10936967e-02f, 1.52513102e-01f,
  -6.62711412e-02f, 1.78984463e-01f, -9.98903885e-02f, -2.49593243e-01f, 2.43286546e-02f, -6.13283599e-03f, -1.36617079e-01f, -2.04301551e-01f, 9.78379771e-02f, 6.32201508e-02f,
  -5.07644862e-02f, 4.27706800e-02f, 1.02711447e-01f, 4.93061431e-02f, -6.08384907e-02f, 1.61439419e-01f, 1.00775965e-01f, -1.61038503e-01f, 8.95582438e-02f, 2.38859933e-02f,
  -7.20010400e-02f, 2.25402042e-03f, 1.34693772e-01f, 1.92082897e-01f, 2.02580672e-02f, -4.21263911e-02f, 1.25538096e-01f, -3.08806393e-02f, -3.37080471e-02f, 1.72518063e-02f,
  -3.50961611e-02f, -8.69419251e-04f, -8.75732675e-02f, 9.32276398e-02f, 7.52854161e-03f, -1.10074386e-01f, 1.84271544e-01f, -2.24173442e-02f, -1.04722098e-01f, -2.93810591e-02f,
  -6.59019500e-02f, -4.90689129e-02f, 1.40723940e-02f, -8.12021792e-02f, 1.36068687e-01f, 9.41325165e-03f, 1.08402252e-01f, -1.27280457e-02f, 2.33433377e-02f, 1.14150271e-01f,
  1.83084950e-01f, 2.22816437e-01f, 1.15354374e-01f, 1.34146214e-01f, -4.45314460e-02f, -1.09877370e-01f, 9.88161340e-02f, 2.14599207e-01f, 3.41170467e-02f, 1.10481478e-01f,
  -1.12935685e-01f, -1.04148112e-01f, -1.55580238e-01f, -2.11001903e-01f, -2.09398314e-01f, 2.01645792e-02f, -2.42617056e-01f, 6.05370775e-02f, -4.85055633e-02f, 5.98547682e-02f,
  1.41738310e-01f, 1.19761825e-01f, 1.53986797e-01f, 8.42686146e-02f, -8.64538997e-02f, -1.51618253e-02f, -2.86085438e-02f, 1.66741870e-02f, -5.07673435e-02f, 1.77518696e-01f,
  -7.34658958e-03f, -3.30729634e-02f, -5.57961874e-02f, -8.74147043e-02f, -3.57590839e-02f, 1.16689399e-01f, 1.09182246e-01f, 2.04249188e-01f, -1.92867145e-01f, 4.84717563e-02f,
  1.11142352e-01f, -1.10732786e-01f, -7.60709792e-02f, 3.22146751e-02f, -7.81623125e-02f, 2.52178335e-03f, -1.32041037e-01f, 3.88440043e-02f, 3.12789716e-02f, -1.19631305e-01f,
  -8.24398845e-02f, 2.47547999e-02f, -3.28340270e-02f, 8.24578777e-02f, 3.09904572e-02f, -1.85109183e-01f, -4.03901078e-02f, 8.31013825e-03f, 1.25494659e-01f, -1.80560984e-02f,
  3.87385972e-02f, 1.69249818e-01f, -1.27846956e-01f, 1.33080781e-01f, 1.01735957e-01f, 1.12442821e-01f, -4.71960865e-02f, -3.67605053e-02f, 7.93354213e-02f, -8.55395272e-02f,
  -5.98822981e-02f, -9.72248986e-02f, -2.22871110e-01f, 1.85129374e-01f, 1.24670118e-01f, -1.60517953e-02f, -6.77408185e-03f, -3.55547778e-02f, 6.49132133e-02f, 7.50286281e-02f,
  1.59071386e-01f, -3.42337459e-01f, 7.93173686e-02f, -1.81350008e-01f, -1.63653553e-01f, -4.86712418e-02f, -6.49269372e-02f, -1.02620445e-01f, 7.09463134e-02f, 2.45587587e-01f,
  -1.13662174e-02f, 3.83185707e-02f, 2.06060290e-01f, -1.38280317e-02f, -1.04191579e-01f, -2.30004042e-02f, -4.60313261e-02f, 8.36443678e-02f, 8.38650912e-02f, -5.30810133e-02f,
  8.26240554e-02f, 8.77941474e-02f, 2.30887234e-01f, -6.50684834e-02f, -3.73015888e-02f, 8.51852670e-02f, -1.28874093e-01f, -2.28246655e-02f, -1.61365699e-02f, 2.31130701e-02f,
  -1.02575347e-02f, -1.36143476e-01f, -3.12668532e-01f, -1.73269421e-01f, 1.58819973e-01f, -8.85497257e-02f, 1.53593287e-01f, 3.53881754e-02f, 7.05572590e-02f, 1.26484901e-01f,
  -6.28640205e-02f, 1.05442569e-01f, 1.43194973e-01f, -4.83363979e-02f, -8.01811665e-02f, 4.36579576e-03f, -2.63955723e-02f, 2.88189016e-02f, -1.72623932e-01f, -6.64960444e-02f,
  1.38379514e-01f, -1.20550238e-01f, -2.15220645e-01f, 1.07352905e-01f, -1.65967152e-01f, 4.90144128e-03f, -1.83766931e-01f, 5.73291327e-04f, 7.93649256e-02f, 1.09473497e-01f,
  -1.10676825e-01f, 6.67417943e-02f, -2.11876944e-01f, 2.71434277e-01f, -3.54046151e-02f, 2.37821750e-02f, 2.47247159e-01f, 1.60671890e-01f, 1.57307491e-01f, -1.92565426e-01f,
  -7.54353637e-03f, 1.25586698e-02f, -3.34163122e-02f, -1.01895645e-01f, 1.38658553e-01f, 1.04093384e-02f, 1.89593896e-01f, -9.87089723e-02f, -1.94332916e-02f, 8.26672316e-02f,
  -2.17766929e-02f, -1.22356124e-01f, 3.70396487e-02f, 3.52151506e-02f, 4.36740890e-02f, 1.12930201e-01f, 6.87018111e-02f, 3.11435908e-02f, 2.62453599e-04f, 1.95598267e-02f,
  -5.53107001e-02f, -3.34982947e-02f, 2.73956507e-02f, 5.65208532e-02f, -1.57924861e-01f, 4.36450541e-02f, -3.60218473e-02f, -3.69997770e-01f, 1.59641832e-01f, -9.02509093e-02f,
  -1.15723498e-01f, 1.03864186e-01f, 2.42770612e-02f, -1.15358315e-01f, 1.16399564e-02f, -2.26824105e-01f, 1.12400495e-01f, 1.95522476e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.10224515e-01f, -1.06823342e-02f, -1.39227668e-02f, 1.31842807e-01f, 5.81262745e-02f, -7.38419080e-03f, -3.38363759e-02f, -9.84580442e-02f, 4.93666567e-02f, 5.50815649e-02f,
  -3.36007550e-02f, -5.39759658e-02f, -1.26354340e-02f, -3.94024402e-02f, 1.00264698e-01f, 9.16030407e-02f, 1.53487995e-01f, 4.74663712e-02f, 6.74470589e-02f, 4.89292629e-02f,
  5.00031561e-02f, 4.73001152e-02f, 3.16961296e-02f, 5.46657406e-02f, 7.20975250e-02f, -1.38296261e-01f, 1.02920614e-01f, 1.11961335e-01f, -1.23768143e-01f, -1.59175336e-01f,
  1.87809654e-02f, 1.36400238e-01f, 1.72045201e-01f, 8.62941220e-02f, 8.79969001e-02f, 1.16690755e-01f, 9.01262090e-02f, 3.31681129e-03f, -4.26461846e-02f, -6.77645802e-02f,
  1.66131973e-01f, -6.52229274e-03f, 1.14882350e-01f, 1.40171736e-01f, 6.32971004e-02f, -2.83863321e-02f, -5.03703244e-02f, 2.45272070e-02f, 2.57633757e-02f, 8.65703672e-02f,
  5.71330339e-02f, 2.62936484e-02f, 1.18409142e-01f, 1.82043970e-01f, 1.03975251e-01f, -2.02045850e-02f, 9.54782888e-02f, 1.16616309e-01f, -2.22900547e-02f, 8.88006389e-02f,
  -2.80133169e-02f, 3.34488265e-02f, 1.32606514e-02f, -2.91106254e-02f, 7.60599077e-02f, 1.26938686e-01f, 1.41820803e-01f, 1.84553117e-02f, 1.89042151e-01f, 1.00950979e-01f,
  -5.66705549e-03f, 3.36336754e-02f, -4.01780307e-02f, -7.36474544e-02f, -7.50958696e-02f, 1.27326036e-02f, -9.11783725e-02f, -4.37686853e-02f, 6.28567412e-02f, -9.18516517e-02f,
  5.29321209e-02f, -1.20490812e-01f, -3.69638652e-02f, 6.31589368e-02f, 1.25345498e-04f, -1.60578012e-01f, -3.70281450e-02f, 2.33765040e-05f, 8.35606530e-02f, 2.46864110e-02f,
  4.60161492e-02f, 6.12095408e-02f, 9.43132639e-02f, 2.08063349e-01f, 9.70432013e-02f, -9.38428342e-02f, 7.84650166e-03f, -1.18931949e-01f, 8.67855176e-02f, -5.46685681e-02f,
  -4.43147086e-02f, -1.11919969e-01f, 8.47374871e-02f, -7.94251114e-02f, 9.66620669e-02f, -1.63000256e-01f, 2.74194330e-01f, 1.46908602e-02f, -8.20541605e-02f, 2.57114554e-03f,
  1.51518181e-01f, 1.10672697e-01f, 7.80727789e-02f, 5.11520207e-02f, -4.75270674e-02f, 7.20870718e-02f, -1.19459748e-01f, 8.77633765e-02f, 7.56002590e-02f, 2.75826678e-02f,
  -1.60026294e-03f, -4.78745587e-02f, -3.14493924e-02f, 4.90834378e-02f, 1.66352652e-02f, 1.02967648e-02f, -1.27795031e-02f, 2.39206217e-02f, 1.11094445e-01f, 1.70786470e-01f,
  8.22550058e-02f, -1.71760526e-02f, -1.70535594e-01f, -6.19315244e-02f, -1.69006288e-02f, 3.99885774e-02f, -3.17738801e-02f, 2.03159809e-01f, -1.78454816e-01f, -1.85274273e-01f,
  -1.63798288e-01f, -1.98406950e-01f, 4.06157933e-02f, 6.62829727e-02f, -1.03817530e-01f, 1.00953631e-01f, 9.32654738e-02f, 2.56138057e-01f, 8.62950534e-02f, 8.81283730e-02f,
  7.72744268e-02f, -9.68563929e-02f, -4.61974740e-02f, -2.18517799e-02f, -7.17127621e-02f, -3.64851207e-02f, 1.23557143e-01f, -4.85614538e-02f, 9.52734575e-02f, -1.04607798e-01f,
  2.98444569e-01f, 8.74752179e-02f, -1.47049716e-02f, 1.76597357e-01f, -8.29288065e-02f, 6.99771568e-03f, 1.07421607e-01f, -6.70387596e-02f, -1.17460594e-01f, -4.93722931e-02f,
  3.24515849e-01f, 5.85243069e-02f, 2.16874387e-02f, -1.70140509e-02f, -6.56036064e-02f, 9.74605307e-02f, 8.21139440e-02f, -5.27796820e-02f, -5.37213497e-02f, -8.19127262e-02f,
  9.99248847e-02f, -6.22197464e-02f, 1.09512523e-01f, 3.44209298e-02f, 2.06790175e-02f, -9.24808905e-02f, -1.25603840e-01f, -6.64402917e-02f, -1.40888214e-01f, -9.05182436e-02f,
  1.86022632e-02f, 4.82126959e-02f, 9.81157720e-02f, -2.58844309e-02f, 8.98955986e-02f, 3.13099921e-02f, 3.95669155e-02f, -8.53132457e-02f, 8.08608681e-02f, 4.59666066e-02f,
  1.63943231e-01f, -6.12467527e-02f, -1.10694416e-01f, 5.73298372e-02f, -1.03714526e-01f, 1.30449519e-01f, 7.17629716e-02f, -4.43887487e-02f, 1.88657746e-01f, 1.01753160e-01f,
  -1.36084422e-01f, -7.39891976e-02f, 3.97492126e-02f, -9.49322879e-02f, 6.71805162e-03f, -4.38407697e-02f, -1.41366631e-01f, 5.87338232e-04f, 1.55650765e-01f, -1.13938622e-01f,
  -1.01244505e-02f, 7.87052661e-02f, 1.21705838e-01f, 1.09348528e-01f, 6.36434108e-02f, 9.55565460e-03f, 9.39616710e-02f, 1.42033011e-01f, 1.20735198e-01f, 9.57216024e-02f,
  3.87065709e-02f, 3.62307578e-02f, 2.62197465e-01f, 2.52742022e-01f, -1.93260033e-02f, 3.85768935e-02f, -6.70301914e-02f, 1.31775185e-01f, 7.41696134e-02f, -2.78742723e-02f,
  -2.45145615e-03f, -8.46236348e-02f, -1.08074091e-01f, 4.20345850e-02f, -2.52224952e-02f, 1.26598135e-01f, -5.89065067e-02f, -1.28469706e-01f, 5.94135597e-02f, 9.36492905e-02f,
  1.26450047e-01f, -1.14249796e-01f, 9.23401560e-04f, -5.61140515e-02f, -9.25200880e-02f, 6.10021576e-02f, -3.93598825e-02f, 4.77696136e-02f, -9.59717333e-02f, -1.04471214e-01f,
  8.51994082e-02f, -5.83635643e-02f, 1.51583597e-01f, 1.08313143e-01f, 7.31143355e-02f, -9.06147435e-02f, 1.12142518e-01f, 4.95780446e-02f, -3.47792022e-02f, 6.67369291e-02f,
  -3.80572639e-02f, -3.12069207e-02f, -1.04160383e-01f, -1.20500997e-01f, -7.16389492e-02f, 3.37363034e-02f, 2.04973444e-02f, -4.71578166e-02f, 1.69978216e-02f, -4.21714187e-02f,
  1.45182282e-01f, 7.09458366e-02f, 4.86349650e-02f, -2.76130978e-02f, 1.48464099e-01f, -4.60875668e-02f, 1.79217905e-02f, -1.18775427e-01f, 7.63577744e-02f, -7.66999200e-02f,
  1.81323998e-02f, 1.05161391e-01f, 3.02542895e-02f, 7.94563293e-02f, -4.58777472e-02f, 1.12316810e-01f, -6.28837198e-03f, 1.30569120e-03f, -2.06592046e-02f, 5.23585342e-02f,
  -8.75220671e-02f, 8.73027742e-03f, -1.18951879e-01f, 1.11952603e-01f, -9.78507027e-02f, 1.16306596e-01f, 3.34997661e-02f, 3.21759656e-02f, 4.40510660e-02f, 2.87231691e-02f,
  -5.12487479e-02f, 7.47094676e-02f, 4.72927317e-02f, -1.33987010e-01f, -4.99882177e-02f, -4.04228605e-02f, 2.41572000e-02f, -4.30508852e-02f, -7.67048448e-02f, -1.09447636e-01f,
  9.07961950e-02f, -7.90731283e-04f, -1.21636949e-02f, -4.65780422e-02f, 3.35399024e-02f, -3.90729830e-02f, 1.21466480e-02f, 1.40437484e-01f, -1.55180708e-01f, 1.73448339e-01f,
  -3.90472561e-02f, -1.21668324e-01f, 6.96824044e-02f, 7.91321024e-02f, -3.49038914e-02f, 3.95048000e-02f, -1.48688003e-01f, 8.97611380e-02f, 1.51280751e-02f, -7.69582912e-02f,
  -3.10387034e-02f, 8.01918507e-02f, 7.71612972e-02f, 7.37751499e-02f, -2.78786141e-02f, 8.25104341e-02f, -1.02293655e-01f, 4.79204161e-03f, -4.84239571e-02f, -8.29742923e-02f,
  4.53487262e-02f, -1.64943282e-02f, 1.07950896e-01f, -7.61768743e-02f, -8.87049437e-02f, -3.94032598e-02f, 2.42197402e-02f, -7.46082589e-02f, 7.35483468e-02f, 5.37047014e-02f,
  6.25351071e-02f, 1.43552825e-01f, 9.73015800e-02f, -7.29532987e-02f, 1.16634339e-01f, -5.20593338e-02f, 8.48351046e-03f, -2.72834976e-03f, 1.06527336e-01f, -1.02918096e-01f,
  -9.86545309e-02f, 1.27825096e-01f, 1.74227372e-01f, -7.61700943e-02f, -5.34412824e-02f, -7.91349038e-02f, -1.40502807e-02f, -8.02645385e-02f, 7.47347102e-02f, 7.86838979e-02f,
  8.09667632e-02f, -1.07670724e-01f, 1.44011229e-01f, -1.34998206e-02f, 1.74401045e-01f, 1.20438866e-01f, 2.62752503e-01f, -1.66889932e-02f, -3.48530561e-02f, 1.00133218e-01f,
  7.47757033e-02f, 3.73211093e-02f, 1.64945368e-02f, 9.33032706e-02f, 7.78543353e-02f, -6.18512258e-02f, 2.46166997e-02f, 3.71464014e-01f, 1.50417536e-01f, -8.87924582e-02f,
  -5.14441244e-02f, -4.34401631e-02f, -2.49222741e-01f, -1.79354087e-01f, -1.65515751e-01f, -1.20198512e-02f, 2.10907698e-01f, 3.35954696e-01f, 7.34727830e-02f, 1.92046668e-02f,
  2.24690251e-02f, -1.20709278e-01f, -8.32627267e-02f, -1.35691553e-01f, -1.88494876e-01f, 7.35855103e-02f, 2.03925386e-01f, 3.71925712e-01f, -1.00893043e-01f, -1.34762451e-01f,
  2.55713224e-01f, -6.08230270e-02f, 6.01328956e-03f, -8.25189501e-02f, 1.99296281e-01f, 6.27172351e-01f, -6.86804950e-02f, 1.67554747e-02f, -5.01213856e-02f, -2.39041336e-02f,
  -1.47285655e-01f, 3.50230299e-02f, -6.24885224e-02f, 2.26159036e-01f, -1.48104563e-01f, -5.24444245e-02f, -2.20524356e-01f, -1.66395739e-01f, 3.17717269e-02f, 6.01151511e-02f,
  1.15626954e-01f, 1.12843640e-01f, -1.41344309e-01f, -3.44835259e-02f, 2.37979880e-03f, 3.05501670e-01f, 4.13335636e-02f, 1.38571179e-02f, -3.72839607e-02f, 4.37663794e-02f,
  2.21804958e-02f, -9.41146910e-02f, -6.23519234e-02f, 1.72047168e-01f, 9.60290954e-02f, 8.92166421e-02f, 8.73367190e-02f, 2.32747011e-02f, 5.20553216e-02f, 8.03182051e-02f,
  -8.80964566e-03f, 1.11850314e-01f, -1.54425904e-01f, -7.39037171e-02f, -6.09250478e-02f, -1.21068582e-01f, 8.91261473e-02f, 7.28423223e-02f, -2.12095737e-01f, -7.78048933e-02f,
  -6.10829815e-02f, 1.24078169e-01f, 4.59519215e-03f, -1.99732576e-02f, 9.63818952e-02f, 5.94233088e-02f, 9.99862477e-02f, -6.61768541e-02f, -1.17244609e-01f, 3.96526717e-02f,
  -1.37294584e-03f, -3.35607454e-02f, 7.10380748e-02f, 9.38513726e-02f, -5.48954457e-02f, -1.23001769e-01f, 1.04234867e-01f, 8.41326118e-02f, -1.13344587e-01f, 1.33212209e-01f,
  -2.79657114e-02f, -2.92532351e-02f, -3.31961699e-02f, -9.98812094e-02f, -9.71370786e-02f, 5.05678169e-02f, -3.83545049e-02f, -6.30830377e-02f, 5.29752858e-02f, 5.31404838e-02f,
  2.36655042e-01f, 2.02254467e-02f, -1.03799649e-01f, 8.79968777e-02f, -1.19827911e-01f, -1.16844624e-01f, 1.17852591e-01f, -1.34569928e-01f, -5.96000105e-02f, 6.80970401e-02f,
  1.36279255e-01f, 1.51311355e-02f, 4.46006395e-02f, 1.48297012e-01f, 7.12542906e-02f, 2.19272569e-01f, 1.10667929e-01f, 8.38114098e-02f, 2.47673586e-01f, 1.13800474e-01f,
  1.96449339e-01f, -1.25205323e-01f, -2.08069906e-02f, 1.53225586e-01f, -2.60408968e-01f, 2.44902782e-02f, 9.59819406e-02f, 1.37756392e-01f, 2.81506628e-01f, 1.24527857e-01f,
  -1.58869103e-02f, 5.80350868e-02f, 2.14594409e-01f, -1.85516328e-01f, 2.06450000e-01f, -2.23809421e-01f, -4.84047793e-02f, -1.19909883e-01f, 3.12387329e-02f, -2.94488575e-02f,
  -4.71201129e-02f, 1.86321959e-01f, 4.14573476e-02f, 5.35342060e-02f, 1.06304064e-01f, -8.04693401e-02f, 1.16197005e-01f, 8.78829360e-02f, -6.30523171e-03f, 4.11311537e-02f,
  -6.22274578e-02f, -1.11212686e-01f, 1.95347697e-01f, 1.53974682e-01f, 3.85204911e-01f, 1.16416872e-01f, -1.94801707e-02f, 6.70746192e-02f, 1.12883568e-01f, -1.05308600e-01f,
  -4.05154042e-02f, 3.47704962e-02f, -1.40980050e-01f, -4.60112840e-02f, -2.15171546e-01f, -1.66397884e-01f, 1.60092786e-01f, -3.66032198e-02f, -1.20252771e-02f, -1.38653904e-01f,
  7.44284466e-02f, 7.19579519e-04f, -3.64903100e-02f, -1.02135167e-01f, 2.80552786e-02f, 9.65445861e-02f, 1.64338276e-02f, -1.01538179e-02f, 5.66043742e-02f, -1.14243373e-01f,
  9.87487957e-02f, 1.40336245e-01f, -6.12116158e-02f, -4.80889296e-03f, -2.98072211e-02f, -1.68935314e-01f, 3.90181243e-02f, -1.33336812e-01f, -5.56390435e-02f, -1.47649571e-01f,
  -1.02809556e-01f, -3.20163853e-02f, 3.38564813e-02f, 7.56846890e-02f, 7.99700171e-02f, -8.37740600e-02f, -7.64091150e-04f, 1.03741147e-01f, 7.00570038e-03f, 7.06317872e-02f,
  -7.73936287e-02f, 1.18672602e-01f, 2.40214281e-02f, 1.02886390e-02f, 1.31440014e-01f, 6.66144267e-02f, 5.88706881e-02f, 1.30194142e-01f, -2.15240091e-01f, 3.43901925e-02f,
  -1.29219189e-01f, 1.07696712e-01f, 1.68065935e-01f, 7.23716393e-02f, 1.12628788e-02f, -1.14435732e-01f, 8.33208561e-02f, -2.25207940e-01f, 1.96460381e-01f, 1.26444966e-01f,
  7.55715882e-03f, -6.20657802e-02f, 2.04207480e-01f, 1.03416510e-01f, -1.05836265e-01f, 3.26483548e-02f, 1.64681509e-01f, 1.50148757e-02f, -1.65455326e-01f, 2.90879309e-01f,
  -1.06453486e-01f, 1.28262728e-01f, 2.64691077e-02f, 4.68316004e-02f, -5.60052395e-02f, 1.29619718e-01f, 7.86068514e-02f, 2.23072827e-01f, 3.67424451e-02f, 7.66877905e-02f,
  6.70952648e-02f, 4.13164636e-03f, -5.19273505e-02f, 1.07971586e-01f, 2.04601474e-02f, 1.66093543e-01f, -1.08282536e-01f, 8.06183517e-02f, 5.86658381e-02f, -1.15179475e-02f,
  5.33578694e-02f, -1.32538244e-01f, 1.19670704e-01f, 1.33436769e-01f, 5.06174602e-02f, -1.19392268e-01f, -1.54970258e-01f, -4.37935814e-02f, -1.79131553e-01f, -1.13800950e-01f,
  -3.51618268e-02f, -2.85824537e-02f, 4.03739475e-02f, 1.95091844e-01f, 8.76343623e-02f, -1.13208741e-01f, 1.48013175e-01f, 1.19199969e-01f, 3.26263160e-02f, 1.14223622e-01f,
  -7.49511737e-03f, 7.97451660e-02f, 1.17422774e-01f, 1.99919567e-01f, 9.47347805e-02f, -1.09299431e-02f, 2.92102695e-02f, -2.23443210e-02f, -1.01133034e-01f, -3.60146817e-03f,
  2.04895571e-01f, 2.50885636e-01f, -9.90609527e-02f, 1.08610660e-01f, -1.27317281e-02f, -2.04903726e-02f, -1.08607247e-01f, -3.61676477e-02f, -2.69368906e-02f, 4.59980108e-02f,
  3.97488102e-02f, 5.51166423e-02f, 4.12932821e-02f, 5.22892289e-02f, -1.80735998e-03f, 6.77077053e-03f, 2.14549005e-02f, 5.06086238e-02f, 4.09002826e-02f, -1.45313740e-02f,
  6.08835146e-02f, 2.11738776e-02f, 1.12000937e-02f, 6.77678809e-02f, -6.83571845e-02f, 1.02626160e-01f, -4.52362858e-02f, -5.72586283e-02f, 1.01356559e-01f, -5.96772097e-02f,
  -6.49790764e-02f, 9.81649682e-02f, 5.18610552e-02f, -5.47187366e-02f, 4.09763679e-02f, -4.33066078e-02f, 1.01483963e-01f, 1.09857433e-01f, -4.49515693e-02f, -2.53538671e-03f,
  2.98428051e-02f, -2.49775611e-02f, 6.00508936e-02f, -9.57505405e-02f, -1.17191829e-01f, 4.89899404e-02f, 1.03114033e-02f, 5.20683713e-02f, 1.32247433e-01f, 1.47842355e-02f,
  5.26411980e-02f, -1.30635977e-01f, 4.44825785e-03f, 3.77095141e-03f, -5.84815536e-03f, -8.93539414e-02f, -6.84093833e-02f, -6.15806133e-02f, -4.19722237e-02f, 6.69282442e-03f,
  -5.86741343e-02f, -7.07769245e-02f, -9.18212757e-02f, -7.62750432e-02f, 2.89839264e-02f, -8.62266272e-02f, 6.75402060e-02f, -5.83647415e-02f, -2.93756966e-02f, -1.24434412e-01f,
  -1.44125491e-01f, -2.44839955e-02f, 1.47891939e-02f, 9.49415043e-02f, -1.39621615e-01f, -8.34167674e-02f, -3.36258672e-02f, -9.58043635e-02f, -2.68122274e-02f, -4.77574691e-02f,
  8.30335990e-02f, 1.58060677e-02f, -9.62230563e-02f, 9.91526842e-02f, 7.59027302e-02f, -1.25544444e-01f, 8.71658772e-02f, 3.50588523e-02f, 1.82640463e-01f, -6.35239929e-02f,
  -1.14756748e-02f, 1.79950103e-01f, 9.83606651e-02f, -7.57774338e-04f, 2.01695319e-02f, 1.07130073e-01f, 2.45369803e-02f, -7.11843595e-02f, -3.53611000e-02f, 1.44751132e-01f,
  3.33612412e-03f, 2.02683881e-02f, -9.77751911e-02f, 9.11042392e-02f, 2.67857593e-03f, 4.35666554e-02f, -2.75822375e-02f, 5.12505919e-02f, -9.02722031e-02f, -8.86077508e-02f,
  1.09312013e-01f, 3.04349419e-02f, -1.67517290e-02f, 1.21765137e-01f, -2.17778794e-02f, -7.47857708e-03f, -3.92458122e-03f, 2.03124404e-01f, 1.00924358e-01f, 3.55274975e-02f,
  -3.39497207e-03f, 1.07837185e-01f, 1.06219627e-01f, -1.16777785e-01f, 7.50754029e-03f, 1.12115569e-01f, 4.76627424e-02f, -4.65877093e-02f, 2.24199779e-02f, 1.06657162e-01f,
  -6.58122217e-03f, -8.55441689e-02f, -9.58866253e-02f, 1.21688686e-01f, -4.18935977e-02f, -1.36022449e-01f, -9.67589170e-02f, -7.50743672e-02f, -1.51598519e-02f, 8.29250440e-02f,
  -1.41606823e-01f, 3.66777070e-02f, -4.90437225e-02f, 7.25533664e-02f, -9.08217728e-02f, -5.40879853e-02f, -1.32580966e-01f, 9.99578238e-02f, -1.01697221e-02f, 7.54174367e-02f,
  1.55224353e-01f, 1.43398017e-01f, 5.23990840e-02f, 1.85449362e-01f, 1.26451463e-01f, -3.16428542e-02f, 9.83343273e-02f, 1.15241267e-01f, 2.61454821e-01f, -4.49174829e-02f,
  -1.87710449e-02f, -1.81396917e-01f, -4.10819873e-02f, 1.12512283e-01f, 4.30955291e-02f, 7.91114271e-02f, 4.60639223e-02f, 4.24722657e-02f, 1.01453871e-01f, -8.10389519e-02f,
  -3.29713058e-03f, 3.11723258e-03f, 3.16699930e-02f, -1.01656578e-01f, 5.90781942e-02f, -1.21579587e-01f, 3.72621752e-02f, 6.08861111e-02f, -2.39550807e-02f, 1.32782593e-01f,
  1.89346090e-01f, 1.88932955e-01f, 1.82801336e-01f, 3.13448645e-02f, -9.60441828e-02f, -5.38889877e-02f, -1.14472836e-01f, -7.73239881e-02f, 1.22778654e-01f, 9.00985822e-02f,
  -1.76755257e-03f, -1.19583897e-01f, 1.29980952e-01f, -9.21908915e-02f, 1.53759509e-01f, -4.23568189e-02f, 3.82760651e-02f, -1.02277167e-01f, 1.38508424e-01f, -5.70274750e-03f,
  1.00585237e-01f, 1.32559925e-01f, -7.18629435e-02f, -4.10637036e-02f, -8.01975206e-02f, -8.30252841e-02f, -8.19523260e-02f, 1.34240702e-01f, 6.46724328e-02f, -8.66647363e-02f,
  2.66351048e-02f, -1.95409935e-02f, -9.76315215e-02f, 3.49166617e-02f, -5.55925816e-02f, 1.96143389e-01f, -7.29471669e-02f, 7.89343640e-02f, 4.66679409e-02f, 1.50252075e-03f,
  4.21179347e-02f, 5.89461699e-02f, 1.57652736e-01f, 9.15436968e-02f, -6.43276200e-02f, 1.59957305e-01f, -5.06711043e-02f, -8.63780528e-02f, 8.07752162e-02f, 8.54772851e-02f,
  -8.32825974e-02f, -9.55877602e-02f, -1.62944555e-01f, -1.04982518e-01f, 8.59279127e-04f, 6.04465865e-02f, -3.11989412e-02f, 1.18619159e-01f, -1.57471552e-01f, 1.94234148e-01f,
  9.00967866e-02f, 9.32355449e-02f, 5.27853407e-02f, -1.01235382e-01f, 1.78795204e-01f, -8.25977027e-02f, 7.61878714e-02f, -3.80686251e-03f, 6.95747584e-02f, 1.28373876e-01f,
  -4.33239378e-02f, 1.84427090e-02f, -5.83909936e-02f, -7.80946910e-02f, -6.52962700e-02f, 1.08957849e-02f, 3.61473635e-02f, 1.29092410e-01f, -2.05315396e-01f, -1.79138165e-02f,
  -7.44255483e-02f, -7.57575706e-02f, -4.83211987e-02f, -1.12069182e-01f, -1.96599029e-02f, 7.08130747e-02f, 5.83326891e-02f, 6.63589463e-02f, -6.88235760e-02f, 8.45628679e-02f,
  -1.08497009e-01f, -4.82769087e-02f, -2.90010571e-02f, 1.35069206e-01f, 9.23893452e-02f, 9.73666925e-03f, 8.56796745e-03f, 1.68133192e-02f, -2.41028573e-02f, 6.44054785e-02f,
  2.29158610e-01f, 2.28635684e-01f, 7.22365826e-02f, 2.54581541e-01f, 2.70750493e-01f, 1.28431380e-01f, 3.93230706e-01f, 1.26533164e-02f, 2.14534357e-01f, 7.67891556e-02f,
  9.46897566e-02f, 4.33188170e-01f, -3.02990675e-01f, 2.49409512e-01f, 1.20383818e-02f, -1.98174641e-02f, -1.82514608e-01f, 2.70719469e-01f, 1.74874574e-01f, 2.97305882e-01f,
  4.80190702e-02f, -3.16855222e-01f, 2.14423269e-01f, -3.34169239e-01f, 7.59108141e-02f, -1.65759549e-01f, 6.40264824e-02f, 1.83524862e-02f, 1.03235394e-01f, 1.86429605e-01f,
  2.61791348e-02f, 6.86659813e-02f, 4.03480560e-01f, -4.94760610e-02f, 9.66037884e-02f, -1.14913605e-01f, 6.06828369e-02f, -9.21654478e-02f, -9.31700692e-02f, 9.25299078e-02f,
  2.25606456e-01f, 3.59609902e-01f, 5.28218504e-03f, -1.15712985e-01f, 9.21189040e-02f, -1.25525832e-01f, -3.34278084e-02f, 1.02843873e-01f, -2.41356138e-02f, 1.74359456e-01f,
  -1.20995589e-01f, 1.48791149e-01f, 8.52130875e-02f, -3.09552550e-01f, 2.19033044e-02f, 1.40365228e-01f, -1.38148293e-01f, -1.70572177e-01f, -1.38845623e-01f, -1.93564996e-01f,
  -5.53295203e-02f, -2.70420253e-01f, 3.95558387e-01f, 1.61392942e-01f, 1.97224766e-02f, 1.33889452e-01f, 3.32061052e-02f, 1.26904830e-01f, 9.28998962e-02f, -4.46584867e-03f,
  1.02518775e-01f, 3.69551927e-02f, -8.29759240e-02f, 7.52682984e-02f, -7.18226805e-02f, 1.27117950e-02f, -1.53178215e-01f, -3.37650254e-02f, 1.99799538e-01f, 1.05210342e-01f,
  6.80348426e-02f, -3.19478922e-02f, 7.33527839e-02f, 5.49002085e-03f, 1.90828934e-01f, -1.34021863e-01f, 2.31454417e-01f, -1.09538324e-01f, -3.70841622e-02f, 1.72733068e-01f,
  -1.12492494e-01f, 9.60175972e-03f, 1.35564238e-01f, 1.22196518e-01f, 2.95687944e-01f, 9.47488099e-02f, -7.98927471e-02f, -1.33155927e-01f, -1.10944189e-01f, 2.90992465e-02f,
  -1.24643147e-01f, 1.28250588e-02f, 1.65712044e-01f, -1.10272735e-01f, 1.37755454e-01f, -8.27728137e-02f, 4.31081593e-01f, 9.78489965e-02f, 1.86598435e-01f, 1.20383292e-01f,
  2.24196929e-02f, 8.26726556e-02f, -1.03505738e-01f, 4.60392646e-02f, 5.48704937e-02f, 1.57010667e-02f, 3.95040996e-02f, -5.05535398e-03f, 1.01532280e-01f, -5.46736754e-02f,
  -2.00055577e-02f, 6.54938892e-02f, 4.46980186e-02f, 1.32557973e-01f, 2.12449823e-02f, 1.47028622e-04f, 4.27989364e-02f, 2.21731424e-01f, 1.15483567e-01f, -2.25071739e-02f,
  -3.33545953e-02f, 2.50176881e-02f, -9.33694094e-02f, 2.93899197e-02f, -2.24706903e-02f, -6.14792167e-04f, -3.89512442e-02f, 1.06899962e-01f, 6.74092844e-02f, 2.33656112e-02f,
  1.16992407e-01f, -5.91488034e-02f, 8.28389227e-02f, -1.09179154e-01f, 1.98181048e-01f, -9.42647830e-03f, 8.21216330e-02f, 7.56825134e-03f, 2.43164636e-02f, 2.24271864e-02f,
  5.94310835e-02f, -1.90119818e-01f, -1.09351993e-01f, 3.01105604e-02f, -1.03491850e-01f, -6.26574829e-02f, -4.63669747e-03f, 1.36782899e-01f, 3.48434374e-02f, 2.78360769e-02f,
  2.92555206e-02f, 7.19827339e-02f, 7.31787384e-02f, 8.93754661e-02f, -6.74358606e-02f, -7.23696351e-02f, 9.30234864e-02f, 2.09390167e-02f, -1.72616187e-02f, -8.33576918e-02f,
  5.64812869e-02f, -1.04689620e-01f, -2.14411714e-03f, 1.06514081e-01f, 4.14031893e-02f, -2.87136510e-02f, -1.23172641e-01f, -1.71442077e-01f, 1.26347411e-02f, 2.37645078e-02f,
  3.96940261e-02f, 7.69014359e-02f, 7.49616176e-02f, -6.67545423e-02f, -4.88643833e-02f, 5.09346761e-02f, -1.11622833e-01f, 1.17840730e-01f, -7.08682090e-02f, -5.86697757e-02f,
  1.79074500e-02f, -7.04033226e-02f, 1.38977975e-01f, -9.33387876e-02f, 7.61702657e-02f, 4.71456014e-02f, -9.20206234e-02f, 8.59047007e-03f, -1.91561738e-03f, -6.55347994e-03f,
  -1.29126936e-01f, -4.59517539e-02f, 1.00879237e-01f, 7.79510364e-02f, 1.50027931e-01f, 8.00563768e-02f, 2.21550371e-02f, -4.37414795e-02f, -2.04013940e-02f, -1.00825638e-01f,
  8.38174149e-02f, 1.75362844e-02f, -1.63072169e-01f, 8.63899365e-02f, -9.15778652e-02f, 1.48095563e-01f, -5.45990616e-02f, 1.01791337e-01f, 1.46677578e-02f, -3.65500152e-02f,
  -2.92766709e-02f, -7.15971962e-02f, 1.02713769e-02f, -5.63442800e-03f, -7.02021969e-03f, 5.84587641e-02f, 6.84429109e-02f, -4.45973538e-02f, 1.49632357e-02f, 1.19189836e-01f,
  8.16439986e-02f, 6.62153289e-02f, 1.64239109e-01f, 1.28537640e-01f, 2.78740767e-02f, 1.61842592e-02f, -3.13965827e-02f, -6.32810071e-02f, 1.05860315e-01f, 1.30049467e-01f,
  1.06104553e-01f, -8.49282518e-02f, 6.46113371e-03f, 5.39608439e-03f, 1.49481282e-01f, -6.44694865e-02f, 5.02347574e-02f, 4.51201797e-02f, 9.03789233e-03f, -9.66970325e-02f,
  3.41411643e-02f, 3.41083370e-02f, 8.90072063e-02f, -4.91344668e-02f, 9.39285606e-02f, 1.04167849e-01f, 1.32022262e-01f, 1.89657643e-01f, 9.02239233e-02f, -1.50935575e-01f,
  6.30449280e-02f, -2.89159287e-02f, -6.60987198e-02f, 5.44697680e-02f, -3.66451102e-03f, -4.98120068e-03f, 1.19866870e-01f, -7.58837387e-02f, 4.36762720e-02f, -3.15009728e-02f,
  -8.20180848e-02f, -8.63862187e-02f, -1.98707670e-01f, -1.50239989e-01f, 9.26330537e-02f, -8.39833915e-03f, 6.57588616e-02f, 2.72716656e-02f, 8.60301964e-03f, 8.18127170e-02f,
  2.18143076e-01f, -2.92448476e-02f, -1.23213097e-01f, 4.30742204e-02f, 1.02676719e-01f, 1.72247246e-01f, -1.20431539e-02f, -5.01648597e-02f, 2.41262257e-01f, -1.18207626e-01f,
  1.04520850e-01f, 5.64734160e-04f, -2.22278107e-02f, 7.07763620e-03f, 3.86904217e-02f, -2.72293054e-02f, -2.17722610e-01f, 6.21590903e-03f, 8.75941366e-02f, 6.56563491e-02f,
  -1.60177082e-01f, 2.08312785e-03f, -9.32506174e-02f, -8.64295568e-03f, -5.55640794e-02f, 1.14509366e-01f, 3.75354439e-02f, -1.43766934e-02f, -3.55561287e-03f, 9.05254558e-02f,
  1.30658343e-01f, -6.45503402e-02f, 9.88959521e-02f, 4.05764440e-03f, -6.07539862e-02f, 1.16260685e-02f, 1.31691936e-02f, 1.26404986e-01f, -3.94520126e-02f, -4.78982367e-02f,
  1.06363833e-01f, -7.60475546e-03f, 2.26845428e-01f, 2.29520038e-01f, 1.63122967e-01f, 9.73233115e-03f, 3.82299840e-01f, 1.57868817e-01f, 1.23135902e-01f, -2.24854827e-01f,
  3.71057428e-02f, 2.80934572e-01f, 1.84164688e-01f, -3.92964892e-02f, -1.70043647e-01f, -3.38086225e-02f, 3.11429858e-01f, 2.33431295e-01f, 1.54267669e-01f, -1.68198705e-01f,
  -1.20734975e-01f, -2.56982625e-01f, -1.73081234e-01f, -2.83504754e-01f, -1.39790833e-01f, 1.40185475e-01f, 1.83915630e-01f, 1.22280203e-01f, 1.45380974e-01f, 4.28501284e-03f,
  2.13922393e-02f, -1.18803762e-01f, -2.38911644e-01f, -1.42884469e-02f, -6.04805276e-02f, -6.48036674e-02f, -1.36859212e-02f, 5.87348640e-02f, 5.22602862e-03f, -2.71877591e-02f,
  3.40217263e-01f, -2.23669391e-02f, -1.92069653e-02f, -9.78878662e-02f, 1.12339079e-01f, -9.31920260e-02f, 2.24460691e-01f, -5.18089309e-02f, -6.97476119e-02f, -7.95229375e-02f,
  -5.31200096e-02f, -1.14389822e-01f, 2.82493353e-01f, 8.51290897e-02f, -1.71944916e-01f, -1.33106902e-01f, 6.75340518e-02f, 1.46939382e-01f, 3.40108499e-02f, -2.11982399e-01f,
  1.69984132e-01f, 8.48981589e-02f, -6.55060560e-02f, 2.09180430e-01f, 7.34969229e-02f, 2.01465845e-01f, 2.59343028e-01f, 9.96303000e-03f, 1.27072275e-01f, 1.82986408e-01f,
  -5.01738079e-02f, 1.47216275e-01f, 1.21433973e-01f, 9.19359103e-02f, 3.28153729e-01f, -1.06870316e-01f, 1.57395542e-01f, -1.46949157e-01f, -2.00058714e-01f, -3.13933641e-01f,
  -3.68718058e-02f, -3.24877864e-03f, 2.20390379e-01f, -1.43933639e-01f, 6.29157871e-02f, 5.19877002e-02f, -2.51363784e-01f, -1.05743855e-03f, 1.88903183e-01f, 2.31258392e-01f,
  -1.07012607e-01f, 6.73109666e-02f, 1.09404027e-01f, 3.12250137e-01f, -7.54090101e-02f, -1.40444607e-01f, -3.83833260e-03f, -5.79621941e-02f, -1.84686799e-02f, 1.26858726e-01f,
  1.24298774e-01f, -3.81558686e-02f, -1.14883572e-01f, 3.27709094e-02f, -4.67301384e-02f, -7.29493201e-02f, 6.00445233e-02f, -5.28498739e-02f, 4.69235936e-03f, -1.26605168e-01f,
  3.42258848e-02f, 1.29856184e-01f, 8.03493634e-02f, -1.25425532e-01f, 7.88689032e-02f, 7.26030096e-02f, 2.05203220e-01f, 5.01461625e-01f, -1.53417408e-01f, -8.91614929e-02f,
  -3.58035266e-02f, -5.68808690e-02f, -3.02441847e-02f, 1.61446363e-01f, 1.30699635e-01f, 2.43193563e-02f, -1.14142932e-01f, -9.74737331e-02f, -7.11683091e-03f, -6.79879785e-02f,
  2.07909495e-01f, -1.72984228e-02f, 1.23542607e-01f, 1.53101817e-01f, -5.36421686e-02f, -3.56483879e-03f, -7.64178112e-02f, 3.56304832e-02f, 1.40428409e-01f, 2.55316645e-02f,
  1.40071958e-01f, 1.29516348e-01f, -1.25424370e-01f, 9.79458354e-03f, -1.72840908e-01f, -9.45575088e-02f, 1.22895101e-02f, 4.28106710e-02f, -2.27039345e-02f, -5.29346615e-02f,
  5.87666407e-03f, 2.53481716e-01f, 4.22951430e-02f, 6.87335953e-02f, 1.06345147e-01f, 7.23115578e-02f, -5.66198900e-02f, 7.46318549e-02f, -6.19651470e-03f, -9.87544004e-03f,
  -6.49647117e-02f, 1.74189731e-01f, -6.88383132e-02f, -9.98095945e-02f, 6.89028502e-02f, -1.22509345e-01f, -9.91228223e-02f, -1.07594684e-01f, 1.96003169e-01f, 3.49851787e-01f,
  -1.58369720e-01f, 6.48038164e-02f, -1.41874880e-01f, 5.28336540e-02f, -1.20947666e-01f, 8.39943886e-02f, -7.28608891e-02f, -8.41816701e-03f, 6.57267347e-02f, 1.24695741e-01f,
  1.33179113e-01f, 1.48993179e-01f, -2.90533546e-02f, -5.42020798e-02f, -1.15481704e-01f, 4.45878319e-02f, 1.08232990e-01f, -7.27826729e-04f, 6.03392161e-02f, -8.29299260e-03f,
  1.18822813e-01f, -1.49192572e-01f, -6.86074607e-03f, 2.36308184e-02f, 1.30567566e-01f, 7.62101710e-02f, -1.38192549e-01f, -1.11055218e-01f, 7.42268041e-02f, -8.87367278e-02f,
  -4.83898865e-03f, 9.09682885e-02f, 1.15666194e-02f, -1.04930364e-01f, 1.24800436e-01f, 6.43192185e-03f, -1.00652054e-01f, 8.31601545e-02f, 1.91854656e-01f, 2.03077629e-01f,
  -1.14155099e-01f, -1.76842049e-01f, -2.14928836e-02f, 5.26827015e-02f, -1.47810072e-01f, -6.36428944e-04f, -1.75752550e-01f, 4.81940918e-02f, 3.76486853e-02f, 1.14431672e-01f,
  -1.55532300e-01f, -6.90614879e-02f, -1.04741350e-01f, -4.87021469e-02f, 2.24814215e-03f, -3.55344005e-02f, 1.19399406e-01f, 2.23375455e-01f, -2.52481885e-02f, 4.95259650e-02f,
  1.07337520e-01f, 7.88987055e-02f, 1.19664699e-01f, 2.36428395e-01f, -2.07685810e-02f, 8.96953046e-02f, -7.16294870e-02f, -2.57520489e-02f, -9.24049094e-02f, 1.38051420e-01f,
  5.62161952e-02f, -9.49193910e-02f, -1.24411039e-01f, -2.35589463e-02f, 3.39228600e-01f, 2.50746399e-01f, -4.56207059e-03f, -9.47673023e-02f, 4.33993991e-03f, 7.28936046e-02f,
  -7.03841299e-02f, 7.13719800e-03f, 8.30075964e-02f, -5.47982305e-02f, 8.71373340e-02f, 1.22771654e-02f, 1.01776861e-01f, -6.20499924e-02f, -6.02481887e-02f, 1.35087827e-02f,
  -5.96695691e-02f, -3.05026248e-02f, 8.47775415e-02f, 3.55350040e-03f, 2.57850923e-02f, -1.04863077e-01f, -2.96256579e-02f, -1.18858859e-01f, -9.54448208e-02f, 5.87342493e-02f,
  -1.65134426e-02f, 9.68521237e-02f, -8.63646790e-02f, -3.15997154e-02f, -4.95819189e-02f, 4.28440496e-02f, -7.86233246e-02f, 1.18695267e-01f, -6.19432218e-02f, -3.02123204e-02f,
  2.64290385e-02f, -1.11288473e-01f, -3.48392986e-02f, 8.45142379e-02f, -7.95027688e-02f, -8.61171782e-02f, -3.67494114e-02f, 1.26892284e-01f, -9.68569070e-02f, -2.21707765e-02f,
  8.81065801e-02f, 2.35746969e-02f, 8.22671503e-02f, -7.60274678e-02f, 9.20399949e-02f, 1.02061011e-01f, 7.01956674e-02f, 7.65340105e-02f, 5.44527359e-02f, -3.23462747e-02f,
  2.18123514e-02f, 5.85225224e-02f, 1.37879355e-02f, -3.18784430e-03f, -7.47997463e-02f, -6.92508221e-02f, 8.47805962e-02f, 8.99089575e-02f, 7.73738995e-02f, -5.03551550e-02f,
  -8.11619014e-02f, -9.98518094e-02f, -1.06979571e-01f, -1.96608733e-02f, 1.07890934e-01f, -8.35755542e-02f, 1.04772210e-01f, 6.26291931e-02f, 1.65224105e-01f, -2.34353580e-02f,
  2.64799427e-02f, 1.11296475e-01f, 2.13042125e-02f, 1.28372451e-02f, 5.03355525e-02f, -2.86547095e-02f, 1.60363287e-01f, -6.93837479e-02f, -5.57374991e-02f, 1.12912118e-01f,
  3.20820138e-02f, 7.95980245e-02f, 1.37688085e-01f, 1.50160983e-01f, -8.11706185e-02f, 1.11570721e-02f, -1.30594119e-01f, -2.25981981e-01f, -2.18592465e-01f, 6.64603263e-02f,
  -1.58675537e-01f, -1.20675564e-01f, -5.12906816e-03f, 1.56339005e-01f, 5.18551245e-02f, 4.46763029e-03f, -1.73216742e-02f, -7.06271008e-02f, 1.66662082e-01f, -9.46031436e-02f,
  -1.35988668e-01f, 7.98211545e-02f, 1.21634007e-01f, 2.12807562e-02f, 5.01935668e-02f, -6.97134808e-02f, 1.24289826e-01f, 8.65772143e-02f, 8.67780298e-02f, 8.36816654e-02f,
  4.22397070e-02f, 1.73798099e-01f, -1.27980977e-01f, 4.94002551e-02f, 1.03279568e-01f, 1.45817799e-02f, -1.25375032e-01f, -1.23804761e-02f, -1.67270582e-02f, 9.92877483e-02f,
  -4.31085601e-02f, 1.60167456e-01f, -1.39799818e-01f, -1.15159683e-01f, 7.52237514e-02f, 7.62028852e-03f, -1.32267049e-03f, 4.06750627e-02f, 3.77017185e-02f, 5.34787923e-02f,
  -1.32411540e-01f, 8.75073969e-02f, 3.71364430e-02f, -6.98101372e-02f, 1.20584548e-01f, 6.35693595e-02f, -1.02963196e-02f, -1.99912097e-02f, -9.65761691e-02f, -5.87097593e-02f,
  4.08294946e-02f, -7.97341540e-02f, -1.14352629e-01f, 5.96202090e-02f, 5.09930663e-02f, 5.25378026e-02f, 9.28408951e-02f, 9.74292110e-04f, 3.02704405e-02f, -8.66480693e-02f,
  -1.90752611e-01f, -1.06443547e-01f, -3.52450763e-03f, 1.47060886e-01f, 6.42046109e-02f, -7.36286491e-02f, 4.47981805e-02f, 1.57841429e-01f, 9.14696380e-02f, 2.08825655e-02f,
  -7.26543292e-02f, -4.84305248e-02f, -4.27182838e-02f, 1.03792988e-01f, -1.15208186e-01f, -8.59423205e-02f, 1.80776969e-01f, 4.61086538e-03f, 2.77115870e-02f, -1.37675211e-01f,
  6.04342297e-02f, -3.16795893e-02f, -5.24197891e-02f, -6.66768923e-02f, -5.13226865e-03f, 4.27997895e-02f, -1.80119395e-01f, -6.70833439e-02f, 6.65742680e-02f, -9.67503861e-02f,
  5.85574051e-03f, -1.80537021e-03f, -7.82858208e-02f, 2.97149401e-02f, -1.21238241e-02f, 1.61324628e-02f, 1.21646024e-01f, -2.29213163e-02f, 1.18279889e-01f, -5.91351502e-02f,
  5.80421723e-02f, -3.81517336e-02f, 1.22386619e-01f, 7.78414076e-03f, 7.07761943e-02f, 2.96612270e-02f, 4.06382643e-02f, 9.90329683e-02f, 3.82064693e-02f, 1.79258317e-01f,
  -8.29793140e-02f, 1.43995322e-02f, -3.39155123e-02f, -8.11699629e-02f, 1.86902940e-01f, 5.86190894e-02f, 1.86364323e-01f, 8.81185755e-02f, 2.10970975e-02f, 1.38035029e-01f,
  4.80922032e-03f, 5.86702712e-02f, 1.57005474e-01f, 1.06310435e-01f, 4.91310358e-02f, -4.27733585e-02f, 1.43329635e-01f, -4.76454152e-03f, 1.37167796e-01f, -7.25846216e-02f,
  1.29333287e-01f, -1.23081483e-01f, -2.03433726e-02f, -6.88407943e-02f, 9.79042351e-02f, -5.63144460e-02f, 1.01044908e-01f, 9.74996481e-03f, -1.23488223e-02f, 1.80133805e-02f,
  2.93617666e-01f, -9.61198062e-02f, 1.24227315e-01f, -8.54998380e-02f, 3.66351716e-02f, 3.07790991e-02f, 6.95924759e-02f, -7.71118468e-03f, 2.95543927e-03f, 8.08441266e-02f,
  1.42536804e-01f, -1.08322382e-01f, 9.83937085e-02f, 1.50482766e-02f, -1.48005918e-01f, 1.10487759e-01f, -9.02872160e-02f, -1.66736599e-02f, 5.91595955e-02f, 9.62731987e-02f,
  8.01660344e-02f, -7.40247071e-02f, -4.09077592e-02f, -6.37702048e-02f, -6.63819015e-02f, -1.33850588e-03f, -4.15360443e-02f, 2.27332804e-02f, 5.38562313e-02f, -1.99512243e-02f,
  1.47885770e-01f, 6.72419742e-02f, 1.29376389e-02f, 1.35407940e-01f, 1.40080228e-01f, -8.14201534e-02f, 7.22704381e-02f, 1.84885517e-01f, -6.36197105e-02f, 1.07044034e-01f,
  6.29705861e-02f, 5.80355003e-02f, 1.76065266e-01f, -2.84140334e-02f, 8.96525159e-02f, -2.56146133e-01f, 3.69520369e-03f, -8.20796415e-02f, 1.42490581e-01f, -4.08224389e-02f,
  1.58800676e-01f, -1.67694047e-01f, 2.81256828e-02f, 1.81317672e-01f, -1.96811780e-01f, 1.39988691e-01f, 1.17114067e-01f, 6.91857487e-02f, -1.27745941e-01f, -1.41082378e-03f,
  -1.71861246e-01f, 9.14409906e-02f, 5.85692190e-02f, -1.56259947e-02f, -1.27050340e-01f, -1.81268957e-02f, 8.42071548e-02f, -5.88071682e-02f, -1.98335871e-02f, -1.00779481e-01f,
  -9.87495407e-02f, -5.48802316e-02f, -2.27580056e-01f, -2.04251707e-01f, -1.51319742e-01f, 6.08757474e-02f, -9.06820670e-02f, 8.61565992e-02f, 4.26705088e-03f, -1.05800070e-02f,
  1.07818171e-02f, -9.06850845e-02f, 1.78852350e-01f, 1.08103184e-02f, 2.08479062e-01f, 4.47629362e-01f, 6.77430909e-03f, 9.43192095e-02f, 3.50750498e-02f, -6.29874095e-02f,
  -6.75915033e-02f, 1.29939639e-03f, 4.71922755e-02f, 1.50664330e-01f, -1.24654770e-01f, -1.13436021e-01f, 1.44769669e-01f, 1.21191397e-01f, -1.74107384e-02f, -2.30556484e-02f,
  -4.34500091e-02f, 8.89609978e-02f, 8.79042968e-02f, 4.58574407e-02f, 6.51585683e-02f, 1.52090266e-01f, 1.13260690e-02f, -1.10373326e-01f, -5.16588651e-02f, -2.26372257e-01f,
  2.05908120e-01f, 1.68602601e-01f, 8.36692229e-02f, 6.41172156e-02f, 7.36696869e-02f, 1.78747967e-01f, 1.53682053e-01f, 1.68087073e-02f, 2.32478589e-01f, -2.15101108e-01f,
  -4.34387885e-02f, -1.09666362e-01f, 2.95764729e-02f, 2.53712777e-02f, -9.25676140e-05f, 1.58859249e-02f, 4.94461432e-02f, 1.03304625e-01f, 9.29062292e-02f, -1.95499603e-02f,
  6.22360595e-02f, 8.89841840e-02f, 5.34108430e-02f, -5.28655685e-02f, 3.23569924e-02f, 4.57753614e-02f, -9.31757838e-02f, -1.48990765e-01f, 4.14846182e-01f, 1.59028336e-01f,
  -4.66340221e-02f, -8.76907110e-02f, -1.94973424e-02f, 1.63877949e-01f, -4.32143956e-02f, -1.76582616e-02f, -3.81204896e-02f, -4.89678234e-02f, -1.82882361e-02f, 6.99923933e-02f,
  5.78616150e-02f, -4.62212153e-02f, -1.01106495e-01f, 1.07998751e-01f, 2.47175023e-02f, -5.20958379e-02f, 7.81991705e-02f, 1.19104773e-01f, 5.47910575e-03f, -1.82973165e-02f,
  1.01861149e-01f, 1.62148878e-01f, 6.24396605e-03f, 8.41896161e-02f, 4.94535901e-02f, 2.69074738e-02f, 1.84977770e-01f, -2.22484320e-02f, 1.31392837e-01f, 3.65584455e-02f,
  -4.96354178e-02f, 7.37296268e-02f, -1.24655254e-01f, 5.33944443e-02f, -9.84296873e-02f, -5.58052212e-02f, 1.30782962e-01f, -2.51365378e-02f, 9.54865292e-02f, 8.13719630e-02f,
  -3.05895563e-02f, -1.22931845e-01f, 6.26053885e-02f, -1.51066750e-01f, 1.11956701e-01f, 1.33128092e-01f, 1.35940373e-01f, -1.04166254e-01f, -7.83137158e-02f, 2.34159138e-02f,
  1.15524143e-01f, 9.20838788e-02f, -3.24527584e-02f, -2.57471744e-02f, 6.81351572e-02f, -2.77172718e-02f, -8.22997540e-02f, 1.12474717e-01f, 7.62200402e-03f, -7.98407421e-02f,
  1.13976240e-01f, 6.66721025e-03f, -4.70427983e-02f, 3.99948210e-02f, 8.77421275e-02f, -7.79598355e-02f, 1.24798343e-01f, 2.36070026e-02f, -1.50753753e-02f, 2.40233354e-02f,
  -9.93275791e-02f, -4.93618511e-02f, -6.68073371e-02f, 5.54717332e-02f, 1.07862696e-01f, -2.77477521e-02f, -1.00761496e-01f, 1.03725605e-01f, 4.48914170e-02f, -1.48061275e-01f,
  -3.05476263e-02f, 1.23644441e-01f, 2.12682108e-03f, 9.31576639e-02f, -3.85213308e-02f, -1.07847914e-01f, 3.53806390e-04f, 4.36718315e-02f, -3.62391174e-02f, 1.27617255e-01f,
  -1.68330446e-01f, 1.10150218e-01f, -1.36814997e-01f, 2.57910997e-01f, -1.65341184e-01f, 6.12616763e-02f, 5.79541475e-02f, -3.25724520e-02f, 1.51961252e-01f, 1.36437118e-01f,
  -1.45694360e-01f, 9.26042348e-03f, -1.41480118e-01f, 1.19101144e-01f, -9.90387499e-02f, 1.15124181e-01f, 1.15898766e-01f, 2.47158751e-01f, 1.24374457e-01f, -7.72922784e-02f,
  -3.73756588e-02f, -5.66016883e-03f, -2.33510528e-02f, 4.82070772e-03f, 4.80202027e-02f, 1.60814375e-02f, 1.81059122e-01f, -2.27981992e-03f, -1.14372388e-01f, 2.68847309e-02f,
  1.48263276e-01f, 6.89059123e-02f, -7.80621246e-02f, -7.94491172e-02f, 4.94659655e-02f, 9.17031243e-02f, 2.09831655e-01f, 3.87958996e-02f, 6.36521131e-02f, 9.06738639e-03f,
  -1.14712112e-01f, -8.94888937e-02f, -3.54959955e-03f, -5.39642796e-02f, 1.03002731e-02f, -1.12862356e-01f, 1.20400049e-01f, 1.86618105e-01f, 1.96764469e-01f, -1.99697670e-02f,
  9.07033235e-02f, -2.31970865e-02f, 2.04649530e-02f, 6.98743807e-03f, 1.02745235e-01f, 7.20537547e-03f, 1.83844298e-01f, -4.97577786e-02f, 1.11719288e-01f, -2.12936196e-02f,
  1.61005512e-01f, -1.01751603e-01f, -1.09142579e-01f, 4.20033634e-02f, 2.52104759e-01f, -2.77683698e-02f, -7.40087107e-02f, 2.34644160e-01f, 9.08441320e-02f, 1.57590508e-01f,
  9.65231061e-02f, -8.82485416e-03f, -1.51089564e-01f, -2.08881170e-01f, -2.36945450e-01f, 1.54219493e-02f, 2.25816354e-01f, 1.00476667e-01f, -1.83676139e-01f, 1.50956586e-01f,
  3.68460268e-02f, 1.17428310e-01f, 1.32535174e-01f, -7.71841705e-02f, -8.81904066e-02f, 1.17069505e-01f, 7.33037218e-02f, 4.37537506e-02f, -1.14477992e-01f, -1.03961639e-01f,
  1.59455732e-01f, -2.11391728e-02f, 6.53560460e-02f, -9.00012553e-02f, -1.10076360e-01f, -3.97450663e-02f, -6.42495081e-02f, -9.71066207e-02f, 4.67011705e-02f, 1.15929030e-01f,
  -4.33446206e-02f, -1.21200740e-01f, -1.01366974e-01f, 1.95548721e-02f, 7.61980861e-02f, 5.96842431e-02f, 8.97337571e-02f, 1.00716092e-01f, -8.20753053e-02f, 9.70396250e-02f,
  3.31788898e-01f, 9.28205773e-02f, -2.55227294e-02f, 1.21883944e-01f, -1.26472875e-01f, -2.97050718e-02f, -3.36719118e-02f, -2.14227661e-02f, 1.52980343e-01f, -2.12653637e-01f,
  1.64081424e-01f, 1.37017639e-02f, -2.07420215e-02f, 5.60705177e-02f, 9.69580710e-02f, 8.44453275e-03f, -1.32597852e-02f, -1.80740207e-02f, 7.82840550e-02f, 1.47496268e-01f,
  -9.31385159e-02f, 1.38732255e-01f, 1.54401347e-01f, -2.20982544e-02f, 7.97916353e-02f, -1.17918346e-02f, -1.65151916e-02f, -1.83052234e-02f, -1.97498396e-01f, -8.29493850e-02f,
  3.44525129e-02f, 2.25928620e-01f, -7.39208609e-02f, -6.01627938e-02f, 2.97604501e-02f, 9.93005466e-03f, 1.53441891e-01f, -1.16667626e-02f, -1.07887961e-01f, -1.07358001e-01f,
  1.39183745e-01f, 1.95775688e-01f, -1.37149813e-02f, 4.70677838e-02f, 3.13076943e-01f, -1.05643123e-02f, 1.72607675e-02f, -3.81400213e-02f, 5.63518219e-02f, 1.20338490e-02f,
  -6.36731312e-02f, -1.03864588e-01f, -1.37497693e-01f, 2.55046785e-01f, -5.39678410e-02f, 6.63148984e-02f, 8.41466337e-02f, 5.25868423e-02f, -2.80395150e-02f, 1.05521709e-01f,
  -1.12743769e-02f, -3.69774289e-02f, 1.36716232e-01f, 4.30368856e-02f, -1.77146755e-02f, -1.42233640e-01f, 1.59297109e-01f, 1.33464783e-01f, -6.57895505e-02f, -9.32936147e-02f,
  9.07417536e-02f, -7.95392320e-02f, -4.31093052e-02f, -3.97461727e-02f, -8.06714073e-02f, -5.35910353e-02f, 9.62004662e-02f, -4.72641550e-02f, -1.07144512e-01f, 7.21703470e-02f,
  -1.46235794e-01f, -1.28672794e-01f, -2.03852030e-03f, 1.41141936e-01f, -9.06811804e-02f, 2.24886298e-01f, -3.27262767e-02f, -3.61892302e-03f, -8.22028294e-02f, -1.65606514e-01f,
  8.73462558e-02f, 1.19936742e-01f, 1.56985730e-01f, 1.47550315e-01f, 1.17721884e-02f, 1.36995703e-01f, 2.48455387e-02f, 1.28114909e-01f, 1.59969509e-01f, -9.17083409e-04f,
  1.25157446e-01f, 4.61690538e-02f, -1.40247956e-01f, -3.44714671e-02f, -2.81109307e-02f, -1.26427695e-01f, -4.33842093e-03f, -9.92539823e-02f, 3.93024795e-02f, -3.89539450e-02f,
  -4.67694774e-02f, 1.13100268e-01f, 9.63481218e-02f, -5.83733805e-02f, -3.82332914e-02f, 9.12513882e-02f, 1.20817550e-01f, 1.73067022e-02f, 2.52295047e-01f, 7.35602400e-04f,
  7.77402073e-02f, -3.24853808e-02f, -1.51052207e-01f, -6.88414350e-02f, -8.17539766e-02f, -6.88176006e-02f, 1.24488054e-02f, 3.20909843e-02f, 2.44492870e-02f, -7.07856938e-02f,
  2.04532862e-01f, 9.85652283e-02f, -9.44012552e-02f, -1.14513256e-01f, 3.27313654e-02f, -3.66481394e-02f, 1.17315248e-01f, -1.29983261e-01f, -4.81906533e-02f, 3.56677100e-02f,
  1.90424204e-01f, 2.31801718e-01f, 2.20708966e-01f, 1.35643914e-01f, 1.17676497e-01f, 2.61510998e-01f, 1.36474311e-01f, 1.99984342e-01f, 3.33513841e-02f, 1.53188527e-01f,
  1.97808415e-01f, 1.99679032e-01f, 2.90199295e-02f, -1.66157141e-01f, -4.17625420e-02f, -2.20453486e-01f, -1.06753372e-01f, -1.36901200e-01f, 2.94649243e-01f, 2.57442534e-01f,
  -2.48828307e-01f, 1.39392734e-01f, -2.71169432e-02f, -5.79775078e-03f, 3.64574969e-01f, -7.48658329e-02f, -4.94394004e-02f, -1.14495434e-01f, -2.91746072e-02f, 6.83977902e-02f,
  -1.80228084e-01f, -4.90403846e-02f, 4.43332382e-02f, -1.10788859e-01f, -1.31372571e-01f, 9.62566361e-02f, -5.68283685e-02f, 1.26567194e-02f, -1.53029040e-01f, -4.17031981e-02f,
  -2.27472484e-01f, 6.61120191e-02f, -1.79887265e-01f, -4.31268141e-02f, -1.60750121e-01f, -1.47567108e-01f, 4.31199931e-02f, 1.43929884e-01f, 2.44084112e-02f, 1.40502647e-01f,
  1.02619326e-03f, 7.51182437e-02f, 2.52415597e-01f, 2.75576860e-01f, 7.40771219e-02f, -1.42353117e-01f, -6.01697192e-02f, -4.79400903e-03f, -4.86811996e-02f, -1.66400895e-01f,
  1.39924407e-01f, -1.84073478e-01f, 2.35400960e-01f, -1.05748817e-01f, 7.07173422e-02f, 1.18183918e-01f, 2.78363805e-02f, 2.07993105e-01f, 2.88369328e-01f, 6.36475682e-02f,
  -2.15957984e-01f, 6.32793531e-02f, 5.29172495e-02f, 1.40566155e-01f, 8.75184387e-02f, -1.72801346e-01f, -1.22216679e-02f, -3.14829499e-02f, -8.60265866e-02f, 3.80706191e-02f,
  -9.66592431e-02f, -1.60237998e-01f, 5.57608083e-02f, -2.18395069e-01f, -1.76599994e-01f, 6.77260384e-02f, -1.32696718e-01f, 2.08930522e-01f, -7.57324323e-02f, 1.08698703e-01f,
  2.08387673e-01f, -5.31145371e-02f, -2.03890383e-01f, 1.05096944e-01f, -2.77403630e-02f, 1.35112986e-01f, -1.08357958e-01f, 1.32883489e-01f, 1.08392918e-02f, 6.89423457e-02f,
  -2.30576936e-02f, -7.54320696e-02f, -6.70868829e-02f, -5.61001711e-02f, 1.85972229e-01f, 6.37366623e-02f, 3.46400924e-02f, 1.08337276e-01f, 3.68197402e-03f, -4.28069048e-02f,
  -1.43408298e-01f, -9.92580503e-02f, -2.30781417e-02f, 4.65684682e-02f, 1.36658832e-01f, -1.13099918e-01f, 8.24823156e-02f, 2.65261352e-01f, 5.64909689e-02f, -1.24949835e-01f,
  -2.49940511e-02f, 4.48387265e-02f, -1.48146525e-01f, 8.75922218e-02f, 4.50707823e-02f, 2.60083675e-01f, -7.07948431e-02f, -1.22829862e-01f, 6.36783540e-02f, 1.63039744e-01f,
  2.03580678e-01f, -2.09934264e-02f, 5.16428193e-03f, 1.69561729e-01f, 5.18967137e-02f, 1.20624222e-01f, 1.10002473e-01f, -4.08349112e-02f, 1.94769219e-01f, -5.32901436e-02f,
  1.14263721e-01f, -2.13352650e-01f, -1.29275516e-01f, -3.12687427e-01f, 3.51955146e-02f, 1.75234657e-02f, 2.17215806e-01f, -6.35337159e-02f, 7.21974745e-02f, 1.23811573e-01f,
  -2.13165417e-01f, 6.11940920e-02f, 2.36390922e-02f, 1.54880762e-01f, -2.06210930e-02f, -6.57736436e-02f, 3.71239521e-02f, 1.55598253e-01f, 2.11496800e-02f, -1.09494768e-01f,
  1.52928069e-01f, -1.09196743e-02f, -4.12129238e-02f, -1.54393157e-02f, 1.38977468e-01f, -1.02013171e-01f, 1.44953877e-02f, -1.29465595e-01f, -1.93426073e-01f, 7.81061053e-02f,
  6.56511560e-02f, -2.82099657e-03f, 1.08943895e-01f, 3.14589255e-02f, 9.05834604e-03f, -5.90180047e-02f, -1.06036991e-01f, -4.57382686e-02f, 3.28519344e-02f, 6.98742047e-02f,
  1.88679472e-01f, 2.10022092e-01f, -1.15401685e-01f, 1.41075209e-01f, 2.20042113e-02f, -5.94721846e-02f, 3.16638649e-02f, 1.55038584e-03f, -2.01144330e-02f, -1.54446634e-02f,
  -1.44111365e-01f, 6.22222871e-02f, 1.00068850e-02f, -8.99407268e-02f, -6.55249432e-02f, -7.34502776e-03f, -5.14293872e-02f, -3.77512537e-02f, -3.80601138e-02f, -9.66956615e-02f,
  4.25983220e-02f, 1.01247035e-01f, 3.32333595e-02f, 3.86940055e-02f, 2.55264230e-02f, -6.79354072e-02f, -7.34201074e-02f, 2.00626743e-03f, 1.24503039e-01f, 1.57746121e-01f,
  1.89981461e-02f, 2.06728876e-02f, 1.22436069e-01f, -2.14724243e-02f, 8.85883719e-03f, 4.54642810e-02f, -4.66710236e-03f, -7.92186484e-02f, -6.31992817e-02f, 5.21431305e-02f,
  -5.08674979e-02f, -1.22202486e-01f, 7.22320527e-02f, 1.95065271e-02f, -4.32340242e-02f, -7.96783939e-02f, 1.19043648e-01f, 1.06066577e-01f, 3.41420621e-02f, -6.65913075e-02f,
  -1.35688251e-02f, 1.09705195e-01f, 4.04586941e-02f, -2.72540525e-02f, -4.89148125e-02f, 8.98355544e-02f, -6.36148378e-02f, -8.91088769e-02f, 8.55815485e-02f, -1.03341505e-01f,
  -5.61536476e-02f, -1.04155742e-01f, -3.57587896e-02f, 3.31662297e-02f, 1.97879598e-01f, 1.35649502e-01f, 9.81301907e-03f, -2.78763715e-02f, -9.85637531e-02f, -8.73713270e-02f,
  -2.40663736e-04f, 1.96101200e-02f, -1.45069649e-02f, 4.85605150e-02f, -9.66521725e-02f, 9.12221745e-02f, 1.28508762e-01f, 5.62153533e-02f, 1.02756411e-01f, 2.17288584e-01f,
  -3.80113535e-03f, 9.87880677e-03f, -6.68763518e-02f, 1.80758834e-01f, 6.44344166e-02f, 7.10749626e-03f, 2.85394639e-01f, -1.71242088e-01f, 1.47640124e-01f, -7.96125978e-02f,
  8.51438344e-02f, -1.81092694e-02f, 3.55281204e-01f, 2.98111886e-01f, 2.95528173e-01f, -1.78632990e-01f, 8.49671438e-02f, -1.48379520e-01f, -5.05885705e-02f, -3.56465876e-01f,
  -2.49856442e-01f, 3.99638638e-02f, -3.82696018e-02f, -3.35987634e-03f, 3.72843519e-02f, 1.50120497e-01f, 2.15364441e-01f, -3.97727229e-02f, 1.02239046e-02f, -1.43108696e-01f,
  -1.34850740e-01f, 1.73799917e-01f, -7.91452602e-02f, 6.44694194e-02f, -4.93536405e-02f, 1.97843257e-02f, -1.04511537e-01f, -2.24040031e-01f, 5.10909796e-01f, 5.87563775e-02f,
  -6.56679869e-02f, 1.15902938e-01f, 2.79696621e-02f, 1.25586390e-01f, 1.10590309e-02f, 7.16534117e-03f, -6.60186335e-02f, -3.84523720e-02f, 1.65039644e-01f, 3.34151119e-01f,
  -4.33559455e-02f, 1.38794994e-02f, -1.85189247e-02f, -1.06998287e-01f, -1.17171645e-01f, 5.13907745e-02f, -6.03891276e-02f, 1.41311130e-02f, -4.77729663e-02f, 5.04456162e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -4.86870296e-02f, -4.75774296e-02f, 6.93028420e-02f, 2.02180259e-02f, 9.59818810e-02f, -2.01162007e-02f, 2.11985096e-01f, -7.72330016e-02f, 8.32842737e-02f, -5.27473725e-02f,
  -4.91018333e-02f, 8.39618966e-02f, 1.22040056e-01f, -2.61419583e-02f, 1.74419075e-01f, -4.33830805e-02f, 1.72713369e-01f, 1.21572763e-01f, -7.75223076e-02f, 1.21234022e-01f,
  6.33691102e-02f, 1.24896899e-01f, 1.00724760e-03f, 1.60037875e-01f, 3.48430686e-02f, 1.53997183e-01f, -7.46054053e-02f, 1.12353951e-01f, 4.57226560e-02f, 1.77847415e-01f,
  4.74637970e-02f, -6.09304495e-02f, 1.27897918e-01f, 8.18683207e-02f, 1.59458205e-01f, 9.91522521e-02f, 1.67358249e-01f, -2.79851314e-02f, -9.01609510e-02f, 1.68385267e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -5.31127714e-02f, -3.00689012e-01f, -9.62626636e-02f, -3.04269612e-01f, -1.71761945e-01f, 8.04436114e-03f, -5.92096671e-02f, -2.97373831e-01f, 1.39515959e-02f, -3.56512398e-01f,
  -1.28635511e-01f, 8.17726180e-02f, -3.40098180e-02f, 2.29239777e-01f, -3.67575251e-02f, 1.46709979e-01f, 1.86474711e-01f, 3.97321135e-01f, 2.28622705e-01f, -1.69468865e-01f,
  -2.26156980e-01f, -1.60505354e-01f, 2.69855827e-01f, 1.99011669e-01f, 1.80403795e-02f, 9.74460915e-02f, 3.12345088e-01f, -1.34763926e-01f, 2.66115963e-02f, 6.34654611e-02f,
  -1.00248866e-01f, 5.71913160e-02f, -6.61422918e-03f, 1.49032369e-01f, 2.33533625e-02f, -9.06963721e-02f, -8.74510035e-02f, -1.59835100e-01f, -6.28357977e-02f, -4.90989357e-01f,
  4.36549515e-01f, 1.86391234e-01f, -3.39205563e-02f, -4.20434400e-02f, -2.59882331e-01f, -4.18934785e-02f, -1.23749733e-01f, 2.74036881e-02f, 5.32861315e-02f, 6.20993460e-03f,
  1.03736341e-01f, -2.28839535e-02f, -5.09861559e-02f, 4.37315822e-01f, -1.73976451e-01f, 2.89737105e-01f, 1.74707752e-02f, -1.24358051e-02f, 3.13766897e-01f, -2.41074532e-01f,
  -7.52815232e-02f, -1.17592447e-01f, -5.04348204e-02f, 4.68728393e-01f, 1.13496900e-01f, 8.76187161e-02f, 1.90151572e-01f, 1.50832444e-01f, 6.50462508e-02f, 1.77356452e-01f,
  -1.20805152e-01f, 1.51770741e-01f, 5.42048700e-02f, 5.46443462e-02f, 3.09554815e-01f, -3.73021305e-01f, 1.90457717e-01f, 4.17321414e-01f, -2.97937728e-02f, 2.92593837e-01f,
  3.82270992e-01f, 4.15233880e-01f, 2.33072340e-01f, -4.50455517e-01f, -3.66768122e-01f, -2.87710339e-01f, 5.89201003e-02f, -3.59821796e-01f, 1.23375170e-01f, 8.36196467e-02f,
  1.19403526e-02f, -5.65790161e-02f, -1.42242178e-01f, -1.61183298e-01f, 1.55467853e-01f, -1.57237113e-01f, -1.55600578e-01f, 2.27877527e-01f, 1.06578693e-02f, -9.50642973e-02f,
  -1.67547481e-03f, -1.38812870e-01f, -1.55160539e-02f, -5.91927469e-01f, -1.25307575e-01f, 1.99002266e-01f, -1.56995490e-01f, 2.99246192e-01f, -4.49730456e-01f, 5.09085596e-01f,
  -1.55457100e-02f, -1.56639516e-01f, -1.27839759e-01f, 2.16388702e-02f, -3.89987752e-02f, -9.78007466e-02f, 5.30294359e-01f, 1.38889328e-02f, -9.95609239e-02f, 1.07667096e-01f,
  -1.83734000e-01f, 9.52721164e-02f, -7.21657202e-02f, 4.32683788e-02f, 3.53732675e-01f, 2.76592225e-01f, 3.47305066e-03f, 1.70522287e-01f, 1.65774748e-01f, -7.92029575e-02f,
  -1.00536607e-01f, 3.25345874e-01f, -2.95017827e-02f, -1.86822601e-02f, 2.23468214e-01f, 4.38554317e-01f, -7.25762546e-02f, 3.02563518e-01f, -1.33031815e-01f, 5.82633540e-02f,
  1.14174962e-01f, -4.74661916e-01f, 2.23189130e-01f, 1.26363128e-01f, -2.69778818e-01f, -4.72074270e-01f, -3.26687396e-02f, 3.94266307e-01f, 2.89321065e-01f, 1.34111792e-01f,
  3.49904954e-01f, -1.30372420e-01f, 6.80533573e-02f, 3.17116119e-02f, -3.03336829e-01f, 1.22439548e-01f, 1.07465968e-01f, -5.03530987e-02f, -5.43954084e-03f, 9.82830767e-04f,
  1.70680836e-01f, -2.16357619e-01f, 6.96798488e-02f, 6.80620223e-02f, 1.44000212e-02f, -9.94653627e-02f, -1.10125683e-01f, 4.34210956e-01f, -1.66635871e-01f, 3.93943489e-02f,
  8.12958255e-02f, -4.21032030e-03f, 4.71055806e-01f, 6.30163550e-02f, 1.33388072e-01f, 2.60839134e-01f, -1.83645189e-02f, -1.60903141e-01f, -1.59768343e-01f, 1.90212816e-01f,
  -2.51222908e-01f, -1.20227031e-01f, 1.83071747e-01f, -2.53302962e-01f, 2.69176364e-02f, -9.46119949e-02f, -1.59719184e-01f, -8.34656414e-03f, 1.23488367e-01f, 1.83780976e-02f,
  -7.45126083e-02f, 3.02473515e-01f, 9.05795768e-02f, 1.12010725e-01f, -1.07857451e-01f, -1.50840595e-01f, 8.68502352e-03f, -1.06980704e-01f, 2.82586645e-02f, 5.70789725e-02f,
  -4.62090895e-02f, 2.28376061e-01f, -1.05961397e-01f, 1.50131986e-01f, -1.70434430e-01f, 2.73480356e-01f, 3.65458690e-02f, 2.39786655e-01f, -1.97039440e-01f, -3.87670755e-01f,
  -9.79810953e-02f, -3.21482956e-01f, 6.64720461e-02f, -2.22236708e-01f, 1.27936721e-01f, -2.64221609e-01f, -2.19166651e-01f, 3.22220594e-01f, -2.83219725e-01f, -1.92855299e-02f,
  -9.95677263e-02f, -2.14608178e-01f, -3.73788416e-01f, -2.26651505e-03f, 1.75810903e-01f, 3.04399967e-01f, -1.01577371e-01f, -1.17056832e-01f, 1.98495299e-01f, 5.26622593e-01f,
  6.37237579e-02f, -1.82440151e-02f, 4.05592203e-01f, 3.39620784e-02f, 4.73008044e-02f, -1.60241500e-01f, 6.77932084e-01f, 5.95255978e-02f, -2.01598734e-01f, -2.67653495e-01f,
  3.07539701e-02f, -1.43807083e-01f, 3.13350819e-02f, -4.89525236e-02f, -7.81566650e-02f, -6.16134563e-03f, 2.26991832e-01f, -3.58372718e-01f, -1.01205327e-01f, -1.49932340e-01f,
  -1.66884139e-01f, -3.01233739e-01f, -1.82307094e-01f, 1.00252166e-01f, -5.79924732e-02f, 2.78710932e-01f, -1.21008843e-01f, 2.88642377e-01f, -1.63314551e-01f, 1.28841907e-01f,
  4.22032960e-02f, 1.66014910e-01f, 1.15880497e-01f, 6.47575855e-02f, -1.51061401e-01f, 9.67923328e-02f, -2.41154402e-01f, -1.29432470e-01f, -1.70401797e-01f, 3.22032452e-01f,
  2.08500803e-01f, 3.48854750e-01f, -7.55817443e-02f, -3.32037061e-01f, -1.65401101e-02f, -5.66888392e-01f, 2.24266678e-01f, -3.68197829e-01f, 1.36513382e-01f, 4.45504576e-01f,
  2.41459936e-01f, 9.71778929e-02f, 4.05967802e-01f, 4.92922356e-03f, 7.65929222e-02f, -8.66068974e-02f, -2.87281662e-01f, -1.27611339e-01f, 4.22617525e-01f, -2.71338701e-01f,
  3.21258488e-03f, -7.42766708e-02f, -7.65529424e-02f, 1.16039552e-01f, -2.80053564e-03f, 3.50307912e-01f, 2.99327642e-01f, 5.82872592e-02f, -4.89037447e-02f, -9.96697098e-02f,
  -1.80960849e-01f, -4.95680898e-01f, -2.17846289e-01f, -5.75548187e-02f, 2.07946673e-02f, -1.26066998e-01f, -7.71423206e-02f, 3.31832707e-01f, -7.10797980e-02f, 3.84029061e-01f,
  5.95761202e-02f, 9.25207585e-02f, -7.75659680e-02f, 8.45240653e-02f, 2.57759899e-01f, -6.93442672e-02f, -2.44370297e-01f, -2.19876364e-01f, 1.11271068e-01f, 8.33019242e-03f,
  1.06628805e-01f, 3.76323938e-01f, 7.21242577e-02f, 2.42563903e-01f, 2.06604183e-01f, 6.69023812e-01f, 1.21272271e-02f, 3.31747144e-01f, 2.59222507e-01f, 1.79147527e-01f,
  3.59690189e-01f, 2.20309019e-01f, -3.68552953e-02f, 8.15963596e-02f, 4.65062894e-02f, -2.55283445e-01f, -1.18610747e-02f, -1.86727906e-04f, 4.28047299e-01f, -1.42940804e-01f,
  8.60695553e-04f, 6.59572408e-02f, 2.59498745e-01f, -2.41693914e-01f, -9.78770331e-02f, 7.72388577e-02f, 7.75147453e-02f, -3.10816884e-01f, 1.04871854e-01f, -5.59540205e-02f,
  -3.13871741e-01f, -2.40687374e-03f, -1.66815165e-02f, -2.14130566e-01f, -1.99082300e-01f, 9.58902761e-02f, -4.00332920e-02f, -5.52102476e-02f, -6.65897224e-03f, 4.80309367e-01f,
  5.64288422e-02f, 5.71022667e-02f, -1.75099559e-02f, 1.58243865e-01f, -8.11518729e-02f, 2.17710897e-01f, -2.01742843e-01f, -2.72344202e-01f, 5.01761138e-02f, -1.80238605e-01f,
  -5.23789078e-02f, 1.90873355e-01f, 3.65041755e-02f, 2.45016858e-01f, 4.46157977e-02f, 1.87874679e-02f, 3.19463342e-01f, 3.12397406e-02f, 1.56131834e-01f, 6.36869967e-01f,
  -1.04051724e-01f, 9.89842508e-03f, -8.34590867e-02f, 1.97460800e-01f, -2.20749304e-01f, -1.94259554e-01f, -2.77900640e-02f, -2.51644492e-01f, -3.23511176e-02f, -2.85366029e-01f,
  -2.39402860e-01f, -1.96486026e-01f, -3.30927908e-01f, -2.97358871e-01f, 1.23130828e-01f, -1.09237768e-01f, -4.83642071e-02f, 1.02278396e-01f, 2.61838406e-01f, -2.97088504e-01f,
  4.07059640e-02f, -8.28982070e-02f, -4.05658215e-01f, -2.00488299e-01f, 3.26702446e-01f, -1.17708221e-01f, 1.32073194e-01f, 3.59008521e-01f, 3.60949337e-03f, -1.97101220e-01f,
  -2.25049615e-01f, -5.20988628e-02f, -1.31426841e-01f, 1.50598839e-01f, 4.05552447e-01f, 1.60021260e-01f, -3.17208350e-01f, -1.37534782e-01f, 2.80042201e-01f, -5.35588861e-02f,
  1.29266873e-01f, -1.74270600e-01f, 1.41316637e-01f, 2.13043451e-01f, -2.27389112e-01f, -2.54106373e-02f, 2.42360160e-01f, -1.13617122e-01f, -2.54881650e-01f, -3.41916054e-01f,
  3.89590830e-01f, 6.54252544e-02f, 5.30510023e-02f, 2.62455940e-01f, 1.11553535e-01f, -6.52286261e-02f, -1.62587121e-01f, -2.20666021e-01f, -7.25035295e-02f, 2.25719839e-01f,
  2.19359353e-01f, 2.29749605e-01f, 1.40255671e-02f, 1.58199817e-01f, -5.99458776e-02f, -2.90510863e-01f, 4.06797752e-02f, -3.42755377e-01f, -3.02909434e-01f, -1.10473908e-01f,
  1.88149780e-01f, 1.66939825e-01f, -1.82375208e-01f, 6.49649128e-02f, -3.89627039e-01f, -3.72142851e-01f, 2.10015982e-01f, -9.97353122e-02f, 1.82111606e-01f, -9.05522406e-02f,
  1.98210374e-01f, -1.34955764e-01f, -2.01779276e-01f, 9.92971361e-02f, -2.32076198e-01f, -2.87860692e-01f, -3.14260840e-01f, 2.70049393e-01f, 1.52052999e-01f, 1.88346058e-01f,
  7.74120912e-02f, -1.46385446e-01f, 4.34094742e-02f, 5.59198158e-03f, -1.10499687e-01f, 1.09897211e-01f, 6.97558047e-03f, -1.08543813e-01f, 6.73897624e-01f, -9.80118513e-02f,
  -2.29492739e-01f, 1.04800507e-01f, 3.21721375e-01f, -6.63549826e-02f, 3.24119553e-02f, -8.19918932e-04f, 2.16025472e-01f, -5.17942786e-01f, -1.67529490e-02f, -1.00138970e-01f,
  9.87666175e-02f, -3.58137228e-02f, 4.64135967e-03f, -9.89481434e-02f, 2.12713927e-01f, 1.26117051e-01f, -1.54152326e-02f, 2.86104888e-01f, -4.26310301e-02f, -1.40568912e-01f,
  -5.36567159e-02f, 4.21884395e-02f, 1.09420717e-01f, 5.40250279e-02f, -3.69028449e-01f, -1.83911249e-01f, -8.78206082e-03f, -3.59006226e-01f, 4.51628655e-01f, -2.58570313e-01f,
  -5.25656156e-02f, -1.42868057e-01f, 1.41042009e-01f, -1.02821469e-01f, -5.72499633e-02f, -6.24466129e-02f, 1.18666627e-01f, -3.72265950e-02f, 1.49963871e-01f, -1.96827754e-01f,
  -4.40714099e-02f, -2.03528345e-01f, -4.52275604e-01f, -5.98978326e-02f, 1.82939336e-01f, -1.93039417e-01f, -3.24705839e-01f, -3.98687810e-01f, -1.50717020e-01f, 4.89300817e-01f,
  2.14638129e-01f, 4.59075153e-01f, -1.46784455e-01f, 2.77689576e-01f, -4.50775653e-01f, -1.27917290e-01f, -6.75089434e-02f, -8.94510970e-02f, -1.11010857e-01f, -1.43501773e-01f,
  8.07431638e-02f, -6.59740046e-02f, -2.52906621e-01f, 2.47591212e-01f, -2.93781698e-01f, -7.98251703e-02f, 5.18314168e-02f, 4.28988785e-02f, -1.28531642e-02f, -1.30220726e-01f,
  2.45524809e-01f, -3.70366335e-01f, -3.41807485e-01f, -4.91487980e-02f, 5.95922545e-02f, 8.93371850e-02f, 5.98799177e-02f, 2.90365100e-01f, 1.53903037e-01f, 8.95931125e-02f,
  1.06164753e-01f, -1.33139566e-01f, 7.50927031e-02f, -1.97684318e-01f, 4.37285781e-01f, -3.05146784e-01f, 8.79600048e-02f, 1.73293605e-01f, 3.87731522e-01f, -1.09830648e-01f,
  -7.53244236e-02f, 5.31323135e-01f, 1.99058279e-01f, 2.20650330e-01f, -5.69861941e-02f, -5.01189590e-01f, 5.06084897e-02f, -1.04296729e-01f, -3.24558049e-01f, 2.79700547e-01f,
  8.46580043e-02f, -3.30333263e-01f, -6.79943860e-02f, -9.76406410e-02f, -2.22339302e-01f, 6.88883141e-02f, -2.35461220e-01f, 2.71450374e-02f, 1.37776300e-01f, -3.91003609e-01f,
  4.37084809e-02f, -1.51684523e-01f, 1.89253151e-01f, -6.34362400e-02f, -3.17441136e-01f, 4.68876451e-01f, 1.57327518e-01f, 9.83535126e-02f, 8.38487595e-02f, 3.68863136e-01f,
  4.83386479e-02f, -6.36258051e-02f, -7.69513622e-02f, 2.82685995e-01f, 1.76751912e-02f, -1.06212378e-01f, 4.20283079e-01f, -1.47382811e-01f, 5.09731054e-01f, -2.43969306e-01f,
  9.71672311e-02f, 4.74946909e-02f, 2.21106514e-01f, 4.19974774e-02f, -1.91107139e-01f, 5.78312159e-01f, 9.36894864e-02f, -2.46088523e-02f, -1.38711944e-01f, -1.71955209e-02f,
  -8.13769326e-02f, -5.36710083e-01f, -1.72508314e-01f, -9.84742716e-02f, -7.35356212e-02f, -4.35766615e-02f, -8.63001123e-03f, 1.32472709e-01f, -5.39891757e-02f, -9.92106497e-02f,
  1.49002373e-01f, 1.31472081e-01f, -1.30889669e-01f, 2.41798759e-02f, 1.69178367e-01f, -3.89538020e-01f, -9.83898416e-02f, -3.44830334e-01f, 8.30083191e-02f, -4.55099672e-01f,
  1.21932797e-01f, 2.37864286e-01f, -6.70607239e-02f, -6.77490011e-02f, -1.70218870e-02f, -2.38448575e-01f, 2.50145912e-01f, 4.25680310e-01f, -6.38158396e-02f, 1.80157781e-01f,
  -1.44471735e-01f, -9.03562903e-02f, -2.70668477e-01f, -2.13534206e-01f, -2.77698010e-01f, 3.74556363e-01f, -3.86660635e-01f, 4.21449155e-01f, -8.10038596e-02f, -7.83547061e-04f,
  -3.30730617e-01f, -1.91268027e-01f, -4.13087964e-01f, -1.69377208e-01f, 1.60059214e-01f, -2.56579012e-01f, -8.17675516e-02f, 1.69208035e-01f, -5.25364205e-02f, -2.21080706e-02f,
  -3.90203744e-01f, -5.48013002e-02f, -2.35127911e-01f, -1.27943173e-01f, -2.00042516e-01f, 1.50582436e-02f, -2.46124998e-01f, -1.13861769e-01f, -1.05972916e-01f, -3.99985135e-01f,
  -9.24186409e-02f, 1.93634242e-01f, -9.39837564e-03f, -2.18589976e-01f, 4.24596757e-01f, 2.34750792e-01f, -2.76325405e-01f, 4.66523439e-01f, -7.46363327e-02f, -8.82350877e-02f,
  2.32460909e-02f, -6.79385439e-02f, 2.14065135e-01f, 3.08974218e-02f, 1.91269349e-02f, -1.40456036e-01f, 1.15096204e-01f, -1.73361138e-01f, 1.44071385e-01f, 4.36635092e-02f,
  -9.58733186e-02f, 8.42927471e-02f, 2.64504999e-01f, 4.15109277e-01f, -1.39982849e-01f, -1.99042588e-01f, 2.14868207e-02f, -4.34653968e-01f, 1.45517707e-01f, 1.84031561e-01f,
  3.85408819e-01f, -3.82387191e-01f, 2.08250046e-01f, 4.92761545e-02f, 4.35328595e-02f, 2.23743424e-01f, 1.63385823e-01f, -1.97123230e-01f, -2.15565801e-01f, -2.88079381e-01f,
  1.41899616e-01f, -2.62276769e-01f, 2.09116310e-01f, 3.66372198e-01f, -6.15708753e-02f, 2.77454257e-01f, -4.29536868e-03f, 1.29087403e-01f, -2.06580803e-01f, 6.16450747e-03f,
  1.26222640e-01f, -1.54383853e-01f, 1.96420655e-01f, 2.76310798e-02f, 2.65148699e-01f, 1.46684855e-01f, -3.22898209e-01f, -2.51779854e-01f, 6.77457601e-02f, -8.98425356e-02f,
  -2.21006647e-02f, 6.01044670e-02f, 2.29817554e-01f, 1.04693197e-01f, -1.10780641e-01f, -4.47421297e-02f, -1.09600183e-02f, 3.37686986e-01f, -3.78412455e-01f, 1.29647851e-01f,
  2.33127791e-02f, -1.45874754e-01f, -1.57469928e-01f, 3.13851655e-01f, 2.98843056e-01f, 1.15122952e-01f, -2.71895468e-01f, -4.78139892e-02f, 4.70161848e-02f, -5.74575961e-02f,
  3.15503836e-01f, 5.13428032e-01f, -7.27128908e-02f, 1.52134880e-01f, -3.75041008e-01f, 2.28028238e-01f, -8.83320719e-03f, -2.65716106e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.42619282e-01f, 8.74506161e-02f, 4.03076746e-02f, -1.13810226e-01f, -1.06391616e-01f, 1.21706203e-02f, -1.55969307e-01f, 1.07306406e-01f, 8.76136962e-03f, 6.87785000e-02f,
  1.42972261e-01f, -7.47976005e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    