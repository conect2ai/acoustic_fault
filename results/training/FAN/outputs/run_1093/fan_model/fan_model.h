/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.66600659e-01f, -5.42965531e-02f, -9.55771469e-03f, 6.67853979e-03f, -1.99762613e-01f, -1.60241887e-01f, -1.54385448e-01f, -6.29175678e-02f, -2.87261438e-02f, -1.74124558e-02f,
  7.12275356e-02f, 1.42308593e-01f, 1.00827359e-01f, 4.89726476e-02f, 3.08187455e-02f, -8.26954022e-02f, -2.06740215e-01f, -1.32849678e-01f, 9.38386843e-03f, -3.61624584e-02f,
  -1.46857321e-01f, 2.51810197e-02f, 6.01030290e-02f, -9.82308686e-02f, -1.24034852e-01f, -5.10915270e-05f, -9.62724015e-02f, 5.91899715e-02f, -9.10145342e-02f, -2.29134738e-01f,
  3.95992488e-01f, -7.60638714e-02f, -1.86995372e-01f, -1.23106837e-01f, -8.84327367e-02f, -6.85465485e-02f, -1.69027686e-01f, -1.90566018e-01f, -1.95960194e-01f, -1.46271527e-01f,
  -5.66090718e-02f, -1.19403452e-01f, -1.23110831e-01f, -1.81789510e-02f, -9.05553699e-02f, -1.10866368e-01f, -9.30170417e-02f, -1.95655286e-01f, -1.29347384e-01f, -1.46190509e-01f,
  -1.13028601e-01f, -1.30536482e-01f, -1.07865043e-01f, -1.29760057e-01f, -1.94900170e-01f, -1.53695703e-01f, -6.12862781e-02f, -7.76965544e-02f, -2.29578242e-01f, -1.21970721e-01f,
  -1.67287758e-03f, -3.02770790e-02f, 8.20536762e-02f, 5.93795814e-02f, 1.55208260e-01f, 2.16273852e-02f, 1.11405797e-01f, 6.45865649e-02f, 3.94296870e-02f, 1.00850768e-01f,
  8.57592523e-02f, -3.65116373e-02f, 7.25473389e-02f, -6.56207441e-04f, -1.96639691e-02f, -1.67930443e-02f, 6.52406085e-03f, 5.60927577e-02f, 6.70679435e-02f, 8.92548859e-02f,
  6.08127303e-02f, 7.34367669e-02f, -1.08555118e-02f, 1.28671989e-01f, -1.35627631e-02f, 2.98698358e-02f, 6.83007315e-02f, 7.65994862e-02f, 1.46617457e-01f, 7.66164213e-02f,
  3.11458051e-01f, -2.47548059e-01f, 2.44818162e-02f, -1.84224635e-01f, -8.17080513e-02f, -1.57325968e-01f, -8.89640301e-02f, -6.10783137e-02f, 3.10669485e-02f, -3.57861519e-02f,
  -3.48373838e-02f, -5.66205122e-02f, -1.01905085e-01f, -1.04538448e-01f, -7.96206817e-02f, -2.01116085e-01f, -1.45564482e-01f, -9.61082876e-02f, -1.23153359e-01f, -6.54970109e-02f,
  -5.33365831e-02f, -1.31513596e-01f, 1.62759144e-02f, -1.11189373e-01f, -4.01653573e-02f, -3.58177572e-02f, 3.63240354e-02f, -1.53669463e-02f, -1.15659058e-01f, 9.20932814e-02f,
  -6.64248109e-01f, -8.94135535e-02f, -1.23732112e-01f, -9.17405635e-02f, 2.31550649e-01f, 1.68157816e-01f, 1.04181930e-01f, -2.16172207e-02f, -1.34068131e-02f, -9.72790271e-02f,
  3.43253016e-02f, -2.30692849e-02f, 1.66722406e-02f, 1.30546764e-01f, -6.17865957e-02f, -1.13132559e-01f, -1.76375976e-03f, -1.43074736e-01f, -1.36543289e-01f, 7.10107684e-02f,
  1.84077188e-01f, -9.84150916e-02f, -1.93214342e-01f, -5.11918850e-02f, 3.32529657e-02f, 5.61155789e-02f, 5.98076805e-02f, -2.02827025e-02f, 1.22051768e-01f, -9.32573304e-02f,
  -1.73396111e-01f, -1.11941211e-01f, 6.29712641e-02f, -5.47171719e-02f, -8.92171785e-02f, -1.42280683e-01f, -1.54079735e-01f, -1.42486334e-01f, -7.22949356e-02f, -3.80319506e-02f,
  -2.47459654e-02f, -6.65560886e-02f, -1.14719763e-01f, 1.03963688e-02f, -1.20541893e-01f, -1.25611305e-01f, -9.14836153e-02f, -4.67507541e-02f, -1.33183330e-01f, -1.38318136e-01f,
  1.40411416e-02f, -6.65351152e-02f, -1.45674184e-01f, -2.57883035e-02f, 4.17256653e-02f, 3.70289735e-03f, -3.40806060e-02f, -5.17074615e-02f, -1.53397610e-02f, -8.49918947e-02f,
  -6.90417811e-02f, -1.24387078e-01f, 2.33901124e-02f, -3.10018007e-02f, 3.61871794e-02f, -2.68318621e-03f, 7.81570561e-03f, 3.84760052e-02f, 4.51831073e-02f, 2.23457292e-02f,
  2.99144816e-02f, -4.26068567e-02f, 4.64643911e-02f, 5.59306443e-02f, -4.39391704e-03f, 5.33927865e-02f, 2.77112052e-02f, 4.60221916e-02f, 3.70565951e-02f, 4.59685065e-02f,
  6.72709644e-02f, -3.48030739e-02f, -3.87986675e-02f, 2.41758879e-02f, 1.91601720e-02f, 6.76630735e-02f, 4.55608964e-02f, 8.88853222e-02f, -3.43579240e-03f, -7.53439143e-02f,
  -1.41715974e-01f, -8.07136111e-03f, -1.14729635e-01f, 6.94870064e-03f, -8.60160664e-02f, -5.33172712e-02f, -1.01398826e-01f, -1.08744860e-01f, -3.55404131e-02f, -3.33609581e-02f,
  5.40994331e-02f, -1.73396185e-01f, -1.19670205e-01f, -6.31885380e-02f, -3.58672328e-02f, -9.03590024e-02f, 8.11294746e-03f, -3.90816182e-02f, -1.87077187e-02f, -7.63647556e-02f,
  -1.13751747e-01f, -1.13577016e-01f, -1.01477027e-01f, -1.25717834e-01f, -7.97505900e-02f, -1.67946130e-01f, 4.41580378e-02f, -4.90576327e-02f, -9.34768021e-02f, -2.56099641e-01f,
  3.01592857e-01f, -3.11049670e-01f, 6.12190850e-02f, -6.22053146e-02f, -1.51123047e-01f, -1.83407471e-01f, -3.63017559e-01f, -2.26886392e-01f, 6.80737710e-03f, -9.33642462e-02f,
  -1.32323623e-01f, 3.27309072e-02f, -3.03251520e-02f, 1.78118851e-02f, -2.47731805e-02f, -9.33996961e-02f, -7.37732053e-02f, 5.02590612e-02f, 1.45447209e-01f, -3.18925120e-02f,
  -1.84960499e-01f, 1.37459161e-03f, 1.12239584e-01f, 2.44178064e-03f, -1.19759738e-01f, 6.64463416e-02f, 2.47764564e-03f, 1.91012751e-02f, -1.20574363e-01f, -7.74509385e-02f,
  1.81480959e-01f, -2.32328773e-01f, 4.42882329e-02f, -2.18704134e-01f, -9.50870812e-02f, -4.01316583e-02f, -7.41116628e-02f, -1.29079074e-01f, -1.81377381e-02f, -1.64381079e-02f,
  -1.55776948e-01f, -1.18907548e-01f, -7.63002262e-02f, -7.22918659e-02f, -1.55980229e-01f, -5.81027195e-02f, -1.37732312e-01f, -1.58006493e-02f, 1.56764258e-02f, -1.03601694e-01f,
  -1.84208885e-01f, -1.28037542e-01f, -6.45065457e-02f, -1.06837370e-01f, -1.82887360e-01f, -2.98043084e-03f, -5.23391813e-02f, -2.11323407e-02f, -1.26713842e-01f, -1.03996955e-01f,
  9.63235721e-02f, -1.77509319e-02f, 9.12382603e-02f, 2.01515511e-01f, 1.27302706e-01f, -1.64500121e-02f, 4.31317315e-02f, -6.29513524e-03f, 7.76471198e-02f, 4.36407439e-02f,
  1.75184950e-01f, 1.72496408e-01f, 7.44367987e-02f, 1.24516092e-01f, 4.92127575e-02f, 6.09065667e-02f, 1.10371672e-01f, 1.39089659e-01f, 1.42724410e-01f, 4.82912436e-02f,
  1.34027258e-01f, 7.98043162e-02f, 1.33314222e-01f, 1.14608938e-02f, 1.64723754e-01f, 1.47710174e-01f, 2.68994011e-02f, 1.11906625e-01f, 1.05311267e-01f, 2.82824412e-02f,
  5.38350493e-02f, 1.26111349e-02f, -4.21015881e-02f, -2.90277023e-02f, -4.78142798e-02f, -6.50004148e-02f, -1.12628959e-01f, -1.00707605e-01f, -1.48194090e-01f, -8.58647972e-02f,
  -1.51545554e-01f, -5.71326762e-02f, -5.72674088e-02f, -1.59631625e-01f, -1.66251704e-01f, -1.72179103e-01f, -1.55525163e-01f, -3.95624191e-02f, -1.54725239e-01f, -1.60655662e-01f,
  -5.92437945e-02f, -3.22257653e-02f, 8.27275664e-02f, -3.19979638e-02f, -7.49264434e-02f, -6.35195300e-02f, -7.29565397e-02f, -3.07547692e-02f, 2.39888169e-02f, -3.27326893e-03f,
  2.95004040e-01f, -1.45167649e-01f, 8.55009779e-02f, 4.38464321e-02f, -9.57263727e-03f, 1.09017499e-01f, -2.92869043e-02f, 1.15806073e-01f, -5.78965545e-02f, 2.06078961e-03f,
  9.51144472e-02f, 1.38523147e-01f, -1.88936125e-02f, -3.27075161e-02f, 9.19215977e-02f, -4.04368900e-02f, -1.09685868e-01f, 9.82437506e-02f, 1.09041274e-01f, 6.05678037e-02f,
  -1.22049809e-01f, 3.46902870e-02f, 9.95347202e-02f, -2.35272050e-02f, -1.13606662e-01f, -1.50361523e-01f, -2.32718885e-01f, -1.52783051e-01f, -1.86168969e-01f, -3.14719349e-01f,
  8.22774172e-02f, 1.71375588e-01f, 2.61044744e-02f, -3.01208720e-02f, 2.31785737e-02f, 1.60285607e-02f, -1.11852102e-02f, -3.31872627e-02f, -1.59239382e-04f, 6.20623641e-02f,
  5.95776029e-02f, 3.35231959e-03f, 3.09090912e-02f, -5.01224063e-02f, 2.01189909e-02f, -1.70298871e-02f, 1.70160327e-02f, 4.85931598e-02f, -4.65062372e-02f, -1.16376013e-01f,
  -1.73393145e-01f, -1.72209173e-01f, -1.06336118e-03f, -4.90933880e-02f, -1.18045151e-01f, 4.23262902e-02f, -1.54978737e-01f, -7.74554312e-02f, -1.07013464e-01f, -1.05133206e-01f,
  4.18697149e-02f, -1.54928621e-02f, 5.46758063e-02f, -8.05745646e-03f, 2.11510509e-02f, 5.98990312e-03f, 3.18075716e-02f, -2.00392410e-01f, 3.85908186e-02f, -5.51406145e-02f,
  1.39972363e-02f, -5.46412580e-02f, -1.07367925e-01f, -8.65514055e-02f, -5.98809943e-02f, -7.51484111e-02f, 1.56102870e-02f, -4.89066653e-02f, -7.41020367e-02f, -9.07149464e-02f,
  6.11862689e-02f, 2.11980604e-02f, 7.24589601e-02f, 3.74173466e-03f, 5.56703843e-02f, 3.83484438e-02f, 1.02661476e-01f, 7.82919824e-02f, 5.06131984e-02f, 5.94321080e-02f,
  5.39000556e-02f, 1.90595418e-01f, -2.96128038e-02f, 1.33122405e-04f, 5.29296584e-02f, -2.10859589e-02f, 4.49194713e-03f, -3.07158679e-02f, -2.46845894e-02f, 2.99367215e-02f,
  -5.71191311e-03f, 1.10300362e-01f, -3.32611687e-02f, 2.61337007e-03f, -4.95369472e-02f, 3.83984931e-02f, -1.15882106e-01f, -9.78185162e-02f, -2.88906172e-02f, -5.22964029e-03f,
  -7.43098930e-02f, -6.51632398e-02f, 3.82447243e-02f, 1.33626619e-02f, -5.02971932e-02f, -1.06023587e-02f, 4.61769775e-02f, -1.10716239e-01f, 9.64752734e-02f, -4.82205302e-03f,
  4.17571992e-01f, 7.58035574e-03f, 1.40403911e-01f, -1.05799906e-01f, -9.06081051e-02f, 5.92844225e-02f, 1.48764819e-01f, 1.52051719e-02f, -1.25503212e-01f, 3.78738493e-02f,
  -8.86694640e-02f, -4.43447530e-02f, -1.03131339e-01f, -8.98626968e-02f, 1.26223296e-01f, 3.52434218e-02f, -1.06349915e-01f, 7.62287229e-02f, 1.33111849e-01f, 4.97741215e-02f,
  -1.37999952e-01f, 3.37065011e-02f, 4.51304242e-02f, -4.36299061e-03f, -4.02340405e-02f, -2.09517069e-02f, 1.37263114e-05f, 5.02351560e-02f, 8.94646719e-02f, -6.74738456e-03f,
  7.43127316e-02f, -1.42312627e-02f, 2.54645795e-02f, -3.62432487e-02f, -3.85285579e-02f, 8.83719884e-03f, -8.33826140e-03f, 4.81868386e-02f, -7.39322305e-02f, 5.20511605e-02f,
  -7.83191100e-02f, -5.49646504e-02f, -7.67271370e-02f, -9.60115194e-02f, -1.15379907e-01f, 2.79020378e-03f, -4.21899632e-02f, 2.27084886e-02f, -4.88165319e-02f, -2.29696464e-02f,
  -1.56734511e-01f, -6.33859262e-02f, 2.62648221e-02f, 3.87021080e-02f, -1.13686258e-02f, -8.85642786e-03f, 5.47049567e-02f, 8.60918984e-02f, 7.94846788e-02f, 1.43424183e-01f,
  1.47755533e-01f, -3.94683033e-02f, -7.01692551e-02f, 8.86928290e-02f, 1.16616137e-01f, 5.52574592e-03f, 3.06095425e-02f, -2.27661077e-02f, 7.42393732e-03f, -2.98196245e-02f,
  4.13313024e-02f, 1.09634712e-01f, -2.48829904e-03f, 1.29353642e-01f, -7.74074495e-02f, -3.03763747e-02f, -1.47078596e-02f, -5.33766374e-02f, 1.70674518e-01f, -2.33489461e-02f,
  -1.08420094e-02f, 6.13928884e-02f, -2.99334638e-02f, 4.71773334e-02f, 9.47860107e-02f, -1.07969493e-02f, 2.58676261e-02f, 6.32810146e-02f, 1.20881207e-01f, 1.04819998e-01f,
  -7.24133570e-04f, -1.76067054e-01f, 1.27992332e-01f, -2.30635554e-02f, 7.47506022e-02f, 6.38323054e-02f, -2.11846307e-02f, 6.71478584e-02f, 4.22128476e-03f, 1.14900447e-01f,
  5.73618449e-02f, 1.50816023e-01f, 4.80054989e-02f, -1.91693883e-02f, 5.61194792e-02f, 8.87606367e-02f, -2.86015663e-02f, -2.38687675e-02f, 1.45354094e-02f, 1.55975437e-03f,
  -1.26484791e-02f, 3.84597201e-03f, 2.80286316e-02f, 1.11058997e-02f, 4.82723117e-02f, 8.37937370e-02f, 1.26446545e-01f, 1.38776720e-01f, 1.75030351e-01f, 1.86714426e-01f,
  -1.07484162e-01f, -2.17926130e-01f, 1.17396466e-01f, -6.18631346e-03f, -3.79877612e-02f, -5.09601049e-02f, 4.61025387e-02f, -3.73046026e-02f, 2.33646631e-02f, -2.74911989e-02f,
  -1.79122567e-01f, -1.49951041e-01f, -1.26176745e-01f, -8.12651813e-02f, 3.52264531e-02f, 1.80974469e-01f, 1.47827014e-01f, 6.46414608e-02f, -2.86572613e-02f, -6.02143146e-02f,
  -1.25783518e-01f, -1.88822355e-02f, -1.11425091e-02f, -1.11065954e-01f, 8.94617289e-03f, -4.35604490e-02f, -7.27957934e-02f, -3.34983766e-02f, -9.07208920e-02f, 2.53113717e-01f,
  7.97893330e-02f, 7.95552582e-02f, 1.59052134e-01f, 1.62111428e-02f, 6.76369518e-02f, 4.39019827e-03f, -2.43070479e-02f, 5.15046045e-02f, -1.37298210e-02f, 3.86609659e-02f,
  -2.22224295e-02f, -2.18780581e-02f, 1.16453677e-01f, 9.38249752e-02f, 1.34522751e-01f, 3.62237096e-02f, 1.01371691e-01f, 1.38189912e-01f, 6.79007173e-02f, 6.81389170e-03f,
  -2.18361802e-02f, 3.60869914e-02f, -2.11975072e-02f, 4.03310135e-02f, 1.40030116e-01f, -3.38811316e-02f, 5.14557250e-02f, 1.10673659e-01f, 1.02017030e-01f, 7.72857368e-02f,
  -2.24542599e-02f, -5.43023907e-02f, -1.09372728e-01f, -2.85263434e-02f, -2.21075378e-02f, -6.45251423e-02f, -1.29818097e-01f, -1.13237686e-01f, -1.75526310e-02f, -1.35889009e-01f,
  -1.39022946e-01f, 8.01259838e-03f, -9.14016739e-02f, -4.69357185e-02f, -9.86317359e-03f, -5.62657043e-02f, 1.08852731e-02f, -7.55155012e-02f, -1.22267611e-01f, -1.04868144e-01f,
  -3.48116197e-02f, -3.92305367e-02f, -1.09832436e-01f, -1.30328229e-02f, -1.71429262e-01f, -6.05978593e-02f, -3.72781418e-02f, -2.23947778e-01f, -1.62974387e-01f, -7.31359720e-02f,
  -4.31239652e-03f, -1.48416832e-01f, 8.16129446e-02f, 9.06221792e-02f, -1.35284495e-02f, 6.55284300e-02f, 4.47226278e-02f, 1.66486837e-02f, 3.86145934e-02f, 3.76127213e-02f,
  -8.93646628e-02f, -6.52381778e-03f, -6.08215891e-02f, 1.56627968e-02f, 5.86543120e-02f, -5.53333983e-02f, 3.93756032e-02f, -6.16099462e-02f, 4.00427217e-03f, -3.89580168e-02f,
  4.89846170e-02f, 3.74605581e-02f, 8.15411843e-03f, 6.18230961e-02f, 5.25669195e-02f, -2.86454265e-03f, 3.86291742e-02f, -1.43572697e-02f, 1.48826819e-02f, 5.55711193e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.18478903e-01f, -8.60541984e-02f, -1.83009896e-02f, -2.03854367e-01f, -1.95735171e-01f, -1.34193420e-01f, -9.65084955e-02f, -1.47730876e-02f, -7.98206553e-02f, -1.34282961e-01f,
  1.20644212e-01f, 2.84346282e-01f, 1.68484285e-01f, 1.85020536e-01f, 2.36572638e-01f, -1.41815528e-01f, -2.72764653e-01f, 3.72861400e-02f, 7.75646791e-02f, 1.12933092e-01f,
  1.36291757e-01f, -1.28187954e-01f, 6.03291243e-02f, 8.73484462e-02f, -6.66286871e-02f, -8.54682252e-02f, -2.27157593e-01f, -1.81632355e-01f, -1.24437660e-01f, -3.02420944e-01f,
  3.49722654e-02f, -6.70136958e-02f, 3.48267294e-02f, -9.24432091e-03f, -1.56538412e-01f, 1.95178520e-02f, -8.15425068e-02f, -8.78388211e-02f, -8.26449245e-02f, -5.98550551e-02f,
  -5.98803759e-02f, 5.96797206e-02f, 3.11380345e-02f, 2.36431956e-02f, 1.79011561e-02f, -1.28946146e-02f, -2.11733729e-02f, -5.80765754e-02f, -9.94014964e-02f, 1.10918254e-01f,
  4.44131680e-02f, -1.31104708e-01f, 1.00079186e-01f, 3.00300978e-02f, -7.63737485e-02f, -1.61014885e-01f, -7.22400621e-02f, -2.45058332e-02f, -3.62577848e-02f, -1.93158761e-01f,
  -2.70892400e-02f, 5.67792319e-02f, 1.17426105e-01f, 8.71597081e-02f, 1.41323224e-01f, 1.05855125e-03f, -2.98278723e-02f, 3.94891985e-02f, -4.76522967e-02f, 7.88010210e-02f,
  1.53261432e-02f, -4.63514924e-02f, -4.20281105e-02f, -6.40940592e-02f, -5.70868924e-02f, -5.01371659e-02f, -2.65763942e-02f, 1.56652674e-01f, 5.15865386e-02f, 2.61606928e-02f,
  9.14847031e-02f, -3.36229503e-02f, 2.31214110e-02f, 2.66901311e-03f, 6.03015013e-02f, -8.33714902e-02f, -2.62495428e-02f, 1.06718607e-01f, 4.08747606e-02f, 5.53684495e-02f,
  1.13003507e-01f, -2.21854717e-01f, 2.46209186e-02f, -7.50305355e-02f, -1.37641272e-02f, 4.01963405e-02f, -7.28406236e-02f, -1.96664128e-02f, 3.41218896e-02f, 7.75825232e-02f,
  9.89008043e-03f, -1.54496375e-02f, 1.17438836e-02f, 1.15838245e-01f, 1.35142356e-02f, -5.76689988e-02f, 5.62326461e-02f, -2.94197965e-02f, 5.48654720e-02f, -6.32061763e-03f,
  7.34982267e-02f, 5.65615706e-02f, 6.24370463e-02f, -7.82975033e-02f, -4.47353534e-02f, 4.28100899e-02f, 6.06735721e-02f, 1.10930435e-01f, -3.40644573e-03f, -9.63792130e-02f,
  5.19564271e-01f, -3.40537310e-01f, 6.75293282e-02f, 1.84333667e-01f, -1.52889188e-05f, 2.44164959e-01f, 1.46390582e-02f, 6.39247745e-02f, 1.91612855e-01f, 3.16219889e-02f,
  -5.71377063e-03f, -3.15529406e-02f, 8.44654813e-02f, -4.50976193e-02f, 7.88061619e-02f, -1.43043697e-01f, -5.66165783e-02f, 1.08503297e-01f, 3.39924634e-01f, 1.20505907e-01f,
  -5.73759414e-02f, -3.52975987e-02f, 1.51508555e-01f, 8.93183947e-02f, -2.78892726e-01f, 5.08745313e-02f, -1.77656740e-01f, -5.63670397e-02f, -6.59236461e-02f, -3.02411824e-01f,
  1.41188623e-02f, -6.77861422e-02f, 1.68540597e-01f, -5.57292365e-02f, -7.99006224e-02f, 2.29647402e-02f, 2.04195917e-01f, 2.69079264e-02f, -2.65250877e-02f, 3.80196981e-02f,
  -6.57822043e-02f, -4.88187857e-02f, -6.35289326e-02f, -5.90403602e-02f, -1.01371899e-01f, -1.21861719e-01f, -5.08506857e-02f, -6.05791323e-02f, 7.05957506e-03f, -1.76690333e-02f,
  -1.02623582e-01f, 1.42625840e-02f, -1.22110680e-01f, 3.35546806e-02f, -1.10457793e-01f, 2.20482927e-02f, -1.59521237e-01f, -2.03648563e-02f, 1.96797922e-02f, 1.67267714e-02f,
  1.30476221e-01f, 8.20354819e-02f, 8.34374502e-03f, -5.36316074e-02f, 1.02259573e-02f, -1.01657711e-01f, -9.27097127e-02f, -2.52069682e-02f, -1.27728596e-01f, 3.79375950e-03f,
  -6.74215555e-02f, 1.24300057e-02f, 1.51704075e-02f, -2.31648330e-02f, 2.60460488e-02f, -2.57356316e-02f, -8.01864788e-02f, 1.83678754e-02f, -6.38717264e-02f, -6.45850524e-02f,
  -9.70859602e-02f, -2.25247219e-02f, 4.12349254e-02f, -1.59746408e-01f, -6.82583749e-02f, 1.44284025e-01f, 4.15281989e-02f, -5.25185950e-02f, -4.48744632e-02f, 2.32295860e-02f,
  -1.55058295e-01f, 9.27505121e-02f, 9.29215774e-02f, -4.53808345e-02f, -2.52291206e-02f, -1.09083198e-01f, 5.27133234e-04f, -1.42074144e-02f, 2.02873554e-02f, 1.12405613e-01f,
  1.46424854e-02f, 4.92212288e-02f, -1.28002055e-02f, -1.38544038e-01f, -1.06830917e-01f, -2.91073546e-02f, -1.48595512e-01f, 1.09499507e-01f, -2.77956109e-02f, -1.85875762e-02f,
  -2.38342196e-01f, 4.68181558e-02f, 1.20208375e-01f, 1.72887259e-04f, -4.86036483e-03f, 1.23563841e-01f, -2.68104672e-02f, 5.84349185e-02f, 8.09372962e-02f, 3.85664552e-02f,
  -6.63633287e-01f, -3.06620598e-01f, 2.69749284e-01f, -5.90800941e-01f, -2.40396246e-01f, 7.02708736e-02f, -1.30922183e-01f, -1.83975086e-01f, -2.96821892e-01f, -2.32967094e-01f,
  -1.99614719e-01f, -8.65408853e-02f, -1.37269190e-02f, 1.53699040e-01f, 8.05719718e-02f, -1.77795559e-01f, -1.62345618e-01f, 2.10011661e-01f, 5.26762187e-01f, 2.80928254e-01f,
  -6.46163002e-02f, -1.23464964e-01f, 6.94077760e-02f, 1.24188915e-01f, -1.65893734e-01f, 4.62826230e-02f, -7.15538561e-02f, -1.15107819e-01f, 5.83524220e-02f, -3.41198593e-01f,
  2.15484843e-01f, -1.37816668e-01f, -1.67951938e-02f, -1.16600603e-01f, -2.09368780e-01f, -9.54195559e-02f, -2.94171199e-02f, -7.86724761e-02f, -1.03455909e-01f, -1.62868083e-01f,
  -1.43781126e-01f, -9.68005210e-02f, 2.54122745e-02f, -3.68465036e-02f, 2.70435642e-02f, -7.42300972e-02f, 2.81236097e-02f, -1.02404401e-01f, 1.39616113e-02f, 7.50496909e-02f,
  6.06140420e-02f, -1.02405719e-01f, 9.80666503e-02f, 1.11153416e-01f, 1.30629405e-01f, 2.72099823e-02f, -1.51644805e-02f, 9.29414779e-02f, 2.84694042e-02f, -1.45567119e-01f,
  -2.00978061e-03f, 7.39243999e-02f, 2.44162657e-04f, 3.17030326e-02f, 8.03298652e-02f, 2.34887227e-02f, -1.98483281e-02f, 4.71471995e-02f, 6.88735917e-02f, 3.81861813e-02f,
  2.47058384e-02f, -4.17617448e-02f, -6.70093521e-02f, -5.61196245e-02f, -2.80980542e-02f, -1.44609809e-01f, 3.71100847e-03f, 1.89439813e-03f, -7.58448839e-02f, -6.55340105e-02f,
  -5.44247888e-02f, -7.68713132e-02f, -1.09927960e-01f, 1.18041210e-01f, -7.65796080e-02f, -5.92791243e-04f, -1.47338593e-02f, 1.01720646e-01f, -1.49570582e-02f, 4.66322489e-02f,
  -6.30555674e-02f, 1.58652350e-01f, -1.55292168e-01f, -9.86165702e-02f, -2.89861299e-02f, -2.78236484e-03f, -8.86665285e-02f, -1.35777667e-02f, -8.38665962e-02f, 2.08946131e-02f,
  6.28840178e-02f, -4.41240147e-02f, -3.57023738e-02f, -6.11851662e-02f, 7.75537789e-02f, -1.64720081e-02f, -4.34720404e-02f, -9.72404629e-02f, 1.62951816e-02f, -9.53197703e-02f,
  -6.29015267e-02f, 5.85261174e-02f, -1.47653511e-02f, 1.06339894e-01f, 7.33551309e-02f, 1.69020116e-01f, 1.59019753e-01f, 7.45532364e-02f, 9.64256898e-02f, -6.30372018e-02f,
  4.47019398e-01f, 2.81593710e-01f, 1.65324971e-01f, 1.22443013e-01f, 1.93509698e-01f, 2.00533405e-01f, 3.57604951e-01f, 1.50433391e-01f, -2.45444283e-01f, 5.80875613e-02f,
  5.62842973e-02f, 6.86128763e-03f, -3.52263008e-03f, -9.24271941e-02f, 9.55005139e-02f, -1.21914614e-02f, -1.21852145e-01f, -4.29461226e-02f, 1.89052150e-01f, 6.46848977e-02f,
  -1.20423786e-01f, -1.47320703e-02f, 2.15387255e-01f, -6.27480745e-02f, -2.17161417e-01f, -8.92668217e-02f, -1.55361831e-01f, 1.13497339e-01f, -3.50463344e-03f, -3.88167620e-01f,
  7.33460486e-02f, 2.51885056e-01f, -1.51402608e-01f, -3.38420346e-02f, 9.96982530e-02f, -7.66248256e-02f, 8.33049230e-03f, -4.66349907e-02f, 1.17323622e-02f, -1.40512899e-01f,
  2.97890976e-03f, 1.36895692e-02f, 2.95158066e-02f, 3.60516831e-02f, -3.07859317e-03f, 4.15542275e-02f, 6.19144998e-02f, 1.91515181e-02f, -1.06260665e-02f, -7.66828423e-03f,
  -8.72911960e-02f, 1.67999491e-01f, 2.09326804e-01f, 9.81320627e-03f, 2.09718314e-03f, 9.06589925e-02f, 1.13267228e-01f, 3.88664193e-02f, 7.21981823e-02f, -1.15018211e-01f,
  -1.61269773e-02f, 3.74610387e-02f, 1.41919598e-01f, 3.07352804e-02f, 4.12205309e-02f, -8.87378976e-02f, -4.31314632e-02f, -3.14961150e-02f, 3.96002550e-03f, 6.35440946e-02f,
  1.65452361e-02f, 9.09708738e-02f, 1.33542165e-01f, 1.13766575e-02f, -9.46971178e-02f, -5.61689325e-02f, 9.22268927e-02f, -2.42080409e-02f, 9.42385988e-04f, 1.52086630e-01f,
  8.83821175e-02f, -2.41984334e-02f, 1.12117985e-02f, -3.11241187e-02f, 3.04359868e-02f, 8.30339044e-02f, -1.06148623e-01f, -3.66831832e-02f, -5.60397655e-02f, 1.56318843e-02f,
  -8.28862637e-02f, 1.94246888e-01f, -1.90194637e-01f, -1.01652436e-01f, -2.14464609e-02f, -1.06386557e-01f, -8.74432698e-02f, -1.54974848e-01f, 1.63616631e-02f, -3.89298797e-02f,
  8.67181942e-02f, -1.16811492e-01f, 3.22284847e-02f, -2.01792852e-03f, -4.40957248e-02f, -8.72688368e-02f, -1.07848145e-01f, -3.03692129e-02f, -1.37933542e-03f, -9.50162932e-02f,
  -8.43041986e-02f, -3.62749472e-02f, 1.73366852e-02f, -7.93509856e-02f, -7.88353756e-02f, -4.44986038e-02f, -3.05272248e-02f, -8.01470503e-02f, 5.92911057e-02f, -1.63455650e-01f,
  -2.26549461e-01f, -2.86795884e-01f, 9.68335941e-02f, -1.58373266e-01f, -1.21895917e-01f, -1.61034510e-01f, -3.88500810e-01f, -2.36294851e-01f, -1.40844196e-01f, -2.11350754e-01f,
  -1.19819410e-01f, 7.31128678e-02f, 2.26271138e-01f, 1.24210879e-01f, 4.23047096e-02f, -2.95418888e-01f, -2.83053488e-01f, 1.67365223e-01f, 2.16081828e-01f, -1.43743649e-01f,
  -3.98444720e-02f, 3.22148502e-02f, 1.77376777e-01f, 1.27790809e-01f, -1.16254032e-01f, 1.13808692e-01f, -2.03018039e-02f, 6.00795113e-02f, 1.39592523e-02f, -1.34976387e-01f,
  6.65825754e-02f, -3.24352309e-02f, 4.09077108e-02f, -5.05067632e-02f, 9.81164873e-02f, -3.15536768e-03f, 8.67191255e-02f, -7.03824610e-02f, 6.78676739e-02f, 5.51637299e-02f,
  -3.87009233e-02f, -6.88126609e-02f, 7.34671280e-02f, 3.51832248e-03f, -1.86465830e-01f, -8.41353387e-02f, -2.99238577e-03f, 2.12960388e-03f, 1.61191951e-02f, -1.07079193e-01f,
  -1.95756227e-01f, -9.80720017e-03f, 1.20606497e-01f, -7.04169422e-02f, -9.93957296e-02f, 1.32629439e-01f, -2.14617699e-02f, -2.27955636e-03f, 7.16472194e-02f, 5.12429476e-02f,
  -1.54320523e-01f, -5.44607863e-02f, -1.47712743e-02f, 8.22489411e-02f, 9.40969512e-02f, -1.10197738e-01f, 3.64561863e-02f, 1.06287979e-01f, 2.58587697e-03f, 3.60564739e-02f,
  4.94858436e-03f, -2.20245905e-02f, 1.32348776e-01f, -2.60443203e-02f, -5.73909562e-03f, 2.76912842e-02f, -3.56465764e-02f, -3.64368334e-02f, 8.78923684e-02f, 5.64656314e-03f,
  7.72653371e-02f, 3.96226682e-02f, -2.46236064e-02f, 2.42180601e-02f, -1.54778153e-01f, -2.48387232e-02f, -1.21362261e-01f, -1.34133741e-01f, 1.54325115e-02f, -8.03839322e-03f,
  1.01561345e-01f, -9.00208279e-02f, -1.76912084e-01f, -8.19540545e-02f, -6.39223978e-02f, 4.94185463e-02f, 2.60480382e-02f, -6.13777116e-02f, -3.03769819e-02f, -6.54016137e-02f,
  -2.91853640e-02f, -7.11314455e-02f, 8.78836811e-02f, -1.10026233e-01f, 2.66513210e-02f, -1.02077000e-01f, -1.05412118e-01f, 6.83500320e-02f, -4.06680210e-03f, -7.40485713e-02f,
  -1.86273888e-01f, -5.32063805e-02f, 4.67417538e-02f, -4.50033993e-02f, -3.56415138e-02f, 1.50176629e-01f, 7.28598610e-02f, -1.33622391e-03f, -1.32540703e-01f, 3.65534723e-02f,
  4.40439224e-01f, 4.04732823e-01f, 4.32837978e-02f, 9.05002505e-02f, -2.28213668e-02f, 1.33596209e-03f, 1.25514224e-01f, 2.69014016e-02f, -4.29236181e-02f, -7.36623490e-03f,
  1.29221063e-02f, -6.08783364e-02f, -3.88889797e-02f, -6.97915927e-02f, -3.48289199e-02f, 1.21761383e-02f, 6.16181158e-02f, -1.00634299e-01f, -8.91457275e-02f, -9.99372974e-02f,
  -4.82795906e-04f, 2.09444955e-01f, 4.23459187e-02f, -3.45203318e-02f, 7.65509903e-02f, -8.55778717e-03f, -5.39663136e-02f, 2.13893160e-01f, -3.74435335e-02f, 2.63457894e-01f,
  1.40070930e-01f, 3.34127307e-01f, -1.84800461e-01f, -9.03534144e-02f, 2.95404810e-02f, -6.21940419e-02f, -3.49453352e-02f, -9.86611471e-02f, -6.75622821e-02f, -1.97499730e-02f,
  2.21695289e-01f, 4.29489128e-02f, 6.50828555e-02f, 1.44584449e-02f, 9.15486366e-02f, -9.19519812e-02f, -9.68613382e-03f, 4.69195321e-02f, -1.24818623e-01f, -1.20760659e-02f,
  -7.54349604e-02f, 2.64349375e-02f, -1.10818101e-02f, -1.38253570e-01f, -3.75197344e-02f, -8.55309293e-02f, 2.79525891e-02f, 5.23372926e-02f, -1.35267466e-01f, 1.40478425e-02f,
  -3.03550094e-01f, -7.87427202e-02f, 2.61180126e-03f, -1.33711562e-01f, -1.11447789e-01f, 1.12710491e-01f, -1.22171767e-01f, -8.73506144e-02f, -1.08791478e-01f, -1.05098709e-01f,
  -1.67920560e-01f, -1.50016978e-01f, -8.82864371e-02f, -1.27476200e-01f, -1.21859580e-01f, -3.56391408e-02f, -3.27525698e-02f, -1.53285086e-01f, -2.18963236e-01f, 3.44342645e-03f,
  -9.16021839e-02f, -8.52545500e-02f, -4.45191609e-03f, -2.83920094e-02f, 4.60473541e-03f, -1.22137934e-01f, -1.32928997e-01f, -6.32593408e-02f, 2.05611046e-02f, 1.00219108e-01f,
  5.74122556e-02f, -2.44034514e-01f, -1.26787499e-01f, 3.31866629e-02f, 2.28938878e-01f, 3.05441004e-04f, -7.74877891e-02f, -5.21666557e-02f, -2.42738873e-02f, -1.39707282e-01f,
  1.97218046e-01f, 5.64032830e-02f, 3.03221624e-02f, -5.68534993e-02f, -1.09416008e-01f, -1.34152055e-01f, -1.21120751e-01f, -5.52192815e-02f, 8.42624903e-03f, 1.40162213e-02f,
  -7.05678612e-02f, -2.19979465e-01f, -1.42813087e-01f, -2.44916335e-01f, -8.62190947e-02f, -2.93429762e-01f, -8.63506570e-02f, 4.15817797e-02f, -1.12318680e-01f, -9.51928198e-02f,
  -2.23004352e-02f, 5.33761382e-01f, 5.80678917e-02f, -3.57427187e-02f, 1.89268783e-01f, 2.93305278e-01f, 4.42376316e-01f, 2.60867834e-01f, 2.55490374e-02f, 2.02787250e-01f,
  3.13531071e-01f, -2.06863344e-01f, -2.97160536e-01f, -3.02939117e-01f, -7.87219480e-02f, 8.90713185e-02f, -5.85775971e-02f, -2.99960256e-01f, -4.72073942e-01f, -8.06893781e-03f,
  -1.35299399e-01f, -9.44825485e-02f, -1.45441413e-01f, -1.93173140e-01f, -1.73171565e-01f, -3.80681276e-01f, -1.11154102e-01f, 1.17167771e-01f, -1.97145529e-02f, -1.84752524e-01f,
  -6.96496069e-02f, 2.64956951e-01f, -2.19878972e-01f, 3.50878537e-02f, 3.04497629e-02f, -7.45275542e-02f, 1.56343244e-02f, -6.16112016e-02f, 4.45384942e-02f, 1.28216535e-01f,
  9.79838297e-02f, 4.52530431e-03f, 2.11173147e-02f, 5.62800765e-02f, 9.52081196e-03f, 1.04559578e-01f, 7.72145987e-02f, 4.83638681e-02f, 5.93631789e-02f, 6.71546087e-02f,
  7.31159821e-02f, 2.46788964e-01f, 2.35479847e-01f, 9.76744741e-02f, 4.82902490e-02f, -7.00395405e-02f, 1.75459817e-01f, 6.23165555e-02f, 1.08220298e-02f, -7.81343952e-02f,
  6.14457950e-02f, 7.58440644e-02f, 3.62283513e-02f, 6.66325465e-02f, 5.36233857e-02f, 1.16334394e-01f, -8.13943967e-02f, 4.55776192e-02f, -3.85012850e-02f, -9.39349383e-02f,
  1.20959520e-01f, -1.61493961e-02f, 1.69660021e-02f, 8.32484569e-03f, -1.39191195e-01f, -5.24305850e-02f, -3.17674801e-02f, -3.46761197e-02f, 3.30817662e-02f, 7.20115826e-02f,
  -2.22766493e-02f, -7.62030855e-03f, -4.43117544e-02f, 2.32555363e-02f, 1.12131298e-01f, -3.71282175e-02f, 3.71992961e-02f, 1.19061798e-01f, -6.82374183e-03f, 6.00619875e-02f,
  -1.19992413e-01f, 9.05891880e-03f, -2.44521856e-01f, -4.19534855e-02f, -5.08205928e-02f, 5.64832166e-02f, 1.14492066e-02f, 2.42622327e-02f, 1.07762389e-01f, 4.93011028e-02f,
  1.89203054e-01f, 1.81380827e-02f, 4.62556109e-02f, 2.43659113e-02f, -2.67131757e-02f, -4.61696461e-02f, 1.06511906e-01f, -1.36146381e-01f, -5.46391197e-02f, 1.37196872e-02f,
  5.47807552e-02f, 7.54143372e-02f, 1.47597184e-02f, -4.44503799e-02f, -2.46368684e-02f, -1.74259365e-01f, -1.01837501e-01f, -6.53964281e-02f, -1.43819049e-01f, -1.60896685e-02f,
  3.32641959e-01f, 1.25205547e-01f, 1.60995379e-01f, 1.13515019e-01f, -4.31157462e-03f, -3.15165997e-01f, -2.96033204e-01f, -1.36074483e-01f, -1.43877581e-01f, 1.22043885e-01f,
  -2.89844275e-02f, -6.02975721e-03f, 3.66856679e-02f, -9.69223082e-02f, -8.79824907e-02f, 5.39154783e-02f, 2.68763695e-02f, 8.69049281e-02f, -2.56932229e-01f, -2.02647462e-01f,
  4.20648195e-02f, -3.76001769e-03f, 3.72235924e-02f, -5.83355911e-02f, 1.84081852e-01f, -1.12141162e-01f, 1.02250338e-01f, 6.53742105e-02f, 1.03099393e-02f, 3.32614034e-01f,
  3.34405273e-01f, 2.84629583e-01f, -2.65463293e-01f, 6.65517151e-02f, 1.23531327e-01f, 1.44027367e-01f, 8.43821764e-02f, 1.01129413e-01f, -1.16437219e-01f, 4.26282920e-03f,
  5.01951724e-02f, 1.32851541e-01f, 3.51333022e-02f, -1.15941994e-01f, 2.44118813e-02f, -7.85994083e-02f, 2.76072901e-02f, 3.98722626e-02f, 2.25400720e-02f, -4.24511544e-02f,
  3.34710721e-03f, -3.94877754e-02f, -8.09288677e-03f, -2.04897359e-01f, -1.25755101e-01f, -1.04956791e-01f, -1.45157084e-01f, -1.61185320e-02f, -8.36436972e-02f, 8.44216123e-02f,
  -2.49997173e-02f, 9.01932716e-02f, 5.25614172e-02f, 1.85675785e-01f, 9.88680869e-02f, -3.05537577e-03f, 5.32863773e-02f, -3.70626710e-02f, -1.29603356e-01f, 7.59755448e-02f,
  -1.14307873e-01f, 6.90425932e-02f, 1.38496235e-01f, 7.78993443e-02f, 2.32161619e-02f, 9.07807425e-02f, -6.39372170e-02f, 2.22781599e-02f, 4.74005975e-02f, 1.04929261e-01f,
  -2.08097696e-02f, -6.91457987e-02f, 4.43333238e-02f, -1.66003853e-02f, -6.17786571e-02f, 1.28366530e-01f, 1.26754254e-01f, -4.43878062e-02f, -5.04596122e-02f, 2.23690078e-01f,
  -5.79474792e-02f, -8.26083943e-02f, 1.96260333e-01f, 1.17762826e-01f, 1.97030813e-01f, -1.18380617e-02f, 5.58338724e-02f, -1.08272187e-01f, 7.64778778e-02f, -4.00060527e-02f,
  -1.20881788e-01f, -1.39406240e-02f, -1.06402319e-02f, -8.54601488e-02f, -2.56933235e-02f, -1.45891070e-01f, 1.07942820e-02f, -4.31094542e-02f, -6.39617592e-02f, 1.18154604e-02f,
  -2.16403186e-01f, -2.39795387e-01f, -2.89573371e-01f, -1.03505090e-01f, 3.75816487e-02f, -2.48711720e-01f, -2.56127387e-01f, -1.37564629e-01f, -1.54757962e-01f, -2.00312629e-01f,
  -3.78223322e-02f, 6.45394325e-02f, 8.84865895e-02f, 1.32650420e-01f, 1.92668810e-01f, 3.71468514e-01f, 4.68091398e-01f, 1.58517629e-01f, -2.06399933e-02f, 1.37224004e-01f,
  1.30825773e-01f, 2.64989436e-02f, 2.43761074e-02f, 1.61266234e-02f, 1.69323653e-01f, 1.99327692e-01f, 1.59451872e-01f, -3.20406407e-02f, -7.44038671e-02f, 6.05821460e-02f,
  -3.27029750e-02f, -1.00768194e-01f, -1.66345477e-01f, -1.39960915e-01f, -1.11897714e-01f, -1.13749400e-01f, 8.77185017e-02f, 1.62157218e-03f, -1.36626037e-02f, -1.31820768e-01f,
  -8.56663275e-04f, 1.14146896e-01f, 6.62852405e-03f, -1.82645563e-02f, 1.14232758e-02f, -4.05851826e-02f, 2.78818402e-02f, -2.28869095e-01f, 1.20663084e-02f, -1.16344251e-01f,
  -1.31642684e-01f, -1.66924253e-01f, 8.82433504e-02f, -4.59460132e-02f, -3.07011772e-02f, 2.79112849e-02f, -8.53744522e-02f, -6.24776445e-03f, 3.40636000e-02f, 9.49202925e-02f,
  1.89247844e-03f, 1.77296549e-01f, 4.68690842e-02f, 2.41254598e-01f, 1.25919417e-01f, 1.01376534e-03f, 8.56841430e-02f, -3.89070041e-03f, -3.41552831e-02f, -4.21600379e-02f,
  2.57933196e-02f, -1.84332803e-02f, 1.17407084e-01f, 2.63175406e-02f, -1.78215280e-02f, -4.47433889e-02f, 1.12485841e-01f, 5.19533455e-02f, 1.25220284e-01f, -3.43696848e-02f,
  -6.13535056e-03f, 3.77055444e-02f, 2.17696596e-02f, -2.72888709e-02f, -7.97634199e-02f, -4.57107089e-02f, 7.28219049e-03f, -9.74536836e-02f, 1.10021271e-01f, 2.96281055e-02f,
  -1.18093118e-02f, -1.56946495e-01f, -1.70223400e-01f, -9.44832712e-02f, 2.66347136e-02f, 5.42157888e-02f, 4.00512666e-03f, -7.46329874e-02f, -8.75656530e-02f, -2.46803597e-01f,
  -1.17741682e-01f, 2.84655303e-01f, 5.22311740e-02f, -6.63763732e-02f, -9.33300555e-02f, -1.84089616e-02f, 1.55632824e-01f, -3.81861888e-02f, -8.68759956e-03f, 1.15906261e-01f,
  6.72851875e-02f, -1.47295460e-01f, 1.18183494e-02f, 4.12910245e-02f, -1.04056112e-01f, -1.47127181e-01f, -7.02782441e-03f, 5.90105429e-02f, -8.60215202e-02f, -7.97320455e-02f,
  -7.62289912e-02f, -6.72564954e-02f, -4.34919074e-02f, -1.91541761e-02f, 5.15417904e-02f, -1.42129689e-01f, -8.28369781e-02f, -1.23059936e-01f, -9.52578038e-02f, -2.89324105e-01f,
  -6.81036636e-02f, -9.78718996e-02f, 2.90706873e-01f, -3.90149001e-03f, 2.26543304e-02f, 6.50622249e-02f, 1.56513572e-01f, -7.07977191e-02f, -2.80744527e-02f, -7.85195604e-02f,
  -9.04411003e-02f, 4.45830822e-02f, 1.38512015e-01f, 2.94661243e-02f, 5.57364756e-03f, -6.55481173e-03f, -1.25107482e-01f, 1.81114972e-01f, 3.32193375e-01f, 1.34463966e-01f,
  -1.20758682e-01f, 2.94870138e-02f, -1.13680556e-01f, -1.02289066e-01f, -8.71000513e-02f, 9.73044485e-02f, -1.31591901e-01f, -6.18892275e-02f, -1.75934806e-02f, -9.52595845e-02f,
  2.87091106e-01f, -1.98633328e-01f, 7.30126724e-03f, -1.62035346e-01f, -1.23732224e-01f, -1.84922069e-01f, 3.49738039e-02f, 7.88859278e-02f, -1.48061782e-01f, -8.15609470e-02f,
  -7.52246231e-02f, -1.49836585e-01f, 6.33053342e-03f, -2.89971549e-02f, -3.10676582e-02f, -1.97860688e-01f, -1.09892152e-01f, -1.21069022e-01f, -8.27640370e-02f, -1.77421317e-01f,
  -1.97849408e-01f, -1.53882489e-01f, 5.28570078e-02f, 4.59261425e-02f, -1.54045105e-01f, 4.72800136e-02f, 6.15713769e-04f, -1.57823652e-01f, -1.27196550e-01f, -1.12840354e-01f,
  2.95769610e-03f, 1.04413390e-01f, -2.82990951e-02f, -2.48871511e-03f, -7.23194852e-02f, 9.99412239e-02f, 7.43937343e-02f, 9.30947997e-03f, 5.36036212e-04f, 1.86328113e-01f,
  1.67336375e-01f, 8.42806324e-02f, 4.33038771e-02f, 1.00784451e-01f, 6.15985580e-02f, -2.29053125e-02f, 8.15566927e-02f, 3.63923050e-02f, 1.95546690e-02f, 4.69300002e-02f,
  1.13862775e-01f, -1.28842322e-02f, 2.91900169e-02f, 1.47349447e-01f, -4.54114862e-02f, 1.00869052e-01f, 5.68876565e-02f, -9.68734249e-02f, 1.32606365e-02f, 8.27295259e-02f,
  2.02793553e-01f, -1.15324333e-01f, 1.19658150e-01f, -1.77123100e-02f, 1.14791587e-01f, -5.47040068e-02f, 2.31338292e-02f, -1.59558505e-02f, -1.26559392e-01f, 6.16294891e-02f,
  2.26793140e-02f, 1.70673728e-02f, 5.20449057e-02f, 8.74436870e-02f, 2.11497858e-01f, -6.05831929e-02f, -6.53008595e-02f, 1.14037082e-01f, -1.63610689e-02f, 1.22265471e-02f,
  9.16635711e-03f, 3.81916091e-02f, 8.84093046e-02f, 1.78203106e-01f, 5.27855568e-02f, 2.03012019e-01f, 2.35189125e-01f, 1.41799465e-01f, -1.03588484e-03f, 1.66733786e-01f,
  -1.02974385e-01f, 9.35076475e-02f, 2.47336701e-01f, -1.11903707e-02f, 1.77250765e-02f, 1.84241086e-01f, 3.46174896e-01f, 9.04422626e-02f, -1.07631005e-01f, -1.17474787e-01f,
  -2.32666448e-01f, -2.37698153e-01f, -2.57289559e-01f, -2.53186285e-01f, -2.70971470e-03f, 1.45790428e-01f, 1.01155795e-01f, 1.01066478e-01f, 4.12097722e-02f, 1.59994029e-02f,
  -8.90829116e-02f, 1.31833896e-01f, 9.78750065e-02f, 6.15281984e-02f, 9.41122100e-02f, -1.90610096e-01f, 2.86437068e-02f, 6.38682321e-02f, -3.19160186e-02f, 1.28499657e-01f,
  -4.17824052e-02f, 1.42161608e-01f, -2.49389783e-01f, -1.83454752e-01f, -1.22894853e-01f, -4.52084467e-02f, 1.78729035e-02f, 3.54316528e-03f, 1.92227867e-02f, 8.10537338e-02f,
  -1.16223857e-01f, 5.72291762e-02f, 1.91833060e-02f, 1.17651755e-02f, 2.18474120e-02f, -2.71724984e-02f, -3.71292979e-02f, 1.87269643e-01f, 3.76398079e-02f, -1.09305680e-01f,
  -1.33900568e-01f, 1.14079125e-01f, -2.17548180e-02f, 4.20873426e-03f, 4.87943133e-03f, -1.42165020e-01f, -1.11268856e-01f, -1.42245144e-02f, 4.44130599e-02f, -9.91756842e-03f,
  2.42857747e-02f, -5.39761670e-02f, -1.94959894e-01f, -4.96205799e-02f, -1.18379220e-01f, -2.76182383e-01f, -2.37983232e-03f, 1.93127498e-01f, 4.04944224e-03f, 7.57498294e-02f,
  6.68111965e-02f, 2.00427532e-01f, 1.91462606e-01f, 1.41159326e-01f, -1.47321336e-02f, 1.72108635e-01f, 1.01652294e-01f, 5.12686558e-02f, 1.22653097e-01f, 6.52409792e-02f,
  5.40729165e-02f, 2.74601609e-01f, 1.39388755e-01f, 8.59892182e-03f, 9.35248360e-02f, 1.26676962e-01f, 9.95301455e-02f, 8.12352598e-02f, 8.96247551e-02f, 2.87427157e-02f,
  8.83386508e-02f, 1.27054363e-01f, -6.73272312e-02f, -5.03562652e-02f, 1.07105121e-01f, -4.33806106e-02f, 7.88244978e-02f, 4.16436717e-02f, 5.25230616e-02f, 1.64236307e-01f,
  2.84511782e-03f, 1.21843405e-01f, 6.24420643e-02f, 9.62360501e-02f, 4.56909500e-02f, 4.18158174e-02f, -3.37435268e-02f, -1.07196987e-01f, 7.62117980e-03f, 1.29203983e-02f,
  -7.02453107e-02f, -9.05479863e-02f, -3.10177244e-02f, -1.04407175e-02f, -9.79659557e-02f, -2.04210356e-02f, -9.91912782e-02f, 2.85183471e-02f, 6.81282207e-02f, 4.46077660e-02f,
  3.33328813e-01f, 1.68120429e-01f, 2.06658557e-01f, 2.13315919e-01f, 1.56729192e-01f, 1.43092737e-01f, 3.23947877e-01f, 1.51580930e-01f, -7.32482746e-02f, 1.43845588e-01f,
  5.92715740e-02f, 6.59701973e-02f, -4.10298333e-02f, -3.72699015e-02f, 1.06192768e-01f, 9.83990282e-02f, -2.68036388e-02f, 1.06881440e-01f, 9.26246867e-02f, 2.38334998e-01f,
  -3.91899012e-02f, 8.83388743e-02f, 2.68357620e-02f, 2.25872789e-02f, 5.06586805e-02f, 1.03520905e-03f, -3.18711903e-03f, -8.75695050e-03f, 2.75806081e-03f, -1.69325620e-01f,
  -1.88060269e-01f, 3.21822673e-01f, -1.19231150e-01f, 8.81956518e-03f, 9.01802331e-02f, 4.49139401e-02f, 4.13984768e-02f, -1.48064140e-02f, 5.48928864e-02f, -6.55824468e-02f,
  3.31596658e-02f, -1.82694327e-02f, -3.02680861e-02f, 2.80821864e-02f, 8.51942822e-02f, -3.47154625e-02f, -3.17732012e-03f, 1.81300491e-02f, -4.59368713e-02f, -2.96087246e-02f,
  -7.92694092e-02f, -2.98170932e-02f, 1.08053491e-01f, 8.56148452e-02f, 8.34309533e-02f, -5.76093234e-02f, -5.00204898e-02f, -6.34296052e-03f, 4.80269901e-02f, 8.08667243e-02f,
  1.08644329e-01f, 1.23477973e-01f, 1.61436405e-02f, -9.34051126e-02f, -1.24894962e-01f, -2.21272372e-02f, 6.79452810e-03f, -2.49579921e-02f, 8.82601552e-03f, 1.31401747e-01f,
  -4.39059027e-02f, 5.89928031e-02f, 2.40239166e-02f, 2.67306399e-02f, -1.28648341e-01f, -1.40450150e-01f, 2.21351199e-02f, 6.69896081e-02f, 7.18020871e-02f, 6.09831288e-02f,
  -1.86869185e-02f, -8.39948431e-02f, -1.58730689e-02f, -9.79785398e-02f, -1.03774518e-02f, 2.64279265e-02f, 3.15030701e-02f, 8.91274065e-02f, 2.06218082e-02f, 9.30238441e-02f,
  -2.12895527e-01f, 1.62239984e-01f, -1.92693308e-01f, -1.20885111e-01f, 3.22212987e-02f, -1.30869681e-02f, 6.63044900e-02f, 2.11285539e-02f, -1.29484087e-01f, -3.87412831e-02f,
  -9.04193446e-02f, -4.83745672e-02f, -1.00907788e-01f, -6.83724415e-03f, 4.51950766e-02f, 4.90230694e-03f, -1.17176332e-01f, -1.04967147e-01f, -1.27339259e-01f, -2.17134237e-01f,
  -1.60068586e-01f, -4.25706338e-03f, -1.15739144e-02f, -1.19626783e-01f, -2.17478648e-01f, -5.44895343e-02f, -1.00211598e-01f, -1.68919235e-01f, -2.80634407e-02f, 4.41081710e-02f,
  -1.31721348e-01f, 2.73208827e-01f, 4.95607369e-02f, -4.33659740e-02f, 2.59439170e-01f, 1.17704429e-01f, 1.11642644e-01f, -5.17997742e-02f, -9.67736319e-02f, 4.92968857e-02f,
  2.76183784e-01f, -6.62122518e-02f, -8.34990665e-02f, -2.29624465e-01f, -3.55546266e-01f, -1.16046764e-01f, -5.31202853e-02f, -2.74502128e-01f, -4.38927919e-01f, -3.75281312e-02f,
  -1.55619541e-02f, -1.92271128e-01f, -3.78749460e-01f, -9.60375071e-02f, -7.93867633e-02f, -1.95108250e-01f, -1.62644997e-01f, -1.13777757e-01f, -1.32920012e-01f, -6.20125607e-02f,
  -5.89698777e-02f, 1.04024842e-01f, 8.16237926e-02f, -3.23349014e-02f, 4.01519462e-02f, 3.07149235e-02f, 1.97453052e-02f, 6.31291643e-02f, 1.81433167e-02f, -2.73143984e-02f,
  1.36953950e-01f, 1.93311334e-01f, 9.91224721e-02f, -9.60881710e-02f, -1.03341252e-01f, -1.23304114e-01f, 2.83042225e-03f, -1.64404169e-01f, -7.10838381e-03f, 1.43494412e-01f,
  1.54905051e-01f, 1.03482887e-01f, 4.35267352e-02f, 1.71411335e-02f, -7.71339461e-02f, -6.56532943e-02f, 6.06251732e-02f, -1.07598044e-02f, -1.10775763e-02f, -2.18071654e-01f,
  -1.41513899e-01f, -9.02794488e-03f, 5.89724183e-02f, 5.47648072e-02f, -1.02468422e-02f, 5.52011002e-03f, -6.22385330e-02f, -3.29849795e-02f, -7.41271898e-02f, -1.17170336e-02f,
  1.95189137e-02f, 6.24747463e-02f, -1.52839586e-01f, -9.49945897e-02f, -1.13471471e-01f, -3.49864438e-02f, -1.73558637e-01f, -1.66031942e-01f, -3.90732959e-02f, -8.78320336e-02f,
  -4.60185111e-02f, -1.12670278e-02f, 6.27598986e-02f, -6.16694987e-02f, -6.66691884e-02f, -1.40939206e-01f, -9.82510224e-02f, -1.08819671e-01f, -2.24399306e-02f, -1.79497823e-02f,
  -4.00243521e-01f, -1.43154711e-01f, 1.92803182e-02f, -5.53675480e-02f, 6.06010221e-02f, 1.02736309e-01f, 4.26942371e-02f, -9.94866118e-02f, 3.60841081e-02f, -1.02098761e-02f,
  7.67205060e-02f, -1.10177696e-01f, 5.62309213e-02f, 1.12406006e-02f, -3.71310972e-02f, -1.16032660e-01f, -8.95610154e-02f, -2.07632631e-01f, 1.50615890e-02f, 1.83188543e-01f,
  5.64373992e-02f, -1.38437927e-01f, -1.68559775e-01f, -1.08182408e-01f, 5.15280152e-03f, -2.90698826e-01f, -2.65946805e-01f, -1.01738058e-01f, -2.27837697e-01f, -3.03985953e-01f,
  -6.37642443e-01f, -1.26466572e-01f, 1.86917245e-01f, -3.63366514e-01f, 3.03409304e-02f, 2.14249417e-01f, 1.26835838e-01f, -9.81419832e-02f, -1.24732859e-01f, -1.30619645e-01f,
  -6.08649254e-02f, -2.21858993e-01f, -1.15409166e-01f, -1.19125564e-02f, 9.12337750e-02f, 7.68669397e-02f, 1.83294266e-01f, 4.64963214e-03f, 1.55688003e-01f, 1.26857042e-01f,
  -2.99685225e-02f, -1.06364205e-01f, -1.70001820e-01f, -1.12932906e-01f, -2.56989807e-01f, -1.73429161e-01f, -1.50595739e-01f, -6.68061748e-02f, 1.35811707e-02f, -2.05353603e-01f,
  -1.74617305e-01f, -1.52490363e-01f, 1.84466392e-01f, 2.46782098e-02f, 5.42859873e-03f, -4.09868062e-02f, -5.23400679e-02f, -4.83442731e-02f, -2.36475412e-02f, -1.14360020e-01f,
  -8.14073756e-02f, 9.44422781e-02f, -1.63302556e-01f, 1.16818445e-02f, -8.36624354e-02f, 6.29049838e-02f, 5.27636632e-02f, 8.14090148e-02f, 1.26565278e-01f, 2.02276498e-01f,
  3.65737528e-02f, -1.53206825e-01f, -3.03237252e-02f, 1.66138917e-01f, 5.06057516e-02f, 4.47387248e-03f, 6.26426144e-03f, 6.52959943e-02f, 2.10415363e-01f, -2.86134958e-01f,
  5.39039299e-02f, -7.15970844e-02f, 8.53392780e-02f, 7.39283264e-02f, -1.03542879e-01f, -3.74605134e-02f, -1.49596017e-02f, -4.90544923e-02f, 3.39128375e-02f, -4.46864590e-02f,
  -9.76221263e-03f, 1.53638035e-01f, -3.36794071e-02f, -9.05653834e-03f, 2.05032015e-03f, 1.06160995e-02f, -1.19416296e-01f, 1.67278312e-02f, 9.83330235e-02f, -6.53055124e-03f,
  3.49068679e-02f, 6.61786273e-02f, -1.00351140e-01f, 2.56695766e-02f, 1.33909687e-01f, 1.55067310e-01f, 8.67974237e-02f, 5.89363798e-02f, 1.08509772e-01f, -1.86847597e-02f,
  -3.67920011e-01f, 2.46035755e-01f, -2.02329010e-01f, 5.44082895e-02f, -1.32041220e-02f, 5.00862375e-02f, -1.13789730e-01f, 1.20936809e-02f, -1.19589783e-01f, 4.88809273e-02f,
  -4.18204181e-02f, -1.16217785e-01f, -1.20833524e-01f, 8.43675658e-02f, 7.62671679e-02f, -8.50298181e-02f, 1.87397283e-03f, -2.34591309e-02f, 1.58627108e-01f, 2.53526308e-02f,
  1.32257724e-02f, -1.24204256e-01f, -3.27072412e-01f, -6.92610964e-02f, -1.06656216e-01f, -2.17628524e-01f, -2.26200610e-01f, -1.28002375e-01f, -7.94970393e-02f, -2.61307448e-01f,
  5.10443509e-01f, -2.55200714e-01f, -4.08263624e-01f, 2.40087762e-01f, -1.63781226e-01f, -1.22509263e-01f, -3.30228835e-01f, 3.94921787e-02f, 1.70509771e-01f, -2.61536241e-01f,
  -1.31670654e-01f, 1.57994241e-01f, 2.19313856e-02f, 9.75762121e-03f, 1.67868853e-01f, -3.05837423e-01f, -3.11159849e-01f, 6.79353178e-02f, 2.09295228e-01f, 2.14075208e-01f,
  1.28081486e-01f, 5.06057553e-02f, 2.52018422e-01f, 1.42079145e-01f, -1.08224206e-01f, 1.07217543e-01f, -1.47564113e-01f, -1.22470327e-01f, -1.19927846e-01f, -4.56227064e-01f,
  -2.83152282e-01f, -1.54032242e-02f, 1.26908526e-01f, 1.68101862e-01f, -6.41576722e-02f, 6.60147369e-02f, -1.42703652e-01f, 2.90928092e-02f, 7.07764458e-03f, -1.34774134e-01f,
  2.01220065e-02f, 3.07320412e-02f, -5.24891950e-02f, -8.99132118e-02f, 5.00702895e-02f, -4.43891287e-02f, 1.70821641e-02f, -1.59111246e-02f, 6.30409047e-02f, -1.39227659e-01f,
  -1.41597986e-01f, -1.73062041e-01f, -2.03715652e-01f, -1.28592059e-01f, -4.42992374e-02f, -3.36672850e-02f, -2.01081872e-01f, -1.02001928e-01f, -7.40121827e-02f, -1.61072925e-01f,
  -8.60505253e-02f, -8.57656822e-02f, -1.11273095e-01f, 4.79119383e-02f, 4.38751467e-02f, -8.74159634e-02f, -6.72382936e-02f, -2.06849780e-02f, 8.61241072e-02f, -3.72962723e-03f,
  -3.12252268e-02f, -6.33442998e-02f, 7.04408949e-03f, 4.70738672e-02f, -3.64079028e-02f, 2.15741862e-02f, -2.19326224e-02f, -7.75314942e-02f, -2.50857510e-02f, 2.63771173e-02f,
  1.82455068e-03f, 5.10627143e-02f, -6.29574284e-02f, -1.55912200e-02f, -5.11657409e-02f, 1.06913848e-02f, -5.19064739e-02f, 4.41432893e-02f, 6.98222369e-02f, -3.97478491e-02f,
  9.43095163e-02f, 8.84024948e-02f, -7.28469118e-02f, 2.20781844e-02f, -6.02806546e-02f, 1.05831940e-02f, -1.12753481e-01f, 2.12328173e-02f, 9.57442448e-02f, -1.44198820e-01f,
  -8.07888880e-02f, 1.22660823e-01f, 1.29373046e-02f, -1.22142583e-01f, 4.64475341e-02f, 5.27216643e-02f, -1.65198110e-02f, -7.51835406e-02f, -3.53451483e-02f, 8.96817595e-02f,
  2.59047747e-03f, 8.03480670e-02f, 1.51102945e-01f, -5.75243235e-02f, -7.40150511e-02f, 7.29780719e-02f, 1.83564369e-02f, -1.56602085e-01f, -9.72595215e-02f, -2.74706613e-02f,
  2.56859601e-01f, -4.67625558e-01f, 2.27667972e-01f, 1.34379670e-01f, 3.17186803e-01f, 4.60937589e-01f, 3.61486912e-01f, 4.69607674e-02f, 5.17274365e-02f, -9.74709988e-02f,
  -2.20698297e-01f, -3.10990304e-01f, -3.39705020e-01f, -2.08143368e-01f, -1.34365827e-01f, 2.18728464e-03f, 1.53883174e-01f, 2.18672037e-01f, 3.45553696e-01f, 1.74742162e-01f,
  -8.99696499e-02f, -9.32041556e-02f, -3.80757637e-02f, -3.71098332e-02f, -1.08859465e-01f, -5.86793162e-02f, -9.51057598e-02f, -1.80033408e-02f, -1.02232128e-01f, -1.46831170e-01f,
  -1.19855665e-01f, -1.37597144e-01f, 6.06315918e-02f, -1.98059902e-01f, -7.87315369e-02f, -9.56741869e-02f, -1.96918491e-02f, -6.17391430e-02f, -3.63304541e-02f, 2.82999575e-02f,
  -7.49633880e-04f, -1.17046013e-01f, 8.81140530e-02f, -2.96395477e-02f, -7.69177359e-03f, 1.34059548e-01f, -7.66180456e-02f, -8.99440795e-02f, -1.88707903e-01f, -4.90606949e-02f,
  -1.83711201e-01f, 2.98754275e-02f, 7.06727132e-02f, 3.64043601e-02f, -1.98293813e-02f, -9.99703258e-02f, -1.20927319e-01f, -8.46395493e-02f, -7.14138895e-02f, 6.82219639e-02f,
  1.34827346e-01f, -2.95795668e-02f, 6.38927594e-02f, -6.54351339e-02f, -1.84100308e-02f, 4.30631824e-02f, 2.43446101e-02f, -1.02879712e-02f, -9.44956094e-02f, 5.37908114e-02f,
  -4.33810912e-02f, -9.16802064e-02f, -5.54222837e-02f, -6.67373762e-02f, -1.07221782e-01f, -1.00850008e-01f, 1.19639203e-01f, -1.96447559e-02f, -1.23037547e-01f, -2.04487983e-02f,
  -1.32972911e-01f, 3.62729246e-04f, 4.73762900e-02f, -1.61450163e-01f, -1.55757159e-01f, 1.71229243e-02f, -5.73775247e-02f, -1.43888980e-01f, 1.17195835e-02f, 1.37613453e-02f,
  -4.12304431e-01f, -2.45298054e-02f, 1.10605836e-01f, -1.58088133e-01f, 1.07232362e-01f, -1.10297598e-01f, -1.37425974e-01f, -7.48703703e-02f, -2.54800059e-02f, 4.02157381e-02f,
  1.72250286e-01f, 5.48576489e-02f, 5.32414205e-02f, 6.46154061e-02f, 1.77254289e-01f, 6.89051002e-02f, -1.34276211e-01f, 5.59586845e-02f, -3.96946855e-02f, -1.40334116e-02f,
  -1.28700018e-01f, 7.48920664e-02f, 1.69186190e-01f, 4.69204299e-02f, 1.32451013e-01f, 1.18395440e-01f, 1.17073715e-01f, 7.69631267e-02f, 1.37521714e-01f, 4.92933504e-02f,
  4.05780554e-01f, 1.55116646e-02f, 9.67304781e-02f, 2.78581262e-01f, -2.04299629e-01f, -4.03841674e-01f, -3.06833595e-01f, -2.39165768e-01f, -1.94860957e-04f, -7.48628974e-02f,
  -6.50203303e-02f, -2.94105429e-02f, 6.83347955e-02f, 4.01795171e-02f, -1.41701654e-01f, -2.63555441e-02f, 8.22270289e-02f, 1.03477918e-01f, -1.11405000e-01f, -1.40340403e-01f,
  -7.52897188e-02f, 4.90376949e-02f, 1.82265446e-01f, 5.11657372e-02f, 1.00427918e-01f, -4.38036136e-02f, 4.26577143e-02f, 1.98748093e-02f, -6.98320717e-02f, 3.88109267e-01f,
  2.20575079e-01f, 2.01642781e-01f, -2.01713160e-01f, -1.09413918e-02f, -2.77514365e-02f, -2.85108238e-02f, -1.32642999e-01f, 2.15716749e-01f, -2.69605946e-02f, -1.74032282e-02f,
  5.19414723e-04f, -3.34003307e-02f, 1.37700699e-02f, -3.44726555e-02f, -2.82000173e-02f, -9.94416848e-02f, 4.11101989e-02f, 1.52067095e-01f, 2.55518347e-01f, 5.76064270e-03f,
  -7.58309588e-02f, -3.26477848e-02f, -3.18877492e-03f, -5.74992970e-02f, -1.11476770e-02f, 8.68720468e-03f, 5.84391765e-02f, 1.10071786e-01f, -4.99577597e-02f, 9.04603116e-03f,
  -6.42015040e-02f, -4.40410618e-03f, -2.53043957e-02f, 2.35802140e-02f, -2.10172720e-02f, -7.96429962e-02f, 2.48217909e-03f, -1.16128074e-02f, 1.16430102e-02f, 1.96974762e-02f,
  4.05340269e-02f, 1.04372226e-01f, -1.28533155e-01f, -1.03061628e-02f, 1.78723872e-01f, -2.64909454e-02f, -1.80439264e-01f, 1.57173071e-02f, 4.67176251e-02f, -1.59761552e-02f,
  -2.94926297e-02f, -3.79261859e-02f, 9.91285592e-02f, 1.14448637e-01f, 1.25029653e-01f, -4.46071923e-02f, -9.25119966e-02f, -2.38070637e-02f, 5.48168235e-02f, 1.12841994e-01f,
  -2.50772744e-01f, -2.18609810e-01f, -1.92994058e-01f, -1.44572854e-01f, -4.07814458e-02f, 4.32739221e-02f, 9.27149281e-02f, -6.44700006e-02f, 1.76908925e-01f, -3.78755219e-02f,
  -1.05842408e-02f, 5.56331687e-02f, 1.48469443e-02f, -1.86424017e-01f, -4.52223308e-02f, -6.72653392e-02f, -3.57412100e-02f, 9.50672256e-04f, -6.29084781e-02f, -1.23183802e-01f,
  -9.97614563e-02f, -2.94116914e-01f, -2.52081335e-01f, -6.58213869e-02f, -7.93345198e-02f, -2.16469646e-01f, -1.63224936e-01f, -1.47646189e-01f, -2.49276102e-01f, -1.24826409e-01f,
  -5.03316224e-01f, 6.57668784e-02f, -3.82055044e-02f, 3.44445817e-02f, 1.74979836e-01f, 1.85966641e-01f, 1.10225983e-01f, 9.02359262e-02f, -2.78990064e-02f, 8.87090713e-02f,
  6.92210048e-02f, 1.06932990e-01f, -3.69404294e-02f, 3.64033133e-03f, -3.95449661e-02f, 4.56690229e-02f, 1.74792945e-01f, -6.74947500e-02f, -5.58146350e-02f, -1.22236758e-01f,
  1.16358235e-01f, 1.51066920e-02f, -2.04059571e-01f, -6.12519719e-02f, -4.21889424e-02f, -2.87796948e-02f, 5.84837794e-02f, 6.22493178e-02f, 1.48027390e-01f, 1.24013349e-01f,
  4.67045933e-01f, 1.38065228e-02f, -1.35870188e-01f, 5.63145790e-04f, -3.85638364e-02f, -8.32900405e-02f, -1.30311683e-01f, -7.36483037e-02f, 4.60823253e-02f, 1.39528885e-01f,
  8.16885158e-02f, -1.47884665e-02f, -8.87903050e-02f, 3.61698009e-02f, 9.52655524e-02f, -2.37220395e-02f, 1.57951824e-02f, -1.50550890e-03f, 1.70850635e-01f, 5.84164113e-02f,
  9.11287889e-02f, 1.94600120e-01f, 1.78692222e-01f, 1.33103937e-01f, 1.24212857e-02f, 6.84691295e-02f, 1.27984479e-01f, -1.75688099e-02f, 4.90348488e-02f, 8.89563486e-02f,
  2.40470562e-02f, -9.71128717e-02f, 2.72766370e-02f, 2.27018520e-02f, -1.74490735e-02f, -1.11855432e-01f, 1.96550693e-02f, -1.67232096e-01f, -7.32906461e-02f, -8.44117031e-02f,
  -1.91338900e-02f, 1.76441982e-01f, 4.84816767e-02f, -1.67396180e-02f, 4.36553769e-02f, 6.96400553e-02f, -3.24979760e-02f, 1.90229751e-02f, 8.37723911e-02f, 7.07225576e-02f,
  -9.70601477e-03f, -5.18233478e-02f, -1.04596987e-02f, 1.04280651e-01f, 1.74493611e-01f, 7.33129308e-02f, 8.28349516e-02f, -7.95336813e-03f, -5.71938343e-02f, -4.93075252e-02f,
  4.57929879e-01f, 1.77232161e-01f, -1.62019342e-01f, -1.59108713e-01f, 4.71809246e-02f, -1.12202995e-01f, 1.70652959e-02f, 5.65238558e-02f, 5.12701832e-02f, 6.57435507e-02f,
  6.95190951e-02f, -5.99802136e-02f, -9.57241654e-02f, -8.96356478e-02f, -1.03308722e-01f, 4.44621928e-02f, -6.50703162e-02f, 6.75066784e-02f, 1.49209335e-01f, 1.26514122e-01f,
  -5.89517765e-02f, -1.32304756e-02f, -3.68456095e-02f, 6.52676728e-03f, -5.21302922e-03f, -1.11834966e-01f, 6.62506744e-03f, -6.23320900e-02f, 1.25214560e-02f, -1.23311095e-01f,
  2.39204735e-01f, -1.14074543e-01f, 2.14939788e-01f, 1.83814421e-01f, 7.77468309e-02f, 9.14855152e-02f, -1.43632397e-01f, 5.96273579e-02f, 7.36247227e-02f, 2.00411994e-02f,
  4.11142297e-02f, 2.10153148e-01f, 1.75121605e-01f, 1.26445934e-01f, 1.99951336e-01f, 2.50528418e-02f, -9.64549407e-02f, 1.77727818e-01f, 2.16470987e-01f, -2.11525895e-02f,
  -1.16176747e-01f, -7.15305135e-02f, 8.73166174e-02f, 5.07154204e-02f, -1.23993658e-01f, 7.01738074e-02f, -3.78606617e-02f, -5.76694012e-02f, -8.61746296e-02f, -1.07375666e-01f,
  3.67296696e-01f, -9.19626579e-02f, 3.81959826e-02f, -5.08711524e-02f, -1.26082897e-02f, -1.40054032e-01f, 8.51070881e-02f, -1.34423956e-01f, -1.83054864e-01f, 1.33097311e-02f,
  -5.66107780e-02f, -8.00011605e-02f, -8.71597379e-02f, -1.14900574e-01f, -2.78762169e-02f, -1.66681513e-01f, -2.51236171e-01f, -6.90274164e-02f, 9.29273814e-02f, -1.82673577e-02f,
  -1.33554079e-02f, 4.67676036e-02f, 1.48429394e-01f, 5.58655113e-02f, 1.39496058e-01f, -7.41294250e-02f, -4.79296856e-02f, -4.40230258e-02f, 1.05144203e-01f, -8.73298123e-02f,
  -3.64658888e-03f, 1.31612942e-01f, 1.36152476e-01f, -1.63289299e-03f, -1.14878140e-01f, -9.04848725e-02f, -6.78915356e-04f, 1.45033583e-01f, 1.03466900e-03f, -4.99815308e-02f,
  -6.42971275e-03f, 1.59913749e-01f, 4.42288220e-02f, -9.92878061e-03f, 1.16937488e-01f, -3.47182415e-02f, -5.39634340e-02f, 1.00709470e-02f, -2.26471536e-02f, 1.15087397e-01f,
  -4.19343151e-02f, -1.20894097e-01f, -1.45928964e-01f, 1.15155064e-01f, -9.33618024e-02f, 6.75436109e-02f, -5.02628870e-02f, 6.96781427e-02f, -6.01265021e-02f, -9.68414266e-03f,
  9.49889719e-02f, 1.38707399e-01f, 7.52149224e-02f, 3.11669074e-02f, 9.06048436e-03f, -2.06348717e-01f, 5.94333559e-02f, -7.89732710e-02f, -2.24398896e-02f, 2.68946085e-02f,
  6.57143220e-02f, 7.59418160e-02f, -1.04254767e-01f, -1.19313821e-01f, -6.47895485e-02f, -1.92115963e-01f, -6.82137087e-02f, 8.79078433e-02f, 1.13504976e-02f, 4.21720855e-02f,
  -2.89639458e-03f, 6.25945907e-03f, 2.72648841e-01f, 5.07983938e-02f, 5.47031015e-02f, 7.61394948e-02f, 2.56664772e-02f, 3.67772207e-02f, 1.08623028e-01f, 1.14282258e-02f,
  -2.27626979e-01f, -6.31737784e-02f, -2.92793870e-01f, 1.97048172e-01f, 1.87467173e-01f, -1.15954049e-01f, -1.64808810e-01f, -1.27753183e-01f, 2.07317472e-01f, 1.01658013e-02f,
  -8.06923583e-02f, 2.51299441e-01f, 2.13230580e-01f, 1.12284176e-01f, 2.48620156e-02f, -7.13964701e-02f, 2.22833768e-01f, 4.84466515e-02f, 7.17750192e-03f, -1.54693961e-01f,
  1.48504436e-01f, 3.91377322e-02f, -7.92343989e-02f, 4.96961996e-02f, 6.66510612e-02f, 4.36012149e-02f, -8.58370587e-02f, 4.93441522e-02f, -5.69249466e-02f, 2.00795516e-01f,
  1.55959213e-02f, -1.36433229e-01f, 2.90754512e-02f, 8.54152143e-02f, 1.18642554e-01f, -1.72032535e-01f, -3.83837074e-02f, -1.12085737e-01f, 2.86947563e-02f, -1.28988251e-01f,
  1.44071560e-02f, -1.77950099e-01f, 9.85942185e-02f, -7.73809999e-02f, -1.44165487e-03f, -8.56573656e-02f, -1.37979776e-01f, -8.00755024e-02f, -3.08086962e-01f, -2.34332278e-01f,
  3.47773224e-01f, 2.61608243e-01f, -9.20166299e-02f, -1.62344322e-01f, -7.29709119e-02f, 1.93960711e-01f, -3.00004423e-01f, -1.06836468e-01f, -2.93733299e-01f, -2.15582158e-02f,
  1.88879445e-02f, -8.57354626e-02f, -3.80981565e-02f, 2.30988208e-02f, 1.09219775e-01f, 1.59593359e-01f, 2.26862326e-01f, 1.50731876e-01f, -2.33309362e-02f, -9.89538357e-02f,
  7.09248930e-02f, -5.34062199e-02f, 5.37516456e-03f, 1.52256992e-02f, 3.42701585e-03f, 2.49163713e-02f, 1.96849480e-02f, 6.62035942e-02f, 1.58097893e-02f, -1.12135522e-01f,
  1.54847920e-01f, 2.44368818e-02f, -7.80364219e-03f, 1.99015960e-01f, -1.73253790e-02f, 1.21258870e-02f, -1.42302275e-01f, -2.98505742e-02f, -3.73423323e-02f, -2.69316405e-01f,
  -7.12356120e-02f, -4.04417031e-02f, -1.12868100e-02f, 4.15156446e-02f, -5.86395226e-02f, -1.48262352e-01f, -6.35086372e-02f, -7.36486493e-03f, 3.04021742e-02f, -3.80769596e-02f,
  -1.34137213e-01f, -5.68589009e-02f, -1.38485521e-01f, 3.81849357e-03f, -5.83698228e-02f, 1.87561642e-02f, 7.69832730e-02f, 9.06034708e-02f, -7.17907548e-02f, -4.22347188e-02f,
  1.16571531e-01f, -2.69986652e-02f, -3.24715562e-02f, 1.86185706e-02f, 2.24962030e-02f, -1.05317533e-01f, -2.10914910e-01f, -2.42457390e-01f, -2.22742513e-01f, -3.79772544e-01f,
  -2.12728649e-01f, 6.06450215e-02f, 1.60737380e-01f, 1.13733172e-01f, 4.35158759e-02f, -6.14490472e-02f, -1.52120769e-01f, -2.68627465e-01f, -2.94506699e-02f, 7.21207028e-03f,
  5.72650358e-02f, 1.96938589e-01f, 1.68460444e-01f, -9.21831727e-02f, -1.26658946e-01f, 8.68416578e-02f, 2.68259048e-01f, 5.72380163e-02f, -3.23779136e-01f, -1.31977364e-01f,
  7.97042176e-02f, 6.86777532e-02f, -1.48203894e-01f, -7.95732886e-02f, 9.95279923e-02f, -7.66111538e-02f, 4.02006842e-02f, -1.41013740e-03f, 1.67991058e-03f, 4.16024327e-01f,
  9.28803682e-02f, -1.20915920e-01f, 6.26161024e-02f, -1.52146682e-01f, -7.45143741e-02f, -1.83495760e-01f, 6.36342838e-02f, 1.74296781e-01f, 1.19879767e-01f, -2.19382998e-02f,
  4.17171009e-02f, -5.76711856e-02f, -7.77960801e-03f, -3.06978766e-02f, -1.74980745e-01f, 8.95205736e-02f, -1.96276754e-02f, -2.53382549e-02f, -1.43414155e-01f, -1.25489712e-01f,
  1.12763174e-01f, 1.56627983e-01f, -2.43162755e-02f, 7.04259519e-03f, -8.31441581e-02f, 7.62400478e-02f, -7.13146701e-02f, 9.08538792e-03f, -6.70129880e-02f, -1.16076786e-03f,
  -7.22138509e-02f, -1.62452966e-01f, -8.35329145e-02f, -3.63375284e-02f, -3.76790240e-02f, 2.86157476e-04f, 8.01000968e-02f, -3.55580598e-02f, 5.51682264e-02f, -1.02331556e-01f,
  -5.10311387e-02f, 6.43326342e-02f, 3.27413669e-03f, -9.78570804e-02f, 2.38359086e-02f, -3.27324099e-03f, -5.65557852e-02f, -1.66440681e-02f, 6.55081794e-02f, -6.72751339e-03f,
  -1.91862062e-02f, 6.10253029e-02f, 2.21277416e-01f, 1.09008476e-02f, 1.30677402e-01f, 1.30636260e-01f, 1.96819231e-02f, 4.48854193e-02f, -3.94662097e-02f, 4.26740339e-03f,
  -1.15641423e-01f, -1.88556742e-02f, 1.04133427e-01f, 2.11082604e-02f, 3.19904760e-02f, -7.39632472e-02f, -1.92483589e-02f, -4.49237041e-02f, 6.10650890e-02f, -7.16111436e-02f,
  -1.40992284e-01f, -1.35340184e-01f, 7.93735012e-02f, 2.79478170e-02f, -2.30891481e-01f, -6.10088818e-02f, -3.30973454e-02f, -1.23199672e-01f, -3.63747701e-02f, -1.82030529e-01f,
  -5.71332723e-02f, -1.89000309e-01f, -1.36984915e-01f, -1.80584043e-02f, -7.29517341e-02f, -4.81627062e-02f, -8.84855837e-02f, -9.09680054e-02f, -7.47862458e-02f, -1.41540036e-01f,
  -3.74830157e-01f, 5.31705506e-02f, -1.38069257e-01f, 1.92377999e-01f, 2.78728426e-01f, 3.28989737e-02f, 5.23636043e-02f, -3.44703943e-02f, 7.19419718e-02f, 3.19702104e-02f,
  -1.13626253e-02f, 5.28352112e-02f, 1.44576952e-02f, 3.50299254e-02f, 3.88555899e-02f, 1.89046144e-01f, 3.26492637e-01f, -1.43884858e-02f, -1.34327382e-01f, -1.61531627e-01f,
  1.74094200e-01f, -1.10626154e-01f, -1.14861913e-01f, -1.35761335e-01f, 2.82084644e-02f, 9.41910297e-02f, 1.31533399e-01f, 1.40812639e-02f, -7.47999325e-02f, 4.16041523e-01f,
  -2.53874093e-01f, -1.56718820e-01f, -1.51860593e-02f, -5.73849306e-02f, -2.31015682e-01f, -1.39657468e-01f, -4.27521318e-02f, -2.01519608e-01f, -2.04383194e-01f, -1.26334220e-01f,
  -3.41110900e-02f, -9.64122936e-02f, 2.32283697e-01f, 4.41097617e-02f, -1.17518589e-01f, -1.02883086e-01f, -1.64969228e-02f, -6.95432574e-02f, -1.44753680e-01f, -2.69211829e-01f,
  2.97258049e-01f, -1.47181116e-02f, 7.50471354e-02f, 6.62801340e-02f, -9.02768895e-02f, -8.11630487e-02f, -1.08017169e-01f, -7.79199675e-02f, -1.21576227e-01f, -1.76065385e-01f,
  -3.02251372e-02f, -3.65879461e-02f, -3.52655761e-02f, -1.71814650e-01f, 6.36070296e-02f, 1.40050963e-01f, 1.40145257e-01f, -6.76974421e-03f, 1.38638914e-03f, 4.26281691e-02f,
  3.78685296e-02f, -1.28737688e-01f, -5.39318332e-03f, -2.54786909e-01f, 1.15630301e-02f, -5.60538936e-03f, 6.22479692e-02f, -8.15964639e-02f, -1.29757673e-01f, -2.28943378e-01f,
  9.58213657e-02f, 4.07303497e-02f, -1.16864197e-01f, 1.83519926e-02f, -6.25007227e-02f, -6.40116185e-02f, -1.16081089e-01f, -7.64653971e-03f, -4.62311432e-02f, -8.04145634e-02f,
  -3.58155109e-02f, 1.09349862e-01f, 2.37916540e-02f, 1.70053974e-01f, -3.39131430e-02f, -2.89612599e-02f, -8.67754817e-02f, -8.42434093e-02f, -1.17351919e-01f, 8.67844969e-02f,
  -7.92039037e-02f, 6.79752082e-02f, 9.28065479e-02f, 6.05389215e-02f, -4.33582552e-02f, -6.87954053e-02f, 9.94069129e-02f, 8.32907185e-02f, 8.43228623e-02f, -1.59525946e-02f,
  1.69969425e-01f, -5.60836606e-02f, -4.28087302e-02f, 2.25233510e-01f, -4.67445189e-03f, -5.15780784e-02f, -6.61159009e-02f, -1.26892896e-02f, -2.25555286e-01f, -2.57449448e-01f,
  1.72202274e-01f, 3.52541625e-01f, 1.51053756e-01f, 7.25479797e-02f, 1.39257848e-01f, 1.94353268e-01f, 4.20781404e-01f, 2.32640713e-01f, -2.08278120e-01f, 1.85318980e-02f,
  1.40456110e-01f, -8.53341743e-02f, -8.26772898e-02f, -1.31503820e-01f, 1.50258631e-01f, 1.65088356e-01f, 4.67818156e-02f, -1.15579981e-02f, -1.09993689e-01f, 1.59230664e-01f,
  4.47651222e-02f, -3.66324522e-02f, 8.68112743e-02f, -6.57115579e-02f, -3.59443389e-02f, -6.61958307e-02f, 3.20269801e-02f, 1.53240129e-01f, 1.15458526e-01f, -2.13862821e-01f,
  -1.65236071e-01f, 2.15543419e-01f, -1.59464866e-01f, -1.24188088e-01f, -1.00805406e-02f, -5.92063293e-02f, 5.15285060e-02f, -7.49209011e-03f, -4.52125520e-02f, -5.61039820e-02f,
  5.46851903e-02f, -8.50112960e-02f, -1.56209931e-01f, 2.05511483e-03f, -6.61273003e-02f, -9.95969996e-02f, -1.96349621e-02f, -1.56134833e-02f, -1.25415074e-02f, -2.76392214e-02f,
  -8.25687572e-02f, 7.87497461e-02f, 3.23798805e-02f, 8.85012001e-02f, 2.08419887e-03f, -2.50609964e-02f, 1.35504156e-01f, 4.42453707e-03f, 8.81474987e-02f, -1.60200462e-01f,
  -6.92384914e-02f, 1.38147742e-01f, -4.56712134e-02f, -5.40599553e-03f, -4.50805807e-03f, -7.59170903e-03f, -7.60231465e-02f, -3.48644704e-02f, 3.76931615e-02f, 2.27436926e-02f,
  2.69990228e-02f, -1.04222171e-01f, -4.45438102e-02f, -4.37817909e-03f, 6.23509474e-03f, 4.71021049e-02f, -4.70389001e-04f, 1.22160101e-02f, 1.16192522e-02f, 1.77029558e-02f,
  5.16198836e-02f, 2.95711402e-03f, 1.02680456e-02f, -1.57855731e-02f, -6.30054027e-02f, 6.25609308e-02f, -1.00664996e-01f, 2.51973402e-02f, -8.71676058e-02f, 1.26791894e-01f,
  -1.92522287e-01f, 5.45704700e-02f, -2.11405203e-01f, 1.53456610e-02f, 5.33100106e-02f, -8.68502706e-02f, -9.11644176e-02f, -6.34452105e-02f, 5.60605489e-02f, 2.78205238e-02f,
  2.96656638e-02f, -1.02581427e-01f, 1.40375439e-02f, -1.10303819e-01f, -9.75976959e-02f, -1.40184015e-01f, -1.92105308e-01f, -2.90626511e-02f, -7.39886910e-02f, -1.51264817e-01f,
  -1.77763298e-01f, -4.24758485e-03f, -9.69686657e-02f, -3.90209220e-02f, 3.49750370e-02f, -1.09090425e-01f, -1.22520126e-01f, 3.41758952e-02f, 6.30812272e-02f, -1.53772831e-02f,
  -9.26428735e-02f, 1.25944823e-01f, 3.82052101e-02f, 6.24775924e-02f, -1.38212740e-01f, -2.18023390e-01f, -3.92504543e-01f, -2.65740246e-01f, -1.25385061e-01f, -1.77059025e-01f,
  -1.34800151e-01f, -3.14843617e-02f, 3.99235860e-02f, 9.72419381e-02f, 7.07861930e-02f, 6.62833899e-02f, 3.67811918e-01f, 3.81361187e-01f, 4.09218259e-02f, -6.17555976e-02f,
  3.19631696e-02f, 9.27656144e-02f, 1.98736787e-01f, 1.30649835e-01f, 1.59510225e-01f, 9.10642296e-02f, 8.72699171e-03f, 1.89874381e-01f, 1.56705640e-02f, 5.19264579e-01f,
  -1.43974379e-01f, -1.71541914e-01f, -1.48534887e-02f, 1.02094203e-01f, -1.47671700e-01f, -2.10348256e-02f, 3.04959103e-04f, -4.89651486e-02f, 5.99209219e-02f, -2.04748437e-02f,
  1.81498826e-02f, 2.13984102e-02f, -1.09348819e-02f, -9.88731254e-03f, -6.14039525e-02f, -3.13798897e-02f, 7.16657266e-02f, 2.27833286e-01f, -3.93814631e-02f, -1.13389835e-01f,
  3.71027514e-02f, -3.49838473e-02f, -1.24421962e-01f, -7.86263496e-02f, -1.55793548e-01f, 1.21274896e-01f, -2.08508283e-01f, 3.89028788e-02f, -1.82191864e-01f, 1.16348900e-02f,
  -2.26641148e-02f, 3.58131677e-02f, 1.03597291e-01f, 3.45827751e-02f, 2.57433709e-02f, -4.08086292e-02f, 2.43428871e-02f, -7.71939382e-02f, 1.29256055e-01f, 8.87094513e-02f,
  -4.09713723e-02f, 4.83308062e-02f, 9.13821757e-02f, -6.18429221e-02f, -1.55997425e-02f, -6.74437508e-02f, -7.34063461e-02f, 3.48864533e-02f, -1.05401561e-01f, 3.64606194e-02f,
  -4.87100370e-02f, -4.08821702e-02f, 4.14762795e-02f, 1.63532272e-01f, -1.08514339e-01f, -4.76237275e-02f, 5.28275147e-02f, -1.16595045e-01f, -1.54970363e-02f, 8.35026242e-03f,
  -2.30727851e-01f, -5.79406433e-02f, -3.74463499e-02f, 6.21049479e-03f, -2.13744789e-01f, 8.09324011e-02f, -3.47749926e-02f, -1.54513738e-03f, -2.01247819e-02f, -6.77495375e-02f,
  -1.59759283e-01f, -1.34451002e-01f, -1.09930940e-01f, -2.26943269e-02f, 1.80983543e-03f, -6.29709512e-02f, 7.91910738e-02f, 5.08203655e-02f, -4.99849617e-02f, -1.27583250e-01f,
  5.85119799e-03f, -1.85458548e-02f, -1.87308416e-01f, -1.31898209e-01f, -1.52224749e-01f, -8.46487433e-02f, -1.43878803e-01f, -1.59887835e-01f, -2.01966450e-01f, -3.46561134e-01f,
  4.23963964e-01f, 1.77414969e-01f, -3.51971909e-02f, 9.94121358e-02f, 1.69096962e-02f, 3.34655084e-02f, 3.32511574e-01f, 1.69203639e-01f, -8.78680963e-03f, 2.44659737e-01f,
  -7.46967420e-02f, -4.30252284e-01f, -4.34262812e-01f, -2.87372172e-01f, -5.72967194e-02f, 2.85608858e-01f, 1.13273285e-01f, -2.36962480e-03f, -1.62597016e-01f, 1.31933019e-01f,
  5.90780377e-02f, 2.44341210e-01f, 2.14387983e-01f, 8.02626535e-02f, 3.04946750e-02f, -1.44320592e-01f, 7.02107698e-02f, -3.41470768e-05f, -1.30471392e-02f, -4.83357646e-02f,
  -1.59239352e-01f, -9.70959105e-03f, -2.85651267e-01f, -1.25606716e-01f, -1.91820070e-01f, -2.14956831e-02f, -1.52611792e-01f, -1.28894508e-01f, -6.48672581e-02f, -5.83199263e-02f,
  -2.16286749e-01f, -1.28612250e-01f, -2.71234900e-01f, -2.19922036e-01f, 5.59175760e-02f, -2.54757772e-03f, 2.47393921e-01f, 5.77991940e-02f, -1.37658849e-01f, 3.66907790e-02f,
  -1.50535196e-01f, 8.06046575e-02f, 8.77421126e-02f, 5.71135664e-03f, 6.30688220e-02f, 4.76064235e-02f, 5.56890145e-02f, -2.59789266e-02f, -8.55709687e-02f, 1.21282056e-01f,
  8.23942348e-02f, -5.22567025e-05f, -2.88378168e-02f, 6.27417564e-02f, 7.02091008e-02f, -6.33696318e-02f, -1.33246571e-01f, -5.80643080e-02f, 3.66156735e-02f, 1.05451897e-01f,
  -6.22460134e-02f, 9.63044614e-02f, -1.06211737e-01f, -3.12106237e-02f, 4.72167926e-03f, 2.71367971e-02f, 8.47264081e-02f, 1.30311087e-01f, -3.37539092e-02f, 5.07507473e-03f,
  -9.79364812e-02f, -5.81619032e-02f, 7.52026364e-02f, -4.44456413e-02f, 1.18960934e-02f, -5.53334318e-02f, -8.14960450e-02f, 1.53972367e-02f, -4.43123933e-03f, 7.57823233e-03f,
  -1.06822148e-01f, -3.27204585e-01f, -1.17556572e-01f, -5.12930751e-02f, -1.72768831e-02f, -1.31037058e-02f, -1.19498499e-01f, -6.65246844e-02f, 8.56854618e-02f, -2.63573956e-02f,
  -8.97734687e-02f, -8.56354982e-02f, -8.79440755e-02f, -1.30829290e-01f, -7.41767585e-02f, 8.88410807e-02f, 5.43103507e-03f, -5.49431778e-02f, -1.41222790e-01f, 5.10598384e-02f,
  8.23949724e-02f, 2.13597611e-01f, 1.09658256e-01f, 4.74549420e-02f, -4.12559994e-02f, 8.94539356e-02f, 1.75291561e-02f, 1.22611327e-02f, 3.44538055e-02f, 3.06560308e-01f,
  9.26297083e-02f, -1.75678283e-01f, -2.46015564e-01f, 1.51987240e-01f, -1.84971735e-01f, -2.42315903e-01f, -3.17031860e-01f, 6.56949952e-02f, 1.59787089e-01f, -3.62877399e-01f,
  -2.26397127e-01f, 3.22025232e-02f, -2.36845315e-02f, 1.40120327e-01f, 6.10637479e-02f, -2.79478520e-01f, -2.02611417e-01f, 6.23048022e-02f, 2.77844250e-01f, 6.76003769e-02f,
  1.09035671e-01f, 1.82890832e-01f, 2.67143339e-01f, 2.65426338e-01f, -9.32465792e-02f, -5.89813702e-02f, -1.93744674e-01f, -1.07818462e-01f, -1.09330542e-01f, -3.41980308e-01f,
  -3.91046405e-01f, -5.80577478e-02f, -4.02483121e-02f, 1.38823956e-01f, -1.10969648e-01f, 8.62244964e-02f, 6.14287257e-02f, 1.46935517e-02f, -4.97926883e-02f, -1.22267246e-01f,
  3.63273956e-02f, -3.49200033e-02f, 6.31519631e-02f, -4.08817306e-02f, 2.48370897e-02f, -3.25224176e-02f, 9.19202864e-02f, -3.08422297e-02f, -5.44804148e-02f, -2.01690957e-01f,
  -5.63577116e-02f, -6.91647008e-02f, -1.50133744e-01f, 1.42387450e-02f, -1.24325134e-01f, -4.41032946e-02f, -1.47975340e-01f, -5.26167043e-02f, -1.80995949e-02f, -1.90116763e-01f,
  -8.48588794e-02f, -6.32141829e-02f, 2.47444380e-02f, -8.51702876e-03f, 7.62782171e-02f, -9.35304761e-02f, 9.63450596e-03f, -6.39302880e-02f, 4.22329176e-03f, -1.69075485e-02f,
  -5.02079576e-02f, -1.58750061e-02f, 4.65792306e-02f, -9.85894469e-04f, -6.99954713e-03f, -7.48976171e-02f, 1.19414572e-02f, -1.24208648e-02f, -7.83964768e-02f, 4.28445935e-02f,
  -1.08344210e-02f, -2.24929135e-02f, -8.37414041e-02f, 1.02437682e-01f, -6.48246557e-02f, 8.20027888e-02f, 5.69599681e-02f, -4.67126779e-02f, 8.16914141e-02f, 5.84117919e-02f,
  1.13845170e-01f, -2.59415172e-02f, -2.97145713e-02f, 6.23522215e-02f, 6.57651499e-02f, -1.01075741e-02f, -1.41403852e-02f, -2.37777699e-02f, 3.81712504e-02f, 1.03812583e-01f,
  -1.06937736e-01f, -1.54451095e-03f, -3.41428369e-02f, 1.31673086e-02f, 3.63865197e-02f, -8.57417062e-02f, 1.46066681e-01f, -6.66489229e-02f, 2.78833485e-03f, 9.08150449e-02f,
  -5.69442585e-02f, 7.91063607e-02f, 8.73907208e-02f, 3.16917300e-02f, 7.52148032e-02f, 9.92380977e-02f, -2.80305184e-03f, -2.14285683e-02f, 5.72556071e-02f, -4.49640527e-02f,
  5.18774331e-01f, 5.99352643e-03f, -1.43707410e-01f, 1.48607686e-01f, -1.04183599e-01f, -7.90175423e-02f, 4.32293527e-02f, 2.12666336e-02f, 1.31171271e-01f, 3.50469202e-02f,
  -2.45814398e-01f, -3.78121972e-01f, -2.87022531e-01f, -2.98197180e-01f, -1.69823945e-01f, 1.84211224e-01f, 1.45230114e-01f, 5.91375194e-02f, -2.08481569e-02f, -9.84558985e-02f,
  -1.71053410e-01f, 9.61122736e-02f, 1.77138150e-01f, 5.89955449e-02f, -3.76216397e-02f, -4.87379245e-02f, 2.63879970e-02f, -1.01801276e-01f, -1.78068608e-01f, -3.56110446e-02f,
  -1.15179867e-02f, -1.39137477e-01f, -7.64002744e-03f, -7.74867982e-02f, -9.39202234e-02f, 8.26443955e-02f, 3.25101875e-02f, 1.95919238e-02f, 1.68140065e-02f, 1.27780631e-01f,
  -1.33328900e-01f, -7.54235461e-02f, -2.40114033e-02f, -1.29023582e-01f, 9.75839868e-02f, -9.27395299e-02f, 2.78415959e-02f, 6.16344772e-02f, -1.76264476e-02f, -1.44748855e-02f,
  -1.12966932e-01f, -1.87729683e-03f, -8.81223083e-02f, -9.27472562e-02f, -1.65331408e-01f, -1.00606576e-01f, -7.66807422e-02f, -1.45600930e-01f, -1.04742646e-01f, 1.70006067e-01f,
  4.66221310e-02f, 1.61695629e-01f, -2.82038040e-02f, 8.94628763e-02f, 2.04074457e-01f, 1.24143586e-01f, 1.15593664e-01f, -4.44020052e-03f, 1.65281240e-02f, 6.09085225e-02f,
  6.76823556e-02f, -2.96057225e-03f, 5.38365170e-02f, 5.39740361e-02f, -4.41411026e-02f, 7.31306151e-03f, -8.56595486e-02f, -2.50590555e-02f, 4.47744783e-03f, -3.92274819e-02f,
  -7.22548068e-02f, -9.22975689e-02f, -4.47944626e-02f, -5.45982756e-02f, -7.20632169e-03f, -3.36459018e-02f, -6.41198084e-02f, -1.19258761e-01f, 9.56825446e-03f, -1.02267817e-01f,
  2.26147939e-02f, -2.80421644e-01f, 1.54659331e-01f, -8.34502578e-02f, -1.22226171e-01f, -2.17119735e-02f, -2.01728698e-02f, -3.74876224e-02f, -6.72511011e-02f, -9.77246556e-03f,
  -1.87249392e-01f, -2.87012476e-02f, 5.83403856e-02f, -6.90034479e-02f, 1.76517926e-02f, -1.00568898e-01f, 3.84180583e-02f, -1.18347213e-01f, -5.34321740e-02f, -4.97030048e-03f,
  8.59302729e-02f, 1.57585114e-01f, 1.99579611e-01f, 6.43953606e-02f, -7.70851299e-02f, 1.00461550e-01f, -1.86423287e-02f, -7.62454001e-03f, 2.92268824e-02f, 3.18152070e-01f,
  5.61690688e-01f, -3.26522402e-02f, 3.24405909e-01f, 1.71892524e-01f, -4.70307097e-02f, 5.05021997e-02f, 8.99438113e-02f, 1.12094603e-01f, 1.67284504e-01f, 1.61477879e-01f,
  -1.07591543e-02f, 1.56737026e-02f, 8.82599354e-02f, 2.70328317e-02f, 1.30157113e-01f, -1.11851757e-02f, 1.94763336e-02f, 9.71709341e-02f, 1.50934786e-01f, 1.39900103e-01f,
  1.17821820e-01f, 4.24824283e-02f, 1.28734410e-01f, 6.36695027e-02f, 7.78979287e-02f, -1.41153987e-02f, -3.90062183e-02f, -1.41145840e-01f, 3.28990184e-02f, -5.08023128e-02f,
  -3.31348032e-01f, 7.55997598e-02f, 5.27824759e-02f, -1.12992264e-01f, 4.31152359e-02f, -5.58826234e-03f, -2.42350204e-03f, 7.09779859e-02f, -1.48766637e-01f, -2.49400008e-02f,
  -9.46590081e-02f, 1.78561779e-03f, 3.32746767e-02f, -6.25677705e-02f, -8.75608176e-02f, 1.25374468e-02f, 9.04630497e-02f, 2.79382803e-02f, 5.29262908e-02f, 3.89416120e-03f,
  -4.68140058e-02f, 1.70660242e-02f, -5.01794915e-04f, 1.12474851e-01f, 1.48839444e-01f, -3.26777771e-02f, 1.30749224e-02f, 6.63131103e-02f, 8.16153064e-02f, 1.44866064e-01f,
  -7.41063133e-02f, 7.85238296e-02f, 2.15165354e-02f, 5.85433729e-02f, -9.01946332e-03f, 3.70502248e-02f, 9.68975425e-02f, -8.33119452e-02f, 9.97128487e-02f, 8.52413252e-02f,
  8.23760685e-03f, -3.34467813e-02f, 5.73906451e-02f, 2.07294926e-01f, 1.78472996e-01f, 3.11515834e-02f, -1.57306045e-01f, 2.50251573e-02f, -5.33384085e-02f, -9.75494385e-02f,
  1.21734485e-01f, 8.73856097e-02f, -6.00989535e-02f, 7.01911449e-02f, 8.20296630e-02f, 6.17487505e-02f, -1.89811829e-02f, -1.30704999e-01f, -1.05000613e-02f, -3.62335593e-02f,
  -5.97100735e-01f, 2.16506645e-01f, 9.38409120e-02f, 4.42159921e-03f, -3.55842039e-02f, -9.67236385e-02f, 3.27954441e-02f, -1.74773782e-01f, -3.33865315e-01f, -2.02188715e-01f,
  -3.51538137e-02f, -4.89970855e-02f, -3.35074514e-02f, 5.75759411e-02f, 5.95488027e-02f, -6.19251244e-02f, -5.95427565e-02f, -1.97253637e-02f, -1.30593285e-01f, -2.60308795e-02f,
  -1.67281367e-02f, 1.91346128e-02f, -5.54515459e-02f, -3.75253777e-03f, -8.17706883e-02f, -3.90521847e-02f, -9.27642453e-03f, 2.75541637e-02f, -1.24756068e-01f, 8.70208219e-02f,
  -3.99600923e-01f, -1.01238489e-01f, -8.06854665e-02f, 9.23140571e-02f, 1.60794124e-01f, -2.59373188e-02f, -1.69500351e-01f, -6.68337345e-02f, 2.79494166e-01f, 1.01421259e-01f,
  1.96101740e-01f, 2.95246989e-01f, 1.20936334e-01f, 1.46373689e-01f, -6.33797944e-02f, -6.03063740e-02f, -2.17745379e-02f, 2.48439759e-02f, 8.72209892e-02f, 1.03777960e-01f,
  1.89047977e-01f, -7.14344066e-03f, -6.01622164e-02f, 1.11340825e-03f, -4.91888635e-02f, 3.27309500e-03f, 5.38634583e-02f, -7.84727037e-02f, -8.56230035e-02f, -2.03588605e-01f,
  -8.08877498e-03f, -3.19482893e-01f, 1.14565276e-01f, 4.29435745e-02f, 7.96777904e-02f, -9.36354995e-02f, 6.46938086e-02f, -2.14502197e-02f, -4.51648012e-02f, -6.21881671e-02f,
  -1.30391913e-02f, -1.43926993e-01f, 3.52578498e-02f, 5.99419996e-02f, -5.92657588e-02f, -3.85421934e-03f, -8.32735524e-02f, -7.48080239e-02f, -2.07825422e-01f, -1.72743902e-01f,
  2.65460581e-01f, 1.71578199e-01f, -1.34220317e-01f, -1.78077236e-01f, -1.22692823e-01f, 1.20900579e-01f, -1.34781480e-01f, -2.80420542e-01f, -2.47915626e-01f, -4.23320740e-01f,
  8.69314224e-02f, 1.66813433e-02f, -1.93644501e-02f, -5.90328760e-02f, -5.48995994e-02f, -1.23279117e-01f, -2.73052957e-02f, -1.51158385e-02f, -6.83566229e-03f, -1.02203622e-01f,
  1.03119075e-01f, 1.66293666e-01f, 6.39357939e-02f, -4.34117280e-02f, -2.50501116e-03f, 1.03919141e-01f, -1.45173632e-02f, -1.36952147e-01f, -1.20836057e-01f, 2.46018227e-02f,
  3.67924757e-02f, -1.66435406e-01f, -7.79230846e-03f, -3.61741595e-02f, -4.22323495e-02f, 3.52005325e-02f, -2.92332452e-02f, 1.03643775e-01f, 1.82308733e-01f, -2.20008828e-02f,
  2.55720206e-02f, 1.63026780e-01f, -7.04943687e-02f, 1.12481806e-02f, -1.06741264e-01f, 9.08055082e-02f, -1.08054705e-01f, -1.21639697e-02f, -6.24627806e-02f, -5.52089661e-02f,
  2.15147659e-02f, -1.77870736e-01f, -4.58082967e-02f, -9.56221670e-02f, 4.17509563e-02f, -1.06388722e-02f, -1.53705984e-01f, -8.89478326e-02f, -4.52583656e-02f, -9.99363735e-02f,
  -6.35885894e-02f, 6.96871877e-02f, -2.37912327e-01f, -2.17416540e-01f, -2.14504544e-02f, 2.79885810e-02f, -3.27759311e-02f, -8.49572420e-02f, -1.61332667e-01f, -3.15593272e-01f,
  4.81004179e-01f, 1.30371407e-01f, 1.44296706e-01f, 4.79578488e-02f, 3.15880179e-02f, 4.56375219e-02f, 1.00368440e-01f, 4.93566878e-02f, 9.24236402e-02f, 8.26525390e-02f,
  9.85904112e-02f, 2.24313825e-01f, 2.08156705e-01f, 8.93287510e-02f, 1.02496892e-01f, 5.03277034e-02f, 1.02172688e-01f, 2.21441180e-01f, 1.53959230e-01f, 1.11645564e-01f,
  4.13487703e-02f, 1.10699952e-01f, 1.18243106e-01f, 8.10583308e-02f, 1.34480214e-02f, 1.46644518e-01f, 1.18707582e-01f, 3.87005098e-02f, 3.87039743e-02f, -5.78556722e-03f,
  9.38280150e-02f, 4.68084849e-02f, 8.80214572e-02f, -2.68701147e-02f, -1.20721772e-01f, -3.78705449e-02f, 1.79342907e-02f, -4.50474843e-02f, -7.56391957e-02f, -1.20247059e-01f,
  -9.28818136e-02f, -6.10541143e-02f, -6.91860020e-02f, -7.73339644e-02f, -2.71104909e-02f, -4.29808944e-02f, 8.95590708e-02f, 1.60925537e-01f, 1.33270353e-01f, 2.84439940e-02f,
  3.31363976e-02f, 4.19457927e-02f, 9.79303382e-03f, 2.12595817e-02f, 1.72698036e-01f, 9.17207971e-02f, 7.00966865e-02f, -1.99751966e-02f, 1.39997587e-01f, 9.69922990e-02f,
  1.14220969e-01f, 1.46124614e-02f, 4.62292731e-02f, 1.15216654e-02f, 8.58479068e-02f, 3.77786160e-02f, -8.34536552e-02f, 3.80392894e-02f, 1.71800226e-01f, 1.43232038e-02f,
  -1.86772972e-01f, 9.86253768e-02f, 1.14810325e-01f, -8.12784135e-02f, -4.02970202e-02f, 4.33960035e-02f, 8.19524378e-02f, -1.36173159e-01f, -1.76645219e-01f, -1.79411933e-01f,
  -4.13714126e-02f, -5.64897507e-02f, -2.35208243e-01f, -1.12931170e-01f, -1.15605541e-01f, -5.88860661e-02f, -4.88310941e-02f, -8.35631862e-02f, -9.41226706e-02f, -1.24937087e-01f,
  -1.95393682e-01f, 3.71178128e-02f, -7.87860677e-02f, 1.34073105e-02f, 4.08583507e-02f, -1.11613363e-01f, -7.83095509e-03f, -4.52173091e-02f, -1.54008642e-01f, 4.22728341e-03f,
  3.91545817e-02f, 5.81929423e-02f, -1.58734053e-01f, -8.97826403e-02f, 5.10403067e-02f, 7.05340728e-02f, -5.71218394e-02f, 1.69958904e-01f, 7.65052531e-03f, -1.95029695e-02f,
  7.49514392e-03f, 1.40526146e-01f, 7.36512244e-02f, 5.44665148e-03f, 2.04525199e-02f, 7.21103996e-02f, -5.26039451e-02f, -1.06485886e-02f, -5.79763241e-02f, 3.48502994e-02f,
  2.86223352e-01f, -1.69841111e-01f, 2.17454776e-01f, -3.66096087e-02f, -5.32109402e-02f, 2.29878630e-02f, -1.21486865e-01f, -2.76728496e-02f, 9.29130316e-02f, 7.68475700e-03f,
  6.51522279e-02f, 6.19239882e-02f, 1.02850340e-01f, 7.24595338e-02f, 1.40022516e-01f, -8.01158696e-03f, 3.72985266e-02f, 2.51026601e-01f, 3.41594487e-01f, 1.13762222e-01f,
  -8.46225843e-02f, 5.73126273e-03f, 1.80244166e-02f, -2.68533695e-02f, 4.55233753e-02f, 1.13397585e-02f, 1.25601571e-02f, -1.33023307e-01f, -2.48947050e-02f, -3.21927257e-02f,
  2.22026020e-01f, -1.26962781e-01f, 1.69950023e-01f, -2.11487889e-01f, -6.33604899e-02f, -6.90116286e-02f, -8.87059197e-02f, 4.61349823e-02f, -2.27775410e-01f, -1.11521967e-02f,
  -1.76764280e-02f, -2.98773893e-03f, -6.69523999e-02f, 3.89394797e-02f, -4.20699492e-02f, -4.54091467e-02f, -4.52789254e-02f, -6.03410527e-02f, 4.62773815e-02f, 6.78457133e-03f,
  -1.20484335e-02f, -3.50247510e-02f, 3.87715772e-02f, -6.73303474e-03f, -1.97362415e-02f, -1.38195902e-01f, -1.00360096e-01f, 2.58053001e-02f, 8.11266247e-03f, 1.00460738e-01f,
  7.74826780e-02f, 7.00073913e-02f, 5.29062673e-02f, -5.42785414e-02f, 6.67520333e-04f, 1.90104805e-02f, -8.26799721e-02f, 1.44443121e-02f, -1.72738992e-02f, 9.08443481e-02f,
  -3.44540589e-02f, 5.91816148e-03f, 8.22988078e-02f, 8.32937807e-02f, -7.71901291e-03f, 2.34224200e-02f, 1.62493233e-02f, 7.55599588e-02f, 2.47898363e-02f, -6.78252056e-02f,
  -9.60395951e-03f, 8.58749896e-02f, -4.18932065e-02f, -3.54971625e-02f, -1.32298553e-02f, 7.19435439e-02f, 1.63780749e-01f, 8.39151591e-02f, 8.50874037e-02f, -1.70311444e-02f,
  -2.62413491e-02f, -7.23701715e-02f, 2.18943655e-01f, -1.24067068e-01f, 5.59613183e-02f, -1.64575696e-01f, -1.06030874e-01f, -2.25902852e-02f, -1.75797552e-01f, 1.54805155e-02f,
  -3.04110255e-02f, -3.23615819e-02f, -8.07613358e-02f, 3.89847718e-02f, 1.22550294e-01f, -1.10560162e-02f, -5.17654344e-02f, -7.79976994e-02f, 3.85078788e-02f, -8.58324859e-03f,
  -5.82988113e-02f, 5.19786291e-02f, 1.79604992e-01f, 1.28454730e-01f, -5.73586114e-02f, -2.42817942e-02f, 8.41398239e-02f, 7.94969201e-02f, 8.18701684e-02f, 1.78357512e-01f,
  3.25587213e-01f, -8.43958110e-02f, -4.34724331e-01f, 2.50504464e-01f, 7.49177411e-02f, -2.62625664e-01f, -4.82682884e-01f, 6.17931597e-02f, 2.43470609e-01f, -1.67145599e-02f,
  -8.54355395e-02f, 1.37917064e-02f, -2.82812584e-02f, -2.92690665e-01f, -4.06849742e-01f, -3.95819038e-01f, -2.46058002e-01f, -2.74247050e-01f, -3.89965683e-01f, -1.49077624e-01f,
  -3.17595862e-02f, 6.05129451e-02f, -4.98892367e-02f, 1.40061956e-02f, 1.95921779e-01f, 1.37667194e-01f, -6.62272349e-02f, 9.29148793e-02f, -1.04741283e-01f, -9.66808498e-02f,
  -3.32923412e-01f, -6.56957030e-02f, 1.17676398e-02f, 2.03996096e-02f, 3.01178941e-03f, 1.09282450e-03f, -1.27204970e-01f, 3.17272246e-02f, 1.20828792e-01f, -2.72932276e-02f,
  9.12680030e-02f, 1.04364589e-01f, -3.98048237e-02f, 1.05658032e-01f, 4.48231287e-02f, -1.47619218e-01f, 2.00569890e-02f, -4.28197533e-02f, -9.84348655e-02f, -1.52902737e-01f,
  -4.16063853e-02f, -1.55026957e-01f, -1.77034676e-01f, -9.32661444e-03f, -1.61731780e-01f, 2.25753263e-02f, -2.75692735e-02f, -4.06745449e-02f, 1.93581660e-03f, 1.68372035e-01f,
  -1.60397887e-02f, 4.60204482e-02f, 1.31644681e-02f, 1.52610969e-02f, 6.18514828e-02f, 1.31774187e-01f, 6.51012082e-03f, 5.67426942e-02f, 9.26100835e-03f, 1.13443471e-01f,
  9.50477179e-03f, -8.29672515e-02f, 9.90341138e-03f, -4.96208668e-02f, 3.26074921e-02f, 6.66211322e-02f, 3.31647918e-02f, 5.11014424e-02f, -6.41301423e-02f, -1.09637408e-02f,
  2.26699300e-02f, 2.27702167e-02f, -6.77371770e-02f, 4.87034284e-02f, -4.07836773e-02f, 3.37653831e-02f, 8.80208611e-02f, 8.48693624e-02f, 1.57345075e-03f, -1.79991196e-03f,
  1.03479102e-01f, -3.32165182e-01f, 9.07319635e-02f, -8.43481719e-02f, 1.16486521e-02f, -4.26532002e-03f, 1.80590868e-01f, 1.09301917e-01f, 1.95867643e-01f, 7.66331777e-02f,
  1.98362730e-02f, -8.69297609e-02f, -3.86524908e-02f, -5.00227474e-02f, -7.40420520e-02f, -1.57510057e-01f, -3.77353840e-02f, 7.48408539e-03f, 1.74618587e-02f, 2.20341042e-01f,
  4.43951180e-03f, -1.15333863e-01f, 7.35250786e-02f, 7.60532394e-02f, 1.65667553e-02f, -2.52251644e-02f, -5.62072024e-02f, 4.04029042e-02f, -1.36511605e-02f, 7.81781897e-02f,
  -6.00116840e-03f, -5.63868046e-01f, 1.99071944e-01f, 1.43097356e-01f, 2.27845699e-01f, 4.14639354e-01f, 2.70177662e-01f, 2.52142221e-01f, 1.65964976e-01f, -1.10135200e-02f,
  -1.84468716e-01f, -2.25222066e-01f, -1.23665266e-01f, -8.92113447e-02f, -1.38164744e-01f, 8.04857090e-02f, 2.71983773e-01f, 2.38949567e-01f, 2.21771464e-01f, 4.18677479e-02f,
  -3.17735188e-02f, -3.85401472e-02f, -1.68811411e-01f, -7.82127529e-02f, -3.86421084e-02f, 6.04024008e-02f, 8.97684172e-02f, -5.21902107e-02f, -2.02674612e-01f, 1.30177841e-01f,
  -1.04729176e-01f, -1.71038747e-01f, 1.14407882e-01f, -8.09276253e-02f, -8.88626948e-02f, -2.13203169e-02f, -1.28284320e-02f, -1.55945346e-01f, -1.46106377e-01f, 9.40082688e-03f,
  -1.13235436e-01f, -1.36493847e-01f, 3.15199979e-02f, -1.65868718e-02f, 1.11096352e-01f, -2.85947919e-02f, -6.26492426e-02f, -2.57952958e-02f, -5.24397381e-02f, 2.28511393e-02f,
  -1.05466947e-01f, -2.76237633e-02f, 1.57270636e-02f, 1.87719334e-02f, 5.23452424e-02f, 3.79125439e-02f, 3.74243520e-02f, 1.19832061e-01f, 8.10856745e-03f, -6.12130426e-02f,
  -1.89321600e-02f, -1.01586863e-01f, -1.10302707e-02f, 3.90322581e-02f, 4.70663272e-02f, 1.69041976e-01f, 1.75253257e-01f, 5.36034396e-03f, -4.65267375e-02f, 7.26635233e-02f,
  1.03409782e-01f, 4.73054610e-02f, -1.66154355e-01f, -1.04148209e-01f, 5.47509529e-02f, 8.91510025e-03f, -5.58335222e-02f, -1.07902870e-01f, -4.60805595e-02f, -2.47739162e-02f,
  -4.60355766e-02f, 1.11255482e-01f, -5.01272231e-02f, 1.24246366e-01f, 8.65777284e-02f, 2.28246432e-02f, -6.78159762e-03f, -8.56176913e-02f, -7.80027285e-02f, -2.66104136e-02f,
  -1.09468229e-01f, -1.61969438e-01f, 9.15980116e-02f, -9.23900157e-02f, 2.18036044e-02f, -1.57962680e-01f, -9.53593999e-02f, -1.72298372e-01f, -1.18321873e-01f, -3.24630179e-02f,
  -1.59692347e-01f, -9.00374632e-03f, 4.23010252e-02f, -9.26735811e-03f, 1.32165506e-01f, 7.12507069e-02f, -1.59267351e-01f, 1.09076118e-02f, -9.43396315e-02f, -2.14876700e-03f,
  -2.82924585e-02f, 1.25365704e-01f, 7.78092965e-02f, 1.09512143e-01f, -7.31110647e-02f, 8.97619501e-02f, -3.93503755e-02f, 1.47482768e-01f, -1.65154021e-02f, -6.41852664e-03f,
  -2.33880311e-01f, -6.58279583e-02f, 1.32017471e-02f, -2.63553768e-01f, -1.37839898e-01f, 9.54795778e-02f, -5.12453802e-02f, 7.61325881e-02f, -3.09957508e-02f, -1.87748760e-01f,
  -8.71398151e-02f, -1.00314066e-01f, -2.09070235e-01f, 4.46038246e-02f, -2.45797727e-02f, -1.76731184e-01f, -1.89180046e-01f, 1.20016642e-01f, 2.97942251e-01f, 2.55586088e-01f,
  1.62907124e-01f, 2.25238819e-02f, 1.75407417e-02f, 8.11992958e-02f, -1.63990870e-01f, -8.33212212e-03f, -1.51314989e-01f, -1.79090217e-01f, -5.11852540e-02f, -4.22060877e-01f,
  -1.00996755e-01f, 1.19949048e-02f, 1.31494418e-01f, 1.34568382e-02f, 3.80119532e-02f, 6.74391910e-02f, 3.88507321e-02f, 6.13242276e-02f, 6.55388609e-02f, -5.51914312e-02f,
  1.44100022e-02f, 1.09958284e-01f, -2.18627639e-02f, 1.59663111e-01f, 5.23849055e-02f, -4.89338022e-03f, 5.55091649e-02f, -1.88053958e-03f, -1.25739262e-01f, 4.28755097e-02f,
  -8.12954009e-02f, -1.61300059e-02f, -1.07895382e-01f, -2.42832657e-02f, -7.99473748e-02f, -6.51664883e-02f, 2.16967091e-02f, -9.01216194e-02f, 2.86463201e-02f, -2.90390402e-01f,
  -3.93541679e-02f, -4.32208776e-02f, -7.43330782e-03f, 8.04379433e-02f, -5.90498224e-02f, -8.11668485e-02f, 4.65748236e-02f, -2.69458978e-03f, 1.87974516e-02f, -4.26097102e-02f,
  4.24925946e-02f, 9.08016413e-02f, 5.55986799e-02f, -3.60305570e-02f, -1.53725892e-02f, 4.45674807e-02f, -4.16505262e-02f, 2.22441386e-02f, 3.52171063e-02f, 2.28135679e-02f,
  2.52738278e-02f, 8.37134197e-03f, -1.27456740e-01f, -1.43667087e-02f, -2.49427035e-02f, -5.41467667e-02f, 1.79146733e-02f, 5.73307574e-02f, 9.13738310e-02f, -1.78647917e-02f,
  -2.43421823e-01f, 1.32126257e-01f, -1.87842369e-01f, 5.95874302e-02f, -6.06269110e-03f, -4.30715159e-02f, -4.73369099e-02f, 4.79170270e-02f, -3.72813046e-02f, 4.86887135e-02f,
  8.95984918e-02f, -5.34496224e-03f, -9.53102633e-02f, 5.52193820e-02f, -8.38621985e-03f, 9.18215811e-02f, -1.82767004e-01f, 5.32866009e-02f, -9.39787272e-03f, -6.54484853e-02f,
  -1.70806319e-01f, -2.52074860e-02f, -1.97995249e-02f, -1.01894014e-01f, -7.20429420e-02f, -1.08713716e-01f, 2.82288846e-02f, 4.23207134e-02f, -1.23466060e-01f, -2.93400139e-01f,
  -3.27207118e-01f, -3.20944935e-02f, -3.40746731e-01f, -2.01861188e-01f, -7.94913694e-02f, -1.18754031e-02f, -6.92258179e-02f, 1.99136749e-01f, 1.66285440e-01f, -2.79267728e-01f,
  -1.95150584e-01f, -1.67585686e-01f, -2.26930737e-01f, -8.34388435e-02f, -7.82635361e-02f, -2.64249057e-01f, -3.44641387e-01f, -2.50560194e-01f, -3.59904803e-02f, 1.04082808e-01f,
  -2.10316340e-03f, -2.38911018e-01f, -1.09331526e-01f, 2.07421109e-01f, 9.23875198e-02f, -1.62093167e-03f, -8.55255574e-02f, -3.69481482e-02f, 9.88292471e-02f, -1.55460894e-01f,
  -1.93430796e-01f, -4.39602137e-02f, -8.80226493e-02f, -3.54371481e-02f, -1.40350208e-01f, -6.23614863e-02f, -1.43168330e-01f, -8.33217576e-02f, -1.85950249e-02f, -1.45326112e-03f,
  -8.28982443e-02f, -5.51536530e-02f, -1.11224607e-01f, -9.17441323e-02f, -6.95629865e-02f, -4.94446643e-02f, -5.99385193e-03f, -8.14351514e-02f, 3.44904475e-02f, 9.19493195e-03f,
  6.09772503e-02f, 8.81637260e-02f, 1.18569285e-01f, 1.15901247e-01f, 6.84787109e-02f, -1.23337366e-01f, 1.28595844e-01f, 2.42526531e-01f, 1.30082086e-01f, 1.79791257e-01f,
  -3.14988829e-02f, -1.22123333e-02f, -1.00413375e-01f, 3.43757793e-02f, -1.24997675e-01f, -8.24377090e-02f, -7.04972399e-03f, -1.50497824e-01f, 1.01969228e-04f, -7.90104568e-02f,
  -2.97607165e-02f, -3.79150845e-02f, 4.00491022e-02f, 6.82209758e-03f, 4.80597652e-02f, -1.42979585e-02f, 6.80473074e-02f, -1.02002211e-02f, -4.26532254e-02f, -6.71500787e-02f,
  4.30692844e-02f, 1.06881084e-02f, 2.35492643e-02f, 1.43157259e-01f, 8.99831727e-02f, -8.23854208e-02f, 4.62173782e-02f, -3.97760794e-02f, -7.46265948e-02f, -2.53874101e-02f,
  -1.78179145e-01f, -1.74753532e-01f, -9.14450362e-02f, 3.81426290e-02f, -2.49450393e-02f, -2.45073680e-02f, -6.35196865e-02f, 1.12263458e-02f, -2.01756522e-01f, 1.59866855e-01f,
  1.16010129e-01f, -3.72312330e-02f, -1.14743173e-01f, 3.36321630e-02f, -1.68631136e-01f, 5.78501746e-02f, -4.04036380e-02f, 4.44347374e-02f, 3.53096239e-02f, 9.95527506e-02f,
  1.00684218e-01f, 1.61528349e-01f, -1.92874130e-02f, -5.69502125e-03f, 4.56653759e-02f, -2.90758125e-02f, -4.03322913e-02f, 1.76583558e-01f, 1.09807514e-01f, 5.29502407e-02f,
  1.91637978e-01f, 3.27842653e-01f, -2.92851049e-02f, 9.38183591e-02f, 2.03607455e-01f, 1.69019297e-01f, 3.00563693e-01f, 1.49340972e-01f, -4.54406217e-02f, 8.50070417e-02f,
  1.04446657e-01f, 8.66715759e-02f, 8.55763480e-02f, 5.82904555e-02f, 1.24761119e-01f, 5.34245186e-02f, -4.13849077e-04f, -1.56919196e-01f, -1.23236910e-01f, 3.38134840e-02f,
  1.47151485e-01f, -3.02201509e-03f, -1.04033701e-01f, 3.22286598e-02f, 6.34906888e-02f, 4.02894057e-03f, 1.10725641e-01f, 4.32872912e-03f, -4.89231758e-02f, -2.49888659e-01f,
  -1.66505828e-01f, 1.28592879e-01f, 3.65031185e-03f, 4.96596731e-02f, 4.29229587e-02f, 4.20847302e-03f, -8.52801204e-02f, -2.98204385e-02f, 1.91547500e-03f, -1.14721805e-01f,
  -1.58496350e-01f, -6.66928589e-02f, 3.91964391e-02f, -8.94279312e-03f, 1.81576554e-02f, 4.05646628e-03f, 2.54422855e-02f, 3.81323174e-02f, -1.65675562e-02f, -3.42381583e-03f,
  8.38017911e-02f, 3.37928832e-02f, -1.17440317e-02f, 8.72212648e-02f, 5.02319373e-02f, -1.36265578e-02f, 1.25911579e-01f, 7.45232403e-02f, -1.83728915e-02f, -9.64131281e-02f,
  1.43915161e-01f, -1.12891076e-02f, 9.48523283e-02f, 6.88806996e-02f, -7.86580495e-04f, -5.32854311e-02f, 1.70822616e-03f, 6.84917569e-02f, -5.14687113e-02f, 8.86550471e-02f,
  -3.09681296e-02f, -9.55710188e-02f, -3.14025767e-02f, 7.04634935e-02f, 1.55768981e-02f, 6.26319945e-02f, -1.00216836e-01f, 1.04076359e-02f, 2.25222670e-02f, -2.50642840e-02f,
  -3.95867191e-02f, -3.49883065e-02f, 7.01366216e-02f, -4.04692888e-02f, 5.38957193e-02f, 1.71308946e-02f, -7.62993544e-02f, 1.67382658e-01f, 8.73608813e-02f, 2.41857134e-02f,
  -1.60027653e-01f, 2.26333514e-01f, -9.72767696e-02f, 6.22273982e-03f, -9.68895257e-02f, -2.10169293e-02f, 7.13679492e-02f, 4.78844019e-03f, -5.96670695e-02f, -1.55298691e-03f,
  -6.62596524e-02f, -1.69571102e-01f, -7.29012936e-02f, -8.24656039e-02f, -4.18398418e-02f, -9.32334661e-02f, -2.58315336e-02f, 8.64592195e-03f, -1.43717989e-01f, -1.39589205e-01f,
  -8.35274011e-02f, -7.22807646e-02f, -4.61018942e-02f, 8.87007103e-04f, -6.83367252e-02f, 1.39969677e-01f, -8.64502564e-02f, -8.66926312e-02f, 1.91364940e-02f, 7.18393251e-02f,
  2.83202827e-01f, -2.84665734e-01f, -2.39583984e-01f, -1.82973519e-01f, -2.51493424e-01f, -1.75260738e-01f, -1.49013668e-01f, 7.91040063e-03f, -1.37706980e-01f, -1.88199237e-01f,
  3.33436951e-02f, 1.95336759e-01f, -6.28255904e-02f, 5.78922145e-02f, -6.48414297e-03f, -3.48583758e-01f, -4.67584580e-01f, -2.04527855e-01f, 3.63202244e-02f, -1.98021196e-02f,
  -9.23963636e-02f, -1.08434625e-01f, -1.86726853e-01f, -1.59277201e-01f, -2.37338856e-01f, -1.83409005e-01f, -3.69238883e-01f, -1.83260545e-01f, -2.87111640e-01f, -4.18404520e-01f,
  -1.39061078e-01f, 9.78250355e-02f, 1.39272094e-01f, 2.29362920e-02f, 2.23580152e-02f, 7.02204257e-02f, 1.08399160e-01f, 4.91050165e-03f, 1.76880538e-01f, -1.52514679e-02f,
  -4.11368087e-02f, -4.92111072e-02f, 5.52785769e-02f, 1.81896836e-02f, -1.33270975e-02f, 1.47057576e-02f, 1.34624511e-01f, 1.51330382e-01f, -5.48828728e-02f, 9.29662660e-02f,
  4.10211422e-02f, 1.84465379e-01f, 1.16786815e-01f, 2.77865022e-01f, 2.09621966e-01f, 1.99133039e-01f, 3.63693908e-02f, 1.44138947e-01f, 8.07147995e-02f, 1.32677108e-01f,
  -1.41965866e-01f, 4.25047241e-02f, 1.28915071e-01f, 1.09784119e-01f, 8.75331461e-02f, 1.56455576e-01f, 2.21958067e-02f, 3.40476632e-02f, 3.24371122e-02f, 3.91672142e-02f,
  6.70083687e-02f, 7.20311180e-02f, 8.12720433e-02f, -8.16094279e-02f, -6.55454025e-02f, 6.18757494e-02f, 7.41429627e-02f, -1.01536177e-01f, -2.94869044e-03f, -7.68188387e-02f,
  -8.99361633e-03f, -6.93117231e-02f, -1.23605236e-01f, -2.75627431e-02f, 6.43255422e-03f, 1.45349642e-02f, 1.59052312e-02f, -3.30987945e-02f, 1.42664267e-02f, -1.30745471e-01f,
  2.13422235e-02f, 4.14313152e-02f, -7.98674747e-02f, 1.82364509e-02f, -1.13242470e-01f, -4.15512398e-02f, -3.96336429e-02f, -1.02679193e-01f, -2.75774058e-02f, -7.54171386e-02f,
  8.11189637e-02f, -1.13175154e-01f, -8.78221914e-02f, 9.31128636e-02f, 1.20033950e-01f, 6.62862360e-02f, 1.07020728e-01f, 1.98798403e-02f, -6.53054416e-02f, -1.70024410e-01f,
  -4.51695994e-02f, 1.03580803e-01f, 1.68366835e-01f, 1.68670893e-01f, 1.44452021e-01f, 1.10676482e-01f, 4.24530432e-02f, 3.12618390e-02f, -2.39548478e-02f, 1.27878681e-01f,
  2.55728424e-01f, 1.87888339e-01f, 2.42707700e-01f, 1.78648099e-01f, 1.05057821e-01f, 1.68189600e-01f, 2.03201801e-01f, 1.32908136e-01f, 2.68194899e-02f, 3.94659629e-03f,
  1.57211185e-01f, 1.24207400e-02f, -3.66218127e-02f, 6.71530738e-02f, 1.48700714e-01f, 1.46570638e-01f, 1.07725166e-01f, 2.72067655e-02f, -3.25087048e-02f, -1.35125136e-02f,
  -2.52778567e-02f, 1.63932480e-02f, 4.87589836e-02f, -2.09780894e-02f, -3.31091061e-02f, -5.64198531e-02f, -3.14197540e-02f, 1.12867765e-01f, -1.20552005e-02f, -1.04960471e-01f,
  -1.18813433e-01f, 1.48354113e-01f, -5.74245043e-02f, -2.84832232e-02f, -7.49030039e-02f, -1.35382429e-01f, -7.10993111e-02f, -5.92464507e-02f, -2.95994394e-02f, -9.91530046e-02f,
  -1.12563908e-01f, -4.95387949e-02f, 6.19833618e-02f, -8.04481804e-02f, 2.75964607e-02f, 2.77000815e-02f, 6.11889809e-02f, 1.02834806e-01f, 7.77022615e-02f, -5.55826649e-02f,
  1.82699952e-02f, 3.48013379e-02f, -7.64463395e-02f, 6.52288422e-02f, 1.07158951e-01f, 5.61381392e-02f, 2.51954398e-03f, -1.16471993e-02f, 4.61421721e-02f, 2.00456902e-02f,
  -1.03950091e-01f, 7.02189878e-02f, 2.75360458e-02f, -1.69396345e-02f, 7.41987675e-02f, 1.19128413e-01f, -5.96794039e-02f, 5.85597903e-02f, 1.44780293e-01f, 2.37209480e-02f,
  5.88519797e-02f, -6.04290888e-02f, -1.61541365e-02f, 1.28496766e-01f, 1.92070194e-02f, -2.62232628e-02f, -1.99804492e-02f, -2.31306739e-02f, -2.43229829e-02f, -7.23409951e-02f,
  6.54808134e-02f, -1.71265498e-01f, 1.12072183e-02f, 7.49439523e-02f, -6.15184419e-02f, 8.56736377e-02f, 1.63207704e-03f, -6.56677317e-03f, -2.81609818e-02f, -1.54756112e-02f,
  -3.22216272e-01f, 1.39402132e-02f, -1.85997665e-01f, -1.47791982e-01f, -1.20237861e-02f, -7.22757056e-02f, 8.51512700e-02f, -1.88129619e-01f, -1.92282200e-01f, -5.79548590e-02f,
  -4.70406525e-02f, -1.53296769e-01f, 1.18532017e-01f, 7.37163797e-02f, -1.41576424e-01f, -5.85512370e-02f, -3.58624198e-02f, -7.56380036e-02f, -6.18494563e-02f, -2.12054640e-01f,
  -3.31241712e-02f, -1.56375691e-01f, -4.59791459e-02f, -6.40039891e-02f, 2.38717254e-02f, -1.88375846e-01f, -1.63613781e-01f, -1.41873226e-01f, 6.75778836e-02f, -2.32834816e-02f,
  -9.42395627e-02f, -2.47236490e-01f, -2.87768513e-01f, -1.93963125e-01f, -1.01020001e-01f, -1.35296099e-02f, -1.61446333e-01f, 1.32580474e-01f, -5.83758950e-03f, -3.29564035e-01f,
  -7.26372749e-03f, 1.22978203e-01f, -1.72619715e-01f, 6.86979815e-02f, -8.39473493e-03f, -3.13770026e-01f, -2.80983865e-01f, 5.12250178e-02f, 2.69316226e-01f, 3.42776507e-01f,
  1.95357725e-02f, -1.38375228e-02f, 1.10103376e-02f, 8.68600756e-02f, -1.21844344e-01f, -4.33866605e-02f, -3.33742380e-01f, -1.02642126e-01f, -9.28179100e-02f, -3.34501743e-01f,
  -2.53899157e-01f, 1.91213444e-01f, 1.50547981e-01f, -3.21280807e-02f, -2.41575301e-01f, 1.37613595e-01f, 4.90132421e-02f, -4.74570766e-02f, 9.27931350e-03f, -8.07596445e-02f,
  8.59308615e-02f, 1.40222088e-01f, 1.29835978e-01f, 6.88917860e-02f, -6.68914318e-02f, 1.59835699e-03f, -1.39734566e-01f, 7.62632443e-03f, 8.32943395e-02f, 8.84187967e-02f,
  8.01190138e-02f, 1.01121152e-02f, 8.79682600e-02f, 8.88138190e-02f, 6.81411326e-02f, -8.74658152e-02f, -3.49527448e-02f, 1.95560843e-01f, 1.11007728e-02f, -1.81428328e-01f,
  -2.42023654e-02f, 2.58024335e-02f, 6.71204478e-02f, 3.46824452e-02f, 9.90408286e-02f, 7.11471364e-02f, 4.20234352e-02f, -4.11957242e-02f, 1.26728758e-01f, 5.89488000e-02f,
  5.84664084e-02f, -2.27641147e-02f, -1.07542761e-01f, -5.27410023e-02f, -1.20911129e-01f, 2.27998700e-02f, 2.68916935e-02f, -7.20045790e-02f, -6.96883816e-03f, -2.70693116e-02f,
  1.37913346e-01f, 8.56522396e-02f, -1.21660069e-01f, 6.26417994e-02f, 5.05491979e-02f, -4.15428989e-02f, 8.64780694e-02f, 1.45164102e-01f, -7.40281790e-02f, 1.02894135e-01f,
  -3.03915590e-01f, 3.56494859e-02f, -4.20580395e-02f, 5.44596165e-02f, 4.01285142e-02f, -3.02665364e-02f, -6.77271187e-02f, -1.37394547e-01f, -1.78753920e-02f, -4.85489257e-02f,
  -4.76316316e-03f, -2.88436729e-02f, -1.58991650e-01f, -2.98394379e-03f, 4.00709324e-02f, 5.81679828e-02f, -1.61117151e-01f, 2.25990918e-02f, 1.43889990e-02f, -9.46953595e-02f,
  -3.64488512e-02f, 6.26202300e-02f, -7.76604936e-02f, -5.13078496e-02f, 4.27296385e-02f, -3.57157886e-02f, -8.04969594e-02f, 3.37727033e-02f, 3.66248265e-02f, -2.54088968e-01f,
  6.19332194e-01f, -2.81313151e-01f, -4.45332915e-01f, 5.49727380e-02f, -1.79521918e-01f, 2.61002616e-03f, -4.64227125e-02f, 2.05735192e-01f, 2.23498046e-01f, -9.46051329e-02f,
  5.16734384e-02f, 1.98921070e-01f, 9.44423303e-02f, 3.74373398e-03f, 9.83470976e-02f, -3.37954462e-01f, -3.05886447e-01f, 1.67317055e-02f, 1.94434151e-01f, 1.02990948e-01f,
  1.41352668e-01f, 1.09732121e-01f, 3.45632553e-01f, 9.10556838e-02f, -2.90740997e-01f, 4.06861007e-02f, -1.92663521e-01f, -1.27444535e-01f, -1.44593030e-01f, -5.43273449e-01f,
  -4.22186404e-01f, -6.08105734e-02f, 3.27274799e-02f, 5.77839185e-03f, -2.24551737e-01f, 9.01555717e-02f, 2.81767938e-02f, -1.05198748e-01f, 9.78572443e-02f, -2.77723316e-02f,
  -1.14245161e-01f, -2.42409315e-02f, -1.11702308e-02f, -2.28642523e-02f, -8.18386301e-02f, -1.52862310e-01f, 2.42668614e-02f, -7.76322633e-02f, 3.75797637e-02f, -1.61927819e-01f,
  -3.04643381e-02f, -1.07113667e-01f, -8.40117708e-02f, -1.26613900e-01f, -9.74972323e-02f, 2.38448083e-02f, -6.33133948e-02f, -4.49449010e-02f, -8.01661834e-02f, -2.47403845e-01f,
  -5.29694036e-02f, -6.77563027e-02f, 7.22528696e-02f, 7.48758465e-02f, 1.92226961e-01f, 6.73669428e-02f, -4.21989076e-02f, -7.17984736e-02f, 1.62831862e-02f, -7.24523887e-02f,
  -9.83720273e-02f, -1.39003629e-02f, 7.48119205e-02f, -8.52239802e-02f, -4.63328362e-02f, 1.09465770e-01f, -8.27217922e-02f, 2.25087330e-02f, -1.70403707e-03f, 1.84946552e-01f,
  1.01150088e-01f, -7.63433725e-02f, 6.44193441e-02f, -4.94094286e-03f, 3.15064862e-02f, 3.37310843e-02f, -1.09442540e-01f, 6.43541738e-02f, -1.52295651e-02f, 1.06971994e-01f,
  5.02247773e-02f, 1.17712215e-01f, -2.62874961e-02f, -5.25142886e-02f, -6.34528100e-02f, 2.16093548e-02f, 6.62407875e-02f, 1.62416492e-02f, 4.57673296e-02f, -1.72430854e-02f,
  -2.80917203e-03f, 3.44370189e-03f, -2.97757387e-02f, 4.81013991e-02f, -1.72210075e-02f, 1.18159264e-01f, 1.42138779e-01f, 6.34562671e-02f, 1.74989685e-01f, 6.80807512e-03f,
  -1.80109479e-02f, 1.18693456e-01f, 1.16615109e-01f, -8.98996443e-02f, 4.82658483e-02f, 1.55784085e-01f, 2.99156141e-02f, 5.99557646e-02f, 7.84312934e-02f, 5.39442077e-02f,
  5.71500182e-01f, -1.81718796e-01f, -2.24134177e-01f, 2.21456245e-01f, -1.07869074e-01f, -4.06535305e-02f, -2.17697006e-02f, 6.39372990e-02f, 4.75584902e-02f, -7.35168606e-02f,
  -2.08595574e-01f, 4.15992290e-02f, -5.72089404e-02f, -1.19670138e-01f, -1.59932282e-02f, -1.10976875e-01f, -8.25883523e-02f, 4.96197157e-02f, -3.21769714e-02f, -3.77017334e-02f,
  4.94430447e-03f, 3.55600715e-02f, 2.85298396e-02f, 8.32352936e-02f, -1.25399396e-01f, 2.01438405e-02f, -1.56206474e-01f, -8.04665312e-02f, -1.87199265e-01f, -3.37895125e-01f,
  -2.86079198e-02f, -2.07580402e-02f, -3.33241224e-02f, -3.46070668e-03f, 1.47804946e-01f, 9.97439846e-02f, -4.21813093e-02f, -5.61694391e-02f, 6.80786297e-02f, 1.23069860e-01f,
  -1.02705806e-02f, -6.67516515e-02f, 4.85017076e-02f, -6.58459403e-03f, 7.01836199e-02f, -3.33098136e-02f, -3.30565348e-02f, -2.50935294e-02f, 5.52713387e-02f, -7.12519065e-02f,
  2.94857696e-02f, 2.70682685e-02f, -3.52817848e-02f, -3.49709466e-02f, -4.54159193e-02f, -5.07760793e-02f, -8.79018009e-02f, -1.34379685e-01f, -1.14011861e-01f, -1.09353632e-01f,
  -6.30882308e-02f, -1.60682518e-02f, 8.60653371e-02f, 2.71518212e-02f, 2.72694118e-02f, 8.68355781e-02f, -4.22797389e-02f, 3.00408900e-02f, -1.49625624e-02f, -4.14976142e-02f,
  -6.59142807e-03f, 2.29229312e-02f, -1.18723353e-02f, 5.92179187e-02f, 4.34002168e-02f, -6.02194071e-02f, 7.01969815e-03f, -3.12621109e-02f, -2.33623330e-02f, 1.09846592e-01f,
  9.46221426e-02f, -4.29267250e-02f, 9.06500667e-02f, 9.19906702e-03f, -2.21422389e-02f, -3.84299792e-02f, -5.28966822e-02f, -1.04537439e-02f, -4.45523188e-02f, 1.48425614e-02f,
  1.82798028e-01f, -9.32658929e-03f, 7.58482218e-02f, -8.18307847e-02f, 8.00339878e-02f, 5.05752452e-02f, -8.62831064e-03f, 7.12256581e-02f, -8.27118158e-02f, -8.92590825e-03f,
  -2.01508358e-01f, 3.16495299e-02f, -4.05616947e-02f, -3.89161557e-02f, 2.81761419e-02f, 2.26585828e-02f, 2.34001316e-02f, -1.58545710e-02f, -1.34671494e-01f, -2.34732851e-02f,
  8.10635388e-02f, 1.89085811e-01f, 1.64421156e-01f, 8.87933299e-02f, -4.80204746e-02f, 2.32340366e-01f, 1.36740401e-01f, -2.04086844e-02f, 1.13888092e-01f, 1.40162036e-01f,
  -2.37367511e-01f, 1.43651171e-02f, -1.47878245e-01f, -2.39347652e-01f, -3.06445658e-01f, -9.35672149e-02f, 7.67279603e-03f, 1.42993433e-02f, -4.39760461e-02f, -1.14777833e-01f,
  -3.43073122e-02f, 1.61700845e-01f, 2.17434287e-01f, 1.21882133e-01f, 1.26118720e-01f, -2.01016739e-01f, -2.98237562e-01f, -2.21781343e-01f, 2.46804580e-02f, -2.67110579e-02f,
  -8.56183022e-02f, -1.39045745e-01f, -1.56574517e-01f, -1.23049907e-01f, -1.44526541e-01f, 5.95528353e-03f, -2.53434777e-01f, -1.46652490e-01f, -5.72888069e-02f, -2.20889032e-01f,
  1.60249695e-01f, -1.29604369e-01f, 3.69780771e-02f, -8.53385106e-02f, -1.16259925e-01f, -5.19531779e-02f, 1.14645675e-01f, -5.25442250e-02f, -2.44591646e-02f, 1.88903194e-02f,
  -4.44574989e-02f, -4.18889001e-02f, -1.18833371e-01f, 3.19929980e-02f, -2.16285139e-02f, -2.50721514e-01f, -3.26716542e-01f, -1.67733535e-01f, -1.27235219e-01f, -7.37545043e-02f,
  -1.35058478e-01f, -2.77675152e-01f, 8.63550380e-02f, -1.24223195e-01f, -1.24028355e-01f, -9.81456935e-02f, -4.77399565e-02f, 8.23742151e-02f, 4.15107980e-02f, -3.66489775e-02f,
  -1.46992458e-03f, -2.67121345e-02f, -4.22616675e-02f, 1.22432239e-01f, 8.81794374e-04f, 9.00104549e-03f, 2.02080887e-02f, 1.39263779e-01f, 5.73640801e-02f, 7.17659295e-02f,
  4.07081991e-02f, -1.38716372e-02f, 1.23896427e-03f, -1.41337458e-02f, -1.05221860e-01f, -7.22645819e-02f, 2.70610321e-02f, -2.62835119e-02f, 9.26095769e-02f, -7.94268623e-02f,
  6.46176841e-03f, -1.77009050e-02f, -6.10843673e-02f, 1.79713052e-02f, -7.39602894e-02f, 7.85211474e-03f, -1.09351777e-01f, 6.77644610e-02f, -4.00662422e-03f, -2.79870722e-02f,
  1.80580512e-01f, -2.25089744e-01f, 1.40288204e-01f, 7.30107725e-02f, 1.89648550e-02f, -4.42849435e-02f, 4.37877588e-02f, -9.68165696e-02f, -2.60329656e-02f, 3.04614976e-02f,
  -4.20602299e-02f, 2.66131070e-02f, -7.21441805e-02f, -1.29850924e-01f, -9.07249302e-02f, -3.42563726e-02f, 4.48194034e-02f, 7.30980001e-03f, 1.79440565e-02f, -2.12838352e-01f,
  -1.55505806e-01f, -5.15536182e-02f, 1.75989062e-01f, 1.29965559e-01f, 7.69480411e-03f, 9.93629023e-02f, 8.83890763e-02f, 1.16293401e-01f, 1.12936996e-01f, 9.28749293e-02f,
  -7.00107992e-01f, -1.88515410e-01f, 3.71799350e-01f, -3.89461905e-01f, -8.88443962e-02f, -4.17317562e-02f, 1.84118375e-02f, -6.27441108e-02f, -2.52219349e-01f, -1.67810604e-01f,
  7.22555965e-02f, -1.78274348e-01f, 4.90941629e-02f, 9.99291316e-02f, -2.96537001e-02f, -5.74159026e-02f, 7.93162212e-02f, 8.21142495e-02f, 1.76624730e-01f, 9.96078849e-02f,
  -8.21769387e-02f, -1.36162132e-01f, -1.21238165e-01f, 8.46735239e-02f, -2.76093394e-01f, -3.21932510e-02f, 2.41855364e-02f, -1.27388254e-01f, 1.55683801e-01f, -8.69778022e-02f,
  2.13194303e-02f, -1.34737119e-01f, 2.52849191e-01f, -2.15555072e-01f, -4.05239873e-02f, 9.27417725e-03f, -1.11514799e-01f, -5.24498001e-02f, 5.86208068e-02f, 6.13653474e-02f,
  -1.98308930e-01f, 1.08400859e-01f, -1.51708618e-01f, -1.27996979e-02f, -6.08175583e-02f, -1.40918419e-01f, 9.79873985e-02f, 8.95715430e-02f, 3.48812081e-02f, 1.91230297e-01f,
  -3.59470882e-02f, -6.79059923e-02f, -4.93587181e-02f, 1.01946414e-01f, 1.01039618e-01f, 9.94313881e-02f, 1.77223742e-01f, 1.24366917e-01f, 2.75840163e-01f, -3.54531035e-02f,
  3.77761782e-03f, -7.82591999e-02f, -1.91179533e-02f, 6.57825917e-02f, 3.94602455e-02f, -5.45113795e-02f, -1.30036637e-01f, -4.65215929e-02f, 1.76692046e-02f, -5.41071892e-02f,
  5.05897067e-02f, 1.85520723e-02f, -5.29453205e-03f, 3.15757617e-02f, 1.31697372e-01f, -1.33230001e-01f, -6.63935170e-02f, 3.74774113e-02f, 9.46405604e-02f, -1.95595939e-02f,
  -1.91937424e-02f, -9.07813758e-03f, -8.63813683e-02f, -1.73328951e-01f, -6.48102164e-02f, -2.22221278e-02f, -1.84699018e-02f, 7.08211437e-02f, 7.42898360e-02f, 7.01198801e-02f,
  -2.50602394e-01f, 4.28635389e-01f, -2.29868010e-01f, -9.95906815e-02f, -3.48343626e-02f, 7.27099031e-02f, -2.01714262e-02f, -2.34744940e-02f, 1.73257031e-02f, -4.04232414e-03f,
  2.13058293e-02f, -5.42215258e-02f, -2.91235838e-02f, 1.69824943e-01f, -5.11129759e-02f, 4.18141298e-02f, 1.98224634e-02f, 8.32391530e-03f, 1.68714654e-02f, -1.48970746e-02f,
  -8.25769734e-03f, -7.73417577e-02f, -2.91699767e-01f, -3.04407272e-02f, -2.41925955e-01f, -6.35652542e-02f, -9.29909013e-03f, 8.03223923e-02f, 1.25243738e-01f, -3.41903530e-02f,
  -5.01288950e-01f, 1.02471896e-01f, -1.56367496e-01f, -2.14385331e-01f, 3.39978546e-01f, 2.46554524e-01f, 1.80939391e-01f, 1.20805994e-01f, 1.28936589e-01f, 1.15966098e-02f,
  1.24319151e-01f, 8.89909342e-02f, -7.69067137e-03f, 1.03035249e-01f, 2.91103702e-02f, -2.28138268e-02f, 8.79653692e-02f, -1.20578900e-01f, -1.37770668e-01f, 9.27868038e-02f,
  1.91303313e-01f, -8.35313126e-02f, -1.55088037e-01f, -7.04581141e-02f, -5.20984419e-02f, 6.73047602e-02f, 4.71387841e-02f, 1.08560890e-01f, 1.18093967e-01f, -3.61873619e-02f,
  -2.15389132e-01f, -1.34388626e-01f, 1.02388531e-01f, -9.09958631e-02f, 6.12264462e-02f, -2.42473736e-01f, 1.67852221e-03f, -1.58655077e-01f, -4.37718667e-02f, -1.30341396e-01f,
  -4.38972414e-02f, 8.32516775e-02f, 3.96012180e-02f, -2.61001624e-02f, -1.31502122e-01f, 1.62227149e-03f, -9.03091580e-02f, -6.47236407e-02f, -3.04879546e-01f, -1.44281417e-01f,
  4.43330482e-02f, 9.42606479e-02f, -2.11525112e-01f, 1.06325105e-01f, -1.22988038e-01f, -1.02297403e-01f, -6.53264076e-02f, -5.66052049e-02f, -7.06144646e-02f, -1.69465140e-01f,
  5.31492233e-02f, 1.33270681e-01f, -1.24722077e-02f, 9.11735967e-02f, -3.04160137e-02f, -4.66321595e-02f, 8.02626535e-02f, 2.01786935e-01f, 6.34361506e-02f, 2.37475671e-02f,
  8.37328434e-02f, 6.39569685e-02f, 7.83732161e-02f, 2.27271840e-02f, 1.63125694e-01f, -5.09106852e-02f, 3.50207165e-02f, -1.51506886e-01f, 7.19432235e-02f, 1.17225863e-01f,
  -9.39766541e-02f, 1.96969416e-02f, -1.78685427e-01f, -8.47914964e-02f, -1.61309659e-01f, -5.06577492e-02f, -7.62903914e-02f, -5.22041470e-02f, -2.39498112e-02f, -2.94819959e-02f,
  -1.46153063e-01f, 1.71856865e-01f, -5.30399680e-02f, 1.00011446e-01f, 1.31497785e-01f, 4.52017505e-03f, -2.66101658e-02f, -1.40228286e-01f, -2.07693204e-01f, -4.12941277e-02f,
  -2.58967355e-02f, 9.73992236e-03f, -7.99788013e-02f, -1.05013125e-01f, -1.81046948e-01f, -1.80011705e-01f, -9.82692838e-02f, 3.04010864e-02f, -9.00788158e-02f, 4.79968339e-02f,
  -1.90680385e-01f, -3.48007716e-02f, -2.45136246e-01f, -4.49203104e-02f, 3.98918465e-02f, -7.64494091e-02f, -2.81707067e-02f, -8.78998488e-02f, -2.00311430e-02f, -1.88159674e-01f,
  3.99483383e-01f, -3.55533868e-01f, -1.95679024e-01f, 1.63486362e-01f, -8.38462040e-02f, -8.48486796e-02f, -1.91865981e-01f, -2.31965017e-02f, 8.81632641e-02f, -3.19551498e-01f,
  -9.42443460e-02f, 2.05100387e-01f, 7.44971335e-02f, 9.36301649e-02f, 9.56447050e-02f, -2.09508047e-01f, -3.10148358e-01f, 7.85983652e-02f, 4.25352454e-01f, 1.75580338e-01f,
  2.50574248e-03f, 4.58440557e-02f, 1.42631307e-01f, 1.25351623e-01f, -2.11523667e-01f, 3.86628285e-02f, -2.06790268e-01f, -1.36601239e-01f, -8.65397677e-02f, -3.45270067e-01f,
  -2.79000193e-01f, 2.13523041e-02f, -1.73649956e-02f, 1.21487699e-01f, -7.18640834e-02f, -4.01072670e-03f, -8.29838961e-02f, -9.74138528e-02f, -1.99803263e-02f, -8.98713842e-02f,
  2.39373744e-03f, 3.98925878e-02f, 7.05826730e-02f, 8.75639692e-02f, -5.58035821e-03f, -3.74770761e-02f, -1.45283073e-01f, 3.60442251e-02f, -1.74276773e-02f, -9.13198590e-02f,
  -1.14932448e-01f, -4.68421094e-02f, -1.96829457e-02f, -1.18477628e-01f, -1.39248550e-01f, -5.65253310e-02f, -1.48498967e-01f, -1.64895635e-02f, 1.72459967e-02f, -1.56463519e-01f,
  -2.94726230e-02f, -1.38007447e-01f, -8.63309279e-02f, 5.26441000e-02f, -2.15771329e-02f, 6.27268925e-02f, 2.19295993e-02f, -1.05927788e-01f, 3.27638611e-02f, -5.58062606e-02f,
  -8.46006051e-02f, -7.46594891e-02f, 2.10534036e-02f, -2.75918059e-02f, -1.09169848e-01f, 8.11000541e-02f, -8.74037221e-02f, 3.97867896e-02f, -5.43779954e-02f, 7.11341277e-02f,
  1.11030988e-01f, -7.83978254e-02f, -1.08152218e-01f, 1.29004875e-02f, -4.33003269e-02f, -9.22054872e-02f, 4.12262604e-03f, -2.18538847e-03f, -2.27388684e-02f, 7.54238293e-03f,
  -3.74955907e-02f, 2.97811441e-02f, -1.79624155e-01f, 1.21124327e-01f, -1.29084624e-02f, -9.39560533e-02f, -1.50658831e-01f, 1.69232849e-03f, 7.39632919e-02f, 1.70641826e-04f,
  5.91588952e-02f, -6.12097755e-02f, 3.04667018e-02f, -8.62371735e-03f, -6.63439631e-02f, -2.18994282e-02f, -1.71166379e-03f, 8.73362347e-02f, 1.79445557e-02f, 2.21031043e-03f,
  3.37487124e-02f, -7.25928647e-03f, 7.67730847e-02f, -4.73132282e-02f, -4.99947136e-03f, 1.31165117e-01f, -3.54781263e-02f, -4.71810251e-02f, 8.02399740e-02f, -2.45654266e-02f,
  1.86157584e-01f, 1.09087661e-01f, -2.39897132e-01f, 2.86665291e-01f, -9.53707248e-02f, -2.60442019e-01f, -2.58389741e-01f, -5.53453155e-03f, 2.62211144e-01f, 2.05588534e-01f,
  3.85388508e-02f, -1.08660040e-02f, -1.35633275e-01f, -3.12664568e-01f, -4.64446634e-01f, -1.83535039e-01f, -1.38847917e-01f, -4.23848808e-01f, -6.20987475e-01f, -2.70696104e-01f,
  6.36502579e-02f, 6.23944886e-02f, 1.08645961e-03f, -1.07612059e-01f, 2.39324361e-01f, 1.12282142e-01f, 2.66045868e-01f, -2.42610686e-02f, -7.69268572e-02f, 1.23470023e-01f,
  -1.30343989e-01f, -2.26576515e-02f, -1.69443011e-01f, -1.15525983e-01f, -6.03685677e-02f, -1.34969965e-01f, -2.09207058e-01f, -2.46537149e-01f, -9.86747965e-02f, -1.86585009e-01f,
  1.40324635e-02f, -1.36598304e-01f, -1.07125066e-01f, -1.62909497e-02f, -8.00890550e-02f, -1.41146541e-01f, 1.62781537e-01f, -2.46665612e-01f, -1.81827635e-01f, -1.46953404e-01f,
  2.22263653e-02f, -1.78466961e-01f, -8.84859785e-02f, -1.77394729e-02f, -1.75473258e-01f, -3.67435552e-02f, -2.01882888e-02f, -1.51741236e-01f, -1.12073757e-01f, 2.35892311e-01f,
  4.09367168e-03f, -3.50093655e-02f, 4.48517222e-03f, 5.38629889e-02f, 1.13850363e-01f, 9.25271437e-02f, -1.24838859e-01f, -1.66035369e-02f, -1.09651081e-01f, 3.26154344e-02f,
  6.52597994e-02f, 9.42829177e-02f, -5.98196499e-02f, 3.08384150e-02f, 9.29144248e-02f, -3.02157290e-02f, -9.50666517e-02f, 5.60466237e-02f, -1.60413906e-02f, -3.23805027e-02f,
  -4.51033115e-02f, 2.82421578e-02f, 2.65301354e-02f, -6.33497611e-02f, -6.61262497e-02f, 3.46204862e-02f, -9.69420522e-02f, -2.06136167e-01f, -7.44712874e-02f, -5.37309162e-02f,
  2.20473275e-01f, -1.29859075e-01f, 1.44795731e-01f, -1.07658684e-01f, -1.40306130e-01f, 5.78303821e-02f, 5.33336028e-02f, -7.28672594e-02f, -7.17266575e-02f, -8.13798979e-02f,
  -1.80140927e-01f, 1.49047272e-02f, -2.59644035e-02f, -9.58166830e-03f, -5.13267070e-02f, 5.24133630e-02f, 1.93090275e-01f, 1.25395292e-02f, 5.84758772e-03f, -4.91836555e-02f,
  8.83355588e-02f, -5.59850968e-02f, 1.26800969e-01f, 1.01646885e-01f, 6.85845315e-02f, -6.63354471e-02f, -1.53561896e-02f, -2.80741025e-02f, -2.23131999e-01f, 2.70563543e-01f,
  2.64432609e-01f, -2.86193222e-01f, -1.25163108e-01f, -7.51072681e-03f, -1.95583299e-01f, -1.41888022e-01f, -4.09515440e-01f, -1.52973086e-01f, 7.49728829e-02f, -2.17903823e-01f,
  -1.50875235e-02f, 1.73574790e-01f, 9.63444486e-02f, 1.02062076e-01f, 1.81305692e-01f, -1.99301869e-01f, -9.53049362e-02f, 2.01057270e-01f, 4.40704077e-01f, 4.54651900e-02f,
  1.00349570e-02f, 9.78527889e-02f, 2.81690836e-01f, 2.34089062e-01f, -2.35228524e-01f, 5.47171012e-02f, -1.08984269e-01f, 8.52293968e-02f, -6.44338429e-02f, -3.00018728e-01f,
  -1.66982681e-01f, -3.09915747e-02f, 1.86670423e-02f, 8.40369314e-02f, -7.09518641e-02f, 4.87976335e-02f, -4.37315032e-02f, -1.24870323e-01f, -2.42340025e-02f, 3.83683927e-02f,
  -2.65579410e-02f, -8.40538517e-02f, 4.87378761e-02f, 1.89889297e-02f, 8.55490565e-02f, 3.66125889e-02f, -2.31561214e-02f, 5.89148998e-02f, 9.36098546e-02f, -2.17880011e-01f,
  -7.97506794e-03f, -5.14536425e-02f, 4.81807925e-02f, -1.06557176e-01f, -5.37886173e-02f, 3.23166437e-02f, -2.25986362e-01f, -5.47879152e-02f, 6.78264424e-02f, -1.69109121e-01f,
  1.35455411e-02f, 1.23363420e-01f, -1.19235169e-03f, -7.55799338e-02f, -7.19878823e-02f, -2.74636205e-02f, 4.52516712e-02f, 3.59258987e-02f, -2.75190431e-03f, -1.18422486e-01f,
  9.77835879e-02f, 7.59375095e-02f, 1.84863117e-02f, 3.25205214e-02f, 6.47418201e-02f, 1.16688581e-02f, -1.84119295e-03f, -1.54462028e-02f, -1.42813018e-02f, -9.00831223e-02f,
  -1.16215684e-02f, 1.82663631e-02f, 2.98483875e-02f, 1.39680952e-02f, 3.85954790e-02f, 1.46007031e-01f, -3.70608382e-02f, -4.19385877e-04f, 1.40562234e-02f, -4.13837237e-03f,
  1.45124465e-01f, 1.52786806e-01f, -1.14894800e-01f, 9.42081213e-02f, 4.26236875e-02f, 2.50409227e-02f, -1.54934913e-01f, -1.21884486e-02f, -9.61722881e-02f, -8.61170813e-02f,
  -3.65810096e-02f, 5.57085406e-03f, 1.01422511e-01f, 2.03998312e-02f, -8.63564163e-02f, -4.07257862e-02f, -1.07413843e-01f, 4.76391949e-02f, -3.24518047e-02f, -1.68212593e-01f,
  -6.85157701e-02f, -4.94159795e-02f, 1.05456943e-02f, -6.19006809e-03f, 2.87607818e-05f, 6.02765307e-02f, 2.23032627e-02f, 4.28866632e-02f, 1.19981878e-01f, -6.05446752e-03f,
  -7.52433836e-02f, 6.85617328e-02f, 5.18377945e-02f, -3.19869481e-02f, -7.73821399e-02f, 1.49105802e-01f, 2.09910214e-01f, 9.26772952e-02f, -4.92781634e-03f, 1.13679737e-01f,
  1.34465769e-01f, -2.96245376e-03f, -2.22114362e-02f, 6.37814626e-02f, 1.32096726e-02f, 9.05054957e-02f, -6.67218911e-03f, -7.60852024e-02f, 3.54567394e-02f, 5.66149168e-02f,
  1.38513660e-02f, 6.63292781e-03f, 2.84137391e-02f, -9.86387879e-02f, -1.47006541e-01f, -7.98991695e-02f, 4.04726081e-02f, 6.17011413e-02f, 3.28691006e-02f, -2.42389455e-01f,
  -3.03735062e-02f, -1.24895513e-01f, -1.93218708e-01f, -2.40071580e-01f, 1.31550189e-02f, -8.82347077e-02f, 2.44304594e-02f, 7.37598985e-02f, 3.64540815e-02f, -9.64206532e-02f,
  9.21992492e-03f, 2.07412578e-02f, 8.60654637e-02f, 1.10782631e-01f, -5.89439422e-02f, 2.08509248e-02f, -1.12378653e-02f, 3.23222764e-02f, -8.79292861e-02f, -1.71839278e-02f,
  -6.97562918e-02f, -1.04992520e-02f, -5.33363856e-02f, -6.45263866e-02f, -8.58502463e-02f, -1.58769861e-01f, -2.11474430e-02f, -1.20074525e-01f, -1.17453691e-02f, -1.32716736e-02f,
  -8.78575742e-02f, -1.16426639e-01f, -9.72545445e-02f, -1.56807348e-01f, 8.80040508e-03f, -2.16042008e-02f, 2.20340714e-02f, 9.32709351e-02f, -1.10736899e-01f, -2.51881517e-02f,
  9.35271010e-02f, 3.12156864e-02f, 1.57873988e-01f, 5.41918501e-02f, 8.73876810e-02f, -2.96730292e-03f, 1.29284346e-02f, 6.44974336e-02f, 1.42798200e-01f, 8.74146447e-02f,
  9.93070193e-03f, 1.16010673e-01f, 3.87744084e-02f, 1.65196285e-01f, -3.54089253e-02f, 6.56609796e-03f, 9.43342522e-02f, 7.79502839e-02f, 6.57145865e-03f, 1.03299893e-01f,
  2.84608960e-01f, -7.56712025e-03f, -2.43291020e-01f, -1.38009220e-01f, 5.95326051e-02f, -1.09294476e-02f, -2.24272143e-02f, 1.01885773e-01f, 1.12557663e-02f, 1.02477640e-01f,
  1.09082013e-01f, 4.93109003e-02f, 1.49775907e-01f, 1.14981130e-01f, 8.15056637e-02f, 7.52243772e-02f, 1.59417856e-02f, -5.40973879e-02f, -3.90321165e-02f, -1.37067899e-01f,
  -4.45320830e-02f, -3.12902741e-02f, 1.09172553e-01f, 5.81942685e-02f, -2.70447191e-02f, -1.45585343e-01f, 7.91981071e-02f, -3.28494757e-02f, 1.06210336e-01f, 1.53767616e-01f,
  -1.55326068e-01f, 8.49348679e-02f, 3.35809924e-02f, 1.76546887e-01f, 1.47125110e-01f, 1.06245749e-01f, 1.77850068e-01f, 1.25731602e-01f, 1.39802158e-01f, 8.49804357e-02f,
  1.37775943e-01f, 1.12826303e-01f, 8.35978389e-02f, 1.92610607e-01f, 1.23434298e-01f, 2.39509925e-01f, 2.67057091e-01f, 5.60837090e-02f, 4.27795872e-02f, 1.76949613e-02f,
  7.34489411e-02f, 7.67677650e-03f, 2.10776720e-02f, 6.07660115e-02f, 1.33300573e-01f, 5.48059121e-02f, 1.05809852e-01f, 1.07279569e-01f, 7.48602077e-02f, 2.96525240e-01f,
  1.67050630e-01f, 3.12534310e-02f, -5.35782017e-02f, -1.41747102e-01f, -1.54520676e-01f, -8.04330409e-02f, -9.62293819e-02f, -1.64932877e-01f, -7.31970072e-02f, -1.23295769e-01f,
  -3.25870700e-02f, -3.32827494e-02f, 1.81700122e-02f, -1.11053605e-03f, -1.64900079e-01f, -1.93410173e-01f, -9.37078148e-02f, 1.24711789e-01f, 5.58938757e-02f, 1.71529558e-02f,
  1.37377441e-01f, -2.78130118e-02f, 7.07193241e-02f, 1.18814120e-02f, 5.53535111e-02f, 7.39984289e-02f, -1.06074112e-02f, 9.32996497e-02f, -7.10859336e-03f, 8.64876658e-02f,
  3.19051415e-01f, 2.06961066e-01f, 1.37061700e-01f, 1.39461994e-01f, 3.34048234e-02f, -6.09824024e-02f, 5.00109792e-02f, -3.58718410e-02f, 1.45509660e-01f, 1.08152358e-02f,
  6.38607964e-02f, 1.17625199e-01f, 1.06423080e-01f, 5.48838861e-02f, 1.54278036e-02f, 1.67559698e-01f, -5.19505516e-02f, 2.79102009e-02f, -1.12413220e-01f, 5.68551645e-02f,
  4.19181921e-02f, -7.54829422e-02f, -6.87828809e-02f, 8.98950547e-02f, -8.53775218e-02f, 7.11543560e-02f, -4.51711901e-02f, -1.78665612e-02f, -4.61704768e-02f, -4.92447242e-02f,
  2.24051118e-01f, 4.56804410e-02f, 9.97002572e-02f, 1.66590586e-01f, -1.16916247e-01f, -1.53869152e-01f, 1.10317525e-02f, -1.63781047e-01f, -2.16059595e-01f, -8.09364915e-02f,
  -1.19729787e-01f, -6.32053912e-02f, 7.94953480e-02f, -1.70619171e-02f, -9.15995799e-03f, -1.27442271e-01f, 4.36752066e-02f, 1.62921548e-01f, 1.33361265e-01f, 1.99226458e-02f,
  1.88928153e-02f, 6.16426095e-02f, 1.06033236e-01f, 5.96598946e-02f, 1.41867444e-01f, 8.11553001e-02f, 1.11967828e-02f, 5.50879911e-03f, -4.38328646e-02f, -1.69254720e-01f,
  -3.65051389e-01f, 6.77485913e-02f, 7.66375884e-02f, 1.20645806e-01f, 4.72384766e-02f, -1.02422215e-01f, -3.07742149e-01f, -1.55279383e-01f, 9.69968811e-02f, -1.12883717e-01f,
  3.14389877e-02f, 3.45739946e-02f, 3.46257389e-02f, 2.83468310e-02f, -2.57362992e-01f, -3.89176518e-01f, -2.85262614e-01f, -3.08984280e-01f, -2.54171491e-01f, -3.07231426e-01f,
  -3.65757290e-03f, 4.42336081e-03f, -7.94333667e-02f, 3.26202363e-02f, 2.20248967e-01f, 1.86141208e-01f, 2.23425031e-01f, 1.01815268e-01f, 2.30340585e-02f, 9.78112370e-02f,
  6.28978610e-02f, 8.20387751e-02f, -1.30311072e-01f, -1.31034628e-01f, 1.72597706e-01f, -1.65705681e-02f, -8.29330236e-02f, 3.97131108e-02f, -6.05692007e-02f, -2.25888193e-02f,
  9.66205597e-02f, -2.29620971e-02f, -1.30354851e-01f, 1.36692241e-01f, -1.86902329e-01f, -2.13253081e-01f, -1.73209295e-01f, -7.82806724e-02f, -5.81596941e-02f, -2.37238467e-01f,
  -1.77095950e-01f, -7.97817782e-02f, -8.05894509e-02f, 8.85028467e-02f, -8.72942060e-02f, -4.75226566e-02f, 1.48096234e-01f, -5.36775105e-02f, 7.59995431e-02f, 1.33064240e-01f,
  1.26025137e-02f, 1.11580558e-01f, -2.33302228e-02f, -3.71574983e-02f, -2.90376823e-02f, 8.96732602e-03f, -4.62363213e-02f, 1.20861139e-02f, 6.81008920e-02f, 1.11743258e-02f,
  7.89377689e-02f, 6.35508224e-02f, 7.55223259e-02f, -2.80784611e-02f, 1.20392896e-01f, -2.53991112e-02f, -3.40904035e-02f, -1.42925149e-02f, -4.98979688e-02f, 4.54259664e-02f,
  -1.86965354e-02f, 1.48675172e-02f, -4.67005223e-02f, 3.99463251e-02f, 1.66863892e-02f, -6.64986745e-02f, -1.54496625e-01f, -1.35577381e-01f, -4.37151901e-02f, -1.08123712e-01f,
  5.78664280e-02f, -1.57514200e-01f, 2.19068341e-02f, -1.14083745e-01f, -4.05465737e-02f, 1.84253931e-01f, 9.78588238e-02f, 4.97004502e-02f, 1.23264745e-01f, 5.15903607e-02f,
  -6.24818634e-03f, 9.34337378e-02f, -2.11246889e-02f, 5.59750423e-02f, -9.96046118e-04f, -4.31450792e-02f, -2.11222202e-01f, 8.54802430e-02f, -4.29151244e-02f, -2.34200224e-01f,
  -1.92941800e-01f, -1.46915123e-01f, 1.02004685e-01f, 1.58401325e-01f, 6.09741509e-02f, -3.29110995e-02f, 2.40596216e-02f, 1.77805498e-01f, -9.01163071e-02f, 2.10048053e-02f,
  1.16947792e-01f, -1.58667602e-02f, 3.38187963e-02f, 1.06137604e-01f, -1.03701763e-01f, -4.13020909e-01f, -2.65611082e-01f, -2.52845228e-01f, 2.07508001e-02f, 6.03303462e-02f,
  -3.39882933e-02f, 1.25021920e-01f, 1.31635159e-01f, -1.47208393e-01f, -1.61549479e-01f, -9.33885400e-04f, -2.45394409e-02f, -1.00185408e-03f, -2.45701611e-01f, -2.49072641e-01f,
  8.09600055e-02f, 2.72869647e-01f, 1.23831682e-01f, -7.59275705e-02f, 1.65185183e-01f, 1.04754254e-01f, 1.86707467e-01f, 4.29590866e-02f, -1.30447194e-01f, 3.04017544e-01f,
  2.77208835e-01f, -1.13679633e-01f, -9.62383822e-02f, -1.54477537e-01f, 1.00795245e-02f, -5.64403310e-02f, -1.24141462e-01f, -7.57301748e-02f, -2.27965504e-01f, -8.64302367e-02f,
  -1.11142881e-01f, -1.84442043e-01f, -1.76116571e-01f, -5.35063259e-03f, -9.87317115e-02f, -3.77124958e-02f, -7.90731087e-02f, 3.64668518e-02f, -4.34608907e-02f, 7.02884719e-02f,
  -1.09181412e-01f, -1.22849336e-02f, -1.52795419e-01f, -2.12137237e-01f, -1.63901180e-01f, 8.72260779e-02f, -6.58335611e-02f, -1.58393592e-01f, -1.42583892e-01f, 1.85666636e-01f,
  -3.04848719e-02f, -4.15680036e-02f, -6.55295476e-02f, 1.43970743e-01f, -3.48339528e-02f, -3.14850174e-02f, -5.15096709e-02f, 7.18972757e-02f, -1.21004030e-01f, -1.68217905e-02f,
  -1.33027643e-01f, -5.60801551e-02f, 6.62568882e-02f, -2.44452115e-02f, -1.31056402e-02f, 1.24728642e-02f, -6.93803877e-02f, 5.67838848e-02f, -2.22014375e-02f, 1.61508061e-02f,
  -2.64485069e-02f, -7.05226213e-02f, 4.69614528e-02f, -5.70625253e-02f, 5.15130488e-03f, -5.09104729e-02f, 9.79681313e-02f, 2.73647276e-03f, 8.29703659e-02f, 6.40170351e-02f,
  2.53926754e-01f, -2.44158253e-01f, 2.08127096e-01f, -4.64631096e-02f, -3.82435471e-02f, -1.38315931e-01f, 7.98363686e-02f, -1.40941992e-01f, -7.64723793e-02f, -1.23839602e-01f,
  -2.08942756e-01f, -1.10706843e-01f, 1.91989899e-01f, -9.28724632e-02f, -4.86235879e-02f, 1.26601100e-01f, -1.08641088e-01f, -6.95999758e-03f, -2.19942397e-03f, 2.09060367e-02f,
  3.53883579e-02f, 6.20333701e-02f, 3.48071009e-02f, 6.02255724e-02f, 5.66086471e-02f, -5.09795658e-02f, 1.33807570e-01f, -2.49908660e-02f, -1.83793724e-01f, 1.90349579e-01f,
  -4.97796476e-01f, 2.84498960e-01f, 7.49117211e-02f, -1.88372418e-01f, 2.81224340e-01f, 1.53064817e-01f, 3.03990543e-01f, 1.59415349e-01f, -2.56377412e-03f, 2.39319935e-01f,
  1.59373179e-01f, -1.61938090e-02f, -4.47303504e-02f, 2.03697812e-02f, -8.19837525e-02f, 1.79170042e-01f, 1.48805574e-01f, -6.35435060e-02f, -3.05258483e-01f, -9.32659358e-02f,
  1.64625533e-02f, -9.42296982e-02f, -3.10190797e-01f, -2.05453500e-01f, -5.37305325e-02f, -6.69524893e-02f, 1.91370938e-02f, 4.44652105e-04f, 8.69008303e-02f, 2.94142179e-02f,
  -8.91665518e-02f, 1.05874740e-01f, -1.05853461e-01f, -1.82364985e-01f, -6.66394755e-02f, -1.38121486e-01f, 6.44189790e-02f, -1.42706499e-01f, 3.98621224e-02f, -9.49720070e-02f,
  -8.49766061e-02f, 2.16460433e-02f, 1.50277078e-01f, -1.28946424e-01f, -4.20318656e-02f, -4.32427563e-02f, -7.89930522e-02f, -1.90979138e-01f, -6.84770495e-02f, -1.42890736e-01f,
  9.99426395e-02f, 1.32014245e-01f, -2.64056735e-02f, -3.39452624e-02f, 7.55424351e-02f, -1.33007646e-01f, 7.96658162e-04f, -1.10333689e-01f, -3.39699686e-02f, -2.30890453e-01f,
  -6.36047423e-02f, -2.02000551e-02f, 9.30347741e-02f, -8.16182643e-02f, -4.90206853e-02f, 1.08978490e-03f, -3.32704745e-02f, 2.88691018e-02f, -1.67935938e-02f, -3.39033790e-02f,
  -2.43805517e-02f, -1.15424007e-01f, 4.97420924e-03f, 1.00909360e-01f, -8.77435952e-02f, -7.69138755e-03f, 9.14918706e-02f, -1.10922746e-01f, 5.35940900e-02f, -2.94568725e-02f,
  3.78292352e-02f, 1.52598456e-01f, 5.75107187e-02f, -1.80003960e-02f, 6.54380471e-02f, 1.97232366e-02f, -2.01102979e-02f, -1.35460705e-03f, -2.12067403e-02f, -1.52068004e-01f,
  -4.01174314e-02f, 1.07563116e-01f, -1.56953856e-01f, -8.04127753e-02f, -6.65749470e-03f, -4.38993871e-02f, -5.04773203e-03f, -2.74455659e-02f, 1.25776947e-04f, -6.78318292e-02f,
  -1.30270988e-01f, -1.85381487e-01f, 3.49616632e-02f, -8.42815489e-02f, -4.07563597e-02f, 4.01065014e-02f, -6.27066940e-02f, -1.55866565e-02f, 5.22617474e-02f, -8.41410607e-02f,
  -2.41544209e-02f, 6.90815896e-02f, -9.25854594e-02f, -5.70543706e-02f, -1.01119149e-02f, -4.26737359e-03f, -6.62933737e-02f, -2.68194914e-01f, -5.33347018e-02f, -2.20659509e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  7.41144121e-02f, 2.02991709e-01f, 3.38931590e-01f, 8.63699019e-02f, 1.79825246e-01f, 1.11908674e-01f, 3.99414688e-01f, 7.72493556e-02f, 1.96531728e-01f, -8.78659785e-02f,
  7.69749731e-02f, 7.20003694e-02f, 6.60237446e-02f, 1.49595276e-01f, 2.25260183e-01f, 1.21847808e-01f, 1.88575387e-01f, -1.70918196e-01f, 1.23996474e-02f, -7.38970563e-02f,
  6.74443990e-02f, -3.45064439e-02f, -1.97835267e-02f, 1.99163649e-02f, 2.67102391e-01f, 1.36894241e-01f, 2.50404358e-01f, 7.93455392e-02f, 2.09046736e-01f, -1.66131899e-01f,
  -5.43601438e-02f, 9.80547220e-02f, 5.43133467e-02f, 1.84972566e-02f, -5.35511412e-03f, 3.29946578e-02f, -1.87430635e-01f, 1.15300655e-01f, -1.31274506e-01f, 1.53638572e-01f,
  9.88627821e-02f, -1.18428757e-02f, 2.38114670e-01f, 1.20387688e-01f, 1.13425441e-01f, 4.12751772e-02f, 1.96576342e-01f, -2.20238455e-02f, 1.50669664e-01f, 2.74513732e-03f,
  1.28148884e-01f, -5.53051056e-03f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  4.99148555e-02f, -4.53929566e-02f, -7.84754902e-02f, -9.64945555e-02f, -9.78069678e-02f, -6.54405579e-02f, -3.05106174e-02f, 7.38815963e-02f, -5.63361868e-02f, 1.23320371e-01f,
  -2.21014638e-02f, -8.28722641e-02f, 7.77518302e-02f, -1.80715267e-02f, -3.08894843e-01f, 7.04118982e-03f, -2.57528245e-01f, 1.07012972e-01f, 7.18048513e-02f, -9.72118825e-02f,
  1.03941657e-01f, -7.90928751e-02f, 6.95378035e-02f, -4.08726111e-02f, 9.73730609e-02f, -5.05761094e-02f, -8.12145993e-02f, -1.68208897e-01f, 8.10980331e-04f, -9.23322961e-02f,
  -9.93139222e-02f, 1.35986716e-01f, 1.32624909e-01f, 1.48036510e-01f, 5.91546595e-02f, -1.03101611e-01f, 1.22020476e-01f, 5.65124154e-02f, 4.96298596e-02f, 1.54404834e-01f,
  -2.03865737e-01f, 5.45922332e-02f, -1.22683212e-01f, -8.81602466e-02f, -1.67184100e-01f, -1.38824388e-01f, -1.32643282e-01f, 9.45555717e-02f, -1.55293360e-01f, 1.63859472e-01f,
  -1.24527380e-01f, -3.57367247e-02f, 1.18353233e-01f, -1.51503971e-02f, -2.74124771e-01f, -1.54157379e-03f, -2.91355867e-02f, -6.95659518e-02f, -1.29118443e-01f, 5.89843243e-02f,
  1.73631743e-01f, -1.17471881e-01f, 8.04144815e-02f, 2.08173037e-01f, -8.80364254e-02f, -1.02462396e-01f, -4.90335971e-02f, -3.10199499e-01f, -8.34066272e-02f, -1.35406122e-01f,
  -1.66762814e-01f, 9.89318937e-02f, -4.47591059e-02f, -2.05167588e-02f, -1.92524001e-01f, 5.21600880e-02f, -5.78403771e-02f, -2.36905724e-01f, -3.43377329e-02f, -1.41816229e-01f,
  1.85571704e-02f, 5.95731437e-02f, -1.00225605e-01f, 1.00813806e-02f, -1.35717914e-01f, -2.45790839e-01f, -1.08837076e-01f, -2.22787917e-01f, 9.87042114e-02f, 2.95387566e-01f,
  7.26122335e-02f, 1.07719582e-02f, 1.03526466e-01f, 8.59294534e-02f, 2.43374761e-02f, 1.99543521e-01f, 1.14093296e-01f, 2.75946528e-01f, -2.40345463e-01f, 1.78627625e-01f,
  -2.27707267e-01f, 1.40650198e-01f, -1.66371733e-01f, -1.17686410e-02f, 2.32955068e-01f, 1.05439842e-01f, -2.07319371e-02f, 7.09907785e-02f, 5.29168583e-02f, 2.10412368e-01f,
  1.28457084e-01f, -1.26925662e-01f, 2.02594995e-01f, -4.77392748e-02f, 2.85245836e-01f, -3.04504067e-01f, -2.60503620e-01f, -1.68426678e-01f, 2.60747612e-01f, 1.87647909e-01f,
  -3.25976238e-02f, -2.28604153e-02f, -5.24519826e-04f, -1.64806396e-01f, 1.33349478e-01f, 9.59553048e-02f, 3.41976285e-02f, 4.28420343e-02f, 5.93017600e-02f, 1.03158899e-01f,
  7.99290463e-02f, 8.72285143e-02f, 1.09590866e-01f, 8.62784591e-03f, 1.77801400e-01f, -2.11716652e-01f, 1.72735408e-01f, -2.17458922e-02f, -1.16173089e-01f, 4.48984578e-02f,
  -3.73736098e-02f, 2.51253545e-01f, -1.71947047e-01f, 2.31716216e-01f, 1.69395491e-01f, 1.70660123e-01f, 2.90706381e-02f, 1.89423874e-01f, -1.59616858e-01f, -9.73430276e-02f,
  1.15271464e-01f, 1.77069440e-01f, -4.10646461e-02f, -9.67431292e-02f, 3.11660558e-01f, 5.63001931e-02f, 2.14598119e-01f, 2.67295749e-03f, 1.56072736e-01f, -3.45313251e-02f,
  -1.04290888e-01f, -2.85880059e-01f, -1.12150908e-01f, -7.83034489e-02f, -1.13621518e-01f, 1.18577965e-01f, 2.23713785e-01f, 9.05241445e-02f, -1.53176948e-01f, 1.18749678e-01f,
  -3.85968164e-02f, -3.55389938e-02f, -1.66058719e-01f, 9.16272774e-02f, 3.35236713e-02f, -1.60321057e-01f, 6.49018884e-02f, 1.05568901e-01f, 1.73819065e-01f, 3.06708485e-01f,
  1.26223117e-01f, -1.81403477e-02f, -2.24934742e-01f, -1.70814678e-01f, 2.64086246e-01f, 4.03367430e-02f, 1.61770463e-01f, -1.25944704e-01f, -9.32868868e-02f, 8.21457356e-02f,
  -9.10579786e-02f, -2.04319134e-01f, 8.83454829e-02f, -5.00330376e-03f, 1.73214674e-01f, 4.17863727e-02f, 2.31670216e-02f, 1.53708190e-01f, 1.47008300e-01f, -1.44974157e-01f,
  9.52845365e-02f, -5.90426102e-03f, 1.22041173e-01f, -6.05605915e-03f, 1.37031913e-01f, 1.35395736e-01f, 1.96760416e-01f, 2.81714618e-01f, 7.64526799e-02f, 5.97001053e-02f,
  6.18689694e-02f, 2.08579719e-01f, -1.01802304e-01f, -6.47723302e-02f, -2.38708872e-02f, 7.24641755e-02f, 9.68119577e-02f, -1.23690993e-01f, -2.12678369e-02f, -1.26179054e-01f,
  -1.01010047e-01f, 6.06617555e-02f, -1.63619936e-01f, -1.80481344e-01f, -7.05222711e-02f, -9.49735120e-02f, 2.31653139e-01f, -1.23457931e-01f, 3.37965190e-02f, -6.61072657e-02f,
  1.72638059e-01f, -1.07698530e-01f, 1.30472541e-01f, -9.11618490e-03f, 4.41829264e-02f, -2.16060951e-02f, -1.04952388e-01f, 1.09314896e-01f, 2.15631686e-02f, 8.97760540e-02f,
  1.80100337e-01f, 2.31638849e-02f, 2.31667057e-01f, 1.61921561e-01f, -3.56603712e-02f, 1.24346979e-01f, 1.74899444e-01f, 3.68924104e-02f, 1.59655839e-01f, -7.49356672e-02f,
  7.61115700e-02f, 1.55697996e-03f, -2.19996631e-01f, 6.41444176e-02f, 7.62248039e-03f, 6.13148212e-02f, 4.71069887e-02f, -2.86151860e-02f, -1.98388007e-02f, -6.24812879e-02f,
  -5.41545488e-02f, -5.96216470e-02f, 7.09384680e-02f, -1.05502278e-01f, 6.97155157e-03f, 9.58349109e-02f, -4.07570712e-02f, -7.13222399e-02f, 6.54491968e-03f, 1.90255508e-01f,
  -5.58523973e-03f, 4.91245426e-02f, 1.36443749e-01f, -1.47926807e-01f, -1.06924981e-01f, -1.22434221e-01f, 2.64923051e-02f, 1.42761603e-01f, -2.87799519e-02f, -3.57714035e-02f,
  -1.05988592e-01f, -1.02334104e-01f, 3.25287998e-01f, 1.77735552e-01f, 1.43392518e-01f, 1.88341975e-01f, 1.24398604e-01f, -3.69329341e-02f, -1.89131677e-01f, -1.28692970e-01f,
  -3.22938040e-02f, -1.71407163e-01f, -2.97002465e-01f, 1.49192968e-02f, -7.36535415e-02f, -1.12824388e-01f, 2.41502356e-02f, 1.87216029e-01f, 6.76255971e-02f, 1.20366752e-01f,
  1.40617147e-01f, 9.33425799e-02f, -2.38072034e-02f, -9.81988460e-02f, -4.49433438e-02f, -1.22538015e-01f, 1.43471584e-01f, 2.59969682e-01f, 1.19784631e-01f, 7.42535759e-03f,
  -1.82444036e-01f, 4.54250239e-02f, 2.70406902e-01f, -2.65736759e-01f, 2.17556134e-01f, -1.32755622e-01f, 1.50026251e-02f, -1.32927671e-01f, -4.43542749e-02f, -1.53452352e-01f,
  -1.10968679e-01f, -2.49555875e-02f, -3.60258333e-02f, -1.30161598e-01f, -3.09671257e-02f, 1.40173864e-02f, 9.06256512e-02f, -1.31544113e-01f, 2.17329502e-01f, 8.13085437e-02f,
  2.04265453e-02f, -5.57804182e-02f, -3.37548107e-02f, 2.46017009e-01f, -6.26168177e-02f, 2.29580298e-01f, -9.94210541e-02f, 9.25557241e-02f, 4.65764627e-02f, -1.58383071e-01f,
  7.86197931e-02f, -2.87819561e-02f, -7.77938515e-02f, 2.11443916e-01f, 7.87474290e-02f, -2.46798471e-01f, 3.36644769e-01f, 5.29699661e-02f, -5.81361703e-04f, -1.30916893e-01f,
  1.30048394e-01f, 2.17179265e-02f, -1.09797224e-01f, -2.23311812e-01f, 1.75087795e-01f, -2.69875884e-01f, 2.73479447e-02f, 1.88910037e-01f, -3.47681828e-02f, -2.02334598e-02f,
  -4.80804214e-04f, -1.20324410e-01f, -4.87646423e-02f, 2.49887742e-02f, -6.61913976e-02f, -2.56182887e-02f, 2.34108735e-02f, 1.08129725e-01f, -2.80933212e-02f, -5.67779653e-02f,
  1.38077036e-01f, 3.37452650e-01f, 1.98604658e-01f, 7.03621795e-03f, -2.10174248e-01f, 3.90333519e-03f, 2.45407701e-01f, 2.49767583e-02f, 1.04878940e-01f, 6.27843291e-02f,
  -1.82288170e-01f, -7.86038935e-02f, -1.78120345e-01f, -4.62225042e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -2.82594990e-02f, -1.00163326e-01f, -1.59681588e-02f, -4.48396616e-03f, -6.54578733e-04f, 2.27316558e-01f, -6.33837357e-02f, 1.69137359e-01f, -1.06614448e-01f, -7.37490654e-02f,
  -1.89223841e-01f, 1.77989066e-01f, -7.60255828e-02f, -8.59701410e-02f, -4.28488441e-02f, -8.70946646e-02f, -1.89730469e-02f, 1.95692122e-01f, -7.62659684e-02f, -1.51368693e-01f,
  5.00871725e-02f, 3.66939306e-02f, 1.43526969e-02f, 9.19516906e-02f, -8.99063125e-02f, 7.48397410e-02f, 1.21832956e-02f, -1.87004626e-01f, 5.44292592e-02f, -7.00703189e-02f,
  4.52449843e-02f, 7.90675655e-02f, 2.91518886e-02f, 9.74852294e-02f, 1.31302193e-01f, 5.30723296e-02f, -7.29027763e-02f, -1.76790163e-01f, -1.29255608e-01f, 1.13967910e-01f,
  3.78126763e-02f, 1.30047221e-02f, -2.36561969e-02f, -2.86757916e-01f, 2.29378611e-01f, -1.04125410e-01f, -2.02623039e-01f, 4.58682664e-02f, -1.27585074e-02f, 1.56780317e-01f,
  -1.08664639e-01f, -1.35920957e-01f, 1.36192039e-01f, -3.00960422e-01f, 1.50228897e-03f, -2.21584104e-02f, -1.86098352e-01f, -9.79088470e-02f, -1.78188220e-01f, -2.55754013e-02f,
  1.96302176e-01f, -1.86233342e-01f, -9.68036652e-02f, 1.29530370e-01f, 9.82724130e-03f, 1.19259059e-01f, -3.27541819e-03f, 1.12137236e-01f, 7.13145733e-03f, 5.62130287e-02f,
  -5.11003658e-02f, -2.50358403e-01f, 2.10809991e-01f, 5.59292994e-02f, 7.59630650e-02f, -1.81490537e-02f, 1.86966732e-02f, 1.87029108e-01f, -7.52250701e-02f, 1.89248950e-03f,
  -1.53182670e-01f, 2.70492941e-01f, 1.31152931e-03f, 2.85395421e-04f, 1.46932691e-01f, -6.83964118e-02f, 7.61854500e-02f, 2.38142237e-01f, -1.84410866e-02f, -2.58624088e-03f,
  3.93228352e-01f, 2.43073776e-01f, -8.61779228e-03f, -1.36898890e-01f, -6.10105433e-02f, 5.51166609e-02f, -1.61962584e-03f, -1.27473041e-01f, 7.73808584e-02f, 4.13841382e-02f,
  2.11980581e-01f, 2.95444131e-01f, 1.95965275e-01f, 1.85225204e-01f, -1.47398591e-01f, 3.58209759e-02f, -5.88434860e-02f, 1.73952691e-02f, 9.67978388e-02f, -2.26061326e-02f,
  -4.80405614e-02f, 1.35486647e-01f, -1.64907783e-01f, 1.66345671e-01f, -6.24898076e-02f, 4.36591774e-01f, 1.01276301e-01f, -8.05176422e-02f, -1.40997376e-02f, -2.04018429e-01f,
  -2.79067773e-02f, 5.05888797e-02f, 1.81416094e-01f, 1.16875013e-02f, -8.42592642e-02f, -8.88697430e-02f, 1.69393495e-01f, -4.35625985e-02f, 3.57980803e-02f, 8.91145021e-02f,
  7.79799893e-02f, 1.45632640e-01f, 4.05212753e-02f, 8.36800709e-02f, 7.32688084e-02f, 1.91603124e-01f, -1.23012736e-01f, -6.44515175e-03f, -5.23404852e-02f, -9.22289565e-02f,
  -1.13359867e-02f, -1.99734494e-01f, -1.51712716e-01f, 1.31972015e-01f, 3.24688181e-02f, 2.62759835e-01f, 1.25224710e-01f, 3.48084778e-01f, 3.33207473e-03f, -2.03445718e-01f,
  1.21493399e-01f, 9.53440368e-02f, 2.94969022e-01f, 6.82711788e-03f, 5.19288443e-02f, -2.77974725e-01f, 2.33771369e-01f, 7.48154074e-02f, 5.56974560e-02f, 8.70624781e-02f,
  2.83336759e-01f, 4.24718075e-02f, 1.75167888e-01f, 8.01561475e-02f, 1.37020396e-02f, -4.92838323e-02f, -2.17302628e-02f, -3.42424512e-01f, 8.96269828e-03f, -7.59366602e-02f,
  -2.40367338e-01f, 1.90994456e-01f, -2.50731915e-01f, -6.54907152e-02f, -2.70830113e-02f, 1.25105232e-01f, -1.90030396e-01f, 4.48910147e-03f, 1.05058150e-02f, -1.98941514e-01f,
  3.58972177e-02f, 6.37131417e-03f, 1.25837415e-01f, 1.76663190e-01f, -8.52524489e-02f, 2.28371546e-01f, 9.93388221e-02f, -3.26011367e-02f, 7.44420364e-02f, 3.46960351e-02f,
  2.53276583e-02f, 1.24388851e-01f, -1.26336917e-01f, 7.36805424e-02f, 1.53173566e-01f, 2.01957654e-02f, 8.36593807e-02f, -7.55549446e-02f, 1.43860178e-02f, 9.70114097e-02f,
  1.21516950e-01f, 9.11588687e-03f, 2.21660323e-02f, -1.47009529e-02f, 5.51474765e-02f, -1.00322925e-01f, -5.96677102e-02f, 1.93344690e-02f, -2.65942328e-02f, -1.05909780e-01f,
  9.95162055e-02f, -9.88666415e-02f, -8.63618255e-02f, -1.00124605e-01f, -7.53476769e-02f, 5.03257923e-02f, 3.92221622e-02f, 8.15749019e-02f, 1.73493311e-01f, -1.46518275e-01f,
  -8.45800154e-03f, -8.81730393e-02f, 1.18811026e-01f, -3.93549427e-02f, -1.83160335e-01f, -7.83833414e-02f, 3.16128172e-02f, -8.94276947e-02f, 4.31706943e-03f, 1.67554408e-01f,
  -1.80926755e-01f, 1.09899893e-01f, 2.98243642e-01f, -6.51903227e-02f, -3.77435721e-02f, 1.24511279e-01f, -7.08309263e-02f, 1.07800782e-01f, 1.56044483e-01f, 1.17018439e-01f,
  1.76070422e-01f, 1.27524793e-01f, 1.33324876e-01f, 2.16936618e-02f, 2.23244336e-02f, 3.18598114e-02f, 6.34663329e-02f, 7.76464120e-02f, -7.07978532e-02f, 2.16721639e-01f,
  -5.11718765e-02f, -7.06318393e-02f, -5.13618588e-02f, -1.42233912e-02f, 1.07496239e-01f, -1.00023314e-01f, 1.57408491e-02f, 3.97612192e-02f, 6.74601877e-03f, -1.26656024e-02f,
  1.79231897e-01f, 2.41813570e-01f, 9.38480124e-02f, 5.73594170e-03f, -2.18508571e-01f, -6.48262426e-02f, 1.62315100e-01f, 1.04060747e-01f, 1.29217431e-01f, 2.23938283e-02f,
  3.36711079e-01f, 7.58615583e-02f, 3.55213247e-02f, 1.37788966e-01f, 2.38078490e-01f, 1.17112696e-01f, 1.12623863e-01f, 6.56357780e-02f, 2.76985019e-01f, 1.50432229e-01f,
  9.20535773e-02f, 1.70430347e-01f, -3.12299788e-01f, 3.13032776e-01f, 4.84389961e-02f, -4.74307239e-02f, -1.54658668e-02f, -3.08301777e-01f, -4.68199551e-02f, -1.83840003e-02f,
  2.43787542e-01f, -9.78807136e-02f, 6.21126175e-01f, -1.31000981e-01f, 3.17474335e-01f, 1.87336095e-02f, -1.70463383e-01f, -1.76545158e-01f, 4.27759141e-02f, -4.57346775e-02f,
  2.57870346e-01f, -5.79510443e-02f, -5.93784936e-02f, 3.84183340e-02f, 3.22191752e-02f, 3.69706638e-02f, -1.49035439e-01f, -2.70552546e-01f, 5.88270985e-02f, 7.52609596e-02f,
  2.23676234e-01f, 2.22067952e-01f, -2.73275644e-01f, -2.23786365e-02f, -2.80345142e-01f, 2.04874277e-01f, -1.11637048e-01f, 9.90950912e-02f, 1.24114625e-01f, 2.87845999e-01f,
  1.17981106e-01f, -5.66798896e-02f, 7.88981691e-02f, 1.58629924e-01f, 1.29273340e-01f, 1.00139491e-01f, 2.55232658e-02f, -3.30099344e-01f, 1.65085018e-01f, 5.41521870e-02f,
  1.05339587e-01f, -1.74010113e-01f, 4.61425446e-02f, 1.18192807e-01f, 6.05867021e-02f, 3.67244007e-04f, 3.37046050e-02f, 3.86295356e-02f, -5.14302924e-02f, -3.44009362e-02f,
  1.05142772e-01f, 1.65992361e-02f, 4.26316308e-03f, 4.98283692e-02f, -1.95308745e-01f, -1.55930698e-01f, 2.59374738e-01f, 2.26741880e-01f, -7.83926249e-02f, -1.29023688e-02f,
  5.95189966e-02f, -1.56803817e-01f, -1.63043499e-01f, -6.10661209e-02f, -2.53157206e-02f, 1.92799885e-02f, 1.35555446e-01f, 1.10885255e-01f, 2.78285772e-01f, 2.62865245e-01f,
  -2.44455218e-01f, -5.91910891e-02f, 1.57794759e-01f, -3.37263420e-02f, 3.24169993e-02f, -3.26425135e-02f, -6.98815137e-02f, 1.95263289e-02f, 2.38137126e-01f, 1.05902627e-01f,
  4.25012633e-02f, 4.08075154e-01f, 1.97042480e-01f, 1.14580795e-01f, 3.05927955e-02f, -1.88126639e-01f, 2.00664148e-01f, -3.35789882e-02f, 2.94919431e-01f, 9.51999277e-02f,
  1.29972801e-01f, -1.30262911e-01f, -4.77688238e-02f, -2.33646989e-01f, 1.65593554e-03f, -5.90159036e-02f, -5.26825301e-02f, 1.61468774e-01f, 8.08629170e-02f, 1.37186661e-01f,
  3.53069007e-02f, 1.57838404e-01f, -3.79428267e-02f, 3.56311351e-02f, -5.83725944e-02f, -1.56943038e-01f, -1.70801580e-02f, -6.14452325e-02f, -4.78531718e-02f, 1.35531083e-01f,
  2.05709636e-02f, -4.14750241e-02f, 1.49976775e-01f, -1.01785742e-01f, 9.80810747e-02f, -2.54295230e-01f, 3.36774513e-02f, -4.73568700e-02f, 8.71881843e-02f, 1.79383561e-01f,
  2.27875009e-01f, -9.14560780e-02f, -1.39273331e-01f, 1.10603832e-01f, 8.58673751e-02f, 1.07107339e-02f, -2.86017600e-02f, 1.27959743e-01f, 2.55872309e-03f, 1.68390782e-03f,
  1.64048016e-01f, 2.28165925e-01f, -3.05146486e-01f, -1.46554440e-01f, 1.52863503e-01f, -9.54596251e-02f, -2.02629894e-01f, 9.96598005e-02f, -6.92030564e-02f, 3.01849563e-02f,
  3.23692709e-02f, 3.25000398e-02f, -2.89908230e-01f, 5.49181662e-02f, 7.86779597e-02f, 1.47136897e-01f, -5.08289821e-02f, -1.15442127e-01f, -9.52456798e-03f, 3.14823061e-01f,
  1.59424677e-01f, -6.42634183e-02f, 1.13564786e-02f, -9.46863964e-02f, 7.36717582e-02f, -1.28762603e-01f, -1.97075292e-01f, 1.62587091e-01f, 3.11966203e-02f, -1.98197842e-01f,
  4.01736377e-03f, 4.29297462e-02f, 5.73708618e-04f, 1.96543634e-02f, 6.56852275e-02f, 2.24332996e-02f, -2.31950715e-01f, 3.34393159e-02f, -2.08456740e-01f, -6.65267408e-02f,
  -9.55146179e-02f, -2.83644468e-01f, 1.00680843e-01f, 1.36473060e-01f, -3.52175355e-01f, 1.57806903e-01f, 2.70071059e-01f, -8.90178010e-02f, 1.73461437e-01f, 2.06913739e-01f,
  2.54776418e-01f, 8.09748396e-02f, 2.16976590e-02f, 1.84924543e-01f, -5.02882779e-01f, 1.18736543e-01f, -2.79532641e-01f, 1.26331493e-01f, -1.52087212e-01f, -1.54243767e-01f,
  1.51241317e-01f, 1.95901189e-02f, 1.73740655e-01f, -1.03535287e-01f, 1.06515184e-01f, -2.02175453e-01f, -8.83613303e-02f, -1.91051036e-01f, 1.06906548e-01f, -1.36112031e-02f,
  -1.17771372e-01f, -9.16781723e-02f, -8.01956374e-03f, 8.95479247e-02f, -6.79484452e-04f, 1.23376064e-02f, -1.16114005e-01f, 1.02489829e-01f, 9.78332851e-03f, -3.32451880e-01f,
  -1.57637149e-01f, 1.42114460e-01f, 8.38925391e-02f, 3.54298085e-01f, -1.80633590e-01f, -6.14768416e-02f, -3.64183366e-01f, 1.64859504e-01f, -1.42614720e-02f, -1.95185944e-01f,
  -2.13991120e-01f, 2.72659004e-01f, 8.92025456e-02f, -3.47162709e-02f, 6.31751046e-02f, -5.55740632e-02f, 7.80192614e-02f, 1.26406446e-01f, 5.66628203e-02f, -9.48311910e-02f,
  1.28138557e-01f, 1.70224998e-02f, 6.25449941e-02f, -6.53489009e-02f, 1.09643713e-01f, 2.22495850e-02f, 1.77665278e-01f, 1.94439307e-01f, 1.77339911e-01f, -1.28774747e-01f,
  -2.92740688e-02f, -3.79105091e-01f, 1.44676164e-01f, 1.88871361e-02f, -1.36615440e-01f, 3.13540213e-02f, -1.29861370e-01f, -1.21252023e-01f, 3.35903525e-01f, 1.27702296e-01f,
  -9.60660949e-02f, -6.02259040e-02f, 3.08661314e-04f, 2.94756237e-02f, -1.39016941e-01f, -1.74333036e-01f, 9.80904475e-02f, -1.60835460e-01f, -1.04627706e-01f, 1.30183309e-01f,
  -1.98693536e-02f, 1.45871192e-01f, -1.24005694e-02f, 4.82991785e-02f, 9.39114764e-02f, 1.43443793e-01f, 2.80025192e-02f, 1.77208498e-01f, 9.86003280e-02f, 8.57016295e-02f,
  2.02928692e-01f, 7.58146197e-02f, 2.21614182e-01f, 3.24435055e-01f, 1.16526529e-01f, -3.57912481e-02f, -5.72439879e-02f, 4.46667373e-02f, 5.90396300e-02f, 7.55158346e-03f,
  1.59879893e-01f, 5.23040183e-02f, -3.24500278e-02f, -9.69024524e-02f, -9.15245563e-02f, -9.64758098e-02f, 8.45542625e-02f, 3.05880439e-02f, 1.01404503e-01f, -2.53553335e-02f,
  -1.25390980e-02f, 7.94731975e-02f, 7.57959262e-02f, 8.95849988e-02f, -3.93615365e-02f, 3.87450941e-02f, 7.50221312e-02f, -7.08094705e-03f, 1.16741426e-01f, 3.89641970e-02f,
  -3.08740050e-01f, -1.65072829e-02f, -6.94937930e-02f, 2.44885758e-02f, 2.76589692e-01f, -1.51254177e-01f, -1.43507570e-01f, -2.31235117e-01f, -1.98113382e-01f, 1.25013277e-01f,
  2.64604986e-01f, -2.46882681e-02f, 1.58921897e-01f, -4.87889200e-02f, -7.68596530e-02f, 1.23925142e-01f, -1.55641675e-01f, 2.65251063e-02f, 3.82030196e-02f, -1.49245143e-01f,
  9.25567523e-02f, -1.61625981e-01f, 1.22310765e-01f, 1.89971715e-01f, 5.67027144e-02f, -2.02332884e-01f, 3.39825034e-01f, -5.99918403e-02f, -1.70535445e-01f, 1.88097998e-01f,
  -1.20690927e-01f, 1.58237487e-01f, 2.47376844e-01f, 7.02001005e-02f, 2.36435458e-01f, -3.40422645e-04f, 9.01018605e-02f, 1.47503549e-02f, -7.19354674e-02f, 9.99075100e-02f,
  -1.05109110e-01f, 1.43557951e-01f, 7.27261882e-03f, 1.82240769e-01f, 1.00327313e-01f, 7.16113672e-02f, -1.24734655e-01f, 1.41199723e-01f, 1.55548394e-01f, 5.44489920e-02f,
  1.77865505e-01f, 1.40950531e-01f, -6.53625354e-02f, 3.18325579e-01f, 1.23468161e-01f, -1.17556648e-02f, -2.55881637e-01f, -1.24152578e-01f, 9.49700475e-02f, 6.83298334e-02f,
  2.18456853e-02f, 1.28602143e-02f, -2.28586718e-01f, -5.37538826e-02f, 1.64502561e-02f, -1.65016074e-02f, 3.78683209e-02f, -1.36245757e-01f, 2.01318637e-02f, -2.09850833e-01f,
  7.45523944e-02f, -3.36657874e-02f, 2.97084540e-01f, 8.36736262e-02f, -1.37523055e-01f, 1.06775396e-01f, 1.99529007e-01f, 1.16719469e-01f, 2.09947024e-02f, -1.39890924e-01f,
  -1.41266599e-01f, 6.90210536e-02f, 1.47976796e-03f, 1.67077765e-01f, 4.26279493e-02f, 5.62084094e-02f, 2.52176136e-01f, 1.60160825e-01f, 2.00225040e-01f, 1.83330160e-02f,
  -1.43240452e-01f, -1.62355870e-01f, -1.03261352e-01f, 1.49583137e-02f, 2.52196699e-01f, -2.36000009e-02f, -6.91357022e-03f, 2.24326015e-03f, -1.17462561e-01f, 5.98123297e-03f,
  -5.02580442e-02f, 2.77074218e-01f, 9.40331817e-02f, -2.03428164e-01f, 5.47757708e-02f, -1.38550356e-01f, 1.13462865e-01f, -1.23750776e-01f, 2.08731979e-01f, -4.98309359e-02f,
  8.08782354e-02f, -1.86203063e-01f, -1.13831289e-01f, 1.47568613e-01f, 1.59955546e-02f, -1.10898428e-01f, -9.76950824e-02f, -7.85747245e-02f, 1.18291199e-01f, 2.53046989e-01f,
  9.81056169e-02f, -1.80365250e-01f, -2.39433423e-02f, 3.43009591e-01f, -1.69312544e-02f, -3.78157459e-02f, -6.58942088e-02f, -1.19951695e-01f, 8.87667462e-02f, -2.07275346e-01f,
  -1.39295846e-01f, -1.86744213e-01f, -1.76226702e-02f, -1.72653571e-01f, -3.64601165e-02f, -2.62564607e-02f, 3.69393528e-02f, -3.04053426e-01f, -2.97206908e-01f, 3.08845006e-02f,
  -8.06182027e-02f, 1.27732098e-01f, -5.97442985e-02f, 1.30228743e-01f, -5.65950200e-02f, -2.56983399e-01f, -5.46939857e-02f, -2.35400781e-01f, 4.77383845e-04f, -2.08612338e-01f,
  -2.72538543e-01f, -1.03982881e-01f, -7.55748972e-02f, -2.00453475e-01f, -9.55909416e-02f, 1.62870690e-01f, -2.21525624e-01f, -4.66901250e-02f, 1.31119220e-02f, -1.42109677e-01f,
  -5.10565862e-02f, -8.26158151e-02f, -8.05379599e-02f, -1.27878383e-01f, -1.31734416e-01f, -2.48718351e-01f, 4.98178899e-02f, -1.35461122e-01f, -3.85234147e-01f, -1.84429765e-01f,
  -9.03409794e-02f, -1.72146827e-01f, -2.01758876e-01f, -1.58588767e-01f, -5.24273142e-02f, 1.99579507e-01f, -1.34176672e-01f, -8.68349001e-02f, 2.45425761e-01f, -3.60258259e-02f,
  2.48499706e-01f, 1.25227600e-01f, 1.49017289e-01f, 1.57297887e-02f, -3.57673764e-02f, -1.16149008e-01f, 1.72027815e-02f, -9.82927904e-02f, -2.31707282e-02f, -8.61938968e-02f,
  -8.23269784e-03f, -1.80984184e-01f, -3.45427871e-01f, -1.53883308e-01f, -1.03786111e-01f, 2.44590342e-01f, 2.39185184e-01f, 4.72480476e-01f, -5.94328046e-02f, -2.46030003e-01f,
  2.25797474e-01f, -1.22339102e-02f, 1.13007337e-01f, -1.87195510e-01f, 3.76843405e-03f, -2.47295529e-01f, 2.27929473e-01f, -1.03651434e-01f, -6.21229559e-02f, 1.62779897e-01f,
  6.89873472e-02f, 3.72919105e-02f, -5.86682260e-02f, 1.74541235e-01f, 1.17243089e-01f, -7.42195174e-02f, 3.25968713e-01f, 1.20716048e-02f, -1.08868733e-01f, -1.95666969e-01f,
  2.89701875e-02f, 2.75152951e-01f, -2.23365515e-01f, -1.49726838e-01f, -1.64250210e-02f, -4.37262468e-03f, 3.61120850e-02f, 7.45353755e-03f, -1.84224591e-01f, 1.11600168e-01f,
  -9.07101929e-02f, -7.82983676e-02f, -1.66812286e-01f, -9.48741734e-02f, -1.44701734e-01f, 1.81896850e-01f, -4.18655612e-02f, -1.84467100e-02f, 2.76688929e-03f, -4.02448922e-02f,
  2.69610524e-01f, -1.12972848e-01f, 1.25333011e-01f, -2.26453841e-02f, 1.66063413e-01f, -4.85341661e-02f, 1.32547364e-01f, 6.00740574e-02f, 2.73911227e-02f, -7.81823471e-02f,
  2.53346533e-01f, 3.06785870e-02f, 2.18161404e-01f, -6.76051304e-02f, -2.28664726e-02f, 1.07926913e-01f, 8.60768035e-02f, -4.45759743e-02f, 1.65238008e-01f, -1.70709923e-01f,
  4.92316857e-02f, -2.83321202e-01f, 2.11444106e-02f, -1.05280206e-01f, -4.60871905e-02f, -6.81054518e-02f, -1.03507660e-01f, 7.61128664e-02f, 2.40443543e-01f, -1.29316792e-01f,
  -1.98028654e-01f, -4.33266116e-03f, -2.32392922e-02f, -2.72908937e-02f, -2.87022859e-01f, -7.68280253e-02f, -1.02613315e-01f, -1.01820081e-01f, -5.87818548e-02f, 2.60486007e-01f,
  1.10619038e-01f, 1.41016543e-01f, -2.64565758e-02f, -1.22655898e-01f, 1.25216603e-01f, 1.18450321e-01f, -3.70062366e-02f, 8.70872661e-02f, 1.20134458e-01f, 7.60342926e-02f,
  -9.49036554e-02f, -4.75413613e-02f, 1.54689834e-01f, 4.03882951e-01f, 1.77569553e-01f, 6.21929727e-02f, 6.97296858e-02f, -7.36085922e-02f, 2.58175969e-01f, -5.67681808e-03f,
  2.81228900e-01f, -3.09508685e-02f, 3.16156074e-02f, 1.25408441e-01f, -2.12699082e-02f, -7.00675137e-03f, 1.91662442e-02f, 1.91634353e-02f, 1.08760722e-01f, 8.30146000e-02f,
  5.12609482e-02f, 1.09631255e-01f, -5.21521047e-02f, -5.80960661e-02f, 1.53265856e-02f, 4.40069996e-02f, 5.76333366e-02f, -1.89645097e-01f, -5.92454076e-02f, -2.49695569e-01f,
  6.21525086e-02f, 1.22225530e-01f, 3.39613669e-03f, 1.06331840e-01f, 1.94674015e-01f, -1.33612258e-02f, 4.51747589e-02f, 1.19364895e-01f, -1.27744764e-01f, 9.10708010e-02f,
  1.93643734e-01f, 1.62377149e-01f, -1.42367318e-01f, -2.94805795e-01f, 8.85984744e-04f, 2.34099641e-01f, 9.07545015e-02f, 4.03822176e-02f, 2.28726298e-01f, 8.33007693e-02f,
  5.75621575e-02f, -3.98578569e-02f, 9.09177400e-03f, -2.31290460e-02f, -1.10815212e-01f, -2.65853047e-01f, -2.60699335e-02f, -3.46279666e-02f, -1.33117139e-01f, -1.01093322e-01f,
  -2.77429167e-03f, -7.61147514e-02f, -6.18137494e-02f, 2.56245639e-02f, -8.02158713e-02f, 2.03910843e-02f, -4.33637798e-02f, -2.01270059e-01f, -3.95274634e-04f, -7.17026368e-02f,
  2.22637862e-01f, 2.05681846e-01f, -2.45236650e-01f, -1.30318224e-01f, 8.27514306e-02f, -7.71398172e-02f, 1.53517993e-02f, -1.36478217e-02f, 2.07494497e-02f, 2.80030310e-01f,
  -3.21572348e-02f, 4.80804443e-02f, -6.34012148e-02f, 1.46373585e-02f, 1.10059366e-01f, 4.01433557e-02f, 9.54943970e-02f, 8.36761147e-02f, -1.86536968e-01f, 1.96281187e-02f,
  -2.19415188e-01f, -1.06630787e-01f, -6.99327094e-03f, -1.74198464e-01f, -2.13092282e-01f, 1.50937170e-01f, -5.10409735e-02f, 1.33290648e-01f, 1.97868869e-01f, 2.64447331e-01f,
  7.30260536e-02f, -3.02648485e-01f, 1.64705902e-01f, -4.83215041e-03f, 1.63507894e-01f, -4.11296114e-02f, -3.27898785e-02f, -1.18522771e-01f, -2.18396895e-02f, 4.99984212e-02f,
  -1.61595017e-01f, -4.52842470e-03f, 2.05023304e-01f, 4.21564877e-02f, 1.31634504e-01f, -4.28102426e-02f, 3.08422465e-02f, -6.75045177e-02f, -1.28751904e-01f, -1.39176041e-01f,
  2.74682476e-04f, -1.34948403e-01f, -1.04379222e-01f, 1.95307493e-01f, -1.54074237e-01f, 2.76302639e-02f, 5.61836511e-02f, 1.57004580e-01f, 2.06157655e-01f, 1.02470197e-01f,
  1.12464570e-01f, -4.73302044e-02f, 7.47676194e-02f, -1.17989659e-01f, -1.97991565e-01f, 5.95058538e-02f, -1.31777659e-01f, 2.87064373e-01f, -1.95883825e-01f, 1.69751700e-02f,
  -2.10446641e-01f, 1.78740099e-01f, 1.19867764e-01f, 1.98188365e-01f, 2.73756962e-02f, -8.93869549e-02f, -6.24641106e-02f, 9.49046388e-02f, 1.16227962e-01f, 3.78965177e-02f,
  -8.11232850e-02f, 7.52840564e-02f, -1.55734807e-01f, -1.50171354e-01f, 6.74726516e-02f, -1.17593743e-01f, -1.28636867e-01f, 3.78595549e-03f, 1.96685225e-01f, 2.16428488e-01f,
  -1.95872754e-01f, 9.84371454e-02f, 1.41792908e-01f, -3.60828638e-01f, 2.67763823e-01f, -2.37573370e-01f, 1.58043191e-01f, -7.34566897e-02f, 1.37745216e-01f, 2.75975198e-01f,
  -1.35972008e-01f, 2.70870537e-01f, -3.18136007e-01f, -1.49307594e-01f, -1.06983215e-01f, -2.85191715e-01f, 4.12283465e-02f, 1.45279651e-03f, 1.71322376e-01f, -1.79182574e-01f,
  3.54966700e-01f, -5.75895421e-02f, 1.02020897e-01f, 1.57723892e-02f, -1.18243052e-02f, -2.13632882e-01f, -1.48995265e-01f, -2.45514929e-01f, 1.07438371e-01f, 1.20505683e-01f,
  1.92037880e-01f, 4.22509201e-02f, -7.60724470e-02f, 1.22881755e-01f, 1.66119754e-01f, -1.19880475e-01f, 5.02894297e-02f, -1.18228979e-01f, 2.30630279e-01f, 2.49900505e-01f,
  -4.79756109e-02f, -1.23392642e-01f, -1.75710857e-01f, 1.00035921e-01f, -8.84408653e-02f, -2.66649187e-01f, -3.75804722e-01f, 1.58460572e-01f, 9.25791487e-02f, 1.88319936e-01f,
  4.47535440e-02f, 2.74022639e-01f, -1.56161021e-02f, 4.21768315e-02f, -1.95951629e-02f, -6.32783324e-02f, -1.36556834e-01f, -1.38721600e-01f, -2.65284061e-01f, -2.18250826e-01f,
  -4.45924327e-02f, -2.20823228e-01f, -2.63648421e-01f, -1.21249780e-02f, 1.28834859e-01f, 8.56584087e-02f, 1.17101725e-02f, 1.80630907e-01f, -8.58002901e-02f, -2.92080101e-02f,
  1.72442123e-01f, 1.11168221e-01f, 2.07953304e-01f, 1.48052657e-02f, 9.46799889e-02f, -2.98095256e-01f, 1.45886406e-01f, 2.05419268e-02f, -4.02707141e-03f, 6.59190565e-02f,
  2.37076849e-01f, 1.81829885e-01f, 1.06218390e-01f, 2.46901482e-01f, 1.37330398e-01f, 4.99557890e-02f, 1.27532348e-01f, -3.87353413e-02f, 9.01018903e-02f, -1.57779023e-01f,
  4.83794399e-02f, 1.27466977e-01f, -1.56991646e-01f, -6.02005236e-02f, -8.08481500e-02f, 1.18210189e-01f, -1.32747605e-01f, -1.12135679e-01f, -1.86789781e-01f, -6.28527254e-02f,
  -9.00543015e-03f, -5.21027297e-02f, 3.85288149e-02f, 3.22151929e-02f, -1.05884038e-01f, 2.49501541e-01f, 8.17692950e-02f, -2.75355857e-02f, -3.02732494e-02f, 1.18425146e-01f,
  8.22276771e-02f, 1.44198626e-01f, -4.67595086e-03f, -1.35843679e-01f, -1.08397044e-01f, -1.34601016e-02f, -5.47007937e-03f, 1.85588911e-01f, 1.01801127e-01f, 2.48541385e-01f,
  -1.05992399e-01f, 8.33668411e-02f, -1.61385760e-01f, 1.14892058e-01f, -2.38458142e-01f, -2.41676241e-01f, -1.24178454e-01f, -1.24788851e-01f, -1.31490365e-01f, 6.36404473e-03f,
  -4.11542296e-01f, -3.79569829e-01f, 1.40525833e-01f, 2.43591100e-01f, -2.68037021e-01f, 6.60395324e-02f, -2.04767257e-01f, 8.86675939e-02f, -9.75851864e-02f, -1.64041504e-01f,
  -2.30315074e-01f, 1.03997238e-01f, 7.83613771e-02f, 1.13847353e-01f, 4.51710187e-02f, 3.53462040e-01f, 8.80021453e-02f, 3.11653391e-02f, -2.51747012e-01f, 9.06969458e-02f,
  -1.46756738e-01f, -1.53069094e-01f, 9.48529765e-02f, -2.05811504e-02f, -6.62423298e-02f, -1.05877206e-01f, 3.56548607e-01f, -7.10653812e-02f, -1.08391888e-01f, -2.04430241e-02f,
  -2.36332864e-02f, 1.12109892e-01f, -3.05582553e-01f, -2.72149313e-02f, 9.57269296e-02f, -3.58533114e-01f, 8.01649410e-03f, 1.86921477e-01f, -1.59931302e-01f, -1.60304695e-01f,
  -7.13670254e-02f, -9.28621143e-02f, 1.51669979e-01f, 1.31134037e-02f, -1.36070460e-01f, 2.13318288e-01f, -5.20326756e-02f, 1.67510644e-01f, 1.24354698e-01f, 3.59106101e-02f,
  2.48634852e-02f, 1.05236731e-01f, -1.16686329e-01f, 2.17603147e-01f, 1.50949098e-02f, -3.80925722e-02f, -1.30296290e-01f, -7.14444593e-02f, 2.06891552e-01f, -5.71929477e-02f,
  4.01402086e-01f, -1.12849116e-01f, 1.98286921e-01f, -1.12740204e-01f, 6.35220204e-03f, -4.62372527e-02f, 7.28766918e-02f, 4.83012311e-02f, -6.23199381e-02f, -3.36808525e-02f,
  2.25047395e-01f, 2.27204412e-01f, 1.16272360e-01f, -1.67854965e-01f, -5.42552620e-02f, -1.18942358e-01f, 2.33427361e-02f, 1.63680270e-01f, 8.79714042e-02f, 1.56308219e-01f,
  -2.02713042e-01f, 8.73167999e-03f, -1.53060064e-01f, 1.15216576e-01f, -1.42483920e-01f, -3.18358168e-02f, 3.26142401e-01f, -1.18495718e-01f, 5.20143732e-02f, 1.98731169e-01f,
  -6.95230290e-02f, 1.35947868e-01f, 1.35684490e-01f, 1.60281360e-01f, -4.73877601e-02f, -9.10835341e-02f, 3.30967568e-02f, 7.71492273e-02f, 3.39891575e-02f, 8.92969370e-02f,
  2.97836065e-01f, 2.31220663e-01f, 1.59657344e-01f, 1.58212800e-02f, 2.03713685e-01f, 1.41508445e-01f, -6.48445711e-02f, 2.58102894e-01f, 1.28012419e-01f, 1.56645760e-01f,
  6.68143108e-02f, 2.58311480e-02f, 1.79017205e-02f, 1.48735613e-01f, 1.19852550e-01f, 2.62918454e-02f, -5.33695072e-02f, -3.07670295e-01f, -8.48175958e-03f, 7.46716708e-02f,
  1.83911204e-01f, -2.51907986e-02f, -1.06344961e-01f, 2.81994175e-02f, -3.60380150e-02f, 1.51096553e-01f, -9.12492499e-02f, 2.52262652e-01f, 1.50133697e-02f, -5.43117449e-02f,
  7.88847581e-02f, -2.69943066e-02f, 3.04690927e-01f, 2.13412911e-01f, -1.16100140e-01f, -1.98071361e-01f, 3.42941247e-02f, 1.27146497e-01f, -1.51603725e-02f, -8.53900313e-02f,
  -1.37948930e-01f, -2.82177329e-01f, -2.88147759e-02f, -4.71049100e-02f, 2.52416693e-02f, -2.58877259e-02f, 2.08433703e-01f, 8.12869295e-02f, 3.63138050e-01f, 2.03085318e-01f,
  -5.03119111e-01f, -4.28534485e-02f, 1.44599691e-01f, 7.67076686e-02f, 1.89803138e-01f, -3.48260626e-02f, 4.10322063e-02f, -1.08167501e-02f, -1.86595358e-02f, 1.21387117e-01f,
  1.02459222e-01f, 1.41831011e-01f, 9.70410034e-02f, -1.00127868e-01f, -2.27145880e-01f, -2.53107786e-01f, -6.03090189e-02f, 1.07262924e-01f, 9.78069603e-02f, 6.01831228e-02f,
  6.89119752e-03f, -3.27470541e-01f, 3.76432836e-02f, -7.26885945e-02f, 9.58370343e-02f, 2.34498397e-01f, 1.63570940e-01f, -6.79046139e-02f, 1.87716670e-02f, 1.12861425e-01f,
  -2.00343113e-02f, 2.09640458e-01f, -8.25712755e-02f, -8.87063220e-02f, -8.80707949e-02f, -4.70945090e-02f, -7.28738634e-03f, 8.59636515e-02f, 9.91334915e-02f, -1.83132619e-01f,
  1.00156918e-01f, -2.13892624e-01f, 2.26856977e-01f, -3.21173295e-02f, -2.26267025e-01f, -2.26526000e-02f, -1.98768545e-02f, -5.25923725e-03f, 2.78143764e-01f, 3.56754839e-01f,
  4.75909524e-02f, -1.61264956e-01f, 7.43983462e-02f, -1.58417642e-01f, -1.13485612e-01f, 7.80317038e-02f, 1.03982046e-01f, -1.57889664e-01f, -1.99483305e-01f, 5.89431860e-02f,
  5.63750230e-02f, 1.53765202e-01f, 2.10657269e-02f, -7.93739501e-03f, 6.75321370e-02f, -1.45281971e-01f, 6.85764477e-02f, -3.94876301e-02f, -2.87393749e-01f, 2.13198885e-01f,
  1.97215483e-01f, -8.27367976e-02f, -2.31891833e-02f, -2.17821971e-01f, -2.46628746e-02f, 1.52821600e-01f, -4.29064557e-02f, -1.17641620e-01f, 3.44051927e-01f, 7.61447176e-02f,
  -1.34112025e-02f, 2.36750484e-01f, -3.98161188e-02f, -6.69915695e-03f, -2.27185085e-01f, 2.04421163e-01f, -3.55799310e-02f, -6.92505995e-03f, -8.47026799e-03f, -5.89372264e-03f,
  -5.68170361e-02f, -1.33604482e-01f, -7.38882124e-02f, -1.38418943e-01f, -8.42729677e-03f, 2.91069336e-02f, 2.37383604e-01f, 2.89456490e-02f, 3.65033536e-03f, -1.22009628e-01f,
  -1.33028254e-01f, 1.00735612e-01f, -6.18773922e-02f, 1.38154432e-01f, -3.64229828e-02f, 6.21973686e-02f, -5.71178049e-02f, -3.99754107e-01f, -4.04310897e-02f, -1.07036337e-01f,
  -1.27453446e-01f, 1.83668092e-01f, -4.28104065e-02f, -4.71117012e-02f, 3.43800277e-01f, -6.72647506e-02f, -1.41987905e-01f, -1.95945743e-02f, 6.31014258e-02f, -6.07258007e-02f,
  -2.84710228e-01f, -2.48707488e-01f, -1.95629336e-02f, -1.86161369e-01f, -1.92160964e-01f, 2.30832905e-01f, 5.58404475e-02f, 9.84741002e-02f, 3.35080251e-02f, 1.20427884e-01f,
  9.65288952e-02f, 7.66629502e-02f, -7.12991133e-02f, 4.11204994e-02f, 3.21225077e-02f, 1.00342602e-01f, 3.10271591e-01f, 4.35186997e-02f, 2.27975398e-01f, 2.42857799e-01f,
  1.07894748e-01f, 4.68523651e-02f, -2.06154168e-01f, -8.63885805e-02f, 6.25982583e-02f, -5.28504066e-02f, 1.49558589e-01f, -1.86544642e-01f, 3.82863730e-02f, 1.49107687e-02f,
  -7.21643120e-02f, -3.89329195e-02f, 8.97390619e-02f, -8.12088102e-02f, 2.50819679e-02f, 2.12673947e-01f, -5.41800112e-02f, 1.39175802e-02f, -8.89256299e-02f, 8.31525102e-02f,
  2.68045604e-01f, -1.21978588e-01f, -2.12808877e-01f, 1.00300625e-01f, 1.64449122e-02f, -1.94860816e-01f, 1.37201816e-01f, -2.37676650e-01f, 1.57191142e-01f, -1.86159313e-01f,
  -2.02086508e-01f, 6.44411743e-02f, 2.08314173e-02f, 2.33214706e-01f, -8.96135997e-03f, -3.12776230e-02f, -5.26847653e-02f, 2.71248013e-01f, -3.26575190e-02f, -2.18825266e-01f,
  1.80064380e-01f, 9.74390656e-02f, 2.21362319e-02f, 3.29431593e-01f, 2.38404244e-01f, 1.43763855e-01f, -1.77202091e-01f, 4.04005229e-01f, -3.23809564e-01f, 1.20604090e-01f,
  -7.62859359e-02f, 1.11237898e-01f, 1.27821803e-01f, -9.08685252e-02f, 1.64698124e-01f, -6.57375678e-02f, 6.30360618e-02f, 2.02025384e-01f, -2.11902276e-01f, 5.08074164e-02f,
  -1.19578227e-01f, 2.76920889e-02f, 1.23925582e-02f, -1.55257732e-01f, -6.89283013e-02f, -6.68479204e-02f, 2.81939149e-01f, -3.75540145e-02f, -5.37534542e-02f, -1.89325750e-01f,
  4.55962569e-02f, -1.18469387e-01f, 4.35637720e-02f, 1.34351686e-01f, -9.66176465e-02f, 5.23549877e-02f, 1.56357750e-01f, -7.89255276e-02f, 1.98713914e-01f, 6.75753132e-02f,
  5.54931760e-02f, 1.44373208e-01f, -1.66678820e-02f, 2.34969318e-01f, -6.29639402e-02f, -1.43421954e-02f, 5.92579544e-02f, -2.38836855e-02f, 1.69035271e-01f, 4.26720865e-02f,
  3.22438300e-01f, -2.80101355e-02f, 5.36346585e-02f, -1.04299925e-01f, 2.83191741e-01f, -3.46804559e-02f, 1.64765239e-01f, 1.39327630e-01f, 1.73093677e-01f, 2.29951944e-02f,
  2.09309459e-02f, 1.50240332e-01f, -2.12120369e-01f, -1.98205233e-01f, -1.13744877e-01f, 6.00356124e-02f, -6.98916689e-02f, -1.05600074e-01f, -1.51194707e-01f, -9.32331905e-02f,
  3.79312336e-02f, -1.44445777e-01f, 4.89708111e-02f, -1.49720237e-01f, -7.61805922e-02f, -5.92459403e-02f, 2.72220939e-01f, -1.11642800e-01f, -3.38313729e-02f, -8.49802718e-02f,
  -1.84854850e-01f, 9.68741700e-02f, 9.00839716e-02f, 1.92051277e-01f, 1.91061683e-02f, 1.06392041e-01f, -3.11321728e-02f, -6.37701154e-02f, -1.15860492e-01f, 1.52483821e-01f,
  2.74643421e-01f, 2.73270875e-01f, -4.31590788e-02f, 8.65723491e-02f, -1.64420292e-01f, 1.24610905e-02f, -1.40920371e-01f, 2.84086447e-02f, 9.84234512e-02f, 8.67606997e-02f,
  -3.56611311e-02f, 6.17041104e-02f, 2.19713300e-01f, 9.11863223e-02f, -5.20390971e-03f, -1.94616113e-02f, -1.04006320e-01f, 1.36992827e-01f, 2.04494204e-02f, 4.83208559e-02f,
  -1.86680779e-01f, 5.23047745e-02f, 5.10449708e-02f, -1.87423736e-01f, 9.94400233e-02f, -2.15004817e-01f, 1.87919483e-01f, 1.03603601e-01f, -2.31767651e-02f, 3.05692583e-01f,
  -4.84661832e-02f, 5.56979775e-02f, -1.44195668e-02f, -1.46545067e-01f, 2.34222189e-01f, -6.40681833e-02f, -9.85527262e-02f, -2.01985359e-01f, 3.29327852e-01f, -8.80073681e-02f,
  1.61110073e-01f, 3.05195749e-01f, 1.32811591e-01f, 1.38933092e-01f, -2.69779801e-01f, 3.03882211e-01f, -3.32135916e-01f, -1.91534758e-02f, -1.20580792e-01f, 2.39285342e-02f,
  1.48240775e-01f, -1.32543698e-01f, 8.40841830e-02f, 1.83719665e-01f, -1.89223796e-01f, 8.61497894e-02f, -1.27560541e-01f, 1.80689897e-02f, 5.61453886e-02f, -2.36015156e-01f,
  3.70658822e-02f, -3.77924383e-01f, 1.32272476e-02f, 4.50613797e-02f, 3.04261539e-02f, 7.81881288e-02f, -5.48259355e-02f, 2.29960859e-01f, 9.02050063e-02f, 6.68584555e-02f,
  -6.29506707e-02f, 3.35045993e-01f, 1.46608531e-01f, -7.59412721e-02f, 1.61096543e-01f, 1.74476862e-01f, 1.68622248e-02f, 1.64690986e-01f, 2.26804286e-01f, 1.55921310e-01f,
  5.39781339e-02f, -1.32704586e-01f, 1.89032361e-01f, 4.34850082e-02f, 2.24778280e-01f, -7.57871717e-02f, 9.82498676e-02f, 2.10406110e-01f, 1.31833181e-01f, 6.93467930e-02f,
  1.98993057e-01f, -1.10815413e-01f, -1.85914204e-01f, -9.47421044e-03f, -1.34717599e-01f, 7.59683549e-02f, 4.09027413e-02f, -9.17936787e-02f, -5.49805351e-03f, -1.00564316e-01f,
  3.43972892e-01f, 1.52409211e-01f, 1.92661047e-01f, -1.24225721e-01f, 1.76439717e-01f, 1.29693151e-01f, 9.43560526e-02f, 2.92697409e-03f, -1.79645240e-01f, 3.41182351e-02f,
  -1.16300799e-01f, 2.04318553e-01f, 1.02332354e-01f, 7.69691989e-02f, 1.39574900e-01f, -9.44776833e-02f, 1.23389028e-01f, -1.88635662e-02f, -7.38491714e-02f, 3.22683603e-02f,
  7.81175345e-02f, -6.69757649e-02f, -1.14507817e-01f, -1.43985555e-01f, 1.23507708e-01f, 4.40122753e-01f, 1.09503463e-01f, 9.10067037e-02f, 1.91934124e-01f, -6.33960068e-02f,
  2.80811161e-01f, 1.45577649e-02f, 2.87450790e-01f, -2.01721359e-02f, -1.27857983e-01f, 1.66856349e-02f, 2.43939713e-01f, -1.66184813e-01f, 4.73493487e-02f, -1.26589164e-01f,
  9.60092545e-02f, -4.69428860e-02f, -3.76647115e-02f, 1.44009069e-01f, 1.22892216e-01f, -1.47665292e-01f, 1.43466154e-02f, -1.36755303e-01f, 1.29899874e-01f, -4.04667072e-02f,
  -1.01591296e-01f, -9.02073383e-02f, -2.48163804e-01f, 1.28701836e-01f, -7.27032125e-02f, 2.27899194e-01f, 1.94726601e-01f, 2.14930922e-01f, 7.02570528e-02f, -3.71358357e-02f,
  2.37458855e-01f, -6.38977960e-02f, 5.56870215e-02f, -1.88563123e-01f, 3.71462852e-02f, -2.62027919e-01f, 3.37541074e-01f, -1.96859147e-03f, 7.22741336e-02f, -2.03918144e-01f,
  -2.07145512e-03f, -1.52068794e-01f, 9.88966525e-02f, 4.71855178e-02f, 2.02252883e-02f, -3.00944328e-01f, -1.53142855e-01f, 2.16144174e-02f, -4.40556556e-01f, 2.19166338e-01f,
  -7.22431093e-02f, -1.54772669e-01f, -2.74457484e-01f, -3.45210060e-02f, -8.54733139e-02f, -4.23708186e-02f, -1.63780749e-01f, 1.05154410e-01f, 6.28217822e-03f, -1.23629138e-01f,
  -1.84025913e-01f, -1.26585931e-01f, -1.71445847e-01f, -1.81323677e-01f, -9.63752642e-02f, -1.91815645e-01f, -1.26267672e-01f, 2.15794072e-01f, 1.73467800e-01f, -1.47735104e-02f,
  -1.01753034e-01f, 6.98707402e-02f, -1.19588688e-01f, -1.35786086e-01f, -7.55709261e-02f, -6.15768731e-02f, 2.76497332e-03f, 2.39717197e-02f, 1.40211582e-01f, 8.27664733e-02f,
  -1.61497012e-01f, -1.54129788e-01f, -8.16962197e-02f, 7.93369114e-02f, 1.95476323e-01f, -1.66842923e-01f, -1.05787069e-01f, 2.86020208e-02f, -3.17636393e-02f, 2.10273653e-01f,
  8.74502957e-02f, 2.49753311e-01f, 1.51350405e-02f, 1.38008654e-01f, -7.51839355e-02f, -9.18749273e-02f, 1.09107964e-01f, -8.63392726e-02f, -1.53626159e-01f, -2.32289076e-01f,
  1.34496912e-01f, -8.93992931e-02f, 7.30901957e-02f, 9.68815982e-02f, 1.61777392e-01f, 4.81945053e-02f, 7.09721446e-02f, 1.78390760e-02f, -2.74341583e-01f, -1.59911320e-01f,
  -2.04870611e-01f, -2.49047399e-01f, 5.73897064e-02f, -1.42767087e-01f, -7.82384425e-02f, -2.85825715e-03f, 4.14196998e-02f, -1.75527781e-01f, 5.76943122e-02f, 7.89783075e-02f,
  9.36513916e-02f, -9.87374187e-02f, 3.07021569e-02f, -3.81892920e-01f, -1.91320375e-01f, -3.87413017e-02f, -9.77515578e-02f, 7.94829130e-02f, -1.98004127e-01f, 2.15339020e-01f,
  -1.81806862e-01f, 1.95332915e-02f, 6.87274486e-02f, 2.67499566e-01f, 5.07547446e-02f, 5.17623313e-02f, 1.72528416e-01f, 2.74135768e-02f, 5.94493281e-03f, 6.92711473e-02f,
  6.17409088e-02f, 8.30312967e-02f, 2.72609647e-02f, -3.04092951e-02f, 3.96158397e-02f, -1.24871477e-01f, -3.10014579e-02f, -2.61383712e-01f, -3.15457918e-02f, -1.76757053e-02f,
  -1.82771727e-01f, -4.13662568e-02f, 2.79914010e-02f, -1.94128416e-02f, 5.66771440e-02f, 4.08595115e-01f, -7.84068778e-02f, -9.98540744e-02f, -7.13491663e-02f, -1.11041799e-01f,
  1.78792581e-01f, -7.93508813e-02f, -1.09912179e-01f, -2.41323963e-01f, 2.28450775e-01f, 2.03695312e-01f, -7.60245100e-02f, 4.91828732e-02f, 1.54780731e-01f, 1.05619095e-01f,
  -1.61861733e-01f, 1.23902120e-01f, 1.48903698e-01f, -2.87143420e-02f, 3.62676233e-02f, -2.68789351e-01f, 6.73432946e-02f, 2.04028580e-02f, 5.91085590e-02f, 1.94072396e-01f,
  -1.98014110e-01f, -4.02761437e-02f, 8.82516801e-02f, -8.25168751e-03f, -1.08211085e-01f, -1.61228165e-01f, -1.74844578e-01f, -2.13236004e-01f, 1.93823203e-01f, -6.48305332e-03f,
  -1.44979388e-01f, 6.51519299e-02f, 4.94535677e-02f, 3.29509348e-01f, -9.13543850e-02f, 1.47657976e-01f, 7.41160065e-02f, 2.21913800e-01f, 1.75707594e-01f, 3.86154018e-02f,
  2.48468578e-01f, -9.66556557e-03f, 4.43597659e-02f, 3.43265124e-02f, 9.88892466e-02f, 4.05685455e-02f, 1.49921119e-01f, 6.07693270e-02f, -1.59515087e-02f, -2.61913482e-02f,
  1.24376543e-01f, 4.59200032e-02f, -1.64692283e-01f, -1.31991711e-02f, -2.88658172e-01f, -1.49015829e-01f, -4.12451588e-02f, 2.86184579e-01f, -1.28442824e-01f, 1.76492140e-01f,
  1.76148057e-01f, 7.82711953e-02f, -8.28205571e-02f, -5.45055382e-02f, 9.36377347e-02f, -1.45113051e-01f, -7.34209269e-02f, -2.83785641e-01f, 2.85519391e-01f, 1.13475211e-01f,
  2.24467948e-01f, 2.51751482e-01f, 1.89255148e-01f, 2.84237534e-01f, 1.06300667e-01f, 6.33380860e-02f, 1.78560972e-01f, -2.25532249e-01f, -8.06489140e-02f, -3.01559474e-02f,
  -1.86253950e-01f, 2.70328969e-02f, -9.09100622e-02f, -5.49730249e-02f, 2.45164678e-01f, -6.17459826e-02f, -2.65175968e-01f, -6.95703998e-02f, -3.11598957e-01f, 7.85869546e-03f,
  3.55474427e-02f, -2.66009420e-01f, -2.03898594e-01f, -4.00887161e-01f, -1.74253359e-01f, -7.49952421e-02f, 4.12437022e-02f, 1.63105503e-02f, -2.32807130e-01f, -7.90758356e-02f,
  1.82107627e-01f, -1.52242377e-01f, 2.50654016e-02f, 1.85558215e-01f, 1.04671024e-01f, -1.68011636e-01f, 5.74106164e-02f, -4.03313190e-02f, 1.36577830e-01f, 3.22606340e-02f,
  -2.28047714e-01f, 3.30350190e-01f, -1.03749700e-01f, -1.40382335e-01f, -2.47001171e-01f, 1.14327282e-01f, 2.55061872e-02f, -1.74474999e-01f, 2.89559424e-01f, -9.81873199e-02f,
  -9.81182083e-02f, -8.00340325e-02f, -3.33854109e-02f, -2.56730407e-01f, 1.43517733e-01f, -2.61125475e-01f, 2.47796904e-02f, -5.79917841e-02f, 2.29369570e-02f, 3.16663414e-01f,
  1.22311123e-01f, 2.35393316e-01f, -1.39668941e-01f, -1.00872159e-01f, -2.81837970e-01f, 1.91431165e-01f, 8.61538425e-02f, 2.43533328e-01f, 6.04138710e-02f, 1.06341943e-01f,
  -1.29739329e-01f, 3.87264229e-02f, -7.84029663e-02f, 1.89790875e-02f, 9.93169993e-02f, -1.95614696e-01f, 8.30888283e-03f, -1.31343305e-01f, 1.45557523e-01f, 1.87289506e-01f,
  1.54644191e-01f, 5.29244319e-02f, -8.60139355e-02f, 1.06740318e-01f, 1.51342094e-01f, -1.02961756e-01f, -1.36752471e-01f, -8.46741572e-02f, 3.47336143e-01f, 2.86244899e-01f,
  -4.10943441e-02f, -1.29684821e-01f, 6.89239800e-02f, 7.78037123e-03f, -9.10714716e-02f, 3.07634491e-02f, -2.70867020e-01f, 2.61805624e-01f, 1.27515672e-02f, 4.45214175e-02f,
  1.11385554e-01f, 2.42325023e-01f, 3.03689111e-02f, 5.99511154e-02f, 2.23464936e-01f, -1.71377823e-01f, -9.02449638e-02f, 6.54852018e-02f, -2.98357308e-02f, 2.83559822e-02f,
  9.87182260e-02f, -5.04073277e-02f, -3.83626610e-01f, -1.46476209e-01f, 3.33572365e-02f, 7.71110207e-02f, 1.98741280e-03f, 8.34388137e-02f, -1.86437443e-01f, 3.22184116e-02f,
  1.62203331e-02f, -1.68772563e-02f, -3.03263552e-02f, -1.84967443e-01f, 1.80416211e-01f, -1.60675257e-01f, -7.91689008e-02f, -1.27120942e-01f, -7.90503100e-02f, -1.40122592e-01f,
  1.47487938e-01f, -3.99525687e-02f, 1.21577993e-01f, -1.41598821e-01f, 1.73741832e-01f, 1.16301499e-01f, 4.01714563e-01f, -2.96935569e-02f, 1.60959531e-02f, -6.65656254e-02f,
  -2.03724056e-02f, 2.75416762e-01f, -1.35835901e-01f, -1.64991602e-01f, 1.57290339e-01f, -8.01702738e-02f, -1.54345497e-01f, -5.32137230e-03f, -6.71049505e-02f, 1.30925357e-01f,
  8.84649381e-02f, -1.85198318e-02f, -1.59218192e-01f, -3.79701070e-02f, 6.35768920e-02f, 2.98983216e-01f, -2.71661095e-02f, -3.86744514e-02f, 6.57103434e-02f, 1.77893594e-01f,
  4.88598585e-01f, 9.91791952e-04f, -5.82922921e-02f, -1.69119522e-01f, -3.82888876e-02f, -1.58547416e-01f, 1.09741628e-01f, 1.20713919e-01f, -1.37686491e-01f, 1.83999717e-01f,
  -1.94220737e-01f, -1.60781324e-01f, 1.83229432e-01f, -1.00982197e-01f, 7.29795322e-02f, -1.66570187e-01f, 5.20108119e-02f, 3.43412012e-02f, -2.28097364e-01f, -6.31272942e-02f,
  1.75728694e-01f, -2.82670408e-01f, 2.61854023e-01f, -2.03124821e-01f, 5.77959046e-02f, -6.81366175e-02f, 9.93527621e-02f, 2.51155674e-01f, 7.33574629e-02f, 8.68085772e-02f,
  -2.13274375e-01f, 8.83193463e-02f, 5.76657802e-02f, 1.69705488e-02f, 2.67446227e-02f, 1.26021624e-01f, 1.58147663e-01f, -2.18420960e-02f, 9.27396938e-02f, 2.71471534e-02f,
  -1.60329252e-01f, 2.44808216e-02f, -4.66084853e-02f, -6.90352470e-02f, -2.11248264e-01f, -1.26072690e-01f, 2.51667649e-01f, 1.93538338e-01f, 1.99483797e-01f, 8.51742551e-02f,
  1.30662128e-01f, -2.55681779e-02f, 3.13173562e-01f, 4.24493290e-02f, -2.91191489e-02f, 5.34678437e-02f, 1.01418374e-02f, 2.71357059e-01f, 1.91049144e-01f, -1.38974458e-01f,
  -1.60430536e-01f, -1.54415265e-01f, 2.10627034e-01f, -1.61445752e-01f, -2.09312215e-01f, 3.01153749e-01f, 1.41955823e-01f, -9.48558673e-02f, 8.60559121e-02f, -1.84953317e-01f,
  1.13354214e-02f, 1.26230139e-02f, -7.05856979e-02f, 2.45442867e-01f, -1.61038622e-01f, -3.54316384e-02f, -1.36798680e-01f, -1.57400876e-01f, 2.63445750e-02f, -1.28832921e-01f,
  2.15238351e-02f, 7.33897090e-02f, -2.04162002e-02f, 1.04164537e-02f, 2.41937011e-01f, -5.94624244e-02f, 2.30923131e-01f, -3.57345372e-01f, 1.66557759e-01f, 3.22403014e-02f,
  2.65098602e-01f, 2.23239392e-01f, -1.83027044e-01f, 6.32127374e-02f, -4.83756000e-03f, 4.41468023e-02f, -1.33573636e-01f, -1.88078210e-02f, 1.32683545e-01f, 1.91062555e-01f,
  4.74167876e-02f, -1.63234740e-01f, 1.63310394e-01f, 2.91888881e-02f, -1.57351241e-01f, -1.61970153e-01f, 1.76325440e-02f, -2.64584929e-01f, -2.53579050e-01f, -7.66983209e-03f,
  5.02256639e-02f, 2.01310232e-01f, 2.30774552e-01f, 1.26265571e-01f, -1.59997702e-01f, 1.16319120e-01f, 1.18395321e-01f, -7.32981414e-02f, -6.78286105e-02f, 9.42600518e-02f,
  1.88551560e-01f, 3.29715312e-01f, -1.33463651e-01f, 1.24772705e-01f, -9.53570381e-03f, -3.06840949e-02f, 2.00290303e-03f, 6.37823856e-03f, -1.59007192e-01f, 2.77392268e-01f,
  1.15673654e-02f, -1.04997326e-02f, -2.64941957e-02f, -5.58334179e-02f, 5.64214289e-02f, 9.27593634e-02f, -1.45942764e-02f, -3.33467983e-02f, -1.33279309e-01f, 5.77061847e-02f,
  -5.88581339e-02f, -1.14102699e-01f, 9.88313183e-02f, -1.20422460e-01f, -3.46212626e-01f, 2.32945472e-01f, -1.72987908e-01f, 1.84697405e-01f, 2.48352557e-01f, -1.88683838e-01f,
  1.42003581e-01f, -9.65243056e-02f, -5.12791872e-02f, 1.29202157e-01f, 1.94073424e-01f, -4.95959744e-02f, -7.36054033e-02f, -9.39874053e-02f, -1.35787623e-02f, 3.81313451e-02f,
  -2.22523913e-01f, -2.28277132e-01f, -1.35341480e-01f, -1.78224728e-01f, 2.71822363e-01f, -1.98520258e-01f, 9.51702520e-03f, 4.34341431e-02f, 1.32650435e-01f, -2.50352383e-01f,
  -6.65853322e-02f, 3.70565318e-02f, -2.25089893e-01f, 5.79289421e-02f, -2.82251626e-01f, -1.66325673e-01f, -8.99945572e-02f, 1.50294572e-01f, -3.73134129e-02f, -3.23105939e-02f,
  -7.44725540e-02f, -8.57327580e-02f, -9.71099362e-02f, 6.11457726e-05f, -1.64069250e-01f, 1.58555806e-01f, -2.53507674e-01f, 6.72272295e-02f, -4.95903119e-02f, -4.61743288e-02f,
  -1.10565923e-01f, -1.36646882e-01f, 5.44064417e-02f, 1.82074323e-01f, 7.29176700e-02f, 1.29469827e-01f, -2.95781484e-03f, 1.98813707e-01f, -6.00188449e-02f, 2.62093879e-02f,
  7.77036026e-02f, -2.63267636e-01f, 5.73859699e-02f, -9.92471799e-02f, -2.62863096e-02f, -3.84603045e-03f, 1.61491647e-01f, 9.39690173e-02f, 1.75438613e-01f, 3.28617394e-02f,
  5.57357632e-02f, 1.39934346e-01f, -2.37513557e-01f, 1.91278815e-01f, -2.26690024e-02f, 1.81061625e-01f, 7.62199908e-02f, 1.82242513e-01f, -1.43848687e-01f, -3.04667711e-01f,
  -9.75062549e-02f, -1.49602145e-01f, 9.40125063e-02f, -1.04956046e-01f, 1.31197751e-01f, -2.62539499e-02f, -4.82070819e-02f, 1.53532818e-01f, 3.12744193e-02f, 6.35148957e-02f,
  -1.22785755e-01f, 7.35992612e-03f, 1.65890977e-01f, 1.70208201e-01f, -1.43886730e-01f, -4.18087542e-02f, 8.91386867e-02f, 5.99110164e-02f, 1.10234797e-01f, -3.60235535e-02f,
  -6.79351091e-02f, 3.12744305e-02f, -7.41582736e-03f, -3.70129012e-02f, -1.27746865e-01f, 3.48844305e-02f, 1.59896389e-01f, 1.83351994e-01f, -5.64570613e-02f, -1.30353406e-01f,
  -3.75737399e-02f, -5.86806796e-02f, 1.65471286e-01f, 8.69842712e-03f, 2.11384445e-01f, 4.34516510e-03f, 2.68127136e-02f, -1.35503113e-01f, 1.94267973e-01f, 7.55676553e-02f,
  -8.55029598e-02f, -8.21513832e-02f, 1.59626141e-01f, 3.36078145e-02f, 4.39951569e-02f, -3.28603536e-01f, 7.00350702e-02f, 1.54085651e-01f, 2.16764063e-01f, 1.27871051e-01f,
  -2.01996356e-01f, 1.13473676e-01f, 4.98263836e-02f, 1.69093251e-01f, -1.80302978e-01f, 1.09422088e-01f, 2.86429703e-01f, 1.51572779e-01f, 4.58959900e-02f, 1.44363418e-01f,
  1.70047134e-01f, 2.14968055e-01f, 1.32701039e-01f, -1.68871626e-01f, -1.43876597e-01f, 2.13893384e-01f, 2.72619694e-01f, -1.23612560e-01f, 4.33939463e-03f, -2.51539499e-01f,
  2.00249236e-02f, -1.92038596e-01f, 2.09798098e-01f, 7.78379962e-02f, 1.88811645e-01f, -1.78030401e-01f, 6.00103661e-02f, 1.42005801e-01f, -3.75208199e-01f, -6.58588931e-02f,
  9.78098135e-04f, -5.84145010e-01f, 7.60009214e-02f, 4.54551121e-03f, -2.59499997e-01f, 1.16943896e-01f, -2.11813942e-01f, 1.97175533e-01f, -3.46070975e-02f, -1.35569656e-02f,
  1.80916041e-01f, -1.57861054e-01f, -2.37041518e-01f, -3.65654290e-01f, -1.99609585e-02f, -4.78988588e-01f, -1.29647508e-01f, 7.08750114e-02f, 2.00706627e-02f, -2.87067831e-01f,
  -1.25127047e-01f, -1.18779480e-01f, 5.40775657e-02f, 3.83867882e-02f, 6.94235787e-02f, 8.78307372e-02f, 5.78009412e-02f, -1.22999977e-02f, 1.63750023e-01f, -2.09409609e-01f,
  -1.74902067e-01f, -1.00606792e-01f, -6.46200255e-02f, 4.34905058e-04f, -8.71333703e-02f, -1.06889643e-01f, -3.36642981e-01f, 7.91454464e-02f, -8.44504610e-02f, 3.06201488e-01f,
  -4.29700315e-02f, 6.54164329e-02f, -1.91797018e-01f, -1.84832022e-01f, -1.24530911e-01f, 1.27403699e-02f, 2.89972257e-02f, -3.06055009e-01f, 1.12745604e-02f, -2.84774244e-01f,
  2.64120162e-01f, -1.77910492e-01f, 3.67569528e-03f, 6.78774640e-02f, 1.00565143e-01f, -1.97086800e-02f, 1.66648209e-01f, -1.23390399e-01f, 6.70105070e-02f, 3.09979096e-02f,
  9.94807258e-02f, 6.71620741e-02f, -2.07625866e-01f, 4.26166654e-02f, 4.50312123e-02f, 1.93715811e-01f, -1.54918522e-01f, -1.11249484e-01f, 4.93392535e-02f, 1.99836046e-01f,
  1.75059333e-01f, 1.49044901e-01f, -1.22368149e-02f, 2.20973082e-02f, 3.61342877e-02f, -2.38915067e-03f, -3.13532680e-01f, -4.05299291e-02f, -2.05264054e-02f, 8.57885480e-02f,
  -5.74544668e-02f, -4.36590500e-02f, 2.11138219e-01f, 2.83897426e-02f, 1.12311646e-01f, 7.03696236e-02f, -2.76636910e-02f, 8.10677260e-02f, 5.92941642e-02f, 1.64601073e-01f,
  -2.41695009e-02f, 1.27131060e-01f, 5.47013357e-02f, -1.73029706e-01f, 2.57952541e-01f, 4.63020653e-02f, 2.10439041e-01f, 2.06949245e-02f, -5.86931454e-03f, 4.62389290e-02f,
  1.02637641e-01f, -1.44128934e-01f, 1.67938709e-01f, 1.35326944e-02f, -2.59443194e-01f, 5.46453558e-02f, -1.44456357e-01f, 2.96636015e-01f, 1.80193126e-01f, -5.60223646e-02f,
  -1.05577841e-01f, -1.71731599e-02f, -1.67916805e-01f, 2.67462313e-01f, 1.50398403e-01f, -1.57261133e-01f, 1.33422479e-01f, -5.43718077e-02f, 9.07393545e-02f, -1.23658106e-01f,
  -1.11668907e-01f, 1.22888871e-01f, 1.48686573e-01f, -1.03787761e-02f, 3.26994628e-01f, 4.03665677e-02f, -1.78832412e-02f, -6.77835494e-02f, 1.72350481e-01f, -1.59905031e-01f,
  2.66277760e-01f, 7.14111999e-02f, -7.76661783e-02f, -1.93534613e-01f, -7.28809880e-03f, 6.59704790e-04f, -2.39012942e-01f, -4.31162529e-02f, 1.26852319e-01f, 8.17135051e-02f,
  2.38370642e-01f, -5.83844483e-02f, -4.12859842e-02f, 1.29351601e-01f, -9.39503610e-02f, 8.42128973e-03f, -1.43593596e-02f, 5.67442887e-02f, 2.81776488e-01f, -4.41288948e-02f,
  1.21739127e-01f, 2.39699647e-01f, 6.72103539e-02f, 2.30337068e-01f, 2.84860760e-01f, -9.91246030e-02f, -8.17673467e-03f, -1.46205530e-01f, -9.25049558e-02f, 7.97866881e-02f,
  -7.06995092e-03f, -5.39268740e-02f, -1.84759330e-02f, -1.39362559e-01f, -2.92682260e-01f, -2.22425684e-02f, -1.94209158e-01f, 6.43564463e-02f, 3.00083756e-01f, 6.69914708e-02f,
  1.54506534e-01f, -1.75036207e-01f, 1.96060345e-01f, 1.77092850e-01f, 7.09604174e-02f, 5.11600636e-03f, 1.68191940e-02f, -1.08499087e-01f, 3.22869383e-02f, -3.30763198e-02f,
  -1.55995026e-01f, -7.53804147e-02f, -3.83429118e-02f, -2.40843352e-02f, 9.93003547e-02f, 2.53320839e-02f, 4.01547194e-01f, 7.49977911e-03f, 3.34670186e-01f, -6.95033669e-02f,
  -3.89063545e-02f, -8.10922757e-02f, -2.59838458e-02f, -8.48169476e-02f, -1.05865754e-01f, -1.73985250e-02f, -1.25610068e-01f, -8.72449204e-02f, -1.43337801e-01f, 5.92140034e-02f,
  -1.71085298e-01f, 8.43199063e-03f, -3.34686087e-03f, 2.31893919e-02f, -5.25517762e-02f, 1.52332529e-01f, -3.44378762e-02f, 2.77811468e-01f, -3.71956788e-02f, 5.98322786e-02f,
  -2.37553641e-01f, -2.03480899e-01f, 1.44767702e-01f, 1.11464925e-01f, 8.49233419e-02f, 7.45637491e-02f, 1.46887749e-01f, 1.62146278e-02f, 8.18367153e-02f, 1.96651276e-02f,
  1.19072139e-01f, 3.60896438e-02f, 1.07116122e-02f, 6.94657117e-02f, 1.66176274e-01f, -5.64112552e-02f, 8.90766457e-02f, -3.53298597e-02f, -2.02025324e-01f, 1.61292210e-01f,
  -1.39322236e-01f, 1.75203457e-01f, 3.14071178e-01f, -1.55507788e-01f, 1.55372843e-01f, -1.92708805e-01f, -1.27803758e-01f, 1.62311971e-01f, 2.84649044e-01f, -1.27682224e-01f,
  3.46393228e-01f, -2.24360049e-01f, -6.40299246e-02f, 7.67472461e-02f, 3.59710678e-02f, -8.86881649e-02f, -1.11138947e-01f, -2.33717546e-01f, 2.45430931e-01f, -9.86438990e-02f,
  6.33895844e-02f, 1.08921297e-01f, 9.57350656e-02f, -1.10063687e-01f, 1.65015921e-01f, -2.87422668e-02f, 3.51963043e-02f, 2.12522924e-01f, -2.39571735e-01f, -1.34656271e-02f,
  2.43478492e-01f, 1.63180336e-01f, 1.15948543e-01f, 2.85142120e-02f, 1.13006510e-01f, 2.79784322e-01f, 3.84703325e-03f, -5.57281487e-02f, -2.65572011e-01f, -1.59342624e-02f,
  5.89553379e-02f, 2.66919017e-01f, -1.33467298e-02f, 3.89906056e-02f, -1.42680496e-01f, 1.71643957e-01f, -2.18553487e-02f, 7.13281110e-02f, 2.33791559e-03f, 1.07299417e-01f,
  7.84327164e-02f, 2.79525727e-01f, 1.08271658e-01f, 1.25556812e-01f, -1.76816240e-01f, -2.08862036e-01f, 7.65002221e-02f, 9.21287015e-03f, -9.72041786e-02f, 1.18988544e-01f,
  -2.89324731e-01f, -3.86955738e-02f, 2.24176291e-02f, -2.58799586e-02f, 1.16215080e-01f, 2.75066823e-01f, -2.59915590e-01f, 2.03923330e-01f, -9.04499590e-02f, -3.92917506e-02f,
  5.36305420e-02f, 2.72290707e-02f, -2.54740447e-01f, 2.16158047e-01f, 9.05436352e-02f, 1.61737800e-01f, 4.01120275e-01f, -1.74795091e-01f, -9.08859298e-02f, 5.63812479e-02f,
  2.59351432e-01f, 2.52504379e-01f, -1.41354188e-01f, 4.97470587e-01f, 2.60863185e-01f, -7.70509988e-02f, 9.35109109e-02f, -9.94234066e-03f, -1.30823459e-02f, 1.04676753e-01f,
  2.79942397e-02f, -2.11784929e-01f, 2.65318811e-01f, -1.24391653e-01f, -5.08502185e-01f, -9.01803598e-02f, -1.19897522e-01f, -6.99306130e-02f, -2.14417830e-01f, 7.36290291e-02f,
  -1.18958531e-03f, -5.19432187e-01f, 1.11273937e-01f, 1.83197006e-03f, 1.82035789e-01f, -1.59282312e-01f, 2.71225005e-01f, -1.44929856e-01f, -1.43998593e-01f, -6.70070946e-02f,
  4.06955704e-02f, -5.20082824e-02f, -7.78536275e-02f, 7.07849711e-02f, 1.65958956e-01f, 2.07454830e-01f, 3.02551668e-02f, 6.97948039e-02f, 1.55652031e-01f, -1.79801360e-01f,
  -4.30158973e-02f, -1.47160694e-01f, 1.71379626e-01f, 1.39877707e-01f, 4.66190539e-02f, 1.49364201e-02f, -1.35282665e-01f, -1.46480605e-01f, 9.62973014e-02f, 2.81473696e-01f,
  8.92544687e-02f, 4.29328442e-01f, -1.56684935e-01f, 2.29496792e-01f, 8.75808224e-02f, 9.98265762e-03f, -3.66624594e-02f, -9.48793367e-02f, -1.43444613e-01f, 2.41073385e-01f,
  2.96043575e-01f, -2.17813447e-01f, -4.22180854e-02f, 7.91342114e-04f, 2.12272614e-01f, 5.25229760e-02f, 6.44852296e-02f, 1.93870947e-01f, 2.01958135e-01f, -1.24815956e-01f,
  2.20223799e-01f, 1.60397310e-02f, -8.44314471e-02f, -4.95846160e-02f, 1.16915926e-01f, -7.65538663e-02f, 1.15368173e-01f, -1.84325784e-01f, -1.26912326e-01f, -1.68212771e-01f,
  -2.36126333e-02f, -6.03199713e-02f, 7.37816375e-03f, -1.62459418e-01f, 8.48061442e-02f, 1.81772739e-01f, -1.38045818e-01f, -2.53140301e-01f, 2.03065164e-02f, 2.40617129e-03f,
  -1.75395906e-01f, -1.93786979e-01f, -1.39093161e-01f, -1.30777303e-02f, 2.41557762e-01f, 6.21327870e-02f, 5.26221059e-02f, 7.53114372e-02f, 5.10341004e-02f, -3.47498804e-02f,
  1.61205113e-01f, -2.95370743e-02f, 1.62379354e-01f, 1.24972731e-01f, 9.58515983e-03f, 6.56017512e-02f, -1.32908281e-02f, -2.21911371e-01f, 8.98845587e-03f, -8.17333683e-02f,
  -3.54710609e-01f, 2.76742131e-02f, -7.30819851e-02f, 8.78139511e-02f, 2.54759759e-01f, -1.19439632e-01f, -3.94948050e-02f, -7.63577316e-03f, -9.09571797e-02f, 1.19401701e-01f,
  2.73293674e-01f, -8.52999687e-02f, 2.65210718e-01f, -2.74332821e-01f, -4.74763438e-02f, -1.09564498e-01f, 1.19513229e-01f, 5.60584962e-02f, -5.81244677e-02f, -3.95022258e-02f,
  2.27515221e-01f, -3.13246131e-01f, 2.50898255e-03f, 2.07822129e-01f, 8.83071646e-02f, 5.10799512e-02f, 2.54838049e-01f, -4.87322435e-02f, -5.21810241e-02f, 2.20018834e-01f,
  -2.10000679e-01f, 1.38864487e-01f, 1.71459123e-01f, 2.70959347e-01f, 2.33918682e-01f, 2.11791508e-02f, 6.48380083e-04f, 3.78551573e-01f, 2.53414027e-02f, -1.41160741e-01f,
  -2.66149759e-01f, 1.53955147e-01f, 1.77629851e-02f, 3.85570467e-01f, 1.40925854e-01f, 1.86572429e-02f, -5.15393615e-02f, 9.02715474e-02f, 7.87046626e-02f, 1.22846708e-01f,
  5.37173674e-02f, -1.55318335e-01f, -7.84213543e-02f, -1.61932647e-01f, 1.23053752e-01f, 1.47869423e-01f, 2.34345207e-03f, 1.51640866e-02f, 3.60340700e-02f, -1.57894388e-01f,
  1.01738937e-01f, 1.80824883e-02f, 9.25860405e-02f, 4.71813567e-02f, 3.57607901e-01f, 1.12660177e-01f, 2.14785397e-01f, -8.34192038e-02f, -8.87582526e-02f, -2.30698720e-01f,
  1.82264641e-01f, 2.21020952e-01f, -2.41330937e-01f, 7.42925890e-03f, -1.13750168e-03f, 2.83713769e-02f, -2.25957595e-02f, -2.77806133e-01f, -2.12454014e-02f, 1.84675232e-01f,
  1.23584084e-01f, 1.78269342e-01f, -2.00392276e-01f, 1.67016715e-01f, -2.33245138e-02f, -1.18384458e-01f, -2.97907054e-01f, 4.01478596e-02f, -2.74804950e-01f, 1.18726395e-01f,
  -4.85545173e-02f, -1.54499346e-02f, 1.20269343e-01f, -6.39413744e-02f, 1.37662157e-01f, 8.38388130e-02f, -3.49173695e-02f, -5.79215400e-02f, 1.42094135e-01f, 3.84484902e-02f,
  1.74017012e-01f, 8.58074427e-02f, 2.80464478e-02f, 1.36819258e-01f, 9.13227648e-02f, 3.51943970e-02f, 2.12232858e-01f, -2.45559469e-01f, 7.75317550e-02f, 8.33055452e-02f,
  3.61678153e-02f, 4.03737053e-02f, -1.57525122e-01f, 1.25912517e-01f, 7.02886656e-02f, 9.19514820e-02f, 1.83148488e-01f, 1.53713718e-01f, -8.09068605e-03f, 3.86640057e-02f,
  1.32234842e-01f, -1.93733543e-01f, 1.92686737e-01f, 7.56270811e-02f, 1.96742695e-02f, -1.04542673e-01f, -4.63125147e-02f, 2.66013682e-01f, 3.35054934e-01f, 5.80266789e-02f,
  1.24885835e-01f, -2.02503935e-01f, -3.77428085e-02f, -3.26569408e-01f, 1.22114323e-01f, 2.77486384e-01f, 5.02163582e-02f, -2.68400647e-02f, -1.39026269e-01f, -1.72666982e-01f,
  2.88747966e-01f, 1.48812965e-01f, -4.20668013e-02f, -2.08986893e-01f, 2.57359862e-01f, -6.76003247e-02f, -1.07647888e-01f, 3.39925475e-02f, -1.82532281e-01f, -1.17640875e-01f,
  -1.27280593e-01f, 2.28041723e-01f, 1.86053962e-01f, 3.40912826e-02f, 1.11920098e-02f, -2.07893122e-02f, 2.21068729e-02f, -4.71742675e-02f, 1.42710999e-01f, -4.00836803e-02f,
  4.89297882e-02f, -1.14486322e-01f, 5.18343821e-02f, -1.07809663e-01f, -1.04566380e-01f, 3.05757761e-01f, 8.85560662e-02f, 9.95234251e-02f, 1.46188796e-01f, -6.67564198e-02f,
  2.11132199e-01f, -4.47805971e-02f, 2.61714011e-01f, 1.07565328e-01f, -4.68344279e-02f, -1.05680749e-01f, 1.05886012e-01f, -2.17193156e-01f, -1.22814238e-01f, -1.48247227e-01f,
  -1.88596100e-02f, 8.55235755e-03f, 7.22527504e-02f, 6.19567186e-02f, -6.78769201e-02f, 7.51594678e-02f, 5.63834831e-02f, 4.97412235e-02f, -2.50148084e-02f, -1.09246867e-02f,
  -1.19429491e-02f, 4.11216058e-02f, -2.82067120e-01f, -1.24612711e-01f, -8.02892447e-02f, -3.76504026e-02f, 3.44158672e-02f, -1.50972698e-02f, 1.38124108e-01f, -1.53496727e-01f,
  -1.33163571e-01f, 1.29856646e-01f, -1.38599530e-01f, -1.16914712e-01f, 4.22451437e-01f, -1.68331072e-01f, 1.14332154e-01f, -1.36957103e-02f, 1.90545693e-01f, 1.60714403e-01f,
  1.80374570e-02f, 1.50689512e-01f, -5.25281653e-02f, 1.32871399e-04f, -3.83218437e-01f, 2.67590821e-01f, -2.19086424e-01f, 1.41386325e-02f, 1.58093557e-01f, 5.10402471e-02f,
  3.33514959e-02f, 3.58348161e-01f, 5.75182550e-02f, 1.73343215e-02f, 1.96779659e-03f, -4.36291620e-02f, 1.16287082e-01f, 1.02057330e-01f, 8.58691186e-02f, 3.81341368e-01f,
  1.94355085e-01f, -2.39718139e-01f, -1.27133638e-01f, 1.27616208e-02f, 8.94611254e-02f, 1.34769931e-01f, 2.33109698e-01f, -8.26565027e-02f, 2.12773249e-01f, -9.81559046e-03f,
  -2.75868364e-02f, -1.09759467e-02f, 3.83084156e-02f, 1.32700622e-01f, 3.80226746e-02f, 5.14234044e-03f, 1.99405521e-01f, 1.10896163e-01f, 1.78593725e-01f, 1.82027444e-02f,
  1.13711447e-01f, -1.37132462e-02f, -3.83413993e-02f, 4.43716608e-02f, 4.76062223e-02f, 4.20746952e-02f, -1.83210716e-01f, -7.64760748e-02f, -5.57069890e-02f, 2.44169667e-01f,
  6.00802824e-02f, 1.15843870e-01f, -1.42298609e-01f, 1.43353090e-01f, -1.14847317e-01f, 2.12193072e-01f, 4.02123295e-03f, -2.21892297e-01f, 1.63144544e-01f, 1.40326247e-01f,
  1.46952480e-01f, -1.46398365e-01f, 4.75162007e-02f, -1.45770356e-01f, -1.08944252e-01f, -1.01035208e-01f, 5.92145510e-03f, -1.74957648e-01f, 1.24611199e-01f, 4.56966572e-02f,
  3.07447135e-01f, 3.80543210e-02f, -1.61417380e-01f, 1.84879273e-01f, 2.09996819e-01f, 2.08045349e-01f, 3.38255093e-02f, -8.09891820e-02f, -1.31826088e-01f, 1.28806889e-01f,
  1.27095906e-02f, 2.00215559e-02f, -3.09367422e-02f, 1.72937661e-01f, 2.02619523e-01f, 2.30952337e-01f, -3.09552640e-01f, -3.49903330e-02f, 1.31656379e-01f, 1.43184364e-01f,
  -2.00091861e-02f, 5.78567339e-03f, -5.50268851e-02f, -9.22954232e-02f, 1.85083166e-01f, -1.94747135e-01f, 3.41167264e-02f, 9.30456519e-02f, 2.04451587e-02f, 2.61501700e-01f,
  -9.41861495e-02f, 1.66325003e-01f, -5.69277294e-02f, -1.68171134e-02f, 1.86408073e-01f, 1.07536964e-01f, 2.30661333e-02f, 8.38278681e-02f, -1.29363298e-01f, 1.27474353e-01f,
  -1.14581183e-01f, -4.39577289e-02f, 1.05943546e-01f, -1.82788163e-01f, -1.44134298e-01f, 6.29208088e-02f, -1.86065629e-01f, 6.55494183e-02f, 1.54054344e-01f, -2.90137902e-02f,
  -2.18903258e-01f, 3.90665978e-01f, 6.34985343e-02f, 2.22299486e-01f, 2.35973343e-01f, -6.56170696e-02f, -4.91491482e-02f, -2.02910244e-01f, 1.28858358e-01f, 2.13501394e-01f,
  1.45850834e-02f, 3.93456042e-01f, 3.87596935e-01f, 6.84287921e-02f, 2.52400190e-01f, -3.97393247e-03f, -2.00191393e-01f, -1.93735555e-01f, 1.06116898e-01f, -8.47502425e-03f,
  3.60524625e-01f, 6.67332485e-02f, -2.10194439e-01f, -3.54742967e-02f, -3.08360100e-01f, -1.46584064e-01f, -2.47011960e-01f, 1.31916642e-01f, 1.32612661e-01f, -3.32238376e-01f,
  1.11507453e-01f, -5.58367372e-02f, 9.82081592e-02f, 1.13485307e-01f, 1.71785831e-01f, -4.27968502e-02f, -9.92888734e-02f, -1.09659024e-01f, 1.02371782e-01f, -8.74503031e-02f,
  1.00980401e-01f, -6.25311434e-02f, -3.71102169e-02f, 1.00639075e-01f, -4.46020737e-02f, 1.37104124e-01f, -1.85135081e-01f, -6.46239007e-03f, -1.64643764e-01f, -3.31476964e-02f,
  -8.38433430e-02f, -2.15172589e-01f, -9.34140012e-02f, -2.72733182e-01f, 2.38290941e-03f, 7.98765421e-02f, 2.71700509e-02f, 1.54135913e-01f, 2.92725384e-01f, 2.89539635e-01f,
  7.47789294e-02f, -1.30575150e-01f, 2.12346703e-01f, 8.34298059e-02f, 2.65664428e-01f, 1.29152551e-01f, -2.01060787e-01f, -1.10339401e-02f, 1.26143768e-02f, -1.40907347e-01f,
  -2.42266133e-01f, 3.04422993e-02f, 9.55771953e-02f, 6.10002801e-02f, 2.24000514e-02f, 1.68249756e-01f, -1.46272227e-01f, -1.52754098e-01f, -6.95818588e-02f, -6.81052953e-02f,
  1.93164479e-02f, -1.52792215e-01f, -1.73109040e-01f, 8.86963233e-02f, -5.93796298e-02f, 1.39187708e-01f, -8.16245154e-02f, -1.07126586e-01f, -1.30577013e-01f, -7.91021064e-02f,
  6.06038943e-02f, -2.95006841e-01f, -1.88276827e-01f, -2.06344388e-02f, 1.24431193e-01f, 1.22200064e-01f, -1.66165665e-01f, -2.90839225e-02f, -1.29996553e-01f, -1.60806149e-01f,
  -3.64517942e-02f, 1.15752034e-01f, 8.64161849e-02f, 2.04911187e-01f, 1.03277430e-01f, 2.01395880e-02f, 1.01647228e-01f, 2.00325530e-02f, 1.11378893e-01f, 2.33858898e-01f,
  4.20504212e-02f, -6.84884116e-02f, 2.74697095e-01f, 4.65927236e-02f, 9.08765793e-02f, -4.11582179e-02f, 1.34260237e-01f, 8.60971883e-02f, 3.04177970e-01f, -1.97691061e-02f,
  2.76083112e-01f, -1.05279773e-01f, -1.46559492e-01f, -3.45770657e-01f, 1.27113879e-01f, 1.48724437e-01f, 1.92513131e-02f, -7.12814331e-02f, -1.66159213e-01f, -3.24671343e-02f,
  5.75688034e-02f, -7.44136870e-02f, -8.98708701e-02f, -2.42373854e-01f, 2.25693166e-01f, 1.20238937e-01f, -2.04837710e-01f, -6.56479001e-02f, 1.51810963e-02f, -1.07778892e-01f,
  -1.53922722e-01f, 1.75362691e-01f, 5.18455096e-02f, 8.69849697e-03f, 1.27377391e-01f, -6.77217990e-02f, 1.45058751e-01f, -6.29257634e-02f, 4.98532094e-02f, 1.97381645e-01f,
  4.43803854e-02f, -1.14858590e-01f, -2.31299456e-02f, 3.10017308e-03f, 2.74981163e-03f, 8.44632164e-02f, 9.33436751e-02f, 1.07575893e-01f, 1.48601919e-01f, -5.51488511e-02f,
  1.21687301e-01f, -1.81907818e-01f, 2.67967075e-01f, -3.14900130e-02f, -9.68717858e-02f, 1.58975258e-01f, -4.49612290e-02f, -1.84743583e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  8.87901336e-02f, 9.21342894e-02f, 1.74160421e-01f, -1.66001506e-02f, 8.78381655e-02f, 6.17927909e-02f, 3.03989779e-02f, -7.93163776e-02f, -6.65979236e-02f, -1.16918288e-01f,
  -9.26297382e-02f, -9.96611193e-02f, 1.07882977e-01f, 4.31469968e-03f, 6.03522360e-02f, 7.58582205e-02f, 7.87758529e-02f, 1.51585281e-01f, -6.68268576e-02f, 1.81844339e-01f,
  -9.33557302e-02f, 5.77433147e-02f, -1.98349118e-01f, 2.59318408e-02f, -4.47516255e-02f, 1.33904144e-01f, 9.52080488e-02f, 8.98988098e-02f, 7.15963989e-02f, 2.41437525e-01f,
  1.63663924e-01f, -1.41312063e-01f, 1.26273900e-01f, -1.22716300e-01f, -6.48437515e-02f, -7.15771839e-02f, 2.16423497e-02f, 5.69952577e-02f, 9.22333747e-02f, 1.81176722e-01f,
  1.66460276e-01f, 2.35825647e-02f, 7.31587112e-02f, 2.06085294e-01f, 1.78699661e-02f, -1.37033463e-01f, 8.96589458e-02f, 1.14535324e-01f, 9.16881301e-03f, -8.05437565e-02f,
  3.65327708e-02f, 4.54325043e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.04810798e-02f, 1.90260947e-01f, -5.90855516e-02f, 7.27774277e-02f, -1.67004034e-01f, -9.75103751e-02f, 1.07942060e-01f, -1.46090686e-01f, -6.80909771e-03f, -8.73798225e-03f,
  7.34912455e-02f, 1.00913458e-01f, -2.99463198e-02f, -1.76216945e-01f, -9.24945474e-02f, 4.88690510e-02f, -1.16257720e-01f, 7.35283569e-02f, 3.80166546e-02f, -1.25549421e-01f,
  7.08379745e-02f, -1.50749218e-02f, -1.31837487e-01f, -1.37639880e-01f, -1.97336823e-01f, 1.11770071e-01f, -1.47431105e-01f, -6.23407364e-02f, 3.22080106e-02f, -1.98268667e-01f,
  3.24152596e-02f, -7.71869943e-02f, 8.43873899e-03f, -1.14562921e-02f, 4.96414788e-02f, 2.41926834e-02f, 4.62133251e-02f, 1.09310605e-01f, 8.55598003e-02f, 1.99877664e-01f,
  -1.20354723e-03f, 7.10779652e-02f, 9.61850733e-02f, -8.05718973e-02f, -1.03745945e-01f, 1.22520156e-01f, 2.97207814e-02f, -8.41041729e-02f, -2.51287525e-03f, 1.44298941e-01f,
  7.07225800e-02f, -1.77608415e-01f, -2.11329311e-01f, 1.02722876e-01f, -1.88412845e-01f, -6.91300407e-02f, 5.33791371e-02f, 2.11518079e-01f, 4.14598063e-02f, 7.03249201e-02f,
  -8.22281465e-02f, -4.34675932e-01f, -1.30813643e-01f, 9.69639271e-02f, 2.30700806e-01f, 4.08388563e-02f, 1.62326932e-01f, -3.00708250e-03f, 1.01403981e-01f, 1.39516562e-01f,
  -1.50483474e-01f, 6.75091939e-03f, -9.96737480e-02f, 2.04995930e-01f, -4.83345799e-02f, -1.48377061e-01f, -1.55408651e-01f, -3.57888937e-02f, -5.95107153e-02f, 8.26719031e-02f,
  4.64642933e-03f, -7.34055415e-02f, -2.06190243e-01f, -1.08753256e-01f, -1.03028171e-01f, 3.17213535e-02f, -1.82619750e-01f, -1.16365701e-01f, 1.29268646e-01f, -1.53150424e-01f,
  1.33838747e-02f, -3.76215242e-02f, -1.64626837e-01f, 8.30015168e-02f, -2.39332661e-01f, 6.62400648e-02f, 7.24061430e-02f, -4.22034077e-02f, -1.80913851e-01f, -3.95511650e-02f,
  -1.04351521e-01f, 5.25454246e-02f, -1.43857867e-01f, -5.85755296e-02f, 1.89352214e-01f, -1.18139293e-02f, -2.28162497e-01f, -1.96230710e-01f, -3.68539281e-02f, -2.53559589e-01f,
  -1.11732394e-01f, -5.12845591e-02f, 1.04555734e-01f, -4.80376594e-02f, 1.21670514e-01f, 1.52718678e-01f, 7.66050741e-02f, 1.08575784e-01f, -2.09012970e-01f, 5.47567345e-02f,
  6.59834743e-02f, 5.05291410e-02f, -6.18047491e-02f, -3.50901261e-02f, 1.32433802e-01f, -1.42019987e-01f, -2.45234836e-02f, -1.21376902e-01f, -2.30774283e-02f, -4.46628369e-02f,
  -1.11866884e-01f, -1.56647235e-01f, -2.13877708e-01f, -1.10448003e-01f, 5.00494987e-02f, 2.97401883e-02f, 2.06605010e-02f, 2.38103941e-01f, -2.78639615e-01f, 2.69534945e-01f,
  -1.64893374e-01f, -9.07709599e-02f, -1.06181227e-01f, -1.14380131e-02f, 3.97308962e-03f, 1.13433912e-01f, 7.02070668e-02f, 5.44309244e-02f, 1.04872987e-01f, 1.17374666e-01f,
  5.28055523e-03f, 3.34978886e-02f, 2.19193269e-02f, 1.06999926e-01f, 9.30691361e-02f, 2.28457078e-01f, 5.63450754e-02f, 6.84481338e-02f, -2.00892448e-01f, -7.23380297e-02f,
  -7.05039129e-02f, 1.42459571e-01f, 1.54762730e-01f, -2.66655684e-01f, -6.36363700e-02f, -5.02376631e-02f, 5.43328114e-02f, 1.25021115e-01f, -7.90260881e-02f, 7.13324398e-02f,
  -1.11279733e-01f, -1.59804057e-02f, 1.44578218e-01f, 8.93797651e-02f, 6.41700849e-02f, 1.16910808e-01f, -2.23313227e-01f, 2.03186329e-02f, 1.01932913e-01f, -1.78846449e-01f,
  -5.73418289e-02f, 2.29905531e-01f, -1.88472360e-01f, -4.69329059e-02f, 7.99855664e-02f, -1.53691163e-02f, -1.14084803e-01f, -9.03956816e-02f, -4.29261886e-02f, 4.60326597e-02f,
  9.70077738e-02f, -9.33878869e-02f, -3.95615622e-02f, -5.92075326e-02f, 3.49815428e-01f, 1.32919326e-01f, 1.32180870e-01f, 7.56017491e-02f, -1.64206594e-01f, 1.18104845e-01f,
  -6.98168427e-02f, 4.06421423e-01f, 1.69178564e-02f, -2.32692003e-01f, -6.89005665e-03f, -1.20015152e-01f, 8.55907947e-02f, 1.82605714e-01f, 2.37400960e-02f, -1.97370380e-01f,
  1.16359387e-02f, -1.31487682e-01f, 3.92323770e-02f, 8.31137374e-02f, -1.86633348e-01f, -6.84073344e-02f, 3.69326994e-02f, -8.08349252e-03f, -1.18614636e-01f, -1.35432780e-02f,
  -1.28846377e-01f, -4.72301953e-02f, -2.08040908e-01f, 1.39133438e-01f, -1.71767339e-01f, 2.33808219e-01f, -2.19350174e-01f, 1.21025048e-01f, 2.16200441e-01f, 5.04474081e-02f,
  3.76029275e-02f, -1.18346810e-01f, 1.60599992e-01f, -2.87268590e-02f, -1.08055107e-01f, 1.65879756e-01f, 3.21342913e-03f, -7.43397847e-02f, 2.99726110e-02f, -1.76006198e-01f,
  4.91330288e-02f, -2.96290547e-01f, -8.77002403e-02f, 3.44214961e-02f, -3.59748886e-03f, -5.65883704e-02f, -5.90124726e-02f, -9.14410651e-02f, -1.77815501e-02f, -2.78008189e-02f,
  -1.90447792e-02f, -9.01178792e-02f, -1.34990916e-01f, 3.56517807e-02f, 6.40206039e-02f, 1.13549940e-01f, -6.02801219e-02f, 3.70951220e-02f, -4.05930495e-03f, 6.73258677e-02f,
  1.10378951e-01f, 3.20021987e-01f, 2.16925532e-01f, -3.10206234e-01f, 2.74646878e-02f, 1.48126826e-01f, -8.69213492e-02f, 2.48623163e-01f, 2.73380745e-02f, -5.60942292e-02f,
  -5.01135252e-02f, -1.06279872e-01f, 1.93002895e-01f, 1.17759675e-01f, -1.01818375e-01f, -2.92017329e-02f, 3.23861092e-02f, -4.93225008e-02f, -8.38456675e-02f, -2.29688715e-02f,
  -9.67147760e-03f, 4.36375849e-02f, 1.52649004e-02f, -1.02611996e-01f, -1.42952418e-02f, -1.17846355e-01f, -7.61324540e-02f, -9.68085676e-02f, 8.93263593e-02f, -1.43829733e-01f,
  1.11235976e-01f, -8.55021104e-02f, -2.16650032e-02f, -7.02565163e-02f, -3.21223624e-02f, 2.16130599e-01f, -1.63493976e-02f, -7.35275447e-02f, 1.14987932e-01f, -2.37192765e-01f,
  -5.54701574e-02f, -1.12384826e-01f, -9.52726603e-02f, 1.98730417e-02f, 1.13623552e-01f, 2.24660680e-01f, 5.14211431e-02f, 1.23660326e-01f, 1.22055952e-02f, 5.96543495e-03f,
  -7.14489073e-02f, 4.78077605e-02f, 3.79942767e-02f, 1.03708290e-01f, -1.85826141e-02f, -4.65860777e-02f, 1.72984242e-01f, -2.26620257e-01f, -1.15232810e-01f, 9.01250690e-02f,
  1.81057587e-01f, -6.10728264e-02f, 1.48173213e-01f, 3.37459564e-01f, -4.11260054e-02f, -6.00862363e-03f, -8.80234409e-03f, 1.43292263e-01f, 1.02391668e-01f, -3.56220715e-02f,
  -1.07798487e-01f, 1.32169917e-01f, -1.80233344e-01f, -4.16933857e-02f, -1.95759609e-02f, 1.32028863e-01f, 1.11342058e-01f, -1.33256525e-01f, 1.15591057e-01f, -3.36272806e-01f,
  -1.49502303e-03f, -5.56993224e-02f, -2.80595943e-02f, -2.09383234e-01f, 1.42262951e-01f, -7.45850652e-02f, -1.27264082e-01f, -7.85014182e-02f, 1.07186273e-01f, 4.23477069e-02f,
  -2.05112427e-01f, 1.90434664e-01f, -1.84344202e-01f, 2.44475469e-01f, -2.62660265e-01f, 5.65459728e-02f, 6.50537089e-02f, 1.70575172e-01f, 1.46063998e-01f, -1.48455024e-01f,
  -8.59948993e-02f, -1.30094783e-02f, -2.10230246e-01f, -1.30097549e-02f, 1.84323683e-01f, 3.69141661e-02f, 1.01926759e-01f, -9.88394469e-02f, -1.78876862e-01f, -2.10353911e-01f,
  7.64028504e-02f, 2.01905340e-01f, -9.42523777e-03f, 6.95428345e-03f, 2.10338403e-02f, -7.76321068e-02f, 1.15710258e-01f, -2.61920124e-01f, -5.72732165e-02f, -2.04649903e-02f,
  -1.83013692e-01f, 2.34364480e-01f, -6.73628002e-02f, -4.49380428e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  4.53239027e-03f, 1.80758044e-01f, -1.85236722e-01f, -2.14248970e-01f, -5.46666861e-01f, -2.88146317e-01f, -9.42555889e-02f, 2.15360880e-01f, -1.05353586e-01f, -2.94215102e-02f,
  1.31603718e-01f, -2.96314746e-01f, -1.51993670e-02f, -5.14267311e-02f, -5.01153134e-02f, -2.44220141e-02f, -1.62737072e-02f, 2.22585276e-01f, 1.50623262e-01f, 1.54047802e-01f,
  1.53306469e-01f, -9.69984457e-02f, -2.27545220e-02f, -3.19054462e-02f, -2.05937639e-01f, 1.72942370e-01f, 1.51908264e-01f, -1.04155026e-01f, 2.07016289e-01f, -4.94171157e-02f,
  1.37427032e-01f, -5.74474223e-02f, 4.99783494e-02f, 1.27963543e-01f, -2.43466720e-02f, 1.74887896e-01f, -2.85063963e-02f, -2.22925027e-03f, -2.52166651e-02f, -3.67045440e-02f,
  1.51978852e-02f, -1.34080902e-01f, 7.37855062e-02f, 2.79939413e-01f, -6.87273666e-02f, 2.19419882e-01f, 3.48815471e-02f, -8.10067505e-02f, 8.60465243e-02f, -2.54051778e-02f,
  -2.77817011e-01f, -9.25907865e-02f, -1.32087693e-01f, -7.63003454e-02f, 1.36389822e-01f, -1.66819677e-01f, 2.01079920e-02f, 9.30905119e-02f, 9.15344059e-02f, -9.45677534e-02f,
  -8.09250772e-02f, 1.98235154e-01f, 9.23812091e-02f, 1.81990698e-01f, 3.46719801e-01f, 3.51347961e-02f, 1.99169621e-01f, 1.81572929e-01f, -2.00810730e-01f, 2.20014248e-03f,
  -3.74082178e-02f, 2.41577461e-01f, 2.39692330e-01f, 2.28414863e-01f, 3.56243104e-01f, -3.29392374e-01f, 1.25342637e-01f, -2.17198431e-01f, 3.20247747e-02f, -1.72350332e-01f,
  -1.01088926e-01f, -9.72505808e-02f, -4.24539335e-02f, 1.49996325e-01f, 3.68886604e-03f, -9.25525930e-03f, -2.62585104e-01f, 2.58059800e-01f, -6.71180189e-02f, 7.41237551e-02f,
  4.87884283e-02f, -1.64731145e-01f, -1.73028052e-01f, -2.19918713e-01f, 1.00799814e-01f, -7.51294047e-02f, -1.51292399e-01f, 2.91953832e-02f, 1.05177023e-01f, 9.14597437e-02f,
  8.72074068e-02f, -4.06091511e-02f, -4.73846607e-02f, -3.41310576e-02f, -4.99844626e-02f, 1.86335504e-01f, 1.06632560e-01f, -2.05236852e-01f, 8.29041451e-02f, 8.82063210e-02f,
  -7.92166963e-03f, 2.08701771e-02f, -8.69868398e-02f, -3.76706421e-02f, -3.75734687e-01f, -1.15159392e-01f, -2.10213155e-01f, 1.97822541e-01f, -1.20050408e-01f, -2.31602967e-01f,
  -7.16451257e-02f, 3.17931511e-02f, 4.73278500e-02f, -2.39232853e-02f, -1.11102633e-01f, -1.86264589e-01f, 4.52208631e-02f, -2.15224713e-01f, -1.57484367e-01f, 7.17783868e-02f,
  -2.24037200e-01f, -1.26196787e-01f, -2.43935555e-01f, -1.51427001e-01f, 2.07371607e-01f, -1.74068540e-01f, 3.93359400e-02f, -3.07013035e-01f, 2.03495905e-01f, 2.19003469e-01f,
  1.94309399e-01f, 1.06482327e-01f, -7.02167973e-02f, 4.28857319e-02f, 3.83972339e-02f, -2.59538461e-02f, 1.47235632e-01f, 2.31676221e-01f, 1.21067397e-01f, 9.18022990e-02f,
  3.41025330e-02f, -7.18772262e-02f, -2.45464608e-01f, -6.85172714e-03f, 1.16891161e-01f, 2.21420452e-02f, 2.05547482e-01f, -5.81855737e-02f, 9.44286436e-02f, 9.16383192e-02f,
  9.00575742e-02f, 9.43152234e-03f, 1.95158124e-01f, -1.23272710e-01f, -1.54408067e-02f, -1.00862019e-01f, -6.64884225e-02f, -5.54548064e-03f, -1.60467252e-02f, -3.02452952e-01f,
  6.88214749e-02f, 1.16687514e-01f, -4.79331054e-02f, 2.59766430e-01f, -5.49955014e-03f, 1.60763189e-01f, 3.07546440e-03f, 2.31887296e-01f, 8.05390924e-02f, -2.05723912e-01f,
  -7.31760636e-02f, -7.43505778e-03f, 4.60938625e-02f, -1.23789392e-01f, 3.99634801e-03f, 2.24911287e-01f, 1.00967094e-01f, 1.80042814e-02f, -3.52655388e-02f, -3.38034302e-01f,
  1.29996866e-01f, 1.19688772e-01f, 6.65533543e-02f, 2.48388499e-01f, 1.77203864e-01f, 2.65530467e-01f, 1.59864157e-01f, -2.68466603e-02f, -5.45228899e-01f, 3.42078745e-01f,
  1.46049455e-01f, 2.47866586e-01f, -3.61312926e-02f, -4.67278004e-01f, -1.94378123e-01f, 3.20208371e-02f, 1.07722484e-01f, -4.67511229e-02f, -2.98194960e-02f, 1.36518195e-01f,
  1.65176895e-02f, -1.03492647e-01f, 5.17389216e-02f, -5.89632727e-02f, 2.04274118e-01f, -3.52249257e-02f, 1.67392403e-01f, 3.84039991e-02f, 1.83706209e-01f, -1.52125835e-01f,
  2.53996328e-02f, 1.60809919e-01f, -2.96758264e-01f, 1.70185491e-01f, 4.81892936e-02f, 4.23392430e-02f, -9.01835337e-02f, 4.45351452e-01f, 1.10684596e-01f, 2.04490602e-01f,
  2.09654868e-01f, -1.69898733e-01f, 5.45290895e-02f, 1.33487076e-01f, 1.24796880e-02f, 1.54407725e-01f, -1.06048636e-01f, -1.99298039e-01f, -1.86345860e-01f, -1.76377356e-01f,
  2.00401545e-01f, -1.70475036e-01f, -1.42060518e-01f, 2.25450531e-01f, -2.58371159e-02f, -3.83377075e-01f, 3.04882079e-01f, 2.94148475e-01f, -3.29909801e-01f, 1.09860092e-01f,
  2.60512531e-01f, -7.65605792e-02f, -3.39901671e-02f, 4.23646986e-01f, 7.89896920e-02f, 2.17817396e-01f, 1.29925072e-01f, 1.03021972e-01f, 3.55137855e-01f, 6.14766032e-02f,
  4.70310360e-01f, 3.32429320e-01f, -6.53264206e-03f, -1.82481296e-02f, 1.47765145e-01f, 3.54982048e-01f, 2.01876745e-01f, 2.33522691e-02f, -5.79645783e-02f, 6.31855726e-02f,
  -1.36120478e-02f, -1.32528238e-03f, 2.19046786e-01f, -1.04722165e-01f, -3.78715154e-03f, -1.97931513e-01f, -1.16069317e-01f, 2.91433241e-02f, -7.12326616e-02f, -6.60441592e-02f,
  1.89941123e-01f, -3.06020826e-02f, -6.17936812e-02f, -2.42617782e-02f, -8.10415298e-02f, 8.06369781e-02f, -1.40738308e-01f, -7.02173784e-02f, 4.95318370e-03f, 7.90101513e-02f,
  1.27195314e-01f, 1.27233481e-02f, 6.66575565e-04f, 1.13127239e-01f, 1.11686841e-01f, -1.88980013e-01f, 1.21214405e-01f, 2.11644843e-01f, 6.95507824e-02f, -1.74252898e-01f,
  1.91311225e-01f, -2.71564275e-01f, -3.12957801e-02f, 3.44216302e-02f, 1.70410991e-01f, -8.13609734e-02f, 1.76141918e-01f, 6.07056953e-02f, -4.96823415e-02f, -7.93650821e-02f,
  -3.44954915e-02f, 3.05013776e-01f, -1.04881022e-02f, -9.92441848e-02f, -9.39635336e-02f, -8.41881707e-02f, 1.79516912e-01f, -4.94821817e-02f, -1.41524468e-02f, 1.30047485e-01f,
  -6.05492182e-02f, -1.32061854e-01f, 1.88129041e-02f, 5.06507568e-02f, 1.04585052e-01f, -1.08731776e-01f, 1.16654150e-01f, -4.72863168e-02f, 3.21136066e-03f, 1.79517447e-05f,
  1.31587321e-02f, -4.87429611e-02f, -4.08408083e-02f, 6.10151812e-02f, -3.11684124e-02f, -9.52102535e-04f, 2.66648009e-02f, -1.09327219e-01f, -1.67208072e-02f, 6.20311033e-03f,
  -8.89183506e-02f, 4.01445404e-02f, -6.75055385e-02f, 7.31816217e-02f, -9.79749113e-02f, 2.14549787e-02f, -1.20493695e-01f, -6.34511486e-02f, 2.58942433e-02f, -4.66793440e-02f,
  -7.08593428e-02f, 6.12818673e-02f, 4.37233858e-02f, -1.03640668e-01f, -2.61955187e-02f, 1.27439164e-02f, -4.80374992e-02f, 6.59601688e-02f, -1.31186083e-01f, -8.32375064e-02f,
  7.60329217e-02f, -1.39179096e-01f, -1.37007535e-01f, 2.95057464e-02f, -1.17788665e-01f, -7.56367818e-02f, -6.42497209e-04f, -9.65891257e-02f, -1.25215888e-01f, 6.70176819e-02f,
  -1.13171272e-01f, -6.49382621e-02f, -8.15293565e-02f, -3.33666876e-02f, 1.71600340e-03f, 4.92116378e-04f, -5.51252067e-02f, -2.30178144e-02f, -4.89973463e-02f, 8.13734680e-02f,
  -9.65685248e-02f, -5.04400097e-02f, 7.72055089e-02f, -1.01887278e-01f, 3.48378748e-01f, 1.63584977e-01f, 1.79551482e-01f, 1.39804661e-01f, 2.74550617e-01f, 1.00988105e-01f,
  -6.86730146e-02f, 1.43678397e-01f, 4.34549928e-01f, 3.62541080e-01f, 1.42044888e-03f, -1.25837877e-01f, -7.63629302e-02f, 1.36989981e-01f, -1.63650382e-02f, -1.07117724e-02f,
  -4.75458354e-02f, 9.12715271e-02f, -9.60058346e-02f, -5.46606593e-02f, -8.81030932e-02f, 6.52913302e-02f, 1.58894569e-01f, -6.09450489e-02f, 3.64425838e-01f, -6.55176565e-02f,
  -3.07213888e-02f, 2.10125998e-01f, -1.44229129e-01f, 1.81833819e-01f, -1.11075185e-01f, -1.14297591e-01f, 7.98729360e-02f, -6.05052710e-02f, -2.35114284e-02f, -8.83272886e-02f,
  4.52939514e-03f, 4.53987569e-02f, -1.53982844e-02f, 4.98207062e-02f, 3.67365517e-02f, 2.63646781e-01f, 7.51856193e-02f, -2.37100914e-01f, 2.27105662e-01f, -1.58722058e-01f,
  -2.32020803e-02f, -1.13747818e-02f, -3.99641842e-02f, 3.70058380e-02f, 2.16360271e-01f, 9.28769559e-02f, 2.17424452e-01f, 3.21766851e-03f, 1.92243874e-01f, 1.66992947e-01f,
  5.30075654e-02f, -1.21649511e-01f, -1.13581598e-01f, 1.08348332e-01f, 1.92512587e-01f, 3.20003718e-01f, 1.39814332e-01f, -1.26294076e-01f, 2.72276640e-01f, 2.19873801e-01f,
  2.31791120e-02f, 1.92009687e-01f, -2.62837350e-01f, 2.65057944e-02f, -3.43382150e-01f, -1.72209099e-01f, 1.59978002e-01f, 1.77259982e-01f, 3.75730157e-01f, 1.41235813e-01f,
  -6.53393045e-02f, 2.23367915e-01f, -2.13747576e-01f, -9.32837650e-02f, -7.99671263e-02f, 3.42417121e-01f, -1.25670567e-01f, 1.01803876e-01f, 8.13261122e-02f, -7.38830790e-02f,
  2.76123315e-01f, 2.18414068e-02f, 9.89569649e-02f, 8.90848637e-02f, -7.52634481e-02f, -2.11691126e-01f, 5.37403822e-02f, -6.81627467e-02f, 7.24441558e-02f, 6.22476859e-04f,
  2.03831106e-01f, 1.26563773e-01f, 1.35536462e-01f, 4.64864708e-02f, -2.50526443e-02f, -7.30580017e-02f, 2.64807165e-01f, -1.09277360e-01f, -1.84364125e-01f, -2.08694085e-01f,
  -5.10197915e-02f, 2.89243050e-02f, 1.33955613e-01f, 7.78247938e-02f, -1.57900468e-01f, 6.80434331e-02f, 9.32935551e-02f, 1.95237815e-01f, -2.72359774e-02f, 2.08747581e-01f,
  -6.30181059e-02f, -8.07296783e-02f, 2.25158334e-01f, 5.64927906e-02f, 4.61615110e-03f, -7.69342855e-02f, 3.63010913e-01f, 1.87481225e-01f, 1.51237860e-01f, 2.11311266e-01f,
  -2.47083738e-01f, 1.80639327e-01f, 2.73035109e-01f, -4.87899780e-02f, 2.05289200e-01f, 2.93982744e-01f, 3.58866304e-01f, 8.40135962e-02f, 1.91555887e-01f, -1.44221485e-01f,
  2.59403318e-01f, 1.57273665e-01f, -9.88388434e-02f, 3.65345180e-01f, -1.09516688e-01f, 1.79244682e-01f, 1.23424716e-01f, -1.01371370e-01f, -4.48231213e-02f, -3.28612477e-02f,
  7.48636127e-02f, 1.01892429e-03f, 7.34309014e-03f, -9.77612883e-02f, 8.68919417e-02f, 1.33808017e-01f, 2.95825720e-01f, 5.83273247e-02f, 9.69776809e-02f, 1.73396200e-01f,
  1.15306228e-01f, 5.08293808e-02f, -1.42489448e-01f, -1.40176222e-01f, 1.92291796e-01f, -1.69483915e-01f, 4.17298116e-02f, -1.33956179e-01f, -5.50630353e-02f, 2.93688849e-02f,
  1.22231971e-02f, 1.60005894e-02f, 1.08750463e-02f, 6.65279701e-02f, 9.78401303e-02f, -1.06475182e-01f, 1.97599292e-01f, -1.95698872e-01f, -6.98163211e-02f, 1.33186609e-01f,
  -2.98163369e-02f, 2.23075569e-01f, 7.41862357e-02f, -1.89885255e-02f, 2.36976713e-01f, 7.88421109e-02f, 2.50269771e-01f, 2.02797964e-01f, 5.78072742e-02f, -1.69437662e-01f,
  -8.27660039e-02f, 1.84448855e-03f, 2.69851983e-01f, 7.45416954e-02f, 2.25978121e-02f, -1.71896458e-01f, 5.17024584e-02f, -3.09016965e-02f, -6.36637881e-02f, -1.89302683e-01f,
  -2.44743660e-01f, -1.69446841e-01f, -5.44489250e-02f, -3.21896851e-01f, 5.49255311e-02f, -8.34368356e-03f, 3.53411674e-01f, 2.04029918e-01f, 6.42993376e-02f, 1.92133516e-01f,
  -1.70892268e-01f, 1.21837683e-01f, -1.82982594e-01f, 1.08083121e-01f, -4.67980690e-02f, 1.42878862e-02f, 1.79227501e-01f, 4.56909835e-03f, 4.84079681e-03f, -6.33279746e-03f,
  -1.06043130e-01f, 1.31380573e-01f, -2.21038654e-01f, -1.00238010e-01f, -1.31354406e-01f, -2.03771368e-01f, 7.33469948e-02f, 3.03284898e-02f, -8.48861933e-02f, -1.10544309e-01f,
  2.48707622e-01f, -1.44795207e-02f, 1.11914620e-01f, 1.15712330e-01f, 1.61319658e-01f, 5.95152155e-02f, -4.42813523e-03f, -1.31155893e-01f, -1.01920314e-01f, 8.28618109e-02f,
  -7.77508423e-04f, 7.57290982e-03f, -7.61176795e-02f, -7.91207254e-02f, 6.02034368e-02f, -4.24533524e-02f, -1.55965984e-02f, 1.36699766e-01f, 1.20763229e-02f, -1.00246646e-01f,
  -2.45311912e-02f, 8.24414045e-02f, 5.76412156e-02f, 6.90023005e-02f, 1.79420903e-01f, 1.44466653e-01f, 1.26003683e-01f, -1.73928604e-01f, -1.77457854e-01f, 2.53966391e-01f,
  6.70863837e-02f, 2.39762992e-01f, 3.77571466e-03f, 2.02950597e-01f, -7.40139931e-02f, -2.63955840e-03f, 5.40313236e-02f, -3.55780154e-01f, 1.26576141e-01f, 1.59934908e-01f,
  2.25975648e-01f, 1.90169141e-01f, 2.43405625e-02f, 1.18077792e-01f, -1.55704943e-02f, 1.28434256e-01f, -2.30562791e-01f, 1.46183342e-01f, 4.78223749e-02f, -1.91041544e-01f,
  1.19259544e-01f, 1.75076758e-03f, -5.03170490e-02f, 1.08031891e-01f, 1.67860031e-01f, 9.12020802e-02f, -2.37202659e-01f, -4.22873767e-03f, -2.11057708e-01f, 4.96511534e-02f,
  9.69093144e-02f, 5.93851358e-02f, 1.57119721e-01f, -3.06433067e-02f, -7.30813202e-03f, -1.47646978e-01f, -1.17266759e-01f, -2.78698131e-02f, 1.32823899e-01f, 1.26412595e-02f,
  1.21264823e-01f, -8.52791369e-02f, 1.19805194e-01f, -2.55354673e-01f, 2.04200447e-01f, -7.09442422e-02f, -1.67978182e-01f, 8.77296403e-02f, 1.90656886e-01f, -1.23581653e-02f,
  2.65161932e-01f, 1.23294964e-01f, -6.03122972e-02f, -2.45586485e-02f, 5.14882095e-02f, 9.27182212e-02f, 1.17807664e-01f, -8.03371891e-02f, 1.21289611e-01f, 1.62868723e-01f,
  2.05381349e-01f, -1.58410013e-01f, -1.21681623e-01f, 1.06731735e-01f, 1.41722187e-01f, 1.04373068e-01f, 1.79863408e-01f, 1.59478769e-01f, 4.88087177e-01f, 3.91921699e-02f,
  9.73795652e-02f, -1.55109629e-01f, 3.51650476e-01f, 1.85404141e-02f, 8.29997584e-02f, 4.52817976e-03f, 8.80099908e-02f, 1.03992417e-01f, 1.69564962e-01f, 1.09470665e-01f,
  3.28442198e-03f, 5.70341013e-02f, 8.83762073e-03f, -1.18617594e-01f, 5.01659065e-02f, 8.87238309e-02f, -7.11997896e-02f, -3.58137558e-03f, 1.60340533e-01f, -1.62148997e-01f,
  -7.27814287e-02f, -3.40962149e-02f, -8.38353485e-02f, -1.76391006e-02f, 1.27122998e-01f, -4.08545099e-02f, 2.04084273e-02f, -2.84705609e-02f, -4.67335768e-02f, -2.22277775e-01f,
  6.75004497e-02f, 3.23812403e-02f, -1.56090289e-01f, -7.62260333e-02f, 1.67419210e-01f, 2.32178662e-02f, 1.28532022e-01f, -8.55696127e-02f, 8.44937414e-02f, -1.54800311e-01f,
  -1.89102471e-01f, -5.43835051e-02f, 1.25962257e-01f, 9.40503553e-02f, 1.63573489e-01f, -1.97228223e-01f, 7.14801848e-02f, 1.54429227e-01f, -6.29384294e-02f, 5.75830191e-02f,
  2.78322324e-02f, -2.22025573e-01f, -7.95197487e-02f, 2.74625663e-02f, 2.68983066e-01f, -1.61442235e-01f, -3.23390849e-02f, -2.70644743e-02f, 1.20249212e-01f, -4.68135215e-02f,
  1.34491650e-02f, -1.04614921e-01f, 1.98141318e-02f, -6.13423213e-02f, -3.50114971e-01f, 3.72770429e-01f, 1.82858676e-01f, 3.82118493e-01f, -1.61369547e-01f, -1.29364029e-01f,
  -1.97790518e-01f, 9.40097198e-02f, 1.26868337e-01f, 2.17807889e-02f, -2.05646738e-01f, 8.75208601e-02f, 1.05841793e-01f, -1.88120693e-01f, 2.56852596e-03f, 6.09273799e-02f,
  6.87132627e-02f, 8.89439508e-02f, 1.03010021e-01f, -4.54485677e-02f, 1.85706511e-01f, -4.71291468e-02f, -1.85925782e-01f, 1.36018082e-01f, -4.10122275e-02f, 1.14986427e-01f,
  -1.37364328e-01f, 3.78245115e-02f, 1.28654778e-01f, 2.05144674e-01f, 3.61839868e-02f, 1.39557600e-01f, -1.08047528e-03f, -2.19949827e-01f, -5.64418249e-02f, 2.21062049e-01f,
  -2.72186339e-01f, -5.91186956e-02f, 5.31131178e-02f, -1.51661649e-01f, -1.02972910e-01f, 1.05280936e-01f, -3.45711075e-02f, -2.68131822e-01f, 6.08909922e-03f, 1.79037735e-01f,
  1.64307207e-01f, 1.10678278e-01f, 1.89043984e-01f, -1.32964507e-01f, 9.43467021e-02f, -1.23976052e-01f, -1.87119562e-02f, 9.80804116e-02f, -1.13427855e-01f, 1.23041674e-01f,
  6.91476390e-02f, -2.51035783e-02f, 2.22936884e-01f, 1.22268163e-01f, 3.68234739e-02f, 3.21483791e-01f, -3.14197019e-02f, 1.67149752e-01f, 2.98700601e-01f, 1.14876822e-01f,
  2.06912711e-01f, -6.51769787e-02f, 1.45043284e-02f, -5.26309311e-02f, 8.94203037e-02f, 1.28587931e-01f, 1.51764780e-01f, -2.27148235e-01f, -5.79220355e-02f, 7.21964017e-02f,
  -5.52711561e-02f, -1.45919904e-01f, -1.44132286e-01f, -2.10903347e-01f, 4.56592962e-02f, 3.65569047e-03f, 2.41650909e-01f, -2.09499508e-01f, -7.12804794e-02f, 9.54964310e-02f,
  -1.44217938e-01f, 1.40112653e-01f, -1.19703554e-01f, -4.01081294e-01f, 1.50528610e-01f, -3.53678882e-01f, 1.36181384e-01f, 1.87546778e-02f, -3.10846418e-01f, -1.13109937e-02f,
  2.36719139e-02f, 3.35053504e-01f, 1.35645390e-01f, 1.62947252e-01f, 1.73432156e-01f, -1.51301444e-01f, 3.46495174e-02f, -2.62560278e-01f, -2.51369327e-01f, 1.23490967e-01f,
  6.46119341e-02f, 1.80342957e-01f, 1.26277238e-01f, -4.52455208e-02f, 1.24405973e-01f, -1.31749943e-01f, 2.68689036e-01f, 1.34434447e-01f, -2.02137813e-01f, 2.33848803e-02f,
  -3.27192277e-01f, -1.72102824e-02f, 9.80037227e-02f, 5.70071489e-02f, 1.84269860e-01f, -3.17616314e-01f, -1.32916179e-02f, -4.83187959e-02f, 8.68263096e-02f, 1.20155267e-01f,
  -8.79160538e-02f, 2.30132639e-01f, -3.10256332e-01f, 2.45625123e-01f, 2.18234416e-02f, -1.48135826e-01f, 9.27767530e-02f, 4.36028242e-02f, -2.08250389e-01f, 2.51553655e-02f,
  7.12132305e-02f, -3.49578112e-02f, 1.52494863e-01f, 6.33375794e-02f, -1.34688849e-02f, -1.36896610e-01f, 9.88797992e-02f, -2.10634559e-01f, 1.75682604e-01f, 1.46988049e-01f,
  -1.53896987e-01f, -1.40151173e-01f, -6.45788088e-02f, -8.25662166e-02f, 1.90388173e-01f, 8.37583244e-02f, -1.14667080e-01f, -8.63102600e-02f, -1.97041463e-02f, 1.52886391e-01f,
  5.79137206e-02f, -6.26731813e-02f, -1.88208893e-01f, -4.96603809e-02f, 1.89868420e-01f, -3.02175790e-01f, -1.29195914e-01f, -2.47274071e-01f, -6.52772859e-02f, 1.87640190e-01f,
  -3.45593840e-02f, 6.81062564e-02f, -1.48318440e-01f, -1.98845014e-01f, -1.60506219e-01f, 4.09182813e-03f, -3.26900780e-01f, 2.17620388e-01f, -7.43823731e-03f, -4.43279386e-01f,
  1.01532891e-01f, 1.77966461e-01f, -2.77674258e-01f, -1.52645394e-01f, 1.95751697e-01f, -2.21813053e-01f, 2.35248618e-02f, 4.89842296e-01f, 1.02770433e-01f, -8.02833680e-03f,
  -1.67847320e-01f, 4.37720530e-02f, 1.55187799e-02f, -7.00578466e-02f, -4.89041209e-02f, -1.07611731e-01f, 1.30322319e-03f, 4.70775366e-02f, -2.47783363e-02f, 7.40424022e-02f,
  8.42506960e-02f, -7.21609546e-03f, -1.31080642e-01f, 2.74850093e-02f, -1.59237422e-02f, -6.42792061e-02f, -1.73513982e-02f, -5.38869761e-02f, -1.21589631e-01f, 8.06901157e-02f,
  -4.70281430e-02f, -9.72415134e-02f, 4.71250229e-02f, -1.01035237e-02f, -1.50304884e-01f, 3.55175361e-02f, 1.18514150e-02f, -9.28490907e-02f, 5.21800220e-02f, -4.87456843e-02f,
  1.00060012e-02f, -1.02905691e-01f, -1.13553204e-01f, 9.17358026e-02f, -1.02928326e-01f, -3.18612084e-02f, -1.07946351e-01f, -2.03604206e-01f, -1.19682059e-01f, -6.11675419e-02f,
  -5.12733450e-03f, -9.13513824e-02f, -1.81765124e-01f, -1.66133828e-02f, 4.31342423e-03f, 5.70909958e-03f, 1.03660502e-01f, -1.74558088e-01f, -1.39677078e-01f, 5.20071387e-02f,
  -1.39016896e-01f, -6.56837970e-02f, -3.82099114e-02f, 3.20991389e-02f, -1.07127436e-01f, -4.00552973e-02f, 6.42346218e-02f, 2.72803344e-02f, 7.60877207e-02f, -4.92200488e-03f,
  -1.07588433e-01f, -1.13936879e-01f, 7.19223320e-02f, -1.41123131e-01f, -1.04521485e-02f, 8.30886960e-02f, -8.98029283e-02f, 9.18245781e-03f, 2.47699954e-02f, -6.94428086e-02f,
  -1.43597707e-01f, 8.54580179e-02f, -6.08446151e-02f, 1.15625709e-01f, -1.06925428e-01f, -2.14754865e-02f, -8.00582021e-02f, -9.66183171e-02f, -1.69244841e-01f, -1.84377432e-01f,
  6.53504729e-02f, 1.88113027e-03f, -1.14162251e-01f, -8.22874308e-02f, 6.71852939e-03f, 9.05003175e-02f, -6.15040474e-02f, 1.80198066e-02f, -7.50358626e-02f, -9.87158492e-02f,
  6.22775368e-02f, 7.29796216e-02f, 4.16641347e-02f, -6.86197355e-02f, -1.55843839e-01f, -1.19200878e-01f, 6.20172806e-02f, -4.81182039e-02f, -3.18416096e-02f, -1.41645700e-01f,
  4.79815230e-02f, -2.11256385e-01f, -1.16528720e-01f, 1.16521139e-02f, -7.80087039e-02f, 6.05380721e-02f, -5.21563850e-02f, 4.25114408e-02f, -1.52687147e-01f, -2.04115912e-01f,
  6.82366500e-03f, 5.26053365e-03f, -6.79434836e-02f, -1.46952376e-01f, -1.57177910e-01f, 3.71771231e-02f, -9.27499607e-02f, -9.67210531e-03f, -9.00824443e-02f, 1.44383848e-01f,
  -1.79206714e-01f, -8.89867917e-02f, -7.18733743e-02f, 1.50424913e-02f, 1.38453931e-01f, -1.51679590e-01f, -1.27066940e-01f, -1.80169255e-01f, -5.38229384e-02f, -1.71431467e-01f,
  3.94090325e-01f, -1.02106117e-01f, 1.98804885e-01f, 9.35704112e-02f, -2.84021944e-01f, 1.68066502e-01f, -2.88521975e-01f, -3.59901376e-02f, -2.08959430e-01f, -9.35646370e-02f,
  -1.07858256e-01f, 3.09294816e-02f, 1.05870076e-01f, -3.26456912e-02f, 1.87602505e-01f, -1.63026556e-01f, -6.06079102e-02f, -9.90717765e-03f, -1.19734213e-01f, 2.58311391e-01f,
  -1.69079006e-01f, 3.11632697e-02f, -7.58352503e-02f, 1.16743065e-01f, 5.62764704e-02f, 1.83592230e-01f, 1.15122542e-01f, 1.76605076e-01f, -1.21893361e-01f, 2.30261892e-01f,
  -2.33194038e-01f, 1.82438940e-01f, -3.81461903e-02f, 1.71960980e-01f, 3.08237433e-01f, 2.76681542e-01f, 1.03547610e-01f, -2.83872694e-01f, 1.28762096e-01f, 1.52794540e-01f,
  -1.19127691e-01f, 1.82307571e-01f, -5.17260358e-02f, 6.94029853e-02f, 2.71945953e-01f, 2.78590955e-02f, -1.74026743e-01f, -2.56952286e-01f, -6.75119758e-02f, 3.87946181e-02f,
  9.38874707e-02f, 1.78670600e-01f, -1.00530997e-01f, 1.02629801e-02f, 1.99292358e-02f, 2.33250082e-01f, -1.39295772e-01f, -1.73835084e-02f, -3.25463712e-02f, -2.46359408e-02f,
  2.21587881e-01f, 1.71633750e-01f, -1.34018483e-02f, -1.10614888e-01f, -2.09677279e-01f, -1.70011282e-01f, -1.90329459e-02f, -3.83282959e-01f, 4.56112362e-02f, -7.14279264e-02f,
  1.62484348e-01f, -1.67650238e-01f, 1.90315753e-01f, 3.33904028e-01f, -1.97716728e-01f, 2.02272192e-01f, 4.43829857e-02f, 3.99083309e-02f, -2.16688111e-01f, 2.81741470e-02f,
  1.37420118e-01f, -1.08263142e-01f, 1.49648324e-01f, 1.54238582e-01f, 3.49671431e-02f, 2.31583968e-01f, -7.38310590e-02f, 1.88920245e-01f, -6.53035715e-02f, -1.23214005e-02f,
  -1.07530283e-03f, 9.97950956e-02f, 1.21446513e-01f, -2.17696168e-02f, -5.08104041e-02f, 2.12387014e-02f, 1.18298717e-01f, -6.04866669e-02f, -9.27116815e-03f, 5.61629906e-02f,
  9.98954987e-04f, -1.02796219e-01f, -1.10725485e-01f, -2.29065448e-01f, -1.44791156e-01f, 1.14175104e-01f, 5.96578866e-02f, 1.03135459e-01f, -4.06167731e-02f, -7.48388022e-02f,
  -1.34193063e-01f, -5.07092588e-02f, -1.15492314e-01f, -1.14358537e-01f, -1.00998171e-02f, 3.04129273e-02f, 1.48244739e-01f, -1.92601681e-01f, -3.57022113e-03f, -1.84520900e-01f,
  7.73654357e-02f, 1.29392013e-01f, 2.63571795e-02f, 1.42344221e-01f, -1.44024268e-02f, 1.02365814e-01f, -7.96448290e-02f, -2.75570154e-02f, -1.88122347e-01f, 2.22021013e-01f,
  -1.94174975e-01f, -1.09749235e-01f, 7.85801485e-02f, -1.73272818e-01f, 6.86405972e-02f, 1.22249462e-02f, 9.58712325e-02f, 5.57156242e-02f, 9.50300787e-03f, 1.81086153e-01f,
  1.13432780e-02f, -8.69115740e-02f, 3.40585858e-01f, 6.38766438e-02f, -5.19879945e-02f, 2.97680199e-01f, -6.87605217e-02f, 6.02160953e-02f, 1.86367214e-01f, -3.94607902e-01f,
  -4.74543422e-02f, 8.26259479e-02f, 8.85838941e-02f, -5.19688651e-02f, 3.40550900e-01f, -1.42828420e-01f, -1.99907809e-01f, -1.54884577e-01f, 2.60231614e-01f, -4.82555293e-02f,
  6.09554499e-02f, -5.28506972e-02f, 7.91778415e-02f, -9.63710323e-02f, 4.55692150e-02f, 1.59198493e-02f, -9.48572904e-02f, -2.43765011e-01f, 1.39430657e-01f, 1.30744934e-01f,
  -1.44562185e-01f, 1.67382941e-01f, 8.03601071e-02f, -3.25470716e-02f, -2.09630607e-03f, 1.93799987e-01f, -9.26973149e-02f, 1.23460785e-01f, 5.82263172e-02f, 2.77016647e-02f,
  4.90497164e-02f, -3.94084826e-02f, -1.08804420e-01f, -1.30882159e-01f, -8.62132534e-02f, 1.86108258e-02f, -1.19151779e-01f, 1.20054297e-02f, 9.51051638e-02f, 1.17648803e-02f,
  -1.90628618e-01f, 6.93931431e-02f, -4.68601324e-02f, -1.87451333e-01f, -3.94294232e-01f, -2.30422884e-01f, 2.64657680e-02f, 2.66906619e-01f, -2.78309938e-02f, -2.24065214e-01f,
  1.67690560e-01f, -9.99231935e-02f, 1.57740153e-02f, 7.00786710e-02f, 1.37162775e-01f, 1.24334849e-01f, -1.94506183e-01f, -1.00980878e-01f, 2.21235424e-01f, -5.85482754e-02f,
  7.80188888e-02f, -3.09710279e-02f, 1.17159523e-01f, 5.88154905e-02f, -1.20607696e-01f, 1.18500739e-01f, 1.19809382e-01f, 1.74820989e-01f, 2.54148036e-01f, 3.96964364e-02f,
  1.60000309e-01f, 1.64884314e-01f, 3.21287173e-03f, 2.38896295e-01f, 9.60999653e-02f, 2.80062389e-02f, -9.35310125e-02f, 4.35395315e-02f, 3.88241634e-02f, -1.16540670e-01f,
  -8.17271769e-02f, 3.29987444e-02f, -2.67880298e-02f, 3.24318945e-01f, -9.93851870e-02f, 8.53248164e-02f, 2.51638979e-01f, 1.07491434e-01f, -1.51161805e-01f, -1.05327152e-01f,
  -2.10975315e-02f, -1.43241584e-01f, 3.00866384e-02f, 5.46917357e-02f, 1.71202689e-01f, -2.00141072e-01f, 1.72840934e-02f, 1.22289114e-01f, 1.03386573e-01f, -4.70218286e-02f,
  -2.35291928e-01f, 1.96916729e-01f, 9.06426013e-02f, 5.25268652e-02f, 4.19645384e-02f, -1.06896803e-01f, 1.40601560e-01f, 3.06102306e-01f, 2.67352253e-01f, 9.65004936e-02f,
  1.19532287e-01f, -2.34822810e-01f, 2.73476809e-01f, 2.90568382e-01f, 1.63143929e-02f, 3.35552424e-01f, 1.59844439e-02f, 1.77890097e-03f, 1.57706037e-01f, 7.62977079e-02f,
  1.73232183e-01f, 1.64798334e-01f, 4.45028283e-02f, 2.56485641e-01f, 8.38400349e-02f, -1.40505210e-01f, 7.15379193e-02f, -5.27359731e-02f, -8.86506680e-03f, 5.00788614e-02f,
  1.71315402e-01f, 1.14150852e-01f, 7.00365081e-02f, 7.20055029e-02f, -2.01206103e-01f, -3.18506882e-02f, 7.51422718e-02f, -8.76230747e-02f, -1.33309692e-01f, -2.43335858e-01f,
  1.63865402e-01f, -1.39280617e-01f, 3.08135878e-02f, 1.42767191e-01f, -1.13681130e-01f, -8.17360058e-02f, -1.50381684e-01f, -1.05594292e-01f, 2.35384107e-02f, -2.91903406e-01f,
  2.16917489e-02f, 3.05564217e-02f, 1.29510641e-01f, 1.46156326e-01f, -1.05531253e-01f, 1.12081189e-02f, 7.98523575e-02f, -5.01953624e-02f, 6.29105344e-02f, 1.32588064e-02f,
  -4.16025184e-02f, -3.14636640e-02f, 8.14370289e-02f, -1.78475603e-01f, 1.55544534e-01f, 1.63011461e-01f, -1.06636703e-01f, 7.94641748e-02f, 4.94717546e-02f, 9.92429256e-02f,
  -4.76132557e-02f, 4.69398592e-03f, -1.06048018e-01f, 9.01914388e-02f, 3.46851684e-02f, -7.41117820e-02f, -6.13742657e-02f, -3.42957117e-02f, 3.12564820e-02f, 5.28710894e-02f,
  2.21691802e-02f, -1.49757475e-01f, -1.14952475e-02f, -5.42017519e-02f, 1.32835200e-02f, -1.77728102e-01f, -8.21099132e-02f, -1.74334161e-02f, -8.41038898e-02f, -2.22130138e-02f,
  5.50980419e-02f, 2.79003754e-02f, -3.96181457e-03f, 8.68851319e-02f, -9.44315568e-02f, 3.48291285e-02f, -4.51647397e-03f, -3.85261588e-02f, -1.05518922e-02f, 9.72726271e-02f,
  -1.21740773e-02f, -5.81217296e-02f, -9.06043313e-03f, -2.99105383e-02f, -7.97737613e-02f, 9.45581403e-03f, -1.04447715e-01f, 1.62958484e-02f, 7.03075752e-02f, -5.94069697e-02f,
  -8.66394192e-02f, -1.34769157e-01f, 7.91193768e-02f, 4.68383841e-02f, 1.15406197e-02f, -2.92437673e-02f, -4.55456674e-02f, 6.52817860e-02f, -1.09070707e-02f, -4.71788049e-02f,
  -1.35148197e-01f, -7.58984834e-02f, 4.44358438e-02f, -5.86857833e-02f, -2.10568868e-02f, -1.27957106e-01f, -7.67631009e-02f, -1.58948958e-01f, 1.28042717e-02f, 9.83955413e-02f,
  -1.19177736e-01f, -1.05515495e-01f, 1.22987248e-01f, -1.23775400e-01f, -3.13559473e-02f, 8.87152925e-02f, -4.45264652e-02f, 7.15290010e-02f, -1.10850371e-01f, -8.26224536e-02f,
  -1.64800078e-01f, 3.19604337e-01f, -1.35527387e-01f, 1.69044882e-01f, -6.09514024e-03f, 5.32931648e-02f, -7.20723495e-02f, 9.14627593e-03f, 1.67426601e-01f, 1.67159393e-01f,
  3.26447822e-02f, 2.04082638e-01f, -3.72024029e-02f, 1.04125105e-01f, -6.89978227e-02f, 2.86167096e-02f, -2.17543349e-01f, 1.00057691e-01f, 3.89980040e-02f, -1.25877216e-01f,
  2.14335591e-01f, 3.33069712e-02f, -1.35997325e-01f, 1.11845963e-01f, -1.37508463e-03f, 9.25989300e-02f, 1.54695511e-01f, -9.59478244e-02f, -1.09402994e-02f, -1.28236786e-01f,
  -2.52754893e-02f, -1.05829434e-02f, -1.88619465e-01f, 4.28875275e-02f, -2.44803816e-01f, -3.61428745e-02f, -9.01510864e-02f, 7.11329579e-02f, -5.11133149e-02f, 1.04887828e-01f,
  2.88527720e-02f, 1.47544563e-01f, -2.33756065e-01f, 1.04830392e-01f, 1.86572462e-01f, 3.01418286e-02f, -1.97794121e-02f, -2.38372833e-01f, 6.87123910e-02f, 9.20604542e-02f,
  -7.43357986e-02f, -8.44005123e-02f, -2.17082560e-01f, -1.63261183e-02f, 1.09714270e-01f, 5.88978268e-02f, 3.67822982e-02f, 3.07462760e-03f, 9.62459072e-02f, -5.92171103e-02f,
  1.44861147e-01f, 7.59700313e-04f, 2.14294698e-02f, -3.79207641e-01f, 2.16474012e-01f, 1.06842734e-01f, 3.71312439e-01f, 1.90430194e-01f, 1.42661244e-01f, 1.79422125e-01f,
  -1.23328827e-01f, -2.59243958e-02f, 2.59919614e-02f, 1.97130293e-01f, -3.25153545e-02f, -1.50842205e-01f, 1.16583243e-01f, 1.53562695e-01f, 1.58442885e-01f, -1.59984514e-01f,
  3.23068686e-02f, 2.30091244e-01f, -3.26734662e-01f, -6.71275482e-02f, -9.09752175e-02f, -1.45355716e-01f, -1.60695970e-01f, -7.76764005e-02f, 1.61807150e-01f, 4.92424034e-02f,
  -4.09074910e-02f, -2.05280542e-01f, 8.48866627e-02f, -1.93590403e-01f, 1.39786467e-01f, -9.19952393e-02f, -1.00230113e-01f, -1.47543028e-01f, -1.95826650e-01f, -2.21053492e-02f,
  2.84861177e-01f, -1.43939301e-01f, -1.09441340e-01f, -9.33388770e-02f, 1.41494453e-01f, -2.05389708e-02f, 1.52760729e-01f, 1.27252713e-01f, 2.14083329e-01f, 1.64895144e-03f,
  -1.30001038e-01f, -1.06660187e-01f, 1.27674714e-01f, -1.23795129e-01f, 2.64692932e-01f, 2.99180076e-02f, 2.53610998e-01f, -9.06655286e-03f, -2.79007524e-01f, 1.72339141e-01f,
  1.53327823e-01f, 3.06077570e-01f, 1.58921629e-01f, -9.51007307e-02f, -1.15673821e-02f, 1.14997827e-01f, 7.92515203e-02f, 4.88114923e-01f, -1.26790106e-01f, -1.86201364e-01f,
  -7.48358592e-02f, -4.11746830e-01f, 1.00960970e-01f, -1.36240423e-01f, 1.90737978e-01f, -8.52103755e-02f, -2.73387190e-02f, -1.57152906e-01f, 1.58924386e-01f, 1.25428006e-01f,
  -8.33211765e-02f, -1.14327250e-02f, 8.87383074e-02f, -1.12148910e-03f, 1.99921858e-02f, -1.47991836e-01f, 2.74651021e-01f, 2.30339959e-01f, 9.19339657e-02f, 2.01673105e-01f,
  1.23761468e-01f, 2.56163869e-02f, -8.95996541e-02f, -8.53864998e-02f, -1.87386289e-01f, -4.39000353e-02f, 7.46373460e-02f, 1.82372764e-01f, -1.17078401e-01f, 6.62570372e-02f,
  1.86345935e-01f, 1.93713516e-01f, 2.54711747e-01f, 2.59739876e-01f, 9.20811947e-03f, 1.52068824e-01f, 4.84618880e-02f, 5.24251163e-02f, 1.16368353e-01f, -8.66836980e-02f,
  1.51932195e-01f, -1.47446811e-01f, 2.48634554e-02f, -1.03567854e-01f, 7.12605715e-02f, -6.90435991e-02f, 5.39251091e-03f, 5.16165532e-02f, -2.22144708e-01f, 8.97708833e-02f,
  -1.86337605e-01f, -5.57391122e-02f, 2.97638923e-02f, -1.67678148e-01f, -4.06203009e-02f, 2.32512839e-02f, 3.01964432e-01f, 3.62990409e-01f, 5.05430341e-01f, 3.17019731e-01f,
  1.69451490e-01f, -2.05378473e-01f, 1.39866367e-01f, -6.17981106e-02f, -3.36108636e-03f, 1.01486668e-01f, 1.05816953e-01f, 1.20464623e-01f, 1.25367776e-01f, 4.37350795e-02f,
  1.35158688e-01f, -1.09816991e-01f, -1.34594008e-01f, -2.36372381e-01f, 9.11472961e-02f, -8.29523504e-02f, -1.38842553e-01f, 3.56083997e-02f, 3.57113853e-02f, 7.43579268e-02f,
  -5.39478473e-03f, 9.08387974e-02f, -2.14496285e-01f, -6.10743277e-03f, 8.74606296e-02f, 5.36590852e-02f, -1.50368184e-01f, 5.73947504e-02f, 9.78460386e-02f, -1.38344243e-01f,
  -4.07827320e-03f, -1.26537669e-03f, -9.87578407e-02f, -5.87514974e-03f, 2.26112735e-02f, 1.81918487e-01f, 1.38650239e-01f, -1.35842860e-01f, 1.91542745e-01f, -3.33023295e-02f,
  1.17783062e-02f, 1.00416958e-01f, 7.40123391e-02f, 5.80084771e-02f, 2.69869149e-01f, 8.28190744e-02f, -1.55302882e-01f, 1.10214286e-01f, -4.14783359e-01f, 8.30615833e-02f,
  1.13440100e-02f, -6.99520484e-02f, -1.21659115e-02f, 3.81212421e-02f, 9.09899473e-02f, -3.22959721e-01f, -3.69605571e-02f, -8.26731026e-02f, -1.91976458e-01f, 4.01877947e-02f,
  -1.04227595e-01f, -1.78707346e-01f, -5.44815898e-01f, -3.12550873e-01f, 1.64224193e-01f, -1.34076253e-01f, 4.26352099e-02f, -6.85612112e-02f, 3.88928086e-01f, 1.38102202e-02f,
  1.14012711e-01f, 3.20631750e-02f, -9.73085165e-02f, 7.89601505e-02f, -4.26593363e-01f, 1.12878911e-01f, 3.56829655e-03f, -1.68854877e-01f, 1.00710921e-01f, 6.27866611e-02f,
  1.06307261e-01f, -1.33584216e-01f, -1.36619985e-01f, 3.90930958e-02f, 5.59884608e-02f, -7.89798517e-03f, -1.95398346e-01f, -2.04628304e-01f, 2.45786026e-01f, 8.65098462e-02f,
  -7.58983940e-02f, -7.50017017e-02f, 1.88504621e-01f, 1.24427691e-01f, -1.28039062e-01f, -7.46468529e-02f, 1.17360093e-01f, -3.89065929e-02f, -9.98200774e-02f, -1.92970991e-01f,
  1.21281333e-01f, 1.06445819e-01f, -1.17356598e-01f, 1.79118272e-02f, -1.90360874e-01f, -7.86603019e-02f, 7.41726011e-02f, -4.78747003e-02f, 2.33149767e-01f, -2.06735432e-01f,
  -2.98964113e-01f, 7.91004151e-02f, -1.59498423e-01f, -2.14002088e-01f, 1.15542583e-01f, 2.17504799e-01f, 4.04171199e-02f, 2.60271192e-01f, -3.20622586e-02f, -5.44848025e-01f,
  -6.58221841e-02f, 9.66476575e-02f, -1.34718344e-01f, -5.85162938e-02f, -4.22423966e-02f, 4.53984775e-02f, 2.01294243e-01f, 1.23304687e-02f, 2.77712464e-01f, -7.05360398e-02f,
  1.74263537e-01f, 8.21804777e-02f, 1.33362830e-01f, 2.77701497e-01f, -8.73255655e-02f, 1.83295328e-02f, -5.38705960e-02f, 1.43813774e-01f, 5.10183312e-02f, -8.53457525e-02f,
  7.82183334e-02f, 9.87341702e-02f, -8.26315656e-02f, 5.49925491e-02f, 1.30277649e-01f, -8.13232735e-02f, 2.30332136e-01f, -7.07038790e-02f, -6.37379847e-03f, -1.99390072e-02f,
  -6.25467747e-02f, 3.05103175e-02f, 1.94450468e-01f, -3.51508893e-02f, -7.23111778e-02f, -1.68324500e-01f, -8.94145817e-02f, -2.21823558e-01f, -1.17788069e-01f, 1.17024072e-01f,
  -1.17380902e-01f, -1.01613477e-01f, 1.40393227e-01f, 8.67929235e-02f, 1.55529171e-01f, -5.05415872e-02f, 7.45906755e-02f, -8.66420120e-02f, 1.36973262e-01f, 2.83378810e-02f,
  8.85409862e-02f, 1.37260288e-01f, 2.15850607e-01f, -1.68162063e-01f, 1.75406978e-01f, 6.31655753e-02f, 9.42167565e-02f, 2.33227611e-02f, 2.25658193e-01f, -1.39339209e-01f,
  -9.44131613e-02f, 1.49051407e-02f, 1.67867392e-01f, -1.30371064e-01f, 6.58722892e-02f, -1.65721208e-01f, 1.49157673e-01f, -6.33910671e-02f, 4.47002873e-02f, 1.77238747e-01f,
  4.08800304e-01f, -1.76977664e-02f, 1.67054892e-01f, -3.44556451e-01f, 2.38521159e-01f, 6.30683079e-02f, 1.44488096e-01f, 4.17025447e-01f, 4.16500345e-02f, 2.02561319e-01f,
  1.20670378e-01f, 1.22172594e-01f, -2.02719793e-01f, 4.73324284e-02f, 1.79401040e-01f, -4.81890775e-02f, -9.50125158e-02f, 8.57534707e-02f, 8.14277530e-02f, -1.39608696e-01f,
  1.73468336e-01f, 1.89650059e-01f, -1.09875791e-01f, 1.14842109e-01f, -9.02769044e-02f, 8.56604725e-02f, -6.48049116e-02f, -1.33694310e-04f, 1.27253085e-01f, -6.89030811e-02f,
  1.06125996e-01f, -2.30987266e-01f, 4.10418399e-02f, 3.52903232e-02f, 8.61010849e-02f, -1.69667572e-01f, 8.80381614e-02f, 6.50770366e-02f, -7.89970681e-02f, -2.61800230e-01f,
  3.40366006e-01f, -2.61119097e-01f, -1.23625785e-01f, 2.86185108e-02f, 9.25437808e-02f, -7.08128512e-02f, 5.26623726e-02f, -5.75141273e-02f, 6.42108992e-02f, 3.24439257e-01f,
  -2.84442678e-02f, 8.67572129e-02f, 2.25839674e-01f, -2.65613616e-01f, -4.63402867e-02f, -6.62517548e-02f, 1.47644028e-01f, -8.03639740e-02f, -8.23565125e-02f, -1.08181741e-02f,
  -2.75629200e-02f, 7.39177838e-02f, 2.35483363e-01f, -1.09830797e-02f, 2.06437677e-01f, 1.20749421e-01f, 2.26169601e-01f, 4.03840244e-01f, -1.01556763e-01f, -2.71984696e-01f,
  -5.41806780e-02f, -2.16718733e-01f, 2.68214326e-02f, -1.15923494e-01f, 2.30506718e-01f, -3.53541528e-03f, -9.16906446e-02f, -1.64167553e-01f, 4.66687381e-02f, 1.31666864e-04f,
  -9.19817165e-02f, 9.33633596e-02f, 9.75785255e-02f, 3.78653295e-02f, 1.38148263e-01f, -6.90043941e-02f, 2.38598511e-01f, 2.36650586e-01f, -8.77105743e-02f, 2.34775588e-01f,
  2.42251813e-01f, 1.66389644e-01f, -4.29237224e-02f, 1.85050233e-03f, -1.27753347e-01f, 1.71460629e-01f, 7.17412904e-02f, 1.98775843e-01f, 7.89677873e-02f, -1.58454999e-02f,
  1.20120548e-01f, 2.34683260e-01f, 2.45312601e-01f, 2.36405376e-02f, 8.39918107e-02f, 8.36826712e-02f, 2.19128728e-01f, -3.51942480e-02f, 1.17852867e-01f, -2.33680069e-01f,
  -5.55243678e-02f, -1.47222308e-02f, -9.60957929e-02f, 4.59963046e-02f, -5.53878322e-02f, 1.85560137e-01f, 2.06108704e-01f, 1.23085767e-01f, -2.79501200e-01f, 2.19912201e-01f,
  4.51001152e-02f, -2.41778679e-02f, 1.56400248e-01f, -1.85566097e-01f, -3.91832665e-02f, -2.88405836e-01f, 2.11018920e-01f, -3.01775485e-01f, 4.17282820e-01f, 3.94358970e-02f,
  -3.71043310e-02f, -2.97413543e-02f, -8.77963528e-02f, 2.13188827e-02f, -3.07013094e-01f, 2.04946578e-01f, -4.52091582e-02f, -8.21887925e-02f, 4.96780723e-02f, 1.03041321e-01f,
  -4.98573370e-02f, -2.61006411e-02f, 9.87504050e-02f, -1.33064836e-01f, 1.17559344e-01f, 2.65723795e-01f, -1.25407343e-04f, 9.30794626e-02f, 1.32278958e-02f, 4.29243632e-02f,
  5.49969897e-02f, 2.34431148e-01f, 4.03693272e-03f, 2.23064274e-01f, -7.20024705e-02f, 6.63890392e-02f, -6.02497458e-02f, 2.62312770e-01f, 1.13284849e-01f, 1.59384757e-02f,
  2.31383428e-01f, 1.38361871e-01f, 1.84231982e-01f, -2.01388523e-01f, 9.74623337e-02f, 1.85287103e-01f, -1.14372991e-01f, 1.14439717e-02f, 2.14526385e-01f, -1.24325223e-01f,
  2.29677051e-01f, 1.16606101e-01f, -1.49240881e-01f, -2.63724744e-01f, 4.06285599e-02f, -3.03533450e-02f, 2.89669307e-03f, 1.54804125e-01f, -1.69449002e-01f, -8.78852233e-02f,
  2.73382157e-01f, -1.01363264e-01f, -1.27801090e-01f, -1.26047313e-01f, 1.60981059e-01f, -2.88235247e-02f, -6.38846606e-02f, 5.65649495e-02f, 5.92722371e-02f, -5.67702316e-02f,
  1.47527620e-01f, 1.07851684e-01f, 3.34326774e-01f, 5.92478886e-02f, -6.68853000e-02f, -2.84783900e-01f, 1.88688919e-01f, 2.19008073e-01f, 1.32022411e-01f, 3.97562861e-01f,
  -1.61842346e-01f, 1.22047924e-01f, -6.14164844e-02f, -5.12475185e-02f, 2.75140315e-01f, -6.18091300e-02f, 1.97444215e-01f, 1.93706572e-01f, 7.26682460e-03f, 1.28514633e-01f,
  1.35825798e-01f, 9.18827131e-02f, 1.59041323e-02f, 5.45031428e-02f, 1.61984488e-02f, -6.44430146e-02f, 2.80162424e-01f, -5.54574318e-02f, -3.21717888e-01f, 4.45971079e-02f,
  1.07200228e-01f, 1.63259745e-01f, -1.02438871e-02f, -2.92406946e-01f, 1.05767794e-01f, -2.69656897e-01f, -7.37522319e-02f, -1.50601000e-01f, -1.69556826e-01f, -5.92440143e-02f,
  -1.75152838e-01f, -3.96530814e-02f, 2.17921108e-01f, 1.25346109e-01f, 9.82764289e-02f, 1.21954456e-01f, -2.53487192e-02f, -4.66888882e-02f, -8.77037793e-02f, 2.77766790e-02f,
  2.37332717e-01f, 2.92692427e-02f, -6.31304607e-02f, -2.05821414e-02f, 1.52699515e-01f, -3.20636421e-01f, -5.20810448e-02f, -2.12821916e-01f, 7.64367655e-02f, 3.23093891e-01f,
  -5.75918406e-02f, -1.30194217e-01f, -2.13201195e-01f, -7.27696270e-02f, -2.20626354e-01f, -2.75604159e-01f, 6.90799132e-02f, -2.11294174e-01f, 1.68007582e-01f, 1.23035021e-01f,
  -3.06820810e-01f, -3.29047620e-01f, 1.01781741e-01f, 5.67471385e-02f, 1.84012860e-01f, 3.11899148e-02f, -3.63245681e-02f, -1.00384047e-02f, 1.08878300e-01f, -2.07641259e-01f,
  1.85162142e-01f, 1.15054660e-01f, -1.73247501e-01f, -5.12166806e-02f, 1.82848364e-01f, 7.67613668e-03f, -1.51888728e-01f, -2.06448495e-01f, -7.58313835e-02f, -4.59395200e-02f,
  1.53049305e-01f, 1.19722255e-01f, 1.71094194e-01f, 1.05930969e-01f, -3.30103785e-02f, -3.28581393e-01f, -2.27730200e-01f, 2.02813111e-02f, -1.26145393e-01f, -3.38544771e-02f,
  -1.95485115e-01f, -1.96666747e-01f, 8.28287601e-02f, -1.59528255e-01f, -5.44521697e-02f, 1.05116785e-01f, -1.29526258e-01f, 1.96037605e-01f, -5.97212173e-04f, -3.42310816e-02f,
  -8.73692557e-02f, -2.13697121e-01f, 1.40870467e-01f, -3.43234897e-01f, -3.33625004e-02f, -2.51365513e-01f, 1.61132708e-01f, -3.45157571e-02f, -3.62591296e-02f, 1.11178525e-01f,
  -8.29126462e-02f, 1.33988753e-01f, -1.75298914e-01f, 1.42329112e-01f, 8.43988284e-02f, -1.26438782e-01f, 1.20953575e-01f, 2.29932576e-01f, 2.24328432e-02f, 2.30926543e-01f,
  -9.05797333e-02f, 8.62076655e-02f, 1.60156801e-01f, -3.97052132e-02f, 1.40264779e-01f, -6.92996457e-02f, 2.29094073e-01f, -1.56825081e-01f, 1.46449164e-01f, 8.17468539e-02f,
  -1.19362414e-01f, -1.26825318e-01f, 1.74023886e-03f, 1.11459590e-01f, -1.58728123e-01f, -1.17064141e-01f, -1.23521365e-01f, -3.03816825e-01f, 4.45125848e-02f, -2.21835196e-01f,
  1.08754806e-01f, -5.75402565e-02f, -2.09881157e-01f, -6.22156933e-02f, -3.70690487e-02f, -6.42324612e-02f, -1.57063439e-01f, -4.96887147e-01f, 5.79017103e-02f, -4.64573681e-01f,
  9.52632427e-02f, 1.55685440e-01f, -1.52912095e-01f, -7.22841099e-02f, -1.11596081e-02f, 1.78493306e-01f, -7.21461549e-02f, -2.62990057e-01f, 1.99739428e-04f, -2.35400870e-01f,
  -1.31459599e-02f, -1.32249326e-01f, -4.07355994e-01f, -5.92672788e-02f, 1.50168866e-01f, 3.96202564e-01f, 1.65773585e-01f, 1.82533875e-01f, 4.63530309e-02f, -3.29280198e-01f,
  1.75280511e-01f, 2.15876549e-01f, -3.30823302e-01f, -5.20034768e-02f, -4.84219491e-02f, -6.23840168e-02f, 4.78716232e-02f, 3.42653960e-01f, -9.75088999e-02f, 1.24611773e-01f,
  -2.66265064e-01f, -5.49722463e-02f, 1.97367013e-01f, -1.26792252e-01f, -4.52077128e-02f, -1.22500651e-01f, -1.22163691e-01f, -3.73333186e-01f, -1.46563604e-01f, 3.24199088e-02f,
  2.20728874e-01f, 9.96829271e-02f, -5.55422641e-02f, -1.05095848e-01f, -1.03925347e-01f, -1.05379634e-01f, 1.03676356e-01f, 4.39926311e-02f, -9.80269089e-02f, -1.57594830e-01f,
  9.38067362e-02f, 1.08716324e-01f, -2.32361972e-01f, -2.53235754e-02f, -1.35593966e-01f, 6.75310716e-02f, 3.70591953e-02f, -1.49061054e-01f, -6.59932643e-02f, -2.24079490e-01f,
  -1.85085833e-02f, 2.22456783e-01f, -3.03128600e-01f, -3.46798338e-02f, 4.60499860e-02f, -7.67028518e-03f, 2.26007611e-01f, -2.75894180e-02f, 4.81113931e-03f, -2.19057411e-01f,
  3.98023166e-02f, -7.51035511e-02f, -1.10903330e-01f, 6.53380295e-03f, 8.21531266e-02f, -1.10810466e-01f, -1.28785551e-01f, -1.26722693e-01f, 3.77558591e-03f, -3.27756912e-01f,
  -1.30877271e-01f, 6.86182007e-02f, -3.38931710e-01f, -6.84019830e-03f, -4.31108356e-01f, 2.66988333e-02f, -1.34243250e-01f, 3.11442137e-01f, 1.27840444e-01f, -2.11449474e-01f,
  7.65896589e-03f, -4.50964689e-01f, -1.58093080e-01f, 1.89945504e-01f, 3.32520828e-02f, 1.49899721e-01f, 2.13103130e-01f, 9.13007706e-02f, 7.77011439e-02f, 1.89665541e-01f,
  -1.89973488e-01f, -2.73860861e-02f, -5.65526485e-01f, 2.13205546e-01f, -7.80892298e-02f, -2.70284832e-01f, -1.03918076e-01f, -3.32057863e-01f, -5.14134318e-02f, -2.34384136e-03f,
  2.95759797e-01f, -7.01186508e-02f, -2.41437107e-02f, 2.80891478e-01f, -2.27212813e-02f, -6.95927590e-02f, -3.35671124e-04f, -1.02517113e-01f, -2.39686936e-01f, 4.73241135e-02f,
  1.41351059e-01f, -9.95414257e-02f, 3.00833732e-01f, -1.25336379e-01f, -4.48343247e-01f, 1.65424757e-02f, -9.23916474e-02f, 1.01393573e-01f, -1.46568269e-01f, -1.17798358e-01f,
  2.62542158e-01f, -1.19708613e-01f, -1.18409924e-01f, 1.04165459e-02f, 6.93428293e-02f, -3.18363272e-02f, -9.96255204e-02f, 1.17188290e-01f, -1.74682766e-01f, 2.22528294e-01f,
  1.65240448e-02f, 3.48118953e-02f, 7.20882267e-02f, 9.38454922e-03f, -3.53614748e-01f, -4.38404344e-02f, 6.62270784e-02f, -9.81003270e-02f, -1.95019975e-01f, -3.52887139e-02f,
  -5.21703139e-02f, 1.29412740e-01f, 6.07900769e-02f, -4.30373311e-01f, -1.37354791e-01f, -2.62462020e-01f, 9.66904834e-02f, 1.00486144e-01f, -1.08610146e-01f, -5.04536703e-02f,
  -3.50651294e-01f, -1.14081735e-02f, -1.76452026e-01f, -2.96385407e-01f, 1.03681438e-01f, -3.58019978e-01f, 8.99026692e-02f, -2.58417517e-01f, 1.18697792e-01f, 3.04636329e-01f,
  1.07208729e-01f, 5.13648428e-02f, -1.76979706e-01f, -3.02366074e-02f, -3.15094888e-01f, 1.33325994e-01f, 1.61215812e-01f, -1.14912197e-01f, 1.24222696e-01f, 1.38808951e-01f,
  1.00638621e-01f, -5.67826033e-02f, -1.11256905e-01f, 1.56380478e-02f, -2.71947712e-01f, -1.03261694e-01f, 7.05168024e-02f, -1.50268078e-01f, -1.01753950e-01f, 6.68506771e-02f,
  -2.69648973e-02f, -1.96597725e-02f, 2.35070124e-01f, -5.91030531e-02f, -4.61562872e-02f, -1.30556121e-01f, 6.35350049e-02f, 1.62556171e-01f, 6.21123333e-03f, -1.71800539e-01f,
  -1.14201708e-03f, -1.56794667e-01f, -2.29018256e-02f, 1.53793961e-01f, 3.78901139e-02f, -2.48010010e-02f, 6.91243932e-02f, 1.41643107e-01f, 2.00181846e-02f, -2.84562036e-02f,
  -1.14673264e-02f, 1.34936452e-01f, -1.38798371e-01f, -1.52681068e-01f, 1.48520857e-01f, -1.76681094e-02f, -6.44734651e-02f, 1.07782096e-01f, 1.33938015e-01f, -3.52357686e-01f,
  -2.05462679e-01f, 2.10871361e-02f, 1.10172413e-01f, -7.28092864e-02f, 1.21303767e-01f, -1.68690532e-01f, 3.10287863e-01f, 1.39530763e-01f, -6.15501851e-02f, -1.67724360e-02f,
  2.81562433e-02f, 1.42024651e-01f, -1.45877048e-01f, 1.02060892e-01f, -5.92183731e-02f, -8.07047859e-02f, 1.00420706e-01f, 1.20531276e-01f, 2.33494923e-01f, -1.11674652e-01f,
  -1.21339396e-01f, -7.81539679e-02f, -1.10785387e-01f, 1.92579702e-01f, -1.33025274e-01f, -8.01689029e-02f, 1.52485460e-01f, -4.52167802e-02f, -9.22145620e-02f, 1.82328939e-01f,
  1.02416404e-01f, 1.52678996e-01f, -2.07173288e-01f, 2.56258920e-02f, -2.38917954e-02f, -2.98403371e-02f, 5.78582883e-02f, -2.47173637e-01f, 1.34239748e-01f, 1.22588605e-01f,
  1.10828310e-01f, -1.02124482e-01f, 9.27869305e-02f, 8.85856375e-02f, -2.70938277e-01f, -9.85468477e-02f, 2.13080436e-01f, -1.50365844e-01f, 8.16308707e-03f, 4.35174815e-02f,
  8.54921062e-03f, -3.06782782e-01f, -4.68048416e-02f, -2.21891142e-02f, -2.90769595e-03f, 6.13576621e-02f, -2.32012630e-01f, 1.42120095e-02f, 1.32349312e-01f, 8.20067376e-02f,
  3.21349502e-02f, -1.94279738e-02f, 9.54242051e-02f, 1.23819903e-01f, -8.11118782e-02f, 6.34660795e-02f, 1.20262921e-01f, 2.99224108e-01f, 1.63370699e-01f, 2.48370811e-01f,
  -2.62743443e-01f, 3.48561443e-02f, -2.25899309e-01f, -2.26039812e-01f, 1.99160874e-02f, -8.56434032e-02f, 2.39685223e-01f, -4.31369171e-02f, 1.65531654e-02f, 5.77678606e-02f,
  -1.98492751e-01f, -1.48248076e-01f, 1.16757192e-01f, 2.38660797e-01f, -1.88176796e-01f, -7.91475996e-02f, 7.36823529e-02f, -2.72070438e-01f, 1.44380406e-01f, -3.62713158e-01f,
  -1.21102527e-01f, 1.71662122e-01f, 4.51934487e-02f, -2.95453727e-01f, -2.42269225e-02f, -2.98104107e-01f, -2.09048111e-02f, 5.64843528e-02f, 9.06641558e-02f, -1.84129089e-01f,
  -3.89295779e-02f, 1.54640362e-01f, -1.16229625e-02f, 3.95379551e-02f, 1.74196616e-01f, -5.55844679e-02f, 9.36787352e-02f, -2.54877687e-01f, 1.92375556e-01f, -9.98973753e-03f,
  -1.05319858e-01f, -6.83433190e-02f, -8.39837864e-02f, -2.53172249e-01f, 2.80274391e-01f, 1.38435990e-01f, -7.66525865e-02f, 2.18140095e-01f, -1.16478555e-01f, -2.25881651e-01f,
  2.37517357e-01f, 2.42827877e-01f, -2.59429514e-01f, 1.59008324e-01f, 8.54543149e-02f, -1.31502658e-01f, 1.24946147e-01f, 9.47803184e-02f, 1.02205083e-01f, 2.74534881e-01f,
  -5.32927550e-02f, 1.63922161e-01f, 3.57677490e-01f, -1.19323330e-02f, 3.99711281e-02f, 3.52390343e-03f, -2.40715399e-01f, -2.53821313e-01f, -2.83907354e-01f, 1.93349689e-01f,
  -5.97645435e-03f, -2.55757838e-01f, 3.94542403e-05f, -1.62260637e-01f, -1.23023484e-02f, -1.16767911e-02f, 1.09660901e-01f, -8.10769037e-04f, -2.31888250e-01f, -1.02640986e-01f,
  -4.95312288e-02f, -9.68532730e-03f, -4.00699347e-01f, -1.23446971e-01f, -6.17523752e-02f, -7.69841969e-02f, -1.66061427e-02f, -1.10421777e-01f, -1.88453853e-01f, -4.69071828e-02f,
  -2.77546197e-02f, 1.90462932e-01f, -1.55591428e-01f, 2.83988137e-02f, -1.02012865e-01f, -4.17339206e-02f, 2.35646926e-02f, 1.88848034e-01f, 1.11208402e-01f, -1.02532528e-01f,
  1.76385000e-01f, 8.95005018e-02f, -2.54392833e-01f, -1.79688960e-01f, 8.79413784e-02f, -1.72670126e-01f, -1.41167641e-02f, -8.99415687e-02f, 1.96939707e-01f, -7.59096742e-02f,
  -7.15374723e-02f, 2.61565626e-01f, -1.31969422e-01f, -8.69360790e-02f, -4.27005559e-01f, 1.11910723e-01f, -1.06869400e-01f, 1.72462642e-01f, 1.16530046e-01f, -1.32924408e-01f,
  -4.42056172e-02f, -4.97491539e-01f, 1.28942832e-01f, 4.81378101e-02f, 1.27462700e-01f, 5.23826256e-02f, -7.92531893e-02f, 1.22358896e-01f, 2.29529858e-01f, 7.84252211e-02f,
  1.97387859e-01f, 3.68420556e-02f, 1.02955557e-01f, -2.44338959e-01f, 1.03088468e-01f, -4.72535715e-02f, 1.14694245e-01f, -5.33857942e-02f, -1.86966285e-02f, -1.77350923e-01f,
  1.96975961e-01f, 2.30992902e-02f, 1.89439669e-01f, 2.16671690e-01f, 3.31256464e-02f, -9.38703641e-02f, 9.31342766e-02f, 4.44451869e-02f, -7.61244670e-02f, -1.52761489e-01f,
  1.37303516e-01f, 3.80813237e-03f, 5.09863421e-02f, -1.07856058e-01f, 1.27915710e-01f, -2.28299260e-01f, -3.93645931e-03f, -2.89036751e-01f, -1.69008598e-01f, 1.38052195e-01f,
  2.65317416e-04f, -1.15299791e-01f, -1.61837682e-01f, 1.77851573e-01f, -2.84847841e-02f, 7.45318830e-02f, 2.16662705e-01f, 1.85302824e-01f, -6.24955259e-02f, 2.42546707e-01f,
  3.03056780e-02f, 9.70882550e-03f, -7.25815296e-02f, -1.03395082e-01f, 5.20409876e-03f, -5.74837513e-02f, 1.24281654e-02f, -1.29143000e-01f, 3.22759673e-02f, 8.98559019e-02f,
  -1.41699137e-02f, -1.02646081e-02f, -2.13130355e-01f, 2.03518732e-03f, 1.31961152e-01f, 1.99862868e-01f, 3.43871228e-02f, -1.00962944e-01f, -9.52598527e-02f, -1.98387817e-01f,
  -1.39787659e-01f, 4.11793888e-02f, 1.16554946e-01f, 6.42723888e-02f, 2.89756298e-01f, -4.60017443e-01f, 5.35410158e-02f, -4.91597615e-02f, 1.45426737e-02f, 5.31279385e-01f,
  -3.64571251e-02f, 1.17374860e-01f, -1.81398690e-02f, 1.98867813e-01f, 7.23920297e-04f, 4.16648388e-02f, 1.26282752e-01f, -3.81212332e-03f, 1.83302224e-01f, 1.09799035e-01f,
  -7.36983046e-02f, -1.05691664e-01f, -9.33757722e-02f, 1.05631642e-01f, -6.03234731e-02f, 1.65408790e-01f, 2.49286696e-01f, -5.37343398e-02f, -2.01335639e-01f, 9.07711312e-02f,
  4.66170274e-02f, -6.51147682e-03f, 1.03933588e-01f, -3.13155472e-01f, 1.19800083e-01f, -1.60948068e-01f, -2.66850945e-02f, 1.13266580e-01f, -7.54439086e-02f, -2.09581137e-01f,
  -1.39167294e-01f, -1.94790158e-02f, 2.50677131e-02f, 9.26527083e-02f, 2.04439864e-01f, 8.23597685e-02f, -8.61588418e-02f, 2.36025989e-01f, -2.18388438e-02f, -1.35566041e-01f,
  8.07177275e-02f, 3.19508940e-01f, -2.88081050e-01f, -3.51856165e-02f, 2.72815347e-01f, 1.17143588e-02f, -1.31490342e-02f, 4.04070206e-02f, 1.31684393e-01f, -2.88954973e-01f,
  -9.49540734e-02f, -8.85283872e-02f, -7.77693689e-02f, -3.58464569e-01f, -3.44246805e-01f, -8.42133611e-02f, 2.54263163e-01f, -5.21704443e-02f, -1.49982601e-01f, 7.70980418e-02f,
  -2.48255268e-01f, -1.58080086e-01f, -4.96492982e-01f, 1.61540791e-01f, -5.84061816e-02f, -9.79548842e-02f, -1.03503510e-01f, -2.62426794e-01f, 1.44383488e-02f, 9.52806696e-02f,
  7.53343031e-02f, 2.30816573e-01f, 1.73029423e-01f, -8.25352371e-02f, -5.77379614e-02f, 3.38523835e-01f, -2.01218694e-01f, 7.27289990e-02f, 1.72099665e-01f, 1.66681537e-03f,
  -9.76038575e-02f, 1.49651403e-02f, 1.65678503e-04f, -2.14125186e-01f, 2.02843435e-02f, -1.49675459e-01f, 1.89429033e-03f, 1.14591420e-03f, 1.09984064e-02f, -1.10054798e-01f,
  3.40631157e-02f, 2.35562012e-01f, -5.78957349e-02f, 1.80046186e-01f, -2.33769864e-02f, -1.24256246e-01f, -3.93670239e-02f, -1.08313754e-01f, -2.81839401e-01f, 1.87853202e-02f,
  6.98968992e-02f, 2.73809931e-03f, -3.37441355e-01f, -5.82628092e-03f, -1.97243765e-01f, -7.65217245e-02f, -2.06751265e-02f, -1.83929548e-01f, -2.78021246e-01f, 3.34811471e-02f,
  6.03620894e-02f, -4.59736362e-02f, 1.26455933e-01f, -2.32308805e-02f, -3.35333467e-01f, -2.52336860e-01f, -5.52626364e-02f, -5.46185970e-02f, -1.21633090e-01f, -1.81385815e-01f,
  -1.89095020e-01f, -3.55931465e-03f, 2.51717791e-02f, 3.40020694e-02f, -3.93112689e-01f, 4.60954849e-03f, -1.00327179e-01f, -1.19567933e-02f, 1.21515185e-01f, -9.69778895e-02f,
  1.33203333e-02f, 5.55362366e-02f, 3.98715883e-01f, 3.42176445e-02f, 1.96653213e-02f, 2.77967423e-01f, -1.45487696e-01f, -4.40713428e-02f, 8.03980455e-02f, -2.72688299e-01f,
  -3.79587412e-02f, -7.50742257e-02f, -7.49122202e-02f, 1.08659349e-03f, 2.62560040e-01f, 4.22418229e-02f, 1.44640699e-01f, -1.94274969e-02f, 1.92931607e-01f, -1.27799928e-01f,
  -2.79075112e-02f, 3.52428257e-02f, 2.26124469e-02f, -1.91844538e-01f, -2.15189427e-01f, -8.07686299e-02f, 9.57391486e-02f, -3.72842848e-02f, 7.96155035e-02f, 1.50932997e-01f,
  -2.88381040e-01f, 1.68708310e-01f, 2.37621769e-01f, -4.10676189e-02f, -8.58462006e-02f, 2.26325005e-01f, 5.30600399e-02f, 6.08698055e-02f, 1.52680039e-01f, -1.01668924e-01f,
  -8.02861154e-02f, 3.74641865e-02f, -1.10372305e-01f, -1.36907597e-03f, -9.09303948e-02f, -1.37987152e-01f, -2.36866191e-01f, 1.43202379e-01f, 1.39210746e-01f, -3.44705358e-02f,
  1.01019237e-02f, 2.60182191e-02f, 9.43391547e-02f, -7.55525008e-02f, -1.00855164e-01f, -1.56937107e-01f, -1.27728358e-01f, -2.20404834e-01f, 2.49787524e-01f, 5.32965846e-02f,
  1.89570934e-01f, 1.46718651e-01f, 1.18646160e-01f, 1.53493747e-01f, -8.20282772e-02f, 1.18278265e-01f, -1.22031949e-01f, 1.41274467e-01f, -1.57021079e-03f, -1.27520666e-01f,
  1.87159449e-01f, 1.47732690e-01f, 7.28606656e-02f, -2.04340480e-02f, -1.37532697e-04f, 2.04395443e-01f, -6.27631471e-02f, -1.32996112e-01f, -2.26013526e-01f, 3.53498012e-02f,
  7.44167045e-02f, 1.85409606e-01f, -1.32158147e-02f, 8.96457508e-02f, 2.32301056e-01f, 1.27306685e-01f, -1.03644691e-01f, 1.69338495e-01f, 6.22442104e-02f, 1.30958026e-02f,
  7.96394795e-02f, 1.93322431e-02f, 7.01826415e-04f, -1.32008687e-01f, 1.76627845e-01f, -1.87428698e-01f, -3.97530049e-02f, -8.23815539e-03f, 1.08970128e-01f, 1.29157910e-02f,
  -5.01463115e-02f, 9.81050283e-02f, -1.20306998e-01f, -7.18218982e-02f, -1.16754808e-01f, -1.26938015e-01f, 1.48041144e-01f, 3.52147184e-02f, 2.75859714e-01f, 1.75892889e-01f,
  6.82066157e-02f, 6.21512998e-03f, -1.60135344e-01f, 5.06230555e-02f, -1.18726104e-01f, -3.40476811e-01f, -2.02171445e-01f, -3.95268612e-02f, 3.63484882e-02f, -2.08056629e-01f,
  -2.74614394e-01f, 1.47109076e-01f, -5.97131886e-02f, 4.14675564e-01f, -2.74363786e-01f, -5.24060093e-02f, 4.04445417e-02f, 1.18309967e-02f, -2.58077323e-01f, -1.85310468e-01f,
  -4.88811471e-02f, 9.53776613e-02f, -7.83642754e-02f, 1.97786033e-01f, 2.28194930e-02f, -4.23262361e-03f, -2.49388274e-02f, 2.98519403e-01f, -8.98633599e-02f, 2.76780725e-02f,
  2.44002305e-02f, -1.31311774e-01f, -2.26897359e-01f, -8.99479315e-02f, 1.05896816e-01f, -2.57464528e-01f, 1.27695277e-01f, -2.06778318e-01f, 9.49023068e-02f, -8.30668025e-04f,
  4.69999854e-03f, -1.70764342e-01f, -1.35224849e-01f, 7.85718635e-02f, -9.53941271e-02f, 4.69958223e-02f, -1.58281431e-01f, -2.52656728e-01f, -2.71427304e-01f, 8.45373049e-02f,
  -1.58370167e-01f, 1.58590421e-01f, -4.06299978e-02f, -6.95229024e-02f, -2.03989431e-01f, 9.26061301e-04f, -2.43696555e-01f, -7.89441094e-02f, -2.75060199e-02f, -1.95610777e-01f,
  -2.31147125e-01f, 1.39110461e-01f, -5.66371605e-02f, -1.26479581e-01f, 1.88243300e-01f, 2.47401185e-02f, -1.49355635e-01f, -7.72854388e-02f, -8.52451473e-02f, -2.67482307e-02f,
  7.41791055e-02f, 2.94486284e-01f, 1.70556620e-01f, 4.14158590e-02f, 3.67053479e-01f, -2.43671000e-01f, 1.50348678e-01f, 9.22908485e-02f, 2.91080587e-02f, 2.55666971e-01f,
  1.43348843e-01f, 1.29252180e-01f, 1.19972914e-01f, -2.34891459e-01f, 4.23041642e-01f, -7.04468340e-02f, -1.92675069e-02f, 1.25477776e-01f, 5.83261438e-02f, -1.72457293e-01f,
  1.54532567e-01f, -1.84587687e-01f, -9.32640955e-03f, -1.73191041e-01f, 1.77156568e-01f, 1.72729149e-01f, 3.00876528e-01f, -1.00485839e-01f, 9.32500511e-02f, -3.78737301e-01f,
  1.14747286e-01f, -3.66490245e-01f, 3.15903267e-03f, 1.30811706e-02f, 8.01844969e-02f, -3.62333879e-02f, -2.75799662e-01f, 2.65080005e-01f, 5.22270985e-02f, -1.64566576e-01f,
  1.63106367e-01f, 8.87632445e-02f, -2.40792185e-01f, 1.61751971e-01f, 1.67437330e-01f, 7.20266476e-02f, 8.00342783e-02f, 4.52305019e-01f, 9.36189517e-02f, -1.31960690e-01f,
  5.56219369e-02f, -1.28186733e-01f, 2.00942494e-02f, 1.46990255e-01f, -9.73123834e-02f, 2.37238426e-02f, -4.55526188e-02f, -1.06503000e-03f, 5.19372858e-02f, 7.47430697e-02f,
  1.64790362e-01f, -4.94241193e-02f, -2.71403223e-01f, -2.10625872e-01f, 3.59623767e-02f, -4.17037122e-02f, 1.80318043e-01f, 7.50050992e-02f, 2.55969882e-01f, -1.41145438e-01f,
  8.73565616e-04f, -2.10180938e-01f, -1.43991411e-01f, 3.07131350e-01f, -7.33631626e-02f, -4.78340164e-02f, 1.48591712e-01f, 1.04797497e-01f, 6.16199970e-02f, -6.81716576e-02f,
  2.24225342e-01f, 5.82139902e-02f, -7.85857588e-02f, 1.03012711e-01f, -8.07898343e-02f, 2.94559468e-02f, -9.51214284e-02f, 1.03454784e-01f, 1.60109341e-01f, 1.18556395e-01f,
  8.12094733e-02f, -9.17770490e-02f, -5.48133850e-02f, 7.37853721e-02f, 2.44937558e-02f, 8.67376775e-02f, 6.86113685e-02f, -1.24896444e-01f, 5.72765199e-03f, 7.37647468e-04f,
  -9.72480327e-02f, 4.63466235e-02f, 6.63144663e-02f, -6.46604747e-02f, -9.26761627e-02f, 2.15979993e-01f, -4.18095291e-03f, 1.17937922e-01f, 1.55343264e-01f, 5.48203886e-02f,
  -1.01340644e-01f, 1.02005348e-01f, -1.40658654e-02f, -1.80806354e-01f, 1.56504408e-01f, 2.71751791e-01f, -6.30817190e-02f, -1.78890109e-01f, 7.54843056e-02f, 1.89285651e-01f,
  -1.94783241e-01f, 1.13635227e-01f, -1.82952613e-01f, -1.31760731e-01f, 1.72945112e-01f, -5.66508062e-02f, -2.15895042e-01f, -2.24746540e-01f, 1.43369824e-01f, 9.67935100e-02f,
  -1.61517084e-01f, 6.93567693e-02f, 1.50915775e-02f, 1.54946163e-01f, -9.13493410e-02f, 1.02025650e-01f, -8.71013664e-03f, -1.34440213e-01f, -4.74837720e-02f, -1.38373435e-01f,
  -8.69804919e-02f, 1.86650470e-01f, 1.32796213e-01f, -1.11254513e-01f, 4.18507010e-02f, -1.67398397e-02f, 1.68813929e-01f, 1.83248162e-01f, 2.10630931e-02f, 7.16402233e-02f,
  -1.15617961e-01f, 9.88351032e-02f, -1.62608735e-02f, -2.60676239e-02f, 2.56535500e-01f, -7.35666081e-02f, -5.64478077e-02f, 2.41104767e-01f, -1.61991224e-01f, 1.32239833e-01f,
  1.67238526e-02f, 1.77332442e-02f, 1.38627946e-01f, 1.00961104e-01f, 2.10736796e-01f, -2.59748846e-01f, 2.05498561e-02f, -8.42030868e-02f, -1.59265548e-01f, 2.37889752e-01f,
  -2.94160731e-02f, 2.18832076e-01f, 9.05544460e-02f, 1.66408136e-01f, -1.28319606e-01f, -2.06875592e-01f, -1.03817590e-01f, 1.46547019e-01f, -7.00962991e-02f, 9.12999734e-02f,
  -1.63674057e-01f, -8.61419290e-02f, 1.02282539e-01f, 1.16821215e-01f, 8.46700370e-02f, -1.23606257e-01f, -8.20437074e-02f, 5.35590248e-03f, -3.71955670e-02f, 8.15183520e-02f,
  3.18379760e-01f, 2.22515255e-01f, 1.56789757e-02f, 2.86862075e-01f, 2.57316858e-01f, 3.14442776e-02f, 1.03271246e-01f, 2.01707780e-01f, 1.68525577e-01f, 2.04827070e-01f,
  -1.83522120e-01f, -3.86599064e-01f, -5.45218885e-02f, 9.19139087e-02f, 1.65857166e-01f, -1.06033750e-01f, -4.35167626e-02f, 4.16671373e-02f, 3.09483092e-02f, -9.18846875e-02f,
  -9.87403914e-02f, -7.18431845e-02f, 2.34057615e-03f, 7.87403807e-02f, 2.60693699e-01f, -1.56092003e-01f, 1.02454744e-01f, -6.91282144e-03f, -8.72276316e-04f, 2.70994216e-01f,
  -4.51504700e-02f, -3.96726839e-02f, 1.01852551e-01f, -1.50174741e-02f, -1.65194925e-02f, 1.95682481e-01f, -1.43839836e-01f, 1.97179735e-01f, 1.06707208e-01f, 1.14554748e-01f,
  1.18964538e-01f, 3.89584973e-02f, 1.09167874e-01f, 9.18301791e-02f, 2.58568171e-02f, -2.57504731e-01f, 7.74380714e-02f, 7.19457492e-02f, 1.40930459e-01f, -2.20151320e-02f,
  2.21660674e-01f, -7.45615512e-02f, 1.06443249e-01f, -1.91280190e-02f, 3.33296716e-01f, 1.70694217e-01f, 2.75531150e-02f, -1.82857946e-01f, -1.48453251e-01f, 3.61336358e-02f,
  -8.34929645e-02f, 1.50189295e-01f, 1.79067940e-01f, -2.16079429e-01f, 1.46990374e-01f, -1.34590836e-02f, 8.23148340e-02f, -9.60170031e-02f, 1.38418078e-01f, -6.08245023e-02f,
  1.92632809e-01f, 2.02966660e-01f, 3.66960354e-02f, -4.80599962e-02f, -2.88691610e-01f, -2.55433917e-01f, 9.55984090e-03f, -9.39649940e-02f, 5.72152585e-02f, 2.18022820e-02f,
  4.51868214e-02f, -2.24952072e-01f, 2.17779338e-01f, 1.28352985e-01f, 9.65553336e-04f, 1.59738109e-01f, 1.28578842e-01f, 1.13181975e-02f, 1.55872166e-01f, -7.88906440e-02f,
  8.94643590e-02f, 3.96382883e-02f, 1.74702421e-01f, 1.16982318e-01f, 1.00586914e-01f, 6.01032050e-04f, -1.01554140e-01f, 5.90681583e-02f, -1.95181414e-01f, 8.91025439e-02f,
  1.17913950e-02f, 1.45840093e-01f, -2.23443396e-02f, 1.32230267e-01f, 1.09448709e-01f, 2.47329488e-01f, 1.80447683e-01f, 2.03491807e-01f, -1.06115378e-01f, 6.80484325e-02f,
  2.39945814e-01f, 2.10283726e-01f, -5.93829937e-02f, -2.24520907e-01f, -9.47667807e-02f, -6.34025335e-02f, 1.49283662e-01f, 4.03385237e-03f, 1.32525668e-01f, 4.73706648e-02f,
  2.14503586e-01f, -8.35968554e-02f, -2.34573066e-01f, 1.45194262e-01f, -8.17891136e-02f, -9.99316573e-02f, 1.78342357e-01f, 1.72334965e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  6.55476898e-02f, 1.79842055e-01f, -1.33846432e-01f, 8.25727955e-02f, 1.62855282e-01f, -7.23223239e-02f, 2.06204340e-01f, -4.78608459e-02f, 2.21744385e-02f, -4.61018458e-02f,
  -4.28161547e-02f, 3.14509347e-02f, 6.48976639e-02f, 7.53044486e-02f, 9.28270072e-02f, -1.22664593e-01f, -3.58781144e-02f, -7.81408511e-03f, 6.24134392e-03f, -8.85787699e-03f,
  1.12649649e-01f, -4.30620983e-02f, -9.73142684e-02f, 7.76520232e-03f, 1.02900481e-03f, 9.98743474e-02f, 5.96651249e-02f, 1.60070497e-03f, -1.16722271e-01f, 1.78207969e-03f,
  1.68557651e-02f, 5.07381819e-02f, 9.23590809e-02f, -9.48460624e-02f, 4.92019132e-02f, -6.04735278e-02f, 1.19074374e-01f, -1.08764127e-01f, 1.97102159e-01f, 5.02711460e-02f,
  8.84591788e-02f, 3.51033472e-02f, -2.12960932e-02f, -1.38791844e-01f, -1.43301994e-01f, 1.08027115e-01f, 1.11760087e-01f, 1.40629858e-01f, 3.49105597e-02f, 4.14534006e-03f,
  1.48025274e-01f, 3.23959440e-02f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  5.35788424e-02f, 9.64242592e-03f, -1.55366794e-03f, 1.41655818e-01f, -5.52435741e-02f, 3.08385957e-02f, -2.46091634e-01f, -1.17827982e-01f, -1.07097276e-01f, -1.21732228e-01f,
  -1.07245341e-01f, -9.55534652e-02f, 1.91549018e-01f, 1.74605370e-01f, 8.74439478e-02f, 2.91020662e-01f, 1.02685481e-01f, -4.73699197e-02f, 1.85434818e-01f, 2.45052353e-01f,
  2.06585005e-02f, 1.48638815e-01f, -1.53902546e-02f, 2.23043654e-02f, 8.74664634e-02f, -2.12777425e-02f, 1.91403076e-01f, 6.41409829e-02f, -4.33111414e-02f, 8.77006128e-02f,
  4.92291413e-02f, 1.44450754e-01f, 1.85170904e-01f, -4.38685380e-02f, 9.08030495e-02f, -6.72912821e-02f, 6.60217404e-02f, 3.98940826e-03f, 3.59210633e-02f, -4.83020619e-02f,
  1.38674811e-01f, 1.24318324e-01f, 6.42204434e-02f, -8.95484984e-02f, 2.40969568e-01f, 6.91280290e-02f, 1.67795390e-01f, -1.38877720e-01f, -1.86250001e-01f, 3.62424143e-02f,
  8.91475938e-03f, 2.97561169e-01f, -7.46019697e-03f, -2.50584930e-02f, -1.72241390e-01f, -1.54457033e-01f, 6.31503612e-02f, 1.70045763e-01f, 5.72074801e-02f, -8.67191516e-03f,
  -1.11929014e-01f, 6.33461252e-02f, -2.35718349e-03f, -3.54795679e-02f, -5.64330667e-02f, -1.68336015e-02f, -1.57871824e-02f, -5.78730088e-03f, 1.12441659e-01f, 3.57665792e-02f,
  -5.54723106e-02f, -2.13603467e-01f, -4.76745181e-02f, -2.61702448e-01f, 8.97120535e-02f, -2.87732959e-01f, 1.08625136e-01f, -1.68475136e-02f, -1.30853921e-01f, -3.80004197e-02f,
  -5.24987243e-02f, -8.93222466e-02f, 2.07896028e-02f, 1.04542628e-01f, 1.22467630e-01f, -1.91697001e-01f, -1.11974768e-01f, 7.12860450e-02f, -1.56506430e-02f, 3.08601856e-02f,
  2.71699488e-01f, 4.95199002e-02f, -1.18158162e-01f, -6.99817240e-02f, 3.84832285e-02f, -7.73892403e-02f, 1.09060086e-01f, -1.50262490e-01f, -6.36867061e-02f, -1.23655647e-01f,
  7.93495849e-02f, 3.93973328e-02f, -3.35971117e-02f, -1.59055695e-01f, 1.00805849e-01f, -7.87721798e-02f, 1.09350093e-01f, -1.23689704e-01f, 4.68281731e-02f, 1.63292930e-01f,
  1.73462376e-01f, 4.22295779e-02f, 5.47258779e-02f, -2.12051660e-01f, -6.38698637e-02f, 7.06093311e-02f, 1.13022871e-01f, 5.07872477e-02f, -3.89373153e-02f, -2.06975371e-01f,
  -7.79418796e-02f, -2.13001758e-01f, -1.46163598e-01f, -9.06510949e-02f, -4.65668179e-02f, 1.42296553e-01f, 5.36084808e-02f, 1.15438022e-01f, 1.28068738e-02f, 9.59666371e-02f,
  1.52921960e-01f, 3.71095426e-02f, -1.12462640e-02f, -1.84934959e-02f, -4.88433726e-02f, -1.19727943e-02f, -2.82487720e-01f, -1.72329932e-01f, 1.78569946e-02f, -6.44013211e-02f,
  -2.57641487e-02f, 9.51940101e-03f, -3.64515744e-02f, -8.01333934e-02f, 7.00988062e-03f, 6.85715303e-02f, 1.21157810e-01f, 3.73910032e-02f, 3.59403081e-02f, 8.45517144e-02f,
  1.40313804e-01f, 8.59636664e-02f, -7.93084651e-02f, 1.09492943e-01f, -3.41642946e-01f, -1.05441868e-01f, -5.58017381e-03f, -1.11684062e-01f, -1.28828079e-01f, -5.49687222e-02f,
  4.93225502e-03f, 5.88269457e-02f, 8.27840790e-02f, -4.78303097e-02f, 1.88070282e-01f, -8.53433609e-02f, 9.67358425e-02f, 2.30190948e-01f, 1.18818596e-01f, 7.26371333e-02f,
  -7.54387006e-02f, 3.66133824e-02f, -1.23308428e-01f, -4.31708619e-02f, -6.36570603e-02f, 8.55819434e-02f, -1.78033784e-01f, -4.79509309e-02f, -9.71776694e-02f, 1.04079843e-01f,
  1.78031310e-01f, 6.20623492e-02f, 7.32150897e-02f, -2.92684495e-01f, -7.37361461e-02f, -1.67349949e-02f, -1.10852502e-01f, 1.01439640e-01f, -2.85610016e-02f, 9.50042605e-02f,
  2.94753890e-02f, -3.39768268e-02f, -6.14861585e-02f, 7.74228275e-02f, 1.33019820e-01f, 2.24915817e-01f, -2.02675834e-01f, 4.82421294e-02f, 6.80889785e-02f, 9.53928083e-02f,
  -1.30048469e-01f, 2.93404192e-01f, -2.91925073e-01f, -4.34140339e-02f, 2.17925925e-02f, 2.02564031e-01f, -1.29722223e-01f, 2.03398615e-01f, -3.58625166e-02f, 4.14623395e-02f,
  -1.26568034e-01f, 2.98105031e-02f, -4.85193320e-02f, 6.78839236e-02f, -1.03353616e-02f, 5.57437018e-02f, -1.02834530e-01f, -7.46140704e-02f, 8.22353140e-02f, -3.43651995e-02f,
  -4.18055104e-03f, 1.26490667e-01f, -6.83619827e-02f, -5.58306836e-02f, -3.50516662e-02f, -1.73494235e-01f, 9.44097489e-02f, -2.47230083e-02f, -4.87727597e-02f, 9.02235229e-03f,
  -1.79949179e-02f, 3.08331344e-02f, 2.04834864e-02f, 1.92914605e-02f, 2.27105603e-01f, -1.28898337e-01f, -4.86444086e-02f, 8.31049159e-02f, -5.88868745e-02f, -1.18115209e-01f,
  -4.41306569e-02f, -1.15994491e-01f, 9.80802178e-02f, 1.38918370e-01f, -1.43801849e-02f, -8.08823016e-03f, -1.04790397e-01f, -1.36760637e-01f, -9.91987288e-02f, 9.40148309e-02f,
  -1.12973757e-01f, 4.06445935e-02f, 6.23033717e-02f, 5.75034805e-02f, -1.64017025e-02f, 9.27080885e-02f, -1.86214258e-03f, -4.02923338e-02f, -1.72178879e-01f, -2.20033631e-01f,
  -9.02652591e-02f, -7.22430646e-02f, 7.58544132e-02f, 3.45876142e-02f, 1.09882452e-01f, 1.31788403e-01f, 2.79469907e-01f, 2.60989547e-01f, -1.31190196e-01f, -1.06260948e-01f,
  1.47362798e-01f, -1.23124108e-01f, 7.82456547e-02f, 2.55959313e-02f, -1.35007054e-01f, -1.80999711e-01f, 8.58500898e-02f, -1.13796309e-01f, 5.74181639e-02f, -1.00693986e-01f,
  -7.48640299e-03f, -1.99337453e-02f, -1.27187923e-01f, 4.43247296e-02f, 8.99054781e-02f, -1.44796550e-01f, -1.26430482e-01f, 1.69838279e-01f, -1.74185067e-01f, 2.69326437e-02f,
  -5.66010103e-02f, 9.71259624e-02f, -1.82453338e-02f, -1.17773369e-01f, -2.54149791e-02f, 2.43607741e-02f, 5.31898886e-02f, 4.43032756e-02f, -1.66990563e-01f, 6.07888550e-02f,
  2.04400331e-01f, -1.10207491e-01f, 6.18428774e-02f, -2.59739876e-01f, 4.46007222e-01f, 1.92128301e-01f, -3.44400965e-02f, -1.11489445e-01f, -4.45502251e-02f, -9.79945511e-02f,
  1.67713240e-01f, 2.35843342e-02f, 4.75926474e-02f, -5.33094481e-02f, -8.54038745e-02f, 7.76045695e-02f, -1.45056834e-02f, -1.42404241e-02f, 2.15217266e-02f, -4.64398526e-02f,
  -5.17307781e-02f, -1.29448786e-01f, 2.83617098e-02f, 2.21418723e-01f, 2.24955335e-01f, 1.86984554e-01f, -7.50499070e-02f, -6.02913052e-02f, 1.41056806e-01f, 2.22796157e-01f,
  3.20195816e-02f, -2.94011757e-02f, -9.09086913e-02f, -1.85087517e-01f, 4.32235897e-02f, 5.95451780e-02f, 1.01838373e-01f, -2.39714161e-02f, 4.93331626e-03f, -2.12952588e-02f,
  -5.67493998e-02f, -1.18647106e-01f, 4.48831953e-02f, 4.08693701e-02f, -7.46481493e-03f, -1.48236856e-01f, 1.15198575e-01f, -1.45052835e-01f, -7.59715959e-02f, 1.50273457e-01f,
  -7.64233433e-03f, 1.14326738e-01f, 1.26757696e-01f, -2.09143348e-02f, 9.19291824e-02f, 2.05744561e-02f, 3.55603583e-02f, -1.73269883e-01f, 3.25478017e-02f, 1.51505962e-01f,
  8.26494247e-02f, 2.27306094e-02f, -1.46734402e-01f, 2.02532098e-01f, 1.31935582e-01f, -1.12959862e-01f, -4.46463786e-02f, 8.49059150e-02f, 8.43575746e-02f, -1.85643405e-01f,
  5.17349727e-02f, 1.53407246e-01f, -1.68661639e-01f, -2.39120424e-01f, 2.88497470e-02f, -2.55246401e-01f, 4.65456806e-02f, 9.26937014e-02f, -1.17762551e-01f, -4.91307974e-02f,
  -6.58694431e-02f, 2.16354400e-01f, -1.09720111e-01f, -1.46035731e-01f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.46293148e-01f, 1.60522848e-01f, 3.72324660e-02f, -1.10773720e-01f, -2.52633005e-01f, 1.85085043e-01f, 1.23715557e-01f, 7.94326887e-02f, -2.12044895e-01f, 4.75387961e-01f,
  -3.03647548e-01f, 2.99865186e-01f, 8.38522539e-02f, 1.76052719e-01f, 1.66826010e-01f, 2.51662642e-01f, 1.92944750e-01f, 1.08414714e-03f, -1.18613794e-01f, -1.18348882e-01f,
  -1.22129373e-01f, 7.86103010e-02f, -1.56154335e-01f, 6.98035285e-02f, 1.75067261e-01f, -4.70650680e-02f, -3.32191866e-03f, -2.61064786e-02f, -1.54787451e-01f, 3.65210980e-01f,
  2.19742227e-02f, -1.78498745e-01f, 2.24668488e-01f, -1.36078104e-01f, 6.32021800e-02f, 6.75083026e-02f, -5.58499172e-02f, 1.02728054e-01f, 8.64965618e-02f, -1.11568766e-02f,
  -1.69197664e-01f, -7.95279369e-02f, 2.33474880e-01f, 5.17196320e-02f, -1.57186929e-02f, 7.16736317e-02f, -1.84778944e-01f, 1.80499330e-01f, 1.18637696e-01f, -1.59291744e-01f,
  2.26825371e-01f, -3.09762023e-02f, 2.53320724e-01f, 9.19304043e-03f, -1.13648638e-01f, 1.55244917e-02f, -1.21071227e-01f, 1.26318201e-01f, 7.62642771e-02f, -1.04671501e-01f,
  1.18967846e-01f, 9.51119363e-02f, 7.33478367e-02f, 9.14192274e-02f, 9.61451083e-02f, 5.27832843e-02f, -3.63098830e-02f, -1.12817578e-01f, -9.40251276e-02f, -2.59611271e-02f,
  4.75136861e-02f, 5.35973199e-02f, -2.22424969e-01f, -1.58359468e-01f, 1.97269022e-01f, -2.74284184e-01f, 1.83301792e-01f, -1.02029897e-01f, 1.32746994e-01f, -5.43594696e-02f,
  -1.66350286e-02f, 2.98077483e-02f, -1.17844313e-01f, 1.54519062e-02f, 1.45203054e-01f, -6.77387342e-02f, -1.05453879e-01f, 1.83054104e-01f, -1.12896085e-01f, 1.85527846e-01f,
  5.59472255e-02f, 2.23953323e-03f, 7.22022280e-02f, 2.82034948e-02f, -4.11653519e-03f, 2.71434337e-01f, -2.52411086e-02f, 1.96410343e-01f, 8.99619386e-02f, -4.73841988e-02f,
  1.00588508e-01f, -2.41955146e-02f, -5.44801094e-02f, -2.15784665e-02f, 8.02514553e-02f, -8.86534620e-03f, -1.18729316e-01f, -1.09170452e-01f, 8.81919935e-02f, 4.95962501e-02f,
  2.80912966e-01f, 2.11745143e-01f, 3.97230953e-01f, -1.23648629e-01f, -2.23795511e-02f, 8.81675482e-02f, 3.18486333e-01f, 6.71664029e-02f, 7.04042464e-02f, -3.47028941e-01f,
  2.88070291e-01f, -1.05545826e-01f, -3.88606519e-01f, 3.89891028e-01f, -1.89491957e-02f, -6.66268393e-02f, 8.79732668e-02f, 2.17131544e-02f, 1.28260218e-02f, -8.77124444e-02f,
  -1.19111769e-01f, 4.59957980e-02f, -1.10237196e-01f, 6.64915293e-02f, -1.06617644e-01f, 1.31675079e-01f, -8.16170946e-02f, 1.01349186e-02f, -9.45701972e-02f, -4.63005714e-02f,
  -7.42834508e-02f, 9.69589204e-02f, -5.78395166e-02f, -5.89760393e-02f, -1.23112783e-01f, -6.61469698e-02f, -9.13512148e-03f, -3.72946747e-02f, -1.09936841e-01f, -2.14224774e-03f,
  -2.68575530e-02f, -8.63012820e-02f, 5.66190705e-02f, 3.06889042e-02f, -6.32783100e-02f, 4.27514613e-02f, 6.64079189e-03f, -8.03047717e-02f, 6.12185784e-02f, 6.78913072e-02f,
  -4.79302295e-02f, -5.34228347e-02f, 1.39721334e-02f, 8.19419250e-02f, 1.50563465e-02f, -1.10292383e-01f, 1.14068791e-01f, -5.43408953e-02f, -1.01085708e-01f, -9.34802368e-02f,
  6.89028725e-02f, -2.59631928e-02f, -1.47536352e-01f, 2.47897338e-02f, 2.76508927e-02f, -1.24534175e-01f, -1.10714272e-01f, 2.91615818e-02f, -1.03646286e-01f, -1.03828326e-01f,
  -6.67535840e-03f, 3.81355872e-03f, 2.14965157e-02f, -8.85341167e-02f, 4.30512019e-02f, -5.50345965e-02f, 1.83079876e-02f, -2.49899435e-03f, -1.45181924e-01f, 4.67700809e-02f,
  -9.34279710e-02f, -3.98886688e-02f, -8.17190483e-02f, -1.93187594e-01f, -4.78814443e-04f, -1.26113296e-01f, 7.51819238e-02f, -1.19883008e-01f, 3.03150322e-02f, 1.61065236e-01f,
  1.32735670e-01f, 1.44915506e-01f, 2.44753454e-02f, -2.00974032e-01f, -1.09760254e-03f, -2.15664711e-02f, -2.91669499e-02f, -1.54049695e-01f, -6.95119575e-02f, -3.15654874e-02f,
  7.57321343e-02f, -6.82173073e-02f, 4.93428446e-02f, 1.68679021e-02f, 6.03701547e-02f, 4.24364805e-02f, -1.73760220e-01f, -2.68725455e-02f, -7.37897977e-02f, -3.13082002e-02f,
  -2.11388201e-01f, 9.87688527e-02f, -2.34135110e-02f, 8.05604234e-02f, 9.25968215e-02f, -4.11713943e-02f, -1.20145380e-01f, -5.06018996e-02f, -9.24510434e-02f, -6.34794682e-02f,
  7.94892535e-02f, -4.57302183e-02f, 9.84662492e-03f, 6.33508042e-02f, -6.83690459e-02f, -4.33667265e-02f, 7.82583728e-02f, 9.54740569e-02f, -9.36830044e-02f, 5.75688742e-02f,
  4.47285064e-02f, -1.43069774e-01f, 4.43461537e-02f, 7.36542195e-02f, -1.07557796e-01f, -4.24776711e-02f, 4.55092551e-04f, -1.19729154e-01f, 2.23222479e-01f, -1.17455550e-01f,
  1.02694586e-01f, 6.81940615e-02f, 1.40752643e-01f, 9.90366340e-02f, 1.75468355e-01f, 3.40683721e-02f, -1.83394715e-01f, -3.71284187e-01f, 2.08112206e-02f, -3.19821239e-01f,
  3.27173881e-02f, -1.29107296e-01f, 1.93587586e-01f, -2.79174268e-01f, 2.06394508e-01f, -7.85165280e-02f, 1.87617078e-01f, 1.49915367e-01f, 1.38185486e-01f, -1.88644692e-01f,
  2.53744155e-01f, -1.88044161e-01f, -4.08634655e-02f, -7.06546977e-02f, -4.54572067e-02f, 2.01771751e-01f, 2.48697307e-02f, 4.05355841e-02f, -3.84994559e-02f, 1.04085607e-02f,
  1.20763391e-01f, -3.73858400e-02f, 8.92260075e-02f, 2.64825001e-02f, 3.12466118e-02f, 3.00866179e-02f, 1.88976511e-01f, 3.16572517e-01f, 1.60824522e-01f, -7.93773532e-02f,
  8.04682076e-02f, 4.64552008e-02f, 8.18429440e-02f, -1.71255365e-01f, -5.56826517e-02f, 8.96646306e-02f, -6.54485077e-02f, 1.09084941e-01f, 2.70057525e-02f, -1.16410693e-02f,
  4.15219031e-02f, -2.66028374e-01f, 9.76536497e-02f, -1.09750427e-01f, 1.72463208e-01f, 1.23713180e-01f, 6.08756654e-02f, 7.22036213e-02f, -2.35622957e-01f, -7.86704347e-02f,
  2.44397283e-01f, -1.27962483e-02f, 1.46443948e-01f, 9.15096104e-02f, 3.49619351e-02f, 1.61722869e-01f, -9.92364902e-03f, -6.37166649e-02f, -1.99286446e-01f, -1.31405607e-01f,
  -1.39018178e-01f, -1.48433838e-02f, 1.49746323e-02f, -2.18080238e-01f, -2.17698693e-01f, -2.60789972e-02f, 2.99142569e-01f, -2.48938188e-01f, -2.86571622e-01f, 1.98254928e-01f,
  -6.08377717e-02f, 1.09385289e-01f, 3.85132015e-01f, 1.28946468e-01f, 2.39790216e-01f, 1.87235504e-01f, -7.47612789e-02f, -6.19172566e-02f, -2.85961837e-01f, 2.40239754e-01f,
  -2.83912748e-01f, 9.60895568e-02f, 7.86923543e-02f, -2.54418463e-01f, -2.74955649e-02f, -9.08710808e-02f, 1.81600899e-01f, 1.55038284e-02f, -4.26015444e-02f, 1.48461193e-01f,
  9.62441415e-02f, 1.55931324e-01f, 1.74868226e-01f, -9.32952538e-02f, 8.86442289e-02f, 1.85557812e-01f, 3.93765755e-02f, 9.02891904e-02f, -2.18277931e-01f, 2.41942242e-01f,
  -5.85261248e-02f, -7.92292804e-02f, -8.28800276e-02f, -8.13265592e-02f, -4.21637297e-02f, -6.54199198e-02f, 1.28389195e-01f, 7.84502774e-02f, 1.80979893e-01f, 1.51232323e-02f,
  -1.44279659e-01f, 3.54890019e-01f, 1.32538900e-02f, 3.36260870e-02f, 7.50721693e-02f, -1.34276487e-02f, 2.02521086e-01f, 5.16696312e-02f, 8.19820017e-02f, -1.31548107e-01f,
  -3.11844442e-02f, 1.37889922e-01f, -4.08773124e-02f, 1.69620160e-02f, 1.35242820e-01f, 2.23124459e-01f, 7.63924941e-02f, 3.50822806e-01f, -6.37415573e-02f, 3.35748643e-01f,
  -8.62894878e-02f, 2.90249556e-01f, 3.40699255e-02f, 2.40985200e-01f, -4.40538749e-02f, 9.99676064e-02f, -2.63745129e-01f, 1.66678280e-01f, -1.70276180e-01f, -2.93048881e-02f,
  1.78887025e-01f, 5.63013852e-02f, 1.15606286e-01f, -6.76918402e-02f, 8.36758539e-02f, 7.22392499e-02f, 7.51479045e-02f, 2.25130051e-01f, 9.99696478e-02f, 1.85785256e-02f,
  -1.19286768e-01f, 2.97669563e-02f, -4.31837365e-02f, 7.68254772e-02f, 9.00345519e-02f, -2.50872165e-01f, 4.99887653e-02f, -1.05524085e-01f, -1.03701554e-01f, -1.95629615e-02f,
  1.02546327e-01f, 4.72317077e-02f, 2.13637650e-01f, -1.24806963e-01f, 1.35531470e-01f, 2.38145381e-01f, 1.17737927e-01f, 2.00260848e-01f, 1.61682829e-01f, 1.80108070e-01f,
  -3.50428313e-01f, -2.00439692e-01f, -2.33392060e-01f, -3.13477814e-02f, 1.45380348e-01f, -2.77937144e-01f, 5.50973788e-02f, 9.26009193e-02f, 1.20550180e-02f, 2.35472530e-01f,
  -2.87973642e-01f, 2.36600071e-01f, 9.59751233e-02f, -1.03161886e-01f, 5.87266609e-02f, -8.91823620e-02f, -4.09958772e-02f, 3.51790115e-02f, 1.53393537e-01f, 2.36675084e-01f,
  8.90327320e-02f, 2.22935155e-01f, 3.26462835e-01f, 1.67899162e-01f, -1.45944759e-01f, 1.24054581e-01f, -3.12530547e-02f, -4.16886583e-02f, 1.94419637e-01f, -1.90029532e-01f,
  -8.99969786e-02f, -2.10286696e-02f, -2.34230105e-02f, 1.51546806e-01f, 2.70302296e-01f, -1.99366249e-02f, 1.91881552e-01f, -9.15626809e-03f, 2.37156242e-01f, 3.87951429e-03f,
  2.89624054e-02f, 1.14128791e-01f, -1.16325386e-01f, 1.85317338e-01f, 1.26097217e-01f, 2.07362801e-01f, -2.26708334e-02f, 2.96395458e-02f, 4.24267575e-02f, -1.01841241e-01f,
  -2.48431012e-01f, 1.85790583e-01f, 1.54720144e-02f, 3.06499396e-02f, 8.99044052e-02f, -1.19243547e-01f, 7.55341304e-03f, -8.20581317e-02f, -2.21493971e-02f, 1.81969672e-01f,
  -1.32019863e-01f, 1.54179223e-02f, 5.48199937e-02f, -1.10197090e-01f, 1.29087687e-01f, 6.81971684e-02f, 2.80557245e-01f, -1.62757672e-02f, 5.91337569e-02f, 4.93086241e-02f,
  1.37854144e-01f, -3.36414278e-02f, 1.03948057e-01f, -5.81966154e-02f, -4.19326983e-02f, -7.95914233e-02f, 8.25009421e-02f, 1.61217883e-01f, -1.33715853e-01f, 3.05258296e-02f,
  1.22218348e-01f, -1.06019713e-01f, -1.21134162e-01f, -1.89586908e-01f, 5.33989035e-02f, -9.25798938e-02f, 1.36918321e-01f, 2.72975750e-02f, 1.03753939e-01f, -1.31979749e-01f,
  1.08215190e-01f, -4.72409697e-03f, 7.99295455e-02f, 8.15420672e-02f, 1.06430084e-01f, -1.39866635e-01f, 2.33819485e-01f, -2.35605597e-01f, -7.28691965e-02f, 1.28190285e-02f,
  -1.90485030e-01f, 7.60669038e-02f, 2.06233785e-02f, 3.77561636e-02f, -8.01747516e-02f, -4.22030967e-03f, -1.95836741e-02f, -1.06089033e-01f, -1.14747293e-01f, -1.22820335e-02f,
  1.18220143e-01f, 8.99209976e-02f, 1.96340516e-01f, 3.65946479e-02f, 1.73190325e-01f, -1.38980195e-01f, -6.49187788e-02f, 1.22389667e-01f, 9.69226137e-02f, 4.48315553e-02f,
  9.31692570e-02f, 2.39215586e-02f, 1.56801611e-01f, 1.71701349e-02f, 1.09583683e-01f, -5.51721205e-05f, 6.78568259e-02f, 6.08877242e-02f, -2.75770724e-01f, 4.11158875e-02f,
  1.39717638e-01f, 1.80266708e-01f, 4.11360376e-02f, -2.44117901e-01f, -2.98546582e-01f, 3.61325219e-02f, 1.74327627e-01f, 2.67300922e-02f, 1.09580331e-01f, -5.63757643e-02f,
  3.15800905e-02f, 7.86235929e-02f, 9.12424549e-02f, 1.37681723e-01f, 7.07343668e-02f, 1.98170185e-01f, 1.31679535e-01f, -1.75236762e-01f, 1.13278970e-01f, -4.15956080e-01f,
  -8.34356099e-02f, -3.58760059e-01f, 2.79983759e-01f, -1.93375126e-01f, 7.64156505e-02f, -1.91528410e-01f, 1.96588799e-01f, -2.49858871e-01f, -1.13563456e-01f, 2.03430980e-01f,
  4.17471528e-02f, -1.20707989e-01f, 2.47950777e-02f, -5.37186787e-02f, 7.62251765e-02f, 7.60132670e-02f, 6.55978173e-02f, 5.29605858e-02f, 1.43016458e-01f, 1.09706461e-01f,
  -1.24881946e-01f, 1.32050991e-01f, -1.92382559e-01f, 2.74706092e-02f, -2.96897814e-02f, -3.65438014e-01f, -2.57458678e-03f, -1.13335334e-01f, -8.30951631e-02f, -1.00969478e-01f,
  -6.41263872e-02f, -9.23076943e-02f, 9.02033597e-02f, 6.61297962e-02f, 2.13518202e-01f, 6.14236519e-02f, -2.73877941e-02f, 1.80047303e-01f, 6.36035353e-02f, -1.42591998e-01f,
  7.84015656e-02f, -1.94533437e-01f, 1.13025963e-01f, -1.51550159e-01f, -2.22743317e-01f, 1.36974096e-01f, -1.47718459e-01f, -5.60239814e-02f, 8.43943655e-02f, -1.17232399e-02f,
  1.43209159e-01f, -3.23215201e-02f, -6.13712966e-02f, -3.51719111e-02f, 1.52577221e-01f, -1.15724094e-01f, 1.47480471e-02f, -8.53771716e-02f, 1.28786162e-01f, -6.44620880e-02f,
  2.05802113e-01f, 1.25080302e-01f, 2.53026783e-01f, 3.36287618e-01f, 6.51930124e-02f, 9.93559510e-02f, -8.38761032e-02f, 9.52697396e-02f, -3.30176443e-01f, 5.79073951e-02f,
  2.01341268e-02f, -5.00015557e-01f, -1.22253634e-01f, 2.06321195e-01f, 7.29491040e-02f, 1.41212031e-01f, 1.89041883e-01f, 1.07815742e-01f, 2.67136488e-02f, -6.59628510e-02f,
  1.83188617e-01f, 1.01432107e-01f, 1.45261228e-01f, 2.07758740e-01f, -6.72883317e-02f, 6.71844408e-02f, -2.11512968e-01f, 4.88551566e-03f, -1.36575311e-01f, 1.29711768e-02f,
  8.21487829e-02f, -2.42124587e-01f, -7.77672231e-02f, -1.06441669e-01f, -3.54090855e-02f, -1.68996274e-01f, 6.40942678e-02f, 6.47940338e-02f, 1.57571971e-01f, 1.16251275e-01f,
  9.21844020e-02f, 1.72561593e-02f, -7.86399189e-03f, 4.85158749e-02f, -2.02985600e-01f, 3.42963070e-01f, -4.30308543e-02f, 2.98765957e-01f, -2.56193113e-02f, -5.90879247e-02f,
  -3.37203071e-02f, -5.32574207e-02f, 3.06154281e-01f, 2.87089258e-01f, -1.40001774e-01f, 1.68697350e-02f, -2.33437214e-03f, 4.40684594e-02f, -3.64137739e-02f, -2.29781438e-02f,
  -6.68573007e-03f, -1.26749903e-01f, 1.94012791e-01f, 5.15729282e-03f, -6.16401471e-02f, -1.76610649e-01f, -1.72324777e-01f, 1.27692625e-01f, 1.70318261e-01f, 2.12793842e-01f,
  -2.85310119e-01f, 5.00633344e-02f, -4.78799902e-02f, -4.42054212e-01f, 1.62850320e-01f, -3.99458967e-02f, -1.26203448e-02f, -8.59173834e-02f, 7.41205588e-02f, 1.69090822e-01f,
  -2.12774370e-02f, -4.40011211e-02f, 1.17037989e-01f, 2.40278840e-01f, 4.20911722e-02f, 5.77184223e-02f, -4.43831049e-02f, -2.65105478e-02f, -1.04817279e-01f, -1.26474440e-01f,
  3.82433355e-01f, -8.34477618e-02f, 9.44343358e-02f, -1.92450479e-01f, 4.32648286e-02f, 1.74438342e-01f, 2.20825095e-02f, -5.95391309e-03f, -3.51064913e-02f, -8.48791376e-02f,
  2.08595991e-01f, -2.41634429e-01f, 2.21540239e-02f, -1.41519874e-01f, -8.81002769e-02f, 3.72101143e-02f, -2.21993253e-01f, 4.10353467e-02f, 1.49381146e-01f, -2.36184239e-01f,
  6.89566806e-02f, -2.63113141e-01f, -1.16403297e-01f, 5.51045500e-03f, -2.76882742e-02f, 8.54797810e-02f, -1.64627731e-02f, -4.45354208e-02f, 1.11162879e-01f, -2.31404379e-02f,
  -6.19064197e-02f, 1.57529607e-01f, -1.70033321e-01f, -2.17420399e-01f, -1.49401218e-01f, -2.28933856e-01f, -6.47103041e-02f, -2.40168363e-01f, 3.37973565e-01f, 3.47340226e-01f,
  7.07118660e-02f, 3.42459410e-01f, 5.01664914e-02f, 1.43494919e-01f, -2.53095210e-01f, -8.42954889e-02f, -5.31184301e-02f, 1.19435906e-01f, -7.48739094e-02f, -2.96468567e-02f,
  2.58181542e-02f, 1.13236353e-01f, -2.30290905e-01f, 1.54488608e-01f, 2.46612117e-01f, 7.69598037e-02f, 2.24343926e-01f, 1.10157663e-02f, 2.90922225e-01f, 4.76819202e-02f,
  9.27612484e-02f, -4.94080447e-02f, 5.12590818e-02f, 1.10736340e-01f, 2.51787990e-01f, -3.60756926e-02f, -2.25909296e-02f, 1.78037062e-01f, 7.54579380e-02f, -1.65936992e-01f,
  6.48124069e-02f, 2.35609040e-02f, -7.28412643e-02f, -1.12947278e-01f, -8.74191672e-02f, -4.62944508e-02f, -3.58357169e-02f, -3.16227376e-01f, 6.81351579e-04f, 1.08976811e-01f,
  3.51666361e-02f, -8.34581777e-02f, 1.32587194e-01f, -4.18292806e-02f, 1.11290149e-01f, -3.65847014e-02f, -1.65095136e-01f, -5.87631064e-03f, 1.28338393e-02f, 2.54403874e-02f,
  1.69616506e-01f, -1.38640121e-01f, -2.01498568e-01f, 1.36104554e-01f, -2.94746399e-01f, -2.53959056e-02f, 6.11679815e-03f, -5.07179908e-02f, 1.29490960e-02f, -3.51263657e-02f,
  2.48443618e-01f, -1.86164258e-03f, 1.19066365e-01f, 9.62250773e-03f, 1.28229201e-01f, 7.78244361e-02f, 3.37287694e-01f, -1.97844222e-01f, -3.88049304e-01f, -3.84172916e-01f,
  1.91208541e-01f, -4.98178780e-01f, 2.07631215e-02f, -7.97782559e-03f, 1.48750275e-01f, 1.54264152e-01f, 3.70941870e-02f, 1.41231865e-01f, -8.64639506e-02f, 9.93257686e-02f,
  4.67880405e-02f, 2.44561896e-01f, 1.82370186e-01f, -1.01857252e-01f, 4.35362160e-02f, 4.67172172e-03f, 1.03008196e-01f, -6.69007748e-02f, 3.83142322e-01f, -7.69399554e-02f,
  1.69355005e-01f, -4.15199921e-02f, 1.80575382e-02f, 2.10080817e-01f, 5.04324995e-02f, 1.86662555e-01f, 2.26646289e-02f, 2.34910809e-02f, 5.21724559e-02f, 1.46500140e-01f,
  -3.77817750e-01f, -1.19801216e-01f, -1.80057380e-02f, -1.42423734e-01f, -3.90045270e-02f, -8.39808285e-02f, 1.70338005e-01f, 2.27345265e-02f, -1.85340032e-01f, -2.67246604e-01f,
  2.95603760e-02f, 5.25640277e-03f, -1.84153184e-01f, -2.76421639e-03f, -2.38602325e-01f, 9.81213897e-02f, -8.08071792e-02f, 4.91104722e-02f, 2.44635820e-01f, -1.75259486e-01f,
  9.18916836e-02f, 8.38631019e-02f, 2.02332344e-02f, -1.49936959e-01f, 5.50651960e-02f, 2.16855839e-01f, 1.43647417e-01f, 4.48853850e-01f, 8.51809084e-02f, 1.15207493e-01f,
  -2.38569260e-01f, 7.67608285e-02f, 6.81777969e-02f, -1.95957813e-02f, 1.36659592e-01f, -4.84664179e-02f, -1.53033122e-01f, -3.64837140e-01f, -1.42081007e-01f, 2.19034076e-01f,
  1.23018203e-02f, 4.74058762e-02f, 7.02426508e-02f, 5.91776073e-02f, 2.54388660e-01f, 3.08038876e-03f, 7.19292387e-02f, -1.69625506e-01f, 1.39889643e-01f, 2.72743814e-02f,
  1.08701780e-01f, 2.70114303e-01f, -4.17664587e-01f, -5.95158748e-02f, 7.53130624e-03f, -9.35524926e-02f, 9.78028253e-02f, -1.12097584e-01f, -2.22270489e-02f, -1.45663843e-01f,
  -2.89406590e-02f, 1.27063915e-02f, -5.50834090e-02f, 2.86611468e-01f, 2.17521176e-01f, 1.46798804e-01f, 6.45800456e-02f, -4.93302867e-02f, 1.53623611e-01f, -7.97630772e-02f,
  -2.53102303e-01f, 3.74568552e-01f, 1.58012196e-01f, 8.85922313e-02f, -3.78294200e-01f, -8.99650976e-02f, 3.74981165e-02f, -1.05559334e-01f, 2.06827745e-01f, 1.86733723e-01f,
  -5.62089272e-02f, -1.03512123e-01f, -6.71795309e-02f, -5.71868755e-02f, 1.51220471e-01f, 1.55686110e-01f, 5.79883195e-02f, -1.48995519e-01f, 2.21841380e-01f, 1.25910074e-01f,
  1.87754139e-01f, 4.41885404e-02f, -4.84505817e-02f, -1.59657612e-01f, 2.55084455e-01f, -1.93601489e-01f, -3.89472574e-01f, -1.48611590e-01f, 2.39794120e-01f, -1.62144646e-01f,
  1.15852684e-01f, 1.96515754e-01f, -8.96361098e-02f, 1.08239777e-01f, -1.11763939e-01f, -1.04143070e-02f, 3.75679471e-02f, -9.18009207e-02f, 6.91854209e-02f, 1.38169006e-01f,
  4.57356274e-02f, -1.44782469e-01f, -1.15416571e-01f, 1.36124149e-01f, 1.72507256e-01f, -7.88772181e-02f, 3.95835489e-01f, -1.26390532e-02f, 3.76649350e-02f, 1.24148931e-02f,
  5.67507856e-02f, 1.25908524e-01f, 3.65173705e-02f, 5.31085767e-02f, -1.10568039e-01f, 2.41862964e-02f, 1.32876029e-02f, -1.40630811e-01f, -3.59489210e-02f, -2.96238452e-01f,
  1.12875693e-01f, 7.84251913e-02f, -1.16927870e-01f, -8.81968439e-02f, 1.75949737e-01f, -2.96650350e-01f, 2.53957026e-02f, -1.93656191e-01f, 4.88502085e-02f, 9.91106108e-02f,
  -1.00586012e-01f, -6.43200800e-02f, -1.57281846e-01f, -8.09148923e-02f, -7.32157230e-02f, 9.87042189e-02f, 1.07634790e-01f, 1.02954894e-01f, 1.98960885e-01f, 1.13454044e-01f,
  1.85238123e-02f, 5.81844151e-02f, 1.52143255e-01f, 2.56842859e-02f, 1.90840840e-01f, 1.39167327e-02f, -2.79323887e-02f, 2.55051196e-01f, 1.37271717e-01f, -1.03368208e-01f,
  -1.83112472e-01f, -1.25289157e-01f, -6.97133616e-02f, -6.87607676e-02f, -2.79011339e-01f, 5.02173044e-02f, 3.36580068e-01f, 6.32822588e-02f, 7.28097260e-02f, 2.02314839e-01f,
  -6.25677258e-02f, 1.16615795e-01f, 1.05405763e-01f, -2.52173524e-02f, 1.94918886e-02f, -2.19697237e-01f, -2.58521706e-01f, -5.57284765e-02f, 1.58082008e-01f, -1.91540316e-01f,
  2.12903842e-01f, 1.14507928e-01f, -1.68146849e-01f, 6.57624379e-02f, 1.68043561e-03f, -1.10529333e-01f, 1.08246192e-01f, -1.17222674e-01f, 3.26620378e-02f, 7.51985833e-02f,
  -9.22867209e-02f, 2.74374068e-01f, -2.37331927e-01f, 2.69531365e-02f, 8.38511884e-02f, -1.16344981e-01f, 1.42156839e-01f, 1.18336521e-01f, -1.01518527e-01f, 2.96887636e-01f,
  -5.55456281e-01f, -5.26526868e-02f, 3.72645371e-02f, -3.09123099e-01f, 4.06601131e-02f, 2.69535840e-01f, -9.77708697e-02f, 8.89271721e-02f, -1.26094520e-01f, -1.23219177e-01f,
  1.67132378e-01f, -1.07617863e-01f, -1.26031339e-01f, -8.44562501e-02f, 2.59950645e-02f, -1.35290504e-01f, 1.64939448e-01f, 2.20831782e-01f, 4.97586541e-02f, 3.76815610e-02f,
  1.85616851e-01f, -1.17769912e-01f, -1.37773171e-01f, -9.67111290e-02f, -6.91995174e-02f, -1.41330110e-02f, -8.19860622e-02f, -1.37736807e-02f, 6.58940971e-02f, -2.42516741e-01f,
  -1.15458854e-01f, 4.14009951e-02f, 3.81410941e-02f, -2.83646315e-01f, 5.36138341e-02f, 7.91830793e-02f, 2.23230690e-01f, -1.44169286e-01f, 2.58786619e-01f, -1.56923115e-01f,
  2.82528959e-02f, 2.24510446e-01f, 5.55322468e-02f, 3.20779145e-01f, -2.01199204e-01f, -9.03239399e-02f, -9.80764851e-02f, -1.26222581e-01f, -5.11650182e-02f, 5.20490520e-02f,
  1.39674887e-01f, -7.00685754e-02f, -9.71424505e-02f, -1.97378561e-01f, -1.40229151e-01f, 2.20821813e-01f, 1.62765548e-01f, 1.45395577e-01f, 1.23626478e-01f, 9.40255895e-02f,
  1.52261242e-01f, -2.39946261e-01f, -2.42924958e-01f, 3.00175697e-01f, 1.52484551e-01f, -5.39130494e-02f, -1.13708921e-01f, -4.80490252e-02f, -1.34623885e-01f, -8.59955028e-02f,
  -1.52557867e-03f, 7.37222135e-02f, 2.79539712e-02f, -1.23645693e-01f, 1.36322275e-01f, 3.09680235e-02f, -1.58621207e-01f, 2.13504374e-01f, 6.45127371e-02f, -1.99347079e-01f,
  1.97640508e-01f, 1.10137209e-01f, 3.64870548e-01f, -5.97345196e-02f, 7.80973732e-02f, -2.99249917e-01f, -1.82463676e-01f, 1.63842142e-01f, 1.34880617e-01f, -2.54915543e-02f,
  -6.04351908e-02f, 2.41589323e-01f, 2.95063138e-01f, 8.23823959e-02f, 2.03710631e-01f, -1.42755106e-01f, 8.51881728e-02f, -5.97133748e-02f, 6.34752065e-02f, -1.12955280e-01f,
  -6.40857816e-02f, -1.56126052e-01f, -2.23754033e-01f, -1.10441536e-01f, -1.98441267e-01f, 9.83172003e-03f, 8.21859017e-02f, -2.97259569e-01f, 4.60033119e-03f, 4.09934819e-02f,
  -9.05763954e-02f, 1.71301037e-01f, -1.45395949e-01f, 6.34811670e-02f, 1.80556238e-01f, 2.74955500e-02f, 1.02412209e-01f, 6.19405508e-02f, -1.13336667e-02f, 1.62214831e-01f,
  2.13742420e-01f, -1.80418566e-01f, 1.08102806e-01f, -2.99697425e-02f, -1.19957328e-03f, -2.49707140e-02f, 1.58288658e-01f, 4.02126759e-02f, -3.93687263e-02f, 2.58605272e-01f,
  6.31102026e-01f, -2.44680360e-01f, 2.17469916e-01f, 2.04806983e-01f, 2.66301870e-01f, -1.08724520e-01f, -9.80898645e-03f, -1.73369065e-01f, 2.06325844e-01f, -8.32502842e-02f,
  1.69514772e-02f, -1.82151070e-05f, 1.27918303e-01f, 2.08402216e-01f, 6.01369217e-02f, -1.41173368e-02f, -4.03512120e-02f, 1.18004382e-01f, -3.97111066e-02f, 2.60464072e-01f,
  4.60527278e-02f, 1.14553392e-01f, -3.46232325e-01f, 6.73035607e-02f, -1.49452582e-01f, -1.08122222e-01f, -1.05258249e-01f, 1.67335719e-02f, -5.91052212e-02f, -1.82742581e-01f,
  -9.23659727e-02f, 2.27483720e-01f, 1.18148394e-01f, -7.57974014e-02f, 6.71419203e-02f, 1.41817093e-01f, 1.62103951e-01f, 1.28737686e-03f, 7.35047087e-03f, 1.07168458e-01f,
  8.00017715e-02f, 9.68653709e-02f, 1.68275937e-01f, 1.21981159e-01f, -1.26009449e-01f, -9.64454487e-02f, -6.40698075e-02f, 2.59647071e-01f, 4.90880630e-04f, 1.20746948e-01f,
  4.78963852e-02f, 1.23126708e-01f, 3.77837084e-02f, -3.82851288e-02f, -2.15914994e-01f, -2.72962332e-01f, 1.09486327e-01f, 1.53188333e-01f, 6.75020888e-02f, -1.49057791e-01f,
  1.36826336e-01f, -9.55117121e-03f, -5.78909665e-02f, -2.10756421e-01f, -1.10910341e-01f, -1.03671357e-01f, -1.69925801e-02f, 1.08935609e-01f, -3.13591123e-01f, 1.10681437e-01f,
  -6.05319440e-03f, -1.58261105e-01f, -8.57538916e-03f, -9.47284475e-02f, -2.52464581e-02f, -2.69389478e-03f, 7.51621947e-02f, -2.06960827e-01f, 1.92638487e-01f, 3.87904644e-02f,
  3.37846689e-02f, -7.21916705e-02f, 2.67814901e-02f, 1.02942280e-01f, -1.37223713e-02f, -5.18897995e-02f, -1.02770671e-01f, 1.19067699e-01f, -1.92800257e-02f, 1.28766775e-01f,
  -1.77194532e-02f, -6.10350110e-02f, -9.16527770e-03f, 5.50352484e-02f, -6.13683164e-02f, -1.50677487e-01f, -7.66869187e-02f, -1.15244284e-01f, -7.51955733e-02f, -5.54054752e-02f,
  -4.81710434e-02f, -1.64104834e-01f, -1.38602570e-01f, -4.05625030e-02f, 6.36250749e-02f, -1.60851762e-01f, -9.53409970e-02f, -4.40810621e-03f, 1.80565156e-02f, 9.07059610e-02f,
  -1.58872396e-01f, -8.92409235e-02f, -4.59182821e-03f, 2.79173013e-02f, 7.90739730e-02f, -1.39869526e-01f, -5.92623726e-02f, -8.81406572e-03f, -3.12751904e-02f, -1.53855205e-01f,
  -6.94409460e-02f, 8.15138072e-02f, -1.19758382e-01f, 5.29163256e-02f, 7.64566138e-02f, 2.89827585e-04f, -1.09678484e-01f, -3.59711759e-02f, -7.90721327e-02f, 7.19626248e-02f,
  -8.89107138e-02f, -7.27592334e-02f, 7.08999857e-02f, 2.50485390e-02f, -1.00881174e-01f, 4.02057078e-03f, -1.97695643e-02f, -1.62086278e-01f, 1.17360186e-02f, 6.64535016e-02f,
  -1.67787209e-01f, -9.69833434e-02f, -9.26695690e-02f, -8.13574120e-02f, -2.52356201e-01f, -3.27729434e-01f, -5.39841056e-02f, -2.70386279e-01f, -1.40579849e-01f, 3.45620841e-01f,
  -2.72656363e-02f, -1.15038510e-02f, -1.02008432e-01f, 2.04449473e-03f, 2.11655766e-01f, 1.47297293e-01f, 2.48728376e-02f, 1.01506948e-01f, 2.76575200e-02f, -1.45005673e-01f,
  -7.58989379e-02f, 9.56542864e-02f, 2.75709461e-02f, 1.75447911e-01f, 1.15340181e-01f, -9.81026515e-03f, -5.50556257e-02f, 3.99970403e-03f, -6.43514991e-02f, 1.74257189e-01f,
  3.06255817e-01f, 1.84255410e-02f, 1.93417557e-02f, -2.30889395e-01f, -1.04768783e-01f, 2.68415779e-01f, -1.70913309e-01f, 1.71943843e-01f, -1.17097087e-01f, 1.22838892e-01f,
  -7.74371326e-02f, -1.85781997e-02f, 1.52477935e-01f, 6.50168629e-03f, -4.41397121e-03f, -5.52855693e-02f, 4.45059985e-02f, -3.59801263e-01f, -5.12299314e-02f, 3.92957740e-02f,
  3.21799725e-01f, -1.84502870e-01f, 1.55787289e-01f, 1.15523435e-01f, -4.24005091e-01f, 1.45433664e-01f, -2.02386111e-01f, 3.43241125e-01f, -7.29492232e-02f, 2.22117960e-01f,
  2.17508033e-01f, 2.36698408e-02f, 3.03574409e-02f, 3.49799722e-01f, 1.27928272e-01f, -1.22896142e-01f, 9.50426515e-03f, -8.38317350e-02f, 1.88224435e-01f, 3.45417887e-01f,
  -8.41029882e-02f, 2.46598750e-01f, 2.03677341e-01f, 9.11691561e-02f, -2.89888918e-01f, -7.72368833e-02f, 2.93837428e-01f, -8.33874270e-02f, -2.36787975e-01f, -1.46891311e-01f,
  -1.19855583e-01f, 1.27857372e-01f, -7.39629343e-02f, 2.79122174e-01f, 1.00451574e-01f, 1.07747711e-01f, 2.88310409e-01f, -2.04191748e-02f, 1.21519580e-01f, -3.44705619e-02f,
  -4.49541211e-02f, 1.04796544e-01f, 1.94679320e-01f, -8.44713487e-03f, -6.62612543e-02f, -7.61390775e-02f, -5.14217280e-02f, 1.34311572e-01f, -7.57339969e-02f, -1.77209243e-01f,
  1.43786278e-02f, 2.34481007e-01f, 6.18416863e-03f, 1.28203049e-01f, -7.17240721e-02f, 9.60794687e-02f, -1.71916708e-01f, -1.04561843e-01f, -6.90671131e-02f, 1.65759340e-01f,
  8.09278563e-02f, 9.71067995e-02f, -1.07935248e-02f, -1.05809614e-01f, 1.47582917e-02f, -2.08102107e-01f, -1.36009781e-02f, -1.88936472e-01f, 7.35692233e-02f, -2.72454977e-01f,
  -2.41714060e-01f, -2.42379725e-01f, -1.93220805e-02f, -4.35833121e-03f, -1.15604125e-01f, 8.26826841e-02f, -1.93901882e-02f, -2.34392464e-01f, -5.81318252e-02f, -1.41999364e-01f,
  2.69529343e-01f, 7.32383057e-02f, 1.11674704e-01f, 1.10242823e-02f, 1.98859692e-01f, 1.78739592e-01f, -1.41302031e-02f, 1.39834419e-01f, -1.12694604e-02f, -9.33481753e-02f,
  7.78601412e-03f, 4.08811688e-01f, -1.65999547e-01f, 3.21680635e-01f, -8.63665715e-02f, -2.06355482e-01f, -5.50754135e-03f, 2.31965438e-01f, 9.50482935e-02f, 9.16111991e-02f,
  1.28445134e-01f, 2.19930634e-02f, -9.99757573e-02f, 3.63862514e-02f, -1.25910878e-01f, 1.64764285e-01f, 1.71908453e-01f, -2.65439093e-01f, -3.70346457e-02f, -2.93824133e-02f,
  5.85181229e-02f, 5.91972545e-02f, 9.62821767e-02f, -7.43087530e-02f, -5.04982062e-02f, -8.66205841e-02f, -5.32735325e-02f, -4.36103083e-02f, 5.29080704e-02f, 5.00400662e-02f,
  4.39977981e-02f, -1.96277440e-01f, -5.21726497e-02f, 4.14494984e-02f, 1.39085844e-01f, 1.77685022e-01f, 1.23145156e-01f, -4.13835645e-02f, -1.54229373e-01f, 9.49420333e-02f,
  4.01931196e-01f, -1.25137329e-01f, 5.78991920e-02f, -3.40820476e-02f, 5.98339662e-02f, -2.15091005e-01f, -4.75880764e-02f, 5.10432161e-02f, -8.22691899e-03f, -5.90872113e-03f,
  -1.47788405e-01f, -2.06004098e-01f, 1.54014351e-02f, 2.01226473e-01f, 1.20267205e-01f, -1.96847972e-02f, 2.17377514e-01f, 7.08739311e-02f, 1.67536080e-01f, 1.90224841e-01f,
  2.04254523e-01f, 1.22503135e-02f, -2.68465936e-01f, 6.09203614e-02f, 2.27366298e-01f, -9.22005475e-02f, -9.35740210e-03f, 2.00414643e-01f, -1.76833183e-01f, -1.78513810e-01f,
  -6.66984618e-02f, -9.15710777e-02f, 1.17257841e-01f, -5.76924570e-02f, 2.91491777e-01f, -1.02558300e-01f, 1.37312353e-01f, -1.82386264e-01f, -7.10885599e-02f, 1.50516823e-01f,
  1.60912350e-01f, -1.50585338e-01f, 9.63367075e-02f, -4.41666357e-02f, -1.52962431e-01f, -2.53189392e-02f, 3.82248359e-03f, 1.55822456e-01f, 1.11397512e-01f, 1.93542376e-01f,
  -9.55950841e-02f, 2.12151349e-01f, 1.03341125e-01f, -7.76789188e-02f, 2.47610062e-02f, -2.28950173e-01f, 7.86346495e-02f, 2.30046064e-01f, 1.17201619e-02f, 3.20090726e-02f,
  1.89438760e-01f, -2.42761195e-01f, -2.99476534e-01f, -1.78871498e-01f, 7.81668201e-02f, -1.37976110e-01f, 1.85192630e-01f, -1.06709518e-01f, -1.49946436e-01f, -4.76390198e-02f,
  1.07244343e-01f, -1.47144422e-01f, -1.89083610e-02f, -6.21894971e-02f, -1.85180739e-01f, 1.18490122e-02f, 1.14822581e-01f, 1.50833922e-02f, 1.87799066e-01f, -4.26068045e-02f,
  -6.85623512e-02f, -3.11547108e-02f, -5.71842790e-02f, -2.92214938e-02f, 9.47747827e-02f, 4.74634347e-03f, -5.05100898e-02f, -9.72669870e-02f, -5.76405376e-02f, 9.75465998e-02f,
  3.19615640e-02f, -5.42812459e-02f, -1.36728615e-01f, 5.81199974e-02f, -9.07891244e-02f, -3.52156162e-02f, 2.12844871e-02f, 2.73730606e-02f, -1.23799846e-01f, -2.77832635e-02f,
  -1.16004959e-01f, -1.58928230e-01f, -3.57329547e-02f, 9.07254368e-02f, -6.88852221e-02f, -8.68263990e-02f, 5.59630431e-02f, -1.04950950e-01f, 3.30560207e-02f, 8.84237587e-02f,
  -1.85390878e-02f, -1.06227458e-01f, -8.21383595e-02f, 4.23725992e-02f, -7.91277140e-02f, -1.54725537e-01f, -1.69702701e-03f, -1.18003204e-01f, -8.77611563e-02f, -4.64503616e-02f,
  -6.86367601e-02f, -5.92374876e-02f, -8.41184109e-02f, 2.86063422e-02f, -7.88628235e-02f, -1.18917525e-02f, 2.22384986e-02f, -8.89802724e-02f, 4.87715239e-04f, -3.82199027e-02f,
  -9.74294171e-03f, -2.98106694e-03f, -1.01043232e-01f, -1.11326680e-01f, -8.17297772e-02f, -1.54990003e-01f, 2.02158559e-02f, -3.82858515e-02f, 1.11456171e-01f, -1.95896626e-02f,
  5.34356572e-02f, 6.65004104e-02f, -4.32195701e-02f, -5.35586104e-02f, -1.34454712e-01f, -1.77687213e-01f, 1.88814513e-02f, -2.26802200e-01f, -1.55073985e-01f, -3.77753302e-02f,
  2.30024144e-01f, -2.46758133e-01f, -1.05438232e-02f, 8.31600428e-02f, -2.11352855e-02f, 3.06430042e-01f, 9.79934633e-02f, 8.02641883e-02f, 1.53096706e-01f, 5.33526167e-02f,
  -3.58307250e-02f, -1.00906648e-01f, -1.49524659e-01f, 8.84718522e-02f, -6.06414638e-02f, 1.20685287e-01f, 2.03000605e-02f, -1.36195391e-01f, 1.32665485e-01f, -7.79512152e-02f,
  -6.30622879e-02f, 4.38145958e-02f, 9.29974094e-02f, 6.42521977e-02f, 1.20978169e-01f, 1.80363759e-01f, 2.16801658e-01f, -8.36822912e-02f, -6.16475381e-02f, 2.08850145e-01f,
  -1.05666168e-01f, -5.89574948e-02f, -3.04471403e-02f, 1.46019354e-01f, -1.30394533e-01f, 3.80324610e-02f, -4.76585031e-02f, 1.12690948e-01f, 6.73481627e-05f, -5.44623621e-02f,
  -9.35887024e-02f, 1.08802542e-01f, -2.10971236e-01f, 1.86154529e-01f, 7.53592551e-02f, -1.29021302e-01f, -2.83800550e-02f, -4.02327452e-04f, 2.74619907e-01f, -1.57559514e-01f,
  -6.06654510e-02f, 1.78847030e-01f, 5.55818379e-02f, 1.23917580e-01f, 2.50321090e-01f, 1.81391165e-01f, -1.50144706e-02f, -5.64306341e-02f, -4.18525189e-02f, 2.10762113e-01f,
  1.01255275e-01f, 2.01907098e-01f, -4.56749871e-02f, 7.03533888e-02f, 2.41587013e-01f, -1.19279511e-02f, -1.87919885e-01f, 2.34433115e-01f, -3.11102539e-01f, 8.99448618e-02f,
  2.82407016e-01f, 1.38564289e-01f, 1.80269405e-01f, 2.05131784e-01f, 3.06830127e-02f, -6.95248097e-02f, -1.27226993e-01f, 1.84053138e-01f, -1.35545224e-01f, 2.50012457e-01f,
  1.08590968e-01f, -6.87946752e-02f, 2.23093167e-01f, -1.52275011e-01f, -1.30173504e-01f, 3.83045860e-02f, -1.13946140e-01f, 9.26051736e-02f, 1.53095159e-03f, -1.83053195e-01f,
  2.25280702e-01f, -8.04483891e-02f, -5.41438460e-02f, 8.55510533e-02f, -6.55204877e-02f, 4.57720086e-02f, -1.11835310e-02f, 3.63648295e-01f, 5.87205552e-02f, 6.69683367e-02f,
  2.73348659e-01f, 8.77661537e-03f, -6.55124709e-02f, 9.64171961e-02f, -9.73756313e-02f, 1.23232782e-01f, -1.01283431e-01f, 1.05899222e-01f, -4.65823896e-02f, 1.57171562e-01f,
  2.76228432e-02f, -1.45925430e-03f, -1.24232702e-01f, -1.03599191e-01f, -2.99591403e-02f, 1.90298930e-01f, 6.27721474e-02f, -1.87599480e-01f, 2.05395609e-01f, 1.27990797e-01f,
  -3.21132923e-03f, 5.06088622e-02f, 1.71215087e-02f, -3.47233117e-01f, 8.15419704e-02f, -2.22119749e-01f, 1.13079801e-01f, 3.70497024e-03f, -2.17700928e-01f, -1.73772454e-01f,
  2.30846051e-02f, -5.56397773e-02f, 6.25355318e-02f, 3.96334641e-02f, 1.41399249e-01f, 1.38748050e-01f, 1.29195914e-01f, 1.51872396e-01f, 3.88899818e-02f, 4.25289981e-02f,
  -1.32741168e-01f, 1.29872248e-01f, -1.43687263e-01f, -1.00746393e-01f, -1.03746787e-01f, -1.78087324e-01f, 2.63863355e-02f, -5.71237355e-02f, 2.54478276e-01f, 4.89602834e-02f,
  3.27843651e-02f, 1.49621040e-01f, -4.37567905e-02f, 2.49707967e-01f, 8.93718973e-02f, 9.75209177e-02f, 3.80897000e-02f, -2.43603345e-02f, -1.00149617e-01f, 2.15387315e-01f,
  -2.77098387e-01f, -2.92977393e-01f, -9.89807677e-03f, -3.86270843e-02f, -1.83578040e-02f, -6.75998181e-02f, 1.39331250e-02f, 4.50879894e-02f, 6.43113628e-02f, -6.83532059e-02f,
  4.46211815e-01f, -2.10320070e-01f, -1.32759541e-01f, 2.74331182e-01f, -7.84133971e-02f, -3.19670923e-02f, -1.19694456e-01f, -9.54902619e-02f, 3.99657100e-01f, -1.38704360e-01f,
  -2.18029484e-01f, 5.73868304e-02f, 1.31928638e-01f, 1.24477968e-01f, -5.76940216e-02f, 1.78871512e-01f, 1.84292138e-01f, -1.62920281e-01f, 4.37910929e-02f, -1.83686584e-01f,
  8.84434581e-02f, -8.08721930e-02f, 2.08568722e-02f, -6.36057630e-02f, -9.28274021e-02f, -2.20977664e-02f, 5.53397015e-02f, -1.04117937e-01f, 2.93203592e-02f, 1.47151634e-01f,
  -2.43759975e-02f, -1.43315241e-01f, -8.99559185e-02f, 1.02509677e-01f, -9.08032805e-02f, -1.56862959e-01f, -5.84863871e-02f, -1.53579816e-01f, -1.07844330e-01f, 8.96495506e-02f,
  -7.30480179e-02f, 9.67828929e-02f, -7.77955027e-03f, 3.70057464e-01f, -1.04807436e-01f, -1.55011177e-01f, -3.96363400e-02f, -4.86854054e-02f, -8.21389034e-02f, -1.70965463e-01f,
  -1.04547441e-02f, -8.46199691e-02f, -9.84501988e-02f, -5.22333663e-03f, 5.04201017e-02f, -6.15382642e-02f, -2.24766761e-01f, -2.45017856e-01f, 1.35431379e-01f, 1.24250300e-01f,
  -7.62482435e-02f, 3.82877469e-01f, -2.92363405e-01f, -1.33537129e-02f, -6.81498498e-02f, -1.36986926e-01f, -7.33950660e-02f, -2.44746715e-01f, -4.61258069e-02f, -6.02314109e-03f,
  1.66878812e-02f, 1.50767952e-01f, -2.28348114e-02f, -1.12269342e-01f, -4.58922191e-03f, -7.92406201e-02f, 1.45545732e-02f, -1.61938742e-02f, -4.52213474e-02f, 3.10790930e-02f,
  2.29758859e-01f, 4.87533957e-02f, -8.43204781e-02f, -1.88140720e-01f, 4.82427292e-02f, 5.52239567e-02f, 2.51723796e-01f, -3.52774292e-01f, 3.93752962e-01f, 1.04605174e-02f,
  6.67321533e-02f, 3.69906515e-01f, 5.84795214e-02f, 1.19669616e-01f, 7.08471537e-02f, -1.97718274e-02f, 1.12239644e-02f, 1.13345273e-02f, -1.32885367e-01f, -1.91516459e-01f,
  -1.54794157e-02f, -3.78952175e-02f, -1.34732917e-01f, -8.52395743e-02f, 9.73595977e-02f, -1.07237101e-01f, -4.01154011e-02f, 1.03932701e-01f, 1.01513110e-01f, 2.54381508e-01f,
  5.82466498e-02f, 9.83405276e-04f, 7.90267810e-02f, -9.49600413e-02f, -9.52398852e-02f, 1.91267282e-01f, 7.57003352e-02f, -1.77216545e-01f, 1.99320376e-01f, -1.04479887e-01f,
  -9.87977907e-02f, 8.51176009e-02f, -4.34415601e-03f, 1.81337431e-01f, 2.24048465e-01f, -3.05913001e-01f, -8.89384672e-02f, -2.06655502e-01f, 1.02714092e-01f, 1.88835129e-01f,
  2.29455262e-01f, -1.63541242e-01f, 3.86676192e-02f, -5.72018512e-02f, 1.13219343e-01f, 2.33820766e-01f, -2.30915368e-01f, 1.01271264e-01f, 8.19349140e-02f, -2.35714018e-01f,
  2.18558714e-01f, 3.05477470e-01f, -1.26407191e-01f, 1.69356287e-01f, 7.13219419e-02f, 1.44032864e-02f, 8.55797306e-02f, 1.04446746e-01f, 9.97868925e-02f, -2.98850462e-02f,
  -2.68593766e-02f, 7.84523711e-02f, -5.94245642e-02f, -1.90815926e-01f, -5.62522970e-02f, -4.33941334e-01f, 2.06329271e-01f, 1.19396321e-01f, -1.47967517e-01f, -5.19027226e-02f,
  2.48216242e-02f, -7.09615797e-02f, 1.39564514e-01f, -2.74424314e-01f, -5.79360034e-03f, -1.77646860e-01f, -1.71711128e-02f, -1.06815004e-03f, -3.91912237e-02f, 7.61024207e-02f,
  -7.24885538e-02f, -1.11853875e-01f, 7.30239898e-02f, 1.11001983e-01f, -4.75595258e-02f, 5.28424699e-03f, 9.37823951e-03f, -2.80497313e-01f, 1.23234633e-02f, -5.69388941e-02f,
  -2.31325239e-01f, 1.36716783e-01f, 1.23345412e-01f, -1.85239494e-01f, 6.42717555e-02f, 4.51927632e-02f, 1.53698042e-01f, -1.46708461e-02f, -1.68562874e-01f, 2.13048100e-01f,
  1.50493741e-01f, 1.26060337e-01f, 1.96288049e-01f, -1.72241405e-01f, 1.01902381e-01f, -3.65462452e-02f, -2.61992356e-03f, 2.80895829e-01f, -1.71477318e-01f, -6.12855051e-03f,
  2.63788551e-01f, -1.84731945e-01f, -1.02364831e-01f, 1.34447962e-01f, -3.63757014e-02f, 1.20979123e-01f, 1.60192907e-01f, 1.62976652e-01f, 2.77394224e-02f, 3.21334690e-01f,
  -5.09278476e-02f, 2.17888981e-01f, 4.16831523e-01f, -1.49803892e-01f, -2.65571892e-01f, -3.55196893e-01f, 1.45762682e-01f, -4.61386412e-01f, -5.94581738e-02f, -1.66786864e-01f,
  7.23791569e-02f, 2.01321423e-01f, -1.67078957e-01f, 2.33447298e-01f, 1.22303195e-01f, -1.01664796e-01f, 2.60813266e-01f, 1.05675764e-01f, 1.02997199e-01f, 8.02474469e-02f,
  1.77543193e-01f, -2.50677392e-02f, 1.31498739e-01f, 1.38789877e-01f, 3.78421128e-01f, -4.12544096e-03f, 1.28404304e-01f, -1.24939092e-01f, 8.14597979e-02f, -1.54154047e-01f,
  6.97286725e-02f, -9.57541987e-02f, 3.71690020e-02f, -1.38993710e-01f, 1.44650936e-01f, -1.04364879e-01f, -2.41130039e-01f, -3.85873988e-02f, 1.26834065e-02f, 1.90389216e-01f,
  -4.06725565e-03f, -1.60211325e-01f, 1.03621455e-02f, -1.95056066e-01f, 1.24405652e-01f, -2.74917156e-01f, -4.10984904e-01f, -7.18434677e-02f, -1.52805418e-01f, 6.23625983e-03f,
  -3.51194590e-01f, -1.26503482e-01f, -2.28439301e-01f, 1.05802737e-01f, -8.97409841e-02f, -1.20338304e-02f, 2.10343227e-01f, -5.55989854e-02f, -1.76761031e-01f, -1.00971982e-02f,
  1.66657507e-01f, 6.61706999e-02f, 5.42836636e-02f, -1.78679675e-01f, 1.54592335e-01f, -3.22128296e-01f, -4.38425355e-02f, 8.83527175e-02f, 3.26960951e-01f, 1.08011611e-01f,
  1.35617837e-01f, 1.18495911e-01f, 3.04256648e-01f, 2.01140776e-01f, -2.72196472e-01f, -3.73616852e-02f, 1.60596415e-01f, -1.86254546e-01f, 2.03603476e-01f, -1.26728669e-01f,
  -1.38327271e-01f, 1.37902036e-01f, -8.72063711e-02f, 1.62224665e-01f, 1.53811365e-01f, 1.84327289e-01f, -2.57114472e-04f, -4.09477241e-02f, -3.52566272e-01f, 6.35801181e-02f,
  -1.22899897e-01f, -8.26333463e-02f, 1.21467203e-01f, 1.17622711e-01f, -4.33966406e-02f, 1.78586468e-01f, 6.61806315e-02f, -3.58032733e-02f, 2.26060003e-01f, -4.15519029e-02f,
  3.19074154e-01f, 1.04562417e-02f, 6.53151050e-02f, 2.04414710e-01f, -4.69675362e-02f, 4.12027501e-02f, 6.88743293e-02f, 1.32547421e-02f, 5.21053895e-02f, 2.49844000e-01f,
  2.21587867e-01f, 1.89551264e-01f, 1.73651040e-01f, 2.43213281e-01f, 4.95378375e-01f, 9.11090076e-02f, 2.13630065e-01f, -1.64603293e-01f, -1.85339134e-02f, 8.05648267e-02f,
  -9.79821682e-02f, 1.53276965e-01f, -1.89027488e-02f, 8.27376544e-02f, -1.04494326e-01f, -5.71072362e-02f, -1.48468360e-01f, -3.32305580e-03f, 3.66299599e-02f, 2.63205506e-02f,
  -5.45766130e-02f, -4.07362401e-01f, -5.74318171e-02f, -2.63685770e-02f, -8.69146064e-02f, -1.58549428e-01f, 1.30995795e-01f, -4.05414522e-01f, 2.31683463e-01f, 1.56257436e-01f,
  -5.59419319e-02f, 6.12925272e-03f, -1.23937704e-01f, -1.00719884e-01f, -1.02090813e-01f, 1.88449755e-01f, -1.42787561e-01f, 1.29595518e-01f, 6.44944012e-02f, -1.04420595e-01f,
  1.14550851e-01f, 1.19171366e-01f, 3.29664558e-01f, 3.26476395e-02f, 1.85679093e-01f, 5.64171141e-03f, 1.84750985e-02f, -4.27100845e-02f, 7.62373907e-03f, -1.51787326e-01f,
  -2.73740143e-02f, -2.53821760e-02f, -4.08140346e-02f, 1.36736110e-01f, -1.91650931e-02f, 7.02140629e-02f, -6.53190389e-02f, -2.01018840e-01f, 1.00342847e-01f, -1.46579444e-01f,
  -3.50776732e-01f, 1.96022585e-01f, 2.77662456e-01f, -2.96924472e-01f, -3.80572617e-01f, -5.77475363e-03f, -1.78420439e-01f, 1.31757140e-01f, -6.39127195e-02f, 1.14680395e-01f,
  -2.49272376e-01f, 1.31119832e-01f, 1.83963552e-01f, 8.23292211e-02f, 2.12911621e-01f, 1.27049059e-01f, -1.56845957e-01f, -1.80409271e-02f, 1.92965325e-02f, 1.65976100e-02f,
  1.27595514e-01f, 6.90571591e-02f, -4.83765379e-02f, -9.24884602e-02f, 2.43523747e-01f, -1.99615970e-01f, 2.41041973e-01f, -3.04065108e-01f, 1.68101966e-01f, -3.30082387e-01f,
  2.15057135e-01f, 9.38325003e-02f, -7.22587481e-02f, 1.37556300e-01f, -2.47194711e-02f, 8.49667415e-02f, 2.47771926e-02f, 5.92380576e-02f, 2.68456619e-02f, 2.55140245e-01f,
  8.55052546e-02f, 2.67170578e-01f, 2.33954638e-01f, 4.42676395e-02f, 3.13311294e-02f, 3.91635665e-04f, -2.74483025e-01f, -1.99264772e-02f, 2.10762974e-02f, -1.23177044e-01f,
  9.80434865e-02f, 2.87310947e-02f, 2.96961088e-02f, -9.93785332e-04f, 1.26397237e-01f, -7.18793198e-02f, 2.50344783e-01f, -1.18927933e-01f, -2.31669806e-02f, 1.11030437e-01f,
  -1.27816632e-01f, 1.61789879e-01f, -1.89842463e-01f, 1.16369590e-01f, 1.10963988e-03f, -5.17294444e-02f, 1.50667116e-01f, -1.12274580e-01f, -3.02218944e-01f, 2.15756804e-01f,
  -1.02134600e-01f, 1.11011878e-01f, 1.15947030e-01f, -1.46327734e-01f, 1.05222482e-02f, 1.58824008e-02f, -1.87643275e-01f, 2.15409204e-01f, 3.15014049e-02f, -1.08044505e-01f,
  -2.90596038e-02f, -7.56084360e-03f, 5.67212030e-02f, -1.75612599e-01f, 2.21473455e-01f, 1.45847991e-01f, -6.54816777e-02f, 7.49396235e-02f, 9.87130925e-02f, 2.85382718e-02f,
  -1.92275234e-02f, -1.97512358e-01f, -8.80460367e-02f, -1.74355268e-01f, 1.21426858e-01f, 2.31296793e-01f, -3.97112546e-03f, -3.07341069e-02f, 2.54366361e-03f, 2.38840684e-01f,
  1.44539684e-01f, 1.42738540e-02f, 2.87186384e-01f, 2.77756870e-01f, 1.54077411e-01f, 1.11254171e-01f, 2.97781318e-01f, -1.13742366e-01f, 1.44653887e-01f, 1.08253792e-01f,
  2.27013662e-01f, -7.11249486e-02f, 1.60020322e-01f, 4.27553803e-02f, 1.77500084e-01f, 6.88557252e-02f, -1.49155349e-01f, 1.52045161e-01f, -6.18012138e-02f, 2.04803765e-01f,
  2.27763578e-01f, -9.11513492e-02f, -6.44076169e-02f, 7.98884127e-03f, 9.22643393e-02f, 1.59664184e-01f, -1.55872062e-01f, -3.20305414e-02f, 5.08446358e-02f, -2.42535010e-01f,
  9.72324982e-02f, 1.18960783e-01f, -1.80867031e-01f, 7.29386955e-02f, -7.55719244e-02f, 2.01828271e-01f, 7.58496821e-02f, 2.06607245e-02f, 4.91982177e-02f, 4.42669876e-02f,
  -9.08755139e-02f, 1.40618593e-01f, 4.16308120e-02f, -6.10317700e-02f, -5.64261712e-02f, -8.72079358e-02f, 1.07888199e-01f, -1.52383998e-01f, 1.79300874e-01f, 1.36686921e-01f,
  1.65655077e-01f, 1.66174456e-01f, -9.07567814e-02f, 1.74120113e-01f, -2.22785875e-01f, 2.57331580e-01f, 1.80751041e-01f, 7.49901757e-02f, -2.03343034e-01f, -1.33577123e-01f,
  -2.16321856e-01f, -9.22220200e-02f, -6.94329590e-02f, -1.18325837e-01f, 1.15538970e-01f, 2.02734079e-02f, 1.72816396e-01f, -1.88850150e-01f, 1.18772686e-01f, -1.35173962e-01f,
  8.75454098e-02f, 6.96578398e-02f, 3.16818096e-02f, 4.44937423e-02f, -1.08294867e-01f, 6.76167682e-02f, 4.31815498e-02f, 8.18905160e-02f, 1.60375923e-01f, 4.11745384e-02f,
  1.35599509e-01f, -3.75749767e-02f, 2.19229590e-02f, 4.72059287e-03f, 3.04232594e-02f, 1.51016310e-01f, 2.14351326e-01f, -2.13464573e-01f, 2.58526325e-01f, 2.60714054e-01f,
  2.67777532e-01f, 1.90971121e-01f, 1.08983278e-01f, 9.47023481e-02f, -1.72160387e-01f, -4.98222373e-02f, -2.24591434e-01f, -3.30538140e-03f, 1.02324776e-01f, -3.98116201e-01f,
  4.29508789e-03f, 1.50031254e-01f, 1.55011132e-01f, -6.58186618e-03f, -3.20226662e-02f, -2.66650487e-02f, -4.07932363e-02f, 7.62155280e-02f, 1.18845917e-01f, 4.28024568e-02f,
  5.42839430e-02f, 1.89957857e-01f, -1.56028345e-01f, 1.31814957e-01f, -3.26069862e-01f, -2.48963565e-01f, -9.43154022e-02f, -2.61077166e-01f, 1.09613419e-01f, -1.26788467e-01f,
  -1.59904346e-01f, 9.54698920e-02f, 1.67380780e-01f, 2.69049257e-02f, -1.30107836e-03f, 2.26458266e-01f, -3.06004100e-02f, 1.10499114e-01f, 1.12914808e-01f, -1.19604826e-01f,
  2.59920936e-02f, 5.37399296e-03f, -6.88553602e-02f, 1.12954117e-01f, 9.21336561e-02f, -2.79129297e-02f, 1.03970684e-01f, -4.91085723e-02f, 4.02774066e-01f, -1.07848933e-02f,
  -3.27340439e-02f, -7.79380575e-02f, 1.41600996e-01f, 1.10154204e-01f, 1.46641016e-01f, 1.67578943e-02f, 7.73772374e-02f, -2.27767844e-02f, 1.52305007e-01f, -3.81537387e-03f,
  6.17957953e-03f, 2.84075290e-01f, -4.29673977e-02f, -1.00526121e-02f, -1.80874690e-02f, 3.47612128e-02f, -1.10948503e-01f, 6.37169480e-02f, 3.34405750e-01f, 2.24593863e-01f,
  -3.02692622e-01f, 1.75901756e-01f, 5.75179271e-02f, 3.55896622e-01f, 1.27255887e-01f, 8.14642161e-02f, -7.37202689e-02f, 1.07733048e-01f, 8.62326846e-02f, 1.76183939e-01f,
  1.81421876e-01f, -7.63733536e-02f, 3.53624895e-02f, 2.03072667e-01f, 3.99704613e-02f, -1.13981538e-01f, 1.18204437e-01f, 2.45821521e-01f, 2.49119446e-01f, 3.17512974e-02f,
  3.09960037e-01f, 1.52386762e-02f, 8.58334973e-02f, -2.20957488e-01f, -1.32189430e-02f, -4.15923864e-01f, -1.31402329e-01f, -4.69221383e-01f, -1.62420720e-01f, 1.10993601e-01f,
  -8.54738951e-02f, -2.84496136e-02f, 5.14416657e-02f, 3.79372016e-02f, 2.89384007e-01f, -1.14647727e-02f, 4.53002639e-02f, 4.68908288e-02f, 8.91813412e-02f, 2.37397984e-01f,
  -6.68972284e-02f, 2.88007498e-01f, -5.53144095e-03f, -5.10573089e-02f, 6.09475486e-02f, -2.33612388e-01f, -4.06966545e-02f, 1.28922656e-01f, -2.15015579e-02f, 1.28003076e-01f,
  7.33837113e-02f, -2.30491400e-01f, -3.95255573e-02f, 2.33877882e-01f, 8.62370431e-03f, 1.84543598e-02f, 2.32479841e-01f, 3.62550654e-02f, 1.06428623e-01f, -3.61429274e-01f,
  -1.87534690e-01f, 3.72269154e-02f, 3.39528650e-01f, -1.75720956e-02f, 2.64049411e-01f, -1.48297578e-01f, -1.68258950e-01f, 1.28294066e-01f, -6.64162636e-02f, 7.56906718e-02f,
  -1.26544520e-01f, -2.50854999e-01f, 1.58648625e-01f, 2.42917761e-02f, -9.92181227e-02f, 3.05576235e-01f, -5.03140651e-02f, -2.11833909e-01f, 1.67006060e-01f, 1.81339875e-01f,
  2.87242047e-02f, -1.17831141e-01f, -8.10097605e-02f, -1.00954417e-02f, -1.37021825e-01f, -1.94581356e-02f, 2.21373513e-03f, 5.18192053e-02f, 5.03715239e-02f, -2.04063486e-02f,
  6.29488602e-02f, 1.65815232e-03f, 3.08854580e-02f, 7.70142674e-02f, -1.36906087e-01f, -2.75071263e-02f, 2.17083357e-02f, -7.19763786e-02f, -7.44983703e-02f, -1.42486408e-01f,
  4.28648815e-02f, -1.45927221e-01f, 1.25576928e-03f, -1.23580284e-01f, -1.96604915e-02f, 2.16094945e-02f, 5.26340157e-02f, -4.68878150e-02f, -9.49509889e-02f, -1.01855099e-02f,
  -6.86658919e-02f, -6.01753518e-02f, -1.16147839e-01f, 4.35840972e-02f, 3.87309939e-02f, -5.61479526e-03f, -9.30511951e-02f, -1.05273306e-01f, -1.42476395e-01f, -1.09021619e-01f,
  -1.26353458e-01f, 2.61749625e-02f, 2.23467369e-02f, -6.71236664e-02f, -3.45138386e-02f, 1.09549928e-02f, 1.09020695e-01f, 1.08383074e-01f, -5.10736704e-02f, -1.49176329e-01f,
  1.00286445e-02f, -1.19415022e-01f, -6.18074536e-02f, -5.57387322e-02f, 3.51765938e-02f, 4.89684269e-02f, -1.09161675e-01f, -7.64382705e-02f, -6.59703538e-02f, -5.16873002e-02f,
  2.32828762e-02f, 4.55741771e-02f, 1.97282881e-02f, -3.70997675e-02f, 2.60682940e-01f, 3.69566470e-01f, -1.04044944e-01f, 2.35080943e-01f, 5.58127873e-02f, 2.92225003e-01f,
  3.77213513e-03f, 1.68259352e-01f, -1.89400062e-01f, -2.05170102e-02f, -8.35342333e-02f, -2.01681942e-01f, -7.63877854e-02f, 1.75397128e-01f, -2.46780679e-01f, 2.24595577e-01f,
  1.51525706e-01f, -1.08752578e-01f, 1.39982730e-01f, -1.02258824e-01f, 1.00126013e-01f, -1.23277292e-01f, -2.80542709e-02f, 1.12676576e-01f, 5.02305441e-02f, 1.01816833e-01f,
  6.26923382e-01f, -6.45613149e-02f, 2.56377701e-02f, 1.04181692e-01f, -1.02723971e-01f, -1.10239781e-01f, -1.35392636e-01f, -1.18102029e-01f, -4.72066849e-02f, -3.42394486e-02f,
  -1.35351926e-01f, 9.01614279e-02f, -4.78473343e-02f, -3.02183777e-01f, -1.59654990e-02f, -4.56984574e-03f, 1.21236108e-01f, 4.53282557e-02f, 5.72737083e-02f, -2.27249756e-01f,
  3.51171374e-01f, 3.58268470e-02f, 2.61868775e-01f, -3.19210708e-01f, 2.85346359e-02f, 2.28477046e-01f, 1.83563188e-01f, -1.66343644e-01f, -8.88926014e-02f, -2.45831504e-01f,
  -1.72577307e-01f, 4.43552472e-02f, -3.50562111e-02f, -1.87627986e-01f, 8.44648331e-02f, 1.74556319e-02f, 5.24057373e-02f, 1.26722708e-01f, 1.57741502e-01f, -1.47016257e-01f,
  -2.68435720e-02f, -3.03516328e-01f, -1.21630892e-01f, 3.15933377e-02f, 9.02860537e-02f, -9.63674933e-02f, 7.33970478e-02f, 5.30291125e-02f, 1.20362669e-01f, 1.01914458e-01f,
  1.75830349e-02f, 2.63870577e-03f, -6.04704283e-02f, 6.53467774e-02f, -1.86862156e-01f, -1.33620664e-01f, 2.89804693e-02f, -1.20680355e-01f, -2.10664019e-01f, -1.40061960e-01f,
  -2.11034566e-01f, -8.01419988e-02f, 3.32204849e-02f, -1.37366399e-01f, 1.73532486e-01f, 1.93785243e-02f, -1.66794248e-02f, 9.24219042e-02f, -5.27189150e-02f, 1.18333332e-01f,
  1.06365271e-01f, -2.43005797e-01f, -8.38637073e-03f, 1.20063826e-01f, -1.20861299e-01f, 1.73691139e-01f, -8.10519233e-02f, -2.55233675e-01f, 1.09184824e-01f, 4.25687693e-02f,
  7.27466345e-02f, 1.74561769e-01f, -2.46560797e-02f, -1.85891956e-01f, -1.78374752e-01f, -1.32151946e-01f, 4.79183286e-01f, 1.02458438e-02f, -3.53702903e-02f, -5.01048416e-02f,
  -7.05673695e-02f, -2.21411034e-01f, 7.77699724e-02f, -1.02602884e-01f, 2.02392817e-01f, -1.96463004e-01f, -1.50824890e-01f, -1.90235414e-02f, 2.11566500e-02f, 7.30589628e-02f,
  -6.55991212e-02f, 1.54897955e-03f, 3.11527938e-01f, 1.02681257e-02f, 7.25262985e-02f, 4.73046228e-02f, 8.51738006e-02f, -1.32743418e-01f, -2.88771182e-01f, 6.04309067e-02f,
  -3.39760110e-02f, -1.67925984e-01f, 4.69783634e-01f, -3.05263922e-02f, -2.37856641e-01f, 2.97542848e-03f, 6.11895360e-02f, -1.34167880e-01f, 2.49886319e-01f, 3.88761573e-02f,
  1.88913614e-01f, 7.96423480e-02f, 1.55731201e-01f, 1.20549686e-01f, 8.38934481e-02f, 1.67754665e-01f, 2.40657441e-02f, 1.10140160e-01f, 2.28925571e-01f, 4.45928015e-02f,
  8.76258942e-04f, 8.98602710e-04f, -9.82826501e-02f, 6.68452010e-02f, -1.91338450e-01f, 3.26933116e-01f, 7.10852742e-02f, 1.50046378e-01f, 2.58102745e-01f, -1.12796694e-01f,
  2.12887168e-01f, -2.42454827e-01f, 1.40459826e-02f, 5.58848940e-02f, -1.43950582e-01f, -9.38915014e-02f, 1.48927256e-01f, 4.19627056e-02f, 2.06239358e-01f, -8.93020481e-02f,
  -1.04416749e-02f, -8.84246081e-02f, -2.39054020e-02f, -2.13361457e-02f, 1.21712528e-01f, 2.71488786e-01f, 1.39866948e-01f, 3.29828225e-02f, 1.11429505e-01f, 8.66766497e-02f,
  1.36937171e-01f, 2.38768861e-01f, -7.83871710e-02f, -9.71377939e-02f, 6.50177896e-02f, 6.47316650e-02f, 1.71840623e-01f, 2.17821136e-01f, 7.93464631e-02f, 1.63668275e-01f,
  1.78809501e-02f, -2.59193797e-02f, -4.84840162e-02f, 9.35634598e-03f, -4.29124497e-02f, 1.38679609e-01f, -1.56229213e-01f, -2.31857505e-02f, -1.51106209e-01f, 1.21699981e-01f,
  3.98745835e-02f, -4.57071811e-02f, 9.81973950e-03f, 9.70237479e-02f, 6.86823279e-02f, -9.68081430e-02f, 1.22718282e-01f, -2.52033826e-02f, -3.49603631e-02f, 2.36325786e-02f,
  1.50961190e-01f, -1.28977954e-01f, -8.68804008e-02f, 1.25909492e-01f, 1.39834955e-01f, 1.73627824e-01f, 2.12085620e-01f, -2.21178308e-02f, -1.85468737e-02f, 6.89184144e-02f,
  1.78354885e-03f, -6.43568784e-02f, 1.67495102e-01f, -2.76155565e-02f, 2.22429663e-01f, -3.91081646e-02f, 1.93307564e-01f, 2.01419190e-01f, 2.22689107e-01f, 2.73043066e-01f,
  -8.93738959e-03f, 8.13036337e-02f, -3.23625773e-01f, -4.04612646e-02f, -4.69437629e-01f, -1.25815347e-01f, 1.93632133e-02f, -3.09991390e-01f, -8.86584297e-02f, 3.06973085e-02f,
  1.09635964e-01f, 1.42878398e-01f, -1.56560034e-01f, 1.21107344e-02f, -1.48382708e-02f, 1.24754168e-01f, 2.01161504e-01f, -6.31810576e-02f, -4.08656672e-02f, 1.52014643e-01f,
  -1.42909542e-01f, -9.95677561e-02f, 9.53644365e-02f, -1.45372078e-01f, 1.16847446e-02f, -2.94951022e-01f, 1.46722138e-01f, -1.34395286e-01f, -3.96246314e-02f, -1.60936236e-01f,
  -3.30659524e-02f, -1.28476754e-01f, -1.00712664e-01f, 1.42048582e-01f, 2.07332522e-01f, -2.20477775e-01f, -3.80783267e-02f, -5.48083372e-02f, -1.40474021e-01f, 1.41751543e-01f,
  -1.59137726e-01f, 2.62562186e-01f, 9.56843346e-02f, 7.16620311e-02f, 7.55494758e-02f, -4.75937426e-02f, -3.18418831e-01f, -7.28062913e-02f, 4.05699387e-02f, -4.20707837e-02f,
  1.40374601e-01f, 2.01384053e-02f, 1.58452630e-01f, -6.29160032e-02f, -7.21660182e-02f, -1.19372889e-01f, 9.20219440e-03f, -3.73840928e-02f, 1.33547068e-01f, 3.85693401e-01f,
  8.35828558e-02f, 1.48190379e-01f, 4.66435775e-02f, -1.03295058e-01f, -4.21056105e-03f, 2.40113139e-01f, -9.74153727e-02f, -3.29024484e-03f, -3.04923683e-01f, 1.72444716e-01f,
  -1.91947985e-02f, 1.20747527e-02f, -6.81138858e-02f, 1.43554538e-01f, 6.52501360e-02f, 4.33422662e-02f, 6.99487925e-02f, 2.19013304e-01f, -1.36382341e-01f, 3.68028581e-02f,
  5.25641628e-02f, 7.41872787e-02f, -6.51894510e-02f, -8.69432539e-02f, 2.08114937e-01f, 1.56224623e-01f, 5.49628809e-02f, 1.38326213e-01f, 3.04366916e-01f, 2.12600455e-01f,
  -2.33646911e-02f, 3.24860029e-02f, 3.90182823e-01f, 9.12321508e-02f, -2.67626643e-01f, 7.61227459e-02f, -7.97010884e-02f, 4.61091381e-03f, -1.53418660e-01f, 9.71887335e-02f,
  1.96958572e-01f, -3.36343870e-02f, 6.53133541e-02f, 2.95593217e-02f, 9.67385843e-02f, -1.29493311e-01f, 1.27516165e-01f, 1.69107601e-01f, 1.29251093e-01f, -9.89408344e-02f,
  -3.47693086e-01f, -3.54775635e-04f, -3.76558900e-02f, 1.40444919e-01f, -6.24019019e-02f, 1.00878544e-01f, 8.87368899e-03f, 9.57232062e-03f, 4.67834137e-02f, 8.58339965e-02f,
  5.35890535e-02f, -4.94965874e-02f, 1.19608946e-01f, -3.58086489e-02f, 4.42129597e-02f, 2.01664329e-01f, -1.06443735e-02f, 7.77577981e-02f, 3.39939713e-01f, 4.85425405e-02f,
  -4.19149190e-01f, 5.53563703e-03f, 2.33899131e-01f, -1.41143769e-01f, 1.90451413e-01f, -2.69697517e-01f, -7.33052939e-02f, -1.85958058e-01f, 2.42173761e-01f, -1.82544470e-01f,
  4.81785722e-02f, 5.46266288e-02f, -1.94656700e-01f, -1.25508338e-01f, 3.95761393e-02f, -1.45374360e-02f, 1.08508598e-02f, 2.53549200e-02f, -1.47412300e-01f, 5.83954006e-02f,
  -2.12362885e-01f, -2.71469634e-02f, 1.29540160e-01f, -1.94259942e-01f, 1.52764201e-01f, -7.10238665e-02f, 4.74981740e-02f, -2.66591579e-01f, 2.13949472e-01f, -2.10740805e-01f,
  -3.06916125e-02f, -1.40626773e-01f, -5.80284707e-02f, -5.77033386e-02f, 4.91897725e-02f, 2.69852858e-02f, 7.27527365e-02f, 1.77465260e-01f, 1.05045147e-01f, 1.19269334e-01f,
  2.34285817e-01f, 5.88834845e-02f, 1.88060626e-02f, -9.92821231e-02f, -1.05282618e-02f, -3.25338840e-02f, -1.58080459e-01f, -1.12747803e-01f, -1.10214680e-01f, 1.76131148e-02f,
  -1.91111758e-01f, -8.13158303e-02f, -8.10083523e-02f, 9.64385550e-03f, 1.71627522e-01f, -4.07400243e-02f, 6.57461062e-02f, 1.73328280e-01f, 8.79483372e-02f, 2.09503919e-01f,
  -2.04571038e-01f, -8.12551230e-02f, 4.29064594e-02f, 6.12686500e-02f, 1.55090675e-01f, -4.28467467e-02f, -2.02182755e-01f, 1.91069543e-01f, 8.78417268e-02f, 7.49591812e-02f,
  -5.15649505e-02f, -7.36144707e-02f, -5.64098917e-02f, -4.12083149e-01f, -9.13843736e-02f, 7.32966214e-02f, -2.89446741e-01f, 4.54352610e-03f, -2.12205015e-02f, -1.43309072e-01f,
  -9.97154638e-02f, -1.13490969e-01f, -1.41679749e-01f, 6.55085817e-02f, -2.51135696e-02f, 3.18790451e-02f, 3.31350751e-02f, -3.38341713e-01f, -1.26413286e-01f, -4.40336406e-01f,
  -1.36266649e-01f, -3.73878092e-01f, -6.67153895e-02f, 3.59769128e-02f, 2.04058751e-01f, 4.16347980e-02f, 6.59875274e-02f, 1.24709010e-01f, -1.16668932e-01f, 7.37249032e-02f,
  3.44095788e-05f, 9.26516727e-02f, -2.06670597e-01f, 9.74285826e-02f, -1.59673423e-01f, -1.55595750e-01f, 5.87490313e-02f, -1.84576944e-01f, 6.22356124e-02f, 3.63158848e-04f,
  3.40437107e-02f, -1.64225549e-02f, 1.69656381e-01f, 7.97715336e-02f, 2.33011961e-01f, -1.99055765e-02f, -1.33232206e-01f, 1.60102472e-01f, -8.32184404e-02f, 1.26557052e-01f,
  -3.63768399e-01f, 1.58428326e-01f, -6.72073141e-02f, 7.02873841e-02f, -1.07871398e-01f, -9.76507962e-02f, -1.22016296e-01f, 1.82792097e-01f, -5.33908606e-02f, -1.69736877e-01f,
  -9.14052576e-02f, 1.29596233e-01f, -1.69096440e-01f, 9.51600820e-03f, -1.27269745e-01f, -8.24656859e-02f, 5.23722395e-02f, -8.63202214e-02f, 2.63119340e-01f, 9.42412913e-02f,
  -6.28766716e-02f, -1.25059292e-01f, 1.31437972e-01f, 8.76505077e-02f, 6.86134994e-02f, 3.36329043e-02f, -2.34929875e-01f, -4.19923030e-02f, -1.05346829e-01f, -2.20443718e-02f,
  -4.52217430e-01f, 9.46065038e-02f, 2.03533873e-01f, -3.34839970e-02f, 3.03761750e-01f, 1.41729996e-01f, -2.37090245e-01f, 1.25596404e-01f, -5.61440643e-03f, -7.00476542e-02f,
  2.74326801e-01f, -2.13970449e-02f, -8.13689902e-02f, 3.83654912e-03f, -1.18569553e-01f, -1.64390609e-01f, 6.62056878e-02f, 7.83620030e-02f, 3.26285027e-02f, 2.40708105e-02f,
  6.67518377e-02f, 1.30875126e-01f, -1.89110160e-01f, -2.19217297e-02f, 8.43887404e-02f, 7.53560439e-02f, 1.22011885e-01f, 2.87607387e-02f, 2.39258483e-01f, -1.40848815e-01f,
  -9.70515385e-02f, 7.59170651e-02f, -4.98525426e-02f, 1.08631253e-01f, 1.16752535e-01f, 2.79506534e-01f, 1.06273502e-01f, 1.30475566e-01f, 1.51601300e-01f, 2.11206391e-01f,
  -2.82526705e-02f, -9.12805572e-02f, -2.43209720e-01f, 5.25830239e-02f, -1.74892679e-01f, 9.07390490e-02f, 2.97035128e-02f, -3.00015230e-02f, -1.27394289e-01f, -9.74134728e-02f,
  2.64930546e-01f, -9.37232226e-02f, -3.04423296e-03f, 5.11973724e-03f, -2.16754660e-01f, 1.48241192e-01f, 1.91886902e-01f, 1.08406255e-02f, 4.45801616e-02f, 6.31901398e-02f,
  2.09205940e-01f, 2.52197385e-01f, -5.76030836e-02f, -1.39482990e-01f, 1.88853189e-01f, 2.32275009e-01f, 3.51376384e-01f, -6.63013756e-02f, -2.71161199e-01f, -1.02522872e-01f,
  2.66236812e-01f, -2.20589980e-01f, 1.54476926e-01f, -8.89496878e-02f, -2.64837537e-02f, 2.18400106e-01f, 1.70966268e-01f, 6.26268312e-02f, 1.51447281e-01f, 6.44138530e-02f,
  5.40143140e-02f, 1.13672860e-01f, -1.71028282e-02f, 7.23454282e-02f, 6.70817569e-02f, 2.14576110e-01f, -9.82945040e-02f, 8.97551328e-02f, 1.30565748e-01f, -6.86085373e-02f,
  -1.11359850e-01f, -2.54335580e-03f, -9.42211524e-02f, 8.94181132e-02f, -1.18101425e-01f, 3.70184816e-02f, 1.14032626e-01f, 7.80350342e-02f, 5.06510213e-02f, 3.37654613e-02f,
  7.31525496e-02f, -1.21219838e-02f, 3.51216719e-02f, -2.58601904e-01f, -2.37446442e-01f, -1.62678286e-01f, 4.16117460e-01f, 3.57716113e-01f, 3.19108695e-01f, 2.57667471e-02f,
  -2.16980606e-01f, 3.43949795e-01f, 2.05390140e-01f, -1.92851126e-01f, -1.43546909e-01f, -1.49544775e-01f, -7.66783059e-02f, 1.98039343e-03f, 6.98480532e-02f, -3.78976166e-02f,
  -1.93856329e-01f, -8.83591920e-02f, -3.45749268e-03f, -7.64164254e-02f, 9.65059251e-02f, 1.74398914e-01f, 1.02796920e-01f, 2.49405667e-01f, -3.82996425e-02f, -3.47574167e-02f,
  1.22058272e-01f, -1.09200366e-01f, 2.51930267e-01f, -2.64984906e-01f, 1.07314177e-01f, -3.33675712e-01f, 3.82532505e-03f, 1.88603252e-01f, -4.11328748e-02f, 5.98974675e-02f,
  5.71987666e-02f, -8.85605589e-02f, 1.81406394e-01f, 9.65568721e-02f, 6.80637732e-02f, 1.51589185e-01f, 6.10587858e-02f, 1.53912548e-02f, 1.55119717e-01f, 1.79136321e-01f,
  -1.77500859e-01f, 2.33179368e-02f, -1.14153944e-01f, -1.75133646e-01f, 4.05597575e-02f, -6.64528692e-03f, 1.02852412e-01f, -1.72796637e-01f, -2.23657507e-02f, -3.91378216e-02f,
  8.12599361e-02f, 3.92816551e-02f, 1.64726730e-02f, 1.67665437e-01f, 4.06131558e-02f, -1.33926636e-02f, 8.56749266e-02f, -3.00353579e-02f, -1.75585479e-01f, -9.06041786e-02f,
  1.45309001e-01f, -1.71080902e-01f, -2.29554445e-01f, -2.90007722e-02f, -2.73231529e-02f, -9.46518853e-02f, 9.29040462e-03f, -1.05031721e-01f, -1.84382975e-01f, -3.52196284e-02f,
  -1.29371434e-01f, 1.68667838e-01f, 3.76069061e-02f, -1.58377528e-01f, -1.71524853e-01f, -1.34844586e-01f, 1.66310817e-01f, 8.53525102e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  2.09963560e-01f, -1.64787218e-01f, 7.21932799e-02f, -1.48610964e-01f, 3.40745260e-04f, -9.86256823e-02f, 7.15274736e-03f, -4.53645326e-02f, -1.52439117e-01f, -4.80202325e-02f,
  2.23277360e-02f, -2.66710315e-02f, 2.53002316e-01f, 8.76238719e-02f, 2.12264165e-01f, 3.44156986e-03f, -2.84358654e-02f, 1.66057155e-01f, 2.23230142e-02f, 7.12585822e-02f,
  -2.83233002e-02f, -5.79017513e-02f, 9.34239924e-02f, -7.62941875e-03f, 1.44072920e-01f, -8.29393119e-02f, 9.96872038e-02f, 1.17231846e-01f, -5.41641787e-02f, -9.65374522e-03f,
  1.26546230e-02f, 3.07583101e-02f, 2.09282592e-01f, 5.25078066e-02f, -5.31504937e-02f, 3.20933498e-02f, 5.51290289e-02f, 9.59150493e-02f, -2.86754705e-02f, -5.40114893e-03f,
  -4.73704897e-02f, 3.57766338e-02f, 5.00749610e-03f, 1.28193066e-01f, 1.55375794e-01f, 2.95668021e-02f, -3.09412163e-02f, 9.74458680e-02f, -6.03774795e-03f, 6.01565512e-03f,
  3.48785799e-03f, 4.82448079e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  4.09635901e-02f, -1.11545384e-01f, -2.44164225e-02f, 7.92820305e-02f, -9.68607962e-02f, 1.59683615e-01f, -7.46794119e-02f, 7.17112869e-02f, -1.33430749e-01f, 1.33848310e-01f,
  -3.00530940e-02f, -3.67259071e-03f, 5.96166104e-02f, -3.80331129e-02f, -2.95014270e-02f, -7.92266577e-02f, 1.46278784e-01f, 1.66930094e-01f, 4.17141877e-02f, -5.60588203e-03f,
  1.63334161e-01f, -5.61825454e-01f, -1.12370707e-01f, -1.92700118e-01f, -2.03934014e-01f, -2.86698639e-01f, -4.26148117e-01f, -1.79761156e-01f, -3.14108342e-01f, -3.79050255e-01f,
  6.07326068e-03f, -2.27707475e-01f, -8.53012055e-02f, -7.27612853e-01f, -1.82165593e-01f, 1.77992601e-02f, -7.68113658e-02f, -1.19396206e-02f, 1.53927565e-01f, 1.67386189e-01f,
  -1.62887231e-01f, -1.42151460e-01f, 1.23776644e-01f, -3.79247397e-01f, -2.86998272e-01f, 5.01666069e-02f, -3.13020289e-01f, -4.65104133e-02f, -9.46847498e-02f, 6.22942969e-02f,
  1.13903128e-01f, -3.03773314e-01f, -4.86702984e-03f, -3.40960979e-01f, -1.19060621e-01f, -2.70971984e-01f, 1.53808832e-01f, 1.49184093e-01f, 2.87253857e-02f, -4.06920284e-01f,
  4.26886864e-02f, 1.79344773e-01f, -4.72053945e-01f, -2.03641549e-01f, 1.28409341e-01f, -1.30646378e-01f, -1.40851796e-01f, -7.63992816e-02f, -1.57784894e-01f, -2.17898432e-02f,
  -7.50819279e-04f, -1.46218061e-01f, 8.43195319e-02f, -2.41218597e-01f, 1.74766868e-01f, -3.30008529e-02f, -2.41205245e-01f, 8.49324316e-02f, 4.49085869e-02f, -8.88978504e-03f,
  1.64561972e-01f, 1.87552020e-01f, -1.79671705e-01f, -2.61251852e-02f, -1.08518339e-04f, -2.94574481e-02f, -1.72865540e-02f, 1.04532570e-01f, -2.74760336e-01f, -1.11506067e-01f,
  5.71830943e-03f, -2.33764440e-01f, -1.48797721e-01f, 1.11106858e-01f, -2.68559456e-01f, -1.07884325e-01f, -8.73448774e-02f, 6.76995739e-02f, -4.07798886e-01f, -2.37601757e-01f,
  -2.72041470e-01f, -2.08378546e-02f, 9.32977349e-02f, 6.62058741e-02f, -4.15636063e-01f, -2.07214594e-01f, -9.36480388e-02f, -1.71901509e-01f, -5.24795242e-02f, 1.70146063e-01f,
  -9.37068649e-03f, 1.92496449e-01f, 1.12844557e-01f, -3.15174848e-01f, 1.04730874e-01f, 5.19530140e-02f, 2.70054042e-02f, -4.69296813e-01f, -1.40766531e-01f, -2.22479980e-02f,
  -1.90281674e-01f, 1.86503440e-01f, -7.28357211e-02f, 2.15997323e-01f, 7.44928196e-02f, 3.43748182e-02f, -3.24291289e-02f, 5.82072064e-02f, -1.07383698e-01f, 1.93540886e-01f,
  2.76740164e-01f, 1.87335312e-02f, 2.05279782e-01f, 2.14899674e-01f, 1.77716032e-01f, -1.94431990e-01f, -1.07978165e-01f, -1.52556866e-01f, -2.78920591e-01f, 3.26200435e-03f,
  6.82896376e-02f, -5.38896203e-01f, 7.10289329e-02f, -1.37752458e-01f, -3.63125280e-02f, 1.26656696e-01f, -1.21067390e-01f, -1.09099917e-01f, -1.16864279e-01f, -1.95352584e-01f,
  -1.63056955e-01f, 7.45218322e-02f, 1.14443749e-01f, 2.14675128e-01f, -4.09733206e-02f, 1.67884141e-01f, 1.97866514e-01f, -3.15140516e-01f, -3.49482298e-01f, 8.27795565e-02f,
  -1.26848435e-02f, -5.05787611e-01f, 2.41413355e-01f, 7.35995248e-02f, 2.64746137e-03f, -1.65076405e-02f, 7.08491206e-02f, 2.03363001e-01f, 1.11194402e-01f, -1.59403026e-01f,
  -7.65144527e-02f, -3.55678320e-01f, 2.06079066e-01f, -3.30977440e-01f, 1.38362244e-01f, 5.39919958e-02f, 1.00802198e-01f, -1.52947739e-01f, 1.35321870e-01f, -4.86258984e-01f,
  6.00781403e-02f, -5.89528494e-03f, -2.79196143e-01f, -1.44611955e-01f, 6.84262961e-02f, -2.15352830e-02f, -7.20439330e-02f, -3.80237937e-01f, 3.40375245e-01f, -1.16759971e-01f,
  -1.31952643e-01f, 7.91243389e-02f, -2.99398955e-02f, 1.30212352e-01f, -1.83806613e-01f, 1.08005099e-01f, 2.00925115e-02f, -2.64692809e-02f, -1.35368615e-01f, 1.10416070e-01f,
  8.29067305e-02f, 7.89371431e-02f, 1.58763006e-01f, 8.31347704e-02f, 5.35943732e-02f, 1.84408389e-02f, -8.69379938e-02f, 3.15258577e-02f, 6.21896237e-02f, 1.64427683e-01f,
  -1.65195093e-01f, -1.42842919e-01f, 1.58749282e-01f, -1.07544947e+00f, -5.14670193e-01f, -1.06854826e-01f, -3.60601515e-01f, -1.08312573e-02f, -2.91646421e-01f, 4.88357618e-02f,
  3.30454856e-02f, -2.08619028e-01f, 1.78367734e-01f, -3.11100543e-01f, -3.41426916e-02f, -7.02736899e-02f, 3.00169494e-02f, 1.23051055e-01f, 8.07890519e-02f, 1.40020167e-02f,
  2.02201009e-02f, -1.06145046e-03f, 2.66736597e-01f, 2.61804074e-01f, 1.60583690e-01f, 2.29314808e-02f, -1.61451980e-01f, -6.05797991e-02f, -2.77693540e-01f, -3.04811656e-01f,
  -4.17424560e-01f, -5.45510463e-02f, -2.71223038e-01f, -3.32802057e-01f, -4.29630876e-02f, -4.29833606e-02f, 2.45363638e-01f, -3.22372794e-01f, -9.66901332e-02f, -2.05437377e-01f,
  3.80603299e-02f, -2.27428898e-02f, 1.06675483e-01f, 4.36937958e-02f, -3.17570508e-01f, -2.48912200e-01f, 1.22665554e-01f, 5.99696226e-02f, 1.46500662e-01f, 8.31490383e-02f,
  6.13562055e-02f, -1.42710149e-01f, -2.58911878e-01f, -1.60438910e-01f, -2.01749057e-01f, 1.21195421e-01f, 2.66531706e-01f, 3.27873051e-01f, 9.12831351e-02f, -4.28130291e-02f,
  -1.42090410e-01f, -1.69462517e-01f, -8.46569017e-02f, 1.75731361e-03f, 1.68693915e-01f, -7.00557837e-04f, -2.44509242e-02f, -1.06735878e-01f, -8.82264674e-02f, -2.44938090e-01f,
  1.78274736e-02f, -2.82911152e-01f, 8.68419856e-02f, 5.73409162e-03f, -1.20286033e-01f, 1.46150002e-02f, 7.04455823e-02f, -2.70388514e-01f, 4.23866399e-02f, 2.36083746e-01f,
  1.20186009e-01f, 8.39986205e-02f, 1.45917177e-01f, 8.73493031e-03f, 2.79453788e-02f, 6.29732898e-03f, -1.73078150e-01f, -7.72213340e-02f, 9.83541086e-02f, -1.23596499e-02f,
  -4.60886061e-01f, 3.17288265e-02f, -5.78232296e-02f, -1.70658171e-01f, -1.29944548e-01f, 1.65615290e-01f, -7.81444274e-03f, -2.74633437e-01f, -6.03265204e-02f, 1.95666432e-01f,
  -7.17191547e-02f, -1.19940173e-02f, 1.32745579e-01f, -7.81742707e-02f, 8.91319960e-02f, -3.19041550e-01f, -1.49358809e-01f, 1.55995160e-01f, -3.72434825e-01f, -9.17127877e-02f,
  1.63705468e-01f, -1.85390770e-01f, -1.11525699e-01f, -1.66515857e-01f, -3.00052017e-02f, -2.85660058e-01f, -1.52082190e-01f, -3.42873067e-01f, -7.06419274e-02f, -1.39191568e-01f,
  6.59489036e-02f, 1.07728697e-01f, -1.81019306e-01f, -1.30911916e-01f, 9.84771252e-02f, -9.19336304e-02f, 3.56329232e-02f, -1.61213547e-01f, 1.83341533e-01f, 1.46354422e-01f,
  6.64963573e-02f, -2.61148661e-02f, 1.87596325e-02f, 1.40971482e-01f, 4.08456326e-02f, 1.27938896e-01f, -1.13974579e-01f, 2.02645048e-01f, -4.17806119e-01f, -1.84829205e-01f,
  -2.37314641e-01f, -3.40000093e-02f, -1.03004031e-01f, -1.42713115e-01f, 7.77178109e-02f, 7.03154579e-02f, 2.38538519e-01f, 7.40511268e-02f, -8.57114643e-02f, -1.09687239e-01f,
  -4.43907231e-01f, -1.12089906e-02f, 8.10095519e-02f, -3.21894854e-01f, 8.56267512e-02f, 6.76147714e-02f, 6.66754469e-02f, 1.48749143e-01f, 1.34585679e-01f, 1.15443759e-01f,
  -5.81051968e-02f, -3.00958812e-01f, -7.15242103e-02f, -1.69930786e-01f, -5.02414048e-01f, 1.82480901e-01f, 1.30753011e-01f, 2.22866200e-02f, 1.87622324e-01f, -6.93644909e-03f,
  -1.56162918e-01f, -1.69632405e-01f, -3.97234887e-01f, -9.33426665e-04f, 1.29615575e-01f, -4.46346477e-02f, -1.52502269e-01f, 6.01696782e-02f, 1.44002691e-01f, -1.84501652e-02f,
  1.40418962e-01f, 1.04107924e-01f, -9.72115714e-03f, -3.25705945e-01f, -1.68578312e-01f, -2.19482660e-01f, -5.82676470e-01f, 8.95915926e-02f, 5.17657548e-02f, -1.58679977e-01f,
  -2.16863677e-01f, -3.20345312e-01f, -2.26604968e-01f, 1.48932293e-01f, -2.41833791e-01f, -1.76795237e-02f, 1.07119627e-01f, -3.02801132e-01f, 1.84470996e-01f, 1.34777743e-02f,
  1.63413987e-01f, 2.71784514e-02f, -2.73510873e-01f, 1.63199961e-01f, -1.99846774e-01f, 2.22396441e-02f, -1.52908862e-01f, -3.23310941e-02f, 1.19683713e-01f, -4.84307528e-01f,
  -9.19009745e-03f, -1.10663459e-01f, -4.21864122e-01f, -4.56812829e-01f, -3.52145195e-01f, -1.42063364e-01f, 3.63145992e-02f, 6.86969385e-02f, 2.54428476e-01f, -1.40728742e-01f,
  -3.10092792e-02f, -2.22163298e-03f, 3.94694880e-02f, -5.72184660e-02f, 1.05165923e-02f, 1.68625697e-01f, -1.16780251e-01f, 1.73391104e-01f, -2.27184016e-02f, 6.35704175e-02f,
  -1.86913937e-01f, -1.76403478e-01f, -2.84490615e-01f, -7.28494599e-02f, -1.06942534e-01f, -2.08953217e-01f, 2.65155166e-01f, 1.07226841e-01f, -2.62107998e-02f, -1.36148244e-01f,
  -6.35424033e-02f, 1.02143586e-02f, -3.60656321e-01f, -2.40891069e-01f, 1.02912359e-01f, 2.53468990e-01f, 9.88094658e-02f, 1.79135621e-01f, -1.91750079e-01f, -4.32016999e-02f,
  -4.42805886e-02f, 3.02667599e-02f, -2.78671887e-02f, -6.73321486e-02f, -1.23238839e-01f, 7.78270885e-02f, 9.50291008e-03f, -3.39628905e-01f, 1.10571340e-01f, 7.13076768e-03f,
  9.00819898e-02f, 6.25220761e-02f, -1.87785804e-01f, 1.10109068e-01f, 1.47799447e-01f, -2.57023782e-01f, 2.00524732e-01f, 1.81639478e-01f, 8.11237171e-02f, -3.64895649e-02f,
  2.38557532e-02f, -5.73926531e-02f, -1.38717979e-01f, -8.61988142e-02f, -1.87896669e-01f, -8.26458856e-02f, -9.10783336e-02f, 7.29458407e-02f, 1.42720133e-01f, 1.36122093e-01f,
  -3.15228164e-01f, 2.16932088e-01f, -1.47440389e-01f, -1.18119508e-01f, 1.82758421e-01f, -2.14443102e-01f, -2.59333223e-01f, 7.05728531e-02f, -1.06833307e-02f, -1.04314219e-02f,
  3.64014246e-02f, -1.60746381e-01f, -7.90414512e-02f, -5.91125041e-02f, 1.20422557e-01f, 1.25271916e-01f, -3.75156641e-01f, -1.41659364e-01f, 1.68585941e-01f, 2.49852855e-02f,
  -3.01954329e-01f, 1.05911046e-02f, -6.04375526e-02f, -9.48617526e-04f, -4.63996641e-02f, 9.97481048e-02f, -5.75493611e-02f, -1.24321831e-02f, 1.81218684e-01f, 3.29650015e-01f,
  3.34903181e-01f, 9.25137009e-03f, 8.99491981e-02f, 2.37542570e-01f, -2.76983321e-01f, 1.62253410e-01f, 5.76178951e-04f, 3.39132547e-02f, 3.19706053e-02f, 6.62353337e-02f,
  -4.20621574e-01f, 9.60910022e-02f, -2.61686474e-01f, -4.12695348e-01f, -1.19149894e-01f, 2.41563335e-01f, 9.22105536e-02f, 1.65333986e-01f, -2.66503751e-01f, 6.61966279e-02f,
  -1.43859178e-01f, -2.80544221e-01f, -1.83531389e-01f, 1.57512382e-01f, -2.69600209e-02f, 2.43732601e-01f, -1.72215432e-01f, -2.00565442e-01f, -2.16065142e-02f, -6.21864200e-02f,
  -2.12576300e-01f, -2.72072345e-01f, 8.53756145e-02f, -5.50831854e-01f, -3.27467561e-01f, -1.84350371e-01f, 7.17698708e-02f, -5.18212020e-02f, 8.75403658e-02f, -1.00715600e-01f,
  1.48278937e-01f, -2.60874808e-01f, 5.71024455e-02f, -1.00080185e-02f, 5.64366393e-03f, 7.48506710e-02f, -2.16681492e-02f, 1.48327589e-01f, -4.17751044e-01f, -1.56019509e-01f,
  -2.83014148e-01f, 2.06244923e-03f, -1.38025479e-02f, -2.53507137e-01f, 3.76975834e-02f, -1.60805762e-01f, 7.70197362e-02f, 8.99393931e-02f, 1.66416243e-01f, 9.05688107e-02f,
  -8.83211270e-02f, -5.25468662e-02f, 2.45034806e-02f, 3.10636107e-02f, 2.80515641e-01f, 2.94636011e-01f, -6.37444705e-02f, -3.41762781e-01f, -1.19613327e-01f, -1.57449245e-01f,
  5.90460934e-02f, -1.44236490e-01f, -2.49488637e-01f, -3.03734183e-01f, 1.62811071e-01f, 9.09481645e-02f, -4.94187996e-02f, -2.10151598e-01f, 1.29850820e-01f, 1.54684791e-02f,
  1.94132358e-01f, 5.18673584e-02f, 1.05811588e-01f, -1.26419485e-01f, 7.80608207e-02f, 4.98469397e-02f, -3.93219143e-01f, 7.75534958e-02f, 7.46899322e-02f, -5.48654020e-01f,
  2.39274412e-01f, -7.99378902e-02f, 1.32655771e-02f, 1.04949698e-01f, -3.00994188e-01f, 1.30119041e-01f, -1.61697075e-01f, -2.54678637e-01f, -5.39097667e-01f, 2.64425501e-02f,
  1.76501662e-01f, -3.09320390e-01f, -1.78130329e-01f, -1.05410352e-01f, -4.07382293e-04f, 8.54895636e-02f, -2.72860765e-01f, 6.76856712e-02f, -5.86754009e-02f, 1.61345795e-01f,
  -4.63723123e-01f, -1.48835510e-01f, 9.88134742e-02f, -1.02369726e-01f, 3.03163938e-02f, -1.58044547e-01f, -2.21674498e-02f, 7.84108043e-02f, -1.07914116e-02f, 2.01005772e-01f,
  9.23476275e-03f, 4.41442877e-02f, -3.30916569e-02f, 7.42533952e-02f, 1.54354289e-01f, -8.94552469e-02f, 2.20671013e-01f, -1.22555502e-01f, 1.17162816e-01f, 2.78407693e-01f,
  1.43588424e-01f, 3.18065852e-01f, 1.47968635e-01f, 2.69758124e-02f, -9.07045826e-02f, -1.44179255e-01f, -3.76607686e-01f, 1.79417521e-01f, -1.10826895e-01f, 1.85261130e-01f,
  -3.92569184e-01f, -5.45599639e-01f, 1.46980718e-01f, -2.56639093e-01f, 8.16343650e-02f, -3.50876242e-01f, -3.32414448e-01f, -3.98065776e-01f, -2.52905451e-02f, -1.96143150e-01f,
  2.56787598e-01f, -8.26538429e-02f, -6.94958270e-02f, -2.06442684e-01f, -2.19300121e-01f, 1.41992003e-01f, -2.07685217e-01f, -8.56888443e-02f, -1.66571915e-01f, 1.86872721e-01f,
  5.04522771e-02f, -3.87860149e-01f, -1.60282090e-01f, -3.11484709e-02f, -2.42268056e-01f, 1.21525899e-01f, -6.05807602e-01f, -3.96208465e-02f, 1.20922081e-01f, -3.36483330e-01f,
  8.92583355e-02f, -4.66933072e-01f, -1.50857270e-02f, 1.89265162e-01f, -4.99034151e-02f, 9.63402316e-02f, -8.76102820e-02f, -2.10741162e-01f, -2.92647555e-02f, -1.73506469e-01f,
  -3.90489399e-01f, -3.36935997e-01f, 3.26776683e-01f, -3.67195666e-01f, -1.45993024e-01f, -3.68570979e-03f, -1.62609056e-01f, -1.49431810e-01f, -4.33743112e-02f, 5.45510724e-02f,
  -9.86266360e-02f, -3.57729313e-03f, 9.51135084e-02f, -3.45769823e-02f, 1.79482818e-01f, -7.25167245e-02f, -4.45506126e-01f, 1.99098513e-01f, -6.02059066e-02f, 1.06948934e-01f,
  4.43500355e-02f, -2.09754914e-01f, -1.61371127e-01f, 7.29430690e-02f, 6.09774590e-02f, -1.09335110e-01f, -1.94710381e-02f, -2.69797176e-01f, 2.59916242e-02f, 1.52355865e-01f,
  1.53552983e-02f, 5.85878193e-02f, -1.00192197e-01f, 1.86519966e-01f, 5.68498224e-02f, 1.41702682e-01f, -9.76958349e-02f, 5.29175578e-03f, 3.58012989e-02f, -3.00669402e-01f,
  2.20265567e-01f, 1.16772301e-01f, -5.47660291e-02f, -3.40613455e-01f, 1.82971265e-02f, -4.30014610e-01f, -3.31600010e-01f, -6.59101978e-02f, -1.84408292e-01f, 4.94191907e-02f,
  -3.99964988e-01f, -2.54196167e-01f, -7.07299113e-02f, 1.84513152e-01f, -3.83973271e-01f, 6.56034425e-02f, 4.15872671e-02f, -3.13460559e-01f, -5.60606122e-02f, 1.77045181e-01f,
  1.64813206e-01f, -6.21340908e-02f, 2.41397321e-02f, -3.40949893e-01f, 2.51917206e-02f, 1.54487953e-01f, -2.47244880e-01f, -1.51733100e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.50338888e-01f, -1.55076742e-01f, 9.15042013e-02f, -5.13568856e-02f, 1.03592955e-01f, 1.75472066e-01f, 7.78343529e-02f, -5.17693907e-02f, -1.88952573e-02f, -5.17539382e-02f,
  1.24057621e-01f, -9.56157446e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    