/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.76671159e-01f, 2.52202936e-02f, 3.07511866e-01f, 1.20878210e-02f, 7.26451650e-02f, -4.75291535e-02f, -8.20337757e-02f, -5.49948588e-02f, 1.21694490e-01f, 3.94089930e-02f,
  1.60239935e-01f, -2.22857609e-01f, -5.31193875e-02f, -4.89149988e-02f, -3.42601240e-02f, -1.11773998e-01f, 1.03471093e-01f, 1.88200381e-02f, -1.68262035e-01f, -2.05946252e-01f,
  -1.94260597e-01f, -1.52595088e-01f, 6.79272169e-04f, -5.13144583e-03f, 3.93340960e-02f, -1.31280884e-01f, 1.46054164e-01f, 4.63447869e-02f, -2.71445177e-02f, 1.48965776e-01f,
  -6.13838471e-02f, 2.97254205e-01f, 1.02159508e-01f, 1.83888465e-01f, 3.40544395e-02f, 1.29756466e-01f, 7.48153105e-02f, 2.94053145e-02f, -2.13340148e-02f, 1.02577955e-01f,
  1.03518300e-01f, 4.55879346e-02f, 5.27727269e-02f, 3.77389346e-03f, 1.35615319e-01f, 1.41146213e-01f, 1.79931149e-01f, 7.07252696e-02f, 7.80611634e-02f, 1.08170196e-01f,
  7.26645514e-02f, 1.62703991e-01f, 2.07719117e-01f, 6.81613162e-02f, 9.55508575e-02f, 1.33894145e-01f, 4.43831235e-02f, 1.69646636e-01f, 2.05822200e-01f, 1.42931998e-01f,
  -7.34675601e-02f, -2.51265261e-02f, -4.34021093e-02f, -4.12383042e-02f, -1.05322249e-01f, 6.26833066e-02f, -5.39484574e-03f, -1.28478885e-01f, -4.89097573e-02f, -9.19192359e-02f,
  -3.99238504e-02f, -1.30049348e-01f, -6.40539899e-02f, -5.27512170e-02f, -1.24536075e-01f, 6.44493103e-02f, -2.98530124e-02f, -8.32688734e-02f, -4.07930985e-02f, -1.51525857e-02f,
  1.01675987e-02f, -1.02903079e-02f, -9.68916714e-02f, -8.75285044e-02f, 4.73601706e-02f, -3.87240238e-02f, 2.09542201e-03f, -8.31574015e-03f, -1.21933684e-01f, 1.65030267e-02f,
  -1.44513652e-01f, 9.80840176e-02f, 1.30225822e-01f, 1.23813227e-01f, -2.64390782e-02f, 5.61228618e-02f, -3.36707532e-02f, 7.44845644e-02f, 8.82600248e-02f, -2.60490030e-02f,
  -1.29436534e-02f, 7.30356425e-02f, -2.40079574e-02f, 8.09743851e-02f, -1.21758528e-01f, 5.96329756e-02f, 7.88046122e-02f, 9.43697318e-02f, 4.78625111e-02f, 3.04026101e-02f,
  1.12474173e-01f, 1.73081942e-02f, 3.84087078e-02f, 4.39397395e-02f, 9.64656398e-02f, 1.02600995e-02f, 2.59946864e-02f, -4.91562067e-03f, 1.23245537e-01f, -1.25739962e-01f,
  1.72654748e-01f, -5.90924583e-02f, -1.88795313e-01f, 1.02877140e-01f, 4.25209254e-02f, -8.14448223e-02f, -1.70492738e-01f, -6.63977414e-02f, 1.90161690e-02f, -5.55174090e-02f,
  2.51274079e-01f, 2.70779669e-01f, 3.40947479e-01f, 1.91157952e-01f, 6.82223141e-02f, -2.21057191e-01f, -7.42180943e-02f, -6.50202185e-02f, -1.17839128e-01f, -1.39047295e-01f,
  8.12701974e-03f, -1.49547324e-01f, 3.42906415e-02f, 1.77737530e-02f, -6.47209659e-02f, 2.27372944e-02f, -4.01581153e-02f, -2.67146733e-02f, 6.50756285e-02f, -2.01617494e-01f,
  -2.80494630e-01f, 1.06499285e-01f, 5.26913144e-02f, 1.86160982e-01f, 1.09086066e-01f, 5.59845380e-02f, 6.15469506e-03f, 1.13698818e-01f, 8.80021155e-02f, 8.06455221e-03f,
  1.46006510e-01f, 1.13729075e-01f, 1.21666856e-01f, 1.85828432e-02f, -6.71238452e-02f, 5.93009703e-02f, 1.21916749e-01f, 3.47659029e-02f, 6.47920072e-02f, -5.56796044e-02f,
  1.03016213e-01f, 9.27967206e-02f, 3.54101285e-02f, 4.07134257e-02f, 4.78383154e-02f, 1.48783207e-01f, -1.24692963e-02f, 1.21024363e-01f, 1.67897493e-01f, -1.93361655e-01f,
  4.41175252e-02f, -6.65152371e-02f, -1.52986990e-02f, -2.20283419e-02f, -4.36512120e-02f, 6.00884296e-02f, 1.38803264e-02f, 4.62152101e-02f, -6.92478716e-02f, -4.57726866e-02f,
  2.59937812e-02f, -3.56275067e-02f, -2.26899087e-02f, 6.20035939e-02f, -3.67797120e-03f, -4.47563455e-03f, -7.01423064e-02f, 5.43279834e-02f, 4.00615036e-02f, 8.35500881e-02f,
  1.63169280e-02f, -3.78466435e-02f, 9.28219594e-03f, -7.76059180e-02f, 4.00934219e-02f, 8.85847136e-02f, 1.61279179e-02f, 1.08354844e-01f, 7.60546029e-02f, -8.28021672e-03f,
  -1.71569809e-01f, 3.18072826e-01f, -1.36793166e-01f, -7.63345324e-03f, -5.53448014e-02f, 3.20532247e-02f, 3.96390222e-02f, 2.08269823e-02f, 1.04445487e-01f, 1.66305471e-02f,
  1.94440708e-02f, 1.60078965e-02f, 4.85551730e-02f, -3.73396580e-03f, 1.99178867e-02f, -2.64761616e-02f, 1.48037616e-02f, -5.36047444e-02f, 3.82482894e-02f, -8.06611180e-02f,
  -6.84812665e-02f, -1.03892624e-01f, -7.25364834e-02f, -3.10297105e-02f, -5.12075946e-02f, 1.07372587e-03f, -1.26289934e-01f, -1.59846768e-01f, -9.14361849e-02f, -3.45825076e-01f,
  -7.50520587e-01f, -8.58341381e-02f, 2.42957771e-01f, -4.96725440e-01f, -4.89638969e-02f, 1.93285346e-01f, -1.63292624e-02f, 2.71624327e-02f, -2.90095240e-01f, -2.04291180e-01f,
  5.46043850e-02f, 1.07806608e-01f, 1.29277810e-01f, 2.61997610e-01f, 2.36072943e-01f, -1.53506696e-01f, -3.33750755e-01f, 1.99999809e-01f, 4.74942833e-01f, 3.32125276e-01f,
  1.48027897e-01f, -1.92757785e-01f, -3.71692069e-02f, 2.26664707e-01f, -2.73746252e-01f, -3.10408603e-02f, -2.63498396e-01f, -1.63258001e-01f, 2.23780960e-01f, -4.00254250e-01f,
  1.66280761e-01f, -9.82197970e-02f, 1.20507337e-01f, -5.12213632e-02f, 7.24413544e-02f, 4.12019622e-03f, -1.44447675e-02f, -5.92811517e-02f, 3.63316275e-02f, -9.86169875e-02f,
  -2.00182796e-02f, 5.71971536e-02f, -5.18558100e-02f, 7.47413235e-03f, -3.86461057e-02f, -6.09544516e-02f, -9.23026260e-03f, 5.47542386e-02f, -5.01486547e-02f, 7.09176138e-02f,
  1.00357747e-02f, 7.37480298e-02f, -4.06146273e-02f, 8.63467306e-02f, 1.42307252e-01f, 8.04719776e-02f, 1.22413240e-01f, 8.53089988e-02f, 8.09740573e-02f, -2.14252993e-01f,
  -5.74282967e-02f, 4.89231534e-02f, 7.17960671e-02f, 5.23260795e-02f, 3.78202833e-02f, 2.07961071e-02f, -1.43209100e-02f, -5.75249642e-02f, 5.46571612e-02f, 8.13852847e-02f,
  -1.30220568e-02f, 2.01509260e-02f, 9.21295360e-02f, -5.24195917e-02f, -3.46921347e-02f, -1.67736504e-02f, 2.94246562e-02f, -3.36844511e-02f, 7.79966870e-03f, -7.35659599e-02f,
  5.39525226e-02f, -2.56630331e-02f, -3.97812910e-02f, 8.82529616e-02f, -5.94515773e-03f, 2.39495467e-02f, -7.54023064e-03f, 6.93570748e-02f, -2.21544430e-02f, 9.09698009e-03f,
  -2.25809962e-01f, 1.19405843e-01f, -6.36159778e-02f, 7.88808912e-02f, -9.07744989e-02f, 2.59934738e-03f, -6.67382106e-02f, -1.89708564e-02f, -6.05495386e-02f, -1.50278527e-02f,
  2.08420344e-02f, -2.42565311e-02f, 1.44664692e-02f, 3.02684978e-02f, 3.15744244e-02f, -4.17507514e-02f, 4.62817512e-02f, -7.47463778e-02f, 4.28353772e-02f, -5.14144860e-02f,
  1.91016272e-02f, -3.31843644e-02f, -7.90844262e-02f, -6.24276362e-02f, 6.00060215e-03f, -7.42326155e-02f, -2.16603950e-02f, 1.89216062e-02f, 1.89756751e-02f, -1.42301753e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.63706195e-01f, 8.34720880e-02f, -4.36664224e-02f, -1.52584063e-02f, 1.76904902e-01f, -1.72917053e-01f, -3.65647852e-01f, -5.11198223e-01f, -1.59329265e-01f, 1.25558168e-01f,
  2.35841930e-01f, 2.40289226e-01f, 2.48519003e-01f, 6.03793561e-02f, -3.44378650e-01f, 1.16995573e-01f, 4.40177590e-01f, -5.49004711e-02f, -4.88772184e-01f, -5.62307179e-01f,
  3.57044548e-01f, -3.36067155e-02f, -2.00706214e-01f, -1.47336319e-01f, 1.26876608e-01f, 1.02846019e-01f, 2.50292510e-01f, 1.97334856e-01f, 1.93566799e-01f, 3.69262338e-01f,
  1.57906771e-01f, -5.76676846e-01f, -2.70025302e-02f, -5.25452122e-02f, 1.67350471e-01f, -1.53015807e-01f, -8.20250735e-02f, -1.49222791e-01f, -2.63696164e-02f, 1.30350932e-01f,
  4.22940329e-02f, -3.70617509e-02f, 1.27958015e-01f, 8.20318144e-03f, -1.19309938e-02f, -2.02225566e-01f, -1.36815369e-01f, -4.37033802e-01f, -2.41059110e-01f, -2.21271142e-01f,
  2.62331635e-01f, 4.20929268e-02f, -3.93889725e-01f, -1.81044310e-01f, -3.12939554e-01f, 1.97763324e-01f, -4.29580867e-01f, -4.27357882e-01f, -5.03108561e-01f, -3.32053363e-01f,
  -9.65286195e-02f, 5.40940240e-02f, -1.02415301e-01f, -7.35085979e-02f, 1.96271949e-02f, -6.34340942e-02f, 9.71970558e-02f, 1.25827849e-01f, 2.08669901e-02f, -1.16230577e-01f,
  5.24291396e-02f, 2.68300697e-02f, 1.13838844e-01f, -4.68236953e-02f, 9.59211439e-02f, -5.66668771e-02f, 2.76283324e-02f, 2.89332252e-02f, -4.94191386e-02f, -6.27409965e-02f,
  1.97060383e-03f, -6.36395738e-02f, 1.64315075e-01f, 4.84524332e-02f, -8.30774754e-02f, -1.51240706e-01f, 3.26069221e-02f, -3.14663909e-02f, -1.31815076e-01f, 6.03297278e-02f,
  1.94829509e-01f, 2.28987843e-01f, -3.21713416e-03f, 3.19402590e-02f, 7.79351741e-02f, 2.69006342e-02f, 1.12913243e-01f, 1.51561610e-02f, 1.72369525e-01f, -9.08122361e-02f,
  -2.92405691e-02f, 5.46523221e-02f, 2.36007094e-01f, 7.75872990e-02f, -8.21066871e-02f, 8.02390352e-02f, 1.94820628e-01f, 3.55097875e-02f, -8.86397809e-02f, 1.13611124e-01f,
  2.40804017e-01f, -2.15606943e-01f, -2.65705884e-01f, -6.83576837e-02f, -1.81622308e-04f, -1.71799108e-01f, 8.17783251e-02f, -6.50658235e-02f, -1.39092326e-01f, 7.28472993e-02f,
  -6.54238939e-01f, -9.66413379e-01f, 3.32016617e-01f, -2.44358882e-01f, 1.75059870e-01f, -1.23459049e-01f, -9.01586294e-01f, -2.97584057e-01f, -8.74783937e-03f, -4.45629895e-01f,
  -9.10305325e-03f, 1.44142415e-02f, 3.28408331e-02f, 6.24136515e-02f, -4.02039170e-01f, -9.19061422e-01f, -3.37953717e-01f, 7.57954419e-02f, 3.89049761e-02f, -4.74599630e-01f,
  -3.03610682e-01f, 1.25341332e-02f, 3.16149533e-01f, 1.51011407e-01f, -9.24523845e-02f, 4.06389624e-01f, 3.74181718e-01f, -3.50550632e-03f, -7.23408461e-02f, -1.79666087e-01f,
  -1.64928526e-01f, -3.44019532e-01f, 2.06575722e-01f, -1.72892392e-01f, -2.08582990e-02f, 4.06660736e-02f, -3.15900385e-01f, 2.94994712e-01f, 9.36223865e-02f, -7.35385418e-02f,
  8.28648582e-02f, 2.69982935e-04f, 3.61998342e-02f, 1.26868397e-01f, -7.70088360e-02f, -2.17494950e-01f, 1.80881470e-02f, -3.33688796e-01f, 5.21736145e-02f, -3.82658690e-01f,
  -1.11376643e-01f, -1.70910001e-01f, 1.07921913e-01f, 1.45803481e-01f, -1.00214869e-01f, 4.36427370e-02f, 3.83417279e-01f, 1.84990302e-01f, 3.78062904e-01f, 1.10051334e-01f,
  1.01351989e-02f, -5.47556505e-02f, 2.96819638e-02f, 3.00062243e-02f, -7.45586678e-02f, 6.64747655e-02f, 1.22903652e-01f, -4.45244871e-02f, -7.67946467e-02f, -8.56506228e-02f,
  6.59727678e-02f, -6.40423149e-02f, -4.51761223e-02f, -2.42923602e-01f, 5.21532334e-02f, 9.45154354e-02f, 3.54770049e-02f, -5.49563393e-02f, 4.58274130e-03f, -3.91084366e-02f,
  9.49967280e-02f, 2.13628441e-01f, -4.53821011e-03f, 6.77798912e-02f, -7.36651346e-02f, -1.45950153e-01f, 9.57889706e-02f, 1.15257412e-01f, -5.24990447e-02f, -1.64723501e-01f,
  -1.07620820e-01f, 2.23413289e-01f, -1.03750460e-01f, 1.38727993e-01f, -4.95783053e-02f, 1.19524814e-01f, 1.71587139e-01f, 2.36180127e-02f, -7.19823763e-02f, -1.13743186e-01f,
  -1.80531725e-01f, -2.11204678e-01f, 5.45555651e-02f, 1.01721272e-01f, -1.53472144e-02f, -1.19699212e-02f, -1.81844056e-01f, 2.15614334e-01f, -7.01642130e-03f, -1.70822322e-01f,
  -4.20424603e-02f, -2.66228616e-01f, -4.09337759e-01f, -1.92254826e-01f, -3.82450104e-01f, -2.73368686e-01f, -1.30362704e-01f, 7.48752877e-02f, -6.72175661e-02f, -4.38704729e-01f,
  1.29102603e-01f, -7.82274783e-01f, 5.33719778e-01f, -1.23333298e-01f, 1.69023395e-01f, 2.28354290e-01f, 2.40350321e-01f, -1.10479668e-01f, -2.65131354e-01f, -1.29458487e-01f,
  -8.78445581e-02f, 9.71557125e-02f, 1.49956718e-01f, 2.64148228e-02f, 3.19718122e-02f, 3.83010171e-02f, -3.61533165e-02f, 4.28255737e-01f, 5.65716565e-01f, 2.10979983e-01f,
  -2.40122974e-01f, -9.70951170e-02f, -2.66968489e-01f, -2.29609504e-01f, -1.34370834e-01f, 1.49735138e-01f, -8.88865814e-02f, -1.57984897e-01f, -8.59538168e-02f, 6.09769411e-02f,
  3.53804767e-01f, -4.23177183e-01f, 1.35763004e-01f, -4.15016204e-01f, -4.95323837e-02f, -1.87710553e-01f, 1.23336010e-01f, -5.27773276e-02f, -3.84943886e-03f, 4.35251035e-02f,
  -7.55114853e-02f, -1.91125914e-01f, 5.69140725e-02f, -2.19805781e-02f, -9.60671436e-03f, -5.16627776e-03f, -1.90018207e-01f, -1.31829843e-01f, -1.53497785e-01f, -1.17802583e-01f,
  -3.41266900e-01f, 2.41021328e-02f, 1.15415387e-01f, -2.52202414e-02f, -2.08845377e-01f, 9.43921730e-02f, -1.08460538e-01f, -1.28665909e-01f, -1.30651519e-01f, -1.82152316e-01f,
  -1.48482159e-01f, 1.31805763e-01f, -3.26038785e-02f, 1.21380659e-02f, 8.31195489e-02f, 2.15194836e-01f, 9.89670679e-02f, 1.17877394e-01f, -6.29433468e-02f, 1.20469406e-02f,
  -1.93445459e-02f, 9.75149572e-02f, -5.08214459e-02f, -1.45411696e-02f, -1.01860188e-01f, 7.12966453e-03f, 7.17120692e-02f, -5.44104502e-02f, 1.40452702e-02f, -2.05605216e-02f,
  -4.92535233e-02f, 8.09017643e-02f, 8.92407447e-02f, 5.85308187e-02f, -1.02752363e-02f, -4.79488857e-02f, 1.09647803e-01f, -1.27645642e-01f, 4.15091850e-02f, -1.75245255e-02f,
  -1.82486568e-02f, -1.45892128e-01f, 2.25636616e-01f, 7.77977109e-02f, 1.14982627e-01f, -4.72321920e-02f, -1.22177266e-02f, 4.79389401e-03f, 3.31994854e-02f, 1.46177307e-01f,
  1.95928346e-02f, 1.35503367e-01f, 7.63655156e-02f, -1.06233679e-01f, 2.58928895e-01f, 8.31172839e-02f, -2.22560182e-01f, 9.87385735e-02f, -1.49285838e-01f, -1.11935571e-01f,
  -1.58233121e-01f, 7.83205479e-02f, 3.49677533e-01f, 1.73334017e-01f, 8.74936506e-02f, 3.49630564e-01f, 1.56041458e-01f, 6.17895350e-02f, 3.29452187e-01f, 1.83847204e-01f,
  7.24814653e-01f, 7.72756338e-01f, 6.05576992e-01f, -3.26029621e-02f, 2.68575456e-02f, 2.81889349e-01f, 5.31649649e-01f, 2.44904950e-01f, -1.36306301e-01f, 1.58019245e-01f,
  3.51244211e-01f, -1.18576944e-01f, -7.82981217e-02f, 2.89915223e-02f, 4.03354675e-01f, 1.95268810e-01f, -9.55990180e-02f, 1.34376347e-01f, -9.04620066e-02f, -1.27494305e-01f,
  -3.60428810e-01f, -5.13890311e-02f, 2.42223442e-01f, -5.71695268e-02f, 8.70614648e-02f, -1.27293423e-01f, 2.42984220e-01f, 3.74576241e-01f, 3.37607473e-01f, 8.91442001e-02f,
  3.47609073e-01f, 4.95908946e-01f, -3.98318917e-01f, 7.18030781e-02f, 6.54711723e-02f, -4.34137620e-02f, -1.37504965e-01f, 1.00238025e-02f, -5.23923077e-02f, -7.78143033e-02f,
  1.40229449e-01f, 1.20618129e-02f, 3.11404560e-02f, 3.87415849e-02f, 1.61094993e-01f, 1.08372651e-01f, -2.60710064e-02f, 3.18654515e-02f, 1.95368826e-02f, 1.77903652e-01f,
  -1.87366530e-01f, 1.05245568e-01f, 1.53054938e-01f, -8.00242722e-02f, 9.10597816e-02f, -1.44287914e-01f, 1.39944941e-01f, 1.16298623e-01f, 1.80249110e-01f, 8.38682353e-02f,
  -1.93516523e-01f, -1.02871977e-01f, -8.80546123e-02f, -1.85809299e-01f, -5.47530279e-02f, -1.55023322e-01f, -1.30300581e-01f, 4.75293249e-02f, -4.31901030e-02f, -1.10805323e-02f,
  -1.54817119e-01f, -3.02602295e-02f, 1.40997216e-01f, -5.36746942e-02f, -1.28316149e-01f, -1.06769437e-02f, -5.08479737e-02f, -2.55339220e-02f, 4.46083099e-02f, -2.57081725e-02f,
  -1.05313165e-02f, 7.24529251e-02f, 7.61176124e-02f, 1.16292499e-01f, 1.01403832e-01f, 2.71160584e-02f, -3.03651411e-02f, -4.48722281e-02f, -9.36061069e-02f, -1.18947849e-01f,
  -7.09128827e-02f, 8.11391547e-02f, -2.40841553e-01f, 9.50239412e-03f, 2.20526204e-01f, 7.96352103e-02f, 1.09441072e-01f, -6.82710931e-02f, -2.56942865e-02f, 5.52232042e-02f,
  2.48270333e-01f, 8.53793472e-02f, 1.17937587e-01f, 2.00692806e-02f, -8.67901891e-02f, -5.31571619e-02f, -4.95286332e-03f, 7.50935003e-02f, 9.91757661e-02f, 1.08229600e-01f,
  -8.34123883e-03f, -1.09494679e-01f, -1.57616243e-01f, -1.67564318e-01f, -6.13391921e-02f, -1.82702512e-01f, -6.05392903e-02f, 6.29805028e-02f, 2.06705511e-01f, -1.81540996e-01f,
  6.90932393e-01f, -8.22393149e-02f, -1.20178115e+00f, -1.05335131e-01f, -8.31434786e-01f, -7.38504827e-01f, -6.42059684e-01f, 6.04275279e-02f, 1.94437224e-02f, -4.11489964e-01f,
  -1.97745666e-01f, 3.68327081e-01f, -5.82610704e-02f, -1.16106980e-01f, -1.46522030e-01f, -7.97584891e-01f, -1.03920400e+00f, -7.24385500e-01f, -4.11194503e-01f, -1.99733406e-01f,
  -2.37907648e-01f, -1.46903336e-01f, -2.14160737e-02f, -1.46822199e-01f, -3.37820560e-01f, -1.61285046e-02f, -5.27650356e-01f, -4.82229680e-01f, -3.16488564e-01f, -5.44626951e-01f,
  -3.64135921e-01f, -1.90955937e-01f, -1.16319604e-01f, 1.60797715e-01f, -3.34237337e-01f, 2.89173890e-02f, -5.12725785e-02f, -6.19872548e-02f, -1.17186606e-01f, -7.60782585e-02f,
  8.39960054e-02f, 2.40588412e-01f, -2.25201368e-01f, -1.66533262e-01f, -4.32282463e-02f, -3.83186564e-02f, -9.81709585e-02f, -3.31007242e-01f, -3.58645052e-01f, -9.38417390e-03f,
  -2.04711780e-01f, -2.14105099e-01f, -1.56000510e-01f, -8.94022267e-03f, -1.86317071e-01f, -1.05868191e-01f, -2.85111457e-01f, -1.59426138e-01f, -1.51030481e-01f, 2.08753422e-01f,
  5.82977664e-04f, -4.62367125e-02f, -1.67456120e-02f, -7.08656237e-02f, 4.10660990e-02f, 6.63302615e-02f, 2.23965019e-01f, 5.47483750e-02f, 5.22392355e-02f, 1.36354016e-02f,
  -1.24854058e-01f, -1.68184772e-01f, 4.02216204e-02f, -2.82492694e-02f, -1.43182382e-01f, 9.51958746e-02f, 7.57362545e-02f, -3.86371613e-02f, 5.60454652e-02f, -5.87863550e-02f,
  -6.66789636e-02f, -1.91658922e-02f, -2.79571721e-03f, 9.75400060e-02f, -2.46098980e-01f, -3.54077891e-02f, 1.29204214e-01f, 1.77740246e-01f, 1.51572078e-01f, -6.26470372e-02f,
  4.30412948e-01f, -5.14531672e-01f, 2.04299718e-01f, 3.11558425e-01f, 2.08793655e-02f, 8.89869779e-03f, 1.03294276e-01f, 1.43266782e-01f, 1.72876135e-01f, -1.07976377e-01f,
  9.97222681e-03f, 2.66858548e-01f, -9.54357386e-02f, -1.03110902e-01f, 2.61826478e-02f, -8.02372843e-02f, 2.25348637e-01f, -5.42313345e-02f, 4.87437323e-02f, 1.12463839e-01f,
  -4.89450358e-02f, 2.87619710e-01f, 2.64788926e-01f, 2.41341993e-01f, 7.16058686e-02f, 1.89904213e-01f, -2.14311704e-01f, -4.87259738e-02f, 7.41954148e-02f, 3.46609116e-01f,
  -2.22216845e-01f, 6.24885894e-02f, -4.88060623e-01f, 3.60523343e-01f, 2.60450453e-01f, 2.82228023e-01f, 3.48306179e-01f, 4.19062108e-01f, 3.30564141e-01f, 2.38995790e-01f,
  1.53200001e-01f, 5.56942105e-01f, 4.15275514e-01f, 3.38829190e-01f, 1.41428083e-01f, 1.40173107e-01f, 2.63221353e-01f, -1.03836335e-01f, -2.04964951e-01f, 1.03976019e-01f,
  2.82847196e-01f, -2.28881221e-02f, -2.52366155e-01f, -4.04971205e-02f, -6.69150651e-02f, 1.52353376e-01f, 9.25865695e-02f, -4.66367751e-02f, -3.28299254e-02f, -4.79363762e-02f,
  -6.56097591e-01f, -1.33291855e-01f, 2.86888897e-01f, 8.54371935e-02f, -6.88915551e-02f, -2.55105980e-02f, -1.97375789e-02f, -2.66303029e-02f, 8.76957476e-02f, 1.08964033e-01f,
  -1.47685766e-01f, -4.30739783e-02f, 6.59809485e-02f, -4.67352271e-02f, -1.89652413e-01f, -1.39965773e-01f, -5.94802536e-02f, 1.00349803e-02f, 1.75990850e-01f, 3.12879533e-02f,
  1.65121004e-01f, -1.07204616e-01f, -1.48028299e-01f, 2.06064925e-01f, 1.32956564e-01f, 1.31734312e-01f, -1.19871115e-02f, 5.31294011e-02f, -1.48191229e-02f, 7.00502172e-02f,
  2.23446071e-01f, -3.29354405e-03f, -1.59411103e-01f, 1.45177320e-01f, -2.62528751e-02f, 7.38891438e-02f, -1.45315543e-01f, 4.44172546e-02f, 1.03715129e-01f, -7.47806355e-02f,
  9.30789765e-03f, 1.02058701e-01f, 1.67430073e-01f, -4.05013561e-03f, 3.86604033e-02f, -8.48461408e-04f, -4.40392271e-02f, -9.50212032e-02f, -2.42960025e-02f, 3.90337892e-02f,
  2.60390230e-02f, -5.49004674e-02f, -2.65348613e-01f, -1.72560081e-01f, -7.01127499e-02f, -1.17533142e-02f, -3.18095312e-02f, 1.01926148e-01f, 2.37763077e-02f, 5.25026098e-02f,
  -3.93725513e-03f, 9.42763463e-02f, 1.51559070e-01f, 7.31517226e-02f, -4.28505540e-02f, -5.45527153e-02f, 8.65096450e-02f, -1.03919186e-01f, -1.30887013e-02f, 5.86934350e-02f,
  -1.77993938e-01f, -1.69129014e-01f, -2.47889180e-02f, -2.48540509e-02f, -1.60964385e-01f, -2.01430246e-01f, 4.59228009e-02f, 1.72568947e-01f, -1.83857903e-02f, -1.35363296e-01f,
  6.16969205e-02f, -2.30784360e-02f, -1.35496780e-01f, 1.03986733e-01f, 1.58095777e-01f, 1.67875484e-01f, -9.89982784e-02f, 1.14216628e-02f, -1.29651010e-01f, 1.12566315e-01f,
  -5.49351871e-01f, 5.68922877e-01f, 3.25446188e-01f, -6.45099103e-01f, -1.47326402e-02f, 2.50097036e-01f, 4.79138464e-01f, 6.16658106e-02f, -4.41405326e-02f, 2.94712335e-01f,
  1.91888884e-01f, -5.13450682e-01f, -2.58246779e-01f, -1.34147152e-01f, -6.55231327e-02f, 3.02548766e-01f, -3.58771160e-02f, -3.48474741e-01f, -6.07503235e-01f, -1.30283535e-01f,
  -2.11578384e-01f, -6.65996194e-01f, -6.49827719e-01f, -3.91898245e-01f, -1.42127320e-01f, -6.32943571e-01f, -1.12294644e-01f, -3.72784249e-02f, 3.34728897e-01f, -2.67554373e-01f,
  8.11081678e-02f, 2.93098360e-01f, -8.85554478e-02f, -6.75757080e-02f, -9.74494312e-03f, 2.30506435e-02f, 1.46696284e-01f, -2.04687729e-01f, 2.83891615e-02f, 1.20307460e-01f,
  -8.48827958e-02f, 1.51707545e-01f, -1.27566501e-01f, -1.39940888e-01f, -5.22413924e-02f, 3.60417254e-02f, 1.04749143e-01f, -9.54782292e-02f, 9.15614590e-02f, 3.01238865e-01f,
  2.13408053e-01f, 2.59736866e-01f, 2.05286101e-01f, 1.35472834e-01f, 2.06290722e-01f, -2.27888413e-02f, 2.50265330e-01f, 7.00415149e-02f, 1.74596474e-01f, -1.55134335e-01f,
  8.41824561e-02f, -2.55705938e-02f, -1.22170828e-01f, 1.44174054e-01f, -6.51882514e-02f, 2.00116690e-02f, 3.47693940e-03f, 1.16701433e-02f, -3.10441218e-02f, -1.52589291e-01f,
  9.45521425e-03f, -1.07560623e-02f, -1.25694409e-01f, 6.79464312e-03f, -9.75184068e-02f, -5.46197668e-02f, 5.76981679e-02f, -5.92384487e-02f, 1.40864672e-02f, 2.68093850e-02f,
  1.60758179e-02f, 7.69372210e-02f, 9.41754729e-02f, -1.01522446e-01f, 7.61633068e-02f, -4.25296389e-02f, 1.18538000e-01f, 7.45720640e-02f, -8.97374153e-02f, 1.38348758e-01f,
  -5.77142179e-01f, -8.55013207e-02f, -1.21584311e-01f, -1.86671186e-02f, 1.03165589e-01f, -7.40344590e-03f, 1.64602064e-02f, 9.74202156e-02f, 6.85126036e-02f, 1.37991309e-01f,
  2.27979004e-01f, 5.73178753e-02f, 1.22212823e-02f, 1.85168087e-02f, -1.36031359e-01f, 3.11887376e-02f, 6.12472370e-02f, -1.81530684e-01f, -1.53853903e-02f, 1.54057555e-02f,
  1.25179961e-01f, 5.98795786e-02f, -1.82948738e-01f, -2.98182890e-02f, 9.76526290e-02f, -2.17856497e-01f, -2.47737810e-01f, -1.88398004e-01f, 2.53688972e-02f, -1.83968365e-01f,
  6.01005673e-01f, 4.35717434e-01f, 4.69986200e-01f, 1.18280105e-01f, -2.09312215e-01f, -6.42372847e-01f, -6.81315720e-01f, -4.44725633e-01f, -1.41876280e-01f, 1.14201188e-01f,
  2.45602041e-01f, -5.44811897e-02f, 1.82312101e-01f, -1.76687520e-02f, -3.16087335e-01f, 6.48244545e-02f, 1.02807760e-01f, -2.14140825e-02f, -5.85351229e-01f, -4.85847771e-01f,
  -1.74837649e-01f, 9.21886489e-02f, 2.29369760e-01f, -5.90386800e-02f, 1.74879804e-01f, -2.50669390e-01f, 2.10638955e-01f, 3.33536774e-01f, 5.95825166e-02f, 5.28877676e-01f,
  5.46879470e-01f, 4.22403991e-01f, -3.65365297e-01f, 1.63680757e-03f, 1.38556451e-01f, 3.09936330e-02f, -5.27260117e-02f, 2.16936380e-01f, 3.07030440e-03f, 2.65830398e-01f,
  1.04585521e-01f, 7.81002343e-02f, -2.03720592e-02f, -3.91601436e-02f, -1.82750784e-02f, -1.17598042e-01f, -1.80125292e-02f, 8.66633058e-02f, 2.89016441e-02f, 1.20732121e-01f,
  -1.28087729e-01f, 9.14702117e-02f, 9.10541415e-02f, -3.40018094e-01f, -8.04481655e-02f, 5.81868514e-02f, 6.05701245e-02f, 7.81469345e-02f, -2.45342001e-01f, 1.42702609e-01f,
  -5.88188469e-02f, 5.55310249e-02f, -4.83312309e-02f, 6.21238165e-02f, -4.21444001e-03f, 5.10464609e-02f, -1.37849711e-02f, -6.01323843e-02f, -9.57992673e-02f, 4.53993976e-02f,
  -8.83777887e-02f, 1.61999352e-02f, 8.09350535e-02f, 5.30041456e-02f, -3.30499560e-02f, 1.06301047e-01f, -1.23664699e-01f, -3.83878686e-02f, 1.18085675e-01f, -1.32538239e-02f,
  -1.56330522e-02f, 3.50927263e-02f, 1.19940385e-01f, -3.43292505e-02f, 3.24770063e-02f, 3.87069136e-02f, 1.07772745e-01f, -1.79499332e-02f, 2.43607573e-02f, 8.88550505e-02f,
  -9.42828730e-02f, -4.05650944e-01f, 1.62454084e-01f, -8.68196562e-02f, 1.68892350e-02f, 3.02232485e-02f, 1.80429682e-01f, -7.02350661e-02f, 1.82589844e-01f, -5.48048057e-02f,
  -7.74458051e-02f, 4.82307933e-02f, 1.37537360e-01f, -1.50079414e-01f, -7.67889917e-02f, -3.95903103e-02f, -2.10710196e-03f, -1.79445282e-01f, -1.77796617e-01f, 5.50408661e-03f,
  -1.01674974e-01f, -2.97332495e-01f, -2.59681702e-01f, -3.01053524e-01f, -1.72948852e-01f, -2.83936530e-01f, -2.37111956e-01f, -2.64968395e-01f, -3.39976043e-01f, -2.28538454e-01f,
  1.58193638e-03f, 2.20397174e-01f, -3.28802988e-02f, 1.53600201e-01f, -3.08044165e-01f, -3.82738769e-01f, -2.50629932e-01f, -2.03769639e-01f, -4.90936674e-02f, 7.19273612e-02f,
  -3.28568220e-01f, -3.84717025e-02f, 1.20311882e-02f, 2.88323592e-03f, 6.51975647e-02f, 3.17787796e-01f, 5.18818021e-01f, 4.57592040e-01f, 7.43999630e-02f, -4.01658565e-02f,
  4.70103860e-01f, 1.56924486e-01f, 3.55303474e-02f, 9.42757353e-02f, 3.55651319e-01f, 1.38907619e-02f, -1.37385279e-01f, 8.54694545e-02f, 7.25619793e-02f, 9.56733406e-01f,
  2.93910503e-01f, 7.87407979e-02f, -1.47253558e-01f, -5.26226684e-02f, -2.69303937e-02f, 1.05235130e-01f, -4.25390266e-02f, 3.67663763e-02f, -1.33001372e-01f, -1.11213392e-02f,
  6.60986081e-02f, 7.60155767e-02f, 2.20450431e-01f, 6.74238354e-02f, -1.77662700e-01f, -1.39014855e-01f, -4.14041281e-02f, 4.19280678e-02f, -1.01715349e-01f, 7.47639686e-02f,
  4.19129223e-01f, 9.42726284e-02f, -3.92356038e-01f, -1.62297815e-01f, 1.23423927e-01f, 1.58120021e-01f, -2.25267574e-01f, 5.28181940e-02f, -2.67203569e-01f, 1.50182709e-01f,
  -6.57608137e-02f, -8.45835283e-02f, -1.23080797e-01f, -5.58339693e-02f, -3.39606628e-02f, 3.51996422e-02f, 4.84213345e-02f, 7.27746487e-02f, 1.57923102e-01f, 1.11958213e-01f,
  -1.55753121e-01f, -2.33982783e-02f, -6.45240694e-02f, -1.56142399e-01f, -3.60725038e-02f, -5.06650433e-02f, 9.56076831e-02f, -9.78527814e-02f, -2.52608061e-01f, -1.19301774e-01f,
  2.11012121e-02f, 1.90805960e-02f, -5.89287095e-02f, 1.59283087e-01f, 5.21420129e-02f, -1.15503676e-01f, 1.02560446e-01f, 7.03141699e-03f, 5.39164338e-03f, -1.44168483e-02f,
  -3.26060772e-01f, -4.22758013e-01f, 2.88203001e-01f, 2.49057055e-01f, 1.93962410e-01f, 2.64256764e-02f, 1.93166986e-01f, -4.95326705e-02f, -1.70695290e-01f, -2.39556395e-02f,
  -8.04806352e-02f, -6.21813312e-02f, 8.62148404e-03f, 2.47741980e-03f, -9.67045650e-02f, -2.00892866e-01f, 2.31414139e-01f, 2.14070484e-01f, -2.47487407e-02f, -1.64949223e-01f,
  1.29079238e-01f, -3.41220922e-03f, -3.43903750e-01f, -1.57227069e-01f, 1.21464934e-02f, -1.66002303e-01f, -1.62204638e-01f, 2.95792874e-02f, -4.08867747e-01f, -7.56585374e-02f,
  -7.39374757e-02f, 3.51974182e-02f, 1.16917372e-01f, -1.61499754e-01f, -1.31883055e-01f, -1.11529566e-01f, -1.40797257e-01f, -1.74126297e-01f, -1.89518780e-01f, -2.15107240e-02f,
  1.55736998e-01f, 4.73328292e-01f, 3.86994779e-01f, 2.34248921e-01f, 2.40624025e-01f, 6.40061349e-02f, -1.28236085e-01f, 6.58633187e-02f, 2.05477431e-01f, 9.55600962e-02f,
  2.69492995e-02f, -1.44591168e-01f, 2.02549174e-02f, -3.72838229e-02f, -1.38445213e-01f, 2.51471460e-01f, 1.42705301e-02f, -6.79384321e-02f, 1.53781056e-01f, -3.33919913e-01f,
  7.33558774e-01f, -7.38681629e-02f, 7.82027021e-02f, 1.03076413e-01f, -1.39833195e-02f, 9.54161361e-02f, 1.03147440e-01f, -1.00759402e-01f, -7.13625774e-02f, 1.46766650e-02f,
  7.71335736e-02f, -9.15478840e-02f, -2.23885980e-02f, -8.35621133e-02f, 1.88202765e-02f, 5.58007881e-02f, -1.79263875e-01f, 4.22541909e-02f, 7.18980506e-02f, 2.22666711e-01f,
  3.09199989e-02f, -1.11509696e-01f, 1.57336324e-01f, -5.17118312e-02f, -3.16661857e-02f, 1.28147289e-01f, -1.68803558e-02f, -1.43193096e-01f, 8.84508640e-02f, -1.93685085e-01f,
  4.92636748e-02f, -6.92392662e-02f, 1.12704309e-02f, -9.03784782e-02f, -1.15264595e-01f, -2.63084434e-02f, -4.01392989e-02f, -1.60015762e-01f, -1.34582361e-02f, -1.61414444e-01f,
  -3.22764320e-03f, 1.16196886e-01f, 5.20946346e-02f, 1.84616353e-02f, 2.08218396e-02f, -3.67571600e-03f, -4.08066362e-02f, 3.75510454e-02f, -1.48489922e-01f, -1.53130833e-02f,
  -4.05939892e-02f, 1.50495946e-01f, 4.57333885e-02f, -7.29936585e-02f, -4.09492105e-02f, 3.47748175e-02f, -5.25868759e-02f, -7.25060031e-02f, -6.58125849e-03f, 1.52725708e-02f,
  6.19373560e-01f, 8.15214366e-02f, 1.31476104e-01f, 2.59136432e-03f, -3.04414872e-02f, -8.40190798e-02f, 2.02711597e-01f, -6.74331114e-02f, -1.30451187e-01f, 1.82794884e-01f,
  1.35173157e-01f, 7.50434324e-02f, 2.64638606e-02f, -8.51936638e-02f, -1.31679168e-02f, 1.05986647e-01f, -6.30113110e-02f, 8.50592852e-02f, 5.96127249e-02f, 1.14971042e-01f,
  -5.51601052e-02f, 6.59531057e-02f, 2.87308335e-01f, 1.06098652e-01f, 9.31513757e-02f, 3.12525988e-01f, 2.03239068e-01f, -1.06728869e-02f, 3.08183074e-01f, 1.40508171e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  7.32136846e-01f, 2.03310922e-01f, 2.68362910e-01f, -9.05393139e-02f, 5.94690919e-01f, -5.24247810e-02f, 1.85522035e-01f, 3.81269813e-01f, 1.13112167e-01f, 2.46377289e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.19789195e-01f, -2.13485792e-01f, -3.75695288e-01f, -1.63966313e-01f, -4.44794476e-01f, -8.91812623e-01f, 1.73399989e-02f, -4.12011057e-01f, 1.68190226e-01f, -1.79280937e-01f,
  -6.89461231e-02f, -2.65816301e-01f, 3.00036460e-01f, 3.52108687e-01f, 8.01142380e-02f, -3.49826813e-01f, -6.29144460e-02f, -3.43680620e-01f, -4.68986571e-01f, -2.00769812e-01f,
  -4.85706031e-01f, -1.32978439e-01f, 4.88471061e-01f, -4.86487389e-01f, -2.40794837e-01f, -3.86355698e-01f, 1.63775031e-02f, 1.73278660e-01f, 1.07536204e-01f, -3.19358945e-01f,
  4.20599729e-02f, -1.98644131e-01f, 3.85516733e-02f, -1.00834072e-01f, -1.68293759e-01f, -4.90695201e-02f, -1.58567920e-01f, 4.96234268e-01f, 4.68416214e-02f, 4.01600823e-02f,
  6.21847585e-02f, -5.51450811e-02f, -6.88498318e-02f, -1.67787537e-01f, 1.46722957e-01f, -2.85039723e-01f, -1.00250570e-02f, 3.20387095e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.48062450e-01f, -2.82129914e-01f, -1.16980299e-01f, 3.38331848e-01f, -7.07348406e-01f, -4.23914313e-01f, -5.95348299e-01f, -4.15495634e-01f, 7.73817062e-01f, 4.78935242e-01f,
  -5.56080222e-01f, -6.44078180e-02f, -7.61106312e-02f, 1.61836609e-01f, 7.91011751e-02f, 3.56721252e-01f, 9.56332982e-02f, 3.46377105e-01f, 2.66880065e-01f, 6.29936084e-02f,
  4.12408262e-01f, -8.90337169e-01f, 2.30436191e-01f, -4.20017362e-01f, 1.57354977e-02f, -1.70104280e-01f, 4.73148435e-01f, 6.60267949e-01f, -1.89547375e-01f, 1.81621075e-01f,
  3.39489311e-01f, 4.29168902e-02f, 2.81301528e-01f, 7.06517577e-01f, -2.36925483e-03f, -5.16911969e-05f, 2.07980320e-01f, 2.74235666e-01f, 9.14365709e-01f, 6.47259772e-01f,
  -1.11234069e-01f, -9.91886109e-02f, 7.32751548e-01f, 3.91508400e-01f, 9.13272381e-01f, -1.53151467e-01f, -9.64499414e-02f, 2.77084321e-01f, 3.92704219e-01f, 4.62682337e-01f,
  1.12301223e-01f, -2.50069192e-03f, 3.55807394e-01f, -1.15097947e-01f, 2.47949272e-01f, 9.05495465e-01f, -6.02912486e-01f, 2.82100379e-01f, 5.03282607e-01f, -2.89011329e-01f,
  4.79241431e-01f, 3.87454480e-01f, -3.97668868e-01f, -6.04624487e-03f, 1.39359847e-01f, 3.28380525e-01f, 1.10797989e+00f, 1.66261822e-01f, -2.31312171e-01f, -1.65430412e-01f,
  6.60916030e-01f, 3.00156385e-01f, 5.09932518e-01f, -1.75817877e-01f, 4.53399688e-01f, -4.13379401e-01f, 3.13427821e-02f, 1.30748177e+00f, 7.78502345e-01f, 1.93524137e-01f,
  5.69234908e-01f, 1.45451143e-01f, 4.93251860e-01f, -1.95797876e-01f, 5.30755401e-01f, 6.38639212e-01f, 6.27322435e-01f, 3.47662866e-01f, -3.70207578e-01f, -5.10947883e-01f,
  -8.10965776e-01f, 5.99246100e-02f, -9.13918734e-01f, 3.59960616e-01f, 6.92107856e-01f, -4.61981654e-01f, 3.51593971e-01f, 3.64984453e-01f, 4.99568135e-01f, 4.98871207e-01f,
  -1.01364488e-02f, 6.78671673e-02f, 4.78101939e-01f, 1.93115875e-01f, 1.45856813e-02f, 3.01519036e-01f, -4.05993313e-01f, -1.76616311e-02f, 6.11652493e-01f, 1.20104766e+00f,
  6.68465734e-01f, -5.03091753e-01f, 3.13986868e-01f, -8.78255665e-02f, 5.28454959e-01f, -2.68827438e-01f, -7.21660778e-02f, 5.62223732e-01f, -3.50522399e-01f, 6.76454976e-02f,
  6.14003778e-01f, -4.71023411e-01f, 6.24187946e-01f, -8.24082047e-02f, -7.06994057e-01f, -4.99067307e-01f, 4.38690901e-01f, 3.16731960e-01f, 3.72238427e-01f, 1.03137180e-01f,
  3.70162219e-01f, 3.58656734e-01f, -7.06103563e-01f, -1.49260688e+00f, 3.49125206e-01f, -3.84692609e-01f, 4.65927422e-01f, -4.04561788e-01f, 6.90738618e-01f, 2.65248716e-01f,
  -7.52162337e-01f, 2.49463812e-01f, 2.15333894e-01f, 1.02083143e-02f, 2.58812726e-01f, 5.10810614e-01f, 5.78654766e-01f, 2.32380912e-01f, 4.90345865e-01f, -3.01107228e-01f,
  -1.04491377e+00f, 3.28040794e-02f, 1.08350120e-01f, 3.92084181e-01f, 8.86202380e-02f, -1.81440338e-02f, 3.81226428e-02f, 6.07677177e-02f, 2.47710615e-01f, -8.07783678e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  1.18994825e-01f, 1.79038793e-01f, 4.52776253e-01f, 7.19719350e-01f, 9.87114131e-01f, 4.92376953e-01f, 5.23227215e-01f, 4.91442382e-01f, 9.18655872e-01f, 1.25937313e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.73154116e-01f, -3.25195521e-01f, -3.53509933e-01f, 1.20282240e-01f, -7.92001933e-02f, -3.49184662e-01f, 8.05702880e-02f, 1.07349575e-01f, -1.41520485e-01f, -2.38787726e-01f,
  2.57805258e-01f, -1.74483389e-01f, -1.53078865e-02f, -1.76232859e-01f, 8.39988701e-03f, 4.30263937e-01f, 4.19046223e-01f, 4.73029196e-01f, 2.12213948e-01f, 6.60230517e-01f,
  4.27710682e-01f, -3.23659450e-01f, -1.06929623e-01f, 1.68588355e-01f, 6.06123246e-02f, 1.09584346e-01f, -1.87077075e-01f, 5.95927611e-02f, 8.45874771e-02f, -4.37959671e-01f,
  2.56557107e-01f, -3.46849501e-01f, -4.06955421e-01f, -1.62739143e-01f, -5.18567748e-02f, -5.29537737e-01f, -3.01502377e-01f, -1.49508342e-01f, -4.41063136e-01f, 1.12457499e-01f,
  -2.03540727e-01f, -1.96450368e-01f, 2.96776325e-01f, 2.36364752e-01f, 2.47170925e-02f, 3.38611543e-01f, 2.72158198e-02f, -1.76441863e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -4.09593105e-01f, -6.66305423e-02f, -8.67783725e-02f, -6.97527034e-03f, -1.00743914e+00f, -2.71618783e-01f, -1.00605629e-01f, -6.77105546e-01f, -3.50947171e-01f, 6.75700068e-01f,
  7.62019098e-01f, 9.17854458e-02f, 8.15321743e-01f, -5.94558120e-01f, -3.05230796e-01f, 1.04147725e-01f, 4.05632108e-01f, 3.17607760e-01f, 1.08014691e+00f, 3.03832918e-01f,
  -5.59526205e-01f, -4.76649404e-01f, -3.55236799e-01f, 2.73378968e-01f, 1.92183286e-01f, 3.20642665e-02f, 2.26377919e-01f, 4.24086265e-02f, -7.48844087e-01f, 4.91567403e-01f,
  1.08120000e+00f, 9.35036764e-02f, -2.27540597e-01f, -9.54423726e-01f, 1.30643034e+00f, -3.89077604e-01f, -5.26332498e-01f, -9.91268575e-01f, -2.94681251e-01f, 8.13949525e-01f,
  1.81945711e-01f, 4.06862587e-01f, 8.44525844e-02f, -6.24078155e-01f, 9.01947618e-01f, -2.50767022e-01f, 1.91957131e-01f, 3.59314173e-01f, 8.45390916e-01f, 8.23225379e-01f,
  4.12544787e-01f, 1.27421975e+00f, -6.99399292e-01f, -7.82364309e-01f, 1.96769059e-01f, -1.18306264e-01f, -8.68084073e-01f, 3.71096551e-01f, 6.85510933e-01f, 1.09656610e-01f,
  5.67260623e-01f, -1.31261826e-01f, 6.88938081e-01f, -1.45003855e-01f, 4.06479537e-01f, 3.97208750e-01f, 3.85357887e-01f, -7.53380079e-03f, 4.26922888e-01f, -8.63745883e-02f,
  -9.37503099e-01f, -6.73980340e-02f, 1.72896490e-01f, -9.15746391e-02f, 3.25732917e-01f, 1.93453157e+00f, 1.00491893e+00f, -8.07461441e-01f, 1.53463576e-02f, -9.50020671e-01f,
  -4.96186882e-01f, -4.02288914e-01f, 1.29647240e-01f, -3.46502066e-01f, -1.10854876e+00f, 5.76415539e-01f, 1.42551605e-02f, -9.52342376e-02f, -5.56672335e-01f, -3.31784517e-01f,
  6.18145466e-01f, -3.21058445e-02f, 3.99076194e-01f, 4.98914897e-01f, 2.72104412e-01f, 3.35399717e-01f, 3.51591945e-01f, 6.59809589e-01f, 1.36623770e-01f, -2.15399384e-01f,
  7.41117656e-01f, 1.68263987e-01f, -1.78496659e-01f, 1.30284373e-02f, 4.24963921e-01f, 8.14351976e-01f, 7.63481930e-02f, 9.06747341e-01f, -6.72376335e-01f, 8.81417990e-02f,
  1.32983834e-01f, -4.43730764e-02f, -6.20362312e-02f, 2.09265381e-01f, 1.42489716e-01f, -1.12618983e+00f, -1.47495002e-01f, 1.23619005e-01f, -5.79554319e-01f, -3.84432375e-01f,
  7.71878660e-01f, 5.46058655e-01f, 6.29712105e-01f, -7.01555967e-01f, 5.42441532e-02f, 6.46684289e-01f, -1.89507287e-02f, -2.59961069e-01f, 4.66908842e-01f, 2.56940484e-01f,
  -1.66154727e-01f, 5.55450544e-02f, 1.69162124e-01f, 8.16821903e-02f, 1.81557789e-01f, 6.56633377e-01f, 9.56469998e-02f, -1.01713932e+00f, 6.23557985e-01f, 1.03310093e-01f,
  2.89324895e-02f, 5.93498647e-01f, 1.08758211e+00f, -2.19328791e-01f, 1.16091895e+00f, 1.35074401e+00f, 1.81384534e-01f, 4.86089587e-01f, 6.20770395e-01f, 6.58999756e-02f,
  -6.88116670e-01f, 6.13969751e-02f, 8.58151793e-01f, 3.61882061e-01f, 2.98598289e-01f, -2.05513552e-01f, 3.97370219e-01f, -8.49531949e-01f, -3.59375179e-01f, -1.16956425e+00f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  6.08233988e-01f, 5.35779774e-01f, 2.34832495e-01f, 5.87374642e-02f, 4.35375810e-01f, 2.50067562e-01f, 1.94590449e-01f, 2.25105301e-01f, 1.53587818e-01f, 4.43432122e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -1.07537341e+00f, -1.68851435e-01f, 6.24431968e-01f, -9.01211575e-02f, -2.15472296e-01f, -2.84447014e-01f, -2.70042777e-01f, 4.19248164e-01f, 1.09055173e-02f, -6.45244360e-01f,
  -1.64604807e+00f, -7.29032457e-01f, 4.01495963e-01f, 2.39506528e-01f, -9.83134925e-01f, 1.47497460e-01f, -3.71720880e-01f, -8.41311440e-02f, -4.60758269e-01f, 7.27549672e-01f,
  -1.19262540e+00f, 6.56528533e-01f, -8.16441238e-01f, 3.31736088e-01f, 6.61111116e-01f, -7.30541945e-01f, -3.19615692e-01f, 2.12272644e-01f, -2.64899105e-01f, 3.11585814e-01f,
  -4.31190506e-02f, -1.12240922e+00f, -1.33242249e-01f, -3.59474719e-01f, -3.05369169e-01f, -7.71627188e-01f, -6.02755606e-01f, 1.26667118e+00f, 4.15991724e-01f, -2.63918251e-01f,
  -4.25574720e-01f, -1.86049983e-01f, 6.25186503e-01f, -9.43053439e-02f, 5.24357259e-01f, -2.96314597e-01f, -8.44694495e-01f, -1.47940710e-01f, -5.87563813e-01f, 3.06333452e-01f,
  -5.67120671e-01f, -1.47531733e-01f, 8.00654888e-01f, -5.38345933e-01f, -1.26405165e-01f, -6.40703976e-01f, -3.63746911e-01f, -1.15131986e+00f, 2.23772213e-01f, -6.56215727e-01f,
  6.53920174e-02f, 2.16340944e-01f, -7.95518637e-01f, 7.44568169e-01f, 8.23318005e-01f, -7.51642436e-02f, 8.69541466e-01f, -8.93692374e-01f, -2.17972517e-01f, -6.05465889e-01f,
  4.33855355e-01f, -3.62119049e-01f, 2.98479110e-01f, -1.14115648e-01f, -3.96347314e-01f, -1.01819241e+00f, -5.42761534e-02f, 2.63817608e-01f, -2.66359389e-01f, 1.09968178e-01f,
  6.20590627e-01f, 4.87282157e-01f, 5.71129501e-01f, -3.52828592e-01f, 1.30168176e+00f, -2.69873381e-01f, -9.95097697e-01f, 6.17003739e-01f, -8.63531325e-03f, 4.04956378e-02f,
  -3.67692024e-01f, -8.68679762e-01f, 2.38747299e-01f, -2.44854763e-01f, 9.78512764e-02f, 5.43273985e-02f, -2.18233645e-01f, -8.23537782e-02f, 3.33585143e-01f, -4.92074877e-01f,
  4.90056932e-01f, 6.67696476e-01f, 3.85227948e-01f, -1.21601748e+00f, 3.85558121e-02f, 2.76900470e-01f, 2.04833969e-01f, 7.02678382e-01f, -2.22399577e-01f, -1.38062608e+00f,
  1.07281007e-01f, -1.20230377e+00f, 1.36536658e-01f, -2.63978422e-01f, -4.89041507e-01f, 5.74047565e-01f, 1.38930544e-01f, 3.86552483e-01f, -8.45398128e-01f, -6.29039288e-01f,
  3.32524860e-03f, -3.87688339e-01f, 6.42363608e-01f, -6.74504519e-01f, 4.06355001e-02f, -5.09188712e-01f, 5.77054918e-01f, 1.92608982e-01f, 5.98111391e-01f, 4.35946465e-01f,
  7.66837120e-01f, 1.02843165e-01f, 6.55673444e-01f, -5.73532939e-01f, -5.35851419e-01f, 2.43016362e-01f, -4.77443814e-01f, 7.59283483e-01f, -5.31770527e-01f, 2.68940538e-01f,
  -8.55745792e-01f, -8.10140014e-01f, 5.73907018e-01f, -8.72066498e-01f, -1.45071596e-01f, -9.91339862e-01f, -1.52426600e-01f, 1.65039051e+00f, 4.46292162e-01f, -4.93458301e-01f,
  3.69737655e-01f, -1.01964049e-01f, -2.99381852e-01f, 4.06334519e-01f, 3.33519638e-01f, 2.68240906e-02f, -3.03142458e-01f, -5.98915517e-01f, -2.72917211e-01f, 2.89666504e-01f,
  5.12892842e-01f, 2.53871512e-02f, -4.53338712e-01f, -5.44074655e-01f, -4.68535900e-01f, 3.43441725e-01f, -2.73363352e-01f, 6.96414039e-02f, -1.54463887e+00f, -7.75552690e-01f,
  -4.67299759e-01f, 4.48583633e-01f, -1.39011100e-01f, 7.10034370e-01f, 4.54720885e-01f, 1.86103135e-02f, 2.23329961e-01f, 6.24089837e-01f, 2.33867034e-01f, 4.62563038e-01f,
  -9.76057529e-01f, -7.92822540e-01f, 7.81634271e-01f, -9.94246781e-01f, 6.40562475e-01f, 2.20540226e-01f, -6.64195657e-01f, 1.43611198e-02f, -1.10859835e+00f, 3.15837339e-02f,
  -1.11977017e+00f, -4.33957309e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.37249798e-02f, 1.60257310e-01f, 4.11987513e-01f, 5.56083992e-02f, -2.14697644e-01f, 1.21961035e-01f, 4.44459505e-02f, -1.70679584e-01f, 4.15136904e-01f, 7.04256669e-02f,
  -4.09110457e-01f, -4.12020013e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    