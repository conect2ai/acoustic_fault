/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.90306628e-01f, 1.10390276e-01f, 1.11435041e-01f, 2.35660285e-01f, -4.81982417e-02f, 1.15256952e-02f, 3.31119411e-02f, 5.97429872e-02f, 2.07917571e-01f, -7.55978972e-02f,
  -5.18642776e-02f, 7.04594180e-02f, -1.68280244e-01f, 2.07170583e-02f, -1.01577550e-01f, -1.35390803e-01f, 1.15516111e-01f, -3.21906656e-02f, 6.17687404e-03f, 2.83876300e-01f,
  9.28793848e-02f, -5.51839080e-03f, -2.20249756e-03f, 5.53192664e-03f, 1.51949584e-01f, 3.85251492e-02f, 2.66694720e-03f, -1.12453736e-01f, -2.90451050e-02f, -1.00982122e-01f,
  4.91950214e-02f, 2.17244551e-01f, -4.72228937e-02f, 3.18105817e-02f, 1.85298715e-02f, 3.19718830e-02f, 2.22651325e-02f, -1.63687021e-01f, -7.26675987e-02f, -3.67355980e-02f,
  -4.44712676e-02f, -1.65026654e-02f, 2.00000927e-02f, -8.91925618e-02f, 5.10834605e-02f, 1.66723076e-02f, -7.73096308e-02f, 6.64078593e-02f, 9.75892413e-03f, -1.49345128e-02f,
  -3.40906117e-04f, 5.59218153e-02f, -4.03110906e-02f, -5.91671932e-03f, -6.55753091e-02f, -1.26930438e-02f, 3.05230040e-02f, 5.26172891e-02f, -3.47115621e-02f, -1.27491471e-03f,
  -8.45305324e-02f, 1.15540825e-01f, -1.23657016e-02f, -8.07428956e-02f, -6.33747801e-02f, 4.03418988e-02f, -9.19025857e-03f, 1.30332615e-02f, -3.63475233e-02f, -1.77298542e-02f,
  -2.25284938e-02f, 6.80674985e-02f, 8.32102671e-02f, 8.98510292e-02f, -3.18514258e-02f, 8.51273090e-02f, -5.09378836e-02f, -9.37369093e-02f, 5.39459698e-02f, 2.58175470e-02f,
  9.63626057e-02f, 3.15070152e-02f, 3.61524825e-03f, 6.72369227e-02f, -2.83655282e-02f, -7.11912662e-02f, 7.93830529e-02f, -7.74995796e-03f, 5.55115119e-02f, 2.15017237e-03f,
  9.91988257e-02f, 2.23959133e-01f, -2.22703330e-02f, -2.26349588e-02f, -4.48070467e-02f, -3.65077634e-03f, -3.54401954e-02f, -7.68964738e-02f, 1.18336640e-02f, 2.46699546e-02f,
  1.35082081e-02f, -6.74245274e-03f, 4.02035527e-02f, 2.93536298e-02f, 3.99322286e-02f, 7.67526180e-02f, 8.24937820e-02f, 6.01165183e-02f, 2.47597527e-02f, -1.25866607e-02f,
  -3.78877670e-02f, 6.17994331e-02f, -2.31532212e-02f, 8.35059956e-02f, -3.35536115e-02f, -5.09349294e-02f, 4.29399461e-02f, 3.23451273e-02f, 3.26707563e-03f, -3.61167416e-02f,
  -3.31947178e-01f, 1.41407192e-01f, -2.76965380e-01f, 1.25200197e-01f, -2.28218641e-03f, 1.22559234e-01f, 2.00254187e-01f, 3.16751786e-02f, -9.28142294e-03f, 3.07029009e-01f,
  1.57628879e-01f, -4.86108772e-02f, -1.59577951e-02f, 2.73922980e-01f, -2.56683022e-01f, -8.59950930e-02f, 1.73238978e-01f, 1.59315497e-01f, 1.87926609e-02f, -1.78139308e-03f,
  -9.76416692e-02f, 2.00969711e-01f, -6.07204735e-02f, 1.22918986e-01f, 2.15655416e-01f, -9.07254815e-02f, 9.42969769e-02f, -8.93424172e-03f, 2.53926605e-01f, 7.42225945e-02f,
  -9.56211612e-02f, -1.60593048e-01f, -8.47460926e-02f, -4.91133817e-02f, -1.26383707e-01f, -5.01441807e-02f, 3.16846520e-02f, -2.44934317e-02f, -3.48348618e-02f, 6.74739107e-02f,
  3.55996042e-02f, -2.97988039e-02f, -2.19709575e-02f, -7.58461729e-02f, 8.38245377e-02f, -3.24755721e-02f, 6.25038072e-02f, 9.23087895e-02f, -6.08810224e-03f, -1.93589274e-02f,
  4.34645899e-02f, 4.95664887e-02f, 1.69111677e-02f, 2.76319720e-02f, -3.82085145e-02f, 8.33592713e-02f, -6.10504970e-02f, -9.92625859e-03f, -3.87529507e-02f, 6.10394627e-02f,
  -8.48024804e-03f, -3.99579853e-02f, 5.55596165e-02f, 3.91358510e-02f, -9.86979902e-02f, -5.81007078e-02f, 4.81084995e-02f, -6.25866354e-02f, -3.94730791e-02f, 1.60445198e-02f,
  -7.41365626e-02f, -2.15012990e-02f, 3.13918479e-02f, 8.62501040e-02f, 9.52219404e-03f, 9.85420495e-02f, 3.62949749e-03f, 5.49824489e-03f, -7.01740291e-03f, -2.39488780e-02f,
  4.45775948e-02f, 1.60775818e-02f, 5.24411239e-02f, -1.87198296e-02f, -1.46892071e-02f, -1.42919850e-02f, 1.02542758e-01f, 3.73841338e-02f, 1.65260062e-02f, -8.86024907e-02f,
  -6.60942569e-02f, 1.02531761e-02f, 1.90270562e-02f, 1.11090038e-02f, -2.33685505e-02f, 1.07922480e-02f, 6.01030476e-02f, 3.11132297e-02f, -4.97276112e-02f, 2.37719845e-02f,
  7.05018416e-02f, -3.13239582e-02f, 4.67477143e-02f, -1.64214186e-02f, -3.66710313e-02f, 2.63360366e-02f, 9.61970016e-02f, 6.16239645e-02f, 6.39296696e-02f, 1.36552111e-03f,
  1.32130325e-01f, -1.35868490e-02f, -5.94682023e-02f, -2.51699220e-02f, -6.02109097e-02f, 9.10264924e-02f, -1.09092809e-01f, -3.77240181e-02f, -5.06059639e-02f, 6.80514574e-02f,
  2.00931236e-01f, -8.39588940e-02f, -1.53002992e-01f, 1.68038588e-02f, 1.16219603e-01f, -2.91267829e-03f, -8.73637572e-02f, 7.25473017e-02f, -1.28446206e-01f, -1.58126637e-01f,
  6.83803409e-02f, -1.62678748e-01f, -6.32640943e-02f, -7.75330663e-02f, 6.30692914e-02f, -1.54299736e-01f, 6.02941290e-02f, -8.45543891e-02f, 2.81057712e-02f, 1.50054932e-01f,
  9.03987139e-02f, 1.02374174e-01f, 1.25340968e-01f, 7.36459494e-02f, 1.76170364e-01f, 8.52233469e-02f, 1.23371087e-01f, -9.44625773e-03f, 7.12520033e-02f, 2.19594361e-03f,
  1.25871614e-01f, -8.31929371e-02f, -1.54273910e-02f, -4.24942598e-02f, -3.76128666e-02f, 7.32042268e-03f, 7.62961153e-03f, -1.04510359e-01f, -4.84543778e-02f, -2.26473175e-02f,
  -1.18439771e-01f, -3.23428735e-02f, 9.90041532e-03f, -4.08841185e-02f, 3.31693590e-02f, -3.27604264e-03f, -2.84637865e-02f, -6.48894208e-03f, -9.55700055e-02f, 9.12914984e-03f,
  -7.43242204e-02f, 1.11390930e-02f, -9.12729371e-03f, -5.17605543e-02f, 2.91239452e-02f, -5.44280326e-03f, 3.48353498e-02f, 5.17042466e-02f, 1.30045239e-03f, 2.19000150e-02f,
  -1.47123616e-02f, 7.45891333e-02f, 6.36381730e-02f, 5.78822009e-02f, 7.91502297e-02f, 1.73611492e-02f, 6.86438978e-02f, 3.26333679e-02f, -6.68002516e-02f, 6.00519404e-02f,
  1.14609249e-01f, 2.82567255e-02f, 3.27459089e-02f, -1.64730847e-01f, 2.29348037e-02f, -1.53194349e-02f, 7.55253807e-02f, -1.09508529e-01f, 1.06409192e-01f, 9.27769169e-02f,
  -5.30421548e-02f, -6.04243018e-02f, 1.43790729e-02f, -1.80074424e-02f, -1.65231805e-02f, -6.49586273e-03f, -7.18823150e-02f, -3.11374962e-02f, -7.06259832e-02f, 6.48572370e-02f,
  1.60048440e-01f, 1.76332995e-01f, -2.21496057e-02f, -1.19121345e-02f, 4.38944586e-02f, 5.05097546e-02f, -4.13259957e-03f, -9.89649966e-02f, -5.61763011e-02f, -5.92072569e-02f,
  -2.45334320e-02f, 7.98776746e-03f, 1.16538525e-01f, -1.14565017e-02f, 6.86380547e-04f, 1.05950311e-01f, 4.27793451e-02f, 2.27406509e-02f, -1.15398467e-02f, 1.26465186e-01f,
  1.51980510e-02f, -5.00595458e-02f, 2.14883015e-02f, 4.16068695e-02f, -7.14198500e-02f, 1.12526737e-01f, 5.20628430e-02f, -2.68041110e-03f, -2.32395669e-03f, -9.16537195e-02f,
  1.75879434e-01f, -5.04544601e-02f, 1.19274095e-01f, 2.36804053e-01f, 9.41977650e-02f, -2.98268199e-01f, -2.74531603e-01f, 9.04002786e-02f, 2.05620438e-01f, -2.26093456e-01f,
  -1.72699079e-01f, 1.72120884e-01f, -2.03075409e-01f, 7.57559342e-03f, -7.81819522e-02f, -1.98600933e-01f, 1.53542561e-02f, -5.29709132e-03f, 8.57066363e-02f, 6.47263676e-02f,
  1.74738288e-01f, 2.89156865e-02f, 1.18555509e-01f, 1.60211772e-01f, 7.39190951e-02f, 2.24077627e-01f, 7.67132863e-02f, -1.22724157e-02f, 1.83019191e-02f, -4.78186719e-02f,
  -4.70728688e-02f, -6.99043795e-02f, -6.73943199e-03f, -2.25712024e-02f, -6.96602538e-02f, 4.09851186e-02f, 2.48945747e-02f, -1.04065724e-01f, -6.13987856e-02f, -7.78025985e-02f,
  -7.36752234e-04f, 2.62245387e-02f, 2.28928141e-02f, 3.84435593e-03f, 5.75444382e-03f, -6.22231560e-03f, 2.67335642e-02f, -4.10700068e-02f, 1.28619626e-01f, 6.73661008e-02f,
  6.67734221e-02f, 5.25274426e-02f, -3.32809836e-02f, -6.15885407e-02f, -2.80126445e-02f, -1.85827364e-03f, -1.10435141e-02f, -4.67843227e-02f, -4.66386937e-02f, 3.07576060e-02f,
  -3.15908119e-02f, 9.90023091e-02f, -3.68388109e-02f, 5.92593756e-03f, -1.50640262e-02f, 4.75546084e-02f, 1.81781147e-02f, -2.21395660e-02f, -5.08965999e-02f, 1.44812139e-02f,
  5.55323586e-02f, 8.57908353e-02f, 1.37605853e-02f, 4.54417393e-02f, -8.01996514e-03f, 2.69281361e-02f, -4.24225330e-02f, -5.36012873e-02f, 6.61987513e-02f, 4.27081659e-02f,
  1.64118886e-03f, -7.11765811e-02f, 7.31879100e-02f, -6.37599442e-04f, -2.62348708e-02f, -3.16555277e-02f, 7.37627149e-02f, 2.24049110e-02f, -8.18355754e-03f, -4.85242903e-02f,
  -2.10149154e-01f, -8.40113685e-02f, -7.88109303e-02f, 3.97630222e-02f, -7.81205446e-02f, -1.95901915e-02f, 1.06112016e-02f, 3.04384641e-02f, -5.98821193e-02f, -1.13192117e-02f,
  6.09145164e-02f, -7.20547140e-02f, -3.51729654e-02f, -4.06210823e-03f, 5.46467816e-03f, 1.47085236e-02f, -2.06205267e-02f, 2.10033190e-02f, -2.34132688e-02f, 1.56099284e-02f,
  2.60224324e-02f, -5.91332056e-02f, -4.31261808e-02f, -1.42548317e-02f, 3.90684931e-04f, 4.74019878e-04f, 6.49467111e-02f, -7.71594280e-03f, -1.28030991e-02f, -1.89818703e-02f,
  1.60116568e-01f, -1.01492874e-01f, -1.43823028e-01f, 9.31136459e-02f, 1.45628557e-01f, -1.62516441e-02f, -9.00495518e-03f, 2.30861038e-01f, 3.25747617e-02f, -1.19708121e-01f,
  1.42791778e-01f, -3.74330692e-02f, -2.51314968e-01f, 2.75866389e-02f, 1.79135650e-01f, -2.14280248e-01f, 1.21998146e-01f, -1.28049552e-01f, -5.59895188e-02f, 1.71033069e-01f,
  5.63513897e-02f, 1.40856221e-01f, 1.25220735e-02f, 1.77899480e-01f, 1.78050265e-01f, 2.30293553e-02f, 1.29752263e-01f, -1.63146734e-01f, 5.70202172e-02f, 3.12490277e-02f,
  1.38458222e-01f, 1.29145905e-01f, -2.06967699e-03f, -2.35904604e-02f, 3.04939467e-02f, -3.55159189e-03f, -6.45753816e-02f, -7.85676092e-02f, -8.19020942e-02f, -2.19954308e-02f,
  -3.19911279e-02f, 6.28511831e-02f, 7.30323493e-02f, -5.23862131e-02f, -1.40479967e-01f, -3.04471944e-02f, 4.95072417e-02f, -3.21697667e-02f, 2.98646316e-02f, 9.67126922e-04f,
  -1.77727733e-02f, -7.72931520e-03f, -1.01356559e-01f, 1.99769661e-02f, -6.23602644e-02f, 1.60907172e-02f, -8.01649690e-02f, 2.23332997e-02f, 1.50894463e-01f, -2.96184216e-02f,
  -6.71008527e-02f, -1.13983802e-01f, -2.48654261e-02f, -2.50156298e-02f, 1.98148862e-02f, 1.01119444e-01f, -7.49524757e-02f, 4.71321819e-03f, 2.11673826e-02f, -6.14082702e-02f,
  1.62000015e-01f, -1.62741803e-02f, 7.93426298e-03f, -1.17924184e-01f, -4.79486734e-02f, 3.61761823e-02f, -1.42147215e-02f, 1.30158924e-02f, 7.55735710e-02f, 1.02201000e-01f,
  5.89198247e-02f, -9.93686821e-03f, -2.32324991e-02f, -1.01317596e-02f, 7.80020505e-02f, 1.90088991e-02f, -7.91567340e-02f, -6.77880570e-02f, 6.73075840e-02f, 2.94818170e-02f,
  5.06498404e-02f, 1.59629449e-01f, 3.45485769e-02f, -6.22646213e-02f, -7.54334703e-02f, -3.72753036e-03f, -1.44507274e-01f, -6.21532574e-02f, -8.26995596e-02f, 7.34056458e-02f,
  -5.02656773e-02f, 1.39150992e-02f, 1.51242614e-01f, 4.75771241e-02f, -4.29972745e-02f, -3.90591286e-02f, 4.47109714e-02f, -3.71495858e-02f, 1.12198673e-01f, 6.21952079e-02f,
  4.10765260e-02f, 7.33873621e-02f, 8.01625196e-03f, 4.19434011e-02f, 1.33944722e-02f, -2.65258644e-02f, 1.35580644e-01f, -4.38008532e-02f, 4.41388302e-02f, -6.53025731e-02f,
  5.24927638e-02f, 1.99032739e-01f, -9.88806635e-02f, -1.57757834e-01f, 3.04509830e-02f, 3.47813308e-01f, 3.08727652e-01f, -3.54274805e-03f, -7.70245045e-02f, 1.22423097e-01f,
  9.64190885e-02f, -1.21934019e-01f, 8.92054662e-02f, 2.40771640e-02f, -3.16647887e-02f, -2.31507774e-02f, 9.94009078e-02f, 8.31624493e-02f, -5.77280186e-02f, 6.57362267e-02f,
  -7.38806278e-02f, 6.45423681e-02f, -1.09240115e-01f, -6.01571761e-02f, 6.48296848e-02f, -1.59011438e-01f, -1.03473857e-01f, 3.18291076e-02f, -1.04927652e-01f, 1.09498594e-02f,
  1.12813555e-01f, -4.61952575e-02f, -5.09585328e-02f, 2.55259611e-02f, -2.24064197e-02f, 4.86100605e-03f, -1.39697846e-02f, -2.29458530e-02f, 2.47351322e-02f, 4.37173136e-02f,
  9.75609124e-02f, 6.72110319e-02f, -1.20923027e-01f, -9.19574127e-02f, 8.89910683e-02f, 2.98347585e-02f, 4.35173064e-02f, 3.36068161e-02f, 1.68936774e-02f, -1.24791428e-01f,
  4.81572524e-02f, 1.73264816e-02f, 4.77579869e-02f, 2.77680531e-02f, 1.41608808e-02f, -3.14212628e-02f, -1.30162388e-01f, 3.01617244e-03f, 9.20615252e-03f, -2.14814004e-02f,
  -1.12179881e-02f, -1.09518491e-01f, -4.37801369e-02f, -3.06056887e-02f, 2.41188984e-02f, -5.65429814e-02f, 5.77974394e-02f, 5.94033375e-02f, -2.72463616e-02f, 7.10205510e-02f,
  -8.73165112e-03f, -3.24295536e-02f, 1.61831174e-02f, 2.53176056e-02f, 3.80254835e-02f, -7.64101893e-02f, -6.35688566e-03f, -4.31063725e-03f, -3.36546334e-04f, -1.02953367e-01f,
  5.64699844e-02f, 1.02101110e-01f, -8.39450303e-03f, 7.75087103e-02f, 4.78246771e-02f, -1.68780831e-03f, 7.39897341e-02f, 8.32899064e-02f, -3.76568921e-02f, 3.06141116e-02f,
  2.07314163e-01f, -8.61111656e-02f, -3.17881852e-02f, 6.54847622e-02f, 7.29154572e-02f, 1.33690145e-02f, -5.82462810e-02f, -2.50657275e-02f, 4.64790920e-03f, 1.14157060e-02f,
  5.83663164e-03f, 3.69518548e-02f, 1.69081260e-02f, 1.05981799e-02f, 3.66141833e-02f, -3.49411368e-02f, -3.43514681e-02f, -1.38005679e-02f, 3.48321609e-02f, -5.09735122e-02f,
  -3.01827155e-02f, 2.55386475e-02f, 1.18722413e-02f, 5.78541048e-02f, 6.91088215e-02f, 3.35914716e-02f, 1.99255664e-02f, -4.95577268e-02f, -2.76604947e-02f, -1.34356003e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.00365877e-01f, 4.21107382e-01f, 1.36020780e-01f, -4.81927879e-02f, 8.70364010e-02f, 2.48494044e-01f, 2.53727078e-01f, 7.86038935e-02f, 2.77175337e-01f, 3.02434206e-01f,
  3.01699787e-02f, -6.78234547e-02f, 1.37305446e-02f, 6.68703346e-03f, 1.77525356e-02f, 2.15887114e-01f, 1.48132563e-01f, 6.73521534e-02f, 1.13153756e-01f, -6.37819842e-02f,
  -6.27142638e-02f, 1.84986163e-02f, -1.65829554e-01f, -1.14432513e-03f, -3.91979404e-02f, -7.79935122e-02f, -1.17003053e-01f, 4.79773842e-02f, -1.67017672e-02f, 1.17950842e-01f,
  -5.80097102e-02f, 2.25094403e-03f, -8.06944445e-02f, -2.21888069e-02f, -7.88777918e-02f, -7.07687810e-02f, -2.40956359e-02f, 2.31371820e-02f, -2.42123604e-02f, 7.02999532e-02f,
  -7.79775009e-02f, -7.63109550e-02f, 4.14118953e-02f, -3.82445604e-02f, 9.41226110e-02f, 2.96530388e-02f, 3.34837735e-02f, 6.90347552e-02f, -4.48983274e-02f, -3.99764702e-02f,
  -4.06048410e-02f, 1.02911875e-01f, -7.12700561e-02f, 9.62980539e-02f, 1.58875622e-02f, 6.79192394e-02f, 8.69758520e-03f, 9.40205902e-03f, 1.03725694e-01f, 9.67226326e-02f,
  -3.13752443e-02f, -5.88207394e-02f, 2.02410519e-02f, 3.95840928e-02f, 4.90266550e-03f, -4.87538055e-03f, -7.60694072e-02f, -7.62364492e-02f, 5.67141920e-02f, -3.93550657e-02f,
  -3.50484326e-02f, 1.85130804e-03f, 3.24220434e-02f, -1.63950939e-02f, 4.72768508e-02f, -7.63804652e-03f, -1.53729841e-01f, 1.78461510e-03f, 1.55167803e-02f, -8.34859163e-03f,
  -1.12001644e-02f, -1.03732375e-02f, 1.85823888e-01f, 5.25622852e-02f, 1.01671172e-02f, -8.43531918e-03f, -2.05564275e-02f, -2.00046804e-02f, 1.78096183e-02f, 6.82627549e-04f,
  2.03799725e-01f, 2.30813846e-01f, -1.01097301e-01f, 2.78006699e-02f, 8.75437341e-04f, -3.84393521e-02f, -2.65397448e-02f, 7.19694374e-03f, 4.65987287e-02f, 3.18402238e-02f,
  -4.79321517e-02f, -7.62364492e-02f, -2.12116409e-02f, -7.91243464e-02f, 3.27463858e-02f, 1.13552250e-01f, -1.78086385e-03f, 1.15694907e-02f, -2.77297795e-02f, -5.38340658e-02f,
  -1.38772160e-01f, -1.87718961e-02f, -1.28934383e-02f, 7.56513700e-02f, 2.28792354e-02f, 2.35946048e-02f, 7.51771703e-02f, -1.17894746e-01f, 1.34842873e-01f, 1.05444841e-01f,
  -1.45400926e-01f, 1.90102737e-02f, 6.38080165e-02f, 1.10955052e-01f, -6.76564351e-02f, -2.82752275e-01f, -2.46969193e-01f, 1.57501116e-01f, -9.11368802e-02f, -4.06678244e-02f,
  8.48566890e-02f, -9.90482746e-04f, 4.02561948e-02f, -1.12974562e-01f, -2.17813589e-02f, -1.43932283e-01f, -2.08911020e-02f, -1.17391326e-01f, 2.10121758e-02f, 1.89365193e-01f,
  1.76156566e-01f, 7.98303038e-02f, 9.85544473e-02f, -7.85057619e-03f, -6.45148605e-02f, 2.13382114e-02f, 1.47664130e-01f, 1.14929639e-01f, 1.43791899e-01f, -2.60879286e-02f,
  -4.41218205e-02f, 1.22924604e-01f, -1.02156745e-02f, -2.96751969e-02f, 7.52846226e-02f, -7.30420575e-02f, -1.19616799e-01f, -6.19076155e-02f, 8.36688923e-05f, 3.39699686e-02f,
  -2.36387644e-03f, -2.86527015e-02f, -4.74666134e-02f, 3.90204624e-03f, -8.25450569e-02f, -3.64726074e-02f, 3.83945927e-02f, 5.91351977e-03f, -9.46393702e-03f, -2.07933895e-02f,
  9.67014208e-02f, -3.69549431e-02f, 5.55737019e-02f, 4.78041582e-02f, 9.35573205e-02f, 8.26583803e-02f, -8.53225812e-02f, 8.07312727e-02f, -3.92545089e-02f, -4.69926596e-02f,
  1.16025299e-01f, -8.53385925e-02f, -4.45601158e-02f, -1.24547146e-01f, 4.10993099e-02f, 6.07041828e-02f, 2.60458067e-02f, 1.00265294e-01f, 1.82386599e-02f, -2.19128095e-02f,
  -1.55552132e-02f, 2.91687399e-02f, -2.94080079e-02f, -7.74281844e-02f, 8.16515684e-02f, -4.55314256e-02f, -1.52173921e-01f, 6.84918314e-02f, 6.63842261e-02f, -1.31430849e-01f,
  5.01056947e-02f, 6.75472841e-02f, -1.09757362e-02f, -4.51332405e-02f, -1.82396453e-02f, 1.26938939e-01f, 6.07081167e-02f, 4.19707373e-02f, 4.92820889e-02f, -7.88757429e-02f,
  6.30607978e-02f, 2.45948091e-01f, -5.89847527e-02f, -1.52720707e-02f, 2.34146342e-02f, -5.93300425e-02f, -7.26513565e-02f, -3.80440317e-02f, 9.88292228e-03f, 2.26882733e-02f,
  2.76031252e-02f, -2.52306480e-02f, -1.83244720e-02f, 4.10424685e-03f, 6.00165352e-02f, 7.07200617e-02f, 9.96683612e-02f, 5.76925091e-02f, 6.21283352e-02f, 6.81315586e-02f,
  -8.14473908e-03f, -7.03918561e-02f, -7.04007670e-02f, -1.40359208e-01f, 3.08582745e-02f, 8.77807885e-02f, 1.79996323e-02f, 7.65437912e-03f, 4.66526337e-02f, -2.63822377e-02f,
  1.38376877e-01f, 3.46005559e-01f, 2.11984679e-01f, -1.10001932e-03f, -8.73960331e-02f, 1.33665815e-01f, 1.63898259e-01f, 5.26734665e-02f, 3.03081542e-01f, 8.32419768e-02f,
  -1.70059443e-01f, 2.81951785e-01f, -6.84006885e-02f, 4.65090647e-02f, -7.22373948e-02f, -1.17022190e-02f, 1.26281321e-01f, 1.51551496e-02f, 5.80896586e-02f, -6.89194072e-03f,
  2.52317488e-02f, -2.14860037e-01f, -2.11625889e-01f, -1.59810960e-01f, -1.22834779e-01f, -1.08059468e-02f, -3.03911000e-01f, -4.81042117e-02f, 3.11528482e-02f, 7.91924894e-02f,
  -4.89968881e-02f, 4.47429810e-03f, -1.15703447e-02f, 9.16623846e-02f, -4.09139432e-02f, -5.36535978e-02f, -2.15706844e-02f, 5.47590889e-02f, 4.07531448e-02f, 4.56200689e-02f,
  3.15781720e-02f, 5.22450618e-02f, 7.76823908e-02f, -8.25014263e-02f, 2.83710193e-02f, 1.99116077e-02f, 9.04557109e-02f, -5.56307435e-02f, 6.63022250e-02f, 9.09243673e-02f,
  6.12006942e-03f, 1.22957088e-01f, 8.74695405e-02f, 6.53449520e-02f, 5.46248928e-02f, 3.52932587e-02f, 7.75138438e-02f, 6.84234202e-02f, 1.02757640e-01f, 9.59333107e-02f,
  -4.75102849e-02f, 5.57053015e-02f, 1.33929262e-03f, -4.52573448e-02f, 3.28075364e-02f, 1.63352042e-02f, 8.45991895e-02f, 7.83683062e-02f, -2.87134736e-03f, -1.03715070e-01f,
  -3.67544480e-02f, -1.37291607e-02f, 1.22279331e-01f, -7.38757476e-02f, 6.84247911e-02f, 4.11225185e-02f, 7.64271757e-03f, 2.23226845e-04f, 5.97747788e-02f, -1.78510785e-01f,
  -2.44981777e-02f, 6.32780716e-02f, -2.20991615e-02f, -5.20747676e-02f, 3.87464799e-02f, -6.83230013e-02f, -1.23870105e-01f, 3.37197483e-02f, -1.44985601e-01f, 1.00892298e-01f,
  1.29244268e-01f, 2.15818122e-01f, 3.22452821e-02f, 7.55566508e-02f, 2.33395286e-02f, -3.20451595e-02f, 5.76452799e-02f, 9.76290628e-02f, 4.17493097e-02f, -2.08653565e-02f,
  1.19152144e-01f, 2.91200001e-02f, 8.30408111e-02f, -6.41606972e-02f, -1.33341691e-02f, 9.16486606e-02f, 9.87735577e-03f, -8.40213057e-03f, 3.46663147e-02f, -1.09712996e-01f,
  -8.41665864e-02f, 5.96393794e-02f, 8.65236819e-02f, 3.98352481e-02f, 4.44679484e-02f, 5.69171160e-02f, -1.53286271e-02f, 1.21380880e-01f, -7.06633329e-02f, 1.65672321e-02f,
  1.79323077e-01f, -2.77014971e-01f, -1.53692365e-01f, 4.11217511e-02f, 1.40777394e-01f, -9.32910386e-03f, -3.96911949e-02f, 4.97554727e-02f, 7.65021071e-02f, -2.19591618e-01f,
  -1.00782759e-01f, -2.13798836e-01f, -2.57885993e-01f, 6.48591518e-02f, 1.38071418e-01f, -1.08661421e-01f, 5.24157621e-02f, 4.58168145e-03f, -9.68871042e-02f, -9.37003642e-02f,
  6.69607669e-02f, 5.05420119e-02f, -5.74333500e-03f, 4.62936535e-02f, 7.18581900e-02f, 5.29829897e-02f, 7.44071230e-03f, -2.59322952e-02f, 7.74840117e-02f, -4.53668507e-03f,
  2.39743721e-02f, 4.44680639e-03f, -8.54651481e-02f, -3.18607502e-02f, 2.72226688e-02f, 9.74201970e-03f, -6.69043064e-02f, 2.60427371e-02f, 4.86443639e-02f, 2.32589711e-02f,
  -4.72609624e-02f, 1.60005316e-01f, -1.57435797e-02f, 1.10011652e-01f, 9.14710909e-02f, 1.40889324e-02f, -6.05342649e-02f, 3.38665098e-02f, 5.99870011e-02f, -5.75948358e-02f,
  -9.92720947e-02f, 5.52614629e-02f, -4.63403985e-02f, 2.58406065e-03f, -3.06909694e-03f, 5.83114363e-02f, -3.44045237e-02f, 1.62149109e-02f, -6.38411716e-02f, -6.51068687e-02f,
  -6.91293702e-02f, -9.79336128e-02f, -1.66559499e-02f, -3.09783928e-02f, 1.05571605e-01f, 3.56781296e-02f, 5.33740669e-02f, -5.03363274e-02f, -3.40224802e-02f, 6.94541708e-02f,
  -1.60120018e-02f, -4.55464981e-02f, -6.80879951e-02f, -2.82282848e-02f, -9.88556445e-03f, -9.26773995e-02f, 1.95663925e-02f, 8.10678005e-02f, -4.30933852e-03f, -2.90993731e-02f,
  -6.39763325e-02f, 6.28280938e-02f, -3.79060337e-04f, 3.00475098e-02f, 2.87003554e-02f, 4.09532525e-02f, -3.82553339e-02f, 7.15277717e-02f, -7.15752319e-03f, 1.05516165e-02f,
  -5.86475655e-02f, -1.59588471e-01f, -8.77212659e-02f, -1.00083977e-01f, -7.92847201e-02f, 5.44317737e-02f, -1.09228581e-01f, -2.18004431e-03f, -8.38706717e-02f, 8.17526132e-02f,
  -4.18536291e-02f, 4.89920452e-02f, 1.90536100e-02f, 6.38941675e-02f, 1.36996046e-01f, 5.79686777e-04f, -8.23158249e-02f, 6.01589493e-02f, 3.07386834e-02f, -9.56363510e-03f,
  -5.16311973e-02f, 7.64371976e-02f, -1.77470054e-02f, -4.74421494e-02f, -3.36265825e-02f, -1.11189321e-01f, -2.45050844e-02f, 1.44722581e-01f, 5.44724241e-02f, 7.89616629e-03f,
  3.46297072e-03f, -2.84305513e-01f, 1.88696802e-01f, -1.59159333e-01f, 3.51271555e-02f, 4.31274809e-02f, 2.07130611e-01f, -1.28563091e-01f, -2.23119780e-01f, -2.94758052e-01f,
  9.40320045e-02f, 2.60932773e-01f, 1.57336190e-01f, -1.40711769e-01f, 3.52474749e-01f, 2.24052407e-02f, -1.40454113e-01f, 7.16121867e-02f, -2.14439631e-03f, -8.38879123e-02f,
  2.78961267e-02f, -1.79397076e-01f, 1.39759794e-01f, -2.17941567e-01f, -3.68712507e-02f, -1.45894006e-01f, 1.60833299e-02f, 2.10482195e-01f, -8.80371779e-02f, 1.29784241e-01f,
  -1.31712452e-01f, -1.81050330e-01f, -7.22914562e-02f, -1.57378335e-02f, -2.56883185e-02f, 5.46650589e-02f, 1.39745548e-01f, 9.43767130e-02f, 4.72477563e-02f, -4.20519710e-02f,
  9.47035700e-02f, -1.70434695e-02f, -7.64520913e-02f, -3.61315627e-03f, -8.43470767e-02f, -6.88808262e-02f, -4.51073386e-02f, -3.10990810e-02f, 4.65763882e-02f, 1.28776759e-01f,
  6.31756708e-02f, 5.54526970e-02f, -8.76518041e-02f, 1.63676571e-02f, 5.94201870e-02f, -2.57750824e-02f, 7.83854397e-04f, 5.80681674e-02f, -2.69451719e-02f, -4.36049737e-02f,
  9.95647013e-02f, 4.61681224e-02f, 1.23984395e-02f, -5.20743541e-02f, -1.14058480e-01f, -1.37371141e-02f, 5.05098961e-02f, 6.80358633e-02f, 4.20839665e-03f, -4.02233675e-02f,
  7.42615527e-03f, -5.04895598e-02f, -1.04933158e-01f, -3.56792025e-02f, -2.51972657e-02f, -1.11214086e-01f, 1.45050287e-02f, 4.71044965e-02f, -3.74866091e-02f, -4.55946550e-02f,
  -5.81812067e-03f, 6.34450167e-02f, -6.38079941e-02f, -1.14138238e-02f, 1.56820975e-02f, 9.14195329e-02f, -9.98388603e-03f, -4.39848043e-02f, 7.58074224e-02f, 1.24986395e-01f,
  -1.80286065e-01f, -2.88988888e-01f, -8.12158361e-02f, -4.79086190e-02f, -1.19450241e-01f, 5.22483066e-02f, -2.54913401e-02f, -4.43251096e-02f, -3.94687429e-02f, -1.61764454e-02f,
  3.32826213e-03f, 3.17412242e-02f, 1.89289171e-02f, -2.13761702e-02f, 8.57176073e-03f, -3.23785357e-02f, -9.61515531e-02f, -7.06043839e-02f, 4.36533131e-02f, -2.97603663e-02f,
  3.92891914e-02f, 9.31664556e-02f, 1.27297819e-01f, 3.52569297e-02f, -7.48135298e-02f, 2.83649582e-02f, -8.90338644e-02f, 9.41052660e-02f, 3.98464501e-02f, 3.99364904e-02f,
  -2.64070928e-01f, 3.43926579e-01f, 1.74878508e-01f, -2.10520357e-01f, 1.15416981e-01f, -1.55009836e-01f, -1.18463978e-01f, 1.06704071e-01f, -3.28939408e-03f, -4.85891290e-02f,
  -6.28291294e-02f, 2.83894986e-01f, -2.93203499e-02f, 6.47049844e-02f, -2.27069706e-01f, -5.26324026e-02f, -6.77418783e-02f, 4.64283526e-02f, 9.38737616e-02f, 8.10498670e-02f,
  -1.71905831e-01f, -9.23505500e-02f, -4.24070470e-02f, 1.89283654e-01f, 2.89715659e-02f, 5.17437160e-02f, -3.06151450e-01f, 8.10167789e-02f, -6.12076968e-02f, 3.08097135e-02f,
  -1.55939788e-01f, -4.50742394e-02f, 1.77800078e-02f, 5.65124676e-03f, -3.51466425e-02f, -2.43084207e-02f, -6.53374195e-02f, -7.44115654e-03f, -4.39960398e-02f, 8.90159607e-03f,
  2.24969722e-03f, 8.74931086e-03f, 1.08251888e-02f, -9.34368093e-03f, -3.93910194e-03f, 1.17816003e-02f, 2.48813890e-02f, -5.02962507e-02f, 8.06995407e-02f, 6.54640421e-02f,
  1.42835721e-01f, -3.20297410e-03f, -3.00336201e-02f, -8.38325694e-02f, 1.42265800e-02f, -2.51438282e-02f, -4.06660847e-02f, -8.61847550e-02f, 3.56341042e-02f, 1.11762201e-02f,
  3.88295390e-02f, -1.02127306e-01f, 2.72099040e-02f, -1.89676061e-02f, 1.20387271e-01f, 5.30817285e-02f, 7.83012733e-02f, -1.04579382e-01f, -1.44632205e-01f, -4.22778204e-02f,
  -7.82341436e-02f, 5.30737638e-02f, 7.95678049e-02f, 3.10544781e-02f, 1.11372031e-01f, -7.18069226e-02f, -1.48659870e-01f, -1.35667240e-02f, -1.35697676e-02f, 3.66167724e-02f,
  -4.96607497e-02f, 3.20514552e-02f, 4.66545112e-02f, 5.14296256e-02f, -6.64522722e-02f, 2.90346090e-02f, -6.30354509e-02f, 8.45725299e-04f, -3.41663659e-02f, -6.75956830e-02f,
  -1.92851797e-01f, -1.58833161e-01f, -7.27913901e-02f, 8.48219078e-03f, 3.13522294e-02f, -4.26842310e-02f, -5.58498092e-02f, 4.01514992e-02f, -1.16154701e-01f, -5.55447228e-02f,
  -1.40488064e-02f, -1.69184078e-02f, -2.00782325e-02f, 1.37946764e-02f, 2.10192390e-02f, -2.97954455e-02f, -9.65304449e-02f, -5.06851524e-02f, -1.01428829e-01f, 1.69502513e-03f,
  5.04571013e-02f, 8.46703723e-02f, 1.57916769e-02f, -5.47782518e-03f, -7.86151737e-02f, -9.93445218e-02f, -9.58753675e-02f, 7.15596452e-02f, -5.06421365e-02f, -7.89113436e-03f,
  -1.86716944e-01f, 1.46651223e-01f, 8.24455693e-02f, -1.48496017e-01f, 3.02738007e-02f, 9.57260951e-02f, -4.93866727e-02f, 1.09226018e-01f, -1.36551052e-01f, 1.24221193e-02f,
  3.51060554e-02f, 5.62327094e-02f, 1.79104917e-02f, -9.95500162e-02f, -1.50093034e-01f, -2.76709907e-02f, -1.35857670e-04f, 9.93625894e-02f, 6.96536154e-02f, 7.28746727e-02f,
  -2.43907925e-02f, -1.43372238e-01f, 1.58151224e-01f, 1.15881115e-01f, 5.31954095e-02f, 1.42606288e-01f, 9.36046541e-02f, -1.66725963e-02f, -1.83915012e-02f, 2.83148792e-02f,
  2.75377240e-02f, 7.82958940e-02f, 1.22606821e-01f, 1.85772385e-02f, 6.24421947e-02f, -2.40263287e-02f, -1.23298086e-01f, -1.13478459e-01f, -5.86059876e-02f, 4.03194688e-02f,
  -1.52900685e-02f, -1.08679775e-02f, -1.12674624e-01f, -5.09510636e-02f, -6.91370890e-02f, -1.53167536e-02f, -7.43229017e-02f, -3.79408821e-02f, 4.36189026e-02f, 1.03541933e-01f,
  3.58719416e-02f, -7.39713386e-02f, 3.62600088e-02f, -9.51394998e-03f, -3.92591432e-02f, -9.37273800e-02f, 3.30872722e-02f, 2.49390578e-04f, 3.62228267e-02f, -9.72638875e-02f,
  5.64628802e-02f, -1.70896747e-04f, -7.91684985e-02f, 1.41841220e-02f, -8.11334029e-02f, 4.89716940e-02f, -1.18765458e-02f, 1.42426211e-02f, -4.59488779e-02f, -4.56459038e-02f,
  -8.33364855e-03f, -8.30903370e-03f, -6.69735745e-02f, 9.07938089e-03f, 1.33251613e-02f, 6.57367408e-02f, 9.51559749e-03f, 9.54655334e-02f, 7.41356472e-03f, 1.58525467e-01f,
  -2.97607537e-02f, -7.64269233e-02f, -1.86681471e-04f, 1.08286947e-01f, -3.32091674e-02f, -2.69480776e-02f, -6.52868226e-02f, 8.16361979e-03f, 1.16756201e-01f, -4.42256667e-02f,
  1.72264197e-06f, 1.16515592e-01f, 3.30519527e-02f, -7.76752532e-02f, -3.11234482e-02f, -4.59095789e-03f, -7.84518197e-02f, -3.30414698e-02f, -4.39721942e-02f, -5.18242903e-02f,
  -2.78306007e-02f, -6.14242889e-02f, -3.03340107e-02f, -2.24133544e-02f, -2.73518991e-02f, 1.64981820e-02f, -2.05960888e-02f, -8.79105553e-02f, -4.23110276e-02f, -1.89608205e-02f,
  2.43006507e-03f, 1.62384901e-02f, -9.62871239e-02f, 3.45004164e-02f, -1.22633353e-02f, -1.19193532e-01f, 1.26701472e-02f, 1.61915440e-02f, 1.73219908e-02f, -2.49510631e-02f,
  -1.63225293e-01f, 1.43649995e-01f, 4.13539400e-03f, 1.12476312e-01f, -1.92907155e-02f, -2.78794318e-01f, -1.54610083e-01f, 8.72082338e-02f, -7.44583383e-02f, 5.65111078e-02f,
  -1.64304096e-02f, -7.96959922e-02f, -2.43640374e-02f, -1.68685064e-01f, -3.74764413e-01f, -3.15890491e-01f, -1.24537960e-01f, -1.73827678e-01f, -1.42669261e-01f, 2.29341108e-02f,
  -8.30410346e-02f, -2.85500158e-02f, -6.02125237e-03f, 3.11280210e-02f, 1.54740345e-02f, 1.97851345e-01f, 3.12125176e-01f, 1.03732742e-01f, 1.38841778e-01f, -6.85674744e-03f,
  -5.22847511e-02f, -1.02690034e-01f, 4.21473086e-02f, -2.29766723e-02f, 6.35617450e-02f, 3.28012817e-02f, 6.14771061e-02f, 5.74826412e-02f, -3.86622325e-02f, -4.87609021e-02f,
  7.67303398e-03f, 7.31508434e-02f, -7.03791156e-02f, -7.15548247e-02f, 9.59764495e-02f, -4.79333326e-02f, -5.70897385e-02f, 6.64791837e-02f, -8.67628232e-02f, -2.08129678e-02f,
  -7.07675964e-02f, 1.43857487e-02f, 5.06227463e-02f, 6.11989275e-02f, 1.34454388e-02f, 4.77856258e-03f, -1.14304334e-01f, -1.33329043e-02f, -9.77838039e-03f, -6.52545318e-02f,
  7.27049261e-02f, -8.10053498e-02f, -7.12929368e-02f, -1.25607237e-01f, -3.43197882e-02f, 2.31420565e-02f, -1.03323301e-02f, -1.21623222e-02f, -7.32418597e-02f, -3.90207954e-02f,
  5.85631244e-02f, 6.84093609e-02f, -5.13944551e-02f, 7.55869523e-02f, 4.66715917e-02f, -3.03074680e-02f, 1.14136180e-02f, 5.14566973e-02f, -1.09836925e-04f, 2.46455055e-03f,
  5.93694560e-02f, 7.90883303e-02f, -4.75917151e-03f, 6.04680553e-03f, -1.26283601e-01f, -3.91569026e-02f, 4.88836393e-02f, 8.91386196e-02f, 6.92184316e-03f, -4.42841090e-03f,
  1.33324757e-01f, 1.98986769e-01f, -5.94052672e-02f, -4.86824960e-02f, -3.15106846e-02f, -4.80753519e-02f, -1.73830502e-02f, 3.67778055e-02f, 7.89426565e-02f, -3.04175168e-03f,
  4.20448836e-03f, 6.58406392e-02f, 1.44572914e-01f, 7.50326663e-02f, 1.29500106e-01f, 4.07530973e-03f, -3.98446433e-02f, 1.26670077e-01f, 1.12777308e-01f, 2.73865648e-02f,
  7.36279488e-02f, -3.59992217e-03f, 5.56641491e-03f, 2.29045246e-02f, 4.65527661e-02f, 6.39675856e-02f, -8.51514004e-03f, -2.12785732e-02f, 1.09547004e-01f, 6.42445236e-02f,
  -3.06830615e-01f, 1.12970583e-01f, -1.68065682e-01f, -2.08921328e-01f, 9.65493917e-02f, -2.43271858e-01f, -1.01807490e-01f, 6.30864650e-02f, -5.08552324e-03f, 2.28970438e-01f,
  5.81838787e-02f, -9.91887897e-02f, 7.87861720e-02f, -2.22089380e-01f, -3.41555476e-01f, -2.75903076e-01f, -3.91205996e-01f, -1.48205012e-01f, -1.13993324e-01f, -7.52041861e-02f,
  -2.55770743e-01f, -4.07254435e-02f, -2.19153360e-01f, 8.81594270e-02f, -8.08773488e-02f, 3.34548987e-02f, 1.60218403e-01f, 1.22685604e-01f, -1.33358151e-01f, 6.10638186e-02f,
  -1.82900950e-02f, 1.45568540e-02f, 3.09698489e-02f, 5.12367599e-02f, -3.75542343e-02f, -8.59242752e-02f, 1.89907863e-04f, -3.10247187e-02f, -4.89541963e-02f, 5.94518483e-02f,
  4.21726853e-02f, -4.47458625e-02f, -1.02969119e-02f, -2.24258541e-03f, -6.08442426e-02f, -3.05787157e-02f, 2.22345758e-02f, 1.56666767e-02f, 1.22190155e-02f, -3.24734412e-02f,
  8.42535496e-03f, -8.55634138e-02f, 3.07298731e-02f, 2.72844415e-02f, -5.58628589e-02f, 8.76909401e-03f, -3.79478064e-04f, 6.28965050e-02f, -8.73733759e-02f, -1.29167899e-01f,
  -3.44536491e-02f, 2.46223621e-02f, -3.05834282e-02f, -3.10024898e-02f, 1.03647724e-01f, 2.01795660e-02f, 4.85449247e-02f, 4.20608073e-02f, -3.85407470e-02f, -4.58197929e-02f,
  -2.17262339e-02f, -1.10463746e-01f, -2.81902701e-02f, -5.82952909e-02f, -9.53886434e-02f, 3.00265905e-02f, -1.07986787e-02f, 1.71298487e-03f, -5.41476645e-02f, 2.03942806e-02f,
  1.75255597e-01f, 6.21070117e-02f, 6.83143139e-02f, 3.51032764e-02f, -1.44284591e-01f, -4.04520966e-02f, -3.27319056e-02f, -5.94303906e-02f, -3.19102779e-02f, -2.38141641e-02f,
  4.70483489e-02f, 5.30142002e-02f, -5.06359003e-02f, 2.77109612e-02f, -1.12884603e-02f, -5.20113818e-02f, -4.60825264e-02f, -2.98004728e-02f, -7.67041370e-02f, -5.35234697e-02f,
  -2.72908732e-02f, 1.61726810e-02f, -4.26942408e-02f, 6.34046495e-02f, 2.28413958e-02f, -6.52639791e-02f, 1.15239643e-01f, 1.32833511e-01f, 6.39646947e-02f, 2.28526741e-02f,
  9.37782526e-02f, 4.89433371e-02f, -7.70798475e-02f, -1.10533439e-01f, -3.93094197e-02f, 5.73911965e-02f, 2.49907747e-02f, 9.06536579e-02f, 2.50941683e-02f, -1.86703785e-03f,
  -3.57278157e-03f, -9.87550914e-02f, -1.63479254e-01f, -9.98107716e-02f, -1.21201478e-01f, -1.85954288e-01f, -9.24844220e-02f, -1.32334977e-01f, 1.21731646e-01f, 2.97615230e-02f,
  -6.71864972e-02f, 1.11364335e-01f, 1.43835187e-01f, -1.08313501e-01f, 1.42372742e-01f, 9.82256010e-02f, -1.71828777e-01f, 3.42384502e-02f, 4.13239077e-02f, -2.15683207e-01f,
  -7.08595209e-04f, -1.43145680e-01f, 5.14149219e-02f, -7.74378553e-02f, -2.30808794e-01f, -1.42459393e-01f, 1.10005654e-01f, -4.09843773e-02f, -1.51267439e-01f, -9.70638543e-02f,
  -8.64885151e-02f, -6.52765706e-02f, -1.36932254e-01f, -1.49528338e-02f, -1.71212424e-02f, -1.99236199e-02f, -1.20452993e-01f, -6.58688918e-02f, -1.58915054e-02f, 5.18488809e-02f,
  3.51827182e-02f, 5.97932935e-02f, -4.98457178e-02f, 1.98013745e-02f, 5.69337122e-02f, -1.22380644e-01f, -3.92594375e-02f, 8.16663280e-02f, -8.39739945e-03f, -4.45224084e-02f,
  -4.58951406e-02f, 4.20235954e-02f, -1.10832951e-03f, 1.54747725e-01f, 3.17856334e-02f, -5.53342737e-02f, 2.84358189e-02f, 6.93206713e-02f, 8.52611512e-02f, -3.25076580e-02f,
  2.18305122e-02f, 1.41846975e-02f, -1.01442911e-01f, -6.04878888e-02f, -3.29413335e-04f, -8.29300284e-02f, -3.95042039e-02f, 8.54302123e-02f, -2.12023244e-03f, -7.70637244e-02f,
  -4.93774787e-02f, -5.94490282e-02f, -4.74312976e-02f, 1.42231919e-02f, -2.87306514e-02f, 5.79886250e-02f, -2.62797158e-02f, 6.36593963e-04f, -1.31135359e-01f, 1.27578266e-02f,
  3.06400321e-02f, 2.22289898e-02f, 7.16348961e-02f, -1.12044225e-02f, -1.44534046e-02f, 1.06062986e-01f, 1.00798354e-01f, 1.78947039e-02f, -5.99698722e-02f, 2.53367517e-02f,
  -4.25950401e-02f, -1.04536533e-01f, -7.85609186e-02f, -9.80156213e-02f, -1.35396356e-02f, -6.38107806e-02f, 1.70433447e-02f, -4.87629995e-02f, -1.32907769e-02f, 6.43531308e-02f,
  7.27098482e-03f, -2.43415479e-02f, 5.11637069e-02f, 6.93267882e-02f, 1.97826624e-02f, -3.29826958e-02f, 9.21552777e-02f, 6.71975017e-02f, 1.66320633e-02f, -8.16778243e-02f,
  -8.97958525e-04f, -3.01449914e-02f, -1.56519804e-02f, -1.06277503e-01f, 3.10289580e-02f, -2.55404543e-02f, -8.73826444e-02f, 5.07911965e-02f, 8.38688463e-02f, -1.08607812e-03f,
  2.37272650e-01f, -1.57210112e-01f, -2.14059666e-01f, -2.23107442e-01f, -1.75975740e-01f, -1.96666777e-01f, -1.63841441e-01f, -9.67251882e-02f, -1.44757494e-01f, -1.12440951e-01f,
  -7.80642331e-02f, -1.56443082e-02f, 1.10330462e-01f, -1.76912963e-01f, 7.40434602e-03f, 2.16320515e-01f, -1.34870663e-01f, -1.54556930e-01f, 6.06441014e-02f, -5.23038842e-02f,
  -6.26866706e-03f, -5.48365247e-03f, -6.40772507e-02f, 5.54440916e-02f, -1.43205777e-01f, 1.19160430e-03f, 4.39820886e-02f, -1.11488149e-01f, -6.25229105e-02f, -8.08783472e-02f,
  5.22028096e-02f, 9.34513379e-03f, -9.54755321e-02f, -2.22662501e-02f, -5.20305857e-02f, -3.44339833e-02f, -1.99147891e-02f, -6.83182627e-02f, 2.68228091e-02f, -8.22031647e-02f,
  1.33528737e-02f, 5.23592308e-02f, -1.44751053e-02f, -7.80192763e-02f, -7.69798504e-03f, -4.25279550e-02f, 3.29801813e-02f, 1.44377118e-02f, 1.52617162e-02f, -2.31646486e-02f,
  -3.23281363e-02f, 6.44161738e-03f, -7.81909749e-02f, -1.97703801e-02f, -2.81690154e-02f, -2.32356675e-02f, -5.20091737e-04f, -5.80221303e-02f, 5.33521026e-02f, 5.03972396e-02f,
  -4.87248413e-03f, 1.10454150e-01f, -1.58527475e-02f, -4.52758223e-02f, -8.21632296e-02f, 3.32315713e-02f, 5.35203144e-02f, 6.12201765e-02f, -9.77574736e-02f, 1.39633399e-02f,
  7.98608661e-02f, -5.65200113e-02f, 9.06912610e-02f, 1.33906752e-01f, 8.85474384e-02f, 1.24255441e-01f, 1.27673261e-02f, 1.95710640e-02f, -1.90244557e-03f, 3.97958830e-02f,
  -2.36473102e-02f, 1.76380575e-02f, -1.23077063e-02f, 3.20559628e-02f, 3.14791128e-02f, -6.18783496e-02f, -6.18900592e-03f, -2.31143534e-02f, -9.88295674e-03f, -2.30548736e-02f,
  -1.19499624e-01f, 1.39157744e-02f, 2.06061304e-02f, 1.89207569e-02f, -7.63290152e-02f, -5.94310462e-02f, 7.37870857e-02f, -1.35328099e-01f, 3.20163369e-03f, 2.42252331e-02f,
  1.82871763e-02f, -1.96441859e-02f, 3.33453864e-02f, 5.38036115e-02f, -8.13252330e-02f, -1.39152884e-01f, 1.00071415e-01f, -8.45424011e-02f, -1.09610215e-01f, 3.83688994e-02f,
  -5.58347851e-02f, 7.14654615e-03f, 5.47906719e-02f, -1.05935968e-02f, 1.28993066e-02f, -1.13380020e-02f, -1.09369248e-01f, -5.14502004e-02f, -2.07123533e-02f, -9.82340351e-02f,
  -1.82603560e-02f, -2.24739611e-01f, -1.35239184e-01f, -1.24591284e-01f, -5.94624914e-02f, -2.25697070e-01f, -2.75399208e-01f, -1.55179694e-01f, 5.95871322e-02f, -2.62151044e-02f,
  -1.05609909e-01f, 7.74070248e-02f, 1.03832863e-01f, -1.79759234e-01f, 1.63945723e-02f, 4.34288383e-02f, -3.32683533e-01f, -1.88792318e-01f, 3.79394670e-03f, -2.22949728e-01f,
  -6.84280694e-02f, -2.40546837e-01f, -1.22835390e-01f, -9.36585367e-02f, -2.72648603e-01f, -5.70871383e-02f, 6.15996905e-02f, -1.51993185e-01f, -1.14070214e-01f, -1.69155970e-02f,
  6.16229430e-04f, 1.25848100e-01f, 1.05849048e-02f, -4.54871021e-02f, -1.22287057e-01f, -8.82014409e-02f, -7.17851147e-02f, -4.54915129e-02f, 8.62967744e-02f, 4.93946895e-02f,
  -5.97291663e-02f, 5.28441593e-02f, -1.34424940e-01f, 7.85467774e-02f, -4.82552983e-02f, 1.49715887e-02f, -3.17372903e-02f, 2.45315637e-02f, 4.11873236e-02f, 7.17107803e-02f,
  -1.46370037e-02f, -2.83190869e-02f, -5.36138844e-03f, 1.44801304e-01f, -9.29506943e-02f, -1.11370999e-02f, 5.05548231e-02f, -7.01319950e-04f, -4.34781797e-02f, -8.08312651e-03f,
  -8.04199949e-02f, 9.33137834e-02f, -3.44517231e-02f, -9.91245210e-02f, -6.01260923e-02f, -6.17764750e-03f, 5.01930155e-02f, 2.10936591e-02f, -9.47650820e-02f, -6.33536801e-02f,
  -7.53272474e-02f, -4.04802226e-02f, 2.36534104e-02f, -8.59755464e-03f, -1.47638381e-01f, 1.33201450e-01f, 4.66866419e-04f, -3.61279808e-02f, -7.92377666e-02f, -2.25084033e-02f,
  3.72232012e-02f, -5.03147505e-02f, -7.74649829e-02f, 2.18405928e-02f, 4.96948557e-03f, 1.26555622e-01f, -1.24450605e-02f, 2.50548427e-03f, 1.02403313e-01f, -4.03702185e-02f,
  -1.08725570e-01f, -5.06465062e-02f, -5.58777228e-02f, -3.56167592e-02f, 5.41721210e-02f, -6.86280951e-02f, -1.06359974e-01f, -1.02645233e-01f, 2.14715675e-02f, 1.65859479e-02f,
  -6.90764710e-02f, 6.30748048e-02f, -4.98347878e-02f, 1.20015584e-01f, -9.98875946e-02f, -9.22236294e-02f, 4.77991067e-03f, 7.68823847e-02f, 2.67307218e-02f, 3.81897874e-02f,
  5.78955980e-04f, 4.80186976e-02f, 8.07265490e-02f, -6.78196922e-02f, -4.08387296e-02f, 5.53258881e-03f, -7.93479756e-03f, 9.84791573e-03f, 2.24120286e-03f, -4.44799848e-02f,
  2.66443323e-02f, 3.62509221e-01f, 8.80086869e-02f, 1.47968367e-01f, -9.99227315e-02f, 3.41595672e-02f, 8.01566765e-02f, 5.29029109e-02f, 1.35430679e-01f, 1.54099703e-01f,
  -1.68845505e-01f, 3.50825280e-01f, -5.82326576e-02f, -1.45648429e-02f, -1.24698445e-01f, -1.76606640e-01f, 4.35396396e-02f, 8.11473057e-02f, 2.05917090e-01f, 7.13359341e-02f,
  -7.96184763e-02f, -1.05705515e-01f, -1.54421195e-01f, 5.95379341e-03f, -4.96545210e-02f, 1.66994795e-01f, -1.03415489e-01f, -4.20070589e-02f, -4.89816368e-02f, -2.22585266e-04f,
  -1.46474004e-01f, 1.33472323e-01f, -8.77707973e-02f, -9.99295861e-02f, -9.35011804e-02f, 3.93297225e-02f, -2.91303080e-02f, -1.74920764e-02f, 2.90554129e-02f, -3.18803452e-02f,
  1.20025866e-01f, -3.08507737e-02f, 4.08006571e-02f, 3.71580175e-03f, 4.69636284e-02f, -3.82298045e-02f, -4.35581841e-02f, -5.40394709e-02f, 9.24382880e-02f, -2.91435979e-02f,
  -9.95084196e-02f, 2.42914539e-02f, -5.32482751e-02f, 1.14919968e-01f, -3.56468931e-02f, 8.65821168e-03f, 3.04288305e-02f, -1.18167577e-02f, 1.67641994e-02f, -6.45217299e-02f,
  4.85546625e-04f, 3.18066999e-02f, 3.75428274e-02f, -7.33161345e-03f, -3.03673875e-02f, -4.87382673e-02f, 1.95055399e-02f, -1.05005033e-01f, 4.07500081e-02f, 1.86318289e-02f,
  1.32610463e-02f, 3.36855203e-02f, -4.03376706e-02f, 1.22252665e-02f, -2.75414437e-02f, 9.58025157e-02f, 1.56642981e-02f, 1.07175417e-01f, -6.60371110e-02f, -6.68075979e-02f,
  6.66735321e-02f, 2.57214848e-02f, 2.24693883e-02f, 1.12794125e-02f, 3.68708447e-02f, -3.06896325e-02f, -2.24729758e-02f, 5.74001186e-02f, -3.92622501e-02f, -8.14040250e-04f,
  -3.49152312e-02f, 2.51021653e-01f, -1.23560419e-02f, -5.90998009e-02f, 7.82557130e-02f, -6.30061701e-02f, 9.37090367e-02f, -7.42356330e-02f, 1.18103869e-01f, 9.60591435e-02f,
  -2.56988872e-02f, -2.74325050e-02f, 7.13451654e-02f, -8.93343687e-02f, 6.43467531e-02f, 4.84433025e-03f, 1.23601109e-02f, 1.36788875e-01f, -6.59234524e-02f, -3.49264070e-02f,
  -2.04189550e-02f, -8.17621592e-03f, -1.26224924e-02f, 2.34066788e-02f, -3.09243426e-02f, -7.38825351e-02f, 6.72803447e-02f, -1.99816655e-02f, -6.69831485e-02f, 2.74123140e-02f,
  1.74108773e-01f, -8.04521739e-02f, -2.11016104e-01f, -1.18160903e-01f, 1.29432619e-01f, 9.19622183e-02f, -4.35593575e-02f, -1.21288963e-01f, -1.75536081e-01f, 1.25330929e-02f,
  1.07679762e-01f, -3.81341390e-02f, -6.60775453e-02f, 7.12455437e-02f, 6.52226731e-02f, -1.12627251e-02f, 3.63653265e-02f, 1.50489137e-01f, -2.31642071e-02f, -4.42597419e-02f,
  -3.66487280e-02f, 2.46051490e-01f, -1.12782590e-01f, 3.49581465e-02f, 2.37664536e-01f, -1.72945902e-01f, 6.08710013e-02f, -2.62336340e-02f, 5.54134604e-03f, 6.17168061e-02f,
  2.47206762e-02f, -2.86925547e-02f, -5.31495996e-02f, 1.24465730e-02f, -2.42980029e-02f, 1.00166313e-01f, 4.08051796e-02f, 8.71405602e-02f, -1.17937736e-01f, -3.39117870e-02f,
  -8.33698921e-03f, -3.69599536e-02f, 1.36374552e-02f, -7.71014951e-03f, 6.66531548e-03f, 8.07824135e-02f, 1.50150582e-02f, 2.50023138e-02f, -1.30625322e-01f, -1.96017716e-02f,
  -1.27226353e-01f, -2.41288077e-02f, 1.12927062e-02f, -4.21836600e-02f, -2.54379418e-02f, -1.09111518e-01f, -4.18192558e-02f, -5.04179560e-02f, -4.85708527e-02f, 4.57383767e-02f,
  1.11455396e-01f, 7.96767771e-02f, 6.55602366e-02f, 3.64189707e-02f, -9.55682714e-03f, 4.30092476e-02f, 6.03733622e-02f, -5.97063377e-02f, -1.38387278e-01f, -3.37503105e-03f,
  -1.34880573e-01f, -5.20804450e-02f, 2.03843624e-03f, 1.74121605e-03f, 1.61575958e-01f, 2.76600048e-02f, 9.28543601e-03f, 4.34107371e-02f, -1.50782347e-01f, -5.23716994e-02f,
  4.17894945e-02f, -2.75631361e-02f, -3.00301351e-02f, -1.22787254e-02f, 4.63728327e-03f, -9.69212353e-02f, 3.08573227e-02f, 1.66065544e-02f, -1.99193880e-02f, -1.22933518e-02f,
  2.24977662e-03f, -9.86496434e-02f, -6.83308765e-03f, 2.40679272e-02f, -2.63208635e-02f, 6.32631630e-02f, 5.06278202e-02f, -1.69526152e-02f, -7.04280287e-02f, 8.19163676e-03f,
  5.20800836e-02f, -1.03174075e-01f, 8.99951085e-02f, -2.69683097e-02f, 3.90282949e-03f, -2.80777607e-02f, 3.88901159e-02f, 5.36997169e-02f, 1.46253372e-03f, -5.55202998e-02f,
  -3.23473029e-02f, 2.60216054e-02f, -1.05853342e-01f, 6.21654056e-02f, 6.21170271e-03f, 6.65109679e-02f, 2.03584246e-02f, -1.32910628e-02f, -2.31407024e-03f, -3.99089977e-02f,
  1.35383576e-01f, -1.22076996e-01f, 1.89918742e-01f, 1.38104349e-01f, 1.40598044e-01f, 1.75358206e-01f, 2.49579161e-01f, -3.15825567e-02f, 1.02858134e-01f, -2.65328974e-01f,
  -6.43256381e-02f, 1.16039596e-01f, 2.03686520e-01f, -1.58750579e-01f, 3.10367674e-01f, 9.92632061e-02f, -7.74872070e-03f, -8.35879818e-02f, 1.67769976e-02f, -2.64396984e-02f,
  -4.35396209e-02f, -2.39539653e-01f, 1.36035343e-03f, -2.99480379e-01f, -1.68636858e-01f, -8.91226083e-02f, -1.38878554e-01f, 1.38977319e-01f, -1.94029823e-01f, 4.52792607e-02f,
  1.06953895e-02f, 3.11013013e-02f, 2.92996597e-02f, -9.06689931e-03f, -2.42432971e-02f, -1.43584274e-02f, 4.00746167e-02f, 2.75680367e-02f, 6.23268820e-02f, -1.14885829e-02f,
  -6.90003037e-02f, -6.84581473e-02f, -5.98844439e-02f, 6.08631037e-02f, 6.06030300e-02f, -9.12227333e-02f, 4.93402146e-02f, -3.15232351e-02f, -7.65675530e-02f, 5.55811264e-03f,
  8.17765296e-03f, 5.52936271e-02f, -3.71794286e-03f, 1.72808056e-03f, 1.74593925e-02f, -3.58594358e-02f, 3.25299390e-02f, 4.29934496e-03f, 3.68457846e-02f, 4.95109223e-02f,
  1.88890733e-02f, -2.55701486e-02f, 5.65916533e-03f, 5.32585979e-02f, 4.56841029e-02f, -5.79045676e-02f, -4.82720695e-03f, -2.49232054e-02f, 8.57928544e-02f, -3.65033224e-02f,
  6.72328919e-02f, -9.62436795e-02f, 7.49339350e-03f, 7.73127973e-02f, -8.16092938e-02f, -3.09648383e-02f, 6.20323233e-02f, -1.98728545e-03f, 2.00203247e-03f, -7.83929378e-02f,
  -3.96630727e-03f, -4.68953885e-02f, -4.10693884e-02f, -2.89164903e-03f, 8.46953988e-02f, 5.62267751e-02f, -3.69203873e-02f, 2.68230811e-02f, -1.00847250e-02f, -1.36935472e-01f,
  -3.50134149e-02f, -6.03609011e-02f, -6.65534511e-02f, -4.41589579e-02f, -4.40491177e-02f, -9.00744572e-02f, -8.12803581e-03f, -4.82220650e-02f, -9.09694191e-03f, -2.24280581e-02f,
  -8.98570493e-02f, -1.49460677e-02f, 4.94408756e-02f, 1.59140571e-03f, 6.31837472e-02f, -2.57683489e-02f, 1.91246122e-02f, -4.68970202e-02f, 8.14071223e-02f, -5.08449115e-02f,
  -1.71500780e-02f, -1.46024730e-02f, 7.28245005e-02f, -1.00426659e-01f, -7.49758109e-02f, 7.97743425e-02f, 4.25667409e-03f, 4.88694496e-02f, 3.02553084e-02f, -7.36082420e-02f,
  -3.71087901e-02f, -3.64244252e-01f, 1.56420350e-01f, 3.78073394e-01f, -7.90023133e-02f, -2.60830373e-01f, -1.22611009e-01f, -1.31041020e-01f, -1.41601250e-01f, -2.87219971e-01f,
  3.60024609e-02f, 1.58488601e-01f, -9.31884125e-02f, 1.57500312e-01f, 1.94908038e-01f, 3.28307115e-02f, 1.20971188e-01f, 2.18918193e-02f, 1.17608100e-01f, -3.72254439e-02f,
  1.49379864e-01f, 9.08967257e-02f, 3.26837301e-01f, 1.68326367e-02f, -2.07711179e-02f, 2.37629265e-01f, 1.31367728e-01f, 9.50596482e-02f, 1.71879441e-01f, 1.40525997e-01f,
  -2.55988628e-01f, -6.72025308e-02f, -4.98903580e-02f, 7.35380081e-03f, 3.50967683e-02f, -1.13119399e-02f, 4.18490656e-02f, 7.39030018e-02f, 1.44547662e-02f, 2.66671032e-02f,
  -4.97290678e-02f, 1.03579182e-02f, 5.19774556e-02f, 4.51966077e-02f, -5.83161190e-02f, -1.59706958e-02f, 1.02278702e-02f, -1.38062276e-02f, 1.40174450e-02f, 4.77238558e-02f,
  -4.85303029e-02f, -2.25182027e-02f, 2.45896522e-02f, 8.34939331e-02f, 3.58712524e-02f, 6.52286690e-03f, 1.41067788e-01f, 5.62288873e-02f, -1.57501623e-02f, -9.82399210e-02f,
  -5.40547632e-02f, -6.88912161e-03f, -5.85754365e-02f, -3.05422023e-02f, -5.91927860e-03f, 9.14451927e-02f, -8.36751089e-02f, -9.64715518e-03f, 7.93805942e-02f, -9.04962793e-02f,
  7.15053007e-02f, 6.20176420e-02f, -2.90623754e-02f, -1.31868005e-01f, -2.75140703e-02f, 4.75881025e-02f, 5.59241064e-02f, -4.49897759e-02f, -2.99207494e-02f, 3.50734293e-02f,
  -2.54286472e-02f, -7.74106383e-02f, -7.58960098e-03f, 3.21058035e-02f, -7.46428296e-02f, -4.04888205e-03f, -6.85390159e-02f, 2.64603086e-02f, 5.09502999e-02f, 2.66614486e-03f,
  -2.58691728e-01f, 1.11590400e-02f, -4.70495597e-02f, -8.06986988e-02f, -6.69164211e-02f, -6.83504939e-02f, -1.73697050e-03f, 2.76349969e-02f, 2.70715188e-02f, 1.89990066e-02f,
  -7.18171224e-02f, 5.66054583e-02f, -5.36241792e-02f, 9.20347124e-03f, 7.89658502e-02f, -2.16949470e-02f, -4.15108167e-02f, 1.13413729e-01f, 1.13736860e-01f, 5.68853226e-03f,
  4.20865752e-02f, -9.89836231e-02f, 1.90857444e-02f, -8.33686516e-02f, 8.86794459e-03f, -1.31794335e-02f, 2.70213839e-02f, 3.27707343e-02f, 3.84923369e-02f, -4.56385016e-02f,
  1.94734018e-02f, -1.07283751e-02f, -2.12625325e-01f, -3.56110819e-02f, -2.41283514e-02f, -3.60709637e-01f, -2.26767257e-01f, -7.81766474e-02f, 1.75099283e-01f, 8.09103772e-02f,
  -1.73690140e-01f, 2.37596594e-02f, 7.80009404e-02f, -2.28330061e-01f, -3.61311436e-02f, 2.02951089e-01f, -3.09570491e-01f, -3.69007364e-02f, 1.90068960e-01f, -1.79801360e-01f,
  -8.94709751e-02f, -1.82744071e-01f, -1.52711496e-01f, -7.17236549e-02f, -2.16680571e-01f, -9.58417580e-02f, 1.47279620e-01f, -7.41228461e-02f, -5.79713695e-02f, -4.77035493e-02f,
  -3.83194089e-02f, -4.22716327e-03f, 3.74710187e-02f, -6.06564581e-02f, -1.25992313e-01f, -1.10867739e-01f, -2.43112855e-02f, -1.98334213e-02f, -1.86972618e-02f, -7.74815911e-04f,
  -2.20100675e-02f, 5.22954315e-02f, 8.24388266e-02f, -7.18610287e-02f, 8.48049521e-02f, -4.68134768e-02f, -2.93823015e-02f, 6.47726282e-02f, -1.92367714e-02f, -1.32258190e-02f,
  -3.19313370e-02f, -4.24588062e-02f, -2.12883316e-02f, 5.92549741e-02f, 2.07096264e-02f, -3.53703052e-02f, -3.37364129e-03f, -1.17310919e-02f, -5.18048331e-02f, 1.04771473e-01f,
  2.78281532e-02f, -1.89988513e-03f, -4.28683236e-02f, -3.34032029e-02f, 5.99264214e-03f, 5.99448606e-02f, 4.83425409e-02f, 6.17162026e-02f, 7.35782236e-02f, 2.88204127e-03f,
  -1.92617718e-02f, 3.98843922e-02f, 6.37359619e-02f, 6.98685870e-02f, 3.30479220e-02f, 2.20317524e-02f, -1.96134560e-02f, 4.70967814e-02f, 3.49343345e-02f, 4.03153412e-02f,
  -8.51454027e-03f, -2.57387082e-03f, 7.34435469e-02f, 1.88284796e-02f, -1.35144904e-01f, -7.26289824e-02f, -2.31841989e-02f, -5.37989028e-02f, -6.00161077e-03f, -4.77558322e-04f,
  -6.63794950e-02f, -5.55886663e-02f, -2.66512800e-02f, 3.30288261e-02f, -9.10907537e-02f, -6.85604885e-02f, 9.62881744e-03f, 5.91337048e-02f, 3.65625471e-02f, -4.44105901e-02f,
  -5.02645373e-02f, 1.00503732e-02f, 4.71921675e-02f, 9.55851469e-03f, 6.32376000e-02f, -6.60293177e-03f, -2.91818455e-02f, -1.23964101e-02f, -2.25812923e-02f, 1.70176439e-02f,
  2.26754174e-02f, -4.38874885e-02f, -2.13917252e-02f, -1.22529939e-02f, 5.97111098e-02f, -5.58853969e-02f, -8.19576681e-02f, 2.31547598e-02f, -1.50200408e-02f, 6.10789470e-02f,
  -2.14915916e-01f, -7.30626401e-04f, 7.36472085e-02f, -2.38649607e-01f, 1.97101124e-02f, -8.46768171e-02f, -1.50091350e-01f, 1.20401055e-01f, 5.30154407e-02f, 3.89755629e-02f,
  -8.72638002e-02f, -1.08364381e-01f, 1.40672147e-01f, -5.12881130e-02f, -3.66875790e-02f, 9.17374492e-02f, -1.54096797e-01f, -1.34530917e-01f, 2.97238063e-02f, -2.08854690e-01f,
  -1.67631239e-01f, -1.87105209e-01f, 3.86230201e-02f, 5.78726977e-02f, -1.76387787e-01f, -9.59073380e-03f, -4.67771105e-02f, 2.37293332e-03f, -9.69592631e-02f, 4.14885730e-02f,
  2.88507715e-02f, 1.17373541e-01f, 9.56742167e-02f, 1.36110187e-01f, 7.43582398e-02f, -9.50590055e-03f, -9.02656317e-02f, -6.65573701e-02f, -5.63705713e-02f, -7.49169216e-02f,
  -9.13679227e-02f, 6.02974854e-02f, -3.67016494e-02f, -3.69617306e-02f, 3.18042077e-02f, 8.06767344e-02f, -4.53871600e-02f, 9.73022822e-03f, 8.03630948e-02f, -3.80907976e-03f,
  -9.78143066e-02f, 7.53242373e-02f, -8.95643085e-02f, 1.88129060e-02f, -6.14418909e-02f, 1.18591957e-01f, -1.07967621e-02f, -3.11556626e-02f, -2.06305645e-02f, -1.07176863e-01f,
  2.40448881e-02f, -7.49984458e-02f, -1.46525661e-02f, 3.76780517e-02f, -1.07067883e-01f, 1.68187141e-01f, 3.69561873e-02f, 8.55674446e-02f, -2.58932970e-02f, 7.57689700e-02f,
  9.01585594e-02f, -3.89294215e-02f, -2.24875119e-02f, -6.95600510e-02f, -1.48716271e-01f, 2.32355241e-02f, 2.99303792e-02f, 2.73664407e-02f, -8.94138142e-02f, 1.33408934e-01f,
  4.09037210e-02f, -1.16645219e-02f, 7.08179697e-02f, -2.25466602e-02f, 1.84084296e-01f, 5.37558608e-02f, -1.40625155e-02f, 3.87350172e-02f, -3.01536992e-02f, -1.88259333e-01f,
  -4.45691589e-03f, -9.40519013e-03f, 1.02334172e-01f, 1.13030106e-01f, 5.10706715e-02f, -2.21151318e-02f, -2.73774490e-02f, -5.75175509e-02f, -6.87303618e-02f, -6.87628612e-02f,
  -1.24677949e-01f, 4.59073996e-03f, -3.23581547e-02f, 3.50916497e-02f, -6.37356788e-02f, 7.05279186e-02f, -8.11325945e-03f, 2.64899433e-02f, -2.34441459e-02f, -5.83115034e-02f,
  1.94755103e-02f, 5.75689748e-02f, -3.52394693e-02f, -7.48663172e-02f, -1.66799314e-02f, -1.48718422e-02f, 4.29664440e-02f, -4.08220589e-02f, 3.96723710e-02f, -7.35118007e-03f,
  -4.62916195e-01f, 9.47324932e-02f, 1.68408453e-01f, -9.32686999e-02f, -2.13577077e-01f, 1.36628509e-01f, 2.03375056e-01f, -9.50858295e-02f, -1.99379086e-01f, 1.01240151e-01f,
  -7.22560063e-02f, -1.47296563e-01f, 2.71882027e-01f, -1.62279550e-02f, 1.90808102e-01f, 1.31916061e-01f, -1.00424392e-02f, 1.36462525e-01f, -9.38380808e-02f, -4.13616709e-02f,
  -1.09940201e-01f, -8.07969347e-02f, 2.81361312e-01f, -6.55764863e-02f, -9.72014666e-02f, -1.50418326e-01f, -6.17799796e-02f, 4.19150516e-02f, -1.16009399e-01f, -9.67223346e-02f,
  -1.88108250e-01f, -2.04396605e-01f, -1.03777058e-01f, 9.43722203e-02f, -1.58650100e-01f, 3.32752354e-02f, -4.32651117e-02f, -7.62880370e-02f, -8.03545788e-02f, 1.09227382e-01f,
  -1.31193222e-03f, -2.57079280e-03f, -6.98880702e-02f, 5.27376600e-04f, -5.12095466e-02f, 5.72942793e-02f, 1.96159165e-03f, -2.29749639e-04f, -7.15354905e-02f, -6.26728386e-02f,
  -1.49340695e-02f, 6.63979081e-05f, 2.91749984e-02f, 1.38003230e-02f, -1.98714118e-02f, -9.77330580e-02f, 3.70661281e-02f, 2.83050031e-04f, -5.16531244e-02f, -8.10820013e-02f,
  -2.09611617e-02f, 3.11455764e-02f, -2.07981821e-02f, 5.35999760e-02f, 4.17014435e-02f, 7.25066336e-03f, 6.85482472e-03f, -2.51784977e-02f, -2.35376917e-02f, -3.16737518e-02f,
  -1.01695955e-01f, 3.44986543e-02f, -4.56415080e-02f, 7.20041171e-02f, -1.50053632e-02f, -3.36492918e-02f, -7.95387954e-04f, -1.95276458e-02f, -2.15451065e-02f, -8.35178047e-02f,
  4.26316783e-02f, -3.22063416e-02f, 5.62571399e-02f, 7.62053281e-02f, -2.03726813e-02f, 3.65571515e-03f, -7.92765245e-02f, 1.12664187e-02f, 9.57502499e-02f, 1.20205702e-02f,
  -9.73305330e-02f, -1.10987611e-01f, -1.24580763e-01f, -6.23510368e-02f, -1.47030326e-02f, 3.42135355e-02f, 6.88043535e-02f, -9.91772562e-02f, -6.47618473e-02f, -3.13586667e-02f,
  2.34394595e-02f, 2.30141217e-03f, 1.20878266e-02f, -9.20076892e-02f, 6.17485829e-02f, 1.31635340e-02f, 1.96727198e-02f, -1.46346644e-03f, 1.03323665e-02f, -4.05901074e-02f,
  1.29027562e-02f, -4.10526842e-02f, -5.20086009e-03f, -2.15986259e-02f, 1.33722872e-02f, -1.23088676e-02f, -1.76643699e-01f, -5.36768474e-02f, 3.95832630e-03f, -3.08377557e-02f,
  -1.26660243e-01f, 1.00485891e-01f, -5.40239587e-02f, -1.23253971e-01f, 8.42779204e-02f, -1.81428075e-01f, -6.68192580e-02f, 5.57298623e-02f, -8.79995823e-02f, 1.30715162e-01f,
  -4.27870899e-02f, 3.96554172e-02f, 5.63300848e-02f, -2.20976427e-01f, -4.09606874e-01f, -2.00696245e-01f, -2.07219824e-01f, -1.19202964e-01f, 3.10337357e-02f, 7.40947959e-04f,
  -1.00441083e-01f, -9.39102396e-02f, -9.29296687e-02f, 3.14934030e-02f, 3.29570062e-02f, 1.21100925e-01f, 1.83514401e-01f, 6.25961646e-02f, 7.23784044e-02f, -3.79804373e-02f,
  -1.16493002e-01f, 9.55820363e-03f, -1.45958653e-02f, -5.25313951e-02f, 6.20442517e-02f, 3.99152562e-03f, -1.25526506e-02f, -7.16971606e-02f, -5.99418841e-02f, -3.83084789e-02f,
  -7.13407947e-03f, 1.01878708e-02f, 1.58481449e-02f, 9.16833803e-02f, -1.52789271e-02f, 1.07388711e-03f, -4.45096903e-02f, -5.42888306e-02f, -1.74025707e-02f, -7.37307593e-02f,
  -2.31608003e-02f, 2.83181816e-02f, 6.86886683e-02f, 3.70200463e-02f, 8.62678960e-02f, 3.41964187e-03f, -3.81447412e-02f, -1.43666407e-02f, -2.52378490e-02f, 3.78158242e-02f,
  7.71407271e-03f, 3.04951873e-02f, 2.62988284e-02f, 1.62076131e-02f, 2.62414459e-02f, 3.62501740e-02f, -3.94998491e-02f, 3.13237533e-02f, -8.35758075e-03f, 6.29252056e-03f,
  8.06962326e-02f, -1.64448470e-02f, -7.50316456e-02f, -4.58782129e-02f, -1.24153513e-02f, 2.49057282e-02f, -5.25155999e-02f, 8.50958342e-04f, -4.48077125e-03f, -3.08093876e-02f,
  1.18785389e-01f, -1.95261929e-02f, 3.68661731e-02f, 1.70753542e-02f, -6.88482821e-02f, 4.20221835e-02f, 4.67955088e-03f, -2.24631727e-02f, 6.47656024e-02f, 5.98483868e-02f,
  -2.10722294e-02f, 1.72912434e-01f, -2.73296423e-02f, 1.79313903e-03f, 2.37032175e-02f, 2.73111984e-02f, 3.09675187e-03f, 4.36365455e-02f, 6.83092847e-02f, 2.43259557e-02f,
  -2.98885140e-03f, 5.85902743e-02f, 7.00694248e-02f, -6.85329884e-02f, -5.52860228e-03f, 2.55449172e-02f, 1.00718789e-01f, 1.33546427e-01f, 7.94308633e-02f, 1.25178788e-02f,
  5.77338263e-02f, 1.25449687e-01f, 2.74800998e-03f, -2.23392695e-02f, 6.71505509e-03f, 7.61024579e-02f, 7.86560103e-02f, 3.07765771e-02f, 4.38327044e-02f, 4.01763618e-02f,
  -1.60434827e-01f, -1.21744715e-01f, -1.55889392e-01f, -8.29564705e-02f, 1.11031778e-01f, 9.01569501e-02f, -4.35665213e-02f, -5.15413098e-02f, -1.42843202e-01f, -3.80866081e-02f,
  -1.91489805e-03f, -5.44618778e-02f, -5.99445812e-02f, -1.85446106e-02f, -4.47734147e-02f, -1.21105514e-01f, -1.35385305e-01f, -1.25935063e-01f, -1.00749232e-01f, 3.58733647e-02f,
  -5.30375727e-02f, -2.27801478e-03f, -1.28673151e-01f, -2.38552764e-02f, 2.91897822e-02f, -1.19722247e-01f, 3.01692393e-02f, 8.55033472e-02f, 1.29962653e-01f, 3.03912815e-02f,
  1.07703835e-01f, -3.24739590e-02f, -6.78585004e-03f, 2.23450698e-02f, 2.13998072e-02f, 5.28909974e-02f, 4.46994081e-02f, -3.62657732e-03f, 1.42111266e-02f, 7.97314867e-02f,
  -4.32152450e-02f, -4.48989123e-02f, -6.67899400e-02f, 1.02956807e-02f, -1.31658977e-02f, -1.52539099e-02f, -8.66749138e-02f, 3.16126682e-02f, -7.64431283e-02f, -1.77047737e-02f,
  -8.35822448e-02f, -9.01141949e-03f, -1.53986812e-01f, -1.45142362e-01f, -1.91389974e-02f, 1.95181388e-02f, 1.46155842e-02f, 6.74590319e-02f, -1.25087216e-01f, 6.90040290e-02f,
  -6.96790963e-02f, 7.14391991e-02f, 3.25964466e-02f, -1.26420021e-01f, 1.63845092e-01f, -1.40488029e-01f, -3.31982560e-02f, -7.76410848e-02f, -1.50268063e-01f, 8.51331428e-02f,
  -4.74552065e-02f, -1.45543516e-01f, -5.42151295e-02f, -2.80949334e-03f, 1.33638382e-01f, 5.23542939e-03f, -2.65501086e-02f, 4.49756756e-02f, -4.47358750e-02f, 9.25111920e-02f,
  1.39608951e-02f, 4.73854244e-02f, 8.36679935e-02f, 1.45417778e-02f, 2.13728901e-02f, 1.53683215e-01f, -4.43144739e-02f, 1.19390547e-01f, -9.36278701e-02f, 1.38320848e-02f,
  6.95466623e-02f, 1.31657803e-02f, 1.69739518e-02f, -4.07580920e-02f, -2.46893447e-02f, 6.47694021e-02f, 1.90450698e-02f, -1.38990982e-02f, -4.37370092e-02f, 4.14034501e-02f,
  2.50167027e-02f, -5.74132204e-02f, 1.10429928e-01f, -2.17897948e-02f, -9.78044719e-02f, 4.47025783e-02f, -5.51751368e-02f, 6.44347668e-02f, -2.96275001e-02f, -8.76340121e-02f,
  -1.90876089e-02f, -7.07202777e-02f, -1.11368902e-01f, -4.83518988e-02f, 1.72232129e-02f, 1.15098223e-01f, 4.36470881e-02f, -1.22132460e-02f, -1.21707514e-01f, -2.51081362e-02f,
  -4.06370088e-02f, 1.83682382e-01f, 2.07315534e-01f, 1.54187093e-02f, -3.08043897e-01f, -1.72255799e-01f, -1.59688279e-01f, 8.23935047e-02f, -6.44240007e-02f, 1.06138714e-01f,
  2.78730560e-02f, 1.23692319e-01f, 1.23747915e-01f, 1.92626178e-01f, 6.35201903e-03f, 2.13404015e-01f, 3.75088193e-02f, -7.26983696e-02f, 3.85900959e-02f, 2.16630846e-01f,
  1.00703798e-01f, 1.04176030e-01f, 1.58832356e-01f, 1.10062569e-01f, 1.49018079e-01f, 8.74233544e-02f, 1.92132182e-02f, 1.81128625e-02f, 2.20018742e-03f, -1.12543769e-01f,
  3.84074263e-02f, 1.01206400e-01f, 7.51911625e-02f, 3.37322652e-02f, 9.37536061e-02f, -7.61746056e-03f, -2.93066315e-02f, -1.31514788e-01f, -3.58715057e-02f, 5.45208231e-02f,
  1.86825711e-02f, -7.05066277e-03f, -5.58257755e-03f, -3.42553332e-02f, -1.78504307e-02f, -6.21705391e-02f, -6.83362782e-02f, 3.51520069e-03f, 1.08045243e-01f, 2.02346668e-02f,
  1.15113690e-01f, 1.47826582e-01f, 1.26976505e-01f, 8.69709700e-02f, -2.28128862e-02f, -9.48373752e-04f, -1.37643337e-01f, 1.91175025e-02f, 1.05451114e-01f, -3.04836407e-02f,
  6.94897771e-02f, -1.36051876e-02f, -1.48723349e-02f, 5.38011380e-02f, -5.52856065e-02f, 2.78696474e-02f, -4.12657782e-02f, -5.85124567e-02f, -3.82201769e-03f, -3.41654941e-02f,
  -8.26951489e-02f, -4.32687178e-02f, -2.12622695e-02f, -3.58448252e-02f, 2.77953614e-02f, 6.41840771e-02f, -3.84660959e-02f, 4.71535139e-02f, -7.70069733e-02f, 1.88370757e-02f,
  7.95056820e-02f, -4.89970483e-02f, 5.18098064e-02f, 1.39016416e-02f, -8.85624439e-02f, 8.13759863e-03f, 7.98297767e-03f, 2.64316443e-02f, 1.42885176e-02f, -6.84360228e-03f,
  1.29447803e-01f, 1.89501524e-01f, 1.28968209e-01f, -5.98993152e-02f, 5.21062836e-02f, 7.59501457e-02f, 1.10274881e-01f, 5.62843494e-02f, 6.33717701e-02f, 4.59079519e-02f,
  1.49585651e-02f, -6.81630969e-02f, 1.61968972e-04f, -3.97079363e-02f, -3.39891613e-02f, 1.22927472e-01f, 8.17858875e-02f, 4.93532047e-03f, -2.32075751e-02f, 4.18504141e-02f,
  5.36807580e-03f, 1.10638840e-02f, 6.65701777e-02f, 5.82892299e-02f, 4.45659384e-02f, 1.34823233e-01f, -9.89396870e-02f, 1.07541151e-01f, 4.53142822e-02f, 3.31788547e-02f,
  1.15612999e-01f, 3.49542387e-02f, 1.41564906e-01f, 8.73511359e-02f, 7.63206556e-02f, 1.21533699e-01f, 1.00919463e-01f, -2.13588942e-02f, 7.76032284e-02f, -8.91950913e-03f,
  -1.60587296e-01f, 1.87751144e-01f, 8.46984461e-02f, 4.23936695e-02f, 1.81212887e-01f, 1.67173222e-01f, 3.38198505e-02f, -2.58465745e-02f, 5.17687276e-02f, -1.59589291e-01f,
  -1.09628089e-01f, -1.09773420e-01f, 1.27764430e-03f, -1.26490206e-01f, 2.88739204e-02f, -2.03258283e-02f, 5.00387289e-02f, 1.92707434e-01f, -6.60615042e-02f, 7.51715302e-02f,
  1.51534360e-02f, -7.61108473e-02f, -1.13103218e-01f, -3.54695097e-02f, 1.05684064e-02f, -7.76012079e-04f, 1.70052070e-02f, 3.84813757e-03f, 1.74209289e-03f, -5.54407611e-02f,
  3.87743041e-02f, 1.40712243e-02f, 1.87969562e-02f, 3.64575833e-02f, -3.96550000e-02f, -8.12036842e-02f, 5.51693030e-02f, -2.12696232e-02f, 7.81464651e-02f, -2.00073402e-02f,
  2.55434075e-03f, 4.90676798e-02f, 1.80970728e-02f, 6.18845969e-02f, -8.06672126e-03f, -2.91849999e-03f, -1.17664356e-02f, 1.38163552e-01f, -4.57382388e-02f, 2.30140276e-02f,
  -3.13160978e-02f, 1.78212579e-02f, -5.40701002e-02f, 1.85307283e-02f, -8.69819149e-03f, -1.36705050e-02f, 2.43834350e-02f, -3.99373695e-02f, -3.32315490e-02f, 3.82059328e-02f,
  5.10031283e-02f, 1.00671716e-01f, 8.48615170e-02f, 1.92815885e-02f, -7.99913704e-03f, -2.73462795e-02f, -6.47245497e-02f, 6.46383315e-02f, 3.51867452e-02f, -3.58524285e-02f,
  2.60444377e-02f, 8.81591365e-02f, 4.40400466e-02f, 5.20507954e-02f, 5.82659617e-02f, -5.03989868e-02f, -4.22572680e-02f, 2.55071800e-02f, -1.35475391e-04f, -2.03703810e-02f,
  7.77759105e-02f, 2.50102859e-02f, -1.08640850e-01f, -9.73659009e-02f, 1.19616650e-01f, 1.36395302e-02f, -5.41697703e-02f, -4.70145196e-02f, 3.81542705e-02f, -1.47419944e-01f,
  -1.60097592e-02f, 7.58716092e-02f, 1.51252858e-02f, -7.52249286e-02f, -9.79135409e-02f, 8.37910082e-03f, -4.20343280e-02f, -7.10628852e-02f, -1.41353961e-02f, -1.27072021e-01f,
  -4.66262847e-02f, -4.96243872e-02f, -5.63598759e-02f, -4.05895822e-02f, -4.79449630e-02f, 5.47952615e-02f, -1.44775603e-02f, 6.62709847e-02f, 3.36811170e-02f, 4.49555591e-02f,
  -3.17509562e-01f, -4.94162850e-02f, 2.74198145e-01f, -8.65245610e-02f, -1.57926828e-01f, 1.74906135e-01f, 2.42266580e-01f, -6.33911490e-02f, -1.14087395e-01f, 1.56047553e-01f,
  9.53513607e-02f, 6.22983910e-02f, 3.29902440e-01f, -2.98373494e-02f, 2.48838320e-01f, 1.08817004e-01f, 2.04352196e-03f, 1.06789842e-01f, -1.43911719e-01f, -1.40156090e-01f,
  -1.15156114e-01f, -1.13024220e-01f, 2.01681405e-01f, -1.78542510e-01f, -1.03933223e-01f, -1.25895396e-01f, -4.08655033e-02f, 5.11704534e-02f, -1.26004487e-01f, -3.17687616e-02f,
  -1.05190217e-01f, -1.48240238e-01f, -1.20273367e-01f, 1.62347704e-02f, -5.29833287e-02f, 6.25388771e-02f, 8.76729041e-02f, 8.97870436e-02f, -7.89413601e-03f, 6.00793362e-02f,
  -3.14203575e-02f, -2.57978402e-02f, -1.17933443e-02f, 2.94940826e-02f, -9.96750817e-02f, 1.77369267e-02f, 1.56647223e-03f, -8.58661681e-02f, 5.83521202e-02f, -5.03671821e-03f,
  1.32749334e-01f, -3.91691551e-02f, -8.49205777e-02f, 6.68384507e-02f, -1.11269541e-01f, 2.57205274e-02f, -4.80171479e-02f, 6.43412918e-02f, -2.63424069e-02f, -1.04098745e-01f,
  -3.78410034e-02f, 6.16991445e-02f, -1.37024105e-03f, 3.06798657e-03f, 4.34707105e-03f, -1.81017793e-03f, 2.53260415e-02f, 6.69441372e-02f, 2.72271484e-02f, -5.42170480e-02f,
  -4.82485211e-03f, -1.71047803e-02f, -3.47725451e-02f, -1.97960325e-02f, -3.01696118e-02f, 1.86551474e-02f, 4.51631546e-02f, -3.82539406e-02f, -3.99311855e-02f, -5.78825772e-02f,
  1.08670056e-01f, -1.70644540e-02f, 4.61525843e-02f, 3.95438028e-03f, -2.11045193e-03f, 7.41868764e-02f, -5.07670194e-02f, 5.66613395e-03f, 4.04567309e-02f, 5.56903146e-02f,
  7.55602494e-03f, -1.22795567e-01f, -2.23744754e-02f, -4.96443287e-02f, -7.36537203e-02f, 1.31420903e-02f, -7.42517859e-02f, -2.40340289e-02f, -1.03141010e-01f, 1.01728020e-02f,
  -2.69655865e-02f, -1.34105152e-02f, -6.05729446e-02f, 2.25107595e-02f, 1.08994678e-01f, 1.41019290e-02f, 7.83319399e-03f, -9.71293747e-02f, -1.67870778e-03f, -1.21190231e-02f,
  1.11885266e-02f, -7.89805874e-02f, 1.29863933e-01f, -8.25482793e-03f, -5.56786992e-02f, -1.99824739e-02f, -7.25425035e-02f, -3.52169760e-02f, -2.65907086e-02f, 5.21535985e-02f,
  -1.52472779e-01f, 3.29528868e-01f, -1.47491638e-02f, 3.43828350e-01f, -2.09387287e-01f, 6.47853091e-02f, 1.81713730e-01f, 1.30343363e-01f, 8.84829238e-02f, 2.09857002e-01f,
  3.75302993e-02f, 6.28457293e-02f, -2.62194779e-03f, 3.17719370e-01f, 5.83830588e-02f, 1.62210211e-01f, 2.72063404e-01f, 2.06777647e-01f, -2.82105221e-03f, 2.09911302e-01f,
  1.10502085e-02f, 2.66575098e-01f, 5.61402291e-02f, 4.82544396e-03f, 3.72149758e-02f, -1.10681154e-01f, 3.71706225e-02f, -1.35216579e-01f, 9.06254649e-02f, -8.57140720e-02f,
  -4.00158204e-02f, 5.36202863e-02f, -3.73114161e-02f, -1.36247545e-01f, 5.42419516e-02f, -1.98392966e-03f, -7.07726181e-02f, -7.15863779e-02f, -6.73995167e-02f, 3.97476330e-02f,
  -2.11914442e-02f, 2.28497628e-02f, 1.06264271e-01f, -2.04378497e-02f, -3.77398953e-02f, -2.19115410e-02f, -2.76330374e-02f, -4.92260195e-02f, -1.59630261e-03f, 1.12869684e-02f,
  -1.50485905e-02f, -3.02287634e-03f, -1.59955975e-02f, 5.73279187e-02f, -1.33312792e-01f, -8.04127306e-02f, 6.48400709e-02f, -6.00003684e-03f, 1.57182310e-02f, 6.75645843e-02f,
  2.21646558e-02f, 3.03908363e-02f, -4.44113724e-02f, -3.68733816e-02f, -4.56564613e-02f, -2.76037510e-02f, 4.21560369e-02f, 6.22703210e-02f, -4.90254648e-02f, 7.77913108e-02f,
  -9.54114273e-03f, 1.19636804e-02f, 2.12223567e-02f, 8.17830395e-03f, 1.36027843e-01f, -1.19241849e-02f, -6.29317313e-02f, 1.11476853e-01f, 2.02409681e-02f, 3.62792574e-02f,
  2.27727443e-02f, 3.45379766e-03f, -1.44529054e-02f, 2.33881753e-02f, 1.48326345e-02f, -5.90630658e-02f, 1.77712739e-02f, -2.80872826e-03f, -7.54925758e-02f, 5.77398017e-02f,
  1.20152391e-01f, 2.75171757e-01f, -8.54840782e-03f, -1.08686322e-02f, 8.36295485e-02f, 1.86747480e-02f, -1.09646423e-02f, 1.29891234e-02f, -5.24407923e-02f, -3.44782434e-02f,
  9.87493433e-03f, -6.59614578e-02f, 2.22313441e-02f, 8.95497575e-03f, 6.65562376e-02f, -1.78428292e-02f, 6.94605038e-02f, -2.07201596e-02f, -2.66016666e-02f, 9.70007926e-02f,
  -3.49699371e-02f, 2.20285840e-02f, -6.76791975e-03f, -5.81036694e-03f, -3.17325369e-02f, -3.97684164e-02f, -1.05697056e-02f, -2.94843093e-02f, -3.04961726e-02f, 2.31124945e-02f,
  1.02584645e-01f, 2.14503303e-01f, 1.88340813e-01f, 1.03824802e-01f, -1.67485401e-01f, -3.33949268e-01f, -1.00494735e-01f, 3.52502987e-02f, 2.44446918e-02f, -1.26977056e-01f,
  -1.48318201e-01f, 2.49371961e-01f, -1.25502601e-01f, 6.02618121e-02f, -1.10789217e-01f, -1.77788958e-01f, 5.14732413e-02f, -4.68237549e-02f, -1.65427532e-02f, -1.41548022e-04f,
  1.44520938e-01f, -1.93576619e-01f, 9.77083743e-02f, -9.71030965e-02f, 9.41441506e-02f, 1.79301679e-01f, 2.48549730e-02f, -5.67336418e-02f, 1.62274837e-01f, 6.81314096e-02f,
  3.08112949e-02f, 8.34030658e-02f, 1.06568888e-01f, -4.13460881e-02f, 6.28923848e-02f, 1.35954469e-01f, 3.28355096e-02f, 3.96322506e-03f, 1.33552775e-02f, -7.87226707e-02f,
  7.73312151e-03f, -8.57701376e-02f, 2.48511368e-03f, -4.31696102e-02f, -3.38954455e-03f, -7.98000693e-02f, 3.24386568e-03f, 1.76760986e-01f, 5.86188249e-02f, 3.77746411e-02f,
  3.64464149e-02f, 6.32745773e-02f, 2.08764654e-02f, 1.43555343e-01f, 2.03837723e-01f, 8.54150653e-02f, -9.10635740e-02f, 1.21209109e-02f, 7.23085031e-02f, 2.93268245e-02f,
  -8.01367033e-03f, -1.01738669e-01f, -1.08615965e-01f, -1.74257085e-01f, -4.77071777e-02f, -2.28139516e-02f, -8.64699036e-02f, 1.05141196e-03f, -7.33509883e-02f, -8.83979723e-02f,
  1.02117829e-01f, 2.93057729e-02f, -1.51625961e-01f, 4.99502718e-02f, -6.80621564e-02f, -2.25042887e-02f, -4.69242455e-03f, -2.46547610e-02f, 4.07085232e-02f, 9.15402323e-02f,
  -8.45108107e-02f, -1.10689104e-01f, 7.30851218e-02f, 6.98291734e-02f, -1.41824465e-02f, -6.95962012e-02f, -1.51324179e-02f, -4.27779183e-02f, 4.07545045e-02f, 6.40402660e-02f,
  2.76186410e-02f, -2.01834850e-02f, 1.62898570e-01f, 6.77851588e-02f, -7.34058246e-02f, 5.47148995e-02f, -8.60849097e-02f, 3.30457315e-02f, -2.99001054e-04f, -4.45742607e-02f,
  7.98514336e-02f, 1.78088974e-02f, -1.09052166e-01f, 1.59078487e-03f, -3.02842110e-02f, -5.75841311e-03f, 5.75500764e-02f, 9.97370947e-03f, 1.23295642e-01f, -1.04874698e-02f,
  1.93570256e-02f, -7.84858838e-02f, -2.03638785e-02f, 4.59307544e-02f, 9.41172540e-02f, 3.13773565e-02f, -2.81828325e-02f, 6.70787245e-02f, 8.00815970e-02f, -3.65180299e-02f,
  2.73319364e-01f, 7.58848190e-02f, 3.25928777e-01f, 1.62055463e-01f, -1.12650886e-01f, 1.10394552e-01f, 1.04468428e-01f, 1.84198804e-02f, 3.66787553e-01f, 8.23905617e-02f,
  -8.96353945e-02f, 1.46328807e-01f, -4.51986566e-02f, 8.76968354e-02f, -1.41995281e-01f, -1.73840895e-01f, 1.68636199e-02f, 3.27000916e-02f, 5.83209516e-03f, 1.21922858e-01f,
  -8.91569778e-02f, -3.03571433e-01f, -1.03134833e-01f, -1.54370859e-01f, 5.60365058e-02f, 1.25007123e-01f, -3.12852979e-01f, -7.10382983e-02f, -1.36792129e-02f, -6.25482500e-02f,
  -4.95874472e-02f, 1.17143698e-01f, 9.75173861e-02f, 8.11312348e-02f, 1.53963957e-02f, 7.90186375e-02f, -3.49852890e-02f, 7.68557936e-02f, 2.19681580e-02f, 8.14521983e-02f,
  -2.06467174e-02f, 7.90304989e-02f, 1.63896531e-02f, 5.61165512e-02f, 1.72354907e-01f, 1.10329092e-01f, -9.05604511e-02f, 2.70606168e-02f, 1.31569713e-01f, 1.17601313e-01f,
  1.00326091e-01f, 2.19978448e-02f, 2.46402510e-02f, -1.04100723e-02f, 1.58633839e-03f, 3.05995904e-03f, 8.05628970e-02f, 1.68961324e-02f, 1.87695727e-01f, 1.10346889e-02f,
  6.92991838e-02f, -5.54698966e-02f, -5.67293279e-02f, 1.77096397e-01f, 3.49430777e-02f, -5.33396341e-02f, -1.19981349e-01f, -1.32870555e-01f, 4.20320630e-02f, 5.22059053e-02f,
  -2.04490535e-02f, -7.32755288e-02f, -9.90645960e-02f, -5.24707623e-02f, -8.86609554e-02f, 8.48763585e-02f, -8.27444419e-02f, 8.19711909e-02f, 8.61589704e-03f, -1.04965277e-01f,
  3.93204112e-03f, 9.93532985e-02f, 9.36223865e-02f, 1.70772837e-03f, -3.06389220e-02f, -3.83582339e-02f, 1.62709236e-01f, 1.61976561e-01f, -5.88656105e-02f, -4.76562418e-02f,
  -1.31334662e-01f, -6.16943277e-02f, -9.50711742e-02f, 8.03988576e-02f, 4.76460496e-04f, 1.35835826e-01f, -1.51576281e-01f, 1.02610111e-01f, -2.88011227e-02f, 6.61837161e-02f,
  9.57595091e-03f, 6.32032156e-02f, 5.06897606e-02f, -7.27562457e-02f, 5.85368252e-04f, -7.34396055e-02f, -9.51538607e-03f, -3.60554419e-02f, -3.86423953e-02f, -2.44124383e-02f,
  7.18755051e-02f, -6.35633245e-02f, 2.83594485e-02f, -1.11568486e-02f, -5.67691633e-03f, -2.11971216e-02f, 5.10910340e-02f, 6.72098622e-02f, -1.40259072e-01f, -8.05820376e-02f,
  -7.39796609e-02f, 1.86803609e-01f, -4.90648411e-02f, -2.86673419e-02f, -2.35821098e-01f, 2.77011722e-01f, 2.60388434e-01f, -3.56312469e-02f, -2.52637956e-02f, 3.61882448e-01f,
  1.62900463e-01f, -1.71638522e-02f, 1.53849483e-01f, 1.11764997e-01f, 9.14908573e-02f, 2.67573327e-01f, 1.15295663e-01f, 1.13228679e-01f, -6.58086464e-02f, 1.96227301e-02f,
  -4.66415808e-02f, 4.29983288e-02f, 3.57202552e-02f, -4.10587937e-02f, 4.75754738e-02f, -1.51715428e-01f, -1.48037389e-01f, -4.41364273e-02f, -6.50615096e-02f, -1.58118270e-02f,
  4.87840213e-02f, -1.36836752e-01f, -6.57796189e-02f, -1.87492892e-02f, -1.42334744e-01f, -3.06979623e-02f, -7.64539838e-02f, 2.26835124e-02f, -1.60664201e-01f, -6.50224090e-02f,
  4.08860147e-02f, -6.00585267e-02f, 9.89682786e-03f, -5.75822070e-02f, -6.18001334e-02f, -8.53958800e-02f, -2.64664236e-02f, 9.09018517e-02f, 7.62921646e-02f, -2.04498209e-02f,
  7.99100995e-02f, -1.37272840e-02f, 2.85061542e-02f, 1.20348353e-02f, -9.81802419e-02f, 9.42781344e-02f, 1.16590522e-01f, -2.17343103e-02f, -8.12297687e-02f, -3.84680741e-02f,
  -5.60954958e-02f, -5.42589352e-02f, -9.48680118e-02f, 3.71508785e-02f, -2.11168118e-02f, 6.53982460e-02f, 1.48264831e-02f, 3.69649753e-02f, -1.14290804e-01f, -7.74464384e-02f,
  5.59196100e-02f, -1.05378278e-01f, 6.72705397e-02f, 6.59390688e-02f, 4.91973832e-02f, 3.90108265e-02f, 5.57433404e-02f, -3.05569207e-04f, 6.00799099e-02f, 1.05939217e-01f,
  4.22178581e-02f, 2.88561527e-02f, -1.04283206e-02f, -9.84705463e-02f, 4.96503711e-02f, -1.24264993e-01f, -6.11677244e-02f, 4.47237976e-02f, 1.63010154e-02f, -2.40017157e-02f,
  3.03227734e-02f, -7.69003406e-02f, -5.72341867e-03f, 3.14848870e-02f, -7.04878792e-02f, 2.87933871e-02f, 1.81796160e-02f, -7.78186182e-03f, -1.66428275e-02f, -3.58934477e-02f,
  7.55617488e-03f, -1.34856235e-02f, 3.46178524e-02f, 3.81167717e-02f, 5.93048520e-03f, 3.21535836e-03f, 1.20893657e-01f, -4.44266871e-02f, -2.56554186e-02f, 2.24817861e-02f,
  -2.38093305e-02f, 5.09104766e-02f, 2.13796549e-04f, -8.32279921e-02f, -1.27980113e-01f, 1.23068616e-01f, 2.15698835e-02f, -2.88120024e-02f, -1.15553178e-01f, -4.34785336e-02f,
  -2.59254873e-01f, 5.61220311e-02f, -1.82059363e-01f, -2.57149905e-01f, 1.24934942e-01f, 7.73098171e-02f, -1.91480312e-02f, 1.23957902e-01f, -1.11509517e-01f, 2.01425239e-01f,
  1.64186597e-01f, -9.26430449e-02f, 2.43202541e-02f, -1.38847470e-01f, -3.44714016e-01f, -1.26472324e-01f, -1.15448669e-01f, -1.71404585e-01f, -1.30929649e-01f, -1.01421751e-01f,
  -1.98775232e-01f, 1.11937169e-02f, -2.36793682e-01f, 1.27340436e-01f, 4.77991626e-03f, 5.86379208e-02f, 1.64726824e-01f, 1.33425131e-01f, 1.00491874e-01f, 1.19433962e-02f,
  -3.30007784e-02f, 1.00931965e-01f, -2.77721137e-02f, -8.37867856e-02f, 3.39537524e-02f, 4.72492836e-02f, 6.89532084e-04f, -7.09296437e-03f, -4.72567603e-02f, -3.75527292e-02f,
  6.34189835e-03f, -3.38572226e-02f, -8.23467672e-02f, 1.81295667e-02f, -4.73992387e-03f, 2.06859969e-02f, -7.13625476e-02f, -1.25997648e-01f, -1.27833271e-02f, -1.03891984e-01f,
  -9.44324955e-02f, 3.19509171e-02f, -9.70999971e-02f, -1.24388054e-01f, -1.35345012e-01f, -2.03722678e-02f, 1.73828397e-02f, 1.49117768e-01f, -7.75613114e-02f, -1.65844895e-02f,
  -8.47376417e-03f, 8.41707885e-02f, -4.37326394e-02f, 3.58749484e-03f, 5.83901331e-02f, 3.94259840e-02f, 1.88614707e-02f, 1.10791452e-01f, -1.64616480e-02f, 2.74612196e-03f,
  3.91894951e-03f, -6.35685399e-02f, -2.07019411e-03f, -2.80637797e-02f, 5.17454892e-02f, -1.79880150e-02f, -8.23946893e-02f, 4.28825319e-02f, -6.66097924e-02f, -1.08613698e-02f,
  4.97667752e-02f, -3.27310748e-02f, -5.36429975e-03f, 4.62783091e-02f, 8.23502466e-02f, -5.83934644e-03f, -8.90658572e-02f, -7.65369460e-02f, -1.33649558e-02f, 6.37055263e-02f,
  8.50902200e-02f, 9.67697874e-02f, -1.74115207e-02f, -5.55279898e-03f, -5.17146057e-03f, 1.07677937e-01f, -6.40185550e-02f, 3.11434665e-03f, -5.04602725e-03f, 3.37046869e-02f,
  2.75351033e-02f, -2.40787566e-02f, 8.24882984e-02f, 2.90479586e-02f, -9.03981365e-03f, -4.34221402e-02f, 2.61375830e-02f, 2.08105240e-03f, -6.17400818e-02f, 8.78040958e-03f,
  -9.23077762e-03f, 1.06374539e-01f, -5.27623817e-02f, 3.66628133e-02f, -6.52769431e-02f, 2.86068837e-03f, 4.01878953e-02f, 2.58783083e-02f, -5.27067110e-02f, -2.81519052e-02f,
  -8.47570673e-02f, -2.03055188e-01f, -1.03803128e-01f, 1.93051666e-01f, 2.88901720e-02f, -7.76502192e-02f, -2.24302962e-01f, 9.36851650e-02f, -7.56607205e-02f, -1.01172156e-03f,
  6.37390316e-02f, -1.40023068e-01f, -1.82735965e-01f, 2.49268830e-01f, 1.81971699e-01f, -8.81937891e-02f, 1.81033716e-01f, 6.00816198e-02f, -9.54176951e-03f, -4.22401652e-02f,
  8.68391022e-02f, 2.20375702e-01f, 6.66113570e-02f, 1.81725144e-01f, 1.72387138e-02f, 9.36019700e-03f, 1.30466864e-01f, -1.76794723e-01f, 3.01847994e-01f, 1.10158280e-01f,
  8.34486447e-03f, -3.40390801e-02f, -4.62669693e-02f, -1.14612728e-02f, -5.51543050e-02f, 8.26631561e-02f, -3.31307948e-02f, 6.42648786e-02f, 1.10447891e-01f, -1.04140557e-01f,
  -1.09964132e-01f, 1.53278768e-01f, 2.42782235e-02f, -5.58783226e-02f, -8.39507729e-02f, -5.11903279e-02f, 7.61755481e-02f, 1.29297972e-02f, 7.42103681e-02f, -9.69829857e-02f,
  -7.87008405e-02f, 1.80852674e-02f, 2.19235141e-02f, 3.59751619e-02f, 2.90490706e-02f, -2.36645378e-02f, -4.06511128e-02f, -1.67636633e-01f, 9.96844620e-02f, -1.32814929e-01f,
  -2.07756702e-02f, -2.56163199e-02f, -8.47026631e-02f, 6.41516969e-02f, -6.59650266e-02f, 6.63585216e-02f, 1.11239314e-01f, 5.34636900e-02f, -8.36828351e-02f, -8.58336315e-02f,
  7.71959051e-02f, 1.13018215e-01f, 1.53074916e-02f, 9.09424350e-02f, 1.66692622e-02f, 8.81292671e-03f, -6.46093860e-02f, 3.60496566e-02f, -5.92140369e-02f, 5.11374623e-02f,
  7.61630982e-02f, -3.26836556e-02f, -2.95287594e-02f, 4.20299433e-02f, 1.19136222e-01f, -7.61570930e-02f, 6.56284317e-02f, -1.59040838e-02f, -2.37956122e-02f, 9.10780579e-02f,
  9.65847075e-03f, -5.93847185e-02f, -5.19352853e-02f, 1.28995314e-01f, -2.75222585e-02f, 9.02276933e-02f, -2.55975057e-03f, 1.77712552e-02f, 9.53020006e-02f, 6.64549228e-03f,
  1.00865431e-01f, 9.32972063e-04f, 3.15055309e-04f, 4.27112961e-03f, 4.37377021e-02f, -5.57176359e-02f, -1.68919247e-02f, 5.58472611e-02f, 1.26734897e-01f, 1.28344446e-01f,
  2.99033746e-02f, -9.27072689e-02f, -5.29666804e-02f, -4.11844626e-03f, 8.26277211e-02f, -5.53736314e-02f, 1.73806492e-02f, -1.43199237e-02f, 8.54768455e-02f, 9.24785733e-02f,
  -4.96844620e-01f, 1.77871391e-01f, 2.33220622e-01f, -2.85368294e-01f, 5.00245132e-02f, 1.62444413e-01f, -1.52749851e-01f, 1.35629132e-01f, -1.81271553e-01f, -5.95573373e-02f,
  -1.15482405e-01f, -9.47895423e-02f, 1.22211188e-01f, -1.98428109e-01f, -4.24056463e-02f, -1.77456841e-01f, -1.18491329e-01f, -1.62581459e-01f, 8.77664685e-02f, 5.14142588e-02f,
  -7.55882189e-02f, -1.15316100e-01f, 2.42253486e-02f, 1.91618577e-01f, -1.83411464e-02f, 2.90663280e-02f, -4.93799374e-02f, 1.50115952e-01f, -4.78390306e-02f, -3.29398252e-02f,
  -4.25174721e-02f, -8.62995088e-02f, -1.89318489e-02f, 6.45343587e-02f, -8.29070900e-03f, 1.03725381e-01f, -3.49634029e-02f, -9.58646759e-02f, -4.60708805e-04f, 7.41917118e-02f,
  -6.21509813e-02f, 4.23642471e-02f, -1.63059365e-02f, -2.02106033e-02f, 7.20228925e-02f, 1.68327138e-01f, 8.85231644e-02f, 5.55812530e-02f, -8.04206505e-02f, 1.08844094e-01f,
  4.95455153e-02f, 7.19787702e-02f, 9.32241008e-02f, 5.06207533e-02f, 6.57306239e-02f, 7.62003809e-02f, -7.87688717e-02f, 5.94077930e-02f, 2.25790832e-02f, -1.86770465e-02f,
  7.40310028e-02f, -6.57121558e-03f, 2.98902597e-02f, 8.25683922e-02f, -1.19469184e-02f, 7.44235516e-02f, 1.72214638e-02f, -5.57331219e-02f, -6.11492991e-02f, -2.08260603e-02f,
  -1.10502735e-01f, -3.05957608e-02f, 5.59370629e-02f, 7.99039826e-02f, 2.69881450e-03f, -1.76980179e-02f, -1.74109846e-01f, -1.38070583e-02f, -1.53192654e-01f, -5.17485626e-02f,
  -7.32599385e-03f, -5.66359870e-02f, -8.09141025e-02f, 4.46162652e-03f, -7.22154835e-03f, -4.98490855e-02f, 8.05446953e-02f, -2.97868886e-04f, 2.44504847e-02f, -1.00895576e-01f,
  -5.82389124e-02f, -1.15490668e-01f, -1.17032148e-01f, -2.22195685e-03f, -8.35957006e-02f, 1.54104009e-01f, 6.22784123e-02f, -8.50975327e-03f, 3.30804735e-02f, -5.38903400e-02f,
  2.30091438e-02f, -5.21566123e-02f, -8.59478489e-03f, -4.40281294e-02f, -7.22398004e-03f, -5.07187992e-02f, -1.08516309e-02f, -9.91822779e-02f, -1.75604492e-01f, -3.15438285e-02f,
  -2.75652502e-02f, -3.32390592e-02f, -7.32048675e-02f, 4.33724970e-02f, 4.21842225e-02f, 2.14776713e-02f, -1.40069686e-02f, 5.41371927e-02f, 1.62124559e-02f, 2.99813133e-02f,
  1.40865192e-01f, 2.09470436e-01f, 1.18930705e-01f, 2.32234061e-01f, 7.86079988e-02f, 1.19513921e-01f, 2.64089435e-01f, 1.16916507e-01f, 3.90597165e-01f, 8.08111578e-02f,
  -1.74140304e-01f, 5.49222790e-02f, -1.24769114e-01f, -3.98829840e-02f, -1.56238779e-01f, 3.94389369e-02f, 2.69064456e-01f, 1.52505144e-01f, 1.78105220e-01f, 1.80428557e-03f,
  2.85545271e-02f, -1.79150715e-01f, -2.16583207e-01f, -2.27048010e-01f, -4.96332012e-02f, 1.81363914e-02f, -2.92931736e-01f, -8.81249458e-02f, -9.80462879e-02f, -1.87856741e-02f,
  7.31088668e-02f, 4.12435941e-02f, -8.92869532e-02f, 1.68342367e-02f, 2.85351630e-02f, -3.62876356e-02f, -5.65507682e-03f, -1.02820478e-01f, 9.12714228e-02f, 6.13225028e-02f,
  8.58720839e-02f, 5.27428538e-02f, 1.16363607e-01f, -2.76421960e-02f, 2.40232330e-03f, -5.23884483e-02f, 3.54210511e-02f, 3.69621292e-02f, -5.55679351e-02f, 2.41301917e-02f,
  -8.33033919e-02f, 4.62597646e-02f, 7.79293105e-02f, 1.00890629e-01f, 8.35589170e-02f, 4.63313274e-02f, 7.53187388e-02f, -2.67589353e-02f, -2.53443569e-02f, 4.71161976e-02f,
  -4.92931297e-03f, 7.81077221e-02f, -3.95056210e-04f, -9.84662175e-02f, -4.07364555e-02f, -8.14958066e-02f, -4.75838669e-02f, 5.37258498e-02f, 6.01103269e-02f, -1.50296884e-02f,
  5.59883416e-02f, 4.00080234e-02f, 1.45530161e-02f, 4.04602364e-02f, 6.20614998e-02f, -1.29816625e-02f, -1.58006363e-02f, 1.31682411e-01f, 8.16614777e-02f, -5.06175729e-03f,
  -3.38830650e-02f, -7.10171685e-02f, -9.60908979e-02f, -1.41235953e-02f, -1.01092625e-02f, 7.58110955e-02f, -3.32175009e-02f, 2.88443360e-02f, -7.10687190e-02f, 3.57243456e-02f,
  5.20737283e-02f, 1.14881083e-01f, -2.25677211e-02f, 4.13820073e-02f, 6.56667650e-02f, -9.19904932e-02f, 2.68324427e-02f, 9.27428678e-02f, -1.27754605e-03f, 1.29661649e-01f,
  7.92960525e-02f, 7.82302618e-02f, 1.03073185e-02f, 2.94343289e-02f, -1.47532718e-02f, -1.22877419e-01f, -5.46370186e-02f, 3.07928473e-02f, 3.20283696e-02f, -4.56878766e-02f,
  -1.71427488e-01f, 5.72025403e-02f, 9.01812594e-03f, -1.41671654e-02f, 1.32590249e-01f, -7.82361999e-02f, -1.19003236e-01f, -7.99007807e-03f, -6.21777065e-02f, 1.03684980e-02f,
  2.23997176e-01f, -9.79595333e-02f, 6.39255419e-02f, -2.60143876e-01f, -1.20836280e-01f, 2.55621046e-01f, 1.97990775e-01f, -7.25078136e-02f, -1.70126259e-01f, 4.25215364e-02f,
  -7.45128561e-03f, 2.91197952e-02f, 2.60613114e-01f, -4.94374633e-02f, 2.46522158e-01f, 1.58715993e-01f, 3.49762812e-02f, 2.30770484e-02f, -2.31481846e-02f, 8.52875188e-02f,
  -3.98307964e-02f, 4.63878885e-02f, 9.85329002e-02f, -4.08648290e-02f, 1.95690002e-02f, -1.42210245e-01f, -6.28653467e-02f, 1.01075031e-01f, -1.46722287e-01f, -6.76587671e-02f,
  -3.34513071e-03f, -7.35761151e-02f, 1.87100153e-02f, -4.49857600e-02f, 4.55722846e-02f, 9.20406058e-02f, 5.34018092e-02f, 8.86031315e-02f, 9.71728284e-03f, -1.05182357e-01f,
  9.16999951e-03f, 6.87109753e-02f, -1.61142007e-01f, -9.30712223e-02f, 7.32771382e-02f, -4.28768992e-02f, -4.85717766e-02f, -7.51421750e-02f, -2.40184925e-02f, 4.80917208e-02f,
  -3.15901190e-02f, -1.65975224e-02f, -1.50768563e-01f, -1.68314308e-01f, -1.69411793e-01f, -1.19814143e-01f, 6.01684749e-02f, 5.29591851e-02f, 4.37388644e-02f, -4.26154360e-02f,
  -3.68699916e-02f, 1.08027466e-01f, -2.34605968e-02f, -2.99960002e-02f, 1.00427046e-02f, -6.18427806e-02f, 4.48676124e-02f, 5.40231578e-02f, 1.01979496e-02f, -5.31241484e-03f,
  -6.74713030e-02f, 5.18110283e-02f, 1.13756038e-01f, -7.31249750e-02f, 3.83904502e-02f, 3.31373625e-02f, 7.62534365e-02f, 5.94586879e-02f, -1.81392282e-02f, 5.61000928e-02f,
  -1.40943974e-02f, -3.22111063e-02f, -5.80432825e-02f, -8.75427052e-02f, 1.05308168e-01f, 3.14690620e-02f, -1.09568834e-01f, 3.81005183e-02f, -1.40308728e-02f, 1.67655230e-01f,
  5.72013333e-02f, -4.10769284e-02f, 3.36174071e-02f, -1.69998743e-02f, 8.00966397e-02f, 3.10345329e-02f, -1.92449670e-02f, 1.57847516e-02f, 6.83016255e-02f, 6.26670793e-02f,
  2.51606964e-02f, -6.79586455e-03f, 1.86467990e-02f, -1.01564275e-02f, -9.28495750e-02f, 5.90135306e-02f, 2.60834433e-02f, 9.90489218e-03f, -1.26686200e-01f, -5.42203430e-03f,
  -1.05030090e-01f, 1.17276862e-01f, 3.75584960e-02f, -7.67717734e-02f, -2.49879882e-01f, -6.95012063e-02f, -1.31868217e-02f, -2.01122873e-02f, -3.57096121e-02f, -3.51298638e-02f,
  -1.14700243e-01f, 1.49066344e-01f, -4.01677378e-02f, -2.74812251e-01f, 1.47331551e-01f, -1.51392117e-01f, -2.58530408e-01f, -4.17300826e-03f, -1.39377102e-01f, -2.02222079e-01f,
  -2.62668878e-01f, 3.62816988e-03f, 1.07818797e-01f, -3.76114547e-02f, 1.58218250e-01f, 1.75179586e-01f, -1.24918394e-01f, -1.06716618e-01f, 9.21321437e-02f, -1.15721405e-01f,
  -1.90374088e-02f, -1.21267334e-01f, 4.12426777e-02f, 1.16987221e-01f, -2.26650432e-01f, -9.20277685e-02f, -2.03398317e-02f, 6.99019730e-02f, -1.41197979e-01f, -5.08766659e-02f,
  8.53565335e-03f, -2.22668037e-01f, -4.27843295e-02f, -1.21090129e-01f, -1.56564772e-01f, -1.86779261e-01f, -6.06427751e-02f, 1.23382667e-02f, -2.28158943e-03f, 2.89116018e-02f,
  -2.62174173e-03f, 2.01085629e-03f, -1.11065291e-01f, -2.54268721e-02f, 9.96062681e-02f, 1.31664034e-02f, 1.32154912e-01f, 5.56758745e-03f, 8.25038254e-02f, -1.17716994e-02f,
  1.12076756e-02f, 7.17517221e-03f, -5.88707812e-02f, 1.26587838e-01f, -4.21306975e-02f, -1.15526333e-01f, 1.86322890e-02f, 6.93887323e-02f, -5.99487722e-02f, -2.43249517e-02f,
  5.20097241e-02f, 9.43959951e-02f, 4.74567935e-02f, 2.09481716e-02f, -1.81667216e-03f, 1.49042206e-02f, -4.25338782e-02f, 5.84665462e-02f, -6.59733266e-02f, 9.72973183e-02f,
  -9.21940207e-02f, -2.08602138e-02f, 1.49035938e-02f, -6.31626546e-02f, -7.37966178e-03f, -1.50293201e-01f, 6.20050095e-02f, 6.29080553e-03f, 4.69390415e-02f, 2.83507276e-02f,
  -1.57532379e-01f, -4.62268926e-02f, -4.09898460e-02f, -8.63664448e-02f, 2.27224622e-02f, 7.96920061e-03f, 3.10390238e-02f, -3.77797242e-03f, 1.83908064e-02f, 1.58037096e-02f,
  -7.60297179e-02f, -2.68748999e-01f, -1.25504825e-02f, -9.19790491e-02f, -4.31054272e-02f, 6.36223517e-03f, 1.40950307e-02f, 2.30641924e-02f, -8.83456599e-03f, -4.85261809e-03f,
  -1.42872646e-01f, 1.56990029e-02f, 1.93193299e-03f, -6.23081811e-02f, 6.79268613e-02f, -8.21040943e-02f, 7.05682207e-03f, 7.48058083e-03f, 8.24159756e-03f, -1.11516658e-02f,
  3.25384475e-02f, 3.79955247e-02f, -7.17064887e-02f, -6.74518049e-02f, 6.87469766e-02f, -1.20093547e-01f, 3.73966098e-02f, 1.47280004e-02f, 5.08687198e-02f, -9.38739069e-03f,
  2.90398654e-02f, -1.64806828e-01f, 8.48225728e-02f, -1.43819779e-01f, 2.83130929e-02f, -4.66068164e-02f, -5.42945694e-03f, -1.68036178e-01f, -1.97756872e-01f, -2.59917736e-01f,
  -5.02980873e-02f, 1.46533102e-01f, 1.83446482e-01f, -1.78205937e-01f, 4.16356951e-01f, 7.52807781e-02f, -1.80669397e-01f, -5.40918335e-02f, -8.98813382e-02f, -2.05060840e-01f,
  -5.80438636e-02f, -2.72569478e-01f, 1.28945500e-01f, -2.33565420e-01f, -2.09736615e-01f, -1.76559120e-01f, 6.45968542e-02f, 9.26267803e-02f, -1.35097444e-01f, 1.57661349e-01f,
  -8.24089348e-02f, 2.39442978e-02f, -1.02888085e-02f, 1.07875429e-02f, -2.31871139e-02f, 4.43018187e-04f, 3.18198577e-02f, 9.05711055e-02f, 8.93145241e-03f, 9.24194381e-02f,
  5.32396324e-02f, 5.53978048e-02f, -8.39348957e-02f, -2.08458351e-03f, -8.42193365e-02f, -1.31403804e-01f, -8.66727531e-03f, 3.81164178e-02f, -6.61000609e-03f, 1.02197282e-01f,
  3.54491100e-02f, 2.98752338e-02f, -6.78620711e-02f, 1.34642851e-02f, -2.76810979e-03f, -6.45318553e-02f, -6.95534237e-03f, 1.42880887e-01f, -5.06153740e-02f, -5.55068515e-02f,
  -7.37837255e-02f, 1.89608429e-02f, -2.75553912e-02f, -2.92334277e-02f, -3.23385037e-02f, -1.00937694e-01f, -5.34694903e-02f, 5.77910990e-03f, -2.89749261e-02f, -9.45704728e-02f,
  -4.46469858e-02f, -1.11627907e-01f, -4.76165004e-02f, -3.93509418e-02f, -1.29699595e-02f, 9.81381610e-02f, 6.72939122e-02f, -4.34667207e-02f, -3.78726907e-02f, -1.87245607e-02f,
  4.51689325e-02f, 4.84411269e-02f, -2.76982430e-02f, -4.38727811e-03f, 3.90693545e-03f, 4.25050408e-02f, 2.62327921e-02f, 1.16719250e-02f, 4.65695411e-02f, 6.58957660e-02f,
  3.58567722e-02f, -8.30179080e-02f, -2.39913985e-02f, -5.18586338e-02f, 6.94899559e-02f, -5.14116473e-02f, -8.16116408e-02f, -1.36986822e-01f, 1.97148677e-02f, -2.31763497e-02f,
  2.20023785e-02f, 3.95265035e-02f, 2.55041122e-02f, -1.60026411e-03f, -4.12079170e-02f, -5.22480160e-02f, -4.78379242e-02f, 3.69070247e-02f, -1.27151730e-02f, -2.68048942e-02f,
  6.04759902e-04f, -3.23452055e-02f, 7.05694929e-02f, 8.43383092e-03f, -1.10817224e-01f, -2.63185985e-02f, -8.37555714e-03f, -6.00429662e-02f, 1.11122571e-01f, -5.67011535e-03f,
  2.59847552e-01f, -2.50238746e-01f, 2.68751998e-02f, 1.79168031e-01f, 1.48463607e-01f, -3.30767632e-02f, 1.32166088e-01f, -4.34146412e-02f, -4.72869985e-02f, -2.34214753e-01f,
  -2.13791579e-02f, -1.23612925e-01f, -1.07491575e-01f, -1.37481853e-01f, -6.71784282e-02f, -1.75483659e-01f, -7.44160218e-03f, 4.83900905e-02f, -4.50857617e-02f, 1.37674510e-01f,
  2.04717010e-01f, -8.67808685e-02f, -3.76502573e-02f, -5.01174703e-02f, 9.53979492e-02f, 2.31299803e-01f, 7.40072131e-02f, 5.37701510e-02f, -3.65659185e-02f, -6.35499284e-02f,
  -6.63659275e-02f, -2.55091190e-02f, -8.43893215e-02f, -1.04604833e-01f, 3.16693373e-02f, 4.52790856e-02f, -4.51112073e-03f, 9.61733144e-03f, 3.11939716e-02f, 1.77043285e-02f,
  4.09794562e-02f, -8.12097117e-02f, -1.27898529e-01f, -2.14940440e-02f, 3.45824175e-02f, -5.40761873e-02f, -1.28252534e-02f, -2.68245041e-02f, -8.98917094e-02f, 1.41526172e-02f,
  1.22295439e-01f, 1.01401486e-01f, 1.27083793e-01f, 8.14882144e-02f, 8.13858435e-02f, -2.50975620e-02f, -3.02342908e-03f, 1.43509820e-01f, -2.61811335e-02f, 3.32612731e-02f,
  -6.11853320e-04f, -5.29643223e-02f, 3.74053717e-02f, -2.02625208e-02f, 3.26691493e-02f, -2.84323487e-02f, -1.30204022e-01f, -8.86141285e-02f, -1.74917672e-02f, -2.65792590e-02f,
  3.57844047e-02f, 2.89158225e-02f, -7.74401873e-02f, -6.62333071e-02f, 4.10243087e-02f, -1.97876971e-02f, 4.80367690e-02f, -2.73984447e-02f, 1.09422036e-01f, -6.59157475e-03f,
  -1.44253612e-01f, -5.32794232e-03f, -3.21099199e-02f, -2.08176374e-02f, -4.89479080e-02f, 6.64798096e-02f, -4.47362326e-02f, -4.17346172e-02f, 9.77366939e-02f, -5.66952005e-02f,
  2.06284430e-02f, -1.40638337e-01f, 4.05017752e-03f, 9.77747515e-03f, -5.60418777e-02f, 2.53977515e-02f, -1.07326701e-01f, -7.91150481e-02f, 3.19884308e-02f, -1.99025664e-02f,
  1.26046002e-01f, -4.55040522e-02f, -6.50182143e-02f, -2.23816037e-02f, -6.03034459e-02f, -5.98996542e-02f, -4.66621928e-02f, 5.87667301e-02f, -1.01871662e-01f, 9.25064310e-02f,
  1.53445259e-01f, 8.08863640e-02f, -2.05828194e-02f, 9.35401320e-02f, -2.60966681e-02f, 2.97528151e-02f, -3.33008766e-02f, 1.18781358e-01f, -3.49725895e-02f, 7.80504197e-02f,
  2.65970826e-01f, -3.34185451e-01f, -1.22779950e-01f, 1.46627650e-01f, 2.15283990e-01f, 4.63994630e-02f, 9.86905172e-02f, -2.83279363e-02f, -9.31099504e-02f, -2.71696061e-01f,
  -3.07790842e-02f, -1.38761669e-01f, -3.13473254e-01f, 1.32817522e-01f, 3.18351895e-01f, -2.40640134e-01f, 1.50262117e-01f, -2.02852897e-02f, -1.12766080e-01f, -1.65288225e-01f,
  6.29003420e-02f, 1.91325739e-01f, -5.93096502e-02f, 7.23680407e-02f, 9.80279446e-02f, -9.44295377e-02f, -3.45048197e-02f, -1.12349816e-01f, 1.37311220e-01f, 1.43576026e-01f,
  -2.90810876e-03f, -5.39638065e-02f, 8.15459266e-02f, -1.61363669e-02f, -1.55276945e-02f, -3.21215205e-02f, 1.02863582e-02f, 7.37604871e-02f, 4.15606126e-02f, -1.05148979e-01f,
  -7.56894350e-02f, 6.99140951e-02f, -3.70439477e-02f, 2.13015750e-02f, 1.45581916e-01f, 2.35700537e-03f, 1.79123431e-02f, -4.53688204e-02f, -7.63500780e-02f, -1.11812122e-01f,
  -2.82758605e-02f, 2.24304311e-02f, 5.31324670e-02f, 7.82259479e-02f, 3.91379707e-02f, -9.70769674e-03f, -1.60270065e-01f, -2.01722473e-01f, 7.52477720e-03f, -5.97125739e-02f,
  -5.41520081e-02f, -1.52606694e-02f, -4.76155505e-02f, 4.39927541e-02f, 3.03658582e-02f, 4.14990894e-02f, 3.85015160e-02f, -9.65190604e-02f, -9.89137664e-02f, 1.05096167e-02f,
  -4.17967178e-02f, -4.37952504e-02f, 1.76402349e-02f, 4.70332541e-02f, 4.07460928e-02f, 4.98671196e-02f, -4.43990901e-02f, -9.24741104e-03f, -1.13593534e-01f, -1.07168674e-01f,
  6.23877272e-02f, 3.02108172e-02f, -4.44525778e-02f, 5.60703613e-02f, 3.63919623e-02f, -4.03170064e-02f, 2.82264929e-02f, -8.83672759e-02f, -1.71362963e-02f, -3.56579348e-02f,
  -1.17498167e-01f, -3.26913774e-01f, -1.10344365e-01f, 4.43605930e-02f, -3.92397046e-02f, -1.06554581e-02f, -1.42029244e-02f, -1.36029469e-02f, -6.00100644e-02f, -2.27761567e-02f,
  -9.76401567e-02f, -3.36434878e-02f, -8.77626427e-03f, 2.23556738e-02f, 7.04227537e-02f, -5.15802167e-02f, -8.66646022e-02f, 1.57095434e-04f, 3.00381938e-03f, -1.07536875e-01f,
  -3.08542382e-02f, -1.52345464e-01f, -1.19203692e-02f, -6.82637319e-02f, 2.10876539e-02f, -2.25222129e-02f, -3.83496806e-02f, -2.76310854e-02f, -3.86456139e-02f, -4.82160551e-03f,
  3.21107417e-01f, -1.46286845e-01f, 5.70295006e-02f, 2.75459677e-01f, 1.59807518e-01f, -8.05045888e-02f, 1.64718449e-01f, 1.26094207e-01f, 4.12335366e-01f, -3.71008933e-01f,
  -5.63098788e-02f, -9.43118557e-02f, -2.33089626e-02f, -8.31112117e-02f, 7.49690011e-02f, 3.26606818e-02f, 4.16535549e-02f, -3.20779830e-02f, 2.25364745e-01f, 9.39316396e-03f,
  1.41551644e-01f, -1.35661617e-01f, -7.79245272e-02f, -2.68642843e-01f, -1.27236117e-02f, -1.80793568e-01f, -3.20536494e-01f, -6.18639775e-02f, -3.83800417e-01f, -1.54917762e-01f,
  7.65285641e-02f, -1.78357761e-03f, -6.52092770e-02f, 2.24850494e-02f, -1.06161386e-02f, 1.46716051e-02f, -1.59148332e-02f, -1.57337159e-01f, 4.42714803e-02f, -8.05445910e-02f,
  2.54790094e-02f, -1.32511286e-02f, -6.58196881e-02f, -3.32533196e-02f, 1.84323132e-01f, 7.71356300e-02f, 1.68326497e-01f, 1.38156980e-01f, -1.11353518e-02f, 1.74958687e-02f,
  2.67809369e-02f, 3.61072309e-02f, 8.10589492e-02f, -1.48474380e-01f, -5.12931868e-02f, 2.77053827e-04f, -1.35403186e-01f, -6.77537024e-02f, 7.09092468e-02f, 9.60426871e-03f,
  5.75231668e-03f, -6.95502525e-03f, 7.16555351e-03f, -7.48571754e-02f, 4.57023792e-02f, -3.05173788e-02f, 1.27860019e-02f, -3.06030661e-02f, 3.39654787e-03f, -4.43916544e-02f,
  1.76720219e-04f, 3.73422098e-03f, 1.36097133e-01f, 8.01018775e-02f, 1.88110285e-02f, 1.50315851e-01f, -4.13874350e-02f, -1.82911634e-01f, -7.48858899e-02f, 9.94754210e-02f,
  1.06007725e-01f, 1.21035799e-01f, -4.84045483e-02f, -6.95295185e-02f, -4.69323546e-02f, 2.52813734e-02f, 6.30217511e-03f, -5.83470836e-02f, 1.71513930e-01f, -8.49243551e-02f,
  7.49619631e-03f, -2.20720083e-01f, -1.26859412e-01f, -6.06635064e-02f, 2.08165515e-02f, -1.33564798e-02f, 5.22566549e-02f, -2.12448537e-02f, 2.02478766e-02f, 3.98539789e-02f,
  -9.45226923e-02f, -4.49855290e-02f, -4.08112332e-02f, 6.00616261e-02f, 1.50147036e-01f, 1.35122919e-02f, -3.43672372e-02f, -1.39953699e-02f, -3.10135391e-02f, 7.28445454e-03f,
  -3.87034863e-02f, -5.42237535e-02f, -6.53757453e-02f, 2.78904065e-02f, -5.40470891e-02f, -7.74068534e-02f, -2.87437532e-02f, -2.08106022e-02f, -1.01623721e-01f, 3.76285873e-02f,
  2.93343753e-01f, -6.59558997e-02f, -9.18421336e-03f, 4.82952520e-02f, 7.83766527e-03f, 1.75340042e-01f, 1.99028969e-01f, 2.64643840e-02f, 8.48118663e-02f, -8.00005347e-03f,
  1.25457764e-01f, 1.46767944e-01f, 1.55588984e-01f, 2.97928881e-02f, 1.12327382e-01f, 6.93854988e-02f, 1.16958164e-01f, 5.99642135e-02f, 1.15386480e-02f, 2.96966285e-01f,
  1.63521603e-01f, 3.15863192e-01f, -1.26506537e-01f, -1.02098562e-01f, 6.13305122e-02f, -1.36785075e-01f, -2.12779313e-01f, 3.03919148e-02f, -1.61213815e-01f, -2.83326749e-02f,
  5.70122562e-02f, -6.60864695e-04f, 3.58742401e-02f, 9.82903615e-02f, -6.29387498e-02f, -7.85126016e-02f, -6.77409992e-02f, 1.94538254e-02f, 7.13640405e-03f, 3.23508680e-02f,
  -2.34035891e-04f, -8.58684257e-02f, 4.78234962e-02f, 2.31546350e-02f, 1.59206446e-02f, 3.47593985e-02f, -9.32890270e-03f, -8.50281864e-02f, -5.85362911e-02f, 2.94615217e-02f,
  -4.72827479e-02f, -1.68161586e-01f, -5.34362113e-03f, -1.92639962e-01f, 3.02994624e-03f, -4.28450620e-03f, -1.73392016e-02f, -6.16658814e-02f, -9.63438377e-02f, 7.80853257e-02f,
  1.20373137e-01f, 5.36804721e-02f, 3.42796817e-02f, 3.94264422e-02f, -1.75835583e-02f, -6.00126348e-02f, -1.10077476e-02f, 1.96273699e-02f, 1.29391614e-03f, -1.96812656e-02f,
  -5.86061813e-02f, -9.16678179e-03f, 5.86213507e-02f, 1.49970055e-02f, 1.50957659e-01f, -1.23377086e-03f, -5.33318594e-02f, -1.52993411e-01f, 5.46771772e-02f, 2.08928459e-03f,
  -6.65905178e-02f, 8.60759243e-02f, 3.52996513e-02f, 1.32408785e-02f, 8.79818574e-02f, 4.23163548e-02f, -6.95324391e-02f, 2.57575996e-02f, -1.16229216e-02f, -1.73991099e-02f,
  9.64793339e-02f, 1.53337762e-01f, 8.05362836e-02f, 5.53707443e-02f, -1.97231472e-02f, 4.06811722e-02f, 1.00292578e-01f, 9.95931402e-02f, -1.21888658e-03f, 1.74002245e-01f,
  -4.35204804e-02f, -6.91013187e-02f, 4.88070212e-02f, -2.91608702e-02f, -2.17116848e-02f, -6.16809390e-02f, 7.02707767e-02f, -4.21235077e-02f, -7.17472360e-02f, 2.78770551e-02f,
  2.03727800e-02f, 2.77062356e-02f, 8.24433845e-03f, -2.76062768e-02f, -4.92783301e-02f, -1.46751245e-02f, 4.34037261e-02f, -1.96288154e-02f, -4.06146348e-02f, 1.02698006e-01f,
  4.01202738e-02f, -2.04039346e-02f, -1.45644277e-01f, -1.35884285e-01f, -5.16098887e-02f, -2.81075016e-02f, -1.20594665e-01f, -4.18512970e-02f, -2.10696533e-01f, 1.49312273e-01f,
  3.63913327e-02f, -1.02135420e-01f, 1.41285881e-02f, -2.05930606e-01f, -1.55936927e-01f, -6.29581884e-02f, -2.74583828e-02f, -8.26581120e-02f, 8.25755019e-03f, 1.55626372e-01f,
  6.31331950e-02f, -2.00702082e-02f, -6.46247864e-02f, 8.67758617e-02f, 7.52546266e-02f, 1.80113763e-02f, 1.35732204e-01f, 2.24532470e-01f, 2.68428270e-02f, -6.65759817e-02f,
  -8.04625526e-02f, 4.09316905e-02f, -3.14131714e-02f, -4.03169766e-02f, 3.68100293e-02f, 1.30647585e-01f, 1.06068417e-01f, -8.88384581e-02f, -4.41125333e-02f, -1.04319956e-02f,
  1.29934903e-02f, -3.95464413e-02f, -2.78567579e-02f, 5.61156422e-02f, 5.03434241e-02f, 7.51368776e-02f, -4.70187962e-02f, -2.18513738e-02f, -1.65995732e-01f, -2.87719015e-02f,
  -8.66589509e-03f, -8.44291523e-02f, 8.28874409e-02f, -1.19835913e-01f, -4.94759344e-02f, -1.80074770e-03f, 1.59242302e-02f, 2.79190242e-02f, -8.76403973e-03f, 5.81764989e-03f,
  1.38131663e-01f, 1.04627863e-01f, -3.41594853e-02f, -3.35112251e-02f, -1.91262569e-02f, -5.56201600e-02f, -4.40248549e-02f, -5.28361537e-02f, -4.02892986e-03f, -1.92243569e-02f,
  -2.24428792e-02f, -2.19478048e-02f, 9.00456607e-02f, 5.87732531e-03f, 8.61764401e-02f, 5.30860797e-02f, 6.57711178e-02f, -8.37287772e-03f, 5.10052070e-02f, -2.19583046e-02f,
  -1.18611120e-02f, -4.36020643e-02f, -2.56247353e-02f, 7.17717484e-02f, -5.01958430e-02f, -5.38837500e-02f, -4.64367196e-02f, 1.53122479e-02f, -7.64085650e-02f, 1.04013309e-01f,
  1.01499446e-02f, 2.13500306e-01f, -6.00141063e-02f, -9.39408764e-02f, 4.83200476e-02f, 1.11050270e-01f, 5.40039465e-02f, -1.08351551e-01f, -1.25159072e-02f, -3.92636769e-02f,
  6.36162013e-02f, 2.29783431e-02f, 8.24916512e-02f, -9.63025886e-05f, -7.25607201e-02f, -4.13017049e-02f, 6.53925687e-02f, -6.05143001e-03f, 2.42064930e-02f, -7.85700977e-03f,
  -6.47779228e-03f, 4.91364338e-02f, -4.19328064e-02f, -2.08168663e-03f, -5.02970107e-02f, 1.03140742e-01f, 8.01958889e-02f, 3.08132879e-02f, -1.17148284e-03f, -7.94624984e-02f,
  1.75170377e-01f, 2.97032416e-01f, 1.83544457e-01f, 1.70748159e-01f, -1.07881494e-01f, -3.86531591e-01f, -1.84716269e-01f, -4.69910018e-02f, 8.19642842e-02f, -2.40177307e-02f,
  -8.24954361e-02f, 3.21942866e-01f, -1.16419628e-01f, 4.52873781e-02f, -2.18849540e-01f, -2.40358517e-01f, -7.69747347e-02f, 5.78814819e-02f, -7.15041533e-02f, 1.11929253e-01f,
  -1.15777709e-01f, -1.68422952e-01f, 1.01579696e-01f, -1.74482223e-02f, 1.07519679e-01f, 1.76751032e-01f, 1.25479372e-02f, -3.23648416e-02f, 9.16442648e-02f, -7.53004998e-02f,
  -1.04273945e-01f, 1.29374862e-01f, 3.36295180e-02f, -7.39044473e-02f, 1.77673937e-03f, 5.25076427e-02f, -7.24671036e-02f, -7.73079135e-03f, -9.99839511e-03f, 9.22956690e-02f,
  -7.31490031e-02f, -6.39151260e-02f, 6.82154000e-02f, 3.32932211e-02f, -2.15454050e-03f, 3.86209711e-02f, 5.73976748e-02f, 1.92918815e-02f, 6.62896708e-02f, -9.33543444e-02f,
  1.59362510e-01f, 7.59794265e-02f, -2.08718516e-02f, 5.50825112e-02f, 8.42831954e-02f, 7.38571808e-02f, -4.44237143e-02f, 7.93818086e-02f, 9.04139783e-03f, -2.17233435e-03f,
  -3.77161540e-02f, -1.07065596e-01f, -5.58937006e-02f, 7.59219080e-02f, 8.66679400e-02f, -4.07797247e-02f, 6.58965409e-02f, 6.31114095e-03f, 4.17231135e-02f, -1.04706123e-01f,
  1.68335196e-02f, 3.37820649e-02f, -2.36900467e-02f, 5.50638624e-02f, 5.52018993e-02f, 4.39518541e-02f, 7.56340921e-02f, 2.41603907e-02f, 1.16004245e-02f, 3.26997191e-02f,
  -2.99062990e-02f, -4.83248420e-02f, 8.76596570e-03f, -4.69048098e-02f, 9.19474214e-02f, 6.09840490e-02f, -4.50044908e-02f, 1.95449237e-02f, -1.54476389e-02f, -1.07624559e-02f,
  -7.26377890e-02f, -6.83730887e-03f, -3.84431295e-02f, -3.48273367e-02f, -1.70835510e-01f, -3.54134738e-02f, 1.18193300e-02f, -1.30871497e-02f, -2.35137250e-02f, 4.36310237e-03f,
  -1.13393836e-01f, -1.18810892e-01f, -3.67473252e-02f, -4.26679961e-02f, 1.31207304e-02f, -1.83575763e-03f, -4.74719964e-02f, 6.53727204e-02f, 5.20867519e-02f, -5.84878847e-02f,
  6.90060332e-02f, -1.51144698e-01f, -1.19619012e-01f, 1.11742141e-02f, -1.12954780e-01f, 1.07550360e-02f, 9.69475508e-02f, 8.00522864e-02f, -2.02005357e-02f, -9.47661251e-02f,
  2.41523143e-03f, -2.30106115e-01f, -2.12418333e-01f, -1.80347398e-01f, 8.15195292e-02f, -7.63284564e-02f, -2.81749517e-01f, -1.21319657e-02f, -1.18781865e-01f, -2.28120834e-02f,
  -1.35523528e-01f, -1.27424151e-01f, -2.47343585e-01f, -1.59151092e-01f, -1.97304592e-01f, -2.94802368e-01f, -1.48397898e-02f, -5.49146906e-02f, -9.64786932e-02f, -1.24108024e-01f,
  5.99888153e-03f, 5.14714196e-02f, -6.44157827e-02f, 2.38406003e-01f, -1.01302760e-02f, 1.92975700e-01f, 3.11808556e-01f, 2.51655970e-02f, 1.82116479e-01f, 6.82451278e-02f,
  -4.15985771e-02f, -1.56184644e-01f, -1.09987952e-01f, 5.53387292e-02f, 5.63024059e-02f, 1.23644494e-01f, 7.63324201e-02f, 5.02552204e-02f, 1.12029137e-02f, -1.00503698e-01f,
  -2.06003059e-03f, 7.02060759e-02f, 2.76202708e-03f, 3.37912166e-03f, 2.02877410e-02f, -3.53882089e-02f, -1.88596081e-02f, -3.47323939e-02f, -5.14367148e-02f, -1.37851223e-01f,
  -1.01045258e-01f, 8.08850750e-02f, -8.99181589e-02f, 1.06573693e-01f, 2.08576210e-03f, -5.18451631e-02f, -2.15753615e-02f, 4.29231711e-02f, 4.42348644e-02f, -9.92557034e-03f,
  6.24136887e-02f, -7.68976239e-03f, -3.00967577e-03f, -5.60616553e-02f, -8.18577111e-02f, 1.13170911e-02f, -7.39142746e-02f, -1.67869180e-02f, -5.92611805e-02f, -3.56221758e-02f,
  5.17533459e-02f, -1.08826064e-01f, -6.84986189e-02f, 7.69573152e-02f, 6.48830533e-02f, 3.55945830e-03f, 3.21343467e-02f, 2.52158958e-02f, -1.50357904e-02f, -3.30451019e-02f,
  -2.71075666e-02f, 7.26602376e-02f, -4.69746627e-02f, 5.77478185e-02f, -3.36882472e-02f, -3.53920273e-02f, -2.08742693e-02f, -3.77283022e-02f, 7.65236169e-02f, 8.34767818e-02f,
  3.40410955e-02f, 9.20918956e-03f, -5.07873558e-02f, 6.13490902e-02f, -4.91684936e-02f, -1.39551729e-01f, -7.65715912e-02f, 3.72258574e-03f, 9.65794697e-02f, 1.12769622e-02f,
  1.05466656e-01f, 1.27801644e-02f, 1.98957279e-01f, -1.35674691e-02f, 6.28138855e-02f, -8.21687456e-04f, 8.96797981e-03f, -2.53575500e-02f, 1.31881595e-01f, 3.54087725e-02f,
  9.33242217e-02f, 5.69369346e-02f, -1.22294202e-02f, -7.19897598e-02f, 9.46161151e-02f, 4.02787104e-02f, 3.30092758e-02f, 2.45928336e-02f, 5.80304936e-02f, -9.21914205e-02f,
  -2.21444279e-01f, 2.18468845e-01f, -2.11004406e-01f, -4.37923409e-02f, -5.71652763e-02f, -1.93719223e-01f, -1.07021518e-02f, -3.37575488e-02f, 1.29574105e-01f, 2.22120389e-01f,
  -3.96593325e-02f, 2.85883043e-02f, 6.68530315e-02f, 3.54932696e-02f, -3.57223988e-01f, -6.06344864e-02f, -1.77651986e-01f, 1.63356643e-02f, -1.09108530e-01f, -8.84522572e-02f,
  -1.11449279e-01f, -5.20066619e-02f, -1.50675133e-01f, 7.89204761e-02f, -1.98714193e-02f, 3.01985946e-02f, -1.80976674e-01f, 3.35893519e-02f, -1.65151373e-01f, -3.76191810e-02f,
  -1.55842900e-01f, 1.07076742e-01f, 1.30350381e-01f, -6.82265759e-02f, -1.04138233e-01f, -5.27744787e-03f, -8.10282156e-02f, 5.83452918e-02f, 9.77379829e-03f, -8.60309508e-03f,
  -7.21002966e-02f, -5.36570745e-03f, 2.36012079e-02f, -3.14467810e-02f, 8.85964185e-02f, -5.37893102e-02f, -8.61927643e-02f, -4.28235419e-02f, 2.92885005e-02f, -8.20368528e-03f,
  -4.08050008e-02f, -9.65226069e-02f, -3.65370661e-02f, -6.78129345e-02f, -6.63497671e-02f, 3.63852875e-03f, -2.66786315e-03f, -6.37084916e-02f, -7.44247809e-02f, -1.54493293e-02f,
  1.56416833e-01f, -5.47889955e-02f, 9.47495922e-02f, -1.13944151e-02f, 2.36817915e-02f, 1.16415687e-01f, 4.99465801e-02f, -3.43528129e-02f, 4.36212830e-02f, 1.04977190e-01f,
  -4.73738462e-02f, 1.22583352e-01f, 1.25271991e-01f, 1.82947852e-02f, 1.59818549e-02f, -8.32542218e-03f, -3.13541549e-03f, 4.48942557e-02f, -4.90876511e-02f, -7.16245025e-02f,
  1.38593707e-02f, 2.38165744e-02f, 2.52865218e-02f, -6.41372800e-02f, 3.36551853e-02f, -3.21934782e-02f, 9.28192865e-03f, -7.19564618e-04f, -6.53815195e-02f, -1.57624111e-01f,
  -2.91300386e-01f, -8.95164087e-02f, 9.49403550e-03f, 6.05675839e-02f, 6.36283308e-02f, -6.43049181e-02f, -5.65594062e-02f, 1.70437247e-02f, -1.55991986e-02f, -1.67404823e-02f,
  -7.21976608e-02f, 2.98144147e-02f, -2.62923297e-02f, -4.79967408e-02f, 1.88962575e-02f, -1.76346585e-01f, 1.94251910e-02f, -4.10806127e-02f, -1.09967127e-01f, -7.97273368e-02f,
  -5.45480140e-02f, 8.20225030e-02f, 2.87546031e-02f, 6.83807395e-03f, -3.62752452e-02f, -2.64553204e-02f, -5.29390275e-02f, 3.46735865e-02f, -2.54274700e-02f, 3.31363566e-02f,
  -1.45311117e-01f, 4.20198739e-02f, 5.36447018e-02f, -6.53432906e-02f, 1.30147338e-01f, 1.00303166e-01f, -3.54799032e-02f, -7.60726770e-03f, -2.25322768e-01f, 8.00611824e-03f,
  5.93320578e-02f, -1.70512453e-01f, -2.68692169e-02f, -1.95906311e-01f, -8.68546218e-02f, 3.04432400e-02f, -2.02158485e-02f, -1.37966305e-01f, 2.12749094e-03f, 3.20717879e-02f,
  -8.20707306e-02f, -6.54384866e-03f, -1.16646640e-01f, 2.73975376e-02f, -7.16159418e-02f, -1.23216264e-01f, 6.64007738e-02f, -3.20664495e-02f, 6.54985011e-02f, -5.94133325e-02f,
  -3.82580832e-02f, -1.22132532e-01f, -4.53174748e-02f, -6.13465756e-02f, 1.32292984e-02f, 3.96215431e-02f, 4.12425138e-02f, 4.19530608e-02f, 2.98887286e-02f, -1.26794562e-01f,
  7.52434656e-02f, 6.12013526e-02f, 5.39710037e-02f, -1.33660913e-01f, 1.79989655e-02f, 2.41501369e-02f, 3.36566828e-02f, -7.53763318e-02f, -1.54890582e-01f, 1.17769144e-01f,
  -6.09223684e-03f, 1.52364910e-01f, 2.29756553e-02f, 7.95086473e-02f, 6.12685867e-02f, 3.58186513e-02f, -8.82711913e-03f, 3.61398086e-02f, 4.31507975e-02f, -5.79208992e-02f,
  2.04831824e-01f, 2.02308502e-02f, 1.08927801e-01f, 7.30235428e-02f, -3.21123041e-02f, 1.13522485e-01f, 8.53093639e-02f, 1.01330981e-01f, -1.21626452e-01f, -7.24187344e-02f,
  7.78333694e-02f, 1.09437831e-01f, -9.23075378e-02f, -7.56453052e-02f, -3.89223062e-02f, -2.24876571e-02f, -8.25371072e-02f, -6.80882409e-02f, 5.19984141e-02f, -4.46592644e-02f,
  4.12829705e-02f, 3.16620283e-02f, -4.69601480e-03f, 1.75716765e-02f, -6.47844970e-02f, -1.14412941e-01f, 6.00274391e-02f, 3.01965117e-03f, 4.40038703e-02f, -7.38527924e-02f,
  1.59844644e-02f, 6.74792379e-02f, -7.49937072e-02f, 3.40346545e-02f, 1.12210765e-01f, 4.86503318e-02f, -6.63202330e-02f, 4.86947820e-02f, 9.01529714e-02f, -6.39409423e-02f,
  2.28284020e-02f, 7.18959793e-02f, 1.05383195e-01f, -9.59514752e-02f, -4.52337181e-03f, 1.06277121e-02f, 6.24142960e-02f, -7.93206021e-02f, 2.68418435e-02f, 5.23042455e-02f,
  5.72960600e-02f, 5.72162829e-02f, -6.73806742e-02f, 1.42046422e-01f, 9.13628004e-03f, 4.47802655e-02f, 1.71044618e-02f, -3.83792855e-02f, 8.38631168e-02f, -5.51813766e-02f,
  -4.62012827e-01f, 2.07901299e-01f, -1.85387164e-01f, 1.70041680e-01f, -2.68528879e-01f, -2.96416104e-01f, 8.96018278e-03f, -7.65288621e-02f, 2.70001572e-02f, 2.55952924e-01f,
  3.20582002e-01f, -1.68262228e-01f, 1.52992725e-01f, 3.31015736e-01f, -3.42242837e-01f, 2.47186065e-01f, 5.82098402e-02f, 6.38709888e-02f, -7.93481991e-02f, 7.37331808e-02f,
  -9.31822732e-02f, 3.33002537e-01f, 9.19931009e-02f, 1.86898559e-02f, -1.00324146e-01f, -2.99852006e-02f, 8.58702585e-02f, -1.70642715e-02f, -3.91312353e-02f, -7.88441300e-02f,
  -6.59062490e-02f, 1.19198710e-01f, -1.26512051e-02f, -4.17728722e-02f, -9.30968970e-02f, -1.64206013e-01f, -1.70032196e-02f, -6.10753857e-02f, 4.67706695e-02f, -1.25902146e-01f,
  -4.08786312e-02f, -6.75978977e-03f, 4.69114780e-02f, 7.63925686e-02f, -9.97380763e-02f, -5.00455834e-02f, -1.06489332e-02f, -6.35202900e-02f, 7.62047130e-05f, -5.35901450e-03f,
  1.24782762e-02f, -9.50892866e-02f, 1.94275435e-02f, -1.00229168e-02f, -1.08192198e-01f, 1.40139684e-02f, -4.62656142e-03f, -1.94145052e-03f, -3.35700847e-02f, -3.80136855e-02f,
  -1.24889314e-01f, -1.03304675e-02f, 3.96543480e-02f, 1.09777212e-01f, 3.59559208e-02f, -3.21692079e-02f, -6.69599697e-02f, 6.13264665e-02f, -1.12771295e-01f, 5.24175875e-02f,
  -1.09551838e-02f, 2.77660023e-02f, -7.95586687e-03f, -3.92862819e-02f, -4.40136157e-02f, -3.21862171e-03f, -2.13579498e-02f, 9.46198180e-02f, -2.52042580e-02f, -2.72949552e-03f,
  1.17792077e-01f, 1.07934279e-02f, 4.93845120e-02f, -8.79801903e-03f, 8.73906389e-02f, 5.87246642e-02f, 1.32657671e-02f, -6.00372292e-02f, 4.62123901e-02f, -2.85105426e-02f,
  -6.82109268e-03f, 5.21121025e-02f, 7.30602518e-02f, -5.43704107e-02f, -1.72532145e-02f, -6.99572265e-02f, 1.93954669e-02f, -1.29845947e-01f, -2.38085128e-02f, -1.28116384e-01f,
  -1.33024603e-02f, -7.83273429e-02f, -9.78863388e-02f, 5.17117456e-02f, -1.33240730e-01f, 9.78717394e-03f, 9.79100391e-02f, 4.79710884e-02f, 1.44305117e-02f, -2.19054781e-02f,
  -4.15028706e-02f, 2.70599918e-03f, -6.79006055e-02f, -8.21510032e-02f, 2.75164522e-04f, 1.76987355e-03f, 4.76990221e-03f, -2.65395921e-02f, -1.53389394e-01f, 1.00350864e-02f,
  -5.77057183e-01f, 3.55847895e-01f, 6.92030489e-02f, -2.73712754e-01f, 2.42543757e-01f, 7.32366070e-02f, -2.96651497e-02f, 9.82110277e-02f, -1.09423362e-01f, -7.84947053e-02f,
  -1.77850366e-01f, -3.64141203e-02f, 8.72005075e-02f, -6.85864910e-02f, -8.99158791e-02f, 2.33823471e-02f, -1.13415502e-01f, -1.21163838e-01f, 2.25545272e-01f, 4.81354631e-03f,
  5.47621958e-02f, 2.70957090e-02f, 3.58277969e-02f, 3.16587210e-01f, 3.43563147e-02f, 4.12986754e-03f, -2.31543154e-01f, 1.16247587e-01f, -1.28476068e-01f, 8.25803168e-03f,
  -7.98924267e-02f, -2.04956651e-01f, 3.77117731e-02f, -5.47210835e-02f, -1.46036044e-01f, -7.20220432e-02f, -5.95022067e-02f, 2.24132296e-02f, -1.11691020e-01f, 2.50341631e-02f,
  4.60543446e-02f, 4.44842130e-02f, -3.76246236e-02f, 5.68767935e-02f, 3.09821740e-02f, -3.66706098e-03f, 1.05943419e-01f, 5.23206815e-02f, 6.77193189e-03f, 1.08637415e-01f,
  1.54630452e-01f, 8.14792961e-02f, -2.21472457e-02f, -7.05661103e-02f, -2.15226668e-03f, -2.39695907e-02f, -2.67538633e-02f, -1.38972342e-01f, 4.44207005e-02f, -2.43914574e-02f,
  7.51869455e-02f, 3.61190140e-02f, 1.07397430e-01f, 4.88364100e-02f, 9.21647921e-02f, 1.25290733e-02f, -3.26229073e-02f, -4.12868410e-02f, -4.26353291e-02f, 4.47702482e-02f,
  -5.88280857e-02f, -6.27959743e-02f, -2.78552081e-02f, -8.00657049e-02f, 6.04842380e-02f, -7.60113746e-02f, -5.33612967e-02f, 3.25896288e-03f, -1.57423671e-02f, 5.48462383e-02f,
  -2.73221321e-02f, -1.02687133e-02f, 4.71876860e-02f, 9.36104357e-02f, 1.09860480e-01f, -5.14067858e-02f, 8.06445628e-02f, 4.19018604e-02f, -6.11590920e-04f, -3.37930135e-02f,
  -1.03952609e-01f, -3.36359650e-01f, -1.71377156e-02f, 1.08354911e-02f, 2.88749561e-02f, -1.74635779e-02f, 3.71834785e-02f, -1.23009169e-02f, 1.27004161e-02f, -1.70690846e-02f,
  -2.68054642e-02f, -7.37673715e-02f, 9.97379888e-03f, 6.34920644e-03f, 9.02901962e-02f, -1.25885174e-01f, -1.05611578e-01f, -9.35016051e-02f, -5.70597574e-02f, -2.01024488e-02f,
  -4.82495092e-02f, 2.11654808e-02f, -9.67862457e-02f, -3.54650319e-02f, -2.50723436e-02f, -3.62560749e-02f, -7.96054527e-02f, 1.27392309e-02f, -9.77958180e-03f, 4.64348234e-02f,
  2.19666183e-01f, 8.07657465e-02f, -4.27053496e-02f, 1.46736890e-01f, -3.36178765e-02f, -1.37867019e-01f, -3.45537476e-02f, 7.74092972e-02f, -5.99078983e-02f, -7.46081537e-03f,
  1.12149879e-01f, 1.04538321e-01f, 3.46399355e-03f, 1.69048503e-01f, 1.21865496e-01f, 1.71388704e-02f, 1.21848226e-01f, 2.03558821e-02f, 1.06971093e-01f, 1.81442767e-01f,
  1.31470338e-01f, 2.17119992e-01f, 1.85286421e-02f, 2.26673409e-01f, 1.18527539e-01f, -9.59427468e-03f, 1.03573248e-01f, 8.94936547e-02f, 1.36365578e-01f, 1.88735686e-02f,
  3.46799232e-02f, 4.18245494e-02f, -3.01745404e-02f, -1.04901455e-02f, 4.09228206e-02f, 5.18057160e-02f, -2.37144325e-02f, 5.02882265e-02f, -1.66705567e-02f, 3.27740051e-02f,
  -2.43642144e-02f, 4.53269295e-02f, 9.54739302e-02f, 1.13999680e-01f, 7.97243714e-02f, -1.77991036e-02f, -7.13457987e-02f, 4.41970723e-03f, -9.48505178e-02f, 3.68082300e-02f,
  -1.80995627e-03f, 6.39875606e-03f, 8.28826800e-02f, 2.08029542e-02f, -1.32750310e-02f, 8.83052591e-03f, 4.06129565e-03f, 1.40059385e-02f, 5.59647977e-02f, 9.55769941e-02f,
  1.33620560e-01f, -1.40117342e-02f, 9.87888426e-02f, -9.18996707e-03f, 2.69618239e-02f, -6.84954971e-02f, 3.48709002e-02f, 5.52493110e-02f, -3.81205380e-02f, -1.44269178e-02f,
  -1.84985492e-02f, 5.93734644e-02f, -1.29824188e-02f, -2.18359344e-02f, 1.15643367e-01f, -1.77644175e-02f, -6.79450575e-03f, 6.70420229e-02f, -5.24035394e-02f, -6.78397343e-02f,
  -9.18198898e-02f, 9.80920196e-02f, -3.43883857e-02f, -5.48883528e-02f, 7.02568702e-03f, -3.68709378e-02f, 2.36543175e-02f, 2.61367466e-02f, -1.01349587e-02f, 3.50226276e-02f,
  3.42590548e-02f, 2.08813399e-01f, -5.47044054e-02f, -3.63710262e-02f, -3.97064351e-02f, 7.82482475e-02f, 8.29049572e-02f, 1.87565699e-01f, 7.41945654e-02f, 1.05027817e-02f,
  -3.38354148e-02f, 1.96497384e-02f, 4.56569158e-03f, -3.41417491e-02f, 3.43810804e-02f, -2.02749483e-02f, 2.94094486e-03f, 1.67664886e-02f, -1.97445787e-02f, -3.08172870e-02f,
  -2.00058520e-02f, -4.16622609e-02f, 1.17085016e-04f, 5.47853149e-02f, 6.99067265e-02f, 5.90025298e-02f, -4.30634841e-02f, -1.18203834e-01f, -3.08331568e-03f, 2.19360180e-02f,
  -1.66790158e-01f, -2.76950032e-01f, -2.87998646e-01f, -3.55496332e-02f, 1.11079827e-01f, 1.83920324e-01f, -4.48991507e-02f, 5.25185242e-02f, -1.75987244e-01f, 1.17208704e-01f,
  1.18908100e-01f, -2.14041486e-01f, -2.07743838e-01f, 3.61135900e-01f, 1.73476830e-01f, -1.06825717e-01f, 2.13594794e-01f, 1.61393300e-01f, -9.58524644e-02f, -7.57996142e-02f,
  8.33313912e-02f, 2.65442342e-01f, -6.60448195e-03f, 1.48849323e-01f, 8.08179528e-02f, -7.41786510e-02f, 2.57904511e-02f, -1.89702809e-01f, 2.93248743e-01f, 1.51121482e-01f,
  9.21862125e-02f, -2.05922529e-01f, 8.61591399e-02f, 4.89065051e-02f, 1.75862927e-02f, 2.39452440e-02f, 1.84159423e-03f, -3.99590544e-02f, 2.47602165e-02f, -3.97227257e-02f,
  -8.64919648e-02f, 5.56242615e-02f, -6.31401762e-02f, -1.25019457e-02f, -2.36941073e-02f, 1.63236409e-02f, 5.56010604e-02f, -9.78488103e-03f, 3.36894989e-02f, 1.86917726e-02f,
  -2.13680230e-02f, 8.78244042e-02f, -1.70800481e-02f, 6.52811751e-02f, 8.16649348e-02f, -5.82395010e-02f, 1.70343779e-02f, -2.44551003e-02f, 6.10419922e-03f, -1.08575840e-02f,
  -1.92920750e-04f, -6.01906702e-02f, 1.95837673e-02f, -2.00128760e-02f, 7.38746226e-02f, -1.67599937e-03f, 5.04145883e-02f, 4.63597029e-02f, -3.78893502e-02f, 1.79310851e-02f,
  -2.57214718e-02f, -3.09804268e-02f, -2.58685593e-02f, -1.46096814e-02f, 5.62025867e-02f, -6.31684810e-02f, 1.89705957e-02f, 4.61433455e-02f, -5.74610382e-02f, 4.73488346e-02f,
  -2.96460353e-02f, -2.88558286e-02f, 9.55615118e-02f, 1.33222677e-02f, 3.01462598e-04f, -2.80334540e-02f, 4.91766222e-02f, 2.02508327e-02f, -4.87717912e-02f, -2.94994600e-02f,
  4.81889173e-02f, -1.52382076e-01f, -4.67688330e-02f, 7.20474198e-02f, -1.02296874e-01f, 3.83841284e-02f, -1.26008317e-01f, 1.31137241e-02f, 9.75446552e-02f, -4.34684120e-02f,
  5.07478006e-02f, 1.72284637e-02f, -8.85264575e-02f, -3.10755074e-02f, 7.31867999e-02f, -5.52139692e-02f, -4.34189625e-02f, -5.60825784e-03f, 4.82084975e-02f, -3.33401859e-02f,
  9.01445001e-02f, 1.15234405e-02f, -1.42613068e-01f, -5.38507812e-02f, 9.57237184e-02f, 4.47194725e-02f, 4.49318672e-03f, 1.36623746e-02f, 1.31255195e-01f, 4.23182920e-02f,
  2.90234745e-01f, -4.41864640e-01f, 6.82515278e-02f, 1.92957997e-01f, 2.81957477e-01f, 1.39523491e-01f, 2.84429312e-01f, 1.15908042e-01f, 9.28876698e-02f, -2.83655614e-01f,
  8.67448095e-03f, -1.08107246e-01f, -8.95894095e-02f, 1.95238777e-02f, 2.72245437e-01f, -3.86673249e-02f, 1.17833614e-02f, -1.13641627e-01f, -2.07311958e-02f, -2.75350958e-02f,
  1.36932179e-01f, 9.02852416e-02f, 1.64567903e-01f, -9.02727097e-02f, 3.71698141e-02f, 4.92822230e-02f, -7.75198191e-02f, 8.80506337e-02f, 4.07255031e-02f, 1.48947969e-01f,
  -1.24698900e-01f, -8.95451233e-02f, -1.10625073e-01f, -8.91984999e-02f, -2.48276051e-02f, -1.12307504e-01f, 7.68162543e-03f, 1.22338772e-01f, 3.22493240e-02f, 3.99680110e-03f,
  -1.87736198e-01f, 6.76655695e-02f, 5.60357012e-02f, -8.94735008e-03f, 8.70598294e-03f, 6.44785305e-03f, 1.15838069e-02f, 1.18548458e-03f, -1.71593316e-02f, -1.15812698e-03f,
  -4.36961837e-03f, -3.47393081e-02f, -1.01814762e-01f, 1.24633247e-02f, -5.40414862e-02f, 6.86652213e-02f, 8.86673331e-02f, 4.51744389e-04f, -3.75463516e-02f, 8.84753838e-02f,
  1.00090096e-04f, -1.01835817e-01f, -7.61873741e-03f, 1.27484342e-02f, 1.40907597e-02f, 9.73650962e-02f, 2.46232152e-02f, -3.27880532e-02f, 9.97625012e-03f, -7.00753853e-02f,
  3.26621979e-02f, 3.57151218e-02f, -9.65570509e-02f, -1.53553803e-02f, -2.73882467e-02f, 1.70217156e-02f, 8.43515899e-03f, -1.64032672e-02f, -4.33821529e-02f, 6.81493990e-03f,
  -1.19141124e-01f, -2.21909080e-02f, -6.38890313e-03f, 1.24517195e-02f, 5.27854972e-02f, 3.76480147e-02f, 5.78577677e-03f, -2.38736602e-03f, -1.20762549e-01f, 3.23248026e-03f,
  -2.59803087e-01f, -3.46731722e-01f, -1.83015745e-02f, -4.25759926e-02f, -9.10542756e-02f, -7.31263608e-02f, -5.65101281e-02f, 8.10849071e-02f, -1.54390812e-01f, -2.99191698e-02f,
  -3.30748782e-02f, 4.33716998e-02f, -8.88606235e-02f, 6.67453855e-02f, -7.52750933e-02f, 4.62355241e-02f, -6.93070982e-03f, -7.23574013e-02f, -3.75800356e-02f, -6.71251044e-02f,
  1.05855785e-01f, -3.83517146e-02f, 1.61012821e-02f, 9.43107605e-02f, -7.76740760e-02f, 3.96935306e-02f, -2.79650856e-02f, 7.35715032e-02f, 6.18738681e-02f, -2.24984414e-03f,
  -1.60153821e-01f, 2.39678666e-01f, -6.90529570e-02f, 1.59724146e-01f, 9.48348045e-02f, -1.94237046e-02f, 2.38130968e-02f, 7.34536350e-02f, -5.43844663e-02f, 1.86280489e-01f,
  1.74773380e-01f, 9.89749879e-02f, 2.53173709e-02f, 1.94269925e-01f, 8.77721161e-02f, -5.06112166e-02f, 1.99911609e-01f, 9.80370715e-02f, 6.47733435e-02f, 2.75138021e-01f,
  5.29784597e-02f, 2.13237211e-01f, 7.23386556e-02f, 1.47443146e-01f, 1.65723994e-01f, -6.58299997e-02f, 1.28414795e-01f, 7.58447424e-02f, 1.62378371e-01f, 9.95245948e-02f,
  1.25274379e-02f, 3.12545151e-03f, -5.06626852e-02f, -2.15737168e-02f, 5.86569719e-02f, 4.36602198e-02f, -5.05452417e-02f, -1.16572767e-01f, -8.32375214e-02f, 3.63454558e-02f,
  4.88141458e-03f, -4.29168716e-02f, -4.32819454e-03f, -1.90927088e-02f, 6.34597912e-02f, 9.50382501e-02f, -5.75433671e-02f, -3.12356818e-02f, -3.72127853e-02f, 7.15934718e-03f,
  -6.40172686e-04f, 1.57770421e-02f, -1.15610454e-02f, -3.12559493e-02f, -2.59731561e-02f, 2.76658684e-02f, -3.73807619e-03f, 8.97544920e-02f, -1.04744673e-01f, 9.92786512e-02f,
  3.53191420e-02f, 1.54347625e-02f, -4.84615937e-02f, -2.32466720e-02f, 5.99733405e-02f, -1.42071291e-03f, 4.57810722e-02f, -5.26313856e-03f, -7.59236291e-02f, 9.68134776e-02f,
  2.21598111e-02f, 2.62751486e-02f, 5.71879447e-02f, -1.16107576e-02f, 4.07335572e-02f, -1.11133484e-02f, -1.35033935e-01f, 9.83560085e-02f, 3.02017480e-02f, -4.51491103e-02f,
  1.12601884e-01f, 8.69991258e-02f, -6.20285003e-03f, -8.56523439e-02f, 4.41652276e-02f, 1.27869761e-02f, 6.97022006e-02f, 1.24020770e-01f, -6.61277620e-04f, -1.99066065e-02f,
  1.00783400e-01f, 2.07859859e-01f, 1.45905856e-02f, -3.36212590e-02f, 3.14467698e-02f, 1.26993080e-04f, 9.32159275e-02f, -1.21478671e-02f, 3.46230306e-02f, -3.09807118e-02f,
  8.38280246e-02f, -9.27034542e-02f, 2.84832297e-03f, 3.11408080e-02f, -3.02696377e-02f, 4.31127027e-02f, 5.19678369e-02f, 5.58534218e-03f, 3.39646786e-02f, 3.45181264e-02f,
  -6.84934184e-02f, 8.87197256e-03f, 2.69857068e-02f, -5.47776334e-02f, -9.72651318e-02f, 9.28846002e-02f, 1.72616579e-02f, 3.98872904e-02f, 3.30837816e-02f, -4.47614752e-02f,
  7.06996471e-02f, -9.67796817e-02f, 2.05260783e-01f, 1.17849879e-01f, 9.62324366e-02f, 9.42119285e-02f, 3.97751071e-02f, 2.00660393e-01f, 3.64179075e-01f, -1.18745357e-01f,
  -1.45994052e-01f, -1.35836437e-01f, -8.45865533e-02f, -9.63411778e-02f, -1.17052039e-02f, -6.28864989e-02f, 1.11040182e-01f, -1.26882300e-01f, 1.37497962e-01f, -5.42030856e-02f,
  1.09726362e-01f, -1.65333539e-01f, -1.52327612e-01f, -7.79195428e-02f, 5.72780287e-03f, -6.09984342e-03f, -8.10995623e-02f, 7.14124274e-03f, -2.09058195e-01f, -2.05769744e-02f,
  1.47072738e-02f, -2.41843909e-02f, -9.84576494e-02f, -1.08632252e-01f, -3.47122326e-02f, 3.43329795e-02f, -9.41187963e-02f, -1.51014596e-01f, 7.83138443e-03f, -1.09856762e-01f,
  -4.19616839e-03f, -5.28756753e-02f, 9.41810478e-03f, -3.75656858e-02f, -2.56139338e-02f, 8.05682037e-03f, -3.18115689e-02f, 2.81885471e-02f, -9.46258381e-02f, -1.49492314e-02f,
  -8.54429081e-02f, 1.32190108e-01f, 1.37495082e-02f, -3.12675387e-02f, -7.95329288e-02f, 4.93241800e-03f, 4.10753042e-02f, -4.01971862e-02f, 4.43840809e-02f, -1.83323044e-02f,
  -2.32962798e-02f, 9.91574582e-03f, -2.30017249e-02f, 7.74500147e-02f, 8.77836421e-02f, -8.16664174e-02f, 1.02326060e-02f, 4.29089330e-02f, 2.67806537e-02f, 2.19785329e-03f,
  -4.68562059e-02f, 7.05094263e-03f, 3.69192883e-02f, 1.95921976e-02f, -5.90714067e-02f, 7.53201619e-02f, -9.31116287e-03f, -9.96603537e-03f, 2.91351750e-02f, 3.91654968e-02f,
  1.76775530e-02f, 3.23232226e-02f, -7.85517171e-02f, -1.27625633e-02f, -3.45849581e-02f, -6.40972257e-02f, -4.57474450e-03f, 1.04979105e-01f, 7.76524395e-02f, -4.74094339e-02f,
  8.50452781e-02f, -5.51884703e-04f, -1.71051875e-01f, -1.41396686e-01f, -3.73789556e-02f, 4.45607379e-02f, -1.10198406e-03f, -4.46772985e-02f, -1.60574988e-02f, -6.23167828e-02f,
  -8.26235488e-02f, -2.09035650e-02f, 6.18691742e-02f, -8.21232144e-03f, 4.24561575e-02f, 9.56673454e-03f, -1.44806713e-01f, 9.39657837e-02f, -1.15528405e-02f, -3.41403447e-02f,
  -7.11555108e-02f, -7.96724558e-02f, -2.32433458e-03f, -1.95297711e-02f, -4.97947410e-02f, 2.45851800e-02f, -1.35851651e-02f, 4.78182882e-02f, -8.62970650e-02f, 7.46320114e-02f,
  -2.11275250e-01f, 3.14479560e-01f, -1.20363176e-01f, 3.10885832e-02f, -1.04788430e-01f, 4.14197028e-01f, 3.90558839e-01f, 1.39712300e-02f, 1.35802686e-01f, 2.61212379e-01f,
  5.72806969e-02f, -1.49813937e-02f, 3.05552613e-02f, 2.45387137e-01f, 6.91204742e-02f, 1.11487277e-01f, 2.25546703e-01f, 1.10156454e-01f, 2.70719565e-02f, 2.78434101e-02f,
  -3.91925350e-02f, 1.16111301e-01f, -6.79099262e-02f, -6.58159181e-02f, -1.15006298e-01f, -3.30766708e-01f, -9.93764624e-02f, -1.67450830e-01f, -1.11207314e-01f, 4.65810448e-02f,
  5.37511334e-02f, 2.70744134e-02f, -1.01730563e-01f, 1.04177091e-02f, -5.04974797e-02f, 8.04296806e-02f, -4.88174148e-02f, -1.04335755e-01f, -1.03103086e-01f, 7.73739815e-02f,
  4.21025753e-02f, -3.30111794e-02f, 1.65679783e-01f, -9.92085338e-02f, 4.65481393e-02f, 3.83897834e-02f, -7.58427829e-02f, -3.77443135e-02f, -5.72111225e-03f, 4.21512462e-02f,
  3.04829776e-02f, -4.67205867e-02f, -8.47527012e-02f, 9.34876427e-02f, -8.78979787e-02f, -3.39751355e-02f, 5.48253059e-02f, -6.41001612e-02f, -2.49472260e-02f, 6.71094358e-02f,
  -5.31044509e-03f, -2.76301783e-02f, 3.13059017e-02f, -4.07846048e-02f, 4.06699181e-02f, -8.30690488e-02f, -3.72826606e-02f, 5.41041791e-03f, -4.07997295e-02f, -1.44261522e-02f,
  1.21851945e-02f, -6.31711930e-02f, -4.55263257e-02f, -7.91282430e-02f, 4.71254140e-02f, 3.90139148e-02f, -2.85734329e-02f, 2.96652988e-02f, 1.43879873e-03f, 8.70377233e-04f,
  -2.84259096e-02f, 6.90460503e-02f, -2.77731884e-02f, -4.49242406e-02f, -2.63372646e-03f, -4.24702391e-02f, 3.97492237e-02f, 2.01100465e-02f, 4.40636687e-02f, -4.92135156e-03f,
  1.34142801e-01f, 2.04852119e-01f, 6.16182433e-03f, -3.80682051e-02f, 5.85579388e-02f, 1.72274411e-02f, -2.50795987e-02f, 4.51465463e-03f, 2.05954891e-02f, 2.34355181e-02f,
  -4.39516455e-02f, -4.90466096e-02f, 1.12625636e-01f, -3.32930498e-02f, -5.04826978e-02f, 8.22919533e-02f, 3.00893728e-02f, 4.29173708e-02f, -2.81655975e-02f, -7.15590939e-02f,
  -1.16983332e-01f, -7.53330886e-02f, -4.94733900e-02f, 7.23965690e-02f, -4.81572151e-02f, -7.43139163e-02f, -6.57136217e-02f, -1.93141866e-02f, 8.01936463e-02f, 1.11904070e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.51261777e-01f, -2.22973172e-02f, 9.94100571e-02f, 7.46943355e-02f, 2.22006310e-02f, 1.16168045e-01f, 1.05234236e-01f, 6.78321198e-02f, 9.44639742e-02f, 1.27113182e-02f,
  6.86521991e-04f, 1.18716294e-03f, 1.17596306e-01f, 4.57915850e-02f, 1.61209226e-01f, 2.00243026e-01f, -8.27713776e-03f, 7.00557828e-02f, 1.01762235e-01f, 5.40165976e-02f,
  7.91807249e-02f, 1.30246624e-01f, 7.88938161e-03f, 8.57593343e-02f, 2.24436656e-01f, 3.16208825e-02f, 1.13760434e-01f, 8.55459943e-02f, 1.52018517e-01f, -1.77858230e-02f,
  9.40824822e-02f, 7.59562925e-02f, 1.52589500e-01f, 1.29904509e-01f, 1.78198516e-02f, 2.06411883e-01f, 1.40425593e-01f, 6.41990751e-02f, 1.39484122e-01f, 4.36793640e-02f,
  1.24387965e-01f, 1.77845076e-01f, 2.04464123e-01f, 1.05842873e-02f, 1.36234745e-01f, 1.14132673e-01f, 2.27512699e-02f, 3.04856058e-02f, 2.58707434e-01f, 4.22635190e-02f,
  1.20464407e-01f, 1.70382351e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.00174531e-01f, 1.14482865e-01f, 9.85401496e-02f, -1.64943431e-02f, 4.06145304e-02f, -7.68245980e-02f, 3.90141346e-02f, 6.30967915e-02f, 2.03910694e-01f, -1.64265893e-02f,
  1.45148024e-01f, -9.23506245e-02f, -7.15570152e-02f, 8.64436701e-02f, -1.91663742e-01f, -1.17677711e-02f, 1.93798304e-01f, -1.07010454e-01f, 2.34552678e-02f, 1.74146190e-01f,
  -1.21585861e-01f, -1.70993075e-01f, -1.69323683e-02f, -1.88598871e-01f, -1.27363488e-01f, 9.30661857e-02f, 8.71642381e-02f, 9.00997818e-02f, -2.14351237e-01f, -1.48676321e-01f,
  -1.49680465e-01f, 8.17692205e-02f, 9.99843031e-02f, 7.50253052e-02f, 5.11759706e-02f, 6.66572005e-02f, 2.69599464e-02f, -4.68072761e-03f, -1.85030326e-01f, -5.48762605e-02f,
  2.23465413e-02f, 1.28632218e-01f, -7.42704347e-02f, -8.89689699e-02f, 5.05658090e-02f, -1.45651668e-01f, 9.63609740e-02f, 1.51990652e-01f, 7.61647597e-02f, -4.83517386e-02f,
  4.34440486e-02f, 5.74300587e-02f, -5.26713133e-02f, 1.39997065e-01f, -2.10361183e-01f, 3.91495265e-02f, -2.45897084e-01f, -7.52181262e-02f, 8.88722464e-02f, 1.43802598e-01f,
  1.49926320e-01f, 1.55753195e-01f, -1.89783081e-01f, -1.11910306e-01f, 2.08305102e-02f, 9.04774964e-02f, -6.84583336e-02f, 8.52283761e-02f, -2.37227324e-02f, -1.26632471e-02f,
  3.01154004e-03f, -1.00976937e-01f, 4.55129668e-02f, 1.64965287e-01f, 6.71527311e-02f, -1.60560012e-01f, -2.03575194e-01f, -2.24921722e-02f, -8.97851288e-02f, -1.38812419e-03f,
  1.51073262e-01f, -5.47978608e-03f, 2.23467639e-03f, 4.87012751e-02f, -1.13553084e-01f, -1.19838856e-01f, -7.30481818e-02f, -1.35659009e-01f, -7.40368813e-02f, 1.54115669e-02f,
  9.60373282e-02f, 2.20970839e-01f, -1.39091045e-01f, -5.83259054e-02f, -1.86633840e-02f, -2.59883832e-02f, -4.40839343e-02f, -7.23707527e-02f, -5.91055676e-02f, -4.11412604e-02f,
  -7.34357610e-02f, 1.80232137e-01f, 3.52004580e-02f, -9.79796574e-02f, -1.56109184e-01f, -4.15560976e-03f, -1.95603609e-01f, 1.86521616e-02f, 9.65358391e-02f, -2.46811599e-01f,
  2.95189545e-02f, 1.55552998e-01f, 1.98371455e-01f, 5.12830354e-02f, 1.66570380e-01f, -9.98205245e-02f, 1.73008442e-01f, 9.83860195e-02f, -1.27781689e-01f, -1.25768170e-01f,
  -1.67691365e-01f, -1.35260463e-01f, 1.23593755e-01f, -5.44132218e-02f, 2.57656634e-01f, -3.88416797e-02f, -7.08569065e-02f, -8.62557516e-02f, -2.10306682e-02f, 1.21424189e-02f,
  -5.20652980e-02f, 8.65932256e-02f, -3.99584882e-02f, -4.56094183e-02f, 2.08333065e-03f, -9.15286765e-02f, 3.24483663e-02f, 1.19761094e-01f, 6.23214990e-02f, -4.94573079e-02f,
  -9.99145433e-02f, -1.12226896e-01f, -5.07598035e-02f, 3.86971235e-02f, 1.89210922e-01f, -9.59416404e-02f, -1.75879933e-02f, -2.39492543e-02f, -1.72751546e-01f, -1.03792511e-01f,
  -1.88353881e-01f, -1.24939397e-01f, -9.39369351e-02f, -2.15585274e-03f, 7.18112960e-02f, 1.25756264e-01f, -1.61132112e-01f, -1.44833118e-01f, 2.33693887e-02f, -4.76216152e-02f,
  -5.09938737e-03f, -1.44989341e-01f, -1.53044555e-02f, 1.07551597e-01f, -1.72390372e-01f, -3.32077555e-02f, -3.23882885e-02f, -3.87631953e-02f, -2.33955421e-02f, -2.53036413e-02f,
  -1.34591118e-01f, -9.84946713e-02f, 1.58041306e-02f, -1.38190761e-01f, 7.39131123e-02f, 3.94731425e-02f, 2.02299431e-01f, 1.24142550e-01f, 1.28562227e-01f, -5.72188869e-02f,
  -2.47881804e-02f, -6.32212264e-03f, -1.38596922e-01f, -6.56085014e-02f, -1.69492692e-01f, -9.61500630e-02f, -3.81090119e-02f, 4.05947417e-02f, 2.48188570e-01f, -3.02451886e-02f,
  -8.37146416e-02f, -7.33643100e-02f, 1.37465343e-01f, 1.65791467e-01f, 8.44460502e-02f, 6.30389154e-02f, -5.84625117e-02f, 3.62484204e-03f, 1.40891373e-01f, -3.37192719e-03f,
  2.17958212e-01f, -1.89115629e-02f, 9.41293165e-02f, 2.32835077e-02f, 1.55480783e-02f, 1.60209194e-01f, 5.39804958e-02f, -2.49861609e-02f, -1.37235805e-01f, -1.22645665e-02f,
  7.07063228e-02f, 8.98291320e-02f, -1.22294920e-02f, -1.66375980e-01f, -4.35934141e-02f, -2.08469942e-01f, 1.28765240e-01f, -1.15957811e-01f, -8.92926604e-02f, -2.00167224e-02f,
  -1.22930601e-01f, -1.21146642e-01f, -7.56225735e-02f, 8.58588815e-02f, -6.37888685e-02f, 3.13538089e-02f, -1.17544770e-01f, -1.28866240e-01f, 1.96871176e-01f, 4.02091220e-02f,
  8.49785730e-02f, -1.17284596e-01f, 5.96659146e-02f, 1.94854602e-01f, 1.90809444e-02f, 2.63239652e-01f, -1.59634411e-01f, -1.09988928e-01f, -2.06807643e-01f, 1.06155366e-01f,
  -1.48550933e-02f, 4.63189147e-02f, -8.03150702e-03f, 4.74462248e-02f, 2.42104009e-02f, 8.24922323e-02f, 4.97724824e-02f, -4.05877866e-02f, -5.20789921e-02f, -1.28197432e-01f,
  1.33807033e-01f, 5.00663668e-02f, -1.62873417e-02f, 1.22165523e-01f, 6.59516305e-02f, 4.35027331e-02f, -8.79179388e-02f, -8.39277450e-03f, 1.03763320e-01f, 1.51135782e-02f,
  -3.62813398e-02f, 2.76904721e-02f, -5.50710373e-02f, -1.67505190e-01f, -1.41776845e-01f, 1.25863165e-01f, -1.66121736e-01f, -4.88851080e-03f, -1.04210697e-01f, -2.22046345e-01f,
  1.51621029e-01f, -5.54451346e-02f, 2.85837334e-02f, 1.44898742e-01f, -2.52502263e-02f, -9.12847146e-02f, 7.84645975e-02f, 5.87541535e-02f, 2.38430779e-02f, 1.11164920e-01f,
  7.52538219e-02f, -1.48464441e-01f, 1.59917340e-01f, -8.12475979e-02f, 2.10094526e-02f, 4.30677086e-02f, 8.15823115e-03f, -6.45516887e-02f, 4.24522161e-02f, -4.14634123e-02f,
  9.65017155e-02f, -2.40163761e-04f, -4.81727123e-02f, 9.16968137e-02f, 9.30298641e-02f, -3.36307772e-02f, -2.57057324e-02f, -2.20653683e-01f, 7.17688724e-02f, 9.67525318e-02f,
  3.51322554e-02f, 1.08126111e-01f, 5.09662032e-02f, -3.75136249e-02f, -6.16163462e-02f, 1.62659094e-01f, -1.26402720e-03f, -7.59512410e-02f, 1.03400320e-01f, -1.93448901e-01f,
  1.10026740e-01f, -1.41610429e-01f, -1.67668775e-01f, 2.09458977e-01f, -1.93834752e-01f, -1.64927498e-01f, -6.00905605e-02f, -1.46093234e-01f, 5.48667386e-02f, -1.23960577e-01f,
  8.44594687e-02f, 1.35010466e-01f, 1.36959970e-01f, 1.75268725e-02f, -1.44148637e-02f, 6.53696954e-02f, 9.44918692e-02f, 8.16141590e-02f, -9.81086679e-03f, 1.59541890e-01f,
  5.73662668e-02f, -6.19379319e-02f, -8.32781643e-02f, 7.46429563e-02f, 4.37356457e-02f, -1.87286222e-03f, -1.39741153e-01f, -8.75078607e-03f, 8.97239801e-03f, 2.17590541e-01f,
  1.90535530e-01f, -9.34011787e-02f, -4.24193814e-02f, -1.57766908e-01f, 1.45565927e-01f, 4.61486839e-02f, -5.42497300e-02f, 1.03484079e-01f, -7.15764239e-02f, -5.98595217e-02f,
  -6.80333003e-02f, 2.01872781e-01f, -2.92994101e-02f, 5.95675893e-02f, 1.20546827e-02f, -8.27537179e-02f, 1.98868439e-01f, 1.73170298e-01f, 2.41370611e-02f, 7.39848986e-02f,
  1.11730620e-01f, 1.89515576e-01f, -9.00985599e-02f, 1.49064854e-01f, -1.11953847e-01f, -2.25151077e-01f, -2.29613081e-01f, 4.14734222e-02f, 1.36641935e-01f, 4.11338918e-02f,
  -1.42701231e-02f, -8.43219012e-02f, 1.51501223e-01f, 1.42076373e-01f, 1.54637381e-01f, -4.02790989e-04f, 1.72916636e-01f, -9.59001109e-03f, 5.41694053e-02f, 2.11680587e-02f,
  8.10089409e-02f, 2.64967773e-02f, -3.02152168e-02f, 1.04299739e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.48222253e-01f, 6.25357777e-02f, 7.15535060e-02f, 6.84770346e-02f, 3.02134361e-02f, 1.38295308e-01f, -6.48895651e-02f, 1.75383613e-01f, 1.01900481e-01f, -2.54864067e-01f,
  -2.55180523e-02f, 1.01338029e-01f, 5.46375066e-02f, 1.21230714e-01f, -1.56050459e-01f, 5.97448237e-02f, -5.25053479e-02f, 8.58832747e-02f, 1.37430519e-01f, 2.15101019e-01f,
  2.75144696e-01f, -1.05953217e-01f, -1.24156252e-01f, -8.89384076e-02f, -8.56020153e-02f, 1.29324682e-02f, -2.93809861e-01f, 7.59160519e-02f, 3.13474238e-02f, 3.21885496e-02f,
  6.46858737e-02f, 2.25676775e-01f, 7.95277953e-02f, -6.38543889e-02f, -9.42087471e-02f, 3.15551385e-02f, 6.42025471e-02f, -2.13224873e-01f, -1.70094222e-01f, 2.79503949e-02f,
  2.56186247e-01f, 2.10850507e-01f, 1.17371887e-01f, -1.98992625e-01f, -2.02617645e-01f, 1.78129394e-02f, -7.78954923e-02f, -6.01780899e-02f, 1.33961737e-01f, -2.96727657e-01f,
  -1.35732040e-01f, 4.28845473e-02f, -7.69696608e-02f, 2.19249815e-01f, 6.53318241e-02f, 1.97222561e-01f, 1.39819160e-01f, 1.57804172e-02f, -5.74956462e-02f, 3.36351663e-01f,
  -1.21538313e-02f, 1.35181889e-01f, -7.53778368e-02f, 3.52903157e-02f, 3.35909091e-02f, 1.41126104e-03f, 1.03739344e-01f, 6.71957433e-02f, 1.15725614e-01f, 9.78262946e-02f,
  -5.76233827e-02f, -1.91228266e-03f, 2.10652240e-02f, -2.18071908e-01f, 8.25047716e-02f, 2.47941747e-01f, 2.19116449e-01f, 6.36076704e-02f, -7.15698749e-02f, 1.05617471e-01f,
  1.86725676e-01f, -1.38266589e-02f, 5.26424162e-02f, -8.57421756e-02f, -1.02759957e-01f, -2.79064924e-02f, 1.10953204e-01f, 1.28551677e-01f, -1.25004113e-01f, 7.01444075e-02f,
  3.70151140e-02f, -9.05307457e-02f, -1.02547966e-01f, 4.43755612e-02f, 2.78361011e-02f, -9.10651386e-02f, 6.57788813e-02f, -3.82808223e-02f, 5.23584411e-02f, 6.74883425e-02f,
  -5.59884235e-02f, -1.30870685e-01f, 5.26898541e-02f, 2.92793829e-02f, 2.35585608e-02f, -5.05972467e-02f, 1.55897677e-01f, -8.01202580e-02f, 1.60643637e-01f, 1.09485976e-01f,
  1.74245253e-01f, 8.34845826e-02f, 7.63134286e-02f, -1.30026126e-02f, 1.17345145e-02f, 5.66424541e-02f, -1.57936379e-01f, -1.98946018e-02f, -1.33400008e-01f, 5.51311523e-02f,
  -1.35771960e-01f, 1.21041127e-01f, 3.87721173e-02f, 4.97575216e-02f, 1.31031692e-01f, 6.82163835e-02f, 3.22115980e-02f, 7.51912370e-02f, 4.08165082e-02f, 8.67378116e-02f,
  9.83856916e-02f, 1.06048450e-01f, -5.02545722e-02f, 7.52478605e-03f, 9.57855061e-02f, 1.24295823e-01f, 2.12128982e-01f, 5.14966100e-02f, 2.66176134e-01f, 4.24906909e-02f,
  -5.97512573e-02f, -9.12497193e-03f, -3.74857262e-02f, 1.22801788e-01f, -6.76594526e-02f, -1.53045595e-01f, -3.57385501e-02f, 7.75884837e-02f, -5.95995933e-02f, -3.78504060e-02f,
  -6.70686215e-02f, -6.96936846e-02f, -4.46360409e-02f, 1.01810619e-01f, -5.58483824e-02f, -5.20817861e-02f, -3.38676274e-02f, -9.41663235e-02f, -2.23425031e-01f, 1.28726915e-01f,
  -1.70958694e-02f, 1.93525888e-02f, -5.01982830e-02f, -4.82379049e-02f, 9.50653255e-02f, -1.27011359e-01f, -1.05875075e-01f, -1.09560937e-01f, 5.35755940e-02f, 9.48960111e-02f,
  -2.09136661e-02f, 2.83909719e-02f, 6.31490946e-02f, -5.54920137e-02f, -1.27699031e-02f, 1.08735479e-01f, 2.29694456e-01f, 9.72626209e-02f, 1.12049907e-01f, 2.17789914e-02f,
  -1.09153710e-01f, 2.53694743e-01f, -3.77831981e-02f, 1.07640468e-01f, -6.30341470e-02f, -1.43750563e-01f, 1.73068300e-01f, 2.32176468e-01f, 1.71926931e-01f, 4.79721166e-02f,
  4.13449965e-02f, 1.44185303e-02f, 7.86481947e-02f, -1.57897025e-01f, -2.76987231e-03f, 6.64983243e-02f, 7.17476290e-03f, 2.52441596e-02f, -8.21344405e-02f, 9.36970189e-02f,
  1.66675989e-02f, -2.35637814e-01f, 1.55995237e-02f, 6.59476295e-02f, 1.84261292e-01f, 1.01632260e-01f, -8.28429610e-02f, 1.44528877e-02f, -3.31261493e-02f, 1.99758168e-02f,
  1.74814351e-02f, -3.49691771e-02f, -1.94550504e-03f, 1.43300921e-01f, 9.62111279e-02f, 1.02021091e-01f, 2.32733414e-02f, 4.83414046e-02f, 1.21883228e-02f, 2.19999962e-02f,
  7.52686933e-02f, 9.20557529e-02f, 1.02331802e-01f, -7.55022094e-02f, 6.72339797e-02f, 1.07521810e-01f, 1.44468099e-02f, 1.85934212e-02f, 1.75250039e-01f, -1.30742416e-01f,
  -1.21864870e-01f, 1.00307822e-01f, 3.31558213e-02f, 7.60666057e-02f, 7.63613954e-02f, -9.15038735e-02f, 8.36676732e-02f, 2.19676509e-01f, 1.11619733e-01f, -1.30092636e-01f,
  5.42180166e-02f, -8.82735252e-02f, 6.31638393e-02f, 2.69224308e-02f, -1.09445281e-01f, 3.59621383e-02f, 7.90487416e-03f, 1.26987904e-01f, 2.41428927e-01f, 1.36010215e-01f,
  1.51797011e-01f, 1.38736129e-01f, -8.77532214e-02f, 1.68082714e-01f, -1.51351746e-02f, 1.79216906e-01f, 6.20331056e-02f, 5.13292067e-02f, -5.01948148e-02f, 1.65524036e-01f,
  -2.69350465e-02f, 8.44982713e-02f, 9.10087526e-02f, 9.36478600e-02f, 1.12947606e-01f, -4.23668064e-02f, 2.69034773e-01f, 2.48071179e-01f, -2.43152715e-02f, -1.58415407e-01f,
  4.44533601e-02f, 1.82384282e-01f, -3.55899185e-02f, -5.23700491e-02f, -1.14489041e-01f, -1.46411106e-01f, -1.24059312e-01f, 1.50891580e-02f, 1.21329926e-01f, -3.82033922e-02f,
  5.83611242e-02f, 9.91153345e-02f, 9.45120677e-02f, -2.38309726e-01f, 6.18317276e-02f, -5.39857037e-02f, -2.35369861e-01f, 2.90133990e-02f, -4.52785343e-02f, -9.64285210e-02f,
  2.15829932e-03f, -1.76329687e-01f, 8.19004998e-02f, -1.13804735e-01f, 7.76190078e-03f, 2.42327731e-02f, -5.40073849e-02f, 3.46411765e-02f, -1.72208607e-01f, 1.77258193e-01f,
  5.41648343e-02f, -7.50333294e-02f, -2.10950919e-03f, 1.83688417e-01f, 2.89194375e-01f, 1.51836887e-01f, 2.14315236e-01f, -9.79657173e-02f, -1.53492726e-02f, 4.27429564e-02f,
  4.79068002e-03f, -1.06687397e-01f, -9.77048352e-02f, -1.12367077e-02f, 9.75106359e-02f, 6.24717325e-02f, 1.22845598e-01f, -2.62018982e-02f, 1.41376391e-01f, 1.32958382e-01f,
  1.56628080e-02f, 4.26004119e-02f, 1.47618830e-01f, 1.17189530e-03f, 5.28119765e-02f, 1.51714638e-01f, -7.76787922e-02f, -5.22891134e-02f, -1.26553208e-01f, -8.81723464e-02f,
  -2.25853384e-01f, -5.92465550e-02f, 2.08037674e-01f, 3.67244743e-02f, 1.01126567e-01f, -1.38405859e-01f, 1.84614152e-01f, 1.67631090e-01f, 1.63922459e-01f, -1.17320769e-01f,
  -8.69281292e-02f, -6.47152364e-02f, -1.63263921e-02f, -4.06577475e-02f, -3.75422165e-02f, -6.53940812e-03f, 1.42021790e-01f, 7.70123824e-02f, -1.28615096e-01f, 1.91053510e-01f,
  2.06531838e-01f, -1.60040841e-01f, 1.09298274e-01f, 7.44110122e-02f, 5.34885861e-02f, 2.27852762e-01f, -1.63099587e-01f, -6.63255602e-02f, 1.46070927e-01f, 9.20189992e-02f,
  5.63136525e-02f, -1.78607285e-01f, 2.43271381e-01f, -9.07814279e-02f, 7.54817724e-02f, 2.19031215e-01f, 2.15435252e-01f, -1.08751044e-01f, -1.39690489e-01f, -8.84574726e-02f,
  -3.12531292e-02f, -3.62983532e-02f, -4.14342247e-02f, -1.34270936e-01f, -8.49067867e-02f, 7.17850327e-02f, -5.29865734e-02f, 3.29949290e-01f, -1.73606139e-04f, -1.04187943e-01f,
  8.96561071e-02f, -3.23105277e-03f, 6.51270151e-02f, -5.69253415e-03f, 1.73784956e-01f, -7.63488049e-03f, 5.07590696e-02f, 9.41153318e-02f, 8.19244459e-02f, 1.30074501e-01f,
  -6.21809484e-03f, 7.91579932e-02f, -1.94551591e-02f, -2.07968369e-01f, 9.16369483e-02f, 2.06674486e-01f, 1.25516176e-01f, -1.69190280e-02f, 3.64784338e-02f, 8.70000049e-02f,
  1.63104936e-01f, -8.51950869e-02f, -2.01532487e-02f, -1.23786449e-01f, -7.23003149e-02f, 8.80868137e-02f, 5.25263101e-02f, 1.99518222e-02f, -1.76193826e-02f, 6.72495663e-02f,
  5.82255609e-02f, -6.55229539e-02f, -6.29265308e-02f, -5.22801802e-02f, -1.23577509e-02f, -7.61211514e-02f, 9.98989344e-02f, -1.10503823e-01f, 8.10545608e-02f, 1.49968281e-01f,
  2.93840412e-02f, -1.72133088e-01f, -1.05436258e-01f, 1.66205943e-01f, 3.28207418e-04f, 3.53131741e-02f, -8.82344395e-02f, 1.15044042e-01f, 1.67665079e-01f, -2.43082084e-02f,
  2.05591857e-01f, 1.16969422e-01f, 2.17772037e-01f, 4.01590019e-03f, 1.84201166e-01f, 5.98770417e-02f, -1.06813036e-01f, 1.11524381e-01f, -1.27641797e-01f, 6.78579286e-02f,
  -7.85301775e-02f, -7.06759244e-02f, 9.99873132e-02f, 1.54939070e-01f, 1.21349566e-01f, 5.10254242e-02f, 4.10842821e-02f, 1.71427950e-01f, -2.62308810e-02f, -1.66175365e-02f,
  -8.21409822e-02f, 3.75315845e-02f, 3.66320312e-02f, -4.17957231e-02f, 7.40532652e-02f, 1.80196445e-02f, 2.83087660e-02f, -7.57210776e-02f, 1.06797181e-01f, 1.00727104e-01f,
  1.20532610e-01f, -8.26341158e-04f, -6.32019639e-02f, 1.37234733e-01f, -4.07357551e-02f, -2.80449670e-02f, -4.59919572e-02f, -9.61963236e-02f, -9.98872817e-02f, 6.40996024e-02f,
  1.40253410e-01f, 9.72808078e-02f, -8.47365111e-02f, 7.08688125e-02f, -3.01342364e-02f, -4.30330113e-02f, 1.35593548e-01f, 9.03206021e-02f, -2.73817535e-02f, -9.33077186e-02f,
  4.81960885e-02f, -7.40363300e-02f, -5.45458272e-02f, -4.32942472e-02f, -1.18753625e-04f, -1.64034575e-01f, -5.23995198e-02f, 1.71931535e-02f, -8.66588205e-02f, 7.30636492e-02f,
  7.69943520e-02f, 1.07064493e-01f, 3.37331928e-02f, 1.16664708e-01f, 2.66147014e-02f, -9.74791683e-03f, 1.16591483e-01f, 1.15908630e-01f, 1.23274811e-02f, 5.51433638e-02f,
  -1.39231518e-01f, 1.17021292e-01f, -8.92714411e-02f, 3.13427821e-02f, -1.47445947e-01f, 7.28452951e-02f, -1.08446681e-03f, 1.21311776e-01f, 1.42970726e-01f, -3.62492800e-02f,
  1.24203756e-01f, 1.50870278e-01f, -6.03828393e-02f, -3.17993104e-01f, -3.39035206e-02f, -1.63511202e-01f, 4.06751335e-02f, -5.87329306e-02f, -4.43207733e-02f, -1.89579740e-01f,
  -2.09770530e-01f, 1.55306607e-01f, -2.05579355e-01f, -2.46249110e-01f, -3.79693545e-02f, 1.26627430e-01f, -1.78021669e-01f, -5.94094060e-02f, -5.84579222e-02f, 1.42459571e-01f,
  5.14162891e-02f, -3.31444815e-02f, 1.93753123e-01f, 1.26121730e-01f, 1.19031690e-01f, 2.28187338e-01f, 7.79705346e-02f, -9.41663887e-03f, 1.27199304e-03f, 2.58740902e-01f,
  2.20735744e-01f, 1.79340452e-01f, 1.21923044e-01f, 6.68147579e-02f, -2.92821210e-02f, 1.86224461e-01f, -5.46034575e-02f, 4.82176915e-02f, 8.84114653e-02f, 3.02503183e-02f,
  -2.62408350e-02f, 4.99488935e-02f, -1.60278697e-02f, 4.51606400e-02f, 8.25580135e-02f, -1.61341459e-01f, -1.16023079e-01f, 1.44617885e-01f, 9.01326537e-02f, -2.05059916e-01f,
  -2.41337731e-01f, 8.35550725e-02f, -1.24569669e-01f, -5.62096797e-02f, 9.51200724e-02f, -1.16776444e-01f, 1.55823112e-01f, -1.72263943e-02f, 3.17213386e-01f, 1.65323302e-01f,
  3.93912103e-03f, -9.74074751e-03f, -1.25044361e-01f, 7.58521259e-02f, 5.61050512e-03f, 3.08162486e-03f, 9.85606089e-02f, -6.22282326e-02f, 5.49567305e-02f, 1.26707852e-02f,
  -2.30576154e-02f, 6.96689785e-02f, -8.38091671e-02f, -4.62400764e-02f, 1.15650073e-02f, -1.11664180e-02f, 5.34161404e-02f, -1.43416122e-01f, -1.00569800e-01f, 3.12552415e-02f,
  -1.62109673e-01f, 1.08067468e-01f, 1.63928762e-01f, -2.06313759e-01f, -1.56587824e-01f, 4.86375056e-02f, -1.15846712e-02f, 1.82692558e-01f, 1.65489703e-01f, 1.58850104e-01f,
  -8.10442716e-02f, 9.07467529e-02f, 5.93322627e-02f, 2.41134509e-01f, 9.99169350e-02f, 2.89027449e-02f, 9.81755182e-02f, -6.51717857e-02f, -3.67029309e-02f, -7.06142932e-02f,
  1.40468493e-01f, 6.93176389e-02f, 1.44145954e-02f, -1.06383115e-01f, -1.44611627e-01f, 3.16564552e-02f, -1.37224391e-01f, 1.83276758e-01f, -2.11865097e-01f, 2.75438242e-02f,
  -6.60205707e-02f, 1.46425504e-03f, 1.60330147e-01f, 3.13554145e-02f, 2.10225791e-01f, 1.44973934e-01f, 1.09995067e-01f, -1.99563093e-02f, -2.32828185e-02f, 5.95636070e-02f,
  -6.01877552e-03f, 1.07389770e-01f, -3.54082808e-02f, -1.86880320e-01f, 5.36617227e-02f, 1.23534784e-01f, 2.66733408e-01f, 9.94254649e-02f, 6.56897053e-02f, 4.67880070e-02f,
  -1.59655660e-02f, -1.44930497e-01f, -1.45997200e-02f, -1.25351101e-01f, -1.23235106e-01f, -1.09587364e-01f, 6.83975816e-02f, -1.35856435e-01f, -1.72573954e-01f, 1.64178640e-01f,
  -9.31870639e-02f, -2.46498778e-01f, -5.90726733e-02f, 1.46179050e-01f, 2.33729836e-02f, -8.51960033e-02f, -8.71691555e-02f, 2.20115274e-01f, -3.71164754e-02f, 1.27182841e-01f,
  1.66751176e-01f, 6.27379119e-02f, 1.61654316e-02f, 1.84729636e-01f, 1.28298223e-01f, -3.19609232e-02f, -3.59456763e-02f, 1.46823987e-01f, 1.14413090e-01f, 9.11291763e-02f,
  -1.47639140e-01f, 1.14085585e-01f, 1.30226687e-02f, 4.37167287e-02f, -7.31344670e-02f, -1.51218787e-01f, 9.73736718e-02f, 1.68582037e-01f, 1.26753926e-01f, -1.58689529e-01f,
  9.67379436e-02f, 9.89495777e-03f, -8.77416041e-03f, -1.07900828e-01f, -1.80096850e-02f, 1.90840825e-01f, -2.78123263e-02f, -1.24249212e-01f, -1.94633901e-01f, -1.84533671e-02f,
  -2.89398748e-02f, 1.61880795e-02f, 1.98747382e-01f, -7.51828253e-02f, 2.49317914e-01f, -1.33920945e-02f, 2.33415559e-01f, 1.61716208e-01f, 4.02362980e-02f, -1.37013122e-01f,
  -1.93417415e-01f, 3.25884260e-02f, -1.23608351e-01f, -2.19426185e-01f, -1.22159813e-02f, 2.29575887e-01f, -8.17832013e-04f, 1.49345949e-01f, 8.47992301e-02f, 1.25971749e-01f,
  1.18399926e-01f, -8.18281621e-02f, -6.72368780e-02f, 2.07658321e-01f, -1.53409749e-01f, -1.37541398e-01f, 3.67103815e-02f, -5.40663786e-02f, 1.52362406e-01f, -3.44623439e-02f,
  -8.48580822e-02f, 2.72363186e-01f, 3.14953625e-02f, -7.95594677e-02f, 2.98904069e-02f, -1.21890254e-01f, -9.54374596e-02f, -7.29555190e-02f, 1.49892017e-01f, -7.84054697e-02f,
  -5.81469852e-03f, 1.10280499e-01f, -1.43437600e-02f, 5.61606213e-02f, 4.69337665e-02f, -6.59296140e-02f, -1.94478929e-01f, 7.81959072e-02f, -1.03090519e-04f, 9.43088811e-03f,
  2.40575951e-02f, 1.92419022e-01f, 2.71047086e-01f, -4.83753495e-02f, -1.21720873e-01f, -7.92443752e-02f, 1.64042115e-01f, 1.81652874e-01f, -1.23695537e-01f, 4.17035930e-02f,
  -1.10184237e-01f, 9.45986137e-02f, -6.14939928e-02f, 1.23473950e-01f, 2.73807980e-02f, -1.16333134e-01f, 1.13164768e-01f, -5.23229130e-02f, 1.56920612e-01f, -1.33298814e-01f,
  -4.06093970e-02f, 2.49633849e-01f, -3.21995392e-02f, -2.09564000e-01f, 1.24285825e-01f, -9.80948508e-02f, 9.61363539e-02f, -1.79488794e-03f, 5.36916293e-02f, -1.58940598e-01f,
  8.15332830e-02f, -2.36756019e-02f, -9.78711806e-03f, 3.00786477e-02f, -1.42400861e-01f, 1.63411111e-01f, -1.99186891e-01f, -2.20836699e-01f, -2.10757136e-01f, 1.03823923e-01f,
  2.77702063e-01f, -2.70767882e-02f, -6.28895238e-02f, 6.45228522e-03f, 2.37515122e-02f, 7.32522160e-02f, 6.32237867e-02f, -7.43200406e-02f, 1.38889730e-01f, 6.48461431e-02f,
  -2.71109678e-02f, 3.03017348e-02f, -8.21886361e-02f, 9.94901955e-02f, -2.43306309e-02f, 3.04563921e-02f, -2.99596647e-03f, 1.42981216e-01f, 3.05153310e-01f, -3.37516181e-02f,
  -3.70222852e-02f, 8.93758386e-02f, -2.65295412e-02f, 2.91530490e-01f, 1.92823112e-01f, -2.17280522e-01f, -2.75489334e-02f, 2.15621457e-01f, 1.10791579e-01f, -1.40021434e-02f,
  6.03423603e-02f, -1.24824472e-01f, 7.18986318e-02f, 9.86580998e-02f, -1.60982292e-02f, -6.49968386e-02f, -3.78323868e-02f, -6.37864545e-02f, 5.03058210e-02f, -4.85442355e-02f,
  -1.62067324e-01f, -1.82421684e-01f, 1.03784800e-01f, 1.01292819e-01f, 3.91923606e-01f, 1.37382939e-01f, -3.50688733e-02f, 6.91778362e-02f, -8.98323506e-02f, 9.55116749e-02f,
  -8.72087777e-02f, 1.83680579e-01f, 1.37615755e-01f, 1.83653370e-01f, 5.96138611e-02f, 4.85720336e-02f, 5.02402596e-02f, 3.53582739e-03f, 1.00422278e-01f, 5.36363646e-02f,
  9.33897942e-02f, -1.81214184e-01f, 1.41289949e-01f, 1.94455609e-01f, 1.15673013e-01f, 1.50825866e-02f, 1.24935135e-01f, -4.06286567e-02f, -6.96537122e-02f, -5.52344210e-02f,
  5.14661334e-02f, 1.15981896e-03f, 6.78105354e-02f, 7.29240999e-02f, 1.42519504e-01f, 4.81110737e-02f, 1.05936043e-01f, 1.04317367e-02f, -4.95797209e-02f, -1.91764042e-01f,
  7.63931051e-02f, 1.13386642e-02f, -5.99654950e-02f, 1.00392513e-01f, 1.38761550e-02f, -5.56011568e-04f, 5.56367785e-02f, -1.41320989e-01f, -3.39876302e-02f, -4.73247729e-02f,
  -5.68037964e-02f, -1.24857211e-02f, 3.51279005e-02f, -4.99804690e-02f, 8.02359805e-02f, 4.55205850e-02f, -2.61279102e-02f, 5.54284379e-02f, 1.08556347e-02f, 1.54631371e-02f,
  -8.69159102e-02f, -7.49672800e-02f, 2.67816894e-02f, 1.41222805e-01f, -7.15093836e-02f, 6.49195835e-02f, -1.01517551e-01f, 4.48767543e-02f, -1.36842802e-01f, -2.52303854e-02f,
  -1.96001213e-02f, 1.51996315e-03f, -1.53730497e-01f, 8.51898920e-03f, 6.93330467e-02f, 1.00936159e-01f, 1.57782380e-02f, 1.96215823e-01f, 6.07804582e-02f, 1.36787578e-01f,
  1.01961322e-01f, 1.05699584e-01f, 1.57502055e-01f, 1.25406429e-01f, 6.96145743e-02f, -9.55769494e-02f, 1.68247938e-01f, 2.01109171e-01f, 1.34964839e-01f, -5.98841496e-02f,
  2.54434556e-01f, 2.14100443e-02f, -1.36038691e-01f, 1.36941532e-02f, 4.99149635e-02f, -1.37983456e-01f, -1.58681825e-01f, 3.89138004e-03f, 1.14021637e-01f, -8.29518214e-02f,
  1.47251174e-01f, 5.65315671e-02f, 2.48137712e-02f, -2.47541860e-01f, -4.14373092e-02f, -3.26873772e-02f, -6.78255633e-02f, 2.18304582e-02f, -5.26978932e-02f, 7.61489272e-02f,
  -4.14209161e-03f, -5.81177957e-02f, 1.92383707e-01f, 5.35579026e-02f, 1.63298398e-01f, 1.22815415e-01f, -9.42686945e-02f, -6.83068112e-02f, -2.74116676e-02f, 2.63326198e-01f,
  5.60080037e-02f, 8.61933641e-03f, -7.96923861e-02f, 1.29919320e-01f, 5.08726714e-03f, 1.21572949e-01f, 2.27886841e-01f, 2.78755580e-03f, 3.67025733e-02f, -2.24957578e-02f,
  -5.28387502e-02f, -1.09353863e-01f, 1.27183041e-02f, -3.26926932e-02f, 1.24658234e-01f, -5.97091988e-02f, -6.55926913e-02f, 1.06812671e-01f, 6.92030564e-02f, 2.85031468e-01f,
  4.35099751e-02f, 5.98267205e-02f, 7.46227130e-02f, 1.25354126e-01f, 1.20448664e-01f, 4.95944247e-02f, 7.08622262e-02f, -7.51022669e-03f, 1.61848828e-01f, -2.07636878e-01f,
  1.13156930e-01f, 2.76894629e-01f, 5.78885563e-02f, 5.66621870e-02f, -5.33418581e-02f, 1.83236286e-01f, 1.78892419e-01f, -1.55148491e-01f, 2.97265463e-02f, -6.22848868e-02f,
  -2.94356551e-02f, 6.26326427e-02f, 1.40328318e-01f, 1.13876089e-01f, -1.28385246e-01f, 1.28620267e-01f, 1.33655608e-01f, -1.16008610e-01f, -3.75052504e-02f, -6.83679655e-02f,
  -7.41117597e-02f, 7.88780898e-02f, 1.27154440e-01f, -1.07149519e-01f, 6.08126745e-02f, 5.04635461e-02f, -7.22910017e-02f, -1.11154012e-01f, -6.30221963e-02f, 1.43945394e-02f,
  6.78023323e-02f, -3.68300565e-02f, -1.32064009e-02f, -6.09231330e-02f, 1.65771097e-01f, -1.89439841e-02f, 1.81606516e-01f, 2.15607882e-01f, 1.26456499e-01f, 1.27679810e-01f,
  1.65335789e-01f, 1.78057894e-01f, -1.50745213e-01f, 1.86828807e-01f, -1.07185610e-01f, 1.30681351e-01f, -2.18705520e-01f, -4.35791314e-02f, 2.70521864e-02f, 5.13231345e-02f,
  6.76140189e-02f, 1.63194165e-02f, 3.58289592e-02f, 1.39072791e-01f, -1.48741147e-02f, 2.10520029e-01f, -1.45984571e-02f, -8.59702122e-04f, -1.73661262e-02f, 3.67770088e-04f,
  2.40399346e-01f, -1.17560364e-01f, 1.32658388e-02f, 2.19358936e-01f, 8.26959535e-02f, -8.20809603e-02f, -3.39713506e-02f, 1.58326790e-01f, 1.79162592e-01f, 6.71495078e-03f,
  -1.35686293e-01f, 6.83668628e-02f, -3.14810276e-02f, 1.06488064e-01f, -9.69925448e-02f, 1.98187362e-02f, 7.36961979e-03f, -1.02494076e-01f, 1.45264432e-01f, -1.64868042e-01f,
  1.00028999e-01f, 6.31714314e-02f, -1.60710197e-02f, -8.78815129e-02f, -6.81949109e-02f, 1.06858844e-02f, -2.61959791e-01f, 2.21579701e-01f, 2.73211394e-03f, -1.12747364e-01f,
  1.44954965e-01f, 2.39270449e-01f, 1.78235993e-01f, 1.93289910e-02f, -1.68118536e-01f, -8.31382871e-02f, -1.38598964e-01f, 2.39254445e-01f, -3.78816761e-02f, -1.13976650e-01f,
  -5.82661219e-02f, 1.26925856e-01f, -1.29890293e-01f, 2.71466970e-01f, 1.32834524e-01f, -1.01360688e-02f, 1.84559524e-01f, -1.09788209e-01f, -2.68319044e-02f, -1.06397294e-01f,
  -1.27791893e-02f, -1.25088468e-01f, 2.18046904e-02f, -2.80973554e-01f, 7.72610959e-03f, 1.93675011e-02f, 1.22087501e-01f, 7.01514259e-02f, 4.94842939e-02f, 1.42132550e-01f,
  9.69517082e-02f, 1.64146200e-01f, 2.55012028e-02f, 8.44444633e-02f, -9.78405774e-02f, 3.33932508e-03f, 1.48377687e-01f, 9.24582258e-02f, 9.20528099e-02f, -1.93677358e-02f,
  -2.01036915e-01f, 1.24179766e-01f, -1.88450724e-01f, 5.35461307e-02f, 2.56121546e-01f, 3.22285220e-02f, 1.40460938e-01f, 5.88000081e-02f, 4.03401107e-02f, -2.07397148e-01f,
  -1.45773470e-01f, -1.85563207e-01f, -9.71896201e-02f, 1.26482667e-02f, 7.00058937e-02f, 9.32709947e-02f, -1.92891747e-01f, 9.36293602e-03f, -1.78518631e-02f, 1.18131801e-01f,
  6.99846745e-02f, -5.65651953e-02f, 3.88470031e-02f, 6.17545843e-02f, -1.19787820e-01f, -4.83841412e-02f, -1.13147579e-01f, -1.45510226e-01f, 2.44305003e-02f, 7.37823471e-02f,
  9.62225273e-02f, -1.10088550e-01f, 9.95494798e-02f, -4.96370122e-02f, 1.03365265e-01f, 1.48837075e-01f, 2.45871425e-01f, 7.94294998e-02f, 2.33744308e-02f, 8.13915282e-02f,
  3.76394391e-02f, 1.28538102e-01f, -1.13396853e-01f, 1.11449115e-01f, -1.47629082e-01f, 6.52817264e-02f, 1.05353959e-01f, 1.24759197e-01f, 2.38368288e-01f, 8.35382119e-02f,
  -7.13787898e-02f, -1.62396029e-01f, 9.23851691e-03f, -3.05856705e-01f, 1.08132157e-02f, -1.60910711e-02f, 8.73718858e-02f, -1.73946861e-02f, -1.88732758e-01f, -1.24055356e-01f,
  -8.63366202e-02f, 2.60674371e-03f, -1.80280223e-01f, -1.22243077e-01f, -1.78881675e-01f, -2.79116258e-03f, -1.93899035e-01f, 1.07196411e-02f, 2.83018738e-01f, -1.17667370e-01f,
  -1.42382383e-01f, -3.76080573e-02f, -1.43136472e-01f, 2.26141468e-01f, 1.75318152e-01f, 2.91190147e-01f, -7.54314438e-02f, 1.19865254e-01f, 1.52886987e-01f, 2.12232292e-01f,
  2.39257723e-01f, 9.85886231e-02f, 1.39159143e-01f, -7.72259906e-02f, 4.27573547e-02f, -3.20925936e-02f, 1.26520962e-01f, 1.55923262e-01f, -1.53126433e-01f, 3.68231046e-03f,
  -6.06750585e-02f, 3.98343392e-02f, -2.39593685e-02f, 4.74298708e-02f, -2.68164352e-02f, -8.06566179e-02f, 5.17180264e-02f, 1.42164201e-01f, 2.58192509e-01f, -2.37214509e-02f,
  -5.19773290e-02f, 8.22976604e-02f, -4.31761071e-02f, -5.60722463e-02f, 1.73764247e-02f, -1.13062840e-02f, -4.09226008e-02f, 8.07294548e-02f, -4.85750549e-02f, -1.42750487e-01f,
  6.28557801e-02f, 2.30707470e-02f, 5.42846397e-02f, -2.77170483e-02f, 7.73858950e-02f, -1.32597327e-01f, 6.14629723e-02f, 3.12627137e-01f, 1.17995508e-01f, 1.17823802e-01f,
  1.67746574e-01f, 1.49260029e-01f, -1.81129556e-02f, 8.45194682e-02f, -9.02058184e-02f, 1.48593426e-01f, -1.28183693e-01f, 6.54520169e-02f, 2.59257108e-01f, 2.94922851e-03f,
  1.58403724e-01f, -9.31223258e-02f, -6.15512393e-02f, 3.14498216e-01f, 8.04366618e-02f, 4.10950147e-02f, 2.88205557e-02f, -1.39169052e-01f, -2.40890728e-03f, -1.92268994e-02f,
  1.73976526e-01f, -7.08320364e-02f, -1.86616126e-02f, -2.23877523e-02f, -7.69014210e-02f, 1.25113726e-01f, 6.26118202e-03f, -3.17598060e-02f, -1.68780293e-02f, 1.59703478e-01f,
  4.20882404e-02f, -3.36788297e-02f, 7.42765889e-02f, 1.37975276e-01f, 2.58276701e-01f, 7.01669455e-02f, 1.75320327e-01f, -1.91357657e-02f, 2.48538196e-01f, 8.92190412e-02f,
  2.86769029e-02f, 1.22561745e-01f, -1.74936771e-01f, -7.80605897e-02f, -1.50335267e-01f, -1.39731899e-01f, 3.37642804e-02f, -2.00417470e-02f, 1.73678279e-01f, -4.74874862e-02f,
  7.05059618e-02f, -2.06606295e-02f, 1.64500609e-01f, 3.37193072e-01f, 8.92086253e-02f, -5.48801273e-02f, -1.30950764e-01f, 2.43060314e-03f, 3.27164843e-03f, 4.31657918e-02f,
  -3.20295580e-02f, 4.35590670e-02f, 3.35880332e-02f, 8.52480978e-02f, 2.19384283e-02f, -2.36321799e-02f, 1.47356600e-01f, -9.33212638e-02f, 5.97956330e-02f, 2.08591521e-01f,
  5.31995706e-02f, -1.81771308e-01f, -1.47269502e-01f, 1.70419842e-01f, 6.89218268e-02f, -2.18481086e-02f, -1.31378293e-01f, 2.00287756e-02f, 3.68270874e-02f, 2.74268746e-01f,
  5.52434996e-02f, -7.05123171e-02f, -8.19039941e-02f, -1.34665936e-01f, 1.01035349e-01f, -9.22167152e-02f, -3.94383408e-02f, 2.24466577e-01f, 2.46106219e-02f, 4.91694734e-03f,
  -1.45874336e-01f, 1.01347454e-01f, -8.96317139e-02f, 1.01292036e-01f, -1.31862899e-02f, -1.35755867e-01f, 6.96554184e-02f, 2.37829745e-01f, 1.60375033e-02f, -1.34910688e-01f,
  -5.70884310e-02f, 1.27848446e-01f, -2.68743727e-02f, 6.53932989e-02f, -1.52846843e-01f, -1.48299724e-01f, -1.81298181e-01f, 1.19992392e-02f, 1.73213065e-03f, 9.85275805e-02f,
  1.96590628e-02f, 2.33775936e-02f, 2.10934743e-01f, 1.17419600e-01f, 1.20656297e-01f, 1.53456815e-02f, -2.94318292e-02f, -9.44952816e-02f, 1.72275618e-01f, 7.46219531e-02f,
  5.02499305e-02f, 3.60160843e-02f, 3.62730809e-02f, -7.66389221e-02f, 1.66543528e-01f, 5.16549572e-02f, 1.28530040e-01f, 1.44234180e-01f, 1.02868848e-01f, 3.93702649e-02f,
  -4.07361649e-02f, -5.15515059e-02f, 1.05845511e-01f, -5.62207066e-02f, 4.18237261e-02f, 2.40766872e-02f, -5.77978455e-02f, 1.40199754e-02f, -5.19468635e-02f, 1.21844336e-01f,
  1.81138039e-01f, 1.62108429e-02f, 5.26904427e-02f, 7.43109882e-02f, 7.43541345e-02f, 1.04608610e-01f, 1.30736217e-01f, 1.70863256e-01f, -4.32839841e-02f, 1.18213445e-01f,
  1.17070533e-01f, -1.93405692e-02f, 1.55763939e-01f, 1.24446250e-01f, -6.61087185e-02f, 1.25869840e-01f, 1.39266968e-01f, -1.22193858e-01f, 6.60281703e-02f, -6.53565899e-02f,
  -1.51653722e-01f, -1.22485369e-01f, 1.78561322e-02f, -4.87266406e-02f, 1.72833055e-01f, -9.02580214e-04f, 1.37511164e-01f, -1.29763946e-01f, 1.19087793e-01f, 1.39808208e-01f,
  8.74071643e-02f, 1.17803499e-01f, 1.35106683e-01f, 1.32145986e-01f, -1.04910294e-02f, 1.04669400e-01f, -4.16169241e-02f, 1.81875765e-01f, 2.90741585e-02f, 1.31953895e-01f,
  -2.11725205e-01f, 2.94717681e-02f, -3.16083096e-02f, 6.79629669e-02f, 1.96711987e-01f, -4.16011587e-02f, 1.36944219e-01f, -1.48423254e-01f, -5.04889339e-02f, 3.30702543e-01f,
  3.22736381e-03f, 3.74885686e-02f, 4.38124985e-02f, 7.30113387e-02f, 9.61136967e-02f, -2.13970900e-01f, 1.85052752e-02f, 1.37508944e-01f, -1.75285172e-02f, -1.00664929e-01f,
  3.56496647e-02f, 4.30447049e-02f, 2.02747524e-01f, -4.12973240e-02f, 8.60992447e-02f, 6.47443756e-02f, 6.98807687e-02f, -1.63963344e-02f, -1.77455887e-01f, -1.02883220e-01f,
  -5.84531277e-02f, -1.31716311e-01f, 9.80902240e-02f, -3.90121788e-02f, 1.38825268e-01f, 2.32893322e-02f, -1.16915822e-01f, 8.70086551e-02f, 1.77389178e-02f, -2.51447558e-02f,
  -9.47305113e-02f, 1.76570877e-01f, -1.08792046e-02f, 1.11078963e-01f, -5.86737692e-02f, 1.81227073e-01f, 2.44486213e-01f, -4.02272046e-02f, -1.01574346e-01f, -1.58628553e-01f,
  8.41645226e-02f, 5.58024459e-02f, 8.77273604e-02f, 5.44168521e-03f, 1.18129395e-01f, 4.72317040e-02f, -1.23112448e-01f, 1.68345258e-01f, 7.26335794e-02f, 2.22325493e-02f,
  1.69143885e-01f, -5.44970706e-02f, -5.88935800e-02f, -6.20644651e-02f, -9.85055044e-02f, 4.23073173e-02f, 8.00346863e-03f, -2.15531752e-01f, 1.85207754e-01f, 1.68966632e-02f,
  6.22166283e-02f, -3.17829661e-02f, 7.24154487e-02f, 2.91158229e-01f, -4.13126592e-03f, 1.71975687e-01f, 8.15774426e-02f, 1.49005741e-01f, 1.69283569e-01f, -1.73837191e-03f,
  1.54747158e-01f, -7.64033124e-02f, 7.10017458e-02f, 3.07514161e-01f, 9.06977952e-02f, -9.45021138e-02f, 1.18795104e-01f, 7.37817362e-02f, -1.65828951e-02f, 9.99986976e-02f,
  9.48854238e-02f, 8.81380215e-02f, 1.43076926e-01f, -1.03689708e-01f, -6.53290823e-02f, -1.75193325e-01f, 8.46196152e-03f, 1.02560066e-01f, -9.38215777e-02f, -2.89993048e-01f,
  -2.17413791e-02f, 3.24867181e-02f, -1.80273160e-01f, 1.37954071e-01f, 9.01557580e-02f, -1.01184517e-01f, -4.93794978e-02f, -1.57504812e-01f, -1.37577821e-02f, 1.12502556e-02f,
  1.70823112e-01f, -3.40029858e-02f, 1.38877794e-01f, 1.24114603e-02f, 1.37149185e-01f, 1.08405888e-01f, 6.41683415e-02f, 8.16318318e-02f, -1.29254967e-01f, 1.45775720e-01f,
  8.99323672e-02f, 1.46164596e-01f, 1.28829613e-01f, 1.07572481e-01f, 6.26577511e-02f, 9.77953598e-02f, 9.35714319e-02f, 4.82504815e-02f, -1.09167034e-02f, 1.11066043e-01f,
  -2.38070358e-02f, 7.63194412e-02f, -1.00332797e-02f, -8.44263285e-02f, 6.01341762e-02f, 4.34200466e-02f, -6.60031626e-04f, -8.28206837e-02f, 3.82872485e-02f, -1.58332083e-02f,
  3.54026109e-02f, 2.40657404e-02f, -7.26918206e-02f, 1.49444817e-02f, -8.24020430e-02f, -8.25925842e-02f, -1.75179869e-01f, -8.32994953e-02f, 1.23375811e-01f, 1.22149855e-01f,
  -1.99180171e-02f, -4.91122901e-02f, -1.25269309e-01f, 1.76183656e-01f, 1.30336672e-01f, 1.58922419e-01f, 3.32334727e-01f, 1.27315335e-02f, -5.44704981e-02f, 3.79249081e-02f,
  1.17519781e-01f, -9.10098478e-03f, -1.29382506e-01f, 1.54505447e-02f, 1.13259107e-01f, 6.11417107e-02f, 1.01893023e-01f, 1.73382193e-01f, 3.76258604e-02f, 9.90869664e-03f,
  -8.85163546e-02f, -3.30358632e-02f, 2.40608444e-03f, 1.98605517e-03f, -1.10395132e-02f, 5.10627292e-02f, 2.26769403e-01f, 4.47799787e-02f, 1.97073951e-01f, -6.62555099e-02f,
  -2.61552744e-02f, 9.64833423e-02f, -1.09062210e-01f, -9.24172848e-02f, -1.12437300e-01f, -9.10816416e-02f, -1.12951554e-01f, 1.85115755e-01f, 7.47826695e-02f, 1.09369896e-01f,
  2.35907346e-01f, 1.31939843e-01f, 1.94107920e-01f, 1.90459713e-01f, -4.16966639e-02f, 5.15563712e-02f, -2.16123909e-01f, 6.22281097e-02f, -4.84778620e-02f, 1.74826675e-03f,
  1.41975693e-02f, 2.25198895e-01f, 1.87691953e-02f, 1.70705281e-02f, 3.87851298e-02f, 1.37278408e-01f, 1.29347637e-01f, -1.03431709e-01f, -5.33181131e-02f, 2.80052096e-01f,
  4.98868944e-03f, -1.87477499e-01f, -1.36944577e-01f, -1.52791262e-01f, 2.23638251e-01f, 7.32175708e-02f, 1.03155799e-01f, -1.45007893e-02f, -1.12387612e-01f, -6.49575284e-03f,
  -1.47441745e-01f, -1.04762623e-02f, -1.12262145e-01f, -3.05746198e-02f, 7.49386251e-02f, -3.56792919e-02f, 1.80410698e-01f, 1.64657488e-01f, 7.65224993e-02f, -2.97183283e-02f,
  -4.41655852e-02f, 3.70799527e-02f, -9.78293940e-02f, -2.46805083e-02f, 1.52657151e-01f, 5.41617759e-02f, 4.55102026e-02f, 1.77033916e-01f, 2.16658056e-01f, -5.88827953e-02f,
  -1.48175612e-01f, 3.22686434e-02f, -1.57994017e-01f, 1.83484852e-01f, -4.75725979e-02f, -1.27644315e-01f, 4.78143543e-02f, 1.07155658e-01f, 1.95253745e-01f, 3.60957563e-01f,
  8.30534101e-02f, -1.91803083e-01f, 1.77646279e-01f, 1.45564191e-02f, 7.57064149e-02f, -9.11094472e-02f, -1.50374636e-01f, -2.84291264e-02f, 4.50892411e-02f, 2.02023834e-02f,
  1.78407192e-01f, -5.35185523e-02f, 1.52975902e-01f, 8.16091225e-02f, 1.21080592e-01f, -1.81115150e-01f, 1.09681368e-01f, 3.34121659e-02f, -3.43762301e-02f, 2.15313770e-02f,
  -1.88189507e-01f, 7.52053857e-02f, -1.66262928e-02f, -1.44141570e-01f, -3.06327716e-02f, -4.70601674e-03f, 1.13435779e-02f, 7.13164285e-02f, -2.14879751e-01f, 9.29010659e-02f,
  2.14277580e-01f, -1.84290728e-03f, -9.91703290e-03f, 2.98498347e-02f, 2.44900912e-01f, -5.86718693e-03f, 1.53334767e-01f, 2.16364175e-01f, -1.02047808e-01f, 1.37331903e-01f,
  -7.72171328e-03f, 1.89502150e-01f, 1.26414627e-01f, 3.92518118e-02f, 9.92525592e-02f, 1.34018973e-01f, 1.44486248e-01f, -1.15483040e-02f, 5.67215979e-02f, 7.58622065e-02f,
  1.12912664e-02f, -1.42252252e-01f, -1.49844110e-01f, -3.19850147e-02f, 1.24508888e-01f, 1.55642942e-01f, 1.21051736e-01f, -2.45366901e-01f, 2.31594890e-02f, 1.49003923e-01f,
  1.46249488e-01f, -6.52759671e-02f, 1.71803981e-01f, -4.81463969e-02f, 6.03708578e-03f, 5.41054904e-02f, -2.29655989e-02f, 1.59991622e-01f, 2.41648573e-02f, 2.44042307e-01f,
  1.38928354e-01f, 3.48976441e-02f, -1.88989509e-02f, 2.38660455e-01f, 2.42980337e-03f, 9.51778442e-02f, -8.13875943e-02f, -6.60774782e-02f, 1.16488449e-01f, -3.89655232e-02f,
  1.14426799e-02f, 4.79139872e-02f, 1.03768840e-01f, 1.16205260e-01f, -1.68442190e-01f, 3.65826860e-02f, -1.60420351e-02f, -2.42120072e-01f, 2.48868037e-02f, 1.78502038e-01f,
  1.71738565e-01f, 3.50031704e-02f, 8.79120454e-02f, -1.46054393e-02f, 2.14078054e-01f, -5.92275411e-02f, 6.55978918e-02f, -2.38788754e-01f, -2.48743355e-01f, 2.69764327e-02f,
  2.87238397e-02f, 6.99900538e-02f, -9.58421975e-02f, 1.12874381e-01f, 1.73317164e-01f, 1.26196817e-01f, -1.30879849e-01f, 2.83762580e-03f, 1.86713800e-01f, -1.82905421e-01f,
  1.03648894e-01f, 8.71574730e-02f, 1.42198578e-01f, 1.86502427e-01f, 3.08432598e-02f, -8.99388418e-02f, -5.37365153e-02f, 1.48517281e-01f, -7.48237669e-02f, 2.29307842e-02f,
  8.03871676e-02f, -1.38537154e-01f, 2.07836449e-01f, 1.50494039e-01f, 1.98734239e-01f, 3.91699597e-02f, 1.73458233e-01f, -9.27517340e-02f, 1.04505606e-01f, 5.25333546e-02f,
  -1.31604895e-01f, -6.56194165e-02f, -1.64067730e-01f, 3.68666016e-02f, -9.64614078e-02f, 7.19938725e-02f, 1.00948840e-01f, 5.12254946e-02f, 7.54074901e-02f, 1.49029240e-01f,
  -8.37848857e-02f, 1.31457299e-01f, 6.74800426e-02f, 5.50239645e-02f, 8.65221471e-02f, -4.46005352e-03f, 9.04557630e-02f, -1.79367606e-02f, -7.37431273e-02f, 1.39384478e-01f,
  -8.58066604e-02f, -2.01067910e-01f, -9.70911086e-02f, 1.55095920e-01f, 2.54307866e-01f, -2.77377740e-02f, 4.19971235e-02f, -1.42265901e-01f, 2.94366442e-02f, -1.40854701e-01f,
  -8.90471041e-02f, -2.46698052e-01f, -1.51948527e-01f, 1.29524857e-01f, 3.46275456e-02f, -1.57570429e-02f, -2.29150392e-02f, -2.95961252e-03f, 1.51279196e-01f, 8.88688490e-02f,
  -1.50877172e-02f, 1.20160002e-02f, 1.51259869e-01f, -1.57645926e-01f, -3.70099470e-02f, 7.61568323e-02f, 1.02695018e-01f, 2.31935367e-01f, 7.50592202e-02f, -6.88684732e-02f,
  -1.14729283e-02f, 2.41612464e-01f, -1.20974936e-01f, -7.17592165e-02f, -1.04079954e-01f, 1.36331245e-01f, 1.69237673e-01f, 3.15677449e-02f, 1.08882494e-01f, -4.60505784e-02f,
  -5.07888049e-02f, 1.11955474e-03f, 1.74716786e-01f, -7.64943361e-02f, -1.66918144e-01f, -1.40223548e-01f, -1.10991091e-01f, -7.65080899e-02f, 6.04993030e-02f, -1.08624436e-01f,
  -8.80922750e-03f, 7.59768859e-02f, -1.02747239e-01f, 6.84527606e-02f, 6.30596280e-02f, 3.13732117e-01f, -9.72684100e-03f, 9.19411890e-03f, 4.97165136e-02f, 3.60769257e-02f,
  1.16936147e-01f, -3.49533604e-03f, -1.09506130e-01f, -1.38073293e-02f, -1.39672160e-01f, 3.42091583e-02f, -1.66676134e-01f, -4.04035188e-02f, 1.50427744e-01f, -2.14212462e-02f,
  3.31235714e-02f, 3.15853246e-02f, 9.73217282e-03f, 3.22529227e-01f, 1.88813269e-01f, 1.80002823e-02f, 2.70713627e-01f, -1.65120214e-02f, -3.91108803e-02f, 3.28978933e-02f,
  -4.89180489e-03f, 1.57669708e-02f, -1.46145970e-01f, -1.42353877e-01f, 1.46623328e-01f, 2.15087578e-01f, 5.60041852e-02f, 9.97306481e-02f, 1.09255940e-01f, -8.89188237e-03f,
  3.41455303e-02f, -4.78566885e-02f, -9.79630351e-02f, 6.10657632e-02f, 1.34893149e-01f, -7.50301555e-02f, 1.02638893e-01f, -5.85955754e-02f, 3.14070553e-01f, -7.41986781e-02f,
  1.57584026e-02f, 2.80701578e-01f, -7.71019384e-02f, -1.48721933e-01f, -1.77455038e-01f, -6.25609457e-02f, -1.44318119e-01f, 4.07967307e-02f, 9.98521224e-02f, 8.02645832e-02f,
  1.68230787e-01f, 1.45572230e-01f, 4.04016674e-02f, 3.42492431e-01f, -1.22255303e-01f, -3.10426317e-02f, -2.17894033e-01f, -2.12619416e-02f, 9.56111178e-02f, -6.79889545e-02f,
  3.39463986e-02f, -4.81747277e-02f, -8.18413566e-04f, -2.56294217e-02f, 3.06019187e-02f, 4.20670286e-02f, 1.27693098e-02f, -2.93191940e-01f, -1.39600560e-01f, 9.93837416e-02f,
  -8.52924809e-02f, -1.54973462e-01f, -3.14785503e-02f, 5.47041185e-02f, 1.31998509e-01f, -6.12889417e-02f, 1.10934161e-01f, 1.26049429e-01f, -4.50341552e-02f, 1.31731397e-02f,
  -4.39689681e-02f, 1.79086775e-01f, 1.37693748e-01f, 1.90027326e-01f, 6.86072856e-02f, -1.65797584e-02f, 1.91743389e-01f, 1.48328453e-01f, 1.56916261e-01f, 5.46507873e-02f,
  1.77793103e-04f, -4.37739231e-02f, 4.90221567e-03f, 1.75184444e-01f, 8.22112560e-02f, 2.20282748e-02f, -5.68808615e-02f, 1.47065297e-01f, 8.75321329e-02f, 3.76731120e-02f,
  -9.51926559e-02f, -8.43917653e-02f, 1.62793149e-03f, -3.46481055e-02f, 5.46756461e-02f, 1.69837520e-01f, 1.85207278e-01f, -5.21689691e-02f, -2.00050771e-01f, 9.54567194e-02f,
  -3.96579504e-02f, 9.83646885e-03f, 1.87587515e-01f, -5.89166805e-02f, -6.05491914e-05f, 2.48432830e-02f, -5.85408211e-02f, -2.23121773e-02f, 9.07219201e-02f, -1.59321398e-01f,
  -7.91892558e-02f, -2.37560365e-02f, 3.59557457e-02f, -1.40486181e-01f, 9.52722579e-02f, 2.25431964e-01f, 1.10426642e-01f, 6.47789389e-02f, 1.40222386e-01f, 1.10603996e-01f,
  1.05599180e-01f, -6.21174276e-02f, 1.15045540e-01f, -1.01013714e-02f, 4.87432368e-02f, 6.32006004e-02f, -3.76894586e-02f, 4.83791158e-02f, 3.06062289e-02f, 6.52524605e-02f,
  -6.40797168e-02f, 5.36540970e-02f, 1.07304648e-01f, 1.49954811e-01f, 2.88524657e-01f, -1.33027345e-01f, -1.76637009e-01f, -1.23355538e-01f, 1.22158580e-01f, -4.69061136e-02f,
  -8.60078707e-02f, -1.73878551e-01f, -5.57967797e-02f, 9.92162004e-02f, -5.64996749e-02f, 1.85133681e-01f, 2.55912971e-02f, -1.49915069e-01f, -2.96400785e-02f, -5.67898154e-02f,
  -1.60157070e-01f, 6.89939037e-02f, 8.50808620e-02f, -4.70030978e-02f, 1.94580212e-01f, -4.78001684e-02f, 1.05495945e-01f, 5.10955937e-02f, -1.50708869e-01f, -5.28032966e-02f,
  -1.18583448e-01f, 1.69190392e-01f, -1.29982129e-01f, 8.42824876e-02f, -1.01491377e-01f, 1.27009496e-01f, 9.05035883e-02f, 7.22786859e-02f, 1.45215139e-01f, 1.22561529e-01f,
  -1.34203106e-01f, 3.11798118e-02f, -1.62202045e-01f, -1.24449786e-02f, -4.96921390e-02f, -2.38281656e-02f, 1.59701481e-01f, -7.70096257e-02f, 1.31861388e-03f, -5.97406700e-02f,
  4.23785439e-03f, -3.27417850e-02f, -1.86501036e-03f, 4.22306620e-02f, -1.10936627e-01f, -6.95898831e-02f, -5.17786406e-02f, -9.13410857e-02f, -1.24655634e-01f, 1.18358992e-01f,
  3.27949077e-01f, -5.18376976e-02f, 8.72450471e-02f, -9.65872705e-02f, 1.05568700e-01f, 7.44240209e-02f, 5.59689738e-02f, -1.88411206e-01f, -1.13583960e-01f, -1.74941812e-02f,
  1.33821862e-02f, 2.84849647e-02f, -4.19498608e-02f, -4.04593237e-02f, 1.41180903e-01f, 4.60884906e-02f, -1.15820892e-01f, 1.37913913e-01f, 3.01821768e-01f, -2.04358473e-01f,
  3.31810117e-02f, 9.06598344e-02f, -3.08867847e-03f, 2.35858902e-01f, 2.49737967e-02f, -1.04260921e-01f, -3.10171134e-04f, 1.32406890e-01f, -2.44763494e-02f, -9.34867561e-02f,
  1.32178426e-01f, -1.47534132e-01f, 1.78164944e-01f, 1.69587031e-01f, 8.81303921e-02f, -7.32676610e-02f, -2.09421199e-02f, -1.62147984e-01f, -7.31796250e-02f, 1.13869049e-02f,
  -1.13534942e-01f, -1.54957354e-01f, -1.37624428e-01f, 6.89748153e-02f, -7.63351843e-02f, 2.23393604e-01f, 3.66392508e-02f, -2.72999424e-02f, -1.45333344e-02f, 2.14225128e-02f,
  9.55242962e-02f, 7.51656294e-02f, -4.85235918e-03f, 3.97762954e-02f, -4.73889336e-03f, 4.32127528e-02f, -7.75348023e-02f, -9.41135548e-03f, 1.15246065e-01f, -8.64198431e-02f,
  1.11671805e-01f, 1.52147710e-01f, 1.27490118e-01f, -1.88910663e-01f, -8.50315541e-02f, 1.38328031e-01f, -1.30230576e-01f, 7.01212659e-02f, -5.56613281e-02f, -1.12900533e-01f,
  -6.40580207e-02f, 1.34191170e-01f, -1.45512685e-01f, -7.89831430e-02f, -9.37750489e-02f, -1.49759784e-01f, -7.66588971e-02f, 6.12311438e-02f, -9.96471047e-02f, 2.04124033e-01f,
  -2.25605723e-02f, -2.96930037e-02f, -1.37386411e-01f, -3.00157610e-02f, -5.72549328e-02f, 6.32872730e-02f, -6.10457845e-02f, -1.45238757e-01f, 7.87213072e-02f, 3.88327874e-02f,
  1.94919221e-02f, -7.22865462e-02f, -1.47041976e-01f, 1.80455923e-01f, -1.51209638e-01f, 1.77635774e-02f, -1.46839917e-01f, -1.74485341e-01f, -9.10927355e-02f, 2.50362288e-02f,
  4.47720587e-02f, 1.96849287e-01f, 1.27324343e-01f, 1.99642889e-02f, -3.88674461e-03f, -4.66327043e-03f, -6.47986978e-02f, -6.87838644e-02f, -4.05727476e-02f, -1.33819014e-01f,
  1.71421126e-01f, 1.74937382e-01f, 1.39676839e-01f, 1.15664825e-01f, 4.20375578e-02f, -5.70120774e-02f, 1.01718076e-01f, -7.81306028e-02f, -4.53886837e-02f, 8.64772312e-03f,
  -3.55138094e-03f, 4.08632793e-02f, 1.22597985e-01f, 7.92238638e-02f, 3.89942341e-02f, -2.08992392e-01f, 2.52174847e-02f, 2.22354338e-01f, 2.36507282e-01f, 7.16739073e-02f,
  1.10407732e-01f, -9.90983099e-02f, -1.82166576e-01f, -1.20701693e-01f, -5.54411002e-02f, -1.74654678e-01f, -1.24113090e-01f, 5.38757034e-02f, 9.99685749e-02f, 4.23792237e-03f,
  1.14196159e-01f, 5.76386079e-02f, -3.10551617e-02f, -1.78077132e-01f, -7.69678131e-02f, -1.50404811e-01f, 5.81164612e-03f, -3.64054181e-02f, -4.49593551e-02f, 1.30439088e-01f,
  7.25442246e-02f, -3.95889673e-03f, 1.99918926e-01f, -2.60798801e-02f, 4.10019122e-02f, 1.37323424e-01f, -7.80881271e-02f, 3.79247926e-02f, -2.29470387e-01f, -9.95404646e-03f,
  7.41280839e-02f, -5.69555163e-02f, -4.60568219e-02f, -1.87643040e-02f, -3.10478173e-02f, -1.59426853e-01f, 1.64236113e-01f, 5.66050857e-02f, -8.53609294e-02f, -2.48340610e-02f,
  -1.39161900e-01f, -6.99551404e-02f, 1.38693079e-01f, -9.57887694e-02f, 1.70927271e-01f, -5.80726080e-02f, -2.16975808e-01f, 1.13994285e-01f, -8.70004073e-02f, 2.30977997e-01f,
  7.13655353e-03f, 3.48955058e-02f, 6.79912185e-03f, 2.61154282e-03f, 5.60185388e-02f, 1.25896692e-01f, 6.47746995e-02f, 1.89437851e-01f, -6.58317730e-02f, -1.27796903e-01f,
  5.06615900e-02f, 2.00016722e-01f, 2.89776146e-01f, -2.98308544e-02f, 1.03525639e-01f, -5.93789620e-03f, -1.22390077e-01f, 1.19105868e-01f, 7.16876611e-02f, -1.89942718e-01f,
  -7.32888952e-02f, -7.06890598e-02f, 6.16894364e-02f, -1.19268410e-01f, 5.75355589e-02f, 1.05564892e-01f, -1.50234029e-01f, -7.74596408e-02f, -1.03032053e-01f, 3.14940512e-02f,
  1.47325531e-01f, -8.43533128e-02f, -9.69829336e-02f, 1.70903698e-01f, 2.24161278e-02f, 2.98528504e-02f, 2.74641246e-01f, 2.68125650e-03f, 7.35901073e-02f, 1.52452052e-01f,
  3.56399007e-02f, 8.71508569e-02f, 1.07082866e-01f, 8.74802470e-02f, 3.61888087e-03f, 8.34774747e-02f, -1.08652614e-01f, -9.18533951e-02f, 5.95240220e-02f, -1.15391791e-01f,
  1.17609091e-01f, 2.55124923e-02f, 2.48252936e-02f, -1.09873392e-01f, 2.28176806e-02f, -9.57334065e-04f, 2.86358774e-01f, 1.94440529e-01f, 1.36698410e-01f, 1.56161994e-01f,
  -3.34667452e-02f, 1.62559137e-01f, -4.37928624e-02f, 2.01249570e-01f, -1.63817313e-02f, -7.95110986e-02f, 1.41302748e-02f, -3.38647105e-02f, 3.82061303e-03f, -6.08336553e-02f,
  4.37614396e-02f, -8.42146575e-02f, -8.47459286e-02f, 1.00512743e-01f, -8.22098181e-02f, -1.75868675e-01f, 2.31519975e-02f, 1.89108178e-01f, 5.09673618e-02f, -1.55433849e-01f,
  -1.08203813e-01f, 5.24637699e-02f, -5.51292254e-03f, 1.26033276e-01f, 3.51236239e-02f, 9.95736793e-02f, 9.69505981e-02f, 3.48052830e-02f, 1.76288813e-01f, -1.05437510e-01f,
  1.60813946e-02f, 2.22503796e-01f, 1.06280237e-01f, -2.13108324e-02f, 7.38978609e-02f, 2.36921795e-02f, -9.21921879e-02f, 1.65044516e-01f, 1.85298789e-02f, 2.27254815e-03f,
  1.89014211e-01f, 2.38215134e-01f, 5.52298203e-02f, 9.20793861e-02f, -1.09940842e-01f, 3.82041931e-02f, -6.00754879e-02f, 8.04642290e-02f, -1.24526009e-01f, 2.31445692e-02f,
  -6.81279674e-02f, -4.65519726e-02f, -1.80056021e-01f, -1.68504044e-02f, -2.47983932e-02f, -5.06685637e-02f, 1.94965184e-01f, -7.37609640e-02f, 1.86839983e-01f, -6.33846689e-03f,
  2.68018514e-01f, -2.28921007e-02f, 1.61597654e-01f, -8.64949226e-02f, -1.84695855e-01f, 6.22879751e-02f, -3.87504958e-02f, 6.47357255e-02f, -3.56445871e-02f, 6.21281117e-02f,
  5.17774075e-02f, -1.51454629e-02f, 8.49465001e-03f, -3.23823355e-02f, 7.71988630e-02f, -1.19074330e-01f, -9.38458648e-03f, 2.40564436e-01f, 1.13860779e-01f, -2.63463676e-01f,
  -2.53565371e-01f, -5.74749932e-02f, -8.23083073e-02f, 1.59668788e-01f, -5.77365384e-02f, -5.21672294e-02f, -4.79485840e-02f, 9.69825462e-02f, -1.42669324e-02f, -6.76128268e-02f,
  -1.55207768e-01f, -1.44799978e-01f, -4.45603803e-02f, -1.45068141e-02f, -2.00877525e-02f, 1.30677357e-01f, 3.76589447e-02f, 1.84744056e-02f, -1.29032612e-01f, 3.21158171e-02f,
  -6.86345771e-02f, -1.89272519e-02f, 3.87096666e-02f, -1.62874937e-01f, -2.24047545e-02f, 9.03893169e-03f, -1.89836882e-02f, -1.33836851e-01f, -8.59540999e-02f, 1.12142645e-01f,
  -4.65206467e-02f, 1.44771323e-01f, -1.57553792e-01f, -1.74761698e-01f, -3.52083929e-02f, 3.73534821e-02f, 2.36310795e-01f, 2.86386549e-01f, 7.59232193e-02f, -1.25978708e-01f,
  6.39107600e-02f, 7.98106641e-02f, 5.68021741e-03f, -1.05215371e-01f, -9.74699259e-02f, -9.79914740e-02f, -2.48211063e-02f, 2.65605021e-02f, 2.81933755e-01f, 3.05052269e-02f,
  1.76187947e-01f, -9.56967026e-02f, 4.09031324e-02f, 1.96157962e-01f, 7.62755647e-02f, 1.49991885e-01f, 1.83499247e-01f, -1.46827372e-02f, 5.17655015e-02f, -1.50415316e-01f,
  -1.15665756e-01f, 4.91225384e-02f, -4.57922779e-02f, -5.25624752e-02f, 7.39290044e-02f, -8.86919871e-02f, 1.47366643e-01f, -3.85868214e-02f, 3.67376693e-02f, -1.81949362e-02f,
  -6.81175590e-02f, -1.61228836e-01f, -1.85452983e-01f, 4.20168675e-02f, -4.07782942e-02f, -9.65833664e-02f, 1.09531298e-01f, -1.24987185e-01f, 2.36126319e-01f, 1.03012465e-01f,
  -1.00391649e-01f, 2.18115021e-02f, 4.02966216e-02f, -1.53381648e-02f, -1.87455177e-01f, 5.23510873e-02f, 1.30785882e-01f, 1.32500812e-01f, -8.17409158e-02f, 8.80193114e-02f,
  2.00667903e-01f, 9.44087356e-02f, -8.51710364e-02f, -2.83964783e-01f, -6.30045682e-02f, 1.61151305e-01f, 1.51994184e-01f, -1.51711956e-01f, 4.14092243e-02f, 1.12875335e-01f,
  -9.28305387e-02f, 1.87308699e-01f, 7.96997845e-02f, -1.49878487e-01f, 6.90237656e-02f, -1.92463383e-01f, -2.33720709e-02f, -1.17717609e-01f, -4.83012944e-02f, 4.12399359e-02f,
  1.47155393e-02f, -3.26072544e-01f, 2.01702476e-01f, -6.99600950e-02f, 9.54136848e-02f, 9.19580385e-02f, -4.04138416e-02f, -1.83504224e-02f, 5.24195842e-02f, -5.51289804e-02f,
  1.36272639e-01f, 1.52256310e-01f, -1.25592425e-01f, -1.84783444e-01f, -2.18429238e-01f, 1.76571324e-01f, -2.16176361e-01f, -2.24012375e-01f, 8.98558795e-02f, -6.77547827e-02f,
  5.79342209e-02f, -3.87355611e-02f, 1.19819976e-01f, 1.47446200e-01f, 8.60460326e-02f, -1.48914801e-02f, 7.42077902e-02f, 1.58933803e-01f, 8.81946739e-03f, 1.55965775e-01f,
  1.19330168e-01f, -4.89571542e-02f, 1.86214000e-01f, 2.34421596e-01f, 1.92953840e-01f, 1.99129909e-01f, 2.05938816e-01f, -8.48336518e-02f, 4.97906059e-02f, 7.58515000e-02f,
  1.77318960e-01f, 1.91081062e-01f, -8.72217678e-03f, 1.42754748e-01f, 1.40093431e-01f, 6.64465055e-02f, 9.29210335e-03f, -6.96146190e-02f, 8.64360258e-02f, 7.46801794e-02f,
  6.50955588e-02f, 1.10957563e-01f, 8.92770439e-02f, -9.00923908e-02f, -7.72786587e-02f, 1.03399314e-01f, -4.81220335e-02f, -8.00656527e-02f, 6.30241632e-02f, -2.86239628e-02f,
  1.59897551e-01f, -1.95317566e-02f, -1.00338617e-02f, 1.05244830e-01f, 6.18521944e-02f, -1.73007865e-02f, 8.42137113e-02f, -5.25592454e-02f, 2.01448470e-01f, -1.57139860e-02f,
  -4.31885459e-02f, 5.51486500e-02f, 5.60249649e-02f, -2.50679310e-02f, -7.39064068e-02f, 5.12176305e-02f, 8.10745060e-02f, -1.45930901e-01f, 1.05233029e-01f, 2.31434464e-01f,
  9.83509868e-02f, -2.96278030e-01f, -2.20525071e-01f, 1.97643071e-01f, -2.73761507e-02f, 7.85645843e-02f, -5.28026186e-02f, -3.13394293e-02f, -7.53218234e-02f, 2.27183044e-01f,
  -1.73384957e-02f, -3.81213613e-02f, -6.89035133e-02f, -1.07418865e-01f, 3.28565104e-04f, -5.23972586e-02f, -5.45887947e-02f, 1.80517673e-01f, -3.33797522e-02f, -5.47647476e-03f,
  -1.29425660e-01f, 1.21849431e-02f, -2.82463357e-02f, 8.94512758e-02f, -8.85858685e-02f, -1.30287036e-01f, 1.29439503e-01f, 8.72781500e-02f, 3.54791842e-02f, -1.59576222e-01f,
  -2.57829130e-02f, 1.22537576e-01f, -2.46125497e-02f, 1.71046555e-02f, -1.75347567e-01f, -1.89173341e-01f, -7.47496411e-02f, 7.10710511e-02f, 1.10686690e-01f, 1.24376327e-01f,
  3.81543301e-02f, 3.48618366e-02f, 1.45601064e-01f, 4.87774536e-02f, 8.10363423e-03f, -5.35528213e-02f, -1.25591941e-02f, -9.87629369e-02f, 8.24701786e-02f, 2.96356492e-02f,
  5.59333637e-02f, 6.66398332e-02f, 9.47076753e-02f, -9.61968824e-02f, 3.15970853e-02f, -2.63782531e-01f, -8.07263926e-02f, -3.05552557e-02f, -7.63527676e-02f, -5.04656285e-02f,
  -8.85961056e-02f, 1.38120428e-01f, 3.89640965e-02f, -2.82341633e-02f, 8.28675926e-02f, -8.84258971e-02f, -1.17567375e-01f, 3.05090658e-02f, -1.26816079e-01f, 2.42426544e-02f,
  -8.65565836e-02f, -2.09752887e-01f, -1.40930921e-01f, 7.79796019e-02f, 2.87409183e-02f, 2.39010766e-01f, 2.12778032e-01f, 1.26274675e-01f, -8.98867473e-02f, 5.52345663e-02f,
  -1.10985063e-01f, 1.92176953e-01f, 2.60448724e-01f, 5.77957332e-02f, 1.70887411e-02f, 8.20271298e-03f, 6.84208199e-02f, -1.97384153e-02f, -3.48994732e-02f, 2.74080113e-02f,
  2.25512818e-01f, -3.59082274e-04f, -2.19289839e-01f, 1.41148180e-01f, -4.43663560e-02f, 2.97493547e-01f, -1.18507423e-01f, 2.46634167e-02f, -7.36607388e-02f, 7.17505291e-02f,
  -7.48120062e-03f, -1.01653725e-01f, 1.49139926e-01f, -1.60114653e-02f, -7.38306269e-02f, 5.19965962e-03f, -1.08836338e-01f, 1.55604288e-01f, 7.49791786e-02f, 7.75076598e-02f,
  1.04413576e-01f, -2.93373764e-01f, 6.51684999e-02f, 2.60006905e-01f, 6.47198260e-02f, 1.19832776e-01f, -1.19479876e-02f, 1.33707821e-01f, 5.15187532e-02f, 3.09696317e-01f,
  1.22269757e-01f, 1.20876707e-01f, 5.10778390e-02f, 1.57393098e-01f, -4.72506396e-02f, -2.06901103e-01f, -4.95680161e-02f, 2.38638625e-01f, -2.43744105e-02f, 2.95984894e-02f,
  -4.79032993e-02f, -1.07443415e-01f, 5.12083285e-02f, 8.73972178e-02f, 3.13980073e-01f, 5.35772704e-02f, 5.75067140e-02f, -2.40656435e-02f, -1.07535467e-01f, -1.58738360e-01f,
  -1.99587181e-01f, -1.31787181e-01f, -4.36590128e-02f, 2.82633342e-02f, 2.05035135e-01f, 7.25328252e-02f, -7.86460638e-02f, 1.32801265e-01f, 3.22369598e-02f, 9.25466605e-03f,
  -3.26067419e-03f, 6.97385706e-03f, 1.51585832e-01f, 1.14142783e-01f, -1.55978471e-01f, 6.86696097e-02f, 2.51363158e-01f, 2.23120619e-02f, 8.80682170e-02f, -1.54195398e-01f,
  1.91691548e-01f, 6.06824942e-02f, 7.93901831e-02f, -5.53198233e-02f, 1.73023462e-01f, 1.12441286e-01f, 1.29885048e-01f, 2.80312538e-01f, 1.23987995e-01f, -7.06876367e-02f,
  4.79566157e-02f, -2.70852894e-02f, -6.98206350e-02f, -4.41418141e-02f, -3.30418736e-01f, 1.85067952e-01f, -1.20360591e-01f, -5.78870401e-02f, 3.19922745e-01f, -1.67781562e-01f,
  2.38270149e-01f, -9.35786404e-03f, 1.28942043e-01f, -2.18652822e-02f, 1.07102588e-01f, 8.33032280e-02f, 6.82524294e-02f, 2.04046443e-02f, 3.42792878e-03f, 2.15976968e-01f,
  -9.01739579e-03f, -2.39385083e-01f, 1.09094627e-01f, 2.30025709e-01f, 2.22034335e-01f, -3.51565629e-02f, 1.17373779e-01f, 1.95127856e-02f, -8.93901214e-02f, -1.17898643e-01f,
  -3.07181589e-02f, -2.34450102e-01f, -1.51932880e-01f, 6.48516640e-02f, 1.38189524e-01f, -1.06377125e-01f, 7.66539201e-02f, 6.30832687e-02f, -2.20155101e-02f, 1.89156160e-02f,
  -7.58153871e-02f, -1.14826225e-01f, 1.93826884e-01f, -8.99531394e-02f, -8.56114030e-02f, 1.64772626e-02f, 6.30735382e-02f, 1.93966076e-01f, 2.30720192e-01f, -5.71733527e-02f,
  -2.75468696e-02f, 2.67926097e-01f, -8.03903118e-02f, 6.08286262e-03f, -1.56639189e-01f, 1.73111454e-01f, 1.50928214e-01f, -6.50264397e-02f, -3.56023088e-02f, -4.62683570e-03f,
  1.22354403e-01f, -7.63670206e-02f, 2.26082563e-01f, -2.21660361e-02f, -1.81307271e-01f, -1.08834244e-01f, -5.37927635e-02f, 3.24236648e-03f, 2.73643076e-01f, -8.50411505e-02f,
  1.30396619e-01f, 8.39943141e-02f, 1.01902848e-02f, 1.08585142e-01f, -2.83871144e-02f, 3.73810977e-01f, 3.21785361e-02f, 1.09598517e-01f, 8.71724542e-03f, 1.08133346e-01f,
  7.05839097e-02f, -6.72430992e-02f, -4.24599601e-03f, 1.38044521e-01f, 2.16235608e-01f, -1.22293204e-01f, 1.62374347e-01f, 5.57260886e-02f, -7.44476989e-02f, 1.55917600e-01f,
  -7.98926782e-03f, 2.43198946e-02f, -4.70835306e-02f, -9.82742533e-02f, 2.40582973e-04f, 1.63595378e-01f, -1.10796038e-02f, 8.53477698e-03f, 7.22710490e-02f, -2.21350957e-02f,
  5.28618358e-02f, 8.66243243e-02f, -1.32464349e-01f, -1.23809138e-02f, -4.92109638e-03f, -1.23793624e-01f, -8.02732334e-02f, 1.23342887e-01f, 7.70193292e-03f, 2.87709781e-03f,
  -4.01849635e-02f, -1.30149469e-01f, 1.11857224e-02f, -3.84532884e-02f, -1.20566800e-01f, -9.85612199e-02f, 8.49737078e-02f, 1.71619132e-01f, 6.33249758e-03f, -7.93799851e-03f,
  -6.36422187e-02f, -3.99951041e-02f, -2.96059195e-02f, 8.55676457e-02f, 2.05943268e-02f, -1.05824292e-01f, -3.36997658e-02f, 1.64976865e-01f, -7.20805824e-02f, 1.83883011e-01f,
  -1.33189365e-01f, 1.02000065e-01f, -1.11290254e-01f, -2.05889672e-01f, 7.86835700e-02f, 1.45570397e-01f, -7.08315894e-02f, 1.09560378e-01f, -5.52772321e-02f, -1.15835341e-02f,
  -4.65976335e-02f, 3.38615298e-01f, 4.77814525e-02f, 5.05354367e-02f, 1.73357353e-01f, 7.58810937e-02f, 1.46497995e-01f, -1.11309037e-01f, 6.54738070e-03f, 1.78976193e-01f,
  -6.59552515e-02f, -1.03788229e-03f, -2.49831025e-02f, -1.60965383e-01f, 2.10896462e-01f, 4.90939915e-02f, 9.63355303e-02f, 1.01919480e-01f, -2.67066229e-02f, -1.46501049e-01f,
  -9.95706618e-02f, 7.17938738e-03f, -8.19227993e-02f, 2.09026691e-03f, -1.00731216e-02f, -9.36734006e-02f, 2.25591227e-01f, -8.98267329e-02f, -5.53466491e-02f, 1.05972849e-02f,
  -2.31893640e-02f, -8.77061766e-03f, -1.43136516e-01f, -2.82211881e-02f, 9.22667384e-02f, 8.16946402e-02f, -7.13693071e-03f, 9.83747542e-02f, 2.67281443e-01f, 1.27512559e-01f,
  -7.16610849e-02f, -2.03987435e-01f, -6.97110817e-02f, 1.56538785e-01f, 6.04530610e-02f, -1.24456093e-01f, 5.55684380e-02f, 5.69397882e-02f, 2.81708688e-02f, 2.83857942e-01f,
  1.76088840e-01f, -4.05204594e-02f, 1.27971157e-01f, -6.33372217e-02f, -2.20093934e-04f, -5.32496274e-02f, -1.00563921e-01f, 1.17154131e-02f, -1.20898418e-01f, -3.58472735e-01f,
  2.21602991e-01f, -1.84221178e-01f, 2.19221309e-01f, 8.84717107e-02f, -2.19474845e-02f, 1.34584472e-01f, 6.02309890e-02f, 8.56441781e-02f, 5.50759770e-02f, 6.11530021e-02f,
  4.00472386e-03f, -1.66428953e-01f, 1.90266408e-03f, 2.07525883e-02f, -4.03466672e-02f, -3.68071012e-02f, 2.70766369e-03f, 1.54041231e-01f, -3.69733036e-03f, -4.36344631e-02f,
  -4.34128381e-02f, 1.53849423e-01f, 2.17963189e-01f, 2.43206427e-01f, 2.83488870e-01f, -7.26919174e-02f, -9.72717181e-02f, 5.03046848e-02f, 1.44839019e-01f, -1.49535909e-02f,
  -1.44863844e-01f, -3.57207395e-02f, -1.55666610e-02f, 1.37812212e-01f, -3.82647775e-02f, 2.36218199e-01f, 5.79664297e-02f, 4.14380766e-02f, -6.88682199e-02f, -7.24545568e-02f,
  -8.09617788e-02f, 1.43768549e-01f, 7.45470226e-02f, -1.64306521e-01f, 1.99569494e-01f, -8.29626769e-02f, 2.37651244e-01f, -1.15754515e-01f, -1.20130174e-01f, 5.92072010e-02f,
  -6.82032481e-02f, 3.83841544e-02f, -2.22304240e-01f, -1.26579449e-01f, -9.66642424e-02f, 2.09362015e-01f, 1.92359626e-01f, 1.47955269e-01f, 1.73558503e-01f, 2.13032924e-02f,
  -3.35809551e-02f, 1.59438565e-01f, 2.13948917e-02f, -9.67791006e-02f, -1.61397830e-01f, 3.05298306e-02f, -5.96264601e-02f, -3.16520512e-01f, -4.49392898e-03f, 7.15670437e-02f,
  4.08707298e-02f, 1.39172580e-02f, 4.34124731e-02f, 9.51652154e-02f, 3.19295451e-02f, 2.87515181e-03f, 1.87095597e-01f, 6.54057711e-02f, 2.32905447e-01f, 1.21281631e-02f,
  -1.46538898e-01f, 1.19013432e-02f, -1.46364629e-01f, 1.67492524e-01f, -3.74187306e-02f, -1.07438870e-01f, -3.82236838e-02f, 5.07805459e-02f, -9.66168866e-02f, -1.47637790e-02f,
  -5.64114330e-03f, -5.71321547e-02f, -1.20323136e-01f, 1.85242802e-01f, -1.36292749e-03f, -8.85518827e-03f, -5.28383180e-02f, -1.62269875e-01f, -2.39951789e-01f, 8.95487666e-02f,
  -3.99670517e-03f, 5.04828021e-02f, -6.15863577e-02f, -1.93618074e-01f, 1.59776464e-01f, -7.06980824e-02f, -6.78523257e-02f, -4.82076667e-02f, -6.61596060e-02f, 8.79943222e-02f,
  -7.64805973e-02f, 3.56547497e-02f, -6.86107576e-02f, -1.12494029e-01f, -4.82531413e-02f, 1.07356362e-01f, 1.17088653e-01f, 1.06423870e-01f, 1.47756249e-01f, -2.87588593e-02f,
  1.90546308e-02f, 1.97234511e-01f, 2.49270089e-02f, 7.07094744e-02f, -1.10675886e-01f, -1.43805668e-01f, 1.91027328e-01f, 1.11891076e-01f, 2.48671800e-01f, 1.01818092e-01f,
  1.12768188e-01f, 5.52320629e-02f, 6.65206909e-02f, 1.82038441e-01f, 8.74288529e-02f, 8.02252144e-02f, 3.70520130e-02f, 3.52691859e-02f, 1.43665835e-01f, 2.30788123e-02f,
  -2.74969097e-02f, -1.55242905e-02f, 2.41342206e-02f, 2.57337373e-02f, 1.21184558e-01f, 4.23544161e-02f, 1.82031080e-01f, -1.04055978e-01f, -2.04438016e-01f, 1.99835405e-01f,
  4.39054780e-02f, 8.85734931e-02f, 2.29891375e-01f, -1.75631735e-02f, -8.92186463e-02f, -1.04199260e-01f, 2.24784136e-01f, -1.36312738e-01f, 9.68196988e-03f, -5.36706373e-02f,
  -3.85871977e-02f, 5.01759574e-02f, -1.24043010e-01f, 1.65936425e-01f, -9.85606983e-02f, 8.39288086e-02f, -6.29819185e-02f, -7.13720322e-02f, 1.89652413e-01f, 1.59081742e-01f,
  2.02995777e-01f, 7.94632286e-02f, 9.24238414e-02f, -4.01913449e-02f, 8.82910192e-02f, 8.81456956e-02f, -3.76329757e-02f, -9.97150596e-03f, -1.49730355e-01f, 8.31435919e-02f,
  -6.99786767e-02f, -1.33575555e-02f, -6.91580474e-02f, 9.93450880e-02f, 1.43963486e-01f, 6.78492188e-02f, 1.46494448e-01f, -9.12173986e-02f, 2.20849022e-01f, 4.55318093e-02f,
  -2.28356235e-02f, -1.15883350e-01f, -1.88618839e-01f, 6.88194335e-02f, 2.82119494e-02f, 8.82677659e-02f, 6.70778453e-02f, 5.57133853e-02f, 4.31803577e-02f, 1.91378184e-02f,
  -2.38981340e-02f, 1.53618902e-02f, -1.18311673e-01f, -5.93071943e-03f, -1.34378314e-01f, -1.95376605e-01f, -9.47546363e-02f, 6.81272149e-02f, 1.20601811e-01f, -9.08437297e-02f,
  -1.53283793e-02f, -5.58867492e-02f, 1.53983772e-01f, -7.06718042e-02f, 3.26246209e-02f, -3.01197055e-03f, -7.35829994e-02f, 1.49317626e-02f, -1.08174317e-01f, 6.60002115e-04f,
  -2.04246882e-02f, -3.26679088e-02f, 6.89849854e-02f, -3.83907109e-02f, -3.21908332e-02f, -9.63925757e-03f, 1.76684380e-01f, -1.94502659e-02f, -7.50662340e-03f, -8.76481906e-02f,
  3.10781784e-02f, 1.76920563e-01f, -8.52741227e-02f, -1.03649095e-01f, -4.74953139e-03f, 9.74229574e-02f, 3.78082012e-04f, -6.56173676e-02f, 2.68762931e-02f, 6.66905474e-03f,
  6.86283782e-02f, -4.61816601e-02f, 3.43097709e-02f, 5.86023107e-02f, 4.34725732e-02f, -1.44676035e-02f, -4.40493859e-02f, -9.48897973e-02f, -6.63855523e-02f, -6.70767128e-02f,
  -8.36315975e-02f, 6.01506233e-02f, -3.43479887e-02f, -7.29578435e-02f, -7.28414208e-02f, -1.76682975e-03f, 9.29207429e-02f, -3.08370292e-02f, 5.52421436e-02f, 1.51443124e-01f,
  -5.19268122e-03f, -2.81795189e-02f, -1.66636123e-03f, -2.02200990e-02f, -6.22076616e-02f, -4.88490723e-02f, -2.57789325e-02f, -2.67309360e-02f, 1.22583814e-01f, 1.22731544e-01f,
  9.98475626e-02f, -1.89050317e-01f, -1.23338833e-01f, 1.66901201e-01f, -9.58640873e-02f, -1.53334225e-02f, -2.83461548e-02f, -1.04112394e-01f, -1.80461332e-02f, 1.29652455e-01f,
  -1.61135383e-02f, -5.33948354e-02f, -4.19843681e-02f, -1.28723159e-01f, -3.16515751e-02f, -1.87828112e-02f, -1.38993979e-01f, 2.39568517e-01f, -9.06192586e-02f, -6.52541220e-02f,
  -6.64476678e-02f, 7.22765177e-02f, -4.25652899e-02f, 1.08314734e-02f, 1.53870480e-02f, -6.87609464e-02f, 9.97951031e-02f, -1.50940986e-02f, -1.77942663e-01f, -1.04654171e-01f,
  -3.04521210e-02f, 1.98579893e-01f, -4.63428795e-02f, -7.18567967e-02f, -1.55493870e-01f, -1.49612680e-01f, -4.34293859e-02f, -4.43871468e-02f, 1.50753364e-01f, -2.48313650e-01f,
  -1.18770301e-01f, 3.82330641e-02f, 1.05224671e-02f, 1.07985385e-01f, -9.08799693e-02f, 7.06471056e-02f, -6.06632493e-02f, -1.72650561e-01f, 1.97255939e-01f, 1.53675720e-01f,
  3.40231322e-02f, 1.68332234e-01f, -1.24525242e-01f, -1.08036429e-01f, 2.27111652e-02f, 2.15087131e-01f, 6.12762049e-02f, 5.70241548e-02f, 4.77947760e-03f, 9.81067773e-03f,
  1.00051500e-01f, -3.41065116e-02f, 1.92354396e-01f, 2.04230100e-02f, 2.23579690e-01f, 6.21423125e-02f, -1.09382100e-01f, 1.66049749e-01f, 1.43083826e-01f, -9.60813463e-03f,
  -9.73553061e-02f, -4.54771295e-02f, 7.13113993e-02f, 1.87022716e-01f, -1.09054931e-01f, -1.32688098e-02f, 7.71743059e-02f, -1.07877858e-01f, 2.50246786e-02f, 9.62123368e-03f,
  -1.27048576e-02f, -1.77566875e-02f, 1.67302024e-02f, -1.24131151e-01f, -1.30706966e-01f, 7.66013488e-02f, -5.95436664e-03f, 1.19942002e-01f, -3.81696448e-02f, -1.93115935e-01f,
  4.62022051e-02f, 1.34466529e-01f, 7.71371648e-02f, -8.39161873e-02f, -1.77150611e-02f, 9.92575958e-02f, -3.90986018e-02f, 1.55301884e-01f, -4.77441065e-02f, -9.94480103e-02f,
  -5.41340094e-03f, 1.65986702e-01f, 8.16986784e-02f, 5.73023446e-02f, 5.75489327e-02f, 1.81810692e-01f, 1.78582370e-02f, 2.21323386e-01f, -8.74630362e-02f, 4.62065898e-02f,
  -1.22143023e-01f, -1.35427728e-01f, 1.36568233e-01f, 8.06677714e-02f, -1.96914189e-03f, 1.07116252e-01f, 2.06439514e-02f, -8.13761633e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -2.34415997e-02f, 5.11673987e-02f, 9.11980271e-02f, 1.86685082e-02f, 9.42361727e-02f, 1.06071560e-02f, 2.66210772e-02f, 7.21558779e-02f, 2.49281283e-02f, -4.48636785e-02f,
  4.05441336e-02f, 5.79843356e-04f, 1.11143753e-01f, 6.41143620e-02f, 6.17003031e-02f, 8.70767087e-02f, -7.51061551e-03f, 1.27510488e-01f, 3.84899564e-02f, 1.18608184e-01f,
  7.82447979e-02f, 4.42774817e-02f, 4.06451151e-02f, 7.93712139e-02f, 1.27488196e-01f, 9.56300348e-02f, -2.22893506e-02f, 2.54837722e-02f, 1.50072768e-01f, -9.80595220e-03f,
  2.57292315e-02f, 1.02063520e-02f, 7.77342170e-02f, -2.49755643e-02f, 1.31598637e-02f, 1.69224724e-01f, -2.40101162e-02f, 3.29308631e-03f, 4.03012848e-03f, 1.01282828e-01f,
  -2.52578817e-02f, 2.96690017e-02f, 1.15437537e-01f, 5.38019314e-02f, 1.47903068e-02f, 9.34423506e-02f, 3.54939513e-02f, -1.50263263e-02f, 2.88925990e-02f, 2.66081542e-02f,
  -3.31970304e-02f, 8.50684494e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  3.96443643e-02f, 6.97381869e-02f, -6.99740660e-04f, -5.59875816e-02f, -4.20415699e-02f, 8.78609419e-02f, -1.32358611e-01f, -9.20088068e-02f, -2.64248322e-03f, -1.12129644e-01f,
  3.92904766e-02f, 1.56989004e-02f, -3.67251895e-02f, 3.63824628e-02f, -2.93055680e-02f, 3.21953036e-02f, -1.54549047e-01f, 5.55542558e-02f, -1.46722183e-01f, 7.04180673e-02f,
  1.88839003e-01f, -8.39928538e-02f, 7.62365013e-02f, 7.80067667e-02f, 1.45204544e-01f, -5.15326224e-02f, -1.07652560e-01f, -4.47129607e-02f, 9.59658474e-02f, -1.50629520e-01f,
  3.10587026e-02f, 9.88171995e-02f, -1.05831668e-01f, 2.18261126e-02f, 3.77478525e-02f, -8.28172341e-02f, -4.45988104e-02f, -5.28916195e-02f, -2.90855728e-02f, -9.61323977e-02f,
  -3.45373638e-02f, 3.34560089e-02f, 9.45367068e-02f, -2.01749355e-02f, 9.23596881e-03f, -4.90717441e-02f, 1.31585440e-02f, 9.31244250e-03f, 1.47606572e-02f, -1.46120843e-02f,
  3.88385691e-02f, 1.07948504e-01f, -1.02515901e-02f, -8.22003372e-03f, 3.47729214e-02f, -6.06732927e-02f, -1.18901774e-01f, 1.17110856e-01f, 1.02574125e-01f, -1.84919555e-02f,
  -6.89185560e-02f, -6.29322454e-02f, -1.30969793e-01f, -1.49953440e-01f, 6.71634674e-02f, -1.17101058e-01f, -4.78333011e-02f, 4.13645990e-02f, 1.04097910e-02f, 2.54553426e-02f,
  2.50624735e-02f, -1.13747373e-01f, -1.77393332e-01f, 1.10801272e-01f, -6.07408583e-02f, 3.08254119e-02f, 1.02856129e-01f, -6.21426944e-03f, 1.24250889e-01f, -3.67662571e-02f,
  1.00711092e-01f, -4.58049588e-02f, 4.52827290e-02f, 1.31021395e-01f, -7.16645122e-02f, -6.42760247e-02f, -5.33534698e-02f, -9.93251149e-03f, -9.31834504e-02f, 1.03016466e-01f,
  1.27438933e-01f, 2.44872849e-02f, 6.82219639e-02f, 9.91753340e-02f, -9.94228646e-02f, -1.04601093e-01f, 8.96208957e-02f, -3.42936954e-03f, -8.72768164e-02f, 8.00364614e-02f,
  -7.66022429e-02f, -1.26291990e-01f, -1.27387792e-02f, -9.25524831e-02f, -7.45152310e-02f, 4.73241555e-03f, -1.10220522e-01f, 2.67881341e-02f, -4.76306267e-02f, 1.06343359e-01f,
  -1.41282305e-02f, 1.22143686e-01f, -1.64644346e-02f, 5.20054325e-02f, -1.07125662e-01f, -1.75584465e-01f, 5.66827767e-02f, 6.91353902e-03f, -1.67948194e-02f, -1.24055473e-02f,
  1.14476204e-01f, -9.73575190e-02f, 4.56950963e-02f, 3.60623039e-02f, 3.27646434e-02f, 1.59308612e-02f, 3.61400060e-02f, 1.32776737e-01f, 6.21561706e-02f, -1.04213562e-02f,
  -3.56431901e-02f, 1.86908036e-01f, 1.32411212e-01f, -1.42109403e-02f, -2.09616259e-01f, -1.12077557e-01f, -1.48067653e-01f, 1.41846329e-01f, 3.33544827e-04f, 3.10196709e-02f,
  -6.63743392e-02f, -1.34713156e-02f, -4.51353267e-02f, -1.50210008e-01f, 1.10811628e-01f, -1.57632947e-01f, -9.81526524e-02f, 8.87217745e-02f, -3.06352116e-02f, -5.32809235e-02f,
  -2.01429203e-02f, 3.15466598e-02f, -1.48439839e-01f, 1.02330409e-01f, 1.25364736e-01f, 1.09240770e-01f, 1.19272647e-02f, -1.57074556e-01f, -3.49335209e-03f, 9.90965366e-02f,
  -9.65460483e-03f, 6.44550547e-02f, -1.01699242e-02f, 2.50075124e-02f, 1.31580113e-02f, 6.83550090e-02f, -1.23117886e-01f, -1.87260628e-01f, -2.42222957e-02f, 1.19593166e-01f,
  -2.20089629e-02f, 1.36800125e-01f, -1.15854077e-01f, -2.77084056e-02f, -5.45167290e-02f, -1.41704500e-01f, -5.55651204e-04f, 3.51063162e-02f, 4.69437279e-02f, 7.68282190e-02f,
  1.33706834e-02f, 1.96019169e-02f, -3.46853882e-02f, -2.59794388e-02f, 9.53786969e-02f, 2.08829805e-01f, 9.32750404e-02f, 2.26083864e-02f, 1.38769329e-01f, 1.11820102e-02f,
  -7.87327588e-02f, 3.80568281e-02f, 1.61997646e-01f, 4.39685062e-02f, -8.34601596e-02f, -8.98354426e-02f, -4.10380997e-02f, -2.56373925e-04f, 6.32648543e-02f, 2.21464131e-02f,
  6.73409179e-02f, -2.77708727e-03f, 7.24416301e-02f, -8.60357955e-02f, -1.54755175e-01f, 1.13826850e-02f, 5.25931939e-02f, 1.95271242e-02f, 1.40989825e-01f, 4.10454348e-03f,
  1.10606737e-02f, -3.85444127e-02f, -9.50012803e-02f, -5.19577861e-02f, -2.21948978e-02f, -5.17858826e-02f, -8.87193456e-02f, 6.56046569e-02f, 1.05294555e-01f, 5.02964593e-02f,
  8.45913962e-02f, -2.47938242e-02f, -2.73926333e-02f, 4.64485362e-02f, -3.86748128e-02f, 6.18473925e-02f, 5.33808246e-02f, -6.31018505e-02f, -1.55714273e-01f, -5.26622906e-02f,
  -1.16744943e-01f, 5.70457540e-02f, 6.16167225e-02f, -1.16272129e-01f, 1.11307083e-02f, -1.37293031e-02f, -2.94660274e-02f, 5.54191088e-03f, 8.27961564e-02f, -4.28570807e-02f,
  -4.02519107e-03f, -9.08450261e-02f, 1.71580568e-01f, -6.77694827e-02f, -9.25177857e-02f, -1.68290600e-01f, 8.69563594e-02f, 3.28846537e-02f, 7.93061312e-03f, 5.76005243e-02f,
  -1.88726792e-03f, 1.75874233e-02f, 2.20757499e-02f, 5.78692667e-02f, -4.28147390e-02f, 1.18318433e-02f, 9.99080092e-02f, 8.92210901e-02f, 6.54291064e-02f, 1.22594602e-01f,
  -4.12748335e-03f, 1.75336152e-02f, 1.11924270e-02f, 5.37931696e-02f, 8.65819529e-02f, -4.64925133e-02f, 1.15305111e-01f, -1.87645685e-02f, -3.48744467e-02f, -3.57230976e-02f,
  8.75365213e-02f, -5.94567955e-02f, 5.19017242e-02f, -6.08421490e-02f, 7.33895749e-02f, -5.56307696e-02f, -1.82240680e-01f, 9.58742946e-02f, -1.41173840e-01f, 3.13667953e-02f,
  -1.50546029e-01f, -9.29163303e-03f, 1.06686600e-01f, -3.14859189e-02f, -6.89220428e-02f, 3.63595225e-02f, -8.17295685e-02f, -7.31113553e-02f, -4.91104499e-02f, -4.18495061e-03f,
  2.33016256e-03f, 7.67031386e-02f, -1.47645343e-02f, 1.77719042e-01f, -9.93576944e-02f, 1.86015517e-02f, -6.81627393e-02f, 1.46720205e-02f, -1.28899366e-01f, 8.35653581e-03f,
  -4.99443673e-02f, -6.63665608e-02f, -1.16314173e-01f, -3.40996981e-02f, -1.12690888e-01f, 5.55401668e-02f, 6.49995208e-02f, 5.00064939e-02f, -5.33322729e-02f, 8.44812989e-02f,
  1.28898129e-01f, 6.86708763e-02f, -4.00235802e-02f, 7.98114389e-02f, -9.21419188e-02f, -3.39170508e-02f, -5.32804281e-02f, 1.00629352e-01f, 2.41268636e-03f, -2.00099926e-02f,
  5.97466677e-02f, 1.01277277e-01f, -2.28759106e-02f, 5.08295791e-03f, 1.30283432e-02f, 2.93005612e-02f, -2.46812627e-02f, 2.98929922e-02f, 1.02732293e-02f, -1.57913528e-02f,
  1.19092114e-01f, 5.10503050e-05f, 9.35696885e-02f, -7.27044344e-02f, -4.82197702e-02f, -6.93039745e-02f, -4.91427779e-02f, 1.28552780e-01f, -3.05366106e-02f, -9.86110792e-02f,
  8.23677704e-02f, -1.83534831e-01f, 4.26102839e-02f, 1.61527455e-01f, -5.37611991e-02f, -3.54768410e-02f, -8.58003125e-02f, -1.41057089e-01f, -1.57175120e-02f, 6.65589049e-02f,
  -7.73266703e-02f, 1.43220752e-01f, 1.00533832e-02f, -4.30515856e-02f, -1.95664875e-02f, 1.36282369e-01f, 2.13205051e-02f, 6.40609190e-02f, -2.53417399e-02f, -7.18645239e-03f,
  -1.61804333e-01f, 1.94142729e-01f, -1.71647631e-02f, 7.03493506e-02f, -7.77126057e-03f, -4.78112139e-02f, -6.07498772e-02f, 2.70726103e-02f, -5.67697808e-02f, -2.45778747e-02f,
  -1.55402809e-01f, 6.14677444e-02f, -4.99936007e-02f, -1.02576159e-01f, 1.41869366e-01f, -1.43074647e-01f, -1.40399218e-01f, -3.99048962e-02f, 1.43894687e-01f, -3.36734913e-02f,
  -4.29024966e-03f, -6.93753362e-02f, -1.21782504e-01f, -1.04313508e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.19272009e-01f, 3.47790346e-02f, -1.45628620e-02f, -9.31205451e-02f, -1.06183700e-01f, -1.27109304e-01f, 1.62469685e-01f, -1.23786189e-01f, -2.22698823e-02f, 4.37535755e-02f,
  -1.24837436e-01f, -4.21303995e-02f, 5.30304052e-02f, 1.77059755e-01f, 8.25283304e-02f, 9.85387042e-02f, 1.48553163e-01f, -8.65168571e-02f, 9.60588679e-02f, 2.21652210e-01f,
  4.96392325e-03f, 6.90106750e-02f, -8.01026635e-03f, -2.18148023e-01f, -1.16061583e-01f, 1.77310407e-01f, 2.35582218e-02f, 2.10377201e-01f, -1.66642606e-01f, -3.53957266e-02f,
  2.14691371e-01f, -1.13683835e-01f, -1.18861653e-01f, 2.55435497e-01f, -1.96833357e-01f, 1.45067677e-01f, 3.09733078e-02f, -1.66439667e-01f, 2.01660797e-01f, 1.00520015e-01f,
  -2.06907690e-02f, 9.69069302e-02f, 1.54356703e-01f, 1.15434363e-01f, -5.00074513e-02f, -4.79340479e-02f, 7.53178522e-02f, -7.07812086e-02f, -1.28149688e-01f, -1.21359266e-01f,
  -1.70622975e-01f, -1.12473905e-01f, -1.20371565e-01f, 1.53493136e-01f, -1.42395154e-01f, -1.32221013e-01f, 8.32814574e-02f, -1.49615765e-01f, 4.94963676e-02f, 1.08145684e-01f,
  5.06379157e-02f, 1.01852626e-01f, -4.45880555e-02f, 2.77426373e-02f, 1.18615352e-01f, -3.63357477e-02f, 6.17847405e-02f, 8.87249708e-02f, 9.53305811e-02f, -3.90257202e-02f,
  -4.44124192e-02f, -3.31432283e-01f, -2.79875696e-01f, 2.16902383e-02f, -1.42642215e-01f, -3.15129161e-02f, 1.43154696e-01f, 8.67936909e-02f, -2.71060299e-02f, 1.27801806e-01f,
  -8.56668875e-02f, 7.42682815e-02f, 1.13507159e-01f, 1.20221317e-01f, 8.85205418e-02f, 1.10881552e-01f, 3.85812717e-03f, -4.10546325e-02f, 2.23410383e-01f, 2.42801875e-01f,
  1.05664162e-02f, 1.29509822e-01f, -1.87662363e-01f, -7.70480409e-02f, 1.26768038e-01f, 1.84351921e-01f, -8.62440839e-02f, 1.79110244e-01f, -1.42722219e-01f, 1.16389878e-01f,
  1.57782152e-01f, -1.46305084e-01f, 9.35908481e-02f, 1.20785616e-01f, 1.26541212e-01f, 1.94454417e-01f, -9.55766626e-03f, 1.44752622e-01f, 1.36726201e-01f, -1.13490157e-01f,
  7.73056298e-02f, 1.38884351e-01f, -1.95180848e-02f, -1.75842300e-01f, -1.13798350e-01f, 1.59992501e-01f, -9.60026905e-02f, 1.66903943e-01f, -8.45697969e-02f, -2.61355075e-03f,
  1.41698092e-01f, -1.53907925e-01f, 1.96415186e-02f, -4.65746187e-02f, 1.27622858e-01f, 5.88363931e-02f, -7.65339211e-02f, 9.73400623e-02f, -1.79373082e-02f, -5.04114330e-02f,
  -1.51023064e-02f, -2.21775677e-02f, 2.64882650e-02f, 2.17350889e-02f, 5.63142858e-02f, 5.58166914e-02f, 1.10422082e-01f, -7.87959024e-02f, -4.39652652e-02f, 1.45370979e-02f,
  1.07127085e-01f, 5.03162965e-02f, 3.85980532e-02f, 5.55875339e-02f, 5.37899672e-04f, 4.25323583e-02f, 6.12851419e-02f, 1.31216943e-02f, 1.96509063e-02f, 8.16414729e-02f,
  4.03840235e-03f, -6.83422610e-02f, 6.06923141e-02f, 6.18633628e-02f, -2.28426754e-02f, 6.48314282e-02f, -8.08175579e-02f, 7.96946213e-02f, 8.49059299e-02f, -4.68964892e-04f,
  -7.75729679e-03f, 6.09006621e-02f, -7.57020479e-03f, 1.97400525e-02f, 3.71649526e-02f, 2.39563249e-02f, 9.58969221e-02f, 6.62581250e-02f, 4.75574769e-02f, 1.17068086e-02f,
  1.22857383e-02f, 3.18717211e-02f, 5.92176653e-02f, 2.06300169e-02f, 2.60183476e-02f, 2.14838814e-02f, -1.91996992e-02f, 1.41733317e-02f, 1.10951141e-02f, 2.99637672e-02f,
  -7.64107611e-03f, 6.32883608e-02f, 2.18546763e-02f, 4.90037240e-02f, 5.33312410e-02f, -6.46229181e-03f, 4.47523780e-02f, 1.52994152e-02f, 3.19028758e-02f, 7.13746771e-02f,
  5.75304180e-02f, -1.82632077e-02f, 7.86070302e-02f, 5.51018156e-02f, 1.16279222e-01f, 4.57865633e-02f, -9.69643667e-02f, 1.01408055e-02f, 1.46746531e-01f, -1.23444818e-01f,
  -1.72627106e-01f, 1.43401414e-01f, -4.30758297e-02f, 6.91760257e-02f, 3.01904827e-01f, -5.09298779e-02f, 6.05282784e-02f, -1.52953351e-02f, -6.26864582e-02f, -2.86171567e-02f,
  -2.33978629e-02f, 3.86919901e-02f, -1.48208320e-01f, -1.20587133e-01f, -3.75047373e-03f, 1.12420423e-02f, -2.14726534e-02f, -2.13846676e-02f, 8.28563571e-02f, 8.17730352e-02f,
  -9.15977657e-02f, 2.03320727e-01f, -1.24411575e-01f, 1.08127132e-01f, 1.24769978e-01f, -6.74368143e-02f, 4.56679910e-02f, 1.83304057e-01f, 1.70593277e-01f, -1.50229931e-01f,
  1.57417066e-03f, 9.94255021e-02f, -9.20918286e-02f, 1.05621301e-01f, -5.90575784e-02f, 1.69519752e-01f, -1.13163423e-02f, 2.59830467e-02f, 3.93929556e-02f, 1.28933966e-01f,
  -3.91345657e-02f, -7.96753392e-02f, -1.74572110e-01f, -1.84442163e-01f, 2.57515442e-02f, 1.23491921e-02f, -5.07879667e-02f, -1.20600849e-01f, 1.00972243e-01f, -1.83320239e-01f,
  1.99135259e-01f, 8.87611285e-02f, 6.65609166e-02f, -1.48261907e-02f, 8.49676505e-02f, 1.48579359e-01f, -1.65087059e-02f, 9.23759341e-02f, 8.04095045e-02f, 4.85943332e-02f,
  -1.49519920e-01f, -7.73524214e-03f, 6.10302240e-02f, -1.14471592e-01f, -1.26985848e-01f, 2.24037901e-01f, -1.33621156e-01f, 8.65434259e-02f, -1.84930488e-02f, -4.16091867e-02f,
  1.30450666e-01f, 6.40015379e-02f, -1.07396040e-02f, -5.32651097e-02f, -9.73231718e-03f, 1.99287944e-02f, -1.25935361e-01f, -1.38656208e-02f, 2.59436760e-02f, 3.49600986e-02f,
  -1.21808439e-01f, 5.93379587e-02f, 8.37660804e-02f, -5.99637069e-02f, 1.58368036e-01f, 9.87800434e-02f, -2.01196253e-01f, 9.89512727e-02f, 5.90359084e-02f, -1.15061610e-03f,
  7.95800611e-02f, 8.44594613e-02f, 4.52245958e-02f, -4.51678038e-02f, -1.20280817e-01f, 3.33231054e-02f, -8.26635510e-02f, -2.29901057e-02f, -6.68745339e-02f, 9.05449986e-02f,
  -5.25086969e-02f, 9.20183808e-02f, 4.12749872e-02f, 7.48506039e-02f, 3.81545089e-02f, -5.30341417e-02f, 1.22854300e-02f, -1.13834158e-01f, 9.55380872e-02f, -1.90274958e-02f,
  -2.95796487e-02f, -5.92930689e-02f, 1.30133986e-01f, -3.65350991e-02f, 8.64545256e-02f, 9.76819843e-02f, 1.28375858e-01f, -1.11181721e-01f, 1.28599793e-01f, 8.94963220e-02f,
  -7.39065036e-02f, -3.30166742e-02f, -4.04164530e-02f, -7.66411126e-02f, -3.56764831e-02f, -5.35336770e-02f, -1.73405454e-01f, 9.37762484e-02f, -2.34711412e-02f, -7.64409602e-02f,
  1.67227551e-01f, -1.09527512e-02f, -1.57297358e-01f, -3.93610187e-02f, -1.23054676e-01f, 3.50092798e-02f, -1.33713588e-01f, 1.32001102e-01f, -1.87240452e-01f, 4.86394987e-02f,
  3.06351781e-01f, -5.01710996e-02f, 2.73094863e-01f, 2.37969354e-01f, -8.81867949e-03f, -3.46894525e-02f, 1.43521065e-02f, -1.65006056e-01f, 2.65136361e-01f, -8.32991377e-02f,
  7.73689523e-02f, 1.79337353e-01f, 1.62693113e-01f, -1.29505973e-02f, 1.91357002e-01f, -8.10391381e-02f, 4.19027396e-02f, 1.90070465e-01f, -2.66124513e-02f, -1.53384078e-02f,
  -7.72496462e-02f, 1.10106885e-01f, 2.44561687e-01f, -3.80024239e-02f, 5.30241579e-02f, 9.30567160e-02f, -6.32230490e-02f, 1.30634885e-02f, 2.47122929e-01f, 1.05986498e-01f,
  1.16486311e-01f, 2.60167718e-01f, 1.32281780e-01f, -3.04646790e-02f, 1.16166286e-01f, -1.07220002e-01f, -1.14247613e-01f, 1.64242983e-01f, 1.18026637e-01f, -4.51247506e-02f,
  5.59117272e-02f, -2.29370315e-02f, 1.69449020e-02f, 6.13891799e-03f, -1.73419058e-01f, -1.55265540e-01f, 1.71780586e-02f, -6.44631609e-02f, -7.41269961e-02f, -6.78585917e-02f,
  1.70661286e-02f, -4.55734953e-02f, -9.93741527e-02f, -8.63177180e-02f, -1.24024816e-01f, -1.13540247e-01f, 3.15133959e-01f, 2.04529092e-01f, 1.16988242e-01f, 2.51813859e-01f,
  -1.42351091e-01f, 7.44752437e-02f, -3.06009296e-02f, 1.57224387e-01f, 2.01551571e-01f, 8.24519396e-02f, 1.18780077e-01f, -2.26803850e-02f, 1.95683584e-01f, 1.76537670e-02f,
  -2.36674309e-01f, 9.52584594e-02f, -2.35493824e-01f, 9.47226435e-02f, 9.38381106e-02f, 2.46634204e-02f, -1.86495646e-03f, 2.00182945e-01f, -6.22502156e-02f, 3.80681157e-02f,
  2.73499131e-01f, -1.26826376e-01f, 3.34187448e-01f, 1.58095017e-01f, -1.10164396e-01f, 2.69668758e-01f, 9.35533866e-02f, 4.24068645e-02f, 1.52544975e-01f, 6.53755739e-02f,
  -2.57329177e-02f, 1.63802743e-01f, -1.09539732e-01f, 2.79735564e-03f, -2.04711586e-01f, 2.14810781e-02f, 5.29414564e-02f, 9.52669308e-02f, -4.99486970e-03f, -8.85209069e-02f,
  3.65244783e-02f, -2.59569019e-01f, 1.69342026e-01f, 6.49372786e-02f, 2.34603100e-02f, 1.26814917e-01f, 1.00880370e-01f, -6.93162158e-03f, -8.59047994e-02f, -4.83753458e-02f,
  -3.24037578e-03f, 1.30997539e-01f, -8.91691744e-02f, -1.03726864e-01f, 9.85285174e-03f, 1.49398118e-01f, 4.39930558e-02f, 1.72668248e-01f, -1.10707164e-01f, 1.76576480e-01f,
  2.19959661e-01f, 1.64477564e-02f, 1.43130675e-01f, 7.69961700e-02f, 9.65450704e-02f, -1.70098081e-01f, 8.69650915e-02f, 1.17106222e-01f, -3.15866508e-02f, 1.28844395e-01f,
  5.84185608e-02f, 1.74046643e-02f, -1.10560305e-01f, 1.08384350e-02f, 6.79593012e-02f, -6.46512285e-02f, 2.20375527e-02f, 8.33996832e-02f, -1.05300963e-01f, -7.53734447e-03f,
  1.35883927e-01f, 1.68766797e-01f, -6.60718009e-02f, 2.00917035e-01f, 9.95162129e-03f, 8.53480473e-02f, 1.08914465e-01f, -1.37080714e-01f, -2.10363999e-01f, 4.69826460e-02f,
  9.66613926e-03f, 1.09166823e-01f, -1.79891467e-01f, 1.96476266e-01f, -9.70147271e-03f, 9.23361704e-02f, 1.39700146e-02f, 1.53196231e-01f, -1.50147796e-01f, -1.37762755e-01f,
  1.75469846e-01f, 1.29818588e-01f, -5.31364754e-02f, -1.35664240e-01f, 4.40999828e-02f, -7.25282878e-02f, 1.15788899e-01f, 1.83665723e-01f, 9.41445753e-02f, -4.20046300e-02f,
  1.13456234e-01f, 4.65328246e-02f, 1.99774519e-01f, 1.14276968e-01f, 4.84627439e-03f, 7.37682879e-02f, 1.07537419e-01f, 7.15581626e-02f, 1.75151035e-01f, 1.08011037e-01f,
  3.24999988e-02f, -2.32823230e-02f, -1.92514225e-03f, -1.07908417e-02f, 1.21959522e-01f, 1.34555459e-01f, 2.21487939e-01f, -4.48820107e-02f, 7.59279057e-02f, 5.25586866e-02f,
  1.63514569e-01f, 7.45749846e-02f, -2.37069413e-01f, 4.80603278e-02f, -2.06410781e-01f, -9.25301686e-02f, -1.31394967e-01f, 6.22581318e-02f, -7.44899958e-02f, 1.94306538e-01f,
  -6.14622496e-02f, 2.40383372e-01f, -6.24111667e-02f, -1.46610811e-01f, 3.75162736e-02f, 1.56871587e-01f, 1.90929815e-01f, 1.49695605e-01f, -2.77659763e-02f, -8.06487165e-03f,
  1.17705747e-01f, 4.19433080e-02f, 4.37040515e-02f, 2.18077637e-02f, -1.27394676e-01f, 1.98123425e-01f, 6.92670941e-02f, 2.67869905e-02f, -2.20189139e-01f, -7.82428682e-02f,
  -2.28514701e-01f, 1.22403443e-01f, 3.82446647e-02f, -4.46475670e-02f, 1.58838034e-02f, -1.11813538e-01f, 1.70374930e-01f, -1.24252453e-01f, 1.21971160e-01f, 8.21025968e-02f,
  1.52344853e-01f, 1.77556872e-01f, -1.06392048e-01f, 4.15376797e-02f, 9.91586074e-02f, 8.92947316e-02f, 1.44480355e-02f, -1.20234855e-01f, -6.13473281e-02f, 1.26190633e-01f,
  5.84284626e-02f, 1.71650276e-01f, 1.60955295e-01f, 1.50054231e-01f, 9.01286453e-02f, -1.03721641e-01f, 4.05016392e-02f, -1.20000970e-02f, 2.03711137e-01f, 1.19811974e-01f,
  8.52375552e-02f, -4.68020067e-02f, 2.10529819e-01f, 1.19556459e-02f, 1.00106865e-01f, 1.50001124e-01f, -9.39041600e-02f, 1.17994837e-01f, -1.22637078e-02f, -1.02274977e-01f,
  -2.91465851e-03f, 4.60458780e-03f, -6.18005209e-02f, 1.31511942e-01f, -8.48410651e-02f, 2.49576822e-01f, 5.63346557e-02f, -1.26148000e-01f, -8.04171190e-02f, 2.67078996e-01f,
  1.62420291e-02f, 2.05685079e-01f, 9.03658271e-02f, 1.23618849e-01f, 1.87840223e-01f, -6.81575537e-02f, -8.92158151e-02f, 3.74554209e-02f, -1.14894487e-01f, 1.62709594e-01f,
  -6.61550313e-02f, 8.01299438e-02f, -1.80122331e-01f, -1.45429134e-01f, -2.20677242e-01f, 1.12943500e-01f, -4.38739955e-02f, 5.91486059e-02f, -3.90648320e-02f, 5.14956340e-02f,
  2.44481042e-01f, -1.14104085e-01f, -1.30740516e-02f, -1.28872953e-02f, 1.15195177e-01f, 1.60192803e-01f, -3.25063579e-02f, 6.07244745e-02f, -2.11343518e-03f, -2.17707679e-02f,
  -4.25443519e-03f, 2.46879905e-02f, 7.33489310e-03f, 9.10670962e-03f, 5.74984215e-02f, -9.23376977e-02f, -3.37392464e-02f, 2.20162004e-01f, 6.19463176e-02f, 1.26132250e-01f,
  5.51731624e-02f, 1.73124298e-01f, 1.84573105e-03f, -1.84050247e-01f, 1.26301676e-01f, -1.29892066e-01f, 9.71750077e-03f, -8.91655982e-02f, -1.39685735e-01f, -6.05976675e-03f,
  -1.61422342e-02f, 6.73032776e-02f, 1.07626483e-01f, 1.97307214e-01f, -1.25714436e-01f, -3.65982391e-02f, -3.65521610e-02f, 4.83968221e-02f, 1.93048671e-01f, 9.92988124e-02f,
  -1.65954560e-01f, -2.85415296e-02f, 2.57335991e-01f, -4.91691707e-03f, 1.77419171e-01f, 1.46393105e-01f, 1.42663345e-01f, 1.08673058e-01f, -9.04516410e-03f, -2.12642252e-01f,
  -2.25184664e-01f, -5.50605590e-03f, 4.80603352e-02f, 2.37724751e-01f, -1.97342396e-01f, 1.69437930e-01f, -1.66364565e-01f, -3.75054367e-02f, 5.88416643e-02f, 2.10586637e-01f,
  4.27491441e-02f, 4.76632006e-02f, 2.20031813e-01f, 6.55030552e-03f, -3.37776146e-03f, -1.31236687e-01f, 8.72154310e-02f, 4.96946685e-02f, 1.74813151e-01f, 1.72169656e-01f,
  1.57500297e-01f, -9.87007096e-02f, 7.19627216e-02f, 1.54223204e-01f, -1.77832246e-01f, -1.53901413e-01f, -9.87617895e-02f, -4.03464623e-02f, -7.89117366e-02f, -1.08321451e-01f,
  7.39512742e-02f, 5.04775681e-02f, 2.32063774e-02f, 3.64755131e-02f, -1.33377045e-01f, 2.96547730e-02f, 1.00287266e-01f, -4.38127387e-03f, 3.04837525e-02f, 1.02705494e-01f,
  -5.28445281e-02f, -8.77035260e-02f, 5.29304445e-02f, 1.27014387e-02f, 1.35215014e-01f, 1.93252444e-01f, 1.16609693e-01f, -1.61979213e-01f, 6.15261495e-02f, -6.34247996e-03f,
  -9.75418836e-02f, 4.12086807e-02f, -9.19015855e-02f, 6.33079000e-03f, 1.73306420e-01f, -1.48149058e-01f, 6.37173057e-02f, 5.89897446e-02f, -1.65933162e-01f, -7.03180954e-02f,
  9.97464508e-02f, -2.07181424e-02f, 1.65824577e-01f, 3.85779552e-02f, 1.61470473e-02f, -4.05323580e-02f, 5.63778505e-02f, -6.45767003e-02f, -2.53294948e-02f, 8.27476382e-02f,
  9.39574838e-03f, -2.56073233e-02f, 8.28529969e-02f, 1.98841467e-02f, -1.09125808e-01f, 4.50972188e-03f, 5.44955470e-02f, 2.28270426e-01f, -1.70668885e-01f, 2.25561019e-02f,
  9.30532292e-02f, -2.00176105e-01f, 7.00150104e-03f, 6.80005550e-02f, -7.72152171e-02f, 4.21774350e-02f, 1.51699558e-01f, 4.26375940e-02f, -7.39274994e-02f, -1.23014294e-01f,
  -5.71316667e-02f, 2.03445442e-02f, -2.95812730e-02f, -4.18130942e-02f, 9.81335342e-02f, 3.16973954e-01f, 2.58903205e-01f, -3.18435766e-02f, 4.02325392e-02f, 3.13781388e-02f,
  6.20250702e-02f, -1.59951840e-02f, 1.89711347e-01f, -1.58007309e-01f, 6.91179857e-02f, -8.89168829e-02f, 8.80654231e-02f, 2.63499208e-02f, -4.36556488e-02f, 3.18846285e-01f,
  3.55871543e-02f, -4.07835469e-02f, -2.65702188e-01f, -9.39693674e-02f, -1.88076034e-01f, 1.66229591e-01f, 4.47149798e-02f, 3.09865117e-01f, 2.52418220e-01f, -3.15922886e-01f,
  2.16695055e-01f, 2.92512923e-01f, 1.01377778e-01f, 2.39658449e-02f, -7.92198777e-02f, 3.70473266e-01f, 1.75535232e-01f, -3.63548882e-02f, -1.30702019e-01f, -1.04096837e-01f,
  1.20902024e-01f, 1.17587455e-01f, -1.78055048e-01f, 1.82934791e-01f, -3.60009313e-01f, -3.46339494e-01f, -9.08364728e-02f, 4.08797413e-01f, 1.01762779e-01f, 1.35817438e-01f,
  2.55177051e-01f, 1.57011062e-01f, 3.32057804e-01f, -2.21108243e-01f, 1.08066007e-01f, 1.61520943e-01f, 7.69844726e-02f, 2.07863703e-01f, -1.43269137e-01f, 1.02621116e-01f,
  2.02743858e-01f, 1.59199759e-01f, -2.00566649e-02f, 3.15506235e-02f, 1.44253271e-02f, -5.70662171e-02f, -1.59953132e-01f, -1.65085912e-01f, -6.91020787e-02f, 2.17792764e-02f,
  -1.30321383e-01f, 1.96463540e-01f, -6.74831346e-02f, 1.48815989e-01f, 1.67716276e-02f, -1.95896253e-01f, -1.10864632e-01f, -2.34925188e-03f, -1.58707559e-01f, -7.13745132e-02f,
  -1.90158695e-01f, -1.48999602e-01f, 1.79603547e-01f, 1.08844284e-02f, 2.85003901e-01f, 7.05590546e-02f, -3.53358984e-02f, 1.06260572e-02f, -8.48447084e-02f, -1.15112439e-01f,
  2.04408213e-01f, 2.54017264e-02f, -6.16784627e-03f, 8.49716216e-02f, 2.20007449e-01f, 4.23245244e-02f, 1.41174763e-01f, 1.83687415e-02f, 1.80147514e-01f, -6.19244343e-03f,
  3.40196602e-02f, -1.45783618e-01f, -1.92472935e-01f, 6.40187413e-02f, 2.24471122e-01f, 9.49145257e-02f, -1.85370415e-01f, 8.74480307e-02f, -2.40285229e-02f, -6.13809079e-02f,
  2.28716701e-01f, -2.65435930e-02f, 2.17516068e-02f, -6.58587227e-03f, 1.11773245e-01f, -5.46016805e-02f, -7.19391257e-02f, -2.01383904e-01f, 1.52572647e-01f, -7.33778104e-02f,
  2.68704742e-01f, -7.42879510e-03f, 2.08281919e-01f, -1.39609188e-01f, 8.48349631e-02f, 2.00578243e-01f, 1.45716146e-01f, 1.53011054e-01f, 1.59834027e-01f, -9.17386115e-02f,
  1.24335192e-01f, 1.50600791e-01f, 1.74160510e-01f, -1.97714552e-01f, 3.69022251e-04f, -4.27400805e-02f, 1.39768329e-02f, -1.20643467e-01f, 1.09840661e-01f, 1.03963926e-01f,
  4.69096638e-02f, 1.47551224e-01f, -8.14361423e-02f, 2.47361913e-01f, 2.21163705e-01f, 9.56240147e-02f, -8.42508674e-02f, 1.61671355e-01f, -2.61578888e-01f, -3.52101102e-02f,
  1.81380466e-01f, 6.91440850e-02f, -1.41688827e-02f, 1.93752602e-01f, -1.47346184e-01f, 1.26784489e-01f, 1.15923598e-01f, -1.50108719e-02f, -1.09084584e-01f, 8.53150412e-02f,
  8.33837986e-02f, -1.05752379e-01f, -5.99793196e-02f, -6.54502809e-02f, 1.45255849e-01f, 2.59097606e-01f, 2.06458405e-01f, -3.13028693e-02f, -7.92530272e-03f, 2.28872355e-02f,
  2.55329818e-01f, -1.26943767e-01f, 4.19293009e-02f, -5.35380766e-02f, -7.69159794e-02f, -1.21929273e-01f, 6.63831308e-02f, 2.57867370e-02f, -1.77535057e-01f, -4.33084890e-02f,
  1.67812109e-01f, 2.82275587e-01f, 3.18081342e-02f, -4.39173616e-02f, -1.57668635e-01f, -1.30006775e-01f, -5.04206680e-02f, 2.44796142e-01f, -5.76714799e-02f, -2.23254785e-02f,
  -1.82822067e-02f, 4.46295850e-02f, 5.58144599e-02f, -1.34767100e-01f, 8.30324553e-03f, 3.11586764e-02f, 1.68771192e-01f, 1.39705971e-01f, 3.25147025e-02f, -1.91298679e-01f,
  1.06201343e-01f, -1.67896435e-01f, -4.21460681e-02f, 1.18914932e-01f, -8.43587145e-03f, 1.08943470e-01f, -9.17438045e-03f, 1.69328511e-01f, 1.23237856e-01f, 1.56407073e-01f,
  -1.19028063e-02f, 1.01242311e-01f, -1.07679769e-01f, -1.39424419e-02f, -3.13420855e-02f, -7.17815757e-03f, 8.24469025e-04f, 1.29830480e-01f, -1.15557179e-01f, 1.29472032e-01f,
  2.91501731e-01f, 3.21357301e-03f, -4.38292809e-02f, 8.99749622e-02f, 1.39827952e-01f, -9.83676612e-02f, -9.18209478e-02f, 1.73678815e-01f, 1.22958034e-01f, 3.35651696e-01f,
  1.38551041e-01f, 2.88055255e-03f, 2.49434352e-01f, -7.45116025e-02f, 2.31291205e-01f, -8.85945838e-03f, -9.29822698e-02f, -1.67327244e-02f, -1.71296690e-02f, -3.27039394e-03f,
  1.81220889e-01f, 2.33890682e-01f, -3.61664146e-02f, -4.69158869e-03f, 2.16176242e-01f, -4.87699583e-02f, -3.41725647e-02f, 1.56840399e-01f, -1.86422139e-01f, -1.11103961e-02f,
  -1.55195028e-01f, 1.52506202e-01f, 5.73019534e-02f, 9.21675935e-02f, 1.81073099e-01f, 5.66720627e-02f, 1.28009856e-01f, 1.22818530e-01f, 1.37001857e-01f, 1.22381216e-02f,
  -6.79835454e-02f, -1.88612401e-01f, -1.61175415e-01f, -1.13013545e-02f, -4.34533060e-02f, 5.83794639e-02f, 5.53114153e-02f, 1.17758453e-01f, 1.87133819e-01f, 1.58958986e-01f,
  1.70692548e-01f, -5.48685389e-03f, 8.72355998e-02f, 1.89559907e-01f, -1.41544983e-01f, 6.85709268e-02f, -2.16497228e-01f, 1.15934081e-01f, 5.49182594e-02f, 2.95247715e-02f,
  2.62922734e-01f, 1.16733089e-01f, -2.11063102e-02f, -5.90479597e-02f, -1.49249285e-01f, -1.15485769e-03f, 7.31207756e-03f, -1.31249785e-01f, -4.53093499e-02f, 1.49546772e-01f,
  6.05654903e-02f, 4.04463820e-02f, -5.00524864e-02f, 1.33653842e-02f, 1.02879733e-01f, -7.69595578e-02f, -8.63791779e-02f, 8.01991392e-03f, 8.16800520e-02f, 2.65724417e-02f,
  1.14008635e-01f, 2.73328096e-01f, -5.14891781e-02f, 4.66321670e-02f, 1.32427588e-01f, -1.26484543e-01f, -5.61327189e-02f, 1.15036383e-01f, -2.54838243e-02f, 2.65137106e-01f,
  7.78897712e-03f, 1.19504750e-01f, -1.40867218e-01f, 1.62023693e-01f, 7.45965317e-02f, 3.27581391e-02f, -1.19190598e-02f, 7.61676654e-02f, 1.11214764e-01f, 2.45745592e-02f,
  6.78399429e-02f, 2.11821496e-02f, -3.04012541e-02f, -3.09769139e-02f, 2.00567678e-01f, -1.39690429e-01f, -5.74991852e-02f, 1.17885008e-01f, -1.58299819e-01f, -2.88047045e-02f,
  2.17700437e-01f, 1.07645027e-01f, 1.79110974e-01f, 6.17613681e-02f, 1.20421372e-01f, -1.45986870e-01f, 1.66565061e-01f, 9.39224884e-02f, -2.18065515e-01f, 7.08802566e-02f,
  -1.57638505e-01f, -2.42415220e-01f, -2.72741113e-02f, 1.13527037e-01f, 4.02115174e-02f, 2.27067813e-01f, -1.97686777e-01f, 1.12020969e-01f, -4.15655551e-04f, -1.48904204e-01f,
  -7.82268494e-02f, 1.66224301e-01f, -1.81723177e-01f, 1.40432552e-01f, 2.96707526e-02f, -1.69010013e-01f, 1.54665843e-01f, 6.77702054e-02f, 5.48383500e-03f, -4.46325392e-02f,
  -1.13664426e-01f, 8.17637071e-02f, -4.07138541e-02f, -1.67306215e-02f, 7.44464770e-02f, 1.13287522e-03f, -2.13515624e-01f, -1.10373341e-01f, -1.62188455e-01f, -2.48716921e-01f,
  -6.36175573e-02f, 1.17387258e-01f, -1.17338069e-01f, 7.70058110e-02f, 2.03286633e-01f, -1.88884720e-01f, -1.69237121e-03f, 1.23400465e-01f, -3.46507393e-02f, 6.04878031e-02f,
  4.97031845e-02f, 1.03088424e-01f, -3.96224819e-02f, 3.24353427e-02f, 9.61080268e-02f, 1.45008326e-01f, 1.82874769e-01f, 4.35259901e-02f, 1.31409541e-02f, -8.31061527e-02f,
  -2.94815414e-02f, -1.05881598e-02f, -8.47108588e-02f, 8.34634230e-02f, 2.16547027e-01f, -1.70330536e-02f, -5.00164740e-02f, -6.92250323e-04f, -7.07994998e-02f, 6.49477839e-02f,
  1.65548194e-02f, 3.97813655e-02f, -1.81532111e-02f, -1.04198921e-02f, -5.74737638e-02f, 3.93126830e-02f, 2.02997833e-01f, -9.26599056e-02f, -4.28655632e-02f, -1.11004867e-01f,
  2.25478560e-02f, 7.41304308e-02f, -8.27199072e-02f, 3.80568691e-02f, 9.15822238e-02f, -1.01526216e-01f, 1.47169512e-02f, 1.62174646e-03f, 9.06539038e-02f, -5.16165458e-02f,
  4.36409712e-02f, 4.12036739e-02f, 3.91237028e-02f, 4.16467190e-02f, -1.43574893e-01f, 9.96887162e-02f, 1.50879743e-02f, 5.87436650e-03f, -7.87912756e-02f, 8.28480646e-02f,
  1.67634450e-02f, 1.38773434e-02f, 3.32845338e-02f, 6.79723173e-02f, 6.85259476e-02f, -2.77669877e-02f, 6.33604499e-03f, 8.12683180e-02f, 2.85303872e-03f, -9.24882293e-02f,
  7.48810843e-02f, -2.77010165e-02f, 4.59389463e-02f, 8.98123309e-02f, 6.00367710e-02f, -6.50436208e-02f, 6.61277473e-02f, 1.11133054e-01f, 3.60328406e-02f, -2.12674830e-02f,
  2.23434926e-03f, -1.86702982e-02f, 7.15542063e-02f, 9.90069285e-03f, 8.43840651e-03f, 1.58745632e-01f, -2.68407799e-02f, 6.03666343e-02f, -2.96151340e-01f, 6.64337426e-02f,
  1.32931679e-01f, 5.10131717e-02f, 3.77131075e-01f, -1.47277981e-01f, 2.36518368e-01f, 9.87488031e-02f, -8.96823853e-02f, 2.08428174e-01f, -1.01373985e-01f, 2.71680132e-02f,
  -5.85948974e-02f, 1.34021446e-01f, 3.94600600e-01f, 2.42284223e-01f, 2.53098518e-01f, -1.36844054e-01f, 9.88131166e-02f, -6.86631948e-02f, 7.71983468e-04f, 1.38145778e-02f,
  6.83224946e-02f, 3.14811468e-02f, -2.16828734e-01f, 1.57134056e-01f, -1.33930176e-01f, 1.22685552e-01f, 2.47730330e-01f, -3.13620746e-01f, 1.69002384e-01f, -8.11140239e-02f,
  -3.83481197e-02f, 5.53488620e-02f, 3.48527253e-01f, 8.78748521e-02f, 1.09849103e-01f, -7.74711668e-02f, 2.52601087e-01f, -4.93121482e-02f, -1.93082169e-02f, 1.21591859e-01f,
  -3.09723634e-02f, 3.11612785e-01f, 9.40675959e-02f, 2.33634755e-01f, -3.52613568e-01f, 1.66431457e-01f, 7.82642737e-02f, 6.33477867e-02f, -9.88485850e-03f, 1.89925805e-01f,
  -2.80977655e-02f, -1.74729954e-02f, -1.99344251e-02f, 2.48579681e-03f, 1.43912630e-02f, 1.04526281e-02f, 2.18925234e-02f, -9.09777265e-03f, 6.71955757e-03f, -9.62021016e-03f,
  -2.37946399e-02f, 1.38998334e-03f, -5.00878319e-02f, -8.61264020e-03f, 1.69885252e-02f, -4.12566103e-02f, 3.00187860e-02f, -3.62916477e-02f, -3.26518249e-03f, 1.58214252e-02f,
  -3.49441431e-02f, 1.65996887e-02f, -3.30477729e-02f, -4.49064113e-02f, -4.67384458e-02f, -1.28940595e-02f, -4.29920964e-02f, 3.95166688e-03f, -3.16125341e-02f, -6.58146432e-03f,
  -1.85590256e-02f, -6.13155141e-02f, -2.57622078e-02f, -6.89934753e-03f, -2.71848589e-02f, -3.75672355e-02f, -6.09022416e-02f, -1.07491864e-02f, -2.76481509e-02f, -2.24290229e-02f,
  -2.05742866e-02f, -4.31162938e-02f, -2.76126005e-02f, -2.77470835e-02f, -2.43274048e-02f, -2.95313657e-03f, -1.45520540e-02f, -4.08664048e-02f, -5.28296232e-02f, -3.53934872e-03f,
  -2.34155301e-02f, -3.65056656e-02f, -1.19553814e-02f, -1.69524830e-03f, -1.34158861e-02f, -9.24312416e-03f, -9.68264416e-03f, -9.07457061e-03f, -4.89644483e-02f, 2.25056279e-02f,
  -5.63025363e-02f, 6.74611237e-03f, -5.34486026e-03f, -3.04143392e-02f, 1.15730509e-01f, 1.38681427e-01f, 8.58333334e-02f, 9.77275521e-02f, 1.59887597e-02f, 1.02948420e-01f,
  -1.91997811e-02f, -2.02621356e-01f, -1.10363729e-01f, -1.16518758e-01f, 1.09128118e-01f, 2.09772140e-02f, 1.73183188e-01f, -2.59197671e-02f, -3.19076665e-02f, -1.12900669e-02f,
  -6.85285553e-02f, 5.68531714e-02f, -7.10127056e-02f, -1.33282244e-01f, -3.02400347e-02f, -1.60887122e-01f, -3.86391999e-03f, 1.21618338e-01f, 2.46997207e-01f, -8.13663453e-02f,
  5.63847460e-02f, -1.12082988e-01f, -5.34896515e-02f, -1.77320372e-03f, -1.77842632e-01f, 1.65486887e-01f, -7.78250098e-02f, -1.42318279e-01f, 8.08114361e-04f, 1.30612329e-01f,
  2.06457689e-01f, -9.45795923e-02f, -3.88372391e-02f, 1.04831524e-01f, 1.39240727e-01f, 7.46920332e-02f, -1.47498593e-01f, 1.32769912e-01f, 5.82423098e-02f, -6.56164289e-02f,
  4.75031212e-02f, 2.59092271e-01f, 4.66498360e-02f, -1.26008779e-01f, 2.28739288e-02f, 1.66752283e-02f, -1.35091186e-01f, -1.54587746e-01f, 6.59177452e-02f, 7.46108592e-02f,
  -8.63037109e-02f, -4.95410599e-02f, 1.24093279e-01f, -8.08333084e-02f, 1.47005484e-01f, 1.86707944e-01f, -1.74530163e-01f, -1.16867214e-01f, 5.87901920e-02f, 1.12923376e-01f,
  -3.66469100e-02f, 1.84516124e-02f, 1.04447365e-01f, 1.22400895e-01f, -6.33063763e-02f, 1.39728442e-01f, 4.98962775e-02f, -2.14723080e-01f, 2.62464464e-01f, -7.20519200e-02f,
  -1.68629721e-01f, 3.65180988e-03f, -1.85719386e-01f, -9.04335007e-02f, -1.35737464e-01f, 2.68570304e-01f, -9.36747193e-02f, -1.74143091e-02f, 5.66228405e-02f, -3.58303152e-02f,
  2.74408255e-02f, 1.76723674e-01f, 3.54924574e-02f, -2.01978888e-02f, -2.43056715e-02f, -5.05623072e-02f, -5.73846437e-02f, 9.60807130e-02f, 1.13129869e-01f, 2.09461242e-01f,
  -7.21991137e-02f, 2.60667298e-02f, 8.07836056e-02f, -1.25516811e-02f, -4.49974872e-02f, 1.52104393e-01f, -4.82390262e-02f, 1.49364769e-01f, 8.83320421e-02f, 1.43350422e-01f,
  1.37128949e-01f, -8.83819256e-03f, 1.34485349e-01f, -1.71033084e-01f, -1.11456225e-02f, 7.49709085e-02f, 6.38759509e-02f, -6.05695471e-02f, 2.00973675e-01f, 2.88135380e-01f,
  -9.04654562e-02f, -1.54287949e-01f, 1.65196270e-01f, -1.26041666e-01f, -1.35673359e-01f, 2.08645925e-01f, 5.51859215e-02f, -8.58181715e-02f, 3.44486684e-02f, 1.59982964e-01f,
  -1.33128256e-01f, -8.04530680e-02f, -7.56132826e-02f, -1.56125143e-01f, -1.14873759e-01f, -7.70541206e-02f, -3.37309055e-02f, -1.68661267e-01f, -1.59341022e-01f, -1.47919118e-01f,
  -1.83702961e-01f, 6.37232587e-02f, -1.17165580e-01f, 4.89100330e-02f, 4.33398485e-02f, -1.46195618e-02f, -1.79506335e-02f, 1.23814404e-01f, -1.15806669e-01f, 3.68159525e-02f,
  1.39551479e-02f, -3.45738344e-02f, 2.76470572e-01f, 6.58650845e-02f, 2.21511483e-01f, -2.55875103e-03f, 1.71598434e-01f, 1.61078908e-02f, 2.57869940e-02f, -1.24880448e-01f,
  1.92065492e-01f, -2.09853649e-01f, 1.42240793e-01f, 1.08492650e-01f, 1.56580865e-01f, -7.42838234e-02f, 3.55948769e-02f, -8.50234777e-02f, 2.33853415e-01f, 4.98631075e-02f,
  -2.98588220e-02f, 6.26098225e-03f, 1.65955201e-01f, 1.27545372e-01f, 1.01284921e-01f, -1.54754855e-02f, 1.02263145e-01f, 1.22995578e-01f, 1.61519900e-01f, 3.06092948e-02f,
  3.06647062e-01f, -2.83106361e-02f, -3.01277414e-02f, 1.14706740e-01f, 3.13409008e-02f, 2.29311287e-01f, -2.68834263e-01f, 1.39821142e-01f, 9.23076365e-03f, -1.52210712e-01f,
  4.26884973e-03f, -4.07412685e-02f, 1.19233653e-01f, -1.59409996e-02f, 1.08126961e-01f, -3.14552104e-03f, 2.63974871e-02f, 2.65366640e-02f, 5.91801070e-02f, -8.97065252e-02f,
  4.03658561e-02f, 1.11451738e-01f, -2.48043420e-04f, 2.92574227e-01f, 2.41450161e-01f, -1.75600171e-01f, 1.91117480e-01f, -8.30261484e-02f, -2.59742409e-01f, 3.12951952e-02f,
  5.72402254e-02f, -7.93380067e-02f, 4.67768237e-02f, 4.50205095e-02f, 5.40582975e-03f, 7.69836977e-02f, -3.05090798e-03f, 9.42173675e-02f, 5.61231002e-03f, 2.31580153e-01f,
  -1.31989136e-01f, -1.25243545e-01f, 1.04272179e-01f, 9.42538604e-02f, 2.98407912e-01f, 7.92078748e-02f, 1.89059377e-02f, 1.14905350e-01f, 3.11080553e-02f, 6.10645078e-02f,
  3.29613358e-01f, 6.12688139e-02f, -2.09753096e-01f, 2.26772815e-01f, -1.68489978e-01f, 1.25262871e-01f, -4.83928919e-02f, -1.08097434e-01f, 1.10955395e-01f, -3.58208956e-04f,
  2.81357504e-02f, 1.66516349e-01f, -4.61461544e-02f, 2.33278088e-02f, 1.30639924e-02f, 1.64669484e-01f, 2.64790565e-01f, 4.40335907e-02f, 8.21058676e-02f, -2.04218999e-01f,
  2.60562211e-01f, -1.04285613e-01f, -1.06569268e-01f, 2.79818386e-01f, -1.10521652e-02f, 1.46380246e-01f, 1.15717258e-02f, -4.25826348e-02f, -3.85307968e-02f, 8.30241814e-02f,
  -2.32671164e-02f, -1.48300231e-02f, -3.15526165e-02f, 1.64554380e-02f, -4.10466082e-02f, -5.85530587e-02f, -7.12745041e-02f, -1.00606168e-02f, -4.92634550e-02f, 7.89573714e-02f,
  -6.70291111e-02f, 1.47340417e-01f, 8.95209312e-02f, -1.45314381e-01f, -9.54878777e-02f, 1.23287290e-01f, -1.22715369e-01f, -4.61374819e-02f, -7.75903612e-02f, -8.67084041e-02f,
  2.56010979e-01f, -8.46739262e-02f, 2.63265043e-01f, 5.49517870e-02f, 1.61091805e-01f, 1.86549220e-02f, 5.44331335e-02f, -1.26577988e-01f, 2.14670882e-01f, -4.97407913e-02f,
  -9.02707055e-02f, 1.81352571e-01f, 1.12110414e-01f, -1.65465593e-01f, 4.16713953e-02f, 2.87657343e-02f, 1.44203603e-01f, -3.92511673e-02f, 4.37004343e-02f, -1.10793598e-01f,
  2.47042160e-02f, -6.48381747e-03f, 1.08778261e-01f, 8.98127034e-02f, -3.79941948e-02f, 5.31862490e-02f, 1.74990267e-01f, 1.59700796e-01f, 2.94317067e-01f, -6.80586025e-02f,
  4.82864678e-02f, 1.05938257e-03f, 1.10353395e-01f, 4.07140702e-02f, -1.75985202e-01f, 7.60667324e-02f, 6.54826500e-03f, -2.66594104e-02f, 1.34369686e-01f, -5.52585255e-03f,
  2.39811867e-01f, -5.24914414e-02f, 5.12373485e-02f, 9.81042758e-02f, -1.14185959e-01f, -1.32828385e-01f, -1.04360446e-01f, 2.09678840e-02f, -1.25232432e-02f, -5.87759912e-02f,
  -1.10168405e-01f, 2.99110468e-02f, 5.34912944e-03f, -3.96768339e-02f, -7.53374174e-02f, 5.26228100e-02f, 4.46074866e-02f, -7.22284317e-02f, -1.24874212e-01f, 1.03467219e-01f,
  -1.34300753e-01f, -6.06979653e-02f, -6.63567260e-02f, 1.33599536e-02f, 2.76915789e-01f, 1.05978847e-01f, 1.79515630e-01f, -8.13479125e-02f, 1.38881519e-01f, -1.89378392e-02f,
  -9.15324315e-02f, -6.10904209e-02f, -1.92932151e-02f, -1.75111830e-01f, 1.53995141e-01f, -8.04099143e-02f, 4.88407025e-03f, 1.76574327e-02f, -1.76578596e-01f, -1.56822428e-01f,
  1.00263029e-01f, -3.49046513e-02f, 9.55538675e-02f, -5.34630865e-02f, 3.88649628e-02f, 4.33079377e-02f, 7.50103816e-02f, -6.56613410e-02f, -3.30572985e-02f, -1.24902825e-03f,
  4.52066399e-02f, -2.64270380e-02f, 1.55680150e-01f, 5.20296134e-02f, -7.90553391e-02f, 1.04001574e-01f, 2.30404474e-02f, 2.20214322e-01f, -2.17178658e-01f, 2.90886983e-02f,
  -5.79672009e-02f, -1.08935893e-01f, -4.80731949e-03f, -9.22572240e-02f, 1.55529687e-02f, 1.77051146e-02f, -5.05140238e-03f, -8.36449414e-02f, -2.08748598e-02f, -9.60571915e-02f,
  -9.49282432e-04f, -5.03444634e-02f, 9.17910412e-02f, 2.38827709e-02f, -5.77808134e-02f, -2.19666258e-01f, -1.49075538e-01f, -1.73699826e-01f, -1.43657431e-01f, -1.15894809e-01f,
  2.49556899e-01f, 1.16127804e-01f, -1.12470880e-01f, 1.93148807e-01f, -3.13101113e-01f, 2.07184717e-01f, -1.08975865e-01f, 1.06573731e-01f, 2.35531613e-01f, 8.27221051e-02f,
  1.07372232e-01f, -5.00458665e-02f, 1.40705988e-01f, 4.25802693e-02f, -8.39157477e-02f, -1.55763067e-02f, -1.57003641e-01f, -2.81262565e-02f, 9.05916840e-02f, -1.49495751e-02f,
  -3.04505527e-02f, 6.75998479e-02f, -5.48110195e-02f, -8.72906595e-02f, 2.13135287e-01f, -2.25112379e-01f, 2.52143353e-01f, -1.13034640e-02f, 1.69414934e-02f, 2.18890056e-01f,
  1.44676631e-03f, 2.15284694e-02f, 1.70659795e-01f, -5.73049560e-02f, -1.09184735e-01f, -9.36672390e-02f, 6.07772619e-02f, -4.68374044e-02f, -1.80793136e-01f, 1.60418049e-01f,
  -7.78509900e-02f, 6.69253990e-02f, -3.67969386e-02f, -1.70698360e-01f, 1.62776895e-02f, -2.01007813e-01f, 1.45596847e-01f, -1.53726801e-01f, 7.03576058e-02f, 1.59669057e-01f,
  -4.59587425e-02f, -7.41394758e-02f, -9.68873501e-02f, -1.50929773e-02f, 9.36271548e-02f, -5.99118136e-02f, -1.63300797e-01f, 1.12288678e-02f, 1.40527755e-01f, 4.46835123e-02f,
  -5.43272085e-02f, 2.46468019e-02f, -1.53470576e-01f, 1.01284804e-02f, 1.55133903e-01f, -4.29016985e-02f, 1.65574789e-01f, 2.08818421e-01f, -5.38313994e-04f, -5.03410362e-02f,
  2.36172974e-02f, 1.44631609e-01f, 4.41018976e-02f, 5.43256067e-02f, 1.31186564e-02f, -1.43498033e-01f, 9.73041952e-02f, -1.09546103e-01f, -6.51516998e-03f, -4.41228831e-03f,
  3.87211912e-04f, 1.22457832e-01f, 1.24554783e-02f, -7.02471882e-02f, 1.77550346e-01f, -1.24402806e-01f, -5.27587347e-03f, -4.77633923e-02f, -1.33732697e-02f, -4.96165566e-02f,
  1.06148094e-01f, 6.18433654e-02f, -1.99344028e-02f, -1.68171257e-01f, -1.84706915e-02f, -1.41541213e-01f, 2.77438294e-02f, 1.86399445e-01f, 5.13419099e-02f, 1.59034595e-01f,
  4.45604622e-02f, 2.01214030e-02f, -1.66742966e-01f, -1.39943674e-01f, 1.94672883e-01f, 1.95412144e-01f, -1.93589658e-01f, 1.22908838e-01f, 9.48667824e-02f, -2.37248331e-01f,
  -4.28470671e-02f, 1.78116813e-01f, -2.53130384e-02f, -1.38832778e-02f, 2.50618458e-01f, 1.97968379e-01f, -4.42516878e-02f, 7.22255558e-02f, -3.89281451e-03f, 1.94792822e-02f,
  1.01890184e-01f, -8.17372352e-02f, -9.51451994e-03f, 1.02240115e-01f, -4.24620397e-02f, 1.27405599e-01f, -1.61661189e-02f, 1.29950538e-01f, -1.57200232e-01f, -6.78176358e-02f,
  1.11910284e-01f, -8.07642378e-03f, -1.23342499e-02f, -6.06856197e-02f, -9.86743942e-02f, 1.04285561e-01f, 9.13350750e-03f, 4.02590856e-02f, 1.04795368e-02f, 1.55061781e-01f,
  -1.98873267e-01f, 6.48563504e-02f, 1.05049908e-01f, -7.53767416e-02f, 1.64965943e-01f, 8.40026736e-02f, -6.02296665e-02f, -4.69508767e-02f, 2.35695541e-01f, -3.71752642e-02f,
  1.55611128e-01f, -2.20626052e-02f, -3.61794699e-03f, 1.98512807e-01f, -1.93842262e-01f, -2.70168781e-02f, -2.25623120e-02f, -7.27392361e-02f, 1.52515411e-01f, 6.11937381e-02f,
  -5.35558164e-02f, 1.28849924e-01f, -5.10722958e-02f, 7.86125809e-02f, 1.39322236e-01f, 1.98206097e-01f, 1.95123971e-01f, 8.98591354e-02f, 1.58439264e-01f, 1.03930265e-01f,
  4.52433936e-02f, -3.42140943e-02f, 1.02376498e-01f, 6.04409054e-02f, 5.46127632e-02f, 5.24463542e-02f, 1.60617530e-01f, 5.75608090e-02f, 1.65589705e-01f, 2.21763492e-01f,
  1.43585252e-02f, 1.71018038e-02f, -3.40453871e-02f, 6.37714416e-02f, 1.74023747e-01f, -1.88908484e-02f, -1.33676648e-01f, 1.02524215e-03f, -1.92666259e-02f, -6.06268905e-02f,
  -2.79087611e-02f, 6.58575520e-02f, -1.05832309e-01f, -9.75338146e-02f, -1.23433918e-01f, -2.56974646e-03f, -4.98273894e-02f, 1.69715155e-02f, -2.63141040e-02f, 3.12679401e-03f,
  5.41263372e-02f, 4.56079245e-02f, -7.25089163e-02f, -2.08000606e-03f, 1.26805946e-01f, -4.65175435e-02f, 5.36263548e-02f, -3.14065479e-02f, 5.87486178e-02f, -1.91566542e-01f,
  2.49140039e-02f, -3.01632173e-02f, -2.64033992e-02f, -1.86784700e-01f, -8.49695317e-03f, -1.25231192e-01f, 1.65938307e-02f, 1.04362369e-02f, -7.47293979e-02f, -3.55018452e-02f,
  1.40113637e-01f, -8.76512006e-02f, 9.08978935e-03f, -9.87887755e-02f, 5.93671165e-02f, -8.69818106e-02f, 1.26984805e-01f, 5.09095713e-02f, 1.21017762e-01f, -4.25659381e-02f,
  1.09990351e-01f, 4.67734598e-02f, -6.95094541e-02f, 8.00089464e-02f, -9.33324397e-02f, 1.78888530e-01f, -7.94185326e-02f, 3.41664329e-02f, -2.02828184e-01f, -1.21599324e-01f,
  4.87849079e-02f, 8.82106125e-02f, -5.69811538e-02f, -4.96257432e-02f, 7.82855228e-02f, 1.52790830e-01f, 2.17297375e-02f, 8.80461857e-02f, 9.50385481e-02f, -5.61061827e-03f,
  -5.60596287e-02f, 5.46531528e-02f, -3.67297009e-02f, -4.14915159e-02f, 4.48066145e-02f, 1.58537507e-01f, -9.67517868e-02f, -3.68721411e-02f, 3.03906538e-02f, -1.44173671e-02f,
  1.95088699e-01f, -1.78738665e-02f, 2.07565174e-01f, -3.73010896e-03f, -9.85734537e-02f, 9.75471269e-03f, -9.63155702e-02f, 5.12891216e-03f, 4.58357818e-02f, -7.78505579e-02f,
  1.94473386e-01f, 5.33789583e-02f, 1.36503607e-01f, -1.25521228e-01f, -8.71945266e-03f, -6.55986741e-02f, 6.20245077e-02f, -6.68878257e-02f, 8.44326615e-02f, 3.30673382e-02f,
  -7.55007043e-02f, 1.67461798e-01f, -4.98978272e-02f, 8.18964243e-02f, 1.93634838e-01f, -1.17840789e-01f, 3.34789930e-03f, -3.95618044e-02f, -7.10109025e-02f, -3.27459536e-02f,
  1.54242709e-01f, 2.03976691e-01f, 5.18223122e-02f, -1.06185046e-03f, 1.45542085e-01f, -1.87189374e-02f, -1.72757972e-02f, 7.04603344e-02f, 2.91765425e-02f, 2.35289425e-01f,
  -4.25982922e-02f, 1.98271394e-01f, -1.96857616e-01f, 9.95124206e-02f, 1.05634920e-01f, 1.40907660e-01f, -1.44092198e-02f, 1.57692596e-01f, -7.48795867e-02f, -1.19288258e-01f,
  -5.48350513e-02f, 3.50996628e-02f, -5.08866161e-02f, -3.60633768e-02f, -3.16823386e-02f, -8.83916952e-03f, -1.08905742e-03f, -2.62834970e-02f, -1.66960746e-01f, 1.18699595e-01f,
  2.12743685e-01f, -9.33998302e-02f, -6.29487708e-02f, 1.58639789e-01f, -1.49413913e-01f, -5.52948490e-02f, -6.58559948e-02f, -3.24070752e-02f, 2.76057988e-01f, 5.21413758e-02f,
  2.02221975e-01f, -5.39308079e-02f, 2.44350716e-01f, -5.08989170e-02f, -8.35911036e-02f, -1.34961963e-01f, -6.55548720e-05f, -7.72955865e-02f, 1.18803065e-02f, 8.40409845e-03f,
  7.60207921e-02f, -8.26424509e-02f, -1.51813954e-01f, -8.98954645e-02f, 2.09824428e-01f, -1.45749882e-01f, 1.41996369e-01f, -5.37384264e-02f, 2.75894590e-02f, 3.32553983e-02f,
  -2.08502170e-02f, 7.96362478e-03f, -3.39254178e-02f, 6.05754629e-02f, 1.22781821e-01f, 9.88766551e-02f, 1.85226873e-01f, -2.02090517e-02f, -1.29086807e-01f, 2.36161668e-02f,
  7.71913379e-02f, 1.86690360e-01f, -2.39607438e-01f, 8.93170983e-02f, 6.40996173e-03f, -1.81464955e-01f, 8.69369507e-02f, -2.49401312e-02f, 1.04361445e-01f, 4.34374548e-02f,
  5.64862154e-02f, -4.99809980e-02f, -1.17647350e-01f, 1.24768429e-02f, -7.96009041e-03f, -1.38465360e-01f, 1.25917971e-01f, 7.59690627e-02f, -1.48102731e-01f, 5.50983734e-02f,
  -1.70737486e-02f, -2.17068553e-01f, 1.36808649e-01f, -8.68930370e-02f, -1.12891316e-01f, 5.47792390e-02f, -1.72167704e-01f, 1.32165834e-01f, -1.58491522e-01f, 2.86334515e-01f,
  7.52579346e-02f, 1.04124378e-03f, 1.94640756e-01f, 9.89752039e-02f, 1.26072064e-01f, 9.20115411e-02f, 1.49089590e-01f, -8.25904869e-03f, -1.33888852e-02f, -5.45515493e-02f,
  -6.80172890e-02f, -3.32786478e-02f, 1.28763914e-01f, 1.17527850e-01f, 3.94727662e-03f, -5.25433421e-02f, 3.16231698e-02f, -1.49100021e-01f, 2.91941538e-02f, 6.66206926e-02f,
  -4.44358028e-03f, 1.08275443e-01f, 9.86368954e-02f, 6.45477846e-02f, 2.17134103e-01f, 1.30485147e-02f, 2.58418739e-01f, -8.10820833e-02f, 1.13063110e-02f, 8.01474229e-02f,
  1.70619622e-01f, -7.84785151e-02f, 8.03456008e-02f, 2.59265631e-01f, -5.56470342e-02f, -2.20113955e-02f, 6.26417622e-02f, -6.24872819e-02f, -1.23635218e-01f, -2.85432376e-02f,
  -4.14375998e-02f, -2.07739785e-01f, 5.01041450e-02f, 1.54914275e-01f, -2.35441253e-02f, -1.37213275e-01f, -1.21939927e-02f, 6.34782538e-02f, 1.66599881e-02f, -4.95405570e-02f,
  -6.92135245e-02f, -8.03977847e-02f, 1.19651139e-01f, -1.04505166e-01f, -1.49060458e-01f, 3.74733992e-02f, -1.25895485e-01f, 4.61394079e-02f, 4.68591787e-02f, 1.02619277e-02f,
  1.53311312e-01f, 1.71914086e-01f, 1.23411722e-01f, -2.11224053e-02f, 1.23803757e-01f, 2.30977491e-01f, 9.99392793e-02f, 2.70303130e-01f, -8.58296081e-02f, 4.16416600e-02f,
  1.55259892e-01f, 2.43019406e-02f, 1.43037513e-01f, 1.85059849e-02f, 4.81124705e-04f, -7.40483450e-03f, 1.46173552e-01f, -1.47166565e-01f, 2.61514653e-02f, 7.32177272e-02f,
  -7.97347054e-02f, -4.68050018e-02f, -8.61089453e-02f, 2.19598468e-02f, 1.62404016e-01f, 2.03459963e-01f, 2.18295902e-01f, -1.48048401e-01f, 4.18784358e-02f, -1.21314839e-01f,
  1.05610311e-01f, 1.73338234e-01f, 1.72905743e-01f, 1.73897415e-01f, 6.66402951e-02f, 6.18568249e-02f, 1.03927255e-01f, 8.29437450e-02f, 5.04976921e-02f, 3.17560434e-01f,
  -1.10968657e-01f, 2.75815576e-01f, 7.59137720e-02f, -6.10318556e-02f, -1.87899977e-01f, 1.56300217e-01f, -8.70402530e-02f, 1.69113070e-01f, 9.36114937e-02f, 1.18845336e-01f,
  9.41041335e-02f, 9.80168208e-02f, 1.19589411e-01f, 7.27781504e-02f, 7.15071708e-02f, 8.47903118e-02f, -4.49514724e-02f, 1.86419129e-01f, 6.85658082e-02f, -2.06381321e-01f,
  1.45131335e-01f, -2.56130323e-02f, -2.31239021e-01f, 6.77447319e-02f, 1.16550885e-01f, -7.18182474e-02f, 1.85639456e-01f, 1.15117855e-01f, 1.17363960e-01f, 1.34412929e-01f,
  -1.39806122e-01f, 1.30564228e-01f, -1.46065637e-01f, 2.40878582e-01f, -2.64628772e-02f, -1.33311182e-01f, 6.55858517e-02f, 7.02058105e-03f, 4.41012271e-02f, 9.15005431e-02f,
  -2.39177868e-02f, 6.06116131e-02f, -1.10535102e-03f, -1.56167177e-02f, 1.72662497e-01f, 9.29028541e-02f, -1.79676354e-01f, 2.23186776e-01f, -1.71441838e-01f, 1.02489591e-01f,
  1.52637303e-01f, 1.52168600e-02f, 3.80047336e-02f, -3.12501490e-02f, 4.55397666e-02f, 4.76033948e-02f, -1.34237289e-01f, 1.13976896e-02f, -1.48122251e-01f, 1.23433866e-01f,
  2.33446404e-01f, 1.33242920e-01f, -5.19576855e-02f, -5.60426153e-02f, 3.43090206e-01f, 1.71986952e-01f, -1.04974620e-01f, 1.86476469e-01f, -1.60877600e-01f, 6.32739887e-02f,
  -4.32987511e-02f, 2.84474269e-02f, -8.11021179e-02f, -5.23666702e-02f, 2.62349099e-01f, 1.40472546e-01f, 8.08110759e-02f, 1.12791672e-01f, 1.38579771e-01f, 1.24378903e-02f,
  -7.81927928e-02f, -2.17735376e-02f, -1.71384797e-01f, 1.19179867e-01f, 1.11513212e-01f, 9.89620294e-03f, -3.92948762e-02f, -2.03411896e-02f, -5.30728418e-03f, -1.05299518e-01f,
  1.77063346e-02f, 1.15751840e-01f, -4.53988500e-02f, -3.66545841e-02f, -1.60782799e-01f, -1.57501265e-01f, -5.15746549e-02f, 1.73565194e-01f, -1.74508110e-01f, 2.20114619e-01f,
  1.90555066e-01f, 1.52653918e-01f, 2.60073811e-01f, -8.25142860e-03f, -1.31354824e-01f, 2.26954430e-01f, 1.08270846e-01f, 5.46614714e-02f, 3.47917467e-01f, 1.76799521e-01f,
  5.58823682e-02f, 1.82193562e-01f, -1.98080570e-01f, -2.50243638e-02f, 3.42683904e-02f, 3.62097323e-02f, 1.98414266e-01f, 2.93671310e-01f, 7.36902356e-02f, -6.57950109e-03f,
  -3.49365883e-02f, -8.94015804e-02f, 7.96912163e-02f, 5.70570566e-02f, 1.83835745e-01f, 1.29732072e-01f, 3.41862887e-02f, -2.61021286e-01f, 3.25808704e-01f, -1.03966288e-01f,
  8.34860802e-02f, 3.13234031e-01f, 2.36243218e-01f, -1.20982081e-02f, 2.49364123e-01f, 1.14717104e-01f, -1.02147885e-01f, 1.75693288e-01f, 8.65871459e-02f, 8.64074826e-02f,
  8.30157399e-02f, 1.10568784e-01f, -5.09107523e-02f, 2.62956414e-02f, -9.77710411e-02f, -1.04163364e-01f, -4.15142626e-02f, -1.94978677e-02f, 5.27615324e-02f, 4.60085422e-02f,
  3.44393179e-02f, 1.28400505e-01f, 1.00455917e-02f, -2.79313624e-02f, 1.92372262e-01f, 9.90260765e-02f, -9.50517803e-02f, 1.89116523e-02f, -1.14344843e-02f, -1.60038009e-01f,
  4.06933427e-02f, 1.92761004e-01f, -2.98425350e-02f, 7.36410171e-02f, 2.09748238e-01f, -2.64453106e-02f, 1.56104326e-01f, 1.42177016e-01f, -1.71436399e-01f, 1.69761375e-01f,
  9.23786089e-02f, 1.35194078e-01f, 5.18923253e-02f, 2.97129065e-01f, 8.65474343e-02f, 4.30004820e-02f, 1.49267241e-02f, -4.41271178e-02f, -1.36579365e-01f, 2.33812079e-01f,
  -2.02406384e-02f, 1.97714701e-01f, -6.58988506e-02f, 6.57762215e-02f, 1.21809198e-02f, 1.46660671e-01f, -8.06803107e-02f, 8.91305506e-04f, -3.77909746e-03f, -1.28368616e-01f,
  3.33741307e-02f, -1.83781743e-01f, 1.60283491e-01f, -6.34497479e-02f, -1.50170438e-02f, 1.35525707e-02f, 2.27332279e-01f, 1.17637932e-01f, 5.88413961e-02f, -5.59630319e-02f,
  -5.51896356e-02f, 1.19014680e-01f, 2.49562436e-03f, 7.71212997e-03f, 3.34662907e-02f, 7.37090316e-03f, 2.16320083e-02f, -4.06546853e-02f, 1.92702636e-01f, -4.93590385e-02f,
  5.46563417e-02f, 1.56596482e-01f, -1.31044477e-01f, 2.03974228e-02f, 5.09067290e-02f, 5.28965611e-04f, 4.17579673e-02f, -2.45662202e-04f, -5.24983741e-03f, -1.48288712e-01f,
  3.12311389e-02f, 3.05630565e-02f, -1.13163106e-01f, 9.46485326e-02f, -1.29984602e-01f, -1.60429850e-01f, 1.97411478e-02f, -2.38938071e-02f, -7.30047598e-02f, 1.66523546e-01f,
  1.44859646e-02f, 9.18390229e-02f, 8.44075531e-03f, -2.37106070e-01f, 1.28091443e-02f, -1.05316117e-02f, -4.43971418e-02f, -5.88750057e-02f, 1.48990713e-02f, -7.93362185e-02f,
  3.39856707e-02f, 5.77478856e-02f, 8.09353739e-02f, -1.78107455e-01f, -4.92945733e-03f, 4.66719717e-02f, -9.19497460e-02f, 2.88561042e-02f, -3.62152308e-02f, -6.26078546e-02f,
  -2.93066036e-02f, -1.34921791e-02f, -1.20868362e-01f, -1.73143357e-01f, 7.07451627e-02f, 1.19388714e-01f, -6.57408088e-02f, 6.85067475e-02f, 1.37579054e-01f, -1.35515392e-01f,
  2.68657766e-02f, 1.12564713e-01f, -8.87161344e-02f, 1.31749868e-01f, 8.46893061e-03f, 5.72314002e-02f, -5.07862940e-02f, -8.12452585e-02f, -4.38970216e-02f, -2.26263881e-01f,
  2.07305606e-02f, 9.61015224e-02f, 1.14097737e-01f, 5.52262254e-02f, -1.78966913e-02f, -2.87994623e-01f, 1.90548047e-01f, -3.39524746e-01f, -6.88703880e-02f, 2.28297979e-01f,
  -1.66180640e-01f, 7.08023906e-02f, -2.33913913e-01f, 2.89055079e-01f, 8.56508315e-03f, 7.12704211e-02f, 1.74779698e-01f, -5.25879040e-02f, 7.44316950e-02f, 5.23301400e-02f,
  -7.80372098e-02f, 4.56420742e-02f, -1.84080780e-01f, 1.77820802e-01f, -1.79549813e-01f, 1.41962767e-01f, 2.38342449e-01f, -6.40676171e-02f, -1.13024563e-01f, 1.93403497e-01f,
  1.05556339e-01f, 9.31159407e-03f, -2.84914766e-02f, -2.69869398e-02f, 2.18796343e-01f, 6.30054250e-02f, -6.75298423e-02f, 1.80759668e-01f, 2.08017379e-01f, -1.32987693e-01f,
  2.18688235e-01f, -1.37490079e-01f, -1.64290771e-01f, -8.28270391e-02f, -7.83626437e-02f, -1.55870557e-01f, -6.51073307e-02f, 8.25657919e-02f, -1.46608382e-01f, -1.42170817e-01f,
  1.33485869e-01f, -1.62297502e-01f, -1.00390442e-01f, -3.58643606e-02f, 5.59178479e-02f, -1.24524064e-01f, -1.92509323e-01f, -5.49609400e-02f, -1.28996715e-01f, -1.05729878e-01f,
  -1.25024747e-02f, -1.54332779e-02f, -1.30821513e-02f, -2.35226899e-02f, 1.74710143e-03f, -1.00428564e-02f, -1.48918889e-02f, 6.35498902e-04f, 1.60785753e-03f, -1.63058210e-02f,
  1.32017657e-02f, -1.73368156e-02f, -2.29512267e-02f, -2.96292752e-02f, -2.02739369e-02f, -2.50628870e-02f, -2.62381900e-02f, -2.09286045e-02f, -3.14897373e-02f, -2.93870829e-02f,
  -7.04513211e-03f, -3.05828955e-02f, -3.02893110e-03f, -1.80477072e-02f, -3.06752641e-02f, -1.95161235e-02f, -2.63154954e-02f, -3.46551165e-02f, -1.52756833e-02f, -2.84925736e-02f,
  -1.92774720e-02f, -2.39214953e-02f, -1.34297768e-02f, -3.19184363e-02f, -1.53767634e-02f, -2.81582531e-02f, -1.94386616e-02f, -2.33460031e-02f, -1.94085762e-02f, -3.22102718e-02f,
  -3.22425105e-02f, -8.44972616e-04f, -2.11177934e-02f, -2.03733072e-02f, -2.42983941e-02f, -1.56121198e-02f, -1.38800684e-02f, -2.46199220e-02f, -1.11431479e-02f, -1.62087549e-02f,
  -2.28795148e-02f, -2.49795076e-02f, -1.42069450e-02f, -1.80091932e-02f, -2.40714345e-02f, -3.05678658e-02f, -1.65057220e-02f, -1.11491121e-02f, -9.20583121e-03f, -2.14735642e-02f,
  -2.06796322e-02f, -3.42830457e-02f, -1.83676730e-03f, -1.84412748e-02f, -9.53039452e-02f, -4.69159372e-02f, -9.41584483e-02f, -2.04967670e-02f, -1.06126137e-01f, -7.81406537e-02f,
  -2.14496315e-01f, 6.78732544e-02f, 2.42098346e-02f, -4.79697902e-03f, 1.47698402e-01f, 8.03715810e-02f, 3.35043669e-03f, -1.38101116e-01f, -2.09896192e-01f, -1.16717309e-01f,
  -7.22940266e-02f, -4.12766859e-02f, -1.95055872e-01f, -1.69921160e-01f, 5.21841235e-02f, -2.66208351e-01f, 2.21754044e-01f, 1.43085390e-01f, -6.53849244e-02f, -2.63929702e-02f,
  -3.86783824e-04f, -1.47292838e-01f, 7.47480020e-02f, -9.11722630e-02f, -9.86997187e-02f, 1.57097280e-01f, 5.72154373e-02f, -3.84392552e-02f, 2.03466024e-02f, 1.04799390e-01f,
  9.23440605e-02f, 3.36650573e-02f, -5.72875142e-02f, -2.32162684e-01f, -1.85692161e-01f, 1.68241218e-01f, 5.65443002e-02f, 1.26401469e-01f, -1.42822251e-01f, -1.25825450e-01f,
  -5.60800135e-02f, -2.46023964e-02f, 6.45693913e-02f, -6.13204651e-02f, -2.59673838e-02f, 6.26334324e-02f, -3.15560289e-02f, -1.12050921e-01f, 6.21226057e-03f, -1.92545325e-01f,
  -1.68822408e-01f, 4.39865217e-02f, 1.99481606e-01f, -1.69225737e-01f, 1.49894759e-01f, -9.64341387e-02f, -2.00711638e-01f, -6.42645359e-02f, 1.11752883e-01f, 8.99858773e-02f,
  1.06908113e-01f, 5.87051548e-02f, -3.63341495e-02f, -5.02189398e-02f, -6.45087436e-02f, -1.72463045e-01f, -2.34961659e-01f, 1.36933118e-01f, 6.08478952e-03f, 6.79238066e-02f,
  -9.10734013e-03f, -6.01576716e-02f, 1.02744140e-01f, 1.41674191e-01f, 2.49011472e-01f, -1.46756813e-01f, 3.85446101e-02f, 1.64104477e-01f, -5.03921025e-02f, -4.86748219e-02f,
  -7.39007220e-02f, 7.15324506e-02f, 1.97559781e-02f, 2.12254375e-02f, 2.18945712e-01f, -7.75986761e-02f, 6.62174299e-02f, -1.50976166e-01f, -1.38195813e-01f, 4.56861220e-02f,
  1.12884954e-01f, -7.18051195e-02f, 6.05125651e-02f, -1.84637122e-02f, -4.72129323e-02f, 1.25370428e-01f, -8.21271613e-02f, -7.49612320e-03f, 7.70143792e-02f, 5.94703592e-02f,
  5.05016707e-02f, -1.28062233e-01f, -4.44805156e-03f, 1.10090099e-01f, 1.80389374e-01f, 2.43616328e-01f, 5.28038256e-02f, -1.48046734e-02f, -5.26455492e-02f, 1.10574393e-02f,
  2.35511418e-02f, 1.53440371e-01f, -1.14544235e-01f, 1.39981031e-01f, 1.46253705e-02f, -4.32875976e-02f, -1.54177278e-01f, 1.64553359e-01f, 1.05978206e-01f, -3.46639007e-02f,
  5.54105826e-02f, 1.27389774e-01f, 1.57817379e-01f, 1.60767421e-01f, 1.38843983e-01f, 5.85769825e-02f, 1.48072571e-01f, 1.19043753e-01f, -3.40949781e-02f, -7.79315829e-02f,
  -6.27972037e-02f, -5.58483340e-02f, 1.50448829e-01f, -9.38523337e-02f, -1.67579666e-01f, 8.36476833e-02f, -7.13573545e-02f, -6.61553666e-02f, -1.08132102e-02f, 1.26254737e-01f,
  6.93964213e-02f, 1.88698564e-02f, -8.47428516e-02f, -6.10878766e-02f, -1.81205586e-01f, 1.68251067e-01f, 5.59028201e-02f, 2.38867216e-02f, 1.00045763e-01f, 9.76741537e-02f,
  5.79571798e-02f, 2.24527996e-03f, -6.41776016e-03f, 1.05467230e-01f, -4.42663766e-02f, -5.41944019e-02f, 1.61396027e-01f, 9.47443619e-02f, -9.08725783e-02f, 7.72548467e-02f,
  -1.49866417e-01f, 1.23394512e-01f, 1.38114676e-01f, -5.58861159e-02f, 2.01203283e-02f, -3.11123710e-02f, 1.37405843e-01f, -9.33380276e-02f, 3.19235958e-02f, 1.35201737e-01f,
  8.91611353e-03f, -3.15284953e-02f, 2.22594485e-01f, 6.06609061e-02f, -5.83502762e-02f, -1.09205894e-01f, 2.37284765e-01f, 7.92494863e-02f, -5.45344502e-02f, 2.27489144e-01f,
  -7.36139119e-02f, -3.25352065e-02f, 5.82156442e-02f, 1.26779348e-01f, -1.24092020e-01f, 9.20977257e-03f, 7.56499767e-02f, 1.41591713e-01f, 1.17800469e-02f, 7.85604045e-02f,
  1.18515715e-01f, 1.81260839e-01f, 1.72667041e-01f, -1.57372370e-01f, 8.78100097e-03f, -1.92749783e-01f, 3.39727439e-02f, -6.49057254e-02f, 8.43241587e-02f, 2.47439012e-01f,
  7.83453211e-02f, 1.76921487e-01f, 2.02143006e-02f, 1.96448565e-01f, 2.27553189e-01f, 3.91736673e-03f, -4.73312847e-02f, 1.31280378e-01f, -1.11282937e-01f, -8.96912962e-02f,
  3.03747326e-01f, -2.56544780e-02f, -2.59265909e-03f, 2.17680290e-01f, -2.18245849e-01f, 5.73094040e-02f, -5.58015797e-03f, 5.60890920e-02f, -1.90031290e-01f, 2.22164486e-02f,
  5.03818765e-02f, 1.02492958e-01f, 5.50321639e-02f, -1.08162299e-01f, 1.48872048e-01f, 1.32984132e-01f, 1.03119604e-01f, -4.95909676e-02f, -1.00353325e-03f, 4.51876223e-02f,
  1.51267782e-01f, -5.83861545e-02f, 1.00132026e-01f, 1.63631439e-01f, -6.39304221e-02f, -1.63570657e-01f, 7.59921595e-02f, -6.90604076e-02f, -2.04192802e-01f, -1.07719414e-01f,
  1.10261841e-02f, 2.25803465e-01f, -7.31265312e-03f, -1.50619755e-02f, -6.07204661e-02f, -9.86454487e-02f, 2.77474336e-02f, 1.30126774e-01f, -1.24099001e-01f, -1.08818226e-01f,
  4.16585524e-03f, 1.33100925e-02f, 4.22347225e-02f, 1.00390151e-01f, 1.86970264e-01f, 4.95373737e-03f, -3.83676797e-01f, -1.02801248e-01f, -1.41290843e-01f, -2.28429630e-01f,
  2.14704871e-01f, 7.47590810e-02f, -1.12582743e-02f, -9.97361615e-02f, -1.66167781e-01f, 1.04160741e-01f, -9.32740346e-02f, 1.46976560e-01f, -1.30105942e-01f, 1.32728457e-01f,
  1.90486401e-01f, -1.21078633e-01f, 8.63954648e-02f, 2.53013134e-01f, 5.70983067e-02f, 5.40787494e-03f, -2.70025805e-02f, -1.98913410e-01f, 1.44091994e-02f, -1.96455330e-01f,
  -1.02135286e-01f, 3.04003447e-01f, 1.28131208e-03f, -6.78317472e-02f, 4.51910309e-02f, 3.91122475e-02f, 2.14398056e-01f, 2.61534527e-02f, 3.77660175e-03f, -1.59152567e-01f,
  1.02619529e-01f, 2.72190064e-01f, -6.01305179e-02f, 1.04248658e-01f, 3.57594527e-02f, -1.16227634e-01f, -3.19630839e-02f, 2.07531780e-01f, 6.95747659e-02f, 1.15045868e-01f,
  -6.59938902e-03f, 1.72743663e-01f, -5.89276776e-02f, -7.31982291e-02f, 7.91805908e-02f, -3.95071022e-02f, -2.77416706e-01f, 1.43917650e-01f, 3.69503722e-02f, -1.38902590e-01f,
  1.51455835e-01f, 1.48092108e-02f, -1.81113020e-01f, -7.46243224e-02f, -1.89828295e-02f, 2.94978935e-02f, 1.41904717e-02f, -3.89727466e-02f, -5.09646572e-02f, -3.97411697e-02f,
  3.46567631e-02f, 5.76933324e-02f, 3.73206250e-02f, -3.11219245e-02f, 2.07504202e-02f, -5.21854572e-02f, -4.83982749e-02f, -2.59355567e-02f, -1.09066628e-02f, -3.87890972e-02f,
  -1.02780303e-02f, -5.04769497e-02f, -2.23128572e-02f, 6.11626590e-03f, -4.42945100e-02f, 4.81176539e-04f, -3.63749713e-02f, -3.72841544e-02f, -4.80905920e-02f, -3.33891809e-02f,
  -3.24337482e-02f, -1.69211943e-02f, -2.43453942e-02f, -1.20801916e-02f, -5.63329738e-03f, -5.49850352e-02f, -1.48446690e-02f, -2.49867681e-02f, -2.91447677e-02f, -3.79996598e-02f,
  -5.57424910e-02f, -1.17457025e-02f, -3.86401638e-02f, -1.92071386e-02f, -2.36484539e-02f, -4.03632596e-02f, -4.34725033e-03f, -3.38597931e-02f, -2.98374314e-02f, -4.69990354e-03f,
  -2.70979293e-02f, -4.67884801e-02f, -5.12396097e-02f, -3.87266884e-03f, -2.22568549e-02f, -4.25390340e-02f, -2.74143252e-03f, -2.75492724e-02f, -2.32306514e-02f, -2.68079396e-02f,
  -1.37188323e-02f, -1.65793989e-02f, -3.65156829e-02f, -7.77912606e-03f, -5.40563948e-02f, -2.92679947e-02f, -2.35551081e-04f, -1.52960923e-02f, -9.73483622e-02f, -1.20657519e-01f,
  -1.01254627e-01f, 1.67199709e-02f, -5.17476872e-02f, -1.18050791e-01f, -6.02866560e-02f, 1.13640845e-01f, 4.69881333e-02f, 1.88665897e-01f, -3.20181437e-02f, 2.15352625e-01f,
  1.17126845e-01f, -1.70437202e-01f, 8.50230679e-02f, 4.39789239e-03f, 4.79581244e-02f, -1.93409652e-01f, -5.91997690e-02f, -9.32744443e-02f, -2.86158342e-02f, 7.47741014e-02f,
  1.02331541e-01f, 1.28699556e-01f, -1.85283631e-01f, 7.85419419e-02f, -2.18257611e-03f, -3.59476842e-02f, 1.55759543e-01f, 4.17624749e-02f, -1.64403841e-01f, 1.08201662e-02f,
  2.59605199e-01f, 1.60863958e-02f, -4.97119986e-02f, 8.03817064e-02f, 1.08570367e-01f, 1.56848192e-01f, -7.03637395e-03f, -1.72652781e-01f, -1.46650314e-01f, 5.42961024e-02f,
  -1.90443993e-02f, 8.10830817e-02f, -2.17298225e-01f, 1.54659078e-01f, -5.41906804e-02f, -3.40655968e-02f, 1.20566547e-01f, 1.57668620e-01f, -1.32952943e-01f, 1.37823392e-02f,
  1.36981189e-01f, 1.03283532e-01f, -1.70109645e-02f, -3.66262607e-02f, 7.89072439e-02f, -3.59394550e-02f, 2.14587957e-01f, 1.52456477e-01f, 1.58815935e-01f, -2.91684624e-02f,
  1.19219527e-01f, 9.70490500e-02f, -1.89744253e-02f, 9.13499221e-02f, 4.86592799e-02f, 9.95646268e-02f, 6.29032627e-02f, -6.20005745e-03f, 1.33963197e-01f, -4.42510210e-02f,
  -2.65727434e-02f, 1.15943849e-01f, -1.55236170e-01f, 9.26581547e-02f, 1.81943074e-01f, -1.68053824e-02f, 1.70317218e-01f, 5.34262024e-02f, 4.29100953e-02f, -1.25202417e-01f,
  4.01932038e-02f, 6.32200344e-03f, -2.01143995e-01f, -2.09793972e-04f, -1.60092771e-01f, -1.28067628e-01f, -1.49133906e-01f, 6.76137879e-02f, -4.64275070e-02f, 1.30306631e-01f,
  -1.35378256e-01f, 1.62862092e-01f, -1.07323550e-01f, -1.37588531e-01f, 1.97076816e-02f, 1.32903636e-01f, -1.01091683e-01f, 4.40609530e-02f, 1.01000182e-02f, 2.75250897e-02f,
  9.22945067e-02f, 9.05444250e-02f, -3.88347618e-02f, -1.18859068e-01f, -7.61639029e-02f, 1.42973945e-01f, -6.91150874e-02f, 3.95309106e-02f, -6.58154935e-02f, 1.42330136e-02f,
  -1.70318484e-01f, 3.23621891e-02f, -1.89394996e-01f, -1.96861461e-01f, 1.03447624e-01f, 1.22391790e-01f, 5.44669013e-03f, 5.28111830e-02f, 1.35572642e-01f, -1.22038834e-01f,
  -1.96558703e-02f, 9.85202715e-02f, -5.92522547e-02f, 8.01279023e-02f, 1.07813545e-01f, 1.72923669e-01f, -6.47762641e-02f, -7.37016201e-02f, -8.92371833e-02f, 1.29875138e-01f,
  1.04025193e-01f, 2.43046451e-02f, -2.11454466e-01f, -7.26663992e-02f, -1.43016115e-01f, -5.26205078e-02f, 3.49271968e-02f, 1.59988448e-01f, 1.45528764e-01f, -4.18650657e-02f,
  -1.64732739e-01f, 8.77568796e-02f, -1.77295461e-01f, 7.83305094e-02f, -1.26776278e-01f, 7.33878091e-02f, 1.40925154e-01f, -1.34642810e-01f, 1.63829938e-01f, 1.24744765e-01f,
  1.60579950e-01f, 1.43161997e-01f, -6.14927597e-02f, -2.79585067e-02f, -6.36854917e-02f, 4.55945954e-02f, -6.98853731e-02f, 2.70993799e-01f, 1.67738833e-02f, 6.62038773e-02f,
  -6.13600090e-02f, 1.72763333e-01f, 1.68947399e-01f, -1.62870213e-01f, 1.16060942e-01f, -1.80203214e-01f, -8.38799700e-02f, 3.11753988e-01f, 2.50797868e-02f, 2.47098908e-01f,
  1.80006921e-02f, -1.57990485e-01f, -3.68671045e-02f, 7.84790292e-02f, -2.69806683e-02f, -3.17131728e-02f, -6.20617718e-02f, 1.75649077e-01f, -8.29849616e-02f, -3.10742017e-02f,
  3.78154628e-02f, -1.78776518e-01f, -3.64457890e-02f, -7.53894448e-02f, 1.46261081e-01f, -1.73817232e-01f, 1.99203610e-01f, 1.01171814e-01f, -1.13250859e-01f, -1.12598322e-01f,
  7.60950148e-02f, 1.58032104e-01f, 1.47773698e-01f, -5.33117801e-02f, 1.60743296e-02f, 3.53572816e-02f, -5.40510714e-02f, -2.59719044e-01f, -3.05585086e-01f, 4.58019786e-02f,
  8.50268230e-02f, -5.04863188e-02f, -6.03926415e-03f, 6.66997582e-02f, -1.63742155e-02f, 1.20600574e-02f, -8.13622475e-02f, 7.33198375e-02f, -8.49846471e-03f, 4.19303514e-02f,
  -4.31550071e-02f, -1.29145563e-01f, 5.70716821e-02f, 7.98504651e-02f, -3.68814766e-02f, 2.30096564e-01f, 1.47736371e-01f, 8.02973434e-02f, 1.75201073e-01f, 2.11283732e-02f,
  -1.80427343e-01f, 2.69700289e-01f, 1.58915147e-01f, 5.03126904e-02f, 2.23840550e-01f, 1.17508814e-01f, 1.30008236e-01f, -8.46563205e-02f, -1.06361948e-01f, -4.75652888e-02f,
  -2.67253760e-02f, 2.27635458e-01f, 1.17477618e-01f, 1.58229396e-01f, 8.98704082e-02f, -7.30067641e-02f, 1.27734944e-01f, 2.15151515e-02f, 9.41622481e-02f, -1.46454409e-01f,
  -8.59127939e-02f, -1.69582553e-02f, 3.83694582e-02f, -1.24498278e-01f, 3.50178103e-03f, -1.70546304e-02f, 7.35658780e-02f, 4.29574624e-02f, 2.55200356e-01f, -6.56781020e-03f,
  1.86246321e-01f, -3.50324288e-02f, 4.32498269e-02f, 2.05222338e-01f, 1.41837031e-01f, 1.30337119e-01f, 1.83043294e-02f, 1.33877441e-01f, 2.23117039e-01f, 6.65946156e-02f,
  -1.97507262e-01f, -6.55614436e-02f, -1.04884245e-01f, 9.73322242e-02f, 1.04144104e-01f, 1.53044581e-01f, 1.04229391e-01f, -7.99832791e-02f, -5.07070720e-02f, -1.30262412e-02f,
  3.56313586e-02f, 1.09460093e-02f, -1.28957286e-01f, 7.70665286e-03f, -7.31910393e-02f, -1.76494613e-01f, 1.64020229e-02f, 2.35424906e-01f, 3.01817134e-02f, 9.43304971e-02f,
  1.46239102e-01f, -4.50058356e-02f, 1.07144699e-01f, -5.16648889e-02f, -2.39155561e-01f, 2.31602415e-01f, 3.84604707e-02f, 1.26938328e-01f, 8.72089043e-02f, 2.12816149e-01f,
  8.45192224e-02f, 9.82338712e-02f, -1.37651309e-01f, -2.14643553e-01f, -7.20424578e-02f, 1.22397579e-01f, 4.44890708e-02f, 3.11908990e-01f, -9.51933414e-02f, -7.86799639e-02f,
  -5.38314953e-02f, -1.69575214e-02f, 3.29905283e-03f, 1.08378902e-01f, -5.78776991e-04f, -1.89312138e-02f, 4.28583771e-02f, -8.40692520e-02f, 1.93454117e-01f, -3.00512947e-02f,
  -3.10765617e-02f, 1.55828699e-01f, 1.54153734e-01f, -3.17018256e-02f, 2.35490531e-01f, -3.14883590e-02f, -1.14673533e-01f, 3.51656154e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  6.40115514e-02f, 7.83540830e-02f, 3.30139287e-02f, 6.95425179e-03f, 1.65977273e-02f, 2.28625666e-02f, 5.76568134e-02f, 4.73028906e-02f, 4.80253510e-02f, -5.03457785e-02f,
  -3.70155741e-03f, -1.92651805e-02f, 2.57096048e-02f, -1.57939954e-04f, 1.65734701e-02f, 1.05355524e-01f, 9.75953043e-02f, 6.97696861e-03f, -1.01494696e-02f, 3.75597030e-02f,
  -4.40408066e-02f, -3.14171351e-02f, 9.83361825e-02f, 8.41059163e-02f, 6.08094372e-02f, 1.06930349e-03f, -7.38811819e-03f, 4.49773632e-02f, -9.86070186e-03f, 5.03874719e-02f,
  -2.95277704e-02f, -6.45997189e-03f, 1.52377151e-02f, 4.08161655e-02f, 3.12466286e-02f, 3.74878012e-03f, -6.19555637e-03f, 1.02679208e-01f, -1.80989280e-02f, -3.56063014e-03f,
  -2.19956841e-02f, -2.79650036e-02f, 1.89864710e-02f, 1.96649935e-02f, 6.76342249e-02f, 8.72706324e-02f, -4.44246642e-02f, 6.96565956e-02f, -4.78475019e-02f, 7.91346207e-02f,
  -3.42385545e-02f, 5.22391014e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.17987700e-01f, 6.60212338e-02f, -9.34536979e-02f, -1.54587980e-02f, 3.29460986e-02f, 1.12819627e-01f, 1.84832439e-01f, -2.98843801e-01f, -2.46677130e-01f, -1.81071296e-01f,
  -1.48018166e-01f, -1.23872824e-01f, -2.25829870e-01f, 1.08452812e-01f, 2.40942389e-02f, -1.02062613e-01f, -3.28049004e-01f, -1.83847874e-01f, -4.69078086e-02f, -3.34890157e-01f,
  -4.50015485e-01f, -3.97958249e-01f, -1.12674423e-01f, 8.52397159e-02f, -1.81357652e-01f, -1.48844153e-01f, 1.08065508e-01f, -9.30813700e-02f, 1.24651827e-01f, -1.32687062e-01f,
  1.69620216e-01f, -1.48291796e-01f, 3.79644334e-02f, 1.65138364e-01f, -9.50520188e-02f, 2.26717338e-01f, -3.44141811e-01f, 1.46836460e-01f, 3.50816399e-01f, 1.78077027e-01f,
  1.85373202e-02f, -2.38050818e-01f, 2.92823553e-01f, 9.15301368e-02f, 4.14662659e-01f, 8.15961584e-02f, 1.87886506e-01f, -1.32735938e-01f, -3.81699294e-01f, -3.70929658e-01f,
  8.44220370e-02f, -3.00591737e-01f, -3.00848801e-02f, -1.12785786e-01f, 9.22987834e-02f, 2.28480063e-02f, 1.38524234e-01f, 1.54497817e-01f, -2.18684087e-03f, -2.82366037e-01f,
  -2.41922423e-01f, -3.02220751e-02f, -2.18947783e-01f, -9.64399725e-02f, -1.60858393e-01f, -4.57250290e-02f, 9.49682388e-03f, 4.86603528e-02f, -5.79062896e-03f, 7.49272704e-02f,
  -2.03126520e-01f, 2.46560782e-01f, -1.69844791e-01f, 8.81620869e-02f, 1.29550904e-01f, 6.12159930e-02f, 2.42269412e-01f, 9.48025137e-02f, 2.54548136e-02f, 1.89826161e-01f,
  8.51371363e-02f, -6.11042321e-01f, 5.26278187e-03f, 2.15231348e-02f, -2.21445598e-02f, -1.18690263e-02f, -2.59631664e-01f, 5.77074811e-02f, -6.05368793e-01f, -1.23406611e-01f,
  7.16223121e-02f, -4.40517776e-02f, 1.86752975e-01f, 5.20540297e-01f, -4.53738533e-02f, 4.47599202e-01f, 3.63664739e-02f, 7.54517466e-02f, -3.15806001e-01f, -1.05496965e-01f,
  -1.48223370e-01f, -7.66976252e-02f, -1.62776738e-01f, -1.44561037e-01f, 1.12051643e-01f, -1.89998448e-01f, -1.42236665e-01f, 1.18970007e-01f, -9.89471301e-02f, -3.32217395e-01f,
  2.13119030e-01f, -4.91237529e-02f, -2.60330677e-01f, 5.24933375e-02f, 1.06956914e-01f, 6.11400865e-02f, 7.64929922e-03f, -1.37604249e-03f, 2.06138611e-01f, -5.95009141e-02f,
  1.87674701e-01f, -3.23204398e-01f, -1.42409476e-02f, -1.49682775e-01f, 9.02130902e-02f, -3.11700165e-01f, -4.28501256e-02f, -2.71995395e-01f, -4.32101712e-02f, 5.88319078e-02f,
  -9.72265378e-02f, -1.01525307e-01f, -1.08359084e-01f, -2.54549761e-03f, 4.15619016e-02f, 1.20281853e-01f, -2.49886028e-02f, -9.72139984e-02f, 1.38764530e-01f, 3.66982333e-02f,
  -3.52734216e-02f, -1.59124672e-01f, 3.84930968e-02f, 7.93457180e-02f, 5.02411053e-02f, -4.08272862e-01f, 8.46441388e-02f, 1.95502847e-01f, 1.31763384e-01f, 2.19003454e-01f,
  4.78516556e-02f, 1.49417654e-01f, 5.24892449e-01f, -2.71709263e-01f, -1.08490452e-01f, 1.19779175e-02f, 1.00751922e-01f, 1.78035140e-01f, 5.05293608e-02f, -2.47198269e-01f,
  -6.66669607e-02f, -3.03684354e-01f, -2.35294968e-01f, -1.15975074e-01f, -1.23354226e-01f, -3.48325104e-01f, -8.26213583e-02f, -1.40666887e-01f, 1.84910759e-01f, 7.39284083e-02f,
  -4.81698364e-02f, 3.85476872e-02f, -1.91703573e-01f, -1.46171093e-01f, 1.66939795e-01f, 2.19457429e-02f, -3.77098083e-01f, -9.00248289e-02f, 9.29712579e-02f, -2.21313730e-01f,
  -5.10863960e-02f, -8.89386502e-05f, 1.11882009e-01f, -2.74247289e-01f, -1.83465540e-01f, -1.16879612e-01f, -2.43954062e-02f, 1.48164511e-01f, 2.20906064e-01f, -2.53444165e-01f,
  -3.89804721e-01f, -3.06006908e-01f, -2.11407781e-01f, -5.10750748e-02f, 1.12717003e-01f, -2.03312084e-01f, -1.21257201e-01f, -1.41374364e-01f, 1.97495311e-01f, -1.31510124e-01f,
  8.52514729e-02f, -2.26602033e-02f, -3.41803171e-02f, -2.00618654e-01f, -6.07908219e-02f, 5.14693670e-02f, 2.46347152e-02f, 4.08872627e-02f, 1.64872445e-02f, 6.63038865e-02f,
  2.27328181e-01f, 4.64732014e-02f, -2.78888017e-01f, 5.25377430e-02f, -2.91090906e-02f, 1.96271446e-02f, -5.64687669e-01f, 8.67021158e-02f, -2.78717071e-01f, -3.70801181e-01f,
  -4.23022568e-01f, -3.31471503e-01f, 1.06967218e-01f, -1.34704977e-01f, 4.49589528e-02f, 1.29917353e-01f, 6.09791325e-03f, 4.40628491e-02f, -1.54992566e-01f, 2.21050993e-01f,
  1.46796867e-01f, 1.64117366e-01f, -1.45708829e-01f, -2.59908855e-01f, -2.24167347e-01f, -4.45882767e-01f, 3.35476667e-01f, -1.78987794e-02f, -2.89366037e-01f, -2.81389654e-01f,
  -1.26682669e-01f, 1.34615287e-01f, -3.25051099e-01f, 5.00932075e-02f, -3.63967684e-03f, 3.33854616e-01f, -2.40341276e-01f, -3.60098958e-01f, -3.14343497e-02f, 2.16928080e-01f,
  -2.97973994e-02f, 5.72055690e-02f, -3.02263349e-01f, 2.72172391e-01f, 2.14665220e-03f, 1.48193032e-01f, -1.22161917e-02f, 4.15625200e-02f, -2.02537616e-04f, 3.64703983e-02f,
  6.65731654e-02f, -7.75030628e-02f, 2.18043268e-01f, -8.61912519e-02f, -1.08161852e-01f, -8.85657817e-02f, -2.07857043e-01f, 3.56287181e-01f, -1.09789513e-01f, 1.58902481e-01f,
  -5.85062094e-02f, 9.00061354e-02f, 1.05367973e-02f, 1.04053006e-01f, 1.66089758e-01f, -2.66659766e-01f, 1.57962099e-01f, -1.40220514e-02f, -2.58703262e-01f, -2.41175428e-01f,
  -4.06581372e-01f, -2.42706850e-01f, 1.83060184e-01f, 1.62191316e-01f, 2.12487839e-02f, -1.76360328e-02f, 1.01563185e-01f, -8.18789244e-01f, -3.88443023e-02f, 1.73319966e-01f,
  1.28645197e-01f, -1.01799935e-01f, 8.04053470e-02f, -1.97163060e-01f, -3.05842668e-01f, 1.75257489e-01f, -6.50585368e-02f, -1.05394214e-01f, -2.48583719e-01f, -2.17868716e-01f,
  -2.39356786e-01f, 1.30140588e-01f, -3.79559919e-02f, 6.98820949e-02f, 1.33778051e-01f, 1.17801949e-01f, -5.98860644e-02f, 2.55126268e-01f, -7.42469547e-06f, -1.80445671e-01f,
  9.69149359e-03f, 1.95404649e-01f, 1.71696350e-01f, 1.68353811e-01f, 3.13598774e-02f, -3.42262536e-01f, -1.38445646e-02f, 6.45774305e-02f, 2.28078425e-01f, 6.02866746e-02f,
  1.06845722e-02f, 3.97468545e-02f, 1.85511693e-01f, 1.54630691e-01f, 9.69742611e-02f, 2.08229065e-01f, -1.13262333e-01f, 6.05765991e-02f, 2.37202063e-01f, 2.10968599e-01f,
  1.26825467e-01f, -1.13623887e-01f, -2.96680957e-01f, 2.65490133e-02f, 1.87448878e-02f, -2.05360636e-01f, 6.41686022e-02f, 1.52534340e-03f, -4.66574192e-01f, -1.90413877e-01f,
  -2.16675416e-01f, -3.15073133e-01f, -1.38080582e-01f, -2.40188599e-01f, -7.16901720e-01f, -2.88932532e-01f, 2.74583511e-02f, -3.36206891e-02f, 2.04939306e-01f, -4.36164677e-01f,
  7.87526462e-03f, 5.35833120e-01f, -3.90638784e-02f, -6.67605037e-03f, 6.10298067e-02f, 1.00510910e-01f, 4.94939163e-02f, -6.20299317e-02f, -1.61250666e-01f, -3.14233601e-01f,
  -2.67940283e-01f, 1.08305596e-01f, 1.49402276e-01f, 1.15877695e-01f, -3.59988213e-01f, 1.37061656e-01f, 5.87249175e-02f, 1.29270807e-01f, 1.74828917e-01f, -3.74919735e-02f,
  -1.40171930e-01f, -2.29794517e-01f, -2.08587013e-02f, -2.92757928e-01f, 1.95128500e-01f, 9.27903652e-02f, -2.56552212e-02f, 1.61047295e-01f, -5.04169334e-03f, -2.69832406e-02f,
  -3.14693749e-01f, -4.46943305e-02f, 9.01663378e-02f, 9.70376432e-02f, 6.80858642e-02f, 3.52038890e-02f, -7.74721503e-02f, 1.96739063e-02f, -1.79640010e-01f, 9.75843668e-02f,
  -1.47089139e-01f, 2.11075738e-01f, 2.84142226e-01f, 1.03558421e-01f, 8.85082483e-02f, -8.74866024e-02f, -2.33334526e-01f, -4.25027460e-01f, -8.73300061e-03f, -2.52396137e-01f,
  -6.95348531e-02f, 4.31449246e-03f, -4.46171850e-01f, 6.78013414e-02f, 1.53830379e-01f, 1.94452778e-01f, 2.05044791e-01f, -3.19088161e-01f, 4.07269269e-01f, -3.29297960e-01f,
  -1.49022624e-01f, -5.60826249e-02f, 1.47769317e-01f, -2.20718548e-01f, -6.66397586e-02f, 1.45660847e-01f, 1.76712610e-02f, -1.00241423e-01f, -7.09892437e-02f, -4.62080717e-01f,
  2.97762305e-01f, -5.53347707e-01f, -1.97544172e-02f, -2.67227173e-01f, -2.63983190e-01f, 1.75473869e-01f, -1.12719394e-01f, 8.67174789e-02f, -1.09008104e-01f, -2.65877575e-01f,
  -3.25194597e-02f, 2.09848493e-01f, 1.72866166e-01f, 1.47112966e-01f, 9.57806967e-03f, -3.42218697e-01f, 9.27221403e-03f, -2.40957186e-01f, -7.15502584e-03f, 4.50798385e-02f,
  -9.81252491e-02f, -2.33367719e-02f, -9.97543707e-03f, 6.72492385e-02f, -6.04102686e-02f, -2.78931677e-01f, -2.09091187e-01f, 1.06372729e-01f, -1.72077492e-01f, -1.83722917e-02f,
  1.70252934e-01f, -4.10198048e-02f, 4.44122069e-02f, 6.84665218e-02f, 8.52965489e-02f, 1.85555629e-02f, 8.46892819e-02f, -1.35790080e-01f, -9.12842155e-02f, -1.33512020e-01f,
  2.47096524e-01f, 2.01847762e-01f, -1.41736001e-01f, -2.69733071e-01f, -2.18373656e-01f, 1.48411736e-01f, 2.20132604e-01f, -1.15872167e-01f, -1.55999705e-01f, 5.23287896e-03f,
  -7.43304864e-02f, 2.09160998e-01f, 1.88645601e-01f, 3.68328393e-02f, 2.79665012e-02f, 1.60161108e-01f, -2.77650684e-01f, 1.16788726e-02f, -3.47780287e-01f, -8.35096240e-02f,
  2.25079563e-02f, -4.02464122e-01f, -3.15006077e-02f, 2.05666497e-01f, -1.22365639e-01f, -9.94753391e-02f, 3.64778012e-01f, 2.59694636e-01f, -8.14941600e-02f, 3.02069187e-02f,
  -9.45036188e-02f, -2.25547284e-01f, 5.62269986e-02f, 1.49139747e-01f, 1.44531623e-01f, -1.58167347e-01f, -2.28422537e-01f, -2.67226636e-01f, 5.83327673e-02f, 2.34871909e-01f,
  -3.69442705e-06f, -4.82356511e-02f, -1.26726672e-01f, -1.24861166e-01f, -8.18646327e-02f, -7.72427246e-02f, 6.54735276e-03f, 2.21283007e-02f, -1.19818099e-01f, 1.99604444e-02f,
  -1.29453287e-01f, -2.08564103e-01f, -1.13799058e-01f, 3.75560448e-02f, 9.20202583e-02f, -3.57540348e-03f, -7.69452378e-02f, -1.15943169e-02f, -1.59972787e-01f, 1.51147291e-01f,
  -1.26256198e-01f, 4.79612835e-02f, -2.51304805e-01f, -9.00125280e-02f, -2.34833568e-01f, -2.10599199e-01f, -4.41611707e-02f, 8.43058825e-02f, 1.99813247e-01f, 2.59867549e-01f,
  -3.89723144e-02f, 1.26219690e-01f, -9.28231850e-02f, -2.85817534e-01f, 1.55795738e-01f, 1.43810272e-01f, 2.68432889e-02f, 2.98105270e-01f, -2.51323462e-01f, -1.06350750e-01f,
  -1.04842283e-01f, -1.73584968e-01f, -3.32658142e-02f, 5.10657430e-02f, 1.69361103e-02f, -2.25164369e-01f, -2.92973280e-01f, 2.13188961e-01f, 1.29691362e-01f, 3.06577832e-01f,
  5.29156551e-02f, -8.26396197e-02f, 2.34584630e-01f, 2.28967279e-01f, -7.64634162e-02f, -5.27809151e-02f, 2.00843409e-01f, -1.09057941e-01f, 7.89622813e-02f, -2.39278033e-01f,
  -2.01222133e-02f, 1.20371906e-02f, 1.14901148e-01f, -1.36823311e-01f, -9.03262664e-03f, -2.21909136e-01f, 6.10930771e-02f, -1.67892307e-01f, -2.75286913e-01f, -3.40349287e-01f,
  -2.29856968e-02f, 1.64944127e-01f, -7.15451688e-02f, -3.71655345e-01f, 1.29700229e-01f, -1.93962038e-01f, -9.57971998e-03f, -9.15664732e-02f, 5.59365749e-02f, 3.11864577e-02f,
  -6.20643795e-02f, 4.69592102e-02f, -1.49132490e-01f, -1.69231981e-01f, -1.89433292e-01f, 1.59050390e-01f, 1.57110527e-01f, -2.91308284e-01f, -1.12292613e-03f, -1.92245945e-01f,
  5.98412678e-02f, -2.88753986e-01f, -2.03151360e-01f, -1.95899263e-01f, -1.52848735e-01f, -2.68507838e-01f, 1.42973885e-01f, 1.94696486e-01f, -2.65237868e-01f, 1.24853030e-02f,
  2.80456662e-01f, -9.04880464e-02f, 2.55311251e-01f, 2.48284593e-01f, -1.13168329e-01f, -4.90935184e-02f, -3.99203748e-02f, 3.79061140e-02f, 3.00343763e-02f, -5.78555604e-03f,
  1.66089952e-01f, -3.14819783e-01f, 1.89780086e-01f, -2.76963711e-01f, -1.60315737e-01f, -1.16858475e-01f, -2.31824681e-01f, -1.00003183e-01f, -7.19579086e-02f, 1.11969886e-02f,
  -1.76865056e-01f, 1.46222413e-01f, 3.38840386e-04f, 1.13520749e-01f, -9.09164734e-03f, -1.90182179e-01f, 9.00974944e-02f, 2.91123182e-01f, 2.51577962e-02f, -1.73454396e-02f,
  -4.39237326e-01f, 7.10011572e-02f, 2.28997633e-01f, -3.78949374e-01f, -2.89581046e-02f, -3.66239548e-01f, -8.57200772e-02f, -3.24586213e-01f, -3.53137851e-01f, -3.53740782e-01f,
  7.03502148e-02f, 1.94272906e-01f, -1.14983730e-01f, -9.71526355e-02f, 9.47349370e-02f, -2.85442849e-03f, -1.49761647e-01f, 2.63713002e-01f, 2.55774051e-01f, -9.31466371e-02f,
  -2.33321592e-01f, 2.45777264e-01f, 1.43529221e-01f, 1.93958029e-01f, 4.22718562e-03f, 2.53412306e-01f, 1.27325639e-01f, -3.39924902e-01f, 6.32213801e-02f, 1.23021021e-01f,
  2.37723857e-01f, 2.05011621e-01f, 1.25809968e-01f, 3.93811539e-02f, 7.32017681e-02f, 9.41169858e-02f, -4.32150671e-03f, -3.63568604e-01f, -9.32578221e-02f, 3.68019193e-01f,
  1.77197307e-01f, -5.02177596e-01f, -3.54296193e-02f, 1.36585860e-03f, -1.82242543e-01f, -1.26980215e-01f, -3.29177827e-01f, -1.33142034e-02f, -1.20432079e-01f, 1.40322402e-01f,
  -7.77691603e-02f, -1.79033596e-02f, -3.92081682e-03f, -2.42746890e-01f, 2.52332408e-02f, -3.71670067e-01f, -1.90118790e-01f, -3.65365386e-01f, 2.11920768e-01f, 7.84204453e-02f,
  1.42369583e-01f, -1.76342219e-01f, 7.80278491e-03f, -6.55377004e-03f, -1.35893583e-01f, -1.63862586e-01f, -1.77381393e-02f, -1.04583077e-01f, 1.74320340e-02f, 1.28423274e-01f,
  2.08264410e-01f, 1.33299410e-01f, 1.20818667e-01f, 1.70763165e-01f, -2.97647733e-02f, 1.23193853e-01f, -1.16208754e-01f, 8.07156563e-02f, 2.48876237e-03f, -2.11193994e-01f,
  1.36107638e-01f, -9.56476405e-02f, 1.69319183e-01f, -1.23563521e-01f, 3.88691314e-02f, 2.00039476e-01f, -2.28110939e-01f, -2.20257103e-01f, -5.12304381e-02f, 1.15194716e-01f,
  2.01103203e-02f, 2.23003104e-01f, -3.20327818e-01f, -1.29945893e-02f, -2.24040866e-01f, -2.12600991e-01f, 1.62112921e-01f, -3.21485698e-01f, -6.41321242e-02f, 2.22433224e-01f,
  -3.44774246e-01f, -8.70221928e-02f, -2.35573635e-01f, -9.67876613e-02f, -6.10468835e-02f, -2.06145018e-01f, -2.56874319e-02f, 1.16656557e-01f, 1.86511651e-01f, -1.04069725e-01f,
  8.79295468e-02f, 5.30524254e-02f, -1.79981247e-01f, -3.00606400e-01f, -2.72159696e-01f, 7.68910199e-02f, -1.24895759e-01f, 1.18255667e-01f, -1.96986154e-01f, -6.45476580e-02f,
  -4.61152822e-01f, 2.62088776e-02f, 2.57533997e-01f, 1.72736034e-01f, -3.67404282e-01f, -2.72668183e-01f, 2.93773746e-06f, 5.45139313e-01f, 6.43625557e-02f, 9.15616527e-02f,
  -3.01293224e-01f, 1.18915446e-01f, -1.18246591e-02f, 1.65835410e-01f, -1.46066606e-01f, 5.12093008e-02f, 1.30241975e-01f, 1.82845265e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  8.49989280e-02f, -8.68262574e-02f, -8.54387730e-02f, -6.22111224e-02f, -3.53661110e-03f, -4.91113141e-02f, -1.57895815e-02f, 6.53822049e-02f, 4.90372404e-02f, 8.13349783e-02f,
  -4.33639176e-02f, -3.59601825e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    