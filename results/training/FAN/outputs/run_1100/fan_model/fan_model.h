/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.32594824e-01f, -1.14951387e-01f, 2.76030123e-01f, -1.87147394e-01f, 4.78762090e-02f, 3.37281674e-01f, 3.28329802e-01f, 1.33959129e-01f, -1.25467656e-02f, 1.31856813e-03f,
  -1.05183549e-01f, -2.66463459e-01f, -1.69804811e-01f, -6.53060973e-02f, 1.74316704e-01f, 9.01672468e-02f, 2.17066810e-01f, 1.28077492e-01f, 2.97885209e-01f, 1.32769167e-01f,
  -9.58743095e-02f, -1.39896885e-01f, -4.38914858e-02f, 4.47111726e-02f, -1.82826314e-02f, -7.44933560e-02f, -2.01627929e-02f, 5.35732768e-02f, 8.90030190e-02f, -4.52103540e-02f,
  -1.36036366e-01f, 5.35922777e-03f, 9.10832267e-03f, -1.14007540e-01f, -3.89466919e-02f, -3.24413739e-02f, 6.50329068e-02f, 1.24033215e-02f, -8.92129019e-02f, 3.34137604e-02f,
  -1.69447009e-02f, -8.90984908e-02f, -4.03862894e-02f, -5.69587983e-02f, 7.91884959e-02f, 1.09324437e-02f, -3.77214365e-02f, -4.75278310e-02f, 1.09411143e-01f, -1.82776786e-02f,
  -1.20879330e-01f, -8.05896297e-02f, 1.01253711e-01f, 1.95970722e-02f, 1.12336539e-01f, -2.62681264e-02f, 2.52245814e-02f, 9.97542054e-04f, 6.00089729e-02f, -3.60282250e-02f,
  -4.22204584e-02f, -7.16181174e-02f, 3.30648683e-02f, 5.08393254e-03f, -9.75615252e-03f, 4.28027920e-02f, -5.76592609e-03f, -2.80455276e-02f, 9.26349871e-03f, 5.33194989e-02f,
  4.89981212e-02f, 2.89463345e-02f, 4.52854700e-04f, -1.49570350e-02f, -1.27988979e-01f, 8.47318843e-02f, 7.53240213e-02f, -1.65496934e-02f, -3.05212308e-02f, 5.56028597e-02f,
  -5.64278476e-02f, 1.30964294e-01f, -7.26626022e-03f, 4.81194220e-02f, 2.64081210e-02f, 1.90298520e-02f, 3.83017063e-02f, 1.20468996e-01f, -1.32702395e-01f, 2.86711827e-02f,
  -2.60713190e-01f, -4.03075339e-03f, -1.62935033e-01f, 1.37566449e-02f, 1.07606957e-02f, -2.46481169e-02f, -2.28401609e-02f, -4.85774055e-02f, -7.31283575e-02f, 1.23785019e-01f,
  8.50875955e-03f, -6.57000616e-02f, -3.56334150e-02f, 6.05733618e-02f, 6.79795220e-02f, 7.39199156e-03f, -1.47056103e-01f, -1.87926386e-02f, 2.83754505e-02f, -2.78048869e-02f,
  7.90050924e-02f, -2.93387715e-02f, -3.95681635e-02f, -2.68759299e-02f, -1.21363059e-01f, -2.97954325e-02f, 1.73986536e-02f, 6.65062740e-02f, 9.37530547e-02f, -7.04532564e-02f,
  3.49083960e-01f, -2.71781564e-01f, 1.49360120e-01f, 1.48891076e-01f, -1.48033112e-01f, 8.61241147e-02f, -1.13658071e-01f, 6.56134337e-02f, 1.45209849e-01f, 3.56730334e-02f,
  -1.21934541e-01f, 3.17452401e-02f, 1.14480570e-01f, 5.60765453e-02f, 8.60802084e-02f, -4.94318716e-02f, -4.59033027e-02f, 2.44699553e-01f, 2.28430957e-01f, 1.83384940e-01f,
  -3.66351195e-02f, 1.84900761e-01f, 2.22218737e-01f, 2.49378636e-01f, -1.48116112e-01f, 1.34749323e-01f, 2.89317593e-02f, 2.44824812e-02f, -7.30425566e-02f, -5.72103374e-02f,
  5.99276274e-02f, -8.65908619e-03f, 5.92301823e-02f, 1.02739803e-01f, -1.43762305e-03f, 7.26092160e-02f, 1.40277758e-01f, 1.16340004e-01f, 1.27246395e-01f, 1.22867920e-01f,
  -4.55800816e-02f, -5.26673347e-02f, 8.14433098e-02f, 3.49657126e-02f, 1.13754340e-01f, 1.37076542e-01f, 1.42804667e-01f, 1.33947015e-01f, 2.18529537e-01f, 7.91733414e-02f,
  -3.61624099e-02f, 9.39151719e-02f, 1.68636128e-01f, 1.20668516e-01f, 2.64946595e-02f, 1.06602393e-01f, 1.98817030e-02f, 1.26417175e-01f, 1.58653766e-01f, 5.39492518e-02f,
  -8.99716616e-02f, -1.74449727e-01f, -1.15174994e-01f, -1.39226010e-02f, -1.93252817e-01f, -1.04502141e-01f, -1.79097176e-01f, -1.87477678e-01f, -1.34733230e-01f, -1.50997266e-01f,
  -7.65637786e-04f, -9.41742733e-02f, -9.46627632e-02f, -1.28463820e-01f, -1.65720299e-01f, -1.06096916e-01f, -1.55186966e-01f, -1.33234635e-01f, -1.46312743e-01f, -1.10108249e-01f,
  -9.03033093e-02f, -1.47731528e-01f, -1.12017572e-01f, -3.11425179e-02f, -7.91528150e-02f, -4.99952398e-02f, -1.76485807e-01f, -1.24315776e-01f, -5.43540604e-02f, -4.17495705e-02f,
  8.44958499e-02f, 1.53144419e-01f, 6.16647266e-02f, 9.33763236e-02f, 1.22207589e-01f, 1.22710645e-01f, 3.28937285e-02f, 4.69903946e-02f, 1.29955783e-01f, 7.50253350e-02f,
  5.98302521e-02f, 1.04940176e-01f, -7.93077145e-03f, 7.01518580e-02f, 4.21336181e-02f, 7.57609531e-02f, 7.25329679e-04f, 1.69477656e-01f, 1.47736117e-01f, 1.53518826e-01f,
  1.14831686e-01f, 1.50141731e-01f, 2.23472908e-01f, 9.99017954e-02f, 9.13705900e-02f, 9.57720801e-02f, 1.43503338e-01f, 3.98490317e-02f, 1.78549573e-01f, 6.72090501e-02f,
  -3.21149290e-01f, -1.02611192e-01f, 6.66721985e-02f, 9.10004880e-03f, 1.42517500e-02f, -1.64374873e-01f, -2.04403564e-01f, -3.00758276e-02f, 7.99921080e-02f, 5.17040603e-02f,
  2.10276723e-01f, 3.96737516e-01f, 2.64642388e-01f, 2.16328785e-01f, -8.07211697e-02f, -1.71808332e-01f, -2.16068611e-01f, -5.95226176e-02f, -5.56159168e-02f, 2.58496609e-02f,
  3.27197500e-02f, -1.40975997e-01f, -1.15426227e-01f, -3.54545377e-02f, 1.18942326e-02f, 1.43646479e-01f, -5.38274348e-02f, -1.71906110e-02f, -7.22176284e-02f, -6.47380799e-02f,
  8.32770318e-02f, -1.77229166e-01f, 2.63397574e-01f, 1.53566495e-01f, 1.60812765e-01f, 1.00079611e-01f, 1.66054945e-02f, 4.54322398e-02f, 1.42525256e-01f, 6.10473379e-02f,
  1.56906471e-01f, 1.06981687e-01f, 2.33513266e-01f, 7.68614560e-02f, 6.92048147e-02f, 8.69630184e-03f, 1.33844197e-01f, 5.69684878e-02f, 1.33166686e-01f, -6.73346892e-02f,
  5.28423227e-02f, -9.13511962e-02f, -8.75098258e-02f, 1.69494916e-02f, 7.06903785e-02f, 7.07643256e-02f, 5.90874329e-02f, 6.35023564e-02f, 9.97508913e-02f, 1.70195788e-01f,
  -5.49009480e-02f, -6.86884373e-02f, -2.47076713e-02f, -1.97109021e-02f, -5.75873926e-02f, 9.56767276e-02f, -7.91879743e-02f, -2.83787306e-03f, -3.49487327e-02f, -9.34545249e-02f,
  8.39311909e-03f, -5.89560457e-02f, 2.86830403e-02f, -1.05176076e-01f, -1.00486912e-01f, -1.24256805e-01f, -9.24252346e-02f, 3.35385138e-03f, 1.42103666e-02f, -7.73560852e-02f,
  -5.78384958e-02f, -3.69790010e-02f, -3.29678170e-02f, -6.99248612e-02f, -1.28636777e-01f, -6.87860250e-02f, -3.80147137e-02f, -1.11593321e-01f, -1.44934759e-01f, -1.75556615e-01f,
  1.57069057e-01f, 1.58200026e-01f, 1.65856794e-01f, 8.83798078e-02f, 1.09768912e-01f, 1.61355853e-01f, 2.90955827e-02f, 1.87084898e-01f, 1.19230077e-01f, 1.18503802e-01f,
  1.11845978e-01f, 6.71749860e-02f, 3.16445976e-02f, 6.61503747e-02f, 9.90669876e-02f, 1.33675009e-01f, 2.16852706e-02f, 1.28228486e-01f, 1.15999535e-01f, 3.24542336e-02f,
  2.93645170e-02f, 1.00745470e-03f, -1.08363926e-01f, 1.00949198e-01f, 6.78396318e-03f, -1.07595883e-02f, 1.09560601e-02f, 3.95354144e-02f, -2.03397572e-02f, -5.41150607e-02f,
  7.71229491e-02f, -1.58453748e-01f, 7.76711330e-02f, 1.54640973e-01f, -1.24722905e-01f, 1.70260239e-02f, -2.03948006e-01f, 5.87764271e-02f, 1.55404434e-01f, -1.81655779e-01f,
  -8.11772514e-03f, 3.36456858e-02f, 5.46034845e-03f, 2.16392018e-02f, -6.57539591e-02f, -3.20515037e-01f, -1.17323354e-01f, 3.97043535e-03f, -4.76541445e-02f, -1.79225102e-01f,
  -1.64335787e-01f, 6.91451877e-02f, 2.88993958e-02f, 2.54947394e-02f, -5.53248301e-02f, -9.83949602e-02f, -1.20624870e-01f, 9.16684046e-02f, -3.64264473e-02f, -1.37605384e-01f,
  -1.10025354e-01f, -5.14804684e-02f, -1.07099731e-02f, -3.53829972e-02f, 4.64097746e-02f, 1.46714523e-01f, 1.00034727e-02f, 8.10887963e-02f, -4.17535082e-02f, 4.39540632e-02f,
  -2.78062187e-02f, 2.90941577e-02f, 8.22081231e-03f, -1.11376196e-02f, 2.48308685e-02f, -2.47565005e-02f, 1.10922940e-01f, -2.44419035e-02f, -1.65689625e-02f, 2.77119111e-02f,
  -7.54232286e-03f, 7.83747584e-02f, -8.11065584e-02f, 7.62595795e-03f, -4.25074510e-02f, 4.41398323e-02f, 7.27091879e-02f, 7.23077804e-02f, 8.46172944e-02f, -4.73848172e-03f,
  -3.46255563e-02f, -9.07564461e-02f, -1.97357554e-02f, 1.36834309e-01f, -2.31289528e-02f, 3.75271179e-02f, -3.93628068e-02f, -4.03355919e-02f, -6.87641576e-02f, 1.65154859e-01f,
  1.15613036e-01f, -1.21410921e-01f, 2.40168553e-02f, -8.56033787e-02f, -3.77345644e-02f, -1.09034710e-01f, 9.32155119e-04f, -3.88065539e-02f, -6.64644539e-02f, -8.98110345e-02f,
  -2.94985119e-02f, -6.51960894e-02f, 1.69297811e-02f, 1.20619409e-01f, -4.65957895e-02f, -4.50574011e-02f, -9.16185603e-02f, -6.92055747e-02f, 3.11852675e-02f, 2.92340852e-03f,
  1.80840015e-01f, 1.55639991e-01f, -6.37472123e-02f, -2.29811683e-01f, -3.98979448e-02f, 2.91223247e-02f, 1.30579486e-01f, 1.13402940e-01f, 2.53638998e-02f, -9.82928090e-03f,
  2.07463913e-02f, 8.97375494e-02f, 1.55874893e-01f, 5.56737892e-02f, 4.72769551e-02f, 4.48304005e-02f, -4.57674600e-02f, -3.70150222e-03f, 6.41020834e-02f, 1.88011490e-02f,
  1.02035224e-01f, -9.16889980e-02f, 5.13953492e-02f, 1.04794964e-01f, -2.59631705e-02f, -1.65752936e-02f, 1.04971379e-01f, -6.11338206e-02f, 7.13030621e-03f, 6.08908664e-03f,
  -3.87835443e-01f, 4.02718820e-02f, -1.53382257e-01f, -1.57048732e-01f, 2.41070867e-01f, 1.31460994e-01f, 3.96825492e-01f, 1.70319807e-03f, -1.64872706e-01f, 1.44801199e-01f,
  -9.28085670e-03f, -2.10915655e-01f, -7.22284988e-02f, -1.05794026e-02f, 3.89173888e-02f, 1.54976085e-01f, 1.29912049e-01f, -3.43199191e-03f, -8.35817829e-02f, -1.74314119e-02f,
  1.02218829e-01f, -1.44803837e-01f, -2.72351146e-01f, -8.59295428e-02f, 3.79107147e-02f, -2.31703930e-03f, -4.22476269e-02f, -1.89033151e-03f, 4.41013202e-02f, 1.73696522e-02f,
  -1.20836593e-01f, -1.54132739e-01f, 4.85730311e-03f, -1.40850127e-01f, -1.94784284e-01f, -1.50247529e-01f, -9.22418013e-03f, -8.80329832e-02f, 2.78532356e-02f, -1.47423476e-01f,
  -1.72228590e-01f, -1.80166230e-01f, -1.98899686e-01f, -1.41224921e-01f, -7.52908662e-02f, -7.02437311e-02f, -1.24305204e-01f, -1.22261733e-01f, -5.50717749e-02f, -1.50710776e-01f,
  -4.41547036e-02f, -1.26168221e-01f, -2.11553693e-01f, 5.37108183e-02f, -2.16071904e-01f, -1.63231671e-01f, -8.22665095e-02f, -1.39207065e-01f, -1.22190654e-01f, -2.32647672e-01f,
  7.09125400e-02f, -1.14973918e-01f, 3.89746651e-02f, 3.49916331e-02f, 4.27324921e-02f, 2.35791616e-02f, -1.31562306e-02f, -4.87059876e-02f, 3.84242088e-02f, 2.65491102e-03f,
  -5.58826141e-02f, -7.41019920e-02f, -6.30958825e-02f, -8.84053856e-02f, -2.53390856e-02f, -3.21639366e-02f, -6.49543153e-03f, -5.70505522e-02f, -2.55412515e-02f, 2.20059141e-04f,
  3.95617969e-02f, 4.93117571e-02f, -6.25661239e-02f, 5.99693246e-02f, -2.04673354e-02f, 1.22670077e-01f, 5.92215061e-02f, -3.50122601e-02f, 2.37987842e-02f, -3.59391049e-02f,
  -9.88927931e-02f, -1.59577936e-01f, 3.17930579e-02f, -1.92110129e-02f, -1.03499465e-01f, -2.01931193e-01f, -8.07503983e-02f, -7.93070793e-02f, -1.33874286e-02f, -6.75952584e-02f,
  -9.26629901e-02f, -1.31734625e-01f, -1.43070042e-01f, -7.02390596e-02f, -1.17561715e-02f, 4.00743959e-03f, -9.52309072e-02f, 8.26227069e-02f, 2.48287368e-04f, -7.34025687e-02f,
  -1.22833595e-01f, 9.83766243e-02f, 2.84941439e-02f, 5.13513312e-02f, -1.60428986e-01f, -1.93411931e-02f, 1.93489660e-02f, -2.24948283e-02f, 2.17140689e-02f, 1.77197561e-01f,
  -3.73080224e-01f, -4.17772308e-02f, 1.15025453e-01f, -5.30321635e-02f, 1.02601089e-01f, 1.90955419e-02f, 2.65513062e-01f, -1.06872365e-01f, -2.09461361e-01f, -4.54443023e-02f,
  -2.47112401e-02f, -8.99230465e-02f, -3.47463600e-02f, -1.93611439e-02f, -7.12524131e-02f, 3.04162294e-01f, 2.21028730e-01f, 9.16527957e-02f, 1.67783760e-02f, 6.78295642e-02f,
  2.75992658e-02f, 4.67741936e-02f, -1.43561482e-01f, 6.13084324e-02f, 9.40630436e-02f, 1.11561313e-01f, 9.94046256e-02f, 1.50589561e-02f, 1.96281493e-01f, 2.59376466e-01f,
  4.34287153e-02f, -1.53064162e-01f, 9.14556831e-02f, 3.62623930e-02f, -2.18113009e-02f, -9.00428966e-02f, 2.78094020e-02f, -7.85204861e-03f, -5.60293309e-02f, -4.48379405e-02f,
  8.44442621e-02f, -5.71516417e-02f, -1.10041901e-01f, -1.20388884e-02f, -1.94687676e-02f, -4.49269935e-02f, 5.14528994e-03f, -1.31779641e-01f, -6.82590604e-02f, 1.59840640e-02f,
  6.22497201e-02f, -1.72626022e-02f, 1.08201597e-02f, 5.64453974e-02f, 2.68018665e-03f, 6.03292175e-02f, 2.74202581e-02f, 6.01005033e-02f, -5.81309497e-02f, -9.15583689e-03f,
  -1.62219666e-02f, 7.13721588e-02f, 1.64053519e-03f, -3.70347835e-02f, 9.05764475e-02f, 5.09544238e-02f, 8.74966606e-02f, 7.53738880e-02f, 7.96702802e-02f, 3.88886854e-02f,
  -9.02606361e-03f, 1.13623403e-01f, -5.21734059e-02f, 9.46628749e-02f, 2.49029770e-01f, 8.11661109e-02f, 6.57566786e-02f, 3.45874839e-02f, 4.52667661e-02f, 1.52655644e-03f,
  2.92462409e-02f, -5.35712857e-03f, 4.96021137e-02f, -4.32575122e-02f, -6.88062385e-02f, 1.16184115e-01f, 1.34711526e-02f, -3.63949104e-03f, -9.73498151e-02f, 4.32248153e-02f,
  -1.36700630e-01f, -2.20797900e-02f, 2.01234762e-02f, 4.66490909e-03f, 5.91807850e-02f, -7.17438981e-02f, -9.22095552e-02f, 3.84251364e-02f, 1.87257398e-02f, -4.58072424e-02f,
  4.12976742e-02f, 4.61023785e-02f, -6.08284883e-02f, -7.19151795e-02f, -2.44493298e-02f, -1.38751799e-04f, 4.45587374e-02f, -5.63887171e-02f, 5.45451902e-02f, -7.51050143e-03f,
  -6.85527995e-02f, 3.17226015e-02f, -3.42154503e-02f, -3.64008062e-02f, 2.71618702e-02f, 4.65121232e-02f, 4.59928922e-02f, 3.89648527e-02f, -6.98312968e-02f, 1.26911715e-01f,
  4.14787143e-01f, -2.34089121e-02f, -7.42028505e-02f, 1.52223691e-01f, 1.72878280e-02f, 9.03626382e-02f, 5.36106229e-02f, 9.63373184e-02f, -8.03076290e-03f, -2.48605590e-02f,
  -3.30869779e-02f, -2.56876647e-01f, -2.26707608e-01f, -2.52785772e-01f, -9.47932675e-02f, -1.28716648e-01f, -1.49272159e-01f, -8.17269180e-03f, 9.53928083e-02f, 2.63413303e-02f,
  -6.09677397e-02f, 8.77526030e-02f, 2.40028903e-01f, 2.46842224e-02f, -1.86966375e-01f, -8.14324766e-02f, -2.01654315e-01f, -2.29584184e-02f, -1.33612141e-01f, -2.37407863e-01f,
  -2.60225177e-01f, 8.26608762e-02f, -7.09750801e-02f, 5.51066361e-02f, 1.72058064e-02f, -9.76949483e-02f, 2.34009959e-02f, -3.91124301e-02f, -6.48170635e-02f, -3.81190628e-02f,
  -1.02178641e-02f, -3.74720916e-02f, -8.40281397e-02f, 2.44518034e-02f, 8.05787146e-02f, -1.50523223e-02f, 1.11229219e-01f, -3.77992243e-02f, -5.14847860e-02f, -1.38829369e-02f,
  -6.53370321e-02f, 1.70982443e-02f, 4.75800820e-02f, 4.08875337e-03f, -6.56822100e-02f, -1.23351086e-02f, -1.04685076e-01f, -1.31467149e-01f, -1.17920287e-01f, 5.89871667e-02f,
  4.99454029e-02f, 1.85300067e-01f, 1.34973243e-01f, 8.48692507e-02f, 2.14927271e-01f, 8.22510347e-02f, 5.84074594e-02f, 7.92378187e-02f, 1.32570609e-01f, 1.87563717e-01f,
  1.60433888e-01f, -2.11624503e-02f, -5.51961781e-03f, 6.23085871e-02f, -3.87803954e-03f, 1.17827475e-01f, 1.35259122e-01f, 6.65068328e-02f, 1.48939759e-01f, 1.33047447e-01f,
  1.01021454e-02f, 1.21898040e-01f, 7.09233209e-02f, 1.00450061e-01f, 8.19235519e-02f, -1.04067605e-02f, 9.60076973e-02f, 7.40857348e-02f, 4.87958267e-02f, 5.53485490e-02f,
  -1.58398226e-01f, -2.46577039e-01f, -1.57536477e-01f, -1.06754318e-01f, -6.67354390e-02f, -9.57569331e-02f, -1.47439465e-01f, -1.07993178e-01f, -1.02473229e-01f, -5.61072901e-02f,
  -1.41629860e-01f, -7.05683902e-02f, -4.65726070e-02f, -1.54365376e-02f, 1.41698092e-01f, -3.69575843e-02f, 1.16005585e-01f, 1.83117222e-02f, -1.38652384e-01f, 1.14033408e-01f,
  6.82863742e-02f, 3.09379194e-02f, 1.01322994e-01f, 3.42256762e-02f, -1.03572480e-01f, -4.96523976e-02f, -1.34525346e-02f, -1.34863093e-01f, -3.86711285e-02f, 1.42819285e-01f,
  -2.30851471e-01f, -2.14283794e-01f, -9.97346118e-02f, 4.01529158e-03f, -8.49104375e-02f, 4.32070531e-02f, -1.41489029e-01f, 6.20585047e-02f, 6.60505816e-02f, -6.03590272e-02f,
  5.32219224e-02f, 2.66457111e-01f, 2.18971431e-01f, 1.66893795e-01f, 2.01264918e-01f, -1.34491161e-01f, -9.64170098e-02f, 1.22064948e-02f, 1.71233952e-01f, 9.71236825e-02f,
  3.17763612e-02f, 3.42450850e-02f, 1.82903364e-01f, 2.25502729e-01f, -1.56382024e-02f, 1.98522568e-01f, -4.94693741e-02f, -8.48236680e-03f, 9.68238041e-02f, -8.83233547e-02f,
  -1.58495203e-01f, -5.89809120e-02f, 1.76558033e-01f, -5.09696491e-02f, 9.20389593e-02f, 9.27453712e-02f, 1.28863350e-01f, 4.01889011e-02f, -1.02621717e-02f, -1.75403412e-02f,
  1.13911085e-01f, 1.40002981e-01f, 9.98824835e-02f, 1.20491490e-01f, -3.60832103e-02f, 5.24731837e-02f, 1.17165126e-01f, 6.24364875e-02f, 1.35598093e-01f, 8.73673186e-02f,
  -6.21101167e-03f, 8.05755779e-02f, -4.63341828e-03f, 8.35253671e-02f, 9.96610746e-02f, 2.08512932e-01f, 9.25644264e-02f, 1.62255764e-01f, 1.57503799e-01f, 5.96991852e-02f,
  2.20030453e-02f, -7.88431466e-02f, 7.16937929e-02f, -3.23941410e-02f, 1.06720338e-02f, 3.00681288e-03f, 5.70669817e-03f, 7.85068572e-02f, -5.85252699e-03f, 6.70217909e-03f,
  3.04198125e-03f, -1.02945991e-01f, -7.71393701e-02f, 5.32148778e-02f, -2.75498889e-02f, 9.59830880e-02f, -3.33928727e-02f, 9.25476179e-02f, 4.12223190e-02f, -1.05589591e-01f,
  -1.33222237e-01f, -8.57486855e-03f, 1.31545160e-02f, -1.20648026e-01f, -4.14967313e-02f, 2.53945347e-02f, 9.80061740e-02f, 5.73108010e-02f, 6.49675652e-02f, -5.81178330e-02f,
  -8.91883820e-02f, 1.09199882e-01f, 4.98094708e-02f, 8.06055069e-02f, 8.90784338e-02f, 1.90939307e-01f, 2.83844918e-02f, -1.25006316e-02f, 2.60768794e-02f, 1.43757075e-01f,
  -1.94592103e-02f, 1.09986596e-01f, 4.23599500e-03f, -9.06638429e-02f, -4.21723127e-02f, 2.15228181e-02f, 1.59825504e-01f, 6.00731280e-03f, 2.85595804e-02f, 6.40091598e-02f,
  -9.55764353e-02f, -1.00346632e-01f, -1.84059635e-01f, -1.01735048e-01f, 9.61321294e-02f, -2.02918071e-02f, -8.26799199e-02f, 5.43530807e-02f, -1.40192121e-01f, -1.35470584e-01f,
  3.64807427e-01f, 1.17815606e-01f, -6.01129979e-02f, 1.93048075e-01f, -1.91084564e-01f, -2.06952050e-01f, -3.28761131e-01f, -6.13069832e-02f, 1.98489413e-01f, -7.11836666e-02f,
  8.79122466e-02f, 1.57510996e-01f, 1.17754452e-01f, -1.20668095e-02f, -1.72362223e-01f, -2.03102589e-01f, -1.23857267e-01f, -1.70391113e-01f, -1.76401705e-01f, -1.25415012e-01f,
  -4.03249636e-02f, 9.49802473e-02f, 8.15203935e-02f, 4.71140631e-02f, 8.12887624e-02f, 9.92624164e-02f, 5.19031398e-02f, 1.69561222e-01f, -1.53912352e-02f, 1.38451178e-02f,
  1.83578096e-02f, 7.40466490e-02f, -1.21996813e-01f, 1.21739253e-01f, 1.26826525e-01f, 8.21830183e-02f, -5.03526591e-02f, 1.41681567e-01f, 1.62412077e-01f, 7.64229894e-02f,
  2.21865356e-01f, 1.61816791e-01f, 8.92041996e-02f, -1.01238266e-02f, 5.10810651e-02f, 7.12900748e-03f, 8.90727416e-02f, -4.65013124e-02f, 2.83870418e-02f, -2.31838338e-02f,
  9.38687939e-04f, 6.13091365e-02f, 5.72698098e-03f, -4.91103306e-02f, 7.43930861e-02f, 5.72050028e-02f, -1.07671251e-03f, 3.12348846e-02f, 9.93744936e-03f, 7.55946785e-02f,
  -3.42676379e-02f, -4.37288843e-02f, -5.84252775e-02f, -1.11258864e-01f, 2.59803999e-02f, 1.56165147e-02f, -4.05687578e-02f, -7.79152140e-02f, -8.97411704e-02f, -6.93040639e-02f,
  -1.43902339e-02f, 8.71932320e-03f, -5.46765886e-02f, -3.36779840e-02f, -3.49524021e-02f, 1.49795339e-02f, -8.18160549e-02f, 4.06968547e-03f, -7.50291049e-02f, 1.69692598e-02f,
  -1.18666686e-01f, -8.36967975e-02f, 3.93421836e-02f, -1.01789601e-01f, -1.10271752e-01f, -1.04489818e-01f, 2.14622244e-02f, -3.46621238e-02f, -2.71968208e-02f, 3.26436684e-02f,
  3.23023856e-01f, -1.12366388e-02f, -1.59192123e-02f, -1.81387570e-02f, 5.12092859e-02f, -2.63164323e-02f, 6.10698573e-02f, 1.54279452e-02f, -7.00457841e-02f, 3.23346630e-03f,
  1.37945876e-01f, 2.80840453e-02f, 3.93651240e-02f, 1.21893115e-01f, -8.56627822e-02f, -7.62938173e-04f, 7.60713965e-02f, -1.86836019e-01f, 6.27241097e-03f, -5.99427037e-02f,
  1.16131390e-02f, -1.05105378e-01f, -1.09026551e-01f, -7.78726935e-02f, -9.12888050e-02f, -8.28858092e-02f, 1.86546165e-02f, -3.20444144e-02f, -1.86782524e-01f, -2.51655012e-01f,
  -2.92021513e-01f, 7.67984763e-02f, -1.57741487e-01f, -6.46658093e-02f, 4.18954529e-02f, -9.33844373e-02f, -3.56506556e-02f, 4.61482629e-02f, 1.48978114e-01f, 8.47511515e-02f,
  2.01412097e-01f, 3.56847286e-01f, 1.93901286e-01f, 2.65278578e-01f, -7.15835392e-02f, -1.41307309e-01f, -1.79580525e-01f, -9.77906361e-02f, 5.27355745e-02f, 5.36713153e-02f,
  2.68643737e-01f, 7.00394362e-02f, -4.75910529e-02f, 8.19587440e-04f, 2.22315013e-01f, 1.36026919e-01f, 9.59591195e-02f, -2.28546769e-03f, 1.76377818e-01f, 4.36314419e-02f,
  4.64000739e-02f, -1.12655200e-01f, 4.91627045e-02f, 7.71616995e-02f, 1.45976111e-01f, 2.38418411e-02f, 6.47283271e-02f, 1.20226182e-01f, 1.69615090e-01f, -6.17219359e-02f,
  1.59574345e-01f, 1.80444762e-01f, 1.89787298e-01f, 2.73572981e-01f, 8.46939385e-02f, 3.73488516e-02f, 8.87352526e-02f, -5.18712550e-02f, 1.36787638e-01f, -2.00657398e-02f,
  1.65562630e-01f, 7.13811368e-02f, -8.99101198e-02f, 3.86445820e-02f, 7.23724365e-02f, -3.58474515e-02f, 2.32069977e-02f, 9.95281786e-02f, 5.02991825e-02f, -3.55839953e-02f,
  -9.25118402e-02f, -5.69641702e-02f, 6.86544552e-02f, -2.80018691e-02f, -4.71727327e-02f, -9.50502072e-05f, -3.40720974e-02f, -1.35027424e-01f, -5.63891605e-03f, -1.10395491e-01f,
  -3.99748795e-02f, -7.45184124e-02f, -1.14138136e-02f, -1.48616880e-01f, -1.38342436e-02f, 3.75007987e-02f, -5.80165796e-02f, -1.64802432e-01f, -2.31788922e-02f, -1.85588077e-02f,
  -4.94562462e-02f, -2.95641180e-02f, 1.92727265e-03f, 5.16922586e-02f, -1.79969817e-01f, -1.53974637e-01f, -5.11756614e-02f, -1.46427631e-01f, -6.42081052e-02f, 1.84864458e-02f,
  1.90129101e-01f, 1.99107170e-01f, 4.13788632e-02f, 6.51836544e-02f, -3.52951488e-03f, -8.52212775e-03f, 1.00093171e-01f, -3.95168662e-02f, 7.47475959e-03f, -1.80196524e-01f,
  -1.22089898e-02f, -2.03120448e-02f, 1.93491310e-01f, 2.38891952e-02f, 6.88153356e-02f, -1.11098200e-01f, 7.07222968e-02f, 1.16965614e-01f, 3.92861478e-02f, 3.66814472e-02f,
  5.09328544e-02f, -8.97068456e-02f, -1.25386879e-01f, 2.26740502e-02f, 2.88818274e-02f, -3.37516107e-02f, -5.08751124e-02f, 6.39517978e-02f, -4.92575876e-02f, -6.09013885e-02f,
  3.26668382e-01f, -2.59578049e-01f, -1.05832942e-01f, -3.75680961e-02f, -2.05191933e-02f, 1.50789097e-01f, 7.41366968e-02f, 5.38660884e-02f, -9.20120627e-02f, -1.43673513e-02f,
  7.49365911e-02f, 1.54996172e-01f, 7.34731629e-02f, 7.63918757e-02f, 9.46148187e-02f, -8.66534486e-02f, -2.29684323e-01f, 5.50898872e-02f, 2.38549560e-01f, 1.60267279e-01f,
  -2.09959671e-02f, -2.68517025e-02f, 1.98879272e-01f, 7.12221339e-02f, -3.48758131e-01f, 2.75064930e-02f, -1.96272433e-01f, -5.42750470e-02f, -9.44668949e-02f, -5.41722357e-01f,
  3.49773206e-02f, -1.06152497e-01f, 8.34526643e-02f, 5.51936328e-02f, -5.89658096e-02f, -6.50926828e-02f, 1.27200156e-01f, -1.20068416e-01f, 1.02252886e-01f, -1.81913450e-02f,
  -1.33039773e-01f, -5.13802690e-04f, 8.26189294e-02f, 3.50241698e-02f, 1.54039999e-02f, 6.13101684e-02f, -1.69753611e-01f, -3.00738607e-02f, 9.46814418e-02f, -5.28245829e-02f,
  -8.65708515e-02f, -2.07305178e-02f, 7.29537159e-02f, -9.96388216e-03f, -7.59583060e-03f, -2.77802963e-02f, -7.83651620e-02f, 2.65132152e-02f, 7.93846995e-02f, -1.70874372e-01f,
  8.50629732e-02f, 3.68710384e-02f, -4.70659733e-02f, 7.89485965e-03f, 5.38458931e-04f, -3.10901217e-02f, -9.52551439e-02f, -5.38687482e-02f, 5.16437925e-02f, -9.66796950e-02f,
  -1.52384043e-02f, -4.94039766e-02f, 4.99690212e-02f, 4.81190197e-02f, -5.59962541e-02f, -2.61415653e-02f, -1.37390038e-02f, -5.00941426e-02f, -1.17803796e-03f, -4.58338968e-02f,
  -3.72364596e-02f, -3.94680388e-02f, -8.92316774e-02f, -5.98278493e-02f, -1.16671942e-01f, -3.65206860e-02f, 5.64792007e-02f, 6.00511627e-03f, 7.35793114e-02f, -9.54207405e-02f,
  -2.61159893e-03f, 2.10429505e-01f, -2.93242298e-02f, -1.56208379e-02f, -5.66603290e-03f, -8.57315138e-02f, -8.06955919e-02f, -1.61473826e-02f, -4.64759432e-02f, -7.27126300e-02f,
  2.28681974e-02f, -1.20975254e-02f, -1.17611304e-01f, -9.89947319e-02f, -7.55137531e-03f, -1.04236063e-02f, -3.08652166e-02f, -6.39055017e-03f, 8.08698237e-02f, 2.06328742e-02f,
  -1.00518897e-01f, 6.42730743e-02f, 1.48792714e-01f, 7.70061761e-02f, 2.13648751e-02f, 1.65939644e-01f, 6.02793917e-02f, 5.04769646e-02f, 1.59696698e-01f, 1.44091427e-01f,
  1.43597588e-01f, -9.19624269e-02f, -2.92584717e-01f, 1.75010425e-03f, 9.13843792e-03f, 6.80178627e-02f, -1.77800626e-01f, -1.31527744e-02f, 3.76875885e-02f, -1.05965219e-01f,
  2.38000397e-02f, -6.86016539e-03f, -1.14520013e-01f, -1.20773502e-01f, -2.37793773e-01f, -2.77770698e-01f, -2.88201660e-01f, -2.51923144e-01f, -2.86716763e-02f, 9.23904032e-02f,
  -6.23879284e-02f, -6.08429946e-02f, 3.51173952e-02f, 3.99275236e-02f, 5.72380535e-02f, 1.24623306e-01f, -5.27996793e-02f, 5.54781966e-02f, -8.34675357e-02f, -7.60021955e-02f,
  -2.78098911e-01f, 4.27377364e-03f, -1.85312647e-02f, -3.15165669e-02f, -7.83590302e-02f, -8.67899284e-02f, -1.29725501e-01f, -8.19060653e-02f, 5.80359548e-02f, -1.13789188e-02f,
  -8.37835446e-02f, 3.53926383e-02f, -4.82506007e-02f, -1.55913666e-01f, -8.06205571e-02f, -2.87585072e-02f, -6.90486431e-02f, -1.62225083e-01f, -1.22922167e-01f, -8.38673785e-02f,
  -2.28967052e-02f, -1.59278050e-01f, -8.29875767e-02f, -1.50420028e-03f, -1.55093381e-02f, -2.14788765e-02f, 4.62481342e-02f, -7.06989020e-02f, -2.64099357e-03f, -6.68629725e-03f,
  1.16564864e-02f, 1.63854938e-02f, 1.01908103e-01f, 7.14680701e-02f, 7.36700669e-02f, 2.44223122e-02f, 2.78922766e-02f, -1.09736517e-01f, -3.70017183e-03f, 4.17640023e-02f,
  -4.85842489e-02f, 1.26535576e-02f, 5.68229817e-02f, -5.02485037e-02f, 4.68045799e-03f, 7.76642263e-02f, 1.39535084e-01f, 3.57070565e-02f, -1.22931320e-02f, 6.70428276e-02f,
  1.25549212e-01f, 4.84282710e-02f, 1.17330901e-01f, 2.34996408e-01f, 8.17625821e-02f, -8.86406749e-02f, 4.31997553e-02f, 1.87522084e-01f, -2.75577381e-02f, 1.26530956e-02f,
  -9.26152170e-02f, -1.41827479e-01f, -1.24686234e-01f, -2.00383365e-01f, -1.32617444e-01f, -1.51880272e-02f, -6.46894872e-02f, -6.14948608e-02f, -5.81153445e-02f, -7.21491948e-02f,
  4.11950871e-02f, -2.32928991e-02f, -8.47327262e-02f, -4.87813987e-02f, 2.20019929e-02f, 2.38447972e-02f, -1.04810692e-01f, 3.45203727e-02f, -4.38963287e-02f, 2.76790150e-02f,
  -8.20864290e-02f, -1.70557853e-02f, -9.18451399e-02f, -3.28201391e-02f, -7.58235082e-02f, -9.68629643e-02f, 9.06564575e-03f, -6.77717626e-02f, -6.05499074e-02f, -1.01176806e-01f,
  -1.46761924e-01f, 8.34176987e-02f, 3.16396803e-01f, -7.80701190e-02f, -4.34620120e-02f, -1.14925303e-01f, -6.24876097e-02f, -1.26923785e-01f, -1.13287747e-01f, 1.25546739e-01f,
  -4.84718569e-02f, -2.29412481e-01f, -5.99077269e-02f, -6.62685558e-02f, -5.91064319e-02f, 2.87398815e-01f, 2.70469278e-01f, 1.70595512e-01f, -2.84402102e-01f, -3.18437070e-01f,
  -1.04124576e-01f, -1.28026828e-01f, -5.84798232e-02f, -3.92411649e-02f, 4.98759747e-03f, -8.74708071e-02f, 1.27682865e-01f, 9.78766680e-02f, 1.18643083e-01f, 3.63817096e-01f,
  1.12832271e-01f, -8.45542476e-02f, -1.48455828e-01f, -9.02454406e-02f, 1.12828789e-02f, -2.94431821e-02f, -3.56820524e-02f, -2.55597420e-02f, 2.25445461e-02f, 1.74309582e-01f,
  3.12572308e-02f, 7.40763824e-03f, 5.45811886e-03f, 6.42687529e-02f, -8.66786391e-02f, 6.95304666e-03f, 5.25535978e-02f, 4.12776135e-02f, -9.73123219e-03f, -6.49882481e-02f,
  9.85341147e-03f, -3.33245769e-02f, -1.45068660e-01f, 1.34765394e-02f, -4.60979417e-02f, -1.14799239e-01f, -1.04999565e-01f, -1.32500827e-01f, -1.60926759e-01f, 1.66671742e-02f,
  -3.92959304e-02f, -1.26709335e-03f, 6.33491483e-03f, 2.99272258e-02f, -2.57352088e-03f, -6.13562167e-02f, 7.32869208e-02f, -1.49841635e-02f, 3.00599933e-02f, -3.85358371e-02f,
  1.39277056e-02f, -9.01618004e-02f, 4.21902090e-02f, -6.57443628e-02f, -9.44225118e-02f, 2.78620105e-02f, -2.54835654e-02f, -7.50104487e-02f, 2.00273376e-02f, -2.42372900e-02f,
  -1.15372099e-01f, 2.59842966e-02f, -8.29141121e-03f, -2.92346496e-02f, -6.79801777e-02f, 2.33141743e-02f, 2.01915428e-02f, -7.65163004e-02f, -3.14223431e-02f, -6.33012736e-03f,
  -1.65993288e-01f, -7.09698498e-02f, 3.61848325e-02f, 6.98754913e-04f, -4.62608077e-02f, -6.21462911e-02f, 3.59764956e-02f, 1.35692498e-02f, 3.27861756e-02f, -9.47301984e-02f,
  -7.55541166e-03f, 1.16645219e-02f, 2.61845719e-02f, -7.10676983e-02f, -8.81517828e-02f, -1.25292361e-01f, 7.20192939e-02f, 3.13310437e-02f, -1.51153177e-01f, -5.97218499e-02f,
  4.18260247e-02f, -7.60607347e-02f, -2.29908064e-01f, -5.78089245e-02f, -1.54473379e-01f, -2.45566443e-01f, -1.28137261e-01f, -1.70980781e-01f, -1.83315560e-01f, -1.09892406e-01f,
  1.31957352e-01f, 5.55564091e-02f, -1.68181345e-01f, -1.08842500e-01f, -5.61723597e-02f, -2.62004286e-02f, 9.87223908e-02f, -1.22342361e-02f, -4.95829321e-02f, -7.30624795e-02f,
  3.67697701e-02f, -7.56864250e-02f, -2.03532323e-01f, 4.59918240e-03f, -5.55758104e-02f, -1.77387163e-01f, -1.83310986e-01f, -1.35874152e-01f, -1.46733582e-01f, -3.26467380e-02f,
  -4.60767299e-02f, -8.27709511e-02f, 4.16231565e-02f, 2.92883292e-02f, -2.65534483e-02f, -5.37312590e-03f, -1.52848735e-01f, -5.59417019e-03f, -5.44094965e-02f, -8.11035335e-02f,
  -2.00915664e-01f, 3.26093465e-01f, 1.93467885e-01f, 1.46002933e-01f, 1.13876298e-01f, 7.44927898e-02f, 1.60568506e-01f, 1.06667481e-01f, 1.44114733e-01f, 1.94635764e-02f,
  -4.57873158e-02f, 8.62684846e-02f, 7.92995021e-02f, -3.87102515e-02f, 1.36952236e-01f, 6.48118649e-03f, 3.80997248e-02f, 1.38271019e-01f, 1.39437407e-01f, 5.61523736e-02f,
  3.01608350e-02f, -2.07093731e-02f, -2.54486725e-02f, 2.09077999e-01f, 2.79275812e-02f, -2.50186957e-02f, 1.47052139e-01f, 1.29518822e-01f, 1.12136938e-01f, 1.63127586e-01f,
  -4.70488928e-02f, 4.66739200e-02f, 5.96325696e-02f, -8.23502988e-02f, -3.20186168e-02f, -6.82513416e-02f, -5.33779897e-03f, -8.02003741e-02f, 3.68328877e-02f, -6.56531379e-02f,
  -1.18797354e-01f, -1.63540468e-02f, -9.71178114e-02f, -5.38267493e-02f, -1.61793325e-02f, 6.21695369e-02f, 4.60934602e-02f, 3.73309059e-03f, -7.59667009e-02f, 7.18801841e-03f,
  -6.54731318e-02f, 3.09172776e-02f, -5.04368953e-02f, 9.14887525e-03f, 7.25180879e-02f, -1.53058255e-02f, -3.47963348e-02f, -1.27107635e-01f, -1.36480540e-01f, 1.91740282e-02f,
  -2.69326031e-01f, 1.01461247e-01f, 2.07995728e-01f, 2.94900388e-02f, 3.00513487e-02f, 2.56505571e-02f, 9.29320976e-02f, 3.56695466e-02f, 7.76647637e-03f, 9.37009901e-02f,
  1.07342996e-01f, 5.06567992e-02f, -8.29200149e-02f, 1.23501327e-02f, -2.86735985e-02f, -6.73817694e-02f, -1.00246236e-01f, 6.94932938e-02f, 5.90123124e-02f, 1.90623820e-01f,
  -2.10695788e-02f, -1.24260627e-01f, -1.10776606e-03f, 2.30399407e-02f, 5.07087037e-02f, 8.86282139e-03f, 6.14240542e-02f, 1.37513161e-01f, 5.29817268e-02f, -8.56097639e-02f,
  4.89651449e-02f, -2.98410147e-01f, 1.20929284e-02f, 4.25016545e-02f, -2.42443547e-01f, -1.37786597e-01f, -9.34189335e-02f, -1.01087712e-01f, 4.88388166e-02f, -1.36361927e-01f,
  -5.25257066e-02f, 1.79771274e-01f, 1.18975505e-01f, 1.67580917e-01f, 1.71491772e-01f, -8.32315627e-03f, -5.93495741e-02f, 1.84247285e-01f, 1.26624286e-01f, -8.34657159e-03f,
  -2.02085540e-01f, -1.45539539e-02f, 1.77558344e-02f, 5.12037091e-02f, -2.44641513e-01f, 3.55797559e-02f, -2.04273909e-01f, -2.23556176e-01f, -9.37348679e-02f, -2.48346567e-01f,
  2.97204584e-01f, -3.46794054e-02f, 1.55518621e-01f, -7.20422901e-03f, 2.13274267e-02f, 3.80629674e-02f, -3.68578769e-02f, -2.52067428e-02f, 3.53731737e-02f, -2.17379648e-02f,
  -5.94118834e-02f, -6.49224296e-02f, 2.62894966e-02f, 9.29464586e-03f, -2.39485502e-02f, 3.10312770e-02f, 5.87082207e-02f, 7.20634237e-02f, -6.84766546e-02f, -3.55401151e-02f,
  -8.47730488e-02f, -1.70227259e-01f, -9.50730294e-02f, 7.04069156e-03f, 1.47146750e-02f, -4.58845356e-03f, -1.67040437e-01f, -1.29981816e-01f, -6.30387813e-02f, -5.62091097e-02f,
  -7.44828535e-03f, 2.02593077e-02f, 1.00307986e-02f, 1.20896101e-02f, 4.00168598e-02f, -6.69682324e-02f, -6.78225905e-02f, -2.65436955e-02f, -9.84146027e-04f, -1.10811917e-02f,
  1.87744610e-02f, 3.69138946e-03f, 1.61026102e-02f, -9.12973583e-02f, 1.09491765e-01f, -6.68890998e-02f, -1.80281717e-02f, -1.44903688e-02f, 4.87259515e-02f, -5.54994233e-02f,
  -1.30229732e-02f, -2.05821963e-03f, 4.70950305e-02f, -6.74752146e-02f, -3.39381546e-02f, -2.40396447e-02f, -2.32766345e-02f, 2.12736409e-02f, 5.51165976e-02f, -2.93258764e-02f,
  1.80864200e-01f, 1.63914159e-01f, 3.03407549e-03f, 9.78155062e-03f, -2.28585079e-02f, 3.81505191e-02f, -8.76117963e-03f, -6.22636825e-02f, -5.75070158e-02f, 2.04877313e-02f,
  -1.12396203e-01f, 6.37905598e-02f, 5.25349043e-02f, -9.25581157e-03f, -4.80442448e-03f, -5.59434369e-02f, 9.31651667e-02f, 2.38445252e-02f, -1.15090877e-01f, -8.17025229e-02f,
  4.52899793e-03f, -8.91892146e-03f, -1.09393641e-01f, -1.50285588e-04f, -5.97738288e-02f, 2.02743392e-02f, 7.02261478e-02f, -7.06462264e-02f, 3.71793024e-02f, -1.02483235e-01f,
  -5.43782837e-04f, -3.69960874e-01f, 2.72521842e-02f, -4.88629974e-02f, -1.02052249e-01f, 3.81337777e-02f, -1.04492135e-01f, 1.06910758e-01f, 8.42554681e-03f, -1.47544235e-01f,
  -1.40159920e-01f, 2.17506453e-01f, 2.18238786e-01f, 1.97269455e-01f, 2.88217276e-01f, -4.21448871e-02f, -4.56129685e-02f, 3.07381064e-01f, 4.24387008e-01f, 1.65059566e-01f,
  -6.58574998e-02f, -6.19493127e-02f, 5.46617024e-02f, 1.78399861e-01f, -1.50730163e-01f, -2.78439689e-02f, -2.07966253e-01f, -2.68879741e-01f, -1.16365932e-01f, -3.39582592e-01f,
  -1.59296945e-01f, -1.46672383e-01f, 2.94610381e-01f, 2.83756591e-02f, 3.55060063e-02f, 1.57943755e-01f, 1.86998229e-02f, -4.63532424e-03f, 1.54251888e-01f, -3.42270471e-02f,
  -3.60226934e-03f, 7.21816570e-02f, 1.33447975e-01f, 6.54039755e-02f, 2.75093280e-02f, 1.02168128e-01f, 1.77198257e-02f, 1.57895163e-01f, 2.11313695e-01f, 4.55884226e-02f,
  5.97293600e-02f, -1.08273193e-01f, -5.45820445e-02f, 1.40646193e-02f, 2.06290558e-01f, 7.35223591e-02f, 2.64447071e-02f, 6.02004640e-02f, 1.74400568e-01f, -1.27199128e-01f,
  1.63854603e-02f, -2.40573306e-02f, -1.19442437e-02f, -1.18297525e-01f, -2.95027141e-02f, -8.03976692e-03f, -5.93198761e-02f, 4.08799909e-02f, 5.52730113e-02f, 3.57317254e-02f,
  -2.04214342e-02f, -1.93149298e-02f, 3.56209204e-02f, -2.61281412e-02f, -1.02185577e-01f, -1.35038299e-02f, 7.90058449e-03f, -6.62926286e-02f, 2.73289308e-02f, -7.95094017e-03f,
  -1.34596769e-02f, -5.31746000e-02f, -7.03605711e-02f, 1.03144489e-01f, -5.26173320e-03f, -4.70132753e-02f, -9.93216187e-02f, -9.18805525e-02f, -1.56047856e-02f, 4.41704458e-03f,
  -2.54503614e-03f, 2.68570602e-01f, 8.62991884e-02f, 1.15864612e-01f, -1.24444440e-02f, 8.22931975e-02f, 6.25958145e-02f, 1.20119676e-01f, 1.01430789e-01f, 8.11833292e-02f,
  9.44408029e-02f, 1.78448156e-01f, 3.84305827e-02f, 1.27545819e-01f, 1.29652023e-01f, 2.15684366e-03f, -1.85925011e-02f, 3.49143036e-02f, 1.30202040e-01f, 4.07369807e-03f,
  -1.70269143e-03f, 5.49135469e-02f, -1.29952258e-03f, 2.58526001e-02f, 3.25712003e-02f, 1.30624339e-01f, 8.36279467e-02f, 1.09323226e-01f, 2.07864001e-01f, -1.88241918e-02f,
  3.36991012e-01f, 2.35430047e-01f, 1.21981010e-01f, 5.41761555e-02f, -5.32254651e-02f, -3.12504992e-02f, -3.00383326e-02f, -4.98472750e-02f, -4.81859334e-02f, 2.00926781e-01f,
  6.71947673e-02f, -1.69709921e-01f, -1.60108894e-01f, -9.47135910e-02f, -1.69213921e-01f, -3.64400148e-02f, 1.04433827e-01f, -1.90537237e-02f, -3.66094857e-01f, -1.80312514e-01f,
  -1.84637025e-01f, 4.06836718e-02f, -2.91261673e-02f, -5.25080264e-02f, 1.52293295e-01f, -7.32678920e-02f, 2.37310857e-01f, 1.02981813e-01f, 4.17547561e-02f, 2.57879257e-01f,
  1.94228053e-01f, 3.12726825e-01f, -2.13027954e-01f, -1.84619874e-02f, 9.15414691e-02f, 1.04733869e-01f, 1.39975417e-02f, 8.45563412e-02f, 5.71683832e-02f, -7.83166289e-03f,
  3.77621204e-02f, 2.24396307e-02f, 5.67732602e-02f, 1.92348827e-02f, 9.18272510e-02f, -3.49720940e-02f, 9.06440839e-02f, 7.08482042e-02f, 7.92224854e-02f, 6.55582100e-02f,
  1.07302666e-01f, 1.92324206e-01f, 2.56922662e-01f, 7.88695142e-02f, 9.12824720e-02f, 7.71577582e-02f, 9.89698023e-02f, 2.00754374e-01f, 1.04112722e-01f, 2.05393434e-01f,
  3.11097968e-03f, 6.04132004e-02f, 3.73380445e-02f, 5.36374673e-02f, -3.06140017e-02f, 4.89514507e-02f, 6.74691275e-02f, -7.72701427e-02f, -1.34795457e-01f, -1.02927834e-02f,
  2.33303402e-02f, -1.11106955e-01f, -3.95343192e-02f, 1.40191559e-02f, 3.52575593e-02f, -3.34921991e-04f, 4.06679176e-02f, -1.10049821e-01f, 7.06177205e-02f, -9.86777470e-02f,
  -7.06422701e-02f, -2.60032248e-02f, -9.70426947e-02f, -5.38492836e-02f, -5.67219369e-02f, -9.71770287e-02f, -1.11549310e-01f, -1.90782905e-01f, -1.00335762e-01f, -1.37902528e-01f,
  -1.25398532e-01f, -1.15483224e-01f, -8.49265233e-02f, -9.42707658e-02f, 1.44251687e-02f, -6.38396479e-03f, 8.95030946e-02f, -7.57420659e-02f, 2.17587799e-02f, 6.09499328e-02f,
  -3.83942872e-02f, 3.83882113e-02f, 8.32627267e-02f, -2.70804763e-02f, -7.23182112e-02f, -5.58589175e-02f, 2.60533206e-03f, 7.69962966e-02f, 2.07350459e-02f, -4.92418325e-03f,
  -1.09076768e-01f, -3.33999209e-02f, -8.38317126e-02f, -7.90403783e-03f, 2.49351524e-02f, -2.80563198e-02f, -9.09946263e-02f, -3.32065597e-02f, -1.11809358e-01f, -3.50045078e-02f,
  1.17305920e-01f, -1.96962431e-01f, 4.12503064e-01f, -3.81221026e-02f, -3.04705024e-01f, -6.24894351e-02f, -1.83359683e-01f, -8.65729600e-02f, -1.31270755e-02f, -1.71693936e-01f,
  -1.87888205e-01f, 1.38289272e-03f, 8.48874971e-02f, 4.77320328e-03f, 2.23795131e-01f, 7.31813759e-02f, 8.27131569e-02f, 3.34714025e-01f, 2.71011233e-01f, -1.48217678e-01f,
  -2.60113001e-01f, -7.10164383e-02f, 2.03229353e-01f, 2.68633161e-02f, -2.68160760e-01f, -3.02867088e-02f, 8.80161766e-03f, -6.47303611e-02f, -1.41033396e-01f, -4.41110097e-02f,
  3.22055578e-01f, -1.76524088e-01f, -3.10498066e-02f, -1.09600276e-01f, 4.02990393e-02f, 2.91126762e-02f, -2.64627934e-02f, 5.12546562e-02f, -4.40997034e-02f, -9.59156197e-04f,
  -1.97296906e-02f, -7.36888424e-02f, 4.32368554e-03f, -3.12659703e-02f, -8.61041397e-02f, -2.30257064e-02f, -4.60862219e-02f, 3.52087058e-02f, 5.47357574e-02f, 4.20465022e-02f,
  -6.23227097e-02f, -6.58869594e-02f, 3.60126272e-02f, -5.29902009e-03f, 4.51983251e-02f, -7.78862461e-03f, 1.00272717e-02f, 6.00194223e-02f, 7.94975981e-02f, -6.67345002e-02f,
  7.36165121e-02f, 6.39709756e-02f, 1.40701011e-01f, 1.98186822e-02f, 6.74347505e-02f, 7.18908682e-02f, -2.07549930e-02f, 3.92461829e-02f, 1.70052182e-02f, 5.15363179e-02f,
  -5.44621507e-05f, 4.46620695e-02f, 3.76882330e-02f, 1.78003907e-02f, -1.65579207e-02f, -6.26947209e-02f, 5.92928752e-03f, 1.35276675e-01f, 5.50042391e-02f, -2.02427600e-02f,
  1.20630182e-01f, 7.58219436e-02f, 8.88914838e-02f, 2.79776957e-02f, 1.31793153e-02f, 7.68146515e-02f, -2.22247820e-02f, -6.05582409e-02f, -3.44831236e-02f, 3.72584537e-02f,
  3.93458828e-02f, 1.17933139e-01f, -4.07403015e-04f, -1.14417195e-01f, -2.38926746e-02f, -1.02325983e-01f, 6.97131157e-02f, 1.76824688e-03f, -3.88294049e-02f, 4.59365174e-02f,
  -8.22994392e-04f, -2.15681698e-02f, -7.85883814e-02f, 1.57382786e-02f, -1.47644237e-01f, 2.28331592e-02f, -6.01304099e-02f, -4.92621809e-02f, 2.11692695e-02f, -9.07750353e-02f,
  2.97674555e-02f, -8.75006989e-02f, 5.26262773e-03f, 3.86757925e-02f, -1.83243062e-02f, 2.94345431e-03f, 2.82848775e-02f, -6.70271590e-02f, 9.08215418e-02f, -1.13477737e-01f,
  6.36830688e-01f, -1.62185058e-01f, 1.75429508e-02f, 1.73004001e-01f, -1.35927632e-01f, 7.66454786e-02f, 2.02186808e-01f, 2.00341821e-01f, 1.33543506e-01f, 6.41853958e-02f,
  -1.40016869e-01f, -1.28017366e-01f, -3.81534137e-02f, -7.24721849e-02f, 1.01219743e-01f, 1.22405440e-02f, 3.16895917e-03f, 7.14019760e-02f, 2.19727799e-01f, 5.54004982e-02f,
  -1.96865231e-01f, 4.80514355e-02f, 2.93218732e-01f, 6.85846582e-02f, -2.68878825e-02f, -1.53921545e-01f, -6.71847314e-02f, -2.74501205e-03f, -1.95758015e-01f, -2.49326125e-01f,
  1.56538546e-01f, 1.32332131e-01f, -8.88901502e-02f, -3.08604278e-02f, -2.42755581e-02f, 1.31185278e-01f, 6.55527366e-03f, -5.24652973e-02f, 2.11412925e-02f, 4.06725965e-02f,
  -3.68662663e-02f, -3.90310325e-02f, -5.28322672e-03f, -4.00483124e-02f, -4.40265946e-02f, 9.83036757e-02f, -5.64974435e-02f, 1.36620514e-02f, 9.42358747e-02f, 1.06603265e-01f,
  -6.38433322e-02f, -4.91935425e-02f, 9.18554142e-02f, -5.04714772e-02f, 3.45245823e-02f, -1.43048614e-02f, -5.77517003e-02f, 2.65194364e-02f, -7.06062838e-02f, 6.04351163e-02f,
  -2.33500488e-02f, 1.20298453e-02f, -1.09806664e-01f, -8.85458197e-03f, -3.97872552e-02f, -7.78927049e-03f, -1.03825517e-01f, -2.07144599e-02f, -2.82794790e-04f, 2.64467634e-02f,
  -3.10887862e-02f, -4.28038165e-02f, -9.45595675e-04f, 2.34414563e-02f, -3.54013219e-03f, 2.09140759e-02f, 1.19175360e-01f, -3.68357971e-02f, 4.76228930e-02f, -2.11846083e-02f,
  1.18618030e-02f, 7.56731443e-03f, -2.46881396e-02f, -4.05647717e-02f, 3.63287292e-02f, 3.12013496e-02f, 1.78775396e-02f, -7.39713311e-02f, -4.26699631e-02f, 6.27750307e-02f,
  2.28743311e-02f, -1.60448387e-01f, 3.33395116e-02f, 5.42616025e-02f, -8.64632726e-02f, -9.18099731e-02f, -6.81574196e-02f, -2.58476976e-02f, -1.04414612e-01f, 1.19975088e-02f,
  3.79053392e-02f, 7.36590326e-02f, -9.94512811e-02f, -5.85790761e-02f, 9.53093395e-02f, -6.31876886e-02f, -9.80862007e-02f, 2.31192484e-02f, -3.42347063e-02f, -3.47869396e-02f,
  -8.72083604e-02f, 7.72581100e-02f, -2.99272463e-02f, 1.65778510e-02f, -2.55318098e-02f, 2.84082908e-02f, 8.64224974e-03f, -4.75463830e-02f, 1.04330570e-01f, 8.16313550e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.33983761e-01f, -2.18380168e-01f, -5.39091408e-01f, -2.73238868e-01f, -2.49958128e-01f, 6.47486448e-02f, -1.74404219e-01f, 1.69428036e-01f, -3.96807194e-02f, -3.91905189e-01f,
  -1.69952646e-01f, 1.19184606e-01f, -6.68393001e-02f, -7.32198134e-02f, 1.47990048e-01f, -3.33609045e-01f, -4.15241867e-01f, -1.77027464e-01f, 2.54984766e-01f, 2.27623716e-01f,
  -3.48020196e-02f, -6.33601844e-02f, 1.18772283e-01f, 6.07012734e-02f, -2.80948669e-01f, 1.58617888e-02f, -3.25820506e-01f, -1.03098832e-01f, 1.46685559e-02f, -3.26251239e-01f,
  -1.40814409e-01f, 1.14709567e-02f, -3.57204117e-02f, 7.09556565e-02f, -2.00651854e-01f, 5.68024591e-02f, 7.39907250e-02f, -6.34289160e-02f, -9.44558010e-02f, -9.45654437e-02f,
  -1.25480831e-01f, 1.28409103e-01f, 1.01336978e-01f, 1.39894839e-02f, -2.22844668e-02f, -1.46152629e-02f, -4.50762846e-02f, 3.50539722e-02f, -1.86512738e-01f, -1.43487111e-01f,
  -7.51440451e-02f, 3.42026632e-03f, 4.43665050e-02f, 1.56600475e-01f, 4.91720177e-02f, 4.42532375e-02f, 1.13973595e-01f, 6.98334426e-02f, 1.48783475e-01f, -1.80363916e-02f,
  2.45508850e-02f, -1.39550203e-02f, 4.97907735e-02f, 7.31705353e-02f, 7.93492794e-03f, 8.46335758e-03f, 1.30053498e-02f, 7.61938319e-02f, 3.17215025e-02f, 7.31343683e-03f,
  -3.49922702e-02f, -2.10557804e-02f, 4.40496057e-02f, -9.93652344e-02f, -1.46481037e-01f, -6.84007928e-02f, -5.36150709e-02f, 9.18282121e-02f, 4.89647351e-02f, -5.68541251e-02f,
  1.11667834e-01f, -9.83482692e-03f, -6.40224665e-02f, 1.38304427e-01f, 1.99104119e-02f, -9.90148634e-02f, 3.65322791e-02f, 1.40474290e-01f, 1.35330990e-01f, -6.41310215e-02f,
  -7.02291653e-02f, 1.47933945e-01f, -1.70099735e-01f, 1.33810803e-01f, -4.82595339e-02f, -2.01646551e-01f, -2.07137510e-01f, -2.59768236e-02f, 5.91995902e-02f, -4.80284058e-02f,
  1.46575570e-02f, 8.34979117e-02f, -1.61859822e-02f, -3.91194113e-02f, 8.99060965e-02f, 3.46790552e-02f, -6.39642179e-02f, -1.75202116e-02f, 5.66152995e-03f, -7.22876042e-02f,
  -1.12310767e-01f, 3.56765240e-02f, 4.82436717e-02f, 9.26574618e-02f, 4.84221578e-02f, 1.94847018e-01f, 1.88024081e-02f, 9.20323655e-02f, 1.31581470e-01f, 2.66681681e-03f,
  -2.68147618e-01f, 3.36829871e-01f, 1.03080105e-02f, -2.06295207e-01f, -7.19358921e-02f, 1.95274372e-02f, 3.53468448e-01f, 7.58851990e-02f, -1.59417346e-01f, 3.59259039e-01f,
  4.40564938e-03f, -2.04021618e-01f, -3.36914025e-02f, -7.53302649e-02f, -4.16300818e-02f, 3.27567995e-01f, 1.66735008e-01f, -2.32182801e-01f, -3.98136020e-01f, -1.34030908e-01f,
  1.24297850e-03f, -3.49610820e-02f, -1.06330797e-01f, -1.62054583e-01f, 1.04569763e-01f, -1.20136552e-01f, 1.93962455e-01f, -2.13968024e-01f, -9.73541364e-02f, 5.23868576e-02f,
  -7.74377584e-02f, -2.99799234e-01f, 3.90466414e-02f, -1.51640534e-01f, -4.51992899e-02f, -9.10090283e-02f, -3.82277146e-02f, -3.57282124e-02f, -8.27298313e-02f, 3.01773511e-02f,
  -1.81809992e-01f, 4.55037318e-02f, -3.25124562e-01f, 1.01741394e-02f, 7.81303458e-03f, -5.80675676e-02f, -1.36134535e-01f, -2.24855855e-01f, -2.08725795e-01f, 3.96922864e-02f,
  -6.44354969e-02f, -1.14862636e-01f, -2.18964189e-01f, -9.00583789e-02f, -2.49230817e-01f, -2.70347655e-01f, -2.37358008e-02f, -2.44351909e-01f, -1.91099435e-01f, 2.72530258e-01f,
  1.31624982e-01f, 2.61414200e-02f, -1.04749858e-01f, -5.94360940e-02f, -5.68767563e-02f, -5.58425561e-02f, 1.13330232e-02f, 7.15536103e-02f, 4.14448902e-02f, -2.80911406e-03f,
  -1.31329959e-02f, 9.01981667e-02f, -1.76304020e-02f, 6.06195480e-02f, 1.02698289e-01f, -4.22874168e-02f, 5.73168248e-02f, 4.34141271e-02f, -1.88531633e-02f, 4.15386222e-02f,
  -5.71611747e-02f, 2.01062299e-02f, 3.35794874e-02f, -1.78884286e-02f, -6.21454138e-03f, 2.52308846e-02f, 8.42905343e-02f, -8.56122747e-02f, -1.66274104e-02f, -2.03940328e-02f,
  1.72537506e-01f, -1.22084767e-01f, 1.95360556e-01f, 2.16064043e-02f, -1.53596373e-02f, 2.40457384e-03f, 7.42164850e-02f, 1.53737918e-01f, -5.62163219e-02f, 7.58709088e-02f,
  -1.54403389e-01f, 9.39118955e-03f, 5.45940027e-02f, 1.98233113e-01f, -4.19529714e-02f, 5.50530478e-02f, 2.20918700e-01f, -9.71070770e-03f, -3.39573771e-02f, 1.37975782e-01f,
  6.74214438e-02f, 1.21177360e-01f, 1.13992505e-01f, 1.30448848e-01f, -5.76770939e-02f, -4.22728918e-02f, 1.00146532e-01f, 1.18520260e-01f, 1.02766201e-01f, 5.85524619e-01f,
  -9.66602623e-01f, -2.52229393e-01f, 1.99506834e-01f, -3.84756029e-01f, -6.34587463e-03f, 1.63350090e-01f, 3.25845003e-01f, -1.65652111e-02f, -2.56194264e-01f, 4.39605676e-03f,
  -2.16002651e-02f, -3.08464430e-02f, 4.38336842e-02f, -5.61436936e-02f, 6.81022555e-02f, 2.63361573e-01f, 1.40222847e-01f, 1.15246326e-01f, 1.22543678e-01f, 1.11114644e-01f,
  2.53174622e-02f, -1.25753656e-01f, -3.56389672e-01f, -2.15686247e-01f, -4.46738824e-02f, -1.00026391e-01f, 4.69020195e-02f, -1.37026966e-01f, -2.37763524e-02f, -7.33365566e-02f,
  4.59358394e-01f, -2.02279314e-01f, 8.13491642e-03f, -1.81249365e-01f, -1.33028179e-01f, -8.83833319e-02f, -4.98376824e-02f, -1.17061045e-02f, -1.01829715e-01f, 7.55733326e-02f,
  -5.82523197e-02f, 5.71832387e-03f, -2.54887845e-02f, -1.00878187e-01f, 5.95057197e-02f, 2.39738859e-02f, 4.46501039e-02f, 1.01478286e-01f, 1.12391233e-01f, 1.04381286e-01f,
  -5.71630225e-02f, -3.23154554e-02f, 4.76938076e-02f, 1.24609865e-01f, 9.67571214e-02f, 1.00156032e-02f, -5.75206764e-02f, -5.69438078e-02f, 4.09449488e-02f, 5.15597872e-04f,
  1.06364831e-01f, 1.14586927e-01f, 4.39852700e-02f, 8.26198384e-02f, 6.70236815e-03f, 7.84244984e-02f, 1.18400808e-02f, 1.83732226e-01f, 7.89209902e-02f, -1.28939241e-01f,
  -3.45186293e-02f, 1.22234412e-01f, 3.65998782e-02f, -4.03940715e-02f, 2.91589815e-02f, -2.97980420e-02f, 2.01161820e-02f, 6.02022596e-02f, -7.80430064e-02f, -2.06251368e-02f,
  1.17046600e-02f, -5.13450615e-02f, -8.55634883e-02f, 3.47918198e-02f, 7.91876484e-03f, 1.60076600e-02f, -8.52031484e-02f, 7.32095689e-02f, -1.52540714e-01f, -1.07004315e-01f,
  5.35315096e-01f, -1.06327139e-01f, -8.14061761e-02f, 3.32721360e-02f, -2.47553121e-02f, -1.93341240e-01f, 7.25414753e-02f, 2.60754749e-02f, -3.49214040e-02f, 1.16978765e-01f,
  9.55887362e-02f, -1.29054664e-02f, -5.34060337e-02f, -1.61489984e-03f, -1.36956880e-02f, 8.05932656e-02f, 5.50252534e-02f, 1.30507603e-01f, 1.42997846e-01f, 1.28057882e-01f,
  -2.38883384e-02f, 1.43263623e-01f, 1.56575233e-01f, 5.44378348e-02f, 3.01471166e-02f, 4.18594480e-02f, 1.23850666e-01f, 1.31845400e-01f, 1.89817369e-01f, 1.60433233e-01f,
  6.10750675e-01f, -1.54228076e-01f, 2.70106912e-01f, 4.41519022e-02f, 3.85125577e-02f, 2.27034882e-01f, -5.30661978e-02f, 4.88299504e-02f, 1.64458618e-01f, 7.41091073e-02f,
  -4.72207367e-02f, 1.20913401e-01f, -1.27836680e-02f, -5.49262315e-02f, 1.19106853e-02f, -6.71318248e-02f, -5.64108901e-02f, 6.75547048e-02f, 3.15452397e-01f, 6.65526912e-02f,
  -1.25622451e-01f, -9.31352451e-02f, 8.98992419e-02f, 5.99668846e-02f, -1.31845936e-01f, -5.17336689e-02f, -2.04786271e-01f, -1.59497947e-01f, -2.39742652e-01f, -3.81598771e-01f,
  1.06626913e-01f, 2.74507493e-01f, 8.81912187e-02f, 3.73451188e-02f, -1.80489998e-02f, 4.36044373e-02f, 1.17323309e-01f, 8.98937881e-02f, -5.10866456e-02f, -5.21979369e-02f,
  -3.87626812e-02f, 8.90345946e-02f, 3.63238640e-02f, -1.47036128e-02f, -1.17520022e-03f, 7.24306703e-02f, 1.89249322e-01f, 1.01559833e-01f, 6.53507560e-03f, 1.54327508e-02f,
  -6.08761869e-02f, 9.13744494e-02f, 1.23758055e-01f, 6.25738725e-02f, 1.05886854e-01f, 1.28212616e-01f, 1.29271328e-01f, 1.28812239e-01f, 2.22527459e-01f, 7.35123781e-03f,
  -1.43278822e-01f, 1.09015340e-02f, 1.88237116e-01f, -1.58530958e-02f, 4.78178188e-02f, 3.96165773e-02f, -3.42176631e-02f, -4.80526388e-02f, -1.35535458e-02f, 1.78689172e-03f,
  -6.41849414e-02f, 9.57468227e-02f, 1.53365880e-01f, 4.35386673e-02f, 1.97657391e-01f, 2.01410308e-01f, 5.75297438e-02f, 1.10829147e-02f, 7.98975118e-03f, 7.27697089e-02f,
  1.54948920e-01f, 3.60066928e-02f, 5.60701266e-02f, 1.59713887e-02f, 5.35389856e-02f, 1.45312632e-02f, 1.53950062e-02f, 1.09602883e-02f, 4.12880033e-02f, -4.40456234e-02f,
  3.17081288e-02f, 2.66805172e-01f, -3.65932211e-02f, -2.05321282e-01f, 8.47994462e-02f, 1.03473915e-02f, 1.52099594e-01f, -6.70640916e-02f, -1.08014643e-01f, 5.70945349e-03f,
  -6.99161217e-02f, -7.14062080e-02f, -8.63365009e-02f, 4.18219566e-02f, -9.48018674e-03f, 1.41074613e-01f, 5.26939938e-03f, 1.17477551e-01f, -1.16241165e-02f, -9.69213098e-02f,
  -1.93592906e-02f, 8.93554837e-02f, 1.50876880e-01f, 9.20230076e-02f, 6.69716448e-02f, 1.39956981e-01f, 1.02499604e-01f, 1.67537890e-02f, 7.45994747e-02f, 1.06249787e-01f,
  1.92369729e-01f, -2.44141847e-01f, -4.21351463e-01f, 1.77124500e-01f, -6.34841993e-02f, 4.11114730e-02f, -2.47112438e-01f, 5.89738227e-02f, 1.41919807e-01f, -1.06790572e-01f,
  9.05251577e-02f, 2.72758961e-01f, -4.87470999e-03f, 3.61358933e-02f, 3.56049417e-03f, -3.52286935e-01f, -2.28027418e-01f, -1.21009186e-01f, 2.06721693e-01f, 8.58614743e-02f,
  2.20760226e-01f, 3.94304618e-02f, 1.22211687e-01f, 1.29821345e-01f, -1.04446828e-01f, 1.15358857e-02f, -2.12634414e-01f, 5.72275966e-02f, -3.52156907e-02f, -1.89436570e-01f,
  -9.97224450e-02f, -4.37732488e-02f, -1.47868246e-01f, 4.12476175e-02f, -2.48655491e-02f, -8.96566063e-02f, -9.09361467e-02f, -3.23437154e-02f, -2.51019485e-02f, -9.88464952e-02f,
  2.89678313e-02f, -1.88982729e-02f, 1.06807709e-01f, 6.85546473e-02f, -8.16252679e-02f, 3.18070017e-02f, -5.86243160e-02f, -7.26752803e-02f, -1.45597771e-01f, 5.01479954e-02f,
  3.89704928e-02f, 6.30877167e-02f, -1.80729292e-02f, -4.15078364e-02f, -7.38327429e-02f, 1.85723510e-02f, -1.21667840e-01f, 6.15313686e-02f, -2.95972787e-02f, -3.53585146e-02f,
  -4.88311239e-02f, -3.16406786e-02f, -3.42353061e-02f, -1.33040473e-01f, 8.18737298e-02f, 1.06427111e-01f, -4.80888747e-02f, 7.53584802e-02f, 2.36663148e-02f, 6.81302175e-02f,
  4.79877368e-02f, -1.38140902e-01f, -6.37196749e-02f, -3.66846658e-02f, 9.50418040e-02f, 8.52345601e-02f, 2.62218174e-02f, 5.42559512e-02f, 8.65999013e-02f, 2.26707086e-02f,
  1.58335224e-01f, 3.96111310e-02f, 4.55612056e-02f, 7.78668374e-02f, -5.07324971e-02f, 1.04089854e-02f, 3.55205201e-02f, 8.29295143e-02f, 1.42738894e-01f, 7.78470114e-02f,
  1.35457814e-01f, -1.76898852e-01f, -7.56656080e-02f, 3.76182497e-02f, -4.12171409e-02f, 3.61216478e-02f, 2.52863448e-02f, -3.39260809e-02f, -1.93961989e-02f, -4.56744954e-02f,
  -2.42180638e-02f, -6.86939359e-02f, -6.67243823e-02f, -4.88033295e-02f, 5.90474233e-02f, -1.60219446e-02f, 1.04935326e-01f, 4.62650359e-02f, -2.13235430e-02f, 5.51487878e-02f,
  4.31084260e-03f, 1.43881515e-01f, 6.75597861e-02f, -1.98016968e-02f, -1.38944527e-02f, -1.83019638e-02f, -1.12939939e-01f, -6.64684474e-02f, -2.13581294e-01f, -1.92444697e-01f,
  -1.48058265e-01f, 5.87505437e-02f, -1.00946724e-01f, 1.78733215e-01f, 1.95098713e-01f, -1.05773203e-01f, -4.57646906e-01f, -2.61066675e-01f, 2.65681982e-01f, -7.36658694e-03f,
  2.01880291e-01f, 2.49759585e-01f, 1.32015109e-01f, 6.89611258e-03f, -4.58550304e-01f, -2.98157603e-01f, -6.88555688e-02f, -1.54115587e-01f, -1.82176888e-01f, 5.40608279e-02f,
  4.15687636e-02f, -8.13667774e-02f, -6.79270104e-02f, -9.15337820e-03f, 2.44391963e-01f, -5.33038517e-03f, -2.04630271e-02f, 1.14359841e-01f, -1.57953762e-02f, 1.17891096e-01f,
  1.88690841e-01f, -5.88480942e-03f, 1.56166488e-02f, 8.33332539e-02f, 9.99130160e-02f, -1.80602059e-01f, 1.16970930e-02f, -4.46788110e-02f, -1.62756592e-02f, -4.91076820e-02f,
  5.30872904e-02f, 1.07697174e-02f, 6.75801858e-02f, 1.60317961e-02f, -1.74892554e-03f, -1.39474884e-01f, -2.84185082e-01f, -1.66203842e-01f, -2.62051493e-01f, -2.31449783e-01f,
  -1.26270697e-01f, 2.39377171e-01f, -8.38533640e-02f, -9.35348198e-02f, -2.92404771e-01f, -1.13137031e-03f, -1.29522383e-01f, -1.72522709e-01f, -1.90880299e-01f, 1.46753313e-02f,
  -3.25029790e-02f, 1.24566346e-01f, 1.38890803e-01f, -6.14964589e-02f, -3.58304642e-02f, 6.28164113e-02f, 9.65773687e-02f, 5.94013333e-02f, 1.73271671e-02f, -7.36645460e-02f,
  9.35931057e-02f, 4.66351844e-02f, 6.25639930e-02f, -3.65583263e-02f, -2.66479868e-02f, 6.06299527e-02f, 1.74114525e-01f, -1.73878163e-01f, -2.26852987e-02f, -4.02863249e-02f,
  4.81475592e-02f, -8.13392699e-02f, -3.39576975e-02f, -4.77777719e-02f, 4.17711511e-02f, 4.59401459e-02f, -1.31915048e-01f, -4.72895196e-03f, -6.94610029e-02f, 1.11023970e-02f,
  2.07121633e-02f, 2.96925232e-02f, -1.57017428e-02f, 3.69277149e-02f, 1.05370708e-01f, -2.35379860e-03f, 9.72325727e-03f, -8.26233923e-02f, 7.30873123e-02f, -7.33203664e-02f,
  -1.12719245e-01f, -1.01823183e-02f, -1.82839353e-02f, -1.28363445e-01f, 3.15579288e-02f, 3.88809405e-02f, -9.99934450e-02f, 5.36591075e-02f, -1.95342302e-03f, -1.01745196e-01f,
  -2.96618432e-01f, -6.88532963e-02f, -1.36305451e-01f, -2.47262254e-01f, 1.04824252e-01f, 1.94795579e-02f, -1.40621156e-01f, -7.92907402e-02f, -2.31371060e-01f, -4.33641046e-01f,
  3.23398709e-01f, -7.37890422e-01f, 4.09294218e-01f, 2.36699656e-02f, -2.93949451e-02f, 1.93349943e-01f, -1.24519788e-01f, -3.64328288e-02f, -4.31032255e-02f, -3.14116865e-01f,
  -4.86371607e-01f, -2.41022930e-01f, -2.62430340e-01f, -1.40242249e-01f, 2.97959819e-02f, 1.32940695e-01f, 2.45327741e-01f, 5.75663209e-01f, 5.14641047e-01f, -1.57087687e-02f,
  -2.70552576e-01f, -9.61077884e-02f, 8.58289823e-02f, 3.30212004e-02f, -3.22313279e-01f, 1.24027491e-01f, -2.70316582e-02f, -1.34758398e-01f, -1.29677445e-01f, -1.56622276e-01f,
  1.94564015e-01f, -2.61550218e-01f, 4.33466770e-02f, -1.45931378e-01f, -4.98467498e-02f, -1.23432331e-01f, 4.77769896e-02f, 1.63711440e-02f, 2.46131863e-03f, 9.70304236e-02f,
  -2.09808387e-02f, -1.68424584e-02f, 8.99325684e-02f, 9.85950418e-03f, 9.06598419e-02f, -5.07914014e-02f, -5.60938865e-02f, -5.41010313e-02f, -7.20323995e-02f, -1.52618766e-01f,
  -2.15829104e-01f, 4.97885421e-03f, 2.48137433e-02f, 7.41510466e-02f, 2.37554125e-02f, 5.78079820e-02f, -9.84980986e-02f, -5.46271028e-03f, 5.16883992e-02f, -1.94411442e-01f,
  1.48073494e-01f, 5.71434852e-03f, -1.26372501e-01f, -1.55826043e-02f, -1.84146538e-02f, 6.88650161e-02f, 1.69082418e-01f, -1.86322536e-02f, 1.26853613e-02f, -7.12274686e-02f,
  -9.71542448e-02f, -9.49662924e-02f, -7.10876510e-02f, -4.22662795e-02f, -3.96011509e-02f, -5.02688438e-02f, 7.68732950e-02f, 3.56605416e-03f, -3.29238251e-02f, 9.08561237e-03f,
  -1.28903657e-01f, -6.65633082e-02f, 9.68929194e-03f, 2.27122605e-02f, -2.95691704e-03f, -3.97246927e-02f, 7.09394226e-04f, -3.09622511e-02f, 6.55198470e-02f, -2.94586513e-02f,
  2.44396757e-02f, 1.67333454e-01f, 9.85223353e-02f, -9.67148542e-02f, 9.26524960e-03f, -1.72830716e-01f, -5.96214877e-03f, 7.30878746e-05f, -6.19482510e-02f, 2.82832328e-02f,
  -6.15559854e-02f, 5.41300438e-02f, -2.21691537e-03f, -8.63702968e-02f, 1.87889367e-01f, -3.23281623e-02f, -2.77432203e-01f, 9.90173197e-04f, 4.69223000e-02f, -4.70272899e-02f,
  -4.12927717e-02f, 1.49619117e-01f, 2.06293881e-01f, 1.30601674e-01f, 2.20230687e-02f, 2.22571984e-01f, 1.41379088e-01f, 3.02314991e-03f, 2.28558198e-01f, 2.76422836e-02f,
  5.26279628e-01f, 1.69711739e-01f, 2.66747832e-01f, 5.58338985e-02f, -2.70273596e-01f, -2.00226735e-02f, -5.33747636e-02f, 3.68740372e-02f, 2.00953279e-02f, -2.17792876e-02f,
  -1.62321374e-01f, -1.88423425e-01f, -6.29700720e-02f, 3.43417004e-02f, 2.41211832e-01f, 2.49754280e-01f, 9.69419926e-02f, 3.33093733e-01f, 2.63066947e-01f, 6.13040105e-02f,
  -1.31841386e-02f, 1.26579255e-01f, 2.39797562e-01f, 2.07928136e-01f, 4.84356247e-02f, 6.50621951e-03f, 1.17373198e-01f, -1.25040552e-02f, 6.96830302e-02f, 1.38470456e-01f,
  4.27062361e-04f, 2.37288803e-01f, -1.04878016e-01f, -1.00759156e-01f, 3.55606265e-02f, 8.55193287e-02f, 6.50320053e-02f, 5.96027598e-02f, -1.47047862e-01f, -9.29649845e-02f,
  -7.31974170e-02f, 1.03632316e-01f, 5.89233823e-02f, -1.67126767e-02f, 8.15681592e-02f, -8.32862873e-03f, 1.42687380e-01f, 1.20695993e-01f, 5.88620156e-02f, -6.88524246e-02f,
  -5.69655336e-02f, -1.26183718e-01f, 3.83903570e-02f, -2.71932818e-02f, 7.44437426e-02f, -4.15171571e-02f, 6.59197196e-03f, 1.41575307e-01f, 4.28693406e-02f, 2.13874012e-01f,
  -5.83894402e-02f, 1.35189295e-01f, 2.01473027e-01f, 7.53329173e-02f, 8.58413726e-02f, -4.95203324e-02f, -7.53681466e-04f, -8.52697268e-02f, 1.14155427e-01f, 2.53463000e-01f,
  2.70111784e-02f, -9.30886716e-02f, 4.51239534e-02f, -1.45771168e-02f, -2.05140576e-01f, 6.88720644e-02f, 8.59528854e-02f, -6.28761277e-02f, -8.44075456e-02f, -9.15778354e-02f,
  1.31920591e-01f, 1.93801504e-02f, 2.25940309e-02f, 1.10524073e-01f, -6.62795305e-02f, -3.97604145e-02f, 2.68520671e-03f, 1.91558630e-03f, -5.68400621e-02f, -5.91083542e-02f,
  -4.22237128e-01f, -3.29279214e-01f, 1.35378940e-02f, 1.21617824e-01f, -4.64370474e-02f, -8.26653615e-02f, 5.33758700e-02f, -2.17887789e-01f, -2.18333364e-01f, -1.73065796e-01f,
  -1.59658387e-01f, 8.51274207e-02f, -1.39939515e-02f, 1.80313945e-01f, -4.30660918e-02f, -7.44377151e-02f, 5.32194972e-04f, 4.09951359e-02f, -1.94701776e-01f, -1.41438559e-01f,
  -7.81215429e-02f, -2.23870063e-03f, -1.49882600e-01f, -3.78633104e-02f, -1.57125533e-01f, -2.26111665e-01f, -4.90558073e-02f, -1.70474406e-02f, -1.23380244e-01f, -8.36288780e-02f,
  -6.01559699e-01f, 3.97319905e-03f, 1.30249903e-01f, -3.18772078e-01f, 1.77170530e-01f, 1.43690810e-01f, 2.29257569e-01f, 1.00924727e-02f, -2.35390440e-01f, 7.91628212e-02f,
  2.13347748e-01f, -1.58149451e-01f, -4.78294492e-02f, 2.33008489e-02f, 4.52514514e-02f, 1.57455608e-01f, 1.58238843e-01f, -6.11827821e-02f, -1.85019702e-01f, 1.50506767e-02f,
  5.32827713e-02f, -1.40212327e-01f, -2.65537620e-01f, -8.43428448e-02f, 1.12399817e-01f, -2.03197822e-02f, 5.42381853e-02f, -5.03764413e-02f, 8.89856666e-02f, 3.55409868e-02f,
  1.49334595e-01f, -5.75861521e-02f, 3.02507095e-02f, -1.89483270e-01f, -2.70973742e-02f, -1.16496809e-01f, 4.03754525e-02f, -5.22819944e-02f, -1.16240894e-02f, -7.52697652e-03f,
  -2.43928924e-01f, -1.60833210e-01f, -1.52977079e-01f, -1.24067478e-01f, -2.41860718e-01f, -8.57702047e-02f, -1.13383085e-01f, 3.26827355e-02f, 4.48897034e-02f, 4.82945591e-02f,
  1.04855821e-01f, 3.87780778e-02f, 1.20050162e-02f, 3.04966886e-02f, 3.01097278e-02f, -1.22173674e-01f, 1.08287342e-01f, 9.31846648e-02f, 1.46033779e-01f, 3.92644741e-02f,
  -8.24179351e-02f, -9.95163172e-02f, -8.39732811e-02f, 1.75867938e-02f, -7.31637031e-02f, -8.37276056e-02f, -6.93738908e-02f, 1.40739447e-02f, 1.05553202e-01f, -3.54927108e-02f,
  -9.24055092e-03f, 3.94954346e-02f, -7.58026391e-02f, -6.48737550e-02f, 3.79986204e-02f, 2.47526094e-02f, 9.12377902e-04f, 3.53470109e-02f, 1.30786514e-02f, 2.27494333e-02f,
  3.37769352e-02f, 1.26154209e-02f, -6.50124028e-02f, -1.84285305e-02f, -4.63136064e-04f, 2.84584463e-02f, -1.06487766e-01f, 3.90032716e-02f, -6.98314421e-03f, -6.61723092e-02f,
  -6.56590462e-02f, 8.55062902e-02f, -1.31307691e-01f, 5.54432869e-02f, -5.71809672e-02f, -3.73762101e-02f, 7.92272165e-02f, -8.45559537e-02f, -2.06754114e-02f, -6.53867498e-02f,
  -1.45266846e-01f, -2.17241153e-01f, 1.12432456e-02f, -9.98933315e-02f, -2.21628994e-01f, -1.77749857e-01f, -6.63839504e-02f, 5.23568913e-02f, 8.61098394e-02f, -1.23170756e-01f,
  -3.93734835e-02f, 7.90296346e-02f, -1.38790533e-01f, 6.54289201e-02f, -2.53978483e-02f, -5.78760356e-02f, 2.74021905e-02f, 1.24726156e-02f, 1.10677920e-01f, -5.20389527e-02f,
  -6.56014681e-01f, 2.09917501e-01f, 1.14111237e-01f, -3.32752675e-01f, 6.96720630e-02f, 1.40355781e-01f, 1.95059553e-01f, 5.18942885e-02f, -1.28847035e-02f, 1.14262022e-01f,
  -1.98911503e-03f, -1.46976545e-01f, -1.00864634e-01f, -9.49278399e-02f, -8.76336694e-02f, 8.77477229e-02f, 2.75787339e-02f, -1.67188793e-01f, -2.18164518e-01f, -2.93307733e-02f,
  -7.32446611e-02f, -2.28814781e-01f, -4.10951644e-01f, -1.93575174e-01f, -9.86114666e-02f, -2.41892397e-01f, -8.58535394e-02f, -1.70378685e-01f, 3.31377685e-02f, -1.65978074e-01f,
  1.33388140e-03f, 1.79133743e-01f, 5.92066683e-02f, -2.11980179e-01f, 8.14532489e-02f, 2.59316317e-03f, 3.33364774e-03f, -6.85360748e-03f, 5.28927557e-02f, -6.07489012e-02f,
  -1.39149604e-02f, -1.06320855e-04f, -1.72845259e-01f, -8.94370601e-02f, -1.22620545e-01f, -1.76643543e-02f, 1.81669798e-02f, -5.92315421e-02f, 7.59659931e-02f, 2.00618312e-01f,
  1.25643864e-01f, 7.89169893e-02f, 5.74518442e-02f, -1.48547757e-02f, 1.32210225e-01f, 6.42063096e-02f, 1.35447726e-01f, -2.48740185e-02f, 8.07037801e-02f, -4.20135707e-02f,
  9.86454040e-02f, 1.36883721e-01f, -5.98427765e-02f, -6.94580227e-02f, -7.16556236e-03f, -9.35866162e-02f, -3.57851796e-02f, -3.47907245e-02f, -6.66790307e-02f, -9.46983099e-02f,
  1.00180879e-01f, 7.58241117e-02f, 6.81239516e-02f, 1.48457205e-02f, -8.54468066e-03f, -6.26792610e-02f, -1.03745654e-01f, -3.08968443e-02f, 1.90091704e-03f, -8.36286470e-02f,
  1.25636645e-02f, 5.06466441e-02f, -4.21321839e-02f, -9.04067084e-02f, -5.43865934e-02f, 8.83832574e-03f, 1.35930881e-01f, 8.83052126e-02f, 8.77674893e-02f, -1.19794142e-02f,
  -3.98015082e-01f, -3.69774885e-02f, -5.03960960e-02f, -1.10709623e-01f, 1.51394326e-02f, 1.23810835e-01f, 3.73990200e-02f, -2.23810412e-02f, 1.71079431e-02f, 1.28048398e-02f,
  1.32977456e-01f, -3.00010629e-02f, -6.82431310e-02f, 7.34349899e-03f, -9.56445336e-02f, -8.13657138e-03f, -3.23810689e-02f, -8.37462842e-02f, 4.90193181e-02f, 1.28968567e-01f,
  1.14772111e-01f, 6.65153144e-03f, -1.24066599e-01f, -8.32801871e-03f, 6.99614137e-02f, -1.16885059e-01f, -4.42377888e-02f, 5.81129380e-02f, -3.31281237e-02f, -1.16303273e-01f,
  -3.44673365e-01f, 8.96999910e-02f, 1.37333065e-01f, -8.78570527e-02f, -4.19770740e-03f, -6.15727715e-02f, 7.12724263e-03f, -2.45751530e-01f, -1.74340457e-02f, 2.35355198e-01f,
  4.22127917e-02f, -1.41919494e-01f, -1.52967498e-01f, -7.17870966e-02f, -3.41805696e-01f, -1.89256538e-02f, -1.84951108e-02f, -1.82436600e-01f, -4.92622972e-01f, -1.58184975e-01f,
  -1.98514074e-01f, -2.67752737e-01f, -4.05389667e-01f, -3.03002801e-02f, 2.12252915e-01f, -7.90510476e-02f, 1.13098174e-01f, -1.11264750e-01f, 1.17984712e-01f, 1.42591298e-01f,
  1.69077024e-01f, 9.85185951e-02f, 4.44529653e-02f, -9.52488706e-02f, 2.22370587e-02f, 6.10677414e-02f, -6.19736165e-02f, 1.29874691e-01f, 9.59783271e-02f, 6.48263544e-02f,
  8.75757784e-02f, 5.60262166e-02f, -4.46837321e-02f, 4.66947556e-02f, -1.61183909e-01f, -4.09981012e-02f, -9.70235169e-02f, -6.50580153e-02f, 7.21492022e-02f, 1.47205904e-01f,
  7.16292486e-02f, -8.54592845e-02f, -2.17655264e-02f, 9.33607854e-03f, 6.16753055e-03f, 7.61279976e-03f, 7.69068003e-02f, -4.15073000e-02f, 1.07337520e-01f, 1.72055498e-01f,
  4.20498215e-02f, 4.06779237e-02f, 8.75134692e-02f, 6.47332519e-02f, -4.55880351e-02f, -1.75689496e-02f, 7.69484136e-03f, 9.26623195e-02f, -1.09259166e-01f, 1.05432691e-02f,
  -8.49151462e-02f, 1.04132034e-02f, 7.83734843e-02f, 1.20511435e-01f, 1.33314237e-01f, -5.45278490e-02f, 9.12960172e-02f, 8.11346173e-02f, 1.53850272e-01f, 1.14273168e-01f,
  -4.83335182e-02f, 1.15202911e-01f, -3.77291255e-02f, 4.43207026e-02f, 1.22500479e-01f, 2.19623134e-01f, 5.43778874e-02f, 8.87801275e-02f, -5.21098189e-02f, 9.47731808e-02f,
  -2.03582197e-01f, -1.47577092e-01f, -5.98568879e-02f, -2.70904452e-02f, -2.96709929e-02f, 1.83851510e-01f, 5.54433167e-02f, 3.96711268e-02f, 9.21877027e-02f, 1.32358377e-03f,
  7.09916353e-02f, 3.16297286e-03f, 1.21402834e-02f, -3.65548879e-02f, -1.00758895e-01f, -8.06671679e-02f, 1.06128313e-01f, -1.27963215e-01f, -9.25121009e-02f, 3.70126925e-02f,
  -3.53827775e-02f, -1.10864930e-01f, -2.83772707e-01f, -7.02010393e-02f, 3.93618196e-02f, -9.19246823e-02f, 1.90897062e-02f, 5.15860096e-02f, -5.85821830e-02f, 1.58782765e-01f,
  8.13376188e-01f, -3.24454218e-01f, 7.54206777e-02f, 4.04239260e-02f, 9.21436679e-03f, 6.65826574e-02f, -7.11652189e-02f, -2.40431484e-02f, 4.83347625e-02f, -1.05141982e-01f,
  -2.86707938e-01f, -1.19753562e-01f, -1.49444640e-01f, -1.57611579e-01f, -7.16242800e-03f, -3.33608836e-02f, -7.44855031e-02f, 2.15122372e-01f, 1.65624961e-01f, -1.24379046e-01f,
  -2.28444174e-01f, -4.34654169e-02f, 1.59513112e-02f, 7.92965107e-03f, -3.51949453e-01f, -1.75066933e-01f, -2.34284669e-01f, -1.68916494e-01f, -3.52163315e-01f, -2.42685422e-01f,
  -2.57313490e-01f, 1.07348114e-01f, 1.90532222e-01f, 7.60387033e-02f, 1.71327502e-01f, 2.85223752e-01f, 1.02563418e-01f, -2.97758356e-03f, 1.16845675e-01f, -2.63121556e-02f,
  1.04758643e-01f, 5.22893481e-02f, 2.85309218e-02f, 3.88915092e-02f, 2.28843056e-02f, 1.11627959e-01f, 3.66505757e-02f, 5.85014746e-03f, -7.98964351e-02f, -1.81204736e-01f,
  -1.62541822e-01f, 1.05986968e-01f, 3.10739521e-02f, 1.05294650e-02f, 6.54212832e-02f, -4.05933745e-02f, 5.64605705e-02f, 1.23950001e-03f, 5.16736582e-02f, 1.15670882e-01f,
  -2.68375754e-01f, -1.08966045e-01f, 1.82229131e-02f, -1.38025776e-01f, 8.37974399e-02f, -3.49063426e-02f, 8.45183656e-02f, -3.90436649e-02f, -1.07877795e-02f, -4.57328279e-03f,
  -5.08128181e-02f, -1.97545439e-02f, -1.09044477e-01f, -8.71290453e-03f, 1.02599494e-01f, -2.87567433e-02f, -2.56256759e-03f, 1.95994265e-02f, -1.51527375e-01f, -1.07615858e-01f,
  1.06674265e-02f, -1.43051609e-01f, -3.81404720e-02f, -1.06150270e-01f, -1.24270283e-01f, -3.18467841e-02f, -9.15344357e-02f, -2.07256600e-02f, 1.69324912e-02f, -6.58689290e-02f,
  -2.82166213e-01f, 1.99942607e-02f, 7.49593414e-03f, -2.24745125e-02f, 2.73450930e-02f, 9.71445292e-02f, -9.62670427e-03f, -1.57526791e-01f, -1.03274323e-02f, -4.76843975e-02f,
  -9.42574590e-02f, 2.22603930e-03f, -1.30363017e-01f, -9.30316299e-02f, 9.81297642e-02f, 1.26125768e-01f, 1.65238738e-01f, 2.11324897e-02f, -6.83898702e-02f, -1.56735078e-01f,
  -7.03080744e-02f, 1.37466505e-01f, 1.97003052e-01f, 1.79889336e-01f, 4.24207076e-02f, 1.31259397e-01f, 1.12994365e-01f, 1.16923608e-01f, 1.47604328e-02f, 1.96980506e-01f,
  -7.14672059e-02f, 1.97033957e-01f, -6.12216368e-02f, 7.11234063e-02f, 1.79799765e-01f, 6.90042973e-02f, -8.04527327e-02f, -1.10536434e-01f, 6.38092086e-02f, 1.97317123e-01f,
  1.16172351e-01f, -6.65554404e-02f, -4.03316841e-02f, -2.13584438e-01f, -4.35691059e-01f, -1.17585972e-01f, -2.08765447e-01f, -2.93449581e-01f, -2.07290888e-01f, -1.04558222e-01f,
  2.13264045e-03f, -1.67709917e-01f, -1.07935064e-01f, -1.56825826e-01f, 3.34811769e-02f, -8.93515423e-02f, -9.93806496e-02f, -6.43864181e-03f, -6.46080375e-02f, -3.59384716e-02f,
  8.08737651e-02f, 2.23587811e-01f, 2.46173441e-02f, -5.77944815e-02f, -1.47448834e-02f, 1.17223859e-01f, 4.85843793e-02f, 8.47848207e-02f, 4.72810604e-02f, 4.82154340e-02f,
  5.25226370e-02f, 2.12705150e-01f, -5.09199612e-02f, -3.09179649e-02f, -3.92981842e-02f, -2.11277846e-02f, -2.54728999e-02f, 1.63294543e-02f, -7.07725808e-02f, 7.81411305e-02f,
  -9.30820629e-02f, 1.56919822e-01f, 1.10393083e-02f, 2.73891557e-02f, -2.19382010e-02f, 4.22004573e-02f, 9.02378410e-02f, 2.25116033e-02f, -7.67069981e-02f, -6.49224669e-02f,
  -8.29608273e-03f, 5.79106770e-02f, 1.32727161e-01f, 1.41037613e-01f, 3.67927104e-02f, 1.37535423e-01f, -1.98771320e-02f, -1.16705127e-01f, -7.04569891e-02f, 6.96664229e-02f,
  -2.41331309e-02f, 1.16594555e-02f, 4.52421457e-02f, -2.88667679e-02f, -1.11008056e-01f, -4.54091392e-02f, -2.67221648e-02f, -1.47278368e-01f, -8.29815418e-02f, -2.98194606e-02f,
  -9.64293107e-02f, 1.32536851e-02f, -9.74746794e-03f, 1.63592715e-02f, -8.18623453e-02f, 1.52406720e-02f, -8.34527984e-02f, -2.47677881e-03f, -1.71707701e-02f, -2.68659256e-02f,
  -1.81190327e-01f, 3.59991342e-02f, 1.39732063e-02f, -4.47802022e-02f, 1.30902246e-01f, 2.45242845e-02f, 8.95269588e-03f, -7.28875250e-02f, -2.61008237e-02f, 6.64142985e-03f,
  -6.67639300e-02f, -1.01515809e-02f, 3.58221866e-02f, -9.05978158e-02f, 2.72218715e-02f, 1.33998552e-02f, -1.01815779e-02f, -6.45646825e-02f, -4.61431630e-02f, 1.78951532e-01f,
  -5.92074022e-02f, -2.07934305e-01f, 4.51850072e-02f, -1.14454009e-01f, 7.55811750e-04f, -1.50543749e-02f, -1.90413266e-01f, -7.90920928e-02f, -1.41587675e-01f, -2.26253465e-01f,
  -5.51716328e-01f, -1.61557138e-01f, -3.51664811e-01f, -2.24932149e-01f, 1.31363571e-01f, 1.40205011e-01f, 1.18990213e-01f, -7.53042996e-02f, -9.91608277e-02f, -5.13098389e-02f,
  1.27314717e-01f, 2.05253437e-01f, 4.70931716e-02f, 1.08756021e-01f, 6.52787695e-03f, 9.51500889e-03f, 1.28993066e-02f, 1.77928898e-02f, 9.77355465e-02f, 3.29788238e-01f,
  2.24234313e-01f, -3.18561569e-02f, -5.37285693e-02f, 6.78735673e-02f, -7.33909830e-02f, -1.34292305e-01f, -2.16431111e-01f, -9.16154012e-02f, 1.24885917e-01f, -2.21123815e-01f,
  -1.63730770e-01f, -1.88059688e-01f, 2.04080284e-01f, 5.47091961e-02f, 9.96045917e-02f, 1.07914060e-01f, 2.24532038e-01f, 1.67435817e-02f, 6.09471276e-02f, 1.93548407e-02f,
  1.03947327e-01f, 4.75586392e-02f, 8.02744925e-02f, 2.23003933e-03f, 6.01229817e-02f, 1.90555118e-02f, -3.52372676e-02f, -1.16682887e-01f, -1.31382987e-01f, -1.70346536e-02f,
  1.35897100e-01f, 2.25032181e-01f, 4.74668480e-03f, -8.43667910e-02f, -5.43076843e-02f, 1.13348410e-01f, -3.97702754e-02f, -1.48156062e-01f, -1.62048787e-01f, -2.98642844e-01f,
  3.14964429e-02f, -2.64619365e-02f, -7.96446800e-02f, -1.03624634e-01f, -7.79634565e-02f, 3.87084000e-02f, -9.75465216e-03f, -1.10406794e-01f, -4.36568595e-02f, -1.18851200e-01f,
  3.75944450e-02f, 9.47974995e-02f, -2.50130612e-02f, -1.67635791e-02f, 7.44820163e-02f, -7.84445032e-02f, 7.08803758e-02f, -1.34009168e-01f, -1.29750501e-02f, -1.13751352e-01f,
  3.80504951e-02f, -3.29748876e-02f, -4.25148979e-02f, 6.15352765e-02f, 1.62447244e-02f, 3.23454291e-02f, 2.90660951e-02f, 1.10021889e-01f, 3.60526778e-02f, 4.45322134e-02f,
  -3.41297299e-01f, 1.92503020e-01f, -3.11615448e-02f, 6.43541990e-03f, -9.19343308e-02f, -3.35098132e-02f, -1.60929799e-01f, 3.14943157e-02f, -4.98611517e-02f, 7.77422562e-02f,
  5.53520992e-02f, -1.63372308e-01f, -6.36067614e-02f, -1.28587991e-01f, 1.03791997e-01f, -4.14070524e-02f, -1.77599311e-01f, -7.49261007e-02f, -4.64783832e-02f, -8.89569074e-02f,
  -2.12573573e-01f, -1.18258908e-01f, -2.03222021e-01f, -2.93450087e-01f, -1.67973444e-03f, 9.83390734e-02f, -6.53236434e-02f, -1.01419501e-01f, -1.77438796e-01f, -3.11679035e-01f,
  -8.41070712e-01f, -8.05553123e-02f, -1.84801854e-02f, -4.28546309e-01f, -1.00049585e-01f, 5.37072755e-02f, 1.79798767e-01f, -1.18317597e-01f, -2.24759325e-01f, 9.14556086e-02f,
  5.09638824e-02f, -1.88153625e-01f, -7.50459656e-02f, -3.55616584e-03f, 7.78921274e-03f, 1.60841316e-01f, 2.52884664e-02f, -2.10731253e-01f, -1.15186386e-01f, 2.25365199e-02f,
  -1.04496712e-02f, -2.99240083e-01f, -4.36199814e-01f, -2.70445645e-01f, -9.98906940e-02f, -1.63498130e-02f, -4.20436040e-02f, -1.61948651e-01f, -6.44430518e-02f, -8.81709978e-02f,
  4.57273871e-01f, -4.78760079e-02f, 1.05276629e-01f, -1.16833009e-01f, 1.27590150e-01f, -8.44569057e-02f, 2.37238109e-02f, -7.79833570e-02f, 1.77096892e-02f, 7.38658011e-02f,
  5.05759120e-02f, 1.11299409e-02f, -1.41377613e-01f, 2.89781336e-02f, 5.62138073e-02f, 1.32614180e-01f, 1.82946548e-02f, 1.00507000e-02f, 1.02612495e-01f, 1.77253515e-01f,
  1.31637743e-02f, -2.68191192e-02f, 6.99012429e-02f, 3.53359953e-02f, -4.18788753e-02f, 2.38394383e-02f, 1.86393663e-01f, 3.36188488e-02f, 7.18609691e-02f, 1.38033986e-01f,
  -1.53810471e-01f, -5.99694774e-02f, 4.95039523e-02f, -6.55600429e-02f, 2.45175306e-02f, 5.12339058e-04f, 3.38478424e-02f, -2.07890626e-02f, 2.19698343e-02f, -8.73213857e-02f,
  3.73971537e-02f, 9.96086970e-02f, -9.43681076e-02f, 6.92518577e-02f, -7.67249539e-02f, -2.07691804e-01f, -1.05872966e-01f, 5.30774258e-02f, 1.19842708e-01f, -5.15803508e-02f,
  -2.88270395e-02f, -4.70010228e-02f, -7.05851475e-03f, -3.58402357e-02f, 1.57689787e-02f, -1.12633258e-01f, -1.02365814e-01f, -8.33328292e-02f, -1.68340251e-01f, -1.81331351e-01f,
  3.01718503e-01f, -1.11493021e-01f, -5.19179553e-02f, -3.91268805e-02f, 3.72468233e-02f, 1.44039104e-02f, -8.13668519e-02f, 6.41706437e-02f, 3.92355770e-02f, 1.43468589e-01f,
  2.30830424e-02f, -8.27097297e-02f, -5.87958507e-02f, 1.33722320e-01f, 7.34041184e-02f, 1.26074255e-01f, 1.83704272e-01f, 2.01747604e-02f, 8.35033879e-02f, 1.29450366e-01f,
  -5.66194765e-02f, 5.31031936e-02f, 1.07973441e-02f, 4.32216525e-02f, 6.15655584e-03f, 1.84850837e-03f, 9.70769599e-02f, 1.22491837e-01f, 1.40790284e-01f, 1.89210385e-01f,
  1.26871243e-01f, -3.13907117e-01f, 3.32226425e-01f, -1.50805175e-01f, -4.66944695e-01f, -3.18164766e-01f, -5.88382065e-01f, -2.97106564e-01f, -1.52893648e-01f, -2.71483719e-01f,
  -1.50344670e-01f, 1.47536591e-01f, 5.55050597e-02f, 1.39707252e-01f, 1.70679837e-01f, -1.11274108e-01f, 1.01684779e-01f, 4.96238172e-01f, 3.53394836e-01f, -1.23282969e-01f,
  -1.07918762e-01f, 1.82085261e-01f, 2.87984818e-01f, 2.74632901e-01f, -2.67785601e-02f, 4.89660800e-02f, 3.48104443e-03f, 2.72780079e-02f, -1.80536017e-01f, 1.62132233e-01f,
  -2.19150377e-03f, 2.05343217e-03f, 1.25965863e-01f, 1.59697860e-01f, 9.78394970e-02f, 4.66564633e-02f, 4.24453057e-02f, 1.18849456e-01f, 8.45892727e-03f, 9.48988795e-02f,
  7.42888972e-02f, 7.60552287e-02f, -6.46939650e-02f, -2.68409252e-02f, -9.44769382e-02f, -6.46306351e-02f, 6.74509928e-02f, 1.67903483e-01f, 1.31863892e-01f, 5.49487676e-03f,
  -1.60951510e-01f, -7.15848356e-02f, -1.55930534e-01f, -9.21323374e-02f, -1.43055215e-01f, 2.07637344e-02f, -8.80969912e-02f, 1.09303758e-01f, -1.29173771e-02f, -6.62384778e-02f,
  -4.66324985e-02f, 3.26461270e-02f, 8.00239295e-02f, -2.11234570e-01f, -1.02250218e-01f, -6.72999546e-02f, -5.78930788e-02f, -6.30799606e-02f, 5.37204742e-02f, -3.71794738e-02f,
  -1.11342281e-01f, 4.00099047e-02f, 5.75847477e-02f, -4.24128175e-02f, 1.59013852e-01f, 4.84760702e-02f, 3.33065651e-02f, -3.72259729e-02f, 1.13559021e-02f, 4.31749113e-02f,
  1.82782523e-02f, 8.12046900e-02f, 4.50163260e-02f, 2.74565443e-02f, -6.45128340e-02f, 2.84656249e-02f, 7.39832297e-02f, -3.77537422e-02f, -2.42819283e-02f, 1.00616952e-02f,
  -2.20363081e-01f, 1.91650465e-01f, -2.14981604e-02f, 9.06855986e-02f, 9.61051285e-02f, 4.21215333e-02f, 5.72509617e-02f, 2.90485797e-03f, 1.84369683e-02f, 4.10937518e-02f,
  -1.57223314e-01f, -5.60378842e-02f, -5.21626733e-02f, 1.40363872e-01f, -8.29307362e-03f, -7.13305101e-02f, 6.85039610e-02f, -5.67086488e-02f, 8.20477828e-02f, 1.01012714e-01f,
  -1.04506955e-01f, -1.65024832e-01f, -2.21253604e-01f, -1.78823397e-01f, -1.49248555e-01f, -5.06512970e-02f, -7.58426264e-02f, -1.29564315e-01f, -1.03432119e-01f, -2.38550380e-01f,
  2.77133495e-01f, -1.90144092e-01f, -3.34589660e-01f, -9.49680526e-03f, -2.77380913e-01f, 4.54266928e-02f, -2.34743640e-01f, 5.69754504e-02f, 1.49287358e-01f, -2.18565196e-01f,
  -1.73680574e-01f, 1.22466259e-01f, 1.03141824e-02f, -3.76889557e-02f, 2.01241001e-01f, -3.09818059e-01f, -1.90543339e-01f, 2.79057119e-02f, 3.17636341e-01f, 1.65358186e-01f,
  -4.17073295e-02f, 8.23566541e-02f, 1.70075089e-01f, 2.39562485e-02f, -2.01234534e-01f, -2.26730891e-02f, -3.57187361e-01f, -1.23032026e-01f, -8.88378024e-02f, -2.76495725e-01f,
  -1.69055045e-01f, 5.19797429e-02f, -7.05963513e-03f, 6.63977563e-02f, -2.51855582e-01f, 8.70377868e-02f, -3.95170487e-02f, -9.15783569e-02f, -4.36769761e-02f, -1.29217599e-02f,
  -2.02825397e-01f, 1.06509306e-01f, 4.43084165e-02f, -4.67395559e-02f, 6.54320270e-02f, 1.17202342e-01f, 7.38555491e-02f, 7.45470896e-02f, 4.72646132e-02f, 7.85090923e-02f,
  -5.82308061e-02f, -5.20234928e-02f, -8.30202177e-02f, -1.24141304e-02f, -1.13922156e-01f, 2.61891335e-02f, -1.68262199e-01f, 1.26305968e-01f, -9.79686603e-02f, -1.41729623e-01f,
  -1.17550112e-01f, -1.37910783e-01f, -2.12565009e-02f, 5.33138514e-02f, 7.35877454e-02f, -7.36364722e-02f, 5.92125542e-02f, 1.39146522e-01f, -4.94059920e-03f, 3.47801298e-02f,
  5.28976368e-03f, 6.02413192e-02f, -7.06315860e-02f, 2.82413848e-02f, -1.43116459e-01f, -8.98416936e-02f, -1.88214090e-02f, 1.73300691e-02f, -7.33378753e-02f, 4.26326767e-02f,
  1.52893243e-02f, 1.10246250e-02f, -1.64514378e-01f, 1.72369648e-02f, -1.37645230e-02f, -1.80548467e-02f, 3.15476619e-02f, -8.09211936e-03f, -5.88940196e-02f, -1.32116554e-02f,
  2.84447968e-02f, -6.13657236e-02f, -1.39051542e-01f, 1.24099202e-01f, -1.12910934e-01f, -1.21173680e-01f, -1.21579111e-01f, -5.58848567e-02f, 1.02370769e-01f, 2.17015826e-04f,
  3.04807480e-02f, -4.62430753e-02f, -5.14122546e-02f, -2.42735781e-02f, -8.13010931e-02f, -1.00221392e-02f, -1.36076203e-02f, 4.35699373e-02f, 2.72966698e-02f, 1.43584296e-01f,
  -6.18703328e-02f, -1.80811826e-02f, 1.90912634e-01f, -3.35048027e-02f, 4.90075946e-02f, -5.71221486e-03f, -4.70418595e-02f, -6.63554966e-02f, -1.15182832e-01f, -2.80589700e-01f,
  -6.53225303e-01f, 1.02071874e-01f, -2.79431492e-01f, -2.47000381e-01f, 1.68574318e-01f, -5.59045598e-02f, 1.29222408e-01f, -4.16929089e-02f, -9.47421324e-03f, 8.83075446e-02f,
  4.94726487e-02f, 1.61268443e-01f, 1.59314916e-01f, 2.03923553e-01f, 1.06893107e-01f, 1.69457570e-01f, 1.58147961e-01f, -4.39723916e-02f, -1.68096069e-02f, 2.45244149e-02f,
  2.47804418e-01f, 4.40940931e-02f, -1.38222724e-01f, -1.34058632e-02f, 1.10146292e-01f, 1.59071088e-01f, 9.01168510e-02f, 1.09948590e-02f, 1.55368462e-01f, -6.89877896e-03f,
  2.91607752e-02f, -3.03858161e-01f, -1.68132067e-01f, -8.11455250e-02f, -7.11850598e-02f, -8.68534371e-02f, 1.61233172e-02f, -2.35235557e-01f, -8.22083205e-02f, -8.60045701e-02f,
  -6.21006563e-02f, -1.47956669e-01f, -8.05793926e-02f, 1.01179606e-03f, -7.31101856e-02f, 8.34016502e-02f, -2.94575337e-02f, -8.56201574e-02f, -1.87177330e-01f, 4.49236892e-02f,
  1.97880685e-01f, -3.88921201e-02f, -1.24026328e-01f, 1.06541537e-01f, -3.86807993e-02f, -8.42092410e-02f, -5.74698150e-02f, -1.58234522e-01f, -1.15173787e-01f, -2.03424901e-01f,
  5.60944676e-02f, -4.85923588e-02f, 4.47807275e-02f, -3.76378559e-02f, 1.21204466e-01f, 1.83444954e-02f, 1.87059194e-02f, 4.13729623e-02f, 1.11483939e-01f, 2.01939624e-02f,
  -9.22109857e-02f, -3.65691781e-02f, -9.06262994e-02f, -5.00259250e-02f, 7.92504549e-02f, 1.64046362e-02f, -2.62651257e-02f, 5.15919998e-02f, -7.41289556e-02f, -1.02299206e-01f,
  -8.36570188e-02f, -1.64998308e-01f, -6.54278137e-03f, -7.12449327e-02f, 1.51455132e-02f, -8.02701991e-03f, -6.71391338e-02f, 9.58477519e-03f, 7.16324523e-02f, -6.18132576e-02f,
  3.34339589e-01f, -4.06916924e-02f, 5.79812862e-02f, -3.81515920e-03f, -1.28949881e-01f, -1.13189891e-01f, 8.31073243e-03f, -1.57209754e-01f, -2.16898695e-03f, 4.99995127e-02f,
  -9.10026580e-02f, -6.46883994e-02f, 1.19385943e-01f, -4.50085886e-02f, -2.12042988e-03f, 5.34210838e-02f, -1.03750518e-02f, 8.05715546e-02f, 2.09195055e-02f, -3.46133709e-02f,
  1.71607405e-01f, -1.31241502e-02f, -8.36167578e-03f, 1.37785405e-01f, 8.79092291e-02f, 9.23218131e-02f, 1.16469108e-01f, 2.09367722e-02f, -2.98200641e-02f, 1.32552892e-01f,
  -2.85900712e-01f, -4.44330692e-01f, -1.29065424e-01f, -2.90156472e-02f, -3.60296667e-02f, -9.91601199e-02f, -3.07170928e-01f, -1.25468612e-01f, 1.02909341e-01f, -3.64242345e-01f,
  -3.00959926e-02f, 2.23688155e-01f, -5.33644781e-02f, -2.92817620e-03f, -2.70713679e-02f, -2.32254326e-01f, -1.51766077e-01f, 1.51098162e-01f, 3.10942531e-01f, 1.75062329e-01f,
  4.83554304e-02f, 4.58000675e-02f, 1.47696197e-01f, 2.87496429e-02f, 4.14877199e-02f, 9.50972885e-02f, -1.00066297e-01f, 3.18072401e-02f, -2.23993417e-02f, 6.68217009e-03f,
  -6.54034019e-02f, -9.81893465e-02f, 4.87160385e-02f, 1.72586367e-02f, -1.22689210e-01f, -1.73838481e-01f, -2.14121267e-01f, 6.96932375e-02f, 1.62203573e-02f, -7.64031932e-02f,
  -1.69266224e-01f, -1.40544295e-01f, 7.43186623e-02f, 6.63548987e-03f, -9.74194407e-02f, -5.44050410e-02f, -2.30435748e-03f, 6.88610151e-02f, -8.79133716e-02f, -2.48256728e-01f,
  -3.00650746e-02f, 6.86724335e-02f, 1.25791743e-01f, 4.33553495e-02f, -5.61249889e-02f, 1.46641299e-01f, 5.26700262e-03f, 1.88520998e-01f, 3.03063449e-02f, -4.10089903e-02f,
  3.47770192e-03f, 7.61282295e-02f, -1.22269981e-01f, -1.47660300e-01f, 5.23276906e-03f, 7.35152364e-02f, 8.97653997e-02f, 7.12274686e-02f, 9.58162248e-02f, -7.22232237e-02f,
  -8.16737339e-02f, -2.10359809e-03f, 1.29413791e-02f, 1.17041335e-01f, 8.69856179e-02f, -5.75383008e-03f, 5.07860407e-02f, 3.02396547e-02f, 1.40289634e-01f, -3.50156166e-02f,
  2.29152311e-02f, 5.15915714e-02f, -1.67329967e-01f, 7.90266842e-02f, -3.39735821e-02f, 3.03289834e-02f, -7.28916600e-02f, 2.62419526e-02f, 5.51560186e-02f, -8.09511691e-02f,
  1.60847325e-02f, 1.03536233e-01f, -2.40988836e-01f, -5.52028231e-02f, -1.74244002e-01f, -2.99851783e-02f, -1.01539373e-01f, 3.71963754e-02f, -1.47994114e-02f, -1.18327715e-01f,
  -8.51075947e-02f, -1.87228665e-01f, -2.21114501e-01f, 3.74914333e-02f, -5.27240969e-02f, -1.13159269e-01f, -2.47298881e-01f, -1.05088629e-01f, 1.51148871e-01f, -5.76385744e-02f,
  -3.33674923e-02f, -2.21296802e-01f, -8.18065032e-02f, -2.67096341e-01f, -1.06817052e-01f, -8.23498443e-02f, -3.55976559e-02f, 1.43441325e-02f, -1.41212896e-01f, -4.09310311e-01f,
  -4.44372654e-01f, 1.04910731e-01f, 6.75731292e-03f, -6.20427169e-02f, 1.07132301e-01f, 1.14791937e-01f, 1.72264859e-01f, -4.72088270e-02f, -6.02042712e-02f, -6.75262287e-02f,
  1.99226867e-02f, -1.19281821e-01f, 1.24123350e-01f, 1.16428591e-01f, 9.77585539e-02f, 2.21438795e-01f, 3.18465322e-01f, 9.33313444e-02f, -1.36904404e-01f, -1.20599836e-01f,
  1.32132709e-01f, -1.31419733e-01f, -4.13733929e-01f, -1.72353193e-01f, 1.77466720e-01f, -5.08627184e-02f, 1.37655735e-01f, 6.67780265e-02f, 1.90747619e-01f, 4.30424750e-01f,
  5.00734635e-02f, 5.72014973e-02f, 1.27466470e-01f, -9.37198848e-02f, -3.14718746e-02f, -3.12761590e-02f, 5.31943776e-02f, -2.50155721e-02f, -6.70346431e-03f, 3.92668210e-02f,
  1.36907518e-01f, 1.42811537e-01f, 1.62199199e-01f, 2.15398282e-01f, -1.30496934e-01f, -4.34456430e-02f, 1.14702389e-01f, -1.19914122e-01f, -1.36290178e-01f, -2.03715950e-01f,
  2.83501029e-01f, -3.69912237e-02f, -1.62400976e-01f, -2.18049176e-02f, 1.58222746e-02f, -1.65484443e-01f, -1.56107381e-01f, -2.05982864e-01f, -2.32589751e-01f, -1.63912639e-01f,
  1.30520286e-02f, 6.54870784e-03f, 5.31731248e-02f, 6.23944774e-02f, 1.50447980e-01f, 1.35826454e-01f, 1.55418515e-01f, 7.92963579e-02f, 1.96818486e-01f, 3.16487327e-02f,
  -2.73550730e-02f, -1.67615712e-01f, -5.65222241e-02f, -7.22967759e-02f, -1.68945670e-01f, 4.45572995e-02f, 5.82345873e-02f, -1.15019314e-01f, -1.51133448e-01f, -1.05237700e-01f,
  1.26395866e-01f, 1.57545805e-02f, -1.18388280e-01f, 9.12181884e-02f, 1.28931120e-01f, 3.09203900e-02f, 7.68150166e-02f, -1.12083675e-02f, -5.92670068e-02f, -4.32537869e-02f,
  -3.33811522e-01f, 1.93303496e-01f, 1.53927729e-01f, 1.47450656e-01f, -1.74199033e-03f, -9.09663960e-02f, -3.12651172e-02f, 4.50674184e-02f, 1.00142926e-01f, 1.71128642e-02f,
  -5.34044690e-02f, 3.03650014e-02f, -2.98086298e-03f, 6.87496662e-02f, -1.55623123e-01f, -1.82561595e-02f, -1.33415656e-02f, -8.71215947e-03f, -7.70902261e-02f, -1.22901186e-01f,
  -8.57650638e-02f, -2.43761763e-01f, -1.73463792e-01f, 6.18894733e-02f, -2.06003055e-01f, -1.80381507e-01f, -1.55965075e-01f, -1.75699174e-01f, -1.00698002e-01f, -3.79059047e-01f,
  -1.62539408e-01f, 3.61101449e-01f, 4.12986204e-02f, -9.94316116e-02f, 1.78975120e-01f, 2.35256061e-01f, 3.89295757e-01f, 1.49560794e-01f, -6.77414462e-02f, 3.93771008e-02f,
  1.07919332e-02f, -2.62323916e-01f, -1.22663759e-01f, -1.05659701e-01f, 1.00538172e-01f, 1.23798862e-01f, -5.61075993e-02f, -1.32226497e-01f, -1.89186603e-01f, 1.71470940e-02f,
  -1.15957551e-01f, 5.22915274e-02f, -2.17037812e-01f, -1.20834097e-01f, 5.43224625e-02f, -2.20272541e-01f, 2.07802784e-02f, 1.64481118e-01f, 1.20049864e-01f, -1.99182451e-01f,
  -8.11431929e-02f, 4.88450199e-01f, -3.99734497e-01f, -2.53452778e-01f, -1.44895971e-01f, -1.43010870e-01f, -7.91086853e-02f, -3.27253863e-02f, 2.18204241e-02f, 8.89942944e-02f,
  6.28284812e-02f, -3.28769274e-02f, -7.08999578e-03f, 3.73822078e-02f, 1.01145901e-01f, 7.37005323e-02f, 2.74211764e-02f, 5.22822067e-02f, -2.08636504e-02f, -6.45428300e-02f,
  3.66312568e-03f, 1.42407611e-01f, 2.51896232e-01f, 1.39092594e-01f, 8.20111781e-02f, -9.57543179e-02f, -3.41396639e-03f, -4.74480689e-02f, 3.96241657e-02f, -9.26560983e-02f,
  -1.47232246e-02f, 1.11654513e-01f, -7.75259212e-02f, 3.31646129e-02f, -5.55105209e-02f, -1.53486550e-01f, -1.22328671e-02f, 9.92650632e-03f, -7.24062696e-03f, 9.73934829e-02f,
  -8.35658014e-02f, 1.17190652e-01f, 1.90546945e-01f, 1.07592501e-01f, -1.07893534e-02f, 5.57165630e-02f, 1.25412822e-01f, -1.53108814e-03f, 4.55637500e-02f, -8.39461461e-02f,
  4.52978648e-02f, 5.28721102e-02f, -1.31061561e-02f, -3.42511646e-02f, 8.75538811e-02f, 3.57863232e-02f, -2.97750998e-02f, 9.87969115e-02f, -8.69397633e-03f, 1.45702645e-01f,
  -8.38913545e-02f, 1.87938705e-01f, -2.40097597e-01f, -1.30841121e-01f, 8.90818089e-02f, 5.87285031e-03f, -8.18203464e-02f, 3.78895104e-02f, 5.00816144e-02f, 7.01769739e-02f,
  8.30498934e-02f, 3.58063285e-03f, 9.61722061e-02f, 1.49779350e-01f, -4.02368940e-02f, 4.43010069e-02f, 3.79574560e-02f, -1.02097504e-01f, -9.93155688e-02f, 3.37883644e-02f,
  -5.76371746e-03f, -4.03478295e-02f, -1.51852518e-02f, -1.69120029e-01f, -6.16139919e-02f, -8.01089406e-02f, -1.04684941e-02f, 1.88155193e-02f, 1.47858995e-03f, -4.29374017e-02f,
  2.39535674e-01f, -1.63798988e-01f, 3.00155938e-01f, 2.99977005e-01f, 1.48315057e-01f, 2.56386369e-01f, 1.40616477e-01f, 1.26941398e-01f, 2.81159878e-01f, 2.21900955e-01f,
  1.89621016e-01f, 8.14802721e-02f, 1.73545346e-01f, 7.81885833e-02f, 9.18232650e-02f, 7.50633851e-02f, 2.66783714e-01f, 2.46265456e-01f, 2.50380099e-01f, 1.56961918e-01f,
  1.03295907e-01f, -4.37238142e-02f, 5.08451238e-02f, 1.01019956e-01f, 1.32308621e-02f, 2.38965616e-01f, 4.26742285e-02f, -1.27117917e-01f, -7.04945028e-02f, 1.57712147e-01f,
  1.87731326e-01f, -1.04081780e-01f, 2.24091858e-01f, -8.75119865e-02f, -2.23154217e-01f, 3.04707885e-02f, 8.30891132e-02f, -3.36788408e-02f, -1.60754248e-01f, -4.93813641e-02f,
  -1.19985804e-01f, -1.57779545e-01f, -1.32705465e-01f, -1.50565341e-01f, -2.08745852e-01f, -2.43979953e-02f, -1.69584066e-01f, 5.30751161e-02f, 2.02787966e-01f, 2.99836248e-02f,
  5.99506907e-02f, -9.29396972e-02f, -4.23658863e-02f, -2.65380344e-03f, -1.02541074e-01f, -8.45689550e-02f, -5.06777987e-02f, -1.42219573e-01f, 9.92092639e-02f, -9.39017311e-02f,
  2.78850347e-01f, 2.56897248e-02f, 1.17531756e-03f, -6.68138266e-02f, -2.41939366e-01f, -1.69517800e-01f, -4.58885171e-02f, 3.64208668e-02f, -6.78238794e-02f, -1.91705823e-01f,
  -2.20680416e-01f, 1.35968849e-01f, 6.91823661e-02f, 1.38040915e-01f, 1.64378703e-01f, 6.87999129e-02f, -3.32115516e-02f, 3.32670584e-02f, -1.11633159e-01f, -1.08151421e-01f,
  -1.17669068e-01f, 2.36705337e-02f, -7.48499781e-02f, 2.86050849e-02f, -3.50147672e-02f, 4.19786721e-02f, -2.81487778e-02f, 1.77071076e-02f, -7.14997351e-02f, -9.09190476e-02f,
  1.11271329e-01f, 1.34116352e-01f, 1.33489802e-01f, 7.54838660e-02f, -8.57353434e-02f, -1.15580447e-01f, 1.08525358e-01f, 2.92854160e-02f, -1.12363108e-01f, 9.07045901e-02f,
  9.57381949e-02f, 1.55370772e-01f, -1.02344841e-01f, -3.66770998e-02f, -1.56194419e-01f, -2.29214760e-03f, -1.10939801e-01f, 1.58201680e-01f, 1.13465704e-01f, 1.22675538e-01f,
  -6.33564815e-02f, 1.25009626e-01f, 1.11935221e-01f, 1.92836791e-01f, 9.73060131e-02f, 1.47149324e-01f, 1.36040300e-02f, 6.96596429e-02f, 1.50022954e-02f, -6.26790673e-02f,
  2.12128371e-01f, -1.68469697e-01f, -8.36712867e-02f, 1.14087276e-01f, -3.03544998e-01f, -2.40978658e-01f, -5.28759003e-01f, -2.59853989e-01f, 9.65690464e-02f, -1.52376890e-01f,
  -6.31958097e-02f, 2.69050479e-01f, 8.76678675e-02f, 4.34542038e-02f, -5.59343621e-02f, -2.45288670e-01f, -2.06131563e-01f, 2.46561877e-03f, 3.15631963e-02f, -9.46337506e-02f,
  -4.30935360e-02f, 7.06630647e-02f, 8.21591169e-02f, 4.23979276e-04f, 1.21976875e-01f, 1.54539943e-01f, -9.00447667e-02f, -1.17329252e-03f, -1.35153194e-03f, 1.39001846e-01f,
  -6.18169829e-02f, -6.84246868e-02f, 1.09776825e-01f, 3.63495164e-02f, 6.23293519e-02f, -2.86184885e-02f, -3.05058267e-02f, 6.27274886e-02f, -5.22098206e-02f, -1.96755335e-01f,
  6.85151517e-02f, 1.75114209e-03f, -7.04702362e-02f, -1.03098750e-01f, -1.18651353e-01f, 8.55487771e-03f, -2.09724512e-02f, -5.53092100e-02f, -3.21151465e-02f, -1.65638402e-01f,
  2.78724711e-02f, 5.65626018e-04f, -1.87788010e-01f, -1.64890915e-01f, -5.65400720e-02f, 8.28346983e-02f, -4.85122502e-02f, 9.73583534e-02f, 4.75431979e-02f, -1.38415480e-02f,
  -9.51341987e-02f, 5.07064685e-02f, 5.09851165e-02f, -8.65036845e-02f, -1.85047835e-02f, -1.06429070e-01f, -1.41368657e-01f, -5.62498793e-02f, 4.71523330e-02f, 2.99885799e-03f,
  -7.82622248e-02f, 1.80543419e-02f, -1.04847699e-02f, -1.97220519e-02f, 1.42169401e-01f, 7.58085176e-02f, 1.31488964e-01f, 3.83365341e-02f, 1.48383286e-02f, -4.94245291e-02f,
  6.64058253e-02f, 2.22637802e-02f, -5.77092804e-02f, -9.70369205e-02f, -1.38817668e-01f, 4.76586223e-02f, 1.02323696e-01f, 1.44949406e-01f, 3.76001075e-02f, 3.79378162e-02f,
  -6.42795721e-03f, -6.08312264e-02f, 4.84822085e-04f, 1.28364488e-01f, 1.09131694e-01f, 4.24873717e-02f, 1.27150163e-01f, 1.80748794e-02f, 5.68447337e-02f, -2.10893229e-02f,
  8.16028118e-02f, 1.68190747e-01f, -8.45188498e-02f, -1.10205784e-02f, -8.53147954e-02f, -2.80259512e-02f, 9.05167088e-02f, 5.18134758e-02f, -1.22939803e-01f, 8.43861029e-02f,
  -8.51876289e-02f, -1.15160324e-01f, 1.76453386e-02f, -1.88224062e-01f, -3.50156426e-02f, 7.77879059e-02f, -1.15700826e-01f, -3.29786837e-02f, -5.81930839e-02f, -1.41941831e-01f,
  -4.84683476e-02f, -2.28293911e-01f, -4.20845389e-01f, -1.14153057e-01f, -1.23673610e-01f, 1.05253518e-01f, -5.39840013e-02f, 1.96824580e-01f, 1.29531771e-01f, -8.68018195e-02f,
  4.26989831e-02f, 3.39119345e-01f, -4.64354921e-03f, 8.18427578e-02f, 9.61174965e-02f, -1.87657967e-01f, -3.02903324e-01f, -2.34035775e-02f, 1.96299687e-01f, 3.55257273e-01f,
  1.84532672e-01f, 7.89967477e-02f, 4.29278333e-03f, 1.18400998e-01f, -1.94455311e-01f, -3.46138550e-05f, -3.48232567e-01f, -2.18963951e-01f, -1.29526809e-01f, -4.74741369e-01f,
  -1.75005361e-01f, -1.96829394e-01f, 5.80779277e-02f, 5.46443872e-02f, -1.13682061e-01f, 1.52923111e-02f, 3.46245766e-02f, -1.16584115e-01f, 1.79344229e-02f, -2.67374925e-02f,
  -1.02039963e-01f, -1.08104832e-02f, 4.70560826e-02f, -2.00314000e-02f, 3.32095511e-02f, 2.91503407e-02f, 9.61411651e-03f, -1.72307510e-02f, 1.25738338e-03f, -7.22227916e-02f,
  7.81035274e-02f, 6.48150668e-02f, -1.15351774e-01f, -4.72715758e-02f, -3.31960805e-02f, -8.58828798e-02f, -4.90310341e-02f, 5.06628342e-02f, -3.57107148e-02f, -1.51665896e-01f,
  -9.16245952e-02f, -1.08077368e-02f, 8.31736550e-02f, 1.08942725e-02f, 2.04855800e-02f, -7.77836293e-02f, -6.61383420e-02f, 8.94607604e-03f, 8.96997377e-02f, -2.70635784e-02f,
  -5.37590496e-02f, 5.20512685e-02f, -3.52867506e-02f, -3.13561596e-02f, 5.35333827e-02f, -1.33800348e-02f, 1.60690967e-03f, -5.23043089e-02f, 7.25163445e-02f, 7.43737817e-02f,
  3.71009717e-03f, 2.93501876e-02f, -1.08846419e-01f, 5.19030243e-02f, -3.39000337e-02f, -1.23834781e-01f, -5.75273782e-02f, 1.13397636e-01f, 1.55731710e-02f, 7.49132782e-02f,
  -5.06522730e-02f, 1.41730070e-01f, -7.97618702e-02f, -1.27934553e-02f, -3.00911646e-02f, 3.04321703e-02f, -3.28848585e-02f, -4.87025753e-02f, -5.28243408e-02f, 5.69828562e-02f,
  4.04603183e-02f, -3.80565925e-03f, -1.32500082e-01f, -7.03473985e-02f, 2.40087472e-02f, 5.19897975e-02f, 1.34268209e-01f, 5.35943778e-03f, 1.49666443e-01f, -3.45752425e-02f,
  5.73955625e-02f, -1.02303345e-02f, 1.57898054e-01f, 2.75142789e-02f, -7.01134577e-02f, 1.79598257e-02f, 3.66164483e-02f, -9.61860418e-02f, -1.10360809e-01f, -1.80990145e-01f,
  -4.30439860e-01f, 3.01326334e-01f, 1.49037108e-01f, -2.83905417e-01f, 1.97248459e-01f, 3.86268198e-01f, 5.83250880e-01f, 2.28017703e-01f, -2.16330558e-01f, 1.24838233e-01f,
  1.20251939e-01f, -2.73628205e-01f, -1.97783381e-01f, -1.22258760e-01f, 4.07126434e-02f, 2.03677446e-01f, 2.85285264e-02f, -1.61914662e-01f, -1.69605970e-01f, 1.05524115e-01f,
  -6.52744919e-02f, -2.30747148e-01f, -2.98249543e-01f, -1.57795742e-01f, -7.12280497e-02f, -3.65171164e-01f, -3.97202559e-02f, 6.99947923e-02f, 1.66829333e-01f, -6.45513386e-02f,
  -4.41331826e-02f, 1.79705724e-01f, -8.86870772e-02f, -6.30969331e-02f, -2.02036742e-02f, -9.82410908e-02f, -3.71757001e-02f, -5.90082332e-02f, -6.69606552e-02f, -1.54025316e-01f,
  3.83466706e-02f, 1.05714418e-01f, -5.92452027e-02f, 1.03592752e-02f, 6.97177798e-02f, 4.42248955e-02f, 8.62084478e-02f, -6.20114170e-02f, 2.96420492e-02f, 1.20382212e-01f,
  4.36236784e-02f, 1.63166419e-01f, 7.89763108e-02f, 1.33333549e-01f, 1.07449308e-01f, -5.38755469e-02f, 1.01280689e-01f, 1.06537901e-01f, 1.03262834e-01f, -2.26885080e-01f,
  -1.06972329e-01f, -1.55980641e-03f, 1.22336306e-01f, -3.52679081e-02f, -7.97244310e-02f, 2.64620651e-02f, -1.58617012e-02f, 3.56433820e-03f, 7.51961954e-03f, 2.89528258e-03f,
  3.74286971e-03f, -4.95459922e-02f, -1.27989417e-02f, -2.74388934e-03f, -1.31515205e-01f, 2.15422199e-03f, 8.09265599e-02f, -1.53161623e-02f, 9.51942615e-03f, 4.38560396e-02f,
  2.50615589e-02f, -3.24627943e-02f, -4.05026563e-02f, -5.99047765e-02f, 3.84222716e-02f, -1.05891384e-01f, -6.16892390e-02f, 1.16919264e-01f, -6.19456824e-03f, -7.62569681e-02f,
  -4.34851617e-01f, 2.13512361e-01f, -2.44098485e-01f, 1.24176323e-01f, 8.63514468e-02f, 1.60261989e-02f, -5.88512756e-02f, -5.53373545e-02f, -3.61010619e-02f, -9.26909670e-02f,
  3.38649899e-02f, -1.04305826e-01f, 1.74050163e-02f, -5.07400464e-03f, -8.32193419e-02f, -2.58061606e-02f, 1.28267154e-01f, -1.20854400e-01f, 1.17386349e-01f, 2.99183931e-02f,
  -1.58320870e-02f, -3.94118251e-03f, -1.00797921e-01f, 7.81345181e-03f, -8.18008631e-02f, -2.65256375e-01f, -3.62424701e-02f, -9.92417783e-02f, -1.68847796e-02f, -2.03005940e-01f,
  1.12661915e-02f, 2.06659406e-01f, -6.57139063e-01f, 2.43534129e-02f, -2.46416196e-01f, -3.31746578e-01f, -1.65865913e-01f, 2.06448510e-02f, 6.92286715e-02f, 1.66859291e-02f,
  -2.96613183e-02f, 1.29956901e-01f, -4.42633256e-02f, -6.90035373e-02f, -9.47831348e-02f, -3.84704560e-01f, -3.66596878e-01f, -2.96590626e-01f, -2.41056263e-01f, -1.91274621e-02f,
  -8.18905905e-02f, 7.24679753e-02f, 4.50184308e-02f, 7.93210492e-02f, -7.07627386e-02f, 4.49198075e-02f, -1.10352844e-01f, 3.41932103e-03f, -1.80118248e-01f, -2.32026383e-01f,
  -2.54658967e-01f, -2.48548031e-01f, -1.71731859e-01f, 1.01365767e-01f, 8.28597322e-02f, 2.91714538e-02f, 6.38444796e-02f, 4.95444201e-02f, 6.87627718e-02f, 7.78587833e-02f,
  -5.41975461e-02f, 7.50400638e-03f, 3.64425518e-02f, 3.52996066e-02f, -5.57980835e-02f, -7.46711437e-03f, -2.60635056e-02f, -4.13526297e-02f, 2.08780244e-02f, 1.20736368e-01f,
  1.31445274e-01f, 1.60241351e-02f, -8.56227353e-02f, -5.40547678e-03f, -1.63507909e-02f, -8.19589123e-02f, -1.52699510e-02f, -2.91054361e-02f, -9.83549431e-02f, 1.47329122e-01f,
  1.45094898e-02f, 8.89272019e-02f, -1.61829088e-02f, 1.48249328e-01f, 1.47450671e-01f, 1.77014381e-01f, 5.73536269e-02f, 1.68473758e-02f, -7.32029602e-02f, 2.64267158e-02f,
  2.47392774e-01f, -3.64063587e-03f, -1.02077857e-01f, -7.60105997e-02f, -3.63494307e-02f, -3.12745497e-02f, -1.49409398e-01f, 9.74265039e-02f, 3.35849300e-02f, 1.76920323e-03f,
  9.43966210e-03f, 5.62965870e-02f, 7.84537271e-02f, 4.30642888e-02f, -1.06495075e-01f, 2.34776232e-02f, -2.03181714e-01f, 2.09510792e-02f, -1.75431091e-02f, -2.00469226e-01f,
  3.36873084e-01f, -3.68520051e-01f, -6.20767288e-02f, -4.42296602e-02f, -2.61496659e-02f, 6.13798238e-02f, 1.05646066e-03f, -1.93324182e-02f, 6.59674108e-02f, -8.15237314e-02f,
  1.05824722e-02f, 3.33856582e-03f, 4.55850735e-02f, 8.50195810e-02f, 6.94420338e-02f, -8.20431039e-02f, 8.07330087e-02f, 1.37430280e-01f, 7.02261478e-02f, -4.71923128e-03f,
  1.52800396e-01f, 2.25985482e-01f, 1.94633245e-01f, 1.46947488e-01f, 1.99529566e-02f, -5.30536212e-02f, -5.91790117e-03f, 1.08854743e-02f, -8.95841047e-02f, 3.17015529e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.01678677e-01f, 1.14637807e-01f, 2.98304390e-02f, 6.74009994e-02f, -2.44890638e-02f, 2.42634155e-02f, 4.08538312e-01f, 1.34812802e-01f, 6.01636283e-02f, -2.34016627e-02f,
  -8.84469151e-02f, 5.42424852e-03f, -5.16826510e-02f, -4.32819575e-02f, -2.73159239e-03f, 1.44455448e-01f, 7.45035857e-02f, 1.13336280e-01f, 8.14368278e-02f, 2.67246435e-03f,
  -1.17582224e-01f, -2.27066614e-02f, 1.65047616e-01f, 1.27950653e-01f, 1.68073833e-01f, 1.86031073e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.74081938e-02f, 7.16572329e-02f, 9.70785022e-02f, -8.14281404e-02f, -3.02281827e-02f, -7.78125226e-02f, 6.97276145e-02f, -1.43151516e-02f, 1.97926670e-01f, 9.80387107e-02f,
  -1.51277706e-01f, -7.53526241e-02f, -3.40716005e-03f, -2.68903282e-03f, 5.16098700e-02f, -7.33045340e-02f, 6.81159943e-02f, -9.97389257e-02f, -2.02226136e-02f, 7.63533786e-02f,
  8.62108544e-02f, 1.56020634e-02f, 4.94729429e-02f, -1.99082032e-01f, 1.54552879e-02f, -9.27647054e-02f, 2.09469184e-01f, 2.23008469e-01f, 1.01454578e-01f, 3.61229107e-02f,
  9.89705697e-02f, -4.10615429e-02f, 6.66233972e-02f, 9.50041935e-02f, 1.50956903e-02f, 5.42655215e-02f, -2.18706027e-01f, -1.05783872e-01f, 1.73040941e-01f, -4.09321338e-01f,
  -1.13829210e-01f, 1.18004888e-01f, 6.20473996e-02f, 1.48304269e-01f, -1.42764241e-01f, -5.32557033e-02f, -6.43471330e-02f, 8.50066170e-02f, -4.11046073e-02f, -1.02151670e-01f,
  2.05072001e-01f, -1.72905847e-01f, -3.68234888e-02f, 1.78029150e-01f, 1.80860519e-01f, -1.34896979e-01f, 1.88994601e-01f, 2.71122098e-01f, -2.20876094e-03f, 1.17353737e-01f,
  3.00332725e-01f, 1.14693485e-01f, 5.39592393e-02f, -1.20803066e-01f, 8.93730968e-02f, 6.94273189e-02f, 2.12085783e-03f, -1.59838542e-01f, 7.19218105e-02f, -1.67725384e-02f,
  4.37033176e-03f, -6.40607625e-03f, 1.22350425e-01f, -7.11961016e-02f, 6.65206239e-02f, -4.97319736e-02f, 9.53027681e-02f, -6.74203783e-02f, 2.76910737e-02f, 1.24626428e-01f,
  4.65718023e-02f, 7.42200986e-02f, 3.46087031e-02f, -4.94947955e-02f, -9.66060981e-02f, 6.51931912e-02f, -1.12700671e-01f, 5.31923845e-02f, -7.28939697e-02f, 2.08635963e-02f,
  7.61983097e-02f, -2.33997509e-01f, 1.42769620e-01f, -3.07154469e-02f, -9.50937197e-02f, -1.19184032e-01f, 6.97060600e-02f, -1.11884914e-01f, 5.92298657e-02f, -5.32387793e-02f,
  -1.14877716e-01f, -6.94629252e-02f, 2.22303778e-01f, 9.40897614e-02f, -4.40777130e-02f, 1.05685787e-03f, -1.26821756e-01f, 2.10456010e-02f, -3.78548861e-01f, -1.25886708e-01f,
  1.25364529e-03f, 2.23105252e-01f, 1.23810582e-02f, 3.61232692e-03f, 5.38133755e-02f, 3.10497105e-01f, 7.99006745e-02f, -2.15295926e-01f, -9.95222256e-02f, 2.19204128e-01f,
  3.09433378e-02f, 3.80396396e-02f, 6.39709756e-02f, -1.25225320e-01f, -1.43070042e-01f, 4.76455577e-02f, 4.66420263e-01f, -4.00380753e-02f, 9.56876576e-02f, -2.67507769e-02f,
  1.09438701e-02f, -5.45607731e-02f, -1.10226586e-01f, -1.27642332e-02f, -3.65608186e-03f, 9.96772125e-02f, 1.11468524e-01f, 1.14630193e-01f, -4.07215953e-02f, 2.59660613e-02f,
  -1.96344525e-04f, -9.85613614e-02f, 3.13499197e-02f, 8.67373049e-02f, -1.81498617e-01f, -3.61755863e-02f, 3.08542494e-02f, -5.11049554e-02f, -1.68614328e-01f, 1.86334729e-01f,
  -4.09278609e-02f, 1.26650974e-01f, 2.59286892e-02f, -1.88325465e-01f, 1.05912730e-01f, -2.35580474e-01f, 8.30013398e-03f, -1.52316511e-01f, -7.61967450e-02f, 1.46689415e-01f,
  -1.36641739e-02f, 2.01631472e-01f, 2.18752876e-01f, -1.72150359e-01f, -6.08582012e-02f, -3.58677030e-01f, -3.81331183e-02f, 1.17207423e-01f, 1.41158596e-01f, -1.70965895e-01f,
  1.29539400e-01f, 9.30107608e-02f, -1.95102185e-01f, -2.26100981e-01f, 2.33080611e-01f, 2.75065333e-01f, 1.70918331e-01f, -2.07288936e-01f, -6.86101764e-02f, 2.64106393e-01f,
  1.86129838e-01f, -1.01526074e-01f, -1.71809167e-01f, 2.45594963e-01f, 1.92914978e-01f, 2.35844895e-01f, -1.50506958e-01f, 1.32851722e-02f, 9.82499029e-03f, 7.84598812e-02f,
  -1.04661338e-01f, 1.35119781e-01f, -7.32814055e-03f, -7.57443234e-02f, -2.30302606e-02f, 2.74883937e-02f, -8.39530155e-02f, 5.41435592e-02f, 6.82489350e-02f, -3.66291665e-02f,
  -1.75760239e-01f, 6.72349408e-02f, -8.09684675e-03f, 3.10689807e-02f, 9.95769873e-02f, 9.67728049e-02f, -1.58040430e-02f, -1.03048831e-02f, -6.24547936e-02f, 6.58283681e-02f,
  -1.45938620e-01f, 5.15945740e-02f, 7.57628679e-02f, -9.03246552e-02f, -1.07624866e-01f, 1.79132968e-01f, 1.38184130e-01f, -1.67413149e-02f, -2.14745756e-02f, -4.37221676e-02f,
  -2.32603662e-02f, -1.45073503e-01f, 6.73547015e-02f, 1.97725356e-01f, -3.46041732e-02f, -4.23079655e-02f, -4.43254896e-02f, 6.93753064e-02f, -1.88094661e-01f, 2.22359542e-02f,
  -2.46409193e-01f, -2.70447508e-02f, 5.18977791e-02f, -3.95300277e-02f, -1.92381769e-01f, -1.10294119e-01f, -9.95000675e-02f, 1.72018960e-01f, -1.13380216e-01f, 1.67977184e-01f,
  7.83327371e-02f, 1.02440067e-01f, 1.28605468e-02f, -1.24732278e-01f, 1.70166835e-01f, -9.96103361e-02f, -1.71876252e-01f, -7.63144493e-02f, -1.18898898e-01f, 1.42062351e-01f,
  1.60838380e-01f, -7.67432079e-02f, -6.26934320e-02f, -9.33842286e-02f, 3.18980068e-01f, -9.03851613e-02f, -8.95849094e-02f, -6.90343138e-03f, 1.76463261e-01f, -5.78983501e-02f,
  3.23273838e-02f, -7.23275766e-02f, 4.28103469e-03f, -1.03878982e-01f, -2.64381375e-02f, -6.44954517e-02f, 2.90359985e-02f, -1.78699002e-01f, -7.89649412e-02f, 1.23892678e-02f,
  -2.66790707e-02f, 3.56782824e-02f, -1.73288748e-01f, -1.11265562e-01f, 3.45761962e-02f, -7.10476190e-02f, -4.12140973e-02f, -4.72109765e-02f, -1.47496359e-02f, -1.56248122e-01f,
  -4.95769493e-02f, -6.02319539e-02f, -2.98322663e-02f, 3.75800505e-02f, 1.09890275e-01f, 1.25757575e-01f, -4.39003576e-03f, -1.16604023e-01f, 7.09865615e-03f, 8.36325958e-02f,
  1.31161749e-01f, -2.39309773e-01f, 1.06464857e-02f, 5.13867922e-02f, 2.28427887e-01f, -3.34406227e-01f, -1.00518584e-01f, 1.10262610e-01f, 9.07142386e-02f, -1.30091682e-01f,
  -3.34256172e-01f, -1.76333502e-01f, -2.38914341e-01f, -1.58828288e-01f, -1.55622154e-01f, 4.96806726e-02f, -8.90952423e-02f, 1.64630428e-01f, -1.03025816e-01f, 1.48847982e-01f,
  2.26483509e-01f, -1.09756589e-01f, 1.53199345e-01f, -1.10719083e-02f, -4.20031697e-02f, 1.23163670e-01f, 5.75248562e-02f, 1.18388891e-01f, -7.79911503e-02f, -3.31752412e-02f,
  1.21813327e-01f, 4.20926837e-03f, 9.02703777e-02f, -3.68193313e-02f, 5.02626523e-02f, -8.73701274e-02f, -1.80003010e-02f, -1.71495765e-01f, -7.08526000e-02f, -1.43527682e-03f,
  -1.23334482e-01f, -1.17832594e-01f, -9.38481241e-02f, -2.34626651e-01f, -2.58246344e-02f, -2.10107282e-01f, -4.72661182e-02f, -1.12549968e-01f, 1.35695934e-01f, 8.53252932e-02f,
  -1.10948039e-02f, 1.35568967e-02f, 6.65629655e-02f, -2.03459278e-01f, 3.39395776e-02f, 1.17269680e-02f, 1.32629961e-01f, -5.84240220e-02f, 4.97471988e-02f, -4.88534644e-02f,
  3.55889685e-02f, 5.68924472e-03f, -2.57844087e-02f, 1.74353838e-01f, -1.27118146e-02f, -1.29363954e-01f, 1.52965397e-01f, -3.01793903e-01f, 8.32196176e-02f, -1.18165597e-01f,
  9.71806701e-03f, -1.20380633e-01f, 3.59427035e-02f, 1.36843100e-01f, -8.60828683e-02f, -8.84373412e-02f, 1.02329805e-01f, 1.19021215e-01f, 1.40557170e-01f, -4.73301932e-02f,
  3.06498888e-03f, 3.74357738e-02f, 1.50617184e-02f, 1.20329648e-01f, -2.43649166e-02f, -2.27106690e-01f, 2.58401453e-01f, -1.95312910e-02f, -9.65618268e-02f, -2.13632450e-01f,
  2.87512541e-01f, 2.09506571e-01f, -1.92969352e-01f, 9.02163982e-02f, -2.84533836e-02f, 6.25749156e-02f, 6.79941177e-02f, 1.20893441e-01f, -1.06339771e-02f, 8.47714674e-03f,
  1.64356261e-01f, 1.30597100e-01f, 6.94702938e-02f, 2.17605188e-01f, -2.01533943e-01f, -1.31364921e-02f, -1.55170456e-01f, 4.17568302e-03f, 5.70284911e-02f, 2.65211686e-02f,
  4.61262353e-02f, -1.27424836e-01f, 8.30389261e-02f, -9.99007598e-02f, 1.81551725e-02f, 1.22195497e-01f, -3.58992890e-02f, 1.00211147e-02f, 6.03324026e-02f, -5.61242178e-02f,
  1.84166746e-03f, -1.73095047e-01f, -3.37359384e-02f, -5.12276255e-02f, 1.53412428e-02f, 2.37072110e-01f, -5.30219823e-02f, 1.52370095e-01f, 1.20160945e-01f, -1.08880207e-01f,
  2.50547618e-01f, -4.16771024e-02f, -5.34963347e-02f, -6.83097392e-02f, 1.60928760e-02f, 5.28825447e-02f, 8.30173865e-03f, -5.43363914e-02f, 1.43958673e-01f, 1.66193753e-01f,
  -2.20912039e-01f, -1.79017782e-01f, 5.51820034e-03f, -3.81013975e-02f, -2.04880953e-01f, -1.80745035e-01f, -1.93309322e-01f, 4.21635024e-02f, 7.88116306e-02f, 1.94707625e-02f,
  6.48183823e-02f, 6.16445541e-02f, -1.33082151e-01f, 9.02047381e-03f, -7.01340334e-03f, -1.19661704e-01f, -1.39733419e-01f, -1.88898314e-02f, -3.42170671e-02f, -8.87814071e-03f,
  -1.18211165e-01f, -1.30539864e-01f, -9.19254720e-02f, -3.74193937e-02f, -9.59507748e-02f, -1.44390156e-02f, -3.45947929e-02f, 7.56688565e-02f, -1.22387275e-01f, 1.82045326e-02f,
  -3.49283069e-02f, -2.10904540e-03f, -5.17138429e-02f, -1.16344579e-01f, -5.60156927e-02f, 3.92015204e-02f, -7.38388225e-02f, -1.16525948e-01f, 5.81492484e-02f, 3.68316285e-02f,
  2.05921024e-01f, -8.06695670e-02f, -5.99109903e-02f, -3.73794511e-02f, -1.55943453e-01f, 2.56603718e-01f, -6.77156774e-03f, -2.37782583e-01f, -6.73150122e-02f, 2.47636482e-01f,
  -6.94481772e-04f, -8.74257535e-02f, -2.01442227e-01f, 2.89427906e-01f, 1.08808324e-01f, -2.18431056e-01f, -3.08502734e-01f, -7.97153041e-02f, 1.06094882e-01f, 9.69622582e-02f,
  -7.61356726e-02f, 1.53039366e-01f, -2.05904633e-01f, 1.90209389e-01f, -2.25447137e-02f, 6.20960854e-02f, 8.92703533e-02f, -1.47464484e-01f, 4.90442179e-02f, -1.97490439e-01f,
  -5.42499796e-02f, -8.13493598e-03f, -2.16488123e-01f, -4.48912680e-02f, 3.19993570e-02f, 1.57869965e-01f, 3.45788896e-02f, 2.02477977e-01f, 5.17451391e-02f, -1.15642287e-01f,
  -5.66607676e-02f, 1.65230185e-02f, 1.01385653e-01f, -2.79420465e-02f, -7.46395513e-02f, -2.68541332e-02f, 8.33173171e-02f, 8.85536429e-03f, 8.59931577e-03f, -6.68103322e-02f,
  2.50963885e-02f, 6.53502792e-02f, -5.02327643e-02f, -1.05381966e-01f, 9.24081504e-02f, 7.49990866e-02f, 4.24591415e-02f, 6.78847730e-02f, -1.01092547e-01f, -5.61328977e-02f,
  4.91630249e-02f, 2.90935468e-02f, 1.00938022e-01f, -1.01334698e-01f, 1.40797421e-01f, -1.30918309e-01f, -9.04734433e-02f, 1.21521927e-01f, 1.15387313e-01f, 1.94889247e-01f,
  -1.50902808e-01f, 5.85460253e-02f, -3.64761464e-02f, -4.96606939e-02f, 1.02816463e-01f, 1.06909238e-01f, 1.12297095e-01f, -2.88525540e-02f, -8.67715999e-02f, 5.00155985e-02f,
  9.26032737e-02f, -1.21807635e-01f, -1.17879324e-01f, 1.38911918e-01f, 2.74298429e-01f, -9.18894112e-02f, 2.39966772e-02f, 1.29037172e-01f, -2.45764941e-01f, -9.64486152e-02f,
  1.13276452e-01f, -7.11654499e-02f, 6.19792752e-02f, 2.32816804e-02f, -3.08465302e-01f, 5.06571587e-03f, 1.73569620e-01f, -1.24984212e-01f, -4.33232486e-02f, -2.22136244e-01f,
  1.09282658e-01f, 4.37777899e-02f, -2.08664755e-03f, 2.32514907e-02f, -1.55819699e-01f, 1.40671521e-01f, -3.68945971e-02f, 3.31043415e-02f, -7.76315182e-02f, 6.46204920e-03f,
  -1.33930475e-01f, 6.38583750e-02f, -1.20877754e-02f, -1.74922729e-03f, -1.09750323e-01f, 5.39607517e-02f, 2.31181402e-02f, 1.16748840e-01f, 6.92222267e-02f, -8.99192020e-02f,
  1.45063922e-02f, 4.29779701e-02f, -1.20696716e-01f, 1.35644734e-01f, 6.08251467e-02f, 8.66966075e-05f, 6.37604482e-03f, 6.06262051e-02f, -2.25588754e-01f, 1.82832658e-01f,
  1.00591354e-01f, 7.27006942e-02f, -2.52779610e-02f, -9.59163830e-02f, -1.30788917e-02f, 1.11023718e-02f, 4.81303111e-02f, 1.16429992e-01f, -4.77364250e-02f, -4.65457253e-02f,
  -1.05197169e-01f, -1.60384625e-01f, -2.44020224e-01f, -9.09509361e-02f, -6.93934336e-02f, 3.69503975e-01f, 3.44225205e-02f, -7.13799372e-02f, -1.40477285e-01f, 1.89212132e-02f,
  -2.53485233e-01f, 4.56341431e-02f, 1.81502044e-01f, 1.12538815e-01f, 1.57035798e-01f, 1.94430761e-02f, -1.21464502e-04f, 1.16526335e-01f, -2.72528231e-02f, -8.02515671e-02f,
  -2.63491124e-01f, 3.32006276e-01f, -2.61175931e-01f, -2.70489696e-02f, 1.59706354e-01f, -1.69963941e-01f, -3.31949405e-02f, -1.34289801e-01f, 2.44059563e-01f, 6.15956001e-02f,
  1.28431991e-01f, 4.08109365e-04f, 3.86671200e-02f, 2.59521510e-02f, 9.44891945e-02f, 3.80824246e-02f, -8.28048810e-02f, -1.10978119e-01f, 7.22350180e-02f, -4.58249077e-02f,
  -8.96173492e-02f, -6.34002611e-02f, -2.48959381e-02f, -5.67807257e-02f, 5.48626669e-02f, 3.66715528e-02f, -9.42204371e-02f, 3.69400810e-03f, 1.13352671e-01f, -6.61665993e-03f,
  -5.49460687e-02f, 3.87708955e-02f, -4.94831533e-04f, -1.22769840e-01f, 1.16658524e-01f, 1.00692786e-01f, 1.77585091e-02f, 1.27358720e-01f, -7.53294751e-02f, 2.01177895e-02f,
  6.23071529e-02f, -4.59044166e-02f, -9.77135077e-02f, 2.97043808e-02f, 7.79299112e-03f, 7.01143146e-02f, 1.02622904e-01f, 1.65629480e-02f, 9.52365696e-02f, -1.99777365e-01f,
  -5.35271801e-02f, -5.50918002e-03f, 1.82640150e-01f, 9.64833274e-02f, -4.89643738e-02f, 8.34724233e-02f, 1.07541531e-02f, 1.13048799e-01f, 1.96591198e-01f, -1.00073665e-01f,
  1.05663836e-01f, 9.46179498e-03f, -8.46895203e-02f, 1.62756473e-01f, -1.91278439e-02f, -6.44430518e-02f, 2.48781130e-01f, -1.47804990e-01f, -2.65885592e-02f, -1.28569473e-02f,
  7.80607909e-02f, 1.17287617e-02f, -3.21196057e-02f, 8.56851041e-02f, -5.63691277e-03f, 4.99556363e-02f, -3.74778211e-02f, 6.52909353e-02f, 1.10783763e-01f, -1.24407344e-01f,
  -5.07110916e-02f, -7.30362255e-03f, -1.58808921e-02f, -8.17233324e-02f, 1.48265824e-01f, -7.22932862e-03f, 7.81000555e-02f, -1.91989932e-02f, 9.85973924e-02f, -1.25940591e-01f,
  6.75665634e-03f, -8.45840499e-02f, 8.66114646e-02f, -5.27638495e-02f, 2.83149127e-02f, 8.25658590e-02f, 1.04469866e-01f, -1.49908918e-03f, -6.33900426e-03f, -1.05132639e-01f,
  1.83475241e-02f, -8.68662912e-03f, 6.15299717e-02f, 5.42128868e-02f, 1.20981783e-01f, -9.33246017e-02f, 1.34766281e-01f, 1.72968060e-01f, -4.86265458e-02f, 1.52154714e-01f,
  1.34035740e-02f, -2.48761669e-01f, 1.80809036e-01f, 2.24004507e-01f, -2.52029244e-02f, -1.00767449e-01f, 1.20845161e-01f, 4.21021618e-02f, 9.41256061e-02f, -9.95338336e-02f,
  1.82760477e-01f, 2.26888850e-01f, 2.25108117e-01f, 7.87172019e-02f, 7.87494779e-02f, 3.64116967e-01f, 1.51176766e-01f, 2.08705459e-02f, -6.28870353e-02f, -8.77112672e-02f,
  -5.47502339e-02f, -2.02246428e-01f, -1.75609678e-01f, -1.76906109e-01f, 2.63762511e-02f, 3.09008330e-01f, -5.73490076e-02f, 2.84109831e-01f, -3.02349590e-02f, -3.65489302e-03f,
  1.03650696e-03f, -1.32322147e-01f, -3.39333492e-04f, 1.26253217e-01f, 6.34329617e-02f, 5.21649979e-02f, -3.79062518e-02f, 9.85717326e-02f, -7.07548577e-03f, -1.19021453e-01f,
  -7.74656460e-02f, -3.82536724e-02f, -5.55924140e-02f, -1.46527782e-01f, -9.44019705e-02f, -9.05547515e-02f, 6.03767857e-02f, -2.76459232e-02f, 5.43990470e-02f, 2.11597934e-01f,
  1.75228208e-01f, -2.34798521e-01f, -1.49986610e-01f, -1.83424175e-01f, 1.33224856e-02f, -8.96474048e-02f, -6.86446205e-02f, -3.26764703e-01f, 1.63076386e-01f, 3.39851648e-01f,
  7.04707950e-02f, 4.24824283e-02f, -1.91431250e-02f, 2.25803614e-01f, -1.64697021e-02f, -2.71506105e-02f, -2.29476586e-01f, 1.06567435e-01f, -2.61893749e-01f, -1.44268170e-01f,
  -9.59310234e-02f, -1.44146401e-02f, -7.91008100e-02f, 2.49026194e-01f, 3.21192294e-01f, 7.03304308e-03f, 1.12324968e-01f, -3.07585120e-01f, 3.05909123e-02f, 5.87127581e-02f,
  -3.92359406e-01f, 3.12889159e-01f, 4.34322879e-02f, 3.41208875e-02f, 1.49381012e-01f, 1.22969419e-01f, 4.49065343e-02f, -2.02147543e-01f, -2.15790849e-02f, -2.75525272e-01f,
  -1.20036215e-01f, -2.79259938e-03f, -5.14065661e-02f, 1.79756805e-02f, -2.17898376e-02f, 9.23445672e-02f, -9.79837030e-02f, 1.95462584e-01f, 1.50628284e-01f, 2.30677538e-02f,
  1.72877103e-01f, 3.21968906e-02f, -5.90292849e-02f, 1.09399006e-01f, -1.84236795e-01f, 2.52897833e-02f, 6.64678141e-02f, 2.25852616e-02f, 6.28788620e-02f, -1.83019284e-02f,
  -6.05443530e-02f, 2.58435719e-02f, -3.18958424e-02f, 1.13062285e-01f, -8.71712938e-02f, -1.08546034e-01f, 5.58168851e-02f, -1.70160353e-01f, 4.73528579e-02f, -1.59856737e-01f,
  -9.11409557e-02f, 7.27368444e-02f, -5.14978804e-02f, 7.86630586e-02f, -7.65936822e-02f, 1.29878670e-01f, 2.23166898e-01f, -6.44292012e-02f, 1.65177181e-01f, 1.06025182e-01f,
  5.50871640e-02f, 1.99677162e-02f, 1.67527199e-01f, -6.84458241e-02f, 4.86388803e-02f, -3.01742494e-01f, 4.68038559e-01f, -6.69268668e-02f, 1.24249905e-02f, -2.14326754e-01f,
  -1.64043188e-01f, -1.22638829e-01f, -1.34113178e-01f, -3.29035848e-01f, -9.89938825e-02f, 1.32778078e-01f, 5.59210852e-02f, -8.22208598e-02f, -2.67610177e-02f, -2.06012830e-01f,
  -1.67478874e-01f, 7.28331059e-02f, 4.04750817e-02f, -1.59299225e-02f, -4.07781303e-01f, -1.29633695e-01f, 8.22824761e-02f, 9.40363407e-02f, 7.75970593e-02f, -4.12917556e-03f,
  -3.18766981e-02f, 1.30003430e-02f, -4.17363159e-02f, -4.30976897e-02f, -1.44868508e-01f, -9.07332462e-04f, 4.46202233e-02f, -5.18865287e-02f, 1.40454099e-01f, 2.13295400e-01f,
  1.13203423e-02f, 2.33621635e-02f, -8.50737374e-03f, -2.29129139e-02f, 8.99787545e-02f, 2.16276869e-01f, -3.34995687e-02f, -6.41180202e-02f, -8.90418515e-02f, -1.31054789e-01f,
  3.63362059e-02f, -1.36793330e-02f, 2.55336426e-02f, 7.62306526e-02f, -2.04330646e-02f, -7.61240497e-02f, -1.78497642e-01f, 8.28487426e-02f, -2.03500941e-01f, 1.03007993e-02f,
  7.99643546e-02f, 4.86483723e-02f, 1.84069142e-01f, 1.95267975e-01f, -1.42388761e-01f, -5.96166626e-02f, -1.26145352e-02f, -1.76244393e-01f, -2.17609644e-01f, -1.22172706e-01f,
  4.09735918e-01f, -4.08189632e-02f, -5.71629256e-02f, -5.64709418e-02f, -1.17196143e-01f, 8.62465724e-02f, -1.98389798e-01f, -1.95742831e-01f, -1.77495237e-02f, 2.34141991e-01f,
  2.84402091e-02f, -1.82271168e-01f, 9.91347209e-02f, 1.28284961e-01f, -1.30761221e-01f, -6.76712468e-02f, -5.75031899e-02f, -2.00333372e-01f, -1.10640056e-01f, -1.49310485e-01f,
  1.42514884e-01f, -6.50271121e-03f, -4.09755632e-02f, -1.45107895e-01f, 1.24222256e-01f, 1.75347645e-02f, 8.91744941e-02f, -2.74721142e-02f, 1.88273966e-01f, 5.16813658e-02f,
  -1.90402544e-03f, -1.99774206e-01f, -5.18440269e-02f, 5.50515801e-02f, 1.39603198e-01f, -4.46596779e-02f, -3.40176634e-02f, 1.62585527e-01f, 1.46339014e-01f, -1.04440942e-01f,
  -5.95008023e-03f, 4.93538864e-02f, 1.21524207e-01f, -2.88893104e-01f, -2.18778074e-01f, 4.72050048e-02f, 6.35922793e-03f, 3.47260356e-01f, 5.09452671e-02f, -6.61101937e-02f,
  4.60624211e-02f, 1.28982440e-02f, 2.81158239e-02f, 1.69489890e-01f, -8.17785859e-02f, 1.34259999e-01f, -4.76673022e-02f, 1.07436009e-01f, 1.39807418e-01f, -1.93343550e-01f,
  -3.10917258e-01f, -1.96836721e-02f, 1.12180620e-01f, 1.70092151e-01f, -1.07156619e-01f, 1.08909741e-01f, -2.09524974e-01f, -7.56286830e-02f, 9.17861387e-02f, 1.37699433e-02f,
  3.95018309e-02f, -1.65976286e-01f, -2.70545572e-01f, 1.54390514e-01f, 3.27546120e-01f, -1.09731354e-01f, 1.19706921e-01f, -1.66203767e-01f, 1.39995581e-02f, 1.69028509e-02f,
  3.69988158e-02f, -3.56445722e-02f, -2.14530796e-01f, 1.72122046e-01f, -5.99379512e-03f, 1.56276450e-01f, 1.54737487e-01f, 9.08965543e-02f, 1.50659487e-01f, -7.24005923e-02f,
  5.64250201e-02f, 1.50505915e-01f, 1.32499397e-01f, -1.27416113e-02f, -3.65058519e-02f, -6.15432393e-03f, 6.17395975e-02f, 6.87363893e-02f, -2.22765692e-02f, -7.39800557e-02f,
  -1.28321677e-01f, -5.53045794e-02f, -7.70015121e-02f, 6.00718148e-02f, 2.19398364e-01f, -1.91090233e-03f, 9.16772410e-02f, -1.58889920e-01f, -1.42165139e-01f, -1.40906116e-02f,
  2.24858597e-01f, 1.22005954e-01f, -1.57908455e-01f, 1.71929181e-01f, -7.05974922e-02f, -1.66624069e-01f, -1.28379557e-02f, 2.46490255e-01f, 2.36587122e-01f, 1.01896785e-01f,
  1.26138464e-01f, 5.70441186e-02f, 1.68489486e-01f, -2.94457883e-01f, -1.54589176e-01f, 8.22320282e-02f, -1.16748467e-01f, 1.45677790e-01f, -1.45811304e-01f, -5.13058677e-02f,
  1.15613170e-01f, 2.48705626e-01f, -1.87830180e-02f, 2.60382593e-02f, -7.16684805e-03f, -6.53452426e-02f, -1.55661069e-02f, 5.91538735e-02f, 4.29909714e-02f, -3.11848253e-01f,
  2.72702575e-01f, 4.33117524e-02f, 4.14389325e-03f, 1.31193042e-01f, 1.70709770e-02f, 1.76864073e-01f, 2.55759716e-01f, 6.30736873e-02f, 2.56782062e-02f, -1.63564682e-02f,
  -2.23855317e-01f, -5.41182980e-02f, -8.55421945e-02f, -5.31291924e-02f, 1.69828355e-01f, -5.54204993e-02f, -3.16289975e-03f, -8.93277377e-02f, 4.87974212e-02f, -2.04206973e-01f,
  3.83174121e-02f, -1.66715518e-01f, -4.19653915e-02f, -1.56122993e-03f, -5.94064221e-03f, -3.17407325e-02f, 5.00945281e-03f, 4.62232940e-02f, -6.88906312e-02f, 6.16431125e-02f,
  2.32173223e-02f, 7.41726160e-02f, -7.67639140e-03f, 1.09032959e-01f, 8.32241625e-02f, -1.35101840e-01f, -1.89132728e-02f, 3.89706165e-01f, -2.24618372e-02f, -3.23921204e-01f,
  9.84154046e-02f, -1.86249256e-01f, -7.94340149e-02f, -1.47720456e-01f, -2.46634364e-01f, 1.68373644e-01f, 2.34927267e-01f, -1.98309068e-02f, 3.09535465e-03f, 1.41428053e-01f,
  -4.94606942e-02f, 1.02600425e-01f, -1.62820872e-02f, -1.85030237e-01f, -1.00474738e-01f, 1.93621427e-01f, -7.05960467e-02f, 3.88573222e-02f, 8.01059604e-02f, 8.61620083e-02f,
  7.32897073e-02f, 7.11771380e-03f, 9.80727226e-02f, -1.09410927e-01f, -2.47167304e-01f, -3.18747014e-01f, 1.25087455e-01f, 1.39155731e-01f, -1.12534031e-01f, 2.17793018e-01f,
  1.69598550e-01f, 1.93710655e-01f, -4.29687053e-02f, 6.56047091e-02f, 3.02595180e-02f, 1.09682931e-02f, 4.28444855e-02f, -2.89593842e-02f, -5.39942794e-02f, 1.59836672e-02f,
  2.32580071e-03f, 4.69863228e-02f, 8.69232789e-02f, 6.36160895e-02f, 2.21823994e-02f, 2.46831123e-02f, -5.16420370e-03f, -8.48753676e-02f, 7.14403540e-02f, 7.47326165e-02f,
  -9.60848629e-02f, -8.47830996e-03f, 2.61175781e-02f, -1.03021398e-01f, -9.91719738e-02f, 1.61653563e-01f, 1.11178398e-01f, 1.56372748e-02f, -1.30680904e-01f, -6.11223727e-02f,
  6.70611411e-02f, -2.03264818e-01f, -3.52570340e-02f, 3.26068938e-01f, 8.29118714e-02f, -9.96877104e-02f, -2.10105091e-01f, 2.62953490e-01f, -1.58658609e-01f, -2.97091287e-02f,
  -2.65603989e-01f, 2.55600512e-01f, -1.42461151e-01f, 1.38058051e-01f, -1.96400136e-02f, 1.43481478e-01f, -9.85029060e-03f, 1.34781688e-01f, -4.60226834e-02f, -1.56205650e-02f,
  3.57104465e-02f, 1.87651664e-01f, 1.31957933e-01f, -9.66214314e-02f, -5.93219362e-02f, -9.89006162e-02f, -2.18124956e-01f, -8.87928680e-02f, -9.92753059e-02f, 2.69369990e-01f,
  1.75185218e-01f, 7.33981580e-02f, 4.35741991e-02f, -1.35374576e-01f, 6.67737424e-02f, -6.48137107e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.21031432e-02f, 6.39871880e-02f, 5.43804839e-02f, 2.85691559e-01f, 2.24615544e-01f, 1.33623019e-01f, 2.14446485e-02f, 8.10563043e-02f, 8.86180252e-03f, -2.38121487e-02f,
  2.51311451e-01f, 8.75440314e-02f, 4.00477387e-02f, 1.25391886e-01f, 1.51409358e-01f, 2.04939824e-02f, 2.21414298e-01f, 2.68484056e-01f, -1.57836035e-01f, 2.15598866e-01f,
  1.87716171e-01f, -2.41240293e-01f, -1.40872911e-01f, -1.87987722e-02f, 4.20714356e-02f, 7.85483345e-02f, 2.74254847e-02f, -2.02630073e-01f, -6.48833439e-02f, 1.38564967e-02f,
  -2.26245262e-02f, 4.20366265e-02f, 7.25896731e-02f, -1.49545252e-01f, -1.93810314e-01f, 1.68768063e-01f, 4.68667075e-02f, 1.66274831e-01f, 1.57467835e-02f, 2.80162157e-03f,
  5.05516790e-02f, 1.45297751e-01f, -2.07752302e-01f, -1.76947311e-01f, 1.79850847e-01f, 9.32644382e-02f, 8.29109624e-02f, 8.64082016e-03f, -9.90986153e-02f, 9.71002579e-02f,
  -1.97887775e-02f, 8.54180455e-02f, -1.57007411e-01f, -1.93549283e-02f, 1.33096497e-03f, -1.84547663e-01f, 5.04692532e-02f, -7.70949647e-02f, 3.43955427e-01f, -1.60191372e-01f,
  -2.56793767e-01f, -8.87665302e-02f, 4.09825861e-01f, -1.78308800e-01f, -5.42031229e-02f, 1.18882969e-01f, 1.31883636e-01f, 5.45367934e-02f, 3.04673668e-02f, -6.04711026e-02f,
  -9.41203684e-02f, 1.66028377e-03f, 8.17531347e-02f, -1.19422629e-01f, -1.33461013e-01f, -9.74701345e-02f, 1.72774363e-02f, -2.05790345e-02f, -1.59633338e-01f, 8.51663947e-02f,
  1.24897836e-02f, 7.51993582e-02f, 7.97822550e-02f, -9.85121354e-03f, -4.30824235e-02f, -2.31760554e-02f, -4.07340229e-02f, -2.48240996e-02f, 2.57789940e-02f, 1.20363869e-01f,
  2.30252147e-01f, 2.18131438e-01f, 1.08351812e-01f, 1.18942998e-01f, 3.45113575e-02f, -1.99259967e-01f, 1.63314883e-02f, -2.94855144e-03f, -2.46101953e-02f, 1.51060477e-01f,
  -3.66545399e-03f, 1.34841781e-02f, 1.87601388e-01f, -1.72835529e-01f, 4.85090204e-02f, 2.41290212e-01f, 1.43592935e-02f, 1.33347809e-01f, -1.20497905e-01f, 1.38834819e-01f,
  1.75598174e-01f, 2.24927381e-01f, -2.62040552e-02f, 6.09787367e-02f, 2.22212642e-01f, 7.77206793e-02f, 6.54990077e-02f, 1.31430542e-02f, 1.60241365e-01f, -2.21303120e-01f,
  2.33461395e-01f, -1.39943957e-02f, 7.57926181e-02f, -2.97238380e-01f, 1.21085262e-02f, 2.05903992e-01f, 2.80796289e-01f, 1.38161734e-01f, 2.11651787e-01f, -6.42036870e-02f,
  4.38020825e-02f, 6.00923821e-02f, -4.23933566e-02f, -9.81940851e-02f, 5.77881075e-02f, 6.17546141e-02f, -6.21611997e-03f, 2.34206781e-01f, 1.24035373e-01f, 4.33441848e-02f,
  -6.54108357e-04f, -7.31160641e-02f, 1.19315639e-01f, -5.18821850e-02f, 2.00716585e-01f, 2.32475670e-03f, 1.28008023e-01f, -2.06623539e-01f, 4.55829017e-02f, 7.63809010e-02f,
  1.65897876e-01f, -2.40868196e-01f, 2.11137533e-01f, -2.41847843e-01f, 8.63932744e-02f, -2.56461138e-03f, 1.68018177e-01f, -1.57706603e-01f, 5.83572574e-02f, 7.34033063e-02f,
  -9.99258757e-02f, 6.41394705e-02f, 1.35314688e-01f, -9.17465985e-02f, 7.19475225e-02f, -3.33153158e-01f, -3.52047570e-02f, -3.46843392e-01f, -2.76745409e-01f, -6.74062446e-02f,
  1.98192909e-01f, 3.81726623e-01f, 1.86809093e-01f, 1.11777797e-01f, 2.76184846e-02f, 9.37116072e-02f, 7.90651217e-02f, -3.56841981e-01f, 4.51784544e-02f, 1.57265201e-01f,
  -4.84257452e-02f, 2.26531699e-01f, 1.46469012e-01f, 1.05567537e-01f, 3.98447722e-01f, 2.32804909e-01f, -5.51029667e-03f, -1.75697684e-01f, 2.31073692e-01f, -1.22427586e-02f,
  2.58335378e-02f, -2.16158167e-01f, 4.44348417e-02f, 1.28528252e-01f, 4.93682101e-02f, 8.41694996e-02f, 5.81721626e-02f, 2.04766229e-01f, 1.16323583e-01f, -2.24922925e-01f,
  4.04362604e-02f, -1.35038262e-02f, -6.86435169e-03f, 3.89400199e-02f, -5.03584854e-02f, 3.29583704e-01f, 2.74053179e-02f, 1.07030049e-01f, -6.20222576e-02f, 1.64691746e-01f,
  8.26771483e-02f, -1.01357594e-01f, -1.87259447e-02f, -2.75250971e-01f, -7.34770074e-02f, -1.62178725e-01f, -1.04102552e-01f, 3.65338102e-02f, -7.69366026e-02f, 1.62976429e-01f,
  -5.43966144e-02f, -1.05286889e-01f, -1.88376904e-01f, 1.54500961e-01f, 4.38404828e-02f, -2.47119784e-01f, -2.30090991e-01f, 4.45237160e-01f, -1.25689611e-01f, 3.73554915e-01f,
  -3.71479243e-01f, -4.71459359e-01f, 1.27858818e-01f, 3.32622528e-02f, -7.99125433e-02f, -1.24370568e-01f, -2.80040413e-01f, 4.05510992e-01f, -7.38472044e-02f, -2.97083318e-01f,
  -1.17730640e-01f, -2.57220000e-01f, -5.26084751e-02f, 5.95899150e-02f, -2.10437879e-01f, 1.09842531e-01f, 7.81182125e-02f, -2.38034233e-01f, 6.39991388e-02f, 7.77523667e-02f,
  1.48185477e-01f, -2.46498227e-01f, 1.05742656e-01f, -5.69896936e-01f, 1.36222780e-01f, -4.21518415e-01f, -5.12517914e-02f, 6.35252818e-02f, -1.06222764e-01f, -2.59035856e-01f,
  -2.30846051e-02f, -2.50546306e-01f, 9.53172669e-02f, -1.24456219e-01f, 1.47180244e-01f, -4.20806259e-02f, 2.77360622e-02f, -2.35106900e-01f, 5.14795557e-02f, 1.07350461e-02f,
  -5.07272966e-02f, -3.44955325e-02f, 6.31129835e-03f, 7.92629272e-02f, 1.62247166e-01f, 3.73723148e-03f, 9.25972611e-02f, -1.89262833e-02f, 2.19251420e-02f, -3.54095027e-02f,
  -2.35188305e-01f, 1.26356229e-01f, 1.59710586e-01f, 1.31390676e-01f, -5.09266704e-02f, 5.27275279e-02f, 6.48926990e-03f, -3.52612108e-01f, 1.26089171e-01f, -1.43959835e-01f,
  1.69973269e-01f, -1.11221135e-01f, -1.46596506e-02f, 2.11969897e-01f, 2.00004801e-01f, -1.03255622e-01f, -1.99664026e-01f, -1.64687023e-01f, 2.13920906e-01f, 1.10725462e-01f,
  -1.06704287e-01f, -3.34367692e-01f, -5.18148206e-02f, -6.08889870e-02f, 1.22197252e-02f, 8.53243768e-02f, -4.55433875e-02f, 3.62810530e-02f, -1.65882438e-01f, -2.04134494e-01f,
  2.67228425e-01f, -2.87592132e-02f, 1.33872330e-01f, -1.11039810e-01f, -2.42523458e-02f, -1.61169097e-01f, 1.29612178e-01f, 2.86038339e-01f, -6.20175563e-02f, 1.30933121e-01f,
  7.71127790e-02f, -4.90349531e-02f, -1.43946251e-02f, -6.12940192e-02f, 1.09823428e-01f, 1.21240400e-01f, 6.38059601e-02f, 4.73445505e-02f, 1.98982030e-01f, 9.86895412e-02f,
  1.84479833e-01f, 4.02628370e-02f, -4.15070951e-02f, -5.16686514e-02f, 7.39490986e-03f, 1.34372696e-01f, 8.96494545e-04f, -3.42545286e-02f, 9.97064710e-02f, 8.76738504e-02f,
  5.31121111e-03f, 8.63768533e-02f, -2.18567923e-02f, -1.04139812e-01f, 1.69186801e-01f, -1.46332100e-01f, 2.03533962e-01f, -6.85681179e-02f, 5.99572696e-02f, -1.05818518e-01f,
  -4.14972715e-02f, -7.39056543e-02f, 1.37799801e-02f, -4.11272123e-02f, 1.23508856e-01f, -1.22054130e-01f, 9.53926444e-02f, -1.78741008e-01f, 1.52886242e-01f, -1.44511387e-01f,
  2.78167635e-01f, 3.86084840e-02f, 7.03497678e-02f, 8.91542062e-02f, -9.89017487e-02f, -8.26345459e-02f, 3.24358821e-01f, 1.05534144e-01f, 1.08933479e-01f, -1.76105618e-01f,
  2.43038964e-02f, 2.20754206e-01f, 3.18286330e-01f, -3.03999614e-02f, 1.41773671e-01f, 1.63671225e-01f, 3.08981687e-01f, 2.23697633e-01f, -2.54144609e-01f, -1.92326885e-02f,
  -1.41039014e-01f, 7.51144141e-02f, 4.68246229e-02f, 7.15260580e-02f, 2.84315366e-02f, 2.32524425e-02f, 9.16895121e-02f, 3.08395833e-01f, 3.07687391e-02f, 5.74614666e-02f,
  5.59840389e-02f, 5.86531423e-02f, 1.53337389e-01f, 1.50196061e-01f, -2.30345875e-02f, 3.60851102e-02f, 6.86925650e-02f, -6.79322481e-02f, 1.65041447e-01f, 6.12171665e-02f,
  4.64667752e-02f, -9.51880068e-02f, 8.12136233e-02f, -1.06879428e-01f, 9.02595520e-02f, 2.25713611e-01f, 2.63580848e-02f, 1.62705313e-02f, 7.95804337e-02f, -1.13606099e-02f,
  -6.45851120e-02f, -1.36980310e-01f, -1.75084528e-02f, 1.80289924e-01f, -1.38128102e-01f, -1.89900279e-01f, 1.00381918e-01f, 3.12672462e-03f, 1.99529544e-01f, -1.63520217e-01f,
  9.55463946e-02f, 5.49497604e-02f, 1.17158204e-01f, -7.19815679e-03f, 1.87334895e-01f, -4.06877175e-02f, -2.01071631e-02f, -3.81575137e-01f, 4.31484580e-01f, -1.41911551e-01f,
  5.99119216e-02f, -2.67280340e-01f, -1.08766764e-01f, 3.65044437e-02f, -1.02892876e-01f, -1.40838832e-01f, -7.33565399e-03f, -1.01046287e-01f, -2.98112333e-02f, 3.94175559e-01f,
  -3.33349973e-01f, -1.04333207e-01f, -1.01790436e-01f, 1.76694393e-01f, -3.42480792e-03f, 7.63334408e-02f, -4.45930809e-01f, 1.47537127e-01f, 5.18944487e-03f, 1.35003641e-01f,
  -5.11824042e-02f, 1.39552308e-02f, 1.45178437e-01f, 8.87650698e-02f, 1.06323600e-01f, 8.46487656e-02f, 4.48561572e-02f, -7.87363574e-02f, 1.35081753e-01f, 1.26804277e-01f,
  1.54265344e-01f, 1.36927292e-01f, 3.66156921e-02f, 3.96788493e-02f, 1.00943998e-01f, 1.06402494e-01f, 1.79066852e-01f, -2.46578887e-01f, -2.54938975e-02f, 9.40987766e-02f,
  3.52014154e-02f, -2.03328788e-01f, -7.04488009e-02f, 4.56344001e-02f, 2.70210020e-03f, 1.35980323e-01f, 1.75367445e-02f, -2.72253484e-01f, -1.26902506e-01f, 3.39020133e-01f,
  1.13343403e-01f, -1.55316144e-01f, -3.09570640e-01f, 2.79370487e-01f, 8.96110311e-02f, 6.14834204e-02f, -2.06469506e-01f, -6.30557314e-02f, -2.03746080e-01f, -1.06467091e-01f,
  7.26490319e-02f, 3.40329558e-01f, -1.60249472e-01f, -5.70710413e-02f, -1.07646873e-02f, -1.15900859e-01f, 3.60451341e-02f, -2.64829278e-01f, 1.49727866e-01f, -8.37260634e-02f,
  -1.84744105e-01f, 3.12262326e-01f, -1.51365981e-01f, -1.73684984e-01f, 1.78788662e-01f, 1.14427775e-03f, -1.21970233e-02f, -2.23726153e-01f, 1.76275805e-01f, -2.04011053e-01f,
  -1.12224758e-01f, 7.36385733e-02f, 1.14803813e-01f, 6.77982941e-02f, 3.22185876e-03f, 1.02476723e-01f, -1.39534101e-01f, 4.55150865e-02f, -7.69861788e-02f, 1.40719563e-01f,
  6.69043288e-02f, 1.35148004e-01f, -9.51294508e-03f, 1.05153464e-01f, 4.03142050e-02f, 8.02883133e-02f, 3.04052327e-03f, 9.42287669e-02f, 8.29457119e-02f, 7.42707923e-02f,
  -1.62647963e-01f, 2.19953880e-01f, 4.55466732e-02f, -5.87515682e-02f, -1.87673956e-01f, 3.17742117e-02f, 9.74306986e-02f, 1.74003497e-01f, 1.31358773e-01f, -6.14396408e-02f,
  -1.88796088e-01f, 1.06004439e-01f, 4.79212143e-02f, 1.19103305e-02f, -4.21307161e-02f, 7.32416660e-02f, 1.43357858e-01f, 1.71969339e-01f, 5.42904548e-02f, 8.66333172e-02f,
  1.68982968e-01f, -2.22964555e-01f, 3.13674271e-01f, 2.14911297e-01f, -1.74693882e-01f, -2.02499986e-01f, 3.60649228e-01f, 1.98747069e-01f, 1.25229910e-01f, 1.03642143e-01f,
  -2.83033121e-02f, -1.76868811e-01f, -1.11128837e-01f, -1.89905260e-02f, -2.22001731e-01f, -1.88467279e-02f, 6.65414184e-02f, 4.35528643e-02f, 1.71021417e-01f, 3.29615831e-01f,
  2.24435061e-01f, 1.38864025e-01f, -3.35224450e-01f, 5.00066094e-02f, 4.95308340e-01f, -1.86153546e-01f, 5.92054613e-02f, 9.48381796e-02f, 9.94159207e-02f, 3.01561877e-02f,
  3.84188220e-02f, 1.76709771e-01f, -2.07073055e-02f, -5.57145365e-02f, 1.20170042e-02f, -5.60404323e-02f, 1.47438273e-01f, 1.23577155e-01f, 1.52894706e-01f, 7.24296048e-02f,
  2.52413511e-01f, 1.52666152e-01f, 5.01666740e-02f, 4.62210998e-02f, 5.47105148e-02f, 4.61237021e-02f, 3.47350910e-02f, 5.56148849e-02f, 4.84956952e-04f, 6.47218078e-02f,
  -1.66314319e-01f, 1.41299099e-01f, 7.24868774e-02f, 1.31752759e-01f, -1.06934734e-01f, 2.13337317e-01f, -8.25931970e-03f, 1.37191653e-01f, 7.55052939e-02f, 6.26327544e-02f,
  6.06560037e-02f, -7.93678090e-02f, -1.21666782e-01f, -1.41024292e-01f, -1.07774489e-01f, 1.03698038e-01f, -3.83116931e-01f, 1.30035430e-01f, 1.68390572e-01f, -2.41769671e-01f,
  -4.81416322e-02f, 3.14067081e-02f, -2.58220196e-01f, -2.20614523e-01f, -1.67715311e-01f, 1.56504497e-01f, -8.56573731e-02f, -1.99180264e-02f, -1.48946896e-01f, 2.40895465e-01f,
  1.64950371e-01f, -7.71249756e-02f, 9.79782734e-03f, -1.07563078e-01f, -2.28270113e-01f, -3.05408183e-02f, 6.23857565e-02f, 1.60316139e-01f, -7.17967451e-01f, 2.66458154e-01f,
  8.69733542e-02f, -8.08231607e-02f, -2.14075595e-01f, -9.66054574e-02f, 5.82832703e-03f, -3.64148640e-03f, -8.56773034e-02f, -5.83041795e-02f, 7.29141384e-02f, 6.81710243e-02f,
  7.87833333e-02f, -1.78470403e-01f, -2.70788148e-02f, -3.26223783e-02f, -5.52607812e-02f, -1.07120477e-01f, -1.62903562e-01f, -5.21859936e-02f, 5.37153222e-02f, -1.00490630e-01f,
  -2.08433270e-02f, 1.88884333e-01f, 1.19012475e-01f, -9.04664323e-02f, -4.33423091e-03f, -1.52764544e-02f, 9.64390561e-02f, 3.81813012e-02f, 7.31024966e-02f, 1.54721498e-01f,
  -4.79753315e-02f, -1.68687880e-01f, 5.43383602e-03f, -6.09449372e-02f, 1.44848764e-01f, -1.04070604e-01f, 1.14532776e-01f, -6.41602799e-02f, 2.65860021e-01f, -1.09876297e-01f,
  7.80986995e-02f, 1.56646207e-01f, 8.29274580e-02f, 1.09256342e-01f, -7.47972280e-02f, 1.88838571e-01f, 1.82479545e-01f, 1.16302632e-01f, -6.53260276e-02f, -5.66172712e-02f,
  1.74694136e-01f, 6.05300628e-02f, -4.47464697e-02f, -1.24621034e-01f, 2.11801797e-01f, 2.78761480e-02f, 1.09527431e-01f, -2.46343419e-01f, -5.43614551e-02f, 1.90048628e-02f,
  -1.39017319e-02f, 1.84557378e-01f, 1.19944461e-01f, -2.37397365e-02f, -7.44710909e-03f, 2.15137061e-02f, -3.32205854e-02f, -8.42334051e-03f, 9.94208902e-02f, -1.69361439e-02f,
  5.41601330e-02f, -2.43851207e-02f, 9.02122781e-02f, 5.87120373e-03f, 2.93518081e-02f, -4.82487604e-02f, 5.11435457e-02f, 1.87868644e-02f, 7.17727169e-02f, 8.45182166e-02f,
  7.91961849e-02f, 1.19294621e-01f, 9.28448886e-02f, 2.44390592e-03f, -1.40849659e-02f, 1.04535900e-01f, 4.86789420e-02f, 1.42214507e-01f, -3.63688692e-02f, 1.71286002e-01f,
  1.22186825e-01f, 3.64708230e-02f, 5.12116551e-02f, 2.49033928e-01f, -5.53880222e-02f, -1.12970226e-01f, 1.50997519e-01f, 4.84948829e-02f, 2.89322317e-01f, -2.12351173e-01f,
  4.60817814e-02f, 1.66653767e-01f, 1.81729421e-01f, 6.35840185e-03f, -1.15479559e-01f, 7.18061393e-03f, 7.65803158e-02f, -1.87520340e-01f, 1.44031703e-01f, -1.94821119e-01f,
  -1.41871080e-01f, -9.99931470e-02f, -1.68359548e-01f, 2.26816107e-02f, -1.33618964e-02f, 2.71529052e-02f, -1.30384535e-01f, 5.80420606e-02f, 1.18188754e-01f, -1.39096202e-02f,
  -1.23032689e-01f, -2.68441290e-01f, -1.14147596e-01f, -3.56479809e-02f, -5.82780652e-02f, 2.91748345e-01f, 7.30873719e-02f, 8.31580348e-03f, -4.43934575e-02f, 2.21668616e-01f,
  1.08949365e-02f, 1.36682391e-01f, 4.94892569e-03f, 5.07415719e-02f, 1.27321154e-01f, 1.89263389e-01f, 4.78579067e-02f, -6.93084151e-02f, 7.60871470e-02f, 9.57903042e-02f,
  -9.43092629e-02f, 8.82387608e-02f, 7.42481649e-02f, 1.37606546e-01f, -1.13739744e-02f, 4.88305874e-02f, -2.85816621e-02f, 1.61860302e-01f, 3.18280011e-02f, -2.82302946e-01f,
  -2.75987089e-01f, -7.73469955e-02f, -1.83770619e-02f, 9.91375670e-02f, -2.70016976e-02f, 5.31832650e-02f, -1.52851835e-01f, 4.41394262e-02f, -1.56306937e-01f, -1.60333931e-01f,
  5.28895855e-02f, -1.40265077e-01f, -1.35137737e-01f, 2.95109302e-01f, 8.99584070e-02f, 4.29565549e-01f, 8.50618258e-02f, -1.04208879e-01f, -3.71375158e-02f, -8.29341710e-02f,
  -3.29228550e-01f, -3.27705681e-01f, 1.87504783e-01f, 3.39880347e-01f, -3.00808400e-02f, -1.41014278e-01f, -3.58401865e-01f, 1.32081136e-01f, -2.04057142e-01f, -1.38395399e-01f,
  -1.82913095e-01f, -7.43249804e-02f, -6.26995927e-03f, -3.23950469e-01f, -2.89897829e-01f, -2.17272695e-02f, 2.08380520e-01f, -2.08557080e-02f, -9.69658270e-02f, -2.99019843e-01f,
  3.04176956e-01f, -2.62139440e-01f, 7.95975402e-02f, 9.21074748e-02f, -3.48353088e-02f, 1.99332926e-02f, 2.35258341e-02f, 7.37140104e-02f, 5.40131070e-02f, 1.64911821e-01f,
  -4.87035650e-05f, 8.55152607e-02f, 3.74922827e-02f, -4.94383201e-02f, -2.45806322e-01f, -5.17029315e-02f, 5.50773218e-02f, 3.31045152e-03f, 2.31617376e-01f, 5.06733917e-02f,
  7.26069137e-02f, 7.64656514e-02f, -1.84857190e-01f, 9.34438556e-02f, -1.29742756e-01f, 2.02330172e-01f, 1.50570482e-01f, -1.21276468e-01f, 1.45346209e-01f, -1.96192548e-01f,
  1.95882082e-01f, 7.76443928e-02f, -1.22501682e-02f, 3.00530475e-02f, 1.67391092e-01f, -4.76137400e-02f, 3.07357430e-01f, -1.93670511e-01f, -2.52565086e-01f, -3.06553304e-01f,
  2.96154618e-01f, 4.18681726e-02f, 2.13227734e-01f, -2.16367081e-01f, -3.20191421e-02f, -2.64523625e-02f, -1.54405832e-01f, 1.33736208e-01f, 2.20853716e-01f, 1.50800794e-01f,
  -6.15854328e-03f, -3.76813531e-01f, -6.86935410e-02f, 1.81596294e-01f, 2.45688751e-01f, -1.54229090e-01f, -4.49824817e-02f, 9.92777273e-02f, 1.42253116e-01f, 3.48629057e-01f,
  1.53165698e-01f, -2.73861233e-02f, -1.64106131e-01f, 1.73584849e-01f, 5.24228394e-01f, -3.01531315e-01f, 6.04054928e-02f, 3.98144461e-02f, 2.17439476e-02f, 6.61821961e-02f,
  1.02494985e-01f, 3.82643170e-03f, 2.60779075e-03f, 1.41942173e-01f, 2.87788212e-01f, -1.96666233e-02f, -1.06411949e-01f, 1.06724374e-01f, 1.89466290e-02f, -4.78487834e-02f,
  9.59282517e-02f, 1.50524050e-01f, 8.91761705e-02f, 1.17813997e-01f, 1.50498688e-01f, 1.20768145e-01f, -9.20967944e-03f, 6.26221299e-02f, 1.52217075e-01f, -1.02764405e-01f,
  -1.09823488e-01f, -9.32242721e-02f, 1.87065139e-01f, -8.40244889e-02f, -1.85292169e-01f, 3.28259394e-02f, -2.38575280e-01f, -6.09118305e-02f, -1.65358767e-01f, 1.85464069e-01f,
  3.11387748e-01f, -1.28292248e-01f, 3.44533056e-01f, -4.84208241e-02f, 3.62133324e-01f, -3.32173795e-01f, -3.72870296e-01f, 3.31747308e-02f, 3.35402079e-02f, -1.23097599e-01f,
  3.26472640e-01f, 2.68724114e-01f, -2.42101997e-01f, -1.59256250e-01f, -2.14284837e-01f, -2.59371530e-02f, -6.65655658e-02f, -4.65502739e-02f, -5.11017561e-01f, 1.78404391e-01f,
  2.36866906e-01f, -7.48175830e-02f, 1.29431397e-01f, -9.05876011e-02f, -1.29911706e-01f, 1.60836250e-01f, 4.89128679e-02f, 2.15094835e-01f, -2.75682092e-01f, 1.79737143e-03f,
  2.70446617e-04f, 2.24701002e-01f, 8.14751163e-02f, 8.64409059e-02f, 2.17308566e-01f, 9.57170129e-02f, 7.76673481e-02f, 8.85489434e-02f, -5.50399832e-02f, -1.80912409e-02f,
  2.70751178e-01f, 2.53511161e-01f, 1.32520169e-01f, 2.23990366e-01f, 1.36623785e-01f, 1.36100531e-01f, 6.88980753e-03f, 1.96686342e-01f, 1.71511412e-01f, -3.85350347e-01f,
  -3.33425924e-02f, -1.67090222e-01f, -2.84673646e-02f, -4.52137850e-02f, -1.72381163e-01f, -1.67628806e-02f, -2.30445087e-01f, 1.91770509e-01f, 4.38902788e-02f, -1.97568119e-01f,
  1.26731798e-01f, 1.58759505e-01f, 1.66540161e-01f, -1.41965553e-01f, -4.42989856e-01f, 2.86881596e-01f, -8.10571313e-02f, 2.13593781e-01f, -2.02643275e-01f, 5.25432587e-01f,
  -9.01381075e-02f, -2.53234003e-02f, -4.99387719e-02f, 3.50539312e-02f, -3.73713017e-01f, -1.16499849e-02f, 9.31720734e-02f, -2.75692474e-02f, 9.67489779e-02f, -1.50298653e-02f,
  1.01852633e-01f, -2.18663916e-01f, 7.54768178e-02f, -2.99641907e-01f, -9.62427557e-02f, 1.22332498e-01f, -1.14125304e-01f, -1.67698190e-01f, 1.04456492e-01f, -2.27400661e-01f,
  7.79863372e-02f, -1.86361223e-01f, -6.88238665e-02f, 2.53301263e-01f, 3.08363438e-02f, 8.83550495e-02f, 2.04189226e-01f, 1.91101432e-01f, 4.94504720e-02f, -1.34716788e-02f,
  1.36360541e-01f, -7.10518956e-02f, 2.70506114e-01f, 1.61074057e-01f, 6.22824021e-02f, 2.50546306e-01f, 2.66835280e-02f, 5.08702546e-02f, 1.62042454e-01f, 5.66714928e-02f,
  1.69246256e-01f, -8.80531594e-02f, 1.15388781e-01f, 1.90896824e-01f, -4.55291383e-02f, 1.73559323e-01f, -9.90810096e-02f, 1.24447513e-02f, 2.02520356e-01f, -1.51779339e-01f,
  -4.04670462e-03f, -2.93372810e-01f, 1.31017314e-02f, -1.75551951e-01f, -2.59775132e-01f, 2.08375424e-01f, -2.02897564e-01f, 1.18029393e-01f, 3.75204653e-01f, -3.49484861e-01f,
  2.21951127e-01f, -3.18215162e-01f, 6.47828653e-02f, -4.57146168e-02f, 2.04286829e-01f, -3.15563142e-01f, -1.05989121e-01f, -1.25716627e-01f, 3.97938937e-01f, -1.60710365e-01f,
  1.53194755e-01f, -2.50828683e-01f, -1.86258972e-01f, -4.75511476e-02f, -3.89514923e-01f, 3.36708501e-02f, 9.67679247e-02f, 3.38036381e-02f, -3.29908431e-02f, 2.76683062e-01f,
  9.40416977e-02f, 2.15204179e-01f, -3.24518234e-01f, -1.98696941e-01f, -1.08446933e-01f, 5.35069080e-03f, -7.60184005e-02f, -2.05623433e-01f, 6.33444935e-02f, 3.74355875e-02f,
  1.38440564e-01f, 1.90526694e-01f, 1.06193878e-01f, 9.69848186e-02f, 7.86581486e-02f, 5.98044880e-02f, 1.39025480e-01f, -4.69287969e-02f, 1.26888245e-01f, 1.37540027e-01f,
  -1.02849700e-01f, 2.05413267e-01f, 8.42488259e-02f, 5.16313389e-02f, -4.18545194e-02f, 1.65774412e-02f, 3.38908806e-02f, -3.43183894e-03f, -1.78672343e-01f, 3.03237066e-02f,
  -8.18874761e-02f, 1.63106546e-01f, 7.49865845e-02f, -2.50791889e-02f, -9.50486884e-02f, -2.53327817e-01f, 3.88239957e-02f, 1.65855020e-01f, 5.63980900e-02f, -1.29613727e-01f,
  6.04603300e-03f, -4.17253897e-02f, 6.01704158e-02f, -2.99043834e-01f, -1.13460869e-02f, -8.64327792e-03f, -1.50378319e-02f, 1.88166037e-01f, 4.82767113e-02f, -3.76287848e-02f,
  8.72700363e-02f, -2.00570732e-01f, 4.22824502e-01f, -5.68173863e-02f, -9.05377865e-02f, -1.18277982e-01f, -9.34939831e-02f, 1.40058458e-01f, -2.19102219e-01f, -1.99736074e-01f,
  -1.78299934e-01f, -5.09325027e-01f, 7.99469277e-02f, 1.75610989e-01f, -4.68074173e-01f, -3.60608548e-01f, -7.76219890e-02f, 8.82808194e-02f, -1.92463383e-01f, 8.26532580e-03f,
  -6.23700440e-01f, 2.94448942e-01f, 5.10798171e-02f, 2.17537910e-01f, -8.16763937e-02f, 1.38873383e-01f, 2.10065350e-01f, 8.78286362e-02f, 4.68817279e-02f, 1.91085860e-01f,
  -1.10201523e-01f, 4.18584533e-02f, 2.65330255e-01f, 1.64768636e-01f, 2.36581117e-01f, 7.48005286e-02f, 1.09068558e-01f, 1.77800253e-01f, 1.35947660e-01f, 7.61262625e-02f,
  5.78644574e-02f, -7.33964220e-02f, 1.53072514e-02f, -1.33630782e-01f, 1.24586895e-01f, 1.89682484e-01f, -1.67519122e-01f, 6.51535541e-02f, 5.00652492e-02f, -7.70983249e-02f,
  -2.05633938e-02f, 1.18188858e-01f, 1.56132644e-02f, -1.42138317e-01f, 1.74071580e-01f, 3.32917273e-02f, -1.56249508e-01f, 7.81881437e-02f, -2.02848136e-01f, 2.00782716e-02f,
  1.53959274e-01f, 4.66654181e-01f, -1.38698611e-03f, -2.00881645e-01f, -8.55680257e-02f, 6.36984557e-02f, -2.98610806e-01f, -1.63315371e-01f, 3.03137079e-02f, 2.74860084e-01f,
  1.02492377e-01f, -2.16135144e-01f, 3.23148482e-02f, 1.40698791e-01f, 2.82343142e-02f, -2.48888209e-01f, 7.16971755e-02f, 2.10214451e-01f, -1.85739487e-01f, -1.69164594e-02f,
  -2.65364833e-02f, -9.53009054e-02f, -5.43189384e-02f, 8.18068758e-02f, 2.01118037e-01f, 1.74819484e-01f, 1.71566784e-01f, 1.41721889e-01f, 1.90364525e-01f, -7.60692358e-02f,
  1.11730024e-01f, -7.74303870e-03f, 9.17364135e-02f, 7.23683164e-02f, 2.29217559e-01f, 3.72322127e-02f, -2.85674315e-02f, -6.23761378e-02f, 1.80984028e-02f, 7.82508850e-02f,
  2.20775068e-01f, 9.05557573e-02f, 7.85457566e-02f, 2.35807449e-01f, 3.49185258e-01f, -9.53489691e-02f, 2.20318083e-02f, 6.21512495e-02f, 6.04438893e-02f, -1.45128265e-01f,
  -1.09976284e-01f, -4.64341193e-02f, 9.78854150e-02f, 1.47865489e-01f, 1.21157793e-02f, 1.20238781e-01f, 1.91772990e-02f, -6.31606877e-02f, 5.41013069e-02f, 1.63972795e-01f,
  1.54515594e-01f, -1.07784785e-01f, -1.02017273e-03f, -6.43690825e-02f, 1.94730759e-01f, 1.56672642e-01f, 2.27270927e-02f, -2.94641078e-01f, 1.58585295e-01f, 1.99603066e-01f,
  6.26309365e-02f, -1.32801101e-01f, 1.28077308e-03f, -2.45341316e-01f, -1.30948133e-03f, -1.94890067e-01f, -6.32181019e-02f, -1.19570486e-01f, -6.25591800e-02f, 1.56715497e-01f,
  2.04117253e-01f, 1.57147080e-01f, 1.08162488e-03f, -4.45075445e-02f, -3.72587413e-01f, -7.12149218e-02f, 1.66297164e-02f, 1.33183420e-01f, -5.44081807e-01f, 2.92061538e-01f,
  6.34541512e-02f, -2.06960775e-02f, -5.43205477e-02f, -1.13428943e-01f, -2.69670159e-01f, -1.70492753e-02f, 5.78623675e-02f, 2.12654825e-02f, -9.84051153e-02f, -6.03835508e-02f,
  -4.77175564e-02f, -4.53796461e-02f, 5.84844239e-02f, -1.21733047e-01f, 1.53867444e-02f, 1.33518532e-01f, 1.44402012e-02f, -1.23175584e-01f, -9.70332026e-02f, 4.96112555e-02f,
  -2.67263293e-01f, 3.25527824e-02f, -1.99575305e-01f, 3.02738577e-01f, 2.20515370e-01f, 1.23223715e-01f, -3.27361226e-02f, -1.29739940e-01f, 2.27472559e-01f, -1.79673329e-01f,
  -6.94619343e-02f, 2.39505544e-01f, -5.65997139e-02f, -2.25383490e-01f, -1.03576221e-01f, -1.34740800e-01f, -3.40253115e-01f, -3.10713679e-01f, -4.06302452e-01f, -1.31885022e-01f,
  5.57935908e-02f, -5.70369698e-02f, -4.97198477e-02f, -1.37547720e-02f, -2.20019251e-01f, 6.02579005e-02f, 4.40414362e-02f, -2.32929826e-01f, -2.12901741e-01f, 2.55973414e-02f,
  -2.51809508e-01f, -1.37270957e-01f, -9.25694630e-02f, -2.39550948e-01f, -1.78540479e-02f, 2.28656903e-01f, -6.72270954e-02f, 2.60818750e-01f, -2.52093762e-01f, 2.65404642e-01f,
  2.60844212e-02f, 6.36804402e-02f, 5.27356565e-02f, -1.50735348e-01f, -4.76391390e-02f, 1.53690293e-01f, 5.89344949e-02f, 1.64644852e-01f, 4.89448532e-02f, 1.49797285e-02f,
  -1.34485238e-03f, 1.98901936e-01f, 1.25124201e-01f, 8.74368772e-02f, 7.19432905e-02f, -1.44731975e-03f, 8.56656656e-02f, 9.63981748e-02f, -9.44678392e-03f, 1.63192060e-02f,
  8.67886841e-02f, -2.77492013e-02f, 1.49541674e-03f, 9.01982933e-02f, -2.17233412e-02f, -6.05838783e-02f, 9.92233492e-03f, -3.76053713e-02f, 6.70706481e-03f, 2.01603658e-02f,
  -4.84450981e-02f, -8.04247782e-02f, -4.36771512e-02f, 1.90393895e-01f, -6.23405166e-02f, 3.89567800e-02f, -2.60442756e-02f, 1.18273020e-01f, 2.12220341e-01f, -2.42088303e-01f,
  2.41459012e-02f, 6.87835887e-02f, 2.39499316e-01f, -1.34314924e-01f, -1.65784627e-01f, 1.93657979e-01f, 9.53088105e-02f, -1.89171821e-01f, 4.73514885e-01f, -7.72244781e-02f,
  -4.50882269e-03f, -9.42595303e-02f, -2.79262275e-01f, 3.64256501e-01f, -6.23279102e-02f, 8.30232352e-02f, -2.28292674e-01f, 8.21589082e-02f, 1.53883487e-01f, -2.42766678e-01f,
  4.30594804e-03f, -1.61369041e-01f, -1.23400047e-01f, 6.93331510e-02f, 6.38432056e-03f, 2.95468509e-01f, -2.65977800e-01f, 1.40389249e-01f, 3.99420261e-02f, 5.88450171e-02f,
  -6.99006766e-02f, -5.31320982e-02f, -1.51567496e-02f, 9.25641954e-02f, 2.98034046e-02f, 1.04956608e-02f, 7.47507857e-03f, -6.81514591e-02f, 5.16045205e-02f, -1.90343708e-01f,
  -4.04096860e-03f, 6.31402899e-03f, -2.37824339e-02f, 6.76854700e-02f, 1.05489515e-01f, 6.18915930e-02f, -4.80603660e-03f, -8.93139467e-03f, 2.67009307e-02f, -1.42781451e-01f,
  1.30239679e-02f, 9.04883072e-02f, -2.01658607e-01f, 1.73370168e-01f, 8.04629102e-02f, -6.77148104e-02f, 1.99028244e-03f, 1.73643231e-01f, -3.76343019e-02f, -2.49366954e-01f,
  -3.49515304e-02f, -6.82650879e-02f, -8.46163090e-03f, -3.41626167e-01f, -1.71553660e-02f, 1.49741724e-01f, 3.26106578e-01f, 1.10381968e-01f, -6.56728968e-02f, 7.26387426e-02f,
  1.08690836e-01f, -7.71981254e-02f, -5.82645237e-02f, -2.57787164e-02f, -2.42723599e-01f, -7.40896538e-02f, -2.19965115e-01f, 2.76008010e-01f, 7.47882994e-03f, 1.27973109e-01f,
  4.78364453e-02f, -1.77528381e-01f, 2.85609931e-01f, 1.15796313e-01f, 2.68941093e-02f, -3.09942335e-01f, -1.72055483e-01f, -9.75911692e-02f, -2.50202175e-02f, 2.90071338e-01f,
  -3.67778167e-02f, 1.62357971e-01f, 3.55474167e-02f, 1.66472808e-01f, 1.38719350e-01f, 8.09740499e-02f, -4.29833727e-03f, -1.90711245e-01f, 5.84155368e-03f, 7.42488774e-03f,
  1.06660739e-01f, -3.23932432e-02f, 3.89791690e-02f, -1.58094659e-01f, -1.58233475e-02f, 7.59885982e-02f, 2.16439188e-01f, 1.86264366e-02f, 7.51574412e-02f, 1.34380609e-01f,
  1.34294853e-01f, -1.19114786e-01f, -4.71987315e-02f, -7.64663666e-02f, 1.67107418e-01f, -4.31662314e-02f, -1.08383946e-01f, 1.59294918e-01f, 8.80920216e-02f, 1.88432280e-02f,
  -8.72207806e-02f, 7.94858262e-02f, -8.06021467e-02f, -2.91754842e-01f, 4.73112427e-02f, 8.69794860e-02f, -9.95513201e-02f, 1.71095226e-02f, -1.29884079e-01f, -5.54242954e-02f,
  2.22808912e-01f, -1.36830240e-01f, -2.87064761e-01f, -1.91363811e-01f, 1.59747958e-01f, 1.86869279e-01f, 5.71196191e-02f, -2.14721411e-01f, -2.84065455e-02f, -6.78096935e-02f,
  -8.81190971e-02f, -1.87352262e-02f, 1.31997824e-01f, 9.68206748e-02f, -2.85682052e-01f, 1.28423735e-01f, 2.71693259e-01f, -6.46370649e-02f, 2.18783706e-01f, 8.02791044e-02f,
  -1.54094502e-01f, -1.07514784e-01f, 1.23679630e-01f, 1.51647195e-01f, -1.61855355e-01f, 1.27190307e-01f, 9.89910439e-02f, 9.79392603e-03f, -4.70124967e-02f, 8.84712953e-03f,
  1.30949348e-01f, 4.52592634e-02f, 2.26862416e-01f, -4.97955345e-02f, 1.56884074e-01f, 1.74509976e-02f, -1.28647294e-02f, -1.27991801e-02f, 6.99426085e-02f, 3.64169329e-02f,
  1.02417484e-01f, -6.39771521e-02f, 2.53617968e-02f, -5.61628975e-02f, 6.32760972e-02f, 3.46366242e-02f, 5.09904400e-02f, 5.86793423e-02f, 1.07144557e-01f, -3.23390335e-01f,
  2.57931538e-02f, -2.30211839e-02f, 8.66098925e-02f, 3.16752642e-02f, -1.07329540e-01f, 3.07946838e-02f, -1.52478188e-01f, 4.99668047e-02f, -5.33951335e-02f, 1.85195968e-01f,
  1.54490978e-01f, -8.31581652e-02f, 1.05060928e-01f, -1.69178054e-01f, 4.87767048e-02f, -2.63909072e-01f, -5.73105849e-02f, 1.57927826e-01f, -1.83128882e-02f, -5.66240102e-02f,
  6.86837882e-02f, 4.09955606e-02f, 4.60948311e-02f, -2.19277501e-01f, -2.11153701e-01f, 1.99599475e-01f, 5.91414347e-02f, -4.22614403e-02f, -5.94166853e-02f, 4.55106616e-01f,
  1.99374869e-01f, -2.77865648e-01f, 2.47094214e-01f, 1.72832850e-02f, -3.37912410e-01f, -4.53346409e-02f, 2.43406937e-01f, 6.41873553e-02f, -2.23776713e-01f, -2.95771539e-01f,
  8.36110264e-02f, 2.18280092e-01f, 3.86278436e-04f, 1.10376269e-01f, 5.93390875e-02f, 1.03304841e-01f, -1.33553222e-01f, 2.21736766e-02f, 6.56165555e-02f, 8.36116895e-02f,
  3.35754491e-02f, 1.02284603e-01f, -2.12186184e-02f, -1.25428792e-02f, -2.73109935e-02f, 6.36034161e-02f, 8.08999911e-02f, 5.06006144e-02f, 1.17509738e-01f, -9.71146300e-02f,
  2.16923282e-03f, 2.67862193e-02f, 1.31857842e-01f, -2.96436958e-02f, -6.17149398e-02f, 3.14788334e-02f, 6.56929938e-03f, 2.16608047e-02f, -4.52384539e-02f, -6.21561781e-02f,
  -5.06354384e-02f, 2.54812360e-01f, 1.02892056e-01f, 1.24297000e-01f, -1.74665496e-01f, 2.04405457e-01f, -5.59445061e-02f, -6.70618787e-02f, -1.18992060e-01f, 1.97422951e-01f,
  1.76434249e-01f, 6.92113191e-02f, -1.97681524e-02f, 2.03196958e-01f, -2.43793756e-01f, -1.55143455e-01f, 1.36323437e-01f, 2.16570064e-01f, 2.12462366e-01f, -5.19730337e-02f,
  1.99401498e-01f, 8.84338245e-02f, 9.86560136e-02f, -2.08272204e-01f, -7.85875991e-02f, -1.22363880e-01f, -6.90500885e-02f, 1.26661181e-01f, -5.06815314e-02f, 1.18688876e-02f,
  -1.55814439e-01f, -8.38522837e-02f, 4.45967466e-01f, -7.09243864e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.94013029e-01f, 5.92247769e-02f, 8.50729346e-02f, 3.64578217e-02f, 4.21063229e-02f, -2.75574997e-03f, -4.12172899e-02f, -4.53020521e-02f, 2.07938790e-01f, 1.18771829e-01f,
  -2.70668585e-02f, 6.38670772e-02f, 1.95429847e-01f, 7.81808943e-02f, 4.49459553e-02f, 1.44554988e-01f, 2.43517105e-02f, 4.97374404e-03f, -6.80132657e-02f, 7.08526149e-02f,
  1.63174778e-01f, 2.78885197e-03f, -1.49116307e-01f, 2.62515917e-02f, 6.43322393e-02f, 6.76287897e-03f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.89801287e-02f, 1.44712448e-01f, 1.85810894e-01f, -1.44109279e-01f, 1.55746043e-01f, -1.43196344e-01f, -2.34009903e-02f, -1.91037714e-01f, 1.75680920e-01f, 2.93430537e-01f,
  -1.07171081e-01f, -1.47944584e-01f, 1.08228482e-01f, 9.21485499e-02f, 1.21280201e-01f, -2.80200094e-02f, 3.21144998e-01f, -9.80709493e-03f, -1.05007730e-01f, 8.60564858e-02f,
  2.48519093e-01f, -3.82290818e-02f, 4.85911518e-02f, -1.17611945e-01f, -2.63092279e-01f, -1.58728451e-01f, -2.71346644e-02f, 1.94414273e-01f, 3.45668532e-02f, 1.22864135e-01f,
  9.05761868e-02f, 3.04745585e-01f, -2.75583059e-01f, 3.76432240e-02f, 2.43650064e-01f, 1.05672844e-01f, 1.67782277e-01f, 3.40908855e-01f, 2.73955036e-02f, 1.12507880e-01f,
  8.67652595e-02f, 3.53962123e-01f, 1.93881869e-01f, 1.30265236e-01f, -1.27396509e-01f, 1.35123804e-01f, 1.50464419e-02f, -5.48202731e-02f, 2.52011865e-02f, -1.89512933e-03f,
  7.27276206e-02f, -1.30358979e-01f, -1.19098499e-02f, 2.75094897e-01f, -3.70038778e-01f, 1.56844836e-02f, 9.18588340e-02f, 6.16448820e-02f, -1.79761097e-01f, -2.27896869e-01f,
  -3.45163443e-03f, 9.88253355e-02f, -2.12140933e-01f, -7.44801611e-02f, -4.31238785e-02f, -1.03608575e-02f, -8.92223865e-02f, -9.34083313e-02f, 1.36531238e-03f, 1.42356008e-01f,
  4.29410953e-03f, 1.46826431e-01f, -2.23218322e-01f, 1.27344325e-01f, -1.16336614e-01f, -4.12485823e-02f, 2.09375530e-01f, -7.50985183e-03f, 8.86034220e-02f, 1.20512350e-02f,
  4.10304181e-02f, 3.96976709e-01f, 1.77314833e-01f, -2.55371127e-02f, 1.84224278e-01f, 6.93515223e-03f, 1.58787966e-01f, -3.13920945e-01f, -2.83575524e-02f, -1.36751816e-01f,
  1.17031209e-01f, -2.26269454e-01f, 2.65497983e-01f, 2.39469528e-01f, -2.79985238e-02f, -7.87519515e-02f, -3.56759787e-01f, -1.14596382e-01f, -1.93962023e-01f, -4.43033315e-02f,
  -2.08708271e-02f, 2.99619943e-01f, -1.06584057e-01f, 9.22183692e-02f, -3.97758596e-02f, -5.79615170e-03f, -1.64526567e-01f, 2.30330020e-01f, 8.59392732e-02f, -4.44885492e-02f,
  -4.67716344e-02f, -3.86046991e-02f, 7.41488859e-03f, -4.55151983e-02f, -1.00128904e-01f, -1.09362088e-01f, -2.79149801e-01f, 8.94391015e-02f, -3.02353591e-01f, -9.29321349e-02f,
  -3.07525005e-02f, -1.55402347e-01f, 6.69269189e-02f, 5.60549982e-02f, -1.00794695e-02f, -6.85027614e-02f, 2.32350789e-02f, 2.60285407e-01f, -1.00004801e-03f, 3.45065594e-02f,
  -3.53512391e-02f, 2.69842386e-01f, -2.79675443e-02f, 1.02000035e-01f, 6.24769256e-02f, -2.08182618e-01f, -1.25441387e-01f, -6.05392978e-02f, 2.08140820e-01f, -6.76044300e-02f,
  -7.38229901e-02f, -1.74960688e-01f, 1.51961491e-01f, -2.51325686e-02f, -1.98260862e-02f, 7.51680210e-02f, 8.44859034e-02f, 1.38403982e-01f, 2.31388789e-02f, 5.75632462e-03f,
  1.38418049e-01f, -1.08635621e-02f, 1.43083334e-01f, 2.05417573e-01f, 2.56087720e-01f, -1.90829948e-01f, -2.78888065e-02f, -1.47171602e-01f, -3.81590068e-01f, 1.91827968e-01f,
  1.76348537e-01f, -6.17856793e-02f, 2.18670264e-01f, -1.51924223e-01f, 4.75464249e-03f, 4.83764568e-03f, -2.78914392e-01f, -3.05252969e-01f, -1.01162761e-01f, 1.05967112e-01f,
  -2.75394171e-01f, 5.22551537e-02f, 1.48476362e-01f, -1.51179865e-01f, -1.20371565e-01f, 4.75251898e-02f, 7.12825218e-03f, -9.08080563e-02f, -4.06046249e-02f, 2.68548876e-02f,
  1.28300890e-01f, -6.73727095e-02f, 7.09968582e-02f, 1.21973805e-01f, -5.35990112e-02f, -1.57139860e-02f, 2.93069690e-01f, -3.11318729e-02f, -9.68204811e-02f, -1.35772482e-01f,
  -1.20659231e-03f, 7.30450302e-02f, -1.04216993e-01f, 5.64755127e-02f, -1.67750701e-01f, 1.30814537e-01f, 3.63147222e-02f, -8.25084597e-02f, 9.72319469e-02f, -1.31535247e-01f,
  -5.01584485e-02f, 2.19161082e-02f, 1.88626722e-01f, 6.95110932e-02f, 6.30474165e-02f, 8.82678702e-02f, 5.50684817e-02f, -5.28230853e-02f, -3.09568401e-02f, 1.87685519e-01f,
  1.68819547e-01f, -7.75613040e-02f, 2.28745222e-01f, 2.08492815e-01f, 3.37010920e-02f, 1.55114993e-01f, 1.26450643e-01f, 2.52600876e-03f, -3.25537995e-02f, -1.69212855e-02f,
  2.47973204e-01f, 1.43800527e-01f, -1.22281320e-01f, -2.46709451e-01f, -2.46564791e-01f, -1.72942922e-01f, -1.10218473e-01f, -4.86813150e-02f, 3.54567878e-02f, -1.10990861e-02f,
  -1.05725013e-01f, 1.14145406e-01f, 1.79132357e-01f, -7.88512751e-02f, 2.36273787e-04f, 1.11511759e-01f, 7.46748149e-02f, -1.01203129e-01f, 1.14962921e-01f, -1.05667248e-01f,
  9.16374177e-02f, 6.36990443e-02f, 7.26138651e-02f, 1.65004790e-01f, -1.31655544e-01f, 5.20946532e-02f, -1.16771892e-01f, -6.69083297e-02f, 2.01928049e-01f, 5.34031428e-02f,
  5.60048297e-02f, -4.73237075e-02f, -6.55932724e-03f, -5.44249378e-02f, -2.76291162e-01f, 2.15638995e-01f, 9.98153836e-02f, 1.51935190e-01f, 1.04169644e-01f, 5.14858514e-02f,
  2.02566162e-01f, -1.97915137e-01f, 1.34952620e-01f, 1.97928295e-01f, 2.60073125e-01f, -2.63188425e-02f, 3.64043973e-02f, -1.22660406e-01f, -3.65954153e-02f, 1.26808271e-01f,
  8.49198699e-02f, 1.65368486e-02f, 2.84131557e-01f, 9.25120786e-02f, 1.38120115e-01f, 2.48177230e-01f, 4.38664444e-02f, -3.18297930e-02f, -4.84712236e-02f, 1.43820554e-01f,
  1.90055706e-02f, -1.54313341e-01f, 2.34849751e-01f, 2.11912811e-01f, -2.10175976e-01f, 6.74190819e-02f, 8.00155476e-02f, -6.16658991e-03f, -2.45474502e-02f, -8.95909742e-02f,
  3.37317914e-01f, 3.31065387e-01f, 1.75563440e-01f, 4.77649271e-02f, 2.20136002e-01f, 2.83030212e-01f, 6.55829301e-03f, 1.52142286e-01f, 1.64790764e-01f, -3.92117873e-02f,
  -2.32167572e-01f, 3.53185445e-01f, -8.80559981e-02f, 2.25826994e-01f, -1.65420379e-02f, -7.81737939e-02f, -1.25007048e-01f, -1.98887855e-01f, 6.15618899e-02f, 1.31487727e-01f,
  -1.93950891e-01f, -1.07084908e-01f, -6.09499961e-02f, 2.54095495e-01f, -2.58615017e-01f, -1.31885603e-01f, 8.68151858e-02f, 1.01713046e-01f, 8.20364952e-02f, -3.29313725e-02f,
  -7.41155222e-02f, 2.21082434e-01f, 2.21553333e-02f, 6.43015206e-02f, 6.52014986e-02f, 8.84874389e-02f, 2.90356427e-01f, -3.15727070e-02f, 2.05093324e-01f, 2.08840042e-01f,
  1.42119899e-01f, -5.52033782e-02f, -7.59840161e-02f, -5.62562458e-02f, 1.44026503e-01f, 2.43125498e-01f, 1.00171432e-01f, 1.97959825e-01f, -3.20058092e-02f, -2.41876338e-02f,
  -2.84671737e-03f, -2.54439503e-01f, 9.22535360e-03f, 3.58017301e-03f, -1.92490011e-01f, 9.71347000e-03f, 7.99811631e-02f, 1.62898943e-01f, -4.18310985e-02f, -1.24714158e-01f,
  -1.81804955e-01f, -2.10638776e-01f, 1.39437124e-01f, -7.00285211e-02f, 2.00730011e-01f, 1.39555171e-01f, 1.92413121e-01f, 1.57098144e-01f, 1.32757783e-01f, 1.93104893e-02f,
  -2.05755085e-01f, 1.42348915e-01f, 2.03416914e-01f, -2.49956980e-01f, 2.68128440e-02f, -5.45991100e-02f, -1.47614092e-01f, 6.38936162e-02f, -1.22762434e-01f, 1.30339280e-01f,
  2.62970150e-01f, -1.81003064e-01f, -5.43778799e-02f, 1.58957645e-01f, -2.21825808e-01f, 2.29328334e-01f, -4.31104973e-02f, 4.92752157e-02f, 5.55551387e-02f, 1.64997295e-01f,
  1.59307569e-01f, -7.64781535e-02f, -2.24333908e-02f, -8.05549026e-02f, -8.40764791e-02f, -6.36619851e-02f, 2.17751727e-01f, 1.79974049e-01f, -1.05806336e-01f, -1.21763118e-01f,
  -2.11639434e-01f, 1.38355136e-01f, -1.69253692e-01f, -1.33748606e-01f, -1.48907825e-01f, -4.70792800e-02f, 1.09489948e-01f, -1.36842757e-01f, 1.59388319e-01f, 1.07722238e-01f,
  -1.03447035e-01f, -3.40848491e-02f, 9.74425897e-02f, -3.49616110e-02f, -1.24722086e-01f, -1.04245663e-01f, 1.57367960e-01f, 6.73203394e-02f, -3.21114361e-02f, -2.30235636e-01f,
  -2.23991364e-01f, -2.57740676e-01f, -1.48995608e-01f, -3.14198315e-01f, 2.76515514e-01f, 9.18066013e-04f, 4.17550117e-01f, -2.25643143e-02f, -2.20039785e-01f, 1.82941198e-01f,
  1.48054406e-01f, -3.14962342e-02f, -9.41092595e-02f, -1.81449071e-01f, -1.07638970e-01f, -3.06260914e-01f, -2.89867401e-01f, 6.41125739e-02f, 2.42280304e-01f, -1.00243159e-01f,
  -4.55463417e-02f, 2.01919019e-01f, -1.46344081e-01f, 2.32530925e-02f, -1.21833421e-01f, -2.79444903e-01f, -4.13365569e-03f, -1.62995622e-01f, 3.06217909e-01f, 1.29572600e-01f,
  -1.65199623e-01f, 1.36501417e-01f, -1.77841976e-01f, 2.09512606e-01f, 9.33849216e-02f, -1.59372523e-01f, 2.02573135e-01f, 7.83898681e-03f, 2.16895062e-03f, -8.53050649e-02f,
  1.72141820e-01f, 1.39658764e-01f, 8.79145190e-02f, 4.98458631e-02f, 5.84118478e-02f, -1.85355395e-01f, 1.42805830e-01f, -8.43969882e-02f, -8.65637511e-02f, -1.68331027e-01f,
  -2.68806815e-01f, -9.21873599e-02f, 6.65192679e-03f, -1.43525124e-01f, 6.60387874e-02f, -1.48696676e-01f, -5.03735803e-02f, -1.24291472e-01f, 1.82814568e-01f, 1.67066365e-01f,
  -2.92539090e-01f, -5.10584787e-02f, -1.37584573e-02f, 1.35936558e-01f, -4.33506906e-01f, 2.83491224e-01f, -6.48767725e-02f, -4.08580489e-02f, 2.16362417e-01f, -1.32041909e-02f,
  -5.33626676e-02f, -8.68142918e-02f, 8.05396065e-02f, 7.84600079e-02f, -1.70862377e-02f, -2.73291431e-02f, -6.88731251e-03f, -2.50908323e-02f, 5.42019121e-03f, -2.33373255e-01f,
  3.21880020e-02f, 2.81052887e-01f, 3.15209687e-01f, -1.87532455e-02f, 3.70046720e-02f, -8.42546150e-02f, 1.75816655e-01f, 1.81738898e-01f, -5.40768877e-02f, -2.90414616e-02f,
  2.62062043e-01f, -1.43352583e-01f, 1.64166033e-01f, 2.51957685e-01f, 1.80949301e-01f, 1.52999774e-01f, -1.05895869e-01f, 1.02412514e-01f, 1.60963088e-01f, 1.80884778e-01f,
  -5.88314608e-02f, -3.08478549e-02f, -3.83848418e-03f, -8.05402920e-02f, 6.27476275e-02f, -1.08791076e-01f, -1.29254222e-01f, -1.15836270e-01f, -5.31163178e-02f, 1.85117626e-03f,
  1.36002436e-01f, -1.38095990e-01f, -1.62602514e-01f, -4.27873470e-02f, -1.62089288e-01f, -9.25632473e-03f, -1.70849457e-01f, -1.16946213e-02f, -1.67787135e-01f, -2.08558589e-01f,
  -3.02157551e-01f, 8.05759728e-02f, -1.31159335e-01f, -9.40356776e-02f, -1.77190781e-01f, 2.23798364e-01f, 1.52577937e-01f, 8.26999173e-02f, -1.18092783e-01f, 1.13049172e-01f,
  -5.37118204e-02f, 1.22540615e-01f, -1.65773585e-01f, 1.45503983e-01f, 1.83404669e-01f, 2.47264370e-01f, 7.56615624e-02f, -5.09948470e-03f, -2.37170458e-01f, -1.07755505e-01f,
  -1.49453089e-01f, -7.04112723e-02f, -4.60034795e-03f, -1.56124844e-03f, 2.13498935e-01f, 5.17216325e-02f, 1.03546388e-01f, 2.99886875e-02f, 2.26600572e-01f, 9.24364850e-02f,
  1.62466809e-01f, 1.26114368e-01f, 1.00808935e-02f, -8.69713873e-02f, 2.88316637e-01f, -3.63765866e-01f, 1.02902323e-01f, 1.58655886e-02f, -2.16740165e-02f, -3.50596011e-02f,
  1.29912585e-01f, 1.49956629e-01f, -3.47635597e-02f, -7.05301613e-02f, 1.13783836e-01f, -1.79928884e-01f, -1.48883583e-02f, -3.90383452e-02f, -6.58069402e-02f, -2.24931344e-01f,
  9.93919224e-02f, -8.70515704e-02f, 1.26476556e-01f, -1.13843426e-01f, 5.01653589e-02f, -1.21892922e-01f, -3.75891067e-02f, 1.44187629e-01f, -5.77473827e-02f, 7.88020417e-02f,
  1.33796245e-01f, -1.30139410e-01f, 2.89034005e-02f, -1.91230163e-01f, -1.59087434e-01f, -2.53235950e-04f, -1.09957837e-01f, 1.81438074e-01f, 2.13427767e-01f, -3.17815617e-02f,
  5.87351508e-02f, 9.15699638e-03f, -2.59288222e-01f, -2.69063205e-01f, -2.54599210e-02f, -1.47545278e-01f, -5.27432151e-02f, -7.10997432e-02f, 4.37252633e-02f, 1.41709596e-01f,
  -5.46901375e-02f, 8.54027420e-02f, 1.45730302e-01f, -1.69566907e-02f, 8.25960562e-02f, 1.11155592e-01f, 1.84240982e-01f, -2.62412012e-01f, 1.48902088e-01f, 4.68141548e-02f,
  -6.40614629e-02f, 1.60297826e-02f, 1.06471851e-01f, -1.53345555e-01f, -4.38637137e-02f, 8.39505941e-02f, -1.11667402e-01f, 1.84189722e-01f, 1.45555092e-02f, -1.59952864e-01f,
  9.43239033e-02f, 8.70935768e-02f, 6.73467219e-02f, -4.06316333e-02f, -1.13433108e-01f, -7.24127442e-02f, -9.98706818e-02f, 8.41585547e-02f, -1.86743930e-01f, -1.80941746e-01f,
  6.41683936e-02f, 1.36328876e-01f, 1.36777550e-01f, 1.05183937e-01f, 8.15944150e-02f, 9.66507420e-02f, 8.28243494e-02f, 3.97561729e-01f, -8.30507353e-02f, -1.25179574e-01f,
  -3.54670361e-02f, -5.87568022e-02f, 3.04050744e-01f, 1.58420399e-01f, -5.54137193e-02f, -5.17637953e-02f, 1.49560452e-01f, 2.34795302e-01f, -6.87768534e-02f, -8.35767612e-02f,
  -1.17316907e-02f, 1.34554699e-01f, 5.05714640e-02f, -1.72570229e-01f, -5.49616404e-02f, -1.74641475e-01f, 9.43613499e-02f, -1.77776724e-01f, 2.20104009e-01f, 4.13146168e-02f,
  3.74309979e-02f, -9.67331883e-03f, -1.66222945e-01f, -1.29572541e-01f, -2.30096847e-01f, -1.62190180e-02f, 1.74093932e-01f, 4.26149398e-01f, 3.21151614e-02f, -1.28086522e-01f,
  -2.18066145e-02f, -9.68348682e-02f, -1.23444155e-01f, -9.68559273e-03f, 8.81987363e-02f, 1.10466510e-01f, -2.03499734e-01f, -3.36707197e-02f, 1.76206362e-02f, -8.00567493e-02f,
  1.73243601e-02f, -1.40233908e-03f, -1.37988299e-01f, 1.33462444e-01f, 5.24751395e-02f, 2.47992173e-01f, 1.60128817e-01f, 4.58300002e-02f, -4.33360375e-02f, -4.34086584e-02f,
  -1.16739258e-01f, -1.31451145e-01f, -1.69740126e-01f, 6.56357408e-02f, -7.57284537e-02f, 1.47494808e-01f, 1.91567481e-01f, 1.04980960e-01f, -1.14813410e-02f, -1.11355148e-01f,
  3.34995687e-02f, -2.47719623e-02f, -6.09756773e-03f, 1.28138259e-01f, 7.36014470e-02f, -1.65929511e-01f, -2.23729406e-02f, 2.79410809e-01f, -4.64782678e-02f, -9.57555547e-02f,
  1.79404374e-02f, 3.03164363e-01f, 3.64804044e-02f, -2.24313036e-01f, 1.67076543e-01f, -9.36238542e-02f, 1.09475916e-02f, -3.99050824e-02f, -1.18691465e-02f, -4.23942953e-02f,
  -3.70059967e-01f, 7.18408450e-02f, -3.95484194e-02f, -1.27926648e-01f, 2.10240185e-01f, -4.29674655e-01f, -9.29555111e-03f, 6.29726499e-02f, -8.36774558e-02f, 8.27009138e-03f,
  4.30899650e-01f, 1.16253167e-01f, -4.21449840e-02f, -2.75751613e-02f, -1.31706104e-01f, -1.57800913e-01f, -1.32990628e-01f, -2.42499888e-01f, -5.89894205e-02f, 8.16358905e-03f,
  -1.19145989e-01f, 9.54388753e-02f, -1.94744527e-01f, -2.62038056e-02f, 2.39220578e-02f, -2.19754353e-01f, 2.17429604e-02f, 1.13324128e-01f, 6.90586641e-02f, 6.86753318e-02f,
  -1.21436693e-01f, -1.32443905e-01f, -1.32839888e-01f, -3.34604830e-02f, 1.51094139e-01f, -1.20095216e-01f, -7.79698603e-03f, -1.24658182e-01f, 1.01877294e-01f, 6.31709071e-03f,
  -2.29140952e-01f, 1.19472042e-01f, 8.25242028e-02f, -1.08296469e-01f, -5.65666966e-02f, 1.52358860e-01f, -1.36655286e-01f, -1.26450375e-01f, 5.73103353e-02f, -1.23021044e-01f,
  7.25877956e-02f, 1.50296211e-01f, 1.60125986e-01f, -1.94279432e-01f, -1.54103953e-02f, 1.32166922e-01f, -1.19206205e-01f, 1.74114823e-01f, 2.45308150e-02f, 1.27522260e-01f,
  -1.13260131e-02f, 2.00215168e-02f, 2.87313968e-01f, -7.29110837e-03f, 2.28616893e-02f, -1.17170602e-01f, 8.04464743e-02f, 1.26747400e-01f, 2.39383802e-02f, 1.71863958e-01f,
  8.89224261e-02f, -2.09162638e-01f, -5.85554875e-02f, 1.92728564e-01f, 3.27486242e-03f, -6.10294752e-02f, -5.65965399e-02f, 1.91625580e-02f, 6.03354387e-02f, -1.53393131e-02f,
  -4.24541831e-02f, 4.46672253e-02f, -1.10115804e-01f, -7.51628578e-02f, -9.43367779e-02f, -1.54592425e-01f, 2.30483338e-02f, 8.28700699e-03f, -2.22914949e-01f, 2.98763365e-01f,
  4.37727161e-02f, 1.16135150e-01f, -8.55917037e-02f, -1.58133790e-01f, 1.27836332e-01f, -1.28122985e-01f, -1.66225240e-01f, -2.64290512e-01f, -3.55828814e-02f, -7.89409503e-02f,
  -1.48449987e-01f, 1.11866988e-01f, -1.35340065e-01f, 1.01284422e-01f, 7.96370432e-02f, 3.63998511e-03f, 6.45097941e-02f, -2.39030737e-02f, 2.83120219e-02f, 2.79656708e-01f,
  5.63152581e-02f, -1.92796454e-01f, -6.86784387e-02f, 5.90135232e-02f, 1.16605394e-01f, -3.27438824e-02f, 9.28112306e-03f, 1.64489374e-02f, 1.83743555e-02f, 4.81362008e-02f,
  1.72409460e-01f, -2.57011324e-01f, -8.58722776e-02f, -1.01863071e-02f, 2.40616240e-02f, -3.25968176e-01f, 6.27645254e-02f, -1.73361297e-03f, -1.70960367e-01f, -2.39934981e-01f,
  -4.07746322e-02f, 5.37434965e-03f, 4.39857692e-01f, 1.28026873e-01f, 1.50594816e-01f, 1.15013167e-01f, -2.20204502e-01f, 2.66892705e-02f, 7.61102065e-02f, 2.17288360e-02f,
  1.23425104e-01f, 3.81106623e-02f, 4.34579030e-02f, -2.28778481e-01f, -2.44897604e-01f, 7.54046738e-02f, 8.37165117e-02f, 8.94792005e-02f, 3.26147638e-02f, 2.97344904e-02f,
  3.94094735e-02f, 8.91008824e-02f, -1.72717810e-01f, -7.37890974e-02f, -9.34505537e-02f, -1.33885458e-01f, 3.16221118e-01f, 1.87354758e-01f, -6.28312677e-03f, -1.10186413e-01f,
  -3.43231916e-01f, 1.32106736e-01f, -3.89345139e-02f, -4.57304083e-02f, 1.76825542e-02f, 3.11230887e-02f, -4.53934930e-02f, -2.17813607e-02f, -5.82481697e-02f, -1.40501801e-02f,
  3.12432647e-02f, -1.42927185e-01f, 6.27046749e-02f, 4.96291891e-02f, 2.70038582e-02f, -5.50458282e-02f, 5.93679622e-02f, -1.04880564e-01f, 1.47727773e-01f, 1.32776067e-01f,
  6.19176552e-02f, 5.01383953e-02f, 1.32752594e-03f, 8.91563967e-02f, -7.40038529e-02f, 3.34192574e-01f, 2.82590508e-01f, 1.16236314e-01f, 6.69057891e-02f, -4.27992903e-02f,
  1.78325176e-01f, -3.39926337e-03f, 7.50902966e-02f, -2.06429496e-01f, 1.84693057e-02f, 2.10225731e-01f, 8.35986882e-02f, -1.18110575e-01f, -1.74696714e-01f, -9.80333611e-02f,
  1.04546264e-01f, 2.83382893e-01f, 6.00150153e-02f, 7.21212253e-02f, -8.10286030e-02f, 8.36815163e-02f, 1.16897121e-01f, 1.12586804e-01f, -2.55642692e-03f, -6.63751885e-02f,
  -1.69524401e-01f, 1.29116371e-01f, 1.50126899e-02f, -1.91257805e-01f, 1.06101252e-01f, -1.81440666e-01f, 3.80344456e-03f, 2.12236732e-01f, -7.56657273e-02f, -5.57103269e-02f,
  -1.89900428e-01f, -2.44359344e-01f, 2.32447714e-01f, 6.30335137e-02f, -5.26681244e-02f, -1.27208948e-01f, -6.06109425e-02f, 1.68814003e-01f, -3.74637870e-03f, 2.95123179e-02f,
  7.16474056e-02f, -1.99618459e-01f, -1.85540468e-01f, 1.17897563e-01f, -4.79372442e-02f, -2.67300695e-01f, 5.30691864e-03f, -1.33603569e-02f, 3.65888663e-02f, -1.43139690e-01f,
  1.19214563e-03f, 1.48703419e-02f, -2.18184486e-01f, -1.39311388e-01f, -1.20451957e-01f, -1.17091261e-01f, 1.44656479e-01f, -1.55345559e-01f, -8.55399892e-02f, 6.02014847e-02f,
  -2.50332475e-01f, -2.69343197e-01f, 3.33142132e-01f, 1.60702318e-02f, -8.19697902e-02f, -2.56912827e-01f, 2.30415255e-01f, -3.06221008e-01f, -1.17123723e-01f, -2.97811359e-01f,
  -2.89039671e-01f, 3.51216048e-02f, 1.69395164e-01f, -1.25229701e-01f, -6.94884807e-02f, 1.28781069e-02f, 6.49635270e-02f, 1.97123632e-01f, 1.72470436e-01f, -5.91125675e-02f,
  -1.73558384e-01f, 1.41368374e-01f, -1.58530667e-01f, -2.33322710e-01f, -1.17327400e-01f, -8.52876306e-02f, 2.96779126e-01f, -5.55067845e-02f, 1.13761544e-01f, -1.86189085e-01f,
  3.39211643e-01f, -8.31158534e-02f, -6.89614713e-02f, -7.19924551e-03f, -1.86874941e-01f, 4.39751707e-02f, 2.02855803e-02f, -4.46108073e-01f, 1.13478214e-01f, -7.09734336e-02f,
  -1.77283928e-01f, -2.62036026e-01f, 5.69215082e-02f, 4.43816893e-02f, 2.40439788e-01f, 2.50494540e-01f, 1.09236740e-01f, 2.08530694e-01f, 9.86921489e-02f, -3.56276184e-01f,
  1.62017569e-01f, 4.72401455e-02f, -3.13173346e-02f, 4.40552942e-02f, 1.19106196e-01f, -8.41781404e-03f, 1.64224520e-01f, 1.58816334e-02f, 9.79233384e-02f, 2.05241323e-01f,
  1.16074845e-01f, 1.00775935e-01f, -2.69743633e-02f, 1.01054646e-01f, -9.82409343e-02f, 6.62581176e-02f, 2.35013310e-02f, 1.85548112e-01f, -3.64656970e-02f, 9.59034264e-02f,
  4.52914476e-01f, -2.91964799e-01f, -1.69304565e-01f, -1.70256808e-01f, -3.83666247e-01f, 7.88820311e-02f, 2.38784879e-01f, -8.09664652e-02f, 1.17367946e-01f, 2.91614253e-02f,
  -4.86627109e-02f, 2.78470337e-01f, 7.71089420e-02f, -1.27294973e-01f, -8.18713829e-02f, -1.12563953e-01f, -1.21927865e-01f, -1.65067449e-01f, -2.23156124e-01f, 2.27129497e-02f,
  1.47354513e-01f, 3.15452106e-02f, -6.22771867e-02f, -1.89159974e-01f, 2.49268375e-02f, 1.07156523e-01f, 1.20207109e-01f, -1.00542843e-01f, 7.36273751e-02f, -6.58808723e-02f,
  -1.80113465e-01f, -2.31989603e-02f, 1.06584482e-01f, 1.33252060e-02f, -1.51174873e-01f, -4.88202348e-02f, 6.28900006e-02f, -1.05279140e-01f, 3.22738104e-02f, 4.70521525e-02f,
  -7.13529158e-03f, 2.12515712e-01f, -1.32372499e-01f, 1.85397536e-01f, 2.51070797e-01f, -6.91366568e-03f, 1.37017936e-01f, -5.21716289e-02f, 1.16992183e-01f, -2.53241479e-01f,
  2.40978137e-01f, -5.14839105e-02f, 4.60138284e-02f, 2.04185367e-01f, -1.63333416e-02f, 3.44779044e-02f, 8.25416744e-02f, 1.32612839e-01f, 3.01305532e-01f, 4.06130284e-01f,
  -3.44991326e-01f, 8.08082968e-02f, 2.89169669e-01f, -8.07515439e-03f, -1.31056473e-01f, 1.36910096e-01f, 2.26035982e-01f, 1.27156051e-02f, 2.17890099e-01f, -8.70572552e-02f,
  1.29650474e-01f, -3.08963627e-01f, 4.01445925e-01f, -2.67561171e-02f, 7.93771893e-02f, -3.83434564e-01f, -1.39139235e-01f, -8.66834372e-02f, 1.58392251e-01f, -1.01682777e-02f,
  1.51269093e-01f, -1.09609224e-01f, 2.35544089e-02f, -2.36451793e-02f, 4.43891101e-02f, 6.98741525e-02f, 3.58699895e-02f, -6.78164372e-03f, -1.76955134e-01f, 6.31707581e-03f,
  9.69962552e-02f, 1.55549869e-01f, 2.66375810e-01f, -7.54607990e-02f, 4.90507260e-02f, 3.78717691e-01f, -1.03578819e-02f, -2.85030510e-02f, -1.99808896e-01f, 2.28101417e-01f,
  -1.80473834e-01f, -1.49742320e-01f, -1.45144016e-01f, -1.45438537e-01f, -2.51901209e-01f, 8.61984491e-02f, -8.16329643e-02f, -9.37709287e-02f, 1.26425743e-01f, -2.58341938e-01f,
  3.21020395e-01f, -7.64753371e-02f, 1.15044825e-01f, -1.58272564e-01f, 6.68463334e-02f, 1.30950093e-01f, 7.46540725e-02f, 1.00808024e-01f, -8.89959782e-02f, -1.52474687e-01f,
  1.20870315e-01f, -8.22087675e-02f, 1.88543394e-01f, 3.64465937e-02f, 4.75526154e-02f, -1.24883488e-01f, -1.32337749e-01f, -1.56064346e-01f, -3.28488648e-01f, -1.20027428e-02f,
  2.64733076e-01f, -6.03226349e-02f, 1.05525799e-01f, -2.76685029e-01f, -2.92449504e-01f, -1.07659169e-01f, -1.43379448e-02f, 7.15593249e-02f, 2.25484893e-01f, -1.42701298e-01f,
  1.06020339e-01f, 1.13651402e-01f, -1.74927078e-02f, -6.59366772e-02f, 1.93714842e-01f, -1.49438232e-01f, -1.75077930e-01f, -3.86218801e-02f, 5.78276217e-02f, 3.55327688e-02f,
  9.02226381e-03f, -2.31644809e-02f, 2.66779065e-02f, 1.78479075e-01f, -1.61032543e-01f, 1.62269235e-01f, -2.20542222e-01f, -2.77018920e-02f, 1.95609108e-01f, -8.13688338e-02f,
  -1.09341465e-01f, -1.64785773e-01f, 1.46718491e-02f, 8.05287510e-02f, -1.71733901e-01f, 1.03797965e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  5.46852387e-02f, -3.68701778e-02f, 6.04697205e-02f, 1.33586794e-01f, -5.92144346e-03f, -7.67953917e-02f, 1.39366925e-01f, -1.75967053e-01f, 1.10285252e-01f, -3.06186080e-02f,
  1.78106770e-01f, -1.96760625e-01f, -2.80851454e-01f, -2.92125158e-02f, -3.51719670e-02f, 1.71610475e-01f, 1.19224146e-01f, 1.60923526e-01f, -8.39140415e-02f, 1.59260944e-01f,
  -3.16653132e-01f, -2.97516227e-01f, 1.53967425e-01f, -4.81822193e-02f, -2.56694168e-01f, 1.34075120e-01f, -1.66018635e-01f, -1.09243058e-01f, -4.08250809e-01f, -6.51982948e-02f,
  -1.63529441e-01f, 8.27209651e-03f, 3.58160049e-01f, 2.24908769e-01f, 3.38657051e-02f, 1.56005979e-01f, 5.14462916e-03f, 1.08178586e-01f, 2.48706073e-01f, -4.88039404e-02f,
  -1.27476975e-01f, 1.70909792e-01f, 1.06848553e-01f, -9.64489654e-02f, 1.59727305e-01f, -1.25808775e-01f, 4.16387349e-01f, 1.05749808e-01f, 9.22987536e-02f, 2.28562485e-02f,
  3.25133115e-01f, -9.36229080e-02f, 3.10203284e-01f, -1.13248043e-01f, -6.53514313e-03f, 2.27912003e-03f, -3.60689193e-01f, -1.35214359e-01f, -6.89521134e-02f, 1.34444207e-01f,
  2.01982651e-02f, -6.17600977e-02f, 6.25883043e-02f, -5.77242635e-02f, -1.04290722e-02f, -7.75770023e-02f, -1.56883210e-01f, 1.25539362e-01f, 6.04061261e-02f, -2.36487724e-02f,
  1.62597701e-01f, -1.33827865e-01f, 7.16472045e-02f, 7.77047547e-03f, -5.30501865e-02f, 2.22637266e-01f, 2.19852682e-02f, 2.21346412e-02f, 2.35283300e-01f, 9.97732580e-03f,
  8.96096230e-02f, -1.03310056e-01f, 3.45090181e-02f, -2.81239897e-01f, -1.19539171e-01f, -9.68141109e-02f, 2.79813498e-01f, -2.16905057e-01f, -1.61278456e-01f, -3.46724503e-02f,
  -3.33024263e-01f, -2.38432884e-01f, 2.54422665e-01f, -3.14008027e-01f, 3.93058285e-02f, -2.06032634e-01f, -1.44507021e-01f, 3.09225559e-01f, -3.00815821e-01f, -1.33575708e-01f,
  -1.38312560e-02f, 2.06210837e-01f, 2.83860892e-01f, -1.22439332e-01f, -1.69474155e-01f, 3.02867424e-02f, -1.96653888e-01f, 7.56665468e-02f, 1.64403245e-01f, -1.23251587e-01f,
  2.71762222e-01f, -1.25032231e-01f, 1.31705135e-01f, 2.43377700e-01f, 1.93296015e-01f, 2.86827356e-01f, -9.12436396e-02f, 5.75244166e-02f, 1.25227854e-01f, 1.66103929e-01f,
  1.55789927e-01f, -3.30782771e-01f, -2.28521079e-01f, -4.71086018e-02f, -1.02613963e-01f, -1.39893219e-01f, -2.63639569e-01f, 2.11396571e-02f, 1.70666024e-01f, 3.91922109e-02f,
  -8.25302303e-02f, 9.78444293e-02f, 1.76004931e-01f, -7.61210397e-02f, 2.80374642e-02f, 1.96939930e-01f, -5.83920255e-02f, -1.63809761e-01f, 5.49923591e-02f, 6.10173382e-02f,
  2.62015373e-01f, 7.43904859e-02f, 2.03363344e-01f, 4.54854220e-02f, 1.13127619e-01f, 4.62790988e-02f, 1.21420585e-01f, 1.78120404e-01f, 1.17895246e-01f, -8.43971819e-02f,
  3.25076163e-01f, -1.17665127e-01f, -8.50481614e-02f, 3.70213133e-03f, -3.53734121e-02f, -2.74800032e-01f, 1.87613532e-01f, 2.17443518e-02f, -1.39748618e-01f, -8.82294495e-03f,
  -2.78036833e-01f, 2.10427064e-02f, -1.84100702e-01f, 3.20200950e-01f, 1.27544150e-01f, 1.41568169e-01f, 2.11141318e-01f, -8.34561698e-03f, 1.23584896e-01f, 7.50735030e-02f,
  -3.19176912e-02f, 1.44026071e-01f, -6.10252805e-02f, -4.93772961e-02f, 2.31589466e-01f, -3.11860144e-01f, 5.12583256e-02f, 1.17031202e-01f, 1.12923376e-01f, 5.93009144e-02f,
  -3.08764696e-01f, 1.92858968e-02f, -1.65604517e-01f, -1.65446460e-01f, 1.07212059e-01f, -2.50560731e-01f, -8.52239877e-02f, -2.81038374e-01f, -2.74627119e-01f, 5.28494120e-02f,
  -2.00819030e-01f, 8.24702159e-02f, -7.78008923e-02f, -2.03694906e-02f, 1.26323804e-01f, 6.44231662e-02f, 7.30965286e-02f, 2.13756874e-01f, 1.85872376e-01f, 2.53038287e-01f,
  -6.98221624e-02f, 1.99095681e-02f, 1.07676193e-01f, 4.40884233e-01f, 2.25919232e-01f, 9.96247232e-02f, 4.48304191e-02f, 1.05314486e-01f, 2.04768360e-01f, 3.60434726e-02f,
  1.08324721e-01f, 1.17647178e-01f, -5.90340123e-02f, -1.91278204e-01f, 2.68225819e-01f, 1.70955181e-01f, -1.87966779e-01f, -1.46021113e-01f, 8.66455212e-02f, -2.03222454e-01f,
  -2.47183871e-02f, -1.28396243e-01f, 1.24212213e-01f, -1.64460205e-02f, -2.49739677e-01f, -4.88432087e-02f, -6.76488727e-02f, 2.10358590e-01f, -6.49307147e-02f, 2.26410925e-01f,
  3.40783000e-01f, 1.51614454e-02f, 1.54232336e-02f, 4.02221113e-01f, -1.55960023e-01f, 1.86231155e-02f, -5.09374253e-02f, 8.58754069e-02f, -4.17955667e-02f, 1.72864228e-01f,
  -2.68515348e-02f, 1.22009724e-01f, 7.70211294e-02f, -1.67452451e-02f, -6.51497319e-02f, 1.09478168e-01f, -2.46466890e-01f, -6.91276118e-02f, 1.14041045e-01f, -1.16519950e-01f,
  -3.14604193e-01f, 7.27947280e-02f, -8.98105502e-02f, -9.17298943e-02f, -9.84825846e-03f, 1.08690679e-01f, 5.94344810e-02f, -8.21012557e-02f, -9.56662819e-02f, 1.66411996e-01f,
  7.82938302e-02f, -1.23324916e-01f, -5.33170775e-02f, 1.43458277e-01f, 1.95733577e-01f, 7.10175885e-03f, 1.76562086e-01f, 4.21993770e-02f, -5.10220341e-02f, -2.40918645e-03f,
  -1.01735763e-01f, 4.29369323e-02f, 9.21565946e-03f, 4.72748168e-02f, 2.10121259e-01f, 2.97828540e-02f, 4.08789366e-02f, 3.28916252e-01f, -1.70057327e-01f, 5.44102453e-02f,
  3.91301572e-01f, 1.22489236e-01f, -2.01147348e-02f, -1.91719197e-02f, 5.74728400e-02f, 2.00819179e-01f, 2.81056195e-01f, 3.55665296e-01f, 8.77958685e-02f, 1.05488844e-01f,
  1.36405811e-01f, 6.63537532e-02f, -1.82679102e-01f, -7.77061582e-02f, 1.95047900e-01f, 3.60999137e-01f, 3.66682202e-01f, -1.69711515e-01f, 2.48712599e-01f, 1.08480357e-01f,
  -2.26044104e-01f, 8.34960565e-02f, -2.54548281e-01f, -1.49081618e-01f, 1.01776309e-01f, 5.71007878e-02f, -2.32628778e-01f, 2.65204877e-01f, 9.83378962e-02f, 5.70846461e-02f,
  2.95665950e-01f, -2.75769323e-01f, 1.63288802e-01f, 1.21987641e-01f, -4.46698874e-01f, 6.25231341e-02f, 2.13987038e-01f, 1.21433608e-01f, 8.39118361e-02f, 1.18404441e-01f,
  1.23890005e-01f, 3.86353768e-02f, 8.08423385e-02f, 1.41646266e-01f, 1.49146602e-01f, 1.26135483e-01f, 2.73605697e-02f, 1.09941341e-01f, 1.79571092e-01f, 2.52611876e-01f,
  1.54739052e-01f, -7.16570439e-03f, 1.46875814e-01f, 7.98218176e-02f, 3.40124555e-02f, 1.11161157e-01f, 1.13967270e-01f, 2.86691248e-01f, 1.02266133e-01f, -1.97790012e-01f,
  7.92443976e-02f, 9.31042731e-02f, -2.75902689e-01f, -2.46802762e-01f, 1.19156815e-01f, -1.15300536e-01f, 1.01155482e-01f, 5.00600077e-02f, 3.33833188e-01f, 2.10182250e-01f,
  2.03023240e-01f, -8.17881003e-02f, -3.34897071e-01f, -3.38009804e-01f, -3.62969227e-02f, 3.10637593e-01f, 3.97246853e-02f, 2.49292523e-01f, -1.07697770e-03f, 5.52460477e-02f,
  2.26496696e-01f, -1.66796848e-01f, -2.11637933e-02f, 9.95538682e-02f, -6.14160746e-02f, 1.06555454e-01f, -2.66994298e-01f, 2.04410464e-01f, 5.97656257e-02f, 1.17981724e-01f,
  -7.37723708e-02f, -2.01071396e-01f, -1.49125442e-01f, 3.57569546e-01f, -2.32544735e-01f, -1.34621409e-03f, 2.28652924e-01f, 2.50780378e-02f, -1.29376441e-01f, -9.21939164e-02f,
  1.11306541e-01f, 1.57409430e-01f, -2.11641893e-01f, 2.26002291e-01f, -2.94305176e-01f, 1.90668076e-01f, -3.18312794e-02f, 1.97766438e-01f, 1.05310619e-01f, 1.96003288e-01f,
  1.72419190e-01f, 3.33811045e-02f, 1.76989675e-01f, -5.49595803e-02f, 2.56123424e-01f, 4.18682173e-02f, -1.91994727e-01f, 2.48175681e-01f, 1.42577380e-01f, -1.06424585e-01f,
  5.68427611e-03f, 1.50891542e-01f, 1.55195698e-01f, -3.17654431e-01f, -1.00072943e-01f, 1.12626947e-01f, -2.92578548e-01f, 3.53654101e-02f, -1.86438516e-01f, 2.10521132e-01f,
  -1.33421183e-01f, 2.29013890e-01f, 8.58791471e-02f, -8.49438608e-02f, 1.58242375e-01f, -5.33945024e-01f, 3.10623288e-01f, -5.05776517e-02f, -6.86362609e-02f, -2.50739247e-01f,
  3.30654681e-01f, -2.03585923e-01f, 2.85145212e-02f, -2.28165582e-01f, -5.59200287e-01f, -2.36708030e-01f, 7.03561157e-02f, -8.15880969e-02f, 1.52967021e-01f, -1.45390317e-01f,
  -1.64177224e-01f, 3.02901834e-01f, -2.04923347e-01f, 1.58089086e-01f, -1.31190782e-02f, -2.52652705e-01f, 1.48714080e-01f, 2.32942194e-01f, 1.47806108e-01f, 3.95542562e-01f,
  1.59267873e-01f, 3.16902190e-01f, -1.71319142e-01f, 1.30898938e-01f, -2.71909758e-02f, -6.33507445e-02f, -3.72714072e-01f, -1.92472264e-01f, 1.17220141e-01f, 8.67209956e-02f,
  -2.65515670e-02f, 6.67232051e-02f, 1.40088037e-01f, -2.53190193e-02f, 1.00144312e-01f, 1.34146869e-01f, 5.78143299e-02f, 1.13144055e-01f, 8.68442431e-02f, -3.33925374e-02f,
  1.79938763e-01f, 1.17098853e-01f, 4.54437472e-02f, -1.10600153e-02f, 2.60298312e-01f, 3.82934630e-01f, 1.47637263e-01f, 2.09198952e-01f, -5.10755740e-02f, 3.12990509e-02f,
  3.85140888e-02f, -1.20291095e-02f, 3.63731533e-02f, 3.96277010e-03f, 1.68714672e-01f, -1.65410250e-01f, 1.24140970e-01f, 9.18374509e-02f, -6.58821538e-02f, 2.30594710e-01f,
  -2.36999810e-01f, -2.37890422e-01f, 6.35241345e-02f, 2.27924675e-01f, -4.83274497e-02f, 4.09307003e-01f, 2.86104567e-02f, 1.41961023e-01f, 1.31052420e-01f, 3.66853476e-02f,
  -1.09005354e-01f, 8.78266618e-02f, -2.68852323e-01f, 1.81991905e-01f, -4.39259522e-02f, -1.67652309e-01f, 6.35050088e-02f, -1.46208763e-01f, 3.50368060e-02f, 6.96952567e-02f,
  -1.57217681e-01f, 1.55001745e-01f, -1.28626347e-01f, -4.02994275e-01f, -2.82760803e-02f, -1.09166659e-01f, -2.44049132e-02f, -4.70885068e-01f, -3.33139718e-01f, 1.10095948e-01f,
  -1.61771346e-02f, 1.04815543e-01f, 2.69616753e-01f, 1.19557858e-01f, 5.81740960e-02f, -6.85176020e-03f, 3.46722335e-01f, 2.06644073e-01f, -3.46366363e-03f, 9.26646069e-02f,
  -3.05083036e-01f, 1.38091892e-01f, -2.98664463e-03f, 5.50731122e-01f, 1.81026220e-01f, 8.53096768e-02f, 1.21937871e-01f, 1.08001366e-01f, 2.28536293e-01f, -5.67747243e-02f,
  2.12352291e-01f, 1.85364887e-01f, -2.73057252e-01f, -1.20389543e-01f, -7.14492202e-02f, 3.11201930e-01f, -6.59941807e-02f, 1.80232614e-01f, 2.89107502e-01f, -8.90754461e-02f,
  -1.76018417e-01f, 1.19760871e-01f, -1.00493371e-01f, 6.66332006e-01f, 1.37761474e-01f, 2.64180571e-01f, 1.77634373e-01f, -2.68138021e-01f, -3.24121833e-01f, 4.22621697e-01f,
  9.85250771e-02f, -2.02194437e-01f, 3.81936699e-01f, 2.88044184e-01f, -1.00475147e-01f, 6.58164993e-02f, -1.69894084e-01f, 1.41805738e-01f, 1.67160332e-01f, 2.09615096e-01f,
  -1.48195967e-01f, -1.71239883e-01f, -3.22299823e-02f, 4.64811828e-03f, 2.44543344e-01f, 3.78753804e-02f, 3.68053466e-01f, -3.74450624e-01f, -2.80905038e-01f, 8.95282701e-02f,
  7.40169957e-02f, -2.09554955e-01f, -2.98217058e-01f, 1.38907239e-01f, 2.23390669e-01f, -6.17083125e-02f, 1.56695828e-01f, -6.16837293e-03f, -1.36390507e-01f, 8.27759057e-02f,
  1.89497143e-01f, 5.93226478e-02f, -6.29448667e-02f, 1.17551699e-01f, 6.20581321e-02f, 1.16741963e-01f, 1.45947695e-01f, 6.01928905e-02f, 8.92915800e-02f, 1.61093809e-02f,
  2.01979026e-01f, -1.04092069e-01f, 2.57973313e-01f, 2.38770425e-01f, 8.56063608e-03f, 1.13080025e-01f, 1.41726695e-02f, -1.66158587e-01f, 2.10013986e-01f, -1.15192845e-01f,
  -1.56012133e-01f, 5.42231128e-02f, 2.15795279e-01f, -5.55086546e-02f, -2.03194600e-02f, 1.37334004e-01f, 1.05359787e-02f, -8.69857967e-02f, -3.47191185e-01f, 1.05834059e-01f,
  6.02858402e-02f, 5.15115149e-02f, -4.46689762e-02f, 3.45999956e-01f, 9.66901779e-02f, 1.65727913e-01f, 4.40008231e-02f, 2.75007397e-01f, -8.96732137e-02f, -5.91432340e-02f,
  -2.32031986e-01f, 1.63262799e-01f, 2.01011807e-01f, -1.79122314e-01f, -6.53870180e-02f, -2.73005608e-02f, 1.91411942e-01f, 1.52053937e-01f, -2.27349177e-01f, 7.59869814e-02f,
  -1.70042828e-01f, -2.95727283e-01f, 1.21682771e-01f, -2.98964083e-02f, -1.78110749e-01f, -2.62519896e-01f, -1.86280727e-01f, 3.45811527e-03f, 8.29858705e-02f, 5.87668596e-03f,
  9.10424739e-02f, 8.10517147e-02f, 2.76567161e-01f, 1.03186220e-01f, 7.76288062e-02f, -1.49660930e-01f, -2.24487036e-02f, 4.76073027e-02f, -7.44871497e-02f, -1.65297195e-01f,
  -1.07677899e-01f, 2.56902784e-01f, 1.01840295e-01f, 1.46980360e-01f, 8.47810283e-02f, -1.25343204e-01f, -1.90436486e-02f, -2.49701604e-01f, 4.77145687e-02f, 1.82016253e-01f,
  -1.00350484e-01f, -1.58252455e-02f, 4.78935391e-02f, 3.18040214e-02f, 1.59599725e-02f, -2.87194736e-02f, 3.83373439e-01f, -1.34580448e-01f, -2.53946662e-01f, -7.25886151e-02f,
  -1.70644537e-01f, 2.97940195e-01f, 1.39854029e-01f, 1.05434053e-01f, 5.74899875e-02f, -3.15998733e-01f, -1.15784317e-01f, 3.13753426e-01f, -1.15376659e-01f, -2.53064215e-01f,
  2.22751155e-01f, 1.20882802e-01f, -2.72599787e-01f, 1.13136165e-01f, 2.21086308e-01f, 3.90969999e-02f, 3.22035849e-02f, 1.64041162e-01f, -3.08903120e-02f, -1.40903041e-01f,
  -1.07584439e-01f, 7.25936564e-03f, 2.05566585e-01f, 6.92740083e-02f, 4.06253397e-01f, 6.44956306e-02f, -6.61068363e-03f, 9.49948728e-02f, 1.23912066e-01f, -3.23542655e-02f,
  -9.00914446e-02f, -8.41608495e-02f, 8.57584551e-02f, -1.20812528e-01f, 1.38213366e-01f, -6.03821594e-03f, -2.02392146e-01f, 1.92795798e-01f, 5.22520989e-02f, 7.76391998e-02f,
  -1.44695388e-02f, 1.74525931e-01f, -5.90915345e-02f, -8.79852399e-02f, 1.26829565e-01f, -2.72551149e-01f, 2.20880553e-01f, -7.36483037e-02f, 1.44717582e-02f, 1.93625409e-02f,
  -3.59028503e-02f, 2.73008287e-01f, 2.11249948e-01f, 1.85771077e-03f, 1.97184607e-01f, 2.24578157e-01f, 1.85936183e-01f, -4.42477196e-01f, 2.17175215e-01f, -1.86003610e-01f,
  1.36652410e-01f, -2.57376015e-01f, 2.34624535e-01f, -1.11509442e-01f, 8.67520496e-02f, 2.29819074e-01f, 4.44233380e-02f, -2.80130338e-02f, -1.88440025e-01f, 1.55817688e-01f,
  -5.65976948e-02f, 2.14168623e-01f, -1.16074614e-01f, 1.02579214e-01f, 1.70984566e-01f, -1.93901300e-01f, -5.16880006e-02f, 5.97835779e-02f, -1.00908317e-01f, 1.27713397e-01f,
  1.18243679e-01f, -3.25068444e-01f, 5.21571899e-04f, -2.02287197e-01f, -6.21742867e-02f, 1.45092949e-01f, -4.04536664e-01f, 3.77679132e-02f, 2.51380265e-01f, -1.07690848e-01f,
  9.12898034e-02f, -4.04957533e-02f, 8.65433216e-02f, -3.96633595e-01f, -1.71308324e-01f, -4.14763205e-02f, -6.79819435e-02f, 2.15632424e-01f, -2.11461708e-01f, 1.85153589e-01f,
  -5.10269925e-02f, 2.19609559e-01f, -1.36798978e-01f, 1.36442900e-01f, 2.87147522e-01f, -3.49332206e-02f, 1.23857327e-01f, 5.29105887e-02f, 1.23480059e-01f, -1.42294139e-01f,
  -5.78872263e-02f, 2.28531435e-01f, 2.16500014e-01f, -3.10551263e-02f, 4.95129451e-02f, 1.63835257e-01f, 1.21834733e-01f, -4.84508723e-01f, 3.52966160e-01f, 3.81449282e-01f,
  -5.17872535e-02f, -2.40264073e-01f, -2.46738896e-01f, -4.39536795e-02f, 5.05466573e-02f, -6.78854361e-02f, 2.39390790e-01f, -1.55671075e-01f, 2.80838728e-01f, -2.75638640e-01f,
  -1.29447803e-01f, -7.93396309e-02f, 5.45872450e-02f, -1.61991298e-01f, 9.60232839e-02f, -1.95110753e-01f, 8.98579359e-02f, -1.08444922e-01f, -1.39219180e-01f, -1.48027822e-01f,
  1.33829087e-01f, 9.37579051e-02f, -1.20222503e-02f, 3.35833728e-02f, -4.86134775e-02f, 1.31798945e-02f, 6.01268671e-02f, 5.04614189e-02f, 5.41597009e-02f, 2.40172833e-01f,
  5.23177162e-02f, 3.71371657e-01f, 8.19862634e-02f, 5.20113744e-02f, 2.86132008e-01f, 1.18521273e-01f, -3.54279280e-01f, -9.13314521e-03f, 7.61044472e-02f, 2.99115647e-02f,
  -2.55291283e-01f, 3.28806937e-02f, -2.30100714e-02f, 2.02568084e-01f, -2.26483315e-01f, 3.38231653e-01f, -7.23140454e-03f, 1.10556809e-02f, 2.27462724e-01f, 1.60490096e-01f,
  -8.01842567e-03f, -1.09194055e-01f, 7.19460696e-02f, -2.47018665e-01f, 2.09499300e-01f, 3.15681957e-02f, 8.79319087e-02f, -1.52267262e-01f, -1.93746954e-01f, 3.53427500e-01f,
  1.26661718e-01f, 2.00964715e-02f, 8.15041587e-02f, 1.72177106e-01f, 1.25400662e-01f, -2.51576334e-01f, 1.17831990e-01f, 5.62570356e-02f, -4.91120964e-02f, -4.02622074e-01f,
  1.52364850e-01f, -1.19506620e-01f, 1.45920411e-01f, 2.32039705e-01f, -2.79045268e-03f, -6.78901747e-02f, -1.54228404e-01f, -1.96118448e-02f, -1.10823773e-01f, -1.38278529e-01f,
  -1.35054812e-01f, -6.19673692e-02f, 1.52466759e-01f, -2.27346674e-01f, -1.73712492e-01f, 2.66771555e-01f, 1.69717699e-01f, 2.81830318e-03f, 3.29500847e-02f, -3.74528021e-01f,
  9.74533334e-03f, -2.55278975e-01f, -1.14167951e-01f, 2.71521121e-01f, -1.16664417e-01f, 8.33588615e-02f, 3.74418795e-01f, -3.48738544e-02f, 4.88154404e-02f, 2.91321222e-02f,
  4.57418971e-02f, -2.12307334e-01f, -2.00506151e-01f, 4.55310754e-02f, -4.06530090e-02f, 2.07191169e-01f, 4.68757190e-02f, 2.50093490e-01f, 5.50799929e-02f, 1.18723094e-01f,
  1.71264648e-01f, -1.07608028e-01f, 1.48218766e-01f, -7.58188367e-02f, 1.36274576e-01f, -4.07626480e-03f, 5.64280972e-02f, -1.32109955e-01f, -1.45210713e-01f, 3.15422677e-02f,
  3.38317454e-01f, 1.33858398e-01f, 3.18368465e-01f, 2.69499063e-01f, 1.42534956e-01f, -1.14698008e-01f, -1.56498864e-01f, -2.96737999e-01f, -1.08040690e-01f, 1.86956003e-01f,
  -2.95166045e-01f, 1.77124292e-01f, -8.92269537e-02f, 9.93112996e-02f, -1.04611434e-01f, -2.93303251e-01f, -2.42327154e-01f, -4.84132111e-01f, 2.36317106e-02f, -4.94833337e-03f,
  3.81041989e-02f, 1.53667107e-01f, 4.33728367e-01f, 1.90932542e-01f, 2.45198444e-01f, 2.06407890e-01f, -4.28541660e-01f, -1.40954638e-02f, 1.02757484e-01f, -3.46577227e-01f,
  -1.65207721e-02f, 5.11435494e-02f, 3.55784535e-01f, 8.67263526e-02f, 6.61042407e-02f, 1.49722928e-02f, 2.88832575e-01f, -2.79475212e-01f, 3.04846168e-01f, -6.93387389e-02f,
  -9.20943394e-02f, 1.91842541e-01f, -2.58211885e-02f, 2.34317500e-02f, -4.04417217e-02f, 2.02759683e-01f, 1.80065155e-01f, 1.23528652e-02f, -2.22234026e-01f, -1.37690470e-01f,
  6.06174469e-02f, 1.53297991e-01f, -4.77408022e-02f, -3.62729542e-02f, -5.38342074e-02f, -6.30697310e-02f, 1.44488931e-01f, 7.28794560e-02f, 7.11872652e-02f, -6.36652857e-02f,
  8.33194777e-02f, -3.51349004e-02f, 6.55713901e-02f, -8.88672322e-02f, -4.18066699e-03f, -3.89028341e-02f, -4.28957529e-02f, 5.71415015e-02f, 5.75641282e-02f, 2.54398495e-01f,
  -2.72539473e-04f, 1.24440804e-01f, -4.71983664e-02f, 2.04412252e-01f, 7.53764808e-02f, 1.62375808e-01f, 1.80825561e-01f, -4.43692245e-02f, -9.11625847e-02f, 4.20317426e-02f,
  -1.70169070e-01f, 9.91884395e-02f, 1.61012784e-01f, -3.71933095e-02f, 1.47200063e-01f, -1.03012659e-01f, -9.61376429e-02f, -6.40983433e-02f, -1.11341827e-01f, 4.43785079e-02f,
  1.43552512e-01f, -2.72860471e-02f, 7.32237399e-02f, 2.32879996e-01f, 1.70103818e-01f, 9.02626142e-02f, 1.01948351e-01f, -3.91500928e-02f, 1.51116237e-01f, -4.77126800e-02f,
  1.10582583e-01f, 1.05514862e-01f, 3.82127017e-01f, -3.00485313e-01f, 3.62374127e-01f, 1.23013191e-01f, 7.04270974e-02f, 5.84917367e-02f, 1.16755985e-01f, -1.26026487e-02f,
  -1.71374694e-01f, -2.54033376e-02f, 1.03062347e-01f, 7.83460438e-02f, -3.48537639e-02f, -2.30117533e-02f, 2.56478548e-01f, -1.51566684e-01f, 2.71387428e-01f, 3.30464542e-02f,
  -4.19339761e-02f, 1.63552910e-02f, 1.45870864e-01f, 1.78832114e-02f, 1.97470523e-02f, 3.70313913e-01f, -2.56281309e-02f, 1.61885500e-01f, 1.40901938e-01f, 1.95914432e-01f,
  4.05322045e-01f, -3.11197191e-01f, -1.03384675e-03f, -5.42814247e-02f, -8.86347368e-02f, -3.22189391e-01f, 5.90214953e-02f, -1.98974889e-02f, -3.02879661e-01f, 9.68557298e-02f,
  -9.10421237e-02f, -1.62048742e-01f, 1.79825556e-02f, -1.96829438e-01f, 1.69414565e-01f, -5.65472730e-02f, -1.90993994e-01f, 1.09386653e-01f, 1.70580447e-02f, -1.17695108e-01f,
  -9.62835625e-02f, 3.10599774e-01f, 2.68036783e-01f, -4.18151356e-02f, 2.17886772e-02f, 3.39268059e-01f, -7.54261613e-02f, -1.92699492e-01f, 2.66030710e-02f, 2.78051674e-01f,
  -2.70320922e-02f, 1.80235639e-01f, -3.00506562e-01f, 1.32308438e-01f, 2.80863971e-01f, -7.29984567e-02f, 3.75573561e-02f, 2.84416914e-01f, -8.51735920e-02f, 5.55525310e-02f,
  1.16803549e-01f, 8.63894634e-03f, -2.73310065e-01f, 2.38798946e-01f, 1.87480867e-01f, 1.24519095e-01f, 7.91247562e-02f, -2.55340617e-02f, 1.58957049e-01f, 9.82140899e-02f,
  1.50931701e-01f, -2.05916673e-01f, 1.10245526e-01f, -5.67139462e-02f, 1.66382059e-01f, -9.68125984e-02f, 1.14404194e-01f, -7.79268444e-02f, 2.03773484e-01f, -1.80668719e-02f,
  -8.93524215e-02f, 1.97692513e-01f, -2.47923341e-02f, 2.17924360e-02f, 2.81781666e-02f, -2.93963403e-02f, 2.29745219e-03f, 1.85297251e-01f, -6.60144351e-03f, -9.51362308e-03f,
  -3.34368646e-01f, 4.60847765e-01f, -2.63708770e-01f, 3.25043470e-01f, -1.01611622e-01f, 3.36037487e-01f, -2.02834666e-01f, 1.39080852e-01f, -1.34950936e-01f, -1.58607572e-01f,
  1.09634034e-01f, -9.56273749e-02f, 3.26403111e-01f, 1.36522308e-01f, 1.05595544e-01f, -9.76002514e-02f, 1.85904756e-01f, 1.44798502e-01f, -3.12778689e-02f, 1.06130958e-01f,
  1.27748162e-01f, -2.34713424e-02f, 5.65369204e-02f, -5.58479540e-02f, 1.35182396e-01f, 2.42005408e-01f, 1.51151195e-01f, 2.15498552e-01f, 1.74960703e-01f, -6.92547560e-02f,
  4.72873151e-01f, -1.75194770e-01f, -1.25428945e-01f, 1.66818604e-01f, 1.11886561e-01f, 1.82637498e-01f, 4.60501611e-02f, 1.98972687e-01f, 1.64038956e-01f, 2.47318447e-01f,
  1.02043428e-01f, -6.43221810e-02f, -1.61421165e-01f, 2.31018573e-01f, 1.17530487e-02f, 1.40060797e-01f, 6.66014329e-02f, 2.15000659e-02f, 1.76357269e-01f, -2.56926194e-02f,
  -7.54301064e-03f, 5.45491129e-02f, -7.05706552e-02f, 5.82470968e-02f, 1.05355948e-01f, 1.30112156e-01f, 2.76460499e-01f, 1.19406141e-01f, 1.77099124e-01f, 1.11572258e-01f,
  3.93375978e-02f, -3.71869206e-01f, -5.93504831e-02f, 1.03867397e-01f, -3.35819840e-01f, 7.03322515e-03f, -3.75689149e-01f, 7.93134198e-02f, -2.89449304e-01f, 1.38120741e-01f,
  2.23298296e-01f, -1.53783023e-01f, 3.94102514e-01f, -2.64455676e-01f, -5.10352813e-02f, -3.54976840e-02f, -1.30693480e-01f, -2.54395604e-01f, 2.55556673e-01f, 8.98087323e-02f,
  1.94595605e-02f, -9.59160998e-02f, -3.36655855e-01f, -2.76521623e-01f, 3.47011238e-02f, -1.55010700e-01f, 1.76675647e-01f, 3.48930284e-02f, -1.51139140e-01f, 6.19356632e-02f,
  -1.37605727e-01f, 1.50764093e-01f, -7.16229156e-02f, -1.59355268e-01f, 1.36186570e-01f, 2.59531438e-01f, 3.36279452e-01f, 4.13619518e-01f, 2.55800456e-01f, 1.42947853e-01f,
  -2.46265247e-01f, 1.02568701e-01f, 1.33730099e-01f, -1.25829920e-01f, -9.96063277e-02f, -1.49640143e-01f, 1.70935050e-01f, 1.26302376e-01f, 1.94206014e-01f, -6.25402927e-02f,
  2.17474461e-01f, 3.24889123e-02f, -4.19707336e-02f, 2.20479727e-01f, 2.18320906e-01f, 1.76729307e-01f, 8.07539448e-02f, 1.59826994e-01f, -4.02314996e-04f, 2.18898281e-01f,
  -4.94443141e-02f, 2.20483374e-02f, 1.66609809e-01f, -6.49974123e-02f, 1.31152824e-01f, 3.98358107e-02f, 1.99288666e-01f, -1.14871813e-02f, -1.57955915e-01f, 1.96614891e-01f,
  -7.33384266e-02f, -2.24953089e-02f, 2.10440993e-01f, 2.80957490e-01f, 1.05527133e-01f, 2.11560577e-01f, 1.28681853e-01f, 1.99701861e-01f, -1.68446660e-01f, -1.88803643e-01f,
  1.87413499e-01f, 1.69294357e-01f, 2.91805491e-02f, 1.72064286e-02f, 1.87392339e-01f, 3.18239391e-01f, 1.38718590e-01f, 4.31331210e-02f, 1.29655808e-01f, 1.72188237e-01f,
  5.71221821e-02f, 1.64004683e-01f, -1.29289195e-01f, 1.24633196e-03f, -1.34166598e-01f, 8.78033489e-02f, -1.13829032e-01f, -6.41347319e-02f, 9.24477205e-02f, 5.64259887e-02f,
  -7.54432678e-02f, -1.56811476e-01f, 8.10743049e-02f, 1.12198815e-01f, -2.69674748e-01f, -1.91442743e-02f, 2.94494718e-01f, 3.27658236e-01f, -6.57226443e-02f, 1.85283884e-01f,
  1.21039204e-01f, -1.01731271e-01f, 1.76241472e-02f, -1.44558653e-01f, -6.47377893e-02f, -1.86479352e-02f, -7.91947693e-02f, -2.62779713e-01f, 4.66712825e-02f, -7.00355694e-02f,
  -4.83741378e-03f, 8.50730389e-02f, -3.03253442e-01f, -4.81578521e-02f, -2.50685275e-01f, 5.75216636e-02f, 6.14542626e-02f, -2.32439861e-02f, 1.21109210e-01f, 1.57198563e-01f,
  -1.99847981e-01f, -6.62778467e-02f, -5.41471355e-02f, 2.12278932e-01f, 7.43907988e-02f, 2.53919810e-01f, -3.06557208e-01f, 3.38286683e-02f, -3.70634466e-01f, 3.68660241e-02f,
  -6.39886558e-02f, -2.32716307e-01f, 1.31900951e-01f, 1.88138083e-01f, -2.31805835e-02f, 4.71443823e-03f, 9.77436733e-03f, -3.09537679e-01f, 9.69354212e-02f, 2.88225204e-01f,
  -1.17757015e-01f, -4.93519045e-02f, 2.41417527e-01f, 9.11966264e-02f, -6.68538585e-02f, -1.33572683e-01f, 1.82584152e-01f, 2.99164653e-03f, 2.08261728e-01f, 1.76007107e-01f,
  1.11302689e-01f, 8.28846917e-02f, 4.60171074e-01f, -3.84791881e-01f, 2.59321243e-01f, -2.73424182e-02f, -5.61769605e-02f, 5.70713207e-02f, -9.36758295e-02f, 9.22991112e-02f,
  1.94465920e-01f, 1.44454122e-01f, 1.73049644e-01f, 3.35583389e-02f, -3.59185450e-02f, 7.92540908e-02f, 8.10900703e-02f, -2.09183190e-02f, 1.54014483e-01f, 1.36802658e-01f,
  1.62865460e-01f, 2.27377951e-01f, -2.91374885e-02f, 1.22058566e-03f, 9.19742361e-02f, 2.73886472e-01f, -1.04300424e-01f, 1.05409987e-01f, -1.88038722e-02f, 1.50788635e-01f,
  3.37703824e-02f, -1.03737816e-01f, 4.86196950e-02f, 5.02729602e-02f, -2.80294389e-01f, -2.55654901e-01f, 2.36396581e-01f, -4.37635817e-02f, -1.07994534e-01f, -2.84145530e-02f,
  2.34321013e-01f, -2.93042958e-01f, -1.27946049e-01f, 1.44858912e-01f, 1.38137089e-02f, 5.92617765e-02f, 4.35994826e-02f, 3.46924752e-01f, 1.04873240e-01f, 4.60295603e-02f,
  -1.86019570e-01f, 2.16582850e-01f, 2.72854179e-01f, -1.04330339e-01f, 2.43166432e-01f, 4.37688351e-01f, -7.45836869e-02f, -7.83857554e-02f, 5.47190271e-02f, 2.37001702e-01f,
  2.65551545e-02f, 1.20925475e-02f, -5.70204929e-02f, 5.00675850e-02f, 2.99327970e-01f, -8.79844949e-02f, -1.96997058e-02f, 1.93216633e-02f, -1.33753389e-01f, -1.60324782e-01f,
  -1.41509965e-01f, -2.06581190e-01f, -2.93964982e-01f, 1.45270631e-01f, -3.04672793e-02f, -6.58524111e-02f, 7.19100237e-02f, -1.24645367e-01f, -2.17437968e-02f, 1.93425149e-04f,
  -2.57397264e-01f, 1.51105389e-01f, 6.26852736e-02f, 3.09197861e-03f, 1.54945284e-01f, -6.19738698e-02f, -1.32310092e-02f, 3.68205048e-02f, -7.37591684e-02f, 2.21677735e-01f,
  6.99250996e-02f, -2.44806260e-01f, 1.57458652e-02f, -3.22859101e-02f, 1.26096964e-01f, 9.75557193e-02f, 1.46497875e-01f, -2.54557073e-01f, -7.60529563e-02f, -2.83390164e-01f,
  2.74838209e-01f, -3.62558842e-01f, -2.87778348e-01f, -1.70576438e-01f, -3.18607777e-01f, -2.91899413e-01f, 1.98931202e-01f, -2.45034382e-01f, -1.61105487e-02f, -2.84070969e-01f,
  -1.24610305e-01f, 4.28217739e-01f, -3.67958814e-01f, -2.09621713e-02f, 7.95858540e-03f, 1.62228599e-01f, 2.32835725e-01f, 1.24877855e-01f, 4.07146551e-02f, -6.79692859e-03f,
  -2.71047503e-01f, -4.22604941e-02f, 4.05654274e-02f, 1.31378351e-02f, 3.02951545e-01f, -2.70038575e-01f, -1.09851882e-01f, 7.40867630e-02f, 1.96713924e-01f, 2.90259778e-01f,
  -1.69107184e-01f, -1.47779003e-01f, 4.51745801e-02f, 1.72194332e-01f, 8.12098980e-02f, -3.66451889e-01f, -2.40176052e-01f, 9.00117755e-02f, -1.11735888e-01f, -1.67600691e-01f,
  -2.56752312e-01f, 6.74075708e-02f, 1.01111680e-01f, -1.57798707e-01f, -1.69887871e-01f, 2.50095427e-01f, 2.83617675e-01f, 1.31041616e-01f, 1.47903919e-01f, -8.21941569e-02f,
  -1.68587148e-01f, -8.99860114e-02f, 5.29850051e-02f, 2.69966900e-01f, 1.58781803e-03f, 2.11722538e-01f, 6.62814379e-02f, -2.25967661e-01f, 7.04895407e-02f, -1.58358619e-01f,
  -2.04290450e-02f, -1.18450001e-01f, 2.71231607e-02f, -2.08484516e-01f, 1.80731013e-01f, -1.90793276e-01f, -4.20426250e-01f, 1.48837328e-01f, -1.60233125e-01f, -2.98838437e-01f,
  8.57851356e-02f, -1.21745363e-01f, -1.09724775e-01f, -1.85641050e-01f, -1.44267842e-01f, 2.53655881e-01f, -3.51643533e-01f, -2.06268162e-01f, 4.16893996e-02f, 2.37664238e-01f,
  9.20680538e-02f, -1.29700184e-01f, 9.09925774e-02f, 2.62736827e-01f, -2.41544843e-01f, 4.40796465e-02f, 1.68451518e-02f, -1.00563448e-02f, 7.37418905e-02f, -7.09159151e-02f,
  -1.88288793e-01f, 8.79849121e-02f, 6.96223527e-02f, 4.81767863e-01f, -6.96947426e-02f, 7.76479095e-02f, 1.86424702e-01f, 9.31519866e-02f, 6.28651911e-03f, -3.00241351e-01f,
  3.52429487e-02f, -7.74679631e-02f, -1.18667096e-01f, -2.17248797e-02f, -3.30521137e-01f, 3.88284661e-02f, -9.71413627e-02f, 9.37523320e-02f, 7.65029341e-02f, 2.37385258e-01f,
  1.38085693e-01f, 1.39657825e-01f, 2.37416491e-01f, 4.43259180e-02f, 2.32485443e-01f, 1.72158077e-01f, 1.57645375e-01f, -6.73497096e-02f, 2.91983008e-01f, 1.34732798e-01f,
  2.30519086e-01f, 1.17043361e-01f, 2.65804231e-01f, 1.35566935e-01f, 6.99124560e-02f, -1.27871364e-01f, 2.33276993e-01f, 2.96954423e-01f, -2.35975191e-01f, -1.14631876e-02f,
  -7.51863122e-02f, 4.32212651e-02f, 1.50341153e-01f, 2.78749734e-01f, 3.74606580e-01f, 6.36653379e-02f, 2.34549895e-01f, 9.05939788e-02f, -2.50909269e-01f, -2.35081762e-01f,
  2.28510752e-01f, 3.87754031e-02f, 6.63444102e-02f, 1.44288331e-01f, 1.69418287e-02f, -4.24469970e-02f, 2.28520840e-01f, -5.95873147e-02f, 1.06292531e-01f, 9.96138752e-02f,
  -1.31134957e-01f, 1.66560903e-01f, -1.35847256e-01f, 1.22886635e-01f, -5.55456281e-02f, -7.57504851e-02f, 5.94660863e-02f, -8.25409815e-02f, -6.07784577e-02f, 4.21211183e-01f,
  -1.92039534e-01f, 5.49216904e-02f, 2.32582241e-01f, 2.31622577e-01f, -1.78691417e-01f, -2.00067043e-01f, -1.30053610e-01f, 1.87925279e-01f, -1.51339337e-01f, -1.10572707e-02f,
  5.30962534e-02f, 1.34123489e-01f, 1.51424736e-01f, -1.87798236e-02f, -2.41223862e-03f, 1.31623805e-01f, 1.20755665e-01f, 1.03580840e-01f, 1.49447635e-01f, 2.85095632e-01f,
  1.37316093e-01f, 8.23715050e-03f, 2.20376238e-01f, 1.89447135e-01f, 3.47624789e-03f, 2.33826190e-01f, 3.30024332e-01f, 5.02341054e-02f, -4.75634763e-04f, -3.67551227e-03f,
  2.22907513e-02f, -1.88884094e-01f, -5.79221435e-02f, -4.13432568e-02f, -6.87829405e-02f, -2.45469660e-01f, 1.03985555e-01f, 7.75345368e-03f, 1.32491738e-01f, 1.43383309e-01f,
  -2.70394934e-03f, -5.15306890e-02f, -3.61453444e-01f, -1.62211105e-01f, 1.67361945e-01f, 1.14951551e-01f, 3.23832989e-01f, 2.63926119e-01f, 9.43039358e-02f, 1.22589874e-03f,
  -3.19627076e-02f, 2.10364118e-01f, 3.65569703e-02f, -1.92094415e-01f, -9.72560719e-02f, 2.16208830e-01f, -5.85477762e-02f, 1.23855717e-01f, 2.31373571e-02f, -3.18433717e-02f,
  2.01112381e-03f, -2.24054337e-01f, -2.76699126e-01f, 3.43967140e-01f, -3.06634754e-01f, -7.03214556e-02f, 1.86607093e-01f, 5.10252863e-02f, -1.38296202e-01f, -1.96173400e-01f,
  -1.18865013e-01f, 1.31715655e-01f, -1.00728765e-01f, 1.07351102e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.84541922e-02f, 5.11419810e-02f, -8.38761777e-02f, 1.48288056e-01f, 5.88145219e-02f, -2.74689011e-02f, 3.00166700e-02f, 1.55970857e-01f, 1.72411487e-01f, 1.81092862e-02f,
  1.98283598e-01f, 3.71431746e-02f, 4.82393019e-02f, -8.38070235e-04f, 3.52781005e-02f, -1.10989712e-01f, 2.44998053e-01f, -3.11136786e-02f, -2.82234903e-02f, 1.97341405e-02f,
  -7.55171999e-02f, -3.11089475e-02f, -5.23200911e-03f, 4.47204933e-02f, 1.28496857e-02f, 1.01807088e-01f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.65343702e-01f, -7.76987746e-02f, 8.35658014e-02f, 1.12613305e-01f, 1.30215436e-01f, 9.60560888e-02f, -2.26485804e-01f, 9.15876552e-02f, 2.88686790e-02f, -9.70144197e-02f,
  1.51290894e-01f, -3.55879106e-02f, 3.59378383e-02f, -1.14882372e-01f, -9.47925597e-02f, 1.65261418e-01f, 9.86047536e-02f, 1.18381888e-01f, -2.42172897e-01f, 2.75536358e-01f,
  1.96922138e-01f, -1.46433309e-01f, 2.13252395e-01f, 2.16705859e-01f, 5.59977964e-02f, 3.12531032e-02f, -3.80508676e-02f, 2.26162411e-02f, -7.13102100e-03f, -7.54541084e-02f,
  1.35694861e-01f, 8.91993493e-02f, -1.39439464e-01f, 1.47805378e-01f, 3.98332886e-02f, -8.12717453e-02f, -3.00069265e-02f, 1.05292812e-01f, -1.53178841e-01f, 6.36930391e-02f,
  -1.84554253e-02f, 9.38763544e-02f, 7.15741217e-02f, 1.29485264e-01f, -1.51930973e-01f, 3.87574695e-02f, 2.10198890e-02f, 1.04412474e-01f, 4.65353690e-02f, -8.76796916e-02f,
  4.55988422e-02f, -1.72905311e-01f, -1.16488356e-02f, 8.77941623e-02f, 1.12670444e-01f, -5.68733774e-02f, -6.58319145e-02f, 2.42854103e-01f, -3.13451663e-02f, 1.76920459e-01f,
  -1.53316036e-02f, -6.23778999e-02f, 6.86592683e-02f, 1.04563922e-01f, 2.53707558e-01f, 1.32426158e-01f, 1.02030471e-01f, 2.30865646e-02f, 4.26714458e-02f, -8.93317759e-02f,
  5.09149171e-02f, -1.58456713e-01f, 1.60692364e-01f, -7.04359710e-02f, 1.63265496e-01f, -9.65109766e-02f, -1.24011226e-01f, -1.62514850e-01f, -1.82850808e-01f, 2.76868403e-01f,
  1.79064557e-01f, 2.30048806e-03f, -1.49971962e-01f, -1.04010820e-01f, 1.03672259e-01f, 3.62305567e-02f, -1.45194650e-01f, -3.19795400e-01f, -7.43977353e-02f, -1.73476592e-01f,
  5.54162748e-02f, -9.46743637e-02f, 1.08837716e-01f, 1.14280216e-01f, 1.10319152e-01f, -8.64885375e-02f, 5.56828280e-04f, 4.51672934e-02f, 1.21681355e-01f, 1.84143018e-02f,
  -1.53350532e-01f, -1.19605906e-01f, -5.82258068e-02f, 3.63889262e-02f, 7.82455504e-02f, 8.03482234e-02f, -1.42263889e-01f, 3.24999774e-03f, -9.54727456e-02f, 1.12193087e-02f,
  4.04248573e-02f, 1.30410865e-01f, 1.15234494e-01f, 9.36344080e-03f, -6.90271631e-02f, -5.95639087e-02f, 4.16541770e-02f, 2.76556425e-02f, -1.04387738e-01f, -2.23364621e-01f,
  -1.02007790e-02f, -1.43166929e-01f, -5.49341505e-03f, -2.23916396e-03f, 1.30218521e-01f, 4.76930402e-02f, -9.67013165e-02f, -1.51604310e-01f, -8.06386769e-02f, -4.17918526e-02f,
  1.99744515e-02f, 1.33562669e-01f, -1.49156943e-01f, 2.38629386e-01f, -1.64874986e-01f, -3.27789858e-02f, 2.66988054e-02f, 9.00242552e-02f, -6.25194460e-02f, 7.79270828e-02f,
  -4.80430909e-02f, -1.94149733e-01f, -1.73651993e-01f, 7.70089552e-02f, 2.55957901e-01f, 1.17928587e-01f, 1.96652561e-02f, 9.67538580e-02f, 3.04980606e-01f, -1.29877329e-01f,
  3.26959491e-02f, -4.59029302e-02f, 2.45817304e-02f, 4.64330763e-02f, 1.51112914e-01f, -1.53607100e-01f, -8.36805776e-02f, 3.44035923e-02f, -9.03776959e-02f, 1.31820962e-01f,
  1.72295421e-01f, -3.69430706e-02f, -3.26258987e-02f, -3.25331241e-01f, -1.65457636e-01f, 9.08091962e-02f, -5.20133413e-02f, 1.33991018e-01f, -1.56105772e-01f, 6.77414387e-02f,
  -5.84465312e-03f, 9.72838514e-03f, 1.10033732e-02f, 8.01461115e-02f, 9.11126286e-02f, -1.90192815e-02f, 1.69297710e-01f, -7.30939955e-02f, 1.12420082e-01f, 2.91439593e-02f,
  -1.67867124e-01f, -3.20993401e-02f, 5.20893955e-04f, -2.31032386e-01f, 1.35591522e-01f, -1.17551297e-01f, -1.99650049e-01f, 1.15013503e-01f, 4.45102677e-02f, -1.37537941e-01f,
  -1.23784401e-01f, -1.21418901e-01f, -1.72896445e-01f, 4.89141978e-02f, -2.73702025e-01f, 7.06934705e-02f, -7.57392049e-02f, 1.97846256e-03f, 2.70482805e-03f, -2.12811530e-02f,
  -1.72748119e-01f, 4.96519096e-02f, 1.22747757e-01f, 1.75921991e-01f, 1.27053196e-02f, 5.24970233e-01f, 1.24364719e-01f, -5.62042184e-02f, -1.31534124e-02f, 8.99214298e-02f,
  5.15285693e-03f, 9.43301618e-02f, 1.58550724e-01f, 1.80250570e-01f, 1.61577508e-01f, 4.43372652e-02f, 1.05270237e-01f, -5.52335307e-02f, 1.35059908e-01f, -2.30208978e-01f,
  -2.06915781e-01f, 2.21135896e-02f, -1.43439695e-01f, -3.13647725e-02f, -4.09461319e-01f, -4.04093452e-02f, 2.39851564e-01f, 9.28688273e-02f, -2.04522967e-01f, 1.50827453e-01f,
  7.34542832e-02f, -8.95216167e-02f, 1.89731717e-01f, -2.41401531e-02f, -1.69739306e-01f, -2.30681244e-02f, -9.88262594e-02f, 1.74006373e-01f, 6.68511540e-02f, 2.24530414e-01f,
  2.85550598e-02f, 4.92806472e-02f, -1.68110967e-01f, 1.09067902e-01f, 7.15496540e-02f, -5.64983264e-02f, -4.72818203e-02f, 5.44695407e-02f, -1.01235248e-01f, -3.77094783e-02f,
  -1.47890627e-01f, 3.50078195e-02f, -7.20961317e-02f, -7.06318766e-03f, 4.40236442e-02f, 2.27903977e-01f, 6.30506203e-02f, 1.53781861e-01f, 1.49354711e-01f, 4.08476591e-02f,
  1.32095337e-01f, 2.69921094e-01f, 9.18448567e-02f, 6.62258714e-02f, -1.06769517e-01f, 6.90792575e-02f, -1.11792639e-01f, 1.94709867e-01f, 7.50322640e-02f, 5.81663996e-02f,
  1.61433369e-02f, -3.56209949e-02f, -1.93859283e-02f, -3.82432379e-02f, -8.03607050e-04f, 3.79941538e-02f, -1.12477325e-01f, 2.04276349e-02f, 1.92959517e-01f, 1.65913075e-01f,
  -1.36999026e-01f, 9.40344259e-02f, 1.95177242e-01f, -2.04537123e-01f, 4.21641953e-02f, 2.61861295e-01f, 3.71871591e-02f, 1.58723786e-01f, 5.42397052e-02f, 2.26834062e-02f,
  -4.32864994e-01f, -8.11121613e-02f, 1.43466145e-01f, 2.44746089e-01f, -7.73255005e-02f, -6.44790232e-02f, 1.56709403e-01f, -5.46645969e-02f, 3.21576260e-02f, 2.38522410e-01f,
  1.21204518e-01f, 1.68842569e-01f, -2.91677117e-02f, -9.98262167e-02f, -6.41265810e-02f, 1.57800186e-02f, 7.74594322e-02f, 2.13345125e-01f, 1.41645849e-01f, -4.98513207e-02f,
  -4.82634902e-02f, 7.72466809e-02f, -4.17144038e-02f, 1.13086775e-01f, -1.00850917e-01f, -2.16781601e-01f, -2.44828030e-01f, -8.57718959e-02f, 4.12026681e-02f, 8.46203491e-02f,
  -1.54385492e-01f, 1.20700859e-01f, 9.68286097e-02f, -2.03648776e-01f, 8.57180804e-02f, 2.15019658e-01f, -4.49050702e-02f, -2.05776710e-02f, 7.59222209e-02f, -1.40668258e-01f,
  3.04043069e-02f, 1.34887546e-01f, -1.34897485e-01f, -1.54918768e-02f, -2.96375662e-01f, 6.74534440e-02f, -1.17133066e-01f, -9.59161893e-02f, -2.30177119e-01f, 1.15896650e-01f,
  2.40313306e-01f, -1.80104584e-01f, -1.30470321e-02f, 1.95022121e-01f, -1.61951676e-01f, -2.06769660e-01f, -1.09868874e-04f, 5.38616590e-02f, 1.03951283e-01f, 1.74275443e-01f,
  -2.65500337e-01f, 6.93409741e-02f, 1.25918612e-02f, -1.63926020e-01f, -1.45218655e-01f, -1.25540078e-01f, 6.32798746e-02f, 6.23337328e-02f, -1.66309178e-01f, -9.42140967e-02f,
  3.68952937e-03f, 1.45317763e-01f, 1.84958652e-01f, 1.57919116e-02f, -2.52595156e-01f, 1.51532367e-01f, -8.52599181e-03f, 1.20942675e-01f, 8.32163319e-02f, 1.82077572e-01f,
  2.45980173e-03f, 1.97053589e-02f, -2.53323376e-01f, -2.91877910e-02f, 1.24858402e-01f, -8.13872367e-02f, 8.22707545e-03f, 1.39234781e-01f, -9.13787261e-03f, 2.07508914e-02f,
  -1.36152178e-01f, -7.01610371e-02f, 4.67576273e-02f, 8.71339217e-02f, 2.87020896e-02f, 6.97270706e-02f, 3.47527526e-02f, 1.43180534e-01f, 1.73921421e-01f, -2.26520494e-01f,
  -1.78844873e-02f, -2.77958065e-02f, -3.94317834e-03f, -3.12921911e-01f, -3.42350416e-02f, -1.06098875e-01f, 1.53305009e-02f, 3.04769278e-02f, -5.39679192e-02f, -2.23071575e-02f,
  -2.09839761e-01f, 1.05803229e-01f, 2.12352704e-02f, -1.40253723e-01f, -3.18459496e-02f, -6.24813177e-02f, 2.18622252e-01f, -4.36818488e-02f, -1.38181880e-01f, 1.99337810e-01f,
  -1.55756772e-01f, -7.79335350e-02f, 1.27938777e-01f, 1.12342045e-01f, 7.36782849e-02f, -1.65098459e-01f, -7.77074918e-02f, 8.91694974e-04f, 6.90877140e-02f, 1.81741893e-01f,
  -1.77646875e-01f, 1.82012171e-01f, 5.82084507e-02f, 2.43396267e-01f, 8.61822590e-02f, -5.29578403e-02f, 1.20282412e-01f, -3.35799903e-02f, 1.22225182e-02f, -7.82395825e-02f,
  -2.19732478e-01f, -3.44429389e-02f, -1.02988869e-01f, 9.94780734e-02f, 1.58993244e-01f, 1.23537317e-01f, 1.15606621e-01f, 7.98407122e-02f, -4.83177304e-02f, 5.85461827e-03f,
  8.77536684e-02f, 7.34179541e-02f, 1.09020911e-01f, -1.13115638e-01f, 1.86241463e-01f, 9.28656757e-02f, -1.20495185e-01f, -6.39463216e-02f, -1.56066015e-01f, 2.02447008e-02f,
  -2.24863663e-01f, 5.32778352e-02f, 8.89544189e-03f, -1.72300607e-01f, -1.32429833e-02f, -2.87651062e-01f, 4.56822626e-02f, -2.83426166e-01f, -1.59962296e-01f, -1.49967549e-02f,
  -1.02811009e-01f, 1.22576818e-01f, 1.78295508e-01f, -4.14292701e-02f, -1.69484153e-01f, 1.65433317e-01f, 3.11346585e-03f, 1.54949218e-01f, -3.49622786e-01f, 1.66403465e-02f,
  3.76604199e-02f, -1.40715808e-01f, 1.89443216e-01f, -3.71092893e-02f, -1.56547219e-01f, 1.35934934e-01f, -5.82813993e-02f, -9.39529538e-02f, 1.33854300e-01f, -6.87170401e-02f,
  -1.21417239e-01f, -1.14254937e-01f, 2.28210703e-01f, -3.11967116e-02f, -7.05429614e-02f, -1.19330570e-01f, 1.16721138e-01f, 1.59584850e-01f, -1.10467188e-01f, -1.05036162e-02f,
  1.16483495e-02f, -1.35670513e-01f, 2.73006499e-01f, 3.46598476e-02f, -1.30756378e-01f, -1.16333924e-01f, 5.27396426e-02f, -1.86740443e-01f, 7.68636242e-02f, -5.90050258e-02f,
  5.47922105e-02f, -6.77524284e-02f, 1.33040443e-01f, 1.64408088e-01f, 8.36090371e-02f, -6.85903877e-02f, 2.08546724e-02f, 4.47416380e-02f, 2.12261066e-01f, 2.06058413e-01f,
  8.00432935e-02f, -4.75227125e-02f, 5.77615723e-02f, -2.47365553e-02f, 1.34708807e-02f, -1.97287984e-02f, 9.82456505e-02f, 8.84083137e-02f, -5.78329451e-02f, 2.67475337e-01f,
  -3.48354653e-02f, 7.66414180e-02f, -8.32744688e-02f, -7.48143122e-02f, 7.83796012e-02f, 5.29914871e-02f, 2.17466764e-02f, 9.82568115e-02f, -5.56119643e-02f, 9.65570733e-02f,
  7.50697628e-02f, -3.78553905e-02f, 5.73604926e-02f, 2.41643712e-01f, -1.43458903e-01f, 2.20516115e-01f, -5.73055185e-02f, -1.02555521e-01f, -3.04422230e-01f, 2.30378002e-01f,
  -2.07724348e-02f, -8.85192603e-02f, -1.95333928e-01f, 1.33380741e-01f, -3.32258604e-02f, -6.09686933e-02f, 1.26570806e-01f, 2.20955104e-01f, -2.61597969e-02f, -3.73190790e-01f,
  -1.40155321e-02f, 3.54641080e-02f, -1.70895100e-01f, 2.29453780e-02f, 1.96067855e-01f, -2.68841814e-02f, -1.96311682e-01f, -1.56084359e-01f, 2.65013337e-01f, -7.09581142e-03f,
  -3.79006602e-02f, -2.79419664e-02f, -2.20723916e-02f, -1.31845191e-01f, -1.34834900e-01f, 8.97380710e-02f, 2.97283940e-03f, 5.85066713e-02f, -1.63209081e-01f, 1.13011718e-01f,
  5.08678742e-02f, -3.25765871e-02f, -1.12630278e-01f, -2.56074462e-02f, 1.31192589e-02f, -6.04631230e-02f, -1.03201643e-01f, -5.38239144e-02f, -2.83131450e-02f, 1.37875870e-01f,
  7.41888806e-02f, -4.44824137e-02f, 4.33568209e-02f, -4.00678217e-02f, 1.46197900e-01f, -2.61623412e-01f, -1.83069617e-01f, -2.29544062e-02f, -8.46590400e-02f, 1.60671808e-02f,
  7.51985144e-03f, -4.55286242e-02f, -2.69279063e-01f, -5.50972447e-02f, 3.25293541e-02f, -2.85472404e-02f, -2.50298351e-01f, 1.08581267e-01f, 1.35113016e-01f, -1.91553142e-02f,
  -2.00375933e-02f, 5.47457673e-02f, 2.51652692e-02f, 7.79274255e-02f, 4.46133092e-02f, -8.51181820e-02f, 2.13354692e-01f, 2.66365130e-02f, -8.68182853e-02f, 6.96818978e-02f,
  -3.53124350e-01f, 1.50095820e-02f, 2.61524647e-01f, 1.63609579e-01f, -1.99610665e-01f, -7.02559948e-02f, -2.11782664e-01f, -6.58360794e-02f, 8.99768807e-03f, 1.32115573e-01f,
  8.48131254e-02f, -1.47930294e-01f, -1.58402175e-01f, 4.94599380e-02f, -1.45177975e-01f, -1.59959912e-01f, 1.80478603e-01f, -6.74742134e-03f, 5.13573829e-03f, -4.72918786e-02f,
  -2.89896373e-02f, 1.21237382e-01f, -1.15759708e-02f, -1.18349744e-02f, 7.26027265e-02f, -1.35940179e-01f, -2.63010599e-02f, 6.79627061e-02f, 1.44801617e-01f, -1.10918611e-01f,
  1.34915737e-02f, -1.37020871e-01f, -3.96414213e-02f, 1.06182888e-01f, 3.42381783e-02f, -2.55039036e-01f, 1.53373063e-01f, -6.28745407e-02f, -2.08799586e-01f, -2.09880304e-02f,
  -1.53507084e-01f, 1.73170250e-02f, 3.20124216e-02f, -1.80021301e-01f, -1.71061561e-01f, 5.47606312e-03f, -1.42106131e-01f, 7.06982911e-02f, 4.94460464e-02f, -3.75713050e-01f,
  -7.16450140e-02f, -2.46053323e-01f, -2.23656148e-01f, 9.28238928e-02f, 3.07394750e-03f, 5.49608544e-02f, -3.38612571e-02f, 9.84158292e-02f, 7.08183572e-02f, -1.86320275e-01f,
  9.85625833e-02f, -1.78947002e-01f, -8.01681131e-02f, 2.55688816e-01f, -8.08307603e-02f, 1.46443158e-01f, -1.17515661e-01f, 1.85196117e-01f, 1.01003744e-01f, -7.51443282e-02f,
  1.73307717e-01f, 5.93195409e-02f, 5.82548566e-02f, 1.33414706e-02f, 1.31791979e-01f, -8.49668980e-02f, -1.01638407e-01f, -8.95175785e-02f, -1.46598294e-01f, -2.55099051e-02f,
  -5.74133405e-03f, -1.69844717e-01f, 1.76215976e-01f, -2.41575211e-01f, 4.07865569e-02f, 6.38501272e-02f, -1.32736996e-01f, 3.29890028e-02f, 1.79294273e-01f, -4.60082032e-02f,
  1.46401405e-01f, -4.49360125e-02f, -1.91641718e-01f, 6.35835528e-02f, -1.15848966e-01f, -2.36239526e-02f, 1.56442493e-01f, 1.05483748e-01f, -8.67740884e-02f, 7.13603348e-02f,
  -1.60657644e-01f, 1.44405931e-01f, 2.90487371e-02f, -2.08800901e-02f, -1.86245274e-02f, -9.80447382e-02f, 3.78861427e-02f, 7.87021294e-02f, 2.00105876e-01f, 6.32728264e-02f,
  5.61237969e-02f, -1.58818051e-01f, 2.83026397e-02f, 1.75467402e-01f, 2.08986118e-01f, 2.12510526e-01f, 2.84505263e-02f, 3.35022241e-01f, -4.07469794e-02f, 1.24871902e-01f,
  4.74982662e-03f, 5.35388757e-03f, 3.96307260e-02f, -1.28489420e-01f, -1.75973967e-01f, -8.94085020e-02f, 1.39101759e-01f, -4.19427175e-03f, 1.14277638e-01f, 2.53925342e-02f,
  2.20468611e-01f, -1.68068215e-01f, -1.08709015e-01f, -1.11979239e-01f, -3.71508338e-02f, 5.25538772e-02f, 2.46707089e-02f, -8.46758783e-02f, -1.87948376e-01f, 2.27085291e-03f,
  7.33162556e-03f, 1.65379904e-02f, 4.68703695e-02f, -9.03094485e-02f, -1.70554549e-01f, -8.61868709e-02f, -1.55697063e-01f, 9.64086428e-02f, 3.23021002e-02f, 1.19498640e-01f,
  -2.12426960e-01f, 6.15119450e-02f, -4.65507768e-02f, 1.13973103e-01f, -3.26770209e-02f, -1.13877930e-01f, 3.87368649e-02f, 2.94692665e-02f, 9.83517468e-02f, 1.66236550e-01f,
  2.10628808e-01f, 1.86471254e-01f, 2.92725027e-01f, -7.72050023e-02f, -6.70385454e-03f, 8.77347216e-02f, 8.54346007e-02f, 1.90599948e-01f, -1.52074218e-01f, 2.12166816e-01f,
  2.94303715e-01f, 1.22286081e-01f, 1.37951285e-01f, -1.48224339e-01f, 9.30396616e-02f, 1.31031960e-01f, 9.70245451e-02f, 1.55810453e-02f, -1.50811464e-01f, -7.38375932e-02f,
  4.96672885e-03f, -2.37602927e-03f, 4.81595881e-02f, 8.39506015e-02f, 9.18220803e-02f, 1.61153320e-02f, -1.14801913e-01f, 1.31894737e-01f, 5.94654046e-02f, -3.81972380e-02f,
  1.29203036e-01f, 9.24255103e-02f, 3.62738341e-01f, 2.57341325e-01f, -7.56256878e-02f, -1.34302169e-01f, 1.31018743e-01f, 1.76277369e-01f, 1.14029437e-01f, 1.69294968e-01f,
  -2.77580991e-02f, -7.86264241e-02f, 1.75763726e-01f, 3.99399661e-02f, 2.19550952e-02f, 9.54647921e-03f, -1.26955718e-01f, -1.31720051e-01f, 6.25511035e-02f, -7.23211169e-02f,
  1.76803067e-01f, -9.11793783e-02f, 1.18134834e-01f, 1.18174449e-01f, 9.61243957e-02f, -4.85596061e-02f, 2.15252908e-03f, 1.05392367e-01f, 5.10686040e-02f, 1.12214260e-01f,
  4.33913432e-02f, 1.50940090e-01f, 1.54605567e-01f, 4.56664525e-02f, -6.24076016e-02f, 4.20209505e-02f, -7.13498145e-02f, 2.00372979e-01f, 7.13011622e-02f, -1.36724040e-01f,
  8.38521644e-02f, 1.39965713e-01f, -5.58615429e-03f, 2.18528703e-01f, 9.26014185e-02f, 1.93160381e-02f, 1.11545675e-01f, -2.06218868e-01f, -1.42672909e-02f, -4.75108856e-03f,
  -2.87055466e-02f, -1.33562967e-01f, -2.08157659e-01f, 1.30334005e-01f, -6.25026971e-02f, -1.79505780e-01f, 3.35285068e-02f, -1.80863246e-01f, -3.01973432e-01f, -6.88753724e-02f,
  2.95168273e-02f, 1.55824035e-01f, 2.16351226e-02f, -8.10189843e-02f, 8.60379189e-02f, -3.93756144e-02f, -9.29906294e-02f, 1.82871908e-01f, 2.34872311e-01f, 1.40430361e-01f,
  -1.01181380e-01f, -4.66558039e-02f, -6.97290003e-02f, -3.13380733e-02f, -8.51853341e-02f, -1.58846647e-01f, 8.31236094e-02f, -1.33630410e-01f, 1.83484375e-01f, -6.95693791e-02f,
  3.05606991e-01f, -1.27423152e-01f, 2.61282045e-02f, 7.97169134e-02f, -1.66854829e-01f, 1.32015848e-03f, 1.50807649e-01f, 1.64944500e-01f, 4.16291766e-02f, 3.03514153e-02f,
  3.70587520e-02f, -5.64685725e-02f, -2.65196472e-01f, 1.72532022e-01f, 3.28783505e-02f, -4.85875504e-03f, 1.36078924e-01f, 2.18942627e-01f, 1.03898801e-01f, 1.57567248e-01f,
  1.08285315e-01f, -6.32696087e-03f, -5.58873825e-02f, 3.89901996e-01f, -9.52969026e-03f, 1.26933176e-02f, 4.11653668e-02f, 6.41166866e-02f, 1.47202406e-02f, -3.68569121e-02f,
  -7.85904229e-02f, 2.02382088e-01f, 8.36299956e-02f, 2.60115620e-02f, -1.37078866e-01f, 1.75725371e-01f, -2.03760475e-01f, -2.41247445e-01f, 2.95545578e-01f, 1.12350695e-01f,
  -5.87468222e-02f, -3.37235898e-01f, -1.42940655e-01f, -1.88524947e-01f, 1.50785133e-01f, 1.24245435e-01f, -6.44887835e-02f, 1.24619156e-01f, 8.97813123e-03f, 3.27904284e-01f,
  -1.19393840e-01f, -3.14531773e-02f, 1.43859610e-01f, 6.59526139e-02f, -1.44094393e-01f, 6.94918483e-02f, 1.18326262e-01f, 1.05237469e-01f, 9.14439410e-02f, 1.56926870e-01f,
  -9.57126692e-02f, 3.78989317e-02f, -2.67043673e-02f, 1.82769075e-01f, -1.46980941e-01f, 3.64962183e-02f, 2.41586119e-01f, -8.52328241e-02f, -1.82914492e-02f, -3.55316103e-02f,
  -1.59240607e-03f, 2.07723118e-02f, 1.36292621e-01f, 6.84292316e-02f, -1.25218466e-01f, 6.62609413e-02f, 7.32565671e-02f, -7.42535293e-02f, 1.35447145e-01f, -2.41066627e-02f,
  -2.97598224e-02f, 2.67835781e-02f, -5.39642274e-02f, -2.23191261e-01f, -2.15730295e-01f, -1.50494605e-01f, 1.40488535e-01f, -2.09477693e-01f, -8.02296922e-02f, -1.13716282e-01f,
  5.85476495e-03f, -8.55825692e-02f, -7.83358812e-02f, 1.74931869e-01f, -1.07239194e-01f, 1.79111391e-01f, 2.46145371e-02f, 7.89588988e-02f, 2.75094248e-02f, -1.51944011e-01f,
  1.30386546e-01f, 2.50234753e-01f, 1.59552723e-01f, -1.88475892e-01f, 5.70077822e-02f, 8.82857963e-02f, -8.57112482e-02f, 4.10523638e-02f, -8.28491598e-02f, -4.75665517e-02f,
  1.03836730e-01f, -1.07986458e-01f, -7.25984424e-02f, 3.26046464e-03f, 2.40972489e-01f, -7.69864991e-02f, -1.36990830e-01f, -1.85994014e-01f, 1.90597638e-01f, 1.86256140e-01f,
  4.56108302e-02f, -1.82989776e-01f, -1.60518974e-01f, -1.10604905e-01f, -2.24374175e-01f, 4.77872677e-02f, -4.68241163e-02f, 1.12410791e-01f, -8.36182013e-02f, -1.40293881e-01f,
  -1.43014774e-01f, 1.28628075e-01f, 5.77751771e-02f, -1.05181433e-01f, 1.08410314e-01f, -1.19396485e-01f, -7.74485618e-03f, -1.73504233e-01f, 8.51725861e-02f, 1.24338537e-01f,
  1.69934765e-01f, 1.03429900e-02f, -2.23080114e-01f, -3.61828282e-02f, -1.04753599e-01f, -2.11301863e-01f, -1.48622580e-02f, -1.34598538e-01f, -2.43396491e-01f, -1.67398244e-01f,
  -4.95336279e-02f, -1.33437008e-01f, -1.91179439e-01f, -1.45027742e-01f, -2.82035954e-02f, -1.42124712e-01f, -1.13059826e-01f, -5.40073924e-02f, 6.31005764e-02f, -1.62907690e-02f,
  -2.10794017e-01f, 1.08751170e-01f, -2.29433812e-02f, -7.14093521e-02f, -1.46845922e-01f, 2.44612992e-01f, -7.93423355e-02f, -3.80924530e-02f, 1.44345723e-02f, 2.62214988e-01f,
  1.48277162e-02f, 1.93355441e-01f, 4.21425365e-02f, -1.18880339e-01f, -1.93187445e-01f, -1.19351640e-01f, 4.05909158e-02f, -4.15640138e-02f, 5.61372340e-01f, 1.90636069e-01f,
  -1.25826865e-01f, -3.88832659e-01f, 1.02217048e-01f, 1.09938659e-01f, -1.09980829e-01f, -9.52339694e-02f, 2.31733248e-02f, -1.28817022e-01f, -9.36299413e-02f, -1.80176012e-02f,
  -2.83348486e-02f, -1.80375099e-01f, 5.95082045e-02f, -8.14764351e-02f, -2.48304065e-02f, -1.76265016e-02f, -1.00566633e-01f, 4.06996608e-02f, -5.68857379e-02f, 1.33348405e-01f,
  -3.65328379e-02f, 3.93894799e-02f, 2.58046091e-01f, 1.35015860e-01f, 1.32519767e-01f, 4.92560007e-02f, -2.04988226e-01f, -1.26686782e-01f, 8.66393596e-02f, 1.57284424e-01f,
  3.42276171e-02f, 2.61800259e-01f, 8.73982757e-02f, 2.17766598e-01f, -8.47979560e-02f, 1.27449473e-02f, 1.10039540e-01f, -1.34312585e-01f, -1.57185733e-01f, 6.41672537e-02f,
  8.38630721e-02f, -6.45287260e-02f, -2.43109792e-01f, -8.21095109e-02f, 7.27948174e-03f, -6.28566965e-02f, 1.41821906e-01f, 1.57004729e-01f, 1.24522215e-02f, -1.25224963e-01f,
  -1.60557821e-01f, 1.45192936e-01f, -1.12512454e-01f, -1.42658547e-01f, -2.28139326e-01f, -2.09675670e-01f, 1.78352714e-01f, 7.33900443e-02f, -1.75101295e-01f, 2.33640417e-01f,
  -9.23512056e-02f, -5.81599446e-03f, -2.50587463e-02f, -4.02316935e-02f, -1.33529559e-01f, 2.27893367e-01f, -1.46145329e-01f, 1.71125885e-02f, 1.76264405e-01f, 2.61059552e-02f,
  1.92072123e-01f, 1.64419517e-01f, -1.16576016e-01f, 2.47815728e-01f, 1.21694408e-01f, 1.96402445e-01f, -1.16872296e-01f, 1.96902394e-01f, -9.89465192e-02f, 1.12828672e-01f,
  -9.31629166e-02f, -1.52789488e-01f, -5.80004230e-02f, -1.08164772e-01f, -5.63684888e-02f, 2.62288116e-02f, -2.28581533e-01f, 1.55247962e-02f, 1.73922211e-01f, 2.09270585e-02f,
  -4.80156094e-02f, -1.19012529e-02f, -1.46154732e-01f, 2.68908560e-01f, 1.95994020e-01f, 2.20300794e-01f, 9.35503319e-02f, -3.56814452e-02f, -2.65645795e-02f, -1.12038158e-01f,
  2.65515894e-01f, 1.88846573e-01f, -7.86042586e-02f, 2.63402432e-01f, 1.09460138e-01f, 1.65721714e-01f, 6.19047359e-02f, 2.03529745e-02f, -1.23888679e-01f, 2.54544616e-01f,
  1.86998129e-01f, 1.64148301e-01f, -3.92145403e-02f, -2.38649845e-01f, -2.44852468e-01f, 4.66941029e-01f, 1.17373735e-01f, -1.22732975e-01f, -1.54186010e-01f, -1.52035326e-01f,
  -2.51875222e-01f, 7.16154128e-02f, 7.07281232e-02f, -5.97065017e-02f, 1.49580956e-01f, 1.11900689e-02f, 1.87298462e-01f, 1.75389379e-01f, 1.21508315e-02f, -1.45901665e-01f,
  1.93840206e-01f, 3.81930210e-02f, -7.45267868e-02f, 6.01209002e-03f, 1.04423441e-01f, 6.93013966e-02f, 2.70587057e-02f, -8.27018451e-03f, 5.10868318e-02f, 1.54682070e-01f,
  -6.30750954e-02f, -7.72869214e-02f, -1.61083996e-01f, -2.44668782e-01f, 2.18406752e-01f, -2.62156546e-01f, 1.26717433e-01f, 5.09697981e-02f, 1.82110250e-01f, 1.29748479e-01f,
  -3.57446112e-02f, 1.58748060e-01f, 3.31687406e-02f, 7.97809213e-02f, 1.13008745e-01f, 8.57371613e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  8.45218897e-02f, -2.38112267e-03f, 2.26588905e-01f, 1.73297703e-01f, 2.32470140e-01f, 2.15486258e-01f, -8.48483369e-02f, 1.81799173e-01f, 1.20333970e-01f, 1.83624297e-01f,
  9.90297124e-02f, -6.04589060e-02f, 1.56047717e-01f, 5.85673302e-02f, 5.59805222e-02f, 2.70708501e-01f, 2.00169504e-01f, 2.75925919e-02f, -1.91916049e-01f, 3.81822824e-01f,
  3.59920003e-02f, -8.87692440e-03f, -1.12032093e-01f, 1.19520649e-01f, 2.10304726e-02f, -3.13184261e-01f, -2.83603400e-01f, -1.02562711e-01f, 1.37936464e-02f, -9.47296470e-02f,
  -1.12122826e-01f, -1.38451412e-01f, -5.52695198e-03f, 1.36813685e-01f, 1.54900759e-01f, 1.33231580e-01f, -3.67116816e-02f, 1.49072647e-01f, -1.23479411e-01f, -1.14604011e-02f,
  -8.36386532e-02f, 1.16180517e-01f, 1.49286643e-01f, 8.96953195e-02f, -1.30696595e-01f, 1.28882587e-01f, 3.09505880e-01f, 7.74559826e-02f, -2.88159330e-03f, -1.37358457e-01f,
  3.09110265e-02f, -8.41700658e-02f, -2.78476682e-02f, 3.04588489e-02f, 2.46430233e-01f, 4.13316861e-02f, -5.30118085e-02f, 2.14975670e-01f, -2.09097937e-01f, 5.83808757e-02f,
  -1.11800991e-01f, 5.23968749e-02f, 3.21450621e-01f, 2.23567396e-01f, 1.41262472e-01f, 1.08786844e-01f, 2.54692852e-01f, 2.43577659e-01f, 2.42679879e-01f, -1.04526505e-01f,
  1.68677419e-01f, 1.56677648e-01f, 4.60347347e-02f, 2.42966071e-01f, 1.27948418e-01f, 2.67829210e-01f, -9.49921981e-02f, -6.34844378e-02f, 4.52363640e-02f, -1.95955373e-02f,
  1.04387291e-01f, -5.47327101e-02f, 1.30968794e-01f, -1.81331653e-02f, -6.65135980e-02f, -2.11268052e-01f, -4.35123831e-01f, 2.30137214e-01f, 1.61401883e-01f, -7.03049600e-02f,
  7.54466280e-02f, 2.20583573e-01f, -3.53634030e-01f, 1.62697434e-01f, -1.20065976e-02f, -2.71792710e-01f, 2.12454081e-01f, -2.15389095e-02f, 4.39576469e-02f, 1.44992739e-01f,
  5.81422225e-02f, -2.20121473e-01f, 9.71438065e-02f, 1.31429866e-01f, 5.86621054e-02f, 1.22352444e-01f, -4.52311756e-03f, -1.10550158e-01f, 2.40309134e-01f, 3.69764050e-03f,
  3.54060262e-01f, 1.16863146e-01f, 2.21908331e-01f, -2.44060054e-01f, -1.42110497e-01f, -2.86569238e-01f, 3.99609953e-01f, -1.10264890e-01f, 3.35736126e-01f, 2.04238445e-01f,
  3.18560570e-01f, 6.47769645e-02f, -1.07958890e-01f, 4.06347990e-01f, 8.18114802e-02f, 2.04637721e-02f, 4.42645960e-02f, 9.35458466e-02f, 1.36901572e-01f, -5.00122197e-02f,
  -7.61542991e-02f, -1.94036126e-01f, -3.01835269e-01f, 2.22315788e-02f, 1.72074348e-01f, -4.43696715e-02f, 6.79373518e-02f, 1.57475531e-01f, -3.93035524e-02f, 5.74082769e-02f,
  1.10365525e-01f, 7.28920996e-02f, 2.14692026e-01f, 1.31986812e-02f, 1.02292011e-02f, 1.17109202e-01f, 1.37686804e-01f, -5.93602657e-02f, 1.82029903e-01f, 5.89704476e-02f,
  3.21268499e-01f, -3.06138009e-01f, -1.44388676e-01f, 5.88813722e-02f, 1.21926308e-01f, -2.73768336e-01f, 5.46479151e-02f, 2.95126021e-01f, -6.43821433e-02f, 2.61197180e-01f,
  1.65059313e-01f, -1.28708733e-02f, -5.72790876e-02f, -3.59767705e-01f, -8.23213905e-02f, 3.50687027e-01f, -1.70530856e-01f, 2.66280860e-01f, -1.22730665e-01f, -7.53730536e-02f,
  -7.33976960e-02f, 2.52634078e-01f, 3.32618088e-01f, -7.44384825e-02f, -1.43254027e-01f, -6.46776259e-02f, 1.58958510e-01f, 3.20306599e-01f, 3.90872031e-01f, 3.87780309e-01f,
  -6.74772114e-02f, 6.12074044e-03f, -8.82886648e-02f, -1.51693225e-01f, 3.18717480e-01f, -1.13353357e-01f, -3.97491336e-01f, -3.35147232e-01f, -9.78176389e-03f, 1.08364359e-01f,
  2.07470968e-01f, -7.06042200e-02f, 8.69716238e-03f, -1.56453326e-01f, 3.05469692e-01f, 1.63851321e-01f, 3.46856952e-01f, 6.92878366e-02f, 1.38618141e-01f, 1.89302534e-01f,
  1.18150502e-01f, 1.48411721e-01f, 5.11440746e-02f, 6.95449475e-04f, 7.71452785e-02f, 6.38484061e-02f, 2.15020925e-01f, 2.89286315e-01f, -7.14753708e-03f, -2.32631162e-01f,
  -2.30455160e-01f, 1.77844688e-01f, -1.55779600e-01f, 1.54467952e-02f, -9.29319039e-02f, 3.30630131e-02f, 2.84594353e-02f, 2.43711229e-02f, -2.55762227e-02f, 1.99247018e-01f,
  -2.75176346e-01f, -1.28154114e-01f, -2.30009183e-02f, -3.01131517e-01f, -3.84967774e-03f, -1.14760101e-01f, -1.12757742e-01f, 8.21205601e-02f, -5.93902133e-02f, -6.99078962e-02f,
  1.29037112e-01f, -1.34773776e-01f, -2.30644777e-01f, 3.11548442e-01f, 1.55497551e-01f, 1.27704635e-01f, 1.47944570e-01f, 2.30331905e-02f, 4.15002972e-01f, 1.01057909e-01f,
  2.23078609e-01f, -3.62564683e-01f, 5.80898151e-02f, -4.43264276e-01f, 2.79887822e-02f, -8.18748996e-02f, 4.15871948e-01f, 3.60839605e-01f, 1.34068921e-01f, 2.93835849e-01f,
  1.74822658e-01f, 3.65856797e-01f, -1.09736793e-01f, 8.73698574e-03f, -1.11910617e-02f, 6.29114509e-02f, -1.72879621e-01f, -5.94223700e-02f, -7.10313246e-02f, -1.04842102e-02f,
  -1.79289728e-01f, -1.21061867e-02f, -1.21580236e-01f, -3.36590479e-03f, -1.53649986e-01f, -8.88646469e-02f, -2.16441020e-01f, 1.29775777e-01f, -2.02319235e-01f, 1.10953040e-02f,
  -1.91217110e-01f, -6.89233914e-02f, -1.48891434e-01f, 1.13534890e-01f, 2.01870695e-01f, 8.02393705e-02f, -7.09653273e-02f, -1.10561319e-01f, 2.29924887e-01f, 1.58229008e-01f,
  4.12534289e-02f, 1.85539067e-01f, 1.66698262e-01f, -3.40504125e-02f, 7.13059381e-02f, -1.32274374e-01f, -2.46598691e-01f, 1.52214587e-01f, -1.29810035e-01f, 4.69603948e-02f,
  2.21575990e-01f, -1.81842998e-01f, 4.81131412e-02f, -1.12579100e-01f, 2.95613378e-01f, -1.05164811e-01f, 9.41286683e-02f, -2.92384297e-01f, 2.68966407e-01f, 9.87109691e-02f,
  -2.21869037e-01f, 2.00738698e-01f, -3.96831542e-01f, 6.51023313e-02f, -2.09500507e-01f, 2.70611793e-01f, 6.42526969e-02f, 2.16154516e-01f, 1.29763469e-01f, 5.71023813e-03f,
  -2.51664251e-01f, 1.04223698e-01f, -1.99500412e-01f, 1.13953516e-01f, 2.78295994e-01f, -1.26654238e-01f, -5.15204072e-02f, -2.39743322e-01f, 3.32916491e-02f, -6.25172406e-02f,
  -4.54507619e-02f, 1.02001891e-01f, -1.34146959e-01f, 8.20550472e-02f, -3.25097591e-01f, 1.24189049e-01f, -1.04664974e-01f, 3.52749527e-02f, -5.60176075e-02f, 2.35273898e-01f,
  -6.55605793e-02f, 3.33533809e-02f, 1.26188189e-01f, 2.16318324e-01f, 1.22741796e-01f, -7.16048628e-02f, 8.70554615e-03f, 2.23459706e-01f, 2.09004760e-01f, -4.51743126e-01f,
  -8.21030885e-02f, 3.92917991e-01f, 2.95849949e-01f, -2.35672921e-01f, 4.33815233e-02f, 2.50603080e-01f, 6.10084906e-02f, -1.20406903e-01f, 1.04378603e-01f, 1.60340622e-01f,
  9.41077247e-02f, -1.95507169e-01f, 3.41976546e-02f, -2.02527165e-01f, 2.35958114e-01f, 1.97587729e-01f, -4.88582328e-02f, -4.58360612e-01f, 2.37763807e-01f, 3.03166986e-01f,
  7.29500735e-03f, -1.29437864e-01f, -6.61660135e-01f, -4.44502831e-01f, 2.53611356e-01f, -2.20236704e-01f, 9.74812135e-02f, -1.09764047e-01f, 1.25043765e-01f, 1.86096743e-01f,
  1.30792499e-01f, 1.75236225e-01f, 2.75150329e-01f, 2.55056769e-01f, -1.87682092e-01f, 8.57110694e-02f, 7.10869581e-02f, -5.60858727e-01f, 1.54744521e-01f, -7.43114203e-02f,
  2.97512650e-01f, 1.18009202e-01f, -4.06225443e-01f, -5.10102153e-01f, 6.67943209e-02f, 7.53036737e-02f, -5.08910157e-02f, -2.50697583e-02f, -1.56046852e-01f, 2.90911138e-01f,
  -4.70245183e-02f, 2.94025075e-02f, -4.06378843e-02f, 3.30900811e-02f, -2.09364697e-01f, 3.33962962e-02f, 1.73475891e-01f, -4.55350399e-01f, -1.05928376e-01f, -3.33176583e-01f,
  -1.41173512e-01f, 1.57130927e-01f, 2.76862204e-01f, 9.48719159e-02f, -2.49847233e-01f, 1.33324012e-01f, 1.72081351e-01f, -1.15950163e-02f, -1.19462341e-01f, 1.53158203e-01f,
  -1.70235723e-01f, -2.30638266e-01f, 4.08620238e-01f, -1.14231683e-01f, 1.80971950e-01f, 2.29255334e-01f, 6.93804100e-02f, 8.12919736e-02f, 7.60566890e-02f, -5.21813929e-02f,
  3.26952904e-01f, 1.51186764e-01f, -4.00017619e-01f, 1.35503232e-01f, -8.73925909e-02f, -1.71791971e-01f, 3.31871957e-01f, 5.97034954e-03f, 1.72635734e-01f, -1.11503959e-01f,
  -2.31628880e-01f, -1.02433734e-01f, -1.86076418e-01f, 4.34895232e-02f, 2.79775500e-01f, 2.89826274e-01f, -2.28933245e-01f, 2.53497511e-02f, -3.10057908e-01f, 4.73370813e-02f,
  2.50144191e-02f, 8.51490721e-02f, 1.06231369e-01f, -4.28880937e-02f, 1.26751691e-01f, -5.04462980e-02f, 7.63434321e-02f, -1.63631320e-01f, 1.99026048e-01f, -4.00706887e-01f,
  1.72660574e-01f, -4.26867492e-02f, -1.06301485e-02f, -8.81586149e-02f, 1.17127128e-01f, 1.22259324e-02f, -2.73973584e-01f, 2.40389824e-01f, -4.14909162e-02f, -1.58026977e-03f,
  -2.10158661e-01f, -1.00535065e-01f, 2.04934180e-02f, -4.00529146e-01f, -2.40534052e-01f, -2.24049434e-01f, 2.26368174e-01f, -2.81223089e-01f, -3.00155997e-01f, -3.88005450e-02f,
  -1.31734172e-02f, 2.45788261e-01f, -1.11284228e-02f, 2.98623741e-01f, 1.68799162e-01f, 1.56028280e-02f, -4.63465974e-02f, -2.82452106e-01f, -1.82556182e-01f, -3.76372202e-03f,
  1.75594792e-01f, -2.16648370e-01f, -1.73863068e-01f, 1.43851817e-01f, 3.37715447e-01f, 2.93018073e-02f, 2.42489487e-01f, -2.37091571e-01f, -2.04663396e-01f, -2.20181391e-01f,
  2.60979742e-01f, 1.69716254e-02f, 1.06093876e-01f, -1.89240307e-01f, -3.48230042e-02f, -1.98217154e-01f, -5.22393640e-03f, 1.05607331e-01f, 9.40989032e-02f, 9.43285748e-02f,
  1.41001180e-01f, 1.87500462e-01f, -1.18409090e-01f, 3.58536094e-01f, 1.12379804e-01f, 1.87615693e-01f, 4.43813622e-01f, -1.71947107e-01f, -2.28919208e-01f, -3.17088097e-01f,
  1.22392122e-02f, -5.29582538e-02f, 1.16573878e-01f, 9.71038863e-02f, -2.38466393e-02f, 2.86344469e-01f, 2.08936930e-01f, -2.39071175e-01f, 2.02851832e-01f, -2.20355958e-01f,
  3.04020733e-01f, 4.32443619e-02f, -1.22483335e-01f, 2.70997852e-01f, 1.29778281e-01f, 3.33505310e-02f, 3.65808010e-02f, 2.75207944e-02f, -3.76931950e-02f, 4.86052446e-02f,
  5.60144335e-02f, -6.45951331e-02f, -5.93254082e-02f, -3.45156103e-01f, -2.57451415e-01f, 1.52070746e-01f, 7.07466230e-02f, 4.79212217e-02f, 1.48577034e-01f, 5.65315746e-02f,
  5.15472405e-02f, 2.31957704e-01f, 4.27360177e-01f, -3.31846297e-01f, 6.28073364e-02f, -1.58941552e-01f, 6.13827594e-02f, -6.47480562e-02f, -2.34100800e-02f, 1.03688456e-01f,
  1.60772335e-02f, 2.97667652e-01f, 1.08120903e-01f, 2.63507594e-04f, -2.20524386e-01f, 1.31335273e-01f, 4.59391981e-01f, -2.63752550e-01f, -1.59201249e-01f, -9.81000587e-02f,
  -1.81663647e-01f, -1.50429189e-01f, 1.61237076e-01f, -3.45152497e-01f, 3.45798284e-01f, -2.64350474e-01f, 3.10745865e-01f, 2.08595857e-01f, 4.25751477e-01f, -4.17992696e-02f,
  2.33926028e-02f, -7.52068907e-02f, 3.61592740e-01f, 1.56658977e-01f, 4.72241640e-02f, 6.36476502e-02f, -2.01730281e-01f, 1.23677263e-02f, 5.65455072e-02f, 9.93729532e-02f,
  1.08381532e-01f, -3.12801600e-02f, -1.60824992e-02f, 5.94091117e-02f, 6.84951395e-02f, 1.80435777e-01f, 2.08194956e-01f, 1.29059345e-01f, -9.61848870e-02f, 7.69204497e-02f,
  -8.91421735e-02f, 1.51945651e-01f, 2.14559764e-01f, 1.30124405e-01f, -2.88293511e-02f, 3.55629981e-01f, 3.00993234e-01f, -3.56116563e-01f, -6.85344562e-02f, 1.23327084e-01f,
  -2.85252985e-02f, -2.66887814e-01f, 1.42229959e-01f, -1.72955066e-01f, -6.53420165e-02f, 3.77433389e-01f, 8.60779136e-02f, -1.13261854e-02f, 1.72077373e-01f, 1.06533729e-02f,
  7.65238851e-02f, -2.66062140e-01f, -1.72296971e-01f, 2.69349366e-01f, 1.24723807e-01f, 2.95308590e-01f, 1.18064068e-01f, 3.19826245e-01f, 4.36437503e-02f, 1.17107682e-01f,
  6.08234890e-02f, 2.52497703e-01f, -1.56424209e-01f, 3.63689005e-01f, -6.53708875e-02f, 5.93163297e-02f, 6.85902014e-02f, -1.76272884e-01f, 1.42164186e-01f, -1.97916046e-01f,
  2.54502177e-01f, -1.86598837e-01f, 1.34306356e-01f, 1.38525218e-01f, -3.25106144e-01f, 1.52044773e-01f, 3.87663096e-01f, -8.38846415e-02f, 1.05317123e-01f, 2.88875699e-01f,
  2.33360440e-01f, 1.01003803e-01f, 1.04946584e-01f, 3.23812157e-01f, 2.98810631e-01f, -1.42721862e-01f, 1.19586706e-01f, -1.36557296e-01f, 1.41572610e-01f, 2.54990067e-02f,
  7.87198767e-02f, 1.09927692e-01f, -9.12267640e-02f, -1.06437504e-01f, 5.19959331e-02f, 6.26667440e-02f, 1.82271421e-01f, -1.07758299e-01f, 4.37044278e-02f, -2.47515477e-02f,
  7.31552690e-02f, -1.38633862e-01f, -1.52368441e-01f, -6.57840446e-02f, 1.45756587e-01f, -1.06734350e-01f, 3.45114261e-01f, -1.68211386e-02f, -1.52025864e-01f, 3.65883529e-01f,
  1.13224119e-01f, -1.39616489e-01f, 2.29081035e-01f, -1.80830546e-02f, -1.85965970e-01f, -3.91938239e-01f, 4.72312281e-03f, 2.55290717e-01f, -2.04059854e-01f, 1.18256003e-01f,
  -5.69700496e-03f, 2.53446907e-01f, -9.41954404e-02f, 1.54946014e-01f, 3.69906187e-01f, -1.05506316e-01f, -1.06204957e-01f, 1.69416368e-02f, 9.06428471e-02f, 3.15825343e-02f,
  3.21639210e-01f, 1.06757786e-02f, 1.19332135e-01f, -1.07080989e-01f, 1.12429030e-01f, 1.19080748e-02f, 2.55989462e-01f, 1.30040318e-01f, -3.29539120e-01f, 1.63761731e-02f,
  4.44734916e-02f, -6.93254545e-02f, 4.01910804e-02f, 4.43781950e-02f, 3.67142260e-02f, 2.66014129e-01f, 2.27429166e-01f, 1.07505500e-01f, 1.94072351e-01f, 8.03684909e-03f,
  -1.43119603e-01f, 1.56082183e-01f, 6.89461678e-02f, 3.08610052e-02f, 4.38226461e-02f, -4.38235253e-02f, -9.34403315e-02f, -3.43261436e-02f, -2.35402912e-01f, 1.96251452e-01f,
  5.20522408e-02f, 2.34285612e-02f, 1.02052860e-01f, 3.00644070e-01f, -2.62036547e-02f, -4.14038338e-02f, 5.66665009e-02f, -5.69584370e-02f, -1.26873493e-01f, -2.53713340e-01f,
  1.82840183e-01f, -1.53907519e-02f, 2.40908027e-01f, 1.90795287e-01f, -1.92834616e-01f, 2.73844481e-01f, 2.83805206e-02f, 2.96673954e-01f, -3.93346190e-01f, -2.04906955e-01f,
  9.62330550e-02f, 2.28295296e-01f, -4.35813189e-01f, -1.24729529e-01f, 2.42460564e-01f, -3.81686576e-02f, 2.68435627e-01f, 1.45787254e-01f, -3.80815655e-01f, 2.04677597e-01f,
  4.17629294e-02f, 3.60690169e-02f, 4.19063829e-02f, 1.50844350e-01f, 1.25326673e-02f, 1.13065824e-01f, -3.77085179e-01f, -5.52829914e-03f, -1.28899083e-01f, -7.28722811e-02f,
  -2.09950194e-01f, 1.15456812e-01f, -4.19371039e-01f, 6.52153045e-02f, -1.40474617e-01f, -3.05209696e-01f, 2.23104700e-01f, 1.51118621e-01f, -1.02988414e-01f, -7.06891418e-02f,
  -2.47296810e-01f, 1.09603509e-01f, -1.41352499e-02f, -4.50927839e-02f, 4.12520654e-02f, 1.98330134e-01f, -7.21371397e-02f, 1.03771582e-01f, -1.12426214e-01f, -1.25325760e-02f,
  3.76498938e-01f, 8.19912925e-02f, -9.97745432e-03f, -3.43685262e-02f, -6.63695410e-02f, -1.68545097e-02f, 6.54076636e-02f, 1.83314100e-01f, 7.87936971e-02f, -2.08332434e-01f,
  3.05371284e-01f, 1.68204457e-01f, 2.38680672e-02f, -3.17429334e-01f, -3.46566588e-01f, -2.82667607e-01f, 2.92448878e-01f, -8.61643106e-02f, 4.26322632e-02f, 2.78837886e-02f,
  -7.20922127e-02f, 4.30932403e-01f, 7.59374574e-02f, 2.54937857e-01f, 2.04157814e-01f, 2.74424285e-01f, -1.92265913e-01f, 8.32137987e-02f, 2.45219901e-01f, 3.13216299e-02f,
  8.07782561e-02f, 1.48012921e-01f, -1.11531198e-01f, 1.47418961e-01f, -1.63967192e-01f, 1.56146586e-01f, -2.21781418e-01f, -7.45503679e-02f, 1.03884369e-01f, -1.63343772e-01f,
  2.48395592e-01f, -1.52228981e-01f, 7.90666640e-02f, 1.78560048e-01f, -1.71584621e-01f, 2.00586408e-01f, 1.22838609e-01f, -8.69398490e-02f, 2.40250528e-01f, 4.44628149e-02f,
  -3.01476773e-02f, 1.03410505e-01f, 2.56287277e-01f, 1.35718659e-01f, 1.70761928e-01f, 2.36553084e-02f, 1.67102560e-01f, 2.12479278e-01f, -4.15993109e-03f, 3.39879572e-01f,
  -6.60170168e-02f, 2.37012029e-01f, 9.39810276e-02f, 1.26085028e-01f, -8.29012468e-02f, 1.50801867e-01f, 2.26396978e-01f, 7.74584338e-03f, 2.75906384e-01f, 4.07251604e-02f,
  1.65098414e-01f, -5.70552051e-02f, -2.63348430e-01f, -7.12248981e-02f, -2.94815630e-01f, 1.55112877e-01f, 2.13114783e-01f, -1.38149545e-01f, -1.18848331e-01f, 2.71764904e-01f,
  -3.47925633e-01f, 6.48168251e-02f, -3.72608185e-01f, -2.33308285e-01f, 2.23532170e-01f, -9.25654825e-03f, 6.48551136e-02f, 3.90840113e-01f, 1.23803124e-01f, -3.70086461e-01f,
  4.23969567e-01f, -6.25549108e-02f, 1.12984434e-01f, 3.32538873e-01f, -2.18442939e-02f, -9.33559462e-02f, -1.33878151e-02f, 2.33049959e-01f, 5.52348793e-01f, 2.16684073e-01f,
  2.77343512e-01f, 7.27499276e-02f, -2.72265017e-01f, -1.95523843e-01f, 1.09077595e-01f, 2.55288750e-01f, 3.34346592e-01f, 1.86199412e-01f, -1.88808644e-03f, -1.68513972e-02f,
  -6.99196011e-02f, 2.25163266e-01f, -1.93005726e-01f, -1.47432992e-02f, -1.86676495e-02f, -2.74408218e-02f, -1.17919870e-01f, -4.13913503e-02f, -2.40482017e-01f, 5.26906028e-02f,
  1.90541763e-02f, 4.83926982e-02f, -7.61170015e-02f, -1.79126263e-01f, -6.88487515e-02f, -8.44550878e-02f, -3.35331932e-02f, -4.29315567e-02f, 2.58889124e-02f, 2.56466478e-01f,
  -1.33631557e-01f, -1.34384885e-01f, -1.66604042e-01f, 2.30713084e-01f, -7.94313028e-02f, 1.01114169e-01f, -2.00548753e-01f, 1.38188347e-01f, 4.06956464e-01f, 3.13243210e-01f,
  -7.27742212e-04f, 2.13209033e-01f, 2.14301482e-01f, -9.53427628e-02f, 1.14671420e-02f, -1.35827929e-01f, -1.10053465e-01f, 1.21792965e-01f, -2.85041869e-01f, -1.80090517e-01f,
  -1.79828197e-01f, -3.46835479e-02f, 2.22136185e-01f, 5.09329587e-02f, -2.37560999e-02f, -9.80624184e-02f, 3.66930440e-02f, -1.57623470e-01f, -1.81799177e-02f, 1.70637012e-01f,
  1.00896917e-01f, -6.74303174e-02f, -3.71523529e-01f, 1.45736903e-01f, -1.16746515e-01f, 8.80308822e-02f, 1.38635992e-03f, -1.16605267e-01f, 4.13504243e-01f, 1.90024480e-01f,
  -3.57997534e-03f, 2.83424765e-01f, -1.22161448e-01f, 2.24402204e-01f, 8.46531540e-02f, -2.56578654e-01f, -2.20217809e-01f, -2.00968772e-01f, -4.06124536e-03f, 1.22905627e-01f,
  4.04704005e-01f, 1.11582959e-02f, 3.49324904e-02f, -2.26091281e-01f, 1.08419575e-01f, -2.89271384e-01f, 7.31802285e-02f, -8.24718550e-02f, -2.84079071e-02f, 1.59503836e-02f,
  -1.94121841e-02f, 5.09437099e-02f, -1.59292430e-01f, -2.35503942e-01f, -9.16349217e-02f, 8.11304301e-02f, -1.31027445e-01f, -3.07284780e-02f, -1.52812928e-01f, -4.58081096e-01f,
  5.51453494e-02f, -1.93138525e-03f, -1.94860235e-01f, -4.92191613e-01f, -1.82256162e-01f, -3.78527194e-02f, -9.23093483e-02f, -1.76528599e-02f, 2.45034918e-01f, 1.12551577e-01f,
  9.03430283e-02f, 1.05988011e-01f, 6.45006895e-02f, 1.67676494e-01f, 1.00342147e-01f, 3.16727757e-01f, -2.95899689e-01f, 3.38809565e-03f, 1.15488749e-02f, 1.98909551e-01f,
  1.48502901e-01f, -4.97940890e-02f, 4.47117947e-02f, -1.26099348e-01f, 5.07038124e-02f, 9.84848887e-02f, -1.78288296e-02f, 1.42495349e-01f, 1.42759234e-01f, 2.13374287e-01f,
  1.38039223e-03f, 2.88956821e-01f, 9.11967382e-02f, -2.02863552e-02f, -2.02831961e-02f, -8.47011432e-02f, 2.36042634e-01f, -9.48693678e-02f, 5.62383654e-03f, -5.49051501e-02f,
  3.93624723e-01f, 5.47360301e-01f, -1.25172794e-01f, -2.69137770e-01f, 1.76412053e-02f, 1.00827143e-01f, 1.34294018e-01f, -1.05303302e-01f, 1.50562346e-01f, -4.45349872e-01f,
  -3.23085748e-02f, -5.90779409e-02f, 1.60675079e-01f, -2.36194417e-01f, 2.50227097e-02f, -3.72726619e-02f, -5.11883944e-03f, -5.26826978e-02f, 4.09412477e-03f, 5.14394976e-02f,
  -1.91734433e-02f, 1.13392599e-01f, -1.31415978e-01f, 2.73459613e-01f, 7.72268102e-02f, -1.86242759e-01f, -7.58184120e-02f, -1.25450313e-01f, 1.92007646e-01f, -2.52491623e-01f,
  -2.97198415e-01f, -1.64808765e-01f, 5.55159822e-02f, 5.35514159e-03f, 1.90899596e-01f, -4.61099111e-02f, -1.12124376e-01f, 1.79595724e-01f, 4.79413897e-01f, 7.06339329e-02f,
  -5.21651089e-01f, 1.93726540e-01f, 1.79858282e-01f, 3.19705725e-01f, 3.62360567e-01f, 2.58854568e-01f, -3.12504433e-02f, -8.28836039e-02f, -1.59818783e-01f, 3.55603285e-02f,
  7.91951492e-02f, 3.90710860e-01f, -1.20597057e-01f, 5.69022037e-02f, 7.76770338e-02f, -1.06689945e-01f, 1.05630502e-01f, -1.04434177e-01f, 2.52719015e-01f, -9.26382244e-02f,
  2.25242730e-02f, -3.49667296e-02f, -4.03904505e-02f, 2.59566784e-01f, 3.94166529e-01f, 2.75578678e-01f, 1.57726870e-03f, -4.30925153e-02f, 2.66072229e-02f, 4.51299846e-02f,
  1.62399895e-02f, -2.76881699e-02f, -2.27013469e-01f, -4.91487160e-02f, 7.23817348e-02f, 1.01590939e-01f, -2.01298282e-01f, 1.98359825e-02f, 2.66644489e-02f, 1.54769555e-01f,
  5.71872527e-03f, 1.23997666e-01f, -8.75199214e-02f, -7.83735700e-03f, 1.31281221e-03f, 1.68666869e-01f, 2.15596169e-01f, 2.52682209e-01f, 2.33999386e-01f, 1.42062344e-02f,
  3.48607928e-01f, 8.08739811e-02f, -9.37847346e-02f, -2.68098474e-01f, 8.62879455e-02f, -3.86796355e-01f, 1.28338411e-01f, 1.82819411e-01f, -2.51599371e-01f, 1.33002102e-01f,
  2.21677333e-01f, 7.16298521e-02f, 1.68895200e-01f, 1.02505730e-02f, 6.52874261e-02f, 5.44951558e-01f, -2.00778037e-01f, 1.89641729e-01f, 2.75738776e-01f, 2.42493391e-01f,
  7.74035305e-02f, 9.50205997e-02f, -5.28856122e-04f, 1.03709809e-01f, -1.55013949e-01f, 2.13741973e-01f, -1.21306866e-01f, 3.36033106e-01f, 3.75698358e-01f, 3.18551838e-01f,
  -1.78089235e-02f, 2.96283271e-02f, -5.63864224e-02f, -6.31660223e-02f, 1.25349969e-01f, 4.79321145e-02f, -2.04450399e-01f, -6.93653226e-02f, 3.17362398e-01f, 2.29014665e-01f,
  2.38457784e-01f, 1.16781697e-01f, 2.18746960e-02f, 3.05682361e-01f, 9.06225070e-02f, 1.81947611e-02f, -7.08037335e-03f, 3.16470563e-01f, -2.61974663e-01f, 3.75455469e-01f,
  4.87770848e-02f, 6.71578348e-02f, 2.17086509e-01f, -5.88286333e-02f, 1.64717242e-01f, 1.66797325e-01f, -1.59781560e-01f, 2.17205226e-01f, 1.11874007e-01f, 1.43997014e-01f,
  2.16309533e-01f, 1.67994633e-01f, 1.92396119e-01f, 1.18020646e-01f, 7.88906962e-02f, -8.99095461e-02f, -1.83159888e-01f, -3.18915933e-01f, 7.76437074e-02f, -1.59308940e-01f,
  1.81312457e-01f, 1.64309770e-01f, -3.30300897e-01f, 2.14716762e-01f, 5.08588478e-02f, 1.88272521e-01f, -1.13263190e-01f, -6.68792725e-02f, 2.27975637e-01f, -9.94068384e-03f,
  -3.22189540e-01f, 1.20739847e-01f, 2.91899890e-01f, 7.18593001e-02f, 1.16572738e-01f, 1.25802889e-01f, -3.24888915e-01f, 3.40733469e-01f, 6.33937642e-02f, 1.97763830e-01f,
  -3.14666554e-02f, 2.68040508e-01f, -5.86158745e-02f, 3.09297889e-01f, -2.84671456e-01f, 1.53663054e-01f, -4.94415453e-03f, -2.19906658e-01f, -1.12789243e-01f, 6.22482412e-02f,
  -4.96644258e-01f, -4.21573222e-02f, 5.65887354e-02f, 9.88294184e-03f, 7.07706660e-02f, 4.18935716e-02f, -2.10925508e-02f, 5.53037286e-01f, -9.79647860e-02f, 1.66108653e-01f,
  2.80526638e-01f, -2.52442118e-02f, -1.11657269e-01f, 2.80356735e-01f, 1.74512893e-01f, 1.98791161e-01f, 2.81938612e-01f, 3.32535416e-01f, 4.28430259e-01f, 6.13154948e-01f,
  3.46137702e-01f, -2.00331122e-01f, -1.80496350e-01f, 1.85228571e-01f, 3.74678284e-01f, 4.61388864e-02f, -8.07430223e-02f, 3.32208425e-01f, 5.77828698e-02f, -6.67058602e-02f,
  3.73236328e-01f, -2.41793647e-01f, -4.16295528e-01f, -1.85220078e-01f, -4.61106701e-03f, 9.55326855e-02f, -3.54154557e-01f, -4.53109443e-02f, -3.53574127e-01f, 1.09863773e-01f,
  3.51786852e-01f, 6.54591620e-01f, -2.20884308e-02f, -2.50452608e-01f, 2.02096477e-01f, 1.62008822e-01f, 3.48953933e-01f, 1.53289467e-01f, -5.57271719e-01f, -1.98906928e-01f,
  -2.81004876e-01f, 2.13160232e-01f, 2.51695335e-01f, 1.91751540e-01f, 3.30593795e-01f, 1.47794098e-01f, -8.37203339e-02f, 1.38111459e-03f, 9.82690603e-02f, 1.44468427e-01f,
  5.27456515e-02f, 9.49828848e-02f, -2.72333443e-01f, -2.06898510e-01f, -2.85715610e-01f, 1.65533140e-01f, -1.43579796e-01f, 4.25146639e-01f, 5.42549528e-02f, 1.42263293e-01f,
  -5.08547202e-02f, -1.56556573e-02f, 4.58399542e-02f, 4.95686419e-02f, -1.53247556e-02f, 1.74372885e-02f, 8.96597281e-02f, -3.92860733e-03f, 7.60334730e-02f, -3.15863527e-02f,
  1.34251639e-01f, 3.93006876e-02f, 1.33120254e-01f, 6.97299540e-02f, 2.70998508e-01f, -1.06160335e-01f, -3.58335748e-02f, -3.79706062e-02f, 2.60857306e-02f, 7.87769556e-02f,
  1.55780539e-01f, 3.13385241e-02f, 1.29554331e-01f, -1.55251086e-01f, 2.41199066e-03f, 1.86662138e-01f, 6.98232129e-02f, -6.02925159e-02f, -1.08571909e-01f, 1.21563464e-01f,
  9.05904397e-02f, 6.22724369e-02f, 7.02657774e-02f, -1.73483446e-01f, -3.54897857e-01f, -3.51534754e-01f, 9.61121023e-02f, 3.21072012e-01f, -2.97056019e-01f, 1.03343703e-01f,
  -1.59631133e-01f, -1.41571671e-01f, -1.19239755e-01f, 1.08083881e-01f, 2.93737203e-01f, -5.41808531e-02f, 4.90436740e-02f, -1.41702190e-01f, 4.03860882e-02f, 1.45175904e-01f,
  2.51018792e-01f, 6.91573098e-02f, 2.02097278e-02f, 5.01007736e-02f, 9.24768373e-02f, 2.66225748e-02f, 2.23860085e-01f, -3.43028009e-02f, -2.45144084e-01f, -2.25429296e-01f,
  -1.15369141e-01f, -9.14195925e-02f, 6.61657825e-02f, 2.30104849e-02f, -4.54084948e-02f, -1.22935779e-01f, 1.42372042e-01f, 2.24540457e-02f, -5.67188300e-02f, 1.77365858e-02f,
  2.91567832e-01f, 1.56019747e-01f, -1.65794730e-01f, 2.40386322e-01f, 9.72108096e-02f, 2.02569321e-01f, 8.17225277e-02f, 2.76455283e-01f, 9.64423642e-02f, -8.01691320e-03f,
  9.12809074e-02f, -2.26330617e-03f, 1.19108163e-01f, -4.08111662e-02f, -3.64744663e-02f, -1.32188439e-01f, 1.54873177e-01f, 3.05110484e-01f, 3.24881896e-02f, 2.39099950e-01f,
  4.03163970e-01f, -9.21457782e-02f, -3.05171758e-01f, 1.24145582e-01f, -1.43550321e-01f, 1.37876971e-02f, -8.46505444e-03f, -1.82754382e-01f, -3.97004634e-01f, -3.20225656e-01f,
  3.77966076e-01f, 6.54406622e-02f, 6.31137192e-02f, -2.70589828e-01f, -9.23629031e-02f, 7.61902565e-03f, 1.27754873e-02f, 2.23465487e-01f, 1.08371124e-01f, 1.32040441e-01f,
  -1.04593635e-01f, -5.63864820e-02f, 3.63107882e-02f, 1.52571231e-01f, 1.88770741e-01f, -6.01647981e-02f, 1.07874371e-01f, -5.61546683e-02f, -3.63258086e-02f, 1.53993815e-01f,
  1.88000679e-01f, 7.24399760e-02f, -9.40470248e-02f, -9.83386394e-03f, -2.70036995e-01f, -3.71463388e-01f, 2.18411133e-01f, 7.21200034e-02f, 1.71803549e-01f, 2.26532836e-02f,
  1.68908104e-01f, -1.57528985e-02f, 2.54852742e-01f, -2.78966904e-01f, -1.77802965e-02f, -1.15588620e-01f, 7.95147493e-02f, -5.31282015e-02f, -1.28830403e-01f, 6.09206855e-02f,
  -4.00660306e-01f, -3.19866270e-01f, -2.44546264e-01f, 8.40923041e-02f, -9.43001732e-02f, -8.44657794e-02f, 2.15759091e-02f, -2.86690056e-01f, -3.27220708e-01f, 1.79656312e-01f,
  -2.30756328e-01f, -1.98976323e-01f, -5.93760535e-02f, 1.40045077e-01f, 1.90300897e-01f, 1.30939052e-01f, 2.98199058e-01f, -3.28388363e-02f, 1.59367561e-01f, -4.53432463e-02f,
  1.39292017e-01f, -4.77472581e-02f, -5.19436747e-02f, -3.28246504e-02f, -5.43227978e-02f, -2.18321919e-01f, 1.58699051e-01f, 2.65084565e-01f, -1.66468080e-02f, -3.95238809e-02f,
  1.64759085e-01f, -6.64894506e-02f, 1.81432307e-01f, -2.20763478e-02f, -3.57537746e-01f, 4.42656726e-02f, 1.35636458e-03f, 9.67601314e-02f, -6.09371578e-03f, 1.48430198e-01f,
  3.49559128e-01f, 1.10001653e-01f, -5.44603802e-02f, 1.13953836e-01f, 1.43987477e-01f, 3.24103311e-02f, 1.43217176e-01f, -1.65660575e-01f, 2.66586900e-01f, 2.49184798e-02f,
  -1.42277658e-01f, -1.55411676e-01f, 4.99450304e-02f, 4.95441854e-02f, -6.81031495e-02f, 1.55153155e-01f, 1.25218052e-02f, 4.48596448e-01f, -1.35630548e-01f, 2.87604541e-01f,
  1.82441726e-01f, 2.60944694e-01f, 1.34435117e-01f, -7.00537860e-02f, 3.36108059e-01f, 1.72779411e-01f, 6.76561669e-02f, 1.04376137e-01f, 2.36712620e-01f, 1.82862282e-02f,
  1.34254813e-01f, -1.47512123e-01f, 5.04268669e-02f, 5.73319718e-02f, -7.73745105e-02f, 4.33140770e-02f, -2.62094021e-01f, -2.98657175e-02f, 6.37326613e-02f, -7.18946457e-02f,
  -1.37024254e-01f, 8.34254771e-02f, -1.63940638e-01f, 9.80683118e-02f, 7.05556273e-02f, 8.92922729e-02f, -3.28703821e-01f, 3.01979046e-04f, 3.94383907e-01f, -1.57539189e-01f,
  -3.13379437e-01f, -2.52146393e-01f, -7.14111254e-02f, -7.50983283e-02f, 1.14493988e-01f, -1.51928831e-02f, 1.79804265e-01f, 6.25697756e-03f, 2.22085625e-01f, -4.51128744e-02f,
  2.98356801e-01f, 2.74310242e-02f, 1.25983998e-01f, 2.02283934e-02f, -2.28286594e-01f, 2.40151398e-02f, -1.15309954e-01f, 1.42853335e-01f, 1.42914951e-01f, 1.68164805e-01f,
  -3.31101805e-01f, -1.66700035e-01f, -2.27831230e-01f, -1.64808743e-02f, 1.24552421e-01f, 3.93256694e-02f, 6.61394075e-02f, -1.45738766e-01f, 6.54008612e-02f, -2.12054640e-01f,
  9.78506729e-02f, -8.49201828e-02f, 7.41908327e-02f, 2.24005952e-02f, -1.00396179e-01f, -7.76469484e-02f, -1.32349595e-01f, -1.99948713e-01f, -2.11696938e-01f, -2.51522630e-01f,
  -2.79400736e-01f, -1.46822348e-01f, -3.74423414e-02f, 1.19078197e-01f, -1.36905629e-02f, -1.19699068e-01f, 1.14090018e-01f, 2.81398483e-02f, 5.81454597e-02f, -9.14745480e-02f,
  -1.84351861e-01f, -2.58848108e-02f, 1.93460256e-01f, 1.91041846e-02f, 3.64856988e-01f, -1.11687399e-01f, -1.07741626e-02f, 2.11642861e-01f, -1.02499805e-01f, -1.00841653e-02f,
  2.28024513e-01f, -7.88262263e-02f, -5.87067865e-02f, 2.01097116e-01f, -1.49103254e-01f, 1.25042260e-01f, 1.69296950e-01f, -3.18326019e-02f, 4.02420908e-01f, 1.05447888e-01f,
  4.04997133e-02f, 3.43179144e-02f, -2.47246861e-01f, 1.23166911e-01f, -3.71457338e-01f, 2.90348500e-01f, 2.62290329e-01f, 2.22456932e-01f, -1.45698711e-01f, 1.20221628e-02f,
  -1.52367428e-01f, 2.04864368e-02f, -1.15385346e-01f, -1.61490438e-03f, 1.48104010e-02f, -4.19269562e-01f, 1.80752918e-01f, 1.65074006e-01f, 4.15143110e-02f, -9.20771062e-03f,
  -5.92964999e-02f, 1.25947565e-01f, -1.36357266e-02f, 1.41503230e-01f, 2.76006293e-02f, 1.70892105e-01f, 2.62982100e-01f, -1.19957983e-01f, -5.04361391e-02f, -4.55891946e-03f,
  4.30187136e-02f, -1.34255141e-01f, 4.01917189e-01f, 2.19409391e-01f, 5.21646738e-02f, -5.85516542e-02f, -2.14397386e-01f, -1.14075430e-01f, -1.16021582e-03f, -9.51920897e-02f,
  -2.38900349e-01f, 5.55195808e-02f, 1.83923110e-01f, 1.26234114e-01f, 1.16900451e-01f, 1.71472520e-01f, -1.43213337e-02f, 8.10018256e-02f, -7.92909879e-03f, 9.54909697e-02f,
  1.37901410e-01f, -5.95968999e-02f, -1.45186350e-01f, 1.30465835e-01f, -5.17954111e-01f, -2.69220900e-02f, 2.58108675e-01f, 3.23871464e-01f, -2.73488820e-01f, -1.58655792e-01f,
  -3.73314440e-01f, -7.19116908e-03f, 1.22801021e-01f, 1.56893596e-01f, 2.51078874e-01f, 1.79122295e-02f, 1.45180905e-02f, -3.90230156e-02f, -3.43997627e-02f, -2.28658080e-01f,
  2.84513414e-01f, -4.57003750e-02f, 2.74929404e-02f, 2.13134795e-01f, 4.08381186e-02f, 2.72676110e-01f, 2.48450682e-01f, 3.00760627e-01f, -5.20853400e-02f, -1.41152337e-01f,
  -1.96355835e-01f, -9.74303111e-02f, 2.64132231e-01f, 7.58101791e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  7.34226927e-02f, -4.70486702e-03f, 1.41256779e-01f, 2.15799421e-01f, 7.50105530e-02f, 2.65116423e-01f, -1.32598370e-01f, -2.32047075e-03f, 8.63902178e-03f, 1.41584054e-01f,
  1.09182224e-01f, -2.06041589e-01f, -5.89263029e-02f, 5.31425215e-02f, 1.06587932e-01f, 7.71913081e-02f, -6.69056699e-02f, 1.29339114e-01f, 9.48611945e-02f, 1.42376915e-01f,
  1.77914932e-01f, 1.82321638e-01f, -5.58980554e-02f, 1.80304006e-01f, -1.57137379e-01f, 1.82916582e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.95821017e-01f, -2.11356729e-01f, -2.16540158e-01f, -1.86194971e-01f, -5.08953184e-02f, -1.27008289e-01f, -2.56680459e-01f, 7.79715031e-02f, -2.79546320e-01f, -5.08703552e-02f,
  -1.57456905e-01f, -4.57725413e-02f, 1.21910296e-01f, -1.44278765e-01f, -1.93889067e-01f, -2.78393418e-01f, -1.63252875e-01f, 3.08458135e-02f, 1.12930804e-01f, 4.79110666e-02f,
  -3.94292995e-02f, 1.92739628e-03f, -1.31855920e-01f, 1.67649597e-01f, 1.42743558e-01f, 3.11967265e-02f, 9.29525644e-02f, 8.68069232e-02f, 2.35275701e-01f, 2.22051024e-01f,
  7.29401857e-02f, -1.97821513e-01f, 7.65810162e-03f, 4.62235510e-02f, -1.02743559e-01f, -1.25764981e-01f, -2.42493391e-01f, 1.50832221e-01f, 8.36871564e-02f, -3.10348958e-01f,
  -1.37591630e-01f, 6.50373623e-02f, 2.19263583e-01f, -6.24061704e-01f, 1.93064302e-01f, 2.22338662e-01f, -1.95124388e-01f, -2.44829312e-01f, -1.88012019e-01f, 2.70294547e-02f,
  1.96973309e-01f, -2.77986616e-01f, 2.09920719e-01f, -1.34793878e-01f, -2.22648028e-02f, -4.75708991e-02f, -1.46188334e-01f, 2.99373288e-02f, -1.24774709e-01f, -3.79648656e-02f,
  1.13370880e-01f, -3.20384353e-02f, 1.12698592e-01f, 1.89444676e-01f, 1.05500571e-01f, -1.42171890e-01f, -2.63686746e-01f, 1.76051155e-01f, 7.79400766e-02f, -1.13477781e-01f,
  1.94242150e-01f, -7.97601417e-02f, 2.58812577e-01f, 2.48884231e-01f, -1.51131123e-01f, 1.81487933e-01f, -1.91397056e-01f, 1.02939866e-01f, 2.18271494e-01f, 5.19127697e-02f,
  -2.23183408e-02f, -7.67797157e-02f, -2.94398129e-01f, -2.86976963e-01f, -1.10444441e-01f, -2.98498005e-01f, 5.94020449e-02f, 1.74323291e-01f, -1.94535375e-01f, 2.56872535e-01f,
  1.32198200e-01f, 3.36611494e-02f, 1.69679642e-01f, -6.75877789e-03f, -5.61453067e-02f, 1.44475117e-01f, 1.27232060e-01f, -2.00991094e-01f, -9.19684321e-02f, 1.83331057e-01f,
  2.35183239e-02f, 6.06508069e-02f, -4.89687443e-01f, 1.00187093e-01f, -4.06009555e-01f, 6.93218708e-02f, 1.59504861e-01f, 8.83398354e-02f, -2.44081110e-01f, 2.88335741e-01f,
  1.14566222e-01f, -4.14716631e-01f, -6.48361370e-02f, -2.52806485e-01f, -8.87117237e-02f, 5.93422018e-02f, 1.65868267e-01f, -1.21969886e-01f, -3.65114450e-01f, -5.18395126e-01f,
  -9.61672440e-02f, 2.14626729e-01f, -4.43991320e-03f, 2.35901102e-01f, 1.08382486e-01f, -1.17088817e-01f, -2.06853747e-01f, 1.01115637e-01f, 9.78673175e-02f, -1.01043411e-01f,
  1.43926069e-01f, -3.28399651e-02f, -6.26984909e-02f, 1.26106858e-01f, -1.33207917e-01f, 1.09335132e-01f, -2.67243236e-01f, -1.17678113e-01f, 1.20059431e-01f, -1.39674738e-01f,
  2.54601508e-01f, -2.60162234e-01f, 5.16524762e-02f, -1.01024337e-01f, -1.18477486e-01f, -1.63308188e-01f, 3.15657407e-01f, 2.37429842e-01f, -3.81467581e-01f, -1.11729525e-01f,
  -4.63036090e-01f, -8.73971730e-02f, 2.55989373e-01f, -2.19394714e-01f, -1.72305733e-01f, 8.96697771e-03f, -1.83363348e-01f, 1.24774516e-01f, 5.85676767e-02f, 1.91252828e-02f,
  -1.06274933e-01f, 1.22602656e-01f, -3.24352175e-01f, 2.31563181e-01f, -3.35712135e-02f, 2.72540569e-01f, 4.95320410e-02f, 1.27408326e-01f, -2.13038966e-01f, 2.68680781e-01f,
  -1.48928493e-01f, -5.28816640e-01f, -3.40999991e-01f, 2.83045620e-01f, -4.29970443e-01f, -4.90761578e-01f, -4.43946838e-01f, -1.69190377e-01f, -1.47064179e-01f, 2.25493118e-01f,
  -2.96779037e-01f, -1.83966625e-02f, -5.21018445e-01f, -3.30928892e-01f, -4.21151370e-01f, -4.76906836e-01f, -2.89379060e-01f, 8.69500339e-02f, -2.32306272e-01f, 1.50980160e-01f,
  -2.37061784e-01f, 3.60549195e-03f, 1.41116083e-01f, -2.24442929e-01f, 4.93992865e-02f, -2.89679170e-02f, 2.44311497e-01f, -2.37256080e-01f, -2.29377896e-01f, -2.05034725e-02f,
  -1.85615778e-01f, -4.12012599e-02f, -7.14016929e-02f, -1.14009649e-01f, -2.13256348e-02f, -1.76157057e-01f, -1.18194543e-01f, 4.78099175e-02f, 3.45179215e-02f, -5.85262552e-02f,
  1.50856730e-02f, 2.26168215e-01f, 3.13875347e-01f, 1.90746654e-02f, -7.09693506e-02f, 1.79817811e-01f, 1.33691639e-01f, -2.46068105e-01f, -1.36912003e-01f, -1.23349261e-02f,
  -9.66816321e-02f, 1.01344205e-01f, -1.72935259e-02f, -5.22046685e-02f, -1.33333713e-01f, -9.36941430e-02f, 5.92442304e-02f, -1.88057274e-02f, 9.71509796e-03f, -3.56731445e-01f,
  2.53655072e-02f, -3.66237372e-01f, 3.96879502e-02f, -4.84804332e-01f, 1.98476715e-03f, -2.86563098e-01f, 2.05370113e-02f, -2.34607652e-01f, -8.62307176e-02f, 1.02431200e-01f,
  5.54868095e-02f, 1.38359979e-01f, -5.94741441e-02f, -2.94157207e-01f, -1.61214218e-01f, 2.70369977e-01f, 2.28025183e-01f, 1.95985720e-01f, 1.03596993e-01f, -2.57897139e-01f,
  -8.62443745e-02f, -4.47157413e-01f, 2.59848654e-01f, -3.51337463e-01f, 2.17935190e-01f, -1.05281860e-01f, -3.94323468e-02f, 2.23704532e-01f, 1.36155769e-01f, 1.11892708e-01f,
  -7.36282691e-02f, -2.62306631e-03f, 1.56333372e-01f, -1.78986266e-01f, 1.69073805e-01f, 1.14533760e-01f, 1.04662992e-01f, 1.07062213e-01f, 1.42863914e-01f, -1.18013434e-01f,
  -9.55085382e-02f, -1.88900918e-01f, -3.09916288e-01f, -1.90384984e-01f, 1.45441234e-01f, 3.30980457e-02f, -1.31069705e-01f, 2.44595110e-01f, 1.91277459e-01f, -1.18463136e-01f,
  -2.19751105e-01f, 1.89120263e-01f, -8.24335814e-02f, -4.89355705e-04f, -1.75414205e-01f, -1.68091223e-01f, 1.33687943e-01f, -2.14850903e-01f, -2.41096422e-01f, -4.95355986e-02f,
  1.36122108e-02f, -5.57908975e-02f, -5.16355820e-02f, 9.44565907e-02f, 6.32749964e-03f, -3.63471210e-01f, 1.11143902e-01f, -1.95901081e-01f, 1.91464245e-01f, 3.12368572e-01f,
  3.72932218e-02f, 3.04315165e-02f, -1.92815483e-01f, 1.43921748e-01f, -5.99276926e-03f, 2.35959813e-01f, -1.23151881e-03f, -1.99021623e-01f, 1.24953933e-01f, -2.79359639e-01f,
  -1.66168839e-01f, 1.48110583e-01f, 2.04329923e-01f, -4.25176799e-01f, 3.98433469e-02f, 1.66712075e-01f, -1.25468567e-01f, 5.78814521e-02f, 1.17515214e-01f, 4.37361598e-02f,
  2.67442048e-01f, 1.30169451e-01f, 2.93677598e-01f, 2.07862929e-01f, 2.60002147e-02f, 3.21819872e-01f, 1.36849225e-01f, 5.78936338e-02f, 7.97265396e-02f, 1.63023904e-01f,
  1.89053252e-01f, 1.13582529e-01f, -2.32951313e-01f, 8.63489956e-02f, -6.64004833e-02f, 1.27497420e-01f, 8.46033990e-02f, -4.55435961e-02f, -3.37577283e-01f, 1.44445598e-01f,
  -1.28113940e-01f, -9.67745781e-02f, 1.93102002e-01f, 1.15576841e-01f, 2.23337729e-02f, 1.36191949e-01f, -6.14913087e-03f, 4.51254472e-03f, 1.28393531e-01f, 1.11649811e-01f,
  1.65683124e-02f, -2.55894005e-01f, 1.50607124e-01f, -1.00828737e-01f, -4.61656079e-02f, -1.36480793e-01f, -3.56964499e-01f, -1.11069061e-01f, 1.47698093e-02f, 1.16074346e-02f,
  1.64431244e-01f, 1.46007270e-01f, -1.78811967e-01f, -2.27829367e-01f, -1.46237224e-01f, -2.77147889e-02f, 2.56788880e-01f, 1.64023146e-01f, 2.29895920e-01f, -2.84009069e-01f,
  -6.49843812e-02f, -1.79451019e-01f, 6.97549060e-02f, -1.77320287e-01f, -2.03344971e-01f, -6.15301989e-02f, -2.76634604e-01f, -2.77376771e-01f, 2.04621077e-01f, 1.73663244e-01f,
  -6.11377358e-02f, 3.57692875e-02f, -1.04690336e-01f, 2.54541039e-01f, 1.51307127e-02f, 2.05543756e-01f, 2.01515779e-01f, 7.28938654e-02f, -2.93236494e-01f, 2.00854585e-01f,
  1.81982532e-01f, -8.99618492e-02f, 2.75062174e-02f, -7.94199780e-02f, 2.48726904e-01f, 4.91237342e-02f, -1.48377582e-01f, 1.07275238e-02f, 2.85334617e-01f, 1.71381459e-01f,
  6.25848472e-02f, 1.63078621e-01f, -1.90966427e-01f, 1.57786980e-02f, 2.21476648e-02f, 5.38508631e-02f, 3.83259386e-01f, 1.83005303e-01f, 1.94425434e-01f, -3.36430520e-01f,
  1.64090335e-01f, 2.47799754e-01f, 2.65179634e-01f, -4.43737924e-01f, 1.48731679e-01f, -5.67527581e-03f, 9.90911275e-02f, -1.81881785e-01f, 1.16107218e-01f, 3.14652383e-01f,
  -1.66176572e-01f, -9.83590856e-02f, 1.07110836e-01f, 1.04124367e-01f, -1.93068504e-01f, 2.17077851e-01f, 1.31732272e-02f, -2.31910229e-01f, -8.86476710e-02f, -3.76663983e-01f,
  -1.31284326e-01f, 7.28334561e-02f, -3.96104842e-01f, -4.66053337e-01f, -4.67453927e-01f, 1.64323553e-01f, -1.23877063e-01f, -2.57288247e-01f, 2.23097399e-01f, -4.90045518e-01f,
  -2.52293497e-01f, 2.75482863e-01f, -1.88815355e-01f, -1.93073586e-01f, -5.65779686e-01f, -1.79654241e-01f, -1.00513719e-01f, -4.82322872e-01f, -3.08196843e-02f, 7.17482716e-03f,
  1.05949543e-01f, -1.89447463e-01f, 5.77249974e-02f, 8.46515596e-03f, 3.85309458e-02f, 1.99576169e-02f, -5.07216994e-03f, -1.44190878e-01f, -7.23800734e-02f, 1.11313410e-01f,
  2.03144759e-01f, 1.42848849e-01f, -6.64596334e-02f, -1.51729241e-01f, -1.02328569e-01f, -2.33821988e-01f, -1.21685332e-02f, -3.39754045e-01f, 1.19388990e-01f, 4.89702746e-02f,
  2.45146051e-01f, -1.51742473e-01f, -2.45427653e-01f, 2.12323904e-01f, -1.37213049e-02f, 3.71525735e-02f, -1.63349926e-01f, -2.10900813e-01f, -2.01043025e-01f, 1.75649170e-02f,
  2.96877086e-01f, 1.12614170e-01f, 2.55601197e-01f, 7.57368729e-02f, 9.83861908e-02f, -1.83897316e-01f, -2.09774435e-01f, -2.77775437e-01f, 1.81089208e-01f, -4.65260506e-01f,
  -2.26364881e-02f, 3.13592166e-01f, -2.24108458e-01f, -8.20926577e-02f, -3.22844565e-01f, -2.20581293e-01f, -4.69894826e-01f, -6.57815337e-02f, -3.16293612e-02f, 2.64299735e-02f,
  -1.31993443e-01f, 2.75093883e-01f, -6.86012506e-02f, 1.23734444e-01f, 2.02910811e-01f, 3.85605365e-01f, -7.21420348e-02f, -1.59840599e-01f, -1.60877809e-01f, 1.96366366e-02f,
  -1.84501633e-01f, -2.81824172e-01f, 9.30982679e-02f, -1.04845889e-01f, 4.66491953e-02f, 6.04766281e-03f, -1.04490593e-01f, -2.24412248e-01f, 1.41938711e-02f, -1.46983609e-01f,
  4.47853245e-02f, 6.62261248e-02f, -1.26723111e-01f, -2.70795137e-01f, 1.55360043e-01f, -8.68597627e-02f, 2.15482250e-01f, -6.24553524e-02f, 1.10933587e-01f, 9.15930346e-02f,
  1.16049275e-01f, -1.84177384e-01f, 4.17728603e-01f, 2.95554787e-01f, -4.96781111e-01f, -1.22257404e-01f, 1.61474198e-01f, 7.14408308e-02f, -2.07255438e-01f, -3.26405346e-01f,
  -8.78390521e-02f, 1.43438263e-03f, -1.12670295e-01f, -2.49384027e-02f, 2.61916965e-02f, -1.48054942e-01f, 1.06454991e-01f, 1.69961248e-02f, -1.09767184e-01f, 1.25814617e-01f,
  -3.75608057e-01f, 1.50902182e-01f, -1.37904495e-01f, 3.20251621e-02f, -2.23571405e-01f, 2.28768885e-01f, -9.95809883e-02f, -2.73515791e-01f, 2.60933459e-01f, 1.33687451e-01f,
  7.14813452e-03f, -2.05838978e-01f, -1.60990834e-01f, -1.01100635e-02f, -3.15088153e-01f, 2.98848212e-01f, 1.08998641e-01f, -3.07435542e-01f, -3.99433494e-01f, -2.22405180e-01f,
  -8.50703418e-02f, -3.71980757e-01f, 3.90835762e-01f, -2.29953498e-01f, -1.16434053e-01f, -2.63040721e-01f, -6.86084777e-02f, 4.14086208e-02f, 1.25465274e-01f, 2.33095974e-01f,
  2.64906526e-01f, 2.37973761e-02f, -1.00225545e-01f, 2.81114373e-02f, -2.32945263e-01f, -1.30752310e-01f, -8.27111453e-02f, -8.08925629e-02f, 1.01288766e-01f, -3.84196267e-02f,
  -1.61578923e-01f, -1.05223797e-01f, 1.74753949e-01f, 3.00197572e-01f, -3.41444872e-02f, 4.56187986e-02f, 6.32176995e-02f, 8.69443640e-02f, 1.76157340e-01f, 6.10055141e-02f,
  1.39710963e-01f, -1.94533706e-01f, -2.35691339e-01f, 2.27867201e-01f, -1.99524194e-01f, -6.96089789e-02f, 1.69937491e-01f, 2.95713276e-01f, 1.25502348e-01f, 9.12945345e-02f,
  -2.35602483e-01f, -2.30578676e-01f, 2.43537858e-01f, 2.27583405e-02f, 2.71938026e-01f, 4.00763787e-02f, -4.04365510e-01f, 1.22303575e-01f, -5.04815638e-01f, -2.07466558e-01f,
  -2.34795645e-01f, -4.81180459e-01f, -1.97850212e-01f, -1.36799393e-02f, -7.69094750e-02f, 2.43214369e-01f, -2.84166224e-02f, 1.09909587e-01f, -2.83163249e-01f, -3.16155642e-01f,
  -2.59602785e-01f, -1.78196952e-01f, 2.51686245e-01f, 9.55600739e-02f, -1.05155565e-01f, 2.87549421e-02f, -2.35878110e-01f, 3.34038287e-01f, -4.54649806e-01f, 1.08045824e-01f,
  -2.32375368e-01f, 3.58638950e-02f, -1.47507727e-01f, -1.68694764e-01f, -1.02989070e-01f, 9.70660523e-02f, -1.39945522e-01f, 2.28525177e-02f, -1.67925552e-01f, 1.37724563e-01f,
  -1.91475168e-01f, -1.40554920e-01f, -1.10419594e-01f, -1.32081494e-01f, -4.68468033e-02f, 1.33310094e-01f, 1.55894773e-03f, 2.21359625e-01f, 8.37581605e-03f, -2.58832633e-01f,
  -2.01784186e-02f, 2.04608113e-01f, -2.63788670e-01f, 2.46446848e-01f, -2.02561513e-01f, -1.67880801e-03f, 1.95639376e-02f, -2.67040849e-01f, 2.77402967e-01f, -3.12713116e-01f,
  -2.56215990e-01f, 3.43756467e-01f, 2.53187478e-01f, 2.84498245e-01f, -1.99596852e-01f, -3.29600871e-01f, 1.27502784e-01f, -2.63448417e-01f, -3.66025925e-01f, -1.80269122e-01f,
  3.44846755e-01f, -4.09005463e-01f, -3.08769464e-01f, 2.13010132e-01f, 4.51641500e-01f, -1.62489731e-02f, -7.67696043e-03f, -1.99901253e-01f, 1.79349408e-01f, -2.64901698e-01f,
  -4.65602189e-01f, -4.06819731e-01f, -4.23525572e-01f, 1.15591362e-01f, -3.61252159e-01f, 1.21856377e-01f, -6.14848956e-02f, -3.45779151e-01f, 2.56111294e-01f, -4.90794592e-02f,
  1.19281700e-02f, 1.39922023e-01f, 1.35662273e-01f, 1.46264523e-01f, -1.58933207e-01f, 7.91340023e-02f, -1.45880595e-01f, -1.98414564e-01f, 6.45446107e-02f, -1.86072350e-01f,
  -4.03717384e-02f, 2.00457182e-02f, -1.79528058e-01f, -7.81609043e-02f, -1.32894292e-01f, 1.30935803e-01f, -1.64237007e-01f, -8.86135474e-02f, -2.59221584e-01f, 1.36952838e-02f,
  1.27571076e-01f, 5.71659487e-03f, -2.12253466e-01f, 2.33916268e-01f, 1.35699496e-01f, 1.62808448e-02f, 2.02702343e-01f, -1.49728879e-01f, -2.04476878e-01f, 8.83009806e-02f,
  8.92078578e-02f, -3.27959150e-01f, -1.08359857e-02f, 3.05897146e-01f, -1.02422915e-01f, -1.87221915e-02f, -2.65503734e-01f, 1.70726240e-01f, 1.97908267e-01f, -3.02072287e-01f,
  3.35165560e-01f, 2.05247536e-01f, -8.47007520e-03f, 1.10278940e-02f, -4.08980936e-01f, -1.17927335e-01f, -2.29056388e-01f, -1.15975477e-01f, -3.92141253e-01f, -2.97944725e-01f,
  8.21063891e-02f, 2.97288209e-01f, -6.50689378e-02f, -9.05073658e-02f, 3.76725554e-01f, -2.28803530e-02f, -8.91644508e-02f, 5.50153945e-03f, 2.76431501e-01f, 2.01098755e-01f,
  -3.35006695e-03f, 1.46865681e-01f, -2.80907512e-01f, -2.22682253e-01f, -2.79642880e-01f, -3.52555454e-01f, -3.85900378e-01f, -1.71486795e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -7.90496320e-02f, -1.60515122e-02f, 8.29332545e-02f, -6.61676899e-02f, -2.33451501e-02f, 1.11343391e-01f, 1.49102002e-01f, 1.28582314e-01f, -1.26999840e-01f, -4.65349331e-02f,
  1.61884278e-02f, -9.88171771e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    