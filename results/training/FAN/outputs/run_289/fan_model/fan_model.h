/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.33894309e-01f, 2.01632470e-01f, 2.69555837e-01f, 1.01828210e-01f, -6.27832115e-02f, -3.28718215e-01f, -2.17166960e-01f, 8.48326162e-02f, 3.12255353e-01f, -6.89360499e-02f,
  -2.13644549e-01f, 2.64372200e-01f, 3.62967253e-02f, -3.07930440e-01f, -8.26057270e-02f, -6.02946095e-02f, -1.16305016e-01f, -1.04910426e-01f, 1.09058112e-01f, 1.06002361e-01f,
  7.71067142e-02f, -3.35983783e-01f, -8.62147510e-02f, -1.30046114e-01f, -2.60707885e-02f, 1.76984847e-01f, -1.16698816e-02f, -2.83212513e-02f, -9.20201614e-02f, -1.47797257e-01f,
  -2.05791801e-01f, 1.71890825e-01f, 8.57330114e-02f, -4.69791004e-03f, -3.04877688e-03f, -8.20325390e-02f, -1.17216073e-02f, -8.96278955e-03f, 4.81798537e-02f, 5.68343364e-02f,
  5.51769556e-03f, -3.38113122e-02f, -1.33803999e-02f, 1.47836620e-03f, -5.45150647e-03f, 5.95479086e-02f, 6.01628758e-02f, 4.38215816e-03f, 2.03044619e-02f, -2.10056007e-02f,
  -2.57697552e-02f, -4.63255681e-02f, 4.24897410e-02f, 2.11799820e-03f, 4.32781056e-02f, -2.73090620e-02f, -3.14439088e-02f, 6.47521690e-02f, 5.88660315e-02f, 3.75287086e-02f,
  4.08920422e-02f, -2.28609070e-02f, 2.94136498e-02f, -5.68649843e-02f, -3.79333906e-02f, -1.89766841e-04f, -1.19094383e-02f, -8.54304284e-02f, 5.88103980e-02f, 5.13729751e-02f,
  -1.34673005e-03f, 2.64117122e-02f, 2.11442467e-02f, 1.17482394e-02f, -1.30161662e-02f, 1.27017964e-03f, -1.11724492e-02f, 2.81978236e-03f, -2.35942639e-02f, -1.22185359e-02f,
  9.19720624e-03f, -1.86272897e-02f, -1.54805118e-02f, -7.02694580e-02f, -6.92528933e-02f, 4.12039645e-02f, -3.92716676e-02f, 3.50625627e-02f, -9.19665862e-03f, 3.43096554e-02f,
  1.11595504e-02f, 2.56700724e-01f, 4.16800845e-03f, -1.73773617e-02f, -2.51637790e-02f, 1.78070255e-02f, 3.85556184e-02f, -1.62042361e-02f, 3.23986895e-02f, -5.54490648e-02f,
  -4.44498211e-02f, 1.08427750e-02f, 1.42862629e-02f, -6.16905130e-02f, 3.61155458e-02f, -4.92340811e-02f, -3.92884761e-02f, 1.27562531e-03f, 1.90489646e-02f, 1.95859522e-02f,
  3.71447541e-02f, 1.35006243e-02f, 6.90404372e-03f, 5.26504889e-02f, 1.87319200e-02f, 2.18501501e-02f, 6.55285418e-02f, 1.02347266e-02f, -5.60131110e-02f, 9.34769399e-03f,
  3.11722547e-01f, -2.46789545e-01f, 8.08046162e-02f, 7.53209218e-02f, 7.70393461e-02f, 3.46103281e-01f, 1.46317154e-01f, -4.31596041e-02f, 5.24771288e-02f, -2.36920983e-01f,
  -1.10115692e-01f, 4.54627536e-02f, -2.62681454e-01f, 2.03870967e-01f, 4.05442417e-01f, -6.96531162e-02f, 2.30158895e-01f, 9.37005281e-02f, 5.84509745e-02f, -6.37690350e-02f,
  3.82699817e-02f, 3.53766941e-02f, -2.00396199e-02f, -3.38329040e-02f, 8.57374743e-02f, -1.16082780e-01f, -1.31367669e-01f, -1.11362077e-01f, -1.37983216e-02f, 7.19934255e-02f,
  1.52279451e-01f, -1.07526347e-01f, -7.27670342e-02f, 4.32943634e-04f, -2.11196523e-02f, -3.74486228e-03f, 1.72205549e-02f, 1.66026447e-02f, 2.72071045e-02f, 9.25394066e-04f,
  -9.88808554e-03f, 3.58964689e-02f, 3.00937351e-02f, 3.35315652e-02f, 2.72944774e-02f, -1.62043273e-02f, 3.40701304e-02f, 4.01017070e-02f, -1.10586695e-02f, 3.36365364e-02f,
  -1.14190318e-02f, 5.08698337e-02f, 3.34363468e-02f, -8.50885082e-03f, -4.08010464e-03f, 5.38504459e-02f, 5.66796400e-03f, 3.25644426e-02f, 7.39005022e-03f, 1.58360563e-02f,
  9.55630187e-03f, 2.11424604e-02f, 3.07165086e-02f, 5.68146147e-02f, 1.03134953e-03f, -3.81398313e-02f, 3.06348056e-02f, -3.52398530e-02f, 1.62888616e-02f, -3.36101046e-03f,
  2.31899209e-02f, 1.77993439e-02f, -1.05738053e-02f, -5.77231776e-03f, -3.57240364e-02f, -8.64262786e-03f, 1.70485340e-02f, -4.80854288e-02f, 5.48753105e-02f, 1.84124503e-02f,
  -2.37343963e-02f, 4.47600186e-02f, -1.43416021e-02f, 6.96607353e-03f, 1.68282874e-02f, 7.50884693e-03f, -4.48541045e-02f, 1.41870994e-02f, -3.03812791e-02f, 4.72082645e-02f,
  1.75635552e-03f, -2.19930947e-01f, -3.72020900e-02f, -1.22596202e-02f, 2.09280122e-02f, 2.90270206e-02f, 9.61590465e-03f, 3.57989594e-02f, -6.31102249e-02f, 1.90711003e-02f,
  5.37448190e-03f, 2.31372416e-02f, -3.14665586e-02f, 4.38604578e-02f, 5.68814576e-02f, -9.62457154e-03f, -6.06273264e-02f, -3.03156860e-02f, -6.74078125e-04f, -3.64467353e-02f,
  -1.83948912e-02f, -4.77674231e-02f, -1.83486454e-02f, 3.10837422e-02f, -1.73609890e-02f, -3.12001258e-02f, 3.51579040e-02f, 8.86123627e-03f, -3.22306901e-02f, -8.59721936e-03f,
  -1.99347913e-01f, 3.36324185e-01f, 8.51136595e-02f, -4.37416524e-01f, 1.53294072e-01f, 1.67115822e-01f, -1.41514286e-01f, 1.63468897e-01f, -3.61002594e-01f, 1.88644141e-01f,
  -1.11357942e-01f, -5.73405996e-02f, -4.66321446e-02f, -1.14966609e-01f, -4.43528801e-01f, -1.69795096e-01f, -1.02740131e-01f, -8.60308558e-02f, -6.51663020e-02f, 2.05505695e-02f,
  -1.53266266e-01f, -7.20113367e-02f, -2.68165972e-02f, 2.47053117e-01f, 9.71404761e-02f, 1.61216632e-01f, -2.90751625e-02f, 1.43653855e-01f, 1.71741024e-01f, 4.39246111e-02f,
  -2.80223377e-02f, -9.67379510e-02f, -3.96771319e-02f, 2.04675235e-02f, 4.54283366e-03f, 7.98355788e-03f, -2.13255044e-02f, -4.72365394e-02f, -2.06225663e-02f, -1.85673013e-02f,
  -1.76482613e-03f, 3.59735661e-03f, -3.08326203e-02f, -3.46043073e-02f, 5.10024503e-02f, 5.56517132e-02f, -3.27316066e-03f, -2.59957975e-04f, 6.86986521e-02f, 4.70074527e-02f,
  -1.48717817e-02f, -1.85954589e-02f, 2.55436450e-02f, -5.54764085e-02f, -1.52562847e-02f, -6.44915849e-02f, 3.15799303e-02f, 3.45707275e-02f, 1.67217311e-02f, -4.61046286e-02f,
  -4.10688808e-03f, -3.18705477e-02f, -2.10131444e-02f, -3.04589048e-03f, -3.02465763e-02f, 1.43397851e-02f, -4.02895398e-02f, -5.53092174e-03f, -3.87289301e-02f, -4.40386310e-03f,
  2.94189365e-03f, -5.77756390e-02f, -3.70526239e-02f, 2.46393513e-02f, -5.43528609e-02f, -1.17010018e-02f, -1.42278317e-02f, 1.39370617e-02f, -7.23776966e-02f, -4.93378146e-03f,
  1.54800275e-02f, -3.77062224e-02f, -3.00335174e-04f, 3.91367823e-02f, 3.55418934e-03f, -6.43681511e-02f, -2.71713622e-02f, 4.63773422e-02f, -2.54788972e-03f, -3.81076485e-02f,
  6.38541579e-02f, 2.30420157e-02f, 5.54013699e-02f, 5.38803823e-03f, -6.68835826e-03f, 1.56440195e-02f, -5.09517305e-02f, 2.29536425e-02f, 7.23392703e-03f, 1.14461565e-02f,
  -8.68220907e-03f, -3.02741360e-02f, 5.75555153e-02f, -2.55942717e-02f, -1.95617620e-02f, -1.78742297e-02f, -3.93725410e-02f, 1.24018034e-03f, -1.71609260e-02f, 3.97238433e-02f,
  3.19566354e-02f, 3.15995663e-02f, -8.28962401e-02f, 1.08428458e-02f, 1.22437235e-02f, 1.85061265e-02f, 9.84196365e-03f, 1.22104101e-02f, 5.11758849e-02f, 9.83248744e-03f,
  -4.02260602e-01f, 1.25419989e-01f, -1.10085785e-01f, -3.57133597e-01f, -5.20839244e-02f, -1.87573090e-01f, -3.19529563e-01f, 7.81813785e-02f, -1.28331915e-01f, 4.35736552e-02f,
  -3.12454998e-02f, -1.15065344e-01f, 2.74293888e-02f, -1.65980205e-01f, -1.91173539e-01f, 7.07110167e-02f, -3.31242442e-01f, -1.32185861e-01f, -1.38013123e-03f, -2.13914961e-01f,
  -3.34963202e-02f, -1.64970040e-01f, -2.67656855e-02f, 2.31382146e-01f, -1.70663178e-01f, 7.36166388e-02f, 3.70522924e-02f, 1.22650340e-01f, -5.38766086e-02f, -2.93150358e-02f,
  1.40289613e-03f, -5.06319292e-02f, -6.57192897e-03f, 1.04915358e-01f, -6.26655594e-02f, -5.01427501e-02f, 2.11806018e-02f, 4.07838337e-02f, 5.27771860e-02f, -1.92770138e-02f,
  -5.83853610e-02f, -1.26797166e-02f, 5.61438315e-02f, 3.10097355e-02f, -2.77476460e-02f, 6.71684593e-02f, 4.37891893e-02f, -1.52976569e-02f, -3.42623070e-02f, 9.65181552e-03f,
  1.28673781e-02f, 3.00661731e-03f, -8.30712318e-02f, 5.93324825e-02f, 4.84105153e-03f, -5.50329685e-02f, -5.72494194e-02f, 6.34989096e-03f, 1.69291422e-02f, 2.73848325e-02f,
  -4.24342556e-03f, -4.61298451e-02f, 4.39528525e-02f, 8.21133703e-02f, -1.46010052e-02f, 2.63766740e-02f, -2.12745070e-02f, 1.70638841e-02f, 4.92163189e-02f, -3.48295574e-03f,
  -3.28820571e-02f, 1.55394105e-02f, -1.83461104e-02f, -3.03071998e-02f, -3.41850370e-02f, -2.10114531e-02f, 9.89515148e-03f, 3.59462248e-03f, -6.05635457e-02f, 5.19650355e-02f,
  -5.89718390e-03f, -2.37225536e-02f, -1.12172244e-02f, 6.25850260e-02f, -1.67298056e-02f, -3.74881877e-03f, -3.14838588e-02f, -2.30350271e-02f, 2.58949697e-02f, 1.92018617e-02f,
  -5.85229660e-04f, -1.06515653e-01f, 2.27558557e-02f, -8.26709718e-03f, -2.49338467e-02f, 2.05286853e-02f, -5.83885498e-02f, -3.25234532e-02f, -1.59183200e-02f, -5.14242686e-02f,
  2.25117598e-02f, -4.55930457e-02f, -3.61153088e-03f, 3.10177691e-02f, 3.12387571e-02f, -5.18566519e-02f, -5.65494783e-02f, -1.52449999e-02f, -3.50505933e-02f, 5.65996207e-02f,
  -2.83206515e-02f, -1.71003025e-02f, -3.73832393e-03f, -3.17513645e-02f, 4.17847894e-02f, -7.63017237e-02f, -4.82525937e-02f, 3.47873233e-02f, -1.16477571e-02f, -2.16752607e-02f,
  5.88612616e-01f, -2.45407417e-01f, 1.65826604e-01f, -7.02255368e-02f, 9.61756632e-02f, 2.74555445e-01f, 1.44200549e-01f, -2.96479035e-02f, 1.61937922e-01f, -2.84579873e-01f,
  -2.32884645e-01f, 2.00797111e-01f, -1.23390362e-01f, -2.26305142e-01f, 2.80718237e-01f, -1.05404466e-01f, -1.74086869e-01f, -1.56459734e-02f, 1.86151359e-02f, -7.64528476e-03f,
  7.48663172e-02f, -2.85405040e-01f, -1.27420381e-01f, -1.94279432e-01f, 1.02678733e-02f, 3.40778865e-02f, -1.82216004e-01f, 6.59063533e-02f, -1.87955126e-01f, 6.24588178e-03f,
  -4.03386578e-02f, 2.82048956e-02f, 4.22014892e-02f, 1.03775188e-01f, 7.00277695e-03f, 7.32090995e-02f, 2.02252716e-03f, 6.46740794e-02f, 5.18000685e-02f, 1.45823006e-02f,
  2.82583702e-02f, 1.41258407e-02f, 1.05791399e-02f, 4.60905842e-02f, 8.79830718e-02f, 2.16986872e-02f, 2.71988213e-02f, 5.25382459e-02f, -2.96878684e-02f, -4.76902933e-05f,
  7.92938173e-02f, -3.44936997e-02f, 2.15467461e-03f, -5.94673725e-03f, 5.88736758e-02f, 6.86587207e-03f, 7.29714008e-03f, 2.20185276e-02f, -3.31153981e-02f, 3.06679402e-02f,
  -9.61678661e-03f, 4.87432778e-02f, -4.66947369e-02f, 1.59226917e-02f, -1.78027675e-02f, -5.22442050e-02f, -4.48193774e-03f, -5.52771091e-02f, 1.03042558e-01f, -4.23334092e-02f,
  1.26984529e-02f, 5.11192949e-03f, 1.91165018e-03f, 3.82336453e-02f, -3.04674059e-02f, -2.01147608e-02f, 6.90119490e-02f, -3.31848525e-02f, 5.41657470e-02f, 2.32184702e-03f,
  -2.46214978e-02f, -1.29082578e-03f, -7.49161281e-03f, -4.67614532e-02f, -3.86339687e-02f, 3.35026439e-03f, -5.07552400e-02f, 5.28641453e-04f, -1.68866608e-02f, -1.47671839e-02f,
  -1.28037900e-01f, -1.63540691e-01f, -1.96687039e-02f, -3.44487280e-02f, -7.52720684e-02f, -3.45375985e-02f, 3.90087534e-03f, 2.82395612e-02f, -6.87153777e-03f, 4.39328253e-02f,
  -1.62225384e-02f, -1.05845220e-02f, -3.72875482e-02f, -1.05917333e-02f, -6.30085766e-02f, -2.09805351e-02f, -8.71324819e-03f, -1.13618989e-02f, 1.44329583e-02f, -3.03005669e-02f,
  -6.62972406e-02f, 5.27289994e-02f, -1.87906821e-03f, 3.19509655e-02f, -5.19133694e-02f, -4.51251753e-02f, 2.85997875e-02f, -3.10864616e-02f, -5.39573934e-03f, -2.17349101e-02f,
  5.51994666e-02f, -3.32224071e-01f, -1.37437331e-02f, -6.84034228e-02f, -7.32622445e-02f, -3.78695339e-01f, -2.13291999e-02f, -2.64316440e-01f, -1.59587577e-01f, 3.83187062e-03f,
  -4.79720458e-02f, -4.68780883e-02f, 3.59911397e-02f, -2.97373921e-01f, -3.06547225e-01f, -9.22969431e-02f, -3.70753884e-01f, -4.20628116e-02f, -5.66890687e-02f, -2.68982463e-02f,
  -1.62333444e-01f, -1.52280822e-01f, -1.25273421e-01f, -8.58951807e-02f, 5.17414212e-02f, 6.34667054e-02f, 1.37069061e-01f, 1.96502447e-01f, -6.10580444e-02f, -2.82684267e-02f,
  -7.06289336e-02f, -1.23027191e-02f, 7.12442324e-02f, 1.02736764e-02f, 2.39781830e-02f, 1.22459963e-01f, 3.30811143e-02f, 1.15323544e-01f, 5.77544086e-02f, -4.31989022e-02f,
  5.24871610e-02f, 2.31618173e-02f, -1.12694509e-01f, 6.79371087e-03f, 1.22468817e-04f, 6.09428808e-02f, -5.88917136e-02f, 4.69654687e-02f, 1.58534050e-02f, -3.93378884e-02f,
  -3.40653397e-02f, 1.07096052e-02f, 3.84427682e-02f, -1.83319747e-02f, -3.02664284e-02f, 4.94446466e-03f, -2.84662265e-02f, 5.69839329e-02f, -3.27187479e-02f, -1.17840528e-01f,
  -5.66230854e-03f, 2.72669885e-02f, -1.15214847e-03f, 6.10556379e-02f, -4.10868526e-02f, 4.66667488e-02f, -1.78598370e-02f, 4.11075028e-03f, 1.09716281e-02f, -8.26836191e-03f,
  -1.08674308e-02f, 7.02515012e-03f, -3.52348648e-02f, 3.61509100e-02f, -1.48364026e-02f, 3.99596728e-02f, 1.17827738e-02f, 1.80825759e-02f, -3.14112194e-02f, -6.90401159e-03f,
  3.23924534e-02f, -4.67919335e-02f, 2.79195723e-03f, 7.43571520e-02f, -3.23267467e-02f, 2.49126144e-02f, 1.54635590e-02f, 1.59166032e-03f, 2.97730379e-02f, 2.44928319e-02f,
  -1.31540000e-01f, -3.05254251e-01f, -8.79606828e-02f, 2.63695624e-02f, -3.26109231e-02f, -5.28768450e-02f, -1.33344764e-02f, -1.08720131e-01f, -1.30953670e-01f, -3.01665813e-02f,
  5.19152321e-02f, -2.90071517e-02f, 6.71471432e-02f, 2.01966856e-02f, 2.46859286e-02f, -7.43108839e-02f, 5.15074357e-02f, -2.22233660e-03f, -4.99613173e-02f, -3.11732106e-02f,
  4.62585203e-02f, 6.35359809e-02f, 6.74380213e-02f, -3.89320701e-02f, -4.99880640e-03f, 4.44852114e-02f, -5.61552420e-02f, -2.08433401e-02f, -2.66599692e-02f, -4.22989717e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.19647384e-01f, 2.66749114e-01f, -1.81772307e-01f, -3.48780341e-02f, 1.80931240e-01f, 2.61421382e-01f, 1.22265212e-01f, 1.57330990e-01f, -9.11348239e-02f, 8.90869945e-02f,
  7.45997578e-02f, -7.86017347e-03f, -9.03387517e-02f, 1.23535246e-01f, 8.77607465e-02f, -2.60816775e-02f, 2.41993576e-01f, 9.05520692e-02f, -3.86405364e-02f, -1.60901286e-02f,
  -6.76530786e-03f, 1.67959034e-01f, -6.50421530e-02f, -3.14322896e-02f, -1.75327696e-02f, -2.03180864e-01f, -2.47271508e-02f, -2.06306517e-01f, 7.82430395e-02f, 1.43563403e-02f,
  5.73373288e-02f, -1.04948081e-01f, 2.20419187e-03f, -2.32193582e-02f, -5.09783365e-02f, -9.34354030e-03f, -8.41833800e-02f, -4.63583581e-02f, -5.94495125e-02f, -1.01468839e-01f,
  3.21787409e-02f, -3.00470032e-02f, -2.04991852e-03f, -6.55329898e-02f, 1.73785072e-02f, -4.54697534e-02f, -5.46217225e-02f, -1.23660518e-02f, -2.75127012e-02f, 3.81859243e-02f,
  4.38815318e-02f, -3.04355565e-02f, 6.65076822e-02f, -2.33365782e-02f, 2.04164144e-02f, 8.96071494e-02f, 5.28428480e-02f, -1.78804132e-03f, 6.18961230e-02f, -3.49901756e-03f,
  -1.27356723e-02f, 3.78994830e-03f, 1.06324501e-01f, -3.95266041e-02f, 9.75992531e-02f, -4.02530394e-02f, 5.41687943e-02f, -8.66396204e-02f, -3.18652838e-02f, 9.25109163e-02f,
  -5.76997846e-02f, -4.48616110e-02f, -5.15396446e-02f, 1.29927248e-02f, -1.01890028e-01f, -6.79349015e-03f, 3.98890153e-02f, 4.97734882e-02f, 2.44080760e-02f, -8.80017802e-02f,
  4.36736867e-02f, 7.70456297e-03f, -6.36981875e-02f, -6.81272373e-02f, 2.83774715e-02f, -6.50438853e-03f, 8.44424069e-02f, -6.82718381e-02f, -1.04053169e-01f, 1.96088720e-02f,
  1.94702342e-01f, 1.24236353e-01f, -4.18890603e-02f, 6.30786568e-02f, -4.06534746e-02f, 1.83675662e-01f, 6.66034818e-02f, 7.89628923e-02f, 2.28859279e-02f, 1.09468639e-01f,
  2.84822565e-02f, -4.75427844e-02f, 4.66174856e-02f, -1.37512777e-02f, -2.40673274e-02f, 1.83351245e-02f, -6.51964843e-02f, -1.34141166e-02f, -1.33893872e-03f, 3.24014202e-02f,
  -2.57436708e-02f, 4.54771593e-02f, -7.99654573e-02f, -3.59666012e-02f, 2.93791536e-02f, -9.56560858e-03f, -3.19474004e-03f, -6.03428856e-02f, 7.25182593e-02f, -6.44482523e-02f,
  -1.37009501e-01f, -4.55909818e-01f, -1.60445385e-02f, 1.36624321e-01f, 2.06518114e-01f, 1.04000298e-02f, 2.51566861e-02f, -2.25343168e-01f, -3.64752203e-01f, -1.78037375e-01f,
  5.58604747e-02f, 1.55716594e-02f, -1.08009435e-01f, -1.63810700e-01f, 1.44264176e-01f, -2.54271984e-01f, -4.40686643e-02f, 5.04544638e-02f, -1.56874344e-01f, 1.45485532e-02f,
  -5.17277643e-02f, -1.02496222e-02f, 6.14887327e-02f, 1.11308783e-01f, -5.82161024e-02f, 1.04572341e-01f, 3.29498142e-01f, 1.65339515e-01f, 1.87307179e-01f, 1.48076221e-01f,
  -1.65367492e-05f, -1.77973092e-01f, 4.38290797e-02f, -3.92993391e-02f, 2.76682694e-02f, 9.59766135e-02f, 1.61231250e-01f, 1.05621360e-01f, 1.01166070e-01f, -1.68133550e-03f,
  1.78005006e-02f, 2.26080660e-02f, -5.67837805e-02f, -2.01529060e-02f, -7.49738142e-03f, -7.94267468e-03f, -2.00862214e-02f, -6.81201369e-02f, -6.29469082e-02f, 1.25906784e-02f,
  -8.64901766e-02f, -4.79125604e-02f, -3.49122360e-02f, -3.76707353e-02f, 3.81330177e-02f, 5.41798025e-02f, 5.68320602e-02f, 9.63283554e-02f, 1.63758304e-02f, -2.68120281e-02f,
  -5.02859540e-02f, -3.40411887e-02f, -9.09971818e-02f, -7.31608346e-02f, -5.18050930e-03f, 5.47545552e-02f, -1.78684425e-02f, -1.23706246e-02f, 7.58508965e-02f, 8.08416586e-03f,
  4.90101278e-02f, 8.59307125e-03f, 3.57435495e-02f, 4.11462896e-02f, 2.42610723e-02f, -3.68022770e-02f, 4.02939692e-02f, 3.03962566e-02f, 3.06304805e-02f, -3.60156745e-02f,
  4.77629751e-02f, 7.59550855e-02f, 4.65080887e-02f, 5.73953427e-02f, -6.11753613e-02f, 3.25746238e-02f, 3.18664871e-02f, -5.66147678e-02f, 5.19781597e-02f, 1.19128272e-01f,
  2.63760705e-02f, -1.11469969e-01f, -9.83757004e-02f, 2.22886764e-02f, -6.77914619e-02f, -1.46295885e-02f, -2.19604447e-02f, -4.34576832e-02f, 6.10500425e-02f, -5.80048524e-02f,
  1.38453459e-02f, -5.40529983e-03f, 2.41102520e-02f, 8.24279785e-02f, 1.05852239e-01f, -2.83038281e-02f, 1.75071303e-02f, 9.92398411e-02f, 7.70769119e-02f, -3.20347808e-02f,
  8.83734673e-02f, 9.34249833e-02f, -3.13490517e-02f, 7.40732700e-02f, 4.77460492e-03f, 8.03197995e-02f, 3.63428183e-02f, 1.43439295e-02f, -6.34531230e-02f, 4.02642004e-02f,
  -1.12880483e-01f, -4.86469306e-02f, -1.54068053e-01f, -1.44074008e-01f, 1.99677050e-02f, 7.38279149e-02f, -1.23048648e-01f, 1.95012521e-02f, -3.88136208e-02f, 1.22422315e-01f,
  7.80213624e-02f, -6.18415102e-02f, -1.82210118e-01f, 4.01086658e-02f, -1.54231608e-01f, -1.98890984e-01f, -5.61248772e-02f, 4.42248806e-02f, -7.82634020e-02f, 1.83433425e-02f,
  8.44195660e-04f, 9.38124582e-02f, 7.07296804e-02f, 1.42886937e-01f, 1.47579581e-01f, 2.57840883e-02f, -1.21308379e-02f, 1.03754755e-02f, 1.13961563e-01f, 6.55056722e-03f,
  -2.21380014e-02f, -1.47822581e-03f, -7.39262849e-02f, 2.64101084e-02f, 8.91213492e-02f, 2.47033872e-02f, 5.92328012e-02f, 5.90615943e-02f, -3.65494303e-02f, 4.95764241e-03f,
  -2.35873181e-02f, 7.95921534e-02f, 2.52109673e-02f, -7.16197044e-02f, -2.80198511e-02f, 6.84694126e-02f, 6.58292696e-02f, 8.32590982e-02f, -2.56506037e-02f, -6.63173348e-02f,
  -4.69564125e-02f, 7.09659606e-02f, 5.82639202e-02f, 3.46640125e-02f, 2.02249549e-02f, 2.50943974e-02f, -8.44059139e-02f, -3.37616727e-02f, 2.14748941e-02f, -1.78339072e-02f,
  2.15461589e-02f, -4.91738096e-02f, -6.38546571e-02f, 5.61236553e-02f, -8.89092684e-02f, 6.08342066e-02f, -1.00611933e-01f, -5.47031574e-02f, 7.65358284e-03f, 8.37110952e-02f,
  -1.56560838e-02f, 4.77364548e-02f, -3.57753318e-03f, 2.87778061e-02f, -8.50616544e-02f, -2.73721367e-02f, 1.01829739e-02f, 5.42353764e-02f, 4.71388884e-02f, -4.82101515e-02f,
  7.86226019e-02f, 2.52647586e-02f, 9.39459279e-02f, -6.81437850e-02f, -8.46797787e-03f, -1.39793474e-02f, -7.51847252e-02f, -7.63907656e-02f, 2.40135230e-02f, -5.86509518e-02f,
  4.22390029e-02f, -1.25492260e-01f, 2.23390758e-02f, -3.70274335e-02f, 2.97380015e-02f, 9.73665491e-02f, -2.49257367e-02f, -3.46689671e-02f, -1.45217553e-02f, 7.43616819e-02f,
  1.21361949e-01f, 4.28532101e-02f, 3.35243554e-03f, 3.00593972e-02f, -8.99437219e-02f, 6.65300786e-02f, 1.20869176e-02f, 4.47877608e-02f, 2.38972642e-02f, 1.20802715e-01f,
  -3.80816683e-02f, 6.25682101e-02f, 6.40200824e-02f, -5.42458706e-02f, 7.18167424e-03f, -1.38751660e-02f, 2.55495235e-02f, 1.71820745e-02f, -2.57605896e-03f, 3.59629914e-02f,
  1.05150558e-01f, -5.88089302e-02f, 2.40334108e-01f, 1.67344362e-01f, 9.23321024e-02f, -7.85566717e-02f, -9.69923213e-02f, 1.46018729e-01f, 5.98402619e-02f, -1.97773352e-01f,
  5.02397167e-03f, 4.78922622e-03f, -3.44116590e-03f, 3.17846388e-02f, 1.01418167e-01f, 5.89896459e-03f, 8.59232098e-02f, 6.46290034e-02f, 1.67490125e-01f, 2.33338490e-01f,
  2.19353035e-01f, 7.00750621e-03f, 2.63782352e-01f, 6.90160170e-02f, 1.70450956e-01f, 1.81557834e-01f, -1.09444380e-01f, 6.06952421e-02f, 6.32836744e-02f, -1.18854694e-01f,
  -6.37994930e-02f, 1.15640173e-02f, 5.80918603e-02f, 3.72957140e-02f, 8.49717781e-02f, -1.62001029e-02f, 6.96062343e-03f, 5.61118945e-02f, 1.06045172e-01f, 6.31689206e-02f,
  -1.09733623e-02f, 2.01548450e-02f, 2.43788641e-02f, 4.99202199e-02f, -1.03153605e-02f, 8.72927755e-02f, 7.58358017e-02f, 7.05398992e-02f, -4.12255496e-04f, 1.42140657e-01f,
  1.65561646e-01f, 7.57923275e-02f, 8.46453533e-02f, 3.09606455e-02f, 2.24827155e-02f, 3.45664993e-02f, -1.23288997e-01f, -5.75525984e-02f, 1.97508675e-03f, -1.19885178e-02f,
  6.60915524e-02f, -9.83793885e-02f, 3.69050689e-02f, 8.85253921e-02f, 1.37298005e-02f, 1.47889592e-02f, 1.59948040e-02f, 7.59260803e-02f, -5.96442744e-02f, -8.39166790e-02f,
  -8.18063691e-03f, 9.43716466e-02f, -1.17723206e-02f, -7.65796155e-02f, 3.08245160e-02f, -3.71694891e-03f, -4.68674153e-02f, 6.37566205e-04f, -2.59938836e-02f, 3.28003056e-02f,
  3.44309881e-02f, -5.44378497e-02f, -6.86438158e-02f, 3.97613607e-02f, -8.83222073e-02f, 4.63175587e-02f, 7.40119396e-03f, -4.52768896e-03f, -3.28220204e-02f, -1.69476569e-02f,
  -1.18855260e-01f, -4.68943156e-02f, 5.29095307e-02f, -6.85524493e-02f, -5.65571710e-02f, 5.42400666e-02f, 1.76403504e-02f, -4.69856523e-02f, -3.83715220e-02f, 5.12969792e-02f,
  -6.81303889e-02f, -1.37822712e-02f, -2.60165576e-02f, 8.74645412e-02f, -4.41320688e-02f, 6.56894371e-02f, 5.49059324e-02f, 2.99999509e-02f, -2.39864420e-02f, 8.63808244e-02f,
  4.17316966e-02f, 3.25201498e-03f, -3.49384099e-02f, 1.91295426e-02f, -1.48329018e-02f, 1.06860148e-02f, -1.14753813e-01f, 4.74880412e-02f, 5.09754494e-02f, -1.38537624e-04f,
  7.99097121e-02f, -1.54508844e-01f, 1.18293338e-01f, -7.27168843e-02f, 7.86617324e-02f, 1.14623941e-01f, 2.36239493e-01f, -4.72355485e-02f, 1.12489574e-01f, -1.20860182e-01f,
  -1.27382681e-01f, 3.28310616e-02f, 1.16972364e-01f, -2.89880335e-02f, 2.04465657e-01f, 1.42356977e-01f, -3.41909332e-03f, 1.11334175e-02f, -8.60838592e-02f, -1.20344296e-01f,
  7.44973049e-02f, -1.32693768e-01f, -1.21737555e-01f, -2.47985646e-01f, -3.83142866e-02f, -6.31182566e-02f, -1.34079054e-01f, 3.20815900e-03f, -2.12156743e-01f, -2.78433561e-02f,
  -8.08496103e-02f, 3.33020687e-02f, 7.41955861e-02f, -3.67157832e-02f, 1.83847528e-02f, -7.30773285e-02f, 5.41512407e-02f, -3.80525999e-02f, -9.96883679e-03f, -4.05798629e-02f,
  3.47033031e-02f, -4.71282639e-02f, 3.26510109e-02f, 5.97823635e-02f, -9.51665640e-02f, 5.24881147e-02f, 1.12585258e-02f, 4.37985212e-02f, -4.47694100e-02f, -8.67392644e-02f,
  -4.39805388e-02f, -6.69475719e-02f, -6.61598742e-02f, -8.35428089e-02f, -7.30525702e-02f, -3.13584805e-02f, -4.93342243e-03f, -7.85177283e-04f, -8.17911923e-02f, 3.63691673e-02f,
  9.04087909e-03f, -4.41332757e-02f, 1.27407466e-03f, 4.88128066e-02f, 5.86578771e-02f, 6.62640333e-02f, -5.65497875e-02f, 6.51952699e-02f, -8.25872719e-02f, 5.06251827e-02f,
  2.85243392e-02f, -8.65303874e-02f, -3.66961062e-02f, -1.58344358e-02f, -4.94297035e-02f, -5.02453968e-02f, 2.65475903e-02f, -2.22596843e-02f, 7.67497495e-02f, 9.31848288e-02f,
  -5.22979572e-02f, 5.01957573e-02f, -3.80404219e-02f, -1.08683579e-01f, 4.41450067e-02f, 7.35991374e-02f, -1.01469547e-01f, -3.03644277e-02f, -1.13558937e-02f, -4.83724773e-02f,
  5.49677797e-02f, -4.65895087e-02f, 5.79051711e-02f, 1.32519007e-02f, 7.08941892e-02f, -5.65717109e-02f, -1.07654944e-01f, -9.54343975e-02f, -4.17618677e-02f, -7.49925897e-02f,
  8.13366845e-03f, 5.01072686e-03f, -2.15877742e-02f, -1.78920366e-02f, -2.85539571e-02f, 5.88057842e-03f, -3.30669768e-02f, -1.06357157e-01f, 3.10067236e-02f, -7.12684095e-02f,
  2.32941303e-02f, -4.96844575e-02f, 4.77972999e-02f, 3.78023717e-04f, -8.23708326e-02f, -2.43050465e-03f, -1.07344678e-02f, -4.12852168e-02f, -7.97568411e-02f, -5.42496145e-02f,
  2.58955896e-01f, 1.77209228e-02f, 2.19112024e-01f, 3.39744508e-01f, 1.26156539e-01f, -4.47577201e-02f, 6.09058365e-02f, 2.13236898e-01f, 4.01714951e-01f, -6.86275885e-02f,
  -4.97890189e-02f, 6.02273643e-02f, -2.63244539e-01f, -2.46072114e-02f, -7.14281946e-02f, -7.57515579e-02f, -2.82557532e-02f, 1.04103805e-02f, 1.56398654e-01f, 7.65572637e-02f,
  1.60413340e-01f, -1.15786836e-01f, -1.23699509e-01f, -2.32272372e-02f, 1.33025989e-01f, 4.24444675e-02f, -1.56484202e-01f, -8.18781406e-02f, -1.06150530e-01f, -8.63036290e-02f,
  1.19255953e-01f, 1.55102730e-01f, -1.27353827e-02f, -8.73747692e-02f, -3.95928062e-02f, -1.61482617e-02f, -2.00043619e-02f, -8.16882551e-02f, 1.45054236e-02f, -1.39710410e-02f,
  -5.98891005e-02f, 1.15633225e-02f, 2.56504249e-02f, -1.00481264e-01f, 8.94224122e-02f, -3.01480368e-02f, 4.81480323e-02f, 1.54556111e-01f, 3.12501676e-02f, 1.14480570e-01f,
  1.83317289e-02f, 5.03823124e-02f, 9.69584361e-02f, -6.88367486e-02f, 6.43924847e-02f, 5.82493544e-02f, 3.66425589e-02f, 4.84245503e-03f, 9.66752600e-03f, 2.60835700e-02f,
  -2.01058201e-02f, -2.90446933e-02f, -4.01927494e-02f, 4.02029194e-02f, -4.19199169e-02f, 4.32171933e-02f, -6.48049042e-02f, -8.30738917e-02f, 3.65356207e-02f, -6.08461201e-02f,
  3.51157933e-02f, 5.96126281e-02f, -2.17871312e-02f, 3.45391175e-03f, -1.20377224e-02f, -3.51027995e-02f, -8.19863304e-02f, 2.72745006e-02f, -1.60046630e-02f, 7.59250447e-02f,
  -4.81756181e-02f, -2.68043838e-02f, -1.48669537e-02f, 5.35737015e-02f, 1.01762237e-02f, 1.33758306e-03f, -2.77301855e-02f, -3.12737525e-02f, 1.86586101e-02f, -4.86103212e-03f,
  -1.32852614e-01f, -1.50479048e-01f, -4.58238088e-02f, 4.40230966e-02f, -7.72658139e-02f, 3.92170623e-02f, 6.19986234e-03f, -1.20740300e-02f, -1.13504650e-02f, 8.49555209e-02f,
  6.55191764e-02f, 9.20144692e-02f, -6.06232323e-02f, -7.47902915e-02f, -1.04060195e-01f, 6.42918497e-02f, -1.85167342e-02f, -1.01157211e-01f, -9.22102705e-02f, 1.44180944e-02f,
  -1.93625921e-03f, -7.24401399e-02f, 4.59824083e-03f, 3.71371098e-02f, 1.25796078e-02f, -1.96812395e-02f, -1.45758819e-02f, -5.50618172e-02f, 1.21771274e-02f, 2.09713299e-02f,
  -2.21093521e-01f, 4.82051186e-02f, -2.86638197e-02f, 6.53880537e-02f, -1.49237067e-01f, -1.80004649e-02f, -1.03057347e-01f, 1.53696612e-01f, -4.61251847e-02f, 1.45726919e-01f,
  6.61564171e-02f, -1.35790199e-01f, 6.59781620e-02f, 1.11221723e-01f, -6.65296316e-02f, 7.33635575e-02f, 7.16878623e-02f, 7.65075609e-02f, -1.02866581e-02f, 7.51266479e-02f,
  1.12543076e-01f, 1.29113585e-01f, 1.37646601e-01f, 1.96385905e-01f, 9.23032686e-02f, 9.31276754e-02f, 1.79216415e-01f, 1.08250134e-01f, 1.81205109e-01f, -3.67645361e-02f,
  -1.06863923e-01f, -6.10466227e-02f, -3.58401090e-02f, -1.42562702e-01f, -3.36781377e-03f, -6.68166624e-03f, 4.85134907e-02f, -1.09738655e-01f, -3.85670252e-02f, -1.71723366e-02f,
  -1.37711927e-01f, 5.45560755e-02f, 4.56348658e-02f, 5.06368652e-02f, -8.50515906e-03f, 3.92776914e-03f, -6.80157542e-02f, 2.25105211e-02f, -5.74352145e-02f, 3.61342132e-02f,
  -3.18791568e-02f, 1.86933391e-02f, 5.53692058e-02f, 8.10802355e-02f, 6.07824884e-02f, -2.14874856e-02f, -4.32450837e-03f, -4.47161756e-02f, -6.87083006e-02f, -7.32693151e-02f,
  -2.63785291e-03f, 8.71118903e-02f, 5.01035340e-03f, -9.79308598e-03f, 4.50085551e-02f, 7.51453191e-02f, -3.27696395e-03f, -7.05130547e-02f, 2.78137773e-02f, -6.14643171e-02f,
  7.54272044e-02f, 1.42858094e-02f, -7.86385015e-02f, -6.74148574e-02f, 7.15238079e-02f, -1.12123720e-01f, -4.06335741e-02f, 5.15481830e-03f, -4.24052104e-02f, 4.05246951e-03f,
  -9.83988717e-02f, -2.58779135e-02f, 1.00974128e-01f, -5.85570000e-03f, -8.50904956e-02f, 7.54979625e-02f, 7.07959980e-02f, 2.68032011e-02f, 9.24124420e-02f, -7.00989924e-03f,
  -3.91178355e-02f, 1.36774570e-01f, 5.80890924e-02f, -3.91019434e-02f, -4.84967940e-02f, 1.69225205e-02f, -6.43211752e-02f, 6.58953860e-02f, -3.23498771e-02f, 2.74964254e-02f,
  8.57088789e-02f, 9.57855210e-02f, -4.95755114e-02f, 7.06485212e-02f, -1.14185084e-03f, 2.50112973e-02f, 7.92668238e-02f, 5.83161674e-02f, 5.89852892e-02f, 5.05434424e-02f,
  3.88645492e-02f, 1.45483762e-02f, -3.77349183e-02f, -1.73456559e-03f, 3.04393247e-02f, 6.63182065e-02f, -8.10739249e-02f, -6.60310611e-02f, 5.28272614e-02f, -6.34488836e-02f,
  -1.06907636e-02f, -5.38454279e-02f, -3.97069119e-02f, -4.45575006e-02f, 3.73693593e-02f, -2.22696826e-01f, -1.74476311e-01f, -1.14245966e-01f, 3.50268930e-02f, -5.15709184e-02f,
  -7.02218562e-02f, 5.54563925e-02f, 9.41356421e-02f, -1.48817105e-02f, 3.59152816e-02f, -4.73812819e-02f, -2.12628007e-01f, -5.56410141e-02f, 1.35231152e-01f, -1.83084741e-01f,
  -1.24506652e-01f, -3.57142910e-02f, -6.95939586e-02f, 8.37129802e-02f, -1.29704654e-01f, 6.86024427e-02f, -2.28624362e-02f, 6.58552647e-02f, -6.24967106e-02f, -3.37157995e-02f,
  -9.56114829e-02f, -9.54747871e-02f, -3.54232602e-02f, -9.33061466e-02f, -5.77294528e-02f, -9.20407847e-02f, -1.00661684e-02f, -4.19013761e-02f, -6.59447908e-02f, 2.84447931e-02f,
  -8.46913178e-03f, 1.21473737e-01f, 4.10042927e-02f, -4.80057113e-02f, -3.51833552e-02f, 9.88025069e-02f, 4.91629913e-02f, 1.30330026e-02f, -1.06248800e-02f, -6.08557388e-02f,
  3.94744202e-02f, -4.05657217e-02f, -9.52917635e-02f, -7.84491971e-02f, 5.27928732e-02f, 6.10407628e-02f, -7.49019980e-02f, 3.68536711e-02f, -1.62562970e-02f, -8.49568620e-02f,
  4.62763980e-02f, 3.05085480e-02f, -4.79785874e-02f, 7.10601732e-02f, -7.81001970e-02f, 5.92695065e-02f, 4.20603342e-02f, 3.42699364e-02f, 8.20862222e-03f, 3.52678932e-02f,
  -9.32679698e-02f, -3.53754014e-02f, 6.83802143e-02f, -7.16551840e-02f, -5.06025031e-02f, -5.37593439e-02f, -3.74795534e-02f, -5.86666539e-02f, 1.88971478e-02f, -4.28632125e-02f,
  -2.70841140e-02f, 5.06992973e-02f, -1.56946629e-02f, -6.72165155e-02f, 2.42179446e-02f, 1.01939160e-02f, 2.43533403e-02f, 4.09072414e-02f, 7.02423975e-02f, 7.61766955e-02f,
  -2.26086199e-01f, -5.77363186e-02f, -1.34468200e-02f, 5.07030152e-02f, 2.81451531e-02f, -7.03545287e-02f, 6.42125607e-02f, 1.86508577e-02f, -1.76579300e-02f, -7.99327791e-02f,
  2.52179895e-02f, -9.45154652e-02f, 3.16679701e-02f, -3.62594649e-02f, 3.15092131e-02f, 2.37491261e-02f, -4.77916710e-02f, -1.16316654e-01f, -5.66955237e-03f, 7.23279640e-02f,
  3.14644389e-02f, 7.73148313e-02f, 3.33365686e-02f, -3.17266732e-02f, -4.37682122e-02f, -1.30024143e-02f, 4.83536758e-02f, -2.28902921e-02f, 3.71021926e-02f, 2.14987416e-02f,
  -9.99043658e-02f, -1.44769490e-01f, 2.10513279e-01f, 3.75892036e-02f, -4.93607521e-02f, 7.32460767e-02f, 2.04908744e-01f, -1.81408823e-01f, -1.98605984e-01f, -1.26160175e-01f,
  -8.68686065e-02f, -1.77175533e-02f, 9.41493064e-02f, -1.37183249e-01f, 2.12185144e-01f, -4.52471990e-03f, -2.39777304e-02f, -1.67564005e-02f, -4.29894552e-02f, 1.80439409e-02f,
  5.83978482e-02f, -7.16845021e-02f, 1.38965532e-01f, -6.33409917e-02f, 5.47588952e-02f, -2.98108328e-02f, 4.30883057e-02f, 1.74780399e-01f, 8.56520236e-02f, 7.48953074e-02f,
  -5.44481203e-02f, -1.84136182e-02f, -5.11643924e-02f, -5.04061393e-02f, 5.95247261e-02f, 8.36239681e-02f, 1.32057026e-01f, 1.27873244e-02f, -5.19709624e-02f, -1.04408078e-02f,
  6.53176233e-02f, 4.99982461e-02f, -2.99373642e-02f, 6.71069026e-02f, -6.89825565e-02f, -2.89830212e-02f, -5.45497686e-02f, -6.43074140e-02f, 7.07749650e-02f, -1.11036124e-02f,
  8.60166699e-02f, -1.00216404e-01f, 6.69506565e-02f, 7.90979862e-02f, -1.67940259e-02f, -5.27943335e-02f, -2.86439061e-02f, 1.36820823e-01f, 2.23671179e-02f, -3.72608192e-02f,
  1.03894927e-01f, -6.86028227e-02f, -2.64865700e-02f, -1.20963797e-01f, -4.54527736e-02f, -3.92685570e-02f, 5.91053814e-02f, 7.43466802e-03f, 2.30524186e-02f, 5.85623384e-02f,
  6.88507855e-02f, -4.89935800e-02f, -4.80650477e-02f, -5.84030673e-02f, 3.69028002e-03f, 1.05494512e-02f, 8.46225247e-02f, 3.17045040e-02f, -3.09528951e-02f, 2.44357344e-02f,
  1.07637150e-02f, 8.75872225e-02f, -5.99983931e-02f, -5.32650808e-03f, 1.90607272e-02f, 1.23372376e-02f, 6.55213147e-02f, -4.34817076e-02f, 1.61781572e-02f, 1.39667526e-01f,
  9.55970399e-03f, 1.95903145e-02f, 2.09135916e-02f, -4.24382761e-02f, -3.63243115e-03f, -8.22828114e-02f, -6.09344430e-02f, 4.92522381e-02f, 1.31855309e-01f, -4.44707723e-04f,
  5.11791669e-02f, 8.85942206e-02f, 4.63905036e-02f, 5.76499887e-02f, 7.80506358e-02f, 5.80441952e-02f, 2.79277824e-02f, -2.41736844e-02f, 4.28428175e-03f, -2.92905197e-02f,
  6.08882047e-02f, -2.80364286e-02f, -5.38746417e-02f, -5.56484088e-02f, -3.57466452e-02f, -3.16773243e-02f, 3.46081741e-02f, -2.45934706e-02f, 7.34227970e-02f, 4.97841910e-02f,
  -1.90972731e-01f, 2.18617260e-01f, 1.69646710e-01f, -6.52804002e-02f, 3.14989001e-01f, -2.23953694e-01f, -4.43022065e-02f, 1.76071182e-01f, 2.04126686e-01f, -1.10825755e-01f,
  -4.07190919e-02f, 5.07741496e-02f, 8.36908966e-02f, -5.71633801e-02f, -4.31817651e-01f, -1.60916269e-01f, -2.93688565e-01f, -1.51058346e-01f, 8.06179345e-02f, -5.57333976e-02f,
  -6.04946427e-02f, 1.54438496e-01f, 1.90294757e-02f, 1.86885118e-01f, 6.48067221e-02f, 1.38074279e-01f, -1.68298215e-01f, 2.16715664e-01f, -1.28148124e-01f, 2.69685090e-02f,
  -1.15278140e-01f, -5.75427078e-02f, -1.98520273e-02f, -3.41852009e-02f, -1.37309968e-01f, -6.11376963e-05f, -1.65859103e-01f, -7.32900053e-02f, 3.49516496e-02f, -1.56314597e-02f,
  -7.74384812e-02f, 1.08461902e-01f, 1.54648386e-02f, 1.28048629e-01f, 1.15076467e-01f, 8.46928805e-02f, 5.90839125e-02f, 2.30883341e-02f, 1.17979176e-01f, -3.37638147e-02f,
  8.91055986e-02f, -6.66882982e-03f, -8.61214027e-02f, -1.57674894e-01f, -4.16011885e-02f, 4.70485985e-02f, -2.35074386e-02f, -9.65528712e-02f, -8.42065271e-03f, -2.25340873e-02f,
  -7.85722807e-02f, 1.60485357e-02f, 5.77957220e-02f, 9.95951071e-02f, 2.58681010e-02f, 3.14601175e-02f, 5.20984195e-02f, -5.38669415e-02f, 1.85836107e-02f, -1.08192071e-01f,
  8.12086836e-03f, 6.44618869e-02f, 9.33879018e-02f, -7.14459494e-02f, -4.11317907e-02f, 1.83376446e-02f, -4.10822891e-02f, -3.41274552e-02f, -1.56855285e-02f, -6.63462132e-02f,
  -6.57355879e-03f, 2.37001223e-03f, 2.68123969e-02f, -2.22139955e-02f, -4.40482870e-02f, 2.14287822e-04f, -2.05235258e-02f, 1.08407468e-01f, -2.55738068e-02f, -6.41714036e-02f,
  -1.75420642e-01f, -2.84971386e-01f, -6.35855645e-02f, -4.38120924e-02f, -6.78696781e-02f, -1.03496201e-01f, -8.88319537e-02f, 6.44794032e-02f, -1.03834920e-01f, 6.01902418e-02f,
  -6.12549372e-02f, -1.66668463e-02f, -3.96231823e-02f, -2.60920990e-02f, -2.20884401e-02f, 1.27533050e-02f, -5.12322932e-02f, -4.76641394e-02f, -3.64107266e-02f, -1.53257757e-01f,
  3.30866426e-02f, 4.06181924e-02f, 1.64894257e-02f, -4.34374511e-02f, -8.05503130e-02f, -1.67934466e-02f, -4.76379842e-02f, 1.58672463e-02f, -4.00430746e-02f, 5.73647255e-03f,
  1.50228173e-01f, -9.82979089e-02f, -4.61688358e-03f, -7.19666407e-02f, 7.93106407e-02f, 1.04900219e-01f, -5.98782152e-02f, 5.11806682e-02f, -4.08119708e-02f, -1.36830270e-01f,
  -2.24149711e-02f, -2.27531403e-01f, -1.33161098e-02f, -5.42692877e-02f, -1.00178219e-01f, -7.37689435e-02f, 1.13154091e-01f, -6.11872114e-02f, 1.37721807e-01f, 2.65716240e-02f,
  6.27123639e-02f, 3.42861824e-02f, 2.45986897e-02f, 8.53837207e-02f, 1.07703872e-01f, 1.69606635e-03f, -1.02627046e-01f, -1.14546679e-02f, -1.00718677e-01f, -6.61681499e-03f,
  2.01447234e-01f, -1.58471316e-02f, 3.84230502e-02f, -1.81680340e-02f, 1.72496036e-01f, 1.19317330e-01f, 5.56492992e-02f, -4.16658446e-02f, -4.47476469e-02f, 4.74215969e-02f,
  -1.07926540e-01f, -6.88012689e-02f, -7.20207617e-02f, -3.63925733e-02f, 1.06528990e-01f, 6.66467249e-02f, 7.65740648e-02f, 1.01867869e-01f, 3.33711207e-02f, 9.14170966e-03f,
  8.38144124e-03f, -2.73467973e-02f, -4.72318195e-03f, -1.90824829e-02f, -4.63115424e-02f, -8.76282062e-03f, -3.50822918e-02f, -9.94133279e-02f, -8.80613178e-02f, 3.81689705e-02f,
  -8.49817693e-02f, -3.45386676e-02f, 4.60499711e-02f, 6.62348792e-02f, 4.06633429e-02f, 1.11696139e-01f, 3.66075113e-02f, -3.52674560e-03f, 7.07470486e-03f, -1.38512421e-02f,
  2.95463670e-02f, -9.44384858e-02f, 7.93337151e-02f, -3.02578788e-03f, 5.52217886e-02f, 1.02143241e-02f, -3.78568955e-02f, -4.36126356e-06f, 1.08885132e-02f, 2.27771252e-02f,
  2.12933309e-02f, -3.86918429e-04f, 4.29459214e-02f, -8.10040608e-02f, -5.86703140e-03f, -8.44651610e-02f, -6.76955506e-02f, -1.61577500e-02f, 5.32389656e-02f, -4.90059964e-02f,
  2.83444375e-02f, -1.91924293e-02f, 1.08281143e-01f, -3.35788317e-02f, -2.58837286e-02f, -9.42205172e-03f, -1.69157016e-03f, -5.37919365e-02f, -5.89002259e-02f, -1.91971231e-02f,
  8.86281114e-03f, -1.98259987e-02f, 4.71404567e-02f, -2.31567305e-02f, -2.73507610e-02f, 9.54445750e-02f, -1.19083278e-01f, -1.06904492e-01f, -1.80994533e-03f, 3.38562541e-02f,
  2.27575861e-02f, -5.13658375e-02f, -5.33300191e-02f, 8.31083134e-02f, -1.86087899e-02f, -8.05874243e-02f, -9.28325132e-02f, -2.97408514e-02f, -1.15192048e-01f, 2.46553812e-02f,
  2.84210175e-01f, -3.25311601e-01f, 4.82781121e-04f, 1.43279647e-02f, 1.32389694e-01f, 1.50505647e-01f, 3.13345045e-01f, -1.11853898e-01f, -1.66094482e-01f, -2.61229873e-01f,
  1.36194706e-01f, -7.26758130e-03f, -1.32914977e-02f, 1.32658402e-04f, 2.68285573e-01f, 7.59283379e-02f, 9.94354561e-02f, 5.90916052e-02f, 8.30572937e-03f, -2.84373052e-02f,
  -2.61541922e-02f, 1.53007627e-01f, 1.00778580e-01f, -5.41957021e-02f, 1.60830066e-01f, -1.19041689e-01f, 4.55767885e-02f, 8.05002078e-02f, -9.77030173e-02f, 6.96090236e-02f,
  4.23799306e-02f, -6.94611948e-03f, 3.19687836e-02f, 2.29520705e-02f, -7.23285377e-02f, -5.79885533e-03f, -1.66597087e-02f, 1.08346418e-01f, 7.90184140e-02f, 5.59796989e-02f,
  6.11731336e-02f, 1.65836252e-02f, -4.94299866e-02f, 9.80142504e-02f, -2.00621840e-02f, -1.13920443e-01f, -4.50308807e-02f, 1.08418399e-02f, -4.50519249e-02f, 7.00042099e-02f,
  1.95535179e-02f, 2.07975879e-02f, 2.63833487e-03f, -8.22169632e-02f, -1.24543370e-03f, -6.03230931e-02f, 4.57798131e-03f, -1.94377322e-02f, -7.32147843e-02f, 5.56033328e-02f,
  1.31176990e-02f, -2.15672873e-04f, 9.58352983e-02f, -1.46806352e-02f, -4.05146331e-02f, 5.98455742e-02f, -6.77796677e-02f, 3.63714918e-02f, 2.87146233e-02f, 1.44273043e-04f,
  -3.76181975e-02f, 4.89178561e-02f, -5.33970557e-02f, -8.70778561e-02f, -2.55376771e-02f, 2.11189575e-02f, 5.67215383e-02f, 1.69815347e-02f, -6.77636340e-02f, -5.76024801e-02f,
  2.17833929e-02f, -2.58248504e-02f, -6.81094304e-02f, 5.59729263e-02f, -4.40739766e-02f, 1.21863289e-02f, -6.14485666e-02f, -3.91595215e-02f, -2.01303512e-03f, 1.05502820e-02f,
  -5.52856699e-02f, -2.51109958e-01f, -1.20954566e-01f, 1.93204731e-02f, 4.83344123e-02f, 5.13840169e-02f, -3.40683833e-02f, -2.20163446e-02f, 5.97307412e-03f, -6.60916492e-02f,
  -7.03044981e-02f, 1.76417772e-02f, -5.01069762e-02f, -1.71325132e-02f, -4.65329848e-02f, -5.14303669e-02f, -5.39096072e-03f, -4.42097150e-03f, -3.15804966e-02f, -7.46799558e-02f,
  6.23671105e-03f, -2.05107424e-02f, 1.19401161e-02f, -3.66317108e-02f, 2.40383297e-03f, 3.61038521e-02f, 5.07373065e-02f, 2.27838960e-02f, -1.60986576e-02f, -3.24667655e-02f,
  -4.01995070e-02f, -9.88802779e-03f, -4.33412530e-02f, 4.97905985e-02f, -2.09637552e-01f, -2.87627667e-01f, -3.53059590e-01f, -5.03412746e-02f, -7.54077407e-03f, -1.38585985e-01f,
  -1.16811760e-01f, 3.26122567e-02f, -4.05023769e-02f, -6.92939460e-02f, 2.05815881e-01f, 2.35943124e-01f, -1.35323331e-01f, -1.10343590e-01f, -3.76724242e-03f, -4.34438139e-02f,
  2.85942536e-02f, -1.70328766e-01f, 2.04625074e-02f, -3.42451856e-02f, -9.19669420e-02f, -2.30774302e-02f, 9.58818272e-02f, -1.33340225e-01f, -2.75534522e-02f, 4.51413840e-02f,
  -8.97763073e-02f, -6.76729530e-02f, -1.04511701e-01f, -1.04461350e-01f, -2.10987832e-02f, -7.65974596e-02f, -9.80948582e-02f, 5.64119853e-02f, -2.84397956e-02f, 4.99144755e-02f,
  6.42438307e-02f, 7.85514861e-02f, -6.16507530e-02f, 9.13452879e-02f, -3.17278728e-02f, 1.99627527e-03f, 5.49409799e-02f, 6.23902082e-02f, -1.12655662e-01f, 4.36639925e-03f,
  4.89025842e-03f, 6.61141053e-02f, 6.28228933e-02f, 8.79286304e-02f, -3.89543101e-02f, -7.42799938e-02f, 8.89298692e-02f, 4.83271144e-02f, -5.67724630e-02f, 1.08578494e-02f,
  -6.15813434e-02f, 1.35893328e-02f, -8.61663148e-02f, -9.15672164e-03f, -3.99272330e-02f, -8.15853942e-03f, -1.67455543e-02f, 5.23874164e-02f, 7.60958195e-02f, 6.64804643e-03f,
  7.78327361e-02f, -5.04651591e-02f, -6.88566864e-02f, -6.66033551e-02f, -6.48244470e-02f, -3.30098756e-02f, -5.59221245e-02f, 7.84527138e-03f, -2.94182748e-02f, -3.59115303e-02f,
  -2.97874287e-02f, 5.45233451e-02f, 2.06187274e-02f, 1.61155369e-02f, 5.78290299e-02f, -2.32422687e-02f, -5.58416806e-02f, -5.19629531e-02f, -3.83461453e-02f, -3.17151695e-02f,
  -9.35540721e-02f, 5.80983832e-02f, -7.18571171e-02f, -4.60450016e-02f, 4.20156121e-02f, -4.82929647e-02f, -6.98953867e-02f, 1.83487050e-02f, -6.46857917e-02f, -3.29502970e-02f,
  -2.13623252e-02f, 2.15443783e-02f, 8.50740355e-03f, -2.47942079e-02f, -2.12060381e-02f, -1.62072647e-02f, -2.45231446e-02f, -5.46653159e-02f, -1.30383624e-02f, -4.46044505e-02f,
  -2.74818279e-02f, -6.22233897e-02f, -1.70563422e-02f, -4.61571552e-02f, -7.85448495e-03f, -9.85785797e-02f, 4.78669591e-02f, 7.90400282e-02f, 1.26215741e-02f, 3.50966267e-02f,
  -1.55059487e-01f, 5.29269166e-02f, -1.44695193e-01f, -7.10701793e-02f, -1.12598920e-02f, 5.99387623e-02f, 5.07013872e-02f, -3.77003178e-02f, -1.03466555e-01f, 3.30774009e-01f,
  4.25027199e-02f, -4.25642915e-02f, -5.29490411e-03f, -1.19435325e-01f, -2.74940848e-01f, -1.45143360e-01f, 5.99956959e-02f, 5.93739785e-02f, -5.56129962e-02f, 3.93201783e-02f,
  -1.40808508e-01f, -8.24964866e-02f, -2.38027856e-01f, 7.81843290e-02f, 6.03991598e-02f, 8.61353576e-02f, 2.14516558e-02f, -6.46770932e-03f, 1.01476178e-01f, -1.26708701e-01f,
  -4.93277982e-02f, -8.00313056e-02f, 9.06430651e-03f, 7.39063770e-02f, 8.64422396e-02f, 4.10409532e-02f, 5.95146418e-02f, 1.96315553e-02f, -5.16762249e-02f, 2.50370055e-02f,
  1.19749568e-02f, -2.44867448e-02f, -2.77498048e-02f, -6.27774186e-03f, -3.02160643e-02f, 6.22628406e-02f, -7.95280486e-02f, 9.97856539e-03f, 1.07333653e-01f, -4.13387315e-03f,
  -3.52111273e-02f, 8.26995969e-02f, 4.45050821e-02f, -4.63557057e-02f, 5.74549921e-02f, -7.16616139e-02f, 1.11679487e-01f, -7.52667859e-02f, 2.63841506e-02f, -8.29541683e-02f,
  -2.47320477e-02f, -3.09632216e-02f, 8.54785144e-02f, -5.43286577e-02f, -8.34780261e-02f, -2.40064394e-02f, -1.78216230e-02f, -5.60566299e-02f, 4.53378446e-03f, -5.37621491e-02f,
  -3.72165591e-02f, -8.44343007e-03f, -3.80633920e-02f, 1.07071837e-02f, -8.27059224e-02f, 4.87931296e-02f, 6.42553717e-03f, -8.77295434e-02f, 5.05365990e-03f, 1.39042102e-02f,
  -5.56560978e-03f, 5.45792542e-02f, 2.65803896e-02f, 4.00747061e-02f, -8.71611573e-03f, -7.05167502e-02f, -2.29701865e-02f, 1.41421892e-02f, 6.89778849e-02f, 7.10988417e-02f,
  3.14405859e-02f, 1.45026669e-01f, 9.07265618e-02f, 3.71160693e-02f, 1.25289470e-01f, 7.64041096e-02f, 7.68023878e-02f, -5.63140213e-02f, 1.20137064e-02f, 5.46325929e-02f,
  1.42763838e-01f, 4.96458597e-02f, -1.07972817e-02f, -5.14724180e-02f, -3.30575891e-02f, 8.94578695e-02f, 1.12702794e-01f, -8.00890028e-02f, 1.28626794e-01f, -6.60097823e-02f,
  7.77705014e-02f, 5.25318235e-02f, -5.82651757e-02f, 1.06667206e-01f, 1.10038653e-01f, 1.88498385e-02f, 5.63974679e-02f, 8.06427374e-02f, -6.33417740e-02f, 7.75092915e-02f,
  -5.53361364e-02f, 7.48921335e-02f, 3.24533433e-02f, 3.68179493e-02f, -1.09950885e-01f, -1.81166217e-01f, -3.21303979e-02f, 4.96329106e-02f, 2.90755257e-02f, -3.17069739e-02f,
  5.35193039e-03f, -5.53685576e-02f, 8.47359598e-02f, 1.17520511e-01f, 1.77076593e-01f, 4.68215942e-02f, 1.15456149e-01f, -4.88526523e-02f, 1.08879797e-01f, 2.07492784e-01f,
  7.68630579e-02f, 1.17476128e-01f, 1.36813089e-01f, 9.18482915e-02f, 4.08261865e-02f, 1.47092670e-01f, 1.68674916e-01f, -5.96157536e-02f, 7.29838908e-02f, -7.35553876e-02f,
  2.22588088e-02f, 7.73386583e-02f, 3.81860621e-02f, -6.28964184e-03f, 3.69385257e-02f, 7.89455883e-03f, -4.89667691e-02f, 4.01842361e-03f, 7.15241134e-02f, 1.61509886e-02f,
  -5.46642020e-02f, -3.01724970e-02f, 3.24180759e-02f, 5.97728193e-02f, -1.12476595e-01f, 6.62359819e-02f, -6.35797754e-02f, -6.94091544e-02f, -4.93381508e-02f, 1.88800208e-02f,
  -4.07251567e-02f, -5.52813383e-03f, 1.06581207e-02f, -3.66855226e-02f, 1.15640067e-01f, -8.40626284e-02f, 5.93773462e-02f, 8.49870294e-02f, -3.74241658e-02f, 7.28695318e-02f,
  -4.20570653e-03f, 2.09897999e-02f, -7.02643618e-02f, -7.90151879e-02f, 6.26289546e-02f, -1.13285268e-02f, 3.75739783e-02f, 3.98994684e-02f, 8.18485767e-02f, 9.15272254e-03f,
  -9.83043239e-02f, 2.27311328e-02f, -1.49210924e-02f, 4.54063714e-02f, 7.74740428e-02f, -2.55494919e-02f, -4.90410812e-03f, -1.89467184e-02f, -2.81396583e-02f, -4.37627248e-02f,
  -5.95542565e-02f, -2.34397016e-02f, -2.84811240e-02f, 5.90482540e-02f, 1.98277421e-02f, -6.32601976e-02f, -3.34862359e-02f, 4.46215644e-02f, -2.35970505e-02f, 5.47339059e-02f,
  1.27127245e-02f, 2.08406195e-01f, 9.22706127e-02f, -7.86309838e-02f, 1.05890051e-01f, 1.77901164e-02f, 3.23178396e-02f, -6.20390847e-02f, 1.00754134e-01f, 3.89186144e-02f,
  7.96777532e-02f, -7.09969224e-03f, -6.62610680e-02f, 3.25771719e-02f, -1.64577048e-02f, 1.11136593e-01f, 1.88735053e-02f, 6.78170621e-02f, -1.89941525e-02f, -1.48750124e-02f,
  2.63641104e-02f, -8.71534180e-03f, -8.07564892e-03f, -4.32583541e-02f, 1.80688873e-02f, -3.52396742e-02f, -8.37022364e-02f, 4.83238026e-02f, 2.37179492e-02f, -4.16722968e-02f,
  -5.22437334e-01f, 1.03536569e-01f, 3.69547844e-01f, -5.27611554e-01f, 1.61392719e-01f, 2.61474609e-01f, -1.16565861e-01f, 1.68312602e-02f, -1.84065029e-01f, -1.89501271e-01f,
  -7.53324404e-02f, -1.07822515e-01f, 3.92577320e-01f, -1.77998111e-01f, 1.20293558e-01f, 2.51763016e-01f, -2.85725027e-01f, -1.95822835e-01f, 1.20429173e-02f, -1.62518710e-01f,
  -8.14428627e-02f, -2.13838428e-01f, 1.44459501e-01f, 6.42736852e-02f, -1.23570226e-01f, -2.15889648e-01f, -1.75671563e-01f, 3.03617567e-01f, -2.10631847e-01f, 1.59063861e-01f,
  -1.64916456e-01f, -1.91135466e-01f, 1.58110615e-02f, 1.49365384e-02f, -1.22124301e-02f, -3.38549204e-02f, -1.08603835e-02f, 8.33755881e-02f, -6.01151995e-02f, 1.18787531e-02f,
  -8.38320851e-02f, 9.31216478e-02f, -1.33368552e-01f, 6.21837862e-02f, 1.30286515e-02f, -5.50243631e-02f, 7.59842098e-02f, -3.33886929e-02f, -3.14739579e-03f, 9.93140563e-02f,
  6.96270242e-02f, 4.21968214e-02f, -7.80213298e-03f, -1.99882891e-02f, 9.70436335e-02f, -2.33294368e-02f, -5.95352575e-02f, 9.76165086e-02f, -3.82074602e-02f, -8.14445689e-02f,
  7.38687292e-02f, -2.34542657e-02f, -5.24249952e-03f, 3.38205695e-02f, -4.16068323e-02f, 3.08287703e-02f, -8.34415630e-02f, -4.79586311e-02f, -5.06062061e-02f, -1.89022720e-02f,
  -6.61772862e-02f, -5.55661954e-02f, -3.76329459e-02f, -3.79877053e-02f, -4.77490425e-02f, -1.15154997e-01f, -2.05137078e-02f, -3.47419791e-02f, 2.16139909e-02f, -2.43139155e-02f,
  -3.88555694e-04f, -4.29490488e-03f, 3.68076712e-02f, 4.82938997e-02f, 1.28864609e-02f, 2.31894422e-02f, 2.67125480e-02f, 8.44958574e-02f, 7.35140732e-03f, 6.15054332e-02f,
  -2.25801095e-01f, -2.47473672e-01f, -6.48102164e-02f, -7.33182440e-03f, -2.63559930e-02f, 9.92650017e-02f, -5.75556140e-03f, -5.63785471e-02f, -4.98733185e-02f, -3.29369716e-02f,
  -1.14587592e-02f, -8.18490144e-03f, -2.91030295e-02f, 2.97220200e-02f, 1.20038930e-02f, 3.81367207e-02f, -1.01202957e-01f, -1.12573266e-01f, -5.14582768e-02f, -1.58554092e-02f,
  -1.02873862e-01f, -4.28093709e-02f, 5.11596270e-04f, 8.39111209e-03f, -5.23907728e-02f, -9.25484896e-02f, -4.24320847e-02f, -7.81373587e-03f, 6.67332718e-03f, 5.50899729e-02f,
  -2.17821389e-01f, 5.92548959e-02f, -1.05163716e-01f, 1.87060200e-02f, -1.74861908e-01f, 1.65213086e-02f, 2.00269505e-01f, -1.42351672e-01f, -1.69529587e-01f, 1.83146000e-01f,
  2.19091818e-01f, 5.78769222e-02f, 8.51869211e-02f, 3.31198305e-01f, -7.18294084e-02f, 1.86454087e-01f, 2.72960722e-01f, 2.39631072e-01f, -1.10794924e-01f, -1.01761825e-01f,
  -4.54200618e-02f, 1.48435757e-01f, 5.85631989e-02f, -9.60801318e-02f, 6.62694424e-02f, -9.41627007e-03f, 1.67487767e-02f, -1.71171173e-01f, 9.60987806e-02f, 9.64761972e-02f,
  -1.09030478e-01f, -1.48059011e-01f, 7.11110458e-02f, -1.01640828e-01f, -9.11934674e-02f, 7.07526505e-02f, -5.93358241e-02f, -1.47138927e-02f, -2.80174334e-03f, -2.04871111e-02f,
  -7.76654631e-02f, 3.20560448e-02f, 2.62743607e-02f, -2.91095730e-02f, -2.09640395e-02f, -3.01562082e-02f, 5.75041063e-02f, -9.82827786e-03f, -5.38155474e-02f, -3.13529037e-02f,
  4.34773229e-02f, 2.73187496e-02f, 8.10467973e-02f, 9.83515903e-02f, -4.25447859e-02f, -2.87110116e-02f, 5.01648523e-02f, -6.82977494e-03f, 2.50385869e-02f, 3.69872898e-02f,
  9.70052928e-03f, 2.09534564e-03f, 6.86569959e-02f, 8.22360720e-03f, -1.03852944e-03f, 7.96685591e-02f, 3.33812311e-02f, -7.19218552e-02f, 2.86172796e-02f, 9.19817481e-03f,
  -6.63270876e-02f, -1.72828883e-02f, -1.48466807e-02f, 6.52703643e-02f, -1.80619843e-02f, -4.83708493e-02f, 3.36010158e-02f, -2.63101049e-03f, -6.11413755e-02f, 6.62740916e-02f,
  4.10994105e-02f, -2.77322605e-02f, -5.40419773e-04f, -4.07874305e-03f, 3.39409970e-02f, 6.01690076e-03f, -7.53885228e-03f, 8.28835145e-02f, 3.89985442e-02f, 2.72371452e-02f,
  -5.22237234e-02f, -2.55480528e-01f, -7.39220679e-02f, 3.57229710e-02f, 1.11936184e-03f, 4.83876653e-02f, 2.38714945e-02f, 1.82176791e-02f, 8.63640569e-03f, -7.00036511e-02f,
  1.88852716e-02f, -8.90247710e-03f, -2.24552117e-02f, 9.64565575e-02f, 4.71502021e-02f, -1.62184425e-02f, -2.00635865e-02f, -2.03880295e-02f, -5.22676930e-02f, -1.59430457e-03f,
  -2.71680281e-02f, -9.47378427e-02f, -6.13452829e-02f, 4.98143258e-03f, 8.71646106e-02f, -2.72851195e-02f, -6.40930906e-02f, -4.54324707e-02f, -6.50459602e-02f, 4.64337096e-02f,
  -2.09210045e-03f, 5.75110376e-01f, 3.56967449e-01f, 7.20117912e-02f, -1.37648895e-01f, -1.33110344e-01f, -5.48018217e-02f, 1.13286749e-01f, 2.34429121e-01f, 1.79855898e-01f,
  -1.49461195e-01f, 4.67275620e-01f, -4.23250087e-02f, 2.16974989e-02f, -4.34460133e-01f, -1.10723495e-01f, -1.59095839e-01f, -4.20662314e-02f, 8.71266872e-02f, -5.45609109e-02f,
  -1.59452826e-01f, -1.90743938e-01f, -2.19827414e-01f, -6.63697869e-02f, 8.91900137e-02f, 9.93042663e-02f, -2.57622451e-01f, 7.12422580e-02f, 7.99457878e-02f, -8.25448427e-03f,
  4.83930744e-02f, 1.98529419e-02f, 9.37892944e-02f, 7.23262951e-02f, -1.02272622e-01f, -3.58685367e-02f, -2.61763390e-03f, 1.73410177e-02f, -9.44817031e-04f, 9.79164466e-02f,
  7.02687353e-02f, -1.48153547e-02f, -1.86614394e-02f, 2.18751635e-02f, 2.62659080e-02f, 6.58871187e-03f, -1.70400422e-02f, 7.96302706e-02f, 1.24829970e-01f, 1.07207030e-01f,
  1.36931717e-01f, 1.05382085e-01f, 1.12672060e-04f, 3.19241323e-02f, -9.28866193e-02f, 1.87937089e-03f, 4.97565009e-02f, -1.74068834e-03f, -3.25602107e-02f, 4.12804559e-02f,
  8.12125765e-03f, -2.57904958e-02f, 4.80859820e-03f, 7.27934949e-03f, 1.64168589e-02f, 4.12536301e-02f, -3.40098888e-03f, -2.31028229e-04f, 1.02800645e-01f, -9.03553665e-02f,
  4.09095036e-03f, 9.34920758e-02f, -2.94223130e-02f, -3.47591378e-02f, 2.49637943e-02f, 5.93687147e-02f, -7.02773780e-03f, -2.07462311e-02f, 6.78391457e-02f, 3.62048484e-02f,
  8.51073395e-03f, -3.10201440e-02f, 1.04066543e-02f, -3.16651575e-02f, -1.94303819e-03f, 1.91383660e-02f, 8.50810632e-02f, 6.29258156e-02f, -2.94718537e-02f, -9.68704969e-02f,
  -1.49093941e-01f, 7.36421579e-03f, -1.56557024e-03f, 1.00371785e-01f, 1.17072808e-02f, 1.09559326e-02f, -2.71324702e-02f, -2.29549911e-02f, -1.21339494e-02f, -5.42265698e-02f,
  -2.62740720e-02f, 6.53054519e-03f, -1.61475986e-02f, 7.51730204e-02f, -5.48992492e-02f, -1.67880226e-02f, -2.84551997e-02f, -1.89528614e-02f, -1.21439099e-01f, 2.55419686e-02f,
  6.60036132e-02f, -7.28084967e-02f, 2.77649960e-03f, -8.78442302e-02f, 4.49808501e-03f, -4.13813181e-02f, 1.45193553e-02f, 9.15098842e-03f, -6.63345307e-02f, -1.54391374e-03f,
  2.16902979e-03f, -3.24988551e-02f, -1.19559281e-01f, -1.35686621e-01f, -1.42503574e-01f, -1.83774769e-01f, -2.37485424e-01f, -6.12215176e-02f, 7.31623620e-02f, -9.16805044e-02f,
  -1.28727674e-01f, 1.14812352e-01f, 5.18863387e-02f, -2.88787216e-01f, 1.30081188e-03f, 1.44983798e-01f, -2.03059167e-01f, -7.65932649e-02f, -1.98726095e-02f, -1.17101893e-01f,
  8.31984356e-03f, -4.92731817e-02f, -1.24344677e-01f, -1.02875397e-01f, -2.10548535e-01f, -1.27070531e-01f, 1.39753908e-01f, -1.25726327e-01f, -2.13505223e-01f, 8.71088449e-03f,
  -1.40277669e-01f, 7.91687053e-04f, -6.63727149e-02f, 4.41545770e-02f, -9.73666459e-02f, -3.75349894e-02f, 2.57341098e-02f, -7.64830038e-02f, -9.83014237e-03f, -2.55529135e-02f,
  3.04955598e-02f, -1.22356545e-02f, -2.96358764e-02f, 1.12912610e-01f, -7.68040195e-02f, -6.14969954e-02f, -4.33176719e-02f, -8.53275657e-02f, 1.39543163e-02f, -6.01085573e-02f,
  -8.08348432e-02f, -5.25070615e-02f, -7.36849979e-02f, 4.11695093e-02f, -4.73051108e-02f, 2.64824163e-02f, 1.21236360e-02f, 3.55456732e-02f, -4.40003397e-03f, -4.98211235e-02f,
  1.48505997e-02f, -2.31886911e-03f, -7.54581541e-02f, 4.39889496e-03f, 2.74281297e-02f, -3.99511717e-02f, 2.32384307e-03f, 3.87757570e-02f, -8.88163410e-03f, -3.08874268e-02f,
  -6.56333938e-02f, 9.58937965e-03f, -2.25131493e-02f, -7.14407563e-02f, 5.07268310e-02f, 7.40027502e-02f, 3.77026983e-02f, 3.23165692e-02f, -4.68746796e-02f, -4.19937856e-02f,
  1.13214366e-02f, 4.28988552e-03f, -2.30277479e-02f, -2.66600922e-02f, 1.16520394e-02f, -3.86237018e-02f, 7.82620013e-02f, -7.19226524e-02f, 3.07648480e-02f, -4.15053181e-02f,
  4.64183576e-02f, 1.56625956e-02f, -3.34780663e-02f, -1.93634275e-02f, -5.28839603e-02f, -3.92911732e-02f, -2.38252431e-02f, 6.35681972e-02f, 7.33954534e-02f, 2.58388948e-02f,
  -6.94804313e-03f, 4.25874665e-02f, 5.09735011e-02f, -4.16778289e-02f, -7.75064826e-02f, -9.51226242e-03f, 1.47115598e-02f, 2.00421680e-02f, -7.54536167e-02f, -6.50952384e-02f,
  -5.02571017e-02f, -9.30434838e-03f, 2.40669046e-02f, 5.38569540e-02f, 7.83993825e-02f, 6.51055109e-03f, 6.40765876e-02f, -5.80403432e-02f, -5.69951721e-02f, -3.22764665e-02f,
  2.24423692e-01f, -7.31295198e-02f, -1.63174570e-01f, -3.38744256e-04f, -8.11695904e-02f, -4.90987152e-02f, -1.25715852e-01f, -8.67759064e-02f, -4.43703346e-02f, -1.18470035e-01f,
  -3.65007333e-02f, -1.24204485e-02f, 8.25698674e-02f, -3.29273008e-02f, 1.47032335e-01f, 1.08633146e-01f, -5.83480485e-02f, -1.06307000e-01f, -6.70044348e-02f, 6.16636313e-02f,
  -1.20989699e-02f, -6.08783625e-02f, -1.51831225e-01f, -1.25820279e-01f, -5.54271154e-02f, -1.45496100e-01f, 8.37994069e-02f, -1.64897010e-01f, -7.56699964e-02f, -3.12917754e-02f,
  -6.30695559e-03f, -2.59437449e-02f, 5.79453669e-02f, -5.58824241e-02f, -8.11103359e-02f, -1.86898164e-03f, -9.73014310e-02f, -3.75315151e-03f, 2.31454354e-02f, 6.76126182e-02f,
  2.11610086e-02f, 7.73005234e-03f, -1.02654040e-01f, -3.63028497e-02f, 4.32327911e-02f, -9.68486769e-04f, -4.87739183e-02f, -6.21105172e-02f, -1.41737470e-02f, -3.43005396e-02f,
  -3.58724073e-02f, -1.97239295e-02f, -1.18185785e-02f, 3.79510187e-02f, -7.60274231e-02f, -6.56746626e-02f, 7.12388530e-02f, -1.59597974e-02f, -3.89947630e-02f, -1.33620556e-02f,
  -2.68060202e-03f, 4.21811715e-02f, 7.66295120e-02f, -3.63004580e-02f, -7.08226860e-02f, 3.62399109e-02f, -1.66895986e-02f, -5.40117593e-03f, -5.40405326e-02f, -5.30364923e-02f,
  -2.62474921e-02f, 9.21785686e-05f, -4.93348353e-02f, 8.78293440e-03f, 7.84107074e-02f, 8.81744027e-02f, -5.27018532e-02f, -2.44846120e-02f, -2.84896735e-02f, -1.13929091e-02f,
  4.72429320e-02f, -4.28875051e-02f, -7.55929016e-03f, -2.45013796e-02f, -6.83966503e-02f, -5.04545569e-02f, -2.38789748e-02f, -8.43451172e-03f, -3.00732162e-02f, -2.47818548e-02f,
  -9.44358930e-02f, -2.00001244e-02f, -1.07933544e-01f, 7.04269111e-02f, 2.49426942e-02f, 4.77883928e-02f, 7.10510537e-02f, 2.88529526e-02f, -3.22914496e-02f, 5.61005175e-02f,
  -6.61789775e-02f, 4.67276312e-02f, -7.82325342e-02f, -7.71661922e-02f, -5.93159907e-02f, 3.59996520e-02f, -2.06666011e-02f, 1.63905118e-02f, -2.68228538e-02f, 2.96885185e-02f,
  6.37305453e-02f, 4.82804328e-02f, 6.42381832e-02f, -3.50138918e-02f, 6.48519546e-02f, 4.21802811e-02f, 6.06030747e-02f, -6.14268035e-02f, -5.68694957e-02f, -2.96175946e-02f,
  3.21294039e-01f, -3.12457383e-01f, -2.97630548e-01f, 1.36425138e-01f, 2.47828051e-01f, 1.82321951e-01f, 8.53220820e-02f, 1.10723957e-01f, 5.41501045e-02f, -4.63031828e-02f,
  1.01331837e-01f, -1.83969960e-01f, -2.55864710e-01f, 1.76177874e-01f, 1.35226563e-01f, -6.08847141e-02f, 1.41570166e-01f, 1.00556791e-01f, 7.20016435e-02f, -8.98974296e-03f,
  1.80288658e-01f, 2.70345539e-01f, -9.69198644e-02f, 8.43142122e-02f, 9.00376961e-02f, 1.60110053e-02f, 3.95033322e-03f, -1.99233294e-01f, 1.65452003e-01f, 9.45408121e-02f,
  6.51619434e-02f, -3.77985463e-02f, 7.61015043e-02f, -7.46855736e-02f, -4.65712138e-02f, -2.74771359e-02f, -9.07727852e-02f, -5.82935475e-02f, 8.47981423e-02f, 1.05597213e-01f,
  -5.68522587e-02f, 5.79239056e-02f, 1.18534639e-01f, -1.08175604e-02f, 3.21170874e-02f, 7.59360120e-02f, -4.01438549e-02f, 2.35185064e-02f, 1.02323843e-02f, -3.24033014e-02f,
  4.75856401e-02f, -2.03517154e-02f, 1.75547302e-02f, -2.33867709e-02f, -4.56055403e-02f, -3.21868695e-02f, -8.58374611e-02f, -3.33857201e-02f, -4.85056220e-03f, -4.64058258e-02f,
  6.70449168e-04f, -5.50208539e-02f, 1.06266113e-02f, 5.90765588e-02f, -6.10745214e-02f, 7.65829533e-02f, -3.69229168e-02f, 5.77189401e-02f, -4.21606861e-02f, 3.12759690e-02f,
  2.81568170e-02f, -2.00383812e-02f, 6.90791532e-02f, -5.57383895e-02f, 4.03481014e-02f, 3.70915141e-03f, 2.38532815e-02f, 2.28911340e-02f, 1.55772297e-02f, 6.72432929e-02f,
  1.85651649e-02f, 4.48479056e-02f, 2.09285785e-02f, -2.21625399e-02f, -8.60039610e-03f, -3.48065943e-02f, 6.39628386e-03f, 5.47647029e-02f, -7.30193406e-02f, 5.90026602e-02f,
  -3.32475714e-02f, -1.90003142e-01f, -7.59234726e-02f, -4.33100909e-02f, -1.04133308e-01f, 4.76653054e-02f, 4.52340767e-02f, 1.57683957e-02f, -6.19890653e-02f, -4.95057218e-02f,
  -2.78964955e-02f, -3.40826847e-02f, -1.76757528e-03f, 2.61930143e-03f, -5.32068349e-02f, 7.56523833e-02f, -6.53114393e-02f, -4.33721989e-02f, 3.55642736e-02f, -2.41135160e-04f,
  -7.02192634e-02f, 3.05102039e-02f, -4.88255098e-02f, 6.01985864e-02f, 6.40527457e-02f, -5.35021164e-02f, 4.61084433e-02f, -7.82984346e-02f, 1.63823348e-02f, 1.15763899e-02f,
  1.93749651e-01f, -1.34431154e-01f, -2.21856296e-01f, 1.80906162e-01f, 1.48396924e-01f, -7.41890073e-02f, -2.13455901e-01f, 6.43431842e-02f, -2.25043833e-01f, -3.14708538e-02f,
  1.27058253e-01f, -1.90826189e-02f, -3.65954250e-01f, 2.58647442e-01f, 2.72848517e-01f, -1.26124606e-01f, 2.83872426e-01f, 1.08095199e-01f, -1.45567015e-01f, 1.09904811e-01f,
  1.27987444e-01f, 3.97867888e-01f, 7.98335150e-02f, 2.53447622e-01f, 1.62519306e-01f, 6.32161275e-02f, 2.53695130e-01f, -1.46543503e-01f, 3.77455264e-01f, 2.27750123e-01f,
  5.42339645e-02f, -7.33311176e-02f, -1.05063086e-02f, 4.11347784e-02f, -1.39967091e-02f, 5.94270639e-02f, 2.40410920e-02f, 6.31084815e-02f, -5.16912229e-02f, -7.21284226e-02f,
  -5.24149910e-02f, 1.81562528e-02f, 1.30151927e-01f, 6.82459697e-02f, 4.07112539e-02f, 3.94323431e-02f, -8.82969890e-03f, -3.66983027e-03f, -7.75445178e-02f, -1.13694370e-02f,
  -1.27155378e-01f, -3.66457365e-02f, 6.37152269e-02f, -3.53034213e-02f, -5.78248724e-02f, 5.92616759e-02f, -6.03335835e-02f, -3.69214341e-02f, 3.50692756e-02f, 6.88572899e-02f,
  2.89121270e-02f, -1.54950302e-02f, -6.80566952e-02f, -6.39022067e-02f, -1.95295513e-02f, -7.64891058e-02f, 3.72609533e-02f, -6.50639459e-02f, -2.23122779e-02f, -5.57415895e-02f,
  -8.23037624e-02f, 1.26458500e-02f, -9.10723209e-03f, -2.79859523e-03f, 2.85557378e-02f, -4.66480851e-02f, -4.31585638e-03f, 4.22645025e-02f, -1.14866547e-01f, -1.74749549e-02f,
  -2.71585472e-02f, -4.86844182e-02f, -5.29293157e-02f, -7.12984754e-03f, -1.86207667e-02f, -1.29629727e-02f, 2.70567369e-02f, -1.23571968e-02f, -9.50839967e-02f, -1.73346978e-02f,
  2.74390653e-02f, 1.33738056e-01f, -8.86877105e-02f, -5.46901226e-02f, 1.17940558e-02f, -3.98168378e-02f, 5.03866896e-02f, 7.11848289e-02f, 4.53853495e-02f, -4.77827564e-02f,
  5.25187291e-02f, -3.65836918e-02f, 2.38341633e-02f, -3.43347825e-02f, 1.05945498e-01f, 3.56393456e-02f, -4.47047912e-02f, -5.88533022e-02f, 2.78643593e-02f, 2.24226471e-02f,
  5.84722720e-02f, -3.54597755e-02f, 3.85634489e-02f, -9.23065618e-02f, 5.94189912e-02f, 5.76591603e-02f, -1.08768446e-02f, 1.97097231e-02f, 2.10976619e-02f, -1.98953301e-02f,
  -1.40891001e-01f, -4.51300573e-03f, -9.72587541e-02f, 2.41503030e-01f, -1.17876396e-01f, 1.65578634e-01f, 1.49461046e-01f, -5.72581552e-02f, 2.82595098e-01f, 2.12141097e-01f,
  4.31048907e-02f, -1.01324581e-01f, -7.47179091e-02f, 2.57148117e-01f, -6.34665340e-02f, 1.54178292e-01f, 3.45438629e-01f, 2.24890620e-01f, -4.33243141e-02f, 7.82577787e-03f,
  -4.54350710e-02f, 1.05029084e-01f, -8.53191763e-02f, -1.67871863e-01f, -3.42736952e-02f, -1.24645166e-01f, -1.31952092e-01f, -2.11936504e-01f, -2.19843909e-02f, -1.23209879e-01f,
  8.66699964e-03f, 1.93262473e-02f, -2.08334215e-02f, -4.35930006e-02f, 5.84037378e-02f, -3.37410532e-02f, -8.33087489e-02f, -2.20502615e-02f, -8.06484148e-02f, -4.55271117e-02f,
  5.19410660e-03f, -1.03641972e-01f, 8.80615562e-02f, -6.25113547e-02f, 1.21803228e-02f, 1.72994286e-02f, -6.76535442e-02f, 6.63675368e-02f, 6.28564283e-02f, -1.04635753e-01f,
  5.63847786e-03f, 4.69119698e-02f, 4.86767292e-03f, 5.54076433e-02f, 4.19195779e-02f, -4.14429009e-02f, -3.22760046e-02f, -9.62770917e-03f, -8.32563117e-02f, 3.66694108e-02f,
  5.63074201e-02f, -6.43895268e-02f, -3.67636457e-02f, -7.49272853e-02f, -7.39718452e-02f, 1.86139364e-02f, 4.11869884e-02f, -2.00631954e-02f, -1.54578956e-02f, -3.40048373e-02f,
  4.89746481e-02f, -5.58705777e-02f, 6.98407516e-02f, -4.34516482e-02f, 8.61575902e-02f, 8.37549567e-02f, -7.76123405e-02f, 3.61281894e-02f, 9.61821005e-02f, 3.40313762e-02f,
  7.82689378e-02f, -2.35707276e-02f, -1.04712941e-01f, 3.75989303e-02f, -6.31790608e-02f, 4.37924545e-03f, 6.42262166e-03f, 7.24526569e-02f, -3.41769010e-02f, 1.23531576e-02f,
  -2.88743060e-02f, -9.33418705e-05f, -2.96616238e-02f, -6.55114418e-03f, 3.54124494e-02f, 6.65224567e-02f, -4.27240942e-04f, -3.69141176e-02f, -3.90532613e-02f, 3.57267447e-02f,
  4.75772247e-02f, 7.99305215e-02f, -6.10979013e-02f, 2.67876666e-02f, -6.59117699e-02f, -1.79851688e-02f, 3.32797840e-02f, 1.01981550e-01f, -4.39014323e-02f, 3.52006294e-02f,
  -1.09560966e-01f, 3.02129444e-02f, 5.66830114e-02f, 5.77001721e-02f, 5.75538212e-03f, -3.16106454e-02f, -4.24201135e-03f, -9.47800279e-02f, 1.71554442e-02f, -2.73095518e-02f,
  -5.66507503e-02f, -9.57349986e-02f, 2.52755910e-01f, 5.51822642e-03f, 1.03196234e-01f, 2.18112692e-01f, 2.61839181e-01f, 1.10303767e-01f, -4.57764566e-02f, -1.87815651e-01f,
  -7.80526847e-02f, -1.87107623e-01f, 8.39771032e-02f, -1.37954712e-01f, 2.54137069e-01f, 1.45226121e-01f, -1.62384659e-02f, -5.53744026e-02f, 3.15103345e-02f, -1.02410026e-01f,
  -5.06674051e-02f, -9.05268490e-02f, 1.49928838e-01f, -6.49302304e-02f, 2.18551252e-02f, -7.82863423e-02f, -1.56370789e-01f, 7.08140507e-02f, -1.66605309e-01f, 1.41681777e-02f,
  -6.23180531e-02f, -1.55231819e-01f, 4.04991135e-02f, 3.23869735e-02f, 3.65747958e-02f, -7.07843676e-02f, 2.45454386e-02f, 1.08169436e-01f, 4.33425568e-02f, 8.26452076e-02f,
  -7.71713108e-02f, -6.97387606e-02f, -6.60643959e-03f, -3.99023155e-03f, -8.47697258e-02f, 3.55216078e-02f, 1.23651676e-01f, 1.28571868e-01f, 7.37385228e-02f, 1.46652132e-01f,
  7.18674362e-02f, 5.56977419e-03f, 9.66019928e-02f, -5.33922836e-02f, -4.07107212e-02f, 1.88536141e-02f, 6.64551780e-02f, 3.69035453e-02f, 4.11097221e-02f, -6.34034947e-02f,
  -8.96924511e-02f, -7.19569623e-02f, 5.08355126e-02f, 1.20613819e-04f, -7.20646456e-02f, 5.69919497e-02f, -1.09813008e-02f, -7.13732690e-02f, 7.18984157e-02f, 7.05317315e-03f,
  -6.35596784e-03f, -9.01928842e-02f, -1.24326092e-03f, 1.47338421e-03f, 4.25869524e-02f, -1.14704936e-03f, -4.44359556e-02f, -1.34604122e-03f, 3.52305844e-02f, 4.44674902e-02f,
  -9.62306187e-02f, 4.99017350e-02f, -6.21492639e-02f, -5.14224209e-02f, 5.23515195e-02f, 6.58698604e-02f, -5.68136312e-02f, 4.66448888e-02f, -2.41234191e-02f, 3.58328596e-02f,
  -9.12998244e-02f, -2.69922435e-01f, 1.27185341e-02f, -1.12873830e-01f, -4.54353876e-02f, -1.16944186e-01f, -1.95531975e-02f, -3.19241546e-02f, -7.27331042e-02f, -3.33841257e-02f,
  1.27065741e-02f, -9.90573838e-02f, 3.36792693e-02f, -7.55635872e-02f, 5.92806190e-03f, -4.63099852e-02f, -9.30142403e-02f, -9.02559757e-02f, -5.49582727e-02f, -7.34408274e-02f,
  -1.33929998e-02f, -9.30067450e-02f, -2.16173194e-02f, -1.82512272e-02f, -4.54517901e-02f, -9.58871692e-02f, -8.48324150e-02f, -5.34090735e-02f, -3.68498489e-02f, 3.43722366e-02f,
  -1.69494390e-01f, 7.83680081e-02f, -1.88852530e-02f, -5.94835691e-02f, 7.08150566e-02f, -5.07348925e-02f, -8.96582603e-02f, 2.31731497e-02f, -1.51090011e-01f, 1.47894666e-01f,
  3.78587805e-02f, -2.82644611e-02f, 4.71089259e-02f, -9.50192213e-02f, -4.23447132e-01f, -2.39522487e-01f, -1.21081829e-01f, -8.21533874e-02f, -7.21401349e-02f, 2.92122960e-02f,
  -1.10087305e-01f, 3.13756876e-02f, -7.38312975e-02f, 7.29097575e-02f, 5.77035733e-02f, 5.63983321e-02f, 1.37941405e-01f, 1.62450403e-01f, 1.36664743e-02f, -4.26444635e-02f,
  -2.90782340e-02f, -6.83314353e-02f, -2.14322540e-03f, -1.87058002e-02f, 2.56442074e-02f, 4.81277145e-02f, 1.54573955e-02f, 1.98539048e-02f, -3.50767337e-02f, 4.04045396e-02f,
  5.96962161e-02f, -7.04486072e-02f, -2.43147612e-02f, 3.34925242e-02f, -6.39147758e-02f, -6.29275516e-02f, 3.64172794e-02f, -9.08882916e-02f, -6.55782819e-02f, 2.95109153e-02f,
  5.10514714e-03f, -7.65370205e-02f, 5.45096360e-02f, 1.42291337e-02f, -7.24087209e-02f, 8.11114535e-02f, -5.02932072e-02f, -4.88837734e-02f, 8.15608203e-02f, 3.45523767e-02f,
  3.61292958e-02f, 7.59958429e-03f, 1.40773214e-03f, -3.07819005e-02f, -2.27029324e-02f, -5.28813489e-02f, 7.83889368e-02f, -7.56539917e-03f, -4.17913161e-02f, 6.79344311e-02f,
  -3.05352472e-02f, -6.54017404e-02f, 4.79282103e-02f, -1.16350595e-02f, 5.52328564e-02f, -5.69344200e-02f, 2.41828971e-02f, -3.94102633e-02f, 4.83707860e-02f, -7.12461118e-03f,
  -2.15139370e-02f, -7.11731538e-02f, -5.22047691e-02f, 5.59844486e-02f, -5.01255468e-02f, -4.44629826e-02f, -2.52732094e-02f, 5.51945008e-02f, -3.15715149e-02f, 6.39266893e-02f,
  9.11709592e-02f, -9.39540938e-03f, 8.45052153e-02f, -1.64160095e-02f, 1.11273423e-01f, -5.10830507e-02f, -6.11021370e-02f, -8.88642892e-02f, 3.35332826e-02f, -5.32496534e-02f,
  -2.72407457e-02f, 6.71208650e-02f, 4.27216031e-02f, -7.61497542e-02f, -6.68731108e-02f, 2.65383404e-02f, 6.85890345e-03f, 7.72590116e-02f, 3.31659685e-03f, 5.47498800e-02f,
  1.15934752e-01f, 6.99962974e-02f, -7.88582712e-02f, 6.96987808e-02f, -5.00321016e-02f, -3.47886197e-02f, 3.00062913e-02f, 8.13562572e-02f, -3.40445973e-02f, -3.76625396e-02f,
  1.41967293e-02f, 3.69932950e-01f, 2.83129066e-01f, 1.12698518e-01f, -3.44290704e-01f, 8.07524025e-02f, 5.40751815e-02f, 2.35407352e-02f, 2.29736462e-01f, 2.00450629e-01f,
  -2.58179635e-01f, 2.33219564e-01f, 4.24324311e-02f, 9.55599174e-02f, 1.66213978e-02f, 1.43138096e-01f, 1.50450483e-01f, 1.26891911e-01f, 1.51268058e-02f, 3.91623378e-02f,
  1.61038333e-04f, -2.13221923e-01f, 5.71467206e-02f, -1.02359451e-01f, -1.28985420e-01f, 1.35007307e-01f, -2.53373593e-01f, -1.01772986e-01f, 1.64002329e-02f, -1.52301997e-01f,
  -1.42685488e-01f, -1.71810773e-03f, 8.01411048e-02f, 1.45689398e-01f, -5.18007353e-02f, -7.09803775e-03f, 9.51810777e-02f, -6.13744780e-02f, -4.92436849e-02f, -1.83904618e-02f,
  6.77853897e-02f, 1.99259389e-02f, 5.36771603e-02f, 2.73483582e-02f, 1.05955591e-02f, -7.12700048e-03f, -1.68954469e-02f, -6.51112720e-02f, 6.62903935e-02f, -4.76671569e-02f,
  3.76657173e-02f, -1.07661746e-02f, -5.29771298e-02f, 1.19412854e-01f, 1.08506698e-02f, 1.41633197e-03f, 1.42939165e-02f, -2.60847416e-02f, 7.71545917e-02f, 2.57997364e-02f,
  -2.06499752e-02f, 6.78410940e-03f, -6.56487932e-03f, -1.68570932e-02f, -2.02492289e-02f, -1.17825747e-01f, -2.70680916e-02f, -7.07602352e-02f, -3.93333770e-02f, -3.62433344e-02f,
  1.08956071e-02f, -7.94616938e-02f, -2.24461686e-02f, -4.48244810e-02f, -5.86553477e-02f, -3.41425017e-02f, -8.13397691e-02f, 6.32692277e-02f, -1.23037910e-02f, -2.73338985e-02f,
  -7.37136006e-02f, 4.64550359e-03f, -7.66179636e-02f, -1.78308208e-02f, 5.35770655e-02f, -6.05213270e-02f, 3.78545821e-02f, 4.83047515e-02f, 3.98634113e-02f, -8.09991136e-02f,
  1.63476706e-01f, 2.40436360e-01f, -3.70616801e-02f, 5.04871607e-02f, 2.94312164e-02f, -1.33538842e-02f, -2.70887036e-02f, 8.25446397e-02f, 9.70061943e-02f, 6.73148185e-02f,
  -3.17478217e-02f, 3.42030567e-03f, -2.00580321e-02f, -8.38336274e-02f, 5.89563362e-02f, 1.64760165e-02f, 1.23188021e-02f, 2.48896871e-02f, -1.74533427e-02f, 2.08938345e-02f,
  -4.98375110e-03f, -4.44760099e-02f, 7.76236802e-02f, 2.19439110e-03f, 1.47577701e-02f, 5.78763857e-02f, 3.58222164e-02f, 5.44179231e-02f, -2.18227319e-02f, 1.47528231e-01f,
  -1.72356263e-01f, 7.37940148e-02f, -1.27839938e-01f, -6.88332468e-02f, -9.87989381e-02f, 1.41587615e-01f, 1.81386560e-01f, 1.01171685e-02f, 4.06409204e-02f, 2.22393170e-01f,
  8.80259722e-02f, -1.20178103e-01f, -2.15434539e-03f, 1.27619147e-01f, -7.34598339e-02f, 1.41246557e-01f, 1.84616417e-01f, 4.91774529e-02f, 1.54869892e-02f, -4.28571776e-02f,
  -4.45686765e-02f, -1.55573804e-02f, 5.26426174e-02f, -3.01985685e-02f, -9.65112261e-03f, -1.68424584e-02f, 2.25701998e-03f, -6.90509528e-02f, -1.11299129e-02f, -6.63216114e-02f,
  1.40314624e-01f, -8.76665264e-02f, 3.47057097e-02f, -3.40428613e-02f, 6.05338672e-03f, 5.72526641e-02f, 6.12122156e-02f, -9.72720832e-02f, -1.05671808e-01f, 1.45748239e-02f,
  -1.55633865e-02f, -9.47025232e-03f, 2.37704925e-02f, 6.96123391e-03f, 8.19339454e-02f, 6.51305988e-02f, -8.91302153e-02f, 1.22582708e-02f, 6.83591813e-02f, -1.12440601e-01f,
  -4.34515961e-02f, 8.78977627e-02f, -6.06007129e-02f, 2.32573990e-02f, -1.03876488e-02f, 1.85007863e-02f, -5.46054030e-03f, 4.53371741e-02f, 7.02462196e-02f, 6.76121935e-02f,
  -8.46660882e-02f, 3.37919407e-02f, -2.97259223e-02f, 6.36435524e-02f, 5.54644130e-02f, 1.95933282e-02f, 3.37540843e-02f, -1.61781013e-02f, 4.58966121e-02f, 8.28606412e-02f,
  -3.03402338e-02f, -6.59089386e-02f, 8.18238556e-02f, -1.74875185e-02f, 5.80361485e-02f, 2.22662743e-02f, 1.65716112e-02f, 1.21237570e-03f, 7.14768246e-02f, -4.42429371e-02f,
  4.73237187e-02f, -1.07348729e-02f, 6.06185235e-02f, -5.82846776e-02f, 1.88920349e-02f, -7.69031176e-04f, -7.19852298e-02f, -1.75602045e-02f, 9.43618827e-03f, -6.00707829e-02f,
  2.04103157e-01f, -6.51274947e-03f, 3.82038206e-02f, -1.26402685e-02f, 2.40832120e-02f, 1.42996376e-02f, 4.84039225e-02f, 1.16195092e-02f, 1.76223665e-02f, -9.33152810e-02f,
  3.80602628e-02f, 7.39384964e-02f, 6.52642176e-02f, -5.82266115e-02f, -4.09789234e-02f, -1.04820039e-02f, 5.11029772e-02f, -6.43844679e-02f, 9.60160047e-03f, -1.13572627e-01f,
  5.25214300e-02f, 4.77821045e-02f, 5.43765686e-02f, -3.64415683e-02f, -2.47449018e-02f, 2.56218277e-02f, 8.05866495e-02f, -9.71349627e-02f, -3.83327007e-02f, 1.34252515e-02f,
  -2.01731877e-04f, -1.27691314e-01f, -7.37650916e-02f, 5.78967147e-02f, -1.95938852e-02f, -1.49230868e-01f, -1.63115226e-02f, 6.58549741e-02f, 2.82841343e-02f, -1.23088621e-02f,
  -8.14471468e-02f, -2.96940067e-04f, -1.82494387e-01f, 3.00280415e-02f, -1.25138257e-02f, -1.71221182e-01f, -5.38686328e-02f, 5.27196787e-02f, 2.53478047e-02f, 1.02133974e-01f,
  3.35354730e-02f, 8.05423185e-02f, 2.84800753e-02f, 1.46357063e-02f, 1.36151053e-02f, 1.24983825e-01f, 1.08866021e-01f, 8.51594731e-02f, 1.96644351e-01f, -3.86445038e-02f,
  -3.81729342e-02f, 2.93375347e-02f, -1.53514082e-02f, -9.85731743e-03f, 1.56427585e-02f, 8.63058940e-02f, 1.64775066e-02f, -5.55700660e-02f, -2.19977591e-02f, -7.58246332e-02f,
  -5.38989305e-02f, 5.74439280e-02f, 8.60432610e-02f, -6.50595725e-02f, 5.90218045e-02f, 9.62675363e-02f, 1.35773104e-02f, -7.55522102e-02f, 3.63306999e-02f, -8.82871822e-02f,
  -3.21645439e-02f, 5.78195369e-03f, 6.96203560e-02f, 3.46003883e-02f, 6.91606998e-02f, 4.02041078e-02f, 4.25453857e-02f, 4.83206697e-02f, -3.48026236e-03f, -2.64912844e-02f,
  -1.38705615e-02f, -1.33528644e-02f, -1.05118379e-01f, 5.42305373e-02f, -3.45277712e-02f, 1.14174346e-02f, -6.21473268e-02f, 1.12811732e-03f, -2.72306409e-02f, -5.68695553e-03f,
  -2.59330906e-02f, 2.32606716e-02f, -1.20879302e-03f, -1.01979829e-01f, -8.50850195e-02f, 7.56568536e-02f, -4.52228226e-02f, -6.36126027e-02f, 7.48852193e-02f, -2.16693636e-02f,
  -3.04557476e-02f, 4.17606533e-02f, 6.33883625e-02f, 1.77900903e-02f, -7.35962763e-02f, -9.18864757e-02f, -2.07706951e-02f, -4.46002148e-02f, -1.22208297e-02f, -5.23589998e-02f,
  -2.07923669e-02f, 7.82958120e-02f, 8.57583210e-02f, -4.00778987e-02f, -7.44214207e-02f, 2.00715736e-02f, -2.04953924e-02f, -2.34529674e-02f, 1.23181716e-02f, -8.90765991e-03f,
  1.38739973e-01f, -5.06581366e-02f, 6.93778098e-02f, 5.07385433e-02f, 7.91443810e-02f, -5.06036207e-02f, 8.31708759e-02f, 2.00787876e-02f, 7.40893632e-02f, 1.04255155e-01f,
  -8.65144713e-04f, -9.74916369e-02f, -5.47618419e-02f, -5.43322638e-02f, 7.49438033e-02f, -2.09815092e-02f, -4.47275490e-02f, 1.01573067e-02f, -4.78196293e-02f, -5.87858297e-02f,
  3.92675474e-02f, 9.12899151e-02f, 9.77500007e-02f, -8.26473534e-02f, -3.46621387e-02f, -1.21939912e-01f, -7.33560175e-02f, 6.43159747e-02f, 1.04411840e-01f, -4.43597138e-02f,
  -1.76342707e-02f, 1.20054200e-01f, -6.05273061e-02f, -5.65258637e-02f, -1.28402844e-01f, -4.14072536e-02f, -9.69350189e-02f, -1.33317001e-02f, 4.81388122e-02f, -5.88730127e-02f,
  -8.90073366e-03f, 4.12831903e-02f, -7.78623074e-02f, 1.03840567e-02f, -6.06271774e-02f, 6.62028268e-02f, -6.68330863e-02f, -7.00134337e-02f, 5.52854277e-02f, 7.90852159e-02f,
  3.68786720e-03f, 1.24277107e-01f, -6.28708526e-02f, -5.64291216e-02f, -8.49537551e-03f, -5.36773726e-02f, -6.04458712e-02f, 5.91806173e-02f, -2.12994404e-02f, 4.00562063e-02f,
  2.94646621e-02f, 5.82698509e-02f, 8.80976543e-02f, 1.48752369e-02f, -5.47694899e-02f, 9.28911790e-02f, 8.07498470e-02f, -7.93067366e-02f, 5.40593937e-02f, 6.59926236e-02f,
  -4.09108624e-02f, -5.30319521e-03f, 2.62537263e-02f, 3.88895832e-02f, -4.16852683e-02f, 3.00287697e-02f, -3.17998230e-02f, -6.15078397e-02f, -3.30343172e-02f, -6.85543120e-02f,
  7.26109417e-03f, -1.19054377e-01f, -2.62153009e-03f, 1.83980621e-03f, 7.14399144e-02f, -3.63819161e-03f, 5.46871386e-02f, 1.70468409e-02f, 6.40328452e-02f, -4.74382490e-02f,
  2.09603515e-02f, 3.43581513e-02f, 8.46146196e-02f, -4.64161672e-02f, -8.21092129e-02f, 2.50692181e-02f, -8.88772160e-02f, -4.63053584e-02f, -1.62509121e-02f, -2.33623944e-02f,
  -7.95152262e-02f, 2.17518434e-02f, 7.89135322e-02f, -3.35794687e-03f, -3.63411717e-02f, -2.75825895e-02f, -5.28602190e-02f, 8.65043700e-02f, -3.59998904e-02f, 8.18239423e-05f,
  -1.34713203e-01f, -1.02359168e-01f, 1.74611416e-02f, 9.20398757e-02f, 4.07225564e-02f, 8.78502429e-02f, -1.27412956e-02f, -6.08076416e-02f, -5.32873273e-02f, -7.58139044e-02f,
  5.38364388e-02f, -7.67689273e-02f, -5.01574278e-02f, -2.32571810e-02f, -3.29939462e-02f, -3.69024798e-02f, 4.35289592e-02f, -9.16053876e-02f, -1.06372580e-01f, -3.44748199e-02f,
  -5.27262315e-02f, 6.13479912e-02f, -5.07895984e-02f, 1.07761949e-01f, 6.97224811e-02f, 2.12575905e-02f, -5.09571983e-03f, 8.79564360e-02f, 7.83727169e-02f, -4.27894928e-02f,
  3.24092269e-01f, 1.39376268e-01f, -6.30847439e-02f, 2.07281555e-03f, 9.53708813e-02f, 1.44801080e-01f, 2.10128516e-01f, -2.24411990e-02f, -8.20467900e-03f, 1.15064621e-01f,
  6.06726259e-02f, 4.53627519e-02f, 1.20267689e-01f, 3.04077193e-02f, 2.81772107e-01f, 8.84812325e-02f, 1.37013733e-01f, 9.90843326e-02f, -2.13749520e-02f, 1.30178958e-01f,
  -4.30575907e-02f, 2.47600004e-01f, -3.24508883e-02f, -7.64842937e-03f, 1.57582611e-01f, -6.77859262e-02f, -3.89010907e-04f, -5.89860156e-02f, -1.01641536e-01f, 6.35367036e-02f,
  -5.35858385e-02f, 1.10037848e-01f, -9.71606672e-02f, -1.08566925e-01f, 5.25462888e-02f, 5.91797940e-02f, -1.14073593e-03f, 6.30128235e-02f, -4.84698564e-02f, 1.81539021e-02f,
  1.06054537e-01f, 2.66529125e-04f, 4.06513475e-02f, -8.74761790e-02f, 2.64307540e-02f, -2.06624698e-02f, -7.95679539e-02f, -8.70655477e-02f, -5.10471426e-02f, 9.79126152e-03f,
  -7.32578486e-02f, 6.19487725e-02f, -1.46886497e-03f, 2.51794942e-02f, -7.36454409e-03f, 7.24285915e-02f, 8.10018461e-03f, 8.98539498e-02f, 7.59034604e-02f, -1.00248512e-02f,
  1.47741869e-01f, -1.12026595e-02f, 9.58924666e-02f, -8.29030946e-02f, 7.09430501e-02f, -9.35394466e-02f, 6.35568574e-02f, -4.92138714e-02f, -1.39794135e-02f, 8.97066519e-02f,
  -1.79886445e-02f, 6.50621951e-02f, 7.83981872e-04f, 2.95697618e-02f, 1.02660023e-01f, 4.00322303e-02f, -9.39637125e-02f, -3.06983609e-02f, -4.06483412e-02f, 2.35097464e-02f,
  -8.99814293e-02f, 9.18540079e-03f, 2.81631277e-04f, 3.96133959e-02f, -2.61409990e-02f, -2.05219928e-02f, 2.85838847e-03f, 6.26951605e-02f, -6.89203739e-02f, 3.49113829e-02f,
  6.49069175e-02f, 3.39996636e-01f, 2.82157492e-02f, -6.98425844e-02f, -1.28357131e-02f, 9.22083035e-02f, 1.40413186e-02f, 7.64112845e-02f, 1.46403179e-01f, 1.06407791e-01f,
  7.14480802e-02f, -3.25725153e-02f, 5.77660725e-02f, 4.08678502e-02f, -1.03445113e-01f, 4.33764681e-02f, 1.02915488e-01f, -2.83967517e-02f, 5.18925563e-02f, -3.68415974e-02f,
  -3.47418934e-02f, 1.06310351e-02f, 8.29802155e-02f, -5.57260960e-02f, -3.92749943e-02f, -4.35585305e-02f, -1.92616526e-02f, -8.12800378e-02f, -1.39107285e-02f, 4.07214724e-02f,
  2.80763388e-01f, 3.68397444e-01f, 1.86909124e-01f, 2.58722365e-01f, -5.77482283e-02f, 8.39095265e-02f, 3.10245324e-02f, -2.71421652e-02f, 2.55637199e-01f, 5.22690862e-02f,
  -2.05798775e-01f, 2.87889600e-01f, -2.49921102e-02f, 1.32003084e-01f, -1.50926813e-01f, -1.64214537e-01f, 1.06169172e-01f, 1.33327127e-01f, 8.08747411e-02f, 1.84178483e-02f,
  1.25432396e-02f, -2.11170986e-01f, -3.93658057e-02f, -2.20366850e-01f, 1.31723851e-01f, 5.84853142e-02f, -2.22319961e-01f, -1.27581820e-01f, -2.26406455e-02f, -6.64753746e-03f,
  6.95126280e-02f, 6.80270093e-03f, 1.15601435e-01f, 3.72896232e-02f, 7.83080384e-02f, 7.74907833e-03f, 5.05501293e-02f, -1.25860676e-01f, -4.50807698e-02f, -4.25370224e-02f,
  9.01389271e-02f, 4.37149517e-02f, 8.60200077e-02f, -6.03451803e-02f, -1.90168042e-02f, 1.49934031e-02f, 5.26701622e-02f, -2.48558894e-02f, 3.88901755e-02f, 4.63918038e-02f,
  6.34836331e-02f, 1.07232049e-01f, 2.06852891e-02f, 1.59971584e-02f, 4.15491313e-02f, 4.84114476e-02f, -1.59712285e-02f, 1.70247182e-02f, 1.50700063e-01f, 1.07220739e-01f,
  -8.93659964e-02f, -1.67262387e-02f, -4.57956940e-02f, -4.17575501e-02f, 3.07416986e-03f, -7.63357198e-03f, -8.47468060e-03f, -6.05911985e-02f, -5.48844272e-03f, -8.55716839e-02f,
  -2.11495012e-02f, -4.88292985e-02f, -4.76077273e-02f, -2.23721266e-02f, -3.75916846e-02f, 3.27958576e-02f, 4.13411483e-02f, -4.28978428e-02f, 1.05224878e-01f, 2.57647131e-02f,
  -1.95201635e-02f, -2.68801376e-02f, 7.32576475e-02f, 3.02820131e-02f, -3.92361134e-02f, -7.13370815e-02f, 9.59305000e-03f, 4.80336435e-02f, -8.79277103e-03f, 2.00228188e-02f,
  -3.39740366e-02f, -5.54274842e-02f, -9.09775589e-03f, 7.62183219e-03f, 5.99983111e-02f, -5.21973707e-05f, -4.66478616e-02f, 9.43113351e-04f, -9.40910168e-03f, 4.27532829e-02f,
  8.01487118e-02f, 5.58784194e-02f, 4.63827699e-02f, 1.87699385e-02f, 3.62175107e-02f, 5.14660552e-02f, -4.81710657e-02f, -1.99097581e-02f, -8.81545432e-03f, -4.56527136e-02f,
  4.20677103e-02f, 1.61108188e-02f, 2.25772094e-02f, -5.67566976e-02f, -2.22499855e-03f, -1.72274038e-02f, -2.36783009e-02f, 9.77457538e-02f, -3.58465053e-02f, -7.09788129e-02f,
  2.58759111e-01f, 1.18602410e-01f, -1.98939554e-02f, 7.57033154e-02f, -4.39835759e-03f, 4.94497754e-02f, -5.77189513e-02f, 9.01981965e-02f, -3.13413650e-01f, 1.11259297e-01f,
  -6.91632107e-02f, 1.21321805e-01f, -1.44055545e-01f, 7.21473917e-02f, -2.15872929e-01f, -4.13380384e-01f, 1.50400512e-02f, 3.77623066e-02f, -2.07856491e-01f, 2.16352999e-01f,
  6.64696544e-02f, 6.72289655e-02f, -7.51380697e-02f, 1.77632406e-01f, 2.26627350e-01f, 2.06502751e-01f, 2.21374616e-01f, -1.28608989e-02f, 2.71216810e-01f, 5.67681603e-02f,
  -4.05618995e-02f, -1.04174502e-01f, 4.82847765e-02f, -1.01763807e-01f, 1.06578007e-01f, 1.37434408e-01f, 7.55826533e-02f, -1.03016503e-01f, 4.54290817e-03f, 4.40026959e-03f,
  5.80411181e-02f, -1.36286672e-02f, 5.16262464e-02f, -9.58216116e-02f, 4.50626612e-02f, 2.43608542e-02f, 5.14963642e-02f, 7.57642463e-02f, 4.88052443e-02f, 3.16000506e-02f,
  7.52481958e-03f, 8.55486766e-02f, 3.90776396e-02f, 4.62646633e-02f, -8.89891312e-02f, -3.95994596e-02f, -1.71126786e-03f, 9.55697894e-03f, 4.49060649e-02f, 7.07323998e-02f,
  1.35621250e-01f, 3.77634168e-02f, 3.78447142e-03f, -3.71092814e-03f, -3.21905352e-02f, 1.08104507e-02f, -6.89448714e-02f, 2.01279460e-03f, 2.06458457e-02f, 4.52344492e-02f,
  6.13731798e-03f, 2.31284294e-02f, -3.23259383e-02f, 9.45533887e-02f, 4.81487252e-02f, 2.52758581e-02f, 2.40992121e-02f, 9.43074748e-02f, -2.44320817e-02f, -6.19552322e-02f,
  -6.38194010e-02f, -3.76523053e-03f, 2.16492433e-02f, -1.10070333e-02f, -1.32395644e-02f, -9.03642643e-03f, 8.96117985e-02f, 3.02129928e-02f, 2.67886720e-03f, -8.43494106e-03f,
  1.80615000e-02f, 1.82117850e-01f, -1.15172546e-02f, 1.87350102e-02f, -8.65304545e-02f, 2.87816580e-02f, -9.95108858e-02f, -1.91242732e-02f, 4.36974131e-02f, -4.45743725e-02f,
  8.14996585e-02f, -1.16777299e-02f, 8.46044049e-02f, -3.13341357e-02f, 4.97380793e-02f, 5.95894232e-02f, 4.59590741e-02f, -4.31724936e-02f, 3.88701074e-03f, 5.74709065e-02f,
  7.77731836e-02f, 3.84506322e-02f, 5.11249751e-02f, -2.82699913e-02f, 5.06596677e-02f, 2.15332815e-03f, 4.35120054e-02f, 9.34741795e-02f, 8.39394629e-02f, 2.30794977e-02f,
  2.47597173e-01f, 2.80332547e-02f, -3.51072729e-01f, -1.49193823e-01f, -1.26894405e-02f, 1.61382541e-01f, 2.01982304e-01f, 4.85935174e-02f, 1.81046590e-01f, 1.91331968e-01f,
  1.71686292e-01f, 4.97091003e-02f, -2.16204040e-02f, 1.30614132e-01f, 5.63229918e-02f, 3.72338519e-02f, 1.43793628e-01f, 1.13158040e-01f, -6.71738982e-02f, 1.46455109e-01f,
  2.11369190e-02f, 2.62269974e-01f, -2.74187148e-01f, 2.16025319e-02f, -1.43810455e-02f, -6.20381236e-02f, -9.67125371e-02f, -1.11874022e-01f, 6.79992288e-02f, 1.90468542e-02f,
  -9.52417497e-03f, -2.29121861e-03f, -1.11565916e-02f, 7.88121764e-03f, -3.81907932e-02f, -8.18859711e-02f, 6.40857173e-03f, -7.18111545e-02f, -1.23136841e-01f, 4.19346849e-03f,
  1.15430374e-02f, -4.00245562e-02f, 4.31336053e-02f, 5.37286177e-02f, 4.27700281e-02f, -2.36239601e-02f, 1.24807749e-02f, -4.65682819e-02f, -3.17569003e-02f, -7.74280876e-02f,
  -6.57020733e-02f, 1.99935175e-02f, -5.35029592e-03f, -1.54456710e-02f, -1.02288999e-01f, 3.58553566e-02f, 2.23784521e-02f, -3.26126739e-02f, 1.23396747e-01f, 5.65541126e-02f,
  6.67967722e-02f, 4.75915074e-02f, -5.39941806e-03f, -2.60891672e-02f, 3.81070115e-02f, 5.70820179e-03f, -3.47803757e-02f, 5.46949450e-04f, -9.30725411e-03f, -4.00025621e-02f,
  -2.83323452e-02f, -3.80101278e-02f, 9.76261683e-03f, 8.49468857e-02f, 6.66309148e-02f, -6.08331431e-03f, 1.86286084e-02f, 6.96892217e-02f, -9.34383720e-02f, -8.54468495e-02f,
  -6.49129599e-02f, 3.02306353e-03f, 7.77634382e-02f, -8.77122954e-02f, 4.08915319e-02f, -4.34566289e-02f, 4.65865619e-02f, 3.93043645e-02f, -3.02096028e-02f, 6.97440701e-03f,
  6.09343313e-02f, 2.56093800e-01f, -3.27473544e-02f, -6.21176474e-02f, -1.96817387e-02f, 1.80305708e-02f, 8.60440638e-03f, 1.67995843e-03f, 6.77821860e-02f, 3.64628732e-02f,
  8.37139785e-03f, 5.16361035e-02f, 3.37971337e-02f, -4.39759046e-02f, 1.87042281e-02f, 6.57208487e-02f, 7.38488361e-02f, -4.92380117e-04f, 2.84030866e-02f, -7.94092715e-02f,
  7.78881907e-02f, 1.04316898e-01f, 2.54733078e-02f, -5.76105267e-02f, -7.59449899e-02f, 8.26093853e-02f, 1.43320085e-02f, -3.63200679e-02f, -5.30302338e-03f, 2.78047416e-02f,
  1.71583265e-01f, -1.02434523e-01f, 7.32773095e-02f, 2.00640798e-01f, 2.32543916e-01f, 1.10985644e-01f, 1.55711368e-01f, 1.58454180e-01f, 2.70285964e-01f, -4.11542431e-02f,
  -5.18040881e-02f, -4.06230241e-02f, -6.76047355e-02f, 1.20743200e-01f, 1.89994112e-01f, 3.85668129e-02f, 1.07583970e-01f, 1.05598181e-01f, 1.35304332e-01f, 6.97640032e-02f,
  -1.22680115e-02f, -4.55758199e-02f, -9.20221359e-02f, -6.30794466e-02f, -1.40158841e-02f, -1.09208994e-01f, -1.50527388e-01f, -2.59390306e-02f, -5.48912063e-02f, 5.08377627e-02f,
  -7.92932808e-02f, 9.89339948e-02f, -8.95021036e-02f, -6.13291450e-02f, 1.88648086e-02f, 2.13869344e-02f, -2.43770145e-02f, -2.16972139e-02f, 1.01919793e-01f, 8.40868130e-02f,
  -4.23486345e-02f, -3.87957059e-02f, 3.19264233e-02f, 1.21214204e-02f, 5.10380231e-02f, 4.67000380e-02f, 3.06489225e-03f, -9.14609134e-02f, 5.00164106e-02f, -2.04772390e-02f,
  -3.04756016e-02f, 1.90187674e-02f, 1.54330777e-02f, -8.19271728e-02f, -2.16881167e-02f, -1.06732594e-02f, 6.87677935e-02f, -7.22575262e-02f, 6.59751818e-02f, -1.01512969e-02f,
  -2.67843079e-05f, 7.90128112e-02f, -2.31201034e-02f, 4.37336341e-02f, 2.62290938e-03f, -1.18390787e-02f, -4.02610712e-02f, 2.71602143e-02f, 9.33413766e-03f, -3.56707796e-02f,
  6.96142018e-02f, 8.90612137e-03f, -4.32195794e-03f, 5.03678918e-02f, 8.78340080e-02f, -4.25585993e-02f, -9.53552052e-02f, -6.89502433e-02f, -6.65903240e-02f, 7.36307204e-02f,
  -6.46352395e-02f, 5.15033267e-02f, 3.90014686e-02f, 8.95866603e-02f, 6.88994478e-05f, -2.98794042e-02f, -2.83692172e-03f, 5.20410296e-03f, 1.29433572e-02f, -2.51252446e-02f,
  1.07006341e-01f, -3.56507208e-03f, -3.84324826e-02f, -4.72049639e-02f, -5.18287383e-02f, -1.64312143e-02f, 6.86249211e-02f, 2.56987438e-02f, 4.34962697e-02f, 5.89662753e-02f,
  -8.07524249e-02f, -2.36001648e-02f, 9.24274474e-02f, -6.83104247e-02f, -1.56616773e-02f, 4.39204611e-02f, 6.59426376e-02f, 2.40640827e-02f, -8.08915868e-03f, 1.88686885e-02f,
  -3.46271917e-02f, 9.01161209e-02f, 2.68629864e-02f, -4.57869619e-02f, -7.77706504e-02f, 2.32931823e-02f, 6.18498959e-02f, -2.38266252e-02f, -7.78956860e-02f, -4.33434173e-02f,
  2.18111649e-01f, -3.75621766e-02f, -1.27742216e-01f, 6.22821301e-02f, 6.70209974e-02f, 1.79677103e-02f, -6.27448112e-02f, -4.24696468e-02f, -3.18014890e-01f, 4.54773195e-03f,
  2.11216718e-01f, -2.36934237e-03f, -1.28294200e-01f, 2.88534194e-01f, 3.15115869e-01f, -3.97006087e-02f, 2.22351432e-01f, 2.89885402e-02f, 1.79001149e-02f, 6.38755187e-02f,
  1.38161918e-02f, 3.87770206e-01f, -3.22246924e-02f, 1.91089049e-01f, 2.53140837e-01f, -7.14140162e-02f, 1.94715098e-01f, -1.05318427e-01f, 2.23552436e-01f, 1.92938820e-01f,
  9.15927906e-03f, 4.73630615e-02f, 2.50492971e-02f, -5.91136143e-02f, 3.41339149e-02f, 2.04517394e-02f, 5.20255528e-02f, -2.73515005e-02f, -2.34126374e-02f, 4.37274501e-02f,
  -5.98629098e-03f, 3.50138061e-02f, -5.15502654e-02f, 5.75874746e-02f, -2.36181226e-02f, 1.26181142e-02f, 1.98218562e-02f, -5.70023581e-02f, 2.35253814e-04f, 5.49561754e-02f,
  -8.17821249e-02f, -1.97935347e-02f, -6.22465722e-02f, -4.29968089e-02f, 1.73988007e-02f, -3.80799621e-02f, 6.47954410e-03f, 3.70949768e-02f, -3.29957679e-02f, 3.89449969e-02f,
  1.26410723e-01f, 5.05212434e-02f, -8.33296496e-03f, 4.82235029e-02f, 8.98012891e-02f, -2.58201547e-02f, 3.77832130e-02f, -2.51055863e-02f, -4.54407372e-02f, 4.45461795e-02f,
  2.52846302e-03f, 3.40050994e-03f, 7.52811432e-02f, -3.37173268e-02f, 3.17339636e-02f, -6.21132459e-03f, -3.02376766e-02f, -1.15433494e-02f, -2.43914668e-02f, -2.46984214e-02f,
  9.11977049e-03f, -2.06118263e-02f, -1.07699130e-02f, -5.40191382e-02f, -2.81645693e-02f, 5.93011416e-02f, -1.40017420e-02f, -3.10003553e-02f, 3.10956687e-02f, 3.19210999e-02f,
  1.16208699e-02f, 1.38320699e-01f, -1.08247116e-01f, -2.50567943e-02f, -2.34696064e-02f, 1.42101735e-01f, -1.22136064e-02f, -3.99582870e-02f, -4.77301776e-02f, -1.35566005e-02f,
  9.81256962e-02f, -6.49368539e-02f, 5.76861016e-02f, -6.42681271e-02f, -5.62980883e-02f, -2.72046812e-02f, -6.08744379e-03f, -3.34488004e-02f, 8.66409466e-02f, 6.34378791e-02f,
  -2.67099533e-02f, 4.14597765e-02f, 6.87965974e-02f, 2.50298847e-02f, 4.15283628e-02f, 3.97099108e-02f, 8.33437871e-03f, -6.49264008e-02f, -2.39162389e-02f, -4.98273708e-02f,
  1.07218310e-01f, 1.28627494e-01f, -3.25491801e-02f, -1.61542535e-01f, -4.19345684e-03f, -5.83661161e-03f, -7.72060379e-02f, -9.61100459e-02f, -1.38332710e-01f, 1.04286306e-01f,
  -9.90680307e-02f, -7.79317245e-02f, 1.33540988e-01f, -6.78404570e-02f, 3.68725844e-02f, 1.11849144e-01f, -3.42658274e-02f, -3.53544988e-02f, -8.36981088e-03f, 2.25512553e-02f,
  -5.30694351e-02f, -1.18506566e-01f, 3.89964953e-02f, 2.42411476e-02f, -1.02989487e-01f, 8.17705598e-03f, 5.06566912e-02f, -1.53622419e-01f, 2.89497618e-03f, -1.72376186e-02f,
  1.44928038e-01f, 6.92429990e-02f, 4.49214354e-02f, -2.40538474e-02f, -3.35502028e-02f, 2.53477264e-02f, -3.50477397e-02f, -7.19450563e-02f, -6.36714995e-02f, -2.71956623e-02f,
  -9.54353809e-03f, -9.15049538e-02f, 1.93606615e-02f, -8.12966004e-02f, 2.25689095e-02f, 1.73671404e-03f, 7.32247978e-02f, 3.98179935e-03f, 5.38466908e-02f, 2.73435377e-02f,
  8.29337984e-02f, 6.51934072e-02f, -6.07574917e-02f, 5.81124648e-02f, -7.14840144e-02f, 2.61123590e-02f, -7.47269485e-03f, -2.00579260e-02f, 2.56380606e-02f, -7.02367127e-02f,
  -5.26225287e-03f, -4.60684076e-02f, -3.15842107e-02f, 5.61602600e-02f, -7.61408880e-02f, -7.82675669e-02f, 1.40530691e-02f, -6.08744435e-02f, -4.22414392e-02f, 4.65909718e-03f,
  4.62542325e-02f, -3.52665223e-02f, -7.44050965e-02f, 5.82360402e-02f, 1.84484553e-02f, 3.22860628e-02f, -3.92570160e-02f, 7.54355937e-02f, 6.14242703e-02f, 4.47387695e-02f,
  -7.47529864e-02f, -5.40522188e-02f, -4.66650911e-02f, 5.21156713e-02f, -7.09576979e-02f, -3.03554796e-02f, -8.54185671e-02f, 4.92963456e-02f, -1.88445058e-02f, -6.02526553e-02f,
  6.73334152e-02f, -6.30561337e-02f, 1.19998669e-02f, 3.99001688e-02f, -4.41645570e-02f, -6.97061568e-02f, 6.89968839e-02f, 1.72402393e-02f, 1.13383159e-02f, -7.48857157e-03f,
  -7.01451525e-02f, 4.40338664e-02f, 2.23179208e-03f, -1.29602728e-02f, -3.20478603e-02f, 2.81911232e-02f, -2.75283214e-02f, -9.50071812e-02f, -1.31754354e-01f, 4.27663028e-02f,
  -5.17900996e-02f, -9.48320236e-03f, -7.15902597e-02f, -8.66866857e-03f, 3.12382355e-02f, -4.78613144e-03f, 6.27321079e-02f, 5.64481914e-02f, 5.82797900e-02f, -3.83475013e-02f,
  -5.22280335e-01f, 1.97547957e-01f, 1.96297333e-01f, -8.95716771e-02f, -1.45520538e-01f, 1.14354059e-01f, 1.83620080e-01f, -1.24421187e-01f, -2.29774132e-01f, 1.61448687e-01f,
  7.87298977e-02f, -9.23815966e-02f, 2.12966830e-01f, 1.49017796e-01f, -6.14564167e-03f, 1.62178934e-01f, 1.37382835e-01f, 6.51491210e-02f, -8.93773213e-02f, -7.63951316e-02f,
  -7.34007359e-02f, 3.94711755e-02f, 2.69842088e-01f, -2.51863035e-03f, -5.10097742e-02f, -6.48685992e-02f, -4.70020156e-03f, 9.30404812e-02f, 2.00572796e-02f, 4.57815081e-02f,
  -1.78123444e-01f, -2.47705966e-01f, -1.35572582e-01f, -9.56697464e-02f, -7.52697960e-02f, -8.74174610e-02f, 2.85399891e-02f, 3.43924528e-03f, -5.85766807e-02f, -2.56057121e-02f,
  -4.88712899e-02f, -5.85423075e-02f, -1.07695840e-01f, -9.35912281e-02f, -1.39109030e-01f, -3.41511294e-02f, -4.94182371e-02f, 1.55603820e-02f, -2.37509403e-02f, -5.82313761e-02f,
  2.55347579e-04f, 2.85945423e-02f, 5.69246635e-02f, 2.11202279e-02f, -5.33565395e-02f, 7.52466768e-02f, 9.64107960e-02f, 4.83729951e-02f, -7.73050683e-03f, -3.50632519e-02f,
  -4.16964851e-03f, -7.23187402e-02f, 3.79884802e-02f, -7.26276338e-02f, 3.82999815e-02f, -3.32000107e-02f, -4.87525202e-02f, 3.66128944e-02f, -4.44772243e-02f, 5.96140511e-02f,
  -7.47964904e-02f, 4.98074889e-02f, -1.46629345e-02f, 9.39559937e-02f, -4.65732962e-02f, -3.08204070e-02f, 4.14484628e-02f, -5.20571582e-02f, 2.77573839e-02f, 7.05454871e-02f,
  1.12988916e-03f, -7.22474232e-02f, -7.40412902e-03f, 1.01811811e-02f, -4.91126254e-03f, 9.46913473e-03f, -9.38082288e-04f, 5.74248210e-02f, 3.23916855e-03f, 1.11588156e-02f,
  -2.58529842e-01f, -2.74539739e-01f, -4.21005376e-02f, -1.17963903e-01f, 2.81885304e-02f, 2.97778100e-02f, 9.94001888e-03f, -1.95938395e-03f, -2.90438887e-02f, 7.19895447e-03f,
  -6.40795976e-02f, 3.61040793e-02f, -3.69645171e-02f, -6.10350445e-02f, -1.99998710e-02f, -4.32020724e-02f, 2.13287771e-02f, -8.73373896e-02f, -1.19269574e-02f, -4.03387211e-02f,
  -4.42419313e-02f, 4.23786715e-02f, 5.05692959e-02f, 7.45762791e-03f, -6.75958470e-02f, -1.12183159e-02f, -9.18598697e-02f, -9.38184839e-03f, -7.41835609e-02f, -3.41180749e-02f,
  1.41752586e-01f, -2.18000233e-01f, -6.23521917e-02f, 1.24897487e-01f, 6.32482618e-02f, 2.60673482e-02f, -5.91722764e-02f, -1.49581000e-01f, -2.40268745e-02f, -3.79832797e-02f,
  6.31119125e-03f, -1.94515437e-02f, 2.36555636e-02f, 1.06551975e-01f, 9.92952511e-02f, -8.76183137e-02f, 5.19261584e-02f, 5.39432205e-02f, -4.89650369e-02f, -1.03375383e-01f,
  5.26290573e-02f, -1.46505861e-02f, 5.71662374e-02f, -5.45325466e-02f, 6.16645738e-02f, -6.37781322e-02f, 5.24884053e-02f, 2.99635287e-02f, 1.23258866e-01f, -2.74633383e-03f,
  6.01171181e-02f, -1.26215190e-01f, 1.32506024e-02f, 4.51089405e-02f, -4.59045060e-02f, -2.53996942e-02f, 9.30346474e-02f, 1.00367993e-01f, -3.17851864e-02f, 5.41439559e-03f,
  5.77751622e-02f, 6.18267059e-02f, 2.30076499e-02f, 7.23977014e-02f, -7.29647130e-02f, -1.46252727e-02f, -4.23712619e-02f, 1.03817945e-02f, -6.54633902e-03f, -9.51041877e-02f,
  -8.14218819e-02f, -5.14360406e-02f, -6.90912604e-02f, 1.11760665e-02f, 6.76621543e-03f, -1.58608053e-02f, -7.20859766e-02f, 3.81810218e-02f, 1.91543940e-02f, -4.22462588e-03f,
  5.59839197e-02f, 6.69369325e-02f, -2.97693983e-02f, 6.87924773e-02f, -6.51799440e-02f, 4.61888686e-02f, 3.07944119e-02f, 8.29712972e-02f, -2.97947396e-02f, -6.03592470e-02f,
  6.51396485e-03f, -1.02541409e-01f, 7.96981379e-02f, -7.64036775e-02f, -1.89444348e-02f, 2.14082077e-02f, 4.46975455e-02f, -3.14179761e-03f, 1.87448051e-03f, -2.66225487e-02f,
  -3.41862217e-02f, 3.14608589e-02f, 3.09944302e-02f, 7.58872628e-02f, 5.19451313e-02f, 6.25610948e-02f, -7.20828176e-02f, -7.60793611e-02f, -5.91800213e-02f, 2.38671321e-02f,
  -3.92591693e-02f, -2.59681582e-01f, 9.13208444e-03f, -7.91148690e-04f, -8.61439947e-03f, 3.43133919e-02f, 6.10158406e-02f, -3.31339203e-02f, -1.01729177e-01f, -5.62513545e-02f,
  4.14651409e-02f, -2.73236241e-02f, -9.90587100e-02f, 2.90467567e-03f, 4.81571676e-03f, -7.88482949e-02f, -5.03410622e-02f, 1.98306981e-02f, -4.98707704e-02f, -1.13797657e-01f,
  -7.45284930e-02f, -1.02930643e-01f, 2.92166527e-02f, -1.29896738e-02f, -2.43072435e-02f, 2.13097734e-03f, 2.94539556e-02f, 6.55078888e-02f, 2.69119646e-02f, -8.77227038e-02f,
  -7.17223287e-02f, -1.20706864e-01f, 1.08639486e-01f, 2.34793216e-01f, 1.50805444e-01f, 5.99727780e-03f, -9.50253010e-02f, 1.12125248e-01f, -5.86888380e-02f, -3.25385809e-01f,
  -1.54342428e-01f, -8.22366849e-02f, -2.27684096e-01f, 9.50066000e-02f, 2.36258164e-01f, -8.92003067e-03f, 9.60367769e-02f, 7.38104898e-03f, 1.29424915e-01f, 5.34176901e-02f,
  2.53691494e-01f, 2.24628404e-01f, 1.74891785e-01f, 2.27649957e-01f, 1.20908156e-01f, 1.68681592e-01f, 9.11685824e-02f, 5.31483404e-02f, 2.13086754e-01f, 9.42691714e-02f,
  -1.05016083e-01f, 1.33524463e-02f, 5.51424474e-02f, -6.82700053e-02f, -7.74684846e-02f, -1.78910233e-02f, -2.57890113e-02f, 2.14167801e-03f, 1.39282979e-02f, -3.14416029e-02f,
  -8.50337818e-02f, 5.59161901e-02f, 2.54015755e-02f, 1.23353917e-02f, 9.15029738e-03f, 7.81383589e-02f, 6.59483150e-02f, -6.33073002e-02f, 5.83763495e-02f, 4.52842452e-02f,
  -4.00105156e-02f, -1.85576007e-02f, 4.11308222e-02f, 5.98611087e-02f, -7.14755058e-02f, -5.94779924e-02f, 2.78293509e-02f, -8.44355971e-02f, 2.22951751e-02f, -1.76455714e-02f,
  8.51442665e-02f, -2.88806725e-02f, 9.31923091e-03f, -6.24792874e-02f, 8.71968120e-02f, -1.62900258e-02f, 6.85187057e-02f, -6.26584888e-02f, -3.48796658e-02f, 2.26271003e-02f,
  5.27692102e-02f, -7.78265446e-02f, -7.64191337e-03f, 2.32297704e-02f, -3.78412232e-02f, -5.57131916e-02f, 4.38277833e-02f, -1.54584402e-03f, 6.73042834e-02f, 7.06052855e-02f,
  -7.88140297e-02f, 2.30591353e-02f, 1.10173998e-02f, -3.26057263e-02f, 7.43727088e-02f, -9.27453116e-02f, -2.27517318e-02f, -1.29548495e-03f, 1.10509351e-01f, -2.02170433e-03f,
  -9.98923555e-02f, -1.17403967e-02f, 4.34881151e-02f, 1.20273735e-02f, -5.76581135e-02f, -1.24050146e-02f, -2.02848967e-02f, 5.44554591e-02f, -4.04814631e-02f, 5.69342896e-02f,
  -6.18898235e-02f, 8.50995779e-02f, 4.29681083e-03f, -7.85048399e-03f, -3.25050093e-02f, -3.73662710e-02f, 1.57042183e-02f, 4.87449653e-02f, -8.41358006e-02f, -6.41852468e-02f,
  -4.01557684e-02f, 3.48896757e-02f, 9.97621343e-02f, 8.30050632e-02f, 8.43093991e-02f, 9.65477340e-03f, -5.76545065e-03f, 6.10986538e-02f, 6.59334883e-02f, 3.97582687e-02f,
  6.54600635e-02f, -2.49095425e-01f, 1.87316418e-01f, 1.65581658e-01f, 5.74296061e-03f, 1.06178068e-01f, 3.70568573e-01f, -4.68826219e-02f, 1.94664150e-01f, -2.65604258e-01f,
  -9.71894562e-02f, -1.09773554e-01f, 1.24668792e-01f, -6.22026585e-02f, 2.69038260e-01f, 9.43091512e-02f, 4.77730483e-02f, 4.70190682e-02f, 1.25719577e-01f, -9.48509723e-02f,
  3.98227721e-02f, -1.44364625e-01f, 4.87266518e-02f, -3.06699872e-01f, -1.61117941e-01f, -6.66526109e-02f, -1.59910873e-01f, 8.55543986e-02f, -3.14395159e-01f, 8.57612193e-02f,
  5.93847707e-02f, -4.84047756e-02f, -8.61355066e-02f, -1.29129542e-02f, 3.59721147e-02f, -9.90024358e-02f, 1.05502801e-02f, 1.18797384e-01f, 8.59419554e-02f, 3.50592099e-02f,
  4.37715091e-02f, -5.45419231e-02f, -3.33752413e-03f, 1.78912003e-02f, 3.22460979e-02f, -9.79336351e-02f, -2.64555365e-02f, -4.18757536e-02f, 4.29413244e-02f, -8.27540457e-02f,
  5.32722995e-02f, -1.53932553e-02f, 7.20547512e-02f, 4.38256823e-02f, 1.02707386e-01f, -6.09617382e-02f, -1.55132972e-02f, 9.13258195e-02f, -1.01449780e-01f, 8.30051675e-02f,
  -5.18916063e-02f, 6.45425171e-02f, 5.44312336e-02f, 5.50724640e-02f, 9.07484535e-03f, 4.64003757e-02f, -7.23377913e-02f, 5.09401113e-02f, 2.67900433e-02f, 2.45190668e-03f,
  -2.02145837e-02f, 3.77018526e-02f, 9.18234736e-02f, 6.84620067e-02f, -3.62844951e-02f, 7.27016181e-02f, -5.00406437e-02f, 4.43469081e-03f, -3.52579206e-02f, -3.08837090e-02f,
  8.08734223e-02f, -2.38725804e-02f, 1.56188821e-02f, -8.20430834e-03f, 7.81881809e-03f, 3.47951725e-02f, -7.89684579e-02f, -7.34339803e-02f, 2.11622585e-02f, 6.55401424e-02f,
  5.67563586e-02f, -4.23862673e-02f, -1.04585737e-02f, -6.22205250e-02f, -1.99377220e-02f, -4.53163777e-03f, -5.37239248e-04f, -9.66150463e-02f, 1.73245203e-02f, 4.73055951e-02f,
  -1.24698348e-01f, -3.04368082e-02f, -3.71853337e-02f, 5.52637614e-02f, 2.84204613e-02f, -2.42885631e-02f, -6.90713003e-02f, 3.28783272e-03f, -2.76492406e-02f, -9.11770016e-02f,
  -3.83898467e-02f, 2.25794874e-02f, 3.73105407e-02f, -8.71282369e-02f, -3.77363861e-02f, 2.82034371e-02f, -8.03228840e-02f, -3.64844315e-02f, 3.64361554e-02f, 4.14516032e-02f,
  -2.20956262e-02f, -3.73965800e-02f, -1.30604610e-01f, -1.56233981e-01f, 4.79215458e-02f, 1.82824731e-01f, 1.01942353e-01f, 2.52589229e-02f, -2.17303596e-02f, 1.38433993e-01f,
  2.02805296e-01f, -1.48860477e-02f, -1.42137613e-02f, 3.13140526e-02f, -2.06896830e-02f, -1.62608437e-02f, 4.63841558e-02f, 1.42827153e-01f, -8.57390389e-02f, 4.57718521e-02f,
  -4.60229181e-02f, 1.86892018e-01f, -7.12631792e-02f, 4.84330617e-02f, 1.60585895e-01f, -1.01576015e-01f, 1.08192712e-01f, -7.31924325e-02f, 2.16961149e-02f, 1.29159838e-01f,
  -3.66645046e-02f, 5.39931022e-02f, -3.14870989e-03f, -2.32487377e-02f, 5.16808890e-02f, 5.87968007e-02f, -5.44167683e-03f, 5.10327145e-02f, -1.85774677e-02f, -6.50556386e-02f,
  9.40286275e-03f, 4.74464446e-02f, -8.47406983e-02f, -9.67379101e-03f, -2.85995174e-02f, -4.94577922e-04f, -6.72463179e-02f, -2.05448959e-02f, -7.86746442e-02f, -6.06494432e-04f,
  -6.78810999e-02f, -4.64100689e-02f, 4.27225931e-03f, 3.38069089e-02f, 6.12453856e-02f, 2.51439400e-02f, -1.23518430e-01f, 3.52250487e-02f, 5.20750694e-02f, 4.57984470e-02f,
  -1.77546311e-02f, 3.18119377e-02f, 9.22681822e-04f, 2.79172268e-02f, 8.39655474e-02f, -8.76461118e-02f, 3.34116537e-03f, 2.55300775e-02f, -2.54530124e-02f, 5.19601889e-02f,
  -9.00642425e-02f, -8.87456313e-02f, -3.81594636e-02f, 1.81945618e-02f, -3.37299518e-02f, -6.34855479e-02f, 1.84189379e-02f, -6.65657520e-02f, -9.31246653e-02f, -7.16363862e-02f,
  -8.56955126e-02f, -6.25829026e-02f, -3.20084095e-02f, -3.51257436e-02f, 7.72806928e-02f, 5.08045666e-02f, 4.24445942e-02f, -2.98054237e-02f, 5.76379634e-02f, -1.17235342e-02f,
  1.56513359e-02f, 5.11252582e-02f, -1.06227718e-01f, 2.70440839e-02f, 6.40551522e-02f, 1.06526844e-01f, -5.05035557e-02f, 2.81631891e-02f, 1.22409770e-02f, -7.46214166e-02f,
  3.59337479e-02f, 1.07840057e-02f, 3.69176269e-02f, 9.17311460e-02f, 1.12668006e-02f, 6.73694611e-02f, -5.81744872e-02f, 3.53342183e-02f, -4.82825525e-02f, 2.32655741e-02f,
  -1.74287837e-02f, -1.06506166e-03f, 1.93125326e-02f, -1.76298711e-02f, 8.76952559e-02f, -4.26846892e-02f, 5.88507950e-02f, 7.86752999e-02f, -6.20978475e-02f, -1.17119655e-01f,
  1.05557390e-01f, -2.21699029e-01f, 1.88610077e-01f, 1.62858859e-01f, 4.46972288e-02f, 1.79052159e-01f, -3.21878376e-03f, -5.72822280e-02f, -2.28032872e-01f, -2.03298524e-01f,
  -2.99003478e-02f, 1.64392546e-01f, -1.95395678e-01f, 7.87135884e-02f, -9.12334770e-02f, -2.43648574e-01f, -1.10579647e-01f, 9.43895355e-02f, -2.80354246e-02f, 3.75486240e-02f,
  -3.85408215e-02f, -1.51855320e-01f, -5.97360209e-02f, -7.92372525e-02f, 1.74880579e-01f, 1.01284645e-01f, -2.83328556e-02f, 5.26013747e-02f, 1.76221758e-01f, 1.22731350e-01f,
  1.11249294e-02f, -1.29583687e-01f, -6.00697920e-02f, 1.01728052e-01f, -3.20025086e-02f, 4.03132699e-02f, 4.97905537e-02f, 1.89080946e-02f, 2.97383480e-02f, -5.39797097e-02f,
  -5.52404299e-02f, 3.25371698e-02f, 1.99378580e-02f, 2.24248413e-02f, -2.83081811e-02f, 1.13361776e-02f, 4.14523222e-02f, 1.08645990e-01f, 4.03911658e-02f, 1.21771485e-01f,
  6.29360378e-02f, 7.76053667e-02f, -1.48246950e-02f, 6.50907606e-02f, 6.55712932e-02f, -2.52349693e-02f, 1.81180667e-02f, 1.43138161e-02f, 3.90539654e-02f, -8.36096033e-02f,
  -3.34679000e-02f, 4.05334197e-02f, 5.61717674e-02f, -1.12923596e-03f, 2.78162882e-02f, 4.05770503e-02f, 6.03939071e-02f, 4.17931937e-02f, -3.00920312e-03f, -3.52905057e-02f,
  -2.26021092e-02f, 2.65230294e-02f, 4.46699262e-02f, -1.39794629e-02f, 5.62031046e-02f, 4.72661108e-02f, 5.21319285e-02f, 8.12210441e-02f, 1.63629390e-02f, -2.40252633e-02f,
  2.52573323e-02f, -6.96674585e-02f, 5.81823699e-02f, 7.05994889e-02f, 4.18140963e-02f, 7.68707171e-02f, -9.40439552e-02f, 9.79659148e-03f, -9.13967192e-02f, -3.32392715e-02f,
  -1.32904381e-01f, -2.37265125e-01f, -8.60507786e-03f, -4.74623777e-02f, -5.63180298e-02f, -5.47066107e-02f, 2.52020173e-02f, 3.85419391e-02f, -3.37015577e-02f, -1.34670120e-02f,
  9.44942534e-02f, 1.11330889e-01f, 5.88290878e-02f, 1.47637809e-02f, 4.00092788e-02f, -3.61251156e-03f, -4.67598289e-02f, -2.84089763e-02f, -5.02543151e-03f, -1.57948881e-02f,
  -1.36416322e-02f, -1.45628424e-02f, 8.05308372e-02f, -3.17975096e-02f, -3.55940312e-02f, 9.42358598e-02f, 6.81270137e-02f, -1.41257336e-02f, 9.62170213e-03f, -7.57499412e-03f,
  3.39438319e-02f, -7.83525780e-02f, 1.34024739e-01f, 8.69780406e-02f, 2.28316382e-01f, -1.14321128e-01f, -9.58558545e-02f, 2.53985047e-01f, 2.27010205e-01f, -1.03937633e-01f,
  -2.22031469e-03f, -2.34346598e-01f, -6.36606365e-02f, -1.80336498e-02f, -1.59971654e-01f, -6.74482584e-02f, -4.27297540e-02f, -2.01206326e-01f, 8.55693500e-03f, -5.11564426e-02f,
  -6.11383468e-03f, -1.43042326e-01f, -9.22817588e-02f, -4.94213104e-02f, -4.71665934e-02f, -1.05395028e-02f, -5.77282235e-02f, 2.17799172e-02f, -1.45844817e-01f, -4.02219892e-02f,
  -3.73134650e-02f, 1.47830188e-01f, 9.28529352e-02f, -9.88447294e-03f, -6.31780177e-02f, 4.48554419e-02f, -6.42109364e-02f, 5.19201681e-02f, 4.35927957e-02f, -2.21775752e-02f,
  -9.23530310e-02f, 6.55480176e-02f, 9.18442085e-02f, 9.71590877e-02f, 1.54322416e-01f, 9.60994605e-03f, -2.75131669e-02f, -4.45667468e-02f, -1.83826294e-02f, -4.30731475e-03f,
  4.32726275e-03f, -2.12700386e-02f, 1.70012214e-03f, 2.18433160e-02f, 6.37011928e-03f, 1.08250819e-01f, -5.78361079e-02f, -5.69567829e-02f, -3.80472206e-02f, 8.32916275e-02f,
  9.19365659e-02f, -8.82797912e-02f, -9.67906266e-02f, -2.33785827e-02f, -8.08465034e-02f, -1.75179765e-02f, -8.75921324e-02f, 1.93778463e-02f, 1.21033913e-03f, -3.11535355e-02f,
  4.77143936e-02f, 3.72589827e-02f, 3.41285691e-02f, 1.93829983e-02f, -7.85339624e-02f, 5.39320149e-02f, -8.89353454e-02f, 7.28030726e-02f, 8.67949352e-02f, -6.65002540e-02f,
  5.23466393e-02f, 4.53767702e-02f, -3.14793363e-02f, 4.71327007e-02f, 2.53479425e-02f, 5.64650409e-02f, 8.52710307e-02f, 2.20578164e-02f, 3.92255522e-02f, -5.29362261e-03f,
  -1.68822870e-01f, -2.02448130e-01f, 3.90359089e-02f, 4.48751859e-02f, -8.26860890e-02f, 1.64550710e-02f, -1.00237638e-01f, -1.90692917e-02f, 1.91586744e-02f, 2.10466310e-02f,
  4.93524149e-02f, -7.16255978e-02f, -6.60014153e-02f, 4.56112847e-02f, -7.75448382e-02f, 6.10640012e-02f, -7.92231634e-02f, -1.76940970e-02f, -7.18540624e-02f, -7.73461536e-02f,
  -1.13256797e-01f, -6.60555661e-02f, -4.86271866e-02f, -3.27136815e-02f, -2.94854329e-03f, -3.06763239e-02f, -4.83070090e-02f, -2.31150165e-02f, -1.10487774e-01f, -2.08572168e-02f,
  -1.15369119e-01f, 1.36175573e-01f, 9.40962061e-02f, 2.11810648e-01f, -1.45620808e-01f, -9.42839980e-02f, -5.72568849e-02f, 1.79432016e-02f, 2.45847423e-02f, 1.87021494e-01f,
  5.23205027e-02f, 8.81654993e-02f, 2.68426090e-02f, 2.33000785e-01f, -7.49226660e-02f, 7.38331005e-02f, 8.31852257e-02f, 2.70224400e-02f, 3.64175513e-02f, -3.45021337e-02f,
  1.85658280e-02f, 1.20610945e-01f, 2.16631085e-01f, 1.51207019e-03f, -7.67781287e-02f, 6.61593005e-02f, 7.40891993e-02f, -9.22972709e-02f, 6.34140745e-02f, -1.41060621e-01f,
  -9.41732824e-02f, 5.46938479e-02f, 6.70402125e-02f, -9.55235288e-02f, -8.56923983e-02f, -7.22101554e-02f, 4.04629856e-02f, 4.51701283e-02f, -5.00789322e-02f, 7.41172284e-02f,
  3.24718580e-02f, -7.68336281e-02f, 4.42952067e-02f, 3.48771214e-02f, -5.85288508e-03f, -4.81503792e-02f, -1.60673242e-02f, -8.78278837e-02f, 4.17830087e-02f, -1.71156172e-02f,
  1.01246692e-01f, -3.42781805e-02f, 5.32434769e-02f, -4.05810215e-02f, 1.37913171e-02f, -3.71637568e-02f, -2.48959903e-02f, -1.81888696e-02f, -7.19038323e-02f, -2.59529185e-02f,
  -1.03199735e-01f, 7.46903494e-02f, -5.80520108e-02f, -4.52894717e-02f, -5.75993620e-02f, 6.31413832e-02f, -1.46506652e-02f, 5.20494357e-02f, 5.16977161e-02f, 4.81549427e-02f,
  8.54646713e-02f, -3.41470763e-02f, 5.11766858e-02f, -5.05217686e-02f, 3.67339514e-02f, 7.82648940e-03f, -4.34752740e-02f, -7.90997148e-02f, -3.21832635e-02f, -3.25352289e-02f,
  -5.97610846e-02f, -2.24703383e-02f, 3.22050340e-02f, 1.98002718e-02f, -3.65776531e-02f, 2.77960859e-02f, 6.67901114e-02f, -2.19621770e-02f, -6.66862801e-02f, -3.32588628e-02f,
  4.53586653e-02f, 1.41592667e-01f, 2.30741706e-02f, -5.22287153e-02f, 7.38953752e-03f, -1.87068451e-02f, -1.13927722e-02f, 2.21674889e-03f, 3.28342430e-02f, -7.70140216e-02f,
  -6.74330369e-02f, -6.40968978e-02f, 5.23443371e-02f, 7.68760666e-02f, -1.46532506e-02f, -2.14274675e-02f, 5.75581044e-02f, 8.07188079e-02f, -2.95353141e-02f, -7.51857683e-02f,
  2.23449920e-03f, -2.32409406e-03f, -3.62648316e-05f, -9.21758860e-02f, -2.97835264e-02f, 5.79547808e-02f, 1.06575433e-02f, 1.76276583e-02f, 5.16608246e-02f, 9.08909515e-02f,
  -4.63454276e-02f, 5.22564119e-03f, 5.26750810e-04f, -1.26216218e-01f, 7.06535205e-02f, 1.19927786e-01f, -1.15215018e-01f, 6.32175878e-02f, -3.98419872e-02f, -6.80012628e-02f,
  -1.14632227e-01f, -5.17954826e-02f, -8.21661055e-02f, -1.05792828e-01f, 1.11022078e-01f, 1.06651559e-01f, -9.50558558e-02f, -1.20748632e-01f, 5.17949983e-02f, -5.98334260e-02f,
  -6.53686374e-02f, -7.87983164e-02f, 8.29840451e-02f, -2.98390109e-02f, -1.05013415e-01f, -5.93715869e-02f, -4.33483571e-02f, -5.48578575e-02f, 4.80692908e-02f, 6.10797368e-02f,
  6.48469701e-02f, -1.04973391e-02f, 1.03009783e-01f, 2.80683860e-02f, 3.86883095e-02f, 5.88983251e-03f, 3.78917195e-02f, -5.35594150e-02f, 3.82237919e-02f, -5.73767945e-02f,
  -2.09567510e-02f, 4.44316715e-02f, 4.81046140e-02f, -4.93141636e-03f, 2.06960347e-02f, -4.46258858e-02f, 1.08107561e-02f, -3.70203592e-02f, -3.09743006e-02f, 4.07252163e-02f,
  -6.99043795e-02f, 1.83670297e-02f, 5.86880669e-02f, 1.88707393e-02f, -1.62824169e-02f, 6.10449016e-02f, 8.91104266e-02f, -4.44978103e-02f, -3.66483405e-02f, 8.86084065e-02f,
  -9.26746242e-03f, -3.16981040e-02f, -7.91944936e-03f, -1.02087922e-01f, 2.91368235e-02f, -8.19741096e-03f, 6.89716637e-02f, 1.35044325e-02f, 4.36304919e-02f, -8.19057077e-02f,
  -1.66918375e-02f, 5.75664975e-02f, -3.36885415e-02f, -9.02479589e-02f, 2.75090744e-04f, 2.88555212e-03f, 1.03901319e-01f, -5.95203862e-02f, -7.41469264e-02f, -3.04242261e-02f,
  -1.37994677e-01f, 2.31031682e-02f, 2.26560831e-02f, -8.49712938e-02f, 2.76195537e-02f, 1.54801980e-02f, -1.37154339e-02f, 8.96124169e-02f, -5.39045744e-02f, -6.20327331e-02f,
  8.76218826e-02f, -4.25828770e-02f, -6.39901087e-02f, -1.09740131e-01f, 2.19387766e-02f, 4.50427644e-02f, 1.19867478e-03f, -2.24931948e-02f, -3.12307067e-02f, -3.22486199e-02f,
  6.63949251e-02f, -7.66398013e-02f, 3.85057181e-02f, 6.70143664e-02f, -6.35027140e-03f, -3.31472009e-02f, -9.31535289e-02f, -8.33397731e-02f, 5.99200390e-02f, 8.29893649e-02f,
  2.56636664e-02f, 7.14626461e-02f, -6.28145635e-02f, 3.06611378e-02f, 6.31510839e-02f, 5.14292978e-02f, 4.47412543e-02f, -2.42125466e-02f, -5.04156500e-02f, -1.74241755e-02f,
  -3.23358215e-02f, -3.95935550e-02f, 1.89558208e-01f, 1.22496821e-01f, -4.19162363e-02f, -9.33639035e-02f, 1.15614213e-01f, 5.80844283e-02f, -4.75113513e-03f, -2.95385942e-02f,
  -2.81476863e-02f, -1.10659629e-01f, 1.41793592e-02f, -8.24761465e-02f, 1.06771976e-01f, 1.19055565e-02f, 3.96536961e-02f, 2.18848176e-02f, 7.34950155e-02f, 1.62441447e-01f,
  3.52632217e-02f, -3.44007239e-02f, 1.46434039e-01f, 6.85612485e-03f, -1.01573884e-01f, 1.36894986e-01f, 1.77042320e-01f, 1.52930155e-01f, 1.04043722e-01f, -6.38505071e-02f,
  2.81282067e-02f, -5.10865636e-02f, -6.36224151e-02f, -1.24216629e-02f, 1.17740206e-01f, -8.12965725e-03f, 6.92563802e-02f, 3.37487832e-02f, -2.21615192e-02f, 4.56166044e-02f,
  9.90765169e-03f, 6.81731701e-02f, -4.97392891e-03f, 3.49060297e-02f, 1.75934602e-02f, 1.70159731e-02f, -2.04714835e-02f, 2.63241604e-02f, 3.38188075e-02f, 2.64527313e-02f,
  7.15138912e-02f, -5.17080463e-02f, -3.84921581e-02f, -3.10957655e-02f, 2.18758807e-02f, 2.27301344e-02f, 1.46766752e-02f, -3.59788798e-02f, 4.42460589e-02f, -4.64270785e-02f,
  -1.12040505e-01f, 8.19259360e-02f, -2.02332120e-02f, 7.17304796e-02f, -7.66452998e-02f, 5.93451783e-02f, 2.92398389e-02f, -5.39748780e-02f, 2.89000589e-02f, -4.28718030e-02f,
  -1.92578640e-02f, 4.21165191e-02f, 6.27366006e-02f, -4.33630757e-02f, -3.48433107e-02f, -1.14420712e-01f, -2.29689647e-02f, 3.34615707e-02f, -3.69521673e-03f, 4.56043407e-02f,
  -1.83486044e-02f, 3.16618606e-02f, -7.77838007e-02f, 1.10869808e-02f, -5.84659278e-02f, -2.70906948e-02f, -5.30958250e-02f, -6.24153428e-02f, 9.80652217e-03f, 5.14009520e-02f,
  1.70967933e-02f, 1.81074589e-01f, -6.17262982e-02f, -2.28715613e-02f, -5.81620634e-02f, -7.24989325e-02f, 1.75558459e-02f, -4.05508168e-02f, 1.46609753e-01f, 2.66978983e-02f,
  3.95555906e-02f, -4.24107630e-03f, -8.01661238e-03f, -7.63977170e-02f, 7.81932175e-02f, 1.16401508e-01f, 8.42010379e-02f, 9.60999429e-02f, 5.52880205e-02f, 8.66831467e-02f,
  5.02858311e-02f, 3.68947499e-02f, -5.01461700e-02f, -8.64487961e-02f, 8.54380312e-04f, -3.22533436e-02f, 4.33538435e-03f, 9.57651660e-02f, -7.77466446e-02f, -3.03062294e-02f,
  1.91761389e-01f, -2.78933495e-01f, -4.64355461e-02f, 3.07517111e-01f, 3.12929899e-01f, 2.82912590e-02f, 6.58917427e-02f, 1.23519175e-01f, 2.09707454e-01f, -2.19962358e-01f,
  -3.88064086e-02f, -2.17447042e-01f, -3.69954050e-01f, -7.46344700e-02f, -1.71330180e-02f, -4.51606035e-01f, 3.87972631e-02f, -1.31607011e-01f, -4.85592936e-05f, 1.38427494e-02f,
  7.71616846e-02f, 1.00384727e-01f, -3.95110324e-02f, 1.12619109e-01f, 9.56821218e-02f, 2.41209358e-01f, 7.08155632e-02f, -7.18821660e-02f, 4.50646691e-02f, -2.74626585e-03f,
  -1.92209054e-02f, 2.74046138e-02f, 3.18624787e-02f, 2.34539304e-02f, 8.52374882e-02f, 3.57444473e-02f, -4.32336368e-02f, -1.48133501e-01f, 1.15888566e-01f, 7.13809021e-03f,
  5.95308316e-04f, -3.13115157e-02f, 6.69099204e-03f, -8.05975720e-02f, 8.40148032e-02f, 8.46315548e-02f, 7.86125958e-02f, -3.41734514e-02f, -6.19618855e-02f, -8.19693580e-02f,
  -2.97711361e-02f, 4.27682064e-02f, 1.58208162e-01f, -2.63296012e-02f, 4.95781526e-02f, -1.47845624e-02f, 3.85083258e-02f, -1.95680074e-02f, -4.68569575e-03f, 1.40158549e-01f,
  -6.66987523e-02f, 7.11206421e-02f, 1.63929630e-02f, -1.02286339e-02f, 3.92388552e-02f, 1.66692343e-02f, -5.96402362e-02f, -2.58384850e-02f, 1.13810664e-02f, -3.13471109e-02f,
  -1.94200017e-02f, 8.78441110e-02f, -3.98727991e-02f, -5.70256403e-03f, 7.57657215e-02f, 3.64466421e-02f, -5.80985025e-02f, -6.40611127e-02f, 3.42513211e-02f, 2.51725540e-02f,
  -4.78043966e-02f, 3.17912512e-02f, -6.90198690e-02f, 4.48730327e-02f, 5.29328687e-03f, -6.07971065e-02f, -7.33555257e-02f, -2.11330634e-02f, 6.39152452e-02f, 4.92156111e-02f,
  -7.77635304e-03f, -2.24777132e-01f, -5.84625965e-03f, -1.96105782e-02f, -1.51461670e-02f, -6.48370236e-02f, -7.86668435e-02f, 3.27066593e-02f, -6.29589930e-02f, -9.86789241e-02f,
  5.66843227e-02f, 5.26825525e-02f, 2.43320838e-02f, -3.30355428e-02f, -2.15068157e-03f, -5.46460152e-02f, -9.86414999e-02f, -3.90707701e-02f, 4.50990647e-02f, -6.54497296e-02f,
  8.09940323e-02f, -6.23564869e-02f, 2.31587142e-02f, 9.18216184e-02f, 1.81607921e-02f, -1.81443393e-02f, 4.31115180e-02f, 4.84469458e-02f, -4.64691743e-02f, -1.11187309e-01f,
  3.49802487e-02f, -2.22710907e-01f, -2.77413785e-01f, -2.76441634e-01f, 9.20785442e-02f, -7.71316960e-02f, -2.96609551e-01f, -1.52248263e-01f, -5.82679957e-02f, -2.58252155e-02f,
  -1.37208149e-01f, -8.35403204e-02f, -3.65485027e-02f, -4.14793521e-01f, -5.06863594e-02f, -1.46366106e-02f, -3.07432353e-01f, -1.50144979e-01f, -1.06587037e-01f, -2.20182016e-01f,
  -5.89050017e-02f, -1.45719230e-01f, -2.41048366e-01f, -1.21742234e-01f, -1.47353753e-01f, -3.32792923e-02f, 2.55017072e-01f, 4.18371856e-02f, -5.45228384e-02f, -1.35046124e-01f,
  -1.27468228e-01f, -1.52237669e-01f, -1.50981843e-01f, -6.76403791e-02f, 3.92122827e-02f, 7.98748359e-02f, 3.86331230e-02f, -9.20778960e-02f, -2.30117720e-02f, 7.63595197e-03f,
  -3.89127468e-04f, 6.33963346e-02f, -9.15283337e-02f, 1.42210331e-02f, -3.45320627e-02f, -1.07211217e-01f, -2.59886030e-02f, 9.64207575e-03f, -2.82140989e-02f, -5.44644818e-02f,
  -1.09356791e-01f, 4.14000601e-02f, 9.04083699e-02f, -3.23534384e-02f, 2.22453792e-02f, 2.25993544e-02f, -4.31604236e-02f, 4.01452966e-02f, 8.48648176e-02f, -1.39116198e-02f,
  1.56355277e-02f, 1.14816032e-01f, -1.94871239e-02f, -4.90789395e-03f, -5.48466928e-02f, -1.09465681e-02f, -1.00015113e-02f, 6.28497750e-02f, -3.26155163e-02f, 5.30765799e-04f,
  -3.22281872e-03f, -4.14027693e-03f, 9.42343194e-03f, -3.33566479e-02f, -2.98354030e-02f, -5.04512414e-02f, 9.05864034e-03f, 1.95606388e-02f, 3.27862836e-02f, -2.84679588e-02f,
  -6.45250008e-02f, -3.20438966e-02f, -3.98843996e-02f, 6.33854270e-02f, -8.51200595e-02f, 1.63903423e-02f, -2.82507949e-03f, 3.42913978e-02f, 4.12934273e-02f, -4.70828824e-02f,
  3.22947688e-02f, 5.45705706e-02f, -1.91699434e-02f, -3.26006785e-02f, -1.76961981e-02f, 7.68396258e-02f, -1.05892252e-02f, -1.50281209e-02f, 1.89021602e-02f, 3.63470428e-02f,
  3.85702029e-02f, 2.19987682e-03f, 1.16992839e-01f, 4.18181531e-02f, 4.77753468e-02f, -6.11353666e-02f, -1.14773884e-02f, 9.32569504e-02f, -3.15037393e-03f, 1.74777601e-02f,
  -1.56477615e-02f, 6.03418332e-03f, 1.80523433e-02f, -2.44483557e-02f, -4.93887812e-03f, 9.07650217e-02f, 6.11427203e-02f, -1.98637582e-02f, 2.28484231e-03f, 3.76249999e-02f,
  2.19066571e-02f, -2.17301056e-01f, 1.75511926e-01f, 1.02235898e-01f, 5.69151528e-02f, 1.31817803e-01f, 2.40065247e-01f, -1.75138801e-01f, 1.30141084e-03f, -7.96626434e-02f,
  -1.50714263e-01f, -6.80073025e-03f, 3.57361697e-02f, 1.14919078e-02f, 2.59986669e-01f, 5.82492389e-02f, 8.75769183e-02f, 1.74759164e-01f, 2.13166308e-02f, 2.59659123e-02f,
  3.83331105e-02f, -3.57285962e-02f, 1.61327031e-02f, -2.50184059e-01f, -9.16252509e-02f, -1.70816690e-01f, -2.24872455e-02f, 3.77365835e-02f, -5.47496649e-03f, 1.40407413e-01f,
  -8.97021890e-02f, -8.21451023e-02f, 5.16737513e-02f, -3.59263718e-02f, -1.10620067e-01f, -6.82454035e-02f, 8.52814913e-02f, 1.19796537e-01f, 2.72378456e-02f, -6.36947006e-02f,
  -4.76281084e-02f, 5.03037795e-02f, -3.07704341e-02f, -2.74032708e-02f, -2.27316935e-02f, -2.44271173e-03f, -5.03728949e-02f, -1.26206651e-01f, 3.03082969e-02f, -6.46609887e-02f,
  5.17031997e-02f, 5.18451743e-02f, 1.14214551e-02f, -2.15878915e-02f, 8.29607695e-02f, 4.64874916e-02f, 8.70418921e-02f, -3.99812125e-02f, 1.84097863e-03f, -5.15257828e-02f,
  -4.04975228e-02f, 8.19825456e-02f, -7.86679890e-03f, -8.49182438e-03f, 8.71306285e-02f, -5.28172441e-02f, -6.19962066e-02f, -1.43143088e-02f, 2.48354347e-03f, -5.47467135e-02f,
  -1.39782056e-02f, -1.25212800e-02f, -2.54020952e-02f, -1.01986630e-02f, 2.85840202e-02f, -5.15026301e-02f, 3.06552015e-02f, 3.75524983e-02f, 5.11813760e-02f, -7.99625218e-02f,
  3.99414934e-02f, -2.85840966e-02f, -1.83832236e-02f, 7.00257136e-04f, 6.69274852e-02f, -6.45367056e-02f, -6.22983463e-02f, 6.80974722e-02f, 7.75440037e-02f, -3.16694602e-02f,
  -2.76800729e-02f, -9.61688831e-02f, 5.02975099e-02f, -5.13226949e-02f, -7.67603815e-02f, -9.77814123e-02f, 8.58629197e-02f, -2.60579828e-02f, 7.59364069e-02f, -3.98216993e-02f,
  2.46999394e-02f, 4.10388671e-02f, -3.69660556e-02f, -5.53501584e-02f, -3.58806178e-02f, -8.96831527e-02f, 7.23965988e-02f, -3.72328684e-02f, 5.00875451e-02f, 2.76584364e-03f,
  6.81612967e-03f, -2.71682981e-02f, -5.14694266e-02f, -3.00330613e-02f, 4.07687649e-02f, 5.59072420e-02f, 2.81335823e-02f, -5.72722144e-02f, 1.88461896e-02f, -8.28811824e-02f,
  -5.51368237e-01f, 4.53392774e-01f, -2.16051087e-01f, -6.30715787e-02f, -6.87894672e-02f, 1.21411867e-01f, 2.30335444e-01f, 1.69314504e-01f, 3.66721183e-01f, 3.69088918e-01f,
  1.49896070e-01f, 2.18612291e-02f, 3.25643539e-01f, 1.74269229e-01f, -1.66468278e-01f, 3.44351828e-01f, 7.00449497e-02f, 1.53874665e-01f, 1.44762635e-01f, -3.28337885e-02f,
  -2.24170268e-01f, 1.08655423e-01f, -2.38986447e-01f, 7.20259249e-02f, -1.91218004e-01f, -2.44699165e-01f, -1.46761641e-01f, 5.61197996e-02f, -1.73162237e-01f, 6.54487312e-02f,
  -1.11000314e-01f, 2.24764068e-02f, -1.92803666e-01f, -8.91338363e-02f, -1.47852004e-01f, -3.06793470e-02f, -3.40584405e-02f, -8.63366500e-02f, 1.58499125e-02f, 6.95318505e-02f,
  -3.66219506e-02f, 2.04085205e-02f, 1.69236632e-03f, -2.88481708e-03f, -1.77989379e-02f, -1.45735331e-02f, -5.17811477e-02f, -3.37968883e-03f, -1.39271235e-02f, -2.31007282e-02f,
  -1.16862744e-01f, -1.91107094e-02f, -3.43325399e-02f, 1.31986411e-02f, -7.27996603e-02f, 2.13129967e-02f, 3.48302498e-02f, -1.01889625e-01f, -3.96714732e-02f, 6.16009682e-02f,
  9.04729515e-02f, 6.27362132e-02f, -8.40814039e-03f, 6.62134141e-02f, -4.15014327e-02f, 2.53788894e-03f, -2.68303491e-02f, -9.55667719e-03f, 7.03744441e-02f, 6.09116023e-03f,
  -4.34010290e-02f, -2.50829495e-02f, -1.47489943e-02f, -4.28258330e-02f, 3.31529863e-02f, 2.06827130e-02f, -3.15029249e-02f, -1.74030918e-03f, 1.23285996e-02f, -1.03728503e-01f,
  1.25951618e-01f, -1.87653061e-02f, -8.63304175e-03f, -5.62999994e-02f, 2.68427972e-02f, 1.89775303e-02f, -6.79627061e-02f, -5.72473183e-02f, -2.48605125e-02f, -6.93052933e-02f,
  6.55696914e-02f, 1.00335576e-01f, 4.27269600e-02f, 2.60127243e-02f, -4.53713723e-03f, -4.73313294e-02f, 1.19634243e-02f, -3.53186019e-02f, 3.89660858e-02f, 4.14219238e-02f,
  -1.15575820e-01f, -8.31145421e-02f, -4.67317961e-02f, 8.28670785e-02f, 7.70856962e-02f, 2.06259992e-02f, -4.44088094e-02f, -1.97633225e-02f, -1.53155066e-02f, 8.13339651e-03f,
  -8.87250379e-02f, 5.24166506e-03f, 8.81029351e-04f, 9.24749649e-04f, 4.40251678e-02f, -3.87637131e-02f, -2.74149459e-02f, 1.02747884e-02f, -5.67236915e-03f, 2.65328847e-02f,
  -8.40341151e-02f, 1.07990764e-01f, 3.07607036e-02f, 2.61137784e-01f, -9.56064314e-02f, -3.42913061e-01f, -3.33132088e-01f, -1.02248482e-01f, -5.95621299e-03f, -1.17975928e-01f,
  -1.94217443e-01f, 1.94148362e-01f, -2.60448694e-01f, 1.15106583e-01f, 2.12749913e-01f, 2.66970508e-02f, 5.04547358e-02f, -7.35562444e-02f, 1.16180256e-01f, 1.12919942e-01f,
  9.40332711e-02f, 4.39057872e-02f, 2.41440251e-01f, 1.19143933e-01f, 4.17719483e-02f, 1.58724159e-01f, 1.16714053e-01f, 7.37559125e-02f, 1.28149167e-01f, 6.52045161e-02f,
  4.22035605e-02f, 1.73192084e-01f, -7.18760013e-04f, 9.55469012e-02f, -7.20953941e-03f, -7.62087479e-02f, -8.59481692e-02f, 2.63707843e-02f, 2.03464273e-02f, 2.93280650e-02f,
  8.58484861e-03f, 5.71170859e-02f, -1.33928622e-03f, 3.16381864e-02f, -9.03196856e-02f, 1.32202044e-01f, 8.86472985e-02f, -7.18746483e-02f, 6.44377898e-03f, -4.67169657e-02f,
  -1.95717532e-02f, -4.20234166e-02f, -7.31496885e-02f, 7.96262175e-02f, 1.08977482e-01f, 2.20702663e-02f, 4.59410883e-02f, -8.39157775e-03f, 7.90952072e-02f, 6.61475360e-02f,
  -3.49088907e-02f, -1.11288026e-01f, -2.85184383e-02f, -5.13428599e-02f, -6.21118546e-02f, -2.92806607e-02f, -4.28777300e-02f, -5.29915169e-02f, -4.15198691e-02f, -6.34668022e-02f,
  -5.65344095e-02f, -7.01379925e-02f, 3.04055959e-02f, 1.33613264e-02f, -7.84074292e-02f, -4.15757851e-04f, 3.31446505e-03f, 3.33998799e-02f, -4.24392559e-02f, 3.22143883e-02f,
  1.89502090e-02f, -3.75522636e-02f, -3.15514132e-02f, -3.41411270e-02f, -5.95212169e-02f, -2.37864302e-03f, -4.43227328e-02f, -2.19203606e-02f, -6.55618235e-02f, -3.21433656e-02f,
  5.68840578e-02f, 2.21980438e-01f, 1.41471010e-02f, -1.29067786e-02f, 1.00632675e-03f, -6.38960823e-02f, 4.54144739e-02f, -1.51779521e-02f, 1.48377836e-01f, -6.20012395e-02f,
  -5.64858951e-02f, -3.10337003e-02f, 1.02875698e-02f, -3.73288766e-02f, 1.92521513e-02f, -6.27812371e-02f, -2.90977699e-03f, 4.13663350e-02f, 1.00983471e-01f, 1.00759767e-01f,
  -4.99784527e-03f, -8.34256262e-02f, 1.54276649e-02f, 8.32197536e-03f, 1.78438518e-02f, -8.11471511e-03f, 1.55620398e-02f, 1.92199217e-03f, 3.32392678e-02f, 8.68488252e-02f,
  -2.79107273e-01f, 2.64788922e-02f, -1.80310696e-01f, 1.50741097e-02f, 4.16761860e-02f, -2.27060035e-01f, -9.06806365e-02f, 6.96275830e-02f, -7.16443434e-02f, 2.66104072e-01f,
  1.37068450e-01f, -1.49951011e-01f, 3.10884174e-02f, -2.25739211e-01f, -3.52593988e-01f, -2.15248778e-01f, -2.55463898e-01f, -2.35761568e-01f, -1.22931600e-01f, 5.36235496e-02f,
  -4.76415381e-02f, 1.81815431e-01f, -1.75909489e-01f, 2.80370921e-01f, 6.58504888e-02f, 9.39891338e-02f, 2.26326272e-01f, 1.66529641e-01f, -3.40761803e-02f, 2.91139148e-02f,
  -1.69428647e-01f, 1.21676095e-01f, -6.23155013e-03f, 2.20044516e-02f, -8.39142725e-02f, -3.00034899e-02f, 5.46325780e-02f, -5.79968281e-03f, -4.79863621e-02f, -9.42913219e-02f,
  9.76306107e-03f, 6.66721016e-02f, -4.29652780e-02f, 2.21734252e-02f, 9.50003341e-02f, -3.81908678e-02f, 3.73798199e-02f, -6.61327988e-02f, 6.18576147e-02f, -5.39475493e-02f,
  -9.75523666e-02f, -8.59131888e-02f, 3.77573655e-03f, 6.13606200e-02f, -8.24422985e-02f, 9.54250526e-03f, -5.75598255e-02f, 1.06604456e-03f, -7.79515430e-02f, -7.46945739e-02f,
  7.10223839e-02f, -4.43291031e-02f, -3.50932893e-03f, 2.75779190e-03f, -6.48248270e-02f, 4.98982146e-02f, 6.37180805e-02f, -4.35149409e-02f, -4.68731225e-02f, -3.11910491e-02f,
  3.95462997e-02f, 3.76922004e-02f, 2.93531679e-02f, -3.51122767e-02f, 1.98280934e-04f, 2.64414623e-02f, 3.45511399e-02f, -2.94963568e-02f, -7.25752627e-03f, -3.63887474e-02f,
  -6.72613364e-03f, 7.40181189e-03f, 6.28535151e-02f, 4.90792990e-02f, -7.05250800e-02f, 1.07806146e-01f, 1.99070405e-02f, -8.80272463e-02f, -4.33677770e-02f, -8.17611627e-03f,
  6.01243712e-02f, 3.22431952e-01f, 2.40604598e-02f, -2.86067724e-02f, 1.28160901e-02f, 4.04242575e-02f, -4.59387712e-02f, -2.87719630e-02f, 2.75230724e-02f, 3.26584578e-02f,
  1.30709540e-02f, 2.77784131e-02f, 1.21964123e-02f, 7.40248784e-02f, 4.72750107e-04f, -2.71033961e-03f, 1.22684300e-01f, 1.41296210e-02f, 3.15701775e-02f, -1.81725137e-02f,
  1.03534803e-01f, 4.62471619e-02f, 3.35244425e-02f, 6.03591464e-02f, 1.39271570e-02f, 6.62574917e-02f, 4.31595407e-02f, 1.10686729e-02f, 6.14550635e-02f, -5.37501983e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.30202919e-01f, 2.02191114e-01f, 9.84683782e-02f, 2.14826226e-01f, 1.08488508e-01f, 1.64825708e-01f, 1.13742322e-01f, 7.24155828e-02f, 2.12768033e-01f, 1.20856725e-01f,
  9.08064097e-02f, 2.16049120e-01f, 8.23030993e-02f, 2.75951922e-01f, 7.44131505e-02f, 3.65883619e-01f, 2.46797651e-02f, 2.93471485e-01f, 1.03126364e-02f, 1.41386762e-01f,
  1.83363706e-01f, 7.57187977e-02f, 2.25706697e-01f, 1.36176541e-01f, 1.84825644e-01f, 3.18291783e-01f, 1.02043040e-01f, 4.87445481e-02f, 2.75849029e-02f, 1.53838634e-01f,
  2.23846257e-01f, 3.41214210e-01f, 2.70403117e-01f, 8.08494166e-02f, 1.08724296e-01f, 5.15561877e-03f, 2.66928911e-01f, 1.68971747e-01f, 4.44684140e-02f, 2.78469324e-01f,
  7.25095794e-02f, 1.53004959e-01f, 1.60429105e-01f, 8.31629187e-02f, 1.02992766e-01f, 1.17114410e-01f, 1.65417492e-01f, 2.50921667e-01f, 1.68069005e-01f, 3.88074517e-01f,
  1.95501208e-01f, 2.41271108e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.56856173e-01f, 1.79088622e-01f, 3.13684973e-03f, 2.38106802e-01f, -4.65126246e-01f, 2.47093782e-01f, -5.23345113e-01f, -1.37391835e-01f, -1.00281730e-01f, 3.43730748e-02f,
  -5.63160598e-01f, -2.17687085e-01f, 1.16639808e-01f, -2.39683852e-01f, 8.00773501e-02f, -1.43496618e-01f, -7.34831691e-02f, -2.14809000e-01f, 2.44375184e-01f, -1.98793605e-01f,
  -9.89444032e-02f, -2.71075010e-01f, 9.48138237e-02f, -7.03526363e-02f, -5.00014015e-02f, 2.10350245e-01f, 4.54806499e-02f, -1.79426402e-01f, 6.59662187e-01f, -2.46817231e-01f,
  -1.90636262e-01f, -1.49514943e-01f, -6.00871742e-02f, -2.63706088e-01f, 5.19042909e-01f, -4.07502465e-02f, 6.55308738e-02f, 6.56552389e-02f, 4.18244988e-01f, -1.11693002e-01f,
  -1.13180414e-01f, -1.78043902e-01f, -4.47477922e-02f, -3.10838878e-01f, -3.85831743e-02f, -2.29984149e-01f, -1.31161064e-01f, 1.15396395e-01f, 7.40048230e-01f, 5.52522242e-02f,
  -3.34168464e-01f, -5.61725423e-02f, 1.60251185e-02f, -1.23856254e-01f, -1.81319132e-01f, 2.59067714e-01f, -2.12553546e-01f, 1.18343644e-02f, -1.82401717e-01f, -2.55806714e-01f,
  5.52921444e-02f, 5.81502140e-01f, -1.43187046e-01f, -4.77676243e-02f, -4.79805954e-02f, 6.80553690e-02f, 7.19742328e-02f, -1.02693431e-01f, 1.09981172e-01f, -3.77020150e-01f,
  -5.96113741e-01f, 3.43870729e-01f, 1.47874858e-02f, -1.78010955e-01f, -2.91179657e-01f, -2.81122267e-01f, 5.92951536e-01f, -3.49611908e-01f, 1.23621114e-01f, -1.06971562e-01f,
  1.17042242e-02f, -8.65133703e-02f, 6.95193335e-02f, -1.98098406e-01f, -2.25176618e-01f, -2.11846665e-01f, 8.58585984e-02f, 2.40789682e-01f, -1.36568055e-01f, -1.43286902e-02f,
  1.29714599e-02f, -2.00663790e-01f, 1.57872230e-01f, -3.11428487e-01f, -1.15430012e-01f, 1.44788057e-01f, 5.10030389e-01f, 4.26214516e-01f, 1.07239746e-01f, -1.18855521e-01f,
  -2.12446198e-01f, -2.96580911e-01f, 1.17022088e-02f, -6.25353903e-02f, 4.43549529e-02f, 5.72735667e-01f, -7.70571753e-02f, 2.93399662e-01f, 5.72182298e-01f, 1.04556538e-01f,
  6.07916296e-01f, 7.38923326e-02f, -2.29090422e-01f, 8.12018216e-02f, -2.53084183e-01f, -3.04853946e-01f, 4.26684231e-01f, -1.88579574e-01f, -2.29179487e-01f, -8.85031074e-02f,
  -6.66428655e-02f, -2.10977420e-01f, -2.20262647e-01f, 6.50227629e-03f, -1.46310464e-01f, 1.25189170e-01f, -3.07537526e-01f, -1.47736862e-01f, -2.20185623e-01f, -4.02664363e-01f,
  -1.85301408e-01f, -7.70268962e-03f, 1.58466533e-01f, -5.35110272e-02f, -4.34674710e-01f, 4.29717451e-01f, -7.22637922e-02f, 5.74720986e-02f, -3.49434428e-02f, -1.57838956e-01f,
  3.30448523e-02f, 4.56400931e-01f, 1.71808645e-01f, 3.54930274e-02f, -3.00883889e-01f, -1.37127861e-01f, 8.59902706e-03f, 5.59296086e-02f, -8.59705964e-04f, -8.21544528e-02f,
  -1.37870863e-01f, 1.70411244e-01f, 6.68608546e-02f, -1.99664026e-01f, -1.07439220e-01f, -3.18471581e-01f, 1.01346992e-01f, -1.88233674e-01f, -1.82929084e-01f, -1.45692855e-01f,
  5.00145972e-01f, 7.40532398e-01f, -3.15637840e-03f, -1.80244103e-01f, -1.68827139e-02f, -3.16226691e-01f, -1.47835121e-01f, 1.96523726e-01f, 7.14092925e-02f, -3.31142753e-01f,
  -2.82542437e-01f, 9.38603878e-02f, -1.58450484e-01f, 4.47521918e-02f, 2.98724592e-01f, -2.23322168e-01f, -3.33684608e-02f, 2.94580489e-01f, 4.88099128e-01f, -1.38702363e-01f,
  -7.50183240e-02f, 3.13284367e-01f, -8.16347077e-02f, -1.07608274e-01f, -1.35677010e-02f, -8.45814198e-02f, 3.95244837e-01f, -8.74187052e-02f, 7.30280429e-02f, -4.04356360e-01f,
  1.64329946e-01f, -1.16140179e-01f, 7.08873123e-02f, -5.57818472e-01f, -1.07904933e-01f, -3.22580934e-01f, -4.69522923e-02f, -1.22159645e-01f, 9.90787297e-02f, -3.96889120e-01f,
  1.84647009e-01f, 2.39862293e-01f, -4.53028470e-01f, 3.27839196e-01f, -2.37033844e-01f, -2.48154595e-01f, 8.57927799e-02f, -2.18868598e-01f, -1.03098363e-01f, -5.95091805e-02f,
  3.74931321e-02f, 2.78024852e-01f, -2.36021444e-01f, 7.44765878e-01f, -5.78316152e-02f, -1.48523703e-01f, -6.40062764e-02f, 1.56971067e-01f, -1.80990770e-01f, 3.87585491e-01f,
  -2.11698502e-01f, 4.26194578e-01f, 3.62360515e-02f, -1.67641670e-01f, -2.91004591e-02f, -7.01134875e-02f, -2.55606055e-01f, -2.70697474e-01f, 3.31387103e-01f, -2.28918046e-01f,
  -1.50041103e-01f, -3.78780230e-03f, 1.92690954e-01f, -1.45604573e-02f, -2.86370307e-01f, -2.76763171e-01f, 1.13747958e-02f, -1.99154213e-01f, -2.16536686e-01f, -6.85742050e-02f,
  5.75730950e-02f, -1.02031371e-02f, -4.84950133e-02f, -1.96957245e-01f, 5.33826202e-02f, -2.33768508e-01f, 2.28679985e-01f, -2.59709973e-02f, -1.97953865e-01f, -1.89417139e-01f,
  -2.59393871e-01f, -6.07279204e-02f, -1.44427165e-01f, 5.40223897e-01f, 4.03096862e-02f, 5.79036891e-01f, 2.10722342e-01f, 3.45739841e-01f, 1.01241849e-01f, 1.86010763e-01f,
  3.32513422e-01f, 3.23729038e-01f, -2.02176824e-01f, 4.34712619e-02f, 6.68998361e-01f, 5.21173596e-01f, 4.54347506e-02f, -3.90241265e-01f, 1.40838951e-01f, -1.70847252e-01f,
  2.58961245e-02f, 2.26674154e-01f, 1.55296192e-01f, -3.65779400e-02f, 1.01040952e-01f, -7.19007524e-03f, 1.07021928e-01f, 1.70536786e-01f, 2.70726234e-01f, 2.45383685e-03f,
  -5.37195876e-02f, -8.42419565e-02f, 3.83696035e-02f, 9.96657073e-01f, -1.14117473e-01f, 1.38114467e-01f, -2.09749997e-01f, -2.26372227e-01f, -7.81112388e-02f, -2.20385998e-01f,
  -3.26363146e-01f, 4.96080309e-01f, -7.92657286e-02f, -5.84237603e-03f, -8.76413949e-04f, -2.13958457e-01f, 4.77169976e-02f, -1.89775914e-01f, -1.29360005e-01f, -2.80394465e-01f,
  -2.45553598e-01f, -1.29729629e-01f, -1.38954565e-01f, 1.37597129e-01f, 4.91717160e-01f, -1.07374534e-01f, 2.07693294e-01f, -3.04514896e-02f, -4.63762805e-02f, -4.25492823e-02f,
  1.55177504e-01f, -2.09418282e-01f, 3.08796674e-01f, 7.50304013e-02f, -2.05577180e-01f, -1.33546501e-01f, -8.96336362e-02f, 1.68232247e-01f, 4.34360504e-02f, -3.88362944e-01f,
  3.52365285e-01f, 2.13575214e-01f, 1.77797094e-01f, 1.06028602e-01f, 5.20209670e-01f, -2.16174945e-01f, 3.11605275e-01f, 3.38980585e-01f, -4.80665773e-01f, -3.59414458e-01f,
  4.54769164e-01f, -5.58111310e-01f, 1.62998050e-01f, -2.15282813e-01f, -2.35785887e-01f, -2.15805560e-01f, 1.97403774e-01f, 3.62614505e-02f, -2.51917541e-01f, -1.87338188e-01f,
  1.08394928e-01f, -2.53377736e-01f, -1.97293296e-01f, -2.00335398e-01f, -5.11328578e-02f, 1.55618072e-01f, 4.83152457e-02f, -2.36451879e-01f, -1.96314454e-01f, 1.41261950e-01f,
  -4.66113649e-02f, 7.04054767e-03f, -2.12724566e-01f, -2.52612978e-01f, 3.29514056e-01f, -1.09130658e-01f, -2.02935442e-01f, 6.26561284e-01f, 1.14424206e-01f, -6.82155341e-02f,
  -7.89064020e-02f, 2.53418803e-01f, 2.90405959e-01f, -1.60278082e-01f, 2.89498866e-01f, 3.28857481e-01f, -2.34342009e-01f, -1.03034526e-01f, -1.51028872e-01f, -2.53422201e-01f,
  -3.17907706e-02f, 3.46181005e-01f, -1.20654821e-01f, -2.43633240e-01f, -1.37631938e-01f, 1.84907280e-02f, -5.56005947e-02f, 1.38973355e-01f, -1.82572722e-01f, -1.49905831e-01f,
  2.32386008e-01f, 6.19516790e-01f, 1.40401796e-01f, -3.10705546e-02f, 2.72051454e-01f, -1.28692254e-01f, -2.39068002e-01f, -9.26757753e-02f, -1.68166816e-01f, 1.72832474e-01f,
  1.23608217e-01f, 3.13359201e-01f, -2.90031970e-01f, -2.50632346e-01f, 5.02539515e-01f, -1.37837529e-01f, -9.83903632e-02f, -2.52236277e-01f, -9.15435180e-02f, 3.54619533e-01f,
  2.16774702e-01f, 6.74312234e-01f, -3.16287987e-02f, -3.24158408e-02f, -1.59944579e-01f, 3.01614404e-01f, 2.83838898e-01f, 2.08226293e-01f, -1.13048837e-01f, -1.71062708e-01f,
  -6.33421391e-02f, -4.75265384e-01f, -1.65772989e-01f, -3.12621713e-01f, -1.56098887e-01f, 1.34663358e-02f, 4.38696295e-01f, -2.30061859e-01f, 2.59633780e-01f, 2.24860251e-01f,
  -1.37086362e-01f, -2.96773374e-01f, -3.63022871e-02f, 8.76603499e-02f, 3.25432122e-02f, -8.48683417e-02f, 9.66808647e-02f, -1.76850244e-01f, -5.92521243e-02f, 3.52833152e-01f,
  -3.06288272e-01f, -1.75754339e-01f, -3.67215931e-01f, 2.45640185e-02f, 1.83787599e-01f, 3.68837625e-01f, -1.22672305e-01f, 7.31430799e-02f, 4.79386121e-01f, -1.25253677e-01f,
  -7.49860257e-02f, 7.09862709e-02f, 6.98751092e-01f, -1.22555286e-01f, 8.21828023e-02f, -4.37668353e-01f, -2.10558355e-01f, -8.96838680e-02f, -2.04817832e-01f, -1.63872004e-01f,
  -7.93120414e-02f, -2.95785755e-01f, -4.89375042e-03f, -1.74740210e-01f, 5.02078474e-01f, -8.58233720e-02f, -3.06412101e-01f, 2.79219151e-01f, 4.74439710e-02f, 2.96008259e-01f,
  -1.64437339e-01f, -8.83801207e-02f, -3.98641527e-02f, -1.82524726e-01f, 2.00835600e-01f, -4.90736552e-02f, -1.20935388e-01f, 3.09866488e-01f, -8.52859914e-02f, -2.54384756e-01f,
  -2.99682710e-02f, -1.49005294e-01f, 5.49294889e-01f, -1.41543314e-01f, -1.23154083e-02f, 2.77160674e-01f, -3.14301513e-02f, -1.05944335e-01f, 5.42424679e-01f, 2.95102775e-01f,
  -7.22519159e-02f, -1.46740109e-01f, -7.80137777e-02f, 2.07937788e-03f, -1.68229520e-01f, 1.72740873e-03f, -1.72085315e-01f, 2.00054143e-02f, 7.84670487e-02f, -1.91048235e-02f,
  -9.34201404e-02f, -2.24613011e-01f, -1.31396681e-01f, -1.30477905e-01f, -8.47058371e-02f, 1.85150892e-01f, -2.42744744e-01f, 6.07189350e-02f, -1.95037663e-01f, 8.94092247e-02f,
  -1.27068177e-01f, -1.29661590e-01f, 1.51184380e-01f, 3.84104289e-02f, 1.43835470e-01f, -1.22854389e-01f, -1.66415647e-01f, 6.63178623e-01f, -1.04002655e-01f, 3.28362212e-02f,
  3.23599964e-01f, -2.27402017e-01f, -3.65726277e-02f, -1.20280094e-01f, -1.53964909e-03f, -6.29205853e-02f, -3.09062451e-01f, -1.65037498e-01f, 4.38354850e-01f, -2.96453863e-01f,
  -1.85656354e-01f, -1.28508508e-01f, -3.55787277e-01f, -2.71805406e-01f, -1.26648411e-01f, 4.25100140e-02f, -5.37855513e-02f, 4.21046227e-01f, -7.96114206e-02f, 2.98686437e-02f,
  3.94877225e-01f, -5.15368432e-02f, 1.75193727e-01f, -1.54846311e-01f, -1.95988387e-01f, -1.49781421e-01f, 1.83158368e-01f, -1.73828855e-01f, 4.34633195e-01f, -1.84149444e-01f,
  -2.19525933e-01f, -1.07211567e-01f, -5.85968532e-02f, -6.08360879e-02f, -1.43710151e-01f, 4.08550322e-01f, -1.43925995e-01f, -1.28159165e-01f, -2.70662475e-02f, 1.14036597e-01f,
  -1.93237662e-01f, 2.03447536e-01f, -9.44302380e-02f, 1.57136783e-01f, -1.25833347e-01f, 3.06702971e-01f, -1.79432616e-01f, -1.26075655e-01f, 2.91062891e-01f, -8.42385963e-02f,
  4.40513566e-02f, -1.98885307e-01f, 3.19106281e-01f, -1.10850900e-01f, -1.88582033e-01f, -1.94037944e-01f, -1.30820900e-01f, 2.93958485e-01f, -4.31226641e-02f, 3.47134709e-01f,
  -1.40619740e-01f, -2.99523383e-01f, -1.96729735e-01f, -2.10746944e-01f, 5.85922539e-01f, 1.67797521e-01f, 1.34679154e-01f, -3.73066813e-02f, 2.51107160e-02f, 1.49402812e-01f,
  -1.16441511e-01f, 3.17303330e-01f, -2.29847327e-01f, 2.83295870e-01f, -4.35907960e-01f, -3.80166829e-01f, 5.47283888e-01f, 3.32919002e-01f, -1.79036379e-01f, 3.95706594e-01f,
  -2.15943739e-01f, 1.95372105e-02f, 3.92877460e-01f, -2.50878841e-01f, -2.54758865e-01f, 5.90949543e-02f, 4.81181890e-01f, -2.67192721e-01f, -2.19203502e-01f, 6.16984665e-01f,
  -3.57198156e-02f, -2.34830871e-01f, -8.38909820e-02f, 2.89981961e-01f, 3.44083421e-02f, -1.95122346e-01f, -6.80069625e-02f, 6.61366284e-02f, -8.14566016e-02f, -2.31028765e-01f,
  -3.05607885e-01f, 4.33734059e-01f, -2.47180518e-02f, -1.87995553e-01f, -2.38813564e-01f, -7.57393315e-02f, -5.99655248e-02f, 1.07132420e-01f, -2.14556977e-01f, -2.35830784e-01f,
  -3.06370407e-01f, -7.95430038e-03f, 5.19976094e-02f, -1.87030464e-01f, 1.63979024e-01f, 2.42850199e-01f, -7.03419074e-02f, 5.88742554e-01f, 3.83674316e-02f, 2.69678980e-01f,
  -2.98785746e-01f, -2.23828062e-01f, -2.22724229e-02f, 9.58932117e-02f, -2.80125946e-01f, 7.84146786e-03f, 5.06349444e-01f, -3.18028897e-01f, -2.60896057e-01f, -1.89744189e-01f,
  2.97372460e-01f, -3.04980706e-02f, -3.02018076e-01f, 5.87223582e-02f, 8.19742158e-02f, -1.03216387e-01f, 1.25666216e-01f, -5.63434839e-01f, 4.83997911e-01f, 1.54539555e-01f,
  -1.16901278e-01f, 5.21783829e-01f, 6.31295592e-02f, 4.75695521e-01f, 3.00763249e-01f, -1.79914355e-01f, -1.13621466e-01f, -4.53699119e-02f, 1.87629670e-01f, -1.14627242e-01f,
  1.30977318e-01f, -2.33988032e-01f, -1.13915568e-02f, -1.30548358e-01f, -2.64017463e-01f, 5.36543548e-01f, -9.32560265e-02f, -2.49691591e-01f, -2.29742482e-01f, -3.22469056e-01f,
  -8.06895494e-02f, -1.39847800e-01f, -1.28860906e-01f, -3.98912169e-02f, 5.85314855e-02f, -1.99024126e-01f, 4.56555873e-01f, -1.66987419e-01f, 1.10498585e-01f, 2.15381369e-01f,
  -1.56874821e-01f, -1.24759756e-01f, -2.57476777e-01f, 5.04978955e-01f, 3.48531716e-02f, -1.86275229e-01f, -1.33024186e-01f, -1.20472021e-01f, 1.63546000e-02f, -7.10915029e-02f,
  -2.01830477e-01f, -2.23947242e-01f, 1.42883807e-01f, 8.15271214e-02f, -9.73116532e-02f, -2.04073787e-01f, 1.96798071e-02f, 1.81960419e-01f, 2.14880913e-01f, 5.04570484e-01f,
  -1.04493991e-01f, -3.04237992e-01f, -3.23507994e-01f, 5.80556035e-01f, -1.68351531e-01f, 1.51967078e-01f, 2.84546372e-02f, 2.32485458e-01f, 7.87204802e-02f, 7.46890306e-02f,
  3.91158730e-01f, -7.78690577e-02f, 3.53822887e-01f, -8.61322284e-02f, 3.05296808e-01f, 1.77229375e-01f, -2.05426261e-01f, -1.42306402e-01f, 1.07851058e-01f, 1.68412238e-01f,
  -9.75857675e-02f, 3.65430266e-01f, -1.44672573e-01f, 1.09953592e-02f, -4.22381274e-02f, 1.63212523e-01f, -4.49768193e-02f, -2.18108520e-01f, -6.78247809e-02f, 1.32096753e-01f,
  -2.06351981e-01f, -3.31822157e-01f, 7.86157101e-02f, 8.70172739e-01f, -2.07993284e-01f, -1.22166499e-01f, -2.03728169e-01f, -1.70258671e-01f, -5.40599227e-02f, -1.23572737e-01f,
  1.09459691e-01f, 4.20928568e-01f, -5.94544932e-02f, 6.75787553e-02f, 1.81351244e-01f, -2.27795914e-01f, 6.39310777e-01f, 4.02770460e-01f, -2.68021017e-01f, -1.09897584e-01f,
  -1.73840433e-01f, 9.71767008e-02f, 3.03918403e-02f, 3.89975756e-02f, -1.65234402e-01f, -2.88754791e-01f, -1.06558032e-01f, 4.19538409e-01f, -3.66846956e-02f, 9.30721015e-02f,
  -9.96917710e-02f, -1.03287168e-01f, 9.42342132e-02f, -2.77099878e-01f, -9.14770067e-02f, -3.60510856e-01f, 6.66208193e-02f, -2.72124708e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.64965089e-02f, -1.75877307e-02f, -3.21015388e-01f, 2.02286765e-02f, 1.98007718e-01f, 1.06809735e-01f, 1.58714294e-01f, -8.43765959e-02f, -2.26567298e-01f, 1.21934704e-01f,
  7.99388885e-02f, 1.05955936e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    