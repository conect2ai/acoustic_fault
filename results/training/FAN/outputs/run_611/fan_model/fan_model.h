/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.63914394e-01f, -9.57733616e-02f, 2.66322643e-01f, 5.21058023e-01f, 4.04205024e-01f, 1.49330735e-01f, 1.76731914e-01f, -3.05451769e-02f, 2.27644965e-01f, 2.66890764e-01f,
  3.04392502e-02f, -2.79485621e-02f, -9.17314291e-02f, -2.33668417e-01f, -2.27139637e-01f, 1.28067091e-01f, 1.88374773e-01f, -1.59830630e-01f, -6.74722195e-02f, 1.82074204e-01f,
  8.97521004e-02f, 1.78974792e-01f, 4.02032062e-02f, -1.94863364e-01f, 2.41690904e-01f, -1.09698609e-01f, 8.92391428e-02f, 2.46420473e-01f, -6.52228147e-02f, 4.20616895e-01f,
  1.41178012e-01f, 6.86860159e-02f, -2.18331981e-02f, -6.30433336e-02f, 4.22492810e-02f, 3.60828489e-02f, 5.31222150e-02f, -3.17088291e-02f, -7.06841424e-02f, -1.02180950e-02f,
  2.89479904e-02f, -9.36635584e-02f, -2.05102246e-02f, 1.26271388e-02f, 1.54179865e-02f, 6.16511405e-02f, 3.05009652e-02f, -7.44396076e-02f, -1.00737080e-01f, 2.52750982e-02f,
  1.44652128e-01f, 1.14117168e-01f, -1.28266457e-02f, -4.31349650e-02f, -3.28991227e-02f, -1.27236933e-01f, -5.65268509e-02f, 7.40397023e-03f, -5.84942512e-02f, 5.37270121e-02f,
  3.73639911e-02f, -8.52554813e-02f, 3.50187160e-03f, 1.86573826e-02f, -1.02723368e-01f, -1.88494958e-02f, -3.36000547e-02f, 2.84692831e-02f, -2.85642315e-02f, 5.47259413e-02f,
  -6.01423383e-02f, 2.43056249e-02f, -1.79225430e-02f, -4.21932004e-02f, -1.83688793e-02f, -1.78854950e-02f, -4.22695689e-02f, 3.06769628e-02f, -2.97470875e-02f, -2.11156439e-02f,
  -5.72028160e-02f, -8.51937458e-02f, 5.30572794e-02f, -8.88716877e-02f, 5.02390973e-03f, 8.21890831e-02f, 4.50444147e-02f, -1.09808713e-01f, -5.10088429e-02f, -8.20701495e-02f,
  -8.61811489e-02f, -6.59058988e-02f, 8.44412595e-02f, -2.27564145e-02f, -2.33170986e-02f, -1.32158235e-01f, 5.75817898e-02f, -6.97429925e-02f, 3.77909020e-02f, 5.09547070e-02f,
  -2.08664052e-02f, -5.14593832e-02f, 2.56185215e-02f, -1.17321633e-01f, 8.63629058e-02f, 4.84988168e-02f, 6.18932843e-02f, 4.81143668e-02f, -6.19711243e-02f, 1.44277571e-03f,
  -8.05498064e-02f, -2.32383842e-03f, -9.74455029e-02f, -1.02089174e-01f, 2.86678802e-02f, 3.88870016e-04f, -1.65664867e-01f, -6.43890537e-03f, -9.06823426e-02f, -2.08620816e-01f,
  -3.39923084e-01f, 2.64361620e-01f, -1.69304889e-02f, 1.55153632e-01f, 1.68593645e-01f, 1.18844517e-01f, 2.26297408e-01f, 2.34265685e-01f, 1.36091918e-01f, -9.47009772e-02f,
  2.81746268e-01f, -2.16347173e-01f, -1.46069899e-01f, -1.33395866e-01f, -6.50887489e-02f, -4.57728468e-02f, -2.05774814e-01f, -3.06119680e-01f, -2.10832253e-01f, 1.49198517e-01f,
  3.84051055e-02f, 5.28532043e-02f, 4.42753173e-02f, 4.70024161e-02f, -1.62361003e-02f, -3.08349937e-01f, 2.21499622e-01f, 6.53163567e-02f, 6.03058301e-02f, -5.19256115e-01f,
  -7.02962726e-02f, 2.40429580e-01f, 6.18031435e-02f, 3.64339389e-02f, -5.23135765e-03f, -1.07309923e-01f, 3.44318673e-02f, 4.89922520e-03f, -4.26332951e-02f, -2.40319222e-02f,
  6.66040629e-02f, 7.11454451e-02f, -1.99702699e-02f, -5.43155782e-02f, 1.34925261e-01f, 5.94751816e-03f, 7.79402480e-02f, -2.26724930e-02f, -1.54785076e-02f, 5.06477840e-02f,
  -6.25262558e-02f, 6.54804260e-02f, 5.88430725e-02f, 1.48463860e-01f, 4.53463979e-02f, -1.97998844e-02f, 2.47696862e-01f, 3.55874337e-02f, 9.52197164e-02f, -1.24193184e-01f,
  -8.73687305e-03f, 8.51077586e-03f, 5.51737510e-02f, 1.93249788e-02f, -4.77454066e-02f, 2.07437966e-02f, -1.78648848e-02f, 1.25477668e-02f, 6.25841618e-02f, -2.41063405e-02f,
  3.73673998e-02f, -4.12058607e-02f, -4.80604209e-02f, 8.18366408e-02f, -7.49550713e-03f, 2.02581310e-03f, -4.71428409e-02f, -8.88455950e-04f, 1.61302241e-03f, -3.41427214e-02f,
  -4.68073562e-02f, -1.44188367e-02f, 4.42689136e-02f, -2.13087797e-02f, 1.82420835e-02f, -2.46678479e-02f, -1.54802632e-02f, 4.21759188e-02f, 3.61153558e-02f, 6.92122206e-02f,
  4.77639958e-02f, 4.86108325e-02f, -7.85603449e-02f, -4.01915237e-02f, 4.36481700e-04f, 2.33043246e-02f, -1.88983567e-02f, -3.45777608e-02f, -3.27231213e-02f, 4.41526622e-03f,
  1.85629372e-02f, -4.72851731e-02f, 3.43032032e-02f, 4.06739907e-03f, -4.18046452e-02f, 1.21388696e-02f, -7.74509087e-02f, -8.26433450e-02f, 3.36677469e-02f, 6.83375597e-02f,
  -1.69605762e-02f, -6.25586659e-02f, -1.30814061e-01f, -8.15553367e-02f, -3.65855172e-02f, -1.44059435e-01f, -7.15634748e-02f, -1.38833866e-01f, -8.44037309e-02f, -1.04301542e-01f,
  1.21291533e-01f, -6.09831512e-01f, -6.69069821e-03f, -6.81711361e-02f, -2.02187747e-01f, 1.49706975e-01f, -1.13291644e-01f, 8.26524422e-02f, 1.23512618e-01f, -2.49961123e-01f,
  -2.74649382e-01f, 6.69699684e-02f, 1.49675667e-01f, 7.34443739e-02f, 2.21667677e-01f, -1.53657019e-01f, -1.81288227e-01f, 2.86435604e-01f, 4.04729277e-01f, 4.43654247e-02f,
  -1.22897051e-01f, -2.12801676e-02f, 2.50311524e-01f, 1.41273171e-01f, -3.66206586e-01f, 9.65113789e-02f, -6.31727055e-02f, -1.70415878e-01f, -2.29696080e-01f, -7.58768439e-01f,
  -1.46393970e-01f, -3.10226381e-01f, 7.66272321e-02f, -5.17210504e-03f, -1.29225373e-01f, 7.75209591e-02f, -3.32357740e-04f, 2.85028759e-02f, -2.71390192e-02f, -3.22122574e-02f,
  -1.37408629e-01f, 5.18994452e-03f, -5.71267866e-02f, 9.35308821e-03f, -1.98906399e-02f, 9.31482669e-03f, -2.34204847e-02f, -2.28527308e-04f, 1.35183901e-01f, -2.71425527e-02f,
  -1.66019261e-01f, -1.83047026e-01f, -3.90257011e-03f, -1.59849729e-02f, 1.99947417e-01f, 8.74558836e-02f, -1.35667890e-01f, -8.84891078e-02f, 5.02567664e-02f, -1.70895159e-01f,
  2.98536178e-02f, -7.42247999e-02f, -2.87380628e-02f, -3.01368348e-02f, -1.57115832e-02f, -6.26873970e-02f, 2.64061708e-02f, -6.31585866e-02f, 1.61220934e-02f, -6.07476756e-02f,
  1.56971645e-02f, 7.04739662e-03f, 5.80301099e-02f, 1.72743537e-02f, -2.73252092e-02f, -3.15277576e-02f, -2.02367846e-02f, -1.93885807e-02f, -3.32568213e-02f, 4.10651229e-02f,
  3.06344610e-02f, 2.85804868e-02f, -4.69266772e-02f, -8.46724119e-03f, -4.43485603e-02f, -2.80277542e-04f, 2.32432690e-03f, -5.27335070e-02f, 1.30881235e-04f, -2.50880923e-02f,
  2.08828703e-01f, 2.04934180e-01f, -1.54477702e-02f, 6.98059201e-02f, 5.02854586e-02f, 3.63615016e-03f, -1.48810847e-02f, -2.84397826e-02f, -9.65890884e-02f, 2.86117848e-02f,
  4.15571667e-02f, 3.68983485e-02f, 9.49285273e-03f, 1.62577573e-02f, 5.45072556e-02f, 3.58961560e-02f, -8.56985599e-02f, 2.94429101e-02f, 8.32623914e-02f, -2.39495393e-02f,
  5.50926551e-02f, 1.80785060e-01f, 2.70351440e-01f, 7.00286105e-02f, 7.79742897e-02f, 1.99464723e-01f, 8.01101401e-02f, 1.70504957e-01f, 2.97643423e-01f, 1.98172301e-01f,
  3.33166160e-02f, 3.01932007e-01f, 6.77558035e-02f, -1.88278377e-01f, 3.02244693e-01f, -2.24306453e-02f, 7.20795542e-02f, -1.86768204e-01f, -8.82958844e-02f, 1.12559356e-01f,
  3.99618834e-01f, 1.77282691e-01f, 1.05179965e-01f, 1.75052006e-02f, -3.00261211e-02f, -5.25866225e-02f, -1.48327053e-01f, -1.57782272e-01f, -1.86065659e-01f, 3.17564309e-01f,
  1.89265043e-01f, -1.93127766e-01f, -3.24885279e-01f, -3.46854270e-01f, 1.93166137e-01f, -9.39893872e-02f, -1.22521907e-01f, -1.74233932e-02f, 9.03249756e-02f, 2.37536892e-01f,
  4.94580805e-01f, 1.92616731e-01f, 1.24156484e-02f, 9.00621936e-02f, 1.33910224e-01f, -3.11846770e-02f, 1.86447259e-02f, 2.11685733e-03f, 1.00839771e-02f, -9.65410694e-02f,
  1.83312565e-01f, 3.25164832e-02f, 1.16701603e-01f, -4.64894474e-02f, -4.09457572e-02f, -8.17903429e-02f, -7.93558657e-02f, 2.92691421e-02f, -3.56364213e-02f, 3.48199233e-02f,
  2.13856816e-01f, 2.37153351e-01f, 1.79573461e-01f, 2.37910915e-02f, 1.63574200e-02f, 6.82701543e-02f, 7.92127773e-02f, 9.21985209e-02f, -4.81465161e-02f, 3.76178254e-03f,
  3.58638987e-02f, 2.93996371e-02f, -3.27078067e-02f, -3.63599658e-02f, 1.08308643e-02f, -2.59290375e-02f, 4.41188738e-02f, -1.88291688e-02f, -1.02908157e-01f, -1.08213857e-01f,
  6.60436153e-02f, 4.21012565e-03f, -1.99423544e-02f, 7.53383860e-02f, -1.53851304e-02f, 3.03432085e-02f, 2.77230125e-02f, -3.99335027e-02f, -1.86825246e-02f, -5.97398318e-02f,
  2.37655267e-03f, 1.81382634e-02f, -3.19506004e-02f, -2.16704682e-02f, -3.12140714e-02f, 5.96112534e-02f, 7.65110105e-02f, -7.65472800e-02f, -8.83963555e-02f, 1.80104729e-02f,
  -1.37032703e-01f, 2.79510934e-02f, -1.36283748e-02f, -5.48809674e-03f, 5.72188944e-02f, -8.39260686e-03f, 4.31300513e-02f, 2.08040345e-02f, 3.34279835e-02f, -2.15848032e-02f,
  -2.19340175e-02f, -8.06641877e-02f, -1.81029066e-02f, -2.49671005e-02f, -2.83816662e-02f, -2.26372089e-02f, -4.62040491e-03f, 5.28889894e-02f, 1.33414334e-02f, -3.64075340e-02f,
  -1.47870749e-01f, -8.26156288e-02f, 6.08690828e-02f, 2.27523111e-02f, 2.92920265e-02f, -2.57998109e-02f, -1.66674316e-01f, -1.47722205e-02f, 3.76332812e-02f, -2.65974253e-01f,
  5.65234087e-02f, -4.65754569e-01f, 7.71111310e-01f, 5.29550388e-02f, 1.49149597e-01f, 7.81669170e-02f, -1.76241457e-01f, -1.36181831e-01f, 1.34201109e-01f, 2.14348324e-02f,
  -3.28638971e-01f, -2.92607933e-01f, -2.95207232e-01f, -1.04097739e-01f, -1.56411216e-01f, 2.10563451e-01f, 4.90621179e-01f, 2.62735635e-01f, -1.82386860e-02f, -1.56503662e-01f,
  -3.24139506e-01f, 1.14007160e-01f, 1.00627922e-01f, -2.05202177e-02f, 1.68341771e-01f, -2.52175242e-01f, 2.01449782e-01f, 1.24600418e-01f, -1.33013755e-01f, 5.89206457e-01f,
  1.37736917e-01f, 8.19025189e-02f, 8.90509263e-02f, -4.19507809e-02f, 8.91629010e-02f, -5.02322316e-02f, -6.77132572e-04f, 7.64565244e-02f, -9.64891911e-02f, 5.76895662e-02f,
  1.20843016e-02f, 4.17070016e-02f, 3.18557583e-02f, 4.64516180e-03f, 2.79556531e-02f, -3.37420707e-03f, 2.58227792e-02f, 3.67460772e-02f, 1.21195003e-01f, -3.81922200e-02f,
  -1.15950488e-01f, -4.61072885e-02f, 1.18244663e-01f, -3.75194363e-02f, -5.38750514e-02f, 3.47643755e-02f, -1.35228196e-02f, 8.76040682e-02f, 4.31908108e-02f, 5.90764135e-02f,
  -2.84580551e-02f, 3.96646820e-02f, 2.42914576e-02f, -3.41390558e-02f, -7.38522634e-02f, 2.26402730e-02f, 5.47762401e-02f, 1.45934932e-02f, -3.41784544e-02f, -2.51177661e-02f,
  2.85914913e-02f, 2.34756600e-02f, 7.09465472e-03f, 3.73938009e-02f, -5.13966288e-03f, 4.89559844e-02f, 2.45132204e-02f, -4.82800268e-02f, 2.46517137e-02f, 3.09063159e-02f,
  -6.85705245e-02f, 6.32802993e-02f, 8.92235804e-03f, 4.62098717e-04f, 3.19164321e-02f, -6.23290353e-02f, 7.28332400e-02f, -1.18845612e-01f, -2.69686189e-02f, 5.31598218e-02f,
  -1.43222317e-01f, -4.62004468e-02f, 5.41610308e-02f, 4.95982170e-03f, 1.23583367e-02f, 3.99477668e-02f, -1.81632172e-02f, 1.39147099e-02f, 1.85125731e-02f, -2.90222536e-03f,
  -4.46117111e-02f, -3.15379846e-04f, -3.14566717e-02f, 5.05100610e-03f, 1.13560036e-02f, -4.67776246e-02f, -5.03041185e-02f, -7.87433051e-03f, 1.89347975e-02f, 8.60565007e-02f,
  4.80320044e-02f, -6.35796180e-03f, -8.77023265e-02f, -3.78849022e-02f, -4.09475863e-02f, -1.42044976e-01f, -4.47998084e-02f, -2.55260561e-02f, -1.23150144e-02f, -1.88919082e-01f,
  3.92030239e-01f, 3.05888325e-01f, 2.68351793e-01f, -2.05179825e-01f, -7.56756887e-02f, 1.73018053e-02f, 4.22025770e-01f, 1.20373264e-01f, -1.61753982e-01f, 1.74109071e-01f,
  9.66614578e-03f, -2.28526890e-01f, -2.28437614e-02f, -1.98932327e-02f, 3.41127098e-01f, 2.15442523e-01f, 2.11010650e-01f, 2.03552529e-01f, 9.85177606e-03f, -2.33431637e-01f,
  -2.80018002e-01f, -3.79487313e-02f, 2.24244714e-01f, -2.10544672e-02f, 8.40499029e-02f, -1.18310630e-01f, 2.14456037e-01f, 1.10149741e-01f, 1.04582369e-01f, 1.44373000e-01f,
  2.08506048e-01f, 6.86195567e-02f, -7.50473738e-02f, -8.18056613e-02f, -1.22478055e-02f, 6.54096678e-02f, 1.59355495e-02f, 9.27014351e-02f, -5.03503233e-02f, 9.31006968e-02f,
  -7.71326646e-02f, -5.35748228e-02f, -5.87062649e-02f, -2.55179890e-02f, 3.23110297e-02f, 1.64669193e-02f, 6.55629858e-02f, 1.36672229e-01f, 9.82288048e-02f, 4.52412888e-02f,
  -7.57240430e-02f, 1.83695499e-02f, 1.52468130e-01f, -3.79724950e-02f, 1.18422695e-02f, -1.44971266e-01f, 1.53131476e-02f, -2.68536583e-02f, 1.43989787e-01f, 1.82625622e-01f,
  2.20127013e-02f, -2.13597734e-02f, -5.50418682e-02f, 1.73477996e-02f, -3.41288149e-02f, -8.97735124e-04f, -1.57038253e-02f, 2.69555077e-02f, -5.83033152e-02f, 4.54940721e-02f,
  -4.43295017e-02f, 4.82102595e-02f, -3.45268436e-02f, 6.94089979e-02f, -2.22918075e-02f, 2.94783786e-02f, -3.69528607e-02f, 3.71062290e-03f, -9.91820917e-02f, -1.01398036e-03f,
  -5.87730901e-03f, -6.88270777e-02f, -4.26148511e-02f, -5.13082482e-02f, 3.13164643e-03f, 2.98351329e-02f, -7.69548416e-02f, 4.96366876e-04f, -7.03491792e-02f, -2.32395586e-02f,
  -4.41742279e-02f, 1.30928112e-02f, 8.62524882e-02f, 9.66883323e-04f, 2.61539612e-02f, -4.05169837e-02f, -1.89218149e-02f, -1.87372118e-02f, -8.08674768e-02f, 1.67803261e-02f,
  2.07099710e-02f, 6.75903931e-02f, 8.70277211e-02f, 5.09692244e-02f, -1.49319218e-02f, -2.60710754e-02f, 3.86414379e-02f, 8.53605382e-03f, -2.26451177e-02f, -6.60292953e-02f,
  3.53757814e-02f, 1.32748365e-01f, 1.14898540e-01f, 8.28069076e-02f, 6.92564249e-02f, 1.46558350e-02f, 6.94970936e-02f, 2.09973678e-02f, 1.61196545e-01f, 2.73500681e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.60510436e-01f, -4.30998132e-02f, 3.39960575e-01f, 3.96817595e-01f, 2.47705549e-01f, 1.47359326e-01f, 6.03034720e-02f, 9.37627256e-02f, 9.31500718e-02f, 2.38816231e-01f,
  -1.13219991e-01f, 2.27240711e-01f, 1.24130242e-01f, 1.72263354e-01f, 1.97178349e-02f, 3.27663630e-01f, 2.26143688e-01f, 1.49851918e-01f, 2.34544352e-01f, 1.18345492e-01f,
  2.59048671e-01f, 1.26994234e-02f, -2.13422447e-01f, 1.06150642e-01f, 1.93820477e-01f, 3.21369559e-01f, 3.03216130e-02f, 3.66999730e-02f, 8.83233398e-02f, 4.80429322e-01f,
  2.85942197e-01f, -8.91847834e-02f, 3.54631662e-01f, -1.77330598e-01f, -2.11897686e-01f, -1.51232705e-01f, -3.16461101e-02f, -8.62652063e-02f, -1.39818192e-01f, 1.35299027e-01f,
  -1.23457424e-01f, -1.06605150e-01f, -9.07639340e-02f, -1.34114444e-01f, -9.28196162e-02f, -1.77738786e-01f, -9.46027562e-02f, 4.93655875e-02f, 5.31153269e-02f, 2.91528329e-02f,
  1.80627808e-01f, -9.18733701e-02f, 5.25194257e-02f, 1.33618504e-01f, 5.90485968e-02f, -1.63492352e-01f, 4.66756336e-02f, 3.38999517e-02f, -1.53911635e-01f, 2.21604466e-01f,
  2.63051808e-01f, 8.63006040e-02f, -1.46528557e-01f, 1.03425696e-01f, 8.32279548e-02f, 9.13658217e-02f, 7.38340430e-03f, -7.78082013e-03f, 1.20897613e-01f, 1.03822753e-01f,
  9.77002904e-02f, 4.41867411e-02f, 4.92814556e-03f, 2.28594437e-01f, 2.32114106e-01f, 9.60283875e-02f, -1.22791186e-01f, -1.85939912e-02f, -1.22793175e-01f, -1.12256281e-01f,
  -8.00752714e-02f, -1.36111125e-01f, -7.23115057e-02f, -1.38063297e-01f, -1.08171821e-01f, 6.21951334e-02f, 2.64252070e-02f, -1.19642271e-02f, -1.41648352e-01f, 4.83816713e-02f,
  1.70492381e-01f, -2.24838674e-01f, 3.02388519e-01f, 1.03102513e-02f, -8.03822950e-02f, -2.02537671e-01f, 1.05063796e-01f, -1.66503526e-02f, -2.66294479e-01f, 1.48090804e-02f,
  -1.38040915e-01f, -4.12090495e-02f, -8.64929780e-02f, -1.27421737e-01f, -5.31789958e-02f, -1.70034066e-01f, -3.63478176e-02f, 1.18883081e-01f, -6.62793145e-02f, -7.85649121e-02f,
  -3.46720107e-02f, -2.99775414e-02f, 1.66100025e-01f, 7.17624500e-02f, 1.06834084e-01f, -9.20606479e-02f, 1.58598255e-02f, 7.79714882e-02f, -1.54866382e-01f, 1.29019320e-01f,
  -1.45113194e+00f, 4.76174831e-01f, -2.33499199e-01f, -2.63179034e-01f, -2.89446056e-01f, -3.03117573e-01f, 9.07385126e-02f, 1.01763777e-01f, -1.37569174e-01f, 3.00269186e-01f,
  1.34082243e-01f, -2.51790345e-01f, 2.03257442e-01f, 1.27533391e-01f, -4.65594441e-01f, 1.18132465e-01f, -1.86461180e-01f, -7.34282732e-01f, -9.15940285e-01f, -1.95950165e-01f,
  2.77354638e-03f, -6.18543386e-01f, -8.06314349e-01f, -1.66032135e-01f, 1.75164580e-01f, -2.30455115e-01f, 1.94904655e-01f, -2.68333793e-01f, -1.48390844e-01f, -9.63278115e-03f,
  1.59326121e-01f, -2.80134648e-01f, -8.86212066e-02f, -2.23358423e-01f, 2.97103953e-02f, 2.76556741e-02f, -6.88627139e-02f, -5.95628880e-02f, 5.88434264e-02f, 1.36824504e-01f,
  -8.66435096e-02f, -2.21417788e-02f, -1.71430409e-01f, -9.82490331e-02f, -8.99848491e-02f, -4.68039094e-03f, -7.09620491e-02f, -1.52218938e-01f, -4.88947518e-02f, 3.80989432e-01f,
  2.21261233e-01f, -1.71342760e-01f, 9.71325673e-03f, 1.52191654e-01f, 1.74097463e-01f, -2.85584301e-01f, 2.88854957e-01f, 1.23123437e-01f, -7.99021348e-02f, 3.26147765e-01f,
  5.17328754e-02f, 1.23109698e-01f, -2.75422051e-03f, 4.35992181e-02f, 2.02750415e-02f, 3.24227358e-03f, -4.82809171e-02f, 4.15004976e-02f, -1.36719674e-01f, 1.32292524e-01f,
  1.04760200e-01f, -3.03577073e-02f, 7.83605948e-02f, 5.49857914e-02f, 5.90817677e-03f, -7.59615302e-02f, -1.78069845e-01f, 7.12673068e-02f, 1.22254573e-01f, -7.23107830e-02f,
  -3.79933193e-02f, -1.87925659e-02f, 4.30387771e-03f, 6.97726160e-02f, -9.04765278e-02f, 4.37496342e-02f, -9.86299217e-02f, -1.19225219e-01f, 1.56512018e-02f, -1.12307720e-01f,
  2.01540411e-01f, -4.64765817e-01f, 1.53936699e-01f, -2.10627485e-02f, -9.99817476e-02f, 1.51830837e-01f, 7.03596100e-02f, 1.43740714e-01f, 1.83850545e-02f, 1.41316466e-02f,
  -6.94346381e-03f, 2.45574601e-02f, 2.13926248e-02f, 1.19812630e-01f, 9.70323570e-03f, -6.55532777e-02f, -4.74207886e-02f, -5.34031689e-02f, -4.15927134e-02f, 1.37153208e-01f,
  1.39673203e-01f, 6.24990277e-02f, 2.65180133e-02f, 1.58581689e-01f, 9.80875082e-03f, -2.83847749e-01f, 1.80045083e-01f, 1.49407819e-01f, -2.29674309e-01f, 6.11326754e-01f,
  1.56445503e-01f, -3.37617010e-01f, 2.82456130e-01f, -2.46486306e-01f, 1.73160464e-01f, 2.73747325e-01f, 2.22236603e-01f, -1.44590244e-01f, -6.89129531e-02f, -1.04111591e-02f,
  -2.17066824e-01f, 1.74631342e-01f, 3.15891691e-02f, 2.20525707e-03f, 8.26403275e-02f, -1.86270718e-02f, -9.27660428e-03f, 2.73531199e-01f, 5.47472417e-01f, 2.05716908e-01f,
  -8.64016861e-02f, -3.32993984e-01f, -2.80041724e-01f, -1.60460144e-01f, -2.49322087e-01f, 1.70898765e-01f, -2.21954793e-01f, -2.34097242e-01f, -1.73047304e-01f, -2.11399749e-01f,
  5.95478714e-01f, -1.21926531e-01f, 2.05718353e-01f, -1.59090489e-01f, 5.28261289e-02f, -7.98613206e-02f, 1.87735170e-01f, -3.63193639e-02f, -2.33471785e-02f, -3.39125423e-03f,
  -5.46506494e-02f, -1.41310245e-01f, -3.61540243e-02f, -4.86569805e-03f, -6.55448362e-02f, 6.54083490e-02f, -1.38645530e-01f, -5.40568978e-02f, -1.94960926e-02f, 1.03557073e-02f,
  -1.03944629e-01f, 3.17423344e-02f, 4.01452072e-02f, 6.01982474e-02f, -7.90285170e-02f, 9.73072872e-02f, -1.66971181e-02f, -1.40155992e-02f, -1.16360355e-02f, 7.15510771e-02f,
  3.93776409e-02f, 1.35076478e-01f, 9.17276666e-02f, 3.89005467e-02f, -2.27974970e-02f, 9.42247659e-02f, 4.32515480e-02f, 3.14976200e-02f, -5.19656725e-02f, 1.38112670e-02f,
  -7.76305562e-03f, -7.78217614e-03f, 2.22512390e-02f, -9.30387750e-02f, 9.94399842e-03f, -1.56184239e-02f, -7.51075447e-02f, -1.50814839e-02f, 1.58581734e-02f, -5.10919802e-02f,
  -1.22134760e-01f, 1.08224578e-01f, -9.10774525e-03f, -2.67042648e-02f, -1.49873421e-01f, 2.47087833e-02f, -8.09939206e-02f, -7.58886337e-02f, 1.61460545e-02f, -6.00722954e-02f,
  2.02772185e-01f, 2.22843383e-02f, 1.87931672e-01f, -8.93321559e-02f, 1.56752095e-02f, -1.36404008e-01f, -1.78247319e-07f, 6.08760640e-02f, 3.67424116e-02f, 1.00910366e-01f,
  1.64490249e-02f, 1.98790450e-02f, -1.55163584e-02f, -6.42289519e-02f, 1.81945905e-01f, 4.55958620e-02f, -8.10637921e-02f, 1.59722537e-01f, -1.04746826e-01f, 4.45821807e-02f,
  -1.69374570e-01f, 1.51380956e-01f, 4.35373843e-01f, 3.79722267e-01f, -4.01837043e-02f, 3.38616371e-01f, 2.23625705e-01f, 9.06224623e-02f, 2.48414353e-01f, 2.68687665e-01f,
  -1.37527549e+00f, 4.41636086e-01f, -1.37505546e-01f, -6.04002237e-01f, 3.93953860e-01f, 1.31746992e-01f, 5.21125019e-01f, -3.37782837e-02f, -3.41907144e-01f, 2.48748526e-01f,
  3.44138704e-02f, -2.59179741e-01f, -4.93654348e-02f, 2.77333170e-01f, 1.67690255e-02f, 5.20221770e-01f, 4.79123056e-01f, -9.62050185e-02f, -4.43685412e-01f, -6.78777397e-02f,
  3.94898266e-01f, -2.78032094e-01f, -6.97735608e-01f, -3.07615697e-01f, -2.76724156e-02f, -5.49468026e-02f, 2.08574042e-01f, 2.48723035e-03f, 1.91692606e-01f, 3.63645285e-01f,
  4.92500663e-02f, -2.34639630e-01f, 3.47568244e-02f, -6.70739412e-02f, -2.59403419e-02f, -6.05488643e-02f, -1.04541309e-01f, -1.60147175e-01f, -1.17916889e-01f, -1.77222863e-02f,
  -1.36876449e-01f, 2.96006463e-02f, -2.18256079e-02f, 1.01801008e-01f, -1.56883255e-01f, -3.36735211e-02f, -5.04703484e-02f, -1.92185730e-01f, -9.70875695e-02f, 1.29824892e-01f,
  3.93512160e-01f, -1.41453445e-02f, -1.56844884e-01f, 1.37163505e-01f, 8.59912932e-02f, -1.88206851e-01f, 1.78726595e-02f, -1.20086903e-02f, -3.26598212e-02f, -1.08801849e-01f,
  -1.33302389e-02f, -6.26118854e-02f, 2.01444142e-02f, 1.04918955e-02f, 9.82418563e-03f, -3.54147255e-02f, 3.70371379e-02f, 1.37667730e-01f, 1.75787660e-03f, -8.98946449e-02f,
  -4.43309546e-02f, 8.46654475e-02f, -2.08771285e-02f, -8.32354650e-03f, 1.11173363e-02f, -2.99418624e-02f, 8.27997476e-02f, -5.02864048e-02f, 3.00432574e-02f, -2.10421570e-02f,
  -9.91601869e-03f, -9.83649399e-03f, -2.86963861e-02f, 3.11947484e-02f, 7.13795498e-02f, 4.29941043e-02f, -1.04110040e-01f, 7.48643558e-03f, -1.38838828e-01f, 1.63129997e-02f,
  -1.91255853e-01f, 1.08620860e-01f, -1.43488288e-01f, 9.33467317e-03f, -7.10448623e-02f, 1.88292973e-02f, -9.79349241e-02f, 8.61049742e-02f, 1.29049923e-02f, 8.13188180e-02f,
  5.57056032e-02f, 2.27499800e-03f, 5.76134585e-03f, -2.81037260e-02f, 6.67000786e-05f, -5.75881568e-04f, 7.82480538e-02f, -1.71346162e-02f, 3.98490503e-02f, -6.10128157e-02f,
  1.19464785e-01f, 4.48569132e-04f, -1.41510874e-01f, -1.05037853e-01f, 9.15297717e-02f, -5.52653670e-02f, 1.05901370e-02f, -9.67949256e-03f, -4.36647907e-02f, -3.79578844e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  4.11723197e-01f, 4.28827792e-01f, 2.86376119e-01f, 6.63791737e-03f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.37941088e-02f, 1.42758757e-01f, 2.98110157e-01f, 4.48415950e-02f, -2.49528393e-01f, 7.45229656e-03f, -6.47144020e-02f, -2.68736124e-01f, 3.07989419e-01f, -2.70186871e-01f,
  -5.00584602e-01f, 7.12119699e-01f, 6.75781816e-02f, 1.32276982e-01f, 4.84938353e-01f, -5.62153816e-01f, -1.10808827e-01f, 6.57774881e-02f, -1.09036930e-01f, -1.56633347e-01f,
  8.59560892e-02f, 3.16519231e-01f, 1.08387843e-01f, -3.71640295e-01f, -2.29850337e-01f, 1.95280209e-01f, -1.88813850e-01f, -5.06497741e-01f, -5.15794158e-02f, -5.86431613e-03f,
  3.07182789e-01f, 4.66429234e-01f, -2.63152778e-01f, 6.33780733e-02f, -1.29832581e-01f, 5.91171421e-02f, -4.04892802e-01f, -3.86433363e-01f, 4.40114401e-02f, -1.74486950e-01f,
  -4.69545312e-02f, -3.10850263e-01f, 4.37322855e-01f, 2.29531452e-01f, -2.44316477e-02f, -4.40311641e-01f, 2.38266483e-01f, 2.38262519e-01f, -7.89251328e-02f, 1.78956732e-01f,
  -1.77991584e-01f, 8.46852884e-02f, 3.54844004e-01f, 5.60583115e-01f, -2.40441233e-01f, -6.46584034e-01f, 1.54003918e-01f, 4.06418085e-01f, 3.20232540e-01f, -6.12570584e-01f,
  1.94748893e-01f, -1.26152769e-01f, 2.32966900e-01f, 2.16873661e-01f, -1.28685042e-01f, -1.38901591e-01f, 1.39723212e-01f, -1.63931146e-01f, -3.81889939e-01f, 1.75070345e-01f,
  -2.20602229e-01f, -5.08566536e-02f, 4.06788111e-01f, -1.96431950e-01f, -6.25395954e-01f, 9.27477181e-02f, 1.33989856e-01f, -9.87393111e-02f, 1.14620991e-01f, 8.56758714e-01f,
  -2.86216795e-01f, -2.63872653e-01f, -7.19886541e-01f, -2.64494084e-02f, 1.44547261e-02f, -1.86884731e-01f, 4.15312171e-01f, -7.47735500e-02f, -3.66557539e-01f, 4.30912107e-01f,
  1.28064394e-01f, 2.83966154e-01f, -4.19511050e-02f, -5.42183995e-01f, 1.90218955e-01f, -7.99483620e-04f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.98826003e-02f, 4.43652034e-01f, 5.75461507e-01f, 4.39917088e-01f, 2.25995909e-02f, 1.89458936e-01f, -4.71814185e-01f, 2.12541506e-01f, 6.26015842e-01f, -1.99138835e-01f,
  -1.10397887e+00f, -2.00881660e-01f, 2.55123317e-01f, 8.70562971e-01f, -6.26175757e-03f, 3.24919492e-01f, -4.20312226e-01f, 4.58585441e-01f, -3.06203783e-01f, 2.07924187e-01f,
  2.04475448e-01f, 4.53374177e-01f, 2.86936283e-01f, -2.81869531e-01f, -2.28085250e-01f, 1.63108662e-01f, -3.06028068e-01f, -4.84391183e-01f, 5.87807775e-01f, -4.63261791e-02f,
  8.81365389e-02f, 1.43621397e+00f, 4.85846996e-01f, 8.80745888e-01f, 2.96798438e-01f, 4.90266353e-01f, -3.35428081e-02f, 1.06820440e+00f, 1.32934213e-01f, -6.62178874e-01f,
  2.15368986e-01f, -7.34895766e-01f, 5.67508101e-01f, 3.17936569e-01f, 4.28518444e-01f, 1.35718256e-01f, 3.70600224e-01f, -2.17047125e-01f, -2.03898802e-01f, 1.67552009e-01f,
  -5.83543070e-02f, 5.22841692e-01f, 7.27581024e-01f, -5.11712581e-02f, 8.90201852e-02f, 5.16201258e-01f, -1.12827039e+00f, 8.10004115e-01f, 6.22500658e-01f, 2.25360110e-01f,
  -9.00781751e-02f, 5.30684114e-01f, -3.53043109e-01f, 1.02506804e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  5.70780635e-01f, -1.27879128e-01f, 5.16717374e-01f, 4.96690243e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.06260943e-01f, -7.24696696e-01f, -3.82221229e-02f, 2.21474841e-02f, 7.31319487e-02f, -2.05594331e-01f, 1.54089943e-01f, 9.29362848e-02f, -4.95031983e-01f, -1.53550014e-01f,
  8.51299763e-01f, -4.43388611e-01f, 4.11344349e-01f, 1.54847309e-01f, 1.85750723e-01f, -3.42779279e-01f, -2.06941485e-01f, -3.18369031e-01f, 1.77806929e-01f, -1.50620356e-01f,
  -2.91359961e-01f, 1.00633228e+00f, -5.15244722e-01f, 2.18936563e-01f, -5.69108464e-02f, 5.42288005e-01f, -9.13944691e-02f, 2.25269973e-01f, -2.20793247e-01f, 3.56079757e-01f,
  -5.09950578e-01f, -2.22044773e-02f, -6.26108050e-01f, 4.95700054e-02f, -1.01626143e-01f, 8.54154006e-02f, -3.80626827e-01f, 2.21913025e-01f, -2.31090143e-01f, 5.08431852e-01f,
  -3.96497250e-01f, 1.99880272e-01f, 1.97555721e-01f, -1.79653749e-01f, 3.47977728e-02f, 2.96677083e-01f, 4.46947902e-01f, -1.06742814e-01f, -3.62144709e-01f, -5.18168032e-01f,
  -8.37770283e-01f, 7.25155100e-02f, -6.19389772e-01f, 3.32569957e-01f, 3.04673195e-01f, 7.62495100e-02f, 2.65360266e-01f, 8.36366639e-02f, 3.48253846e-01f, 4.54376280e-01f,
  -2.70672888e-01f, 3.14951062e-01f, 3.65517199e-01f, -1.07186861e-01f, -1.95225477e-01f, -8.74415860e-02f, 5.28680861e-01f, -3.23845208e-01f, 2.45172121e-02f, -9.62864608e-02f,
  3.31064463e-01f, 4.98180419e-01f, -5.35579503e-01f, -1.01735033e-01f, 4.37084496e-01f, -2.71189809e-01f, 3.37300181e-01f, 2.88491338e-01f, -4.57394451e-01f, -1.15948141e-01f,
  1.86526567e-01f, -1.15338407e-01f, -1.76374316e-01f, -1.90709636e-01f, -2.35576898e-01f, 2.99341440e-01f, 1.96501896e-01f, 7.72910178e-01f, 6.80263698e-01f, 5.70011079e-01f,
  -1.79820538e-01f, 1.68076366e-01f, -3.13262463e-01f, 7.16791451e-02f, 3.84981275e-01f, 8.47177505e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -2.88922310e-01f, 8.66301000e-01f, 9.27990019e-01f, 8.48488986e-01f, 6.02117896e-01f, 1.23963602e-01f, 1.31092143e+00f, -4.38833207e-01f, 1.10011183e-01f, -7.75440112e-02f,
  2.38292649e-01f, -7.61002004e-02f, 6.91257596e-01f, -6.87090158e-02f, 6.75915599e-01f, -8.17383230e-01f, -6.29339635e-01f, -1.59527019e-01f, 5.84931314e-01f, -4.44841504e-01f,
  -7.65584946e-01f, 7.40259409e-01f, -6.47421479e-02f, 1.57264459e+00f, -7.44699955e-01f, 6.83941245e-01f, 7.70008981e-01f, -4.85647649e-01f, 4.21026200e-01f, 9.71184492e-01f,
  -1.37835801e-01f, 4.77051765e-01f, -3.64500314e-01f, -1.60852179e-01f, -7.24749684e-01f, 5.25607169e-01f, 1.04519233e-01f, -6.02754891e-01f, -7.35348523e-01f, -5.22094443e-02f,
  -7.63594329e-01f, -9.51602340e-01f, 1.98961169e-01f, -2.58294672e-01f, 1.08106101e+00f, -2.62390096e-02f, 3.73730473e-02f, 1.24473715e+00f, 3.35322708e-01f, 3.84424180e-01f,
  -6.91043362e-02f, 7.95722246e-01f, -1.02339432e-01f, 9.28478658e-01f, -5.47501147e-02f, -1.17232412e-01f, 1.06402695e+00f, -3.62365663e-01f, -1.01782012e+00f, 1.43760729e+00f,
  -4.02663082e-01f, 6.68226719e-01f, 2.88407564e-01f, 1.28560936e+00f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  6.35700285e-01f, -4.91901860e-02f, 3.55103612e-01f, 5.27320683e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -1.00719512e+00f, -1.62378833e-01f, 6.91779375e-01f, -1.52434003e+00f, -1.12721908e+00f, -7.86353767e-01f, 8.73040080e-01f, 2.79966384e-01f, -9.07455921e-01f, 7.34853029e-01f,
  2.46297374e-01f, 5.79162657e-01f, 2.70170152e-01f, -5.13805509e-01f, 3.28558445e-01f, -1.23546445e+00f, -8.62624109e-01f, 3.99621069e-01f, -5.32721244e-02f, 2.26327136e-01f,
  3.89719963e-01f, 5.23256063e-02f, 8.89626980e-01f, -6.73434794e-01f, 5.88607371e-01f, 1.62978306e-01f, 8.79757822e-01f, 1.15179324e+00f, 3.01725447e-01f, 6.52162969e-01f,
  -8.18433166e-01f, -2.72181034e-01f, 9.17037249e-01f, -6.71779633e-01f, -6.92325234e-02f, -3.97857428e-01f, 2.81683266e-01f, 3.98093969e-01f, 5.55224657e-01f, 2.29145750e-01f,
  6.18836462e-01f, -1.43200636e+00f, -1.68791604e+00f, 1.35607350e+00f, 5.30268669e-01f, -9.32741821e-01f, -5.71748257e-01f, -9.88907158e-01f, -5.61727285e-01f, 7.85981476e-01f,
  -6.13465011e-01f, 8.01622629e-01f, -8.91552806e-01f, 3.12634766e-01f, 9.77307618e-01f, -8.95313025e-01f, 6.06974304e-01f, -6.54948413e-01f, 6.51020706e-01f, -6.72618926e-01f,
  -1.57258177e+00f, 3.06256652e-01f, 3.70561719e-01f, -2.54778147e-01f, 8.63780081e-01f, -1.28123176e+00f, 4.13391262e-01f, -3.57066542e-01f, 9.39643323e-01f, 6.22991519e-03f,
  1.46932909e-02f, 3.94560307e-01f, -3.58696550e-01f, -1.96185037e-01f, 2.29013652e-01f, -8.55852783e-01f, -3.64553273e-01f, -4.50227141e-01f, 5.24201751e-01f, 1.21237516e-01f,
  -1.13295531e+00f, -1.71038732e-01f, -3.22100848e-01f, 8.00324976e-01f, 1.25157237e+00f, 1.30216181e-01f, -3.08207959e-01f, 8.47327113e-01f, 6.15050614e-01f, -5.86961865e-01f,
  8.04519415e-01f, -1.45261943e+00f, 4.77530301e-01f, -5.03575444e-01f, 3.90647538e-02f, -5.39692163e-01f, -1.11248314e+00f, 2.82398969e-01f, 8.29621017e-01f, 6.11484230e-01f,
  -2.19899282e-01f, -7.73425579e-01f, -2.66666949e-01f, -7.69710660e-01f, -2.02027470e-01f, 2.99934596e-01f, -2.98304930e-02f, 1.03624690e+00f, -2.88935751e-01f, -1.11949348e+00f,
  -1.39397287e+00f, 7.09382355e-01f, 2.76702166e-01f, -1.63766921e-01f, -1.92777634e-01f, -4.34862345e-01f, -6.04345724e-02f, -2.95523167e-01f, 6.09503686e-01f, 4.93381739e-01f,
  -1.06823635e+00f, 2.94220686e-01f, -1.00615192e-02f, -8.12148824e-02f, -6.56194866e-01f, 6.39598310e-01f, -3.39690655e-01f, 2.06518397e-01f, 9.00440693e-01f, -8.51980150e-01f,
  -4.99869138e-01f, -1.96366295e-01f, -1.14831448e+00f, -5.87371826e-01f, 4.09677595e-01f, -6.47664428e-01f, -3.55521113e-01f, 1.49010432e+00f, -4.41415131e-01f, -4.81506199e-01f,
  5.63095748e-01f, -4.26726639e-01f, -9.78579760e-01f, -1.34529144e-01f, 3.76033187e-01f, 7.71802962e-01f, -1.12459683e+00f, 6.84088886e-01f, 4.72302735e-01f, -7.11967051e-01f,
  -1.45789373e+00f, 9.74874616e-01f, 1.61821783e+00f, 1.31540122e-02f, -1.03910542e+00f, 8.32001328e-01f, -1.13998091e+00f, 2.67235130e-01f, -8.09151232e-01f, 2.94801891e-01f,
  6.22649252e-01f, -5.22087455e-01f, -2.46005401e-01f, 3.53994340e-01f, -4.39219803e-01f, 7.67844737e-01f, -7.55267441e-01f, 8.27422291e-02f, -1.00899827e+00f, 1.18911934e+00f,
  5.60664952e-01f, 2.91137397e-01f, -4.63298500e-01f, 6.83593392e-01f, 3.60666990e-01f, -1.17792475e+00f, -2.34366283e-01f, 1.02900743e+00f, 8.71725976e-01f, -3.85884374e-01f,
  9.64476109e-01f, 1.95671272e+00f, -2.32180774e-01f, 3.01240504e-01f, -1.03694773e+00f, -1.39957881e+00f, -4.00126338e-01f, -1.85020015e-01f, -4.66057420e-01f, -8.80785763e-01f,
  -1.05843976e-01f, 5.19524455e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.61433339e-01f, 3.49448882e-02f, 5.48738055e-02f, -5.22612631e-01f, -2.27948558e-02f, 1.23676233e-01f, 3.30736637e-02f, -4.22297478e-01f, -4.60165232e-01f, 6.89757645e-01f,
  -6.80155694e-01f, 1.59163862e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    