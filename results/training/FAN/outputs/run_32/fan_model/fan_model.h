/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.92844954e-02f, 4.16172780e-02f, 2.75132269e-01f, -1.02379359e-01f, -9.64236185e-02f, 1.60665214e-01f, 3.46646428e-01f, -7.72588253e-02f, -2.26324201e-02f, 4.11428977e-04f,
  4.36033681e-02f, 6.31120130e-02f, 8.63990411e-02f, 2.49209136e-01f, 4.61490788e-02f, 6.08482175e-02f, 1.37523830e-01f, 1.07042771e-02f, -9.01201889e-02f, -9.02355462e-02f,
  -2.14994308e-02f, -1.17564760e-01f, 3.43903840e-01f, -8.10187906e-02f, 5.08922106e-03f, -1.39142051e-01f, -1.65396988e-01f, -8.12448096e-03f, -1.37794897e-01f, -5.73990308e-02f,
  5.21915443e-02f, -8.28613713e-02f, 8.54007080e-02f, -5.58274090e-02f, 3.47121470e-02f, 4.65897657e-02f, 1.00512758e-01f, 5.30552901e-02f, -2.53130570e-02f, -1.86169725e-02f,
  1.38457324e-02f, 4.97747436e-02f, -6.96442127e-02f, -5.45900762e-02f, 5.27885929e-02f, -2.41472516e-02f, -5.16531840e-02f, 6.82032779e-02f, -2.80646345e-04f, 6.00774102e-02f,
  4.67636064e-02f, 8.07240605e-02f, 2.55801324e-02f, -6.52636066e-02f, -4.42097075e-02f, 6.65250421e-02f, 5.15579134e-02f, -8.11216515e-03f, 1.09769497e-03f, -3.16170640e-02f,
  -7.72272125e-02f, 4.64693680e-02f, 2.72269920e-02f, -5.17041944e-02f, -7.07507208e-02f, -9.39482171e-03f, 2.13568136e-02f, -3.31780389e-02f, 1.04341939e-01f, -1.37215974e-02f,
  -8.84485841e-02f, 8.50840509e-02f, -5.26866224e-03f, 1.21066220e-01f, 1.47047965e-02f, 3.71647924e-02f, 6.93119615e-02f, 3.47985886e-02f, 8.65209550e-02f, 7.79810846e-02f,
  -6.30459860e-02f, 9.50901806e-02f, 2.01323926e-02f, 1.28374681e-01f, -8.80087763e-02f, 6.47695363e-02f, -1.06050307e-03f, -4.78900522e-02f, 3.35453488e-02f, 3.19722332e-02f,
  -2.74341792e-01f, -3.70073140e-01f, -1.02963738e-01f, 9.34102945e-03f, 2.95611261e-03f, 4.00039814e-02f, 1.78708006e-02f, -5.75277358e-02f, -7.52096325e-02f, -4.00660187e-02f,
  1.20755352e-01f, -1.48525713e-02f, -9.64454561e-02f, 5.36987074e-02f, 8.84937402e-03f, 3.85017321e-02f, 1.01845250e-01f, -2.82759722e-02f, -2.49683429e-02f, -2.98195127e-02f,
  3.60922003e-03f, -1.39963478e-01f, 2.04570200e-02f, 4.91455547e-04f, 7.86769837e-02f, -8.93218908e-03f, -9.67425555e-02f, -3.66984401e-03f, 1.85322277e-02f, -3.01017575e-02f,
  -2.32462212e-01f, 2.26831324e-02f, -7.61441514e-02f, -1.23502649e-01f, 1.26325235e-01f, -1.58275202e-01f, -2.53996521e-01f, 4.14836518e-02f, 3.50477621e-02f, -1.48484290e-01f,
  -8.25412124e-02f, -3.67892021e-03f, -6.71376586e-02f, -4.25883234e-01f, -2.86554933e-01f, -1.20579258e-01f, -2.95208812e-01f, -1.12463094e-01f, 9.71250534e-02f, -3.87307182e-02f,
  6.30936399e-02f, -1.28776789e-01f, -1.52605757e-01f, 1.60030462e-02f, 2.28263997e-02f, 1.30834252e-01f, 7.40123540e-02f, -6.30486459e-02f, -1.06187994e-02f, -5.81091568e-02f,
  -7.69808516e-02f, 7.18462318e-02f, 2.69886851e-02f, 3.45589630e-02f, 6.16934448e-02f, -1.70794558e-02f, -4.53094989e-02f, -1.61206558e-01f, 2.93808281e-02f, 3.68106104e-02f,
  5.97053058e-02f, 2.44756509e-02f, -6.52844459e-03f, -3.85089293e-02f, -5.84749281e-02f, 7.21963719e-02f, -1.61370374e-02f, -9.63067785e-02f, 3.01305819e-02f, -3.85276750e-02f,
  1.21103069e-02f, 3.06317434e-02f, 8.10994133e-02f, -3.99203859e-02f, 8.29000399e-02f, 8.14832747e-04f, -7.13054836e-02f, -1.35520045e-02f, 8.12363327e-02f, -4.10963781e-02f,
  3.97779867e-02f, -4.24697027e-02f, -7.48638809e-02f, -1.26523012e-02f, -9.85468626e-02f, 4.29327600e-03f, 6.51478544e-02f, -1.10312756e-02f, -4.10140939e-02f, -4.37544212e-02f,
  -2.40447149e-02f, -4.93695252e-02f, 5.71439266e-02f, 7.13410368e-03f, 5.52513972e-02f, -3.56053039e-02f, -4.84103262e-02f, -6.70233602e-03f, -3.67476456e-02f, 5.25602996e-02f,
  -2.62466632e-02f, 8.06536898e-03f, 6.48455322e-02f, 3.04084122e-02f, -5.02769612e-02f, 7.12080952e-03f, 3.32113318e-02f, -2.85654198e-02f, -8.43797717e-03f, -4.27138666e-03f,
  9.74714085e-02f, 5.82932122e-02f, 4.29447740e-02f, -5.43263108e-02f, 4.70675975e-02f, -4.87839170e-02f, -2.14382093e-02f, 2.74184868e-02f, 4.48001139e-02f, -3.75964344e-02f,
  2.05997527e-02f, -3.65066901e-02f, -3.21847722e-02f, 3.22504826e-02f, 9.65780765e-03f, -1.57722160e-02f, -1.16626807e-02f, 1.34000584e-01f, 7.09920079e-02f, 1.20170601e-02f,
  5.62586971e-02f, -3.82717215e-02f, -1.47878649e-02f, -4.80361283e-02f, -2.15039849e-02f, 9.21660662e-03f, 5.04079424e-02f, -7.88829401e-02f, -4.62615266e-02f, 1.45925269e-01f,
  2.05401227e-01f, -2.16548383e-01f, -3.56830865e-01f, 1.43734172e-01f, 1.63121030e-01f, -4.34382036e-02f, -7.86056295e-02f, 3.16819735e-02f, 1.92242675e-02f, -7.76342452e-02f,
  7.75991529e-02f, 3.95306870e-02f, -4.94789124e-01f, 2.34246608e-02f, 2.57046312e-01f, -3.99003834e-01f, 2.23227262e-01f, 2.84922831e-02f, -1.74301147e-01f, 2.07096368e-01f,
  2.91028805e-02f, 5.63075542e-02f, -2.70747602e-01f, 6.51236624e-02f, 5.36901038e-03f, 9.75260735e-02f, 2.54129618e-01f, -1.81076169e-01f, 1.40340820e-01f, -1.04156360e-02f,
  -1.22668652e-03f, -4.17074338e-02f, -9.03216526e-02f, 6.02960363e-02f, 1.44171581e-01f, 8.44099596e-02f, 5.66838570e-02f, -3.15072946e-02f, 1.33351043e-01f, 7.10109249e-02f,
  3.07316259e-02f, 1.66324347e-01f, -1.30472761e-02f, -1.25688508e-01f, 2.98025161e-02f, 7.17881769e-02f, -7.04335347e-02f, -4.13228422e-02f, 4.88922596e-02f, -7.59170353e-02f,
  -1.12485424e-01f, 5.44199906e-02f, 3.22558954e-02f, 1.11348256e-01f, 5.88239878e-02f, -1.45622110e-02f, -4.76643853e-02f, -3.50625403e-02f, 8.33441243e-02f, 4.27644886e-02f,
  1.98430009e-02f, 1.60902441e-01f, 8.91673639e-02f, 9.77486931e-03f, 3.39366011e-02f, -1.31564721e-01f, 8.74929279e-02f, 1.31153822e-01f, -4.87105176e-02f, 5.76740690e-03f,
  6.43397197e-02f, 2.35616341e-02f, 4.58059609e-02f, -4.06674705e-02f, 7.51180649e-02f, -3.13217640e-02f, -1.86558478e-02f, -7.66330631e-05f, 7.24440366e-02f, -1.20707350e-02f,
  -1.32827219e-02f, 2.26295111e-03f, -2.03746688e-02f, 1.51470408e-01f, -1.97379384e-02f, -2.64897943e-02f, -1.99081562e-03f, 6.69343118e-03f, -9.44795460e-03f, -8.82128701e-02f,
  -6.30339608e-03f, 1.80432066e-01f, 6.15076795e-02f, -3.59978601e-02f, 1.12762898e-01f, -6.62445202e-02f, -3.74627784e-02f, -5.61356768e-02f, -6.62670583e-02f, -6.09228835e-02f,
  8.04422051e-02f, 3.32494862e-02f, 5.08433692e-02f, 2.12587509e-02f, 5.72989099e-02f, -7.86014497e-02f, 4.21424285e-02f, 1.64785385e-02f, 4.04327102e-02f, 9.54827070e-02f,
  4.42408212e-02f, 9.62310508e-02f, 3.85803245e-02f, 6.07112795e-02f, 1.77452117e-01f, -3.29792723e-02f, 1.34752929e-01f, -8.44959468e-02f, -6.81516307e-04f, -1.52145401e-02f,
  -2.43742242e-01f, 3.71419229e-02f, -9.55834687e-02f, 7.88396969e-02f, -3.80308256e-02f, 2.98498403e-02f, 8.74603260e-03f, 2.15741724e-01f, -9.88783017e-02f, 2.26239637e-01f,
  1.66434839e-01f, -7.80767873e-02f, -1.31939560e-01f, 3.25946867e-01f, -3.09880167e-01f, -1.67334571e-01f, 2.47583255e-01f, 1.12163588e-01f, -1.16074316e-01f, 2.45089740e-01f,
  -8.59163254e-02f, 2.34949648e-01f, -9.41595882e-02f, 1.07025675e-01f, 2.87178829e-02f, 8.59941021e-02f, 1.70906276e-01f, -2.04182714e-01f, 1.89616919e-01f, 3.76471952e-02f,
  -3.74158397e-02f, -2.81516258e-02f, -1.49550289e-02f, -1.93267718e-01f, 8.55273455e-02f, 1.02644991e-02f, 3.52299772e-02f, -1.04657613e-01f, 2.08419580e-02f, 8.68093781e-03f,
  -1.06168007e-02f, -6.10411279e-02f, -2.26192549e-02f, 5.33825196e-02f, 5.93978688e-02f, 2.53897458e-02f, -3.32836173e-02f, 4.87310104e-02f, 3.69627401e-02f, -8.49913731e-02f,
  -4.81151678e-02f, 6.39708117e-02f, 3.96920443e-02f, -4.40325867e-03f, -1.02795124e-01f, 3.24360728e-02f, -2.65427656e-03f, -1.60364788e-02f, 7.09335729e-02f, 5.60496487e-02f,
  -2.06851847e-02f, 2.83405613e-02f, -1.06472587e-02f, 2.30527725e-02f, -4.29927483e-02f, 4.29694392e-02f, 4.91392892e-03f, -5.87914549e-02f, -2.68761255e-02f, -1.64024774e-02f,
  4.31127176e-02f, 3.50280199e-03f, -7.97979534e-03f, 4.68583554e-02f, 6.86602965e-02f, 9.77294669e-02f, -7.55166123e-03f, 1.97598841e-02f, 6.87181428e-02f, 7.63533711e-02f,
  1.55933970e-03f, 5.49963191e-02f, 1.22156590e-02f, -4.29819524e-02f, -2.19568163e-02f, -4.04477306e-02f, 1.05447188e-01f, 1.50598716e-02f, -2.94611845e-02f, 7.84145296e-02f,
  7.67942071e-02f, 8.59623849e-02f, 2.62037776e-02f, -2.13811826e-02f, 4.47124094e-02f, -6.87094731e-03f, -5.25944568e-02f, 2.45728288e-02f, 6.61638826e-02f, -2.51975600e-02f,
  1.22217819e-01f, 6.47770688e-02f, -1.47439092e-02f, 5.81301097e-03f, 5.05617149e-02f, 8.31309259e-02f, 4.23498377e-02f, 4.81200330e-02f, 3.18134539e-02f, 5.02309902e-03f,
  2.37781112e-03f, -1.03202969e-01f, 3.57278325e-02f, -5.69328479e-02f, 5.82755655e-02f, -1.75497960e-02f, 1.01802856e-01f, -5.83366416e-02f, -2.18012147e-02f, 3.21744755e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.62064224e-01f, -5.43757388e-03f, -1.27142072e-01f, -3.39500867e-02f, -4.22411591e-01f, 3.26464400e-02f, 4.42355871e-01f, -4.26482707e-01f, 1.21989638e-01f, -1.19342329e-03f,
  -2.73451000e-01f, 3.58239383e-01f, 1.37361482e-01f, -1.89680353e-01f, 3.49621862e-01f, 3.07240039e-01f, 4.56931740e-02f, 2.65914112e-01f, -7.86316406e-04f, -2.03729253e-02f,
  -8.42502937e-02f, -1.66816004e-02f, -5.78082204e-02f, -4.14287269e-01f, -1.37448549e-01f, -2.74209380e-01f, -1.37047209e-02f, -9.64087993e-02f, -2.43515253e-01f, -7.10804239e-02f,
  -1.64298072e-01f, 8.24587643e-02f, -7.93558583e-02f, 1.52589843e-01f, 7.51110865e-03f, -9.81088504e-02f, 3.92668284e-02f, 1.40469475e-02f, 2.52099596e-02f, 1.25905424e-01f,
  1.36506245e-01f, 8.21584985e-02f, 2.20542364e-02f, -5.91436327e-02f, 2.38555074e-02f, -8.04510638e-02f, 3.32828499e-02f, -1.49756089e-01f, 1.65811777e-02f, -1.03468522e-01f,
  -2.14923881e-02f, 7.00524135e-04f, 2.08455816e-01f, 9.87215340e-02f, 9.34494659e-02f, -4.99751084e-02f, 3.34242620e-02f, -5.35015687e-02f, -2.68702209e-02f, -3.41068879e-02f,
  -2.00490169e-02f, -1.65793467e-02f, -3.09173521e-02f, -6.59477487e-02f, -9.57557559e-03f, -1.48066401e-01f, 1.45994946e-01f, -5.74486703e-02f, 1.62196890e-01f, 6.93270713e-02f,
  -6.31932467e-02f, 1.75058618e-02f, -9.45263822e-03f, 5.60593568e-02f, 1.20608017e-01f, 1.68776382e-02f, 1.36361003e-01f, -1.16103046e-01f, -5.81986196e-02f, -5.26962094e-02f,
  3.22448537e-02f, 4.54825275e-02f, 2.73747705e-02f, -3.90480296e-03f, 7.39284381e-02f, -1.92475170e-02f, 2.07081418e-02f, 3.51824090e-02f, -5.47934100e-02f, 8.09125006e-02f,
  9.40472179e-04f, 2.74108917e-01f, 5.19870520e-02f, 9.33340639e-02f, -5.83399972e-03f, 2.16200035e-02f, -5.89457825e-02f, -5.18788137e-02f, 4.94134240e-02f, 2.87898630e-02f,
  -1.83100492e-01f, -5.73468842e-02f, 1.23023093e-02f, -2.22059861e-02f, -4.51641530e-02f, 7.65010342e-02f, 4.53751981e-02f, 5.92412166e-02f, 8.82630050e-03f, -9.19786245e-02f,
  -5.26974574e-02f, 1.11314561e-02f, 8.77053961e-02f, -5.22880703e-02f, -3.54366973e-02f, 5.22471033e-02f, -4.30208771e-03f, -8.06847401e-03f, 1.41603108e-02f, 3.52308042e-02f,
  2.58264929e-01f, 3.53826195e-01f, 1.90997735e-01f, 2.76539624e-01f, -8.31430554e-02f, -2.44270340e-01f, -3.17813307e-01f, 3.25274505e-02f, 3.77882093e-01f, 1.09921433e-01f,
  -3.77706975e-01f, 6.35285974e-01f, -3.82864565e-01f, 2.17081621e-01f, -6.15037680e-01f, -4.42211688e-01f, -1.14600569e-01f, -7.58579150e-02f, -1.16439257e-02f, 1.28712401e-01f,
  -1.29832998e-01f, -2.57355541e-01f, -6.80529997e-02f, -3.32858413e-02f, 1.49120748e-01f, 3.21071059e-01f, -3.45924109e-01f, -7.81305209e-02f, 2.33458817e-01f, -4.22960520e-02f,
  7.25255832e-02f, 1.15027785e-01f, 1.46144077e-01f, 1.01731056e-02f, -2.59900279e-02f, -8.69668052e-02f, -6.24638684e-02f, -1.87152661e-02f, -7.67887905e-02f, 7.01131225e-02f,
  -4.71471958e-02f, 1.03010222e-01f, 1.04951099e-01f, 3.78981940e-02f, 1.92111880e-01f, 1.96224868e-01f, 1.52928725e-01f, 5.91886155e-02f, 1.29326299e-01f, 1.88104697e-02f,
  5.95381968e-02f, 7.23929927e-02f, 3.22541371e-02f, 7.55182374e-03f, 3.39951515e-02f, 4.75976653e-02f, 2.75162663e-02f, 4.19356301e-02f, 5.34582101e-02f, 7.89724439e-02f,
  -1.07925609e-01f, -1.36149690e-01f, -7.97848925e-02f, -4.70508076e-02f, 4.10328880e-02f, 4.16451367e-03f, -3.56025696e-02f, -1.20803140e-01f, 4.89911251e-02f, -8.22567120e-02f,
  -2.05552410e-02f, 1.04567677e-01f, -9.88857746e-02f, 5.94034307e-02f, -8.33505839e-02f, 5.57363406e-02f, -6.65380955e-02f, -7.01344237e-02f, -4.49195392e-02f, 7.90616646e-02f,
  -4.10065353e-02f, -6.43898845e-02f, -1.81029618e-01f, -6.41625673e-02f, 3.06455791e-02f, 1.06511846e-01f, 1.26980454e-01f, 8.77095163e-02f, -4.25880738e-02f, -5.77630177e-02f,
  -7.24527359e-01f, -3.65151882e-01f, -8.87079537e-02f, 8.76364112e-02f, 9.25154537e-02f, 7.74040222e-02f, -1.81028768e-02f, 1.10444613e-01f, 8.05124640e-02f, 2.59612985e-02f,
  -1.96195135e-04f, -2.13998109e-02f, -8.49719867e-02f, -5.18462341e-03f, -2.01621670e-02f, -1.33404776e-01f, -1.26215711e-01f, 2.30108481e-02f, -8.58446881e-02f, -1.27172973e-02f,
  5.99196069e-02f, -3.60708535e-02f, 7.99563713e-03f, 8.00518319e-02f, 7.69185796e-02f, 1.06274532e-02f, 2.24141069e-02f, 1.81506444e-02f, -3.41260433e-02f, -1.38551280e-01f,
  1.10612594e-01f, -7.91980475e-02f, -1.72956049e-01f, -1.46156512e-02f, -1.02045462e-01f, -2.29555547e-01f, -1.17049791e-01f, -1.95727423e-01f, 9.43791494e-02f, -8.78394693e-02f,
  -5.11316257e-03f, 4.04091924e-01f, 3.47429246e-01f, -6.03018515e-02f, 5.70006251e-01f, 1.27120703e-01f, -4.59908634e-01f, -4.12073620e-02f, 2.82257497e-02f, -2.00981438e-01f,
  -1.34810016e-01f, -3.32734525e-01f, 1.26039132e-01f, -2.65442818e-01f, -2.19746798e-01f, -2.62758452e-02f, 1.53225631e-01f, -1.86740682e-02f, -2.54508227e-01f, 4.22594436e-02f,
  -1.86127961e-01f, -2.85089076e-01f, -1.88613027e-01f, -6.55096844e-02f, -1.44963577e-01f, 9.28052515e-02f, 1.88596116e-03f, 7.99125582e-02f, 8.38020071e-02f, 4.83270213e-02f,
  9.54754800e-02f, 5.42328171e-02f, -2.04947162e-02f, 2.06415623e-01f, 2.30084863e-02f, -1.01851545e-01f, -2.99304854e-02f, -8.72921348e-02f, -2.78447680e-02f, 1.24306627e-01f,
  -3.81566677e-03f, -2.70512439e-02f, -2.58774817e-01f, -5.57730868e-02f, -1.60827845e-01f, -7.35711679e-02f, -1.12772696e-02f, -5.78291118e-02f, -7.64559433e-02f, -9.45587084e-02f,
  -3.83481309e-02f, 2.72217970e-02f, -9.96748731e-02f, 2.15505697e-02f, -1.73058257e-01f, 4.09195805e-03f, -1.31794021e-01f, -2.11860687e-02f, -4.46863584e-02f, -1.46648914e-01f,
  -1.24197707e-01f, -4.48486283e-02f, -1.40989088e-02f, -1.04326215e-02f, -3.64189334e-02f, -1.88609436e-02f, 2.09705327e-02f, 9.79168415e-02f, 6.15859963e-02f, 4.76249233e-02f,
  1.25220105e-01f, -8.56253058e-02f, 3.07619497e-02f, 1.50091611e-02f, -5.24617173e-02f, 1.13941856e-01f, 2.16662399e-02f, -4.16603126e-02f, -9.24604479e-03f, -5.02544530e-02f,
  1.53453305e-01f, -2.48892665e-01f, -1.30408898e-01f, -7.26323947e-02f, 5.38437851e-02f, -6.05420433e-02f, -7.39729628e-02f, 2.08744686e-02f, -8.79391283e-02f, 1.28739076e-02f,
  -1.07390404e-01f, 3.03506237e-02f, -1.52198803e-02f, -5.60311042e-02f, 2.21336246e-01f, -1.44027884e-03f, -7.30559006e-02f, -4.48773196e-03f, -7.07932264e-02f, -3.31325158e-02f,
  -7.58769885e-02f, -2.66360249e-02f, -8.74606445e-02f, -3.42744263e-03f, -1.35813534e-01f, -2.95223501e-02f, 1.44938424e-01f, -2.37239320e-02f, 1.34340078e-02f, 6.47716410e-03f,
  1.63480088e-01f, -9.47776213e-02f, 5.35114288e-01f, 2.06945688e-01f, 1.06459878e-01f, 1.58441171e-01f, 2.21865028e-01f, 8.42625275e-02f, 4.54188704e-01f, -4.00034338e-01f,
  -3.75909895e-01f, 2.59461135e-01f, 3.63847688e-02f, -3.05065811e-01f, 3.43842596e-01f, 2.09057182e-01f, -1.63444564e-01f, 1.27973884e-01f, 2.19758842e-02f, 2.49936767e-02f,
  3.91931236e-02f, -4.06874716e-01f, -2.01066658e-02f, -4.43806738e-01f, -1.88118681e-01f, -6.12130798e-02f, -2.60170966e-01f, 1.28128394e-01f, -4.06973481e-01f, 2.72498652e-02f,
  -1.54764473e-01f, 1.51194304e-01f, -5.30316085e-02f, 2.36324854e-02f, -6.00747317e-02f, 2.03741621e-02f, 6.35585636e-02f, 1.45473331e-01f, 6.58196062e-02f, 1.73616841e-01f,
  -2.88401544e-02f, -5.47178276e-02f, -1.80580929e-01f, 3.08928546e-02f, 5.64910807e-02f, -6.73412979e-02f, 5.82563058e-02f, -9.13393125e-02f, 1.36037216e-01f, 1.83658943e-01f,
  5.53238653e-02f, 3.63682061e-02f, -5.09418920e-02f, 4.56863875e-03f, 8.26199204e-02f, -2.05602825e-01f, 3.80017050e-02f, 4.22827750e-02f, 5.01919538e-02f, 4.84816507e-02f,
  5.33771049e-03f, 1.38738230e-01f, 2.74666175e-02f, 5.49156740e-02f, -4.80832085e-02f, -1.03880309e-01f, -4.11567353e-02f, -8.57756361e-02f, 1.59955576e-01f, -5.42938104e-03f,
  -6.43614447e-03f, -6.76314607e-02f, 6.55668303e-02f, -4.42354009e-02f, -7.48079792e-02f, 6.85330406e-02f, -1.47926047e-01f, -8.78732768e-04f, -3.09841894e-02f, 3.16003151e-02f,
  7.63113350e-02f, 3.25920619e-02f, -7.76272491e-02f, 1.99676547e-02f, -2.08558254e-02f, 7.59171695e-02f, -1.48408026e-01f, 1.28773808e-01f, 3.59556377e-02f, -7.11336061e-02f,
  -4.79599054e-04f, 7.48505965e-02f, 7.51301553e-03f, -9.45895389e-02f, 7.98508897e-02f, -1.67712376e-01f, 3.40612717e-02f, -1.22187480e-01f, 1.15536831e-01f, -2.42375745e-03f,
  2.25675832e-02f, -4.27494049e-02f, 2.71051582e-02f, -5.72387092e-02f, -2.84778085e-02f, -8.92549306e-02f, 5.24560474e-02f, -6.99075907e-02f, -2.32814163e-01f, -7.99580142e-02f,
  -1.09989338e-01f, 3.09861125e-03f, 2.15204388e-01f, 2.51602549e-02f, -8.64630640e-02f, 4.79372218e-02f, 2.47020930e-01f, -5.90339415e-02f, -1.03172667e-01f, -3.45975794e-02f,
  6.17933422e-02f, -1.89540703e-02f, 2.21128449e-01f, 4.48537141e-01f, -3.08796346e-01f, -8.33953798e-01f, -5.61613977e-01f, 1.35340676e-01f, 1.82644650e-02f, -1.53541997e-01f,
  -1.01669639e-01f, 8.17697197e-02f, 1.66749060e-01f, 2.21792743e-01f, 3.07887614e-01f, 1.21549107e-01f, 2.61110246e-01f, -2.59984910e-01f, 1.31295696e-01f, 1.36465639e-01f,
  2.67089307e-01f, 1.86672613e-01f, 3.55794191e-01f, -1.94816291e-01f, 6.05658628e-02f, 2.12011144e-01f, 4.92151976e-01f, -1.15878291e-01f, 1.18142195e-01f, -7.76818469e-02f,
  -1.58088520e-01f, 1.78145245e-01f, -1.04587100e-01f, 5.28307036e-02f, 7.19094649e-02f, -6.86601698e-02f, -2.20758289e-01f, -6.52536228e-02f, -3.83351706e-02f, 1.77809685e-01f,
  -4.20870259e-02f, 1.15447842e-01f, -3.25790159e-02f, -2.16562226e-02f, 6.09662123e-02f, 5.42804636e-02f, 1.67132616e-02f, -1.26776487e-01f, -4.58926037e-02f, 3.40056121e-02f,
  -4.46648747e-02f, 7.08578080e-02f, 6.22354820e-02f, 3.30324806e-02f, 1.70519516e-01f, 7.46421143e-02f, 2.04483178e-02f, 7.67536536e-02f, 6.00786991e-02f, -1.34492829e-01f,
  1.61088351e-02f, -3.75121795e-02f, -1.15382954e-01f, -5.13151772e-02f, -2.77720727e-02f, -1.60142110e-04f, -1.50209799e-01f, -2.10523140e-02f, -6.76368549e-02f, -1.29051223e-01f,
  3.72910984e-02f, -3.80299166e-02f, -6.15847930e-02f, -8.32173154e-02f, 1.63943425e-01f, -1.18277058e-01f, 4.25938517e-02f, 8.89008641e-02f, 5.39937355e-02f, -5.03207855e-02f,
  4.65347059e-02f, 4.75815721e-02f, -9.19028521e-02f, -3.83196361e-02f, 3.04421149e-02f, 2.27211304e-02f, 1.92683280e-01f, 1.94487944e-01f, -1.20645575e-01f, -3.80051844e-02f,
  8.80445763e-02f, 4.92446721e-01f, 7.08462074e-02f, -2.01091260e-01f, -6.66190637e-03f, -6.07936010e-02f, 1.12507500e-01f, 2.94233784e-02f, 2.69990116e-01f, -2.74058860e-02f,
  1.31099865e-01f, -9.58233327e-02f, 2.80673746e-02f, 1.15760945e-01f, 2.71471664e-02f, 1.08995780e-01f, 2.38121301e-02f, 3.43923271e-03f, 1.76399127e-02f, 4.94409576e-02f,
  1.72448695e-01f, -1.51027650e-01f, 1.30712222e-02f, -1.53098717e-01f, -6.21121936e-02f, 7.75211398e-03f, -1.81031778e-01f, -1.07086375e-01f, -3.77890468e-02f, 2.00367440e-03f,
  7.87226856e-01f, -5.55499732e-01f, -1.34526402e-01f, 4.05194432e-01f, 4.58286524e-01f, 2.36485392e-01f, 3.96140516e-01f, -8.42817202e-02f, 5.36107384e-02f, -7.07442105e-01f,
  2.28000388e-01f, -2.01702118e-01f, -1.08618058e-01f, -6.48313947e-03f, 6.37305140e-01f, -1.84169695e-01f, 1.00626864e-01f, -1.62848756e-01f, 1.14248268e-01f, 1.06145978e-01f,
  2.03870192e-01f, 4.76826102e-01f, 1.80588812e-01f, -1.92770325e-02f, 1.37139797e-01f, 1.02037902e-03f, 5.96771091e-02f, -1.75098896e-01f, -4.93989401e-02f, 5.48778512e-02f,
  2.04274580e-01f, 5.20686619e-02f, 4.66716513e-02f, -7.52746984e-02f, -3.88789661e-02f, -8.57006907e-02f, 2.53318250e-02f, 8.08493933e-04f, 6.00354560e-02f, -1.24866001e-01f,
  -6.51290491e-02f, -5.03179757e-03f, 7.76267722e-02f, 4.75573950e-02f, 1.27302647e-01f, 5.05383387e-02f, 7.40759671e-02f, -4.65842634e-02f, -9.66686606e-02f, -8.22828785e-02f,
  8.04965477e-03f, -7.65649974e-02f, 1.39974102e-01f, -1.50163352e-01f, 7.95607641e-03f, -1.59512814e-02f, -1.36039615e-01f, 1.47708943e-02f, -4.16530222e-02f, -7.60529041e-02f,
  3.88162658e-02f, -1.46158874e-01f, -8.11440200e-02f, 8.63903835e-02f, -4.27317657e-02f, -1.43244751e-02f, 9.55017358e-02f, -6.85271854e-03f, -9.34913475e-03f, 3.11487988e-02f,
  2.84099057e-02f, -1.63834002e-02f, -4.88405898e-02f, 3.18081714e-02f, -1.15711488e-01f, -5.76867871e-02f, 9.40526277e-02f, 8.39625821e-02f, -1.89204738e-02f, 5.37463389e-02f,
  -4.16872874e-02f, -1.72277335e-02f, -2.05868557e-01f, -6.16723718e-03f, -6.66941330e-02f, 2.32641865e-03f, -2.97463499e-02f, -6.27395287e-02f, 1.54316677e-02f, 7.87756816e-02f,
  -2.54282922e-01f, -7.44670808e-01f, -7.37041757e-02f, 1.08112067e-01f, -4.31121066e-02f, -4.22860421e-02f, -5.27308211e-02f, -6.31003901e-02f, -1.27634540e-01f, -2.79640649e-02f,
  5.70808388e-02f, 1.77679758e-03f, -5.89055233e-02f, 1.58774540e-01f, -8.59052036e-03f, 1.56257134e-02f, -6.67928606e-02f, -1.00210598e-02f, -4.00730520e-02f, -1.19276762e-01f,
  4.31431197e-02f, -4.80490588e-02f, 4.35810350e-02f, 5.44469319e-02f, -6.89917579e-02f, -4.17393781e-02f, -9.69602913e-02f, -1.28610600e-02f, -1.18023947e-01f, -1.11666426e-01f,
  1.03940737e+00f, 3.06851357e-01f, 7.30261058e-02f, 2.86668569e-01f, 1.49507329e-01f, 5.06760359e-01f, 3.67556781e-01f, 3.63423467e-01f, 7.25274086e-01f, 1.79010242e-01f,
  1.04250591e-02f, -2.48832516e-02f, -1.11776792e-01f, 2.22149059e-01f, -1.28395692e-01f, 1.00902729e-01f, 3.64435285e-01f, 2.03690633e-01f, 3.01661640e-01f, 2.05299675e-01f,
  2.04628840e-01f, 1.87715992e-01f, -3.74615967e-01f, -3.90254557e-02f, 2.04570055e-01f, -3.25832181e-02f, -3.54989082e-01f, -1.48622170e-01f, -2.02529445e-01f, 7.64258951e-02f,
  -3.13018598e-02f, 1.49324715e-01f, -7.66267851e-02f, 9.86964721e-03f, -7.35709956e-03f, 3.54610905e-02f, -1.28777415e-01f, -1.88881069e-01f, -2.67407037e-02f, 1.04717845e-02f,
  5.52979670e-02f, 2.57912148e-02f, 1.31346881e-01f, -6.05430715e-02f, 1.46952957e-01f, 4.79144603e-02f, 1.87533107e-02f, 9.21970755e-02f, -9.41862538e-02f, 4.51525152e-02f,
  -3.42315398e-02f, -5.53453788e-02f, 9.67643857e-02f, 1.48494802e-02f, -2.16285256e-03f, 1.38825968e-01f, -3.16890795e-03f, -2.36227997e-02f, 2.35603843e-02f, 1.43000290e-01f,
  6.29360452e-02f, 8.80620629e-02f, 9.26430300e-02f, -8.68210420e-02f, 7.18040913e-02f, -3.18265782e-04f, 5.21014631e-02f, -1.14807166e-01f, 3.03261634e-02f, 1.44719118e-02f,
  -6.29320517e-02f, 5.28364442e-02f, -1.73681471e-02f, -9.27350949e-03f, 4.63342965e-02f, -3.47845927e-02f, -1.15216905e-02f, 1.35629922e-02f, -3.35055552e-02f, 4.08029929e-02f,
  -4.49353084e-02f, 2.69627925e-02f, -1.30634770e-01f, 6.61555529e-02f, 5.14151976e-02f, -3.74805741e-02f, 5.59077822e-02f, 1.34485941e-02f, -5.27694859e-02f, -2.45171208e-02f,
  5.28891310e-02f, 8.46664459e-02f, -4.73974161e-02f, -5.96095286e-02f, -9.38137546e-02f, -3.03321127e-02f, 6.91279769e-03f, 1.25907049e-01f, 4.54817414e-02f, -2.67553292e-02f,
  -1.01283006e-02f, -4.26651053e-02f, -7.92600214e-02f, 6.97500929e-02f, -7.96357170e-02f, 5.98992258e-02f, -4.24163193e-02f, 3.15733328e-02f, 6.11180402e-02f, -7.07020387e-02f,
  -1.89843285e-03f, 4.00862172e-02f, -2.23421063e-02f, -6.83389902e-02f, 2.13444736e-02f, -6.45759627e-02f, 6.93349391e-02f, 2.33636256e-02f, -6.72159791e-02f, 7.86079913e-02f,
  -1.14149237e+00f, 1.11537896e-01f, -4.63214517e-01f, 4.54861000e-02f, -2.57253557e-01f, -3.68259192e-01f, 1.30153537e-01f, -3.84095348e-02f, 3.07069998e-02f, 1.69343635e-01f,
  1.53742611e-01f, -2.42049426e-01f, 1.99717030e-01f, 1.34660244e-01f, -4.11391765e-01f, 1.55849159e-01f, -1.85557738e-01f, -3.29790898e-02f, -2.73918211e-02f, -1.49584875e-01f,
  -1.16642818e-01f, 2.78224386e-02f, -2.99081743e-01f, 1.65447280e-01f, -3.02346051e-01f, -4.58461717e-02f, -1.38665080e-01f, 8.12048987e-02f, -1.29722029e-01f, -4.35331054e-02f,
  -1.62498564e-01f, 2.63924062e-01f, -3.07185650e-02f, -8.38757977e-02f, -1.92234188e-01f, -9.24059451e-02f, -1.45125613e-01f, 7.82448202e-02f, 1.83644220e-02f, -6.47597536e-02f,
  4.55662906e-02f, -2.84788534e-02f, 7.24623725e-02f, 4.72930856e-02f, 7.41906390e-02f, 1.63463615e-02f, -4.80429456e-02f, 4.55296300e-02f, 4.58030216e-03f, 6.01587519e-02f,
  5.62145468e-03f, 5.66716716e-02f, -1.38237074e-01f, 3.51412520e-02f, -1.08408920e-01f, -6.61290362e-02f, 5.08952774e-02f, -4.72488292e-02f, -6.60849214e-02f, -4.73188385e-02f,
  -6.50216192e-02f, -5.52383922e-02f, 6.64804578e-02f, -8.61726552e-02f, 1.14418203e-02f, 5.87856136e-02f, -1.14601422e-02f, -1.53208431e-02f, -1.86971389e-02f, 4.13185684e-03f,
  -8.09702426e-02f, -2.26979200e-02f, -1.09776370e-02f, 2.35115290e-02f, -5.66475056e-02f, 8.12906772e-02f, -1.97450798e-02f, -3.13514397e-02f, -7.82472789e-02f, -1.10707870e-02f,
  1.20276749e-01f, -1.54690379e-02f, -5.07059209e-02f, 1.79114044e-02f, 1.07822172e-01f, 3.90783213e-02f, -7.53747448e-02f, -1.06785834e-01f, 6.64734319e-02f, -2.76794787e-02f,
  -4.59476441e-01f, -1.95147514e-01f, 7.53526315e-02f, -6.72598109e-02f, 4.97099049e-02f, -2.85971332e-02f, 1.08927544e-02f, -5.83897457e-02f, -8.35593119e-02f, -1.37498192e-02f,
  3.10041532e-02f, -6.79161027e-02f, -1.10455431e-01f, 4.86539453e-02f, -4.39318735e-03f, -6.56106994e-02f, 2.93061174e-02f, -1.28999576e-02f, -5.91768473e-02f, -1.10577732e-01f,
  2.45990139e-02f, 1.67226680e-02f, 2.04380274e-01f, -2.43307911e-02f, 7.34371245e-02f, -1.90428309e-02f, 7.57211400e-03f, 6.30617365e-02f, 5.07140197e-02f, -4.26500142e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.96361744e-01f, 6.19524419e-01f, -3.04799944e-01f, 7.67480552e-01f, -4.91325855e-01f, 3.59089524e-01f, 4.45572674e-01f, 6.79350197e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.36269230e-01f, 9.68693420e-02f, -4.39406425e-01f, 2.55896807e-01f, 6.92787692e-02f, 3.80586982e-01f, -2.04926133e-01f, 9.82619002e-02f, -5.97822785e-01f, 4.16822940e-01f,
  -2.95892596e-01f, -3.59824188e-02f, -3.62576127e-01f, 2.16959476e-01f, -4.14887875e-01f, 5.58418259e-02f, 5.41941822e-02f, -4.06804830e-01f, -1.26415938e-01f, 1.57893933e-02f,
  -4.37652826e-01f, 3.44252378e-01f, 4.64648515e-01f, 5.50235271e-01f, 2.40222007e-01f, 4.53345925e-01f, -1.49939746e-01f, -6.32309541e-02f, -9.42811444e-02f, 4.56837751e-03f,
  -7.47550428e-01f, 3.50061245e-02f, -4.57308859e-01f, 7.75196031e-02f, -1.09983616e-01f, 2.43979558e-01f, 2.23718584e-01f, -2.17408285e-01f, -4.62392956e-01f, -6.40985370e-02f,
  -9.29482952e-02f, 4.42232668e-01f, -5.63922703e-01f, -3.47594358e-02f, 2.48959705e-01f, 4.39847797e-01f, -5.98291516e-01f, 5.16627371e-01f, -9.88091901e-02f, -1.23783194e-01f,
  8.12270716e-02f, -2.37432405e-01f, -3.60733837e-01f, 6.36118591e-01f, -2.21381024e-01f, -5.10711551e-01f, 2.16074675e-01f, -5.88035166e-01f, 3.17471892e-01f, -1.86640635e-01f,
  9.29769725e-02f, -2.12046012e-01f, 3.45371217e-02f, 2.60304421e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.50044221e-01f, 1.55571789e-01f, -8.34910013e-03f, 1.55461710e-02f, -8.76465797e-01f, -6.78082168e-01f, 7.26406097e-01f, 2.33782113e-01f, -2.04275146e-01f, -1.68985382e-01f,
  -4.03192490e-01f, -5.56953788e-01f, 4.81333673e-01f, 3.34850758e-01f, 3.79994065e-01f, -4.97869551e-01f, 3.67594689e-01f, 1.62458271e-02f, 3.45791429e-01f, 9.26768258e-02f,
  -1.08665168e+00f, 6.07414186e-01f, 5.10018170e-01f, 4.77140397e-01f, -7.33355224e-01f, -1.07930064e-01f, -5.47207773e-01f, 3.77364196e-02f, 4.26365763e-01f, -5.06881893e-01f,
  -4.03800011e-01f, -5.10518074e-01f, 5.40970206e-01f, 5.96500039e-01f, 1.10988142e-02f, 7.80207336e-01f, 3.25123072e-01f, 9.74544406e-01f, -3.47169518e-01f, -5.88650584e-01f,
  -6.33699358e-01f, 9.11616564e-01f, -5.97105145e-01f, 2.67355740e-01f, -4.21532780e-01f, -1.08854942e-01f, 1.72275573e-01f, 3.40309560e-01f, 7.63769865e-01f, 4.89952462e-03f,
  5.60133755e-01f, 1.17359184e-01f, -8.02839041e-01f, 9.46367800e-01f, 1.42153529e-02f, 3.91685605e-01f, 5.79863489e-01f, 4.60282654e-01f, 4.55163449e-01f, 4.51149017e-01f,
  5.95203817e-01f, -1.06721318e+00f, 3.87120187e-01f, 5.78200638e-01f, 3.44145298e-01f, 5.33190817e-02f, 4.27523404e-02f, 4.47381228e-01f, -5.97485721e-01f, -7.98693538e-01f,
  6.56241119e-01f, 9.93380666e-01f, -1.00331448e-01f, -2.84623444e-01f, -5.83292603e-01f, -9.76608157e-01f, 3.55742842e-01f, 5.21672785e-01f, -4.92431968e-02f, 6.79339230e-01f,
  6.49220288e-01f, 2.78633416e-01f, -1.15292005e-01f, 3.77275914e-01f, -4.29900140e-01f, 3.46917361e-01f, 7.77095973e-01f, 6.20325029e-01f, 4.28686403e-02f, 7.78136134e-01f,
  -6.63242161e-01f, -1.32304743e-01f, -9.74824429e-02f, 5.21755695e-01f, 8.86143744e-01f, -6.81848824e-01f, 6.72873080e-01f, 8.66893291e-01f, 4.51854914e-01f, 8.12468767e-01f,
  3.89197677e-01f, -3.86849195e-01f, 3.19938123e-01f, -5.64127684e-01f, 4.82730389e-01f, 4.48926330e-01f, 1.37495294e-01f, 9.30250347e-01f, -4.48549539e-01f, 8.75814676e-01f,
  7.11186469e-01f, -7.46423006e-01f, 4.71302807e-01f, -3.08686495e-01f, -5.15446723e-01f, 4.15010840e-01f, -1.07469395e-01f, -2.44807467e-01f, 2.01088324e-01f, 3.18671525e-01f,
  -1.55769750e-01f, 3.97875607e-02f, -3.74952286e-01f, -1.55873736e-02f, 7.71789014e-01f, 2.72304386e-01f, -4.07557309e-01f, -3.54142427e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.58603179e-01f, 3.19577664e-01f, 5.92009723e-01f, 4.30288315e-01f, 9.77880359e-01f, 5.05531311e-01f, 4.42496210e-01f, -3.99605602e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  2.10661724e-01f, 1.26825675e-01f, -1.74875692e-01f, 2.68106729e-01f, -4.02091175e-01f, -4.55215812e-01f, 2.31301188e-01f, 2.02453315e-01f, -1.09108113e-01f, -5.39721489e-01f,
  -1.93550289e-02f, 3.72407526e-01f, -2.58967765e-02f, -1.52612239e-01f, -2.51098961e-01f, -4.90232795e-01f, -1.52524099e-01f, -3.25886697e-01f, 2.42703512e-01f, -6.08143844e-02f,
  5.05724132e-01f, 2.12074593e-01f, -5.13923347e-01f, 3.19419086e-01f, -1.25635684e-01f, -1.06870532e-01f, 3.56532365e-01f, -1.03865221e-01f, -2.18971312e-01f, 1.97246298e-01f,
  1.68909848e-01f, -2.87572324e-01f, -4.37652133e-02f, 2.06963286e-01f, -4.07870680e-01f, -8.11587796e-02f, -5.38879454e-01f, -2.30813429e-01f, 5.37881792e-01f, -1.76060691e-01f,
  -5.19066453e-02f, -1.75077766e-01f, -1.92330077e-01f, 3.19000930e-01f, 1.04815356e-01f, -1.64858148e-01f, -2.59193957e-01f, 1.58761188e-01f, -3.00217811e-02f, -1.36195242e-01f,
  2.78261900e-01f, 1.19223986e-02f, 6.83781385e-01f, 2.62660161e-02f, 3.07073563e-01f, -2.06323415e-01f, -7.38423169e-02f, -4.20154184e-01f, 9.67109054e-02f, -3.15101713e-01f,
  -2.03449860e-01f, 4.66035455e-02f, 1.82774931e-01f, 1.09355532e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  6.38047814e-01f, 1.22926421e-01f, 5.07469356e-01f, 1.99480072e-01f, 1.50989461e+00f, 1.00103235e+00f, 6.59715772e-01f, 2.74535269e-01f, -4.52276260e-01f, 2.32204750e-01f,
  1.40174055e+00f, 4.68413085e-01f, 3.91129941e-01f, 4.95987952e-01f, -1.10919699e-01f, -8.69491100e-02f, 5.63866735e-01f, 9.07095671e-01f, 2.40619659e-01f, 7.89058328e-01f,
  -6.50121793e-02f, -1.21887589e+00f, 1.19140160e+00f, -8.66979539e-01f, -7.14538634e-01f, -2.11547077e-01f, 2.15368383e-02f, -2.67363906e-01f, 2.24129751e-01f, -8.74727368e-01f,
  5.65844834e-01f, -4.99009728e-01f, 4.49365020e-01f, -5.04922941e-02f, 3.45592946e-01f, 2.53122121e-01f, 4.45112705e-01f, -7.78255999e-01f, 3.17522814e-03f, -4.55250353e-01f,
  -7.67424464e-01f, -1.55515984e-01f, 7.35687196e-01f, -5.25091112e-01f, -8.61293972e-01f, 2.44492501e-01f, 9.74506974e-01f, -4.19440150e-01f, 8.72611254e-02f, 2.86550242e-02f,
  4.20820683e-01f, -5.52400231e-01f, 3.04844409e-01f, 4.55871493e-01f, 2.19120160e-01f, -2.56316453e-01f, 4.87473160e-01f, -7.34097898e-01f, 2.80057818e-01f, -8.78497064e-01f,
  5.08702755e-01f, 1.12210464e+00f, 9.92631257e-01f, -3.24566811e-02f, 5.72157681e-01f, 6.02458417e-01f, 7.72414431e-02f, 1.07810795e+00f, 1.35011777e-01f, -8.80684078e-01f,
  9.45421934e-01f, 7.64147416e-02f, 3.44986081e-01f, -4.24467266e-01f, 6.55262172e-01f, 2.07457721e-01f, 9.67704833e-01f, -3.41964573e-01f, -4.10723895e-01f, 6.50386587e-02f,
  3.23988587e-01f, 1.75786436e-01f, 1.47615448e-01f, 8.27170670e-01f, -9.88189876e-01f, -2.40708143e-01f, -5.69314100e-02f, -7.80711174e-01f, 1.08856225e+00f, 1.11523294e+00f,
  -3.81407768e-01f, -7.20556229e-02f, 1.15127766e+00f, 7.90710509e-01f, 2.58655906e-01f, 1.16965503e-01f, -7.03289330e-01f, -1.09984381e-02f, -2.52049446e-01f, -6.11312091e-01f,
  -4.92885411e-01f, 3.50164950e-01f, -4.78667319e-01f, 5.27037382e-01f, -2.87496179e-01f, -5.06526649e-01f, 5.71991980e-01f, 1.50301683e+00f, -5.16430914e-01f, 4.71876085e-01f,
  8.59143659e-02f, 5.73893726e-01f, 4.10573602e-01f, -9.80052575e-02f, 5.69585323e-01f, 1.02531040e+00f, -9.29177463e-01f, -5.89239597e-01f, -1.31101227e+00f, -1.47678301e-01f,
  -1.25259399e-01f, 2.32600793e-01f, -3.59865844e-01f, 5.29058218e-01f, -3.27875130e-02f, 1.67127296e-01f, 7.44515598e-01f, -1.34968674e+00f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  5.84965050e-01f, 4.99869883e-01f, 4.06414598e-01f, 2.67946869e-01f, 7.82765687e-01f, 4.41971332e-01f, 2.58156538e-01f, 6.88640594e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -1.62499830e-01f, -2.91709453e-02f, 4.39402238e-02f, 4.67349082e-01f, 1.00007546e+00f, -1.02665663e+00f, 1.23798454e+00f, -3.94607902e-01f, -4.22087908e-01f, 9.14506614e-01f,
  -2.52764374e-01f, -7.81489074e-01f, 7.76657820e-01f, 1.08337343e-01f, -6.88398302e-01f, 3.69693637e-02f, -4.01881337e-02f, 4.89349477e-02f, 8.45029429e-02f, 6.03592277e-01f,
  -1.17966068e+00f, -6.35725200e-01f, -2.92775273e-01f, -1.33530974e-01f, -1.42472267e+00f, -1.48650721e-01f, -6.14124358e-01f, 2.80326188e-01f, 4.11179587e-02f, 4.33722556e-01f,
  -9.97813106e-01f, 4.39164788e-01f, -1.45179755e-03f, -1.92039445e-01f, -1.59852833e-01f, -2.23880053e-01f, 6.05048776e-01f, -4.55418706e-01f, -4.03139561e-01f, 5.49913347e-01f,
  6.67016432e-02f, -6.71807051e-01f, -7.09591150e-01f, 8.04404974e-01f, 7.89152086e-02f, 1.12543717e-01f, -5.25633991e-01f, -1.30210960e+00f, -2.68608242e-01f, -2.57097110e-02f,
  2.88269758e-01f, 2.70618528e-01f, 6.97203159e-01f, -5.51139601e-02f, 9.28096294e-01f, -6.30017519e-02f, 8.14626813e-01f, -4.55536187e-01f, -9.00669217e-01f, -8.92973781e-01f,
  5.84025323e-01f, -1.19240594e+00f, 4.52752382e-01f, -8.98119807e-01f, 4.34953004e-01f, 3.63794297e-01f, 3.61322522e-01f, -2.93205738e-01f, 4.77400661e-01f, 6.98377192e-01f,
  -8.38481843e-01f, 6.88660026e-01f, 4.39764231e-01f, 6.51903570e-01f, 4.98446941e-01f, -3.54817837e-01f, 5.00980854e-01f, -9.65290129e-01f, -5.42353868e-01f, -1.70416459e-01f,
  5.81503570e-01f, -2.38782987e-01f, -3.52576196e-01f, 5.81536710e-01f, -7.42847741e-01f, 7.69845903e-01f, -8.94772649e-01f, 6.26318753e-01f, -6.32756710e-01f, -5.33935666e-01f,
  7.52889141e-02f, -2.76217282e-01f, -7.94725835e-01f, -1.68775871e-01f, 4.06709075e-01f, 6.69636905e-01f, -2.80352861e-01f, -7.29525149e-01f, -1.49055989e-02f, -4.18083966e-01f,
  5.38666487e-01f, 4.35609557e-02f, 9.40222204e-01f, -4.59027767e-01f, -3.26616764e-01f, -5.09222567e-01f, 4.45174038e-01f, 4.81059104e-01f, -3.71028632e-01f, -2.06837267e-01f,
  -3.48961830e-01f, 4.57766466e-02f, -1.56204149e-01f, 3.76037985e-01f, -4.50739376e-02f, -3.97379845e-01f, 6.46785736e-01f, 8.22199583e-02f, 7.43874907e-01f, -6.18826389e-01f,
  -5.52636266e-01f, -6.59253120e-01f, -1.19996715e+00f, -7.73291945e-01f, -5.97866952e-01f, -7.60122836e-01f, 9.51703131e-01f, 6.39971972e-01f, -1.15635701e-01f, -5.75457931e-01f,
  -8.73768404e-02f, -4.66046900e-01f, 5.11830039e-02f, 7.02225193e-02f, 7.37887502e-01f, -2.42088705e-01f, -4.54796463e-01f, -5.54835260e-01f, -2.67025411e-01f, -6.24608457e-01f,
  3.07408333e-01f, 7.94640779e-01f, 2.71561414e-01f, -1.05458283e+00f, -3.69072258e-01f, 4.43883568e-01f, -1.46576881e-01f, -7.35677183e-01f, -4.06037003e-01f, 7.00822398e-02f,
  -3.71803999e-01f, 2.28509188e-01f, -1.31825221e+00f, 1.00003052e+00f, 4.01281744e-01f, -6.48220256e-02f, -1.18796206e+00f, -2.35048383e-01f, -1.15084887e+00f, 4.40327704e-01f,
  2.98238009e-01f, 5.88617742e-01f, 2.78582990e-01f, 8.23269114e-02f, -7.62942553e-01f, 1.70635700e-01f, -8.01915050e-01f, -7.26832509e-01f, 9.74230587e-01f, -8.03097904e-01f,
  -6.56983733e-01f, -5.58789015e-01f, -4.55978839e-03f, 1.58737987e-01f, -7.40965307e-01f, 1.10126004e-01f, -1.92009702e-01f, -3.26834500e-01f, -3.04897726e-01f, -3.53340447e-01f,
  -5.45540512e-01f, 3.14158387e-02f, -4.11825508e-01f, 2.01627120e-01f, 4.46462214e-01f, -4.45776045e-01f, 1.84198339e-02f, 1.86931208e-01f, -7.06663787e-01f, -6.08293235e-01f,
  5.64776123e-01f, -7.83731878e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  5.14761172e-02f, -9.04033259e-02f, -1.05408505e-01f, 1.92452386e-01f, 9.52094868e-02f, 1.32760063e-01f, -2.62399949e-02f, 2.70887733e-01f, -8.31506774e-03f, 4.46389765e-02f,
  2.52572715e-01f, -1.29871249e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    