/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.27019206e-01f, -4.46277827e-01f, -1.84727028e-01f, -7.69025832e-02f, 4.61012647e-02f, 1.78390905e-01f, -4.94661480e-02f, 1.07755894e-02f, -2.47896723e-02f, -1.79318726e-01f,
  -6.75754175e-02f, 6.73732236e-02f, 8.03868473e-02f, 3.91718112e-02f, 9.65209454e-02f, -1.16288185e-01f, -2.09970046e-02f, 1.15611516e-01f, 1.84925154e-01f, 2.15897694e-01f,
  1.85269669e-01f, -5.55368513e-02f, -1.19529545e-01f, 6.14953041e-02f, -1.69550762e-01f, 1.49157390e-01f, -1.71091855e-01f, -1.87373579e-01f, 4.46017981e-02f, -2.12401435e-01f,
  -6.30568489e-02f, -1.59309953e-01f, 1.80788025e-01f, -1.99482497e-02f, -2.71107387e-02f, 2.35788450e-02f, 3.44042741e-02f, -9.76464748e-02f, 2.92259865e-02f, -8.36957172e-02f,
  -4.86837514e-02f, -5.82745634e-02f, -4.19313535e-02f, -5.59909977e-02f, -1.07122391e-01f, -4.93685976e-02f, -1.49244756e-01f, -1.22405678e-01f, -2.73042787e-02f, -5.68795316e-02f,
  -2.67426223e-02f, -5.65706939e-02f, -5.64992093e-02f, 1.11069120e-02f, 2.46173590e-02f, -2.53346842e-02f, -1.35215476e-01f, 1.54276453e-02f, -1.16731398e-01f, -1.53773993e-01f,
  2.24997774e-02f, -9.26424637e-02f, 3.50058521e-03f, -5.02297431e-02f, -2.53689121e-02f, 1.48296095e-02f, -1.21283062e-01f, -7.79665112e-02f, -2.91451477e-02f, -1.06399924e-01f,
  -5.78406602e-02f, -5.86016141e-02f, -6.41926900e-02f, -9.87889543e-02f, -1.04593381e-01f, -9.21992734e-02f, -8.99230540e-02f, -1.16827525e-01f, -2.27710363e-02f, -6.35858551e-02f,
  -1.05886236e-01f, 3.46028851e-03f, -9.40924287e-02f, -7.97811896e-02f, -5.60647286e-02f, -5.56363128e-02f, -1.44343272e-01f, -2.36354545e-02f, -1.56081378e-01f, -1.08234137e-01f,
  3.42380069e-02f, 7.91808367e-02f, -5.12154140e-02f, 2.76575554e-02f, -1.13216247e-02f, -2.79221889e-02f, -2.13497896e-02f, -3.56669514e-03f, -8.13423749e-03f, -1.04714353e-02f,
  -3.27277146e-02f, -1.60524733e-02f, -6.68563619e-02f, 2.34828703e-02f, 5.40453121e-02f, 2.81631183e-02f, -6.06813692e-02f, 9.25878435e-02f, 4.18173056e-03f, 1.88418839e-03f,
  -2.97453534e-02f, 6.42880350e-02f, 6.05890192e-02f, -3.33573036e-02f, -4.86345477e-02f, 1.43026978e-01f, -7.98174553e-03f, -2.08766349e-02f, 8.27285200e-02f, -1.83955938e-01f,
  3.92965645e-01f, 2.61305999e-02f, -3.78104039e-02f, 1.48482502e-01f, 1.63963437e-01f, 1.13070309e-01f, 1.56926215e-01f, 1.14347234e-01f, -5.58197200e-02f, -6.78300485e-03f,
  2.63665497e-01f, 3.25635344e-01f, 1.51377454e-01f, 1.83842912e-01f, 1.50078669e-01f, -2.09754527e-01f, -2.51554221e-01f, 2.53932085e-02f, 8.47293288e-02f, 1.92620575e-01f,
  8.97469297e-02f, 7.99576640e-02f, 1.10096268e-01f, -8.29553697e-03f, -1.12640940e-01f, 1.24017196e-02f, -9.46462005e-02f, -7.46908858e-02f, -9.10168365e-02f, -2.19560236e-01f,
  -9.15015340e-02f, 2.05888882e-01f, 9.03089046e-02f, 7.73425251e-02f, 1.72500864e-01f, 1.11900479e-01f, 5.76329567e-02f, 1.28884166e-01f, 9.05398056e-02f, 6.80114552e-02f,
  1.55251414e-01f, 7.74005949e-02f, 1.13361672e-01f, -4.34700921e-02f, 6.96830526e-02f, 3.87486666e-02f, -5.86030781e-02f, 3.42191011e-02f, 4.95244563e-02f, 1.50353298e-01f,
  1.57040611e-01f, 1.11520663e-01f, 1.35064557e-01f, -8.15987587e-03f, 1.12378784e-01f, 1.71524704e-01f, 4.03526612e-02f, -3.99538502e-02f, 1.49595395e-01f, -9.36336964e-02f,
  -7.69280866e-02f, -4.76651751e-02f, -3.54140601e-03f, -2.19820011e-02f, -1.34026036e-01f, -9.27504599e-02f, -8.93550515e-02f, -5.44473380e-02f, -1.24495521e-01f, -1.14218786e-01f,
  -2.22688541e-02f, -1.03074908e-01f, -5.14444187e-02f, -6.66121021e-02f, -1.06508732e-01f, -5.74153140e-02f, -3.79531644e-02f, -1.19401649e-01f, -7.79361352e-02f, -9.37605873e-02f,
  -3.42213288e-02f, -9.48772281e-02f, -1.47635460e-01f, -1.37903601e-01f, -1.01717561e-01f, -3.89882140e-02f, -8.53618458e-02f, -4.73100021e-02f, -1.38815477e-01f, -8.03728923e-02f,
  -2.87271552e-02f, 2.51370877e-01f, -6.21563755e-03f, 4.93573695e-02f, 6.12279512e-02f, 7.76115730e-02f, 1.95493065e-02f, 8.60257149e-02f, 1.48684338e-01f, 8.19417089e-02f,
  1.90234900e-01f, 7.74290636e-02f, 8.93725976e-02f, 2.12519746e-02f, 6.23744205e-02f, 1.12124272e-01f, 9.20266956e-02f, 2.18949039e-02f, 3.21687087e-02f, 6.19167555e-03f,
  -3.24756391e-02f, 6.89685568e-02f, 1.82471618e-01f, 1.18332706e-01f, 8.60390142e-02f, 1.02620639e-01f, -3.31700929e-02f, 1.03869572e-01f, 6.23615161e-02f, -1.47592515e-01f,
  -7.31080294e-01f, -2.77135987e-02f, 9.41943154e-02f, -1.70804799e-01f, 1.04306862e-01f, 7.71989375e-02f, 1.45469129e-01f, -2.90108062e-02f, -1.80037156e-01f, -1.06426410e-01f,
  -1.43582717e-01f, -1.45467579e-01f, -1.58153057e-01f, -2.07142159e-01f, -2.23456293e-01f, 1.48146516e-02f, 6.21361323e-02f, -3.22224677e-01f, -2.44241506e-01f, -1.49559990e-01f,
  -1.17465146e-02f, -2.67603576e-01f, -3.57495725e-01f, -2.80751675e-01f, -1.10765183e-02f, -4.93695438e-02f, 1.45710306e-02f, -5.83606176e-02f, -8.48192647e-02f, -4.94430885e-02f,
  3.73555794e-02f, -1.88184351e-01f, -7.04337507e-02f, -1.77373275e-01f, -1.50331641e-02f, -2.11283505e-01f, -2.47078780e-02f, -9.51096565e-02f, -1.07749283e-01f, -2.50428673e-02f,
  -5.42917550e-02f, -1.72268555e-01f, -1.12644821e-01f, -1.47977054e-01f, -1.29008234e-01f, -3.84143442e-02f, -9.39679891e-02f, -1.04001522e-01f, -7.84939453e-02f, -1.09900534e-01f,
  -8.90147779e-03f, -1.09966166e-01f, -1.70148209e-01f, -1.19960040e-01f, -2.19659097e-02f, -1.83628798e-01f, -1.17237121e-01f, -1.94131389e-01f, -1.93289191e-01f, -1.46259293e-01f,
  1.48790374e-01f, 1.43188253e-01f, 1.24968499e-01f, 1.82138667e-01f, 1.39282376e-01f, 1.31830350e-01f, 1.08380176e-01f, 1.62442356e-01f, 3.16861719e-02f, 1.06589563e-01f,
  1.44635573e-01f, 1.17264375e-01f, 1.08983636e-01f, 8.69922042e-02f, 1.47926196e-01f, 1.02908425e-01f, 1.22670986e-01f, 1.74456537e-01f, 1.66455925e-01f, 1.60091206e-01f,
  9.28678587e-02f, 1.45354897e-01f, 1.96306571e-01f, 1.25038952e-01f, 1.77806690e-01f, 7.81050101e-02f, 1.21655606e-01f, 7.93019682e-02f, 1.38594225e-01f, 1.16743490e-01f,
  -1.09817103e-01f, -9.39899385e-02f, -1.18407175e-01f, -2.51670331e-01f, -1.32565334e-01f, -2.06908718e-01f, -1.29082114e-01f, -1.81037709e-01f, -6.94680810e-02f, -1.73904523e-01f,
  -1.61303565e-01f, -1.33329287e-01f, -9.58772153e-02f, -8.89977217e-02f, -1.73498973e-01f, -1.69177160e-01f, -2.04613805e-01f, -1.91362962e-01f, -6.66765273e-02f, -1.37280524e-01f,
  -5.31600192e-02f, -2.06599742e-01f, -2.10744426e-01f, -6.58470318e-02f, -1.06124341e-01f, -2.25631282e-01f, -1.22800685e-01f, -1.12403087e-01f, -1.17137082e-01f, -1.12728022e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.97630727e-01f, 4.80553545e-02f, -1.24158233e-01f, 9.89302099e-02f, -4.28817198e-02f, -2.07172871e-01f, -3.11733305e-01f, -1.73122749e-01f, 1.40014514e-01f, -4.82771657e-02f,
  -1.23928629e-01f, 3.33664268e-02f, 2.00338408e-01f, 5.49999848e-02f, -4.02537733e-02f, 2.90749937e-01f, 4.11420703e-01f, 9.58456025e-02f, -1.88964561e-01f, -9.14436430e-02f,
  2.36157075e-01f, 1.19522974e-01f, -1.09756827e-01f, -2.07432993e-02f, 3.82703841e-01f, 8.97118375e-02f, 1.47528544e-01f, 4.99530472e-02f, 5.63954599e-02f, 5.92874348e-01f,
  -2.44372226e-02f, -2.67516933e-02f, -2.01545749e-02f, 2.26014145e-02f, 7.99585227e-03f, -9.51914638e-02f, -5.40947318e-02f, 8.98513496e-02f, -1.32366225e-01f, 4.24760059e-02f,
  1.08061455e-01f, 1.19576246e-01f, 4.37715016e-02f, 1.27316177e-01f, 7.07809106e-02f, -3.34874839e-01f, 8.25333223e-02f, 1.27966046e-01f, -1.16569839e-01f, -1.50782079e-01f,
  2.64977723e-01f, 5.51045756e-04f, -2.75852203e-01f, -2.25550428e-01f, -6.99684396e-02f, -5.62952794e-02f, -1.38439462e-01f, -1.24090679e-01f, -5.24267137e-01f, -4.29553427e-02f,
  1.69385195e-01f, 3.40836734e-01f, 6.87260646e-03f, 7.05453977e-02f, 1.28820956e-01f, 2.05131888e-01f, 3.43226850e-01f, 7.43297786e-02f, 9.78438407e-02f, 6.73927665e-02f,
  1.45033658e-01f, -1.84459195e-01f, -1.89126134e-02f, -1.22370608e-01f, -3.69600877e-02f, -4.57902402e-02f, -1.39747918e-01f, -5.99519648e-02f, -8.78106803e-02f, -2.52796978e-01f,
  9.62362662e-02f, 2.64325790e-04f, 1.55350566e-02f, 1.64717108e-01f, -9.00098607e-02f, 1.58397518e-02f, -1.52892135e-02f, -8.61743242e-02f, -1.91954136e-01f, -2.74140090e-01f,
  -2.25168422e-01f, -7.33980015e-02f, -2.74849199e-02f, 2.28798658e-01f, -1.68653075e-02f, -4.10494357e-02f, -7.14417845e-02f, -1.30688408e-02f, -2.80473009e-02f, -7.81761557e-02f,
  -3.53419513e-01f, -4.23520841e-02f, 5.12953214e-02f, 1.89105734e-01f, -5.40105700e-02f, -2.50466317e-02f, 1.33587360e-01f, -6.62429407e-02f, -2.17953771e-02f, -1.11581169e-01f,
  -1.28751978e-01f, -2.34435454e-01f, -2.69495755e-01f, -2.00086758e-01f, -4.01370861e-02f, -2.21749991e-01f, -2.27279454e-01f, -1.11424416e-01f, -4.67691511e-01f, -6.17826521e-01f,
  2.33236209e-01f, -3.73123646e-01f, -6.75313652e-01f, -2.53044516e-01f, -5.62124729e-01f, -3.96327525e-01f, -3.36898893e-01f, 2.19696179e-01f, 4.14660312e-02f, -3.45255554e-01f,
  -2.44093433e-01f, -3.73634472e-02f, -1.57343447e-01f, -1.13625832e-01f, 1.72819942e-02f, -4.06572163e-01f, -5.47176301e-01f, -2.96351284e-01f, -9.81850252e-02f, -5.07766269e-02f,
  -2.23152697e-01f, -2.53315479e-01f, -1.00001074e-01f, -1.33299813e-01f, -3.95902812e-01f, -3.68526310e-01f, -4.89074737e-01f, -3.74217808e-01f, -3.99110317e-01f, -6.62776291e-01f,
  -4.63932306e-01f, 3.65162380e-02f, -1.08632252e-01f, 1.38704672e-01f, -2.75410533e-01f, 9.20771062e-02f, -5.06333634e-02f, -4.00785655e-02f, 1.51320264e-01f, -7.49673918e-02f,
  -5.03976271e-02f, 2.48987973e-02f, 7.94458762e-02f, -4.01298180e-02f, -4.28686216e-02f, 6.43587038e-02f, 6.36637071e-03f, -2.33567003e-02f, -7.13197067e-02f, -9.05393797e-04f,
  1.33708969e-01f, 4.19505872e-02f, 5.22255898e-02f, 1.17492557e-01f, 1.05682097e-01f, 3.08359191e-02f, -1.92758113e-01f, 4.73422371e-02f, -1.60535872e-02f, -1.88110992e-01f,
  1.06958546e-01f, -3.04769110e-02f, -4.83902283e-02f, 8.05536434e-02f, 5.71053624e-02f, -1.43574819e-03f, -6.30014688e-02f, -5.64416982e-02f, 2.68131141e-02f, -7.79427066e-02f,
  5.81921544e-03f, 7.85582289e-02f, -7.43531669e-03f, 7.86190480e-02f, -1.23488605e-01f, -3.15482356e-02f, 5.05387112e-02f, 1.01427985e-02f, 3.50360982e-02f, 1.78699978e-02f,
  4.13090959e-02f, 1.19065465e-02f, 2.53574774e-02f, 4.74517308e-02f, 5.47142625e-02f, 1.79872531e-02f, 7.30006862e-03f, 1.21533178e-01f, 9.43563730e-02f, 5.00399955e-02f,
  -2.83767641e-01f, -2.50909850e-02f, -9.49954838e-02f, 2.28986219e-01f, -9.75186899e-02f, 9.46140364e-02f, -1.60008118e-01f, 1.66253280e-02f, 3.64962936e-04f, 8.81098509e-02f,
  5.56265116e-02f, 8.41422677e-02f, -1.31638855e-01f, -4.42027487e-02f, -1.84336036e-01f, 1.67055987e-02f, -1.46587277e-02f, -5.02820462e-02f, 1.25193089e-01f, 1.81673467e-02f,
  1.20380633e-01f, 2.51278162e-01f, 2.69599557e-01f, 4.89010029e-02f, 1.56552166e-01f, 1.45752877e-01f, -4.58616018e-02f, 5.09622023e-02f, 2.57567793e-01f, 2.38563284e-01f,
  6.08279765e-01f, 7.10585654e-01f, -1.45438313e-01f, 1.34520484e-02f, 8.33413824e-02f, 2.71970421e-01f, 4.92717236e-01f, 3.53360116e-01f, 1.22827031e-01f, 2.63374329e-01f,
  -4.35849279e-02f, -1.54713497e-01f, -2.25727439e-01f, -1.38021410e-01f, -2.00225096e-02f, 1.52431473e-01f, 1.26211837e-01f, -2.02605128e-01f, -1.65354148e-01f, 3.83781120e-02f,
  1.93833277e-01f, 2.28964135e-01f, 1.83837771e-01f, 4.01244946e-02f, 1.45975217e-01f, -1.13197781e-01f, 8.96207243e-02f, 1.16468750e-01f, 4.54214141e-02f, 1.03350900e-01f,
  -5.97855270e-01f, 8.64037201e-02f, -2.20144063e-01f, -6.87217325e-05f, -9.06913877e-02f, -5.68519011e-02f, -5.75220361e-02f, 4.19658050e-02f, 1.90841407e-02f, 9.97178927e-02f,
  5.24423197e-02f, 3.20426635e-02f, -3.86793613e-02f, 7.52183050e-02f, 7.41173550e-02f, -3.29642221e-02f, 5.48614860e-02f, 7.62723461e-02f, -8.39203224e-02f, -8.34708065e-02f,
  -4.43002768e-02f, -2.82415971e-02f, 5.28936693e-03f, -1.44519389e-01f, -1.10735491e-01f, -1.38405055e-01f, 4.92663868e-02f, -1.19455487e-01f, -1.59650579e-01f, 3.45870107e-02f,
  -3.93487662e-01f, 1.04015373e-01f, -9.25129801e-02f, -2.35689282e-01f, -9.53345001e-02f, 2.13789344e-02f, -1.11502618e-01f, -7.01041743e-02f, -7.31528550e-02f, -1.41835529e-02f,
  -1.19954161e-02f, -1.46101341e-01f, -2.14378178e-01f, -1.40031517e-01f, -2.54417837e-01f, -3.70240188e-03f, 7.40705207e-02f, -9.21755880e-02f, -2.51680642e-01f, 8.76819901e-03f,
  -1.71204224e-01f, 1.07595406e-01f, 2.68581286e-02f, -1.32994235e-01f, 4.21224581e-03f, -1.99633062e-01f, -1.30112067e-01f, -5.51172420e-02f, 6.15617298e-02f, 1.45588338e-01f,
  -1.85216263e-01f, -4.59143251e-01f, -1.09776244e-01f, 2.18377933e-01f, 7.03001693e-02f, -4.05308418e-02f, -2.78189540e-01f, -1.34988695e-01f, 7.58458003e-02f, -1.33284349e-02f,
  5.13097085e-02f, 2.82723103e-02f, -5.59148788e-02f, 6.92977570e-03f, -8.00769180e-02f, -1.41066089e-01f, 2.47253608e-02f, 3.31928991e-02f, -7.61317387e-02f, -9.36869066e-03f,
  1.09464727e-01f, 1.00953929e-01f, 7.99779296e-02f, -1.07293082e-02f, -7.72291049e-02f, -9.36381426e-03f, 6.07588515e-02f, 2.12853625e-02f, -3.15805152e-02f, 1.42906949e-01f,
  -9.97544110e-01f, -2.66630262e-01f, 5.00527918e-01f, -6.73092425e-01f, -3.50968510e-01f, -1.55547887e-01f, -3.85911502e-02f, -3.58441323e-01f, -4.75450486e-01f, -9.06899571e-02f,
  -7.04486445e-02f, -1.18865319e-01f, -4.10778001e-02f, 1.25243023e-01f, -9.63095129e-02f, 3.16272438e-01f, 3.43975499e-02f, -1.46793395e-01f, -3.03112626e-01f, -3.23470145e-01f,
  -2.40111828e-01f, -4.75451767e-01f, -4.72191006e-01f, -3.26768875e-01f, -2.17918739e-01f, -2.06330642e-01f, 1.19532779e-01f, -1.64642483e-01f, 6.10747859e-02f, 3.74632031e-02f,
  6.01447046e-01f, -5.22781193e-01f, -2.93712448e-02f, -2.22575665e-01f, -6.90831169e-02f, -2.32286677e-02f, -1.21046856e-01f, -1.76730931e-01f, -1.35883301e-01f, -1.12485223e-01f,
  -3.01695049e-01f, -1.00676849e-01f, -1.09254427e-01f, -9.24178064e-02f, -1.69834107e-01f, -7.56596997e-02f, -5.39489053e-02f, -1.93708658e-01f, 7.17218593e-03f, 2.05554843e-01f,
  5.28287962e-02f, -2.02017352e-02f, 4.01628315e-02f, 1.89421788e-01f, 1.98973604e-02f, -7.94754848e-02f, -1.05835991e-02f, -7.36384764e-02f, 1.14732934e-02f, 1.27487704e-01f,
  2.54818529e-01f, 1.82065591e-01f, -3.20764631e-02f, 4.07909229e-02f, 3.59250195e-02f, 6.76409900e-03f, 6.86731003e-03f, 1.09570302e-01f, -7.15090558e-02f, -7.32702389e-03f,
  -1.79898530e-01f, 1.97635964e-02f, -6.52152374e-02f, -5.49574867e-02f, -4.72510979e-02f, -1.57680497e-01f, -6.23418577e-02f, 1.29496962e-01f, -2.23209262e-02f, -1.39150918e-01f,
  -2.21901581e-01f, -7.15106055e-02f, 5.72450198e-02f, 2.99687367e-02f, -5.74312136e-02f, -4.06623147e-02f, -4.53107767e-02f, -3.59706916e-02f, -1.91401634e-02f, -1.92045718e-01f,
  2.03186750e-01f, -1.63354665e-01f, 5.25812060e-02f, -2.55888291e-02f, -2.88601890e-02f, 4.50577997e-02f, 3.86598855e-02f, -3.53864171e-02f, 3.27726034e-03f, 8.50676596e-02f,
  -8.73764530e-02f, -4.10050899e-02f, 4.76361401e-02f, -4.03636023e-02f, -9.20643359e-02f, -3.17498371e-02f, 1.00895099e-01f, 5.43532223e-02f, 9.03040543e-02f, 6.56708032e-02f,
  2.48636380e-01f, 2.25513831e-01f, 3.01270992e-01f, 3.48833233e-01f, 1.39653802e-01f, 1.80840775e-01f, 2.63928920e-01f, 1.65427193e-01f, 2.10095748e-01f, 3.03225577e-01f,
  -3.12381595e-01f, 6.28238380e-01f, 5.07702649e-01f, -4.28166777e-01f, 2.26130813e-01f, 4.48457986e-01f, 5.04262567e-01f, 2.17934996e-01f, -1.77438527e-01f, 2.19774649e-01f,
  3.17844272e-01f, -2.82971054e-01f, -1.32501870e-01f, -1.32754281e-01f, -7.16769472e-02f, 3.38185549e-01f, 1.03563786e-01f, -2.63221800e-01f, -3.89214247e-01f, -1.52042687e-01f,
  -1.31551728e-01f, -2.44796306e-01f, -3.86764079e-01f, -2.73476303e-01f, -1.38204500e-01f, -3.54406208e-01f, 8.44934508e-02f, -5.83630130e-02f, 4.05896865e-02f, -1.58077106e-01f,
  1.01771325e-01f, 2.72001117e-01f, -5.00437021e-02f, -1.32625684e-01f, 3.91132012e-02f, -2.86825389e-01f, -1.05940811e-01f, -1.07030645e-01f, 2.86487339e-04f, 6.76673055e-02f,
  4.77198064e-02f, 9.75797474e-02f, 1.06069654e-01f, -1.72857687e-01f, -1.61611348e-01f, -1.89586449e-02f, -9.07757729e-02f, -8.44952837e-02f, -1.91435724e-01f, 1.50448143e-01f,
  -1.34791970e-01f, -1.77731365e-02f, 4.86244857e-02f, 5.06320223e-02f, 7.75470138e-02f, -2.21412018e-01f, 1.52238443e-01f, -2.00666785e-01f, -8.16553012e-02f, -3.73830795e-01f,
  -1.48416340e-01f, 1.01898327e-01f, 7.53019825e-02f, 7.93262571e-02f, 5.91670163e-03f, 8.29826742e-02f, -1.38676167e-01f, -6.57760492e-03f, -5.63419648e-02f, -4.56840396e-02f,
  5.71014844e-02f, 5.01884986e-03f, 7.73831829e-02f, 9.53501165e-02f, -3.62661257e-02f, -1.03418730e-01f, -9.60995555e-02f, -1.24970460e-02f, -3.23153213e-02f, 1.94903221e-02f,
  -5.46588972e-02f, -5.04102856e-02f, -1.04306772e-01f, -6.57820255e-02f, 3.78858075e-02f, 3.11788972e-02f, -3.01780142e-02f, -7.15891644e-02f, -8.03392529e-02f, 2.16226906e-01f,
  -2.22508147e-01f, 2.37565935e-01f, -3.07832867e-01f, 6.38959836e-03f, 6.45148903e-02f, -6.31006807e-02f, 2.68627014e-02f, -1.93115279e-01f, 1.40481919e-01f, -1.70218483e-01f,
  1.83878034e-01f, -1.24663919e-01f, 8.42401683e-02f, -3.78515944e-02f, -3.06046724e-01f, -1.17378429e-01f, -1.25777766e-01f, -2.21386358e-01f, -2.76586623e-03f, -1.05550446e-01f,
  -8.15736577e-02f, -1.76547974e-01f, -4.38206524e-01f, -2.15525582e-01f, -2.61994928e-01f, -4.01012033e-01f, -2.89519578e-01f, -3.46076250e-01f, -1.94675013e-01f, -5.61891615e-01f,
  -5.87486982e-01f, 2.94366241e-01f, 2.30686516e-01f, -3.90392661e-01f, -7.38881081e-02f, 9.14518088e-02f, 2.39189357e-01f, 1.24560399e-02f, -1.11342795e-01f, 1.28990784e-01f,
  -1.02976389e-01f, -1.78095132e-01f, -2.53958721e-02f, 3.28077935e-02f, 6.46614209e-02f, 3.53465080e-01f, 3.44071984e-01f, 1.49396667e-02f, -3.31205100e-01f, -2.24257365e-01f,
  -5.50872646e-02f, -3.27751517e-01f, -3.49979877e-01f, 1.78026706e-02f, 7.68970624e-02f, 4.97155115e-02f, 1.57031089e-01f, -1.36478812e-01f, 1.38245508e-01f, 4.17758882e-01f,
  -1.60004959e-01f, -9.66592655e-02f, 4.44638468e-02f, -1.58781394e-01f, -8.78152326e-02f, 5.21710292e-02f, 7.84586836e-03f, -6.76468462e-02f, 1.96105719e-01f, 2.11640552e-01f,
  -2.03893304e-01f, 1.24275900e-01f, -1.84085791e-03f, -4.46285605e-02f, -1.78045779e-01f, -5.24107926e-02f, 7.49835894e-02f, 7.83263966e-02f, -1.82923883e-01f, 1.49405906e-02f,
  1.56599090e-01f, -3.37224841e-01f, -3.58547062e-01f, 1.53742015e-01f, 1.13412261e-01f, -2.79587179e-01f, -2.58744270e-01f, -6.60823658e-02f, -1.05750613e-01f, 1.90428197e-02f,
  1.78142563e-02f, -8.47362131e-02f, 7.98220858e-02f, 2.21006330e-02f, 3.60431410e-02f, 1.13084488e-01f, 2.94834916e-02f, 2.04386432e-02f, 4.36938740e-02f, -9.91409793e-02f,
  3.39199826e-02f, -1.16976999e-01f, -2.46787015e-02f, 1.97642529e-03f, 7.22634494e-02f, -3.23007219e-02f, 6.91930652e-02f, 6.08629547e-03f, 4.16852999e-03f, 1.05199106e-01f,
  -7.87409022e-02f, 4.31857146e-02f, -5.41855544e-02f, 1.50834829e-01f, 2.87715852e-01f, -1.59648489e-02f, 1.12230275e-02f, -4.87662740e-02f, -2.71573793e-02f, -1.59226313e-01f,
  -1.91435322e-01f, -7.08761392e-03f, -2.32562348e-02f, 1.03065580e-01f, -1.53708318e-02f, -5.90758063e-02f, 9.05408785e-02f, -6.51934296e-02f, -1.90412141e-02f, -6.50876984e-02f,
  2.43600961e-02f, 1.89375551e-03f, -1.50774112e-02f, 2.12770015e-01f, -8.14306643e-03f, 7.17076212e-02f, -4.36849035e-02f, 7.03142211e-02f, -1.05998605e-01f, -1.18891813e-01f,
  8.14491585e-02f, -1.55451268e-01f, -3.52725297e-01f, 1.04762867e-01f, -3.90857011e-02f, -4.25012082e-01f, -2.80688435e-01f, -2.36259289e-02f, -2.63993472e-01f, -1.60422415e-01f,
  -4.75284189e-01f, -5.05817056e-01f, -5.78580350e-02f, -4.00455236e-01f, -4.68441881e-02f, -1.27703454e-02f, -3.24451447e-01f, -1.28328204e-01f, -9.10603628e-02f, -2.34643295e-01f,
  -4.75447848e-02f, -1.01158969e-01f, -2.56102979e-01f, -1.43481702e-01f, -2.35004202e-01f, -4.39728737e-01f, -3.66197318e-01f, -7.37801939e-02f, 3.05604577e-01f, 2.76418298e-01f,
  1.11287571e-01f, -4.65469464e-04f, 1.55101880e-01f, 5.72422929e-02f, -3.30540568e-01f, 1.82372313e-02f, -6.84517920e-02f, -3.11547127e-02f, -3.13132978e-03f, -4.57235724e-01f,
  -4.22167331e-01f, -1.96831614e-01f, 1.91543773e-01f, 1.82980001e-02f, 1.65052161e-01f, -3.83846607e-04f, 4.88723926e-02f, 1.74760316e-02f, 1.49261793e-02f, -1.90035850e-01f,
  -1.15761854e-01f, 2.35530362e-01f, -9.61429905e-03f, -1.15916707e-01f, -1.72820427e-02f, -9.22894478e-02f, -2.39175111e-02f, 7.36276433e-02f, -1.01903059e-01f, 1.05137751e-02f,
  2.53330413e-02f, -1.40515462e-01f, -2.99930394e-01f, -8.56145844e-02f, -1.64600253e-01f, -9.56040546e-02f, 8.62457976e-02f, -7.10542798e-02f, -1.19304694e-01f, -4.39687133e-01f,
  5.59978373e-02f, 1.16742641e-01f, 1.27918750e-01f, -1.55558316e-02f, -2.83409767e-02f, -3.32455412e-02f, -2.04072863e-01f, -5.51245771e-02f, 1.50886402e-01f, -1.37136355e-01f,
  -8.56871903e-02f, -4.44346573e-03f, 1.56866506e-01f, -2.13463604e-01f, -2.97078602e-02f, -1.24774791e-01f, -1.55214280e-01f, 4.32580570e-03f, -3.05605866e-02f, -3.68936621e-02f,
  -1.89912021e-02f, -2.03766022e-02f, -1.06539048e-01f, 7.97210038e-02f, -3.48873697e-02f, -1.19233452e-01f, 4.58905138e-02f, -6.55699288e-03f, -1.29013211e-01f, -2.80379225e-02f,
  -4.65115964e-01f, 3.20991397e-01f, -3.08902025e-01f, 8.04787353e-02f, 6.50005043e-02f, 1.01204090e-01f, -7.85110369e-02f, -1.04476586e-01f, -3.65988584e-03f, -8.19174759e-03f,
  9.34074540e-03f, -6.31834045e-02f, -1.54235959e-01f, 9.20952335e-02f, 1.32896662e-01f, -1.00712270e-01f, -8.79719704e-02f, -1.61185563e-01f, -7.10461736e-02f, 2.15076804e-01f,
  2.35804468e-02f, -2.72036642e-01f, -5.83258450e-01f, -3.59510332e-01f, -1.68986648e-01f, -2.18044192e-01f, -1.38553217e-01f, -1.19737638e-02f, -1.89997420e-01f, -4.70274001e-01f,
  9.52803902e-03f, 1.03417233e-01f, -2.45462790e-01f, 3.06041330e-01f, 2.20748894e-02f, -4.35175359e-01f, -4.63546246e-01f, -2.38188267e-01f, 1.83836535e-01f, 1.17307223e-01f,
  2.00969502e-01f, 1.90716818e-01f, -1.00794425e-02f, -3.71231884e-01f, -6.56221390e-01f, -5.91316521e-01f, -3.78794193e-01f, -5.40646434e-01f, -4.63836789e-01f, -3.10345262e-01f,
  -5.51273413e-02f, -6.95653707e-02f, -1.89914271e-01f, -1.52664974e-01f, 4.98103827e-01f, 1.92418829e-01f, 2.09567308e-01f, 8.71750619e-03f, -1.29557595e-01f, 9.46044177e-02f,
  2.05324486e-01f, -3.23435962e-01f, -1.28453434e-01f, -2.13468060e-01f, 1.02030955e-01f, -1.70008525e-01f, -1.56407237e-01f, -7.60446256e-03f, 4.35506105e-02f, 4.29557823e-02f,
  4.14022021e-02f, -1.78114802e-01f, -9.25160125e-02f, 1.43587880e-03f, -4.94876690e-02f, -1.17533684e-01f, -1.85796991e-01f, -3.31192136e-01f, -1.69129863e-01f, -1.82183847e-01f,
  -1.09381922e-01f, -1.91429868e-01f, -2.30009019e-01f, -2.02515066e-01f, -3.67679328e-01f, 1.20012062e-02f, 1.45846903e-01f, -4.71779257e-02f, -1.07043199e-01f, 3.73307407e-01f,
  -1.67952944e-02f, -5.47112823e-02f, -1.68536752e-02f, 4.56159227e-02f, 1.31259397e-01f, 3.72946821e-02f, 6.76966086e-02f, -9.89746954e-03f, -3.34529988e-02f, 7.26360828e-02f,
  8.72476473e-02f, -1.35408258e-02f, -1.75354667e-02f, -2.47506574e-01f, -5.42447083e-02f, -3.08218747e-02f, -6.56144097e-02f, -9.14448798e-02f, -1.68197766e-01f, 2.70081926e-02f,
  -2.72338782e-02f, 4.38152105e-02f, 1.50398612e-01f, 2.09781155e-02f, -1.26651064e-01f, 1.03361003e-01f, -1.55284554e-01f, 5.37592452e-03f, -6.79143593e-02f, -1.14974238e-01f,
  2.67078668e-01f, -3.76782835e-01f, 3.29577848e-02f, -3.08782727e-01f, -1.79114848e-01f, 1.16281971e-01f, 2.01826841e-01f, 2.96159589e-04f, 6.29582256e-02f, 1.24269903e-01f,
  -1.89748213e-01f, 1.80923820e-01f, 8.45361277e-02f, 8.76392052e-02f, 1.34895602e-02f, 2.57166903e-02f, -3.19199324e-01f, 9.88611504e-02f, -3.14352870e-01f, 3.08049861e-02f,
  3.83678712e-02f, -2.02764750e-01f, 3.96339446e-02f, 1.43066430e-02f, -9.45631266e-02f, -8.41955766e-02f, 2.03240573e-01f, 1.90042749e-01f, -2.68571705e-01f, 2.75335640e-01f,
  -5.77829897e-01f, -1.66950413e-04f, 1.83294430e-01f, 2.13076234e-01f, 3.95362884e-01f, 3.85242432e-01f, 3.18233222e-01f, 1.75898463e-01f, 1.95054874e-01f, 2.67539829e-01f,
  3.09268892e-01f, 2.54426539e-01f, 2.65532464e-01f, 2.38442302e-01f, 1.99534699e-01f, 3.21987450e-01f, 1.56954050e-01f, 6.35675341e-03f, 1.84829965e-01f, 2.29799405e-01f,
  3.48405123e-01f, 2.29171086e-02f, -1.50492072e-01f, 1.18968256e-01f, 1.52824342e-01f, 3.91320765e-01f, 1.76444605e-01f, 1.81108341e-01f, 2.62098610e-01f, 1.42111242e-01f,
  5.41743815e-01f, -5.77921942e-02f, 1.08081631e-01f, -5.68117537e-02f, -7.59358555e-02f, -2.24843428e-01f, -2.29711551e-02f, -1.00106545e-01f, -1.66460592e-02f, -1.40657164e-02f,
  -6.32091537e-02f, -1.41128451e-01f, -6.38541877e-02f, -9.90468860e-02f, -6.15798235e-02f, -1.28053680e-01f, -2.14352742e-01f, -6.96807206e-02f, 5.46803847e-02f, 6.96769804e-02f,
  3.27150375e-02f, 9.55113694e-02f, 1.52424157e-01f, -2.32713041e-03f, -9.42020863e-02f, -2.86642890e-02f, -7.98270926e-02f, -1.25640213e-01f, -5.49028628e-02f, -1.02395937e-01f,
  2.74851918e-01f, -9.76976845e-03f, -9.57154408e-02f, 6.18949020e-03f, -7.04280958e-02f, -5.58606423e-02f, -3.97437550e-02f, 1.20222002e-01f, 4.36313543e-03f, -1.28493801e-01f,
  2.22791880e-01f, 2.14692578e-01f, 8.44916180e-02f, 1.05035752e-01f, 4.58400585e-02f, 8.04233924e-02f, -1.09453432e-01f, 1.20392039e-01f, -1.35485619e-01f, -5.94716426e-03f,
  -3.07295546e-02f, 1.87973026e-02f, -1.33403912e-01f, -2.98590008e-02f, 1.86050516e-02f, 7.61044025e-02f, 1.48981795e-01f, 9.70101282e-02f, 1.19588107e-01f, 1.00869061e-02f,
  7.84515142e-01f, 1.61616787e-01f, 7.08941668e-02f, -6.97492734e-02f, -8.21865425e-02f, -1.91250473e-01f, 3.95098813e-02f, -3.37931737e-02f, -4.99003679e-02f, 9.94104967e-02f,
  -7.42912218e-02f, -2.08960116e-01f, -6.01076595e-02f, -1.41781285e-01f, -1.69638500e-01f, -2.60665994e-02f, -9.08632278e-02f, 1.18750982e-01f, 1.20900266e-01f, 8.80265981e-02f,
  -1.05731860e-01f, -1.01715121e-02f, 2.30569005e-01f, 4.74438742e-02f, -8.28676149e-02f, 1.78396448e-01f, 1.15057989e-03f, -1.47031710e-01f, 3.71433645e-02f, -1.25944033e-01f,
  -1.54413367e-02f, -4.27408576e-01f, 2.97977805e-01f, 1.83169059e-02f, 5.95065840e-02f, 2.39672661e-01f, 2.81045660e-02f, -7.80138597e-02f, -4.15996648e-02f, -6.14331476e-03f,
  -4.59265262e-02f, 1.67630956e-01f, 5.53172342e-02f, 1.10807559e-02f, 1.21095426e-01f, 3.18261348e-02f, 6.62268475e-02f, 1.81140780e-01f, 2.07629025e-01f, 8.17238614e-02f,
  -2.98429858e-02f, -5.78093641e-02f, -5.28677814e-02f, 2.97800940e-03f, -1.83689535e-01f, 3.73765454e-03f, -5.54501973e-02f, -2.31800437e-01f, -8.50819200e-02f, -1.04710303e-01f,
  2.01458588e-01f, -2.53835231e-01f, 1.00066870e-01f, -2.52023548e-01f, -7.72628710e-02f, -7.76012316e-02f, 7.95369968e-02f, -1.93210706e-01f, -2.26810768e-01f, -1.10040624e-02f,
  -7.71405995e-02f, -6.64924607e-02f, 6.85200244e-02f, -1.42905533e-01f, -4.35604379e-02f, -9.00366306e-02f, -1.43875435e-01f, -1.62553802e-01f, -9.19430628e-02f, -1.47112653e-01f,
  -1.03066847e-01f, -1.02726236e-01f, 1.18640520e-01f, 1.63976863e-01f, 4.90816571e-02f, -4.87440825e-02f, -1.35017902e-01f, -1.46038726e-01f, 7.01844022e-02f, -8.04596990e-02f,
  1.19373726e-03f, 1.02451295e-02f, 7.44722113e-02f, 8.34179670e-02f, 7.85162300e-02f, 8.64312649e-02f, 1.18062109e-01f, 1.79376286e-02f, 6.41214475e-02f, 2.82590520e-02f,
  3.17454413e-02f, 1.04874536e-01f, 3.15687561e-04f, -7.20209703e-02f, -1.80327501e-02f, -1.26869172e-01f, -5.87390661e-02f, -8.23769495e-02f, 9.54099894e-02f, -6.35755137e-02f,
  1.03969842e-01f, -1.20939195e-01f, -2.10132867e-01f, -1.69860616e-01f, -2.63740182e-01f, -5.90413883e-02f, 3.86792310e-02f, -5.41558377e-02f, -9.09670368e-02f, -4.03154343e-02f,
  1.50115713e-01f, 2.78828084e-01f, 2.46576011e-01f, -3.73098478e-02f, -1.66769195e-02f, -2.21691966e-01f, 1.09353133e-01f, -2.80061178e-02f, -1.14547752e-01f, 4.03945409e-02f,
  7.80238062e-02f, 5.93549572e-02f, 5.26877530e-02f, -9.56990048e-02f, 2.03528091e-01f, 1.89093780e-02f, -2.43334636e-01f, -1.16758041e-01f, -9.51884538e-02f, -5.69556542e-02f,
  -4.76194061e-02f, 1.83030590e-01f, 3.09221029e-01f, 3.53130668e-01f, 1.53880283e-01f, 2.55863696e-01f, 1.88302189e-01f, 1.36695400e-01f, 1.43813312e-01f, 1.11701891e-01f,
  2.18384296e-01f, -7.92480186e-02f, 1.28164530e-01f, 5.53150065e-02f, -4.46325272e-01f, -3.46088976e-01f, -5.15833139e-01f, -1.24102667e-01f, -1.26467600e-01f, -9.36745033e-02f,
  -2.87446260e-01f, -1.34729251e-01f, 6.33206517e-02f, 1.44893870e-01f, 1.60220027e-01f, 2.35694557e-01f, 3.03282112e-01f, 5.55179000e-01f, 3.78640234e-01f, 1.14652827e-01f,
  5.75215630e-02f, 3.23496670e-01f, 4.64953184e-01f, 2.68568128e-01f, 5.47413379e-02f, 5.69477119e-02f, 1.13132387e-01f, 5.65717630e-02f, 7.64819011e-02f, 4.99547154e-01f,
  2.42627278e-01f, -7.54303485e-02f, -3.07884902e-01f, -1.88003421e-01f, -1.77294508e-01f, 2.12846801e-01f, -3.01277842e-02f, 5.32995984e-02f, -7.28238821e-02f, 2.17903972e-01f,
  -1.54873505e-01f, -5.25888987e-02f, -1.43793412e-02f, -1.79491770e-02f, -5.87297305e-02f, -5.96313961e-02f, 1.23028152e-01f, 3.44744802e-01f, 1.35807499e-01f, -1.55210570e-01f,
  -3.68361250e-02f, -2.26536781e-01f, -3.82779598e-01f, -3.64688337e-01f, -1.27204597e-01f, -6.77496493e-02f, -1.36543259e-01f, -5.64146452e-02f, -1.41147703e-01f, 1.67452648e-01f,
  -9.55664590e-02f, -1.24328487e-01f, -2.45146342e-02f, 1.47494704e-01f, 1.25249401e-01f, 4.02688142e-03f, -1.61821898e-02f, -1.17747337e-01f, 1.14668027e-01f, 6.12427592e-02f,
  -2.80850530e-02f, -2.69939163e-04f, 1.32514879e-01f, 1.13899797e-01f, 4.74267686e-03f, 1.50630429e-01f, -1.14271425e-01f, 8.70811790e-02f, -1.50592610e-01f, -5.64889424e-02f,
  -1.09078951e-01f, 6.61966205e-02f, -1.59400031e-02f, 2.24525541e-01f, 7.79552236e-02f, -5.56261018e-02f, 1.94339484e-01f, -1.11665018e-02f, -8.20437297e-02f, -5.76632097e-02f,
  4.29482646e-02f, -1.62398651e-01f, -1.13115840e-01f, 8.22670460e-02f, -5.14583141e-02f, -5.73419742e-02f, 4.27565463e-02f, -9.83339548e-02f, -6.72453642e-02f, 9.82132852e-02f,
  -3.87964398e-02f, 1.70545563e-01f, 5.81888147e-02f, 1.08195342e-01f, -3.18297856e-02f, -2.99178846e-02f, -5.26083373e-02f, -1.06435250e-02f, 8.77469853e-02f, -5.98611794e-02f,
  1.20168954e-01f, -2.44884983e-01f, -3.57287019e-01f, -2.21212894e-01f, -3.55567902e-01f, -3.34473878e-01f, -1.05791226e-01f, -2.52479017e-01f, -4.16557819e-01f, -2.26120293e-01f,
  8.29854071e-01f, -4.73089889e-02f, -6.31733179e-01f, 2.54280150e-01f, -1.59446955e-01f, -4.57510687e-02f, -1.13493958e-02f, 7.80512393e-02f, 2.85609692e-01f, 1.91387504e-01f,
  -4.35865857e-02f, 6.50674105e-02f, -2.08873581e-02f, -1.37690291e-01f, 6.99803466e-03f, -6.64761662e-02f, -2.14660875e-02f, -1.23869583e-01f, -6.50171340e-02f, -1.78874552e-01f,
  2.50325501e-02f, 2.09800258e-01f, 2.56593019e-01f, -6.78869663e-03f, -3.20186913e-01f, -1.07466772e-01f, -1.28079459e-01f, -2.53000259e-01f, -3.17336440e-01f, -4.40080941e-01f,
  -4.85784739e-01f, -3.00561637e-01f, -2.71257088e-02f, -5.39156720e-02f, -1.92791313e-01f, 1.22990936e-01f, 6.41491413e-02f, -1.27931256e-02f, 1.00522950e-01f, 3.79018001e-02f,
  -1.56448051e-01f, -2.09512888e-03f, -1.75843034e-02f, -1.58524349e-01f, -1.02533743e-01f, -4.34205681e-02f, -3.07204798e-02f, -7.90782571e-02f, 4.70031537e-02f, -1.70751452e-01f,
  -1.69402108e-01f, -2.23372325e-01f, -2.16040477e-01f, -8.78012255e-02f, -3.10663790e-01f, -1.11116044e-01f, -3.02931637e-01f, -4.05646116e-01f, -1.49842978e-01f, -2.41033155e-02f,
  -3.20504606e-02f, 7.44569823e-02f, 2.14250330e-02f, 1.91146612e-01f, 3.33754987e-01f, 1.54302746e-01f, 8.59613568e-02f, 7.19177276e-02f, 8.28218386e-02f, 5.22461757e-02f,
  -1.25831097e-01f, 5.90144284e-02f, 1.13107651e-01f, 6.44107386e-02f, -8.82342905e-02f, -1.10318668e-01f, -3.03103775e-02f, 9.17377174e-02f, 7.12740794e-02f, 2.45603919e-01f,
  1.25533655e-01f, -5.95692135e-02f, 1.12052128e-01f, 9.38903540e-02f, -4.93227644e-03f, -3.26224826e-02f, -3.60604338e-02f, -9.17165168e-03f, 2.85566226e-02f, -2.66553201e-02f,
  3.79900962e-01f, -1.29610999e-03f, 1.23780623e-01f, 1.18964529e-02f, -2.46455241e-02f, 6.70179874e-02f, 8.32950994e-02f, 6.92069903e-02f, 2.51425151e-03f, -2.90164836e-02f,
  -1.56552359e-01f, 4.29383740e-02f, 4.50963937e-02f, -2.69245524e-02f, 1.42652586e-01f, 5.59174158e-02f, 1.87764153e-01f, 7.59848021e-03f, 1.15308531e-01f, -8.02988186e-02f,
  7.28310645e-02f, 2.27703854e-01f, 2.07117826e-01f, 1.29839793e-01f, 3.97417955e-02f, 1.46849722e-01f, 6.34853840e-02f, 4.02458534e-02f, 1.92561239e-01f, 4.37459916e-01f,
  -3.82728547e-01f, 4.11841661e-01f, 5.63526452e-02f, -2.45167345e-01f, 1.41601235e-01f, 2.57213324e-01f, 5.47633946e-01f, 1.59910053e-01f, -2.39730790e-01f, 1.10387474e-01f,
  1.67848423e-01f, -3.70122105e-01f, -2.19583124e-01f, -1.47439361e-01f, 7.90964141e-02f, 2.18699172e-01f, -2.09518559e-02f, -2.04094604e-01f, -2.36083582e-01f, -1.27185047e-01f,
  -2.48533580e-02f, -1.13560250e-02f, -2.13459581e-01f, -1.38905182e-01f, -1.06009960e-01f, -3.73687625e-01f, -2.32462101e-02f, 1.63057804e-01f, 1.86247885e-01f, -1.19197384e-01f,
  -3.23333256e-02f, 2.51972914e-01f, -4.11788762e-01f, -2.69445688e-01f, -3.72391865e-02f, -9.70904827e-02f, 1.26592899e-02f, -4.98355404e-02f, 3.22235152e-02f, -5.52671067e-02f,
  -7.36535713e-02f, 4.10585813e-02f, 5.66999763e-02f, 5.34236766e-02f, 1.70387458e-02f, -4.90087569e-02f, -2.45370120e-02f, -6.12953454e-02f, -1.29769027e-01f, -4.18678857e-02f,
  1.40675992e-01f, 1.64121062e-01f, 1.95880592e-01f, 1.16847530e-01f, 6.88524097e-02f, -1.34331450e-01f, 1.47358835e-01f, -3.78461070e-02f, -1.78480260e-02f, -1.40352041e-01f,
  7.72000030e-02f, -8.98697898e-02f, -1.03356466e-01f, -7.34076351e-02f, 6.38650134e-02f, 7.18413759e-03f, -2.93768235e-02f, 7.78114125e-02f, 1.43973632e-02f, 1.37736723e-01f,
  1.00463457e-01f, 7.03846589e-02f, 3.00887734e-01f, 1.26175344e-01f, -2.18360145e-02f, 1.52970925e-01f, 1.24809943e-01f, 1.14681467e-01f, 7.70807043e-02f, 7.14723393e-02f,
  -1.60347670e-02f, 1.48548514e-01f, 8.29515755e-02f, 7.08727315e-02f, 1.91215500e-01f, -1.68668311e-02f, 7.17939213e-02f, 4.29736823e-02f, 4.10173424e-02f, 1.32222041e-01f,
  -8.24952275e-02f, 3.19433749e-01f, -3.12875926e-01f, -6.17087968e-02f, 6.88321069e-02f, 6.64984211e-02f, 3.65018919e-02f, 6.82976693e-02f, 9.46669206e-02f, 5.29022701e-02f,
  1.39399111e-01f, 1.22280568e-01f, 2.60135770e-01f, 8.30590203e-02f, -3.77326459e-02f, 2.32219566e-02f, 8.42306837e-02f, -7.34069273e-02f, -2.62582004e-02f, 2.39731912e-02f,
  1.02765359e-01f, 3.59130800e-02f, -1.12466864e-01f, -7.81081691e-02f, -2.00898908e-02f, -2.19284952e-01f, -1.14795230e-02f, 3.59955244e-03f, -9.85748991e-02f, -4.64100428e-02f,
  1.09061740e-01f, -1.89203039e-01f, -2.03919765e-02f, 4.44528982e-02f, 7.77552510e-03f, 1.07332058e-01f, -5.08555770e-02f, 1.95502043e-02f, 1.01708949e-01f, 5.40249310e-02f,
  9.41986740e-02f, 1.39481634e-01f, 6.73764572e-02f, 6.13497943e-02f, -7.18970373e-02f, 8.85791555e-02f, 5.92659786e-02f, 1.56255066e-02f, 3.46044041e-02f, -6.35344312e-02f,
  1.89908426e-02f, -8.27240273e-02f, -1.41109988e-01f, -1.01808585e-01f, 2.71319896e-02f, -1.03637941e-01f, -1.25173062e-01f, -1.31431505e-01f, -7.80497044e-02f, -6.81624189e-02f,
  -7.44448826e-02f, 2.69884113e-02f, 2.23931238e-01f, 1.89034140e-03f, -4.79399078e-02f, -4.99321073e-02f, 5.06479153e-03f, -3.25415768e-02f, -5.86492568e-02f, -7.54962415e-02f,
  -1.08302049e-01f, -9.45480093e-02f, -8.08836333e-03f, 4.38253395e-02f, 4.33917111e-03f, -6.54275641e-02f, 2.17382550e-01f, 2.09988892e-01f, 1.30264014e-01f, 6.98947906e-02f,
  1.88017875e-01f, 2.04553545e-01f, 4.93525341e-02f, 1.96744859e-01f, 1.22818023e-01f, 9.33678597e-02f, -8.23496934e-03f, 1.60370544e-01f, 1.30733475e-01f, 1.64638892e-01f,
  1.55062731e-02f, 1.70758978e-01f, 1.84381828e-01f, 1.36813551e-01f, 6.61010714e-03f, 4.38045487e-02f, 2.15392765e-02f, -5.31844683e-02f, 9.24453214e-02f, -3.44858766e-02f,
  -3.05434857e-02f, 6.98850453e-02f, 1.45255014e-01f, -1.96114071e-02f, 1.41523272e-01f, -5.11732465e-03f, 2.99836732e-02f, 1.99923571e-02f, 9.43355337e-02f, -2.10205046e-03f,
  1.35766953e-01f, -2.30404418e-02f, -2.75880724e-01f, -9.62344632e-02f, 5.44741116e-02f, 5.67057207e-02f, 1.51706086e-02f, -8.88012573e-02f, -1.16875596e-01f, -7.75148794e-02f,
  -1.24674536e-01f, 2.36901164e-01f, 2.11359486e-01f, 1.07379928e-01f, -2.72075143e-02f, -2.64965538e-02f, 1.71194941e-01f, -1.21049233e-01f, -7.65909329e-02f, -9.53266695e-02f,
  5.51977521e-03f, -1.66704953e-01f, 4.34292592e-02f, 3.47973406e-02f, -9.88200977e-02f, 2.32531875e-02f, 1.96694732e-01f, 1.37699813e-01f, 7.64656290e-02f, -1.16500221e-01f,
  -3.69889587e-02f, 1.37121871e-01f, 2.01258078e-01f, 1.50706023e-01f, 5.99743389e-02f, 1.33871317e-01f, 2.54229046e-02f, -2.38386095e-02f, -4.43281159e-02f, -2.09788755e-02f,
  -5.80919743e-01f, -8.49885717e-02f, 5.73539697e-02f, -2.57648796e-01f, 9.33483541e-02f, 9.08600911e-02f, -4.08814847e-02f, 1.48570150e-01f, 1.20494626e-01f, 7.75194839e-02f,
  3.12025577e-01f, 8.86165649e-02f, -2.22384125e-01f, -2.90255696e-01f, -4.04291272e-01f, -1.78317800e-01f, -4.17064399e-01f, -4.27790970e-01f, -3.30440640e-01f, 1.25136971e-01f,
  -1.33973977e-03f, -1.92723274e-01f, -1.43089071e-01f, -9.95885581e-02f, 5.27065247e-02f, -3.76492292e-01f, -2.95707822e-01f, -3.21650088e-01f, -3.42142791e-01f, -5.30917585e-01f,
  -8.51868838e-02f, 1.81042090e-01f, 5.88042513e-02f, -6.65670410e-02f, -9.73099396e-02f, -2.95168981e-02f, 7.21473759e-03f, 1.70597866e-01f, 1.63903460e-01f, 5.32878488e-02f,
  1.84863120e-01f, 1.62782088e-01f, -2.71821231e-01f, 1.10259011e-01f, 9.56438631e-02f, 1.67800009e-01f, 2.70009071e-01f, 9.20666084e-02f, 9.49250162e-02f, 3.17429662e-01f,
  7.77405798e-02f, 2.78501846e-02f, -2.15545073e-02f, 1.43644825e-01f, 3.13071162e-01f, -1.39243558e-01f, -1.50584402e-02f, 7.57908151e-02f, -1.82681665e-01f, -3.61956149e-01f,
  -4.63729389e-02f, 9.80518460e-02f, 2.23050132e-01f, -1.34652425e-02f, 7.04250410e-02f, 1.24656305e-01f, -1.66192919e-01f, -1.32048920e-01f, -9.07018557e-02f, -1.93629488e-01f,
  1.37218639e-01f, 4.07195315e-02f, -5.11873066e-02f, -1.61323160e-01f, -9.55575183e-02f, -3.52939311e-03f, -3.15857194e-02f, -2.79640350e-02f, 1.47993546e-02f, -3.26822959e-02f,
  -3.33250058e-03f, -7.49373361e-02f, 9.55597013e-02f, -2.35939119e-02f, 7.68388659e-02f, -9.59943235e-02f, 2.95234919e-01f, 2.23491684e-01f, 2.99607038e-01f, 1.59759507e-01f,
  -3.32342207e-01f, -1.89820617e-01f, -2.58096814e-01f, 1.54834643e-01f, 3.27805057e-02f, 1.15838073e-01f, -2.08285987e-01f, 1.38228223e-01f, -2.46905424e-02f, 3.20236422e-02f,
  1.81484297e-01f, -5.71706332e-02f, -2.11197808e-01f, -5.20110782e-03f, -6.39373884e-02f, 2.28469804e-01f, 3.42402607e-02f, -2.35503688e-01f, -5.83359320e-03f, 2.01372951e-01f,
  -6.16188347e-02f, -5.99775799e-02f, -4.20278668e-01f, -4.12878543e-01f, -2.18173191e-01f, -4.73079592e-01f, -3.64179313e-01f, -3.27633440e-01f, -5.12676597e-01f, -8.37668598e-01f,
  1.16097637e-01f, 2.31458127e-01f, 1.44848347e-01f, 2.77135074e-01f, 2.15991497e-01f, -2.08775669e-01f, -2.57222474e-01f, -4.08335596e-01f, 2.93921940e-02f, 1.93718728e-02f,
  1.48288712e-01f, -8.79390612e-02f, 5.78419417e-02f, -1.81103662e-01f, -4.13361669e-01f, -1.54830620e-01f, -1.01466447e-01f, -3.57734978e-01f, -5.56328416e-01f, -3.87263179e-01f,
  -8.31134319e-02f, 6.94009438e-02f, -1.05177134e-01f, -1.03903294e-01f, 4.57915008e-01f, 1.12601005e-01f, 4.10543799e-01f, 2.16767117e-01f, 8.65059644e-02f, 3.09680104e-01f,
  1.80937603e-01f, 3.95447403e-01f, -1.37247026e-01f, -1.89776160e-02f, 2.34922633e-01f, -9.01002586e-02f, -1.48393631e-01f, -3.31755728e-02f, 2.01912578e-02f, 1.25875305e-02f,
  2.25815609e-01f, 1.03827789e-01f, 9.54832975e-03f, 7.00490996e-02f, -3.11338473e-02f, -6.94342107e-02f, -1.22511767e-01f, -3.04624677e-01f, -1.07234210e-01f, -1.93647116e-01f,
  -9.27819908e-02f, 1.33628011e-01f, 1.02296308e-01f, -5.32632321e-02f, 8.87925103e-02f, -4.99526644e-03f, 1.73839316e-01f, 1.45332828e-01f, -1.81735940e-02f, 5.03453799e-02f,
  -7.05432743e-02f, 1.16160408e-01f, 3.37961875e-03f, 1.57847464e-01f, 4.80219983e-02f, 5.69760315e-02f, 1.40832230e-01f, -3.15735862e-02f, -2.17177626e-02f, 6.83893077e-03f,
  -2.03276262e-01f, 1.74222253e-02f, 1.22288845e-01f, 2.23087575e-02f, -5.35716005e-02f, 1.46015361e-01f, -1.74075514e-02f, -1.01662345e-01f, 4.87872474e-02f, 1.33981988e-01f,
  -1.58979539e-02f, -3.08859814e-02f, -1.44421365e-02f, -1.83666542e-01f, -7.50818253e-02f, 5.94383292e-02f, 7.24909976e-02f, 2.23271810e-02f, 4.17399108e-02f, 1.86789557e-01f,
  9.22817588e-02f, 4.73964959e-02f, 5.46570681e-02f, -9.75684077e-02f, 6.95544258e-02f, 1.09641805e-01f, 1.44562438e-01f, -8.06600451e-02f, 2.14365304e-01f, -8.89098421e-02f,
  -1.43140674e-01f, -3.26349661e-02f, 1.07490234e-01f, -2.52780765e-01f, -2.08051786e-01f, 4.91539501e-02f, -7.87708685e-02f, -1.10630885e-01f, -2.36048028e-01f, 7.87391439e-02f,
  -2.02931777e-01f, -3.03663313e-01f, -3.27467322e-01f, -1.59788251e-01f, -9.58211645e-02f, -1.32186294e-01f, -1.01377577e-01f, -9.04352218e-02f, -8.94192383e-02f, -3.22393298e-01f,
  -5.29280484e-01f, -1.59102589e-01f, -3.15174669e-01f, -7.32191920e-01f, -4.48046833e-01f, -2.74572019e-02f, -1.50374630e-02f, -2.20526874e-01f, -4.25707519e-01f, -2.40555555e-01f,
  -4.22948971e-02f, 3.02717268e-01f, -1.75784916e-01f, 1.90767907e-02f, 1.28615022e-01f, -3.78797203e-01f, -6.23217762e-01f, -1.36329323e-01f, 3.53179455e-01f, 4.34459209e-01f,
  1.97831262e-02f, -9.97664109e-02f, -1.87040076e-01f, -1.45271808e-01f, -3.08731794e-01f, 3.53848115e-02f, -4.07347977e-01f, -2.85829157e-01f, -8.43786448e-02f, -4.80601221e-01f,
  2.77239203e-01f, -2.38556862e-01f, -1.07246496e-01f, -2.24093169e-01f, -1.47480145e-01f, -6.73402995e-02f, 6.53604418e-02f, -1.94776818e-01f, 2.31928416e-02f, -1.04032293e-01f,
  -1.48382604e-01f, -8.19237381e-02f, 8.31520278e-03f, 7.27155283e-02f, 2.23767702e-02f, 1.02414586e-01f, -1.93508461e-01f, -1.55713350e-01f, -2.31810808e-01f, 3.30454931e-02f,
  -3.73519845e-02f, -1.27109841e-01f, 7.17057660e-02f, 6.10589534e-02f, -7.93232545e-02f, -3.62863354e-02f, 6.45768866e-02f, -2.49313079e-02f, 3.86989079e-02f, -1.28695056e-01f,
  -2.79075140e-03f, 4.84901294e-02f, 1.34752035e-01f, 1.51269689e-01f, -1.10341869e-01f, -1.07162474e-02f, 4.74151708e-02f, 3.95187549e-02f, -6.94402754e-02f, 9.69399810e-02f,
  -4.81668748e-02f, -1.55785918e-01f, 5.95583096e-02f, 2.45297365e-02f, -4.59691994e-02f, -3.58124040e-02f, 8.66935626e-02f, -8.72179270e-02f, -3.11381854e-02f, -1.43831655e-01f,
  -7.26647377e-02f, -6.61486164e-02f, -7.50546083e-02f, 5.10810316e-02f, -7.99619332e-02f, -1.42503768e-01f, -3.12189246e-03f, 1.73352167e-01f, 1.14616282e-01f, 1.71509981e-02f,
  4.82601821e-01f, -2.60289103e-01f, -8.66308361e-02f, 5.91770001e-02f, -5.71143106e-02f, -6.84823245e-02f, -8.33368152e-02f, -1.24604218e-01f, -3.56180109e-02f, 1.22739552e-02f,
  -3.80616784e-02f, 8.69684145e-02f, -1.16098545e-01f, 1.47989541e-01f, 1.22717313e-01f, 5.60733303e-02f, -1.67406984e-02f, 1.45467237e-01f, -1.32480070e-01f, 2.67362986e-02f,
  -1.04284532e-01f, 3.32653485e-02f, 3.18843961e-01f, 1.61179289e-01f, -5.15538678e-02f, 1.61512047e-01f, 2.56711483e-01f, 1.24223158e-01f, 1.82678491e-01f, 1.95751771e-01f,
  -5.29060721e-01f, -1.53240666e-01f, -4.29911196e-01f, 2.41647795e-01f, 4.62942898e-01f, 2.55058736e-01f, 1.55108690e-01f, -6.18435629e-02f, 1.18792236e-01f, 8.75450075e-02f,
  6.67714328e-02f, 2.75584191e-01f, 6.96320981e-02f, 2.31532142e-01f, -5.10158539e-02f, 1.22911789e-01f, 2.37761334e-01f, 4.63902354e-02f, 7.82107040e-02f, 1.50346965e-01f,
  3.96118611e-01f, 4.20455337e-02f, -3.29290837e-01f, 9.80260596e-02f, 1.78161755e-01f, 2.47938156e-01f, 7.12934360e-02f, -3.98257971e-02f, 2.22015366e-01f, 3.27982098e-01f,
  -5.44404507e-01f, -4.61118907e-01f, 1.72243416e-01f, 2.70260543e-01f, 8.85150023e-03f, -3.70511979e-01f, -2.77602494e-01f, -3.58276576e-01f, -9.01562721e-02f, -2.46198952e-01f,
  1.47932068e-01f, -1.12783127e-01f, 1.30318671e-01f, -7.68285692e-02f, -6.14753701e-02f, -1.67786494e-01f, -2.18648344e-01f, -3.60159308e-01f, -3.29101205e-01f, -3.56329501e-01f,
  6.96032941e-01f, 2.48474047e-01f, -3.97287369e-01f, -2.55397022e-01f, -3.73216033e-01f, 5.99447712e-02f, -3.65452707e-01f, -2.72292823e-01f, -3.96808982e-01f, -4.89303529e-01f,
  2.24011787e-03f, 5.22140525e-02f, 1.00778207e-01f, -2.65341215e-02f, 1.72803491e-01f, 1.37807712e-01f, 2.22011909e-01f, 1.90675467e-01f, 1.73630416e-01f, -8.09033662e-02f,
  9.59701613e-02f, -1.20686539e-01f, -1.34681419e-01f, -1.07028700e-01f, 1.56924084e-01f, -1.20128049e-02f, 4.87595014e-02f, 2.93926466e-02f, 1.45676315e-01f, -2.52378229e-02f,
  6.49185106e-02f, 1.02626598e-02f, 9.49568748e-02f, 9.73470286e-02f, 7.65802525e-03f, 1.49239153e-01f, -5.62361702e-02f, 1.03080675e-01f, 8.62779245e-02f, -1.32440934e-02f,
  -4.03783828e-01f, -1.69335037e-01f, -2.46573046e-01f, -7.82427043e-02f, 3.70853767e-02f, -2.37821434e-02f, -7.47824013e-02f, -1.63492203e-01f, 7.98777714e-02f, -1.32509172e-01f,
  -1.11126900e-02f, -2.43088096e-01f, -2.18458056e-01f, -6.77046254e-02f, 8.27580243e-02f, -2.91796904e-02f, 1.24116391e-01f, 1.42587751e-01f, -7.98449889e-02f, -5.83857521e-02f,
  2.84551591e-01f, 6.83446676e-02f, -1.92476839e-01f, -1.66455507e-01f, -7.87025169e-02f, -7.44208172e-02f, -2.22498611e-01f, -2.13107452e-01f, -4.01377171e-01f, -3.18325996e-01f,
  1.21031605e-01f, 2.17996240e-01f, 3.14516693e-01f, 2.27155238e-01f, -1.16517372e-01f, -4.89958376e-01f, -6.24594331e-01f, -2.91282058e-01f, -8.30588862e-02f, 1.80079937e-01f,
  -5.25057986e-02f, -9.97926295e-03f, 2.69064475e-02f, -1.54950954e-02f, -1.63129404e-01f, 6.79269657e-02f, 1.50944650e-01f, -6.49891645e-02f, -2.63012886e-01f, -2.69055635e-01f,
  -1.28557369e-01f, -1.70014594e-02f, -1.68418465e-03f, 1.12140561e-02f, 4.60666597e-01f, 6.48153722e-02f, 4.26583923e-02f, 1.82223588e-01f, -2.69345008e-02f, 5.35454094e-01f,
  4.23467636e-01f, 1.55744910e-01f, -1.05985574e-01f, -4.82684607e-03f, 1.81392595e-01f, 3.07983272e-02f, 5.87035157e-03f, 1.72548324e-01f, 1.57083794e-02f, -3.43189575e-02f,
  1.81603909e-01f, 7.38613680e-02f, 5.25474809e-02f, 1.65529940e-02f, 8.45842157e-03f, -1.49231285e-01f, -1.48911439e-02f, -1.90785937e-02f, 8.74003321e-02f, 1.30498275e-01f,
  1.32900044e-01f, -6.84927329e-02f, -1.27510995e-01f, -2.68781543e-01f, -1.88515887e-01f, -4.84808311e-02f, -2.29007035e-01f, -6.83862194e-02f, -3.23903054e-01f, -1.34797201e-01f,
  -4.49890286e-01f, -3.96094471e-02f, 6.65834397e-02f, -1.58540934e-01f, -1.20750375e-01f, -4.29912657e-02f, 7.23708561e-03f, -1.06063172e-01f, -1.17618456e-01f, -8.40121061e-02f,
  4.80007045e-02f, 1.25000089e-01f, -2.40038577e-02f, 5.22882417e-02f, 7.71423802e-02f, 9.22509953e-02f, 2.53100339e-02f, 3.72484438e-02f, 5.74217997e-02f, 1.24154732e-01f,
  4.15200330e-02f, -9.62756854e-03f, 3.05327505e-01f, 7.21457005e-02f, 7.36226887e-02f, 3.95166427e-02f, -3.06987856e-02f, -7.73885921e-02f, 2.01858096e-02f, 8.66812244e-02f,
  -4.53926157e-03f, -2.22792432e-01f, 3.04417551e-01f, 2.42825329e-01f, 2.07288951e-01f, 2.22387582e-01f, 2.11399719e-01f, 1.03607088e-01f, 1.29917905e-01f, 7.69787580e-02f,
  2.32765693e-02f, 6.60270080e-02f, 2.00830996e-01f, 4.30900976e-02f, -1.42828375e-01f, -6.99629411e-02f, 4.52670828e-02f, 1.43928260e-01f, 6.28354922e-02f, 1.24707244e-01f,
  7.27928728e-02f, -2.28231192e-01f, -2.14930370e-01f, -1.49354145e-01f, 6.37743175e-02f, -1.48827657e-01f, -7.90285692e-02f, -1.46328270e-01f, -1.92491099e-01f, -3.47375363e-01f,
  5.16696930e-01f, -5.64997792e-01f, 3.99503261e-01f, 2.60444105e-01f, 3.74098390e-01f, 3.59368026e-01f, 2.97564358e-01f, 7.52587095e-02f, 5.47221527e-02f, 3.81478406e-02f,
  -4.59668219e-01f, -6.43622458e-01f, -6.24469161e-01f, -4.74019766e-01f, -3.44193935e-01f, 6.05676062e-02f, 3.40610981e-01f, 3.47794652e-01f, 2.19444945e-01f, 1.15161143e-01f,
  -2.81982254e-02f, 3.44936907e-01f, 1.98453546e-01f, 2.54475679e-02f, 4.91317138e-02f, -9.30021033e-02f, 6.29249737e-02f, 9.49417651e-02f, -1.32302538e-01f, 2.22054422e-01f,
  -8.48947391e-02f, -1.19625166e-01f, 1.11218251e-01f, -1.29130885e-01f, -1.03066251e-01f, -1.15710929e-01f, -1.66991409e-02f, -6.84527308e-02f, -9.73356292e-02f, -3.58935036e-02f,
  -9.51300785e-02f, -2.20123932e-01f, -3.01685989e-01f, -1.38105035e-01f, 3.21699455e-02f, 9.81690064e-02f, -2.35612065e-01f, 1.78077398e-03f, -1.54407665e-01f, -2.92156875e-01f,
  -3.02443296e-01f, 1.46247447e-01f, 2.42807850e-01f, -6.39467016e-02f, -1.75208822e-01f, 1.55416233e-02f, 5.34740612e-02f, -5.93578070e-02f, 1.62614454e-02f, 1.16714813e-01f,
  2.90135574e-02f, 5.38674407e-02f, 3.94180231e-02f, 1.28792614e-01f, 6.82886541e-02f, -8.68957043e-02f, 1.32488936e-01f, -3.26917320e-02f, 6.54400289e-02f, 1.00374520e-01f,
  -3.03756837e-02f, 2.88315173e-02f, 7.76835829e-02f, 1.80270020e-02f, -2.22942345e-02f, 5.78036159e-02f, 1.23367332e-01f, -1.33216754e-01f, -7.39953071e-02f, 8.50306675e-02f,
  8.48314783e-04f, 1.58164985e-02f, -3.99759635e-02f, -1.08176075e-01f, -6.02331571e-02f, 2.46604811e-02f, 1.23145036e-01f, -4.41598222e-02f, -2.99129225e-02f, 2.06163630e-01f,
  -4.36142534e-02f, -1.65923223e-01f, -3.27725112e-02f, -1.51751041e-01f, 1.03252135e-01f, -1.65535852e-01f, -8.15814659e-02f, -5.42127155e-02f, 2.01507136e-02f, -1.11037809e-02f,
  -1.85964465e-01f, -1.31465569e-01f, -2.24872202e-01f, -7.33534768e-02f, 1.06167436e-01f, 1.40378565e-01f, -1.75743818e-01f, -4.95358445e-02f, -1.22008361e-01f, -2.79203020e-02f,
  -7.08777830e-03f, 2.09546700e-01f, 1.66038021e-01f, -3.28582823e-02f, -7.48959258e-02f, 1.16608202e-01f, 1.61966145e-01f, 1.89827338e-01f, 9.24724527e-03f, 2.61200339e-01f,
  7.66104162e-01f, -6.06512964e-01f, -1.64919838e-01f, 1.62033856e-01f, -2.02929541e-01f, -3.73981893e-01f, -8.71290565e-01f, -2.50245839e-01f, -3.69172776e-03f, -4.83733922e-01f,
  -6.10530935e-02f, 4.70574379e-01f, 4.07912672e-01f, 4.26577896e-01f, 2.32760489e-01f, -6.62865639e-01f, -2.78163135e-01f, 4.57105368e-01f, 5.31037390e-01f, -6.36786893e-02f,
  -1.51846543e-01f, 2.11306706e-01f, 3.59972775e-01f, 1.25174433e-01f, -5.12679875e-01f, 2.39412025e-01f, -3.40182096e-01f, -3.39271203e-02f, -3.92215848e-01f, -4.13233459e-01f,
  -2.29101107e-01f, -1.98598996e-01f, 1.34723589e-01f, 2.82016516e-01f, 1.29439356e-02f, -1.15854055e-01f, -2.31539637e-01f, -5.89023679e-02f, -8.90106559e-02f, -2.01708883e-01f,
  9.46184099e-02f, -1.48094967e-02f, 1.96545556e-01f, -7.47044990e-03f, -2.38422100e-02f, -1.14731200e-01f, -6.60333335e-02f, -4.77292687e-02f, 9.68753397e-02f, -1.35976955e-01f,
  -1.63152054e-01f, -3.24395895e-02f, -1.73373688e-02f, -2.66634226e-01f, -1.93105295e-01f, 3.20557356e-01f, -4.75105196e-01f, -3.69249791e-01f, -1.15840964e-01f, -6.25720263e-01f,
  -1.47424176e-01f, 1.19274762e-03f, 4.62071039e-02f, -8.88339281e-02f, -3.10865957e-02f, 5.54323643e-02f, 9.33737215e-03f, -7.55694434e-02f, 8.51807930e-03f, 2.57601589e-02f,
  8.36980641e-02f, -8.70347470e-02f, -5.53322285e-02f, -1.31718099e-01f, -4.02784050e-02f, -1.75773650e-02f, -7.91387409e-02f, -6.81229830e-02f, 2.64512617e-02f, 4.21391316e-02f,
  3.71320024e-02f, -1.70402396e-02f, 4.02455106e-02f, 9.20523927e-02f, 1.63708143e-02f, 7.46577680e-02f, -7.81916603e-02f, 4.69247214e-02f, 1.50462091e-01f, 6.79794252e-02f,
  7.42833912e-02f, 4.35125381e-01f, -1.82794943e-01f, 5.26747070e-02f, -5.39942272e-02f, -1.69518311e-02f, -1.74148694e-01f, 2.02380177e-02f, 1.55302137e-01f, 6.64594444e-03f,
  -1.18774749e-01f, -6.92244843e-02f, -6.07981533e-02f, -1.16987556e-01f, -2.29797866e-02f, -8.80620182e-02f, -7.20475195e-03f, 1.54241711e-01f, -3.12048681e-02f, -9.89952534e-02f,
  7.37471730e-02f, -1.31111071e-01f, 1.71838507e-01f, -5.87107912e-02f, -5.10144457e-02f, 1.06801704e-01f, -1.33950546e-01f, -1.88695490e-01f, 2.54809223e-02f, -4.75058258e-01f,
  -5.43756068e-01f, -1.16226338e-01f, 5.92075050e-01f, -4.41514105e-01f, -4.57413375e-01f, -2.49209031e-01f, -1.92026213e-01f, -4.63920176e-01f, -3.87763262e-01f, -3.55784595e-02f,
  -9.76203158e-02f, -5.32394767e-01f, -1.61492437e-01f, -3.79079580e-03f, 9.59545225e-02f, 3.54378998e-01f, 4.30999249e-01f, 3.02699059e-01f, -7.41338134e-02f, -2.93949693e-01f,
  -2.20005140e-01f, -1.87481031e-01f, -1.70393172e-03f, 4.89465073e-02f, -1.94804907e-01f, -1.40494660e-01f, 3.75726253e-01f, -2.92852521e-03f, 3.41204077e-01f, 1.51300788e-01f,
  1.40160710e-01f, 6.79366961e-02f, 1.61640629e-01f, -5.54546788e-02f, 1.32322550e-01f, -1.80337485e-02f, -1.77569404e-01f, -1.39544070e-01f, -3.52463089e-02f, 1.43446818e-01f,
  -1.53446347e-01f, -2.62865514e-01f, -3.78899634e-01f, -6.82272017e-02f, -3.01928729e-01f, -8.11166391e-02f, 9.99632552e-02f, 2.41287172e-01f, 2.51790524e-01f, 2.38289218e-02f,
  -4.78778742e-02f, -9.77553502e-02f, 1.38404425e-02f, 1.40129939e-01f, 3.05919666e-02f, 6.40857816e-02f, 3.13652642e-02f, 9.60993487e-03f, 4.36653376e-01f, -7.11266324e-03f,
  -6.73325062e-02f, -3.97932269e-02f, 8.26598704e-02f, 4.54259962e-02f, -1.17047772e-01f, -1.04178853e-01f, 2.08918527e-02f, -1.94537535e-01f, -4.13654884e-03f, -8.45393986e-02f,
  -6.07163310e-02f, 1.19797319e-01f, -1.00379437e-01f, 6.00989610e-02f, -6.76847771e-02f, 2.78394204e-03f, -2.81379875e-02f, 6.68364093e-02f, 1.94607794e-01f, 2.67525204e-02f,
  1.43549517e-02f, 1.03029668e-01f, -7.43023725e-03f, -1.88470885e-01f, 1.97421163e-01f, 1.69634968e-01f, -5.91875166e-02f, 1.16685264e-01f, -1.14129819e-01f, 6.60527796e-02f,
  -3.84394735e-01f, 5.00258088e-01f, -1.41662657e-01f, -4.18356508e-02f, -3.07301637e-02f, 2.23344490e-01f, 1.13801092e-01f, 1.51848838e-01f, -8.94156098e-02f, -1.13978587e-01f,
  -3.32323834e-02f, -1.84293315e-01f, -5.67264780e-02f, -9.34097171e-03f, -3.37180495e-01f, -2.23437965e-01f, -1.06372245e-01f, -2.04229206e-01f, 5.75183742e-02f, -7.18505681e-02f,
  2.09206785e-03f, -1.67030349e-01f, -4.50111121e-01f, -4.25789267e-01f, -1.40471891e-01f, -2.23310947e-01f, -1.33105651e-01f, -1.94707379e-01f, 1.01386949e-01f, -2.97546029e-01f,
  4.68002647e-01f, 3.16262543e-01f, -5.22200048e-01f, 4.28644896e-01f, -8.21942464e-02f, -2.36634299e-01f, -1.64378762e-01f, -5.96485361e-02f, 2.07401946e-01f, 1.70257673e-01f,
  1.62170053e-01f, -1.92592189e-01f, -1.48172319e-01f, -3.36228013e-01f, -3.44445378e-01f, -2.15688586e-01f, -1.66945934e-01f, -4.19950813e-01f, -6.42331183e-01f, -1.89982742e-01f,
  1.24546334e-01f, 3.66677552e-01f, 2.24392176e-01f, -1.78023338e-01f, 2.43492603e-01f, -1.51317567e-01f, 4.96608056e-02f, 1.49244651e-01f, -2.38021374e-01f, 9.05031189e-02f,
  -1.51306108e-01f, -2.71802004e-02f, -2.99876750e-01f, -2.65596192e-02f, 4.14307006e-02f, -5.11756316e-02f, -4.88987751e-02f, 1.02724843e-02f, 3.49954516e-03f, 2.62491778e-02f,
  -9.02363360e-02f, -1.96757540e-01f, -3.96415621e-01f, -1.63673759e-01f, -7.70572871e-02f, -1.44750729e-01f, 4.09625247e-02f, -2.21994191e-01f, -2.53984774e-03f, -8.00539851e-02f,
  5.28251603e-02f, -1.34520471e-01f, -2.05762014e-01f, -1.14705682e-01f, -3.47864866e-01f, -2.14738026e-01f, -3.01069200e-01f, -4.45216388e-01f, -3.64734083e-01f, 3.56072307e-01f,
  1.17222942e-01f, -5.84841752e-03f, -7.65498877e-02f, 1.52304396e-01f, 1.70278281e-01f, -1.27989084e-01f, -2.48641707e-02f, 2.33186060e-03f, -6.08051047e-02f, 2.29598377e-02f,
  -3.86220664e-02f, 5.56420237e-02f, -2.12680120e-02f, 1.37491021e-02f, -9.50725898e-02f, -6.67128712e-02f, -6.89421147e-02f, 1.36446908e-01f, 6.17406815e-02f, -8.62652361e-02f,
  -4.25486267e-02f, -1.34165108e-01f, 3.62232812e-02f, -8.72709043e-03f, -4.12336998e-02f, -1.12787716e-01f, 5.94030358e-02f, -1.18078694e-01f, -5.64907119e-02f, 6.64574131e-02f,
  3.80627930e-01f, -2.79946297e-01f, 3.21106464e-02f, -6.96626976e-02f, 1.24562439e-02f, -1.00374989e-01f, 5.19275106e-02f, -7.33843967e-02f, -9.61268321e-02f, -7.91936740e-02f,
  -1.85374022e-01f, -2.33722582e-01f, 6.04008697e-02f, -1.25880241e-02f, -7.05789402e-02f, -6.39845207e-02f, 1.31252348e-01f, -1.04325563e-01f, 7.88366050e-02f, 1.79044202e-01f,
  2.02205464e-01f, 4.17554416e-02f, 1.81855395e-01f, -5.46569005e-02f, 1.26131803e-01f, -8.62139743e-03f, -3.91300097e-02f, -1.41712293e-01f, -3.23188096e-01f, 3.94347340e-01f,
  -7.01676428e-01f, -2.42706910e-01f, -5.06695092e-01f, -8.18456233e-01f, -3.31285030e-01f, -1.78183988e-02f, -1.24459930e-01f, 6.73175082e-02f, -2.75589049e-01f, -3.45169246e-01f,
  1.00217953e-01f, 1.30055010e-01f, -2.86623389e-01f, 6.89316317e-02f, -5.05476631e-02f, -4.93441820e-01f, -5.90050876e-01f, -2.30818450e-01f, 2.06851631e-01f, 2.43181705e-01f,
  -1.17732175e-01f, -1.31019592e-01f, -8.22807755e-03f, 2.05874592e-01f, -1.51241988e-01f, 8.07525367e-02f, -1.16328642e-01f, -2.64480859e-01f, 4.72939052e-02f, -4.17032301e-01f,
  9.22671407e-02f, -2.73655295e-01f, 1.43382028e-02f, -6.49850443e-03f, -1.75431699e-01f, -3.19791317e-01f, -6.94337860e-02f, -5.57268085e-03f, 1.02983743e-01f, -2.62102455e-01f,
  -2.72152275e-01f, -1.80049203e-02f, -3.57789963e-01f, -6.74411878e-02f, -1.26712635e-01f, -1.12905562e-01f, -8.79286379e-02f, -2.33994544e-01f, -2.15289176e-01f, -2.24428430e-01f,
  -2.32300133e-01f, -1.92143187e-01f, -4.33294810e-02f, 2.05629766e-01f, 9.42442492e-02f, -4.00354803e-01f, 1.52691275e-01f, -3.43049616e-02f, 1.03586830e-01f, -4.78058159e-02f,
  -6.57116547e-02f, 1.09345689e-01f, -2.37355251e-02f, -6.41891137e-02f, 1.05541520e-01f, 9.84728411e-02f, 7.24175991e-03f, 7.60230348e-02f, 1.82427272e-01f, 1.75390020e-01f,
  1.21256910e-01f, 7.88498074e-02f, 2.50566453e-01f, 1.69095755e-01f, 1.25378311e-01f, -2.51868162e-02f, 1.52485922e-01f, 1.49643272e-01f, 9.58999768e-02f, 2.16092527e-01f,
  1.36230320e-01f, 2.38256201e-01f, 1.28275022e-01f, 2.56898195e-01f, -4.90366332e-02f, -1.01167366e-01f, -1.02163978e-01f, 1.78339556e-01f, 7.18236342e-02f, -1.23073682e-01f,
  3.13895643e-01f, -9.17711705e-02f, -3.10883164e-01f, 7.70703703e-02f, -4.84443679e-02f, 4.91507836e-02f, -1.86692774e-01f, 6.97485209e-02f, -1.25627697e-01f, -4.65628356e-02f,
  6.68256804e-02f, 5.05080149e-02f, -1.35410950e-01f, -5.93791232e-02f, 5.17412722e-02f, -9.68204215e-02f, -1.00214832e-01f, -2.23173425e-01f, -4.81390990e-02f, 2.41286326e-02f,
  -1.30755574e-01f, 2.80377101e-02f, -2.21108031e-02f, 6.77286610e-02f, 1.14649534e-01f, -1.69251516e-01f, 3.06650341e-01f, 2.10371181e-01f, -4.56195064e-02f, 1.71323746e-01f,
  6.44830763e-01f, 4.29111794e-02f, 2.28728399e-01f, 2.28543460e-01f, -1.37825757e-01f, -2.49621332e-01f, -3.99049848e-01f, -9.36660096e-02f, -3.99462916e-02f, 1.10541128e-01f,
  6.76889047e-02f, 2.19865531e-01f, 1.30877957e-01f, 2.68864091e-02f, 1.62841976e-01f, -7.91163892e-02f, -5.27820811e-02f, 1.88830703e-01f, 1.31488502e-01f, 5.61837405e-02f,
  5.61577491e-02f, 1.13832183e-01f, 3.93741280e-01f, 1.94693714e-01f, 1.76693752e-01f, 1.00269243e-01f, 6.27471432e-02f, 2.27030709e-01f, 5.97020462e-02f, 3.00976723e-01f,
  5.29507101e-01f, 3.08642060e-01f, -7.31415153e-02f, 7.35393539e-02f, 3.17941420e-02f, 6.69621071e-03f, 2.95051932e-02f, 1.75132994e-02f, -2.12496761e-02f, 2.41340715e-02f,
  -7.18901157e-02f, 8.07890370e-02f, -4.56336513e-02f, -1.05531357e-01f, -7.00601116e-02f, 4.91209514e-02f, 1.89553984e-02f, 3.65047157e-02f, 4.30142647e-03f, 3.06404568e-02f,
  -1.39730722e-01f, -1.03418767e-01f, -7.22117648e-02f, -2.16986656e-01f, -3.56882289e-02f, -3.67594101e-02f, -7.14347884e-02f, 2.31018644e-02f, 2.23646443e-02f, 8.68660212e-02f,
  3.17319900e-01f, 2.33022124e-01f, 1.68124035e-01f, 1.51529953e-01f, 6.59756735e-02f, 2.48209946e-02f, -5.87762631e-02f, 1.25011221e-01f, 1.52008757e-01f, 1.58653390e-02f,
  -3.27468589e-02f, 5.44559099e-02f, 5.42718582e-02f, 9.11160558e-02f, 1.69559300e-01f, 7.38950074e-02f, -5.56556992e-02f, 1.25382945e-01f, 5.98092191e-02f, 9.56545547e-02f,
  1.28491104e-01f, -3.67174931e-02f, 9.13457572e-02f, -6.53102323e-02f, -1.44645497e-02f, 4.36662920e-02f, 1.50506333e-01f, -9.64738545e-04f, 1.35848388e-01f, 1.03548430e-01f,
  -1.04151137e-01f, -8.19010511e-02f, 6.94558173e-02f, 2.46157199e-02f, -8.56154561e-02f, -7.29720816e-02f, 8.73671845e-02f, 1.91688277e-02f, 4.41282950e-02f, -3.18287276e-02f,
  1.94050372e-02f, -1.33108171e-02f, -1.31559834e-01f, -1.20200641e-01f, -4.03100736e-02f, -1.20622955e-01f, -6.28663152e-02f, -6.15361147e-02f, -7.32619166e-02f, -1.14335559e-01f,
  -2.39864260e-01f, -2.76457489e-01f, -2.17688650e-01f, -3.26959461e-01f, -1.92202091e-01f, -2.20832273e-01f, -1.58943117e-01f, -1.17973670e-01f, -2.29531735e-01f, -1.18058540e-01f,
  1.16530597e+00f, 2.45966032e-01f, 4.88950253e-01f, 2.64627099e-01f, 5.95669402e-03f, 1.77562475e-01f, 2.82902777e-01f, 2.28902921e-01f, 1.04794614e-01f, 7.08661228e-02f,
  -8.83049741e-02f, 5.22656785e-03f, 4.84392345e-02f, 2.60560140e-02f, 1.68082774e-01f, 5.82987182e-02f, -1.63852621e-03f, 2.65718400e-01f, 2.41391480e-01f, 1.77555382e-01f,
  -3.38501967e-02f, 1.18220903e-01f, 2.89414138e-01f, 9.47162062e-02f, -1.01469472e-01f, -2.75873374e-02f, 2.27321070e-02f, 4.75819148e-02f, 3.20326798e-02f, 3.40100862e-02f,
  -1.64852485e-01f, 4.62193936e-01f, -1.25015840e-01f, -1.39706284e-01f, -5.83113097e-02f, -1.24367841e-01f, 4.60010543e-02f, -1.44731417e-01f, -8.76174495e-02f, -1.57310963e-01f,
  -1.49441138e-01f, -3.21600623e-02f, 7.44414777e-02f, -1.15861066e-01f, -1.98079981e-02f, -1.29028574e-01f, -2.03610025e-03f, 1.14953555e-01f, 1.73456129e-02f, -5.55341579e-02f,
  -6.85133189e-02f, 8.01957212e-03f, 2.06739660e-02f, -1.82239816e-03f, 1.44160002e-01f, -2.74720080e-02f, 7.66300857e-02f, 3.88356410e-02f, 3.37020010e-02f, 2.19881535e-01f,
  -1.45487100e-01f, 1.17997356e-01f, 2.30656564e-01f, 2.08312616e-01f, 1.89920291e-01f, 1.26562566e-01f, 7.25231096e-02f, -5.93730099e-02f, 1.62398696e-01f, 1.68961599e-01f,
  -1.43738642e-01f, 3.67905982e-02f, 9.94461328e-02f, 2.16853470e-02f, -5.30073270e-02f, -1.06401995e-01f, -7.59642646e-02f, -3.55925784e-02f, 3.87881696e-02f, -7.08295330e-02f,
  9.44629684e-02f, 8.40410870e-03f, -1.08231781e-02f, 7.34267533e-02f, -1.44922495e-01f, 8.94805714e-02f, 3.04289479e-02f, 3.51046473e-02f, -1.49877653e-01f, -1.33029044e-01f,
  -8.27334285e-01f, 1.37779087e-01f, -1.29101593e-02f, -2.77663860e-02f, -8.67126584e-02f, -8.09254474e-04f, 3.16378959e-02f, -4.09086607e-02f, -1.85410202e-01f, -1.53066963e-01f,
  -2.02693641e-01f, 1.00454584e-01f, -2.57155057e-02f, -2.98203225e-03f, -9.03842226e-02f, -2.04486698e-01f, -2.67547257e-02f, 8.34417064e-03f, -7.77389556e-02f, -8.39052722e-02f,
  -1.35427520e-01f, -1.35887442e-02f, -1.43982440e-01f, -3.71826366e-02f, -1.03958063e-01f, -1.31986439e-01f, -6.37432113e-02f, -3.63689624e-02f, 2.94440426e-02f, 7.56239295e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.12397408e-01f, 2.31482431e-01f, 5.38983703e-01f, 6.27301157e-01f, 3.40586722e-01f, 1.70972794e-01f, 2.46761546e-01f, 4.12239164e-01f, 4.42727268e-01f, 2.48772487e-01f,
  5.08706093e-01f, 5.34045517e-01f, 5.83551109e-01f, -8.20033625e-02f, -1.87791176e-02f, 5.12850881e-01f, 4.02640879e-01f, 1.42216027e-01f, 5.13897955e-01f, 3.47602993e-01f,
  6.69264495e-01f, 5.02283454e-01f, 4.67881024e-01f, 4.13026810e-01f, 4.31273967e-01f, 6.32049084e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.68692529e-01f, -3.45147289e-02f, 8.73393193e-03f, 2.48054937e-02f, 1.69991300e-01f, -2.41825283e-01f, -7.44836777e-02f, 2.28068918e-01f, -1.65563941e-01f, 2.41775569e-02f,
  6.73702508e-02f, -1.64330587e-01f, 2.45823950e-01f, -1.33723125e-01f, 2.26239100e-01f, 6.19989149e-02f, -2.07483262e-01f, -2.54070759e-01f, -3.20987791e-01f, -9.80534032e-02f,
  1.86988160e-01f, -4.26904410e-01f, 2.09619939e-01f, 1.60693342e-03f, -9.05420929e-02f, -3.61629039e-01f, 5.94346970e-02f, -3.00287664e-01f, -3.85690451e-01f, 1.91067874e-01f,
  4.32215147e-02f, -8.98831934e-02f, -1.76353931e-01f, 6.44020885e-02f, 1.20175648e-02f, 2.22125605e-01f, 3.07898223e-02f, -3.71331386e-02f, -1.64840162e-01f, -2.46270373e-01f,
  -2.31275842e-01f, -5.98840639e-02f, -1.02756374e-01f, 4.71241325e-01f, 1.97693110e-01f, -9.93392989e-02f, 2.78577089e-01f, 8.38495344e-02f, -2.73082346e-01f, 6.15109205e-02f,
  3.01173348e-02f, -2.52230875e-02f, -3.03626746e-01f, -4.36388403e-01f, 2.82702506e-01f, 1.07771568e-01f, -3.28788102e-01f, -3.71326268e-01f, 3.44977796e-01f, 2.26174101e-01f,
  -3.13859314e-01f, 9.78823006e-02f, -3.52116317e-01f, 1.58235446e-01f, -1.67564720e-01f, -2.10002270e-02f, 1.88451320e-01f, 1.23262696e-01f, 1.56411871e-01f, -3.68355587e-02f,
  1.07992396e-01f, -8.06123465e-02f, 6.54193535e-02f, -3.23630832e-02f, 3.65551800e-01f, 9.57760066e-02f, 2.49400780e-01f, -1.69422641e-01f, 5.64272106e-02f, -8.73303488e-02f,
  -1.98413074e-01f, -2.66796023e-01f, 3.12883347e-01f, 1.83749765e-01f, 7.71561684e-03f, 1.21148519e-01f, -1.39558809e-02f, 1.80846587e-01f, -2.69202560e-01f, -5.08910697e-03f,
  -2.44702883e-02f, 1.01730555e-01f, -3.34610939e-01f, -1.22495398e-01f, -1.43674091e-01f, 5.55316824e-03f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.37285041e-02f, 6.80742934e-02f, 4.47570831e-02f, -3.19486372e-02f, -1.16764665e-01f, 2.69994587e-01f, -6.93912581e-02f, 2.65537709e-01f, -5.08872449e-01f, 6.33745968e-01f,
  4.68291700e-01f, 2.20111102e-01f, 1.94674999e-01f, 3.59485388e-01f, -3.56932342e-01f, -2.73272276e-01f, -1.33431554e-01f, -5.22048414e-01f, 2.56769896e-01f, 8.18150118e-02f,
  3.55779737e-01f, 4.72292513e-01f, 3.31267804e-01f, -3.95770609e-01f, 4.10391629e-01f, -1.44048035e-01f, -6.20894551e-01f, 5.10462046e-01f, -2.83583403e-01f, 2.20533356e-01f,
  -8.51786137e-02f, -5.14360487e-01f, 3.46058697e-01f, 4.41302583e-02f, 4.01974112e-01f, -3.95408392e-01f, -3.87508541e-01f, -3.94063443e-01f, 5.11345685e-01f, 1.15557589e-01f,
  5.36187112e-01f, 6.11712262e-02f, 2.74322480e-01f, 1.21074416e-01f, 2.08665222e-01f, 3.51539016e-01f, -3.31869394e-01f, -6.09209657e-01f, 4.16518390e-01f, 2.10754350e-01f,
  3.16853285e-01f, -1.66418821e-01f, 8.93806294e-02f, 5.90734363e-01f, -3.98765057e-01f, -1.40592113e-01f, 6.63857520e-01f, -5.80423065e-02f, 1.02028213e-01f, 6.75691187e-01f,
  6.12266004e-01f, 1.49559423e-01f, 3.91578406e-01f, -5.72771244e-02f, 2.37421934e-02f, 1.40194401e-01f, 1.45751119e-01f, 2.93057144e-01f, 1.18035585e-01f, -7.12299496e-02f,
  -1.61864564e-01f, 1.84904143e-01f, 1.19987242e-01f, -8.57161060e-02f, -2.57032514e-01f, -6.61266148e-01f, 2.90523589e-01f, -6.82184845e-02f, -5.81045225e-02f, 3.34462285e-01f,
  2.29470015e-01f, 5.90666533e-01f, -1.42504916e-01f, 3.61672491e-01f, -8.36650003e-03f, -4.50176895e-01f, 1.18857667e-01f, 2.25386731e-02f, -4.97265160e-01f, 5.25058746e-01f,
  5.79510987e-01f, -2.03870714e-01f, 2.97326781e-02f, 5.04066944e-02f, 1.92769542e-02f, -2.73559168e-02f, 2.04611465e-01f, -1.24704994e-01f, -1.08811192e-01f, -5.56237884e-02f,
  8.16208124e-02f, 4.96377936e-03f, -5.48539534e-02f, 4.58919592e-02f, -4.12000656e-01f, 3.38527858e-01f, -4.39527743e-02f, -5.31143069e-01f, 1.62524417e-01f, 1.66987032e-01f,
  7.34699219e-02f, 1.51777804e-01f, 1.27603173e-01f, -1.23193659e-01f, -3.63736928e-01f, 1.43928621e-02f, -9.30122435e-02f, 2.90396232e-02f, 4.41660225e-01f, -1.53349325e-01f,
  8.02069381e-02f, -5.53156435e-01f, 8.04195881e-01f, 7.19344392e-02f, -7.50939369e-01f, 3.44038606e-01f, -2.54936479e-02f, 4.08394367e-01f, 5.51700369e-02f, 1.29946992e-01f,
  1.62825078e-01f, -2.93248355e-01f, 1.77779078e-01f, -2.36489847e-02f, 1.35778949e-01f, -4.52348232e-01f, 4.55772251e-01f, -5.84793746e-01f, 4.75314230e-01f, 1.72769669e-02f,
  1.27280504e-01f, -2.42921978e-01f, -2.55486161e-01f, -2.46424645e-01f, 4.78511691e-01f, -1.73671097e-01f, 5.45019746e-01f, -1.71079591e-01f, -3.05919468e-01f, 6.13333285e-01f,
  -4.51461673e-01f, 3.91098291e-01f, 6.37918413e-01f, 9.09761786e-02f, 5.10915220e-01f, 1.05938651e-01f, 4.22263831e-01f, -6.46418512e-01f, 2.60370314e-01f, 2.18996301e-01f,
  3.16010147e-01f, 4.08044867e-02f, 2.45510414e-01f, 8.79552439e-02f, -7.84310997e-02f, 6.16640411e-02f, 6.08134687e-01f, 1.93334669e-02f, 4.18140255e-02f, -2.37510338e-01f,
  -1.38159782e-01f, -1.24182865e-01f, 7.35230222e-02f, 4.11703736e-01f, 2.12481663e-01f, 4.61930335e-02f, -8.32280666e-02f, -5.07882178e-01f, 1.45393208e-01f, 1.67645812e-02f,
  3.58072847e-01f, 4.98555332e-01f, -3.98875862e-01f, 3.04603368e-01f, 5.76046884e-01f, 6.18190408e-01f, -1.35402128e-01f, -4.56010044e-01f, 2.59743124e-01f, -3.85021627e-01f,
  4.87044543e-01f, 2.63557911e-01f, -1.77597590e-02f, 9.90983769e-02f, 3.68122071e-01f, -3.55149180e-01f, -7.39919692e-02f, 1.82739511e-01f, 3.93981487e-01f, 4.28545550e-02f,
  4.09011722e-01f, -5.97401410e-02f, 2.43224725e-01f, 7.10852623e-01f, -4.92452711e-01f, -3.15446436e-01f, 2.36670822e-01f, 1.40437586e-02f, 3.29633415e-01f, -2.11536586e-01f,
  -1.71694651e-01f, 6.79840147e-02f, -2.05578417e-01f, -6.21500909e-02f, -2.52302170e-01f, -7.01142382e-03f, 1.84500232e-01f, -3.96476001e-01f, -4.57161576e-01f, 4.17257473e-02f,
  1.56188920e-01f, -2.66455591e-01f, 1.92543507e-01f, 6.48366928e-01f, 2.55055606e-01f, 1.46269634e-01f, 1.05059281e-01f, -1.62779927e-01f, 1.63393423e-01f, 3.75905260e-02f,
  -6.56532645e-02f, 5.09893239e-01f, 4.76953894e-01f, -1.76765732e-02f, 2.87782073e-01f, -4.25830424e-01f, 1.62258029e-01f, 3.26377153e-01f, -1.44271508e-01f, -4.45723742e-01f,
  -5.62600076e-01f, 6.12540543e-01f, 4.25935000e-01f, 1.22276269e-01f, 4.00556535e-01f, 1.78451702e-01f, 5.16653210e-02f, -2.51482546e-01f, -2.13452920e-01f, -1.94342267e-02f,
  2.24104136e-01f, -3.12651768e-02f, 8.88700187e-01f, 7.35715628e-02f, -3.05041730e-01f, 4.59574103e-01f, 1.64365292e-01f, 1.29796043e-02f, 1.41516671e-01f, -6.44121272e-03f,
  -2.93382052e-02f, 2.67693162e-01f, 1.25068054e-01f, 1.91610172e-01f, 4.43828618e-03f, 4.10486162e-01f, 5.34475207e-01f, 7.60621786e-01f, 1.40905946e-01f, -5.84856942e-02f,
  2.91767389e-01f, 2.60675550e-02f, -3.41460615e-01f, -2.99323440e-01f, 6.83107793e-01f, 2.42901221e-03f, 2.82442003e-01f, -7.55956620e-02f, -2.42443606e-01f, 1.99345663e-01f,
  -6.18590489e-02f, 7.95124948e-01f, -5.26730478e-01f, 6.68362200e-01f, -3.28570336e-01f, -1.53420389e-01f, -2.84388691e-01f, 3.74473900e-01f, 6.36310801e-02f, 1.86384499e-01f,
  -6.22123368e-02f, 2.40925759e-01f, -1.14995800e-01f, 4.10136312e-01f, 5.33116698e-01f, -1.24427378e-01f, -1.81974798e-01f, -2.37197250e-01f, 5.87845087e-01f, 3.15484196e-01f,
  6.34956062e-01f, 5.26088834e-01f, -2.69016605e-02f, 7.33295083e-02f, -4.40596119e-02f, -3.94721031e-01f, 7.55434260e-02f, -7.09528476e-02f, 8.03676844e-01f, 3.55734140e-01f,
  1.60848364e-01f, 6.59057975e-01f, 2.78404534e-01f, -2.39532322e-01f, -1.21210776e-02f, -3.21006060e-01f, -1.34673595e-01f, 4.51996952e-01f, -9.22683701e-02f, -3.50427300e-01f,
  3.64346266e-01f, 3.93319398e-01f, 1.03734471e-01f, 2.75554568e-01f, -2.00981289e-01f, 3.31701547e-01f, 5.09450078e-01f, -4.09506768e-01f, 5.50947487e-02f, 5.69358587e-01f,
  -2.02544741e-02f, 8.31282973e-01f, 1.64183706e-01f, -2.86667943e-01f, -3.08103740e-01f, 1.68648884e-01f, 3.73252749e-01f, -8.64064787e-03f, -1.61538363e-01f, -9.44607034e-02f,
  -7.31014237e-02f, -9.30591077e-02f, 2.43742332e-01f, -4.40034643e-02f, 1.78026989e-01f, 7.70240843e-01f, 7.15815425e-02f, 8.64824772e-01f, -7.52182961e-01f, 2.01504827e-01f,
  3.13564241e-02f, 1.40633732e-01f, 4.68368649e-01f, 7.53711686e-02f, 1.05571903e-01f, 2.76858389e-01f, -2.31180370e-01f, 3.32051218e-01f, 5.29127344e-02f, -2.07782879e-01f,
  8.95008147e-02f, 4.00718600e-01f, 5.40550649e-01f, 6.27126217e-01f, 1.83814466e-01f, -4.42850232e-01f, 2.84774154e-01f, 1.46665886e-01f, -4.26092222e-02f, 1.22480892e-01f,
  4.35790539e-01f, -1.71569660e-01f, -8.36406499e-02f, -1.10670388e-01f, 4.40218836e-01f, 2.79035538e-01f, -2.97418237e-01f, 8.28513861e-01f, -1.00187278e+00f, 2.24144563e-01f,
  -4.93839025e-01f, 9.30888280e-02f, -4.06549424e-01f, -2.35109836e-01f, 4.64483649e-01f, 4.60880011e-01f, 3.92279178e-01f, 6.97618276e-02f, -2.30180368e-01f, 2.35502318e-01f,
  3.08633029e-01f, -1.44391898e-02f, -2.26982892e-01f, 7.26282954e-01f, 6.34674355e-02f, 4.29816097e-02f, 4.55585152e-01f, 4.72107381e-01f, 1.46072619e-02f, -2.75901079e-01f,
  1.82003543e-01f, 2.15922650e-02f, -1.80670768e-01f, 2.89167045e-03f, 4.48067874e-01f, -1.84296161e-01f, 5.21825552e-01f, 5.51595569e-01f, -1.20706208e-01f, -1.89853743e-01f,
  3.90927494e-01f, 2.11978316e-01f, 7.91989043e-02f, 7.34690547e-01f, -2.37595573e-01f, -3.40164125e-01f, 3.42221886e-01f, 4.56795804e-02f, 3.60463597e-02f, -1.66293383e-02f,
  5.93355596e-02f, 9.66599211e-02f, -5.24704278e-01f, 9.30267051e-02f, -2.84274340e-01f, -1.33121591e-02f, -5.49202204e-01f, -3.92797381e-01f, -5.06703323e-03f, 1.20656617e-01f,
  2.38390669e-01f, 4.13553387e-01f, -4.75418929e-04f, 5.62898934e-01f, 9.41283721e-03f, -9.10032839e-02f, 1.05052300e-01f, -7.68588722e-01f, 5.44568360e-01f, 1.50614798e-01f,
  -3.06577146e-01f, 3.41428459e-01f, 2.89457709e-01f, -5.76572955e-01f, -3.00931960e-01f, 2.42937669e-01f, -2.28373632e-01f, 2.44350031e-01f, 3.73663545e-01f, 2.07423314e-01f,
  -1.11943103e-01f, 1.21438295e-01f, -2.40637094e-01f, -7.66496882e-02f, 3.86397243e-01f, 7.59602264e-02f, 5.87578118e-01f, 3.58266622e-01f, -4.37141091e-01f, 1.95509698e-02f,
  -5.29365480e-01f, 2.11119279e-01f, 3.00332546e-01f, 1.39815047e-01f, 5.15134394e-01f, 6.53371692e-01f, 6.84892535e-02f, -3.74947079e-02f, -4.24136817e-01f, -1.39832661e-01f,
  2.58528918e-01f, 2.91483313e-01f, 2.11590335e-01f, 3.06959778e-01f, -4.16273862e-01f, -2.77451485e-01f, 7.67120302e-01f, 1.05791979e-01f, 8.47495571e-02f, -4.22824889e-01f,
  4.13712889e-01f, -7.19778612e-02f, 1.00254200e-01f, 4.36346717e-02f, 8.95995200e-02f, 2.95052044e-02f, -3.18762511e-01f, 2.37274125e-01f, 5.24846762e-02f, 1.26364110e-02f,
  -3.51838738e-01f, -2.49299601e-01f, -3.03676575e-02f, -2.65322924e-02f, 2.41632506e-01f, 1.20392978e-01f, 1.13171473e-01f, 4.95078117e-01f, -2.59527005e-02f, -3.00802946e-01f,
  1.13611251e-01f, -5.33664644e-01f, 4.92770433e-01f, 5.92180073e-01f, -4.81765717e-01f, -4.82515454e-01f, 1.30843297e-01f, -3.62563998e-01f, 4.78750169e-01f, 3.60510021e-01f,
  1.10265784e-01f, -4.89608990e-03f, 1.39003336e-01f, 4.01557349e-02f, 8.77765939e-02f, 9.40375924e-02f, 8.44667032e-02f, -1.56776130e-01f, -2.01752648e-01f, 5.24855673e-01f,
  8.29223394e-01f, 6.78506047e-02f, 4.81070578e-01f, 1.40016064e-01f, -4.29970622e-02f, -3.92316282e-01f, -2.87388526e-02f, 2.67006695e-01f, 2.59680688e-01f, 2.49538332e-01f,
  2.88246542e-01f, 1.25829894e-02f, 8.94619599e-02f, -1.51557952e-01f, -9.25550833e-02f, -4.10625547e-01f, -7.52953887e-02f, 2.19903156e-01f, 1.35409996e-01f, 6.62925124e-01f,
  -1.10967137e-01f, -2.41877198e-01f, -1.04823736e-02f, 8.44010830e-01f, 1.22046299e-01f, 7.98611715e-02f, -6.24223351e-02f, 2.11452216e-01f, 6.34994954e-02f, -2.98291892e-01f,
  3.04641426e-01f, 2.78393477e-01f, -5.45909345e-01f, -1.85575545e-01f, 2.65397746e-02f, 9.74980071e-02f, 2.79189765e-01f, -1.26552969e-01f, -3.34342122e-01f, 3.03890929e-03f,
  4.40832496e-01f, -1.13110282e-01f, -9.97131597e-03f, 2.97086090e-01f, -3.44041623e-02f, -2.41845369e-01f, 5.40241450e-02f, 2.57642001e-01f, 3.20997387e-01f, -1.43439010e-01f,
  6.81986451e-01f, 1.10223278e-01f, -3.73625100e-01f, 2.04615518e-01f, 2.06435040e-01f, -7.51387700e-02f, 4.25040305e-01f, 2.41378248e-01f, 7.71216154e-02f, -1.89865783e-01f,
  1.86916262e-01f, 8.19976777e-02f, -1.15105156e-02f, -9.66484621e-02f, 2.56077141e-01f, 1.28915727e-01f, 6.86595887e-02f, -5.44043183e-01f, -3.26915890e-01f, 5.85796356e-01f,
  1.74101293e-01f, -1.96374729e-01f, 1.05084322e-01f, 4.14308608e-01f, 3.44626993e-01f, -2.23176867e-01f, -6.03380986e-02f, 4.66027886e-01f, -1.08500339e-01f, 1.01225689e-01f,
  3.52487832e-01f, 2.24517062e-01f, 7.80661181e-02f, -3.26105416e-01f, 7.42419064e-01f, -8.01443867e-03f, 2.32302397e-01f, 6.71562999e-02f, 2.45080635e-01f, 1.62897989e-01f,
  1.58176169e-01f, 2.35606730e-01f, 1.28414243e-01f, 4.41603065e-02f, 1.58188805e-01f, 2.72936314e-01f, 3.05938691e-01f, 1.69293106e-01f, 5.70041180e-01f, -3.12078655e-01f,
  4.22585726e-01f, 3.00763398e-01f, 1.79906040e-01f, -8.34932774e-02f, -2.13289320e-01f, -1.46153852e-01f, 6.01431310e-01f, -3.52681056e-02f, 8.86529505e-01f, 5.09573162e-01f,
  4.86539975e-02f, 5.44400401e-02f, -1.27490878e-01f, 7.86810517e-01f, -7.28985667e-01f, -1.94294199e-01f, 6.91515565e-01f, 1.48354143e-01f, -1.93096101e-01f, -1.49657786e-01f,
  3.37506890e-01f, 2.28019357e-01f, 2.38896579e-01f, 1.58497974e-01f, 2.97253162e-01f, -1.33128569e-01f, -4.05473262e-01f, 2.10160166e-01f, -4.17228609e-01f, -9.49745849e-02f,
  -2.00023547e-01f, -2.17997491e-01f, 2.14381650e-01f, -4.25148197e-02f, 9.06752944e-02f, 3.32637079e-04f, 1.26061901e-01f, 5.03631711e-01f, 2.09867358e-01f, -8.03720504e-02f,
  -9.59203616e-02f, -6.57841086e-01f, 9.51419920e-02f, 3.34137887e-01f, -5.89232743e-01f, 1.79962367e-01f, 8.52053225e-01f, 8.88461340e-03f, -2.48561889e-01f, 1.23081006e-01f,
  2.55664021e-01f, 4.99816358e-01f, 2.76856087e-02f, -9.70051736e-02f, -1.59263790e-01f, 9.94086936e-02f, 2.83701122e-01f, 9.71466452e-02f, 2.33514369e-01f, 3.67630512e-01f,
  -6.02317266e-02f, -9.83202457e-02f, 2.23316178e-01f, 3.38441163e-01f, 9.56882983e-02f, -1.02337040e-01f, 2.23153755e-01f, -4.65563359e-03f, -4.03039120e-02f, -3.15810628e-02f,
  -3.49923402e-01f, 1.21768080e-01f, 3.50021958e-01f, -2.28829935e-01f, 5.22286773e-01f, 4.34505701e-01f, -3.12584490e-01f, -4.76104319e-01f, 1.66557357e-01f, -5.47714055e-01f,
  -5.40100515e-01f, 2.54554689e-01f, -2.88041741e-01f, 3.23780775e-01f, -1.18324749e-01f, 1.35524720e-01f, 2.07740411e-01f, 2.53372908e-01f, 1.52704984e-01f, 8.52703750e-02f,
  -1.55089740e-02f, 1.41757190e-01f, -2.30394259e-01f, -1.68179929e-01f, -1.78159922e-01f, 7.18899295e-02f, 4.00929183e-01f, 4.16238494e-02f, 4.40415181e-02f, 2.39960775e-01f,
  3.06813776e-01f, 3.43252085e-02f, -1.92508727e-01f, 2.55178154e-01f, 7.26016834e-02f, -4.21607435e-01f, 5.87070473e-02f, -5.05652577e-02f, 2.08334029e-01f, 1.07533634e-01f,
  8.42051446e-01f, -1.09650448e-01f, -5.91964245e-01f, 3.81420523e-01f, 3.49700302e-01f, 4.90648210e-01f, 2.16929078e-01f, 2.38737494e-01f, -1.04249433e-01f, -1.44503847e-01f,
  -2.05113500e-01f, 1.69290211e-02f, 4.39736396e-01f, -1.34828642e-01f, -7.65964855e-03f, 2.59306282e-01f, -3.15969437e-01f, 2.73220204e-02f, -2.29504406e-01f, 6.50864482e-01f,
  5.55859029e-01f, -5.23473881e-02f, -2.24382743e-01f, 5.30006215e-02f, -4.59979802e-01f, 1.76709086e-01f, -7.61367157e-02f, 5.59272945e-01f, -5.67938983e-02f, 5.77945828e-01f,
  3.52186948e-01f, -6.30211055e-01f, 2.15141132e-01f, -3.33788157e-01f, 5.24126410e-01f, 1.74335957e-01f, -2.12498888e-01f, -3.61426979e-01f, 2.21094135e-02f, -9.05337334e-02f,
  9.86451730e-02f, -6.70033693e-03f, 2.34513432e-01f, 9.94703025e-02f, -2.65638173e-01f, 4.17682290e-01f, 3.73874813e-01f, 1.99468270e-01f, 6.56145811e-01f, -2.18126457e-02f,
  1.44304499e-01f, 3.07749540e-01f, -2.04424746e-02f, 7.51009211e-02f, -3.78148675e-01f, 2.01979503e-02f, 3.27219605e-01f, -1.38466939e-01f, 9.02934447e-02f, -3.28966267e-02f,
  3.45198095e-01f, -7.92675540e-02f, -3.43502551e-01f, -4.06691283e-01f, 3.94184172e-01f, -2.42138957e-03f, -3.81350666e-01f, 1.60471797e-01f, 1.01236455e-01f, 6.57989025e-01f,
  3.80739510e-01f, 1.27723247e-01f, 3.49255085e-01f, 1.78497717e-01f, 3.94316345e-01f, -4.47862111e-02f, 2.91879848e-02f, 4.93867904e-01f, -2.09058732e-01f, -2.83601433e-01f,
  -3.62601668e-01f, -7.33726323e-01f, 3.37622911e-01f, 5.23109615e-01f, 1.48090333e-01f, -1.69859812e-01f, -3.51460627e-03f, 5.30418158e-01f, -2.10827872e-01f, -2.06278339e-01f,
  4.21210378e-02f, 3.74966055e-01f, 8.39178711e-02f, 4.22053397e-01f, 7.20322803e-02f, -3.34847033e-01f, 8.56376767e-01f, -3.12920988e-01f, 1.65966302e-01f, 9.77675244e-03f,
  2.66042024e-01f, -2.46343091e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.74252689e-01f, 2.46568218e-01f, 1.76089823e-01f, 3.30085248e-01f, 2.90354162e-01f, 2.46054716e-02f, -7.20580891e-02f, 2.39080399e-01f, -1.85083315e-01f, 1.02678910e-01f,
  3.16704452e-01f, 3.13687101e-02f, 1.74006626e-01f, 2.49999091e-01f, 2.64655709e-01f, 8.98324102e-02f, 7.42408410e-02f, 3.45446706e-01f, 2.92823523e-01f, -1.10982180e-01f,
  2.38752887e-01f, -1.36183962e-01f, 5.31721003e-02f, 2.31659546e-01f, -3.41283972e-03f, 6.66328445e-02f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -9.54241157e-01f, -1.79403275e-01f, -2.05461551e-02f, 1.56398714e-01f, -8.44662264e-02f, -2.94814885e-01f, 6.20582439e-02f, -1.73143044e-01f, 3.14895034e-01f, 1.49525151e-01f,
  -2.37812579e-01f, -1.63823158e-01f, -1.82488903e-01f, 1.30620241e-01f, -5.93469918e-01f, 2.84426302e-01f, -5.74570954e-01f, -3.08247536e-01f, 1.05593771e-01f, 1.41880274e-01f,
  -8.49023402e-01f, 2.69401163e-01f, -2.12328330e-01f, 3.46821904e-01f, -5.65690219e-01f, 1.25460252e-01f, 4.35570888e-02f, 3.40492547e-01f, 2.69563973e-01f, -2.16735110e-01f,
  1.60693541e-01f, 1.66586995e-01f, 1.10474020e-01f, 2.71970421e-01f, 8.93788114e-02f, 9.00653452e-02f, 6.22400999e-01f, 1.28739193e-01f, -4.28565562e-01f, -7.36847937e-01f,
  2.88119972e-01f, 4.15457278e-01f, -3.17249447e-01f, 1.78353898e-02f, 2.31383532e-01f, 6.74990490e-02f, 7.61624752e-03f, -9.47133303e-01f, -5.83803236e-01f, -3.95805955e-01f,
  -6.61612162e-03f, 2.67296821e-01f, -1.45674378e-01f, 2.90537059e-01f, 2.97253430e-01f, 1.89000934e-01f, -1.91845044e-01f, -7.27048337e-01f, 5.73757768e-01f, 2.23351464e-01f,
  2.91216731e-01f, -2.83842951e-01f, 5.26268661e-01f, 4.61529166e-01f, 4.22336400e-01f, 4.13926512e-01f, 2.54615378e-02f, -4.77224499e-01f, 2.71135494e-02f, 6.98555946e-01f,
  -4.97163013e-02f, 1.76865950e-01f, 1.51661173e-01f, 2.38294527e-01f, 1.03784084e-01f, -2.37829715e-01f, -3.31048906e-01f, -5.52204609e-01f, -2.91230939e-02f, -5.61669767e-02f,
  5.03575325e-01f, -4.96876687e-01f, 3.29110056e-01f, -3.52963060e-01f, -5.09275556e-01f, -2.03216523e-01f, -1.05574489e-01f, 5.28396130e-01f, -6.91610336e-01f, -5.49643040e-01f,
  3.67310435e-01f, -4.29048359e-01f, 2.18862072e-01f, 5.65221310e-02f, -5.10219336e-01f, 2.55283952e-01f, -2.34501168e-01f, 2.23146662e-01f, -1.89762861e-01f, 2.72198588e-01f,
  -1.01423718e-01f, 5.39221942e-01f, 3.69097441e-01f, -2.72750724e-02f, -1.88298643e-01f, -2.28994295e-01f, -6.79916263e-01f, -1.01082635e+00f, -6.13979697e-01f, -8.48300308e-02f,
  6.07174695e-01f, 1.31818026e-01f, 3.92961472e-01f, 5.70931554e-01f, 1.13740981e-01f, -2.28163704e-01f, -2.96100765e-01f, -2.76037455e-01f, 1.09817021e-01f, -1.15548052e-01f,
  -7.45858908e-01f, 2.78578728e-01f, -1.21526502e-01f, 1.27558887e-01f, -6.19476855e-01f, -8.96337092e-01f, 1.68038309e-01f, -4.09617752e-01f, 4.66253012e-01f, -4.83802587e-01f,
  3.64614069e-01f, 3.24609786e-01f, 3.48503411e-01f, -6.38751268e-01f, 2.87430108e-01f, 3.21438998e-01f, -2.28684545e-01f, 1.20049141e-01f, -9.66573238e-01f, 1.09842561e-01f,
  9.83200297e-02f, 1.39929637e-01f, 1.11495936e-02f, 1.46323398e-01f, -1.70384720e-01f, -5.26363909e-01f, 1.51518211e-02f, -4.91230875e-01f, -2.13763148e-01f, -6.00334287e-01f,
  1.61939695e-01f, -4.32772934e-01f, 7.46504962e-02f, 2.63053834e-01f, -4.48800296e-01f, 1.10505655e-01f, -3.24259773e-02f, 3.76162320e-01f, 1.28004298e-01f, 9.18309391e-02f,
  3.55330929e-02f, 8.77017602e-02f, -1.77919358e-01f, -2.57670313e-01f, -5.67562580e-01f, -2.52040237e-01f, -2.02473536e-01f, 2.84201950e-02f, 1.65192962e-01f, -6.99838936e-01f,
  -1.22753412e-01f, -4.36795890e-01f, -1.07010826e-01f, 4.65169519e-01f, -5.98623157e-01f, -4.05440450e-01f, -6.48273408e-01f, -2.00122893e-01f, 8.28927010e-02f, -3.61896306e-02f,
  4.54696089e-01f, 5.14048696e-01f, 8.75180960e-02f, -3.77764463e-01f, 3.74106199e-01f, 9.89819020e-02f, 1.80414185e-01f, -3.14528376e-01f, -3.78705800e-01f, 1.04019552e-01f,
  1.90187376e-02f, 2.75850832e-01f, -2.25629196e-01f, -3.06768030e-01f, -2.46585011e-01f, -5.51462956e-02f, 1.73127666e-01f, -4.69976306e-01f, -3.05412799e-01f, 4.88361716e-01f,
  -1.82634175e-01f, -6.34857535e-01f, 2.86049783e-01f, 1.95031062e-01f, 4.58414853e-01f, -4.67401922e-01f, -5.96881628e-01f, -8.06841850e-01f, 2.25984097e-01f, -6.79088593e-01f,
  -1.00931215e+00f, -2.87424624e-01f, 2.47952014e-01f, -5.68081319e-01f, 2.92206973e-01f, 1.28384709e-01f, 2.44089961e-02f, -3.79072189e-01f, -5.16716123e-01f, -3.03211600e-01f,
  -1.05600851e-02f, -4.49968010e-01f, -7.33810008e-01f, -7.27315009e-01f, -2.86236644e-01f, -2.70453274e-01f, -1.61821201e-01f, 1.21826269e-01f, 3.76036137e-01f, 4.66431320e-01f,
  -7.19832242e-01f, -1.69087902e-01f, -1.52407706e-01f, 1.19910777e-01f, 1.31809143e-02f, 8.52861777e-02f, 1.77557245e-01f, -8.50860715e-01f, 1.53520063e-01f, 4.35894042e-01f,
  -6.65073246e-02f, 4.26267177e-01f, 1.13305845e-03f, 4.09319773e-02f, 1.04818217e-01f, 2.11303294e-01f, -2.08586350e-01f, -2.06852764e-01f, -4.01717693e-01f, -1.08182721e-01f,
  -4.76037532e-01f, 3.67335021e-01f, -2.59127021e-01f, 3.27307284e-01f, -2.71638215e-01f, -4.71007138e-01f, 4.82730269e-02f, 4.46652353e-01f, 3.93737465e-01f, -3.99834782e-01f,
  -6.58577681e-01f, -3.93078886e-02f, -5.85868418e-01f, -6.14457726e-01f, 3.54052395e-01f, -5.70326447e-01f, -4.71155345e-01f, 4.37117293e-02f, -3.18978608e-01f, -9.69690979e-02f,
  2.23224908e-01f, -5.10335624e-01f, 5.61844826e-01f, 6.08838201e-01f, -3.91868353e-01f, 3.92814308e-01f, 1.98956415e-01f, -2.85785437e-01f, 2.05246545e-02f, -5.15273750e-01f,
  7.57087618e-02f, 2.92879671e-01f, 2.66000152e-01f, -3.37603539e-01f, 2.03047600e-02f, -4.60220903e-01f, -2.20202416e-01f, -8.42525840e-01f, 1.07103579e-01f, -4.10064429e-01f,
  3.86866957e-01f, -1.38218269e-01f, -1.72198176e-01f, -2.94882655e-01f, -4.34654057e-02f, 1.47972986e-01f, -4.87471282e-01f, -3.60076606e-01f, 2.95799881e-01f, 5.13528347e-01f,
  -1.90701365e-01f, -2.58677453e-01f, -6.30966365e-01f, 3.68807554e-01f, -2.57437706e-01f, -8.59820962e-01f, -2.29558557e-01f, -6.03142560e-01f, 1.03203794e-02f, -4.18516040e-01f,
  -8.46317649e-01f, 1.59936935e-01f, 3.58455688e-01f, -9.19524506e-02f, -1.22010075e-01f, -2.84980893e-01f, -1.43594608e-01f, 3.13973933e-01f, -4.34737951e-01f, 6.10816896e-01f,
  9.59930569e-02f, -4.46423292e-02f, -2.73901165e-01f, 5.90346992e-01f, 4.99875963e-01f, -3.48835856e-01f, 1.42284706e-01f, -6.45397723e-01f, -5.35376370e-01f, 4.92954701e-01f,
  -3.53509665e-01f, -6.19079351e-01f, -7.13329971e-01f, -6.63922429e-01f, -6.16211176e-01f, 3.17670405e-02f, 3.42041194e-01f, 3.32041264e-01f, 3.13878357e-01f, 3.45542341e-01f,
  1.92366466e-01f, 4.93417710e-01f, -4.60258603e-01f, -6.43590510e-01f, 1.02876022e-01f, -1.12710617e-01f, 6.12924099e-02f, 1.39544949e-01f, -4.30438906e-01f, 3.92205685e-01f,
  1.18275329e-01f, -2.34102517e-01f, -2.70379156e-01f, -6.62497357e-02f, -3.44883323e-01f, -4.93417025e-01f, -4.08100128e-01f, 6.53134823e-01f, -5.20985648e-02f, 1.41585814e-02f,
  -4.88584578e-01f, -1.29163533e-01f, 4.54408348e-01f, -1.27044007e-01f, 3.07899415e-02f, 2.53303111e-01f, 2.14423761e-01f, -2.00731903e-01f, -5.09796917e-01f, 5.27115986e-02f,
  -6.05669022e-01f, -5.91133952e-01f, -3.14966381e-01f, -2.62437999e-01f, 3.03656548e-01f, -3.15998256e-01f, 3.08901429e-01f, 3.07158977e-01f, -1.38431579e-01f, -4.88090366e-01f,
  -5.83252430e-01f, -9.90283489e-01f, 4.61481333e-01f, -3.48619193e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.64425015e-01f, 7.46410564e-02f, 3.01709831e-01f, -3.77156377e-01f, -5.78437932e-02f, 1.87009439e-01f, -8.02777112e-02f, -1.24520518e-01f, 3.12997520e-01f, 1.28130957e-01f,
  -2.49758601e-01f, 1.17516212e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    