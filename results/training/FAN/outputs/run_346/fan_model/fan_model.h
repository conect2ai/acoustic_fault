/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.54836057e-02f, -5.04422300e-02f, 3.83910276e-02f, 1.54305696e-01f, -9.23843831e-02f, -1.38623655e-01f, -1.00773893e-01f, -8.91197920e-02f, -4.32984019e-03f, -1.43510610e-01f,
  -8.78940374e-02f, 1.25234678e-01f, -1.01843551e-02f, 8.36867541e-02f, 3.09787601e-01f, 2.44128212e-01f, 1.07163586e-01f, -3.04252631e-03f, -5.25454096e-02f, 2.11650021e-02f,
  9.85319093e-02f, 1.81558609e-01f, 1.28922790e-01f, -7.02918768e-02f, -1.30448684e-01f, -1.08279973e-01f, 6.94745630e-02f, 2.65725814e-02f, -1.96723603e-02f, 8.12730566e-02f,
  -4.26107235e-02f, -6.74261600e-02f, -6.53992034e-03f, -9.78395715e-03f, 2.37481538e-02f, -1.40823558e-01f, -4.73283641e-02f, 1.16774954e-01f, -6.50893198e-03f, -3.60657126e-02f,
  5.05106673e-02f, 8.40709209e-02f, 2.48136017e-02f, 3.59033570e-02f, -1.55978082e-02f, -7.85726234e-02f, -1.18298724e-01f, -1.26943022e-01f, 3.53143290e-02f, -1.36544527e-02f,
  -3.33397724e-02f, -8.65114406e-02f, -5.43412864e-02f, 3.71127315e-02f, -1.61145478e-02f, -7.11527541e-02f, 5.33688851e-02f, 6.52486235e-02f, -1.11212740e-02f, 2.28215121e-02f,
  3.21254097e-02f, -3.30437124e-02f, -6.52855560e-02f, 7.89139234e-03f, 4.00790200e-02f, -4.48814109e-02f, 4.95263338e-02f, -5.98833412e-02f, 1.83782242e-02f, -3.02015040e-02f,
  4.50409651e-02f, -5.53139206e-03f, -4.05000038e-02f, 3.91022302e-03f, -1.07069919e-02f, -5.87988645e-02f, -3.36579159e-02f, -4.22134772e-02f, 2.23856904e-02f, -8.23190659e-02f,
  -1.81973893e-02f, -2.28333287e-02f, -1.92118797e-03f, 4.15349863e-02f, -5.35488268e-03f, -5.00114970e-02f, -8.85680900e-04f, 2.59972438e-02f, -7.37660900e-02f, 7.65419304e-02f,
  1.83148198e-02f, 2.21009716e-01f, -2.84110736e-02f, 1.64570563e-04f, -1.08743422e-02f, 2.81581990e-02f, 9.60852727e-02f, 3.90874557e-02f, 5.46140485e-02f, 2.21865848e-02f,
  -9.72397923e-02f, -7.86680728e-02f, -5.29917516e-02f, -1.30714308e-02f, 1.01459250e-02f, 4.26920988e-02f, 8.14756900e-02f, 3.93127389e-02f, -3.00155655e-02f, -4.44128849e-02f,
  -3.52184586e-02f, 1.17195277e-02f, -7.88919814e-03f, 1.28131406e-02f, -3.24198529e-02f, -2.49258205e-02f, 1.05792210e-02f, 3.96518894e-02f, 4.38922420e-02f, -7.38192210e-03f,
  5.76743841e-01f, -2.99007632e-02f, 2.11131960e-01f, 2.17003569e-01f, 7.76103407e-04f, -1.68242857e-01f, -1.00436240e-01f, -8.81968513e-02f, 1.77688107e-01f, -3.02829832e-01f,
  -2.85174757e-01f, 2.33119324e-01f, -1.90350637e-01f, -1.00579761e-01f, 4.44384776e-02f, -1.10228501e-01f, -7.91776180e-02f, -7.92385042e-02f, 9.25747752e-02f, 6.16537035e-02f,
  1.20175727e-01f, -2.81415552e-01f, -2.12380197e-02f, -1.75171256e-01f, -2.45715473e-02f, 8.59179646e-02f, -8.71120840e-02f, -9.85057950e-02f, -9.48728696e-02f, -6.72565252e-02f,
  -8.15986395e-02f, 1.27392821e-02f, 1.52340876e-02f, 9.44165885e-03f, -1.02168564e-02f, 7.32118040e-02f, 2.07640622e-02f, 1.75717734e-02f, 7.08625913e-02f, -3.60967196e-03f,
  6.22272976e-02f, -4.78816070e-02f, -9.48576722e-03f, 2.58059893e-02f, 3.93134132e-02f, 3.06583364e-02f, -1.78504866e-02f, 5.13093919e-02f, 1.65024903e-02f, 2.92869620e-02f,
  6.93010092e-02f, 3.75354700e-02f, -4.33436641e-03f, -9.07649919e-02f, 2.87051238e-02f, -3.59661095e-02f, 3.21239680e-02f, 7.47030647e-03f, -2.71720309e-02f, 6.67566359e-02f,
  9.84455645e-03f, 1.28150545e-02f, -3.43558528e-02f, 6.33099722e-03f, 9.68816876e-03f, -4.05103713e-03f, -8.41195136e-03f, 1.48027157e-03f, 4.68357578e-02f, -4.61467952e-02f,
  -2.10397691e-03f, 8.81615207e-02f, -5.17189950e-02f, 5.48088811e-02f, 5.05691953e-03f, -5.23248571e-04f, 4.51086909e-02f, 2.22472213e-02f, 2.12152465e-03f, 4.60535213e-02f,
  8.77938606e-03f, 2.77210008e-02f, -2.47697420e-02f, -6.94558164e-03f, -3.00326273e-02f, -1.12688057e-02f, -4.61537391e-02f, 2.49915943e-02f, 1.03305746e-02f, -2.75203511e-02f,
  -6.96285218e-02f, -5.69115356e-02f, 4.88966424e-03f, 2.43234560e-02f, -4.11765240e-02f, -4.93880473e-02f, 6.15928648e-03f, -3.45960609e-03f, -2.11408362e-02f, 2.01523211e-02f,
  -1.04744118e-02f, 4.18316312e-02f, 4.04750975e-03f, -6.72073066e-02f, -1.42259318e-02f, -6.67053461e-02f, -4.27674279e-02f, -1.33452791e-04f, -8.36769864e-02f, 2.80399043e-02f,
  -1.14275046e-01f, -3.00474688e-02f, 3.29678021e-02f, 4.69268188e-02f, -6.46631718e-02f, -7.13260332e-03f, 7.58904265e-03f, 5.19314595e-02f, -1.83840748e-02f, -3.53409462e-02f,
  -1.49187654e-01f, -1.76188305e-01f, 3.98934819e-02f, -2.04544336e-01f, -1.97176188e-02f, 2.31098048e-02f, 7.37168789e-02f, -1.78963229e-01f, -1.90969169e-01f, -8.75702500e-02f,
  -2.04496868e-02f, 4.48998027e-02f, 2.33711049e-01f, -1.74540624e-01f, 1.35414913e-01f, 1.34967431e-01f, -1.74231693e-01f, -1.00954799e-02f, -8.47320110e-02f, -1.56588554e-01f,
  -2.12823842e-02f, -2.79864103e-01f, 1.39908552e-01f, -1.68311253e-01f, -5.45839444e-02f, -9.20053944e-02f, -2.69406959e-02f, 1.13295920e-01f, -9.60067511e-02f, -2.58057727e-03f,
  -1.38250574e-01f, -1.58948004e-01f, 3.58533785e-02f, 1.54643282e-02f, -4.62435298e-02f, 3.53301913e-02f, 6.26653582e-02f, 9.74257663e-02f, 3.56442370e-02f, -1.43194897e-02f,
  4.76125889e-02f, -3.12554352e-02f, -6.84498698e-02f, -5.37492149e-03f, -5.29842190e-02f, -1.80698540e-02f, -8.72503500e-03f, 1.52044399e-02f, -2.92569809e-02f, -6.18426595e-04f,
  5.12039959e-02f, -2.67457440e-02f, -7.67650679e-02f, -4.71783988e-02f, 1.37929823e-02f, -4.82116938e-02f, -1.71452276e-02f, 6.44667521e-02f, 3.08404211e-03f, -3.50134149e-02f,
  5.66035435e-02f, -4.71472554e-02f, -5.31170750e-03f, -3.50825787e-02f, -3.60391662e-02f, 6.12611882e-03f, -2.45462619e-02f, -2.65328791e-02f, 4.39042337e-02f, -1.79993398e-02f,
  3.74827487e-03f, 8.99108872e-03f, 1.52171776e-02f, 4.15101089e-02f, 2.21351888e-02f, -9.09870714e-02f, 6.02240190e-02f, 4.05715555e-02f, -3.07607073e-02f, -1.31070884e-02f,
  4.45798188e-02f, -1.72178708e-02f, 1.11063011e-02f, 5.45475259e-02f, -4.56677526e-02f, 6.48117959e-02f, -6.11230694e-02f, 2.94117853e-02f, -1.28851132e-02f, 4.96187620e-02f,
  -1.86098307e-01f, -2.79270768e-01f, -6.95784837e-02f, -5.63044138e-02f, 2.33664736e-02f, -1.70770120e-02f, -6.85047880e-02f, -3.67085822e-02f, -2.19813343e-02f, -4.23948169e-02f,
  1.53098805e-02f, 2.00047996e-02f, -2.84181628e-03f, 3.00945509e-02f, 4.00486737e-02f, -5.37721738e-02f, -6.58188760e-03f, -5.87095805e-02f, -1.80813577e-02f, 1.16568021e-02f,
  -2.69360878e-02f, 6.34047389e-02f, 7.16415271e-02f, 1.86074208e-02f, -1.75155792e-02f, 3.15167159e-02f, 2.35400535e-02f, 6.56354427e-02f, 2.43913494e-02f, -1.91454478e-02f,
  6.54201433e-02f, -1.67192355e-01f, 1.55969024e-01f, -2.64081685e-03f, 2.27998719e-01f, 1.27048001e-01f, 2.54771680e-01f, 7.47208297e-02f, 1.60890594e-01f, -1.19421571e-01f,
  -2.00508684e-02f, -2.44951203e-01f, 7.12127537e-02f, -2.70303637e-01f, -1.00354590e-02f, -1.89516339e-02f, -9.71367508e-02f, -1.59369081e-01f, 5.53794503e-02f, -4.49237414e-03f,
  1.58242462e-03f, -2.73343444e-01f, -9.78475660e-02f, -2.04261139e-01f, -7.20323995e-02f, -1.21275492e-01f, -1.99560225e-01f, 1.64651543e-01f, -1.73602939e-01f, -6.38981760e-02f,
  2.52258405e-02f, -9.03353691e-02f, 5.18649668e-02f, 4.30598706e-02f, 5.69674037e-02f, 3.96653190e-02f, -3.53418067e-02f, 3.12252473e-02f, 5.21089956e-02f, -1.28964894e-03f,
  -6.53237998e-02f, -8.47382024e-02f, -7.89302066e-02f, -1.47052864e-02f, 2.95760129e-02f, -8.45719278e-02f, 3.87559123e-02f, 6.85113966e-02f, 5.49131855e-02f, 5.29886084e-03f,
  2.98523158e-02f, 2.04403382e-02f, 1.03726275e-01f, -6.59683645e-02f, -1.68879237e-02f, -9.57263075e-03f, 4.95779552e-02f, 8.09273031e-03f, 3.43796588e-03f, -6.00531474e-02f,
  3.65578793e-02f, 5.41204140e-02f, 2.26818901e-02f, -8.43958836e-03f, 1.59330964e-02f, 3.70584913e-02f, -3.25655416e-02f, -9.74845141e-03f, 4.43851389e-03f, 2.58263275e-02f,
  -3.86604220e-02f, -6.54725730e-02f, 2.58896723e-02f, -2.39600167e-02f, -3.73522267e-02f, -6.60728663e-02f, 1.97250675e-02f, -4.30001430e-02f, 5.02660163e-02f, -5.03185764e-02f,
  -5.66437794e-03f, 2.70239753e-03f, -7.19760209e-02f, -1.75065901e-02f, 7.62448981e-02f, -2.23406889e-02f, -8.90953988e-02f, 3.40819992e-02f, 6.97485171e-03f, -8.42188206e-03f,
  -2.97591705e-02f, 3.20914127e-02f, -3.80049460e-02f, 3.30357626e-03f, -3.96560244e-02f, -1.00563325e-01f, -3.36782336e-02f, -6.43309131e-02f, 6.74005970e-02f, 9.12625343e-03f,
  -1.61131751e-02f, 7.04126433e-02f, -2.11085118e-02f, 5.29852416e-03f, 2.69456767e-02f, 2.80128960e-02f, 4.70474884e-02f, -2.21306924e-02f, 1.46695673e-02f, 2.72355266e-02f,
  4.25117984e-02f, 2.58663185e-02f, -5.01145199e-02f, 2.64965706e-02f, 2.07580514e-02f, -1.08161401e-02f, -3.79090756e-02f, -9.59189050e-03f, 1.88701190e-02f, 3.28984968e-02f,
  1.00930914e-01f, 6.75864443e-02f, -8.91050249e-02f, -4.17022035e-02f, -2.93029007e-02f, -7.61198029e-02f, 2.62458995e-02f, -3.58815566e-02f, -9.16340947e-02f, -2.03693137e-02f,
  5.90932975e-03f, 9.77055654e-02f, 5.15221171e-02f, 1.12818226e-01f, 2.29441151e-01f, 1.06767185e-01f, 1.14114344e-01f, 9.63034928e-02f, 7.01284930e-02f, 1.61263838e-01f,
  4.41537760e-02f, 2.22830966e-01f, 1.44559681e-01f, 3.11542246e-02f, 6.94418550e-02f, -8.25620666e-02f, 9.59962681e-02f, 2.53775399e-02f, 1.12788659e-02f, 1.01933897e-01f,
  -3.14843804e-02f, 5.07823639e-02f, -1.81214307e-02f, -6.97665587e-02f, -5.81791885e-02f, 7.05068279e-03f, -5.05889654e-02f, 5.52216098e-02f, 1.17826890e-02f, -1.98179241e-02f,
  8.27537850e-04f, -5.09174392e-02f, -1.83419865e-02f, 6.54252013e-03f, 1.26132378e-02f, -9.32151526e-02f, 3.42356339e-02f, 2.00977344e-02f, 1.76817959e-03f, 2.65194364e-02f,
  -1.08146202e-02f, -1.00761019e-01f, -1.11410297e-01f, 3.03900465e-02f, -4.86505665e-02f, 1.88462355e-03f, -2.17938889e-02f, -8.42439011e-02f, -5.40153421e-02f, -4.59811538e-02f,
  3.56506146e-02f, -3.95977348e-02f, -2.47254614e-02f, 4.42150012e-02f, 5.78917488e-02f, 5.33483513e-02f, -4.46645580e-02f, -3.96622196e-02f, 5.66803478e-03f, 5.58766238e-02f,
  -8.60640779e-03f, -1.39097208e-02f, 3.99969295e-02f, 4.53111082e-02f, -5.67724518e-02f, -5.84650822e-02f, -2.69277580e-02f, 1.55027686e-02f, 3.12350760e-03f, -5.04530296e-02f,
  -5.30735627e-02f, 2.39258856e-02f, -7.65874684e-02f, -3.09962817e-02f, -3.10523473e-02f, 9.81661025e-03f, -7.33388513e-02f, 2.39608195e-02f, 3.31796482e-02f, 8.59818757e-02f,
  -1.18785128e-02f, 1.70933947e-01f, -4.29449975e-02f, -8.37004744e-03f, -4.11446579e-02f, 6.58550858e-02f, -5.60828969e-02f, 2.08737291e-02f, 3.87864932e-02f, 4.01958115e-02f,
  -5.42086698e-02f, 3.42994407e-02f, -4.72051054e-02f, 3.02808657e-02f, 2.40261741e-02f, 2.53814571e-02f, 8.66132230e-03f, -5.58892824e-02f, -3.34469974e-02f, 7.97969699e-02f,
  7.09070787e-02f, -4.96813394e-02f, -4.65596355e-02f, 5.24062291e-02f, 7.86340330e-03f, -9.04485881e-02f, 3.02833803e-02f, -3.73821482e-02f, 6.77672401e-02f, 7.47391656e-02f,
  -2.57274091e-01f, 2.04793453e-01f, -2.72085946e-02f, -1.03820354e-01f, -2.02882532e-02f, -1.34816021e-01f, -4.62412611e-02f, -8.38806555e-02f, 1.61529686e-02f, 1.34305179e-01f,
  -7.13609606e-02f, 1.06412679e-01f, 6.07209541e-02f, -2.44612798e-01f, -3.66074383e-01f, -7.48628974e-02f, -2.61088401e-01f, -7.81109259e-02f, -1.80028901e-02f, -5.17476872e-02f,
  -1.96289182e-01f, -1.34043425e-01f, -2.20912024e-01f, -1.83073292e-03f, -6.53358400e-02f, 7.88938403e-02f, -1.34106085e-01f, 1.75906241e-01f, -1.39301747e-01f, -4.95138131e-02f,
  -9.23111141e-02f, 1.34926904e-02f, 5.57313152e-02f, 1.15537029e-02f, -5.45144752e-02f, 6.46028742e-02f, -1.95091348e-02f, 2.51985677e-02f, 2.61829644e-02f, -6.22776709e-02f,
  4.22283895e-02f, 3.28982109e-03f, 4.30847227e-04f, 1.73213780e-02f, 5.56483269e-02f, -5.76042123e-02f, 3.94650958e-02f, -4.46989313e-02f, 9.23155546e-02f, 3.16296555e-02f,
  -2.07191128e-02f, -7.90551007e-02f, -7.36074373e-02f, 2.71288715e-02f, -3.33829224e-02f, -1.58862825e-02f, -3.29706669e-02f, 5.08134998e-02f, 3.34932618e-02f, 1.16109597e-02f,
  2.79075652e-02f, 3.94673608e-02f, -3.28764486e-06f, -4.65301387e-02f, 6.45166785e-02f, -4.01623696e-02f, 3.78949530e-02f, -4.31689359e-02f, 5.56536056e-02f, -3.66508737e-02f,
  -1.56941395e-02f, 1.62273794e-02f, 3.98405688e-03f, 3.37355561e-03f, -3.06903627e-02f, 1.01231309e-02f, -4.81068902e-03f, 3.16694900e-02f, -3.48148495e-02f, -1.82580277e-02f,
  -7.28196511e-03f, -2.67109312e-02f, 1.87354181e-02f, -3.18070455e-03f, -3.89333814e-02f, -8.48213769e-03f, 1.14568947e-02f, 1.25273364e-02f, -1.25091663e-02f, 6.30371412e-03f,
  1.81670170e-02f, 1.16735563e-01f, 1.65647583e-03f, 8.29112679e-02f, -1.71945915e-02f, -7.28302523e-02f, 6.64390344e-03f, -3.55610140e-02f, 3.66771705e-02f, 4.87536304e-02f,
  4.84755710e-02f, 6.79336339e-02f, 1.99077185e-02f, -1.34968827e-03f, 2.64202766e-02f, -6.55770302e-02f, -1.54333636e-02f, -1.84112582e-02f, -6.19216487e-02f, -6.67353049e-02f,
  3.29452902e-02f, 5.82334027e-02f, 2.36774813e-02f, -1.14390524e-02f, -8.05543922e-03f, 3.10376287e-02f, 3.57363299e-02f, 4.47564311e-02f, -7.34466827e-03f, -2.53722072e-02f,
  -1.50408462e-01f, 2.64356434e-01f, 8.76696557e-02f, 1.08793996e-01f, -2.12784991e-01f, 2.63964683e-02f, 2.89395414e-02f, -3.52208205e-02f, 1.00015581e-01f, 1.48207158e-01f,
  3.88879403e-02f, 1.59117386e-01f, 4.86750863e-02f, 2.12585405e-01f, -3.55330929e-02f, 1.89688370e-01f, 1.70397326e-01f, 1.44812420e-01f, -4.79088314e-02f, -8.08470920e-02f,
  1.29482185e-03f, -7.50878379e-02f, 8.76113996e-02f, -2.41260022e-01f, -1.28166065e-01f, -7.74371102e-02f, -1.32504061e-01f, -1.57742590e-01f, -2.59676985e-02f, 6.00344315e-03f,
  -1.47319764e-01f, -4.61213253e-02f, -2.85599846e-02f, 5.53668365e-02f, -1.18773475e-01f, -1.69065353e-02f, 2.40145512e-02f, -6.03103824e-02f, -9.72713623e-03f, 4.70393263e-02f,
  -5.00495993e-02f, -1.30240330e-02f, -3.70781273e-02f, 5.07133678e-02f, -6.71039000e-02f, 4.59151566e-02f, 6.28793240e-02f, 1.07730199e-02f, 5.96965551e-02f, -4.25130799e-02f,
  1.28830954e-01f, 4.72432338e-02f, 8.98094103e-02f, 9.63545032e-03f, 5.29355220e-02f, -6.26799613e-02f, -6.71507930e-03f, -1.34452796e-02f, -3.61587033e-02f, 4.22268473e-02f,
  -1.00382201e-01f, 3.08475196e-02f, -1.14572681e-02f, 2.93996800e-02f, 1.12816785e-02f, -4.18909919e-03f, 3.26777017e-03f, -5.03841639e-02f, 4.07166965e-02f, 2.46637687e-02f,
  -8.02850351e-02f, -9.05248709e-03f, -2.30719708e-02f, 1.26959392e-04f, -3.53631075e-03f, 4.58853766e-02f, -4.98208515e-02f, -6.72191978e-02f, 4.57244143e-02f, -1.63589884e-02f,
  -5.44244386e-02f, 1.41826645e-02f, 2.87058372e-02f, -1.39318109e-02f, -6.97904406e-03f, -5.72178513e-02f, -3.32609490e-02f, 8.16040859e-02f, 1.83979422e-02f, -8.43059570e-02f,
  -1.06993094e-01f, 4.39367108e-02f, -3.13364342e-02f, -6.17947318e-02f, -7.32101128e-03f, 5.52852489e-02f, -1.46744018e-02f, -4.88432590e-04f, 2.88421363e-02f, -8.28444287e-02f,
  1.20933475e-02f, -2.28188504e-02f, -5.72870336e-02f, -6.19301014e-02f, 4.69996817e-02f, 4.47537266e-02f, -5.04216924e-02f, -2.24751662e-02f, -6.45713434e-02f, -1.12878345e-02f,
  -5.85641265e-02f, -2.89676152e-02f, 3.93003635e-02f, 9.60935093e-03f, -7.65219098e-03f, -3.73533973e-03f, -2.18184609e-02f, 5.37919104e-02f, 5.45985289e-02f, -5.57835251e-02f,
  9.40307975e-02f, 1.13652706e-01f, -3.14585567e-01f, -1.04592731e-02f, 7.52911568e-02f, -1.12665527e-01f, -2.32205421e-01f, 9.24185291e-02f, 1.47828117e-01f, 1.55990094e-01f,
  1.13623165e-01f, -8.07746649e-02f, -4.25368780e-03f, 1.60086844e-02f, -3.09291810e-01f, -1.40818268e-01f, -6.42428994e-02f, 8.03201227e-04f, -5.27467169e-02f, 5.55538349e-02f,
  6.33663908e-02f, 1.56475946e-01f, -2.14083418e-01f, 1.30600035e-01f, 7.09585622e-02f, -7.40105100e-03f, 8.70552361e-02f, -4.63754572e-02f, 6.93135476e-03f, -8.89489129e-02f,
  1.33941591e-01f, 1.17503047e-01f, 4.12312113e-02f, 3.78591008e-02f, -3.91684799e-03f, -3.61213610e-02f, -1.23047680e-01f, -1.15828805e-01f, -5.74020334e-02f, -3.25206295e-02f,
  2.41854992e-02f, -4.83453013e-02f, 5.39048426e-02f, 9.70052462e-03f, 7.30612203e-02f, 5.23852706e-02f, 3.42614353e-02f, -1.36364214e-02f, -5.71778603e-02f, -6.27688766e-02f,
  -6.41151518e-02f, -1.94995422e-02f, 2.70974170e-02f, 4.52078916e-02f, -5.79200834e-02f, 1.55847073e-02f, -2.80791544e-03f, -4.82314974e-02f, -5.81173711e-02f, 2.06479244e-02f,
  -9.38895717e-02f, -3.69394645e-02f, 1.76110547e-02f, 5.24802171e-02f, 5.08427918e-02f, 1.24273042e-03f, 1.94039214e-02f, -3.30351144e-02f, -7.75104575e-03f, -3.32547687e-02f,
  6.44498616e-02f, -4.24535498e-02f, 7.81410486e-02f, -6.07259832e-02f, 2.31080614e-02f, -1.91768389e-02f, 3.17334756e-02f, 3.44005898e-02f, 4.62373830e-02f, -4.46704514e-02f,
  -7.00053498e-02f, -1.58470739e-02f, 5.82561605e-02f, 5.85410511e-03f, -5.56359515e-02f, -2.38935798e-02f, 6.04967736e-02f, -1.60318892e-02f, 4.44411678e-04f, -8.30404386e-02f,
  1.46697953e-01f, -2.95528062e-02f, 4.93528508e-02f, 9.54817533e-02f, 6.46457896e-02f, 4.22889739e-03f, -3.29984142e-03f, 1.72485914e-02f, 3.42716277e-02f, 5.40834330e-02f,
  -8.23490601e-03f, 4.66335602e-02f, -6.81203529e-02f, 1.66789908e-02f, -7.57664219e-02f, 8.28491896e-02f, -7.05534369e-02f, -2.47921627e-02f, 5.63513152e-02f, 4.64004949e-02f,
  2.00888328e-02f, 1.84419770e-02f, -2.91731805e-02f, -2.77768020e-02f, -3.10101509e-02f, -2.24132184e-02f, -4.79602888e-02f, -5.07615395e-02f, 7.58131221e-02f, -2.43090801e-02f,
  2.78688520e-02f, -6.14659190e-02f, -2.85277992e-01f, 1.08525686e-01f, 9.92934778e-02f, 1.00359328e-01f, -1.37797995e-02f, 1.74825285e-02f, -1.12460628e-01f, 8.52360725e-02f,
  9.41460058e-02f, -9.16165709e-02f, -1.07086264e-01f, 1.59920931e-01f, 1.13923073e-01f, -5.23019023e-03f, 2.94281960e-01f, 1.64167151e-01f, -3.30531709e-02f, 8.82225409e-02f,
  1.00988798e-01f, 3.29790831e-01f, 1.89131107e-02f, 1.76909029e-01f, 1.36060908e-01f, -7.62261897e-02f, 1.11520723e-01f, -1.69688657e-01f, 1.83263361e-01f, 2.29057763e-02f,
  1.22512378e-01f, 6.08330667e-02f, -2.11280864e-03f, -6.67332187e-02f, 9.89411697e-02f, 2.99384315e-02f, 6.05429406e-04f, -7.60061368e-02f, -6.72464296e-02f, -3.55824386e-03f,
  -6.75083995e-02f, 2.94201262e-02f, -6.23131171e-02f, -5.07237427e-02f, -1.89571939e-02f, -8.34564865e-02f, -1.00815548e-02f, -3.23350951e-02f, 1.13153923e-02f, -1.64401885e-02f,
  -1.01034932e-01f, 2.27116235e-02f, 1.03066256e-02f, -4.41668145e-02f, -4.69285697e-02f, 8.24589655e-03f, -2.05982849e-02f, -5.59060164e-02f, -6.23398321e-03f, 3.53725106e-02f,
  8.24356303e-02f, -1.65836234e-02f, -4.89634871e-02f, 7.05043748e-02f, -5.48091494e-02f, 4.77639176e-02f, -6.21892177e-02f, 4.73147258e-02f, -5.40701896e-02f, 3.90880331e-02f,
  3.62240039e-02f, 7.79161835e-03f, -6.54101139e-03f, -1.54010383e-02f, -9.50840395e-03f, 2.38335766e-02f, -3.90888304e-02f, 1.71469571e-03f, -4.60995070e-04f, 5.84805384e-02f,
  -3.53127532e-02f, -3.62074487e-02f, -3.17066573e-02f, -1.18661253e-03f, 3.19586731e-02f, -5.24650998e-02f, 3.19305025e-02f, -5.38296811e-03f, -3.55377644e-02f, -6.53476920e-03f,
  2.07713604e-01f, 2.50268966e-01f, -6.94563705e-03f, 4.21919115e-02f, 1.02928383e-02f, 1.36578027e-02f, 2.58009247e-02f, -5.07508032e-02f, 4.38626744e-02f, -1.41742099e-02f,
  4.24068756e-02f, 1.93530917e-02f, 6.73740283e-02f, 1.15646957e-03f, -1.70171913e-02f, 8.00587684e-02f, -2.42983289e-02f, 6.84055910e-02f, 3.98271196e-02f, 9.77409557e-02f,
  -2.03228332e-02f, 8.79512634e-03f, 1.60616674e-02f, 1.06712461e-01f, 9.16783884e-02f, 6.16384782e-02f, 9.53321997e-03f, 2.72256676e-02f, 6.09818920e-02f, -4.69955653e-02f,
  -7.45033473e-02f, 9.57726091e-02f, -1.39095029e-02f, 2.01784763e-02f, -3.83852758e-02f, -5.28569482e-02f, 1.04181372e-01f, -1.72279421e-02f, 1.24726243e-01f, 1.84301138e-01f,
  3.50956693e-02f, -1.45478770e-01f, 2.41295487e-01f, -1.08503528e-01f, -2.18223706e-01f, 1.49235219e-01f, -1.47581697e-01f, -9.45387557e-02f, 6.70293793e-02f, 3.53022739e-02f,
  -5.61287813e-02f, 9.73916650e-02f, -2.39468310e-02f, -3.99981029e-02f, -7.91952759e-02f, -9.98847857e-02f, -7.01192617e-02f, -1.36145754e-02f, -1.49061441e-01f, 1.18542544e-03f,
  4.00697161e-03f, 1.43323556e-01f, -5.48124760e-02f, -5.08513078e-02f, -5.14646210e-02f, -1.22296482e-01f, 6.17932389e-03f, 4.80201319e-02f, -1.18879795e-01f, 6.65778443e-02f,
  7.08710914e-03f, -6.62645176e-02f, -5.80468327e-02f, 5.56354262e-02f, -1.29803270e-02f, -7.08467364e-02f, -8.34309384e-02f, -1.04447313e-01f, 4.87527065e-02f, 2.85355914e-02f,
  -1.58778466e-02f, 1.79987103e-02f, -5.21119609e-02f, -2.53993683e-02f, -8.36505443e-02f, 8.55126139e-03f, 2.11038142e-02f, -5.67410402e-02f, 1.41254198e-02f, 4.46122251e-02f,
  2.58545242e-02f, 1.96410827e-02f, 1.90015025e-02f, 3.24441530e-02f, -5.99120818e-02f, 1.29820993e-02f, 3.41858082e-02f, 7.33497366e-02f, -5.41356318e-02f, 5.19758910e-02f,
  2.54546385e-03f, -3.54159577e-03f, 5.38628772e-02f, -5.18287495e-02f, 3.81596126e-02f, 7.28432834e-02f, -6.88633025e-02f, 6.80984631e-02f, -9.91363227e-02f, -2.33880840e-02f,
  1.28563691e-03f, -8.35466087e-02f, 5.19190617e-02f, -6.96943626e-02f, 4.63317102e-03f, 1.87677667e-02f, 1.40557624e-03f, -6.35876507e-02f, 7.10151566e-04f, 6.50408268e-02f,
  -5.01257703e-02f, 3.16523388e-02f, 8.26559812e-02f, -3.45515423e-02f, 3.46786231e-02f, -4.20892537e-02f, 4.22368608e-02f, 1.88794862e-02f, -1.57428265e-03f, 4.67115976e-02f,
  1.72151588e-02f, 2.82432442e-03f, -2.06939876e-02f, -9.08187404e-02f, -3.51113863e-02f, 2.46866830e-02f, 9.65983607e-03f, 2.20674388e-02f, -1.26603274e-02f, -5.76110743e-02f,
  -6.19002022e-02f, -4.55834791e-02f, -3.10350750e-02f, 4.69313301e-02f, -1.35388551e-02f, 4.47093733e-02f, -7.50269741e-02f, 2.98644546e-02f, -1.20543703e-01f, 1.50007326e-02f,
  -3.36430013e-01f, 3.72919217e-02f, -3.34560692e-01f, -2.89712608e-01f, -1.74883753e-02f, -1.94300815e-01f, -1.62390888e-01f, -6.21904293e-03f, -1.30368039e-01f, 2.87925422e-01f,
  1.97586447e-01f, -2.65197366e-01f, 1.12363555e-01f, -2.07511876e-02f, -1.50966957e-01f, 1.69516325e-01f, -1.09221563e-01f, 5.11660576e-02f, -4.84194718e-02f, -1.10325396e-01f,
  -1.32269844e-01f, 1.00392051e-01f, -8.36998224e-02f, 7.55913854e-02f, -1.71444491e-01f, -7.00676292e-02f, 2.52687991e-01f, -4.46003899e-02f, 3.51273455e-02f, -4.56974842e-02f,
  -5.66958226e-02f, 2.14022025e-02f, -1.24342576e-01f, -7.25878999e-02f, -3.44488919e-02f, 1.75106060e-02f, -3.52326743e-02f, -8.20058882e-02f, 1.22536644e-02f, -3.59696895e-02f,
  -1.82973570e-03f, -2.98802387e-02f, -2.69246590e-03f, 5.92340231e-02f, -9.31808259e-04f, -6.26860932e-03f, -5.74892946e-02f, 4.89575863e-02f, -2.46936437e-02f, -3.53842117e-02f,
  -8.65275264e-02f, -1.96840409e-02f, 1.81842446e-02f, 2.30451319e-02f, -3.09456903e-02f, 1.60017032e-02f, -1.78613905e-02f, -6.94377124e-02f, 3.05869654e-02f, 1.28940318e-03f,
  4.99514826e-02f, 6.08920902e-02f, 9.88766998e-02f, -5.72436303e-02f, -4.01544720e-02f, 7.39098117e-02f, 3.46597023e-02f, 4.13952842e-02f, -4.36748192e-03f, 4.14519086e-02f,
  -4.52111028e-02f, 1.03528369e-02f, -3.97825278e-02f, 4.23014946e-02f, 8.36220686e-04f, 3.39942810e-04f, -3.13776173e-02f, 6.07414320e-02f, -5.05837798e-02f, 3.38588618e-02f,
  4.14933749e-02f, -4.64874655e-02f, 3.45277488e-02f, 1.94704272e-02f, -4.16758005e-03f, 1.41633479e-02f, 2.47467943e-02f, 9.30391438e-03f, 1.58571880e-02f, 1.87450759e-02f,
  1.53000401e-02f, 1.41301617e-01f, 1.33906472e-02f, -1.94781628e-02f, 1.01453923e-02f, 3.48199308e-02f, -1.75153799e-02f, 2.53162980e-02f, -2.62435842e-02f, -9.92563739e-03f,
  5.72195649e-03f, 2.01730616e-02f, -2.75395848e-02f, -3.02728880e-02f, -1.17230099e-02f, 3.66998799e-02f, 1.23759778e-02f, -3.20861675e-02f, -4.28733155e-02f, 2.47912258e-02f,
  2.31456235e-02f, 5.46656959e-02f, -5.68236895e-02f, 3.22440229e-02f, 1.26198856e-02f, -4.25687172e-02f, -6.29430786e-02f, 2.62604039e-02f, -5.94524620e-03f, 1.77579708e-02f,
  -2.21938416e-01f, 5.29212020e-02f, 2.23455131e-01f, -3.47865261e-02f, 1.77816022e-03f, 1.20397415e-02f, -1.49207726e-01f, 1.41306072e-01f, -1.43600971e-01f, -7.83844292e-02f,
  -1.92585334e-01f, -3.29737216e-02f, -1.86139807e-01f, -2.43070479e-02f, -3.73797938e-02f, -9.35501978e-02f, 4.81479317e-02f, -4.84648794e-02f, 1.37570258e-02f, -3.41520011e-02f,
  9.84142050e-02f, 1.91961695e-02f, 1.20231569e-01f, 1.96705565e-01f, 3.45641095e-03f, 1.43074572e-01f, -8.37920886e-03f, 1.45520583e-01f, 1.24219626e-01f, 1.36493683e-01f,
  -1.43623367e-01f, -2.01957040e-02f, -3.11578102e-02f, 7.97164887e-02f, -4.79043499e-02f, -8.48491341e-02f, -1.22464234e-02f, 5.61366044e-02f, 8.75571147e-02f, 1.04114302e-02f,
  -7.00033158e-02f, 5.63558191e-02f, 6.61443472e-02f, 1.46020502e-02f, -2.62896847e-02f, 1.01147555e-01f, -5.33795543e-02f, -1.97598431e-02f, 4.62012328e-02f, 2.72051189e-02f,
  -1.21887038e-02f, 1.16228824e-02f, 3.81403305e-02f, 1.21457487e-01f, 9.29217041e-02f, 1.36494115e-02f, 9.21106860e-02f, -4.44508567e-02f, 9.55342874e-02f, 3.17860842e-02f,
  9.81001109e-02f, -7.88400546e-02f, -6.90413192e-02f, -6.38417825e-02f, -3.53930779e-02f, 3.77052128e-02f, -6.16493113e-02f, -3.99569385e-02f, -2.50769127e-02f, -7.90026858e-02f,
  -5.06208651e-02f, -8.75353068e-02f, -1.60094649e-02f, 2.14361977e-02f, -6.17848262e-02f, 7.01584294e-03f, -2.25399341e-02f, 4.01550829e-02f, 1.96838975e-02f, -4.49266694e-02f,
  -2.38085613e-02f, 2.26556067e-03f, -8.17597657e-02f, 4.97911498e-02f, -2.00561453e-02f, 9.62326885e-04f, 6.22922881e-03f, 4.77241278e-02f, -4.63582226e-04f, -2.32888330e-02f,
  -6.63977489e-02f, -2.07954310e-02f, 8.03148374e-02f, 2.04305816e-02f, 5.97252175e-02f, 8.39358196e-03f, 8.61459672e-02f, 5.44443307e-03f, -2.85185985e-02f, 2.79877633e-02f,
  2.09317878e-02f, 8.55136756e-03f, -7.35598011e-03f, 2.32440345e-02f, 4.41589542e-02f, -8.32613260e-02f, -1.06244376e-02f, 1.48335509e-02f, 3.32111754e-02f, 6.86139539e-02f,
  4.10761349e-02f, -1.00624196e-01f, 4.69740182e-02f, 3.04786451e-02f, 6.36052117e-02f, -7.33090863e-02f, 7.91510753e-03f, 7.54089132e-02f, -3.29338983e-02f, 1.21549048e-01f,
  -1.09950408e-01f, 8.62399116e-02f, 7.65895769e-02f, -1.83662754e-02f, 6.36392797e-05f, 1.46229550e-01f, 2.10111871e-01f, -9.50113311e-02f, -1.54912040e-01f, 3.29817422e-02f,
  -2.38674805e-02f, -3.23798321e-02f, 1.33159176e-01f, -8.92386679e-03f, -4.16741073e-02f, -1.30250873e-02f, 5.23154624e-02f, 7.60174841e-02f, 1.83134619e-02f, -1.36375828e-02f,
  -9.15336702e-03f, -1.48576260e-01f, -3.61992116e-03f, -6.00317866e-02f, -4.82986383e-02f, -1.43654108e-01f, -1.40522137e-01f, -2.36559622e-02f, 4.94605936e-02f, 1.65194925e-02f,
  -7.81227602e-03f, -1.33195743e-01f, 2.84449607e-02f, 8.37733224e-02f, 8.71809050e-02f, 8.90185162e-02f, 1.43284932e-01f, 4.49888222e-02f, -3.65329124e-02f, -2.14964077e-02f,
  -8.16701038e-04f, -4.21221815e-02f, -1.04676925e-01f, -6.04817346e-02f, 2.19079889e-02f, -9.16521102e-02f, 2.30470560e-02f, -5.16441688e-02f, 7.25972839e-03f, 1.17788799e-02f,
  2.69104578e-02f, -4.61226664e-02f, -3.64380777e-02f, 1.20428376e-01f, -7.86321312e-02f, -8.10065195e-02f, 9.91530046e-02f, 8.13381895e-02f, 1.24217821e-02f, -1.57187153e-02f,
  2.32404075e-03f, 7.16418549e-02f, 5.82558438e-02f, 4.06782813e-02f, 5.47573492e-02f, 6.42365888e-02f, 3.02946698e-02f, 4.48489077e-02f, -4.90388125e-02f, 1.49839725e-02f,
  -4.91111986e-02f, 6.15489185e-02f, -2.92053781e-02f, -6.54739514e-02f, 4.93061319e-02f, -7.40557462e-02f, 3.62505671e-03f, -2.27790922e-02f, 5.93820936e-04f, -6.69692010e-02f,
  -2.98153125e-02f, 1.87082996e-03f, -4.87777889e-02f, -2.89179161e-02f, -6.71952544e-03f, -4.60827835e-02f, 4.48124222e-02f, 5.18728159e-02f, 2.04313844e-02f, -4.63539828e-03f,
  -5.62301558e-03f, -6.73242956e-02f, 4.45866305e-03f, 6.39062002e-02f, 6.73258752e-02f, 1.68415904e-02f, 1.08604915e-01f, -9.00626183e-02f, -9.84828994e-02f, 3.42810452e-02f,
  -4.23457213e-02f, 3.85220572e-02f, 8.27634800e-03f, 5.26290163e-02f, 7.35030919e-02f, -6.06207810e-02f, -1.55623425e-02f, -1.52489543e-02f, -1.95490997e-02f, -3.20248902e-02f,
  -5.60588799e-02f, -2.48620361e-02f, -7.23927692e-02f, 2.84856129e-02f, 8.85870829e-02f, -2.98412573e-02f, -9.43093225e-02f, -6.74801171e-02f, 3.79715301e-02f, -1.57115404e-02f,
  -7.12345466e-02f, 2.87570804e-01f, 8.07355195e-02f, -8.47579539e-02f, -1.64910078e-01f, -1.07003614e-01f, -3.98369133e-02f, -2.83573642e-02f, 1.45675316e-01f, 2.71673918e-01f,
  -1.15185961e-01f, 1.23807162e-01f, 6.95912465e-02f, -9.39864293e-02f, -3.71990860e-01f, 3.99685279e-03f, -7.37720355e-02f, -8.55844934e-04f, -3.50664333e-02f, -9.72710997e-02f,
  -1.61951974e-01f, -2.36742914e-01f, -1.41164944e-01f, -1.69652700e-01f, -9.67575237e-02f, 1.29378531e-02f, -1.80972740e-01f, 1.44583778e-02f, -1.11110955e-01f, -1.11873843e-01f,
  -5.90304919e-02f, 1.12123728e-01f, -4.20722086e-03f, 6.35573454e-03f, -2.98481360e-02f, -5.58004752e-02f, -6.79964246e-03f, -7.39876106e-02f, -1.99995115e-02f, 3.51262838e-02f,
  4.54762578e-02f, 3.51104923e-02f, 5.08356020e-02f, -3.54564600e-02f, 2.85003278e-02f, 6.73547983e-02f, -4.08100262e-02f, 2.01029913e-03f, 8.64314884e-02f, 2.33807638e-02f,
  1.53643843e-02f, 6.06843010e-02f, -5.89113832e-02f, -3.27623114e-02f, -5.03417887e-02f, 6.39675632e-02f, 4.96084131e-02f, -7.13483244e-02f, 6.47430494e-02f, -4.03497070e-02f,
  -1.45245790e-02f, 1.57909188e-02f, 4.98622321e-02f, 3.06458306e-02f, -7.54768727e-03f, 2.66499128e-02f, -2.22151028e-03f, 1.15322592e-02f, 4.97410670e-02f, 3.70322801e-02f,
  3.13591212e-02f, 5.20663820e-02f, 1.12209842e-02f, 3.18597667e-02f, -5.26036732e-02f, 7.32684880e-02f, -1.31623987e-02f, -2.90468857e-02f, 2.95413379e-02f, -2.34413538e-02f,
  5.92498221e-02f, 3.68952006e-03f, 1.50370179e-02f, -1.24476552e-02f, 1.58282171e-03f, 1.01346420e-02f, 3.37288231e-02f, 7.21617714e-02f, -5.37531392e-04f, -1.04455054e-01f,
  -7.01961666e-02f, -6.53881356e-02f, 5.10520563e-02f, 8.08044672e-02f, 2.44239569e-02f, -4.84065861e-02f, 1.12248957e-02f, 2.01099832e-02f, -2.51451135e-02f, -8.07607397e-02f,
  -8.80092978e-02f, 1.19936951e-02f, -2.36717761e-02f, -1.12098698e-02f, -7.14818463e-02f, -5.15317619e-02f, 2.90938802e-02f, 3.47785689e-02f, -9.11943838e-02f, -4.12972458e-02f,
  2.19519925e-03f, -4.11155298e-02f, 1.71265863e-02f, 4.96619055e-03f, -7.34908786e-03f, -4.07433584e-02f, -6.03759140e-02f, 6.09839968e-02f, -2.61806548e-02f, 6.57560155e-02f,
  2.82682240e-01f, -1.77498013e-01f, 4.57858182e-02f, 1.78022042e-01f, -4.54797260e-02f, 2.17583999e-01f, 1.48651809e-01f, -1.05262734e-01f, -3.74121480e-02f, -2.42160425e-01f,
  -1.12977996e-02f, 8.93869847e-02f, -2.90508661e-02f, 1.42207846e-01f, 4.87964064e-01f, 8.19138736e-02f, 2.36843348e-01f, 9.40314755e-02f, 4.38776286e-03f, -8.03469773e-03f,
  1.17851131e-01f, -3.37830819e-02f, 5.80369011e-02f, -2.24017739e-01f, -6.97496310e-02f, -1.51215285e-01f, 8.39946698e-03f, -4.74893041e-02f, 3.83349578e-03f, 2.64665242e-02f,
  5.22065498e-02f, -7.10129216e-02f, -6.95934072e-02f, 2.02616081e-02f, 4.80458736e-02f, -1.21250367e-02f, 7.45477527e-02f, -4.03678138e-03f, 2.48903036e-02f, -3.62897068e-02f,
  2.32378393e-02f, 5.40268496e-02f, 2.04379745e-02f, 1.46213863e-02f, 6.56917365e-03f, -4.58132997e-02f, -3.63439647e-03f, -3.92893925e-02f, -5.46077639e-02f, 8.10637847e-02f,
  6.12378912e-03f, 2.34110299e-02f, 6.84747472e-02f, -8.96550342e-03f, 8.87887701e-02f, 2.45303325e-02f, 4.38564457e-02f, 5.66961654e-02f, 3.77058727e-03f, 5.00367954e-02f,
  2.00028475e-02f, 4.45649913e-03f, 5.67345135e-02f, -5.48778959e-02f, -3.10884230e-03f, 7.61870237e-04f, -2.07065009e-02f, 4.27997857e-02f, -1.77138988e-02f, 5.16827926e-02f,
  5.93396090e-02f, 1.87814608e-02f, -1.56053090e-02f, -6.56731369e-04f, 3.38584706e-02f, -3.42438668e-02f, 4.11903206e-03f, 1.98788438e-02f, -6.81606214e-03f, 4.02075090e-02f,
  -7.90195763e-02f, 7.34689608e-02f, -3.23787518e-02f, 3.75418104e-02f, -5.87252975e-02f, 3.17622395e-03f, 1.88836176e-02f, 5.00538619e-03f, 3.51842120e-02f, 3.20573933e-02f,
  5.17125987e-02f, -1.57145727e-02f, -6.91121295e-02f, -8.00142065e-02f, -6.14312775e-02f, 5.83330542e-03f, 2.95104366e-02f, 3.20016555e-02f, 2.08467450e-02f, 2.38307044e-02f,
  -1.42754288e-02f, -4.93729413e-02f, 7.00521003e-03f, -1.46909449e-02f, 1.15284482e-02f, 1.54455975e-02f, 3.49838398e-02f, 5.37982956e-02f, 6.15339316e-02f, -5.07988669e-02f,
  3.26406723e-03f, -3.70614976e-02f, 6.64403960e-02f, -7.71275759e-02f, -4.45851758e-02f, -1.51474494e-02f, 2.23488696e-02f, -2.39788797e-02f, 3.85035202e-02f, -1.50016649e-02f,
  3.07364702e-01f, -1.78809404e-01f, -1.16855375e-01f, 1.06569424e-01f, -3.36067937e-02f, -2.15376943e-01f, -1.53119028e-01f, -8.86533409e-02f, 1.25789165e-01f, -5.40079586e-02f,
  -1.25732332e-01f, 1.26510058e-02f, -1.14549436e-01f, 2.04640143e-02f, -3.75612341e-02f, -9.96076968e-03f, 4.40853573e-02f, 3.53918336e-02f, -2.26560626e-02f, -9.08934399e-02f,
  9.43339989e-02f, -3.52339149e-02f, -2.44064704e-02f, -1.38685107e-01f, -8.26042593e-02f, -7.84893036e-02f, -3.82168451e-03f, -1.67410299e-01f, -3.50299589e-02f, -7.95517117e-02f,
  9.77547914e-02f, -2.40158141e-02f, -2.93612294e-02f, 1.06188349e-01f, -1.34439794e-02f, -5.86828664e-02f, -5.43019213e-02f, -6.86075613e-02f, -4.45626453e-02f, -2.83527058e-02f,
  -8.85032266e-02f, -3.53951938e-02f, -1.96060743e-02f, -1.14560721e-03f, 6.33411333e-02f, -5.37799373e-02f, 2.42320001e-02f, 2.87607443e-02f, -9.27170273e-03f, 3.24650370e-02f,
  4.44735587e-02f, -4.18215021e-02f, -4.32985239e-02f, 3.69515419e-02f, -3.38638276e-02f, -5.99497855e-02f, -8.40390250e-02f, -5.65984808e-02f, -1.61006581e-02f, 4.38408665e-02f,
  -8.00632611e-02f, -3.90983336e-02f, 3.43145132e-02f, 6.98671630e-03f, -2.89339740e-02f, 1.09201828e-02f, -3.24820168e-03f, -3.30195501e-02f, 1.21807214e-02f, -5.67984767e-02f,
  -1.47189992e-02f, 2.70663993e-03f, 5.57363927e-02f, 2.46581510e-02f, -2.13443451e-02f, 8.95659178e-02f, -5.13006449e-02f, 9.95552819e-03f, -1.14156669e-02f, 4.11704928e-02f,
  5.98045923e-02f, -6.64933845e-02f, -4.66092154e-02f, 2.98280511e-02f, 4.45748717e-02f, -3.27048264e-02f, -5.16892038e-02f, -2.76933983e-02f, 3.38934958e-02f, -2.06442475e-02f,
  -1.70403957e-01f, -2.41737768e-01f, 8.33886042e-02f, -4.54393551e-02f, -5.44528142e-02f, 3.42192203e-02f, 3.44925299e-02f, -6.00514887e-03f, -9.80572850e-02f, 8.30979552e-03f,
  -5.22903278e-02f, 9.35732946e-02f, -3.26100253e-02f, -1.59486085e-02f, -5.40384874e-02f, 7.95976259e-04f, -1.10241584e-01f, 1.76204275e-02f, -5.28784618e-02f, -6.83084801e-02f,
  -1.66210812e-02f, -7.70254508e-02f, -8.59858189e-03f, 4.98030242e-03f, -4.66207974e-02f, 1.08113000e-02f, 3.03559713e-02f, -1.98206473e-02f, -9.06545445e-02f, 2.06168508e-03f,
  -4.51923937e-01f, 1.46541625e-01f, 5.59177920e-02f, -2.44415611e-01f, -4.00179364e-02f, -1.57828048e-01f, -1.97076783e-01f, 6.48726001e-02f, -2.18421817e-01f, 1.25725251e-02f,
  1.79603361e-02f, -1.38225153e-01f, 1.84278816e-01f, -1.91260025e-01f, -8.89704376e-02f, 1.14041090e-01f, -2.16301754e-01f, -1.73404083e-01f, -3.49423625e-02f, -5.92258424e-02f,
  -1.18926123e-01f, -3.82947959e-02f, 1.04959600e-01f, 3.15705985e-02f, -2.88055614e-02f, -8.64225731e-04f, 1.74618021e-01f, 2.08239123e-01f, -1.18085921e-01f, -1.45886438e-02f,
  4.24201367e-03f, -5.72350919e-02f, 6.07137978e-02f, -1.62303774e-03f, -3.26029360e-02f, 4.54849675e-02f, -2.21230648e-02f, -2.41494738e-02f, 2.81774495e-02f, -3.58113907e-02f,
  -7.41999820e-02f, 4.11962010e-02f, -8.17847848e-02f, -1.74307898e-02f, -7.60087445e-02f, -2.89382227e-02f, -1.88023578e-02f, -8.68020728e-02f, -4.45939116e-02f, 1.74043365e-02f,
  -1.17688831e-02f, -1.64840836e-02f, -6.03596158e-02f, -4.10254262e-02f, 2.77772397e-02f, -4.90333848e-02f, 7.38039985e-03f, 4.62110303e-02f, -1.84608828e-02f, -5.38059957e-02f,
  3.51953343e-03f, 9.48341563e-03f, 7.18321837e-03f, 3.94093581e-02f, 2.71598231e-02f, 6.21925741e-02f, -6.41241297e-02f, 8.27120896e-03f, -5.98679297e-02f, -3.11371665e-02f,
  -2.45187320e-02f, -4.01388742e-02f, -6.97651356e-02f, 7.11329398e-04f, -1.42669550e-03f, -3.52084786e-02f, 3.28568486e-03f, -2.46186312e-02f, 5.61913429e-03f, -4.97761779e-02f,
  1.73435509e-02f, -3.92414406e-02f, 6.21712208e-02f, -1.17337899e-02f, -1.01670399e-02f, 6.19884059e-02f, 6.77553341e-02f, -4.90783863e-02f, 1.48485908e-02f, -3.45578454e-02f,
  1.05838804e-02f, -3.31739685e-03f, 2.69335192e-02f, -5.73257990e-02f, 4.22213860e-02f, -5.68214804e-02f, 2.65708957e-02f, -7.48915970e-02f, 1.04347263e-02f, 5.30170575e-02f,
  5.28556965e-02f, -7.53756016e-02f, -3.14260386e-02f, -1.10545233e-02f, 4.79831919e-02f, -2.45544873e-02f, 5.39189316e-02f, 5.03398776e-02f, 2.53489092e-02f, -2.63417959e-02f,
  -1.62482057e-02f, -3.23030613e-02f, 2.89876647e-02f, -2.74257641e-02f, -7.01058730e-02f, 5.46157770e-02f, -3.59579958e-02f, -4.01863828e-02f, 3.32976808e-04f, 6.33052140e-02f,
  1.71713099e-01f, -1.79028943e-01f, 9.77938473e-02f, -4.40924987e-02f, 1.26595786e-02f, -1.61414430e-01f, -7.15896711e-02f, -1.46209262e-02f, -3.49727347e-02f, -8.85614827e-02f,
  -1.01027876e-01f, 2.03728110e-01f, -3.24449837e-02f, -1.64842233e-01f, 1.55591797e-02f, -2.12490842e-01f, -1.38413504e-01f, 7.98044074e-03f, -1.45528594e-03f, 5.40546700e-02f,
  -5.21140359e-02f, -1.24734275e-01f, -6.65947720e-02f, -9.40083638e-02f, 7.56486878e-02f, 1.25340149e-01f, -1.46290334e-02f, 3.53397913e-02f, -7.68528953e-02f, -9.84023884e-02f,
  -2.20473278e-02f, -6.14657700e-02f, 4.80555072e-02f, 6.10852754e-03f, -2.43888870e-02f, 1.07592940e-01f, 1.62182841e-02f, -1.97735876e-02f, 3.58746350e-02f, 7.18027540e-03f,
  -3.80092475e-04f, 4.45605479e-02f, -5.13101481e-02f, 4.26801480e-02f, 3.30080651e-02f, 2.91711628e-03f, 8.34793597e-02f, 9.43407118e-02f, -1.86330900e-02f, 8.15400407e-02f,
  8.86670724e-02f, 1.49242887e-02f, 6.80241659e-02f, -1.01361852e-02f, -1.77029893e-02f, -3.58552560e-02f, -3.99292912e-03f, 6.59432495e-03f, 8.28618277e-03f, -1.32524483e-02f,
  7.21226865e-03f, 4.27772030e-02f, -3.70678902e-02f, -6.44764155e-02f, -7.67671838e-02f, -5.40049076e-02f, -5.06236926e-02f, 2.05576755e-02f, 5.55822738e-02f, -6.82666376e-02f,
  -6.30595209e-03f, -2.09998358e-02f, 2.27412954e-02f, 1.77040827e-02f, 2.75102984e-02f, 8.06116685e-02f, -2.12778207e-02f, -9.66711622e-03f, -3.38986963e-02f, 8.03106874e-02f,
  -9.55786370e-03f, 1.26317088e-02f, -8.80006142e-03f, 5.75382486e-02f, -2.79143942e-03f, -5.57114780e-02f, -3.60330641e-02f, 5.03973439e-02f, 5.60817728e-03f, 3.80172879e-02f,
  -1.02329686e-01f, -9.08070505e-02f, -1.69210671e-03f, 6.76714927e-02f, -1.99589226e-02f, -7.69893033e-03f, -3.25574987e-02f, 1.92363430e-02f, -7.32285976e-02f, -6.36179969e-02f,
  1.04562908e-01f, -3.50909270e-02f, 5.05253151e-02f, -1.77858416e-02f, -4.74594124e-02f, 2.75261775e-02f, 2.64823604e-02f, 1.44090541e-02f, -5.60898595e-02f, 6.96441308e-02f,
  6.36320338e-02f, -4.46566194e-02f, -7.16955066e-02f, 5.35575151e-02f, -4.37278077e-02f, 4.66858894e-02f, 4.22049761e-02f, 4.61141858e-03f, 4.60570976e-02f, -2.63629369e-02f,
  -1.88936037e-03f, 2.22232163e-01f, 1.24735810e-01f, 9.14718583e-03f, 1.44439295e-01f, -1.68034315e-01f, -3.10879201e-01f, 2.27485031e-01f, 3.23889911e-01f, -1.92443982e-01f,
  -9.33856890e-02f, 6.16642945e-02f, -9.52564850e-02f, -4.68232594e-02f, -6.88225403e-03f, -8.41273516e-02f, 4.34835814e-03f, -1.34519100e-01f, 2.43526295e-01f, 5.52262254e-02f,
  1.55143693e-01f, 1.34433003e-03f, 1.33825531e-02f, 1.73643664e-01f, 1.00489743e-02f, 6.31963685e-02f, -1.24004520e-01f, 9.72796082e-02f, -1.73694447e-01f, -4.33358289e-02f,
  -2.49660555e-02f, 2.12722346e-01f, 3.02740112e-02f, 6.53526634e-02f, -4.27814424e-02f, -1.00577220e-01f, -7.38969520e-02f, -5.38171083e-02f, 7.82589540e-02f, 6.60042539e-02f,
  -5.33109494e-02f, 5.67404106e-02f, 8.12132210e-02f, 2.78234272e-03f, 2.70732325e-02f, 4.86930599e-03f, 8.93656090e-02f, 2.51426303e-04f, -2.45676190e-02f, 3.37932818e-02f,
  3.44618298e-02f, 2.64681992e-04f, -6.80771424e-03f, -1.07975036e-01f, 6.02954775e-02f, -1.51747502e-02f, -7.55687356e-02f, -1.16684781e-02f, 8.46674386e-03f, 6.92905411e-02f,
  2.22518165e-02f, 6.00419613e-03f, 1.41126234e-02f, -8.46863817e-03f, 4.02584597e-02f, 6.65416121e-02f, -4.29095589e-02f, 2.30369531e-02f, -2.31521670e-02f, 3.77331525e-02f,
  4.22662981e-02f, -2.20031338e-03f, 8.81039575e-02f, -8.29103068e-02f, 7.31797069e-02f, -3.90457883e-02f, -1.55212991e-02f, 1.45295402e-02f, 7.11751403e-03f, -2.18657143e-02f,
  -1.37528405e-02f, -1.67449303e-02f, 1.03947408e-02f, -3.88705991e-02f, 2.72566290e-03f, -3.23481709e-02f, -5.78167886e-02f, -8.14557541e-03f, -4.00106385e-02f, -8.12251940e-02f,
  6.54209405e-02f, 1.14412107e-01f, 4.14839387e-02f, 4.07931395e-02f, -3.78341042e-02f, -2.50702575e-02f, 1.83629245e-02f, -1.21311434e-02f, -3.70639600e-02f, 3.76211815e-02f,
  -6.23464361e-02f, -1.09217666e-01f, -7.40434155e-02f, -1.99560020e-02f, -5.22549711e-02f, 1.72769316e-02f, -1.18221328e-01f, 2.24083122e-02f, -7.45017594e-03f, 1.24669224e-02f,
  -5.77760376e-02f, -4.28998992e-02f, -5.92603087e-02f, 7.49744847e-02f, -1.03480309e-01f, 1.99161517e-03f, 3.11875138e-02f, -2.81350873e-02f, -4.96324971e-02f, -2.57889759e-02f,
  1.99075818e-01f, 1.84548527e-01f, -1.03962079e-01f, 3.36702690e-02f, -5.27817532e-02f, 1.35685816e-01f, 5.34585156e-02f, 1.50504604e-01f, 1.27240643e-01f, 4.67974916e-02f,
  -6.40314743e-02f, 7.47274887e-03f, 3.93033735e-02f, -1.20170288e-01f, 2.52919681e-02f, 4.31571230e-02f, 1.11740023e-01f, 8.62336159e-02f, -8.54171440e-02f, 8.49053860e-02f,
  -7.03443065e-02f, 3.92011553e-02f, -6.35339618e-02f, -9.80115682e-02f, 7.75751621e-02f, -1.29997125e-03f, 2.51547899e-02f, -1.75586298e-01f, -2.86966078e-02f, -1.06846116e-01f,
  1.21036887e-01f, -1.13012327e-03f, -8.89005512e-02f, -5.91290463e-03f, 7.12914541e-02f, 2.30482612e-02f, -7.21359029e-02f, -4.62484248e-02f, 1.25451507e-02f, -2.63063516e-02f,
  7.27004791e-03f, -1.84075851e-02f, -8.92814656e-04f, -1.63790938e-02f, 2.04843059e-02f, -1.05725443e-02f, -5.03905602e-02f, 4.22573686e-02f, -4.08398770e-02f, -7.16508031e-02f,
  3.01037971e-02f, 6.52421042e-02f, -8.50220863e-03f, 5.74580813e-03f, -5.62327122e-03f, -5.73453493e-02f, -1.87311769e-02f, -7.72621259e-02f, 9.32353139e-02f, 7.75633678e-02f,
  -2.53649000e-02f, -3.57499123e-02f, -4.22826596e-02f, 2.77029560e-03f, -2.41454002e-02f, 1.27161655e-03f, 5.02745016e-03f, -8.12105536e-02f, 7.35630244e-02f, 3.72251943e-02f,
  8.28258917e-02f, -4.43104431e-02f, -6.91056298e-03f, 5.02143502e-02f, 7.37870112e-02f, 4.92205545e-02f, 3.76410969e-03f, 6.41614646e-02f, -2.52631996e-02f, 6.22659223e-03f,
  1.94254593e-04f, 8.83817226e-02f, -2.22641695e-02f, -5.89286648e-02f, -5.98782822e-02f, -5.43575585e-02f, 5.10235652e-02f, -2.97649335e-02f, -8.12095925e-02f, -6.79413229e-02f,
  3.22603345e-01f, 2.36656949e-01f, 3.94150019e-02f, 7.35415220e-02f, 6.23505116e-02f, -1.13250669e-02f, -1.62879769e-02f, -3.10652852e-02f, 4.67474721e-02f, 9.62462351e-02f,
  9.76898596e-02f, 5.95145263e-02f, 4.07143831e-02f, 4.51891199e-02f, 3.62621918e-02f, -2.92705861e-03f, -1.57550704e-02f, -1.51947299e-02f, 9.73031446e-02f, 4.27878313e-02f,
  6.14110241e-03f, 2.66153812e-02f, -5.56534417e-02f, 5.57911433e-02f, -2.27495320e-02f, -8.21617199e-04f, -3.86876762e-02f, 1.69063658e-02f, 3.35796140e-02f, 3.23228687e-02f,
  -1.99344024e-01f, 2.59531941e-03f, -1.91777140e-01f, -1.73817083e-01f, 1.56503320e-01f, 1.70272410e-01f, -1.65712878e-01f, 5.11453338e-02f, -7.60946721e-02f, -1.70876771e-01f,
  -1.24965310e-01f, -1.60016239e-01f, -2.24452436e-01f, -1.04296751e-01f, -6.55473694e-02f, -1.08666770e-01f, -1.14369672e-02f, -1.30305082e-01f, 2.96264701e-02f, -1.39608994e-01f,
  -4.05638814e-02f, 5.14353216e-02f, -4.38919328e-02f, 1.46028519e-01f, -5.16043827e-02f, -3.66102182e-03f, -1.15688145e-01f, 4.59263846e-02f, 3.92592810e-02f, 7.20167831e-02f,
  9.37824845e-02f, -2.14750528e-01f, 5.21457187e-05f, -3.41052487e-02f, -5.94821908e-02f, -6.53285459e-02f, -1.51450867e-02f, 3.63867842e-02f, -3.19103599e-02f, 7.78314173e-02f,
  2.06180586e-04f, 1.01476952e-01f, 8.79593864e-02f, -5.31727541e-03f, 6.28703758e-02f, 2.76264790e-02f, 8.72308761e-02f, 5.66316321e-02f, 6.91446140e-02f, 6.08175397e-02f,
  1.19265625e-02f, -2.61375774e-03f, -9.18173194e-02f, -3.15622985e-02f, -2.67989114e-02f, 2.24888716e-02f, -5.83198480e-02f, 1.70271713e-02f, -2.19866596e-02f, 4.33034934e-02f,
  -4.91463915e-02f, -4.03857455e-02f, -6.21287562e-02f, -3.41016129e-02f, -4.11824062e-02f, 5.58652841e-02f, -2.89143417e-02f, 3.53342593e-02f, -1.35667576e-03f, -2.01194361e-02f,
  7.00076371e-02f, 6.97467849e-03f, 6.26552850e-02f, 2.44473815e-02f, -4.61633988e-02f, 1.37095274e-02f, 4.06804346e-02f, 1.75719820e-02f, 9.90782585e-03f, 9.17911250e-03f,
  -5.31175882e-02f, 1.79810021e-02f, -5.27757816e-02f, 7.36798123e-02f, 2.97554024e-02f, -4.28868234e-02f, 5.70598617e-02f, 5.42023741e-02f, -4.92559336e-02f, -1.36239566e-02f,
  -8.24887753e-02f, -2.15068758e-01f, -9.30833910e-03f, 6.92452490e-03f, -4.82896119e-02f, 5.01264147e-02f, -3.89504409e-03f, -2.70371828e-02f, -7.75611624e-02f, -4.09242809e-02f,
  -3.98747586e-02f, 1.23189744e-02f, -6.86009601e-02f, 7.21479729e-02f, 2.89579062e-03f, 5.08238655e-03f, -3.94051708e-02f, 1.15603441e-02f, -8.53797644e-02f, 7.20261335e-02f,
  -7.94574767e-02f, 3.25357988e-02f, -5.21049649e-02f, -1.41288564e-02f, 6.11137412e-02f, -4.81566750e-02f, -2.99489908e-02f, -2.31801197e-02f, 1.58465710e-02f, 3.87424640e-02f,
  -3.10363799e-01f, 1.11812845e-01f, 1.25952050e-01f, -1.21989116e-01f, -2.27515697e-01f, -4.80698831e-02f, -8.22415017e-03f, -7.68510476e-02f, -4.06602174e-02f, -2.36989502e-02f,
  -3.49799246e-02f, 5.51960133e-02f, 8.66744667e-02f, 9.02875438e-02f, 1.16707318e-01f, 5.15569411e-02f, 1.04244072e-02f, -2.60257460e-02f, 6.15891740e-02f, -1.14742465e-01f,
  -6.82407096e-02f, 2.89886855e-02f, 2.21452951e-01f, 4.66815569e-02f, -6.38040677e-02f, 1.54725583e-02f, 8.61285701e-02f, 8.12971592e-02f, 2.40584258e-02f, 7.85252005e-02f,
  -9.67026427e-02f, 2.36937515e-02f, 4.83074784e-02f, 5.29939830e-02f, 5.93171045e-02f, -2.92706559e-03f, 5.28224036e-02f, 9.72099751e-02f, -6.50453335e-03f, 5.33106849e-02f,
  -1.08079523e-01f, -4.65269526e-03f, 5.02894148e-02f, -7.52325356e-03f, -4.90831956e-02f, 6.52969722e-03f, -3.88812609e-02f, 1.17070088e-02f, 3.48517522e-02f, -5.66983633e-02f,
  -4.35992032e-02f, 1.64963659e-02f, -8.06528628e-02f, 1.58726200e-02f, 2.03770325e-02f, -7.16078877e-02f, 1.79802813e-02f, 1.59069691e-02f, -8.31932276e-02f, -8.92360210e-02f,
  -9.02497023e-02f, -5.98970614e-02f, 2.71681882e-02f, -2.53843293e-02f, -6.40354306e-02f, 5.04360348e-02f, -4.26907912e-02f, 5.28075807e-02f, 3.89421694e-02f, -9.23910085e-03f,
  -2.40015052e-02f, -1.47906858e-02f, 3.43746543e-02f, -3.24524902e-02f, -4.49995697e-03f, -7.52601400e-02f, 7.75609016e-02f, -3.10946032e-02f, 4.04426679e-02f, 9.89551842e-03f,
  -1.97531097e-02f, 5.13344444e-02f, -4.26577516e-02f, -6.85704523e-04f, 1.38566848e-02f, 3.16538266e-03f, -4.22769506e-03f, -3.04790474e-02f, 4.01216671e-02f, -5.29495403e-02f,
  1.60291214e-02f, 6.49454743e-02f, 2.50188578e-02f, 4.20378111e-02f, 7.62068257e-02f, -1.26660824e-01f, -1.52884666e-02f, 5.88355586e-03f, -2.72147991e-02f, -6.12647319e-03f,
  1.88316777e-02f, -1.21576982e-02f, -6.64678821e-03f, -5.92205264e-02f, -3.00269127e-02f, -1.02281328e-02f, -3.09974365e-02f, -1.09990891e-02f, -4.66301553e-02f, 5.99713884e-02f,
  -1.86513457e-02f, -3.42809223e-02f, -5.98143274e-03f, 5.91263622e-02f, -5.53728566e-02f, 7.11157499e-03f, -9.34379473e-02f, 1.76698025e-02f, 3.57329622e-02f, 3.06547955e-02f,
  -2.33467706e-02f, 2.96816736e-01f, 9.57624540e-02f, -1.45476207e-01f, -1.40255630e-01f, 1.19661339e-01f, 2.28648745e-02f, 7.75509849e-02f, 1.25013553e-02f, 5.46532385e-02f,
  -2.37473566e-02f, 1.13486513e-01f, 4.22437564e-02f, 2.01505646e-02f, 5.19794375e-02f, 2.23294169e-01f, 1.10919876e-02f, 4.60477322e-02f, 8.60833824e-02f, -4.45767790e-02f,
  4.73806411e-02f, -1.66650951e-01f, -5.79996556e-02f, -1.16684943e-01f, -2.30029896e-02f, -9.41500887e-02f, -1.58105984e-01f, -8.34911540e-02f, -1.24582887e-01f, -2.21469086e-02f,
  1.12739235e-01f, -2.60390956e-02f, 1.85022205e-02f, 1.09432042e-01f, 2.06174757e-02f, -1.81178898e-02f, 4.71535027e-02f, -7.43672401e-02f, 1.16082756e-02f, 5.88370264e-02f,
  1.05826207e-01f, 4.94205346e-03f, -4.22231629e-02f, 4.76797344e-03f, 3.15908380e-02f, -7.83477351e-02f, 2.34040315e-03f, 5.36487699e-02f, -1.67574044e-02f, 7.27581084e-02f,
  4.32319846e-03f, 7.62034878e-02f, -7.98715651e-02f, -3.22180726e-02f, 6.25489727e-02f, -7.42006823e-02f, 5.07255225e-03f, 1.53386062e-02f, 4.40564677e-02f, -5.10027371e-02f,
  3.49825397e-02f, -1.28396815e-02f, 7.63918757e-02f, -7.02809617e-02f, 3.47073562e-02f, -7.79660011e-04f, -1.04312273e-02f, -1.13640008e-02f, -8.23632032e-02f, -1.43089853e-02f,
  -5.18539995e-02f, -6.71921968e-02f, -1.07092515e-03f, -8.74739047e-03f, 4.89297770e-02f, 3.47397141e-02f, -9.81820971e-02f, 2.59126611e-02f, 5.82803190e-02f, -4.34743501e-02f,
  -5.89223020e-02f, -2.24822573e-02f, 5.69419004e-02f, 2.80688051e-02f, 6.69417903e-02f, 5.96438982e-02f, -5.51026762e-02f, 1.03891447e-01f, -3.60972155e-03f, 5.63889556e-03f,
  1.23378515e-01f, 4.12206687e-02f, 3.21121365e-02f, 6.68937266e-02f, -1.38671175e-02f, -6.54036738e-03f, 5.53183854e-02f, -7.54966959e-03f, -6.63442090e-02f, -5.07889278e-02f,
  -1.57214366e-02f, -8.67390782e-02f, 4.45884280e-02f, -3.76412794e-02f, -2.46933172e-03f, 4.88517545e-02f, -6.46244809e-02f, -6.86731488e-02f, -7.61828274e-02f, 3.29592302e-02f,
  2.75402889e-02f, -5.71449585e-02f, 2.43925732e-02f, 5.52291125e-02f, -5.72371744e-02f, -2.29808800e-02f, -6.71909153e-02f, 5.09476773e-02f, -5.52643053e-02f, 5.77663407e-02f,
  2.50395864e-01f, -6.88700974e-02f, 3.09010036e-02f, -5.00637889e-02f, 3.35270800e-02f, 9.21592712e-02f, 1.10214606e-01f, 4.66045663e-02f, 1.05792277e-01f, -1.59789696e-01f,
  -1.63245514e-01f, 1.81975793e-02f, -5.03872819e-02f, -7.97971115e-02f, 2.08309948e-01f, 7.35411013e-04f, -1.04594596e-01f, -5.42395562e-02f, 1.74603574e-02f, -7.75429085e-02f,
  -4.39634845e-02f, -7.10772276e-02f, -5.68925440e-02f, -2.00954273e-01f, -1.70955677e-02f, -1.08577915e-01f, -2.49007225e-01f, -7.93304592e-02f, -2.35979661e-01f, -1.98815949e-02f,
  1.16956644e-01f, -4.51231822e-02f, -2.56494433e-02f, -4.95181419e-02f, 5.39074764e-02f, 3.22356634e-02f, 3.83799151e-02f, 4.66739945e-02f, 3.31621505e-02f, 5.95517457e-02f,
  -2.46859584e-02f, 3.40777077e-02f, -5.62983751e-02f, -2.46494189e-02f, -1.64000969e-02f, -5.85856996e-02f, 1.73159465e-02f, 4.50622244e-03f, 5.69274276e-02f, 8.64170864e-02f,
  5.18831536e-02f, 1.58663206e-02f, -8.36096937e-04f, 3.37297283e-02f, 1.60985887e-02f, -2.31951401e-02f, 6.73162341e-02f, -6.82582259e-02f, 7.19261691e-02f, 7.72594139e-02f,
  8.79846662e-02f, 8.70227627e-03f, -1.33004468e-02f, -4.41445038e-02f, 1.23630324e-02f, -8.92493278e-02f, -7.06014261e-02f, -1.46862110e-02f, -3.77183929e-02f, -3.68066616e-02f,
  -5.20668887e-02f, 1.02808177e-02f, -1.84554774e-02f, -3.17514390e-02f, 2.85274629e-02f, 5.94812334e-02f, 3.14597227e-02f, -5.55993430e-02f, 5.25014699e-02f, -3.27420756e-02f,
  4.79256511e-02f, -4.64622118e-02f, 3.75075080e-02f, -1.33570423e-02f, 6.59852847e-02f, 3.10711619e-02f, -1.05058596e-01f, -7.78495567e-03f, -9.64664109e-03f, 1.26890549e-02f,
  -5.99632226e-02f, -6.82678493e-03f, -9.28754583e-02f, 4.28624190e-02f, -3.40132415e-02f, 5.56908101e-02f, -5.82007505e-02f, 5.66610433e-02f, -5.61019666e-02f, 1.04729529e-03f,
  -1.16837015e-02f, 4.00135405e-02f, 1.16825048e-02f, -1.02787176e-02f, 3.62562686e-02f, 6.74001500e-02f, -1.81737244e-02f, -3.01472507e-02f, -2.07909103e-02f, -8.82375464e-02f,
  -1.25660926e-01f, 2.84053944e-02f, -1.89812351e-02f, -6.79826513e-02f, -2.14464813e-02f, 3.87784578e-02f, -5.30488566e-02f, -2.74367183e-02f, -2.59250496e-02f, 5.28822578e-02f,
  -1.76882222e-01f, 6.18710034e-02f, -7.82251880e-02f, 4.18171734e-02f, 2.43357359e-03f, 2.17862532e-01f, 1.56979546e-01f, -5.04375994e-02f, 7.61284530e-02f, 1.38811782e-01f,
  7.96615928e-02f, -9.06976685e-02f, 3.20748053e-02f, 1.94118962e-01f, 1.45454392e-01f, 2.05981359e-01f, 1.98497117e-01f, 2.58294731e-01f, -2.97778621e-02f, 6.35158271e-02f,
  5.04669501e-03f, 1.17808282e-01f, 3.90080689e-03f, -6.23175949e-02f, 2.24135444e-02f, -1.61748201e-01f, 7.90059380e-03f, -1.92077577e-01f, -2.72374693e-02f, -2.34287474e-02f,
  -4.04473431e-02f, -3.75184342e-02f, -6.46628998e-03f, -1.98214389e-02f, -7.59231299e-03f, -6.58952445e-03f, -1.56364571e-02f, 2.16181651e-02f, -7.66511932e-02f, -5.17898425e-02f,
  -7.92775899e-02f, 2.61995066e-02f, 6.95567578e-04f, -7.83505756e-03f, -1.12519793e-01f, -7.52692670e-02f, 5.09278178e-02f, 7.44530410e-02f, -1.56367421e-02f, -5.43435290e-02f,
  -3.05845053e-03f, 5.83649427e-02f, -1.88010074e-02f, 4.14651213e-03f, -2.60703787e-02f, 2.52000522e-02f, 1.50577324e-02f, -2.71916222e-02f, 5.97806983e-02f, 3.06781139e-02f,
  -2.42079124e-02f, -2.88969260e-02f, -5.57227656e-02f, -1.15156255e-03f, -5.74502675e-03f, -2.87360046e-02f, 4.17567827e-02f, -5.79309687e-02f, -6.50129914e-02f, -4.46096845e-02f,
  -2.44956091e-02f, 3.02476669e-03f, -3.71213071e-02f, 5.20915259e-03f, 4.14015129e-02f, 3.31914537e-02f, -5.27069122e-02f, -2.55532824e-02f, 5.61187193e-02f, 4.57410105e-02f,
  -3.87075618e-02f, 9.51625581e-04f, -1.29945828e-02f, 6.72548488e-02f, 4.97839041e-02f, -3.52096856e-02f, -6.17562011e-02f, -2.50111800e-02f, 2.13728547e-02f, -2.31044479e-02f,
  1.73929498e-01f, -8.25099088e-03f, 1.43345958e-02f, 1.12092188e-02f, 6.93883002e-03f, 4.05866541e-02f, 6.41460670e-03f, -4.80263196e-02f, 4.27417010e-02f, 2.06573904e-02f,
  2.02693157e-02f, 3.24130654e-02f, 7.01794103e-02f, -6.08926192e-02f, 4.96698893e-04f, 5.09646200e-02f, 7.67868161e-02f, -3.34242955e-02f, 1.03123434e-01f, -5.07025197e-02f,
  -6.38977066e-02f, 3.83552089e-02f, 1.73271317e-02f, 6.66835457e-02f, 1.98801309e-02f, 7.03156814e-02f, 2.79701483e-02f, -8.02670494e-02f, -3.67680867e-03f, 7.01417550e-02f,
  1.78094372e-01f, -7.86161944e-02f, 5.59143424e-02f, -4.50200103e-02f, -5.78514002e-02f, -1.17044441e-01f, -1.75603688e-01f, -8.30383319e-03f, -6.27439767e-02f, -2.17779234e-01f,
  -1.11492753e-01f, 1.46889925e-01f, 3.27905416e-02f, -2.86679380e-02f, 1.24756299e-01f, 8.13296959e-02f, -4.15030681e-02f, -1.08075291e-01f, 3.99099812e-02f, -9.98198986e-03f,
  1.22269541e-01f, 1.05823375e-01f, 1.76694021e-01f, -1.81785468e-02f, -2.74438839e-02f, 4.05030362e-02f, 1.32936493e-01f, 1.22359291e-01f, 5.09863868e-02f, 1.34341285e-01f,
  -3.83097189e-03f, -3.72285880e-02f, -6.68902919e-02f, 4.28964682e-02f, -8.80795904e-03f, -4.05309796e-02f, 7.25681409e-02f, 1.43917268e-02f, -3.50348055e-02f, 3.17052230e-02f,
  4.08850946e-02f, 5.55918887e-02f, -1.76815200e-03f, -3.97690199e-02f, -3.55329067e-02f, -7.20486939e-02f, 4.97592688e-02f, -8.22740495e-02f, 4.63652462e-02f, 3.79217565e-02f,
  8.26621719e-04f, -2.15459820e-02f, 2.82107498e-02f, -3.51643711e-02f, -4.68627550e-02f, -1.73356701e-02f, -4.52337041e-02f, -3.45389545e-02f, -3.48480828e-02f, -6.92547187e-02f,
  -8.18991587e-02f, 3.51349153e-02f, 4.01234673e-03f, 6.99882582e-02f, -4.70293127e-02f, -7.16802105e-02f, -3.28078307e-02f, -2.06725504e-02f, -4.08230349e-02f, -7.99496323e-02f,
  5.86385988e-02f, -5.19206189e-03f, 5.92703335e-02f, -1.33237541e-02f, 2.02704240e-02f, 3.98276560e-02f, -3.94856595e-02f, 8.14408064e-02f, -5.16581312e-02f, 3.20026577e-02f,
  -1.86209753e-02f, 5.34370765e-02f, 3.32184806e-02f, -2.24596225e-02f, -7.55216032e-02f, 5.93529232e-02f, 5.19364439e-02f, 3.33842710e-02f, -7.28909522e-02f, 9.42475498e-02f,
  9.68758985e-02f, 1.39172375e-01f, -6.61708787e-02f, 9.31617171e-02f, 1.35902967e-02f, -2.07640007e-02f, 3.60340774e-02f, 4.25352566e-02f, -6.73251506e-03f, -6.03820663e-03f,
  -2.38431431e-02f, 2.54335646e-02f, 5.69875985e-02f, -6.13010637e-02f, 4.26915176e-02f, 2.05409676e-02f, 2.64843013e-02f, -6.24624006e-02f, 3.04395873e-02f, 2.01536678e-02f,
  -2.48164427e-03f, 6.09682202e-02f, -8.25115740e-02f, 1.87909268e-02f, -5.99684902e-02f, -5.62470965e-02f, -6.12013452e-02f, -5.29748797e-02f, 1.10944537e-02f, 3.69007550e-02f,
  -1.41352400e-01f, 2.31839612e-01f, 1.59963667e-01f, 1.75723508e-01f, -2.09156349e-01f, 1.35958910e-01f, 2.41142511e-01f, -9.72043276e-02f, 8.32519531e-02f, 1.98481753e-01f,
  7.82836154e-02f, 2.38673866e-01f, 1.56065390e-01f, 2.09741041e-01f, 1.85918778e-01f, 1.76882774e-01f, 2.03743652e-01f, 2.76626140e-01f, -5.56748398e-02f, -2.43790187e-02f,
  -2.09841728e-02f, 4.24941182e-02f, 5.18141873e-02f, -1.75408423e-01f, -4.00253274e-02f, -2.04751179e-01f, -1.59782037e-01f, -9.96804833e-02f, 4.10578661e-02f, 8.74890015e-02f,
  1.18462006e-02f, -6.51044101e-02f, 2.30732132e-02f, -5.19201569e-02f, -1.00476928e-01f, -5.53872921e-02f, -5.53468876e-02f, 2.40406785e-02f, -1.23571288e-02f, 4.24466729e-02f,
  4.83106486e-02f, 9.34962835e-03f, 1.68934464e-02f, -2.02303175e-02f, 3.05200629e-02f, -7.19702467e-02f, 7.61401951e-02f, 4.73481230e-02f, 2.01336928e-02f, 8.51566270e-02f,
  6.94707632e-02f, 8.23585242e-02f, 9.02592018e-03f, 1.00404434e-01f, 3.24345008e-02f, 1.14973839e-02f, 3.19722071e-02f, -1.40449416e-03f, 3.05385515e-02f, -6.18858151e-02f,
  5.07955905e-03f, 9.35848057e-03f, 1.70304012e-02f, -1.24800475e-02f, 1.38082150e-02f, -3.99917923e-02f, 1.05089672e-01f, 1.76493768e-02f, -4.48538810e-02f, -2.69523971e-02f,
  -8.87032785e-03f, 2.20234655e-02f, -2.95448266e-02f, 2.83726025e-02f, -5.09265587e-02f, 1.78052217e-03f, 3.10893320e-02f, 1.20453900e-02f, 2.56146919e-02f, 1.41301183e-02f,
  4.60255258e-02f, 1.40019425e-03f, -1.11036710e-02f, -4.28529307e-02f, 3.49038430e-02f, 5.20600602e-02f, -4.60650213e-03f, 4.28518839e-02f, -6.03380315e-02f, -3.71149406e-02f,
  -5.98259456e-02f, -1.37423530e-01f, -1.10988074e-03f, -4.69819456e-02f, 1.10259905e-04f, 2.96855792e-02f, 1.01136053e-02f, 4.35589813e-03f, 5.83773181e-02f, -3.50850560e-02f,
  -7.00170696e-02f, -7.94963911e-02f, 1.49346022e-02f, 6.76680878e-02f, 6.70713652e-03f, 5.39195240e-02f, 1.97031372e-03f, -1.81778390e-02f, -1.63471289e-02f, -6.59421757e-02f,
  -9.48041156e-02f, -5.05371802e-02f, 1.44805452e-02f, -6.99072182e-02f, 2.31910571e-02f, 2.94502601e-02f, -4.70558107e-02f, -9.36276559e-03f, 4.52444553e-02f, 9.93994698e-02f,
  -1.58691436e-01f, 2.65696704e-01f, 1.84221908e-01f, -1.72760084e-01f, 4.89455350e-02f, 5.45797795e-02f, -1.78438455e-01f, 7.98044354e-02f, -1.20181948e-01f, 3.90930697e-02f,
  -9.24004838e-02f, 4.33880650e-02f, 7.66080990e-02f, -5.97940050e-02f, -1.89828038e-01f, -1.21353418e-01f, -6.46081939e-02f, -8.46854970e-02f, 2.55424455e-02f, 1.97787806e-01f,
  3.91778722e-03f, -1.24027044e-01f, 4.40602750e-02f, 1.64694831e-01f, 6.84039518e-02f, 1.28440827e-01f, 1.07841752e-02f, 1.38405308e-01f, 8.76214355e-02f, -8.95030499e-02f,
  -6.53870925e-02f, 9.65112541e-03f, -3.09951007e-02f, 3.52241397e-02f, 9.71094221e-02f, -1.66704238e-03f, -5.13271280e-02f, -1.04899317e-01f, -3.51612456e-02f, 4.00829129e-02f,
  -6.01561693e-03f, 3.81597057e-02f, 3.79478075e-02f, 7.00693764e-03f, -4.79102284e-02f, -1.02112833e-02f, -5.31256228e-05f, 7.21301213e-02f, -1.35436915e-02f, 4.35460396e-02f,
  4.62713689e-02f, -2.94993427e-02f, -3.48018669e-02f, -2.72292569e-02f, -7.14493543e-03f, -8.19593295e-03f, -5.53905144e-02f, 5.49106300e-02f, -1.78091903e-03f, 9.16466340e-02f,
  2.68021170e-02f, 3.86790596e-02f, 4.61277179e-02f, -3.23115885e-02f, 4.90185656e-02f, -3.66915129e-02f, 6.29086867e-02f, 2.29163580e-02f, -5.69966249e-03f, -7.29676988e-03f,
  -2.01096311e-02f, 2.69519947e-02f, -5.02765067e-02f, 5.89297265e-02f, -4.89848852e-02f, -7.88351893e-02f, -4.74116951e-02f, -1.39618954e-02f, 2.51785461e-02f, 3.23604420e-02f,
  -1.05061065e-02f, -6.82363007e-03f, 4.27917317e-02f, 2.53502820e-02f, -8.74640420e-03f, 5.01872636e-02f, -2.86272410e-02f, 2.80827675e-02f, 2.88072391e-03f, 4.86462228e-02f,
  1.56334206e-01f, 2.09113613e-01f, 2.53448579e-02f, -7.00048357e-02f, 5.10514043e-02f, 3.73681709e-02f, -5.71938790e-03f, 3.69604528e-02f, 1.34033188e-01f, -1.04317171e-02f,
  4.80313972e-02f, 7.70413782e-03f, 2.88044047e-02f, -7.41539150e-02f, 7.51497224e-02f, 1.30507082e-01f, 1.96466427e-02f, -4.65224572e-02f, 1.88851990e-02f, 3.10445633e-02f,
  3.96709740e-02f, 2.36038081e-02f, 2.29726043e-02f, -1.41218556e-02f, -1.19666930e-03f, 2.66209524e-02f, 4.74020801e-02f, 3.54519784e-02f, 7.35224560e-02f, -2.24146955e-02f,
  -2.84014761e-01f, 3.92247513e-02f, 1.68551236e-01f, -5.98542914e-02f, -2.33332485e-01f, 2.44239327e-02f, -1.44737750e-01f, -1.47782862e-01f, -3.06057662e-01f, -5.00754192e-02f,
  -1.56946823e-01f, 1.37707233e-01f, 2.73666214e-02f, -1.51365232e-02f, 1.35069713e-01f, 9.09225792e-02f, -5.29129468e-02f, 8.78270045e-02f, -5.11314720e-02f, -5.08337393e-02f,
  7.90016493e-05f, -2.02813134e-01f, 2.53183693e-01f, 3.37013020e-03f, -1.22529611e-01f, 1.22645914e-04f, 1.39964879e-01f, 8.54438096e-02f, 1.80773064e-01f, 1.56518519e-02f,
  2.00106073e-02f, -9.46081206e-02f, 2.54895003e-03f, 1.03013404e-01f, -5.24014421e-02f, -1.44774150e-02f, 4.50442769e-02f, 1.58523768e-02f, -2.33948976e-02f, 4.46463563e-02f,
  -3.93475443e-02f, 6.50230702e-03f, -5.47398627e-02f, -1.83180384e-02f, -7.44298398e-02f, -3.23520377e-02f, 6.08778633e-02f, -1.04362806e-02f, 4.18302901e-02f, 1.68462321e-02f,
  1.01190001e-01f, 1.02242403e-01f, -5.90677075e-02f, 4.42741327e-02f, 6.50685430e-02f, -2.93027088e-02f, 2.78341565e-02f, 4.60191593e-02f, -1.31632136e-02f, -2.67196689e-02f,
  -1.27741396e-02f, -2.49436945e-02f, -8.84774178e-02f, -4.26371545e-02f, -8.49291973e-04f, -2.74640303e-02f, -6.17191754e-03f, -1.42333284e-02f, -1.11339502e-02f, 5.57500031e-03f,
  1.73068303e-03f, -5.04916944e-02f, -2.92017348e-02f, -3.39174420e-02f, -2.56149601e-02f, -1.24443509e-02f, 3.24172936e-02f, 3.57397087e-02f, -2.24299915e-02f, -3.84202488e-02f,
  2.29001753e-02f, -5.31725883e-02f, 7.86110312e-02f, 1.97900310e-02f, 5.45032620e-02f, -3.18587422e-02f, -3.36587057e-02f, -2.87989806e-02f, -9.22783930e-03f, 4.43421565e-02f,
  3.63397561e-02f, -1.27270475e-01f, 5.42436689e-02f, -8.65075924e-03f, 9.25715715e-02f, -2.17229910e-02f, 8.99799354e-03f, -2.16666912e-03f, 3.81388739e-02f, -3.39844972e-02f,
  7.85561204e-02f, 1.72148217e-02f, -1.25408070e-02f, 5.50334677e-02f, 2.69246195e-02f, 2.81369239e-02f, -4.66892980e-02f, -1.02252541e-02f, 2.33700834e-02f, 6.45749718e-02f,
  -4.43795957e-02f, -5.68094738e-02f, 4.44690473e-02f, -5.00320457e-02f, -9.41799395e-03f, 5.13258465e-02f, 3.31962667e-02f, 7.73359882e-03f, 3.20861451e-02f, 6.65485347e-03f,
  -9.46474355e-03f, -1.14316225e-01f, 1.84605026e-03f, 7.93926492e-02f, 8.60359445e-02f, -1.74984355e-02f, -3.73592861e-02f, 1.11463137e-01f, -2.56241336e-02f, -7.65854400e-03f,
  -2.92295236e-02f, -9.07980576e-02f, -3.15939754e-01f, 1.63859978e-01f, -1.43346041e-01f, -2.61162728e-01f, 5.13192005e-02f, 2.87067872e-02f, -3.41319963e-02f, 7.20588192e-02f,
  1.30929053e-01f, -3.70981693e-02f, 2.47443244e-02f, 1.57058090e-01f, 1.27738208e-01f, 6.49064183e-02f, 1.94719397e-02f, -5.48909418e-02f, 2.34856918e-01f, -3.27212028e-02f,
  1.01544142e-01f, 3.52329277e-02f, -2.02133525e-02f, -8.18032399e-02f, 4.61870357e-02f, 1.52600586e-01f, 7.82038048e-02f, -7.56694609e-03f, 7.30715543e-02f, 2.55386773e-02f,
  1.38262762e-02f, -1.34899132e-02f, 8.19872990e-02f, -1.30483165e-01f, 7.71019310e-02f, 6.11856170e-02f, 8.27059448e-02f, 8.55322853e-02f, 3.31505612e-02f, -3.54082435e-02f,
  -2.39614099e-02f, 4.79957536e-02f, 6.88484386e-02f, -2.85774972e-02f, -1.96174979e-02f, 1.76902930e-03f, 4.58847769e-02f, -9.66217369e-02f, 9.08412635e-02f, 4.40120872e-04f,
  1.35991406e-02f, -4.40414716e-03f, -2.65985932e-02f, 9.24449936e-02f, -6.31957315e-03f, -5.45912376e-03f, -1.42229376e-02f, 2.87938840e-03f, -5.55644259e-02f, -4.64429818e-02f,
  1.76119637e-02f, -2.14049369e-02f, -2.70305332e-02f, 1.94542203e-02f, -4.64563034e-02f, 2.82182135e-02f, 5.21344915e-02f, -9.07966588e-03f, 1.06862076e-02f, 5.75967729e-02f,
  -5.93858659e-02f, 3.80252078e-02f, -6.00065626e-02f, 3.32485838e-03f, -3.27900751e-03f, -7.51735270e-02f, 1.71200037e-02f, -1.66274775e-02f, 4.60662842e-02f, -1.91360004e-02f,
  3.57796662e-02f, -1.78099051e-01f, -4.52245697e-02f, 4.03149053e-02f, -7.05749169e-02f, 1.91044416e-02f, 1.97989494e-02f, 3.31600793e-02f, -7.14926049e-02f, -8.08499381e-02f,
  7.31180310e-02f, -2.71584354e-02f, 3.41739170e-02f, 2.73534097e-02f, 4.79682870e-02f, -1.09726461e-02f, -3.48315835e-02f, -2.96159321e-03f, 1.93418581e-02f, 9.34077799e-02f,
  1.60718970e-02f, 1.71168223e-02f, -9.88245383e-03f, 4.13688198e-02f, 2.42525190e-02f, 1.16086612e-02f, 1.71101950e-02f, 7.08819553e-02f, -2.33781114e-02f, 3.00650708e-02f,
  4.75691669e-02f, -7.48713687e-02f, -1.69717416e-01f, -1.17736369e-01f, 1.79495767e-01f, 2.41243526e-01f, -1.04588173e-01f, 1.18438870e-01f, 5.70773706e-03f, -1.39610410e-01f,
  5.82222156e-02f, -1.05769902e-01f, -1.85759291e-01f, 3.15027870e-02f, 2.35360175e-01f, 6.91758469e-02f, 6.08947501e-02f, -1.00117631e-01f, 8.39160457e-02f, -8.99229497e-02f,
  -4.78123724e-02f, 7.88962245e-02f, 8.08644220e-02f, 1.36667341e-01f, 4.58848365e-02f, -1.35663971e-01f, -1.02233909e-01f, 2.64390521e-02f, 4.16152179e-02f, 1.28304511e-01f,
  8.58954564e-02f, -1.41638713e-02f, 6.19785115e-03f, 3.49791571e-02f, -4.40485962e-02f, 5.22004552e-02f, 2.49090176e-02f, 9.77289304e-02f, -3.54168415e-02f, -2.95830648e-02f,
  6.76106894e-03f, 3.67297344e-02f, 4.43771258e-02f, -3.39551382e-02f, 7.13763535e-02f, 3.52958217e-02f, -4.09248844e-02f, -6.79122061e-02f, 2.84359418e-02f, 7.53622651e-02f,
  -7.47201666e-02f, 2.43070759e-02f, -1.19336553e-01f, -6.92677051e-02f, -6.12058416e-02f, 6.70844689e-02f, 2.93927863e-02f, -9.72633958e-02f, 6.41490892e-02f, 6.87898770e-02f,
  7.01909363e-02f, 5.63093014e-02f, -7.81400595e-03f, 3.66323143e-02f, 7.36949593e-02f, -8.65660515e-03f, 2.87184655e-03f, -5.90505712e-02f, 6.71852231e-02f, 2.60098819e-02f,
  3.52371037e-02f, -3.50458100e-02f, -5.39266020e-02f, -4.60591540e-02f, -4.02615108e-02f, 1.56105058e-02f, -3.61672975e-02f, -2.90583018e-02f, -8.53588805e-02f, 6.94378614e-02f,
  -2.44212244e-02f, 1.63944457e-02f, -9.69099104e-02f, -1.07960589e-01f, 3.62344384e-02f, 3.42850271e-03f, -8.04013386e-02f, -6.04034066e-02f, 1.18513610e-02f, -8.55132341e-02f,
  -6.94595054e-02f, -1.02547340e-01f, 2.40721460e-02f, 3.18422616e-02f, -1.96170565e-02f, 5.46804490e-03f, -6.61857240e-03f, -8.24815128e-03f, 3.49738039e-02f, -2.71279048e-02f,
  -2.62864195e-02f, -6.93319142e-02f, 2.65324712e-02f, -3.73888128e-02f, 3.08278482e-02f, -4.60624956e-02f, 1.20299198e-02f, -4.29408513e-02f, 1.57890783e-03f, 5.80652151e-04f,
  -4.10044231e-02f, 2.38194177e-03f, -4.40566465e-02f, 1.98035389e-02f, -6.69106096e-02f, -3.56784798e-02f, 9.88543779e-03f, -3.19292694e-02f, -1.04057379e-01f, -9.29283202e-02f,
  -1.87559143e-01f, 2.53034383e-01f, 3.68752629e-02f, -2.78248727e-01f, 6.24648817e-02f, -1.81182213e-02f, -5.31088002e-02f, 2.91648116e-02f, -3.41358095e-01f, 2.88361341e-01f,
  1.31459445e-01f, -3.90818454e-02f, 1.16153069e-01f, 8.71398225e-02f, -3.94910693e-01f, -1.00073561e-01f, 8.37200973e-03f, -5.40896244e-02f, -1.13890737e-01f, 1.58342924e-02f,
  -1.55185118e-01f, 3.10770366e-02f, -1.30464127e-02f, 1.41537994e-01f, 1.34561405e-01f, 3.42019573e-02f, 8.86916965e-02f, 1.43600032e-01f, 6.58263862e-02f, -1.29029620e-02f,
  2.11094469e-02f, -1.43567035e-02f, 9.31591317e-02f, -3.87382768e-02f, -2.12877598e-02f, 7.05536678e-02f, 3.33600417e-02f, 3.70638371e-02f, -6.05557337e-02f, 2.78441366e-02f,
  -7.06042722e-02f, -2.37856098e-02f, -7.41271907e-03f, -7.82942399e-02f, 8.94216169e-03f, -5.89572545e-03f, 3.60485651e-02f, 4.22617346e-02f, 3.96174975e-02f, 1.05278112e-01f,
  7.93729126e-02f, 9.74988863e-02f, 3.38339545e-02f, -1.81484986e-02f, -7.66812041e-02f, -1.30048087e-02f, -4.06687036e-02f, 9.73400846e-03f, 2.62070093e-02f, -2.28949673e-02f,
  -2.03070864e-02f, -5.41091599e-02f, 1.65031455e-03f, -1.82384178e-02f, -5.75265959e-02f, 5.84634058e-02f, 3.68431099e-02f, 1.97881479e-02f, -1.48260957e-02f, 5.83213344e-02f,
  -3.92365679e-02f, -3.46617922e-02f, -2.43392065e-02f, 4.72524092e-02f, -1.69947520e-02f, 6.87796529e-03f, -3.51476185e-02f, -2.28570066e-02f, 1.48532661e-02f, -5.53422235e-03f,
  -9.27253999e-03f, 1.89784747e-02f, 5.90837141e-03f, 9.86664891e-02f, 1.81991141e-02f, -6.51540607e-02f, -2.00813208e-02f, 5.68637811e-02f, 1.05077187e-02f, -2.71009542e-02f,
  7.94436410e-02f, -5.08455336e-02f, -5.53857088e-02f, -5.95150329e-02f, 2.82841772e-02f, 1.00314304e-01f, -2.55771484e-02f, -9.30100773e-03f, 3.13882008e-02f, -5.36317751e-03f,
  1.10928211e-02f, -2.15962697e-02f, -1.01476032e-02f, -1.50477858e-02f, -1.06630579e-01f, 7.42674097e-02f, -8.87428448e-02f, 2.79050041e-02f, 1.05033834e-02f, 6.90061226e-02f,
  -4.83515933e-02f, -1.24579817e-02f, -2.98498962e-02f, 1.02172513e-02f, -2.98864469e-02f, -1.70053262e-02f, -4.10832763e-02f, 2.25786269e-02f, 7.81723931e-02f, -1.55588398e-02f,
  -6.54642284e-03f, 2.15642720e-01f, 2.27411106e-01f, 2.77485132e-01f, -1.33446977e-01f, -2.88028181e-01f, -1.29199222e-01f, 5.40450513e-02f, -1.53291933e-02f, 8.83111209e-02f,
  -7.49643100e-03f, -9.08266474e-03f, 7.01864483e-03f, 2.88321506e-02f, -2.82924682e-01f, -8.73999298e-02f, 4.38791104e-02f, -8.56267288e-02f, -3.70824039e-02f, 1.00466110e-01f,
  -7.16235116e-03f, -1.00895189e-01f, 6.70156553e-02f, 6.95809796e-02f, 1.22402757e-01f, 2.17271566e-01f, 5.75823374e-02f, 6.78262413e-02f, 7.54610449e-02f, -6.73792139e-02f,
  -3.36582103e-04f, 1.28034458e-01f, 2.86172982e-02f, 5.17856702e-02f, 8.63463059e-02f, -5.83395921e-02f, 5.27030462e-03f, -4.55026627e-02f, 1.99022982e-02f, 5.00532426e-02f,
  -4.47210623e-03f, 9.68367141e-03f, -3.27450372e-02f, -5.04087005e-03f, 1.48833552e-02f, 3.39810387e-03f, 7.08621740e-02f, 6.84710145e-02f, 7.56243020e-02f, -4.65935655e-02f,
  2.12983657e-02f, 4.36325930e-02f, -2.17122715e-02f, 4.71118279e-02f, 5.05411590e-04f, 5.30056991e-02f, -2.14313958e-02f, 3.45106870e-02f, -1.79280154e-02f, 1.36564309e-02f,
  2.44362541e-02f, 9.77089279e-04f, -1.14341743e-01f, 2.27703806e-02f, -3.77726071e-02f, -2.68153157e-02f, 1.51591981e-02f, -3.98508571e-02f, 1.28130298e-02f, -5.13791293e-02f,
  4.26581539e-02f, 6.17931969e-03f, 1.49363594e-03f, -3.37909870e-02f, 1.08232629e-02f, 2.29533166e-02f, 1.32797835e-02f, 1.17189856e-02f, 7.65172988e-02f, 2.69305017e-02f,
  5.77731943e-03f, -8.33413377e-02f, -3.41649838e-02f, 5.46703255e-03f, -1.93714406e-02f, 3.30032827e-03f, -2.94690225e-02f, -5.56241255e-03f, -3.06402352e-02f, 2.46018078e-02f,
  -3.22519094e-02f, -2.30165459e-02f, -1.05081694e-02f, -8.12331587e-02f, 2.63322070e-02f, 1.97256170e-02f, 7.64267705e-03f, -2.58071404e-02f, -1.67634233e-03f, -1.06190756e-01f,
  4.99387272e-02f, 7.41728470e-02f, -4.82953563e-02f, -1.51484581e-02f, 7.38762319e-02f, -8.59157518e-02f, 3.39957178e-02f, 8.01573228e-03f, 5.84297106e-02f, 3.69006507e-02f,
  9.94504765e-02f, 3.52634899e-02f, -8.27130396e-03f, -2.71806605e-02f, 1.50962174e-02f, 2.15210523e-02f, 3.88404727e-03f, 2.29926836e-02f, -3.41443196e-02f, 6.01564907e-02f,
  1.75978690e-01f, 1.03915378e-01f, 2.97028750e-01f, 3.40491861e-01f, -5.67331128e-02f, -2.08865162e-02f, 4.66987416e-02f, 9.98175666e-02f, -8.91518667e-02f, -1.70608535e-01f,
  3.78120989e-02f, 1.04504608e-01f, -2.30248839e-01f, 9.64442641e-02f, 2.17102796e-01f, -1.66007608e-01f, 8.78014714e-02f, -2.96920668e-02f, 4.77192178e-02f, 1.46538794e-01f,
  4.94181290e-02f, 3.69525217e-02f, 1.50845975e-01f, 4.03011031e-02f, 2.05329955e-01f, 1.26815245e-01f, 7.82466009e-02f, 3.88437696e-02f, 1.87506169e-01f, 3.14977095e-02f,
  -7.32509345e-02f, -6.13390505e-02f, 1.06864780e-01f, -1.05667487e-01f, 2.45926622e-02f, -1.23346997e-02f, 5.61006814e-02f, 3.23969200e-02f, 4.86808410e-03f, 4.98102233e-02f,
  -1.14028715e-02f, 6.95546791e-02f, 2.86963079e-02f, -6.38767853e-02f, 1.46097038e-02f, 1.74409579e-02f, -3.17973122e-02f, -3.13784592e-02f, -3.99648696e-02f, 7.18488991e-02f,
  4.23235558e-02f, 4.33853604e-02f, 9.07303244e-02f, 2.33313814e-02f, 6.43592924e-02f, 4.60831970e-02f, 3.65812108e-02f, -3.52697563e-03f, 7.92324767e-02f, 5.29214703e-02f,
  -1.19766437e-01f, -4.63452525e-02f, 2.98384521e-02f, -8.47876817e-03f, 7.26592587e-03f, -2.41829902e-02f, 3.10388915e-02f, -5.67987598e-02f, 4.13948148e-02f, 3.41888075e-03f,
  -9.46687441e-03f, 7.67306313e-02f, -2.90410575e-02f, -3.87929976e-02f, -2.92593297e-02f, -2.96234395e-02f, 1.54449213e-02f, -5.90621941e-02f, -3.93493362e-02f, 4.84349579e-02f,
  -6.60762340e-02f, 2.25385949e-02f, -5.48714167e-03f, 5.25885681e-03f, -5.14637046e-02f, -2.96580791e-02f, -1.51355807e-02f, 4.26967926e-02f, -1.08035589e-02f, -2.57700053e-03f,
  2.52259988e-02f, 1.25242531e-01f, -3.79540236e-03f, -2.30539404e-02f, -6.37908727e-02f, 5.32295369e-02f, -4.49265726e-02f, 5.14532812e-02f, 5.28512895e-03f, 2.04609092e-02f,
  -2.92559117e-02f, -5.23472764e-02f, -4.88931611e-02f, -6.96017873e-03f, 8.82250909e-03f, 4.64695739e-03f, 2.72619650e-02f, 8.83677229e-02f, 2.39224564e-02f, -6.64389180e-03f,
  4.00007591e-02f, 5.88854018e-05f, -6.41443059e-02f, -5.95974028e-02f, -8.97917198e-04f, -2.61623003e-02f, 7.57215172e-03f, -9.02994163e-03f, 2.84259301e-02f, 3.14017534e-02f,
  3.14951062e-01f, -2.64416009e-01f, 1.38601884e-01f, 2.51961380e-01f, -2.54227524e-03f, 2.32796296e-01f, 1.85661018e-01f, 4.61785346e-02f, 2.33480543e-01f, -2.98346996e-01f,
  -1.82701237e-02f, -5.99073507e-02f, -4.26262952e-02f, 2.41276938e-02f, 2.95283496e-01f, 8.17794055e-02f, 4.71602045e-02f, 5.65832704e-02f, 1.22180216e-01f, -2.45997440e-02f,
  1.41394719e-01f, -4.09037136e-02f, 9.40168053e-02f, -1.87812150e-01f, 2.83787027e-02f, 2.10599769e-02f, -1.59501702e-01f, -3.73802856e-02f, -1.26127690e-01f, -5.68141527e-02f,
  7.62878135e-02f, 7.05687329e-02f, 4.39858846e-02f, -2.43877526e-02f, 3.51649597e-02f, -1.65357403e-02f, -2.35853530e-02f, -5.83081320e-03f, 5.56061417e-02f, 2.53291111e-02f,
  -5.42404316e-02f, -1.27598376e-03f, 5.06254807e-02f, -8.70190095e-04f, 1.11979293e-02f, 3.09925228e-02f, -6.44062608e-02f, 8.05592835e-02f, 3.32827121e-02f, 5.01568057e-03f,
  3.73525210e-02f, -6.62417850e-03f, 1.32558774e-02f, -4.31175157e-02f, 5.56675270e-02f, -9.35365912e-04f, -1.08824647e-03f, -5.03100716e-02f, -3.39644477e-02f, -1.72882341e-02f,
  -4.13092375e-02f, 1.58861578e-02f, 3.29674082e-03f, -1.79269277e-02f, 6.25084788e-02f, -2.94484347e-02f, -1.34458039e-02f, -2.99606323e-02f, 1.89321488e-02f, -2.64664665e-02f,
  6.49915636e-02f, 1.51652116e-02f, 1.70153752e-02f, 5.21121509e-02f, 1.63718760e-02f, 3.37125137e-02f, -3.71234166e-03f, -5.33789545e-02f, 5.64255230e-02f, 6.42016670e-03f,
  -7.46587887e-02f, 4.01576832e-02f, -4.74314293e-04f, 2.03137044e-02f, -2.51179188e-02f, -1.87769383e-02f, 6.51322585e-03f, 6.92835916e-03f, 5.28120138e-02f, 6.86518177e-02f,
  -7.60973394e-02f, -1.98008522e-01f, -2.41643074e-03f, -4.48325984e-02f, -4.70796190e-02f, -4.99963723e-02f, -1.17323697e-02f, -3.81696559e-02f, 3.08830719e-02f, -1.13042127e-02f,
  1.53014867e-03f, 5.44044524e-02f, -6.61777332e-02f, -1.55993206e-02f, 3.12389359e-02f, -4.97201607e-02f, 6.34810003e-03f, -2.55740732e-02f, -3.56453620e-02f, -5.40440604e-02f,
  -6.35257289e-02f, -1.37516027e-02f, 4.32292297e-02f, 5.94596937e-02f, -2.72687874e-03f, -1.95231829e-02f, -1.30153093e-02f, 2.21114624e-02f, -4.71488684e-02f, 5.07667894e-03f,
  -1.87190667e-01f, 2.29010746e-01f, -1.23113252e-01f, 1.33835733e-01f, -1.05420522e-01f, 5.10967001e-02f, -9.24839452e-03f, 5.40155657e-02f, -3.20818126e-02f, 2.35745907e-01f,
  8.96975473e-02f, -4.83008698e-02f, 1.36851694e-03f, 1.25305727e-01f, -1.56628996e-01f, 8.81970152e-02f, 2.01426595e-01f, 1.43749103e-01f, -6.35642484e-02f, 8.68493393e-02f,
  -8.93189572e-03f, 1.00009382e-01f, 9.70248580e-02f, 8.65746439e-02f, 5.59991114e-02f, 1.19864978e-01f, 1.28349632e-01f, -1.55939072e-01f, 1.07143551e-01f, -1.07155249e-01f,
  4.09014821e-02f, 2.72909738e-02f, 1.21072284e-03f, -1.73664168e-02f, 5.64432554e-02f, 1.70797836e-02f, -2.76859012e-02f, -9.84322876e-02f, -3.28910612e-02f, 2.28998270e-02f,
  2.08938047e-02f, -5.93471527e-02f, 2.26270892e-02f, -8.20840374e-02f, -9.75701399e-03f, -3.28923799e-02f, 4.54689190e-03f, 2.09564865e-02f, -7.07336469e-03f, -8.43157545e-02f,
  1.50457509e-02f, 6.57187849e-02f, 5.26403375e-02f, 2.48169806e-02f, -4.10155803e-02f, -6.75134808e-02f, 6.34677112e-02f, -1.42305205e-03f, -1.41951870e-02f, 6.10935083e-03f,
  5.73331118e-02f, 1.23140065e-03f, 2.10367981e-03f, -2.88146157e-02f, -4.34455462e-02f, -7.01755434e-02f, -5.73737770e-02f, 2.44127158e-02f, 1.36472033e-02f, 2.10191365e-02f,
  6.39543161e-02f, 4.76808436e-02f, -4.67892513e-02f, 4.48226742e-03f, 9.56031084e-02f, 1.92148387e-02f, 4.31961659e-03f, -3.78118642e-02f, 4.96676518e-03f, -3.68060470e-02f,
  -6.99542928e-03f, 2.30363179e-02f, -3.25235724e-02f, 5.82317673e-02f, -1.91817712e-02f, -4.93847281e-02f, -1.17452163e-02f, 9.75789968e-03f, 1.16258748e-02f, 2.00236961e-02f,
  9.78727862e-02f, 1.22874148e-01f, -4.68223207e-02f, -1.22364210e-02f, 2.71685086e-02f, 5.70537560e-02f, 8.37909058e-02f, 3.66097403e-04f, 5.94899729e-02f, 5.60644679e-02f,
  8.64448100e-02f, -9.77402760e-06f, 4.77226600e-02f, -4.15443778e-02f, 4.18475904e-02f, 5.83923087e-02f, 2.93197320e-03f, -4.69738618e-03f, 3.72025557e-02f, 1.01718873e-01f,
  1.13981282e-02f, 2.48323306e-02f, 3.84163274e-03f, -1.38063002e-02f, 6.33590221e-02f, 9.29127783e-02f, 3.66491266e-02f, 3.22001167e-02f, -3.04058520e-03f, 1.29240258e-02f,
  -3.05342823e-01f, 9.26541239e-02f, 2.09153406e-02f, 1.70543157e-02f, -2.19930917e-01f, -1.54224232e-01f, -1.45002142e-01f, -1.28384614e-02f, 1.23531207e-01f, 7.52684474e-02f,
  -6.57425672e-02f, -5.96419871e-02f, 1.88238904e-01f, -5.75804561e-02f, -6.27051741e-02f, 2.53132254e-01f, -7.50257745e-02f, -1.24924771e-01f, 1.12951353e-01f, -1.12861022e-01f,
  1.00192223e-02f, -7.64848068e-02f, 1.30650520e-01f, -1.43214483e-02f, -1.77082509e-01f, -4.74993624e-02f, 7.38431420e-03f, -2.29066610e-03f, -6.76564798e-02f, 2.22934019e-02f,
  -9.53088254e-02f, -4.34666686e-03f, -2.42044628e-02f, -7.17561468e-02f, -9.21689868e-02f, -5.42888455e-02f, 5.31830650e-04f, 1.79903861e-02f, -1.69058852e-02f, -7.85013009e-03f,
  -2.53558010e-02f, -5.25460690e-02f, -2.22268291e-02f, 6.79915026e-03f, -8.91381279e-02f, -4.50186022e-02f, -1.51935061e-02f, -3.44119817e-02f, -1.75836124e-03f, 5.60553325e-03f,
  -4.68705930e-02f, -7.17299134e-02f, 4.06192951e-02f, -7.58365868e-03f, -5.12030348e-02f, 5.33315688e-02f, 4.63787802e-02f, -5.02932407e-02f, -6.35302663e-02f, -3.28545608e-02f,
  -6.93693478e-03f, -3.43714096e-02f, 1.93494819e-02f, -1.60400697e-03f, 7.08677759e-03f, -5.27586527e-02f, 4.39337045e-02f, -6.77949861e-02f, -2.35569905e-02f, -3.67249660e-02f,
  1.38037736e-02f, 2.52790768e-02f, -4.25721779e-02f, -3.40688452e-02f, 3.83902378e-02f, 7.08103403e-02f, 1.06744259e-03f, -4.44189869e-02f, -4.40171771e-02f, 6.00587018e-02f,
  8.38347450e-02f, 3.54157165e-02f, 1.17250653e-02f, -6.18605781e-03f, -4.50552143e-02f, 5.75178862e-02f, -6.37526205e-03f, -2.46323701e-02f, -3.37890051e-02f, -1.77757423e-02f,
  -6.31037802e-02f, 1.20883420e-01f, 3.71457823e-02f, 7.93991424e-03f, 4.57044691e-02f, -5.03138714e-02f, 2.70286985e-02f, 2.12230440e-02f, 3.28285210e-02f, -4.96312790e-02f,
  -7.96790570e-02f, -1.12510677e-02f, 1.35548376e-02f, 4.68288809e-02f, 8.71440768e-02f, -3.19236666e-02f, 2.28405148e-02f, 9.42827389e-03f, 1.88813470e-02f, -5.34824515e-03f,
  -3.51855420e-02f, 9.97024588e-03f, 2.46189274e-02f, -2.35254690e-02f, -4.35155705e-02f, -8.56253207e-02f, -3.15286256e-02f, -4.44771126e-02f, 4.45866250e-02f, 7.80745000e-02f,
  1.52707547e-01f, -9.34120044e-02f, 1.79847151e-01f, 6.46129176e-02f, -8.94215479e-02f, -3.34762126e-01f, -3.71572748e-02f, -1.22735389e-01f, 1.60969436e-01f, -1.60969853e-01f,
  -2.10047066e-01f, 2.88222730e-01f, 1.16051808e-02f, -2.26640329e-01f, -9.94587690e-02f, -1.06398031e-01f, -2.79667348e-01f, -9.10482779e-02f, 8.53659734e-02f, -4.94954884e-02f,
  -3.15511562e-02f, -3.56967568e-01f, -2.51091551e-02f, -1.91839933e-01f, -1.67039577e-02f, 6.37529194e-02f, -1.38552979e-01f, 1.36998504e-01f, -1.21030465e-01f, -9.98937488e-02f,
  -1.41620293e-01f, 3.76505330e-02f, 1.70172349e-01f, 4.61006723e-02f, -5.86418808e-02f, -3.67427096e-02f, 1.03775074e-03f, 8.26568231e-02f, 3.69763863e-03f, 1.96623746e-02f,
  4.32659462e-02f, 7.21025513e-03f, -5.55977486e-02f, -3.88996340e-02f, 7.95780420e-02f, 5.84227555e-02f, 4.70701559e-03f, -4.57927659e-02f, 1.67182460e-02f, -5.29107498e-03f,
  -1.14853738e-03f, 5.47809014e-03f, 5.07106185e-02f, -2.36458313e-02f, 4.93606962e-02f, -8.19283910e-03f, -6.45977855e-02f, 1.83812696e-02f, -8.22648928e-02f, -4.99178618e-02f,
  -9.50851664e-03f, 3.96773266e-03f, -1.59881748e-02f, 3.28302197e-02f, -3.11380625e-02f, 3.52653973e-02f, -4.56747152e-02f, -2.36770287e-02f, 7.77298287e-02f, -1.83239672e-02f,
  3.56229730e-02f, 2.06990745e-02f, -1.65705830e-02f, -1.20904883e-02f, -5.84782138e-02f, -1.70042331e-03f, 4.57199328e-02f, 1.94723085e-02f, 1.91785209e-02f, 2.07864251e-02f,
  -2.62296945e-02f, -5.03551699e-02f, 2.50275359e-02f, -3.11450846e-02f, -6.95594819e-03f, 3.82822752e-02f, -6.08955335e-04f, 3.38068865e-02f, 3.32081020e-02f, -5.02626300e-02f,
  -7.31980875e-02f, 3.14652435e-02f, -4.17371318e-02f, 1.45837653e-03f, 8.98891967e-03f, -6.84980676e-02f, 1.84092801e-02f, -6.72114566e-02f, 4.61344309e-02f, 3.24145854e-02f,
  1.19993906e-03f, 1.95519943e-02f, -9.24601126e-03f, 1.46082928e-02f, -7.66567662e-02f, -5.99714667e-02f, 4.91947643e-02f, 4.39937823e-02f, 1.99129917e-02f, -3.58707272e-02f,
  -8.74712830e-04f, 2.83315517e-02f, -2.39981096e-02f, -3.16432118e-02f, -6.72335848e-02f, -2.60068923e-02f, 5.05699813e-02f, 3.31917629e-02f, 2.60221716e-02f, 7.32829124e-02f,
  -2.95739204e-01f, -1.18009783e-01f, 1.52703598e-02f, -8.95234570e-02f, -1.45888835e-01f, -2.20511705e-01f, 5.00578247e-02f, -1.73286229e-01f, 4.90751453e-02f, 1.00256063e-01f,
  4.13677730e-02f, -5.99592812e-02f, 3.21898460e-01f, -1.73133433e-01f, -3.98234576e-02f, 2.60043979e-01f, -1.95930004e-01f, -7.29283504e-03f, -5.78681985e-03f, -1.97576746e-01f,
  -4.91237044e-02f, -6.69934601e-02f, 3.91593985e-02f, -4.04061899e-02f, -1.83060229e-01f, -5.67422397e-02f, 8.38510767e-02f, 7.95139596e-02f, -2.62035519e-01f, -5.74867167e-02f,
  -1.50812015e-01f, 1.69857200e-02f, 1.32129397e-02f, 6.75601587e-02f, -6.59009069e-02f, -5.30199744e-02f, 1.14485025e-02f, 3.56044844e-02f, -2.72601936e-02f, -3.57523700e-03f,
  -3.25093642e-02f, -9.13256556e-02f, -3.65534499e-02f, 1.52299972e-02f, 1.38741098e-02f, -4.61060368e-02f, -1.21221263e-02f, -1.93247516e-02f, -4.88686860e-02f, -9.69093889e-02f,
  6.26877472e-02f, -3.92446332e-02f, 2.83130370e-02f, -4.60230038e-02f, 5.54761179e-02f, -2.73467582e-02f, 1.42042739e-02f, 3.26277092e-02f, -7.54524395e-02f, -6.87777996e-02f,
  -4.76794019e-02f, 4.67454530e-02f, 3.05996258e-02f, 1.08711459e-02f, -2.22713631e-02f, 4.06755581e-02f, 2.18659118e-02f, 3.46208774e-02f, 5.00607155e-02f, -4.16755630e-03f,
  -6.39536232e-02f, 4.44530956e-02f, 1.00709004e-02f, 3.83498110e-02f, 2.28496399e-02f, 3.01377047e-02f, 5.10922298e-02f, -6.59172013e-02f, 1.71627849e-02f, -2.08643004e-02f,
  1.56710409e-02f, 9.77351516e-03f, -5.71009144e-02f, 7.13500381e-02f, -1.23156793e-03f, -8.37696902e-03f, 9.56915959e-04f, -9.67238564e-03f, 4.98390459e-02f, 3.45007889e-02f,
  -2.19349682e-01f, -1.14106402e-01f, -4.22411412e-02f, 4.75274026e-03f, -5.44577488e-04f, 3.49440314e-02f, -2.12801881e-02f, -7.41323829e-02f, 9.40882193e-04f, -2.44102739e-02f,
  -4.89180051e-02f, 3.18448767e-02f, -1.07619993e-01f, 3.14379185e-02f, 6.99955458e-03f, 4.72215936e-03f, -5.90919629e-02f, -4.66518477e-02f, -6.71354458e-02f, 1.47608705e-02f,
  -5.85732833e-02f, -4.19249572e-02f, -3.01622637e-02f, 1.06026500e-03f, -6.38713501e-03f, 2.23837849e-02f, -7.60284811e-02f, -5.57541428e-03f, -9.28177591e-03f, -4.53035198e-02f,
  1.85053758e-02f, -2.26978183e-01f, -1.84549466e-01f, 2.23994523e-01f, 3.84428166e-02f, -8.19617286e-02f, -1.06258586e-01f, -3.82640511e-02f, -1.17392398e-01f, 5.89090548e-02f,
  1.78666219e-01f, -1.18546061e-01f, -1.99593797e-01f, 1.95796743e-01f, 6.54010475e-02f, -1.10186338e-01f, 1.14797480e-01f, 3.83111350e-02f, -6.72844648e-02f, -2.00691260e-02f,
  6.06807284e-02f, 2.98414975e-01f, 5.90290166e-02f, 3.12571414e-03f, 9.57882032e-02f, 7.08504692e-02f, 2.66022831e-01f, -9.55845416e-02f, 2.01874927e-01f, 7.60203376e-02f,
  6.43092915e-02f, -4.67787087e-02f, -1.60255376e-02f, -1.51646780e-02f, 3.94302197e-02f, 6.68534860e-02f, 4.03112508e-02f, -4.71925288e-02f, -2.35355087e-02f, -1.13803305e-01f,
  -9.92420502e-03f, 6.06581708e-03f, 5.06130122e-02f, -8.84276479e-02f, 3.89525220e-02f, -3.04400008e-02f, 2.77619138e-02f, -2.35770494e-02f, -6.64644763e-02f, -5.29736988e-02f,
  -9.62713808e-02f, 1.38581526e-02f, -2.12827660e-02f, 2.11528633e-02f, 5.63536547e-02f, 2.01880187e-02f, -5.78708015e-02f, 4.28223126e-02f, 4.42565791e-02f, 2.42760517e-02f,
  3.35711092e-02f, -2.51387320e-02f, -2.12741382e-02f, -4.62206230e-02f, 3.65672335e-02f, 4.65835892e-02f, 2.11762451e-02f, 5.13492785e-02f, -2.59409640e-02f, 5.70353866e-02f,
  -4.75570373e-02f, 1.34334182e-02f, -1.53750302e-02f, 4.85731326e-02f, 7.68813342e-02f, -7.21484702e-03f, 6.33542165e-02f, -1.46466317e-02f, -2.05905386e-03f, -4.22809534e-02f,
  -5.48580941e-03f, -3.27579156e-02f, 1.81713037e-03f, 5.32694720e-02f, -5.32160401e-02f, 5.53602204e-02f, -1.02333035e-02f, 3.89857516e-02f, -5.50097860e-02f, 4.30577733e-02f,
  -9.45191272e-03f, 9.96236503e-02f, -4.13524657e-02f, -7.45383948e-02f, -1.65498499e-02f, -4.63750847e-02f, -2.91757621e-02f, 2.22407072e-03f, 5.78013249e-02f, 3.22462320e-02f,
  3.88661213e-02f, 2.74105202e-02f, -6.72584065e-05f, 5.31139709e-02f, -4.83592041e-02f, -2.34311931e-02f, 1.02587163e-01f, 3.17842066e-02f, 6.80844933e-02f, -5.14282146e-03f,
  -4.28185938e-03f, -2.13008188e-02f, 6.42862618e-02f, 9.74135324e-02f, 2.88946298e-03f, -5.52710798e-03f, 2.71740463e-02f, -1.11235388e-01f, 6.08371086e-02f, -4.97483946e-02f,
  2.31812432e-01f, 8.12520683e-02f, -8.73805434e-02f, 1.55434072e-01f, -8.27914700e-02f, -2.33186409e-03f, 1.99716061e-01f, 5.07896990e-02f, 3.09924960e-01f, 1.72151282e-01f,
  3.83101590e-02f, 1.46477178e-01f, -6.64301403e-03f, 2.54819453e-01f, 1.36472628e-01f, 2.20594063e-01f, 2.91485012e-01f, 1.41462892e-01f, -4.97500375e-02f, 7.28355497e-02f,
  5.12220040e-02f, 1.65648326e-01f, -4.63041700e-02f, -3.26425880e-02f, -7.07054933e-05f, -1.65633038e-01f, -8.99181068e-02f, -7.86964148e-02f, -3.68073434e-02f, -9.83723775e-02f,
  6.41366169e-02f, 5.04561327e-02f, -1.66699365e-02f, 9.88778695e-02f, -7.51223862e-02f, -6.55880496e-02f, 4.00913507e-02f, -7.14553371e-02f, 7.62026384e-03f, 3.82423475e-02f,
  7.39268959e-02f, -7.27541652e-03f, 6.84884414e-02f, 1.24572264e-02f, 4.22118604e-03f, -7.57144168e-02f, 3.12529355e-02f, -7.50027969e-02f, 2.84288675e-02f, -8.26176852e-02f,
  -9.70368832e-03f, 3.76286209e-02f, 4.77382727e-03f, 8.21084678e-02f, -2.60099359e-02f, -2.08583958e-02f, -2.72374824e-02f, -4.71395627e-02f, 2.13515311e-02f, -5.56565449e-03f,
  3.04491241e-02f, 2.42533302e-03f, -3.21544074e-02f, 4.02314588e-02f, -6.36468902e-02f, -7.04482198e-02f, -3.66361812e-02f, -8.12799409e-02f, -3.47848795e-02f, 2.22165533e-03f,
  -2.21827794e-02f, -6.96129426e-02f, 1.82612129e-02f, -1.91243012e-02f, 3.43013555e-02f, -1.93254631e-02f, 1.20531274e-02f, -1.94672868e-02f, 2.08255183e-02f, -4.75910380e-02f,
  6.51199892e-02f, 1.87451560e-02f, 7.10135549e-02f, -6.94383867e-03f, 5.36035933e-02f, -3.11488714e-02f, 5.13581969e-02f, -2.50051916e-02f, 3.21079046e-02f, -4.03091349e-02f,
  6.98550195e-02f, 5.75462580e-02f, 2.68925820e-02f, -1.39765134e-02f, -4.12119329e-02f, 3.68415825e-02f, 5.90471476e-02f, 5.92503995e-02f, 7.16903731e-02f, 6.18158914e-02f,
  -4.45902981e-02f, 3.26711172e-03f, -7.43435398e-02f, 2.48713735e-02f, 4.86792549e-02f, 9.49269608e-02f, 6.03015050e-02f, 2.15403885e-02f, 3.88129167e-02f, 3.40060256e-02f,
  -4.06333692e-02f, -3.06739267e-02f, -3.71789769e-03f, -6.87684044e-02f, -5.51626980e-02f, -1.82200801e-02f, -2.72083888e-03f, -2.91642360e-02f, -3.56214792e-02f, 1.65983252e-02f,
  2.31830738e-02f, -4.19070989e-01f, 2.36783847e-02f, -2.17670664e-01f, 1.30405590e-01f, 2.22879186e-01f, 1.30899131e-01f, -1.86955139e-01f, -2.26419896e-01f, -2.59324610e-01f,
  2.35969424e-02f, -2.62905180e-01f, -1.90314017e-02f, -1.18784659e-01f, 2.51322746e-01f, 3.62752303e-02f, -4.49107029e-02f, -1.09849527e-01f, -5.31567968e-02f, -1.77605391e-01f,
  -2.84280715e-04f, -4.83148806e-02f, 1.61355361e-01f, -2.75953319e-02f, -1.02423262e-02f, -1.34798184e-01f, 6.90371543e-02f, 5.35023287e-02f, -8.51863623e-02f, 7.05080256e-02f,
  1.01722879e-02f, -1.82171017e-01f, -5.24016172e-02f, 2.51678247e-02f, 9.24986228e-02f, 5.31094931e-02f, 5.03208581e-03f, 3.10354847e-02f, 6.20086640e-02f, 6.22477233e-02f,
  -3.83553430e-02f, -4.78255423e-03f, -7.23096728e-02f, -9.56362579e-03f, -8.11921284e-02f, -1.84304994e-02f, 7.36068338e-02f, 5.72733907e-03f, -4.32722270e-02f, -1.51569722e-02f,
  -2.33100764e-02f, 4.41318639e-02f, 6.66597113e-02f, -2.47745495e-02f, -1.83978304e-02f, -1.56781003e-02f, 1.53130363e-03f, 2.05519684e-02f, -8.13841373e-02f, -6.75612763e-02f,
  2.25487957e-03f, 1.84655022e-02f, 4.39860523e-02f, 2.46944223e-02f, -7.43191596e-03f, 6.23568296e-02f, -1.55465407e-02f, 1.39324442e-02f, 2.37186048e-02f, -5.06935129e-03f,
  1.67180821e-02f, -3.46731693e-02f, -3.38662937e-02f, -2.26231685e-04f, -8.72725714e-03f, 9.11321957e-03f, 9.01416093e-02f, -4.23309319e-02f, 4.83682230e-02f, 6.32795170e-02f,
  4.29607853e-02f, -4.20275843e-03f, 5.41803520e-03f, 5.00662103e-02f, -1.73295774e-02f, 3.73556502e-02f, -2.98466254e-02f, 3.45233688e-03f, -1.00548305e-02f, 6.02952205e-03f,
  -8.18583146e-02f, -2.24686056e-01f, 3.59700732e-02f, 6.33032713e-03f, -6.14598282e-02f, -3.80794816e-02f, 3.34236324e-02f, 1.11300510e-03f, -7.51362145e-02f, -2.53031682e-02f,
  5.26575111e-02f, 2.34673508e-02f, -6.77987328e-03f, -2.00171284e-02f, 3.95923704e-02f, 1.38793560e-02f, -5.80393523e-02f, -8.25865194e-03f, -1.76533125e-03f, 7.07171112e-03f,
  -1.65374484e-02f, 1.34803141e-02f, -3.12989503e-02f, -1.86933801e-02f, -3.20048444e-02f, 2.88107079e-02f, -4.67254966e-02f, 2.49236822e-02f, -3.03048640e-02f, -8.08835700e-02f,
  -2.39784539e-01f, -4.22490276e-02f, 1.28781453e-01f, 6.89803511e-02f, 2.11892173e-01f, 1.83028743e-01f, 1.22896068e-01f, 9.44429860e-02f, 7.23575354e-02f, -2.78972089e-02f,
  -3.40582095e-02f, -1.05756752e-01f, -9.70869064e-02f, 4.19370010e-02f, -5.63405454e-02f, 2.64899023e-02f, -3.60969044e-02f, 1.84626244e-02f, 6.32359693e-03f, 3.46723683e-02f,
  -2.21473929e-02f, 2.87370123e-02f, 2.36824639e-02f, 1.02506116e-01f, 9.35950726e-02f, -1.19050421e-01f, -1.74675614e-01f, 6.69703782e-02f, -6.20025769e-02f, 4.18543480e-02f,
  -9.26658213e-02f, -1.36177568e-02f, 8.32246765e-02f, -1.59326065e-02f, 3.18197310e-02f, -5.55987544e-02f, -9.61084664e-02f, 7.08966032e-02f, 3.81058082e-02f, 1.29230618e-02f,
  -3.92164849e-02f, 2.48563085e-02f, -4.20533540e-03f, 9.97827277e-02f, 2.98837703e-02f, 4.48817313e-02f, 5.37024289e-02f, -1.91294439e-02f, -1.12775313e-02f, -1.67901963e-02f,
  8.51964206e-02f, -3.12946178e-02f, -1.64301433e-02f, -4.23407927e-02f, -2.45591570e-02f, 6.66749850e-02f, 3.19878943e-02f, 5.64884488e-03f, -2.60372888e-02f, 6.01594634e-02f,
  -2.85949558e-04f, -5.64658381e-02f, -3.24678198e-02f, 9.50965509e-02f, -3.75845889e-03f, -5.72313666e-02f, 5.36845811e-02f, -6.17501587e-02f, 1.19423512e-02f, -7.81831518e-03f,
  -5.14732599e-02f, 3.80439088e-02f, 2.50879508e-02f, -1.91761851e-02f, -3.29847299e-02f, -8.18084925e-02f, -2.56832018e-02f, -4.42136042e-02f, -2.15151310e-02f, 8.47066194e-03f,
  -4.97206934e-02f, -6.20493665e-02f, 3.86253446e-02f, -1.99793205e-02f, 8.52058530e-02f, 4.55587544e-02f, -5.61675057e-02f, 6.24535494e-02f, -7.97474943e-03f, -4.60496359e-02f,
  -1.80833817e-01f, -2.61487186e-01f, 5.17075621e-02f, 3.32862400e-02f, -2.51944251e-02f, 3.66898812e-02f, 5.15888678e-03f, -5.55875851e-03f, -7.36499354e-02f, -2.95279808e-02f,
  -4.72072791e-03f, -5.25924526e-02f, -6.63114712e-02f, -9.45180953e-02f, -8.45212415e-02f, -1.79282464e-02f, -1.00171700e-01f, -4.25703600e-02f, 2.94275191e-02f, -8.80080834e-02f,
  -2.66355090e-02f, -4.95916829e-02f, 2.99692322e-02f, -2.65294202e-02f, -3.32783088e-02f, -1.10751484e-02f, -9.46263447e-02f, 6.87102899e-02f, -2.69739237e-02f, 3.35206948e-02f,
  -2.05687791e-01f, 3.15921903e-01f, -8.57039243e-02f, -6.18159696e-02f, -1.00609578e-01f, -4.84013790e-03f, 8.99885595e-02f, -2.97558121e-02f, 4.89132777e-02f, 1.22623242e-01f,
  -1.00886978e-01f, 8.91270116e-02f, 7.93515891e-02f, 1.93309903e-01f, -1.13404088e-01f, 1.83031246e-01f, 3.31994519e-02f, -3.89849697e-03f, 9.21572670e-02f, -1.08962052e-01f,
  -1.42670497e-01f, 3.71804014e-02f, 4.95518222e-02f, 1.83730754e-05f, -1.72506988e-01f, -1.15972627e-02f, -2.25133821e-01f, -3.55371125e-02f, -1.16184853e-01f, 2.43178941e-02f,
  -1.34169532e-03f, -1.57483608e-01f, -3.78571674e-02f, -1.11505546e-01f, -1.08090281e-01f, -1.21678084e-01f, -1.27250776e-01f, 6.68840408e-02f, -3.93874124e-02f, -8.84019583e-03f,
  2.52604336e-02f, -4.06416170e-02f, -1.84185635e-02f, 7.93539137e-02f, -6.98387623e-02f, -1.69499889e-02f, 6.32628202e-02f, -4.54550348e-02f, -2.09442731e-02f, 1.64194293e-02f,
  1.09712027e-01f, 4.68767397e-02f, 7.47329835e-03f, -7.74889207e-03f, -7.95013532e-02f, 8.81470591e-02f, 5.66255786e-02f, -4.17813808e-02f, -6.19208440e-02f, 5.34282485e-03f,
  -5.76818064e-02f, -4.80074733e-02f, 3.46021801e-02f, 1.77588351e-02f, 7.14159533e-02f, -5.86287342e-02f, -2.62466334e-02f, 4.65693995e-02f, -3.88710178e-04f, 9.86411609e-03f,
  4.93650744e-03f, -3.34327444e-02f, -6.41551241e-02f, -2.89274510e-02f, -4.08230387e-02f, -4.81358096e-02f, 3.16203721e-02f, -2.23197825e-02f, -4.03131545e-02f, 5.27481772e-02f,
  3.72525044e-02f, -1.08277351e-02f, 2.60913204e-02f, -7.77538195e-02f, -7.46131642e-03f, -1.87264811e-02f, -4.45409417e-02f, 1.83125250e-02f, -5.77847362e-02f, 7.60306371e-03f,
  -2.04571038e-01f, -2.83408612e-01f, -4.53383662e-03f, 2.41972972e-02f, 2.55488232e-02f, -8.46394375e-02f, 5.57185058e-03f, -2.77445689e-02f, 2.64366027e-02f, -5.89673929e-02f,
  -4.08323631e-02f, -1.97405228e-03f, -7.03158379e-02f, 6.34586513e-02f, 7.95294419e-02f, -1.03545086e-02f, -5.14501445e-02f, 4.88573499e-02f, -6.94242194e-02f, 4.29817662e-03f,
  -5.65308668e-02f, -4.25561965e-02f, -5.38333738e-03f, -2.91243028e-02f, 3.50334146e-03f, -1.12171680e-01f, -9.22969431e-02f, 3.77375558e-02f, 3.17610316e-02f, -6.59651607e-02f,
  1.04344197e-01f, -2.90694892e-01f, -6.38133213e-02f, 1.29461706e-01f, 8.87659118e-02f, -7.04175085e-02f, -6.02453249e-03f, -1.09715804e-01f, 1.70189187e-01f, -2.53429025e-01f,
  -1.41299725e-01f, 2.98363864e-02f, -1.87454864e-01f, -2.32059643e-01f, 9.77713168e-02f, -2.54862756e-01f, -1.56988889e-01f, -9.53683406e-02f, -2.32200529e-02f, -9.69193578e-02f,
  -1.84262730e-02f, -6.32367730e-02f, -1.45824179e-01f, 1.92350615e-02f, -7.68013969e-02f, 7.03017712e-02f, 9.98412445e-03f, 2.42861342e-02f, 5.19262925e-02f, -3.76535114e-03f,
  1.11580295e-02f, 2.55019609e-02f, -1.43881293e-03f, 1.02929901e-02f, -9.55768526e-02f, 6.87610880e-02f, 2.78160162e-02f, -3.15832868e-02f, 1.23173282e-01f, 6.33559898e-02f,
  -1.45210996e-02f, -1.33376727e-02f, 4.72745001e-02f, 2.05299463e-02f, 5.63531630e-02f, -6.46660030e-02f, 4.77282479e-02f, -7.46866828e-03f, 7.84647744e-03f, -3.00026294e-02f,
  -7.60118440e-02f, -3.89232077e-02f, 1.36133889e-02f, -1.79456081e-02f, 3.27214152e-02f, 7.79118109e-03f, 3.64885367e-02f, 4.49277349e-02f, -5.67430109e-02f, -5.33907451e-02f,
  -2.92008296e-02f, -4.12458600e-03f, 3.11866011e-02f, 3.24972905e-02f, 1.96499042e-02f, -2.26313379e-02f, 6.47336543e-02f, -1.90866217e-02f, -3.14973085e-03f, -7.17549324e-02f,
  4.71943878e-02f, -3.65915224e-02f, -6.36971444e-02f, 2.41912436e-02f, 1.95711106e-02f, -3.20548080e-02f, 1.15271835e-02f, -5.62355667e-02f, 7.23272189e-02f, -6.17900491e-02f,
  2.41422188e-02f, -4.48324066e-03f, -4.58458699e-02f, 4.96401964e-03f, 5.58811836e-02f, -5.45566157e-02f, -5.75901680e-02f, -5.32577112e-02f, 1.02710947e-02f, 2.38367934e-02f,
  -1.22034334e-01f, -1.74925491e-01f, -1.02521796e-02f, -7.74940196e-03f, 3.25807109e-02f, -8.07976797e-02f, 1.67093910e-02f, -1.96139645e-02f, 1.80673674e-02f, -3.23536545e-02f,
  5.41372076e-02f, 3.66743803e-02f, -3.12550105e-02f, 4.56345081e-02f, 6.37229905e-02f, 3.54260691e-02f, -8.10156167e-02f, -2.75844540e-02f, 5.58538213e-02f, -6.02249317e-02f,
  -5.86192906e-02f, 2.84903552e-02f, 6.85445443e-02f, 1.05246074e-01f, 3.17567624e-02f, 6.54098466e-02f, 1.26528079e-02f, -2.80698258e-02f, 4.26499061e-02f, 5.66252582e-02f,
  5.58893681e-02f, -2.20946991e-03f, -7.59191737e-02f, -1.15164844e-02f, -5.17127477e-02f, 1.45414650e-01f, 2.18712509e-01f, 2.53845062e-02f, 1.59603640e-01f, 2.69840568e-01f,
  6.75342754e-02f, 1.93584021e-02f, 1.96210910e-02f, 8.71455446e-02f, 1.06605254e-01f, 9.08731599e-04f, 7.85757601e-02f, 1.87519908e-01f, -6.41227812e-02f, 6.85006455e-02f,
  -3.99442483e-03f, -2.41046492e-02f, -7.73781687e-02f, -1.64480925e-01f, -3.20517160e-02f, -4.78594601e-02f, 2.44808514e-02f, -3.11221909e-02f, -6.24132976e-02f, -7.23517910e-02f,
  8.98515061e-02f, 1.98352069e-01f, 1.02285154e-01f, -5.20369620e-04f, 5.34470342e-02f, 5.23372702e-02f, 5.69552034e-02f, -3.40461135e-02f, -1.92407537e-02f, 2.20247954e-02f,
  -2.04560813e-03f, -1.49168167e-03f, 1.19037228e-02f, 3.79526522e-03f, 1.05904741e-02f, -1.62842702e-02f, -1.07497778e-02f, -7.67977461e-02f, 6.46801712e-03f, -5.70338592e-02f,
  -2.31075496e-03f, 1.09905647e-02f, -2.00928897e-02f, -3.08347549e-02f, -8.09950754e-02f, 4.37562577e-02f, 4.52842861e-02f, -4.57932875e-02f, -7.28356792e-03f, 2.50778776e-02f,
  7.89733678e-02f, -4.85565066e-02f, 9.74226184e-03f, -7.53102675e-02f, 6.86259568e-02f, -2.24024281e-02f, 4.89615351e-02f, -7.76777789e-02f, -7.05510080e-02f, -7.07165375e-02f,
  -1.49497399e-02f, -1.60338227e-02f, 6.59621321e-03f, 4.12724912e-02f, -5.42576835e-02f, 1.76224709e-02f, 5.14093488e-02f, 1.46437539e-02f, 7.97426142e-03f, -1.61241665e-02f,
  4.08943333e-02f, 2.91132648e-02f, 2.67940760e-03f, 5.82856312e-02f, 9.21975300e-02f, -2.00192481e-02f, -2.88223363e-02f, 2.09740978e-02f, 1.88973005e-04f, -1.56465136e-02f,
  1.57865718e-01f, 2.80178308e-01f, -3.56079638e-02f, 5.77713959e-02f, 4.82475292e-03f, -1.86108518e-02f, -4.13749041e-03f, -6.43893033e-02f, 7.87212551e-02f, 5.96724153e-02f,
  -2.71132030e-02f, -2.02720705e-02f, 8.52085128e-02f, -4.23484202e-03f, -5.56224696e-02f, 6.73419517e-03f, 1.58835133e-03f, -3.27016599e-03f, -1.62542537e-02f, 6.43821731e-02f,
  5.73631972e-02f, 1.07476726e-01f, -1.01239076e-02f, -4.15924191e-02f, 2.24970728e-02f, 6.82933554e-02f, 5.84039651e-02f, -2.23201904e-02f, -5.89793622e-02f, 5.45463935e-02f,
  -1.92017391e-01f, -1.87452435e-01f, -2.44361207e-01f, -2.76785284e-01f, 4.94681150e-02f, 2.85683542e-01f, 1.37801632e-01f, -1.21215411e-01f, -1.80121779e-01f, 9.05921012e-02f,
  8.40362906e-02f, -1.75111175e-01f, 1.48203403e-01f, -1.84563071e-01f, 1.04067028e-01f, 8.62599909e-02f, -1.00213997e-01f, -7.60874525e-02f, -7.78260827e-02f, -1.23439550e-01f,
  -1.48509592e-01f, -2.94759087e-02f, -1.17618196e-01f, -2.51018554e-02f, -2.01923728e-01f, -1.54247180e-01f, 1.90359857e-02f, 9.55735669e-02f, -9.37797204e-02f, 1.01145260e-01f,
  -1.36220027e-02f, -1.07224002e-01f, -1.41104698e-01f, -3.19614410e-02f, -5.00257276e-02f, 4.74627353e-02f, 7.50061050e-02f, 1.04842432e-01f, 2.74474453e-02f, -4.74435976e-03f,
  1.84970703e-02f, 2.07837559e-02f, 4.09072898e-02f, -1.02528995e-02f, 7.02174706e-03f, -8.22285339e-02f, -8.14288408e-02f, 1.67293735e-02f, -2.10811440e-02f, 1.02896793e-02f,
  -9.47243273e-02f, -3.43990289e-02f, -4.56579030e-03f, -3.50593589e-02f, -1.21357944e-03f, -4.02458869e-02f, -3.58310901e-02f, 4.94468864e-03f, 9.01946239e-03f, 2.00431347e-02f,
  -3.22348997e-02f, 4.34206873e-02f, -4.20353152e-02f, 1.00355307e-02f, 4.51342249e-03f, -1.00311659e-01f, 3.19009162e-02f, 5.64244241e-02f, -3.16972546e-02f, 7.09682181e-02f,
  -1.39604462e-02f, -4.35630567e-02f, 1.22819794e-02f, 1.26046874e-02f, -5.15376702e-02f, -3.79260592e-02f, 6.30878955e-02f, 5.73389651e-03f, -9.03604180e-02f, -7.05968291e-02f,
  -1.28328730e-03f, 5.65518299e-03f, -2.19406970e-02f, 6.92319870e-03f, 5.44837937e-02f, -4.06872928e-02f, -1.89812237e-03f, -5.28374054e-02f, 3.86489667e-02f, 1.88820418e-02f,
  5.83888106e-02f, -2.38452535e-02f, 2.92113080e-04f, -8.74905661e-03f, 4.39048894e-02f, 9.58332967e-04f, -7.79714622e-03f, -2.72338092e-02f, -1.95439793e-02f, 7.33495802e-02f,
  -1.02417367e-02f, -3.66843268e-02f, 2.03961332e-04f, 3.36599462e-02f, 2.31628437e-02f, -7.51576526e-03f, -8.14833678e-03f, 1.24328965e-02f, -2.39459295e-02f, -6.19681031e-02f,
  8.05226788e-02f, 4.73164581e-02f, 3.10915112e-02f, 2.43511181e-02f, -5.11929467e-02f, -1.29931187e-02f, 3.92170325e-02f, 2.92712301e-02f, 3.58063467e-02f, 1.95852052e-02f,
  3.35256904e-02f, 2.13151239e-02f, -5.34818992e-02f, -4.22370359e-02f, 4.71617766e-02f, 4.16287147e-02f, 9.27188247e-02f, 6.87798336e-02f, -7.14251921e-02f, -1.25792125e-04f,
  8.24771821e-02f, 1.10884592e-01f, -1.03451125e-01f, -1.97827443e-02f, -2.90050685e-01f, -1.87380508e-01f, -8.04661140e-02f, -3.10807079e-02f, -9.77759659e-02f, -2.12078653e-02f,
  -1.59550577e-01f, 1.02740772e-01f, -1.23122148e-01f, 1.13069944e-01f, 6.96060956e-02f, 9.53326747e-02f, 1.19786123e-02f, 3.49737220e-02f, -4.12661508e-02f, -5.37413321e-02f,
  2.34024487e-02f, 3.33960727e-02f, 2.69014686e-02f, -5.15602268e-02f, 2.98846420e-02f, 5.09815104e-02f, 7.41468146e-02f, -8.59436672e-03f, 2.01589148e-02f, -4.67150770e-02f,
  -2.98769865e-02f, 3.65715474e-02f, -5.52178733e-02f, -4.84490953e-03f, 4.15560417e-02f, -1.37753198e-02f, -3.05011962e-02f, -6.55332729e-02f, -1.66966002e-02f, -6.43182546e-02f,
  7.53936619e-02f, 4.13728878e-02f, 6.33515865e-02f, -6.59355596e-02f, -6.69970885e-02f, 3.12445220e-02f, -2.81276461e-02f, -6.80920854e-02f, -6.73621148e-02f, -3.39227393e-02f,
  4.76588085e-02f, 3.94063629e-02f, -5.47665311e-03f, -2.89376453e-02f, -6.25191852e-02f, -2.89255138e-02f, -6.04709284e-03f, -2.17046216e-02f, 5.66303032e-03f, -1.73269268e-02f,
  -1.71037484e-02f, 4.65950835e-03f, 7.00929463e-02f, 3.06249112e-02f, 2.56804265e-02f, -5.64940460e-02f, -4.22734693e-02f, 2.34395973e-02f, -5.13600335e-02f, -7.90079832e-02f,
  2.21701376e-02f, 2.05372125e-02f, 1.07653271e-02f, -4.83305566e-02f, -5.91036268e-02f, -3.48540843e-02f, -3.38489190e-02f, 4.48074453e-02f, 5.15782014e-02f, 4.46315669e-02f,
  -1.59342572e-01f, -9.29673687e-02f, 7.98935518e-02f, 6.44520670e-02f, -7.27419704e-02f, -2.53423695e-02f, -1.72532741e-02f, 8.31492711e-03f, -1.05689272e-01f, -1.94197949e-02f,
  1.83233414e-02f, 4.76282127e-02f, -5.01357252e-04f, 8.07935186e-03f, -2.43191905e-02f, -5.27453469e-03f, -4.81871469e-03f, -6.43750131e-02f, -1.17521943e-03f, -5.19427396e-02f,
  4.97034192e-02f, 2.06245519e-02f, -7.16738105e-02f, -1.93913635e-02f, -1.70977693e-02f, -6.05427241e-03f, -2.62508448e-02f, 4.82223108e-02f, 5.80862025e-03f, 1.13522336e-04f,
  -1.60581559e-01f, 3.10447901e-01f, 9.10674334e-02f, -2.23037481e-01f, 1.27136394e-01f, 3.15353394e-01f, 2.12902844e-01f, 1.28606856e-01f, 1.68338835e-01f, 1.16693117e-01f,
  -5.57733513e-02f, 1.54510960e-02f, 1.33492678e-01f, -7.31787309e-02f, -1.12883039e-01f, 7.06025911e-03f, 2.19427906e-02f, 6.43686056e-02f, 9.62131023e-02f, 6.51163422e-03f,
  -6.44419044e-02f, -4.56669256e-02f, -1.34089053e-01f, 7.57495314e-02f, -7.36768320e-02f, -2.62386929e-02f, -2.34879002e-01f, 6.05662130e-02f, -1.35315418e-01f, 7.32633471e-02f,
  6.05109520e-02f, -5.18619157e-02f, 2.24541314e-02f, 8.33921060e-02f, -1.19117191e-02f, -5.63196354e-02f, -8.93030874e-03f, 1.38528161e-02f, -2.26685740e-02f, 3.35074738e-02f,
  1.74959153e-02f, -3.30623873e-02f, -3.98069955e-02f, -4.23945710e-02f, 6.76748380e-02f, 7.49141956e-03f, -1.07048871e-02f, -4.02047783e-02f, 4.73660976e-02f, 6.51808605e-02f,
  7.34213442e-02f, -3.18924040e-02f, -3.33581939e-02f, 4.30751145e-02f, 5.60481250e-02f, -2.57739853e-02f, 4.42686304e-02f, -2.67332289e-02f, 1.38377715e-02f, -4.67840992e-02f,
  -5.49360774e-02f, -2.37155403e-03f, -1.29239131e-02f, -1.41625647e-02f, -2.25638710e-02f, -6.99326918e-02f, -7.15257972e-02f, -3.78504880e-02f, 4.98733371e-02f, -3.35238408e-03f,
  7.83038558e-04f, -4.63989377e-02f, -4.62714210e-02f, -7.86323845e-02f, -3.92987393e-02f, -3.72160412e-03f, -3.09908278e-02f, 3.06058824e-02f, -6.83664531e-02f, -3.46858799e-02f,
  -2.67379126e-03f, -4.91026901e-02f, 2.18616370e-02f, -6.33956790e-02f, 4.43115085e-02f, -7.78754652e-02f, -2.20334008e-02f, 4.19682674e-02f, -2.15813704e-03f, 3.73617746e-03f,
  1.18236937e-01f, 1.00279279e-01f, 2.53014751e-02f, -5.86478747e-02f, -3.88894267e-02f, 4.60217856e-02f, 8.28061067e-03f, 2.77147517e-02f, 2.66077346e-03f, 8.23447034e-02f,
  -5.48713803e-02f, -2.55454704e-02f, -3.22644077e-02f, -4.19531576e-02f, -8.42292532e-02f, -5.10417449e-04f, -3.89166363e-02f, 7.09834462e-03f, -9.16035473e-02f, -6.77664503e-02f,
  -8.25308040e-02f, 4.15897407e-02f, -1.30557092e-02f, 3.77003243e-03f, -1.73081588e-02f, -2.57577020e-04f, 4.04308885e-02f, 4.81340885e-02f, -2.77594086e-02f, 1.71373263e-02f,
  -3.66815865e-01f, 3.41211110e-01f, 6.14803880e-02f, -8.99798498e-02f, -1.08882889e-01f, 6.94754440e-03f, -7.26042464e-02f, 9.46203619e-02f, -3.92108746e-02f, 1.26158699e-01f,
  -8.41017067e-02f, 8.54711235e-02f, -2.97599062e-02f, 8.56726021e-02f, -3.32208604e-01f, -1.07357698e-02f, -7.28902444e-02f, 7.17416182e-02f, 5.15581444e-02f, -8.39704201e-02f,
  -1.73482046e-01f, 4.02680710e-02f, -6.20879829e-02f, 1.73939764e-01f, 2.44151615e-03f, 5.42102605e-02f, -1.56629845e-01f, 7.71341175e-02f, 1.36569977e-01f, -1.30574759e-02f,
  1.53268464e-02f, 1.63954124e-02f, 2.56453175e-02f, 1.33808523e-01f, -6.20714128e-02f, -6.58341795e-02f, 3.38578336e-02f, -1.02605382e-02f, -4.14594412e-02f, -6.64650742e-03f,
  -5.43221422e-02f, -2.67417133e-02f, 3.98491584e-02f, -2.26890226e-03f, 2.30648033e-02f, 1.18038915e-01f, 2.57954095e-02f, -4.14658105e-03f, 7.26005062e-02f, 1.02245798e-02f,
  -2.04021074e-02f, 7.79386312e-02f, 3.79709601e-02f, 1.29643083e-02f, -6.10323586e-02f, 6.21700436e-02f, 2.50587948e-02f, -6.43627271e-02f, -2.57737637e-02f, -6.63168728e-02f,
  -5.03882915e-02f, -2.68553253e-02f, 5.30677661e-02f, -6.55510370e-03f, 3.32030952e-02f, 2.17905436e-02f, 4.55910414e-02f, 4.34455611e-02f, 2.97547854e-03f, -2.57058698e-03f,
  3.75596061e-02f, 3.57379466e-02f, -2.85137258e-02f, -7.19048604e-02f, 3.43594397e-03f, -2.08224151e-02f, -3.29356641e-02f, 7.85793066e-02f, 1.44212833e-02f, 1.31743988e-02f,
  4.40933667e-02f, -8.28015525e-03f, -1.18488027e-02f, 4.50347848e-02f, -8.51768907e-03f, 3.92097197e-02f, -3.22699489e-04f, 2.15843059e-02f, -2.71981899e-02f, -8.00310299e-02f,
  -5.10015897e-02f, -1.46839857e-01f, -2.91530397e-02f, 6.69927001e-02f, 1.34654809e-02f, -5.56575209e-02f, 1.15178712e-02f, 4.96449880e-02f, -5.08014299e-03f, -7.37065747e-02f,
  3.33853662e-02f, -6.97496871e-04f, 1.20340157e-02f, -6.55334350e-03f, 1.51388897e-02f, -7.81739652e-02f, 9.58423689e-03f, -7.62369297e-03f, -3.38501744e-02f, -1.91396438e-02f,
  7.56719261e-02f, -5.35610914e-02f, -2.66661644e-02f, 5.43028563e-02f, 2.81614661e-02f, -7.14650527e-02f, -5.00136428e-02f, -9.93676390e-03f, 2.26832014e-02f, 2.31033806e-02f,
  2.69163072e-01f, -2.05181211e-01f, -2.08442166e-01f, -4.14630622e-02f, 2.35985592e-01f, 1.00139201e-01f, 1.04523562e-01f, -5.00580333e-02f, -1.99140474e-01f, 1.00173596e-02f,
  8.77689645e-02f, -3.19110532e-03f, -2.30203569e-01f, 1.00906529e-01f, -1.00577459e-01f, -2.73085237e-01f, -4.10395823e-02f, 1.39346763e-01f, -1.79545715e-01f, 1.38404503e-01f,
  -3.69650126e-02f, 1.03735395e-01f, -1.68474615e-01f, -1.44638816e-05f, 1.89276859e-01f, -2.01846547e-02f, 1.38237149e-01f, -1.11060679e-01f, 2.29541004e-01f, 1.24359898e-01f,
  6.20410852e-02f, -2.41800081e-02f, 2.31372826e-02f, -2.37474237e-02f, 1.59837063e-02f, 2.60314532e-02f, 7.04794154e-02f, 4.06705476e-02f, 6.54780120e-02f, -3.29413824e-03f,
  8.86854623e-03f, 2.86336802e-02f, -2.74638906e-02f, -6.52017370e-02f, 6.32557645e-02f, -3.50624174e-02f, -2.64609102e-02f, -2.99067106e-02f, -3.45093496e-02f, 2.18468215e-02f,
  -2.26235092e-02f, -1.12905204e-02f, -2.96555106e-02f, -1.71362702e-02f, 4.02392671e-02f, -3.87047604e-02f, 3.54652293e-02f, 3.11060459e-03f, 9.15003195e-03f, -7.27809817e-02f,
  8.53089709e-03f, -1.03891902e-01f, -1.64653230e-02f, -4.12675403e-02f, 5.66493869e-02f, 3.44550703e-04f, 1.94704793e-02f, 1.59982610e-02f, -5.04303426e-02f, 4.40680310e-02f,
  2.66267303e-02f, -6.05475344e-02f, -3.51999588e-02f, -9.83797088e-02f, 5.45812920e-02f, 4.50799353e-02f, -1.27290934e-03f, 3.26871201e-02f, -2.69299448e-02f, -1.69336814e-02f,
  2.20969710e-02f, -4.93979156e-02f, 6.86853379e-02f, 6.63242191e-02f, -8.19888432e-04f, -3.96285504e-02f, -5.50967827e-03f, -5.52468672e-02f, -5.62742501e-02f, 1.03876619e-02f,
  8.71142372e-02f, -8.59986618e-02f, -5.57380961e-03f, 7.55946860e-02f, 1.38305372e-03f, -1.10749872e-02f, -1.08721524e-01f, -2.65531242e-02f, -6.99362308e-02f, 1.13688130e-02f,
  4.37310375e-02f, 2.27076672e-02f, 7.29225054e-02f, 5.00252284e-02f, -5.62923104e-02f, -6.55536130e-02f, -3.55362892e-02f, 5.62177151e-02f, 8.30067322e-02f, -1.80421416e-02f,
  7.63794780e-02f, 5.02304472e-02f, -3.61854956e-02f, 2.75369175e-02f, 2.40512732e-02f, 7.68087208e-02f, 3.93433589e-03f, -3.62030156e-02f, -1.82512458e-02f, -3.16281281e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.88534391e-02f, -1.30039705e-02f, 1.60832956e-01f, 3.10051464e-03f, -3.02165318e-02f, 1.83564857e-01f, 1.61829397e-01f, -1.33608386e-01f, -1.32129058e-01f, -7.29993433e-02f,
  -1.09974198e-01f, 6.87200055e-02f, -1.04050888e-02f, -8.68062675e-02f, 1.77440688e-01f, 9.40273702e-02f, -8.15837309e-02f, -1.51951853e-02f, -3.35556716e-02f, 3.51183303e-02f,
  -6.19018599e-02f, -1.00725897e-01f, 2.89000012e-03f, -1.46558834e-02f, -4.04093079e-02f, 2.33863499e-02f, -9.17561725e-02f, 6.81984872e-02f, -1.06530681e-01f, -9.53509659e-02f,
  7.60231614e-02f, -1.29977226e-01f, -5.84160909e-02f, -1.45427454e-02f, -8.66283104e-03f, 5.02689295e-02f, 1.02061875e-01f, 6.42902553e-02f, -9.87606868e-02f, -6.49934337e-02f,
  -5.55197001e-02f, -8.15497637e-02f, -3.57345417e-02f, -5.13900667e-02f, -5.93408458e-02f, -2.30874326e-02f, -7.10105449e-02f, -9.19241738e-03f, -5.07671125e-02f, 7.08500594e-02f,
  -1.46163395e-03f, 2.27363873e-02f, 1.55686121e-02f, -6.12993613e-02f, 1.01757990e-02f, -7.05938041e-02f, -3.05816326e-02f, 3.31572704e-02f, 6.58394694e-02f, -1.22345276e-02f,
  1.10088373e-02f, 1.39762927e-02f, -2.78987642e-02f, -1.77700687e-02f, -6.51441440e-02f, -2.00126246e-02f, 1.53985247e-02f, 5.86778112e-02f, -4.32522595e-02f, -2.22348375e-03f,
  5.83932176e-02f, -9.31728929e-02f, 6.13934174e-02f, -3.90220135e-02f, 6.38685524e-02f, 3.39467973e-02f, 7.20336288e-02f, -4.39076014e-02f, 3.83567140e-02f, 6.08412782e-03f,
  -1.01054199e-02f, -1.87728237e-02f, -9.10296515e-02f, -6.57996833e-02f, 1.07023425e-01f, -6.25654086e-02f, 2.18004230e-02f, -7.43082985e-02f, -6.00633472e-02f, -7.87976459e-02f,
  -6.26341160e-03f, 1.00603066e-02f, -4.90065888e-02f, 5.08051217e-02f, 1.63410120e-02f, 3.20406095e-03f, -7.22395256e-02f, -3.39317024e-02f, -7.73959383e-02f, -4.52255420e-02f,
  1.07735507e-02f, -3.44509557e-02f, 1.27444491e-02f, -1.14601888e-02f, -7.23739713e-02f, -4.25815247e-02f, 3.13744023e-02f, 7.52245542e-03f, 6.66325837e-02f, 3.27313989e-02f,
  -4.53885198e-02f, -5.85924760e-02f, -3.43201347e-02f, -2.26045400e-02f, -1.28833175e-01f, -2.00226679e-02f, -5.61523400e-02f, -7.88644850e-02f, -9.31098685e-02f, 6.16766699e-02f,
  1.78252365e-02f, 1.07819252e-01f, -4.17386033e-02f, 7.52419904e-02f, 1.58179775e-01f, 2.13865057e-01f, 1.22422859e-01f, 1.99925825e-02f, 2.75810510e-01f, -1.45315416e-02f,
  -3.05325072e-02f, 9.45262983e-02f, -1.05954092e-02f, -6.49404228e-02f, 1.01627178e-01f, -1.90616250e-02f, 1.26329854e-01f, 1.31200448e-01f, 9.39556658e-02f, 1.77834686e-02f,
  1.26314275e-02f, 3.56439315e-02f, -2.65267879e-01f, -5.53113632e-02f, -6.91327155e-02f, -1.08720720e-01f, -3.74129303e-02f, -3.78635786e-02f, -1.31365284e-01f, 6.27013519e-02f,
  1.84148969e-03f, -4.70865108e-02f, -1.85174663e-02f, -8.75715837e-02f, 6.89106807e-02f, 7.89436419e-03f, -3.48826125e-02f, 3.74247469e-02f, -7.10876472e-03f, 3.90289463e-02f,
  -2.31872127e-06f, -6.04464971e-02f, 3.48545834e-02f, 2.47068703e-02f, 7.17707574e-02f, -8.60218480e-02f, 2.70584933e-02f, -8.58181193e-02f, 1.98450331e-02f, -2.17497181e-02f,
  -1.63476020e-01f, -3.24774627e-03f, -1.02325380e-02f, -2.27674004e-02f, 5.56717291e-02f, 5.10131940e-02f, 5.18168211e-02f, 3.35724130e-02f, -3.79508585e-02f, 9.20101814e-03f,
  7.02052414e-02f, 6.97531998e-02f, 4.67332304e-02f, -4.75237146e-02f, 2.52167434e-02f, -2.17762962e-03f, 3.72961387e-02f, 7.04294592e-02f, 6.58222437e-02f, -4.77625839e-02f,
  8.33385717e-03f, 4.79251295e-02f, 5.95044568e-02f, 2.57962830e-02f, -4.37095463e-02f, 6.18235441e-03f, -1.52267721e-02f, 5.02819046e-02f, 7.28661269e-02f, -1.66843794e-02f,
  4.91688401e-02f, 6.66423440e-02f, -4.63708043e-02f, 2.46027764e-02f, 5.66202849e-02f, 5.23379594e-02f, -2.05780137e-02f, 6.06212206e-03f, 8.04637279e-03f, -1.05296343e-03f,
  8.26740339e-02f, 2.64791965e-01f, -3.27895619e-02f, -1.08943898e-02f, 3.85239907e-02f, 3.39158513e-02f, 4.27169800e-02f, 4.88873310e-02f, 1.01858996e-01f, 8.43149200e-02f,
  5.64602611e-04f, 8.74474086e-03f, 1.89340636e-02f, -7.04735368e-02f, 1.37506844e-02f, 8.96451101e-02f, 4.54360321e-02f, 5.42941839e-02f, 6.14916794e-02f, -1.50301615e-02f,
  4.60745709e-04f, -3.33710536e-02f, -3.54394689e-02f, -1.17546255e-02f, -1.72892381e-02f, 5.09667471e-02f, 1.13829792e-01f, -9.63907540e-02f, 4.27628569e-02f, 6.75764382e-02f,
  -8.58106911e-02f, -7.94538110e-02f, 1.19711515e-02f, -7.15146447e-03f, 7.42745325e-02f, 1.34450138e-01f, -9.34169255e-03f, 1.45707741e-01f, -8.15449804e-02f, -2.72025988e-02f,
  -1.66431665e-02f, -1.83474228e-01f, -2.29778156e-01f, 1.58553943e-02f, -3.98019701e-03f, -8.43395516e-02f, 1.20880648e-01f, -1.17489100e-01f, -1.54526178e-02f, -5.01580834e-02f,
  1.04856670e-01f, -4.83470298e-02f, 1.71953905e-02f, 8.03612769e-02f, -1.50432298e-02f, 7.56270997e-03f, -1.84278507e-02f, 4.80740182e-02f, 3.34830396e-02f, 1.00271562e-02f,
  -9.58829466e-03f, 1.62063595e-02f, -1.31873101e-01f, 3.37069556e-02f, 6.58782991e-03f, -8.95035639e-02f, -4.84525561e-02f, -3.88612412e-02f, -2.13861521e-02f, -3.25942924e-03f,
  -9.02417302e-02f, 2.57911868e-02f, -5.28419539e-02f, -7.80322403e-03f, 6.40221089e-02f, -4.88815717e-02f, 6.45860806e-02f, -7.75190666e-02f, 2.81983260e-02f, 1.02652170e-01f,
  -5.74114174e-02f, 9.43450332e-02f, -7.21676722e-02f, 1.00505434e-01f, -3.64637026e-03f, 7.96325877e-03f, -4.58734930e-02f, -3.64572369e-02f, 2.03888398e-02f, -1.98974172e-04f,
  7.02338815e-02f, 3.42454668e-03f, -2.24387627e-02f, -4.78168996e-03f, -5.03896028e-02f, 9.62550938e-02f, 3.03283129e-02f, 3.78820971e-02f, -3.55882980e-02f, 1.37550673e-02f,
  7.75461085e-03f, -7.19918609e-02f, -2.51727514e-02f, 1.40149305e-02f, 5.75831234e-02f, -6.43356070e-02f, -6.43659532e-02f, -4.30273861e-02f, -5.05696796e-02f, 5.38058169e-02f,
  5.59626007e-03f, -6.19140603e-02f, 5.58064431e-02f, 1.30783487e-02f, -5.05977683e-02f, -3.23513225e-02f, 3.24364007e-03f, 9.43120103e-03f, 3.73088717e-02f, 3.46701667e-02f,
  -8.77409950e-02f, -3.23070101e-02f, -8.30153003e-02f, 9.33315679e-02f, -2.10965835e-02f, 6.38368651e-02f, -4.51497026e-02f, -1.48495557e-02f, 2.86160242e-02f, -4.94895689e-02f,
  -5.39918020e-02f, 1.68555453e-02f, 4.19899039e-02f, -6.53160363e-02f, 5.40393479e-02f, 6.86241165e-02f, -5.58674969e-02f, -7.68905133e-02f, -9.11241490e-03f, -4.18762490e-02f,
  -1.03963889e-01f, -4.46055643e-02f, -6.68425262e-02f, -1.74459759e-02f, -6.58875108e-02f, 4.33341153e-02f, -2.75154300e-02f, -7.44437873e-02f, 4.17611934e-02f, -3.46231200e-02f,
  -2.33618356e-02f, 3.41688134e-02f, -4.76882681e-02f, -1.80308938e-01f, 4.71104421e-02f, -2.86783036e-02f, -1.92441300e-01f, 7.29257464e-02f, 3.37952450e-02f, -2.97929738e-02f,
  -1.16534807e-01f, -7.99105689e-02f, 8.80673900e-02f, -7.18670934e-02f, 4.29183096e-02f, 1.39639497e-01f, -6.13393597e-02f, -8.20044726e-02f, 3.85207087e-02f, -1.47453090e-02f,
  3.94860795e-03f, -8.10360089e-02f, -1.92173887e-02f, -8.07883497e-03f, -1.55187562e-01f, -8.51686969e-02f, -5.79568371e-02f, -4.50897217e-02f, -3.11875455e-02f, -4.12691198e-02f,
  3.28513645e-02f, 4.45735967e-03f, -2.44222814e-03f, -5.19379601e-02f, -1.27592996e-01f, -4.26953062e-02f, -2.95794699e-02f, 3.86042744e-02f, 6.82744682e-02f, -3.79368663e-02f,
  6.35049641e-02f, 1.02287173e-01f, 4.59053218e-02f, 8.03820230e-03f, -5.94544597e-02f, -9.92400274e-02f, 5.57998493e-02f, -8.33815485e-02f, -5.40715232e-02f, -4.08075787e-02f,
  9.10305418e-03f, 3.84957679e-02f, -3.86835523e-02f, -4.82568480e-02f, 6.19497523e-02f, -6.65017143e-02f, 6.72641098e-02f, -7.95587450e-02f, 1.02017270e-02f, 3.37557532e-02f,
  5.57767339e-02f, 2.24992447e-03f, -9.61823463e-02f, -5.07135093e-02f, 1.32815214e-02f, -8.36178362e-02f, 5.17884009e-02f, -2.30709258e-02f, 4.69588824e-02f, 5.42469285e-02f,
  -1.93857774e-02f, -3.27661894e-02f, 5.09938300e-02f, -2.01693317e-03f, 4.87108976e-02f, -8.18195846e-03f, -4.16989326e-02f, 3.42586264e-02f, 2.91620623e-02f, 2.18549576e-02f,
  4.66603078e-02f, 6.65087551e-02f, 1.87217519e-02f, -5.83101762e-04f, -2.38666255e-02f, -6.42915517e-02f, 6.68606088e-02f, 4.40098830e-02f, -2.92206611e-02f, -1.55475615e-02f,
  -3.45233791e-02f, -1.32405281e-01f, -1.11122712e-01f, -5.63370250e-02f, -7.68015906e-02f, -1.07218899e-01f, 6.27751276e-02f, 8.86006746e-03f, -7.67047778e-02f, 1.22901751e-02f,
  -9.68354717e-02f, -8.51339027e-02f, 4.75683734e-02f, 4.50274497e-02f, -8.03958252e-02f, 3.90736610e-02f, -1.07337385e-02f, 5.56620955e-02f, -3.09762061e-02f, 6.47491263e-03f,
  -2.05536373e-02f, 5.98997511e-02f, -6.45827949e-02f, 4.18227687e-02f, 2.65730661e-03f, 2.51476839e-02f, -5.92107587e-02f, 2.20786221e-03f, 5.71187772e-03f, -7.26657435e-02f,
  5.95992878e-02f, -1.74517259e-02f, 6.08672015e-02f, 9.45817530e-02f, -3.07036862e-02f, 4.58098687e-02f, 1.14540286e-01f, 1.17994592e-01f, 1.77144632e-01f, 7.02237412e-02f,
  9.32270363e-02f, -7.69140050e-02f, 7.39772543e-02f, 3.22018862e-02f, -5.24846315e-02f, 4.21764329e-02f, 4.12463732e-02f, 3.12729180e-02f, 1.13252528e-01f, -5.55589981e-02f,
  8.56950209e-02f, 2.52084211e-02f, 1.65134165e-02f, -5.02036698e-02f, 7.10082278e-02f, 2.64968891e-02f, -1.23274475e-01f, -8.16931501e-02f, -9.02462304e-02f, -6.77581355e-02f,
  1.16006862e-02f, 4.89123613e-02f, 1.28755970e-02f, -5.64330909e-03f, 7.06194192e-02f, 3.51145789e-02f, -8.07075948e-02f, -1.12280793e-01f, 5.45539372e-02f, 5.42773493e-02f,
  6.74636383e-03f, 2.00710390e-02f, 5.93156144e-02f, 5.43110296e-02f, 5.24101853e-02f, -2.31849533e-02f, 2.43997741e-02f, 4.04359922e-02f, -2.89204773e-02f, 7.42192119e-02f,
  -2.87926216e-02f, 5.94549105e-02f, 4.86960635e-02f, -5.01133539e-02f, -7.24411681e-02f, 9.38744992e-02f, -9.10324529e-02f, -9.75959599e-02f, -6.31642342e-02f, 6.77215979e-02f,
  -1.05014913e-01f, -3.78785916e-02f, -1.11302864e-02f, 9.15202871e-02f, -3.93420421e-02f, 5.40759712e-02f, -1.60358590e-03f, -4.44260612e-02f, 1.27039235e-02f, -3.37077752e-02f,
  -4.79055662e-03f, -8.51784125e-02f, -5.07610925e-02f, -2.28277240e-02f, -3.63865867e-02f, -7.19816610e-02f, -1.73532777e-03f, -4.64316532e-02f, 8.41258559e-03f, 2.12444291e-02f,
  5.44479042e-02f, -3.47892530e-02f, 4.53386046e-02f, 6.18667193e-02f, -3.05570122e-02f, -4.51812036e-02f, -7.91245028e-02f, 7.32440427e-02f, 3.23672444e-02f, 7.93755334e-03f,
  6.09913319e-02f, -1.96394362e-02f, 2.87119076e-02f, 2.04476211e-02f, 7.04428926e-02f, 9.17274803e-02f, 4.53096852e-02f, 6.15208447e-02f, 5.98598421e-02f, 8.34084861e-03f,
  -2.63659214e-03f, -5.59188426e-04f, 1.56222386e-02f, -3.72628532e-02f, 2.63128877e-02f, -4.00361829e-02f, -6.77988604e-02f, -8.49515870e-02f, -1.67515017e-02f, -1.08437181e-01f,
  -2.88146418e-02f, 4.72909585e-02f, -8.36258009e-02f, -4.09626551e-02f, -3.61117832e-02f, -1.65481921e-02f, -7.55137578e-02f, 2.09884476e-02f, -9.97559950e-02f, -4.79419269e-02f,
  1.42872622e-02f, -5.64461462e-02f, -9.68173593e-02f, -1.32175358e-02f, 1.08591318e-01f, 4.90746200e-02f, 3.36487703e-02f, -1.40798651e-02f, -1.24490693e-01f, -2.70782430e-02f,
  1.24152698e-01f, -2.64655221e-02f, -2.68553514e-02f, -8.07446763e-02f, -6.85778111e-02f, 1.65113285e-02f, -2.97068860e-02f, 7.56816939e-02f, -1.09809831e-01f, -3.19646299e-02f,
  -2.25857254e-02f, 4.95833382e-02f, 7.62859732e-02f, 1.20283164e-01f, 3.69424559e-03f, 2.72542071e-02f, 8.43422934e-02f, -5.31931687e-03f, 1.06568336e-01f, -3.17395553e-02f,
  6.57841116e-02f, -1.01853423e-01f, 5.29706106e-02f, 2.15122495e-02f, 2.17822939e-02f, -4.78824973e-03f, -1.04492456e-02f, -6.14470094e-02f, 3.93520035e-02f, 6.56195357e-02f,
  2.08605733e-03f, 5.99510260e-02f, -5.34553954e-04f, -1.05104662e-01f, -5.83653413e-02f, -5.35295643e-02f, -7.79915601e-03f, 4.20111790e-02f, 1.90696195e-02f, 7.88756683e-02f,
  -4.56215888e-02f, -7.11061712e-03f, -3.40718441e-02f, 5.33477738e-02f, -5.28285932e-03f, -4.41981992e-03f, -4.85534780e-02f, 6.81843748e-03f, -3.14246304e-02f, 2.90536918e-02f,
  1.13403454e-01f, -4.51513864e-02f, 2.49257423e-02f, -1.75056309e-02f, 4.08908129e-02f, 7.28516132e-02f, -3.48134078e-02f, -4.22488749e-02f, 4.47183885e-02f, -8.30001011e-02f,
  3.86933126e-02f, -5.81582263e-02f, 5.74927516e-02f, 8.77329260e-02f, -6.42610341e-02f, -3.38858962e-02f, -3.57588679e-02f, -2.27771290e-02f, 4.30689119e-02f, 4.72019538e-02f,
  -5.22160493e-02f, 3.12006357e-03f, -6.63814470e-02f, 7.03188870e-03f, -4.58343886e-02f, 1.40668536e-02f, -6.33614287e-02f, -5.43441586e-02f, 7.01533705e-02f, 8.32640603e-02f,
  -3.18573602e-02f, 8.40917677e-02f, 2.71420255e-02f, 6.00049645e-02f, -2.67105643e-02f, 2.01713834e-02f, -3.09996828e-02f, 6.96223006e-02f, -5.49692251e-02f, 2.76967492e-02f,
  1.10673599e-01f, 8.23427588e-02f, -3.58724035e-02f, 6.89226091e-02f, 8.39836244e-03f, 7.29063386e-03f, 9.42759290e-02f, -8.70486870e-02f, -9.16453749e-02f, 4.21160422e-02f,
  -3.52236927e-02f, 6.85078278e-02f, 3.17340181e-03f, 3.31976861e-02f, -6.15487024e-02f, 7.33723715e-02f, -1.40418867e-02f, 2.06993837e-02f, -1.66878179e-02f, 6.53881812e-03f,
  5.62629364e-02f, 4.25806344e-02f, -8.36579949e-02f, 4.60488498e-02f, -8.68676454e-02f, -1.77922532e-01f, -2.50854164e-01f, -5.53913340e-02f, 1.38913738e-02f, 1.70903336e-02f,
  -6.27217591e-02f, 2.42426973e-02f, -8.32253918e-02f, -1.09235227e-01f, 1.63461169e-04f, 6.69868067e-02f, -9.18610543e-02f, -4.48403396e-02f, 2.77998708e-02f, -1.04848281e-01f,
  -2.65253372e-02f, 8.43022019e-02f, 4.20404263e-02f, 5.90341911e-02f, -6.76478520e-02f, -3.03878766e-02f, 1.94882587e-01f, 6.23609759e-02f, 5.47876731e-02f, 3.83363664e-02f,
  -5.23641557e-02f, 5.13530560e-02f, -3.96343917e-02f, 5.90895973e-02f, -9.95251723e-03f, -9.44479257e-02f, 3.45027223e-02f, 8.40808917e-03f, 9.65563022e-03f, 6.34922832e-02f,
  -5.38310558e-02f, -1.44518623e-02f, -4.33123857e-02f, -1.45012024e-03f, -3.96302119e-02f, 9.75876972e-02f, 8.72989222e-02f, 1.13246441e-02f, 2.68482827e-02f, 5.49156107e-02f,
  7.23822489e-02f, -7.04968944e-02f, -3.70539501e-02f, -5.03516831e-02f, -7.04399496e-02f, -9.36865062e-02f, 1.94001999e-02f, 6.89343140e-02f, 2.19649859e-02f, 6.25322238e-02f,
  4.44642529e-02f, -5.87424412e-02f, -6.41934515e-04f, -8.06369539e-03f, -1.59390830e-02f, -3.02763917e-02f, 8.20927918e-02f, 4.05211560e-02f, -3.17504369e-02f, 8.64441395e-02f,
  -5.17686419e-02f, -1.81122646e-02f, -2.81075705e-02f, -7.65654221e-02f, -5.98946735e-02f, -1.05521781e-02f, -1.71149988e-02f, 3.61670405e-02f, 1.88955478e-02f, -4.43445891e-02f,
  5.84017262e-02f, -1.99985597e-02f, -8.57645646e-02f, 1.08433713e-03f, 4.39861715e-02f, 9.35771614e-02f, 9.91445413e-05f, -7.49310181e-02f, 5.99988513e-02f, -5.95730655e-02f,
  3.96291651e-02f, 1.53150722e-01f, 1.77397355e-02f, 1.31378928e-03f, -6.78765923e-02f, -7.25502288e-03f, 5.54140583e-02f, 1.35733411e-02f, 2.15356145e-02f, 5.49334101e-02f,
  6.86732903e-02f, 7.44131068e-03f, -2.97587328e-02f, 9.42228138e-02f, 9.01042372e-02f, -2.45480519e-02f, 9.01854336e-02f, -4.25812267e-02f, -6.58346787e-02f, -2.51900461e-02f,
  5.45609929e-02f, -3.46434303e-02f, 2.51829773e-02f, -6.29151752e-03f, 8.32683519e-02f, 5.01232455e-03f, 2.25278107e-03f, 3.68263386e-02f, 7.14837313e-02f, 6.91129416e-02f,
  1.51822716e-03f, 1.54390149e-02f, -5.87579794e-02f, -1.84036773e-02f, -3.70380329e-03f, 1.32749602e-02f, 5.88837564e-02f, -1.90936215e-02f, -8.57920498e-02f, 5.91820702e-02f,
  -4.87229154e-02f, 9.97292325e-02f, -9.36801136e-02f, 5.32186031e-02f, -3.38703841e-02f, -4.08428721e-02f, 1.28340870e-01f, 3.71369272e-02f, -1.02417432e-01f, 1.41107231e-01f,
  -6.10129163e-02f, 1.31879345e-01f, -2.27932259e-02f, 2.86290403e-02f, 1.45079926e-01f, 6.76832646e-02f, 1.17472149e-01f, -1.04002900e-01f, 1.37712345e-01f, -1.74966883e-02f,
  1.00009806e-01f, -2.44990028e-02f, 4.57080267e-03f, -1.83142703e-02f, 8.56849030e-02f, -5.37268519e-02f, 3.48437838e-02f, 4.85734530e-02f, 4.92418371e-02f, 2.35617001e-04f,
  -4.01401706e-02f, -3.03305071e-02f, 3.84982303e-02f, -5.54318987e-02f, 1.75409317e-02f, 6.27668276e-02f, 1.19830454e-02f, -9.15953666e-02f, 1.48352310e-02f, 7.13920295e-02f,
  -9.15828124e-02f, -2.98392046e-02f, 1.78348180e-02f, 4.36600670e-03f, -7.54738227e-02f, -6.18545115e-02f, 6.09932207e-02f, 9.99276787e-02f, 5.81450313e-02f, -2.40272097e-02f,
  -1.62673481e-02f, 2.00878624e-02f, 2.82883830e-02f, -5.56159653e-02f, 8.20459612e-03f, -4.99737300e-02f, -4.89766300e-02f, -3.44099626e-02f, 4.33359668e-02f, 7.96952173e-02f,
  -8.91739726e-02f, 5.42420335e-02f, -5.68753183e-02f, 4.57771197e-02f, -1.87623780e-02f, -3.84191275e-02f, -2.99047735e-02f, 2.16086544e-02f, -9.52407252e-03f, -8.53935033e-02f,
  6.33443287e-03f, 6.47848621e-02f, 6.58750162e-02f, 1.25194630e-02f, 8.69324282e-02f, -8.32016990e-02f, -2.46333219e-02f, -6.45804182e-02f, -7.64080323e-03f, 4.37403023e-02f,
  3.19223218e-02f, 1.13231450e-01f, -9.22362506e-02f, 6.33949637e-02f, -6.63322955e-02f, -3.04356888e-02f, 3.27323712e-02f, -7.53245652e-02f, 8.89293924e-02f, -2.73416401e-03f,
  4.54396121e-02f, -4.32889350e-02f, 2.00150218e-02f, -6.40747696e-02f, 1.06798917e-01f, 9.84108001e-02f, -1.99516658e-02f, 1.59447547e-02f, -3.20049934e-02f, -1.69838611e-02f,
  -2.12512125e-04f, -1.31150177e-02f, 7.48105422e-02f, 7.21780360e-02f, 3.05494815e-02f, 3.37054837e-03f, -1.49876866e-02f, 1.08439393e-01f, 9.07628238e-02f, 1.75551344e-02f,
  9.52122435e-02f, -1.22446045e-02f, -9.17811319e-03f, -1.32016182e-01f, -3.11714187e-02f, 7.80465230e-02f, 6.70589879e-02f, -1.16131671e-01f, -1.12685174e-01f, -7.11103827e-02f,
  -2.75471378e-02f, -1.17866494e-01f, 1.18572354e-01f, 9.76346806e-02f, -1.67218316e-02f, 9.47268009e-02f, 2.68319584e-02f, 9.76616610e-03f, 3.62459682e-02f, -4.96122614e-03f,
  -1.96960457e-02f, 7.39350244e-02f, 6.98800609e-02f, 8.23793635e-02f, -1.23578683e-02f, -7.19000846e-02f, -1.07062355e-01f, 1.26129221e-02f, -7.05680847e-02f, -3.50677408e-02f,
  6.13499396e-02f, 1.00800231e-01f, 9.35331881e-02f, -3.08038276e-02f, 7.57761225e-02f, 9.78724100e-03f, -5.34754321e-02f, 4.21819948e-02f, 7.33645260e-02f, -7.12723704e-03f,
  5.06021678e-02f, 6.07665516e-02f, 5.76323308e-02f, 1.89634133e-02f, 3.51575240e-02f, 3.37223671e-02f, -3.16810608e-02f, 7.70338476e-02f, -4.18975726e-02f, 8.29063281e-02f,
  3.77108939e-02f, -9.61418301e-02f, -1.53049855e-02f, -1.33172750e-01f, -9.84680131e-02f, -9.01615396e-02f, 4.74537909e-03f, -7.84466416e-02f, -1.03879973e-01f, 3.84756317e-03f,
  7.28500187e-02f, -2.36585885e-02f, -1.83360034e-03f, -6.53304085e-02f, 4.68547866e-02f, -3.84255648e-02f, 2.06834674e-02f, -6.71456754e-02f, -7.45235160e-02f, 2.91461144e-02f,
  -7.51764700e-02f, 4.30847798e-03f, 7.98093081e-02f, -4.27373722e-02f, -4.57528271e-02f, 8.08249712e-02f, 1.01939924e-01f, 7.67300501e-02f, -1.02256238e-01f, -4.36859243e-02f,
  7.55152032e-02f, 3.83369401e-02f, -2.68459339e-02f, -7.37433434e-02f, 7.00716302e-03f, -1.64257176e-02f, -7.90999830e-02f, -7.56111443e-02f, -5.84682859e-02f, 9.02480446e-04f,
  7.07270652e-02f, 1.37325851e-02f, -1.58171076e-02f, 6.74790069e-02f, 4.32107709e-02f, 8.99618715e-02f, 5.45289367e-02f, 3.81325074e-02f, -8.14894736e-02f, -3.22465412e-02f,
  -6.01153784e-02f, -5.57443164e-02f, -5.64524122e-02f, -6.07155599e-02f, -9.09634903e-02f, 8.56524110e-02f, 2.47743889e-03f, -1.31816521e-01f, -2.39400435e-02f, -6.72342703e-02f,
  -9.34744328e-02f, -5.88326566e-02f, -2.94506084e-02f, 4.27677631e-02f, -9.78931636e-02f, -3.28531154e-02f, 7.90892355e-03f, -3.19739059e-02f, 2.31457651e-02f, 3.90201844e-02f,
  -1.34880915e-01f, 1.64586991e-01f, -1.76355004e-01f, -1.99609116e-01f, -2.08637081e-02f, -1.58139062e-03f, -1.17243715e-01f, -3.79336104e-02f, -3.68706509e-02f, 1.28138691e-01f,
  -4.54405546e-02f, 4.46144603e-02f, 5.59201017e-02f, -2.78521571e-02f, -6.35545105e-02f, 9.17964503e-02f, -1.21680290e-01f, -3.75339314e-02f, -2.49196682e-02f, 8.49575549e-03f,
  -5.87562211e-02f, 1.33950813e-02f, 2.63068974e-02f, 3.65011878e-02f, -1.77293941e-01f, -1.41615167e-01f, -8.54845941e-02f, -5.16551025e-02f, -1.53760403e-01f, 2.57689767e-02f,
  -1.56785563e-01f, -1.48792431e-01f, -5.27400076e-02f, -1.06534295e-01f, -1.30833194e-01f, -6.40510023e-02f, -5.10265604e-02f, -7.98941776e-02f, -3.93141210e-02f, 2.35003214e-02f,
  -5.14801443e-02f, 8.05453882e-02f, -5.59322983e-02f, -2.41022147e-02f, 3.37730348e-02f, -6.34100363e-02f, -6.83239996e-02f, -9.24981385e-03f, -5.23168631e-02f, -6.62317201e-02f,
  -3.86678465e-02f, 9.06833634e-03f, 4.95842751e-03f, 6.34167269e-02f, 5.51139079e-02f, -1.08767070e-01f, 2.50956900e-02f, 1.97556894e-02f, -4.06210348e-02f, -5.54969870e-02f,
  7.27720931e-02f, 2.34152954e-02f, -5.96266054e-02f, -4.12855335e-02f, 1.00089554e-02f, -8.76417980e-02f, 1.82084590e-02f, 2.35103108e-02f, -7.46785179e-02f, -5.08135231e-03f,
  -2.57819910e-02f, -8.64643678e-02f, 5.52713238e-02f, -3.00322548e-02f, -8.32916349e-02f, -3.99946682e-02f, 1.73687823e-02f, 5.49202412e-02f, 5.22029474e-02f, 4.31382656e-02f,
  1.26765892e-02f, -2.44638212e-02f, 2.76449360e-02f, 7.96666518e-02f, 1.52185746e-02f, -5.77864163e-02f, 1.23616252e-02f, 7.93143362e-02f, 7.20080510e-02f, -4.11186591e-02f,
  -1.13167651e-01f, -1.05072752e-01f, -8.63771439e-02f, -1.51985604e-02f, -9.05222073e-02f, -2.08158959e-02f, -7.40273446e-02f, -5.35034500e-02f, -5.91718475e-04f, -4.91141854e-03f,
  -6.23051040e-02f, 3.75035927e-02f, -5.46724834e-02f, 2.88276915e-02f, -1.40027469e-02f, 4.55849979e-04f, 4.09989199e-03f, 6.88204691e-02f, -3.03184595e-02f, 4.23383527e-02f,
  -7.40371048e-02f, -6.69650063e-02f, 6.32818416e-02f, 4.05539125e-02f, 7.94034898e-02f, -1.04310485e-02f, -2.71602124e-02f, -4.69252281e-02f, -3.01659927e-02f, -1.98890790e-02f,
  4.71270084e-02f, 3.57330665e-02f, 2.03404069e-01f, -8.93919170e-02f, 1.26320701e-02f, 1.43053085e-01f, 4.27509882e-02f, -1.32119572e-02f, 2.09972337e-02f, -1.13651022e-01f,
  1.98971126e-02f, 5.52140689e-03f, 7.05224723e-02f, -8.67011771e-02f, 7.23991171e-02f, 9.28933844e-02f, -9.29080024e-02f, 1.67640988e-02f, 6.57945722e-02f, -7.19246194e-02f,
  2.32251287e-02f, -1.37441903e-01f, -1.11113302e-02f, -1.21544644e-01f, -5.74572980e-02f, -7.17522427e-02f, -1.37044474e-01f, 1.12988293e-01f, -5.05494960e-02f, 7.30214342e-02f,
  4.60464247e-02f, 2.03514230e-02f, 2.20959000e-02f, -2.04427540e-02f, 7.24698082e-02f, -6.27398938e-02f, 3.95116434e-02f, -4.42144535e-02f, 7.03193173e-02f, -4.93411981e-02f,
  -5.45339920e-02f, -1.36489747e-02f, 4.33640145e-02f, 3.12561020e-02f, -6.47020340e-02f, 2.71302219e-02f, 7.43424073e-02f, -1.90475471e-02f, -5.68040311e-02f, 4.12283652e-02f,
  -2.07198667e-03f, 7.12114275e-02f, 4.67200875e-02f, -8.17497522e-02f, -1.72873493e-02f, 3.30546945e-02f, 4.77775633e-02f, 5.27803674e-02f, -1.03393622e-01f, -8.35139081e-02f,
  -1.28396265e-02f, 2.03155372e-02f, 2.68019065e-02f, -6.81473687e-03f, 6.48964271e-02f, -6.63133897e-03f, 2.11322699e-02f, -4.44793589e-02f, -1.96429808e-02f, -1.53203085e-02f,
  1.16166370e-02f, 1.15008699e-02f, -4.00525033e-02f, -3.21035720e-02f, -1.74873229e-02f, 4.57063168e-02f, -4.19122353e-02f, 4.57742810e-02f, -3.02525647e-02f, 4.62002493e-02f,
  1.73831806e-02f, 1.05143655e-02f, -9.90171060e-02f, -2.06847060e-02f, 1.10682920e-02f, 4.67849895e-02f, 4.93785068e-02f, 4.81402315e-03f, -2.92140357e-02f, -4.86993752e-02f,
  -7.20229074e-02f, 1.85154732e-02f, -2.58654263e-02f, 5.70008121e-02f, 5.41591495e-02f, 6.33537844e-02f, -5.95279895e-02f, -4.63081412e-02f, -1.74594223e-02f, -4.10040729e-02f,
  -5.63041829e-02f, -1.73491575e-02f, 5.95316924e-02f, 3.71668376e-02f, -5.17583564e-02f, -3.46034445e-04f, -9.60436165e-02f, 6.54032975e-02f, -4.25761230e-02f, -7.88678066e-04f,
  -8.95088241e-02f, 2.89194155e-02f, -1.97692513e-02f, -9.44320932e-02f, 4.21043448e-02f, -4.37925979e-02f, -5.39719760e-02f, 2.90934164e-02f, -5.23195835e-04f, 6.19091932e-03f,
  1.59638792e-01f, 2.85489801e-02f, -7.48140505e-03f, -5.79890609e-02f, -3.39424387e-02f, -1.15634695e-01f, -1.09741911e-01f, -7.84331039e-02f, 1.50109390e-02f, -1.28001302e-01f,
  9.42176431e-02f, -4.51306887e-02f, -6.36109337e-02f, 1.55967260e-02f, -5.24850562e-02f, 9.66466144e-02f, -5.75198010e-02f, 3.07567753e-02f, 9.34134573e-02f, 5.23981750e-02f,
  4.95641977e-02f, -3.41176763e-02f, 1.15003519e-01f, -5.58492877e-02f, -8.84235487e-04f, 1.15858698e-02f, 2.72937808e-02f, 1.43655762e-02f, -8.98721665e-02f, -6.33305311e-03f,
  6.56900555e-02f, 3.11672036e-02f, 4.94184485e-03f, -6.48488328e-02f, -2.30282918e-02f, -3.30291055e-02f, 5.51132783e-02f, 7.08177239e-02f, 7.69002959e-02f, 4.89661507e-02f,
  -6.66176006e-02f, -4.89057824e-02f, -5.84165342e-02f, 7.42003247e-02f, -5.00914119e-02f, 5.57587901e-03f, -8.75227991e-03f, -6.84192032e-02f, 1.72817763e-02f, -3.51633355e-02f,
  -7.47483596e-03f, -4.26466614e-02f, 6.24459237e-02f, 3.58798914e-03f, -4.39036451e-02f, -7.47891795e-03f, -2.88425628e-02f, 5.45001589e-02f, -4.76920307e-02f, 3.39782145e-03f,
  8.52305740e-02f, 3.23506892e-02f, 8.12719464e-02f, 7.55503029e-02f, 7.96168521e-02f, -3.02914567e-02f, 1.92789901e-02f, 5.14070280e-02f, 7.35680312e-02f, 7.19570508e-03f,
  -1.01093166e-01f, 9.64763835e-02f, 4.69601192e-02f, -1.40800830e-02f, 7.32982233e-02f, 7.01280776e-04f, -8.90503973e-02f, -2.97384225e-02f, -7.20151886e-02f, 3.06410412e-03f,
  -7.52124190e-02f, 6.74656108e-02f, 7.41980672e-02f, 5.98086454e-02f, -6.05671406e-02f, -1.89818535e-02f, 6.59716427e-02f, -5.38837202e-02f, -7.08196685e-02f, -4.15445194e-02f,
  -6.81389645e-02f, 7.29047656e-02f, -4.10708487e-02f, -4.44548652e-02f, -5.57201840e-02f, -6.57146471e-03f, -8.26316327e-02f, 5.87278903e-02f, -8.96604210e-02f, -6.99227899e-02f,
  3.31566781e-02f, 3.67558524e-02f, 8.23356807e-02f, -8.41426775e-02f, 3.52184512e-02f, -6.00628853e-02f, -3.02031171e-03f, 2.59363074e-02f, 8.42039287e-02f, 9.11313295e-02f,
  9.49701741e-02f, 4.70037907e-02f, 7.68947005e-02f, 2.26818323e-02f, -8.20306093e-02f, 6.69895783e-02f, -6.56105056e-02f, 5.55998087e-02f, -6.11523837e-02f, 3.16129588e-02f,
  1.33741185e-01f, -1.69587404e-01f, 1.40924364e-01f, 9.60590392e-02f, 1.07267678e-01f, 7.19578266e-02f, 1.54873878e-01f, 1.01706564e-01f, 9.91621390e-02f, -1.58787459e-01f,
  -2.72521619e-02f, -2.15314075e-01f, -7.12922886e-02f, 6.40014634e-02f, 1.17975334e-02f, 4.66858335e-02f, 4.18184400e-02f, -5.03124446e-02f, 9.04266983e-02f, -6.19884059e-02f,
  6.99976310e-02f, 6.06070086e-02f, 4.40845871e-03f, -8.19045752e-02f, 6.56520128e-02f, 1.65159591e-02f, -3.42443027e-02f, -4.95124310e-02f, -5.07884808e-02f, -2.74701025e-02f,
  -4.59426567e-02f, 5.70382103e-02f, 4.45753410e-02f, 1.08855655e-02f, -6.05225451e-02f, -1.06153847e-03f, -5.23108169e-02f, 4.18974012e-02f, -1.89277332e-03f, 4.96220961e-02f,
  -9.99303088e-02f, 7.17663467e-02f, 5.24178632e-02f, 7.13314414e-02f, 3.16352816e-03f, -4.14149687e-02f, -2.79001724e-02f, -5.07430825e-03f, 4.27258462e-02f, -3.05165946e-02f,
  3.88195664e-02f, -7.95860738e-02f, 1.36234146e-02f, 2.66537610e-02f, 1.08337998e-01f, -2.05055345e-03f, 5.65459132e-02f, -7.28270710e-02f, 3.77850123e-02f, -6.59808889e-02f,
  -6.76658899e-02f, -2.97693741e-02f, -3.96176279e-02f, -1.35342907e-02f, 7.53576905e-02f, 9.00577158e-02f, -2.84891855e-02f, -4.02926765e-02f, 6.37940466e-02f, 7.15962872e-02f,
  -4.76936251e-02f, -2.43546572e-02f, -4.15360928e-02f, 4.21422906e-03f, -1.57239791e-02f, 3.64432372e-02f, -9.83896479e-02f, -8.40895623e-03f, 7.88590237e-02f, -4.47224490e-02f,
  3.51627320e-02f, 3.87131944e-02f, -1.69587135e-02f, 4.94509339e-02f, -4.23837975e-02f, 8.99371654e-02f, -3.14998589e-02f, 1.20442752e-02f, 3.64233665e-02f, -7.44708851e-02f,
  -1.98655069e-01f, -2.18176931e-01f, -1.05472043e-01f, 2.95842476e-02f, -4.77163978e-02f, -1.23575173e-01f, -5.87053709e-02f, -4.64043170e-02f, 3.57914828e-02f, 1.59378871e-02f,
  3.03557143e-02f, -3.28043550e-02f, -7.14866221e-02f, -6.15047291e-02f, -7.26189837e-02f, 7.58116543e-02f, 2.84953117e-02f, 1.10587934e-02f, -7.08043575e-02f, -5.17111942e-02f,
  6.04103357e-02f, 3.09127197e-02f, -4.71499655e-03f, 7.50443265e-02f, -6.93449453e-02f, -8.77006873e-02f, -6.82439804e-02f, -9.82004032e-02f, 1.72373429e-02f, -6.67341501e-02f,
  -4.45158891e-02f, -8.45791176e-02f, 1.27490044e-01f, -1.39957845e-01f, -7.88538065e-03f, -2.99731772e-02f, -7.70953149e-02f, -3.85108367e-02f, -8.59920233e-02f, 9.11390223e-03f,
  -1.26535539e-02f, 4.57280949e-02f, 5.09118326e-02f, -4.94702719e-02f, 5.35446070e-02f, 4.12010290e-02f, -3.72153185e-02f, -7.31625557e-02f, 2.13968903e-02f, -1.53593436e-01f,
  3.10151167e-02f, -9.83651951e-02f, 3.66493687e-02f, -1.27040446e-01f, 2.49328953e-03f, -1.12992965e-01f, -2.63927039e-02f, -5.33498228e-02f, -8.00322741e-02f, 6.45409897e-02f,
  -9.53267813e-02f, -4.26328778e-02f, -8.98209140e-02f, 4.57262769e-02f, 7.87379779e-03f, 4.10881564e-02f, 8.57753605e-02f, 6.55148849e-02f, -4.78166901e-02f, -6.98579103e-02f,
  -1.80209093e-02f, 5.92579655e-02f, 3.74956578e-02f, -8.22715908e-02f, -5.71146514e-03f, 1.42193269e-02f, 2.54453737e-02f, -3.49763669e-02f, 7.80328065e-02f, 8.41118246e-02f,
  8.27525854e-02f, -7.11375400e-02f, -1.14815414e-03f, 1.67054683e-02f, -7.46282414e-02f, 5.27028041e-03f, 2.35518208e-03f, 1.10316604e-01f, -5.59891537e-02f, 3.55603024e-02f,
  3.50361131e-02f, -7.53654093e-02f, -3.85030359e-02f, 2.79759839e-02f, 7.81650189e-03f, -4.26777564e-02f, -7.51889497e-02f, 4.68147285e-02f, -2.78003118e-03f, -2.37314906e-02f,
  8.37200135e-02f, -7.47983977e-02f, 5.25413491e-02f, 6.74832687e-02f, 1.00901006e-02f, -5.20909131e-02f, -5.61752841e-02f, -4.88970429e-03f, 5.43975420e-02f, -2.54281014e-02f,
  -9.33444574e-02f, 2.73604505e-02f, 3.66888288e-03f, -5.44953048e-02f, -2.28343357e-04f, -4.46765907e-02f, -6.86857551e-02f, 7.78856054e-02f, 1.95272639e-02f, 8.44135042e-03f,
  -8.71635079e-02f, -2.50982610e-03f, 5.08093089e-02f, -6.68212399e-03f, -5.51145300e-02f, 4.82964031e-02f, -7.10122734e-02f, -8.13982636e-02f, 7.52595440e-02f, 7.56836832e-02f,
  4.64713834e-02f, -1.36324065e-02f, 6.17095940e-02f, 3.02194767e-02f, 4.24047224e-02f, 1.01335654e-02f, 2.51737293e-02f, -6.10706257e-03f, -1.30699342e-02f, -3.65971960e-02f,
  -8.47797841e-02f, -1.23178652e-02f, 4.10853922e-02f, -1.11573217e-02f, 3.21195759e-02f, -4.95939516e-02f, -5.53998388e-02f, -5.35377525e-02f, 3.00918873e-02f, 4.25268300e-02f,
  1.11459553e-01f, -3.79635021e-02f, -1.62941530e-01f, -1.48762405e-01f, -1.15771145e-01f, 8.53649080e-02f, -5.32776825e-02f, -3.74539159e-02f, -7.35929310e-02f, 1.44769788e-01f,
  -3.56620513e-02f, -4.21097949e-02f, 2.04238389e-02f, -4.35162485e-02f, -2.28685178e-02f, 7.84160569e-03f, 4.95464075e-03f, -5.71714193e-02f, -9.92114320e-02f, 4.45387736e-02f,
  -1.87829398e-02f, -2.50812769e-02f, -5.99272139e-02f, 5.49243949e-02f, -1.27874259e-02f, 1.44229019e-02f, 2.58509703e-02f, -1.26797423e-01f, -7.90141076e-02f, -1.10392302e-01f,
  -7.32851923e-02f, 3.05188540e-02f, -1.54756457e-02f, 1.96212232e-02f, -2.45909113e-02f, 8.48525390e-02f, -5.16696461e-02f, -2.70711910e-02f, -5.53021207e-02f, -3.73113304e-02f,
  -2.71718856e-03f, 4.01766151e-02f, -2.17442308e-02f, -4.77958135e-02f, 6.51290640e-02f, 3.59823257e-02f, -5.10901362e-02f, -8.39900896e-02f, -3.31063755e-02f, -6.48294017e-02f,
  -1.87875386e-02f, -3.05841062e-02f, 4.31142412e-02f, 6.07727235e-03f, 3.40897143e-02f, -3.08294613e-02f, -3.54460515e-02f, -9.30205360e-02f, -6.25327826e-02f, -9.25105810e-02f,
  6.70498312e-02f, -5.59376972e-03f, 4.15181592e-02f, -7.40132332e-02f, 4.19001989e-02f, 4.27324884e-02f, -6.28640968e-03f, -7.38699734e-02f, 1.88437328e-02f, -5.26280776e-02f,
  1.41534144e-02f, 1.93075370e-02f, -8.55309796e-03f, -3.94213162e-02f, -2.74322461e-02f, -4.77533750e-02f, 1.55707616e-02f, 5.95764779e-02f, 3.31071415e-03f, -4.10429500e-02f,
  -7.05723241e-02f, 4.90521081e-02f, 2.25436199e-03f, 6.58298582e-02f, -1.03052910e-02f, 3.86062153e-02f, 5.66056445e-02f, 6.16593054e-03f, -6.89708143e-02f, -6.70806244e-02f,
  5.74061042e-03f, 1.01768024e-01f, -4.09433804e-02f, 9.59957391e-02f, 3.83003149e-03f, 4.00457792e-02f, -1.19845653e-02f, -1.45609956e-02f, -1.52316336e-02f, 7.06340596e-02f,
  4.33070362e-02f, -3.34649533e-02f, -3.53965946e-02f, -3.54305208e-02f, -8.54858980e-02f, -1.63264349e-02f, 6.80387616e-02f, 5.36057539e-02f, 2.85279173e-02f, -7.08099604e-02f,
  5.54490015e-02f, -4.11984771e-02f, -4.43694443e-02f, -5.70846982e-02f, 2.82236915e-02f, 3.02792154e-03f, 6.69392869e-02f, -5.35490774e-02f, 6.80828169e-02f, 4.78671081e-02f,
  2.37856749e-02f, 2.05880851e-01f, 2.43169099e-01f, 1.84042662e-01f, 8.40717554e-02f, 4.16887812e-02f, 7.75039420e-02f, 1.09377690e-01f, 3.50017816e-01f, -3.63082588e-02f,
  -1.37463868e-01f, 1.23990044e-01f, -9.54672024e-02f, 1.10760003e-01f, 1.04483506e-02f, -6.51080161e-02f, 5.25787212e-02f, -1.04229543e-02f, 1.42980844e-01f, -3.19645996e-03f,
  1.56921577e-02f, -1.97367594e-01f, -8.75200406e-02f, -7.67633170e-02f, -6.43198863e-02f, 3.72616691e-03f, -2.28863493e-01f, -1.46093860e-01f, 3.65779595e-03f, 3.25320400e-02f,
  3.64635624e-02f, 1.29131317e-01f, -5.68740703e-02f, 1.04876675e-01f, 4.96476665e-02f, 5.12927584e-02f, 7.27835298e-02f, -7.51715973e-02f, -1.59868859e-02f, 2.88592074e-02f,
  -3.36518101e-02f, -5.93656823e-02f, 6.09872900e-02f, -8.28529075e-02f, 2.76071634e-02f, -1.17419930e-02f, 9.79006961e-02f, 7.12724105e-02f, 1.17774261e-02f, 1.01220170e-02f,
  -3.50420177e-02f, 3.96954864e-02f, -3.63201387e-02f, 1.58135016e-02f, 3.22059542e-02f, 1.03874274e-01f, 2.49645039e-02f, 6.69958219e-02f, 4.34397198e-02f, 4.40709516e-02f,
  5.95274866e-02f, -8.86078365e-03f, -8.90850499e-02f, -2.53614690e-02f, 3.20024937e-02f, 3.45798731e-02f, -2.96180490e-02f, 3.18606272e-02f, -4.11261659e-04f, -1.90542564e-02f,
  1.89768020e-02f, -1.75125096e-02f, 5.94469532e-02f, 1.07775867e-01f, 7.67502412e-02f, -5.13574108e-03f, -1.32900141e-02f, -1.94610227e-02f, 1.17514571e-02f, -9.20088664e-02f,
  -1.69028472e-02f, -5.84777817e-02f, -5.50048687e-02f, -1.67002920e-02f, 4.11759838e-02f, 1.89048680e-03f, 4.01448607e-02f, -3.88852805e-02f, -3.95455696e-02f, 4.01699059e-02f,
  1.03423998e-01f, 9.29562524e-02f, 6.10541739e-02f, 2.18125507e-02f, 4.37841341e-02f, -3.41751054e-02f, -4.65848809e-03f, -1.80327836e-02f, 2.18646042e-03f, 4.22562584e-02f,
  1.03142776e-01f, -5.04734106e-02f, 4.46721055e-02f, 3.86189930e-02f, -5.88206649e-02f, 2.71332599e-02f, -6.83612451e-02f, -2.30248179e-03f, 8.27644244e-02f, 8.25440604e-03f,
  -6.96610510e-02f, 5.96751757e-02f, 4.24138419e-02f, 5.49758524e-02f, 1.87964402e-02f, -7.34178722e-02f, 4.79014479e-02f, 4.10782583e-02f, -3.36152269e-03f, 4.79887798e-02f,
  -4.65099737e-02f, 5.60844913e-02f, 1.56761296e-02f, -6.46094680e-02f, -1.35854021e-01f, 6.69525862e-02f, -9.87191871e-02f, 9.39104110e-02f, 9.80605371e-03f, 1.42603004e-02f,
  3.22757810e-02f, -9.66483131e-02f, -2.07916833e-02f, 2.13384721e-02f, 1.96978450e-02f, 7.78894052e-02f, 1.13627382e-01f, 2.05161721e-02f, 1.99002326e-02f, -6.61650747e-02f,
  -5.46272844e-02f, -1.69275001e-01f, -9.56366062e-02f, -8.83198306e-02f, -6.94879889e-02f, -2.81188264e-02f, -1.45437375e-01f, -1.46788806e-01f, -2.56514791e-02f, -5.97594418e-02f,
  2.59604305e-02f, -5.59371449e-02f, -2.65211407e-02f, 2.61800289e-02f, 1.88051295e-02f, 7.90999457e-02f, -5.08424789e-02f, -7.24479035e-02f, 6.07703179e-02f, 2.86978390e-02f,
  -2.60649044e-02f, -6.72146380e-02f, 4.42979345e-03f, 1.62033234e-02f, -9.00047049e-02f, 6.96399659e-02f, 2.40854267e-02f, -5.31500690e-02f, 2.79000960e-02f, -6.64085299e-02f,
  9.49847475e-02f, 2.31560059e-02f, -3.31404582e-02f, 8.49638432e-02f, 9.42923799e-02f, -6.80307001e-02f, 5.09999227e-03f, -2.57490501e-02f, -1.43372845e-02f, 8.07124525e-02f,
  4.95339520e-02f, 6.81868270e-02f, 2.84261443e-02f, -6.38846606e-02f, -8.52436200e-02f, 5.61750084e-02f, 3.70046161e-02f, 1.30445287e-02f, -6.98384224e-03f, -9.08045247e-02f,
  -7.59703964e-02f, -5.88194504e-02f, 1.89557336e-02f, 9.73375514e-02f, -1.16831400e-02f, 3.76767176e-03f, -5.56402132e-02f, 3.12907211e-02f, 4.20084931e-02f, 2.35270727e-02f,
  -1.01917032e-02f, 7.88816065e-02f, 3.74488482e-05f, -5.14176348e-03f, -6.30781874e-02f, -7.72502124e-02f, -4.01180498e-02f, -7.58629516e-02f, 8.51359293e-02f, -4.18296782e-03f,
  6.40454749e-03f, -1.76735444e-03f, 2.10976116e-02f, -8.99482891e-02f, -5.05119823e-02f, -7.23824352e-02f, 5.14314568e-04f, -3.96416262e-02f, -9.07923467e-03f, -1.12077100e-02f,
  -2.74587353e-03f, 3.50159616e-03f, 1.00784292e-02f, -5.47423512e-02f, 3.00943628e-02f, -5.31749427e-02f, -6.53775111e-02f, 3.68035026e-02f, -2.31532287e-02f, -6.82115555e-02f,
  -5.04509546e-02f, 2.36084927e-02f, 9.46298055e-03f, -3.60257402e-02f, 2.11444944e-02f, 3.55442539e-02f, -4.57053855e-02f, -4.59772721e-02f, 1.05237216e-03f, -5.56835718e-02f,
  -1.23906448e-01f, 1.71958998e-01f, -3.72106582e-02f, 8.15098453e-03f, -1.60043929e-02f, 2.48404797e-02f, -1.56509638e-01f, 1.73509687e-01f, -2.43057236e-02f, -7.34169260e-02f,
  -3.93663757e-02f, -6.73949048e-02f, 6.97429553e-02f, -5.51473275e-02f, -7.03697279e-02f, 1.38387725e-01f, -4.49632183e-02f, -1.83248997e-01f, 2.59231441e-02f, -6.07146621e-02f,
  -8.47698003e-02f, -7.46411085e-03f, 4.26922739e-02f, 1.36870474e-01f, -1.16411410e-01f, -7.12225810e-02f, 2.51180213e-02f, 1.80536620e-02f, -1.18600070e-01f, 7.70463347e-02f,
  -4.28771339e-02f, 1.01763122e-01f, -1.27189644e-02f, -3.36047858e-02f, -3.50420885e-02f, -7.55468160e-02f, -7.82013685e-02f, -6.52351752e-02f, -1.00542538e-01f, -2.35722195e-02f,
  -9.21486095e-02f, 7.06385374e-02f, -4.39732037e-02f, 7.53636211e-02f, 2.45069414e-02f, -3.85049991e-02f, -3.29146348e-03f, -4.31966633e-02f, 4.12198678e-02f, 6.55860156e-02f,
  6.78002834e-02f, -1.57541074e-02f, -1.81518700e-02f, -2.68058032e-02f, 6.25115931e-02f, 2.55598277e-02f, -3.94957699e-02f, -7.21056312e-02f, 4.80896086e-02f, 1.41439424e-03f,
  -1.15336403e-02f, -1.17816068e-01f, 6.71598539e-02f, 6.70319498e-02f, -3.60794626e-02f, -4.88899536e-02f, -5.60931526e-02f, 2.05208715e-02f, 5.80583699e-03f, 4.69372794e-02f,
  -2.37769205e-02f, 1.28192335e-01f, -6.25179335e-02f, -7.61424601e-02f, -3.60524654e-02f, -1.11060748e-02f, 4.02463414e-02f, -4.79217917e-02f, 4.15073372e-02f, 2.55757757e-02f,
  3.13444622e-02f, 4.68564890e-02f, 8.48016143e-02f, 2.84193195e-02f, -5.08582331e-02f, -8.04821551e-02f, 5.88542745e-02f, 2.72194482e-02f, -2.73149274e-02f, -4.36864235e-02f,
  9.24062058e-02f, 7.26572573e-02f, 6.54962063e-02f, 7.55309537e-02f, -5.48338555e-02f, 6.11820184e-02f, -3.53258438e-02f, 4.87404689e-02f, -5.30017614e-02f, 1.05553426e-01f,
  -5.82859069e-02f, -1.05411835e-01f, -3.82789746e-02f, 2.83156950e-02f, -5.33038825e-02f, 1.18608311e-01f, 1.73764229e-02f, -9.98625681e-02f, -1.19953886e-01f, -1.11714080e-02f,
  9.24527496e-02f, -5.52543104e-02f, -9.76248682e-02f, -9.76144448e-02f, -8.95477533e-02f, -1.71038825e-02f, -4.42184173e-02f, 3.65448967e-02f, -3.63032930e-02f, 9.00753811e-02f,
  1.19853020e-01f, -6.14209753e-03f, -2.39883140e-01f, -1.87053263e-01f, -1.34018928e-01f, -2.18782604e-01f, -3.16097319e-01f, -1.56981856e-01f, -4.08863723e-02f, 4.62412485e-04f,
  -1.37790060e-02f, 7.72356242e-02f, 1.22066401e-01f, -2.64889657e-01f, -8.82142633e-02f, 5.59013337e-02f, -2.58438140e-01f, -1.19256198e-01f, 6.62681982e-02f, -1.22084327e-01f,
  -1.06797665e-01f, -5.16241677e-02f, -1.74309224e-01f, -5.90544827e-02f, -5.71653768e-02f, -1.64201092e-02f, 6.77302480e-02f, 6.03092695e-03f, -1.41900256e-01f, 2.24806946e-02f,
  6.98873028e-03f, -5.84064536e-02f, 2.57092379e-02f, -7.92163238e-02f, -1.72853079e-02f, 6.39940202e-02f, 4.04531918e-02f, 6.36106804e-02f, 4.44576629e-02f, -3.95248048e-02f,
  1.04438402e-01f, 1.50420493e-03f, 3.09755970e-02f, 6.81517720e-02f, 7.58041395e-03f, -5.64338081e-02f, 2.53236499e-02f, 2.88744736e-02f, -5.14797904e-02f, 6.73368499e-02f,
  6.01663161e-03f, -9.31039453e-03f, 5.17786965e-02f, 8.75929371e-02f, -2.20085252e-02f, -6.66973442e-02f, -1.62370168e-02f, 4.34690192e-02f, -3.12246438e-02f, 8.63430928e-03f,
  8.39868635e-02f, -3.31811942e-02f, -1.03867511e-04f, 6.04730062e-02f, 3.73220183e-02f, 3.49671990e-02f, -3.31298485e-02f, 3.37555259e-02f, -4.69358191e-02f, -6.41619042e-02f,
  3.10696326e-02f, 3.21500003e-02f, -4.43809442e-02f, -5.57039566e-02f, -2.86194533e-02f, -4.91965339e-02f, 4.01277244e-02f, 1.65271517e-02f, -3.53398025e-02f, -4.35242839e-02f,
  -5.33060962e-03f, -6.99748322e-02f, 8.02259669e-02f, 5.36203422e-02f, 1.49224708e-02f, -5.66298142e-02f, 4.75430638e-02f, 2.36501694e-02f, 4.75466140e-02f, 2.57865973e-02f,
  -4.98298034e-02f, -7.64902756e-02f, -4.73358259e-02f, -2.72154491e-02f, 6.08019382e-02f, 1.55386589e-02f, -5.92098571e-02f, -3.21211480e-02f, -1.23675674e-01f, -1.04188383e-01f,
  2.22010799e-02f, -6.87354207e-02f, 3.59759517e-02f, 5.04243746e-02f, -8.37390721e-02f, -9.96585116e-02f, 8.27965140e-03f, 4.65956293e-02f, -4.96618971e-02f, -3.14039215e-02f,
  2.56277202e-03f, 6.26597032e-02f, 6.28978806e-03f, -5.18484153e-02f, 2.56386511e-02f, -1.69276930e-02f, 1.91216879e-02f, 5.86914923e-03f, -4.76687327e-02f, -5.15793897e-02f,
  -1.83194559e-02f, -7.25341514e-02f, -1.33019999e-01f, 3.08471136e-02f, -1.03360325e-01f, 9.72115621e-02f, 1.54893637e-01f, -4.96356711e-02f, 1.19566508e-02f, 5.02221994e-02f,
  2.20459960e-02f, 2.73656566e-02f, 8.46079290e-02f, 9.50335786e-02f, 5.82902431e-02f, 3.39339338e-02f, 1.60232801e-02f, 6.35788366e-02f, -3.96373644e-02f, 8.54296684e-02f,
  8.57015550e-02f, 7.14986697e-02f, 7.24759996e-02f, 2.92022228e-02f, -8.18221048e-02f, -3.23035307e-02f, -3.85452583e-02f, -1.85628366e-02f, -8.19831043e-02f, 2.75791879e-03f,
  5.30638434e-02f, -6.13712100e-03f, 7.03483745e-02f, -5.85558899e-02f, -3.15596461e-02f, 3.32322009e-02f, 9.39744040e-02f, -6.44842535e-02f, 7.67257065e-02f, -6.53133541e-02f,
  6.44128099e-02f, -6.29106984e-02f, 1.21037783e-02f, -5.62645867e-02f, -8.37003514e-02f, -7.28032589e-02f, -2.73817894e-03f, -1.00310087e-01f, -7.42657036e-02f, -5.33127859e-02f,
  5.84592856e-02f, 3.25028300e-02f, -5.19779250e-02f, -1.68198533e-02f, -4.72221598e-02f, -5.68987429e-02f, 5.74474297e-02f, 7.38702193e-02f, -3.15993018e-02f, 3.98985390e-03f,
  -1.00526527e-01f, 7.32145533e-02f, 2.44221427e-02f, -3.32794040e-02f, -7.62456059e-02f, -5.23338281e-02f, -4.44170944e-02f, 7.82800466e-02f, -9.19352937e-03f, 6.00344315e-02f,
  7.84968678e-03f, 3.18959132e-02f, 6.16818517e-02f, 2.69229710e-02f, -1.17128959e-03f, -1.89841520e-02f, 4.28645946e-02f, -3.06521822e-02f, 8.30302835e-02f, -1.21432124e-03f,
  -1.30701317e-02f, 5.56636192e-02f, 8.69302824e-02f, 2.27357727e-02f, 7.00741261e-03f, -4.71909866e-02f, -7.87066594e-02f, -5.51524013e-03f, -3.41343246e-02f, -8.87383148e-02f,
  -2.06560176e-02f, 3.93201895e-02f, -1.43859563e-02f, -2.24159914e-04f, -3.98689471e-02f, -3.40985283e-02f, 1.02958739e-01f, -4.89713736e-02f, 9.12804604e-02f, 7.10335225e-02f,
  -4.02242653e-02f, 5.48870228e-02f, -4.68586013e-02f, -7.03620389e-02f, 5.02307378e-02f, 2.85310373e-02f, -6.04984835e-02f, -4.58108522e-02f, 7.12009296e-02f, -3.32625732e-02f,
  -4.69651595e-02f, -6.51222095e-02f, 1.79660483e-03f, -2.79266238e-02f, -5.02567505e-03f, -6.88555511e-03f, 4.68288874e-03f, -2.31279004e-02f, -9.79192741e-03f, -4.56170819e-04f,
  -3.69436443e-02f, -7.79012404e-03f, 1.57901552e-02f, 1.41265512e-01f, -8.24002773e-02f, -3.33429314e-02f, -6.51984587e-02f, 5.85182123e-02f, 1.25954464e-01f, -8.41547921e-02f,
  -2.98359226e-02f, -8.67590159e-02f, -7.52701238e-02f, 7.67414123e-02f, -7.12236911e-02f, -3.18219550e-02f, 9.39749405e-02f, -8.84809494e-02f, 5.48837148e-02f, -3.66976634e-02f,
  -4.36733179e-02f, -1.75678395e-02f, -3.36020254e-02f, 1.08403094e-01f, 1.82290189e-02f, 1.26243770e-01f, 7.29201511e-02f, -9.69828665e-02f, -6.31463006e-02f, -8.23569968e-02f,
  -7.88434669e-02f, 7.02529177e-02f, -1.61454380e-02f, -5.38707301e-02f, -1.58550106e-02f, 7.41644353e-02f, 5.46879359e-02f, 6.90601394e-02f, 3.81827541e-02f, -2.53225528e-02f,
  5.90980519e-03f, 5.04006147e-02f, -2.53096987e-02f, 4.27372642e-02f, -6.68648556e-02f, 6.37779161e-02f, -4.24056873e-02f, -4.33891453e-02f, 7.91367814e-02f, 1.87851507e-02f,
  4.64461260e-02f, -6.71279505e-02f, 5.57203367e-02f, -8.76955539e-02f, 5.55091836e-02f, -1.54285114e-02f, 4.93925251e-02f, -1.40221491e-02f, 3.26249935e-02f, -5.60950041e-02f,
  -5.23398481e-02f, 6.57915697e-02f, 2.36107558e-02f, 8.64929631e-02f, -6.06635846e-02f, -6.26021028e-02f, -3.89460823e-03f, -8.93513709e-02f, -4.95128594e-02f, -9.56546422e-03f,
  5.59757538e-02f, -1.90419592e-02f, -4.90558371e-02f, 5.41801676e-02f, 4.28869948e-02f, -6.82275444e-02f, -1.46879710e-03f, -2.69429404e-02f, -2.64681093e-02f, 6.55720308e-02f,
  -2.47318950e-02f, -5.83416335e-02f, 5.29629625e-02f, -9.22615156e-02f, -5.76316044e-02f, -1.38315000e-02f, -2.01770570e-02f, -2.65309773e-02f, 3.93540710e-02f, 5.81915230e-02f,
  -4.36232872e-02f, -9.02889445e-02f, 7.63727799e-02f, -9.16306749e-02f, -3.18847001e-02f, 5.21665812e-02f, -4.01959345e-02f, -3.35598774e-02f, -5.73726073e-02f, 3.78163233e-02f,
  -8.51854980e-02f, -4.02608849e-02f, 6.15938604e-02f, 3.40395956e-03f, 5.90596795e-02f, -2.14562770e-02f, 5.70870675e-02f, -1.25495493e-02f, 6.04874529e-02f, -5.19541539e-02f,
  -6.20291336e-03f, 8.60340297e-02f, 7.82100856e-02f, 5.88129982e-02f, 6.03967644e-02f, -5.51841967e-02f, -4.08884212e-02f, -7.70074362e-03f, 2.02939790e-02f, -3.25789489e-02f,
  2.12361097e-01f, -2.19448403e-01f, -6.03840277e-02f, 8.35336074e-02f, 1.91406026e-01f, 2.29603276e-02f, 1.06493436e-01f, 2.61655934e-02f, -4.01111580e-02f, -1.46882445e-01f,
  2.12498736e-02f, -6.35182038e-02f, -1.85725212e-01f, 7.82472640e-02f, 1.29572928e-01f, -6.52912632e-02f, 1.14154369e-01f, 5.78506589e-02f, 5.34703629e-03f, 2.89002415e-02f,
  3.28455456e-02f, 1.61163479e-01f, -3.56129035e-02f, -2.02211756e-02f, 1.37030989e-01f, -1.22575769e-02f, -2.35987213e-02f, -1.03156358e-01f, 8.89069214e-02f, 1.65029205e-02f,
  1.65653229e-02f, -9.44683999e-02f, -5.56043871e-02f, 7.73572922e-02f, 4.68750037e-02f, 1.58213098e-02f, 2.47739069e-02f, 4.32687961e-02f, -4.40984853e-02f, 3.31277843e-03f,
  2.94817649e-02f, -7.76116773e-02f, 9.15280730e-02f, 8.81836936e-02f, 4.35650647e-02f, 6.53160065e-02f, -6.45612776e-02f, 2.22664140e-02f, -5.48158698e-02f, 1.80883706e-02f,
  -6.08158186e-02f, -8.65878984e-02f, -4.17693611e-03f, -3.22008245e-02f, 4.12810296e-02f, -3.27174552e-02f, -4.45708334e-02f, -1.00208856e-01f, 4.29139800e-05f, -6.53695241e-02f,
  -4.54607010e-02f, -3.71970087e-02f, -2.01764479e-02f, 5.61029464e-02f, -1.02806254e-03f, 3.25224698e-02f, 7.42098019e-02f, 4.20850925e-02f, 1.12308254e-02f, -7.49448240e-02f,
  4.47867950e-03f, 5.06092459e-02f, -1.23894885e-02f, 3.42584662e-02f, -3.58323865e-02f, 5.27062118e-02f, 4.38314304e-02f, 5.35927340e-03f, -6.75333813e-02f, 5.49070761e-02f,
  -1.31417178e-02f, -7.35584833e-03f, -5.81735149e-02f, 6.30205944e-02f, -2.19483357e-02f, 5.95655739e-02f, 7.17730299e-02f, 3.53055634e-02f, -2.96313819e-02f, 7.32374042e-02f,
  3.33675854e-02f, -1.88454643e-01f, -4.96803671e-02f, 3.49106197e-03f, 1.69009399e-02f, -1.33482227e-02f, -1.51953800e-03f, -1.56707931e-02f, -7.67746894e-03f, -6.50038710e-03f,
  -5.46248928e-02f, -7.77054951e-02f, 1.54941967e-02f, 8.01276602e-03f, -9.42544732e-03f, -4.04514372e-03f, -9.41851828e-03f, -7.66126215e-02f, -5.61413653e-02f, -4.48893271e-02f,
  5.71991019e-02f, -2.65617613e-02f, -1.73595473e-02f, -5.27321324e-02f, 4.75003384e-02f, -1.24592707e-02f, -8.59386250e-02f, 3.20251919e-02f, 6.37887791e-02f, 7.51720835e-03f,
  2.39514202e-01f, -1.61223814e-01f, -1.06435083e-01f, -7.52763748e-02f, 5.02669960e-02f, 1.18164003e-01f, 1.95539609e-01f, -5.95897585e-02f, -2.24483386e-01f, -6.92372695e-02f,
  1.55649379e-01f, 1.15091242e-01f, 6.00607842e-02f, 6.21904898e-03f, 2.59607255e-01f, 6.88793883e-02f, -3.65190431e-02f, 1.00520946e-01f, -1.45797744e-01f, 3.41563374e-02f,
  -5.24239875e-02f, 1.59717098e-01f, 4.50605303e-02f, -1.87906995e-02f, 1.46863028e-01f, -3.40897776e-02f, -8.65766034e-03f, 4.87102680e-02f, 1.16450801e-01f, 1.12374634e-01f,
  6.31814301e-02f, -7.74821341e-02f, -5.10637164e-02f, -4.36803363e-02f, -2.53932476e-02f, 8.03186819e-02f, 2.68100724e-02f, -7.10639916e-03f, 3.45896780e-02f, 2.38443427e-02f,
  8.16413909e-02f, -6.15453459e-02f, -1.91767439e-02f, 8.73339325e-02f, -8.81498009e-02f, -7.09710494e-02f, -4.28656191e-02f, -2.82223187e-02f, 4.59359437e-02f, 8.31369869e-03f,
  -2.98039317e-02f, 2.50536297e-02f, -2.97056865e-02f, 6.20958880e-02f, -1.14870339e-03f, -5.94810359e-02f, -2.77151018e-02f, -2.76136603e-02f, -4.79453430e-02f, 5.78053743e-02f,
  -1.83231104e-02f, -5.20377792e-02f, 7.55031928e-02f, -5.45095429e-02f, 5.40916100e-02f, -7.20738918e-02f, -5.31828031e-02f, -5.44487610e-02f, -5.39105274e-02f, -1.24029033e-02f,
  4.17016214e-03f, -1.80035736e-03f, -2.97110695e-02f, 1.87939927e-02f, 2.25775894e-02f, 1.00278566e-02f, -6.95270598e-02f, 1.50547558e-02f, 1.48054268e-02f, -5.12985587e-02f,
  -3.83704132e-03f, 1.96271800e-02f, 2.32761689e-02f, -6.07492328e-02f, 5.88232949e-02f, 1.11892544e-01f, -4.51149158e-02f, -3.14011164e-02f, 3.73694077e-02f, 3.86468545e-02f,
  4.21466716e-02f, -8.34974796e-02f, 3.16536352e-02f, -6.40928699e-03f, -8.40764344e-02f, -4.53308690e-03f, 8.93341079e-02f, -7.74239451e-02f, 7.81757310e-02f, -8.33903998e-02f,
  -1.42171755e-02f, -3.25402245e-02f, -1.15445657e-02f, 2.27896422e-02f, 6.11865195e-03f, -3.36771347e-02f, -2.87540425e-02f, -3.66925411e-02f, 3.86461131e-02f, -7.33550340e-02f,
  3.95928919e-02f, -9.71606821e-02f, -5.10786921e-02f, -1.21681660e-01f, -4.31374237e-02f, 4.03832905e-02f, -5.22723887e-03f, 2.97252592e-02f, -5.37112076e-03f, -3.06893680e-02f,
  -6.09864220e-02f, 7.63507858e-02f, -2.74158884e-02f, 6.09912686e-02f, 3.80510613e-02f, 1.97076965e-02f, 8.95265192e-02f, -3.52204368e-02f, 1.28243834e-01f, -7.84327101e-04f,
  -8.72162431e-02f, -1.03582546e-01f, -7.95467645e-02f, -7.30160400e-02f, 1.95038859e-02f, 4.41940986e-02f, -3.74498311e-03f, 6.68123141e-02f, 7.73653295e-03f, 1.19684115e-02f,
  8.63106847e-02f, -8.89023840e-02f, -9.73402187e-02f, -9.17436779e-02f, -7.90285096e-02f, 1.10841230e-01f, -2.87424633e-03f, 9.08766836e-02f, 6.13894202e-02f, -2.20056288e-02f,
  -2.20659059e-02f, 4.47334535e-02f, -1.18240230e-02f, -4.34424877e-02f, 1.11387208e-01f, -1.77268721e-02f, 3.22334990e-02f, -1.03197590e-01f, -6.28229082e-02f, -4.53630416e-03f,
  3.83336581e-02f, -6.58530816e-02f, 5.95749505e-02f, 5.10547459e-02f, -1.83655955e-02f, 7.44314045e-02f, -1.82595123e-02f, 9.43790525e-02f, 5.49152493e-02f, -4.36043069e-02f,
  5.84742017e-02f, -5.26662469e-02f, 5.69894016e-02f, -3.70603874e-02f, 4.20977436e-02f, 1.63778011e-02f, -7.33560994e-02f, 5.69969900e-02f, 9.60219353e-02f, 6.59850016e-02f,
  3.09360344e-02f, 5.10368049e-02f, -2.71568745e-02f, -2.37814821e-02f, -7.43542612e-02f, 3.44367698e-02f, 3.51356789e-02f, -4.10264544e-02f, 2.90492661e-02f, -1.63339972e-02f,
  -3.77165191e-02f, -7.31150880e-02f, 5.07386262e-03f, -3.14899497e-02f, -8.69036838e-02f, -6.98900893e-02f, -8.72791409e-02f, 8.64827447e-03f, 4.26675333e-03f, 3.15343700e-02f,
  -3.20400037e-02f, 1.80942882e-02f, -7.80830830e-02f, -6.12448528e-02f, 6.04065806e-02f, 2.24005966e-03f, -7.15258494e-02f, -4.95746061e-02f, 6.38726503e-02f, 2.06766091e-02f,
  1.14096709e-01f, 7.81584755e-02f, 2.79938970e-02f, 7.67700449e-02f, -6.38677645e-03f, -3.36426310e-02f, -2.99036968e-02f, -4.04958650e-02f, -2.74963789e-02f, -1.36434212e-02f,
  7.78270289e-02f, -7.95383751e-02f, -6.59318641e-02f, -2.36169696e-02f, 8.31258446e-02f, 4.47083861e-02f, -3.61038297e-02f, 9.54324007e-02f, -2.68435236e-02f, 3.59202959e-02f,
  3.23976949e-02f, -5.13748685e-03f, -7.87033979e-03f, -7.23197758e-02f, -2.03540754e-02f, -8.84133298e-03f, 2.87225079e-02f, -7.12297708e-02f, -1.96198095e-02f, 6.01830035e-02f,
  5.10878079e-02f, -7.51939462e-03f, -1.28571048e-01f, -1.87490899e-02f, -1.72931418e-01f, -6.33056909e-02f, -6.28661066e-02f, -1.01873346e-01f, -3.23893540e-02f, -2.20705271e-02f,
  -2.36217096e-03f, -9.68196150e-03f, 1.51822776e-01f, 1.81216747e-02f, 6.52866215e-02f, 2.07760453e-01f, -4.78760228e-02f, -2.88132224e-02f, 4.86950018e-02f, 7.66785303e-03f,
  -6.22961856e-02f, -8.36913064e-02f, -9.18693170e-02f, -1.16837092e-01f, -2.07137302e-01f, -1.68545358e-02f, -4.39656414e-02f, -4.22842288e-03f, -1.40993983e-01f, -1.03260480e-01f,
  3.36198807e-02f, -6.17905967e-02f, -2.16293032e-03f, 5.64041473e-02f, 2.88206665e-03f, 3.88686545e-02f, -1.04757823e-01f, -3.78966071e-02f, 5.48939686e-03f, -1.46525097e-03f,
  -2.46115308e-02f, -6.55734586e-03f, -5.78156114e-02f, 4.30249721e-02f, 5.48412651e-02f, -1.40831890e-02f, 2.04514507e-02f, -1.00389950e-01f, 7.06878898e-04f, -1.22257054e-01f,
  -8.98420662e-02f, -7.82111138e-02f, 1.33902598e-02f, 4.80066985e-02f, -5.18012121e-02f, -6.18233392e-03f, -6.21161200e-02f, 2.72911740e-03f, 3.43320817e-02f, 2.97384821e-02f,
  -1.00021124e-01f, -2.68134987e-03f, 7.16792196e-02f, -6.14506565e-02f, -5.64249158e-02f, 1.34606808e-02f, -7.97841549e-02f, 2.22780611e-02f, 5.84397390e-02f, 6.55289590e-02f,
  5.10720499e-02f, -5.83118498e-02f, -7.25016966e-02f, 4.17553708e-02f, -4.23415340e-02f, 1.30502116e-02f, 2.98483223e-02f, 4.20817966e-03f, 3.45490761e-02f, -8.28784145e-03f,
  -1.09971380e-02f, -6.99038580e-02f, -7.50531852e-02f, -7.02293068e-02f, -5.76284193e-02f, 3.69731970e-02f, 1.78950224e-02f, 4.79917563e-02f, 6.46902323e-02f, -9.48688686e-02f,
  4.91897054e-02f, 6.39484301e-02f, -2.03177240e-02f, 5.12407236e-02f, 4.90088109e-03f, -1.05340518e-01f, 5.38379364e-02f, 5.20807430e-02f, 5.95313124e-02f, -4.33256943e-03f,
  7.05856606e-02f, 6.46112189e-02f, 7.46094957e-02f, 3.42551693e-02f, -1.91771965e-02f, 6.29014671e-02f, -4.07481529e-02f, 4.27725613e-02f, -2.44000293e-02f, -9.07069966e-02f,
  -4.60001873e-03f, -3.81631590e-02f, -4.72182874e-03f, -7.63465688e-02f, 7.84956962e-02f, 2.82484721e-02f, 6.41674399e-02f, -6.61540926e-02f, 4.01784889e-02f, 5.76683804e-02f,
  1.86331615e-01f, -1.36905327e-01f, 7.57034719e-02f, -3.00793489e-03f, 5.96105307e-02f, 2.39869803e-02f, -7.78838694e-02f, 1.36015579e-01f, 1.35423496e-01f, -1.06556043e-01f,
  5.85828237e-02f, -2.39836257e-02f, -3.10651138e-02f, -1.50027573e-02f, 2.03842428e-02f, 9.98461246e-03f, 9.02172923e-02f, -9.01870653e-02f, -2.70617614e-03f, 1.78734988e-01f,
  6.35074377e-02f, 1.90787427e-02f, 8.19593221e-02f, 2.93327421e-02f, 1.18071720e-01f, 4.29869071e-02f, 3.97402383e-02f, -8.30653235e-02f, -6.05244078e-02f, -1.00392811e-01f,
  8.06278549e-03f, 1.48314565e-01f, 5.72886690e-02f, -2.06499025e-02f, 7.21453279e-02f, 6.58265948e-02f, -4.22998369e-02f, -5.09717464e-02f, 5.09805791e-02f, 7.22790733e-02f,
  -9.15292948e-02f, -1.00640878e-01f, -1.06063090e-01f, 5.90498671e-02f, 9.86878723e-02f, -7.84041956e-02f, -3.25296447e-02f, -6.15142137e-02f, -8.01377967e-02f, -2.90000029e-02f,
  7.22944364e-02f, -9.34116393e-02f, 2.64044590e-02f, -2.08977759e-02f, 1.51630053e-02f, -5.62625118e-02f, -4.42359559e-02f, 3.93950986e-03f, -4.52855639e-02f, -5.14610037e-02f,
  5.07958084e-02f, -6.78289831e-02f, -1.67379156e-02f, -7.54113793e-02f, 2.77334750e-02f, -3.84084135e-02f, -8.63416865e-03f, -3.20142717e-03f, 7.09103793e-02f, -2.15047449e-02f,
  6.58970838e-03f, 1.04495632e-02f, -6.12423755e-02f, -4.17778231e-02f, -1.59310065e-02f, 9.39309504e-03f, -6.87848032e-02f, 4.65149954e-02f, 1.57587584e-02f, -1.15555963e-02f,
  -9.99971554e-02f, 8.56894180e-02f, -5.44693135e-02f, -7.52347708e-02f, -6.32185861e-02f, -2.19018031e-02f, 7.83160999e-02f, 1.66314673e-02f, 2.63643414e-02f, -3.48383971e-02f,
  -2.79873833e-02f, 7.79009536e-02f, -1.16720553e-02f, 1.24775264e-02f, 6.98215589e-02f, -1.04684038e-02f, -8.98858309e-02f, -4.33216766e-02f, -4.96793427e-02f, -3.20765637e-02f,
  -6.37781098e-02f, -8.28056112e-02f, 6.33488968e-02f, 4.71509770e-02f, 2.95714214e-02f, -1.58342142e-02f, 3.00576957e-03f, -1.69435926e-02f, -5.76107875e-02f, -2.56000739e-02f,
  6.35330053e-03f, 5.07914983e-02f, -1.10917510e-02f, 4.45856079e-02f, 6.20454885e-02f, -1.60149653e-02f, 8.83074626e-02f, -5.92884347e-02f, -6.42020479e-02f, 2.56091333e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.32428597e-03f, 5.96217662e-02f, 1.11277448e-03f, -2.54554162e-03f, 1.56691611e-01f, -1.51415002e-02f, 1.58290163e-01f, 7.14757964e-02f, -6.81415126e-02f, 1.20096371e-01f,
  1.04882091e-01f, -3.80811915e-02f, 7.90964290e-02f, 4.24530618e-02f, -5.64444484e-03f, 1.16869412e-01f, 5.90796694e-02f, 1.08435087e-01f, 1.79286316e-01f, 6.10998971e-03f,
  -1.51292002e-02f, 1.34889752e-01f, 2.37821918e-02f, -3.08758374e-02f, 4.44217436e-02f, 9.48232561e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  1.04996376e-01f, -3.97292912e-01f, 1.09926209e-01f, 1.12292990e-01f, 1.34184122e-01f, 1.37313157e-01f, -3.67217451e-01f, 1.12704724e-01f, 1.48026615e-01f, -5.24505712e-02f,
  -1.63999259e-01f, 6.89965189e-02f, -4.27604429e-02f, 1.61426201e-01f, 1.68264564e-02f, 4.44651395e-02f, 1.33015975e-01f, -1.30479962e-01f, -2.23913550e-01f, 1.42854244e-01f,
  5.42769060e-02f, -1.67148765e-02f, -6.10751621e-02f, 1.05751365e-01f, -2.92589009e-01f, -1.03270978e-01f, -4.31067020e-01f, -1.95553191e-02f, 6.07758004e-04f, -3.67849953e-02f,
  1.22276038e-01f, -3.42953727e-02f, 4.19292003e-02f, 6.43393099e-02f, -3.07969861e-02f, -1.94453448e-01f, -1.90681238e-02f, -1.69630587e-01f, -3.04878466e-02f, 1.43672869e-01f,
  1.50907272e-02f, -1.69057529e-02f, 3.81490754e-05f, -1.83314130e-01f, -2.09629908e-01f, 1.92141458e-02f, 6.91118017e-02f, 5.76471128e-02f, 4.99297865e-02f, 6.75646216e-02f,
  8.62711482e-03f, -7.05781728e-02f, -4.43705946e-01f, 1.24044016e-01f, -2.49413669e-01f, 6.93599973e-03f, -1.67393088e-01f, 4.26441044e-01f, -7.54503459e-02f, 1.84592158e-01f,
  1.11017212e-01f, 4.10270303e-01f, -1.60079390e-01f, 2.77525365e-01f, 1.53951153e-01f, -7.47968704e-02f, 5.06766252e-02f, 1.23011783e-01f, -2.65072048e-01f, -4.05770212e-01f,
  -1.07918382e-01f, -1.90371007e-01f, 2.12991834e-01f, 1.00436866e-01f, -2.64055222e-01f, 3.67323399e-01f, -2.97492832e-01f, 3.79139602e-01f, -2.43522868e-01f, 1.20767333e-01f,
  -2.47820257e-03f, -1.90007940e-01f, 1.67371914e-01f, 1.93918776e-02f, -3.03650796e-01f, -1.06004290e-01f, 3.47356170e-01f, 2.38312885e-01f, -4.61078525e-01f, 4.34589386e-01f,
  1.62703991e-01f, 3.24975342e-01f, 2.31155492e-02f, 6.94281980e-02f, 3.48553121e-01f, -3.18472177e-01f, 1.08892530e-01f, 1.04433276e-01f, -8.28045532e-02f, 9.01420116e-02f,
  2.61464596e-01f, -1.41026616e-01f, -1.45477394e-03f, -2.07120761e-01f, -1.01752445e-01f, -8.01031366e-02f, 1.43360645e-01f, 8.65302142e-03f, -1.60253629e-01f, 5.56349382e-03f,
  1.13674566e-01f, 2.03903973e-01f, -1.03316069e-01f, -6.25162870e-02f, 6.15685545e-02f, -6.40899613e-02f, -2.44983677e-02f, -1.95198044e-01f, 1.56193048e-01f, -6.93833530e-02f,
  -1.02996275e-01f, 1.94752008e-01f, 4.30060439e-02f, -5.92665933e-02f, -6.35039285e-02f, -1.03251338e-01f, 1.38370335e-01f, -1.85541600e-01f, 1.34291127e-01f, -1.56014711e-01f,
  1.72336388e-03f, 5.55337109e-02f, -1.25881270e-01f, -2.67041810e-02f, -2.06208434e-02f, -1.29071057e-01f, -3.24529022e-01f, 1.56262338e-01f, 2.11816981e-01f, 6.88809343e-03f,
  -6.71192110e-02f, -1.21519649e-02f, 1.07469395e-01f, -1.16527140e-01f, -5.15090525e-02f, -4.08689072e-03f, 1.40620172e-01f, -1.26436725e-01f, 4.77203876e-02f, -4.05209847e-02f,
  1.67883873e-01f, 1.28746983e-02f, -2.58316785e-01f, 5.52329980e-02f, -1.13316685e-01f, 2.35708561e-02f, 6.19398383e-03f, 6.42002523e-02f, 8.67186859e-02f, 1.57953322e-01f,
  -1.61401585e-01f, 1.12179473e-01f, 2.03756720e-01f, -4.65188026e-02f, -7.91972056e-02f, -4.52405840e-01f, -2.62775980e-02f, 4.78029288e-02f, -1.59835681e-01f, -3.33520323e-02f,
  -1.07287727e-01f, 1.42434314e-01f, -1.97659666e-03f, -1.13493748e-01f, 1.82290494e-01f, 8.57142359e-02f, 8.78901854e-02f, -2.72708014e-02f, -1.02785580e-01f, 7.26356208e-02f,
  -3.39589536e-01f, -3.63869429e-01f, -3.16765815e-01f, 1.96846366e-01f, -3.33557308e-01f, 2.32512653e-02f, 3.25724781e-01f, 3.71809661e-01f, -1.07612886e-01f, 1.67402253e-01f,
  -3.66221607e-01f, -6.57112151e-02f, -4.07976449e-01f, 2.59820133e-01f, -1.33926198e-01f, -2.01797441e-01f, -1.29368186e-01f, -1.72444671e-01f, 3.58395547e-01f, -1.10278212e-01f,
  -2.06016392e-01f, 1.35173738e-01f, -8.31666926e-04f, 1.50608495e-01f, -8.80637392e-03f, 2.00696379e-01f, -6.16818964e-02f, -3.61550778e-01f, 4.86491434e-02f, 2.56312400e-01f,
  1.89418837e-01f, -3.34251612e-01f, 4.87131476e-02f, -5.85263185e-02f, 1.53220654e-01f, -2.88549244e-01f, -3.60173821e-01f, -4.35155571e-01f, 3.40719968e-01f, 2.70604551e-01f,
  -1.18625574e-01f, -9.17992592e-02f, -6.04028329e-02f, -2.77810484e-01f, 1.78953573e-01f, 1.17835015e-01f, 1.61334705e-02f, 1.53677404e-01f, -9.48987156e-02f, 4.23709482e-01f,
  -3.85703892e-02f, 2.37280518e-01f, 3.55903246e-02f, -7.69328848e-02f, -2.75746100e-02f, 7.28947148e-02f, -7.49871954e-02f, 1.74689859e-01f, 2.51313746e-01f, -4.31787968e-02f,
  -6.69283345e-02f, 8.81884098e-02f, -1.90216973e-01f, -1.14532776e-01f, 1.40019938e-01f, -7.56448880e-02f, -7.82391503e-02f, 6.74057007e-02f, 6.05012439e-02f, 7.09829554e-02f,
  -2.01671824e-01f, 1.76757574e-01f, 3.28025550e-01f, -1.04533717e-01f, -1.03458669e-02f, 1.59270838e-01f, 2.77284011e-02f, 1.32588014e-01f, 8.79814401e-02f, 3.23840417e-02f,
  6.12739176e-02f, -1.78373680e-01f, -1.04424395e-01f, -1.56851187e-02f, -1.15410402e-01f, -2.68037200e-01f, 7.90912062e-02f, -1.29991636e-01f, 8.29815716e-02f, -3.25042367e-01f,
  -1.04609840e-01f, 3.64415199e-02f, -1.01838239e-01f, 1.09031923e-01f, 6.23512305e-02f, -1.13829277e-01f, -3.92530821e-02f, 8.10746774e-02f, -1.52528569e-01f, 2.49441545e-02f,
  -1.41267208e-02f, 1.04933865e-01f, -2.97648963e-02f, 2.29296610e-02f, 1.14213742e-01f, -2.75345445e-01f, -1.45126134e-01f, 4.16284567e-03f, 9.14257243e-02f, -3.85018773e-02f,
  8.70367140e-02f, 2.33425181e-02f, -4.38544489e-02f, -9.44641382e-02f, -1.60671011e-01f, -3.22204739e-01f, -6.12493269e-02f, 7.96119496e-02f, 3.61467116e-02f, 7.85673186e-02f,
  -6.90868720e-02f, 2.10255366e-02f, 1.43343195e-01f, 9.31818224e-03f, -1.06587201e-01f, 1.22062668e-01f, -2.24853709e-01f, 1.59111828e-01f, 1.03785591e-02f, -1.80135563e-01f,
  -4.05694664e-01f, 2.52467152e-02f, -2.54541546e-01f, -1.91297203e-01f, -4.94721206e-03f, 3.24233860e-01f, -2.64857888e-01f, -2.24716097e-01f, 3.44444752e-01f, -8.41794759e-02f,
  -3.08859885e-01f, 2.08632916e-01f, 1.91339612e-01f, -2.58925527e-01f, -4.17971909e-02f, -8.71246159e-02f, -3.14961344e-01f, 3.01901340e-01f, 4.34505232e-02f, -2.95069963e-01f,
  -1.22436896e-01f, -3.17986123e-02f, 1.02744371e-01f, -1.69085160e-01f, -3.03868443e-01f, 1.39059559e-01f, 3.41238797e-01f, 2.74641246e-01f, -2.28438959e-01f, -1.12700976e-01f,
  2.56146252e-01f, 1.09865591e-01f, -5.49912751e-02f, -2.02041462e-01f, -2.75131792e-01f, -2.63572723e-01f, 3.49902809e-01f, -1.21639319e-01f, 3.27092826e-01f, 9.00725573e-02f,
  -1.67705610e-01f, 3.46557707e-01f, -2.87486345e-01f, -5.88210560e-02f, 7.63714500e-03f, -4.62156862e-01f, -4.16407958e-02f, 3.37421805e-01f, -8.20314810e-02f, -7.81708881e-02f,
  2.06113413e-01f, -7.54224584e-02f, -1.84339389e-01f, 7.10603744e-02f, 2.52393577e-02f, 1.50047287e-01f, -9.02288109e-02f, -8.39488730e-02f, -1.14869498e-01f, -1.80938877e-02f,
  3.33080515e-02f, -8.01026970e-02f, -1.45005226e-01f, -1.25955045e-01f, -9.92531478e-02f, -9.47893038e-02f, -1.55208781e-01f, 3.29957120e-02f, 3.80512998e-02f, 3.69949371e-01f,
  1.37830466e-01f, -1.09092548e-01f, -3.17898504e-02f, -5.67106530e-02f, -1.07291780e-01f, 4.85001877e-02f, 1.40162274e-01f, 1.62861243e-01f, 8.31597224e-02f, -4.12426889e-01f,
  1.80435702e-01f, -1.53205827e-01f, -1.60601780e-01f, -1.44528270e-01f, -1.19878165e-01f, 5.89341559e-02f, -1.03980862e-02f, -2.28370249e-01f, -5.22682607e-01f, 7.23961517e-02f,
  -2.52787560e-01f, 1.01779528e-01f, -7.57788271e-02f, -5.48910610e-02f, -9.68666375e-02f, -5.42413741e-02f, 5.43057211e-02f, 1.12043969e-01f, -1.02459695e-02f, 2.71541681e-02f,
  9.03923362e-02f, 4.91891839e-02f, 6.72302768e-02f, 1.22265495e-01f, 6.00343756e-02f, -9.39429775e-02f, 6.18305169e-02f, -6.78072497e-02f, -2.40227863e-01f, 5.85116893e-02f,
  3.26246507e-02f, 5.09259924e-02f, -9.31695774e-02f, -2.06761807e-02f, -5.03035262e-03f, -1.08138686e-02f, 1.13578483e-01f, -5.23473993e-02f, -8.44594557e-03f, -1.64007410e-01f,
  8.57846141e-02f, -9.90264565e-02f, -7.14046657e-02f, -2.06846774e-01f, 1.93968058e-01f, -8.04910585e-02f, -3.73473048e-01f, -1.63399167e-02f, 7.64993438e-03f, -1.05912447e-01f,
  3.36040109e-01f, -1.31303459e-01f, 3.35959524e-01f, -3.63675207e-01f, 3.02460760e-01f, 3.54257613e-01f, 7.51442611e-02f, -9.97953489e-02f, 2.95768857e-01f, -3.64235401e-01f,
  -1.60396427e-01f, 2.64564365e-01f, -6.62663877e-02f, 3.08257937e-01f, -2.35314444e-01f, 1.28251880e-01f, 9.93904546e-02f, -1.16080970e-01f, -2.52072304e-01f, -2.64237314e-01f,
  -9.46510211e-02f, -3.12836736e-01f, 1.38038427e-01f, -2.22695157e-01f, -2.07265213e-01f, -7.16571361e-02f, 1.92228511e-01f, 1.54677019e-01f, -3.54143679e-01f, -3.21076751e-01f,
  -1.54336184e-01f, 2.60199666e-01f, 2.43886158e-01f, 4.16036099e-01f, -1.38930202e-01f, -1.23244017e-01f, -3.48489225e-01f, 1.76604450e-01f, 3.15305442e-01f, 2.60359887e-03f,
  -1.88261300e-01f, 6.25040010e-02f, 2.61592001e-01f, 1.79400444e-01f, 3.01274389e-01f, -1.46691531e-01f, -1.97640300e-01f, -2.69241072e-02f, -8.00196230e-02f, 1.01366527e-01f,
  -1.87921971e-02f, -5.77745624e-02f, 1.09406240e-01f, -7.82165900e-02f, 3.71073522e-02f, 2.71944016e-01f, 1.08783739e-02f, 4.19991761e-02f, -5.69290332e-02f, -1.08457759e-01f,
  -1.34039083e-02f, -1.67761073e-01f, -1.82605252e-01f, 3.38441283e-01f, 1.39015272e-01f, -1.12202071e-01f, 2.55141035e-02f, -6.13715090e-02f, -1.34690046e-01f, -8.49702209e-02f,
  -3.73632535e-02f, -3.96898314e-02f, 2.70612705e-02f, 1.87096670e-01f, -5.76288402e-02f, -8.62573758e-02f, -1.46309689e-01f, 2.30989665e-01f, 4.50910395e-03f, -2.96560582e-02f,
  -9.61987376e-02f, 1.26184225e-01f, 2.11020008e-01f, -3.23653105e-03f, 2.82840114e-02f, 2.37657335e-02f, 3.88390243e-01f, 2.40606442e-02f, 2.02629175e-02f, 5.36128618e-02f,
  1.43781513e-01f, 5.67288920e-02f, -2.02098012e-01f, -6.03186414e-02f, -4.14463468e-02f, 5.09908609e-03f, 2.36715496e-01f, 1.34792728e-02f, 1.46291062e-01f, 1.25146285e-01f,
  -4.40971740e-02f, 1.57887578e-01f, -8.44599903e-02f, 2.30276585e-01f, 5.48811369e-02f, 1.49643555e-01f, 2.82033086e-01f, 3.03089302e-02f, 1.04415044e-01f, 1.29792213e-01f,
  1.17843643e-01f, -9.99867544e-02f, 2.44574949e-01f, -3.04943044e-02f, -9.15858671e-02f, -2.02320173e-01f, -6.69571618e-03f, -7.47117996e-02f, 3.10637373e-02f, 7.67530501e-02f,
  -1.23893186e-01f, 7.98585266e-02f, -1.01121604e-01f, -1.41766667e-01f, -2.30991617e-01f, 3.45248014e-01f, 1.88171163e-01f, -1.25249950e-02f, 1.05200067e-01f, 8.27891231e-02f,
  -3.58365268e-01f, -1.79937392e-01f, -7.38802478e-02f, -4.95418236e-02f, 3.56657505e-01f, 1.87817693e-01f, -3.40207070e-02f, -1.97331831e-01f, -2.51514494e-01f, 4.42198306e-01f,
  -1.04686022e-01f, 2.27065563e-01f, -1.73077852e-01f, 3.74579459e-01f, 2.04425201e-01f, 2.84258395e-01f, 9.77728814e-02f, 2.93005276e-02f, 7.09728850e-03f, 1.49273559e-01f,
  3.49514902e-01f, 3.04940075e-01f, -7.20598027e-02f, 2.44661793e-01f, 3.30787390e-01f, -1.56739071e-01f, -1.29430652e-01f, 2.01613270e-02f, -1.59994006e-01f, 1.67248949e-01f,
  -1.28059939e-01f, 9.35107470e-02f, -3.63427758e-01f, -3.05082828e-01f, 4.16557014e-01f, 3.71472955e-01f, 3.00714493e-01f, -1.96106479e-01f, -2.30699688e-01f, 1.86669588e-01f,
  -1.45826295e-01f, 4.05958384e-01f, 3.32181960e-01f, -4.01970595e-01f, 2.07954854e-01f, -1.38733506e-01f, 2.01900586e-01f, 1.26637250e-01f, 1.29308831e-02f, 5.25655337e-02f,
  -8.45321938e-02f, -1.77418739e-01f, 2.06719637e-01f, 1.48928910e-01f, 2.65557289e-01f, -5.10320142e-02f, 6.08122423e-02f, 1.42446443e-01f, -8.24289918e-02f, 6.29721535e-03f,
  6.92790374e-02f, 2.70450056e-01f, -2.35300407e-01f, -1.15135834e-01f, -8.98717158e-03f, -3.17604579e-02f, -1.13545351e-01f, -2.72120885e-03f, -1.21452510e-01f, 8.97229686e-02f,
  -5.48989438e-02f, 4.02655810e-01f, -1.02241440e-02f, 8.51048753e-02f, 1.16618663e-01f, 2.30764225e-01f, -6.97842389e-02f, -4.80127484e-02f, 3.31359953e-01f, 4.25492227e-03f,
  2.08994165e-01f, 1.85954869e-02f, -4.70529161e-02f, 1.29565522e-01f, 1.76873490e-01f, 1.25489365e-02f, 1.14609171e-02f, 3.00186779e-02f, 5.36406711e-02f, -3.62798907e-02f,
  1.12424031e-01f, 1.83126759e-02f, -1.41937628e-01f, -2.10545212e-02f, -1.24778887e-02f, 7.51621136e-03f, 3.24201048e-03f, 8.02285001e-02f, -3.16079669e-02f, -4.13875356e-02f,
  -3.14784646e-02f, 5.54484390e-02f, 1.57078370e-01f, 8.14659521e-03f, 1.47335276e-01f, 8.72131512e-02f, 8.62315521e-02f, 3.42029095e-01f, 1.29998788e-01f, -5.53086959e-02f,
  -1.67169452e-01f, 6.78578913e-02f, -4.05775122e-02f, 3.40363048e-02f, 1.15351550e-01f, -5.82925528e-02f, 8.21790751e-03f, -1.05318993e-01f, -2.01366976e-01f, 1.44452780e-01f,
  -2.66972575e-02f, 2.03413025e-01f, 1.42036289e-01f, -2.13483796e-01f, 1.66381404e-01f, 5.95389456e-02f, 1.41827002e-01f, 1.88175574e-01f, -1.42155617e-01f, 7.39777610e-02f,
  5.91404028e-02f, -2.93130577e-01f, -1.99015066e-02f, 2.71649007e-02f, 2.03441292e-01f, 2.40090877e-01f, -1.61355764e-01f, -2.69816577e-01f, -1.85319141e-01f, 1.09229229e-01f,
  4.06912774e-01f, -2.92848855e-01f, 4.15142253e-02f, 1.76264331e-01f, 1.96614996e-01f, 2.13922039e-01f, -2.95662675e-02f, 3.95146698e-01f, 6.00104686e-03f, -1.55129284e-01f,
  -2.15196833e-01f, -5.79178222e-02f, -4.79262561e-01f, -2.26305917e-01f, -1.45779336e-02f, 3.06312799e-01f, 1.14101782e-01f, 1.54472187e-01f, -2.05051806e-02f, -1.44800097e-01f,
  -2.59626269e-01f, 3.94444615e-01f, -4.39649284e-01f, -9.43462029e-02f, 8.88935477e-02f, -5.56715466e-02f, 4.42732304e-01f, 3.72405238e-02f, -9.43803340e-02f, 3.42579633e-01f,
  -5.37911383e-03f, -2.97710150e-01f, 1.20618716e-01f, 4.61701393e-01f, -6.89431652e-02f, 2.62204977e-03f, 4.73732688e-02f, -1.56453580e-01f, -9.81844217e-02f, 5.69915026e-02f,
  -8.02713335e-02f, 4.28091139e-02f, 6.95325956e-02f, -1.24811381e-01f, -1.63114727e-01f, -5.15801497e-02f, 1.53735563e-01f, 3.87040406e-01f, 1.18535750e-01f, 1.58962831e-02f,
  -2.65566885e-01f, 9.15625021e-02f, -3.66880521e-02f, -2.18265578e-01f, -1.98010102e-01f, 1.52495384e-01f, 1.61233932e-01f, -8.62514302e-02f, 8.68251026e-02f, -9.07801390e-02f,
  1.83765590e-01f, -9.73385572e-02f, 9.78521183e-02f, 7.92855490e-03f, -7.98143148e-02f, 8.38479698e-02f, 1.51840597e-01f, -1.23329759e-02f, -1.52847037e-01f, -2.93177627e-02f,
  8.27668980e-02f, 1.69977531e-01f, -7.05747008e-02f, 2.96739694e-02f, -1.96509257e-01f, 7.72225782e-02f, 1.26967132e-02f, 7.58975297e-02f, -4.27620336e-02f, -6.84235767e-02f,
  2.55370773e-02f, -1.28620816e-02f, -5.50728617e-03f, 7.73748755e-02f, 2.17212783e-03f, -4.26609814e-02f, -1.75166443e-01f, 4.42383625e-03f, -5.26334345e-03f, -2.12931946e-01f,
  4.51320633e-02f, 1.83623165e-01f, -5.38133740e-01f, -5.27571654e-03f, 2.55699307e-02f, 8.88272151e-02f, 2.14717701e-01f, 2.16728121e-01f, 2.31586825e-02f, 2.02330336e-01f,
  -1.06504500e-01f, 8.69394094e-02f, -1.32399753e-01f, 4.79905792e-02f, -7.13337073e-03f, -8.29626434e-03f, 1.57350942e-01f, -8.91590044e-02f, 1.20260805e-01f, -2.28762209e-01f,
  4.21608061e-01f, -1.21969707e-01f, 4.39280361e-01f, -1.43099144e-01f, -2.98288286e-01f, -1.44747257e-01f, 3.10669504e-02f, -2.56798733e-02f, 4.98772562e-02f, -2.53451914e-01f,
  -2.00868547e-01f, -1.24986298e-01f, -1.91614017e-01f, 4.97306921e-02f, 3.91274750e-01f, -2.92488784e-01f, 7.83034265e-02f, 3.28438789e-01f, 4.05409606e-03f, 6.65254593e-02f,
  -3.08853388e-01f, -1.31579593e-01f, 3.28055382e-01f, -5.51102534e-02f, -1.06629968e-01f, -3.03284913e-01f, -2.53327847e-01f, -5.29740334e-01f, 1.73230574e-01f, 2.48675067e-02f,
  -2.44551659e-01f, 1.35422423e-02f, 1.40648305e-01f, 4.02129978e-01f, -2.31602564e-01f, -1.46209463e-01f, 1.75984293e-01f, -1.60687566e-01f, 5.62214479e-03f, 1.27812251e-01f,
  2.50345737e-01f, 2.34334022e-01f, -2.02742338e-01f, 2.56618679e-01f, -4.49383408e-02f, -2.93428540e-01f, 8.07001069e-03f, -1.43604558e-02f, -2.55864441e-01f, 2.28020716e-02f,
  -4.63269912e-02f, 6.22910149e-02f, 1.19457223e-01f, -1.52422981e-02f, 2.30840594e-01f, -2.44692136e-02f, -2.10997120e-01f, -1.01106934e-01f, 1.33315278e-02f, -1.68067977e-01f,
  9.05408189e-02f, 1.19273486e-02f, 4.30398792e-01f, -9.04993713e-02f, -1.08356789e-01f, 1.79575875e-01f, -8.75668414e-03f, -1.13667035e-02f, -1.77794442e-01f, -2.15446018e-02f,
  1.11779690e-01f, 2.31888026e-01f, -1.95345119e-01f, 3.89325023e-02f, -1.21314630e-01f, 2.69862413e-01f, -4.48224507e-03f, -4.53345776e-02f, -2.00431094e-01f, -2.18393430e-01f,
  -1.03767127e-01f, 7.50751793e-03f, 1.25382677e-01f, 1.02181382e-01f, -1.94069266e-01f, 3.31904320e-03f, -1.32364914e-01f, -1.18640430e-01f, -6.71640709e-02f, -9.44308862e-02f,
  2.65183467e-02f, -2.50556648e-01f, -3.63228988e-04f, 3.79661731e-02f, -8.09498057e-02f, 4.66618612e-02f, 6.12608753e-02f, -1.70220342e-03f, 2.26893537e-02f, 4.16896231e-02f,
  7.88437277e-02f, -1.91534787e-01f, 7.86682591e-02f, -2.43824404e-02f, -3.80132161e-02f, -1.71110153e-01f, -7.05529191e-03f, 4.78817411e-02f, 8.48024040e-02f, -2.41596371e-01f,
  9.36100408e-02f, -8.79160501e-03f, -3.77530865e-02f, -1.79255351e-01f, -2.84112543e-01f, -1.08996227e-01f, 6.27806112e-02f, 8.30259472e-02f, -9.52154472e-02f, 6.56643063e-02f,
  -9.85500664e-02f, 2.45009083e-02f, -9.56990421e-02f, -5.79776540e-02f, -9.35531706e-02f, 8.59488472e-02f, -1.05801329e-01f, 2.13252857e-01f, 2.64824659e-01f, 2.59570122e-01f,
  -8.34733546e-02f, 2.16484517e-02f, 7.49666542e-02f, 4.60308902e-02f, 8.62658694e-02f, -8.43691602e-02f, 1.88408140e-02f, 3.67763937e-01f, -1.68475404e-01f, -1.23839915e-01f,
  1.78045169e-01f, -1.95930954e-02f, 3.66958767e-01f, 2.12560013e-01f, 1.99725807e-01f, 5.39224297e-02f, -4.90186848e-02f, 6.23540133e-02f, 5.11824824e-02f, 1.49821594e-01f,
  1.68246180e-01f, -1.57550067e-01f, 1.11806422e-01f, -1.80368826e-01f, -2.27957547e-01f, 1.82287768e-01f, -1.29160628e-01f, -6.25967532e-02f, -2.80665129e-01f, -2.05677539e-01f,
  -2.01518074e-01f, -1.15196198e-01f, -1.93956450e-01f, 2.48522073e-01f, 2.94055879e-01f, 1.51362523e-01f, -8.47372711e-02f, -6.00282252e-02f, 4.95483652e-02f, -3.26540202e-01f,
  5.84253594e-02f, 1.29420713e-01f, -1.90337390e-01f, 6.89292103e-02f, -2.22591430e-01f, -1.83215216e-01f, -2.38001361e-01f, -1.89478666e-01f, 4.26143259e-02f, 4.31660637e-02f,
  9.00213839e-04f, 2.81174093e-01f, -8.11993107e-02f, -7.49095455e-02f, 2.69834876e-01f, -8.49570334e-02f, -6.11540303e-02f, 2.54446328e-01f, 1.04705907e-01f, 1.04981028e-01f,
  -1.07574910e-01f, 1.25226602e-01f, 4.94639538e-02f, -8.27589333e-02f, 1.47927985e-01f, 1.05788827e-01f, 5.26361406e-01f, -7.11318254e-02f, -6.71774196e-03f, -1.17645651e-01f,
  -7.62274042e-02f, -3.86793874e-02f, 2.93891519e-01f, -1.64933084e-03f, -7.08736554e-02f, 4.71954457e-02f, -1.53788552e-01f, -4.97198328e-02f, -8.59446153e-02f, -1.40579399e-02f,
  1.05250254e-01f, 1.06613368e-01f, -5.21594733e-02f, 8.45358372e-02f, 3.29901204e-02f, 3.36163901e-02f, -8.47704485e-02f, -8.64850208e-02f, 1.07821912e-01f, 4.22470691e-03f,
  8.39624852e-02f, 9.49322134e-02f, 2.95902528e-02f, -3.86792645e-02f, -1.65782779e-01f, -4.82307039e-02f, 3.75207514e-02f, -1.68842733e-01f, 1.17698051e-01f, -4.34090309e-02f,
  6.82273805e-02f, -2.38428712e-02f, -4.79488587e-03f, 1.49218336e-01f, 1.03524446e-01f, 8.18692744e-02f, -2.50397593e-01f, -4.14774925e-01f, 7.76096880e-02f, -7.61116222e-02f,
  6.79189041e-02f, 6.78660795e-02f, 5.99855036e-02f, -4.86031249e-02f, 8.52025449e-02f, -8.51130709e-02f, -2.06678901e-02f, -5.99570610e-02f, -2.33892519e-02f, 2.82787606e-02f,
  -3.17387581e-01f, -1.37318566e-03f, -1.65524602e-01f, -4.44800444e-02f, 4.30915877e-02f, 3.30016583e-01f, 1.30952233e-02f, -2.25302637e-01f, -2.51516044e-01f, 2.44157702e-01f,
  -2.42075115e-01f, -2.67484854e-03f, -1.40052130e-02f, 2.57875949e-01f, -1.50311708e-01f, -7.06509035e-03f, 2.33451754e-01f, -2.18799576e-01f, -2.34780028e-01f, 1.69208720e-01f,
  -2.00869158e-01f, 1.46933690e-01f, -6.87207654e-02f, 3.64958674e-01f, 7.85905216e-03f, -3.75823885e-01f, 1.96591690e-01f, -1.57523528e-01f, -2.09431142e-01f, -1.06579669e-01f,
  2.97669470e-01f, -1.44018799e-01f, 3.25850874e-01f, 1.54826969e-01f, 1.07659489e-01f, -2.77720809e-01f, -2.60509849e-02f, 4.12272036e-01f, 4.23336267e-01f, -1.78052023e-01f,
  2.71649420e-01f, 1.27939820e-01f, 2.58811060e-02f, -2.01212659e-01f, 2.78102428e-01f, 2.32790131e-03f, -3.09086919e-01f, -3.94171447e-01f, -2.80369550e-01f, -1.72021642e-01f,
  -8.41302797e-02f, -3.92378420e-01f, -2.11534441e-01f, -3.75904948e-01f, -1.54417157e-01f, -1.98357463e-01f, -9.29596052e-02f, -1.36243194e-01f, -6.31430894e-02f, -1.21311061e-01f,
  -4.17496413e-02f, 6.57233149e-02f, 2.25574732e-01f, 1.52557656e-01f, -1.22315459e-01f, -1.03550583e-01f, 7.30022136e-03f, 1.27897382e-01f, -4.58847843e-02f, -1.19422980e-01f,
  -8.73357505e-02f, -1.01557914e-02f, -2.67146360e-02f, 1.70915082e-01f, -1.79777309e-01f, 4.97570075e-02f, 6.56273365e-02f, -1.39244825e-01f, -4.48817499e-02f, 2.20575538e-02f,
  -7.46334940e-02f, 2.00618580e-01f, 9.68756750e-02f, 1.48062229e-01f, -2.57091910e-01f, -5.06890826e-02f, 4.62088026e-02f, 1.27163976e-01f, 1.64698213e-01f, -3.51259857e-01f,
  1.59112066e-01f, -2.15231534e-02f, -3.65979597e-02f, 9.43562463e-02f, -1.09618716e-01f, 3.69444340e-02f, -2.08952665e-01f, 8.07117000e-02f, 1.97357520e-01f, 8.84616673e-02f,
  -4.10777926e-02f, 1.36300270e-02f, 1.10648386e-01f, 9.10294726e-02f, 7.59648308e-02f, -1.31663769e-01f, 1.43194839e-01f, 1.06012598e-01f, 1.59389138e-01f, 2.96656005e-02f,
  1.09514117e-01f, -7.88549334e-03f, -8.72803777e-02f, 2.49272864e-02f, -1.12482838e-01f, 8.23176578e-02f, -8.16972852e-02f, -1.98483855e-01f, 7.38360360e-02f, 7.30647892e-02f,
  8.92760232e-02f, 3.94628234e-02f, 1.64238334e-01f, -2.94905722e-01f, 7.97085837e-02f, 6.58924431e-02f, -5.76646365e-02f, 1.25175431e-01f, -2.32397225e-02f, 1.82400830e-02f,
  1.39388546e-01f, -6.64450228e-02f, 3.97820100e-02f, 1.62953004e-01f, 1.37163103e-01f, 6.37734115e-01f, 2.89557010e-01f, 6.00778162e-02f, -1.01985663e-01f, -1.36214957e-01f,
  -3.52963924e-01f, -3.08033526e-01f, -2.80555971e-02f, -3.37566614e-01f, -2.43291989e-01f, 1.99138775e-01f, -2.41410509e-01f, 3.68499994e-01f, -1.02241181e-01f, -1.46274706e-02f,
  1.44541055e-01f, -4.91637617e-01f, -2.07699105e-01f, -2.00116172e-01f, 7.35799298e-02f, -9.04050544e-02f, 1.21702552e-01f, -3.11048552e-02f, 1.50075018e-01f, 1.96075693e-01f,
  -3.03110510e-01f, 2.18090281e-01f, -3.34476650e-01f, -1.01382561e-01f, -1.13825709e-01f, -2.30628029e-01f, 8.88877362e-02f, 4.00659770e-01f, -3.37697923e-01f, -8.75783041e-02f,
  2.98102826e-01f, 2.33510450e-01f, -1.18892990e-01f, -1.35483250e-01f, 4.95295018e-01f, 6.59351498e-02f, -1.67752326e-01f, 1.70519620e-01f, -5.97530864e-02f, 3.37996960e-01f,
  -3.04091200e-02f, -5.72555140e-02f, -3.30808043e-01f, 1.18320070e-01f, 3.24059039e-01f, -8.97401348e-02f, -1.78167656e-01f, -6.19112588e-02f, -1.52583688e-01f, -2.19802149e-02f,
  -1.12765588e-01f, -1.08343631e-01f, 7.36834705e-02f, -1.27252698e-01f, 2.28775382e-01f, 5.48271164e-02f, 8.21703598e-02f, 6.85972795e-02f, -1.59124732e-01f, -2.50237763e-01f,
  -2.11584151e-01f, -1.35239810e-01f, -8.17070827e-02f, 7.57910609e-02f, -1.77324608e-01f, 8.94907415e-02f, 3.32903594e-01f, -1.37661010e-01f, -2.32988130e-02f, -8.90632719e-02f,
  -1.00949131e-01f, 4.39151265e-02f, 6.82080910e-02f, 1.07063182e-01f, -1.48852803e-02f, 3.64201665e-02f, -9.91549939e-02f, 3.89764793e-02f, 1.42822206e-01f, 1.00760236e-01f,
  3.88604663e-02f, 9.15826634e-02f, 4.78567034e-02f, 2.35656887e-01f, -1.19347929e-03f, -4.20336947e-02f, -4.69932184e-02f, 1.76071916e-02f, -1.59704648e-02f, 6.80342242e-02f,
  6.75505772e-02f, 4.87596840e-02f, 2.03226823e-02f, -5.54989241e-02f, -2.77274419e-02f, 1.61191672e-02f, -2.57023662e-01f, -1.22341901e-01f, -4.59995680e-02f, -5.82721224e-03f,
  1.72545090e-02f, -1.06939487e-01f, 2.27199234e-02f, 1.87822327e-01f, -1.40994191e-01f, 3.18398178e-02f, 8.74505937e-02f, 1.68540269e-01f, 1.50028601e-01f, 1.70504391e-01f,
  -1.05824396e-01f, 1.46381527e-01f, 1.02348335e-01f, -5.24198599e-02f, 1.01424694e-01f, 9.46186483e-02f, -4.52084169e-02f, 5.85043319e-02f, 1.29321307e-01f, 1.32274285e-01f,
  1.05471611e-02f, -3.58232468e-01f, -2.74292916e-01f, -4.76032272e-02f, 1.60255924e-01f, -2.42103010e-01f, 4.55135703e-01f, -3.25196147e-01f, 2.52390027e-01f, 1.49123400e-01f,
  -5.64630069e-02f, 4.15541410e-01f, 2.88861208e-02f, 6.55218586e-02f, 2.91516650e-02f, -4.28627342e-01f, -3.01358998e-01f, 2.57737339e-01f, 1.27600521e-01f, -2.99795747e-01f,
  1.51884496e-01f, 9.88439545e-02f, -1.97848871e-01f, -2.10220739e-01f, -1.53458536e-01f, -4.41786572e-02f, -1.09506980e-01f, -5.05364597e-01f, 2.26392001e-01f, -9.62686166e-03f,
  2.39054054e-01f, -1.58493772e-01f, 2.67913312e-01f, 7.06727579e-02f, -9.97239724e-02f, -4.00394738e-01f, 1.90649122e-01f, -2.13898957e-01f, -3.21564674e-02f, -1.02174781e-01f,
  2.11616710e-01f, -4.06494260e-01f, 1.67820491e-02f, -2.06230015e-01f, -4.49562401e-01f, 1.86830223e-01f, -1.25093982e-02f, 2.76707172e-01f, 2.20940560e-01f, 4.47621569e-02f,
  -2.61269063e-02f, 3.98771226e-01f, -2.91109104e-02f, 6.74353773e-03f, 3.59440260e-02f, -1.49507612e-01f, -1.38042644e-01f, 2.12362811e-01f, -1.01273153e-02f, 1.20470338e-01f,
  -1.82798848e-01f, -8.73165354e-02f, -5.92545457e-02f, -1.28352389e-01f, -1.35585546e-01f, -7.32159168e-02f, 1.53106391e-01f, -1.89117819e-01f, -7.22123533e-02f, -1.33924916e-01f,
  6.96754158e-02f, -5.06651625e-02f, -3.06245754e-03f, -1.16039664e-01f, -3.39296050e-02f, 7.35980794e-02f, -9.66934338e-02f, -1.07731847e-02f, 2.56056394e-02f, -1.71603605e-01f,
  1.36714563e-01f, 3.26578617e-02f, -1.13210399e-02f, 2.54100487e-02f, 1.02612376e-01f, 1.03079088e-01f, -6.35989010e-02f, -5.75377606e-03f, -6.31159171e-02f, 1.08769946e-01f,
  7.42959827e-02f, -2.18358740e-01f, 1.89585134e-01f, 7.39157374e-04f, 7.08911382e-03f, -9.50921923e-02f, -3.33686210e-02f, -1.51620600e-02f, 5.12447022e-02f, 5.93506545e-03f,
  -3.76329757e-02f, 1.31878972e-01f, 3.11933029e-02f, 1.23587303e-01f, 1.88416839e-01f, 8.64850208e-02f, -6.98278658e-03f, -1.24094766e-02f, -2.71796528e-02f, 2.80783270e-02f,
  -1.51786834e-01f, 6.90368116e-02f, 2.40095869e-01f, 3.49326693e-02f, -2.19955528e-03f, -2.31294408e-01f, 4.72249882e-03f, 9.63014290e-02f, 8.36259313e-03f, -1.99883565e-01f,
  8.52583721e-02f, 2.10585698e-01f, 1.49116650e-01f, 1.32417172e-01f, -2.16672674e-01f, 4.94042635e-02f, 1.59903616e-01f, -1.87338497e-02f, 1.88224018e-01f, -2.91920364e-01f,
  5.36884427e-01f, -8.46758932e-02f, -8.60114023e-02f, -1.73093736e-01f, 3.60456556e-01f, 2.64627457e-01f, 1.01515949e-02f, -3.53903770e-01f, -1.66177198e-01f, -4.22441930e-01f,
  1.43262401e-01f, 7.19662309e-02f, 5.30576289e-01f, -2.37166122e-01f, 9.68091190e-02f, -1.96317583e-01f, 2.98093319e-01f, -1.45429168e-02f, 1.65252611e-02f, -1.34543300e-01f,
  -7.59493783e-02f, 1.52905315e-01f, 4.17905785e-02f, -1.93694219e-01f, -7.81197473e-02f, 1.91690952e-01f, 2.20702946e-01f, 1.73077956e-01f, 2.52104163e-01f, -2.77871221e-01f,
  2.99117118e-01f, 3.85933012e-01f, 3.39900494e-01f, -1.54459894e-01f, 3.13483924e-02f, -1.32817701e-01f, 4.13379699e-01f, -2.30839506e-01f, -2.84598649e-01f, -3.69297713e-02f,
  -3.43340605e-01f, -7.67518729e-02f, 6.38169050e-02f, 4.06918973e-02f, -1.01588011e-01f, -5.56346774e-01f, 1.74099386e-01f, 1.45485342e-01f, 3.87035787e-01f, 9.31547359e-02f,
  5.08687906e-02f, -1.61830008e-01f, -1.32202640e-01f, -1.28171682e-01f, 3.65429036e-02f, -2.26291250e-02f, -1.72329135e-02f, 5.31175323e-02f, -2.42018010e-02f, -1.40427053e-01f,
  3.98665108e-02f, 4.17422839e-02f, -1.25890404e-01f, -4.15249020e-02f, -9.28335041e-02f, 3.21269721e-01f, 1.43399490e-02f, -8.00515637e-02f, 1.21242553e-02f, -1.43500119e-01f,
  3.42680663e-02f, -3.58754420e-04f, -5.92190921e-02f, -2.78784167e-02f, -1.46846101e-01f, -5.41253015e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  8.80716592e-02f, 1.24974269e-02f, -7.99804702e-02f, 8.13504830e-02f, 5.75452633e-02f, -1.01319872e-01f, 1.83310248e-02f, 4.46231253e-02f, -2.73624603e-02f, 4.98273000e-02f,
  4.11272943e-02f, 9.10934657e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    