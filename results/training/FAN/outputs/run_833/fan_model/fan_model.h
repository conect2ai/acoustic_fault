/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.95415181e-02f, -1.56643838e-01f, -3.06783766e-01f, -5.66709861e-02f, -2.67255366e-01f, -1.86364204e-01f, -2.79293895e-01f, 1.48360059e-01f, 1.07412845e-01f, -1.26039967e-01f,
  -2.17989236e-01f, -4.02568877e-02f, 3.67086418e-02f, 4.38050888e-02f, 9.34311599e-02f, -1.88897163e-01f, -5.05648181e-02f, -9.97922719e-02f, 9.40779373e-02f, 6.14836439e-02f,
  5.50841279e-02f, 7.56810531e-02f, 1.48118824e-01f, 2.24759981e-01f, 5.95984012e-02f, 8.18547383e-02f, -1.09064221e-01f, -1.26208849e-02f, 2.42422167e-02f, -2.00326353e-01f,
  -3.56256306e-01f, -1.72070727e-01f, -3.62259597e-02f, 4.07596640e-02f, -9.63131040e-02f, 7.25276172e-02f, -8.63799155e-02f, 3.44729014e-02f, 4.08234000e-02f, 7.62785450e-02f,
  -1.82833388e-01f, 3.74427885e-02f, -1.45189613e-02f, -2.21187659e-02f, -7.83958472e-03f, -4.82822128e-04f, 6.17751479e-02f, 4.36106622e-02f, -5.34401536e-02f, -1.60104930e-01f,
  -1.58648521e-01f, -1.70417279e-01f, -1.62949085e-01f, 7.94267282e-02f, 1.83365829e-02f, -2.98095681e-02f, -8.60759020e-02f, -3.52830328e-02f, 5.53119965e-02f, 1.66441023e-01f,
  2.09507197e-02f, -2.83071529e-02f, -3.77088436e-03f, 3.45254503e-02f, 1.62491333e-02f, 9.68081784e-03f, -2.41680816e-02f, 4.83359955e-02f, 5.84743395e-02f, -4.33504145e-04f,
  -8.67589936e-03f, -7.41408840e-02f, 3.93683128e-02f, -5.03841380e-04f, -2.44205967e-02f, 4.42816271e-03f, 2.65372209e-02f, -1.37940925e-02f, 1.58304106e-02f, 3.97296064e-02f,
  -1.05064863e-03f, -2.61349268e-02f, -2.87433360e-02f, 4.44825292e-02f, -5.10702506e-02f, 1.75154768e-02f, -7.35851750e-03f, 1.25472283e-03f, 5.67768738e-02f, -7.69990310e-02f,
  3.48537862e-01f, -9.59099978e-02f, -2.39108503e-03f, 4.37398665e-02f, 6.09592311e-02f, -1.39639166e-03f, -3.28425840e-02f, 9.95254591e-02f, -7.46708289e-02f, -4.69765160e-03f,
  -5.50324237e-03f, -1.42736724e-02f, -4.00306433e-02f, 1.31931640e-02f, 1.12802191e-02f, -2.86119450e-02f, 6.45866022e-02f, -3.90501581e-02f, 3.92319001e-02f, 5.32707609e-02f,
  4.76047657e-02f, 8.33602697e-02f, 8.91212821e-02f, 6.54392838e-02f, 1.46380290e-02f, -1.60248787e-03f, -3.75315472e-02f, 3.90514173e-02f, -1.16209663e-03f, 2.18178958e-01f,
  -2.32346192e-01f, -4.37229902e-01f, -1.52833313e-01f, 6.26434535e-02f, 2.29544402e-03f, -1.81322098e-01f, -5.94994366e-01f, -1.21809505e-01f, 2.08563387e-01f, -7.41490945e-02f,
  6.71337619e-02f, 2.74771631e-01f, 2.37983748e-01f, 1.46205485e-01f, -9.19746421e-03f, -4.48013484e-01f, -2.90834129e-01f, -7.44829848e-02f, 9.64993462e-02f, 1.15877673e-01f,
  2.32391004e-02f, -1.14301564e-02f, 7.00902045e-02f, 1.02775566e-01f, -1.06062375e-01f, 1.91110685e-01f, -8.37658867e-02f, -2.87833940e-02f, -1.55119011e-02f, -5.25882840e-02f,
  -1.76978260e-02f, -2.65318483e-01f, 1.34319097e-01f, 3.36684920e-02f, 8.21296349e-02f, 3.35676745e-02f, -5.65153807e-02f, 6.11157797e-04f, 7.97251537e-02f, 3.71295004e-03f,
  8.75572637e-02f, 3.58498618e-02f, 7.66650192e-04f, 1.46539388e-02f, -6.62600398e-02f, -7.59872794e-02f, 2.29318570e-02f, 1.97627824e-02f, 2.23741475e-02f, 2.62910463e-02f,
  7.18382895e-02f, -1.00698560e-01f, -4.23588604e-02f, -8.13051686e-02f, -5.28512076e-02f, 7.41897002e-02f, 4.43039164e-02f, 5.95579892e-02f, 4.83574905e-02f, -3.44087332e-02f,
  5.65430596e-02f, -3.51296589e-02f, -3.91655192e-02f, -3.28265913e-02f, -9.24180262e-03f, 2.28161067e-02f, -6.69565871e-02f, -3.83477956e-02f, 8.00988823e-03f, -3.69330458e-02f,
  1.05535075e-01f, -6.90924078e-02f, 4.56561372e-02f, -4.26470265e-02f, 3.31078693e-02f, -1.78048071e-02f, -3.40925679e-02f, -4.08603773e-02f, 9.58224535e-02f, -1.82419643e-02f,
  3.00713442e-02f, 5.58684282e-02f, 1.46130715e-02f, -4.33825031e-02f, -4.26273234e-02f, 2.81140506e-02f, -1.05251996e-02f, 3.46146822e-02f, 2.83286665e-02f, 6.59561157e-02f,
  1.55163705e-01f, 1.10043116e-01f, -2.96750125e-02f, 1.54700484e-02f, -3.32525782e-02f, 6.49461150e-02f, 7.02797472e-02f, 2.06746701e-02f, 7.79548511e-02f, -3.36547568e-02f,
  -5.51721267e-02f, 5.13258716e-03f, -3.28784361e-02f, 2.41412483e-02f, -7.33908731e-03f, 1.93889271e-02f, -2.85686608e-02f, -4.78517450e-02f, -1.83044635e-02f, 3.35810222e-02f,
  7.57536143e-02f, 2.59188935e-02f, -5.29523892e-03f, -3.95678692e-02f, -1.50004579e-02f, 1.32095927e-04f, -1.24321394e-02f, -2.61944253e-02f, -9.32927132e-02f, -1.55315250e-01f,
  -4.53201979e-01f, -1.89693898e-01f, -1.45070091e-01f, -2.55050808e-01f, -6.85813054e-02f, -9.50271413e-02f, -2.00461075e-01f, -6.82813451e-02f, -5.55920340e-02f, -1.66003495e-01f,
  7.53639340e-02f, 1.62473768e-01f, -5.46603799e-02f, 1.17905095e-01f, -6.70610145e-02f, -2.61973977e-01f, -2.64085263e-01f, -9.48917419e-02f, 1.10453792e-01f, 6.83115497e-02f,
  1.58002134e-02f, -3.36505414e-04f, -1.10054417e-02f, 1.25760108e-01f, -2.08746642e-02f, 6.73564225e-02f, 8.18977132e-03f, 1.98885184e-02f, 3.78850251e-02f, 7.10573718e-02f,
  4.22097780e-02f, 5.90605885e-02f, 6.01261072e-02f, 4.12088446e-02f, 4.17722091e-02f, -4.81788255e-02f, -4.75458801e-02f, 7.78497532e-02f, 7.88616762e-02f, -7.58923143e-02f,
  -7.87598360e-03f, 4.02022712e-02f, -8.37273058e-03f, 6.09333031e-02f, -6.97465688e-02f, 2.33550873e-02f, -4.54185903e-02f, -3.52806114e-02f, -3.67665924e-02f, -6.21545315e-02f,
  6.80676922e-02f, 3.93248945e-02f, -1.60301309e-02f, 1.96476257e-03f, 1.09320715e-01f, 7.57890046e-02f, 6.95424601e-02f, 1.49949089e-01f, 8.99881050e-02f, -1.49951165e-03f,
  2.21944936e-02f, -5.73036168e-03f, 3.30420770e-02f, -1.13916649e-02f, -6.96508912e-03f, 1.46664828e-02f, -3.64015182e-03f, 5.88681409e-03f, -1.48404827e-02f, 2.37639584e-02f,
  2.84374319e-02f, 4.16097641e-02f, 2.34438702e-02f, -7.05395713e-02f, -3.24865021e-02f, -7.03299716e-02f, -9.95968119e-04f, -6.35359436e-02f, -4.80708592e-02f, 4.72569838e-02f,
  -1.58026405e-02f, 1.58659089e-02f, -5.97842112e-02f, 2.85627563e-02f, -2.34052278e-02f, -3.17017175e-02f, -3.23168710e-02f, 1.34571239e-01f, -7.55276605e-02f, 7.88285658e-02f,
  -1.96283728e-01f, 9.92494971e-02f, -1.41351148e-01f, -1.03136599e-01f, -2.30477396e-02f, -2.31642090e-02f, -6.05371222e-03f, -3.12290378e-02f, 7.54095672e-05f, -8.22268128e-02f,
  -3.70001644e-02f, -6.66486397e-02f, -1.14956506e-01f, 5.45676611e-02f, 5.02936095e-02f, -7.35406578e-02f, -1.50658518e-01f, -1.35144796e-02f, 1.13456927e-01f, -8.18649456e-02f,
  -1.38673782e-01f, -1.46253943e-01f, -1.51000142e-01f, -5.52199930e-02f, -6.90947026e-02f, -7.15348721e-02f, -4.47945036e-02f, -4.54294728e-03f, -1.05804734e-01f, -3.42903435e-01f,
  4.12033051e-01f, 4.24434990e-01f, 1.89745188e-01f, 1.46183729e-01f, -6.06186390e-02f, -1.13018215e-01f, 1.88935503e-01f, -3.85051663e-03f, -3.79460603e-02f, 2.00000674e-01f,
  -4.90852296e-02f, -3.30568254e-01f, -2.15368658e-01f, -2.33571470e-01f, -1.62370607e-01f, 1.30121022e-01f, 6.57156929e-02f, -1.64719373e-01f, -2.44772568e-01f, -1.70687363e-01f,
  -1.54640555e-01f, 1.08091258e-01f, 1.35037318e-01f, -8.39764401e-02f, 1.38802454e-01f, -2.07656249e-01f, 1.83267936e-01f, 1.01723403e-01f, -6.53295368e-02f, 2.16865987e-01f,
  1.66303843e-01f, 3.60796452e-01f, -2.10789993e-01f, -1.35792881e-01f, 1.10997945e-01f, 7.42139369e-02f, 9.16554481e-02f, 1.19649790e-01f, -5.42178676e-02f, 1.25431225e-01f,
  -1.46907587e-02f, -3.63377072e-02f, -7.34919012e-02f, -7.09802061e-02f, 1.29522562e-01f, 4.50180881e-02f, 6.13003373e-02f, 6.53835610e-02f, -7.12197833e-03f, 9.33353975e-02f,
  -3.10033839e-02f, 7.49542788e-02f, 1.67146608e-01f, -1.71020254e-02f, -7.58956894e-02f, -1.89707950e-01f, 2.17665751e-02f, 4.65464639e-03f, -7.05172867e-02f, 2.47963831e-01f,
  6.45598536e-03f, 1.33091146e-02f, 6.31331000e-03f, 2.26609893e-02f, -7.58444294e-02f, -1.13212382e-02f, -4.18124199e-02f, 5.49512319e-02f, 3.06088533e-02f, 9.92427170e-02f,
  -1.68310665e-02f, 7.35659851e-03f, -1.12936506e-02f, 1.11914687e-01f, -4.21373844e-02f, -1.82630755e-02f, 6.91297427e-02f, -3.56311463e-02f, -3.85425724e-02f, -4.53133248e-02f,
  2.39470135e-03f, -7.40671065e-03f, 4.47601713e-02f, 2.30794046e-02f, -7.15205371e-02f, 2.73065809e-02f, -1.22966208e-02f, -3.57125513e-02f, -3.48993503e-02f, 1.94148719e-02f,
  4.89111319e-02f, -2.30290040e-01f, 1.35338649e-01f, -2.45761685e-02f, -2.25376263e-02f, -2.21115220e-02f, -7.54621550e-02f, -9.77037102e-02f, -6.35432824e-02f, -7.77106639e-03f,
  -4.68361825e-02f, -3.11365835e-02f, -1.67557187e-02f, -3.59417894e-03f, 4.16739695e-02f, -3.50007117e-02f, -2.48705223e-02f, -6.31903037e-02f, -2.75178924e-02f, 5.12677729e-02f,
  -8.74818116e-03f, 2.55040713e-02f, -1.74432062e-03f, 7.05131665e-02f, -4.71701436e-02f, -1.16955645e-01f, 7.09426776e-02f, 7.47111291e-02f, -1.44403234e-01f, 2.47922853e-01f,
  7.13593125e-01f, -1.95711285e-01f, -1.50371104e-01f, 2.23202869e-01f, -1.98721111e-01f, -1.33863524e-01f, -1.86949894e-01f, 9.91246104e-02f, 1.33523986e-01f, -6.54356107e-02f,
  -1.92269534e-01f, 4.15358506e-02f, 4.71892916e-02f, 8.53581950e-02f, 1.51015878e-01f, -6.41266536e-03f, -9.98552665e-02f, 2.00557515e-01f, 3.48846227e-01f, 9.51297879e-02f,
  -1.36951983e-01f, 8.25914368e-02f, 1.44140810e-01f, 1.14887938e-01f, -5.91731705e-02f, 8.23383555e-02f, -7.63520673e-02f, -1.20093182e-01f, -2.68176705e-01f, -1.23265415e-01f,
  1.83041841e-02f, -1.10078178e-01f, 2.15264019e-02f, 6.13000430e-02f, -9.37978700e-02f, 1.56059712e-01f, 6.46249577e-02f, 2.95171998e-02f, -3.52688767e-02f, -7.40770102e-02f,
  -4.67767417e-02f, 2.73225876e-03f, 1.10590635e-02f, -1.00853428e-01f, -3.41891758e-02f, 3.09063941e-02f, -6.33931533e-02f, 9.66868773e-02f, 8.96387100e-02f, 1.08387098e-02f,
  -2.12082237e-01f, -1.96676433e-01f, -3.02674174e-02f, -1.08450674e-01f, -5.09422682e-02f, -3.36679853e-02f, -8.28599259e-02f, -2.78282743e-02f, -8.81200731e-02f, -4.83760796e-03f,
  1.36724012e-02f, -6.28967956e-03f, -2.98985410e-02f, -1.06689576e-02f, 3.24453861e-02f, 1.98387839e-02f, -2.43536420e-02f, -2.06370209e-03f, -3.16626485e-03f, 6.64907396e-02f,
  -4.68180068e-02f, -5.65104419e-03f, 4.17003110e-02f, 2.62808148e-02f, -2.00129542e-02f, -4.77380715e-02f, 7.69945160e-02f, -4.04064134e-02f, 1.73063902e-03f, 3.79538350e-02f,
  6.68408051e-02f, -3.48873250e-02f, -2.24014111e-02f, -2.84481850e-02f, -2.61629894e-02f, -2.86555085e-02f, 8.14983808e-03f, -2.62245368e-02f, 3.97584066e-02f, 2.45054029e-02f,
  1.56555980e-01f, -2.10163876e-01f, 1.10648476e-01f, -1.94132011e-02f, -2.41814014e-02f, -6.02078475e-02f, -5.36385030e-02f, -7.72456359e-03f, -3.84304672e-02f, 3.89179140e-02f,
  -2.27170549e-02f, 1.08564153e-01f, -2.13199239e-02f, -1.24444216e-02f, 8.64294544e-02f, 1.15786586e-02f, -8.10958445e-02f, -8.50526709e-03f, 4.65300977e-02f, -3.42936767e-03f,
  -2.33244132e-02f, 1.48429766e-01f, 1.44124255e-01f, 1.26690492e-01f, -1.47947844e-03f, 1.42008796e-01f, -5.85904047e-02f, 4.44642976e-02f, 1.37596205e-01f, 1.24095827e-01f,
  2.44911805e-01f, 2.49632940e-01f, -1.40445456e-02f, 2.39328921e-01f, -1.33165970e-01f, -3.50076765e-01f, -2.42883071e-01f, -1.19186759e-01f, 1.06976256e-02f, 1.37922093e-01f,
  9.11425725e-02f, 5.75770363e-02f, -1.88865177e-02f, 2.97814887e-02f, -6.23431429e-02f, 3.42758074e-02f, -1.22544263e-02f, -3.59283090e-02f, -3.49773020e-01f, -1.82233766e-01f,
  -6.17010482e-02f, 8.64267126e-02f, 9.39402506e-02f, 7.59269111e-04f, 1.47833824e-01f, -1.17280535e-01f, 1.26057267e-01f, 2.09236264e-01f, -8.66529867e-02f, 3.25014681e-01f,
  3.66302840e-02f, 3.63630861e-01f, -1.98196486e-01f, 4.74387370e-02f, -1.84540246e-02f, -6.09184988e-03f, -3.22208703e-02f, 9.38149169e-02f, -2.11539306e-02f, 1.92912016e-02f,
  2.46705227e-02f, 8.44970569e-02f, 5.31100519e-02f, 4.31746617e-02f, 1.90319903e-02f, 4.51391414e-02f, 1.43492699e-01f, 1.12415522e-01f, -1.14307888e-02f, 9.20433328e-02f,
  1.41690791e-01f, 1.06466420e-01f, 3.10181677e-02f, -9.20208246e-02f, 8.79092440e-02f, -1.64843686e-02f, 6.82771355e-02f, 1.31142125e-01f, -1.10437132e-01f, 1.76163003e-01f,
  1.97407138e-02f, -1.26530826e-02f, -3.35647389e-02f, 4.36923206e-02f, -1.13284411e-02f, -3.17066759e-02f, 7.68132135e-02f, -1.33128306e-02f, -4.85083759e-02f, 2.02131527e-03f,
  1.92125817e-03f, -4.59605269e-02f, 2.50580497e-02f, 3.11381109e-02f, 7.86020886e-03f, 2.30916440e-02f, -6.28687292e-02f, 3.27554457e-02f, 6.19900087e-03f, 3.48191448e-02f,
  -1.53364008e-02f, -5.98177873e-02f, 1.39177060e-02f, 8.28493014e-03f, 8.33268017e-02f, 1.87357645e-02f, -3.57938483e-02f, -6.77015167e-03f, 4.92054671e-02f, 3.34266499e-02f,
  -1.58919603e-01f, -5.02673239e-02f, -1.39915068e-02f, -4.65872288e-02f, 3.59469615e-02f, -3.34862396e-02f, 9.88969058e-02f, -6.67603081e-03f, 1.59461126e-02f, -9.55301989e-03f,
  -2.29215659e-02f, 4.34523039e-02f, 9.85416919e-02f, -5.09480052e-02f, -9.84894857e-02f, -8.29668418e-02f, 2.41473783e-02f, -7.03674778e-02f, -2.72947494e-02f, 4.35372293e-02f,
  3.60712036e-03f, -2.61839896e-01f, -2.35299766e-01f, -2.00921193e-01f, -1.77331883e-02f, -2.75654167e-01f, -1.84238985e-01f, -2.06193447e-01f, -2.78147012e-01f, -3.16702306e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.89954031e-01f, -6.06265254e-02f, 4.51837592e-02f, 1.70830145e-01f, 7.36556808e-03f, -1.12771004e-01f, -1.79989725e-01f, -9.14685428e-02f, -5.30759841e-02f, -5.15319295e-02f,
  -1.61547646e-01f, -1.29978983e-02f, 4.73193638e-02f, 2.15369150e-01f, 9.62702706e-02f, 1.82478547e-01f, 4.43414867e-01f, 2.86725998e-01f, 1.78751677e-01f, 2.10931487e-02f,
  1.80125341e-01f, 7.88143948e-02f, 1.29663751e-01f, 9.67046916e-02f, 2.19101131e-01f, 1.29002318e-01f, 1.52401075e-01f, 1.24140263e-01f, 9.08342972e-02f, 3.88518333e-01f,
  -2.15653270e-01f, -2.89237022e-01f, 1.93466302e-02f, 4.69191149e-02f, 6.38808310e-02f, -4.03736420e-02f, -1.57814696e-01f, -4.35715728e-02f, 1.37520637e-02f, -5.65768555e-02f,
  -2.13190336e-02f, -8.39776024e-02f, 7.93882981e-02f, -6.11608149e-03f, -9.32081640e-02f, -8.49800929e-02f, 3.01396232e-02f, 1.22516870e-01f, 1.12527244e-01f, -8.48758295e-02f,
  1.02323897e-01f, -1.71375163e-02f, -1.07493155e-01f, -2.83006541e-02f, -8.44123494e-03f, 2.51530204e-02f, -2.15985849e-02f, -1.05421349e-01f, -1.18762910e-01f, -2.09854573e-01f,
  7.02779219e-02f, -5.68002127e-02f, -1.06690988e-01f, 2.02386230e-02f, 3.41601372e-02f, -9.69411954e-02f, 1.11153468e-01f, 8.12046602e-02f, 1.27285838e-01f, -3.33688892e-02f,
  5.55927642e-02f, -1.06289148e-01f, 1.41645717e-02f, 4.74650897e-02f, 1.43033750e-02f, -2.39848681e-02f, -2.60364991e-02f, 4.80393618e-02f, -2.57531833e-02f, -6.74842158e-04f,
  7.69229932e-03f, -2.19168868e-02f, -4.15336005e-02f, 9.69942734e-02f, 2.05231234e-02f, 7.36127421e-02f, 1.21155605e-02f, -5.10564521e-02f, -1.16047919e-01f, -9.73392203e-02f,
  -2.04205692e-01f, 2.68183537e-02f, -7.14050699e-03f, -2.11759396e-02f, -3.31542566e-02f, 3.50644663e-02f, 4.42053104e-04f, 6.59287092e-04f, -1.09467460e-02f, -1.26001909e-01f,
  -2.73083840e-02f, -3.69138978e-02f, -6.18741214e-02f, -9.59103275e-03f, -1.92180835e-02f, -3.74369808e-02f, 2.50815880e-03f, 5.48521616e-02f, 3.31594632e-03f, -1.27154663e-01f,
  1.18342536e-02f, -2.03011766e-01f, -2.69763201e-01f, -1.47461027e-01f, -1.33790508e-01f, -1.17155209e-01f, -2.45203331e-01f, -2.15848073e-01f, -3.21203679e-01f, -3.65207732e-01f,
  -4.71232422e-02f, 1.46905839e-01f, 7.45793357e-02f, -2.79417001e-02f, 2.93223113e-02f, -2.22659148e-02f, 1.09114900e-01f, -4.25375924e-02f, -6.71567395e-02f, -1.71740577e-02f,
  6.46580160e-02f, 4.63812761e-02f, -1.13359697e-01f, 1.82061531e-02f, -3.77425142e-02f, 1.58855125e-01f, 1.10716887e-01f, -3.79135869e-02f, 1.62918773e-02f, 6.44623265e-02f,
  1.41005386e-02f, 1.49279058e-01f, -8.19084197e-02f, 8.23372751e-02f, 1.41750723e-01f, 2.81658350e-03f, 1.84591282e-02f, 7.41745681e-02f, 5.61256148e-02f, 3.11381966e-01f,
  3.26607376e-01f, -1.75642110e-02f, -1.47929564e-01f, -5.50543070e-02f, 1.57909673e-02f, -2.37803478e-02f, 4.22094315e-02f, 6.28502369e-02f, -4.38880585e-02f, 3.18996720e-02f,
  -1.00487536e-02f, -5.01947068e-02f, 2.92103365e-03f, -6.79038167e-02f, -7.13808388e-02f, -8.37643668e-02f, -5.51415049e-03f, -9.91875157e-02f, -4.03365418e-02f, 1.24886137e-04f,
  7.36745670e-02f, -1.26843364e-03f, -5.25971279e-02f, -1.23171896e-01f, -8.62875432e-02f, -4.55435850e-02f, -6.93577528e-02f, 5.77558316e-02f, -1.38156459e-01f, -6.56240582e-02f,
  4.48728865e-03f, -7.45230541e-02f, 7.67831877e-02f, -4.73032445e-02f, -1.43476024e-01f, 2.91838422e-02f, 2.82585546e-02f, -4.07752991e-02f, -5.30782039e-04f, -1.16434619e-01f,
  -1.23714218e-02f, -4.44083810e-02f, -4.37655300e-02f, -8.91848095e-03f, -7.57583752e-02f, 7.53485486e-02f, 1.77815463e-02f, 2.31228815e-03f, -5.84638156e-02f, -3.37559953e-02f,
  -3.36913019e-02f, -1.42113650e-02f, 1.56007363e-02f, 1.95681909e-03f, -6.23476841e-02f, -3.65446545e-02f, -5.96439876e-02f, -6.56606033e-02f, -5.15275225e-02f, 3.26630585e-02f,
  1.12472996e-02f, -2.06546977e-01f, 5.15725240e-02f, 3.06782350e-02f, 1.04916334e-01f, 4.13361490e-02f, -8.62052385e-03f, 7.44667575e-02f, 1.91452038e-02f, 1.45282090e-01f,
  1.43673673e-01f, 3.17460746e-02f, 1.23156244e-02f, -4.71594259e-02f, -3.64918336e-02f, -2.16746181e-02f, -8.28038082e-02f, 1.25979841e-01f, 6.11727312e-02f, 1.14910029e-01f,
  -3.36385914e-03f, 1.40742846e-02f, -3.97052020e-02f, -7.59328008e-02f, 8.54265392e-02f, -1.89254172e-02f, 8.66424814e-02f, 1.74828824e-02f, 7.88880289e-02f, -8.72360766e-02f,
  5.11335954e-02f, 1.07972346e-01f, 2.49822754e-02f, 7.41765648e-02f, 2.97659021e-02f, 1.47838131e-01f, 1.28119841e-01f, 3.60474773e-02f, -2.60197744e-02f, 1.31766737e-01f,
  1.30426094e-01f, -7.10075498e-02f, -1.21676177e-02f, -7.57024214e-02f, -1.57661736e-02f, -1.63424090e-02f, 9.37774628e-02f, 9.83391106e-02f, 6.28097877e-02f, 9.08640325e-02f,
  1.14609390e-01f, 6.37939200e-02f, -1.41642513e-02f, 9.14171711e-02f, -1.83367170e-02f, -9.62311476e-02f, -6.98388182e-03f, 1.40539810e-01f, -2.26977449e-02f, 1.05924837e-01f,
  5.69516905e-02f, 2.38388628e-01f, -8.13114271e-03f, 3.54653760e-03f, 7.79481530e-02f, -3.26498188e-02f, 2.26668864e-02f, -7.69268200e-02f, 9.41529684e-03f, -6.61621466e-02f,
  6.08069748e-02f, 4.41402532e-02f, -1.61214564e-02f, 6.10793158e-02f, -5.96852861e-02f, 9.43358913e-02f, 1.09190140e-02f, 2.66303960e-02f, -3.86294536e-02f, 6.46472126e-02f,
  3.00431754e-02f, 9.98755638e-03f, 1.06427088e-01f, 1.58816198e-04f, -4.84431535e-02f, 1.98864862e-02f, 1.73872430e-02f, 7.37165287e-02f, 5.10996245e-02f, 1.04924000e-03f,
  -5.72264567e-02f, -7.44897425e-02f, 4.74268161e-02f, 2.81596221e-02f, 3.03727295e-02f, -3.60830761e-02f, -2.43264511e-02f, -3.34580280e-02f, 5.43301478e-02f, 5.19186966e-02f,
  -8.07315484e-02f, 5.44826128e-02f, 1.83312092e-02f, 3.47592705e-03f, -4.18697856e-02f, 9.52556506e-02f, 3.46402079e-02f, 1.19688706e-02f, -1.54859954e-02f, 8.35263059e-02f,
  7.61328731e-03f, -3.43717001e-02f, -1.86844300e-02f, 7.59676099e-03f, -4.08892967e-02f, 5.15936911e-02f, -6.54892400e-02f, 8.02080408e-02f, 7.33585507e-02f, -1.12457462e-02f,
  -3.97084951e-02f, 6.86828047e-02f, 7.00140223e-02f, -4.73521432e-05f, 1.21958805e-02f, 5.71557926e-03f, 8.40722024e-03f, 1.21486045e-01f, 6.98481873e-02f, 7.80284256e-02f,
  1.80551205e-02f, 4.65189293e-02f, 8.56694877e-02f, 3.87483351e-02f, -5.00018746e-02f, -7.85132796e-02f, -2.54316181e-02f, 9.73568261e-02f, 4.91070151e-02f, 1.15988664e-02f,
  6.65572733e-02f, 5.10514937e-02f, -6.07477967e-03f, 4.22221944e-02f, 3.09297983e-02f, -4.13618833e-02f, -3.72635797e-02f, -7.36497268e-02f, -2.21446928e-04f, -9.89070311e-02f,
  3.09501082e-01f, 1.85960725e-01f, -1.85814008e-01f, 1.84116103e-02f, -1.21185623e-01f, -7.74771497e-02f, 2.54344847e-02f, 8.02683830e-02f, 1.55272916e-01f, 1.00256860e-01f,
  9.83555391e-02f, 4.65711616e-02f, 1.31564252e-02f, -9.64169651e-02f, 3.66404131e-02f, -5.61016286e-03f, -6.31488785e-02f, -8.60397369e-02f, 2.26122010e-02f, 4.84320186e-02f,
  6.88252524e-02f, 1.37989363e-02f, 1.88815951e-01f, 7.61573315e-02f, 5.09113483e-02f, -4.68786247e-02f, 2.64811311e-02f, 8.06736667e-03f, 6.35771602e-02f, -7.65868947e-02f,
  -1.80575192e-01f, -8.46467018e-02f, -4.78986874e-02f, 1.55723840e-01f, -7.50257969e-02f, 6.28161430e-02f, 1.18804984e-01f, 8.43792558e-02f, 9.56178978e-02f, 5.39625399e-02f,
  7.25728273e-02f, 3.53411073e-03f, -5.50900996e-02f, 9.00372043e-02f, 2.16250308e-02f, -3.39987427e-02f, 7.12351128e-02f, 4.20519710e-02f, -4.22175750e-02f, -2.50027981e-02f,
  -6.16979375e-02f, -8.27983394e-03f, -1.29814431e-01f, -2.63626426e-02f, -1.08650923e-01f, -1.09576389e-01f, -7.18097985e-02f, 3.07868198e-02f, -8.40012506e-02f, 5.97554073e-02f,
  5.81634864e-02f, 5.95046058e-02f, -8.84862840e-02f, 6.86317608e-02f, 2.66322196e-02f, -1.65588073e-02f, -8.33799243e-02f, 1.80106517e-02f, -4.43121903e-02f, 6.21551797e-02f,
  -4.55256030e-02f, -1.24634113e-02f, 1.72834168e-03f, -3.07317674e-02f, -6.73336089e-02f, -1.13076769e-01f, -5.20972498e-02f, -4.05317964e-03f, -5.76561615e-02f, 8.76900405e-02f,
  -3.23391370e-02f, -7.04214498e-02f, -8.80654603e-02f, -8.46529901e-02f, -3.88350189e-02f, 2.22324282e-02f, -5.98900095e-02f, -8.01473334e-02f, -6.05596155e-02f, 7.43363872e-02f,
  1.10895857e-01f, -2.16036454e-01f, -4.43991460e-02f, 6.49924278e-02f, -2.28362475e-02f, 7.91275650e-02f, -6.42968938e-02f, -3.38613875e-02f, -4.93546054e-02f, 3.20994034e-02f,
  4.38989848e-02f, 7.30564147e-02f, -4.27648239e-02f, 9.02521424e-03f, 8.89901668e-02f, 6.97567388e-02f, 2.68922541e-02f, -4.39560637e-02f, 6.20608851e-02f, -5.75914606e-02f,
  6.86451867e-02f, 1.05340116e-01f, 8.45407844e-02f, -2.14675274e-02f, -3.48406993e-02f, 3.29351723e-02f, 1.77185945e-02f, 7.06771016e-02f, -5.65246269e-02f, 1.94170296e-01f,
  1.81910782e-05f, 2.58820131e-02f, -1.13224998e-01f, 1.87626377e-01f, -8.55072401e-03f, -1.84799895e-01f, -3.51742357e-01f, -1.53643683e-01f, -6.41357079e-02f, 3.24059911e-02f,
  4.66452949e-02f, 1.24173984e-01f, 7.08186394e-03f, -1.34228487e-02f, -5.65688983e-02f, 8.43865350e-02f, 1.52058110e-01f, 1.76812336e-01f, 8.12596679e-02f, 1.20969534e-01f,
  1.56406537e-01f, 2.76489526e-01f, 1.28995717e-01f, 3.65765989e-02f, 2.76870638e-01f, 1.33961663e-01f, 2.52688136e-02f, 1.34710923e-01f, 1.30619302e-01f, 3.92214984e-01f,
  1.13585472e-01f, -1.40281886e-01f, -9.95465294e-02f, 1.79555476e-01f, 3.24785337e-02f, -4.79008146e-02f, 1.13518881e-02f, -5.67170680e-02f, -8.91694650e-02f, 7.32813776e-02f,
  2.78532077e-02f, 1.31186262e-01f, -3.50273475e-02f, 4.25963737e-02f, -1.82524079e-03f, -6.03927672e-03f, -3.25299390e-02f, -1.13056235e-01f, -1.61022142e-01f, -3.31417732e-02f,
  1.16820469e-01f, 1.38128132e-01f, -7.27942511e-02f, -1.75188795e-01f, -1.12871334e-01f, 9.98378620e-02f, -1.40783474e-01f, 1.28126973e-02f, -1.66242674e-01f, 2.50162147e-02f,
  1.17672747e-02f, 6.13749810e-02f, 4.59103361e-02f, 6.71442598e-02f, -1.64057724e-02f, 6.87697902e-02f, 3.33059323e-03f, 4.80153449e-02f, -5.39055467e-02f, -4.35366714e-03f,
  -8.54424909e-02f, 2.75464226e-02f, 2.78586242e-02f, -4.87218685e-02f, 5.82100227e-02f, 2.48862859e-02f, -3.53827253e-02f, 7.47563839e-02f, -2.48574819e-02f, -1.63327828e-02f,
  7.29845464e-02f, -8.99240449e-02f, 1.48649607e-02f, 3.93547080e-02f, -3.93028893e-02f, 5.52692600e-02f, 5.92349321e-02f, -1.97633058e-02f, 8.15148354e-02f, 2.99903029e-03f,
  -6.86741099e-02f, -2.19262987e-01f, 1.85877860e-01f, -1.11271795e-02f, -5.90051245e-03f, -2.62598228e-03f, 9.46901068e-02f, -1.05631307e-01f, 2.60937531e-02f, 8.72232951e-03f,
  -3.00751068e-02f, -7.38375410e-02f, -4.15724218e-02f, -7.16150505e-03f, 8.20147712e-03f, -9.55980197e-02f, 3.99089977e-02f, -2.84787957e-02f, -1.17147923e-03f, 1.38524808e-02f,
  -7.37731531e-02f, -4.82080765e-02f, -1.57155544e-01f, -1.14806443e-01f, -1.31234601e-01f, 2.41937563e-02f, -7.74967447e-02f, -1.07682817e-01f, -1.80951938e-01f, -1.16898745e-01f,
  -5.03960298e-03f, -2.77753592e-01f, -4.15928274e-01f, -3.15338463e-01f, -3.04845035e-01f, -1.08791567e-01f, -2.37831727e-01f, 4.73040417e-02f, -1.60310641e-02f, -2.49339029e-01f,
  -1.27923295e-01f, -1.58676896e-02f, -1.75400332e-01f, -3.64569239e-02f, -1.58745468e-01f, -3.28446329e-01f, -4.85194772e-01f, -3.17606837e-01f, -1.54664917e-02f, -6.36160225e-02f,
  -1.67170927e-01f, -3.06371957e-01f, -7.26713315e-02f, -1.21888839e-01f, -3.19542199e-01f, -2.60032594e-01f, -4.83875573e-01f, -2.27092311e-01f, -1.96046799e-01f, -3.98625523e-01f,
  -3.60439181e-01f, 2.00831547e-01f, 3.32553983e-02f, -1.10357450e-02f, -1.55282050e-01f, 1.27618974e-02f, 7.18508065e-02f, -3.94388102e-02f, -1.37677724e-02f, -2.53397841e-02f,
  2.12383047e-02f, 6.45481199e-02f, -2.51269937e-02f, 7.77065456e-02f, 3.13335322e-02f, 1.86221208e-02f, -3.68767447e-04f, -1.02330567e-02f, -3.97530049e-02f, 4.78609055e-02f,
  -3.52594890e-02f, -5.81915118e-03f, 2.57468950e-02f, -3.01506855e-02f, 1.16732754e-02f, 2.55714618e-02f, -1.23622117e-03f, 2.15489585e-02f, -1.41269034e-02f, -2.37973273e-01f,
  -3.07919122e-02f, 1.08063072e-02f, 1.48858018e-02f, 5.19266166e-02f, 4.63165641e-02f, 1.49120269e-02f, 2.18072161e-03f, -4.53706756e-02f, 3.20978984e-02f, -6.90701008e-02f,
  4.49126475e-02f, -4.60947640e-02f, -4.06362414e-02f, 6.46654889e-02f, -7.36628026e-02f, -2.42273677e-02f, -3.07144374e-02f, -2.88042594e-02f, -3.58035527e-02f, -3.19070555e-02f,
  2.07606610e-02f, 8.58875550e-03f, -6.27486594e-03f, 6.40593171e-02f, -8.31067339e-02f, -8.61399099e-02f, 4.90104742e-02f, 2.14782897e-02f, 2.49324454e-04f, 3.41405123e-02f,
  -1.04652338e-01f, 6.30035670e-03f, -6.70836717e-02f, 4.07559015e-02f, -1.25778154e-01f, -2.19615363e-02f, -4.48497646e-02f, 5.29237017e-02f, -2.57279854e-02f, -1.27045186e-02f,
  1.09180592e-01f, 1.44384494e-02f, -8.39851350e-02f, -2.44466700e-02f, 9.92318094e-02f, 9.01139826e-02f, -1.41489670e-01f, -3.71424593e-02f, 3.85676511e-02f, 2.79918704e-02f,
  -2.45881546e-02f, 7.12885708e-03f, 5.93058132e-02f, -1.79854855e-02f, 2.46028863e-02f, -2.10506842e-02f, -1.69033688e-02f, -8.09080303e-02f, -4.58527990e-02f, -1.39211223e-01f,
  -5.09987734e-02f, -1.33313134e-01f, -2.97338776e-02f, 2.37423792e-01f, 1.39028668e-01f, 2.13138670e-01f, 1.43902048e-01f, 1.19648717e-01f, 1.89244881e-01f, 1.57122612e-01f,
  1.43589541e-01f, 1.83935285e-01f, 1.27013177e-01f, 1.85070261e-01f, 1.17908336e-01f, 1.35168200e-02f, 9.26782489e-02f, 1.21256426e-01f, 1.79673672e-01f, 3.41691077e-02f,
  1.19701512e-01f, -1.46387359e-02f, -4.17829007e-02f, -6.75477684e-02f, -2.59535331e-02f, 9.60711837e-02f, 4.42788824e-02f, -1.27807140e-01f, -8.90473202e-02f, 1.60107657e-03f,
  -7.23112449e-02f, -2.93725114e-02f, 1.66985795e-01f, 1.81156341e-02f, -3.19563635e-02f, -8.74150321e-02f, -1.12751245e-01f, -1.99013557e-02f, -4.73705456e-02f, -1.69898212e-01f,
  6.04426768e-03f, -7.01644495e-02f, 8.01440105e-02f, 4.10526613e-04f, -1.56710893e-02f, -9.79028046e-02f, -1.17056854e-01f, -5.67007251e-02f, 4.62165754e-03f, 3.73952575e-02f,
  1.14984261e-02f, -6.87170699e-02f, -9.32179168e-02f, 2.30941884e-02f, 3.41164283e-02f, 4.88870628e-02f, -1.10335492e-01f, 4.07388918e-02f, 4.36915495e-02f, -1.34729981e-01f,
  -2.92951763e-02f, 4.26216424e-02f, 7.26446211e-02f, -7.43896291e-02f, 5.51509894e-02f, 4.32194769e-02f, -5.37896566e-02f, 4.02152017e-02f, 7.33764917e-02f, -4.69870754e-02f,
  5.98541759e-02f, 6.49055913e-02f, 8.41228217e-02f, 4.01574932e-02f, -3.74958403e-02f, -6.47683218e-02f, 2.62482185e-03f, -3.38914096e-02f, -4.63798344e-02f, -7.63416290e-02f,
  -5.82395419e-02f, -2.76308153e-02f, -1.11480944e-01f, -5.93230650e-02f, 5.90104461e-02f, 9.38281119e-02f, -1.19593891e-03f, 1.90989599e-02f, -3.33779231e-02f, -1.89949330e-02f,
  1.89499464e-02f, 1.97388873e-01f, 6.38808496e-03f, -3.21564935e-02f, -3.61788571e-02f, -3.34520563e-02f, 7.09905177e-02f, -5.09955212e-02f, -1.18594274e-01f, -2.55374089e-02f,
  -5.18802973e-03f, 1.04457652e-02f, 3.00656259e-02f, 2.76898388e-02f, -3.16814855e-02f, -6.38559982e-02f, -4.38804366e-02f, 9.97750387e-02f, 2.54115406e-02f, 2.37979852e-02f,
  7.92093799e-02f, 3.00393091e-03f, 5.65760955e-02f, 2.43395157e-02f, 4.22363319e-02f, 1.14017412e-01f, -3.98619957e-02f, -1.25274643e-01f, -3.85251045e-02f, -6.11548908e-02f,
  6.73719645e-02f, -1.64666831e-01f, 2.14962915e-01f, 1.77883543e-02f, 1.75690427e-01f, 2.52951235e-01f, 1.95757151e-01f, 6.12542704e-02f, 4.64517921e-02f, 3.24825719e-02f,
  -1.67449266e-01f, -7.97697529e-02f, -1.08146019e-01f, -1.47069454e-01f, 3.58924246e-03f, 7.49153793e-02f, 1.34243041e-01f, 1.65126815e-01f, 1.07423842e-01f, 1.53544312e-02f,
  -3.76680605e-02f, 2.14780215e-02f, 7.20470864e-03f, -2.22368841e-03f, -1.29948631e-01f, -1.67141631e-02f, -5.30125275e-02f, -1.14884460e-02f, -5.81344329e-02f, 2.46081911e-02f,
  -1.00108251e-01f, -8.04328173e-02f, 3.48985121e-02f, -7.91610926e-02f, -7.41015673e-02f, 2.56309118e-02f, -2.36655343e-02f, -7.69493729e-02f, -9.09625844e-04f, -7.58971050e-02f,
  -7.16712996e-02f, -1.38155192e-01f, -2.86094379e-02f, -7.57096410e-02f, 3.00465077e-02f, -2.68490352e-02f, 1.00273304e-02f, -1.36271492e-01f, -5.97180389e-02f, -1.48397818e-01f,
  -4.15884443e-02f, -6.82218596e-02f, 2.77184583e-02f, 2.68491101e-03f, 1.35000208e-02f, -4.87323292e-02f, -3.98000237e-03f, -1.92920398e-02f, 7.33754337e-02f, -3.85917835e-02f,
  8.08137804e-02f, -8.42217077e-03f, 4.88420092e-02f, -7.49365166e-02f, 2.77482662e-02f, -1.47645017e-02f, 5.21214530e-02f, 6.43703118e-02f, -1.36886854e-02f, -3.46897803e-02f,
  -1.62236057e-02f, -4.94082551e-03f, -6.15568012e-02f, 4.29392084e-02f, -4.67460193e-02f, 3.65929790e-02f, -1.21772345e-02f, -9.06347472e-04f, -6.12114631e-02f, 7.07370490e-02f,
  6.27078712e-02f, -4.57288399e-02f, -5.12447469e-02f, -7.11515173e-02f, 8.21297150e-03f, 5.10258079e-02f, -3.18536386e-02f, -8.92277509e-02f, -7.59316683e-02f, 8.13522488e-02f,
  -7.00757578e-02f, 4.12771245e-03f, 8.64733309e-02f, -5.66655397e-02f, 1.19641900e-01f, -6.07481152e-02f, -1.27829853e-02f, -6.16874285e-02f, 8.28547180e-02f, 2.84764115e-02f,
  3.51898670e-02f, 5.09813726e-02f, -2.60461442e-04f, 7.43039465e-03f, 9.50253904e-02f, 1.37415573e-01f, -5.76615930e-02f, 1.07361436e-01f, -2.54407665e-03f, -1.45506012e-04f,
  -7.52897840e-03f, 6.77150786e-02f, 7.66394213e-02f, 7.96374008e-02f, 1.98850892e-02f, 1.94491863e-01f, 4.39695083e-02f, 2.55342224e-03f, 1.03936255e-01f, 3.36385742e-02f,
  5.36447801e-02f, -2.35445112e-01f, 2.40271822e-01f, -1.38178263e-02f, 3.03670131e-02f, 1.10038757e-01f, 1.43928498e-01f, -7.28711560e-02f, 7.33731240e-02f, 3.81952710e-02f,
  -6.64212648e-03f, 5.64746074e-02f, 2.85638720e-02f, -6.02594055e-02f, 7.02658654e-05f, -1.58997290e-02f, 1.28210232e-01f, 1.07026152e-01f, 2.07609072e-01f, 2.07990780e-01f,
  -8.47642943e-02f, 2.54029445e-02f, -1.04139321e-01f, 5.66115491e-02f, 5.85510843e-02f, -2.23228540e-02f, -8.50979909e-02f, 1.01931900e-01f, 1.06392168e-01f, 1.05365939e-01f,
  2.90039718e-01f, -6.60797060e-02f, 9.41248760e-02f, -3.50662284e-02f, 1.29920067e-02f, 4.09128331e-02f, 2.65723225e-02f, 1.63587891e-02f, -1.26442447e-01f, -8.35130364e-02f,
  1.90010034e-02f, -5.54714762e-02f, 2.44649407e-02f, 4.29012179e-02f, -6.21229410e-02f, -9.77841169e-02f, -1.23625942e-01f, -6.43137693e-02f, -1.03371106e-01f, -6.33255055e-04f,
  -1.06134713e-01f, 1.28254801e-01f, 1.13976277e-01f, 5.03976010e-02f, -4.44706855e-03f, -6.43756613e-02f, 6.24681376e-02f, -2.48009805e-02f, 2.91775949e-02f, -8.36065933e-02f,
  -2.93901423e-03f, 9.65049341e-02f, -1.25418073e-02f, 1.66203436e-02f, 7.80132040e-02f, -3.01336800e-03f, -3.18980776e-02f, 1.93638485e-02f, -1.94761355e-03f, -2.98877116e-02f,
  3.97154428e-02f, -1.83237754e-02f, -9.93595738e-03f, 5.27856871e-02f, -1.36691025e-02f, -1.80205293e-02f, 3.98525558e-02f, -9.42836106e-02f, 6.30888119e-02f, -8.75450019e-03f,
  8.41277093e-03f, 5.50394580e-02f, -1.70389507e-02f, -5.67607880e-02f, 5.90115562e-02f, -4.52491306e-02f, 4.00928743e-02f, -2.10688449e-03f, 1.49712758e-02f, 4.94260043e-02f,
  4.82502170e-02f, -6.03877380e-02f, 1.15759529e-01f, -5.72133064e-02f, 4.92993407e-02f, 2.91466825e-02f, -7.77818402e-03f, -2.13420596e-02f, -3.87902670e-02f, -8.84839334e-04f,
  2.63813585e-02f, 7.05213249e-02f, -3.77843045e-02f, -3.32715549e-02f, 1.01971172e-01f, 4.98925988e-03f, 3.37678008e-02f, -9.43609979e-03f, 3.15792784e-02f, -4.01676111e-02f,
  -6.30946010e-02f, 2.88756210e-02f, 1.52772382e-01f, 1.27260000e-01f, -4.48279902e-02f, 1.77700892e-01f, 1.35574430e-01f, 2.94839628e-02f, 6.54337257e-02f, 4.24075797e-02f,
  -3.37815464e-01f, -4.17728089e-02f, -1.26828581e-01f, 8.34582075e-02f, 1.80605426e-01f, 1.06167234e-01f, 7.63434097e-02f, 9.72986817e-02f, -3.82773466e-02f, 3.32695134e-02f,
  5.44929318e-02f, 6.74137250e-02f, 1.59600213e-01f, 7.13617876e-02f, -1.24048945e-02f, 9.84738991e-02f, 4.54543233e-02f, 1.27788156e-01f, -2.33617648e-02f, 9.04917195e-02f,
  1.49830461e-01f, 5.57222264e-03f, -1.60263956e-01f, -3.39389965e-03f, 2.57820096e-02f, 1.06528580e-01f, 6.86767325e-02f, -3.51450220e-02f, 4.68692742e-02f, 1.71572998e-01f,
  -1.18212309e-02f, -2.06661388e-01f, 6.18530214e-02f, 9.24509913e-02f, -2.40663961e-02f, -8.63107517e-02f, -8.64281505e-02f, -1.33739516e-01f, -6.26930669e-02f, -1.08620645e-02f,
  -7.37220645e-02f, -9.68333613e-03f, -1.97894145e-02f, 7.52355205e-03f, -5.80034172e-03f, 4.82122749e-02f, -1.64317358e-02f, 5.61110862e-02f, 5.83974607e-02f, 4.70469072e-02f,
  1.17426693e-01f, 5.74205928e-02f, 3.37077770e-03f, -3.53907198e-02f, 3.06647420e-02f, 4.27131541e-02f, 3.91159952e-02f, -9.22079012e-02f, -4.10225242e-02f, -2.71658693e-02f,
  -5.58291096e-03f, 5.96660003e-02f, 6.87294081e-02f, 1.56257208e-02f, 8.41788054e-02f, 6.53785467e-02f, 4.59253155e-02f, -1.50402626e-02f, -7.69970287e-03f, 3.86460647e-02f,
  5.66743426e-02f, 4.97157276e-02f, -2.64358465e-02f, -9.14523099e-03f, 1.32974625e-01f, 5.00520803e-02f, 2.20638085e-02f, 4.52629924e-02f, 1.40678632e-04f, 3.20421904e-02f,
  -2.59946696e-02f, 7.84744415e-03f, -3.67373340e-02f, 8.28676578e-03f, -3.56571823e-02f, -6.47616088e-02f, 9.19286236e-02f, -3.49463932e-02f, 1.59282014e-02f, -6.92368150e-02f,
  -1.36242032e-01f, -1.07390530e-01f, -2.35682502e-02f, 9.08648744e-02f, -2.07667984e-03f, -9.31954607e-02f, 7.07743764e-02f, 4.13806662e-02f, -1.75507050e-02f, 1.24040321e-02f,
  -1.39397904e-01f, 4.66343984e-02f, 4.89767157e-02f, -8.17646086e-02f, 3.96821052e-02f, -8.54179636e-02f, 4.45585586e-02f, 8.97197053e-02f, -5.16419820e-02f, -9.31380540e-02f,
  8.79809409e-02f, 9.29550920e-03f, -8.69821981e-02f, 8.55994523e-02f, 5.14539033e-02f, 1.25929326e-01f, -2.06864215e-02f, 1.74566358e-02f, 1.38596143e-03f, -6.57340884e-02f,
  3.72108310e-01f, -8.37897733e-02f, 2.24187955e-01f, 7.77678490e-02f, 1.65741425e-02f, 1.47539647e-02f, -3.06628756e-02f, -7.70954564e-02f, 4.26494926e-02f, -1.26411006e-01f,
  -1.39822975e-01f, -1.86158136e-01f, -1.24713950e-01f, -4.37992327e-02f, -5.06376922e-02f, 2.91598346e-02f, 1.26627609e-01f, 3.18546891e-01f, 1.71796530e-01f, 8.93536881e-02f,
  -2.38187183e-02f, 1.46795079e-01f, 1.26672268e-01f, 1.35723442e-01f, 1.06428638e-01f, -4.80559003e-03f, 1.86628047e-02f, 9.85935479e-02f, 8.25278461e-03f, 1.49544835e-01f,
  4.22628969e-03f, 1.08347408e-01f, 4.92665097e-02f, -7.36463442e-02f, -1.00800484e-01f, -1.77420918e-02f, -5.59401661e-02f, 8.53732973e-02f, -7.10826414e-03f, 2.98072118e-03f,
  -3.38007547e-02f, 8.66277069e-02f, -3.99141386e-02f, 6.70684874e-02f, 3.49049503e-03f, 2.44193021e-02f, -3.12840589e-03f, 1.66965470e-01f, -5.09720817e-02f, -2.71755550e-02f,
  -6.43077940e-02f, -9.23757777e-02f, 1.08101522e-04f, -1.20888524e-01f, 2.12735310e-02f, -6.47074170e-03f, -1.65191755e-01f, -6.75149485e-02f, -4.87307012e-02f, 1.02464631e-01f,
  -3.99786718e-02f, 5.30782491e-02f, -5.03731668e-02f, -9.35053751e-02f, -2.86613498e-02f, -5.98058030e-02f, 9.40625146e-02f, -6.09227680e-02f, -3.14401239e-02f, 2.50649676e-02f,
  3.59008834e-02f, 5.89912161e-02f, -4.23959941e-02f, 2.48824209e-02f, 3.19648236e-02f, -6.24041222e-02f, -2.68114191e-02f, 9.68378503e-03f, -5.39868027e-02f, -3.81361246e-02f,
  7.83717632e-02f, -3.14323045e-02f, -2.40440499e-02f, 2.78504509e-02f, -3.19085754e-02f, -2.33097933e-02f, 7.79543892e-02f, -5.74930944e-02f, 3.53518575e-02f, -2.22513787e-02f,
  -2.27426589e-01f, -1.58164680e-01f, 9.47312564e-02f, 8.55699927e-02f, -1.46601321e-02f, 3.10626868e-02f, -1.42351976e-02f, -2.19733994e-02f, -1.01942070e-01f, -4.16356213e-02f,
  -6.01992011e-02f, 6.91849887e-02f, -1.12716295e-02f, -4.64090779e-02f, 8.69451389e-02f, 1.01804964e-01f, -9.41014290e-02f, 1.35148272e-01f, 4.03744392e-02f, -2.45146491e-02f,
  1.75241251e-02f, 1.31670162e-01f, 3.85269485e-02f, -9.08440277e-02f, 8.79732240e-03f, 9.09513980e-02f, -3.98596525e-02f, 2.63630855e-03f, 2.04292759e-02f, 4.13450152e-02f,
  3.87216061e-01f, -3.81320626e-01f, 1.75997645e-01f, 9.89928748e-03f, 7.37142051e-03f, 8.19342677e-03f, -1.90213025e-01f, -9.77937430e-02f, -5.77078154e-03f, -1.15258791e-01f,
  -4.87692170e-02f, 9.60543081e-02f, 2.35365301e-01f, 1.58037558e-01f, 7.36598670e-02f, -1.37041643e-01f, 4.78718095e-02f, 1.72960058e-01f, 3.60056669e-01f, 1.27198072e-02f,
  -3.18552628e-02f, -1.04221754e-01f, 2.04905048e-02f, 4.87930179e-02f, -1.39365181e-01f, 3.04214619e-02f, -3.23565267e-02f, -4.15555537e-02f, -4.37572934e-02f, -2.67442584e-01f,
  9.56711769e-02f, -5.72159700e-03f, 1.76406056e-01f, 6.69487640e-02f, 2.56901374e-03f, 4.12949771e-02f, 2.69530173e-02f, -5.24105430e-02f, 7.67339170e-02f, 3.09467167e-02f,
  2.23009158e-02f, 5.58210798e-02f, -6.29696175e-02f, -5.41502424e-02f, -5.78510575e-02f, -2.60159988e-02f, -6.01459220e-02f, 4.82595637e-02f, 2.14628447e-02f, -1.19212538e-01f,
  -1.73737258e-01f, 1.09843113e-01f, 5.90624139e-02f, 2.35613268e-02f, 6.50609210e-02f, 2.49156222e-01f, -4.21075262e-02f, -6.85116136e-03f, 4.37544696e-02f, -1.22235626e-01f,
  7.37937447e-03f, 3.33648212e-02f, 8.02569687e-02f, 1.03207016e-02f, -2.57258955e-02f, -1.32776288e-04f, 1.41701102e-01f, -4.59033772e-02f, -1.38738891e-02f, -9.16920006e-02f,
  5.07327616e-02f, 9.85945389e-02f, -3.19366306e-02f, 5.64887486e-02f, 3.44447792e-03f, -3.00832670e-02f, -7.14407861e-02f, -1.50350165e-02f, -6.05411232e-02f, -8.56909007e-02f,
  -1.11830235e-02f, 4.55644764e-02f, -8.32384266e-03f, 1.59949157e-02f, -3.13194767e-02f, 6.62058890e-02f, 1.50514022e-02f, -7.37642422e-02f, -2.26419549e-02f, -7.10317418e-02f,
  -1.61691308e-01f, 4.15133595e-01f, -2.02156380e-02f, 5.91476588e-03f, 9.16460063e-03f, -2.27578487e-02f, 1.20172556e-02f, -1.88995097e-02f, -4.84691374e-02f, -1.21409411e-03f,
  -8.89705420e-02f, 7.52370059e-02f, -1.08727836e-03f, -1.72625422e-01f, 6.75662681e-02f, -4.36948091e-02f, -1.37548283e-01f, 1.09653890e-01f, 1.14876777e-01f, -8.46241862e-02f,
  -6.43482804e-02f, 1.39288679e-01f, 2.65568048e-01f, 1.78236499e-01f, -2.79047582e-02f, 2.65102297e-01f, 6.46622777e-02f, 6.70501143e-02f, 3.03500354e-01f, 1.03539545e-02f,
  -2.10942432e-01f, 2.39915624e-01f, -1.94731534e-01f, -1.37556002e-01f, -6.49093091e-02f, -1.43219352e-01f, 1.15900025e-01f, 1.95966810e-02f, 2.83676777e-02f, 6.47396967e-02f,
  1.65714949e-01f, 2.12820768e-01f, 7.42395073e-02f, 8.65023583e-03f, 4.02562991e-02f, 1.06858276e-01f, -1.40470937e-01f, -2.14972079e-01f, 1.23482826e-03f, 4.23452929e-02f,
  -6.06605895e-02f, 1.72061920e-02f, -7.57939368e-02f, 2.03741957e-02f, 1.00892223e-01f, 1.14201067e-03f, 1.17116399e-01f, -9.54368114e-02f, -1.69458408e-02f, -3.81466821e-02f,
  2.59964943e-01f, -3.13953966e-01f, 3.98355362e-04f, -4.16973382e-02f, -7.81701785e-03f, 9.88542140e-02f, 2.33149603e-02f, -1.65515281e-02f, -4.95869899e-03f, 1.25958428e-01f,
  -8.98537785e-03f, -1.83960851e-02f, -3.78681049e-02f, 9.65538919e-02f, 3.55525538e-02f, 7.95361027e-03f, -2.77474411e-02f, -8.96076560e-02f, 8.64045788e-03f, 7.78324082e-02f,
  7.83130620e-03f, -1.04834974e-01f, 9.25592706e-03f, 3.55273336e-02f, -1.18245803e-01f, -2.70581748e-02f, -2.19205096e-02f, -8.73322561e-02f, -3.52911539e-02f, 1.68830663e-01f,
  2.59406716e-02f, 3.27084474e-02f, -1.09386988e-01f, 4.91456054e-02f, 2.39671282e-02f, 1.41322752e-02f, 6.34206161e-02f, 1.08124755e-01f, -5.07063605e-02f, 1.62931159e-02f,
  9.15515199e-02f, 2.17366293e-02f, 1.23777524e-01f, 2.35225670e-02f, 8.40872824e-02f, -1.22662351e-01f, -8.92774761e-03f, 1.34432450e-01f, -3.00107915e-02f, -8.87793973e-02f,
  1.19594373e-02f, -1.27286971e-01f, 5.41942380e-02f, 6.42407462e-02f, -9.26942751e-02f, 2.85395738e-02f, -4.61357161e-02f, -3.85551937e-02f, -6.87142313e-02f, -4.17463854e-02f,
  4.07182276e-01f, -3.45856637e-01f, 3.72816175e-02f, 2.71029845e-02f, -5.17812185e-02f, 5.48768975e-02f, -7.14584067e-03f, -1.30926706e-02f, -5.05653247e-02f, 1.07896015e-01f,
  -3.36272195e-02f, 6.08680360e-02f, 1.30641431e-01f, 1.71627756e-02f, 1.40975360e-02f, -5.14282882e-02f, 1.35853859e-02f, -5.78652136e-03f, -4.07721056e-03f, -3.55094671e-02f,
  8.96868855e-02f, 1.68027785e-02f, 1.84750706e-02f, 1.11791603e-01f, -5.84588870e-02f, -7.45653883e-02f, 1.53479621e-01f, 6.88368157e-02f, 5.10077253e-02f, 2.95904160e-01f,
  1.23193972e-01f, 1.57842904e-01f, 3.31390277e-02f, 1.36642009e-01f, 2.33155042e-01f, 2.26373494e-01f, 1.78041056e-01f, 1.55927405e-01f, -3.55995223e-02f, 7.12653175e-02f,
  1.18841857e-01f, 2.36126781e-02f, -2.94079795e-03f, -9.22138318e-02f, 6.50866143e-03f, 1.42273396e-01f, -1.53568648e-02f, -7.07166344e-02f, 1.67392613e-03f, -2.36633979e-02f,
  4.94695157e-02f, 8.98879766e-02f, -7.25923032e-02f, -8.19869637e-02f, -7.84670189e-02f, -6.61742240e-02f, -2.80509819e-03f, -2.94351317e-02f, -2.64877919e-02f, -1.61558054e-02f,
  -1.23940162e-01f, 1.94525912e-01f, -1.68651231e-02f, -9.08748433e-02f, 7.30725825e-02f, -2.75818314e-02f, -2.46720910e-02f, -1.15842186e-01f, 1.44423945e-02f, 4.08446193e-02f,
  4.16687950e-02f, -3.05351745e-02f, 7.90531710e-02f, 5.86473159e-02f, -5.85222319e-02f, -5.51790409e-02f, -7.14510307e-02f, 4.66935597e-02f, 2.06925981e-02f, -5.11568151e-02f,
  -5.55224009e-02f, 1.10057369e-01f, -3.68145900e-03f, 8.42810720e-02f, 4.52301912e-02f, -1.63232479e-02f, 3.99704762e-02f, -4.44598421e-02f, -4.50403849e-03f, -1.55064352e-02f,
  4.22046781e-02f, 2.89938971e-03f, 1.15789935e-01f, 1.86005849e-02f, -1.13762813e-02f, 6.22928701e-02f, 2.97980737e-02f, -2.35118927e-03f, -1.35077685e-02f, 9.65273753e-03f,
  -3.63439880e-02f, 6.64319247e-02f, -4.47801268e-03f, 3.35656404e-02f, -4.03354429e-02f, 1.48452271e-03f, 1.15347402e-02f, 7.49783292e-02f, 1.95158403e-02f, -7.84195885e-02f,
  -4.15530382e-03f, 8.50617364e-02f, 6.12354726e-02f, 7.82469139e-02f, -3.26664373e-02f, 4.26247418e-02f, 1.47201773e-02f, -1.04042673e-02f, -1.15597085e-03f, -7.16229761e-03f,
  -2.25273818e-01f, 1.80737689e-01f, -8.12090635e-02f, -1.12069383e-01f, -4.33649169e-03f, -1.95925366e-02f, 8.60562623e-02f, -2.09525786e-02f, -5.92308789e-02f, 4.33140025e-02f,
  -1.93125755e-02f, 9.52951312e-02f, -3.83240096e-02f, 3.72535437e-02f, -5.27648330e-02f, -3.47645395e-02f, -7.58996755e-02f, 4.39444520e-02f, -7.16247186e-02f, -1.18738376e-01f,
  -9.08622444e-02f, -1.30971847e-02f, -1.19368909e-02f, -7.12050032e-03f, -5.84059358e-02f, 3.65018137e-02f, 1.16338963e-02f, -6.60425005e-03f, -7.51270354e-02f, -1.38942137e-01f,
  7.49293482e-03f, 8.28618184e-02f, 1.06440574e-01f, 1.88322905e-02f, 1.50100201e-01f, 8.98479298e-02f, 1.37624383e-01f, 1.47045255e-01f, 6.22228980e-02f, -3.35699990e-02f,
  1.67329565e-01f, 1.60363257e-01f, 1.25018746e-01f, 1.81624204e-01f, 2.06719749e-02f, -1.74486227e-02f, 4.66756858e-02f, 1.24683551e-01f, 9.85732675e-03f, 4.77138050e-02f,
  2.33900100e-02f, -7.22582191e-02f, 1.86765958e-02f, -2.92510297e-02f, 7.76206329e-02f, 7.32348785e-02f, 3.12909186e-02f, 8.35368410e-02f, 5.03995568e-02f, -1.69875361e-02f,
  1.03039872e-02f, 1.33439586e-01f, -5.21111190e-02f, -5.92889860e-02f, 9.91420001e-02f, -5.81403822e-02f, -7.76352827e-03f, -1.05180897e-01f, -2.40997337e-02f, -4.12675217e-02f,
  3.23491581e-02f, -4.44207229e-02f, 1.41457783e-03f, -2.32272483e-02f, 1.76536608e-02f, 1.09267747e-03f, -1.76150817e-02f, -4.58969064e-02f, -3.05566192e-03f, 4.53395955e-02f,
  2.78042499e-02f, 5.97847141e-02f, -4.90480885e-02f, -6.69627935e-02f, 1.03438668e-01f, 1.05726786e-01f, -7.85581395e-02f, -1.24125205e-01f, 3.19739617e-02f, -1.19870402e-01f,
  2.04896480e-02f, -1.30064815e-01f, 1.02361292e-02f, -1.04378462e-01f, -4.91804220e-02f, -6.65119514e-02f, -1.90149583e-02f, -6.61610290e-02f, 2.45242324e-02f, 1.70948729e-02f,
  -8.90847109e-03f, 3.17300558e-02f, 9.33483616e-02f, 9.96858254e-03f, 2.27235891e-02f, -4.99032214e-02f, -4.47047837e-02f, -9.12817661e-03f, 4.73896880e-03f, 5.29197268e-02f,
  6.53234422e-02f, -4.43462767e-02f, -1.27113014e-01f, 1.31325433e-02f, 1.69876870e-02f, -7.02952519e-02f, -8.36012736e-02f, 3.83246131e-02f, -1.06478706e-01f, -1.30259180e-02f,
  8.43845424e-04f, 2.47007161e-01f, 5.02948537e-02f, 3.84242497e-02f, -3.84680033e-02f, 2.20634975e-02f, 8.55272189e-02f, -6.64090039e-03f, 5.07821590e-02f, 5.62244020e-02f,
  4.65813205e-02f, -4.92444113e-02f, -3.25827897e-02f, -1.17620938e-02f, 2.18587518e-02f, -8.64628479e-02f, 1.73398457e-03f, 5.63092344e-02f, -4.14023772e-02f, 2.92955600e-02f,
  -4.94166426e-02f, -1.38088921e-03f, -4.45926227e-02f, 2.76685935e-02f, 7.86850636e-04f, 3.43310311e-02f, -8.76876786e-02f, -1.35852266e-02f, 3.68806496e-02f, -1.12219885e-01f,
  -4.72109795e-01f, 1.04188226e-01f, 3.56625840e-02f, -1.03503354e-01f, 5.98653518e-02f, -8.69444236e-02f, -1.25574052e-01f, -2.53144771e-01f, -8.24528635e-02f, 4.62447340e-03f,
  9.54417884e-02f, 7.14114532e-02f, 1.04368879e-02f, -6.76119104e-02f, -3.05267125e-01f, -1.47497997e-01f, -7.33025745e-02f, -1.63427457e-01f, -2.24930376e-01f, -9.91848484e-02f,
  7.05860481e-02f, -7.55709410e-02f, -1.10405594e-01f, -4.15208675e-02f, 1.01999395e-01f, 2.07003728e-01f, 4.85678166e-02f, 1.15521781e-01f, 9.81451645e-02f, 2.72189230e-01f,
  3.87691438e-01f, -8.64677504e-02f, 7.28802430e-03f, 5.96746802e-02f, 1.36338547e-01f, 6.48960322e-02f, 5.86586669e-02f, -5.07342480e-02f, -1.64555255e-02f, 4.80903871e-02f,
  -1.57512128e-02f, -1.77744143e-02f, -2.80543254e-03f, -7.27338865e-02f, -7.52025470e-02f, -1.12824500e-01f, -5.54030538e-02f, -2.25089848e-01f, -1.15531296e-01f, 7.40844896e-03f,
  6.95846677e-02f, -3.58857922e-02f, -9.89010558e-02f, -1.42012522e-01f, -1.08275115e-01f, -4.85054739e-02f, 6.94062468e-03f, -5.65138757e-02f, -1.06705114e-01f, 2.00761817e-02f,
  -2.40699556e-02f, 4.77546379e-02f, 3.91866229e-02f, -3.24234888e-02f, 4.91230451e-02f, 8.91968608e-02f, 7.82973468e-02f, 5.45356236e-03f, 1.12887640e-02f, -8.80123228e-02f,
  -5.84990866e-02f, 5.21300398e-02f, 2.22461820e-02f, 4.73767221e-02f, 2.61956789e-02f, 2.27052413e-04f, 1.69187058e-02f, -4.24523167e-02f, -8.26589093e-02f, 5.80030233e-02f,
  9.62451845e-03f, -5.34481890e-02f, 7.59535804e-02f, -6.85392395e-02f, 2.87923515e-02f, 5.37956506e-02f, -4.49261852e-02f, -9.70162824e-02f, -3.28328162e-02f, -4.66941819e-02f,
  1.21936373e-01f, -2.46193141e-01f, 5.90121038e-02f, -9.78039950e-02f, 2.89381221e-02f, 1.36493174e-02f, 1.10364325e-01f, -9.16817039e-02f, 2.39300020e-02f, 5.23453802e-02f,
  -3.52639332e-03f, 3.36058176e-04f, 2.99269985e-02f, -4.45383489e-02f, -3.08954380e-02f, 7.59139797e-03f, -1.09490998e-01f, -9.19923335e-02f, -4.21468094e-02f, 8.87553245e-02f,
  -1.24943532e-01f, -8.40129182e-02f, -4.59861867e-02f, -3.30995582e-02f, 3.05395247e-03f, 5.18224314e-02f, 7.75024295e-02f, 5.73256090e-02f, -1.25894777e-03f, 1.49421254e-02f,
  1.15831107e-01f, 1.51620992e-02f, 3.52377862e-01f, 1.33074045e-01f, 1.86410218e-01f, 2.50032365e-01f, 7.25300238e-02f, 1.63325861e-01f, -2.15029940e-02f, 5.68501279e-02f,
  -1.09295100e-01f, -1.00985877e-01f, -7.51482993e-02f, 4.42862026e-02f, 2.06341341e-01f, 1.66233540e-01f, 1.67006627e-01f, 1.55859426e-01f, 2.89294720e-01f, 1.80674896e-01f,
  2.69711856e-02f, 1.33255959e-01f, 1.03719994e-01f, 1.82921633e-01f, 4.95984256e-02f, 3.51395532e-02f, 1.37224644e-01f, 2.91562509e-02f, 9.93435271e-03f, 5.39367497e-02f,
  -2.21429795e-01f, 3.26727852e-02f, -3.28175873e-02f, -1.74504161e-01f, -2.02254262e-02f, -4.20128256e-02f, -9.24233720e-02f, -3.42801884e-02f, -4.02736031e-02f, -2.57244017e-02f,
  -4.61214483e-02f, -7.87260383e-02f, -4.63577034e-03f, -1.02393441e-01f, 5.12859263e-02f, 4.79763933e-02f, 6.50369748e-02f, 1.05978018e-02f, -1.81697700e-02f, 6.06820802e-04f,
  -6.86638802e-02f, -7.07556680e-02f, 5.11609055e-02f, -5.78465033e-03f, 1.01395771e-01f, 5.14903069e-02f, -2.61314139e-02f, 1.02886036e-02f, -3.95065844e-02f, -9.61028859e-02f,
  -1.90640707e-02f, -2.12251488e-02f, 6.03210330e-02f, 8.64246860e-02f, 5.82152829e-02f, 4.04335447e-02f, -3.63348983e-02f, -4.65528443e-02f, 3.60602960e-02f, 1.13342260e-03f,
  -2.62754727e-02f, 6.91730157e-02f, -4.57391292e-02f, 9.36884806e-02f, 6.81233779e-02f, 1.09983824e-01f, -4.83499989e-02f, -5.49532510e-02f, 1.62207950e-02f, 5.60000539e-02f,
  1.49821350e-02f, 3.27953100e-02f, -1.94732603e-02f, -5.00524826e-02f, -2.38019507e-02f, 6.30482063e-02f, -1.12781830e-01f, -1.14799120e-01f, -1.06002931e-02f, 6.71182480e-03f,
  -2.77585000e-01f, 5.26030697e-02f, -1.56261846e-01f, -1.77633129e-02f, -5.30083627e-02f, -8.00077617e-02f, -1.39651850e-01f, -8.83862078e-02f, -7.56511316e-02f, -1.14391461e-01f,
  -4.63873707e-02f, -9.86620784e-02f, -7.27156326e-02f, -9.83861089e-03f, -5.68096861e-02f, 3.96785215e-02f, -1.37062803e-01f, 6.93746135e-02f, 5.89479171e-02f, -7.82546476e-02f,
  -5.91402985e-02f, -1.22744851e-02f, 9.63479653e-03f, -1.80123020e-02f, -8.37307721e-02f, -1.17709540e-01f, 3.55907413e-03f, -9.80231911e-03f, 2.99037378e-02f, -7.94931874e-02f,
  -3.45039397e-01f, 9.71790180e-02f, 1.92182697e-02f, -3.84338498e-01f, -1.89638555e-01f, -1.78680807e-01f, -1.09196790e-02f, -7.67678171e-02f, -2.60381013e-01f, -1.71465788e-03f,
  6.86640218e-02f, 4.22815196e-02f, 4.67773415e-02f, 1.20764583e-01f, 7.64858350e-02f, 1.82878032e-01f, -4.77702310e-03f, -1.08251035e-01f, -1.70976356e-01f, -6.14201985e-02f,
  -1.65707618e-02f, -2.09681287e-01f, -1.89423397e-01f, -2.35972315e-01f, -9.12982225e-02f, -1.24715261e-01f, -8.26940015e-02f, -8.06413814e-02f, 1.62368417e-02f, 3.22823338e-02f,
  4.86415178e-01f, -1.30541846e-01f, 3.37179191e-02f, -1.49548471e-01f, -2.69044675e-02f, -9.40143242e-02f, 3.00634559e-02f, -4.39619943e-02f, -1.05356984e-02f, -1.07337922e-01f,
  -5.60124815e-02f, -3.42826769e-02f, -8.71590003e-02f, 4.32270020e-02f, -1.67106435e-01f, -2.04305854e-02f, -1.04353525e-01f, -8.90213624e-03f, -5.35671338e-02f, 6.61346912e-02f,
  1.98551789e-02f, 1.54494529e-03f, 8.80252868e-02f, -2.97463164e-02f, -8.08553398e-02f, -1.23162620e-01f, 6.63647726e-02f, -1.39189228e-01f, -2.98215561e-02f, 3.79392728e-02f,
  6.22064732e-02f, 1.04378397e-02f, -3.14526968e-02f, -4.59044613e-03f, 3.11684515e-02f, 1.34736979e-02f, 6.12223567e-03f, 5.49749397e-02f, -4.82304469e-02f, 7.57406801e-02f,
  -7.02338293e-02f, 7.29335696e-02f, -4.23819944e-02f, 7.36575052e-02f, 2.15519648e-02f, -3.91722331e-03f, -6.18095025e-02f, 4.86109443e-02f, 1.49478223e-02f, 8.88681877e-03f,
  -1.17654786e-01f, -3.18481922e-02f, -1.86751876e-02f, 3.99098545e-02f, 2.53335871e-02f, 1.12603540e-02f, -9.38523561e-03f, -7.84720033e-02f, 8.50577839e-03f, -6.77981377e-02f,
  1.69847712e-01f, -1.08260345e-02f, 1.85875148e-01f, -2.90190149e-02f, -9.33447704e-02f, -1.40801873e-02f, 4.90830578e-02f, -8.64423737e-02f, -9.21190977e-02f, -2.67308243e-02f,
  -8.69285911e-02f, 1.29630873e-02f, -4.98954169e-02f, -3.49586233e-02f, -3.26615870e-02f, -1.34113599e-02f, 6.76163062e-02f, 4.78987135e-02f, 4.17906679e-02f, 3.50073539e-02f,
  -5.68604581e-02f, 1.13131881e-01f, 2.45723814e-01f, 1.15184881e-01f, 3.08288243e-02f, 1.13607801e-01f, 1.59831613e-01f, 1.32399023e-01f, 4.80138808e-02f, 2.14834392e-01f,
  -1.39018431e-01f, -8.14872459e-02f, -4.16887738e-02f, 1.32069558e-01f, 7.86146894e-03f, -2.29788706e-01f, -2.50352681e-01f, -1.62817851e-01f, 3.84821370e-02f, 5.27844240e-04f,
  1.73535626e-02f, 3.29425223e-02f, -1.67508889e-02f, -6.90960884e-02f, -3.21073771e-01f, -8.40037018e-02f, -6.28180727e-02f, -2.32561707e-01f, -3.68536472e-01f, -2.78934658e-01f,
  -2.71331310e-01f, -7.63975829e-02f, -1.01605400e-01f, 7.14429130e-04f, 1.73173487e-01f, 9.23323259e-02f, 1.72291428e-01f, 6.46985788e-03f, 1.68380551e-02f, 3.07368785e-02f,
  -1.43932015e-01f, -4.00344580e-02f, -1.10161804e-01f, -8.60028490e-02f, 4.24391106e-02f, -9.08851102e-02f, 1.19015742e-02f, 8.39927271e-02f, 4.85694259e-02f, -5.20907454e-02f,
  6.21581227e-02f, -3.25384289e-02f, 6.00762991e-03f, 5.65439975e-03f, -2.84258649e-02f, -1.47847205e-01f, -9.04148296e-02f, -7.75343552e-02f, -9.27325413e-02f, 4.44918731e-03f,
  -1.20670319e-01f, -1.50556445e-01f, -1.61003143e-01f, 1.01455249e-01f, 9.15295556e-02f, -2.48119030e-02f, 1.31487370e-01f, 4.66437414e-02f, 2.70577632e-02f, 1.06245413e-01f,
  -1.29276495e-02f, -2.19813772e-02f, 8.89014974e-02f, -8.10088143e-02f, -5.88942952e-02f, -4.38461034e-03f, 5.00258803e-02f, -1.15569530e-03f, -9.67268944e-02f, 6.31335378e-02f,
  2.15949118e-02f, 4.75055762e-02f, -3.00845467e-02f, -2.02651676e-02f, 5.34722768e-02f, -2.75334856e-03f, -6.88439235e-02f, -3.27261798e-02f, -3.14850360e-02f, -2.37792954e-02f,
  -1.88822988e-02f, -1.43976267e-02f, 6.91076964e-02f, 2.17173547e-02f, 4.89951372e-02f, -2.67702304e-02f, -8.41435697e-03f, -2.89093796e-02f, -6.55245222e-03f, -1.05983496e-01f,
  -8.24044272e-03f, -1.51576996e-01f, -4.41961028e-02f, -5.53186536e-02f, 3.78551371e-02f, 7.39784017e-02f, 2.11893208e-02f, 2.12681573e-02f, 6.29612207e-02f, -8.76917019e-02f,
  -6.78454116e-02f, 2.64829514e-03f, 2.61051450e-02f, -1.63213145e-02f, -5.88983446e-02f, -2.32461393e-02f, -1.22627057e-01f, -1.21170105e-02f, -1.41087905e-01f, -8.85416288e-03f,
  -3.21944617e-02f, -7.18847886e-02f, -2.05743819e-01f, 3.62143889e-02f, 7.12714121e-02f, -1.31096095e-01f, -1.52225912e-01f, -2.14240011e-02f, -1.49312928e-01f, -6.45236000e-02f,
  -8.04022431e-01f, 3.33339334e-01f, 2.86227852e-01f, -3.78403932e-01f, 1.75858140e-01f, 3.28632414e-01f, 4.56448078e-01f, 4.82118092e-02f, -1.76832333e-01f, 9.57393274e-02f,
  4.45110463e-02f, -2.02612206e-01f, -5.54018095e-03f, -8.59339442e-03f, 1.04623131e-01f, 3.29056144e-01f, 1.68460563e-01f, -4.26929556e-02f, -7.60196820e-02f, -9.53227133e-02f,
  2.91278977e-02f, -2.18621224e-01f, -2.89414376e-01f, -9.14496779e-02f, -1.44398361e-01f, -2.09795535e-01f, 1.77834798e-02f, -7.63667077e-02f, 1.57373965e-01f, -1.35832518e-01f,
  -2.44046718e-01f, -2.29228973e-01f, -6.62045255e-02f, -7.76556060e-02f, 1.65036954e-02f, -6.11383002e-03f, 2.92113330e-03f, -6.25909120e-02f, -1.03691155e-02f, 2.78232321e-02f,
  -4.81747417e-03f, -6.55738562e-02f, -7.96130598e-02f, -4.35115695e-02f, -6.68366104e-02f, -6.10193610e-02f, 2.20985636e-02f, -7.64514059e-02f, -4.50515859e-02f, 6.99201077e-02f,
  1.97754174e-01f, 5.13840057e-02f, -7.08822161e-02f, 7.16519803e-02f, 5.82397096e-02f, 8.19262210e-03f, -6.20483309e-02f, -5.35215139e-02f, -7.18973130e-02f, -2.38839716e-01f,
  -1.18849240e-02f, 3.99755463e-02f, 6.24664649e-02f, -1.57175418e-02f, -4.99455705e-02f, -7.23826438e-02f, 5.82920238e-02f, 4.39349748e-02f, -1.70989372e-02f, -8.29508454e-02f,
  5.69258220e-02f, 6.05960237e-03f, 3.76127996e-02f, -4.35486883e-02f, 2.82578636e-02f, -5.23531996e-02f, 1.02318652e-01f, 1.39741674e-02f, 7.76703283e-02f, -5.94896972e-02f,
  -3.36476834e-03f, -1.49146747e-02f, -4.72994037e-02f, -2.35632844e-02f, 1.86484810e-02f, 8.04957002e-02f, -4.52490672e-02f, -5.17963171e-02f, 1.43464524e-02f, -7.29737990e-03f,
  -3.80492657e-01f, 2.19247982e-01f, -1.34004623e-01f, -1.33836240e-01f, -3.87987532e-02f, -1.49597107e-02f, -2.69556995e-02f, 6.25225017e-03f, -5.70302308e-02f, 1.83097385e-02f,
  1.40842861e-02f, -3.90699357e-02f, 7.82796368e-02f, 5.69636412e-02f, -1.50524341e-02f, -2.74975337e-02f, -7.48489611e-03f, -1.05223469e-01f, 9.70942453e-02f, 6.30097315e-02f,
  6.94149211e-02f, -1.07313082e-01f, -1.86691850e-01f, 2.81288121e-02f, -4.84413803e-02f, -2.26487309e-01f, -1.07417248e-01f, -1.92737266e-01f, -6.13506585e-02f, -3.04204524e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.60816836e-01f, 9.62238461e-02f, -2.24661902e-02f, 3.84927727e-02f, 1.60542682e-01f, 2.51784325e-01f, 1.40893921e-01f, 1.17480613e-01f, 4.75594699e-02f, 1.09061785e-01f,
  1.87746868e-01f, 2.56093740e-01f, 1.43221110e-01f, 2.11164489e-01f, 6.94426745e-02f, 2.04308212e-01f, 3.13684493e-01f, 1.60492301e-01f, -1.51383774e-02f, 2.95636773e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -4.92070280e-02f, -2.26313546e-01f, -4.19188827e-01f, -4.76948172e-03f, -1.23299867e-01f, 2.37908527e-01f, -1.36620551e-01f, 3.27041984e-01f, 1.17303878e-01f, -6.14132345e-01f,
  -5.16258895e-01f, -1.80278376e-01f, 1.82726011e-01f, 8.59446730e-03f, -5.72213158e-02f, -2.30381921e-01f, 7.39930198e-02f, 1.28512487e-01f, 1.19657435e-01f, 1.20095007e-01f,
  -1.67746797e-01f, 2.64318019e-01f, -7.95203671e-02f, -5.37089780e-02f, -2.76944712e-02f, 3.50311473e-02f, -4.92239632e-02f, 2.44497061e-01f, -2.20196813e-01f, -1.64298236e-01f,
  1.41564801e-01f, 4.64398533e-01f, -1.70323342e-01f, 2.35262681e-02f, 2.61031301e-03f, -2.68641144e-01f, -3.96163046e-01f, 9.85622406e-02f, 1.14398167e-01f, -2.18056113e-01f,
  -1.01195492e-01f, -3.91310036e-01f, 3.31375510e-01f, -6.48373544e-01f, -2.34772295e-01f, -6.99876621e-03f, -5.45133129e-02f, -1.16350688e-01f, -2.18243226e-01f, 2.97452629e-01f,
  9.48298126e-02f, 1.86351657e-01f, 1.72456175e-01f, -7.47558326e-02f, -1.70493349e-01f, 3.58649671e-01f, 1.23830646e-01f, -6.05365448e-02f, 1.44850120e-01f, -3.15278679e-01f,
  1.51703745e-01f, -1.19526424e-01f, -4.19117242e-01f, 1.76025659e-01f, 1.70969695e-01f, 1.78145602e-01f, 1.02760963e-01f, 1.18618600e-01f, -2.51965702e-01f, -2.30975188e-02f,
  -1.72678888e-01f, -2.46925518e-01f, -1.48543596e-01f, -1.69533975e-02f, -4.13953885e-02f, -1.28056288e-01f, 1.46270126e-01f, 1.16178647e-01f, -6.92111701e-02f, -1.89291853e-02f,
  4.26280722e-02f, -2.61801392e-01f, 1.54405132e-01f, 1.69818744e-01f, 2.15452284e-01f, 2.39982665e-01f, 1.26700014e-01f, 1.54039413e-01f, -5.01415581e-02f, 1.75888449e-01f,
  4.58451174e-02f, 3.32379639e-02f, 4.07393016e-02f, 2.68172592e-01f, -1.87157214e-01f, 3.72765609e-03f, -4.23314795e-02f, 2.98483789e-01f, 1.59697921e-03f, 3.07551175e-01f,
  -3.16344529e-01f, -3.17792863e-01f, -7.73146152e-02f, 1.91263054e-02f, -2.35262111e-01f, -2.24242300e-01f, -5.07103577e-02f, -3.25032026e-01f, -4.84029680e-01f, 3.03161759e-02f,
  1.00220881e-01f, -1.17917903e-01f, -1.77757740e-01f, -1.62104890e-01f, -4.98629324e-02f, 2.84465045e-01f, 2.54365236e-01f, -2.10850388e-02f, 2.08150651e-02f, 1.70293838e-01f,
  -8.61798227e-02f, 2.63775811e-02f, 1.04843276e-02f, 2.12625727e-01f, -5.42365685e-02f, 2.43837059e-01f, 7.95843601e-02f, 2.36971349e-01f, -1.19679816e-01f, -3.01508039e-01f,
  2.45472521e-01f, -6.55380264e-02f, -1.32399136e-02f, -4.63978350e-02f, -2.91193783e-01f, -3.59047055e-01f, -2.54023135e-01f, 1.36225373e-01f, 1.84028104e-01f, 1.55496180e-01f,
  1.75969422e-01f, -6.36112168e-02f, 1.79609627e-01f, -1.46727026e-01f, -4.75928374e-02f, -2.68358916e-01f, 2.40096450e-01f, 7.00707287e-02f, -1.27502322e-01f, 1.36845171e-01f,
  2.74520695e-01f, -9.64928120e-02f, -4.79723960e-02f, -1.94850452e-02f, 1.44064218e-01f, -2.70179957e-01f, 2.34054461e-01f, -1.25468373e-01f, 8.33852515e-02f, 4.04713787e-02f,
  1.14875749e-01f, -3.22954476e-01f, 1.60495356e-01f, -2.42272213e-01f, 1.47081971e-01f, -4.45786864e-01f, -1.30508244e-01f, -5.12114167e-01f, -2.21399277e-01f, 6.05860651e-01f,
  2.43991673e-01f, 1.73637271e-01f, -5.59802838e-02f, 2.57764429e-01f, 1.48877203e-01f, 1.04324952e-01f, -1.07935898e-01f, -3.04293428e-02f, -2.60953933e-01f, 2.34604254e-01f,
  -7.21830688e-03f, -2.51788527e-01f, 3.05198044e-01f, -2.82555550e-01f, -2.61282682e-01f, 1.47769913e-01f, -1.82301328e-01f, -2.63251424e-01f, 1.22275628e-01f, -1.25150248e-01f,
  -8.35659057e-02f, -3.35918099e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.95919037e-01f, 6.03571832e-02f, -4.04610299e-02f, -5.47033511e-02f, -5.45909517e-02f, 9.64607298e-02f, -1.96250901e-01f, 1.76279247e-01f, 1.37553662e-01f, -3.00225168e-01f,
  -6.12802133e-02f, -1.84265330e-01f, 2.48450920e-01f, 1.39404342e-01f, -1.27267510e-01f, -2.22559661e-01f, 9.71096903e-02f, 4.50383544e-01f, 3.87029536e-02f, -1.87945500e-01f,
  1.87726632e-01f, 2.40253031e-01f, -1.58055555e-02f, 1.36686593e-01f, -1.39610276e-01f, 7.56425969e-03f, -7.06448546e-03f, -5.31338900e-03f, 1.18744195e-01f, 2.57075816e-01f,
  -3.50593120e-01f, 1.25604138e-01f, 4.02418196e-01f, 5.04388630e-01f, 3.88546735e-01f, 3.67879272e-01f, 1.89460099e-01f, -3.73639107e-01f, -3.89248103e-01f, 1.74224317e-01f,
  4.68617558e-01f, 2.05666855e-01f, -2.96875775e-01f, 2.51476794e-01f, 1.99595600e-01f, 4.11093295e-01f, 1.62963182e-01f, -7.03334510e-02f, 4.83843744e-01f, 2.17664689e-02f,
  -1.04263805e-01f, -1.05052590e-01f, 1.81746215e-01f, 1.25679493e-01f, -9.71674025e-02f, -2.28819892e-01f, 9.76007953e-02f, 4.89192083e-02f, 1.87927783e-01f, 5.24203002e-01f,
  -2.69542277e-01f, 4.92070377e-01f, 1.70174897e-01f, 2.16589704e-01f, 2.92155910e-02f, 1.57862812e-01f, 1.81632519e-01f, 2.98550785e-01f, 9.85429808e-02f, 3.87886614e-01f,
  3.70691687e-01f, 6.10436082e-01f, 2.24765316e-01f, -5.39664805e-01f, 4.90335315e-01f, -1.99583769e-01f, 3.00095499e-01f, -1.92563355e-01f, -8.40498731e-02f, 8.61443207e-03f,
  8.99122655e-02f, 2.02618361e-01f, 3.50951970e-01f, 5.30292206e-02f, -7.16842636e-02f, 8.07669610e-02f, 7.46354014e-02f, 4.24366832e-01f, -2.55068928e-01f, 1.20168768e-01f,
  1.56446636e-01f, -2.05906421e-01f, 1.99067160e-01f, -2.96380162e-01f, 4.67595980e-02f, -3.18928927e-01f, -1.38791695e-01f, -5.90485632e-02f, -1.57344323e-02f, -8.65624771e-02f,
  3.78028810e-01f, 2.21758693e-01f, -3.00320834e-02f, 3.02334458e-01f, 3.65442991e-01f, -8.63199010e-02f, 8.97857919e-02f, 2.66075462e-01f, 1.95581257e-01f, 3.55933420e-02f,
  -2.18620487e-02f, -2.12813597e-02f, 2.50290155e-01f, 3.73010606e-01f, -3.47266607e-02f, -2.19514325e-01f, -1.38264447e-01f, -1.46228537e-01f, -5.81290573e-03f, -2.45689139e-01f,
  2.71735583e-02f, -2.08643138e-01f, -7.15003461e-02f, 1.03375323e-01f, 3.07973251e-02f, -2.95016795e-01f, 8.34380537e-02f, -5.25871217e-02f, -1.09601408e-01f, 2.00393684e-02f,
  -3.10816839e-02f, 9.06883478e-02f, 6.21986166e-02f, 1.32274151e-01f, 5.21007419e-01f, 1.14691973e-01f, -1.64841451e-02f, 1.09508395e-01f, 1.09135069e-01f, 5.79333305e-02f,
  -3.68015647e-01f, -7.91642964e-02f, -1.94165573e-01f, 7.26945028e-02f, -2.18944192e-01f, 7.09302425e-01f, -1.61153540e-01f, -1.66945606e-01f, -2.21447855e-01f, -8.41492508e-03f,
  -1.50711730e-01f, -2.72103161e-01f, 2.61529624e-01f, -1.07978433e-01f, -2.68234134e-01f, 1.74150124e-01f, -2.74732709e-01f, -1.92799300e-01f, 5.69016993e-01f, -1.95678219e-01f,
  5.78654325e-03f, 7.86421746e-02f, 1.27747536e-01f, 4.43755612e-02f, -1.43071666e-01f, -3.03879470e-01f, -1.64078213e-02f, -1.86314926e-01f, 5.92915202e-03f, 1.52977824e-01f,
  3.25829655e-01f, -1.68268308e-01f, 6.39597699e-02f, -1.62572742e-01f, -7.03063905e-02f, -1.87988564e-01f, -1.49219289e-01f, 2.90902704e-02f, 5.80537394e-02f, 8.58589858e-02f,
  8.55339468e-02f, 1.39423743e-01f, 3.01392168e-01f, 2.16118753e-01f, -9.37754102e-03f, -3.93090248e-02f, -1.72541797e-01f, -3.84224616e-02f, 2.83334196e-01f, 1.71216667e-01f,
  9.30026472e-02f, -2.53442258e-01f, 9.51418132e-02f, -3.56459506e-02f, 9.56838951e-03f, 4.35853153e-02f, 2.08455056e-01f, -2.34890595e-01f, -4.46376912e-02f, -7.23342970e-02f,
  1.15865394e-01f, 2.12276161e-01f, 1.58421800e-01f, 6.68813512e-02f, 6.47571087e-02f, 2.25524530e-01f, -7.57019967e-02f, 1.24531165e-01f, -5.01972474e-02f, -1.13194615e-01f,
  -1.32444218e-01f, 3.41879912e-02f, 2.57968247e-01f, 8.22117999e-02f, 1.91888019e-01f, 3.43180518e-03f, 2.15086147e-01f, -1.10438943e-01f, 6.53920695e-02f, -5.52968308e-02f,
  1.68860584e-01f, 4.26984653e-02f, -1.48160130e-01f, -1.81495517e-01f, 1.78094015e-01f, 1.97314501e-01f, 1.12615265e-01f, 3.35514843e-01f, 6.72084019e-02f, -3.58117908e-01f,
  -2.13437274e-01f, -1.14671268e-01f, -6.46910742e-02f, 2.88498942e-02f, 2.20189542e-01f, 9.37482994e-03f, 3.95039707e-01f, 2.25176021e-01f, 9.96872187e-02f, -1.01224661e-01f,
  4.18612748e-01f, -7.06427023e-02f, 2.29202807e-01f, 2.44825101e-03f, 1.37998939e-01f, 3.45549822e-01f, 2.15863287e-02f, -8.87025073e-02f, -2.39649594e-01f, 1.94449633e-01f,
  3.60512286e-02f, 5.73761500e-02f, 2.24398986e-01f, -7.67613500e-02f, -1.37736529e-01f, -2.57525921e-01f, 4.88542795e-01f, 4.18439507e-01f, 2.45592728e-01f, 3.44197512e-01f,
  -1.40730575e-01f, 4.38908070e-01f, 2.79063433e-01f, 2.59833097e-01f, 3.13360184e-01f, -3.37846398e-01f, -4.83125359e-01f, 1.88475922e-01f, 4.59915370e-01f, -2.06142843e-01f,
  -2.83566147e-01f, -1.32717386e-01f, -1.37154132e-01f, -8.11037272e-02f, -1.09754009e-02f, 1.14077829e-01f, -1.55958295e-01f, 2.79104620e-01f, -1.96905106e-01f, -1.33114830e-01f,
  -1.51666865e-01f, -8.15768614e-02f, -1.39702603e-01f, -1.67490672e-02f, 9.13881138e-02f, 1.28007874e-01f, 2.67291665e-01f, 8.35183680e-01f, -2.95395046e-01f, -3.16151232e-01f,
  1.51513189e-01f, -2.53800958e-01f, 9.20395777e-02f, 3.92357290e-01f, -4.82398659e-01f, -2.67152488e-01f, -4.57238071e-02f, 1.44338995e-01f, -2.33567178e-01f, 6.26351908e-02f,
  2.56034523e-01f, 1.11707255e-01f, 9.96310934e-02f, -1.70634255e-01f, -3.40595812e-01f, -5.58363646e-02f, 3.11158538e-01f, 2.08693996e-01f, -2.05327980e-02f, 1.48538396e-01f,
  -2.19243005e-01f, -1.53069884e-01f, -6.42380565e-02f, 5.25455534e-01f, 3.59332919e-01f, -1.02920890e-01f, 4.05542314e-01f, 4.09391820e-02f, -2.70372555e-02f, 6.21685565e-01f,
  3.87312025e-01f, 4.03777659e-01f, 3.44945848e-01f, 4.17011976e-02f, 2.23637193e-01f, -7.14069381e-02f, -2.20234901e-01f, -2.10127652e-01f, -1.41080767e-01f, 4.09993470e-01f,
  1.55853495e-01f, -7.01991767e-02f, 6.10430360e-01f, 1.56434342e-01f, -6.93834722e-02f, 1.16032943e-01f, 5.26472151e-01f, -1.58858091e-01f, -2.19754636e-01f, 2.33342752e-01f,
  -2.93325111e-02f, 1.09325700e-01f, 3.68808806e-01f, -1.13771252e-01f, -1.13665067e-01f, -1.78701490e-01f, -7.19381571e-02f, -2.62849238e-02f, 3.26668471e-01f, -2.55521297e-01f,
  -2.37364605e-01f, -2.98904199e-02f, -3.70929986e-01f, 3.48739982e-01f, 2.13083386e-01f, -7.47312978e-03f, 1.47920936e-01f, 5.29956996e-01f, 4.10059035e-01f, 1.85261481e-02f,
  -4.51836377e-01f, -1.13297269e-01f, 7.10326910e-01f, -5.26692688e-01f, 3.69232446e-02f, -3.24182361e-01f, -2.19240170e-02f, 3.79447132e-01f, -2.85563674e-02f, 5.52109897e-01f,
  1.36300236e-01f, 2.25194633e-01f, -1.14861928e-01f, -1.60796598e-01f, 1.44684851e-01f, 4.24451120e-02f, -8.30999166e-02f, 2.79420435e-01f, 9.06963870e-02f, -4.02430475e-01f,
  3.11302960e-01f, 1.09889107e-02f, -1.56884342e-01f, -2.08215211e-02f, 2.98780859e-01f, -7.10433498e-02f, -9.70696937e-03f, 4.59900330e-04f, 3.03712618e-02f, -1.32145405e-01f,
  1.16313227e-01f, -3.31103295e-01f, -2.47885659e-01f, 1.35845408e-01f, 5.03552482e-02f, -2.46909633e-01f, 1.55699939e-01f, 1.06764808e-01f, -1.18530542e-02f, -1.44207403e-01f,
  -1.91217601e-01f, -7.35916719e-02f, 2.01920941e-01f, 4.47711088e-02f, 2.17928529e-01f, -6.47084862e-02f, 8.43205601e-02f, 1.09408230e-01f, 2.95837343e-01f, 1.45549208e-01f,
  1.03082374e-01f, -6.48587057e-03f, -8.45407322e-03f, 3.34770381e-01f, -4.87526432e-02f, 1.69101223e-01f, 1.54018730e-01f, -9.75397006e-02f, 2.97992438e-01f, 7.14255273e-02f,
  1.46536335e-01f, 1.11728363e-01f, -6.91608526e-03f, 4.79672670e-01f, 1.56810209e-01f, -1.67233467e-01f, -5.46072908e-02f, 2.13167772e-01f, 3.62397999e-01f, -1.44349054e-01f,
  -1.22162722e-01f, -3.83248664e-02f, 1.61705136e-01f, 9.58837569e-02f, 2.31203333e-01f, -2.05088362e-01f, 2.74813883e-02f, -6.44285977e-02f, 1.91657860e-02f, 2.33538345e-01f,
  -8.96229818e-02f, 4.38195169e-02f, 2.48172924e-01f, -2.98729837e-02f, -1.75861552e-01f, 1.16993360e-01f, 1.16832875e-01f, -2.58736849e-01f, 3.44776601e-01f, 1.06956244e-01f,
  -1.20101966e-01f, 5.83484359e-02f, 1.01557635e-01f, -1.46987453e-01f, 1.40651539e-01f, 2.05814525e-01f, 1.03621326e-01f, -5.09061702e-02f, 2.65053034e-01f, -3.51001583e-02f,
  2.11947247e-01f, -2.03724369e-01f, -1.87532485e-01f, -3.24948043e-01f, -1.72908336e-01f, -1.95910111e-02f, -8.35634246e-02f, 2.79868990e-01f, 2.67816156e-01f, -1.34381890e-01f,
  3.32937837e-01f, 4.19198543e-01f, -3.11083376e-01f, 2.24273745e-02f, -3.30802463e-02f, -7.56707489e-02f, 2.48747051e-01f, -1.06655590e-01f, -4.44792137e-02f, -2.44261175e-02f,
  -1.19727038e-01f, -5.88536114e-02f, 2.12553009e-01f, -8.03660974e-02f, -1.81413770e-01f, 1.77708328e-01f, 1.02606371e-01f, 8.61601382e-02f, 2.79243559e-01f, -3.08171064e-01f,
  2.31821746e-01f, -1.34661019e-01f, -1.44456208e-01f, -2.35262722e-01f, 1.14511624e-01f, 5.56157297e-03f, -1.54544786e-01f, 5.53691268e-01f, -5.80562628e-04f, -1.74671829e-01f,
  -1.89568009e-02f, 1.47888912e-02f, -1.88868001e-01f, 2.93893754e-01f, -2.30504975e-01f, -1.08042412e-01f, -4.49736416e-02f, -1.35025397e-01f, -9.59358439e-02f, 4.95493077e-02f,
  -3.29631194e-02f, -1.20625272e-01f, -7.42342621e-02f, 3.79311442e-02f, -2.44347468e-01f, 4.34104726e-02f, 1.88048154e-01f, 4.03568409e-02f, -9.12265182e-02f, -1.96810216e-01f,
  2.80926168e-01f, 2.61471182e-01f, -3.96290690e-01f, 1.34582430e-01f, -1.26163363e-01f, -1.34916538e-02f, -8.24161097e-02f, 1.71870872e-01f, 1.34256864e-02f, 4.66960818e-01f,
  6.19463772e-02f, -1.88299671e-01f, 2.35615410e-02f, -6.50501717e-03f, 7.11149164e-03f, -3.04499328e-01f, -7.20758811e-02f, 1.51653262e-02f, -9.56924856e-02f, 6.06550239e-02f,
  7.03697726e-02f, -1.94786072e-01f, 2.44298980e-01f, 1.90674827e-01f, 2.26098880e-01f, 1.90898776e-01f, 1.41708761e-01f, 1.64891213e-01f, 7.44870827e-02f, 4.82390255e-01f,
  -1.70504436e-01f, 2.80571878e-01f, 3.63910139e-01f, -3.34677339e-01f, -6.53645813e-01f, 1.99200079e-01f, 3.30987453e-01f, -1.07709192e-01f, 2.60216147e-01f, -3.05446804e-01f,
  -2.04491004e-01f, 3.38813126e-01f, -6.02875426e-02f, -2.22573206e-02f, -5.99789955e-02f, 7.99283460e-02f, -1.89333335e-01f, 3.43911439e-01f, -3.12811106e-01f, 6.75877109e-02f,
  1.96012750e-01f, -4.92772609e-02f, 1.86481848e-01f, 5.84345162e-02f, -2.12181702e-01f, 7.03937173e-01f, -1.47651806e-01f, 5.29171480e-03f, 2.36881375e-02f, -4.75071371e-02f,
  5.99712655e-02f, -8.12019035e-02f, -3.44106555e-01f, -6.14754371e-02f, -5.12549691e-02f, 2.59781927e-01f, -5.40769063e-02f, 7.45897368e-02f, 2.87102044e-01f, 1.66890115e-01f,
  2.35510871e-01f, -3.43681127e-02f, -6.93109781e-02f, -1.98274598e-01f, -1.38996854e-01f, -1.96856439e-01f, -7.26185814e-02f, -1.34791166e-01f, 2.92068928e-01f, -9.65071172e-02f,
  6.41406998e-02f, 2.55502671e-01f, 1.06643051e-01f, -2.50959754e-01f, 1.97798803e-01f, -1.39079727e-02f, 6.51528090e-02f, -3.39628682e-02f, -7.35037401e-02f, 3.67683709e-01f,
  4.86536264e-01f, 1.54415920e-01f, 3.84762555e-01f, 2.19410598e-01f, 2.96352983e-01f, -9.79168713e-03f, -3.78587961e-01f, 3.71070921e-01f, 3.77887487e-01f, -5.74177504e-02f,
  -7.28465058e-03f, 4.27940488e-02f, -1.26095161e-01f, 8.32922459e-02f, 5.14548235e-02f, 7.28593990e-02f, -9.20651667e-03f, -1.42635331e-01f, -2.24625006e-01f, 1.17426306e-01f,
  -2.28825048e-01f, -4.42951232e-01f, 6.75729454e-01f, -5.83277270e-02f, 2.93645319e-02f, 4.27279353e-01f, 4.12546657e-02f, 5.43518364e-01f, -9.07679200e-02f, -2.04878896e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  4.50151823e-02f, 2.46862188e-01f, 3.84677529e-01f, -1.52669405e-03f, 4.22094285e-01f, 3.00425619e-01f, -1.87982954e-02f, -5.55148721e-02f, 1.61452889e-01f, 1.85372666e-01f,
  3.75534385e-01f, 4.84760165e-01f, 5.85124223e-03f, 1.67181149e-01f, 3.28979284e-01f, 2.11963773e-01f, 3.09026062e-01f, 1.76112518e-01f, 7.06927702e-02f, 1.57091662e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -5.63896656e-01f, 3.51097047e-01f, -3.96296710e-01f, -3.32795411e-01f, -1.72682390e-01f, -2.58121163e-01f, 3.49639744e-01f, 3.37493122e-01f, -2.51558283e-03f, -5.61657369e-01f,
  -2.59301156e-01f, -2.50996739e-01f, 2.49906898e-01f, -6.70865178e-01f, 2.30158463e-01f, 4.78372782e-01f, 4.94989663e-01f, -2.39855811e-01f, -7.30005205e-02f, -2.57638961e-01f,
  -4.39466327e-01f, 4.52489145e-02f, -4.11755979e-01f, 3.86123717e-01f, 1.41317947e-02f, 5.05387262e-02f, -9.60288942e-02f, 4.53656822e-01f, 3.60740483e-01f, 1.19980760e-01f,
  -1.32839009e-03f, -3.77218097e-01f, 5.24692953e-01f, -3.14268887e-01f, 3.71734914e-03f, 1.20283231e-01f, -2.01986969e-01f, -2.98811253e-02f, -9.17475298e-02f, 6.78447068e-01f,
  -1.88345373e-01f, 3.41094792e-01f, -5.10296843e-04f, -5.40242195e-01f, 3.34748656e-01f, -4.23897684e-01f, 7.77993917e-01f, -3.05823267e-01f, 1.27904087e-01f, 2.59768009e-01f,
  -2.16725096e-01f, 1.29014388e-01f, -3.95695239e-01f, 3.23779553e-01f, -3.33781779e-01f, 5.85769475e-01f, -2.24461153e-01f, 3.17029119e-01f, 1.31340429e-01f, 6.51422441e-01f,
  -4.28382635e-01f, -2.28921726e-01f, -5.12347706e-02f, -2.93896914e-01f, 2.24916786e-01f, -1.58435628e-01f, 4.31030393e-01f, -7.81885833e-02f, 5.14829695e-01f, 1.86979361e-02f,
  2.97703296e-01f, -5.47702432e-01f, -1.06931493e-01f, -3.48159254e-01f, -1.22782946e-01f, -5.89195311e-01f, -3.06366682e-02f, -2.61934429e-01f, 6.43416882e-01f, 8.72463137e-02f,
  -5.05232394e-01f, -2.42089435e-01f, -1.23038866e-01f, -3.60863000e-01f, 6.99374616e-01f, -3.41266781e-01f, -1.19712176e-02f, -1.66926622e-01f, -3.05333406e-01f, 3.57612729e-01f,
  4.41414475e-01f, -2.92832963e-02f, -2.44803667e-01f, 5.52588344e-01f, -1.34059340e-01f, -2.40046963e-01f, -4.10089433e-01f, 5.51341057e-01f, 1.95757732e-01f, 3.45220082e-02f,
  -2.69456536e-01f, -3.98123801e-01f, 1.07161395e-01f, 2.77735531e-01f, -1.13578722e-01f, 4.90239620e-01f, -4.12433028e-01f, -8.12591240e-02f, 1.32358804e-01f, 2.15724692e-01f,
  -3.85320038e-01f, -2.81327844e-01f, -2.06571460e-01f, -8.58526304e-02f, -1.16746053e-01f, -3.68360102e-01f, 7.96884894e-01f, -1.00240447e-02f, -3.87206316e-01f, -4.65344638e-02f,
  9.84828174e-02f, -3.23616862e-01f, -1.77555159e-02f, 1.06203802e-01f, 2.19269067e-01f, 7.29569793e-01f, -2.71661639e-01f, -4.10925031e-01f, -6.75655305e-02f, -1.86297551e-01f,
  -2.32000202e-01f, 3.56674433e-01f, -1.29133239e-01f, -3.41595225e-02f, 5.70096135e-01f, -7.77800024e-01f, -4.72590715e-01f, -1.04838587e-01f, -4.12549376e-01f, -5.73910713e-01f,
  -4.69673127e-01f, 4.26474839e-01f, -1.60185527e-02f, 1.89031124e-01f, 6.70136273e-01f, -4.80439663e-02f, 1.91328317e-01f, -1.61889225e-01f, 3.62406820e-01f, -2.42190629e-01f,
  -5.34871280e-01f, -6.44868553e-01f, 9.57648829e-02f, 2.02009723e-01f, -5.04851229e-02f, 2.42498387e-02f, 3.30225796e-01f, 5.86415119e-02f, -1.11194715e-01f, -1.22397855e-01f,
  -8.32571089e-03f, 7.62345970e-01f, 3.29378545e-01f, 3.89700651e-01f, 3.41357917e-01f, 3.42584014e-01f, -3.43099535e-01f, 2.02363819e-01f, -3.10023248e-01f, 2.89100409e-02f,
  -1.44017339e-01f, -1.27351806e-01f, -3.94740522e-01f, -4.20654833e-01f, 2.21877113e-01f, -4.67355587e-02f, 5.35702944e-01f, -1.84273973e-01f, -3.07782087e-02f, -3.63124870e-02f,
  5.40287681e-02f, -1.33596048e-01f, 2.07974747e-01f, 9.78048623e-01f, -1.85861997e-02f, -2.35981286e-01f, -3.95772308e-01f, -1.20642468e-01f, -1.14363700e-01f, -5.32367587e-01f,
  -4.41069826e-02f, 7.25195289e-01f, -4.85224843e-01f, -4.37025011e-01f, 6.60262853e-02f, -2.38424152e-01f, -4.74431179e-02f, -4.83726293e-01f, -3.74463946e-01f, -4.80670691e-01f,
  1.00054219e-01f, -4.33786303e-01f, 5.10851443e-01f, 7.87200093e-01f, -8.59009624e-02f, 2.28471905e-01f, -4.11263913e-01f, -1.01481125e-01f, -3.34405869e-01f, 1.73580796e-01f,
  3.69155586e-01f, 2.46433347e-01f, -3.52546006e-01f, -4.30805624e-01f, 8.55470896e-01f, -1.07679561e-01f, -3.11095528e-02f, -6.71372339e-02f, 1.25622498e-02f, 1.89928468e-02f,
  5.93018234e-02f, -5.39429069e-01f, 3.92800033e-01f, 1.65281480e-03f, -6.43414974e-01f, -4.06967729e-01f, -4.73065197e-01f, -4.03300852e-01f, -5.93114793e-01f, 6.63197413e-02f,
  4.87728566e-01f, 6.22998700e-02f, 6.24475479e-02f, -1.86939880e-01f, 2.64587939e-01f, 7.83405080e-02f, 2.03288347e-01f, 1.25753507e-01f, -1.32639959e-01f, -1.49909422e-01f,
  -2.52138168e-01f, -1.97023422e-01f, -8.49559829e-02f, 1.17821701e-01f, 6.59053266e-01f, 5.92260182e-01f, 1.38006791e-01f, -3.47533017e-01f, 1.88868612e-01f, 3.82969826e-02f,
  -2.83898562e-01f, -2.85938144e-01f, -2.41687596e-01f, 3.28947604e-01f, -5.29694594e-02f, -2.19548061e-01f, 2.03189328e-02f, 2.43075579e-01f, -2.48623148e-01f, -2.71742970e-01f,
  2.91261673e-01f, 2.20252872e-01f, -3.82586181e-01f, 8.03923845e-01f, 5.05599797e-01f, 7.31121361e-01f, 3.25574845e-01f, 7.95637965e-01f, -1.91694632e-01f, -4.29678857e-01f,
  -1.15062026e-02f, -2.97320724e-01f, -2.27144942e-01f, 4.73082125e-01f, 2.17333198e-01f, 3.58706057e-01f, -4.08094078e-01f, -1.95465505e-01f, 4.50661391e-01f, 2.28433862e-01f,
  2.99349874e-01f, -3.90980244e-01f, 6.11868262e-01f, -2.52385706e-01f, -1.52005985e-01f, -4.63440299e-01f, -1.59009829e-01f, -3.30865175e-01f, 5.27258277e-01f, -8.92788768e-01f,
  1.67290699e-02f, 1.51694298e-01f, 2.80604392e-01f, 7.90232837e-01f, 1.18451305e-01f, -1.28541812e-01f, 2.62980573e-02f, -2.49915585e-01f, -1.60474390e-01f, -1.18307091e-01f,
  1.52857110e-01f, 8.39514971e-01f, -8.10420960e-02f, 2.25989878e-01f, -2.37281248e-01f, -2.93120444e-01f, 5.88071235e-02f, 4.08026338e-01f, -1.46952346e-01f, -4.24045831e-01f,
  4.32313323e-01f, -5.77857792e-01f, -3.89868081e-01f, 3.69212359e-01f, -5.82209490e-02f, -2.00637951e-02f, 1.29704788e-01f, -8.54008794e-02f, -2.38250941e-02f, -1.84031501e-01f,
  8.67063552e-02f, 4.81300205e-01f, 2.53612697e-01f, -9.49015543e-02f, -7.54083842e-02f, -1.34524718e-01f, -5.36885299e-02f, -7.13281184e-02f, 1.76382020e-01f, 6.49761975e-01f,
  -3.69371474e-01f, -4.49197322e-01f, 1.25380233e-01f, 4.84986097e-01f, -4.75126624e-01f, -2.41541862e-01f, -1.11714199e-01f, 1.32508248e-01f, 1.35208249e-01f, -2.93966800e-01f,
  -1.19614370e-01f, -1.57966062e-01f, -1.02575168e-01f, -3.69120628e-01f, 2.56343722e-01f, 3.95682119e-02f, -2.75060207e-01f, -1.11071929e-01f, -2.71208793e-01f, -4.63903338e-01f,
  -1.68389171e-01f, 9.61206734e-01f, 3.02399188e-01f, 3.54683220e-01f, 3.90191883e-01f, 4.16408598e-01f, -1.09303370e-01f, -1.42199054e-01f, -2.30298564e-01f, -5.36229610e-01f,
  3.97035301e-01f, -3.26271415e-01f, 4.33722943e-01f, 8.33856881e-01f, -1.82614271e-02f, -9.01000500e-02f, -5.92467546e-01f, -3.22273374e-01f, -3.82645339e-01f, -1.74542934e-01f,
  -1.04039319e-01f, -2.48086199e-01f, -3.07336181e-01f, 9.48330998e-01f, 6.91157356e-02f, -7.14976862e-02f, -1.22822467e-02f, -1.18248478e-01f, -1.18297637e-01f, -2.06296101e-01f,
  2.71751791e-01f, 2.93089718e-01f, 4.38490987e-01f, -4.44294289e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.81183434e-02f, 5.99842258e-02f, 5.47369905e-02f, 2.72378568e-02f, 1.69941545e-01f, 3.04444939e-01f, 4.76580225e-02f, -2.64917284e-01f, 1.62022457e-01f, -1.48371130e-01f,
  -6.95770159e-02f, 3.78936946e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    