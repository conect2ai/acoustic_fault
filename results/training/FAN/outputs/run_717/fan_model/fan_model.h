/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.49130428e-01f, -1.76762670e-01f, -5.80326766e-02f, 2.68478662e-01f, -1.41249210e-01f, -2.25278899e-01f, -3.78862202e-01f, -2.32856274e-01f, 1.49639338e-01f, -3.76679413e-02f,
  -1.29778147e-01f, -1.06450776e-02f, -6.30692616e-02f, -2.28618711e-01f, -7.49804229e-02f, -2.28778169e-01f, -1.23959906e-01f, -1.09597221e-02f, -1.49988502e-01f, -7.86124542e-02f,
  -4.74386066e-02f, 2.79544502e-01f, 4.02390033e-01f, 6.10656328e-02f, -9.04023368e-03f, -9.81837511e-03f, -4.52579036e-02f, 4.80786078e-02f, -1.70819193e-01f, -2.27932017e-02f,
  2.75471471e-02f, 1.62864029e-02f, -6.46645576e-02f, 1.01401232e-01f, -8.43288079e-02f, -2.19780561e-02f, -1.20452307e-01f, -2.74338364e-03f, -4.30580415e-02f, 5.87692810e-03f,
  -3.94431688e-02f, -7.47626796e-02f, 9.33756307e-03f, -1.19341966e-02f, -2.96540912e-02f, -3.25002261e-02f, -6.37292564e-02f, -2.32424885e-02f, -6.20670915e-02f, -6.46345168e-02f,
  -1.21982172e-02f, 5.26418397e-03f, 5.72004803e-02f, -1.55574098e-01f, 9.15693957e-03f, -5.90658523e-02f, -7.06464499e-02f, -7.04870969e-02f, -1.27140462e-01f, 1.16155553e-03f,
  4.60631251e-02f, 6.83247969e-02f, -6.01422563e-02f, 2.09025964e-02f, 1.77021399e-02f, -2.07731631e-02f, -1.37235960e-02f, -1.23573400e-01f, -1.13742696e-02f, -2.40769051e-02f,
  -7.07915649e-02f, -9.66493189e-02f, 7.66509958e-03f, -4.74746339e-02f, -7.14395866e-02f, -2.96768118e-02f, 1.77166816e-02f, -7.76135772e-02f, 5.39119206e-02f, 3.14454548e-02f,
  -3.39465551e-02f, 4.63367216e-02f, 1.72959175e-02f, 8.53777863e-03f, -7.57009536e-02f, -1.39990360e-01f, -4.53293100e-02f, -6.77695647e-02f, -1.53341657e-03f, -2.05281861e-02f,
  -4.27189209e-02f, -2.77907372e-01f, -4.39013995e-04f, -1.10370263e-01f, -5.43322153e-02f, -3.51808518e-02f, -5.99584281e-02f, -1.01355882e-03f, 4.77951244e-02f, -3.51428837e-02f,
  -8.57554525e-02f, -9.80594680e-02f, -5.48676290e-02f, -8.01983476e-02f, -7.54587948e-02f, 3.45693319e-04f, -7.22760409e-02f, -4.48856177e-03f, -1.07468009e-01f, 3.79010811e-02f,
  -1.07886761e-01f, -2.40615383e-02f, 4.47617359e-02f, -2.39650607e-02f, -2.99839731e-02f, -6.21397234e-02f, -4.35354933e-02f, -1.14221580e-01f, -6.17025606e-02f, 5.31662209e-03f,
  -5.60375035e-01f, 2.33036146e-01f, 8.04869980e-02f, -3.96735221e-02f, 2.20933065e-01f, 3.91925685e-02f, 3.19855571e-01f, -2.07420271e-02f, -1.81042448e-01f, 2.60512620e-01f,
  -8.26739613e-03f, -1.25038609e-01f, -9.11181793e-02f, -1.62212268e-01f, -9.41557810e-02f, 2.96751767e-01f, 2.42977679e-01f, -4.38347422e-02f, -1.85989186e-01f, -5.86454794e-02f,
  1.06478751e-01f, -3.85748483e-02f, -2.40431637e-01f, -2.11953640e-01f, 7.22845942e-02f, -2.10075275e-04f, 2.61145900e-03f, 2.36806367e-02f, 3.58899646e-02f, 2.60958344e-01f,
  -1.10738441e-01f, -1.69475377e-01f, -1.43987536e-01f, -9.63665992e-02f, -6.36761934e-02f, -9.13516134e-02f, -7.59076700e-02f, -1.98886067e-01f, -6.40586093e-02f, -4.78629768e-02f,
  -5.56558184e-02f, -1.55273288e-01f, -2.45545805e-01f, -1.64802492e-01f, -8.09703693e-02f, -1.14826724e-01f, -3.28215249e-02f, -2.57430762e-01f, -1.70075893e-01f, -1.25717923e-01f,
  2.35315729e-02f, 2.41506379e-02f, -9.07795131e-02f, -1.58135802e-01f, -1.47055373e-01f, -8.19301978e-02f, -6.60727322e-02f, -2.84993559e-01f, -1.54957145e-01f, -3.92003097e-02f,
  3.56816873e-02f, 1.23595130e-02f, 7.09982514e-02f, -3.81933339e-02f, 1.88719034e-01f, 3.87220606e-02f, 7.36377612e-02f, 1.16442956e-01f, 1.35997096e-02f, 5.71476705e-02f,
  9.14847255e-02f, 3.45536210e-02f, -6.10361481e-03f, -5.56025608e-03f, 1.05534069e-01f, 7.94077665e-02f, 8.74579847e-02f, 8.47551823e-02f, 3.23971622e-02f, 4.69023287e-02f,
  9.34818313e-02f, 8.32733884e-02f, -7.10878242e-03f, 4.17187363e-02f, 1.29501015e-01f, 7.24933296e-02f, 6.16860576e-02f, 1.64622739e-01f, 6.64995015e-02f, 5.21518476e-02f,
  -6.13025296e-03f, -2.21164361e-01f, -3.62057649e-02f, -7.23526999e-02f, -6.69400394e-02f, -4.30228747e-02f, -1.48162365e-01f, -1.41811639e-01f, -1.73661992e-01f, -2.72083152e-02f,
  -1.57205909e-01f, -1.54370159e-01f, -6.05422705e-02f, -1.12225376e-01f, -9.59700644e-02f, -8.01224187e-02f, -3.35613862e-02f, -1.41536474e-01f, -6.58347234e-02f, -1.29288822e-01f,
  -1.09047294e-01f, -4.90869116e-03f, -1.07600644e-01f, -7.69726606e-03f, -6.39625192e-02f, -9.26198959e-02f, 1.19960774e-02f, -1.16235122e-01f, -1.74969643e-01f, 1.19961552e-01f,
  -1.48121655e-01f, -1.16537370e-01f, -1.66370377e-01f, -2.94429600e-01f, -2.28104800e-01f, -1.01798147e-01f, -3.13349366e-02f, 1.86498836e-02f, 9.24634188e-02f, -1.98891327e-01f,
  -2.79648453e-01f, -2.07535803e-01f, -1.75791040e-01f, -6.16942309e-02f, -3.71135568e-04f, 2.39110105e-02f, -3.22011076e-02f, -7.48865604e-02f, -1.97883844e-01f, -2.82137603e-01f,
  -2.39682689e-01f, -7.42835775e-02f, -1.86432555e-01f, -4.53914553e-02f, -1.81636214e-01f, -1.37589052e-01f, -9.59360972e-02f, -1.26344293e-01f, -2.04435691e-01f, -3.58617127e-01f,
  -2.34630242e-01f, -2.87327319e-01f, -1.30246118e-01f, -2.04627112e-01f, -7.99427405e-02f, 2.33089738e-02f, -1.37045577e-01f, 5.47118299e-03f, -5.30488119e-02f, -9.04073641e-02f,
  -1.66421264e-01f, -9.65158939e-02f, -2.04473600e-01f, -6.27565458e-02f, -8.57169852e-02f, 4.51072166e-03f, 8.09599236e-02f, -1.80365015e-02f, -1.10561259e-01f, -1.64070278e-01f,
  -1.28684044e-01f, -1.80629537e-01f, 3.97422537e-02f, 6.17441908e-03f, -2.64871661e-02f, -5.46836555e-02f, -1.84671342e-01f, -1.01421647e-01f, -1.13346696e-01f, 6.87323511e-02f,
  8.58968720e-02f, 1.72949675e-02f, 1.51487976e-01f, 1.33432075e-01f, 1.38227925e-01f, 1.43739895e-03f, -1.90381296e-02f, 9.12313238e-02f, -4.36606407e-02f, 2.22338766e-01f,
  5.98191172e-02f, 3.38994935e-02f, 4.34905849e-02f, 9.89939552e-03f, -9.33530033e-02f, -7.06429407e-02f, -3.31950001e-02f, -9.13892593e-03f, 1.12401478e-01f, 1.05108522e-01f,
  7.10461661e-02f, 9.88844130e-03f, 1.53380111e-01f, 3.24625000e-02f, -1.45331156e-02f, 7.96843395e-02f, -2.38603144e-03f, 1.72769483e-02f, 1.12497590e-01f, 2.24655736e-02f,
  -5.98657131e-03f, -2.58318901e-01f, -1.81450859e-01f, -6.61793426e-02f, -1.03813745e-01f, 6.81674778e-02f, -1.60551175e-01f, -9.48308632e-02f, -1.85805708e-01f, -1.35594472e-01f,
  -2.02498317e-01f, -1.55080050e-01f, -1.21297821e-01f, -6.32406250e-02f, 3.29000689e-02f, -4.58977558e-02f, -1.68144718e-01f, -1.94103643e-01f, -1.67049512e-01f, -1.00563906e-01f,
  -1.07151799e-01f, 1.22545669e-02f, 1.48408085e-01f, 9.24875811e-02f, -1.64434522e-01f, -1.17417373e-01f, 2.14982498e-02f, -8.89442191e-02f, 6.08228855e-02f, 3.07035297e-01f,
  5.65744080e-02f, -1.91410050e-01f, -2.09943518e-01f, 1.01370946e-01f, -1.23190418e-01f, 2.58205775e-02f, -1.83930144e-01f, 7.51619786e-02f, 1.26732305e-01f, -1.52604327e-01f,
  1.46540359e-01f, 1.63120016e-01f, 9.10539739e-03f, 1.57849833e-01f, -4.52000424e-02f, -1.84062660e-01f, -1.20012984e-01f, -8.80781785e-02f, 4.84807491e-02f, 3.43791880e-02f,
  8.77915472e-02f, -6.20265640e-02f, 1.62084639e-01f, 1.32335812e-01f, 9.87170935e-02f, 6.24467805e-02f, -1.39168814e-01f, 9.29419026e-02f, 1.04733244e-01f, -1.34830922e-01f,
  -8.75804648e-02f, 1.31296724e-01f, 6.16274513e-02f, 2.10508093e-01f, 1.65857702e-01f, 6.13451228e-02f, -8.06563813e-03f, 6.76671788e-02f, 8.69585872e-02f, 1.13259912e-01f,
  1.79416239e-01f, 1.20952539e-01f, 1.71893891e-02f, -2.35665403e-02f, -8.99271443e-02f, -4.41037642e-04f, 1.17561199e-01f, 4.69553880e-02f, -7.13718608e-02f, 4.44515236e-02f,
  -8.94371346e-02f, 1.96727142e-02f, -5.35026491e-02f, 2.41200044e-03f, 9.43301693e-02f, 1.49577588e-01f, 1.24391332e-01f, 1.77179173e-01f, 5.61463237e-02f, 1.75725706e-02f,
  6.32664263e-02f, -1.37599660e-02f, -2.62323264e-02f, -2.46438403e-02f, -1.29998038e-02f, -1.22088090e-01f, 7.25314915e-02f, -1.04991995e-01f, -1.60970509e-01f, -8.00261274e-02f,
  -1.34031802e-01f, -1.63979322e-01f, -9.46644694e-02f, -5.14449663e-02f, -1.42004276e-02f, -7.58584728e-03f, 4.94966954e-02f, -4.56118770e-02f, 1.42267317e-01f, 3.41737233e-02f,
  -9.30337887e-03f, 7.18588755e-03f, -2.02803351e-02f, 6.58967867e-02f, -7.90969729e-02f, 7.52423406e-02f, 2.02786904e-02f, 4.91421148e-02f, -8.94732997e-02f, 5.99237792e-02f,
  -1.35989279e-01f, 7.70278350e-02f, -5.91425821e-02f, 1.31461099e-01f, 1.66847423e-01f, 1.63040057e-01f, -4.79276367e-02f, 9.03641433e-02f, 1.69801917e-02f, 1.42968059e-01f,
  1.07695192e-01f, 2.86097489e-02f, 9.33582410e-02f, 6.47758774e-04f, -5.73809557e-02f, -7.99792185e-02f, -8.70305952e-03f, 5.56696244e-02f, 7.44223073e-02f, 4.62262779e-02f,
  -6.23424910e-02f, -7.71384984e-02f, -7.28441104e-02f, -1.30940512e-01f, -6.12525493e-02f, -8.52829292e-02f, -1.32383600e-01f, -6.73614442e-02f, -9.65925306e-02f, -3.42274457e-01f,
  -1.62203178e-01f, 3.50610316e-02f, -3.73936921e-01f, -2.46960267e-01f, -8.02551582e-02f, 3.24782766e-02f, 3.46268900e-02f, 2.41506454e-02f, -1.63164996e-02f, -2.20270962e-01f,
  -2.33191341e-01f, -2.95163661e-01f, -1.84968099e-01f, -2.04105943e-01f, -2.18213603e-01f, -2.69257307e-01f, -2.88290888e-01f, -2.46357962e-01f, -1.56110659e-01f, -1.36586100e-01f,
  2.62294579e-02f, -1.60140190e-02f, -1.53052598e-01f, -5.17393909e-02f, 5.39488755e-02f, 2.07633059e-02f, -5.98257743e-02f, 1.43384621e-01f, 5.86639196e-02f, -8.04506317e-02f,
  -2.36464277e-01f, 1.71343103e-01f, -2.98177134e-02f, 4.09326021e-04f, -3.31600346e-02f, 1.56166181e-02f, -3.27637382e-02f, -1.41278788e-01f, -7.65926316e-02f, -1.02060564e-01f,
  -4.97566052e-02f, -5.70131540e-02f, -1.84909463e-01f, -1.70185253e-01f, -1.67970851e-01f, -9.88948792e-02f, -1.02163311e-02f, -1.55168504e-01f, -1.25155762e-01f, -1.01473212e-01f,
  -1.52741745e-01f, -1.08164139e-02f, -1.66191131e-01f, 1.07594311e-01f, -6.23272397e-02f, -5.20081893e-02f, 7.02541098e-02f, -1.84656365e-03f, 5.26437424e-02f, 9.32850614e-02f,
  -5.76558225e-02f, -1.90928251e-01f, -6.99310303e-02f, -5.92099391e-02f, -9.09798890e-02f, -1.21685557e-01f, -2.99921967e-02f, -8.01530108e-02f, -7.15954527e-02f, 4.95732129e-02f,
  -8.76768604e-02f, -1.66566432e-01f, -4.56480682e-02f, -1.11865878e-01f, -1.17017701e-01f, -2.31163837e-02f, -5.95344510e-03f, -5.54636866e-03f, 9.18739513e-02f, 4.71086726e-02f,
  -1.00549333e-01f, -1.53667247e-02f, -8.53830352e-02f, -5.73595054e-02f, -1.83045909e-01f, -5.52637391e-02f, 3.92796919e-02f, -2.93256659e-02f, 3.63096148e-02f, 8.92310217e-03f,
  -6.62082061e-02f, 2.97853984e-02f, 7.01131374e-02f, -4.76602167e-02f, 1.79542959e-01f, 4.56005754e-03f, 6.21874556e-02f, -1.50008928e-02f, -3.43140797e-03f, 8.96677896e-02f,
  -4.09327075e-02f, -9.01209116e-02f, -6.76224306e-02f, -8.09344500e-02f, -7.63314068e-02f, -1.14617907e-01f, -2.79499236e-02f, -9.83185098e-02f, -5.51617146e-03f, -1.89847574e-01f,
  -2.18061179e-01f, -9.01729017e-02f, 3.21926549e-02f, 8.46871883e-02f, 1.39745310e-01f, -5.97026534e-02f, 2.44831834e-02f, 1.62976548e-01f, -4.79477681e-02f, 7.05012307e-02f,
  -1.49375990e-01f, -3.53025682e-02f, -2.38596201e-01f, -8.72205347e-02f, -1.43678188e-01f, -1.59941524e-01f, -1.49981037e-01f, -9.07080024e-02f, 7.25903036e-03f, -9.43871737e-02f,
  -3.09519877e-04f, 2.14612763e-02f, -2.90070549e-02f, -9.34098735e-02f, -8.52684379e-02f, -2.59429842e-01f, -3.75341535e-01f, -1.94693998e-01f, -2.38025755e-01f, -1.22548155e-01f,
  -1.57020420e-01f, -1.70839235e-01f, -1.77779019e-01f, -2.12849796e-01f, -2.39995748e-01f, -2.13596433e-01f, -2.88969457e-01f, -1.57832548e-01f, -1.85053498e-01f, -4.60497975e-01f,
  -1.89561531e-01f, -2.64513433e-01f, -1.36303887e-01f, -7.43947998e-02f, -1.57910138e-02f, -1.60028860e-01f, -5.89711517e-02f, -5.56744412e-02f, 3.18618938e-02f, -7.68753588e-02f,
  -3.47840525e-02f, -1.55237261e-02f, -1.35699973e-01f, -1.45297479e-02f, -1.46404326e-01f, -5.94016947e-02f, -1.35836629e-02f, -2.04464078e-01f, -2.00382963e-01f, -1.15415789e-01f,
  -1.61931291e-01f, -2.18369931e-01f, -9.19531882e-02f, -9.01374891e-02f, -1.14372388e-01f, -1.12497739e-01f, -1.83152363e-01f, -1.38855025e-01f, -1.62756056e-01f, -2.93606609e-01f,
  -5.85408509e-02f, -7.97367319e-02f, -5.01490906e-02f, 5.33763953e-02f, 1.78042099e-01f, 5.30591123e-02f, 3.89765576e-02f, 4.50108983e-02f, 2.51767375e-02f, 7.66314715e-02f,
  3.85578498e-02f, -7.86824599e-02f, -3.15056965e-02f, -1.00776277e-01f, 3.96232456e-02f, -5.79732843e-02f, 5.48398308e-02f, 2.72615049e-02f, -2.20848992e-02f, 1.45364046e-01f,
  1.44368067e-01f, 9.52652022e-02f, 8.22934285e-02f, 1.84412211e-01f, 7.87400305e-02f, -2.73133405e-02f, 3.34315971e-02f, 1.32267073e-01f, 1.39269516e-01f, 2.51526125e-02f,
  -8.68279636e-02f, -5.86732663e-03f, -6.40371516e-02f, -1.16303742e-01f, -7.62998238e-02f, 1.23076059e-03f, -1.22628853e-01f, -8.15123245e-02f, -3.14205028e-02f, -1.59414247e-01f,
  -6.99173957e-02f, -1.15956880e-01f, -5.81927523e-02f, -1.24937847e-01f, -1.69502810e-01f, -1.63226634e-01f, -6.09760545e-02f, -1.07648022e-01f, -7.88977668e-02f, -1.62335232e-01f,
  -7.57671520e-02f, -1.77673861e-01f, -1.04867496e-01f, -1.32245021e-02f, -2.24244565e-01f, -1.69090569e-01f, -1.85009226e-01f, -1.02602758e-01f, -1.92836657e-01f, -3.45287584e-02f,
  -6.06626213e-01f, -1.78047344e-01f, -2.20538944e-01f, -1.68315142e-01f, -9.17441100e-02f, -1.56764984e-01f, -2.26838619e-01f, -1.68851186e-02f, 7.02848062e-02f, -1.53049733e-02f,
  -4.87105139e-02f, -6.94380477e-02f, 1.39739667e-03f, 1.25908703e-01f, 5.41941188e-02f, -2.41987333e-02f, 1.26844853e-01f, -3.26285735e-02f, -3.77746932e-02f, 1.12043403e-01f,
  1.15695879e-01f, 4.36430937e-03f, -1.74819343e-02f, 5.08044884e-02f, 1.78319871e-01f, 1.61139205e-01f, 1.01172410e-01f, 1.29566461e-01f, 2.54189521e-01f, 2.32121304e-01f,
  -2.69856416e-02f, -2.58046657e-01f, 2.40343213e-02f, -3.88044082e-02f, 7.17928484e-02f, 1.02212273e-01f, 6.73081204e-02f, 1.73668474e-01f, 5.52500263e-02f, 7.86543116e-02f,
  1.14318915e-01f, 1.42794594e-01f, 1.20239677e-02f, -3.87898227e-03f, -6.85390830e-02f, 7.80398622e-02f, 1.61880836e-01f, 6.70389310e-02f, -3.79653871e-02f, 7.99588934e-02f,
  4.65613604e-02f, 2.67527457e-02f, -2.67620031e-02f, 1.63931288e-02f, 8.91904440e-03f, 5.25611453e-03f, 4.94129583e-02f, 1.86854184e-01f, 3.88374627e-02f, 1.49281740e-01f,
  -2.79263593e-02f, -7.47573152e-02f, -1.22433379e-02f, -3.25753912e-02f, -2.76523456e-02f, 2.01322854e-01f, -7.88207501e-02f, -5.27566187e-02f, 1.55508444e-02f, 9.01689157e-02f,
  -6.50636032e-02f, -4.67088409e-02f, -1.34260468e-02f, -1.31103128e-01f, 8.11930075e-02f, -5.61532490e-02f, -5.61031550e-02f, 6.44162446e-02f, 3.74763533e-02f, 3.03788427e-02f,
  -3.83528061e-02f, -7.25806970e-03f, -8.00961405e-02f, -3.73002850e-02f, -7.28622526e-02f, -5.73314764e-02f, 2.68982016e-02f, -1.99066475e-02f, 2.60104910e-02f, 1.40644044e-01f,
  -2.68698931e-02f, -3.79420631e-02f, 1.04511514e-01f, 6.45509660e-02f, 3.55395861e-02f, 1.67218700e-01f, -4.88641858e-02f, 1.58950426e-02f, -5.73448613e-02f, 4.58045341e-02f,
  6.05717041e-02f, 4.55495389e-03f, 4.21235599e-02f, 1.02118783e-01f, 7.25821331e-02f, 4.79964912e-02f, 3.81950662e-02f, 4.25200025e-03f, 6.91502839e-02f, 1.34101406e-01f,
  1.04525559e-01f, 7.91294575e-02f, 1.30884573e-01f, 2.89038159e-02f, 1.77633211e-01f, 1.11130670e-01f, 2.24813193e-01f, 5.15553989e-02f, 7.89812356e-02f, 5.96548170e-02f,
  5.51881671e-01f, -2.53671199e-01f, 9.24612880e-02f, 2.17070766e-02f, -1.39891341e-01f, 6.47614896e-02f, -9.08274017e-03f, -3.62120830e-02f, -1.42384553e-02f, -1.40513644e-01f,
  -1.11542940e-01f, -9.69746709e-02f, -1.80718042e-02f, -5.40805273e-02f, 1.86110243e-01f, 3.10498085e-02f, -6.33912012e-02f, 1.71961248e-01f, 1.81033090e-01f, -1.13510348e-01f,
  -2.92564571e-01f, -5.76938726e-02f, 1.87420473e-01f, -6.56397715e-02f, -2.26671085e-01f, -2.68386696e-02f, -1.43053755e-01f, -4.02741358e-02f, -1.77197427e-01f, -3.72592092e-01f,
  3.09251454e-02f, 3.42663750e-02f, 2.73242290e-03f, 4.87449020e-03f, -1.21309562e-02f, 2.88803689e-02f, 1.70492753e-02f, 1.03181312e-02f, 4.36828993e-02f, -6.26784563e-02f,
  -1.06606394e-01f, -4.97837588e-02f, 5.09449327e-03f, -1.48888454e-01f, -4.43182886e-02f, 3.05239987e-02f, 2.07853336e-02f, 5.51672764e-02f, 5.81699945e-02f, -1.02064840e-01f,
  -1.07790895e-01f, -3.69270928e-02f, 4.02547494e-02f, -1.05896192e-02f, 2.36204080e-02f, 5.21815494e-02f, -1.14542462e-01f, 7.25146979e-02f, 4.77337725e-02f, -1.26790792e-01f,
  -2.49465518e-02f, 6.16378002e-02f, 1.13450013e-01f, -2.86538783e-03f, 9.99856144e-02f, -2.24699192e-02f, -6.91616982e-02f, -8.41317400e-02f, -6.65574893e-02f, 2.07888726e-02f,
  -3.18193156e-03f, -4.28100489e-02f, 8.37366283e-03f, -3.60726044e-02f, 2.18914207e-02f, -1.09190503e-02f, 4.10268866e-02f, 5.17802909e-02f, -3.66244279e-02f, 3.07569117e-03f,
  -6.46706522e-02f, -3.23791653e-02f, 2.01572645e-02f, -5.74451536e-02f, -1.48418024e-02f, 1.99603513e-02f, 1.10520646e-02f, -8.81397054e-02f, 5.89496531e-02f, 4.46030162e-02f,
  -1.40346065e-01f, 1.56565569e-02f, -4.68532629e-02f, -3.79562750e-02f, -3.90761793e-02f, 1.04447016e-02f, -7.87561536e-02f, -4.58827615e-02f, -3.92839313e-02f, -9.80203077e-02f,
  5.68765327e-02f, 1.20676838e-01f, -1.70978550e-02f, -5.16636018e-03f, 4.99557219e-02f, -5.40346913e-02f, -5.81227355e-02f, 9.53109339e-02f, -1.80927757e-02f, -4.50371876e-02f,
  3.13018188e-02f, 6.00792132e-02f, 8.64302292e-02f, 9.00094863e-03f, -2.23218910e-02f, 1.21668018e-01f, 1.79929715e-02f, 6.88002855e-02f, 1.69999540e-01f, 4.14933488e-02f,
  4.76925105e-01f, 8.54347721e-02f, 1.03181034e-01f, 1.25021249e-01f, -5.48390150e-02f, -4.78144214e-02f, -1.62001718e-02f, 7.93340877e-02f, 8.39712471e-02f, 8.78596585e-03f,
  -3.30735631e-02f, -1.72754645e-01f, -1.46449491e-01f, -1.74856916e-01f, 1.29495844e-01f, -8.66876990e-02f, 3.80236208e-02f, 1.06861733e-01f, -9.00453478e-02f, -7.46496767e-02f,
  -2.11868942e-01f, -9.59751457e-02f, 2.06076726e-01f, -2.88870186e-02f, -2.28416957e-02f, -2.15667084e-01f, -2.56521930e-03f, 4.87306667e-03f, -2.29877830e-01f, -1.88209936e-01f,
  -2.61863023e-02f, 7.17894658e-02f, -1.20576128e-01f, -8.06053355e-03f, -4.66479966e-03f, -4.05136980e-02f, -1.47158168e-02f, 1.11501105e-01f, 1.38812559e-02f, 5.71247016e-04f,
  4.08777297e-02f, 1.63428411e-02f, -2.48003248e-02f, 2.06113812e-02f, 2.36849301e-02f, 5.23159429e-02f, 1.13410853e-01f, 7.61782527e-02f, 3.67412232e-02f, 1.06946416e-01f,
  -2.87966095e-02f, -8.39938298e-02f, 1.43641010e-01f, 3.21502760e-02f, 1.32392108e-01f, 1.20828226e-02f, 1.13949023e-01f, 2.24950239e-02f, 6.80642202e-02f, 1.41111955e-01f,
  2.46763676e-02f, 7.62798870e-03f, 8.95586088e-02f, 2.47997884e-02f, -1.71967074e-02f, -1.44999698e-01f, -1.04477644e-01f, -1.05038226e-01f, -3.84842344e-02f, -2.80098710e-02f,
  -8.48953500e-02f, 3.49066071e-02f, 1.55822737e-02f, -3.29232216e-02f, -1.50021225e-01f, 1.52847115e-02f, -3.51577736e-02f, -6.84097270e-03f, 1.68304164e-02f, -8.41001347e-02f,
  -5.34244906e-03f, -3.51290479e-02f, -1.70074046e-01f, -1.87660102e-02f, -3.70374098e-02f, -1.57192107e-02f, 1.37302777e-04f, -9.73311365e-02f, -2.93202661e-02f, -2.09872164e-02f,
  -4.46896628e-02f, -4.42524925e-02f, -3.49936411e-02f, -5.27627906e-03f, -4.53813970e-02f, 2.84323785e-02f, -6.75543696e-02f, -1.17255814e-01f, -1.06018288e-02f, 9.18107107e-02f,
  2.39122137e-02f, 5.06150424e-02f, -1.96316256e-03f, -5.31158522e-02f, -4.18925472e-02f, -2.96471827e-02f, 5.26999049e-02f, -6.85409307e-02f, -8.35231319e-02f, 2.58868467e-02f,
  -4.53527048e-02f, 2.29309928e-02f, 1.97529122e-02f, -6.51650950e-02f, -1.31005784e-02f, -9.30995122e-02f, -7.46798739e-02f, 2.75886767e-02f, 1.14425430e-02f, 9.45752300e-03f,
  -2.86116321e-02f, 4.77932021e-02f, -4.65208143e-01f, 9.33767036e-02f, -2.45785397e-02f, -1.62588477e-01f, -2.70170808e-01f, -1.24083117e-01f, 9.44885612e-02f, 3.08744553e-02f,
  2.04277799e-01f, 3.78846675e-01f, 1.53061166e-01f, 4.63790372e-02f, -1.45944551e-01f, -3.84808749e-01f, -2.86476105e-01f, -3.83021951e-01f, -3.18376929e-01f, -1.60675883e-01f,
  5.09502329e-02f, -1.30167916e-01f, -1.98659450e-01f, -1.81770056e-01f, 3.46380398e-02f, 1.69735953e-01f, -1.47569686e-01f, -1.24813817e-01f, -1.08309612e-01f, -7.64882043e-02f,
  -8.46715085e-03f, -2.42770106e-01f, -6.22913428e-03f, 5.39890490e-03f, -7.95536023e-03f, -1.30463719e-01f, -8.09124932e-02f, -1.52938992e-01f, 1.70328896e-02f, -2.32833046e-02f,
  -1.67529751e-02f, -4.90995720e-02f, -5.29957376e-02f, -1.01593800e-01f, -1.87122643e-01f, -1.66298866e-01f, -1.60383835e-01f, -2.13202029e-01f, -1.19715042e-01f, -1.67048320e-01f,
  -4.62855631e-03f, -1.71211392e-01f, -1.65811181e-01f, -2.74415314e-01f, -2.29141638e-01f, -8.21302831e-02f, -2.03029364e-01f, -2.32641384e-01f, -1.45236343e-01f, -9.28217545e-02f,
  2.69140285e-02f, 5.65659404e-02f, 1.63938366e-02f, 4.62549999e-02f, 1.50583275e-02f, 5.50119765e-02f, 1.78036094e-02f, -1.29605143e-03f, -9.06344056e-02f, -9.23678949e-02f,
  2.68483162e-02f, 1.79394949e-02f, 7.91825205e-02f, 9.90440622e-02f, 3.13599631e-02f, -9.90382396e-03f, -8.29269737e-02f, 5.80749288e-02f, 1.00605777e-02f, 1.10446848e-02f,
  2.20753103e-02f, -4.97247977e-03f, 1.48763349e-02f, 5.28044775e-02f, -1.98902562e-03f, -5.22353174e-03f, -6.11654967e-02f, 2.10117549e-02f, 7.98677951e-02f, 3.45639549e-02f,
  1.76770926e-01f, -9.51084122e-02f, -3.26369107e-02f, -1.11409299e-01f, -1.39120504e-01f, -1.10966444e-01f, 3.39150405e-03f, -1.05940951e-02f, 1.08508635e-02f, -6.01417311e-02f,
  -2.48673558e-02f, 1.07293865e-02f, 2.82932147e-02f, -5.08997813e-02f, -2.51473002e-02f, -9.93008539e-02f, -6.31759018e-02f, 4.53468412e-04f, -5.33067472e-02f, -2.14700424e-03f,
  -7.70741627e-02f, -1.36965290e-01f, -8.58009383e-02f, -7.66504630e-02f, -6.84363320e-02f, 2.66778823e-02f, -1.18457980e-01f, -8.49458501e-02f, -9.35653448e-02f, 1.51763402e-03f,
  -2.97024678e-02f, 7.55052790e-02f, 2.25938112e-01f, -2.26040766e-01f, 2.35323295e-01f, 2.41196185e-01f, 4.98988956e-01f, 1.72765911e-01f, -9.50532779e-02f, 1.18310601e-01f,
  6.51467517e-02f, -1.84045836e-01f, -1.92024797e-01f, -2.61590630e-01f, -4.08528522e-02f, 8.89056250e-02f, -1.16488069e-01f, -1.22310810e-01f, 5.43375425e-02f, 3.03928256e-01f,
  2.04245627e-01f, 1.25470340e-01f, -2.01804787e-01f, -1.30189098e-02f, 9.86374021e-02f, -8.01545531e-02f, -3.11623700e-02f, 4.93163094e-02f, -3.03156651e-03f, -1.55159533e-01f,
  -2.67259758e-02f, 2.84618419e-02f, -6.22663721e-02f, -1.02380849e-01f, 7.33693168e-02f, -5.60264587e-02f, 4.33196867e-04f, -9.49384943e-02f, 4.40420816e-03f, -2.57086717e-02f,
  -5.63993305e-02f, -1.09176636e-01f, -5.58140501e-02f, -2.63697188e-02f, -6.79667220e-02f, 2.26738285e-02f, -1.77177548e-01f, -1.00914404e-01f, -4.95373011e-02f, 8.45118910e-02f,
  1.68082174e-02f, -1.06134731e-02f, 9.35955346e-02f, -2.26514563e-02f, -3.46090682e-02f, -1.02302305e-01f, 4.07191813e-02f, -1.13071747e-01f, -1.65615678e-02f, 5.80522195e-02f,
  7.63722789e-03f, 9.21449438e-02f, 6.92116097e-02f, 1.24875173e-01f, -1.19323004e-02f, -7.60834804e-03f, 3.29660177e-02f, -6.38540015e-02f, -1.06793018e-02f, -2.18743403e-02f,
  -3.59983891e-02f, 4.43832986e-02f, -2.37098876e-02f, 8.50782022e-02f, -2.71868035e-02f, 1.17282748e-01f, 4.10995111e-02f, 3.62659851e-03f, -8.24047923e-02f, -2.63313018e-02f,
  1.25097288e-02f, 9.75018218e-02f, -2.22641299e-03f, 9.45564657e-02f, 1.70388203e-02f, -8.71906579e-02f, -9.93119460e-03f, 1.11948336e-02f, 2.93954425e-02f, 1.62173212e-01f,
  7.12965503e-02f, -1.22745987e-02f, -5.32081835e-02f, -7.92828426e-02f, 1.01669967e-01f, -3.42379441e-03f, -2.34538149e-02f, -8.63395035e-02f, -1.29990920e-01f, 7.95597881e-02f,
  1.27006128e-01f, -6.08199649e-03f, 1.37993123e-03f, 5.04875742e-02f, 6.31215647e-02f, 1.40195349e-02f, -9.69887823e-02f, 6.41082227e-02f, -1.41395897e-01f, -2.94533744e-02f,
  -4.24135290e-02f, 6.02910295e-02f, 1.07275523e-01f, 1.96927898e-02f, 2.75016669e-02f, 3.06646526e-02f, 1.39113873e-01f, 8.62166584e-02f, 1.16933025e-01f, 1.47842944e-01f,
  1.41062170e-01f, -3.15713346e-01f, 8.84454921e-02f, 1.72237381e-02f, -2.50487864e-01f, 3.10784187e-02f, 6.03551455e-02f, 4.40407172e-03f, 1.04488386e-02f, -1.44293578e-02f,
  -9.08545870e-03f, 1.74139261e-01f, 1.08802840e-01f, 2.14253500e-01f, 3.40756595e-01f, 4.28199992e-02f, -7.80857773e-03f, 1.31840587e-01f, 3.81310463e-01f, 8.78876522e-02f,
  -9.34401229e-02f, -8.58910754e-02f, 1.65434748e-01f, 1.75683975e-01f, -2.50007004e-01f, 6.31642789e-02f, -1.61560073e-01f, -4.87383865e-02f, -1.57504424e-01f, -4.13930923e-01f,
  -9.65332240e-02f, -1.65344134e-01f, 1.69458777e-01f, -7.43529573e-02f, -1.00505151e-01f, 3.99503345e-03f, -3.96929262e-03f, -8.64789039e-02f, 9.45454240e-02f, 1.28203765e-01f,
  9.73106921e-03f, -7.25719705e-02f, 4.55605686e-02f, 7.33530596e-02f, 7.49710202e-02f, 1.13673285e-01f, 6.83063343e-02f, 8.55627581e-02f, 1.45506725e-01f, 2.28854548e-03f,
  -7.28506222e-02f, -1.61866322e-01f, -3.84449586e-02f, 5.51286377e-02f, 1.05826534e-01f, 3.94461825e-02f, 9.47476774e-02f, -6.22653328e-02f, 1.16983578e-01f, 1.21611189e-02f,
  -1.38142511e-01f, 8.80607683e-03f, -1.44965178e-03f, 1.58100370e-02f, 4.37728800e-02f, -4.14647795e-02f, 4.28926051e-02f, 3.61206792e-02f, 1.16476202e-02f, 1.26857096e-02f,
  -3.58441807e-02f, 6.67720437e-02f, -2.12649312e-02f, 6.17101789e-02f, 1.14758380e-01f, -3.35600562e-02f, 3.14790867e-02f, 1.83301400e-02f, 8.61281604e-02f, 3.51122320e-02f,
  1.07496083e-02f, -3.38937738e-03f, -2.63912734e-02f, 4.44122031e-02f, 2.38118824e-02f, -7.15354532e-02f, 1.11743927e-01f, -4.32675332e-02f, 8.24494883e-02f, -3.60311419e-02f,
  1.51697308e-01f, 1.30092412e-01f, -2.21037697e-02f, -9.83890053e-03f, 3.41194198e-02f, -5.90450019e-02f, 4.42846864e-02f, 3.68548557e-02f, 4.72970903e-02f, -3.31583656e-02f,
  2.73493826e-02f, 1.18461819e-02f, 4.12673876e-02f, 3.56295630e-02f, 1.06139094e-01f, 1.88199673e-02f, -9.17919632e-03f, 1.08897135e-01f, 5.10975607e-02f, -5.50107248e-02f,
  1.07428003e-02f, 3.34990211e-02f, 9.63828564e-02f, 1.39012143e-01f, 5.99896275e-02f, 1.03982259e-02f, -3.79921421e-02f, 6.30172342e-02f, 4.16648313e-02f, 1.45898789e-01f,
  1.22860126e-01f, 1.37071013e-01f, -3.75213176e-01f, -4.91315760e-02f, -3.60669345e-02f, -2.34048843e-01f, -1.49767473e-01f, -2.44667545e-01f, -2.67848186e-02f, 9.64377970e-02f,
  1.79328054e-01f, 2.85452396e-01f, 9.52751935e-02f, -4.42212187e-02f, -2.17233121e-01f, -2.54426450e-01f, -2.70262092e-01f, -2.72307515e-01f, -4.28609997e-01f, -2.61686802e-01f,
  3.17442864e-02f, -5.85010462e-03f, -1.14628844e-01f, -1.32712334e-01f, 1.22243417e-02f, 7.70791546e-02f, -3.20626348e-02f, -1.79742603e-03f, -2.14661229e-02f, 4.29167412e-02f,
  7.32077733e-02f, -1.61929339e-01f, -4.11641523e-02f, 5.66410795e-02f, -1.04295509e-03f, 4.99874912e-02f, 3.81916598e-03f, -4.43106107e-02f, 7.27917701e-02f, -1.41441645e-02f,
  9.44748968e-02f, 6.34834021e-02f, -2.12700553e-02f, 9.30501707e-03f, -4.98865694e-02f, -8.38124827e-02f, 8.80111381e-03f, -3.78506109e-02f, -8.75704512e-02f, 1.40524786e-02f,
  7.65293837e-02f, -4.65964302e-02f, -8.71359855e-02f, -1.28707699e-02f, -3.00047286e-02f, -1.32641336e-02f, -1.27274856e-01f, -1.64621264e-01f, -1.51430741e-01f, 4.50709946e-02f,
  1.39601883e-02f, 5.62310731e-03f, 4.30394225e-02f, -7.24613806e-03f, 5.08540832e-02f, 4.53499220e-02f, -6.89622387e-02f, -4.58608568e-02f, -1.48290778e-02f, 1.04654282e-01f,
  2.13175919e-02f, 4.91092652e-02f, 6.93306923e-02f, 3.31190554e-03f, -2.62882281e-02f, -1.25304937e-01f, 1.46682709e-02f, -2.14157514e-02f, 2.28706971e-02f, 9.00837108e-02f,
  -9.07169655e-03f, 5.41861691e-02f, 2.75853761e-02f, -1.17262587e-01f, 9.61994603e-02f, 1.63824297e-02f, 2.54133400e-02f, 2.66814269e-02f, -4.47542183e-02f, 3.34107019e-02f,
  2.68819183e-02f, 9.03868750e-02f, 1.97089717e-01f, -3.30112912e-02f, -1.17679564e-02f, 1.21329755e-01f, 1.37174636e-01f, -1.40416855e-02f, 8.95833671e-02f, 6.76033869e-02f,
  1.09858945e-01f, 1.92276657e-01f, 8.36588368e-02f, 1.69701315e-02f, -4.89463005e-03f, 4.35341075e-02f, 6.21150099e-02f, -1.12285949e-01f, -5.96773699e-02f, -3.81918773e-02f,
  6.21733721e-03f, 9.30308923e-02f, 2.60915048e-02f, 5.05132601e-02f, -2.99839415e-02f, 1.15434878e-01f, 5.48383743e-02f, -5.45107666e-03f, -2.29106043e-02f, 6.86638728e-02f,
  -3.96212548e-01f, -2.37047553e-01f, -3.50446068e-02f, -2.09717840e-01f, -3.49479243e-02f, -1.26937076e-01f, -2.49229878e-01f, -2.00501531e-01f, -1.34320885e-01f, -2.82590866e-01f,
  -1.79576680e-01f, -5.85408658e-02f, -1.56441614e-01f, -6.02719970e-02f, -5.76385669e-02f, -2.94144839e-01f, -2.07687020e-01f, -4.31929082e-02f, 1.55908316e-01f, 8.61402005e-02f,
  6.62785629e-03f, -1.10810719e-01f, -2.76997723e-02f, 6.52224123e-02f, -1.87758610e-01f, -4.17850800e-02f, -1.17952958e-01f, 1.85370389e-02f, -5.77611774e-02f, -5.87695390e-02f,
  -2.02589199e-01f, -2.05552831e-01f, 9.26670805e-03f, -7.53352270e-02f, -6.11123592e-02f, -7.12024197e-02f, -2.43662149e-02f, -1.68549299e-01f, 7.18607800e-03f, -8.27067345e-02f,
  -1.56093225e-01f, -3.45491879e-02f, 1.49185201e-02f, -2.99417339e-02f, -3.61182680e-03f, -6.93633361e-03f, -1.40395939e-01f, -1.28839150e-01f, -7.47591704e-02f, -1.13829523e-01f,
  -9.12435055e-02f, -1.40204355e-01f, -9.09653157e-02f, -8.07835087e-02f, -1.62758246e-01f, -1.80765856e-02f, -1.51915029e-01f, -5.14456742e-02f, -3.88379879e-02f, -1.68705940e-01f,
  1.63007841e-01f, 1.18647575e-01f, 8.16194564e-02f, -5.18397614e-02f, -1.00631297e-01f, -6.12049364e-03f, 3.18659432e-02f, 4.03618664e-02f, 1.62765980e-01f, 3.97458151e-02f,
  -2.34572124e-02f, -4.45697047e-02f, -1.84496697e-02f, -9.44457427e-02f, -2.00125240e-02f, -1.00339487e-01f, -1.50456578e-02f, 2.38377042e-03f, -1.79551132e-02f, -5.47644980e-02f,
  -7.17908069e-02f, -6.90104580e-03f, -3.63061428e-02f, 9.54358876e-02f, -7.37206126e-03f, -8.26631486e-02f, -1.05921283e-01f, -3.51083279e-02f, -4.57994379e-02f, 2.68924404e-02f,
  -2.19216779e-01f, 7.12395320e-03f, -2.71259636e-01f, -2.73017883e-01f, -8.61680135e-02f, -1.17321782e-01f, -1.48529738e-01f, -1.53450981e-01f, -1.86371401e-01f, -1.39313176e-01f,
  -9.19814035e-02f, -1.47775590e-01f, -1.50522962e-01f, -2.58383919e-02f, -1.56244962e-02f, -1.96120441e-01f, -2.46459171e-01f, -9.89057347e-02f, -2.94008739e-02f, -1.46589845e-01f,
  -1.99729204e-01f, -8.43611062e-02f, -1.31609827e-01f, -6.44160733e-02f, -2.28885666e-01f, -1.27742425e-01f, -1.48102358e-01f, -1.58514351e-01f, -8.59880671e-02f, -2.35476017e-01f,
  2.48398215e-01f, 6.40365034e-02f, 1.81617975e-01f, 1.35022402e-01f, 4.43882234e-02f, 4.69263317e-03f, 1.59471452e-01f, 8.48666877e-02f, 1.79018006e-02f, 7.74721131e-02f,
  -4.94699404e-02f, -3.12589169e-01f, -2.19941765e-01f, -1.27330748e-02f, 1.08255774e-01f, 1.94745064e-01f, 1.75740629e-01f, 2.02697128e-01f, 5.96043505e-02f, 1.32861793e-01f,
  -7.63425753e-02f, -1.48889929e-01f, -2.84544975e-02f, 2.30880398e-02f, 1.47329748e-01f, -7.62387738e-02f, -6.27869042e-03f, 5.58053851e-02f, 7.05875978e-02f, 2.82615215e-01f,
  -1.12393141e-01f, 1.24612473e-01f, 6.14868961e-02f, -5.34077361e-02f, -1.62418321e-01f, -9.32438746e-02f, 1.22311497e-02f, -1.14716835e-01f, -6.36872426e-02f, 5.41783273e-02f,
  -1.24488018e-01f, -1.59695715e-01f, -1.62576869e-01f, -3.99679169e-02f, 1.25986896e-02f, 6.77074268e-02f, -8.29810128e-02f, 1.75546035e-02f, -5.97990630e-03f, 5.54643646e-02f,
  -4.41202074e-02f, 1.99643113e-02f, -2.93737045e-04f, 1.78777575e-02f, 1.00589208e-01f, -1.38598364e-02f, -6.25444651e-02f, -3.04364022e-02f, -2.19138749e-02f, 1.59170225e-01f,
  9.95174646e-02f, 9.40144807e-03f, -2.37815343e-02f, 4.51121591e-02f, -1.56471476e-01f, -6.11287467e-02f, 5.87479398e-02f, 4.33495641e-02f, 1.54007673e-02f, 2.80855689e-02f,
  -1.35661811e-02f, 9.13449824e-02f, 5.77375218e-02f, -1.44858062e-02f, -4.83948588e-02f, -8.03914890e-02f, -2.56839618e-02f, -4.73861722e-03f, -8.37020576e-02f, -3.24462242e-02f,
  -1.65849611e-01f, -1.02821425e-01f, -1.00760534e-01f, -1.54818788e-01f, -6.05743825e-02f, 6.58367120e-04f, 3.35437967e-03f, -3.72765884e-02f, -1.99197084e-01f, -8.48315507e-02f,
  -2.64263004e-01f, -3.52495834e-02f, 3.55703793e-02f, 1.35251489e-02f, -4.90375794e-02f, -7.60099664e-02f, -7.88284838e-02f, -6.47884682e-02f, -3.61498930e-02f, -4.73516621e-02f,
  6.69200793e-02f, 4.07961123e-02f, -2.14730009e-01f, -2.25863811e-02f, 7.16459453e-02f, -1.02534585e-01f, -1.53040498e-01f, -8.53868574e-02f, -1.24495812e-02f, -2.19100211e-02f,
  6.13951609e-02f, 1.31889433e-01f, -3.81892771e-02f, -8.88089612e-02f, -8.18085894e-02f, -3.94477472e-02f, 1.13489442e-02f, 1.89930834e-02f, -1.25763819e-01f, -9.30726603e-02f,
  1.85557887e-01f, 5.11033297e-01f, -4.30979244e-02f, 1.77420720e-01f, -2.85376608e-02f, -3.26648742e-01f, 5.11056408e-02f, -7.53226178e-03f, 3.93876173e-02f, 2.14887112e-01f,
  2.00838760e-01f, -1.65625155e-01f, 5.98657969e-03f, -2.30538294e-01f, -1.04820102e-01f, 1.36674374e-01f, -6.71105683e-02f, -2.92458504e-01f, -5.15450239e-01f, -1.92045376e-01f,
  1.68641587e-03f, 1.34163871e-01f, -7.38617927e-02f, -5.78207709e-02f, 1.70578003e-01f, -2.44607165e-01f, 1.21174440e-01f, 9.03568491e-02f, 4.52598967e-02f, 3.44362170e-01f,
  2.56227199e-02f, 1.15710281e-01f, -3.73175830e-01f, -6.51866868e-02f, 7.59237632e-02f, 3.78013751e-03f, -5.18100187e-02f, -4.82443199e-02f, 5.18899783e-02f, 1.53765574e-01f,
  -7.22425729e-02f, -3.01473159e-02f, -2.59817652e-02f, 3.36633250e-02f, -1.21592069e-02f, 2.51123006e-03f, -3.87124643e-02f, -9.32479836e-03f, -6.25748634e-02f, 2.38467027e-02f,
  7.94700906e-02f, -2.29469277e-02f, 2.34906040e-02f, -7.54122883e-02f, -5.00109568e-02f, -1.11710817e-01f, -2.63641477e-02f, 3.07773016e-02f, -1.02379262e-01f, 1.27465725e-01f,
  -1.24520240e-02f, -2.66134590e-02f, -1.05070047e-01f, 8.54195133e-02f, -2.48114914e-02f, -5.06206555e-03f, -1.55434217e-02f, 4.73559019e-04f, 2.24584453e-02f, 3.08524650e-02f,
  -2.13547088e-02f, 4.31125201e-02f, 1.31196648e-01f, 9.62190852e-02f, 9.31061152e-03f, 4.17838022e-02f, -6.47988245e-02f, 2.62740403e-02f, 1.68120060e-02f, 1.40617797e-02f,
  1.25178155e-02f, 7.58780092e-02f, -3.20558883e-02f, -5.10324091e-02f, 7.65767545e-02f, -9.67580155e-02f, 3.25253345e-02f, 5.98868937e-04f, 3.37606482e-02f, -8.57367441e-02f,
  -2.05718763e-02f, -1.54664606e-01f, -5.33064303e-04f, 3.50852869e-02f, -1.16180377e-02f, -8.71288851e-02f, 6.62588794e-03f, -2.10437253e-02f, 5.02132997e-02f, 5.34985512e-02f,
  6.57851100e-02f, -8.20316896e-02f, 8.27036873e-02f, 4.75258492e-02f, -2.36230399e-02f, -7.15130419e-02f, 9.17385295e-02f, -1.42967124e-02f, 2.94971745e-02f, 6.58399761e-02f,
  4.65887077e-02f, -5.59661090e-02f, -1.49139270e-01f, -1.02755226e-01f, -1.07052453e-01f, -2.61775106e-01f, -1.94184229e-01f, -1.67987436e-01f, -3.09767365e-01f, 3.68980169e-02f,
  -2.24117294e-01f, 9.44845676e-02f, -1.28327295e-01f, -2.71857709e-01f, -2.76519150e-01f, -1.71586469e-01f, 8.40567145e-03f, 5.90706170e-02f, -1.06329150e-01f, 9.19122398e-02f,
  2.13101730e-01f, 1.95326671e-01f, 2.86313314e-02f, 4.19175550e-02f, -4.28625662e-03f, -1.22997813e-01f, -3.47522765e-01f, -2.01692387e-01f, -4.11831066e-02f, 1.21488109e-01f,
  -6.77695964e-03f, -1.92112595e-01f, -1.69560656e-01f, 2.08219588e-02f, -1.57192037e-01f, 9.33340937e-02f, -1.38873726e-01f, -1.65945798e-01f, -5.44455601e-03f, -1.86995700e-01f,
  3.05344284e-01f, 1.39844388e-01f, 1.36371717e-01f, 8.07418600e-02f, 7.66384602e-02f, 5.10569997e-02f, -7.23364726e-02f, -1.28878523e-02f, 1.39317855e-01f, -9.69382841e-03f,
  9.30895098e-03f, 7.25119784e-02f, 4.80216481e-02f, -5.78663833e-02f, -8.49978924e-02f, -8.61442927e-03f, 2.01812238e-02f, -2.94149593e-02f, 3.20430137e-02f, 6.49779066e-02f,
  7.78085887e-02f, -1.69784501e-02f, 7.83149526e-02f, 4.16069627e-02f, 7.65634477e-02f, -1.09345168e-02f, 2.21761148e-02f, -2.79899798e-02f, 1.39966011e-01f, 3.07725742e-02f,
  3.02113779e-02f, 3.95270623e-02f, -5.22560142e-02f, -1.23870566e-01f, 4.41771820e-02f, 2.93550491e-02f, -5.51287271e-02f, -5.43767810e-02f, -5.87924235e-02f, -3.75297889e-02f,
  -1.41009107e-01f, 6.60567582e-02f, 5.70555627e-02f, -6.84268028e-02f, -7.22496957e-02f, -8.53618160e-02f, -3.45747522e-03f, 9.78228971e-02f, 5.68719022e-02f, -6.50761127e-02f,
  6.29025549e-02f, -7.24148601e-02f, -2.85461098e-02f, -1.01574566e-02f, -1.10061541e-01f, -1.66394226e-02f, 4.18592803e-02f, -5.24984933e-02f, -1.20178405e-02f, -5.97184487e-02f,
  2.46454626e-01f, 9.03183892e-02f, -2.57563740e-02f, 5.30899987e-02f, 1.87019072e-02f, 1.02480911e-01f, 5.06291315e-02f, -1.32005170e-01f, -7.43078664e-02f, 3.98860574e-02f,
  5.78993037e-02f, 9.50307678e-03f, -4.60426323e-02f, 8.86258930e-02f, -3.14693078e-02f, 2.21869582e-03f, 3.71524766e-02f, 2.65407544e-02f, 1.09352723e-01f, 9.50662121e-02f,
  -4.40435112e-02f, -7.51758888e-02f, 9.24972519e-02f, -1.15921358e-02f, 3.69768515e-02f, 4.33494672e-02f, 4.10309210e-02f, -7.20063448e-02f, 1.52574718e-01f, 4.74996306e-02f,
  3.50063927e-02f, -8.75504911e-02f, -9.64396596e-02f, 1.85446292e-01f, 1.09271273e-01f, -2.67779231e-01f, -2.64165550e-01f, -2.31974393e-01f, 5.06711453e-02f, 1.11552544e-01f,
  -3.68201993e-02f, 3.08518726e-02f, 8.38790238e-02f, 8.61268211e-03f, -2.55643398e-01f, 9.53379199e-02f, 2.75686800e-01f, 1.17769219e-01f, -1.16784967e-01f, -1.51838332e-01f,
  1.13502160e-01f, 1.39728948e-01f, -5.90625219e-02f, -8.62349719e-02f, 1.15034379e-01f, 1.48029670e-01f, -1.30446572e-02f, -1.11490354e-01f, -3.56841385e-02f, 3.90959859e-01f,
  -8.25329311e-03f, -2.46325955e-01f, 1.30257338e-01f, 4.85552326e-02f, -5.65086640e-02f, -4.31382060e-02f, -2.27606054e-02f, -1.13874353e-01f, -6.43338859e-02f, -1.70406535e-01f,
  -9.14810672e-02f, -8.75095874e-02f, -6.46493807e-02f, -5.22685610e-02f, -4.74802181e-02f, -3.15038748e-02f, -1.25170678e-01f, -1.51353195e-01f, -3.66539694e-02f, -9.72293988e-02f,
  -6.07042722e-02f, -1.75043970e-01f, -1.50071323e-01f, -1.84597224e-01f, -2.06381798e-01f, -4.57405411e-02f, -1.69871733e-01f, -1.64441004e-01f, -2.30005652e-01f, -8.70633051e-02f,
  4.75999787e-02f, -5.00358269e-02f, 4.68785167e-02f, -6.19004807e-03f, 8.26222301e-02f, 5.04987910e-02f, 7.34275654e-02f, 1.05632255e-02f, 6.51606396e-02f, -6.55158609e-03f,
  1.86069068e-02f, -4.61360142e-02f, 2.14141775e-02f, -1.57314520e-02f, 7.82583356e-02f, 6.34282653e-04f, -8.98298919e-02f, 3.82209383e-02f, -1.07379295e-01f, 1.44276256e-02f,
  2.30122562e-02f, 5.38187014e-05f, 8.39644298e-02f, 3.39612588e-02f, -7.92175308e-02f, -2.37948950e-02f, 1.28450453e-01f, -8.92776623e-02f, -3.60568464e-02f, -4.52083834e-02f,
  2.25965023e-01f, -2.65239745e-01f, 1.83849975e-01f, -6.03893511e-02f, -8.67069140e-02f, -1.11393467e-01f, 8.60556290e-02f, -7.82928243e-02f, 5.15848920e-02f, -1.24625666e-02f,
  -1.16433918e-01f, -1.29243031e-01f, -6.10136427e-02f, 2.51566470e-02f, 4.75540273e-02f, -5.40803559e-02f, -8.61881524e-02f, -1.17207295e-03f, -3.85386907e-02f, -9.08763632e-02f,
  -6.51793331e-02f, -1.69190727e-02f, 1.10208057e-01f, -1.37488134e-02f, 4.28718925e-02f, 1.66858971e-01f, 3.10656335e-02f, -3.19595598e-02f, -8.61332044e-02f, 2.24971399e-01f,
  2.57398218e-01f, 3.23487110e-02f, -1.09373227e-01f, -1.51339294e-02f, 4.79328595e-02f, -1.38354627e-02f, 2.12048501e-01f, 1.40646368e-01f, -2.36993935e-03f, 9.98930782e-02f,
  -5.15318401e-02f, -8.18319991e-02f, -1.36058956e-01f, -1.10583417e-01f, -1.85227327e-04f, 1.64875597e-01f, -3.28993686e-02f, -1.25450850e-01f, 7.10518807e-02f, 3.76265310e-02f,
  8.20810795e-02f, 9.80656669e-02f, -3.72667722e-02f, 9.48792789e-03f, -7.73457065e-02f, 9.92791951e-02f, -8.27778131e-02f, -3.18575613e-02f, -1.31549552e-01f, -1.54267922e-01f,
  -1.15725420e-01f, -1.65482596e-01f, 1.06893420e-01f, 6.33002892e-02f, -6.84388280e-02f, -2.09013466e-03f, 7.71606416e-02f, -4.69634905e-02f, 6.94608465e-02f, 4.94099036e-02f,
  -7.97027126e-02f, 5.41901737e-02f, -1.19992860e-01f, 1.23189781e-02f, 2.82793008e-02f, 3.79156396e-02f, -4.69531119e-02f, -8.35420266e-02f, 5.42043447e-02f, 6.64803525e-03f,
  3.28787640e-02f, -1.13611735e-01f, -1.23723876e-02f, -2.44198143e-02f, 2.34068222e-02f, -4.23040912e-02f, -5.41007482e-02f, -5.06510362e-02f, 6.70305043e-02f, 1.45181730e-01f,
  1.83441401e-01f, -7.14347884e-02f, -9.77936760e-02f, 5.03136665e-02f, 6.06757924e-02f, -3.99156399e-02f, 2.06181966e-02f, 4.52332310e-02f, -1.15905199e-02f, 6.12036213e-02f,
  -4.15805802e-02f, 1.06954150e-01f, 7.91811049e-02f, 6.74244836e-02f, -1.40914018e-03f, -1.18523017e-01f, 6.05957322e-02f, 9.44653228e-02f, -3.55290063e-02f, 1.11999298e-02f,
  -3.42008434e-02f, -1.34882927e-01f, -5.24067543e-02f, 2.19516782e-03f, -8.98607969e-02f, -1.33597493e-01f, -5.25852107e-02f, 1.00516593e-02f, 2.27162596e-02f, 9.30284336e-03f,
  2.83059806e-01f, -1.58435509e-01f, 4.85624857e-02f, 8.87627825e-02f, 3.77755016e-02f, 3.42472717e-02f, -3.96329165e-02f, 4.86198775e-02f, 8.92957225e-02f, 8.89578611e-02f,
  2.84716077e-02f, 6.18390441e-02f, 3.51531580e-02f, -1.78601444e-02f, 1.71165660e-01f, 6.53962344e-02f, 1.09082535e-01f, 1.30668595e-01f, 3.68903540e-02f, -3.40715125e-02f,
  1.93405584e-01f, 2.32928708e-01f, 1.44620836e-01f, 1.67614102e-01f, 8.91225636e-02f, 2.56555855e-01f, 1.42093793e-01f, 2.33653694e-01f, 2.12932989e-01f, 5.26637197e-01f,
  2.52133667e-01f, 1.70864075e-01f, 7.15860873e-02f, -1.22401202e-02f, 9.54971015e-02f, 2.55601227e-01f, 4.40303594e-01f, 1.97047725e-01f, -7.87372887e-02f, 1.07740477e-01f,
  3.11248768e-02f, -1.83689997e-01f, -1.98913261e-01f, -6.91074058e-02f, 2.03513447e-02f, 1.37965888e-01f, 5.97343668e-02f, 1.95643511e-02f, -1.14534840e-01f, -4.07962799e-02f,
  -1.86571404e-01f, -9.95328054e-02f, -8.17488006e-04f, -1.87363699e-01f, -2.14395359e-01f, -1.84147403e-01f, -8.87750555e-03f, 1.34885553e-02f, -6.54674023e-02f, -2.38246918e-01f,
  -1.92155724e-03f, 5.35627864e-02f, -1.41728193e-01f, 7.01919869e-02f, 1.19176414e-02f, 4.83377054e-02f, 5.31828254e-02f, -5.49492911e-02f, 5.62746041e-02f, -2.39120182e-02f,
  3.60264666e-02f, -5.71251176e-02f, 6.49379939e-02f, 5.08342981e-02f, 4.74095903e-02f, -2.66766152e-03f, 5.08913845e-02f, -3.94622087e-02f, -6.78839162e-02f, 7.04849660e-02f,
  -1.05346441e-02f, 7.28137121e-02f, 1.94563553e-01f, 8.30442533e-02f, 6.36161789e-02f, -8.43665674e-02f, -1.09101295e-01f, -1.91091541e-02f, 5.72160408e-02f, -6.21783920e-02f,
  -1.66674275e-02f, 3.86505723e-02f, 4.20063287e-02f, -1.31664217e-01f, -3.06457207e-02f, -8.02829936e-02f, -1.22483373e-01f, -2.23281998e-02f, 6.79088151e-03f, 1.30728260e-02f,
  -7.92612359e-02f, -4.76141274e-02f, -1.13035832e-03f, -8.56086910e-02f, -6.08385652e-02f, 3.81547003e-03f, 1.17412210e-01f, -4.54548597e-02f, -8.57431069e-02f, 2.72241887e-02f,
  -1.08424455e-01f, -7.24109039e-02f, 1.36982556e-02f, 1.66291762e-02f, -8.80098045e-02f, -7.79425167e-03f, -8.05959478e-02f, -1.22211380e-02f, -8.40336084e-02f, 6.68377578e-02f,
  7.47936890e-02f, 4.56393436e-02f, -1.12470603e-02f, 2.92011071e-02f, -4.51082774e-02f, -4.51581329e-02f, -2.25865673e-02f, 3.88199720e-03f, -1.06361294e-02f, 3.89566720e-02f,
  1.72924191e-01f, -3.54946107e-02f, -7.03127915e-03f, 6.36552498e-02f, 2.93130763e-02f, 1.05128109e-01f, 3.32260355e-02f, -5.96050099e-02f, -8.62050503e-02f, -1.57049987e-02f,
  -6.79814890e-02f, 1.14236481e-01f, 1.59689054e-01f, 1.87283009e-01f, 3.00378762e-02f, 4.30929512e-02f, 2.30763294e-02f, 8.87800753e-02f, 1.16597801e-01f, 2.52780974e-01f,
  3.42850864e-01f, -2.13804081e-01f, 1.63705319e-01f, -4.43600863e-02f, -4.40159254e-02f, 1.18153758e-01f, 1.57408282e-01f, 4.06851396e-02f, -1.16747327e-01f, -1.72357276e-01f,
  -2.05211520e-01f, -2.97136366e-01f, -1.53108686e-01f, -1.09421253e-01f, 2.11527139e-01f, 1.75030306e-01f, 4.10141349e-02f, 8.26610178e-02f, 1.94499746e-01f, 2.00815424e-02f,
  -1.26953557e-01f, 5.02195917e-02f, 6.05392270e-02f, 1.56708919e-02f, -1.10787675e-01f, -7.50471950e-02f, 6.34073913e-02f, -5.75008728e-02f, -6.22083712e-03f, -1.21561989e-01f,
  1.81656137e-01f, 1.18570752e-01f, 1.61927212e-02f, -9.55506340e-02f, -5.03170937e-02f, -4.89858154e-04f, 7.43642896e-02f, -6.32796064e-02f, -1.09772913e-01f, -9.75629091e-02f,
  -1.20749027e-01f, 2.13087580e-04f, -5.20670153e-02f, -8.97024423e-02f, 2.47562937e-02f, -7.23904818e-02f, -6.04349859e-02f, 5.32524809e-02f, 3.16437073e-02f, -9.93451551e-02f,
  -1.75295666e-01f, -1.23359285e-01f, 9.80298966e-03f, -3.88362817e-02f, -1.89965349e-02f, 5.25722839e-02f, -8.14648122e-02f, 2.64822617e-02f, -1.64268669e-02f, -1.07444219e-01f,
  -6.75900355e-02f, 6.13853335e-02f, 7.57890195e-03f, 3.22856680e-02f, 2.43679266e-02f, 3.49234305e-02f, 1.47844581e-02f, -7.81678930e-02f, 5.63883819e-02f, -4.65404615e-03f,
  -5.08825621e-03f, 9.49067697e-02f, -8.82522985e-02f, 2.66602654e-02f, 7.03768656e-02f, -1.04466937e-01f, 8.28872323e-02f, 4.49723862e-02f, -8.61446932e-02f, -4.19984125e-02f,
  1.13130664e-03f, -1.20378481e-02f, 8.24391395e-02f, -2.95992680e-02f, 1.45310545e-02f, 2.08631158e-02f, 4.74587157e-02f, 8.18560086e-03f, -5.63080981e-02f, 3.91871743e-02f,
  -1.30046278e-01f, 1.35891423e-01f, 1.68936044e-01f, 1.57686561e-01f, -5.38798273e-02f, -6.03158362e-02f, 8.02333206e-02f, 6.00976907e-02f, 5.65889776e-02f, 7.16605708e-02f,
  3.66065092e-02f, 4.96072695e-02f, -1.97576825e-03f, 6.68839901e-04f, 4.08487692e-02f, -1.89773217e-02f, -1.08908892e-01f, 3.86215523e-02f, -6.57808315e-03f, -6.64037094e-02f,
  -7.05778375e-02f, -2.29159500e-02f, 1.12430580e-01f, 1.40358314e-01f, 8.73136446e-02f, 1.32168591e-01f, 5.46675175e-02f, 1.34000760e-02f, 1.72248870e-01f, 1.46690365e-02f,
  6.30075932e-01f, -2.64453351e-01f, 2.05944508e-01f, -3.86270657e-02f, -2.87700295e-01f, -1.39198110e-01f, -3.09484750e-01f, 5.18931299e-02f, -3.58084105e-02f, -1.02045566e-01f,
  -1.10862017e-01f, -5.52788079e-02f, 1.06033161e-01f, 5.57269827e-02f, 2.07007840e-01f, -8.44280943e-02f, -4.74779755e-02f, 2.64123261e-01f, 2.48604119e-01f, 1.00331074e-02f,
  -1.07572943e-01f, 6.58611059e-02f, 2.20656186e-01f, 2.17497230e-01f, 2.28655222e-03f, -1.60410665e-02f, -1.16308205e-01f, 4.80853058e-02f, -1.23497033e-02f, 1.03548879e-03f,
  1.92606702e-01f, 1.02012545e-01f, -4.25542099e-03f, -6.81885844e-03f, 7.47821629e-02f, 4.71089631e-02f, 1.15843136e-02f, 1.54308975e-01f, 6.59479648e-02f, 1.72595978e-01f,
  1.72033533e-02f, 1.89142907e-03f, 1.11417249e-01f, 5.25218286e-02f, 1.17703713e-01f, 7.19962344e-02f, -2.80156396e-02f, 2.39137322e-01f, 8.05616304e-02f, -9.55976825e-03f,
  -1.35573968e-01f, -5.22474432e-03f, 1.38233975e-01f, 6.49672281e-03f, 1.06796525e-01f, 1.06853090e-01f, 8.29347745e-02f, 6.25295341e-02f, 9.82323959e-02f, 2.43495852e-02f,
  -1.89396814e-02f, -8.71218799e-05f, -3.15868668e-02f, -3.59978457e-03f, 2.52154074e-03f, -2.55970769e-02f, 3.40023339e-02f, -1.00805193e-01f, 5.18116467e-02f, 8.27018917e-03f,
  -6.19038194e-02f, -5.06478027e-02f, -2.06827130e-02f, -1.76878204e-03f, -1.05491146e-01f, 8.69605988e-02f, 2.40117740e-02f, -5.29632829e-02f, 4.42837738e-02f, 8.42987075e-02f,
  -2.32263524e-02f, 1.99175850e-02f, -1.82863370e-01f, -4.08282094e-02f, 8.68162699e-03f, -2.35904921e-02f, 1.30025614e-02f, -2.15771738e-02f, -6.02224879e-02f, 3.12251206e-02f,
  -6.32128492e-02f, 6.32928386e-02f, 1.66561171e-01f, 3.44963335e-02f, 1.28331315e-02f, 2.54185703e-02f, 9.68326256e-02f, 8.26492682e-02f, 8.79080072e-02f, 5.55487387e-02f,
  1.45766269e-02f, 8.02941471e-02f, -5.58909681e-03f, 7.43899122e-02f, 7.14097917e-02f, 4.97484021e-02f, -9.41421166e-02f, 2.00304743e-02f, 7.42327943e-02f, 5.91008700e-02f,
  -9.38352868e-02f, -4.26939279e-02f, 3.39369327e-02f, 7.86955282e-03f, 1.06303304e-01f, -4.34226729e-02f, 9.59526747e-02f, 4.91136797e-02f, -1.77422240e-02f, -4.90295850e-02f,
  1.52094230e-01f, 6.69037104e-02f, 4.28377278e-02f, 8.13424662e-02f, 2.25872193e-02f, -1.10607378e-01f, -1.16886087e-02f, -3.03434059e-02f, -4.13197614e-02f, -6.49950206e-02f,
  1.48940030e-02f, 5.99902123e-02f, 8.62766244e-03f, 3.74599844e-02f, -6.29418045e-02f, 4.09913994e-02f, 2.19465211e-01f, 1.36285320e-01f, 8.61437060e-03f, -7.59217888e-02f,
  -9.07837152e-02f, 3.36874160e-03f, 3.51881832e-02f, -1.61563810e-02f, 1.48071989e-01f, 3.87430489e-02f, -4.64500636e-02f, 2.36621425e-02f, -1.30790481e-02f, 3.20781767e-01f,
  2.68439591e-01f, 5.39987907e-02f, 5.41150495e-02f, 1.17859095e-01f, 3.01608117e-03f, -9.37220976e-02f, -5.79214804e-02f, -4.42834273e-02f, -1.11090183e-01f, 2.22196765e-02f,
  1.38564259e-02f, 3.76586197e-03f, 1.25034884e-01f, -3.98151949e-02f, 2.62374450e-02f, -9.41877142e-02f, 4.40965369e-02f, -1.05611086e-01f, -7.91749135e-02f, -4.50198837e-02f,
  5.81712909e-02f, 5.11147901e-02f, 9.68973786e-02f, 2.31211279e-02f, 3.84636112e-02f, -1.55741461e-02f, 6.28214777e-02f, 6.84799328e-02f, -2.61335354e-02f, 1.83876023e-01f,
  1.29807154e-02f, 8.79542604e-02f, -4.06277403e-02f, -4.76228744e-02f, 3.74651491e-03f, -2.86722295e-02f, 6.48823231e-02f, 5.77945635e-02f, 9.11103934e-03f, -9.21883993e-03f,
  2.79876571e-02f, 3.91907096e-02f, 7.70878093e-03f, -3.33506949e-02f, -1.28908996e-02f, 4.90900651e-02f, -7.46331736e-02f, -5.69128431e-02f, -1.94978956e-02f, 4.37549613e-02f,
  7.74062946e-02f, 5.06871240e-03f, -6.77411864e-03f, 4.24934216e-02f, 1.16099700e-01f, 1.41557440e-01f, 1.57134347e-02f, -2.21735667e-02f, 7.35536516e-02f, -3.21625695e-02f,
  -1.55741781e-01f, -7.61120021e-02f, 1.01660630e-02f, 5.19685633e-02f, -1.65881682e-02f, -1.36696115e-01f, -1.22055550e-04f, -1.64528385e-01f, 1.02065774e-02f, -2.59260274e-02f,
  1.86780766e-02f, -7.61786802e-03f, -9.95634571e-02f, -2.17828061e-02f, -3.17279436e-02f, -1.01428516e-01f, -1.28797609e-02f, -1.37382569e-02f, -1.04130179e-01f, -6.71510100e-02f,
  -6.56421557e-02f, -1.66620582e-01f, -1.14428096e-01f, -6.91802502e-02f, -4.32581687e-03f, 1.63711607e-02f, -1.41397998e-01f, 1.61429297e-03f, -1.33413479e-01f, -1.23542525e-01f,
  -5.31663120e-01f, 5.66712841e-02f, -2.13565543e-01f, -2.32871976e-02f, 1.41917393e-01f, 2.24568188e-01f, 2.99543977e-01f, 1.30940437e-01f, 1.36327505e-01f, 2.98893079e-02f,
  3.46062556e-02f, 1.11729190e-01f, 3.51863392e-02f, -2.51191333e-02f, -1.06046461e-01f, -1.26847224e-02f, -9.68118683e-02f, -1.72563210e-01f, 1.65745411e-02f, 1.50293455e-01f,
  2.08870023e-01f, -2.04912592e-02f, -1.89616829e-01f, 5.75974286e-02f, 8.04486722e-02f, 9.32203680e-02f, -8.48258361e-02f, -8.37278366e-02f, 1.76709458e-01f, -1.41381174e-01f,
  -3.06206316e-01f, 3.91407404e-03f, 1.32391453e-01f, 4.07671109e-02f, 7.73621351e-03f, 3.36320996e-02f, 4.85862158e-02f, -6.63197339e-02f, 1.62383206e-02f, 9.60930139e-02f,
  -1.46917254e-02f, 3.46871130e-02f, 3.75756919e-02f, 1.36532173e-01f, 9.14270654e-02f, -1.63852908e-02f, 7.61751011e-02f, -3.20460903e-03f, 3.53982411e-02f, 9.84198451e-02f,
  1.32601395e-01f, 1.69317514e-01f, -6.12731688e-02f, 1.36146739e-01f, 3.72806713e-02f, -4.03365167e-03f, -4.05792929e-02f, 1.14138260e-01f, 5.63609041e-02f, 2.69103199e-02f,
  1.65022090e-01f, -6.20261161e-03f, 4.90663424e-02f, 6.55451193e-02f, 5.55280633e-02f, -1.59708466e-02f, 3.20868625e-04f, 7.48473555e-02f, 5.70568256e-02f, 9.87724364e-02f,
  9.32111219e-02f, -9.85284075e-02f, 1.70022577e-01f, 6.04186989e-02f, 1.38103813e-02f, 4.18667123e-03f, 1.95619762e-02f, 5.17237037e-02f, -4.54244204e-03f, 3.03346105e-03f,
  1.56518780e-02f, 1.04076341e-02f, 3.66508812e-02f, -2.04931460e-02f, 3.22817750e-02f, -8.81359950e-02f, -3.49232964e-02f, 5.72061017e-02f, -3.08613256e-02f, -6.33903891e-02f,
  1.36157230e-01f, 4.12798077e-02f, 4.12337705e-02f, 8.72100890e-02f, 9.25115794e-02f, 2.79432572e-02f, 1.28805056e-01f, 8.05702247e-03f, 4.89264540e-03f, -1.71476174e-02f,
  7.84254223e-02f, -1.02203563e-01f, -4.00977656e-02f, -4.88757044e-02f, 1.62426513e-02f, 4.45378721e-02f, -2.28759553e-02f, 8.50213096e-02f, 7.68796653e-02f, 9.82513651e-02f,
  1.13165736e-01f, 1.14195906e-01f, 4.54290323e-02f, 3.36917825e-02f, 1.54138938e-01f, -8.58895853e-03f, -6.33805916e-02f, 9.92165357e-02f, -8.97528082e-02f, 1.04725607e-01f,
  -4.24541920e-01f, 3.49016413e-02f, 3.22068743e-02f, -5.59528172e-01f, -1.79717869e-01f, -5.45816347e-02f, -6.01282567e-02f, -8.32600296e-02f, -3.06656033e-01f, -2.27636531e-01f,
  6.96974099e-02f, 2.74927560e-02f, -9.47743133e-02f, 1.14783794e-01f, 1.68265745e-01f, 3.08551583e-02f, -1.47584781e-01f, -3.41206454e-02f, 4.29627560e-02f, 4.42970917e-02f,
  -1.77780688e-01f, -1.54883742e-01f, -1.66475400e-01f, -4.29101326e-02f, -6.02177233e-02f, -1.83404852e-02f, -1.11460917e-01f, -1.42856404e-01f, -2.78594252e-03f, -8.09299797e-02f,
  1.74634323e-01f, 1.33004934e-01f, 5.74346781e-02f, -9.72023830e-02f, 4.64862101e-02f, 8.62580463e-02f, -8.17509275e-03f, -1.60405096e-02f, 4.02038805e-02f, -2.98751816e-02f,
  3.28704454e-02f, -1.46428766e-02f, -9.11618397e-02f, 2.80984100e-02f, -1.31342718e-02f, -4.51017544e-03f, -7.38730729e-02f, 7.40198269e-02f, 2.00422946e-02f, 1.31120961e-02f,
  4.70610559e-02f, 3.87330689e-02f, 4.81596626e-02f, 9.68902558e-02f, 7.72215575e-02f, -2.17627585e-02f, 2.18523666e-02f, 1.02936901e-01f, 8.50947872e-02f, 7.30219260e-02f,
  -8.09950829e-02f, 1.76886339e-02f, 9.54900682e-02f, -3.76414252e-03f, -1.52466580e-01f, 2.15582624e-02f, 9.64539498e-02f, -2.35000458e-02f, -6.99830428e-02f, -7.28403106e-02f,
  -5.80412410e-02f, -9.20139924e-02f, -6.04172908e-02f, 9.07143764e-03f, -8.53914320e-02f, 1.71264652e-02f, 6.34852201e-02f, -1.54583067e-01f, -5.46118133e-02f, -1.53101102e-01f,
  -2.14019150e-01f, -1.51624233e-01f, -4.76937816e-02f, 2.45809089e-03f, -1.01351842e-01f, -1.05222389e-01f, -8.79725162e-03f, -1.51664410e-02f, 3.16652507e-02f, -5.26640229e-02f,
  -1.06794633e-01f, 1.28609076e-01f, -1.31008387e-01f, 3.40542160e-02f, -2.12422162e-02f, -6.46495447e-02f, -1.08357377e-01f, 5.02272602e-03f, 7.03696385e-02f, 3.32958363e-02f,
  5.17219342e-02f, 4.21429463e-02f, 3.47536318e-02f, -7.12233689e-03f, -1.19515687e-01f, -1.92476511e-02f, -5.66627756e-02f, -4.12356220e-02f, -1.51277808e-02f, 4.36082780e-02f,
  2.12742146e-02f, 2.75332225e-03f, -3.90185160e-03f, -7.18037784e-02f, -1.37337362e-02f, -6.74114078e-02f, 1.49675205e-01f, 9.88386869e-02f, 1.25381872e-01f, -6.11454472e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.93202156e-01f, -3.19494963e-01f, -5.26689887e-01f, -1.81951746e-02f, -3.14880818e-01f, -1.78351492e-01f, -2.44778663e-01f, 1.41899273e-01f, 7.54466355e-02f, -3.43113810e-01f,
  -1.39404178e-01f, 2.45189488e-01f, 5.06893778e-03f, 3.95407006e-02f, 1.23287968e-01f, -3.39210063e-01f, -2.79860586e-01f, -2.93376055e-02f, 1.17302433e-01f, 3.10193785e-02f,
  4.37341370e-02f, 4.91430126e-02f, 1.26615718e-01f, 7.57718682e-02f, -1.23385414e-01f, 2.62312293e-02f, -2.65527099e-01f, -9.95662734e-02f, -8.95426497e-02f, -3.27926993e-01f,
  -2.78169394e-01f, -1.22181579e-01f, -6.68292940e-02f, 1.40338242e-01f, 2.37648282e-02f, 1.57375321e-01f, 4.00922932e-02f, 3.78895439e-02f, 6.17098622e-02f, -8.86020064e-03f,
  -3.07304636e-02f, 3.44201773e-02f, 1.92573100e-01f, -6.19042702e-02f, -8.65294188e-02f, -5.97866066e-02f, -4.58529219e-02f, 3.54908071e-02f, 4.73399609e-02f, -6.87377527e-02f,
  2.96989046e-02f, 6.45970330e-02f, 2.22608186e-02f, -7.64601380e-02f, 1.68777499e-02f, -1.07396193e-01f, -1.19723313e-01f, 6.01523258e-02f, 1.21398196e-02f, -2.12927714e-01f,
  -4.99233417e-02f, -2.99071963e-03f, 5.60401641e-02f, 3.10037322e-02f, 1.55808419e-01f, 2.79561691e-02f, 1.29900262e-01f, 7.73468763e-02f, 3.25641595e-02f, -4.26347973e-03f,
  -9.50939022e-03f, 6.51765009e-03f, 9.39797983e-02f, 2.83946581e-02f, -1.29436487e-02f, 7.20083565e-02f, 6.45680651e-02f, -4.16389331e-02f, 4.41879313e-03f, -5.29434830e-02f,
  6.50457144e-02f, 1.19475611e-02f, -1.24973999e-02f, 1.16709046e-01f, -9.57277864e-02f, -7.73031414e-02f, -1.19545914e-01f, 8.12561065e-02f, 5.93993366e-02f, -7.36834705e-02f,
  -8.52299780e-02f, -2.78443694e-02f, -1.94812771e-02f, 2.85945158e-03f, -6.97307959e-02f, -3.23203504e-02f, 4.57735825e-03f, 5.36677577e-02f, 1.13547437e-01f, -3.66278775e-02f,
  -6.58411831e-02f, -1.49243958e-02f, -7.16775050e-03f, -3.80018838e-02f, -3.55939157e-02f, -6.75287619e-02f, -7.98127875e-02f, -8.00850987e-03f, 3.21668275e-02f, -6.23058341e-02f,
  -6.84414012e-03f, 1.31086037e-01f, 8.65535885e-02f, 1.75000331e-03f, 6.28916621e-02f, 9.70717818e-02f, -7.36960843e-02f, 7.55228277e-04f, 8.37153643e-02f, -9.45500284e-02f,
  -4.56577688e-01f, 3.81131023e-02f, 4.72822040e-02f, -1.11413717e-01f, 9.15687457e-02f, 7.69286752e-02f, -2.34327137e-01f, 6.60570432e-03f, 4.96219331e-03f, -2.47383565e-01f,
  1.83831472e-02f, 4.88254009e-03f, -1.54058710e-01f, -1.47756472e-01f, -2.49904051e-01f, -3.36484820e-01f, -4.26488340e-01f, -2.56996214e-01f, -5.61814234e-02f, 2.80049816e-02f,
  -1.10129736e-01f, -2.04858348e-01f, -7.14948475e-02f, 1.06434725e-01f, 1.35296419e-01f, 1.77433610e-01f, 7.46728554e-02f, 1.26443636e-02f, 1.04795799e-01f, 3.10122129e-02f,
  -6.30879998e-02f, 1.37874976e-01f, 1.29268140e-01f, -7.58443996e-02f, 9.06236768e-02f, 1.27939805e-01f, 9.30986181e-02f, -2.28658821e-02f, 9.16807204e-02f, -1.75869972e-01f,
  6.62576333e-02f, 6.10086769e-02f, -4.46073338e-02f, -2.72306055e-02f, 4.69757169e-02f, -1.00793771e-01f, -9.54080522e-02f, -8.42212439e-02f, -3.63910235e-02f, 9.83382538e-02f,
  -9.75660011e-02f, 2.86209378e-02f, -2.80398373e-02f, 1.36547074e-01f, 1.21567219e-01f, -5.43884337e-02f, 2.20411584e-01f, 1.77526861e-01f, 1.79778948e-01f, 6.26227111e-02f,
  1.38382375e-01f, 4.41875029e-03f, 1.34059889e-02f, -2.71763504e-02f, -1.35756686e-01f, 1.10567369e-01f, 6.32343218e-02f, -3.69342044e-02f, -5.34011424e-02f, -1.02095172e-01f,
  4.65980396e-02f, 1.77712124e-02f, -8.65630880e-02f, 8.54425132e-02f, 6.50237948e-02f, -6.08008765e-02f, 1.95739269e-02f, 4.57423106e-02f, -1.30775794e-01f, 3.67447101e-02f,
  2.75832992e-02f, 3.55049707e-02f, -4.47415039e-02f, -2.63207313e-02f, 7.05387518e-02f, -1.07585579e-01f, -9.69789270e-03f, 1.32992566e-01f, -6.50620982e-02f, -5.54044172e-02f,
  -2.15545580e-01f, 1.45190228e-02f, -4.07273434e-02f, -1.38248920e-01f, -6.72501475e-02f, 1.46389484e-01f, 7.19870925e-02f, -4.39168811e-02f, -4.53476422e-02f, -2.24461555e-02f,
  9.89464074e-02f, -9.35759842e-02f, -3.39974053e-02f, -6.20048419e-02f, -1.73912514e-02f, 6.09626099e-02f, -1.17076665e-01f, -2.88397893e-02f, 2.93719787e-02f, 2.60066893e-02f,
  -1.13903590e-01f, -1.05348036e-01f, -2.83534139e-01f, -1.36713177e-01f, 1.18835960e-02f, -1.39214844e-01f, -5.08186184e-02f, 7.16225505e-02f, 1.08328303e-02f, -1.69117138e-01f,
  -7.39715993e-01f, 1.00895360e-01f, -1.67104676e-01f, -3.40791315e-01f, 1.26473993e-01f, 3.52075398e-01f, 4.86514777e-01f, 1.13350384e-01f, -4.33048867e-02f, 5.45247607e-02f,
  -2.10903864e-03f, -1.85544014e-01f, -7.93072805e-02f, 1.11901119e-01f, 2.24860385e-01f, 3.53192478e-01f, 2.97887176e-01f, -8.29477608e-02f, -1.23506226e-01f, 1.35741740e-01f,
  2.36072972e-01f, -2.56260216e-01f, -4.18852359e-01f, -9.87859368e-02f, -4.58985530e-02f, -2.01791063e-01f, -5.09742945e-02f, -1.38123497e-01f, 3.10252439e-02f, 1.05833754e-01f,
  -2.72893518e-01f, -1.33930981e-01f, 2.61457324e-01f, -1.72572643e-01f, -1.12045310e-01f, -1.20130487e-01f, -4.98520359e-02f, -1.86028704e-01f, -3.49767543e-02f, -9.48103666e-02f,
  -7.66174570e-02f, 1.96983349e-02f, -3.55931148e-02f, 4.29643467e-02f, -5.70098199e-02f, -4.12368998e-02f, -1.08986609e-02f, -2.35968418e-02f, 8.45368505e-02f, -8.60998183e-02f,
  2.48449117e-01f, 2.05034800e-02f, -7.26099405e-03f, 1.15325876e-01f, 1.52773321e-01f, -1.54598981e-01f, -5.11551537e-02f, 5.14983432e-03f, -6.57046121e-03f, -8.91104713e-02f,
  -2.86772735e-02f, -5.82071953e-02f, -2.42564343e-02f, -2.92284545e-02f, 8.08544755e-02f, 1.87341124e-02f, 2.34804377e-02f, 3.61462720e-02f, 1.23857865e-02f, 9.46122408e-03f,
  2.96535641e-02f, 3.34123373e-02f, -5.57667241e-02f, -7.26906508e-02f, -3.39286067e-02f, 2.37745885e-02f, 5.83628118e-02f, -1.05945850e-02f, -1.50831693e-04f, 1.12030767e-01f,
  -2.80058035e-03f, 1.60988644e-02f, -5.94670475e-02f, 1.91029012e-02f, 7.94183537e-02f, 1.37345793e-04f, 7.72941709e-02f, -2.62065586e-02f, -1.85289513e-02f, 7.03809364e-03f,
  -3.19534212e-01f, 1.72867447e-01f, -4.46365476e-02f, 5.62996715e-02f, -5.35780042e-02f, -8.88300613e-02f, -1.82891116e-01f, -9.14731994e-02f, 6.56684209e-03f, -2.59599611e-02f,
  1.03011221e-01f, -4.77300286e-02f, -2.31227148e-02f, -4.59959395e-02f, -7.72716850e-02f, -6.53251559e-02f, 8.54897350e-02f, -9.50759053e-02f, 9.45069566e-02f, -4.69330847e-02f,
  9.00440514e-02f, 6.71712235e-02f, -5.34558436e-03f, 5.70158176e-02f, 9.85100567e-02f, -5.61321452e-02f, -9.79503691e-02f, -7.21313432e-02f, -2.82765459e-02f, -2.26971477e-01f,
  -4.70179617e-01f, 1.38296664e-01f, 4.39516783e-01f, -2.73813039e-01f, 7.78996646e-02f, 5.10248058e-02f, 5.52409291e-02f, 3.82169969e-02f, -8.04495811e-02f, -7.72924125e-02f,
  1.71877235e-01f, -1.10912241e-01f, -1.03503607e-01f, -5.19636832e-02f, -6.34531602e-02f, -2.62193698e-02f, -7.53041655e-02f, 9.03847907e-03f, 1.51350379e-01f, 3.90684493e-02f,
  -5.06758839e-02f, -1.22145496e-01f, -1.46592289e-01f, 2.78035030e-02f, -1.45880267e-01f, -7.53612667e-02f, -1.08130500e-01f, -1.55469194e-01f, 3.22736539e-02f, -3.91917080e-01f,
  -6.54223710e-02f, 2.02283800e-01f, 9.56618041e-02f, -1.68280944e-01f, 1.32273898e-01f, -8.21036100e-03f, 1.22531997e-02f, 5.96153252e-02f, 1.54310698e-02f, 3.03729773e-02f,
  1.91530418e-02f, 1.67865425e-01f, -3.62049676e-02f, 1.09982036e-01f, -1.36650808e-03f, 4.05268483e-02f, 1.05193421e-01f, -5.46096452e-02f, -8.82904902e-02f, -1.28622702e-03f,
  -1.42332137e-01f, 5.82021773e-02f, -1.91185787e-01f, -1.46465287e-01f, -1.32104516e-01f, -7.77599663e-02f, 1.64500717e-02f, -9.79183391e-02f, 5.26249893e-02f, -4.04259592e-01f,
  4.32717651e-02f, -1.08541129e-02f, 1.96380138e-01f, 5.81743531e-02f, -5.06869592e-02f, 4.89073656e-02f, -3.30684111e-02f, 2.48636748e-03f, 6.60386384e-02f, -8.26290995e-02f,
  -4.01344523e-02f, 6.25376776e-02f, -8.70806631e-03f, -1.28758430e-01f, 8.47852696e-03f, 3.45447585e-02f, -6.66402802e-02f, -1.86445996e-01f, -4.16076928e-02f, -1.01524808e-01f,
  -7.69124180e-02f, -3.84969451e-02f, 5.40835895e-02f, -6.43670112e-02f, -3.73320505e-02f, 1.28136545e-01f, 7.07814191e-03f, 1.28400609e-01f, 2.68223304e-02f, -4.02754499e-03f,
  -2.14482695e-01f, 2.68712133e-01f, -5.69616742e-02f, -4.96483892e-02f, 6.27203658e-02f, -1.07692908e-02f, 5.66654205e-02f, 4.69389521e-02f, 4.83322106e-02f, -3.46118100e-02f,
  5.43401651e-02f, -1.12140700e-02f, 4.57470939e-02f, 7.87488818e-02f, -1.19787797e-01f, 2.56870408e-02f, -1.45393401e-01f, -1.77725255e-01f, -1.54810548e-01f, 4.44779918e-02f,
  -1.80905372e-01f, -3.16046834e-01f, -4.04219419e-01f, -2.29552999e-01f, -2.13790193e-01f, -1.75726429e-01f, -9.34215710e-02f, -2.24658817e-01f, -2.43703738e-01f, -2.85552830e-01f,
  -7.69850388e-02f, -2.66026378e-01f, -2.13261008e-01f, -1.41594201e-01f, -2.40225226e-01f, -1.50106207e-01f, -5.00679135e-01f, -2.23093759e-03f, 2.03396901e-01f, -4.50078070e-01f,
  -2.47698933e-01f, 7.08416179e-02f, -9.64422226e-02f, 8.67869928e-02f, 4.78787497e-02f, -4.32259619e-01f, -2.93416172e-01f, -5.50986864e-02f, 3.53753030e-01f, 3.79022099e-02f,
  -1.39754951e-01f, -1.32188961e-01f, 2.47210503e-01f, 1.74011022e-01f, -1.74066558e-01f, 1.45829633e-01f, -2.66538113e-01f, 2.78359139e-03f, 1.63095389e-02f, -2.26970807e-01f,
  -3.46898228e-01f, -4.82985377e-02f, 5.25451526e-02f, 1.27093568e-01f, -2.47924030e-01f, 8.80877525e-02f, -7.63844550e-02f, -1.41940219e-03f, -1.09384872e-01f, -9.66291502e-03f,
  -1.01484559e-01f, 1.56853646e-02f, 8.96614194e-02f, -1.37467220e-01f, -9.55057368e-02f, 1.13365510e-02f, 3.66341472e-02f, 1.00926764e-01f, 9.39663425e-02f, -9.81429815e-02f,
  -1.88667729e-01f, -3.45938168e-02f, -1.73645914e-02f, 9.93338693e-03f, 1.14003129e-01f, 8.53630081e-02f, 1.09597698e-01f, 1.70139477e-01f, 1.79064497e-01f, -5.45563102e-02f,
  -4.39432003e-02f, -8.19603577e-02f, 9.20564309e-03f, 3.42250504e-02f, -1.45685831e-02f, 4.47430238e-02f, -2.56147068e-02f, -5.27457409e-02f, 7.37815350e-02f, 1.25320526e-02f,
  -3.92967910e-02f, -7.31122717e-02f, 4.35403325e-02f, -4.12335247e-02f, -4.59311754e-02f, 4.52471487e-02f, -6.14013057e-03f, 4.02061902e-02f, -1.24439940e-01f, -6.26305640e-02f,
  7.74867879e-03f, 9.39001143e-02f, -4.64977250e-02f, 3.05633713e-02f, 5.65537950e-03f, -2.94430871e-02f, 1.43096335e-02f, 9.35801193e-02f, -9.87919942e-02f, 3.29465456e-02f,
  -2.53588008e-03f, 6.17951043e-02f, -2.40595743e-01f, -6.77042007e-02f, -1.19001083e-01f, -1.48133948e-01f, 2.40462683e-02f, -1.18877724e-01f, -1.17193848e-01f, -7.93542862e-02f,
  8.03179890e-02f, -9.32511166e-02f, -1.34060690e-02f, 1.25461128e-02f, -2.36294977e-03f, -1.10874444e-01f, -3.75477299e-02f, -8.69787484e-02f, 6.75201714e-02f, 3.85633595e-02f,
  6.94623962e-02f, -2.97770239e-02f, -9.51728821e-02f, 9.09004081e-03f, 8.21778178e-02f, -3.46887894e-02f, -1.01528861e-01f, -5.23783872e-03f, -3.10486946e-02f, -2.05198020e-01f,
  2.38478556e-01f, 1.15250699e-01f, 1.24674581e-01f, 1.57679111e-01f, -2.01902632e-02f, 4.10596430e-02f, -4.74421941e-02f, 3.01629268e-02f, 5.85604459e-02f, -4.89381105e-02f,
  1.15166074e-02f, 1.80004776e-01f, 2.16859981e-01f, 1.39940113e-01f, 1.49265617e-01f, 2.60116637e-01f, 2.33811513e-01f, 7.17674345e-02f, -4.42200676e-02f, -3.27342078e-02f,
  -1.02740750e-02f, -1.11305237e-01f, -7.47565851e-02f, -6.95580170e-02f, 3.71525064e-02f, -5.82199618e-02f, 2.14206669e-02f, -6.19776733e-02f, -1.52490228e-01f, 2.30195835e-01f,
  5.11499882e-01f, 9.33158621e-02f, 1.98907003e-01f, 7.41127655e-02f, -3.84147167e-02f, -7.84751028e-03f, -2.02334747e-02f, 3.07187508e-03f, 7.41784647e-02f, -3.43799102e-03f,
  1.18815325e-01f, -5.68699948e-02f, -2.06487313e-01f, -1.14529721e-01f, -1.80534631e-01f, -6.62625581e-02f, -1.15065522e-01f, 1.12928249e-01f, 1.56066924e-01f, 1.58258259e-01f,
  1.12843122e-02f, -1.32173851e-01f, -5.49937040e-02f, -4.32477593e-02f, 1.05382241e-01f, 7.45825693e-02f, -1.26553532e-02f, 2.46260241e-02f, -3.80726457e-02f, -6.91829249e-02f,
  1.27578720e-01f, 7.34812245e-02f, -1.56855043e-02f, -4.53099832e-02f, -3.96793969e-02f, 3.45231742e-02f, 8.39020684e-02f, -9.67244338e-03f, -5.42636290e-02f, -2.13558272e-01f,
  -1.08241960e-01f, 7.40116909e-02f, 1.04643673e-01f, 6.86728433e-02f, -2.92489771e-02f, 1.38595812e-02f, 4.30562906e-02f, -2.12049987e-02f, -1.42739505e-01f, -1.05378397e-01f,
  -6.31229160e-03f, 5.16820848e-02f, -2.40959153e-01f, -1.61308758e-02f, -5.33054993e-02f, -1.34497702e-01f, -2.68860888e-02f, -1.92087591e-01f, -1.85499489e-01f, -5.24665080e-02f,
  2.17697650e-01f, 1.00532584e-01f, 2.34668612e-01f, 1.37221366e-01f, 5.68401366e-02f, -6.06586225e-02f, -2.69275848e-02f, 1.11020692e-01f, 1.88044906e-01f, 2.01015428e-01f,
  1.54782116e-01f, -6.41273335e-02f, -1.50918841e-01f, -1.50243148e-01f, -2.58644167e-02f, -1.70631990e-01f, 5.03100827e-02f, 1.46329150e-01f, 1.77333206e-01f, 1.94276884e-01f,
  7.77628645e-02f, 2.47350279e-02f, 3.15060504e-02f, 9.05802939e-03f, 1.15322493e-01f, -2.25226730e-02f, -6.97803944e-02f, 6.02022111e-02f, 5.28303534e-02f, -9.34044719e-02f,
  -1.97788939e-01f, -2.35917851e-01f, -2.31770739e-01f, -1.45985976e-01f, -8.82576555e-02f, -1.13060392e-01f, -1.37478054e-01f, 1.03448294e-01f, -5.97236492e-02f, -2.88430333e-01f,
  -3.31657752e-02f, 8.20875391e-02f, -9.12317112e-02f, -8.85524824e-02f, -4.68545184e-02f, -3.19009930e-01f, -4.67132479e-01f, -1.83419883e-01f, 1.32810444e-01f, 5.53871542e-02f,
  -1.35438338e-01f, -2.47160181e-01f, -4.30596322e-02f, -8.41294527e-02f, -9.74212810e-02f, -7.62512609e-02f, -4.03422952e-01f, -1.66450515e-01f, -1.67705476e-01f, -4.26949114e-01f,
  -1.71096668e-01f, 2.10578337e-01f, 1.95763126e-01f, 1.83912680e-01f, -5.89082725e-02f, 2.15884358e-01f, 3.91571410e-02f, 1.25096617e-02f, 1.02746285e-01f, 1.32703586e-02f,
  1.54272854e-01f, 5.55931143e-02f, 3.84517014e-02f, 8.40765908e-02f, 7.13260099e-02f, 9.46508870e-02f, 8.67607743e-02f, 2.58636530e-02f, -9.17642713e-02f, 5.19421063e-02f,
  4.38234843e-02f, 3.90433408e-02f, 1.31010227e-02f, 6.81177154e-02f, 1.08133569e-01f, 1.31060779e-01f, 1.48031294e-01f, 1.34486184e-01f, 7.07634017e-02f, -5.03433347e-02f,
  -2.48142019e-01f, -1.33478194e-01f, 1.10825552e-02f, 6.69465959e-02f, 4.65787239e-02f, 2.23020706e-02f, 1.39377275e-02f, -1.34889930e-01f, -3.25879082e-02f, -6.14134371e-02f,
  -1.81818753e-02f, -3.06013389e-03f, 1.28610671e-01f, 2.96800490e-02f, 2.73036491e-03f, 2.33849175e-02f, 3.28842644e-03f, 5.91229349e-02f, 2.10556239e-01f, 3.82405855e-02f,
  1.52658001e-01f, 5.65141663e-02f, -2.08503297e-05f, 4.42074947e-02f, 3.78396325e-02f, -4.77573741e-03f, 6.91906810e-02f, -4.04212363e-02f, -5.10603637e-02f, -2.60922592e-02f,
  -5.82839968e-03f, 2.14774042e-01f, -1.16015173e-01f, 6.49498496e-03f, 2.64728144e-02f, 1.20654656e-02f, -6.20762669e-02f, 6.42595366e-02f, 9.02707055e-02f, 3.84220295e-02f,
  1.40936494e-01f, 6.91724345e-02f, -5.82212843e-02f, 1.71040334e-02f, 7.28718489e-02f, 1.87994584e-01f, 1.54485315e-01f, 6.55321479e-02f, 1.03456732e-02f, 8.84442404e-02f,
  -2.36229431e-02f, 4.74136956e-02f, 6.77669002e-03f, 3.05337310e-02f, 6.82763532e-02f, 8.18192214e-02f, 1.02096908e-01f, 4.50592116e-02f, -3.32691967e-02f, -1.65705264e-01f,
  4.07449864e-02f, -2.81714052e-01f, -2.24163964e-01f, 2.96184327e-02f, 9.18529630e-02f, 1.04246661e-01f, -7.75324032e-02f, 2.37008780e-02f, 1.25767171e-01f, -1.58450246e-01f,
  1.57287031e-01f, 2.26966992e-01f, -1.02013331e-02f, -1.41332112e-03f, 7.93497115e-02f, -3.60027373e-01f, -2.99443632e-01f, -7.85194058e-03f, 3.58679146e-01f, 3.71138662e-01f,
  2.74808854e-01f, 1.96373269e-01f, 4.97315153e-02f, 1.28948033e-01f, -1.10972971e-01f, 1.82732809e-02f, -2.29237899e-01f, -1.84138238e-01f, -9.27597731e-02f, -3.74278933e-01f,
  -2.82083064e-01f, -1.67060927e-01f, -7.21712038e-02f, 9.06980932e-02f, -2.65559088e-02f, -1.55446902e-01f, -9.07306746e-02f, -3.04641694e-01f, -4.14424799e-02f, 1.09960558e-02f,
  7.27041950e-03f, -3.76673578e-03f, 1.38178334e-01f, 1.31270394e-01f, 1.47854477e-01f, 3.17838714e-02f, -9.48520191e-03f, -4.22267206e-02f, -1.34955376e-01f, -2.97933002e-03f,
  3.84335010e-03f, 1.43170550e-01f, -9.59728062e-02f, -6.90349042e-02f, -2.23015711e-01f, 1.01633288e-01f, -1.86838657e-01f, -8.75674039e-02f, -1.93134189e-01f, -3.53385448e-01f,
  2.80268043e-02f, 4.33776043e-02f, -6.22441433e-02f, -1.44945145e-01f, 7.86027312e-02f, -2.48885602e-02f, -1.28194332e-01f, 1.53273880e-01f, 1.14766590e-01f, -3.15748565e-02f,
  3.63078825e-02f, 4.27088793e-03f, 7.66481385e-02f, -3.55206169e-02f, -1.92042720e-02f, -8.31628889e-02f, 1.20484494e-02f, -6.96395487e-02f, 2.83490214e-03f, 1.51808112e-04f,
  7.09529743e-02f, -1.54222474e-01f, -1.11295626e-01f, 3.96883041e-02f, -7.53177702e-02f, -4.48071808e-02f, -2.01498605e-02f, 6.58903942e-02f, 1.60736237e-02f, 1.58850178e-02f,
  1.27844006e-01f, -1.26521826e-01f, -5.97099662e-02f, 1.97430588e-02f, -6.24495894e-02f, 8.38018209e-03f, -9.41186547e-02f, 3.06889955e-02f, -5.83219230e-02f, -4.41087782e-02f,
  -4.51277643e-02f, -6.42375574e-02f, -3.35756801e-02f, -1.34292141e-01f, 2.85974760e-02f, 4.45600599e-02f, -2.82105692e-02f, 1.02549291e-03f, 8.68213624e-02f, -1.02991961e-01f,
  -1.00475937e-01f, 1.37127131e-01f, 8.77249539e-02f, -1.86060071e-01f, -1.91481318e-02f, -1.19188046e-02f, -1.90187037e-01f, -9.03098136e-02f, -1.08361229e-01f, -2.31045887e-01f,
  -2.82141734e-02f, 2.70643204e-01f, -2.24854723e-01f, 1.44216912e-02f, -9.37693473e-03f, -6.74903095e-02f, -9.21305828e-03f, -8.52518752e-02f, -1.49370804e-02f, 1.07629605e-01f,
  -1.39571711e-01f, 4.61956300e-02f, 8.87774304e-02f, 9.31575298e-02f, 3.69889289e-02f, 4.26822193e-02f, 1.91594318e-01f, -1.86626483e-02f, -4.14050892e-02f, 8.09698105e-02f,
  2.80962467e-01f, 8.65468755e-02f, 1.69876665e-02f, -2.18516402e-02f, 2.34117836e-01f, 1.08780339e-01f, 4.20970656e-02f, 6.75067455e-02f, 1.21173047e-01f, 6.16082668e-01f,
  1.18661569e-02f, 3.50687676e-03f, -1.44632459e-01f, 7.94768333e-02f, -2.62183864e-02f, 1.77113395e-02f, 6.50464976e-03f, -1.12090357e-01f, -3.08946799e-02f, -2.26929095e-02f,
  1.76845670e-01f, 1.20033868e-01f, 1.32234544e-01f, 4.92742956e-02f, -4.22782488e-02f, -4.40099351e-02f, 1.28955185e-01f, 6.06636517e-03f, -1.41710222e-01f, -9.90595296e-02f,
  1.35580570e-01f, -1.43018246e-01f, -1.81096271e-01f, -2.89356232e-01f, -1.72019199e-01f, -1.70540556e-01f, -1.19226314e-01f, -4.52078646e-03f, -2.78312773e-01f, 7.21024647e-02f,
  -6.87680468e-02f, -6.42075092e-02f, 3.39445309e-03f, -4.16259691e-02f, 7.75642395e-02f, 2.27625191e-01f, 4.90989611e-02f, -1.60492975e-02f, -4.81481710e-03f, 5.03835939e-02f,
  -1.07247479e-01f, -6.38214722e-02f, -9.52621251e-02f, -6.22696690e-02f, 2.34986581e-02f, -2.13169977e-02f, 2.09412761e-02f, -5.30151837e-02f, -2.57546991e-01f, -1.05681211e-01f,
  2.74131284e-03f, -2.24981178e-02f, -5.02701476e-03f, 1.03480928e-02f, -9.35095698e-02f, -1.16064645e-01f, 6.88226148e-03f, -2.24974584e-02f, -2.53001936e-02f, -5.49655072e-02f,
  8.04497898e-02f, -3.07168484e-01f, 1.90991592e-02f, 1.31238744e-01f, -3.92542630e-02f, -1.21804224e-02f, -3.01836841e-02f, -2.78982311e-01f, -1.17065161e-01f, -7.42895678e-02f,
  9.56851467e-02f, -6.74120784e-02f, 1.07035920e-01f, -1.51138362e-02f, -4.57130782e-02f, -3.27569097e-02f, 2.03791827e-01f, -2.71088164e-02f, -5.13429493e-02f, -9.54495817e-02f,
  1.14675023e-01f, 4.26200181e-02f, -3.46020050e-02f, -2.24063732e-02f, 7.32602924e-02f, -5.25193885e-02f, 4.82886769e-02f, -3.11503615e-02f, -9.00298059e-02f, 1.81123465e-02f,
  -9.59161580e-01f, 1.41571894e-01f, 9.67199579e-02f, -6.72613800e-01f, -8.82633626e-02f, -1.69037413e-02f, 1.11478180e-01f, -9.20819864e-02f, -3.37734014e-01f, 7.37398565e-02f,
  3.84196490e-02f, -1.81382403e-01f, -4.03385833e-02f, 4.74923737e-02f, -2.27973722e-02f, 7.52222091e-02f, -1.40366733e-01f, -3.06509167e-01f, 3.52133028e-02f, 5.75238764e-02f,
  -3.94789129e-02f, -4.31220233e-01f, -5.15409052e-01f, -2.18186155e-01f, -1.43747270e-01f, -1.45608321e-01f, -1.05856225e-01f, -1.70435041e-01f, 9.39049423e-02f, -1.59232065e-01f,
  2.70726681e-01f, -1.40895069e-01f, 3.39524224e-02f, -2.88026612e-02f, 8.43466595e-02f, -6.35718480e-02f, -1.81656312e-02f, -3.97120230e-02f, -1.60760842e-02f, 5.40717691e-02f,
  -1.29842982e-01f, 3.62932906e-02f, -2.04998657e-01f, 9.57646221e-02f, -5.19686341e-02f, 7.49958977e-02f, 1.44067500e-02f, 2.76581626e-02f, -1.72213186e-02f, 2.26156473e-01f,
  1.30398780e-01f, -3.65125723e-02f, 1.37258217e-01f, 1.56661153e-01f, 1.28243148e-01f, -6.39977977e-02f, 1.67595059e-01f, 2.73448229e-02f, 1.84364483e-01f, 1.06544159e-01f,
  9.44675207e-02f, 1.47010684e-01f, -4.29474749e-02f, -1.11440429e-02f, -3.90343890e-02f, -4.09531966e-02f, -7.62595683e-02f, 1.26348048e-01f, 7.68132582e-02f, -9.02226716e-02f,
  2.81889476e-02f, -6.86898381e-02f, -2.81287059e-02f, 4.24460624e-04f, 1.79572590e-02f, -2.19871067e-02f, -1.65449709e-01f, 3.65732163e-02f, 6.13892563e-02f, -3.45913880e-02f,
  -7.70112425e-02f, 1.08708935e-02f, -1.11392781e-01f, -5.11164851e-02f, 3.85927670e-02f, -1.22792693e-02f, -6.47730678e-02f, -2.30512433e-02f, 3.19245309e-02f, -6.72993734e-02f,
  -1.07935153e-01f, -2.29210079e-01f, -1.90292299e-01f, 1.25333015e-02f, -5.88939749e-02f, 7.71196038e-02f, -7.57783353e-02f, 4.94629405e-02f, -8.78286213e-02f, 4.37774882e-02f,
  2.60793511e-02f, 3.77165452e-02f, 4.18993458e-02f, 2.76861712e-02f, -5.78225963e-02f, 5.22874929e-02f, 2.37600319e-02f, -8.07977170e-02f, -1.52992951e-02f, -2.11047698e-02f,
  2.71986537e-02f, -4.41637374e-02f, 1.16356984e-01f, 1.06355689e-01f, 1.11505806e-01f, -5.16703539e-02f, 1.07717082e-01f, 9.09904391e-02f, 9.70894843e-02f, 5.11934310e-02f,
  4.21830356e-01f, 1.68631986e-01f, 2.57722497e-01f, 2.54101276e-01f, 4.47994381e-01f, 5.66686630e-01f, 5.42665601e-01f, 2.79589921e-01f, 1.05168462e-01f, 8.35355818e-02f,
  1.47500053e-01f, 8.73932615e-02f, 2.67865346e-03f, -1.28605515e-01f, 1.14490934e-01f, 3.08895838e-02f, -9.55904201e-02f, -6.84763817e-03f, 8.17215145e-02f, 2.56846428e-01f,
  -2.45730877e-02f, -4.87114079e-02f, -1.18303679e-01f, -1.28964126e-01f, -1.42360181e-01f, -9.40675214e-02f, -8.41542706e-02f, 2.96125170e-02f, -6.41767727e-03f, -4.28594887e-01f,
  -1.20574512e-01f, 3.01152080e-01f, 3.87043133e-02f, -3.82961407e-02f, 3.45500410e-02f, -1.97819486e-01f, 6.49310052e-02f, -1.48335844e-01f, 3.42105627e-02f, -1.61076933e-01f,
  -1.44583173e-02f, -8.78015161e-02f, -5.85702388e-03f, -7.86820799e-02f, -2.33755931e-02f, -5.46408258e-02f, -6.61726445e-02f, -7.47791678e-02f, -6.13650791e-02f, 7.53631070e-02f,
  -1.60807129e-02f, 1.71338007e-01f, 2.59588450e-01f, 2.03211978e-01f, 1.33206561e-01f, 7.73737282e-02f, 2.21335590e-02f, 5.52136637e-02f, 2.82467864e-02f, -1.18421607e-01f,
  1.68826401e-01f, 2.16562115e-02f, -5.45626543e-02f, 6.53531402e-02f, -3.92546542e-02f, 1.17009103e-01f, 6.97373971e-02f, 9.18340832e-02f, -3.36402655e-02f, -1.00509144e-01f,
  2.21150070e-02f, 2.91093457e-02f, -1.74412166e-03f, 1.02280127e-02f, -1.13171590e-02f, 2.61766370e-03f, -2.68645454e-02f, 7.97567144e-02f, 5.32645807e-02f, -8.72291848e-02f,
  1.31885093e-02f, 5.23279533e-02f, -5.13562709e-02f, -5.40309362e-02f, -5.63783161e-02f, 8.27117711e-02f, 3.59212495e-02f, 1.99962016e-02f, -5.09756943e-03f, 2.65957788e-02f,
  -3.88295352e-01f, 3.27136248e-01f, -1.26791671e-01f, -1.42927974e-01f, -8.97736028e-02f, -1.51875615e-01f, -1.60712912e-03f, -1.40941724e-01f, -3.53247598e-02f, 1.08340509e-01f,
  1.50559798e-01f, 6.07195459e-02f, 8.95247981e-02f, 1.06550325e-02f, -9.86461900e-03f, 2.89906980e-03f, -6.89143389e-02f, -3.30670998e-02f, -1.13625214e-01f, -1.26514465e-01f,
  -8.28898475e-02f, 5.19345589e-02f, 1.60287634e-01f, 1.36855707e-01f, 1.03319876e-01f, 7.51948804e-02f, 5.34815490e-02f, 1.75683647e-02f, 1.24381743e-01f, 6.25924841e-02f,
  6.43119263e-03f, 3.15247834e-01f, -4.73456502e-01f, -1.33299217e-01f, -2.15634242e-01f, -1.09039918e-01f, 1.53172448e-01f, 2.00074196e-01f, 1.92470178e-01f, 7.78658539e-02f,
  9.43012759e-02f, -1.57709122e-01f, -2.77063906e-01f, -3.27753499e-02f, -3.90778221e-02f, -1.93755031e-02f, -3.11388403e-01f, -2.11970568e-01f, -9.74751413e-02f, 1.33351952e-01f,
  1.05266400e-01f, 1.45472139e-01f, 9.17818099e-02f, 1.29865542e-01f, -4.18168046e-02f, -8.55127051e-02f, -9.45049450e-02f, -1.76373214e-01f, -4.11025397e-02f, -4.08374459e-01f,
  -3.50737989e-01f, -1.03287131e-01f, -1.21347770e-01f, 1.29256934e-01f, -2.30968788e-01f, 1.66297287e-01f, -4.27924059e-02f, -7.93294422e-03f, 3.78668942e-02f, 1.37292994e-02f,
  -1.27732009e-01f, -5.14481664e-02f, -2.25228429e-01f, 7.66262338e-02f, -2.47161947e-02f, -3.11799832e-02f, 1.59477100e-01f, -2.95300670e-02f, -2.65645027e-01f, -3.68689448e-02f,
  -5.51966317e-02f, -2.69059807e-01f, -2.38470092e-01f, -1.35679245e-01f, -1.23769343e-01f, -2.19214901e-01f, 6.26382455e-02f, -7.49362335e-02f, -1.88135982e-01f, 1.61851496e-01f,
  7.73131251e-02f, -8.13731998e-02f, 8.13096315e-02f, 1.29950330e-01f, 9.15361345e-02f, -1.47427410e-01f, -9.97719243e-02f, -1.38558215e-02f, -6.28891513e-02f, -6.68519437e-02f,
  -2.33760662e-02f, -1.22278720e-01f, 8.34203735e-02f, -4.68466766e-02f, -2.16282502e-01f, -7.58692697e-02f, -2.91833244e-02f, 7.30500370e-02f, -5.84598482e-02f, -2.79098842e-02f,
  -4.45943177e-02f, -6.49168789e-02f, -2.69647408e-02f, 1.68231562e-01f, -4.53752242e-02f, 1.04446635e-01f, -4.90626320e-02f, 1.41770437e-01f, 1.11257672e-01f, 2.30669416e-02f,
  1.79218993e-01f, -1.59810558e-01f, -2.30797436e-02f, -4.02810164e-02f, -9.31281149e-02f, 4.43116091e-02f, -1.69840202e-01f, 1.01851605e-01f, 6.18906617e-02f, -3.90877295e-03f,
  -3.68832052e-02f, 5.43643646e-02f, -7.86541551e-02f, 2.74421545e-05f, 4.18866659e-03f, -1.62579715e-01f, 7.91355520e-02f, -3.38855875e-03f, -1.32697105e-01f, 1.97204977e-01f,
  2.37889588e-01f, 1.20279461e-01f, 6.92131519e-02f, 1.06772684e-01f, 5.70669062e-02f, -1.97794363e-02f, 1.51096527e-02f, 1.80143550e-01f, 9.96295363e-03f, 5.62862813e-01f,
  3.09970409e-01f, -1.94237724e-01f, -2.50297338e-01f, 1.33024260e-01f, 4.96609733e-02f, 8.45381152e-03f, -3.15708071e-01f, 9.53970924e-02f, 2.45701209e-01f, 1.17226932e-02f,
  2.55571365e-01f, 5.02372801e-01f, 3.23040754e-01f, 1.30692557e-01f, 2.21766666e-01f, -2.70773143e-01f, -3.61145437e-01f, 1.45272585e-02f, 3.63537580e-01f, 3.37724626e-01f,
  9.80398953e-02f, -8.20206404e-02f, 6.93110451e-02f, 1.14118055e-01f, -2.18259707e-01f, 7.32646883e-02f, -3.53189737e-01f, -2.44686887e-01f, -1.83807224e-01f, -5.22281766e-01f,
  -4.71954569e-02f, 1.72567293e-02f, 1.36867851e-01f, 7.60776317e-03f, -1.03483729e-01f, -5.06517105e-02f, -1.54370079e-02f, -5.13766147e-02f, -8.82069021e-02f, -1.15225881e-01f,
  1.74698792e-02f, 1.90711357e-02f, 2.69323085e-02f, -4.75628935e-02f, -1.46227092e-01f, -3.83569822e-02f, -9.03923512e-02f, -6.89152488e-03f, 3.56909670e-02f, -1.08121224e-01f,
  8.90714303e-03f, 5.50080389e-02f, 1.74203873e-04f, 6.29195720e-02f, 1.27086803e-01f, 2.22041160e-01f, -1.18211821e-01f, -1.80966426e-02f, -3.24430615e-02f, -3.62522870e-01f,
  1.39536664e-01f, 2.86795311e-02f, 3.44254635e-02f, -7.96576440e-02f, 8.30893293e-02f, -6.08422644e-02f, -3.44834141e-02f, -4.41525970e-03f, 6.83130473e-02f, -1.40913855e-02f,
  1.14746399e-01f, -6.19402342e-03f, -3.12073771e-02f, -4.41126674e-02f, 3.10997032e-02f, -5.70335127e-02f, -9.57972631e-02f, -2.23208852e-02f, 2.29972024e-02f, -5.26522696e-02f,
  5.28191589e-02f, -9.17138085e-02f, -2.46013477e-02f, -9.30485651e-02f, 1.04091726e-02f, 9.61422101e-02f, 1.02782853e-01f, 1.20344616e-01f, 7.02361166e-02f, -1.00988830e-02f,
  2.00528391e-02f, 2.10632116e-01f, 2.73610335e-02f, 9.83328670e-02f, -1.89085588e-01f, 2.64804233e-02f, -4.50594127e-02f, -5.11127152e-03f, -7.21930992e-03f, -4.27567549e-02f,
  6.72296062e-02f, -4.74071540e-02f, -1.67694047e-01f, -5.29547036e-02f, 2.51666140e-02f, 2.56728847e-02f, -2.88295019e-02f, 3.98441553e-02f, -1.92007497e-02f, -8.86215121e-02f,
  -2.21868381e-02f, -7.86392018e-02f, 7.04473332e-02f, 2.34879181e-02f, 1.24831729e-01f, 1.19506627e-01f, -4.44865115e-02f, 1.04817767e-02f, 1.07005090e-02f, -2.87654907e-01f,
  6.59810841e-01f, 4.12181109e-01f, 1.34429440e-01f, -7.66291171e-02f, -1.54178217e-01f, -1.93306655e-02f, 2.92428821e-01f, 1.22402452e-01f, -1.05121650e-01f, 4.81154472e-02f,
  1.04914993e-01f, -5.00070043e-02f, -7.24922568e-02f, 1.62593536e-02f, 1.60886385e-02f, 1.19370818e-01f, -1.35018155e-01f, 1.65178757e-02f, 7.40364641e-02f, 1.58912409e-02f,
  -4.36429307e-02f, -1.78802274e-02f, 1.24511011e-01f, 1.15211993e-01f, 1.32762775e-01f, -2.37526461e-01f, -7.49950530e-03f, 1.81536633e-03f, -1.46952493e-03f, 1.52784631e-01f,
  -8.02207552e-03f, 4.97963279e-01f, -2.08934546e-01f, -2.48500165e-02f, 1.01563543e-01f, 1.69573531e-01f, 3.89224514e-02f, 2.23071158e-01f, 4.78489958e-02f, -1.29339889e-01f,
  -6.33094981e-02f, 1.85334072e-01f, 1.56633124e-01f, 6.18680045e-02f, 1.19506374e-01f, 1.40467882e-01f, 2.36927584e-01f, 1.50960624e-01f, -1.57631971e-02f, 5.78222610e-02f,
  -1.24512929e-02f, 8.55996758e-02f, 3.34808230e-02f, -3.13200839e-02f, 8.08412805e-02f, -7.03631341e-02f, 1.41757950e-02f, 6.07334040e-02f, 6.20402545e-02f, 4.28397618e-02f,
  -8.33119527e-02f, -6.58452213e-02f, 7.47552421e-03f, -3.83763313e-02f, 2.27960981e-02f, -2.00577620e-02f, -8.47100019e-02f, -1.13314549e-02f, -2.11431831e-02f, 1.76764026e-01f,
  1.16929393e-02f, 4.08291407e-02f, -1.50742397e-01f, 1.07886277e-01f, -1.03443362e-01f, 7.12613240e-02f, 1.89618173e-03f, -8.40887204e-02f, -8.13816022e-03f, 4.11248356e-02f,
  -1.77669916e-02f, -1.79944355e-02f, -6.13827668e-02f, 1.35629058e-01f, 2.93310490e-02f, -1.25740469e-02f, -2.26359572e-02f, 5.82694262e-02f, 5.62910438e-02f, -9.50741488e-03f,
  -4.89719450e-01f, -2.52942219e-02f, -5.03591560e-02f, 1.39338672e-01f, 2.75751986e-02f, -1.13740331e-03f, -5.24666440e-03f, 4.90062311e-02f, -2.45479107e-01f, -5.48577905e-02f,
  -2.55530030e-02f, -3.95180769e-02f, 9.71031785e-02f, 3.35033685e-02f, -1.70444638e-01f, -1.29235789e-01f, -9.95811448e-02f, -9.99756306e-02f, -1.20354906e-01f, -1.11605026e-01f,
  -3.05978917e-02f, -1.26309231e-01f, -2.07988739e-01f, -2.02391699e-01f, -1.89869449e-01f, -3.30722630e-01f, -1.11784816e-01f, -5.78952432e-02f, -2.22856835e-01f, 4.41742800e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.64225714e-02f, 1.25805989e-01f, 1.43188834e-01f, 5.31211197e-02f, 1.45954471e-02f, -7.92057589e-02f, -1.31068885e-01f, -2.19665505e-02f, 1.67822614e-01f, 1.19942173e-01f,
  1.43662885e-01f, 1.48143068e-01f, 2.39557967e-01f, 1.54250219e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.41129866e-01f, 8.36611167e-02f, 1.11115038e-01f, 4.24810238e-02f, 7.81608969e-02f, -1.49499597e-02f, 1.72317594e-01f, -1.21604651e-01f, 3.59070115e-02f, 6.53487220e-02f,
  -2.38756835e-01f, 1.86113238e-01f, -1.24351509e-01f, 2.78597903e-02f, 1.17022870e-02f, -5.77968219e-03f, -5.42693101e-02f, 9.43522975e-02f, 9.59150791e-02f, -9.62710604e-02f,
  1.42619861e-02f, -5.86925074e-02f, 1.11168310e-01f, 4.00523841e-02f, 4.03772406e-02f, 1.20713390e-01f, -1.32283673e-01f, -1.54733568e-01f, -1.60078511e-01f, 2.09352840e-02f,
  -2.81217061e-02f, 4.75108922e-02f, 5.83306924e-02f, 4.74277772e-02f, -1.27646655e-01f, 3.16394158e-02f, 3.91809903e-02f, -1.89344317e-01f, -7.43063688e-02f, 3.73363239e-03f,
  7.54840150e-02f, -2.43103743e-01f, 4.68371846e-02f, 2.07855962e-02f, 1.35983750e-01f, 1.50432259e-01f, -2.43471004e-02f, 5.62594272e-02f, 1.16944835e-01f, -1.37407348e-01f,
  1.45135656e-01f, -2.70834923e-01f, 1.36576399e-01f, -2.05079928e-01f, -4.68509309e-02f, 4.48192982e-03f, 5.14683463e-02f, -1.84391379e-01f, 1.57989949e-01f, -1.75977141e-01f,
  -5.11639267e-02f, -7.24690333e-02f, -4.79989290e-01f, -1.45442886e-02f, -1.10528674e-02f, 2.10858397e-02f, -8.39132071e-03f, 4.13872525e-02f, 1.49310790e-02f, -3.31108682e-02f,
  3.40773165e-02f, -7.33923838e-02f, 2.86935419e-02f, -5.59773259e-02f, -2.26439297e-01f, -9.09823477e-02f, -1.07191123e-01f, 7.17554763e-02f, -9.06317011e-02f, -2.78967351e-01f,
  -2.69221887e-02f, -3.24378721e-02f, 6.86459467e-02f, 5.57031855e-02f, -1.21302903e-01f, -1.02362268e-01f, 5.64995641e-03f, 2.75621228e-02f, 7.34520853e-02f, -3.70468050e-02f,
  9.08403918e-02f, -3.45864855e-02f, -6.88078851e-02f, -7.13245422e-02f, -2.73038801e-02f, -8.64288211e-02f, 9.69267786e-02f, -5.22474609e-02f, -1.22750327e-01f, 1.73872292e-01f,
  -3.98261361e-02f, -1.69183478e-01f, 4.97935340e-02f, 8.26946199e-02f, -9.17979181e-02f, -7.43545741e-02f, 1.33440793e-02f, -4.19825315e-02f, 5.82285523e-02f, 1.32295832e-01f,
  -8.40220153e-02f, 6.49857819e-02f, -1.81566477e-01f, -8.05981979e-02f, -8.08257833e-02f, -6.15096726e-02f, -9.59782153e-02f, -1.81828901e-01f, -1.02113694e-01f, -3.40291671e-02f,
  -4.96542491e-02f, -2.62613326e-01f, -1.73213437e-01f, -1.85806572e-01f, 2.80978262e-01f, -2.85139352e-01f, -1.54028982e-01f, 2.24371403e-01f, 1.76254269e-02f, 2.15526503e-02f,
  1.83239669e-01f, 8.20702538e-02f, 3.95745672e-02f, -1.14669137e-01f, 1.83533043e-01f, 3.55041139e-02f, 1.34168074e-01f, -4.32990305e-02f, -3.14335167e-01f, 3.79585437e-02f,
  -3.54990214e-02f, 1.15050934e-02f, -1.82470962e-01f, -3.51414591e-01f, 1.90660469e-02f, 8.24329108e-02f, -6.93397522e-02f, -1.57439053e-01f, 1.04647867e-01f, 1.04536014e-02f,
  -1.35729432e-01f, -5.09951375e-02f, 2.14663502e-02f, 4.60604131e-02f, -1.22227021e-01f, 1.48568496e-01f, -1.08127259e-01f, -7.80519843e-02f, -8.53695255e-03f, -3.18780239e-03f,
  2.49029607e-01f, 1.87486246e-01f, -3.39147359e-01f, 8.25174600e-02f, 1.34275734e-01f, -2.54788876e-01f, -1.17338441e-01f, 1.96966290e-01f, -7.72605538e-02f, -3.70641612e-02f,
  -6.07037693e-02f, -1.08864240e-01f, 5.19752018e-02f, 2.47001767e-01f, 1.49463192e-01f, -5.59431687e-03f, 1.58211380e-01f, -3.26631367e-02f, -2.48513639e-01f, -9.21764821e-02f,
  -2.82899570e-03f, 1.25898317e-01f, -2.42203757e-01f, 8.32506735e-03f, -2.26691797e-01f, -3.41916859e-01f, -9.86761414e-03f, 1.79763764e-01f, -2.49766573e-01f, -2.32882932e-01f,
  -5.47670305e-01f, 2.73563899e-02f, -1.24573596e-02f, -1.05237998e-01f, 1.71441525e-01f, 4.53234427e-02f, 6.92093074e-02f, 1.17077380e-01f, 8.48345682e-02f, -1.23096488e-01f,
  -1.75139327e-02f, -1.28449708e-01f, 2.19769124e-02f, -3.25911306e-02f, 1.17541919e-03f, -2.47523338e-02f, 6.49815723e-02f, -1.17901720e-01f, 5.98302260e-02f, -1.71078984e-02f,
  3.39731053e-02f, -6.62367344e-02f, -7.24941120e-02f, -6.37975335e-02f, 7.22665861e-02f, 6.32825494e-02f, 6.39543161e-02f, -1.49736106e-01f, 1.18645512e-01f, 6.13363646e-02f,
  5.27273342e-02f, 4.02195938e-02f, -1.52625144e-02f, 1.21278636e-01f, -1.28491938e-01f, -1.32539392e-01f, 1.27041778e-02f, 4.19968888e-02f, -1.57162577e-01f, 2.36724783e-02f,
  3.66801172e-02f, -5.11808358e-02f, 1.29600555e-01f, 3.28773148e-02f, 2.19687387e-01f, -1.71598181e-01f, -5.91420522e-03f, -7.76802078e-02f, -5.06118834e-02f, 3.76025774e-02f,
  2.50979632e-01f, -7.29122851e-03f, 1.06363744e-01f, 2.50684291e-01f, 4.40390795e-01f, 7.01325759e-02f, -3.74766178e-02f, 4.19875681e-02f, 1.01756409e-01f, 2.98461109e-01f,
  2.91070491e-02f, 3.07047367e-01f, 2.09300481e-02f, 7.46903718e-02f, 1.29835665e-01f, -2.70760864e-01f, -2.65995450e-02f, 7.00487047e-02f, 6.92323148e-02f, -8.72574747e-02f,
  6.45530373e-02f, 4.38507870e-02f, 1.88935041e-01f, 2.34845847e-01f, 1.76847488e-01f, 1.19024590e-01f, -1.38750866e-01f, 1.46786660e-01f, -5.60976975e-02f, 9.03253928e-02f,
  1.56100526e-01f, -7.87611604e-02f, 7.57792145e-02f, 1.07114732e-01f, 1.05046518e-02f, -6.70115799e-02f, 1.60911381e-01f, 1.38270825e-01f, 3.60800177e-02f, -1.28595168e-02f,
  1.56398609e-01f, 5.33997715e-02f, 6.60252124e-02f, -1.74330398e-02f, -1.71744019e-01f, 6.59465939e-02f, -8.21316689e-02f, -5.88582940e-02f, -4.05968130e-02f, 8.44072849e-02f,
  -2.16577962e-01f, 2.44067028e-01f, -6.81121200e-02f, -7.82086104e-02f, -3.86748612e-02f, 1.31940737e-01f, 3.85598540e-01f, -2.94596136e-01f, 8.79403353e-02f, -1.54719368e-01f,
  -3.08079161e-02f, -6.20757528e-02f, -1.49775401e-01f, -1.32172495e-01f, -9.58703831e-03f, 7.11196959e-02f, -1.95957020e-01f, -5.09978943e-02f, -2.11464003e-01f, 1.33546174e-01f,
  -1.56030789e-01f, -1.26561701e-01f, -2.35875115e-01f, -1.72878921e-01f, 9.82565656e-02f, 1.24783330e-01f, 6.14371523e-02f, 2.01044455e-01f, -4.01537448e-01f, 1.28265098e-01f,
  4.88934033e-02f, 1.05589561e-01f, 1.86795015e-02f, -4.31655757e-02f, 1.50156617e-01f, 3.07350084e-02f, 1.51200348e-03f, -3.10484525e-02f, 1.26044214e-01f, 7.15769380e-02f,
  -2.30793834e-01f, 2.22419843e-01f, 1.88520804e-01f, -4.96435799e-02f, 5.56048527e-02f, 1.59226105e-01f, 1.65221334e-01f, 6.91602454e-02f, 8.85072425e-02f, -9.79630947e-02f,
  1.59645379e-01f, 2.56516755e-01f, 3.01727634e-02f, -2.60309763e-02f, 1.42529219e-01f, 1.71135608e-02f, -1.35135323e-01f, 1.31105981e-03f, 3.53605524e-02f, -7.49823777e-03f,
  -3.75248082e-02f, -1.17960006e-01f, 2.59199500e-01f, 2.14428917e-01f, -2.68313941e-02f, 3.80572788e-02f, 2.23192662e-01f, -1.73195541e-01f, -1.35968626e-01f, 2.66016684e-02f,
  -2.91911453e-01f, -2.48882128e-03f, -2.41826028e-01f, 9.97318625e-02f, 2.50457913e-01f, 1.01068281e-01f, 4.75783609e-02f, -7.50244483e-02f, 6.49033710e-02f, 8.13310444e-02f,
  2.45976308e-03f, -4.21626568e-02f, -2.73876727e-01f, 1.83223393e-02f, 3.49398226e-01f, 1.30137086e-01f, 2.50158124e-02f, 2.71072179e-01f, -2.17216760e-01f, -1.70700625e-01f,
  1.15190268e-01f, 1.67439640e-01f, 8.83992910e-02f, -1.41097158e-01f, 1.00729331e-01f, 1.48290083e-01f, -4.58283313e-02f, -3.11589148e-02f, 3.23144719e-02f, -1.50112454e-02f,
  2.05312058e-01f, 1.22467205e-01f, -2.73857601e-02f, -5.27052730e-02f, -9.59841311e-02f, 1.14592314e-01f, -8.35409388e-02f, 4.67750765e-02f, -1.09117426e-01f, 1.15119249e-01f,
  9.78184417e-02f, 3.15380283e-02f, -1.12976216e-01f, -1.10275485e-02f, -7.69562125e-02f, -1.37526870e-01f, 9.27037224e-02f, 1.48881242e-01f, -1.01585545e-01f, -2.74707172e-02f,
  6.71856385e-03f, 4.41922508e-02f, -1.78776756e-01f, -8.22749436e-02f, 8.81059766e-02f, 1.64654881e-01f, -1.92826360e-01f, 3.24334092e-02f, -9.21298489e-02f, 4.82577384e-02f,
  -1.18426241e-01f, -6.75099762e-03f, 5.52267358e-02f, -8.78177397e-03f, -1.39590055e-02f, -1.66901633e-01f, 3.17094326e-01f, 8.96476507e-02f, -1.50826067e-01f, -6.56746700e-02f,
  2.60629300e-02f, 3.26698297e-03f, -3.18694301e-02f, -9.56714451e-02f, -5.36665209e-02f, -7.57266507e-02f, -1.76812336e-01f, 9.02145170e-03f, -2.24371374e-01f, -4.71631028e-02f,
  3.84769440e-02f, -2.04971254e-01f, 2.66612977e-01f, 1.17605731e-01f, -2.16368407e-01f, -4.33421554e-03f, -3.91192377e-01f, -3.15015055e-02f, 1.29613981e-01f, 1.54741600e-01f,
  -6.16816245e-02f, -7.90212825e-02f, -5.48202842e-02f, 6.20346703e-02f, 1.01119637e-01f, 7.07032457e-02f, 8.42024758e-02f, 1.02895454e-01f, -9.50616300e-02f, 8.27709660e-02f,
  -2.04442754e-01f, 9.00462344e-02f, 2.47093495e-02f, -8.43547434e-02f, 5.96375950e-02f, 1.03446424e-01f, 4.25997190e-02f, 5.14863394e-02f, -8.94078426e-03f, 6.16087243e-02f,
  7.84337074e-02f, 1.56812388e-02f, 1.87148154e-01f, 3.88021201e-01f, -1.75237373e-01f, -6.75381497e-02f, 1.50114968e-01f, -2.11065169e-02f, -2.91576888e-02f, -9.02625546e-02f,
  -2.77613122e-02f, 1.42102659e-01f, 2.78842505e-02f, -2.81408399e-01f, -2.30850428e-02f, 5.08763343e-02f, 1.74438551e-01f, -1.01365738e-01f, 2.18428954e-01f, -3.22196190e-03f,
  1.60310686e-01f, -6.18081242e-02f, -2.39951074e-01f, 2.31066551e-02f, 1.78477675e-01f, 1.45476967e-01f, -8.61557946e-02f, 3.63174342e-02f, 1.61717951e-01f, 1.45372063e-01f,
  -5.18733084e-01f, -1.88382551e-01f, 1.92344069e-01f, 9.09695327e-02f, 1.20378695e-01f, 2.61127688e-02f, -5.61383329e-02f, -2.56572038e-01f, -1.14532774e-02f, 1.16176791e-01f,
  1.56101689e-01f, 1.24325261e-01f, -5.36759458e-02f, 3.35570611e-02f, 7.25229532e-02f, -1.35590911e-01f, -3.55371200e-02f, -9.88057479e-02f, 1.44646481e-01f, 1.71007402e-02f,
  6.75937980e-02f, -1.54299363e-01f, -2.37220138e-01f, 3.48628722e-02f, -5.58762439e-02f, -3.04184034e-02f, 4.77949111e-03f, -5.24656288e-02f, 1.04438581e-01f, -5.77228554e-02f,
  -1.96932107e-01f, 6.49949312e-02f, 7.00667733e-03f, -6.34483546e-02f, -4.85074073e-02f, -2.00634360e-01f, -5.90874664e-02f, 9.83221829e-02f, -1.41952187e-02f, 6.22502007e-02f,
  -5.49495406e-02f, 5.94347082e-02f, -2.29846290e-03f, -8.42340440e-02f, 3.23981158e-02f, 4.05155867e-03f, -7.95891508e-02f, -3.58202159e-02f, -1.97550636e-02f, 3.21576893e-02f,
  7.22665638e-02f, 1.37364432e-01f, 2.72905231e-01f, -2.21142452e-02f, 4.21592295e-02f, 1.26929373e-01f, 2.71995738e-02f, -6.13419637e-02f, 8.24451894e-02f, -9.99575630e-02f,
  1.85652152e-01f, -3.22478935e-02f, 1.04690604e-01f, -1.10150598e-01f, -1.95086837e-01f, -2.06104860e-01f, -2.49609612e-02f, 1.25429496e-01f, -3.15489136e-02f, -3.16554487e-01f,
  1.12815417e-01f, -3.15079875e-02f, 5.46263792e-02f, -3.51707195e-03f, -3.02859962e-01f, 2.85599530e-01f, -2.67758518e-02f, 3.81062068e-02f, -5.24376184e-02f, -5.82335293e-02f,
  -1.36256471e-01f, 6.23241253e-02f, -4.81072478e-02f, 6.00672811e-02f, 3.52972932e-02f, 8.93436074e-02f, 1.37157559e-01f, 6.37961701e-02f, -9.72291976e-02f, 1.08178534e-01f,
  -3.29201259e-02f, 1.03995770e-01f, 2.05290914e-01f, 1.29439142e-02f, 7.71821141e-02f, 3.40597928e-02f, 8.52670074e-02f, 1.59445986e-01f, 6.76897466e-02f, -5.74283190e-02f,
  1.30522335e-02f, 2.75974214e-01f, -3.71348746e-02f, -1.72607630e-01f, 2.45836645e-01f, -9.35847163e-02f, -1.05545372e-01f, -1.57702938e-01f, -1.01637589e-02f, 2.07266688e-01f,
  6.47338554e-02f, -6.67840987e-02f, -1.58838242e-01f, 1.29387572e-01f, -6.42146394e-02f, 6.66480735e-02f, 2.63163805e-01f, 8.24001059e-02f, 1.72542292e-03f, 5.92098273e-02f,
  -7.65044242e-02f, -1.54745933e-02f, 1.19004741e-01f, 8.83423761e-02f, -1.42258078e-01f, -3.38603626e-03f, 2.89977282e-01f, 1.78005695e-02f, -4.22972709e-01f, -7.40450844e-02f,
  2.46668220e-01f, -1.58370629e-01f, 1.41714647e-01f, 7.33525530e-02f, 4.90157865e-02f, -3.16381693e-01f, 2.21794075e-03f, -6.24733083e-02f, 2.96730071e-01f, 2.92050958e-01f,
  -2.40907982e-01f, 8.28359947e-02f, -1.14221508e-02f, 3.30609083e-02f, -7.15591758e-02f, 1.51782960e-01f, -4.10748869e-02f, -6.74043968e-02f, -4.77693900e-02f, 2.53398232e-02f,
  1.18419543e-01f, -5.89127373e-03f, 3.65125760e-02f, 2.39371303e-02f, 1.02067351e-01f, 2.18059063e-01f, 1.23315774e-01f, -4.89369556e-02f, 6.20706901e-02f, 4.43703458e-02f,
  -9.62533709e-03f, -4.18587849e-02f, -1.51950225e-01f, -3.25153442e-03f, 1.40778795e-01f, 8.06834102e-02f, 2.87485998e-02f, 4.88032699e-02f, 5.77215627e-02f, 3.25972997e-02f,
  2.54386310e-02f, 1.86370969e-01f, -2.40888849e-01f, -1.04161344e-01f, 2.47726023e-01f, -1.91118777e-01f, -1.91630349e-01f, 3.01652551e-01f, 4.70583187e-03f, -2.01060906e-01f,
  -5.35722896e-02f, 8.80204290e-02f, 1.24531388e-01f, 4.67000306e-02f, -1.72049195e-01f, -2.05688998e-01f, -1.11183748e-01f, 2.54777893e-02f, 1.94399849e-01f, -1.67263314e-01f,
  2.37710834e-01f, 8.12290758e-02f, 4.21613604e-02f, 8.31097830e-03f, 1.66606531e-01f, 1.73129097e-01f, 9.43301618e-02f, 3.56699765e-01f, -1.41760424e-01f, 1.54927569e-02f,
  1.23646017e-02f, 2.91445166e-01f, 2.88192332e-01f, -2.81850845e-01f, 1.31576270e-01f, 5.49653210e-02f, 1.02058090e-01f, -1.06573086e-02f, -7.95125291e-02f, -1.02069296e-01f,
  -1.75891533e-01f, 1.37976538e-02f, -3.30413915e-02f, -5.42965308e-02f, 1.82088569e-01f, 1.23689048e-01f, 5.01343682e-02f, 6.65133074e-02f, -1.17957227e-01f, -1.89695740e-04f,
  -9.42981616e-02f, 4.71891239e-02f, 1.08566783e-01f, 1.81836204e-03f, 6.09566830e-02f, 2.85678748e-02f, -1.51957190e-02f, 9.04089361e-02f, -2.16133401e-01f, -3.01208179e-02f,
  -6.00837469e-02f, 3.66120227e-02f, -5.11578843e-02f, 1.66719198e-01f, -1.80637240e-01f, 1.69676915e-01f, -9.72788632e-02f, -1.27161071e-01f, 1.21957332e-01f, 6.60719201e-02f,
  3.94829139e-02f, 1.27323717e-01f, -1.51868314e-01f, -4.03494611e-02f, -1.69455260e-01f, 2.97952294e-01f, -1.12652123e-01f, 1.44406110e-01f, 1.05413727e-01f, -1.94383366e-03f,
  -6.66120835e-03f, -8.79980326e-02f, 2.57990181e-01f, -3.32657737e-03f, 1.53884962e-01f, -1.85150676e-03f, 3.75062883e-01f, -5.12603633e-02f, 2.27214806e-02f, -1.38910994e-01f,
  2.64107846e-02f, 2.94500440e-01f, -1.56858638e-02f, 1.54397085e-01f, -9.84779671e-02f, 9.95482355e-02f, 4.91276011e-02f, -5.73156634e-03f, -1.47067055e-01f, -2.12174430e-02f,
  -9.61388573e-02f, 1.05950683e-02f, -2.12441031e-02f, -1.00174718e-01f, -1.23897806e-01f, -4.34755087e-02f, -1.73133966e-02f, -2.03646645e-02f, 1.10871620e-01f, 1.69945341e-02f,
  7.90285133e-03f, -1.74217582e-01f, -4.61832136e-02f, -7.42271990e-02f, 8.82393196e-02f, 1.61861673e-01f, 4.57720868e-02f, -1.88751109e-02f, -4.74831127e-02f, 5.67232678e-03f,
  -1.03527941e-01f, 3.20460275e-02f, 5.75349890e-02f, 5.55306822e-02f, 2.39577834e-02f, 1.74126513e-02f, 1.43314138e-01f, -3.87517875e-03f, 8.06136243e-03f, 8.11061412e-02f,
  2.35661003e-03f, -4.47877310e-02f, -1.01068094e-01f, -6.06976897e-02f, -5.28197624e-02f, -6.19639046e-02f, 1.35809317e-01f, 2.67199185e-02f, -1.39518276e-01f, -4.69610803e-02f,
  6.21939413e-02f, -5.93763553e-02f, -1.44752219e-01f, 8.63251314e-02f, 1.91590130e-01f, 8.42617601e-02f, -2.40308091e-01f, 1.39236420e-01f, 9.78325605e-02f, 1.26972860e-02f,
  -8.91154706e-02f, 1.02900267e-01f, 2.18580842e-01f, -1.15265325e-02f, 1.60088822e-01f, 1.33996621e-01f, -8.64566788e-02f, 5.78280278e-02f, -1.34134993e-01f, 2.95851994e-02f,
  2.24122301e-01f, -2.72784859e-01f, -6.66197250e-03f, 3.14504132e-02f, -1.35937914e-01f, -1.59407295e-02f, 1.18478768e-01f, -2.93120556e-03f, -8.18429887e-02f, 6.19770847e-02f,
  -4.19986323e-02f, 8.20591953e-03f, -6.64486885e-02f, 1.08239479e-01f, 6.84184283e-02f, 1.61824152e-02f, 3.26846503e-02f, 6.52206168e-02f, -5.28400578e-02f, -1.50865570e-01f,
  -1.54202254e-02f, -1.16745736e-02f, -5.30806705e-02f, 8.32374115e-03f, 1.07515834e-01f, -7.64918625e-02f, -4.91083600e-02f, -1.49585024e-01f, -1.06979914e-01f, -2.65355892e-02f,
  -2.01369360e-01f, 7.18215182e-02f, -1.22901350e-01f, -1.08050913e-01f, 6.79991618e-02f, 1.08836509e-01f, 1.48514211e-01f, 2.91667640e-01f, 1.40568137e-01f, -3.33689153e-02f,
  -1.75135404e-01f, -1.62744746e-01f, -1.51790224e-03f, 1.18559457e-01f, -1.49956957e-01f, 8.95261392e-02f, 2.94917315e-01f, 6.79042786e-02f, -1.81566864e-01f, -1.95118546e-01f,
  2.19876945e-01f, -1.04140557e-01f, 2.39201412e-02f, -4.43732053e-01f, -1.53400257e-01f, -7.27147758e-02f, -2.89173514e-01f, -1.35840133e-01f, -1.53761148e-01f, 1.69742912e-01f,
  4.38729674e-03f, -1.06982533e-02f, 8.61804038e-02f, 3.08266908e-01f, -3.86621542e-02f, 3.95209044e-02f, 8.15098062e-02f, -1.02905966e-01f, -3.76307480e-02f, 4.21596952e-02f,
  5.40698804e-02f, -1.19703680e-01f, -1.74123496e-01f, -8.41253921e-02f, 1.13100275e-01f, -7.97909647e-02f, 1.70576766e-01f, 3.35424207e-02f, -9.29287151e-02f, 9.00820494e-02f,
  -2.71242801e-02f, 8.72575119e-02f, -2.67255176e-02f, -5.13910241e-02f, 1.20307110e-01f, 3.58621664e-02f, 1.41071364e-01f, 2.98470818e-02f, -1.15583830e-01f, -9.09322724e-02f,
  4.43779454e-02f, -1.49579331e-01f, 2.01194495e-01f, 1.13906227e-01f, -2.21147966e-02f, 1.42191797e-01f, 6.45794496e-02f, 7.40556195e-02f, 7.20346421e-02f, 1.19784564e-01f,
  5.50957769e-03f, 1.28641486e-01f, -4.28797118e-03f, 1.63841516e-01f, -5.72474226e-02f, -3.27274576e-02f, 1.62524119e-01f, -1.61160678e-02f, 3.00188307e-02f, 5.98787144e-03f,
  1.67994991e-01f, 6.30053750e-04f, -1.50554299e-01f, -2.18135878e-01f, -1.05321575e-02f, -8.78674164e-02f, 2.20933452e-01f, 9.27550718e-02f, 2.99062189e-02f, -1.89529348e-03f,
  1.11162134e-01f, 3.87294218e-02f, 3.85356881e-02f, -1.12254329e-01f, -6.40108138e-02f, 2.48806074e-01f, -2.38335997e-01f, 4.04914200e-01f, -8.22534487e-02f, -5.84456809e-02f,
  1.84602857e-01f, 1.70056835e-01f, -4.15782109e-02f, 2.31399909e-02f, 5.69326989e-02f, -1.52462378e-01f, 1.56847209e-01f, 1.27687648e-01f, -4.82765352e-03f, -5.54751679e-02f,
  -1.33390516e-01f, 9.29747745e-02f, 3.63186351e-03f, 2.14180816e-02f, 7.94825405e-02f, -2.95995567e-02f, -7.50731910e-03f, 1.50637537e-01f, -8.94159228e-02f, -3.77102159e-02f,
  1.37171045e-01f, 2.20380589e-01f, -2.96313707e-02f, 4.65946682e-02f, -5.75813055e-02f, -1.17467962e-01f, 1.46025524e-01f, 4.05631447e-03f, -5.27311787e-02f, 4.71041240e-02f,
  7.13317841e-02f, 9.37555358e-02f, 1.83086067e-01f, -2.59665083e-02f, 5.94634749e-02f, 3.59444261e-01f, -6.88373223e-02f, -9.07094404e-03f, -6.92280009e-02f, -8.28953460e-02f,
  -9.41947997e-02f, -6.23083115e-02f, -2.82030320e-03f, 3.06444094e-02f, 2.32662395e-01f, 7.47212246e-02f, 1.74422981e-03f, -1.11270629e-01f, -9.74029079e-02f, -6.94849864e-02f,
  -5.92321716e-02f, -2.29257420e-01f, -4.78792451e-02f, -9.61002079e-04f, -7.19496980e-02f, -1.10760160e-01f, -7.22314417e-02f, 8.94931704e-02f, -2.66647726e-01f, 1.42476097e-01f,
  8.07202980e-02f, 3.00798923e-01f, -1.53125878e-02f, -3.42319071e-01f, 7.76582062e-02f, -7.23099560e-02f, 2.55993232e-02f, -4.88627069e-02f, -9.25427601e-02f, 1.68859154e-01f,
  -6.14567697e-02f, 1.24409191e-01f, 1.83577821e-01f, 2.38655567e-01f, 2.81515181e-01f, 4.36333753e-02f, 1.34928897e-01f, -1.88036382e-01f, -8.99835303e-02f, 1.55383885e-01f,
  1.59048319e-01f, 3.78335193e-02f, -5.91309965e-02f, -6.57657459e-02f, 6.73983991e-02f, 6.32494241e-02f, -2.74993517e-02f, -8.02284032e-02f, 1.49411693e-01f, 1.18185900e-01f,
  -9.88953486e-02f, 6.45780116e-02f, 1.35110483e-01f, -4.75957207e-02f, -5.73779233e-02f, 1.08472183e-01f, -1.03262700e-02f, 8.48942436e-03f, -1.29853696e-01f, -4.24459130e-01f,
  -2.36276001e-01f, 1.06559815e-02f, 2.20763851e-02f, 3.74290384e-02f, 1.96890384e-01f, -1.25819087e-01f, -1.05121955e-01f, -3.00157577e-01f, -1.66741416e-01f, 3.51287723e-02f,
  1.71942547e-01f, 2.99044739e-04f, -1.38585180e-01f, -4.98822257e-02f, -9.63297635e-02f, 4.07517672e-01f, -1.02051251e-01f, 3.58352333e-01f, 1.82716370e-01f, -1.43482283e-01f,
  -9.38240439e-03f, -7.09175095e-02f, -1.03597715e-01f, -9.31279808e-02f, 5.49699785e-03f, -8.78467336e-02f, 1.01516552e-01f, 1.97154686e-01f, 5.77029921e-02f, 7.87931234e-02f,
  1.02337375e-01f, 1.11229613e-01f, 5.07954620e-02f, 7.68896863e-02f, 3.79477292e-02f, 2.31395990e-01f, 1.45172834e-01f, 9.06089395e-02f, 2.82265302e-02f, 2.41850033e-01f,
  1.63482457e-01f, -6.80168197e-02f, -1.06368728e-01f, -1.97457690e-02f, -1.79856196e-02f, 7.11750761e-02f, 1.05085492e-01f, 7.11499080e-02f, -4.45462912e-02f, 1.22295916e-01f,
  2.71516927e-02f, -8.30447823e-02f, -1.68572459e-02f, -3.19429010e-01f, -8.23559985e-02f, -1.29437505e-03f, -2.07680121e-01f, 5.48057742e-02f, -8.66061524e-02f, 3.77157927e-02f,
  1.54615059e-01f, -1.74415018e-02f, -5.78093305e-02f, 2.57767498e-01f, 1.15289867e-01f, -2.11452961e-01f, 6.62705898e-02f, 6.76868409e-02f, -2.46486410e-01f, 1.64769799e-01f,
  -2.01339483e-01f, -6.64266348e-02f, 1.31254032e-01f, 2.45770335e-01f, -7.34534021e-03f, 1.54075548e-01f, -4.32447856e-03f, 4.91314344e-02f, -3.07369739e-01f, -1.12080507e-01f,
  4.05519038e-01f, 1.41265467e-01f, -9.09484401e-02f, -7.83302933e-02f, -1.95519760e-01f, -3.63876760e-01f, 6.87170075e-04f, 2.21394062e-01f, 1.43920397e-02f, -1.36414737e-01f,
  -1.78800419e-01f, 2.89549023e-01f, 3.10105253e-02f, 4.51659895e-02f, -6.52392358e-02f, 7.77051970e-02f, 7.02884048e-02f, -2.19578147e-01f, -1.19752968e-02f, 7.45539740e-02f,
  -8.21066499e-02f, -1.18000552e-01f, -5.12082539e-02f, 1.74655784e-02f, 1.16126627e-01f, 6.58756644e-02f, 8.46628770e-02f, 2.17890203e-01f, 9.90254432e-02f, -6.70422688e-02f,
  -1.23079218e-01f, -1.59055106e-02f, -9.75107327e-02f, 6.44155294e-02f, 1.80685356e-01f, -1.46285910e-02f, -1.08941682e-01f, 5.33245243e-02f, 2.38379344e-01f, 8.75230581e-02f,
  -7.31731877e-02f, 5.04017100e-02f, 1.47153046e-02f, 4.01323102e-02f, -4.53404225e-02f, 2.13395968e-01f, -9.20834206e-03f, 2.39196569e-01f, -1.22526892e-01f, 7.55571052e-02f,
  -1.60670370e-01f, -2.44594906e-02f, 4.23422158e-01f, 8.79860595e-02f, -9.98581797e-02f, -5.05008909e-04f, 2.17984021e-01f, -1.01547122e-01f, -2.35186309e-01f, -4.06130664e-02f,
  2.69048482e-01f, -1.91676952e-02f, -9.94416773e-02f, 1.11073256e-01f, 1.15896903e-01f, 7.93091580e-02f, -5.56833409e-02f, -8.51098374e-02f, -2.43331447e-01f, 6.97453618e-02f,
  9.98463482e-02f, 2.83294410e-01f, 5.19614145e-02f, 2.58178890e-01f, -9.38037857e-02f, 1.33065507e-01f, 2.07017794e-01f, 8.92697740e-03f, -1.03973962e-01f, -6.44214377e-02f,
  4.45224307e-02f, 5.54962829e-02f, -2.04125628e-01f, 4.39950526e-02f, 3.52183841e-02f, 2.17614975e-02f, -1.27693396e-02f, 1.02086194e-01f, 1.87037945e-01f, 2.24233251e-02f,
  8.59460309e-02f, 2.06919357e-01f, 1.09540083e-01f, 5.80897108e-02f, 1.67382434e-02f, 3.82225551e-02f, 7.61821344e-02f, 1.40414596e-01f, -7.68237421e-03f, 4.36640643e-02f,
  -5.44657409e-02f, 5.42248376e-02f, 4.03231606e-02f, 8.57054517e-02f, 1.28152966e-01f, -1.17593095e-01f, 8.68393406e-02f, -1.26409248e-01f, -7.70568177e-02f, 2.89447047e-02f,
  -2.45469417e-02f, -3.36684361e-02f, -2.50497162e-01f, 3.62994745e-02f, 1.04376495e-01f, -1.87855676e-01f, -1.47603713e-02f, 1.36825249e-01f, -1.84438214e-01f, -1.77611813e-01f,
  -6.73023537e-02f, -6.72230218e-03f, 2.84728762e-02f, -1.59783885e-01f, -7.09668100e-02f, 1.54707938e-01f, -2.34349504e-01f, 2.11661950e-01f, -1.56850308e-01f, 3.35817546e-01f,
  1.77014738e-01f, -3.08466703e-02f, -9.73863676e-02f, 1.73275873e-01f, -1.87392607e-01f, -6.33713230e-02f, -8.19007084e-02f, 1.69909727e-02f, 1.67726964e-01f, -1.09810978e-01f,
  1.20517537e-02f, 1.01884529e-01f, 1.98055916e-02f, 2.67870277e-01f, 1.52417958e-01f, -3.23219858e-02f, 2.36184865e-01f, 4.80909497e-02f, -1.00067280e-01f, 2.12577373e-01f,
  -1.35378048e-01f, 9.64391828e-02f, -5.32660447e-03f, -5.82560264e-02f, -9.96604934e-02f, -3.76697779e-02f, 7.99439773e-02f, 1.61710694e-01f, 8.67552981e-02f, 1.07961014e-01f,
  -5.23363203e-02f, -3.15782167e-02f, -1.19568080e-01f, -1.60608724e-01f, 8.36461335e-02f, 3.42410117e-01f, -7.62815028e-02f, 1.72148988e-01f, 6.13376833e-02f, -2.74099782e-02f,
  -1.59286037e-01f, -1.04499474e-01f, 3.79656345e-01f, 2.99987108e-01f, -2.75408298e-01f, 1.56033030e-02f, 1.43357217e-01f, -2.21479386e-01f, 6.58612326e-02f, 1.10421762e-01f,
  -1.54237270e-01f, -2.44499281e-01f, -4.30729352e-02f, -1.21632293e-02f, 1.67267755e-01f, 2.26101279e-01f, 1.99078918e-01f, 2.98688207e-02f, -9.83770639e-02f, -2.12788910e-01f,
  2.36714840e-01f, -1.60495758e-01f, -1.24947362e-01f, 1.39645897e-02f, 2.74448633e-01f, 1.10368289e-01f, 1.23695366e-01f, 9.80149135e-02f, -2.16541082e-01f, -2.42663637e-01f,
  2.97372431e-01f, 4.40509729e-02f, 2.48612836e-01f, 7.57815689e-02f, -9.15155634e-02f, 4.09360416e-02f, -1.31003633e-01f, -6.82526007e-02f, -6.15704767e-02f, 5.30146174e-02f,
  -1.05830833e-01f, -4.56491625e-03f, 1.36507198e-01f, 1.23898692e-01f, 2.01228648e-01f, 2.29664072e-02f, -5.41189201e-02f, -7.42114782e-02f, 5.45954332e-02f, 2.40818754e-01f,
  -2.75075417e-02f, -1.43846139e-01f, 9.78390202e-02f, 9.36862007e-02f, 3.45817134e-02f, -1.98862907e-02f, -5.44124395e-02f, -1.48615450e-01f, 5.02170920e-02f, 4.66965623e-02f,
  -1.53217148e-02f, -1.63640261e-01f, 9.38428044e-02f, -1.33297250e-01f, 4.64093275e-02f, -8.97517353e-02f, -2.90411890e-01f, 7.42371753e-02f, -5.13694854e-03f, -1.64837301e-01f,
  -1.82426155e-01f, -5.02208471e-02f, -3.01764850e-02f, 9.28306282e-02f, 2.53020912e-01f, -1.50488093e-01f, -1.59067184e-01f, -1.04923129e-01f, -1.65115237e-01f, -2.43628267e-02f,
  7.33455941e-02f, 1.23733237e-01f, -1.19911417e-01f, -6.10295162e-02f, -1.70063764e-01f, 3.52238923e-01f, 5.06333113e-01f, 3.02733272e-01f, 1.31193250e-01f, 1.22421525e-01f,
  2.12454777e-02f, -1.41575664e-01f, 1.03034809e-01f, -2.17540935e-01f, -2.17481300e-01f, -2.12567717e-01f, 1.90833267e-02f, 2.87571549e-01f, -6.57429621e-02f, -7.31907785e-02f,
  -8.97286609e-02f, -1.17668889e-01f, -6.98428005e-02f, -5.74570335e-02f, -2.88633138e-01f, -2.02428132e-01f, -1.61269382e-01f, 3.43728513e-02f, 4.57872301e-02f, -2.09924355e-02f,
  -5.38394153e-02f, -1.58751681e-02f, -1.34844601e-01f, -8.97849798e-02f, 2.81214155e-02f, 1.01276129e-01f, 1.38091967e-01f, 1.25567913e-01f, -5.93493506e-02f, -1.28591686e-01f,
  -1.09130247e-02f, -9.83352214e-02f, -2.25032315e-01f, -1.14419602e-01f, -1.32669210e-01f, -4.29057665e-02f, -1.18050225e-01f, -4.34195846e-02f, 1.12437792e-01f, -9.79058221e-02f,
  6.33230358e-02f, 5.72885126e-02f, 1.55198470e-01f, 1.99157596e-01f, 1.38702020e-01f, 3.21417153e-02f, -1.07885554e-01f, -9.28864479e-02f, -3.08378100e-01f, 3.22452709e-02f,
  -8.38767514e-02f, 1.44752756e-01f, 1.06544182e-01f, 2.76365638e-01f, 6.11077435e-02f, 6.42770082e-02f, -2.69766841e-02f, 1.07041702e-01f, 2.21674860e-01f, -1.13427892e-01f,
  -1.16545573e-01f, -3.14129084e-01f, -1.34798199e-01f, 1.95008963e-01f, 1.57665625e-01f, 2.02818383e-02f, -1.42777026e-01f, 8.31596628e-02f, -7.35200047e-02f, -2.75588870e-01f,
  1.93419650e-01f, 5.39520755e-02f, -3.84622552e-02f, -1.20680563e-01f, -4.20292504e-02f, -1.17136613e-02f, 6.21032491e-02f, 1.44667581e-01f, -7.46817738e-02f, 2.35856771e-01f,
  4.81175072e-03f, -5.91282174e-02f, -7.53526241e-02f, 1.10359266e-01f, -2.90768705e-02f, 8.98731465e-04f, 9.35804769e-02f, -5.28485626e-02f, 8.26648325e-02f, -6.08341731e-02f,
  -1.64434575e-02f, -6.22877926e-02f, -1.86871827e-01f, -1.25421397e-02f, 1.60902087e-02f, -6.27561435e-02f, 9.76633877e-02f, -1.77897021e-01f, 1.05878212e-01f, -1.28813475e-01f,
  -8.38586167e-02f, 6.01140670e-02f, 2.12683454e-02f, -1.34889960e-01f, -1.96142465e-01f, 7.52927661e-02f, 3.98374535e-02f, 2.10511282e-01f, -2.20874295e-01f, -1.10095024e-01f,
  -1.57827663e-03f, -3.04409843e-02f, 3.02318990e-01f, -1.47676751e-01f, -4.26344723e-02f, -8.78775269e-02f, 1.30522475e-01f, -1.29103987e-02f, -1.21582814e-01f, 1.39320027e-02f,
  -2.83152633e-03f, -1.05166361e-01f, -2.75794715e-01f, 5.87403178e-02f, 7.77562186e-02f, 7.81737342e-02f, -3.26782554e-01f, 5.97991981e-02f, -2.38123924e-01f, -2.41193414e-01f,
  6.15553968e-02f, 1.15170017e-01f, 1.56947508e-01f, -2.14075167e-02f, -3.90398771e-01f, 2.35660374e-01f, 1.67766120e-02f, -1.52943563e-02f, 9.45432261e-02f, -8.49607363e-02f,
  -2.76539512e-02f, -4.53501046e-02f, 7.13979229e-02f, -9.24969912e-02f, -7.09053949e-02f, 2.80478634e-02f, 1.88520283e-01f, 1.05168879e-01f, 1.89104564e-02f, -1.47305951e-02f,
  -1.18148886e-01f, -5.66148721e-02f, -4.82929423e-02f, 4.39153798e-02f, 4.17529643e-02f, -1.22160636e-01f, -4.27005701e-02f, -1.62814900e-01f, -7.73510411e-02f, -4.20078635e-02f,
  -7.09208474e-02f, -1.90391794e-01f, -6.49244413e-02f, 6.13281578e-02f, 1.88223757e-02f, -8.97834077e-02f, -4.72302176e-02f, -3.86762843e-02f, -9.44508314e-02f, -4.30268608e-02f,
  -1.59857795e-01f, -1.98688768e-02f, 7.45112821e-02f, -8.39485675e-02f, -2.88511384e-02f, 1.85503513e-01f, -2.88005650e-01f, -7.24010319e-02f, -3.47752422e-02f, 9.72264446e-04f,
  -1.82949454e-02f, 1.24505281e-01f, 7.07681552e-02f, -4.01720442e-02f, 1.44847691e-01f, -5.34030497e-02f, -1.52437001e-01f, 1.27562117e-02f, 4.22321796e-01f, -5.70724793e-02f,
  1.15703873e-01f, 1.10626288e-01f, 3.14454943e-01f, 7.07879886e-02f, -1.41034592e-02f, 7.72004500e-02f, -1.07568480e-01f, -6.64340109e-02f, -1.05007164e-01f, 1.44013413e-03f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -2.15262100e-02f, 2.04273432e-01f, 3.08391564e-02f, -6.43268228e-02f, -3.11536379e-02f, -3.98302972e-02f, -1.57438293e-02f, 2.06317067e-01f, -4.57169954e-03f, -2.15345919e-02f,
  8.22365507e-02f, -2.96012163e-02f, 2.55774826e-01f, 7.05530420e-02f, 1.62162334e-01f, -2.64174007e-02f, -2.02042554e-02f, 6.98329583e-02f, 3.94200459e-02f, 7.29791373e-02f,
  6.95733679e-03f, 1.70337930e-01f, 7.91114047e-02f, 2.08253227e-02f, -1.15209632e-01f, -1.32455990e-01f, 2.67169159e-02f, 2.77184155e-02f, 8.85218382e-03f, 1.91640537e-02f,
  -9.10924152e-02f, -6.39925227e-02f, -3.07195067e-01f, -1.09212369e-01f, 1.47747062e-02f, -1.11979127e-01f, -4.91054207e-02f, 6.67640865e-02f, -1.45648662e-02f, -2.95316167e-02f,
  -6.15561865e-02f, 1.87211201e-01f, 5.65554574e-02f, -2.49812985e-03f, -1.30776718e-01f, -1.80073321e-01f, -1.33556098e-01f, -1.21939726e-01f, 1.35366628e-02f, 1.12589449e-01f,
  -2.82400399e-01f, 2.14467734e-01f, -8.19637161e-03f, 3.54707181e-01f, 1.43821523e-01f, -1.19713619e-01f, -7.31502026e-02f, 1.19852789e-01f, -7.65198702e-03f, 4.30903733e-01f,
  -3.63270760e-01f, 1.86146632e-01f, 6.12740219e-02f, -1.53620318e-01f, 4.40091081e-02f, 1.79112907e-02f, 4.42106090e-02f, -2.89019141e-02f, -1.52615877e-02f, 1.42913917e-02f,
  -4.98397648e-02f, -1.37352021e-02f, -5.38815632e-02f, 1.09723635e-01f, 2.75138408e-01f, -5.38388379e-02f, 8.25917125e-02f, 4.25790437e-02f, 2.12675139e-01f, 5.74853458e-02f,
  1.81533620e-02f, -1.01670541e-01f, 2.51025259e-02f, 1.41213834e-01f, 5.10088727e-02f, 2.03496777e-02f, 1.55160353e-01f, 3.54728848e-02f, -1.30480692e-01f, -1.31865174e-01f,
  1.74484700e-01f, -9.65004489e-02f, 8.20981935e-02f, -1.32059485e-01f, -1.45219490e-01f, -1.65782452e-01f, -2.18827263e-01f, -2.42791581e-03f, 7.54125565e-02f, 5.35617545e-02f,
  -1.08106442e-01f, 4.17468548e-02f, 6.83631897e-02f, 2.89235543e-02f, -3.50417309e-02f, 4.80179414e-02f, 6.24728948e-02f, -1.03994668e-01f, 2.27980930e-02f, 5.60556576e-02f,
  -2.23730430e-01f, 9.26727150e-03f, 1.41103014e-01f, -3.59470434e-02f, -1.04528062e-01f, 1.77487120e-01f, 6.03097498e-01f, 1.94184333e-01f, -4.81286347e-02f, 6.98192269e-02f,
  4.61355112e-02f, 5.37796356e-02f, -1.06759056e-01f, 1.39029529e-02f, 1.71606854e-01f, -2.62940433e-02f, 8.34018216e-02f, -1.71292335e-01f, 1.76551327e-01f, 9.79755446e-02f,
  1.39758080e-01f, 7.96319619e-02f, 4.45938706e-02f, 6.38554767e-02f, 8.06931481e-02f, 3.73747535e-02f, 1.35497987e-01f, -3.93389165e-02f, 9.04687271e-02f, 1.24303669e-01f,
  -1.96620785e-02f, -1.33665325e-03f, -1.63772836e-01f, -1.69161156e-01f, -2.25768741e-02f, -7.76133453e-03f, 6.59875497e-02f, 8.16893056e-02f, 1.04387917e-01f, 3.88560742e-02f,
  -7.16840401e-02f, -5.27948104e-02f, -9.46019292e-02f, 1.29173234e-01f, 9.97489691e-02f, 1.40848905e-01f, -9.61356312e-02f, -7.19926879e-02f, -2.05056101e-01f, 1.98648907e-02f,
  -1.87259763e-02f, 2.65415549e-01f, -5.74475303e-02f, 2.67253816e-01f, 6.22636676e-02f, -8.66606459e-02f, -8.30500424e-02f, 1.24806881e-01f, 1.93878815e-01f, -1.86208144e-01f,
  4.16860357e-02f, 8.27991292e-02f, 5.31214923e-02f, 1.26038820e-01f, 2.65559077e-01f, 9.39101353e-02f, 4.64022271e-02f, -6.66503534e-02f, -2.24781066e-01f, -2.62675017e-01f,
  7.13122040e-02f, -1.77969158e-01f, -1.70568470e-02f, 9.39052254e-02f, 3.26179937e-02f, -2.82872319e-01f, 6.82126805e-02f, -2.25587755e-01f, -1.35728210e-01f, -2.56975830e-01f,
  -4.74228680e-01f, 2.55309194e-01f, -2.56309479e-01f, -1.14757910e-01f, 6.99813962e-02f, -7.94987753e-02f, -4.93556336e-02f, -8.26370344e-02f, 1.77763984e-01f, -2.27777045e-02f,
  3.09937783e-02f, -1.27100572e-01f, 2.25757152e-01f, 1.82935111e-02f, -7.11873360e-03f, -4.26329859e-02f, 1.10151209e-02f, 2.03864247e-01f, 4.33202498e-02f, -1.98142305e-02f,
  2.51879226e-02f, 1.02779195e-01f, 2.65986696e-02f, 8.09352919e-02f, -1.33557677e-01f, 6.48140535e-02f, 2.52093207e-02f, 1.80467382e-01f, 8.12857151e-02f, -3.08621317e-01f,
  2.30867982e-01f, 1.16096206e-01f, -9.05819386e-02f, -2.91651070e-01f, -1.12252042e-01f, 1.42245656e-02f, -1.93543825e-02f, -5.83743304e-02f, -1.58661097e-01f, 6.51623607e-02f,
  -2.56281734e-01f, 6.54271170e-02f, 1.92810431e-01f, -1.88186802e-02f, 1.70719713e-01f, -8.33198503e-02f, -7.67643154e-02f, -6.64339438e-02f, -9.59926620e-02f, 1.86800092e-01f,
  -6.86268462e-03f, -3.18542898e-01f, 6.67704344e-02f, 5.53830387e-03f, 1.87151000e-01f, -2.35165194e-01f, -1.51663572e-01f, 7.26052979e-03f, -2.33499065e-01f, 7.93236569e-02f,
  2.65521884e-01f, -2.67590195e-01f, 1.70605510e-01f, 1.07570089e-01f, 2.12169707e-01f, 1.86867833e-01f, 8.71393457e-02f, 1.52768850e-01f, -1.30624250e-02f, -1.11864939e-01f,
  3.08527872e-02f, -8.77870098e-02f, 5.56125194e-02f, 6.74309433e-02f, -3.53060029e-02f, 1.01404831e-01f, -1.13552421e-01f, 1.39870763e-01f, 1.21970393e-01f, 1.37761995e-01f,
  1.77751407e-01f, 1.67479083e-01f, -5.40114846e-03f, -6.67464081e-03f, 9.59563106e-02f, -5.40128257e-03f, -7.77324513e-02f, 1.24646099e-02f, -5.01212403e-02f, 5.09737097e-02f,
  -2.12246180e-02f, 8.49548727e-03f, -6.31197393e-02f, 7.34056830e-02f, 1.42192453e-01f, 1.17412843e-01f, 9.03391540e-02f, -9.50522497e-02f, -1.37875408e-01f, 1.21618666e-01f,
  -1.22878723e-01f, 2.04275399e-01f, 1.81717947e-02f, 4.42399643e-02f, -6.24960624e-02f, 5.21586500e-02f, 1.67562187e-01f, 7.97573626e-02f, -1.76548541e-01f, 1.68694168e-01f,
  1.51459411e-01f, 2.08998434e-02f, -5.70514500e-02f, -4.41370206e-03f, 3.82000320e-02f, 9.32718143e-02f, 9.67087820e-02f, 1.03884913e-01f, 2.18865335e-01f, 1.83843091e-01f,
  1.45460948e-01f, -8.45306814e-02f, 2.78321803e-01f, 2.35084817e-01f, -2.63143837e-01f, 8.26368853e-02f, 5.19669913e-02f, 1.38617992e-01f, -5.62085323e-02f, 2.47297153e-01f,
  1.38110891e-02f, 2.00858578e-01f, 1.02514727e-02f, 1.46911070e-01f, 1.81640595e-01f, 1.76532567e-01f, 3.02417278e-01f, 1.15122288e-01f, -8.71017873e-02f, 4.33377028e-02f,
  1.74480379e-01f, 2.43573204e-01f, -1.25000268e-01f, 1.09844729e-01f, 1.76536456e-01f, 3.20629984e-01f, -1.34082764e-01f, 1.66326985e-01f, -1.33572519e-01f, 2.47705758e-01f,
  1.31860271e-01f, -7.84520954e-02f, 3.48112434e-02f, 2.08294198e-01f, 1.97776910e-02f, -8.99500027e-02f, 1.41963184e-01f, 1.78476289e-01f, -3.02436352e-01f, 2.11752713e-01f,
  1.26388520e-01f, 1.37301181e-02f, -8.18333179e-02f, -1.37475491e-01f, 9.42910649e-03f, 2.06229165e-01f, 1.01462165e-02f, 8.00331216e-03f, -1.37483329e-01f, -7.28728399e-02f,
  1.93008527e-01f, 8.36964324e-02f, 2.22375765e-01f, 2.86380708e-01f, -1.33678773e-02f, -9.35381949e-02f, -2.79744029e-01f, 4.28756513e-02f, 1.76021963e-01f, -1.89964280e-01f,
  -3.30123529e-02f, -3.35536189e-02f, 5.22921801e-01f, -9.56033468e-02f, -2.51532316e-01f, -1.65328309e-01f, -2.84065634e-01f, -1.32464871e-01f, 3.31952423e-01f, 3.40044111e-01f,
  -1.74461812e-01f, 3.07090014e-01f, -4.19432968e-01f, -7.94825554e-02f, -1.15877450e-01f, -5.34607396e-02f, 2.36369416e-01f, 6.04665205e-02f, 8.20814297e-02f, 3.31160985e-02f,
  2.00429320e-01f, 1.14015497e-01f, 1.08087018e-01f, 1.32737374e-02f, 3.52853179e-01f, 1.39185071e-01f, 2.32426394e-02f, 1.96715333e-02f, 8.19841176e-02f, 2.10750960e-02f,
  1.15065724e-02f, 5.99137449e-04f, 9.51002911e-02f, -3.12720463e-02f, 7.44904876e-02f, -1.80496544e-01f, 1.58138238e-02f, -7.30680348e-03f, 1.46216154e-01f, 4.53507081e-02f,
  4.01805863e-02f, -1.98990405e-02f, 1.74251840e-01f, 7.05421939e-02f, -7.31325671e-02f, 3.70061696e-02f, 7.92226288e-03f, -1.66830450e-01f, 7.87796602e-02f, -2.52792299e-01f,
  -8.65630507e-02f, 4.38223854e-02f, 1.61692664e-01f, -3.07158791e-02f, 1.73486203e-01f, -2.15447649e-01f, 1.81689262e-01f, -2.26854712e-01f, -4.09345686e-01f, -1.62107304e-01f,
  2.55253553e-01f, 2.42032319e-01f, -1.19250968e-01f, -8.10184181e-02f, 1.97713892e-03f, -1.38216883e-01f, 1.45721287e-01f, -1.09521382e-01f, 1.84406176e-01f, 1.69230178e-01f,
  -2.58982349e-02f, -1.52600622e-02f, 1.46298409e-01f, -4.94147539e-01f, -2.77497321e-01f, -4.35298204e-01f, 8.74356031e-02f, 4.72492771e-03f, -5.41417785e-02f, -4.50686105e-02f,
  7.34697506e-02f, -8.11511055e-02f, 9.10535604e-02f, -1.25890866e-01f, 2.76260171e-02f, 8.96225944e-02f, 6.27661869e-02f, 6.40204847e-02f, 1.42644912e-01f, 1.15400061e-01f,
  3.40633057e-02f, 7.92677775e-02f, 7.53460778e-03f, 2.09435876e-02f, 1.21856399e-01f, -1.04579128e-01f, 1.80325821e-01f, -4.36834730e-02f, 1.26670837e-01f, 2.50997506e-02f,
  7.82791600e-02f, -8.04050043e-02f, 1.47349074e-01f, -4.34014946e-02f, -2.32479908e-02f, -1.31695613e-01f, 1.67289302e-01f, -5.62918819e-02f, 1.64130926e-02f, -1.77184388e-01f,
  -1.76336125e-01f, 2.33243465e-01f, -7.78662562e-02f, -5.81658334e-02f, -2.00216174e-02f, 2.99875923e-02f, -1.12051457e-01f, 2.69313902e-01f, 4.05309796e-01f, -1.53558180e-01f,
  -2.23318264e-01f, -4.79904041e-02f, -8.98124576e-02f, -1.16428286e-01f, 2.21724734e-01f, 2.85522938e-02f, -1.36420190e-01f, 1.48612395e-01f, -2.48677850e-01f, -9.13595110e-02f,
  -1.09194048e-01f, -2.12659419e-01f, -1.12463579e-01f, -1.74306899e-01f, -8.78871512e-03f, -3.37546259e-01f, 5.59269115e-02f, -3.37139696e-01f, -8.20263475e-02f, -4.34858710e-01f,
  -6.78334013e-02f, 1.74035951e-01f, 7.11341798e-02f, 4.18322831e-02f, 1.67422369e-01f, 7.67079368e-02f, -9.94907618e-02f, -9.14968625e-02f, -7.84258917e-02f, 2.96152402e-02f,
  -2.89097838e-02f, -2.99526956e-02f, -4.81289886e-02f, -8.37507658e-03f, -6.72816709e-02f, -8.04975703e-02f, -6.14982620e-02f, 1.07737463e-02f, -1.16776645e-01f, -7.05953315e-02f,
  -8.78720433e-02f, -5.89685217e-02f, -1.91637143e-01f, 1.31226063e-01f, 4.85795736e-02f, 8.82439986e-02f, 9.54492167e-02f, 6.30130386e-03f, 6.51927665e-02f, -7.51442164e-02f,
  -4.37580682e-02f, 5.59655875e-02f, -3.60769741e-02f, 8.09557810e-02f, -2.89007630e-02f, 1.95427254e-01f, -9.07228217e-02f, 1.01864710e-01f, 6.56101853e-02f, -4.58122008e-02f,
  -1.67591676e-01f, 1.55996591e-01f, 5.29794209e-02f, 5.26136532e-03f, -9.19815227e-02f, 1.86732714e-03f, 1.71559453e-01f, 9.01600793e-02f, -1.79562755e-02f, 8.04003552e-02f,
  -3.42791826e-02f, 2.62494329e-02f, -2.42920712e-01f, -2.33805224e-01f, 2.00820357e-01f, -2.63301551e-01f, -4.91423756e-02f, 2.27328613e-01f, -6.12148382e-02f, -2.06899375e-01f,
  8.73680487e-02f, -2.00033858e-01f, -6.41841441e-02f, -1.59965724e-01f, -2.31547758e-01f, 1.98183767e-02f, 1.74299240e-01f, 7.62356445e-02f, 9.95268077e-02f, 1.68667197e-01f,
  -1.40097020e-02f, -2.44500134e-02f, 2.70755619e-01f, 9.36488658e-02f, 2.61348039e-01f, 2.52130508e-01f, -7.86366761e-02f, 2.93297805e-02f, 1.07938714e-01f, 7.37999529e-02f,
  1.25605658e-01f, 1.19507238e-01f, -3.67683880e-02f, 2.05198184e-01f, -5.21839336e-02f, 2.96575800e-02f, 8.10809582e-02f, 1.09204138e-02f, 1.90125540e-01f, 2.15923697e-01f,
  -6.13703839e-02f, -1.61487109e-03f, -7.25358501e-02f, 2.50074565e-01f, 1.45493913e-02f, -1.51008293e-01f, -1.09822117e-01f, 5.27838841e-02f, 4.50539589e-02f, -1.85869172e-01f,
  -1.26494706e-01f, -9.73996893e-02f, 3.97769272e-01f, -1.05141804e-01f, 1.79608554e-01f, -6.07971335e-03f, -7.35680997e-01f, -4.41263132e-02f, 2.61600204e-02f, -2.11118590e-02f,
  -2.94394325e-02f, 8.73441324e-02f, -3.35580818e-02f, -2.67508682e-02f, -1.76212676e-02f, 8.42360035e-02f, 1.84104174e-01f, 8.56121257e-03f, -2.55412430e-01f, 4.57500704e-02f,
  2.85982460e-01f, -3.95130999e-02f, -1.46230668e-01f, 2.69612446e-02f, -2.15260163e-01f, 1.63792282e-01f, -1.40162364e-01f, 1.82876289e-01f, 2.04550147e-01f, -3.06864053e-01f,
  -1.52911460e-02f, 1.71512797e-01f, 1.58527009e-02f, 2.37626620e-02f, 6.09922633e-02f, -1.18310917e-02f, 8.19961578e-02f, 1.21231824e-01f, 2.35598395e-03f, -1.74129620e-01f,
  -3.76146019e-01f, -1.59240812e-01f, 2.74551362e-02f, 2.59125605e-02f, -3.06134149e-02f, -2.33277544e-01f, 9.71313342e-02f, 3.19552310e-02f, -1.49958909e-01f, -2.46590301e-02f,
  -1.17944278e-01f, 1.52001157e-01f, -5.20196520e-02f, 7.27813169e-02f, 1.67379305e-01f, 3.98641042e-02f, 3.90954405e-01f, 3.50514986e-02f, -1.17516726e-01f, 4.07132116e-04f,
  -1.36119768e-01f, -7.60420114e-02f, -3.64975393e-01f, -8.77071172e-02f, -1.62270702e-02f, 2.74417978e-02f, -3.78184468e-01f, 1.60391822e-01f, -1.58528034e-02f, -8.55162069e-02f,
  4.03829575e-01f, 1.74351986e-02f, 1.60522796e-02f, -9.66573041e-03f, -2.03519897e-03f, -2.14608282e-01f, -2.19589338e-01f, 8.93813446e-02f, 2.82291975e-02f, 9.71170887e-02f,
  -2.00429812e-01f, 3.60366739e-02f, -3.00338507e-01f, 1.10468030e-01f, -1.56010509e-01f, -1.22430488e-01f, -2.78839797e-01f, -1.84116796e-01f, 1.19631760e-01f, 6.86777160e-02f,
  -8.63018334e-02f, 1.01313487e-01f, -3.14661741e-01f, -3.62651758e-02f, 3.03473193e-02f, -8.23300779e-02f, 5.21713942e-02f, 3.09957061e-02f, -1.46009494e-04f, -2.03658640e-01f,
  -1.84367478e-01f, -1.33253768e-01f, -7.39351511e-02f, 1.83279872e-01f, 1.93022162e-01f, -6.54980168e-02f, -1.00912303e-01f, 1.45357221e-01f, -5.74479587e-02f, -5.72672449e-02f,
  -1.66932583e-01f, 1.77360594e-01f, 2.09818900e-01f, 1.34835362e-01f, 1.19429037e-01f, 9.80279967e-02f, -3.66359167e-02f, 6.64162487e-02f, -1.97448015e-01f, -2.88656205e-02f,
  -5.28054461e-02f, 1.81300975e-02f, -1.52682841e-01f, 4.13922444e-02f, 8.03294033e-02f, 9.19239819e-02f, 9.33520198e-02f, -1.71851516e-01f, 2.00077385e-01f, -9.51002538e-02f,
  1.46008402e-01f, 1.67720661e-01f, -2.58692354e-02f, 3.24706510e-02f, -4.06913102e-01f, 1.20788574e-01f, 7.39761516e-02f, 1.22235671e-01f, -2.87254732e-02f, -1.49038276e-02f,
  1.51795313e-01f, -5.90699613e-02f, -1.60680413e-02f, 1.22678749e-01f, 1.60140991e-01f, -1.30556643e-01f, -3.12066853e-01f, -2.72952855e-01f, -5.90235107e-02f, 2.13247746e-01f,
  -6.85044676e-02f, 7.28068277e-02f, -2.01450542e-01f, 4.31138463e-02f, 2.96094924e-01f, 7.04328343e-03f, 4.79006559e-01f, -2.07943823e-02f, 4.55096141e-02f, 9.56940874e-02f,
  4.59992029e-02f, 5.98522127e-02f, -2.56631952e-02f, -4.55152132e-02f, -8.90145749e-02f, -4.98348176e-02f, 6.14648983e-02f, -6.40184581e-02f, 1.82083645e-03f, 6.51052222e-02f,
  4.55756634e-02f, 6.20449428e-03f, 1.27812907e-01f, 9.41281095e-02f, -1.76563114e-02f, -2.54210755e-02f, 4.71361354e-02f, 1.08717680e-01f, -3.09991967e-02f, 1.46384194e-01f,
  6.48073480e-02f, 6.91246912e-02f, -1.62965730e-01f, -1.73971489e-01f, -8.92247036e-02f, 6.52391613e-02f, 1.62631825e-01f, -5.67099303e-02f, -5.41076064e-02f, -7.96988755e-02f,
  -1.01648390e-01f, 6.92066876e-03f, -8.56668279e-02f, 1.13465684e-02f, -2.21108556e-01f, -1.26145452e-01f, 4.48900312e-02f, 1.30411386e-02f, 1.08477853e-01f, -4.61987667e-02f,
  -8.19111094e-02f, -2.76234448e-01f, -1.30494004e-02f, 4.68124915e-03f, -1.89245537e-01f, 3.97971421e-02f, 7.46411011e-02f, -6.91136941e-02f, 3.65832113e-02f, 2.17522129e-01f,
  6.56071424e-01f, 3.79868925e-01f, 1.44269571e-01f, -2.22583767e-02f, 2.98124939e-01f, 1.16920248e-01f, -2.37126760e-02f, 2.46244818e-01f, 3.60330269e-02f, -9.43140015e-02f,
  -9.15557221e-02f, -8.04583505e-02f, -2.03546748e-01f, -7.01514930e-02f, -2.69105937e-02f, -4.59594578e-02f, 4.19607498e-02f, -2.80213263e-02f, -7.95088634e-02f, -2.12979671e-02f,
  9.26719233e-02f, 2.62762550e-02f, 1.02206126e-01f, -2.96781654e-03f, -3.70463282e-02f, -2.19473969e-02f, -4.24405225e-02f, 4.74724434e-02f, -1.74383316e-02f, -2.24849507e-02f,
  1.39781371e-01f, -1.80338528e-02f, -5.99190779e-03f, -1.59114487e-02f, -1.24396712e-01f, -1.43858299e-01f, 1.24791674e-01f, 1.30362406e-01f, -4.12234105e-03f, -3.86958830e-02f,
  4.13188897e-02f, -2.47259513e-02f, -6.85916049e-04f, 1.64759881e-03f, -9.95268077e-02f, -5.37550561e-02f, 9.22630951e-02f, -8.86943862e-02f, -2.39132077e-01f, 1.49600871e-03f,
  4.82815206e-02f, 7.13980868e-02f, 3.07968289e-01f, -2.50900742e-02f, 3.82764079e-02f, 3.88631001e-02f, -8.27019215e-02f, -1.92646071e-01f, -2.08219420e-02f, 1.37973621e-01f,
  -1.05777003e-01f, -1.56461671e-01f, -1.25837862e-01f, 9.85042751e-03f, 5.04423797e-01f, -2.19732493e-01f, -1.65030852e-01f, 2.69015074e-01f, -1.61140412e-01f, -8.31411406e-02f,
  1.92724243e-01f, -3.56329411e-01f, -1.37606218e-01f, -2.46707469e-01f, -2.36724734e-01f, -6.59453869e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.22209017e-02f, -9.26662832e-02f, -5.13703339e-02f, 2.79485043e-02f, -3.79657894e-02f, 9.79172662e-02f, 3.52724567e-02f, 2.03264967e-01f, 1.25823393e-01f, 1.43993005e-01f,
  -6.60818741e-02f, 5.28722815e-02f, 2.59198179e-03f, 1.91980764e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  9.34688598e-02f, -9.93699133e-02f, -6.62731472e-03f, 2.39905223e-01f, 8.71106982e-02f, -8.57287645e-02f, -1.74542200e-02f, 3.90599594e-02f, 3.45997475e-02f, -8.99314135e-02f,
  6.19877093e-02f, -2.28553444e-01f, 7.19887540e-02f, 3.24411273e-01f, -2.98070293e-02f, -1.33558037e-02f, 1.59762785e-01f, -5.49680181e-02f, 4.23056811e-01f, 3.60890210e-01f,
  -9.50642228e-02f, -5.85886762e-02f, 6.46517798e-02f, -1.35618336e-02f, -1.70675382e-01f, -7.51401484e-02f, -1.27593111e-02f, 4.46188897e-02f, 1.49422958e-01f, -1.41128913e-01f,
  -6.52991459e-02f, -7.54405111e-02f, -8.01173523e-02f, -4.59987074e-02f, -3.13109428e-01f, -2.71849111e-02f, 5.31021059e-02f, -2.13486865e-01f, -3.10710333e-02f, -1.70949504e-01f,
  2.72896606e-02f, -1.56326711e-01f, 3.88464481e-01f, 2.75589172e-02f, 9.47363749e-02f, -1.42348692e-01f, -6.88412634e-04f, 3.04695427e-01f, 3.01466346e-01f, 2.35800162e-01f,
  -5.19149080e-02f, 3.65789384e-02f, 7.34942257e-02f, 2.75506377e-01f, -1.77363694e-01f, 1.30729914e-01f, 3.36794555e-02f, -2.35044118e-02f, -1.55754369e-02f, -9.50648785e-02f,
  -2.16096625e-01f, 1.51131526e-01f, -1.83610052e-01f, 9.27932411e-02f, 9.90137160e-02f, 1.92745358e-01f, 3.94976735e-02f, -1.56153321e-01f, -3.10561974e-02f, 1.70179054e-01f,
  7.39149526e-02f, -1.98777467e-01f, -1.61619503e-02f, -9.66856331e-02f, 2.36295700e-01f, 5.55603951e-02f, 1.27380818e-01f, -4.76220138e-02f, 2.40413681e-01f, -1.06679335e-01f,
  -5.50948381e-02f, 3.84153984e-02f, -1.60897579e-02f, 1.24663459e-02f, 1.17750749e-01f, -1.38977647e-01f, 9.18710306e-02f, 3.11586678e-01f, -1.70715421e-01f, -1.01887442e-01f,
  1.21530823e-01f, -5.17482162e-02f, 2.00442046e-01f, -1.75914355e-02f, -2.01567799e-01f, -1.78841725e-01f, -4.25533026e-01f, 1.53875407e-02f, -4.19709027e-01f, 3.19449872e-01f,
  8.78839567e-02f, 1.25685036e-01f, 1.22999705e-01f, 7.63822421e-02f, 7.19655678e-02f, -2.10136816e-01f, -1.03839122e-01f, -3.69661413e-02f, -1.47301853e-01f, -2.88669765e-01f,
  -4.92658578e-02f, 1.50752570e-02f, -1.20482512e-01f, -3.72742079e-02f, 1.61647379e-01f, 2.73210406e-01f, 5.57878725e-02f, -1.98769301e-01f, 1.17071308e-01f, 5.60432971e-02f,
  -8.80808011e-02f, -7.73231387e-02f, 1.28488675e-01f, -1.54564947e-01f, -1.68743759e-01f, 2.07174689e-01f, 1.68516546e-01f, 4.18442674e-03f, 1.99643727e-02f, 7.25725889e-02f,
  -3.63998767e-03f, -8.87768939e-02f, 1.79637581e-01f, 2.30140332e-02f, 1.59662947e-01f, -2.01361746e-01f, 1.55314267e-01f, 2.36483335e-01f, -4.23175208e-02f, 1.60997242e-01f,
  -2.66332887e-02f, -1.01750284e-01f, 5.21247722e-02f, 3.94947529e-02f, -1.38309434e-01f, 1.70793712e-01f, -2.13516951e-02f, -1.21170521e-01f, 1.23912722e-01f, 7.90150389e-02f,
  -7.37547204e-02f, 1.53038546e-01f, 1.49754640e-02f, -1.20027170e-01f, -1.56789362e-01f, -5.06928623e-01f, 1.49529859e-01f, -3.39104906e-02f, -3.79835874e-01f, 2.51284242e-01f,
  -1.23867624e-01f, -2.21232444e-01f, -1.67018786e-01f, 3.36196423e-01f, 6.86012805e-02f, 3.04907352e-01f, -3.37896198e-01f, -4.63785455e-02f, -8.23783223e-03f, 7.65078738e-02f,
  -1.66191831e-01f, -1.34803146e-01f, 8.43153521e-02f, -1.20447293e-01f, 1.85914725e-01f, -1.95809901e-01f, -3.41044277e-01f, -1.34561136e-01f, 1.27096459e-01f, 1.14231102e-01f,
  8.98471195e-03f, 2.10449379e-02f, -1.63532406e-01f, 1.99447826e-01f, 1.36272117e-01f, -1.52490214e-01f, -6.66074157e-02f, 3.88968028e-02f, -6.63169324e-02f, -7.23994151e-02f,
  1.56813830e-01f, 2.16609880e-01f, 1.74493015e-01f, 9.05925333e-02f, 4.10000514e-03f, -8.39629173e-02f, -1.55101866e-01f, 2.28690490e-01f, 1.45822361e-01f, -6.27178103e-02f,
  5.21190278e-02f, -1.99295938e-01f, -1.24289937e-01f, 2.05095842e-01f, 1.85536772e-01f, -1.35089174e-01f, 2.65881300e-01f, -2.05399945e-01f, 2.11010631e-02f, -1.32145569e-01f,
  -9.20239314e-02f, -9.78843123e-02f, -4.77703400e-02f, -6.78850114e-02f, 1.42318547e-01f, 8.72294083e-02f, -1.41494334e-01f, 2.16413185e-01f, 2.53277689e-01f, -2.67163515e-02f,
  -2.95469850e-01f, -1.43538654e-01f, -2.82511115e-01f, 3.03637795e-02f, -1.64131016e-01f, 9.47898105e-02f, -2.31913999e-01f, -6.84590340e-02f, 1.54553987e-02f, -1.17386445e-01f,
  2.28870943e-01f, -1.78575441e-01f, -8.67228583e-03f, 6.03516698e-02f, 5.55113144e-02f, -6.99232072e-02f, -1.99877828e-01f, 4.37228307e-02f, 5.06866686e-02f, -1.60351411e-01f,
  7.92618915e-02f, -1.65650383e-01f, -1.79756179e-01f, 7.91981444e-02f, 2.10019782e-01f, -1.20291837e-01f, 8.79418030e-02f, -1.87816381e-01f, -1.09055713e-01f, -6.85570985e-02f,
  2.08586022e-01f, -2.17202708e-01f, -1.60703689e-01f, 5.68235740e-02f, 1.00916788e-01f, -1.83802638e-02f, 6.23460934e-02f, -3.61027522e-03f, -2.52158970e-01f, 2.47151777e-01f,
  1.23729981e-01f, -5.13495542e-02f, -2.47782424e-01f, 5.26807718e-02f, -5.55999428e-02f, 2.92617511e-02f, 3.39340001e-01f, 1.57748789e-01f, 2.81561967e-02f, -2.49279868e-02f,
  -1.40719622e-01f, -5.65686636e-02f, 1.63560510e-01f, 1.15734406e-01f, -1.23766363e-01f, -1.40280992e-01f, 1.69105437e-02f, 1.05569415e-01f, -5.72842024e-02f, 2.82290101e-01f,
  1.19452752e-01f, -2.33408540e-01f, 2.28360802e-01f, -2.09077939e-01f, -1.17938913e-01f, 1.34638593e-01f, 1.10970959e-01f, 7.13098571e-02f, 3.47486705e-01f, 1.56516984e-01f,
  1.11068450e-01f, 2.18480937e-02f, -2.43925080e-01f, -2.16161028e-01f, -9.12651792e-02f, -4.04569954e-01f, -1.57407552e-01f, 1.21229753e-01f, 1.37378752e-01f, -6.69824630e-02f,
  -8.20653066e-02f, 7.33623281e-02f, 4.79279794e-02f, 4.99064988e-03f, 6.36880919e-02f, -2.44190186e-01f, -8.25511888e-02f, 1.43895909e-01f, -1.38406809e-02f, 2.92553574e-01f,
  -1.93970799e-02f, -1.39348181e-02f, 2.61280626e-01f, -2.32316516e-02f, 1.75356597e-01f, -1.76912621e-01f, -2.16714889e-02f, 1.18595891e-01f, -7.45935589e-02f, 1.23215288e-01f,
  1.16472661e-01f, -1.53688058e-01f, -9.16419104e-02f, 1.19662449e-01f, -8.92095193e-02f, -9.69927572e-03f, 1.53861016e-01f, 7.59440735e-02f, 1.50259256e-01f, 2.35987864e-02f,
  -9.61635727e-03f, 2.43492853e-02f, -3.20477724e-01f, 3.36551405e-02f, -3.56362045e-01f, 1.47194445e-01f, 1.57238245e-01f, -8.61734003e-02f, 2.31382248e-04f, -5.41113168e-02f,
  8.18238966e-03f, 1.82510167e-01f, -1.32711872e-01f, -4.21887010e-01f, -1.56204000e-01f, -7.78238475e-02f, -1.76013514e-01f, -3.94265980e-01f, 4.19275463e-03f, -9.02670342e-03f,
  1.37516290e-01f, -2.74604321e-01f, 2.62406945e-01f, -1.59611672e-01f, 3.51490110e-01f, 1.54378310e-01f, -4.36462201e-02f, -1.68441430e-01f, -4.36247960e-02f, 1.27843976e-01f,
  -7.03687295e-02f, 2.48616278e-01f, -3.02889049e-01f, 2.96141617e-02f, 1.42156184e-01f, 1.52777806e-01f, 2.06603408e-02f, -8.73151422e-02f, -1.71905100e-01f, -2.83563286e-01f,
  -6.54299781e-02f, 1.08972453e-01f, -1.26212016e-01f, 8.99997428e-02f, 1.22080788e-01f, -1.43896699e-01f, -8.67411792e-02f, 3.11283227e-02f, -9.65747163e-02f, -6.62992969e-02f,
  2.81828225e-01f, -5.77732734e-02f, -9.21832398e-02f, -1.01479165e-01f, 7.33165145e-02f, -1.08076856e-01f, 8.14284608e-02f, 1.57309070e-01f, -2.81046540e-03f, 1.03110120e-01f,
  2.51699507e-01f, 9.50981900e-02f, 3.64027351e-01f, 1.60436913e-01f, -1.02700725e-01f, 9.31670815e-02f, 8.91984627e-02f, -8.33350942e-02f, -7.00513870e-02f, -4.72273715e-02f,
  -2.15738919e-03f, 8.62956792e-02f, -5.77011630e-02f, -7.84412697e-02f, 1.99493617e-01f, -6.66864663e-02f, -1.57200828e-01f, 2.52527237e-01f, -8.25915635e-02f, 1.67401358e-01f,
  -2.72620499e-01f, 9.21755806e-02f, 2.43659213e-01f, 1.74086079e-01f, -4.83337007e-02f, 2.06950799e-01f, -3.03705037e-01f, 1.03047892e-01f, -3.52410264e-02f, 1.45850241e-01f,
  1.47900507e-01f, 3.90841300e-03f, 1.36331037e-01f, 1.70652926e-01f, 1.19622283e-01f, -2.33738273e-01f, -1.11250155e-01f, 1.26990885e-01f, -7.67179579e-02f, -1.45773351e-01f,
  -1.19532615e-01f, -4.77046430e-01f, -4.78694350e-01f, -1.63022384e-01f, 1.32707506e-02f, 1.26820384e-02f, -1.99576765e-02f, -7.30690127e-03f, -9.73860249e-02f, 4.32379693e-01f,
  -2.97447473e-01f, 2.39347257e-02f, -2.03738213e-01f, -1.25171170e-01f, 1.25868171e-02f, -2.12947026e-01f, -7.27293119e-02f, -2.96053410e-01f, -1.41912336e-02f, 1.77247375e-02f,
  -3.06246467e-02f, -1.27733424e-01f, -1.38903007e-01f, -5.03530446e-03f, -4.50144932e-02f, 4.11734655e-02f, 5.76775931e-02f, -1.46656334e-01f, -1.39945254e-01f, 1.24881513e-01f,
  -9.70564187e-02f, 1.57898217e-01f, -2.36072987e-02f, 7.71203861e-02f, 1.46968976e-01f, -9.87745821e-02f, -8.46725628e-02f, -8.04452673e-02f, -5.28533896e-03f, 1.63927063e-01f,
  -2.02335373e-01f, -2.41264179e-01f, -1.59979373e-01f, 4.36393619e-02f, 3.31005268e-02f, -2.89154679e-01f, -1.98320076e-01f, -1.05198734e-01f, 8.78932774e-02f, -2.77164042e-01f,
  3.40861976e-01f, 2.44473383e-01f, 3.35339725e-01f, -1.69296518e-01f, 3.24538574e-02f, -1.71285912e-01f, 3.39009874e-02f, -4.34066840e-02f, -7.99937695e-02f, -7.29886293e-02f,
  -2.34802067e-01f, -1.37538677e-02f, -1.60842985e-01f, 1.63467392e-01f, 3.59250442e-03f, 5.57937883e-02f, 2.44715437e-01f, -5.53687289e-02f, -1.84395760e-01f, -5.92256412e-02f,
  -6.00761473e-02f, 1.06466591e-01f, 2.86384430e-02f, -2.49383628e-01f, -1.11800402e-01f, 1.22130893e-01f, -3.65427844e-02f, -2.84998298e-01f, 2.31745958e-01f, 7.51852319e-02f,
  -5.68188773e-03f, -1.32207125e-01f, -8.31382498e-02f, 2.78462619e-01f, -2.39749700e-01f, -8.88576582e-02f, -2.07384586e-01f, 1.28445670e-01f, -7.07878470e-02f, -1.48953125e-01f,
  -2.19144687e-01f, -1.32377461e-01f, -1.24864973e-01f, -1.17130063e-01f, -6.00402392e-02f, -1.14186838e-01f, 1.32668898e-01f, -2.84344908e-02f, 5.34295440e-02f, -1.80499375e-01f,
  -1.07596256e-01f, -9.70810801e-02f, 1.41355798e-01f, 1.70788437e-01f, 2.48307571e-01f, 1.51292887e-02f, -2.45305955e-01f, -1.86789408e-02f, 2.83440411e-01f, -5.30831963e-02f,
  -4.03243750e-01f, 5.45872115e-02f, 8.37873444e-02f, -9.30765420e-02f, -1.00182511e-01f, -1.54297993e-01f, 1.77200198e-01f, -2.82839447e-01f, 1.59150567e-02f, -5.80859669e-02f,
  1.67155474e-01f, -4.39466797e-02f, -3.42207262e-04f, 1.26246035e-01f, -3.16763520e-02f, 1.62470341e-01f, -2.39903163e-02f, -3.20314541e-02f, 3.35223407e-01f, 4.01839018e-02f,
  2.10084081e-01f, 1.32300943e-01f, -6.37114644e-02f, 1.59985125e-01f, 3.24199200e-01f, 9.37980786e-02f, 1.31016314e-01f, 2.52522945e-01f, 3.49336043e-02f, 3.49966168e-01f,
  9.45488140e-02f, -2.80817121e-01f, -1.47326395e-01f, 1.07025988e-01f, 1.95636526e-01f, -1.10542709e-02f, 1.05583020e-01f, 1.33306244e-02f, -1.22119434e-01f, 1.88172817e-01f,
  -3.28477696e-02f, -1.78722978e-01f, 8.19151476e-02f, 1.15398206e-01f, 8.86578485e-02f, 3.04685831e-01f, -2.10342124e-01f, -3.04168519e-02f, 5.30042388e-02f, -9.57740992e-02f,
  -1.20699473e-01f, -8.91766697e-02f, -1.47617817e-01f, 1.65203482e-01f, 9.80568379e-02f, -3.41632627e-02f, -3.22443061e-02f, -3.85784097e-02f, 1.92514673e-01f, 2.96615977e-02f,
  3.04907709e-01f, 4.75299358e-02f, -1.55625001e-01f, 2.47811183e-01f, 4.66081612e-02f, 1.59786388e-01f, 2.65225828e-01f, 1.36202097e-01f, 5.90460300e-02f, 1.27867371e-01f,
  -2.05272332e-01f, -2.16513082e-01f, -1.32334381e-01f, -7.00412765e-02f, 1.25181928e-01f, -5.98915070e-02f, 3.37258250e-01f, -2.48401687e-01f, 7.80553520e-02f, 1.84620723e-01f,
  -9.97518152e-02f, 1.81756064e-01f, -3.28276128e-01f, -2.65251338e-01f, -1.97376817e-01f, 2.56847739e-02f, -6.57134131e-02f, -2.14016229e-01f, 2.42018580e-01f, 1.55109435e-03f,
  -3.53746153e-02f, 2.43597791e-01f, -8.68321732e-02f, 4.10813540e-02f, -1.42912418e-01f, 1.92362159e-01f, -3.69373649e-01f, -9.00491923e-02f, -2.34432161e-01f, -1.41468540e-01f,
  6.69288710e-02f, 7.83667862e-02f, 1.47480726e-01f, -1.92369595e-01f, 4.71120887e-02f, -1.00245968e-01f, -6.76686913e-02f, -1.52264729e-01f, 1.05304107e-01f, 1.42196240e-02f,
  1.24676237e-02f, -2.07459822e-01f, -1.96062490e-01f, -2.60012783e-02f, 2.39024267e-01f, 1.20508626e-01f, 2.32054982e-02f, -1.03691556e-02f, -1.72472838e-02f, -1.00682408e-01f,
  -3.47585827e-02f, -7.77467042e-02f, 1.66667197e-02f, -2.18914405e-01f, -1.55803263e-01f, 1.72129959e-01f, -1.60562366e-01f, 6.54060766e-02f, -7.40165636e-02f, -5.68322241e-02f,
  2.46077999e-02f, 1.02030508e-01f, -8.35527852e-02f, -2.91732848e-01f, -2.34219611e-01f, -9.43856388e-02f, 1.96311072e-01f, 2.94024378e-01f, 3.00456434e-02f, 2.20047146e-01f,
  -6.83126925e-03f, 1.02075338e-01f, 4.51182202e-02f, -6.49376288e-02f, 3.07946771e-01f, 2.89687365e-02f, -1.17282607e-01f, 1.18533140e-02f, 2.69706007e-02f, 2.25025922e-01f,
  1.76589668e-01f, -5.63523509e-02f, -2.09841236e-01f, -1.19531274e-01f, -2.19014985e-03f, 1.37428179e-01f, -9.81529653e-02f, -5.34272790e-02f, -1.55736089e-01f, 3.51675928e-01f,
  -2.41456833e-02f, 4.19597290e-02f, 1.47614926e-01f, -2.40854602e-02f, 1.09592818e-01f, -1.34856716e-01f, -9.97215435e-02f, -1.46072023e-02f, -1.97970197e-01f, -3.08069941e-02f,
  -2.85764009e-01f, 5.98435774e-02f, -9.25766230e-02f, -9.88081321e-02f, -1.02871627e-01f, -3.41550648e-01f, 4.42891661e-03f, 1.86013535e-01f, -2.62632668e-01f, -7.99503550e-02f,
  2.84930170e-01f, -4.61696312e-02f, -1.74849957e-01f, 9.67827141e-02f, -2.49844734e-02f, -1.88285872e-01f, 4.21331413e-02f, -3.39261740e-01f, 2.52482686e-02f, -8.01251307e-02f,
  1.00442581e-02f, -1.02692746e-01f, 8.73744339e-02f, 3.03348117e-02f, -7.21347407e-02f, -1.52843416e-01f, -9.53373536e-02f, -1.08201511e-01f, 8.19639713e-02f, 7.87440464e-02f,
  8.52642348e-04f, -8.55261013e-02f, 2.97601700e-01f, 1.87771693e-01f, 2.87984282e-01f, -1.16779782e-01f, -1.57251209e-01f, 1.27904102e-01f, 3.85990217e-02f, 7.94572383e-02f,
  -1.48236692e-01f, 2.48025507e-01f, 1.49855360e-01f, -5.12095019e-02f, 5.52939437e-02f, 2.08339691e-01f, -2.56904848e-02f, 4.99293320e-02f, 1.73361003e-01f, -1.09003112e-01f,
  -1.95626125e-01f, -2.54660666e-01f, -1.06518120e-02f, 2.79198810e-02f, 1.75547212e-01f, 2.54888564e-01f, 1.83557700e-02f, -1.25662699e-01f, 7.79884756e-02f, -1.36406168e-01f,
  -4.73610312e-02f, 2.51021415e-01f, -1.55316278e-01f, -1.02054238e-01f, -9.52434167e-02f, 5.06909005e-02f, -1.08045802e-01f, -9.73883420e-02f, -8.71348679e-02f, 2.02645939e-02f,
  7.65582696e-02f, 1.21573910e-01f, 5.01683168e-02f, -1.77665561e-01f, 7.31725618e-02f, -8.62964615e-02f, -8.48169923e-02f, -1.18220709e-01f, -2.16862455e-01f, -1.03090204e-01f,
  -4.83826473e-02f, -7.89253637e-02f, 1.03143826e-01f, -5.72959296e-02f, 2.30908409e-01f, 2.70254076e-01f, -2.31814478e-02f, 1.67782363e-02f, 1.63191080e-01f, -1.91279456e-01f,
  1.65391758e-01f, 3.13305736e-01f, 1.23436391e-01f, -1.69707537e-01f, -1.97707787e-01f, -9.55431983e-02f, 1.10710621e-01f, -1.72476754e-01f, 1.07882492e-01f, -2.67865807e-01f,
  1.47538215e-01f, -6.00741729e-02f, -6.42912742e-03f, 2.67326415e-01f, -2.69747764e-01f, 3.25457424e-01f, 3.22574556e-01f, -9.13717151e-02f, -3.59447122e-01f, -7.21577629e-02f,
  1.26914471e-01f, 1.17394939e-01f, 4.21020463e-02f, -2.23431334e-01f, -8.64074379e-02f, 8.40373784e-02f, 8.85427296e-02f, -6.78513199e-02f, 1.07692868e-01f, 7.36756027e-02f,
  -6.73453063e-02f, 1.26075000e-02f, -4.10700925e-02f, -1.78148672e-02f, 2.36003920e-02f, -7.60181714e-03f, -1.10878870e-01f, 8.35162960e-03f, 3.37725691e-02f, -1.85521338e-02f,
  5.44682182e-02f, 1.26852453e-01f, -7.22951302e-03f, -3.17948051e-02f, 3.52654932e-03f, 5.36596961e-02f, -9.36309621e-02f, 6.79828823e-02f, -3.97817884e-03f, 8.24351888e-03f,
  -9.00348425e-02f, -7.06211030e-02f, -3.22808623e-01f, -1.89264342e-02f, 1.68901030e-02f, 6.33391440e-02f, 1.19666997e-02f, -1.20764591e-01f, -3.08239013e-01f, -4.03583944e-02f,
  -1.55410111e-01f, -1.07293829e-01f, 2.82509446e-01f, -8.69709402e-02f, 1.71835348e-01f, -8.17590207e-02f, -1.03873506e-01f, 1.85952976e-01f, -2.48551648e-02f, 2.20640346e-01f,
  1.58120245e-02f, 2.97369212e-01f, 1.53771564e-01f, -1.39879674e-01f, 2.22894028e-01f, -7.34177083e-02f, 5.45754097e-02f, 1.30872279e-01f, -9.31004360e-02f, 2.07315728e-01f,
  -2.29829505e-01f, 3.32211740e-02f, 9.36148390e-02f, 4.47969884e-02f, -7.83254355e-02f, -6.01681881e-02f, 3.28660086e-02f, -1.74628586e-01f, -3.29505265e-01f, 3.65548744e-03f,
  1.34215867e-02f, 2.17605948e-01f, 4.42888997e-02f, 2.45027468e-01f, 5.80788366e-02f, -2.58884609e-01f, 2.35363588e-01f, 1.65517200e-02f, -1.00162238e-01f, 1.34549797e-01f,
  6.59468845e-02f, -6.69395775e-02f, -9.69820991e-02f, -1.90459341e-01f, -8.27896446e-02f, -2.90601939e-01f, -1.69100702e-01f, -2.90771630e-02f, 1.45517945e-01f, 7.77032599e-02f,
  1.03679784e-01f, 1.12798251e-01f, 1.34348884e-01f, -1.98383909e-02f, -3.30623090e-02f, 2.64645457e-01f, 1.87657833e-01f, 1.01545807e-02f, 1.86969191e-01f, -8.30004886e-02f,
  -1.17997140e-01f, 1.58657566e-01f, 1.56504214e-01f, -2.72365004e-01f, 2.83223838e-02f, 6.92048147e-02f, -1.84609622e-01f, -2.87662894e-01f, -3.84711660e-02f, 2.60256946e-01f,
  5.34922667e-02f, 8.69911611e-02f, -1.24634974e-01f, -2.34064646e-02f, 1.27327591e-01f, -1.63781896e-01f, -1.05445646e-01f, -1.71901584e-02f, -2.25553527e-01f, 4.91421409e-02f,
  -9.31847692e-02f, 7.09262714e-02f, -6.99916780e-02f, -9.40036625e-02f, 2.86551565e-01f, 9.04434994e-02f, -3.86394858e-01f, 5.25167808e-02f, -1.90649205e-03f, 5.48433326e-02f,
  1.05929665e-01f, 1.14709988e-01f, 5.39177880e-02f, 2.46651322e-01f, 6.07561059e-02f, -3.31619680e-01f, 5.47146052e-02f, 1.03963539e-01f, 1.90323174e-01f, 1.96338028e-01f,
  -3.00182458e-02f, -8.17604139e-02f, 6.46574125e-02f, 1.02401733e-01f, 6.18232414e-02f, 1.83489230e-02f, -1.43445745e-01f, 9.12137032e-02f, 1.07303873e-01f, 7.01354071e-02f,
  3.47131610e-01f, 1.08048536e-01f, -2.96138078e-02f, 1.93189859e-01f, 2.80924235e-03f, 2.87406817e-02f, 6.17153235e-02f, 1.27804160e-01f, -7.50626996e-02f, -5.09305438e-03f,
  8.62957537e-02f, 1.12044141e-01f, 5.96655272e-02f, -1.88339666e-01f, 6.82852976e-03f, 3.02657392e-03f, 2.34933630e-01f, 1.33781001e-01f, -1.60514507e-02f, -1.44460825e-02f,
  2.38230541e-01f, -1.33827701e-01f, -2.42720604e-01f, -1.19367518e-01f, -6.54196069e-02f, -1.08700171e-01f, -2.51949038e-02f, -1.31348193e-01f, 2.65962183e-01f, -2.65694290e-01f,
  5.84777854e-02f, 1.50785059e-01f, 2.75628567e-01f, 2.21098587e-01f, 2.13222235e-01f, 3.72830741e-02f, -9.95357409e-02f, -2.21642144e-02f, 6.85048550e-02f, 5.20176068e-02f,
  1.86986417e-01f, 9.05232579e-02f, -1.37396231e-01f, -1.59957595e-02f, 1.79174632e-01f, 6.40814155e-02f, 7.17910305e-02f, -1.08734101e-01f, 6.11077435e-02f, 7.45367035e-02f,
  -1.70624629e-01f, -2.21132413e-01f, 1.95827261e-01f, -1.88113958e-01f, 6.71325549e-02f, -2.14703813e-01f, -1.50534123e-01f, -8.14983770e-02f, 1.00352064e-01f, 8.01680833e-02f,
  6.17711246e-02f, -2.68540680e-02f, 1.30455837e-01f, -1.22950457e-01f, -7.26156607e-02f, 1.60351783e-01f, 7.53370225e-02f, 9.34604332e-02f, 1.77287124e-02f, -5.74309528e-02f,
  1.23814896e-01f, -2.38108844e-01f, -3.21987197e-02f, 7.79969851e-03f, 6.73187152e-02f, 6.67217933e-03f, -1.46967798e-01f, -5.79401813e-02f, -1.47555947e-01f, 1.46153644e-01f,
  -4.20952849e-02f, -1.37714252e-01f, 1.01404220e-01f, 1.24116465e-01f, -2.45845720e-01f, 1.11183465e-01f, -1.52850121e-01f, 7.82740042e-02f, 8.49517994e-03f, -8.48310143e-02f,
  1.83626071e-01f, -1.56905502e-01f, 2.90634513e-01f, -1.32092759e-01f, -7.91917443e-02f, -1.91860572e-01f, -2.15804458e-01f, 2.24849433e-01f, -1.42613709e-01f, -2.08976679e-02f,
  -1.29493073e-01f, -2.49327287e-01f, -3.32087371e-03f, -3.93263519e-01f, -2.41940230e-01f, -4.20502648e-02f, -8.60805809e-02f, 8.42529908e-02f, -7.46091083e-02f, 1.96363315e-01f,
  -7.13261366e-02f, 5.20521067e-02f, -7.91875795e-02f, -3.02169889e-01f, -1.51775956e-01f, -2.05202833e-01f, -2.09091743e-03f, -1.05712377e-02f, 5.56794144e-02f, 1.63630635e-01f,
  -2.10750103e-01f, -1.17647655e-01f, 9.43184644e-02f, 2.41959944e-01f, 1.21706761e-01f, -2.92174429e-01f, 1.26994118e-01f, -6.49447069e-02f, -1.58382840e-02f, 1.55133739e-01f,
  2.09496886e-01f, -2.08782852e-02f, -2.01942265e-01f, 6.00754023e-02f, 1.29343823e-01f, 9.69883725e-02f, 1.12506889e-01f, 1.48744121e-01f, -1.27217313e-02f, -1.82580918e-01f,
  2.08001286e-02f, 1.62946180e-01f, -5.26507981e-02f, -9.80511904e-02f, -1.50470778e-01f, -3.29385340e-01f, 8.89429972e-02f, -1.22941531e-01f, -3.12719613e-01f, -6.41064569e-02f,
  -1.20889857e-01f, 5.36005422e-02f, -2.83668399e-01f, 2.70080447e-01f, 1.78204402e-01f, 1.26679063e-01f, -3.34585845e-01f, -8.19608942e-02f, -7.07147121e-02f, 3.15783992e-02f,
  -3.68980654e-02f, -2.60946095e-01f, -1.96204081e-01f, -1.25295401e-01f, 1.24152385e-01f, 9.08248872e-02f, -3.36156115e-02f, 3.31837833e-01f, -1.83354914e-01f, 1.32180318e-01f,
  -4.02658023e-02f, 2.12826699e-01f, -9.89647880e-02f, 1.02896325e-01f, -3.63398753e-02f, 1.79275095e-01f, 6.74985796e-02f, -1.11200310e-01f, -9.83816162e-02f, 1.52801394e-01f,
  -3.38124633e-02f, 3.14920425e-01f, -5.48863597e-02f, -3.88987064e-02f, -2.73873638e-02f, 2.61527281e-02f, -3.03277113e-02f, -2.07474846e-02f, 1.77054018e-01f, -3.25866044e-02f,
  -2.95976073e-01f, -3.53208967e-02f, -1.41598895e-01f, -2.60976795e-02f, -7.02033192e-02f, -1.98529541e-01f, -1.29295429e-02f, -1.45530447e-01f, -1.18739065e-02f, 1.66735183e-02f,
  -2.26818994e-01f, 5.38172685e-02f, 2.21309423e-01f, 4.06595469e-02f, 4.21325117e-02f, 1.71326235e-01f, -2.10629776e-01f, -4.10757214e-02f, 1.06391363e-01f, -5.96045703e-02f,
  -1.07114233e-01f, -6.25028014e-02f, -1.66728184e-01f, -1.18027329e-01f, 6.15910487e-03f, 2.76551783e-01f, 1.75592765e-01f, -1.01712048e-01f, -1.53512239e-01f, -3.15218121e-02f,
  -1.08217590e-01f, -6.08576350e-02f, -1.87822849e-01f, 1.12509109e-01f, -3.58171016e-02f, 8.76481608e-02f, 3.71568464e-02f, -2.05760852e-01f, 3.45647722e-01f, -2.23407567e-01f,
  1.54428557e-01f, 8.44952092e-02f, 7.40780449e-03f, -5.82773387e-02f, 5.56471534e-02f, 1.06806576e-01f, 1.93924904e-01f, 3.67056690e-02f, 1.01150572e-01f, 2.69130826e-01f,
  5.76993376e-02f, -2.92554200e-01f, -5.48316911e-02f, -3.14220965e-01f, 8.35297555e-02f, 1.47986963e-01f, 1.28772527e-01f, 3.09875876e-01f, 5.85248023e-02f, 8.81285593e-02f,
  1.57793447e-01f, -1.25325888e-01f, -1.14420794e-01f, -1.18960358e-01f, 1.74723923e-01f, 2.31047541e-01f, 1.03441037e-01f, 2.44075686e-01f, 2.05069259e-01f, 1.16023228e-01f,
  1.96718454e-01f, 9.96901691e-02f, 4.10006344e-02f, 1.82950109e-01f, 1.46377146e-01f, 2.92039990e-01f, 2.96045151e-02f, -5.17970882e-02f, 2.00118609e-02f, 2.18964934e-01f,
  3.30651551e-02f, 2.32004002e-01f, -1.95643395e-01f, -1.69585124e-01f, -5.26731536e-02f, 1.14653893e-02f, 2.75618762e-01f, -1.45332605e-01f, 2.50367135e-01f, 1.54698923e-01f,
  1.52810961e-01f, 2.78232008e-01f, -1.30151793e-01f, 1.09951973e-01f, 3.63942571e-02f, 4.19211760e-02f, -4.99436185e-02f, -2.89187312e-01f, -1.16700128e-01f, -1.52866811e-01f,
  -2.76109446e-02f, 1.37263149e-01f, 5.08996472e-02f, 1.69229746e-01f, -9.45660695e-02f, -2.19881758e-02f, -2.19916508e-01f, -1.58986151e-01f, -6.84019644e-03f, 1.24434441e-01f,
  -1.67544167e-02f, 1.16172336e-01f, 2.16627851e-01f, -1.92419365e-02f, -9.23321620e-02f, 1.27997786e-01f, -2.69733995e-01f, -1.77117944e-01f, -1.44620985e-01f, -8.37943777e-02f,
  -2.92560793e-02f, 1.03997685e-01f, -2.18407456e-02f, 1.29814642e-02f, 1.27327308e-01f, -9.67837423e-02f, -2.49279752e-01f, -5.14578335e-02f, -8.22168440e-02f, -4.13005017e-02f,
  9.98819992e-02f, -1.44487858e-01f, -5.74439240e-04f, 1.91387460e-01f, -1.63762465e-01f, 4.45144549e-02f, 1.22921631e-01f, -7.83841088e-02f, 1.24444082e-01f, 1.20860778e-01f,
  -1.65767923e-01f, -1.71454638e-01f, -4.61869827e-03f, 1.76962972e-01f, 1.66272402e-01f, -2.05139920e-01f, 1.88857287e-01f, 1.94304749e-01f, -4.56007794e-02f, -1.05218537e-01f,
  -2.60885786e-02f, 1.93322614e-01f, 8.66542533e-02f, -1.06015176e-01f, -4.37413692e-01f, 4.94876988e-02f, 5.89690320e-02f, 2.44328734e-02f, -2.70319074e-01f, -1.60560962e-02f,
  -3.49586755e-02f, -2.71524400e-01f, 4.33320701e-01f, -1.02984481e-01f, -1.88531205e-01f, -1.35827392e-01f, -8.68671015e-02f, 3.15497041e-01f, 2.76645303e-01f, 2.39190400e-01f,
  -3.30332294e-02f, -3.55705693e-02f, -7.12917224e-02f, 1.19517758e-01f, -3.04088056e-01f, -3.45017798e-02f, 7.82394186e-02f, -1.55699551e-01f, 5.57030812e-02f, 4.76266630e-02f,
  -3.62245627e-02f, 2.69182980e-01f, -2.48988345e-01f, 1.85403869e-01f, -6.91366242e-03f, -1.33919761e-01f, 1.21330814e-02f, 5.94241135e-02f, 7.35355401e-03f, 1.35664538e-01f,
  -4.56508696e-02f, 1.19867720e-01f, 6.62750527e-02f, 2.05715641e-01f, -2.80723069e-02f, -2.71629877e-02f, 3.15285753e-03f, -1.42492622e-01f, -4.17492315e-02f, 2.52723824e-02f,
  -9.91983246e-03f, 2.97884196e-02f, 1.22558087e-01f, -1.53368607e-01f, 2.00941950e-01f, -8.71374905e-02f, -2.74477988e-01f, 3.39733839e-01f, 5.02457283e-02f, -9.95524749e-02f,
  -3.41061056e-01f, -7.41853565e-02f, 6.81626275e-02f, 4.17722668e-03f, 5.72918020e-02f, 3.75767529e-01f, 1.80670902e-01f, 8.97660926e-02f, 2.05892339e-01f, 2.66264588e-01f,
  -1.69701919e-01f, 1.00431954e-02f, -1.56650558e-01f, 2.35455304e-01f, -2.65314579e-02f, -1.38235077e-01f, -3.62312436e-01f, -7.94811770e-02f, 5.23033813e-02f, -1.89885363e-01f,
  -1.32606300e-02f, -1.02252111e-01f, -3.15606952e-01f, -8.47697780e-02f, 1.30131289e-01f, -1.46760568e-01f, -1.15072271e-02f, 3.54327187e-02f, -4.20082696e-02f, -1.74128160e-01f,
  3.53289209e-02f, 1.50140831e-02f, -2.35720947e-01f, -1.13050558e-01f, 7.73672163e-02f, -1.60976648e-01f, -1.19846635e-01f, -2.88046956e-01f, -8.39117989e-02f, 6.75417930e-02f,
  1.92789994e-02f, -1.23319894e-01f, -1.29525006e-01f, 1.95860863e-01f, 2.51237098e-02f, 7.26352737e-04f, -5.99767379e-02f, -3.51556204e-02f, 8.93801600e-02f, -1.12143815e-01f,
  -8.91839899e-03f, 2.06783697e-01f, 1.50987923e-01f, -8.98602011e-04f, 1.47877321e-01f, -3.60716954e-02f, 1.37781724e-01f, 7.56708607e-02f, -1.10245205e-01f, -2.69982278e-01f,
  7.22800195e-02f, 1.89359754e-01f, -3.20021659e-02f, 1.94816098e-01f, 4.02538717e-01f, 3.96030039e-01f, -2.37121060e-02f, -2.80243950e-03f, 1.19781114e-01f, 7.63954967e-02f,
  -3.24148238e-01f, 1.07795916e-01f, -1.86427340e-01f, -3.69063944e-01f, 1.38034225e-01f, -1.53545707e-01f, 1.41560882e-01f, -1.31633252e-01f, 5.12140281e-02f, -7.03013316e-02f,
  5.00075698e-01f, 2.57866740e-01f, -2.10417613e-01f, 1.50896952e-01f, -1.41151011e-01f, -8.33381712e-02f, 1.65915653e-01f, 2.41733044e-01f, 1.04885794e-01f, -1.18498385e-01f,
  8.01294595e-02f, -2.82639451e-02f, -1.32867083e-01f, 2.85768837e-01f, -1.18202291e-01f, 4.63231988e-02f, -2.05766141e-01f, -5.91925681e-02f, -2.83695072e-01f, -3.41129690e-01f,
  1.51739910e-01f, 8.31477195e-02f, -4.37336788e-02f, -2.04266787e-01f, -7.38158971e-02f, 1.87592469e-02f, -1.30036861e-01f, 6.52026478e-03f, -1.54080719e-01f, -8.94926712e-02f,
  1.23849116e-01f, -9.81788710e-02f, 6.37909397e-02f, -8.45572352e-02f, -2.44706929e-01f, 1.02400690e-01f, -2.69872516e-01f, 8.93578753e-02f, 1.64472699e-01f, -2.10652679e-01f,
  -1.39988497e-01f, -1.95686847e-01f, -1.43582970e-01f, -1.37688881e-02f, 5.20307720e-02f, -2.49181017e-01f, 1.33390771e-02f, -3.46793723e-03f, 2.05605254e-01f, -8.77036452e-02f,
  -4.69504707e-02f, -1.13958515e-01f, 1.42233908e-01f, -4.81125772e-01f, -3.77593786e-02f, -4.83195633e-02f, 2.49097303e-01f, -1.06200380e-02f, -1.84195023e-02f, -2.28123106e-02f,
  1.37485738e-03f, 4.72342409e-02f, 7.80421793e-02f, 6.15723338e-03f, 1.02050059e-01f, 2.16158424e-02f, -7.99442679e-02f, 1.18503794e-01f, -2.39234880e-01f, 1.54350966e-01f,
  1.88052669e-01f, 8.58376846e-02f, -8.72954279e-02f, 2.71995664e-01f, -6.94808513e-02f, 2.18575373e-01f, 1.43434837e-01f, -2.15345025e-01f, -3.46039027e-01f, -6.40118644e-02f,
  4.70676040e-03f, 2.15406772e-02f, 1.41863868e-01f, 8.91575310e-03f, 1.62755445e-01f, -1.48937821e-01f, 1.82837173e-02f, -2.19404474e-02f, -1.10739850e-01f, 2.36800477e-01f,
  -6.58955146e-03f, 2.13764489e-01f, 2.32170373e-02f, 1.86894462e-01f, 7.35316798e-02f, 2.67473273e-02f, 1.33462429e-01f, 3.39253068e-01f, -6.70175850e-02f, 8.36775289e-05f,
  -7.02289417e-02f, -1.29761428e-01f, 1.74299970e-01f, 9.88669321e-02f, 5.67489490e-02f, 3.16353049e-04f, -2.13817373e-01f, 2.23141592e-02f, -1.00980550e-02f, -6.93370961e-03f,
  2.21807525e-01f, -6.11144379e-02f, -2.82033589e-02f, -1.51326368e-02f, -8.69260356e-02f, 1.30735502e-01f, 2.51935422e-01f, -1.36091068e-01f, 2.18674049e-01f, 2.62373060e-01f,
  3.22785497e-01f, -1.31039992e-01f, -1.15327805e-01f, -1.14643462e-01f, 6.86055720e-02f, -8.51980299e-02f, 1.20226756e-01f, 1.31410405e-01f, -1.46254048e-01f, -3.81904542e-02f,
  -5.80590144e-02f, 3.18985939e-01f, 5.59465550e-02f, 2.92437039e-02f, 3.03020440e-02f, -3.30323100e-01f, -9.02950764e-02f, -1.83688805e-01f, -5.11261215e-03f, -5.73125929e-02f,
  -3.82847190e-02f, -1.61765739e-01f, 1.27973944e-01f, -2.74802167e-02f, 1.05320476e-01f, -1.12011477e-01f, -4.32581417e-02f, 1.02438889e-01f, -6.67763054e-02f, -1.09349877e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  8.56642947e-02f, 1.41074076e-01f, -8.90157297e-02f, -1.53727248e-01f, -1.81024268e-01f, -1.89842656e-02f, 2.29258895e-01f, -1.13582768e-01f, 6.39401376e-02f, -5.66484258e-02f,
  -3.65354598e-01f, 9.31852460e-02f, 7.65826926e-02f, -1.83484882e-01f, 2.23008752e-01f, -4.25551608e-02f, -2.19171062e-01f, 8.61633196e-02f, 9.77142155e-02f, 7.18075857e-02f,
  8.08104798e-02f, -5.20389061e-04f, -1.29362002e-01f, -2.91409600e-03f, -2.03912988e-01f, -9.48181152e-02f, -1.04970232e-01f, -9.48132947e-02f, 4.92800772e-02f, -7.56871849e-02f,
  -2.53450334e-01f, 2.79651314e-01f, 1.86370704e-02f, 1.39236644e-01f, -3.36103976e-01f, 3.15666478e-03f, 5.84418932e-03f, -9.21424255e-02f, -3.23855519e-01f, 4.46680002e-02f,
  -4.15350765e-01f, -8.38287696e-02f, -1.45979226e-01f, -1.05297565e-01f, -3.08894098e-01f, -6.99675679e-02f, 2.15782627e-01f, -1.96656480e-01f, 9.20976251e-02f, 2.73806393e-01f,
  -1.69371650e-01f, 1.68963149e-01f, 6.59287274e-02f, 1.21735886e-01f, -2.41430089e-01f, 1.79381087e-01f, 3.17464769e-01f, 2.17893690e-01f, 2.36584365e-01f, -3.24697137e-01f,
  -2.13012472e-02f, 1.36552947e-02f, -9.86381993e-03f, 1.98583215e-01f, 1.25101045e-01f, 2.27598801e-01f, -1.16287045e-01f, 2.82767601e-02f, -1.04516543e-01f, -1.94956109e-01f,
  -5.98817952e-02f, -4.80417758e-02f, -1.66490421e-01f, 6.46124184e-02f, -9.05796140e-02f, -3.15504670e-01f, -1.11824110e-01f, -6.60911351e-02f, -9.17181298e-02f, 3.52960601e-02f,
  1.18161857e-01f, 3.88158932e-02f, 1.11352485e-02f, -2.78415307e-02f, -5.13229445e-02f, 5.76756448e-02f, 4.26774651e-01f, -4.55294102e-01f, -3.78704853e-02f, 1.95206702e-02f,
  5.04809022e-02f, 2.68222123e-01f, 1.12469699e-02f, -2.20743954e-01f, 1.68478712e-01f, -9.27354023e-02f, -2.24651564e-02f, -3.08718354e-01f, -1.08108893e-01f, -5.17028160e-02f,
  1.37073845e-02f, 1.18347742e-02f, 5.94008043e-02f, 9.60664416e-04f, 2.95660138e-01f, 1.58881888e-01f, -1.22894354e-01f, -8.72139260e-02f, 2.64802754e-01f, 6.58166185e-02f,
  -3.93591225e-02f, 2.64860213e-01f, 1.71510980e-01f, 3.14834416e-01f, 1.02210127e-01f, 7.99792185e-02f, 1.78281456e-01f, 1.93091780e-01f, 1.36655897e-01f, -1.73485488e-01f,
  5.93676120e-02f, -2.36488804e-01f, 6.41747788e-02f, 9.11865458e-02f, 3.80941965e-02f, 1.62206158e-01f, 7.53246322e-02f, 1.34271741e-01f, -2.29924116e-02f, 1.52558804e-01f,
  7.42501467e-02f, -5.52164018e-02f, -3.00586969e-02f, -3.47995609e-02f, 9.80307534e-02f, -5.78509904e-02f, -9.31603555e-03f, -5.21736667e-02f, 1.33248549e-02f, 2.26401567e-01f,
  2.56247252e-01f, 1.48836643e-01f, 3.62160593e-01f, -1.61160246e-01f, 3.99725363e-02f, 1.68564200e-01f, 5.69934323e-02f, 2.25903392e-01f, -2.27361083e-01f, -2.32355282e-01f,
  2.47228935e-01f, 2.38799289e-01f, -1.54382382e-02f, 1.72867090e-01f, 4.93279099e-01f, 6.08010769e-01f, -1.13672316e-02f, 1.19553566e-01f, 2.70039171e-01f, 5.45597002e-02f,
  -2.76798934e-01f, 2.05271859e-02f, -3.52128327e-01f, -4.56988275e-01f, 2.28867978e-02f, -2.96733797e-01f, 8.77307802e-02f, -1.85544834e-01f, 1.45855308e-01f, -2.26597264e-01f,
  2.14604318e-01f, 1.28634855e-01f, -3.84110600e-01f, 7.71154538e-02f, -2.73388391e-03f, 1.72793344e-01f, 2.59545028e-01f, 2.24529490e-01f, -4.56360340e-01f, -8.07347707e-03f,
  2.93280154e-01f, -1.52211115e-01f, -1.78650126e-01f, 1.27641067e-01f, 1.73252672e-01f, 6.21395633e-02f, 1.61687434e-01f, -9.17946175e-02f, -3.21128666e-01f, -2.24267110e-01f,
  1.05382964e-01f, 2.16196656e-01f, -9.97961015e-02f, -1.57007188e-01f, 1.10155478e-01f, 8.89056101e-02f, 2.25488976e-01f, 3.52399349e-01f, 7.45383576e-02f, -8.68556499e-02f,
  4.50362593e-01f, -3.80018093e-02f, 1.01881385e-01f, -4.74508144e-02f, 2.45145321e-01f, 1.38353035e-01f, -1.36633337e-01f, 4.96906741e-03f, 2.09336445e-01f, 5.58290407e-02f,
  2.08922550e-02f, 2.10005596e-01f, -7.53671676e-02f, -9.66255516e-02f, 1.56017497e-01f, 3.40686589e-01f, 1.14990421e-01f, -1.08245611e-01f, -1.76375121e-01f, -2.80288402e-02f,
  -6.25976245e-04f, 2.20511809e-01f, -1.38736693e-02f, 1.53037861e-01f, -2.38295317e-01f, -1.00150771e-01f, -1.12516150e-01f, 1.81073785e-01f, 2.52329111e-01f, -3.88750620e-02f,
  3.21358621e-01f, 2.61759907e-01f, 1.65587157e-01f, -2.01878622e-01f, 1.16563872e-01f, 1.29275993e-01f, 8.02657157e-02f, -6.92592114e-02f, -3.30533117e-01f, 4.47918594e-01f,
  -1.97907135e-01f, -6.89153299e-02f, 1.22002706e-01f, 6.04972616e-02f, -1.40577659e-01f, 1.81585237e-01f, 4.37421389e-02f, 2.40911186e-01f, -1.78132817e-01f, -2.86186427e-01f,
  1.04154728e-01f, 1.25799760e-01f, -1.76903307e-01f, 9.17967707e-02f, -3.12307179e-02f, -1.21739194e-01f, 5.14806025e-02f, 2.83195704e-01f, 2.27320388e-01f, -1.97248217e-02f,
  1.88378856e-01f, -1.53018311e-01f, 6.74582785e-03f, 1.75789446e-01f, 3.45542505e-02f, -2.43348345e-01f, -2.31231391e-01f, -1.33087546e-01f, 9.02860090e-02f, -5.03162928e-02f,
  1.77667007e-01f, -7.26971254e-02f, -7.35528991e-02f, 1.96087569e-01f, 3.11915547e-01f, 3.75776529e-01f, 1.75873712e-01f, -4.86735106e-02f, -4.55188639e-02f, -1.42535195e-01f,
  -1.24251088e-02f, 1.27181783e-01f, -3.91173027e-02f, -2.63567179e-01f, 2.11910754e-01f, -1.26888871e-01f, -2.88342416e-01f, 6.73023239e-02f, 8.82279128e-02f, -3.15497257e-02f,
  -2.92886972e-01f, 2.06471875e-01f, 1.14916682e-01f, -5.97033612e-02f, -2.57341474e-01f, 7.46212304e-02f, -2.16159105e-01f, -1.78364262e-01f, -2.11973548e-01f, -8.59740674e-02f,
  -2.37974539e-01f, -1.53243169e-01f, 8.34436566e-02f, -1.81426421e-01f, 2.17936575e-01f, 2.71576643e-01f, 4.32820544e-02f, 1.27920240e-01f, -3.42642367e-02f, -3.62618873e-03f,
  -2.59860069e-01f, 1.80840075e-01f, -5.69023285e-03f, -6.99341297e-02f, 1.60485104e-01f, -2.12869897e-01f, -9.06626880e-02f, 6.50700778e-02f, -1.48716077e-01f, 1.38409376e-01f,
  6.06163330e-02f, -6.95427433e-02f, -1.72989741e-01f, 1.21259518e-01f, 1.73743919e-01f, 1.20380171e-01f, -3.74074047e-03f, 1.79060251e-01f, 3.30460310e-01f, -2.75585651e-01f,
  7.16618868e-03f, 1.05959482e-01f, 8.96256417e-02f, 6.67217225e-02f, -8.19976255e-03f, -7.55605847e-02f, 2.23994181e-01f, -1.54183665e-02f, 9.29186344e-02f, 2.73369521e-01f,
  4.36686128e-02f, 2.47602463e-02f, 1.21703587e-01f, 9.74281803e-02f, 1.72037512e-01f, 8.12646076e-02f, -1.53308824e-01f, 2.43242551e-02f, 1.10046536e-01f, 1.12596430e-01f,
  1.38699189e-01f, 2.55981654e-01f, -2.12559793e-02f, 1.14857681e-01f, -2.41036922e-01f, 1.70956999e-02f, 3.54594052e-01f, -7.28484169e-02f, 3.41618419e-01f, -6.20326446e-03f,
  9.18240547e-02f, -2.16181993e-01f, -3.18350613e-01f, 2.51096785e-01f, -2.60582268e-01f, -1.39588416e-02f, -4.51658785e-01f, -5.70582449e-02f, -1.50838256e-01f, -2.60279745e-01f,
  -1.24533288e-01f, -1.07651882e-01f, -1.48111746e-01f, 1.94220155e-01f, -9.91748199e-02f, 4.05575842e-01f, 6.62134553e-04f, -3.75833839e-01f, 8.84058699e-02f, 1.34648867e-02f,
  -3.57987940e-01f, 7.34831542e-02f, -2.86692351e-01f, 1.37750104e-01f, 1.02143414e-01f, 1.29032359e-01f, 5.51898070e-02f, 1.60317749e-01f, 1.76520050e-02f, 3.41322064e-01f,
  1.81050137e-01f, 2.30953068e-01f, 2.80341893e-01f, -5.82368001e-02f, 5.39218523e-02f, 1.74661234e-01f, 1.22744799e-01f, -3.72760021e-03f, -6.87702820e-02f, 1.71511307e-01f,
  1.72110170e-01f, 7.82440305e-02f, -3.81302461e-02f, 2.80414186e-02f, 2.18168229e-01f, -1.05237760e-01f, 1.29325554e-01f, 1.88759431e-01f, 5.26111349e-02f, -7.85429403e-02f,
  -2.97575444e-01f, -2.00672567e-01f, 2.83922017e-01f, 2.23306119e-01f, -1.31469965e-01f, 2.79406875e-01f, 2.83889920e-01f, 4.57860082e-02f, 2.88265556e-01f, 2.94371575e-01f,
  6.99789524e-02f, 2.25989029e-01f, 5.70154227e-02f, 2.71889120e-01f, -4.97532897e-02f, 5.08846790e-02f, -4.94337678e-01f, 2.44160034e-02f, 1.48138121e-01f, -1.04661390e-01f,
  -7.43014216e-02f, 3.65000665e-02f, -2.97573954e-01f, -3.79560083e-01f, 1.79722607e-01f, -5.13921417e-02f, -9.00951214e-03f, 1.99604973e-01f, -1.90132797e-01f, 1.71543378e-02f,
  1.56704009e-01f, 8.86699855e-02f, -1.05197966e-01f, 2.35538736e-01f, -2.57114470e-02f, 1.20764233e-01f, -3.15132767e-01f, 1.60032183e-01f, -1.81133468e-02f, -3.41752231e-01f,
  2.11728096e-01f, -1.45942271e-01f, 2.25693390e-01f, 1.78263098e-01f, 5.18765636e-02f, 1.48517400e-01f, 4.02200073e-01f, -1.62009627e-01f, 3.59284095e-02f, 8.60758647e-02f,
  1.16945088e-01f, 1.13221273e-01f, -1.35064200e-01f, 1.71881706e-01f, 2.89832056e-01f, 1.98513619e-03f, 2.18092009e-01f, 2.79847175e-01f, 2.85447985e-01f, 1.32260755e-01f,
  3.72166634e-02f, 2.82717228e-01f, -1.51292533e-01f, -2.06072152e-01f, -2.11555690e-01f, -6.26107678e-02f, -5.71678244e-02f, 3.95314209e-02f, -1.36586174e-01f, 7.36576989e-02f,
  -3.72772813e-01f, -3.93389314e-02f, -1.31277775e-03f, 2.12614506e-01f, 1.78229764e-01f, -2.00723693e-01f, 1.91498816e-01f, 8.48465487e-02f, -6.54075518e-02f, 2.11519733e-01f,
  1.54501289e-01f, 5.43973029e-01f, 1.32162437e-01f, -2.31187612e-01f, -7.00426400e-02f, -2.56191164e-01f, -2.58637130e-01f, -1.26302689e-01f, 2.48786911e-01f, -1.62918027e-02f,
  -1.19399130e-01f, 1.67614240e-02f, 1.64880276e-01f, 5.12033522e-01f, -2.50551105e-01f, -2.61563491e-02f, -2.51384556e-01f, -8.02458227e-02f, -7.61381462e-02f, -6.34208396e-02f,
  2.03534141e-01f, -6.66905940e-02f, 2.99268484e-01f, -3.26897204e-02f, -4.31625592e-03f, 2.76059180e-01f, -1.00631550e-01f, 2.04725191e-01f, 2.56118655e-01f, 1.92061625e-02f,
  -4.39830981e-02f, 2.46086478e-01f, -1.82284750e-02f, 2.78966933e-01f, 1.36815071e-01f, 6.42024875e-02f, 1.17930077e-01f, -1.26951501e-01f, 7.96790570e-02f, 3.59570794e-02f,
  2.06570029e-01f, 6.58557862e-02f, 2.15402305e-01f, -2.82890536e-02f, 7.81421363e-02f, 1.65827125e-01f, 9.19715837e-02f, 1.71417385e-01f, 1.92917153e-01f, 3.38444948e-01f,
  -2.36349981e-02f, 1.52304828e-01f, 4.04922545e-01f, -2.76409183e-02f, 2.45208919e-01f, 2.52585828e-01f, 1.60392731e-01f, -1.75908536e-01f, -1.62350357e-01f, -1.84202179e-01f,
  2.04777211e-01f, -1.44727051e-01f, 2.98094749e-01f, 1.86654329e-02f, -1.77087396e-01f, 1.35203570e-01f, -6.22391552e-02f, 3.11825961e-01f, -1.26091018e-01f, -1.40375674e-01f,
  -8.95164087e-02f, -2.21713945e-01f, -1.45965949e-01f, -2.78943896e-01f, 3.19376647e-01f, 2.44380683e-02f, 1.42830029e-01f, 1.32170245e-01f, 1.61848456e-01f, 7.48789981e-02f,
  1.88792601e-01f, 1.25554577e-01f, -2.74819881e-01f, -2.95635253e-01f, -9.15668383e-02f, 1.07609130e-01f, 1.84268236e-01f, 8.75191242e-02f, 2.36115381e-01f, 9.92259458e-02f,
  1.54568091e-01f, 1.33768395e-01f, 2.41548792e-01f, -3.51313986e-02f, 1.24142349e-01f, 2.56604224e-01f, 2.29638278e-01f, 2.12834239e-01f, 2.06179455e-01f, -7.74949268e-02f,
  1.02351330e-01f, 2.53501683e-01f, -1.28815666e-01f, 2.20284313e-01f, -3.81224044e-02f, -1.23574235e-01f, 1.91838562e-01f, -1.07281215e-01f, -1.34040028e-01f, -4.48406674e-02f,
  1.67704850e-01f, 1.08105429e-01f, -1.94394857e-01f, -3.35109144e-01f, 6.66006431e-02f, 2.01551184e-01f, 1.06489460e-03f, -1.55156106e-01f, 2.72499949e-01f, 4.10183370e-02f,
  1.74810395e-01f, 6.35909289e-02f, -2.89434999e-01f, 1.37642622e-01f, -1.27544239e-01f, -3.20607543e-01f, -1.10615522e-01f, 2.31596768e-01f, -1.98849458e-02f, -1.40821174e-01f,
  1.23742163e-01f, 3.40461312e-03f, 1.30977347e-01f, -1.97962120e-01f, -8.17483440e-02f, -1.21305667e-01f, -6.38938025e-02f, 1.52682096e-01f, 1.89767972e-01f, 2.73454487e-01f,
  -9.63858142e-02f, 3.14903483e-02f, 3.43660861e-01f, 1.94375008e-01f, 1.49470359e-01f, 6.25342354e-02f, -6.50732070e-02f, -9.41863358e-02f, 9.19521973e-02f, 3.42313558e-01f,
  2.19630465e-01f, 2.00499296e-01f, 3.34248602e-01f, 1.52441934e-01f, -5.02889529e-02f, 2.29564831e-01f, 2.06211299e-01f, -9.32076797e-02f, -2.09301710e-01f, 2.35012397e-01f,
  1.87583968e-01f, 2.44785845e-01f, 1.72893628e-01f, -8.13942179e-02f, 2.41889820e-01f, -6.71454668e-02f, -6.38241619e-02f, 1.04048043e-01f, -7.68093392e-02f, 1.27722740e-01f,
  1.68973222e-01f, 5.37193893e-03f, -1.29832417e-01f, 1.25729099e-01f, -8.37587267e-02f, 7.35593140e-02f, 1.53470233e-01f, -1.35070473e-01f, 1.32611185e-01f, 6.35678470e-02f,
  -5.09987436e-02f, -1.74457937e-01f, -2.42851935e-02f, 6.68273494e-03f, 2.14429870e-01f, 7.99064338e-03f, -1.96238354e-01f, -7.12363198e-02f, -3.05651426e-01f, -3.04051697e-01f,
  -1.37779713e-02f, 2.48025149e-01f, 6.57918230e-02f, -1.23191036e-01f, 1.39202073e-01f, 5.82005307e-02f, 4.67499852e-01f, -2.48078763e-01f, -6.20160960e-02f, -1.32371709e-01f,
  -1.84186026e-01f, -2.23322604e-02f, 1.37959093e-01f, 9.05588195e-02f, 8.28210637e-02f, 1.15061238e-01f, 4.86637264e-01f, 3.71014178e-01f, 1.72548071e-01f, 9.94333178e-02f,
  -6.46281838e-02f, -3.27403098e-01f, 1.40038552e-02f, 3.71661901e-01f, -7.77813196e-02f, -4.04870063e-02f, -8.11445713e-02f, -1.40697718e-01f, -1.02406994e-01f, -1.03310727e-01f,
  -7.59821087e-02f, 1.03985585e-01f, 5.88099100e-02f, -2.21743852e-01f, -1.29848465e-01f, -2.87711710e-01f, -5.76915778e-02f, -2.94204634e-02f, -1.10452279e-01f, 5.80371469e-02f,
  -1.57962814e-01f, 9.85175595e-02f, 2.41557062e-01f, -7.93491453e-02f, 1.47482306e-01f, 9.77585688e-02f, 1.20691471e-02f, -1.32542223e-01f, -6.23708889e-02f, 3.10764257e-02f,
  1.76590279e-01f, 9.79224890e-02f, -1.69106871e-02f, -1.02059036e-01f, -4.82898690e-02f, -6.16485160e-03f, -8.30668360e-02f, -1.68030277e-01f, -4.21585217e-02f, -9.67937987e-03f,
  2.30849892e-01f, -1.23366311e-01f, -1.70028895e-01f, 8.73406753e-02f, 6.74494281e-02f, 3.20525430e-02f, -2.75439471e-01f, 1.32275224e-01f, 1.77956313e-01f, 3.01481903e-01f,
  -4.63429205e-02f, -4.67808157e-01f, -3.58705968e-02f, 3.83782573e-02f, 1.38851464e-01f, -7.42397457e-02f, 8.38917196e-02f, -1.77460700e-01f, 2.32782349e-01f, -1.40084386e-01f,
  -6.00623004e-02f, -7.36320987e-02f, 1.24295436e-01f, -7.00291917e-02f, 1.16561897e-01f, 8.66033584e-02f, 2.50918388e-01f, -6.84705451e-02f, -1.14278764e-01f, 1.53209567e-02f,
  -3.20787966e-01f, 1.11883953e-01f, -3.77026126e-02f, 1.86783627e-01f, 6.01173425e-03f, 1.16739236e-01f, 1.79923877e-01f, -6.43681660e-02f, 9.74347740e-02f, 9.24642757e-02f,
  6.79815486e-02f, 2.49997243e-01f, -1.11791141e-01f, 3.12313973e-03f, 3.04844409e-01f, 3.49531136e-03f, 1.07817709e-01f, 6.13821782e-02f, -3.78123373e-02f, 4.13463190e-02f,
  -3.33030038e-02f, -1.65030017e-01f, -9.20398103e-04f, 8.31069648e-02f, -1.44171759e-01f, -6.27358407e-02f, -1.40410796e-01f, 8.24600756e-02f, 4.19935644e-01f, -1.48840964e-01f,
  5.78725822e-02f, 1.81500629e-01f, 1.44142419e-01f, 1.04318120e-01f, -1.16767779e-01f, -5.68052009e-02f, 2.64240652e-01f, 4.85122204e-02f, 1.21742532e-01f, -6.47554323e-02f,
  -1.18137300e-01f, 1.26063988e-01f, 3.08719315e-02f, 1.77109495e-01f, -3.20139438e-01f, 1.37900531e-01f, -5.96686862e-02f, -3.98864657e-01f, -1.70867413e-01f, -1.10052265e-01f,
  3.85691337e-02f, 3.05924296e-01f, -1.47061303e-01f, 1.40795290e-01f, -1.43347904e-01f, -1.96003214e-01f, -4.16787155e-03f, 1.87120423e-01f, -7.99610913e-02f, 5.08778505e-02f,
  -2.27971703e-01f, -4.10391167e-02f, -1.99665397e-01f, 7.00775534e-02f, 2.09893107e-01f, -2.79598534e-01f, 9.73957330e-02f, 1.55198425e-01f, 2.88597923e-02f, 4.86908108e-02f,
  4.32529338e-02f, 7.97449946e-02f, 1.61129117e-01f, -5.56101911e-02f, 2.98592579e-02f, 1.58802614e-01f, 3.54037285e-02f, 2.40652725e-01f, 1.07853403e-02f, 1.57692075e-01f,
  -1.98014919e-02f, -7.51862898e-02f, 1.43278494e-01f, -8.06269273e-02f, -9.21978354e-02f, 6.08080178e-02f, -7.65040666e-02f, -1.27493620e-01f, -1.09233722e-01f, -2.53988206e-02f,
  -6.20100684e-02f, -1.01984620e-01f, -1.76487401e-01f, -1.76375270e-01f, -2.75583237e-01f, -1.96758613e-01f, -3.18620615e-02f, 2.01473325e-01f, 6.69747218e-02f, 1.05510257e-01f,
  -2.83205569e-01f, 2.41470993e-01f, -9.86275747e-02f, 2.19169840e-01f, 2.32394964e-01f, 9.17510241e-02f, 1.00941084e-01f, -2.25025371e-01f, 3.23950976e-01f, 1.01617627e-01f,
  1.46988248e-02f, 5.40310085e-01f, 1.77859411e-01f, 2.63750106e-01f, 3.73733230e-02f, -1.25825197e-01f, 1.72609359e-01f, -1.74004883e-02f, -3.58437514e-03f, 7.07099331e-04f,
  -2.57116914e-01f, 1.85736001e-01f, 4.93473448e-02f, -6.09610602e-02f, 3.05575430e-01f, -1.21839888e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.07895322e-01f, -9.57692415e-02f, 1.54717728e-01f, 5.83221093e-02f, 1.30308345e-01f, -8.42111260e-02f, 7.62326866e-02f, 1.10452309e-01f, 1.86930165e-01f, 2.68191472e-03f,
  2.19799578e-01f, -2.31184755e-02f, 4.09842581e-02f, -6.14988059e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  2.98293121e-02f, -2.34411299e-01f, -8.37513879e-02f, -1.49465531e-01f, -2.55719244e-01f, 1.16399907e-01f, -2.99119204e-01f, -2.42234826e-01f, -4.44069318e-02f, 1.66196004e-01f,
  -2.58177340e-01f, -2.00215906e-01f, -2.86379643e-02f, 1.03609599e-01f, -7.58537129e-02f, -7.32962713e-02f, -2.95347571e-01f, -6.13919646e-02f, -1.22268334e-01f, -5.22083193e-02f,
  2.07336560e-01f, -1.42100647e-01f, 1.01263434e-01f, -1.07925504e-01f, -2.22695976e-01f, 5.05273342e-01f, -2.20211953e-01f, -7.46688768e-02f, -1.02282636e-01f, 5.80905564e-02f,
  -3.33342224e-01f, -1.62000507e-01f, -1.01595722e-01f, 6.20298274e-02f, -8.39588866e-02f, 2.45768726e-02f, -7.57569969e-02f, 1.20210201e-01f, -9.00419708e-03f, -6.71995804e-02f,
  -7.51556009e-02f, -3.70983444e-02f, -1.25694811e-01f, 5.66992052e-02f, 2.38433912e-01f, 4.43137705e-01f, 4.62502725e-02f, 2.78174251e-01f, -5.28691635e-02f, -1.72108442e-01f,
  2.28159185e-02f, 2.68130690e-01f, 1.16739593e-01f, -8.22204053e-02f, 5.09204827e-02f, -4.48512495e-04f, -1.20580159e-01f, -1.37605101e-01f, -1.08420812e-01f, -1.20032057e-02f,
  3.64273340e-02f, -1.02664948e-01f, -1.72550872e-01f, 5.78995794e-02f, 1.43285498e-01f, 6.95181713e-02f, 7.19908029e-02f, 2.21273512e-01f, -5.23096286e-02f, -1.03053292e-02f,
  -1.06368467e-01f, -1.44303933e-01f, 1.68348458e-02f, 1.92938566e-01f, -8.51089582e-02f, -8.46716091e-02f, 9.65823233e-02f, -5.27083278e-02f, 1.13769896e-01f, -3.12016234e-02f,
  -2.24902347e-01f, 7.76029527e-02f, -2.16012746e-01f, 3.52287898e-03f, 8.62563699e-02f, 2.64123976e-01f, -7.09857419e-02f, -1.25720531e-01f, -2.44084880e-01f, 2.40425631e-01f,
  -1.26426026e-01f, -3.14073622e-01f, -1.55618623e-01f, -2.44311050e-01f, -2.29425535e-01f, 1.83155611e-02f, 4.92358878e-02f, -2.85834707e-02f, 3.68685842e-01f, 2.29219452e-01f,
  -4.17255796e-02f, 2.46162727e-01f, 4.62719351e-02f, -1.37295172e-01f, 2.18355693e-02f, -2.29929741e-02f, 1.59800172e-01f, -2.89248914e-01f, 3.64948250e-02f, 3.35751772e-01f,
  -2.15216592e-01f, 3.57587039e-01f, 4.89019379e-02f, -6.07887581e-02f, -8.79669562e-02f, 3.43483649e-02f, 6.92158937e-02f, 1.41156152e-01f, -2.56631494e-01f, 5.40521480e-02f,
  -7.69852102e-02f, 2.94864550e-02f, 1.07132301e-01f, -1.87365767e-02f, -7.30745420e-02f, 5.17459922e-02f, 4.03829776e-02f, 1.66338652e-01f, -1.01308666e-01f, -3.36681828e-02f,
  -4.30059284e-02f, 1.48171142e-01f, 2.53236949e-01f, 1.01710036e-01f, 1.00372374e-01f, 1.46299034e-01f, 6.66600987e-02f, -3.86996605e-02f, 2.78274566e-01f, -4.42749374e-02f,
  2.47785598e-02f, -3.05840373e-01f, -7.74583519e-02f, 1.24127202e-01f, -1.05131947e-01f, -1.59790158e-01f, 1.38186023e-01f, 1.90219343e-01f, -2.65035294e-02f, -8.28981102e-02f,
  -1.22536279e-01f, -1.26485890e-02f, 1.84524536e-01f, -2.66006589e-01f, -1.34436442e-02f, 1.01073235e-01f, 9.38772559e-02f, 2.44419605e-01f, 4.12890106e-01f, -2.92982191e-01f,
  2.14242980e-01f, 1.09204434e-01f, -2.58926988e-01f, 1.72562376e-01f, -1.11213982e-01f, -3.52689385e-01f, -1.49721950e-01f, 7.24692792e-02f, -6.65207207e-02f, 6.50649294e-02f,
  -1.46077633e-01f, -1.85595527e-02f, -2.41374820e-01f, -2.37948567e-01f, -5.40388525e-02f, -2.66544521e-01f, 8.77832621e-02f, 1.05619547e-03f, 4.34676446e-02f, 1.69802412e-01f,
  -2.79286534e-01f, -1.76451549e-01f, 5.29448949e-02f, -2.18720719e-01f, 4.84102294e-02f, 3.23306359e-02f, -2.17696682e-01f, 1.04890175e-01f, 3.60495847e-04f, 1.47099525e-01f,
  -1.74134284e-01f, 2.19027385e-01f, -1.27335787e-01f, 2.65486747e-01f, -1.44824162e-02f, -1.07961968e-01f, -1.08900115e-01f, -3.16345304e-01f, -1.58087373e-01f, 2.51743317e-01f,
  1.13116287e-01f, 1.01243563e-01f, -1.37387514e-01f, -9.57364514e-02f, -6.19458742e-02f, 1.49445727e-01f, -7.13505819e-02f, -1.70025811e-01f, -2.89802831e-02f, -1.22112401e-01f,
  5.40590398e-02f, -2.02963933e-01f, -1.92116037e-01f, -5.87778986e-02f, -7.40225241e-02f, 1.19137421e-01f, 7.52849579e-02f, 7.89401978e-02f, 2.22938970e-01f, 1.35846078e-01f,
  -1.01145402e-01f, -1.93409488e-01f, 4.67914455e-02f, -7.34114647e-02f, -2.48647943e-01f, -1.29789367e-01f, -2.90603876e-01f, 1.49964899e-01f, -8.91107395e-02f, -1.41634524e-01f,
  9.31938738e-02f, -2.79026181e-01f, 2.02192366e-01f, -1.57584026e-02f, -2.35593453e-01f, 3.21016461e-02f, -1.97538450e-01f, 1.69527099e-01f, 2.15933278e-01f, -1.45442620e-01f,
  -4.76931259e-02f, -2.79129297e-01f, 1.54856248e-02f, 1.39570758e-01f, -1.83678523e-01f, -6.60536364e-02f, 8.92697051e-02f, 1.92093141e-02f, 2.20251642e-02f, -6.53797984e-02f,
  -1.97634146e-01f, -1.15194164e-01f, -2.17172772e-01f, 9.35773924e-02f, 5.24042249e-02f, 4.62784665e-03f, 7.82981142e-02f, -1.30411938e-01f, -1.46920517e-01f, 9.15625542e-02f,
  -1.13514960e-01f, 1.11318938e-01f, 2.79614162e-02f, -3.59991379e-02f, -1.00206397e-01f, -1.17002279e-01f, 2.39581674e-01f, 5.72913811e-02f, -2.16432065e-02f, -5.14732115e-02f,
  2.77543701e-02f, 1.02743007e-01f, 1.40321925e-01f, -9.42602679e-02f, -1.33156374e-01f, 1.83858916e-01f, 1.94083989e-01f, -8.18093196e-02f, -6.40890896e-02f, 6.21702038e-02f,
  5.66414632e-02f, -1.50439516e-02f, 1.25688285e-01f, 2.77315348e-01f, -1.00535214e-01f, -2.03950778e-01f, 1.35438487e-01f, 3.13293517e-01f, 1.39648363e-01f, -3.35917994e-02f,
  -1.48849025e-01f, 9.53465328e-03f, 1.19865313e-01f, -2.05811828e-01f, 2.53287643e-01f, 1.79849938e-02f, -2.14006633e-01f, 1.40641615e-01f, 2.24413022e-01f, 4.44374233e-02f,
  5.77269830e-02f, 2.12001763e-02f, 2.17896312e-01f, -1.67026043e-01f, -3.56284603e-02f, 1.04371784e-03f, 1.78594038e-01f, -1.87219948e-01f, -2.98570514e-01f, 1.19468421e-02f,
  2.72653788e-01f, 1.36598691e-01f, 8.82804617e-02f, 1.95008457e-01f, -2.13541284e-01f, -1.35057092e-01f, -4.67723468e-03f, -4.15919349e-02f, 8.18171203e-02f, -2.03492627e-01f,
  -5.65235093e-02f, -1.29757509e-01f, 1.20174952e-01f, 7.60783404e-02f, 1.91780522e-01f, -4.21855040e-02f, 5.77606075e-02f, 1.67477846e-01f, -2.42794678e-02f, -2.46422905e-02f,
  2.67217398e-01f, 2.66255066e-02f, 1.37089357e-01f, -1.67370826e-01f, -6.82771578e-02f, -2.68936325e-02f, 3.15484107e-02f, -1.14235952e-01f, -9.08391774e-02f, -1.00395940e-01f,
  -2.37517618e-02f, -5.82842231e-02f, -1.50696948e-01f, 1.31732255e-01f, 2.97097981e-01f, -3.70048769e-02f, 1.86416000e-01f, 2.73971204e-02f, 3.02628875e-01f, 2.17331648e-01f,
  -1.19322702e-01f, -4.95510474e-02f, -9.11088809e-02f, -5.15587591e-02f, -1.76547989e-02f, -6.76472858e-02f, -1.40974356e-03f, 7.95015395e-02f, -1.29524499e-01f, 8.38227496e-02f,
  -1.12687200e-01f, -1.10297650e-01f, 8.27922896e-02f, 4.10483144e-02f, -2.76125912e-02f, 1.37629002e-01f, 3.01125199e-02f, 3.35578597e-03f, -1.52717218e-01f, -1.79427415e-01f,
  2.48167664e-01f, 1.21894311e-02f, 2.67319649e-01f, -2.05894317e-02f, 3.04790169e-01f, 1.32392332e-01f, -5.10003157e-02f, -1.43040746e-01f, 4.95398976e-02f, -1.07599720e-02f,
  -3.16172726e-02f, -1.32949069e-01f, 5.13720661e-02f, -2.46394500e-02f, -2.30951998e-02f, -8.90803710e-03f, -1.05465427e-01f, 7.72203058e-02f, 2.12393180e-01f, 9.61695239e-02f,
  2.93626729e-02f, -2.38434970e-02f, 2.90328801e-01f, 1.44805968e-01f, 1.70913771e-01f, 2.67858922e-01f, 2.98554730e-03f, -2.37996310e-01f, 1.05122522e-01f, 6.54189289e-02f,
  -1.77496031e-01f, -1.78241149e-01f, -1.80064421e-02f, 9.08553675e-02f, 1.31113917e-01f, 3.39198597e-02f, 6.67991340e-02f, 2.25576796e-02f, 1.40101478e-01f, -2.26150140e-01f,
  1.45364136e-01f, 1.34015039e-01f, 2.52273649e-01f, 1.99498534e-01f, 3.86807323e-01f, -3.27516466e-01f, 3.27030003e-01f, 1.37295365e-01f, -3.11246961e-01f, -5.67300543e-02f,
  -9.35062417e-04f, -7.40804970e-02f, 2.32470170e-01f, 1.34871766e-01f, -1.26601398e-01f, -2.66883850e-01f, 1.24697216e-01f, 7.20933229e-02f, 1.06036298e-01f, 3.72434109e-02f,
  6.44849762e-02f, -2.15659291e-01f, -1.80367958e-02f, -1.47801936e-01f, 2.31921434e-01f, 1.91273317e-02f, -1.84488654e-01f, 1.61004752e-01f, 1.42709807e-01f, -9.48604047e-02f,
  7.74139017e-02f, 2.95796487e-02f, -2.34731153e-01f, 5.90398908e-02f, -7.09324852e-02f, 2.24322118e-02f, 1.61136128e-02f, 3.79485846e-01f, -1.75937861e-02f, 9.41454843e-02f,
  1.75433401e-02f, -2.01129522e-02f, 1.24562904e-01f, -9.27425921e-02f, 1.57886073e-01f, 2.99944460e-01f, 3.24998759e-02f, -3.88076343e-02f, 2.30444103e-01f, -3.94233968e-03f,
  1.54335067e-01f, 4.17966768e-02f, 7.29065835e-02f, 2.02591196e-01f, 6.32404611e-02f, 1.36915460e-01f, 9.36478227e-02f, 7.56700486e-02f, 1.48581803e-01f, -3.10310945e-02f,
  -1.24561809e-01f, 1.52907059e-01f, 2.05055743e-01f, -1.44609407e-01f, -3.92724127e-02f, 9.66827944e-02f, 3.01618248e-01f, 2.15807498e-01f, 3.43937576e-02f, -1.14883088e-01f,
  -8.71845186e-02f, -2.98149176e-02f, -2.58618325e-01f, -2.30116040e-01f, 1.13580905e-01f, 1.52848110e-01f, -1.08606249e-01f, 3.52253437e-01f, -8.29074085e-02f, 3.36698107e-02f,
  1.31368950e-01f, 2.47935206e-02f, 7.60099590e-02f, -1.03583917e-01f, 1.09401353e-01f, -3.24440211e-01f, 4.35453393e-02f, 2.73782223e-01f, 3.24265420e-01f, 1.93898715e-02f,
  1.81658953e-01f, 1.09854884e-01f, 1.78791396e-02f, 1.67565405e-01f, 4.01196964e-02f, -1.19549416e-01f, 5.08423224e-02f, 1.59360945e-01f, 1.75296560e-01f, 2.96990592e-02f,
  5.74706756e-02f, -1.33202747e-01f, -2.46678859e-01f, -9.14389789e-02f, 6.41679317e-02f, -8.47951099e-02f, -8.61324519e-02f, 5.27267978e-02f, 2.21158974e-02f, -9.02208462e-02f,
  -8.89000744e-02f, 4.82198074e-02f, -4.25904505e-02f, 1.31125927e-01f, -3.14359874e-01f, -1.66236222e-01f, -1.80218726e-01f, -3.14469747e-02f, 1.79974455e-02f, -1.15239039e-01f,
  -1.14478044e-01f, -9.07857418e-02f, -4.77066413e-02f, -3.09110194e-01f, -1.87716797e-01f, 3.62614468e-02f, -1.70597181e-01f, 2.66709536e-01f, 1.57892823e-01f, -1.83135234e-02f,
  -1.82879254e-01f, -4.58203778e-02f, -5.76738864e-02f, -7.39715025e-02f, -2.30056569e-02f, -6.48217127e-02f, -3.04719925e-01f, 1.38108050e-02f, 1.11135326e-01f, 2.80568935e-02f,
  3.47216874e-02f, -1.91250309e-01f, 2.37214684e-01f, -3.20343785e-02f, -7.80702531e-02f, 1.24320403e-01f, -2.07223967e-01f, 3.38809162e-01f, 1.10168085e-01f, -6.30920678e-02f,
  2.27156177e-01f, -2.43383825e-01f, -1.11755043e-01f, 1.56171992e-01f, -7.11778551e-02f, 2.00243086e-01f, 1.32083520e-01f, 4.16088551e-02f, -7.63768330e-02f, 9.27761048e-02f,
  -2.69417763e-01f, -2.60091871e-02f, -9.15327743e-02f, 6.42215684e-02f, -1.97106183e-01f, 1.10301338e-01f, -1.63682237e-01f, 7.48222098e-02f, -5.80352508e-02f, -9.65847597e-02f,
  -4.28948402e-02f, -7.48742744e-02f, -4.65258881e-02f, -6.23602644e-02f, 6.88299313e-02f, 2.42940724e-01f, 1.58178583e-01f, 6.84033781e-02f, -5.53822406e-02f, -2.08016802e-02f,
  5.34948148e-02f, 1.07172757e-01f, -1.40472457e-01f, 9.00942981e-02f, -3.51694711e-02f, 2.02793866e-01f, 1.51279852e-01f, -3.98504622e-02f, -1.36395559e-01f, 9.34111793e-03f,
  1.14868045e-01f, 1.81812286e-01f, 2.79767275e-01f, 5.08416295e-02f, -1.00647546e-02f, -1.58079550e-01f, -1.88371316e-01f, -4.29865578e-03f, -1.00198202e-02f, -1.17322855e-01f,
  -7.64745846e-02f, 1.34272054e-01f, -3.31790373e-02f, -1.86560787e-02f, 9.59814116e-02f, 2.21799109e-02f, -1.91166755e-02f, -1.56042367e-01f, 2.18536809e-01f, -4.08746526e-02f,
  -1.61873281e-01f, 4.85950261e-01f, -3.12089361e-02f, -2.10486531e-01f, 1.50517970e-01f, -2.91592687e-01f, 1.64288610e-01f, -1.05105758e-01f, 6.24330528e-02f, 1.98276624e-01f,
  1.52807161e-01f, -7.72302747e-02f, 2.20166042e-01f, 2.05544056e-03f, -2.40581185e-01f, -1.33709669e-01f, -2.17474759e-01f, -7.97896236e-02f, 1.43537462e-01f, 3.60482484e-02f,
  -1.52057573e-01f, 1.54746309e-01f, -1.83232382e-01f, -2.48699918e-01f, -9.46902782e-02f, -1.78884163e-01f, -1.54110774e-01f, -1.39035106e-01f, 1.17711298e-01f, -2.02471018e-01f,
  8.39999393e-02f, 3.52440844e-03f, -1.36901692e-01f, 1.21892460e-01f, -1.80274501e-01f, 1.72760636e-01f, 7.50228539e-02f, -5.04193688e-03f, 1.79898232e-01f, 1.88944459e-01f,
  -6.10457771e-02f, -5.91085479e-02f, -1.00106329e-01f, 3.37057374e-02f, 3.44126113e-02f, 1.45792335e-01f, -7.38598928e-02f, 1.11852050e-01f, -1.27010584e-01f, -3.61988358e-02f,
  -3.27355228e-02f, 2.29075894e-01f, -9.14013311e-02f, -2.44157746e-01f, -1.08471796e-01f, -1.44577011e-01f, -1.13881916e-01f, -1.27824992e-01f, -2.82211881e-02f, -2.14041501e-01f,
  9.32968967e-03f, 9.91715491e-02f, -5.61296679e-02f, -4.18980382e-02f, -1.20491296e-01f, 7.07613379e-02f, 4.21354830e-01f, -2.21979707e-01f, 1.41537234e-01f, -1.86812937e-01f,
  -3.62000763e-02f, -3.47182043e-02f, -5.90299256e-02f, 5.96216470e-02f, -1.45953327e-01f, -5.46425842e-02f, 1.26686677e-01f, 4.62826937e-02f, -2.37016797e-01f, -4.87223230e-02f,
  -1.41951963e-01f, 8.11889172e-02f, -1.63935125e-01f, 8.22323561e-02f, 1.25983227e-02f, -2.17323318e-01f, -8.55053440e-02f, -7.84794837e-02f, -2.44782716e-01f, 1.41182572e-01f,
  -8.54181275e-02f, -2.29472026e-01f, -9.06294063e-02f, -8.90263394e-02f, -1.49571016e-01f, 1.73841566e-02f, -4.17990349e-02f, 1.04235187e-01f, 1.28472894e-02f, 1.03025734e-01f,
  -1.85716338e-02f, 2.22182751e-01f, 2.25321352e-01f, -6.13217019e-02f, -8.26497674e-02f, -1.53171167e-01f, 2.38860808e-02f, 2.49903072e-02f, -1.21699251e-01f, -2.29481667e-01f,
  -2.57423371e-01f, -1.39666066e-01f, -1.07527904e-01f, -9.12902504e-02f, 2.67427981e-01f, -4.90799807e-02f, 6.77784905e-03f, 6.81593046e-02f, -1.70972243e-01f, 1.51088843e-02f,
  2.67907046e-03f, 1.72236040e-01f, -6.10685349e-02f, 9.96969733e-03f, 2.77685851e-01f, -2.30885088e-01f, -4.49941419e-02f, 5.22208773e-02f, -5.38800471e-02f, -1.15734547e-01f,
  -1.50008172e-01f, -1.50191456e-01f, 2.41140619e-01f, 2.07271829e-01f, -3.11480165e-01f, -2.21535593e-01f, -2.11496547e-01f, -2.88133137e-02f, -3.45423818e-01f, -2.15142444e-01f,
  -8.12048316e-02f, 6.89055026e-02f, 8.43676478e-02f, -9.63626131e-02f, 1.13415547e-01f, -1.59412742e-01f, 7.70847797e-02f, 6.05338514e-02f, -2.40984783e-01f, -9.79489088e-02f,
  -2.17222214e-01f, 9.10463259e-02f, -8.28350952e-04f, -2.80732065e-02f, 7.17584789e-02f, -1.49718761e-01f, 1.82619646e-01f, -6.37693033e-02f, -7.32366666e-02f, 1.32522061e-01f,
  -2.65779406e-01f, 2.13027373e-03f, -3.93027291e-02f, -4.83309180e-02f, 7.88311735e-02f, -1.41023755e-01f, -6.11253381e-02f, 2.39323899e-01f, -1.97317675e-01f, -2.19221279e-01f,
  1.83645589e-03f, 8.70869830e-02f, 1.16318449e-01f, 1.89990997e-01f, 3.73061746e-01f, 2.35069111e-01f, 1.33710086e-01f, 5.15837036e-02f, -3.25440131e-02f, 2.71643307e-02f,
  1.85823683e-02f, 4.78601046e-02f, -2.53537863e-01f, -1.83173776e-01f, -8.78339857e-02f, -1.11583173e-01f, -2.04415992e-01f, 1.23894222e-01f, 1.88188970e-01f, 1.68106504e-04f,
  5.01340032e-02f, 1.52208060e-01f, 6.45002797e-02f, 1.13301724e-01f, 1.37537882e-01f, -4.79251295e-02f, -1.53756380e-01f, -1.54421151e-01f, 1.54335991e-01f, -1.65805176e-01f,
  2.13812757e-02f, 2.19919514e-02f, 1.94187954e-01f, 2.68167369e-02f, 1.49878681e-01f, -8.75138212e-03f, -7.82681853e-02f, 2.72956621e-02f, -2.47222395e-03f, -5.94527796e-02f,
  -9.38664302e-02f, -4.48221453e-02f, -1.12160288e-01f, 1.83415592e-01f, 2.78695583e-01f, -1.44752920e-01f, -4.85267602e-02f, 2.91608572e-02f, -1.22040741e-01f, 9.92018133e-02f,
  -9.20090675e-02f, 2.50756145e-01f, 2.69727353e-02f, -2.87590921e-01f, 1.99644148e-01f, -1.46920830e-01f, 2.34239906e-01f, 2.11858615e-01f, -1.86345428e-02f, -1.31825833e-02f,
  -4.64597642e-02f, -1.00755967e-01f, -1.89904943e-01f, -3.23649645e-02f, -4.27677383e-04f, -8.97103846e-02f, 4.18984005e-03f, 2.04899207e-01f, 2.31024390e-03f, 2.37684518e-01f,
  -4.27256562e-02f, 7.62191787e-02f, -3.78963246e-04f, -5.15562177e-01f, 3.65643576e-02f, -8.90360028e-02f, -2.00220644e-01f, -1.42101228e-01f, 1.97933272e-01f, -2.72625145e-02f,
  -3.73107307e-02f, 1.76216707e-01f, -1.86110690e-01f, -4.86138277e-02f, 6.69462532e-02f, 2.14818940e-01f, 8.79171789e-02f, 1.61006436e-01f, -2.18504742e-01f, -4.94459234e-02f,
  -7.23961294e-02f, 1.70496926e-01f, 1.14904448e-01f, 1.77002043e-01f, 8.45491141e-02f, 2.36049760e-02f, 8.69630128e-02f, 3.67791392e-02f, 6.73432946e-02f, -2.39124909e-01f,
  4.91573066e-02f, 1.18008085e-01f, 8.50653127e-02f, 6.45073727e-02f, 8.45790803e-02f, -1.42285809e-01f, -4.23459299e-02f, 1.87797874e-01f, -1.65811300e-01f, 2.55815506e-01f,
  -1.61132023e-01f, 7.17782974e-02f, 1.23861954e-01f, 1.28337577e-01f, 1.54521435e-01f, 3.52884308e-02f, -2.53591686e-01f, -1.43521234e-01f, -8.45810249e-02f, 4.02523987e-02f,
  9.16704610e-02f, -1.99833661e-01f, -3.50310504e-02f, -7.85202608e-02f, -1.46154657e-01f, -1.28913969e-01f, -4.59436029e-02f, -1.10000454e-01f, 1.14893667e-01f, -2.17040747e-01f,
  6.87744692e-02f, -1.27134770e-01f, 7.31496885e-02f, 1.90358777e-02f, 5.97136840e-03f, 2.40589473e-02f, 2.22550943e-01f, -1.74481556e-01f, -2.43646950e-01f, 7.53613561e-02f,
  -1.65468425e-01f, -1.19336814e-01f, -1.14334621e-01f, -3.02398235e-01f, -2.09454224e-01f, -6.47281513e-06f, -1.27334833e-01f, 2.01049104e-01f, -1.25722706e-01f, 2.25430563e-01f,
  8.58743489e-02f, -1.55450389e-01f, 5.32986075e-02f, 4.06743065e-02f, -4.02020514e-01f, -1.29557595e-01f, -1.04389459e-01f, 5.73701486e-02f, 3.02193388e-02f, -2.65391439e-01f,
  2.45378576e-02f, -6.40664995e-02f, 1.23441771e-01f, -1.15087882e-01f, -2.88516749e-02f, -1.33855775e-01f, 1.82274833e-01f, -2.90302299e-02f, -1.92914441e-01f, 1.33107314e-02f,
  2.54102141e-01f, -3.55304688e-01f, -7.60418247e-04f, 2.10192297e-02f, 4.57860343e-03f, 1.72050476e-01f, -6.07332550e-02f, -2.16740757e-01f, 3.87251028e-03f, -3.07587795e-02f,
  -9.56579298e-02f, 6.13850579e-02f, 3.18995565e-02f, -1.02136850e-01f, 5.03667295e-02f, 1.67201653e-01f, 1.56509399e-01f, -1.27405137e-01f, -1.15541309e-01f, -1.41828209e-02f,
  1.46217644e-01f, 1.49036482e-01f, 6.62442520e-02f, 7.74220452e-02f, -1.06531411e-01f, 1.57564864e-01f, -8.17528963e-02f, 1.75407156e-01f, -1.20627759e-02f, -2.54231393e-01f,
  2.40349881e-02f, 1.63755596e-01f, 2.63040483e-01f, 7.60775805e-02f, 7.83100724e-02f, 2.85734478e-02f, 1.31191254e-01f, -6.38616160e-02f, 2.81420350e-02f, 3.22349131e-01f,
  -3.41919899e-01f, 5.24494089e-02f, 3.57591510e-01f, 1.66254953e-01f, 1.54888630e-01f, -5.01320362e-02f, 6.83763325e-02f, -1.15431450e-01f, -8.20118338e-02f, -3.22993705e-03f,
  1.93004459e-01f, -2.52055395e-02f, -2.23622724e-01f, 2.14775264e-01f, 2.87385911e-01f, 1.05551831e-01f, -5.08159548e-02f, 1.68129176e-01f, -1.93721682e-01f, -8.33601952e-02f,
  -6.10499270e-02f, -7.69763663e-02f, 6.74536265e-03f, -7.32251629e-02f, 9.65071470e-02f, -1.04998313e-02f, -2.53822565e-01f, 1.35580793e-01f, 8.35835785e-02f, 9.00304243e-02f,
  1.02898898e-02f, -2.06765696e-01f, 1.03725672e-01f, 4.26009372e-02f, -1.92571909e-03f, 3.10183823e-01f, -1.68746457e-01f, -9.38067809e-02f, 7.56912120e-03f, 4.46450338e-02f,
  1.61851451e-01f, -2.49124959e-01f, 1.82797555e-02f, 2.42141992e-01f, -6.62584696e-03f, 1.61625609e-01f, 3.19623947e-01f, -9.35667679e-02f, -2.46778861e-01f, -6.53448626e-02f,
  -8.42152238e-02f, 5.99808581e-02f, -1.33816898e-01f, -1.56240374e-01f, 3.97405513e-02f, 3.45413506e-01f, -6.49146959e-02f, 3.02658916e-01f, -4.62216511e-02f, 1.46582335e-01f,
  1.00120291e-01f, -2.46100903e-01f, -9.28683132e-02f, 4.93273092e-03f, 1.15244891e-02f, 2.82123327e-01f, 1.22623704e-01f, 2.02690974e-01f, -1.24323368e-01f, -2.32382357e-01f,
  -1.75075278e-01f, -1.14721440e-01f, 9.50743631e-02f, -1.31696001e-01f, -2.30273843e-01f, -1.29536897e-01f, -2.50877291e-01f, 7.00653419e-02f, -1.19634785e-01f, -4.49546240e-03f,
  1.19246684e-01f, 2.76740491e-01f, 7.14461952e-02f, -8.31377730e-02f, -4.69892994e-02f, -1.01121366e-01f, -8.25715065e-02f, 8.72078910e-02f, -6.61544800e-02f, 2.02449605e-01f,
  3.04240081e-02f, -1.25505194e-01f, -2.74636671e-02f, -2.39289284e-01f, -2.69375622e-01f, 9.67737883e-02f, 1.25785336e-01f, -6.87621310e-02f, 1.56968355e-01f, 6.32281154e-02f,
  4.62210327e-02f, 3.55006419e-02f, 2.56212149e-02f, -5.81037551e-02f, -7.41420388e-02f, -5.34497313e-02f, -1.13555327e-01f, -6.64527621e-03f, -1.89363603e-02f, -9.84133855e-02f,
  -1.50833344e-02f, 1.66293740e-01f, 2.39104897e-01f, -5.74325174e-02f, -9.98878852e-02f, -9.41995252e-03f, -7.35712424e-02f, -1.08161166e-01f, -2.18423158e-02f, 3.22773844e-01f,
  -1.31989866e-01f, -2.18629345e-01f, 1.84395581e-01f, 5.80383986e-02f, 1.29488781e-01f, 4.15637158e-02f, 1.45931602e-01f, -1.64895266e-01f, -1.05087748e-02f, -4.53934893e-02f,
  -3.19177061e-02f, -3.03644478e-01f, -2.37977237e-01f, 1.99400350e-01f, 3.18260938e-01f, -1.07558884e-01f, 2.52288401e-01f, -1.16098113e-01f, 1.37233645e-01f, 9.51602235e-02f,
  -9.58527327e-02f, 7.96952918e-02f, -6.39179647e-02f, 7.86949769e-02f, -5.46757914e-02f, -2.43355483e-02f, -4.46738563e-02f, -2.27155462e-02f, -1.54985011e-01f, 1.16994545e-01f,
  1.37435570e-01f, -5.10630570e-02f, 7.33261108e-02f, 9.32370275e-02f, 2.90448461e-02f, 9.93066803e-02f, -1.64077468e-02f, 1.17581517e-01f, -2.04080567e-02f, -1.29964411e-01f,
  1.18342645e-01f, 1.78844854e-01f, 2.74752975e-02f, 2.76652187e-01f, -6.05405960e-03f, 1.08683690e-01f, 4.65933569e-02f, -3.23286876e-02f, 8.20449665e-02f, 5.03090285e-02f,
  -1.13904230e-01f, 3.09713185e-01f, -8.19266886e-02f, 4.73883562e-03f, 1.36927366e-01f, -9.34654474e-03f, -4.44052704e-02f, 2.89185137e-01f, 3.96468379e-02f, -2.33393461e-01f,
  1.53569788e-01f, -2.95518130e-01f, 3.38835642e-02f, 1.54316574e-01f, 1.50054723e-01f, -1.20746428e-02f, 8.81674215e-02f, 1.61339976e-02f, 9.10008028e-02f, 2.60075450e-01f,
  5.20759188e-02f, 7.39668980e-02f, 5.96273877e-02f, 1.89498112e-01f, -8.18405375e-02f, -9.30439383e-02f, 7.52802864e-02f, -4.44211736e-02f, -1.41404554e-01f, 1.36395723e-01f,
  1.46357164e-01f, -3.48099950e-03f, -1.27271086e-01f, 4.81859595e-02f, -3.05729005e-02f, 1.01723120e-01f, -3.94401401e-02f, 2.21947849e-01f, 3.40578295e-02f, -1.20452598e-01f,
  1.58858061e-01f, -1.10004134e-01f, -1.07613817e-01f, -8.11795816e-02f, 2.44874924e-01f, -6.32000938e-02f, 2.12164089e-01f, 1.28373072e-01f, 2.46728554e-01f, -1.51642054e-01f,
  -1.47220239e-01f, 1.45371712e-03f, -1.45137861e-01f, 1.90501153e-01f, -1.00686559e-02f, 1.02788754e-01f, 5.43622114e-02f, -5.76922037e-02f, 6.34574071e-02f, -6.39730021e-02f,
  -1.13829419e-01f, 7.70713240e-02f, -1.87019199e-01f, 4.97857109e-02f, -1.97757706e-01f, -1.73698232e-01f, 1.52589485e-01f, 8.32569674e-02f, 4.99613993e-02f, 6.27904683e-02f,
  1.87346146e-01f, 8.45016241e-02f, 1.32023454e-01f, 7.60977268e-02f, -2.60788828e-01f, 1.01507328e-01f, -3.07401210e-01f, 1.50040805e-01f, -2.14755028e-01f, -3.14239502e-01f,
  3.83087933e-01f, 1.90925136e-01f, -2.09823698e-01f, -2.06604511e-01f, 1.06773220e-01f, -1.85322046e-01f, 3.86416875e-02f, 1.87383160e-01f, -2.27898195e-01f, -2.98206717e-01f,
  -1.04704462e-02f, 1.33691505e-01f, 1.88644320e-01f, 7.69183412e-02f, -2.87551552e-01f, -1.00583127e-02f, 7.33801499e-02f, 2.93443620e-01f, 1.48628026e-01f, 1.44598022e-01f,
  2.90281266e-01f, 5.49751669e-02f, 1.75824910e-02f, 1.32772714e-01f, 6.50175139e-02f, 3.30331363e-02f, -1.36341020e-01f, 1.65368468e-01f, -4.70070504e-02f, -1.03108972e-01f,
  -2.68746912e-01f, 6.35882467e-02f, 5.35932090e-03f, 9.03174728e-02f, -1.37199953e-01f, 1.37688601e-02f, 5.90781122e-02f, 1.01967312e-01f, -1.61098510e-01f, 1.56863853e-02f,
  3.34515646e-02f, -2.87416846e-01f, -1.11418471e-01f, -9.16619040e-03f, -1.33510694e-01f, 2.17810631e-01f, -3.84596288e-02f, 2.03906655e-01f, 4.50062118e-02f, -1.52984455e-01f,
  -9.65307206e-02f, 2.10096557e-02f, -1.49810925e-01f, 7.58893497e-04f, 1.73450425e-01f, -2.12559681e-02f, 2.52504081e-01f, 1.25861943e-01f, 6.24357313e-02f, 1.22841904e-02f,
  1.09285891e-01f, 1.74935791e-04f, 6.92634881e-02f, -1.42584205e-01f, -1.11010812e-01f, 8.04585144e-02f, 1.50406539e-01f, -1.57794338e-02f, -4.76990454e-02f, -1.36485323e-01f,
  -6.64879382e-02f, -5.16340993e-02f, 1.24382928e-01f, -1.87703192e-01f, 4.29420285e-02f, 2.15079293e-01f, 1.41553849e-01f, -1.90750018e-01f, 3.98655832e-02f, 3.05719636e-02f,
  1.43415794e-01f, -8.89663026e-02f, -9.01983082e-02f, 8.83423239e-02f, 2.54977673e-01f, 2.16602609e-01f, 2.59500623e-01f, 6.34379983e-02f, -1.06854491e-01f, 1.26836166e-01f,
  -4.94551030e-04f, -8.42317641e-02f, 1.28631741e-01f, -5.61755225e-02f, 1.70591295e-01f, -1.12560630e-01f, -1.39385030e-01f, -5.46867549e-02f, 2.16818973e-01f, 5.03148511e-02f,
  9.98550095e-03f, -1.35727143e-02f, 1.95028216e-01f, -2.56972432e-01f, 1.32223681e-01f, 3.30947489e-01f, 1.37139320e-01f, 9.84528139e-02f, -2.56049037e-02f, -1.23703226e-01f,
  -1.79493856e-02f, 4.27332334e-02f, 2.14424990e-02f, -1.25600753e-04f, 4.30893749e-02f, -4.21218164e-02f, 1.57208502e-01f, 6.40526712e-02f, -6.18917271e-02f, 9.56018269e-02f,
  8.57525766e-02f, 6.46781269e-03f, 6.34050518e-02f, 7.29937777e-02f, -1.31540477e-01f, 3.03063035e-01f, -1.87317610e-01f, 8.57704058e-02f, 8.60524848e-02f, 7.77578279e-02f,
  -1.08231671e-01f, -1.36980534e-01f, 1.33673310e-01f, -3.08039468e-02f, 2.61424202e-02f, -9.92250443e-02f, 5.55421449e-02f, -1.26673087e-01f, 1.34643316e-01f, -4.47398424e-02f,
  2.12143987e-01f, 9.26907361e-02f, -2.13624816e-03f, -1.39964595e-01f, -1.09480195e-01f, -6.43510967e-02f, -1.39526963e-01f, 2.56279409e-01f, 8.43357295e-02f, 1.27006516e-01f,
  -1.65048033e-01f, 2.06059620e-01f, -1.59078687e-01f, -2.01085791e-01f, -1.89863995e-01f, 1.69874355e-01f, -1.06729768e-01f, 1.46783695e-01f, -9.11567286e-02f, -1.53456584e-01f,
  -6.04577623e-02f, 4.34781164e-02f, -2.17294216e-01f, 1.14197254e-01f, -2.43243784e-01f, -1.46858618e-01f, -1.68647528e-01f, -5.29663172e-03f, -1.86549634e-01f, 5.61464764e-02f,
  -1.25133604e-01f, -3.56060900e-02f, 8.63487870e-02f, -2.09964260e-01f, -1.36143550e-01f, -2.36909747e-01f, -1.39814302e-01f, 2.90822536e-02f, -1.21195279e-01f, -2.04111129e-01f,
  -3.23880231e-03f, -1.14194818e-01f, -4.30987567e-01f, 1.78417042e-01f, -1.95398435e-01f, -1.30343571e-01f, 9.18828025e-02f, -3.18869837e-02f, -3.21627371e-02f, -2.20525742e-01f,
  6.12324066e-02f, 1.33788541e-01f, -9.98038426e-02f, 1.29799964e-02f, 8.74483734e-02f, 1.58951521e-01f, 7.06093013e-02f, -1.69157743e-01f, 1.95433229e-01f, 8.16548616e-02f,
  -7.55612254e-02f, 1.26486629e-01f, -1.89739883e-01f, 2.26380825e-01f, -1.45842910e-01f, 9.58641693e-02f, 2.49746099e-01f, -9.98303220e-02f, -2.13463202e-01f, 3.68514583e-02f,
  -9.68661681e-02f, 1.52100250e-01f, -7.10091665e-02f, -1.48983866e-01f, -2.22968608e-01f, 8.05000514e-02f, -1.55975252e-01f, -1.15381137e-01f, -1.50739506e-01f, -1.47640124e-01f,
  2.27874350e-02f, 1.30671740e-01f, -4.47453558e-02f, 1.80821911e-01f, 8.47044028e-03f, 7.03105852e-02f, 2.02746484e-02f, -1.95291415e-01f, -1.52763426e-02f, -4.99324240e-02f,
  7.66740292e-02f, 1.01263911e-01f, 2.73013264e-02f, 1.68564335e-01f, -7.66898990e-02f, 3.05731267e-01f, -3.57320085e-02f, 2.24721134e-01f, 1.33098662e-01f, 1.96361527e-01f,
  2.81537563e-01f, 2.57288009e-01f, 4.92303893e-02f, -8.14546719e-02f, 1.40361592e-01f, 1.24937212e-02f, 6.89756498e-02f, -8.83652791e-02f, 4.51915711e-02f, -8.49637315e-02f,
  9.55159441e-02f, 2.39842758e-02f, -2.18532220e-01f, 2.88986713e-01f, -8.05090591e-02f, -6.54967278e-02f, 1.47468418e-01f, -4.31729592e-02f, 5.34663461e-02f, 1.43925518e-01f,
  1.27195671e-01f, -1.66222438e-01f, 4.34810668e-01f, 3.22767012e-02f, -3.03116202e-01f, -1.06091574e-01f, 9.27853212e-03f, 6.89825490e-02f, -7.10539054e-04f, 1.04673147e-01f,
  7.07491785e-02f, -4.25719768e-02f, -1.43111899e-01f, -1.19110577e-01f, 1.37045965e-01f, -4.87319194e-02f, -1.50916949e-01f, 8.07140842e-02f, -2.35713189e-04f, 1.56113163e-01f,
  1.03857823e-01f, -8.76251906e-02f, -6.84885830e-02f, 9.06318203e-02f, 1.01620860e-01f, -1.06754176e-01f, -1.21593140e-01f, 2.00066954e-01f, -5.19506596e-02f, 3.43493558e-02f,
  2.95006067e-01f, -2.82479022e-02f, -2.68088877e-02f, 2.83670157e-01f, 1.27101630e-01f, 2.22211763e-01f, -1.03270775e-02f, 9.30643082e-02f, 2.31322497e-02f, -3.14530879e-02f,
  1.51040629e-01f, -4.07893248e-02f, -1.67862013e-01f, 8.91593918e-02f, -1.49470463e-01f, 1.12884015e-01f, -1.51966915e-01f, 9.52223390e-02f, 8.56048688e-02f, -3.26400883e-02f,
  6.56089708e-02f, -1.07409433e-02f, -3.11993435e-03f, 9.34704468e-02f, -3.51409048e-01f, -1.13694899e-01f, -2.50969399e-02f, 3.68793607e-01f, -3.09916466e-01f, -3.95402431e-01f,
  2.97733754e-01f, 1.45457655e-01f, -2.78168291e-01f, -4.18473393e-01f, -5.80369309e-02f, -8.32185149e-02f, 3.47934633e-01f, 1.71000615e-01f, -2.33304247e-01f, 3.17845866e-02f,
  4.97809723e-02f, -2.21922681e-01f, 2.50384718e-01f, 1.10481247e-01f, 1.46819663e-03f, 4.29617390e-02f, -2.95085639e-01f, 1.09644718e-02f, 6.02478273e-02f, 1.79165989e-01f,
  -1.56207934e-01f, 2.32294664e-01f, 1.67032391e-01f, 1.11310193e-02f, -2.51602642e-02f, 7.57900327e-02f, 7.69915953e-02f, -9.75496992e-02f, 1.26118377e-01f, 7.50122294e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  5.96266501e-02f, -7.35073313e-02f, 3.80534947e-01f, 1.87378660e-01f, 1.73865259e-02f, -1.81851476e-01f, -3.45509723e-02f, 4.76361476e-02f, -8.66302103e-02f, 1.00114986e-01f,
  3.51877809e-02f, 1.40795941e-02f, 2.49418199e-01f, -8.08155462e-02f, 1.16673090e-01f, 8.09776261e-02f, 8.19080696e-02f, 2.55720109e-01f, -1.61795765e-01f, 6.10919520e-02f,
  2.78835654e-01f, 4.12862211e-01f, -4.16587330e-02f, 1.83809642e-02f, 3.28610279e-02f, 2.20628485e-01f, -4.25945856e-02f, -8.85354578e-02f, -3.44543755e-02f, -1.22507803e-01f,
  -6.80431724e-01f, -1.49279937e-01f, -2.42607176e-01f, -4.44738269e-01f, 4.18192744e-01f, 9.05791447e-02f, -8.30207020e-02f, 1.30372733e-01f, 5.30837029e-02f, -2.39758864e-01f,
  -1.51553035e-01f, -4.19869781e-01f, 3.45360786e-01f, -2.12310344e-01f, 3.04778844e-01f, 6.25474989e-01f, -1.41349122e-01f, 1.07237948e-02f, -3.35570574e-01f, -3.63163613e-02f,
  -8.89974926e-03f, 1.03267379e-01f, 2.71267176e-01f, 2.50086099e-01f, -7.45216459e-02f, 1.71445459e-01f, 1.81999445e-01f, 3.96163650e-02f, 7.51603246e-02f, -1.48960762e-02f,
  -5.91387413e-02f, -2.89100021e-01f, 6.40136823e-02f, -1.19565785e-01f, 1.81262225e-01f, 4.77578580e-01f, -1.83906317e-01f, 5.01506567e-01f, -4.30792034e-01f, 1.46210507e-01f,
  -1.54944826e-02f, 2.48420164e-01f, 2.86952317e-01f, -8.20528790e-02f, -1.80171400e-01f, 1.08426787e-01f, -7.61422142e-02f, -6.76953271e-02f, -4.80976254e-02f, 1.61040083e-01f,
  1.58455431e-01f, -2.52120525e-01f, -4.96528763e-03f, -1.32179961e-01f, 1.49275601e-01f, -3.89343500e-02f, 1.40180454e-01f, -9.32690054e-02f, 1.20635480e-02f, 4.12838012e-01f,
  4.20924217e-01f, -2.61070877e-01f, 4.06399462e-03f, -3.49561423e-02f, 2.01047122e-01f, -1.90309674e-01f, 3.75617057e-01f, 3.61948907e-01f, -1.75882056e-01f, -4.25519288e-01f,
  -1.18150398e-01f, 1.38331980e-01f, -2.01597035e-01f, 3.41052741e-01f, -5.82492389e-02f, 3.10145140e-01f, -4.36432473e-02f, 4.57981735e-01f, 2.21743241e-01f, -4.06649038e-02f,
  -2.36071363e-01f, 1.34674892e-01f, 7.55055845e-02f, 2.47560620e-01f, 2.66361803e-01f, -3.22325877e-03f, 1.52835295e-01f, 1.18732043e-01f, 1.60096720e-01f, 2.62956887e-01f,
  1.39580771e-01f, 9.43058729e-02f, 1.72509015e-01f, 2.00297371e-01f, 2.14979261e-01f, -3.67088616e-01f, 2.91734904e-01f, -1.21309765e-01f, 4.22916174e-01f, 3.23123038e-01f,
  -3.43463629e-01f, 6.81135058e-02f, 1.67081550e-01f, 2.67762572e-01f, 2.29938373e-01f, 8.62609223e-02f, 4.52917553e-02f, -1.06169596e-01f, -2.18122862e-02f, 1.58288956e-01f,
  -5.09481505e-02f, 4.10156995e-01f, 2.99000144e-01f, -1.77005619e-01f, 4.23838377e-01f, 7.37565011e-02f, 2.14631766e-01f, -9.87295434e-03f, -1.84519812e-01f, 1.21017404e-01f,
  2.15019971e-01f, 5.84390275e-02f, 5.24875559e-02f, -2.79212624e-01f, -2.08143383e-01f, 2.08931118e-01f, -2.01063398e-02f, -7.93986470e-02f, 5.49237609e-01f, 2.56980896e-01f,
  -4.85776588e-02f, 2.08819702e-01f, -3.30268949e-01f, -1.31147072e-01f, -1.65193185e-01f, -2.57788062e-01f, 1.48754567e-02f, -5.59159778e-02f, 9.18146074e-02f, -3.96103896e-02f,
  1.40135899e-01f, 2.07985997e-01f, 1.33074187e-02f, -7.28137672e-01f, 1.67100877e-01f, -2.47867420e-01f, -6.33363437e-04f, 1.40464857e-01f, -1.40801042e-01f, 4.89997603e-02f,
  -2.92979181e-01f, 1.09994728e-02f, -1.40383571e-01f, -5.36970533e-02f, 9.68607794e-03f, 2.82819360e-01f, 2.48695716e-01f, 1.80046663e-01f, 3.06521654e-01f, 1.76487774e-01f,
  1.85269222e-01f, 5.01543395e-02f, 8.46930891e-02f, 6.45004362e-02f, -2.86809385e-01f, -7.62956440e-02f, 3.57070029e-01f, 1.68652311e-01f, 2.20853731e-01f, -3.79103124e-02f,
  9.62867066e-02f, 2.23628819e-01f, 8.72809961e-02f, 1.61827669e-01f, 6.85328096e-02f, 2.47352600e-01f, 1.55629024e-01f, 6.25676215e-02f, 7.88939744e-02f, 1.97893292e-01f,
  1.24996595e-01f, -1.28822073e-01f, -2.13465884e-01f, 1.23474374e-01f, 1.53900638e-01f, 1.00972228e-01f, 2.56848663e-01f, -1.95836827e-01f, -3.67039591e-01f, 1.70324892e-01f,
  -2.63060391e-01f, 1.29841015e-01f, 3.98988754e-01f, 2.87930995e-01f, -1.24667972e-01f, -1.45527422e-01f, 2.08956838e-01f, 2.43691832e-01f, -4.31120425e-01f, -3.87113065e-01f,
  -3.03681642e-02f, -5.10261022e-02f, 1.54191256e-01f, 2.93367714e-01f, -2.18530223e-01f, -2.81185228e-02f, 1.60973787e-01f, -3.74006540e-01f, 1.66998297e-01f, -9.04709753e-03f,
  -2.10877523e-01f, 6.42432198e-02f, -4.00170386e-01f, -1.92617908e-01f, -2.64168411e-01f, -7.10738897e-02f, -1.63994089e-01f, -7.49972090e-02f, 1.79355294e-01f, 1.81685060e-01f,
  1.23268083e-01f, 3.24420393e-01f, 2.61728913e-01f, -2.71008730e-01f, 1.04976349e-01f, -6.54093176e-02f, -4.77126539e-02f, 2.38097489e-01f, 9.44330264e-03f, -8.02761093e-02f,
  -2.65788753e-02f, -1.21083669e-01f, 4.84869443e-02f, -3.68109681e-02f, 3.76606107e-01f, -2.17088908e-02f, -1.89901143e-01f, 4.84596848e-01f, -1.78184435e-01f, 1.46339953e-01f,
  2.54413307e-01f, 4.79054898e-02f, 3.75621587e-01f, 2.76573393e-02f, 2.40892246e-02f, 3.23751748e-01f, -1.18371397e-01f, -1.07247233e-02f, 3.34806561e-01f, 1.37762204e-01f,
  5.96715957e-02f, -6.39716759e-02f, 2.47444183e-01f, -2.53940504e-02f, -1.48628980e-01f, -5.54909885e-01f, 3.20257097e-01f, 4.55893040e-01f, -6.38656691e-02f, 8.51892531e-02f,
  -2.30637416e-01f, 2.41886124e-01f, 3.27769101e-01f, -2.19248176e-01f, 1.71707630e-01f, -2.22335204e-01f, -1.34391785e-01f, 5.63592315e-02f, 1.87118612e-02f, -1.54267456e-02f,
  -9.11567956e-02f, -1.56745628e-01f, 3.35720628e-01f, -3.62283736e-01f, 1.77444488e-01f, -1.70383707e-01f, -7.16594234e-02f, -1.27024159e-01f, -5.27300894e-01f, 1.68172941e-01f,
  -2.54748493e-01f, 2.25376219e-01f, 2.57273704e-01f, 4.06228572e-01f, -1.37894049e-01f, -2.60700881e-01f, -3.92910272e-01f, 1.15061492e-01f, 1.30408227e-01f, 7.00604841e-02f,
  -2.46741951e-01f, -3.08298450e-02f, -5.86603045e-01f, 1.58852071e-03f, 1.88780919e-01f, 3.86860073e-02f, 2.14776412e-01f, -2.24777341e-01f, 2.49071479e-01f, 6.61104321e-02f,
  1.38450578e-01f, 1.80497408e-01f, -6.04894459e-01f, -1.06995702e-01f, -8.82330462e-02f, 1.94047794e-01f, 1.15291558e-01f, -1.77691504e-02f, 1.79221436e-01f, 2.21389934e-01f,
  5.72533645e-02f, -2.20507368e-01f, -1.44139469e-01f, 2.00090975e-01f, -1.14863403e-01f, 2.78375838e-02f, 2.34121963e-01f, -5.20936362e-02f, -3.59631568e-01f, -2.34583557e-01f,
  2.47168746e-02f, 2.98830479e-01f, -4.67822224e-01f, -3.12933713e-01f, -3.44675899e-01f, 3.17183942e-01f, -3.15297723e-01f, -7.91977048e-02f, 1.14974566e-01f, -4.54043627e-01f,
  2.29119971e-01f, 4.95130457e-02f, 8.86819884e-02f, 1.31847009e-01f, 3.13573964e-02f, -6.73647411e-03f, 4.92430270e-01f, 8.19576457e-02f, -1.85649216e-01f, -2.99646735e-01f,
  -4.53223772e-02f, -2.34272137e-01f, -1.07400194e-01f, 1.25019997e-01f, 7.66694173e-02f, -1.39410436e-01f, 1.24886669e-01f, 4.23873246e-01f, -2.38339141e-01f, 4.04666245e-01f,
  2.36485437e-01f, -7.65097747e-03f, -2.46222883e-01f, 3.55056345e-01f, -4.40629050e-02f, -1.06027685e-01f, 7.55300447e-02f, 1.86497480e-01f, -3.71640064e-02f, -1.83860093e-01f,
  1.30493239e-01f, 2.02300221e-01f, 3.34841669e-01f, -1.60269767e-01f, -1.15209475e-01f, -3.03189158e-01f, 1.56551853e-01f, 9.55964327e-02f, -1.01146707e-02f, 1.63417622e-01f,
  1.91073790e-01f, -1.22322418e-01f, 2.17655697e-03f, -1.96857050e-01f, 1.92414988e-02f, 1.58653364e-01f, 4.35589172e-04f, 8.07640329e-02f, -7.09377825e-02f, 2.35983506e-01f,
  9.44584757e-02f, 2.13552505e-01f, 8.30857754e-02f, -5.77732287e-02f, -3.57881188e-01f, 1.46598712e-01f, -6.58047050e-02f, 1.78622633e-01f, -2.39203647e-01f, -1.19484954e-01f,
  -1.35036528e-01f, -2.03743264e-01f, -3.18929374e-01f, 3.43930602e-01f, -2.70133585e-01f, -2.05655564e-02f, 2.88792819e-01f, 3.15764517e-01f, 2.56192267e-01f, 1.57416150e-01f,
  3.87266397e-01f, 1.86384439e-01f, -3.15000296e-01f, -3.28339003e-02f, 4.35889214e-01f, -1.37314042e-02f, 3.90984416e-01f, -3.22702020e-01f, 1.87938720e-01f, 7.69576728e-02f,
  7.17998073e-02f, 6.51827082e-02f, 7.92464986e-02f, 9.93490666e-02f, 2.23481163e-01f, 5.26084527e-02f, -3.81034136e-01f, -6.69660941e-02f, 1.47600964e-01f, 2.65416391e-02f,
  2.94597834e-01f, -2.07881421e-01f, 5.75894080e-02f, 8.89290646e-02f, 1.49031058e-01f, 2.60237992e-01f, -2.38215193e-01f, 2.23472804e-01f, 2.04058930e-01f, -3.39969546e-01f,
  2.29431331e-01f, 2.36387625e-02f, 1.51133344e-01f, 4.73845661e-01f, 6.37685657e-02f, 3.41214389e-01f, 5.06635495e-02f, 5.68972938e-02f, 2.90864766e-01f, 4.18629050e-01f,
  -9.04824212e-02f, -9.29697528e-02f, 3.32065582e-01f, -2.59196222e-01f, -2.12058336e-01f, 3.36123765e-01f, -1.48731157e-01f, 6.34213313e-02f, 9.76641551e-02f, -3.04723829e-01f,
  -1.16773486e-01f, -3.15608352e-01f, -1.17311887e-01f, 1.83185134e-02f, 1.13282256e-01f, 3.50348949e-02f, 2.51670718e-01f, -1.26277572e-02f, -1.37634203e-01f, -5.17485619e-01f,
  3.32251519e-01f, -5.00903912e-02f, 1.47243828e-01f, -1.27231758e-02f, 8.44161287e-02f, -5.22745311e-01f, -1.74314857e-01f, 1.14668377e-01f, 1.98881645e-02f, -5.46952337e-03f,
  -1.67220399e-01f, 1.13636695e-01f, -7.46168941e-02f, -4.42658588e-02f, 4.15326864e-01f, -1.47276521e-01f, 1.70044586e-01f, 2.61421114e-01f, 3.09052199e-01f, -7.02713281e-02f,
  1.76384389e-01f, 8.95859599e-02f, 3.56216699e-01f, 5.75471073e-02f, -1.22494809e-01f, 6.00468973e-03f, 1.63468763e-01f, 2.25406796e-01f, 5.60225174e-03f, -1.54584527e-01f,
  -1.12402756e-02f, 3.29142846e-02f, 1.57419235e-01f, 1.94091231e-01f, 1.12618968e-01f, 3.30931723e-01f, 4.73999791e-02f, 5.08668199e-02f, 2.02828839e-01f, 3.36587913e-02f,
  -2.39069783e-03f, -2.90819276e-02f, 9.89911780e-02f, 4.57433686e-02f, 3.41632396e-01f, 1.16789892e-01f, 1.55782830e-02f, 2.13374406e-01f, -2.55228411e-02f, -8.90835077e-02f,
  -9.90025029e-02f, 2.00991798e-02f, -1.10198483e-01f, 2.95497358e-01f, -5.82052693e-02f, -1.47530541e-01f, 3.22520345e-01f, 5.83659764e-03f, 1.32343604e-03f, 7.27708191e-02f,
  6.51933923e-02f, 7.92933032e-02f, 3.17800134e-01f, 4.69687432e-01f, -2.41310149e-01f, -3.61235738e-01f, 4.65755798e-02f, -1.75719395e-01f, -3.54690105e-03f, 6.23607123e-03f,
  -1.25693962e-01f, 1.35292053e-01f, -4.06510860e-01f, -2.23217413e-01f, 1.06127769e-01f, 3.01970720e-01f, -2.15597123e-01f, 4.57147241e-01f, 9.33148414e-02f, 2.65987813e-01f,
  2.79717416e-01f, -2.33453557e-01f, -1.48498788e-01f, -2.96653390e-01f, 2.19422519e-01f, -4.45328802e-01f, -4.57684100e-02f, 2.92139560e-01f, -2.79480089e-02f, 4.46331650e-01f,
  6.86597601e-02f, -3.84277776e-02f, 6.84200674e-02f, 1.22888371e-01f, 1.42720863e-01f, -2.66164273e-01f, 2.46894330e-01f, 5.16171813e-01f, 5.31714968e-02f, 1.06632911e-01f,
  2.97595784e-02f, -9.83878896e-02f, 1.53655171e-01f, -2.46784806e-01f, 1.41845763e-01f, 1.22623496e-01f, 5.43950088e-02f, -1.55664012e-01f, -1.68580905e-01f, 2.43685186e-01f,
  6.75149262e-02f, 2.07383275e-01f, 2.47956038e-01f, -1.13323912e-01f, 3.43484104e-01f, 1.77037984e-01f, -8.56588595e-03f, 7.82664716e-02f, 2.78216541e-01f, 3.75629425e-01f,
  7.76198506e-02f, -1.90714419e-01f, -1.97252408e-01f, 9.48964506e-02f, -2.35741705e-01f, 2.48931915e-01f, 1.64045647e-01f, 4.15752888e-01f, 7.87298083e-02f, 1.63646355e-01f,
  7.99494013e-02f, -2.09630549e-01f, -1.41486019e-01f, 2.80593902e-01f, 8.02178085e-02f, 1.63190469e-01f, 1.90683991e-01f, -7.62557164e-02f, 3.16188335e-01f, 8.72999132e-02f,
  3.36222202e-01f, 2.58918375e-01f, -7.44496882e-02f, 2.70045191e-01f, 1.67699322e-01f, 1.84352204e-01f, 1.21560976e-01f, -4.00057472e-02f, 2.81545490e-01f, 1.90245017e-01f,
  2.39205584e-01f, 2.43358195e-01f, 1.89524263e-01f, 7.81307593e-02f, -1.63549632e-01f, -2.95933858e-02f, -1.34115845e-01f, 1.36871755e-01f, 1.56658038e-01f, 2.47801796e-01f,
  7.79637019e-04f, -1.27862230e-01f, 5.62555492e-02f, -2.43972749e-01f, 1.17680803e-01f, 2.63384074e-01f, 2.78727636e-02f, -5.80620989e-02f, -4.28134263e-01f, 1.09820090e-01f,
  4.02679741e-01f, 5.89467347e-01f, -7.72479996e-02f, -2.95664072e-01f, 1.17390659e-02f, 2.34395027e-01f, -6.57060519e-02f, 3.34374607e-02f, -2.28080079e-01f, -2.26413235e-01f,
  -1.20211765e-01f, -1.20977059e-01f, 1.41806677e-01f, -3.07267934e-01f, 9.38761327e-03f, -1.55766860e-01f, -1.49013689e-02f, 2.44605109e-01f, -2.06096798e-01f, 1.04276845e-02f,
  -4.15559947e-01f, -2.28634000e-01f, 3.40556055e-01f, 7.54456315e-03f, 1.71105474e-01f, 3.79266143e-01f, 7.04258457e-02f, -1.45474479e-01f, -8.58015642e-02f, 1.59912288e-01f,
  3.67829879e-03f, 5.12072667e-02f, 6.41001910e-02f, 2.38294780e-01f, -2.33945772e-02f, -3.12721287e-03f, 2.98960060e-01f, -1.18744113e-01f, 1.08840033e-01f, 1.57129481e-01f,
  7.65197873e-02f, -3.32262903e-01f, 1.69626996e-01f, 2.11807955e-02f, -1.52682498e-01f, 2.60001510e-01f, -2.60584652e-01f, -1.29829980e-02f, 2.33646229e-01f, -1.13645084e-01f,
  2.06581622e-01f, 2.60402244e-02f, 1.13549985e-01f, -2.16675131e-03f, 2.09915966e-01f, 2.96477944e-01f, -2.02087939e-01f, 4.79019284e-02f, 5.21688983e-02f, 1.03608586e-01f,
  1.76264584e-01f, 2.06252620e-01f, -7.85425305e-02f, -8.25210381e-03f, -9.36272368e-02f, -5.47924601e-02f, 5.16338572e-02f, 7.07702637e-02f, 3.29798907e-01f, -3.00971349e-03f,
  4.02868718e-01f, 1.37473315e-01f, -1.32440224e-01f, 1.06021278e-01f, -1.74759433e-01f, 4.83629644e-01f, -4.17645395e-01f, -3.54860365e-01f, 1.70076206e-01f, -2.17555352e-02f,
  -2.11232483e-01f, -3.26167017e-01f, -2.41556969e-02f, -2.10351706e-01f, 5.57007268e-02f, 3.11981708e-01f, -1.20242760e-01f, -1.30145505e-01f, 3.46640088e-02f, 1.19312800e-01f,
  3.91343325e-01f, -1.32219747e-01f, -3.57211292e-01f, -6.65496811e-02f, -1.50582448e-01f, -3.88722926e-01f, 1.74115933e-02f, 2.20690355e-01f, 7.40208803e-03f, 2.20715478e-01f,
  2.87760824e-01f, 2.19289988e-01f, 1.66244894e-01f, -1.00035638e-01f, -1.56178609e-01f, -5.06767072e-02f, 5.73650524e-02f, -6.21457547e-02f, 2.22847864e-01f, -4.69912767e-01f,
  1.12274028e-01f, 4.01075155e-01f, 1.81275129e-01f, 2.25536987e-01f, 2.69573659e-01f, -4.61163312e-01f, 8.07812139e-02f, 2.28974111e-02f, -9.83257070e-02f, 2.44245589e-01f,
  6.40286207e-02f, 9.69601721e-02f, -6.02567792e-02f, -1.42287910e-01f, -4.06291112e-02f, 9.80094373e-02f, -7.39273429e-02f, 2.11843655e-01f, 3.17484856e-01f, 9.88803878e-02f,
  6.14444874e-02f, 1.53299376e-01f, -3.45758140e-01f, 4.80125487e-01f, 1.18008941e-01f, -2.26611823e-01f, 1.23733006e-01f, -6.45634681e-02f, -4.25031126e-01f, 4.65813540e-02f,
  4.39024754e-02f, 1.79616138e-01f, 3.40204030e-01f, 1.49594456e-01f, -3.66644077e-02f, 2.61924714e-01f, -1.50743514e-01f, 2.05656812e-02f, 1.58538986e-02f, -4.74913456e-02f,
  2.46247947e-01f, -2.18638126e-02f, 2.64612049e-01f, 1.68784425e-01f, -2.81012446e-01f, 7.13542879e-01f, -2.42447168e-01f, 3.70085724e-02f, -1.26654804e-01f, -1.70612216e-01f,
  5.47107816e-01f, 2.15690002e-01f, 1.94557875e-01f, -1.01224281e-01f, -1.93515912e-01f, 3.39373291e-01f, 1.70096725e-01f, -8.00738782e-02f, 1.96235389e-01f, -1.35763451e-01f,
  -6.85655177e-02f, 4.23513502e-01f, -3.32539231e-02f, 9.24582407e-02f, 3.03184897e-01f, -1.53425887e-01f, -4.15503718e-02f, 1.72813669e-01f, -3.28841239e-01f, 9.09220949e-02f,
  -2.35968698e-02f, 2.23840043e-01f, -1.16273135e-01f, -1.00056514e-01f, 1.28746524e-01f, -3.88560258e-02f, 1.89198077e-01f, 6.74016625e-02f, -2.14774609e-01f, 1.03006281e-01f,
  1.54609770e-01f, 2.64988728e-02f, -4.35862206e-02f, 3.70162204e-02f, 1.75754800e-01f, -9.31990985e-03f, -3.06490995e-02f, -3.56267244e-02f, -7.10761547e-02f, -3.09008360e-02f,
  -2.77733296e-01f, -3.38979572e-01f, 2.36067325e-01f, 1.24807432e-01f, 1.57510653e-01f, -1.51791861e-02f, -2.89719980e-02f, 2.70121962e-01f, 3.97618711e-01f, -9.73488986e-02f,
  3.55618745e-01f, -1.27300555e-02f, 1.90759972e-01f, -9.03297886e-02f, -5.01088649e-02f, -3.37136000e-01f, -2.18313515e-01f, -1.14205852e-02f, 1.10056400e-01f, -2.18738064e-01f,
  1.52463019e-01f, 8.98934752e-02f, -1.70337558e-02f, 5.24433434e-01f, -4.61712182e-01f, 2.06802070e-01f, -5.70799485e-02f, 2.91348100e-01f, 3.39148603e-02f, 1.93131402e-01f,
  -8.55519697e-02f, 7.47594833e-02f, -2.16348663e-01f, 4.42990661e-01f, 2.01541156e-01f, 1.58654660e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.87996075e-01f, 7.39651965e-03f, 1.44110873e-01f, -1.41105670e-02f, 1.88773111e-01f, 1.41612992e-01f, 1.37607262e-01f, 2.91638970e-01f, 4.43259114e-03f, 1.73876472e-02f,
  1.76296353e-01f, 3.65048237e-02f, 1.12280190e-01f, 2.22023055e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  2.78673351e-01f, 1.68608516e-01f, -2.99112886e-01f, -4.52312678e-01f, -6.90963194e-02f, -8.59128758e-02f, 5.17274551e-02f, -3.63105126e-02f, 1.93549976e-01f, -1.47031203e-01f,
  2.03659106e-02f, 2.20103279e-01f, -3.55802774e-01f, 3.07674855e-01f, -3.08971971e-01f, 1.97380587e-01f, 1.50992721e-01f, 1.11388065e-01f, 1.02334455e-01f, -1.53661549e-01f,
  -1.19945565e-02f, -2.20915675e-01f, 2.11529732e-01f, 1.54447988e-01f, 2.97753900e-01f, -1.57626513e-02f, 4.15456861e-01f, 1.46433890e-01f, 3.06052983e-01f, -2.48575255e-01f,
  -2.46541277e-01f, 1.85359001e-01f, -3.79655600e-01f, 2.17945412e-01f, -2.27323666e-01f, 3.41898859e-01f, -1.79097310e-01f, -2.68415302e-01f, -3.80862206e-01f, 3.67309898e-01f,
  -4.86192822e-01f, 1.80736557e-01f, 3.32845986e-01f, -2.06582204e-01f, 3.74260783e-01f, -3.46803814e-01f, 3.64330828e-01f, 1.90853223e-01f, 4.91020083e-02f, 2.45192319e-01f,
  -3.31082523e-01f, -4.68652964e-01f, 7.46485665e-02f, -2.77028322e-01f, 1.66885287e-01f, -4.43312936e-02f, -2.77795225e-01f, -2.33378887e-01f, -2.38566980e-01f, -3.02015394e-01f,
  -3.30864966e-01f, -2.50353485e-01f, -4.93082136e-01f, 3.30704182e-01f, 1.90525532e-01f, 7.49527588e-02f, 3.06019455e-01f, 3.96753103e-01f, 1.32824033e-01f, 1.98162675e-01f,
  -7.17337653e-02f, -1.10519186e-01f, 1.63448989e-01f, -1.30940408e-01f, 2.74991006e-01f, 2.39961237e-01f, -1.62611175e-02f, -2.32577041e-01f, 3.92281357e-03f, 1.52621076e-01f,
  4.22245488e-02f, 6.72328845e-02f, 4.38932292e-02f, 4.21417981e-01f, -7.16116205e-02f, 1.26774535e-02f, 2.59124339e-01f, 1.82309508e-01f, 4.69849020e-01f, -1.45792872e-01f,
  1.39971986e-01f, -2.21998259e-01f, 3.94937247e-02f, -3.66728790e-02f, -3.73131633e-02f, 3.66536915e-01f, 2.88006186e-01f, 1.14802919e-01f, 3.16458166e-01f, -1.66728705e-01f,
  -5.85602745e-02f, -1.78437904e-01f, 2.45508462e-01f, -1.67748287e-01f, -1.05196990e-01f, -4.79806602e-01f, 1.31573901e-01f, 3.17918003e-01f, -1.61490098e-01f, 1.23823628e-01f,
  -2.52584636e-01f, -2.01245189e-01f, -1.79681048e-01f, 1.05313264e-01f, 1.60680309e-01f, 1.65644065e-01f, -2.76852161e-01f, -3.75053018e-01f, -1.51326418e-01f, -3.33466560e-01f,
  -2.60905832e-01f, 1.99624658e-01f, -1.86374366e-01f, -1.56197429e-01f, 3.80431056e-01f, -1.50273740e-01f, -4.74161386e-01f, 1.49132147e-01f, -1.10529415e-01f, 2.25799710e-01f,
  5.71448766e-02f, 3.56229544e-02f, 2.20910981e-01f, 2.47776657e-01f, 2.71649957e-01f, -1.30660549e-01f, -1.24320209e-01f, 6.01715967e-02f, 1.22844458e-01f, 7.77082592e-02f,
  2.69649904e-02f, 1.14002995e-01f, 1.13862768e-01f, -1.69983208e-01f, -3.87919657e-02f, 3.10326993e-01f, 3.64010297e-02f, 3.55027556e-01f, -9.34973583e-02f, -1.52528092e-01f,
  -9.98186618e-02f, 2.51319528e-01f, -3.74950022e-01f, -2.07065523e-01f, -2.37503558e-01f, 3.02912682e-01f, -1.38395071e-01f, -5.28386414e-01f, -1.54179543e-01f, 1.51419550e-01f,
  3.68488193e-01f, 2.37231771e-03f, -3.89744967e-01f, -1.29858449e-01f, 3.70141357e-01f, -2.56035626e-01f, 3.17412287e-01f, -7.33768393e-04f, -3.80004227e-01f, -1.21911667e-01f,
  -2.45301545e-01f, -2.66506165e-01f, 2.08743423e-01f, 4.13449816e-02f, -2.72617072e-01f, 4.67344485e-02f, -1.38501264e-02f, 4.89997864e-02f, -5.40386327e-02f, -6.54931843e-01f,
  9.90086719e-02f, 4.48478848e-01f, -7.50514746e-01f, 1.20387658e-01f, -4.90817696e-01f, 2.66971499e-01f, -8.58177766e-02f, -8.76510501e-01f, -1.11886002e-01f, 2.60735098e-02f,
  -3.24087113e-01f, -5.95308058e-02f, 9.14940313e-02f, -4.66704845e-01f, 2.91388631e-01f, 2.63310596e-02f, 1.27236649e-01f, -1.94730625e-01f, -3.21650244e-02f, -1.19381361e-01f,
  -1.84114739e-01f, 3.37272845e-02f, 1.00535154e-01f, -3.04498345e-01f, -4.21088561e-02f, -2.31131598e-01f, -1.35211810e-01f, -1.84711784e-01f, -2.33092174e-01f, 5.76400384e-03f,
  3.22064608e-02f, 1.78064778e-01f, 6.85778707e-02f, -7.97698200e-02f, -3.91846895e-01f, 4.70627248e-02f, 1.68936118e-01f, 1.11912154e-02f, 2.48522073e-01f, -1.28316790e-01f,
  -3.67256284e-01f, 1.20552443e-01f, -3.63586610e-03f, -5.83098195e-02f, -2.51502424e-01f, 1.28530085e-01f, -2.55610943e-01f, 1.31167382e-01f, 2.64834225e-01f, -2.76631773e-01f,
  -7.59031251e-02f, 2.89271008e-02f, 1.95988268e-01f, -7.30001554e-02f, -2.79724956e-01f, -9.23130102e-03f, -2.55437285e-01f, -3.23828429e-01f, -8.98947418e-02f, 2.78987229e-01f,
  -2.40184311e-02f, 4.52734865e-02f, -3.50429267e-01f, -4.13447529e-01f, 6.56231344e-02f, -5.67530505e-02f, 2.15365924e-02f, 2.17953086e-01f, -5.48456967e-01f, -6.04950547e-01f,
  -3.10669929e-01f, -8.92245844e-02f, -4.35407996e-01f, -3.73912573e-01f, 4.43394929e-01f, 6.06808923e-02f, -4.83727366e-01f, 5.52307814e-02f, -1.80787109e-02f, 1.00413501e-01f,
  8.73376653e-02f, -3.48190740e-02f, -3.39146405e-01f, 2.29211345e-01f, 3.48142674e-03f, 1.67720526e-01f, -3.46119344e-01f, -4.79136929e-02f, 1.94775015e-01f, -1.56150609e-01f,
  2.93962479e-01f, 1.20903462e-01f, -4.87110345e-03f, -1.07503079e-01f, 2.33018156e-02f, 6.26287535e-02f, 4.60864864e-02f, -2.58458499e-02f, 2.63969272e-01f, -1.37476146e-01f,
  -3.51617694e-01f, 8.04154724e-02f, -1.57178700e-01f, 2.28624836e-01f, 2.82186657e-01f, 2.21442327e-01f, -1.03644133e-01f, 7.94447437e-02f, -6.16431013e-02f, 2.80293286e-01f,
  2.90795833e-01f, -2.32564639e-02f, 2.23478138e-01f, 2.63616115e-01f, -3.20576161e-01f, -1.22833639e-01f, 7.96580389e-02f, 3.18131447e-01f, 2.78328985e-01f, -1.79448813e-01f,
  1.76566273e-01f, 2.77589887e-01f, 2.40878507e-01f, -1.28654703e-01f, 1.66207492e-01f, 1.39518306e-01f, -4.64987934e-01f, -1.24527119e-01f, 6.78876415e-02f, 4.10406329e-02f,
  2.73087978e-01f, 2.86864489e-01f, 5.32995835e-02f, -1.34070203e-01f, -4.06290591e-01f, -1.08772293e-01f, -3.19287390e-01f, 2.18439281e-01f, -3.68376732e-01f, 8.49799588e-02f,
  -3.54630411e-01f, 1.46572873e-01f, 3.03833764e-02f, 1.27167910e-01f, -4.76943329e-02f, 4.35776711e-02f, 6.64393380e-02f, -6.16705380e-02f, 1.18393637e-01f, 2.96278656e-01f,
  2.53352463e-01f, -8.69910419e-02f, 4.30903621e-02f, 3.15678298e-01f, -1.74945086e-01f, 8.09451640e-02f, 5.20148091e-02f, -1.11419357e-01f, -1.78086713e-01f, -3.88728529e-01f,
  8.50085467e-02f, 1.01873167e-01f, -3.83581638e-01f, -2.97108386e-02f, -3.23725104e-01f, 2.91618645e-01f, -6.49825558e-02f, -3.93257767e-01f, -1.43076152e-01f, 4.02779371e-01f,
  -8.95026103e-02f, -1.59059644e-01f, 2.65245229e-01f, -1.98964536e-01f, 2.40139052e-01f, 3.98765579e-02f, 8.30482543e-02f, -1.21087134e-02f, 7.73640408e-04f, -2.68076450e-01f,
  4.58026648e-01f, 3.06224138e-01f, 1.24139167e-01f, 2.23408356e-01f, -1.11151345e-01f, 1.33208662e-01f, 2.19620079e-01f, -1.02761328e-01f, 1.61658630e-01f, -3.95527780e-01f,
  -1.50263123e-03f, -6.89013749e-02f, 6.27945364e-02f, 7.95051754e-02f, 1.69032291e-01f, -3.86533320e-01f, 8.65013525e-03f, -1.15497177e-02f, 3.81088763e-01f, -7.18694627e-02f,
  -6.46682978e-02f, 1.93319872e-01f, -3.78547281e-01f, 1.46503970e-01f, 2.13599801e-02f, 1.24114238e-01f, 8.61459151e-02f, 1.64716318e-02f, -4.75339554e-02f, -9.90573913e-02f,
  8.02314878e-02f, -1.35927290e-01f, -2.08610341e-01f, -1.08058773e-01f, -1.12317681e-01f, -5.34030981e-02f, -2.34772004e-02f, -1.40137404e-01f, -4.04491052e-02f, -1.21801542e-02f,
  -2.54566878e-01f, -3.14228386e-01f, 1.10924952e-01f, 1.01769373e-01f, 1.00556284e-01f, -4.85436693e-02f, -2.43144289e-01f, 1.44517243e-01f, -5.23110665e-02f, 1.31422743e-01f,
  -5.38037643e-02f, -3.00087661e-01f, 9.84252915e-02f, -2.51910210e-01f, 2.26168782e-01f, -4.19283360e-01f, -1.29235089e-01f, -4.15041484e-02f, -1.64332479e-01f, 4.05430585e-01f,
  -1.72369272e-01f, -5.01994267e-02f, -6.35988861e-02f, 3.23037297e-01f, -3.60648904e-04f, -2.66686045e-02f, 5.95311038e-02f, -3.79748672e-01f, 4.25470434e-02f, 2.43179113e-01f,
  1.34781837e-01f, 3.07861805e-01f, -2.56423116e-01f, -3.67635190e-01f, 2.68312633e-01f, 9.40770134e-02f, -3.12358677e-01f, -2.27579087e-01f, -2.59717017e-01f, -5.64852357e-01f,
  2.82073855e-01f, 1.42153710e-01f, -3.02354485e-01f, -6.93100691e-02f, 2.37812370e-01f, -2.94348121e-01f, 2.33701453e-01f, -3.35982114e-01f, 4.23390754e-02f, -1.65631577e-01f,
  2.00907990e-01f, -5.11101373e-02f, 6.44157231e-02f, -7.30575770e-02f, 5.05621061e-02f, -1.63652182e-01f, 4.01578508e-02f, -8.54008570e-02f, -1.28689945e-01f, -2.13285655e-01f,
  -2.63724178e-01f, 3.05368751e-02f, 2.86369724e-03f, 2.86610592e-02f, -8.58905539e-02f, -2.90172528e-02f, -8.53527337e-03f, -6.25150949e-02f, -4.00819838e-01f, 1.05774835e-01f,
  -3.76741812e-02f, 1.00346103e-01f, 4.90189828e-02f, 1.77625209e-01f, -2.36009121e-01f, 8.22909698e-02f, 9.63633135e-02f, 2.60002166e-01f, -1.54246995e-02f, 3.10195684e-01f,
  1.03774026e-01f, 3.54830563e-01f, -8.36763252e-03f, -1.91452771e-01f, 2.81499736e-02f, 1.89087227e-01f, -1.73226018e-02f, 1.67477224e-02f, 2.18198329e-01f, 5.81832454e-02f,
  -5.12935445e-02f, -1.35605961e-01f, 3.05624992e-01f, 1.66451380e-01f, 1.08508049e-02f, -2.06013128e-01f, 4.22267616e-03f, 3.14531736e-02f, -4.42896515e-01f, 1.94016099e-01f,
  -7.22727597e-01f, -4.11220461e-01f, -4.76969391e-01f, 3.42093617e-01f, 1.21315233e-01f, -3.42380613e-01f, -3.27735871e-01f, 2.22532630e-01f, -4.62573230e-01f, -3.75571996e-02f,
  2.53438115e-01f, -1.05545193e-01f, 4.96012270e-02f, -2.39733160e-01f, -4.33934301e-01f, -7.17896968e-02f, -4.81965281e-02f, -2.36786216e-01f, -3.10544848e-01f, 1.17132831e-02f,
  5.47575671e-03f, 1.10300839e-01f, -1.57223925e-01f, -1.57915503e-01f, 1.87495455e-01f, 2.69631982e-01f, -1.85793340e-01f, -2.42204428e-01f, -3.20259146e-02f, 2.63709933e-01f,
  4.56270278e-02f, 9.38135311e-02f, 3.54885459e-01f, 2.55650491e-01f, -3.23806852e-02f, -2.80359417e-01f, -1.77719057e-01f, -3.05308521e-01f, 2.08501011e-01f, 3.66891697e-02f,
  -3.77960235e-01f, -1.61200479e-01f, 3.58398855e-01f, -2.65407026e-01f, -1.04921842e-02f, -1.99157864e-01f, 1.44652680e-01f, -3.85941148e-01f, -5.00164330e-01f, -1.99339867e-01f,
  6.59446493e-02f, -3.45444709e-01f, -4.60057333e-02f, -4.91049796e-01f, -6.73569879e-03f, -6.81456737e-03f, 3.01469326e-01f, 1.02409638e-01f, 2.65424937e-01f, -2.17629313e-01f,
  2.08989643e-02f, 3.00244749e-01f, 3.51927668e-01f, -1.61886573e-01f, -2.45669007e-01f, -2.01295257e-01f, -5.30285239e-01f, -3.56029630e-01f, -3.20350260e-01f, -6.25273064e-02f,
  2.81991988e-01f, 1.10756397e-01f, 1.76263209e-02f, 2.48951063e-01f, 3.03411096e-01f, -3.18113804e-01f, -2.04814643e-01f, -4.96330112e-01f, -5.66589907e-02f, -2.78747469e-01f,
  -1.08675525e-01f, 4.34483290e-02f, 4.71875854e-02f, -6.23574778e-02f, -1.58526614e-01f, 8.68851617e-02f, -1.32511839e-01f, -1.01451248e-01f, -2.06294224e-01f, -1.46974593e-01f,
  -1.82896957e-01f, 1.62258208e-01f, 1.37499958e-01f, -3.43514055e-01f, -9.45517868e-02f, 9.30189192e-02f, -1.60394847e-01f, -2.02712208e-01f, 4.72024977e-02f, -2.38063499e-01f,
  2.95153111e-02f, -1.69230029e-01f, -2.07005635e-01f, 1.18613198e-01f, -9.19388235e-02f, 3.65913272e-01f, 2.54309207e-01f, 1.16516717e-01f, -3.44463915e-01f, -1.57999396e-01f,
  -2.84995139e-01f, -9.51146930e-02f, -2.82599092e-01f, 4.63867575e-01f, 1.39604241e-01f, 3.17021489e-01f, 2.08316699e-01f, 8.31965432e-02f, -2.07896352e-01f, -2.80028492e-01f,
  -5.73127195e-02f, -9.06918049e-02f, 6.32073134e-02f, 2.27905229e-01f, -1.69669881e-01f, 1.16568953e-01f, -3.81060213e-01f, 1.29869565e-01f, 1.65758505e-01f, 9.90537181e-02f,
  -3.10881883e-01f, 7.10960403e-02f, 9.42896158e-02f, 9.79593173e-02f, -1.81594514e-03f, -3.90498564e-02f, 1.26724869e-01f, 2.19651744e-01f, -2.58371681e-01f, -7.14396775e-01f,
  3.41499448e-01f, -1.74962461e-01f, -1.09085061e-01f, 7.50788748e-02f, -4.00356710e-01f, -9.62778553e-03f, -1.74968451e-01f, 1.16514653e-01f, -3.06826919e-01f, -5.73405385e-01f,
  -2.32328296e-01f, 2.64452938e-02f, 6.07235655e-02f, 2.48542167e-02f, -2.46980190e-01f, -3.92529428e-01f, -2.21235260e-01f, -2.04191096e-02f, -4.95415889e-02f, -4.16305542e-01f,
  -2.86897302e-01f, -2.61046767e-01f, 2.66860187e-01f, -1.81965679e-01f, -4.99654770e-01f, 7.14562163e-02f, 1.11638896e-01f, -2.49248356e-01f, 6.13152161e-02f, 2.63037503e-01f,
  -1.56632408e-01f, -8.83321837e-03f, -4.68829930e-01f, 1.61422968e-01f, -1.47273660e-01f, 4.21020329e-01f, -1.08922563e-01f, 3.71664315e-01f, -1.18558466e-01f, 8.53613541e-02f,
  6.22462183e-02f, 2.86362201e-01f, 1.51595578e-01f, 2.35310271e-01f, -1.07406653e-01f, -8.72755609e-03f, 4.55631781e-03f, 8.32279697e-02f, -1.14296079e-02f, 9.82093886e-02f,
  3.52576852e-01f, -6.66626215e-01f, -5.25442541e-01f, -1.27975360e-01f, 1.33986145e-01f, 1.24563880e-01f, -2.60887176e-01f, -1.11709505e-01f, 7.85796866e-02f, -4.29774255e-01f,
  7.53196031e-02f, 2.17052683e-01f, 3.34193230e-01f, 1.91838071e-02f, -5.09641133e-02f, 3.18797469e-01f, 2.15524569e-01f, -4.08867836e-01f, -2.03783706e-01f, 2.59265602e-01f,
  1.19873844e-01f, -9.99570638e-02f, -8.13842192e-02f, -1.90884620e-01f, -2.85278261e-01f, 2.24779919e-01f, 2.00536862e-01f, 2.35598147e-01f, 1.39733061e-01f, 7.48080909e-02f,
  3.71354282e-01f, -1.86184347e-01f, -1.36015743e-01f, -1.08360179e-01f, 1.16989627e-01f, -2.68190384e-01f, 1.84067279e-01f, 2.48669349e-02f, 1.90724567e-01f, -1.31187022e-01f,
  -8.64125416e-02f, -3.26600581e-01f, -3.41929309e-03f, -3.86789799e-01f, -2.32336838e-02f, -2.86887139e-01f, 2.78487802e-01f, -3.34835440e-01f, -4.58767921e-01f, -2.43426308e-01f,
  4.90147680e-01f, 9.71043482e-03f, 1.02853626e-01f, -6.90912455e-02f, -3.01347673e-01f, -1.27811637e-02f, -2.11984247e-01f, 3.82992864e-01f, -6.03732407e-01f, -4.56668764e-01f,
  -3.05401206e-01f, -1.82973877e-01f, 3.74528766e-01f, -2.79919565e-01f, -4.70447302e-01f, 2.12940201e-01f, 1.21482566e-01f, 1.96879789e-01f, -1.62501946e-01f, -5.37231207e-01f,
  -1.59086436e-01f, -2.37689525e-01f, 7.24449232e-02f, 2.09056109e-01f, -1.02761291e-01f, -2.38990963e-01f, 1.90393567e-01f, -3.61168236e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.23355603e-02f, 2.55324990e-02f, 5.47028072e-02f, -1.21262699e-01f, -2.87899543e-02f, -2.41008382e-02f, 4.69304062e-03f, 3.02975457e-02f, 1.01367190e-01f, 9.12434235e-03f,
  -2.19121873e-01f, -9.00709929e-05f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    