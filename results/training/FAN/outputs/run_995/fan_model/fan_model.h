/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.88353956e-01f, -5.09891927e-01f, -1.24506742e-01f, -1.12251863e-01f, -1.58980712e-01f, -1.18703052e-01f, -4.39308882e-01f, -4.58351225e-02f, 9.28276926e-02f, -2.02787548e-01f,
  -5.03146537e-02f, 1.70345515e-01f, 2.38913581e-01f, 8.97430331e-02f, 7.42421523e-02f, -1.84809834e-01f, -2.87733495e-01f, 2.28932321e-01f, 5.15914857e-01f, 3.59149016e-02f,
  -1.39627054e-01f, -2.48505604e-02f, 2.59386808e-01f, 2.33005255e-01f, -2.44911060e-01f, 2.47985512e-01f, -1.28159568e-01f, 8.36943090e-02f, 2.54680682e-02f, -4.84717160e-01f,
  7.64188766e-02f, -7.98184872e-02f, 3.68106104e-02f, -1.74699295e-02f, -5.35814911e-02f, 1.08848535e-01f, 7.01313466e-02f, 4.79751453e-02f, 1.14649758e-01f, 8.85087065e-03f,
  -2.55386531e-02f, 4.26365808e-02f, 8.02853853e-02f, -2.02320479e-02f, 1.70321204e-02f, -1.51548162e-02f, 3.65687907e-02f, 1.06939979e-01f, -2.08152123e-02f, -9.35997888e-02f,
  -1.29076377e-01f, 3.48231271e-02f, -8.45259950e-02f, 5.74031956e-02f, -2.48912144e-02f, 8.12375993e-02f, -5.53243235e-02f, -1.17103104e-02f, 2.99832299e-02f, 5.00409417e-02f,
  -2.69294716e-02f, -7.55181210e-03f, 2.48191616e-04f, -3.22771668e-02f, 1.28580742e-02f, -1.26316948e-02f, 3.42280306e-02f, -3.13049555e-02f, -2.07749959e-02f, 7.42276981e-02f,
  -2.30517169e-03f, 7.93195609e-03f, 3.74420248e-02f, 3.05445809e-02f, -8.15023184e-02f, -3.22777517e-02f, -2.76898332e-02f, 3.28988060e-02f, -2.96928287e-02f, -6.90829009e-03f,
  1.23375542e-02f, -5.08145755e-03f, 1.87175944e-02f, -3.41957398e-02f, -6.57218471e-02f, 2.53914166e-02f, 8.12079478e-03f, -6.58435076e-02f, -5.35137486e-04f, -9.90337576e-04f,
  2.81766895e-02f, 6.37475215e-03f, 8.47944170e-02f, 4.04914804e-02f, 1.88867263e-02f, -1.89573150e-02f, -4.51665111e-02f, 5.49170859e-02f, -2.88054161e-02f, 3.03243157e-02f,
  -3.29955458e-03f, 1.14500895e-01f, -5.88494316e-02f, -5.65194599e-02f, 1.29134700e-01f, -5.98777970e-03f, -5.83221251e-03f, -3.40557955e-02f, 4.35224921e-02f, -4.93437285e-03f,
  -1.01941541e-01f, -9.53022856e-03f, 1.99930206e-01f, 1.70236453e-02f, 3.44875567e-02f, 1.28457025e-01f, 5.73011152e-02f, 7.75235966e-02f, 8.18565339e-02f, 2.05403976e-02f,
  -3.84603262e-01f, 3.12252827e-02f, 5.78516781e-01f, -4.63473856e-01f, 1.52354956e-01f, 1.35009900e-01f, 3.61468762e-01f, -1.64731428e-01f, -3.04361045e-01f, 4.43056561e-02f,
  6.71385825e-02f, -9.67315659e-02f, -1.72971319e-02f, -3.80914956e-02f, 1.49798736e-01f, 4.56054240e-01f, 2.78117776e-01f, 2.63895661e-01f, 2.79255182e-01f, 8.51863250e-02f,
  -1.85865402e-01f, -1.60024092e-01f, -2.74769425e-01f, 9.24575794e-03f, -1.19212642e-01f, -9.15553123e-02f, -4.91376258e-02f, -1.68208361e-01f, 1.22786455e-01f, -1.88241392e-01f,
  2.80036569e-01f, -1.01832680e-01f, 6.13316223e-02f, -1.16751343e-01f, 4.53145206e-02f, 6.33376790e-03f, 8.20881054e-02f, 3.42120156e-02f, -4.08652611e-03f, 3.58015113e-02f,
  -1.43988775e-02f, -1.14689432e-01f, 1.83236841e-02f, -4.70206104e-02f, -4.79706749e-02f, -2.99875103e-02f, 3.08337100e-02f, 1.86008941e-02f, 3.33255827e-02f, 4.56199124e-02f,
  -5.00871567e-03f, 1.51487395e-01f, 2.45865509e-01f, 9.59183127e-02f, 2.78020743e-02f, -7.33636990e-02f, -3.42412124e-04f, -5.91524541e-02f, -1.76641140e-02f, -1.96279973e-01f,
  -5.48655987e-02f, 7.54090026e-02f, -1.14740087e-02f, -3.76082361e-02f, -4.42353636e-02f, -2.50023901e-02f, -5.90377152e-02f, -2.03741714e-02f, -1.81494020e-02f, -1.79204382e-02f,
  2.91303303e-02f, -3.07896249e-02f, -3.21447328e-02f, 9.55119787e-04f, -9.97585058e-03f, 3.19423750e-02f, -8.29137303e-03f, -4.76470664e-02f, 1.63847599e-02f, -4.16062772e-02f,
  1.43661397e-02f, 1.17679397e-02f, -5.27713075e-02f, -4.64457832e-02f, 9.38824471e-03f, 3.62365916e-02f, 6.02612784e-03f, -2.83088423e-02f, -1.39465732e-02f, -1.78846084e-02f,
  -2.39230305e-01f, 7.62641206e-02f, -8.58225822e-02f, 2.30086613e-02f, 2.86868699e-02f, -4.76540476e-02f, -2.48696059e-02f, -1.75847486e-02f, -8.56469944e-02f, -7.15984926e-02f,
  5.28454110e-02f, 4.96311374e-02f, 1.02501819e-02f, 7.32501096e-04f, 2.41515599e-02f, -1.87329128e-02f, -1.88250858e-02f, 1.04346965e-02f, -1.59263313e-02f, -6.58313483e-02f,
  -7.00762048e-02f, 6.81832666e-03f, 2.89216638e-02f, 4.69527533e-03f, -8.43144655e-02f, 9.24421996e-02f, 1.09156221e-01f, 3.74320224e-02f, 1.31788000e-01f, -1.91498157e-02f,
  2.76560545e-01f, 2.60320634e-01f, 1.78221017e-01f, 6.39674664e-02f, -1.76692754e-02f, -1.87815249e-01f, -2.54570693e-02f, -9.55085158e-02f, -1.16181910e-01f, 1.54332578e-01f,
  2.34233841e-01f, -4.51802425e-02f, -1.41461998e-01f, -2.15421647e-01f, -8.88582319e-02f, 4.46391217e-02f, -6.99828565e-02f, -1.29632950e-01f, -4.05805022e-01f, -1.96476504e-01f,
  -1.11904830e-01f, 5.90660572e-02f, 9.82111171e-02f, -1.01750091e-01f, 1.91202417e-01f, -3.08651090e-01f, 1.63853839e-01f, 2.37487614e-01f, 1.13021597e-01f, 5.27706146e-01f,
  2.70491481e-01f, 4.45262939e-01f, -1.87548518e-01f, 2.53644623e-02f, 5.92066571e-02f, 1.43865079e-01f, 4.58037294e-02f, 8.89823213e-02f, -5.89553907e-04f, 5.34259714e-02f,
  6.64953515e-02f, 1.94217637e-02f, -7.06706271e-02f, -5.26993349e-02f, 1.44874007e-01f, 9.39541385e-02f, 1.35265410e-01f, 7.42154196e-02f, -3.78590748e-02f, 1.79795280e-01f,
  1.23363477e-03f, 1.54567897e-01f, 1.68438822e-01f, 1.77393686e-02f, 8.91484204e-04f, -2.03225970e-01f, 8.61127600e-02f, 1.62419632e-01f, -1.01870634e-02f, 3.44476581e-01f,
  -9.71831903e-02f, 1.39351934e-02f, 8.26156139e-03f, 6.91857859e-02f, -8.19222033e-02f, 2.10862793e-03f, 1.55425612e-02f, -6.19307421e-02f, -6.58986494e-02f, 6.92150071e-02f,
  1.91762652e-02f, 5.27701154e-03f, -8.83802027e-03f, 4.52172421e-02f, -3.93474065e-02f, 1.28677487e-02f, 1.32811954e-02f, 1.56267025e-02f, 6.22309409e-02f, 3.89028341e-02f,
  -4.16955799e-02f, 3.15073528e-03f, -2.52055889e-03f, -4.34082840e-03f, 2.71682702e-02f, -5.37546836e-02f, 1.29112313e-02f, -2.01196056e-02f, -7.66973989e-03f, 6.06723987e-02f,
  -1.97532445e-01f, -2.25512624e-01f, 9.03232247e-02f, -2.01876592e-02f, 1.54048880e-03f, -2.55819429e-02f, 7.02318624e-02f, -2.56209765e-02f, 1.73065905e-02f, -3.38571984e-03f,
  2.08161231e-02f, 3.01739071e-02f, 6.43326761e-03f, -5.55698611e-02f, -2.18536593e-02f, -5.65368347e-02f, -1.88143346e-02f, -1.26013994e-01f, -2.23761005e-03f, -2.13443823e-02f,
  -1.15346380e-01f, 1.82944573e-02f, -6.75829276e-02f, -6.19808920e-02f, -5.20127751e-02f, -5.99632114e-02f, -9.94644091e-02f, -1.56609282e-01f, -1.86287537e-01f, -2.18285277e-01f,
  -8.56900960e-02f, 3.48090231e-02f, -4.33149576e-01f, -6.33442849e-02f, -1.94780342e-02f, 1.44611672e-02f, 6.25606328e-02f, 1.17377557e-01f, 1.85217455e-01f, 1.83034003e-01f,
  -9.36801285e-02f, -2.01374680e-01f, -4.92095798e-02f, -1.58112302e-01f, -2.24438146e-01f, 8.81047472e-02f, -3.19701619e-02f, -1.82993576e-01f, -4.47854668e-01f, -2.71678567e-01f,
  7.81715438e-02f, -2.12197453e-01f, -1.86596572e-01f, -8.88030827e-02f, 4.91528437e-02f, -5.85925160e-03f, -3.37399542e-02f, 7.67037496e-02f, -1.40688308e-02f, -2.67384768e-01f,
  -7.67928287e-02f, -2.56571453e-02f, -7.66304880e-02f, -4.31001186e-02f, 5.51281385e-02f, 7.85696059e-02f, -1.51361851e-02f, -5.44094965e-02f, 8.56474563e-02f, 5.42949997e-02f,
  -6.51154295e-02f, -4.76156287e-02f, -3.93197611e-02f, -7.06289336e-02f, -5.13301827e-02f, -1.12777464e-01f, -3.32576334e-02f, -4.36401088e-03f, 2.63453182e-02f, 6.97961673e-02f,
  9.50012207e-02f, -6.95154220e-02f, 5.08790882e-03f, 6.94915187e-04f, 5.35327271e-02f, -1.49389356e-01f, 2.55811829e-02f, -7.27727450e-03f, -5.54361083e-02f, 6.96917996e-02f,
  -4.28167507e-02f, 5.31078167e-02f, 1.65914726e-02f, -5.18755503e-02f, 7.73807392e-02f, 5.25190011e-02f, -8.23223591e-02f, 5.11311591e-02f, 8.26368667e-03f, -4.31036344e-03f,
  4.32404540e-02f, -6.34653494e-02f, 3.89350094e-02f, -1.97896287e-02f, -1.09148689e-01f, -5.59294894e-02f, -5.27896639e-03f, -7.67192468e-02f, -2.06974968e-02f, -7.13231042e-03f,
  -2.70798653e-02f, 4.08732425e-03f, -3.20418850e-02f, 3.25827859e-02f, -1.02239259e-01f, 3.73392776e-02f, -9.94588360e-02f, -9.23456065e-03f, 2.11064629e-02f, -9.51286871e-03f,
  3.10889687e-02f, -6.62776381e-02f, 9.69164819e-02f, 1.26300380e-02f, 8.38428363e-02f, 2.98314616e-02f, -2.12953463e-02f, 1.10371180e-01f, 4.25573327e-02f, 3.57046835e-02f,
  -2.79495735e-02f, -3.17089595e-02f, 9.03988928e-02f, 1.00158907e-01f, 1.25828935e-02f, 2.61920970e-03f, 7.74487108e-02f, -3.63786444e-02f, -3.18763629e-02f, 5.37911989e-02f,
  5.12938686e-02f, 6.10418990e-02f, 1.37173772e-01f, 7.39313215e-02f, 9.09620598e-02f, -7.03119114e-02f, 1.53158037e-02f, 2.54452489e-02f, 3.83538567e-02f, 2.21884817e-01f,
  7.51301706e-01f, -3.04518789e-01f, 3.20027798e-01f, -3.56004089e-02f, -1.12135328e-01f, 2.21166566e-01f, 1.46002606e-01f, 5.69274090e-02f, -8.36258456e-02f, 1.92513894e-02f,
  -2.00135589e-01f, -3.77473116e-01f, -1.86498597e-01f, -2.26511464e-01f, 2.30839461e-01f, 2.70893991e-01f, 3.21265131e-01f, 2.91470289e-01f, 5.31849861e-02f, -2.49974057e-01f,
  -3.09652776e-01f, -4.60421704e-02f, 2.53484637e-01f, 1.39598414e-01f, -1.23038121e-01f, -2.26699814e-01f, 5.93506806e-02f, 1.41735785e-02f, -2.55787782e-02f, -1.89770833e-01f,
  -9.06883031e-02f, 1.14027299e-01f, 1.04807667e-01f, 4.01983300e-04f, -6.67659268e-02f, 1.21588960e-01f, -1.34611279e-02f, -4.73406799e-02f, 9.76372212e-02f, 7.50822499e-02f,
  -8.59161317e-02f, 7.68999429e-03f, 4.74062301e-02f, -1.05721755e-02f, 3.85481566e-02f, 9.72691253e-02f, 4.17530276e-02f, 7.47672543e-02f, 1.06179990e-01f, -6.22195601e-02f,
  -1.81884691e-01f, 1.21313604e-02f, 7.92383179e-02f, 9.10826400e-02f, 1.20598488e-01f, 6.84552565e-02f, 2.13878620e-02f, 8.17778185e-02f, 1.34334654e-01f, -3.07903625e-02f,
  3.96529771e-02f, -2.15840396e-02f, 2.84915771e-02f, -4.70265886e-03f, -6.52072057e-02f, -3.26028354e-02f, -2.46257279e-02f, -3.82666662e-02f, 2.24472545e-02f, -3.70670743e-02f,
  -5.07922843e-02f, 1.51539315e-02f, -6.06414415e-02f, 7.28820115e-02f, -2.31226012e-02f, 3.91042344e-02f, 3.51829343e-02f, -5.27477190e-02f, -1.96251869e-02f, 2.40624715e-02f,
  -2.68230792e-02f, 1.26377836e-01f, -7.27734491e-02f, 7.58800190e-03f, 3.52603234e-02f, 6.83532804e-02f, -6.15795655e-03f, -5.29468106e-03f, 6.25558272e-02f, 7.01119080e-02f,
  -1.13155529e-01f, 1.58247039e-01f, 3.37997335e-03f, 1.88404713e-02f, 4.47548106e-02f, 6.40447810e-02f, 4.22276929e-03f, 1.14302905e-02f, -3.49706002e-02f, 9.14291441e-02f,
  -1.79070588e-02f, -2.10564751e-02f, -3.58205661e-02f, 1.43326232e-02f, 4.43208292e-02f, 9.57816094e-03f, -2.66250484e-02f, 6.43550456e-02f, -1.06428307e-03f, 7.86097199e-02f,
  5.78614548e-02f, 1.02295019e-01f, 8.61974210e-02f, 2.64426377e-02f, -2.72876993e-02f, -7.41992369e-02f, -3.18627991e-02f, -9.90429893e-02f, 6.20017163e-02f, -8.75031129e-02f,
  -1.14130698e-01f, -1.83029145e-01f, 1.57751739e-01f, -2.68020779e-01f, 2.91920215e-01f, 2.36661062e-01f, 2.52619892e-01f, -1.88751072e-02f, -2.00855866e-01f, -3.25729325e-02f,
  -2.42314115e-01f, -1.00551248e-01f, -1.73564136e-01f, -4.96383756e-02f, -1.02115922e-01f, -1.26858801e-01f, -3.01701367e-01f, -2.05945298e-01f, 3.50052536e-01f, 3.96693558e-01f,
  1.23841025e-01f, -9.21684876e-02f, -1.76565126e-01f, -6.53311685e-02f, 1.46194294e-01f, 1.27601087e-01f, -1.01178382e-02f, 1.34532496e-01f, 9.64855626e-02f, -2.00185061e-01f,
  3.49185944e-01f, -6.26932606e-02f, 9.58925337e-02f, -6.75034374e-02f, 9.31417644e-02f, -5.63461334e-02f, 2.89295521e-02f, -2.49284599e-02f, -2.21673474e-02f, -1.67699605e-02f,
  -4.45077382e-02f, -5.42270020e-04f, -1.35069201e-02f, 4.49892581e-02f, 5.72145507e-02f, 5.16063999e-03f, -6.81702644e-02f, -9.49733853e-02f, -8.60338807e-02f, -4.63897698e-02f,
  -9.42155719e-02f, 9.31764916e-02f, -1.89038347e-02f, -8.19813907e-02f, -2.74461601e-02f, -7.18914047e-02f, 8.26350823e-02f, 9.39145125e-03f, 2.89977659e-02f, 7.06200749e-02f,
  1.99054424e-02f, 3.70296016e-02f, 8.34093019e-02f, 8.73264223e-02f, -6.33405149e-02f, 5.05471453e-02f, -4.04574983e-02f, 6.66948035e-03f, -3.00783571e-03f, 9.06939991e-03f,
  4.04421762e-02f, 1.16035743e-02f, 2.37593055e-02f, -5.19703552e-02f, -1.07250609e-01f, 4.88000736e-02f, -3.31715904e-02f, -2.67445948e-02f, -1.67466134e-01f, -7.55166337e-02f,
  1.60292387e-02f, 6.60793260e-02f, -4.35163220e-03f, 2.43122466e-02f, -4.96700481e-02f, -9.56260115e-02f, 1.03152664e-02f, 2.40484346e-02f, 6.14856146e-02f, -1.39738666e-04f,
  -1.03416927e-02f, -2.21427321e-01f, -1.66938826e-02f, 1.21196322e-02f, 8.73429887e-03f, -4.38070903e-03f, -7.35849440e-02f, 4.92317565e-02f, -1.15244165e-01f, -1.04039917e-02f,
  -3.90309282e-02f, -2.65129302e-02f, -7.64588863e-02f, 6.67750537e-02f, 7.27791488e-02f, 8.62438884e-03f, -2.30278838e-02f, 7.10450336e-02f, -3.29233967e-02f, 7.46954931e-03f,
  -7.09659830e-02f, 3.95706370e-02f, 7.79062137e-02f, 1.13211554e-02f, 7.05116764e-02f, 3.02740727e-02f, 1.31240621e-01f, 2.01840818e-01f, 6.14476986e-02f, 1.38696894e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.75907120e-01f, 5.48824608e-01f, 3.02559704e-01f, -1.10889599e-01f, -1.11075759e-01f, 9.31537673e-02f, 5.81793010e-01f, 3.93400192e-01f, -1.01202697e-01f, 1.15261711e-01f,
  -2.61741057e-02f, -2.84614712e-01f, -8.70915651e-02f, 4.76781325e-03f, 3.96612197e-01f, 2.19008610e-01f, 1.82290822e-01f, 1.81697264e-01f, -9.73896161e-02f, 6.56284615e-02f,
  -9.67706218e-02f, 1.47320097e-02f, 1.39997303e-01f, 1.07980333e-01f, 3.55515368e-02f, -4.06963915e-01f, 7.01855719e-02f, 1.58509940e-01f, 7.03785047e-02f, -3.49664222e-03f,
  1.19675726e-01f, 4.66381758e-01f, -3.44210625e-01f, -2.11308986e-01f, 1.26991626e-02f, -2.04772670e-02f, -3.01903132e-02f, 1.84812136e-02f, -1.77370772e-01f, -3.69332917e-02f,
  -9.77903903e-02f, -1.02922821e-03f, 6.81564808e-02f, 7.95152858e-02f, 1.82083324e-01f, 8.36819634e-02f, 8.28324035e-02f, 2.56270885e-01f, -7.21979365e-02f, 6.17850348e-02f,
  -7.57207647e-02f, -1.56126320e-02f, -7.07333609e-02f, -4.05678339e-02f, 1.88685507e-01f, -1.93124518e-01f, 5.57734407e-02f, 1.40478313e-01f, 1.04493285e-02f, 1.42475158e-01f,
  -5.26906624e-02f, -5.99392764e-02f, -2.07910016e-02f, 1.27886757e-01f, 2.01727837e-01f, -2.42276564e-02f, 6.51829615e-02f, 1.87210739e-02f, 5.55442125e-02f, 2.64250711e-02f,
  -1.46338448e-01f, 3.92763317e-02f, 1.78923234e-02f, -1.91101618e-02f, -1.04922362e-01f, 8.74659121e-02f, -1.29062859e-02f, 2.18988806e-02f, -8.80347639e-02f, 3.42404209e-02f,
  -2.62751766e-02f, -5.83789274e-02f, 3.31388824e-02f, 2.08221540e-01f, -4.89820354e-02f, 3.75231467e-02f, -7.63963088e-02f, 8.65171291e-03f, 1.30851669e-02f, -1.37160271e-01f,
  -5.58391988e-01f, 2.75016036e-02f, -2.43158937e-02f, 1.94247350e-01f, 1.95067711e-02f, -4.06473316e-02f, -4.17423807e-02f, -6.68794364e-02f, -3.54755409e-02f, -6.39769584e-02f,
  -2.61088222e-04f, -3.64370644e-02f, 5.63438721e-02f, -1.77719514e-03f, -1.83082551e-01f, -1.79702505e-01f, 5.84351607e-02f, 3.29559706e-02f, -4.17824544e-04f, -2.60103610e-03f,
  -8.91934633e-02f, -2.34897032e-01f, -4.30952817e-01f, 8.81991629e-03f, -1.57104939e-01f, -4.80145931e-01f, 2.77967900e-02f, -1.15928993e-01f, -2.48117764e-02f, -5.55577278e-02f,
  -1.83712855e-01f, -3.32267910e-01f, 4.28453863e-01f, 1.79094076e-01f, -4.35852170e-01f, -4.48366702e-01f, -6.39113009e-01f, -7.23863766e-02f, 3.89044359e-02f, -1.51652172e-01f,
  -3.22134465e-01f, -9.17429402e-02f, 6.05172627e-02f, 1.15779877e-01f, 1.89228758e-01f, 1.15837671e-01f, 3.90489548e-01f, 5.89935064e-01f, -1.17784843e-01f, -2.98597485e-01f,
  -3.74529324e-02f, 1.74075335e-01f, 3.13400388e-01f, -2.10175943e-02f, 1.21270463e-01f, -2.01486588e-01f, 1.66050762e-01f, 1.92893192e-01f, -4.43370119e-02f, 5.40382683e-01f,
  2.44170651e-01f, -6.74741268e-02f, 1.92442182e-02f, -1.69239402e-01f, 8.18486139e-02f, 5.92161082e-02f, 1.85644496e-02f, 3.00396383e-01f, -1.08549617e-01f, 1.62694916e-01f,
  4.98449467e-02f, -7.59571511e-03f, -1.54450526e-02f, 5.27782552e-02f, -7.10013285e-02f, -1.12110294e-01f, 1.20045364e-01f, 3.33042771e-01f, -2.63886396e-02f, -2.03947306e-01f,
  -1.42700281e-02f, -1.09361820e-01f, -2.58876652e-01f, -2.08586112e-01f, -1.08326800e-01f, 4.78839464e-02f, -1.17246233e-01f, 1.03828199e-01f, -1.06572127e-02f, 2.32045770e-01f,
  -1.88885033e-02f, 1.41654490e-02f, 4.41825204e-03f, 1.03826458e-02f, -1.00003973e-01f, 8.36584624e-03f, 7.70084336e-02f, -1.19472608e-01f, 4.48179804e-02f, -9.86219198e-02f,
  1.86203551e-02f, 3.59517820e-02f, 5.25291786e-02f, -1.09408431e-01f, 1.66980997e-02f, 4.55713384e-02f, -8.59359652e-02f, -6.62601739e-02f, -1.23070240e-01f, -1.25290174e-02f,
  2.03935076e-02f, 9.67398807e-02f, 1.58383437e-02f, 7.35659376e-02f, -5.99017404e-02f, 1.32013217e-01f, 1.10008672e-01f, -3.95312086e-02f, -3.08259744e-02f, -4.83795851e-02f,
  -1.58647597e-01f, -3.33860889e-02f, -7.58171128e-03f, 9.29066762e-02f, 4.90442328e-02f, -8.93543214e-02f, -2.23135184e-02f, 1.80594679e-02f, 1.66647800e-03f, -7.98707828e-02f,
  -1.92077935e-01f, -6.86530173e-02f, 8.05325657e-02f, 2.84415111e-02f, -9.12401900e-02f, -7.29439631e-02f, -2.29423083e-02f, -9.83482823e-02f, 2.41444465e-02f, 4.47675064e-02f,
  4.13867459e-02f, -2.72804290e-01f, -4.24961388e-01f, -2.08903626e-01f, 3.38874906e-02f, -1.64402813e-01f, -2.17755884e-01f, -1.12848729e-01f, -3.56618166e-01f, -5.25393546e-01f,
  -9.77676034e-01f, -2.20366985e-01f, 5.22720218e-02f, -8.47186506e-01f, -2.04868451e-01f, 1.03525028e-01f, -2.90916294e-01f, 2.71168381e-01f, -6.48175552e-02f, -3.23904365e-01f,
  -4.08919975e-02f, -8.74191150e-02f, -2.89978117e-01f, 1.10010982e-01f, -6.90603023e-03f, -2.85062581e-01f, -5.29315531e-01f, -1.44829750e-01f, 3.11026782e-01f, 5.93018770e-01f,
  2.02881411e-01f, -2.27440074e-01f, -1.58659279e-01f, 2.91779280e-01f, -1.69039130e-01f, -6.02437817e-02f, -4.15558457e-01f, -3.10889572e-01f, 2.41213977e-01f, -8.33192825e-01f,
  -1.55836642e-01f, 1.68532178e-01f, 4.94779013e-02f, -1.80315241e-01f, -5.11125289e-02f, 4.11501974e-02f, -2.39046626e-02f, -2.18954250e-01f, 8.86148661e-02f, -3.20989415e-02f,
  -1.81207016e-01f, 2.61872232e-01f, -2.35667527e-01f, 6.59955549e-04f, -1.65538400e-01f, 3.01923975e-02f, 4.33292873e-02f, 1.72228307e-01f, -6.07438795e-02f, 1.57776564e-01f,
  2.34715529e-02f, 9.32943746e-02f, -1.07634611e-01f, 3.51043314e-01f, 3.41731548e-01f, -4.29335535e-02f, 2.54814237e-01f, 3.26212704e-01f, 2.95468509e-01f, -1.47394612e-01f,
  1.00719212e-02f, 2.75604464e-02f, -9.27777681e-03f, -1.22270267e-02f, -6.41280860e-02f, -1.56651214e-02f, -6.64272159e-02f, -7.28083998e-02f, 2.29762550e-02f, -4.43515070e-02f,
  5.78963496e-02f, -1.75581325e-03f, 1.09098010e-01f, -1.37616351e-01f, 1.97148677e-02f, -9.07362327e-02f, -4.45582494e-02f, -7.70975202e-02f, 6.52951673e-02f, 1.22237401e-02f,
  4.15619500e-02f, 6.47270977e-02f, -3.29054147e-02f, 7.84275159e-02f, -7.16272742e-02f, 2.56531313e-02f, 8.93853381e-02f, 4.47637774e-02f, 1.82817187e-02f, 3.82879563e-02f,
  -3.28110665e-01f, 1.28466934e-01f, -2.95293123e-01f, 7.51205906e-02f, -4.40703556e-02f, 3.18215042e-02f, -1.70974448e-01f, 9.87001434e-02f, -6.98661059e-03f, -4.34828773e-02f,
  1.37701958e-01f, -1.83664039e-01f, -2.03264996e-01f, 7.03664199e-02f, -2.21439432e-02f, -1.96035625e-03f, -8.17319527e-02f, -1.72290593e-01f, 8.07128251e-02f, -2.43326998e-03f,
  -3.38568985e-02f, -6.69820234e-02f, -3.16570133e-01f, -3.17950219e-01f, 4.21362668e-02f, -1.89185962e-01f, -9.79392007e-02f, -1.50050586e-02f, -1.75345421e-03f, -4.73902166e-01f,
  1.41679153e-01f, -4.03508574e-01f, 5.75686514e-01f, 5.15930474e-01f, 5.88468969e-01f, 5.24244189e-01f, 4.80553985e-01f, 2.13352963e-01f, 1.94762245e-01f, 1.46787474e-02f,
  -4.29126397e-02f, 4.41810265e-02f, -3.52234617e-02f, 4.34844904e-02f, -8.65715370e-02f, 2.67736256e-01f, 2.69037157e-01f, 2.16122553e-01f, 4.44881707e-01f, 3.04065377e-01f,
  2.30706587e-01f, 1.17786221e-01f, -2.21858159e-01f, -5.10757975e-02f, 8.53361934e-02f, 3.27852249e-01f, -4.85557094e-02f, -3.06204081e-01f, -1.24688178e-01f, -1.36480005e-02f,
  -2.85641593e-03f, -1.24924332e-01f, 2.76545197e-01f, -5.90408184e-02f, 5.08784838e-02f, -5.29345199e-02f, 4.26042732e-03f, -6.97258255e-03f, -5.17903566e-02f, 2.58276127e-02f,
  5.36733977e-02f, -5.48890680e-02f, -3.84187363e-02f, -8.43929276e-02f, -1.92955453e-02f, -3.15399542e-02f, -2.12822333e-01f, 9.93833095e-02f, 1.87140137e-01f, -6.49077445e-02f,
  2.48391591e-02f, -4.57456745e-02f, 3.79258730e-02f, 5.37428409e-02f, 8.66825283e-02f, 7.65519217e-02f, -4.56291586e-02f, -1.06123738e-01f, 1.06246635e-01f, -2.60638874e-02f,
  -3.61338854e-02f, -5.26626371e-02f, 5.86197414e-02f, 6.47787238e-03f, -8.41786042e-02f, 8.49087089e-02f, -2.70629842e-02f, -1.31340504e-01f, 1.02000520e-01f, -6.61286265e-02f,
  6.28077611e-02f, 1.16680771e-01f, 3.72357517e-02f, -1.98488180e-02f, -7.40013272e-02f, -6.64883526e-03f, 6.58762231e-02f, -1.22178219e-01f, -1.69316411e-01f, -5.49664088e-02f,
  2.99437772e-02f, 9.04576182e-02f, 9.22858715e-02f, 8.17150399e-02f, -1.38797686e-02f, -5.28437458e-02f, 1.56809706e-02f, -4.89644893e-02f, -6.69720247e-02f, -6.48553148e-02f,
  -1.46372706e-01f, 1.90538079e-01f, 1.65129378e-01f, 6.23952709e-02f, 6.51904047e-02f, -2.53584087e-01f, 7.78768137e-02f, 3.31199020e-02f, 2.66650021e-02f, 6.61164597e-02f,
  -1.43006742e-01f, -2.90700085e-02f, -1.20195903e-01f, -8.12899768e-02f, 1.95019856e-01f, 4.98209633e-02f, -2.13029251e-01f, 1.55768737e-01f, -2.83813253e-02f, -4.11898233e-02f,
  -5.97174875e-02f, 1.19855888e-01f, 5.48069812e-02f, 1.14729285e-01f, -3.48567031e-02f, 3.21566290e-03f, 8.75458866e-03f, 9.78931636e-02f, 5.19684851e-02f, -2.06777658e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  4.98115718e-01f, 5.13426661e-02f, 1.82300180e-01f, -2.93860823e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.34457240e-01f, 7.46418908e-02f, 3.05570159e-02f, -7.19516426e-02f, 1.60450250e-01f, 5.20438366e-02f, 1.36736095e-01f, -1.63938869e-02f, -4.47704852e-01f, 5.20897090e-01f,
  -2.47974060e-02f, 8.36500302e-02f, -4.72922362e-02f, -4.86573994e-01f, -4.80770946e-01f, 4.54570651e-01f, -1.84836298e-01f, 3.83217372e-02f, -8.75628814e-02f, 1.03705637e-01f,
  -6.42189533e-02f, -2.00618759e-01f, -3.11495781e-01f, 2.36795262e-01f, 1.27281621e-01f, -2.84278870e-01f, -3.22014213e-01f, -6.19116537e-02f, 2.38288715e-01f, 7.27966249e-01f,
  -3.79711628e-01f, -1.72654778e-01f, 4.27437782e-01f, 3.42200510e-02f, -4.15923774e-01f, -3.06165516e-01f, 1.15868459e-02f, 6.63507357e-02f, 2.22066209e-01f, -2.19370008e-01f,
  6.55710459e-01f, -8.03142041e-02f, 2.91035324e-01f, -1.71028078e-01f, 2.23835021e-01f, 2.18107954e-01f, -4.72464621e-01f, -1.35808900e-01f, 3.88964564e-01f, 1.62217319e-02f,
  2.87282914e-01f, 5.08631207e-02f, -3.51953626e-01f, -4.43859875e-01f, -1.61394268e-01f, 4.89349484e-01f, 1.55967802e-01f, 9.53006521e-02f, -2.76173931e-03f, 2.33250752e-01f,
  -1.38422638e-01f, -2.95727968e-01f, -3.82880628e-01f, 2.75034785e-01f, -4.13138360e-01f, 2.77377099e-01f, 2.63508651e-02f, -4.38176319e-02f, 1.47098288e-01f, 2.10306436e-01f,
  4.74485129e-01f, -3.51436168e-01f, -9.87735316e-02f, -3.61750394e-01f, 1.45094469e-01f, -2.97177285e-01f, 8.62600747e-03f, 2.71132588e-01f, -3.53006929e-01f, 1.01463608e-01f,
  -8.26324046e-01f, 2.48974070e-01f, -2.33581021e-01f, 2.67362505e-01f, -1.50673566e-02f, -1.30096048e-01f, -8.47101584e-02f, 4.78773266e-01f, -2.36603454e-01f, -4.10307229e-01f,
  3.61475468e-01f, -9.04810354e-02f, 1.28171012e-01f, -6.40219226e-02f, 2.58123100e-01f, 8.27205032e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.41661423e-01f, 9.76315662e-02f, 1.70604572e-01f, 6.05976343e-01f, -1.69149309e-01f, -1.77394897e-01f, 7.31666327e-01f, 7.20047057e-01f, -6.16359234e-01f, -1.68071557e-02f,
  -1.14599675e-01f, 6.97070599e-01f, -5.09357631e-01f, -9.61753905e-01f, 1.53859064e-01f, -1.92772821e-01f, -1.84631169e-01f, 6.53545558e-02f, -6.56771600e-01f, 3.80616218e-01f,
  4.89175133e-03f, 4.18348074e-01f, -7.38227189e-01f, 2.90562123e-01f, 6.81704879e-01f, -4.20910060e-01f, 2.73332000e-01f, -6.11091591e-02f, 6.16303265e-01f, 2.49671772e-01f,
  -8.09201777e-01f, -2.95592725e-01f, 4.39213395e-01f, 2.39213202e-02f, 4.50332612e-01f, 2.39381492e-02f, 4.64511305e-01f, 3.58630985e-01f, -8.37341726e-01f, 6.84980825e-02f,
  -3.09452444e-01f, 7.53410339e-01f, -2.05786992e-02f, -2.67138839e-01f, -2.32998192e-01f, 4.40791309e-01f, 7.71987379e-01f, -4.63222682e-01f, -2.90098965e-01f, 4.00964200e-01f,
  4.43217635e-01f, 4.91924971e-01f, 1.86673149e-01f, 4.42563355e-01f, -2.80660361e-01f, 4.17428344e-01f, -7.11937904e-01f, 2.31416225e-01f, 6.48764670e-01f, -7.82301500e-02f,
  6.94432020e-01f, -5.07614255e-01f, -2.81202402e-02f, 7.68048316e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.68179500e-01f, 9.01887238e-01f, 5.86627722e-01f, 5.60290754e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.20037693e-01f, 1.71460435e-01f, -2.55688727e-01f, -2.05229819e-02f, -1.19840741e-01f, 1.27663523e-01f, -4.51661944e-01f, 3.92991036e-01f, 9.28309411e-02f, 3.69447470e-01f,
  -9.11612391e-01f, -6.59977794e-01f, -1.27312273e-01f, 3.37717503e-01f, 2.26263657e-01f, -4.60698187e-01f, 6.87261149e-02f, 7.75850773e-01f, 8.98825824e-01f, 1.99889570e-01f,
  -3.33801001e-01f, -2.08996803e-01f, -2.88686544e-01f, -2.07169250e-01f, 1.11651875e-01f, -4.10424799e-01f, -5.42513728e-01f, -4.76479262e-01f, -1.52642459e-01f, -1.55907482e-01f,
  4.28502232e-01f, -3.89573202e-02f, -6.22216314e-02f, -2.87054386e-02f, 2.77946264e-01f, -9.48577225e-02f, 4.74021554e-01f, -5.14710009e-01f, -1.20849460e-01f, 3.35103065e-01f,
  -3.58746015e-02f, -4.47476447e-01f, 5.57004273e-01f, -4.61090803e-01f, -3.15631181e-01f, 3.99007648e-01f, -3.15248936e-01f, -1.82644159e-01f, -1.16316609e-01f, -2.66292185e-01f,
  -6.30254269e-01f, 1.77740470e-01f, -5.63439786e-01f, 1.85385734e-01f, -5.97673118e-01f, 6.95497036e-01f, -3.60401720e-01f, -3.65291476e-01f, 6.40252590e-01f, 9.10029471e-01f,
  -3.34156066e-01f, 4.48444393e-04f, 2.15512365e-02f, -6.76144892e-03f, 3.02322567e-01f, 3.31625819e-01f, -1.96396578e-02f, 3.10866714e-01f, -1.43008962e-01f, -3.62334520e-01f,
  2.30910644e-01f, 5.47430217e-01f, -2.08190113e-01f, 3.85426670e-01f, -5.61083794e-01f, 4.52699006e-01f, 3.11253995e-01f, 4.89671588e-01f, -2.92950779e-01f, -7.35799968e-02f,
  -1.00623243e-01f, 1.58709466e-01f, 3.17844838e-01f, 4.48872447e-01f, 8.09774816e-01f, -5.34661293e-01f, -2.06288278e-01f, -1.79249734e-01f, 5.14292002e-01f, 2.91305818e-02f,
  -1.85502887e-01f, -6.03112042e-01f, -3.96251261e-01f, 3.59532565e-01f, -3.18737477e-02f, 1.29356524e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.68801558e-01f, 1.27892482e+00f, 1.18744898e+00f, 9.22473609e-01f, -5.50829351e-01f, -1.12849742e-01f, -6.19172275e-01f, -7.89290592e-02f, -1.62083134e-01f, -1.05381668e+00f,
  3.66812080e-01f, 1.37348369e-01f, -9.23502684e-01f, -3.56430970e-02f, 6.92473471e-01f, 5.58325231e-01f, 1.00862551e+00f, 2.88302064e-01f, -3.18774253e-01f, 8.48974228e-01f,
  3.31345737e-01f, -1.07704706e-01f, -4.00599182e-01f, 2.41631612e-01f, 6.31330535e-02f, -1.83436275e-01f, -1.76032734e+00f, -1.26242507e+00f, 8.66761982e-01f, 4.27230150e-01f,
  9.30353105e-01f, -9.38304007e-01f, -3.38300675e-01f, 1.08920181e+00f, 4.77057070e-01f, -7.14855716e-02f, 4.88333285e-01f, 9.52326715e-01f, -1.12217999e+00f, 9.32267547e-01f,
  1.20324218e+00f, -1.09751329e-01f, 2.85677582e-01f, -3.22599828e-01f, -5.97763002e-01f, 1.19578624e+00f, 2.83438861e-01f, -5.56969523e-01f, -4.45860714e-01f, 1.29185319e+00f,
  -4.97746021e-01f, 3.28402102e-01f, -3.47021192e-01f, 8.91341329e-01f, 2.70176291e-01f, -3.23407620e-01f, -3.04408848e-01f, 6.61930680e-01f, -5.03928006e-01f, 4.57329750e-01f,
  1.06066632e+00f, 9.96850431e-01f, -1.35241300e-01f, 5.85372269e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  2.63935626e-01f, 7.31734455e-01f, 7.35862017e-01f, 6.46868944e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -7.74689615e-01f, 5.72712541e-01f, -2.52520174e-01f, 7.91684747e-01f, -3.41327906e-01f, 5.68703353e-01f, 5.37853658e-01f, 4.14498121e-01f, -1.42750844e-01f, 7.54060507e-01f,
  -1.32728493e+00f, -1.03698456e+00f, -1.20846450e+00f, 9.52841580e-01f, -7.04146028e-01f, -1.09150398e+00f, -2.84643412e-01f, 7.93794334e-01f, -3.69326472e-02f, 1.13583624e+00f,
  1.82476804e-01f, 3.77718955e-01f, 5.08601010e-01f, 5.99603295e-01f, -8.09834421e-01f, -5.61875045e-01f, -1.18085849e+00f, -1.09360325e+00f, 7.33137548e-01f, -1.23880112e+00f,
  -1.07827723e+00f, 1.16120584e-01f, 5.71586013e-01f, -2.03910679e-01f, 7.84399271e-01f, -3.71195465e-01f, -6.07615411e-01f, 7.07181036e-01f, -1.81942999e-01f, 1.00332797e+00f,
  1.35954127e-01f, 1.55970168e+00f, -8.84531975e-01f, -7.33292937e-01f, 5.43709278e-01f, -1.49559319e+00f, 5.15337229e-01f, -1.14301503e+00f, 1.18417013e+00f, -1.53822362e+00f,
  -1.17625225e+00f, 9.89511386e-02f, -5.31163335e-01f, -4.10239369e-01f, 5.60498349e-02f, 5.64976454e-01f, 1.22301292e+00f, 1.31513906e+00f, 5.43044060e-02f, -7.63402343e-01f,
  6.40648425e-01f, -3.20853554e-02f, -1.12167454e+00f, -3.70030962e-02f, -3.64978582e-01f, -1.92579105e-01f, 7.00898230e-01f, 1.18428236e-03f, -1.72299027e-01f, 7.18024611e-01f,
  1.03753829e+00f, -1.44656408e+00f, -1.22854459e+00f, -8.31023753e-01f, 8.42090309e-01f, 1.26129806e+00f, 2.54690230e-01f, 4.64570642e-01f, -9.73975286e-02f, -5.37308335e-01f,
  7.51096725e-01f, -9.44420338e-01f, 1.37368405e+00f, -1.18999827e+00f, 5.79084679e-02f, 1.46841049e-01f, -1.60810697e+00f, 8.41765583e-01f, -4.30137247e-01f, -1.01720595e+00f,
  -9.62891519e-01f, 1.42516816e+00f, 5.24856627e-01f, -3.14302631e-02f, -1.18085790e+00f, -7.25321293e-01f, 2.81421363e-01f, -7.49640763e-01f, -1.28496051e-01f, -8.83874178e-01f,
  8.91140044e-01f, 1.28162038e+00f, 7.29516387e-01f, -6.84742332e-01f, 6.45920813e-01f, 1.09756850e-01f, 9.12504315e-01f, 8.24150562e-01f, -1.16009963e+00f, -8.96350503e-01f,
  4.00836229e-01f, 5.82271338e-01f, -8.95414591e-01f, 7.35202014e-01f, -6.91842064e-02f, -5.73068440e-01f, -1.16248858e+00f, 9.32296693e-01f, -4.95905548e-01f, -1.21418023e+00f,
  1.18400669e+00f, 1.36515462e+00f, 1.40673494e+00f, 2.49029711e-01f, 4.19486403e-01f, -9.16785300e-01f, -8.30061257e-01f, 1.01728424e-01f, -1.08300197e+00f, 7.54561424e-01f,
  -8.34237397e-01f, -8.17548871e-01f, 4.16231632e-01f, -8.49215388e-02f, -4.40288067e-01f, -7.43938029e-01f, -5.73299825e-01f, -1.01313615e+00f, 8.79811704e-01f, -7.26913214e-01f,
  -1.09190571e+00f, -1.56454957e+00f, -7.59397864e-01f, 1.02977848e+00f, 2.92591572e-01f, 1.06768882e+00f, -9.20319200e-01f, 1.43533957e+00f, 8.04185688e-01f, -1.43223691e+00f,
  5.10668218e-01f, 4.12493870e-02f, 3.55166972e-01f, -4.07469533e-02f, -7.78880537e-01f, 7.24934161e-01f, -2.71065205e-01f, -2.83344090e-01f, 6.59393251e-01f, -1.15249085e+00f,
  6.76566839e-01f, -8.40037644e-01f, -6.63173616e-01f, 3.44763584e-02f, 4.14074928e-01f, -1.63235188e-01f, 1.09872267e-01f, 7.70884454e-01f, 6.51951656e-02f, -1.04941487e+00f,
  1.52986872e+00f, -1.73081338e-01f, -1.05192304e+00f, 4.66692269e-01f, -8.30192327e-01f, 5.36268830e-01f, 4.81274933e-01f, 1.75005734e-01f, 6.87379315e-02f, 1.29988775e-01f,
  -1.25950146e+00f, -1.96700835e+00f, -1.05453968e+00f, 5.56498989e-02f, -8.30376670e-02f, -2.62546420e-01f, 1.25100747e-01f, -2.70858228e-01f, -8.36992785e-02f, -1.05194187e+00f,
  3.63542497e-01f, 6.10650241e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.38764679e-01f, 4.09646928e-01f, -5.11737049e-01f, -5.45322359e-01f, -6.14833236e-02f, 1.49968207e-01f, 2.76385844e-02f, 3.03191245e-01f, 1.25051677e-01f, 4.36838537e-01f,
  -4.91810828e-01f, -6.14847302e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    