/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.43073598e-01f, -2.11198702e-01f, 2.67626971e-01f, -1.36904687e-01f, 3.91500816e-02f, -6.41748980e-02f, -2.19579116e-01f, 4.00741287e-02f, -2.13300064e-01f, -1.09447166e-01f,
  -1.70222864e-01f, -5.83702289e-02f, -2.83034354e-01f, -5.08711599e-02f, -1.76784188e-01f, -1.90870762e-01f, -2.33236402e-01f, -1.09799504e-01f, -4.95132506e-02f, 3.58689167e-02f,
  8.49516615e-02f, -1.45775273e-01f, 2.30338518e-02f, 9.93782282e-02f, 1.47093371e-01f, 1.68381646e-01f, -3.95270139e-02f, 1.06121667e-01f, 9.69320387e-02f, -2.19184030e-02f,
  8.54086503e-02f, 1.97310634e-02f, 3.17403302e-02f, -4.52584252e-02f, 3.36411074e-02f, -3.98074910e-02f, 5.49136661e-02f, 4.13573012e-02f, 8.94277617e-02f, 7.58869126e-02f,
  1.77121870e-02f, 2.31973901e-02f, 2.12948583e-02f, 1.81366801e-02f, -3.58470082e-02f, 6.93679228e-02f, 6.89212307e-02f, 1.20742163e-02f, 4.56221886e-02f, 3.31298485e-02f,
  9.96571481e-02f, 1.82486027e-02f, -3.44992094e-02f, -2.49147713e-02f, 5.41907130e-03f, -5.15840538e-02f, 1.68146733e-02f, 6.75401464e-02f, 1.83412191e-02f, -1.03748702e-02f,
  2.80323885e-02f, -1.31998241e-01f, -4.96612955e-03f, -9.31446552e-02f, -7.26568396e-04f, 4.89218421e-02f, -9.95555520e-03f, 3.41077372e-02f, -1.24599645e-03f, 3.76242511e-02f,
  1.75470533e-03f, 1.63355023e-02f, -4.80079353e-02f, 3.68238725e-02f, -4.32930514e-02f, 1.12670315e-02f, 4.34194170e-02f, 5.34992851e-02f, -1.33187743e-02f, 3.05852592e-02f,
  3.20083871e-02f, -2.93392800e-02f, 5.09613715e-02f, 1.80686545e-02f, 2.58804560e-02f, 2.93301493e-02f, 1.61086640e-03f, 1.82466824e-02f, 5.74834757e-02f, 3.61330733e-02f,
  -1.55193195e-01f, -2.43450865e-01f, -6.39351457e-03f, 6.64860606e-02f, -4.96613830e-02f, -1.39120286e-02f, 1.66960470e-02f, -1.16020152e-02f, -4.70831431e-02f, -1.61068365e-02f,
  7.39707127e-02f, 2.04799343e-02f, -7.16517195e-02f, -5.20929880e-03f, -4.19203416e-02f, 4.31352071e-02f, -1.07628768e-02f, -5.03956974e-02f, -2.67582797e-02f, 5.81632741e-03f,
  -3.95478830e-02f, -7.30700325e-03f, 4.21702024e-03f, 4.23543826e-02f, -1.51751032e-02f, 6.98378310e-02f, -1.47154806e-02f, 2.01104097e-02f, 6.54010847e-03f, 1.62356067e-02f,
  -4.93968189e-01f, 3.41593437e-02f, 1.71941407e-02f, -2.62544662e-01f, 8.60901549e-02f, 1.57683175e-02f, -2.13211253e-01f, 8.78886655e-02f, -2.41079405e-01f, 2.70865858e-02f,
  4.09599170e-02f, -1.58819139e-01f, -2.50120759e-02f, 2.83682048e-02f, -1.61729887e-01f, -3.47937755e-02f, -9.28027779e-02f, -4.75518033e-02f, -9.71071143e-03f, 1.20656848e-01f,
  -1.72456875e-02f, 6.06713863e-03f, -2.51845289e-02f, 2.17017651e-01f, 4.49570268e-02f, 1.06013440e-01f, 1.56468954e-02f, 2.69301962e-02f, 5.97485565e-02f, -4.14836444e-02f,
  7.15271458e-02f, -2.69428678e-02f, 3.45668234e-02f, 4.15417328e-02f, -4.91990335e-02f, -3.45527045e-02f, -1.49198892e-02f, -6.24582991e-02f, -3.63007337e-02f, 5.40008508e-02f,
  2.49407403e-02f, 4.38111760e-02f, 3.28178033e-02f, 4.79445532e-02f, 4.82359827e-02f, 3.27815823e-02f, 2.67828200e-02f, 1.33308098e-02f, -6.06922582e-02f, 1.35791465e-03f,
  -5.40485838e-03f, 8.71341769e-03f, -9.46167186e-02f, -9.68440622e-02f, -2.83210017e-02f, 3.84465158e-02f, 8.75483826e-02f, -5.85451312e-02f, 2.06442159e-02f, 2.64415648e-02f,
  -3.43594067e-02f, -6.57771826e-02f, -3.60841788e-02f, 3.54492627e-02f, -6.32825866e-02f, 1.76863968e-02f, -5.27908513e-03f, 4.47639115e-02f, -1.59519203e-02f, 2.54395735e-02f,
  2.84505859e-02f, -4.50868420e-02f, -2.32501850e-02f, 5.85285686e-02f, 3.57913855e-03f, -5.50926803e-03f, -8.39295909e-02f, 3.93774211e-02f, 3.03679164e-02f, -2.74576829e-03f,
  -7.87595883e-02f, 1.25276006e-03f, 4.32377569e-02f, 4.51839902e-02f, 2.56109424e-02f, -1.74947083e-02f, 8.19758251e-02f, -2.79089180e-03f, -2.47888304e-02f, -3.15127000e-02f,
  1.60856685e-03f, -1.40554635e-02f, -7.97934160e-02f, 3.21582966e-02f, -3.47953252e-02f, 2.30454952e-02f, -1.27289612e-02f, -4.13697138e-02f, 4.02457602e-02f, -6.27835840e-02f,
  5.47466651e-02f, -5.00115044e-02f, -4.23571840e-02f, -4.50694654e-03f, -6.16291314e-02f, -4.73037697e-02f, -1.19814850e-01f, 4.20227870e-02f, -7.63865188e-02f, 5.14405221e-02f,
  8.00808612e-03f, 2.16517057e-02f, 3.41282971e-02f, 6.25442937e-02f, -7.04442784e-02f, -3.39559428e-02f, -4.81679589e-02f, 3.20606865e-02f, -5.26221991e-02f, 1.35736656e-03f,
  -1.27914295e-01f, -1.27213240e-01f, -2.59783417e-01f, -2.66108185e-01f, -1.91653594e-01f, -1.14303559e-01f, -6.99966475e-02f, -2.13757694e-01f, -3.87069553e-01f, 8.47950354e-02f,
  6.83540478e-02f, -1.49428949e-01f, 3.09748024e-01f, -8.42726007e-02f, 1.23802930e-01f, 2.00955093e-01f, -7.76642635e-02f, -1.26741633e-01f, -8.46626908e-02f, -1.33047774e-01f,
  -4.73529100e-02f, -8.14915523e-02f, 2.10885122e-01f, -3.13544534e-02f, 1.83327182e-03f, -1.27736226e-01f, -2.63340957e-02f, 3.07883881e-02f, -2.52314601e-02f, -3.02172564e-02f,
  1.50054514e-01f, 1.42251581e-01f, 1.67151410e-02f, -1.42676029e-02f, -4.11531515e-02f, -5.21181896e-02f, 1.12556331e-02f, 5.48106283e-02f, -2.96308827e-02f, -1.33163612e-02f,
  -3.15645407e-03f, -5.48193417e-02f, -7.54392147e-02f, -1.67275127e-02f, -9.85559449e-02f, -3.83739360e-02f, 1.08640026e-02f, 7.73672909e-02f, -2.60083787e-02f, 5.97210452e-02f,
  -5.92285506e-02f, 8.85890871e-02f, -6.77302293e-03f, -7.70067722e-02f, -2.32268535e-02f, -1.50315817e-02f, -1.52407223e-02f, 3.81260887e-02f, 9.08020977e-03f, -1.35022223e-01f,
  -4.74012010e-02f, -1.02821214e-03f, 3.31484675e-02f, 4.45463546e-02f, -2.48619877e-02f, 2.23462600e-02f, 6.25232095e-03f, 2.55095679e-02f, -4.91954423e-02f, -4.32110801e-02f,
  -1.65655669e-02f, -4.58111279e-02f, -7.20781535e-02f, 7.13573128e-04f, -4.79345061e-02f, 2.03058366e-02f, 4.42738198e-02f, -6.07694387e-02f, -4.81585693e-03f, -2.43860316e-02f,
  6.06131405e-02f, -3.16746198e-02f, 4.70894538e-02f, 2.47973762e-02f, -3.16041224e-02f, 1.77939404e-02f, -3.39842737e-02f, -9.94604919e-03f, 3.60396728e-02f, 5.01928329e-02f,
  -2.91134387e-01f, -3.15170407e-01f, -1.15634045e-02f, -2.64952406e-02f, 7.77282864e-02f, 7.00804368e-02f, -7.61539070e-03f, -1.59746613e-02f, -7.51617476e-02f, 5.41102625e-02f,
  -7.00174049e-02f, 2.04499885e-02f, -4.06290358e-03f, -1.34499511e-02f, 6.86902553e-04f, 3.64570296e-03f, -7.79617354e-02f, -8.41147974e-02f, -9.07377750e-02f, -7.26543888e-02f,
  6.23474419e-02f, 9.84935835e-03f, -8.19481164e-03f, -2.57118605e-02f, -3.08500212e-02f, 1.16126081e-02f, -1.13713391e-01f, -1.85887869e-02f, -2.10434366e-02f, -2.54615606e-03f,
  5.23552537e-01f, -1.49865717e-01f, -1.91545144e-01f, 2.61170954e-01f, -7.10796937e-02f, -1.04298197e-01f, -2.02343404e-01f, 3.42368372e-02f, 1.74226508e-01f, -1.19692624e-01f,
  -1.12529837e-01f, 6.90137371e-02f, -2.50883758e-01f, 3.59679908e-02f, -7.76548833e-02f, -2.35929713e-01f, 4.60735001e-02f, 2.28936262e-02f, -8.77573853e-04f, 3.60975638e-02f,
  5.79635762e-02f, -4.37963530e-02f, -2.90815942e-02f, -4.36837673e-02f, 7.30305091e-02f, 3.12317759e-02f, -6.28867224e-02f, -1.83187187e-01f, 9.73504875e-03f, -5.75756133e-02f,
  -4.52095866e-02f, 6.86432095e-03f, 7.10877255e-02f, 4.51334100e-03f, -1.04259625e-02f, 8.33944976e-02f, -4.33566719e-02f, -3.36687230e-02f, 3.54811177e-02f, 2.58688740e-02f,
  -2.51762364e-02f, -5.37524931e-02f, 8.52508247e-02f, -5.03838770e-02f, 7.81518221e-02f, 9.92267355e-02f, 9.64560546e-03f, 4.40153927e-02f, 1.31065864e-02f, -2.97358055e-02f,
  -1.87749264e-03f, 3.01781725e-02f, 6.29440248e-02f, -4.06202488e-02f, -1.00531047e-02f, 3.23805064e-02f, 2.63198894e-02f, -5.79077341e-02f, 4.15872037e-02f, 2.34592799e-02f,
  -1.09684526e-03f, -1.92487109e-02f, -1.84198655e-02f, 1.28064435e-02f, -1.39688458e-02f, 1.73060801e-02f, 4.84993914e-03f, -1.00746108e-02f, 4.91366871e-02f, -5.91114070e-03f,
  6.48829415e-02f, 4.52491716e-02f, 5.50249405e-02f, 3.50409560e-02f, 2.42825300e-02f, 1.01251025e-02f, -3.48134525e-02f, 2.27150798e-04f, 1.00469981e-04f, 2.38830540e-02f,
  -5.43542840e-02f, 1.77153535e-02f, -6.17012009e-02f, 2.98304483e-02f, -4.65373136e-03f, -3.42760421e-02f, -1.85729526e-02f, -1.90126069e-03f, -1.50403054e-02f, -1.75813437e-02f,
  -1.20899290e-01f, -1.74712449e-01f, -6.80634007e-02f, 1.89352427e-02f, -1.93601865e-02f, -2.69693532e-03f, 2.23764852e-02f, -8.41197371e-03f, -8.23557153e-02f, -1.49208643e-02f,
  4.92696948e-02f, 3.00623402e-02f, -5.28794080e-02f, 8.33263695e-02f, -4.63428684e-02f, -9.91263092e-02f, -4.47820453e-03f, -2.67434269e-02f, 1.27909379e-02f, 1.26298070e-02f,
  7.75060877e-02f, -6.12303130e-02f, -1.45383961e-02f, 3.18161696e-02f, -3.49265267e-03f, -5.42125292e-02f, 3.88418771e-02f, 3.28712761e-02f, 5.97679662e-03f, -3.16017307e-02f,
  3.15029800e-01f, -2.00600937e-01f, 4.33119461e-02f, 1.35255530e-01f, 2.71259665e-01f, 5.11677824e-02f, 1.06223665e-01f, 1.17838435e-01f, -1.26890959e-02f, -1.90046594e-01f,
  1.07119337e-03f, -6.92941993e-02f, 2.95711420e-02f, -1.62464939e-02f, 1.72483891e-01f, -3.78649570e-02f, 8.70836750e-02f, -6.32133707e-02f, -4.43170555e-02f, 7.19203353e-02f,
  1.90475315e-01f, 1.38719901e-01f, 1.51386848e-02f, 4.87686461e-03f, 6.73145801e-02f, 5.49998460e-03f, -4.58205566e-02f, -3.67476977e-02f, -7.27124885e-02f, 3.66420485e-02f,
  -9.26087499e-02f, 4.49927598e-02f, 4.73944284e-02f, -2.47948300e-02f, 2.46565677e-02f, -6.42936155e-02f, 4.45593102e-03f, -6.53486885e-03f, -6.33184314e-02f, 8.65945891e-02f,
  1.22728432e-02f, 5.15625514e-02f, 1.77891497e-02f, -4.62609045e-02f, 5.06583117e-02f, -1.76021259e-03f, 1.68178473e-02f, -9.38887522e-02f, -1.23810731e-02f, -3.33163254e-02f,
  2.69713724e-04f, 1.22089172e-02f, 5.25650522e-03f, -3.91303487e-02f, 2.03889031e-02f, -4.79367515e-03f, -5.10308221e-02f, 2.74621937e-02f, 3.76189612e-02f, 7.77416676e-02f,
  -9.42848325e-02f, -2.88018137e-02f, 2.74947193e-02f, 5.63302413e-02f, 2.31055208e-02f, 3.71724460e-03f, 1.68440957e-02f, 8.68204236e-03f, -7.21303076e-02f, -2.66500120e-03f,
  9.88165382e-04f, 3.67030837e-02f, 4.38229814e-02f, -4.08199206e-02f, 4.38214988e-02f, -6.52310848e-02f, 2.12911572e-02f, -4.85122316e-02f, -1.92859657e-02f, -1.34341819e-02f,
  8.21408909e-03f, -1.02892131e-01f, 7.06390962e-02f, -5.66614643e-02f, 4.48590815e-02f, 1.01729156e-02f, -7.11390898e-02f, -2.06357357e-03f, 1.61570534e-02f, 6.98471293e-02f,
  8.45219344e-02f, 2.56290108e-01f, 1.60987880e-02f, 1.25860989e-01f, 2.93302219e-02f, 5.64636989e-03f, -2.25544181e-02f, -5.20073995e-02f, 1.25388503e-02f, 1.59572531e-02f,
  1.93363447e-02f, -8.40385631e-03f, 9.15913954e-02f, -7.72417476e-03f, -8.46743360e-02f, 6.41656741e-02f, -4.35320251e-02f, 9.65629071e-02f, -2.40657441e-02f, -3.60920541e-02f,
  2.40468280e-03f, 7.66094401e-02f, -5.90357706e-02f, -1.30908145e-02f, 3.62445880e-03f, 3.27768386e-03f, 1.33965472e-02f, -6.45737350e-02f, 3.12779322e-02f, -6.59206435e-02f,
  -1.68260515e-01f, -6.83421642e-02f, 1.72501773e-01f, 2.84254588e-02f, -3.40014547e-01f, -1.27927721e-01f, -3.85494493e-02f, -1.19648524e-01f, 1.65041387e-01f, -2.71390975e-02f,
  -1.15492649e-01f, 1.37209609e-01f, 2.24930495e-01f, -8.22202638e-02f, -6.71798736e-02f, 2.93548614e-01f, -7.11358339e-02f, -9.48907584e-02f, 6.55225515e-02f, -2.01279759e-01f,
  -6.40415177e-02f, -3.00042778e-01f, 1.57603510e-02f, -2.82819718e-01f, -1.38692871e-01f, -4.65956889e-02f, -1.34461746e-01f, 1.43443057e-02f, -1.84088811e-01f, -3.64194997e-02f,
  -1.36546632e-02f, 9.20654014e-02f, -2.73440173e-03f, -5.92030548e-02f, -8.43267366e-02f, -1.86224300e-02f, -2.52822544e-02f, 3.85839716e-02f, -1.81159861e-02f, -2.05990300e-02f,
  1.14786206e-02f, -3.50914784e-02f, 6.17222004e-02f, 2.99125649e-02f, -1.55859816e-04f, 2.21251771e-02f, 4.99323495e-02f, -4.78911139e-02f, 1.25756171e-02f, -2.65981965e-02f,
  -4.94157569e-03f, 2.21146364e-02f, -5.31911813e-02f, -3.24428082e-02f, 5.64785190e-02f, -9.67862904e-02f, 4.18734886e-02f, 9.05287452e-03f, 1.71664357e-02f, 1.96317993e-02f,
  -7.57842734e-02f, 3.91716771e-02f, -7.35434529e-04f, 1.18610030e-02f, -4.60381657e-02f, -1.82813909e-02f, -9.20780096e-03f, 2.79784249e-03f, -2.24521291e-03f, -6.62357137e-02f,
  -2.98087299e-02f, 3.41865979e-02f, 1.30834160e-02f, 4.46497723e-02f, -3.05656139e-02f, -1.67531800e-02f, 6.50070561e-03f, -1.24767683e-02f, -1.58092678e-02f, 4.42188978e-02f,
  1.47079760e-02f, 2.98983441e-03f, 9.92302038e-03f, 2.23288741e-02f, 1.44805368e-02f, -9.61834099e-03f, 3.80102731e-03f, -3.62377008e-03f, 1.53132696e-02f, 9.94216185e-04f,
  -3.66572589e-01f, -1.81924924e-01f, 5.31140948e-03f, -2.15379335e-02f, 6.96969107e-02f, -3.22609767e-02f, 1.79620162e-02f, -2.23343875e-02f, -2.19499785e-02f, 2.87905261e-02f,
  -6.57210797e-02f, 3.37089389e-03f, -6.73134848e-02f, -3.22719701e-02f, -4.67959000e-03f, -2.98824571e-02f, -9.20898002e-03f, -6.75069075e-03f, -4.89807390e-02f, -1.58558432e-02f,
  -2.55305152e-02f, -4.84047532e-02f, -2.15537082e-02f, -5.69452979e-02f, -7.96275958e-02f, 3.30519043e-02f, -4.62601557e-02f, -2.28085946e-02f, 1.04677510e-02f, 3.15280110e-02f,
  7.51385884e-03f, -1.57187641e-01f, 5.12924977e-02f, 1.57672241e-02f, 1.75852049e-02f, 6.09150790e-02f, 1.03595011e-01f, -9.63951200e-02f, -1.47457138e-01f, -1.69381157e-01f,
  -4.41985428e-02f, -1.19996056e-01f, -7.61882737e-02f, -4.26392742e-02f, -1.97846904e-01f, -1.25048906e-01f, -1.98956653e-01f, -1.36663094e-01f, -1.83706786e-02f, -5.38438223e-02f,
  -1.60661023e-02f, -1.34979491e-03f, 4.40094285e-02f, -5.57705872e-02f, 1.75210878e-01f, 1.70630798e-01f, 8.30355063e-02f, 7.25923330e-02f, 8.62165317e-02f, -5.00254184e-02f,
  1.61574617e-01f, 7.30187893e-02f, -4.34163772e-03f, 7.03911483e-02f, 2.80201919e-02f, 6.21438473e-02f, 9.55959335e-02f, -4.13186736e-02f, -4.87074740e-02f, -6.75135180e-02f,
  2.63973754e-02f, 2.79405639e-02f, 9.42294393e-03f, 3.84387039e-02f, -7.71242846e-03f, -7.98266679e-02f, 4.59460402e-03f, -1.58378612e-02f, 2.04080883e-02f, 2.52808873e-02f,
  -4.03019637e-02f, 9.07545350e-03f, 1.51225580e-02f, 7.85358399e-02f, -3.83772352e-03f, 5.17689213e-02f, 5.55516109e-02f, 4.06278782e-02f, -4.80953008e-02f, 6.31636679e-02f,
  -6.38824999e-02f, 7.90547207e-02f, 4.06796932e-02f, -1.32603506e-02f, -3.10802869e-02f, 2.45851390e-02f, -2.97847781e-02f, -1.70696173e-02f, -4.67464142e-03f, -1.03751430e-03f,
  -1.89847443e-02f, 2.52264040e-03f, -3.54529172e-02f, 8.56590569e-02f, 8.20827857e-02f, 1.80989075e-02f, -9.23746526e-02f, 2.46270970e-02f, -2.08830293e-02f, -4.52401154e-02f,
  -3.16863135e-02f, -2.30856463e-02f, -4.71763648e-02f, 3.14071635e-03f, -7.16660321e-02f, 3.82548049e-02f, -7.33816922e-02f, -1.40202884e-02f, 8.64810497e-03f, 1.03346379e-02f,
  -1.85894206e-01f, -1.34190753e-01f, -5.83530776e-02f, 3.28560406e-03f, 3.91567796e-02f, 3.31004597e-02f, -1.39309153e-01f, 2.90063154e-02f, -5.24834469e-02f, -2.24277144e-03f,
  4.13945578e-02f, -7.94586465e-02f, 1.76676549e-02f, 7.64624774e-02f, -7.08334446e-02f, -8.52285419e-03f, -3.03646382e-02f, 1.02835357e-01f, -1.24816537e-01f, -3.92781496e-02f,
  2.40657642e-03f, -5.09505672e-03f, -2.00368427e-02f, 8.36600512e-02f, -3.94020826e-02f, 2.74735480e-03f, -1.11338859e-02f, 2.08372381e-02f, -2.63475534e-02f, 1.66809969e-02f,
  -2.73457050e-01f, -3.65740620e-02f, 1.90527663e-01f, -1.33577123e-01f, -1.18128222e-03f, 4.95025478e-02f, -9.02193040e-02f, 6.34105355e-02f, -2.71216575e-02f, -1.88641638e-01f,
  1.29431471e-01f, -7.44677484e-02f, -8.61914363e-03f, 2.00307202e-02f, 3.12466715e-02f, 1.21271491e-01f, 1.22240767e-01f, -7.85360634e-02f, 6.20035455e-02f, -1.46281272e-01f,
  1.04815178e-01f, -2.14735921e-02f, 1.57557890e-01f, 8.93158615e-02f, -3.01376656e-02f, -5.52756116e-02f, 4.29421067e-02f, 5.20944931e-02f, 1.23727880e-02f, -7.64846802e-02f,
  1.46928504e-02f, 1.87724642e-02f, 2.74877474e-02f, 2.55925823e-02f, -4.85639200e-02f, -5.13550788e-02f, 5.93667366e-02f, -1.31423892e-02f, -4.34936695e-02f, 8.76144227e-03f,
  5.55394851e-02f, 8.00388772e-03f, -4.97617051e-02f, -4.74438071e-02f, 1.06165878e-01f, 1.87733229e-02f, -7.62684792e-02f, 1.36134718e-02f, -9.59400367e-03f, 4.71180268e-02f,
  -2.03815661e-02f, -5.16797118e-02f, 2.28277165e-02f, -1.22166472e-02f, 5.92333786e-02f, 8.05906300e-03f, -6.23068884e-02f, -1.00605220e-01f, -4.94627841e-02f, 1.16165848e-02f,
  1.44046098e-01f, -1.12815164e-01f, 2.67288014e-02f, -1.11872135e-02f, -1.19501259e-02f, -1.05628408e-01f, -6.21710382e-02f, -2.74035009e-03f, 5.93005456e-02f, 6.32326826e-02f,
  -4.74729426e-02f, 7.21438900e-02f, 2.26311311e-02f, 2.33483929e-02f, 7.74454847e-02f, 3.53431404e-02f, 1.02289088e-01f, -1.84446704e-02f, 4.08586562e-02f, -3.60061564e-02f,
  -4.26004454e-02f, -2.29322556e-02f, 8.36249590e-02f, 4.95458171e-02f, -6.96548894e-02f, -3.02155856e-02f, -2.18852516e-02f, -1.50431180e-02f, -2.21839007e-02f, -7.12407380e-02f,
  -1.91935584e-01f, -1.76651161e-02f, 6.43519089e-02f, -5.51740080e-02f, 5.73438453e-03f, 6.05942085e-02f, 7.27966130e-02f, 9.15641412e-02f, 6.95965588e-02f, -4.57738824e-02f,
  -6.85225334e-03f, 2.04744413e-02f, -8.24980321e-04f, 1.03314564e-01f, 3.91618460e-02f, 7.97149613e-02f, -2.86373589e-03f, 4.35840972e-02f, 5.03005646e-02f, 1.01457879e-01f,
  -8.48467201e-02f, -1.31010860e-02f, 9.09896474e-03f, -7.26334006e-03f, 5.99062145e-02f, -2.76380796e-02f, -7.51188248e-02f, 1.63138546e-02f, 1.13113254e-01f, 2.90984288e-02f,
  8.47022831e-02f, -1.73746452e-01f, 3.36957395e-01f, -3.61769535e-02f, 2.97107130e-01f, 6.10834323e-02f, 8.73196796e-02f, 6.53015226e-02f, -6.94019943e-02f, -3.87225121e-01f,
  -5.30069545e-02f, 5.52516803e-02f, -1.41320273e-01f, -6.07460439e-02f, 4.12951335e-02f, -2.54805803e-01f, -9.96729285e-02f, -1.14734091e-01f, 4.02984582e-02f, 2.58502867e-02f,
  4.67034392e-02f, -9.98808295e-02f, -1.67173166e-02f, 4.16798219e-02f, 1.17486820e-01f, 6.96958974e-02f, -1.36128575e-01f, 2.12921798e-01f, 3.11161503e-02f, 2.94608093e-04f,
  -2.45412793e-02f, -4.98614311e-02f, 1.52019396e-01f, 2.64285114e-02f, 6.69113621e-02f, 2.54398938e-02f, 5.48599660e-03f, 1.46273881e-01f, 7.43638575e-02f, 3.99934174e-03f,
  -1.98330656e-02f, 3.06292325e-02f, -8.06635320e-02f, 4.75238003e-02f, 5.04681207e-02f, -3.32439765e-02f, 1.01474933e-02f, 5.39376028e-02f, 1.48859667e-02f, 4.07915562e-02f,
  1.74743440e-02f, -1.26245851e-02f, 9.78765544e-03f, -1.02897450e-01f, 9.86000244e-03f, -1.04473317e-02f, -2.66153328e-02f, 2.35774498e-02f, -1.30758360e-02f, -1.11865327e-01f,
  -1.09452596e-02f, 2.40933150e-02f, -4.94820364e-02f, 3.15398420e-03f, 6.42288104e-02f, 7.98776932e-03f, -1.60657074e-02f, 7.09398091e-03f, 4.82710265e-03f, 4.13227454e-02f,
  3.20542119e-02f, -3.82983126e-02f, 8.85575172e-03f, 1.87952593e-02f, -2.54472960e-02f, -2.01866161e-02f, 3.12400493e-03f, -9.80072934e-03f, -3.40130702e-02f, 3.15322727e-02f,
  1.84141193e-02f, 2.72001177e-02f, -5.08509576e-02f, 1.83732696e-02f, 4.50679623e-02f, 4.24845852e-02f, 1.97441000e-02f, -2.54989266e-02f, -4.47975956e-02f, -8.60823970e-03f,
  -1.03309698e-01f, -2.13099778e-01f, -5.25055453e-02f, -1.58653723e-03f, -6.34817081e-03f, -2.20841542e-02f, -1.96216814e-02f, -8.61388743e-02f, -4.35994230e-02f, -8.00212994e-02f,
  -5.29791601e-02f, -1.93848014e-02f, 2.48631053e-02f, 1.21697374e-02f, 1.55910440e-02f, -1.06244065e-01f, -2.38506123e-03f, -9.95323285e-02f, -2.93114837e-02f, -2.39651091e-02f,
  -3.88807654e-02f, -3.11187301e-02f, -1.55843832e-02f, 5.70590980e-02f, -4.40321453e-02f, -2.45583877e-02f, 7.42912963e-02f, 8.69553089e-02f, -2.64432207e-02f, -5.18045761e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.05191508e-01f, -3.20622348e-04f, 1.57667741e-01f, 1.72599420e-01f, -1.38172805e-01f, -3.06036144e-01f, -2.63730139e-01f, 1.10061012e-01f, -2.21181050e-01f, -5.84470816e-02f,
  5.97637109e-02f, -1.20131642e-01f, 2.17814520e-02f, 5.37622571e-02f, 1.47377700e-01f, -2.28062883e-01f, 8.56736079e-02f, -1.20037191e-01f, -9.40162763e-02f, 3.15934718e-02f,
  4.80879657e-02f, 1.91514060e-01f, 3.26971978e-01f, 3.29057366e-01f, 7.28963614e-02f, 2.13469714e-01f, 4.26875710e-01f, 1.18367262e-01f, 2.81928092e-01f, 4.78250682e-02f,
  -2.16453552e-01f, -8.26526508e-02f, 7.40271732e-02f, 4.20006923e-02f, -2.90487520e-02f, -3.70959453e-02f, -6.15632273e-02f, 3.17801125e-02f, -1.41492831e-02f, -3.91711108e-02f,
  -4.74774987e-02f, 1.69542916e-02f, 4.93136458e-02f, 2.24697590e-02f, 1.85443312e-02f, 1.68897305e-02f, -2.05622371e-02f, -3.80832814e-02f, -6.67040050e-02f, 6.56539053e-02f,
  -6.17120154e-02f, -2.34356895e-02f, 4.00654823e-02f, -7.45668933e-02f, 1.32080883e-01f, 7.42955552e-03f, 8.16458371e-03f, -3.60550061e-02f, -7.70715298e-03f, -4.06229869e-02f,
  -5.70881292e-02f, -2.81377248e-02f, 2.02628281e-02f, 2.37599062e-03f, 7.98030868e-02f, 3.93115543e-02f, -6.63928911e-02f, 1.76005233e-02f, -3.53942476e-02f, 1.38516081e-02f,
  1.59077328e-02f, -1.09952949e-02f, -3.55123766e-02f, 4.65740487e-02f, -2.61144470e-02f, 2.07202998e-03f, -4.87512238e-02f, 2.44571846e-02f, -1.92120194e-03f, 1.77104343e-02f,
  -9.81256515e-02f, 6.39753118e-02f, -1.32554071e-03f, 1.70463845e-02f, 1.16638035e-01f, 4.81120404e-03f, -1.54201621e-02f, 2.81038843e-02f, 2.81016156e-02f, -5.52973188e-02f,
  6.31876290e-02f, 2.88429558e-01f, 1.13161141e-02f, 1.01786470e-02f, 3.48073915e-02f, -9.92019698e-02f, -9.37935803e-03f, 6.47768704e-03f, 5.70580885e-02f, 7.01490343e-02f,
  -1.05017074e-03f, -4.84890714e-02f, 2.04181485e-02f, 1.61317699e-02f, 7.48110861e-02f, 2.32613254e-02f, 6.15885928e-02f, 3.43301892e-02f, 6.07050732e-02f, 3.13751213e-02f,
  1.30668934e-03f, -9.19059068e-02f, -1.29943434e-02f, 1.47969900e-02f, 2.85254116e-03f, -1.23197816e-01f, -8.77702422e-03f, 1.54742040e-02f, 2.58048009e-02f, 3.46379750e-03f,
  -1.38441892e-02f, -1.93634517e-02f, -3.04596107e-02f, 6.13609590e-02f, -1.30575215e-02f, -1.24437496e-01f, -1.33641273e-01f, 5.75658008e-02f, -1.90288469e-01f, 1.10976554e-01f,
  1.78854652e-02f, -7.34957159e-02f, 7.21528307e-02f, -6.69341683e-02f, 1.89846456e-02f, 5.43267000e-04f, 9.73176137e-02f, -8.56852531e-02f, 2.04962138e-02f, 1.64756835e-01f,
  7.40297735e-02f, -1.64950024e-02f, 8.63548145e-02f, 1.66556448e-01f, -3.75233032e-03f, 1.85657114e-01f, 1.69035345e-01f, 1.12319805e-01f, 2.02342227e-01f, 1.30203124e-02f,
  -7.30052516e-02f, -1.29937127e-01f, 1.85781270e-02f, -3.41831669e-02f, 9.88835096e-02f, 1.83986291e-01f, -2.36726813e-02f, -1.17491307e-02f, -6.11059405e-02f, -1.49076255e-02f,
  -2.91378498e-02f, 1.77736357e-02f, -1.53651088e-01f, -8.09461400e-02f, -4.65439446e-02f, -5.65605909e-02f, -4.33943495e-02f, -6.81629851e-02f, 2.29605101e-02f, -4.34421375e-02f,
  -4.47809659e-02f, -2.03514844e-02f, -1.94145478e-02f, -1.45694176e-02f, -2.00855546e-02f, 3.62985721e-03f, -4.95650023e-02f, -9.75161139e-03f, -5.05909845e-02f, -1.96875492e-03f,
  7.40656406e-02f, 3.70445400e-02f, -2.79870871e-02f, -9.66076180e-02f, -2.73929052e-02f, 7.08255544e-03f, 1.28895462e-01f, 5.42985499e-02f, -7.00589130e-03f, 4.87533212e-02f,
  7.62647539e-02f, 6.43584654e-02f, 7.49026164e-02f, -7.99975265e-03f, 5.32634743e-02f, -7.46062100e-02f, 3.73441204e-02f, -1.86330341e-02f, -4.55331132e-02f, -2.64657475e-02f,
  7.84797519e-02f, -1.13244634e-02f, 1.12369629e-02f, 8.04825276e-02f, -6.60862550e-02f, -3.78029495e-02f, 8.33764672e-02f, 3.08484305e-02f, -5.89046590e-02f, 5.50144985e-02f,
  1.35863215e-01f, 1.94124207e-01f, 1.54691786e-02f, -8.88361633e-02f, -8.31065699e-02f, 1.23637326e-01f, -6.21877313e-02f, -4.62807789e-02f, -8.34069960e-03f, 1.33354170e-03f,
  6.93542976e-03f, -4.19075228e-03f, -6.31118789e-02f, -4.32273187e-02f, -2.89442274e-03f, -6.57924414e-02f, 3.52015980e-02f, -1.66499652e-02f, 6.37742430e-02f, 5.95613532e-02f,
  -3.36420164e-03f, 1.10799238e-01f, 3.66555452e-02f, -3.29700746e-02f, -1.04670629e-01f, 1.27967298e-01f, 7.50964507e-02f, 6.05370998e-02f, 1.48757353e-01f, -6.60975650e-02f,
  3.37942421e-01f, 7.64244944e-02f, -1.34571120e-01f, -7.51605332e-02f, -2.05013067e-01f, -4.74678814e-01f, -5.08951783e-01f, -7.41153657e-02f, -6.76044077e-02f, -1.56890169e-01f,
  -1.65119290e-01f, 4.84792478e-02f, 9.61503461e-02f, -3.72050911e-01f, 6.72696382e-02f, 1.78035572e-01f, -2.71024764e-01f, -2.71386415e-01f, 1.86652318e-01f, -8.41393247e-02f,
  1.14300333e-01f, -2.36278042e-01f, 3.55906747e-02f, 3.01879607e-02f, -1.27332345e-01f, 1.24663420e-01f, 2.59655625e-01f, 3.07445358e-02f, -1.21964678e-01f, -7.16991648e-02f,
  -1.37037247e-01f, 6.39804527e-02f, -6.72773644e-02f, 6.54805452e-02f, 3.45798470e-02f, 1.40749064e-04f, -4.62794490e-03f, 2.72498559e-02f, 1.88385160e-03f, 3.34641449e-02f,
  3.38493288e-02f, -1.80238660e-03f, 5.14564663e-03f, 2.56617330e-02f, -7.30507970e-02f, -2.94272918e-02f, -4.04966697e-02f, 2.71490738e-02f, -1.46049574e-01f, 5.25992513e-02f,
  -1.09684067e-02f, -7.12938886e-03f, -6.06047027e-02f, -1.50762114e-03f, -5.00170961e-02f, -3.33596058e-02f, -3.54948677e-02f, -4.43219654e-02f, 8.32777470e-02f, 1.02881975e-02f,
  1.99361742e-02f, -2.71690022e-02f, -6.23144843e-02f, -3.49697843e-02f, 5.06834537e-02f, 1.07247494e-01f, -8.84485170e-02f, -4.27469052e-03f, -1.64231416e-02f, 5.77609912e-02f,
  -3.78956385e-02f, -2.68860487e-04f, -4.54736277e-02f, 7.04187080e-02f, 7.08389357e-02f, 2.80342121e-02f, 1.67993002e-03f, -3.23703922e-02f, -7.70598724e-02f, 8.43090564e-02f,
  3.28856334e-02f, 2.29670107e-02f, -6.30015060e-02f, 4.47670445e-02f, 4.24550800e-03f, 5.21773733e-02f, -1.01437904e-02f, 2.76635736e-02f, 1.57057252e-02f, -4.46530804e-02f,
  -1.20151199e-01f, 2.61560649e-01f, -6.16693236e-02f, -1.09134562e-01f, -1.95671525e-02f, -7.33216945e-03f, 3.27459015e-02f, 9.75806545e-03f, 6.98670819e-02f, -5.13961278e-02f,
  -3.64184529e-02f, 2.31748689e-02f, -7.47959130e-03f, 4.74572219e-02f, 1.78621542e-02f, -1.74490009e-02f, 4.76255752e-02f, -8.60702060e-03f, -4.80206124e-02f, 2.22488027e-02f,
  -4.38455828e-02f, -2.25911234e-02f, 6.03204146e-02f, 4.30417135e-02f, -2.47694943e-02f, 2.39232257e-02f, 1.07905187e-01f, 9.16421264e-02f, -2.81997733e-02f, -2.99583972e-02f,
  -2.34859198e-01f, 1.28101513e-01f, 7.88973793e-02f, -2.19185650e-03f, 7.43451193e-02f, -1.11090347e-01f, -4.73258160e-02f, 1.18057169e-01f, -2.40941141e-02f, 8.10696483e-02f,
  -5.97961955e-02f, 7.68077075e-02f, 3.73451039e-02f, 1.39384810e-02f, -1.17336340e-01f, -6.68078810e-02f, -1.18215643e-01f, -5.02943657e-02f, 1.01145534e-02f, -7.08579496e-02f,
  -5.01481257e-02f, -1.84046216e-02f, -3.14197391e-02f, 6.64028004e-02f, -5.99004366e-02f, 3.58996615e-02f, -3.42529193e-02f, -5.27348407e-02f, -6.19940758e-02f, 3.89764979e-02f,
  4.91791638e-04f, 1.28927052e-01f, 1.36613816e-01f, 9.53316018e-02f, 4.91046049e-02f, -3.39629389e-02f, -2.43229158e-02f, -2.34918483e-02f, -7.64517561e-02f, 8.95339102e-02f,
  -3.51344757e-02f, 1.11921236e-01f, 8.69207531e-02f, -1.87290870e-02f, -6.32177964e-02f, 8.13081264e-02f, -5.84749877e-02f, 3.20356293e-03f, 7.80513510e-02f, 1.77400131e-02f,
  -8.56666360e-03f, 3.54031734e-02f, -1.21931331e-02f, 1.17297163e-02f, 1.60791725e-02f, 3.92708965e-02f, -7.10528940e-02f, 4.16941866e-02f, -1.63484253e-02f, 1.05993589e-02f,
  -7.86937252e-02f, -6.25996739e-02f, 3.67687121e-02f, -1.07421102e-02f, -2.52794567e-03f, -2.58379541e-02f, -4.87020314e-02f, -3.87083553e-02f, -3.95506620e-03f, 1.46357073e-02f,
  3.21833082e-02f, 5.39366901e-02f, -1.82179653e-03f, -1.04766093e-01f, -7.98061341e-02f, -3.74458730e-02f, -1.01287058e-02f, -4.33110781e-02f, -2.15718783e-02f, -2.81805135e-02f,
  6.63805008e-02f, -8.98601785e-02f, -1.81573424e-02f, -2.63210777e-02f, 6.58721477e-02f, -2.35230569e-03f, 1.27992574e-02f, 4.28529568e-02f, -3.33039314e-02f, -3.68262194e-02f,
  -7.91211128e-02f, -1.09320045e-01f, 1.00943327e-01f, 4.35290970e-02f, 6.50629252e-02f, 4.37915064e-02f, -8.96054134e-02f, 3.42982784e-02f, -6.70840144e-02f, -4.82130200e-02f,
  -7.51004070e-02f, -3.26506235e-02f, 4.84080911e-02f, -3.52537669e-02f, 3.98502089e-02f, -2.42846254e-02f, -4.76157479e-02f, -7.81683717e-03f, -1.57124586e-02f, -5.86410649e-02f,
  1.38029411e-01f, 3.02226618e-02f, -9.16345343e-02f, 4.57324833e-02f, -9.15481821e-02f, -6.91025779e-02f, -7.36938715e-02f, 1.39836371e-01f, -3.34087610e-02f, -6.38813376e-02f,
  -5.38929999e-02f, 7.38128349e-02f, 1.92845576e-02f, -1.00739948e-01f, -1.50496727e-02f, 2.89819390e-02f, -1.19384332e-02f, 2.38729641e-04f, -7.76639655e-02f, 4.11981046e-02f,
  2.79503874e-02f, -7.74114653e-02f, 1.07365347e-01f, 6.25250190e-02f, 6.68648183e-02f, -2.80844830e-02f, 8.01592842e-02f, -9.69218165e-02f, -3.39413583e-02f, 2.01548822e-02f,
  5.78076132e-02f, 4.72936705e-02f, -5.82049191e-02f, -5.97021841e-02f, 5.63625880e-02f, -7.06384033e-02f, 2.39202883e-02f, -3.29724774e-02f, -1.67907253e-02f, 1.78707242e-02f,
  -4.10119183e-02f, -1.30097661e-02f, 5.41486079e-03f, 8.13471079e-02f, 4.97526079e-02f, 2.68102083e-02f, 9.14628208e-02f, 5.64118922e-02f, -4.46978174e-02f, 9.65160318e-03f,
  6.71066493e-02f, -1.50704300e-02f, -5.29438630e-02f, 1.31885102e-02f, -2.21172702e-02f, -2.61984430e-02f, -2.79135276e-02f, -4.85307239e-02f, -6.80147484e-02f, 8.56308453e-03f,
  -3.74041572e-02f, 9.83740762e-02f, -3.12920138e-02f, 8.75359029e-03f, -1.28883841e-02f, 3.92353237e-02f, 6.71480456e-03f, -2.20761285e-03f, 3.14415097e-02f, 4.50984538e-02f,
  -8.31730291e-02f, -4.67613563e-02f, 9.31110159e-02f, -3.43325138e-02f, -7.62630552e-02f, 1.26554375e-03f, -1.82143897e-02f, -4.15408835e-02f, -2.54283343e-02f, -1.36868022e-02f,
  -9.67861190e-02f, -6.41878694e-02f, 3.11492309e-02f, 3.10455840e-02f, 7.99362212e-02f, 1.03492721e-03f, 7.38239586e-02f, 2.30218768e-02f, -6.08931929e-02f, -4.91243601e-03f,
  2.14078836e-02f, -9.37904045e-02f, -4.83612567e-02f, -2.20778286e-02f, -8.73341858e-02f, 5.89110628e-02f, -3.81476618e-02f, 2.74230018e-02f, 6.99659437e-02f, -7.43005052e-02f,
  2.84729395e-02f, -2.34544557e-02f, -1.86404958e-02f, -7.40699237e-04f, -5.80983646e-02f, 5.58025837e-02f, 9.71266627e-02f, 8.11521932e-02f, -8.07223991e-02f, -4.15792353e-02f,
  -4.90895659e-03f, -5.23111448e-02f, 3.98816243e-02f, 4.02759984e-02f, -1.08006923e-02f, -2.32341569e-02f, -6.78309414e-04f, 1.31313968e-02f, 3.90050113e-02f, 5.92102259e-02f,
  -4.71180631e-03f, 5.83183542e-02f, -5.84025159e-02f, 5.65039441e-02f, -6.08497299e-04f, 8.01216513e-02f, -6.79050386e-02f, 6.59478456e-02f, 8.00241902e-02f, 5.68243302e-03f,
  -1.10531382e-01f, 2.44289823e-02f, -1.11016542e-01f, -4.71126512e-02f, 5.11882156e-02f, -3.08709983e-02f, -6.82679340e-02f, 1.52327009e-02f, -5.25146611e-02f, -1.16713671e-02f,
  6.98728859e-02f, 1.39497519e-02f, 6.59349710e-02f, -8.81697536e-02f, -9.56286192e-02f, 2.61844490e-02f, -7.95404240e-02f, 4.58354726e-02f, -6.57671317e-02f, -2.45074686e-02f,
  -4.31043059e-02f, 4.88159135e-02f, -5.86648025e-02f, 6.31196126e-02f, 3.58535238e-02f, 2.99871545e-02f, 1.41483441e-01f, -2.51576724e-03f, -5.24572097e-02f, 1.30855711e-02f,
  -7.75930062e-02f, 7.42053688e-02f, 3.92891243e-02f, 6.47754297e-02f, 1.62476357e-02f, -5.19411936e-02f, 6.97067603e-02f, -2.44181398e-02f, -3.67833748e-02f, 5.44227511e-02f,
  -4.77748252e-02f, -5.26783094e-02f, -3.37431543e-02f, -3.07239071e-02f, -8.13998207e-02f, 1.86122097e-02f, 8.74958783e-02f, 4.05672304e-02f, -1.02750389e-02f, -3.33118401e-02f,
  -6.63773119e-02f, 6.54642656e-02f, -5.54788336e-02f, -5.90244681e-02f, -4.22090553e-02f, -1.87506955e-02f, -5.16765378e-02f, 6.26722500e-02f, -1.21807680e-02f, 6.03472628e-02f,
  8.34855735e-02f, -2.88563836e-02f, -8.33284780e-02f, -2.46895440e-02f, 1.73458010e-02f, -1.26003744e-02f, 2.26855036e-02f, 9.36888251e-03f, 1.25099374e-02f, 4.36539538e-02f,
  -6.83177710e-02f, -3.52478847e-02f, 3.55284773e-02f, 8.70707445e-03f, -6.72389790e-02f, -1.69362966e-03f, 5.99268358e-03f, 2.69341934e-03f, -2.12006718e-02f, -1.17268329e-02f,
  6.26260266e-02f, -8.74183401e-02f, 4.12230901e-02f, 3.81074250e-02f, -1.06396131e-01f, 6.78771660e-02f, -4.56655398e-02f, -6.71565980e-02f, 2.79088244e-02f, 4.69172299e-02f,
  8.60141814e-02f, -1.57445651e-02f, 4.52071838e-02f, 9.04109478e-02f, -6.41735569e-02f, -3.55987661e-02f, -9.10249949e-02f, -1.67518184e-02f, -4.46550623e-02f, 1.79168303e-02f,
  -1.85966380e-02f, -5.84667102e-02f, -3.20771560e-02f, -4.66857329e-02f, -6.93330243e-02f, 2.88937744e-02f, -7.31290057e-02f, -2.75677126e-02f, 6.41058981e-02f, -1.61759672e-03f,
  -9.93546378e-03f, 1.06891461e-01f, -5.37841208e-02f, -1.94196943e-02f, -3.89425121e-02f, 3.88691644e-03f, 6.93587139e-02f, -3.25991400e-02f, -5.11622131e-02f, -3.07318494e-02f,
  8.45453516e-02f, -1.77411661e-02f, -2.61311159e-02f, 1.79343317e-02f, 3.28837633e-02f, 9.62984487e-02f, 9.54006314e-02f, 1.33852335e-02f, 8.10650066e-02f, 5.59804365e-02f,
  2.28370782e-02f, -8.02968442e-02f, 8.81704092e-02f, -3.83674305e-05f, -9.58387181e-03f, 6.21875860e-02f, -3.60464081e-02f, -7.83649832e-03f, 6.07652636e-03f, -7.69525319e-02f,
  -1.06593132e-01f, 2.98612304e-02f, -8.00357312e-02f, 6.51371013e-03f, -7.14165643e-02f, -5.84498197e-02f, 9.69795603e-03f, -4.30923067e-02f, 1.24434242e-03f, -9.55586582e-02f,
  4.45386432e-02f, -6.32500276e-02f, 1.08999312e-02f, 4.54859845e-02f, -5.84307238e-02f, 8.27845559e-02f, -2.85061654e-02f, 1.32040754e-02f, -8.14010948e-02f, 6.11292459e-02f,
  1.21516570e-01f, -4.55240272e-02f, 4.07089405e-02f, -2.86368337e-02f, -6.76337928e-02f, 9.33486447e-02f, -8.10851529e-02f, 7.52506852e-02f, -3.31478901e-02f, -1.54201873e-02f,
  1.25054875e-02f, -5.00941910e-02f, 6.11144751e-02f, -5.48521839e-02f, 1.54830897e-02f, 3.53471301e-02f, 3.50077525e-02f, 3.14448327e-02f, 3.71447541e-02f, -5.95049299e-02f,
  -5.75974174e-02f, -9.54083726e-02f, -3.41446213e-02f, -2.10659765e-02f, 6.04688227e-02f, -4.53176387e-02f, -7.79650062e-02f, -1.87353638e-03f, -1.19766593e-01f, 4.16732132e-02f,
  -8.46132450e-03f, -6.84830248e-02f, 7.45660886e-02f, 1.34513617e-01f, -3.42809223e-02f, 7.85250962e-02f, 5.35136797e-02f, 1.36870965e-02f, 3.27985026e-02f, -6.32164534e-03f,
  4.46401313e-02f, 2.37007458e-02f, 3.99459079e-02f, 1.53236136e-01f, 3.69053409e-02f, 3.22116576e-02f, -1.66192763e-02f, -6.19474091e-02f, -2.33676657e-02f, 4.85678390e-02f,
  1.37090189e-02f, 3.40555459e-02f, 4.67287153e-02f, 1.46398321e-02f, 8.39860961e-02f, -9.47556691e-04f, 2.38424037e-02f, 3.09453649e-03f, -3.14581096e-02f, 5.60048083e-03f,
  1.13721089e-02f, 3.66440713e-02f, -6.50942624e-02f, -8.62910375e-02f, -1.40948705e-02f, -5.69819612e-03f, -3.14461589e-02f, 3.63600440e-02f, -7.36082112e-03f, 5.29888161e-02f,
  3.57037485e-02f, 1.49929458e-02f, -3.78126353e-02f, 1.14999212e-01f, -5.47214411e-02f, 8.26542825e-02f, 1.62719637e-02f, 1.02328256e-01f, 3.59575041e-02f, -9.79528576e-03f,
  -4.75115657e-01f, 2.41328835e-01f, -1.08226210e-01f, -1.79810852e-01f, 9.94464457e-02f, -1.53700963e-01f, -6.99767247e-02f, 9.83094648e-02f, -8.06825012e-02f, -4.73357961e-02f,
  -5.09453565e-02f, -2.25524545e-01f, 1.09113030e-01f, -1.46615461e-01f, -3.49028498e-01f, -2.73955297e-02f, -2.07962647e-01f, -2.53199935e-01f, -1.71821695e-02f, -5.05723357e-02f,
  -1.36190597e-02f, 2.05632553e-01f, -1.58044502e-01f, 2.57451177e-01f, -3.35175730e-02f, 9.95771866e-03f, 2.00115908e-02f, 1.31714672e-01f, -4.47405428e-02f, 7.12887198e-02f,
  -2.16723904e-02f, 6.07000589e-02f, -1.32332101e-01f, -3.07459664e-02f, -3.79547812e-02f, 6.86937652e-04f, -3.69840711e-02f, 1.04062455e-02f, -1.42614305e-01f, -7.11608231e-02f,
  -1.02372944e-01f, 4.22468111e-02f, -5.48163615e-02f, 6.07099049e-02f, -7.60092586e-02f, -3.92251983e-02f, 3.42706144e-02f, 1.71278827e-02f, 5.82766309e-02f, -4.98709269e-03f,
  -3.90849933e-02f, -3.73018980e-02f, 4.66098599e-02f, -9.08887014e-02f, 4.60564792e-02f, 5.23738749e-02f, -3.88267860e-02f, 1.83293652e-02f, -1.44636258e-02f, -9.69297998e-03f,
  1.28451167e-02f, -3.38222086e-02f, 1.10292446e-03f, 1.01578362e-01f, 9.05587077e-02f, 6.97520226e-02f, -1.51780741e-02f, 4.16399771e-03f, -3.95704284e-02f, 5.62832616e-02f,
  -3.17008118e-03f, -5.56165241e-02f, 8.80913287e-02f, 3.83923464e-02f, -6.33766036e-03f, -7.09348172e-03f, -2.29686033e-02f, 2.86119874e-03f, -1.12049915e-01f, -4.15374571e-03f,
  -2.18862370e-02f, -2.01391745e-02f, 2.37880158e-03f, -5.25724404e-02f, 5.56562357e-02f, 8.97932723e-02f, 1.26663269e-03f, 1.44968018e-01f, -9.32012722e-02f, -3.66119668e-02f,
  9.83090885e-03f, 5.29015809e-02f, -1.20481560e-02f, -2.41783317e-04f, -1.82633866e-02f, -4.21168730e-02f, -7.79950023e-02f, 2.18965560e-02f, 6.89693317e-02f, -5.09147868e-02f,
  -2.19456684e-02f, -2.82934923e-02f, -2.05925200e-02f, 4.13077809e-02f, 1.00299083e-02f, -8.98075197e-03f, 7.77100772e-02f, -5.25002927e-02f, -2.36872695e-02f, 5.42906336e-02f,
  -2.24689599e-02f, -8.79545435e-02f, 4.51220125e-02f, -1.32371290e-02f, -2.50541586e-02f, -8.25497359e-02f, 1.18474960e-02f, -9.13140643e-03f, 1.85998604e-02f, 4.28701751e-02f,
  -2.63091981e-01f, 6.82326853e-02f, -1.84447557e-01f, -1.69698909e-01f, 1.14283189e-02f, -1.48745507e-01f, -1.13971895e-02f, 4.69495431e-02f, -2.26085126e-01f, 1.81167260e-01f,
  5.72510669e-03f, -2.04172861e-02f, -3.62886265e-02f, -2.66550630e-01f, -4.33695048e-01f, -1.81118116e-01f, -2.52669305e-01f, -1.12995505e-01f, -8.07021856e-02f, -1.96369104e-02f,
  -5.00883348e-02f, -2.50543598e-02f, -1.32010937e-01f, 2.35803291e-01f, -8.38103238e-03f, 1.78073719e-01f, 2.16529474e-01f, 2.49564677e-01f, -1.92301392e-04f, -5.13235442e-02f,
  -6.90208524e-02f, -6.87447563e-02f, 1.49233667e-02f, -3.51430662e-02f, 6.06814548e-02f, 5.90407923e-02f, 6.58139810e-02f, 6.20176867e-02f, -1.58814632e-03f, -7.75719434e-02f,
  3.02097481e-02f, 2.06208527e-02f, -5.21550588e-02f, -4.34569456e-02f, -2.13115122e-02f, -8.87681693e-02f, 2.53703296e-02f, -3.71805276e-03f, -1.02790259e-01f, -1.00621708e-01f,
  -1.23249725e-01f, -1.18497431e-01f, 2.34548524e-02f, 3.09668183e-02f, -2.09163185e-02f, -4.27643210e-03f, -5.15542999e-02f, -3.06863133e-02f, 4.39725108e-02f, -1.14438199e-01f,
  8.31099376e-02f, 1.00254178e-01f, -2.21696012e-02f, -1.02153093e-01f, -7.45033752e-03f, -5.94255067e-02f, 4.09918390e-02f, -7.89034963e-02f, -1.31655671e-02f, -4.63328734e-02f,
  -7.80011341e-03f, 2.78845690e-02f, -2.04378385e-02f, 1.46578699e-02f, -1.37542505e-02f, 4.09340933e-02f, -1.04398942e-02f, -2.32835859e-02f, 1.09885791e-02f, -6.17041439e-02f,
  4.91357371e-02f, 5.33653647e-02f, -8.85349214e-02f, 2.66879778e-02f, -4.59386818e-02f, -4.38590758e-02f, 1.53050618e-03f, -9.78701040e-02f, 7.30297789e-02f, 3.71717922e-02f,
  -3.61558236e-02f, 3.25916819e-02f, 6.56363219e-02f, -1.26302391e-02f, 8.22491869e-02f, -3.26829366e-02f, 6.75121918e-02f, -3.83872632e-03f, 4.01783064e-02f, 1.20315686e-01f,
  1.40428813e-02f, 9.91320610e-03f, 1.30634218e-01f, -8.33541974e-02f, -4.02576588e-02f, -2.94739436e-02f, -3.43798362e-02f, 2.67198272e-02f, 1.04723342e-01f, -9.16709006e-02f,
  8.28455612e-02f, 2.73297131e-02f, 3.67519967e-02f, 6.03424534e-02f, -2.87573077e-02f, 3.19966339e-02f, 7.45380819e-02f, -4.56625130e-03f, 5.43940403e-02f, -2.89515108e-02f,
  3.39006670e-02f, -1.74867772e-02f, -1.91734973e-02f, 4.38466854e-02f, -6.51720017e-02f, -1.42734334e-01f, 2.46104021e-02f, 5.62096052e-02f, -2.08158046e-01f, 5.76608703e-02f,
  -2.12066639e-02f, -8.56945813e-02f, -1.69898961e-02f, -9.47762579e-02f, 8.99951980e-02f, 2.61900593e-02f, -2.89663095e-02f, -7.42755905e-02f, -8.73892084e-02f, 1.37927547e-01f,
  -1.44253016e-01f, 9.71373450e-03f, -1.37986299e-02f, 9.02799889e-02f, 9.66350585e-02f, -4.44865339e-02f, 1.74121857e-01f, -8.31362512e-03f, -3.78456041e-02f, -1.33291200e-01f,
  -2.62661148e-02f, 2.39304882e-02f, -2.33063921e-02f, -5.97725622e-02f, 1.04498617e-01f, 5.10737076e-02f, 2.38534939e-02f, 4.43920307e-03f, -4.15678322e-02f, -1.00548133e-01f,
  -9.81680304e-03f, 5.43464310e-02f, -4.57364619e-02f, 4.47876751e-02f, -6.93257956e-04f, -3.02736964e-02f, 1.04789928e-01f, 3.43127511e-02f, 3.94914672e-03f, -5.11482283e-02f,
  -1.86430616e-03f, 8.44134763e-03f, 1.62708033e-02f, 5.38701676e-02f, -3.72728743e-02f, -5.70288934e-02f, -8.82389769e-02f, 5.42382188e-02f, -8.04527551e-02f, 1.67840216e-02f,
  9.89032760e-02f, -8.05947408e-02f, -3.89215387e-02f, -8.19285288e-02f, -4.69358265e-03f, -4.07511890e-02f, -4.53516506e-02f, 3.20693403e-02f, 3.00428253e-02f, 7.98036084e-02f,
  3.79351154e-02f, -2.72944127e-03f, -9.37385112e-02f, 7.33443424e-02f, 8.33154917e-02f, 3.46263573e-02f, 7.71924481e-02f, 4.56657521e-02f, 3.91982272e-02f, -3.02204881e-02f,
  -4.88736741e-02f, 3.53855900e-02f, -2.98313033e-02f, 7.02678086e-03f, -8.06594044e-02f, 5.12444638e-02f, 6.27404898e-02f, -2.66791172e-02f, 2.87177395e-02f, -2.33976506e-02f,
  8.20399076e-02f, 1.81240752e-01f, -8.93962234e-02f, -9.97675508e-02f, 4.33169380e-02f, 8.34145993e-02f, -7.33119622e-03f, -7.92461559e-02f, 8.81766379e-02f, -4.93283495e-02f,
  1.51801422e-01f, -1.02590941e-01f, 6.62270710e-02f, 1.04503207e-01f, -7.74603039e-02f, 1.56411484e-01f, -3.41898762e-02f, -3.40888053e-02f, -8.11346341e-03f, 1.12847634e-01f,
  1.14079878e-01f, 2.03296375e-02f, -1.51604727e-01f, 1.11035064e-01f, 9.05959960e-03f, 2.92604659e-02f, -4.58621606e-02f, 1.25519514e-01f, -1.14768684e-01f, 3.02661173e-02f,
  -1.53854743e-01f, -6.27788380e-02f, 1.50825819e-02f, 1.07398771e-01f, 2.00970322e-02f, -1.06097781e-03f, -1.15370058e-01f, -1.19221564e-02f, 8.68240669e-02f, 4.97634150e-02f,
  -5.09470375e-03f, 8.49751085e-02f, 3.07520255e-02f, -1.54035771e-02f, -5.73080685e-03f, -1.09355047e-01f, -2.07073260e-02f, -1.30620005e-03f, 8.10568854e-02f, 3.04919314e-02f,
  4.87240404e-02f, -9.59892571e-02f, -1.00448588e-02f, 9.30166915e-02f, -1.42814517e-02f, 1.44582260e-02f, 7.83084407e-02f, -1.72699224e-02f, 7.55298091e-03f, 2.34232545e-02f,
  4.53951433e-02f, 1.39147073e-01f, -9.71326903e-02f, -4.24530916e-02f, -5.85910901e-02f, 1.46339145e-02f, -3.30722742e-02f, 2.22342089e-02f, 6.58003762e-02f, 2.18200460e-02f,
  -7.29080737e-02f, -1.77909061e-02f, -8.11692029e-02f, -3.43780071e-02f, -9.32797566e-02f, 1.70151051e-02f, 2.33003609e-02f, 4.00008112e-02f, -8.25541317e-02f, 6.14264645e-02f,
  5.29263504e-02f, 7.91808367e-02f, -9.18953717e-02f, 1.03684038e-01f, -1.01880834e-01f, 5.39181009e-02f, 8.81131664e-02f, 8.47547278e-02f, 8.60889629e-02f, 6.55985028e-02f,
  -5.52794188e-02f, 4.18522535e-03f, 1.01597659e-01f, -1.40484851e-02f, 1.79695357e-02f, 3.00263520e-03f, 7.89960548e-02f, -3.44270729e-02f, 4.22689086e-03f, -1.13441736e-01f,
  1.26774423e-02f, 2.11505760e-02f, -1.97815262e-02f, 2.87364200e-02f, 1.50900129e-02f, 1.18251313e-02f, 8.62569958e-02f, -1.27211772e-02f, -1.50058651e-02f, 2.83435099e-02f,
  3.58937718e-02f, 5.51708005e-02f, -8.42685178e-02f, -2.54256325e-03f, -6.53215731e-03f, 1.69519465e-02f, -5.34787886e-02f, 5.01174713e-03f, 7.30664879e-02f, -7.57337660e-02f,
  -1.35767922e-01f, 9.82259810e-02f, -9.28870738e-02f, 1.63140669e-02f, -5.37927337e-02f, 4.08758968e-02f, -5.53093068e-02f, -8.13425183e-02f, -4.96216072e-03f, 3.36897299e-02f,
  2.95759160e-02f, 2.16954276e-02f, -8.80681500e-02f, -4.50583771e-02f, 4.75028669e-03f, -3.19880992e-02f, 9.73209143e-02f, -8.56247395e-02f, 1.25818867e-02f, 2.82701664e-02f,
  1.98228145e-03f, -5.74103668e-02f, 3.73719819e-02f, 5.47870882e-02f, 6.59026876e-02f, 4.89204787e-02f, 4.79758121e-02f, 1.15680143e-01f, -7.28510842e-02f, -1.06384382e-01f,
  5.12301028e-02f, -1.41429901e-01f, 6.16306216e-02f, 1.43160909e-01f, 4.77480702e-02f, 5.27998954e-02f, -5.51476851e-02f, 2.40003457e-03f, 4.62616645e-02f, -1.74363539e-01f,
  1.19203292e-01f, -7.40589127e-02f, -2.06958309e-01f, 1.66130453e-01f, 5.20685203e-02f, -1.36704873e-02f, 4.88268621e-02f, 1.13900863e-01f, 5.24495095e-02f, -7.26624429e-02f,
  1.47303522e-01f, 1.51625544e-01f, 4.89640385e-02f, 1.23711646e-01f, 1.28101230e-01f, 8.89002625e-03f, -5.82743734e-02f, 1.68180442e-03f, 1.29924625e-01f, 5.24103567e-02f,
  -5.08121587e-03f, 7.71317026e-03f, 6.77809790e-02f, 1.50132887e-02f, -6.50338903e-02f, -1.11516245e-01f, 5.76239340e-02f, 4.90917498e-03f, 3.70246102e-03f, -2.56322585e-02f,
  -3.19311358e-02f, 1.32824719e-01f, 8.46831948e-02f, -2.09031273e-02f, -4.18724455e-02f, 7.73894489e-02f, -4.73912507e-02f, 6.63809478e-02f, -1.83910634e-02f, -2.19951253e-02f,
  6.03162625e-04f, -2.51525827e-02f, -8.21192786e-02f, 9.09761563e-02f, 4.21004742e-02f, 4.91569676e-02f, 5.26418760e-02f, -5.06877378e-02f, -7.46345818e-02f, 1.43783197e-01f,
  -7.46350437e-02f, 4.82106060e-02f, -2.30166204e-02f, 6.10658266e-02f, -8.67889524e-02f, -4.34402339e-02f, 9.93925333e-02f, -7.73752108e-02f, 1.58329923e-02f, -6.46985024e-02f,
  -1.00859022e-02f, 2.04696842e-02f, 7.36965537e-02f, -3.27388644e-02f, 1.99453980e-02f, -1.82077494e-02f, -8.79859999e-02f, -8.16644877e-02f, -1.16867661e-01f, -6.65839165e-02f,
  3.59843858e-02f, 8.73612054e-03f, -1.33904358e-02f, -4.09717448e-02f, 1.07910372e-02f, -3.26280296e-03f, 4.72988561e-02f, 3.35852429e-02f, -1.13274110e-02f, 5.77484779e-02f,
  -1.38998833e-02f, -6.57836571e-02f, -2.22112779e-02f, -9.32579511e-04f, -3.12797166e-02f, 1.82404164e-02f, 4.26747557e-03f, 8.16190615e-02f, -1.20952949e-02f, -6.54519945e-02f,
  -2.34242082e-02f, 3.96177638e-03f, -1.29951835e-01f, -9.20633692e-03f, -4.82698679e-02f, -1.22144453e-01f, 5.69292717e-02f, 5.62351234e-02f, -1.13473594e-01f, -3.44008654e-02f,
  1.34761026e-02f, -1.47546470e-01f, 4.49857339e-02f, 7.41165802e-02f, -7.46051520e-02f, 2.57176608e-02f, -5.92960343e-02f, 1.84457953e-04f, -4.92677987e-02f, 9.35757384e-02f,
  -7.16953278e-02f, 1.98781505e-01f, 3.29642557e-02f, -7.61612281e-02f, -4.24686447e-03f, -9.73396078e-02f, -1.82231754e-01f, -1.98107455e-02f, 2.17990335e-02f, 2.26434991e-01f,
  -2.37010084e-02f, 1.07599579e-01f, 1.69027038e-02f, -1.73474565e-01f, -4.29253876e-01f, -1.90987036e-01f, -1.30185321e-01f, -5.43605015e-02f, -1.36599347e-01f, -2.89923921e-02f,
  -1.81951359e-01f, -1.39119774e-01f, -7.31296018e-02f, -2.89925020e-02f, 2.95519494e-02f, 1.30613267e-01f, 1.02626644e-01f, 1.21127702e-01f, 1.78636108e-02f, -1.00709476e-01f,
  -7.04023540e-02f, 1.06974483e-01f, 2.21496403e-01f, 1.04832545e-01f, 3.28650959e-02f, 4.54140380e-02f, 7.05252811e-02f, -1.78427622e-02f, 6.34616911e-02f, -7.81005993e-03f,
  1.10001169e-01f, -3.38826887e-03f, 7.38107339e-02f, 3.67281511e-02f, 8.38944167e-02f, 6.20716065e-02f, 3.29155102e-02f, 6.41603917e-02f, -1.24526583e-03f, -5.36410511e-02f,
  7.65264630e-02f, 8.60568210e-02f, -3.44446227e-02f, 6.71865465e-03f, -1.94762014e-02f, -1.22966236e-02f, -1.12561481e-02f, -3.29169855e-02f, -3.04928236e-02f, -1.41747098e-03f,
  -1.33374199e-01f, -1.92508325e-02f, -3.37140858e-02f, 3.21758091e-02f, 5.76390214e-02f, 4.77303192e-03f, -7.62597844e-02f, 1.04832910e-02f, 6.98159412e-02f, 5.70743810e-03f,
  1.82165280e-02f, -4.36179303e-02f, 6.64809197e-02f, -5.28585203e-02f, 5.99835329e-02f, 1.31987305e-02f, 4.24678577e-03f, -1.76414456e-02f, -2.61315312e-02f, 4.48800176e-02f,
  4.35469300e-02f, -3.46824490e-02f, -3.87332551e-02f, -2.14232132e-02f, -2.93532275e-02f, 4.16751206e-03f, 7.97162130e-02f, 5.40506840e-02f, 5.63137867e-02f, -1.22344904e-02f,
  3.53654986e-03f, 1.15723804e-01f, 5.70852635e-03f, 3.31423767e-02f, 1.40919462e-02f, 3.58530357e-02f, 1.69070978e-02f, 3.63001004e-02f, 5.81144877e-02f, -4.03623991e-02f,
  -2.09392961e-02f, 7.05306455e-02f, 2.78959759e-02f, -4.65577468e-02f, 5.31739220e-02f, -5.91760837e-02f, -7.27653829e-03f, 1.34374425e-01f, 4.63419370e-02f, 5.28622046e-02f,
  2.83457916e-02f, 4.48766835e-02f, -1.19031677e-02f, 2.97563728e-02f, -5.49677052e-02f, 1.13752730e-01f, -1.50265926e-02f, 2.28228793e-02f, -5.58844618e-02f, -2.21111793e-02f,
  -3.31154883e-01f, -6.07763045e-02f, 1.28675267e-01f, -1.44465491e-01f, -3.60869132e-02f, 1.96654111e-01f, 2.05790296e-01f, -8.90732110e-02f, -2.63426721e-01f, -1.77312404e-01f,
  -3.67011465e-02f, -8.28788057e-02f, 1.58118501e-01f, -6.01100065e-02f, 2.04945147e-01f, 2.35885829e-01f, 3.83649617e-02f, -2.39477623e-02f, -1.09584980e-01f, 3.96164246e-02f,
  4.81598228e-02f, 9.96259302e-02f, 2.78854162e-01f, 3.75910662e-02f, 6.14294372e-02f, -1.21188655e-01f, 8.50499347e-02f, 1.66245118e-01f, -5.75647429e-02f, 2.95909513e-02f,
  4.72603217e-02f, -8.22957829e-02f, 1.44664153e-01f, -3.13985571e-02f, -8.22386704e-03f, -2.67375484e-02f, 5.40517382e-02f, 8.30739290e-02f, -5.61515130e-02f, 4.48092408e-02f,
  9.73019842e-03f, -6.85487268e-03f, -7.51986206e-02f, -1.10612102e-01f, 6.31611096e-03f, -5.05704619e-02f, 1.00834511e-01f, 2.11780481e-02f, -6.40710965e-02f, -5.84331676e-02f,
  2.61631273e-02f, 8.56765658e-02f, 8.85881204e-03f, 2.00594150e-05f, 3.19330581e-02f, -1.88435463e-03f, -2.03761179e-02f, 1.51339425e-02f, -3.84321436e-02f, -7.32794851e-02f,
  -3.40046547e-02f, -2.23853905e-02f, 2.36747675e-02f, -1.02607891e-01f, -6.15951512e-03f, -2.02696584e-02f, 1.15685917e-01f, -2.51851305e-02f, -7.90721625e-02f, -5.04720956e-02f,
  2.11995803e-02f, -2.89392211e-02f, 1.53754503e-01f, -3.31520364e-02f, -1.47151425e-02f, -4.79805842e-02f, -3.56429666e-02f, -6.28713332e-03f, -5.49770035e-02f, -7.68553913e-02f,
  2.48818062e-02f, -2.72459872e-02f, -8.47956340e-04f, -2.62092389e-02f, 4.47544642e-02f, 4.41925041e-02f, 4.27700467e-02f, 4.93739881e-02f, 2.95382254e-02f, 1.10099368e-01f,
  -3.24331000e-02f, -1.06636144e-01f, -3.06697283e-02f, 1.13165814e-04f, 3.25019546e-02f, -2.44795671e-03f, 7.53872842e-02f, -9.74010080e-02f, 5.84833883e-02f, -1.83341987e-02f,
  -1.05657121e-02f, 4.90162224e-02f, -4.06955555e-03f, -5.68146445e-03f, -1.11408047e-01f, 2.73733307e-02f, 1.99571438e-03f, -5.08134626e-03f, 9.82735008e-02f, -1.12359278e-01f,
  4.01713662e-02f, -1.06652670e-01f, -8.72668326e-02f, 2.81721354e-02f, -7.03430474e-02f, 1.41241541e-02f, -6.15498750e-03f, -6.60132915e-02f, -3.08022629e-02f, -7.17018619e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -1.90533265e-01f, -8.96653533e-03f, -2.20978811e-01f, -3.28599475e-02f, -3.76774669e-02f, -7.56841153e-02f, -2.30699144e-02f, -4.29922342e-02f, -7.51693025e-02f, -1.13096505e-01f,
  -5.11431918e-02f, 1.01695983e-02f, 9.78675932e-02f, -2.57263612e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.25675008e-01f, 4.94490825e-02f, 3.95913720e-01f, -6.47405982e-02f, 2.51985788e-02f, 9.08755958e-02f, -1.04875162e-01f, 8.94362554e-02f, 2.08691224e-01f, 9.10832584e-02f,
  -9.28098857e-02f, -1.67580009e-01f, 1.89322621e-01f, 3.50138009e-01f, -1.27478004e-01f, -2.11232845e-02f, 3.97891477e-02f, 1.51927754e-01f, 2.43619427e-01f, 1.60367846e-01f,
  -1.57821372e-01f, -1.87995985e-01f, -3.25824060e-02f, -1.30418658e-01f, 1.13209449e-01f, -1.21603627e-02f, 2.56834477e-01f, 2.74391562e-01f, 6.95538446e-02f, -5.55774234e-02f,
  5.99383265e-02f, -7.27160797e-02f, -7.87606984e-02f, 1.10933550e-01f, 1.02570720e-01f, 2.36591682e-01f, 1.59401074e-01f, -8.00372586e-02f, -4.89026979e-02f, 1.40527621e-01f,
  1.54391423e-01f, 1.63452446e-01f, -1.71418682e-01f, -1.48703694e-01f, 4.68450896e-02f, 2.71394610e-01f, -2.02668607e-01f, -9.07416046e-02f, -1.88219205e-01f, -1.84344687e-02f,
  2.37432078e-01f, 1.82679325e-01f, 2.84219813e-02f, -1.61919624e-01f, -7.34188035e-02f, 8.23761895e-03f, 1.46729827e-01f, -8.15453380e-02f, -1.11718886e-01f, 1.06719069e-01f,
  2.38053557e-02f, -1.72413755e-02f, 2.32328817e-01f, -1.22047231e-01f, -3.76068912e-02f, -1.43927187e-01f, 4.32818942e-03f, -8.42794105e-02f, 1.47358403e-01f, 2.83801369e-02f,
  1.29501313e-01f, -1.57892406e-01f, 1.40075892e-01f, 3.96572769e-01f, 1.16953440e-01f, 4.61608022e-02f, 3.64055395e-01f, 1.35588735e-01f, 2.59023875e-01f, 2.49249130e-01f,
  1.32713228e-01f, 2.53427982e-01f, -1.44967377e-01f, -4.11877967e-02f, -5.16847193e-01f, -5.03624864e-02f, -1.50016546e-01f, 1.11282878e-02f, -1.88190803e-01f, 3.13651860e-01f,
  1.04526617e-01f, -1.87902421e-01f, 7.64670298e-02f, -1.43707022e-01f, 2.50651509e-01f, -1.01967581e-01f, 5.89935370e-02f, -2.79580981e-01f, 1.44613639e-01f, -2.62107663e-02f,
  1.33334443e-01f, 3.05196524e-01f, -6.68202899e-03f, -3.02450776e-01f, 8.47098976e-02f, 1.99263424e-01f, 3.67357820e-01f, 3.42318892e-01f, -2.03052089e-01f, -1.62441075e-01f,
  2.11240008e-01f, 1.83040295e-02f, 1.53659359e-01f, -1.19652629e-01f, -2.57335395e-01f, -2.07009315e-02f, -2.41867989e-01f, 1.11199312e-01f, 9.74823087e-02f, 1.01698376e-01f,
  -2.01339096e-01f, 4.03614044e-01f, 2.79893968e-02f, 4.47009057e-02f, 1.86322466e-01f, -1.11403465e-01f, 1.24871820e-01f, 1.41287103e-01f, 4.90104072e-02f, -6.40353411e-02f,
  -4.87263873e-02f, 1.29924893e-01f, -1.26144275e-01f, -1.36856422e-01f, 1.79755196e-01f, -6.39090687e-02f, 4.14163955e-02f, -2.07254827e-01f, 2.64035374e-01f, 9.36085284e-02f,
  -2.93471485e-01f, -2.06608295e-01f, -9.21754912e-02f, -5.14808223e-02f, -5.98822720e-02f, -2.08583266e-01f, -7.28614330e-02f, 5.86762500e-04f, 3.22749108e-01f, -1.93268317e-03f,
  -1.46614149e-01f, -9.61912572e-02f, 7.36039206e-02f, 1.36938497e-01f, -2.62451023e-01f, -8.49343836e-02f, 1.01894625e-01f, -8.96839648e-02f, 6.14248030e-02f, 1.51228949e-01f,
  7.39090964e-02f, 1.75805375e-01f, -2.55838037e-01f, 1.75368115e-01f, 2.55708117e-02f, -1.29470959e-01f, 1.54696867e-01f, -1.29548848e-01f, -1.92176566e-01f, -2.06533894e-01f,
  -1.57642096e-01f, -4.82790023e-02f, -2.67610699e-01f, -2.57608797e-02f, 1.00968637e-01f, -1.05894573e-01f, 2.97064297e-02f, 1.57080352e-01f, 1.16064698e-01f, -1.31544843e-02f,
  1.66208059e-01f, 4.30624560e-02f, 1.62411660e-01f, -6.85462430e-02f, 8.39488059e-02f, -3.02793592e-01f, -3.68295461e-01f, -1.06963562e-02f, -1.17076449e-01f, -7.55107179e-02f,
  -1.52412087e-01f, 2.20757793e-03f, -6.24797568e-02f, 3.80739607e-02f, 2.06982046e-01f, 2.27894634e-01f, 2.24537298e-01f, -4.29504693e-01f, -1.25779316e-01f, -1.14413714e-02f,
  7.09318295e-02f, -2.76244819e-01f, 2.03600198e-01f, -1.95367169e-03f, -1.51142195e-01f, -8.80713388e-02f, -4.35337961e-01f, -1.01607449e-01f, -2.53970176e-01f, -1.47423729e-01f,
  1.82163551e-01f, 3.10796291e-01f, 2.04594091e-01f, -1.11613430e-01f, 2.17300117e-01f, 1.25560924e-01f, -3.98904420e-02f, 7.45619312e-02f, 7.42210224e-02f, 2.03611746e-01f,
  -2.92734921e-01f, 9.53389108e-02f, 8.02263394e-02f, -5.04360385e-02f, 7.91222975e-02f, -1.39749825e-01f, 2.08978593e-01f, -1.35551184e-01f, -6.11420572e-02f, 1.31369889e-01f,
  -1.88315101e-02f, -5.39569184e-04f, 2.10332826e-01f, 3.04198358e-02f, 2.00232431e-01f, 1.90999418e-01f, -6.17743097e-02f, -1.35105953e-01f, -1.36112764e-01f, -1.00393705e-01f,
  -4.64825742e-02f, 2.10719518e-02f, -6.78082108e-02f, 1.71325937e-01f, -2.40103841e-01f, -3.15290899e-03f, -1.66616932e-01f, 1.88312948e-01f, 6.84477314e-02f, 3.13622057e-01f,
  3.54115546e-01f, 4.46705185e-02f, 9.35106259e-03f, -1.19894385e-01f, 3.58730108e-02f, -5.99520048e-03f, 2.44671196e-01f, -2.55820882e-02f, 1.77204058e-01f, -1.71439648e-01f,
  1.59502193e-01f, -1.20035689e-02f, 1.94457695e-01f, 6.26801401e-02f, 3.64047080e-01f, 3.54575098e-01f, 2.05531135e-01f, -1.09387323e-01f, 4.51271176e-01f, -1.45838976e-01f,
  1.15558796e-01f, -9.03705060e-02f, 7.35039338e-02f, 1.29501909e-01f, -3.63852307e-02f, -1.84130713e-01f, -2.83601105e-01f, 2.42212117e-01f, -3.29116322e-02f, 7.49042258e-02f,
  -2.12416217e-01f, 2.96429664e-01f, 4.34314311e-01f, -1.46424323e-01f, 1.62967622e-01f, 4.96139340e-02f, 4.12709177e-01f, -2.17394471e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -4.58863489e-02f, -8.83202404e-02f, 1.61128074e-01f, -3.00649498e-02f, -3.82232666e-02f, 1.60759002e-01f, 2.26328805e-01f, -8.61511827e-02f, 1.88168168e-01f, 3.59332934e-02f,
  1.71213679e-03f, -1.58188134e-01f, -2.49580410e-03f, -4.79261056e-02f, 2.33752117e-01f, 1.95225447e-01f, 6.43649548e-02f, 2.52594441e-01f, 1.08472280e-01f, -1.49882093e-01f,
  -4.91092242e-02f, 1.48099184e-01f, -7.10859597e-02f, -1.42492041e-01f, 1.25660196e-01f, 6.08617142e-02f, 2.19169799e-02f, -1.23082817e-01f, -1.91520322e-02f, 1.21818356e-01f,
  -6.31058887e-02f, 2.59077638e-01f, 4.47351933e-02f, 8.61964673e-02f, -6.40052930e-02f, -8.80008750e-03f, 2.38755718e-01f, 9.86830965e-02f, 1.90522239e-01f, -1.25562593e-01f,
  1.02091581e-01f, 1.09074086e-01f, -3.95565741e-02f, 2.57582460e-02f, -3.38321209e-01f, -7.63255209e-02f, 1.68575346e-01f, 1.47217110e-01f, 1.16120785e-01f, 2.43763894e-01f,
  -1.52968735e-01f, -3.51626128e-02f, -2.51749396e-01f, -5.62875122e-02f, 1.20477952e-01f, -1.50483221e-01f, -1.04924254e-01f, 2.21195400e-01f, -4.82685417e-02f, -5.62045239e-02f,
  -1.09956916e-02f, -1.69171587e-01f, -2.75019735e-01f, 3.48733276e-01f, -7.81034157e-02f, -5.00464393e-03f, 7.80995563e-02f, 7.10628033e-02f, 1.16670497e-01f, -1.80157796e-01f,
  2.32126340e-01f, -2.50630248e-02f, 2.58806776e-02f, -2.25424230e-01f, -8.88446495e-02f, 6.07570307e-03f, -1.85149327e-01f, -5.62352361e-04f, -2.96501607e-01f, -8.48471299e-02f,
  1.03043713e-01f, -7.27034807e-02f, 3.50534499e-01f, 2.80850142e-01f, 1.10201947e-01f, -1.05747826e-01f, 1.10619672e-01f, -1.18203368e-02f, 6.25291765e-02f, -3.83789535e-03f,
  1.39064670e-01f, 1.83700293e-01f, 7.36481100e-02f, -6.23680837e-03f, -3.46844606e-02f, -6.18652701e-02f, 1.90948710e-01f, -2.36168155e-03f, -2.46658083e-02f, -7.52680898e-02f,
  -1.31891996e-01f, -1.82828069e-01f, 1.14865169e-01f, 1.21167682e-01f, -1.80107415e-01f, -2.05314010e-01f, 8.45032930e-02f, 2.34455347e-01f, -2.37392634e-02f, -2.37556860e-01f,
  7.93654546e-02f, -1.57113642e-01f, -3.65431271e-02f, -3.59684974e-01f, -1.45148814e-01f, 5.91967963e-02f, 3.98029089e-01f, -1.61038458e-01f, -2.79670279e-03f, -5.29551655e-02f,
  2.14422286e-01f, -4.94348109e-02f, -3.35138701e-02f, -9.32201091e-03f, -1.15646444e-01f, -7.30647221e-02f, -2.07677037e-02f, 6.60933033e-02f, -1.35796845e-01f, -8.77875164e-02f,
  1.46021277e-01f, -4.74028215e-02f, 4.66545969e-02f, 1.22473063e-02f, -6.48756996e-02f, 1.81306541e-01f, 1.00294791e-01f, 9.81439725e-02f, 7.02449828e-02f, 5.82637750e-02f,
  -5.98687828e-02f, 2.08956078e-01f, -7.31713846e-02f, -6.38277382e-02f, -1.43978566e-01f, -1.51332431e-02f, 2.25582123e-01f, 1.25482187e-01f, 2.02983245e-02f, -7.99202174e-02f,
  -1.16581693e-01f, 4.01473083e-02f, 1.21367842e-01f, 1.00084729e-01f, -4.35398938e-03f, 7.84443095e-02f, 4.03157808e-02f, 4.05849479e-02f, 1.01200774e-01f, 8.60886723e-02f,
  1.15801588e-01f, 2.46721432e-01f, 1.07708462e-01f, 1.07155778e-01f, -1.49649993e-01f, 1.64036408e-01f, 1.18833937e-01f, 1.83953688e-01f, 6.27654195e-02f, 5.82309999e-02f,
  2.77677607e-02f, -2.23145485e-01f, 7.67800212e-03f, 1.58800393e-01f, -1.22952111e-01f, -6.89503849e-02f, 3.34165581e-02f, 8.71908218e-02f, 1.81093797e-01f, -4.01082635e-02f,
  -3.45655382e-02f, -1.48679912e-01f, 1.91789586e-02f, -5.51661365e-02f, -1.33329049e-01f, -1.62597656e-01f, -5.18505909e-02f, 1.47364438e-01f, -1.10769905e-01f, 2.40185842e-01f,
  -3.90193872e-02f, 1.78266808e-01f, -1.48994595e-01f, 1.55708909e-01f, 6.82936981e-02f, 9.80309695e-02f, -1.50710732e-01f, -9.14028510e-02f, 4.80656736e-02f, 4.87205498e-02f,
  -1.85829289e-02f, 2.54021846e-02f, 1.34989366e-01f, 2.56519824e-01f, 1.00001946e-01f, -4.56318557e-02f, -3.43987495e-02f, 1.24195330e-01f, 1.97804794e-01f, -1.59669816e-01f,
  -5.41533232e-02f, -1.45773679e-01f, 2.19083756e-01f, -4.91326535e-03f, 4.57362235e-02f, 1.89586431e-01f, -1.62257746e-01f, -8.88212174e-02f, 3.23617761e-03f, -1.09118931e-01f,
  6.60737976e-02f, 6.54144585e-02f, 6.02885783e-02f, 2.03415588e-01f, 1.80720404e-01f, 2.76506543e-01f, 3.76312360e-02f, 2.43900746e-01f, 2.05878302e-01f, 7.30781704e-02f,
  -1.25817403e-01f, 3.11814398e-01f, 2.57466622e-02f, -9.55496058e-02f, -1.95414990e-01f, -1.27012298e-01f, 1.19753398e-01f, 3.29365402e-01f, -1.61551610e-01f, -1.47466466e-01f,
  1.62820026e-01f, 1.48359276e-02f, 4.93957639e-01f, 1.35418981e-01f, 2.19564885e-01f, -1.50419623e-01f, 1.71138737e-02f, 1.38458431e-01f, -8.25537294e-02f, -3.20654735e-02f,
  -1.92016259e-01f, -1.16252759e-02f, -1.30751938e-01f, 3.29058230e-01f, -2.57067353e-01f, -3.36218104e-02f, 3.13106626e-02f, 1.29787803e-01f, -1.59410298e-01f, -4.58392687e-02f,
  1.56098884e-03f, 1.30962729e-01f, -1.07334130e-01f, 1.71360865e-01f, 4.03612815e-02f, 5.28019331e-02f, -1.34341776e-01f, -1.13006264e-01f, 5.02606370e-02f, -6.72815964e-02f,
  7.95451328e-02f, 1.02856755e-01f, -1.61673054e-01f, -1.12621143e-01f, 7.14855492e-02f, -7.64108151e-02f, -1.24622673e-01f, 1.12284131e-01f, 1.19141072e-01f, -1.17336787e-01f,
  -7.06967860e-02f, -1.95888996e-01f, 7.69002661e-02f, -4.33193846e-03f, 1.31632373e-01f, -6.48674145e-02f, -1.04752645e-01f, 1.62906513e-01f, 3.13492209e-01f, 4.83174287e-02f,
  -1.42622799e-01f, 2.37997428e-01f, 2.81879101e-02f, 3.18961382e-01f, 2.99519211e-01f, 6.30685315e-02f, -1.55236006e-01f, 1.93695858e-01f, -4.43304963e-02f, 1.88463256e-01f,
  -2.81988889e-01f, -1.87340096e-01f, 2.96459675e-01f, -1.32669974e-02f, 1.95717856e-01f, 2.63297468e-01f, -3.01047295e-01f, -2.06311405e-01f, -6.34298543e-04f, 1.28627285e-01f,
  -6.41598031e-02f, 8.97888243e-02f, 9.05419588e-02f, 7.13209286e-02f, -9.06822681e-02f, -2.17123717e-01f, 7.47654960e-02f, 5.78108151e-03f, 1.33347452e-01f, 3.66618276e-01f,
  2.70905681e-02f, 9.44076758e-03f, 4.37795371e-03f, -7.17421770e-02f, -2.26365682e-02f, 1.38072953e-01f, -8.33177343e-02f, 2.49604002e-01f, 1.01620831e-01f, 1.43014431e-01f,
  -1.49537101e-01f, -2.63838708e-01f, 3.13872725e-01f, -2.32442897e-02f, 1.09046176e-01f, 2.04601198e-01f, 6.52989969e-02f, 2.90704459e-01f, 1.72016080e-02f, -4.24029632e-03f,
  -6.20578565e-02f, 7.22590238e-02f, -9.23321024e-02f, -1.50339544e-01f, 5.55428751e-02f, -7.64363855e-02f, 6.01287037e-02f, 3.11561394e-02f, 7.69027248e-02f, 2.53331572e-01f,
  1.19617045e-01f, -4.51907031e-02f, 1.55119285e-01f, 2.13584378e-02f, -8.85231718e-02f, 2.11006090e-01f, 7.75628388e-02f, 4.67455499e-02f, -8.95648636e-03f, 1.79416761e-01f,
  7.33094364e-02f, 2.08844438e-01f, 1.22061118e-01f, 8.19716379e-02f, -2.58425444e-01f, 6.11000992e-02f, -3.89351882e-03f, -3.88777889e-02f, 5.91386557e-02f, -2.07499992e-02f,
  -2.23457128e-01f, -8.80877823e-02f, -7.53986761e-02f, 1.50851279e-01f, 5.06743416e-02f, -1.97881870e-02f, 8.00044909e-02f, 3.30242291e-02f, -1.88644677e-01f, -1.60778672e-01f,
  -7.08909556e-02f, -1.58252671e-01f, -9.58118737e-02f, 2.82442659e-01f, -7.95851722e-02f, -6.30274564e-02f, 1.55845791e-01f, -6.52642250e-02f, 3.32064410e-05f, -7.74359703e-02f,
  1.24578901e-01f, 4.83063348e-02f, 1.97104916e-01f, 6.11231476e-02f, -3.88437472e-02f, 2.05822885e-02f, 1.26450717e-01f, 7.91377574e-02f, -6.29000664e-02f, 9.34231561e-04f,
  4.75205556e-02f, 7.82002434e-02f, 2.96198994e-01f, -8.03897157e-02f, -7.39569291e-02f, -1.19285651e-01f, 1.15416393e-01f, -9.58135948e-02f, 8.99891406e-02f, -1.88628942e-01f,
  -2.81445403e-02f, -1.34755835e-01f, -1.83217637e-02f, 2.08199278e-01f, 7.84919560e-02f, -1.69076338e-01f, 1.56582907e-01f, -1.82069793e-01f, -8.35110992e-02f, 4.73916680e-02f,
  1.41127557e-01f, 4.04700600e-02f, -8.35697055e-02f, 2.97450647e-03f, -1.68408096e-01f, -5.25551699e-02f, -1.99439690e-01f, 1.25416741e-01f, 1.91617191e-01f, 1.98612571e-01f,
  5.13190590e-02f, -5.52268028e-02f, -1.57288630e-02f, 1.21484295e-01f, -1.21037081e-01f, 3.89123783e-02f, -1.49262220e-01f, 1.22257799e-01f, -8.05315822e-02f, -4.53741616e-03f,
  -1.68826640e-01f, -8.78755823e-02f, 4.26402949e-02f, 1.30517781e-01f, 5.05298376e-02f, -5.62193803e-02f, 1.80781409e-02f, -1.37502566e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  8.95405114e-02f, 1.29603282e-01f, 6.32551387e-02f, 1.47706717e-01f, -1.16229225e-02f, 1.48617765e-02f, -3.23151536e-02f, 1.04146384e-01f, 3.87151390e-02f, 3.72882903e-01f,
  5.68209328e-02f, 1.80984549e-02f, -2.74116639e-02f, 5.77326901e-02f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.75907993e-01f, -2.04640970e-01f, -1.26507223e-01f, -6.42479733e-02f, -7.33793005e-02f, -6.58132061e-02f, -1.76245555e-01f, -1.43132165e-01f, -1.09980464e-01f, -1.27849504e-01f,
  -7.59044513e-02f, -2.14887649e-01f, -3.25425267e-02f, 1.50185689e-01f, 7.58421570e-02f, 4.52952594e-01f, 1.46353394e-01f, 2.47709617e-01f, 2.04102546e-02f, -2.53837287e-01f,
  1.36297509e-01f, 2.29742095e-01f, 1.94149718e-01f, 7.28671625e-02f, -6.52133971e-02f, 1.38194516e-01f, -2.12264672e-01f, -2.14559481e-01f, -1.91879421e-01f, -1.35808915e-01f,
  -5.68800978e-02f, -9.46598314e-03f, 2.07517162e-01f, 1.16680354e-01f, 2.70037323e-01f, -9.26746354e-02f, 6.46371767e-02f, 4.69357520e-02f, 9.89658460e-02f, -3.75877097e-02f,
  -1.60233416e-02f, 2.37745702e-01f, 1.15133084e-01f, 2.75004804e-01f, 6.58298433e-02f, -1.47144914e-01f, 1.19652778e-01f, -2.81411320e-01f, -2.46635973e-01f, 5.53414598e-02f,
  1.87104508e-01f, 2.77407706e-01f, -2.96183914e-01f, -7.22700506e-02f, -4.09515798e-02f, -1.24977015e-01f, -2.34905645e-01f, 8.49253014e-02f, 8.51214081e-02f, 1.82945579e-01f,
  2.88337886e-01f, 1.71829000e-01f, 1.60245866e-01f, 2.20320418e-01f, -7.04855332e-03f, 8.86665192e-03f, -1.07240833e-01f, -1.71648458e-01f, 1.62188351e-01f, -3.42873931e-02f,
  -2.68538147e-02f, -1.62269533e-01f, -3.42829555e-01f, 3.99201542e-01f, 2.57120300e-02f, 3.72727573e-01f, 2.44092584e-01f, -2.16076255e-01f, -2.81219959e-01f, -1.73743710e-01f,
  2.04317167e-01f, 2.21152872e-01f, 2.12097764e-01f, -7.64722452e-02f, 9.58074480e-02f, -2.59714544e-01f, 1.66062564e-01f, -1.94659941e-02f, 5.78129850e-03f, 8.61524884e-03f,
  -1.25276849e-01f, 7.58228227e-02f, 3.08398865e-02f, -2.07408309e-01f, 1.78899571e-01f, 2.30335936e-01f, 2.18263030e-01f, 1.91284060e-01f, -1.88199028e-01f, -4.02475446e-01f,
  1.42501608e-01f, 1.65749893e-01f, 2.60951161e-01f, 3.04464204e-03f, 5.17403567e-03f, -2.36980349e-01f, -1.87512591e-01f, 2.56022543e-01f, 3.31125021e-01f, 3.91508996e-01f,
  1.24044597e-01f, -3.70998353e-01f, 1.85712382e-01f, -1.99582919e-01f, 5.06128743e-02f, 1.30891681e-01f, -2.33041763e-01f, 7.18709379e-02f, -1.85661986e-01f, -1.80089459e-01f,
  9.32274982e-02f, -1.97340474e-01f, -1.15774840e-01f, 4.57421899e-01f, -9.10915360e-02f, 1.82486579e-01f, -2.17630312e-01f, -1.30329445e-01f, -1.08420528e-01f, 7.27774277e-02f,
  -1.25113621e-01f, 7.42241181e-03f, 1.08775146e-01f, 9.07545164e-02f, 3.77790742e-02f, 3.77821773e-02f, 4.26816851e-01f, -2.90371507e-01f, -9.45636854e-02f, 5.42981271e-03f,
  2.66123980e-01f, 3.65741730e-01f, 1.95255995e-01f, -2.86868691e-01f, -2.41033621e-02f, -2.40427911e-01f, 8.19035918e-02f, 3.24208707e-01f, 3.91338132e-02f, 1.41900435e-01f,
  -4.09812666e-02f, -2.10368797e-01f, 1.47190943e-01f, -1.73702389e-01f, -8.47656354e-02f, 2.47516870e-01f, -2.65989721e-01f, 2.94657439e-01f, -1.13403246e-01f, 8.31342340e-02f,
  -1.08490735e-01f, 5.17392866e-02f, -1.10730402e-01f, 3.59613508e-01f, 3.84259298e-02f, 8.31035450e-02f, 1.11302242e-01f, 6.92019425e-03f, 4.50549811e-01f, 5.05933724e-02f,
  7.18969340e-03f, -4.95946914e-01f, -4.91542250e-01f, -1.53096363e-01f, 2.20421314e-01f, -1.58539452e-02f, -1.56467304e-01f, -3.03805500e-01f, 3.10617741e-02f, -2.02799603e-01f,
  1.28405795e-01f, 6.84082434e-02f, -1.38274476e-01f, 2.68947721e-01f, -1.40573964e-01f, 4.13104355e-01f, 7.53478482e-02f, -4.82795760e-02f, -3.15224193e-02f, -1.58455983e-01f,
  -5.65764830e-02f, 1.16719142e-01f, -1.43684387e-01f, 4.81325872e-02f, 1.79015234e-01f, -3.50794435e-01f, 6.13453649e-02f, -1.95840746e-01f, 2.52632678e-01f, -2.56445974e-01f,
  -4.20229703e-01f, -3.31114568e-02f, -7.51834959e-02f, 4.33142453e-01f, 2.77763397e-01f, -1.26480624e-01f, -2.93660194e-01f, -1.17753178e-01f, 1.93754941e-01f, 4.10924464e-01f,
  -6.27721101e-02f, -1.51329907e-02f, 2.07278747e-02f, 7.16272593e-02f, -1.23754397e-01f, -1.92819506e-01f, -1.45893872e-01f, -3.50156873e-01f, -5.09534478e-02f, -4.77837361e-02f,
  -1.22758359e-01f, 1.41844571e-01f, -6.63606524e-02f, -6.89699873e-02f, 1.24585137e-01f, 7.67564178e-02f, 1.67412981e-01f, -4.50344354e-01f, -6.56775087e-02f, -1.28993848e-02f,
  2.31616676e-01f, 5.78769930e-02f, -1.19360864e-01f, -1.82709008e-01f, -3.35279793e-01f, 2.41310522e-01f, 3.02765459e-01f, 9.98987257e-03f, -2.86312640e-01f, -1.25343814e-01f,
  2.92815953e-01f, -1.32201716e-01f, -2.38743816e-02f, 2.57018447e-01f, -1.43245444e-01f, -4.83455472e-02f, 1.15195625e-01f, -5.80915026e-02f, 1.75381094e-01f, -2.45200142e-01f,
  2.63952054e-02f, 3.51256430e-01f, 7.66268792e-03f, 5.77889457e-02f, -2.22070456e-01f, 1.66121244e-01f, -1.14746191e-01f, -2.11958542e-01f, 9.04989690e-02f, -1.47487998e-01f,
  1.51618645e-01f, -1.88168749e-01f, -1.58841491e-01f, -2.57554084e-01f, -1.84267774e-01f, 6.48113480e-03f, -2.59205788e-01f, 7.70273730e-02f, 3.73749703e-01f, -3.82553637e-02f,
  -1.57025874e-01f, 9.24951658e-02f, 2.30099112e-01f, -1.67441875e-01f, -1.20897800e-01f, 5.51932976e-02f, -1.26175806e-01f, -9.47844684e-02f, -1.45147368e-01f, 2.06449740e-02f,
  -4.80059348e-02f, -1.18339963e-01f, -9.42382812e-02f, -1.03191808e-01f, -2.74187744e-01f, 1.90813970e-02f, -2.17688575e-01f, -1.66917667e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -7.18076974e-02f, 2.03976724e-02f, -3.16802859e-02f, 8.85740742e-02f, 1.76605508e-01f, -2.58965567e-02f, 1.56220019e-01f, -1.70951828e-01f, -2.01627493e-01f, -3.40951025e-03f,
  6.78676143e-02f, 1.05034210e-01f, -7.85478279e-02f, -5.19841164e-02f, -8.13519508e-02f, 7.73809012e-03f, -1.90613884e-02f, -1.69346303e-01f, 1.79651648e-01f, -1.60758808e-01f,
  -1.87564101e-02f, -8.87328908e-02f, 8.17575902e-02f, 1.58383593e-01f, -2.55417842e-02f, 7.64517486e-02f, 1.72930196e-01f, -9.80949923e-02f, -1.58158720e-01f, 1.49570569e-01f,
  -1.59765910e-02f, 2.05791164e-02f, 2.51321882e-01f, -1.65786147e-02f, 2.88146645e-01f, 1.26745887e-02f, 1.85225770e-01f, 1.16526932e-01f, 2.98268855e-01f, -1.79008003e-02f,
  -2.98589468e-01f, 1.37675077e-01f, 2.03880951e-01f, 6.28275573e-02f, 1.78284451e-01f, -8.47695172e-02f, -3.48103851e-01f, 1.43335342e-01f, 2.78908312e-01f, 2.50079602e-01f,
  4.47610989e-02f, -6.54038265e-02f, 5.64332027e-03f, 9.68149975e-02f, 1.70250833e-01f, -1.37800509e-02f, -4.33162563e-02f, -1.38826653e-01f, 1.64119676e-01f, 2.54974842e-01f,
  5.60476333e-02f, 6.58030286e-02f, -4.25494984e-02f, -2.23119091e-02f, 4.27185139e-03f, 1.56107947e-01f, -6.70455843e-02f, 1.57724440e-01f, -2.09343564e-02f, 1.15461938e-01f,
  8.63097385e-02f, -1.17041670e-01f, -2.23320909e-02f, -1.31223053e-01f, -3.65595706e-03f, 1.58136245e-02f, 1.48864582e-01f, 1.90189257e-01f, 6.42364994e-02f, 8.94728210e-03f,
  -1.59140676e-01f, -2.03377560e-01f, 9.04176161e-02f, -7.95101970e-02f, 1.48019537e-01f, -9.88113880e-02f, 8.70081037e-02f, 6.56196773e-02f, -1.35537004e-02f, -1.58578053e-01f,
  -9.97784883e-02f, 1.77362300e-02f, -1.29070148e-01f, 8.83385837e-02f, -4.90336344e-02f, -1.39400110e-01f, 4.94088948e-01f, 4.50557739e-01f, 4.16550815e-01f, 2.82123148e-01f,
  3.46792668e-01f, 4.28675294e-01f, 4.50086623e-01f, 3.82017463e-01f, 5.54049671e-01f, -1.93588302e-01f, -1.78979516e-01f, 2.65085604e-02f, 1.15554832e-01f, -1.49097212e-03f,
  2.84847379e-01f, -4.23343092e-01f, -1.25731871e-01f, -8.77980515e-02f, 2.76426703e-01f, 3.04776222e-01f, -1.18554130e-01f, 6.46489337e-02f, -1.31115451e-01f, 1.57617152e-01f,
  6.85336590e-02f, -3.37176137e-02f, 1.04568399e-01f, 5.12463331e-01f, 3.37247737e-02f, 1.17033094e-01f, -1.30650595e-01f, -6.77566044e-03f, 1.95869535e-01f, -2.91661751e-02f,
  -5.25686853e-02f, 3.86277474e-02f, -7.36495182e-02f, -7.77816400e-02f, 1.19724043e-01f, -1.13380544e-01f, 4.60817628e-02f, 1.81017458e-01f, 2.42395476e-01f, 1.18099421e-01f,
  -2.16607556e-01f, -6.27534539e-02f, 8.06244612e-02f, -9.21432301e-02f, -9.00160372e-02f, 1.13139346e-01f, 4.65673208e-02f, -1.44989058e-01f, 9.54613388e-02f, -6.34309947e-02f,
  -1.59454420e-01f, -6.42082021e-02f, -1.80985406e-01f, 1.54178366e-01f, 1.19461127e-01f, -1.13420539e-01f, 1.78274751e-01f, 1.22948058e-01f, -8.88821185e-02f, 1.54795557e-01f,
  1.00125268e-01f, 1.96477175e-01f, 1.61637187e-01f, 1.70836583e-01f, -5.05748205e-02f, 1.97832793e-01f, 1.69959441e-01f, 3.07105016e-03f, 4.01533842e-01f, -4.43592668e-01f,
  1.56966403e-01f, -5.84860861e-01f, -2.97039986e-01f, 4.83251721e-01f, 4.42802131e-01f, 1.83970645e-01f, -3.59716564e-01f, -2.64783919e-01f, -2.16032460e-01f, -6.13461323e-02f,
  2.36793131e-01f, 4.69705075e-01f, -1.84591934e-01f, -2.12763622e-01f, -3.67013440e-02f, 2.26293765e-02f, 1.07815757e-01f, 1.16076171e-01f, -2.72144377e-01f, 1.77509218e-01f,
  -1.18942454e-01f, -1.18272863e-01f, -1.36605591e-01f, -1.15286544e-01f, -3.59033607e-02f, -1.26478942e-02f, 7.33643696e-02f, 9.13508162e-02f, -1.56430796e-01f, 5.17715514e-02f,
  2.01535478e-01f, 3.59057561e-02f, -1.18263207e-01f, -1.63409814e-01f, -2.54724056e-01f, 2.45149627e-01f, 2.23022074e-01f, 2.74568558e-01f, -1.04849041e-02f, -1.06348135e-01f,
  -1.39889613e-01f, 6.11393154e-02f, 8.30213875e-02f, 1.93026409e-01f, 1.23550352e-02f, 7.80891106e-02f, 2.15782344e-01f, 2.83066690e-01f, 8.64149854e-02f, 1.48372352e-01f,
  1.68036681e-03f, -1.45581231e-01f, -1.09963305e-01f, -1.36942714e-01f, -1.01481147e-01f, 2.36790236e-02f, 2.26851702e-01f, 9.89540592e-02f, -7.65681118e-02f, 8.51225108e-03f,
  -6.31799400e-02f, 1.53313115e-01f, 2.18411073e-01f, -7.70626813e-02f, -1.18206263e-01f, 8.27190131e-02f, 2.64882017e-02f, -1.53807430e-02f, 8.36726800e-02f, 2.94312015e-02f,
  1.16418466e-01f, -2.94403099e-02f, 9.77979600e-02f, -2.33157706e-02f, -1.85130939e-01f, -2.26062424e-02f, -1.66325182e-01f, -6.42191246e-02f, 1.31928965e-01f, 2.53432244e-03f,
  -1.40267864e-01f, 2.21207917e-01f, 5.04063740e-02f, -1.09262452e-01f, 1.55414358e-01f, -7.54256845e-02f, 6.83305785e-02f, 3.42754535e-02f, 6.82977736e-02f, 5.30880429e-02f,
  -9.36132520e-02f, -1.77449137e-01f, 1.40069216e-01f, -4.23677601e-02f, -2.06535175e-01f, 7.58957192e-02f, 5.28901862e-03f, 1.70690775e-01f, 1.43621325e-01f, -1.80804059e-01f,
  -1.18224196e-01f, 1.23018801e-01f, -3.09448019e-02f, -4.64838520e-02f, -6.35377318e-02f, -1.50936574e-01f, 1.37647629e-01f, 7.53446668e-02f, 9.34638679e-02f, -6.85353503e-02f,
  -1.48506388e-01f, -1.46526232e-01f, -1.64139509e-01f, 1.42994285e-01f, -4.78823520e-02f, -3.66569124e-02f, -7.17632920e-02f, -8.68754387e-02f, 1.68109722e-02f, -8.49905908e-02f,
  -1.03028156e-01f, -5.04000187e-02f, -5.02425134e-02f, -9.21175256e-02f, 5.52995056e-02f, -1.29656732e-01f, 4.70103212e-02f, 1.38897290e-02f, 1.15619630e-01f, -1.54611334e-01f,
  -6.23468347e-02f, 3.70172709e-02f, 1.55016273e-01f, 2.56969154e-01f, 1.28441811e-01f, 9.38392058e-02f, -1.42242074e-01f, -4.89698797e-02f, -5.12687117e-02f, 5.73801361e-02f,
  -5.69930002e-02f, -1.03345029e-01f, 1.80210263e-01f, 6.44508749e-02f, 7.41774887e-02f, -6.18081763e-02f, 1.42900556e-01f, -7.84153864e-02f, 1.70489937e-01f, 1.08007438e-01f,
  -9.35971662e-02f, -1.35650292e-01f, 7.61030018e-02f, 8.31718817e-02f, -8.30191225e-02f, -3.68734896e-02f, 1.30360574e-01f, -9.99005437e-02f, -9.62154046e-02f, 8.08554590e-02f,
  1.14270836e-01f, 1.94250330e-01f, -1.07450940e-01f, 6.09942414e-02f, -8.06230530e-02f, -1.62814572e-01f, 6.51131794e-02f, -1.22588232e-01f, 1.98574051e-01f, 1.53739244e-01f,
  -3.10643464e-02f, -8.85454938e-03f, -1.64242566e-01f, -1.10280015e-01f, 6.12695441e-02f, 2.09722623e-01f, 6.52599521e-03f, -1.23449294e-02f, 8.00145324e-03f, -9.10436958e-02f,
  1.55595541e-01f, -1.02887608e-01f, -4.03173715e-02f, 1.52841002e-01f, 8.19575638e-02f, 1.86215088e-01f, 2.38067523e-01f, -2.61212979e-02f, 8.08638185e-02f, 2.26146951e-01f,
  8.15812871e-02f, 9.37675387e-02f, 2.74706632e-01f, 1.91563308e-01f, -2.92247951e-01f, -3.16095918e-01f, 1.12515211e-01f, -1.75976045e-02f, -1.78968161e-01f, 1.00159064e-01f,
  -2.05043980e-04f, -2.78981104e-02f, 1.58223063e-01f, -2.31881231e-01f, 1.84445918e-01f, 2.01299980e-01f, 2.98552884e-04f, 2.74510503e-01f, 1.51137173e-01f, -9.28446352e-02f,
  1.50251940e-01f, 7.55974874e-02f, -3.54935043e-02f, -8.19862708e-02f, 7.55926222e-02f, 2.60168403e-01f, 1.48721993e-01f, 1.28715768e-01f, -5.41729480e-03f, -4.39042076e-02f,
  4.22970764e-02f, 1.61690161e-01f, -1.31587446e-01f, 7.44225234e-02f, 5.35974838e-03f, 2.66666859e-01f, -8.74147862e-02f, -2.35296860e-01f, 8.83855522e-02f, -2.25942358e-02f,
  3.49968262e-02f, 6.79700747e-02f, -7.78385103e-02f, 4.43781838e-02f, -1.85645577e-02f, -2.20477074e-01f, -3.50424112e-03f, 1.94809422e-01f, 2.39554923e-02f, 2.80605387e-02f,
  -1.51661351e-01f, -7.18549341e-02f, 1.58098921e-01f, -3.35008763e-02f, -3.47606950e-02f, -6.43521920e-02f, 1.87618554e-01f, -4.17177938e-02f, 8.15283209e-02f, 1.53621957e-01f,
  1.93480209e-01f, 2.58673877e-02f, 4.29592542e-02f, -9.18990225e-02f, -6.03695512e-02f, 3.49753022e-01f, 1.54116154e-01f, -3.23409230e-01f, -1.72129080e-01f, -5.39963730e-02f,
  -6.36001974e-02f, 3.82640630e-01f, 1.75888613e-02f, 4.04488295e-02f, 1.31985381e-01f, 6.08962309e-03f, 3.05002898e-01f, -1.69363350e-01f, 1.64517667e-02f, 9.00741220e-02f,
  -1.33735150e-01f, 4.29716676e-01f, 1.97647866e-02f, -2.33398005e-01f, 4.13870960e-02f, -1.82613403e-01f, 2.30456665e-01f, -1.49249926e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.04820043e-01f, 3.80567536e-02f, 8.22220966e-02f, 1.95126787e-01f, -9.59689245e-02f, 3.23675573e-01f, -3.50332148e-02f, -5.46013415e-02f, 7.16452152e-02f, 2.74608955e-02f,
  -7.03604892e-02f, 1.71555713e-01f, 2.47564629e-01f, -3.26908231e-02f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  2.18956568e-03f, -7.24876300e-02f, 1.13656104e-01f, 2.52819538e-01f, 1.76866785e-01f, -7.30700865e-02f, 4.36650738e-02f, 7.43038654e-02f, -1.50104001e-01f, -1.99687392e-01f,
  2.31198639e-01f, 1.21848665e-01f, -2.62695104e-01f, -6.11311555e-01f, 9.25315246e-02f, 7.50587210e-02f, -3.35431039e-01f, -1.88030109e-01f, 1.32786497e-01f, 1.77478616e-03f,
  -1.14089787e-01f, -2.44308054e-01f, 2.08389953e-01f, -2.23586634e-01f, -1.43542916e-01f, -2.30834186e-01f, 9.54167545e-02f, -1.12320326e-01f, -2.96517126e-02f, 2.49800250e-01f,
  1.85387939e-01f, 1.72240004e-01f, -1.16835319e-01f, -1.44368425e-01f, 2.47225165e-01f, -1.11786656e-01f, 7.12000951e-02f, 7.42703080e-02f, 2.83638120e-01f, -1.98261738e-01f,
  2.84043849e-01f, -3.91894847e-01f, 1.85766742e-01f, 4.31519181e-01f, 4.86283123e-01f, 1.39893800e-01f, -3.65116239e-01f, 3.67111295e-01f, 4.71430868e-01f, 4.68967035e-02f,
  1.13290161e-01f, 4.25946601e-02f, 3.48427854e-02f, 2.76860982e-01f, -1.48396552e-01f, -2.95851499e-01f, -9.86949801e-02f, -6.45750165e-02f, 2.63800528e-02f, -1.62965864e-01f,
  -9.62241832e-03f, -8.34368691e-02f, -9.00792331e-02f, -2.62301862e-01f, -2.80266434e-01f, -5.05901799e-02f, -7.64685199e-02f, 2.06511393e-01f, -1.75997660e-01f, 1.99336261e-01f,
  2.74192065e-01f, 2.68871874e-01f, -1.39833108e-01f, -1.22961484e-01f, 2.36037657e-01f, -2.67414957e-01f, 4.53129292e-01f, 5.72892010e-01f, 1.73264325e-01f, -3.46541196e-01f,
  1.07804306e-01f, -9.17483419e-02f, 3.04212365e-02f, -9.22977999e-02f, 6.63753748e-02f, 2.77836412e-01f, -1.32252380e-01f, 2.00349987e-01f, -6.59836503e-03f, 1.53152153e-01f,
  -9.07467753e-02f, 9.06626210e-02f, -1.17123149e-01f, -7.84137547e-02f, 8.84310380e-02f, -2.33601466e-01f, -1.92361489e-01f, -1.86267234e-02f, 2.59551965e-03f, -1.52282670e-01f,
  -1.97726294e-01f, 9.01247561e-03f, 5.08896649e-01f, 2.32838169e-01f, -5.86826354e-02f, -1.72488898e-01f, 3.16772878e-01f, 1.59774106e-02f, 3.68252844e-01f, 3.71254653e-01f,
  -1.29572809e-01f, 2.40137875e-01f, 3.06280792e-01f, -1.20075211e-01f, -1.43194079e-01f, 1.74651951e-01f, 1.03928506e-01f, 1.92573130e-01f, -1.34826690e-01f, -2.34823599e-01f,
  -2.74126440e-01f, -3.23444009e-02f, -4.02325690e-02f, -1.50406078e-01f, 9.65944007e-02f, -9.87732932e-02f, 1.80191010e-01f, -3.23505729e-01f, -1.50222316e-01f, -1.08039759e-01f,
  1.59209609e-01f, -3.29947740e-01f, -2.74260819e-01f, -7.77023844e-03f, -6.78441152e-02f, -5.86859845e-02f, 1.24338828e-01f, -3.23914200e-01f, 2.23101541e-01f, -2.91977525e-01f,
  3.07506770e-01f, 5.46437144e-01f, -1.30578682e-01f, -3.86452675e-03f, 2.53669739e-01f, -9.54047665e-02f, 8.48761275e-02f, -8.74922518e-03f, 2.04124972e-01f, 4.54533070e-01f,
  3.80699150e-02f, -8.05545971e-02f, 9.04243737e-02f, -9.11669284e-02f, -1.82867765e-01f, -1.43434659e-01f, 9.41922367e-02f, -2.74029374e-01f, -1.91717520e-01f, -6.09400496e-02f,
  2.95003027e-01f, 2.34352157e-01f, -3.43245894e-01f, 2.55808234e-01f, 5.01124784e-02f, 2.24069636e-02f, -2.16945261e-01f, 5.48718758e-02f, -1.68627664e-01f, 1.63204655e-01f,
  -3.90565723e-01f, -3.49621356e-01f, -1.58979550e-01f, -8.91590714e-02f, 2.21268713e-01f, -5.17777056e-02f, -3.87158126e-01f, -1.26747876e-01f, -1.53408600e-02f, -3.85335535e-02f,
  -3.66291329e-02f, -1.97404563e-01f, 8.74727666e-02f, 4.09726709e-01f, 1.03682190e-01f, -1.69282854e-02f, -1.49954662e-01f, 1.18114263e-01f, -2.19398424e-01f, -1.31132901e-01f,
  -1.88443407e-01f, 8.70522261e-02f, 1.46282420e-01f, 1.28959730e-01f, -2.87092239e-01f, 3.22365671e-01f, -1.60850957e-02f, 2.29815766e-02f, -1.25370875e-01f, 1.51627243e-01f,
  -9.69341770e-02f, 1.24893449e-02f, -2.97323108e-01f, -4.85945523e-01f, -1.18945371e-02f, 4.43231076e-01f, 3.43812585e-01f, -3.24059933e-01f, 4.72205393e-02f, -2.11758837e-01f,
  -1.69362947e-01f, -2.05226690e-01f, 7.47136623e-02f, 1.92249224e-01f, -1.74914449e-01f, 3.72578204e-01f, 2.51741201e-01f, 6.24897592e-02f, -3.15120704e-02f, 6.68485016e-02f,
  -1.45334736e-01f, -2.51095861e-01f, -1.36506975e-01f, -2.32024148e-01f, -2.20530927e-01f, -2.47616842e-01f, 1.66103080e-01f, -2.08327502e-01f, -2.42461756e-01f, -2.32741952e-01f,
  4.45474032e-03f, -3.75088781e-01f, -9.35101584e-02f, -1.07583016e-01f, 1.18738741e-01f, -5.83914593e-02f, 2.51821727e-01f, 8.82416964e-02f, 4.78664003e-02f, 9.38628837e-02f,
  9.08146426e-02f, -1.22316569e-01f, -1.29589915e-01f, -1.77563995e-01f, -9.81837884e-02f, 1.41776949e-01f, 3.52767445e-02f, -9.74240229e-02f, 1.48367420e-01f, 5.54945953e-02f,
  -1.59522578e-01f, -1.23138808e-01f, 8.68039355e-02f, 2.71297172e-02f, 1.64030436e-02f, -1.51707709e-01f, 2.17094496e-01f, 1.38876647e-01f, -3.62409234e-01f, -1.71652779e-01f,
  3.24780680e-02f, -4.17867362e-01f, -5.62713206e-01f, -1.63342804e-01f, -1.70119569e-01f, 1.41614750e-01f, -9.18754786e-02f, -2.10546494e-01f, -1.92338124e-01f, -1.59581780e-01f,
  3.58654439e-01f, 6.08027279e-02f, -3.34061384e-01f, 1.06019333e-01f, 6.05359301e-03f, -1.60437122e-01f, 1.51632763e-02f, -3.04301262e-01f, -1.14430144e-01f, 1.58165395e-01f,
  2.33460769e-01f, -4.55842949e-02f, -2.18192060e-02f, 2.47014351e-02f, -1.30527154e-01f, 1.30360544e-01f, -4.92318794e-02f, 2.10509732e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.53015897e-01f, 2.48203706e-02f, -4.17804681e-02f, -7.18481094e-02f, -4.75891866e-02f, 5.69261098e-03f, -3.85673232e-02f, 1.73690077e-02f, -1.12664424e-01f, -2.35408798e-01f,
  2.41185188e-01f, -7.88674206e-02f, 2.10849382e-02f, 9.69046280e-02f, 2.65558034e-01f, -1.57035306e-01f, -2.39197791e-01f, -1.55836597e-01f, -1.02866076e-01f, 6.43767649e-03f,
  -6.94658160e-02f, -3.58290784e-02f, 1.35062598e-02f, 1.33851081e-01f, -1.68242320e-01f, 4.62598614e-02f, 3.62338386e-02f, -1.57063622e-02f, -1.50648519e-01f, 2.04391722e-02f,
  1.96712986e-01f, 1.12277843e-01f, -2.61731684e-01f, -9.43061262e-02f, 6.93805888e-02f, 2.19620973e-01f, 1.40021428e-01f, 1.13944165e-01f, -7.23802224e-02f, 3.51422191e-01f,
  -1.34754777e-01f, -2.80243933e-01f, 6.22808896e-02f, -1.00503102e-01f, 3.50428224e-01f, 2.19747841e-01f, 2.26547733e-01f, -2.70224303e-01f, -2.16236226e-02f, -2.61800945e-01f,
  1.24136955e-01f, 1.24389537e-01f, -5.47294840e-02f, 4.07451510e-01f, -9.75076556e-02f, 3.22131217e-01f, -1.77019715e-01f, 1.53965920e-01f, 8.45382363e-03f, -1.77694678e-01f,
  -1.86648294e-01f, -1.31563842e-01f, -1.73537433e-01f, -1.66717604e-01f, 2.73579568e-01f, 2.74590433e-01f, 1.68450296e-01f, -3.21353167e-01f, -1.04377426e-01f, -4.08777781e-03f,
  2.65917063e-01f, -2.60043383e-01f, 3.65833908e-01f, -2.82678813e-01f, 2.32013121e-01f, 3.55134666e-01f, 1.65270805e-01f, 4.73250486e-02f, -4.46296126e-01f, 4.10507381e-01f,
  2.33961716e-01f, 2.16895118e-02f, 4.41504307e-02f, 3.36400628e-01f, 1.82258282e-02f, 2.62326002e-01f, -1.27574414e-01f, -1.30440220e-01f, -4.90115881e-02f, -2.40233950e-02f,
  -6.47332519e-02f, -1.96739137e-01f, -1.68559194e-01f, -2.54274309e-01f, 1.48314953e-01f, 9.36229676e-02f, -1.29756659e-01f, -1.03298537e-01f, -3.16846743e-02f, -9.54924449e-02f,
  2.56340235e-01f, 5.13136499e-02f, 2.77297080e-01f, 3.34778894e-03f, -3.77011187e-02f, -1.19463846e-01f, 9.29056555e-02f, 7.85581917e-02f, 2.79898822e-01f, 1.17842719e-01f,
  7.95560237e-03f, 1.74291059e-01f, 8.27595368e-02f, -1.33932769e-01f, -2.30993032e-02f, 2.65724570e-01f, -1.54881150e-01f, 3.51104081e-01f, -2.00736791e-01f, -1.49084926e-01f,
  -6.21792376e-02f, 7.77033344e-02f, 5.28753810e-02f, -8.32603276e-02f, 1.59059286e-01f, -1.79308698e-01f, -1.50672376e-01f, -8.18740204e-02f, -1.39937118e-01f, -1.66380972e-01f,
  7.91491717e-02f, 4.01624292e-01f, 1.90277427e-01f, 1.23279877e-01f, 2.87621051e-01f, 4.48508620e-01f, -3.09714838e-03f, -4.76823628e-01f, 3.70926142e-01f, -3.41153532e-01f,
  -3.97131331e-02f, 2.74186969e-01f, 4.81517732e-01f, -6.25402093e-01f, 2.40307152e-02f, -4.42528039e-01f, -1.35501564e-01f, -2.46333286e-01f, -8.79971087e-02f, 9.10798907e-01f,
  6.78114519e-02f, 4.16183144e-01f, 7.49459490e-02f, 8.98917466e-02f, -1.87466353e-01f, -1.57757476e-01f, -1.75684914e-01f, 2.17305765e-01f, 1.40950948e-01f, -1.44797862e-01f,
  2.92161703e-01f, 2.84842938e-01f, -7.82141928e-03f, -1.58631355e-01f, -1.60941899e-01f, 1.57739390e-02f, 2.23528177e-01f, -4.33695838e-02f, 1.67659298e-01f, -2.60896593e-01f,
  -1.06885791e-01f, -3.12930256e-01f, 2.30966404e-01f, 3.06249529e-01f, 1.75160468e-01f, -1.71009034e-01f, 1.52106434e-01f, 5.87358922e-02f, -9.47754160e-02f, -6.76529482e-02f,
  7.64642432e-02f, 3.79115582e-01f, -4.42742445e-02f, 5.44600561e-02f, -9.16360132e-03f, 9.39771459e-02f, 1.97007023e-02f, -1.61264107e-01f, -5.87772503e-02f, -2.39865288e-01f,
  -9.91887897e-02f, -1.39127495e-02f, 2.11659875e-02f, -1.19099021e-01f, -4.99309003e-02f, -6.51897267e-02f, -6.28451407e-02f, 1.00491181e-01f, -8.47312883e-02f, 8.79926905e-02f,
  1.89362057e-02f, 2.32586619e-02f, 8.45113769e-02f, -6.83654994e-02f, -2.87065972e-02f, -1.70871124e-01f, -1.44968823e-01f, 1.74887493e-01f, -2.45449059e-02f, -6.57103434e-02f,
  -1.72495976e-01f, -1.22270942e-01f, 6.81905523e-02f, -7.60970861e-02f, 4.78097126e-02f, -1.47967383e-01f, -7.50836581e-02f, 1.44246146e-01f, 1.33627594e-01f, -5.09335287e-02f,
  1.22535028e-01f, 1.31763816e-01f, -1.72503546e-01f, -1.36544988e-01f, -8.77936929e-02f, -6.89092129e-02f, -6.88572526e-02f, -1.59158245e-01f, 3.43551822e-02f, -1.28707550e-02f,
  -1.31285027e-01f, -7.81708304e-03f, -2.10029557e-02f, 3.15556340e-02f, 1.64758712e-01f, 1.02486856e-01f, -9.63454172e-02f, 6.62216991e-02f, 2.24759746e-02f, -1.64977536e-01f,
  -7.61159509e-02f, -8.44368935e-02f, -1.64639995e-01f, 1.30016103e-01f, -1.59384608e-01f, 1.48651496e-01f, -5.22469506e-02f, -1.10581871e-02f, -1.52371839e-01f, 8.97007659e-02f,
  1.13262057e-01f, 1.22727320e-01f, -1.41314283e-01f, -1.83075815e-02f, 1.50897011e-01f, 1.55283719e-01f, -1.68621361e-01f, -1.79522112e-01f, 4.61515114e-02f, -6.10229671e-02f,
  1.19940683e-01f, 2.53152281e-01f, 1.54314056e-01f, 7.75814727e-02f, 2.76153743e-01f, -2.61989295e-01f, 2.84833938e-01f, 1.02099450e-02f, 5.32157481e-01f, 2.86849707e-01f,
  -2.90850729e-01f, 4.02766764e-02f, 2.75996953e-01f, -2.15829492e-01f, 4.10402678e-02f, -4.96397093e-02f, 1.25943169e-01f, 4.10718471e-01f, -1.89513475e-01f, -9.90092196e-03f,
  -1.67469129e-01f, 1.02981485e-01f, 1.10513344e-01f, -4.37415130e-02f, -5.65162674e-02f, 6.25946596e-02f, -2.12413054e-02f, -8.79867151e-02f, 2.45720103e-01f, 2.88769305e-01f,
  3.87280107e-01f, 4.14781868e-01f, 5.21770239e-01f, 5.41871369e-01f, 7.38325417e-01f, 3.36455584e-01f, 3.75927210e-01f, -4.37141418e-01f, 3.50223839e-01f, 7.13687420e-01f,
  1.90187603e-01f, -4.27147657e-01f, -4.50970739e-01f, 5.69437444e-01f, 3.23066115e-01f, -2.56197810e-01f, -6.20670691e-02f, 4.95638669e-01f, -6.34648800e-02f, 1.94962975e-02f,
  7.38477558e-02f, -4.78940904e-01f, -1.92831725e-01f, 9.02575329e-02f, 1.60341948e-01f, 1.02079310e-01f, -8.57199728e-02f, 6.03123829e-02f, 1.20791242e-01f, -9.62163806e-02f,
  3.15168425e-02f, 1.24073945e-01f, 1.30335435e-01f, -1.42608449e-01f, -3.59207727e-02f, -2.57199276e-02f, -6.65559694e-02f, 4.72205095e-02f, 1.11572824e-01f, 2.47492101e-02f,
  9.78470817e-02f, -1.06989533e-01f, 6.00741804e-03f, -8.18159804e-02f, -1.52886555e-01f, -9.83106252e-03f, 4.04277928e-02f, -7.94508085e-02f, 9.12541077e-02f, -7.58831054e-02f,
  6.54943511e-02f, -9.25526172e-02f, 7.31884092e-02f, 5.46880299e-03f, -1.32831559e-01f, 1.54170737e-01f, -4.07132879e-02f, 2.44286098e-03f, -9.82115269e-02f, 1.57519132e-01f,
  -6.37270361e-02f, 9.02271792e-02f, 1.85013264e-01f, 3.44728917e-01f, -3.47670406e-01f, 2.21056208e-01f, -5.87535761e-02f, -5.69408163e-02f, -1.44627811e-02f, 2.43092254e-01f,
  5.32658510e-02f, -1.88957393e-01f, -6.34161234e-02f, -3.09533864e-01f, 3.50219101e-01f, 4.15517002e-01f, 2.05734551e-01f, -1.80424035e-01f, -1.96448743e-01f, -8.00372213e-02f,
  -1.44399181e-01f, 2.64912769e-02f, 2.11278319e-01f, 1.64881587e-01f, -5.36482669e-02f, 8.04693878e-01f, 2.01333627e-01f, -9.31621715e-02f, -1.87596038e-01f, -8.52465909e-03f,
  3.18898633e-02f, -2.82860816e-01f, -7.30993822e-02f, -2.24582478e-01f, 2.10148111e-01f, -1.22841513e-02f, 3.57637197e-01f, 2.48423308e-01f, 1.13061424e-02f, -3.80193107e-02f,
  1.60661638e-01f, 5.25622845e-01f, -1.59871444e-01f, -3.29916686e-01f, 4.39645946e-01f, 5.83139993e-02f, -2.30979040e-01f, -5.75176418e-01f, 4.95648026e-01f, -4.39894050e-01f,
  -3.67364496e-01f, -2.55193204e-01f, 9.38497558e-02f, 1.32267207e-01f, -1.12453019e-02f, 3.47566217e-01f, 2.12081999e-01f, -3.59046519e-01f, -2.25363120e-01f, 5.70910983e-02f,
  -1.70539066e-01f, -1.15936413e-01f, 1.30158231e-01f, 3.51441592e-01f, 2.76461750e-01f, 1.61826879e-01f, 1.62739307e-01f, 1.04817137e-01f, 7.97268748e-03f, -2.65404999e-01f,
  2.38468930e-01f, -2.34002143e-01f, -3.20979089e-01f, -1.92837834e-01f, 1.04606159e-01f, 1.97716296e-01f, -2.45002255e-01f, 7.77474865e-02f, -9.67723206e-02f, -3.11962157e-01f,
  5.09615615e-02f, 1.08688176e-01f, 8.24741051e-02f, -2.58872807e-01f, 1.42900357e-02f, -2.72459295e-02f, 1.20462313e-01f, 8.51089973e-03f, -1.22465380e-01f, 3.33073325e-02f,
  2.90338904e-01f, -8.96511227e-02f, -5.96186072e-02f, -4.34033014e-02f, 1.35440886e-01f, 1.17687717e-01f, 7.53280595e-02f, 4.40544605e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.24835014e-01f, 1.58678293e-02f, 3.74136269e-01f, 2.32723922e-01f, 2.72487283e-01f, -6.96944967e-02f, 4.29291017e-02f, 3.83587107e-02f, 2.48769000e-01f, 2.19757780e-01f,
  -5.25198467e-02f, 1.58993900e-01f, 2.77360976e-01f, 2.70815790e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -5.51732481e-01f, 6.50566876e-01f, -4.75274205e-01f, 3.67713153e-01f, -4.66443509e-01f, 5.11987567e-01f, -4.90447491e-01f, 1.22549199e-02f, 1.60674334e-01f, -2.97189176e-01f,
  5.96433133e-02f, -6.17906488e-02f, 4.22808260e-01f, 1.38683319e-01f, 3.55482459e-01f, -3.02343011e-01f, -2.52364855e-02f, -4.11594093e-01f, 9.68876779e-02f, 2.33206004e-01f,
  4.56501544e-02f, 7.54117519e-02f, 2.09011450e-01f, 6.05247438e-01f, -1.27085105e-01f, -1.02341495e-01f, 1.46073580e-01f, -4.08590823e-01f, -3.55368480e-02f, 5.53037643e-01f,
  -2.40998149e-01f, -2.05685705e-01f, 3.36289257e-01f, -4.60093170e-01f, 7.75152683e-01f, -6.72454178e-01f, 3.51209134e-01f, -5.63901842e-01f, -4.73097265e-01f, -1.91562474e-02f,
  4.53195311e-02f, 1.91269666e-01f, -3.89764994e-01f, -3.30657899e-01f, -3.59804749e-01f, -2.76265591e-01f, 5.06629348e-01f, 7.62585044e-01f, -2.33429730e-01f, 2.95944601e-01f,
  1.18584409e-01f, -1.73505008e-01f, -2.50643343e-01f, -2.85985649e-01f, 4.60882664e-01f, 4.06196304e-02f, -1.04592793e-01f, -4.14136536e-02f, -3.42244536e-01f, -3.52197200e-01f,
  1.00920439e-01f, 2.03159571e-01f, 8.10988620e-02f, 2.39255175e-01f, -2.13678122e-01f, -1.04062192e-01f, 4.11527753e-01f, 5.51602021e-02f, 1.57025218e-01f, 4.00646180e-01f,
  2.17711553e-01f, 1.46619707e-01f, 5.35831749e-01f, 6.07705772e-01f, -4.50333089e-01f, -6.71249926e-01f, -7.60101855e-01f, -1.98653027e-01f, 1.52214810e-01f, -2.92369992e-01f,
  2.32980289e-02f, 4.61916596e-01f, 2.89572865e-01f, -4.29295450e-01f, -3.33640836e-02f, -2.24533707e-01f, -2.97021698e-02f, -5.22742188e-03f, -2.47772541e-02f, 1.85397074e-01f,
  -3.53354603e-01f, -2.80148357e-01f, -7.35403076e-02f, -4.27722543e-01f, 9.23932850e-01f, -2.65792217e-02f, 1.85879230e-01f, -5.85191488e-01f, 4.18960184e-01f, 5.90286404e-02f,
  -6.86773434e-02f, -3.37339789e-01f, 2.19587386e-02f, 1.74928874e-01f, 3.10683027e-02f, -1.71572447e-01f, 1.47444174e-01f, -2.01822281e-01f, 5.27071297e-01f, 4.15424228e-01f,
  -4.79417473e-01f, -4.01726156e-01f, 1.81812108e-01f, -4.36050326e-01f, -4.86731417e-02f, -3.91849607e-01f, 7.16416836e-01f, 3.07133615e-01f, -9.14134502e-01f, 2.59840060e-02f,
  3.52387428e-02f, 1.28202692e-01f, 2.94034868e-01f, 5.92847943e-01f, -1.16856717e-01f, -2.59398073e-01f, -4.57468927e-01f, 2.65958309e-01f, -4.35696363e-01f, -3.10005903e-01f,
  -2.75931358e-01f, -3.45211416e-01f, -5.91987550e-01f, -2.08479926e-01f, 3.70174587e-01f, -8.51365104e-02f, -3.79172027e-01f, -4.70886946e-01f, 3.36804420e-01f, 3.64796370e-01f,
  3.98376614e-01f, -9.26743373e-02f, -1.98110402e-01f, 1.54620782e-01f, 4.17440414e-01f, 1.10381439e-01f, -1.12104630e-02f, -1.41849309e-01f, 5.30549288e-01f, 2.92316765e-01f,
  2.25908041e-01f, 2.36084178e-01f, -4.49197441e-02f, 1.28017962e-01f, 4.09310132e-01f, 2.28447989e-01f, 3.31361406e-02f, 5.51325381e-02f, -4.63368207e-01f, -7.75103830e-03f,
  5.93202114e-01f, 3.51479828e-01f, -1.51681483e-01f, 3.84572715e-01f, 3.22355367e-02f, 3.58210504e-01f, -4.78940278e-01f, -3.00178770e-02f, 6.20464265e-01f, -1.74333807e-02f,
  -7.75133431e-01f, 3.68463635e-01f, -2.33090073e-01f, 5.03282845e-01f, 5.58672905e-01f, 4.06786025e-01f, 1.57360896e-01f, -8.23091269e-02f, 1.85912088e-01f, 3.40382904e-01f,
  -3.48766863e-01f, -6.57966584e-02f, 5.04006565e-01f, 7.30155185e-02f, 1.45813927e-01f, 1.85360298e-01f, -7.34561980e-02f, -6.09082639e-01f, -9.05675143e-02f, 2.36581475e-01f,
  2.62161195e-01f, -1.30856767e-01f, 9.64960828e-02f, 8.24585378e-01f, 1.42892480e-01f, 5.67722261e-01f, 1.62089437e-01f, 1.77386358e-01f, 4.42450494e-01f, 5.86774871e-02f,
  1.93856314e-01f, 1.25522539e-01f, 1.06258743e-01f, 4.93341237e-01f, 1.22830197e-02f, -2.05615219e-02f, -3.24634284e-01f, 1.91381395e-01f, 1.57061890e-02f, -5.18421173e-01f,
  1.47181734e-01f, -6.07057959e-02f, -3.59738261e-01f, 9.72487256e-02f, 4.93886143e-01f, -2.23413005e-01f, -1.05455920e-01f, 1.33588150e-01f, -1.97065547e-01f, 4.87426445e-02f,
  -3.60965841e-02f, -3.69902849e-01f, 5.98807573e-01f, -1.32118344e-01f, -2.09411740e-01f, -2.75287241e-01f, -4.11856771e-01f, -1.56588197e-01f, 2.92255998e-01f, -3.04650992e-01f,
  -1.52809739e-01f, -2.13323846e-01f, 1.00583687e-01f, -4.49711859e-01f, -1.81314811e-01f, 5.37081778e-01f, -4.06555831e-01f, 8.85294378e-02f, 1.71153218e-01f, -5.50399125e-01f,
  1.12442054e-01f, 3.25253934e-01f, 4.66918312e-02f, 1.31769702e-01f, -2.56993532e-01f, -2.43465394e-01f, 2.50844449e-01f, 4.30944450e-02f, -6.46592900e-02f, -4.45024744e-02f,
  -2.17009470e-01f, -4.02453870e-01f, -5.85834272e-02f, 8.47457886e-01f, -5.74841917e-01f, -1.82898462e-01f, 1.37684658e-01f, -4.77142125e-01f, -5.10927856e-01f, -6.16423130e-01f,
  2.69725204e-01f, 8.65092687e-03f, 3.27398658e-01f, 2.93271840e-01f, -3.04863721e-01f, 3.76832634e-01f, -5.58435857e-01f, -5.81413388e-01f, -1.77266762e-01f, -2.56243676e-01f,
  4.30224001e-01f, -2.17778459e-01f, 6.45713508e-02f, 3.46029788e-01f, -2.22127542e-01f, -3.71800244e-01f, -8.90306532e-02f, -3.03737938e-01f, -6.99646056e-01f, -2.93884009e-01f,
  3.36872526e-02f, 4.27691452e-02f, -3.87369663e-01f, -4.62247670e-01f, 9.98853594e-02f, -2.29773805e-01f, -7.87183642e-02f, 7.24234104e-01f, -4.22263965e-02f, 1.51090175e-01f,
  -4.47829068e-01f, -9.66971461e-03f, -2.84249395e-01f, 1.00530326e-01f, -1.98967203e-01f, -9.92143005e-02f, -3.24717939e-01f, -3.89978945e-01f, 7.85683811e-01f, -2.34773174e-01f,
  3.64784807e-01f, -2.82752030e-02f, -6.53302312e-01f, 5.45183063e-01f, 3.95151317e-01f, -2.41598263e-01f, -1.28542483e-01f, 3.19681466e-01f, -2.32913941e-01f, 7.17808530e-02f,
  6.12686574e-01f, -3.26348320e-02f, 6.58753235e-03f, 5.82734384e-02f, 4.24080223e-01f, -6.48664057e-01f, 1.19949877e-01f, -1.58437416e-01f, 1.50631368e-01f, -5.01855686e-02f,
  4.26949486e-02f, 4.29704815e-01f, 5.43055050e-02f, 4.42006290e-01f, -5.30534759e-02f, 3.03635985e-01f, 8.56944397e-02f, -3.63148928e-01f, 1.15699954e-01f, 4.32416469e-01f,
  4.86919165e-01f, -6.34545803e-01f, 9.77742821e-02f, -6.35780692e-01f, -3.85652259e-02f, -3.57107371e-01f, -4.79074240e-01f, -2.95666367e-01f, -1.75168380e-01f, -3.63633305e-01f,
  3.57346714e-01f, -3.25079858e-02f, -5.34073412e-01f, -1.72754049e-01f, 5.65948486e-02f, -1.04449369e-01f, -2.06751794e-01f, 9.75176513e-01f, 1.67496651e-02f, -2.62363523e-01f,
  1.43190011e-01f, 2.20840070e-02f, 6.80380240e-02f, -1.17735215e-01f, 3.85724311e-03f, -1.40415713e-01f, 2.16836005e-01f, 4.55860421e-02f, 2.44281948e-01f, 7.90376887e-02f,
  -5.22915781e-01f, 3.44275266e-01f, 6.77934289e-01f, 5.01893342e-01f, 4.51925516e-01f, 1.58793211e-01f, -2.17870906e-01f, -1.51965380e-01f, -3.84805389e-02f, 1.50846429e-02f,
  -2.02597752e-01f, 3.24846199e-03f, -2.04756200e-01f, 1.33112356e-01f, -5.00893295e-02f, -2.33989954e-01f, 1.43230453e-01f, -2.03899527e-03f, 3.35290104e-01f, 9.30081785e-01f,
  7.37437559e-03f, -1.07492052e-01f, 2.85038322e-01f, -3.21854167e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.54781225e-02f, 1.26464143e-01f, 1.58337414e-01f, 1.45961702e-01f, 7.93759748e-02f, -1.24629095e-01f, 3.79124060e-02f, -4.09105532e-02f, 1.60990700e-01f, -2.36540750e-01f,
  4.12209779e-02f, -1.13106845e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    