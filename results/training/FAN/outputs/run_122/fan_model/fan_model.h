/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.83809251e-01f, 1.11982048e-01f, -7.49229938e-02f, -1.03377163e-01f, -7.32127652e-02f, -1.16393268e-01f, 1.75495110e-02f, -9.50133801e-02f, 1.24723665e-01f, 3.08849569e-02f,
  -1.72672078e-01f, -1.77347683e-03f, 2.13885829e-02f, -2.85829246e-01f, -2.85078675e-01f, -1.03044286e-01f, -1.80761695e-01f, -5.03196158e-02f, 2.00622026e-02f, 1.37449890e-01f,
  -8.46894160e-02f, -2.03590259e-01f, -2.46676415e-01f, -6.33435547e-02f, 3.69466469e-02f, 8.42409953e-02f, -5.19797504e-02f, -1.42138014e-02f, -2.12638274e-01f, -1.31577685e-01f,
  4.46555018e-02f, 2.72039995e-02f, 7.41206259e-02f, 2.28227284e-02f, 3.14798169e-02f, 7.09847063e-02f, 1.47094220e-01f, 3.34167965e-02f, -3.29561010e-02f, -4.65342328e-02f,
  7.95319900e-02f, -5.01130223e-02f, -1.25404269e-01f, 3.90844122e-02f, 1.16136484e-01f, -2.41322741e-02f, -9.22709852e-02f, -8.22952166e-02f, -7.74265826e-02f, -1.07692473e-01f,
  -1.73731312e-01f, -3.19501460e-02f, -8.78604054e-02f, -8.22141692e-02f, -8.13332498e-02f, 1.94953047e-02f, 1.32876979e-02f, -1.81205163e-03f, -1.07198609e-02f, 4.57137935e-02f,
  -3.56080905e-02f, 1.23502441e-01f, -1.25511914e-01f, 3.09309345e-02f, -2.70198844e-02f, -8.23266339e-03f, -2.77635525e-03f, -1.38249481e-02f, 4.59825099e-02f, 6.17205203e-02f,
  5.27059361e-02f, -2.48371735e-02f, 1.31237626e-01f, -7.16204196e-02f, -6.35817274e-02f, 5.46246618e-02f, -5.35685569e-03f, -3.24448422e-02f, 1.14225578e-02f, -1.35103256e-01f,
  -1.89278070e-02f, 5.46419062e-02f, 6.30883202e-02f, 8.28723982e-02f, 7.78784230e-02f, -7.44295791e-02f, 1.70613453e-02f, -1.87041014e-02f, 8.83010700e-02f, 6.18702918e-02f,
  8.27973783e-02f, 1.03420675e-01f, -1.30931549e-02f, 1.28878579e-02f, 9.96199325e-02f, -1.84669439e-02f, 1.81133505e-02f, -8.16003159e-02f, 5.99171780e-02f, 2.10687742e-02f,
  8.12641978e-02f, 1.39910147e-01f, 4.07597683e-02f, -1.01426184e-01f, 8.54625404e-02f, 1.28284037e-01f, 3.37718986e-02f, 2.27362681e-02f, -4.64148372e-02f, 7.18781799e-02f,
  -4.16066051e-02f, 2.49097012e-02f, -5.50927259e-02f, -8.30869898e-02f, -1.24191634e-01f, 3.24947461e-02f, 1.45016104e-01f, -3.16315740e-02f, -8.51589292e-02f, 3.00380066e-02f,
  3.40502523e-02f, 3.85392696e-01f, 7.33581036e-02f, 1.29032165e-01f, 9.60404724e-02f, 6.57293499e-02f, -1.26723230e-01f, 2.07767427e-01f, 1.65620431e-01f, 3.79425213e-02f,
  -1.55134350e-01f, 9.81341228e-02f, -1.70325771e-01f, 1.36449009e-01f, -3.95603431e-03f, -9.82994810e-02f, 1.97676077e-01f, -3.75001505e-02f, 1.27987251e-01f, 3.02894022e-02f,
  6.77538142e-02f, 4.67615165e-02f, 6.91438615e-02f, 1.41409725e-01f, 1.35777052e-02f, 8.17673802e-02f, -1.12344585e-01f, -8.62383619e-02f, 7.05690235e-02f, -1.18026540e-01f,
  1.17290989e-02f, 1.64905965e-01f, 9.20704305e-02f, 5.72926998e-02f, 8.38088058e-03f, -3.33868600e-02f, -1.15485610e-02f, -1.53639928e-01f, -2.45936811e-02f, 4.46016006e-02f,
  -2.26212144e-02f, 2.28264015e-02f, -1.30355293e-02f, 8.43692757e-03f, 5.41077927e-02f, 9.34588015e-02f, 3.66866663e-02f, 3.43377404e-02f, 5.75117879e-02f, -7.75332972e-02f,
  -3.83966453e-02f, -1.12871222e-01f, -1.85867455e-02f, 4.06498127e-02f, 7.05120154e-03f, -7.44472817e-02f, 3.13805304e-02f, -8.88394937e-02f, -1.31341498e-02f, 7.02292994e-02f,
  -1.35441065e-01f, 1.81124005e-02f, 6.91596717e-02f, -2.21545584e-02f, 1.18765019e-01f, 1.22911505e-01f, -4.76153195e-03f, 8.59725773e-02f, 7.21090659e-02f, 6.09379262e-02f,
  4.95791528e-03f, 2.12737899e-02f, -2.10547131e-02f, -4.66663353e-02f, -7.05728249e-04f, -5.87540455e-02f, -9.86685082e-02f, -1.44007385e-01f, 3.25520486e-02f, 1.51004978e-02f,
  -6.05086200e-02f, 1.13962233e-01f, -1.35290101e-02f, 2.32725125e-02f, -1.84013732e-02f, -2.40066946e-02f, -1.47846444e-02f, 2.61252169e-02f, -2.14543659e-02f, -2.80976109e-02f,
  1.53180242e-01f, 1.41341060e-01f, 1.34017214e-01f, 9.56771225e-02f, 8.47698748e-02f, 9.77266580e-02f, 4.14298847e-02f, 6.19518645e-02f, 8.24781656e-02f, -2.38270648e-02f,
  2.21191049e-02f, 1.47569105e-02f, -5.93079142e-02f, -1.87277030e-02f, -5.67300171e-02f, 2.97409110e-02f, -1.12545043e-02f, 7.55978078e-02f, 4.38539423e-02f, -2.18389444e-02f,
  -9.66744423e-02f, -6.94457814e-02f, 2.09166650e-02f, 1.42784104e-01f, -2.05444619e-02f, -1.16364405e-01f, 1.89200956e-02f, -5.24090379e-02f, -9.11408886e-02f, 9.03165638e-02f,
  4.26574379e-01f, -2.41464332e-01f, -1.07544020e-01f, 1.71204597e-01f, -1.16060816e-01f, 1.11549541e-01f, -1.50155378e-04f, -7.49621689e-02f, 9.86692980e-02f, -2.14843258e-01f,
  6.03575222e-02f, -5.58142923e-02f, -1.30705416e-01f, 3.83187197e-02f, 4.07526523e-01f, 7.35863950e-03f, 1.78667977e-01f, -3.81499976e-02f, 2.95846649e-02f, -8.98730084e-02f,
  1.58386782e-01f, 2.99811922e-02f, -3.19140144e-02f, -1.42791539e-01f, -1.06941074e-01f, -1.26327515e-01f, -4.83347336e-03f, -1.65646091e-01f, 7.45873014e-03f, -1.57653108e-01f,
  3.26766372e-02f, 5.90288080e-02f, 8.07463676e-02f, 1.86776463e-03f, 8.02550837e-02f, -4.09157611e-02f, 1.44744711e-02f, 1.76000912e-02f, 1.24215940e-02f, -1.06170841e-01f,
  -6.16162755e-02f, 3.35061215e-02f, 1.68971550e-02f, -3.52015644e-02f, -6.31840825e-02f, -1.74002144e-02f, -7.60733113e-02f, 5.53795621e-02f, -1.00994669e-01f, -9.94604640e-03f,
  -1.37181520e-01f, -5.94200613e-03f, -1.19547203e-01f, -9.24606025e-02f, 2.03070454e-02f, -1.10854015e-01f, 3.14729125e-03f, -8.36570635e-02f, -1.13811614e-02f, 3.11589483e-02f,
  -3.94792631e-02f, -9.76113696e-03f, -7.96781257e-02f, 4.41371836e-02f, -2.12387438e-03f, -5.02179451e-02f, -2.41862424e-02f, 3.18004675e-02f, 5.08256331e-02f, 1.08890310e-02f,
  7.35160857e-02f, 6.21661358e-02f, 8.03178400e-02f, 2.48270389e-02f, 1.24700209e-02f, 3.60210873e-02f, 2.27833912e-02f, -1.87847167e-02f, 8.21684152e-02f, 3.10852304e-02f,
  -3.44790369e-02f, -1.51641443e-02f, -4.54880595e-02f, -1.99233741e-02f, -1.79257449e-02f, 6.37148619e-02f, 3.19085717e-02f, -6.01335429e-02f, -5.18964604e-02f, 2.35602986e-02f,
  1.88761234e-01f, -3.86537425e-02f, 2.17652768e-02f, 4.94795926e-02f, 5.90659752e-02f, 1.38437659e-01f, 1.13924565e-02f, -2.12765709e-02f, 1.04144206e-02f, -4.03932994e-03f,
  -2.73399241e-02f, -3.28441486e-02f, 6.03226535e-02f, 6.18410185e-02f, 2.04550307e-02f, -5.35259694e-02f, -8.39342549e-03f, 4.43616463e-03f, 1.27961067e-02f, 4.53678705e-02f,
  -7.10240332e-03f, -2.99960934e-02f, -5.56115173e-02f, -3.30404267e-02f, -6.68280721e-02f, -1.20696565e-02f, 6.62986711e-02f, -5.38151935e-02f, -8.62749368e-02f, 2.58504096e-02f,
  -3.56101274e-01f, -4.50419169e-03f, -5.82059957e-02f, -3.15577507e-01f, 1.74649283e-01f, 1.55220767e-02f, -2.95288086e-01f, 2.06916079e-01f, -1.94638427e-02f, -1.00193927e-02f,
  -3.25478017e-02f, -2.60401994e-01f, 9.75430831e-02f, -9.46791470e-02f, -2.88686752e-01f, 4.05198485e-02f, -2.13605747e-01f, -2.00531051e-01f, -3.55098769e-02f, -5.03158942e-02f,
  7.00084791e-02f, -1.39963076e-01f, 3.04261073e-02f, 1.20615989e-01f, 3.96278035e-03f, 7.45462477e-02f, -1.57992065e-01f, 6.61922544e-02f, -9.14184749e-02f, 2.18431465e-02f,
  3.95820998e-02f, -2.12191511e-03f, -6.49791164e-03f, 3.13105136e-02f, 3.06211635e-02f, -2.26128567e-02f, 1.68058854e-02f, -3.49737564e-03f, 4.82327864e-02f, -6.01345673e-02f,
  -5.66456877e-02f, -2.75467150e-02f, -5.52434586e-02f, -2.64095385e-02f, 4.80528213e-02f, 2.83733872e-03f, 3.18330117e-02f, 7.01436847e-02f, 7.18993172e-02f, 2.63913181e-02f,
  2.44794022e-02f, 4.07304950e-02f, -4.08777110e-02f, -2.43965746e-03f, 1.17547568e-02f, -1.84336677e-02f, -7.40973204e-02f, -2.30792221e-02f, 4.21984270e-02f, 6.81324527e-02f,
  -2.21318100e-02f, -1.02101550e-01f, 5.04077319e-03f, -8.71103108e-02f, 3.84019986e-02f, -3.32932509e-02f, 2.58351415e-02f, 1.65501609e-02f, 1.74860358e-02f, -2.83170231e-02f,
  7.66589120e-02f, 1.50074186e-02f, 2.01628953e-02f, 3.12469304e-02f, 3.33743095e-02f, -2.70168912e-02f, -2.14640666e-02f, 3.59662957e-02f, -4.86424975e-02f, 4.94794957e-02f,
  -4.78444211e-02f, -7.48487860e-02f, 6.53604493e-02f, 3.29989903e-02f, -3.91140431e-02f, 5.34704588e-02f, 4.37128246e-02f, 7.71606192e-02f, -2.40960903e-02f, -2.88706794e-02f,
  6.20614029e-02f, -8.36751089e-02f, -1.53967394e-02f, 9.14125983e-03f, 1.55207459e-02f, -7.53180264e-03f, -4.66522425e-02f, 3.59392352e-02f, 3.73954661e-02f, -1.21706976e-02f,
  2.73588933e-02f, 7.99652264e-02f, -1.90642551e-02f, -3.84667441e-02f, 1.78820360e-02f, 3.06033865e-02f, -7.89272338e-02f, 5.84515277e-04f, -1.23726107e-01f, -1.02843396e-01f,
  -3.06848548e-02f, -7.44253993e-02f, 4.00878303e-02f, 8.21700878e-03f, -3.88528313e-03f, -1.69913210e-02f, -4.77847531e-02f, -1.84244979e-02f, 2.37771422e-02f, -2.75586639e-02f,
  4.37952310e-01f, -1.26624614e-01f, -2.21057516e-02f, 5.13723642e-02f, -1.11024529e-01f, -2.86898762e-01f, -2.50513642e-03f, -6.17477521e-02f, 1.81436181e-01f, -1.76832527e-01f,
  -7.79314414e-02f, 1.01739362e-01f, 1.65136382e-01f, -5.38710132e-02f, 3.22971016e-01f, 1.60427168e-01f, -6.64579272e-02f, -2.63461489e-02f, 6.20256504e-03f, 8.22909772e-02f,
  8.29513893e-02f, -1.24256119e-01f, 2.40824949e-02f, -2.29502082e-01f, -9.97739881e-02f, 9.83777549e-03f, -2.89853364e-02f, -2.28856485e-02f, -2.40307853e-01f, -1.93918515e-02f,
  3.49602997e-02f, 2.05367386e-01f, 1.21514678e-01f, 1.42185777e-01f, 1.42995432e-01f, 5.39987050e-02f, 8.87978077e-03f, 9.36367139e-02f, 1.35492817e-01f, -5.10259047e-02f,
  1.62877217e-02f, 1.35861740e-01f, -8.52470174e-02f, 5.26015870e-02f, -8.79156739e-02f, -1.50021911e-01f, 4.25929613e-02f, -1.01792850e-01f, 4.38911021e-02f, -8.90660957e-02f,
  8.08236015e-04f, -5.36832176e-02f, -4.88265939e-02f, -5.89099713e-02f, -1.50196068e-02f, -4.90980446e-02f, 1.79652739e-02f, -8.58991072e-02f, -1.72399715e-01f, -1.09461240e-01f,
  -1.40528372e-02f, -2.65254844e-02f, 4.81045097e-02f, 4.26201113e-02f, 5.98719195e-02f, 1.87836327e-02f, 8.62753317e-02f, 2.69186478e-02f, 6.32707924e-02f, 1.36302821e-02f,
  8.80598277e-02f, 1.86224133e-02f, 2.37000491e-02f, 5.95646910e-02f, -3.75198051e-02f, -5.05376756e-02f, -1.65461674e-02f, 5.00930734e-02f, 4.70998921e-02f, -3.45994420e-02f,
  1.21512614e-01f, 1.59398809e-01f, 6.50417879e-02f, -3.61334570e-02f, 8.38970318e-02f, -5.81578314e-02f, 8.34579766e-02f, -3.54905464e-02f, 9.54680592e-02f, -8.78013670e-02f,
  1.15173697e-01f, 1.24527767e-01f, 1.75677851e-01f, 1.22146845e-01f, 1.01285391e-01f, 8.99868906e-02f, 6.93700016e-02f, 6.93308711e-02f, 7.21608847e-02f, 1.27092093e-01f,
  -4.73028161e-02f, 2.25197786e-04f, -3.26140958e-04f, -4.61262427e-02f, -1.05572045e-01f, -6.62810281e-02f, 9.74854007e-02f, 3.80827971e-02f, 2.89557818e-02f, 1.40672375e-03f,
  4.34660725e-02f, 3.42793874e-02f, 1.99751798e-02f, -3.56330648e-02f, -1.22177109e-01f, 1.61569249e-02f, -4.89873402e-02f, -2.11518966e-02f, -6.02371395e-02f, -2.00934801e-02f,
  1.81727242e-02f, -3.12620282e-01f, 1.55531213e-01f, -1.16368629e-01f, 2.04621375e-01f, 7.74633437e-02f, 1.93281509e-02f, 8.56801588e-03f, 3.74290943e-02f, -1.68466404e-01f,
  -1.55692436e-02f, 8.03342164e-02f, -7.06744865e-02f, -9.21944305e-02f, -1.00641795e-01f, -2.37142041e-01f, -4.58969101e-02f, 1.74106043e-02f, -4.75436002e-02f, -1.61573440e-02f,
  -4.46525998e-02f, -1.35595053e-01f, -2.28919424e-02f, 1.28385246e-01f, 4.70161811e-02f, 1.27881885e-01f, -8.72502476e-02f, -2.82974616e-02f, 1.22757614e-01f, 5.58617450e-02f,
  3.88360173e-02f, -1.02859549e-01f, 1.30609656e-02f, 1.01314522e-01f, 8.75466019e-02f, 3.50896008e-02f, 6.15148023e-02f, 6.17957525e-02f, -4.63539585e-02f, 3.32506709e-02f,
  5.91240153e-02f, 9.75811183e-02f, 1.03875529e-02f, -5.77043444e-02f, -5.58945276e-02f, 7.96796456e-02f, 9.68214869e-02f, 4.55486737e-02f, 3.19281220e-02f, 5.65174222e-02f,
  1.13601543e-01f, 1.17502920e-02f, 7.33615831e-02f, 2.09681783e-02f, 6.72536492e-02f, 1.03976578e-01f, 1.22058533e-01f, 1.56102073e-03f, -5.25463335e-02f, 7.34442323e-02f,
  -5.73051013e-02f, 3.81121635e-02f, 3.45478989e-02f, -1.53091364e-02f, 9.61140916e-02f, 6.19734377e-02f, 5.34386225e-02f, 5.86659573e-02f, 4.14535701e-02f, -1.49652893e-02f,
  6.71148160e-03f, -8.13729316e-02f, -8.63891616e-02f, -1.45901786e-02f, 4.34936285e-02f, 3.43204848e-03f, -2.74023265e-02f, 8.43621343e-02f, -8.72359946e-02f, 4.83940765e-02f,
  -2.67329048e-02f, 5.41344397e-02f, -1.20936260e-01f, -4.22596873e-04f, -4.74121794e-02f, -3.67998667e-02f, 6.56227544e-02f, -2.14109314e-03f, -6.74415603e-02f, -5.79483211e-02f,
  -1.50425389e-01f, -5.73866963e-02f, -7.97483400e-02f, 1.75712258e-02f, -1.21477611e-01f, -6.53632581e-02f, -1.05499648e-01f, -3.68621238e-02f, -1.13726899e-01f, 3.81721295e-02f,
  5.82487062e-02f, 8.10278133e-02f, 4.84925136e-03f, -4.14945409e-02f, -6.85046911e-02f, -1.24577750e-02f, -3.58150378e-02f, -9.37224403e-02f, 1.59271173e-02f, 6.71377918e-03f,
  4.75211591e-02f, 6.61332114e-03f, 3.02109122e-02f, 7.40398616e-02f, 2.68661883e-02f, 2.87452973e-02f, 4.07461450e-02f, -2.80099325e-02f, 1.07115135e-02f, -4.48374264e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.10705400e-01f, -1.49281785e-01f, 4.78309207e-02f, 1.75158992e-01f, 2.76122004e-01f, -9.54541005e-03f, 6.45655170e-02f, 4.18948233e-02f, 1.64202660e-01f, -1.07595265e-01f,
  -1.00233173e-02f, -8.45174193e-02f, -1.37584627e-01f, -6.38565570e-02f, 1.19488575e-01f, -2.07980767e-01f, 4.38267365e-03f, -1.05013505e-01f, 8.33919868e-02f, -4.20026444e-02f,
  1.06506236e-01f, -8.35951343e-02f, 8.73623639e-02f, 3.24795246e-02f, 1.61504149e-01f, 9.31654647e-02f, -1.18528217e-01f, 6.48694392e-03f, -1.09093286e-01f, -9.15146992e-02f,
  -5.13967201e-02f, 3.45307551e-02f, 7.64832720e-02f, -1.40606770e-02f, -8.08947347e-03f, 1.28577203e-01f, -3.54125500e-02f, -9.66880769e-02f, -3.86374108e-02f, 3.81228328e-02f,
  3.58830281e-02f, -6.36745021e-02f, -5.58539927e-02f, 1.53987240e-02f, 1.20856300e-01f, 1.82093650e-01f, 1.81675330e-02f, 8.84675235e-03f, 4.27290313e-02f, 1.18885890e-01f,
  1.10093363e-01f, -8.95929616e-03f, 9.27166566e-02f, -2.18372837e-01f, 5.37852980e-02f, 1.63310200e-01f, -2.62678228e-02f, -6.04309924e-02f, 3.56567204e-02f, 5.87048344e-02f,
  1.03891462e-01f, 1.39126023e-02f, -8.11160505e-02f, 4.70265746e-02f, -2.57239062e-02f, 1.02615103e-01f, -3.99588980e-02f, -4.42161523e-02f, -5.76464646e-02f, -8.73988047e-02f,
  -8.05033222e-02f, -7.93260857e-02f, 1.39115239e-02f, 4.26516263e-03f, -3.46637778e-02f, 3.11563797e-02f, -9.15390924e-02f, -1.87533721e-01f, 1.57119799e-03f, 3.30184884e-02f,
  7.40706921e-02f, -4.76633124e-02f, 3.95121872e-02f, -1.05895251e-02f, 5.78591526e-02f, -3.14923818e-03f, -2.49057636e-03f, -5.41603044e-02f, 2.60153972e-02f, 2.66378038e-02f,
  -3.20356101e-01f, -2.29456931e-01f, 2.42570713e-05f, -1.41949862e-01f, -6.28766418e-02f, -9.40041393e-02f, -1.38510287e-01f, -9.97193810e-03f, -1.17637902e-01f, 2.84320787e-02f,
  8.12849961e-03f, -5.76780997e-02f, -7.07592219e-02f, -5.98514192e-02f, -3.53590883e-02f, -7.41500780e-02f, -1.36916578e-01f, -2.27639392e-01f, 6.75695986e-02f, -9.27070901e-02f,
  3.49274911e-02f, 6.57299883e-04f, 7.20363557e-02f, 4.41891104e-02f, -5.75992614e-02f, 8.70166048e-02f, -1.06989285e-02f, -2.74420977e-02f, -3.28751318e-02f, -9.53121856e-02f,
  -2.32524604e-01f, -3.95776704e-02f, -1.54110298e-01f, -5.85466363e-02f, -3.92350256e-02f, -3.71095128e-02f, -1.52730465e-01f, 1.60812020e-01f, -2.83800930e-01f, -2.38643121e-02f,
  1.06902570e-02f, -2.40902513e-01f, -2.27806896e-01f, 1.48761319e-02f, 1.31322697e-01f, -2.66732007e-01f, 1.49076864e-01f, 4.48581614e-02f, -1.03455052e-01f, 2.86930174e-01f,
  1.30092397e-01f, 3.27221930e-01f, 1.01929180e-01f, 3.34120601e-01f, 2.04589241e-03f, 2.00152650e-01f, 3.60475630e-01f, 1.79167837e-02f, 3.99995893e-01f, 1.59900829e-01f,
  -1.83204543e-02f, -5.13150319e-02f, 6.68105111e-02f, -8.08709040e-02f, 6.43057227e-02f, 3.60572785e-02f, 6.68324903e-02f, -4.47312519e-02f, 5.10542467e-02f, 7.14600757e-02f,
  1.88512541e-02f, 2.34668851e-02f, 6.49003759e-02f, -1.60361007e-02f, 4.04571518e-02f, 5.00981398e-02f, -1.09970421e-01f, -1.31587967e-01f, -4.97018099e-02f, 4.16423604e-02f,
  -1.84145406e-01f, -4.35720421e-02f, -6.38843179e-02f, 3.35123874e-02f, -1.99254397e-02f, 8.25366229e-02f, -3.03373416e-03f, -1.17193200e-02f, -2.59358864e-02f, 8.70794132e-02f,
  9.93503034e-02f, 3.96215282e-02f, 1.12514547e-03f, 2.52797711e-03f, -1.42990639e-02f, -4.43572216e-02f, -1.03294477e-01f, -1.68099534e-03f, 3.78345400e-02f, 4.31413092e-02f,
  7.72509798e-02f, 4.43707369e-02f, 1.55830476e-02f, 7.38964882e-03f, 9.62357596e-02f, -1.22634962e-01f, 2.65639015e-02f, 7.86251500e-02f, 3.71367335e-02f, 2.47204266e-02f,
  -1.34312451e-01f, 4.55229171e-02f, 2.76753306e-02f, 4.40960564e-02f, -5.01612090e-02f, 1.32586122e-01f, 9.75688527e-05f, 2.27657687e-02f, 5.67471310e-02f, -6.02505617e-02f,
  5.12971207e-02f, 1.69990301e-01f, -9.00780857e-02f, 2.68849055e-03f, 1.76024232e-02f, -9.23042297e-02f, 2.05929782e-02f, -5.73680699e-02f, 7.33038224e-03f, -1.02738226e-02f,
  1.58183932e-01f, -3.05861663e-02f, 2.98311803e-02f, -4.98010255e-02f, 1.00565173e-01f, 8.14594403e-02f, -6.71093389e-02f, -8.70468691e-02f, -7.91686997e-02f, 1.00170329e-01f,
  2.67246682e-02f, 3.14366519e-02f, -6.09061383e-02f, -5.67734465e-02f, 6.35829493e-02f, -1.69620737e-02f, 6.70584142e-02f, 4.16970765e-03f, -4.42991965e-03f, 5.18492125e-02f,
  2.10859999e-01f, -6.40971661e-02f, -1.31668866e-01f, -1.05057821e-01f, 1.09100696e-02f, 6.07698821e-02f, 2.06588164e-01f, -2.76577473e-01f, -3.56622934e-01f, 9.14779007e-02f,
  1.77595834e-03f, -3.83796766e-02f, 9.40375328e-02f, -1.30578540e-02f, -7.51677752e-02f, -1.67662688e-02f, 5.14816456e-02f, 1.06110781e-01f, -1.62780046e-01f, 5.07812425e-02f,
  -7.39384152e-04f, 1.22848168e-01f, -1.45898880e-02f, -1.58076268e-02f, 1.62616372e-01f, 7.22942408e-03f, 2.40813419e-02f, 7.87852332e-02f, -5.04026525e-02f, 3.09819542e-02f,
  -5.97117431e-02f, 5.01941703e-02f, -1.23918757e-01f, 3.55084799e-02f, 3.27541716e-02f, 1.62848517e-01f, 7.57666007e-02f, 2.38517188e-02f, -8.15872028e-02f, 5.52145690e-02f,
  3.99423502e-02f, -5.01286648e-02f, -2.37168688e-02f, -5.33472560e-02f, -4.29177247e-02f, -1.88448709e-02f, -2.05568984e-01f, 1.64617598e-02f, -1.47823721e-01f, 1.31693333e-01f,
  5.03618792e-02f, 4.84854952e-02f, -3.60839360e-04f, -1.20744165e-02f, -1.14967838e-01f, -4.25487086e-02f, 8.31132829e-02f, 4.97877337e-02f, -3.09060365e-02f, 5.94608746e-02f,
  1.88234821e-02f, 9.56773087e-02f, 4.44252715e-02f, -1.22520596e-01f, 6.52141543e-03f, -9.71898660e-02f, -3.06813195e-02f, -1.99672170e-02f, -1.21786244e-01f, -3.94873917e-02f,
  -1.76009998e-01f, -7.90106207e-02f, -9.86959133e-03f, 1.64169935e-03f, -1.58171151e-02f, -5.65812849e-02f, 6.49858937e-02f, -5.51829375e-02f, 4.73713167e-02f, -7.62220547e-02f,
  -1.24835223e-02f, -7.63907209e-02f, 8.33541900e-02f, -4.01291922e-02f, -2.12015770e-02f, 4.72187102e-02f, 3.17830332e-02f, -3.88589725e-02f, -1.36826932e-01f, 1.31420463e-01f,
  4.13974784e-02f, 8.94185062e-03f, -4.07547951e-02f, -1.08879097e-01f, 3.67784165e-02f, 1.34113297e-01f, -3.54071818e-02f, 1.10368421e-02f, -6.00799127e-03f, -4.50674072e-02f,
  9.18067545e-02f, 7.73095191e-02f, -7.26766661e-02f, 6.56002238e-02f, -5.50685488e-02f, 9.02397931e-02f, 6.08641952e-02f, -9.84900631e-03f, -7.07404539e-02f, 1.32933110e-02f,
  5.90418465e-02f, 1.24905435e-02f, 9.76376906e-02f, -1.37544945e-01f, -9.81701389e-02f, 8.46755132e-02f, -1.54913613e-03f, 2.55309734e-02f, -4.45862999e-03f, -1.39453813e-01f,
  -3.28493387e-01f, 2.57654220e-01f, 9.18728039e-02f, 5.56333102e-02f, 2.23676767e-02f, -6.84866402e-03f, 1.79916203e-01f, 1.61508977e-01f, 3.39542389e-01f, 1.24612324e-01f,
  6.32641613e-02f, 8.14163685e-02f, 1.53780878e-01f, 1.07881270e-01f, -2.64251918e-01f, -5.13616279e-02f, -8.10113177e-03f, 3.80041637e-02f, 2.53863186e-01f, -7.66595155e-02f,
  -5.19166514e-02f, 5.09269908e-02f, -5.46986349e-02f, 3.14902142e-02f, -8.60287994e-02f, 2.92070722e-03f, -1.51976421e-01f, 1.44690260e-01f, -1.07415743e-01f, 9.53302830e-02f,
  3.33608128e-02f, 1.84605256e-01f, 2.70624124e-02f, 5.63530922e-02f, -1.46894947e-01f, 1.92714520e-02f, 7.25587504e-03f, -3.53890173e-02f, -7.80097349e-03f, 9.18168633e-04f,
  -2.00447869e-02f, -1.18232928e-01f, 1.39160370e-02f, -1.05658593e-02f, 4.02181558e-02f, 2.00241543e-02f, -3.59883197e-02f, -2.41065565e-02f, 5.97241521e-02f, 8.01234841e-02f,
  4.32844162e-02f, -1.79201807e-03f, -1.85925066e-01f, -6.51161075e-02f, -8.46477374e-02f, 1.30228028e-01f, -2.31924709e-02f, -6.26886487e-02f, 1.69693455e-02f, 3.97475483e-03f,
  3.46151367e-02f, -3.92589644e-02f, -7.32374415e-02f, 1.22097187e-01f, -5.74980304e-02f, -5.74542508e-02f, -5.59070595e-02f, -1.31713673e-01f, 2.99810022e-02f, 2.03974452e-03f,
  6.24636896e-02f, 3.72563601e-02f, 8.36645290e-02f, -3.89382355e-02f, 3.74961197e-02f, 8.46028235e-03f, -1.90990232e-02f, 1.26914203e-01f, -5.91113083e-02f, 1.62139144e-02f,
  -3.41149345e-02f, 7.24245012e-02f, 1.06394276e-01f, 1.27663925e-01f, 6.70059472e-02f, -7.51674548e-03f, -1.84349976e-02f, 2.91064605e-02f, 4.36873809e-02f, -7.42719769e-02f,
  1.25075459e-01f, 1.19492888e-01f, 1.10037513e-01f, 1.21748395e-01f, -8.90826955e-02f, 2.51426604e-02f, 8.74500424e-02f, -1.46227583e-01f, 6.91792518e-02f, -1.04442149e-01f,
  3.06658465e-02f, -3.52657102e-02f, 2.57026684e-02f, 3.74195948e-02f, -3.28204297e-02f, -4.56349403e-02f, 6.44665435e-02f, -6.08228147e-02f, -6.31249622e-02f, -6.08585067e-02f,
  -4.01194617e-02f, 5.16518168e-02f, -9.82300192e-02f, -9.04587507e-02f, -1.03973582e-01f, -6.86528860e-03f, -7.22369179e-02f, 1.28059894e-01f, 3.96983959e-02f, 4.55032289e-02f,
  3.18101466e-01f, -2.57691920e-01f, -4.95800786e-02f, 1.56049162e-01f, 3.12911481e-01f, -1.14030624e-03f, 6.53111637e-02f, 1.16597958e-01f, 2.59614140e-01f, -2.09320009e-01f,
  -3.07604820e-02f, -1.07904106e-01f, -8.64253044e-02f, -4.19034436e-02f, 1.43628672e-01f, -2.24130392e-01f, 1.27234086e-01f, -1.63289219e-01f, 2.64479942e-03f, 2.55913697e-02f,
  1.95593625e-01f, 1.33047268e-01f, 1.70663640e-01f, -8.77183452e-02f, -1.18272249e-02f, 3.18540819e-02f, 6.00623563e-02f, -8.56295004e-02f, -1.41108423e-01f, 7.09586591e-02f,
  3.14749256e-02f, 9.47701484e-02f, -2.87987385e-02f, -5.35136238e-02f, 5.35109565e-02f, 4.52718325e-02f, -5.04368097e-02f, -1.06368527e-01f, 3.27296779e-02f, -3.48719880e-02f,
  -1.54560357e-01f, 3.78107885e-03f, -1.21799977e-02f, -1.14225656e-01f, 1.22902401e-01f, -1.64419431e-02f, -5.53075001e-02f, 1.76753998e-02f, 1.04592152e-01f, 7.13096634e-02f,
  1.20652793e-02f, -1.52614964e-02f, 4.97680269e-02f, -5.22013269e-02f, -5.56329638e-02f, 1.05398342e-01f, 3.34710665e-02f, 2.44576624e-03f, -3.92928533e-02f, 2.28383169e-02f,
  4.82096197e-03f, -1.04372052e-03f, 6.31573871e-02f, 2.34365501e-02f, 2.71624904e-02f, 2.12710872e-02f, 2.08472763e-03f, 2.82282918e-03f, -4.89119925e-02f, -5.62034175e-02f,
  -2.54130289e-02f, -2.04003379e-02f, 1.42131019e-02f, -7.68971443e-03f, -8.70835334e-02f, 1.03171997e-01f, -6.47289529e-02f, -1.47354648e-01f, 8.45775902e-02f, 8.47309008e-02f,
  -1.00958817e-01f, 7.57057890e-02f, -2.10610079e-03f, 1.17875256e-01f, 5.35520427e-02f, -9.71206799e-02f, -3.61396447e-02f, -1.08244516e-01f, 1.10545114e-01f, -9.74239036e-02f,
  -2.62400568e-01f, -8.85305703e-02f, -4.33780393e-03f, -7.36834332e-02f, -1.18627638e-01f, -2.94753741e-02f, -7.14949965e-02f, -1.01251170e-01f, -6.62803873e-02f, -1.03831679e-01f,
  -1.53491199e-01f, -8.94816890e-02f, 6.66989908e-02f, -1.21919684e-01f, -4.92198728e-02f, -9.28824395e-02f, 3.39271985e-02f, -2.32587289e-02f, 4.24380004e-02f, -6.41573370e-02f,
  -5.46442308e-02f, -1.18529156e-01f, 7.18586966e-02f, 1.48929641e-01f, -1.47487462e-01f, 1.03068456e-01f, -1.26157906e-02f, 6.89719710e-03f, -8.50010756e-03f, 1.24827009e-02f,
  9.24283192e-02f, 2.64745444e-01f, 1.42920613e-01f, 3.32821608e-01f, 1.49303764e-01f, -4.24443521e-02f, 9.07291993e-02f, 1.22887567e-01f, 3.47381800e-01f, -2.32271895e-01f,
  -1.48503587e-01f, 1.18967809e-01f, -1.47744879e-01f, -1.25651527e-02f, -2.37916112e-01f, -1.42172709e-01f, 4.32109460e-02f, -8.03335309e-02f, 2.02031046e-01f, 1.21319164e-02f,
  2.24225685e-01f, -1.18974157e-01f, 4.12349589e-02f, -1.36177987e-02f, 2.57954765e-02f, 8.72534513e-02f, -8.04253072e-02f, 1.08276650e-01f, -8.64897817e-02f, -7.44568110e-02f,
  2.17904653e-02f, 2.23229751e-01f, 3.99605110e-02f, -5.18967211e-02f, -1.84631087e-02f, -2.05750167e-02f, -1.09532969e-02f, -9.84733030e-02f, 2.26693554e-03f, -1.16297659e-02f,
  -9.79413837e-02f, -7.11686835e-02f, -5.91549696e-03f, -1.38450503e-01f, 8.39345753e-02f, -1.47760427e-02f, 1.71353996e-01f, 1.92256778e-01f, 7.05460832e-02f, 5.23724928e-02f,
  9.29303542e-02f, 7.21631721e-02f, 1.57794625e-01f, -4.82508587e-03f, 9.54364389e-02f, 1.89815879e-01f, -2.56782100e-02f, 4.56088856e-02f, 5.54835647e-02f, 1.04845718e-01f,
  6.92947360e-04f, 1.03941420e-02f, -5.48328944e-02f, -8.61586705e-02f, -4.47482020e-02f, 9.96523630e-03f, 4.54942621e-02f, -8.54612663e-02f, 1.32097811e-01f, -2.81632822e-02f,
  -1.39163494e-01f, 1.90711673e-02f, -3.69270239e-03f, 7.89886564e-02f, 4.19493616e-02f, -4.02300432e-02f, -1.12181544e-01f, -1.68823951e-03f, 4.01361994e-02f, 9.07443464e-02f,
  6.55063540e-02f, 3.06225922e-02f, 3.90853398e-02f, -2.28200313e-02f, -1.41158909e-01f, 2.67485552e-03f, -4.08346951e-02f, -6.99563622e-02f, 5.21277040e-02f, -3.01485322e-02f,
  -1.34592846e-01f, 1.33500129e-01f, -3.83883598e-03f, -6.37738258e-02f, 4.46533449e-02f, -1.67210430e-01f, -7.12912828e-02f, -1.11173034e-01f, 1.00776285e-01f, -1.95462674e-01f,
  2.46022791e-02f, -9.37868282e-02f, -1.54228816e-02f, 2.11004261e-02f, -5.41973598e-02f, -6.04050905e-02f, 2.50857025e-02f, 1.09164700e-01f, 3.44752421e-04f, -5.26299551e-02f,
  -5.55762537e-02f, -2.24897712e-02f, -2.38367170e-02f, 1.00713439e-01f, -1.05638072e-01f, 1.92055926e-02f, -5.86657152e-02f, 2.60810480e-02f, -2.55283732e-02f, 9.20571480e-03f,
  -4.76105809e-01f, 1.92108110e-01f, -8.69913623e-02f, -1.79939583e-01f, -1.80793530e-03f, -9.49513242e-02f, -1.00395076e-01f, -1.70066118e-01f, -5.21276519e-03f, 1.03906384e-02f,
  4.41975566e-03f, -8.23421255e-02f, 8.21713954e-02f, 4.22995016e-02f, -1.40407905e-01f, 1.72274813e-01f, -7.49910325e-02f, -7.47273490e-02f, 7.60003254e-02f, -1.16662487e-01f,
  -2.57430207e-02f, 8.38119537e-02f, -9.75862611e-03f, 1.41094342e-01f, -2.08082467e-01f, -1.28649190e-01f, -3.91886346e-02f, 5.04908860e-02f, -6.49685636e-02f, 1.33945169e-02f,
  -1.96294740e-01f, -1.05615370e-01f, -1.00804791e-01f, -1.64075121e-01f, -1.58680484e-01f, -1.74488518e-02f, -2.33108690e-03f, -1.03387341e-01f, -2.29583345e-02f, 3.27672511e-02f,
  2.82711703e-02f, -1.11907404e-02f, 1.12716137e-02f, -7.14381784e-03f, -5.40451966e-02f, -8.63699056e-03f, 7.77536333e-02f, -2.20264196e-02f, 1.74154155e-02f, -7.15710828e-03f,
  4.43642214e-03f, -2.76221931e-02f, -6.08428894e-03f, 8.23834091e-02f, -8.42215307e-03f, -1.68642160e-02f, 1.93322077e-02f, 9.24339239e-03f, -6.87795654e-02f, -3.85753103e-02f,
  4.74930182e-02f, 3.25367302e-02f, -7.29084387e-03f, 1.96656082e-02f, -4.94257808e-02f, -1.53358430e-01f, -5.12656122e-02f, 2.05594264e-02f, 4.48950417e-02f, 1.99661441e-02f,
  3.88935469e-02f, -1.91241540e-02f, 5.70730232e-02f, -8.38683844e-02f, -3.65997292e-02f, -5.74015500e-03f, 8.76097456e-02f, -5.56729473e-02f, -4.96440567e-02f, -2.90696770e-02f,
  2.00637765e-02f, 4.17397503e-04f, -5.13169244e-02f, 3.35454941e-02f, -2.90002003e-02f, 1.05274729e-01f, 1.05420966e-02f, 4.32519652e-02f, -1.32307522e-02f, -1.73417702e-02f,
  -3.94739240e-01f, -2.80905038e-01f, -5.52189387e-02f, -1.40922576e-01f, 4.10950892e-02f, -6.69310391e-02f, 1.48913395e-02f, -4.40892763e-02f, -9.76881683e-02f, -1.37684494e-01f,
  -5.08254617e-02f, 7.18408749e-02f, -1.11185983e-01f, 2.40492523e-02f, 3.42316590e-02f, 5.95676526e-02f, -6.89316913e-02f, -3.04789431e-02f, -1.72636092e-01f, -3.15064304e-02f,
  -1.42005235e-01f, -9.87632386e-03f, 8.36587697e-02f, -4.20210697e-02f, 3.08575779e-02f, -5.37772067e-02f, -6.31108508e-02f, 5.74480183e-03f, 4.68154587e-02f, -7.66656687e-03f,
  -4.33656901e-01f, 3.60370010e-01f, 2.03949466e-01f, -3.30186576e-01f, 1.66844562e-01f, 8.55448693e-02f, -2.70509869e-01f, 2.03871697e-01f, -8.57143775e-02f, -1.17354676e-01f,
  -5.60978875e-02f, -1.30192816e-01f, -8.85167532e-03f, -1.15265422e-01f, -2.16360554e-01f, -3.86693999e-02f, -9.76679325e-02f, -1.77271292e-01f, 8.97244290e-02f, -7.20717534e-02f,
  -4.88199927e-02f, -6.32896200e-02f, -3.45918862e-03f, 3.09897959e-01f, 1.66768536e-01f, 1.30112348e-02f, -9.64777768e-02f, 1.63289174e-01f, 2.79794205e-02f, 1.36592731e-01f,
  -9.11361799e-02f, -1.17511310e-01f, -1.45607246e-02f, 5.89160156e-03f, 6.19148649e-02f, 2.43234411e-02f, -6.55540675e-02f, -4.51560207e-02f, -7.60443658e-02f, 1.76052347e-01f,
  -9.89758410e-03f, 5.66977225e-02f, 5.84914302e-03f, 1.59867391e-01f, 4.84957024e-02f, 1.06868804e-01f, 1.33370366e-02f, 2.41655186e-02f, 5.41543849e-02f, 1.21978752e-01f,
  1.19678386e-01f, -3.89399864e-02f, -2.46420540e-02f, -1.13540329e-01f, 2.52738409e-03f, -6.41090348e-02f, 4.27780338e-02f, -3.55938599e-02f, -6.67740628e-02f, -2.54182760e-02f,
  1.10212294e-02f, 2.92215426e-03f, 4.63538580e-02f, -2.93735620e-02f, 6.77415682e-03f, 8.93038809e-02f, 4.56852168e-02f, -1.13970987e-01f, 2.78791459e-03f, 3.08919586e-02f,
  -8.73529539e-02f, -4.11771610e-02f, -2.78640427e-02f, -1.22649521e-02f, 2.13038921e-03f, -1.06824264e-02f, -6.48008063e-02f, -4.95722592e-02f, -1.36917653e-02f, -5.09156659e-02f,
  8.70041782e-04f, -9.20569673e-02f, 2.34830584e-02f, 6.10643812e-03f, 3.78559195e-02f, 4.62461114e-02f, -7.29796896e-03f, 5.50543219e-02f, -9.40344259e-02f, 1.07374843e-02f,
  -3.32498074e-01f, -2.81153142e-01f, -1.06465086e-01f, -3.12326346e-02f, -1.13102339e-01f, 8.95778686e-02f, 3.01876925e-02f, 3.29255536e-02f, -9.62851197e-03f, 6.24792986e-02f,
  3.67838405e-02f, -7.36053288e-02f, -8.64965469e-02f, 2.43740045e-02f, -3.88420001e-02f, 1.28379036e-02f, -1.36277393e-01f, -1.23771220e-01f, -1.61522940e-01f, 1.06497981e-01f,
  -9.40330178e-02f, 1.57821993e-03f, -6.89193830e-02f, 1.57864876e-02f, -6.45686360e-03f, -9.20980498e-02f, -8.75483826e-02f, 2.69584563e-02f, 7.63214678e-02f, 1.52807701e-02f,
  -2.58661866e-01f, 6.93401694e-02f, -1.57573596e-01f, 1.67304888e-01f, 1.19897254e-01f, 4.57086474e-01f, 2.32831627e-01f, 1.73756585e-01f, 9.12235975e-02f, 2.08505690e-01f,
  1.65115252e-01f, -1.13028236e-01f, -5.64353429e-02f, 2.70181090e-01f, 4.59967330e-02f, 2.28026241e-01f, 2.78421193e-01f, 5.75528815e-02f, -7.39099383e-02f, -7.99351111e-02f,
  -4.60775979e-02f, 1.75348833e-01f, 4.74652722e-02f, -2.27647536e-02f, 1.09496251e-01f, -7.70283639e-02f, -8.22139457e-02f, -2.24211752e-01f, 1.16675928e-01f, 8.27524588e-02f,
  1.45962751e-02f, -1.72550917e-01f, -6.97310269e-02f, -5.66865578e-02f, -1.04080647e-01f, -1.05997965e-01f, -3.30972625e-03f, -1.25721782e-01f, -6.55839220e-02f, -1.33185508e-03f,
  2.45385040e-02f, -4.39594537e-02f, 7.46914819e-02f, -4.14020522e-03f, -3.87580842e-02f, -1.67850859e-03f, 9.07643959e-02f, 1.06071413e-01f, 7.99538475e-03f, -2.41668597e-02f,
  -1.38525022e-02f, 6.82406425e-02f, 5.02539100e-03f, 1.39184624e-01f, 1.86083000e-02f, 4.02556248e-02f, -1.27332294e-02f, -4.54030074e-02f, 5.41572161e-02f, 3.25893015e-02f,
  -1.17049575e-01f, -1.21655427e-01f, -5.98599799e-02f, 4.53834888e-03f, 5.48441596e-02f, -2.31757201e-02f, 1.33641332e-01f, 4.99902479e-02f, -5.40545136e-02f, 7.92864263e-02f,
  9.94346812e-02f, 1.07258208e-01f, -2.96223331e-02f, 3.32940668e-02f, 1.28546849e-01f, 1.01575684e-02f, -6.38373047e-02f, -1.53360246e-02f, 1.31541356e-01f, 6.07567951e-02f,
  7.34409615e-02f, 2.76915878e-02f, -1.77256670e-02f, -1.11238146e-02f, -6.14069775e-02f, -7.06275627e-02f, -2.07551420e-02f, 1.05234317e-01f, 1.13621578e-01f, 2.73156986e-02f,
  1.23795234e-01f, -2.06770375e-01f, 7.32649118e-02f, -3.13086100e-02f, -1.35734543e-01f, 6.01783916e-02f, -5.64292818e-02f, -6.91942871e-02f, -1.08322039e-01f, -3.61192524e-02f,
  1.94147788e-02f, -1.08289197e-02f, 1.43971192e-02f, 6.43751398e-02f, 1.25243366e-01f, 2.89076641e-02f, -2.13146526e-02f, -5.72083220e-02f, 1.11965440e-01f, -8.09683371e-03f,
  -1.09157469e-02f, 4.46178205e-03f, -8.90853256e-02f, -1.11692369e-01f, 1.34943910e-02f, 3.83625105e-02f, -7.50676766e-02f, 2.92622950e-02f, -3.12697329e-02f, 2.01489255e-02f,
  1.44249678e-01f, -2.89094299e-01f, 4.84037399e-03f, -2.39280969e-01f, 3.13343294e-02f, -1.86533302e-01f, 9.41169858e-02f, -2.67760158e-01f, -1.24670573e-01f, -2.34239757e-01f,
  -5.09256646e-02f, 1.25562534e-01f, 2.52729565e-01f, -2.79021561e-01f, 3.44476789e-01f, 2.30797991e-01f, -2.18744799e-01f, -3.81930508e-02f, 4.06806730e-02f, -9.65712667e-02f,
  -1.03102848e-01f, -2.15930536e-01f, 1.30934387e-01f, -2.77584791e-01f, -2.10330501e-01f, -2.31630951e-01f, 8.71876180e-02f, 8.06428567e-02f, -2.82691807e-01f, 4.98619601e-02f,
  -5.99640757e-02f, -7.78968409e-02f, -9.12958235e-02f, 2.28447653e-02f, -7.10756928e-02f, -3.53749463e-04f, 3.45688835e-02f, 8.58025700e-02f, -1.62721202e-02f, 7.51500111e-03f,
  7.53604174e-02f, -4.62728068e-02f, -5.36851883e-02f, 7.27388412e-02f, -5.91174290e-02f, -1.06263712e-01f, -1.90158207e-02f, 2.87010130e-02f, -3.88880707e-02f, 1.12830088e-01f,
  9.92612839e-02f, -3.40858959e-02f, 1.01950523e-02f, -5.32027967e-02f, 3.74236479e-02f, -5.01165129e-02f, 6.29696026e-02f, 7.78741539e-02f, -2.94229686e-02f, 1.73656102e-02f,
  9.23927699e-04f, 5.23292460e-02f, 4.67519229e-03f, -1.80699117e-02f, 1.03559634e-02f, -3.23194377e-02f, 1.66574325e-02f, 7.28736594e-02f, 1.10592935e-02f, -6.71711564e-02f,
  -9.66104493e-03f, -5.28171994e-02f, -1.01916179e-01f, 1.48186861e-02f, -9.53887496e-03f, -4.95102117e-03f, -3.54749262e-02f, 2.25958712e-02f, -4.85775322e-02f, -4.23757210e-02f,
  3.93242985e-02f, -1.41927861e-02f, 1.04470337e-02f, 1.95505954e-02f, -4.94279079e-02f, 6.03740336e-04f, -3.56585719e-02f, -1.45200953e-01f, 5.93532575e-03f, 5.22541767e-03f,
  -3.19682583e-02f, -1.83898032e-01f, -1.37584377e-02f, -9.46753994e-02f, -2.91555636e-02f, 3.23093273e-02f, -1.20615169e-01f, -8.40091556e-02f, -3.27850357e-02f, -2.25173822e-03f,
  -7.70636275e-02f, 4.36414443e-02f, -6.34294674e-02f, 1.88591145e-02f, 1.85143966e-02f, -6.94593638e-02f, 6.03394061e-02f, 7.20275715e-02f, 3.31481658e-02f, -3.29172872e-02f,
  -1.07679171e-02f, 1.88886486e-02f, 4.28131223e-02f, 2.45423093e-02f, -1.65023301e-02f, 1.01149462e-01f, 5.73545210e-02f, 1.64976586e-02f, 6.97973594e-02f, -2.58456878e-02f,
  -4.93250847e-01f, 8.03940222e-02f, 8.02069232e-02f, -2.27493539e-01f, -3.57669517e-02f, 1.63413435e-02f, -5.13985418e-02f, -6.38270229e-02f, -2.40608528e-02f, 7.73935989e-02f,
  -3.90253253e-02f, -6.46688044e-02f, 8.10965598e-02f, 5.71718588e-02f, -9.58202407e-02f, 1.96321741e-01f, -9.77095217e-02f, -1.39356405e-01f, 2.78038736e-02f, 1.31058143e-02f,
  -5.14674820e-02f, 4.54819091e-02f, 4.59872223e-02f, 1.10117257e-01f, -4.60527465e-03f, -9.23953280e-02f, -4.18400019e-02f, 1.45445555e-01f, -6.39336407e-02f, -4.75371815e-02f,
  -1.25198483e-01f, -1.88860461e-01f, 1.41393036e-01f, -1.75314825e-02f, -6.94963709e-02f, 6.57142233e-03f, -5.63540384e-02f, 3.13000493e-02f, 3.02771330e-02f, -3.56472156e-04f,
  4.19846065e-02f, -9.08845589e-02f, -8.74157250e-03f, 6.04538880e-02f, -2.33422238e-02f, -4.80985381e-02f, 8.44532028e-02f, -1.21861465e-01f, 5.41631915e-02f, 3.11641507e-02f,
  5.81337325e-02f, 3.00431438e-02f, 4.12200689e-02f, -9.32763238e-03f, -2.87343524e-02f, 1.25983462e-01f, -4.51530106e-02f, -8.95553827e-02f, -5.53193949e-02f, -1.40502349e-01f,
  -7.18103116e-03f, -1.53754381e-02f, -1.27068032e-02f, -2.58718804e-02f, 8.39705318e-02f, -1.72425270e-01f, 1.45305216e-01f, -3.26453820e-02f, 2.68488377e-02f, 5.65888807e-02f,
  -2.69226078e-02f, -1.25705481e-01f, 2.53949873e-02f, -5.86469024e-02f, 2.60503367e-02f, 3.24847549e-02f, 1.51791006e-01f, -6.45462889e-03f, -9.00064558e-02f, -6.04184531e-02f,
  -1.49117399e-03f, 1.93514000e-03f, -9.43922251e-02f, -4.99712788e-02f, -3.00570503e-02f, 8.23108181e-02f, 1.36154955e-02f, 7.51118958e-02f, -8.97337645e-02f, 7.94878379e-02f,
  -1.69913590e-01f, -3.09991777e-01f, 1.41169146e-01f, -7.70928785e-02f, 6.73923865e-02f, -2.65533500e-03f, 1.10331930e-01f, -2.28201272e-03f, 4.57840897e-02f, -2.10718010e-02f,
  1.53168276e-01f, -9.85822268e-03f, -6.94405362e-02f, -6.68562762e-03f, 6.48046099e-03f, 6.67167678e-02f, -1.84726864e-02f, -1.12017147e-01f, -1.09137669e-01f, -6.24441803e-02f,
  -2.90484168e-02f, -1.14466455e-02f, 1.02841392e-01f, -4.28758077e-02f, -3.48389857e-02f, -3.62618873e-03f, -1.31998181e-01f, -1.10734543e-02f, -6.77969959e-03f, -1.08756408e-01f,
  -1.66504696e-01f, 1.78948134e-01f, -2.09481835e-01f, 2.53009088e-02f, -1.50063664e-01f, 1.80981547e-01f, 2.76613981e-01f, -1.56796202e-01f, -6.92131072e-02f, 3.41539353e-01f,
  2.35009879e-01f, -1.34507269e-01f, 2.11505741e-01f, 3.30043256e-01f, -3.22278351e-01f, 2.61197418e-01f, 2.43366569e-01f, 1.60321206e-01f, -1.76885128e-01f, -9.36498120e-02f,
  -4.78262194e-02f, 2.93729573e-01f, 6.69856668e-02f, -6.02945089e-02f, 3.20448610e-03f, -1.68067575e-01f, 4.92603444e-02f, -2.08269879e-01f, 1.01041690e-01f, -5.62307164e-02f,
  6.51088208e-02f, -1.70712695e-02f, -7.38831088e-02f, 2.18215380e-02f, -6.08715527e-02f, 1.99380945e-02f, -8.69204756e-04f, -8.65695402e-02f, -1.08316643e-02f, 5.04283197e-02f,
  -1.23236459e-02f, -9.15960073e-02f, 6.54690564e-02f, -1.10912368e-01f, -1.28905147e-01f, -1.39117297e-02f, 7.63598531e-02f, -5.37934946e-03f, 9.81048942e-02f, -2.00610310e-02f,
  -6.23706318e-02f, -1.73572879e-02f, 5.03708869e-02f, 4.15936150e-02f, -7.79301822e-02f, -4.46205772e-02f, 1.76643450e-02f, -1.45875188e-02f, -2.00248789e-02f, -4.44580503e-02f,
  1.68636013e-02f, -4.28384840e-02f, 9.45472047e-02f, 4.62223627e-02f, -5.81277013e-02f, 3.28726023e-02f, -6.01794431e-03f, 6.79311305e-02f, 5.31069934e-03f, -1.37035083e-03f,
  2.92171910e-02f, -7.95787573e-02f, 8.95043183e-03f, -1.27612252e-03f, -4.56935028e-03f, -6.69091642e-02f, 8.31074268e-03f, -2.60374378e-02f, 4.28208858e-02f, 1.61025804e-02f,
  1.18635178e-01f, -1.14755351e-02f, 5.27690910e-02f, 7.34035298e-02f, 5.14508672e-02f, -7.07167834e-02f, 5.40068746e-02f, -1.04039691e-01f, 2.92835701e-02f, 3.07579599e-02f,
  1.38315320e-01f, -6.99841604e-02f, -1.93110835e-02f, 6.62892237e-02f, 5.88226542e-02f, 4.02244367e-02f, -6.42626435e-02f, -2.51912605e-02f, -1.87453199e-02f, 3.02598178e-02f,
  -3.99885178e-02f, 4.70568240e-02f, -9.11519304e-02f, -3.60975275e-03f, -1.12786591e-01f, 4.01429459e-02f, 1.22812949e-01f, -1.16615929e-01f, 6.05700687e-02f, -8.91722441e-02f,
  4.60822843e-02f, 5.25209308e-02f, 2.10036337e-02f, 6.14545867e-02f, 1.92128737e-02f, 6.56795651e-02f, -1.43682197e-01f, -1.01753749e-01f, 8.83570611e-02f, 3.01471557e-02f,
  -6.58162758e-02f, 1.04727298e-01f, -2.31675833e-01f, -5.23576587e-02f, -9.93370712e-02f, -3.35595459e-01f, -1.88647181e-01f, -1.14586867e-01f, 4.41280194e-02f, 1.53043285e-01f,
  -1.54360592e-01f, 1.56694040e-01f, 1.17278978e-01f, -8.42813104e-02f, -2.88487852e-01f, 1.73364766e-02f, -1.47561193e-01f, -8.87171999e-02f, 1.33265004e-01f, -1.23435386e-01f,
  -1.31593451e-01f, -1.37324125e-01f, -1.98413938e-01f, -1.00849897e-01f, -1.60155475e-01f, -2.30322797e-02f, 3.43600027e-02f, -8.86016563e-02f, -8.04641843e-02f, -1.62332386e-01f,
  -3.52032930e-02f, 5.37849916e-03f, 4.79946062e-02f, -4.81664576e-03f, 9.01286840e-04f, 1.26656611e-03f, -3.16464938e-02f, 7.28605688e-02f, 8.36033672e-02f, -4.42654826e-02f,
  2.79292371e-03f, -1.46879271e-01f, -2.78589632e-02f, 7.73935346e-03f, -2.14203764e-02f, -7.40856752e-02f, -1.30215585e-01f, 4.45985608e-03f, -7.39744753e-02f, -4.02423888e-02f,
  -1.57995850e-01f, 2.06632242e-02f, -9.11634564e-02f, -6.15204778e-03f, -2.97492296e-02f, -1.58806339e-01f, -3.05060651e-02f, 4.47670110e-02f, -4.93224822e-02f, 1.76254548e-02f,
  -7.05438927e-02f, 1.25074431e-01f, 1.07519232e-01f, 1.14528332e-02f, -6.82110116e-02f, -3.40889418e-03f, 2.44288482e-02f, 3.97205837e-02f, -3.17641385e-02f, -1.34856608e-02f,
  -5.79544120e-02f, 4.41260673e-02f, -6.04360476e-02f, -8.37286636e-02f, -1.15339030e-02f, 1.03933036e-01f, 4.00343537e-02f, 6.40552342e-02f, 7.17382599e-03f, -7.72929341e-02f,
  -1.07166953e-01f, -1.10204421e-01f, 7.82368928e-02f, 6.99419007e-02f, 6.59497157e-02f, 1.56331025e-02f, 2.68058684e-02f, -1.96138732e-02f, 4.06101495e-02f, 4.74249152e-03f,
  -8.41181278e-02f, -1.45048290e-01f, 1.05737425e-01f, -4.28346246e-02f, 1.86305270e-02f, -8.10059346e-03f, 7.61040254e-03f, 1.03751041e-01f, -4.45247442e-02f, -1.92121938e-02f,
  -1.35827288e-01f, -8.37915204e-03f, 2.79524326e-02f, 2.76292525e-02f, 4.60117981e-02f, -7.23682642e-02f, -3.44435498e-02f, 2.12045833e-02f, -1.91176720e-02f, 3.00726350e-02f,
  3.79632483e-03f, 1.09810106e-01f, 2.19327002e-03f, -3.91017608e-02f, 3.55028734e-02f, -1.00709803e-01f, -7.54525438e-02f, -5.16449213e-02f, -1.14320973e-02f, -1.69608630e-02f,
  -7.03181624e-02f, 9.88952443e-02f, 1.84921458e-01f, 1.88728988e-01f, -1.18486725e-01f, -3.27415943e-01f, -1.82363287e-01f, 1.43373564e-01f, 7.98989609e-02f, -2.78147943e-02f,
  -3.77360918e-02f, 1.28414512e-01f, 8.47119018e-02f, 6.57759979e-02f, -9.60621331e-03f, -2.94659548e-02f, 2.39582062e-02f, -3.27240154e-02f, 7.91742653e-02f, 9.78800505e-02f,
  2.34647095e-01f, -4.09841584e-03f, 1.74181536e-01f, 1.13414600e-01f, -3.28953341e-02f, 2.58487374e-01f, 2.93788224e-01f, 3.08803860e-02f, 1.35784909e-01f, -2.64620967e-03f,
  -1.43456385e-01f, 1.02406636e-01f, 5.83086349e-02f, -7.57215321e-02f, 7.65233487e-02f, -1.68463290e-01f, 2.51427628e-02f, 3.31501738e-04f, -9.25260186e-02f, -2.35998854e-02f,
  6.91024214e-02f, -3.23904958e-03f, 8.00956227e-03f, 1.43977255e-02f, -3.80417681e-04f, 1.05608059e-02f, -2.99873203e-02f, -3.76282856e-02f, -2.44263820e-02f, 2.86336914e-02f,
  -5.37701957e-02f, -2.06283014e-03f, 6.87744759e-04f, 1.29784226e-01f, 1.32909399e-02f, 1.37906760e-01f, 3.98124345e-02f, 2.96260463e-03f, 1.01713408e-02f, 1.37426123e-01f,
  -1.61465090e-02f, -5.05597554e-02f, -5.68621270e-02f, -1.70024689e-02f, -3.92417125e-02f, -5.82551991e-04f, 1.10311462e-02f, 2.81135794e-02f, -7.12176338e-02f, 5.32994494e-02f,
  -9.88506712e-03f, 9.08760261e-03f, -8.97788256e-02f, 1.95129532e-02f, 9.79441851e-02f, 1.97807029e-02f, 4.57544737e-02f, 2.50718128e-02f, 7.57686049e-02f, 1.11173220e-01f,
  7.49635398e-02f, -9.57456753e-02f, 9.82163548e-02f, 1.48428313e-03f, -7.83746019e-02f, 7.32561946e-02f, -3.58701311e-02f, -4.01317477e-02f, 1.25238284e-01f, 2.52115559e-02f,
  7.43300989e-02f, 3.37765783e-01f, 3.38029005e-02f, -1.80707630e-02f, -5.40377796e-02f, -8.90279785e-02f, 2.00011916e-02f, 5.47017381e-02f, 1.21008620e-01f, 9.35792224e-04f,
  8.35218802e-02f, -1.29024416e-01f, -8.56090561e-02f, -2.15066578e-02f, 4.16894481e-02f, 1.38421103e-01f, 6.95192590e-02f, 1.17462188e-01f, 1.33197695e-01f, 6.52312413e-02f,
  5.51146083e-02f, -5.04929535e-02f, -3.92717756e-02f, 1.03633374e-01f, -2.58052573e-02f, 2.51953006e-02f, -3.31673063e-02f, 5.65260742e-03f, 1.23024054e-01f, 6.92851841e-02f,
  2.31958106e-01f, -1.95617937e-02f, 1.23907775e-01f, 2.12700784e-01f, 1.82278842e-01f, 1.79390535e-01f, 2.14587316e-01f, 1.56737909e-01f, 3.83026093e-01f, -6.72460673e-03f,
  1.98405161e-02f, 1.19686179e-01f, 3.59943211e-02f, 8.92886817e-02f, 9.95833948e-02f, 1.30425971e-02f, 1.92884594e-01f, 1.83546901e-01f, 1.26955673e-01f, 5.41282184e-02f,
  5.48166074e-02f, -2.95487773e-02f, -3.32450747e-01f, -1.92367658e-01f, 2.13769805e-02f, -8.38626772e-02f, -2.72775084e-01f, -1.06365673e-01f, -1.36189222e-01f, -1.94395296e-02f,
  2.47040503e-02f, 1.77872106e-02f, -7.31075108e-02f, -5.37241325e-02f, 7.40498230e-02f, -3.44080366e-02f, -6.99418038e-03f, -1.44610144e-02f, -8.30932986e-03f, 5.03041334e-02f,
  1.01830572e-01f, -2.05849819e-02f, 1.12344034e-01f, -6.05199784e-02f, 3.79015207e-02f, -4.46100682e-02f, 2.35929824e-02f, -9.06657521e-03f, -1.29552007e-01f, -1.88458748e-02f,
  -5.37658744e-02f, 8.99034087e-03f, 8.41790363e-02f, -3.89040336e-02f, -9.61934030e-03f, -5.98540381e-02f, 4.09362279e-02f, 1.26728006e-02f, 2.68069841e-03f, 7.98591524e-02f,
  2.80820597e-02f, 8.53326470e-02f, -2.17359662e-02f, -7.48158991e-02f, 3.05811390e-02f, -7.64788652e-04f, -9.69938294e-04f, 1.06970072e-02f, 9.30131078e-02f, 3.45055945e-02f,
  -2.78935283e-02f, 6.05965219e-02f, 1.91377431e-01f, -1.32993683e-01f, 6.81947917e-02f, 3.89234200e-02f, 1.84943213e-03f, 1.22845627e-01f, 1.28629103e-01f, 2.56760269e-02f,
  -4.92211170e-02f, -1.54320048e-02f, -1.77399606e-01f, -7.16887042e-02f, 2.77708825e-02f, 7.27603361e-02f, -7.53369853e-02f, 1.27849057e-01f, 4.61370610e-02f, 7.07352012e-02f,
  5.39911725e-02f, 9.06977654e-02f, 7.27637708e-02f, -1.07610645e-02f, 1.69670279e-03f, 7.28751123e-02f, 8.81549492e-02f, 6.82123899e-02f, -5.90375178e-02f, -1.20750563e-02f,
  8.62455294e-02f, 1.05124362e-01f, 9.59254801e-03f, -3.25559266e-02f, -4.50067669e-02f, -3.67284083e-05f, -7.36453477e-03f, 2.28926018e-02f, 8.28747824e-02f, 2.04749703e-02f,
  -2.45974702e-03f, 1.48644373e-01f, 1.11462094e-01f, -2.48644017e-02f, 1.25683308e-01f, -9.09558311e-02f, 9.40139145e-02f, -9.12814140e-02f, 4.34532091e-02f, 3.09028886e-02f,
  1.21592321e-01f, -4.63843159e-02f, -1.06706716e-01f, -8.31981655e-03f, -1.40192106e-01f, -3.13019603e-01f, -1.90869823e-01f, -1.01419732e-01f, 1.17599629e-01f, 5.61988465e-02f,
  -8.91260430e-02f, 1.43728256e-01f, 1.34827122e-01f, -2.19974145e-01f, -7.81970099e-02f, 5.02056442e-02f, -1.32367507e-01f, -1.71203483e-02f, 1.18075997e-01f, -1.00413248e-01f,
  -1.06772773e-01f, -2.26780578e-01f, -1.42071486e-01f, -2.28785276e-02f, -2.66395450e-01f, -5.81969656e-02f, -4.50905971e-02f, -7.21707121e-02f, -1.83017612e-01f, -1.05341813e-02f,
  -8.21965113e-02f, 7.91440830e-02f, -5.49619971e-03f, 8.45199227e-02f, -2.89024208e-02f, -1.22303352e-01f, -3.19895484e-02f, -2.14075260e-02f, 2.13257335e-02f, 4.64320965e-02f,
  7.61525845e-03f, 7.54184574e-02f, 5.88193461e-02f, 3.55468839e-02f, -4.97838706e-02f, -2.40067742e-03f, 7.70649314e-02f, 2.94886455e-02f, 2.67248992e-02f, -7.01394528e-02f,
  -1.63606983e-02f, 1.43695120e-02f, -1.57281354e-01f, 1.41452476e-01f, 3.17531489e-02f, 3.16368006e-02f, -1.91521682e-02f, -5.25018238e-02f, -1.28991781e-02f, 1.06678568e-01f,
  3.44003066e-02f, -2.30929740e-02f, -2.02458892e-02f, -5.21369167e-02f, 2.73926444e-02f, -4.90102284e-02f, 2.20773704e-02f, 3.48885432e-02f, -8.74047913e-03f, -1.12232767e-01f,
  1.12484340e-02f, 3.69001664e-02f, 2.02789083e-02f, 1.51838781e-02f, -8.35629106e-02f, -5.40892407e-02f, -2.71222349e-02f, 1.02831855e-01f, -8.55762139e-02f, 1.04485471e-02f,
  -5.75927123e-02f, -1.51106818e-02f, 4.70185541e-02f, -5.45582734e-02f, -9.91529673e-02f, 8.21011588e-02f, -4.63582054e-02f, -1.08666487e-01f, -3.41509767e-02f, -4.51271497e-02f,
  5.41533753e-02f, 1.06959984e-01f, 3.27930897e-02f, 2.42030248e-02f, 1.59120571e-03f, -5.83371967e-02f, -1.11061119e-01f, -1.98232159e-02f, -1.43302539e-02f, 3.43383930e-04f,
  -1.41146049e-01f, -3.23539646e-03f, 5.44476323e-02f, 1.48430495e-02f, -7.10456222e-02f, -1.15475610e-01f, -4.91150506e-02f, 1.04551718e-01f, -4.64401767e-03f, 5.18873669e-02f,
  -2.29599699e-02f, 1.09389663e-01f, 2.50664391e-02f, -4.66764830e-02f, 2.55764592e-02f, 7.43746161e-02f, -1.32555803e-02f, 7.83236399e-02f, 6.88497201e-02f, 6.50855601e-02f,
  2.68527687e-01f, -2.49417290e-01f, 1.00359917e-01f, 2.09055632e-01f, 3.43758434e-01f, 2.09427387e-01f, 1.16312072e-01f, 2.11881340e-01f, 3.24013770e-01f, -1.35914192e-01f,
  2.13745702e-02f, -1.46176979e-01f, -1.83808476e-01f, 2.31928732e-02f, 3.07572596e-02f, -1.28538802e-01f, 6.65294752e-02f, -8.73954743e-02f, 6.77050129e-02f, -3.75835672e-02f,
  1.50732443e-01f, 7.65162660e-03f, -1.46769390e-01f, -1.12895101e-01f, 1.47972956e-01f, 6.99532107e-02f, -1.00765936e-01f, -9.15732682e-02f, -8.73744786e-02f, 7.39197852e-03f,
  7.22339153e-02f, -2.39217896e-02f, -1.32819965e-01f, -1.19155519e-01f, 9.99391824e-02f, -5.62802777e-02f, -1.38723746e-01f, -1.67971820e-01f, -2.45223450e-03f, 6.05506599e-02f,
  -1.14330523e-01f, -1.33370414e-01f, 3.53888273e-02f, 4.74829897e-02f, 4.06078883e-02f, 9.25458129e-03f, -1.82013847e-02f, 3.24119558e-03f, -1.44590855e-01f, 7.45633468e-02f,
  -7.33577535e-02f, 6.91844225e-02f, 1.58194870e-01f, -3.87321152e-02f, -3.68907989e-04f, 3.73386107e-02f, -4.13944684e-02f, -7.96032790e-03f, -4.47441153e-02f, -7.12689087e-02f,
  -7.72754056e-03f, 4.22309972e-02f, -4.96720374e-02f, 1.00599602e-01f, 1.22647479e-01f, 1.21246174e-01f, 1.86986491e-01f, 7.60306641e-02f, 1.04217030e-01f, 9.74426493e-02f,
  6.62015527e-02f, 8.11603386e-03f, 7.36230463e-02f, 1.11485206e-01f, -4.10507917e-02f, 2.56099906e-02f, -3.81701323e-03f, 8.64007026e-02f, -4.16751578e-02f, 3.69053558e-02f,
  -2.60060336e-02f, -9.77615360e-03f, -8.25601572e-04f, 4.27986011e-02f, 2.11109444e-02f, 4.89437990e-02f, 6.33681864e-02f, 1.51382133e-01f, 3.09099779e-02f, -1.40386537e-01f,
  7.97703210e-03f, -2.04089507e-01f, -2.37703789e-02f, -1.76017191e-02f, -8.18221346e-02f, -1.34786693e-02f, -4.57009161e-03f, -1.08748309e-01f, -1.24077098e-02f, 1.05238914e-01f,
  -1.02911748e-01f, 4.80207503e-02f, 8.42435956e-02f, -5.09935841e-02f, -1.20384209e-02f, 1.29751554e-02f, -3.72966789e-02f, -1.02319472e-01f, -1.77819535e-01f, -5.57903349e-02f,
  3.93842086e-02f, 1.06200866e-01f, -9.07800570e-02f, 4.61021177e-02f, -6.48667589e-02f, -7.52199963e-02f, 1.16021894e-01f, 8.03280920e-02f, 7.51091680e-03f, -6.18189909e-02f,
  -6.21209502e-01f, 4.30651605e-02f, -1.46444157e-01f, 1.29389718e-01f, -2.89592087e-01f, -1.06970027e-01f, -8.00063834e-02f, -5.45104109e-02f, -8.47337544e-02f, 1.64344802e-01f,
  7.79288933e-02f, -1.37427062e-01f, 9.17604193e-02f, 3.59187216e-01f, -2.02501312e-01f, 2.25074589e-01f, 2.54259676e-01f, 1.07770652e-01f, 1.08499244e-01f, -4.05405685e-02f,
  2.53843963e-01f, 2.33529136e-01f, 2.25453362e-01f, 7.13304132e-02f, -1.09136149e-01f, 9.76559818e-02f, 1.66716591e-01f, -1.20385503e-02f, 1.61627322e-01f, -1.73280582e-01f,
  -2.27342099e-01f, -1.12076169e-02f, -4.29750755e-02f, -1.08301900e-01f, -5.08085676e-02f, -6.19557127e-02f, -3.94371152e-02f, -1.04133643e-01f, -1.40057169e-02f, -1.34348452e-01f,
  -2.61089578e-02f, 4.49517369e-02f, 2.38565803e-02f, -5.24889256e-05f, -5.83837219e-02f, 1.53548913e-02f, -2.43252963e-02f, 7.02278093e-02f, -3.34033780e-02f, 4.25065421e-02f,
  8.44056830e-02f, -4.98794466e-02f, 9.32777599e-02f, 7.58179575e-02f, 8.02231953e-02f, -8.55460614e-02f, 7.40835965e-02f, -6.28685206e-02f, -9.16556045e-02f, -4.36800085e-02f,
  -7.99032301e-02f, 7.10961074e-02f, 9.33546871e-02f, -5.34487218e-02f, -5.75915389e-02f, -1.93139017e-02f, 6.13813438e-02f, 6.00326881e-02f, 3.72463129e-02f, 6.86508492e-02f,
  -8.66918042e-02f, 1.98875908e-02f, 7.74806514e-02f, 1.76995788e-02f, 5.22516891e-02f, -1.14348773e-02f, -5.78739457e-02f, -2.58430149e-02f, -8.84850919e-02f, -1.53781408e-02f,
  -1.01014651e-01f, -1.03765139e-02f, -3.15801948e-02f, -4.84657474e-02f, -7.73031404e-03f, 9.19611156e-02f, 7.77587369e-02f, -2.04813783e-03f, -6.40649945e-02f, -1.21277636e-02f,
  -6.25858903e-02f, 1.04090378e-01f, -4.76285294e-02f, -2.06412658e-01f, -1.27315363e-02f, -4.00579795e-02f, -5.67932939e-03f, -8.77505317e-02f, 9.75190699e-02f, -1.50120616e-01f,
  -4.19945940e-02f, 3.50401215e-02f, -2.79918523e-03f, 4.37263120e-03f, -3.14369611e-02f, 5.31507023e-02f, -2.02266797e-02f, -6.73379600e-02f, -5.38638700e-03f, 4.95782532e-02f,
  4.23964672e-02f, -4.03087251e-02f, 6.36963546e-02f, 2.48715989e-02f, 6.18641563e-02f, -1.27401367e-01f, -3.56942713e-02f, -3.79552059e-02f, -1.75535902e-02f, 4.00819331e-02f,
  1.40657276e-01f, 2.50665486e-01f, 1.49916396e-01f, 2.56020635e-01f, -4.97044399e-02f, -5.05242646e-02f, -5.02397642e-02f, 1.09393217e-01f, 1.50380149e-01f, 4.93748002e-02f,
  2.55418513e-02f, 2.20683351e-01f, -1.03990078e-01f, 1.19236581e-01f, 9.43629071e-02f, -5.61433323e-02f, 2.65003234e-01f, 1.07739136e-01f, 7.87022859e-02f, 1.27508610e-01f,
  1.28906727e-01f, 1.79620117e-01f, 1.19397089e-01f, 1.11993432e-01f, 1.46943405e-01f, 1.47718921e-01f, 2.66357120e-02f, -7.13063031e-02f, 5.73795214e-02f, -3.39192674e-02f,
  -2.85157282e-02f, -2.24120691e-02f, 1.11632524e-02f, -1.57524541e-01f, -6.61403909e-02f, 2.36559846e-03f, -1.34457707e-01f, -1.29695147e-01f, -2.21412536e-02f, -2.56360471e-02f,
  7.48165548e-02f, 3.77736054e-02f, -6.25824407e-02f, -4.75191772e-02f, -3.69026884e-02f, -9.51122120e-02f, -4.96608764e-02f, -8.92687961e-02f, 1.59929376e-02f, 4.37659100e-02f,
  3.80766205e-02f, -9.63428174e-04f, 2.09909976e-02f, -1.13040216e-01f, 4.29401472e-02f, -2.85200402e-02f, 5.64787388e-02f, 2.11496167e-02f, 4.75988127e-02f, 7.09866062e-02f,
  9.05354023e-02f, 8.18438828e-02f, 3.01237497e-02f, 6.98026866e-02f, 3.06810942e-02f, -5.63246794e-02f, -4.86928113e-02f, -1.08183265e-01f, -3.39316092e-02f, 1.02021150e-01f,
  -1.30484581e-01f, -1.04011288e-02f, -1.87012795e-02f, -1.42412946e-01f, 9.91536230e-02f, 4.27928343e-02f, 4.66563143e-02f, -7.48891383e-02f, 7.80295208e-02f, 6.55588135e-02f,
  -1.49234049e-02f, 8.04530308e-02f, -5.24325483e-03f, 2.22433172e-02f, 3.92137542e-02f, 2.00771857e-02f, 5.79367504e-02f, 7.22283497e-02f, 8.99768174e-02f, 5.97818941e-02f,
  9.15752500e-02f, 1.85810909e-01f, -8.91963206e-03f, -9.10269246e-02f, -1.23668909e-01f, 3.61724533e-02f, 7.34974667e-02f, 9.36986879e-03f, 1.19356349e-01f, -4.29978147e-02f,
  -5.26718516e-03f, -3.99099328e-02f, -6.58651441e-02f, -8.71701911e-02f, -1.77802984e-02f, -2.38245409e-02f, -2.86161527e-02f, 2.94165071e-02f, 7.00566471e-02f, 3.44091058e-02f,
  1.17478691e-01f, -2.06020754e-03f, 8.14622194e-02f, -1.11593463e-01f, -3.96887437e-02f, -8.82872492e-02f, 3.86764295e-02f, -1.42149702e-02f, 5.90729602e-02f, 4.04747538e-02f,
  3.02688092e-01f, 2.66659707e-01f, -2.63030261e-01f, -1.18530266e-01f, 3.52435410e-02f, 9.27858427e-02f, 7.32171237e-02f, -8.04402903e-02f, -1.10604621e-01f, 1.47053927e-01f,
  1.74825177e-01f, -2.41739266e-02f, 4.03357893e-02f, 2.82592446e-01f, 8.75530019e-02f, 1.39986768e-01f, 2.63478905e-01f, 1.55101687e-01f, -1.05369752e-02f, 2.83193350e-01f,
  1.04530811e-01f, 3.96876097e-01f, 5.33065246e-03f, 1.67622641e-01f, 3.18707526e-01f, -1.64777741e-01f, 1.72114849e-01f, -1.81842178e-01f, 7.82050714e-02f, 7.35349581e-02f,
  -1.06573692e-02f, 6.38210624e-02f, 1.59187044e-03f, 2.56374609e-02f, 5.60544580e-02f, 4.34133373e-02f, -5.39608523e-02f, -2.31931061e-02f, -4.76278439e-02f, -6.36148080e-02f,
  1.60220098e-02f, -3.26471240e-03f, 6.88592484e-03f, -3.39910761e-02f, -5.87070733e-02f, -2.77830251e-02f, -5.20511530e-02f, -1.42342791e-01f, -6.44746497e-02f, 1.44459322e-01f,
  -1.24956034e-01f, -1.46800196e-02f, -1.92154087e-02f, 1.59442017e-03f, -1.82490498e-01f, -2.97807101e-02f, -6.76859468e-02f, 2.20589824e-02f, -8.25719442e-03f, 2.09904835e-02f,
  7.47955814e-02f, 1.84402452e-03f, -4.32996601e-02f, 2.11418103e-02f, 4.23350893e-02f, -6.73158318e-02f, 4.76378873e-02f, 4.86025363e-02f, -1.11438096e-01f, 2.00655013e-01f,
  -1.35721594e-01f, -6.57838956e-02f, 5.74982353e-02f, -4.93132807e-02f, 5.61593734e-02f, 3.96533646e-02f, -1.87552236e-02f, 5.23980819e-02f, -9.74491090e-02f, -1.38512790e-01f,
  -2.92401426e-02f, -4.13032472e-02f, -3.86712775e-02f, -8.05321336e-02f, 2.77755614e-02f, 2.80451011e-02f, 1.37177452e-01f, 1.11222997e-01f, -4.45050746e-02f, 4.33493257e-02f,
  1.92582351e-03f, 1.40034452e-01f, -3.93324271e-02f, -5.80299832e-02f, -1.04677081e-01f, 9.90553945e-02f, 1.66259229e-03f, 1.05482876e-01f, -7.73085356e-02f, 8.66916254e-02f,
  1.41252324e-01f, -2.08465517e-01f, 1.32095721e-02f, 2.39578336e-02f, -7.67817944e-02f, 1.30144969e-01f, 6.99936450e-02f, 1.23959538e-02f, -7.94646516e-02f, 1.14456251e-01f,
  8.82176161e-02f, 3.72145185e-03f, 9.25429538e-02f, -1.26693994e-01f, -6.27961755e-02f, -7.98980892e-03f, -5.80588132e-02f, -9.11070779e-02f, -1.19390693e-02f, -9.00013745e-02f,
  2.62066841e-01f, -4.60489467e-02f, -2.39148811e-01f, -2.44209301e-02f, -2.24893183e-01f, -1.60297394e-01f, -1.31649747e-01f, -4.08297889e-02f, 1.42028809e-01f, -3.31425108e-02f,
  1.15311975e-02f, 1.25593022e-01f, 1.10484704e-01f, -9.41582471e-02f, 1.36544794e-01f, 8.55027884e-02f, 7.21985288e-03f, -2.95413937e-02f, 2.71277539e-02f, 4.70773950e-02f,
  5.04167974e-02f, -8.89856145e-02f, -9.94253159e-02f, -1.33338735e-01f, -2.72088528e-01f, -5.88241778e-02f, -1.20848142e-01f, -2.40186453e-01f, -2.52003521e-01f, -6.30640164e-02f,
  -1.92910396e-02f, 1.05608903e-01f, 1.84495728e-02f, -5.31911962e-02f, 2.78245322e-02f, 1.14028808e-02f, -1.50779665e-01f, -1.36709809e-01f, -2.15609297e-02f, 1.05036475e-01f,
  3.37441452e-02f, -2.64524072e-02f, 9.86237898e-02f, -3.54534537e-02f, -9.77903157e-02f, -2.78256536e-02f, 1.37640140e-03f, -2.92802937e-02f, 1.18149235e-03f, -2.60551497e-02f,
  5.85500412e-02f, -5.93755506e-02f, -4.29335535e-02f, -1.80585254e-02f, 2.58775428e-02f, 1.43622058e-02f, -8.20760578e-02f, -2.45701689e-02f, 3.47179249e-02f, 4.27912883e-02f,
  2.31405739e-02f, -3.28794755e-02f, -2.57123392e-02f, -6.40368760e-02f, -4.00491804e-02f, -4.24338010e-04f, 4.39469777e-02f, -2.16572937e-02f, 9.43424180e-02f, -4.96224910e-02f,
  -4.27357256e-02f, 7.02710971e-02f, 6.20619133e-02f, -2.27712803e-02f, -5.54655166e-03f, 6.37813658e-02f, -1.06321862e-02f, -1.33069167e-02f, 1.78278200e-02f, -8.03980678e-02f,
  -5.30838855e-02f, 3.21222693e-02f, -2.95468811e-02f, -3.67423370e-02f, -2.77214069e-02f, 9.54740420e-02f, 1.19430602e-01f, 1.03825964e-02f, -5.74709624e-02f, 2.43064500e-02f,
  6.80247396e-02f, 1.00589134e-01f, -1.22735323e-03f, -2.80417837e-02f, -9.61458683e-02f, 1.02343097e-01f, -4.19815890e-02f, 2.19591558e-02f, 3.39990780e-02f, 1.12649716e-01f,
  -7.15725571e-02f, 8.46259817e-02f, 3.54290307e-02f, -1.31543472e-01f, -2.53799949e-02f, 5.91840744e-02f, 6.46940768e-02f, 2.65334602e-02f, -5.58260195e-02f, 4.93366532e-02f,
  6.19129911e-02f, 7.66092315e-02f, 2.15332285e-02f, 1.70019343e-02f, -3.73892412e-02f, 6.01605028e-02f, -2.46351794e-03f, 7.98548292e-03f, 1.61056314e-02f, -4.05356325e-02f,
  -3.05667877e-01f, -1.51373804e-01f, 2.98893511e-01f, -2.42101595e-01f, 1.12809636e-01f, 1.03866130e-01f, 1.01560771e-01f, -8.18962455e-02f, -3.52360159e-01f, -2.22906888e-01f,
  -3.48963737e-02f, -1.66935418e-02f, 1.77816778e-01f, -1.37017041e-01f, 3.57299149e-01f, 1.40746534e-01f, -1.58879519e-01f, -8.44802782e-02f, 7.23405555e-02f, 1.40420914e-01f,
  -4.62453067e-02f, -1.37332827e-01f, 3.59251410e-01f, 1.11218236e-01f, 4.75299545e-03f, -1.79224443e-02f, 6.82461709e-02f, 2.57686645e-01f, -9.86535996e-02f, 1.88994169e-01f,
  1.19005758e-02f, 2.27689166e-02f, 5.27283698e-02f, -2.65649017e-02f, 7.05487132e-02f, -1.32520879e-02f, 3.51085886e-02f, 1.37387887e-01f, -6.29999265e-02f, -8.47469419e-02f,
  -7.54826292e-02f, -3.74538335e-03f, -2.88821030e-02f, 2.78699864e-02f, -1.00723036e-01f, -1.22649945e-01f, 5.30696847e-02f, -4.27471064e-02f, -6.30585402e-02f, 8.50773081e-02f,
  1.53776668e-02f, -5.69761358e-02f, -1.15238480e-01f, -2.62405574e-02f, -1.18120052e-02f, 1.33310454e-02f, -1.55691067e-02f, 3.29497308e-02f, -7.58678615e-02f, -1.53815504e-02f,
  -2.50126943e-02f, 9.67720058e-03f, -1.29428664e-02f, -3.98721732e-02f, 8.43811929e-02f, -5.77589720e-02f, -3.42477262e-02f, -9.52252932e-03f, 4.05954104e-03f, -1.32623643e-01f,
  5.31747304e-02f, -1.12339882e-02f, 4.43350896e-02f, -1.85583860e-01f, -8.38270411e-03f, -6.97907507e-02f, 6.84669241e-02f, 5.38831837e-02f, -6.58735484e-02f, -1.69063210e-02f,
  -5.33110686e-02f, -1.03834689e-01f, -8.07875674e-03f, -3.85556854e-02f, -3.40307504e-02f, -3.88322137e-02f, 3.60951968e-03f, 5.13400063e-02f, 4.52292748e-02f, 1.20900653e-01f,
  -4.13038060e-02f, 5.20136729e-02f, 3.67058069e-02f, -3.51694636e-02f, 2.23576222e-02f, 2.14227736e-02f, -2.68082768e-02f, -1.83600694e-01f, -6.64968938e-02f, 3.59063782e-02f,
  -9.15835649e-02f, 5.21876663e-02f, -3.34222876e-02f, -5.01582250e-02f, 2.16811360e-03f, -4.29862775e-02f, 2.68576872e-02f, -8.63094926e-02f, -3.76705751e-02f, -8.91000964e-03f,
  4.39599417e-02f, 5.30935824e-02f, 7.15425122e-05f, 1.27536178e-01f, -9.81088132e-02f, 1.33711714e-02f, 8.32644477e-03f, -3.13863307e-02f, -9.78015363e-03f, -6.35533258e-02f,
  -2.99596608e-01f, 3.02803755e-01f, -1.25748858e-01f, -1.22635536e-01f, -4.14218977e-02f, -2.47372970e-01f, -2.52783179e-01f, -1.67516358e-02f, 7.14046434e-02f, 9.46390256e-02f,
  -1.31337434e-01f, 1.96085066e-01f, 1.35546515e-03f, 1.38047547e-03f, -2.02615350e-01f, 1.19495383e-02f, -1.90436795e-01f, -1.64937466e-01f, 3.40777561e-02f, -1.04521671e-02f,
  2.66553331e-02f, -5.60065964e-03f, -7.67174214e-02f, 1.21484950e-01f, -9.02511925e-02f, -3.19149680e-02f, -8.59716162e-02f, 8.51212144e-02f, -1.82297722e-01f, -1.86397824e-02f,
  -1.56815454e-01f, -1.20836459e-02f, -2.20471714e-02f, -3.54711413e-02f, -1.88373879e-01f, 4.78876382e-03f, -7.19173327e-02f, 5.07905427e-03f, -1.49583489e-01f, -5.05668856e-02f,
  1.07600056e-01f, -1.19643472e-02f, -5.07733412e-02f, 3.81091610e-02f, -9.00073647e-02f, 4.17619161e-02f, -7.41741210e-02f, -1.10893168e-01f, 4.89561446e-02f, 7.80770332e-02f,
  7.96024054e-02f, -1.59971174e-02f, -6.27120817e-03f, 2.15869695e-02f, -1.43924698e-01f, -1.40891060e-01f, -9.83009562e-02f, 1.94773991e-02f, 7.95083959e-03f, -5.70411384e-02f,
  6.14146702e-02f, -8.25585872e-02f, 2.45546196e-02f, -2.12668572e-02f, 2.90452093e-02f, -5.44448048e-02f, 9.90717672e-03f, -8.74485373e-02f, 8.50769598e-03f, -2.55003255e-02f,
  1.54146468e-02f, 7.24766403e-02f, 3.11151650e-02f, -1.18229464e-01f, -1.81947779e-02f, -5.65085858e-02f, 2.68135630e-02f, 8.40437189e-02f, 3.94082256e-02f, 9.58926529e-02f,
  -7.74316164e-03f, -9.38634947e-02f, 1.87309667e-01f, 1.91432741e-02f, 5.98138571e-02f, -4.64245342e-02f, 6.43914714e-02f, 1.32619634e-01f, 1.17307724e-02f, 2.35065240e-02f,
  -3.68266910e-01f, -1.94782421e-01f, -1.06315471e-01f, 2.90762889e-03f, 1.79951675e-02f, 3.87228504e-02f, -2.35172119e-02f, -9.68169197e-02f, -7.75115937e-02f, 5.38737178e-02f,
  2.98640262e-02f, 2.97448598e-02f, -1.57477096e-01f, -7.80577958e-02f, 6.29806705e-03f, -4.09697108e-02f, -1.09573156e-01f, -7.89296702e-02f, -1.56357288e-01f, -2.57740938e-03f,
  -6.95997942e-03f, -1.11745419e-02f, 8.27355310e-02f, -5.20473570e-02f, -6.87678605e-02f, 6.55780872e-03f, 1.14804851e-02f, 1.80761758e-02f, -4.00453992e-02f, -2.67650411e-02f,
  -6.83896765e-02f, 1.72616795e-01f, 2.92939514e-01f, 2.03633338e-01f, -3.90268713e-02f, -3.60829592e-01f, -3.53626311e-01f, 1.24615125e-01f, -4.65210266e-02f, -3.02729048e-02f,
  -3.71947363e-02f, 1.96690232e-01f, -7.55523518e-02f, 5.99913970e-02f, -5.98331429e-02f, -1.20779030e-01f, -4.80757952e-02f, 6.10368289e-02f, 8.71798620e-02f, 5.90363108e-02f,
  6.75225258e-02f, 5.07057011e-02f, 2.00149402e-01f, 1.82611942e-01f, 7.68305361e-02f, 2.33611479e-01f, 1.70229897e-01f, -4.25385721e-02f, 2.41847038e-01f, 4.03869106e-03f,
  -1.46390349e-01f, 1.46297827e-01f, 5.36359288e-02f, -2.06357893e-02f, 7.03479648e-02f, -7.03028589e-02f, -4.27509174e-02f, -9.33261514e-02f, 7.54686296e-02f, 1.01148777e-01f,
  -2.70366203e-02f, -2.02006586e-02f, 3.50332744e-02f, 3.44683528e-02f, -5.02845319e-03f, 1.25940358e-02f, 1.24553584e-01f, 8.89351666e-02f, 1.55988738e-01f, -8.34068507e-02f,
  1.15919240e-01f, -2.06063949e-02f, -3.70307900e-02f, -3.35618779e-02f, 1.06873937e-01f, 9.95135754e-02f, 4.54291888e-02f, -7.28091449e-02f, 2.24353047e-03f, 3.77379637e-03f,
  -1.38773903e-01f, -7.38635138e-02f, 1.77213788e-01f, 4.18152735e-02f, 4.56949808e-02f, 2.85240803e-02f, 9.37598720e-02f, 4.40236740e-03f, -3.69454175e-02f, -2.65948605e-02f,
  -6.06936179e-02f, 4.43548225e-02f, -1.13917343e-01f, 2.70915050e-02f, 7.99543187e-02f, 5.78362159e-02f, -2.83937007e-02f, 6.57244399e-03f, -1.81440320e-02f, -1.61788650e-02f,
  5.82077503e-02f, 5.63933849e-02f, 4.36815294e-03f, -8.33382979e-02f, -1.15470931e-01f, 2.00002212e-02f, 3.56256105e-02f, -5.54653555e-02f, 6.75428435e-02f, -6.76108450e-02f,
  -3.10758427e-02f, 2.12742895e-01f, 6.16245754e-02f, 3.89867695e-03f, 4.13740538e-02f, -1.22402243e-01f, 6.07428215e-02f, -1.38927782e-02f, 6.88299984e-02f, 6.29084408e-02f,
  5.51290773e-02f, -1.42125441e-02f, -4.67017144e-02f, -4.81152488e-03f, -1.21477872e-01f, -3.88563983e-02f, 8.24697092e-02f, 5.25484271e-02f, 1.99150309e-01f, -1.28601063e-02f,
  1.35297820e-01f, -1.21863991e-01f, 7.24507496e-02f, 1.81184504e-02f, -5.13064004e-02f, -1.43384580e-02f, -5.39234951e-02f, -4.85747419e-02f, 6.34307638e-02f, 7.14593381e-02f,
  2.21426070e-01f, 1.85307339e-01f, 2.80574352e-01f, 1.89526260e-01f, -6.01589307e-02f, 8.25437978e-02f, 2.48724893e-02f, 1.10639028e-01f, 2.15981230e-01f, 5.87975271e-02f,
  -1.09728597e-01f, 2.09502220e-01f, -1.14852779e-01f, 1.28566414e-01f, -2.31480777e-01f, -1.53480008e-01f, -2.74413731e-02f, -8.10038596e-02f, -6.52994663e-02f, -1.35150664e-02f,
  -8.60541034e-03f, -2.72255272e-01f, 5.44710830e-02f, -9.96219292e-02f, 2.02584177e-01f, -2.51595229e-02f, -2.39985526e-01f, -2.70161241e-01f, 1.25164092e-01f, -1.65771976e-01f,
  -1.07761184e-02f, -1.10358885e-02f, 1.32143393e-01f, 8.27227756e-02f, 6.99985325e-02f, 4.80140857e-02f, 7.81327188e-02f, -9.79814827e-02f, -4.71353456e-02f, 1.29283756e-01f,
  1.03283517e-01f, 8.55764002e-02f, 2.62607839e-02f, 3.39526311e-02f, 1.11900508e-01f, 1.09294541e-01f, 1.39059752e-01f, 1.85083538e-01f, 1.31161243e-01f, 6.80168271e-02f,
  1.76998571e-01f, 8.73446167e-02f, 1.53239667e-01f, 3.60205304e-04f, -1.10507822e-02f, -1.95325688e-02f, -7.53388554e-03f, -3.03280214e-03f, 6.15817271e-02f, 2.70866156e-02f,
  -1.23839341e-01f, 1.66096985e-02f, 6.31109402e-02f, 6.23726174e-02f, -4.80292812e-02f, -5.53716905e-02f, 2.01713704e-02f, -9.12911743e-02f, -3.07870451e-02f, 4.70548943e-02f,
  -1.02204740e-01f, -1.40739679e-02f, -8.56519416e-02f, 5.94938956e-02f, -5.46645410e-02f, 5.17805517e-02f, -7.51005411e-02f, 5.18681556e-02f, 3.08820754e-02f, -5.68742445e-03f,
  -1.37011737e-01f, -1.23968720e-02f, 2.18211045e-03f, 8.57135747e-03f, -1.98283996e-02f, 3.47357541e-02f, 8.27041939e-02f, 3.34908068e-02f, 3.22600417e-02f, -2.13977888e-01f,
  -7.98625126e-02f, -2.05342397e-01f, -1.70780085e-02f, 2.77695414e-02f, -1.17556140e-01f, 4.88666706e-02f, -5.80117330e-02f, 1.47586465e-01f, 1.39001999e-02f, 6.64727315e-02f,
  1.64391007e-02f, 8.89874324e-02f, 7.42470622e-02f, 6.61653280e-02f, -1.39841124e-01f, -5.03849387e-02f, -8.81019235e-02f, -9.39793959e-02f, -1.03706047e-01f, -2.44757421e-02f,
  5.40424958e-02f, 1.58759430e-02f, 4.49796990e-02f, -5.53489588e-02f, 3.70601416e-02f, -1.10420264e-01f, 6.81831241e-02f, 3.06335855e-02f, -2.87019648e-02f, -1.32678315e-01f,
  -2.49099374e-01f, 2.84351826e-01f, 4.30130661e-02f, 2.01531649e-01f, -1.15662925e-01f, 3.67186993e-01f, 4.08188820e-01f, 9.84504372e-02f, 3.39599103e-01f, 1.86999410e-01f,
  -4.37527255e-04f, 6.38822392e-02f, 1.25461563e-01f, 1.60018042e-01f, 1.81627110e-01f, 2.82522351e-01f, 2.05445215e-01f, 1.99912086e-01f, 7.51762241e-02f, 7.28648379e-02f,
  2.89755519e-02f, 1.12219125e-01f, -1.35318832e-02f, -8.08841214e-02f, -1.15234032e-01f, -8.22860748e-03f, -5.33654913e-02f, -3.48655358e-02f, 1.74494721e-02f, 1.35108709e-01f,
  6.40389770e-02f, -8.53834525e-02f, -9.36821178e-02f, 7.26175606e-02f, 4.53158133e-02f, -7.95539394e-02f, 6.72916770e-02f, -2.20808741e-02f, -6.71115667e-02f, -1.46272425e-02f,
  -3.83332148e-02f, -3.97780687e-02f, 1.18429311e-01f, -2.97416728e-02f, -1.33295313e-01f, -6.24673478e-02f, -1.42877661e-02f, -6.16896674e-02f, -2.85676084e-02f, -5.13367616e-02f,
  -8.24738815e-02f, -8.12955350e-02f, -5.70579097e-02f, 7.25126937e-02f, -9.24006924e-02f, -1.13290083e-02f, 1.03084922e-01f, 6.75055757e-02f, 1.62717905e-02f, 9.10016373e-02f,
  -2.91017108e-02f, 1.80195123e-02f, -1.27692699e-01f, -5.37788160e-02f, -1.72207144e-03f, -6.76738098e-02f, -1.69265717e-02f, 6.32246360e-02f, -1.88061930e-02f, -1.14468867e-02f,
  6.97202459e-02f, -1.08361533e-02f, -2.32580788e-02f, -6.02893271e-02f, 3.25283292e-03f, 1.17444180e-01f, -3.03782169e-02f, 3.27436551e-02f, 1.13027126e-01f, 1.48759712e-03f,
  7.84237087e-02f, 1.24050044e-01f, -4.37060073e-02f, 7.93921798e-02f, 1.72034651e-02f, -5.93929216e-02f, 7.76730757e-03f, -9.66310725e-02f, 2.07537301e-02f, -3.80790383e-02f,
  1.77759960e-01f, 2.50963330e-01f, 1.92712266e-02f, -6.18672110e-02f, -2.96048895e-02f, -4.60694619e-02f, 1.25871018e-01f, -6.20681532e-02f, 1.22295856e-01f, -1.59503147e-02f,
  8.99292994e-03f, 2.91906614e-02f, 7.73128346e-02f, 5.03493659e-02f, 5.92077561e-02f, 6.81143329e-02f, 3.97998989e-02f, -3.95926507e-03f, 1.17086969e-01f, -3.17331664e-02f,
  -2.59737000e-02f, 1.12313017e-01f, -7.76932314e-02f, -9.28179324e-02f, 1.91179924e-02f, 2.31743734e-02f, 6.75336197e-02f, -2.38257721e-02f, -5.90244681e-02f, 5.62133081e-02f,
  -4.67602313e-02f, 6.18698560e-02f, -2.26171985e-01f, -5.98559417e-02f, -6.37018755e-02f, -4.60305214e-01f, -2.58575648e-01f, -8.19972903e-02f, 2.07971156e-01f, 1.11217320e-01f,
  2.51089782e-02f, 1.10620640e-01f, 2.14901716e-01f, 4.78289323e-03f, -3.04070383e-01f, 9.27391350e-02f, -3.13766062e-01f, -5.46284653e-02f, 7.66243339e-02f, -7.89734125e-02f,
  -2.42235456e-02f, 5.05267782e-03f, -2.32467711e-01f, 9.79771651e-03f, -2.01222509e-01f, 4.65881266e-02f, -7.70082846e-02f, 1.27005074e-02f, -1.23752683e-01f, -9.15304050e-02f,
  -8.52712691e-02f, 2.80294687e-01f, 1.71385929e-02f, -5.23989797e-02f, -1.01808399e-01f, -9.97997075e-02f, -6.42891154e-02f, 4.89181317e-02f, -5.52046932e-02f, -4.60408218e-02f,
  4.54847813e-02f, 2.81433687e-02f, -2.46633738e-02f, 6.71900287e-02f, 3.81495543e-02f, -5.72327264e-02f, 1.01244353e-01f, -5.31736715e-03f, -1.86050441e-02f, -3.60770943e-03f,
  -1.55335972e-02f, 7.45195374e-02f, -1.09387264e-01f, 2.55970117e-02f, 1.57214720e-02f, -1.54195530e-02f, -5.98212183e-02f, -1.31561561e-02f, -2.18228009e-02f, -1.30730895e-02f,
  3.31288017e-02f, -1.86166525e-01f, -7.88448676e-02f, 2.23547593e-02f, -2.20943075e-02f, 6.86085448e-02f, 2.88628284e-02f, 1.42152514e-02f, -6.55066818e-02f, -3.74123566e-02f,
  1.73941255e-02f, 6.05335906e-02f, -3.93346418e-03f, -2.17726249e-02f, -1.25419185e-01f, 4.04393263e-02f, -1.15512190e-02f, 1.11139394e-01f, -6.08553812e-02f, -9.19723585e-02f,
  -9.70803481e-03f, -3.72804552e-02f, 1.22906696e-02f, -2.26301397e-03f, -3.57831754e-02f, 7.75520429e-02f, 2.99454983e-02f, -5.42869382e-02f, -1.54397823e-03f, -8.48758370e-02f,
  -3.76168378e-02f, -3.23741101e-02f, -2.60233227e-02f, 2.85776500e-02f, 2.59333979e-02f, -3.04389223e-02f, -3.25591750e-02f, -4.35753874e-02f, -1.47873119e-01f, -6.96043149e-02f,
  -1.02314748e-01f, 5.16765676e-02f, -3.66071872e-02f, 3.53358053e-02f, -6.41604438e-02f, -1.47614673e-01f, 2.44863448e-03f, 6.21211976e-02f, -1.18568897e-01f, -5.70556223e-02f,
  3.43369916e-02f, -1.34638250e-02f, 4.68737185e-02f, -1.61049161e-02f, -5.24892993e-02f, 6.54017031e-02f, -3.88704129e-02f, 6.67142794e-02f, -6.36550337e-02f, -5.39927296e-02f,
  1.79402698e-02f, -3.47148955e-01f, 5.16021140e-02f, 3.38879704e-01f, 2.51729935e-01f, -1.59031972e-01f, -1.97072953e-01f, 1.22503161e-01f, 2.37758793e-02f, -2.55635917e-01f,
  1.42122954e-01f, -7.36380368e-02f, -2.38249436e-01f, 7.59340078e-02f, 2.20545933e-01f, -1.70482218e-01f, 1.09962046e-01f, 1.02251431e-03f, 1.18399978e-01f, 3.48761864e-02f,
  2.52593696e-01f, 1.69023886e-01f, 1.42100647e-01f, 1.30955443e-01f, 7.44403452e-02f, 1.58354089e-01f, 2.07980528e-01f, -5.83759882e-02f, 1.23797625e-01f, -3.63095365e-02f,
  -3.66165973e-02f, 1.48773845e-02f, -6.93561509e-02f, -8.56267475e-03f, -1.85149629e-02f, -6.83849975e-02f, 1.11425966e-01f, -9.29737762e-02f, -2.11134274e-02f, -3.38453799e-03f,
  -2.52296235e-02f, 8.25589746e-02f, 6.11636378e-02f, -1.97248179e-02f, 4.32506986e-02f, 8.73457566e-02f, 5.44947386e-02f, 4.90115136e-02f, 3.42708081e-02f, 5.62514290e-02f,
  1.31330580e-01f, -1.62790678e-02f, -4.79830354e-02f, -7.80268610e-02f, 7.97261223e-02f, 1.07421987e-01f, 1.38960674e-01f, -6.46228530e-03f, 2.28144024e-02f, 5.99498004e-02f,
  -9.16797817e-02f, -4.16227505e-02f, 6.20011147e-03f, 3.81372832e-02f, 7.58415908e-02f, 1.51257375e-02f, -3.60778905e-02f, 1.29645364e-02f, -2.32246239e-02f, -5.71265966e-02f,
  1.01553619e-01f, 3.86366621e-02f, 5.80400601e-02f, 1.04245320e-01f, 5.52092232e-02f, 8.47067684e-02f, -1.77702424e-03f, 9.58180130e-02f, 8.06236733e-03f, 1.21010043e-01f,
  5.40550463e-02f, 5.14757894e-02f, -3.92364226e-02f, 2.86872108e-02f, -7.56292343e-02f, 7.69279990e-03f, 8.64576325e-02f, -9.03647169e-02f, 3.36081162e-02f, -3.63490619e-02f,
  -1.25452280e-01f, -1.39456630e-01f, -3.17847021e-02f, 6.64029224e-03f, -7.56765669e-03f, -2.03634761e-02f, 1.39239222e-01f, -3.09448242e-02f, -9.06145126e-02f, 3.22226831e-03f,
  5.01561426e-02f, 9.99533013e-02f, -1.11906454e-01f, 4.04049903e-02f, -6.59838691e-02f, -6.96785934e-03f, -6.37625903e-02f, -1.30172268e-01f, 6.49599954e-02f, 8.70628133e-02f,
  6.86302334e-02f, -3.20164412e-02f, 6.15195930e-02f, -5.90984710e-03f, 9.78125706e-02f, -5.21781631e-02f, 1.10762492e-02f, -5.15246205e-02f, -2.23618280e-02f, 3.24446522e-02f,
  -2.12015823e-01f, -5.19235618e-02f, 2.63444364e-01f, -1.33616805e-01f, -6.70615435e-02f, 2.86207587e-01f, 3.05880845e-01f, -2.24179700e-01f, -2.38007650e-01f, -1.91255301e-01f,
  -7.36062825e-02f, 1.57870203e-01f, 2.86126554e-01f, 3.51600833e-02f, 4.14099604e-01f, 2.70506710e-01f, -8.41615871e-02f, 3.78249362e-02f, -3.35883275e-02f, -1.77232414e-01f,
  -5.83343580e-02f, -2.49652863e-01f, 1.81689605e-01f, -2.06704140e-01f, -4.60219607e-02f, -5.34597673e-02f, -7.21225217e-02f, 2.00445980e-01f, -9.82629731e-02f, 9.37471315e-02f,
  2.60976572e-02f, -2.10038513e-01f, -7.64071867e-02f, 7.71967545e-02f, 6.44223168e-02f, 2.05988698e-02f, 4.83694923e-04f, 1.63284570e-01f, 3.40618566e-02f, -1.31283879e-01f,
  1.25095099e-01f, 3.92343402e-02f, -7.85635933e-02f, 5.84586896e-02f, -2.78397836e-02f, 8.59936606e-03f, -7.93042481e-02f, 9.84539613e-02f, 3.12283952e-02f, 1.31104216e-01f,
  7.55565539e-02f, -3.96226486e-03f, 1.19274631e-01f, -2.81382306e-03f, -2.01840885e-02f, -4.10889499e-02f, 1.33800590e-02f, 1.25440255e-01f, 5.94259538e-02f, -3.37981209e-02f,
  4.39997278e-02f, -8.23186710e-02f, -7.06501827e-02f, 3.65438983e-02f, 2.66694017e-02f, -9.16291773e-02f, 1.30945578e-01f, 6.13744603e-03f, -4.55094837e-02f, 6.90641776e-02f,
  8.05918425e-02f, -1.01914275e-02f, 6.22626133e-02f, 1.66245624e-02f, -7.30563775e-02f, -2.58303862e-02f, 2.30359826e-02f, 2.11739521e-02f, -2.45952024e-03f, -3.79799157e-02f,
  5.85085750e-02f, 1.61083695e-02f, 4.71775122e-02f, -3.01408526e-02f, 2.50756787e-03f, 7.42923245e-02f, -2.75398269e-02f, 1.03926927e-01f, -4.48753387e-02f, 3.72262821e-02f,
  -2.33686790e-02f, -1.29872128e-01f, 2.63785105e-02f, -7.01926509e-03f, -5.29656932e-02f, 4.20187041e-02f, 1.30374312e-01f, 1.33232726e-02f, -6.04868568e-02f, -4.96173166e-02f,
  3.41657437e-02f, 8.31480846e-02f, -1.80462636e-02f, -5.36951795e-02f, 6.92295879e-02f, -8.29939917e-03f, -3.28762755e-02f, 3.94506613e-04f, -5.28581366e-02f, 7.08852708e-03f,
  8.49015266e-02f, -8.84133354e-02f, 4.09371629e-02f, -1.47083774e-01f, -5.24660125e-02f, -3.62603851e-02f, -8.37189183e-02f, 7.91944489e-02f, 6.95078671e-02f, 7.76351094e-02f,
  1.35332093e-01f, -7.08047003e-02f, 1.80786014e-01f, 1.34793362e-02f, 1.93268150e-01f, 2.53495097e-01f, 3.90397966e-01f, 8.17705840e-02f, 1.68600380e-01f, -2.53514111e-01f,
  -9.07246545e-02f, -6.21970091e-03f, 4.96037379e-02f, -8.33128467e-02f, 4.14849550e-01f, 2.09178656e-01f, 4.45156880e-02f, -6.74514100e-02f, -3.12805250e-02f, -1.40229329e-01f,
  -6.23088442e-02f, -2.11584926e-01f, 1.89923346e-01f, -3.03613961e-01f, -9.69790369e-02f, -3.71292755e-02f, -6.65916502e-02f, 1.63527310e-01f, -1.43375307e-01f, 9.84207466e-02f,
  3.90655128e-03f, -7.01222345e-02f, -2.48293877e-02f, -4.10484485e-02f, -1.24301895e-01f, -3.42809707e-02f, 3.03788930e-02f, 8.84895548e-02f, 3.91661674e-02f, -4.38899584e-02f,
  4.07235250e-02f, -3.06048221e-03f, -5.97131206e-03f, 3.08062788e-03f, 7.76583403e-02f, 1.00058913e-01f, 9.29348450e-03f, -7.99578503e-02f, 4.36301902e-02f, 1.18990289e-02f,
  7.00250939e-02f, -8.27018986e-04f, 5.59374224e-03f, 6.61483705e-02f, -1.52952624e-02f, -1.54975178e-02f, 3.08564100e-02f, 5.74720278e-02f, 5.88999316e-02f, 4.32066649e-04f,
  4.33341265e-02f, 3.54173928e-02f, -9.34200734e-02f, -1.12844389e-02f, -5.50386496e-02f, -1.01313934e-01f, -3.24956700e-02f, -1.16935655e-01f, -6.08928613e-02f, 4.08793837e-02f,
  7.25830644e-02f, 4.85777631e-02f, 1.45091757e-01f, 1.26169845e-01f, -1.32154003e-01f, -9.59239304e-02f, 1.53945219e-02f, -9.33688581e-02f, 3.03215366e-02f, 1.89439803e-02f,
  7.53871650e-02f, -2.30250247e-02f, -8.55714455e-02f, 3.52545120e-02f, 1.31527800e-02f, 7.11511075e-02f, -6.56023473e-02f, 5.26134185e-02f, -9.84801538e-03f, 5.56088798e-02f,
  -6.56582415e-02f, -1.95800260e-01f, -4.21638377e-02f, -1.31800741e-01f, -1.40912831e-01f, -8.21614638e-02f, 1.14656821e-01f, -8.09890106e-02f, -9.18494612e-02f, -6.15711324e-02f,
  -2.31933594e-02f, -3.84410992e-02f, -5.53686172e-02f, 7.82768503e-02f, -6.73588691e-03f, -2.21855249e-02f, 6.44271672e-02f, -7.30503723e-02f, 1.03259213e-01f, -9.37239155e-02f,
  -6.01650886e-02f, -4.89848405e-02f, 6.48170114e-02f, -5.98217286e-02f, -1.15066715e-01f, -8.64937995e-03f, -4.24124300e-02f, 5.74302748e-02f, -5.76299839e-02f, -3.97841856e-02f,
  -3.81788254e-01f, 3.22854519e-01f, 2.69725412e-01f, 4.76472005e-02f, 6.42546266e-02f, 2.67355919e-01f, 1.62450269e-01f, 1.48714513e-01f, 3.18256408e-01f, 5.90074062e-02f,
  -1.55144915e-01f, -5.10233082e-02f, 2.93497518e-02f, 1.45777419e-01f, -7.87761584e-02f, 1.58320397e-01f, 1.81235090e-01f, 1.85215428e-01f, 1.22385532e-01f, -2.20857114e-02f,
  -2.08902750e-02f, -1.27463877e-01f, -1.39212823e-02f, -5.04710786e-02f, -1.16683029e-01f, 1.74870603e-02f, -8.96188095e-02f, 5.20114750e-02f, -3.88486497e-02f, 5.10297678e-02f,
  -1.56852439e-01f, -7.03214183e-02f, -1.14863582e-01f, 5.92470989e-02f, 1.27809299e-02f, 6.33802824e-03f, -2.11437941e-02f, -2.60071140e-02f, 4.21671420e-02f, 7.81632513e-02f,
  -4.39470150e-02f, -1.20622247e-01f, -1.49157336e-02f, 4.09417860e-02f, 1.33351073e-01f, 1.75278150e-02f, 3.81175205e-02f, 1.25335112e-01f, 2.02487316e-02f, 1.80224329e-02f,
  -8.64720270e-02f, 4.52696830e-02f, 5.07046245e-02f, 7.74254352e-02f, -6.33061752e-02f, 6.63832948e-02f, 9.86690670e-02f, -5.44973277e-03f, -8.54477286e-02f, 8.79164040e-02f,
  7.49885663e-02f, 3.70172001e-02f, -6.03387579e-02f, 4.24037874e-03f, -1.20241372e-02f, -9.07071307e-03f, -6.93585277e-02f, -2.33389199e-01f, 2.43204720e-02f, 4.79417145e-02f,
  -2.46867770e-03f, 3.95745970e-02f, -1.14465086e-02f, 5.01234941e-02f, -4.44465540e-02f, 1.23979807e-01f, 1.31493002e-01f, 6.13306016e-02f, 5.59151452e-03f, -2.46118028e-02f,
  9.58087817e-02f, 5.45134172e-02f, -1.57369077e-01f, -4.40132916e-02f, 6.46313354e-02f, -1.27737876e-02f, 2.78176535e-02f, -4.50833850e-02f, -1.27476409e-01f, -9.65138490e-04f,
  3.13347988e-02f, 6.67154193e-02f, -6.61972314e-02f, -1.51225971e-02f, -1.64756514e-02f, -9.99976471e-02f, 1.34092182e-01f, -8.76758248e-02f, 1.45683303e-01f, -4.00276342e-03f,
  1.00247622e-01f, -2.99730282e-02f, -5.82890846e-02f, 4.83256616e-02f, 8.97209719e-03f, -1.01666987e-01f, -4.55362126e-02f, 6.34685084e-02f, -4.99180369e-02f, -7.38793164e-02f,
  -1.06534623e-01f, -4.70368452e-02f, -7.71441385e-02f, -1.02570243e-01f, 5.40529098e-03f, 4.28366549e-02f, -5.47871217e-02f, -1.91611145e-02f, -7.91996792e-02f, 6.80072978e-02f,
  4.43225324e-01f, -8.75831991e-02f, -1.94234308e-02f, 2.02232093e-01f, 5.95146716e-02f, 5.91906272e-02f, 1.44546077e-01f, 5.39651066e-02f, 2.46423692e-01f, -1.78389736e-02f,
  8.22258834e-03f, 9.68122557e-02f, -1.16729170e-01f, 7.91986138e-02f, 1.52709633e-01f, -1.36060670e-01f, 1.45520657e-01f, 5.76858735e-03f, 3.40890512e-02f, 1.08743779e-01f,
  2.62873411e-01f, 1.01942241e-01f, -1.49411827e-01f, -2.58604810e-02f, 1.13729537e-01f, -1.65317685e-03f, -8.12757835e-02f, -1.57528535e-01f, -2.86941864e-02f, -1.09312661e-01f,
  8.85716826e-02f, -2.17218380e-02f, 1.01898508e-02f, 3.39985490e-02f, -7.99357519e-02f, -1.36156427e-02f, -4.11961377e-02f, -1.20768353e-01f, 4.35696393e-02f, 6.33610412e-02f,
  -1.46013321e-02f, 1.58306696e-02f, 2.73323990e-03f, -1.74774751e-02f, 1.26297653e-01f, 4.10710871e-02f, -7.73930177e-03f, 1.71426199e-02f, -2.17053220e-02f, -1.64933177e-03f,
  3.73333544e-02f, -8.53743590e-03f, 3.91384438e-02f, -1.52113959e-01f, -4.01830897e-02f, -4.83590066e-02f, -7.23814368e-02f, -1.00016855e-01f, -2.21673818e-03f, 4.84333448e-02f,
  6.24345653e-02f, 1.63037349e-02f, -4.95994799e-02f, 7.37253157e-03f, 4.25042324e-02f, -3.35931405e-02f, 4.08135429e-02f, -6.48850724e-02f, -7.89622834e-04f, -4.77835126e-02f,
  2.43442785e-02f, 1.64881777e-02f, 2.67602708e-02f, 5.11660017e-02f, 8.29375070e-03f, 9.75422487e-02f, -2.76199784e-02f, -4.92881611e-03f, 2.20062006e-02f, 3.19543742e-02f,
  -4.48280908e-02f, 4.19598818e-02f, -2.76972223e-02f, 2.19698739e-03f, -9.18515399e-02f, 2.84430734e-03f, 6.02925308e-02f, 5.28413281e-02f, -8.02434534e-02f, -7.04081506e-02f,
  -1.73096016e-01f, -1.26945958e-01f, 5.19435778e-02f, 2.61940039e-03f, -2.85267327e-02f, 1.93106569e-02f, 7.33911172e-02f, 2.01254487e-02f, -2.48982720e-02f, 8.53459910e-02f,
  2.47993097e-02f, 6.81331232e-02f, -7.36919418e-02f, -1.04547232e-01f, -9.43932757e-02f, 2.64407303e-02f, -3.59801799e-02f, 2.79510440e-03f, 1.13257980e-02f, 7.33465403e-02f,
  -1.77607108e-02f, -5.86373173e-02f, 7.31058419e-02f, 3.85503024e-02f, -3.28964298e-03f, -1.00490503e-01f, -5.76105528e-02f, -3.53156403e-02f, -1.49528831e-01f, -1.69416405e-02f,
  5.31836152e-02f, 2.79680431e-01f, 2.40904227e-01f, 1.23118564e-01f, -1.05992466e-01f, -1.48568898e-01f, -5.55756241e-02f, -1.09225493e-02f, -1.29465433e-02f, 2.48121470e-01f,
  -1.66792050e-01f, 2.04176232e-01f, -3.96611495e-03f, -8.18668529e-02f, -2.77088493e-01f, -2.54895151e-01f, 4.42804359e-02f, 2.21215431e-02f, -1.33932605e-02f, 3.04112166e-01f,
  -3.11541408e-02f, -2.17417464e-01f, 7.61627406e-02f, -1.73663363e-01f, 1.56613037e-01f, 2.06582993e-01f, 9.72990617e-02f, -6.66452125e-02f, 2.47208253e-01f, -7.04180598e-02f,
  1.49051454e-02f, 2.60534957e-02f, 1.48324445e-01f, 3.60156335e-02f, 1.14698477e-01f, 1.31109003e-02f, 2.07924116e-02f, 8.61202460e-03f, -5.46864942e-02f, -4.45235483e-02f,
  1.12949066e-01f, 4.45304736e-02f, -3.16213109e-02f, -3.08812242e-02f, -2.12955959e-02f, 1.42404735e-02f, 8.46347958e-02f, 8.18397477e-02f, 1.26756668e-01f, 2.50684340e-02f,
  6.38459250e-02f, 1.25612721e-01f, 1.36457067e-02f, 9.26181152e-02f, 1.37924440e-02f, 4.49035503e-02f, 1.70742422e-01f, 9.08371285e-02f, 1.69526190e-01f, 4.89826091e-02f,
  1.36983544e-02f, -1.22796362e-02f, 6.31654263e-03f, 4.85249348e-02f, -6.45520836e-02f, 6.05611987e-02f, -2.67315656e-02f, -1.06481344e-01f, 1.81274172e-02f, -5.36676416e-05f,
  1.01377415e-02f, 4.92335707e-02f, 2.83850003e-02f, 4.51925732e-02f, -4.35969830e-02f, 5.93965203e-02f, -9.35260300e-03f, 8.82435590e-03f, 1.40646681e-01f, -8.09336826e-03f,
  -1.59656927e-02f, -3.49260983e-03f, 6.58968687e-02f, 3.25133502e-02f, -3.80959734e-02f, 7.51736611e-02f, 5.39234467e-02f, 2.07946077e-02f, 6.13099150e-02f, -3.71064134e-02f,
  7.09917804e-04f, 1.16792992e-01f, -2.15116404e-02f, -7.24970922e-02f, 5.79977594e-02f, 1.60019584e-02f, 1.62741765e-02f, 9.60063711e-02f, 7.66940489e-02f, -5.52344471e-02f,
  1.52957380e-01f, -7.70975426e-02f, 6.67211190e-02f, -7.82653540e-02f, -5.24749495e-02f, 1.00287661e-01f, 2.44064089e-02f, -2.51273904e-03f, 9.67014953e-02f, 5.60328998e-02f,
  9.91758704e-02f, 1.12615250e-01f, -4.25763205e-02f, 4.59960438e-02f, -2.43875049e-02f, 1.28879882e-02f, -1.13088647e-02f, 1.14398874e-01f, 1.15955500e-02f, 8.50545838e-02f,
  -2.79928604e-03f, 2.17266411e-01f, -1.41381383e-01f, 1.77964360e-01f, -6.18862547e-02f, 3.55439484e-01f, 3.92799526e-01f, -6.53288215e-02f, 1.59423828e-01f, 2.61456460e-01f,
  1.21532634e-01f, 5.60796894e-02f, 1.55847803e-01f, 1.96310073e-01f, -9.33532566e-02f, 2.14894786e-01f, 1.88664764e-01f, 1.58100784e-01f, 3.82161373e-03f, 2.33550817e-02f,
  -8.92400667e-02f, 2.46575385e-01f, -5.69235906e-02f, -6.40424937e-02f, 7.67458277e-03f, -1.47231892e-01f, -2.31442586e-01f, -2.32141033e-01f, -2.01452561e-02f, 8.02792050e-03f,
  2.77183224e-02f, 5.84665425e-02f, -7.55934790e-02f, -1.31761711e-02f, 5.70445322e-02f, -9.63781774e-02f, 8.86585284e-03f, -6.84963614e-02f, -6.77327439e-02f, 1.15579441e-01f,
  5.35492226e-02f, 6.81609735e-02f, 1.05355028e-02f, -1.33799180e-01f, -2.15705601e-03f, -1.42905107e-02f, 6.63973317e-02f, -1.54823795e-01f, 1.64891072e-02f, 3.03254556e-02f,
  1.14759989e-02f, -2.00945837e-03f, 1.56564750e-02f, 4.36420552e-02f, -1.28346652e-01f, 6.42092302e-02f, 3.53977494e-02f, -2.16206647e-02f, 5.85466363e-02f, 6.81779021e-03f,
  -3.27115208e-02f, 7.65309483e-02f, 8.87966808e-03f, -6.79536089e-02f, -5.11027919e-03f, -2.05766782e-02f, 9.23654139e-02f, 8.18530470e-02f, 6.86278269e-02f, -7.05864355e-02f,
  -4.12198901e-02f, -7.63836280e-02f, 7.03177527e-02f, 4.92921658e-02f, 4.81918305e-02f, 8.20429549e-02f, -1.04997806e-01f, -3.82913053e-02f, 5.10393456e-02f, 4.54728305e-02f,
  -2.06811577e-02f, 3.42809856e-02f, -1.00316538e-03f, 4.76982258e-02f, 9.62752923e-02f, -1.03900321e-01f, -5.08843064e-02f, -2.28366144e-02f, 1.34104714e-02f, -1.02585331e-02f,
  1.42420575e-01f, 5.20836897e-02f, 9.38688070e-02f, 8.84542987e-02f, 9.61151347e-02f, -2.17517596e-02f, 7.30595179e-03f, 5.86685687e-02f, 2.12645736e-02f, 6.60107061e-02f,
  -4.84935008e-02f, 1.30630136e-01f, -4.58392166e-02f, -1.11329585e-01f, -5.91862127e-02f, 8.24343413e-02f, 9.23641175e-02f, -2.47997530e-02f, -5.34774619e-04f, -4.93135080e-02f,
  -8.86380970e-02f, 8.46269727e-02f, -1.58311613e-02f, -3.86242792e-02f, 2.25662142e-02f, 9.81490240e-02f, -1.34094469e-02f, -8.96402169e-03f, 1.10254399e-02f, -1.75594110e-02f,
  1.90315142e-01f, -3.37706089e-01f, -2.14984670e-01f, 8.96517262e-02f, 2.46368796e-01f, 1.26224652e-01f, -1.81993499e-01f, 1.79919958e-01f, -6.79573938e-02f, -1.15879960e-01f,
  6.83709458e-02f, -5.60330115e-02f, -3.93374264e-01f, 2.17761606e-01f, 2.30637491e-01f, -1.84475943e-01f, 2.52270013e-01f, 3.46550010e-02f, -1.64767757e-01f, -1.27582774e-01f,
  5.47889657e-02f, 2.19695985e-01f, -1.04262553e-01f, 1.38784736e-01f, 1.64069980e-01f, 1.84962228e-02f, 2.08195195e-01f, -6.06048666e-02f, 2.44195804e-01f, 1.38626158e-01f,
  4.05498929e-02f, -1.39787078e-01f, 9.02950019e-03f, 5.09016067e-02f, -1.32231429e-01f, 4.44353744e-02f, -5.52325845e-02f, 9.81186181e-02f, 1.42217912e-02f, -1.10488862e-01f,
  5.44478782e-02f, 1.17811926e-01f, 2.45651118e-02f, 7.27782175e-02f, 6.68883994e-02f, 9.04596746e-02f, -3.42539325e-02f, 3.95513698e-02f, 3.68657559e-02f, -6.41476512e-02f,
  -1.48072883e-01f, 8.26176181e-02f, 3.45857106e-02f, 4.38984204e-03f, -1.10932820e-01f, 4.22891937e-02f, 3.00076697e-02f, -6.40965030e-02f, 9.48300585e-02f, 7.20252097e-02f,
  4.78740931e-02f, -1.24542536e-02f, -8.88129100e-02f, 1.06912218e-01f, -1.23887658e-02f, -1.11497259e-02f, -4.21704091e-02f, -2.36820262e-02f, -1.09441236e-01f, -5.04707359e-02f,
  -9.76894610e-03f, 5.41421175e-02f, 6.21788688e-02f, 3.92409507e-03f, -2.42133029e-02f, 1.21146567e-01f, 6.61230534e-02f, -1.28957545e-02f, -8.77977163e-02f, 6.62899464e-02f,
  4.92137112e-02f, -1.77155435e-02f, 2.88414918e-02f, 4.40969951e-02f, 9.99701694e-02f, -1.74114611e-02f, -1.12340841e-02f, 1.55314207e-02f, 1.55289080e-02f, 5.80827445e-02f,
  -2.63810754e-02f, -2.56776661e-01f, -1.11473985e-01f, 7.24165216e-02f, -1.07471779e-01f, 3.71971689e-02f, 6.80957288e-02f, 2.96568703e-02f, -5.27082719e-02f, -1.12481758e-01f,
  8.77374411e-02f, 1.00053832e-01f, 5.90193346e-02f, 5.99397272e-02f, 7.81023577e-02f, -2.18870342e-02f, -1.05111733e-01f, 2.02572555e-03f, 8.37413520e-02f, 2.38136593e-02f,
  -3.82190123e-02f, -7.08130300e-02f, -5.31126522e-02f, 2.70950776e-02f, 2.46465169e-02f, -7.27653801e-02f, -3.02040391e-03f, -7.81356841e-02f, 7.08092824e-02f, -1.17132580e-02f,
  -3.94289643e-02f, 3.28067243e-02f, -7.50546753e-02f, 1.06078975e-01f, -4.69841920e-02f, -2.48561516e-01f, -1.00073423e-02f, 1.15093619e-01f, 2.89915383e-01f, 1.08991139e-01f,
  -4.27610762e-02f, 1.08474739e-01f, 1.12550050e-01f, -1.01511419e-01f, 9.13650692e-02f, 8.91100839e-02f, -2.35363916e-01f, -1.09280579e-01f, 9.85437036e-02f, -6.56960830e-02f,
  -7.19399098e-03f, -1.92942500e-01f, -1.56295359e-01f, -8.24188888e-02f, -2.83828050e-01f, -3.20988521e-02f, -8.32608715e-02f, -1.62578316e-03f, -2.36467302e-01f, -4.48891893e-03f,
  -2.21748337e-01f, 8.29413161e-02f, -1.78820685e-01f, -4.82039228e-02f, -2.38923356e-01f, 1.80962197e-02f, 5.00702262e-02f, 9.33282003e-02f, 2.90675629e-02f, 2.50668381e-03f,
  -3.92847918e-02f, -4.85241301e-02f, 7.41833746e-02f, 1.48512408e-01f, 9.56174079e-03f, -5.70985749e-02f, -1.02353124e-02f, -1.82460174e-01f, -2.45350618e-02f, 3.34720984e-02f,
  -1.54394612e-01f, -8.14040303e-02f, -1.20219596e-01f, 4.10905890e-02f, -6.12108186e-02f, 5.67330867e-02f, -7.82465935e-02f, -2.24906001e-02f, -5.26916049e-02f, 9.06950235e-02f,
  5.42730466e-02f, 1.88929901e-01f, 1.35205062e-02f, 2.98677552e-02f, -1.70335218e-01f, -1.20589577e-01f, -1.45339668e-02f, -9.49010253e-02f, -1.52192131e-01f, -1.48155659e-01f,
  -7.10577965e-02f, 3.60961221e-02f, 2.72123702e-02f, 8.73877387e-03f, -6.42661825e-02f, 1.80283487e-02f, -4.10030074e-02f, 1.45982075e-02f, -6.37778491e-02f, 1.28544286e-01f,
  -9.82517190e-03f, -6.02358673e-03f, 6.44290373e-02f, -2.59641241e-02f, 8.63782987e-02f, 8.16804618e-02f, 1.53868526e-01f, 2.67402399e-02f, -4.60173190e-02f, 3.63266356e-02f,
  -1.83858603e-01f, 8.07197113e-03f, -1.70580633e-02f, -1.26855135e-01f, -6.01688251e-02f, 6.78348541e-02f, 7.12750247e-03f, 1.03447646e-01f, -6.31825179e-02f, 1.57374870e-02f,
  8.83843750e-03f, -6.93303905e-03f, -8.02498311e-03f, 4.58646752e-02f, -2.37223948e-03f, 2.39161830e-02f, -2.98296027e-02f, -2.63685398e-02f, -5.63738458e-02f, 6.79608509e-02f,
  -2.00258613e-01f, 2.16085929e-02f, -4.42291461e-02f, -6.57736659e-02f, -1.38827726e-01f, -6.71408623e-02f, 8.33900347e-02f, -3.49318199e-02f, 4.47237603e-02f, 9.93201323e-03f,
  3.67626809e-02f, -9.53186676e-02f, -1.81700751e-01f, -2.02874631e-01f, 1.10579975e-01f, -1.61685899e-01f, -2.33897462e-01f, -1.09478287e-01f, -9.76693034e-02f, -6.63420707e-02f,
  -8.16393793e-02f, 4.96178605e-02f, 1.26236722e-01f, -3.30672622e-01f, -3.00145112e-02f, -4.63754758e-02f, -1.86595589e-01f, -7.39047974e-02f, -1.59369782e-02f, -5.45981154e-02f,
  -1.12422056e-01f, -2.98590541e-01f, -1.43525034e-01f, 1.26525899e-02f, -1.55778125e-01f, 4.96338704e-04f, 2.44486660e-01f, 8.20058882e-02f, -9.01854336e-02f, -8.21167827e-02f,
  -8.77701193e-02f, -1.00743473e-01f, -4.86393049e-02f, -9.74115059e-02f, -3.30247879e-02f, -2.62705665e-02f, 4.28368710e-02f, -1.07798092e-01f, -1.61657948e-02f, -7.40204528e-02f,
  4.85105328e-02f, -4.30176370e-02f, -5.78092597e-02f, 1.01358764e-01f, -6.67814389e-02f, -9.29000005e-02f, -2.06655990e-02f, -1.08340075e-02f, -1.50101423e-01f, -4.30660211e-02f,
  3.03812511e-02f, 8.14346224e-03f, -2.62739453e-02f, 8.81934911e-02f, 3.69975492e-02f, -4.55870070e-02f, 3.72286178e-02f, 1.36712849e-01f, 5.38016716e-03f, 2.91960351e-02f,
  -3.51108015e-02f, 9.86830890e-02f, 1.12856776e-02f, -8.26088488e-02f, -1.20855398e-01f, -6.18450940e-02f, -6.79778829e-02f, 8.89148414e-02f, -1.01374658e-02f, -1.02429621e-01f,
  -1.72457900e-02f, -1.83082477e-03f, 1.54868690e-02f, -3.88312526e-02f, 3.92001681e-02f, 7.59464949e-02f, 3.25924670e-03f, -5.50518036e-02f, -7.92312324e-02f, -2.88054161e-02f,
  1.00662068e-01f, -8.64616334e-02f, -7.83440843e-02f, -2.37579495e-02f, -1.55828958e-02f, 6.96631894e-02f, -3.97578962e-02f, -4.87878546e-02f, -2.13302160e-03f, 1.50553863e-02f,
  -1.00181624e-01f, 9.68813226e-02f, -2.42569461e-03f, -6.18679151e-02f, 5.16445488e-02f, 2.54102866e-03f, 1.11462623e-02f, -9.14103016e-02f, 8.64630286e-03f, 5.09853438e-02f,
  2.13658063e-06f, 5.36646508e-02f, 1.44342676e-01f, 4.54114238e-03f, -6.33389503e-02f, 6.83615506e-02f, 3.28737602e-04f, 4.47381176e-02f, 7.59168640e-02f, 1.77245140e-02f,
  1.10659838e-01f, 5.17858639e-02f, -5.97279556e-02f, 1.99588500e-02f, 1.13500565e-01f, 5.04526757e-02f, 1.56518131e-01f, -4.01953943e-02f, 1.14007451e-01f, -1.07825464e-02f,
  4.45690751e-01f, -3.55293959e-01f, -2.22103596e-01f, 1.61357015e-01f, 3.38096023e-01f, 1.46136507e-01f, 7.21296966e-02f, 2.33980250e-02f, 5.52191548e-02f, -2.38812566e-01f,
  2.75362935e-02f, -4.38203588e-02f, -2.24682629e-01f, 1.24415360e-01f, 1.79712355e-01f, -2.54941076e-01f, 1.68245926e-01f, -3.87104787e-02f, -1.05268143e-01f, -2.83225160e-02f,
  1.61762059e-01f, 1.87801301e-01f, -8.50377080e-04f, 7.01392442e-02f, 1.23279564e-01f, 3.94496955e-02f, 1.43611252e-01f, -1.12179615e-01f, 1.00130297e-01f, 6.20920844e-02f,
  1.15363702e-01f, -2.19254754e-02f, -2.76514776e-02f, -9.31648538e-03f, -1.13762319e-02f, 4.12559956e-02f, -9.58499536e-02f, 7.14385435e-02f, 2.13220194e-02f, -8.15359950e-02f,
  1.83587465e-02f, -1.30213834e-02f, 1.16544172e-01f, 9.58387256e-02f, 1.50317863e-01f, 1.34165078e-01f, -8.61499645e-03f, -3.03541850e-02f, -5.66858277e-02f, -9.14590955e-02f,
  5.49759250e-03f, -1.15858041e-01f, 3.19669470e-02f, -1.57829467e-02f, -5.99948131e-02f, -5.36751701e-03f, -7.80199841e-02f, 1.44941953e-03f, 3.87006663e-02f, 1.30692320e-02f,
  4.05277424e-02f, 3.47519852e-02f, -7.54321814e-02f, 9.16638374e-02f, -2.94601452e-02f, 1.41618932e-02f, 5.07393666e-03f, -1.20164938e-02f, -3.01072113e-02f, -6.09246641e-02f,
  -1.26124965e-02f, 1.07429184e-01f, 1.66049208e-02f, 1.94022357e-02f, 8.08282271e-02f, 3.45151164e-02f, 1.48604378e-01f, -1.61644537e-02f, -3.74891283e-03f, 5.03297560e-02f,
  -6.47882894e-02f, 7.65676573e-02f, 1.16603747e-02f, -1.40135242e-02f, -9.88399144e-03f, 2.68558729e-02f, -8.73504952e-02f, 1.97169222e-02f, -3.03214733e-02f, -1.55061157e-02f,
  -9.70803201e-02f, -2.20337346e-01f, -1.10190257e-01f, -9.18631181e-02f, -4.42633778e-02f, 8.57554451e-02f, -1.66550651e-02f, 3.73060443e-02f, 2.12614816e-02f, 7.02100992e-02f,
  -6.06987905e-03f, 2.66880007e-03f, -4.26714458e-02f, 5.79019338e-02f, 2.47867703e-02f, -6.16951194e-03f, -2.48526409e-02f, -1.26679894e-02f, -6.22970052e-02f, 8.26749578e-03f,
  3.18224579e-02f, -8.00679177e-02f, -3.25833783e-02f, 7.44766369e-02f, -3.70688476e-02f, 2.74732336e-02f, -2.28639524e-02f, -1.20573845e-02f, -1.40737817e-01f, -2.05249041e-02f,
  3.62610132e-01f, 2.60037631e-01f, 2.29639873e-01f, 1.55966610e-01f, -1.10043630e-01f, -2.28302240e-01f, -5.03931046e-02f, -3.91022898e-02f, 8.98330286e-02f, 2.29603238e-02f,
  -1.98872000e-01f, 3.93910199e-01f, -1.26265287e-01f, 1.81431115e-01f, -5.84429987e-02f, -2.81229258e-01f, 2.02076122e-01f, 1.27186785e-02f, -7.30884867e-03f, 1.43188089e-01f,
  3.90186789e-03f, -1.12165302e-01f, 1.55830070e-01f, 1.38735007e-02f, 1.78909630e-01f, 1.32255405e-01f, -1.23925164e-01f, -1.05070531e-01f, 1.68044955e-01f, -1.27286613e-01f,
  -5.09373546e-02f, 3.06260213e-02f, 1.29359871e-01f, 2.05706805e-02f, -2.09537763e-02f, -7.99781606e-02f, -5.89731932e-02f, -7.40214512e-02f, -4.20974381e-02f, 5.55842742e-02f,
  4.05056365e-02f, 8.53794627e-03f, 5.69565520e-02f, 2.49190927e-02f, 3.67613398e-02f, 2.49547474e-02f, -1.87182315e-02f, 9.06838290e-03f, 6.97082700e-03f, 4.14279886e-02f,
  8.68783966e-02f, 1.18709147e-01f, 7.86418840e-02f, -8.76637399e-02f, 5.99898137e-02f, -4.62229848e-02f, 6.17516339e-02f, 8.07448179e-02f, 2.34395117e-02f, 9.20149013e-02f,
  -1.20058674e-02f, 4.27812487e-02f, 5.55343181e-02f, 6.07080832e-02f, -4.85050902e-02f, -5.78846000e-02f, -6.59908205e-02f, -8.38377401e-02f, 4.72481884e-02f, 1.55063653e-02f,
  -2.66211815e-02f, 9.29722637e-02f, -7.72094280e-02f, 5.83610348e-02f, 4.20506820e-02f, 1.17802948e-01f, 4.90449276e-03f, -1.92393847e-02f, 5.95064908e-02f, 3.58215049e-02f,
  -1.07456520e-01f, -1.08611053e-02f, 5.87364212e-02f, -4.37790435e-03f, 9.71824955e-03f, -4.07857411e-02f, -1.17998607e-02f, 1.02071695e-01f, -2.72069359e-04f, -4.51867469e-02f,
  -8.02214295e-02f, -7.65325353e-02f, 7.49509186e-02f, -3.34267057e-02f, -1.91168059e-02f, 3.24084976e-04f, -2.45003682e-02f, 1.03471480e-01f, -6.34419769e-02f, -9.85612646e-02f,
  6.84652030e-02f, -5.06434292e-02f, -6.73130080e-02f, 3.88074259e-04f, -7.20471144e-02f, -6.42978027e-03f, 1.51544446e-02f, -1.75928057e-03f, 1.45672746e-02f, 3.36941294e-02f,
  -5.50045669e-02f, -2.11339425e-02f, 1.30591929e-01f, -5.96897816e-03f, -7.40639772e-03f, 1.93212256e-02f, 7.64069054e-03f, 1.56034097e-01f, -3.78623558e-03f, -3.93652655e-02f,
  1.19476384e-02f, -9.40682068e-02f, -1.59773797e-01f, -7.09838197e-02f, -1.59649044e-01f, 1.18577249e-01f, 3.08211386e-01f, -1.19572788e-01f, -9.61139426e-02f, 1.74253598e-01f,
  1.20266862e-01f, -1.03882197e-02f, 2.38831893e-01f, 1.66320458e-01f, 8.03973898e-03f, 2.24014953e-01f, 2.56664287e-02f, 1.21913277e-01f, 5.76694636e-03f, -2.06871517e-02f,
  -1.25529647e-01f, 1.55559480e-01f, 1.20385602e-01f, -7.93710425e-02f, 1.26533851e-01f, -4.99021634e-02f, -5.19167371e-02f, 9.16566923e-02f, -1.36457056e-01f, -3.58547382e-02f,
  9.74698514e-02f, 2.85131112e-02f, -1.16650365e-01f, -1.11000901e-02f, -4.69203256e-02f, 3.87239046e-02f, -2.24875417e-02f, 7.08740065e-03f, -4.65898067e-02f, -3.82431522e-02f,
  4.82533053e-02f, -6.34971447e-03f, -7.39411935e-02f, 4.28682007e-02f, -9.67254490e-02f, -9.48465765e-02f, 7.05646025e-03f, -3.53410877e-02f, -6.74954196e-03f, 7.91560560e-02f,
  1.34816878e-02f, -5.17607816e-02f, 7.50711188e-03f, -4.94389348e-02f, -2.47274414e-02f, -1.94714535e-02f, 4.92122956e-02f, 9.34272259e-03f, -1.23642590e-02f, 4.60040709e-03f,
  3.63383517e-02f, 1.23936705e-01f, 1.68492515e-02f, 8.91021173e-03f, -2.19590683e-02f, 5.61853163e-02f, 8.89862999e-02f, -3.51138413e-02f, -7.87821338e-02f, -1.22501299e-01f,
  -1.07677467e-01f, -2.03681625e-02f, 2.07350142e-02f, -4.67474721e-02f, -5.76976500e-03f, -6.15427978e-02f, 4.20936272e-02f, 2.50406638e-02f, -5.08920327e-02f, -1.19383214e-03f,
  -1.21581182e-02f, 5.96993901e-02f, 9.01645720e-02f, 5.25324158e-02f, 7.76695982e-02f, -3.32901292e-02f, -9.15092602e-02f, 5.85179427e-04f, -5.75508513e-02f, 1.00994304e-01f,
  4.73647080e-02f, -2.41662115e-02f, -8.64042155e-03f, -1.48981586e-02f, -3.22209112e-02f, -4.13547233e-02f, 5.11423238e-02f, -4.30137478e-03f, -6.83126450e-02f, -3.37464036e-03f,
  -3.05250399e-02f, 9.39291492e-02f, -5.33724390e-02f, 5.28098978e-02f, -4.23257276e-02f, -1.96035728e-02f, 1.28500864e-01f, -3.59019078e-02f, 5.01924679e-02f, 2.42312849e-02f,
  -7.26630390e-02f, 1.21802367e-01f, 1.03728794e-01f, 3.82896513e-02f, -3.20428237e-02f, 4.76404391e-02f, -1.01259798e-01f, 3.94110419e-02f, -2.20446358e-03f, -5.32020517e-02f,
  -2.69931287e-01f, -2.03956887e-02f, -5.68337552e-02f, -1.83386669e-01f, -3.33320290e-01f, -1.72541812e-02f, -1.13916181e-01f, -7.46228024e-02f, -1.61388423e-02f, 1.54217869e-01f,
  -1.69535160e-01f, -5.43162460e-03f, 1.88099101e-01f, 3.43017094e-02f, 1.22801393e-01f, 3.03976685e-01f, 8.60449672e-03f, 7.21187145e-02f, -8.14596948e-04f, -5.84724545e-02f,
  3.28980153e-03f, -2.20852182e-03f, 2.27880627e-02f, -6.30281791e-02f, -2.53806710e-01f, -1.26760542e-01f, -6.11168751e-03f, -2.13227898e-01f, -1.50083080e-01f, -1.26343533e-01f,
  -9.27515924e-02f, -1.00717172e-01f, -4.86834124e-02f, 4.55658063e-02f, -6.05019405e-02f, -4.59200591e-02f, -2.10993021e-04f, -6.11010678e-02f, -1.29974857e-01f, -3.53694558e-02f,
  1.45787466e-02f, 1.23030075e-03f, 3.82615812e-02f, 4.25429344e-02f, 1.98940914e-02f, -6.55282810e-02f, -1.04729757e-01f, 2.91750929e-03f, -1.29068017e-01f, 4.33501564e-02f,
  -2.45330166e-02f, 2.14112438e-02f, 2.37861220e-02f, 1.44512996e-01f, -1.09549433e-01f, -1.52016476e-01f, -1.60780456e-02f, -1.32250702e-02f, -4.04268019e-02f, 1.01080080e-02f,
  -7.48291425e-03f, 1.33420918e-02f, -5.38776517e-02f, -1.50160968e-01f, -2.86675114e-02f, -1.00773461e-02f, 3.04509066e-02f, -7.77312964e-02f, 1.72377750e-02f, 3.85456234e-02f,
  4.18838449e-02f, -1.09691583e-02f, 7.59332553e-02f, 9.39387232e-02f, -5.38911223e-02f, 1.01789959e-01f, 2.14725398e-02f, -6.15023822e-02f, 1.15793318e-01f, -4.28101905e-02f,
  -6.63398579e-02f, 2.61386274e-03f, 1.60630867e-02f, 5.69828637e-02f, -3.21390256e-02f, -8.38358793e-03f, -4.27310762e-04f, 1.57160759e-02f, -2.45578645e-04f, -5.01319543e-02f,
  -6.62705973e-02f, -2.27285683e-01f, -3.97974215e-02f, -3.01554687e-02f, -6.86755255e-02f, 7.62540326e-02f, 4.34112176e-02f, -1.56008685e-02f, -1.63127691e-01f, -1.01979850e-02f,
  1.59552768e-02f, 9.47563127e-02f, 2.85412073e-02f, -2.66511701e-02f, 1.37731820e-01f, 6.59207487e-03f, -1.24871798e-01f, 3.85656767e-02f, -1.04323424e-01f, -7.54908100e-02f,
  -8.43820497e-02f, -3.12587582e-02f, 3.84159461e-02f, 6.37129694e-02f, 2.30982024e-02f, -2.70498991e-02f, 3.01153888e-03f, 1.20379799e-03f, -7.99519569e-02f, -3.81958234e-04f,
  1.22180566e-01f, -4.47062284e-01f, -4.11402844e-02f, 4.37053107e-02f, 2.23465398e-01f, 1.42776057e-01f, 2.39778683e-01f, -2.20253870e-01f, -1.62145346e-01f, -2.67413288e-01f,
  1.28041729e-01f, 1.10521995e-01f, 9.12699383e-03f, 5.95092587e-02f, 5.58896065e-01f, 2.96191424e-02f, -8.07679296e-02f, 1.27000868e-01f, 8.50617792e-03f, 3.20155248e-02f,
  1.04941167e-01f, 7.29108527e-02f, 2.72332281e-01f, -1.87775865e-01f, 3.25557441e-02f, -1.45451397e-01f, 3.85739766e-02f, 1.32205695e-01f, 1.39624043e-03f, 2.32589990e-01f,
  -5.49636707e-02f, -2.06064701e-01f, 9.42099541e-02f, -7.18686879e-02f, -4.11595069e-02f, 2.87793372e-02f, 7.16964304e-02f, 9.14052725e-02f, 1.20612033e-01f, 3.61173861e-02f,
  9.61105712e-03f, 3.16866301e-02f, -1.04677528e-02f, -3.05894446e-02f, -3.42592373e-02f, -1.79580506e-02f, 5.87461181e-02f, 4.16999608e-02f, -3.18893865e-02f, 5.19384071e-02f,
  2.64019165e-02f, -1.98070593e-02f, -6.72882944e-02f, -1.92840789e-02f, 7.97291100e-02f, -7.14826807e-02f, 4.45246138e-02f, 7.45906457e-02f, -3.84103842e-02f, -3.19182698e-04f,
  2.31172866e-03f, 1.58345085e-02f, -5.88483363e-02f, -4.13341783e-02f, -2.56967116e-02f, -1.95889100e-02f, -2.70047854e-03f, 3.91924754e-02f, 1.11279659e-01f, 2.86714989e-03f,
  -1.01544894e-02f, 1.55320577e-02f, -3.98386717e-02f, -9.26676765e-02f, -1.69798825e-02f, -3.23097073e-02f, 8.42392743e-02f, -8.18154886e-02f, -7.07061663e-02f, 2.39882953e-02f,
  -1.20137334e-02f, -4.37160544e-02f, -7.44320918e-03f, 9.49202254e-02f, -9.57590416e-02f, 7.46906623e-02f, -1.37588486e-01f, -9.28674266e-02f, 8.67031142e-02f, 1.11212276e-01f,
  -3.66974503e-01f, -3.74194354e-01f, -3.69021669e-02f, -2.34722029e-02f, -3.83804031e-02f, -1.34000033e-01f, -3.51222046e-02f, -6.10454679e-02f, -8.79683271e-02f, 2.78130081e-02f,
  -5.82589060e-02f, -8.45917151e-04f, -1.23722978e-01f, -7.05224201e-02f, -2.44921539e-03f, 2.67128926e-02f, -1.41281821e-02f, -6.49908334e-02f, -6.26548519e-03f, -6.26558587e-02f,
  -6.35358393e-02f, -1.29945297e-02f, 5.84809929e-02f, 3.39415707e-02f, -5.45954108e-02f, -8.60151947e-02f, -8.85532349e-02f, -7.17232525e-02f, -9.78424330e-04f, -5.63346781e-03f,
  -2.40589529e-01f, -1.77641973e-01f, -2.65060425e-01f, -1.38770953e-01f, 9.10823047e-02f, -2.56964684e-01f, -1.64895505e-01f, -2.43009757e-02f, -1.71643775e-02f, 2.42338330e-01f,
  4.26966064e-02f, -1.46958632e-02f, 4.88717295e-02f, -2.47846916e-01f, -3.59367967e-01f, -4.20110226e-02f, -2.67040849e-01f, -1.39115319e-01f, -6.14071265e-02f, -2.14661136e-01f,
  -1.60354450e-01f, -2.98659485e-02f, -2.45388865e-01f, 1.64312720e-02f, -7.18266815e-02f, -7.03161508e-02f, 1.14846922e-01f, 1.33032158e-01f, -4.58825491e-02f, 1.34476891e-03f,
  -1.07778020e-01f, 7.54108578e-02f, 3.99637371e-02f, -6.32010624e-02f, -6.89235404e-02f, 1.15641654e-01f, 1.11202756e-02f, 4.71652895e-02f, 5.39167747e-02f, -2.42722686e-02f,
  5.25918752e-02f, -9.65648666e-02f, 3.62683125e-02f, 1.45147648e-03f, -1.65219456e-02f, 3.11852507e-02f, 6.39931783e-02f, -2.43871775e-03f, 7.51521438e-02f, -8.33999440e-02f,
  -8.15938637e-02f, -5.65260416e-03f, 3.31730619e-02f, 6.33272678e-02f, -5.74399792e-02f, 2.77199838e-02f, -2.30770595e-02f, 4.70440350e-02f, 3.01619736e-03f, -1.22367367e-01f,
  4.52498421e-02f, 3.06780171e-03f, 4.74583954e-02f, -4.06985544e-02f, 8.95045176e-02f, 5.61643019e-02f, 1.88827924e-02f, -5.10168867e-03f, 4.83126193e-02f, -5.84848933e-02f,
  -4.47704755e-02f, -7.28889033e-02f, 2.05511730e-02f, 1.20192925e-02f, -7.62358634e-03f, 4.94900681e-02f, -6.59057274e-02f, -8.18232968e-02f, -1.33727148e-01f, -1.16122790e-01f,
  7.21399412e-02f, 5.79130882e-03f, -8.78437422e-03f, 5.24926707e-02f, -9.67129916e-02f, 4.60946374e-03f, 1.62170120e-02f, -9.24965888e-02f, -4.24530990e-02f, -5.27760834e-02f,
  -3.06082219e-02f, 9.58169326e-02f, 7.60951266e-02f, -4.45941417e-03f, 5.06778806e-02f, -6.21818099e-03f, -1.53074071e-01f, -1.07923999e-01f, -1.22789002e-03f, -2.42764894e-02f,
  -6.45103231e-02f, -1.18014105e-02f, 6.55775294e-02f, 7.27430657e-02f, -6.67902678e-02f, -1.62975807e-02f, 4.24867347e-02f, -1.31552583e-02f, -1.90329663e-02f, 4.85473871e-02f,
  8.38852599e-02f, 9.57367793e-02f, 6.42939582e-02f, 5.21653891e-03f, 5.81725836e-02f, 9.52940620e-03f, 7.82701075e-02f, 2.67055468e-03f, 2.44511440e-02f, -1.48711307e-02f,
  4.94096540e-02f, 1.43694222e-01f, 1.88525170e-01f, -7.52062649e-02f, 2.03935191e-01f, 3.31851453e-01f, 2.14672819e-01f, 1.30103886e-01f, 4.97974791e-02f, -2.34731272e-01f,
  -1.94863483e-01f, -1.76219091e-01f, -3.84573452e-03f, -1.27908289e-01f, 2.03989699e-01f, 1.57129884e-01f, 1.79829836e-01f, -1.09825291e-01f, 1.98592305e-01f, 4.82030883e-02f,
  7.05747530e-02f, -8.31026211e-02f, 1.46935299e-01f, 4.97904718e-02f, 1.48808341e-02f, -6.21777624e-02f, -2.46805713e-01f, -9.66424793e-02f, -2.51426309e-01f, -2.32099202e-02f,
  1.14576451e-01f, 4.09942903e-02f, 4.78769988e-02f, 8.74325410e-02f, 3.85489911e-02f, -7.38936290e-02f, -9.36751738e-02f, -8.34277049e-02f, -1.63037535e-02f, -4.01522219e-02f,
  -1.75624356e-01f, -1.11372277e-01f, 4.71225679e-02f, 7.01602455e-03f, -1.15651853e-01f, -3.28501133e-04f, 9.16686356e-02f, 2.02605911e-02f, -6.34396374e-02f, 3.87784541e-02f,
  7.75508285e-02f, -7.67491236e-02f, 6.25084527e-03f, -7.64942393e-02f, -2.93923747e-02f, -4.03543711e-02f, -3.14485282e-02f, -1.00864895e-01f, 2.68487930e-02f, -6.34136349e-02f,
  -1.11373499e-01f, -1.89832170e-02f, 4.44469089e-03f, -1.15771107e-01f, 1.16315387e-01f, -1.10925391e-01f, -4.79195863e-02f, -2.42968332e-02f, 1.31642461e-01f, -3.96693535e-02f,
  -1.49216443e-01f, -1.86684970e-02f, 9.39462855e-02f, 1.53995780e-02f, -3.85090932e-02f, -1.90365454e-03f, -5.52235730e-02f, -1.69367529e-02f, -5.60478233e-02f, -6.55119792e-02f,
  -6.59714341e-02f, -1.24803949e-02f, -3.93869504e-02f, -9.76821035e-02f, -8.32943693e-02f, -5.58243021e-02f, -8.70202482e-02f, -8.54794588e-03f, 9.44702327e-02f, -5.12911053e-03f,
  1.18289970e-01f, 8.94739032e-02f, 1.09038293e-01f, -5.91998845e-02f, 8.39661658e-02f, 1.24428451e-01f, 6.18099980e-02f, 5.05071841e-02f, -7.21122995e-02f, 3.96885835e-02f,
  -6.51779547e-02f, -2.14421120e-03f, -8.90658870e-02f, -6.77900091e-02f, -5.27906492e-02f, 1.68735117e-01f, -3.02355625e-02f, -8.20366368e-02f, -4.35077064e-02f, -7.34492689e-02f,
  -1.13542266e-01f, -1.51645504e-02f, -8.84733722e-02f, 1.08805010e-02f, 7.34828040e-02f, -1.01739086e-01f, 3.27826180e-02f, 9.98225342e-03f, 9.72213037e-03f, -6.56267107e-02f,
  -3.10303807e-01f, 1.06956586e-01f, -2.39627853e-01f, -1.37903765e-01f, 3.50648165e-02f, 5.80800474e-02f, -6.92146271e-02f, -4.84068021e-02f, -2.89000630e-01f, 2.24637270e-01f,
  1.45484865e-01f, -2.61748791e-01f, -1.30995855e-01f, 8.14372823e-02f, -3.95451486e-01f, -1.06267080e-01f, 5.68151437e-02f, 4.53243256e-02f, -1.22105666e-01f, -6.91186935e-02f,
  -8.38536173e-02f, 2.04774275e-01f, -1.40619695e-01f, 1.73362792e-01f, 1.51408479e-01f, -2.71633659e-02f, 9.70463082e-02f, -2.58070305e-02f, 1.34690434e-01f, 5.03366925e-02f,
  -4.78519052e-02f, -3.05615924e-02f, -8.42686743e-03f, -5.35764694e-02f, -4.44318280e-02f, 5.21121845e-02f, 2.98838578e-02f, 3.07151433e-02f, -8.35179687e-02f, -4.58188429e-02f,
  -1.19957412e-02f, -1.40810404e-02f, -3.19858342e-02f, -6.56295121e-02f, -4.49826233e-02f, -6.87381923e-02f, 8.31910148e-02f, -7.84577206e-02f, 8.50281492e-03f, -1.53696850e-01f,
  -1.22573130e-01f, -2.58019120e-02f, 8.09737071e-02f, -5.36068417e-02f, -6.06144369e-02f, 7.25978762e-02f, 7.72474706e-02f, 7.63493478e-02f, -8.33453983e-03f, -7.83706829e-02f,
  -3.14125820e-04f, -5.89705147e-02f, 6.11157762e-03f, -5.58628561e-03f, 5.09600453e-02f, 5.14665879e-02f, 3.60963913e-03f, 1.10453218e-01f, -3.25275511e-02f, -2.24118680e-02f,
  1.83073282e-02f, -1.67673081e-01f, 6.73549026e-02f, 1.25757858e-01f, 7.75839621e-03f, 2.30565798e-02f, -4.07919399e-02f, -7.31188804e-03f, -1.45658366e-02f, 3.28207873e-02f,
  -2.99017821e-02f, 5.95361032e-02f, -1.27154784e-02f, -8.89693573e-02f, -2.68810540e-02f, 2.81064567e-04f, 4.96597402e-02f, -5.92548363e-02f, 1.25511825e-01f, -7.05730990e-02f,
  5.80341369e-02f, -3.79825979e-02f, -1.21359661e-01f, 3.67835462e-02f, -9.72026028e-03f, 3.12640667e-02f, -3.11246775e-02f, 1.22974915e-02f, 1.84181891e-02f, 8.22193772e-02f,
  1.30910345e-03f, 1.11257918e-01f, -2.65017170e-02f, -7.14011565e-02f, 5.36074080e-02f, 2.80732326e-02f, 1.02527365e-02f, -1.66377295e-02f, 9.84401722e-03f, -9.49867722e-03f,
  -8.48520696e-02f, -3.33766192e-02f, 2.50945296e-02f, -2.49778256e-02f, 1.22414343e-02f, 9.33744460e-02f, -1.16323493e-01f, -1.44413370e-03f, 7.66321570e-02f, 9.36966985e-02f,
  -3.15461755e-01f, -8.69848281e-02f, -1.77111953e-01f, -2.31772438e-01f, 9.51538011e-02f, -2.15835065e-01f, -1.53146192e-01f, 3.19863595e-02f, -2.36337464e-02f, 1.66182324e-01f,
  6.38565421e-02f, -1.84125274e-01f, 5.04508168e-02f, -3.32750112e-01f, -3.16020161e-01f, -1.87796369e-01f, -2.90467680e-01f, -2.37597540e-01f, -1.62644207e-01f, -1.52573571e-01f,
  -1.51270196e-01f, -1.52415037e-01f, -2.67604381e-01f, 2.34546252e-02f, -1.40013145e-02f, 6.61411509e-02f, 1.17657550e-01f, 8.39078873e-02f, -1.33101836e-01f, -1.75500824e-03f,
  -6.19969927e-02f, 7.65971914e-02f, -3.88029180e-02f, -8.48716795e-02f, 6.86048297e-03f, 1.20851500e-02f, -4.98526022e-02f, 3.75223272e-02f, 4.10390347e-02f, -1.67420991e-02f,
  -1.02427052e-02f, 1.89228486e-02f, -4.64732014e-02f, 6.20157039e-03f, 5.16364500e-02f, 5.01322299e-02f, 3.89570855e-02f, 5.24361394e-02f, -5.29105589e-02f, -7.70147294e-02f,
  -7.52138123e-02f, 6.18420839e-02f, 3.53076169e-03f, 8.49191565e-03f, -2.87943203e-02f, 8.03828016e-02f, -2.90729646e-02f, 4.51945141e-02f, -9.69544351e-02f, -5.28129861e-02f,
  1.88597832e-02f, -3.29753221e-03f, -5.22269160e-02f, -6.82247132e-02f, -6.12650961e-02f, 1.88643001e-02f, -1.79773513e-02f, -3.77016403e-02f, -2.26132590e-02f, -7.17281848e-02f,
  4.75535840e-02f, -3.53095494e-02f, -9.45825502e-02f, -7.44266510e-02f, -6.42537400e-02f, -7.24263936e-02f, -8.51334631e-02f, 1.26241446e-02f, -5.24568968e-02f, -1.43615991e-01f,
  8.69711339e-02f, 1.30458176e-03f, -5.09077758e-02f, -1.65773071e-02f, -5.38181700e-02f, 3.58750932e-02f, -7.95819834e-02f, -3.27817313e-02f, -2.53452845e-02f, 2.14732978e-02f,
  6.74078465e-02f, 1.58687070e-01f, 7.75133297e-02f, 3.74691300e-02f, 8.55503753e-02f, -4.25079949e-02f, -1.02574922e-01f, -1.60700176e-02f, 4.13423544e-03f, -2.20838729e-02f,
  -4.14270125e-02f, -3.99457961e-02f, 1.24116078e-01f, -5.42600229e-02f, -2.69427802e-03f, 8.61124247e-02f, 7.89661556e-02f, 4.01022807e-02f, 5.27925231e-03f, 6.06649294e-02f,
  1.05699360e-01f, 1.41013265e-01f, 4.21282323e-03f, 4.84110005e-02f, 2.18880102e-02f, 7.22712502e-02f, 6.45985380e-02f, -2.51146685e-02f, -4.58108669e-04f, 6.20906390e-02f,
  -2.66230047e-01f, -1.43766822e-02f, -1.21153677e-02f, -1.74100742e-01f, -2.20670983e-01f, -1.02502614e-01f, -2.29500309e-02f, -6.09329045e-02f, -2.15687081e-02f, 1.48855790e-01f,
  -3.91424857e-02f, 8.89779180e-02f, 2.44554266e-01f, -1.00340314e-01f, -1.54425472e-01f, 1.12162761e-01f, -8.54721665e-02f, -1.86431818e-02f, 6.95757642e-02f, -1.18962750e-01f,
  -9.02918950e-02f, -5.79301268e-02f, -8.94787833e-02f, 7.76190832e-02f, -1.99717492e-01f, -8.40576142e-02f, -1.11375982e-03f, -2.24647492e-01f, -1.07800387e-01f, -1.12182781e-01f,
  -8.15877318e-02f, 1.17488131e-02f, 4.68252227e-02f, -3.11595742e-02f, 1.09555507e-02f, -9.33010206e-02f, -1.30429655e-01f, 1.74138939e-03f, 2.75055342e-03f, -1.92520246e-02f,
  1.20005878e-02f, 1.47652281e-02f, 1.60535686e-02f, 8.70942846e-02f, -1.08626112e-01f, -9.63087305e-02f, -8.04814920e-02f, -4.23243530e-02f, 1.42946929e-01f, -1.06577473e-02f,
  7.56028071e-02f, 2.74705403e-02f, 1.23229148e-02f, 8.36753100e-02f, -2.38189436e-02f, 2.99519091e-03f, 5.19080050e-02f, -6.90528518e-03f, 8.57328549e-02f, -2.63316128e-02f,
  -6.73416033e-02f, -6.75129658e-03f, -6.70162290e-02f, -4.12556492e-02f, -7.32143670e-02f, 3.13094556e-02f, 2.90299933e-02f, 1.53775867e-02f, 9.84513108e-03f, -6.64356202e-02f,
  1.16956988e-02f, -9.31551456e-02f, -1.47271976e-02f, 1.18370801e-02f, -7.34322816e-02f, 2.02164482e-02f, 1.82804018e-02f, 1.21374764e-02f, 3.86918001e-02f, -1.61926970e-02f,
  -7.39877671e-02f, -3.33643034e-02f, 4.00927700e-02f, -1.63154155e-02f, -8.90957937e-02f, 2.08565556e-02f, -1.32138198e-02f, -5.10232598e-02f, 9.89599079e-02f, -3.91473025e-02f,
  -9.92998481e-02f, -8.22385922e-02f, 4.94406037e-02f, 7.64403567e-02f, 5.50323464e-02f, -3.76972705e-02f, -1.30463168e-02f, 1.19454833e-02f, 1.20028330e-03f, -3.85491252e-02f,
  -3.70274447e-02f, 8.18098634e-02f, 7.59001672e-02f, 6.97968379e-02f, 5.27058542e-02f, 3.49809304e-02f, 1.13604618e-02f, 1.22703440e-01f, -2.46788450e-02f, 2.85721906e-02f,
  9.00619701e-02f, 5.54872341e-02f, 1.29659936e-01f, 5.50302975e-02f, 3.24660130e-02f, 1.15560777e-01f, -6.71251044e-02f, 8.53871629e-02f, 7.01376656e-03f, -7.69039765e-02f,
  5.35213910e-02f, 3.14537257e-01f, -1.73514038e-01f, 1.32263586e-01f, 1.18466273e-01f, 2.95700312e-01f, 1.23773403e-01f, 1.11521862e-01f, 8.06424767e-02f, 8.22637752e-02f,
  1.24049366e-01f, 2.66425963e-02f, -2.56208004e-03f, 3.44712138e-01f, 6.85682297e-02f, -3.37983556e-02f, 2.68036366e-01f, 1.98163271e-01f, -1.02424407e-02f, 1.15632810e-01f,
  -1.21794678e-02f, 3.15809309e-01f, -1.64278269e-01f, -2.95768608e-03f, 9.37696993e-02f, -2.53463686e-01f, -1.95628256e-01f, -2.91628391e-01f, -2.97702453e-03f, -3.59810367e-02f,
  2.23708991e-02f, 9.81970578e-02f, -5.13568446e-02f, -8.58717337e-02f, 1.00586973e-01f, -2.70013721e-03f, -1.05879799e-01f, -7.78049156e-02f, -4.93797334e-03f, 3.80451158e-02f,
  -3.86502333e-02f, -6.61854520e-02f, 7.84447044e-02f, -2.59069987e-02f, 1.23142205e-01f, -6.37218431e-02f, 7.34225437e-02f, -1.32736415e-02f, 1.92525815e-02f, -5.19041121e-02f,
  4.52829264e-02f, 1.66330095e-02f, -6.06799163e-02f, -4.94437329e-02f, -4.95083407e-02f, 4.42085788e-02f, -6.38698712e-02f, -6.47089705e-02f, 2.73779351e-02f, -1.92828365e-02f,
  -2.85322443e-02f, 5.63387293e-04f, 1.35538843e-03f, -5.10965660e-02f, 1.54619757e-02f, 5.14304638e-03f, 1.90180652e-02f, 4.82083522e-02f, -3.67328078e-02f, 8.30643326e-02f,
  7.53041431e-02f, 1.03536300e-01f, -1.31957291e-03f, -6.68135509e-02f, -2.85613071e-02f, -5.08472472e-02f, -1.03916831e-01f, 2.25147628e-03f, -5.08473031e-02f, -8.16829279e-02f,
  -1.23735510e-01f, 9.54379365e-02f, -7.08383545e-02f, -4.20271493e-02f, 5.26819052e-03f, 1.76700335e-02f, 1.03913695e-01f, -8.57514068e-02f, 3.82750221e-02f, 1.16104828e-02f,
  1.06340371e-01f, 1.53386578e-01f, -1.05742671e-01f, -2.25201584e-02f, 3.94285955e-02f, 9.83546525e-02f, -6.51998520e-02f, 4.58821133e-02f, -6.33921698e-02f, 6.04961477e-02f,
  6.21719006e-03f, -1.48855848e-02f, 7.97166228e-02f, -8.26591044e-04f, -6.40547805e-05f, 9.79390964e-02f, -3.89122851e-02f, -9.41082370e-03f, -1.28210951e-02f, -1.89577453e-02f,
  -6.13801293e-02f, -1.56738926e-02f, -7.89776742e-02f, 3.73413563e-02f, 4.17358950e-02f, 8.25422443e-03f, 3.54658104e-02f, -1.15014829e-01f, -9.08992514e-02f, 2.48986110e-02f,
  -3.24662030e-01f, 1.12522297e-01f, -3.12421229e-02f, -4.90752347e-02f, -4.48803864e-02f, 2.42077466e-03f, -1.31006539e-02f, -1.91029102e-01f, -1.02976874e-01f, 2.00315118e-01f,
  -6.37004301e-02f, 2.76870690e-02f, 1.45664467e-02f, -2.35977909e-03f, -4.47968334e-01f, -1.07207105e-01f, -4.02241163e-02f, 5.95178306e-02f, -1.32460162e-01f, -8.94703120e-02f,
  -1.63991138e-01f, -1.05205022e-01f, -1.29497483e-01f, -8.70780274e-02f, 4.35249135e-02f, 6.80513009e-02f, -1.05276555e-02f, -5.96545450e-03f, 1.58429712e-01f, -1.21026799e-01f,
  -1.19569115e-02f, -7.00607011e-03f, 9.31017473e-02f, 3.11300601e-03f, 4.05148864e-02f, 1.32373571e-01f, 5.17822430e-02f, 2.33409330e-02f, 5.29858135e-02f, 8.05381406e-03f,
  1.21363923e-01f, -9.29710194e-02f, -3.63536999e-02f, 1.70450266e-02f, 6.58681765e-02f, 8.52724910e-02f, -8.09615292e-03f, -4.12493059e-03f, -1.26059111e-02f, 1.49304727e-02f,
  6.23138398e-02f, -2.94803996e-02f, 9.17063951e-02f, 7.89989829e-02f, -4.44130599e-02f, -3.47273163e-02f, 9.96691883e-02f, -7.61270225e-02f, 2.18635844e-03f, -7.29480609e-02f,
  -6.27941266e-02f, 8.84969905e-02f, 6.81053251e-02f, -8.95575508e-02f, 7.32549280e-02f, 3.11595500e-02f, -3.66959758e-02f, -7.55201727e-02f, 5.68279140e-02f, 2.04573702e-02f,
  -7.29741082e-02f, -1.34295244e-02f, -4.10943739e-02f, -4.74819839e-02f, 5.85599653e-02f, 3.34458686e-02f, 1.28158201e-02f, -2.32571252e-02f, -1.29099607e-01f, 3.38375159e-02f,
  1.79570224e-02f, 1.04959421e-02f, 4.31540199e-02f, -2.85996087e-02f, -5.67798354e-02f, -6.80794790e-02f, 5.54340966e-02f, 1.27534986e-01f, -1.11187443e-01f, -4.05247547e-02f,
  -1.04728103e-01f, -9.65073109e-02f, 6.95355088e-02f, 1.09201428e-02f, 3.43690882e-03f, 5.09637855e-02f, -2.85912696e-02f, 4.32614610e-02f, 9.05189663e-02f, 2.45471997e-03f,
  1.09119982e-01f, 2.23593973e-02f, -5.54792874e-04f, 1.47912391e-02f, -1.04424030e-01f, 6.74585626e-02f, -6.38529435e-02f, -8.75011832e-02f, -7.50250220e-02f, -2.09021568e-02f,
  1.48178218e-02f, -8.95426944e-02f, 3.35497037e-02f, 3.68084311e-02f, 4.02726885e-03f, -5.04667349e-02f, -5.11660799e-02f, -4.47636247e-02f, -7.59204030e-02f, -4.13841829e-02f,
  -4.20495570e-01f, 1.44046888e-01f, 5.80173098e-02f, -3.21007907e-01f, 1.74493194e-01f, 7.68509880e-02f, -1.63010915e-03f, 2.33253017e-01f, -1.20551296e-01f, 1.37165368e-01f,
  1.08721495e-01f, -1.85549513e-01f, 1.70091152e-01f, -2.56658643e-01f, -3.87454689e-01f, -2.76522279e-01f, -2.44827285e-01f, -1.52505308e-01f, -1.42159015e-01f, -4.25188392e-02f,
  -1.37715355e-01f, -1.73361883e-01f, -1.00802973e-01f, 2.26110041e-01f, 7.44258636e-04f, 1.25816897e-01f, 9.24184397e-02f, 1.87727749e-01f, 1.43559556e-02f, 6.37128130e-02f,
  1.18256345e-01f, 1.15414545e-01f, -8.47154856e-03f, 3.95567194e-02f, 1.95121188e-02f, 5.96053079e-02f, 6.38803700e-03f, 9.19085275e-03f, -5.81162572e-02f, -3.44185568e-02f,
  4.64648753e-02f, -8.38864446e-02f, -8.08304548e-02f, -4.00073007e-02f, 6.51202798e-02f, 7.25115538e-02f, 3.62925194e-02f, 3.70266885e-02f, 1.22491773e-02f, -1.28089517e-01f,
  -1.05463475e-01f, 2.02689841e-02f, -1.82830617e-01f, -4.15919442e-03f, -2.54981555e-02f, 1.33606330e-01f, -7.68356323e-02f, 5.55988103e-02f, -9.30911228e-02f, -1.25636384e-01f,
  3.20944912e-03f, -1.15958288e-01f, -1.11887783e-01f, -1.42759876e-02f, -4.05302867e-02f, 8.87687877e-02f, -1.03137627e-01f, 4.01452109e-02f, -7.84593076e-02f, 6.29068837e-02f,
  6.18637204e-02f, 5.79032674e-02f, 4.18937281e-02f, -1.23668248e-02f, -9.08328220e-02f, 5.34232669e-02f, -5.57073280e-02f, -5.34837805e-02f, -4.90989685e-02f, 4.11932208e-02f,
  1.23090275e-01f, -2.57314816e-02f, 3.80034931e-02f, -9.32938419e-03f, 3.59899327e-02f, -4.50586267e-02f, -1.50124226e-02f, 4.21268120e-02f, 7.10295141e-02f, -4.91626859e-02f,
  8.37091729e-02f, 6.44973144e-02f, 3.81666906e-02f, 1.26056492e-01f, -6.74125627e-02f, -3.67534310e-02f, -8.09950680e-02f, 7.52820959e-03f, 5.19876182e-02f, -4.82841656e-02f,
  5.11902869e-02f, 3.24110650e-02f, 9.82546657e-02f, -6.70998124e-03f, 4.17135395e-02f, 2.74673174e-03f, 3.65826562e-02f, 7.68899843e-02f, 3.43706571e-02f, -1.97778102e-02f,
  -6.66990653e-02f, 4.07595281e-03f, -9.19094682e-02f, 6.06063940e-03f, -1.08196400e-01f, 5.72151802e-02f, 2.86144521e-02f, 1.52998175e-02f, -3.93437520e-02f, 2.45762058e-02f,
  4.41295505e-01f, 2.80656546e-01f, 7.23264590e-02f, 1.79325908e-01f, -2.62681931e-01f, -2.54606009e-02f, 3.27824429e-02f, -1.33939916e-02f, 2.59525124e-02f, 2.47374073e-01f,
  -6.32315651e-02f, 3.64506453e-01f, 8.97181127e-03f, 1.31867453e-01f, -2.83646822e-01f, -1.52558550e-01f, 1.50327096e-02f, 2.25380003e-01f, -5.00000902e-02f, 6.64175376e-02f,
  -1.00798104e-02f, -1.37009904e-01f, 7.35083874e-03f, -1.00875475e-01f, 1.24242410e-01f, 1.63303852e-01f, -1.46685749e-01f, -5.26453517e-02f, 1.24867678e-01f, -1.45501778e-01f,
  2.05532350e-02f, -5.32249175e-02f, 5.71395122e-02f, 4.47772294e-02f, -4.22095042e-03f, -4.58370261e-02f, -4.98892590e-02f, -1.01756290e-01f, -1.00255094e-01f, 2.25867387e-02f,
  1.58641785e-01f, -6.12406209e-02f, 6.36009052e-02f, -2.14468185e-02f, 1.62771996e-02f, 7.04958215e-02f, 2.46341657e-02f, 1.58469081e-01f, 5.75264655e-02f, -3.94162303e-03f,
  3.49501371e-02f, 1.08020864e-01f, 3.54645438e-02f, -6.25140499e-03f, 1.44052496e-02f, 1.24751814e-02f, 4.63379920e-02f, 5.88582829e-02f, 4.75129709e-02f, -5.88457100e-02f,
  4.14916836e-02f, -5.39425239e-02f, 3.86797935e-02f, 3.99751440e-02f, -4.79343683e-02f, -1.96058061e-02f, -2.53735948e-02f, -6.49079606e-02f, -9.53086913e-02f, 9.68414024e-02f,
  -4.43966947e-02f, 9.01266709e-02f, 4.81447279e-02f, 1.87093049e-01f, -1.20898420e-02f, 8.53965655e-02f, -1.13878157e-02f, 3.12734507e-02f, 5.08182161e-02f, 2.02162154e-02f,
  -3.82709578e-02f, 2.48848647e-02f, -4.50281128e-02f, 1.78703442e-02f, -5.46812750e-02f, 1.83289275e-02f, -4.58080955e-02f, 9.64862257e-02f, 4.88585047e-02f, 2.30294317e-02f,
  -8.22597221e-02f, -1.50417179e-01f, 6.68206364e-02f, -4.28190976e-02f, -2.44640019e-02f, -8.09504241e-02f, 8.64828974e-02f, -2.97783185e-02f, -1.13705419e-01f, -5.26369847e-02f,
  6.12421334e-02f, -6.37354553e-02f, -2.92749144e-02f, -1.68465718e-03f, -1.25946347e-02f, -1.27956092e-01f, 9.97149125e-02f, 8.75414982e-02f, -1.14856593e-01f, 6.51661083e-02f,
  -1.27241937e-02f, -2.87882844e-03f, 2.28812434e-02f, 6.20619059e-02f, 1.01518333e-01f, 3.45296375e-02f, 7.45880455e-02f, 1.50900617e-01f, -1.33723497e-01f, -1.02711961e-01f,
  2.90078878e-01f, 5.96583448e-02f, 1.34406850e-01f, 2.49692872e-01f, -1.55083984e-01f, -2.89988339e-01f, -2.65013993e-01f, 1.06771000e-01f, -3.21965851e-02f, -6.40115142e-02f,
  1.12032980e-01f, 6.76334500e-02f, -1.09242260e-01f, 2.59758443e-01f, 2.81869471e-01f, -2.85384078e-02f, 1.36435911e-01f, 1.08340560e-02f, 8.81345272e-02f, 1.18601069e-01f,
  2.58669406e-01f, 1.93018198e-01f, 1.31706297e-01f, 2.64338732e-01f, 4.14877087e-02f, 2.36961037e-01f, 1.67413518e-01f, 9.39689763e-03f, 1.56249374e-01f, -2.35434994e-02f,
  -2.86972430e-02f, 7.97674805e-02f, 3.80791090e-02f, -8.24856758e-02f, -3.63551150e-03f, -5.71329258e-02f, 2.81111561e-02f, 2.21660789e-02f, 2.95012090e-02f, -6.67054802e-02f,
  3.92124429e-02f, 3.49037908e-02f, -6.76610274e-03f, -2.12552119e-02f, -9.60496590e-02f, 1.49263414e-02f, -2.77894344e-02f, -9.54083875e-02f, -6.65087923e-02f, 7.31847212e-02f,
  -9.26626101e-02f, -1.05632581e-01f, 7.77848065e-02f, 6.33101314e-02f, 1.03411756e-01f, 6.29764199e-02f, -3.09637412e-02f, 4.54682261e-02f, 2.41156556e-02f, 7.47171119e-02f,
  1.36439770e-01f, -6.11058017e-03f, -8.37647393e-02f, -3.43054757e-02f, -1.12404465e-03f, -1.31359622e-01f, 6.73269257e-02f, 1.83272995e-02f, -5.97345345e-02f, 5.70280999e-02f,
  -2.02678218e-02f, -1.31936176e-02f, -4.05149609e-02f, -9.64984596e-02f, 1.25091702e-01f, 6.11137301e-02f, -2.79583726e-02f, 3.82897258e-02f, 8.58196393e-02f, 8.24522674e-02f,
  -6.23654611e-02f, 5.90193123e-02f, 1.98711734e-02f, 5.25846239e-03f, -2.64474936e-02f, -7.36936778e-02f, 3.21440250e-02f, 7.65678510e-02f, 1.73848942e-02f, 9.28962007e-02f,
  6.71215206e-02f, 1.20497592e-01f, -2.11675614e-02f, -2.51797643e-02f, 4.26576566e-03f, 5.93924038e-02f, 1.75860837e-01f, 1.31380111e-01f, 2.38527022e-02f, -9.98884719e-03f,
  6.52613416e-02f, -1.32687479e-01f, -2.42218412e-02f, -4.67282441e-03f, -1.87133090e-03f, -2.13317610e-02f, 5.87207787e-02f, 8.08611959e-02f, 5.58389351e-02f, 1.02701008e-01f,
  4.41150367e-02f, -1.24841124e-01f, 5.26360758e-02f, -1.12174325e-01f, -3.91372219e-02f, 1.64887533e-02f, -7.97702372e-02f, 4.92970692e-03f, 4.69293743e-02f, 3.64075266e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.19244912e-01f, 2.24726468e-01f, 2.38388665e-02f, 9.86367986e-02f, 1.65283844e-01f, 3.03013146e-01f, 9.15355757e-02f, 1.69442743e-01f, 1.32105887e-01f, 9.16938484e-02f,
  1.40141770e-01f, 7.00455485e-03f, -9.33404174e-03f, 1.32279797e-02f, 1.24251306e-01f, -5.32486066e-02f, 1.19364865e-01f, 2.05327988e-01f, 8.29307362e-02f, 5.26523441e-02f,
  4.12110277e-02f, 2.72855699e-01f, 1.14632301e-01f, 2.28621423e-01f, 2.36167893e-01f, 1.00685313e-01f, 6.81255013e-02f, 8.78058299e-02f, 3.69193345e-01f, 2.36936718e-01f,
  1.33868322e-01f, 4.37550619e-02f, 1.79195836e-01f, 1.89446539e-01f, 1.45953491e-01f, 1.79517031e-01f, 1.77807838e-01f, 2.20863953e-01f, 1.72989294e-01f, 3.03448308e-02f,
  1.13090567e-01f, 2.45569840e-01f, 1.59990788e-01f, 1.97336927e-01f, 2.48226061e-01f, 2.01667681e-01f, 1.22704178e-01f, 2.52975915e-02f, 1.80360615e-01f, 1.16907708e-01f,
  1.46179363e-01f, 1.05321212e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.59249038e-03f, -9.09436643e-02f, 4.13131453e-02f, -9.89480466e-02f, -6.78126700e-03f, -3.65219563e-02f, 7.15108663e-02f, 3.89411077e-02f, -2.65427995e-02f, 2.03649253e-02f,
  1.96314463e-03f, -1.63467191e-02f, 2.69747544e-02f, 1.38237060e-03f, -4.11254950e-02f, 2.47507114e-02f, -4.38242629e-02f, 1.39188811e-01f, 3.40267457e-02f, 9.92762893e-02f,
  -2.13564858e-01f, 6.73941597e-02f, -3.44119780e-02f, -9.39263105e-02f, 1.12900473e-01f, 1.62646428e-01f, -1.27676547e-01f, 6.88919425e-02f, -2.52294481e-01f, 1.44670859e-01f,
  1.81933627e-01f, 5.77567592e-02f, 2.02421900e-02f, -1.18181005e-03f, 1.93852827e-01f, 2.24432915e-01f, 6.67118141e-03f, -5.24571016e-02f, 2.03720510e-01f, -3.31894159e-02f,
  -1.07525953e-03f, -1.54120043e-01f, -6.61286386e-03f, -1.35827959e-01f, 8.35177153e-02f, -2.02854782e-01f, -2.16192648e-01f, 5.25617935e-02f, 1.69673696e-01f, -2.60443211e-01f,
  7.69211873e-02f, -1.16979524e-01f, -1.95675631e-04f, -1.21082090e-01f, 1.79678217e-01f, -8.75446796e-02f, 1.13436341e-01f, 1.15637831e-01f, 1.09336309e-01f, -1.03552811e-01f,
  7.33285025e-02f, 6.06137253e-02f, 1.18052617e-01f, 6.07138909e-02f, 1.26151830e-01f, 9.48518664e-02f, 7.42324293e-02f, -6.50721043e-02f, 2.25477312e-02f, 7.83704445e-02f,
  3.67791019e-02f, 3.91601622e-02f, 1.00726657e-01f, -7.94070810e-02f, 1.07243307e-01f, 1.59718245e-01f, 1.44119263e-01f, -2.79825687e-01f, -4.67705093e-02f, -2.42700540e-02f,
  5.33258431e-02f, 1.44719079e-01f, -7.77887180e-02f, 6.73367903e-02f, -1.26652822e-01f, 1.61544800e-01f, -5.72219752e-02f, -1.42649114e-01f, -4.33800779e-02f, 3.82662117e-02f,
  1.28726408e-01f, 1.17611848e-02f, 1.20576173e-01f, -1.61989987e-01f, 5.38771674e-02f, -1.65703356e-01f, 5.42789511e-03f, 1.06378764e-01f, 7.07676038e-02f, 2.93238480e-02f,
  1.29675806e-01f, 7.10091181e-03f, -1.33436695e-01f, 3.65646742e-03f, 2.96752065e-01f, 3.04060876e-01f, 9.55672488e-02f, 5.42563479e-03f, -5.44639416e-02f, -8.70452225e-02f,
  -2.29330167e-01f, 3.71575058e-02f, 7.51249418e-02f, -5.03863804e-02f, 1.01509757e-01f, 3.91259417e-02f, -4.71363915e-03f, 4.52823564e-02f, -1.95618421e-01f, 2.45442018e-01f,
  -2.84357041e-01f, -5.21286204e-02f, 2.15206239e-02f, -1.60072714e-01f, -1.17684357e-01f, -1.07739381e-01f, 1.11927181e-01f, 5.85069172e-02f, -3.66986021e-02f, -1.57642812e-02f,
  -4.90041785e-02f, 2.23837662e-02f, -1.14895523e-01f, -1.22819670e-01f, 1.56546049e-02f, -1.75588846e-01f, -1.35677740e-01f, 1.31079257e-01f, -1.06531203e-01f, 2.25588027e-02f,
  4.02092896e-02f, 1.94364786e-02f, 1.38535753e-01f, -4.95159216e-02f, -6.50202632e-02f, -1.32554516e-01f, 1.24611132e-01f, 1.61799133e-01f, -6.51761219e-02f, 1.91236511e-01f,
  1.63788810e-01f, 8.09840485e-02f, 2.56110989e-02f, -1.94837358e-02f, -1.22361556e-01f, 1.02341190e-01f, -1.37842715e-01f, 1.47271663e-01f, -1.13846041e-01f, -5.94097525e-02f,
  8.95203575e-02f, 2.25544408e-01f, 1.27020076e-01f, -8.98377448e-02f, -2.00058088e-01f, -1.29001588e-01f, 9.68236104e-02f, -1.10408731e-01f, 1.86953232e-01f, 2.98798475e-02f,
  -2.94146109e-02f, -1.68714523e-01f, -6.62736669e-02f, 2.92921960e-02f, -1.72776133e-01f, 2.27685738e-02f, 1.02099173e-01f, -1.09213188e-01f, -1.73813820e-01f, 9.90754291e-02f,
  8.23429301e-02f, 1.24712609e-01f, 2.16017261e-01f, -1.66164227e-02f, 9.46839973e-02f, 1.82351828e-01f, 1.54299304e-01f, -9.59783643e-02f, 4.16449131e-03f, 2.38292769e-01f,
  -1.07077621e-01f, -1.62742063e-01f, 1.23690583e-01f, -3.17502692e-02f, -1.15479074e-01f, 3.60105596e-02f, -1.71911009e-02f, -7.67691731e-02f, -1.07595094e-01f, -2.82204128e-03f,
  1.58702150e-01f, -9.14372802e-02f, 9.35099721e-02f, -7.71493241e-02f, 2.87850965e-02f, -1.82514682e-01f, -8.05691853e-02f, 2.29150057e-01f, -1.16243176e-02f, 1.18905030e-01f,
  1.87597305e-01f, 6.79960027e-02f, 1.06439315e-01f, 9.19998903e-03f, 1.93249777e-01f, -4.28509712e-02f, -1.39042791e-02f, 7.85166491e-03f, 1.38700325e-02f, 6.42381534e-02f,
  6.47013634e-02f, 8.42597783e-02f, -2.99698431e-02f, 1.99224398e-01f, 1.50461808e-01f, -5.85837029e-02f, 9.71841961e-02f, -2.12075952e-02f, -6.99209124e-02f, 1.99280813e-01f,
  1.89897880e-01f, -7.57603496e-02f, 1.00833587e-01f, 8.38804543e-02f, 3.96173969e-02f, 6.45780191e-02f, -9.86098275e-02f, 1.03799134e-01f, -1.03849135e-01f, 2.05558568e-01f,
  -1.58569783e-01f, -9.11119580e-02f, -1.91383399e-02f, 3.85802612e-02f, 6.58475757e-02f, -7.70350471e-02f, 3.43558602e-02f, 1.92910120e-01f, 1.43136848e-02f, -2.37572994e-02f,
  5.95897585e-02f, 1.09541677e-01f, 1.00150136e-02f, 2.31787879e-02f, -8.20476711e-02f, -6.13633869e-03f, 1.34513125e-01f, 6.79879114e-02f, 2.50503689e-01f, 4.89487238e-02f,
  5.82522713e-02f, 1.51567608e-01f, -9.12369788e-02f, -2.77998112e-02f, -6.65801158e-03f, -7.86264017e-02f, -1.22267775e-01f, 6.05814457e-02f, -3.54146841e-03f, -1.13062630e-03f,
  1.92843661e-01f, 7.37823769e-02f, 3.12758461e-02f, 9.31198243e-03f, -5.42316772e-02f, -1.49799377e-01f, 2.65138835e-01f, -8.04271922e-03f, -7.30173364e-02f, 1.58619747e-01f,
  -1.35154039e-01f, -1.64414331e-01f, 1.17447652e-01f, -1.24909349e-01f, -5.22059686e-02f, -8.30863602e-03f, -4.80585173e-02f, 3.69221456e-02f, -9.85688940e-02f, -7.39037711e-03f,
  -1.79363206e-01f, -1.85066417e-01f, 4.91819866e-02f, 2.27000430e-01f, -2.16723725e-01f, -1.13128938e-01f, 1.68254584e-01f, 1.64351135e-01f, 1.44817814e-01f, 9.98796001e-02f,
  -1.21996365e-02f, 1.87396988e-01f, -8.71798322e-02f, -7.22860545e-02f, -2.33182311e-02f, 1.82259828e-02f, 4.15691435e-02f, 1.15659982e-01f, 3.19252424e-02f, 1.85435951e-01f,
  -1.02906607e-01f, 4.49873805e-02f, 2.81949695e-02f, -1.55778125e-01f, 1.41010955e-02f, 9.15051922e-02f, 1.72698032e-02f, -1.38719961e-01f, 1.78517848e-01f, -4.86800447e-02f,
  3.39699499e-02f, -1.23936264e-02f, 3.72890085e-02f, -2.34219176e-03f, -1.07459938e-02f, 7.39544407e-02f, -1.28587320e-01f, 1.45339713e-01f, 1.30418554e-01f, 2.10695937e-02f,
  7.51220211e-02f, -2.37223431e-02f, 5.48356660e-02f, -1.50416391e-02f, -2.06869934e-02f, -5.35990782e-02f, 1.24390498e-01f, 3.69521342e-02f, -7.99560100e-02f, -6.57097176e-02f,
  8.08736077e-04f, 3.58839035e-02f, -6.50694445e-02f, -1.09322585e-01f, -1.16962507e-01f, 4.33640815e-02f, 8.58399794e-02f, -1.09746624e-02f, 7.17552677e-02f, -1.43791676e-01f,
  6.55974820e-02f, 1.70583695e-01f, 1.58835068e-01f, 2.03949392e-01f, -5.86640462e-02f, 1.20215625e-01f, 5.46353962e-03f, 4.89272289e-02f, -9.95044187e-02f, 1.08365148e-01f,
  5.17870896e-02f, 6.74638227e-02f, -1.24412030e-03f, 6.70360178e-02f, -1.30788133e-01f, -1.81263424e-02f, -6.29299879e-03f, 1.44842947e-02f, -3.77198383e-02f, 8.74164104e-02f,
  -1.67609775e-03f, -2.12465804e-02f, -1.20529987e-01f, 4.20600809e-02f, -1.73258454e-01f, 1.50226608e-01f, -1.75554872e-01f, -1.28521934e-01f, -7.48254731e-02f, 1.41201228e-01f,
  -1.73914179e-01f, -1.80261061e-01f, -1.45052165e-01f, 1.66011915e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.77908748e-01f, 8.61044750e-02f, 9.90983769e-02f, 1.17753416e-01f, 5.20002246e-02f, 8.59858915e-02f, 6.01418875e-02f, 9.46916640e-02f, -1.23032227e-01f, 6.19958974e-02f,
  -9.40425172e-02f, -8.80349204e-02f, -3.61962169e-02f, 4.05372269e-02f, 9.81625170e-02f, 2.21581131e-01f, -1.64231494e-01f, 1.34516701e-01f, 1.52123541e-01f, 1.97293647e-02f,
  1.55675948e-01f, -1.42658696e-01f, 7.88841769e-02f, 1.96100920e-01f, -4.93958630e-02f, -9.56599228e-03f, 1.95879787e-02f, -3.69529687e-02f, -1.03625931e-01f, 1.56765804e-01f,
  2.43389308e-02f, 6.05790690e-02f, -8.61815065e-02f, 3.99082787e-02f, 2.37519648e-02f, 2.17208099e-02f, 1.31418198e-01f, 2.73522466e-01f, 7.64528662e-02f, -1.56855360e-01f,
  8.84393528e-02f, -1.74309369e-02f, 1.44827664e-01f, -8.03468749e-02f, 1.64266452e-01f, 1.39275923e-01f, -5.17000742e-02f, -4.61968891e-02f, -1.16850615e-01f, -6.32321909e-02f,
  2.29546539e-02f, 1.14851773e-01f, 1.30158022e-01f, -1.65299043e-01f, 2.00036191e-03f, 1.00677058e-01f, 8.63696933e-02f, -7.24307522e-02f, 7.11522922e-02f, 1.18056349e-01f,
  6.91403523e-02f, 4.47658338e-02f, 6.86262473e-02f, -1.04131669e-01f, -4.20676433e-02f, 7.65387295e-03f, 1.76144559e-02f, 4.50707674e-02f, -1.61280148e-02f, -6.30440637e-02f,
  7.34709948e-02f, 4.81798723e-02f, -9.69966967e-03f, 2.55522430e-02f, -2.31280439e-02f, 2.46012956e-02f, -6.91034123e-02f, -1.79403406e-02f, 1.66466925e-02f, 1.03439078e-01f,
  -5.35295904e-02f, 2.78398395e-03f, 5.81328198e-02f, -2.51917727e-03f, 7.41877183e-02f, -8.49305540e-02f, 4.85621206e-02f, 1.59257904e-01f, -5.99600524e-02f, -2.35262103e-02f,
  -3.13527398e-02f, -6.55430034e-02f, -1.20827086e-01f, 8.89425278e-02f, -1.98432803e-03f, 1.04206786e-01f, -2.81157084e-02f, -5.25134280e-02f, 4.51447256e-02f, -3.72071192e-02f,
  8.05708990e-02f, 4.85012531e-02f, 4.44030538e-02f, -7.30565563e-02f, -3.42979319e-02f, -1.08102575e-01f, 5.50356805e-02f, 6.54167496e-03f, 1.18653759e-01f, 1.23952135e-01f,
  -5.51326051e-02f, -6.48206547e-02f, -1.06374510e-01f, -1.00232624e-02f, 9.37436125e-04f, 4.47427295e-02f, 2.71667354e-02f, -7.22414628e-02f, 3.45729776e-02f, -9.96623281e-03f,
  9.03872028e-02f, -6.03005998e-02f, 2.71393289e-03f, 6.44894764e-02f, 5.30507378e-02f, 1.22712441e-01f, 6.07220680e-02f, -1.24765731e-01f, -7.00997608e-03f, 4.31752466e-02f,
  8.17797408e-02f, 6.02002628e-02f, -9.72986743e-02f, -1.49393547e-02f, -4.21716683e-02f, -3.67920958e-02f, -1.29562607e-02f, -8.58189072e-03f, 7.81004280e-02f, 8.53055194e-02f,
  -3.06609962e-02f, 3.05656698e-02f, 6.13758415e-02f, -4.56367806e-02f, -6.67775348e-02f, -3.33947390e-02f, -4.64982875e-02f, -1.54936677e-02f, 1.37463622e-02f, -3.84499528e-03f,
  -4.50321846e-02f, 3.38365734e-02f, -1.53117776e-01f, 7.54162390e-03f, -1.08429361e-02f, 4.11917977e-02f, -1.94839214e-03f, -1.33062573e-02f, -3.62986773e-02f, 2.27691028e-02f,
  3.17467488e-02f, 5.10665169e-03f, -1.55476108e-02f, -8.77502337e-02f, -8.24297443e-02f, -1.39236730e-02f, -7.48430379e-03f, -4.43132129e-03f, -6.56655058e-02f, -8.70379061e-02f,
  7.90051837e-03f, 2.23462190e-02f, -8.65912903e-03f, 2.57985350e-02f, 9.03366879e-03f, -1.14180505e-01f, -2.77052663e-04f, 8.15756246e-02f, -3.38633470e-02f, 5.28398566e-02f,
  -9.51024592e-02f, -2.19772886e-02f, 8.08409899e-02f, -1.39230490e-02f, -1.56319849e-02f, 7.87882209e-02f, 1.26715610e-02f, -4.49495651e-02f, 5.69827016e-03f, 4.96627614e-02f,
  -5.35724685e-02f, 5.30122966e-02f, -1.51244206e-02f, 1.80999324e-01f, 8.04471374e-02f, 1.70490276e-02f, 6.57059178e-02f, 1.70749351e-01f, -1.60350442e-01f, -7.28800818e-02f,
  6.84265792e-02f, -1.04639098e-01f, 1.13352671e-01f, 1.88291445e-02f, 7.87881166e-02f, 1.22964747e-01f, -3.24104764e-02f, -6.72849491e-02f, 9.96560082e-02f, -6.20257743e-02f,
  -4.37046401e-02f, -1.04067817e-01f, -1.39207095e-01f, 1.37892157e-01f, -4.37016077e-02f, -6.22828491e-02f, -5.16547710e-02f, 1.18727595e-01f, -6.86989054e-02f, -1.10191546e-01f,
  -1.32414699e-01f, 1.28196925e-02f, -1.80817284e-02f, -1.05553113e-01f, -9.64040086e-02f, 2.95130670e-01f, -9.54567418e-02f, 1.15076214e-01f, -1.11080073e-01f, -5.37913963e-02f,
  -1.35335982e-01f, 9.07425657e-02f, 2.34170496e-01f, 1.55461818e-01f, -1.29059851e-01f, -1.80926770e-02f, -6.03010915e-02f, -6.18078373e-02f, 1.74073353e-01f, -1.51400780e-02f,
  7.49227777e-02f, 3.15148309e-02f, -3.27955224e-02f, 4.46635932e-02f, -2.30189823e-02f, 3.42339337e-01f, -1.28844053e-01f, -4.16854657e-02f, 1.20167108e-02f, -6.59891367e-02f,
  -6.60982132e-02f, -1.43631086e-01f, -9.56422165e-02f, -7.21957758e-02f, -1.61351666e-01f, 1.23429529e-01f, 1.21559948e-01f, 1.46398559e-01f, 1.87634587e-01f, 5.38704619e-02f,
  1.31949812e-01f, 8.20733458e-02f, -1.61445946e-01f, 5.44420443e-03f, -9.81754735e-02f, 2.07049027e-01f, -1.18595272e-01f, 1.13862537e-01f, 7.45251775e-02f, 3.13350946e-01f,
  2.02075485e-02f, -1.84530288e-01f, 1.06496096e-01f, -9.53637809e-03f, -4.75941878e-03f, 1.92356348e-01f, -5.01421690e-02f, -5.67051694e-02f, 1.88584570e-02f, -1.39142305e-01f,
  -1.10019773e-01f, 3.15807573e-02f, -1.16825551e-01f, -8.46276581e-02f, 1.33491337e-01f, 1.44505929e-02f, 2.73802895e-02f, -6.69643804e-02f, -9.06133279e-02f, 1.56683236e-01f,
  -1.53728258e-02f, -3.51279718e-03f, 2.82863043e-02f, -1.46001771e-01f, -2.34634921e-01f, 1.62284449e-01f, 9.28630009e-02f, 5.85966185e-03f, -3.60536762e-02f, -4.51269671e-02f,
  -4.52190824e-02f, -1.68786108e-01f, 1.72100857e-01f, -1.03131920e-01f, 7.49943629e-02f, 1.44750655e-01f, -2.37635057e-02f, -9.73910093e-02f, 2.52461974e-02f, 1.91130266e-01f,
  2.98734270e-02f, 2.18023822e-01f, 1.12194479e-01f, 1.00596823e-01f, -3.22834551e-02f, -9.45684910e-02f, -1.58254858e-02f, 1.30853772e-01f, -1.43992379e-01f, 7.57830963e-02f,
  -1.19477501e-02f, 1.72608957e-01f, -2.12643668e-02f, 1.11736238e-01f, 1.62464529e-01f, 1.83075830e-01f, 5.25478572e-02f, 4.98532280e-02f, -7.76763931e-02f, 1.68597192e-01f,
  -1.83267936e-01f, 1.20489813e-01f, 9.49873403e-02f, 1.85572654e-01f, -1.24595976e-02f, 7.65282810e-02f, 1.30734742e-01f, 7.33811334e-02f, 2.93739643e-02f, 2.31287479e-01f,
  -5.45116663e-02f, -1.12756640e-01f, 2.53974516e-02f, -9.69616696e-02f, 2.91706063e-02f, -3.03290505e-02f, 1.94349177e-02f, -8.70831013e-02f, 8.57885480e-02f, -8.80163163e-02f,
  -1.16544969e-01f, -2.26550385e-01f, -1.31790757e-01f, 8.24473612e-03f, 1.23259470e-01f, 8.54978636e-02f, 6.86034188e-02f, -2.47002944e-01f, 1.43368654e-02f, 1.68119684e-01f,
  -1.15333319e-01f, -3.94156016e-02f, -7.17446953e-02f, 3.23036984e-02f, -3.04444088e-03f, -8.87644142e-02f, 2.08509326e-01f, -3.61753330e-02f, 2.21869480e-02f, 7.25686103e-02f,
  -1.09571666e-02f, -7.14802146e-02f, -1.81407686e-02f, 1.56162143e-01f, 2.30030671e-01f, -5.91611536e-03f, 1.25882059e-01f, 2.56889820e-01f, -3.19142863e-02f, -1.20368630e-01f,
  1.89571887e-01f, 3.42466325e-01f, -2.38669068e-02f, -9.50202271e-02f, -1.04732111e-01f, -4.44649048e-02f, -6.51915744e-02f, 2.79448256e-02f, 1.24881499e-01f, 4.01693070e-03f,
  -4.74813767e-02f, 2.78196279e-02f, 3.76604423e-02f, 1.11675553e-01f, -3.24961729e-02f, -1.07073121e-01f, 3.92392948e-02f, 2.67400350e-02f, -9.28115100e-02f, 3.67807634e-02f,
  -1.24126039e-02f, -1.14182672e-02f, 2.20356598e-01f, 2.17834905e-01f, 6.96778819e-02f, 1.34056121e-01f, 1.64678425e-01f, 6.35552127e-03f, 2.06117436e-01f, 4.49892357e-02f,
  -1.44895837e-01f, 1.23750523e-01f, -7.66449049e-02f, 2.22519606e-01f, -4.55500409e-02f, -6.14424190e-03f, 4.84427735e-02f, 4.22522053e-02f, 2.38825426e-01f, 5.49570024e-02f,
  -5.05387746e-02f, -2.11114641e-02f, 2.26399407e-01f, 6.48181513e-02f, 1.27514511e-01f, 3.70313041e-02f, -9.19351727e-03f, -1.42594993e-01f, -1.15150213e-01f, -2.12583039e-02f,
  1.59105994e-02f, 2.36227185e-01f, 9.98620093e-02f, -9.92958620e-02f, -1.45124957e-01f, -1.88049469e-02f, 1.78516880e-01f, 1.36848226e-01f, 1.87810004e-01f, 3.72746885e-02f,
  1.49418861e-01f, 1.72716573e-01f, 1.00162126e-01f, -4.40147556e-02f, 9.49685127e-02f, 1.42244563e-01f, -1.28554836e-01f, -2.42776908e-02f, -1.16221979e-02f, -1.63546354e-02f,
  -2.12653354e-01f, -1.16366528e-01f, 7.23644421e-02f, -8.35148320e-02f, -1.17003344e-01f, 6.07017502e-02f, 1.17901720e-01f, -9.02623963e-03f, 1.27051041e-01f, 1.24571510e-02f,
  5.87515049e-02f, -3.69121172e-02f, -2.23164633e-01f, 1.20245449e-01f, 3.12746391e-02f, 2.95402692e-03f, 2.62749165e-01f, 2.23377600e-01f, -5.11849998e-03f, 1.15794092e-01f,
  2.70314157e-01f, -7.81273395e-02f, 1.48068458e-01f, -2.75097918e-02f, -1.47976637e-01f, 2.41320170e-02f, -6.76325150e-03f, 1.23771362e-01f, -1.35387592e-02f, -8.22635442e-02f,
  1.30657367e-02f, -3.42860050e-03f, 2.80963391e-01f, 1.14358731e-01f, -8.65614042e-02f, -8.15887004e-02f, 2.45405644e-01f, 2.32456118e-01f, 8.32170174e-02f, 6.20018318e-02f,
  -1.28330570e-02f, -5.65791922e-03f, -1.33573383e-01f, -5.28708100e-02f, 2.83091426e-01f, 2.48583376e-01f, 2.33162846e-02f, 1.72345772e-01f, -5.28407581e-02f, -1.75056495e-02f,
  1.23660773e-01f, 2.58583546e-01f, 7.95068145e-02f, 7.62593746e-02f, 1.42859265e-01f, 1.23810992e-01f, 5.42503297e-02f, -2.85038799e-02f, 3.92348617e-02f, 6.08706325e-02f,
  -4.50452492e-02f, 2.59816973e-03f, 1.93746001e-01f, 9.67519432e-02f, 2.12053075e-01f, 1.30963057e-01f, 2.03242809e-01f, 1.20897040e-01f, 2.08388135e-01f, -8.19944516e-02f,
  -4.49508429e-02f, -9.54811648e-02f, -6.52940497e-02f, 1.33534774e-01f, 9.17202011e-02f, -5.74823767e-02f, 6.72530904e-02f, -3.94526385e-02f, 1.28166238e-02f, 1.55063674e-01f,
  -8.21734816e-02f, 2.60486323e-02f, -7.90097099e-03f, 8.20761826e-03f, -2.08339095e-02f, -1.29116029e-01f, 5.95223624e-03f, -1.86659638e-02f, 2.27376685e-01f, 5.57945073e-02f,
  1.24004304e-01f, -1.14289664e-01f, 4.34731208e-02f, -1.85663596e-01f, 4.10556942e-02f, 1.78969409e-02f, -3.07947118e-03f, -5.66629916e-02f, 1.87858805e-01f, 4.04860452e-02f,
  -8.63590613e-02f, -5.96827492e-02f, 2.15954900e-01f, 2.28993446e-01f, 1.60854861e-01f, -4.25940603e-02f, 2.00811431e-01f, 5.56521490e-02f, -1.65904149e-01f, 7.63685107e-02f,
  5.70880882e-02f, -1.26775488e-01f, 1.91236213e-01f, -2.80705485e-02f, 3.71369198e-02f, -2.73622144e-02f, 2.42264289e-02f, 1.40207916e-01f, 9.49528720e-03f, 6.30626082e-02f,
  1.00110903e-01f, -1.74853355e-01f, 1.73114955e-01f, 1.25527933e-01f, 2.35850349e-01f, -1.88746497e-01f, -1.39140189e-01f, -1.59720272e-01f, -1.21248432e-01f, -8.70398805e-02f,
  4.03594337e-02f, -3.97730432e-02f, 3.47706378e-02f, -9.12828892e-02f, 1.26211315e-01f, -3.02115711e-03f, 1.30420208e-01f, -1.18886687e-01f, 5.10893278e-02f, -1.16608649e-01f,
  -1.22285262e-01f, 2.14929618e-02f, 3.70926932e-02f, -8.41804668e-02f, 1.86267197e-01f, 5.62703721e-02f, -6.76834360e-02f, 2.46078163e-01f, 1.24540679e-01f, -6.01841249e-02f,
  2.34035194e-01f, 5.95346978e-03f, -6.32301196e-02f, 2.04651222e-01f, -2.99540740e-02f, 1.20514045e-02f, -5.29612564e-02f, -1.22127280e-01f, 1.80918336e-01f, -6.37855055e-03f,
  1.46287695e-01f, 3.36275138e-02f, -6.85504749e-02f, -6.14929646e-02f, 2.57607788e-01f, 4.42086793e-02f, 7.71168992e-02f, 1.23762980e-01f, -9.18400288e-02f, -5.52006774e-02f,
  -7.17357174e-02f, -5.87994158e-02f, -2.95869969e-02f, 2.65700310e-01f, 1.16693646e-01f, -4.90899235e-02f, -3.44249532e-02f, -3.33513431e-02f, 1.72288790e-01f, 1.43248260e-01f,
  1.05973288e-01f, -5.83744794e-03f, -2.67391419e-03f, 1.39320135e-01f, 1.94476709e-01f, -4.29596156e-02f, 9.89023037e-03f, 9.44067072e-03f, 1.84055697e-02f, -1.22051453e-02f,
  3.44659269e-01f, 1.66706488e-01f, 1.48804739e-01f, -9.03883763e-03f, 1.67128056e-01f, 7.01757222e-02f, -1.58991963e-02f, 2.45467603e-01f, -1.36862010e-01f, 1.69883072e-01f,
  -4.79851617e-03f, 3.67291048e-02f, 1.44579068e-01f, -2.01354504e-01f, -9.76615548e-02f, 1.74040705e-01f, -3.92632466e-03f, 3.36687267e-01f, 1.28869191e-01f, 2.51442641e-01f,
  -4.44171615e-02f, -2.42750391e-01f, 1.34154946e-01f, -4.54986803e-02f, -7.21965209e-02f, 6.49154931e-02f, 3.13016325e-02f, 7.08216429e-02f, 6.70472905e-02f, -3.92384045e-02f,
  8.52497742e-02f, -1.54149666e-01f, 9.39383581e-02f, 1.16607724e-02f, 2.22424150e-01f, 2.65198965e-02f, 2.03877956e-01f, 2.45965540e-01f, 1.11223534e-01f, -4.64128144e-02f,
  1.16768807e-01f, 1.43454447e-01f, 3.20295274e-01f, 6.83621019e-02f, 6.60396367e-02f, 7.43882135e-02f, -1.36711717e-01f, 9.57896411e-02f, -1.60966322e-01f, -1.39763877e-01f,
  1.63046241e-01f, 3.45521905e-02f, 1.82412744e-01f, -2.15205580e-01f, -1.05868876e-01f, 2.72589833e-01f, -1.03540421e-01f, -9.70518738e-02f, 9.99237970e-02f, 2.75936536e-02f,
  1.27942646e-02f, 1.38971135e-01f, 1.79688364e-01f, -4.43947176e-03f, 1.71198428e-01f, 1.33651882e-01f, 2.82810301e-01f, 5.46555370e-02f, 7.53526092e-02f, 6.55580312e-02f,
  -1.31245092e-01f, 2.05183536e-01f, 9.96231334e-04f, 6.96642250e-02f, 2.65657174e-04f, -1.51644006e-01f, -7.99099430e-02f, 1.16851501e-01f, -4.62664515e-02f, 1.32335916e-01f,
  -6.37419894e-02f, 8.13506842e-02f, 2.04928648e-02f, 2.95444783e-02f, 1.93074331e-01f, -1.91066921e-01f, 9.78960916e-02f, 1.30983189e-01f, -1.07296936e-01f, 1.44650877e-01f,
  -2.83961575e-02f, -1.27482831e-01f, -1.40674546e-01f, 2.96187818e-01f, 1.53112754e-01f, 2.49044761e-01f, 7.29317442e-02f, 8.18461552e-02f, 2.92842928e-02f, 1.96149945e-01f,
  -9.15063024e-02f, 2.95589417e-01f, -1.08715050e-01f, -1.08155668e-01f, 6.60241172e-02f, 3.51852253e-02f, 1.61401808e-01f, -9.32568088e-02f, 1.05877399e-01f, 1.62904516e-01f,
  -1.77675217e-01f, 4.52587083e-02f, -8.46082941e-02f, -1.95393592e-01f, -1.01502702e-01f, 1.22535862e-02f, 1.49913460e-01f, -1.11559771e-01f, -1.54839531e-01f, 2.31073469e-01f,
  4.76223677e-02f, -1.33506268e-01f, 3.83946747e-02f, 7.64809549e-02f, -4.99691144e-02f, -2.14279182e-02f, -8.61471593e-02f, 8.84281248e-02f, 2.81734943e-01f, 5.46182357e-02f,
  2.74279136e-02f, -1.20668888e-01f, 1.74688801e-01f, 2.09644675e-01f, -2.44475855e-03f, 1.90522760e-01f, 1.00866891e-01f, -9.92121771e-02f, 1.24923602e-01f, -7.64242858e-02f,
  1.20261565e-01f, 5.08292392e-02f, -2.35709146e-01f, 2.22891510e-01f, 1.79673821e-01f, 3.20830107e-01f, 6.47459775e-02f, 1.21130906e-01f, -1.87057868e-01f, -6.23169430e-02f,
  7.38233626e-02f, -3.18915755e-01f, -1.96555573e-02f, 3.12054843e-01f, 1.02976188e-01f, 8.61182734e-02f, -1.88893136e-02f, -9.01100859e-02f, 1.46290630e-01f, -2.16728717e-01f,
  3.34026180e-02f, 1.29579738e-01f, 1.63705111e-01f, 2.73153543e-01f, 4.79901396e-02f, 1.35972992e-01f, -2.46472359e-02f, 1.24267869e-01f, 1.25571132e-01f, 1.86160281e-01f,
  1.12231821e-01f, -1.12310164e-02f, 1.40885532e-01f, 3.08533348e-02f, -6.47031888e-02f, 1.53413117e-01f, 3.39032733e-03f, -1.23479441e-02f, 1.53709352e-01f, -1.06726736e-01f,
  -1.35586062e-03f, 1.38908699e-02f, 8.17724213e-04f, 1.26838118e-01f, -1.49697989e-01f, 5.18549792e-02f, 6.31291345e-02f, -6.40041530e-02f, -4.61925566e-02f, 1.06678136e-01f,
  2.88468283e-02f, 2.36119300e-01f, 4.48235497e-02f, 1.70298517e-01f, 1.52700827e-01f, -2.29821876e-02f, 4.27988470e-02f, 7.58160651e-02f, -2.04609577e-02f, 8.75647739e-02f,
  5.33686876e-02f, -2.16519251e-03f, -1.42854946e-02f, 2.10274663e-03f, -8.49981830e-02f, 3.40651900e-01f, -2.40816362e-02f, -1.14132479e-01f, -9.63116344e-03f, 1.35131255e-02f,
  -1.22290336e-01f, 5.18114753e-02f, -9.50753763e-02f, -1.51658848e-01f, -1.65869400e-01f, -1.07308373e-01f, -6.76477179e-02f, 1.18673243e-01f, -8.15508440e-02f, -1.75753445e-03f,
  -7.79205486e-02f, 2.21799269e-01f, 1.54717356e-01f, 1.90798149e-01f, 4.02473415e-05f, 1.27557799e-01f, -1.38492212e-01f, 2.21383497e-01f, -6.70421571e-02f, -6.03737161e-02f,
  -4.60316986e-02f, 1.61211729e-01f, -1.43866241e-01f, -1.77491397e-01f, -9.30999666e-02f, 3.53422984e-02f, 3.08785774e-02f, -7.15998933e-02f, 2.17035621e-01f, -1.07277133e-01f,
  1.30106658e-01f, 5.61579578e-02f, -1.70045253e-02f, -5.21547757e-02f, -9.22671705e-02f, 2.31730379e-02f, 4.78419736e-02f, -4.02376503e-02f, 1.16479650e-01f, 1.80377856e-01f,
  -8.58218875e-03f, 4.27449606e-02f, -9.06224698e-02f, 3.51243317e-02f, -1.84990004e-01f, 2.61455178e-01f, 4.89855669e-02f, 1.86640590e-01f, 1.69696882e-01f, 1.43169954e-01f,
  1.74740523e-01f, 1.36881948e-01f, 7.88995158e-03f, -1.42264470e-01f, -6.24490716e-02f, 1.20880436e-02f, -1.71857938e-01f, 2.73451041e-02f, -5.36556691e-02f, 1.60206303e-01f,
  2.43915748e-02f, 1.71510160e-01f, -8.84724408e-02f, -1.47491351e-01f, 1.17425866e-01f, 1.73595138e-02f, 1.87933028e-01f, 6.90381899e-02f, 1.95516527e-01f, 1.48610130e-01f,
  -9.49303359e-02f, -1.90518647e-02f, -3.25438939e-02f, -1.71233982e-01f, -8.48550200e-02f, 1.22651473e-01f, -7.33689219e-02f, 6.04164824e-02f, -1.20668568e-01f, 2.36363441e-01f,
  2.71459911e-02f, -6.68441281e-02f, -5.16864397e-02f, 1.95976973e-01f, -1.02576233e-01f, -9.86634865e-02f, 2.55543649e-01f, 6.76729009e-02f, 1.29310951e-01f, -1.44819126e-01f,
  6.07194845e-03f, 7.54836947e-02f, -5.72346039e-02f, -9.80838537e-02f, -2.84822211e-02f, -8.36422145e-02f, -8.85766745e-02f, 1.87797710e-01f, -6.92998804e-03f, 2.79484183e-01f,
  5.42912558e-02f, -1.26363104e-02f, 1.14718236e-01f, 1.06916763e-01f, -1.39403706e-02f, 4.59644981e-02f, 7.36547112e-02f, 2.08120257e-01f, -8.42083842e-02f, -1.70969546e-01f,
  1.39904201e-01f, -2.13252828e-02f, 7.04838857e-02f, 5.89660257e-02f, 1.24794453e-01f, 7.30393082e-02f, -2.05686279e-02f, 9.18408781e-02f, 1.06773123e-01f, 3.13424394e-02f,
  2.52602901e-02f, -7.76125640e-02f, 1.65136784e-01f, -2.57334989e-02f, -7.19310790e-02f, 1.68817878e-01f, 8.72708708e-02f, 2.20684707e-03f, 8.13890994e-02f, -2.81472933e-02f,
  1.52183086e-01f, 8.35663676e-02f, 1.20202385e-01f, -5.00842296e-02f, -2.12575477e-02f, 5.50119989e-02f, 2.04546124e-01f, 1.05721630e-01f, 1.12616755e-01f, -3.64378020e-02f,
  2.99870037e-02f, 6.16100021e-02f, 1.59798682e-01f, 1.22937439e-02f, 9.96924378e-03f, -1.10731073e-01f, -3.97730619e-02f, 1.22862101e-01f, -2.51285397e-02f, 1.50858937e-03f,
  5.24735786e-02f, 2.51220971e-01f, 1.43918693e-01f, 2.24484932e-02f, -1.47895724e-01f, 1.80707067e-01f, -1.34766579e-01f, 2.55448520e-01f, 9.08303540e-04f, 8.19073766e-02f,
  -1.32808775e-01f, 2.96717025e-02f, 1.52474180e-01f, -1.68612134e-02f, -2.89322548e-02f, 2.38841787e-01f, -1.33870229e-01f, -1.03025474e-02f, 1.52401686e-01f, 6.24785153e-03f,
  -7.04425648e-02f, -1.76240988e-02f, -1.04992948e-01f, -7.83371702e-02f, 1.48271680e-01f, 2.25752518e-01f, 1.58352852e-01f, 7.21444935e-02f, 3.83452103e-02f, 1.63901016e-01f,
  -1.78940803e-01f, -7.45371506e-02f, 2.46775635e-02f, 2.09951982e-01f, -6.96512312e-02f, 1.65890783e-01f, 1.05857730e-01f, 1.00789823e-01f, 7.95702916e-03f, -1.29019126e-01f,
  1.48431689e-01f, 6.70060441e-02f, 5.55081181e-02f, 1.56684726e-01f, 1.10790327e-01f, -1.53635135e-02f, -2.41439007e-02f, -1.65104479e-01f, -1.20050520e-01f, -9.75828692e-02f,
  -2.11838204e-02f, -1.17049932e-01f, 2.47575492e-01f, -8.16209540e-02f, -2.14802902e-02f, -9.23443884e-02f, -3.31579931e-02f, 1.80786654e-01f, -1.01168510e-02f, -8.77107903e-02f,
  1.28050447e-01f, -1.22088641e-01f, -2.32751489e-01f, 1.62113324e-01f, 3.90661769e-02f, 1.36701956e-01f, -8.88201147e-02f, 6.49455143e-03f, -9.75477323e-02f, -1.25232428e-01f,
  1.46288350e-01f, 8.57207179e-03f, 5.05025648e-02f, 1.93582267e-01f, -5.88372536e-02f, -6.77945912e-02f, -1.71815907e-03f, 1.32666141e-01f, -9.93588790e-02f, 1.77170634e-01f,
  -5.90975676e-03f, 5.51933795e-02f, -5.97138070e-02f, -5.72251901e-02f, -4.10126969e-02f, 1.59510136e-01f, -9.92769226e-02f, -2.75649596e-02f, 4.71460149e-02f, -4.46288195e-03f,
  1.70360297e-01f, 1.73055008e-01f, 3.70692797e-02f, 8.32253918e-02f, -1.70067415e-01f, 6.22832440e-02f, 1.08426459e-01f, -1.72405034e-01f, -3.58980522e-02f, -1.34242415e-01f,
  -1.04154475e-01f, 1.87297121e-01f, 2.30405405e-02f, 5.56847565e-02f, 4.19315249e-02f, -3.57924914e-03f, -1.66302681e-01f, -1.83826268e-01f, 1.09062426e-01f, -1.65394042e-02f,
  -9.21889544e-02f, -3.32508907e-02f, -1.25060767e-01f, 2.59578489e-02f, 3.14484554e-04f, -5.47632761e-02f, -2.17956267e-02f, 5.16878329e-02f, 1.19310990e-01f, 2.71821380e-01f,
  6.41061692e-03f, 7.63063207e-02f, -1.96180373e-01f, 1.34226605e-01f, -1.94377914e-01f, 2.17873141e-01f, -5.44758178e-02f, 4.72827964e-02f, -2.07207482e-02f, -1.43507635e-02f,
  -1.95296537e-02f, 4.27076146e-02f, 1.07554076e-02f, 1.16128229e-01f, 1.80982485e-01f, -1.51734158e-01f, -3.06968708e-02f, 1.57582849e-01f, -2.39052530e-02f, 9.42551345e-02f,
  -2.01562911e-01f, 3.95621620e-02f, -9.86591130e-02f, 6.93248771e-03f, 1.24849357e-01f, -1.13986194e-01f, -1.77702039e-01f, 2.61813939e-01f, -6.53777644e-03f, -2.11836100e-01f,
  -3.48403305e-02f, 1.63908184e-01f, -5.17035602e-03f, -1.04517862e-01f, 2.19562516e-01f, 2.14532718e-01f, 5.98870590e-02f, 3.33184041e-02f, 1.51487470e-01f, -1.52142316e-01f,
  4.46468405e-02f, -1.53006390e-01f, -1.71078071e-02f, -1.69223964e-01f, -8.96174535e-02f, 7.14195594e-02f, 1.34891495e-01f, -3.65827158e-02f, -5.66382036e-02f, -1.78043112e-01f,
  4.06260379e-02f, -2.87787646e-01f, 1.11393765e-01f, 2.59958148e-01f, -1.52821466e-02f, 2.47187719e-01f, 1.91018552e-01f, 5.27363690e-03f, 8.04233775e-02f, 1.10953063e-01f,
  -1.55914932e-01f, 9.25957263e-02f, 5.53385168e-02f, 8.55439082e-02f, 1.01512901e-01f, -1.80899978e-01f, -1.61766652e-02f, -1.11982323e-01f, -5.67555055e-02f, 2.55294830e-01f,
  1.34711415e-01f, -1.60115853e-01f, 1.04176730e-01f, -1.11544151e-02f, 5.44143580e-02f, 1.75504405e-02f, 1.97959289e-01f, 2.09970072e-01f, -2.46992484e-02f, 3.13194767e-02f,
  2.02790797e-01f, 8.76443088e-02f, 3.40733603e-02f, 6.92488402e-02f, 2.03284949e-01f, 4.62463535e-02f, 9.30528715e-02f, -1.41369998e-01f, 1.67014092e-01f, 4.95208204e-02f,
  1.42451495e-01f, 2.10948586e-02f, 8.47906396e-02f, -1.93457365e-01f, 1.28857836e-01f, -7.70420767e-03f, 1.95369005e-01f, 1.42244637e-01f, 1.51788995e-01f, 8.47980753e-02f,
  9.30032432e-02f, 1.46224976e-01f, -5.10504246e-02f, 1.20493114e-01f, 5.76976761e-02f, -1.21740431e-01f, 1.25069767e-01f, 6.33238852e-02f, 1.79421395e-01f, -4.16233838e-02f,
  1.06564693e-01f, -2.50511570e-03f, 1.17788531e-01f, 1.69811368e-01f, -1.15109764e-01f, -2.20349897e-02f, 4.54812422e-02f, -1.26430571e-01f, -1.54935181e-01f, -8.72441456e-02f,
  3.08340415e-02f, -2.92423628e-02f, 9.32526216e-02f, 1.45149389e-02f, 1.47577196e-01f, -7.15570748e-02f, 1.37713075e-01f, 1.56628639e-01f, 4.27138470e-02f, -1.69847846e-01f,
  3.70558053e-02f, 5.79512976e-02f, 2.29920924e-01f, -8.23880285e-02f, 6.62882533e-03f, -3.86540331e-02f, -1.94215432e-01f, 5.58945239e-02f, 6.90143183e-02f, 1.69026777e-01f,
  3.78019065e-02f, 1.22187629e-01f, 9.65773221e-03f, -1.06363250e-02f, 3.25055346e-02f, 1.00515321e-01f, 2.61506379e-01f, 1.11160632e-02f, -8.72457772e-02f, -7.52981976e-02f,
  -1.19787008e-01f, -1.73175912e-02f, -9.48925093e-02f, -1.31434575e-01f, -8.01198334e-02f, 1.39812931e-01f, 1.02217542e-02f, -2.01581910e-01f, 2.62943596e-01f, 6.49605989e-02f,
  3.67164314e-02f, 1.75739646e-01f, 8.20209384e-02f, 1.27581477e-01f, 9.84999686e-02f, 1.76405966e-01f, -2.04552487e-01f, 1.33414060e-01f, 9.79882032e-02f, 4.21345755e-02f,
  4.29564603e-02f, -2.19631158e-02f, 7.32215345e-02f, 1.30451277e-01f, -3.05568501e-02f, 5.35236485e-02f, 1.21589713e-01f, 1.88047528e-01f, -7.88039118e-02f, 1.55811325e-01f,
  5.29871546e-02f, -1.70651257e-01f, -1.15467019e-01f, -4.43955548e-02f, -8.78008753e-02f, 7.59946853e-02f, 1.13149688e-01f, 4.40316424e-02f, 1.49418503e-01f, 7.57972449e-02f,
  1.76112473e-01f, 1.45868853e-01f, 7.77394474e-02f, -4.35813738e-04f, 2.92048324e-02f, 2.15675801e-01f, 8.63320008e-02f, 3.52946036e-02f, -9.30214208e-03f, 1.38701066e-01f,
  -1.41943663e-01f, -1.22385927e-01f, -3.18556875e-02f, 9.51754376e-02f, 7.32005462e-02f, 1.65745001e-02f, 1.17670581e-01f, -7.76726054e-03f, -3.92008871e-02f, 1.38190344e-01f,
  1.53735936e-01f, -1.10420741e-01f, -1.54135615e-01f, -1.19097658e-01f, -1.73331559e-01f, 1.37036502e-01f, -1.10330964e-02f, -1.13824233e-01f, -5.79251014e-02f, 1.90846294e-01f,
  -1.16675295e-01f, -8.26011822e-02f, -2.62758695e-02f, 2.18096703e-01f, 1.63953871e-01f, 8.10771808e-02f, 4.99646217e-02f, 4.98651713e-02f, 9.08379555e-02f, 1.10295981e-01f,
  -9.94035378e-02f, 1.67490855e-01f, -5.07362187e-02f, 3.59092727e-02f, 9.99285653e-02f, 1.42116159e-01f, 1.83974624e-01f, 7.52414390e-02f, -1.43336415e-01f, -3.40978988e-02f,
  1.84294939e-01f, 2.49583349e-01f, 1.41574247e-02f, 1.87353984e-01f, -2.27415085e-01f, -2.52937675e-01f, -1.00303292e-01f, -2.22584814e-01f, 3.71162556e-02f, 1.58247501e-01f,
  5.41365407e-02f, 5.45723848e-02f, 9.87188444e-02f, 1.38336271e-01f, 1.33661687e-01f, -1.07352875e-01f, -6.48264810e-02f, -4.11730111e-02f, 6.44540191e-02f, 2.52732098e-01f,
  3.65072578e-01f, -1.14491269e-01f, 5.50874807e-02f, 2.40405232e-01f, -3.41369845e-02f, -7.93597475e-02f, 7.05732778e-02f, 1.21503353e-01f, 2.33804390e-01f, -6.19765595e-02f,
  1.63254157e-01f, 1.84158683e-02f, -8.51269066e-02f, 1.46757504e-02f, 3.22424471e-01f, -1.52949572e-01f, -4.85729724e-02f, -8.44876543e-02f, -1.38906166e-01f, -4.64262888e-02f,
  -1.19641066e-01f, -4.11025770e-02f, -4.34748419e-02f, -4.54998985e-02f, -1.02683455e-02f, 1.02636710e-01f, 1.46032915e-01f, 1.15483083e-01f, 1.10553158e-02f, -6.02182327e-03f,
  6.70732558e-02f, 1.00598708e-01f, 1.36173919e-01f, 1.67203575e-01f, 1.54479548e-01f, -4.13256884e-02f, 7.23996684e-02f, -1.42266780e-01f, 9.37073156e-02f, 3.48320156e-02f,
  1.23820603e-01f, -1.40240103e-01f, 8.63542855e-02f, 9.45819318e-02f, 1.75546810e-01f, 1.48081966e-02f, -8.18531439e-02f, -1.36587650e-01f, 9.57571715e-02f, 2.29244217e-01f,
  -2.80333571e-02f, -2.30180635e-03f, -6.19376302e-02f, -2.90337726e-02f, 1.57834783e-01f, 7.49114901e-02f, 2.26703137e-01f, -2.45909914e-01f, 6.89600687e-03f, 1.86632991e-01f,
  1.36095241e-01f, 4.92288992e-02f, -7.47429878e-02f, -1.61046296e-01f, -6.97802529e-02f, 1.02080926e-01f, 4.55090180e-02f, -5.56649715e-02f, 5.28360680e-02f, 1.72646374e-01f,
  -5.06471246e-02f, 1.29568830e-01f, -1.67015433e-01f, 9.62111875e-02f, 4.29121172e-03f, 1.00537725e-01f, 8.69394317e-02f, 8.97628665e-02f, 6.48361519e-02f, 6.00237139e-02f,
  4.86566871e-03f, 1.01683505e-01f, -2.00973339e-02f, 7.46296048e-02f, -1.50631815e-01f, -7.85943791e-02f, -1.64271030e-03f, 8.58412907e-02f, -8.22167024e-02f, -2.31450438e-01f,
  1.01906143e-01f, -4.80915122e-02f, 4.07219529e-02f, -5.37031442e-02f, -4.45883814e-03f, 1.28315955e-01f, 6.18440062e-02f, 4.23382260e-02f, -6.73112124e-02f, 3.64250056e-02f,
  1.98835775e-01f, -1.52546018e-01f, 1.18711717e-01f, -1.03713356e-01f, 1.22566611e-01f, 9.26476941e-02f, 8.65180343e-02f, -1.02743618e-01f, 1.00026324e-01f, 2.79494538e-03f,
  -8.26645195e-02f, -1.00587167e-01f, 6.38426542e-02f, 1.34634316e-01f, -9.95563120e-02f, 4.45694989e-03f, 1.92365870e-02f, -6.87521230e-03f, 2.22367868e-01f, 1.36013120e-01f,
  1.68939605e-01f, -6.27831891e-02f, 7.35501200e-03f, 1.78281054e-01f, 1.94880247e-01f, -1.33697912e-01f, -9.21119228e-02f, -2.62703113e-02f, -7.28887916e-02f, 9.01410431e-02f,
  1.15589954e-01f, 1.72231138e-01f, -4.75730151e-02f, 7.01942667e-02f, -1.53658077e-01f, 1.14041023e-01f, -1.41969562e-01f, 8.45391676e-02f, 2.06721798e-01f, 1.10255025e-01f,
  1.44350771e-02f, 2.52907485e-01f, -1.44614233e-02f, 7.77444020e-02f, 5.64127171e-04f, 1.39472038e-01f, -4.75565679e-02f, 2.35111304e-02f, -7.14797601e-02f, 7.66714662e-03f,
  1.87917687e-02f, 1.01491831e-01f, -1.27100199e-01f, -1.34986088e-01f, -3.35316025e-02f, 2.00023100e-01f, 1.13048382e-01f, 4.11150269e-02f, 1.28988683e-01f, 5.91906495e-02f,
  1.16266549e-01f, 2.19022349e-01f, 1.44808754e-01f, -5.75200282e-02f, 1.34615377e-02f, -2.54803300e-01f, 1.04582317e-01f, 3.42750847e-02f, 7.75833800e-02f, -1.87536567e-01f,
  1.72711253e-01f, 5.00955768e-02f, 7.50547871e-02f, 8.31220970e-02f, -1.29699558e-01f, -1.93227708e-01f, 4.68885787e-02f, 1.85711414e-01f, -1.04414299e-01f, 8.87270737e-03f,
  -8.48933384e-02f, 2.05168612e-02f, 2.56464690e-01f, -1.86562892e-02f, 1.66009173e-01f, -2.81934738e-01f, -3.23784016e-02f, -7.00175911e-02f, -1.70145985e-02f, 5.74935339e-02f,
  -1.35489702e-01f, -1.64749414e-01f, -7.64213502e-02f, 2.08002821e-01f, -7.12861046e-02f, -3.39088775e-02f, 1.60127267e-01f, 2.18325481e-01f, 8.41204375e-02f, 1.19826771e-01f,
  3.57368141e-02f, 1.27198517e-01f, -6.39171228e-02f, 4.26770970e-02f, 2.29829587e-02f, 1.90183520e-01f, 1.26292259e-02f, 1.38414159e-01f, -6.23603687e-02f, 1.63271084e-01f,
  4.78226766e-02f, 6.64460957e-02f, -7.07994327e-02f, -3.35271866e-03f, 2.91169509e-02f, -4.98898588e-02f, 1.50568970e-03f, -2.23500669e-01f, 1.51211143e-01f, -5.85987512e-03f,
  5.74234053e-02f, 6.86937496e-02f, 1.21592291e-01f, 2.05756262e-01f, 1.37490079e-01f, 3.08567304e-02f, 7.84449503e-02f, 8.51194412e-02f, -8.35707784e-02f, -1.80755436e-01f,
  -4.38324176e-02f, -7.61941299e-02f, -6.57927021e-02f, -3.64061221e-02f, 2.27953777e-01f, 7.44029805e-02f, -8.94066319e-02f, -8.51773694e-02f, -5.42393476e-02f, -2.13499665e-01f,
  2.44328693e-01f, -6.80873245e-02f, -3.68557125e-02f, 2.13414475e-01f, -1.77133121e-02f, -1.22705311e-01f, 5.21116741e-02f, -2.73045264e-02f, -1.29279643e-01f, 4.42228019e-02f,
  9.97046307e-02f, 3.43099505e-01f, 9.20909867e-02f, -1.92474023e-01f, -1.10796697e-01f, -1.16815858e-01f, 6.07754216e-02f, 1.15264028e-01f, 4.26873788e-02f, -1.92592368e-01f,
  -3.58150899e-03f, -8.54334012e-02f, 1.13988131e-01f, 7.94465914e-02f, 1.05451427e-01f, 1.95248514e-01f, 5.30944541e-02f, -1.35016218e-01f, -8.68023336e-02f, 9.23103243e-02f,
  6.65843040e-02f, 1.81620941e-01f, 3.98090631e-02f, -1.38390884e-01f, 6.01581950e-03f, 7.93391466e-02f, 1.51478291e-01f, -1.61193565e-01f, -1.78759638e-02f, 2.46447071e-01f,
  2.48342790e-02f, -1.85071588e-01f, 1.28638446e-01f, 2.31751576e-02f, -2.28512846e-02f, -5.84955178e-02f, -1.69313073e-01f, -9.46266502e-02f, 9.52014625e-02f, -4.29992676e-02f,
  1.70037717e-01f, -3.99763638e-04f, -8.20365082e-03f, 1.31887451e-01f, 1.50585780e-03f, -1.56939905e-02f, 9.42387581e-02f, -1.03209466e-02f, 4.22262475e-02f, 2.43135005e-01f,
  -3.96928936e-02f, 1.10970259e-01f, 9.39447209e-02f, 2.16250181e-01f, -1.51626468e-01f, -6.63535148e-02f, 1.30170345e-01f, -8.08121040e-02f, 1.27900422e-01f, 1.03534937e-01f,
  -4.49863523e-02f, 1.42115444e-01f, 1.82972115e-03f, -1.32843941e-01f, -5.97671233e-02f, -6.40636533e-02f, 4.13846318e-03f, 3.17843556e-02f, 8.63659829e-02f, 1.04821168e-01f,
  -5.23301177e-02f, -1.30407095e-01f, 2.24382862e-01f, 5.37875183e-02f, -7.37297460e-02f, -1.16392046e-01f, 3.44363824e-02f, -7.83427656e-02f, -4.44994075e-03f, -5.43826260e-02f,
  3.35999914e-02f, 8.04685876e-02f, 6.82397485e-02f, -1.21069066e-01f, -2.04887800e-03f, 1.13357492e-02f, -6.47276938e-02f, -1.15233064e-01f, 2.60587752e-01f, -3.64025831e-02f,
  7.57031813e-02f, 1.55896679e-01f, 9.42178257e-03f, -4.51671481e-02f, 1.45362794e-01f, 2.22660258e-01f, 2.21700799e-02f, -8.95051435e-02f, 3.81260142e-02f, 1.54059559e-01f,
  7.36406958e-03f, 7.53022805e-02f, 2.76929028e-02f, -1.52616529e-02f, 3.08520850e-02f, -1.14478273e-02f, -1.61975414e-01f, 1.22882247e-01f, -1.36177421e-01f, -2.09213290e-02f,
  -3.52199259e-03f, -4.79510315e-02f, -5.00123948e-03f, 2.36605182e-01f, -9.46056768e-02f, 7.64706284e-02f, 1.67545781e-01f, 2.25164324e-01f, 1.43575937e-01f, -1.76027507e-01f,
  1.97904289e-01f, 2.02249125e-01f, 3.60958427e-02f, -5.69106452e-02f, -1.10523470e-01f, -1.02811068e-01f, -1.65561423e-01f, 1.33394390e-01f, 9.69512016e-03f, -4.78731468e-02f,
  -9.72187817e-02f, 9.98635776e-03f, 1.26768082e-01f, 4.37160172e-02f, 1.77812949e-01f, -2.02934537e-02f, 1.31941929e-01f, -7.29636401e-02f, 1.21106505e-01f, -3.24713401e-02f,
  2.13562042e-01f, -8.86816233e-02f, 1.08259656e-01f, 2.59063821e-02f, -9.69283357e-02f, -1.09041236e-01f, -9.38647613e-02f, -1.42657161e-01f, 1.43132359e-01f, -1.93876959e-02f,
  -1.62873715e-02f, 6.07054494e-02f, 8.48173723e-02f, 2.51366980e-02f, 1.77196383e-01f, 3.98210977e-04f, -4.32628877e-02f, 4.72727325e-03f, 1.30724132e-01f, 2.25360513e-01f,
  1.97612524e-01f, -1.37687266e-01f, 2.53459752e-01f, 1.18228398e-01f, 2.08585829e-01f, 1.16302535e-01f, 1.12827346e-01f, 7.24672154e-02f, 1.99073507e-03f, 8.85138214e-02f,
  1.05102368e-01f, 1.81828197e-02f, -3.45689878e-02f, -1.25065356e-01f, -4.49583167e-03f, -3.14865336e-02f, 6.39385283e-02f, 1.14037521e-01f, 1.87670402e-02f, -7.24121854e-02f,
  9.15842280e-02f, -5.31912930e-02f, 2.28273779e-01f, 1.46386087e-01f, 1.08165257e-01f, 1.29682913e-01f, -1.52388260e-01f, -3.06232367e-02f, 8.03366601e-02f, -5.59189096e-02f,
  7.67601505e-02f, 1.91247463e-02f, -1.11431908e-02f, 1.44771755e-01f, 5.97934388e-02f, 2.02551007e-01f, 4.96110730e-02f, -2.03934267e-01f, -6.42328411e-02f, 2.73818552e-01f,
  -1.00183696e-01f, -1.89128593e-01f, 2.85473347e-01f, 1.74317181e-01f, 1.68269664e-01f, -3.20673324e-02f, -3.65717635e-02f, 2.07049355e-01f, -9.40820128e-02f, 6.63584694e-02f,
  -6.61790594e-02f, -7.24293217e-02f, -1.50678009e-01f, 6.74684048e-02f, 1.92189246e-01f, 1.25624210e-01f, -1.47473827e-01f, 2.01771021e-01f, -1.08359046e-01f, -8.36156979e-02f,
  9.36751589e-02f, 7.94127956e-02f, -5.86882830e-02f, -1.18675686e-01f, -6.26850575e-02f, -9.24357325e-02f, 5.69781326e-02f, 1.33017227e-01f, 2.27857679e-01f, 2.34224111e-01f,
  1.82454556e-01f, 1.68865129e-01f, -3.58876288e-02f, 1.78979322e-01f, 3.59315425e-02f, -2.43226990e-01f, 5.61692426e-03f, -6.37973249e-02f, 2.42460910e-02f, -3.59688438e-02f,
  1.23402223e-01f, 9.18609276e-02f, 6.98321685e-02f, 2.10770845e-01f, -1.32962555e-01f, -1.28949642e-01f, 1.55479446e-01f, -1.70074582e-01f, -1.00396901e-01f, 1.18677199e-01f,
  2.41009630e-02f, -3.93969342e-02f, 2.14914426e-01f, -2.61595640e-02f, -1.14793889e-02f, 9.49559510e-02f, 1.58726752e-01f, 2.03373566e-01f, 7.61800483e-02f, -2.05817088e-01f,
  -3.64622958e-02f, 8.50488916e-02f, 2.48975530e-01f, 4.55609486e-02f, -1.99621357e-02f, -6.27627829e-03f, -2.19380409e-01f, -7.18722865e-02f, 3.55393179e-02f, 1.99987188e-01f,
  1.36650518e-01f, 1.44321993e-01f, 4.67256121e-02f, -1.87193677e-01f, -9.66280401e-02f, 1.07955053e-01f, 2.72417963e-01f, -5.04894629e-02f, -5.18868603e-02f, -1.95651978e-01f,
  -6.56494349e-02f, -6.45138323e-02f, 8.00255910e-02f, -1.21967532e-01f, -5.47748841e-02f, 1.79339498e-01f, 1.39963716e-01f, -2.14454100e-01f, 3.03479522e-01f, 1.43896848e-01f,
  1.56487226e-01f, 1.42373130e-01f, 9.73911304e-03f, 4.47391160e-02f, 1.10389076e-01f, -5.71745355e-03f, -8.03756714e-02f, 8.86739865e-02f, -1.07858188e-01f, 2.34773144e-01f,
  -2.24940658e-01f, 1.40349686e-01f, 9.75876004e-02f, -7.15250447e-02f, 9.51305106e-02f, 1.75492257e-01f, 3.60318497e-02f, 1.03808558e-02f, 1.54708490e-01f, 3.29851508e-01f,
  1.77667096e-01f, 2.36407034e-02f, 1.37482166e-01f, -1.07318154e-02f, -4.45968239e-03f, -1.52141228e-01f, -1.28673073e-02f, -1.07765757e-01f, -2.68460461e-03f, -1.02863805e-02f,
  4.88031432e-02f, 2.03170329e-01f, -6.00939058e-02f, 1.65008247e-01f, 2.18415648e-01f, -4.21198495e-02f, 2.21808910e-01f, -7.90309235e-02f, -7.78786466e-02f, -1.20874770e-01f,
  6.14732392e-02f, 1.27037600e-01f, 4.79816906e-02f, -3.16238143e-02f, 1.67709161e-02f, 6.90777004e-02f, 1.22438502e-02f, -5.06597571e-03f, -1.07793286e-01f, 1.06342630e-02f,
  7.56961033e-02f, 8.39958712e-02f, 9.96093266e-03f, 7.06398338e-02f, -7.78207034e-02f, 3.31430137e-01f, -1.48377018e-02f, -7.68994913e-02f, -6.76791184e-03f, 7.51919672e-02f,
  7.60890767e-02f, 1.85724333e-01f, 9.92082134e-02f, -1.67401657e-02f, 1.28045052e-01f, 2.25616574e-01f, 1.21780202e-01f, 1.05734169e-01f, -2.56519876e-02f, 1.11103438e-01f,
  -1.48827672e-01f, 4.32364009e-02f, -1.68270916e-01f, 1.93616211e-01f, -1.44210488e-01f, 6.91890568e-02f, 1.07686445e-01f, -1.98546126e-02f, 1.35633871e-02f, 1.04642831e-01f,
  -1.10411784e-02f, 7.95805901e-02f, 1.12866841e-01f, 2.43592635e-01f, 1.00100301e-01f, 8.10224190e-03f, 1.92856997e-01f, 7.48633295e-02f, -5.22863790e-02f, -1.42924622e-01f,
  7.23811099e-04f, -8.43126997e-02f, -4.48027207e-03f, 6.33669645e-02f, 1.96604244e-02f, 8.60445648e-02f, -1.13087483e-01f, 1.20797493e-01f, 1.04148731e-01f, -2.40084976e-02f,
  2.46418625e-01f, 3.29325162e-02f, -2.37337835e-02f, -1.32973164e-01f, 2.28265062e-01f, 1.57197922e-01f, 1.75237656e-01f, -3.74513119e-02f, 1.06078908e-01f, -2.26519369e-02f,
  -6.59419745e-02f, -2.77140643e-02f, -7.88727850e-02f, -6.47058040e-02f, 1.36098355e-01f, 6.41217679e-02f, 1.59301937e-01f, 5.99216409e-02f, -7.23374709e-02f, 2.26583764e-01f,
  5.66194244e-02f, -4.30432148e-02f, 7.49273505e-03f, -3.18392925e-02f, 8.55118856e-02f, 6.40984476e-02f, 1.21699229e-01f, -1.75199404e-01f, -8.47671460e-03f, 4.05347869e-02f,
  -6.05039410e-02f, 1.87592059e-01f, -3.27124447e-02f, 4.96013686e-02f, -2.42276564e-01f, -5.81532083e-02f, 2.07637906e-01f, -1.18266251e-02f, -3.35047692e-02f, 9.15115848e-02f,
  1.69682100e-01f, 1.24373399e-01f, 4.52740751e-02f, -2.21932188e-01f, 2.28618801e-01f, -1.22476049e-01f, -7.26715475e-02f, -5.28913364e-02f, 2.41509303e-01f, 4.94645610e-02f,
  -1.71269819e-01f, 3.38867977e-02f, -1.19123228e-01f, -1.44140586e-01f, 9.19523016e-02f, -9.25018638e-02f, 2.24253759e-01f, -1.73003867e-01f, -8.45631137e-02f, 1.75504342e-01f,
  1.00711226e-01f, -1.76041543e-01f, -1.51626006e-01f, -1.48378074e-01f, 2.05841986e-03f, -1.84973508e-01f, 4.74887481e-03f, 1.29020125e-01f, -2.60899514e-01f, -4.92067784e-02f,
  -3.20610166e-01f, 2.46944517e-01f, -2.12816760e-01f, 1.14966378e-01f, 2.95808643e-01f, -9.87496004e-02f, -1.54490843e-01f, 4.39242095e-01f, 1.07808802e-02f, 5.89605495e-02f,
  -1.72190174e-01f, 1.97275653e-01f, -7.70209208e-02f, 1.62776083e-01f, 1.26004279e-01f, -1.00320928e-01f, -1.81167945e-01f, 2.17879638e-01f, -1.20890595e-01f, -7.13199675e-02f,
  -3.35330144e-02f, 8.27455670e-02f, 2.47844290e-02f, 3.62454057e-02f, 8.40156674e-02f, 1.18008569e-01f, 6.67207018e-02f, -1.39132934e-02f, 1.01701282e-01f, -1.37971237e-01f,
  -1.10990942e-01f, 1.47829577e-01f, -2.30055109e-01f, 3.15445252e-02f, 1.66147798e-02f, 1.60359383e-01f, 7.85637274e-02f, 7.84328952e-02f, -3.04343775e-02f, -5.98603934e-02f,
  2.09365681e-01f, 1.06511027e-01f, 1.93532601e-01f, 6.28513321e-02f, 1.60504639e-01f, 2.14765221e-01f, 5.48470905e-03f, -3.94339263e-02f, -1.03073098e-01f, -1.29049569e-01f,
  -3.39595713e-02f, 2.71233827e-01f, -7.40397796e-02f, -6.75952882e-02f, -1.65003866e-01f, 1.67773634e-01f, 6.37834668e-02f, -6.51766360e-02f, -3.77880856e-02f, -3.57330069e-02f,
  5.09047997e-04f, 1.21011795e-03f, 9.79575291e-02f, 8.27139318e-02f, 8.94558281e-02f, -1.72962576e-01f, 3.20651708e-03f, 1.13615487e-02f, 2.80400217e-02f, -6.85594678e-02f,
  7.37197138e-03f, -5.67489192e-02f, -2.05498129e-01f, 9.62404907e-02f, 1.70125514e-01f, 2.23967850e-01f, 2.34898239e-01f, -4.39963713e-02f, 2.13950470e-01f, 2.48426586e-01f,
  1.39008254e-01f, -1.18315682e-01f, 1.87139839e-01f, 3.04690987e-01f, -1.55703992e-01f, -2.55495757e-01f, -6.91600889e-02f, -1.46305049e-02f, -3.72820497e-02f, 2.11299270e-01f,
  2.77434532e-02f, 5.79657406e-02f, -2.19867423e-01f, -1.11434512e-01f, 1.64092183e-01f, -2.23140463e-01f, 3.20036560e-02f, 5.33971451e-02f, 4.21889834e-02f, 1.17242403e-01f,
  1.24213316e-01f, -2.22872719e-02f, 1.79241613e-01f, -1.20501332e-01f, -8.50214288e-02f, -4.87682708e-02f, 1.37977123e-01f, 1.59464091e-01f, -7.19453618e-02f, -4.28285636e-02f,
  -1.50149539e-01f, -1.83912650e-01f, 9.25137848e-02f, -1.18941873e-01f, 1.70170933e-01f, -1.89118907e-01f, 3.04170027e-02f, 3.18720162e-01f, 6.06011562e-02f, 1.18378170e-01f,
  -2.04448789e-01f, -1.31827042e-01f, -7.48662502e-02f, -1.31370082e-01f, -5.76786473e-02f, 7.80401081e-02f, 1.30101964e-01f, 9.94932801e-02f, -2.78190017e-01f, 1.17270477e-01f,
  -1.68867201e-01f, -1.41218239e-02f, 3.91359150e-01f, -1.79372668e-01f, -8.49909112e-02f, 4.18960750e-01f, 8.22389778e-03f, 1.08493462e-01f, -1.15128718e-01f, 2.66173869e-01f,
  -7.66564831e-02f, 1.13787629e-01f, 1.22486472e-01f, -1.38369516e-01f, -2.30394885e-01f, 1.76392972e-01f, -1.17793707e-02f, -1.20427653e-01f, -6.53133988e-02f, 7.07051083e-02f,
  6.67270273e-02f, 8.56773183e-02f, 2.31825411e-01f, 2.51937598e-01f, 1.51483133e-01f, 1.40045717e-01f, -1.98934823e-02f, 2.20596865e-01f, -3.29261869e-02f, -1.61576793e-01f,
  2.99969921e-03f, -7.77893662e-02f, -1.34001330e-01f, 2.07872525e-01f, 1.64044932e-01f, -1.98710989e-02f, -6.51152432e-02f, 6.06999621e-02f, -1.80524439e-01f, -9.28686783e-02f,
  -5.15702507e-03f, -1.01095110e-01f, -1.78839788e-01f, -5.34781553e-02f, -4.43872474e-02f, 7.07145929e-02f, -9.29519013e-02f, 3.76261547e-02f, -1.52973756e-01f, 9.92487818e-02f,
  1.12116404e-01f, 2.73345679e-01f, 2.17150729e-02f, -4.51458506e-02f, -1.59921318e-01f, 2.26873532e-01f, 7.94536769e-02f, 1.04446821e-01f, 4.50785272e-02f, 4.74081095e-03f,
  -7.95750692e-02f, -1.70482114e-01f, 6.14707805e-02f, 5.45395203e-02f, 4.88042086e-02f, -1.78050157e-03f, 2.19305113e-01f, -2.30142012e-01f, 1.03539214e-01f, 7.89699107e-02f,
  1.63225815e-01f, -3.31903137e-02f, -2.58482158e-01f, -1.60770923e-01f, -8.13752487e-02f, -1.16296649e-01f, 1.47204757e-01f, 1.06899925e-02f, -1.33863792e-01f, 2.34713271e-01f,
  -4.48810756e-02f, -1.33319408e-01f, 2.33706106e-02f, 2.58165866e-01f, 1.88984275e-02f, -2.63678320e-02f, 1.65741324e-01f, 1.63532645e-01f, 1.24003634e-01f, 7.13212639e-02f,
  2.68533885e-01f, -1.20288201e-01f, -4.17457968e-02f, -8.83003324e-02f, -1.05201807e-02f, -7.40884319e-02f, -4.99537252e-02f, 1.76059663e-01f, 8.38548243e-02f, -9.80043486e-02f,
  -6.54861182e-02f, -1.64590418e-01f, 6.62621949e-03f, -1.47206202e-01f, 2.95280889e-02f, 1.61381155e-01f, 5.31757660e-02f, 2.49559194e-01f, 1.96005970e-01f, 3.71307768e-02f,
  7.03034773e-02f, 4.28201221e-02f, -8.02724063e-02f, 1.39523461e-01f, -1.20665587e-03f, 1.70888215e-01f, -3.76198962e-02f, -2.17990801e-01f, 4.69440110e-02f, -5.63328713e-03f,
  4.39446568e-02f, 6.68919384e-02f, 1.05642322e-02f, -9.44541022e-02f, 7.50098899e-02f, -7.63549581e-02f, -6.31614253e-02f, -2.19376255e-02f, 1.81489080e-01f, 1.49571598e-01f,
  2.56377999e-02f, 1.97702367e-02f, 1.24605149e-01f, -6.55966103e-02f, 2.22693011e-02f, 9.47208926e-02f, 1.90248191e-01f, -1.15425922e-01f, 1.85162812e-01f, -1.74627960e-01f,
  2.08400920e-01f, 8.15375745e-02f, 1.64964527e-01f, 2.64209453e-02f, 1.43900409e-01f, 3.63355642e-03f, 1.52980581e-01f, 4.47443388e-02f, 1.39295474e-01f, 2.66072333e-01f,
  2.68428355e-01f, 1.46679476e-01f, 5.99307604e-02f, 1.97430581e-01f, 2.82486137e-02f, -9.17963907e-02f, -1.54728433e-02f, 2.64397804e-02f, -1.17817625e-01f, 1.49558559e-01f,
  1.27812967e-01f, 2.43502930e-01f, 3.70266959e-02f, -1.83043033e-01f, 1.39729351e-01f, 1.51061947e-02f, -1.29252255e-01f, 5.43687418e-02f, -1.94351915e-02f, 9.96090546e-02f,
  1.15760192e-02f, -1.32526174e-01f, -9.12165865e-02f, -7.61719644e-02f, -2.38110814e-02f, -1.27021506e-01f, 5.91491945e-02f, -4.59932573e-02f, -1.31569728e-01f, -1.26554415e-01f,
  -1.51346907e-01f, 2.85556287e-01f, -1.26776412e-01f, -5.43648303e-02f, 6.45261332e-02f, -1.42155200e-01f, -2.59151459e-01f, 2.25384254e-02f, 2.86713570e-01f, 2.50651717e-01f,
  -4.23169956e-02f, -3.38615268e-03f, 9.12538096e-02f, -1.74369857e-01f, 1.01415455e-01f, -1.40302330e-01f, 2.28024423e-01f, 1.16556995e-01f, 5.09888045e-02f, -7.38902092e-02f,
  3.78537774e-02f, 3.73253882e-01f, 1.58750135e-02f, -3.63972224e-02f, 1.20338820e-01f, 1.33639842e-01f, -4.50912677e-02f, -1.24842845e-01f, 1.16691768e-01f, 1.65510103e-01f,
  -1.61402915e-02f, -1.22121356e-01f, -3.07368282e-02f, 3.14994007e-02f, 2.21506115e-02f, 1.64434537e-01f, 5.03122918e-02f, 1.22233674e-01f, -2.65542865e-02f, -1.03469536e-01f,
  1.14496127e-01f, -2.43573740e-01f, -9.52035654e-04f, -4.51491624e-02f, -1.31613351e-02f, 3.82802673e-02f, 2.42026955e-01f, 1.13833949e-01f, 4.73830625e-02f, -5.54265231e-02f,
  -7.65741915e-02f, -1.35796756e-01f, 2.39260569e-01f, 1.87553972e-01f, 1.41701587e-02f, 1.27677888e-01f, -8.51512998e-02f, -1.61123171e-01f, 7.53651261e-02f, -8.98186192e-02f,
  1.75939098e-01f, -1.93151593e-01f, -7.46011883e-02f, 2.37181872e-01f, -8.10019374e-02f, 1.62106767e-01f, -2.01037586e-01f, -1.27270654e-01f, -1.68885469e-01f, 8.56491476e-02f,
  -3.83207500e-02f, 1.20248133e-02f, 1.12201571e-01f, 1.32870853e-01f, -8.75962898e-02f, 1.51131347e-01f, -9.18310583e-02f, 9.00931209e-02f, 1.11556664e-01f, -1.05592415e-01f,
  -1.13199793e-01f, 2.76676089e-01f, -4.01854515e-02f, 1.45215794e-01f, -1.77851796e-01f, 2.32238010e-01f, -4.06759307e-02f, 3.69011275e-02f, 8.29473138e-02f, -1.23832658e-01f,
  -9.13533792e-02f, 3.90455909e-02f, -2.46333070e-02f, -1.58730060e-01f, 3.70712439e-03f, -4.16111723e-02f, 7.12771863e-02f, -3.11287362e-02f, 9.68406349e-02f, 2.65246071e-02f,
  1.34258270e-01f, 6.47065789e-02f, 1.45716324e-01f, 9.68352407e-02f, 3.37909423e-02f, -1.45575494e-01f, 9.07374322e-02f, 7.50418678e-02f, 1.45337924e-01f, -1.43693492e-01f,
  -5.34773208e-02f, 1.55163586e-01f, 1.18893035e-01f, 2.16429666e-01f, 6.44791732e-03f, 1.36663854e-01f, -8.25631693e-02f, 3.21521983e-02f, 3.92973125e-02f, -1.25921786e-01f,
  3.80250737e-02f, -2.26426814e-02f, 2.22475454e-01f, 1.48039371e-01f, 1.66088983e-01f, -2.17284232e-01f, 2.69135237e-02f, -1.27349392e-01f, 7.02374205e-02f, -1.02228932e-01f,
  2.07096562e-01f, 1.23557576e-03f, 2.14344040e-01f, 5.69717735e-02f, 4.64255922e-02f, 7.27996975e-03f, 1.25559300e-01f, 1.88743159e-01f, 9.23168883e-02f, 9.39482674e-02f,
  1.54291138e-01f, 1.13797307e-01f, -9.54066291e-02f, 1.06609814e-01f, 1.26399081e-02f, -1.60154719e-02f, 1.76551133e-01f, -4.03709263e-02f, 5.65508045e-02f, -1.30019769e-01f,
  2.42800661e-03f, 1.04020938e-01f, -1.63185403e-01f, -5.90602942e-02f, 1.03303641e-01f, -2.27961410e-02f, 9.59553421e-02f, -7.57599846e-02f, 2.78072983e-01f, -9.39486623e-02f,
  1.14667989e-01f, -1.23542342e-02f, 1.89180691e-02f, 1.72928989e-01f, 1.81757197e-01f, 7.52514973e-02f, 6.43363670e-02f, -1.23705149e-01f, 1.27619252e-01f, -2.55702496e-01f,
  1.43932760e-01f, 1.73923090e-01f, 2.36589327e-01f, -1.65019795e-01f, 8.16650763e-02f, 3.88710126e-02f, 1.90363333e-01f, 1.30499259e-01f, -8.13307539e-02f, -1.69578105e-01f,
  8.00602511e-02f, 1.15836687e-01f, -1.03090540e-01f, -6.92663416e-02f, 1.26484996e-02f, -4.09474745e-02f, 2.54545718e-01f, 8.61648992e-02f, 2.69214422e-01f, -2.74929762e-01f,
  5.35809807e-02f, -1.18199021e-01f, 5.04245721e-02f, -8.52203369e-03f, -5.22902422e-02f, -1.34508625e-01f, 3.65429111e-02f, -8.58701691e-02f, 1.72703173e-02f, 9.17912275e-02f,
  1.48759797e-01f, 2.74852633e-01f, -1.03825025e-01f, 1.19089045e-01f, 6.91474527e-02f, -4.56395140e-03f, 9.12364647e-02f, 3.89194563e-02f, 5.17086126e-02f, 2.32196614e-01f,
  1.88109353e-01f, 4.36041094e-02f, -1.01853862e-01f, 2.01762736e-01f, -3.40990424e-02f, -2.08026022e-02f, -7.91505352e-02f, -4.90414239e-02f, -2.19134483e-02f, -4.99009639e-02f,
  7.80603960e-02f, -1.45019636e-01f, 1.90020651e-01f, -6.16883971e-02f, -3.25859524e-02f, -1.00585461e-01f, -4.29486632e-02f, 5.74152470e-02f, 1.77506283e-02f, -6.18924871e-02f,
  1.49674222e-01f, -2.55645037e-01f, 8.31354484e-02f, -2.82959223e-01f, 8.83145556e-02f, -7.74913877e-02f, 7.24853799e-02f, -1.98593453e-01f, 1.24225818e-01f, -7.68314302e-02f,
  5.26386015e-02f, -1.81106031e-01f, 4.73879650e-02f, -2.29732096e-01f, -1.87964290e-01f, 4.28493410e-01f, -1.88419353e-02f, -1.92295909e-01f, 2.12002441e-01f, 4.47038747e-03f,
  -1.07820794e-01f, 1.69026211e-01f, -1.62636414e-01f, -1.43114999e-01f, -1.48098856e-01f, -1.98335834e-02f, 1.57046378e-01f, 1.10463962e-01f, -8.90775118e-03f, -1.31843641e-01f,
  -1.45667404e-01f, -5.65998219e-02f, 4.33135293e-02f, -1.04020670e-01f, 3.18187982e-01f, 2.91694641e-01f, -1.30414367e-01f, 1.51396217e-02f, -5.15244491e-02f, -1.41755372e-01f,
  -9.29529890e-02f, 1.37098476e-01f, 2.53702521e-01f, 1.23750806e-01f, 3.60455923e-02f, 4.66830581e-02f, 1.21409945e-01f, 3.46144199e-01f, 9.94488746e-02f, 1.65900320e-03f,
  -2.26364255e-01f, -3.20712514e-02f, 4.13609929e-02f, -2.99321413e-01f, -5.25004566e-02f, -2.26236150e-01f, -6.50650859e-02f, -6.09046146e-02f, 1.80554599e-01f, -1.20892432e-02f,
  7.96663538e-02f, 1.52972266e-01f, 2.65338011e-02f, 3.67164537e-02f, -2.10246742e-02f, -2.61909664e-02f, -9.45518166e-02f, -9.91935655e-02f, -8.00470337e-02f, -1.81389645e-01f,
  -7.16720596e-02f, -6.19062074e-02f, 6.97828904e-02f, 9.70625803e-02f, -1.46038607e-01f, -1.56890988e-01f, 1.05807155e-01f, -2.26927564e-01f, 2.38252938e-01f, -1.53964996e-01f,
  1.07486673e-01f, 3.73694360e-01f, 1.25835137e-02f, -8.80811363e-02f, 6.37567192e-02f, -1.34685561e-01f, -1.03611693e-01f, 1.49551928e-01f, 8.97988975e-02f, 2.45549977e-01f,
  -9.84034985e-02f, -1.76001355e-01f, 1.32801058e-02f, -6.64059967e-02f, 4.50131893e-02f, 2.27218419e-01f, 2.38430277e-02f, -2.68776000e-01f, 4.50076796e-02f, -5.72188869e-02f,
  1.66647494e-01f, -8.09571519e-03f, 8.38847011e-02f, 2.70117283e-01f, -2.02687848e-02f, -2.10309312e-01f, -1.95617646e-01f, -8.34833458e-02f, 5.15345372e-02f, 1.79598987e-01f,
  8.87481589e-03f, -6.36209324e-02f, -6.05777837e-02f, 1.11743240e-02f, 1.11940056e-01f, -1.60359800e-01f, -4.83513512e-02f, 2.43240550e-01f, 1.15849301e-01f, -7.38563091e-02f,
  1.15299150e-01f, -7.97100067e-02f, 1.30709350e-01f, 8.54229480e-02f, 4.20565307e-02f, 2.06187461e-02f, 7.00198933e-02f, 1.15268029e-01f, 9.60425064e-02f, -4.70900051e-02f,
  -4.40163724e-02f, 1.85990214e-01f, -1.91639453e-01f, 1.75818607e-01f, 2.04096705e-01f, 8.44667181e-02f, -6.16350956e-02f, -9.97433662e-02f, 1.57387674e-01f, 1.12186506e-01f,
  7.42627084e-02f, 2.19250038e-01f, -2.14613955e-02f, 8.24175104e-02f, 1.50328338e-01f, -2.02741429e-01f, 6.14244454e-02f, -1.24922089e-01f, 6.14038408e-02f, -1.13024171e-02f,
  2.28175849e-01f, -2.56260335e-01f, -6.50239363e-02f, -1.78597882e-01f, -1.03350669e-01f, 9.84540358e-02f, 7.37374946e-02f, -1.04218304e-01f, 2.54417628e-01f, -2.64026910e-01f,
  -1.12927081e-02f, 1.76699966e-01f, 1.13296278e-01f, 1.76738799e-01f, -1.04100354e-01f, 8.26487970e-03f, -6.44500647e-03f, -1.57756999e-01f, 2.13545948e-01f, 6.03363663e-02f,
  9.26444679e-02f, 1.93506166e-01f, 9.31967869e-02f, -6.80429488e-02f, 2.37019565e-02f, 2.01247975e-01f, 2.01023847e-01f, 1.15013175e-01f, 6.49493262e-02f, 2.22903937e-01f,
  -1.10490862e-02f, -1.85198918e-01f, 1.28156573e-01f, 3.68329763e-01f, 6.47190213e-02f, -1.54276475e-01f, -6.55342941e-04f, -3.45060751e-02f, 2.45126747e-02f, -2.56010089e-02f,
  9.25532728e-02f, 6.51812181e-02f, -1.72057189e-02f, 4.18597981e-02f, 6.89270720e-02f, 5.14474548e-02f, 3.73047441e-02f, -6.53920844e-02f, 1.21585689e-01f, 1.83444932e-01f,
  3.20917629e-02f, -4.54525761e-02f, 8.54547918e-02f, -3.86428237e-02f, 5.03719263e-02f, 4.68884520e-02f, -1.40104413e-01f, 1.65607125e-01f, 4.79454622e-02f, -1.49534807e-01f,
  9.81333852e-02f, 2.10139543e-01f, -1.27730697e-01f, 4.30443399e-02f, -8.02907348e-02f, 1.09438978e-01f, 1.25107512e-01f, 1.19696438e-01f, 6.49567395e-02f, 2.08952665e-01f,
  8.47295299e-02f, 1.86354369e-01f, -8.96974504e-02f, -8.84676501e-02f, 8.40709582e-02f, 1.73032507e-01f, 5.91728389e-02f, 9.31447465e-03f, -1.18544772e-01f, -1.67509109e-01f,
  2.41061337e-02f, -1.97327852e-01f, 1.90659110e-02f, 1.87983155e-01f, 1.32475138e-01f, -3.65000106e-02f, -1.04774863e-01f, -7.58582577e-02f, 6.89321011e-02f, 1.30310014e-01f,
  8.16189125e-02f, 9.86932293e-02f, -2.18369439e-02f, 9.44788381e-02f, 5.74987642e-02f, -8.56411159e-02f, -8.50702971e-02f, -4.03502323e-02f, -2.00835377e-01f, 2.24969387e-01f,
  -4.14801985e-02f, 5.82022257e-02f, 6.48466963e-03f, 4.56502996e-02f, -3.10181715e-02f, 2.62420680e-02f, -1.23583600e-01f, -3.78269292e-02f, 7.22555667e-02f, 7.39126131e-02f,
  1.10347673e-01f, -1.57496244e-01f, 4.98127602e-02f, 1.88153520e-01f, 3.80933806e-02f, -2.01184619e-02f, 1.65679920e-02f, -2.38055680e-02f, 6.76858872e-02f, 2.53406577e-02f,
  1.06973052e-02f, 4.46834490e-02f, 1.07453153e-01f, -9.03457105e-02f, 1.43194720e-01f, 1.99839905e-01f, -1.37782186e-01f, 2.72112172e-02f, -1.45749420e-01f, 2.50111490e-01f,
  1.45417020e-01f, 1.15088202e-01f, 7.02560842e-02f, 1.99080646e-01f, 6.33320808e-02f, 2.81017870e-01f, -1.92440245e-02f, 7.07435012e-02f, 1.07726917e-01f, 1.91420123e-01f,
  1.96550593e-01f, 5.13936281e-02f, -5.85929193e-02f, -1.69077784e-01f, 6.75883070e-02f, -9.68305096e-02f, -5.90097345e-02f, 1.18195102e-01f, 1.56759828e-01f, -1.37954265e-01f,
  -1.06463149e-01f, -7.53410682e-02f, 1.61149949e-01f, 1.21085748e-01f, -3.20963562e-02f, 9.35840979e-02f, 5.89097440e-02f, 7.02797472e-02f, 3.77123952e-02f, 7.41024851e-04f,
  -1.01715513e-01f, 1.69572942e-02f, -2.14977801e-01f, 2.66935974e-01f, -6.53806329e-02f, -5.99005930e-02f, -1.12267599e-01f, 3.84089649e-02f, 6.10321090e-02f, 3.11714448e-02f,
  2.45811567e-01f, -1.22014405e-02f, 2.62078531e-02f, 4.02615517e-02f, -4.01622467e-02f, 7.90259838e-02f, 8.92971084e-03f, 4.22128104e-02f, -1.71004818e-03f, 1.83658570e-01f,
  -9.15799364e-02f, 8.30718130e-02f, 3.88923078e-03f, 1.19471349e-01f, -2.15391845e-01f, -6.50912970e-02f, 6.79642707e-02f, -5.35567850e-02f, 1.12103477e-01f, 5.74476123e-02f,
  -2.12073904e-02f, 3.93152945e-02f, -6.62184507e-02f, -1.22737095e-01f, -5.02920151e-02f, -1.26772225e-01f, 1.96096431e-02f, -4.58182283e-02f, 1.27540335e-01f, 5.21246623e-03f,
  5.69896679e-03f, -1.66905016e-01f, 2.26204500e-01f, 2.73331702e-02f, -1.83893114e-01f, -2.17857137e-01f, -1.14910878e-01f, -3.28305885e-02f, 8.98029357e-02f, -7.50133097e-02f,
  3.46014649e-02f, 4.58224304e-02f, 5.74177578e-02f, -1.56795401e-02f, 5.30926883e-02f, -3.06971581e-03f, -1.52732700e-01f, -1.09828003e-01f, 2.91213423e-01f, -1.51456758e-01f,
  1.46533117e-01f, 2.82087892e-01f, 1.92290619e-02f, -6.69639036e-02f, 1.83621511e-01f, 2.85140991e-01f, 5.25709167e-02f, -1.34725243e-01f, 8.34613666e-03f, 1.55649781e-01f,
  2.44189724e-01f, 2.35911652e-01f, 1.92749977e-01f, 2.93155283e-01f, 1.05982333e-01f, 7.92933069e-03f, -2.21057341e-01f, 8.82514268e-02f, -1.65419191e-01f, 9.99864116e-02f,
  -1.57797406e-03f, 2.79439151e-01f, 8.74571577e-02f, -2.31846198e-01f, 2.80156042e-02f, 6.21229298e-02f, -2.24642560e-01f, -7.01392144e-02f, -4.42547761e-02f, -1.43986031e-01f,
  -1.57911807e-01f, 1.53410509e-02f, 8.64194408e-02f, 4.96226689e-03f, 8.05303156e-02f, -9.40125287e-02f, 5.45213968e-02f, -1.94843505e-02f, 3.63979228e-02f, -3.34724262e-02f,
  -1.05349690e-01f, -1.07717095e-02f, -1.28228784e-01f, 7.15963989e-02f, 2.14874595e-01f, -2.04498067e-01f, -2.12351620e-01f, 1.23348713e-01f, -1.46953806e-01f, -1.32137969e-01f,
  -1.67996421e-01f, -4.89708968e-02f, 2.41804630e-01f, -8.48389268e-02f, 2.39377156e-01f, -1.96558356e-01f, 2.71098286e-01f, 1.14765786e-01f, 1.99733719e-01f, -1.35315433e-01f,
  -1.08092748e-01f, 1.91873256e-02f, 6.26220256e-02f, -1.67427227e-01f, 2.42096514e-01f, 1.78887472e-01f, 1.59804113e-02f, 3.05523351e-02f, 7.03784078e-02f, 1.20322749e-01f,
  3.32105197e-02f, -8.40499066e-03f, 2.38436446e-01f, 4.74441051e-02f, 1.94013268e-01f, 1.67185828e-01f, 9.68915075e-02f, 1.76149338e-01f, -4.54403386e-02f, -5.39248437e-03f,
  1.13849439e-01f, -5.10276332e-02f, 5.36397509e-02f, 1.60830304e-01f, 1.60218254e-01f, -1.54917657e-01f, 1.23572417e-01f, 6.87920153e-02f, 2.24855065e-01f, 1.12062946e-01f,
  -8.17553774e-02f, 5.10042496e-02f, 5.25464900e-02f, 1.34136170e-01f, 6.38878495e-02f, -1.73473328e-01f, -8.99545476e-02f, 3.45435669e-03f, 1.65680736e-01f, -1.00429043e-01f,
  1.80953071e-01f, -1.70922235e-01f, 1.68547612e-02f, -3.58104855e-02f, 8.73282645e-03f, 1.78160533e-01f, -8.81198868e-02f, -1.36354342e-01f, -3.55727598e-02f, 1.12943776e-01f,
  -1.24007046e-01f, -7.56026283e-02f, 2.89040238e-01f, 3.23958308e-01f, 1.74131364e-01f, 6.41067922e-02f, -3.71652506e-02f, 1.64505467e-02f, -1.26258075e-01f, 1.23614306e-02f,
  -4.76862217e-04f, 1.21002076e-02f, -7.56224245e-02f, 1.14431404e-01f, -2.77090948e-02f, 1.87987611e-01f, -9.04846266e-02f, 2.19634607e-01f, -1.97615996e-01f, -9.06526949e-03f,
  4.75234650e-02f, -1.27023563e-01f, -3.90947284e-03f, -5.80815598e-02f, -6.09560907e-02f, 1.65892970e-02f, 1.01286791e-01f, 8.85574054e-03f, -1.54485563e-02f, 8.69480968e-02f,
  2.23490316e-02f, 6.92164004e-02f, 5.60973696e-02f, 2.76940223e-02f, 1.19906619e-01f, 3.32930125e-02f, 4.73307781e-02f, -2.36270633e-02f, 8.21456686e-02f, -7.15917423e-02f,
  3.09256315e-02f, 1.25817098e-02f, 1.35166734e-01f, 2.26120844e-01f, -4.58303429e-02f, 9.80012305e-03f, 1.19207967e-02f, 1.87380090e-02f, -5.71029447e-02f, -5.13682654e-03f,
  -3.82738598e-02f, 3.31751704e-02f, 3.06076884e-01f, 1.97507009e-01f, 2.84578830e-01f, -2.45182380e-01f, 7.17377141e-02f, -2.26126369e-02f, 2.26224437e-01f, -2.18408391e-01f,
  -3.88301350e-02f, -9.73926261e-02f, 1.12256251e-01f, 7.73234591e-02f, 9.46883187e-02f, 8.31585675e-02f, -1.09287299e-01f, -2.95450576e-02f, 7.36799538e-02f, 1.93452746e-01f,
  -2.00675875e-02f, 1.23162575e-01f, -1.28599303e-02f, 2.14868456e-01f, -2.68745795e-02f, 9.33177620e-02f, 3.30336876e-02f, 4.90472876e-02f, 2.17298325e-02f, -2.09583268e-01f,
  -6.08307449e-03f, 1.57270133e-01f, -1.70737892e-01f, 3.16980071e-02f, 4.82953638e-02f, 8.18681195e-02f, -1.16299346e-01f, -1.17674321e-01f, 2.80391127e-02f, 3.80772054e-02f,
  2.37053677e-01f, 1.81833759e-01f, 2.80544627e-02f, 2.73337029e-02f, 2.22247854e-01f, 1.33050591e-01f, -6.25163829e-03f, 2.54258811e-01f, 7.16704801e-02f, -1.45020515e-01f,
  2.62318701e-01f, 4.20229957e-02f, 1.75177574e-01f, 1.14775216e-02f, -1.41446725e-01f, 6.48780465e-02f, 1.29832983e-01f, 2.32693002e-01f, -1.80697709e-01f, -6.40873564e-04f,
  -1.58086106e-01f, -2.42163226e-01f, -2.05187008e-01f, -2.01643810e-01f, 1.36152366e-02f, 2.73564935e-01f, 2.73680896e-01f, 9.38497782e-02f, 2.59292917e-03f, 4.74270880e-02f,
  2.49491706e-01f, -6.55592307e-02f, 1.86518297e-01f, -1.92739919e-01f, 1.24294214e-01f, 2.72534311e-01f, 1.06508404e-01f, 1.45571023e-01f, 8.09232369e-02f, 8.66522864e-02f,
  -1.79410383e-01f, 4.64955121e-02f, 1.49178460e-01f, 1.72099233e-01f, 2.35122070e-01f, 6.43852279e-02f, -2.49336548e-02f, 1.82444125e-01f, -8.91769603e-02f, 3.24230045e-02f,
  2.95449108e-01f, -1.68834388e-01f, 3.82149816e-02f, -1.18282467e-01f, -1.88105285e-01f, -1.25876497e-02f, -2.11223736e-01f, -1.03602201e-01f, -1.83374586e-03f, 1.09177239e-01f,
  -1.01690859e-01f, -2.04076976e-01f, 2.54358500e-01f, 1.66627422e-01f, 1.23158216e-01f, 7.64726102e-02f, 5.56714507e-03f, 3.99061218e-02f, 4.03854065e-02f, 4.76144906e-03f,
  3.21151838e-02f, 3.08057182e-02f, 1.54754192e-01f, 7.29671866e-02f, 9.32105109e-02f, 1.66651011e-01f, 2.39829361e-01f, -1.16361544e-01f, -1.90184992e-02f, -9.25852656e-02f,
  2.56114006e-01f, 1.67042241e-01f, -7.11112469e-02f, 3.24913673e-02f, -2.36850581e-03f, -2.43052747e-02f, -1.02279082e-01f, -9.62843467e-03f, -9.75659937e-02f, -1.84410042e-03f,
  1.18417196e-01f, 1.83448642e-02f, 2.85416126e-01f, -1.75772756e-01f, -6.32283613e-02f, -1.36765838e-01f, 1.26157820e-01f, -5.80313653e-02f, -4.22212780e-02f, -1.61764979e-01f,
  7.91181698e-02f, -1.63334131e-01f, -6.24890067e-02f, 1.20878682e-01f, -1.66803539e-01f, 1.92201361e-01f, -3.98879535e-02f, 2.13678285e-01f, -2.29590282e-01f, 9.42454711e-02f,
  3.02557331e-02f, 9.45285931e-02f, -1.58481270e-01f, 2.01276660e-01f, -6.53801933e-02f, 8.67594127e-03f, -1.06607396e-02f, 8.96598119e-03f, -3.14316340e-02f, 2.29647517e-01f,
  -1.42205089e-01f, 1.97393298e-02f, -2.54149642e-02f, 6.85594529e-02f, -1.00423992e-01f, 9.68499389e-03f, -3.97962928e-02f, -4.38200273e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  3.57037522e-02f, 5.59840910e-02f, -2.63469219e-02f, 1.10575788e-01f, 1.98652655e-01f, 6.67770356e-02f, 1.64807066e-02f, 8.27958807e-02f, 1.54326856e-01f, -5.07376008e-02f,
  1.94203407e-01f, 9.00734887e-02f, 1.72219053e-01f, 1.30021706e-01f, 1.61860839e-01f, 2.49846056e-02f, 1.68326229e-01f, -1.01549700e-02f, 4.43181433e-02f, 1.34222284e-01f,
  5.87762753e-03f, 7.55690783e-02f, 4.86651734e-02f, 3.34738009e-02f, 1.48223341e-01f, 1.68682747e-02f, 2.22255792e-02f, 7.85292964e-03f, 8.24093968e-02f, 9.61960554e-02f,
  1.27684593e-01f, 1.85640737e-01f, 1.15407847e-01f, 1.30387679e-01f, 5.98794967e-02f, 1.66988522e-01f, 2.88504846e-02f, 1.46093860e-01f, 1.51855841e-01f, 1.09381258e-01f,
  9.81481150e-02f, 4.11053561e-03f, 5.18105961e-02f, 2.66305089e-01f, 1.32938847e-01f, 8.96309167e-02f, 2.80589089e-02f, 1.15081474e-01f, 1.99183580e-02f, -3.49779823e-03f,
  2.32189591e-03f, 3.07584293e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.14497021e-02f, -1.00815885e-01f, 5.04669622e-02f, 1.01577328e-03f, -1.83705121e-01f, -8.54219049e-02f, 1.16571799e-01f, -6.85060769e-02f, 5.35870865e-02f, 1.16783567e-01f,
  -4.47604656e-02f, 7.42915692e-03f, 3.84720191e-02f, 1.52183967e-02f, -3.73206697e-02f, -6.28231168e-02f, 1.49588089e-03f, -3.03034112e-02f, 1.30850151e-01f, -5.40022366e-02f,
  -6.37309328e-02f, -8.36975814e-04f, -3.96088585e-02f, 9.69559327e-02f, 1.33445650e-01f, 2.35862043e-02f, 6.15218431e-02f, -6.02595955e-02f, -6.39625564e-02f, 9.30199698e-02f,
  -1.74494255e-02f, -8.58678594e-02f, -4.18446353e-03f, 3.73247787e-02f, -1.38235446e-02f, -1.06818691e-01f, -7.20566362e-02f, -2.38705166e-02f, 1.17894247e-01f, 4.50714864e-03f,
  -8.66855010e-02f, 7.75472298e-02f, -8.00794736e-02f, 1.94360409e-02f, -1.90179288e-01f, 3.50141972e-02f, -9.26725790e-02f, 1.41489908e-01f, 3.52746844e-02f, -1.07264131e-01f,
  -1.24732390e-01f, 3.26678008e-02f, -2.29917243e-02f, -3.57085913e-02f, -1.07771996e-02f, -4.93319072e-02f, 4.80224490e-02f, 7.25333095e-02f, 1.18142389e-01f, 1.71555597e-02f,
  -6.71933889e-02f, 5.96160674e-03f, 1.54173270e-01f, -1.28112108e-01f, -1.49792712e-02f, 7.07342289e-03f, 9.02729481e-02f, 9.43089500e-02f, -2.32998431e-02f, 3.91536914e-02f,
  -3.97589663e-03f, 8.66882280e-02f, -2.12641880e-01f, -3.75621617e-02f, 3.07428800e-02f, 9.46013704e-02f, -1.87549070e-02f, -1.39488682e-01f, -5.12211211e-02f, 5.80328144e-02f,
  -7.63645163e-03f, 4.21269657e-03f, -1.16894893e-01f, -8.49164203e-02f, -3.72339264e-02f, -1.16959982e-01f, -1.29721621e-02f, -3.12178656e-02f, 9.90723744e-02f, 9.37774628e-02f,
  -6.12120703e-02f, -6.25939518e-02f, 1.15175083e-01f, 4.83552366e-02f, -1.14663206e-01f, 1.85263917e-01f, 7.92770386e-02f, 1.37429476e-01f, 5.41087836e-02f, 2.23966446e-02f,
  1.88104920e-02f, -4.52844873e-02f, -1.27652094e-01f, -6.62835836e-02f, -3.52367498e-02f, 1.48939729e-01f, -1.12049609e-01f, -3.90469506e-02f, -8.15646797e-02f, -7.73529410e-02f,
  4.22524475e-02f, 1.65457185e-02f, -9.70733538e-02f, 1.04021236e-01f, -6.63182214e-02f, -2.30116560e-03f, 8.41024593e-02f, -1.08886965e-01f, 2.82536577e-02f, 3.71177346e-02f,
  -9.30015519e-02f, -1.09905209e-02f, -1.89293772e-01f, 1.04510948e-01f, 7.64218792e-02f, 9.29583758e-02f, 1.56362310e-01f, 2.04177783e-03f, 1.51976515e-02f, -4.65813242e-02f,
  1.22788571e-01f, -1.29096936e-02f, -2.93960702e-02f, 5.14306352e-02f, -2.06559181e-01f, -1.41243890e-01f, 7.77554363e-02f, -1.02646470e-01f, -5.78067042e-02f, 9.11333337e-02f,
  -5.52884303e-02f, -9.39837620e-02f, -6.76859310e-03f, 1.14668891e-01f, 3.21696512e-02f, -3.46148349e-02f, 2.96672899e-02f, 4.61328961e-02f, -2.38857314e-01f, -5.11746760e-03f,
  -9.57531482e-02f, 8.06812868e-02f, -2.23697126e-01f, 1.30735472e-01f, 6.97180405e-02f, -2.82893982e-02f, -1.80025343e-02f, 1.16847269e-01f, 3.67817655e-02f, -5.42851053e-02f,
  8.37704316e-02f, -8.72202367e-02f, -1.29034102e-01f, 7.18136951e-02f, -1.91654280e-01f, 1.11836744e-02f, -1.13079324e-01f, -1.14235662e-01f, 5.39005958e-02f, 7.65823945e-02f,
  -1.01206079e-01f, -1.02646925e-01f, 1.16187662e-01f, -2.95625776e-02f, 8.75594914e-02f, 2.20968142e-01f, -4.82183732e-02f, -2.12718137e-02f, 1.47117721e-02f, -1.68366522e-01f,
  -3.52149904e-02f, 1.50788799e-02f, 1.44347057e-01f, -1.19415663e-01f, -5.60244955e-02f, 5.91544732e-02f, -9.10650343e-02f, 1.41102806e-01f, -4.12066281e-02f, -9.83441174e-02f,
  -1.75338626e-01f, -1.23106956e-01f, -1.14381924e-01f, -5.47230849e-03f, -2.69860541e-03f, 7.28878900e-02f, -1.51933014e-01f, -7.47974664e-02f, -2.75496617e-02f, -1.78535730e-02f,
  -2.04843864e-01f, 1.36341751e-02f, -2.42071189e-02f, 9.29381251e-02f, -3.81269492e-02f, -6.73105270e-02f, -8.91239494e-02f, -7.73089612e-03f, -1.68046858e-02f, 3.44338045e-02f,
  -3.65562625e-02f, 8.37933496e-02f, -1.14287019e-01f, 6.91257194e-02f, -5.80082163e-02f, -5.00896871e-02f, -1.30218193e-02f, 5.95758259e-02f, -1.87129796e-01f, 7.13603571e-02f,
  -1.49135832e-02f, 9.66792852e-02f, -1.21628493e-02f, 1.09702326e-01f, 8.01010150e-03f, 6.28831312e-02f, 8.38491917e-02f, 6.63031042e-02f, -2.76733283e-02f, 6.73143864e-02f,
  8.61371867e-03f, -6.43855259e-02f, 3.00539248e-02f, 9.63525176e-02f, -1.07530899e-01f, -1.45435706e-01f, 3.38353440e-02f, -1.91138744e-01f, 7.83528537e-02f, 6.18844740e-02f,
  3.00998073e-02f, -5.66143580e-02f, -3.98648903e-02f, 5.47655970e-02f, 3.88512015e-02f, 7.64168352e-02f, 1.06210001e-02f, -3.03348601e-02f, -4.53501157e-02f, -4.46701907e-02f,
  -7.75766969e-02f, 9.75680575e-02f, -3.91430520e-02f, 2.33701337e-02f, -6.44412963e-03f, -9.08906758e-03f, 7.29019791e-02f, 5.91432378e-02f, 3.20923589e-02f, 4.70145307e-02f,
  3.36385593e-02f, 2.53619533e-02f, 1.65711924e-01f, 6.62022233e-02f, 2.62538474e-02f, -1.19648375e-01f, 1.03683934e-01f, -1.81445569e-01f, -1.09710209e-01f, -2.74781417e-02f,
  -1.09999925e-02f, -1.19835280e-01f, 1.02485344e-02f, 9.67213325e-03f, -1.39469251e-01f, -1.64619043e-01f, 7.63314068e-02f, -1.32429346e-01f, -7.32151717e-02f, -9.76651981e-02f,
  1.23589039e-02f, 2.60100476e-02f, -5.86686172e-02f, -2.35023834e-02f, -3.05951796e-02f, -4.39085253e-02f, 1.32047608e-01f, -7.56003661e-03f, -8.26442242e-02f, 1.30210683e-04f,
  -6.03537913e-03f, -6.30797446e-03f, 8.25149044e-02f, 3.68897989e-02f, -1.97272897e-02f, -2.25949753e-02f, -1.15754157e-01f, 1.88990254e-02f, -1.42305434e-01f, -9.45564657e-02f,
  -1.43261701e-01f, 6.35022521e-02f, -1.41937926e-01f, 6.18109703e-02f, 1.04528613e-01f, 1.25119954e-01f, -1.75008010e-02f, 9.83972475e-02f, 6.65945560e-02f, 6.60274625e-02f,
  -1.06054962e-01f, -1.18097432e-01f, -1.28164729e-02f, -9.80504975e-02f, 1.05003768e-03f, 1.49063602e-01f, -3.13273557e-02f, -3.08486819e-03f, 4.99548577e-02f, -5.70260473e-02f,
  1.05336539e-01f, 6.38308376e-02f, 2.40340214e-02f, -1.09237358e-01f, 1.54704571e-01f, 1.28146103e-02f, -6.46135509e-02f, -1.60974428e-01f, 1.51808009e-01f, -4.87368219e-02f,
  -4.31815982e-02f, -5.38044460e-02f, 1.61620796e-01f, 9.02586132e-02f, 3.68127674e-02f, -9.63615477e-02f, 4.02251780e-02f, 7.69624338e-02f, -2.30932143e-02f, -3.44430432e-02f,
  -4.62517701e-02f, 4.89423051e-03f, -1.00175077e-02f, 7.65451789e-02f, -1.71206132e-01f, -6.06856160e-02f, 1.59880400e-01f, 6.33495301e-02f, 7.62912706e-02f, 3.22559383e-03f,
  -8.07294548e-02f, -8.40653107e-02f, -2.68808790e-02f, -7.76694417e-02f, -6.31302968e-02f, -4.24215496e-02f, -1.09815560e-01f, 4.04521190e-02f, 1.30798727e-01f, 2.78851371e-02f,
  3.81412096e-02f, -2.33763028e-02f, 1.55783787e-01f, 1.18002184e-01f, 1.19276911e-01f, 1.88471481e-01f, 3.88229042e-02f, -9.02617425e-02f, -3.68488096e-02f, -7.13413656e-02f,
  -5.34718065e-03f, -1.11517243e-01f, -1.06749505e-01f, -1.65315583e-01f, 6.22800924e-02f, 1.03020512e-01f, -4.04556952e-02f, -3.12980004e-02f, 2.90757995e-02f, -3.53343748e-02f,
  -4.50018831e-02f, 4.58501317e-02f, -2.34198526e-01f, 4.01603878e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  9.77792963e-02f, -2.91661713e-02f, 1.49826584e-02f, 1.43134609e-01f, 1.37218848e-01f, 5.67740723e-02f, 1.39564008e-01f, 2.19274938e-01f, 1.94423020e-01f, -1.13792151e-01f,
  1.60001487e-01f, -7.68036544e-02f, -1.30785664e-03f, -6.79965019e-02f, -1.43520385e-02f, 9.73546579e-02f, 1.27537921e-01f, 1.97247397e-02f, -5.47490232e-02f, -1.63120091e-01f,
  2.47562200e-01f, -7.60285556e-02f, 2.58939546e-02f, -6.58328235e-02f, 7.09201768e-02f, -5.60073107e-02f, 6.58502653e-02f, -4.65263985e-02f, 1.32685155e-01f, -2.05687076e-01f,
  1.13693550e-02f, 1.73273221e-01f, -1.57213390e-01f, 1.59974501e-01f, 6.45439476e-02f, -8.25593472e-02f, 2.65056908e-01f, 3.74335349e-02f, -1.98788211e-01f, 9.10351053e-02f,
  8.34762603e-02f, 8.49163719e-03f, -1.29673406e-02f, 1.42693207e-01f, -9.38504562e-02f, 4.08389494e-02f, -6.74927309e-02f, -1.27601743e-01f, 5.98668866e-02f, 3.61445755e-01f,
  5.83948866e-02f, 1.08510308e-01f, 3.04673612e-01f, 1.35171264e-01f, 4.20266837e-02f, 1.77346647e-01f, -1.14667982e-01f, -1.45146325e-01f, -1.25754282e-01f, 2.34547049e-01f,
  2.66562581e-01f, -7.57248998e-02f, 8.84972885e-02f, 4.48897071e-02f, -1.71541020e-01f, -6.39509931e-02f, 4.95802462e-02f, 2.40390208e-02f, -1.49777889e-01f, -3.32023688e-02f,
  1.50410989e-02f, 1.41687259e-01f, -6.46085143e-02f, -5.82032688e-02f, -9.60789695e-02f, 8.57252628e-02f, -1.78472161e-01f, -1.21574670e-01f, -4.32014205e-02f, 2.80872077e-01f,
  4.54288125e-02f, 1.49969030e-02f, -4.38300818e-02f, 1.20165467e-01f, 7.90765733e-02f, 8.15732703e-02f, -5.31031154e-02f, -7.17175528e-02f, 2.83484161e-01f, 7.34429434e-02f,
  -5.41561916e-02f, 9.67488065e-02f, 5.51682012e-03f, 2.65434422e-02f, -7.00983629e-02f, 6.27383590e-02f, -5.72233424e-02f, 6.72249049e-02f, 4.28823307e-02f, 8.00866168e-03f,
  9.35867876e-02f, -1.04177989e-01f, -7.65069574e-02f, -1.63959965e-01f, 1.01421298e-02f, -7.42622465e-02f, -1.78682253e-01f, -8.04816857e-02f, 2.02317210e-03f, -8.94551203e-02f,
  5.96769862e-02f, -1.43951857e-02f, -7.44850487e-02f, 2.34577104e-01f, -4.97807376e-03f, 1.20229311e-01f, 1.42661259e-01f, 8.12961236e-02f, -1.84883088e-01f, -7.90043082e-03f,
  2.63454504e-02f, 6.38474077e-02f, -7.04261214e-02f, 5.00980727e-02f, 1.19376272e-01f, 2.55780630e-02f, 1.84433520e-01f, 1.11644171e-01f, -1.09541878e-01f, 1.82026753e-03f,
  -7.87408054e-02f, 3.93468440e-02f, -1.83357418e-01f, -3.96141373e-02f, -4.98627685e-02f, -8.39383081e-02f, -1.69594601e-01f, 2.27591489e-02f, -2.90451925e-02f, 9.55584273e-02f,
  1.64397672e-01f, 1.24070466e-01f, 3.41723226e-02f, -1.26015544e-01f, -2.13911965e-01f, 3.24914046e-02f, 3.35139371e-02f, 1.02730848e-01f, 1.62038580e-01f, -7.68163353e-02f,
  2.91434795e-01f, 9.18070450e-02f, 1.00692749e-01f, -1.61789898e-02f, 8.70278552e-02f, -6.70791790e-02f, -2.75386602e-01f, 6.57619238e-02f, -2.12821923e-02f, 1.34064361e-01f,
  1.71786696e-01f, 1.23049282e-01f, -1.38092771e-01f, -8.64714086e-02f, -8.63004699e-02f, 2.01398805e-01f, 1.64735481e-01f, 2.77262062e-01f, -7.64285475e-02f, 2.30939105e-01f,
  1.42056540e-01f, 9.59169492e-02f, -8.58170614e-02f, -1.96232111e-03f, -1.72102228e-01f, 1.27389938e-01f, 9.54752341e-02f, -1.81335405e-01f, -1.28646642e-01f, 1.73498794e-01f,
  -7.63027817e-02f, -1.98016509e-01f, 2.41964594e-01f, -6.04588874e-02f, -6.16754554e-02f, -5.91622330e-02f, 3.35429162e-02f, -1.02639854e-01f, -1.38787270e-01f, -6.11681305e-02f,
  2.75536180e-01f, -2.00354591e-01f, 1.04647338e-01f, 1.83864191e-01f, -9.33033228e-03f, 1.45572528e-01f, 1.32923573e-01f, 4.41183522e-02f, 1.86441410e-02f, 4.43267941e-01f,
  -1.90075338e-02f, 1.38452098e-01f, 2.43450329e-01f, 1.47218108e-01f, 2.22221836e-02f, -2.76579484e-02f, -3.85527499e-02f, -5.97488992e-02f, 7.31572732e-02f, -4.72203679e-02f,
  -1.27084523e-01f, -1.24585509e-01f, 1.89098686e-01f, 1.46400323e-03f, 2.89182097e-01f, 1.12602182e-01f, 3.33376855e-01f, -3.68900560e-02f, -1.40485959e-02f, 1.41826496e-01f,
  1.54492527e-01f, -9.62353423e-02f, -1.53362647e-01f, 2.48232540e-02f, 6.33210167e-02f, 1.03246927e-01f, 1.17941990e-01f, -1.50523975e-01f, 1.24137029e-01f, -5.25010042e-02f,
  3.41648385e-02f, -6.63554966e-02f, 1.45302907e-01f, -3.90825532e-02f, 2.36269712e-01f, 1.70766369e-01f, -2.19296858e-01f, -1.16985574e-01f, -1.41429842e-01f, -3.33613977e-02f,
  -1.04834788e-01f, -4.62924875e-02f, -1.29923046e-01f, 2.43439198e-01f, 1.78121924e-01f, -6.46081418e-02f, -1.65045068e-01f, 7.27230832e-02f, 2.15195157e-02f, 1.52017027e-02f,
  -9.11927298e-02f, -1.24973081e-01f, 3.10380518e-01f, 2.12102547e-01f, 2.27118239e-01f, 1.53878659e-01f, 9.12522078e-02f, -1.31364495e-01f, 1.72649279e-01f, 1.19847149e-01f,
  -1.37380231e-02f, 1.16583504e-01f, 4.03101891e-02f, -6.27664328e-02f, 6.45898134e-02f, -1.92482218e-01f, 1.01266868e-01f, -1.70099378e-01f, -7.81480148e-02f, 2.19246708e-02f,
  -3.60261984e-02f, 1.21406004e-01f, -2.63900943e-02f, 5.80192730e-03f, -1.05296843e-01f, -1.69636160e-01f, 2.07785711e-01f, 5.84544279e-02f, -2.43165672e-01f, -1.62176266e-01f,
  -3.05128563e-02f, -1.60310082e-02f, 1.36860251e-01f, -4.70992066e-02f, 3.82229537e-02f, 5.94167635e-02f, 2.98834354e-01f, 4.15455513e-02f, -1.57867417e-01f, -1.68810278e-01f,
  1.24352174e-02f, 3.62397619e-02f, 2.24467933e-01f, 1.84695154e-01f, -1.18508441e-02f, -1.61348857e-04f, 9.95739177e-02f, 7.57254958e-02f, -2.55137440e-02f, -7.84152895e-02f,
  -2.66266391e-02f, 2.79365070e-02f, 6.76893294e-02f, 4.89481278e-02f, 2.11587071e-01f, 1.78716883e-01f, 2.66426224e-02f, 7.80971795e-02f, 2.16672271e-01f, 3.70058239e-01f,
  6.05485477e-02f, 9.22894031e-02f, 4.74196970e-02f, -2.61818785e-02f, 6.92758858e-02f, 2.40987420e-01f, 1.35070086e-01f, -1.16603345e-01f, -1.10236794e-01f, -1.36934340e-01f,
  -6.25972152e-02f, 1.01894446e-01f, -1.37504026e-01f, -5.52411489e-02f, -4.71076854e-02f, -9.16184019e-03f, -1.33933887e-01f, 1.23044021e-01f, -1.93988122e-02f, 2.00424612e-01f,
  4.47332449e-02f, 2.13888854e-01f, -6.98125213e-02f, 8.07955861e-03f, -6.25694767e-02f, 8.33756477e-02f, 1.20119177e-01f, 2.22888663e-01f, 1.34826645e-01f, 3.00047874e-01f,
  6.89650103e-02f, 4.52486165e-02f, 1.60431325e-01f, -1.27035618e-01f, 2.93003827e-01f, -4.45153788e-02f, -6.60266578e-02f, 1.67992845e-01f, 1.53953880e-01f, 2.55989898e-02f,
  -2.72038579e-01f, 2.46179570e-02f, 5.97551093e-02f, 1.06650338e-01f, 2.33593788e-02f, 1.09504677e-01f, 2.99173538e-02f, -1.67961821e-01f, 1.91748112e-01f, 6.96161296e-03f,
  6.94419742e-02f, -1.89449355e-01f, 2.36322805e-01f, 1.09998144e-01f, 1.43136516e-01f, 7.72916079e-02f, 1.96079433e-01f, -2.19543859e-01f, -1.71266258e-01f, -1.13827968e-02f,
  8.39913636e-02f, 1.28087670e-01f, 7.02015683e-02f, -5.46879172e-02f, -2.26654992e-01f, 1.94962934e-01f, 1.04457669e-01f, 6.70376122e-02f, 1.08655438e-01f, -1.02536865e-01f,
  1.85438424e-01f, 9.25822854e-02f, 3.84949744e-02f, 2.68967867e-01f, -1.35699809e-01f, 2.54415013e-02f, -3.27958278e-02f, -6.76515326e-02f, -2.97856610e-02f, 9.40701459e-03f,
  7.14028105e-02f, -3.91965546e-02f, -2.99564421e-01f, 7.47082829e-02f, -1.64483160e-01f, 1.35919675e-01f, -8.06416720e-02f, 1.22706313e-02f, -2.06861980e-02f, -9.65492949e-02f,
  2.38044523e-02f, -1.02012539e-02f, 5.25967591e-02f, 1.61857396e-01f, 5.59105016e-02f, 1.28638774e-01f, 9.17970091e-02f, -4.43316884e-02f, 1.50381148e-01f, 1.08757064e-01f,
  -2.48462677e-01f, 1.23669095e-01f, -3.28828059e-02f, 7.59017542e-02f, 2.69747619e-02f, 2.49806210e-01f, 2.59673983e-01f, 2.55088955e-01f, 6.26219362e-02f, 2.37286881e-01f,
  1.36343827e-02f, 6.58627823e-02f, 5.58214262e-02f, -1.02965489e-01f, -1.52208015e-01f, 2.76351273e-01f, -5.39049469e-02f, -7.81977922e-02f, 8.81229267e-02f, -1.88244700e-01f,
  3.51123586e-02f, 2.00987980e-01f, 9.30932239e-02f, -1.58303350e-01f, -1.08878687e-01f, 1.83352932e-01f, 7.74543732e-02f, -5.83249293e-02f, -3.99310216e-02f, -1.70557271e-03f,
  2.04123884e-01f, 9.57656875e-02f, 1.17974110e-01f, 1.56087140e-02f, -1.05459347e-01f, 2.27199152e-01f, 3.02052826e-01f, -7.77614769e-03f, 5.68349808e-02f, -1.07762687e-01f,
  1.65441975e-01f, 8.06314945e-02f, -4.91602309e-02f, 6.35437220e-02f, -3.62646952e-02f, -1.33841291e-01f, 2.09953517e-01f, 4.49998640e-02f, 2.38003619e-02f, -6.07277602e-02f,
  3.94195355e-02f, 2.31881030e-02f, -4.37704436e-02f, 1.07107356e-01f, -1.04162440e-01f, -1.08020246e-01f, 9.90550071e-02f, 1.50969058e-01f, 2.96834856e-03f, 6.92681223e-02f,
  -1.24641396e-01f, 5.33777326e-02f, -1.29257634e-01f, -7.31702447e-02f, 2.22242862e-01f, 1.10278368e-01f, -7.71037415e-02f, 1.01052679e-01f, 2.67722964e-01f, 5.76405413e-02f,
  -7.83465654e-02f, -2.15751261e-01f, 1.37041047e-01f, -2.80047953e-02f, 1.22471243e-01f, 6.33361042e-02f, -1.17350534e-01f, 1.84840951e-02f, 8.75418633e-02f, -5.68343177e-02f,
  -3.06085031e-02f, 6.50362074e-02f, 6.48717629e-03f, 8.87899399e-02f, 8.91269818e-02f, 2.66083032e-02f, 1.59443572e-01f, 1.46801308e-01f, 1.68369964e-01f, -1.13727659e-01f,
  1.80583671e-02f, 3.20710033e-01f, 2.29685560e-01f, -7.97974989e-02f, 1.20511219e-01f, 8.72255266e-02f, -1.31562933e-01f, -8.09056237e-02f, 1.46769345e-01f, -8.79190937e-02f,
  -1.57016203e-01f, -8.12050998e-02f, -2.53418181e-02f, -5.18892445e-02f, 4.68406975e-02f, 1.57009974e-01f, 6.18557371e-02f, -3.11607472e-03f, 1.88303545e-01f, 1.80487446e-02f,
  1.84692830e-01f, 2.77671907e-02f, -1.03169203e-01f, -7.83080235e-02f, -9.98596894e-04f, -7.40318419e-03f, -7.43334591e-02f, -4.96465638e-02f, 5.74861094e-03f, 2.17723906e-01f,
  1.32281348e-01f, 8.51730183e-02f, 2.18488559e-01f, 1.07819594e-01f, 5.51296771e-02f, -1.49863571e-01f, 1.33217737e-01f, -3.71901393e-02f, 7.64216483e-03f, -1.55901641e-01f,
  -6.45743357e-03f, -1.95879564e-01f, -3.20090950e-02f, 2.51161885e-02f, -4.27752882e-02f, 2.34900907e-01f, -6.23397268e-02f, -1.19641803e-01f, -1.24061681e-01f, -1.02728039e-01f,
  1.41326174e-01f, 8.23616982e-02f, -2.62235224e-01f, 2.69014519e-02f, 1.33018851e-01f, 6.48300201e-02f, -1.32116020e-01f, 1.46142960e-01f, -9.40324739e-02f, -3.73784713e-02f,
  2.61413492e-02f, 1.00936770e-01f, -1.50846601e-01f, 1.99387684e-01f, 8.88652578e-02f, 5.79857454e-02f, -1.26222566e-01f, 2.80736834e-01f, 9.13239792e-02f, 8.02725181e-02f,
  1.75991595e-01f, 1.43446952e-01f, -9.69387032e-03f, -4.88075949e-02f, 4.56278920e-02f, -4.67299744e-02f, 1.63732450e-02f, 4.79703993e-02f, -7.15615749e-02f, -4.70206439e-02f,
  -8.64706933e-02f, 8.27933699e-02f, -1.88346937e-01f, 1.63359627e-01f, 1.06379483e-02f, 2.20780209e-01f, 1.01531848e-01f, 1.51934400e-01f, 4.44295630e-02f, 4.42907633e-03f,
  -6.11209273e-02f, -1.71836652e-02f, -7.34082609e-02f, 9.21753421e-02f, 1.31896809e-01f, 3.05736542e-01f, 4.97179292e-02f, 2.38227770e-01f, 2.91996002e-01f, 1.48136050e-01f,
  3.26539159e-01f, -1.39304772e-01f, 4.49203998e-02f, 2.99973637e-01f, 6.80051148e-02f, -4.71523032e-02f, -2.85522602e-02f, -1.82911493e-02f, -9.88616422e-03f, 1.04462177e-01f,
  7.57667869e-02f, 8.93791839e-02f, 2.31942981e-02f, -7.36202374e-02f, -1.06592635e-02f, 1.28862873e-01f, 1.28007799e-01f, -1.60437495e-01f, 1.10116415e-01f, 1.39627457e-01f,
  1.18596163e-02f, 9.82105657e-02f, -4.63829935e-03f, -2.93145686e-01f, -6.67168275e-02f, -1.67555794e-01f, -6.94074780e-02f, 1.90919042e-01f, -9.27209854e-03f, -7.77225792e-02f,
  -5.10556921e-02f, 1.26738429e-01f, 9.82684642e-02f, 5.79530112e-02f, -6.32997006e-02f, -3.30609411e-01f, 1.77040040e-01f, 9.18954164e-02f, 1.70438081e-01f, 1.85745016e-01f,
  1.19492397e-01f, 1.55652881e-01f, 1.57184619e-02f, 2.10749172e-02f, 2.39114225e-01f, 7.13620409e-02f, 1.02290086e-01f, 1.25776544e-01f, 9.77457836e-02f, 6.67726770e-02f,
  8.40154588e-02f, 7.08746240e-02f, 2.25011930e-01f, 4.04223390e-02f, 1.90550610e-02f, 6.74575940e-02f, 6.20742142e-02f, -1.36195600e-01f, -6.83242828e-02f, -1.13087878e-01f,
  1.97253570e-01f, -1.42206103e-01f, 2.58098096e-01f, 3.41909647e-01f, 1.78868547e-01f, 9.78264511e-02f, 1.66631535e-01f, 9.66092646e-02f, -1.60678104e-02f, 1.37650371e-01f,
  -3.27837765e-02f, 1.14679344e-01f, 1.35765165e-01f, 8.60972479e-02f, -1.35058478e-01f, -6.78954944e-02f, -1.56705510e-02f, 6.90791607e-02f, -1.67421907e-01f, 1.08046494e-01f,
  1.25416130e-01f, 1.14080407e-01f, -3.39204594e-02f, 1.03965156e-01f, -3.42368931e-01f, -3.72063764e-03f, -2.54017174e-01f, 2.04711258e-01f, 1.29065663e-01f, -2.93779690e-02f,
  -1.66445613e-01f, 1.39146708e-02f, -2.16621011e-01f, -2.14683786e-01f, 1.73312217e-01f, -2.34796599e-01f, 1.17367364e-01f, 2.13744253e-01f, -2.43972644e-01f, -6.04152903e-02f,
  7.52812997e-02f, -8.20761696e-02f, 1.22343704e-01f, -7.82420188e-02f, 2.28341773e-01f, 7.03820139e-02f, -7.63144344e-03f, 1.11368291e-01f, 1.76943153e-01f, 8.50850642e-02f,
  -9.53998640e-02f, 1.09906428e-01f, -1.00635476e-02f, 1.39516860e-01f, 1.89649656e-01f, 9.13227722e-02f, 1.47894382e-01f, 4.70096543e-02f, 5.49680134e-03f, -2.17887536e-01f,
  -5.79694025e-02f, -1.96335092e-01f, -1.43243238e-01f, -1.59630150e-01f, 2.11472481e-01f, -1.17023125e-01f, 2.89368331e-01f, 2.13049486e-01f, 1.42682809e-02f, -7.87557065e-02f,
  -6.86822241e-05f, 1.96668163e-01f, 2.15301998e-02f, 6.40870407e-02f, 7.63643607e-02f, 1.15621381e-01f, 1.69715300e-01f, 4.71174531e-02f, 1.74184889e-01f, -7.60317966e-02f,
  1.64215580e-01f, 1.68858618e-01f, -1.51747033e-01f, 6.30366877e-02f, 2.37968609e-01f, 2.23843411e-01f, 2.15997085e-01f, 2.29798183e-01f, -6.49235696e-02f, -1.56084999e-01f,
  -8.32732320e-02f, 1.41481280e-01f, 5.42750843e-02f, -9.09213722e-02f, 3.42059657e-02f, 2.14032367e-01f, 6.07813783e-02f, 1.43522210e-03f, 1.12808749e-01f, -3.36921983e-03f,
  -4.34363745e-02f, -1.08024091e-01f, -1.62314206e-01f, 9.71105229e-03f, 2.31326252e-01f, 1.41408384e-01f, 1.72365561e-01f, 3.83671410e-02f, 2.31148419e-03f, 2.05540136e-02f,
  -2.83006392e-02f, 3.23873498e-02f, 7.07408553e-03f, 8.86974204e-03f, 4.58885543e-03f, 7.88872987e-02f, -1.99975699e-01f, 5.50326556e-02f, -4.73693907e-02f, -2.07888968e-02f,
  2.05174968e-01f, 2.28874385e-02f, 3.84983644e-02f, -1.42673790e-01f, -9.29413885e-02f, -1.51643723e-01f, -1.01421468e-01f, -1.36136144e-01f, 5.61940335e-02f, -9.60206985e-02f,
  2.04486161e-01f, 1.73520714e-01f, 1.14703551e-01f, 9.05480981e-02f, -9.56652090e-02f, 1.53797895e-01f, -6.06924370e-02f, 1.17480077e-01f, 2.24710211e-01f, 2.35018790e-01f,
  1.16487183e-01f, 1.38637364e-01f, -5.05646178e-03f, 6.28870875e-02f, 8.84083360e-02f, 1.79370657e-01f, -1.32153139e-01f, 5.74694835e-02f, 5.19211367e-02f, 2.76084781e-01f,
  -4.34086435e-02f, 8.53970423e-02f, -1.50628835e-01f, -6.31727949e-02f, -2.04267621e-01f, 3.86780091e-02f, 7.45079666e-02f, -1.17409825e-01f, -6.64530620e-02f, 1.02513626e-01f,
  4.23390381e-02f, -1.60468563e-01f, 1.01374246e-01f, -2.58973867e-01f, -5.08711711e-02f, 1.12635978e-02f, -9.18710828e-02f, 8.78331251e-03f, 6.70390204e-02f, 2.15228856e-01f,
  3.17625523e-01f, 4.37555574e-02f, 3.87457870e-02f, 4.44000661e-02f, 5.21804914e-02f, 5.61983325e-02f, 1.89870775e-01f, 6.69002980e-02f, -8.78398567e-02f, -1.16865031e-01f,
  9.01530683e-02f, 1.26895467e-02f, 1.82465672e-01f, -7.87654147e-02f, 1.88006043e-01f, 9.37542766e-02f, -9.52151045e-03f, -1.79936811e-01f, 9.18401480e-02f, 3.82544510e-02f,
  -2.20187474e-02f, 1.78184696e-02f, 1.34886233e-02f, -6.59353137e-02f, 2.79887989e-02f, -4.33276743e-02f, -1.12509146e-01f, -1.30437966e-02f, 1.64011419e-01f, -1.61716994e-02f,
  1.00324944e-01f, -2.01961258e-03f, -6.09924039e-03f, 6.70019463e-02f, 1.38060287e-01f, 5.31837754e-02f, -4.41624448e-02f, -3.25767323e-02f, 3.30698639e-02f, 2.61784852e-01f,
  1.11567965e-02f, 1.58060968e-01f, 4.04123589e-03f, 1.85366318e-01f, 1.80754811e-01f, 1.81049004e-01f, 2.68637300e-01f, 1.01311915e-01f, 2.22435117e-01f, 1.46415353e-01f,
  7.76772127e-02f, -6.63270289e-03f, 1.96064234e-01f, 1.72291119e-02f, 7.35890418e-02f, -1.12364784e-01f, 2.17634067e-01f, 2.00238377e-01f, -9.79323611e-02f, -1.33914724e-01f,
  -2.39784326e-02f, 1.37814298e-01f, -4.00197431e-02f, 2.44871173e-02f, -1.66660368e-01f, -5.09218574e-02f, -4.39071916e-02f, 4.30743024e-02f, -7.78010562e-02f, 2.49109901e-02f,
  9.87729952e-02f, -7.74396509e-02f, -8.15194175e-02f, -1.05997965e-01f, -1.65318623e-01f, -5.42863570e-02f, -1.05558865e-01f, 1.09330498e-01f, -1.34019807e-01f, -5.58744408e-02f,
  5.29924408e-02f, 1.31013572e-01f, 1.49926826e-01f, -1.90464519e-02f, -1.07484981e-01f, -1.13731772e-02f, -2.18549639e-01f, -2.99000088e-02f, -2.14651331e-01f, -3.27657312e-02f,
  -1.24461211e-01f, 2.32983261e-01f, -5.03971316e-02f, 2.36561336e-02f, 1.61504015e-01f, 2.34479830e-01f, -2.50227731e-02f, 1.20719016e-01f, 1.45797968e-01f, -1.16914716e-02f,
  1.42238438e-01f, 2.24695891e-01f, 1.09345086e-01f, 1.31528929e-01f, -5.76526560e-02f, -1.50248766e-01f, 3.16014769e-03f, 5.34226038e-02f, 4.06398065e-02f, -8.10565427e-03f,
  3.71786326e-01f, -1.94128692e-01f, 3.63990724e-01f, 2.51833588e-01f, -7.69638866e-02f, 3.17781866e-02f, 1.68110237e-01f, -2.34744266e-01f, 1.13255925e-01f, 6.72222599e-02f,
  9.32973111e-04f, -2.41258163e-02f, 1.70842782e-01f, 3.66265848e-02f, -8.51297602e-02f, 8.79778713e-02f, 6.10799119e-02f, 1.21253677e-01f, 9.46842134e-02f, 1.71612546e-01f,
  2.47776099e-02f, 3.54949161e-02f, -7.72617385e-02f, -3.43291089e-02f, 9.02817398e-02f, 1.33942172e-01f, 1.16799347e-01f, 8.71506240e-03f, 2.06573293e-01f, 2.03548416e-01f,
  -9.39746276e-02f, 6.27484098e-02f, 9.86710936e-02f, 9.52098072e-02f, -4.28150594e-02f, -1.62391327e-02f, 4.34235595e-02f, 1.12613894e-01f, 2.04712868e-01f, 2.07930028e-01f,
  1.80353224e-01f, 1.53635129e-01f, 1.75054058e-01f, -3.00585385e-02f, 2.07167774e-01f, -1.74403489e-02f, 1.53207958e-01f, 8.46663043e-02f, 1.11574586e-02f, -3.86706926e-02f,
  -8.92662480e-02f, -5.31951040e-02f, 8.37212801e-02f, 1.11335047e-01f, -1.21548332e-01f, -7.51739368e-02f, -1.81752846e-01f, -1.07414715e-01f, 1.50561228e-01f, 1.35175258e-01f,
  -6.23395517e-02f, -1.22993879e-01f, 2.46999934e-01f, 1.20472752e-01f, -4.19364236e-02f, 2.31432039e-02f, -7.86886662e-02f, -5.81185743e-02f, 5.94570525e-02f, -2.37103328e-02f,
  -1.33427590e-01f, 8.16640928e-02f, -1.43032074e-01f, -1.23355743e-02f, -1.74808845e-01f, 2.52782494e-01f, 1.39774561e-01f, 8.54454488e-02f, 1.30849287e-01f, -1.19876161e-01f,
  -5.95440753e-02f, 4.52406369e-02f, 6.01310767e-02f, -7.29096979e-02f, -6.36657625e-02f, -1.98052432e-02f, 1.45059600e-01f, 8.68227258e-02f, -6.78511038e-02f, -7.53001124e-03f,
  8.40750933e-02f, -3.57028395e-01f, 5.03698103e-02f, -3.98059078e-02f, -1.76199377e-01f, 4.49797660e-02f, -9.53145176e-02f, -1.42629379e-02f, -1.06585911e-02f, 2.16989905e-01f,
  1.52431488e-01f, 1.32395148e-01f, 1.91516578e-01f, 1.61597803e-01f, -9.21250731e-02f, 1.61010697e-01f, -3.36372912e-01f, 2.91106477e-02f, 3.90238836e-02f, 3.05587620e-01f,
  1.59707397e-01f, -4.77528386e-02f, 9.04711634e-02f, 2.15393364e-01f, 2.08388671e-01f, -7.47104064e-02f, 7.73165524e-02f, -9.05883610e-02f, -3.92068699e-02f, 1.35389149e-01f,
  3.69703807e-02f, 5.55107966e-02f, 6.91856965e-02f, -1.38200477e-01f, -2.60004681e-02f, -2.40251794e-02f, -1.19809784e-01f, -4.93899658e-02f, 1.01413384e-01f, 1.04675956e-01f,
  2.17830136e-01f, 1.47158906e-01f, 5.69296777e-02f, 1.99747577e-01f, 1.72608331e-01f, -1.97215542e-01f, -9.03251842e-02f, 2.39782795e-01f, -1.90263577e-02f, 1.25326201e-01f,
  2.11735889e-01f, 2.36538634e-01f, 9.89138484e-02f, 2.52384186e-01f, -4.08867970e-02f, -1.34204119e-01f, -8.76002833e-02f, -1.92184106e-01f, -7.46470839e-02f, 1.10838681e-01f,
  -3.30387801e-02f, -8.62902105e-02f, -5.02564944e-02f, 3.42688039e-02f, -8.19325298e-02f, -6.22930713e-02f, -1.38452873e-01f, -5.65096103e-02f, -2.14732904e-02f, 1.26984164e-01f,
  -6.83220327e-02f, -9.29188356e-02f, 3.08452523e-03f, 2.21371472e-01f, 1.08764745e-01f, 3.78721543e-02f, -1.71110034e-02f, 1.23245873e-01f, -1.74384952e-01f, -5.67517392e-02f,
  -4.84930314e-02f, 5.43347634e-02f, 1.25279441e-01f, 2.44914830e-01f, -6.69496879e-02f, -8.38877168e-03f, 3.99908572e-02f, 1.58585712e-01f, -8.82376730e-02f, -5.61530814e-02f,
  1.53499350e-01f, 1.72257498e-01f, -1.30872712e-01f, 1.14882760e-01f, -1.05599172e-01f, -8.42485502e-02f, -9.71569791e-02f, -6.72459230e-02f, 3.23389024e-02f, 8.65627080e-03f,
  -1.15959771e-01f, -1.04345568e-02f, 9.92806703e-02f, -8.59473944e-02f, -2.61290348e-04f, 6.58108592e-02f, -1.62472755e-01f, 1.42086878e-01f, -9.24474150e-02f, -1.36708200e-01f,
  -7.90573582e-02f, -1.40464157e-01f, -1.08661197e-01f, -1.13653049e-01f, 1.55742079e-01f, 2.31330737e-01f, -1.33616328e-01f, 6.63196743e-02f, -7.41639882e-02f, -5.55486828e-02f,
  1.97220951e-01f, -6.54759780e-02f, -1.82933167e-01f, -4.77341637e-02f, -8.17433968e-02f, 5.07515371e-02f, 3.77989635e-02f, -6.65266439e-02f, 1.34947017e-01f, 1.25811830e-01f,
  -1.29065394e-01f, -1.33795738e-01f, -1.71827540e-01f, -2.41682529e-02f, -1.56279162e-01f, -7.96702281e-02f, -1.39128612e-02f, 1.04391791e-01f, 1.51057452e-01f, 4.58160266e-02f,
  -4.13363576e-02f, 1.20058514e-01f, -7.70954564e-02f, -2.51811985e-02f, 9.58641320e-02f, -1.02459379e-01f, 7.83890262e-02f, 3.37495320e-02f, -2.74764299e-01f, -2.02547014e-02f,
  7.94026330e-02f, -9.28299725e-02f, -1.47239923e-01f, 2.16079921e-01f, 2.12044179e-01f, 2.90555865e-01f, -1.10342354e-01f, 7.12408870e-02f, -1.34249032e-01f, -5.52196875e-02f,
  -2.45732758e-02f, -2.63355044e-03f, -1.74197018e-01f, 1.12993577e-02f, -6.26931638e-02f, 3.48097794e-02f, 7.07658082e-02f, -1.54082477e-01f, 4.11053449e-02f, 6.87381700e-02f,
  -1.31799608e-01f, 8.46951976e-02f, -5.84097430e-02f, 1.41522363e-01f, 8.24370012e-02f, -2.73529112e-01f, -1.65137202e-01f, 9.83544812e-02f, 1.40437454e-01f, 1.60434425e-01f,
  -8.39422643e-02f, 1.60117730e-01f, -2.11582258e-02f, 7.14668259e-02f, 2.06309110e-01f, 6.27545789e-02f, 3.99513394e-02f, 2.66860407e-02f, -3.35907117e-02f, 5.47127314e-02f,
  1.20473698e-01f, 3.49143445e-02f, 9.71316621e-02f, 3.35735008e-02f, 1.40729010e-01f, -1.46371171e-01f, 4.15587947e-02f, -1.85846969e-01f, 5.05212136e-02f, 6.19676448e-02f,
  1.72928851e-02f, -2.09350824e-01f, 2.94987541e-02f, 8.87254626e-02f, -9.72168893e-02f, -3.09200473e-02f, 8.80904719e-02f, -8.67550969e-02f, 1.81545809e-01f, -8.91542360e-02f,
  1.93508193e-02f, -9.27634090e-02f, -1.64585486e-02f, -4.72235307e-02f, 2.98757534e-02f, -1.80870980e-01f, -1.75272021e-02f, 1.29467815e-01f, 6.94194529e-03f, 1.59325212e-01f,
  -5.26313893e-02f, -6.02445751e-02f, 3.14865932e-02f, 8.80939588e-02f, -3.20409588e-03f, 1.45523623e-01f, -1.00772120e-01f, 7.46555328e-02f, 1.05248392e-01f, 1.99949339e-01f,
  1.10690529e-02f, 7.40922168e-02f, -1.20246030e-01f, -4.02952470e-02f, 7.60512352e-02f, 1.05826542e-01f, -1.64425239e-01f, 1.71747118e-01f, 1.13754664e-02f, -2.09803566e-01f,
  9.75013152e-02f, 7.50977471e-02f, -1.74954087e-01f, -1.90015271e-01f, 8.52792040e-02f, 1.62601426e-01f, -5.65702282e-02f, 4.79562581e-02f, 7.87630901e-02f, 2.79933810e-02f,
  1.43065006e-02f, 5.98427653e-02f, 8.41646120e-02f, 2.23353565e-01f, 2.65271753e-01f, 3.84045355e-02f, 6.59594536e-02f, -8.77581816e-03f, 2.58620471e-01f, -9.02146250e-02f,
  7.62836710e-02f, -3.81905288e-02f, 3.43608335e-02f, -5.06858639e-02f, 2.21724734e-02f, 2.21223116e-01f, 2.97157198e-01f, 2.46512458e-01f, 1.22708278e-02f, -2.62839776e-02f,
  1.77631125e-01f, -2.18765214e-01f, -2.44888440e-02f, -2.34864838e-02f, 1.64638251e-01f, 1.96073443e-01f, 2.24457547e-01f, -5.03166094e-02f, 1.64702430e-01f, -8.52730032e-03f,
  -1.59610286e-01f, -1.28608599e-01f, -9.74376723e-02f, -1.40947737e-02f, -1.08225107e-01f, -1.32126033e-01f, 6.72153905e-02f, -1.34206623e-01f, 1.72962323e-02f, 8.48350227e-02f,
  -6.78321570e-02f, -2.12829188e-01f, 1.81437247e-02f, 1.23200200e-01f, -1.39507502e-01f, 1.07607223e-01f, 5.89777566e-02f, -2.35814359e-02f, -7.08526000e-02f, 2.11338177e-01f,
  9.41127539e-03f, -2.97778547e-02f, -3.04073319e-02f, -1.27928481e-01f, -1.22961022e-01f, 1.65448070e-01f, 1.92377061e-01f, 1.22450411e-01f, 7.90172145e-02f, 1.89792648e-01f,
  1.84066862e-01f, -2.04511181e-01f, -1.14765175e-01f, -4.01941650e-02f, -1.50148377e-01f, 6.60561845e-02f, 1.11119188e-02f, 4.06443141e-02f, -9.03991237e-02f, -2.92483345e-02f,
  4.43636999e-02f, -1.39462903e-01f, -2.30761513e-01f, -6.88383952e-02f, -5.96215762e-02f, 1.61858037e-01f, 1.09267369e-01f, -7.51881627e-03f, -3.35407630e-02f, 1.12467997e-01f,
  1.28606647e-01f, 7.68939108e-02f, 6.48101941e-02f, 3.57439183e-02f, -1.02394477e-01f, -4.82755899e-02f, -6.16438920e-03f, 6.61514550e-02f, 1.16683766e-01f, 2.60023981e-01f,
  3.91895920e-02f, -1.78331017e-01f, -1.88559610e-02f, 1.94313645e-01f, -9.83447582e-02f, 7.48105347e-02f, 2.33893484e-01f, 2.14748070e-01f, -8.94189551e-02f, -2.23447904e-02f,
  -1.97838902e-01f, 2.99907234e-02f, 1.32821783e-01f, 1.53962210e-01f, -1.31345585e-01f, 1.10951163e-01f, -4.90173995e-02f, 1.20881394e-01f, 2.17375625e-02f, -9.51525941e-02f,
  1.28217489e-01f, 2.83999085e-01f, -4.91482504e-02f, 3.75557039e-03f, -8.70874524e-02f, -8.24221671e-02f, -5.09567074e-02f, -1.48536295e-01f, -7.60542527e-02f, -7.74029940e-02f,
  1.72176272e-01f, 1.31557688e-01f, 6.35383055e-02f, 1.27713010e-01f, -1.24258645e-01f, -1.51176661e-01f, 1.88779324e-01f, -2.25921631e-01f, 1.27780259e-01f, 1.03196643e-01f,
  2.95753758e-02f, -9.49029103e-02f, 2.12182939e-01f, 6.58877045e-02f, 1.92873225e-01f, 6.90374151e-02f, -5.87117150e-02f, 1.30073696e-01f, -6.56172931e-02f, 6.10703230e-02f,
  1.28123596e-01f, 6.96519464e-02f, 4.47066082e-03f, -1.17104225e-01f, -4.60618064e-02f, -1.62059173e-01f, 7.46521875e-02f, 4.18091193e-03f, 6.51212558e-02f, 1.00994661e-01f,
  1.19932830e-01f, 2.26941809e-01f, -8.20792764e-02f, -1.74884666e-02f, -7.73614645e-02f, 1.82324618e-01f, -3.04668620e-02f, 8.53565484e-02f, 1.37938514e-01f, 1.68137789e-01f,
  2.13410676e-01f, 1.79337151e-02f, 5.46059571e-02f, 1.01004452e-01f, -4.01744284e-02f, 1.80646166e-01f, -3.94074582e-02f, -6.02765754e-02f, 1.50815949e-01f, 1.03322461e-01f,
  1.07519627e-01f, 7.10232407e-02f, -5.03532290e-02f, -1.62504867e-01f, -2.05458719e-02f, 2.76072770e-02f, 6.74329177e-02f, -2.10114345e-01f, -1.28418937e-01f, 1.15915120e-01f,
  -1.30135849e-01f, -5.33697531e-02f, 7.95902461e-02f, -1.45117044e-01f, 1.67119980e-01f, 2.11602628e-01f, -1.88437313e-01f, -1.31283598e-02f, 5.03204688e-02f, 1.60134301e-01f,
  2.22338185e-01f, 2.95949336e-02f, 2.07980007e-01f, 1.93722602e-02f, 6.54764026e-02f, 9.55956429e-02f, 3.23120475e-01f, 4.58196066e-02f, 9.06062275e-02f, -5.75086921e-02f,
  3.19616318e-01f, -6.14093896e-03f, 3.26968059e-02f, -9.86984149e-02f, 1.89501345e-01f, 4.92467396e-02f, -2.82227509e-02f, -8.07896405e-02f, 2.18273029e-01f, 2.23192722e-01f,
  8.81001279e-02f, 7.89395571e-02f, -2.27154475e-02f, -6.97650164e-02f, 9.31424126e-02f, 5.71006052e-02f, 6.96026608e-02f, 2.74160318e-02f, 1.44903153e-01f, -3.05147860e-02f,
  1.20745294e-01f, -1.61925837e-01f, -1.78507432e-01f, 8.99230875e-03f, 1.70145242e-03f, 1.72648638e-01f, -2.65148401e-01f, -2.08831191e-01f, -2.22978503e-01f, -1.53046533e-01f,
  1.41682267e-01f, 2.09956378e-01f, -4.79260683e-02f, -1.41128093e-01f, 1.42374769e-01f, 1.54039860e-01f, -2.81593278e-02f, 2.31783390e-01f, -1.05851218e-01f, -1.10913411e-01f,
  -7.94956088e-03f, 3.42801102e-02f, -7.95789585e-02f, -6.79222643e-02f, -2.16314569e-01f, -2.99216628e-01f, 5.95313683e-02f, 2.45568648e-01f, -5.89270517e-02f, 4.22689021e-02f,
  5.43601178e-02f, 1.72712728e-01f, -1.10134095e-01f, -4.06207293e-02f, -9.15537626e-02f, -2.74558924e-02f, 1.47601878e-02f, -3.83567289e-02f, -6.97459735e-04f, 6.86298832e-02f,
  3.79438512e-02f, -7.68064111e-02f, 1.79479554e-01f, -9.93690267e-02f, 2.41548344e-01f, -1.81714594e-02f, 4.31325659e-03f, -1.83504328e-01f, 1.00156076e-01f, 1.20340727e-01f,
  -9.10230353e-03f, -8.51336718e-02f, 7.17620598e-03f, 1.63448766e-01f, 8.39567259e-02f, -2.01163013e-02f, 9.16444063e-02f, -4.75899465e-02f, 8.94851610e-02f, 3.55188437e-02f,
  7.58020952e-02f, 3.76740992e-02f, 1.40228912e-01f, -1.97334349e-01f, -6.45198971e-02f, -1.49343237e-01f, 2.38423366e-02f, -7.98725411e-02f, 3.95164415e-02f, 1.92977861e-01f,
  -1.77193314e-01f, -2.18078345e-01f, -2.20368654e-01f, 4.76863561e-03f, 1.19466938e-01f, 2.66587704e-01f, -1.20138146e-01f, 6.15146123e-02f, 2.10364163e-02f, 9.11550000e-02f,
  -2.13545233e-01f, 2.68633962e-01f, -2.01433286e-01f, 5.76229729e-02f, 1.48888901e-01f, 8.97739306e-02f, -2.08405539e-01f, -7.38748387e-02f, -2.03048065e-01f, -1.98475957e-01f,
  2.77882554e-02f, 1.60787582e-01f, 7.18345642e-02f, 9.64157283e-03f, 8.10353905e-02f, 1.11516088e-01f, -1.71892285e-01f, -1.16308831e-01f, -9.60633066e-03f, -1.44491404e-01f,
  -1.68375701e-01f, -1.04075789e-01f, 5.86849749e-02f, -2.13645250e-02f, -1.41998008e-01f, -1.24094866e-01f, -8.74062851e-02f, -2.16265783e-01f, 1.15392484e-01f, 9.76741537e-02f,
  -1.09665461e-01f, -1.23557501e-01f, 1.86988831e-01f, 1.53805122e-01f, 1.06161535e-02f, -8.15648064e-02f, -1.96711093e-01f, 1.07884943e-01f, 9.23399031e-02f, 1.54244438e-01f,
  -7.42428899e-02f, -1.47832120e-02f, 7.69409388e-02f, 7.59572815e-03f, -4.49935487e-03f, -1.22231029e-01f, 2.20174566e-01f, -9.18728206e-03f, -2.53151238e-01f, -8.63793418e-02f,
  7.02618882e-02f, -8.51958543e-02f, -1.37036979e-01f, 5.56914955e-02f, -1.25200540e-01f, -5.52269891e-02f, -8.72793645e-02f, 6.50235936e-02f, 1.63034067e-01f, 2.83893824e-01f,
  -6.30422542e-03f, 7.55524682e-03f, 1.14976533e-01f, 1.88459575e-01f, -1.16105683e-01f, 2.67401546e-01f, -9.25739929e-02f, -5.65768592e-02f, 1.85512617e-01f, -2.88502872e-01f,
  -7.48087987e-02f, 1.79965273e-02f, -1.92425594e-01f, -2.46645004e-01f, 2.42004886e-01f, -6.89968467e-02f, -1.12524785e-01f, 4.23659645e-02f, 2.15007037e-01f, -1.33296996e-01f,
  -1.90973505e-01f, -1.12834103e-01f, -7.85251707e-02f, -1.01347327e-01f, -8.36109295e-02f, 9.33567286e-02f, -3.26520018e-02f, -1.67723805e-01f, 4.19161618e-02f, 2.21602730e-02f,
  -1.61169589e-01f, -2.97924429e-02f, -1.57642797e-01f, -5.90956025e-02f, 2.71116234e-02f, 8.81998837e-02f, -1.58202142e-01f, -4.48801517e-02f, 1.77183992e-03f, -2.04552105e-03f,
  1.12294950e-01f, 2.01449186e-01f, -3.31719108e-02f, 1.47747606e-01f, -1.51153162e-01f, -5.55584095e-02f, -5.15151434e-02f, -9.62649062e-02f, 5.07181101e-02f, 1.34683400e-01f,
  -8.79683346e-02f, 1.33774336e-02f, 1.76676854e-01f, 1.30041152e-01f, -1.05852231e-01f, 1.24430828e-01f, 1.76129162e-01f, 6.27574995e-02f, -5.73870726e-02f, 2.13900968e-01f,
  5.23186736e-02f, -6.49675354e-02f, 1.70096271e-02f, -1.34832904e-01f, -7.73759782e-02f, 9.76727977e-02f, -7.59696141e-02f, -1.96812242e-01f, 2.73045152e-01f, -6.10560887e-02f,
  3.14872079e-02f, -1.08409077e-01f, -1.52786061e-01f, -2.44240686e-02f, 2.05846671e-02f, -1.21339113e-01f, 1.59156308e-01f, -2.55146325e-01f, -1.07050598e-01f, 1.26546770e-01f,
  3.41752842e-02f, -1.32316634e-01f, 1.93761326e-02f, 4.17701714e-02f, 4.77301106e-02f, 1.67458877e-01f, 1.50992900e-01f, 2.52266973e-01f, 9.82153136e-03f, -3.41971358e-03f,
  -2.13522352e-02f, 2.52416227e-02f, 6.16665669e-02f, -5.30364439e-02f, 3.36362310e-02f, -1.51729554e-01f, -1.05225250e-01f, -4.17270772e-02f, 3.45185329e-03f, 1.98798209e-01f,
  -7.07506314e-02f, -9.49778110e-02f, 2.02741995e-02f, 6.58076927e-02f, 5.74527010e-02f, -8.37645829e-02f, -1.10986054e-01f, -1.18553534e-01f, -2.02685237e-01f, -3.69247757e-02f,
  -2.13711157e-01f, -4.38614413e-02f, -6.10354133e-02f, 1.19463392e-01f, 5.25406096e-03f, 1.78041682e-02f, 8.15165937e-02f, 1.91507265e-01f, -8.38195458e-02f, 3.05887237e-02f,
  5.48399985e-02f, -1.70993060e-02f, 4.28497009e-02f, 2.22495362e-01f, 7.10096136e-02f, 1.68440253e-01f, -7.11744875e-02f, -1.05316125e-01f, -3.01129706e-02f, 2.80628987e-02f,
  4.66032000e-03f, -8.15608129e-02f, 2.12410301e-01f, -1.35599211e-01f, 3.17632198e-01f, 1.82017297e-01f, 1.05813500e-02f, 1.09386139e-01f, 2.03116104e-01f, -8.76688063e-02f,
  1.17915794e-01f, 6.81755245e-02f, 3.79176736e-02f, -2.47854982e-02f, 1.87827051e-01f, 9.63824019e-02f, -8.55881721e-02f, 6.71798959e-02f, 1.09750338e-01f, 2.88457889e-02f,
  -1.06861025e-01f, 2.47091930e-02f, 2.43867245e-02f, 2.55530234e-02f, -4.06638645e-02f, 1.26967300e-02f, 1.97474621e-02f, 7.56402984e-02f, 8.44869390e-02f, 7.32700750e-02f,
  1.32388592e-01f, 2.05609456e-01f, -1.14316218e-01f, 5.38091995e-02f, -1.27834797e-01f, 3.76631180e-03f, -8.64104256e-02f, 9.65864807e-02f, 5.60288094e-02f, 6.26649633e-02f,
  1.79407030e-01f, 2.01655060e-01f, -1.45597442e-03f, 2.35832497e-01f, 2.43688393e-02f, -5.00595421e-02f, 1.32410541e-01f, 1.94184890e-03f, -3.81579027e-02f, 1.61568075e-01f,
  9.45748687e-02f, -5.25873192e-02f, -7.03587756e-02f, -9.68023986e-02f, -1.95561629e-02f, -1.49896797e-02f, -3.86950778e-05f, -2.45444346e-02f, -8.71922225e-02f, -1.40584245e-01f,
  1.12208232e-01f, 2.44092885e-02f, 1.22831063e-03f, -2.20151767e-01f, 1.22263290e-01f, -2.85530603e-03f, -8.23656917e-02f, 1.01600168e-02f, -1.92313641e-02f, -4.98982929e-02f,
  -2.95712519e-02f, 4.48000170e-02f, -7.68021420e-02f, 8.85966942e-02f, -5.79903871e-02f, 2.03819305e-01f, -2.59983420e-01f, 2.35180303e-01f, 2.50948340e-01f, 1.95768073e-01f,
  9.00589395e-03f, -1.28091037e-01f, 5.91316931e-02f, 3.68442503e-03f, -7.45245889e-02f, 1.29227601e-02f, 1.80133048e-03f, -9.94515195e-02f, 1.30247949e-02f, -2.18832418e-02f,
  -1.85394496e-01f, 1.42360723e-03f, -1.47450063e-02f, -7.42442608e-02f, 5.16385064e-02f, 5.39099313e-02f, -3.90948206e-02f, -7.09060356e-02f, 6.53335825e-02f, 1.51035646e-02f,
  -4.24596444e-02f, 1.43998235e-01f, -2.78614927e-02f, 4.59184498e-03f, 6.26494512e-02f, 1.81711614e-01f, 1.31747022e-01f, 1.68595344e-01f, -3.68787348e-02f, 2.79115364e-02f,
  1.68183357e-01f, -8.28951299e-02f, 2.05372512e-01f, 1.40277803e-01f, -8.87450203e-02f, -6.48237988e-02f, 1.43319324e-01f, -1.72596872e-01f, -1.45860329e-01f, -1.45629704e-01f,
  2.14963825e-03f, -2.52653323e-02f, 9.17938724e-02f, -5.23294769e-02f, 1.13131918e-01f, 7.45699331e-02f, 6.75038174e-02f, -1.52450070e-01f, -6.89908043e-02f, 1.34778991e-02f,
  -1.37612030e-01f, 1.48280919e-01f, -7.83007741e-02f, -1.15123823e-01f, 1.48739725e-01f, 2.75985128e-03f, 7.81011954e-02f, -3.33066210e-02f, 5.81145547e-02f, 2.18700454e-01f,
  2.07257923e-02f, 6.23286776e-02f, 8.43759999e-02f, 7.75854737e-02f, 1.59895569e-01f, -1.06220782e-01f, 1.09063098e-02f, -6.79150969e-02f, -5.18216006e-02f, -7.32266977e-02f,
  -4.18558754e-02f, 4.30023558e-02f, -4.79782559e-02f, 6.64645657e-02f, 3.20513733e-02f, -1.23647176e-01f, 1.73683763e-01f, -2.51292646e-01f, -7.31570739e-03f, -1.56307295e-01f,
  -2.15840057e-01f, -5.37263080e-02f, -8.14199969e-02f, -2.24330798e-02f, 1.36942565e-01f, 1.17882073e-01f, 1.65094599e-01f, 1.47341400e-01f, 2.25980371e-01f, 5.14930263e-02f,
  -4.86594364e-02f, 6.58608973e-02f, -1.21739559e-01f, -8.05343408e-03f, 5.39971627e-02f, 2.61316508e-01f, 9.76314917e-02f, 6.33449340e-03f, 3.39381285e-02f, 9.77892131e-02f,
  2.23528501e-02f, -1.40623763e-01f, 5.39982207e-02f, 9.01528522e-02f, -6.67930096e-02f, 1.50219828e-01f, -7.04557896e-02f, -3.45169306e-02f, 1.81725860e-01f, -6.33384883e-02f,
  -8.06860998e-02f, -6.82477141e-03f, -1.60356194e-01f, -8.26585963e-02f, -6.75497875e-02f, 2.44716823e-01f, -6.87602311e-02f, 1.39282912e-01f, 1.56081334e-01f, 6.33998439e-02f,
  -6.60975128e-02f, -1.37344480e-01f, -1.73236400e-01f, 7.39405211e-03f, -1.45941839e-01f, 1.55043425e-02f, 2.24880502e-01f, 2.27705911e-01f, 1.68685406e-01f, 2.37415075e-01f,
  -1.39472395e-01f, 2.89040431e-02f, 3.36141177e-02f, 3.45850512e-02f, 1.85438871e-01f, 6.95592314e-02f, 5.00958338e-02f, 1.75384387e-01f, 4.73098040e-01f, 3.57595719e-02f,
  2.12480620e-01f, 4.17915136e-02f, 1.13248073e-01f, -2.71472692e-01f, 2.39234902e-02f, -1.50451168e-01f, 1.22965127e-02f, -1.06559098e-01f, -1.00240670e-02f, -2.25744303e-03f,
  2.63518333e-01f, 1.12972766e-01f, -6.28658608e-02f, -1.87605619e-01f, 9.49378088e-02f, -1.34606794e-01f, -3.70500870e-02f, 5.24907093e-03f, -1.20168570e-02f, 1.93636447e-01f,
  4.29475568e-02f, -1.24829762e-01f, 2.57111520e-01f, -1.85731187e-01f, -2.30896585e-02f, 5.63890673e-02f, 1.01210982e-01f, 1.41166851e-01f, -1.84594586e-01f, -1.59730002e-01f,
  -1.53084427e-01f, -1.43692791e-01f, -1.07705489e-01f, -7.19663650e-02f, 8.62738234e-04f, 4.68816273e-02f, 6.90012127e-02f, 1.97320029e-01f, -1.19644560e-01f, 9.16715786e-02f,
  -1.22013234e-01f, 8.76891613e-02f, 3.01479213e-02f, 3.29996407e-01f, -1.36506230e-01f, -6.91321194e-02f, -4.76768054e-02f, -1.76839754e-01f, -7.73875937e-02f, 2.12366581e-01f,
  6.27301261e-02f, 3.20544802e-02f, -1.60074130e-01f, 3.31607908e-01f, 8.46573338e-02f, -2.90681720e-02f, -3.49957645e-02f, -1.40585722e-02f, 9.12325233e-02f, -7.49815479e-02f,
  6.44368380e-02f, 6.85580671e-02f, -4.58709486e-02f, -9.28675830e-02f, 1.32753998e-02f, 1.13444276e-01f, 5.46976477e-02f, -2.39547323e-02f, 2.50295829e-02f, -7.19479425e-03f,
  -5.85734583e-02f, -2.01332886e-02f, -4.91747074e-02f, -4.80955094e-03f, -1.18323853e-02f, 1.18639700e-01f, 4.84679900e-02f, -2.16093455e-02f, 1.49210826e-01f, 2.00937856e-02f,
  -2.64315959e-02f, 2.19987091e-02f, 1.17039047e-01f, -7.07649365e-02f, 6.83062151e-02f, 2.03499347e-01f, 4.30209003e-02f, -9.22644958e-02f, 6.19533509e-02f, -9.00647491e-02f,
  -2.63969712e-02f, -1.68625891e-01f, 6.30712882e-02f, 6.51311353e-02f, 1.80517718e-01f, -3.18914093e-02f, 4.88934070e-02f, -5.35681359e-02f, 1.07781865e-01f, -1.81237936e-01f,
  -1.09369300e-01f, -9.72872600e-02f, -2.96916347e-02f, 8.65162238e-02f, -1.21441379e-01f, -2.00106099e-01f, 1.04014210e-01f, 4.91156466e-02f, 8.65928903e-02f, 3.51509750e-02f,
  1.70417920e-01f, 4.72989567e-02f, -9.62511376e-02f, 1.22750968e-01f, -1.68281905e-02f, -3.97769064e-02f, 9.20187309e-02f, 1.27469590e-02f, 1.28152400e-01f, 1.26149446e-01f,
  -1.98942181e-02f, 1.34109050e-01f, 1.82944417e-01f, 4.88411710e-02f, 1.31715268e-01f, -1.05173318e-02f, -3.71216573e-02f, 2.01123077e-02f, -4.12583817e-03f, 2.29886035e-03f,
  3.12537611e-01f, 1.38734251e-01f, 1.54589107e-02f, -1.07121319e-01f, 1.33808926e-01f, 8.91983137e-02f, -5.58327921e-02f, 5.03291488e-02f, 5.40751852e-02f, -3.08402330e-02f,
  1.56217679e-01f, 1.13515943e-01f, 9.48342830e-02f, 9.17848498e-02f, 7.63381794e-02f, 1.35651186e-01f, 4.43759561e-02f, -9.26401764e-02f, 2.39676341e-01f, 1.88967541e-01f,
  3.58400047e-02f, -4.91571315e-02f, 3.28285471e-02f, -8.15529376e-02f, -1.57857150e-01f, -1.63855031e-01f, -3.33685912e-02f, -3.63153741e-02f, -5.89105487e-02f, 5.87595478e-02f,
  -5.40004671e-02f, 1.61131620e-01f, 2.27095485e-01f, -2.22280338e-01f, 1.14701957e-01f, 1.99218899e-01f, -2.04636082e-01f, 2.35388160e-01f, -8.46837908e-02f, -1.09107859e-01f,
  9.60929394e-02f, 1.98066130e-01f, 2.60222740e-02f, -4.38128319e-03f, -6.43167347e-02f, 1.39543325e-01f, -2.31674146e-02f, 8.58390555e-02f, 5.04461527e-02f, 6.34661689e-02f,
  -1.23948276e-01f, -1.21038303e-01f, 1.33720711e-01f, -1.22958019e-01f, -1.08166233e-01f, -2.05382947e-02f, 1.72149062e-01f, 1.62043974e-01f, -8.70255195e-03f, 6.00305274e-02f,
  -1.06503777e-01f, 1.03994451e-01f, -5.92117496e-02f, 9.46036801e-02f, 1.29529819e-01f, 2.36599565e-01f, 1.20937467e-01f, 1.97769299e-01f, 1.56306565e-01f, 3.46699990e-02f,
  -5.06778732e-02f, 1.60288662e-01f, 2.20329389e-02f, -1.41025692e-01f, 1.62798077e-01f, 7.01330453e-02f, -5.76232225e-02f, 1.05455272e-01f, 1.56067520e-01f, 3.05342853e-01f,
  1.75954312e-01f, -2.70441473e-02f, 1.98196262e-01f, 1.34048522e-01f, -8.80113170e-02f, 7.48976618e-02f, 8.13137516e-02f, -4.64777052e-02f, 1.18654063e-02f, -9.95479301e-02f,
  -8.52563232e-03f, -2.11749058e-02f, -3.51273231e-02f, 9.87994447e-02f, 1.17531074e-02f, 9.78107750e-02f, 2.32519969e-01f, -1.77688405e-01f, 1.58706754e-01f, 2.99782902e-02f,
  -1.00872636e-01f, 4.71136793e-02f, 4.19760607e-02f, 5.97886480e-02f, 3.97645599e-05f, 7.59715587e-02f, 1.49605170e-01f, 8.67083520e-02f, -1.37831956e-01f, 2.69947052e-01f,
  1.19593017e-01f, -7.24046528e-02f, 2.30230153e-01f, 2.61023909e-01f, -1.84040859e-01f, -2.64429450e-01f, 1.17229797e-01f, 7.65416538e-03f, -1.76613182e-01f, -1.16062023e-01f,
  5.08963652e-02f, 7.02612326e-02f, 1.09643638e-02f, -8.23513791e-03f, 1.00478465e-02f, 9.68883336e-02f, -1.51452720e-01f, 5.78611754e-02f, -2.57555157e-01f, 3.14515531e-02f,
  1.57027930e-01f, 1.17380127e-01f, -4.43339301e-03f, 2.27900967e-02f, 7.67481839e-03f, 4.17589620e-02f, 5.68635911e-02f, -1.15931462e-02f, -1.62499636e-01f, -1.63189787e-02f,
  4.89050113e-02f, -1.01109289e-01f, 1.54308274e-01f, -1.09533854e-01f, 6.93864003e-02f, -2.77623814e-02f, 1.21245747e-02f, 4.09715995e-02f, 1.78926855e-01f, 1.30704761e-01f,
  -6.92273527e-02f, 1.84575364e-01f, 6.95505664e-02f, 5.90017019e-03f, 2.42252752e-01f, 1.50167733e-01f, 2.85818011e-01f, 1.13590501e-01f, -7.32825175e-02f, -1.28675058e-01f,
  1.30509824e-01f, 4.22546715e-02f, 1.72430739e-01f, 5.97260557e-02f, 2.16050535e-01f, -1.93248734e-01f, 2.43405148e-01f, 9.76248980e-02f, -5.67394756e-02f, 4.80579585e-02f,
  1.65444747e-01f, 1.58053175e-01f, 2.67535746e-01f, 7.13326633e-02f, -7.54422648e-03f, 1.09611757e-01f, -9.43441242e-02f, -2.13615790e-01f, -6.20780811e-02f, 6.46309182e-02f,
  1.43094838e-01f, 1.02983460e-01f, 4.07127067e-02f, 1.06129222e-01f, -5.69589324e-02f, -1.75868180e-02f, -5.74431056e-03f, -6.86575240e-03f, -2.46810708e-02f, -6.27697557e-02f,
  1.45941123e-01f, 6.75546899e-02f, -1.69089958e-01f, -2.83205807e-02f, -6.10613897e-02f, 1.59294123e-03f, 2.66361274e-02f, 2.23746672e-02f, -4.17486392e-02f, -1.09886907e-01f,
  -4.42727692e-02f, 7.42212385e-02f, 1.31783724e-01f, -2.58106701e-02f, 2.82635063e-01f, 1.26250803e-01f, 1.79795250e-01f, -6.13118224e-02f, 2.24575832e-01f, -8.40422045e-03f,
  -1.09566748e-01f, 9.84012187e-02f, -7.06446171e-02f, -9.87759531e-02f, 1.82867199e-01f, 1.83249325e-01f, 1.62984848e-01f, 2.01848254e-01f, 1.18756488e-01f, 1.80846527e-02f,
  1.01872347e-01f, 1.41992029e-02f, 9.43446234e-02f, -4.95090261e-02f, -1.45877942e-01f, 2.28835702e-01f, -1.12625338e-01f, -3.92450429e-02f, -1.93609595e-01f, -7.06563517e-02f,
  -2.28258729e-01f, -8.33874494e-02f, 1.87744290e-01f, 6.41241670e-03f, -2.11555213e-01f, 2.13352829e-01f, 3.24224010e-02f, -6.25979006e-02f, -1.65881664e-01f, 1.48792580e-01f,
  8.68228078e-02f, 4.28330339e-02f, 9.61594209e-02f, 1.06190316e-01f, -4.06568870e-03f, 2.52349883e-01f, 3.18491191e-01f, 5.18282242e-02f, 1.97041973e-01f, 5.07441238e-02f,
  1.34221286e-01f, 6.35858923e-02f, 1.83991507e-01f, 5.31330928e-02f, 9.62527841e-02f, -3.57445292e-02f, 5.91083840e-02f, -7.60682076e-02f, 1.34779364e-01f, -2.05863699e-01f,
  1.71675056e-01f, 1.62600338e-01f, -1.42305428e-02f, -1.01869605e-01f, 2.20936630e-03f, 5.44680431e-02f, -4.20123301e-02f, -1.50092080e-01f, 1.73222438e-01f, -1.49184704e-01f,
  1.96961075e-01f, 9.81940553e-02f, -6.00734353e-02f, -5.10162860e-02f, 1.38658255e-01f, -6.67687878e-02f, -7.46016726e-02f, -8.95066336e-02f, 2.11137280e-01f, -1.14880903e-02f,
  -3.35457288e-02f, 1.81736480e-02f, -8.11320469e-02f, -9.80026051e-02f, -3.11946077e-03f, 2.18828663e-01f, -6.83455542e-02f, 1.18856229e-01f, 7.47011974e-02f, 1.69149190e-01f,
  1.40704140e-01f, 6.05450422e-02f, -2.24445105e-01f, 4.73179370e-02f, -2.05513105e-01f, 3.63813080e-02f, 1.48801699e-01f, -5.44077065e-03f, -6.44524992e-02f, 5.25958277e-02f,
  -4.25201207e-02f, -9.34341624e-02f, 2.04755992e-01f, 2.56831385e-02f, -8.31251964e-02f, -1.71547774e-02f, 1.26607288e-02f, 7.60558993e-02f, -3.19312215e-02f, 3.18528600e-02f,
  1.16235219e-01f, -1.55652806e-01f, 1.55266831e-02f, -1.95763353e-02f, 1.08205214e-01f, -8.37965012e-02f, -1.37360603e-01f, -2.58585089e-03f, -8.78480971e-02f, -1.05121613e-01f,
  -5.50564677e-02f, 3.94231305e-02f, 3.08402367e-02f, -3.15843187e-02f, 1.44065022e-01f, 3.61378714e-02f, -5.64440945e-03f, -4.42703962e-02f, -1.41388968e-01f, -1.60465166e-01f,
  7.66035989e-02f, -2.63970960e-02f, -6.09107278e-02f, 6.46303073e-02f, -7.10815340e-02f, 1.29175991e-01f, -7.06909522e-02f, -5.18940249e-03f, 1.65681560e-02f, 2.01382369e-01f,
  -4.54385914e-02f, 2.11711556e-01f, 2.52957195e-01f, 9.28207636e-02f, 1.55160949e-02f, -1.73271090e-01f, 1.67470872e-01f, 1.34225219e-01f, 1.55055821e-01f, 2.67880827e-01f,
  -1.04486406e-01f, -5.93813397e-02f, 2.31378973e-01f, 1.32467270e-01f, 8.53057206e-02f, 7.57122859e-02f, 3.11672892e-02f, 1.08984970e-02f, 4.07714583e-03f, 1.10434651e-01f,
  1.93191513e-01f, -1.33441627e-01f, 1.55924112e-01f, 4.80915345e-02f, -3.27422284e-02f, 1.40646979e-01f, 2.34300196e-01f, -2.07966685e-01f, 5.33183813e-02f, 9.51118395e-02f,
  -8.78669322e-02f, -9.10654515e-02f, 8.79385322e-02f, 3.66480052e-02f, -4.91517149e-02f, 2.67285574e-02f, -8.89869481e-02f, -3.21708769e-02f, -3.66669893e-02f, 1.99051090e-02f,
  -5.01768328e-02f, 4.05796431e-02f, -3.35315168e-02f, -1.42776221e-01f, -5.44582158e-02f, 7.55715147e-02f, 1.31426826e-02f, 6.74349768e-03f, 2.08757594e-02f, -1.02043403e-02f,
  -3.89498007e-03f, -3.53503483e-03f, -3.30880955e-02f, 2.12354541e-01f, 6.94740489e-02f, 2.53323317e-01f, -1.30603844e-02f, 2.80527100e-02f, 1.26165329e-02f, -1.98728442e-01f,
  8.05857331e-02f, -8.49712864e-02f, 2.02105250e-02f, -1.44106194e-01f, 1.46303149e-02f, 2.48900894e-02f, -1.56867087e-01f, 1.57458663e-01f, 8.70534405e-02f, 1.37225077e-01f,
  -1.69784613e-02f, -5.97170880e-03f, -4.79533970e-02f, -6.36343211e-02f, 1.68524548e-01f, 1.41409785e-01f, -1.33996889e-01f, 1.03708610e-01f, 2.61425704e-01f, 1.60605460e-01f,
  2.77890235e-01f, -1.60127005e-03f, 2.54397184e-01f, 1.00470753e-02f, -1.71458840e-01f, 9.58618801e-03f, 9.86484364e-02f, 9.81756374e-02f, 9.50382650e-02f, -1.11235343e-01f,
  -3.45775560e-02f, 2.10155696e-01f, 5.13439402e-02f, -8.70550573e-02f, 8.75680894e-02f, -8.30732435e-02f, -1.07715510e-01f, -3.69861796e-02f, -1.96136497e-02f, -2.23823525e-02f,
  1.24294110e-01f, -8.82817134e-02f, 6.50303112e-03f, -2.61052754e-02f, 1.09950148e-01f, 8.50120261e-02f, 2.57540052e-03f, 1.07297316e-01f, 1.61392778e-01f, -3.78889851e-02f,
  5.87498285e-02f, 2.23190691e-02f, -1.42246053e-01f, -9.17595997e-02f, -5.80132939e-02f, 1.54536232e-01f, 1.47650585e-01f, 6.91005588e-02f, -1.15309574e-03f, 8.78877044e-02f,
  9.83093008e-02f, 7.13273361e-02f, -1.84514765e-02f, -6.70779347e-02f, -4.03328016e-02f, -3.11221108e-02f, -9.10964012e-02f, 6.68868572e-02f, 2.50738472e-01f, -5.60822636e-02f,
  -1.70342118e-01f, -2.11747009e-02f, -4.98139821e-02f, 9.19515043e-02f, 3.43006290e-02f, 3.97590362e-02f, -3.67939509e-02f, -6.35863841e-02f, -7.25236833e-02f, -8.05589557e-02f,
  7.81525224e-02f, -1.89644456e-01f, 6.91893771e-02f, 1.27929300e-01f, 1.35952055e-01f, 4.28466685e-02f, 8.52569193e-02f, -1.97871909e-01f, -6.91938996e-02f, 2.45851114e-01f,
  3.85322198e-02f, 7.14812726e-02f, 1.50852323e-01f, 9.28196833e-02f, -9.80070680e-02f, 1.37083694e-01f, 6.17194511e-02f, -2.02267077e-02f, -1.57286316e-01f, 2.83544380e-02f,
  7.30018914e-02f, -3.45287728e-03f, 1.48705663e-02f, 1.71216086e-01f, 2.68817276e-01f, 2.56106481e-02f, 1.41973317e-01f, 9.52852890e-02f, 3.30992043e-01f, 4.47641127e-02f,
  2.52940468e-02f, -2.70525068e-01f, 1.79259256e-01f, 1.30300716e-01f, 9.27815959e-02f, -5.17213382e-02f, 7.28734806e-02f, 1.60201445e-01f, -4.55442443e-03f, -2.36093909e-01f,
  1.71060011e-01f, 6.22129366e-02f, 1.11982539e-01f, -9.73153040e-02f, 2.20812932e-02f, -1.07546411e-01f, -6.07791245e-02f, 1.94568455e-01f, -2.59371877e-01f, 4.93786484e-02f,
  7.69646689e-02f, 1.25941247e-01f, 1.39692038e-01f, -1.09500680e-02f, 1.30530167e-02f, -7.02990685e-03f, 1.40058920e-01f, -9.41383466e-02f, 2.49976963e-02f, -1.26826959e-02f,
  -9.98127684e-02f, 2.58779913e-01f, -4.14938331e-02f, 1.39594167e-01f, 1.80475429e-01f, 1.50913358e-01f, 2.41344661e-01f, 1.76206276e-01f, 2.80127227e-01f, 2.62790918e-01f,
  1.49223432e-01f, 1.52153838e-02f, 1.17608659e-01f, 5.17293811e-03f, 1.78952903e-01f, -4.56009433e-02f, -1.96390986e-01f, -1.80482492e-01f, 1.43214121e-01f, 4.56519760e-02f,
  -2.82340106e-02f, 6.62458614e-02f, -6.32607862e-02f, 7.76814073e-02f, -7.76087865e-02f, 7.58100953e-03f, -2.64151126e-01f, 6.01162352e-02f, 1.16525747e-01f, 7.08571374e-02f,
  3.29990219e-03f, 1.33948987e-02f, 5.90334684e-02f, -2.38828436e-02f, -1.13976754e-01f, 1.89058140e-01f, 3.83725800e-02f, 1.52725987e-02f, 1.18328132e-01f, 1.09625727e-01f,
  -1.59934923e-01f, -1.00580588e-01f, -5.89575581e-02f, 1.90441728e-01f, 1.91329166e-01f, 7.27334917e-02f, -1.33327991e-02f, 1.35044158e-01f, 7.54326433e-02f, 4.90895764e-04f,
  1.41013525e-02f, -3.14777270e-02f, 1.94518626e-01f, 2.66029742e-02f, 3.62391099e-02f, 2.24587664e-01f, 2.08564833e-01f, -5.91421016e-02f, -1.88363686e-01f, -6.13779351e-02f,
  4.77264002e-02f, 1.22421319e-02f, 1.34912848e-01f, 9.76245180e-02f, 4.97931167e-02f, -2.06926510e-01f, -7.41348714e-02f, -1.02303080e-01f, 1.28688574e-01f, -2.15532973e-01f,
  1.01353802e-01f, -1.71956641e-03f, 1.06354862e-01f, 4.55109328e-02f, 1.07707873e-01f, -1.56637847e-01f, -1.70186400e-01f, 2.47603223e-01f, 1.53863281e-01f, 4.44086045e-02f,
  9.92698967e-02f, 7.23430663e-02f, -1.76085651e-01f, 1.24386102e-01f, 1.00740470e-01f, 4.80651446e-02f, -1.34604350e-01f, -1.66001804e-02f, 1.72537431e-01f, 2.64164228e-02f,
  -3.62846106e-02f, 1.86618507e-01f, 4.80398387e-02f, -5.39986268e-02f, 3.53681552e-03f, 9.56768617e-02f, 5.77335767e-02f, -2.80559883e-02f, 1.39443517e-01f, -3.22477520e-02f,
  -7.27115422e-02f, -1.97202533e-01f, 1.68108623e-02f, -3.64454612e-02f, -3.00276950e-02f, -6.58223405e-02f, 3.70145328e-02f, 1.14454016e-01f, 1.58576667e-01f, 2.02101797e-01f,
  -1.42516866e-01f, -7.43336976e-02f, -2.54393322e-03f, -1.39534444e-01f, -2.00878277e-01f, -6.59744442e-02f, 3.68965752e-02f, 2.15374738e-01f, 7.24690408e-02f, -1.44262269e-01f,
  5.50915115e-02f, 1.26665786e-01f, 3.58512849e-02f, 1.19799182e-01f, 1.00036100e-01f, -1.52394651e-02f, 1.37040228e-01f, 1.36684865e-01f, 2.02938557e-01f, 1.85347125e-02f,
  -5.92464507e-02f, -2.59360056e-02f, -1.13189057e-01f, 6.42595515e-02f, -2.68443245e-02f, 1.90744735e-02f, 1.08283892e-01f, -3.78187299e-02f, 2.08095759e-01f, 2.20104218e-01f,
  6.31688535e-02f, 2.30486616e-01f, 1.01391576e-01f, -5.33000827e-02f, 1.37857705e-01f, 3.72310095e-02f, -4.20589931e-02f, 1.49483651e-01f, 1.21476129e-01f, 8.21077228e-02f,
  1.35670351e-02f, 3.22812915e-01f, 1.18495643e-01f, -8.25988948e-02f, 3.89841907e-02f, 6.93806484e-02f, 2.49259286e-02f, -2.90001314e-02f, 1.85042005e-02f, 7.19324946e-02f,
  9.09125358e-02f, -4.27974015e-02f, 7.52933770e-02f, -2.82284766e-02f, 1.61905646e-01f, -1.14886247e-01f, 3.58569287e-02f, -1.11309864e-01f, -6.20670952e-02f, -3.97702195e-02f,
  -3.58366258e-02f, 8.30717608e-02f, 1.26898468e-01f, 2.78611004e-01f, -5.28447814e-02f, -3.19040194e-02f, 1.85195282e-01f, -1.01421624e-01f, -8.77138004e-02f, -2.22393468e-01f,
  -2.42724586e-02f, -2.30203830e-02f, 5.64034283e-02f, -4.48664464e-02f, 1.36856169e-01f, -1.30564034e-01f, -7.69402757e-02f, 9.20393690e-02f, -7.81338364e-02f, 1.10447235e-01f,
  1.97876208e-02f, -3.01957205e-02f, 8.04510638e-02f, -7.45409802e-02f, 7.19655082e-02f, 8.91256034e-02f, -1.37883797e-01f, -1.08581200e-01f, -3.74169298e-03f, 4.30601053e-02f,
  1.67894691e-01f, 1.47554740e-01f, 1.45388097e-01f, -1.73275068e-01f, 2.92470232e-02f, 2.68615037e-01f, 7.47797489e-02f, -9.25378408e-03f, 2.50383735e-01f, -4.93543781e-02f,
  -1.13906734e-01f, 2.54113674e-01f, -4.83946130e-03f, -1.43070981e-01f, 2.14677766e-01f, 2.04488516e-01f, 1.00513384e-01f, 2.59587634e-02f, -2.48116013e-02f, 1.84366241e-01f,
  2.48948075e-02f, -4.96896449e-03f, 1.20631106e-01f, -2.56083589e-02f, -1.04893923e-01f, -3.14287767e-02f, -1.25653952e-01f, 3.95929068e-02f, -2.55004823e-01f, 2.02873368e-02f,
  6.65056929e-02f, 1.80127919e-01f, -4.09790687e-03f, -1.04765296e-02f, 2.57556457e-02f, 2.84347823e-03f, 1.95869431e-02f, -5.44018336e-02f, -2.28123650e-01f, -1.23229660e-01f,
  2.75203679e-02f, -7.93596953e-02f, -7.62132928e-02f, 2.50823051e-02f, -5.70912175e-02f, -6.18554354e-02f, -3.77382860e-02f, 1.20757379e-01f, 5.12673780e-02f, 1.97945401e-01f,
  2.41340511e-02f, 1.76330611e-01f, 3.39916274e-02f, -1.95560336e-01f, 2.83194870e-01f, 1.92953050e-01f, 2.13606656e-01f, 1.43996537e-01f, -1.46227777e-01f, -1.39882863e-01f,
  1.19469821e-01f, 2.97921356e-02f, -2.16142796e-02f, -1.05249239e-02f, 2.49873683e-01f, -1.23546354e-01f, 3.01857978e-01f, -3.20411623e-02f, -3.48152295e-02f, -1.38703184e-02f,
  3.17071348e-01f, 1.30890710e-02f, 2.97494680e-01f, 7.54124746e-02f, 7.32442066e-02f, 9.98777431e-03f, -3.51831764e-02f, -1.86310664e-01f, -1.21614464e-01f, -5.62086143e-03f,
  2.46802837e-01f, 1.32744998e-01f, 3.33973876e-04f, 2.51586348e-01f, 1.15096562e-01f, -8.42778534e-02f, 3.38521153e-02f, -6.07288210e-03f, 8.59756768e-03f, 1.77607359e-03f,
  -8.79319832e-02f, -1.73013777e-01f, 1.72923684e-01f, 9.54952911e-02f, 1.13220155e-01f, 6.63024411e-02f, 2.39071194e-02f, 6.87543303e-02f, -6.83377981e-02f, 4.65235859e-02f,
  4.92775366e-02f, -1.04237348e-01f, 7.72467181e-02f, 1.45030692e-01f, -1.67018294e-01f, 1.67391703e-01f, -8.18950459e-02f, 2.19954588e-02f, -2.36569226e-01f, -2.19921526e-02f,
  1.53590068e-01f, -1.94508757e-03f, 4.04498577e-02f, 2.05538690e-01f, 7.59654790e-02f, 9.32285679e-04f, -7.36178160e-02f, -1.92290410e-01f, 8.74666646e-02f, 1.42512143e-01f,
  -5.31271771e-02f, 1.02102533e-01f, -1.56186566e-01f, 1.03617817e-01f, 4.21861261e-02f, 2.53260415e-02f, 1.75255284e-01f, 1.80875793e-01f, 1.50930941e-01f, 1.34045258e-01f,
  2.21378490e-01f, 1.64858494e-02f, 1.19311750e-01f, 1.10181965e-01f, 1.33711144e-01f, -1.33896306e-01f, -1.84089225e-02f, 2.50045717e-01f, 1.47300616e-01f, 2.22572442e-02f,
  8.31126571e-02f, 1.11381434e-01f, -9.61372107e-02f, -8.10393542e-02f, -9.47090052e-03f, -1.79993540e-01f, -2.61974722e-01f, -6.46569058e-02f, -5.79208694e-02f, -2.65358426e-02f,
  -3.86650264e-02f, 6.26211092e-02f, -1.24518491e-01f, -8.88093412e-02f, 1.65785253e-01f, -9.01174471e-02f, -1.77514739e-02f, 3.36918011e-02f, -1.27713174e-01f, -4.86500785e-02f,
  -6.17840998e-02f, -2.37779003e-02f, -4.71678935e-02f, -2.15719324e-02f, -2.54302919e-02f, 1.45135075e-01f, 1.90959737e-01f, 6.09390400e-02f, 8.17891881e-02f, 2.23825589e-01f,
  -1.54040605e-01f, -2.02285767e-01f, 9.71566588e-02f, 6.30559325e-02f, -1.20479025e-01f, -1.09465413e-01f, -6.06232584e-02f, -9.83940512e-02f, 1.76601127e-01f, -4.68194596e-02f,
  -6.66246489e-02f, 9.31450948e-02f, -2.88025886e-02f, 1.79451425e-02f, -5.02861291e-02f, -9.25113335e-02f, 2.42176428e-01f, 1.12109184e-02f, -2.84686744e-01f, 2.55351625e-02f,
  -8.84720683e-02f, -1.38853461e-01f, -9.83092487e-02f, 7.86165223e-02f, -9.91167054e-02f, 1.05949163e-01f, 1.98944807e-01f, 2.41492968e-02f, -1.41204804e-01f, 1.61945179e-01f,
  4.92932163e-02f, 7.86351115e-02f, -1.61830097e-01f, 1.80054694e-01f, 1.68009147e-01f, 1.01201341e-01f, 1.62901506e-01f, 1.64875478e-01f, -1.47849411e-01f, 9.21399146e-03f,
  1.15305245e-01f, -7.59716630e-02f, -6.02890514e-02f, -1.62673052e-02f, 1.36574522e-01f, -6.14272431e-02f, -1.17083259e-01f, 8.09602961e-02f, -7.93687031e-02f, -2.84824595e-02f,
  -1.62571445e-01f, 7.60351792e-02f, 4.89943214e-02f, 1.07082911e-02f, 2.52973214e-02f, 4.12022360e-02f, -6.44401982e-02f, -1.92388758e-01f, -1.77906573e-01f, -1.76513121e-01f,
  7.21022720e-03f, 1.59998778e-02f, 3.65670733e-02f, 1.98345542e-01f, -2.85522752e-02f, -2.64883731e-02f, -7.98224211e-02f, -7.31671229e-02f, 2.26050448e-02f, 2.10516751e-01f,
  -5.11400439e-02f, -9.52897070e-04f, 2.32698336e-01f, 2.03836232e-01f, 7.01904893e-02f, -1.01947226e-01f, 2.17488557e-01f, 1.66694120e-01f, 1.75491467e-01f, 1.45304203e-01f,
  -1.24003723e-01f, -1.12006746e-01f, 5.93568720e-02f, 2.16083512e-01f, -5.96887060e-02f, 2.80928407e-02f, 1.16412498e-01f, -1.74977601e-01f, 5.02486117e-02f, 6.15268461e-02f,
  1.67101175e-01f, -1.30628482e-01f, 1.90305099e-01f, 1.56739235e-01f, 2.26412788e-01f, 1.98332876e-01f, 1.71864644e-01f, -4.30861115e-02f, -2.60932930e-02f, -1.90318581e-02f,
  -8.79985839e-02f, -3.17711048e-02f, 8.25414062e-02f, 2.23442674e-01f, 1.24234863e-01f, 1.34933397e-01f, 1.77248865e-01f, 6.84402809e-02f, 4.91652936e-02f, 5.36664166e-02f,
  1.48520008e-01f, 1.13847405e-01f, -8.73906389e-02f, 3.88346791e-01f, 1.17270365e-01f, 1.52732998e-01f, 2.35897854e-01f, 7.79820681e-02f, 8.99512600e-03f, 1.89312305e-02f,
  -1.12439562e-02f, 7.47300591e-03f, 3.61079276e-02f, 6.55525178e-02f, -1.73589233e-02f, -2.07098201e-02f, 2.46013120e-01f, -8.20287317e-02f, 3.12411010e-01f, -8.92020296e-03f,
  2.69452363e-01f, -1.35089636e-01f, 1.29250158e-02f, 3.46619040e-02f, 5.81401587e-02f, -2.21000999e-01f, -1.01750255e-01f, 1.19379856e-01f, 2.20603608e-02f, 1.46768019e-01f,
  1.65493980e-01f, -5.32571264e-02f, 1.94760993e-01f, 1.27142556e-02f, -2.86802091e-02f, 8.89072940e-03f, 1.25923365e-01f, -4.59108092e-02f, 2.05263391e-01f, 1.95968509e-01f,
  -8.86381567e-02f, -8.67864117e-02f, -1.05218418e-01f, -1.52072012e-01f, -1.42267287e-01f, 6.56158030e-02f, 2.83268020e-02f, 2.82317370e-01f, 1.78959280e-01f, -1.84948910e-02f,
  -7.43482634e-02f, 7.76238367e-02f, -3.82605121e-02f, -5.60522191e-02f, -4.84581292e-02f, -7.96959326e-02f, 2.69124955e-01f, 8.18895847e-02f, 1.07881896e-01f, 1.87492236e-01f,
  7.51760462e-03f, 4.61632460e-02f, -4.60771695e-02f, -5.18115759e-02f, -2.02918705e-02f, 2.97035445e-02f, 3.29440134e-03f, 2.64620241e-02f, -2.64148027e-01f, 5.75875491e-03f,
  -1.57017000e-02f, 1.59728333e-01f, 4.30267714e-02f, -4.48948406e-02f, 4.71591875e-02f, 2.13821349e-03f, -5.42854704e-02f, -1.87397406e-01f, -1.70921668e-01f, -1.40145600e-01f,
  2.26678085e-02f, -1.19302489e-01f, 1.38324305e-01f, 1.78650126e-01f, 6.49621636e-02f, 1.28698498e-01f, -1.04131758e-01f, 6.04015365e-02f, -2.12026350e-02f, 5.49561083e-02f,
  4.88969758e-02f, 4.44818698e-02f, 9.73260254e-02f, 8.80927965e-02f, 7.11144060e-02f, 1.05486825e-01f, 2.07482576e-02f, 2.27963068e-02f, -1.07361443e-01f, -1.21344469e-01f,
  1.69556662e-02f, 1.33707941e-01f, -1.82087392e-01f, -9.67616122e-03f, -1.39209315e-01f, -1.93516538e-01f, -1.49689019e-01f, 2.07724690e-01f, 2.06194725e-02f, -4.38305400e-02f,
  -9.10257027e-02f, 1.25353155e-03f, -3.63463126e-02f, -1.78538218e-01f, 8.86448175e-02f, -1.90554827e-01f, 4.76578102e-02f, 1.42292110e-02f, -1.10983714e-01f, 3.97907980e-02f,
  7.78893456e-02f, 1.40719175e-01f, 2.16555461e-01f, -2.66768485e-02f, 2.23529965e-01f, 2.33546555e-01f, 2.81253345e-02f, -4.31569964e-02f, 2.66115099e-01f, 1.53004006e-01f,
  -1.63689375e-01f, 1.29915178e-01f, 6.95200935e-02f, 6.95744646e-04f, 1.96572497e-01f, 5.08380905e-02f, 1.22198217e-01f, -3.76854911e-02f, 2.73879264e-02f, 2.29263216e-01f,
  1.51076213e-01f, -4.42132428e-02f, 5.36513701e-02f, 5.91830648e-02f, -9.92836803e-02f, -4.47168313e-02f, 1.79472551e-01f, 2.07105234e-01f, 1.18889421e-01f, 5.10887504e-02f,
  1.94478884e-01f, 1.62749782e-01f, 2.00175017e-01f, 8.67254138e-02f, -9.76323709e-02f, -5.88290766e-02f, 1.23348445e-01f, -7.88626969e-02f, -8.28885660e-03f, 3.34011875e-02f,
  7.33795762e-02f, 5.71352169e-02f, -1.09464265e-01f, -5.66723458e-02f, 2.50295997e-01f, -1.48907825e-01f, 5.91574460e-02f, 1.78746119e-01f, 5.19444160e-02f, -5.17674759e-02f,
  1.44412413e-01f, 5.10572866e-02f, -1.53743163e-01f, 1.09659314e-01f, 1.07489280e-01f, 2.95597203e-02f, -9.31407511e-02f, -2.94978917e-02f, 3.41359377e-02f, -2.47063190e-02f,
  4.84605245e-02f, 1.44359320e-01f, -3.16828668e-01f, -5.34952581e-02f, 8.68670046e-02f, -1.76634230e-02f, 3.38308811e-02f, -2.43617576e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -4.92007704e-04f, 1.42301973e-02f, -3.17702852e-02f, 6.30962029e-02f, 6.28481284e-02f, 5.33228777e-02f, 7.23626241e-02f, -3.58444452e-02f, 7.62974098e-02f, -4.91329189e-03f,
  1.11587122e-01f, 2.39073485e-02f, -1.23936702e-02f, 8.71869922e-02f, 2.82539092e-02f, -1.46210007e-02f, 1.27782956e-01f, -6.05936302e-03f, -7.31665567e-02f, -4.60274592e-02f,
  1.64207280e-01f, 7.43084326e-02f, 1.05155595e-01f, 5.77044860e-02f, 1.00620545e-01f, -7.69947022e-02f, -5.09002022e-02f, -1.35401310e-02f, -1.18575562e-02f, -5.50911352e-02f,
  1.34310111e-01f, 6.67845756e-02f, 9.45480242e-02f, 7.73892030e-02f, -1.86399240e-02f, 8.71070400e-02f, 2.81713177e-02f, -1.12665286e-02f, 6.11751080e-02f, -5.95835634e-02f,
  -7.60535011e-03f, 7.83887412e-03f, 5.00225425e-02f, 1.14985883e-01f, 6.97085261e-02f, 9.15234983e-02f, 7.99026713e-02f, 2.31040316e-03f, 9.00318027e-02f, 1.45187583e-02f,
  3.15000378e-02f, 6.88578412e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.34492949e-01f, -8.31998140e-02f, -8.55650660e-03f, 2.01664791e-02f, -1.03727005e-01f, -1.00078732e-01f, 5.70882894e-02f, -1.85517564e-01f, 2.09021330e-01f, -3.45617607e-02f,
  -1.34800166e-01f, 8.18533748e-02f, -5.48011139e-02f, -1.30808815e-01f, 1.39596775e-01f, -3.27152461e-01f, 5.83601967e-02f, -3.39107543e-01f, -3.04127067e-01f, 2.55954891e-01f,
  -9.29195136e-02f, 7.40474612e-02f, 1.26469612e-01f, 1.46815926e-02f, 7.79901445e-02f, 8.73014703e-02f, -3.58796924e-01f, -1.51359409e-01f, -8.29019174e-02f, -1.24121897e-01f,
  7.60793388e-02f, 5.13153635e-02f, -2.29525015e-01f, -2.18167976e-01f, 1.13574222e-01f, 3.43495458e-02f, 1.61768481e-01f, 3.19613993e-01f, -1.73949683e-03f, -1.63668290e-01f,
  -2.23536521e-01f, 6.29569739e-02f, -1.26352862e-01f, -2.83875912e-01f, -6.91511407e-02f, 2.03554928e-01f, 1.34632483e-01f, -2.55236447e-01f, -1.23086445e-01f, 2.01838493e-01f,
  2.41566777e-01f, -1.70740291e-01f, -1.06894992e-01f, 2.63913214e-01f, -4.21528429e-01f, -3.32212538e-01f, -2.03193083e-01f, -1.46849528e-01f, 2.58243471e-01f, -2.02157319e-01f,
  7.13225752e-02f, -1.44171044e-01f, -7.07331374e-02f, -7.40882615e-03f, 7.58446530e-02f, 2.03354433e-02f, -6.15625270e-02f, 3.29576656e-02f, -1.81565359e-02f, -3.15006264e-02f,
  -4.93870415e-02f, 1.37237862e-01f, 2.22267449e-01f, 1.91849753e-01f, -4.11138535e-02f, 2.02534515e-02f, -1.58446461e-01f, -3.05093437e-01f, -2.41552200e-03f, -1.38040319e-01f,
  1.65513843e-01f, -2.93318361e-01f, 3.87907289e-02f, 2.16387242e-01f, -8.86490270e-02f, -2.82752633e-01f, -9.76731256e-02f, 1.26978710e-01f, -4.86060008e-02f, 1.84441492e-01f,
  2.32841685e-01f, -3.15895855e-01f, 9.90762860e-02f, -1.06891014e-01f, -2.88002968e-01f, -1.67512119e-01f, -2.27436647e-01f, 1.20753624e-01f, 1.56613931e-01f, -2.29701445e-01f,
  -2.07349405e-01f, -2.12168142e-01f, -1.37309864e-01f, 3.00603628e-01f, -4.42291126e-02f, -2.08564281e-01f, -1.47778645e-01f, -5.47379926e-02f, -2.56116301e-01f, -1.87410206e-01f,
  1.42366022e-01f, 1.96972713e-01f, -2.97136813e-01f, -3.88809890e-02f, 2.14567840e-01f, 6.33549914e-02f, -1.67311519e-01f, 2.38249421e-01f, -1.83232561e-01f, 1.26929268e-01f,
  -1.56979963e-01f, 2.38379449e-01f, 2.22562715e-01f, -1.30372718e-02f, 1.91948175e-01f, -1.65986314e-01f, 4.58049886e-02f, 2.24942137e-02f, -1.62108257e-01f, -2.45431829e-02f,
  6.22491390e-02f, -2.19309721e-02f, -1.74299926e-02f, 7.98686296e-02f, -1.96795061e-01f, 7.41433948e-02f, 1.70095697e-01f, 1.97766051e-01f, -4.64662872e-02f, 4.45812754e-02f,
  -9.89587698e-03f, 8.91005844e-02f, -2.02035084e-01f, -4.21655983e-01f, -8.11220258e-02f, 1.52971998e-01f, 8.48257169e-02f, -1.15188435e-01f, -6.96855783e-02f, -1.49667755e-01f,
  -4.23551679e-01f, -3.65374029e-01f, -3.87989134e-01f, 1.66295022e-01f, 1.88833222e-01f, -9.43410322e-02f, 2.64501184e-01f, 2.78788954e-01f, 1.62241340e-01f, 5.77684753e-02f,
  1.90518778e-02f, 1.23229340e-01f, -2.34664530e-01f, -1.39343413e-02f, -1.67317912e-01f, -1.42602354e-01f, 2.99076468e-01f, 9.65873525e-02f, -9.35781375e-02f, -8.09689686e-02f,
  6.46721870e-02f, 4.99396920e-02f, -2.71068662e-01f, -1.03557564e-01f, -1.39858037e-01f, 1.92842886e-01f, -3.22252154e-01f, -1.73937842e-01f, -9.60094482e-02f, 2.51687199e-01f,
  9.56454054e-02f, -7.93541372e-02f, 1.81765616e-01f, 1.36903763e-01f, 1.08428590e-01f, 8.29792488e-03f, 8.64033028e-02f, -2.94202566e-02f, -1.86759472e-01f, -2.20455259e-01f,
  -9.67047587e-02f, 2.08320647e-01f, -2.19055265e-01f, -7.32779801e-02f, -5.28081506e-02f, -1.06834501e-01f, -1.06788933e-01f, 1.02993008e-02f, 6.52164668e-02f, -1.34682423e-02f,
  -3.96591611e-02f, -1.15151465e-01f, -2.13279992e-01f, 5.03287986e-02f, -3.91046107e-01f, -1.62073463e-01f, 2.60771185e-01f, -5.44844568e-02f, -4.25548851e-01f, 2.85437316e-01f,
  2.16258131e-03f, -1.62167907e-01f, 1.79733828e-01f, 1.82846516e-01f, -1.21093109e-01f, -3.40618670e-01f, -2.78491497e-01f, -3.29429395e-02f, 4.44798283e-02f, 2.10250363e-01f,
  -4.47650813e-03f, 8.79814476e-02f, -1.71623006e-01f, 2.21955609e-02f, 9.59274694e-02f, 1.50585711e-01f, -3.31263959e-01f, 1.30161941e-01f, 1.37549907e-01f, 3.02384794e-01f,
  -6.45613112e-03f, -6.28316426e-04f, 1.50352478e-01f, 1.49982691e-01f, 7.64314905e-02f, -4.27876145e-01f, 2.77015734e-02f, 1.62628032e-02f, 2.96405088e-02f, -3.27419251e-01f,
  6.43441007e-02f, -2.47183498e-02f, -3.85922372e-01f, 2.60400772e-01f, -1.89482450e-01f, -7.43951797e-02f, -7.72428587e-02f, -3.24996710e-01f, 2.87377406e-02f, 6.38087764e-02f,
  -7.43028745e-02f, 1.08169734e-01f, -4.68498856e-01f, -1.97830778e-02f, 2.92483494e-02f, -3.21335196e-01f, 1.30464435e-01f, 6.54283091e-02f, 1.12293899e-01f, -1.35622323e-01f,
  -5.24901152e-02f, 2.10466962e-02f, -1.60832889e-02f, -1.41719505e-01f, -9.84990448e-02f, 1.34998616e-02f, -3.14744294e-01f, 2.67602205e-01f, 6.24810420e-02f, -1.36580065e-01f,
  -1.10820279e-01f, 2.57368773e-01f, -1.82880521e-01f, 1.79850414e-01f, -1.63634554e-01f, -1.63053814e-02f, 7.82099590e-02f, 2.08247378e-01f, 1.39170691e-01f, 7.80503899e-02f,
  -1.83411449e-01f, 9.26977620e-02f, -1.12494752e-01f, 1.62459001e-01f, -1.67402312e-01f, 8.66877753e-03f, -7.52191618e-02f, 7.60618299e-02f, 1.60029963e-01f, -6.18918575e-02f,
  1.03036083e-01f, 2.40956083e-01f, 3.51380706e-02f, -9.51021388e-02f, -1.18005753e-01f, -3.48539688e-02f, 1.39181614e-01f, -7.96593055e-02f, -2.08460703e-01f, 1.60493881e-01f,
  -2.19382737e-02f, 1.66374087e-01f, 2.12534681e-01f, -1.01899996e-01f, -1.11058287e-01f, 6.06306121e-02f, -1.45574331e-01f, 1.91748515e-02f, 1.87855527e-01f, 2.18448579e-01f,
  9.86729488e-02f, -1.86185122e-01f, -3.15081440e-02f, -2.69682318e-01f, 6.12756871e-02f, -3.02869469e-01f, -2.74992973e-01f, 2.25722596e-01f, -1.69312552e-01f, 2.51814604e-01f,
  1.79965690e-01f, 1.19378798e-01f, 7.94468224e-02f, 1.13997169e-01f, -3.91352642e-03f, 2.93024164e-02f, -5.49146682e-02f, 1.06911451e-01f, -3.22691709e-01f, 1.07061692e-01f,
  1.20576613e-01f, -1.69345766e-01f, 3.42670903e-02f, -2.18962021e-02f, 7.11842403e-02f, 3.16433161e-01f, -5.38886711e-03f, 1.72846057e-02f, 7.13180825e-02f, -7.71195814e-02f,
  -3.53017867e-01f, 2.07223207e-01f, 1.90180957e-01f, 2.20611498e-01f, 1.99952334e-01f, 1.98284127e-02f, -2.39496052e-01f, -1.89852700e-01f, -3.75254005e-01f, 7.81997070e-02f,
  -2.59805948e-01f, -1.21067103e-03f, -3.06854546e-01f, -1.58330932e-01f, 1.08248927e-01f, -3.66898090e-01f, -3.77236992e-01f, -9.66441929e-02f, 2.97476556e-02f, -2.50149846e-01f,
  -1.94284871e-01f, 2.31690314e-02f, -2.60425776e-01f, -2.30822489e-01f, 8.50080550e-02f, 5.68599533e-03f, 1.61695704e-01f, 1.71813384e-01f, 1.67478755e-01f, 1.54022604e-01f,
  1.11621983e-01f, -3.51529658e-01f, -1.81711748e-01f, -1.24310762e-01f, -2.60627009e-02f, -1.84595272e-01f, -3.69118422e-01f, 8.13618675e-02f, -2.22185120e-01f, -2.34299079e-01f,
  1.66302666e-01f, 2.17388958e-01f, 2.29507715e-01f, 1.38039574e-01f, -5.45977764e-02f, -3.21397521e-02f, -1.65341914e-01f, -3.83347198e-02f, -2.51227189e-02f, -6.32871762e-02f,
  -4.32581156e-02f, -5.83421476e-02f, -1.52528614e-01f, 1.57428592e-01f, 3.29882018e-02f, 5.03588654e-03f, 1.03795893e-01f, 1.28286228e-01f, -3.66274327e-01f, 1.87223300e-01f,
  -1.19178995e-01f, 2.28817821e-01f, 1.56567186e-01f, -2.85097778e-01f, -4.96207848e-02f, 2.17513949e-01f, -5.29590547e-01f, -1.81460958e-02f, -2.10948195e-02f, -1.86186209e-02f,
  1.39206603e-01f, -1.65582970e-01f, -3.42693388e-01f, -8.78380612e-02f, 2.32072622e-01f, 5.86820580e-02f, -1.72714874e-01f, -2.94771641e-01f, 3.50303985e-02f, 7.71473870e-02f,
  -9.78290886e-02f, 4.34605667e-04f, 2.91189015e-01f, 2.53066234e-02f, -9.68267471e-02f, -2.77732968e-01f, -4.56149541e-02f, -1.56865511e-02f, 1.20610639e-01f, -3.91347706e-01f,
  -2.99835652e-01f, 1.81484208e-01f, 1.58922747e-01f, -3.33926022e-01f, 1.27461040e-02f, 7.21961856e-02f, 1.82223707e-01f, -8.76509678e-03f, 2.14754090e-01f, 7.67323151e-02f,
  1.62919790e-01f, 2.45900691e-01f, -2.24073127e-01f, -1.10505208e-01f, 1.38481513e-01f, 1.74852222e-01f, -3.76520008e-02f, -6.68348372e-02f, 7.31405020e-02f, 3.65259685e-02f,
  1.97092127e-02f, 3.07876002e-02f, 4.21407484e-02f, -4.84150974e-03f, 2.12445602e-01f, -1.31290406e-01f, 1.71753019e-01f, 9.84464586e-02f, 1.07232966e-01f, -1.87035814e-01f,
  -1.38828620e-01f, 1.91981167e-01f, -1.78418070e-01f, 1.60147846e-02f, 1.31348446e-01f, 7.13733137e-02f, 2.18317717e-01f, 1.74003243e-01f, 1.47765353e-01f, 1.28252655e-01f,
  -1.97019562e-01f, -1.66606918e-01f, -9.54666361e-02f, -2.84505725e-01f, -1.90831468e-01f, 7.91327879e-02f, 2.21479833e-01f, 4.09739353e-02f, -1.58467051e-02f, -1.62829086e-01f,
  -2.38795847e-01f, -1.00472301e-01f, 8.06088373e-02f, -2.47927040e-01f, -8.51314217e-02f, -1.66672081e-01f, -3.93421873e-02f, -1.20261624e-01f, 2.67943352e-01f, 1.74046293e-01f,
  7.63668567e-02f, -1.83727637e-01f, 1.42454147e-01f, 4.98132780e-02f, 9.99213234e-02f, -1.66101575e-01f, 2.43801609e-01f, -8.93771946e-02f, 4.57497537e-02f, -1.11636393e-01f,
  6.80758208e-02f, -2.06609920e-01f, 4.99157906e-02f, -1.88410297e-01f, -1.80519953e-01f, -2.20708534e-01f, 6.14957176e-02f, 2.81153470e-01f, 1.54206246e-01f, -1.45523593e-01f,
  -3.62062529e-02f, -1.54945418e-01f, 2.10750382e-03f, -1.38518721e-01f, 1.65931117e-02f, 2.46835593e-02f, -4.86168265e-02f, -1.09032936e-01f, 9.06191915e-02f, 9.25084129e-02f,
  1.43176004e-01f, 2.18518730e-02f, -2.25224737e-02f, -1.26984522e-01f, -2.82011718e-01f, 1.14640132e-01f, 9.17525962e-02f, 5.53453378e-02f, -2.34834462e-01f, -1.13500088e-01f,
  2.34742582e-01f, -2.16604769e-01f, -4.21463922e-02f, -4.75189909e-02f, 3.49835545e-01f, -1.15485571e-01f, 1.23253800e-01f, -3.15632135e-01f, 1.36866152e-01f, -6.05177954e-02f,
  1.55775174e-01f, 2.75067300e-01f, 2.24720165e-01f, -2.46928826e-01f, 1.07910119e-01f, 2.73259878e-01f, 1.96244672e-01f, -1.75075039e-01f, 9.05320700e-03f, -2.15527460e-01f,
  -2.59854309e-02f, 8.64033625e-02f, 4.02562134e-02f, -1.15915313e-01f, 3.14830780e-01f, 6.43088743e-02f, -1.75735220e-01f, -1.60961926e-01f, 7.26470128e-02f, -1.43237516e-01f,
  1.48447379e-01f, -1.12460308e-01f, 1.39139527e-02f, -1.11974224e-01f, -1.79362386e-01f, -2.84473538e-01f, -2.77369637e-02f, 1.11253478e-01f, -2.67955333e-01f, -2.31967241e-01f,
  -2.81304896e-01f, 7.37535283e-02f, -1.69147417e-01f, -1.44252330e-01f, 2.87179083e-01f, 5.71776964e-02f, -7.39413872e-02f, 1.07763015e-01f, 4.64803725e-02f, 1.27226487e-01f,
  -1.21592050e-02f, -2.77260295e-03f, 1.08661219e-01f, 2.55077094e-01f, -1.12396620e-01f, 5.47980145e-02f, -3.34325247e-02f, -2.74069220e-01f, 2.69491494e-01f, 2.18082845e-01f,
  -3.03988546e-01f, 6.43103421e-02f, 2.60195911e-01f, 1.07293658e-01f, -4.05055106e-01f, 2.35059112e-01f, -1.18068457e-01f, 6.59958869e-02f, -1.15244254e-01f, -1.17123678e-01f,
  -3.49914402e-01f, -1.15943998e-01f, -5.97525155e-03f, -2.50567496e-01f, 2.66702529e-02f, -1.66293189e-01f, -1.76295951e-01f, -1.56019047e-01f, 2.11164519e-01f, -3.82430375e-01f,
  -2.42556810e-01f, -3.36213559e-01f, -2.78561443e-01f, -6.10330887e-02f, -1.81056425e-01f, 7.33153597e-02f, -1.77610293e-03f, 1.47272170e-01f, -2.96540916e-01f, -9.48365405e-02f,
  1.27632648e-01f, 6.63219094e-02f, 1.86437011e-01f, 1.16695054e-01f, -2.98359901e-01f, -1.66037962e-01f, 2.94168852e-02f, -4.68886197e-02f, 1.30958050e-01f, -3.12254161e-01f,
  2.16075167e-01f, 9.52982679e-02f, 9.99358818e-02f, 1.62446260e-01f, 7.21332878e-02f, -2.32642740e-01f, -5.80429994e-02f, 1.68466508e-01f, -1.76330104e-01f, 1.07959524e-01f,
  1.24390580e-01f, 8.30237567e-02f, 6.33556917e-02f, -1.00615911e-01f, 1.65822923e-01f, -3.53289172e-02f, 2.57830381e-01f, -2.96102017e-01f, -1.12385012e-01f, -1.14289269e-01f,
  3.03222209e-01f, 2.35402644e-01f, 1.43612370e-01f, -1.96205184e-01f, -1.18773468e-01f, -2.60061383e-01f, 2.82376677e-01f, -2.00756252e-01f, -2.71879971e-01f, -3.28107327e-02f,
  1.66312099e-01f, -5.74529648e-01f, 2.10130028e-02f, -2.64616549e-01f, -2.22881466e-01f, 6.66047484e-02f, -2.77441233e-01f, -6.32227659e-02f, 2.34042630e-01f, -1.71167806e-01f,
  -1.41836643e-01f, 1.65188238e-01f, 2.98492998e-01f, 2.98572332e-02f, -2.58157790e-01f, 1.94479734e-01f, 2.16914400e-01f, 4.19926131e-03f, -1.16809778e-01f, -2.03723758e-01f,
  -9.20318067e-02f, 4.48712753e-03f, 2.64408380e-01f, 2.92274833e-01f, 1.26359567e-01f, -1.93856098e-02f, -3.88558120e-01f, -3.14329475e-01f, 7.19443113e-02f, 1.72620058e-01f,
  -3.83908153e-02f, -1.14764817e-01f, -1.07803874e-01f, 1.83724925e-01f, -1.39933079e-01f, 2.26286814e-01f, 2.83063591e-01f, -1.94565490e-01f, -1.38556436e-01f, 9.84506086e-02f,
  -1.62050337e-01f, -1.96954265e-01f, -1.89832404e-01f, -2.80908465e-01f, -3.98819111e-02f, -4.79406454e-02f, -9.89475623e-02f, -1.33824632e-01f, -3.86781991e-02f, 8.69587250e-03f,
  -3.74448337e-02f, 7.87814613e-03f, 4.87240702e-02f, -3.80551890e-02f, 2.34077066e-01f, -1.65454581e-01f, 2.91597486e-01f, -3.26160006e-02f, 2.83370346e-01f, 2.29502738e-01f,
  9.85848010e-02f, -7.37808272e-02f, 1.70113951e-01f, -2.82999724e-01f, 2.42475346e-01f, -1.42068997e-01f, 7.78275281e-02f, 1.21961236e-01f, 9.11027193e-02f, 1.46508113e-01f,
  -3.82880151e-01f, 9.40222526e-05f, -4.98459220e-01f, -3.18090051e-01f, 1.65792450e-01f, 3.31757545e-01f, -6.03333451e-02f, 1.32042736e-01f, 4.55396846e-02f, 1.18530458e-02f,
  1.38154104e-01f, -2.74207257e-02f, -2.61654884e-01f, -3.44628662e-01f, -2.24190623e-01f, -2.18489066e-01f, -3.37885559e-01f, 1.28880709e-01f, -2.04972818e-01f, -1.77012101e-01f,
  -3.37634444e-01f, 6.36548623e-02f, 2.43858635e-01f, 2.14320406e-01f, -3.76450717e-01f, 1.67053193e-01f, -1.79474745e-02f, -1.81508526e-01f, -2.02358112e-01f, 2.89489124e-02f,
  3.41205299e-02f, -2.19583228e-01f, -1.77486867e-01f, 4.79512848e-02f, -9.54078957e-02f, 2.24732071e-01f, 2.24080682e-02f, -2.82803416e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.08367465e-01f, 8.68059993e-02f, -7.33744726e-02f, -8.39114338e-02f, -1.51358601e-02f, -7.77531341e-02f, -1.35328755e-01f, 7.42306560e-02f, -1.01666376e-01f, 6.97758496e-02f,
  1.72554448e-01f, -5.09300753e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    