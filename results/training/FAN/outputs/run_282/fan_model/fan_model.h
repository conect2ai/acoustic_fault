/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.66710755e-02f, -1.77869976e-01f, -6.31466955e-02f, -8.40766914e-03f, 9.44605619e-02f, 3.26032072e-01f, 7.36679733e-02f, -7.75755495e-02f, 2.39808708e-01f, -2.37840354e-01f,
  3.32423635e-02f, -1.84654504e-01f, 2.33508553e-02f, 1.44697398e-01f, 4.96894419e-01f, 2.56004363e-01f, 3.03138703e-01f, 3.41762193e-02f, 9.37296152e-02f, -1.22647867e-01f,
  1.21901512e-01f, 1.37457848e-01f, 1.54041290e-01f, -1.95207708e-02f, -1.21696226e-01f, -2.21894220e-01f, -1.47128060e-01f, -1.71953335e-01f, -7.54163489e-02f, 3.80082875e-02f,
  1.92576990e-01f, 1.02143269e-02f, -1.98884681e-01f, -2.59513557e-02f, 1.34160370e-02f, -1.24417894e-01f, -2.97981501e-02f, 6.69454457e-03f, 4.03524283e-03f, 2.72518140e-03f,
  -4.00845408e-02f, 4.58316095e-02f, 2.46677659e-02f, -1.53989380e-03f, -8.34305678e-03f, -1.22323195e-02f, -4.01009917e-02f, 5.50184697e-02f, 1.96582526e-02f, -9.42450203e-03f,
  6.02559149e-02f, 2.84962151e-02f, 2.10794178e-03f, -8.68588965e-03f, -3.37415338e-02f, 2.41782684e-02f, 6.33995142e-03f, -6.75922409e-02f, 5.82056046e-02f, -1.41376769e-02f,
  -2.90251952e-02f, 6.19163178e-02f, 1.75920483e-02f, -3.81481514e-04f, -1.69091187e-02f, -4.36461121e-02f, 5.43169379e-02f, -3.41781378e-02f, -3.55698504e-02f, 1.98431108e-02f,
  -5.86711010e-03f, -4.77053039e-02f, 9.96547099e-03f, -3.09793204e-02f, -1.60499029e-02f, -2.11306801e-03f, 2.78303809e-02f, -1.17561035e-02f, 6.35061562e-02f, -1.34284813e-02f,
  -1.71987172e-02f, 1.28400981e-01f, -8.59745499e-03f, 1.28471106e-02f, -8.43302533e-03f, -4.70332168e-02f, 5.30742761e-03f, -4.52071503e-02f, 1.00737708e-02f, -1.54936649e-02f,
  1.44109325e-02f, -1.50978431e-01f, -2.35164948e-02f, 1.18226251e-02f, 2.48450367e-03f, 6.55031055e-02f, 9.84174982e-02f, -9.38390102e-03f, 7.21825985e-03f, 1.51769714e-02f,
  -4.71752957e-02f, -5.74385077e-02f, -1.46824829e-02f, 3.25487256e-02f, 3.36844623e-02f, 1.17982235e-02f, -2.85099428e-02f, -7.29086250e-02f, -8.21658149e-02f, -1.54038211e-02f,
  -8.49069804e-02f, -3.70970508e-03f, -2.87406817e-02f, -1.56643279e-02f, 4.62225974e-02f, -3.55651192e-02f, -1.31183304e-02f, 1.99019294e-02f, -3.15891728e-02f, 6.19143546e-02f,
  -9.83852893e-02f, -1.47855967e-01f, 1.88390210e-01f, -4.11094874e-02f, 1.58464283e-01f, 1.38571877e-02f, -1.47975057e-01f, 1.27764374e-01f, 6.42371029e-02f, -2.02689514e-01f,
  -1.13824837e-01f, -1.27923712e-01f, -1.11475803e-01f, -2.99167931e-01f, 3.25655751e-02f, -1.23250872e-01f, -8.21195245e-02f, -9.05163214e-02f, 1.13746814e-01f, 1.94628630e-02f,
  1.37592871e-02f, -1.05733909e-01f, -1.00933257e-02f, 1.14043333e-01f, 6.93184789e-04f, 6.25852793e-02f, -6.43994883e-02f, 1.35576278e-01f, -7.80886114e-02f, 1.34169711e-02f,
  -3.01309787e-02f, -3.37468199e-02f, 1.07654020e-01f, -1.86085645e-02f, -1.03304520e-01f, -5.60904387e-03f, 6.15263963e-03f, 4.49364558e-02f, 2.29021516e-02f, 9.21783037e-03f,
  -6.89230189e-02f, 2.63444819e-02f, -1.02362214e-02f, 1.20987492e-02f, 3.31207402e-02f, -4.36186185e-03f, 5.30628525e-02f, -3.88057046e-02f, 2.60179341e-02f, 1.71058699e-02f,
  -3.18894163e-02f, 3.18618901e-02f, -1.96045693e-02f, -1.51869236e-02f, 1.31323896e-02f, -4.82843118e-03f, -4.19718586e-02f, 5.62194362e-02f, 1.87108777e-02f, 1.68090630e-02f,
  -3.52989100e-02f, 1.89401433e-02f, -3.11376490e-02f, -1.30719254e-02f, 3.59430201e-02f, 9.35591292e-03f, -4.07674983e-02f, -1.66377593e-02f, 6.04632404e-03f, -5.87071292e-02f,
  -3.21306125e-03f, -1.90083161e-02f, 4.81074490e-02f, 5.19849248e-02f, -3.37832347e-02f, -9.47645828e-02f, -3.11713535e-02f, -2.91825105e-02f, 6.36902917e-03f, -4.11654077e-02f,
  6.73060631e-03f, 4.46312651e-02f, 2.59870365e-02f, -8.65269452e-02f, -1.20911037e-03f, 3.14496160e-02f, -2.89704883e-03f, 4.13171351e-02f, 5.01403138e-02f, -4.74459678e-02f,
  -8.94103125e-02f, 1.01945335e-02f, 6.53736815e-02f, -2.74898447e-02f, -2.15379205e-02f, -4.08565365e-02f, -5.60005233e-02f, -1.30428635e-02f, 4.19874713e-02f, 1.35378279e-02f,
  -5.50025841e-03f, -2.08809990e-02f, 2.39589419e-02f, 2.55091526e-02f, 1.34205185e-02f, 8.33592378e-03f, -6.91170692e-02f, 4.41043824e-02f, 1.62247885e-02f, 1.29403239e-02f,
  -2.26380099e-02f, -4.93342476e-03f, 5.23597598e-02f, -1.82810221e-02f, -5.83223812e-02f, -3.44432071e-02f, -4.88276128e-03f, 4.05481048e-02f, -2.63498146e-02f, 9.96864215e-03f,
  -6.35727271e-02f, -7.58705735e-02f, -1.96483657e-01f, -1.12383090e-01f, -7.15229139e-02f, -5.76119535e-02f, 1.03750691e-01f, 1.23405091e-01f, -1.79093271e-01f, 1.17649585e-01f,
  2.39520207e-01f, -2.85923809e-01f, 2.99163200e-02f, -1.77944582e-02f, -2.68090498e-02f, -6.74509481e-02f, -1.53972402e-01f, -9.60509330e-02f, -1.28720030e-01f, -1.73900072e-02f,
  1.19362390e-02f, 5.04911840e-02f, 5.63762784e-02f, 1.25165120e-01f, -2.62982678e-02f, 1.61942523e-02f, 7.45569691e-02f, 3.91602283e-03f, 5.33088334e-02f, -7.08151460e-02f,
  1.38528794e-01f, -2.07933962e-01f, -3.69409285e-02f, -1.65696010e-01f, 5.81478663e-02f, -2.50182319e-02f, -1.54825076e-02f, 1.01826889e-02f, 2.48895362e-02f, 1.30495042e-01f,
  8.80098268e-02f, -1.85396206e-02f, 4.86708693e-02f, 7.17927527e-04f, -9.52287465e-02f, -1.90751060e-04f, -1.64034422e-02f, -6.11610487e-02f, -2.64039878e-02f, 4.89684232e-02f,
  2.51564328e-02f, 1.24425059e-02f, 7.03689875e-03f, -3.62356417e-02f, -3.30945887e-02f, -4.85585593e-02f, -3.91243361e-02f, -3.38633321e-02f, -9.74798501e-02f, 2.56577209e-02f,
  -1.47921052e-02f, -8.91772658e-03f, -1.87999308e-02f, 7.69887567e-02f, -1.01585931e-03f, 3.19497027e-02f, -6.51860563e-03f, 1.11288950e-01f, -2.34477017e-02f, -1.34758996e-02f,
  1.91913359e-02f, -2.30734888e-02f, -1.23620085e-01f, 3.77136320e-02f, 2.17927936e-02f, -6.10197615e-03f, 3.94810066e-02f, -7.34416011e-04f, 3.39956880e-02f, 2.05492415e-02f,
  1.83309577e-02f, -5.01377322e-02f, 3.27085592e-02f, 1.64398234e-02f, -3.91299091e-02f, 2.71635056e-02f, -2.81187873e-02f, 1.72358043e-02f, 3.80578674e-02f, 2.58271955e-02f,
  9.61160567e-03f, -1.86751544e-01f, 5.60421385e-02f, 8.19234177e-02f, -2.72031371e-02f, 6.02428131e-02f, -7.14271516e-02f, 1.00482389e-01f, -1.22549370e-01f, -9.77208018e-02f,
  3.74604091e-02f, 3.48268077e-02f, -1.38577014e-01f, 3.27494070e-02f, 9.23641920e-02f, 1.13394493e-02f, 2.80035734e-02f, -3.33411582e-02f, -1.08450158e-02f, 2.93644815e-04f,
  -2.92601436e-02f, -1.81651078e-02f, 9.16629136e-02f, -1.57688223e-02f, 4.39245850e-02f, 5.45751490e-02f, -2.92242561e-02f, 2.82379985e-03f, -2.71668211e-02f, -1.77151244e-02f,
  -2.67372012e-01f, 1.39093503e-01f, 7.16725290e-02f, -2.70383388e-01f, -5.79983629e-02f, 5.04560880e-02f, -2.39095658e-01f, 1.44007787e-01f, -1.17234983e-01f, -1.29188551e-02f,
  -2.00498939e-01f, -1.84607446e-01f, -8.50749314e-02f, -2.89312422e-01f, -3.73570532e-01f, -8.25254098e-02f, -3.23319286e-01f, -2.31890753e-01f, -2.81590456e-03f, -5.03919944e-02f,
  2.95142122e-02f, -2.63208598e-01f, -4.80432361e-02f, 1.44805893e-01f, 3.04890014e-02f, 1.93979666e-01f, -6.52086660e-02f, 1.34810179e-01f, 9.40166414e-02f, -2.23278310e-02f,
  -5.62186725e-02f, -1.39937550e-01f, 4.06632312e-02f, 5.23435734e-02f, 1.69740282e-02f, 5.82759865e-02f, 6.01468002e-03f, -3.60862985e-02f, -3.25122885e-02f, 6.95822090e-02f,
  -1.15339728e-02f, 4.47424914e-04f, 6.90089306e-03f, 9.37177613e-03f, 1.50748342e-02f, -1.05235854e-03f, -3.00627369e-02f, 4.52203341e-02f, 2.06073299e-02f, -1.18675493e-02f,
  2.94264052e-02f, -1.42121948e-02f, 1.31928949e-02f, -1.98644772e-02f, -4.41262051e-02f, 7.28082983e-03f, 3.60953398e-02f, 2.58267410e-02f, 8.33034143e-02f, 8.02145619e-03f,
  -2.66976226e-02f, -7.92815909e-02f, 4.22214977e-02f, -2.38486938e-02f, 3.55712734e-02f, -3.69612128e-02f, -4.12915647e-02f, -9.00785252e-02f, -1.54649159e-02f, -3.72879617e-02f,
  -4.58398871e-02f, -3.47906426e-02f, -3.50734890e-02f, -1.62369553e-02f, -2.48805364e-03f, 2.23574564e-02f, -1.95910800e-02f, -2.84133833e-02f, 1.89203699e-03f, -1.25672221e-02f,
  -3.76154110e-02f, -1.78934855e-03f, 2.17548292e-02f, 4.86391969e-02f, -5.54691665e-02f, 6.40990287e-02f, -2.31951270e-02f, 3.33007425e-02f, 6.86241034e-03f, 8.60722642e-03f,
  8.66516978e-02f, -4.90908287e-02f, -1.05059324e-02f, -9.49913915e-03f, -8.15601870e-02f, 4.55312766e-02f, -6.99029341e-02f, 1.21334992e-01f, 5.17222248e-02f, -3.93240377e-02f,
  6.94386959e-02f, -6.82632774e-02f, 5.89615479e-03f, 3.05508971e-02f, 3.30451578e-02f, -9.21055023e-03f, -4.38335948e-02f, -2.55676173e-02f, -6.31154552e-02f, 2.36266246e-03f,
  3.39762308e-02f, -1.90634523e-02f, -7.37013146e-02f, 7.82752410e-02f, 5.57156987e-02f, 4.44747955e-02f, -2.39560120e-02f, 2.79833898e-02f, -4.22742143e-02f, -3.90767418e-02f,
  -1.29315540e-01f, -7.59219155e-02f, -4.94431555e-01f, -1.31864652e-01f, 2.44076580e-01f, 8.82652774e-02f, -1.74498081e-01f, 1.54843673e-01f, -3.17311734e-01f, 2.50644267e-01f,
  1.97989240e-01f, -1.52777791e-01f, -1.43727079e-01f, 9.16833580e-02f, 2.98938733e-02f, -2.89448738e-01f, 1.54637739e-01f, 2.08163578e-02f, -2.10916862e-01f, 6.14653826e-02f,
  -9.80566740e-02f, 2.09383696e-01f, -5.64906225e-02f, 1.58553362e-01f, 5.28999865e-02f, 1.44940913e-02f, 3.03267032e-01f, -1.10480472e-01f, 3.36446911e-01f, -1.69365145e-02f,
  9.68764946e-02f, -1.32929951e-01f, -1.52690550e-02f, -8.00874233e-02f, 1.11051135e-01f, 9.35190916e-02f, 3.04993242e-02f, -7.47983381e-02f, -3.17269824e-02f, 1.08503560e-02f,
  -6.81816367e-03f, 9.83865559e-03f, -6.54632086e-03f, -5.19019999e-02f, -3.10371742e-02f, 2.44999975e-02f, -3.09517458e-02f, -4.48982269e-02f, -4.35323678e-02f, -2.49240343e-02f,
  -5.30672958e-03f, -5.80906216e-03f, 2.16013063e-02f, -6.49100682e-03f, -5.29771186e-02f, -1.32432515e-02f, -6.60337433e-02f, 1.82687584e-02f, -3.59221548e-02f, -3.77947045e-03f,
  -1.45437578e-02f, -1.78981759e-02f, 9.17617790e-03f, -1.97746977e-02f, 2.07058084e-03f, 1.85072236e-02f, 1.55312160e-03f, 8.13336223e-02f, -7.47223720e-02f, 5.83468229e-02f,
  2.64644139e-02f, -1.13245947e-02f, -5.25586829e-02f, 3.41081917e-02f, -4.41911770e-03f, -5.77879101e-02f, 2.53089182e-02f, -3.45416330e-02f, 7.26638129e-03f, -1.77438781e-02f,
  -1.79962125e-02f, 2.83628833e-02f, -1.17732435e-02f, 1.43641029e-02f, -4.52627391e-02f, -1.50239551e-02f, 7.57376291e-03f, -4.47759554e-02f, 3.68818664e-03f, 4.43187691e-02f,
  2.98836023e-01f, 2.56647885e-01f, 1.64718367e-03f, 6.11114576e-02f, 2.10999604e-03f, 9.02791247e-02f, -1.00518204e-01f, 2.10151449e-02f, 3.11177224e-02f, -4.98743542e-02f,
  6.80933595e-02f, 8.19563586e-03f, 2.81180348e-02f, 3.89007777e-02f, -1.40559431e-02f, 5.82491159e-02f, 2.11522281e-02f, 4.58459295e-02f, 1.28656894e-01f, 3.20023969e-02f,
  5.39844148e-02f, 4.26189713e-02f, -1.05110146e-02f, 5.91510981e-02f, 5.24770617e-02f, 5.87696843e-02f, 6.93739429e-02f, 5.44350082e-03f, 6.57832250e-02f, -4.45234664e-02f,
  1.82446510e-01f, 5.04297726e-02f, 2.79523563e-02f, 2.04294533e-01f, 3.34596932e-02f, -1.21045969e-01f, -8.59146863e-02f, 3.17399539e-02f, 8.99659693e-02f, -5.22396341e-03f,
  8.87332601e-04f, 2.07652710e-02f, -2.14307711e-01f, 1.82668552e-01f, -1.45554334e-01f, -2.17207596e-01f, 1.09716617e-01f, 7.86607340e-02f, -4.74848747e-02f, 4.71342951e-02f,
  3.01276892e-02f, -1.21078022e-01f, 2.63712415e-03f, 1.64460726e-02f, 7.41844773e-02f, 2.03304201e-01f, 2.65588947e-02f, -2.86534168e-02f, -4.00153222e-03f, -2.81492174e-02f,
  6.81606606e-02f, 6.61335811e-02f, 4.69467491e-02f, 1.96608827e-02f, -2.19963025e-02f, 1.33284340e-02f, 7.92050883e-02f, -4.52807993e-02f, 9.87989921e-03f, 9.71043482e-03f,
  -1.21909581e-01f, -7.89193287e-02f, 7.18558719e-03f, -1.17361918e-01f, 2.89979409e-02f, 7.36955693e-03f, 6.60667792e-02f, 6.59360960e-02f, 1.37629405e-01f, -3.36166434e-02f,
  1.19218051e-01f, 4.07196693e-02f, 2.38135178e-02f, 5.37493173e-03f, 2.27891039e-02f, 7.55720139e-02f, 1.02825888e-01f, 2.09461860e-02f, 5.66834472e-02f, 9.93108377e-03f,
  3.45155671e-02f, 1.09412502e-02f, 4.85862941e-02f, -4.84445691e-02f, 1.48584507e-02f, 2.74965670e-02f, -5.35827549e-03f, 1.54049816e-02f, 1.09749489e-01f, -6.70640767e-02f,
  -9.54275578e-03f, 3.48054022e-02f, 1.52314957e-02f, 6.83234781e-02f, -1.90432929e-02f, -1.45829115e-02f, -2.47958601e-02f, -4.71936017e-02f, 2.65411939e-02f, -1.44126881e-02f,
  -5.88708296e-02f, 1.40236150e-02f, -7.09579736e-02f, 3.42391655e-02f, -1.05157129e-01f, 1.25485975e-02f, 4.95483577e-02f, -2.49087382e-02f, -1.99354882e-03f, 6.24779426e-03f,
  2.33124383e-03f, -9.48371217e-02f, -4.19502147e-02f, -4.67783585e-02f, -1.43783994e-03f, -7.98314512e-02f, -2.59704012e-02f, 4.45612073e-02f, -6.16871053e-03f, -4.64599617e-02f,
  -2.53113569e-03f, 1.33737987e-02f, -3.56993191e-02f, 1.07374210e-02f, 1.59696061e-02f, -2.42924746e-02f, 5.19414693e-02f, -2.82501150e-02f, 1.02236852e-01f, 5.17073902e-04f,
  1.89554170e-02f, -9.53181610e-02f, -7.50073651e-03f, -1.13033131e-03f, 3.69577184e-02f, -1.30039332e-02f, -7.01871142e-02f, 1.31214052e-01f, -8.31162632e-02f, 1.88667718e-02f,
  -1.85363114e-01f, 5.13298154e-01f, 2.02267438e-01f, -1.30262107e-01f, -2.60469228e-01f, -1.63905993e-01f, -1.19027801e-01f, 6.79501742e-02f, 4.60890681e-02f, 5.11383601e-02f,
  -1.19081140e-01f, 8.77462253e-02f, 1.38718620e-01f, 1.27960965e-01f, -6.54793680e-02f, 1.69506371e-01f, -1.08984217e-01f, -1.25718694e-02f, 6.12116978e-02f, 3.21830399e-02f,
  7.15471208e-02f, 2.45242417e-02f, 2.10915767e-02f, 7.18222111e-02f, 4.54682559e-02f, 6.82233423e-02f, -8.95371661e-02f, -2.71134805e-02f, -4.34839539e-02f, -9.62034464e-02f,
  -9.08205658e-02f, 7.15028942e-02f, 1.53649366e-02f, 8.58582333e-02f, -6.18615560e-02f, -7.48796761e-02f, -4.29081172e-02f, -1.78319383e-02f, 2.72975415e-02f, -2.81020589e-02f,
  -5.69208674e-02f, 1.84977204e-02f, 6.45077378e-02f, -1.62527096e-02f, 7.43420348e-02f, 2.26749666e-02f, -6.52461872e-03f, 2.67091468e-02f, 1.63168181e-02f, 4.60128300e-02f,
  2.42569968e-02f, -1.57840047e-02f, -5.55026904e-02f, -2.09269989e-02f, -3.35675590e-02f, 1.71085410e-02f, -1.31142009e-02f, 1.13379620e-02f, -3.91168408e-02f, -1.41091021e-02f,
  -4.36199345e-02f, 2.82755662e-02f, -2.07198914e-02f, 2.65963320e-02f, 5.42387292e-02f, -1.01758838e-01f, 2.87668742e-02f, -6.78201318e-02f, -3.98737080e-02f, -1.71502177e-02f,
  -2.95965169e-02f, 1.02747409e-02f, -4.90336940e-02f, -2.84770969e-02f, -1.08659994e-02f, -4.24431264e-02f, -5.23010753e-02f, -2.12644208e-02f, 4.06617625e-03f, 1.51857510e-02f,
  -6.73468634e-02f, 4.63007540e-02f, -8.05672333e-02f, -1.63144302e-02f, 4.48159650e-02f, -1.15872724e-02f, -4.67525646e-02f, 1.11102313e-02f, -4.53708284e-02f, -3.02143972e-02f,
  1.82058051e-01f, 2.04717502e-01f, 2.03178870e-03f, -9.94481072e-02f, 2.28291638e-02f, -8.08519572e-02f, 3.69153023e-02f, 3.53524275e-02f, 1.35241114e-02f, 2.71602850e-02f,
  -8.20595473e-02f, -2.56430935e-02f, -9.14321560e-03f, -2.83868965e-02f, -5.82468249e-02f, -2.94217281e-02f, 2.61336640e-02f, -1.09074295e-01f, -1.02882199e-01f, 6.50857855e-03f,
  6.78966418e-02f, -7.05717877e-02f, -3.52080837e-02f, -3.20698246e-02f, 2.04313155e-02f, -3.43266465e-02f, 2.69943252e-02f, -6.17275666e-03f, -1.01531716e-02f, 2.64687240e-02f,
  -4.91992533e-02f, 7.47925416e-02f, -1.72700286e-01f, 9.01869237e-02f, -3.08071673e-02f, -2.64140546e-01f, -2.53596693e-01f, 9.96853039e-03f, -6.45785108e-02f, 2.08507106e-02f,
  -5.32964095e-02f, 1.84424222e-01f, -9.19655710e-02f, -2.09749177e-01f, -2.73941308e-01f, -4.05517928e-02f, -1.37561455e-01f, 7.28004947e-02f, 4.94361669e-02f, -3.58723328e-02f,
  -9.40032825e-02f, -1.67794451e-01f, -2.10938975e-01f, 7.04242662e-02f, -1.06287383e-01f, 1.25009164e-01f, -2.45209783e-03f, 1.29863039e-01f, -2.73066759e-02f, -3.43390033e-02f,
  -1.24309786e-01f, 1.28761545e-01f, -1.32968614e-03f, -1.15013368e-01f, -1.22472093e-01f, 2.20580511e-02f, -2.08010189e-02f, -1.19428784e-01f, 2.85209976e-02f, -3.89729179e-02f,
  4.25179256e-03f, -4.09618504e-02f, -7.68307224e-02f, -1.10182688e-02f, -7.63604641e-02f, -3.18539068e-02f, -4.12458740e-02f, -3.53344232e-02f, -5.25636561e-02f, -1.75836794e-02f,
  -4.34450544e-02f, -9.19665396e-02f, -7.15036271e-03f, 8.55651721e-02f, -7.74912462e-02f, -3.42850760e-02f, 2.37208083e-02f, 9.61533375e-03f, -1.73050687e-02f, 6.01131432e-02f,
  5.45871407e-02f, -1.40136490e-02f, -3.11228521e-02f, -2.04198752e-02f, -4.60675135e-02f, 2.74082366e-02f, -4.53647301e-02f, -2.02622265e-02f, 2.43034679e-02f, -6.16155118e-02f,
  3.09522133e-02f, 8.85082558e-02f, 4.40159999e-02f, 2.21709087e-02f, 1.89224929e-02f, -4.50123325e-02f, 6.96633980e-02f, 6.37644976e-02f, 4.83977757e-02f, -5.75528527e-03f,
  3.69709432e-02f, -1.49077820e-02f, -4.91027199e-02f, 4.89533804e-02f, 1.86556280e-02f, 5.48719950e-02f, -2.68747434e-02f, 4.14315127e-02f, -9.19650495e-03f, -4.31269556e-02f,
  5.55528253e-02f, 1.73361525e-01f, -6.06930777e-02f, 1.68479122e-02f, 1.03527173e-01f, 8.83698165e-02f, 3.36842649e-02f, 8.25996231e-03f, 7.07140053e-03f, -2.85980720e-02f,
  -2.44252589e-02f, -5.54170758e-02f, -1.80468801e-02f, -1.20636784e-02f, 6.60219416e-02f, -4.30314168e-02f, 9.75223184e-02f, 6.27965033e-02f, 1.28495887e-01f, 3.55928234e-04f,
  -5.48094697e-02f, 9.64035168e-02f, -3.40063847e-03f, -6.18935414e-02f, 3.02656349e-02f, 1.37822211e-01f, 8.06327816e-03f, -2.33236924e-02f, -7.59388879e-03f, -4.77545429e-03f,
  7.27735981e-02f, 8.27363059e-02f, 9.53701138e-02f, 1.08131446e-01f, -4.26598601e-02f, 1.68301553e-01f, 3.41785371e-01f, -1.72069490e-01f, -4.09305654e-03f, 5.34191765e-02f,
  6.10369779e-02f, 1.75659696e-03f, 4.93413098e-02f, 3.95173803e-02f, 2.24608928e-01f, 1.27184033e-01f, 1.19247943e-01f, 3.59623767e-02f, 2.55342461e-02f, -2.07174513e-02f,
  5.25718136e-03f, 6.38400987e-02f, 6.66881949e-02f, -5.99365495e-02f, 1.08175896e-01f, -1.22345891e-02f, 1.10600404e-01f, -6.98263058e-03f, 1.61264896e-01f, 8.68453681e-02f,
  1.24213375e-01f, 5.38351312e-02f, 1.07595004e-01f, 7.43556619e-02f, 1.72345545e-02f, -4.55832519e-02f, 1.59064934e-01f, 1.74967162e-02f, 1.03447335e-02f, -7.40938634e-02f,
  -7.79512245e-03f, -4.71078753e-02f, -1.34814465e-02f, -3.46674137e-02f, -6.02320710e-04f, 1.21871810e-02f, -2.12341920e-02f, -3.40758041e-02f, -4.29220423e-02f, -3.68269905e-02f,
  -1.32905664e-02f, -3.32622826e-02f, 2.22513322e-02f, 8.38815048e-02f, -1.50556872e-02f, 5.31771667e-02f, 7.48795196e-02f, 3.08508165e-02f, 6.56800792e-02f, 4.50097434e-02f,
  -7.63753280e-02f, 3.17950025e-02f, 1.24660125e-02f, -7.34693091e-03f, 4.83554192e-02f, -4.25249450e-02f, 4.80074510e-02f, -4.34447359e-03f, -4.10003215e-02f, 1.48265334e-02f,
  -7.22356653e-03f, 3.10080089e-02f, -2.23858077e-02f, -3.22100669e-02f, -2.97958520e-03f, -6.48696944e-02f, 7.71723837e-02f, -1.79779399e-02f, 4.50729541e-02f, -6.93317801e-02f,
  -2.65303515e-02f, 6.04698397e-02f, 1.06487740e-02f, 1.59641597e-02f, 2.92284470e-02f, 1.62887890e-02f, 4.09772620e-04f, -1.08730551e-02f, -6.34350255e-03f, 5.39530534e-03f,
  3.21226031e-01f, 2.05405235e-01f, -7.02813491e-02f, -2.60787215e-02f, 4.45595272e-02f, 3.61127369e-02f, -5.29160313e-02f, -6.56524524e-02f, 6.10033944e-02f, -5.99494949e-02f,
  -7.57358819e-02f, -7.47542421e-04f, 5.65305799e-02f, 3.49723995e-02f, 1.91339329e-02f, 1.34169003e-02f, 5.61613552e-02f, 9.88692883e-03f, 4.62611131e-02f, -9.26427450e-03f,
  -6.23009875e-02f, 4.27725576e-02f, -5.52262701e-02f, -8.28083605e-02f, -2.84778643e-02f, -6.72656968e-02f, -6.69716299e-02f, 1.25044659e-02f, -6.42083064e-02f, 5.06436788e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.59308529e-02f, -1.89733014e-01f, -3.61696407e-02f, 7.44044874e-03f, -4.62389849e-02f, -4.07829471e-02f, 1.18072316e-01f, -1.80931732e-01f, -8.14904794e-02f, 4.91921119e-02f,
  6.14338890e-02f, 2.69763377e-02f, 4.70833704e-02f, 4.19964753e-02f, 1.50437653e-01f, 1.56900451e-01f, -7.56781623e-02f, 3.11814882e-02f, -5.39409034e-02f, -1.41754732e-01f,
  -4.57648076e-02f, -6.64803088e-02f, 3.67402695e-02f, -1.40111983e-01f, 6.98360801e-02f, -4.98171784e-02f, 1.00989632e-01f, 1.15329273e-01f, -3.84284668e-02f, -2.04360429e-02f,
  -9.84283760e-02f, -1.18739381e-01f, 3.61742787e-02f, 7.26300254e-02f, -5.67169674e-02f, -2.37302836e-02f, 6.80631474e-02f, -1.30054383e-02f, 5.21092229e-02f, -9.42783523e-03f,
  2.38226242e-02f, 5.67507893e-02f, 5.22255301e-02f, -9.99516770e-02f, -9.84745100e-02f, -8.68647024e-02f, -7.73187578e-02f, -8.33155122e-03f, 6.67491779e-02f, 5.48484623e-02f,
  8.10258389e-02f, 7.96429291e-02f, 2.43338328e-02f, -7.59503320e-02f, -7.39865154e-02f, -1.25644915e-02f, 4.96214367e-02f, 6.99023008e-02f, 1.23124858e-02f, -8.13719183e-02f,
  -9.16212890e-03f, 4.33580801e-02f, -2.36958191e-02f, 2.21525342e-03f, -5.23091443e-02f, 2.45032739e-03f, 4.15187795e-03f, -4.23093699e-02f, -9.29711238e-02f, -5.41526265e-02f,
  8.24970528e-02f, 4.63552363e-02f, -8.01699013e-02f, 7.76454434e-02f, -5.54075930e-04f, -4.22007479e-02f, 6.33324757e-02f, -3.36135775e-02f, 2.18141358e-02f, 1.16065241e-01f,
  2.98183318e-02f, 1.64797902e-02f, -7.64645711e-02f, -9.73721445e-02f, -2.52250340e-02f, -2.32977048e-02f, -3.30169201e-02f, 3.35383252e-03f, -4.50438745e-02f, -2.15224158e-02f,
  1.77277648e-03f, -3.70006412e-02f, 2.61475588e-03f, -1.02082379e-02f, -5.82009032e-02f, -5.60581349e-02f, 1.05283912e-02f, -6.69085607e-02f, -8.25493112e-02f, 7.21842200e-02f,
  4.45210421e-03f, -1.03411581e-02f, -8.69386867e-02f, 1.62400752e-02f, -4.70892228e-02f, -8.73867348e-02f, -9.13784467e-03f, 1.03503093e-02f, -1.38338190e-02f, 1.05267307e-02f,
  5.96266147e-03f, 5.41447364e-02f, 9.72210169e-02f, -7.31907710e-02f, -6.36631399e-02f, 4.24395464e-02f, -8.64085183e-02f, 3.78126092e-02f, -1.46491945e-01f, -3.00569758e-02f,
  3.73323634e-02f, -1.41887233e-01f, 2.10150890e-02f, 6.57823756e-02f, -9.23314765e-02f, -5.13101332e-02f, 1.14003725e-01f, -2.55739223e-02f, 6.77964324e-03f, -8.16030055e-02f,
  4.00397107e-02f, -9.62904096e-03f, 5.39977327e-02f, -9.30496305e-02f, 6.74371719e-02f, 4.15863916e-02f, 1.53706335e-02f, 3.24115460e-03f, -1.03036925e-01f, 3.83428521e-02f,
  -9.71872285e-02f, -1.13794796e-01f, -5.99537492e-02f, -9.12721530e-02f, -2.48656459e-02f, -5.79935685e-02f, 3.18396091e-02f, -1.09042237e-02f, -8.94951150e-02f, 5.35819940e-02f,
  -4.17875089e-02f, 3.56881171e-02f, -6.83198497e-02f, 6.17703386e-02f, 5.35034202e-02f, 8.59459490e-02f, -8.40063021e-02f, 1.17800035e-01f, -3.46527584e-02f, 6.13341480e-03f,
  -4.25261557e-02f, -5.71774878e-02f, -9.13935825e-02f, -3.91253196e-02f, 2.05894914e-02f, 3.86023968e-02f, 4.88994904e-02f, 2.83259097e-02f, 8.49028677e-02f, 5.27027473e-02f,
  -7.90961087e-02f, 3.55166616e-03f, 2.49770246e-02f, -5.54195829e-02f, 8.44588652e-02f, -4.59237248e-02f, 1.50444927e-02f, -6.74392730e-02f, -1.16163464e-02f, -5.74239381e-02f,
  3.56506817e-02f, 4.68603484e-02f, 1.01098148e-02f, 6.77410662e-02f, 4.41009514e-02f, 6.21073283e-02f, -8.68475214e-02f, -1.54733462e-02f, 1.04480907e-01f, -9.02679637e-02f,
  4.32613939e-02f, 7.12269172e-03f, -6.56190515e-03f, -5.31915687e-02f, 4.99752350e-02f, 6.37865067e-02f, 6.36279956e-02f, 3.26676480e-02f, -3.97189707e-03f, 1.28333261e-02f,
  -8.23708549e-02f, -5.18269986e-02f, 2.12858934e-02f, 4.27858233e-02f, -7.50265196e-02f, -1.93336066e-02f, -2.81027611e-02f, -6.56781495e-02f, -2.70845685e-02f, -3.77395563e-02f,
  5.08887274e-03f, -3.14884186e-02f, 5.52676665e-03f, 5.47428429e-02f, -5.19400910e-02f, -4.60381620e-02f, 4.61972281e-02f, -9.92582366e-02f, 9.47964340e-02f, 5.69363274e-02f,
  9.96519849e-02f, 3.95158119e-02f, -4.64785770e-02f, -1.26467317e-01f, 4.43454087e-02f, 2.48533599e-02f, 6.37307763e-02f, 9.38058794e-02f, -1.67303905e-02f, 7.74774104e-02f,
  1.07009612e-01f, 1.76352542e-02f, 1.35701466e-02f, -6.36209249e-02f, 7.96210691e-02f, -2.04845108e-02f, 1.06723467e-02f, -9.51644324e-04f, 8.02112892e-02f, 4.09361646e-02f,
  -1.51064163e-02f, -4.62821983e-02f, -3.09156086e-02f, 5.15465364e-02f, -4.75117266e-02f, 1.05609894e-01f, 2.12484654e-02f, -2.45531723e-02f, -8.62307474e-02f, -2.10930426e-02f,
  5.99259026e-02f, 6.10463023e-02f, 6.17718026e-02f, 2.35623377e-03f, 1.15762517e-01f, -6.04235276e-04f, 6.59612939e-02f, 8.12194794e-02f, 4.25031818e-02f, 4.64800112e-02f,
  -6.85486943e-02f, 7.07379729e-02f, -9.78092402e-02f, -6.51315302e-02f, -8.54434744e-02f, -2.22213194e-02f, -1.73227824e-02f, -7.36220479e-02f, -8.25601891e-02f, -1.52379703e-02f,
  3.78309377e-02f, 9.37989503e-02f, 2.45366041e-02f, 6.65258709e-03f, -1.32930186e-02f, 4.06779349e-02f, 5.12565300e-02f, 3.18197496e-02f, 5.51858321e-02f, 4.84527089e-02f,
  3.23020369e-02f, -3.96588759e-04f, 2.56131627e-02f, -5.74523956e-02f, -2.29485817e-02f, -1.63670778e-02f, -1.46789029e-02f, -8.81547034e-02f, 2.35315096e-02f, -4.38154787e-02f,
  -5.36540039e-02f, 5.49735166e-02f, -7.57999569e-02f, -1.72319803e-02f, 1.46036793e-03f, 1.49077540e-02f, -2.16152333e-02f, -3.30093838e-02f, -1.36248050e-02f, 7.73176849e-02f,
  6.18575811e-02f, -6.96905479e-02f, -2.11569816e-02f, -3.78910229e-02f, 4.74921055e-02f, 3.35782804e-02f, 3.27605829e-02f, -5.65507114e-02f, 3.06911301e-02f, -3.45782377e-02f,
  7.44047984e-02f, -6.34043440e-02f, 6.14659637e-02f, 5.70875220e-02f, 6.11543842e-02f, 6.30807423e-04f, 4.23210077e-02f, 2.70806290e-02f, -3.40780281e-02f, 1.00063998e-02f,
  3.16209421e-02f, 5.63257970e-02f, 3.47994044e-02f, -4.91434969e-02f, -5.63128553e-02f, 3.76713648e-02f, -8.99588540e-02f, -7.45562240e-02f, -4.17820364e-02f, 6.50161654e-02f,
  6.66486919e-02f, 2.27822214e-02f, 4.47693840e-02f, 4.64522839e-02f, -8.80546169e-04f, 7.05980510e-02f, 7.32700527e-02f, 2.00339667e-02f, 1.07415821e-02f, 4.33701836e-03f,
  9.37986001e-02f, 2.45564803e-02f, 3.33409421e-02f, -3.29522341e-02f, 4.05016318e-02f, 4.76775952e-02f, 2.64127366e-02f, -4.61913832e-02f, 9.68689471e-02f, -2.73177717e-02f,
  -5.32781035e-02f, 9.89722162e-02f, 7.27496147e-02f, -1.38177269e-03f, 7.13680731e-03f, 4.71211672e-02f, -5.56272008e-02f, 9.68775153e-03f, 8.00328329e-02f, -2.29253210e-02f,
  3.00626695e-01f, 4.13689673e-01f, 3.61432880e-01f, 3.27895194e-01f, -2.71503270e-01f, -2.76540130e-01f, -2.03650981e-01f, 8.21665525e-02f, -7.83368349e-02f, 5.84252775e-02f,
  -1.27111360e-01f, 4.66268301e-01f, -1.01897400e-02f, 2.03123093e-01f, -6.26935884e-02f, -6.19619973e-02f, 1.36854947e-01f, 1.28862992e-01f, 3.71799543e-02f, 1.51461393e-01f,
  7.28799775e-02f, -1.30157188e-01f, 2.36917198e-01f, -1.25368997e-01f, 1.48289025e-01f, 1.68784410e-01f, 3.79945943e-03f, -1.28350839e-01f, 2.38645077e-01f, -5.09887114e-02f,
  -4.66413684e-02f, 7.06839412e-02f, 1.11414663e-01f, -8.24931916e-03f, -2.51750294e-02f, -8.54149237e-02f, 7.79785588e-02f, -4.87869754e-02f, -2.36551333e-02f, -5.98028477e-04f,
  9.00728777e-02f, -5.26534915e-02f, 4.79102843e-02f, -7.07009137e-02f, -2.51595564e-02f, 6.45935237e-02f, 6.42993376e-02f, 1.40691381e-02f, -1.79834459e-02f, 9.98069718e-02f,
  8.46242756e-02f, 1.06113590e-01f, -3.35179195e-02f, -5.09989597e-02f, 8.58204737e-02f, 1.44934077e-02f, -1.19301910e-02f, 5.80246672e-02f, 3.41007672e-02f, 3.35352644e-02f,
  -6.20648265e-02f, -4.71642166e-02f, 4.76768799e-03f, 6.57154992e-02f, -3.86401713e-02f, -1.04437778e-02f, 5.34242531e-03f, -4.47950251e-02f, -1.98647399e-02f, -7.42076635e-02f,
  2.70312047e-03f, -1.99532229e-02f, -8.98059756e-02f, 1.30116772e-02f, -8.22874717e-03f, 3.91639136e-02f, -1.98236275e-02f, -4.59177233e-02f, -1.00368131e-02f, 8.49199072e-02f,
  -7.24643609e-03f, 2.22377125e-02f, 5.37554845e-02f, -2.67169531e-02f, -3.80468145e-02f, -1.07306624e-02f, -4.68157046e-02f, 5.88658219e-03f, 1.91638302e-02f, -3.73335965e-02f,
  -9.33988690e-02f, 6.24524876e-02f, 5.03493519e-03f, -2.97944322e-02f, 5.84090222e-03f, -8.42268672e-03f, -2.45964266e-02f, 6.96539804e-02f, 4.44621965e-02f, -1.96170099e-02f,
  -1.40640875e-02f, -1.58729460e-02f, -3.42361256e-02f, 3.43548879e-02f, -3.04058064e-02f, 5.92885306e-03f, 5.52084809e-03f, -3.36601809e-02f, 5.05691804e-02f, 6.39940575e-02f,
  -2.41337270e-02f, -4.40883152e-02f, -4.37419722e-03f, -2.64901221e-02f, 3.42502408e-02f, -2.01750528e-02f, 4.33792137e-02f, 2.58261655e-02f, -1.84863154e-02f, -6.80301264e-02f,
  6.71413839e-02f, 2.99715195e-02f, 8.51551592e-02f, 1.63911119e-01f, -6.07417300e-02f, -2.35658556e-01f, -1.34915560e-01f, 9.03622806e-02f, -3.68842334e-02f, -5.35116643e-02f,
  9.51630548e-02f, -1.49725094e-01f, 5.63756656e-03f, 8.87541100e-02f, 1.85537383e-01f, 1.22857258e-01f, 7.90299997e-02f, -7.28800148e-02f, 5.60529083e-02f, 1.13908798e-01f,
  9.98738334e-02f, 1.43789992e-01f, 2.28705272e-01f, 1.09576434e-01f, -1.53898522e-02f, -4.84343385e-03f, 2.16356769e-01f, -1.87438354e-02f, 3.68607640e-02f, -1.14878183e-02f,
  -1.57135710e-01f, -2.23195646e-02f, -1.05298059e-02f, -3.32297459e-02f, 2.88779344e-02f, -2.90249549e-02f, -8.45454037e-02f, -2.10904777e-02f, 1.04758993e-01f, 6.32724017e-02f,
  -2.74539050e-02f, 7.80195091e-03f, 1.49151655e-02f, 3.25630195e-02f, -5.79516180e-02f, 3.89601365e-02f, -1.85943097e-02f, -7.99636021e-02f, -1.83273747e-03f, -3.07009239e-02f,
  5.42745627e-02f, -8.18208754e-02f, 5.26455082e-02f, -1.54472783e-03f, 9.51182693e-02f, -2.31202040e-02f, -3.40868644e-02f, 5.20871095e-02f, 3.67006287e-02f, -5.04914336e-02f,
  -5.57033643e-02f, 8.87279809e-02f, 4.32937965e-02f, 2.05159262e-02f, 5.05224727e-02f, -1.99448671e-02f, 9.63603556e-02f, -2.36432012e-02f, -1.99772753e-02f, 1.38297603e-02f,
  3.69966067e-02f, -1.37984604e-01f, 4.61947024e-02f, 2.17825337e-03f, 1.56567954e-02f, -1.10789247e-01f, 4.57444564e-02f, -1.19417999e-03f, -1.52827101e-02f, 5.92916086e-02f,
  -1.99283883e-02f, 1.71821211e-02f, -5.69474064e-02f, -1.02985352e-01f, -1.08613163e-01f, -5.42180799e-02f, 9.96825248e-02f, -1.06797010e-01f, 2.47902498e-02f, 3.54135409e-02f,
  1.75333265e-02f, 1.91047385e-01f, -2.07950342e-02f, 1.15377409e-02f, -5.45192547e-02f, 1.08652245e-02f, -3.42022441e-02f, -9.22569409e-02f, 6.89324439e-02f, -3.19684818e-02f,
  -5.27117178e-02f, 5.46456873e-02f, -3.17561142e-02f, -5.29479142e-03f, 8.17387626e-02f, 6.35555061e-03f, 1.84298004e-03f, -2.68434510e-02f, -3.71636599e-02f, 8.97773653e-02f,
  -1.89058594e-02f, 5.65109700e-02f, 2.33545527e-02f, -4.71393205e-02f, -1.33395754e-02f, -1.59805149e-01f, 3.64889652e-02f, -6.83851540e-02f, 1.40505340e-02f, 9.19863731e-02f,
  -8.98787305e-02f, -1.71381265e-01f, -1.90358952e-01f, -8.22035074e-02f, -2.86934763e-01f, -1.78732723e-01f, -2.64652371e-01f, -9.15745497e-02f, -1.22930892e-01f, -1.81623735e-02f,
  -1.47031277e-01f, 8.89304131e-02f, 1.04696482e-01f, -5.38508072e-02f, 7.88819492e-02f, 1.24663472e-01f, -6.16670251e-02f, 6.41317964e-02f, -4.71445657e-02f, 2.93230843e-02f,
  5.67756705e-02f, -7.66711533e-02f, 7.06744045e-02f, -1.13730259e-01f, -1.46896452e-01f, -1.01506509e-01f, -2.59320177e-02f, -7.53367543e-02f, -1.76807925e-01f, -1.76418871e-01f,
  -1.68232188e-01f, -8.49443078e-02f, 2.68338118e-02f, -7.18591735e-02f, -1.00222275e-01f, 2.51622256e-02f, -6.44106939e-02f, -1.26750600e-02f, 2.90850434e-03f, 8.88944268e-02f,
  -3.49607766e-02f, 3.25638056e-02f, -4.56244536e-02f, 7.71758482e-02f, 2.50971802e-02f, -4.90040071e-02f, -6.30440982e-03f, -5.37781827e-02f, 2.81684007e-02f, -3.72918397e-02f,
  -4.51697186e-02f, -7.38258585e-02f, -8.62200707e-02f, -1.47016160e-02f, 2.55074222e-02f, -6.77506179e-02f, -1.25096798e-01f, 2.02490371e-02f, 4.24534418e-02f, -1.87980663e-02f,
  -4.10196036e-02f, -9.28795617e-03f, -7.23792911e-02f, -7.01827556e-02f, -1.89305618e-02f, -2.06407160e-02f, -5.00430614e-02f, 2.24672966e-02f, 2.08323523e-02f, 5.46374209e-02f,
  -3.97834033e-02f, 2.99659446e-02f, 6.39578700e-02f, 1.59029346e-02f, 4.00364446e-03f, -6.40884340e-02f, -3.14505547e-02f, -4.20326181e-02f, -5.12585603e-02f, -8.13940540e-04f,
  4.60892208e-02f, -2.02943441e-02f, -5.61614409e-02f, 6.80329353e-02f, -3.51551957e-02f, 7.22825304e-02f, -4.17544022e-02f, 8.26344714e-02f, -1.93131641e-02f, 4.48093526e-02f,
  -1.13614313e-01f, -1.07133672e-01f, -2.24331929e-03f, -7.04427883e-02f, -1.46166130e-03f, 8.72544385e-03f, -4.04593162e-02f, 2.87722535e-02f, -5.81663661e-02f, -5.09974919e-02f,
  -6.46328032e-02f, -2.08766274e-02f, -7.43227825e-02f, 1.31047061e-02f, 5.88050857e-02f, -1.93723701e-02f, -7.11357966e-02f, 1.05230382e-03f, -7.97061920e-02f, -1.61708798e-02f,
  2.64490601e-02f, -7.25716799e-02f, 6.96910769e-02f, 6.14714287e-02f, 1.50230927e-02f, 3.69827040e-02f, 2.42156796e-02f, -8.65504704e-03f, -3.81782390e-02f, -2.35292185e-02f,
  -5.00345349e-01f, 2.97606766e-01f, -2.34266110e-02f, 2.50163168e-01f, -2.92249471e-01f, 1.38744190e-01f, 1.47414550e-01f, 1.89348739e-02f, 2.59577662e-01f, 2.27331161e-01f,
  1.90204643e-02f, -4.67124172e-02f, 2.17741858e-02f, 8.85102525e-02f, -9.18675214e-02f, 1.20326862e-01f, 2.13935986e-01f, 1.32712722e-01f, 1.12344287e-01f, -5.71887381e-02f,
  -6.18709475e-02f, 3.22197638e-02f, -1.45646390e-02f, 4.70973831e-03f, -1.38298288e-01f, -6.39011413e-02f, -9.75999385e-02f, -1.31033137e-01f, -1.46674607e-02f, 6.00552298e-02f,
  4.80855256e-02f, -2.51987204e-02f, -1.42742515e-01f, -4.90062796e-02f, -1.42887339e-01f, 2.03997903e-02f, -4.61233361e-03f, 1.42768789e-02f, -2.06368081e-02f, -4.94280970e-03f,
  -2.64502652e-02f, -1.25251785e-01f, 3.32531482e-02f, 2.18971563e-03f, -6.51696026e-02f, -6.58594444e-02f, 1.61710251e-02f, 2.54034046e-02f, -2.56791804e-02f, -3.35479118e-02f,
  -8.93587153e-03f, 3.87290753e-02f, 9.31173388e-04f, 7.22036734e-02f, -6.36088997e-02f, 5.84780723e-02f, 1.01139732e-01f, -4.38016914e-02f, 7.66523008e-04f, 3.38880606e-02f,
  1.56129049e-02f, 4.17622067e-02f, -9.88907088e-03f, -5.01461625e-02f, 6.81481212e-02f, -4.97766258e-03f, -1.87110454e-02f, -3.07475850e-02f, 6.96555898e-02f, -1.16188355e-01f,
  -1.58789139e-02f, 2.27002315e-02f, 5.84969996e-03f, 1.10966310e-01f, -1.74907148e-02f, -2.01760046e-02f, -1.67974103e-02f, -2.70659123e-02f, 6.40095472e-02f, -2.11766940e-02f,
  6.64220601e-02f, 8.66589919e-02f, -8.40505026e-03f, 5.48832789e-02f, -4.12705867e-03f, -3.07913087e-02f, 7.17248023e-02f, -2.65889894e-03f, 1.09959543e-01f, -5.05420007e-02f,
  1.28935695e-01f, 8.09203684e-02f, 4.71102670e-02f, -2.35396661e-02f, 6.38383776e-02f, -4.78155352e-02f, 4.28711995e-02f, -7.44238272e-02f, 7.26759881e-02f, 5.01506310e-03f,
  1.42841600e-02f, -7.42314979e-02f, -2.22721603e-02f, -1.33343264e-02f, 6.92804009e-02f, 9.65519324e-02f, 5.41901961e-02f, 2.29835398e-02f, 8.77242535e-02f, -3.17079062e-03f,
  -1.00766934e-01f, -6.59688190e-02f, -3.56208300e-03f, -7.27605894e-02f, -1.92108694e-02f, 5.63898869e-02f, -7.77562782e-02f, -2.64592357e-02f, 9.90139320e-03f, 1.12328455e-01f,
  1.63000375e-01f, -1.26125971e-02f, -5.60978875e-02f, -1.06311943e-02f, -1.38348833e-01f, -1.63690925e-01f, -1.54277775e-02f, -2.77222972e-03f, -1.21139102e-01f, -1.22279925e-02f,
  -3.67940739e-02f, -8.07675123e-02f, 5.34001254e-02f, 1.15139380e-01f, 2.00794414e-01f, 6.34327754e-02f, 1.52405024e-01f, -3.78111377e-02f, -7.24835098e-02f, 4.94810529e-02f,
  -1.00818612e-02f, 5.08964323e-02f, 1.26128644e-01f, 9.63772237e-02f, 7.32194856e-02f, 4.86066975e-02f, 7.10650086e-02f, 4.76961732e-02f, 1.03858799e-01f, -2.44026445e-02f,
  6.51579797e-02f, 2.15535532e-04f, 1.76783577e-02f, -4.39369269e-02f, 2.33087149e-02f, 7.41551667e-02f, -9.44920406e-02f, 5.72302826e-02f, 4.18244563e-02f, -7.88684096e-03f,
  -1.48111731e-02f, 7.28586093e-02f, 1.33866007e-02f, -1.66737065e-02f, -1.08926855e-01f, -2.34211478e-02f, -9.46078449e-02f, 1.52809871e-02f, -1.62358899e-02f, -6.42581005e-03f,
  -4.61812653e-02f, -6.83843493e-02f, -1.64204333e-02f, -4.48009856e-02f, -6.84685856e-02f, 4.73876148e-02f, 4.69298586e-02f, -1.07302152e-01f, -2.93343677e-03f, -6.79424480e-02f,
  7.91204441e-03f, -4.68483195e-02f, -6.08471930e-02f, 6.88003078e-02f, -1.48922727e-02f, -6.58326596e-03f, 6.27197325e-02f, 5.37284464e-02f, 4.52985913e-02f, 4.16032001e-02f,
  1.99019667e-02f, -2.59599146e-02f, 1.09287903e-01f, -2.32516229e-02f, 6.91203997e-02f, 9.83019844e-02f, -2.56480090e-02f, 1.85587015e-02f, -7.33847544e-02f, -7.02701285e-02f,
  8.55780113e-03f, -4.28271526e-03f, -1.49871623e-02f, -2.76390626e-03f, -4.17614961e-03f, -9.21439976e-02f, -1.06391888e-02f, 3.99795584e-02f, 3.88437845e-02f, 1.04253627e-02f,
  5.30710369e-02f, 1.67165026e-01f, -4.08595577e-02f, -4.12674099e-02f, -4.24183495e-02f, 4.87295128e-02f, 3.66551951e-02f, -5.56777604e-02f, 5.65717630e-02f, 5.48193492e-02f,
  -5.17096072e-02f, -4.53136042e-02f, -1.07006289e-01f, -2.38716900e-02f, -3.21511589e-02f, -4.27558459e-02f, 1.54827489e-02f, 5.60694560e-02f, 6.51643658e-03f, -2.36656629e-02f,
  7.26695592e-03f, -5.50830662e-02f, 1.41264582e-02f, 5.25128879e-02f, -4.32555117e-02f, -6.25116378e-02f, -3.58582288e-02f, -9.82433371e-03f, 4.99559916e-04f, -7.48482347e-02f,
  5.92092015e-02f, 5.40868230e-02f, 1.06455363e-01f, 2.06991091e-01f, 4.23075557e-02f, -1.77188903e-01f, -1.14221916e-01f, -4.79934178e-02f, -9.74517018e-02f, 6.65706098e-02f,
  -7.12863430e-02f, 8.16228390e-02f, -4.88939788e-03f, 1.26006410e-01f, 1.89373214e-02f, -1.02320081e-02f, 7.88144171e-02f, -1.31402919e-02f, -8.55609216e-03f, 3.53943221e-02f,
  -2.82054506e-02f, -6.83004456e-03f, -8.62305611e-03f, 3.53724957e-02f, -3.64454724e-02f, 2.73406673e-02f, 6.05446324e-02f, -9.97487232e-02f, -2.76295152e-02f, -9.05983374e-02f,
  -5.08435816e-02f, -5.87219633e-02f, 1.20458893e-01f, -5.93200810e-02f, -2.59900047e-03f, 8.46060514e-02f, 4.41531874e-02f, -6.70245811e-02f, -4.37308140e-02f, -3.31925899e-02f,
  -8.05483386e-03f, 1.05117530e-01f, -5.14624827e-02f, -4.14417461e-02f, 6.83700368e-02f, 9.58005991e-03f, -3.65293995e-02f, -8.74722097e-03f, 7.99853951e-02f, 1.81620866e-02f,
  -3.60329933e-02f, 4.75260690e-02f, 5.12055941e-02f, 4.37918566e-02f, 8.00978392e-02f, 3.59360427e-02f, -7.11918175e-02f, 4.81180139e-02f, -1.82712693e-02f, -5.51942177e-02f,
  -4.50181030e-02f, -6.49234789e-05f, -3.37501839e-02f, -3.02538704e-02f, 5.08343801e-02f, 5.74861057e-02f, 2.21587531e-02f, 2.75481418e-02f, -3.11157852e-03f, 5.92295602e-02f,
  3.75162661e-02f, 7.50232041e-02f, -7.91637450e-02f, -4.57615964e-02f, 1.08533524e-01f, -2.14750413e-02f, 6.57878234e-04f, -4.24944721e-02f, -2.67501399e-02f, -4.06954922e-02f,
  -5.60929477e-02f, 2.59889383e-02f, -2.07745582e-02f, -7.73506537e-02f, 1.72684100e-02f, 7.32701793e-02f, 3.15297134e-02f, -2.93507129e-02f, -3.51136588e-02f, -9.34746414e-02f,
  7.75964782e-02f, 3.39335091e-02f, 3.26628387e-02f, -7.90318251e-02f, 2.95033194e-02f, 7.52163380e-02f, 3.60800847e-02f, -8.49761721e-03f, -4.35680617e-03f, -1.64917465e-02f,
  1.00475900e-01f, -2.33187769e-02f, -3.29335295e-02f, -1.75632462e-02f, -6.35202006e-02f, -3.97200882e-02f, -1.40400119e-02f, 7.63962045e-02f, 9.30527374e-02f, 2.35802513e-02f,
  -5.79479747e-02f, -2.15899833e-02f, 2.91499551e-02f, 1.08332388e-01f, -6.27131201e-03f, 2.28360333e-02f, 6.95083514e-02f, -6.10088259e-02f, 7.44086206e-02f, 5.67093343e-02f,
  1.19405091e-01f, -6.08421210e-03f, -2.14963257e-01f, 4.84402515e-02f, -2.62394935e-01f, -2.40945339e-01f, -2.82567650e-01f, -7.82096460e-02f, 2.30028361e-01f, 9.54823643e-02f,
  -1.04040332e-01f, 2.46194810e-01f, -3.67280245e-02f, -1.40574366e-01f, 1.55942887e-01f, 6.75232485e-02f, -2.80767113e-01f, -3.12802605e-02f, -2.95949839e-02f, -2.69069433e-01f,
  1.07796574e-02f, -1.58980325e-01f, -1.53820872e-01f, -2.27768943e-01f, -1.87276185e-01f, -1.56857260e-02f, 5.32812625e-02f, -1.43484861e-01f, -9.28655937e-02f, -6.14701733e-02f,
  -1.69851165e-02f, 5.33151440e-02f, 4.82571162e-02f, 8.89243856e-02f, -1.06081711e-02f, -6.34233356e-02f, -6.27952581e-03f, -3.01379487e-02f, 4.74299490e-02f, 6.47678375e-02f,
  1.16107225e-01f, 2.47090682e-02f, 4.20609266e-02f, 4.68189120e-02f, -1.17718289e-02f, 2.38716649e-03f, -3.04702725e-02f, -1.31311044e-01f, -2.70791110e-02f, -1.99962836e-02f,
  -7.38990819e-03f, -1.57036856e-02f, -5.27951680e-02f, 7.45428503e-02f, -1.94024220e-02f, -6.42380789e-02f, -3.76233421e-02f, -4.34827320e-02f, -2.45249141e-02f, 3.75989564e-02f,
  -9.20897536e-03f, 2.87778545e-02f, 4.03024703e-02f, -3.19203958e-02f, -1.59527995e-02f, -4.02677730e-02f, 1.61561131e-01f, 3.52993757e-02f, -2.03371048e-02f, 8.64362903e-03f,
  1.36915110e-02f, -1.28057366e-02f, -4.79825437e-02f, -3.09381243e-02f, -7.17349797e-02f, 8.37679580e-02f, -3.94821614e-02f, -2.77684443e-02f, 1.62505843e-02f, -4.68634255e-02f,
  -6.38765246e-02f, -3.06586791e-02f, 7.31926858e-02f, -1.01242468e-01f, -8.79127719e-03f, -5.03189228e-02f, 6.97147995e-02f, 7.75362849e-02f, -2.72630360e-02f, -1.25465896e-02f,
  2.53857691e-02f, -1.43158138e-02f, 1.08365260e-01f, 2.50606034e-02f, 9.71176475e-02f, -4.72649708e-02f, 2.27642301e-02f, 4.60400283e-02f, -4.24349532e-02f, -2.46784035e-02f,
  -7.69986361e-02f, 6.71996772e-02f, -2.52736602e-02f, 2.11290065e-02f, 4.37612981e-02f, -3.89795937e-02f, 4.60653938e-03f, 4.59094681e-02f, 5.22989631e-02f, -5.62073067e-02f,
  -4.53202873e-02f, 7.81465471e-02f, 8.53675008e-02f, 2.86398698e-02f, -3.88674662e-02f, -3.70136090e-02f, 2.27199905e-02f, 5.23076244e-02f, 5.72527945e-03f, 4.16766554e-02f,
  1.03422932e-01f, 7.37565085e-02f, 7.17881545e-02f, -1.95560083e-02f, -1.14482224e-01f, -5.15483841e-02f, -3.96492518e-02f, 7.08141848e-02f, 4.84875888e-02f, -6.64605349e-02f,
  3.73945571e-02f, -1.29393592e-01f, -1.36148900e-01f, -1.02386363e-02f, -1.26377016e-01f, -1.13158584e-01f, -3.70976888e-02f, -7.99116492e-02f, 2.59601437e-02f, -2.16321349e-02f,
  -6.67993957e-03f, 8.72594714e-02f, 1.03419408e-01f, -3.10319979e-02f, 1.40951559e-01f, -3.10639031e-02f, 1.13160975e-01f, -4.89114411e-02f, 1.88782625e-02f, 5.70774376e-02f,
  -4.79953475e-02f, -3.72150615e-02f, -1.91523768e-02f, 8.09968710e-02f, -8.29371214e-02f, -8.92571080e-03f, 1.40792578e-02f, 7.73764476e-02f, -5.77378906e-02f, -3.00643090e-02f,
  -5.26464693e-02f, -2.09072027e-02f, 9.44648758e-02f, 7.07326010e-02f, 3.57640609e-02f, 1.24448640e-02f, 7.73267597e-02f, -3.78364138e-02f, -3.23465541e-02f, -5.62615022e-02f,
  -2.40077227e-02f, 4.37659547e-02f, 6.23395815e-02f, 5.87668270e-02f, -1.04133189e-01f, -4.79225852e-02f, -6.58571348e-03f, -9.08639729e-02f, -9.38624889e-02f, -1.66085421e-03f,
  -1.69858728e-02f, -3.21270004e-02f, -1.09925196e-01f, -2.51838993e-02f, 3.24373990e-02f, -1.48456410e-01f, -6.90504685e-02f, -7.07584172e-02f, 3.31115425e-02f, 6.91333637e-02f,
  -4.93506342e-02f, 5.57770133e-02f, -4.20944765e-02f, -6.34381846e-02f, -9.26882401e-02f, 4.84004505e-02f, 2.20028311e-02f, -1.43419681e-02f, 7.38819316e-02f, -2.18314100e-02f,
  -1.86002534e-02f, 4.24805991e-02f, 1.39420526e-02f, 9.90602225e-02f, 4.32660319e-02f, -4.51532789e-02f, -2.97662355e-02f, 1.05638996e-01f, -3.83194946e-02f, 4.60341685e-02f,
  7.25984126e-02f, -5.81942759e-02f, 1.24012241e-02f, 4.86763790e-02f, 1.03598870e-02f, -8.63402635e-02f, 3.76958959e-02f, 6.23181229e-03f, 9.94390547e-02f, 2.58142427e-02f,
  -2.90899519e-02f, -1.10696796e-02f, -1.68677773e-02f, -2.59796120e-02f, 7.77946189e-02f, 2.37051658e-02f, -6.10048808e-02f, 4.89529893e-02f, -5.04520573e-02f, -2.96602864e-02f,
  3.97462212e-02f, -1.15790769e-01f, -5.25123477e-02f, 5.16749732e-02f, -7.40830153e-02f, -2.12377068e-02f, 4.68894988e-02f, -5.91984130e-02f, 3.73533331e-02f, -1.98973138e-02f,
  2.36190483e-01f, -1.69034868e-01f, -8.09627119e-03f, 6.80099502e-02f, 1.17302734e-05f, -1.13520592e-01f, -4.92094681e-02f, 8.37015659e-02f, 3.99761237e-02f, -3.96729484e-02f,
  5.87774403e-02f, 8.18284694e-03f, -9.42109451e-02f, 3.42302509e-02f, 1.06329955e-01f, -1.19361795e-01f, 1.12942271e-01f, -2.18870528e-02f, -5.05829640e-02f, 5.61310016e-02f,
  1.54759556e-01f, 1.90683469e-01f, 1.13763742e-01f, 1.99137963e-02f, -8.75575468e-03f, 1.70930438e-02f, 1.85352881e-02f, -9.10612345e-02f, 8.65229741e-02f, -1.17262464e-03f,
  4.93630655e-02f, 1.05981939e-02f, 6.64345222e-03f, 4.80184667e-02f, 4.69042547e-03f, -4.26786095e-02f, 7.36994995e-03f, 5.46480976e-02f, 4.75457050e-02f, 2.21621897e-02f,
  -1.04840957e-01f, -4.07009535e-02f, 5.03721572e-02f, 1.47578465e-02f, 2.91379951e-02f, -7.03884065e-02f, -8.69299918e-02f, 4.07963395e-02f, -1.21350065e-01f, 7.41685461e-03f,
  -2.71971859e-02f, -1.22542880e-01f, -8.36486593e-02f, -7.65797794e-02f, -7.42200837e-02f, -5.99308796e-02f, 2.38789190e-02f, -3.53559013e-03f, 5.81377819e-02f, 1.70024373e-02f,
  9.00572259e-03f, 6.06962759e-03f, -1.27602126e-02f, 4.00226051e-03f, 6.56255931e-02f, -5.42470813e-03f, -5.20364791e-02f, -1.20747410e-01f, -1.17014699e-01f, -2.77278982e-02f,
  6.21542260e-02f, 1.22966714e-01f, -1.47236092e-02f, 5.77658415e-02f, 1.25757203e-01f, -1.09010898e-01f, 8.80917534e-03f, 2.53769569e-02f, 6.21976294e-02f, -5.37714958e-02f,
  -2.80690081e-02f, 1.31856248e-01f, -5.00707440e-02f, -5.82419755e-03f, -6.70531169e-02f, 6.29286468e-02f, -3.18625830e-02f, 1.15217552e-01f, -9.51153114e-02f, -4.33290377e-02f,
  3.00801657e-02f, 1.76066477e-02f, 8.82959813e-02f, -6.29943162e-02f, -3.16311121e-02f, -6.18741252e-02f, -1.00228347e-01f, 3.07831243e-02f, 5.49196228e-02f, 1.05346374e-01f,
  -1.71837788e-02f, 8.61636735e-03f, 4.98172604e-02f, 2.21708715e-02f, 2.20325775e-04f, 1.16475292e-01f, -2.93647610e-02f, -9.39570740e-02f, -1.06486976e-01f, 1.24536091e-02f,
  8.65660831e-02f, 3.52778137e-02f, -3.71088982e-02f, -3.09101641e-02f, 1.75897870e-02f, 2.18455419e-02f, -3.97843421e-02f, -1.83584541e-02f, -5.75252110e-03f, -6.14507273e-02f,
  2.07116053e-01f, -5.97282313e-02f, -1.62472367e-01f, 1.99115634e-01f, -6.34803176e-02f, 7.03666417e-04f, -2.02716231e-01f, 1.88436881e-01f, -1.62804201e-01f, 1.45589337e-02f,
  4.29464951e-02f, -5.52716590e-02f, -1.36588216e-01f, 1.84334069e-01f, 2.18990520e-01f, -4.06074151e-02f, 2.05038592e-01f, 1.42763719e-01f, -6.91533685e-02f, -7.31222630e-02f,
  1.42589033e-01f, 3.14583033e-01f, -2.95033026e-02f, 2.37186015e-01f, 1.11258492e-01f, 8.74447748e-02f, 1.42872036e-01f, -1.82443541e-02f, 2.24340916e-01f, 1.28521785e-01f,
  -2.27123667e-02f, 6.63078274e-04f, -3.94471399e-02f, 1.77777819e-02f, -2.85978913e-02f, -6.88622817e-02f, -3.78323011e-02f, 7.56455353e-03f, 7.33146584e-03f, -9.18476582e-02f,
  4.58174944e-03f, -5.59600256e-03f, 7.16210231e-02f, 5.76288700e-02f, 3.49144414e-02f, 2.08388977e-02f, 2.04314739e-02f, -6.92382306e-02f, 1.85096078e-02f, 4.84235734e-02f,
  -6.49864078e-02f, 5.67010418e-02f, -6.21619374e-02f, 1.18821204e-01f, 6.82657631e-03f, -1.79947559e-02f, -1.78562885e-03f, -8.77369288e-03f, -3.23852263e-02f, 2.36138906e-02f,
  8.60103965e-02f, 4.77093719e-02f, 7.51237497e-02f, -1.82415806e-02f, 5.09423949e-02f, -5.46337254e-02f, 6.32901415e-02f, 3.93388718e-02f, -7.11086318e-02f, -4.64870259e-02f,
  -4.34547141e-02f, -1.21001173e-02f, 3.38609703e-02f, -1.23283667e-02f, -3.68849672e-02f, 8.37523956e-03f, 1.31336665e-02f, -3.51284561e-03f, 2.20800154e-02f, 5.96927702e-02f,
  3.02167125e-02f, -2.75929142e-02f, 8.60324055e-02f, 7.37953857e-02f, 1.15542114e-01f, -3.20710465e-02f, 9.59641710e-02f, -4.32745963e-02f, -4.21093851e-02f, -7.55945640e-03f,
  5.94888926e-02f, 1.34300292e-01f, 1.01662977e-02f, -1.35153877e-02f, -6.49375841e-02f, -5.76682854e-03f, -2.16291025e-02f, 5.48602417e-02f, 5.23142866e-04f, -3.36578749e-02f,
  1.79863665e-02f, 1.94095671e-02f, -3.22470069e-02f, -3.85474451e-02f, 6.00467362e-02f, -5.90144806e-02f, 6.98342472e-02f, 1.35032898e-02f, 4.29085009e-02f, -1.91109106e-02f,
  1.07311942e-02f, -6.43076897e-02f, 8.73306859e-03f, -1.38364330e-01f, 3.00910734e-02f, 2.12237909e-02f, -6.21088594e-03f, 5.55322170e-02f, 7.19471127e-02f, 6.26382753e-02f,
  8.33723247e-02f, -1.81463242e-01f, -3.84676792e-02f, 7.17686340e-02f, 1.98467690e-02f, 1.21321995e-02f, 4.67530936e-02f, -2.10370496e-02f, 1.65184811e-02f, -1.22223064e-01f,
  5.72194979e-02f, -9.52865630e-02f, -4.56225201e-02f, 8.02131891e-02f, -3.35756922e-03f, -6.89741597e-02f, -2.20940020e-02f, 5.86466156e-02f, -5.17265573e-02f, 2.89986786e-02f,
  4.81128655e-02f, -4.33768444e-02f, -6.38630316e-02f, -6.32952228e-02f, 4.60334122e-02f, 6.98284581e-02f, 7.75033534e-02f, -4.39752229e-02f, 7.11217895e-02f, -9.77810100e-02f,
  -4.82826643e-02f, 1.75877921e-02f, 4.22114842e-02f, -9.38079599e-03f, 7.42217153e-02f, 7.17611983e-03f, -3.36422957e-02f, -9.51812416e-03f, -7.22118840e-02f, -3.97655676e-05f,
  -5.35031296e-02f, -4.32339162e-02f, 6.03087917e-02f, 3.10319383e-02f, 5.51182684e-03f, -1.34593779e-02f, 4.84847799e-02f, 1.06377783e-03f, -7.95878991e-02f, -1.66544579e-02f,
  -8.08907673e-02f, -8.79695043e-02f, -2.70974450e-02f, -5.32901920e-02f, 3.60219218e-02f, -2.65914388e-03f, -3.13467905e-02f, 4.39751260e-02f, -3.40968706e-02f, 8.84117708e-02f,
  -4.28683721e-02f, -2.91035902e-02f, -8.96675587e-02f, -2.70913579e-02f, 7.67798629e-03f, 7.43184760e-02f, 1.01980641e-02f, 2.36577471e-03f, 3.60742696e-02f, -8.39422364e-03f,
  4.91478145e-02f, 4.64721881e-02f, -4.93264645e-02f, 5.10101505e-02f, -2.65927408e-02f, -5.97426407e-02f, -5.26776649e-02f, -5.42726554e-02f, -6.97210804e-03f, 4.49143127e-02f,
  -9.60547011e-03f, -6.52486309e-02f, -9.51642096e-02f, 6.83070868e-02f, 5.61101660e-02f, -1.62805207e-02f, -8.69206563e-02f, 6.13816753e-02f, 4.26916741e-02f, -3.01559158e-02f,
  -7.53212571e-02f, 1.85608342e-02f, 8.53642300e-02f, -2.85109486e-02f, 6.86200187e-02f, 7.08535165e-02f, -6.01733588e-02f, -8.82844348e-03f, -4.47465107e-02f, -3.87134030e-02f,
  8.25765058e-02f, -4.65641804e-02f, -3.84803191e-02f, 4.65572774e-02f, 5.26167965e-03f, 8.83361474e-02f, 6.62887748e-03f, 8.37283060e-02f, -4.35116589e-02f, 2.92019229e-02f,
  -3.49578187e-02f, 1.00308517e-02f, 3.10168210e-02f, -7.84576777e-03f, 1.37653956e-02f, 1.12966351e-01f, -7.00812265e-02f, -8.81839991e-02f, -1.94052607e-02f, 1.48792192e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.58996809e-02f, 2.62042438e-03f, 3.45639400e-02f, -1.49001971e-01f, -1.96891144e-01f, 6.51906952e-02f, 5.71561046e-02f, -2.78507862e-02f, -2.98903622e-02f, -6.68577775e-02f,
  1.08704813e-01f, 5.65476418e-02f, -1.01760849e-01f, -1.96535047e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.54572332e-01f, -2.10721254e-01f, 2.10181132e-01f, -1.30106732e-01f, 8.04561153e-02f, 2.69967377e-01f, 1.90964900e-02f, 2.37291157e-01f, 5.57349101e-02f, 4.11194593e-01f,
  -7.77154416e-02f, -1.10248469e-01f, -4.00566787e-01f, -1.80075034e-01f, 8.24565887e-02f, -2.25018203e-01f, -4.22279209e-01f, 9.93097946e-02f, 1.74235344e-01f, -8.22825283e-02f,
  6.46496490e-02f, -4.69430774e-01f, -2.91298509e-01f, -2.88373604e-02f, 8.91003311e-02f, -4.23094146e-02f, -6.85389265e-02f, -2.46043503e-01f, -7.56170601e-04f, 8.43184888e-02f,
  4.64534461e-02f, 6.84478581e-02f, -1.24320045e-01f, -5.36389947e-02f, -1.05244204e-01f, -3.62680942e-01f, -4.63612258e-01f, -1.37108579e-01f, -2.86130816e-01f, -1.30090833e-01f,
  -2.10170195e-01f, -2.35390931e-01f, -1.45126149e-01f, -2.39143401e-01f, -2.11951554e-01f, 4.52700466e-01f, 5.39354831e-02f, -2.91939467e-01f, 1.24325387e-01f, 1.07785448e-01f,
  -1.35620788e-01f, -1.00287981e-01f, 1.21870205e-01f, 1.95543140e-01f, 2.00665042e-01f, -3.21649313e-01f, -4.18132633e-01f, 1.86647609e-01f, 1.70944080e-01f, -1.27974868e-01f,
  5.43683581e-02f, 2.15715155e-01f, 2.96929508e-01f, 3.54546979e-02f, 1.75004616e-01f, -6.88342610e-03f, 1.11695461e-01f, 2.31653843e-02f, -2.25228399e-01f, 3.13964903e-01f,
  -1.18328340e-01f, 1.15594253e-01f, 3.25030714e-01f, 4.94425185e-02f, -1.86527874e-02f, 1.67886242e-01f, -1.87559515e-01f, 2.28821576e-01f, -9.25386846e-02f, -3.10728759e-01f,
  -2.56146878e-01f, 4.42696409e-03f, 2.27056667e-01f, -1.74303781e-02f, -2.12622598e-01f, -9.59681049e-02f, -1.35087883e-02f, -7.95731619e-02f, -2.58807633e-02f, 1.55334875e-01f,
  1.41018182e-01f, -3.32666546e-01f, -6.87744468e-02f, 1.47050515e-01f, 1.25513524e-01f, 1.42213255e-01f, 1.24156900e-01f, -2.95579154e-02f, -1.47652505e-02f, -1.07610062e-01f,
  1.24524526e-01f, -1.23726539e-01f, -4.27894108e-02f, 2.04251334e-02f, -3.06108482e-02f, 1.41906723e-01f, -7.62096047e-02f, 6.07069954e-02f, -1.34046555e-01f, 5.34621030e-02f,
  -9.92372036e-02f, -1.10729830e-02f, 1.63474962e-01f, -5.29416651e-02f, 1.02056563e-01f, 1.21189579e-01f, -1.46924064e-01f, -2.27785110e-01f, -1.23602591e-01f, 9.67041403e-02f,
  -5.21924235e-02f, 6.78182840e-02f, 1.38190597e-01f, 1.73653513e-01f, -1.55377695e-02f, 6.14892393e-02f, -1.26360580e-01f, 1.10935740e-01f, -9.06595513e-02f, 4.65960890e-01f,
  -1.46503195e-01f, -1.12380505e-01f, 1.37794912e-01f, 1.05661742e-01f, 6.49769604e-02f, 1.25106305e-01f, -6.52359352e-02f, 7.18806684e-02f, 2.15736404e-01f, -1.26943707e-01f,
  2.30912402e-01f, -2.52425969e-01f, -5.90157509e-02f, 1.14546962e-01f, 7.75300637e-02f, -4.99666482e-02f, -3.14364471e-02f, 1.05887450e-01f, -4.04827930e-02f, 2.53681242e-01f,
  1.15289874e-02f, -1.66738197e-01f, -2.35540003e-01f, -1.50214396e-02f, -8.24806318e-02f, 1.36976525e-01f, -2.63222102e-02f, -2.96664760e-02f, -2.11812794e-01f, 6.17175326e-02f,
  -2.89669335e-01f, 3.38903725e-01f, 4.03846771e-01f, -1.69914380e-01f, 1.07120210e-02f, -1.90553352e-01f, -4.52127978e-02f, 1.91622421e-01f, 2.77798474e-01f, -1.71351328e-01f,
  4.24449742e-01f, 1.75269544e-02f, 4.71110463e-01f, 8.02367851e-02f, 2.69876778e-01f, -1.00144058e-01f, 1.16124094e-01f, -4.14730817e-01f, -2.82097608e-01f, -1.05517603e-01f,
  -1.49685532e-01f, 4.23476174e-02f, 1.99985251e-01f, -3.70902836e-01f, -2.38146931e-01f, -1.57274321e-01f, 9.73418280e-02f, -2.05610558e-01f, 2.67668545e-01f, 1.19589396e-01f,
  2.55769998e-01f, 1.20345257e-01f, 1.58927917e-01f, 6.47567362e-02f, -9.37429890e-02f, -4.09913510e-02f, -8.16993695e-03f, -1.85895920e-01f, 1.26589134e-01f, -1.12428769e-01f,
  -6.11692928e-02f, -4.33961041e-02f, -1.08707994e-01f, -1.01828828e-01f, -1.17025964e-01f, 1.38462812e-01f, -1.50760472e-01f, 2.17841387e-01f, 2.11033881e-01f, 8.32868218e-02f,
  3.41099352e-02f, -1.83483120e-02f, 1.02918856e-01f, 3.24820906e-01f, 1.47627771e-01f, -1.10079817e-01f, 2.46478040e-02f, 9.30915549e-02f, -8.91556870e-03f, -8.26526210e-02f,
  -6.23757690e-02f, -1.55524820e-01f, 1.09827612e-02f, 5.17538339e-02f, -4.68226038e-02f, -1.69136655e-02f, 6.63546249e-02f, -2.83724982e-02f, 7.48262927e-02f, 1.74238548e-01f,
  -8.64856094e-02f, -1.54885620e-01f, -1.51152477e-01f, -6.75102770e-02f, -2.09061414e-01f, 1.57837063e-01f, -1.91301942e-01f, 3.27786416e-01f, -1.36127889e-01f, 2.59602159e-01f,
  1.72803048e-02f, 2.09124073e-01f, -8.73393789e-02f, -1.66459810e-02f, 9.18606222e-02f, -9.58294347e-02f, 5.62585611e-03f, 1.01776764e-01f, 3.09191018e-01f, 1.77990180e-02f,
  1.55819550e-01f, -4.28034142e-02f, -1.17616892e-01f, 1.34700716e-01f, 2.17592940e-01f, -2.07246408e-01f, -9.40538496e-02f, -4.18268442e-02f, 1.81800455e-01f, -8.90340880e-02f,
  9.31858197e-02f, -8.62913858e-03f, -1.08503953e-01f, 2.04518721e-01f, 1.00568347e-01f, -5.94772995e-02f, -6.09830543e-02f, 5.28996661e-02f, 1.99657410e-01f, 1.92950636e-01f,
  1.36480227e-01f, 1.34583205e-01f, -1.97434217e-01f, -2.43175507e-01f, -2.17261910e-01f, -1.96788445e-01f, 9.16443095e-02f, -1.51432827e-01f, 1.00366265e-01f, -9.45754424e-02f,
  -9.79771242e-02f, -1.20054139e-02f, -1.78306356e-01f, -9.73424241e-02f, -3.19908224e-02f, -6.82065412e-02f, 3.69121544e-02f, 8.74407515e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -7.98464045e-02f, 3.12536955e-02f, -1.23223290e-01f, -5.82610890e-02f, -2.59365533e-02f, -9.84182134e-02f, 1.04020536e-01f, -1.79232880e-01f, 7.64595866e-02f, -9.05324891e-02f,
  1.25573531e-01f, -1.16227679e-01f, -9.22680944e-02f, -5.36918938e-02f, 6.84589371e-02f, 1.59309670e-01f, 5.01849763e-02f, 1.17083773e-01f, -1.04348734e-01f, 7.95567781e-02f,
  6.46760836e-02f, -1.44957796e-01f, 1.38211891e-01f, 4.01220145e-03f, 4.94675338e-02f, -1.41751915e-01f, -1.57050088e-01f, 1.45493075e-01f, -1.59238130e-01f, -1.26290187e-01f,
  -1.87340081e-02f, -8.47422406e-02f, 3.23116817e-02f, -6.49820268e-02f, 6.64091557e-02f, 1.87844962e-01f, 7.92836118e-03f, 1.05719706e-02f, 1.86677068e-01f, -1.50274679e-01f,
  7.36109680e-03f, -2.09900111e-01f, 1.54963389e-01f, 1.49166420e-01f, 4.54151444e-02f, -1.95539832e-01f, 1.17898263e-01f, -3.89079973e-02f, 1.22203745e-01f, -1.40366450e-01f,
  5.06245606e-02f, -1.75062343e-01f, -1.36300653e-01f, 2.01453030e-01f, 1.01975635e-01f, 6.40468895e-02f, -1.26151115e-01f, 1.90604720e-02f, -3.51399519e-02f, 9.64735523e-02f,
  -7.88576342e-03f, -1.21044755e-01f, -1.37011573e-01f, 5.68903126e-02f, -1.03321873e-01f, 2.65853196e-01f, 2.58749932e-01f, 5.10374494e-02f, -1.42072186e-01f, 1.97105799e-02f,
  1.92592531e-01f, 2.41092384e-01f, 2.15127259e-01f, 6.04883907e-03f, -1.89367607e-02f, 7.15033188e-02f, 3.63713801e-02f, 3.05133432e-01f, 1.48751989e-01f, -3.37089419e-01f,
  -7.75290653e-02f, -1.03199445e-01f, 8.41736346e-02f, -7.18100369e-02f, 8.57753903e-02f, 8.34635049e-02f, 2.24681776e-02f, -1.56201676e-01f, -2.42861837e-01f, 6.74684420e-02f,
  1.54399753e-01f, -1.11858800e-01f, 1.39563605e-01f, 1.94395095e-01f, 1.79111317e-01f, 1.19314283e-01f, 3.08344960e-01f, 7.96304271e-02f, 2.42041554e-02f, 4.17575277e-02f,
  -7.82280713e-02f, 2.59450972e-01f, 8.05089697e-02f, 3.37843895e-02f, 8.28164220e-02f, 2.00623527e-01f, -2.01151967e-01f, 2.47021522e-02f, -8.86134654e-02f, 6.79855570e-02f,
  1.55193552e-01f, 3.15339230e-02f, -1.61991656e-01f, 9.19103175e-02f, -1.15576841e-01f, 9.04911384e-02f, 5.98337315e-02f, -1.45727366e-01f, -1.06725842e-01f, 3.96103114e-02f,
  6.84481040e-02f, -4.32016589e-02f, -3.73613313e-02f, -7.54533615e-03f, -1.78700328e-01f, 1.60862342e-01f, 6.81146607e-02f, 2.99460404e-02f, -2.13262171e-01f, 5.90995364e-02f,
  -8.64320993e-02f, -1.40379339e-01f, -6.17179461e-02f, 6.61004037e-02f, 1.53404132e-01f, 8.75400454e-02f, 1.15322359e-01f, -1.41784713e-01f, 4.86688912e-02f, 1.64633542e-01f,
  1.97402611e-01f, -1.02569116e-02f, -5.61773181e-02f, 5.61868362e-02f, 1.97351411e-01f, -1.01539968e-02f, -1.90524518e-01f, -1.02787100e-01f, 6.78816736e-02f, 7.25403801e-02f,
  -1.74457014e-01f, 3.62902209e-02f, 7.22119063e-02f, -8.10261220e-02f, 6.99526444e-02f, -1.51430964e-01f, -1.21266820e-01f, 1.12973653e-01f, -1.79878641e-02f, 1.64995447e-01f,
  9.54863876e-02f, 6.02636561e-02f, 1.55013740e-01f, -1.37284279e-01f, -2.79797390e-02f, 1.60302863e-01f, -1.20471455e-02f, 1.63310066e-01f, 1.39561400e-01f, -2.40445539e-01f,
  -1.03717089e-01f, -3.75331119e-02f, -4.23693191e-03f, -8.23587179e-02f, -1.68797538e-01f, 1.70766726e-01f, -1.15689710e-01f, -2.27681711e-01f, 1.20014682e-01f, -1.35555178e-01f,
  1.20560713e-01f, -1.50357187e-01f, -5.96356951e-02f, -1.66636407e-01f, 1.94518283e-01f, 1.24468468e-01f, 1.19681753e-01f, -7.20538795e-02f, 1.37810364e-01f, 1.00593999e-01f,
  -1.78145066e-01f, -1.10918254e-01f, -7.81549215e-02f, -4.87204716e-02f, -1.50734067e-01f, 1.17258660e-01f, 4.91112061e-02f, 1.01810090e-01f, 2.05001775e-02f, 1.75157815e-01f,
  -7.51838461e-02f, -9.06294882e-02f, 7.24514648e-02f, -1.25704139e-01f, 1.41457856e-01f, -2.03243792e-02f, 1.86126620e-01f, 1.56668738e-01f, 5.99166602e-02f, -1.59746602e-01f,
  8.25621113e-02f, 1.37756363e-01f, 1.42659888e-01f, -6.07645176e-02f, -1.52503178e-01f, -3.74146625e-02f, 4.49362136e-02f, 1.17612876e-01f, 1.76656261e-01f, 6.89572990e-02f,
  1.14496537e-01f, -1.71814650e-01f, 1.24216825e-01f, 4.90647592e-02f, -5.84653616e-02f, 1.20706141e-01f, -1.94918234e-02f, -1.23850957e-01f, 1.32020369e-01f, -5.34401499e-02f,
  -1.23343036e-01f, 1.79727986e-01f, -6.12487607e-02f, -8.49673152e-03f, -3.47136694e-04f, -3.94368283e-02f, -2.30613053e-02f, -6.27058074e-02f, -2.95583773e-02f, -1.26598969e-01f,
  -7.33565763e-02f, 1.02245227e-01f, 1.15794182e-01f, -1.02188766e-01f, 8.60126782e-03f, 8.88822079e-02f, -1.07612848e-01f, 6.33902773e-02f, -1.16893470e-01f, 1.20903887e-01f,
  9.65456814e-02f, -1.31995797e-01f, -1.08024202e-01f, 2.35932425e-01f, 1.95860922e-01f, -7.87901282e-02f, 1.93221137e-01f, 1.12938322e-01f, -1.80302352e-01f, 1.00457981e-01f,
  4.80091780e-01f, -1.34822667e-01f, 3.15361649e-01f, 1.58819601e-01f, -1.70444682e-01f, 2.29236409e-01f, -9.35617238e-02f, -1.18351512e-01f, 5.96739091e-02f, 3.64251528e-03f,
  -1.05281375e-01f, 2.94132859e-01f, 1.91695720e-01f, -2.61379004e-01f, -9.98662189e-02f, 9.80991200e-02f, 1.80329323e-01f, 2.46189520e-01f, -1.81676913e-02f, 1.96190938e-01f,
  1.97991192e-01f, -9.27438680e-03f, -1.72631711e-01f, 5.38693964e-01f, 5.91534888e-04f, -1.99774951e-01f, -1.58568829e-01f, -7.22887963e-02f, -1.35956228e-01f, 2.75160760e-01f,
  1.02530181e-01f, 1.44023910e-01f, 1.91598371e-01f, 7.73396343e-02f, -1.20162770e-01f, 2.38142088e-01f, 1.70364082e-01f, -1.90806121e-01f, -1.33488253e-01f, -1.10400289e-01f,
  8.53763297e-02f, 1.81286246e-01f, 2.65329033e-01f, 1.32121131e-01f, -1.64605994e-02f, 1.16876420e-02f, -6.72997981e-02f, -9.37910080e-02f, 6.68761060e-02f, 5.61448812e-01f,
  3.94068569e-01f, -5.69012463e-02f, -1.33217067e-01f, 2.00527802e-01f, 2.14369595e-01f, -5.38572371e-02f, 2.79921144e-01f, 1.28755597e-02f, 2.88225800e-01f, 7.72412568e-02f,
  -1.99572414e-01f, 3.06585789e-01f, -1.16974963e-02f, -5.34282625e-02f, 5.70477992e-02f, -4.00460437e-02f, 2.30300948e-02f, -8.22392758e-03f, 1.94000825e-01f, -1.88659370e-01f,
  -4.44723964e-02f, -1.97079796e-02f, 2.60172069e-01f, -1.12150274e-01f, 1.16800211e-01f, 1.71598736e-02f, 1.25588076e-02f, -1.55938879e-01f, -7.33041484e-03f, 1.57761022e-01f,
  -1.22232936e-01f, 3.15491706e-01f, 1.30466446e-01f, -2.07538456e-01f, 1.09974936e-01f, -1.65108573e-02f, 1.16264127e-01f, -6.87912777e-02f, -2.11499613e-02f, 4.45046760e-02f,
  -6.40470088e-02f, -9.99920964e-02f, 1.43795639e-01f, -1.80509657e-01f, -6.40982529e-03f, 1.69795036e-01f, 4.41285037e-02f, 1.59967303e-01f, -6.48272783e-02f, 9.89979357e-02f,
  1.04766421e-01f, 9.85424872e-03f, -2.41321951e-01f, 1.74036831e-01f, -1.53452396e-01f, 9.14079100e-02f, -7.42140040e-02f, 1.73081011e-01f, -1.76153049e-01f, 2.11335525e-01f,
  -7.49367177e-02f, 1.00260153e-01f, 1.44001484e-01f, 1.81272790e-01f, 1.34304821e-01f, 1.72454774e-01f, 6.65964112e-02f, 2.52165169e-01f, -5.08753397e-02f, -1.93645462e-01f,
  1.63065523e-01f, 2.21021920e-01f, 3.08526099e-01f, -8.54792371e-02f, -4.63126674e-02f, -1.25490427e-01f, 1.04234613e-01f, 1.09301127e-01f, 1.20205149e-01f, 2.11850211e-01f,
  -1.14905730e-01f, 1.64398551e-01f, -7.87805244e-02f, -1.07679665e-01f, -1.55666061e-02f, 2.10961886e-02f, 1.01957642e-01f, 1.61820561e-01f, -9.19841751e-02f, -8.95837694e-02f,
  -8.42513591e-02f, -7.26236403e-02f, -1.06134161e-01f, -1.09820023e-01f, -5.96743217e-03f, -1.02557890e-01f, -1.38879940e-01f, 1.74552664e-01f, -4.00662757e-02f, 1.47787780e-01f,
  2.18636505e-02f, -8.67619216e-02f, 1.38738200e-01f, 6.41044322e-03f, -3.55734117e-02f, -9.85770673e-02f, -4.30381373e-02f, -7.16469064e-02f, -1.38890147e-01f, 7.59052532e-03f,
  1.92495346e-01f, 2.91930318e-01f, 2.68132359e-01f, 5.66844866e-02f, 1.38358411e-03f, 2.95490436e-02f, -2.00636774e-01f, 1.19393721e-01f, -8.49614944e-03f, -8.31475854e-02f,
  4.71244827e-02f, 2.24391907e-01f, 3.93865108e-02f, -1.57892436e-01f, -8.59795231e-03f, -8.39170516e-02f, 3.81107703e-02f, 3.88238295e-05f, 2.52369158e-02f, 8.80474821e-02f,
  4.54460859e-01f, -4.75235619e-02f, 2.65578330e-02f, 1.51915058e-01f, -8.75050277e-02f, -1.15389876e-01f, -2.70623602e-02f, -1.29210502e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  9.38991457e-02f, 8.51994287e-03f, 7.55502656e-02f, 2.16306031e-01f, -4.20369469e-02f, 1.05282720e-02f, -5.59632480e-02f, 3.29754315e-02f, 2.79713213e-01f, -2.56442260e-02f,
  1.08746037e-01f, -2.39807200e-02f, 1.27669170e-01f, 2.19768748e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.25642359e-01f, 1.97903901e-01f, 1.22434475e-01f, 2.29701512e-02f, 1.85306728e-01f, 8.69253129e-02f, -1.84171334e-01f, 1.31540358e-01f, -2.46593617e-02f, 8.59658420e-02f,
  3.05488735e-01f, 2.67185718e-01f, 6.72587454e-02f, 3.21388841e-02f, 2.82778025e-01f, 1.64180165e-04f, 8.78296569e-02f, 2.42083699e-01f, 8.20269361e-02f, -1.31364614e-01f,
  1.48038164e-01f, -6.51415288e-02f, 1.37123480e-01f, 3.19039822e-02f, -1.81897521e-01f, 3.65107157e-03f, -2.66270369e-01f, 2.04320520e-01f, 8.56278930e-03f, 1.11083627e-01f,
  2.05728769e-01f, -2.54125237e-01f, 2.67006516e-01f, -2.69968897e-01f, -9.84811261e-02f, 3.83362919e-02f, 1.75493985e-01f, -8.11836645e-02f, -6.10951670e-02f, 1.11609660e-01f,
  -8.49520341e-02f, 4.73129779e-01f, -3.86937618e-01f, 2.96701044e-02f, 2.18838260e-01f, -7.95497820e-02f, -4.74982768e-01f, -2.59946510e-02f, 2.32490838e-01f, 8.60129949e-03f,
  1.26867974e-02f, -6.89741895e-02f, -8.83590132e-02f, 8.65350943e-03f, -1.39262527e-01f, -3.55946682e-02f, 3.71998623e-02f, -1.30928084e-01f, 2.05317676e-01f, -2.33516753e-01f,
  -2.69468725e-01f, -1.42360255e-01f, -1.45169171e-02f, 1.32216051e-01f, -5.51566016e-03f, 2.31265612e-02f, -2.32173502e-01f, -1.79058850e-01f, -2.33945832e-01f, -2.61704233e-02f,
  8.18572864e-02f, -2.27677763e-01f, 7.36232400e-02f, -2.89082944e-01f, 4.80451316e-01f, 5.01218028e-02f, 1.77574474e-02f, -1.82473660e-01f, 2.03743622e-01f, 2.52187490e-01f,
  1.38021141e-01f, -9.51074511e-02f, -6.18527718e-02f, -4.35403176e-02f, 2.64958262e-01f, -1.33539781e-01f, -1.41614959e-01f, -2.05339044e-01f, 1.51782051e-01f, 2.01372251e-01f,
  -3.07623297e-02f, 3.10651839e-01f, 1.97361663e-01f, 9.43660066e-02f, -1.31862685e-01f, 8.28373730e-02f, 1.76043838e-01f, -2.65782356e-01f, 1.68832988e-01f, -6.30648732e-02f,
  1.64872915e-01f, 2.59633899e-01f, 1.88517317e-01f, 1.37948602e-01f, -9.26707014e-02f, 1.62114173e-01f, -4.33391362e-01f, -2.44701788e-01f, -1.59891718e-03f, 2.60237217e-01f,
  1.75828025e-01f, -1.54114380e-01f, -2.02416703e-01f, 1.65813148e-01f, 8.70451555e-02f, 8.37128982e-02f, -2.85291635e-02f, 2.19223406e-02f, 1.60308629e-01f, -1.00697406e-01f,
  -6.36903718e-02f, -2.60594301e-02f, 1.30164161e-01f, -9.78411883e-02f, -8.70433003e-02f, -2.13913888e-01f, 1.20333694e-01f, 1.90123439e-01f, -1.12289183e-01f, 2.24873021e-01f,
  -8.43952373e-02f, -2.06003268e-03f, -1.57548890e-01f, -1.76780596e-01f, -6.61203414e-02f, 1.36713415e-01f, -7.11535364e-02f, 4.05382365e-01f, 5.39586022e-02f, 5.19335985e-01f,
  1.56155393e-01f, -3.57961923e-01f, 2.58670896e-01f, -3.12298954e-01f, -2.28022020e-02f, -1.84346735e-02f, 1.15714476e-01f, -1.54588252e-01f, 3.32191616e-01f, 1.53710097e-01f,
  1.77809611e-01f, 2.51308471e-01f, -1.34382024e-01f, 2.57262141e-02f, -3.35669279e-01f, -3.77486497e-01f, -7.63151795e-02f, 7.83318579e-02f, 2.58972585e-01f, 4.00849096e-02f,
  -2.09449250e-02f, -3.45990866e-01f, 1.41057745e-01f, -9.12104771e-02f, -2.05417126e-01f, -3.93238008e-01f, -4.73821983e-02f, 2.03172062e-02f, -1.66928396e-01f, 1.52254310e-02f,
  -5.80356598e-01f, -4.81993616e-01f, 2.22769767e-01f, 1.04962587e-01f, -3.24267775e-01f, 7.08661303e-02f, -1.65377110e-02f, -1.90657854e-01f, -7.71915987e-02f, -1.48209125e-01f,
  -1.21405572e-01f, -1.37148723e-01f, -2.07174383e-02f, -7.32749104e-02f, 5.38925007e-02f, -8.56395662e-02f, 3.40895414e-01f, -2.44530484e-01f, 1.01823412e-01f, -2.28847146e-01f,
  -6.04500845e-02f, 1.86213866e-01f, 2.01425463e-01f, -8.21475461e-02f, -1.59286320e-01f, 4.51095663e-02f, -5.89965284e-02f, -1.95117250e-01f, -1.03891999e-01f, -2.19139308e-01f,
  -6.75274385e-03f, 4.97309625e-01f, 1.18619045e-02f, 3.38647097e-01f, -1.48261279e-01f, -3.84028822e-01f, -1.99824795e-01f, -1.70908004e-01f, 2.54866481e-01f, 2.07889333e-01f,
  -1.39901012e-01f, -2.09415797e-02f, -1.08664900e-01f, 1.53798342e-01f, -4.64587994e-02f, 2.91236311e-01f, 1.58648834e-01f, 4.71376255e-02f, -3.36885393e-01f, -3.45019162e-01f,
  2.95491237e-03f, 9.88710765e-03f, 8.44270587e-02f, 2.33467653e-01f, -1.55203149e-01f, 7.93514103e-02f, 2.64451243e-02f, 1.79385655e-02f, -1.65832028e-01f, -2.41146117e-01f,
  7.03981742e-02f, -3.21285278e-02f, -2.02625230e-01f, 1.77257374e-01f, 3.28566670e-01f, 5.33555329e-01f, -5.10569327e-02f, -3.87530535e-01f, -2.15726987e-01f, 2.07828864e-01f,
  2.38563761e-01f, 2.01077342e-01f, 1.10219500e-03f, -9.39251333e-02f, 1.69231400e-01f, -2.50327270e-02f, -1.84800178e-01f, 6.91048130e-02f, -2.10465819e-01f, 7.11225048e-02f,
  -4.21015918e-01f, 1.85432270e-01f, -5.70995323e-02f, 4.18474525e-01f, 9.12753493e-02f, 1.46120623e-01f, 5.16716531e-03f, -1.34707645e-01f, 5.77778183e-02f, 8.25169217e-03f,
  -6.92056194e-02f, -1.12199984e-01f, -2.79497821e-02f, -1.71055496e-01f, -1.54957682e-01f, 2.99010366e-01f, -7.59311542e-02f, 1.95953995e-01f, 1.85430110e-01f, -1.17530771e-01f,
  -1.41433895e-01f, -2.29640335e-01f, -9.94500741e-02f, 1.45501718e-01f, 2.86290850e-02f, 1.09562084e-01f, -2.90019494e-02f, -8.49099904e-02f, 7.37745315e-02f, 1.51020028e-02f,
  9.51071158e-02f, -1.77832693e-01f, -4.65248227e-02f, -3.30728114e-01f, -1.91223383e-01f, 6.66294321e-02f, 1.39402732e-01f, -9.58287716e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.29306123e-01f, -1.38346687e-01f, -7.24340975e-02f, -1.54573292e-01f, 1.10011660e-01f, -4.23806682e-02f, -1.26273140e-01f, -4.13276926e-02f, 2.09980458e-02f, -1.32000059e-01f,
  -2.62361597e-02f, 6.47700652e-02f, 1.18168414e-01f, -5.41287921e-02f, 1.04223199e-01f, -4.29052263e-02f, -1.62245911e-02f, -9.47751626e-02f, 6.27463311e-02f, 1.78381771e-01f,
  1.28396302e-01f, -6.00303598e-02f, -9.37571153e-02f, -1.37654766e-01f, -1.34776635e-02f, -1.37583062e-01f, 1.55636385e-01f, -1.73755690e-01f, 1.24920970e-02f, -9.73630995e-02f,
  -8.37201774e-02f, 1.29035681e-01f, 2.56205976e-01f, -2.01968789e-01f, 3.50890458e-01f, 2.19889522e-01f, 1.92149356e-01f, 3.39716189e-02f, 2.93023288e-01f, 1.33527324e-01f,
  2.34778553e-01f, 2.80227900e-01f, -4.29897338e-01f, 9.26765501e-02f, 1.53469265e-01f, -2.13305056e-01f, -4.97719496e-01f, -4.08447385e-02f, 3.33214700e-01f, 1.19127467e-01f,
  -1.51782140e-01f, -1.10326335e-01f, -2.40840778e-01f, 1.49197429e-01f, -1.93877429e-01f, -2.76073888e-02f, -7.52144307e-02f, 1.39778042e-02f, 4.10764426e-01f, -1.38933197e-01f,
  -8.28150213e-02f, 3.13304871e-01f, 1.70493945e-01f, 4.52851802e-01f, -1.26694590e-01f, -1.14947120e-02f, -9.67813581e-02f, 1.24265194e-01f, 1.04408428e-01f, -8.88593942e-02f,
  -1.29991636e-01f, -1.47491351e-01f, -1.28964875e-02f, -1.08538613e-01f, 2.65739150e-02f, -1.35759741e-01f, -2.89377607e-02f, -6.26240000e-02f, 1.62635922e-01f, 7.17795501e-03f,
  1.55055299e-01f, 8.94410610e-02f, 7.70243853e-02f, 1.05526745e-01f, -8.67308527e-02f, 1.63062334e-01f, -9.57105309e-02f, 1.55249909e-01f, -3.26220389e-03f, -7.10844100e-02f,
  -2.54597012e-02f, -1.66392043e-01f, -2.11280994e-02f, 3.96006629e-02f, -2.43639164e-02f, 1.50766652e-02f, -1.01927944e-01f, -4.66489699e-03f, -5.41208349e-02f, -9.94132459e-02f,
  -1.76382735e-02f, -1.21452950e-03f, 1.27348199e-01f, -1.55017033e-01f, 5.15172295e-02f, -7.39695430e-02f, 1.20749891e-01f, 1.22309271e-02f, 2.48538442e-02f, -7.09769055e-02f,
  1.70556724e-01f, 1.25964373e-01f, 1.15826458e-01f, 1.12654485e-01f, -1.10371858e-02f, -1.03069574e-01f, -9.72436592e-02f, -1.07684918e-01f, 6.68391287e-02f, -1.00749046e-01f,
  -1.61947072e-01f, 3.31802182e-02f, 1.31824672e-01f, -8.81408155e-02f, -7.44310319e-02f, 5.49001507e-02f, -1.02087870e-01f, -1.31830648e-01f, -1.39395863e-01f, -4.32893112e-02f,
  -2.55382266e-02f, -1.23109519e-02f, -6.88876882e-02f, 5.56300469e-02f, -1.17047660e-01f, -1.11334071e-01f, -6.28040209e-02f, 2.69571003e-02f, -1.75805897e-01f, 1.31893560e-01f,
  -5.06185880e-03f, -7.91372955e-02f, -8.04812610e-02f, 4.13172022e-02f, -1.53431565e-01f, 1.70067281e-01f, -7.71360993e-02f, -2.61220019e-02f, -7.94586316e-02f, 2.55393256e-02f,
  1.67846113e-01f, 8.10477361e-02f, -2.95459833e-02f, 1.21247202e-01f, 1.04134277e-01f, 1.42543197e-01f, -4.30665575e-02f, 1.82462543e-01f, 6.69331923e-02f, 5.33941649e-02f,
  1.93795949e-01f, 1.83238819e-01f, -4.38977964e-02f, 3.03008854e-01f, 4.94295871e-03f, -4.13845337e-05f, 2.82119989e-01f, 1.25543952e-01f, 2.57659495e-01f, 2.17170328e-01f,
  5.84388524e-02f, 3.01077694e-01f, -1.33841500e-01f, -2.00021043e-02f, 4.48227942e-01f, -4.53649126e-02f, -2.02575698e-01f, 8.94875377e-02f, -2.03563958e-01f, 1.66069716e-01f,
  3.70906115e-01f, 6.08331226e-02f, -5.69183156e-02f, 1.81225091e-02f, 1.78221285e-01f, -1.04803197e-01f, -1.02519467e-01f, 2.50079989e-01f, 1.33605018e-01f, -1.32071748e-01f,
  3.03784444e-04f, -1.61971182e-01f, 2.52824605e-01f, -7.41891041e-02f, 8.20284560e-02f, 1.25390649e-01f, 1.92032292e-01f, -5.56420088e-02f, 3.12964648e-01f, 1.78935882e-02f,
  3.15306544e-01f, 4.38073963e-01f, -3.38731974e-01f, 7.11521879e-02f, -1.55042693e-01f, -2.74623215e-01f, -4.40569967e-01f, 2.97763795e-02f, 7.72083029e-02f, -2.76913434e-01f,
  1.65678114e-01f, -3.94188799e-02f, -5.87080652e-03f, 3.51902962e-01f, -3.06258369e-02f, 1.10183179e-01f, -7.10041225e-02f, -3.48142534e-02f, 3.47265825e-02f, -1.99699141e-02f,
  -1.48481056e-01f, 1.58672896e-03f, -9.93730649e-02f, 8.19289982e-02f, 1.06271230e-01f, 1.83739230e-01f, -8.18834156e-02f, 1.69305533e-01f, 9.53953154e-03f, -1.03557065e-01f,
  1.86418712e-01f, 2.21564770e-01f, -5.65962195e-02f, 3.23219411e-02f, -1.55194357e-01f, -1.33961186e-01f, 1.04310550e-01f, -5.17779104e-02f, 3.08208495e-01f, -1.76416561e-02f,
  3.59071530e-02f, 1.57117143e-01f, 1.00708060e-01f, 1.78612813e-01f, 9.97771919e-02f, -1.53255507e-01f, 1.06082164e-01f, 1.08341537e-01f, 1.13375612e-01f, 1.16833679e-01f,
  1.37394175e-01f, -2.07002729e-01f, 2.05608159e-01f, -4.69311513e-02f, -1.53982803e-01f, 9.00028553e-03f, 1.00216202e-01f, 1.67214096e-01f, -1.92899734e-03f, -6.70176372e-02f,
  2.59068385e-02f, 1.80873334e-01f, 1.14697151e-01f, 2.28696931e-02f, 6.12647564e-05f, 1.35123685e-01f, 2.22430497e-01f, 4.34890874e-02f, -2.86387894e-02f, -1.91673800e-01f,
  -1.47127016e-02f, 1.00078493e-01f, 9.54349935e-02f, 6.20908178e-02f, 1.57196790e-01f, -1.35030039e-02f, -8.97000507e-02f, 1.59164090e-02f, -4.68778424e-02f, -1.58687055e-01f,
  -9.13702026e-02f, 1.55005082e-01f, 1.13767467e-01f, -3.22414003e-02f, -9.72183868e-02f, -9.78771299e-02f, -1.32994875e-01f, 7.99337476e-02f, -5.11588752e-02f, 1.83639273e-01f,
  -1.54908702e-01f, 2.15384573e-01f, -6.63400209e-03f, 2.02986337e-02f, -1.22660853e-03f, -9.90778208e-02f, 2.09335424e-02f, 1.63351059e-01f, 2.53120929e-01f, 1.38715625e-01f,
  1.12741224e-01f, -2.21325472e-01f, -1.83890119e-01f, 7.48316012e-03f, 3.82348359e-01f, 3.73385847e-02f, 2.32212264e-02f, -1.24185987e-01f, 2.60175377e-01f, 7.55499005e-02f,
  1.52154535e-01f, -5.15480433e-03f, 1.35509506e-01f, -1.31663727e-02f, 6.97268024e-02f, 3.41825277e-01f, -1.85259789e-01f, 1.99585885e-01f, 1.33649424e-01f, -4.34694886e-02f,
  1.45002365e-01f, 3.27412412e-02f, 3.59234452e-01f, 1.89811051e-01f, 7.50596300e-02f, 3.72984499e-01f, 9.85895842e-02f, 2.46034950e-01f, 3.21771175e-01f, -4.48300987e-01f,
  -1.39626786e-01f, -4.48534578e-01f, -7.35067390e-03f, 3.87760282e-01f, 3.21304053e-01f, 2.32735649e-01f, 1.40621156e-01f, -1.30166113e-01f, 1.23117797e-01f, 2.44711682e-01f,
  -1.60218403e-01f, -1.28249764e-01f, 1.53684810e-01f, 1.63977489e-01f, 1.79477766e-01f, -2.46365964e-01f, 2.60428965e-01f, 3.21829706e-01f, 2.40287989e-01f, -1.38731092e-01f,
  -8.23758449e-03f, 2.63511509e-01f, 2.39060819e-01f, -1.83661357e-02f, 1.36344746e-01f, 6.14232980e-02f, 1.03379712e-02f, 2.03900918e-01f, 9.99741033e-02f, 2.05469187e-02f,
  3.48235041e-01f, -2.72047311e-01f, 5.52530177e-02f, 1.80917263e-01f, -2.73608655e-01f, 2.63389379e-01f, 7.37261832e-01f, -4.63611409e-02f, -3.12689573e-01f, 3.00392747e-01f,
  -1.34710833e-01f, -1.83040109e-02f, 2.97419459e-01f, -2.00716615e-01f, 1.10784009e-01f, 1.54511809e-01f, -1.08480439e-01f, 1.54870257e-01f, -2.51613334e-02f, 4.07948554e-01f,
  3.25273931e-01f, -1.31115228e-01f, 6.13008700e-02f, -1.48173701e-02f, 1.07804693e-01f, -7.58616328e-02f, -1.20542705e-01f, 1.22298323e-01f, -3.34232002e-02f, -7.77035877e-02f,
  7.90558532e-02f, 6.44431412e-02f, -5.38831167e-02f, -1.69597417e-01f, -1.94001004e-01f, -1.68370664e-01f, 2.68002842e-02f, 6.17552586e-02f, 9.35544595e-02f, -1.62739068e-01f,
  5.53830788e-02f, -1.19726919e-01f, -4.89038713e-02f, -2.88244523e-03f, 1.44109786e-01f, -1.76663876e-01f, 1.45429119e-01f, 9.87299066e-03f, -8.46698359e-02f, -1.51849091e-01f,
  2.46832177e-01f, -1.04912259e-01f, 1.64323166e-01f, -5.76432422e-02f, 1.75370306e-01f, 1.97232708e-01f, 1.66128770e-01f, -5.34259975e-02f, -1.42096505e-01f, 1.50683910e-01f,
  -9.50062796e-02f, -1.03342794e-01f, 1.65296406e-01f, -3.57815735e-02f, -6.89365044e-02f, 2.30471492e-02f, -5.86810410e-02f, -1.45997807e-01f, -1.62852891e-02f, 8.14300552e-02f,
  8.05833414e-02f, 1.26712531e-01f, -7.10875988e-02f, -6.98559061e-02f, -1.68509007e-01f, -1.12087943e-01f, -2.37072129e-02f, -5.42708784e-02f, 1.31083950e-01f, -1.42966554e-01f,
  1.29793197e-01f, -1.13300152e-01f, -1.45773962e-01f, -1.02428071e-01f, -8.02970007e-02f, 7.93693066e-02f, 1.03935659e-01f, -6.28038645e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -6.20879158e-02f, 1.09977305e-01f, -4.72254828e-02f, -1.51264891e-01f, -1.20827734e-01f, 1.97539672e-01f, 2.87303030e-01f, 1.39574468e-01f, -1.00323804e-01f, 7.24164248e-02f,
  1.35651395e-01f, 3.16951483e-01f, 1.12609923e-01f, -1.58199742e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.83458820e-01f, -4.59260680e-02f, 5.60705848e-02f, 3.64202820e-02f, -2.85057127e-01f, -4.89063025e-01f, -2.54477590e-01f, 6.23599486e-03f, -2.32891992e-01f, 2.47895241e-01f,
  -1.26434579e-01f, 1.98286533e-01f, -1.50478199e-01f, 3.18557292e-01f, -2.47752130e-01f, 4.14890461e-02f, 3.35699499e-01f, 4.20636199e-02f, -9.70843285e-02f, -2.46378049e-01f,
  -5.21085039e-02f, 1.67832047e-01f, 1.88803449e-01f, 2.78257787e-01f, -1.77843243e-01f, 9.58161335e-03f, 1.85719430e-01f, 2.71520074e-02f, -2.39449337e-01f, 3.71476024e-01f,
  -9.26478207e-03f, 1.45355798e-02f, -1.35910332e-01f, 1.55557215e-01f, -1.82221264e-01f, -2.30961308e-01f, -1.10375866e-01f, 3.51151496e-01f, -3.81317735e-02f, -9.36996564e-02f,
  -1.65710419e-01f, -1.68389171e-01f, -1.58778310e-01f, -2.09950209e-01f, 1.67191803e-01f, -5.46259761e-01f, 4.00826842e-01f, -5.16242385e-01f, -4.32893604e-01f, -2.13578284e-01f,
  -2.18049753e-02f, -2.02844031e-02f, 9.75140110e-02f, 8.52753296e-02f, 1.55672014e-01f, -3.47024530e-01f, -6.03308342e-02f, 1.59420609e-01f, 7.15945438e-02f, -8.72845203e-02f,
  4.23532605e-01f, 2.00415030e-02f, -1.11156516e-01f, -5.17478213e-02f, 6.48635998e-02f, 1.27121314e-01f, -7.30356723e-02f, 2.84963816e-01f, 6.91063851e-02f, 1.09253965e-01f,
  2.03786001e-01f, -1.92878265e-02f, 2.59070784e-01f, 6.94259703e-02f, 2.15023443e-01f, -2.72581160e-01f, -8.77526104e-02f, 9.61739942e-02f, 1.78544462e-01f, 2.75676966e-01f,
  3.36237401e-01f, 1.33445442e-01f, 2.60101575e-02f, 4.88249689e-01f, -1.40928492e-01f, -1.26951903e-01f, 1.39374961e-03f, -7.16470322e-03f, 2.63644993e-01f, -7.98782706e-02f,
  -1.48785070e-01f, 1.04432233e-01f, -4.00983781e-01f, -2.64043182e-01f, 2.03409605e-02f, -1.55087277e-01f, 1.16349980e-02f, -3.73345762e-02f, -1.04481936e-01f, -1.99771766e-02f,
  3.43960583e-01f, 3.14180404e-01f, 2.56769300e-01f, 2.60363251e-01f, -9.95706245e-02f, -6.84195310e-02f, 2.46853009e-01f, -3.93330932e-01f, -1.39578208e-02f, 3.55570227e-01f,
  1.25106603e-01f, 3.19705844e-01f, 1.96913674e-01f, 1.48159698e-01f, 1.08744740e-01f, 1.66904882e-01f, 1.26430899e-01f, 1.75955430e-01f, 5.06701209e-02f, -2.50261072e-02f,
  2.06334248e-01f, -1.52634606e-01f, 5.87976873e-02f, -7.07815588e-02f, -2.84673035e-01f, -2.51529962e-01f, -1.28833219e-01f, 8.22560564e-02f, -2.58565605e-01f, -1.60925046e-01f,
  -9.93051678e-02f, -1.68797195e-01f, -1.80102021e-01f, -1.09125167e-01f, -3.85710895e-02f, 9.94062126e-02f, -5.05335964e-02f, 1.84979476e-02f, -2.67180502e-01f, 8.49570632e-02f,
  1.56314269e-01f, -3.41586202e-01f, -4.60253097e-03f, -4.09570992e-01f, -2.64463842e-01f, -2.20479369e-01f, 1.52835652e-01f, -1.97528437e-01f, -1.71916202e-01f, 4.22456264e-02f,
  -7.20205531e-02f, 2.10680410e-01f, -2.97002584e-01f, -1.91340312e-01f, -4.53324616e-02f, -1.20272860e-01f, 3.16609025e-01f, 4.45938319e-01f, -1.82048827e-01f, 4.94065136e-02f,
  3.79241668e-02f, -4.34995778e-02f, -6.72627091e-02f, -2.73347884e-01f, -2.46174768e-01f, 4.00380343e-01f, -1.74551219e-01f, -1.82737589e-01f, 9.54099968e-02f, -4.29011583e-01f,
  1.64502233e-01f, -2.25532845e-01f, 3.92086506e-01f, -4.19688433e-01f, 4.64608699e-01f, -1.23951294e-01f, -5.40107131e-01f, 2.45418400e-01f, -2.87458040e-02f, 1.87674001e-01f,
  -1.42582759e-01f, -1.59366410e-02f, 1.41498327e-01f, -1.76624417e-01f, 1.50639042e-01f, 1.34409964e-01f, -5.81534468e-02f, -2.40815878e-01f, 1.47917315e-01f, -8.34981799e-02f,
  1.59519892e-02f, -4.97608073e-02f, 2.29800254e-01f, -1.05176479e-01f, -9.35257375e-02f, 1.59622207e-01f, 8.83890390e-02f, 3.85337919e-01f, 9.82367694e-02f, 7.68845528e-02f,
  8.44988301e-02f, -7.25997016e-02f, 4.76954103e-01f, -2.95041323e-01f, 2.01791227e-01f, -2.85003960e-01f, 2.38725096e-01f, 3.07690259e-02f, -4.10661697e-01f, -1.23165488e-01f,
  1.45452857e-01f, 2.67997921e-01f, 1.48974359e-02f, -1.68384969e-01f, 1.10271864e-01f, -1.56301215e-01f, 3.40419263e-01f, -8.24688599e-02f, -1.04013138e-01f, -2.04061225e-01f,
  1.50945818e-03f, -3.44030201e-01f, 1.22703850e-01f, 1.25431389e-01f, 5.69774173e-02f, 2.49492433e-02f, 3.17013189e-02f, -2.43825808e-01f, -2.35483684e-02f, 4.27833438e-01f,
  1.11256748e-01f, 2.28837833e-01f, -1.08539112e-01f, -1.76323578e-01f, 4.14357573e-01f, -3.22364032e-01f, 1.51925862e-01f, -2.84448892e-01f, 4.19881433e-01f, 2.47225985e-01f,
  -9.12035033e-02f, -6.92662448e-02f, -7.91841671e-02f, 4.05450225e-01f, -8.71917233e-02f, -1.52337506e-01f, -1.81976017e-02f, -3.08071047e-01f, 1.89454854e-01f, -4.02570739e-02f,
  -1.16149373e-01f, -1.21656343e-01f, -1.20476587e-02f, -1.21869676e-01f, -7.98045695e-02f, -6.42229617e-02f, -1.29835904e-01f, 1.82331577e-02f, 1.87871262e-01f, 1.46411853e-02f,
  -3.82458419e-01f, 2.76773512e-01f, -2.19320804e-01f, 1.05665609e-01f, -1.58652827e-01f, -4.32729125e-01f, 4.46237884e-02f, -1.12058446e-01f, 3.12049508e-01f, -2.30774209e-01f,
  4.97220695e-01f, -2.98247963e-01f, -2.83894658e-01f, -9.35830697e-02f, 1.43981189e-01f, -1.22938626e-01f, -1.68647036e-01f, -9.11759958e-02f, -1.58498153e-01f, 1.43635171e-02f,
  5.58407865e-02f, 1.14830755e-01f, 1.23505153e-01f, -2.26340294e-01f, 2.29338318e-01f, -9.75061804e-02f, 2.41331443e-01f, -1.34234920e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -5.21549024e-02f, -7.63172433e-02f, 2.60254741e-01f, 2.52753526e-01f, 1.70566551e-02f, 1.40577257e-01f, -8.00048187e-02f, 2.70137101e-01f, -6.80395290e-02f, 2.45858267e-01f,
  -3.79139155e-01f, 1.25948310e-01f, 8.74455944e-02f, -4.96922508e-02f, -3.06698740e-01f, -1.34218112e-01f, -6.39648438e-02f, -4.47724946e-02f, -8.03417247e-03f, -2.14958310e-01f,
  -1.31958500e-01f, 1.41727015e-01f, 3.07117086e-02f, 4.26243357e-02f, -4.57524322e-02f, 1.73557505e-01f, -6.22894466e-02f, -8.08820799e-02f, 1.53022736e-01f, 1.90977305e-01f,
  -1.35893792e-01f, -6.75956458e-02f, 1.48596525e-01f, 1.36459485e-01f, 3.88337433e-01f, 4.05620158e-01f, 1.38344482e-01f, 6.50825649e-02f, 1.99830890e-01f, 1.11189976e-01f,
  3.07674468e-01f, 6.80318922e-02f, 7.28641599e-02f, -3.67553718e-02f, 3.55810449e-02f, 5.47468483e-01f, -3.93939972e-01f, 4.28676873e-01f, 4.63108450e-01f, -1.87009200e-02f,
  -1.55496389e-01f, 2.43475631e-01f, -1.52948588e-01f, -2.16366380e-01f, 1.59170270e-01f, 2.90154576e-01f, 3.95035833e-01f, 7.40821064e-02f, 1.64966196e-01f, 2.81005412e-01f,
  -3.65544736e-01f, 6.83650225e-02f, -1.55477300e-01f, -2.24498302e-01f, 1.05153084e-01f, -2.04484224e-01f, 7.53766522e-02f, 1.55773014e-01f, -4.92076315e-02f, 2.76872873e-01f,
  -2.24980056e-01f, -5.23380414e-02f, -3.48622143e-01f, 5.85008319e-03f, -3.24533284e-01f, 3.11471343e-01f, -1.89708009e-01f, -4.60425943e-01f, -1.28839239e-01f, -1.75318971e-01f,
  -1.14576228e-01f, -3.46045010e-02f, -1.48224473e-01f, -2.11476058e-01f, 2.60511581e-02f, -1.36171713e-01f, -8.91991332e-02f, 2.01143682e-01f, -3.71215165e-01f, 3.05666439e-02f,
  3.48494798e-02f, 1.29424393e-01f, 6.58676744e-01f, 5.40988326e-01f, 6.14932775e-02f, 1.63558591e-02f, -1.73170358e-01f, -1.12155229e-01f, -1.59126192e-01f, 9.81145352e-02f,
  -1.37188986e-01f, 1.01867422e-01f, -1.27114907e-01f, -2.14039721e-02f, -9.84241590e-02f, -1.18550189e-01f, -2.78062969e-02f, 8.32954198e-02f, -1.19471394e-01f, 8.73659179e-02f,
  1.10655598e-01f, 1.36300638e-01f, 5.65300249e-02f, -1.53536618e-01f, 1.28569175e-03f, -1.71937853e-01f, -2.23563164e-02f, 8.07647556e-02f, -4.75370996e-02f, -4.37283255e-02f,
  1.26945198e-01f, -9.59922001e-02f, 4.01815698e-02f, -7.67505020e-02f, -1.39908448e-01f, 1.45281091e-01f, 1.01159394e-01f, -1.41386330e-01f, 3.75049859e-01f, 3.57540518e-01f,
  -4.34511639e-02f, 4.14793193e-02f, 4.55177933e-01f, 5.19856751e-01f, 6.99992239e-01f, 5.00823677e-01f, 2.26268962e-01f, 1.45431742e-01f, 7.77456760e-02f, -5.46541214e-01f,
  4.87905741e-01f, 1.98823199e-01f, -1.84379607e-01f, -1.30305886e-01f, -5.37140191e-01f, 1.26893654e-01f, 6.94890544e-02f, -7.34491572e-02f, -5.13501652e-02f, 7.94764012e-02f,
  -7.66412076e-03f, 4.82179016e-01f, -1.43514514e-01f, 2.62168586e-01f, -1.95750911e-02f, -4.01248515e-01f, 1.05736561e-01f, 3.98876101e-01f, 1.44452497e-01f, 1.47253588e-01f,
  -1.06330402e-01f, -5.24465926e-02f, -5.62993288e-02f, -1.26371279e-01f, 3.59604582e-02f, -1.29432172e-01f, 6.01738952e-02f, 7.86430165e-02f, 2.41001719e-03f, -7.84742013e-02f,
  -5.48432674e-03f, -1.59399118e-02f, -1.26654953e-01f, 1.04956701e-01f, 9.05171782e-03f, -1.40045583e-01f, -3.90633307e-02f, 5.50216287e-02f, 1.66987449e-01f, 2.59517739e-03f,
  -1.72256038e-01f, 6.33410141e-02f, -1.30523264e-01f, 1.52010014e-02f, -1.64091196e-02f, -1.52649239e-01f, -1.59493402e-01f, 1.63480192e-01f, 2.61582360e-02f, -1.16908923e-01f,
  -5.86216636e-02f, -1.08703613e-01f, 2.18529075e-01f, -1.61639884e-01f, -4.16366104e-03f, 2.49725189e-02f, 1.87967420e-01f, 1.42828584e-01f, 1.58405468e-01f, 1.74010202e-01f,
  1.07665487e-01f, -1.32946745e-01f, 3.99187475e-01f, -2.29603559e-01f, 1.50865555e-01f, -3.79706286e-02f, 3.38754147e-01f, 2.63019174e-01f, 1.46510080e-01f, -6.14972450e-02f,
  -2.45338716e-02f, 5.27125716e-01f, -1.03647098e-01f, 1.49414735e-02f, -1.41874164e-01f, -1.57427460e-01f, 4.56149459e-01f, -1.42126471e-01f, 1.77209690e-01f, -9.18584988e-02f,
  1.03266127e-01f, -2.82273978e-01f, -7.24007487e-02f, 1.18379079e-01f, -1.26253232e-01f, 1.73854575e-01f, 1.48243964e-01f, -2.40001883e-02f, 8.57044682e-02f, -1.89501137e-01f,
  -8.86137486e-02f, -7.55648240e-02f, 1.23871602e-02f, -2.36781761e-01f, 1.99941531e-01f, -9.93151516e-02f, -4.76610847e-03f, -2.24435702e-01f, 2.51751363e-01f, 8.55919868e-02f,
  5.20092547e-02f, 3.37450561e-04f, 5.56275509e-02f, 4.29490536e-01f, 1.38411030e-01f, -1.55141786e-01f, -1.40031666e-01f, -7.19022825e-02f, 1.89038068e-02f, 1.57471150e-01f,
  1.31328017e-01f, 1.71262488e-01f, 2.16439009e-01f, -1.02741361e-01f, 2.91890383e-01f, -1.94219360e-03f, 1.14864103e-01f, -9.65962373e-03f, 1.85866937e-01f, -1.47050440e-01f,
  -1.07570343e-01f, 1.03510670e-01f, -1.69714436e-01f, -2.12313026e-01f, -6.59409985e-02f, -7.89065659e-02f, 6.78124791e-03f, 1.39127970e-01f, 1.43256634e-01f, -1.41424432e-01f,
  1.04222551e-01f, -4.66427393e-02f, -2.28713989e-01f, 1.04139104e-01f, 1.74847737e-01f, -1.23175740e-01f, -3.27694905e-03f, 6.30721748e-02f, 6.34882879e-03f, -1.58939958e-01f,
  -1.79293424e-01f, 1.30078763e-01f, -4.11394574e-02f, -7.63544962e-02f, 3.51909846e-01f, 1.78986359e-02f, 1.73199102e-01f, 5.24706654e-02f, 4.02879834e-01f, 4.34275478e-01f,
  1.91364616e-01f, -2.08191976e-01f, 2.13700488e-01f, 5.20546019e-01f, 4.95875865e-01f, 3.67542207e-01f, 2.39239573e-01f, 2.28011280e-01f, -8.79408419e-02f, -2.03783557e-01f,
  9.61012989e-02f, -1.98175013e-01f, -2.65213937e-01f, -3.72046530e-01f, -2.86213189e-01f, -5.11748418e-02f, -1.80800065e-01f, -6.77364394e-02f, 1.48062646e-01f, 1.00294389e-01f,
  -6.72342852e-02f, 8.17186534e-02f, 1.25453740e-01f, 1.82986513e-01f, -4.88429852e-02f, -2.05928639e-01f, 1.07482977e-01f, 2.96269238e-01f, 6.19568415e-02f, 1.29531339e-01f,
  1.84076473e-01f, -1.51706757e-02f, -2.80412901e-02f, -4.03477512e-02f, 2.44823456e-01f, 3.67016435e-01f, -1.27887920e-01f, 8.22344571e-02f, 1.56797066e-01f, -1.59574181e-01f,
  -3.86585034e-02f, 2.92132441e-02f, -1.12573490e-01f, -3.51886749e-01f, 2.38232851e-01f, 2.16413304e-01f, -2.07764879e-01f, -9.32027493e-03f, 7.06057996e-02f, 5.24311662e-01f,
  1.23041563e-01f, 3.20029235e-03f, 6.07834458e-02f, 3.26770097e-02f, 2.15691507e-01f, -1.03214242e-01f, 1.29105940e-01f, 1.96546838e-01f, 2.92811364e-01f, -1.88696355e-01f,
  -1.32790700e-01f, -1.59606114e-01f, -1.67854980e-01f, -4.62983642e-03f, -1.07467107e-01f, -1.08814187e-01f, 1.80161465e-02f, -1.94959477e-01f, 3.10177237e-01f, -1.15068540e-01f,
  1.63948983e-01f, 2.96807140e-01f, -4.62947153e-02f, 1.26488239e-01f, -2.15147480e-01f, 1.75667152e-01f, -5.92114553e-02f, -1.72994435e-02f, 4.21514623e-02f, -6.46487921e-02f,
  -1.56459242e-01f, 4.06861641e-02f, 1.55981323e-02f, -4.37892340e-02f, 1.25801250e-01f, 2.30700076e-01f, 1.92650370e-02f, 1.69046789e-01f, -9.05748736e-03f, -1.65695194e-02f,
  6.08464405e-02f, 3.82870078e-01f, 4.68751192e-02f, -1.17895029e-01f, 2.47091949e-01f, 1.20428577e-02f, 1.30905345e-01f, 1.90253645e-01f, -8.33905190e-02f, 9.21417996e-02f,
  1.52148351e-01f, 3.03278193e-02f, 2.65591443e-01f, 3.28101330e-02f, -5.42539209e-02f, 1.75326131e-02f, -1.74811855e-01f, 2.96206325e-01f, -2.27612674e-01f, 7.75972828e-02f,
  3.00659567e-01f, -3.73119898e-02f, -1.28045723e-01f, -4.14085127e-02f, 6.58894284e-03f, -1.09000213e-01f, -7.19100758e-02f, 1.10051103e-01f, 3.21242094e-01f, 7.49116316e-02f,
  1.50960207e-01f, 1.55138716e-01f, -1.94251791e-01f, -1.89860612e-01f, -1.44966751e-01f, -6.54756604e-03f, 6.01379462e-02f, 1.86020449e-01f, -4.48559523e-02f, 9.35922116e-02f,
  1.65735006e-01f, -2.73543596e-01f, 1.97154090e-01f, 6.82643652e-02f, 1.49256960e-01f, 1.92276523e-01f, -2.02523172e-02f, -1.44698927e-02f, -2.06006002e-02f, 2.21911103e-01f,
  -2.88569350e-02f, -9.24094319e-02f, 9.82666463e-02f, -1.12858817e-01f, -9.34641659e-02f, -1.21159673e-01f, -5.20395711e-02f, 7.59666860e-02f, -1.54239565e-01f, 2.04875350e-01f,
  8.64906907e-02f, -2.96245106e-02f, 1.54764801e-01f, -1.58682186e-02f, 2.18115393e-02f, 5.13182469e-02f, -1.70093358e-01f, -1.47249073e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.28255993e-01f, 2.74220198e-01f, 6.22956455e-02f, 2.70425621e-02f, 7.89705105e-03f, 1.77390024e-01f, 3.04276913e-01f, 1.22490115e-01f, -3.50545570e-02f, -2.62904167e-02f,
  2.18983695e-01f, 1.12298161e-01f, 7.98837170e-02f, -6.59262836e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -3.44633721e-02f, 4.72236611e-02f, -2.12052509e-01f, -2.35546112e-01f, -4.40446347e-01f, 4.45310563e-01f, -2.04211578e-01f, -1.91848800e-01f, 2.57747471e-01f, -3.18136334e-01f,
  -6.20590925e-01f, -2.28688747e-01f, 4.02036965e-01f, -1.19190007e-01f, 5.41508317e-01f, 5.82919233e-02f, 1.13292933e-01f, -6.81768134e-02f, -1.15803689e-01f, 4.49480563e-01f,
  -1.16992123e-01f, -4.93375435e-02f, -4.57605809e-01f, -6.32290170e-02f, 5.28600454e-01f, 1.15143560e-01f, 1.54193956e-02f, -6.71052456e-01f, 3.43750298e-01f, -1.08699553e-01f,
  4.39528339e-02f, -2.93590218e-01f, 2.74416238e-01f, -7.60867119e-01f, -2.29447529e-01f, 2.28591785e-01f, -3.24523777e-01f, -2.84511775e-01f, 3.52868944e-01f, 5.33907115e-01f,
  -2.26951122e-01f, 2.14946419e-01f, -3.81912917e-01f, 1.20524503e-03f, 3.30068439e-01f, -7.31904507e-01f, -7.64936864e-01f, -4.03472364e-01f, -3.35160315e-01f, -2.99947768e-01f,
  -3.46904546e-02f, 6.92631602e-01f, -2.65018612e-01f, 8.80971104e-02f, -4.65616882e-01f, 1.19550392e-01f, 4.33776528e-02f, 1.78761661e-01f, 7.37958699e-02f, -1.46888033e-01f,
  -1.09799290e-02f, 3.86406295e-02f, 5.00623941e-01f, 6.93587884e-02f, -3.46185833e-01f, -8.04701269e-01f, 2.69269288e-01f, 1.05090037e-01f, 5.35856843e-01f, -3.24704885e-01f,
  -5.99891484e-01f, -5.33614993e-01f, -1.42502606e-01f, 4.09316301e-01f, -4.49685067e-01f, -2.86465529e-02f, -1.46846965e-01f, 1.72998637e-01f, -2.87571037e-03f, -5.16345620e-01f,
  -4.63030457e-01f, -5.32366633e-01f, -7.98287094e-02f, 5.04976034e-01f, -3.02985013e-01f, 1.69495657e-01f, -8.50659311e-02f, 1.15836546e-01f, -2.55213678e-01f, -1.30613651e-02f,
  -5.01619056e-02f, -2.53568023e-01f, -4.60914493e-01f, 5.16710162e-01f, 1.66913465e-01f, 3.20469439e-01f, -1.87193438e-01f, -3.43560368e-01f, 1.18790358e-01f, -1.35931030e-01f,
  -2.03281775e-01f, 1.34948641e-01f, 2.83108175e-01f, 3.82129788e-01f, -6.71706796e-02f, -3.80277365e-01f, 1.38902187e-01f, -7.43718207e-01f, -4.83035088e-01f, 8.22620213e-01f,
  3.61501455e-01f, 2.60561079e-01f, 2.85063595e-01f, 3.97588670e-01f, -4.41730469e-02f, -5.21779835e-01f, 2.37941548e-01f, -1.47491872e-01f, 4.35294807e-01f, -1.10275954e-01f,
  -2.40926787e-01f, 1.08094223e-01f, 2.06729993e-01f, 4.19807643e-01f, 1.69561148e-01f, 9.83942579e-03f, -7.14848489e-02f, -3.43707465e-02f, -2.81642079e-01f, 3.46462905e-01f,
  4.22145575e-01f, 6.68236792e-01f, 3.32767278e-01f, 1.51097164e-01f, -2.57744372e-01f, -2.22673878e-01f, 2.56882012e-01f, -3.05738866e-01f, 6.52322114e-01f, 3.33527595e-01f,
  7.54177496e-02f, 3.66701245e-01f, 4.81622577e-01f, 4.14049894e-01f, 5.90871990e-01f, 2.56164074e-01f, -2.63298005e-01f, -1.70140833e-01f, -2.50919968e-01f, 8.61869380e-02f,
  7.34693229e-01f, -1.28795281e-01f, 4.02387492e-02f, -1.71465456e-01f, -3.05049509e-01f, 5.65346599e-01f, 2.07613543e-01f, 1.69473618e-01f, -3.21904391e-01f, -1.89277291e-01f,
  -9.12667662e-02f, 4.37343895e-01f, -4.96954709e-01f, 2.52163768e-01f, 2.24762559e-01f, 3.87892476e-03f, -3.39346677e-01f, -4.90623593e-01f, 9.67850685e-02f, -4.49199229e-02f,
  3.78800303e-01f, 4.03198421e-01f, 5.24986804e-01f, -8.05207312e-01f, 2.81567663e-01f, -3.00058395e-01f, 1.53025925e-01f, 4.43051428e-01f, -2.16240600e-01f, -1.82480201e-01f,
  -3.71208072e-01f, -1.16136879e-01f, 9.56094190e-02f, -6.86556324e-02f, 6.33723378e-01f, 1.21082522e-01f, -1.63266465e-01f, -7.72866979e-02f, 4.86700058e-01f, -4.16569263e-02f,
  -1.04279861e-01f, 1.17294580e-01f, 5.22561371e-01f, 3.12336594e-01f, 3.79706442e-01f, 4.73629355e-01f, 8.13965499e-01f, 4.70327735e-01f, 7.66516745e-01f, 5.39007127e-01f,
  2.84059912e-01f, 2.33734280e-01f, -6.29029870e-01f, 3.81029785e-01f, 2.07002401e-01f, 9.99934450e-02f, -1.62805110e-01f, 6.65992796e-02f, -2.07854211e-01f, -2.92046577e-01f,
  1.38902530e-01f, 2.91524768e-01f, -3.56673688e-01f, 4.89008054e-02f, 7.98079252e-01f, 8.65918696e-02f, -1.54422075e-01f, -2.50490725e-01f, -8.99760053e-02f, 2.53685057e-01f,
  -3.48389238e-01f, 1.27466112e-01f, 4.04837541e-03f, 1.48115948e-01f, -8.09077099e-02f, -1.84999123e-01f, 4.95560944e-01f, 1.56680033e-01f, 4.55505699e-01f, -5.85849047e-01f,
  -3.17764312e-01f, 1.56220077e-02f, -6.49357140e-01f, -3.66299242e-01f, 5.87178767e-01f, 1.87571943e-01f, -5.62043726e-01f, 1.95535526e-01f, 4.97390419e-01f, 5.08329868e-01f,
  6.07696295e-01f, 5.47655642e-01f, -1.81393728e-01f, -5.06321728e-01f, -2.99545825e-01f, -1.70666784e-01f, -5.35515428e-01f, 1.51143968e-01f, 3.39301676e-01f, 4.49499518e-01f,
  1.43647119e-01f, -3.53155524e-01f, 1.28875971e-01f, 4.04546298e-02f, 1.38714258e-02f, -1.36577144e-01f, -2.36504912e-01f, 5.82543969e-01f, -7.38786682e-02f, -4.84564900e-01f,
  -3.66308004e-01f, -1.42949551e-01f, -3.12633961e-01f, -2.33929634e-01f, 1.74955413e-01f, 1.66368872e-01f, 4.60411549e-01f, -5.89658201e-01f, -3.45686287e-01f, 1.55492365e-01f,
  -7.57686138e-01f, -3.81768882e-01f, -6.11586690e-01f, -4.58840996e-01f, 2.19567195e-01f, -3.07761997e-01f, 6.64688945e-01f, -1.31884497e-02f, -6.32033229e-01f, -8.13880414e-02f,
  -2.01099217e-01f, -5.66966198e-02f, -8.07025656e-02f, -2.03493640e-01f, -8.52860361e-02f, 3.36416245e-01f, -1.07218094e-01f, -3.48221569e-04f, 8.54162872e-02f, 9.28711593e-02f,
  -6.09721065e-01f, -1.19075790e-01f, -1.01293750e-01f, 6.54384732e-01f, -9.51615870e-02f, 2.93775201e-01f, 3.13073426e-01f, -4.33128625e-01f, -6.43128157e-01f, 4.38393086e-01f,
  6.17481351e-01f, -6.56308532e-01f, -2.25311264e-01f, 4.59617078e-01f, 6.81926727e-01f, -2.94679374e-01f, -1.56716302e-01f, 3.58382165e-01f, -1.70757309e-01f, 8.48575905e-02f,
  4.80429351e-01f, -7.48734251e-02f, 2.43504241e-01f, -3.05335611e-01f, -9.74192023e-02f, 2.28162259e-01f, -1.58274561e-01f, -2.21947461e-01f, 3.71271700e-01f, -6.22308962e-02f,
  2.64581501e-01f, 2.36658111e-01f, 2.04742327e-01f, 5.72356135e-02f, 3.77412811e-02f, -1.74407676e-01f, 4.53517325e-02f, -3.41902971e-01f, 2.98703015e-01f, 4.08502907e-01f,
  -4.87114042e-01f, -6.01022661e-01f, -3.59440714e-01f, 5.90635896e-01f, -5.92785060e-01f, -5.22758901e-01f, -6.92318618e-01f, -1.86451092e-01f, 4.43887174e-01f, -1.42029911e-01f,
  1.06346615e-01f, -1.05604470e-01f, 5.17044783e-01f, -5.79880783e-03f, -2.49575213e-01f, 8.50310698e-02f, -2.03931659e-01f, 4.87100482e-01f, -2.97033310e-01f, 1.62563726e-01f,
  -3.62270251e-02f, 6.12730384e-02f, 3.33381712e-01f, -4.37591016e-01f, -4.22339141e-01f, -3.92019182e-01f, -4.30332720e-01f, 3.14834088e-01f, 3.72380555e-01f, 2.54776120e-01f,
  -4.10731912e-01f, 1.61766008e-01f, 6.29579723e-01f, -1.71930879e-01f, 1.43815413e-01f, 1.52972877e-01f, 5.60126305e-01f, -2.99573004e-01f, -4.33809280e-01f, 2.76582092e-01f,
  2.91282743e-01f, -2.71341294e-01f, 7.29950607e-01f, -3.83956619e-02f, -3.93080935e-02f, -1.14916481e-01f, -2.09356979e-01f, -2.87889600e-01f, 1.38082892e-01f, -1.67809781e-02f,
  3.17597799e-02f, -2.03001484e-01f, 2.99180076e-02f, -1.05399258e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.32551253e-01f, 1.38105363e-01f, 1.84286520e-01f, -2.12397128e-02f, 8.90624002e-02f, -4.71146889e-02f, -8.93512070e-02f, 4.21716243e-01f, 1.00001194e-01f, 4.51123491e-02f,
  -4.69051823e-02f, -1.64620001e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    