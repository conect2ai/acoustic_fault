/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.68194766e-02f, 5.30464202e-02f, 1.38808534e-01f, -1.80623587e-02f, -1.81147009e-01f, 9.42604691e-02f, 9.87849012e-02f, -1.20907627e-01f, -2.19628230e-01f, 9.14253518e-02f,
  1.24091759e-01f, 4.83871065e-02f, 1.62713066e-01f, 1.29043534e-01f, 2.14864790e-01f, 2.26331681e-01f, 9.57321674e-02f, 6.99273944e-02f, -1.31713912e-01f, -9.29697305e-02f,
  -1.74389426e-02f, 4.19458151e-02f, 3.05526465e-01f, -5.53014427e-02f, 4.79350463e-02f, -1.15541495e-01f, 9.14265439e-02f, -4.44703251e-02f, 6.12347275e-02f, -9.83944535e-02f,
  -6.07176870e-02f, -2.07005382e-01f, 1.18704237e-01f, -5.00404127e-02f, -1.53410155e-02f, 3.05787623e-02f, 6.25739172e-02f, 1.70812067e-02f, -3.71853374e-02f, -2.17110738e-02f,
  2.17416082e-02f, -3.40640247e-02f, -1.39131080e-02f, -2.80530797e-03f, -3.78888007e-03f, -1.75850727e-02f, 3.91892791e-02f, 5.55043258e-02f, -1.61212832e-02f, 3.60401869e-02f,
  5.00666872e-02f, 5.42555265e-02f, 2.40813233e-02f, 8.66848323e-03f, 1.94680560e-02f, 3.39813740e-03f, 4.30898666e-02f, -9.77386298e-05f, 3.63834798e-02f, -1.44673111e-02f,
  1.33356666e-02f, -6.29090220e-02f, 3.23759690e-02f, -1.55970864e-02f, -4.69885543e-02f, 5.84840216e-02f, 8.35761987e-03f, 5.64087965e-02f, -8.45355075e-03f, 4.06153947e-02f,
  2.10076962e-02f, -1.56854801e-02f, -1.26016010e-02f, 4.42863666e-02f, 1.61355326e-03f, 2.60707606e-02f, 1.09985918e-02f, -4.87941429e-02f, 5.23442542e-03f, 5.35369404e-02f,
  -2.36853249e-02f, 7.96057750e-04f, 3.38626504e-02f, -9.03713331e-03f, -3.13785337e-02f, 4.85302657e-02f, -1.47611350e-02f, 1.03901587e-02f, 7.67468289e-03f, 4.02906798e-02f,
  -7.58992061e-02f, -2.91668743e-01f, -5.91960438e-02f, 1.97552424e-02f, 3.41275670e-02f, 4.54414599e-02f, -4.68097515e-02f, -6.07367186e-03f, 1.35786543e-02f, -1.67259090e-02f,
  3.47718783e-02f, -3.59070790e-03f, -4.80557978e-02f, -2.23213863e-02f, 5.71939722e-02f, 3.39162089e-02f, -2.71667447e-02f, -2.13530716e-02f, 3.27931605e-02f, -1.19407102e-02f,
  3.35228294e-02f, -4.56137732e-02f, 1.34182610e-02f, 1.75598059e-02f, -1.45780323e-02f, 2.17950195e-02f, -6.02865256e-02f, -7.17556775e-02f, 5.52413948e-02f, -1.77843254e-02f,
  -2.88686365e-01f, 6.80714622e-02f, -3.49730968e-01f, 7.45400637e-02f, 2.22825026e-03f, -1.43280119e-01f, -6.75304309e-02f, -2.22227331e-02f, -2.18366459e-02f, 9.30382833e-02f,
  4.36073430e-02f, -8.96688327e-02f, 4.99444939e-02f, -9.86235589e-03f, -1.14625223e-01f, -5.45657240e-02f, 6.45961463e-02f, 7.76726827e-02f, -6.79518515e-03f, 1.81393772e-01f,
  -3.30943167e-02f, 2.78990120e-01f, -1.03209309e-01f, 1.31904423e-01f, -1.63343996e-02f, -2.90265922e-02f, 1.88056558e-01f, -8.08027200e-03f, 1.32917892e-02f, -1.85046624e-02f,
  8.80463049e-02f, 3.27157825e-02f, -4.15659398e-02f, -3.13234255e-02f, 2.42828056e-02f, 5.95501922e-02f, -1.83527246e-02f, -3.50118540e-02f, 1.83857623e-02f, -2.12514531e-02f,
  4.19227406e-02f, -1.07817026e-02f, -6.16752468e-02f, -3.88096124e-02f, -4.88871001e-02f, -1.05130546e-01f, 7.32182246e-03f, 1.95833482e-02f, -8.34557787e-02f, -1.17993139e-01f,
  -3.73934843e-02f, -1.82958618e-02f, -1.32831391e-02f, -2.52822358e-02f, -7.48754963e-02f, -3.47942263e-02f, 7.35057704e-03f, -5.07772379e-02f, 1.44420937e-02f, 5.36228996e-03f,
  -9.38899964e-02f, 2.51764874e-03f, -1.70673933e-02f, -5.57291768e-02f, -1.96669549e-02f, 1.87000055e-02f, 5.40509224e-02f, -9.26952157e-03f, 4.33752164e-02f, -1.79119278e-02f,
  -4.05628700e-03f, -6.05230266e-03f, -3.48205343e-02f, -1.09296991e-02f, 7.60242417e-02f, -3.29096173e-03f, -3.53520960e-02f, -5.86828776e-03f, -2.17285249e-02f, -4.42286255e-03f,
  3.59723195e-02f, 2.04892755e-02f, 2.67539285e-02f, 3.96104269e-02f, -2.89551336e-02f, -5.32109700e-02f, 2.23423764e-02f, -2.81360932e-02f, 7.80929327e-02f, -7.61937052e-02f,
  2.80125290e-01f, 3.04433256e-01f, 1.09140314e-02f, 5.56141622e-02f, 4.32835221e-02f, -4.84319404e-02f, 1.58036090e-02f, -5.15225306e-02f, 9.62022226e-03f, 1.28821656e-02f,
  -5.27495099e-03f, 4.68894206e-02f, 8.99863467e-02f, 3.44084017e-02f, -3.36217636e-04f, 6.16588145e-02f, 1.13536924e-01f, 6.84517324e-02f, 4.71954681e-02f, 3.89173105e-02f,
  1.12458386e-01f, 1.00536579e-02f, -7.43349344e-02f, -6.46828189e-02f, 3.82179990e-02f, -4.36284207e-02f, -2.84493398e-02f, -8.64631534e-02f, 7.51212537e-02f, 5.84220588e-02f,
  -7.62351826e-02f, -7.13201761e-02f, -3.33713531e-01f, -1.25582233e-01f, -8.92702639e-02f, 3.12710166e-01f, 1.42920762e-01f, -2.16313630e-01f, -9.73320529e-02f, 1.35792613e-01f,
  6.40569255e-02f, 8.00425485e-02f, -3.83067154e-03f, 7.80331045e-02f, -6.09717742e-02f, 3.71115468e-02f, 8.55671316e-02f, 1.32819593e-01f, -7.26611093e-02f, 4.53611910e-02f,
  -2.07039610e-01f, 2.67824799e-01f, -2.03483254e-01f, 5.79441972e-02f, -4.05741781e-02f, -1.43962383e-01f, -5.28166741e-02f, 1.24395834e-02f, -1.36926234e-01f, 6.42582541e-03f,
  -6.95874449e-03f, -7.31492639e-02f, -1.09742083e-01f, -1.11932447e-03f, 6.13212697e-02f, 2.65144631e-02f, -2.98001356e-02f, 1.96625013e-02f, 1.73797254e-02f, 5.26754558e-02f,
  4.35490683e-02f, 3.06047164e-02f, 3.02185249e-02f, -2.97142891e-04f, 2.55054533e-02f, -9.26869139e-02f, -5.20588383e-02f, 2.73968978e-03f, -3.59213762e-02f, -1.50208101e-02f,
  -4.47303280e-02f, 1.09482068e-03f, -2.16008606e-03f, 1.17802974e-02f, -5.00010811e-02f, 3.44544463e-03f, 1.04231983e-01f, 4.54167873e-02f, -5.65930009e-02f, 3.53615358e-02f,
  8.31041932e-02f, 5.34482449e-02f, 1.09876785e-02f, -4.67616804e-02f, -3.57983895e-02f, 1.63311779e-03f, 9.50445421e-03f, 1.02765135e-01f, -7.04359189e-02f, 1.92321613e-02f,
  -2.32423637e-02f, -1.12478705e-02f, -5.56044169e-02f, 3.96359805e-03f, 4.19419929e-02f, 7.27636740e-02f, 5.99284619e-02f, 6.79484680e-02f, -2.16679145e-02f, -4.88489727e-03f,
  5.70592396e-02f, -8.89185369e-02f, -1.72153525e-02f, 5.22292778e-02f, -4.53062216e-03f, -2.19094399e-02f, -1.66032445e-02f, -5.57805598e-02f, -6.55200407e-02f, -3.57535444e-02f,
  1.14572123e-01f, 2.11857513e-01f, 1.85410623e-02f, 1.18560027e-02f, -1.21999551e-02f, 5.42260800e-03f, 4.12791595e-02f, -5.34883961e-02f, -6.21510074e-02f, -1.77306104e-02f,
  -5.54740475e-03f, 2.15951465e-02f, 3.99074331e-02f, 9.90228169e-03f, -4.58555184e-02f, -6.71084374e-02f, 1.82359535e-02f, 3.92750427e-02f, 9.14118588e-02f, 1.28361648e-02f,
  3.74678858e-02f, 6.91451281e-02f, 8.70327652e-02f, -4.08902280e-02f, 7.81716127e-03f, 9.76640135e-02f, 2.75802687e-02f, 1.28279310e-02f, 6.10670336e-02f, 1.90432314e-02f,
  5.07562399e-01f, 6.13279939e-02f, -6.51857331e-02f, 2.45872989e-01f, 1.43999517e-01f, -9.20008309e-03f, 1.14628971e-02f, 1.74851224e-01f, 1.81483492e-01f, 1.35071855e-02f,
  1.36249602e-01f, -4.07961570e-02f, -3.45807709e-02f, 1.53008848e-01f, 1.89362660e-01f, -3.23712863e-02f, 1.93504006e-01f, 9.52392817e-02f, 2.56231036e-02f, 1.64805532e-01f,
  1.16691478e-02f, 1.87495843e-01f, -7.80509505e-03f, -2.86837891e-02f, 9.60561037e-02f, -1.43089354e-01f, 4.74018604e-02f, -1.72185749e-01f, -4.53988947e-02f, -2.94942930e-02f,
  1.47106320e-01f, 4.84075435e-02f, 6.33432046e-02f, -1.09917767e-01f, 2.08725575e-02f, -8.95160623e-03f, -7.16806501e-02f, -6.21651374e-02f, 5.73537312e-03f, 1.17774960e-02f,
  -8.89654830e-02f, -4.89464924e-02f, 2.21958086e-02f, -5.75846396e-02f, -3.84364165e-02f, 4.34062677e-03f, 3.53347743e-03f, 6.94014307e-04f, 1.21642733e-02f, -1.50863174e-02f,
  -3.96268368e-02f, -2.84949187e-02f, 9.80168022e-03f, -7.49925375e-02f, -1.56209059e-02f, 7.36705260e-03f, -4.01376672e-02f, 5.83012309e-03f, 3.28945671e-03f, 2.85024699e-02f,
  4.55984659e-02f, -5.46530113e-02f, 8.18271656e-03f, 2.52720341e-02f, 4.55780551e-02f, -1.72562785e-02f, -4.60578091e-02f, 6.11936627e-03f, -2.52959449e-02f, 8.22240021e-03f,
  1.11636287e-02f, 3.63344629e-03f, -8.49139132e-03f, -7.08423853e-02f, -7.05484394e-03f, 8.72626528e-02f, -2.44556051e-02f, 1.98445823e-02f, 6.64869230e-03f, 4.77908703e-04f,
  2.71888711e-02f, -2.56086537e-03f, -1.19965803e-02f, -2.15694495e-02f, 3.41111943e-02f, 3.23762768e-03f, 2.56708823e-02f, 2.02662358e-03f, 5.47433943e-02f, -5.24594495e-03f,
  2.18260586e-02f, 7.78774992e-02f, -1.37110269e-02f, -1.00178560e-02f, -6.39106110e-02f, 4.65246662e-03f, 4.69170474e-02f, 6.13593832e-02f, -3.48504782e-02f, 6.13117814e-02f,
  -7.74772391e-02f, -3.35695893e-02f, 4.85069025e-03f, 3.76369283e-02f, 2.34128404e-02f, 2.74228901e-02f, 2.50069164e-02f, 5.28112166e-02f, 5.13006113e-02f, 4.97433590e-03f,
  4.40194942e-02f, -2.38998588e-02f, 3.48822996e-02f, 1.28062993e-01f, 5.74748442e-02f, -5.73983267e-02f, -2.99643073e-02f, -6.40301108e-02f, 1.68353431e-02f, -2.19124183e-02f,
  7.55114675e-01f, 1.23311326e-01f, 5.56945801e-02f, 2.54298240e-01f, 1.21301033e-01f, -1.34124234e-01f, -1.33643568e-01f, 3.78386341e-02f, 2.01103184e-02f, -1.16999678e-01f,
  -6.70700744e-02f, 1.09086938e-01f, -6.35162443e-02f, 4.26481180e-02f, -6.34854659e-02f, -1.04053594e-01f, 1.15174033e-01f, 8.97973701e-02f, 9.70385149e-02f, 2.15925142e-01f,
  9.04245004e-02f, 1.65210024e-03f, 7.04995617e-02f, 9.66827199e-03f, 1.33818984e-01f, 5.37901893e-02f, -4.56960984e-02f, -7.07330629e-02f, -4.30607535e-02f, -1.12721652e-01f,
  6.17797114e-02f, 1.19585589e-01f, 8.04555342e-02f, -4.04166542e-02f, 7.11581632e-02f, -2.66376287e-02f, -1.24539481e-02f, -1.10494860e-01f, -4.41815555e-02f, 2.40360051e-02f,
  4.10104804e-02f, 3.55359241e-02f, 4.28682454e-02f, -6.61170930e-02f, -6.37352094e-02f, 2.62107402e-02f, 1.65891852e-02f, 5.44933788e-02f, -4.60483842e-02f, 2.02211291e-02f,
  -1.85337979e-02f, 1.87852178e-02f, -1.04617318e-02f, -1.52358264e-02f, -5.50832413e-02f, -3.38427052e-02f, 4.97866757e-02f, -1.18998475e-02f, 5.40400334e-02f, -1.70894768e-02f,
  -5.88647053e-02f, -1.02024544e-02f, -3.89840864e-02f, 5.11463247e-02f, -7.45054409e-02f, -7.95826595e-03f, -3.38266008e-02f, 7.72768026e-03f, -6.77865893e-02f, 1.76968183e-02f,
  -3.78275625e-02f, 2.96451841e-02f, 2.13820506e-02f, -2.82895528e-02f, 3.41580287e-02f, -4.10424359e-02f, 2.30267067e-02f, 2.86478363e-02f, 1.34396960e-03f, 4.60281484e-02f,
  2.82466691e-03f, -1.82152819e-02f, 4.59767953e-02f, -5.98483533e-03f, -4.85654771e-02f, -5.39604053e-02f, 2.23413184e-02f, 1.02326591e-02f, 2.95579899e-02f, -9.48843360e-03f,
  -3.15162651e-02f, 7.04616904e-02f, -1.50444238e-02f, 1.54030537e-02f, -3.36596221e-02f, 1.44883329e-02f, 2.56785564e-02f, 3.11189052e-02f, -3.90949622e-02f, -1.89016797e-02f,
  -2.89718062e-03f, 3.74075137e-02f, -2.69212332e-02f, -2.31747841e-03f, -3.81584391e-02f, -1.59848705e-02f, 6.98527414e-03f, -1.34623526e-02f, 5.44111468e-02f, -4.62909276e-03f,
  6.21480346e-02f, -1.61025237e-04f, -3.98348533e-02f, 1.68706942e-03f, -1.45698516e-02f, -2.65187118e-02f, 1.30426632e-02f, 1.29902419e-02f, -1.89639311e-02f, 1.37855504e-02f,
  4.68062550e-01f, -1.92145213e-01f, 1.11036800e-01f, -8.11576545e-02f, 8.24693814e-02f, 2.57474363e-01f, 1.10358752e-01f, 1.43945394e-02f, 2.09108189e-01f, -2.38677174e-01f,
  -2.44047190e-03f, 9.88298561e-03f, -7.79888630e-02f, -1.38945058e-01f, 4.08663779e-01f, -1.76361099e-01f, -5.21654598e-02f, -1.58699110e-01f, -7.94014335e-02f, -8.93081576e-02f,
  -5.14279306e-02f, -9.47136581e-02f, -1.00801580e-01f, -1.41299129e-01f, -1.39307752e-01f, -2.65988242e-02f, -5.24591468e-02f, -6.11319914e-02f, -9.52038020e-02f, 9.13735405e-02f,
  -6.35617450e-02f, -1.30372629e-01f, 3.75663899e-02f, 2.11799536e-02f, 1.14709929e-01f, 4.21840250e-02f, -7.03042233e-03f, 2.30334774e-02f, 6.28812686e-02f, 2.16012192e-03f,
  3.99324996e-03f, -2.84370929e-02f, -2.99021769e-02f, 5.52076623e-02f, 3.61853912e-02f, -4.80310656e-02f, -3.50445919e-02f, -4.56237383e-02f, -6.01135753e-02f, -4.58036996e-02f,
  -1.12985000e-02f, 1.75061007e-03f, -2.98660658e-02f, -7.73750991e-02f, 7.47264549e-02f, -2.34070886e-02f, 2.83562150e-02f, -3.04816454e-03f, -4.73159105e-02f, 8.72710720e-02f,
  4.77022268e-02f, 5.54165728e-02f, -2.44433861e-02f, -4.50787731e-02f, -2.31496561e-02f, -1.90395229e-02f, 2.95737889e-02f, -3.92698944e-02f, 3.08434088e-02f, -4.23363782e-02f,
  4.90504354e-02f, 2.62713572e-03f, -1.28771691e-02f, 3.42628499e-03f, -2.38900334e-02f, 3.39396521e-02f, -6.12874422e-03f, -1.89986993e-02f, -3.99696343e-02f, 1.57912262e-02f,
  -3.36570153e-03f, 9.14021656e-02f, -4.41508591e-02f, 1.94671273e-03f, 4.40269373e-02f, 6.34006038e-02f, -3.91375758e-02f, 9.67851933e-03f, -6.64687157e-03f, -6.96523581e-03f,
  -3.20458636e-02f, 5.09179533e-02f, 3.35307829e-02f, 3.81923765e-02f, -7.63713792e-02f, 2.80725993e-02f, 2.71537732e-02f, 3.30761708e-02f, -1.83887407e-02f, 3.69654372e-02f,
  1.69392000e-03f, 1.22059770e-02f, 6.08105734e-02f, 8.56200606e-03f, 2.10806448e-02f, -1.52016981e-02f, -1.50786107e-02f, -9.92848072e-03f, 7.57585689e-02f, -4.51562516e-02f,
  -4.30207700e-02f, 8.76184925e-03f, -5.28533235e-02f, -5.91742760e-03f, -2.36686338e-02f, 3.98680195e-02f, 8.53801072e-02f, 1.66727789e-02f, 5.23668900e-02f, -8.11053906e-03f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.00857183e-01f, -9.12961736e-02f, 1.50056615e-01f, -2.88177487e-02f, -6.92074746e-02f, -1.01585448e-01f, -1.17374994e-01f, 1.50734084e-02f, -1.59172341e-01f, -1.44365638e-01f,
  -3.22479941e-03f, -4.22147773e-02f, 7.97851980e-02f, -7.33200386e-02f, 1.88986525e-01f, 9.37184915e-02f, 4.69841175e-02f, 9.48876813e-02f, 1.64493144e-01f, 7.55549371e-02f,
  1.35898188e-01f, -4.39971499e-02f, 2.51218855e-01f, 1.22008353e-01f, 1.25407010e-01f, 1.44936529e-03f, 5.48775196e-02f, 1.96541712e-01f, 8.95306244e-02f, 1.32974684e-01f,
  -1.02442436e-01f, -1.37379006e-01f, -6.07637390e-02f, 6.26055971e-02f, -3.27737629e-02f, 6.97367545e-03f, 5.49062565e-02f, -1.03675490e-02f, 5.18675037e-02f, -6.05607443e-02f,
  -3.84725071e-02f, 7.18046054e-02f, -2.62598470e-02f, -3.76503728e-02f, 3.81153226e-02f, 6.01910874e-02f, 1.11333616e-01f, 1.84478052e-02f, -7.91529417e-02f, 5.49331903e-02f,
  5.04114293e-02f, -1.79247512e-03f, 4.41491008e-02f, 7.90985525e-02f, -5.43080941e-02f, -1.20374570e-02f, -7.93185160e-02f, 4.88881953e-02f, -3.82178277e-02f, -1.84188582e-04f,
  -5.50044924e-02f, -3.42904031e-02f, 5.32682836e-02f, -7.25381495e-03f, 4.54614265e-03f, -6.70867413e-02f, 8.09682235e-02f, 3.91858779e-02f, -2.05196608e-02f, -8.02500173e-02f,
  3.88043933e-02f, 1.61062051e-02f, -5.07307425e-02f, -1.75554864e-02f, -2.70982757e-02f, -4.35630120e-02f, 7.44686946e-02f, -1.50890434e-02f, -6.04692809e-02f, -3.07448655e-02f,
  -7.62511045e-02f, -8.61112997e-02f, -3.74404117e-02f, 2.61265598e-02f, -2.37280317e-03f, 4.48729098e-02f, -5.49728796e-03f, -5.48126660e-02f, 5.49476109e-02f, -2.64800508e-02f,
  2.51622591e-02f, -1.13822473e-02f, -5.40996417e-02f, -9.68666747e-03f, 5.27796857e-02f, 1.32414466e-02f, -5.42691397e-03f, -1.15174605e-02f, 1.74020492e-02f, 4.91541587e-02f,
  -3.42538022e-03f, 7.86426514e-02f, 4.55594435e-02f, 5.31812944e-02f, -4.03837524e-02f, -7.32946470e-02f, -4.25260216e-02f, -6.17233850e-02f, 1.16161304e-02f, -2.98751574e-02f,
  -1.77989788e-02f, 6.44168034e-02f, 1.45655274e-02f, 8.94022174e-03f, 1.53026055e-03f, -5.29936627e-02f, 2.90157404e-02f, -4.41896990e-02f, 8.25724527e-02f, 8.14582314e-03f,
  -1.00606486e-01f, -7.61502469e-03f, 1.57673080e-02f, -7.88765252e-02f, 4.00442854e-02f, 1.26161158e-01f, -1.19269174e-02f, -8.90024006e-02f, -2.99534984e-02f, -1.98923107e-02f,
  -5.02086878e-02f, -3.90097909e-02f, 9.99959409e-02f, 9.20859873e-02f, 3.19809951e-02f, 6.38837963e-02f, -5.82615472e-02f, -8.76504555e-02f, 6.67733401e-02f, -3.87583207e-03f,
  7.22544119e-02f, 3.51066422e-03f, -3.44320922e-03f, -4.31941934e-02f, 3.57977375e-02f, -6.47306442e-02f, -1.95196420e-02f, 5.95909804e-02f, 2.54430510e-02f, 2.16328409e-02f,
  -7.64418095e-02f, -1.19264491e-01f, 8.04982111e-02f, 8.30591097e-03f, -5.78979403e-02f, 1.68415792e-02f, -7.14162067e-02f, 1.29906675e-02f, -3.86475399e-02f, 3.35546695e-02f,
  -9.65576470e-02f, -6.76082820e-02f, -2.37463508e-02f, -6.15592003e-02f, -2.16485448e-02f, 7.17876628e-02f, -8.64495616e-03f, -8.41387957e-02f, 5.23150265e-02f, 5.72681092e-02f,
  -4.89829667e-02f, -4.19077240e-02f, 3.49467881e-02f, -7.23048821e-02f, -4.27171253e-02f, 1.29433908e-02f, 3.25301439e-02f, 5.58527969e-02f, -6.21645786e-02f, -8.69625509e-02f,
  8.51482674e-02f, 2.39407960e-02f, 6.77921101e-02f, 1.60573721e-02f, -4.92415158e-03f, -1.96446050e-02f, 8.28112140e-02f, -6.35400563e-02f, 6.11740798e-02f, 1.43701967e-03f,
  -5.42704202e-02f, 5.80055527e-02f, 3.40593904e-02f, 5.97717687e-02f, -9.37401259e-04f, -6.00795560e-02f, 6.41567959e-03f, 5.48844188e-02f, 5.05316183e-02f, -2.53216643e-02f,
  -6.23838138e-03f, -4.08002436e-02f, 7.42404759e-02f, -7.00963885e-02f, 4.08986211e-02f, 1.54306358e-02f, -1.82262640e-02f, 1.95784010e-02f, 7.20417351e-02f, -1.13005871e-02f,
  -1.56142237e-02f, -1.74463838e-02f, 6.10675551e-02f, -9.11390781e-02f, 2.84833424e-02f, 1.02423644e-02f, -8.97831619e-02f, 6.56219125e-02f, -3.80876623e-02f, -2.13798247e-02f,
  5.18649034e-02f, -2.62024961e-02f, 6.56475574e-02f, 6.32509142e-02f, -8.51407349e-02f, 9.77927819e-04f, 4.30771261e-02f, -6.99801371e-02f, -2.11906675e-02f, 1.18022310e-02f,
  7.49206766e-02f, 6.36492902e-03f, 3.20924520e-02f, -3.73670273e-02f, 5.47970692e-03f, -4.75531630e-02f, -5.93882240e-02f, 4.51494493e-02f, -6.24798350e-02f, -4.25456427e-02f,
  -1.04406774e-01f, 4.60660197e-02f, 8.17016140e-02f, -1.37563169e-01f, 4.75429669e-02f, 1.29311979e-01f, 1.43583789e-01f, 2.70150993e-02f, 3.20854336e-02f, -1.52983880e-02f,
  -9.29211825e-02f, 6.29750341e-02f, 1.65199056e-01f, 4.84758802e-02f, 1.14751332e-01f, 1.10567115e-01f, 7.83150569e-02f, 5.77697577e-03f, 5.50961271e-02f, -5.37138283e-02f,
  -5.34985326e-02f, -5.83400428e-02f, 1.00951411e-01f, -5.90593927e-02f, -1.94943268e-02f, -1.14308245e-01f, -1.38978854e-01f, -4.54551242e-02f, -1.20583393e-01f, -2.51109488e-02f,
  8.81827697e-02f, 1.55616915e-02f, -3.49793322e-02f, 9.74394009e-02f, 8.72245133e-02f, 3.33195664e-02f, 2.29012184e-02f, -4.73503657e-02f, 8.19893274e-03f, 1.32851005e-02f,
  -5.85460775e-02f, 2.40887236e-02f, 1.50895510e-02f, 8.09564907e-03f, 3.58104743e-02f, -4.81621884e-02f, -1.21568637e-02f, 4.68566380e-02f, -3.39721292e-02f, 1.51230125e-02f,
  -3.76864336e-02f, 6.36067428e-03f, 3.51164266e-02f, -1.92591604e-02f, -3.09453942e-02f, -2.31448673e-02f, -3.69188040e-02f, 7.63322860e-02f, 6.29489720e-02f, 4.26536463e-02f,
  5.03180288e-02f, 3.83363105e-02f, -5.85261658e-02f, 1.49384588e-02f, 4.02161628e-02f, -1.07068298e-02f, -3.26369777e-02f, 1.28429988e-02f, 3.94097976e-02f, 7.55954385e-02f,
  -1.39075387e-02f, -6.05550855e-02f, 1.11127906e-01f, 1.42594669e-02f, -2.74218917e-02f, -8.67440626e-02f, -2.90663745e-02f, -4.69324477e-02f, -5.05891442e-02f, 6.06853329e-02f,
  2.39307098e-02f, -6.24719113e-02f, 7.23089352e-02f, -7.99846947e-02f, 5.33921160e-02f, -2.99283798e-04f, 2.18907949e-02f, 3.05563547e-02f, -1.70384869e-02f, -4.99031805e-02f,
  -4.28717136e-02f, -1.37549639e-03f, 4.06739637e-02f, 3.14622931e-02f, 2.16948316e-02f, -9.54559222e-02f, 7.68424869e-02f, 4.97110523e-02f, 4.06500734e-02f, 5.60233295e-02f,
  -7.04551265e-02f, 2.25268584e-02f, 2.43948046e-02f, -7.31540918e-02f, 5.14341854e-02f, -6.72217682e-02f, 2.42286250e-02f, 2.50306334e-02f, -5.74290082e-02f, 7.89567307e-02f,
  -9.28467792e-03f, -4.55289055e-03f, 3.67518775e-02f, 3.06026451e-02f, -1.49666350e-02f, -1.29295420e-02f, 6.38087839e-02f, -7.06535280e-02f, 3.11665908e-02f, 5.61075322e-02f,
  2.05812261e-01f, -1.53849870e-01f, -4.34685320e-01f, 1.26608193e-01f, -3.01050637e-02f, 2.28376508e-01f, 8.23814198e-02f, -5.05863316e-02f, -2.15612710e-01f, 1.07820384e-01f,
  1.29796773e-01f, -1.02397643e-01f, -2.44424909e-01f, 5.30991733e-01f, 2.43139982e-01f, 1.50170214e-02f, 4.19264227e-01f, 1.59623295e-01f, -1.39352724e-01f, -1.04319535e-01f,
  2.38903537e-02f, 3.70745957e-01f, 3.05902269e-02f, 8.44429880e-02f, 9.46240872e-02f, -1.61474794e-01f, 5.89298569e-02f, -2.62656301e-01f, 3.62014771e-01f, 2.17570394e-01f,
  1.64081946e-01f, -4.68731448e-02f, -6.71965182e-02f, 2.21504290e-02f, -1.33787319e-02f, 1.43981259e-03f, -5.75438142e-02f, -3.95093579e-03f, -6.34421855e-02f, -7.95437098e-02f,
  -3.77462283e-02f, 3.37596871e-02f, 1.30056530e-01f, -2.80708559e-02f, 3.99168879e-02f, 1.97662842e-02f, 8.39128718e-03f, -4.90821823e-02f, -8.82889703e-02f, 1.48201790e-02f,
  -9.81832966e-02f, -6.03896677e-02f, -6.84863999e-02f, -1.39960134e-02f, -1.39342740e-01f, 5.51437214e-03f, -2.17730105e-02f, -7.87298903e-02f, -5.50304875e-02f, 1.58637147e-02f,
  -2.73610018e-02f, -9.91018340e-02f, -1.65005401e-02f, 1.22946396e-01f, -2.70874742e-02f, 8.74329880e-02f, 3.57755721e-02f, -2.87453341e-03f, -1.70010198e-02f, 1.37888081e-02f,
  -4.60899770e-02f, 2.10684016e-02f, 1.89074967e-02f, 3.68072167e-02f, 1.75811592e-02f, -1.71973668e-02f, -2.24153474e-02f, 4.81868163e-02f, -5.13049141e-02f, 4.37213713e-03f,
  -4.70614843e-02f, -9.83600225e-03f, 1.20887505e-02f, 1.15623465e-02f, -4.36846577e-02f, -3.19724791e-02f, 2.29182057e-02f, 3.11915553e-03f, -1.85771642e-04f, -2.99040265e-02f,
  3.63763347e-02f, -2.63165295e-01f, 1.34845939e-03f, 6.83609992e-02f, -3.79926041e-02f, 1.46343093e-03f, -4.65664640e-02f, 2.43673399e-02f, 5.65145444e-03f, 8.38363357e-03f,
  5.49839251e-02f, 3.21850032e-02f, -1.44480597e-02f, 7.72723416e-03f, -2.40916926e-02f, 4.35418710e-02f, -7.23364875e-02f, -5.14435805e-02f, -2.39784047e-02f, -1.24959340e-02f,
  4.11377996e-02f, 3.81848253e-02f, -4.97634299e-02f, -1.78933609e-02f, 6.11368492e-02f, -2.58985627e-02f, -1.43882670e-02f, -1.63803995e-02f, -1.33230435e-02f, -1.78083312e-02f,
  3.03026646e-01f, 2.11565085e-02f, 1.37163565e-01f, 1.10316128e-01f, -1.01507545e-01f, -7.71035813e-03f, 7.37587586e-02f, -1.15239844e-02f, 3.79829109e-01f, -9.53821838e-02f,
  -3.22395079e-02f, 1.30416349e-01f, -1.23103708e-01f, -5.69065362e-02f, -4.98712547e-02f, -5.52277602e-02f, 2.75391378e-02f, 1.73902139e-02f, -6.76296577e-02f, 2.53555402e-02f,
  7.40958238e-03f, -2.36187235e-01f, -2.22985730e-01f, -2.51292318e-01f, -4.29715104e-02f, -5.10207973e-02f, -2.42434114e-01f, -2.06537843e-01f, -6.36277050e-02f, -1.43389553e-01f,
  6.56356961e-02f, 1.11978829e-01f, -3.54847163e-02f, 7.68914595e-02f, 2.13908963e-02f, -4.03868034e-02f, -7.17628896e-02f, -5.93186691e-02f, 1.79093890e-02f, 1.22602191e-02f,
  9.01341811e-02f, -3.71367559e-02f, 1.09695293e-01f, -1.48828691e-02f, -1.96680557e-02f, -2.20932881e-03f, 7.69412071e-02f, 5.53777777e-02f, 8.18066448e-02f, 2.58171409e-02f,
  7.49020576e-02f, -6.18060213e-03f, -4.91800234e-02f, -5.83969988e-02f, 1.89678017e-02f, -2.74788439e-02f, 4.13438715e-02f, -6.47879317e-02f, -7.83235878e-02f, 6.42148107e-02f,
  -5.40707558e-02f, -9.41081271e-02f, -5.44708855e-02f, -1.09887011e-01f, -2.25752704e-02f, 2.33309325e-02f, 1.80577505e-02f, -4.40515168e-02f, 1.29482105e-01f, 5.83596118e-02f,
  -4.37785946e-02f, -1.17151598e-02f, -3.97135168e-02f, 9.96473804e-02f, 2.83952393e-02f, -4.81245518e-02f, 4.61477786e-02f, -1.55169433e-02f, 5.37354015e-02f, -2.76385322e-02f,
  7.34865591e-02f, -2.29059607e-02f, -3.01633328e-02f, -3.60279121e-02f, -6.99528158e-02f, -2.26880871e-02f, -6.87031001e-02f, 5.40941171e-02f, -7.42435232e-02f, -5.02727553e-02f,
  1.23682281e-03f, -1.50269167e-02f, -7.06425682e-02f, 8.95255655e-02f, -4.00821194e-02f, -1.67609472e-02f, -3.60173814e-04f, 6.72066286e-02f, -1.35662658e-02f, -7.05367178e-02f,
  -1.04500666e-01f, -2.13612281e-02f, 9.60030481e-02f, -4.06481177e-02f, 5.75859472e-02f, 3.57434922e-03f, 7.01028109e-02f, 4.26573381e-02f, -9.23574567e-02f, -4.60809991e-02f,
  4.59857062e-02f, 2.11633388e-02f, 4.95786704e-02f, -6.30059093e-02f, 2.62979744e-03f, -2.44286610e-03f, 4.82468382e-02f, -2.38712728e-02f, 2.46468410e-02f, -6.20596148e-02f,
  -1.38007924e-01f, 3.51011865e-02f, 2.90266052e-02f, -9.08978581e-02f, 3.66911083e-03f, 1.78026497e-01f, 2.08858520e-01f, 1.70692261e-02f, 6.81861937e-02f, 2.05287308e-01f,
  1.54498927e-02f, -5.95787680e-03f, 2.48895232e-02f, 1.97662428e-01f, 9.90837961e-02f, 1.67546108e-01f, 1.65647462e-01f, 1.47803903e-01f, 6.06735274e-02f, 2.75221504e-02f,
  2.38249209e-02f, 2.04480570e-02f, -4.68268767e-02f, -9.95718092e-02f, -1.09771781e-01f, -1.75893068e-01f, -8.01505297e-02f, -8.64198282e-02f, -2.53395196e-02f, 9.29060206e-02f,
  7.06279799e-02f, -8.38008150e-02f, 6.66737854e-02f, -6.30920157e-02f, -6.85060993e-02f, -1.23455770e-01f, 8.74617323e-03f, 8.00020397e-02f, 5.91582581e-02f, 6.23995513e-02f,
  3.37642282e-02f, -2.99976077e-02f, 9.00234561e-03f, -1.09755091e-01f, -7.15275237e-04f, 3.67029347e-02f, -7.01263128e-03f, -5.93277207e-03f, 2.58172769e-03f, 4.10028622e-02f,
  1.90518815e-02f, 5.22018000e-02f, -4.09885794e-02f, 1.17828153e-01f, 2.64741126e-02f, -6.87788427e-02f, 1.01844668e-01f, -3.58354971e-02f, 4.85789105e-02f, -7.93077946e-02f,
  -2.29733512e-02f, -4.64130938e-02f, 8.53201523e-02f, -2.57190596e-03f, -5.14129102e-02f, -1.71485189e-02f, 7.61607811e-02f, 1.61440596e-02f, 6.98414519e-02f, 4.18930091e-02f,
  1.75310802e-02f, 2.10096408e-02f, -4.45007347e-02f, -4.31965515e-02f, -4.32737917e-02f, 4.64566536e-02f, -1.04216568e-01f, -1.70178637e-02f, 6.14839830e-02f, 7.24196732e-02f,
  5.24043897e-03f, -2.31976397e-02f, 6.30933866e-02f, 5.59077598e-02f, 1.01912573e-01f, -1.84315834e-02f, 3.96907553e-02f, -5.29817480e-04f, 2.23407224e-02f, 3.03816446e-03f,
  1.64214194e-01f, 6.09964579e-02f, -3.08191068e-02f, 3.22221741e-02f, -2.55679432e-02f, 2.69317050e-02f, -5.48771545e-02f, 4.98003364e-02f, -3.24205197e-02f, -2.64282022e-02f,
  -6.73924387e-02f, 2.11229622e-02f, 3.72667313e-02f, -5.52576371e-02f, 5.58282286e-02f, 3.24265733e-02f, -5.30879665e-03f, 8.90925005e-02f, 1.30554792e-02f, -4.42194529e-02f,
  4.16372903e-03f, 8.62920210e-02f, 2.75937226e-02f, 1.74260214e-02f, 2.54982095e-02f, -4.32574227e-02f, -6.93876203e-03f, -8.50140676e-02f, 5.36972955e-02f, 6.34417683e-02f,
  -1.07768454e-01f, -5.75353205e-02f, -1.73131377e-01f, -2.02536479e-01f, 1.05345109e-02f, -5.23103140e-02f, -3.03141952e-01f, -1.02968194e-01f, -1.43495187e-01f, -2.88899541e-01f,
  -1.29638612e-01f, -1.42906025e-01f, 5.40425964e-02f, -3.68788391e-01f, 1.89093307e-01f, 1.41948640e-01f, -1.40340611e-01f, -1.70962855e-01f, 7.88940042e-02f, -2.20069662e-01f,
  4.49219123e-02f, -2.22429037e-01f, 2.62962915e-02f, 2.71743480e-02f, -1.88317597e-01f, -1.84232071e-01f, 2.86746714e-02f, 3.15601081e-02f, -1.31364480e-01f, 1.04636364e-01f,
  4.88578826e-02f, -1.09318398e-01f, -2.00963039e-02f, -6.96035996e-02f, -1.32546499e-02f, -1.21820311e-03f, -1.90612450e-02f, 5.30788712e-02f, 2.08375659e-02f, 5.86373284e-02f,
  -1.01723649e-01f, 2.83579193e-02f, 5.78343216e-03f, -2.69489698e-02f, 3.67192701e-02f, -9.59831178e-02f, 1.08929902e-01f, 1.86132193e-01f, -1.40051963e-02f, 1.79021936e-02f,
  4.13332917e-02f, 5.85985892e-02f, -6.06069006e-02f, -3.02444212e-03f, 8.33337232e-02f, -1.91624742e-02f, 7.27412179e-02f, -6.06447831e-02f, 7.59593323e-02f, -3.71525809e-02f,
  -7.64973611e-02f, -2.04895064e-03f, -3.62442285e-02f, 1.27111319e-02f, 6.25773612e-03f, -6.28527179e-02f, -1.93285905e-02f, -2.40155845e-03f, -3.36808823e-02f, -4.28727008e-02f,
  5.78632578e-03f, -2.77575292e-02f, -1.25386149e-01f, -2.59738206e-03f, -9.99475047e-02f, -3.97769362e-02f, -7.66857564e-02f, 9.16285161e-03f, 1.22687193e-02f, 8.04826170e-02f,
  9.52568129e-02f, 2.69811954e-02f, -1.64584033e-02f, -1.26278782e-02f, 5.28605538e-04f, -6.66255713e-04f, 2.92832050e-02f, 2.84490045e-02f, 3.30307558e-02f, -6.85397908e-02f,
  4.87933233e-02f, -7.78678507e-02f, 6.34259135e-02f, 5.01932539e-02f, 5.32344207e-02f, 6.21688776e-02f, -3.35217948e-04f, -4.99892049e-03f, -5.45349270e-02f, -5.13789319e-02f,
  -1.03678375e-01f, -1.07114604e-02f, 5.71833439e-02f, 3.39452643e-04f, 3.03833559e-02f, -8.10782239e-02f, -1.09542869e-01f, 4.91882674e-03f, -1.43444249e-02f, 9.58993807e-02f,
  -2.07999013e-02f, 6.62259981e-02f, -6.23440854e-02f, -1.13038786e-01f, -3.99652906e-02f, -1.00551657e-01f, -5.04990853e-02f, -3.01028527e-02f, -1.76069383e-02f, 2.17728666e-03f,
  2.35222310e-01f, -8.47749561e-02f, 1.63764164e-01f, 8.00567567e-02f, 8.06300789e-02f, -8.96983072e-02f, -1.09383233e-01f, 3.99018079e-02f, 1.18592054e-01f, -1.20849192e-01f,
  -1.15194023e-01f, 7.64655992e-02f, 2.75404714e-02f, -7.91780874e-02f, 1.23928256e-01f, 8.67540017e-02f, 5.11412546e-02f, 4.64643724e-02f, 3.64894345e-02f, -4.30777632e-02f,
  1.70658350e-01f, -8.57648104e-02f, -2.96083614e-02f, -1.16254658e-01f, -9.14978608e-02f, 3.04326806e-02f, -8.99304301e-02f, -1.45952161e-02f, -8.02963674e-02f, -8.90045017e-02f,
  1.17715122e-02f, 6.46653995e-02f, -4.75273468e-02f, -2.41388232e-02f, 1.08574536e-02f, -5.04980683e-02f, -9.53268856e-02f, 3.06066293e-02f, -1.96794588e-02f, -4.64768559e-02f,
  -9.13579296e-03f, -8.32116604e-02f, 5.50363474e-02f, -1.23771187e-02f, 6.12352453e-02f, 2.44438592e-02f, 5.67213073e-02f, 1.97759066e-02f, -5.00134714e-02f, -1.71533879e-02f,
  2.27770582e-02f, -5.56661934e-02f, 7.93636665e-02f, -4.26336154e-02f, 3.71448137e-02f, 5.75360283e-02f, 3.45096067e-02f, 5.71918972e-02f, -2.46427935e-02f, -5.02404049e-02f,
  3.09771392e-02f, 7.64493570e-02f, 6.48088232e-02f, -2.84975097e-02f, 4.35335860e-02f, -9.70946345e-03f, 2.85515765e-04f, 7.40728155e-02f, 9.10002962e-02f, -4.99914177e-02f,
  1.20734153e-02f, 2.09668018e-02f, -2.64669098e-02f, -8.45897198e-02f, 6.56060651e-02f, 4.82550822e-02f, -2.99109891e-03f, -1.95906665e-02f, -4.32854481e-02f, -4.87808809e-02f,
  -4.32547741e-02f, -1.41177634e-02f, -1.78844072e-02f, -1.97142754e-02f, -3.61390784e-02f, -2.78397882e-03f, -9.54000428e-02f, 1.06562063e-01f, 6.95340633e-02f, -2.72103846e-02f,
  -1.29633129e-01f, -5.71837723e-02f, -3.37630585e-02f, -1.14609405e-01f, -3.96632180e-02f, -6.86873645e-02f, 5.43338321e-02f, -6.16442002e-02f, 7.62133747e-02f, 1.03488281e-01f,
  2.86104102e-02f, 3.15611772e-02f, -2.51473468e-02f, 1.72222406e-02f, 3.56462151e-02f, 5.86110093e-02f, -5.73732071e-02f, -1.76759996e-02f, -1.48792833e-01f, 9.37955305e-02f,
  2.35063713e-02f, -8.47675279e-02f, -8.32341053e-03f, -3.11763957e-02f, -5.36616556e-02f, 4.09492664e-02f, -3.62213776e-02f, 7.41682947e-02f, 2.89583039e-02f, -1.50098056e-02f,
  1.45869059e-02f, 4.30591218e-02f, -7.09944125e-03f, -4.79780436e-02f, -2.34340550e-03f, -1.89518869e-01f, -1.98065817e-01f, -7.46246353e-02f, 6.31819516e-02f, 4.28322814e-02f,
  -6.75866827e-02f, 1.90968975e-01f, -5.01738153e-02f, -2.20512040e-02f, -3.85262333e-02f, -7.56219625e-02f, -4.58687693e-02f, -3.34766246e-02f, 1.21859647e-01f, 4.28617299e-02f,
  5.79613447e-02f, -9.49264765e-02f, 2.76429839e-02f, -8.34437907e-02f, -1.37867611e-02f, 1.14922874e-01f, 1.40145063e-01f, -6.49234056e-02f, 2.75940225e-02f, 1.25105083e-02f,
  5.70134334e-02f, -6.40384201e-03f, 1.00013480e-01f, -3.23072798e-03f, -2.07009427e-02f, -1.19951889e-02f, -5.82642294e-02f, -4.74322811e-02f, -9.79781672e-02f, 6.51681572e-02f,
  1.22166686e-01f, 7.01717138e-02f, 3.76849249e-02f, 5.74846705e-03f, 7.41633326e-02f, 8.56639296e-02f, 2.35297177e-02f, -3.30277458e-02f, 3.09136808e-02f, 1.07694283e-01f,
  9.48271006e-02f, -2.75659654e-02f, 6.97837919e-02f, -5.59862480e-02f, 4.08904515e-02f, 4.28740047e-02f, -6.35456294e-02f, -1.14743896e-02f, -5.71763217e-02f, 9.60927363e-03f,
  -1.30436104e-02f, -6.34793565e-02f, 1.70429703e-03f, 7.58965164e-02f, -2.57407669e-02f, 5.12731932e-02f, 1.58366542e-02f, 4.58507892e-03f, 8.18416849e-02f, -3.42754535e-02f,
  -2.14611646e-03f, -5.64411050e-03f, -6.48899004e-02f, 3.04212477e-02f, -2.12420169e-02f, -2.99827685e-03f, -2.10340787e-02f, 1.62124187e-02f, 1.13152778e-02f, -3.42576019e-02f,
  -2.34683827e-02f, 3.72641087e-02f, -3.76153663e-02f, -5.92667796e-02f, -7.04887286e-02f, 1.42097166e-02f, 2.06260253e-02f, 7.06105605e-02f, 1.58118233e-02f, -1.52271222e-02f,
  4.07487415e-02f, -9.14530531e-02f, -7.39743039e-02f, 5.33156516e-03f, -8.17268193e-02f, 6.64902329e-02f, 2.07029395e-02f, -2.83326469e-02f, -4.60089147e-02f, -1.09655000e-01f,
  -9.58131067e-03f, -6.95316717e-02f, -1.77735239e-02f, 2.69043315e-02f, -1.92802679e-02f, 5.24147525e-02f, -2.13520024e-02f, -7.49397054e-02f, -1.76254157e-02f, 8.06895196e-02f,
  4.75310422e-02f, 7.25425258e-02f, 5.80073521e-02f, 5.71971647e-02f, -9.56014991e-02f, 3.54734510e-02f, -7.70624578e-02f, -3.51930819e-02f, 5.29924259e-02f, 5.02713397e-02f,
  4.18989435e-02f, 4.48813848e-02f, 9.64672938e-02f, -9.08671468e-02f, -4.55735885e-02f, -2.75192559e-01f, -1.30876109e-01f, 2.03703921e-02f, 5.04778884e-02f, 1.82821959e-01f,
  -8.45403522e-02f, 1.67110160e-01f, -3.38383429e-02f, -6.91555962e-02f, -2.51170039e-01f, -1.61599144e-01f, -2.61216640e-01f, 1.07303392e-02f, -1.24113135e-01f, -6.45676851e-02f,
  -2.29733348e-01f, -1.09683231e-01f, -1.68649152e-01f, -1.95141673e-01f, 1.99331511e-02f, 2.19510142e-02f, 3.48549485e-02f, -9.84989330e-02f, -1.04896361e-02f, -3.93499341e-03f,
  1.32861203e-02f, 2.16415018e-01f, 1.18855201e-01f, 9.78775397e-02f, 1.26912314e-02f, 1.73045788e-03f, -8.88918042e-02f, 1.67225115e-02f, 3.44864242e-02f, -2.28854967e-03f,
  7.14931414e-02f, 1.60245912e-03f, -1.84169207e-02f, -6.03531254e-03f, -6.61356375e-02f, 5.55024035e-02f, 1.35474084e-02f, -9.89074353e-03f, -4.44768742e-02f, -9.04755518e-02f,
  -5.27267866e-02f, 2.91876117e-04f, -7.59986416e-02f, 6.54000118e-02f, -1.50448401e-02f, 5.82316034e-02f, 5.60832582e-02f, 1.05233103e-01f, 5.50585939e-03f, 5.10370210e-02f,
  -5.26584163e-02f, 1.67708080e-02f, -8.04732963e-02f, 3.86972353e-02f, 5.83023299e-03f, 2.77416874e-02f, 2.17892248e-02f, 4.96819019e-02f, 4.17892002e-02f, -6.82784710e-03f,
  3.38226743e-02f, 2.95977984e-02f, -4.59890254e-02f, -1.26304165e-01f, -9.04217586e-02f, 7.60224536e-02f, 6.42088999e-04f, 7.28052557e-02f, -7.86795169e-02f, 5.78171574e-02f,
  2.97138380e-04f, 5.06799482e-02f, -1.13237733e-02f, 1.66888647e-02f, 4.37645763e-02f, 3.51046734e-02f, 4.64402884e-02f, -4.92772534e-02f, -1.56330150e-02f, -1.32149652e-01f,
  -7.57756531e-02f, -4.99948040e-02f, 6.65009618e-02f, 9.68278423e-02f, 2.23799283e-03f, -5.05612791e-03f, 2.35306751e-03f, -4.32101414e-02f, 2.81160288e-02f, -5.60371764e-02f,
  -6.74197450e-02f, 5.46298213e-02f, 1.80417817e-04f, 4.02433090e-02f, -9.36914310e-02f, -9.43806991e-02f, 4.90783453e-02f, 9.36268419e-02f, 1.79854576e-02f, -3.43541056e-02f,
  -5.48320562e-02f, 6.89965412e-02f, -7.04830186e-03f, -6.63805455e-02f, -5.02821393e-02f, 7.30102286e-02f, -4.32776008e-03f, 5.85306622e-02f, 6.35723099e-02f, -6.54169777e-03f,
  1.71752885e-01f, 1.67837515e-01f, 1.01682469e-01f, 1.17375828e-01f, -9.63618606e-02f, -1.40548676e-01f, -1.42392620e-01f, -1.47401467e-01f, -3.12195290e-02f, -8.46683383e-02f,
  -1.79010272e-01f, 4.21281129e-01f, -1.77608430e-01f, 2.13433474e-01f, 3.39017659e-02f, -6.17251620e-02f, 7.14916512e-02f, 1.40829533e-01f, 5.21297008e-02f, 1.59523496e-03f,
  8.81935507e-02f, -1.58483446e-01f, 1.87426016e-01f, 4.54434343e-02f, 1.95040181e-01f, 1.46420360e-01f, 7.01748282e-02f, -4.20764945e-02f, 5.39256446e-02f, 1.47780374e-01f,
  -5.85390739e-02f, -1.33776059e-02f, 6.21155687e-02f, -1.55139081e-02f, -1.21505566e-01f, 6.03865422e-02f, 8.27205405e-02f, 6.53612465e-02f, 6.43643960e-02f, 3.54347490e-02f,
  4.07352448e-02f, 2.26969216e-02f, 8.56499188e-03f, -7.75325671e-02f, 9.00390651e-03f, -7.69195394e-05f, 3.39778326e-02f, 3.59784886e-02f, 1.22090362e-01f, 3.11070457e-02f,
  4.99864332e-02f, 7.31529146e-02f, 5.80649218e-03f, 3.03453747e-02f, 1.09454252e-01f, -1.01485133e-01f, 5.62757216e-02f, 7.26097971e-02f, -1.12342471e-02f, 6.69341460e-02f,
  2.36808993e-02f, -5.61826862e-02f, 1.61730722e-02f, -3.96668911e-02f, -3.69360372e-02f, 4.70494293e-03f, -2.46458612e-02f, -7.99122453e-03f, 4.72878059e-03f, -8.76476020e-02f,
  -3.71376239e-02f, 3.71895283e-02f, -1.90696716e-02f, -2.47315280e-02f, -8.52441937e-02f, 8.47067777e-03f, 7.64346346e-02f, -3.23830880e-02f, 3.98259982e-02f, 6.03335164e-02f,
  -3.56751010e-02f, -1.02522604e-01f, 4.93564047e-02f, 7.76599050e-02f, -5.92987165e-02f, -5.47188483e-02f, -1.56035379e-03f, -5.36413454e-02f, 6.21604882e-02f, -9.99112427e-03f,
  -1.81814224e-01f, -2.78284699e-01f, 5.77525049e-02f, -3.31529230e-02f, 5.33583947e-02f, 3.87452617e-02f, -3.58179095e-03f, -6.34210696e-03f, 2.16981471e-02f, -3.07286773e-02f,
  -4.31487672e-02f, -2.73051988e-02f, -5.65391295e-02f, 7.66442642e-02f, -4.48808894e-02f, 2.24080011e-02f, -7.47933909e-02f, -2.01377943e-02f, -2.39161402e-02f, -5.06663695e-02f,
  -4.91749682e-02f, -5.84324412e-02f, 3.54472324e-02f, 3.73298340e-02f, -1.20580452e-03f, 5.18583320e-02f, 6.14431687e-03f, -1.45102190e-02f, 2.71539055e-02f, 2.75912639e-02f,
  3.07682484e-01f, -2.21095890e-01f, 1.24237277e-01f, -1.33173419e-02f, 6.52705207e-02f, 4.10226807e-02f, 2.69615978e-01f, -2.27146178e-01f, -1.38692409e-01f, -1.38881534e-01f,
  3.36616486e-02f, 6.07139431e-02f, 1.23578027e-01f, -4.72035706e-02f, 2.26067916e-01f, 5.61033636e-02f, 1.67069621e-02f, 5.73510341e-02f, -1.68489888e-02f, -8.73724073e-02f,
  6.84603974e-02f, -6.79634092e-03f, 1.85178712e-01f, -7.86632672e-02f, 1.17488123e-01f, 8.92981701e-03f, -2.83400137e-02f, 1.22174054e-01f, -3.08686122e-02f, 9.82769057e-02f,
  1.18801571e-01f, -1.40298344e-02f, 3.74360345e-02f, 1.79688185e-02f, 2.35640295e-02f, 9.01947394e-02f, 1.44359052e-01f, 1.35902688e-01f, -6.45891577e-02f, -5.85214011e-02f,
  2.07240321e-02f, 3.87316272e-02f, -1.17814220e-01f, 7.92802870e-02f, -2.74160448e-02f, 2.62754085e-03f, -9.80074890e-03f, 7.53335701e-03f, -7.80633986e-02f, 9.29114223e-02f,
  7.02156639e-03f, -5.93288168e-02f, 8.98408107e-05f, 2.29785163e-02f, -2.50313506e-02f, -6.77805245e-02f, -2.08712928e-02f, 1.25565410e-01f, -5.06946221e-02f, -1.41136378e-01f,
  -1.18827829e-02f, -1.86322480e-02f, 3.09252366e-02f, 1.13574159e-03f, 2.62778811e-02f, -1.39255032e-01f, 3.56965214e-02f, 3.04341782e-02f, -3.37781757e-03f, 5.26104979e-02f,
  9.11280606e-03f, -1.45808291e-02f, -4.44638692e-02f, -6.60215840e-02f, 1.34540210e-03f, -3.94756570e-02f, 2.72963736e-02f, -5.45070358e-02f, -4.47413512e-02f, -1.79051589e-02f,
  1.93835963e-02f, 5.03201550e-03f, 4.52332618e-03f, 1.03416249e-01f, -1.11873923e-02f, -3.89976352e-02f, -2.43322439e-02f, -5.89615218e-02f, -8.08565617e-02f, 1.05406299e-01f,
  -8.23153704e-02f, -1.68313816e-01f, -5.62079363e-02f, 2.42997576e-02f, 2.01610755e-02f, 3.18854339e-02f, 8.08461308e-02f, 3.91931552e-03f, 2.18330268e-02f, 1.88004859e-02f,
  -5.95112592e-02f, 3.26005854e-02f, -1.56997163e-02f, 4.77042273e-02f, -3.87510881e-02f, -4.03312407e-02f, 6.94755763e-02f, -1.61108319e-02f, -5.83251342e-02f, -6.05350360e-02f,
  -3.29630263e-02f, 5.46171553e-02f, -8.42186809e-03f, -1.22898228e-01f, -9.06703323e-02f, 7.65066454e-03f, -9.84663144e-02f, 5.83166108e-02f, -2.70175170e-02f, 9.27894004e-03f,
  -1.67066649e-01f, -7.78253004e-02f, -1.14339426e-01f, -1.95546657e-01f, 5.28436340e-02f, -1.47080421e-01f, -1.97080776e-01f, -4.69318591e-02f, 1.57515034e-01f, 8.53086635e-02f,
  -6.96645454e-02f, 9.36498493e-02f, 1.11772448e-01f, -1.92102626e-01f, 7.63469143e-03f, 4.18377258e-02f, -1.73786715e-01f, -1.49022520e-01f, -3.08555774e-02f, -1.08604454e-01f,
  -3.44013050e-02f, -9.85998362e-02f, -1.85899913e-01f, 1.75773911e-02f, -1.66204467e-01f, 7.57787153e-02f, 2.22340263e-02f, 1.07528515e-01f, -1.18281037e-01f, 8.13905895e-02f,
  3.59172411e-02f, 1.84909269e-01f, 5.92349656e-03f, 4.77921069e-02f, -8.26835036e-02f, -2.85019279e-02f, 1.39666852e-02f, 5.55605181e-02f, 3.20599899e-02f, -4.23814021e-02f,
  -2.67869029e-02f, -7.70620583e-03f, -2.00108509e-03f, -6.02822080e-02f, 4.04066704e-02f, 6.43974692e-02f, -5.05955890e-02f, -5.32046668e-02f, -5.87608889e-02f, -1.17310397e-01f,
  -1.05423093e-01f, -9.58120003e-02f, -9.98711586e-03f, -1.95200592e-02f, -8.65228176e-02f, 7.38981441e-02f, -4.57065105e-02f, 9.71062630e-02f, 3.35076675e-02f, -2.26744823e-02f,
  4.97833379e-02f, -5.24013899e-02f, 3.05495840e-02f, -2.99065392e-02f, 7.94305815e-04f, 9.25833583e-02f, -1.66001469e-02f, 1.02245532e-01f, -5.81086054e-02f, 1.61772426e-02f,
  2.68082451e-02f, -2.02160776e-02f, 8.27954784e-02f, -8.65435824e-02f, -1.30593954e-02f, 8.16471502e-02f, -4.60887253e-02f, 9.74093676e-02f, -1.05159245e-01f, -8.51486772e-02f,
  1.01650134e-03f, -4.75573428e-02f, 2.38081496e-02f, -2.91164238e-02f, 4.72938940e-02f, -2.08648667e-03f, 5.56190982e-02f, -3.78499203e-03f, -7.31434068e-03f, -4.06049863e-02f,
  -1.11558095e-01f, 1.09195933e-01f, 5.92026301e-02f, 5.66159002e-02f, 5.81315197e-02f, -2.42267605e-02f, 4.35224408e-03f, -3.73035893e-02f, 2.72328462e-02f, 1.52893513e-02f,
  -7.72153661e-02f, -3.20912413e-02f, -2.46602818e-02f, 7.34341592e-02f, -4.01736125e-02f, 3.77191068e-03f, -5.85961789e-02f, 2.66116988e-02f, 1.01430370e-02f, 5.81962056e-03f,
  4.96769659e-02f, -1.18239149e-02f, -2.79927682e-02f, 1.87735409e-02f, -1.43642249e-02f, -5.85781112e-02f, 5.86965382e-02f, -6.20747101e-04f, 3.37981954e-02f, 7.71007389e-02f,
  2.02889089e-02f, 1.74261704e-01f, 1.58326533e-02f, 1.55162334e-01f, -5.85535541e-02f, -8.97287577e-02f, -5.95097877e-02f, 4.23361510e-02f, 9.90890190e-02f, 1.37103006e-01f,
  1.85911264e-02f, 1.17758401e-01f, -7.61399567e-02f, -2.30586939e-02f, -2.43930161e-01f, -1.25738457e-01f, -1.05014510e-01f, 7.14523792e-02f, 5.96843176e-02f, -1.99304670e-02f,
  -1.55419052e-01f, -1.45145267e-01f, -8.63373056e-02f, -4.58986685e-02f, 7.15591311e-02f, 1.13352537e-02f, -1.08806022e-01f, 1.07397437e-01f, -1.41099691e-02f, 1.66523457e-02f,
  -4.84732985e-02f, 7.31756836e-02f, 3.62078361e-02f, -2.07409225e-02f, -9.75834019e-03f, 6.81721512e-03f, 2.21191868e-02f, 5.19647710e-02f, -4.13421132e-02f, -6.83716685e-02f,
  7.98003078e-02f, 7.72962719e-02f, -6.69176131e-03f, 9.85793397e-03f, 9.32293162e-02f, 2.48449277e-02f, 5.15395142e-02f, 7.88363144e-02f, -3.64073105e-02f, -3.01902704e-02f,
  3.83439958e-02f, -8.69423989e-03f, 9.20947082e-03f, -8.44724197e-03f, -1.00777693e-01f, -1.09543027e-02f, 1.07060112e-01f, -3.63864042e-02f, 3.71778235e-02f, 8.57323259e-02f,
  -3.29248011e-02f, 3.70918214e-02f, -3.43677076e-03f, -3.71989273e-02f, -8.28231871e-02f, -1.81103498e-02f, 2.61912718e-02f, 3.11271679e-02f, -5.87220304e-02f, -8.34958181e-02f,
  -1.43548511e-02f, -4.24873047e-02f, -2.05550645e-03f, 2.58064140e-02f, 1.05507597e-02f, -2.91042179e-02f, -4.63402681e-02f, 5.84406555e-02f, -7.19624236e-02f, -8.23775902e-02f,
  -1.55464781e-03f, 2.53093373e-02f, 3.56583185e-02f, -7.39586679e-03f, -4.32065688e-02f, -9.34173167e-03f, -3.25943008e-02f, -1.25338770e-02f, -2.64953170e-02f, 5.30905230e-03f,
  -1.08223381e-02f, 4.60521616e-02f, -7.00909793e-02f, 2.13055201e-02f, -5.04520535e-02f, 1.63676254e-02f, -1.60878580e-02f, 6.44258261e-02f, -2.00910051e-03f, 2.68976297e-02f,
  -7.86718447e-03f, 2.52199676e-02f, 3.57552868e-04f, -6.82169050e-02f, 8.94789696e-02f, 1.71187632e-02f, -1.57374563e-03f, -1.08702764e-01f, 6.37016594e-02f, 8.08291510e-02f,
  3.62067632e-02f, 2.14214679e-02f, -3.45548354e-02f, 1.09062549e-02f, -9.62608233e-02f, -3.41087133e-02f, 3.03921197e-02f, 6.51117123e-04f, 5.67718931e-02f, -9.11600608e-03f,
  6.51425943e-02f, -8.56357813e-02f, -4.45665643e-02f, 4.76848474e-03f, 1.08587533e-01f, -4.34834398e-02f, 5.30139729e-03f, -7.72830695e-02f, 6.69244025e-03f, 2.46562418e-02f,
  -6.66190963e-03f, -1.11572139e-01f, -9.38919261e-02f, 6.03467934e-02f, -1.14968583e-01f, -6.50863051e-02f, -6.53816713e-03f, -6.27622241e-03f, -4.30369973e-02f, -9.89990309e-03f,
  2.80875224e-03f, 1.22936532e-01f, -7.37954155e-02f, 1.09036088e-01f, 1.07251264e-01f, 1.54125905e-02f, 3.56910750e-04f, 8.81666318e-02f, -9.55878496e-02f, -8.77668336e-02f,
  -7.21778348e-02f, -3.87055427e-02f, 6.72289683e-03f, -2.84206960e-02f, 4.73175496e-02f, -2.32800711e-02f, 4.51497473e-02f, -5.35727590e-02f, -3.61266024e-02f, 5.43826409e-02f,
  8.30521993e-03f, 2.08044332e-02f, -9.10834223e-02f, -6.21010475e-02f, 1.63168143e-02f, -7.01126382e-02f, -3.51789482e-02f, -3.55362073e-02f, -5.64406477e-02f, -4.55938950e-02f,
  -8.71753767e-02f, -5.04704267e-02f, 8.48381445e-02f, -6.88985512e-02f, 2.30682027e-02f, 3.58950421e-02f, -4.69078273e-02f, -4.00920212e-02f, 2.86688190e-02f, 1.04333991e-02f,
  -1.08161487e-01f, 3.15810777e-02f, -1.12871956e-02f, -2.09318195e-03f, 1.22944647e-02f, 1.49204005e-02f, 4.75786552e-02f, 9.37719494e-02f, -3.11352611e-02f, 3.66245098e-02f,
  7.76205286e-02f, -4.20374386e-02f, -8.97736661e-03f, -2.65112016e-02f, -5.71101867e-02f, -4.21194285e-02f, -1.84143670e-02f, 3.92315909e-02f, -1.01689808e-02f, 1.40755959e-02f,
  -4.70134392e-02f, -4.43079174e-02f, 7.51278698e-02f, -6.06990121e-02f, -2.80978922e-02f, -2.83285901e-02f, 1.21665746e-02f, -3.25890258e-02f, 3.85008054e-03f, -7.50902742e-02f,
  3.10392138e-02f, -1.06681973e-01f, 5.02781272e-02f, -4.76513058e-02f, -1.46233151e-02f, 8.02588686e-02f, -1.49585614e-02f, -4.41201823e-03f, -3.89317758e-02f, -2.87354272e-03f,
  -1.43592292e-02f, -5.03373556e-02f, -4.99137640e-02f, 3.27643342e-02f, 1.10106415e-03f, -1.74806789e-02f, -4.35610116e-02f, 7.52488226e-02f, 2.18859483e-02f, -8.59150216e-02f,
  -3.07273697e-02f, 8.28204975e-02f, -5.24597131e-02f, 2.45339777e-02f, 5.13645820e-02f, 6.52112216e-02f, 2.07558889e-02f, -2.79911738e-02f, 7.48043209e-02f, -7.00602755e-02f,
  -1.71225205e-01f, -7.00095966e-02f, -1.77232668e-01f, -2.20923886e-01f, -2.83369552e-02f, -2.45990172e-01f, -3.52154613e-01f, -1.32218406e-01f, -1.37818232e-01f, -2.20684588e-01f,
  -2.15272903e-01f, -3.62186991e-02f, 1.66666508e-01f, -1.39967799e-01f, 1.17593817e-01f, 2.29948178e-01f, -3.20715785e-01f, -1.46866009e-01f, 8.18242952e-02f, -2.21378908e-01f,
  1.03078196e-02f, -5.63205555e-02f, -5.59523106e-02f, 3.68700288e-02f, -2.29208916e-01f, -1.69364423e-01f, 1.37175266e-02f, -8.32020640e-02f, -8.82710069e-02f, -2.30496731e-02f,
  -1.41696095e-01f, -1.52157560e-01f, -1.61535949e-01f, -1.20750248e-01f, -1.29480973e-01f, -4.71521169e-02f, -6.37742728e-02f, 2.45617274e-02f, -8.94473940e-02f, 1.01165893e-02f,
  5.56453206e-02f, 3.18371058e-02f, -5.30995838e-02f, 8.79517794e-02f, -6.46250620e-02f, -3.84289585e-02f, -5.20514622e-02f, -8.32749307e-02f, 7.07598822e-03f, 3.20548266e-02f,
  -1.60590820e-02f, -4.97336946e-02f, -1.10632017e-01f, 7.87874963e-03f, -1.38312636e-03f, -3.29956077e-02f, 2.66756210e-03f, 4.71599437e-02f, -1.52003691e-01f, -6.64489493e-02f,
  -1.36011578e-02f, 8.89332369e-02f, -1.03968538e-01f, 6.24576360e-02f, -8.64590332e-02f, -4.88828868e-02f, -2.45040748e-02f, 1.05394004e-02f, -3.32337506e-02f, 2.23079678e-02f,
  -2.38918345e-02f, -3.52850407e-02f, 4.65762895e-03f, -6.64130673e-02f, -7.59574026e-02f, -8.64716806e-03f, 7.16634244e-02f, -4.51796465e-02f, -2.11645067e-02f, -8.45986009e-02f,
  4.96196225e-02f, 3.02685313e-02f, 5.44157736e-02f, -6.29356802e-02f, 1.56958904e-02f, 4.38082814e-02f, -4.03458104e-02f, -1.07879788e-02f, 5.04220976e-03f, 2.21951734e-02f,
  -2.16100886e-01f, -2.61609524e-01f, -2.66362820e-02f, -1.47409782e-01f, -3.58943045e-02f, -1.21320061e-01f, 9.74184461e-03f, 3.17878090e-02f, -7.32003525e-02f, -4.52896953e-03f,
  -7.35107660e-02f, -1.53887048e-02f, 4.46818620e-02f, -4.59652506e-02f, 6.11793958e-02f, -3.18500586e-02f, -1.81377586e-02f, 4.03563194e-02f, -8.69951248e-02f, -3.36592495e-02f,
  -7.67133459e-02f, 1.40940500e-02f, 1.03219166e-01f, 6.40189946e-02f, 5.31120934e-02f, -1.22202769e-01f, 2.01153904e-02f, -4.55944091e-02f, -1.66988764e-02f, -2.80543044e-03f,
  2.09768340e-01f, -2.38609120e-01f, 1.17900223e-01f, 2.97917038e-01f, 1.78412229e-01f, -4.70776707e-02f, 2.86401752e-02f, -1.04403064e-01f, -5.48218749e-02f, -2.15550497e-01f,
  -7.64959827e-02f, 1.05186757e-02f, -2.55253941e-01f, 1.13532066e-01f, 7.19770491e-02f, -1.65310845e-01f, 9.30100456e-02f, 1.38810405e-03f, -4.42674942e-02f, -8.29920396e-02f,
  -3.83348316e-02f, -4.88539576e-04f, -2.00074355e-04f, 6.17297329e-02f, 1.30121857e-01f, 1.85726918e-02f, 9.43270400e-02f, 7.08898604e-02f, 2.20702529e-01f, 1.12725198e-01f,
  4.19521369e-02f, 8.99432506e-03f, 4.60109450e-02f, 6.05525188e-02f, -1.07085377e-01f, -6.47923880e-05f, -4.23388742e-02f, 1.41566202e-01f, 9.93501674e-03f, -6.15403987e-02f,
  -5.00967465e-02f, 8.62722546e-02f, 1.41665310e-01f, 3.76097450e-04f, 7.26652518e-02f, 4.91423020e-03f, 9.33848768e-02f, 5.98499700e-02f, -1.44833466e-02f, -8.07903633e-02f,
  5.43536711e-03f, 4.57359776e-02f, 4.40037362e-02f, 8.77868459e-02f, 1.05411358e-01f, -1.46689080e-02f, -4.41340264e-03f, 5.79808615e-02f, -4.09212522e-02f, -1.97078474e-02f,
  -6.52114898e-02f, 2.32737046e-02f, 8.94512702e-03f, 8.98371730e-03f, 5.62492711e-03f, 6.40847385e-02f, 7.40711838e-02f, -2.19886824e-02f, -3.80061045e-02f, -7.54571110e-02f,
  7.01525435e-03f, -2.78104208e-02f, 8.79935846e-02f, 6.80894554e-02f, 4.05579917e-02f, 2.86903698e-02f, -2.98022944e-02f, 8.91832411e-02f, 6.79742843e-02f, 6.58052489e-02f,
  3.48552503e-02f, -3.50864567e-02f, -1.22577269e-02f, -3.81928240e-03f, 1.04746573e-01f, -7.63671398e-02f, 2.16410216e-02f, -6.17143810e-02f, -2.44936086e-02f, 1.19263502e-02f,
  -2.49938399e-01f, -2.15121463e-01f, -7.36984313e-02f, 7.86243007e-03f, 4.93422225e-02f, -8.95726085e-02f, 2.27721296e-02f, 1.01350747e-01f, -1.37395546e-01f, -5.13044447e-02f,
  -4.63671125e-02f, -8.82502273e-03f, -2.34394707e-02f, 2.95630563e-02f, 2.00705063e-02f, -9.56523791e-02f, 5.40795289e-02f, 5.05197048e-03f, 2.12199949e-02f, -5.40916845e-02f,
  -5.14638312e-02f, -4.87923883e-02f, 4.01493050e-02f, -2.20780652e-02f, 3.63448672e-02f, 1.39952442e-02f, 2.84464229e-02f, -4.09617238e-02f, 7.61108985e-03f, 5.19441105e-02f,
  1.84359327e-01f, -2.58106608e-02f, -4.16644663e-02f, 2.47303426e-01f, -9.33870580e-03f, -2.91057885e-01f, -4.18568194e-01f, 1.10673204e-01f, -3.68040740e-01f, -5.65905795e-02f,
  6.62525445e-02f, -8.72549936e-02f, -2.13556290e-01f, -1.07630407e-02f, 2.63948683e-02f, -3.63485187e-01f, 4.43385914e-02f, -8.87977108e-02f, -1.59506232e-01f, 1.27797842e-01f,
  1.93704143e-01f, 2.36529931e-01f, 1.26376480e-01f, 3.83442312e-01f, 7.24684671e-02f, 4.50262040e-01f, 5.12939572e-01f, 4.78241555e-02f, 3.33487988e-01f, 7.14564770e-02f,
  -1.45819381e-01f, -7.28370175e-02f, -5.73392510e-02f, -9.40058082e-02f, 1.60446521e-02f, 7.65644908e-02f, 2.71144398e-02f, -1.11983968e-02f, -1.31032635e-02f, -2.93882061e-02f,
  1.27174603e-02f, 6.09608665e-02f, -2.16687731e-02f, -3.42668593e-02f, -3.94402370e-02f, -1.13517800e-02f, 2.68970095e-02f, -1.13050127e-02f, -7.77508169e-02f, -9.87253990e-03f,
  -3.09030004e-02f, 1.58627070e-02f, 2.22448055e-02f, -1.24546615e-02f, -2.74900217e-02f, 1.57471988e-02f, -2.65672393e-02f, -2.92886309e-02f, 5.11691794e-02f, 1.06539829e-02f,
  8.47012326e-02f, 2.07865033e-02f, -1.89265590e-02f, 1.02202548e-02f, 2.03485917e-02f, -1.87914576e-02f, -9.50728636e-03f, -1.54552571e-02f, -9.23384819e-03f, -1.91074777e-02f,
  9.09513235e-02f, 5.30420290e-03f, -7.18158297e-03f, -1.71359454e-03f, 2.70514265e-02f, 3.27022374e-02f, -1.99750811e-03f, -1.71620529e-02f, -3.47142182e-02f, -5.38471155e-02f,
  -5.62185310e-02f, 2.77312919e-02f, 2.30231192e-02f, -1.89506747e-02f, -1.37788607e-02f, 3.77018750e-02f, 8.77591968e-02f, -6.84459135e-02f, -8.50216970e-02f, 3.44678313e-02f,
  8.99064615e-02f, 3.23166102e-01f, -1.48420017e-02f, -2.25866884e-02f, -1.60345566e-02f, 3.95634398e-03f, -1.03885680e-02f, 3.69912237e-02f, 1.04144104e-01f, 9.52745148e-04f,
  3.45305130e-02f, 5.13118915e-02f, -1.32190185e-02f, 3.17845009e-02f, 4.85481918e-02f, -3.93296853e-02f, 2.96352897e-02f, 5.34176417e-02f, 9.30341259e-02f, 1.71112970e-01f,
  8.51854533e-02f, -4.35375161e-02f, 5.60197569e-02f, 2.78235395e-02f, 6.59458861e-02f, 1.85547955e-02f, 4.68258299e-02f, 5.98338917e-02f, 7.79628148e-03f, -2.52138563e-02f,
  8.62051919e-02f, -5.00057995e-01f, 1.27505526e-01f, 1.70634836e-01f, 2.86289662e-01f, 2.18380556e-01f, 2.18277067e-01f, -1.31489724e-01f, -4.57050242e-02f, -3.84839177e-01f,
  -1.20662622e-01f, -4.42182831e-02f, 2.22258773e-02f, -1.13023311e-01f, 3.12119395e-01f, 4.43438860e-03f, 1.84147526e-02f, 3.16604413e-02f, 3.77473794e-02f, 2.76893694e-02f,
  1.41600847e-01f, 2.79211942e-02f, 1.58998802e-01f, -1.21979125e-01f, 8.71986966e-04f, -8.70225132e-02f, -5.27792312e-02f, 1.85771614e-01f, -1.22815505e-01f, 1.59510851e-01f,
  2.51010899e-02f, -1.15482457e-01f, -1.31542876e-01f, -4.27180007e-02f, -1.20176092e-01f, -7.75796473e-02f, -6.71665743e-02f, 1.20172925e-01f, 9.01433975e-02f, -1.63636487e-02f,
  2.43310835e-02f, 4.22601737e-02f, -8.63132849e-02f, 2.56430712e-02f, 8.62859655e-03f, 6.36124192e-03f, -2.14374587e-02f, 1.69325732e-02f, -1.71133578e-02f, -1.89152155e-02f,
  -3.73042896e-02f, -7.68260881e-02f, -5.51545657e-02f, -5.17825708e-02f, -1.11239135e-01f, 5.80683351e-02f, 1.09162997e-03f, -5.44083118e-03f, -1.46701857e-02f, 5.15549816e-02f,
  -1.33268327e-01f, -2.32888609e-02f, -8.01689178e-02f, -2.55818069e-02f, -2.48082262e-02f, 4.74100411e-02f, -3.65787596e-02f, 4.01993515e-03f, -2.44541895e-02f, -6.40528649e-02f,
  -5.87843806e-02f, -2.64530759e-02f, -4.80904691e-02f, -8.76812264e-02f, 5.04997149e-02f, -2.89687999e-02f, 4.62532192e-02f, -5.51347844e-02f, -6.17792271e-02f, -9.29238945e-02f,
  5.52894287e-02f, 3.49766836e-02f, 1.72206648e-02f, -4.06631641e-03f, -5.39735965e-02f, 4.88723814e-02f, -6.00702539e-02f, -4.02946733e-02f, 4.70051058e-02f, 1.63589772e-02f,
  -2.23932624e-01f, -1.49838328e-01f, -9.01404768e-02f, -2.51323879e-02f, -1.10755190e-02f, -1.57708794e-01f, -3.01689543e-02f, -1.32051200e-01f, 1.32570621e-02f, 1.61438938e-02f,
  -5.90247586e-02f, 2.51160772e-03f, -3.17601115e-02f, -1.14218350e-02f, -9.75880679e-03f, -3.79098095e-02f, -1.69212762e-02f, -6.09751828e-02f, -4.49828841e-02f, 5.14992625e-02f,
  -7.96125755e-02f, -3.35498550e-03f, 4.64362688e-02f, -4.16985676e-02f, -7.23497942e-02f, -3.34625952e-02f, -5.91693819e-03f, -6.05654530e-02f, 2.99712885e-02f, 6.22559979e-04f,
  1.43623039e-01f, -1.64221793e-01f, -5.91846444e-02f, 5.73562980e-02f, 2.17769176e-01f, 1.23498440e-01f, -5.66418208e-02f, 1.19479731e-01f, 1.54304266e-01f, -9.68252495e-02f,
  5.93551546e-02f, -2.07749203e-01f, -2.24534258e-01f, 1.03085339e-02f, 1.21699413e-02f, -1.00344636e-01f, -4.83631007e-02f, -6.38411439e-04f, 5.23202159e-02f, 3.25200297e-02f,
  1.43021166e-01f, 9.99911577e-02f, -1.49576679e-01f, 9.93039180e-03f, 9.26735774e-02f, 5.92808984e-02f, 1.26834348e-01f, 6.78758994e-02f, 3.28139588e-02f, -6.46289811e-02f,
  -6.21102639e-02f, -9.06402320e-02f, -9.64089558e-02f, 8.67800508e-03f, 1.00131474e-01f, 5.58715463e-02f, 4.38160114e-02f, -5.73850907e-02f, -2.35507339e-02f, -5.29143447e-03f,
  6.40023965e-03f, 4.29835357e-02f, -4.17051427e-02f, 1.35321751e-01f, 1.61230087e-01f, 1.03519864e-01f, -3.86716761e-02f, 8.05186704e-02f, -9.06232279e-03f, -2.32107770e-02f,
  -4.51654717e-02f, 2.26293597e-03f, 4.86420915e-02f, 7.50101283e-02f, 5.38197681e-02f, 2.13451702e-02f, 2.68783942e-02f, -1.27850669e-02f, -5.41428896e-03f, 4.61025573e-02f,
  9.62111950e-02f, -2.31053401e-02f, -7.15794936e-02f, -4.36122306e-02f, 5.36135072e-03f, 7.40767270e-02f, 4.05272953e-02f, 1.02754474e-01f, 1.03948347e-01f, -7.43614277e-03f,
  3.86956111e-02f, -2.25761589e-02f, 6.44937679e-02f, -5.34586422e-02f, -3.36609297e-02f, -7.47577846e-02f, -3.69583368e-02f, 3.87775227e-02f, 1.24695711e-03f, 8.47703218e-03f,
  -5.84083330e-03f, 6.07329905e-02f, -8.82388577e-02f, -9.36063603e-02f, -1.06584635e-02f, 5.58011420e-03f, 2.80112028e-02f, 1.17761306e-02f, -2.69345734e-02f, -1.32186124e-02f,
  7.41467997e-02f, 5.63045591e-02f, 4.03328158e-04f, 5.70404418e-02f, 9.57994536e-02f, 6.49059638e-02f, 4.29915376e-02f, -4.56295311e-02f, 8.97590220e-02f, -9.34749544e-02f,
  4.85803895e-02f, -2.72156131e-02f, 2.80783940e-02f, -3.99891324e-02f, 8.78797024e-02f, -6.11244254e-02f, -6.74779713e-02f, 2.40860227e-02f, 1.08425714e-01f, -4.24478017e-02f,
  -5.92698865e-02f, 1.15373731e-01f, 6.80847093e-02f, -1.23216733e-02f, -3.27389943e-03f, -5.92542142e-02f, 2.09750999e-02f, -6.03641570e-02f, 2.55338475e-02f, -8.20420310e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  -2.09977757e-02f, 7.28215724e-02f, 2.95461584e-02f, 8.09076428e-02f, 2.25582272e-01f, -2.22185347e-03f, 1.88642833e-02f, 2.38069847e-01f, -3.23021933e-02f, 1.45737216e-01f,
  2.23319203e-01f, 1.22381724e-01f, 1.09811909e-01f, 2.99941166e-03f, -5.87419793e-02f, 1.43511638e-01f, 1.17474012e-01f, 3.68175834e-01f, 3.37458909e-01f, 1.49747849e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.31357476e-01f, 1.57548979e-01f, 4.43256684e-02f, 1.11654028e-01f, 4.23932999e-01f, -1.18845209e-01f, 7.77723789e-02f, 3.62928480e-01f, 4.40671057e-01f, 1.88324740e-03f,
  -5.36370218e-01f, -1.22409761e-02f, -2.50400305e-01f, 4.47442196e-02f, -5.79943322e-02f, 4.51128006e-01f, -3.09501439e-01f, 2.94598132e-01f, -1.96777433e-01f, -1.69237912e-01f,
  -1.66998789e-01f, -2.33662948e-01f, -3.19256663e-01f, 3.55092764e-01f, -7.03816563e-02f, -2.23246664e-02f, 6.27969131e-02f, -4.86268364e-02f, -1.16810678e-02f, -1.92253977e-01f,
  9.23071280e-02f, -6.74158856e-02f, 3.15588899e-02f, 1.98089704e-01f, 6.52756309e-03f, 2.85645068e-01f, -3.02067604e-02f, 6.70445561e-02f, 2.15007871e-01f, 3.54023725e-02f,
  2.84042627e-01f, -2.87861556e-01f, -2.82653809e-01f, -4.07141387e-01f, -1.61899224e-01f, -1.04124434e-01f, 1.94904208e-01f, 1.88272193e-01f, -7.89120346e-02f, 8.87492299e-02f,
  -8.34437087e-02f, -6.95471326e-03f, 4.08033915e-02f, 1.74570918e-01f, 1.49639338e-01f, 1.62305489e-01f, 2.10166633e-01f, 1.58614025e-01f, -2.45250866e-01f, 1.98229045e-01f,
  -2.16602208e-03f, -3.03258151e-01f, -2.14751557e-01f, -1.35778695e-01f, 1.93895027e-01f, 1.83882728e-01f, -1.62137598e-01f, -1.90160573e-01f, 2.15270787e-01f, 1.93553373e-01f,
  -2.27063298e-01f, 1.49589419e-01f, -1.04502596e-01f, 2.57870853e-01f, 2.42946550e-01f, 1.23096749e-01f, -1.68948099e-01f, -9.85244587e-02f, -4.57260162e-02f, 2.23914847e-01f,
  7.63235167e-02f, 2.85809916e-02f, -2.48864099e-01f, 6.29567951e-02f, -8.94122347e-02f, -1.58426598e-01f, -8.37846547e-02f, -2.92484686e-02f, -1.66822433e-01f, 1.63085312e-01f,
  1.20075464e-01f, -2.06972018e-01f, -8.06009620e-02f, 2.00774357e-01f, -1.22305088e-01f, 8.93291757e-02f, 2.37871364e-01f, -3.39909494e-02f, 3.42689872e-01f, 2.86312789e-01f,
  2.48393044e-01f, 7.85349905e-02f, -1.84248164e-01f, -4.90740359e-01f, -1.77092165e-01f, -1.47991195e-01f, 2.93914437e-01f, 3.56687099e-01f, 8.07086155e-02f, 6.50632903e-02f,
  6.43521249e-02f, -3.31593871e-01f, 3.37634772e-01f, -7.49053359e-02f, 2.24761561e-01f, 2.35410616e-01f, 6.10154793e-02f, -1.06853001e-01f, 3.21493745e-01f, 1.23490393e-01f,
  8.92543644e-02f, 1.15573734e-01f, -7.98486099e-02f, -1.14329334e-03f, 2.22057447e-01f, -3.46364409e-01f, 2.11985350e-01f, 1.49725541e-01f, 1.27793998e-01f, -2.00738981e-01f,
  -1.61015615e-01f, -4.99585941e-02f, 2.97373906e-02f, 1.35103673e-01f, 1.97356090e-01f, 1.79085974e-02f, -8.11618343e-02f, -4.87291254e-02f, 2.04815283e-01f, 3.26034069e-01f,
  5.58688045e-02f, 8.65276456e-02f, 9.18665379e-02f, 7.51107559e-02f, -3.20810303e-02f, 7.32243210e-02f, 2.76784271e-01f, 1.58933371e-01f, -2.03200188e-02f, 4.43987064e-02f,
  2.33108863e-01f, 1.86301202e-01f, 2.69936956e-02f, -2.26176545e-01f, -1.63001493e-01f, 4.07500528e-02f, 1.23407304e-01f, 1.66867957e-01f, 1.40029132e-01f, 1.19105846e-01f,
  -5.31911626e-02f, 1.81739226e-01f, -1.49402931e-01f, 3.46940160e-02f, 2.45236576e-01f, 2.06267953e-01f, -4.03008521e-01f, 3.29264164e-01f, 3.27932596e-01f, -2.35608354e-01f,
  -2.60359257e-01f, -8.19869116e-02f, -2.17264920e-01f, 4.53787260e-02f, 1.10796891e-01f, -1.15721606e-01f, 6.55377060e-02f, 1.52213812e-01f, -2.29732439e-01f, -1.63879991e-01f,
  -1.62509352e-01f, 5.70246391e-02f, -2.68511891e-01f, -2.87320107e-01f, 1.54515266e-01f, 1.99696004e-01f, -1.54644651e-02f, 1.42222084e-02f, -1.47219539e-01f, -7.33828917e-02f,
  -1.66371897e-01f, 1.56525020e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -3.36651728e-02f, 1.52603880e-01f, -2.45711785e-02f, 1.72457024e-01f, -1.41599804e-01f, -1.06143862e-01f, 1.73248023e-01f, 1.63086597e-02f, -1.30753934e-01f, -1.98678777e-01f,
  1.48205683e-01f, 7.80288726e-02f, 1.19742885e-01f, -1.16908096e-01f, 6.82218671e-02f, -1.04688421e-01f, -1.14842504e-01f, -7.54349083e-02f, -5.99241769e-03f, 1.62429407e-01f,
  7.72018284e-02f, -7.53100142e-02f, -4.25994918e-02f, -1.15754299e-01f, 1.20260753e-01f, -1.55275762e-01f, -1.28688291e-01f, 6.36547133e-02f, 1.26774451e-02f, -5.95909655e-02f,
  1.25834540e-01f, -3.01420372e-02f, -1.22801863e-01f, 2.07306102e-01f, -3.76614220e-02f, 1.08283944e-01f, 9.24825966e-02f, -6.71343587e-04f, 1.00086920e-01f, 5.09144291e-02f,
  1.48471981e-01f, 9.65484977e-02f, -1.45446166e-01f, -4.67357002e-02f, -2.53981538e-02f, -8.59163478e-02f, -9.07332450e-02f, 1.75286978e-01f, 2.66482886e-02f, 1.67977735e-01f,
  -6.52087480e-02f, 3.23886238e-02f, -8.48846626e-04f, 9.67461020e-02f, 3.94846052e-02f, 7.54154697e-02f, 4.56905328e-02f, 1.86894864e-01f, 7.27948621e-02f, -2.03751791e-02f,
  -3.79667506e-02f, -1.77943423e-01f, 3.08589195e-03f, -1.72139108e-01f, 3.73746268e-02f, 2.73727506e-01f, 1.14766605e-01f, 1.70784235e-01f, -3.28146815e-02f, -7.20637441e-02f,
  6.55698776e-02f, 1.64529979e-01f, 4.36783373e-01f, 8.26109573e-02f, -1.15789538e-02f, 1.96341842e-01f, -1.57295406e-01f, -8.37577656e-02f, 6.92327619e-02f, 4.28638995e-01f,
  3.75745632e-02f, 9.02654529e-02f, -2.14923978e-01f, -1.08002074e-01f, 4.69193496e-02f, -2.22249180e-01f, -3.23357396e-02f, -5.58700264e-02f, 4.19546105e-02f, -1.98817879e-01f,
  2.20863983e-01f, 1.95692945e-02f, 2.53648460e-01f, 1.73001528e-01f, 4.93591605e-03f, 1.44446224e-01f, -3.53104658e-02f, 6.51620552e-02f, 1.66847646e-01f, -9.97741446e-02f,
  -1.56710654e-01f, -1.10626630e-01f, -1.84141025e-01f, 6.10660911e-02f, 9.66955647e-02f, -9.25271735e-02f, 9.04199854e-02f, -1.57103121e-01f, -1.12165548e-01f, 1.11627065e-01f,
  -1.10289223e-01f, 2.04448253e-02f, 4.14143346e-04f, 8.84603709e-03f, 5.91316298e-02f, 3.78139466e-02f, 1.70537651e-01f, 9.74816363e-03f, 1.44171253e-01f, -6.14443012e-02f,
  6.40245480e-03f, 2.25017801e-01f, -5.74141629e-02f, 3.30596641e-02f, -3.48445252e-02f, -1.09130979e-01f, -1.75969034e-01f, -1.03078209e-01f, 2.77934015e-01f, 5.28750680e-02f,
  6.16477951e-02f, 3.42913479e-01f, 1.20885812e-01f, -4.47481051e-02f, 4.14504185e-02f, -6.23029545e-02f, 7.90673941e-02f, -1.13533519e-01f, 1.69575647e-01f, 3.49702984e-01f,
  -1.03343561e-01f, 4.86158952e-02f, 2.76965797e-01f, -1.34974554e-01f, 2.10723937e-01f, 5.46446405e-02f, -9.77912247e-02f, 1.24860927e-01f, -1.76790148e-01f, -2.50443786e-01f,
  -8.77355561e-02f, 3.93067867e-01f, 2.20293887e-02f, -1.68320253e-01f, -1.23724565e-01f, 1.01305187e-01f, -4.82480563e-02f, -2.67321169e-01f, 4.14870888e-01f, 1.53449595e-01f,
  1.44469976e-01f, -4.12058793e-02f, 2.32387483e-01f, 2.43306324e-01f, -6.82445690e-02f, -1.71721324e-01f, 3.28335822e-01f, -1.21542811e-02f, 2.79650651e-02f, -2.12661847e-01f,
  -1.56460702e-01f, 1.16788462e-01f, 2.42369756e-01f, -1.52690697e-03f, -8.47135782e-02f, 2.96614408e-01f, -2.28111833e-01f, -1.18727103e-01f, 1.24619387e-01f, 4.20877002e-02f,
  -7.41427541e-02f, -1.43303238e-02f, 1.99006453e-01f, 6.45609051e-02f, -6.25374541e-02f, -1.39062136e-01f, 1.53765336e-01f, 2.73142636e-01f, 2.70415425e-01f, 4.60635088e-02f,
  4.44577634e-01f, -2.74933036e-03f, -1.81639995e-02f, -1.21617811e-02f, -6.56049028e-02f, -2.04990841e-02f, 2.82965481e-01f, 5.87438121e-02f, -1.15779184e-01f, -1.25801519e-01f,
  1.35139838e-01f, -1.69964314e-01f, 2.71882191e-02f, 1.01786599e-01f, 1.76450357e-01f, -5.85198402e-02f, 1.99590296e-01f, -1.36415645e-01f, -1.06945761e-01f, -1.51456809e-02f,
  -1.10302553e-01f, -6.48955405e-02f, 1.06268018e-01f, -6.04717582e-02f, 8.39681178e-02f, -1.03670537e-01f, 1.31561592e-01f, 7.37634525e-02f, -1.30560294e-01f, 1.03365192e-02f,
  8.84483457e-02f, -1.64827574e-02f, 2.50672519e-01f, -1.27319410e-01f, 2.47730568e-01f, 9.05003119e-03f, 1.13852039e-01f, 1.07183158e-01f, 8.63340423e-02f, 1.65365010e-01f,
  2.37806275e-01f, -4.60388571e-01f, -3.06917489e-01f, 1.26494989e-01f, 4.58095044e-01f, -4.70054261e-02f, -4.84631322e-02f, -1.42209426e-01f, -1.13097049e-01f, -1.31069198e-01f,
  5.38053453e-01f, -1.40591204e-01f, -7.63864368e-02f, 2.20782876e-01f, 2.12968469e-01f, 3.37588519e-01f, 5.32183349e-01f, -6.58937916e-02f, 2.54979264e-03f, 1.40953839e-01f,
  -9.42230448e-02f, -4.79586981e-02f, 2.92363465e-01f, 6.42382503e-02f, 2.86433369e-01f, -1.61348626e-01f, 2.57781357e-01f, 7.25165904e-02f, 1.47515565e-01f, 1.45623401e-01f,
  -2.87968535e-02f, 1.73659325e-01f, 7.62584805e-02f, 6.60167113e-02f, -1.21706165e-01f, 2.92277008e-01f, 2.79504597e-01f, -7.57354572e-02f, 1.58103108e-01f, -1.29104957e-01f,
  2.21596006e-02f, 2.24715590e-01f, -7.90245011e-02f, -8.92472193e-02f, -2.10686877e-01f, 1.88884720e-01f, -3.29798311e-02f, -8.16411898e-03f, -2.52067465e-02f, -3.40274791e-03f,
  -1.75477147e-01f, 5.00881113e-02f, -8.96067992e-02f, -9.30348784e-02f, 1.60657763e-01f, 4.63228285e-01f, -1.61240667e-01f, -3.26496176e-02f, 2.67081469e-01f, -1.71752535e-02f,
  4.06706110e-02f, 3.19608897e-02f, 1.38330787e-01f, 1.67539790e-02f, -1.00871891e-01f, 1.39887214e-01f, -2.81902459e-02f, 2.19687074e-01f, 9.26681235e-02f, -8.67773667e-02f,
  -1.51288003e-01f, -1.16922721e-01f, -1.27050206e-01f, -6.64780736e-02f, 2.97922567e-02f, -8.90669525e-02f, -1.50499731e-01f, 9.42465663e-03f, 1.49043530e-01f, 3.77495699e-02f,
  -1.53315663e-01f, -6.09882250e-02f, -1.14798911e-01f, -1.63307697e-01f, -6.39469996e-02f, -1.54251710e-01f, -1.52145430e-01f, 2.77903914e-01f, -3.77104478e-03f, 2.65181065e-01f,
  1.76368728e-01f, 1.77576784e-02f, 1.19438164e-01f, 1.91123202e-01f, 7.15602562e-02f, 3.47582102e-02f, 2.51590312e-01f, -5.04679307e-02f, 2.76605278e-01f, 1.61818951e-01f,
  -3.61082494e-01f, 2.57268131e-01f, -5.28663360e-02f, 2.03231797e-01f, 1.26722649e-01f, 4.74645078e-01f, -1.83104351e-01f, 3.01696062e-01f, -1.43405139e-01f, -1.16793424e-01f,
  -6.20232783e-02f, 8.13876931e-03f, 1.95483118e-01f, 2.02335238e-01f, -1.05632834e-01f, -1.83007047e-01f, -1.59464300e-01f, 2.06229702e-01f, 1.16910145e-01f, -5.18965349e-02f,
  2.45080248e-01f, -1.65288895e-01f, -7.13753849e-02f, -1.45888096e-03f, 9.00107771e-02f, -2.32402965e-01f, -1.47992507e-01f, 4.10990268e-02f, 1.64976075e-01f, 8.24074224e-02f,
  9.82078016e-02f, 2.79211700e-01f, 2.12963641e-01f, 2.34087594e-02f, 9.31540206e-02f, 8.15538839e-02f, -4.20913473e-02f, 3.36041629e-01f, -1.31345540e-01f, -7.60182142e-02f,
  8.12414810e-02f, 2.45093014e-02f, -1.63991779e-01f, -1.33876562e-01f, -1.80939168e-01f, 1.43345118e-01f, 1.17612556e-01f, 1.03493229e-01f, -6.00670874e-02f, -1.32625312e-01f,
  1.06146567e-01f, 2.70656317e-01f, -1.47590563e-01f, 6.88076466e-02f, 2.26112664e-01f, -2.27633230e-02f, 1.96631625e-01f, 4.27650586e-02f, 3.90760452e-02f, 3.67694646e-02f,
  -9.51272249e-03f, 2.67878264e-01f, -1.34385511e-01f, -8.88657123e-02f, -8.04523006e-02f, -2.70382941e-01f, 1.23036638e-01f, -1.55899167e-01f, -2.01651171e-01f, -2.23405764e-01f,
  -1.11991510e-01f, -2.86889970e-01f, 3.76650989e-01f, 1.74700338e-02f, 1.27153829e-01f, 1.48584858e-01f, 3.94071005e-02f, -2.02688128e-01f, 2.37092480e-01f, -8.01405236e-02f,
  1.30426913e-01f, 2.44902626e-01f, -1.61172748e-01f, 3.57126564e-01f, -2.31841773e-01f, 1.84021041e-01f, 2.87023306e-01f, 2.99205780e-01f, 1.95158079e-01f, 1.20611101e-01f,
  1.08709522e-01f, 9.32883024e-02f, -3.28176200e-01f, 1.81755498e-01f, -3.15836102e-01f, -3.39514971e-01f, -2.41999671e-01f, -5.69503665e-01f, -8.88445750e-02f, 1.23967126e-01f,
  -1.54981554e-01f, 5.82437739e-02f, 6.31976128e-02f, -1.51432902e-01f, 3.22081566e-01f, -3.25665846e-02f, 1.20815590e-01f, 3.12277257e-01f, 1.03011295e-01f, -2.91614562e-01f,
  5.17324507e-01f, 1.43161073e-01f, -1.01238362e-01f, 6.55718505e-01f, -1.60668269e-01f, 1.94189698e-01f, -2.10500985e-01f, 2.08966210e-02f, 1.92547902e-01f, 2.35416129e-01f,
  3.20769489e-01f, -4.21144534e-03f, 2.72531509e-01f, 1.79360196e-01f, -3.46216895e-02f, -6.45507202e-02f, -1.21736199e-01f, -4.49770421e-01f, -3.60570073e-01f, -1.44125834e-01f,
  2.42083505e-01f, 2.02355199e-02f, 8.56493711e-02f, -7.20013157e-02f, -5.80989309e-02f, 1.19512513e-01f, 3.39264274e-01f, 7.26924017e-02f, 1.65090084e-01f, -1.08428992e-01f,
  -1.27980769e-01f, -9.66622531e-02f, 1.99439809e-01f, -6.77675232e-02f, -1.09845012e-01f, 1.78823262e-01f, 2.87172832e-02f, -3.61755043e-02f, 1.63446203e-01f, -3.86336930e-02f,
  3.19335729e-01f, -2.33953558e-02f, -2.14908738e-02f, 1.01731099e-01f, 1.54490680e-01f, 1.30192176e-01f, -9.33211967e-02f, -5.51318116e-02f, 1.65003836e-02f, 7.91709200e-02f,
  1.20626368e-01f, 2.31662169e-02f, 1.19255580e-01f, -7.15603232e-02f, -2.21773997e-01f, 1.61115751e-01f, -1.89935222e-01f, -1.14039741e-01f, -6.76633269e-02f, -7.53990039e-02f,
  3.93943340e-02f, 4.68579829e-02f, -1.52372913e-02f, 4.91498113e-02f, 3.10857617e-03f, 2.11470202e-02f, -4.26550843e-02f, -2.28686601e-01f, 2.52699494e-01f, 5.49570441e-01f,
  -8.23583603e-02f, 1.81304932e-01f, 1.14658810e-01f, 1.17571726e-01f, -3.27906981e-02f, 3.31286862e-02f, -5.36848679e-02f, 1.21308342e-01f, -6.51896074e-02f, 2.85811245e-01f,
  1.52700171e-01f, -1.96474254e-01f, 1.36982486e-01f, -2.55185336e-01f, -1.22335605e-01f, 1.15822375e-01f, -1.20987132e-01f, 1.39761582e-01f, -1.50524855e-01f, -1.79995432e-01f,
  2.33395025e-02f, 6.09488338e-02f, -6.47638366e-02f, 6.64550625e-03f, -1.70960918e-01f, 3.04260068e-02f, -9.51800272e-02f, 1.44078344e-01f, -8.79483745e-02f, -1.27834156e-01f,
  -1.57261848e-01f, 2.84548670e-01f, -2.46851966e-01f, 1.20065331e-01f, 1.13761034e-02f, 9.78093445e-02f, 1.70895234e-01f, -6.35129064e-02f, -2.42968858e-03f, 1.05479650e-01f,
  2.93936193e-01f, 4.45345826e-02f, 1.33301646e-01f, 2.02922542e-02f, -2.70448998e-02f, -2.34872177e-01f, 2.05691546e-01f, 1.73530564e-01f, 8.67409557e-02f, 1.84409246e-02f,
  -1.94894627e-01f, 3.14854011e-02f, 2.54755110e-01f, 9.74311084e-02f, -1.06386632e-01f, 8.86395797e-02f, 4.73277345e-02f, 9.83269140e-02f, -5.85671701e-03f, -4.45479341e-02f,
  7.42757618e-02f, 2.05332786e-01f, -1.85821906e-01f, -1.93221763e-01f, 2.40781635e-01f, -1.42061606e-01f, 4.69050139e-01f, 3.26522559e-01f, 8.08109492e-02f, -2.20923554e-02f,
  4.55404460e-01f, 2.28349492e-01f, -4.04334545e-01f, -4.61121202e-02f, 5.06323809e-03f, 4.60244894e-01f, 3.63086909e-01f, 5.86646795e-01f, -8.04517865e-02f, 2.06504166e-02f,
  7.52597004e-02f, 4.02893722e-01f, 1.50318787e-01f, 1.87564060e-01f, -5.82783893e-02f, 3.15849304e-01f, -1.25931710e-01f, -1.27854049e-01f, 1.26973391e-01f, 2.76793092e-02f,
  3.12363654e-02f, -6.55057281e-02f, -7.51049519e-02f, -2.09126711e-01f, 3.80629778e-01f, 6.50251567e-01f, 3.75693947e-01f, 4.13601190e-01f, 1.37034431e-01f, -8.81368071e-02f,
  -1.70021740e-04f, -7.37295374e-02f, -2.08760858e-01f, 6.47348166e-02f, -6.04611374e-02f, -1.42007172e-01f, 1.00013338e-01f, -1.69898078e-01f, -1.06780246e-01f, -7.34903589e-02f,
  -9.60270986e-02f, -1.18823394e-01f, 1.05613768e-01f, -1.34594753e-01f, 5.30093983e-02f, -5.86062036e-02f, 2.69046247e-01f, 2.19353914e-01f, -8.15824792e-02f, -4.44978550e-02f,
  9.29369330e-02f, -2.16939207e-02f, 6.85498491e-03f, -9.62523669e-02f, -1.31781623e-01f, 3.95937026e-01f, -1.57086655e-01f, -1.43694403e-02f, -3.25090401e-02f, -6.37197569e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  -5.39461197e-03f, 8.01162273e-02f, 1.08686173e-02f, -1.19633809e-01f, 1.35495543e-01f, 1.28741309e-01f, 1.92764446e-01f, 5.08609891e-01f, -2.61488277e-02f, 1.57325327e-01f,
  2.37301856e-01f, -9.72336158e-02f, 2.60647595e-01f, 4.72626328e-01f, 5.18331975e-02f, 2.07213104e-01f, 6.30544797e-02f, -4.75981198e-02f, 1.20934784e-01f, 5.79873973e-04f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.09375753e-01f, -1.21702090e-01f, -1.67838767e-01f, 2.21152440e-01f, -2.91994750e-01f, -1.26790762e-01f, 1.46958202e-01f, 1.00290542e-02f, -3.08188856e-01f, -3.58963281e-01f,
  -1.02458529e-01f, 2.98219025e-01f, 7.38260373e-02f, 6.09805323e-02f, -2.32258737e-02f, 1.87066361e-01f, -1.24263719e-01f, 1.94785461e-01f, 5.74210659e-02f, -2.58682787e-01f,
  1.78274408e-01f, -1.49288729e-01f, 2.33515739e-01f, 1.17392629e-01f, 2.26050988e-01f, 2.89413005e-01f, -3.41664697e-03f, 1.51471093e-01f, 6.25982136e-02f, 1.63380131e-01f,
  3.13209929e-02f, -6.33478686e-02f, -2.49794528e-01f, -1.50848493e-01f, -2.06583738e-01f, -3.93420219e-01f, 1.24537244e-01f, 1.66460052e-02f, -3.34956437e-01f, -6.34379610e-02f,
  -3.41618091e-01f, 8.24910626e-02f, 2.57867962e-01f, -5.52443147e-01f, 2.45631129e-01f, -1.88825086e-01f, -1.77427679e-01f, -1.62474826e-01f, -5.81296571e-02f, 2.10548744e-01f,
  -9.52590480e-02f, 2.31747776e-01f, 1.40137915e-02f, -1.95588529e-01f, 1.39421821e-01f, -1.30584136e-01f, -1.11269474e-01f, -1.29077747e-01f, 7.03108832e-02f, -2.01150924e-02f,
  -1.83425531e-01f, 2.35899389e-01f, -3.25467706e-01f, -4.75525521e-02f, 6.32147908e-01f, 3.71617347e-01f, 3.19294572e-01f, -1.18774883e-01f, 2.49461129e-01f, -9.01504159e-02f,
  5.59658289e-01f, 4.33885232e-02f, 6.96379617e-02f, 5.63066959e-01f, -2.19255569e-03f, 2.54977703e-01f, 3.14464942e-02f, 5.36499396e-02f, 1.80849522e-01f, -2.32613087e-01f,
  2.97512501e-01f, -3.04084178e-02f, 1.41709358e-01f, -2.17241824e-01f, -2.16063663e-01f, 2.11316738e-02f, -6.11869991e-03f, -2.50822186e-01f, -1.06140770e-01f, -2.77705550e-01f,
  2.55139709e-01f, 9.66732129e-02f, 8.23343098e-02f, -5.46871610e-02f, 1.95764229e-01f, -9.19229835e-02f, 3.60632658e-01f, 5.06186001e-02f, 8.93816054e-02f, 1.10503875e-01f,
  2.50677377e-01f, 1.43159449e-01f, 3.19683433e-01f, -3.52806777e-01f, 1.87211037e-02f, 6.53278753e-02f, 1.73950478e-01f, -2.96218812e-01f, 1.02389507e-01f, 1.38685942e-01f,
  1.92329645e-01f, 2.67879665e-02f, 1.71122849e-01f, 1.24345146e-01f, 8.00871551e-02f, -2.04895884e-01f, 1.55655071e-01f, 7.32948929e-02f, 7.92485327e-02f, 9.48334783e-02f,
  -2.11013079e-01f, -2.69177824e-01f, 4.29292722e-03f, 7.45608211e-02f, 7.74835609e-03f, 1.54210001e-01f, 2.04375416e-01f, -2.50652134e-01f, -2.21909255e-01f, 2.34724432e-02f,
  -4.95697930e-02f, -4.19155061e-01f, -1.23936780e-01f, 1.13038749e-01f, -8.07196368e-03f, 3.60764325e-01f, -3.11271340e-01f, 2.33116716e-01f, -5.49088381e-02f, 1.87072866e-02f,
  7.82411471e-02f, 1.93954095e-01f, -1.44734934e-01f, 1.75400063e-01f, 1.49988100e-01f, -6.56022877e-02f, 4.02121842e-02f, 4.50291038e-02f, -1.88609585e-02f, -1.92888230e-01f,
  9.90250185e-02f, -4.66243811e-02f, -2.14279518e-02f, 1.81643695e-01f, 2.00646684e-01f, -2.77112633e-01f, 2.20280662e-02f, 1.55827373e-01f, -1.85118392e-01f, 1.54805765e-01f,
  3.76335680e-02f, 2.14072112e-02f, 5.74128702e-02f, 2.63863206e-01f, 5.57948425e-02f, -2.96633542e-02f, 6.14542067e-01f, 1.74407899e-01f, 1.33743435e-01f, -2.48937592e-01f,
  -1.54915899e-01f, 3.74501944e-01f, -2.38367692e-01f, 1.28839791e-01f, 3.58142555e-01f, 8.08155984e-02f, -9.82749090e-02f, 1.09824408e-02f, 8.24280083e-02f, -4.21662569e-01f,
  7.03526661e-04f, 8.00237730e-02f, 2.67015100e-01f, -8.88244361e-02f, -1.61085099e-01f, 1.11101858e-01f, -1.54145777e-01f, 9.89075936e-03f, 6.04260974e-02f, -1.28064364e-01f,
  1.63999692e-01f, 9.90941897e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.04007222e-01f, 1.07683107e-01f, 1.96815684e-01f, -2.78188258e-01f, 2.57816583e-01f, 8.61395076e-02f, -5.92463493e-01f, -3.86169761e-01f, 2.21803263e-01f, -1.08884752e-01f,
  -8.04801434e-02f, -3.19271237e-01f, -1.35686174e-02f, -1.20296277e-01f, -7.36863911e-02f, 3.48293968e-02f, 1.76285312e-01f, -3.10931474e-01f, -5.52289002e-02f, 3.94273698e-01f,
  1.00118883e-01f, 3.03503603e-01f, -2.80341983e-01f, 2.13598311e-02f, 6.67137876e-02f, 3.02394014e-02f, -3.45778793e-01f, 2.06354298e-02f, 1.20795444e-01f, -1.35064065e-01f,
  1.24430478e-01f, -4.78688963e-02f, 8.52696318e-03f, 4.27798294e-02f, 1.61787927e-01f, 3.22185636e-01f, 2.69281805e-01f, -3.06030344e-02f, -9.87792611e-02f, 1.02679357e-01f,
  4.21106279e-01f, 3.95206474e-02f, -1.06781954e-02f, 2.29016379e-01f, -2.24958166e-01f, 1.36071935e-01f, 2.93285668e-01f, 9.05764848e-02f, -2.27753043e-01f, -6.35808483e-02f,
  1.03535935e-01f, 1.51416123e-01f, 3.25706899e-01f, 2.60126531e-01f, -1.28738612e-01f, -4.76513011e-03f, 1.81910731e-02f, 7.77730420e-02f, -1.59101516e-01f, 3.96517247e-01f,
  2.28785411e-01f, -1.77863225e-01f, 6.09015644e-01f, -2.14201823e-01f, 7.17656629e-04f, 3.47643316e-01f, 1.44627988e-01f, 2.56161869e-01f, 9.37583745e-02f, 3.57402623e-01f,
  -4.66678321e-01f, 2.64883757e-01f, -2.80192703e-01f, 2.34709978e-02f, 2.56731838e-01f, -8.80003199e-02f, 1.00300267e-01f, -1.55905932e-01f, -1.36690378e-01f, 9.50072184e-02f,
  -1.29519418e-01f, 4.42716293e-02f, 1.46474972e-01f, 9.34691727e-02f, -1.81211587e-02f, -6.45200387e-02f, -1.47824392e-01f, -1.25734424e-02f, 4.58920479e-01f, 5.91833234e-01f,
  3.77628237e-01f, 1.21444963e-01f, 5.86020537e-02f, 2.55093485e-01f, -5.58573529e-02f, 3.65248412e-01f, -2.24182039e-01f, 3.38477373e-01f, -7.12528005e-02f, 2.88415909e-01f,
  1.17996030e-01f, 9.60927904e-02f, -1.47282302e-01f, -1.53817147e-01f, 5.56523323e-01f, -4.97269988e-01f, 3.10524166e-01f, -3.64913307e-02f, -1.76004007e-01f, -1.29258960e-01f,
  7.13113695e-02f, -7.53059462e-02f, 1.29208062e-02f, -2.64874965e-01f, -1.79622144e-01f, 2.01763082e-02f, 2.11924791e-01f, 2.66153783e-01f, 1.66476846e-01f, 2.96568513e-01f,
  2.12553009e-01f, -3.92208956e-02f, -9.78783593e-02f, 3.27947080e-01f, 1.31964535e-01f, -2.22397283e-01f, 6.10703051e-01f, 9.42817479e-02f, -5.93949445e-02f, 4.73613113e-01f,
  3.52712959e-01f, -9.50598940e-02f, 2.55025566e-01f, 4.15840536e-01f, 1.31336730e-02f, 3.69975060e-01f, 6.38240650e-02f, 2.40446150e-01f, 2.10152507e-01f, -1.79412588e-01f,
  -1.82833329e-01f, 1.17019914e-01f, 1.94251731e-01f, 1.06309451e-01f, 1.05052583e-01f, -1.80039220e-02f, 6.42323345e-02f, 3.31954271e-01f, -4.42386270e-02f, -9.07235295e-02f,
  3.53642732e-01f, 5.26746884e-02f, -2.38652438e-01f, -1.08283110e-01f, -7.10588694e-02f, -4.58969511e-02f, -1.01801969e-01f, 9.27355215e-02f, 9.42567736e-02f, -6.42791437e-03f,
  -1.60614699e-01f, 1.10359207e-01f, -6.54603764e-02f, -8.83102417e-02f, -6.00080416e-02f, 3.40398476e-02f, 3.37025733e-03f, -4.93595675e-02f, 2.21659318e-01f, -2.22702418e-02f,
  -2.11260393e-02f, 2.35165805e-01f, 1.52978048e-01f, 2.01466642e-02f, -9.69692543e-02f, -8.63838661e-03f, 6.80076033e-02f, -2.02936530e-01f, -1.17456660e-01f, 1.32002532e-02f,
  -1.03247277e-01f, 4.93443832e-02f, -3.22712213e-02f, 1.28639996e-01f, 1.61930919e-01f, -1.40095055e-01f, -8.74247700e-02f, 5.26023209e-02f, 6.78492039e-02f, 2.29556840e-02f,
  2.30916053e-01f, 7.93713238e-03f, 5.15864551e-01f, 2.62612283e-01f, 3.60599101e-01f, -2.46536121e-01f, 2.75661916e-01f, 1.61446720e-01f, -4.46356162e-02f, -1.92803875e-01f,
  -1.50780305e-01f, 7.89492130e-01f, 3.53724569e-01f, -3.64588678e-01f, 3.38469632e-02f, 1.13171197e-01f, -3.38861197e-02f, 3.27763185e-02f, 5.72247386e-01f, 3.10712010e-01f,
  1.92932352e-01f, 4.56576079e-01f, -1.21422127e-01f, -1.86450809e-01f, 2.31912851e-01f, -1.99499115e-01f, -3.21972549e-01f, -2.43362635e-01f, 9.38337967e-02f, -1.06767386e-01f,
  -3.00156564e-01f, -1.25168160e-01f, 5.77823639e-01f, -1.12855276e-02f, 6.71152711e-01f, 2.55805254e-01f, 3.16585243e-01f, 2.23314747e-01f, 2.59087890e-01f, -2.28638835e-02f,
  -3.67240518e-01f, 1.98841900e-01f, -2.81086147e-01f, 4.65014428e-01f, -1.26853764e-01f, 3.87756795e-01f, -3.32197137e-02f, -1.68231055e-01f, -2.82536775e-01f, -1.69868749e-02f,
  -2.05235273e-01f, -1.23014085e-01f, 9.56166983e-02f, -3.55012296e-03f, -1.59890339e-01f, 1.48989663e-01f, -1.29062936e-01f, -2.39552990e-01f, 5.02417386e-01f, 7.60488331e-01f,
  4.67050672e-01f, -3.72560024e-02f, 1.02343298e-01f, -2.44613066e-02f, -1.49163470e-01f, 1.42893255e-01f, 5.46989590e-02f, -2.38592118e-01f, 1.79544091e-01f, 3.60411644e-01f,
  1.14514418e-01f, 2.03754380e-02f, 1.13233410e-01f, 1.52038619e-01f, -1.90105140e-01f, -1.93265080e-01f, -3.35885555e-01f, 3.44572455e-01f, -5.58932088e-02f, 7.28788376e-02f,
  1.38812035e-01f, 1.20709896e-01f, -1.07176259e-01f, 1.58663109e-01f, -4.37742025e-02f, -1.72332451e-01f, -3.59177366e-02f, -4.57812622e-02f, 1.38928980e-01f, -1.82287365e-01f,
  7.40247080e-03f, 6.70727015e-01f, 2.94492304e-01f, -2.02599883e-01f, 1.05795734e-01f, 8.20049718e-02f, -3.16416085e-01f, -1.14130765e-01f, -2.72496045e-02f, 9.57695418e-04f,
  -1.96310252e-01f, -5.69461752e-03f, 1.44369960e-01f, -1.67951390e-01f, -9.74657107e-03f, -1.80753678e-01f, -2.74635479e-03f, -1.24313004e-01f, -9.68337059e-02f, 1.18244521e-01f,
  -1.04704527e-02f, -4.79927957e-02f, 4.17428240e-02f, 5.15079312e-02f, 3.52665745e-02f, 5.54587543e-02f, -1.15487970e-01f, -1.09297171e-01f, 1.87802076e-01f, 7.69749507e-02f,
  -1.18873514e-01f, 1.00416273e-01f, 8.72259960e-02f, -3.41381244e-02f, 6.11144081e-02f, 2.84732968e-01f, 1.21656936e-02f, -2.44985335e-02f, 1.89603388e-01f, -4.34393287e-02f,
  2.04988912e-01f, -7.74760172e-02f, -1.15679570e-01f, -1.14166692e-01f, -1.46810785e-01f, -1.17934138e-01f, 1.03388570e-01f, 8.66808146e-02f, -1.62708506e-01f, 2.20782980e-01f,
  1.95283100e-01f, -1.04705617e-01f, -1.16670854e-01f, 7.38730654e-02f, -1.53545260e-01f, -9.88137498e-02f, 1.29646689e-01f, 2.06362039e-01f, 8.19432735e-03f, -4.15667333e-02f,
  -1.23949401e-01f, -2.40436848e-02f, -9.47195590e-02f, 1.77404303e-02f, 3.46035026e-02f, -9.39035341e-02f, -1.20546117e-01f, -7.88702890e-02f, -4.46834750e-02f, -2.54599086e-04f,
  -7.80629590e-02f, 1.45044491e-01f, -1.40463993e-01f, 6.08596504e-02f, 1.75396293e-01f, -2.06611574e-01f, -1.98457316e-02f, -1.50451481e-01f, -2.81819910e-01f, -1.40365809e-01f,
  1.55288309e-01f, 3.71676624e-01f, 1.94349691e-01f, -1.67168155e-01f, 5.49107306e-02f, -9.88153294e-02f, -1.72955796e-01f, -8.91668499e-02f, -1.13698885e-01f, -9.94440392e-02f,
  2.72362772e-02f, 6.31660402e-01f, 1.59418032e-01f, 3.35465930e-02f, -9.61250514e-02f, -1.59710303e-01f, -4.77540530e-02f, -2.56964982e-01f, -1.86670467e-01f, 2.97525704e-01f,
  -7.16478005e-02f, -2.30482429e-01f, 2.93504894e-01f, -1.78846389e-01f, 2.32207328e-01f, -2.38206327e-01f, -1.85048953e-01f, 4.99364473e-02f, -2.89425433e-01f, -3.06764126e-01f,
  1.19961556e-02f, -4.03164327e-01f, 1.45028055e-01f, 5.42143062e-02f, 3.07616025e-01f, -5.47520399e-01f, -5.17811477e-02f, -1.99166387e-01f, 3.74858171e-01f, 5.55323437e-02f,
  -3.75756808e-02f, 2.64316112e-01f, -1.13584407e-01f, 1.54436715e-02f, 2.05361679e-01f, -1.18203508e-02f, 2.42450833e-01f, 1.64756939e-01f, -3.91834490e-02f, -3.33148241e-01f,
  -9.43184495e-02f, 1.99541152e-01f, -1.48619667e-01f, -8.45043957e-02f, 7.15638220e-01f, 8.28382000e-02f, 3.50807935e-01f, 1.47396168e-02f, 9.52446926e-03f, 1.22132130e-01f,
  1.82653069e-01f, -1.31947815e-01f, -2.59339601e-01f, -3.81482065e-01f, 2.10340679e-01f, -7.66905770e-02f, 1.24510415e-01f, -2.26987168e-01f, -1.26954354e-03f, -2.03224227e-01f,
  -1.57419831e-01f, -1.12477414e-01f, 1.00484014e-01f, 4.98707732e-03f, 1.43473029e-01f, -2.03141887e-02f, 1.25416905e-01f, 1.42603427e-01f, -2.22690672e-01f, -1.62586689e-01f,
  2.41775677e-01f, -9.19647291e-02f, -5.14811166e-02f, 4.39402554e-03f, 2.05653325e-01f, -3.59034650e-02f, 3.30659389e-01f, -1.72407851e-01f, -5.71478857e-03f, 2.23979250e-01f,
  2.54130393e-01f, -1.55448273e-01f, 3.55610326e-02f, 5.54988980e-02f, -2.80159116e-01f, -7.45230615e-02f, -1.04623148e-02f, 1.69428572e-01f, 6.77368119e-02f, 2.20926311e-02f,
  7.21143633e-02f, -6.88508153e-02f, -1.50315106e-01f, -2.04311162e-01f, 1.74544111e-01f, 1.12922676e-01f, 1.01984978e-01f, 1.19920924e-01f, 1.68947488e-01f, 1.71120405e-01f,
  -2.00047001e-01f, 8.03056806e-02f, -4.78449538e-02f, 5.34973890e-02f, 1.13895714e-01f, 1.00078478e-01f, -7.17374822e-03f, -1.80966467e-01f, -1.05294310e-01f, -5.66309541e-02f,
  2.45512888e-01f, -5.99763356e-02f, 1.57977454e-02f, 1.21582493e-01f, -2.73386277e-02f, -4.12265584e-02f, -2.27178670e-02f, -1.95976943e-01f, 1.15501650e-01f, 1.22389354e-01f,
  -1.86891392e-01f, 3.12591195e-02f, 5.59030697e-02f, 6.78761154e-02f, -5.84754869e-02f, -1.61730796e-01f, -1.33626387e-01f, -8.34483057e-02f, -1.41702890e-01f, 6.46776482e-02f,
  1.44028440e-01f, -5.85690187e-03f, -2.07971200e-01f, 1.05769828e-01f, 1.04042783e-01f, 2.60700345e-01f, 2.20266413e-02f, 1.02562815e-01f, 1.05092727e-01f, -1.47034392e-01f,
  2.71514952e-01f, -1.10354796e-01f, -1.09533116e-01f, -3.98438051e-02f, -6.38742670e-02f, -2.42219627e-01f, -2.34110821e-02f, -6.58637509e-02f, -5.39086461e-01f, -1.80793509e-01f,
  6.69879466e-02f, -1.88429169e-02f, 2.20700711e-01f, -1.02313675e-01f, -1.77804176e-02f, -9.48066935e-02f, -1.44977748e-01f, 1.23107499e-02f, 5.29627539e-02f, 9.46825296e-02f,
  -1.71052530e-01f, 2.64879853e-01f, 2.14963317e-01f, -4.03352734e-03f, -4.76022586e-02f, -1.04604729e-01f, 1.86963826e-01f, 2.84888059e-01f, -3.03568076e-02f, -4.54812720e-02f,
  -1.39011145e-01f, -9.53535363e-02f, 2.04451114e-01f, 2.45599389e-01f, 5.47155023e-01f, 3.95734966e-01f, 2.83513516e-01f, 1.32271111e-01f, 3.10856432e-01f, 2.19568610e-01f,
  1.03733189e-01f, 1.29936859e-02f, 5.24972118e-02f, 5.75361729e-01f, -8.32542628e-02f, 3.85546416e-01f, 5.60191635e-04f, 1.87516108e-03f, -1.35017127e-01f, -7.21161661e-04f,
  2.97845334e-01f, -1.57307684e-01f, 2.36877039e-01f, 1.28983825e-01f, 3.14742923e-02f, -1.55674890e-01f, 1.07676379e-01f, -2.11982623e-01f, -1.98398471e-01f, 1.40810758e-01f,
  7.47708157e-02f, 3.38285975e-02f, -1.68920010e-01f, 3.35328840e-02f, 1.24958128e-01f, 4.27382253e-02f, -3.73628348e-01f, -2.51486637e-02f, 6.53583333e-02f, -1.26411349e-01f,
  1.99901447e-01f, 2.61221886e-01f, -4.83685434e-01f, 2.47578308e-01f, 9.26972181e-02f, -1.82004765e-01f, 6.84235692e-02f, -8.29880163e-02f, 4.66102958e-02f, 1.61567867e-01f,
  -1.53879642e-01f, 1.64880365e-01f, -2.60389060e-01f, -3.94561179e-02f, -3.24778445e-02f, 4.20099467e-01f, 2.12319434e-01f, -4.92390394e-02f, -1.18716709e-01f, -7.56900664e-03f,
  3.72591913e-02f, 5.75653791e-01f, -4.69869636e-02f, 6.75949529e-02f, 1.89529836e-01f, 3.82644311e-02f, -2.42109038e-02f, -1.11115910e-02f, -1.80664986e-01f, -1.03269324e-01f,
  6.40994636e-03f, 5.65702654e-02f, 1.59282044e-01f, -3.03693190e-02f, 1.80750683e-01f, 2.87767589e-01f, -7.97543749e-02f, -1.71597853e-01f, 2.19771370e-01f, -2.97239929e-01f,
  -9.69329625e-02f, 8.73807222e-02f, -1.38119990e-02f, 2.67581046e-02f, 2.34185934e-01f, 4.05389160e-01f, -9.57337022e-02f, 1.92937970e-01f, -2.90893670e-02f, -1.87138870e-01f,
  4.48591232e-01f, -4.74646688e-02f, -7.61000440e-02f, -3.61586697e-02f, 1.67802379e-01f, 4.59581912e-02f, 3.79211344e-02f, 2.57534921e-01f, -5.74393682e-02f, -1.36130795e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  2.59005636e-01f, 2.93456197e-01f, 9.60980207e-02f, 1.17739551e-01f, 2.94130743e-01f, 6.32046536e-02f, 6.94190934e-02f, 4.03485715e-01f, 5.67209683e-02f, 6.16199933e-02f,
  1.21277958e-01f, 2.35001057e-01f, 1.00694902e-01f, 1.83757618e-01f, 1.96512625e-01f, -8.85126144e-02f, -4.26673181e-02f, 2.56381124e-01f, 8.59743804e-02f, 1.28805280e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  2.22672313e-01f, 4.41748053e-01f, 6.13252044e-01f, 7.43213832e-01f, 7.14056432e-01f, -4.87937301e-01f, 5.98104715e-01f, -4.01731193e-01f, 1.25802621e-01f, 2.06148475e-01f,
  4.26042497e-01f, 8.40858400e-01f, -3.15720826e-01f, 1.14857163e-02f, -4.37958166e-02f, -3.22065324e-01f, 2.53303885e-01f, -5.02060689e-02f, -3.68157357e-01f, -3.73683155e-01f,
  6.26253068e-01f, -1.80977479e-01f, -2.66057283e-01f, -4.16416079e-01f, -2.56513625e-01f, -3.87906849e-01f, -2.25474596e-01f, -1.75786242e-01f, -1.79376736e-01f, -1.81145892e-01f,
  1.64748535e-01f, 4.25668240e-01f, 3.17986488e-01f, -3.54414940e-01f, 3.35740209e-01f, -2.69928545e-01f, -1.32906675e-01f, -4.06928152e-01f, 3.23205918e-01f, -4.39178377e-01f,
  9.69836563e-02f, 7.13668227e-01f, -6.33267462e-01f, 4.07074809e-01f, -1.55056203e-02f, 3.69324327e-01f, -2.97111601e-01f, 8.34751666e-01f, 3.31894010e-01f, 2.14615509e-01f,
  -3.65891188e-01f, -6.19586706e-01f, -3.19314301e-01f, 9.05323923e-02f, -5.45011014e-02f, -3.89706343e-01f, 2.97440559e-01f, -1.74032256e-01f, -3.16657484e-01f, -1.12909719e-01f,
  -2.54362166e-01f, -3.96965146e-01f, -1.68117732e-01f, 1.47337755e-02f, -3.53043795e-01f, -2.37701833e-01f, 7.40637556e-02f, -3.91635507e-01f, -7.26933479e-01f, -2.34184399e-01f,
  2.19641738e-02f, 2.16328442e-01f, -1.92149788e-01f, -1.72833204e-01f, 1.42771631e-01f, 1.58321872e-01f, -3.01800549e-01f, 3.81630957e-01f, -2.84369946e-01f, 1.25382598e-02f,
  -1.35311261e-01f, -5.66319004e-02f, 2.38887429e-01f, -1.24433912e-01f, 4.52396311e-02f, 1.60905853e-01f, 1.40723541e-01f, 2.30939493e-01f, 9.86220777e-01f, 3.00657544e-02f,
  -2.32459307e-01f, 2.23655507e-01f, -5.57679571e-02f, -2.35164225e-01f, -3.23814780e-01f, 1.29534006e-01f, -3.23709756e-01f, -3.27778369e-01f, 4.87008631e-01f, -3.42006654e-01f,
  1.08760923e-01f, 5.61143458e-02f, 3.24879527e-01f, -4.65068042e-01f, -2.13887826e-01f, -1.01645684e+00f, 7.86532283e-01f, -7.39190429e-02f, 7.08541051e-02f, -1.57144830e-01f,
  1.23376213e-01f, -3.22699606e-01f, -4.58767563e-01f, 7.05095828e-02f, -3.51396561e-01f, 8.07984889e-01f, 6.98702753e-01f, -1.08156525e-01f, 1.22319400e-01f, -2.94367731e-01f,
  -1.49214908e-01f, -1.07191443e-01f, -2.18508735e-01f, 1.99197710e-01f, -2.48152658e-01f, -4.24868315e-02f, 1.50900915e-01f, -1.67283013e-01f, 2.90625513e-01f, 3.91863137e-01f,
  1.83729269e-02f, 4.40912545e-01f, 1.63558140e-01f, 4.23878133e-01f, -1.50622576e-01f, 4.19399589e-01f, 5.65225005e-01f, 5.97961713e-03f, 4.51498151e-01f, -4.43447053e-01f,
  -1.63977742e-01f, -4.94525552e-01f, 4.85992402e-01f, -3.45520556e-01f, 2.20022142e-01f, -2.43518203e-01f, 2.97444284e-01f, 6.31010652e-01f, -5.46846241e-02f, -2.00085923e-01f,
  1.49480939e-01f, -3.06896120e-01f, -3.58781427e-01f, -1.11755513e-01f, 1.55908138e-01f, -8.88073966e-02f, -1.01304933e-01f, 3.47013175e-01f, -2.55155474e-01f, 1.27925664e-01f,
  2.61498898e-01f, -3.10336620e-01f, -9.44811046e-01f, 3.77842754e-01f, 4.95642751e-01f, 1.57555670e-01f, -4.28451449e-01f, -6.96252406e-01f, 2.15470031e-01f, 2.44603813e-01f,
  1.02251016e-01f, 5.31091154e-01f, -1.04350120e-01f, 3.34708303e-01f, -3.13652039e-01f, 2.43895426e-02f, 2.32600272e-01f, 1.27429336e-01f, 5.18718183e-01f, 6.83549838e-03f,
  -1.76742241e-01f, 2.47356631e-02f, -1.81520566e-01f, -5.32719791e-02f, -1.78964734e-01f, -1.37275010e-01f, 2.38496587e-02f, 8.03964809e-02f, -2.25525826e-01f, 7.90010810e-01f,
  -2.13347539e-01f, -3.89183700e-01f, -3.83248240e-01f, 3.01965415e-01f, 6.61869422e-02f, -3.09985340e-01f, -1.47174850e-01f, 1.27005845e-01f, -5.62161207e-01f, 2.82068431e-01f,
  3.65668267e-01f, 2.35144183e-01f, -5.34054816e-01f, -4.90585268e-01f, 6.80970371e-01f, -5.67234494e-02f, -5.02220571e-01f, -4.22440208e-02f, -5.38011827e-02f, 8.21602624e-03f,
  5.50761640e-01f, -3.27273965e-01f, 4.34477404e-02f, -6.24218956e-02f, -4.45626723e-03f, 3.66167635e-01f, 3.69645119e-01f, 4.96488243e-01f, -4.14208360e-02f, 1.00638814e-01f,
  2.02112481e-01f, -2.43367374e-01f, -1.86488867e-01f, -2.71349788e-01f, -2.48541877e-01f, -8.59828517e-02f, -3.29476714e-01f, -7.23725915e-01f, -3.42705667e-01f, -5.21438681e-02f,
  2.63255358e-01f, 4.68994945e-01f, -6.36762500e-01f, -2.10875690e-01f, 2.81605393e-01f, -4.50562596e-01f, 5.94647713e-02f, -2.76647329e-01f, 6.94504321e-01f, -1.77588537e-01f,
  -3.16188812e-01f, 3.47931832e-02f, -1.78031355e-01f, 2.80703217e-01f, 1.42684564e-01f, 8.62288009e-03f, 9.03695896e-02f, -1.58644393e-01f, -1.36126369e-01f, -2.04102442e-01f,
  -1.13979004e-01f, -3.06775831e-02f, 4.88796622e-01f, -2.17241064e-01f, 4.89854723e-01f, -1.05444983e-01f, 4.18846533e-02f, -8.96249563e-02f, -1.64560318e-01f, 1.83120519e-02f,
  -3.52265656e-01f, 1.61826998e-01f, -1.45005034e-02f, 2.11813942e-01f, -1.06598556e+00f, 2.30731413e-01f, -1.33488432e-01f, -4.98321742e-01f, 4.53429908e-01f, 2.52336055e-01f,
  1.43643752e-01f, 5.02467632e-01f, -2.92403251e-01f, 8.44719633e-02f, -3.85991156e-01f, -3.23011994e-01f, -1.97346866e-01f, 2.08189681e-01f, -1.57755211e-01f, 1.61768213e-01f,
  1.55664891e-01f, 2.43131846e-01f, 1.76411286e-01f, 2.23628551e-01f, 3.38109910e-01f, -4.12016332e-01f, 3.15680116e-01f, -8.97994041e-02f, 9.04670060e-02f, 1.76621437e-01f,
  -4.07855421e-01f, -2.22835228e-01f, 2.15671480e-01f, 3.49064589e-01f, -2.39191055e-01f, 5.48456550e-01f, 2.52989382e-01f, 4.01983410e-01f, 3.80843610e-01f, -2.39665747e-01f,
  -2.82729566e-01f, -5.23570240e-01f, -4.06224370e-01f, -4.77875501e-01f, 3.06378365e-01f, -7.72336051e-02f, 8.55864942e-01f, -5.51924348e-01f, -3.55366021e-01f, -1.59812436e-01f,
  1.80263892e-01f, 9.69946906e-02f, 2.20920652e-01f, -6.46313056e-02f, 6.66616783e-02f, -1.90966666e-01f, -2.03077018e-01f, -4.29484844e-02f, -3.63926798e-01f, 3.52063268e-01f,
  2.01660857e-01f, -5.43246686e-01f, 2.60943584e-02f, 6.57791853e-01f, 2.58069098e-01f, 4.70784344e-02f, 3.06032181e-01f, -3.52184147e-01f, 6.84450388e-01f, 1.08066304e-02f,
  -6.59889519e-01f, 3.55948538e-01f, 8.77594426e-02f, 4.56450999e-01f, 2.08473012e-01f, 1.70957267e-01f, -2.69245356e-01f, 4.01156023e-02f, -6.79699361e-01f, 5.68569124e-01f,
  8.80918056e-02f, 1.86319500e-01f, -6.37409762e-02f, -2.44579867e-01f, -3.43792945e-01f, 2.85258114e-01f, 1.38258144e-01f, 2.57957906e-01f, -1.99507356e-01f, 5.11877239e-02f,
  -7.13564530e-02f, -3.55578572e-01f, -2.65602440e-01f, 1.83336183e-01f, 3.99387479e-01f, 3.35797310e-01f, 6.69905245e-02f, -7.54033551e-02f, -3.49123687e-01f, 3.24982256e-01f,
  -4.76046771e-01f, -4.95954603e-01f, 2.04971015e-01f, -6.33202910e-01f, 4.99296606e-01f, 2.04934552e-01f, 9.04843584e-03f, -1.19439527e-01f, 4.62003022e-01f, 1.49688914e-01f,
  1.53073696e-02f, -1.22544810e-01f, -1.36887029e-01f, -2.21983820e-01f, -5.52389249e-02f, 5.84618986e-01f, -4.48839933e-01f, -1.99009836e-01f, 2.49335870e-01f, 3.02441455e-02f,
  2.38291830e-01f, -5.57085574e-02f, 5.84621608e-01f, 4.76873684e-04f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  3.58788908e-01f, 1.11649007e-01f, -3.55470330e-01f, -3.17582041e-01f, 2.08959460e-01f, 1.85748905e-01f, -6.59264773e-02f, -1.47730693e-01f, -4.05231714e-01f, 1.37550727e-01f,
  1.37612388e-01f, -4.19467986e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    