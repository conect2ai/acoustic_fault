/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.67836064e-01f, 3.28794308e-02f, -2.68972188e-01f, 1.93314448e-01f, 1.67129323e-01f, -1.17016714e-02f, 3.81520204e-02f, 1.49718195e-01f, -2.30864398e-02f, 1.63708225e-01f,
  7.30063114e-03f, 9.39668342e-03f, -1.66825056e-01f, -7.83113316e-02f, -2.36655518e-01f, -3.26991558e-01f, -3.70032452e-02f, 3.58751900e-02f, -8.05099458e-02f, 1.33377910e-01f,
  -7.42543489e-02f, 1.76118046e-01f, -4.81118970e-02f, 7.00720251e-02f, 1.96579278e-01f, 4.85300459e-02f, 8.64414200e-02f, 6.13145437e-03f, 4.65555824e-02f, 2.91129127e-02f,
  3.15201096e-02f, 1.19970776e-01f, -5.26489578e-02f, 3.56501364e-03f, 1.45751471e-02f, 1.91243682e-02f, 1.43742543e-02f, -1.49674565e-01f, -2.78237183e-02f, -9.11741983e-03f,
  -7.70897977e-03f, 4.73207720e-02f, -2.06191614e-02f, -3.14816949e-03f, 6.26126230e-02f, 7.35500734e-03f, -7.10092112e-02f, -3.85138281e-02f, 4.58400585e-02f, -1.28470995e-02f,
  -8.39335546e-02f, -1.31157160e-01f, -8.43437910e-02f, 7.63561651e-02f, -5.63078299e-02f, -3.19016874e-02f, -9.80470181e-02f, 1.04226470e-02f, 8.98836032e-02f, -2.76011024e-02f,
  -6.22576736e-02f, -3.66147123e-02f, -4.09532115e-02f, 1.52223250e-02f, 1.78921018e-02f, 8.50914121e-02f, -3.39905918e-02f, -2.96255318e-03f, -3.88741009e-02f, 3.82743552e-02f,
  4.30588536e-02f, -7.92408420e-04f, 1.03134671e-02f, -6.03743494e-02f, -1.65568627e-02f, 3.28213647e-02f, -7.43062273e-02f, -3.87704074e-02f, 3.28836665e-02f, 1.76273733e-02f,
  7.07968250e-02f, 3.35950442e-02f, 7.18067586e-02f, -1.16316043e-02f, 1.01305721e-02f, -5.26297688e-02f, -2.95852013e-02f, 2.98712403e-02f, 4.84210392e-03f, -3.10746823e-02f,
  1.54488146e-01f, 8.74891654e-02f, 2.49401852e-02f, 4.24235947e-02f, -1.49626313e-02f, -2.23869961e-02f, -4.06737961e-02f, 3.79505046e-02f, 1.36150233e-02f, 1.94189623e-02f,
  1.88939702e-02f, 8.12072456e-02f, -1.16521604e-02f, 3.83491674e-03f, 1.65379550e-02f, -5.17552160e-02f, -1.70067921e-02f, -2.27805823e-02f, 1.30002901e-01f, -1.37333488e-02f,
  9.73776504e-02f, 8.59030858e-02f, 4.12748195e-02f, 9.09688920e-02f, 3.16451676e-02f, 3.44369188e-02f, 6.94729835e-02f, -3.90948839e-02f, 9.80866235e-03f, -1.16698965e-01f,
  4.07849163e-01f, 3.59428413e-02f, -2.21090782e-02f, 8.91262740e-02f, 9.04326215e-02f, 1.06675521e-01f, 7.29944557e-02f, 8.61367502e-04f, 7.91881233e-02f, -4.86958213e-02f,
  -2.72768084e-02f, 7.55976560e-03f, -1.55269191e-01f, 2.14622058e-02f, -1.29359201e-01f, -1.92893982e-01f, 1.62094533e-01f, -4.95698245e-04f, 9.66265798e-03f, 7.89905638e-02f,
  8.99245124e-03f, -6.56867772e-02f, -4.89449911e-02f, 1.99102913e-03f, 2.47340813e-01f, 9.13503468e-02f, -4.34738845e-02f, -1.58696949e-01f, 5.40945083e-02f, -4.36704643e-02f,
  2.04240069e-01f, -9.78894234e-02f, 1.24474114e-03f, -3.53743955e-02f, 1.13123827e-01f, -2.86384933e-02f, 5.28696254e-02f, -8.22459012e-02f, -2.71418206e-02f, -4.34042849e-02f,
  -4.18738015e-02f, -4.16017659e-02f, 2.91958973e-02f, -1.88821722e-02f, 1.76882348e-03f, -3.58644351e-02f, 6.12691082e-02f, 8.47594365e-02f, 3.29896156e-03f, 4.92211245e-02f,
  -4.95194122e-02f, 4.80605774e-02f, 3.18047851e-02f, 4.05269191e-02f, 4.42294404e-02f, 5.27992137e-02f, 4.14805859e-02f, -3.32564861e-02f, -5.30509977e-04f, 2.27922127e-02f,
  -1.15182042e-01f, -3.34331989e-02f, -3.72096598e-02f, 2.48519052e-02f, -5.87673858e-02f, 4.06980477e-02f, -5.68926707e-02f, -5.31495064e-02f, 4.17290349e-03f, -2.44060857e-03f,
  8.96302760e-02f, 3.39677222e-02f, -1.58213619e-02f, 4.93671233e-03f, 1.33778201e-02f, 6.98268265e-02f, 7.70702809e-02f, 2.25970764e-02f, 1.07744627e-01f, -1.65182687e-02f,
  -3.31286788e-02f, 1.13878557e-02f, -3.79343592e-02f, -1.15935970e-02f, -8.92833248e-03f, -5.86197339e-02f, -3.16296406e-02f, 2.62113754e-02f, 2.51813959e-02f, 6.02858094e-03f,
  1.92382112e-01f, -6.01526126e-02f, -1.09927263e-02f, 6.75887167e-02f, 3.27750295e-03f, 4.29478548e-02f, -8.71219337e-02f, 3.90420854e-02f, -7.81659037e-02f, 7.90957138e-02f,
  -5.35560190e-04f, 9.33529362e-02f, 3.33999693e-02f, -1.09526915e-02f, -2.17092279e-02f, -3.03127486e-02f, -8.09885710e-02f, 7.89998695e-02f, 6.66743219e-02f, -1.29198597e-03f,
  -2.09208652e-02f, -2.56987922e-02f, -5.21116741e-02f, 2.52707805e-02f, 3.12428772e-02f, 5.77376448e-02f, 3.88538986e-02f, 1.29829030e-02f, -1.18147852e-02f, 1.46481739e-02f,
  3.11708599e-01f, -1.14915870e-01f, -2.23909885e-01f, 8.88690278e-02f, 7.36626163e-02f, 1.02901138e-01f, 2.59637415e-01f, -4.32837382e-02f, 1.14249684e-01f, -1.41791617e-02f,
  1.51680633e-01f, -9.68528837e-02f, -4.27536704e-02f, 1.74983054e-01f, 3.18023443e-01f, 8.54183361e-02f, 1.62348986e-01f, 8.99080262e-02f, -3.08243576e-02f, 3.36616747e-02f,
  -8.13410338e-03f, 1.30289108e-01f, -1.68399602e-01f, -1.72582835e-01f, -5.17419092e-02f, -1.59081802e-01f, -3.35718431e-02f, -2.07653120e-01f, -1.57728028e-02f, -9.65469237e-03f,
  1.36756137e-01f, 5.61559796e-02f, -3.91940698e-02f, -6.17865697e-02f, 4.83355746e-02f, 7.72203552e-04f, -1.79549735e-02f, -4.22098488e-02f, -1.52058573e-02f, -3.67076956e-02f,
  2.60734055e-02f, 3.03215850e-02f, -8.16289522e-03f, -8.40296037e-03f, 3.86556983e-03f, -2.89398693e-02f, -3.53418365e-02f, -5.29053882e-02f, -9.56223756e-02f, 1.08263083e-02f,
  -6.25266787e-03f, -1.57279428e-02f, -3.97248529e-02f, -6.65293708e-02f, -4.43489812e-02f, 2.76633296e-02f, -3.07444413e-03f, -1.31631093e-02f, 5.26526533e-02f, 8.24849587e-03f,
  6.81121200e-02f, -8.99012312e-02f, -1.07381381e-01f, -3.34845446e-02f, -1.62793603e-02f, 4.10169130e-03f, -2.72269472e-02f, -4.01430912e-02f, -1.00126721e-01f, -2.25806814e-02f,
  6.17041923e-02f, -1.63691901e-02f, -3.71540460e-04f, -2.86328187e-03f, 3.22214998e-02f, 1.19717289e-02f, -1.12074211e-01f, 1.48427626e-02f, -5.97871877e-02f, -4.05384116e-02f,
  -8.34948663e-03f, 1.09693455e-02f, -1.93714537e-02f, 7.55723566e-03f, -5.33447042e-03f, -3.62058589e-03f, -5.17513901e-02f, -3.82095985e-02f, -1.39803370e-03f, 6.41978756e-02f,
  6.21357076e-02f, 4.88205068e-03f, -6.66702613e-02f, 6.07184395e-02f, -5.52887097e-02f, -1.18857548e-02f, 1.83975063e-02f, -4.82640378e-02f, 1.24820564e-02f, 7.91365728e-02f,
  -7.37417266e-02f, -5.10353036e-02f, 2.73333061e-02f, -1.57613643e-02f, -6.11557402e-02f, -1.98753215e-02f, 3.44512314e-02f, 7.59529173e-02f, 4.38797474e-02f, -4.61501768e-03f,
  -2.26199459e-02f, -2.18127202e-02f, -2.90801972e-02f, 6.78391382e-02f, 1.54095814e-02f, -1.25678973e-02f, -3.67091037e-02f, -1.37606449e-02f, 2.52027661e-02f, -1.73615161e-02f,
  -1.46783605e-01f, 9.52547118e-02f, -5.68991015e-03f, -1.00919735e-02f, 4.84705493e-02f, -8.72595161e-02f, -4.55971994e-02f, 1.02075830e-01f, -1.61084682e-01f, 1.86196044e-01f,
  3.31622437e-02f, -1.83255896e-02f, 4.14169542e-02f, 1.74414471e-01f, -2.86567271e-01f, -2.11216472e-02f, 1.72962621e-01f, 6.03547208e-02f, -8.76284912e-02f, 8.74485001e-02f,
  -3.80298644e-02f, 2.37027794e-01f, -5.07950457e-03f, 9.41015407e-02f, 7.82806799e-02f, -1.81671195e-02f, 1.28902286e-01f, -3.37041803e-02f, 9.54381973e-02f, -7.34694302e-02f,
  -4.43073735e-02f, 4.66356501e-02f, 4.72017452e-02f, 4.12741899e-02f, 1.56253576e-02f, 3.68713252e-02f, 4.78857346e-02f, -2.76550613e-02f, -4.40393351e-02f, -3.86974998e-02f,
  -7.51465037e-02f, -3.11949905e-02f, -3.10393106e-02f, -7.41209686e-02f, -3.48263457e-02f, -8.95240307e-02f, -1.97184421e-02f, -2.13322137e-02f, 8.14323276e-02f, -2.43695285e-02f,
  -3.64537388e-02f, 1.45818165e-03f, 5.05446419e-02f, -4.47504371e-02f, -4.82598245e-02f, 2.54697371e-02f, -6.71878606e-02f, -2.02755034e-02f, -8.41436163e-03f, -1.09239511e-01f,
  4.08596452e-03f, -7.68984184e-02f, -3.87872197e-02f, -2.50949692e-02f, -2.88969073e-02f, -1.88735791e-03f, -5.59609346e-02f, 4.01970604e-03f, -1.03876896e-01f, 1.07297236e-02f,
  -1.42533174e-02f, 2.38523576e-02f, 2.12318115e-02f, -8.15323219e-02f, 3.19393724e-02f, 2.93331500e-02f, -6.22729138e-02f, 5.98311191e-03f, -5.41806370e-02f, -3.78987659e-03f,
  6.16626395e-03f, -6.31196499e-02f, -9.44889523e-03f, 5.98676363e-03f, 2.89600734e-02f, -3.59100848e-02f, 3.48727480e-02f, -1.72162428e-02f, -4.78430390e-02f, -4.69916835e-02f,
  1.39518604e-01f, 7.85787255e-02f, -2.16729343e-02f, 1.03655988e-02f, 3.80396992e-02f, -3.15452479e-02f, -9.65754408e-03f, 5.71754649e-02f, 3.55952233e-02f, 5.07259145e-02f,
  3.98848988e-02f, 4.92942929e-02f, 2.95912866e-02f, -1.30439340e-03f, -7.41077065e-02f, 2.87378449e-02f, 3.98869514e-02f, 3.88946235e-02f, 3.77900936e-02f, 1.76415853e-02f,
  4.68566455e-02f, -2.57728472e-02f, -2.94340421e-02f, 7.85339847e-02f, 2.85120606e-02f, -2.97635738e-02f, -4.78882641e-02f, -3.01981829e-02f, -2.04456784e-02f, -1.48912296e-02f,
  -8.39701667e-02f, -2.62617379e-01f, -1.80698156e-01f, -9.02053416e-02f, 2.92523392e-02f, 9.26944241e-02f, -8.54929388e-02f, -5.85232787e-02f, -1.12910859e-01f, -1.49754226e-01f,
  1.30487785e-01f, -2.27482051e-01f, -6.32866248e-02f, -8.20239410e-02f, 1.74982116e-01f, -4.12771702e-02f, -7.93408900e-02f, 7.00767734e-04f, -1.13548683e-02f, -1.22607835e-01f,
  1.08298268e-02f, 1.00176409e-01f, -2.45736763e-02f, -2.05910541e-02f, -1.10913597e-01f, -1.06851228e-01f, 2.00100332e-01f, 9.69787594e-04f, 4.80018631e-02f, 4.20964527e-04f,
  -5.69902547e-03f, -1.51837483e-01f, -7.88863078e-02f, -7.06032738e-02f, -2.04949342e-02f, 1.89431885e-03f, -1.38043296e-02f, 4.37425151e-02f, 6.69182390e-02f, 1.79008693e-02f,
  8.10778365e-05f, 2.77708340e-02f, -4.87814248e-02f, 6.67870715e-02f, -4.62953039e-02f, -5.85660189e-02f, 3.09567060e-02f, 7.82821625e-02f, -1.06309287e-01f, 8.09892663e-04f,
  -6.63794279e-02f, 5.09790704e-02f, 4.05290797e-02f, -1.25933159e-02f, 3.39342877e-02f, 2.28700899e-02f, 2.59731095e-02f, -1.30841536e-02f, -3.10253929e-02f, -6.43579848e-03f,
  3.52668837e-02f, 9.02258232e-03f, 1.06048649e-02f, 3.64303589e-02f, 3.68251987e-02f, -5.48429266e-02f, 8.07229429e-02f, 2.12820359e-02f, -2.07922533e-02f, -7.38156587e-02f,
  7.13299289e-02f, 3.76985036e-03f, -6.87708333e-02f, 3.38230990e-02f, -3.09335254e-02f, -1.08063789e-02f, 7.26305554e-03f, 4.12956923e-02f, -4.53184582e-02f, 6.29867986e-02f,
  -7.76406936e-03f, -2.72266497e-03f, 3.63647845e-03f, 4.08997620e-03f, 4.28010076e-02f, -1.87871121e-02f, 2.86964942e-02f, -9.39007029e-02f, -3.45403068e-02f, 5.49131855e-02f,
  1.39212031e-02f, 3.03591415e-02f, -2.44530234e-02f, -7.66270654e-03f, 2.89773438e-02f, 4.75987457e-02f, -2.49829702e-02f, -5.41309416e-02f, -5.98868243e-02f, -9.69705917e-03f,
  6.65158629e-02f, 6.72923103e-02f, 8.08926448e-02f, 1.40461931e-02f, 9.23541859e-02f, -8.44254624e-03f, 4.63226438e-02f, 5.13072126e-03f, 3.21517773e-02f, 6.70671761e-02f,
  6.24376796e-02f, -1.08963600e-03f, 6.74587535e-03f, 2.20561996e-02f, 2.20603645e-02f, 6.98235771e-03f, -9.41734761e-02f, -3.67948902e-03f, 2.67353505e-02f, 4.48263576e-03f,
  -2.04531655e-01f, -2.22949311e-01f, 1.19859330e-01f, -2.09758393e-02f, 2.67920103e-02f, -5.43368198e-02f, 6.79104626e-02f, -1.55328214e-01f, -1.85434327e-01f, -1.34464011e-01f,
  -3.03046424e-02f, -9.29448754e-02f, 1.13073606e-02f, -1.05833851e-01f, 8.77296254e-02f, -1.73063613e-02f, -3.92844006e-02f, -6.78129941e-02f, 1.22089744e-01f, 2.05409969e-03f,
  1.56178232e-02f, -3.22086401e-02f, 1.30693257e-01f, 1.33419007e-01f, -1.38569117e-01f, -3.93163562e-02f, 1.84705496e-01f, 1.64207250e-01f, 7.89900571e-02f, 2.73435097e-03f,
  -1.10338144e-01f, -1.27359033e-01f, -9.46129486e-02f, 1.62229761e-02f, -6.70390278e-02f, -4.38869838e-03f, -4.80858376e-03f, 1.61681641e-02f, 1.61821432e-02f, 1.19203434e-03f,
  1.20660989e-02f, -4.32194062e-02f, -7.74857216e-03f, -2.19410025e-02f, -1.52282521e-01f, -6.61960095e-02f, -8.79120752e-02f, -6.70395233e-03f, 3.00303400e-02f, -4.29476285e-03f,
  -6.96784556e-02f, -5.23237549e-02f, 2.75526512e-02f, -5.43149337e-02f, 1.11716045e-02f, -4.16337885e-02f, 1.31366134e-01f, 6.37737140e-02f, -8.27063322e-02f, -6.08481690e-02f,
  1.12619832e-01f, 5.30489050e-02f, 1.12211267e-02f, -8.49483013e-02f, -4.22422290e-02f, 4.96274140e-03f, -6.02952614e-02f, 2.56898198e-02f, -2.16271356e-02f, -5.02122240e-03f,
  -4.18134779e-02f, -2.63843816e-02f, -6.02045134e-02f, -3.53455208e-02f, 2.28192899e-02f, -3.49976607e-02f, 8.17613900e-02f, -1.03789188e-01f, 3.86199504e-02f, -3.74119841e-02f,
  2.46297568e-02f, -9.88973584e-03f, -4.52834405e-02f, 4.97309156e-02f, -7.78440684e-02f, 7.42145702e-02f, -1.17529901e-02f, -8.82479027e-02f, 9.88246724e-02f, 5.46507947e-02f,
  -1.76662266e-01f, -5.46108447e-02f, 1.56960487e-02f, -1.32701948e-01f, 3.03177442e-03f, -4.78864759e-02f, 8.93302113e-02f, -4.75284420e-02f, 2.30529662e-02f, -2.71312203e-02f,
  1.32259950e-02f, -1.02504179e-01f, 3.24729495e-02f, -2.83566173e-02f, 4.98819873e-02f, -2.30099224e-02f, 8.72244388e-02f, -8.20010086e-04f, -6.83445930e-02f, -2.72221938e-02f,
  -3.32691446e-02f, 1.15306983e-02f, 7.09292740e-02f, 5.12088723e-02f, 4.41770302e-03f, 8.77460167e-02f, -2.67701522e-02f, -5.38071012e-03f, 7.35812783e-02f, 1.25746541e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.88180596e-01f, -7.75191486e-02f, 5.37392721e-02f, 2.21601292e-01f, 1.42027825e-01f, 1.81769744e-01f, 2.20578387e-01f, 1.04251921e-01f, 2.08794147e-01f, -2.69154042e-01f,
  -1.14370964e-01f, 3.52579355e-02f, -4.26492915e-02f, 1.97651088e-02f, 1.32418394e-01f, -5.44678941e-02f, 2.00076640e-01f, 1.87646553e-01f, 9.31878909e-02f, 3.30081489e-03f,
  7.41294622e-02f, -7.82577172e-02f, -3.06824237e-01f, -2.57181227e-01f, 1.52811974e-01f, -4.16634083e-02f, -1.89394251e-01f, -4.69627976e-02f, -1.67847335e-01f, 9.59256068e-02f,
  6.82907924e-02f, -5.10396361e-02f, 5.82463816e-02f, -6.89787865e-02f, -2.03513131e-02f, 7.88585544e-02f, -2.24226862e-02f, -3.48553360e-02f, 1.40176984e-02f, -6.89464360e-02f,
  -1.03413895e-01f, -8.38802904e-02f, -9.09180939e-02f, -4.29900065e-02f, 2.71796132e-03f, -6.47148117e-02f, -8.05830061e-02f, -1.03197545e-02f, -1.25103876e-01f, -5.31140827e-02f,
  -7.90273845e-02f, -6.08032905e-02f, -1.21221077e-02f, 1.76041052e-02f, 7.73943961e-02f, -2.47232243e-02f, -3.98530327e-02f, 1.01877078e-01f, 1.29149631e-02f, 2.92124245e-02f,
  -5.88800460e-02f, 7.66522139e-02f, 7.11959898e-02f, -1.91066077e-03f, 1.08046733e-01f, -4.37272154e-03f, -1.60467215e-02f, -7.38969743e-02f, 3.25654447e-02f, 1.05863288e-01f,
  1.09620064e-01f, -1.76608190e-02f, -4.15690690e-02f, -6.96863234e-02f, -1.64671559e-02f, -4.27100174e-02f, 1.00525096e-01f, 7.10396841e-02f, -1.28349494e-02f, -1.73077866e-01f,
  -4.57068682e-02f, 9.53880847e-02f, 2.20584366e-02f, -7.03994632e-02f, -3.99837620e-04f, 4.29553203e-02f, 1.63327157e-02f, -7.02583650e-03f, -8.17271918e-02f, 9.71972272e-02f,
  -3.71616744e-02f, 1.13086194e-01f, 3.00935600e-02f, -3.35144065e-02f, -3.93582880e-02f, 1.80960242e-02f, 9.85044762e-02f, -7.84974825e-03f, -3.99145707e-02f, -5.22246249e-02f,
  -1.67183839e-02f, 8.59972369e-03f, -3.29512171e-02f, -2.80470867e-02f, -7.58540034e-02f, -6.12103604e-02f, -7.30094463e-02f, -2.54249237e-02f, -1.40411451e-01f, -8.23971033e-02f,
  -3.43089690e-04f, -1.35887023e-02f, -3.65541503e-02f, -2.79843379e-02f, -5.02186306e-02f, -1.16508000e-01f, -4.49462868e-02f, 2.64789462e-02f, -2.97162086e-02f, -1.03008784e-02f,
  -2.50022709e-01f, 3.45846295e-01f, 3.17062855e-01f, -1.24414816e-01f, 1.00445189e-01f, -9.18221325e-02f, -3.01894575e-01f, 1.06466964e-01f, 3.26762050e-02f, 1.94786206e-01f,
  -6.07477166e-02f, 2.90612310e-01f, 3.81150804e-02f, -1.60236716e-01f, -3.70613337e-01f, -2.16326356e-01f, -2.55281240e-01f, -1.86543345e-01f, -3.98765504e-02f, -2.01088209e-02f,
  -1.62838161e-01f, -2.14256436e-01f, -1.01564057e-01f, 8.35447237e-02f, 1.72179416e-01f, 9.47779268e-02f, -3.36337149e-01f, 8.90831351e-02f, -2.99112555e-02f, 1.15375053e-02f,
  -2.19448373e-01f, 9.16675702e-02f, 2.62518041e-02f, 7.69062415e-02f, -7.09530488e-02f, 6.41018748e-02f, -8.83679092e-02f, -1.18212000e-01f, 2.02931073e-02f, 7.10724071e-02f,
  2.63289418e-02f, -1.12937344e-02f, -7.04149250e-03f, -3.33195068e-02f, 5.07683270e-02f, 6.50147572e-02f, 1.71859398e-01f, 5.77010075e-03f, 2.12966241e-02f, 6.37992192e-03f,
  1.30965933e-01f, 1.53946979e-02f, 2.23100819e-02f, -2.46710200e-02f, 1.53094068e-01f, 3.10852528e-02f, 7.46209128e-03f, -3.04045971e-03f, 1.08564027e-01f, 2.49075051e-03f,
  -1.16182424e-01f, -1.25200331e-01f, 4.77337167e-02f, -4.26263642e-03f, 9.30373073e-02f, -3.12900431e-02f, 1.03918873e-01f, -6.73657805e-02f, -4.83623594e-02f, -3.17970403e-02f,
  -7.84447491e-02f, -5.89167187e-03f, 4.88307066e-02f, -1.26466781e-01f, 1.73889275e-03f, -4.84174155e-02f, -4.26405706e-02f, -2.88669448e-02f, -9.08222198e-02f, 2.81182304e-02f,
  -6.97294623e-02f, -9.19905454e-02f, -2.15998031e-02f, -5.95790893e-02f, -9.50098876e-03f, -3.82988863e-02f, 2.64539868e-02f, -1.67654026e-02f, -8.89431536e-02f, -2.36877743e-02f,
  -3.47376168e-01f, -2.23399550e-01f, -8.35180581e-02f, 7.23274201e-02f, -3.52696665e-02f, -2.57354900e-02f, 1.45426542e-02f, -2.91500855e-02f, -8.91246796e-02f, -7.73677975e-02f,
  -3.42263356e-02f, -9.12335366e-02f, 8.22010357e-03f, 1.87915415e-02f, -9.77931544e-02f, -1.65565640e-01f, -1.03105359e-01f, 2.73498055e-02f, -5.57935499e-02f, 4.60345596e-02f,
  5.43241873e-02f, -8.95608682e-03f, 2.27737264e-03f, -9.26378071e-02f, -1.13710491e-02f, 2.57555470e-02f, -2.34035458e-02f, -1.14699146e-02f, -1.10455975e-02f, -7.87274688e-02f,
  -3.31747800e-01f, -3.33696604e-01f, -1.39935270e-01f, -1.15391396e-01f, 2.17315450e-01f, 7.21404776e-02f, -3.47766340e-01f, 4.40434515e-02f, -2.58169085e-01f, -1.25695661e-01f,
  -5.20701036e-02f, -6.85489550e-02f, -2.10516483e-01f, 1.56241655e-01f, 1.74192160e-01f, -8.69022161e-02f, 2.41754860e-01f, 1.11912727e-01f, -4.49453965e-02f, -5.25473617e-03f,
  5.08194007e-02f, 1.91594198e-01f, 8.06519762e-02f, 2.40847409e-01f, 1.70261994e-01f, 9.18273628e-02f, 2.07218453e-01f, 1.02108672e-01f, 2.61293858e-01f, 1.97871193e-01f,
  -4.52696979e-02f, -1.31436646e-01f, -1.28739309e-02f, 5.22327684e-02f, 4.37578000e-02f, -1.81914598e-03f, 1.46613466e-02f, 5.49028292e-02f, 7.03497007e-02f, -5.35358535e-03f,
  -6.69733733e-02f, 1.42939538e-01f, 1.57556459e-01f, 3.82154770e-02f, -4.79900390e-02f, 4.77821715e-02f, 7.87146762e-03f, 4.08001281e-02f, -1.07663341e-01f, -7.15776309e-02f,
  -1.47170737e-01f, -4.17073630e-02f, -3.42998952e-02f, 2.38851197e-02f, -1.25828981e-01f, 3.69973853e-02f, -2.47803926e-02f, -7.72336572e-02f, 1.64794490e-01f, 1.01118805e-02f,
  -3.76754478e-02f, 5.24066128e-02f, -8.25845599e-02f, 1.41507508e-02f, -2.80376822e-02f, -1.73096247e-02f, 5.26133850e-02f, 8.06725025e-02f, 1.87858306e-02f, -7.24806115e-02f,
  2.01629195e-02f, 6.20924495e-02f, -8.36799592e-02f, -1.23927847e-03f, 9.16141272e-02f, 4.77589406e-02f, -4.08826731e-02f, 3.07689924e-02f, -9.94724035e-02f, 1.65193416e-02f,
  8.17892887e-03f, -1.60270650e-03f, -6.53265044e-02f, -6.13718368e-02f, 1.00323446e-02f, -8.91765952e-02f, 1.62126292e-02f, -9.41415057e-02f, -3.51170003e-02f, 9.56379771e-02f,
  -1.75829995e-02f, -3.54137421e-02f, 2.24895868e-02f, 3.71835046e-02f, -9.04780440e-03f, 2.86801010e-02f, -1.78906997e-03f, 1.06319658e-01f, -2.64524901e-03f, 2.04912368e-02f,
  8.90454557e-03f, 2.22374741e-02f, 1.85550097e-02f, -2.63521038e-02f, 1.90794453e-01f, -9.89607126e-02f, -7.53278583e-02f, -6.90209121e-02f, -2.00814512e-02f, 2.63436735e-02f,
  -2.95446608e-02f, -6.40415624e-02f, 1.07929222e-01f, 3.94210778e-02f, 7.14961663e-02f, -4.93483059e-02f, 4.98461425e-02f, -8.49506706e-02f, 1.19436182e-01f, -6.87201619e-02f,
  3.21263313e-01f, -1.33816928e-01f, -2.63894469e-01f, 3.04659307e-02f, 1.95891351e-01f, 2.98315942e-01f, 1.42917216e-01f, 1.89609632e-01f, 1.87225997e-01f, -7.26512074e-02f,
  9.68764871e-02f, -7.33438507e-02f, -2.13081732e-01f, 1.57512203e-01f, 2.77625024e-01f, -1.04035735e-01f, 2.44778439e-01f, 1.35495186e-01f, 1.33607358e-01f, 1.39664680e-01f,
  2.00400352e-01f, 3.14649999e-01f, -2.41389334e-01f, -2.72183158e-02f, 1.89624116e-01f, -1.78852320e-01f, -2.82303125e-01f, -2.48016983e-01f, -7.91997984e-02f, 7.50480518e-02f,
  1.08041078e-01f, 9.25110951e-02f, -1.01007007e-01f, 1.82749256e-02f, -2.11927556e-02f, -2.76093539e-02f, -1.41866669e-01f, -4.56112698e-02f, -6.70179427e-02f, 5.60221225e-02f,
  -3.83312628e-02f, -9.81068145e-03f, 1.83457673e-01f, -5.74536473e-02f, 1.27690986e-01f, 5.70639372e-02f, -1.22375460e-02f, -8.07577074e-02f, -1.07423514e-01f, -5.35683818e-02f,
  4.34053391e-02f, -7.68002942e-02f, 6.24399893e-02f, -1.05567977e-01f, 3.55145112e-02f, 2.13301810e-03f, -2.21015103e-02f, -7.77861550e-02f, -2.63553322e-03f, 4.78340797e-02f,
  5.74562661e-02f, -1.79272294e-02f, 9.11902636e-02f, 7.52324611e-02f, 5.54388128e-02f, -1.01709999e-01f, 4.80256155e-02f, -6.37953877e-02f, 5.51032647e-02f, -1.08869195e-01f,
  4.53144275e-02f, 2.64147576e-02f, 7.61449710e-02f, 1.07190043e-01f, -1.09785311e-02f, 5.43314265e-03f, 4.40396033e-02f, -3.46931405e-02f, 3.51981074e-02f, 9.53568053e-03f,
  -4.46273163e-02f, 1.82882845e-02f, -6.31773770e-02f, -2.14852188e-02f, -1.69147700e-02f, 2.82458179e-02f, 5.23205400e-02f, 1.24189781e-03f, -4.68351319e-02f, -8.37785676e-02f,
  3.87218110e-02f, -1.35614634e-01f, -3.87136154e-02f, -4.19150926e-02f, -7.59621114e-02f, 9.46844518e-02f, -6.04662821e-02f, 7.49712735e-02f, 2.38290224e-02f, 1.41790956e-01f,
  -2.35295407e-02f, -3.60136554e-02f, 5.17707951e-02f, 6.32783100e-02f, -4.46055345e-02f, 1.35698825e-01f, 1.71049088e-02f, -3.73430625e-02f, -1.24776743e-01f, 6.11183001e-03f,
  -3.69474031e-02f, 1.30965054e-01f, -5.66330180e-02f, 7.76124895e-02f, 2.98477407e-03f, -5.94978295e-02f, 1.32768042e-02f, -2.11674273e-02f, 1.57509297e-02f, -5.35481647e-02f,
  -6.19671285e-01f, 3.14959496e-01f, 4.28955741e-02f, -2.43020654e-01f, 9.32037272e-03f, -4.33417559e-02f, 1.17361866e-01f, 4.84323725e-02f, -3.11823860e-02f, 1.95508406e-01f,
  1.21176399e-01f, -1.72029987e-01f, 1.95342034e-01f, 1.40839592e-01f, -1.38150230e-01f, 2.23909914e-01f, -1.31559983e-01f, 2.17753137e-03f, -1.35384733e-02f, -9.12117809e-02f,
  -1.80686161e-01f, 5.51995123e-03f, -2.02099374e-03f, 7.11914748e-02f, -1.14083119e-01f, -1.34457067e-01f, -9.26804841e-02f, 9.86728966e-02f, -2.82520782e-02f, 7.50629650e-03f,
  -2.72627115e-01f, -2.76557446e-01f, -1.90966606e-01f, -1.28923327e-01f, -5.24352677e-02f, -8.63581430e-03f, -1.04108676e-01f, 7.20202401e-02f, -1.10807143e-01f, -7.29258358e-02f,
  -5.11438027e-02f, 5.42048439e-02f, -6.49706796e-02f, 1.59808211e-02f, -1.17641307e-01f, -1.48863178e-02f, -2.73477323e-02f, -9.90312546e-02f, 8.62841979e-02f, 7.80484900e-02f,
  1.50893241e-01f, -4.79489788e-02f, -4.14578989e-02f, -5.98086752e-02f, 3.04982476e-02f, -1.51869589e-02f, -6.11970872e-02f, -4.54009250e-02f, -1.47067472e-01f, -5.92609495e-02f,
  1.83132105e-02f, -1.33902088e-01f, 1.13803837e-02f, 5.90160638e-02f, 7.05946013e-02f, 1.78234733e-03f, 2.20754500e-02f, -3.30906622e-02f, -9.90490392e-02f, -1.08746633e-01f,
  -1.56792328e-01f, -7.21522272e-02f, -3.22210863e-02f, -2.15654708e-02f, -6.77390844e-02f, 6.70461357e-02f, 7.61896595e-02f, -6.15093915e-04f, -1.82591472e-02f, -3.01115420e-02f,
  5.19524589e-02f, 4.91712317e-02f, 2.18199324e-02f, -5.81982471e-02f, -5.06855845e-02f, 5.11405170e-02f, 1.54564762e-02f, 9.63714123e-02f, -5.37799560e-02f, -4.09761928e-02f,
  -3.36008936e-01f, -4.23466504e-01f, 2.65193470e-02f, -3.62495072e-02f, 4.27845195e-02f, -6.24260772e-03f, -8.68643373e-02f, -1.49681494e-02f, -7.90055841e-02f, -1.35720707e-02f,
  -6.81138560e-02f, 2.21953876e-02f, -6.96799085e-02f, -5.26233725e-02f, 8.49920418e-03f, -1.87981427e-02f, 7.99986124e-02f, -1.16231814e-01f, -1.41447261e-01f, -6.76757470e-02f,
  5.91444708e-02f, 1.45395612e-02f, 1.03782624e-01f, -1.10089481e-01f, -7.58919790e-02f, -5.66161014e-02f, -5.01423590e-02f, -4.46529835e-02f, -2.04382151e-01f, 3.04422230e-02f,
  2.27853268e-01f, -1.56597629e-01f, -1.78069144e-01f, -1.44804060e-01f, 1.80037573e-01f, 1.67129815e-01f, -1.57763794e-01f, 3.75097208e-02f, -3.16723645e-01f, -4.27521840e-02f,
  1.98756143e-01f, -1.67530119e-01f, -1.41314730e-01f, 1.18403800e-01f, 2.24075884e-01f, -2.37860486e-01f, 2.79412150e-01f, 5.35163060e-02f, -1.13190986e-01f, 1.16648771e-01f,
  -4.68332767e-02f, 2.70185739e-01f, -1.07444890e-01f, 2.38284633e-01f, 1.40746534e-01f, 3.27781978e-04f, 2.01612681e-01f, -1.16433732e-01f, 2.24269181e-01f, 1.56346306e-01f,
  -1.80689283e-02f, -5.12670800e-02f, 9.58386436e-03f, -6.36551622e-03f, -6.55545155e-03f, 9.53963846e-02f, 1.09789595e-02f, -6.18705302e-02f, -3.50520089e-02f, 2.22830940e-03f,
  -5.82856536e-02f, -4.66740727e-02f, 1.08488478e-01f, -6.14000633e-02f, 1.27206191e-01f, -7.33288229e-02f, -9.81260613e-02f, -3.10874339e-02f, -5.45741059e-02f, -4.81042825e-02f,
  -6.64190799e-02f, 2.92891804e-02f, 8.85992050e-02f, 2.35539582e-02f, -7.21055046e-02f, -1.45354206e-02f, -3.63682844e-02f, -3.78728062e-02f, 3.33565846e-02f, -4.05679606e-02f,
  1.21952139e-01f, -6.81575760e-03f, 4.18198705e-02f, 4.99061532e-02f, -8.06366373e-03f, -5.42007536e-02f, 7.51303062e-02f, -9.30198934e-03f, -1.86512470e-02f, -8.22541937e-02f,
  -7.50999525e-03f, 6.59075454e-02f, 1.81087311e-02f, -2.06728801e-04f, 9.44738761e-02f, -6.81280345e-02f, -4.78625298e-02f, 1.01056248e-01f, -1.15637124e-01f, 8.74345228e-02f,
  -8.00243914e-02f, 3.81704532e-02f, 1.52371014e-02f, 9.71597910e-04f, 8.58671125e-03f, -3.03252209e-02f, -3.23257111e-02f, 3.31765302e-02f, -3.70451845e-02f, 2.19430793e-02f,
  6.64608181e-02f, 1.67574268e-02f, -4.67381813e-02f, 2.61081066e-02f, -1.16163515e-01f, 5.49006723e-02f, 6.35895282e-02f, 1.31344751e-01f, -6.16913242e-03f, -2.98846252e-02f,
  6.28068373e-02f, 3.10105979e-02f, 6.54592225e-03f, -1.62527692e-02f, 4.26382944e-02f, -4.13542017e-02f, 1.48950601e-02f, -8.95920321e-02f, 6.76946342e-02f, 5.27866967e-02f,
  1.15522137e-02f, 5.82178384e-02f, -1.17515996e-02f, 8.44726637e-02f, -4.86324243e-02f, 9.67140570e-02f, 9.58436402e-04f, -1.21589959e-01f, 4.30907123e-02f, -4.96210121e-02f,
  3.71752828e-01f, -1.51766278e-03f, 2.14014813e-01f, 2.02353984e-01f, 1.37363270e-01f, 2.36509785e-01f, 1.06172457e-01f, 9.55194384e-02f, 2.21504316e-01f, -2.74852365e-01f,
  -1.74439505e-01f, 1.26824841e-01f, -2.85401084e-02f, 5.95798492e-02f, 2.96926629e-02f, 9.78081301e-02f, 4.19469026e-04f, -1.25535235e-01f, 1.40089571e-01f, 2.24334419e-01f,
  7.27663338e-02f, -1.54667333e-01f, 1.73181698e-01f, -1.05568349e-01f, 1.10571468e-02f, -8.20513889e-02f, -2.62329698e-01f, -6.79698735e-02f, -2.68982977e-01f, -1.82071567e-01f,
  6.26349524e-02f, 1.40057027e-01f, 1.61886871e-01f, -7.85746351e-02f, 3.99452373e-02f, -1.18510410e-01f, -3.62899862e-02f, -4.23335768e-02f, -2.89550330e-02f, 3.63472663e-02f,
  3.92239057e-02f, -9.41905305e-02f, 5.22376113e-02f, -5.99535974e-03f, 4.27532494e-02f, 6.15290366e-02f, 2.20241323e-01f, 2.62086689e-01f, 3.77316512e-02f, 9.30750370e-02f,
  1.59955248e-01f, -8.26229714e-03f, 1.38305500e-01f, -2.10153252e-01f, 6.91413134e-02f, -2.12616138e-02f, 9.21376050e-02f, -1.98174492e-01f, -1.84413761e-01f, 1.68625236e-01f,
  1.44760191e-01f, -9.60942134e-02f, -1.08602300e-01f, -1.34193346e-01f, -1.72064960e-01f, -3.85980867e-02f, -5.24193607e-02f, -7.24790338e-03f, 4.48769554e-02f, 2.93225497e-02f,
  1.68462992e-02f, -4.59436998e-02f, -4.75303158e-02f, 2.98602730e-02f, 8.01729187e-02f, 3.90611365e-02f, -6.27690703e-02f, -1.76186815e-01f, 7.00729042e-02f, 1.02490030e-01f,
  5.24739921e-02f, -1.32014289e-01f, -3.68845686e-02f, -3.57177132e-03f, -1.15031257e-01f, 5.42262979e-02f, 8.60487297e-02f, -1.12756200e-01f, 2.05244601e-01f, 7.98800960e-02f,
  9.99196526e-03f, -9.55017209e-02f, -7.51662860e-03f, 3.94987129e-02f, -7.49867931e-02f, -1.88890249e-02f, 7.34747201e-02f, -8.12416449e-02f, 6.09163977e-02f, 9.10944045e-02f,
  -2.47595808e-03f, -9.98051614e-02f, 1.32585838e-01f, -1.91912293e-01f, 5.97804710e-02f, 1.35018826e-01f, 4.30013686e-02f, 3.08476301e-04f, -6.43043593e-02f, -1.84098203e-02f,
  -5.86671382e-02f, 8.14128593e-02f, 2.31605838e-03f, 2.04094741e-02f, -1.26042008e-01f, -1.66091114e-01f, 6.69727623e-02f, -1.38419539e-01f, 9.70981345e-02f, 1.40062660e-01f,
  1.52295128e-01f, 1.32405700e-03f, 1.44683018e-01f, -3.21579099e-01f, 8.58750120e-02f, 3.81795675e-01f, 1.14532575e-01f, -1.90334693e-02f, -2.22862959e-01f, -2.59221405e-01f,
  -1.20012976e-01f, -2.36462876e-01f, -3.49694975e-02f, 2.82749441e-02f, 2.01853618e-01f, -5.71152680e-02f, 9.00166035e-02f, -1.36586919e-01f, 9.02135223e-02f, 1.58563331e-02f,
  2.74797622e-02f, 3.44341435e-02f, 2.02901185e-01f, 7.99263939e-02f, 1.27951950e-01f, -1.80946484e-01f, -2.69010097e-01f, 4.38552871e-02f, -6.60033301e-02f, 6.89760894e-02f,
  1.45406663e-01f, 6.23075925e-02f, 1.73205376e-01f, 1.08852647e-01f, 1.31960794e-01f, 2.01606769e-02f, 5.56048565e-02f, -3.05589754e-02f, -5.01386225e-02f, -1.22393526e-01f,
  -6.59284368e-02f, -3.15150060e-02f, -9.27326828e-02f, -5.27117774e-02f, -2.01944839e-02f, -7.75265843e-02f, 1.55088427e-02f, -3.63963023e-02f, -1.05065115e-01f, 1.59549341e-01f,
  7.07503036e-02f, -1.40434489e-01f, -3.43061015e-02f, -1.74640849e-01f, -1.05493791e-01f, -2.12129250e-01f, 1.10521596e-02f, 2.11476050e-02f, 2.52826456e-02f, -3.91120873e-02f,
  2.39816755e-02f, 1.28610477e-01f, 5.39652258e-02f, 8.73542204e-02f, 6.50860295e-02f, 1.94678977e-02f, 4.66107987e-02f, 3.45196053e-02f, -3.58018056e-02f, 3.06481160e-02f,
  -6.32642806e-02f, -1.24959759e-01f, 3.59683521e-02f, 5.90580478e-02f, 4.93007228e-02f, 9.18067694e-02f, -2.31456254e-02f, -3.85948382e-02f, -5.78860939e-02f, -1.69348214e-02f,
  4.81709838e-03f, -4.36029956e-02f, -6.32836074e-02f, -1.35270953e-01f, 1.49542408e-03f, 6.80845454e-02f, -6.21867217e-02f, -5.50682843e-02f, 5.54997064e-02f, 8.68226960e-02f,
  1.68900155e-02f, -8.83655697e-02f, 4.36938070e-02f, 2.58194339e-02f, 2.77012009e-02f, 1.50478184e-01f, 6.66960627e-02f, 9.13057104e-03f, -2.89137997e-02f, 6.35748729e-02f,
  -7.05909878e-02f, -3.19698006e-02f, -4.82350811e-02f, 1.48366822e-03f, -1.77165836e-01f, 1.80431664e-01f, -1.49021208e-01f, -1.10944612e-02f, -1.86071634e-01f, -6.51065111e-02f,
  -4.66051996e-02f, -3.91460322e-02f, -8.33421722e-02f, -9.73120853e-02f, -2.04097763e-01f, -1.91053107e-01f, 4.56853444e-03f, -2.65723374e-02f, -8.84087235e-02f, -1.63072214e-01f,
  -2.93591529e-01f, 2.18342096e-01f, 2.26648189e-02f, 1.09050818e-01f, -2.11589009e-01f, -1.89954392e-03f, 2.98330858e-02f, 8.26906189e-02f, -2.11718321e-01f, 1.88297212e-01f,
  2.49056354e-01f, -1.63538083e-01f, 1.79527670e-01f, 2.45986268e-01f, -3.10251093e-03f, 3.00641805e-01f, 2.67283261e-01f, 1.54040977e-01f, -7.40514882e-03f, 1.45397022e-01f,
  1.26334742e-01f, 1.28791735e-01f, 2.96028942e-01f, 1.26440600e-01f, 3.39367092e-02f, 8.08875263e-02f, 1.14046596e-01f, -1.94246098e-02f, 1.34863824e-01f, -1.98683277e-01f,
  1.33291818e-02f, 3.41134109e-02f, -1.50008462e-02f, -3.44544724e-02f, 7.63365105e-02f, -9.87201557e-02f, 1.65432878e-02f, -1.04227223e-01f, -2.92241294e-02f, -6.11634441e-02f,
  -1.22070782e-01f, -3.45377848e-02f, 5.09506576e-02f, -3.40453200e-02f, -5.00011146e-02f, 1.83391459e-02f, -1.78147722e-02f, -4.92239697e-03f, -4.97766696e-02f, 3.32589038e-02f,
  4.94875647e-02f, -8.62157810e-03f, -1.58542413e-02f, 1.67575434e-01f, 2.02707294e-02f, 3.02091930e-02f, 1.17815640e-02f, -1.81339420e-02f, 6.17176369e-02f, 3.16160470e-02f,
  1.03160247e-01f, -1.04252785e-01f, 1.87160112e-02f, 2.47355402e-02f, 3.25545333e-02f, 1.06823519e-02f, 1.06679045e-01f, 7.86127150e-02f, -1.20230764e-01f, 1.06154807e-01f,
  -9.62626860e-02f, -1.00929007e-01f, -4.23527509e-02f, -9.31589901e-02f, 3.86217125e-02f, -8.53729099e-02f, -3.05635165e-02f, 5.64991683e-03f, -2.05797274e-02f, 3.14199030e-02f,
  -1.09869927e-01f, -1.73502937e-02f, 8.80808104e-03f, 8.08234140e-02f, -6.38501644e-02f, -6.37978837e-02f, 5.60467318e-02f, -1.88608300e-02f, 4.33008187e-02f, -1.49816312e-02f,
  2.26339325e-01f, 6.66215941e-02f, 1.22444399e-01f, -1.01566099e-01f, 5.47415689e-02f, -2.82579735e-02f, 5.15265353e-02f, 1.80331729e-02f, 1.17424257e-01f, -6.11193255e-02f,
  -8.04461613e-02f, -6.58691674e-02f, 5.47849610e-02f, -5.94170913e-02f, 3.79601307e-02f, 3.49063091e-02f, 4.70881090e-02f, -9.81382839e-03f, 2.02195160e-03f, 1.03233933e-01f,
  9.09045339e-02f, -1.85956173e-02f, 4.68280539e-02f, -2.43616421e-02f, 7.13521391e-02f, 2.85702851e-02f, 2.92154215e-02f, -3.10891122e-02f, -6.25319257e-02f, 9.65153873e-02f,
  -6.30798265e-02f, 2.47680247e-01f, -1.18412673e-01f, 9.23726186e-02f, -2.94405222e-01f, 3.44693840e-01f, 2.59251624e-01f, 1.11644872e-01f, 2.79112339e-01f, 2.25234374e-01f,
  -9.76972431e-02f, 2.33387664e-01f, 4.03145608e-03f, 5.69618819e-03f, 1.33815438e-01f, 1.87371239e-01f, 2.33629659e-01f, 1.18030004e-01f, 1.07034661e-01f, -4.13933061e-02f,
  -1.31209139e-02f, -6.95175901e-02f, -2.97773778e-01f, -1.10014223e-01f, -2.72924572e-01f, -1.32779419e-01f, -2.49292776e-01f, -1.09127849e-01f, -7.44785890e-02f, -1.22409321e-01f,
  6.81299157e-03f, -4.65775989e-02f, -1.19466364e-01f, 1.10947564e-01f, 1.50894634e-02f, -3.86885740e-02f, -3.59864682e-02f, 1.33467475e-02f, -6.00337386e-02f, -1.54534802e-02f,
  1.53783306e-01f, 2.82808840e-02f, 2.05462411e-01f, 4.61748652e-02f, -8.31794459e-03f, 5.51833324e-02f, -3.52970622e-02f, 4.03834460e-03f, -1.62404273e-02f, -6.71182051e-02f,
  -6.85670078e-02f, 5.61863557e-02f, -5.52890897e-02f, 2.87310015e-02f, -7.87142664e-02f, -1.59530584e-02f, 1.72957718e-01f, -8.87445062e-02f, 1.41161099e-01f, 3.27224322e-02f,
  -1.36076808e-01f, 7.11222067e-02f, -1.98534932e-02f, -7.39495680e-02f, 8.87116492e-02f, -7.18038008e-02f, -4.94979173e-02f, -6.95073083e-02f, -2.92626917e-02f, -8.28325748e-03f,
  6.64847046e-02f, -2.65974104e-02f, -1.61534082e-02f, -8.36321060e-03f, 3.40882577e-02f, 5.89574240e-02f, -3.39416564e-02f, -6.54580370e-02f, 7.21743405e-02f, 2.99181007e-02f,
  -8.36169794e-02f, 7.98753202e-02f, 1.85418379e-04f, -2.05703974e-02f, 2.97397003e-02f, -5.30063882e-02f, -1.02040827e-01f, -5.73030412e-02f, 4.03333195e-02f, -1.82964467e-02f,
  2.05265675e-02f, 1.96750268e-01f, 6.67644814e-02f, 2.69139688e-02f, 1.37131914e-01f, 3.59350070e-03f, 8.79005566e-02f, 6.80977702e-02f, 6.74771471e-03f, 7.82796461e-03f,
  1.05103895e-01f, -1.10006873e-02f, 3.37249041e-02f, -5.58564393e-03f, 9.12721455e-02f, 3.36968191e-02f, 4.32504490e-02f, 2.08790470e-02f, 4.51100133e-02f, -1.62466094e-01f,
  2.28510052e-02f, 6.63581938e-02f, -4.47008852e-03f, 1.00093752e-01f, 7.54811987e-02f, -5.33977114e-02f, 1.38256922e-01f, 2.51838914e-03f, -4.43146154e-02f, -1.07615264e-02f,
  1.58084765e-01f, -1.46135643e-01f, 2.82330722e-01f, 2.71813441e-02f, -1.59032282e-03f, 9.45008919e-02f, 3.24311942e-01f, -1.35037467e-01f, -9.16430876e-02f, -2.37052038e-01f,
  -5.69289401e-02f, 3.38763654e-01f, 2.20038727e-01f, -4.22334522e-02f, 2.29565531e-01f, 4.19382304e-02f, -6.96137026e-02f, 2.30203792e-01f, -5.77335507e-02f, -3.73366512e-02f,
  -1.94814622e-01f, -3.06767762e-01f, 1.04429327e-01f, -3.01258087e-01f, 1.21645451e-01f, -1.06016800e-01f, -7.67915249e-02f, 1.60673290e-01f, -5.83843850e-02f, 7.46281445e-02f,
  6.21385649e-02f, -8.65471363e-02f, 3.93085629e-02f, 3.54590677e-02f, 1.82152633e-02f, 6.84324652e-02f, 8.88357311e-02f, 4.05338556e-02f, 1.26817390e-01f, -5.93280084e-02f,
  1.72231257e-01f, 4.54441644e-02f, -2.32556779e-02f, 4.06063199e-02f, 7.91559592e-02f, -1.04804216e-02f, 8.41225218e-03f, 4.51538619e-03f, 1.44079238e-01f, 1.19491480e-01f,
  -1.41140837e-02f, 9.01427492e-02f, -3.70216779e-02f, -2.81908419e-02f, 1.63591579e-02f, 4.60150465e-02f, -3.38542201e-02f, 7.82845169e-02f, -4.69541475e-02f, -8.44894275e-02f,
  8.22127312e-02f, -1.08890526e-01f, -5.62414154e-02f, -4.54610325e-02f, -2.91515235e-02f, 7.55925663e-03f, 8.68367963e-03f, -1.41153976e-01f, 4.31117266e-02f, 1.86376888e-02f,
  -3.52823548e-02f, 1.53191574e-02f, -1.18928112e-01f, -7.00915279e-03f, -1.31570354e-01f, -1.40424341e-01f, 1.01030737e-01f, -1.84777137e-02f, 6.84250379e-03f, -8.63459855e-02f,
  -1.33694291e-01f, -2.01259684e-02f, 1.14335269e-01f, -3.28048319e-02f, 4.25272714e-03f, -8.96915887e-03f, -1.36209249e-01f, 1.17137700e-01f, 1.47543391e-02f, 2.41687540e-02f,
  -1.69867836e-02f, -2.46819064e-01f, 3.02924830e-02f, -1.46138370e-02f, 3.06974985e-02f, -1.10022612e-02f, -2.04755273e-02f, -1.85861159e-02f, 4.44352962e-02f, 1.73968747e-02f,
  -8.39396939e-02f, -4.03726362e-02f, -7.95183480e-02f, -8.94287154e-02f, 7.58329257e-02f, -6.02574646e-02f, 3.23601030e-02f, 2.35766862e-02f, -6.45176321e-02f, -5.87942451e-02f,
  4.52492237e-02f, 2.71723103e-02f, 1.21794917e-01f, -1.50859319e-02f, -4.38843817e-02f, 3.41905244e-02f, -6.93272129e-02f, 1.02515705e-01f, 7.10686594e-02f, 7.45279491e-02f,
  -4.02512848e-01f, 2.33850144e-02f, -7.24591389e-02f, -1.30533367e-01f, -2.34298721e-01f, -1.33292705e-01f, -3.97194698e-02f, -1.61547333e-01f, -3.22276503e-02f, 2.67166227e-01f,
  1.44709600e-02f, -1.91017181e-01f, 2.15097696e-01f, 1.31192684e-01f, -2.59989411e-01f, 2.57957935e-01f, 6.71662465e-02f, 4.56645265e-02f, -1.01920955e-01f, -2.80166507e-01f,
  -3.86359286e-03f, -1.20469853e-01f, 2.21607536e-02f, -4.54787277e-02f, -1.72562599e-01f, -1.99623808e-01f, -5.37757501e-02f, -1.89794257e-01f, -4.29304913e-02f, -9.35269520e-02f,
  -2.16594309e-01f, -1.00414082e-01f, -1.99597001e-01f, -1.35930017e-01f, -3.53378966e-03f, -5.03712194e-03f, -5.44659281e-03f, -7.13078827e-02f, -1.01600632e-01f, -8.30817521e-02f,
  -6.53704777e-02f, -7.69561976e-02f, 5.13369329e-02f, -1.30959116e-02f, -6.14523143e-02f, -2.11038324e-03f, -7.62949698e-03f, 5.68250082e-02f, -1.35098696e-01f, 7.03251362e-03f,
  -3.72553952e-02f, -2.03481205e-02f, -1.86766554e-02f, 1.48659497e-01f, -1.07284077e-01f, -8.14232901e-02f, 4.48715575e-02f, -6.36174306e-02f, -1.06623612e-01f, -1.02526672e-01f,
  3.99463670e-03f, 8.23394209e-03f, -7.45617524e-02f, 6.52378127e-02f, 2.06228439e-03f, 6.46878555e-02f, -1.27366679e-02f, 5.15145548e-02f, 4.35282588e-02f, 4.18938622e-02f,
  4.82622869e-02f, -5.61935194e-02f, -3.37363034e-03f, -3.18229347e-02f, 2.60390118e-02f, 2.13339273e-02f, -8.17926899e-02f, -4.24118675e-02f, 7.69145340e-02f, 3.76671329e-02f,
  -3.35666351e-02f, -2.61666719e-02f, 1.21454060e-01f, 6.10514469e-02f, -7.29749426e-02f, -9.92474630e-02f, -3.84435058e-03f, 9.28601325e-02f, -1.19818887e-02f, -1.17795959e-01f,
  -2.32265338e-01f, -2.71065146e-01f, -5.52724637e-02f, -9.22909379e-03f, -8.71720240e-02f, -4.92319725e-02f, 4.29233816e-03f, -1.07527941e-01f, 1.23393498e-02f, -1.14939392e-01f,
  2.06112047e-03f, 8.09802711e-02f, -1.03169590e-01f, -1.12726577e-02f, 5.34165837e-02f, -2.61306507e-03f, -1.76033136e-02f, 6.02904297e-02f, -7.62094781e-02f, 4.62763710e-03f,
  -2.76014507e-02f, 7.25386590e-02f, 5.93704917e-02f, 1.03189677e-01f, 4.92656566e-02f, 1.19740935e-02f, -5.48331179e-02f, 4.22472805e-02f, -9.79855210e-02f, -2.58237105e-02f,
  1.72368437e-01f, -1.77291296e-02f, -6.64116293e-02f, -1.41456336e-01f, -4.07932959e-02f, -2.03481734e-01f, -2.48818293e-01f, -7.67282397e-02f, -8.86028185e-02f, 1.02252938e-01f,
  1.84650924e-02f, 9.16100815e-02f, -1.76909611e-01f, -1.01974651e-01f, -1.85012266e-01f, -2.17629969e-01f, 7.86476731e-02f, -1.55911699e-01f, -8.97129774e-02f, 1.69485241e-01f,
  -2.39934474e-02f, 6.17492124e-02f, -6.28909618e-02f, 1.86992049e-01f, 1.51198074e-01f, 3.86119708e-02f, 1.22581504e-01f, -4.50590625e-02f, 5.60095645e-02f, -1.91516131e-02f,
  -4.00296822e-02f, 9.06666294e-02f, -6.77711666e-02f, 2.25887191e-03f, -2.58243047e-02f, 1.92090534e-02f, 1.87405292e-02f, 6.12855628e-02f, -1.09957084e-01f, -9.05556455e-02f,
  3.41233797e-02f, -1.77816756e-03f, -5.13694175e-02f, -4.47996855e-02f, -2.69001871e-02f, 4.53426391e-02f, -9.18753445e-02f, -4.69611352e-03f, -1.19831592e-01f, 4.79664989e-02f,
  -4.05203700e-02f, -8.64792243e-02f, 5.83722182e-02f, -1.41891956e-01f, -3.90157662e-02f, 3.27404402e-02f, -1.64507460e-02f, 3.01189534e-02f, -8.64589214e-03f, 5.12469783e-02f,
  4.95009907e-02f, -9.75271512e-04f, 2.11126376e-02f, -6.17095344e-02f, 1.34210673e-03f, -5.43966144e-02f, -7.57355466e-02f, 1.32219987e-02f, -8.58222246e-02f, 4.80674431e-02f,
  -3.45305651e-02f, -1.56565532e-02f, -2.90983878e-02f, -3.98262357e-03f, 1.69829801e-02f, -2.38270648e-02f, 5.18689044e-02f, 7.21631721e-02f, 2.43164003e-02f, -2.24221107e-02f,
  7.58832647e-03f, 3.62261129e-03f, 1.59289856e-02f, -7.76453018e-02f, -6.29548216e-04f, 1.82255134e-02f, 1.03240944e-01f, 8.30717087e-02f, -7.34993890e-02f, -2.21419111e-02f,
  4.39274050e-02f, 1.81928679e-01f, -3.24079511e-03f, -1.22087188e-01f, -4.23301123e-02f, -1.09474985e-02f, 5.12672327e-02f, 4.59619947e-02f, 2.10194364e-02f, 5.55677824e-02f,
  9.55695380e-03f, 2.84072142e-02f, 2.92536709e-02f, 3.13328803e-02f, 1.58812269e-03f, 1.39637310e-02f, 7.88248554e-02f, 2.46914942e-02f, 6.40184954e-02f, 7.99431130e-02f,
  7.03882501e-02f, 2.24523768e-02f, 8.91072378e-02f, -1.30972058e-01f, 1.09822666e-02f, 2.92173959e-02f, -5.37913814e-02f, 9.35246497e-02f, 1.30370453e-01f, -2.71168333e-02f,
  -1.29343748e-01f, -3.19662660e-01f, 1.44653380e-01f, -5.74871004e-02f, 1.73728362e-01f, 1.42023429e-01f, -1.74673766e-01f, -1.75396562e-01f, -2.71306604e-01f, -8.52875933e-02f,
  -6.24273010e-02f, 9.64321047e-02f, -2.56111622e-01f, 3.38965617e-02f, 1.28625378e-01f, -2.31607646e-01f, -9.67499986e-02f, 1.61749139e-01f, 1.09943405e-01f, -9.88641381e-02f,
  7.25485664e-03f, -9.88988951e-02f, 6.22588322e-02f, -2.79085636e-02f, 8.43724087e-02f, 8.69066119e-02f, -3.65925580e-02f, -1.73095819e-02f, 9.23493281e-02f, 6.20171800e-02f,
  1.48506805e-01f, -2.21581504e-01f, 7.47708455e-02f, -1.61301065e-02f, -8.09749737e-02f, 2.39494760e-02f, 2.22134978e-01f, 1.45783156e-01f, 9.73944180e-03f, 4.80057932e-02f,
  -3.09323485e-04f, 1.43143252e-01f, 9.15690511e-02f, -3.94123495e-02f, -2.24797409e-02f, 4.13190983e-02f, 7.11240843e-02f, 6.68828785e-02f, -1.83542669e-02f, 9.28309187e-02f,
  5.07580116e-02f, 1.55425206e-01f, 2.18760525e-03f, 1.02415539e-01f, 9.40112695e-02f, 8.73833746e-02f, 6.65683448e-02f, 1.37976319e-01f, 8.85031074e-02f, -5.25833853e-02f,
  -2.08956413e-02f, 3.72558497e-02f, -1.24882258e-01f, 1.27841840e-02f, -7.89974537e-03f, -5.48350476e-02f, 6.13697385e-03f, -4.04642746e-02f, 1.33040047e-03f, 1.09523674e-02f,
  1.21734813e-01f, 5.56867048e-02f, -1.28722042e-01f, -4.06428762e-02f, -3.01267840e-02f, -2.83505651e-03f, 1.43338829e-01f, 3.46666314e-02f, 6.85216039e-02f, 1.83329046e-01f,
  1.01113386e-01f, 8.71213526e-02f, -1.78513408e-01f, 1.21136732e-01f, -9.99983177e-02f, -7.43729621e-02f, -2.74169575e-02f, -5.20978943e-02f, -1.32951587e-02f, -7.62655539e-03f,
  -1.42432913e-01f, -2.68666685e-01f, 5.74292950e-02f, 7.50745460e-02f, -4.17033620e-02f, 2.07711523e-03f, 1.30085751e-01f, 5.90578578e-02f, -1.66650303e-02f, -1.40728289e-02f,
  7.20334500e-02f, 8.08674991e-02f, 1.62353758e-02f, -4.41057645e-02f, 9.49180648e-02f, -1.13570675e-01f, -1.19126640e-01f, -1.03829592e-01f, 1.59623504e-01f, 2.87018772e-02f,
  6.02537654e-02f, 4.38107029e-02f, -3.16625535e-02f, 9.55983810e-03f, 2.85851466e-03f, -5.31798862e-02f, -5.20963408e-02f, 2.36709556e-03f, 4.04417254e-02f, 3.63253728e-02f,
  3.20775241e-01f, -2.63287932e-01f, -3.84174027e-02f, 4.00235265e-01f, 3.02645057e-01f, -1.56319067e-01f, 2.28566587e-01f, 7.52914622e-02f, 5.61014771e-01f, -2.00504854e-01f,
  7.69995302e-02f, -1.10842884e-01f, -8.89991000e-02f, -1.54506788e-01f, 6.99467137e-02f, -2.34467667e-02f, -8.07341710e-02f, -1.02328628e-01f, 2.39048615e-01f, -3.46072502e-02f,
  1.72707051e-01f, -3.04896962e-02f, -1.26166582e-01f, -1.24209054e-01f, -1.05121836e-01f, 1.68625340e-02f, -1.84267074e-01f, -2.96688974e-02f, -3.19135129e-01f, -8.15312490e-02f,
  -3.09673529e-02f, 1.66732490e-01f, -8.26083496e-03f, -1.99697185e-02f, -3.46022248e-02f, -1.44118571e-03f, 1.88320167e-02f, -2.21040919e-02f, 1.83671847e-01f, 3.67129855e-02f,
  1.84964482e-02f, 6.67438358e-02f, -7.25772306e-02f, 1.70873012e-02f, 6.33925125e-02f, -2.06508208e-02f, 6.62995279e-02f, 2.36156993e-02f, 3.38415839e-02f, -1.02376781e-01f,
  1.10279545e-01f, -2.52180379e-02f, 8.35509002e-02f, -1.35085657e-01f, -6.87576085e-02f, 1.01140626e-01f, -8.56471248e-03f, -4.56817858e-02f, -1.42697869e-02f, 1.13705516e-01f,
  -1.28005907e-01f, 1.11230701e-01f, 3.18337046e-02f, 7.21899346e-02f, 2.03837408e-03f, 3.34998257e-02f, 9.31183696e-02f, -1.34248761e-02f, 2.64214855e-02f, -2.18275841e-02f,
  2.98319124e-02f, 3.52228098e-02f, 9.77665633e-02f, 8.86019915e-02f, 7.32454881e-02f, 1.41501889e-01f, -1.65746927e-01f, -1.13607965e-01f, 1.02177083e-01f, 1.31680772e-01f,
  -2.46528778e-02f, 1.06982980e-02f, -6.95507005e-02f, 5.24189733e-02f, -6.72463924e-02f, 9.25024971e-02f, 5.13513237e-02f, -1.00040480e-01f, 1.72030732e-01f, -5.63160777e-02f,
  -8.63097236e-02f, -2.04393968e-01f, -8.45857933e-02f, -1.28248092e-02f, 4.17407043e-02f, -1.04535438e-01f, 3.77997756e-02f, -4.97459993e-03f, 4.48992513e-02f, -5.85925505e-02f,
  -5.61075434e-02f, 4.39598821e-02f, -8.43070075e-03f, -4.14245343e-03f, -3.15448120e-02f, -1.71969216e-02f, 1.58049427e-02f, -9.44549367e-02f, 8.21653903e-02f, -1.44513980e-01f,
  -4.53940853e-02f, 6.14775941e-02f, -2.87827458e-02f, 3.74224633e-02f, -9.65856016e-02f, -3.68546024e-02f, 4.74621402e-03f, -1.26109079e-01f, -1.01108409e-01f, -6.27725348e-02f,
  -5.68233468e-02f, 3.55616063e-01f, 2.84904391e-01f, 2.46618554e-01f, -5.89766353e-02f, 4.06490624e-01f, 9.17088613e-02f, 1.29846528e-01f, 2.83348143e-01f, 3.73832993e-02f,
  -1.37115255e-01f, 1.82035774e-01f, -7.19386786e-02f, -2.03607175e-02f, -3.68661918e-02f, 1.94513112e-01f, 2.04854578e-01f, 6.39331937e-02f, 1.15935668e-01f, -8.51292312e-02f,
  4.97785881e-02f, -2.51115918e-01f, 1.82689168e-02f, -1.53246105e-01f, -5.79514744e-06f, 6.67646080e-02f, -1.80171981e-01f, -1.17709495e-01f, -3.95973176e-02f, -2.10144129e-02f,
  -1.07224688e-01f, -9.78631526e-02f, -1.25530344e-02f, 4.89236452e-02f, -7.92289525e-03f, 4.92978059e-02f, 7.77927111e-04f, -1.48788586e-01f, -1.04073092e-01f, 1.23762917e-02f,
  9.18334499e-02f, 7.88203627e-02f, -3.59949805e-02f, 6.29429892e-02f, 6.07990834e-04f, -3.42660137e-02f, 3.73519547e-02f, 2.83926539e-02f, 5.06297313e-02f, 9.99491364e-02f,
  1.63238108e-01f, 1.49958193e-01f, -5.08559011e-02f, -8.20112377e-02f, -7.37495197e-04f, 1.27386302e-01f, 3.83755825e-02f, -3.25189754e-02f, 1.41719133e-01f, 1.12474211e-01f,
  -6.46955445e-02f, -5.94894476e-02f, -7.26966411e-02f, -9.54328105e-02f, 1.58772524e-02f, -7.59106800e-02f, 1.16433427e-01f, -7.32838511e-02f, -4.72821668e-02f, 2.48035584e-02f,
  4.61142473e-02f, -1.76222622e-02f, -1.21279964e-02f, 4.55337092e-02f, -1.82274915e-02f, -3.57148461e-02f, -1.04519442e-01f, 4.45290394e-02f, 7.21499771e-02f, 1.96994804e-02f,
  -8.63176361e-02f, 1.48781836e-01f, 8.03687349e-02f, -3.82657312e-02f, -7.37834675e-03f, -8.40713084e-02f, 2.25101653e-02f, 7.28344098e-02f, -2.18817927e-02f, -4.58651856e-02f,
  8.39970857e-02f, 1.15891263e-01f, 2.77710222e-02f, -7.43239298e-02f, 6.37567416e-02f, 1.13912411e-02f, -3.38712404e-03f, 1.28563084e-02f, 6.41742349e-02f, -5.55748567e-02f,
  -5.38188219e-02f, 7.68112391e-02f, 4.44876440e-02f, 3.29358913e-02f, 2.15835273e-02f, 1.61519181e-02f, -6.54409966e-03f, -5.42803071e-02f, -4.40393426e-02f, -7.81568959e-02f,
  -5.08076511e-02f, -7.17942566e-02f, -7.41198137e-02f, -2.89938804e-02f, 1.18940398e-02f, -2.93291043e-02f, -1.75432283e-02f, 6.67290092e-02f, -3.40833589e-02f, -3.61200459e-02f,
  2.27892637e-01f, -1.76672235e-01f, 1.73705816e-01f, -1.75860777e-01f, 1.83339015e-01f, 2.54803091e-01f, 3.67348850e-01f, -2.37526372e-01f, -2.39103004e-01f, -3.19839388e-01f,
  2.29259767e-02f, 1.69634387e-01f, 1.55993998e-01f, -1.14716023e-01f, 2.98427761e-01f, 1.01625696e-02f, -8.58483389e-02f, -2.34874729e-02f, -8.34080577e-02f, -5.18590361e-02f,
  -4.33387347e-02f, -1.24315515e-01f, 1.82824418e-01f, -1.59420073e-01f, 1.27081335e-01f, -1.23040944e-01f, -1.50097504e-01f, 2.27359399e-01f, -1.58377469e-01f, 1.41179234e-01f,
  4.25635353e-02f, -4.16791812e-02f, 2.00902134e-01f, 3.34776342e-02f, -5.32098524e-02f, -4.12062220e-02f, -5.47106154e-02f, 1.54060557e-01f, 8.07287022e-02f, -6.10837191e-02f,
  5.80987148e-02f, -1.06363796e-01f, 3.03106755e-03f, 8.78774971e-02f, -9.96430665e-02f, -8.97869691e-02f, -2.73780096e-02f, 7.09512383e-02f, -7.86944851e-02f, 2.93593742e-02f,
  -2.48328270e-03f, -5.08762822e-02f, 7.25212321e-03f, -1.54175192e-01f, -5.87009043e-02f, -1.37512654e-01f, -1.38061894e-02f, 1.06895551e-01f, -8.34590271e-02f, -1.06472075e-01f,
  -9.49824080e-02f, -5.60106672e-02f, 1.27363037e-02f, -7.22859204e-02f, 4.53160666e-02f, -8.17654431e-02f, -9.89239812e-02f, 5.54776266e-02f, 4.67686318e-02f, -2.61152381e-05f,
  -9.22757611e-02f, -1.38510438e-02f, -2.08429452e-02f, -2.24206671e-02f, -3.72440591e-02f, 9.81988036e-04f, 6.78149015e-02f, -6.04664162e-02f, 8.20091274e-03f, 4.81706066e-03f,
  -4.09935638e-02f, -8.58287141e-02f, 3.98961939e-02f, 4.10892405e-02f, -6.69049323e-02f, -1.91287766e-03f, -9.31912102e-03f, 4.27427441e-02f, 6.61633909e-02f, 1.39642609e-02f,
  -6.77130371e-02f, -2.40293503e-01f, -1.91162024e-02f, -2.13670973e-02f, 9.80550870e-02f, 7.17388913e-02f, 2.76688170e-02f, -5.47215715e-02f, 5.98626547e-02f, -3.08576506e-02f,
  -7.88138434e-02f, 3.08946632e-02f, 3.62774804e-02f, -4.53916453e-02f, -8.29330552e-03f, -4.78436686e-02f, 2.81900503e-02f, 1.13625368e-02f, 1.26471043e-01f, -7.09819421e-02f,
  -1.13972858e-01f, 6.57931715e-02f, -6.65740818e-02f, -1.55950367e-01f, -1.83262359e-02f, -2.94103250e-02f, 2.69948617e-02f, -8.90145972e-02f, -1.19467095e-01f, -6.58798739e-02f,
  4.34928328e-01f, -2.41007015e-01f, 1.65154070e-01f, 3.55809093e-01f, 2.58405626e-01f, -1.34862870e-01f, 1.11547466e-02f, 1.92381978e-01f, 2.69232064e-01f, -2.22962365e-01f,
  -7.22991023e-03f, 4.76153679e-02f, -1.44906998e-01f, -8.24665874e-02f, -1.92247760e-02f, -1.19664624e-01f, -3.54749337e-02f, 1.05729522e-02f, 1.95014417e-01f, 5.92483096e-02f,
  3.40761468e-02f, -2.65037924e-01f, -1.39056951e-01f, -9.58383530e-02f, 6.95042387e-02f, 1.61907554e-01f, -1.49626404e-01f, -9.37337242e-03f, -8.48554969e-02f, -9.76386890e-02f,
  -9.18490365e-02f, 1.28752738e-01f, -7.60287642e-02f, -6.66396767e-02f, 6.79578632e-03f, -6.79141656e-02f, -5.29717058e-02f, 1.32478727e-03f, 6.47250265e-02f, 1.08130246e-01f,
  -6.75099567e-02f, -3.09548713e-02f, -1.16441287e-01f, -1.75039400e-03f, 7.32103065e-02f, 1.06320024e-01f, 7.03350902e-02f, -1.34572573e-02f, 6.66614398e-02f, 1.56617954e-01f,
  5.17765135e-02f, 7.04659596e-02f, 3.90696563e-02f, -2.09859405e-02f, -2.45178137e-02f, 2.37798188e-02f, -4.14348468e-02f, -3.54777984e-02f, 5.78439720e-02f, 7.56249297e-03f,
  9.15872306e-02f, -2.69435253e-02f, 1.21314516e-02f, 4.32257019e-02f, 9.24711823e-02f, 4.19623479e-02f, -7.98930321e-03f, -1.89068783e-02f, -6.34161606e-02f, -4.58793994e-03f,
  2.65117083e-02f, 5.23766056e-02f, 6.10126331e-02f, 1.03946075e-01f, 3.01548764e-02f, 4.27682512e-02f, -8.23291913e-02f, -5.84917888e-02f, -3.69308740e-02f, -6.96019270e-03f,
  -6.40121698e-02f, -9.87008885e-02f, -5.81890270e-02f, 8.99954815e-04f, 8.55195075e-02f, -3.15864645e-02f, -8.40477720e-02f, 1.69410959e-01f, 9.49434340e-02f, -6.56117722e-02f,
  -4.37066376e-01f, -3.67522597e-01f, -7.66516402e-02f, -2.89358329e-02f, -1.66111246e-01f, -5.65759391e-02f, -1.08388953e-01f, 3.84041928e-02f, -1.35323837e-01f, 9.86428037e-02f,
  -1.04731031e-01f, 5.47725148e-02f, -9.74057317e-02f, 5.51091172e-02f, -1.43802077e-01f, 5.43637872e-02f, -1.40894085e-01f, -1.47692129e-01f, -1.72653899e-01f, -5.22701740e-02f,
  4.36321013e-02f, -6.11540712e-02f, 2.88938526e-02f, 8.41876268e-02f, -4.22157422e-02f, -1.28853908e-02f, -2.40683760e-02f, 1.29566127e-02f, -4.11638767e-02f, 1.56386383e-03f,
  -3.14800024e-01f, 1.03521518e-01f, 3.58254850e-01f, -1.37239015e-02f, 2.35997662e-01f, 4.27929342e-01f, 2.17977449e-01f, 2.47262239e-01f, 2.15746850e-01f, -1.48307174e-01f,
  -1.59023494e-01f, -2.35147148e-01f, 1.02561414e-01f, -5.68725541e-02f, 3.60735059e-01f, 1.85285896e-01f, 1.65865302e-01f, -1.07276194e-01f, 5.26247248e-02f, -5.80410920e-02f,
  6.48544803e-02f, -1.93933412e-01f, 1.09569155e-01f, -1.42068699e-01f, -1.92426801e-01f, -1.19635515e-01f, -2.19935432e-01f, 2.54163817e-02f, -1.36672914e-01f, 1.47176638e-01f,
  -2.22607702e-01f, -1.77710280e-01f, -2.27168500e-01f, -5.26097715e-02f, -5.34254685e-02f, 1.58681795e-02f, 8.43978897e-02f, 4.45485078e-02f, 6.25498369e-02f, 6.07031882e-02f,
  -1.54634878e-01f, -2.26689894e-02f, -8.53353739e-02f, -8.43201205e-02f, 8.22162703e-02f, -9.96217784e-03f, 5.12126535e-02f, -1.55716231e-02f, -4.89809141e-02f, 7.75040984e-02f,
  2.25770269e-02f, 5.01221605e-02f, 5.72295114e-02f, 2.79126093e-02f, 6.61325008e-02f, 2.32300386e-02f, 8.91409516e-02f, 6.83165118e-02f, 1.30305048e-02f, 3.86057980e-02f,
  2.24368963e-02f, 8.77430886e-02f, -6.89726472e-02f, 5.30606210e-02f, 4.20621894e-02f, -2.43957378e-02f, -1.36924699e-01f, -1.01240493e-01f, 4.18533124e-02f, -9.33675021e-02f,
  2.75524799e-02f, -3.08745746e-02f, -3.83809581e-02f, 1.28105626e-01f, -1.31802097e-01f, -9.87105519e-02f, -2.89710588e-03f, -6.93728402e-02f, 1.39834697e-03f, 6.66323081e-02f,
  -1.21489167e-02f, -1.15986441e-04f, -3.08416877e-02f, 8.30656812e-02f, 1.34868212e-02f, -2.95045637e-02f, -1.31449461e-01f, 3.32660638e-02f, -8.06249976e-02f, 6.08830573e-03f,
  -6.11578710e-02f, -7.64343813e-02f, -1.65507853e-01f, -1.26778081e-01f, -6.85167834e-02f, 2.91097928e-02f, 2.39813030e-02f, 5.06761624e-03f, -4.66050282e-02f, -5.83922490e-02f,
  -6.85359463e-02f, 1.96315087e-02f, -2.31335144e-02f, -2.55604349e-02f, 7.42221475e-02f, 7.83898458e-02f, 1.32854376e-02f, -2.83874143e-02f, 4.72118743e-02f, -7.94888064e-02f,
  -1.25128910e-01f, -5.44349588e-02f, -3.62835377e-02f, -6.08030371e-02f, -4.55002673e-02f, -1.93776395e-02f, -3.54553796e-02f, 1.00725368e-01f, -4.76570725e-02f, -4.36221287e-02f,
  4.03311290e-02f, 4.09161225e-02f, -3.32629144e-01f, -3.00590903e-01f, 1.54208690e-01f, -2.36042902e-01f, -1.99595124e-01f, -6.45908937e-02f, -1.06409192e-01f, 2.42533401e-01f,
  7.19634593e-02f, -2.53194362e-01f, 1.09336302e-01f, -2.68205971e-01f, -3.50254983e-01f, -1.70566589e-01f, -2.65519768e-01f, -7.29103163e-02f, -8.85646865e-02f, 3.91227901e-02f,
  -1.27769232e-01f, 3.41910087e-02f, -1.90188795e-01f, 2.28232041e-01f, 5.42460270e-02f, -6.70918673e-02f, 2.57822424e-01f, 1.26364172e-01f, -5.36006019e-02f, 2.05888762e-03f,
  -7.15119839e-02f, 8.48082975e-02f, -1.92060899e-02f, -9.11743268e-02f, 3.94946896e-02f, 4.89491187e-02f, 9.22065973e-02f, 4.89925668e-02f, -2.38673184e-02f, -1.96660906e-02f,
  7.17102885e-02f, -2.84953434e-02f, -1.34009281e-02f, -5.83306188e-04f, 6.15740381e-03f, 5.57216257e-02f, -1.63738161e-01f, -3.57571281e-02f, -1.96454719e-01f, -2.32117642e-02f,
  -8.79467651e-02f, -1.04902931e-01f, -5.76216541e-02f, -1.02482118e-01f, -1.44666247e-02f, -8.01952332e-02f, -3.06073274e-03f, 2.26837173e-02f, -1.42782126e-02f, 2.44699232e-02f,
  4.90178615e-02f, 1.03852995e-01f, -5.24415895e-02f, -1.82971302e-02f, 5.39911985e-02f, -8.27636421e-02f, -1.21146850e-02f, -4.41328473e-02f, -8.62441808e-02f, 3.61786857e-02f,
  -1.05832845e-01f, -5.14401533e-02f, 1.43663511e-01f, 4.18080650e-02f, 1.25711754e-01f, -5.09360097e-02f, 4.59440239e-02f, -1.84398536e-02f, -1.25231296e-01f, -5.78923263e-02f,
  -6.64474741e-02f, 1.29564228e-02f, -1.35152310e-01f, 9.99131892e-03f, -7.12236017e-02f, 2.70228405e-02f, 6.65506115e-03f, 2.61756163e-02f, -5.71433082e-02f, 6.16764463e-02f,
  -2.17876192e-02f, 1.79331824e-01f, -2.53098495e-02f, 3.34518426e-03f, -5.24883643e-02f, 1.08470887e-01f, -2.97916513e-02f, -8.87503289e-03f, 5.89515306e-02f, 6.17996641e-02f,
  9.18310732e-02f, -5.44186421e-02f, 7.85633996e-02f, -2.46014614e-02f, -7.65110254e-02f, 7.65058547e-02f, -9.65763349e-03f, 1.09009249e-02f, -7.62378750e-03f, -8.34426954e-02f,
  9.21593681e-02f, 1.03939194e-02f, -7.77373463e-02f, -3.28797363e-02f, 1.11736596e-01f, 1.08711526e-01f, 2.10429803e-02f, -1.88564565e-02f, 7.04459846e-02f, 9.64042637e-03f,
  -2.70024449e-01f, -6.34630919e-02f, 3.06535363e-01f, -3.03935744e-02f, 3.15260231e-01f, 2.27060556e-01f, 5.14316857e-02f, 3.31715256e-01f, 2.10696310e-01f, -2.31298581e-01f,
  -1.35544255e-01f, -2.38178581e-01f, -1.78070307e-01f, -7.68431574e-02f, 5.57889640e-02f, -5.05904108e-03f, 5.85765466e-02f, -2.47516111e-01f, 6.62829429e-02f, -1.07579231e-01f,
  5.91479801e-02f, -8.81009996e-02f, 1.13203488e-01f, 8.41459855e-02f, 1.54580891e-01f, 3.31675634e-02f, -1.95601836e-01f, 1.11511774e-01f, -2.78621167e-02f, 5.74181266e-02f,
  -8.57926011e-02f, 6.75886683e-03f, -2.96064727e-02f, 4.14705537e-02f, -4.53942269e-02f, 9.12109204e-03f, -1.20535776e-01f, -4.58999388e-02f, 5.59951738e-03f, -5.17762676e-02f,
  -1.60452485e-01f, -1.46237276e-02f, 3.27004157e-02f, -3.75416502e-02f, 1.39811873e-01f, 3.02706156e-02f, 6.04800135e-02f, 1.26841351e-01f, 9.47454050e-02f, 6.35753646e-02f,
  7.64097199e-02f, 5.37189543e-02f, 1.46186650e-01f, 2.46252473e-02f, 5.94571382e-02f, 1.76404759e-01f, 3.53705920e-02f, -3.59493457e-02f, 8.22112896e-03f, 9.52351317e-02f,
  1.41651973e-01f, 7.69185424e-02f, 5.85146658e-02f, -4.11639921e-02f, -6.52646497e-02f, 3.80533263e-02f, 1.40933255e-02f, -1.24421105e-01f, -1.99465640e-02f, -5.27458452e-02f,
  -9.88817029e-03f, -3.63047346e-02f, 8.63095075e-02f, 1.35447029e-02f, -8.13472196e-02f, 1.42588038e-02f, -1.40409723e-01f, 1.17408652e-02f, 4.92517315e-02f, 3.17405462e-02f,
  3.06222253e-02f, 2.18295287e-02f, 6.47412892e-03f, -1.03480853e-01f, 2.53063943e-02f, 3.61272804e-02f, -1.32765874e-01f, 1.02573365e-01f, -7.88639188e-02f, -4.33549322e-02f,
  -2.49020442e-01f, -2.61716127e-01f, -6.12622574e-02f, -1.05602987e-01f, -6.66762218e-02f, -4.85240556e-02f, -8.98228139e-02f, -1.42223472e-02f, -2.71414388e-02f, -9.18109715e-02f,
  3.58975418e-02f, -1.54654428e-01f, -7.84939677e-02f, -6.14814740e-03f, -1.83899663e-02f, -7.44620338e-02f, -1.54136226e-01f, -6.72720373e-02f, -1.66933656e-01f, -9.22117233e-02f,
  -4.46840711e-02f, -9.10174400e-02f, 6.09916337e-02f, -2.68989732e-03f, -7.75334612e-02f, 8.27484298e-03f, -4.55051847e-02f, 2.25141756e-02f, 2.11461959e-03f, 8.64268243e-02f,
  -2.55754918e-01f, -1.18040964e-01f, -3.84963483e-01f, 3.16131487e-02f, 1.11675143e-01f, 3.09339911e-01f, 2.32392982e-01f, -2.66451575e-02f, -1.22297645e-01f, 3.03411216e-01f,
  2.62672752e-01f, -2.93010831e-01f, -7.08701760e-02f, 2.34185010e-01f, -1.82173982e-01f, -6.57852069e-02f, 3.25980365e-01f, 2.04089001e-01f, -1.89587519e-01f, -5.18818572e-02f,
  -6.04439341e-02f, 2.91164547e-01f, -8.74512596e-04f, 1.01714596e-01f, 1.17806636e-01f, -1.65692329e-01f, 1.51229247e-01f, -2.77669668e-01f, 3.23407799e-01f, 8.88158157e-02f,
  4.38588485e-02f, -9.79535431e-02f, -9.77726430e-02f, -1.24035068e-01f, 1.62802562e-02f, 8.78286213e-02f, 5.26911765e-02f, -6.09095804e-02f, -4.69836146e-02f, -2.85431482e-02f,
  -5.89713342e-02f, -8.99798200e-02f, 3.48949502e-03f, -1.41056910e-01f, -2.27435715e-02f, -2.06049643e-02f, -9.11630318e-02f, 3.15658213e-03f, 3.94176468e-02f, -1.43778816e-01f,
  -1.56260341e-01f, 4.18143421e-02f, 1.88161507e-01f, 1.62738729e-02f, -2.49344315e-02f, 4.12193220e-03f, 5.62449954e-02f, -6.96158335e-02f, 7.30883479e-02f, 2.54804455e-02f,
  -6.15696050e-02f, 7.84404203e-03f, 3.97494063e-02f, -1.00949042e-01f, 2.64687743e-02f, -1.05118868e-03f, 8.29952955e-03f, 1.32391691e-01f, -1.13274403e-01f, -2.96181235e-02f,
  2.74535213e-02f, -4.51347139e-03f, 2.11893748e-02f, 7.70630538e-02f, 7.83814117e-03f, -5.37054650e-02f, -1.51713761e-02f, 4.30548191e-02f, 8.06405488e-03f, 6.56524673e-02f,
  -2.18194444e-02f, -2.02246942e-02f, -3.30564529e-02f, 8.76118615e-02f, 8.16940442e-02f, -3.10813058e-02f, 1.03416048e-01f, -6.94998130e-02f, 8.68272781e-02f, 1.06465079e-01f,
  2.13964820e-01f, 1.81231380e-03f, 4.37569842e-02f, 3.99863534e-02f, 7.67470151e-02f, -4.73643169e-02f, -6.96679130e-02f, -8.03071856e-02f, -4.02926765e-02f, -1.82930548e-02f,
  -4.68978621e-02f, 1.00290790e-01f, 8.64321962e-02f, -3.41101140e-02f, 9.90298241e-02f, 7.04047456e-02f, 1.01762988e-01f, -3.03442478e-02f, 6.44088164e-02f, 6.36599362e-02f,
  7.63901025e-02f, 1.55743100e-02f, 2.70011630e-02f, 1.33281974e-02f, 8.53072703e-02f, 6.12744242e-02f, 9.00073349e-02f, -6.87791482e-02f, 5.27965017e-02f, -6.62350655e-02f,
  3.09524368e-02f, -8.52330774e-02f, -2.03849107e-01f, -1.79187566e-01f, -1.19305260e-01f, -2.91999936e-01f, -2.00464457e-01f, -4.77935560e-02f, 1.34795964e-01f, 9.38296616e-02f,
  -3.01734395e-02f, -7.11076939e-03f, 1.67793974e-01f, -1.73935205e-01f, -8.96473154e-02f, 2.24605396e-01f, -3.14196080e-01f, -2.55914539e-01f, 2.19057113e-01f, -1.49396628e-01f,
  -5.15088513e-02f, -1.35761559e-01f, -1.19973108e-01f, -3.61950248e-02f, -1.95263863e-01f, 1.39934327e-02f, 3.74488123e-02f, 1.18664987e-02f, -2.28241891e-01f, -5.80767840e-02f,
  8.65599513e-03f, 1.60331339e-01f, 7.05286786e-02f, -1.14652794e-02f, 2.79482640e-02f, -2.78568845e-02f, -2.07862273e-01f, 4.78593037e-02f, -1.82290766e-02f, -4.08988222e-02f,
  -3.86067741e-02f, 3.59556824e-02f, 7.10047828e-03f, 2.84445919e-02f, -3.69139202e-02f, -4.28552106e-02f, 5.65500418e-03f, 1.56851970e-02f, 8.63377284e-03f, -4.08008061e-02f,
  -1.27209216e-01f, 6.12342432e-02f, 5.19221008e-04f, 7.90187493e-02f, -2.73682587e-02f, -1.24245957e-02f, -7.95473605e-02f, 2.54641008e-02f, 3.05163953e-02f, -3.66059504e-02f,
  -1.17557354e-01f, -6.86948076e-02f, -7.50581399e-02f, 5.64956218e-02f, -4.55546230e-02f, -1.00418162e-02f, 1.11684697e-02f, 7.96383396e-02f, 1.57216981e-01f, -4.08808850e-02f,
  3.00789848e-02f, -2.89914459e-02f, -2.02057734e-02f, -1.13059804e-01f, -1.20660793e-02f, 8.25903788e-02f, -1.10610917e-01f, -1.79004557e-02f, 6.29697964e-02f, -6.47925958e-02f,
  -3.37809585e-02f, -1.52320594e-01f, 1.32799566e-01f, 2.46113949e-02f, -1.15559146e-01f, 1.64192572e-01f, -7.08281398e-02f, -7.87699316e-03f, -7.72245834e-03f, -3.00428886e-02f,
  4.51822169e-02f, -2.98533533e-02f, 1.11543052e-02f, 8.78136456e-02f, 5.86055219e-02f, -1.05048418e-02f, -6.28680438e-02f, -3.89766432e-02f, 4.89455611e-02f, -1.00004338e-01f,
  -3.30691449e-02f, 9.28647909e-03f, -4.43219058e-02f, 2.44864561e-02f, 8.00652131e-02f, -5.24191000e-02f, -3.91252004e-02f, 1.46313205e-01f, 7.31699122e-03f, 3.52145657e-02f,
  -1.76086985e-02f, 7.63343461e-03f, -2.98401862e-02f, 1.31640613e-01f, 1.12542799e-02f, 6.35092258e-02f, -6.22155890e-02f, 4.99408506e-02f, 9.95286629e-02f, -2.46568508e-02f,
  2.38828331e-01f, 1.89209864e-01f, 7.53184184e-02f, 1.88690260e-01f, 4.09030020e-02f, -4.52125743e-02f, -2.42465883e-01f, 2.48047307e-01f, -1.12687111e-01f, -2.12143064e-01f,
  1.10240102e-01f, 7.32396543e-02f, -2.41871595e-01f, 4.03462708e-01f, 2.80172050e-01f, -2.09472850e-01f, 3.39323580e-01f, 6.55756667e-02f, -6.32530153e-02f, 1.20610990e-01f,
  1.97304755e-01f, 1.96908340e-01f, 2.16012686e-01f, 1.38444826e-01f, 1.66637659e-01f, 6.65819719e-02f, 1.13060482e-01f, -1.28940195e-01f, 1.90960020e-01f, 7.27280974e-02f,
  9.62439850e-02f, 1.06182277e-01f, 5.16596511e-02f, -8.22391510e-02f, -4.42625359e-02f, -2.62393747e-02f, -1.07054554e-01f, -7.60580937e-04f, -1.04085254e-02f, -5.97954020e-02f,
  -9.21071395e-02f, 3.49477157e-02f, 6.76731691e-02f, 8.42500106e-02f, 2.78340150e-02f, -3.06566358e-02f, -3.14481161e-03f, 6.47592694e-02f, -3.34987231e-02f, 4.90491129e-02f,
  5.56216538e-02f, 6.76424131e-02f, -6.47111833e-02f, 6.27775788e-02f, 3.39148119e-02f, -5.20449970e-03f, -2.64197588e-02f, -1.28450636e-02f, -1.52790295e-02f, 8.96320194e-02f,
  -2.06595827e-02f, -1.06812134e-01f, 4.44836915e-02f, 2.25481335e-02f, 5.03665721e-03f, 5.51542304e-02f, 4.29822095e-02f, -5.96133508e-02f, -5.37412986e-02f, -2.14100573e-02f,
  7.19492212e-02f, 1.43706454e-02f, -8.06540027e-02f, -1.87577482e-03f, 6.60295784e-02f, -5.61014237e-03f, -5.66530563e-02f, -4.27941941e-02f, -8.30255076e-02f, 7.02657178e-02f,
  -3.18048261e-02f, 4.61026542e-02f, 1.53853549e-02f, 1.43650966e-02f, -6.95017725e-03f, -1.86802263e-05f, 1.57943983e-02f, -5.12236543e-02f, -6.59542605e-02f, 3.71939316e-02f,
  4.81988396e-03f, 2.65238769e-02f, -9.68902186e-02f, -5.18825315e-02f, -1.09373808e-01f, 1.34223074e-01f, -1.01286635e-01f, 9.31707397e-02f, 1.82205662e-02f, 3.87773360e-03f,
  -1.94773811e-03f, -1.08393893e-01f, -7.08603710e-02f, -2.71039940e-02f, 7.49268308e-02f, 6.69260398e-02f, -6.93055317e-02f, -1.48529215e-02f, -4.77241836e-02f, 1.10624947e-01f,
  7.42100328e-02f, 8.36288091e-03f, -4.62497305e-03f, 2.05309261e-02f, -9.49660782e-03f, -4.99440208e-02f, 3.73712741e-02f, 3.60466614e-02f, -2.43364833e-02f, -6.58528954e-02f,
  7.51553327e-02f, -1.82244182e-01f, -2.92756408e-01f, -3.83047424e-02f, 1.11558838e-02f, 3.85783702e-01f, 6.23044372e-01f, -2.95639634e-01f, -4.16735113e-02f, 1.81562111e-01f,
  1.44428924e-01f, 1.56703338e-01f, 2.63208240e-01f, 4.34081435e-01f, 3.50280643e-01f, 2.35198379e-01f, 2.79519469e-01f, 2.02047884e-01f, -1.32078007e-01f, -5.95233811e-04f,
  -2.40455419e-01f, 1.82828277e-01f, -8.73352215e-02f, -2.73659170e-01f, 1.28509805e-01f, -3.30915362e-01f, -3.70798558e-02f, 9.65222623e-03f, 2.04574037e-02f, 1.61667660e-01f,
  -3.77375595e-02f, -1.43615967e-02f, -4.63963486e-02f, -6.11524396e-02f, -1.13549791e-02f, -1.01839304e-02f, 1.17809363e-01f, 1.49266750e-01f, -1.09780148e-01f, 2.76588146e-02f,
  1.75929174e-01f, -7.46987462e-02f, -1.19705044e-01f, 1.20405713e-02f, -8.85622501e-02f, -1.81779504e-01f, -6.78382292e-02f, 1.79434754e-02f, -3.42936888e-02f, -3.40568572e-02f,
  -4.26577106e-02f, -1.83553219e-01f, 6.65809736e-02f, -6.83143809e-02f, 7.35800341e-02f, 1.94135029e-02f, -2.49307286e-02f, 5.30772842e-02f, 8.70232210e-02f, -3.93829122e-02f,
  -4.12491448e-02f, 3.78802791e-02f, 5.98056614e-02f, -4.12303843e-02f, -2.24536122e-03f, -3.16810864e-03f, -1.44829601e-03f, 7.00228708e-03f, -7.17187859e-03f, 1.55976415e-01f,
  -6.46167397e-02f, -7.71945491e-02f, 3.51837836e-02f, 5.84967397e-02f, 2.23797690e-02f, -1.74709084e-03f, 5.32159917e-02f, 3.01890224e-02f, -9.55673084e-02f, 7.13679716e-02f,
  -5.70340902e-02f, -5.44427671e-02f, 1.89552344e-02f, 2.01126225e-02f, 7.15030730e-02f, -8.50215107e-02f, -8.56503174e-02f, -1.12947188e-01f, -1.09384745e-01f, 8.03974345e-02f,
  9.30216983e-02f, -3.08844901e-04f, -3.63358743e-02f, 4.10337113e-02f, 8.83217808e-03f, 7.07240999e-02f, 9.88166258e-02f, -5.23150414e-02f, 1.00997932e-01f, 5.63291609e-02f,
  -3.18144783e-02f, 4.12599891e-02f, -4.86044288e-02f, 4.98537682e-02f, 6.09086640e-02f, -3.34915258e-02f, 1.23581365e-01f, -6.70368448e-02f, 2.21136902e-02f, 2.68721357e-02f,
  5.16597964e-02f, 6.18065882e-04f, 9.88678634e-02f, -9.76966135e-03f, -2.01746635e-02f, -1.69198234e-02f, -1.84628535e-02f, -3.53004858e-02f, 8.92099813e-02f, 1.27671421e-01f,
  -1.22418106e-02f, 2.87618160e-01f, 2.29385778e-01f, 3.90051484e-01f, -1.63878217e-01f, 4.20049690e-02f, 9.61136445e-03f, 2.00243697e-01f, 2.95021951e-01f, 4.19952944e-02f,
  -1.61891177e-01f, 1.57751441e-01f, 9.61045325e-02f, 1.39769271e-01f, 1.44205675e-01f, 1.23424910e-01f, 2.17079431e-01f, 1.21189222e-01f, 7.74999708e-02f, 1.97800606e-01f,
  9.42737535e-02f, 1.93433732e-01f, -7.41538852e-02f, 9.98254493e-02f, -5.79836369e-02f, -4.37958427e-02f, -1.18575752e-01f, -8.82008392e-03f, -5.20111620e-02f, -1.54368833e-01f,
  -7.07929805e-02f, 1.30098209e-01f, -1.68407604e-01f, -7.15015456e-02f, 8.53362679e-02f, -7.48596415e-02f, -4.56653833e-02f, -5.45189567e-02f, 6.96638003e-02f, -6.93257004e-02f,
  -7.58511797e-02f, 7.09950849e-02f, 1.85736548e-02f, -4.25256556e-03f, -1.56441294e-02f, -8.50243568e-02f, -7.52777755e-02f, -1.17370769e-01f, -3.27902436e-02f, -9.80571657e-03f,
  -8.20325315e-02f, 8.75538290e-02f, -4.45748530e-02f, -6.26280531e-02f, -6.92129731e-02f, 3.89733277e-02f, 1.47513754e-03f, -1.44280285e-01f, -6.29989952e-02f, 1.29674137e-01f,
  1.60344630e-01f, 1.06368959e-01f, -3.21928412e-02f, -1.00081973e-01f, 6.34711469e-03f, -1.53175756e-01f, 6.27392754e-02f, -2.21343841e-02f, -8.38749260e-02f, -9.88089293e-02f,
  -8.98256972e-02f, -1.33667931e-01f, -3.94176412e-03f, 5.92132509e-02f, 2.89055668e-02f, 4.16544601e-02f, -1.13042578e-01f, -3.81982401e-02f, -8.16203132e-02f, -5.38993999e-03f,
  9.26786587e-02f, -3.55061702e-02f, -5.60702756e-02f, -1.20515309e-01f, -6.84110895e-02f, 1.80596896e-02f, 1.99412555e-01f, 2.30055787e-02f, -6.68297783e-02f, -2.55300179e-02f,
  1.65233314e-01f, 2.97019988e-01f, 3.33050676e-02f, -4.48675342e-02f, -5.29268123e-02f, 4.41869050e-02f, 2.94217728e-02f, -6.78916723e-02f, 5.84973954e-02f, 9.27350074e-02f,
  -1.01266652e-02f, 7.85533637e-02f, -8.28176513e-02f, -5.25934920e-02f, 9.74325556e-03f, -5.65313324e-02f, 9.78851020e-02f, -1.38471480e-02f, -1.34775089e-02f, 1.10676579e-01f,
  -5.41245914e-04f, 2.15184409e-03f, -7.09596127e-02f, -1.49914443e-01f, -7.36045539e-02f, -1.00649759e-01f, 1.02835195e-02f, -1.38657093e-01f, -5.02589382e-02f, -1.58766247e-02f,
  -4.26182121e-01f, 2.04667792e-01f, -2.38409296e-01f, 9.44463983e-02f, -6.29007295e-02f, 2.21711412e-01f, 1.12355955e-01f, -6.97820857e-02f, -2.80324042e-01f, 1.75329491e-01f,
  2.03102127e-01f, -2.34103531e-01f, 1.51705816e-01f, 2.30231419e-01f, 1.43231183e-01f, 1.61777496e-01f, 3.32401544e-01f, 8.42430070e-02f, 8.19111168e-02f, 1.15139231e-01f,
  1.47991786e-02f, 3.71695340e-01f, 1.66604698e-01f, 2.30003461e-01f, 7.95414299e-02f, -1.40125543e-01f, 2.06053883e-01f, 4.03520428e-02f, 1.73247755e-01f, -3.98422107e-02f,
  3.36075537e-02f, -4.63544987e-02f, 1.24951228e-02f, -1.83036193e-01f, 1.04692467e-01f, 5.38380854e-02f, -3.76711935e-02f, -9.11585912e-02f, -6.74707582e-03f, 4.84328233e-02f,
  -6.78735077e-02f, 4.90326881e-02f, 9.51802451e-03f, -4.98107895e-02f, -7.36939311e-02f, -1.19425561e-02f, 3.92414778e-02f, -7.63511583e-02f, -4.40408438e-02f, 8.78010616e-02f,
  3.09967864e-02f, 7.65489936e-02f, -8.23268518e-02f, 1.32272243e-01f, -1.97672173e-02f, -4.67021689e-02f, -4.60096523e-02f, 6.58976287e-02f, 1.66627727e-02f, 2.02050023e-02f,
  8.87268782e-03f, -1.04908727e-01f, -7.72754662e-03f, -4.42182310e-02f, 4.73964848e-02f, 5.79692535e-02f, -1.06126461e-02f, 6.45901486e-02f, -3.70966196e-02f, 1.33704066e-01f,
  6.58181757e-02f, 2.86917947e-02f, -6.83099106e-02f, 7.28796124e-02f, 5.97373322e-02f, 2.05874089e-02f, 5.51070319e-03f, -6.36699125e-02f, 1.17641138e-02f, 6.41419366e-02f,
  -5.17570004e-02f, -4.90479358e-02f, 2.59947646e-02f, -5.77158295e-02f, 9.69838817e-03f, 2.46763378e-02f, -2.62663215e-02f, 1.83937550e-02f, -3.41333653e-04f, -9.99482051e-02f,
  2.51012534e-01f, 3.75343934e-02f, -7.68227726e-02f, 3.79976397e-03f, 6.68559149e-02f, 1.53707964e-02f, -4.06459272e-02f, -2.32694186e-02f, -4.93671596e-02f, -9.04360339e-02f,
  5.41259721e-03f, -7.32673034e-02f, -6.35654926e-02f, 5.42325079e-02f, 2.96571217e-02f, -1.43266446e-03f, 3.72015759e-02f, -4.83457670e-02f, -8.46558288e-02f, 6.46732152e-02f,
  -1.08104073e-01f, -5.26568331e-02f, -2.59434385e-03f, -3.91759761e-02f, -3.27534452e-02f, 1.00270867e-01f, 2.05190238e-02f, 5.72602674e-02f, 9.85053629e-02f, 9.70533025e-03f,
  -5.18472552e-01f, 1.91929042e-01f, 4.43990454e-02f, -2.51047581e-01f, -2.27765292e-02f, 2.29405701e-01f, 1.27200529e-01f, 9.14580524e-02f, -1.35335801e-02f, 1.38363153e-01f,
  1.51977524e-01f, -1.16870761e-01f, 2.51775831e-01f, 1.47652850e-01f, -1.78744614e-01f, 2.81310737e-01f, 4.09475081e-02f, 7.66606396e-03f, 1.22343510e-01f, -8.24808776e-02f,
  -6.19936846e-02f, 1.86945975e-01f, 8.23436528e-02f, 1.38580725e-01f, -4.37795892e-02f, -1.85871080e-01f, -9.37632993e-02f, 1.33681804e-01f, -1.38532668e-01f, 1.86272478e-03f,
  -2.13699996e-01f, -2.47896969e-01f, -1.19021632e-01f, -1.16131024e-03f, -6.53970167e-02f, -4.47747670e-02f, -2.12801155e-02f, 9.75520760e-02f, -2.29285806e-02f, 7.14001507e-02f,
  2.73738205e-02f, 6.66781841e-03f, -2.64213011e-02f, -6.02562260e-03f, -3.04927267e-02f, 8.61992463e-02f, 1.03359573e-01f, 9.79464650e-02f, 9.94520709e-02f, 1.52679358e-03f,
  4.80188429e-02f, 1.54333678e-03f, 5.91687560e-02f, 6.85459226e-02f, 1.03066586e-01f, -1.20528927e-02f, -2.00678203e-02f, 3.33524309e-02f, -2.77063735e-02f, -8.22600424e-02f,
  -7.11573362e-02f, 9.44984406e-02f, 1.07945956e-01f, -4.89918850e-02f, -7.29171634e-02f, 3.23439129e-02f, -7.69567862e-03f, -1.00157991e-01f, 8.35752115e-02f, 7.76963085e-02f,
  2.14486420e-02f, -1.57921538e-02f, -4.20852415e-02f, 5.14149060e-03f, -1.64142959e-02f, 6.75689280e-02f, 3.48489992e-02f, -6.95074275e-02f, -3.51165608e-02f, -9.98556688e-02f,
  -8.83532017e-02f, -1.64659008e-01f, 7.10601546e-03f, 3.16543840e-02f, 2.82053109e-02f, -1.16193760e-02f, -4.32392545e-02f, 4.94397059e-02f, 1.07591905e-01f, -3.98828462e-02f,
  -1.37395024e-01f, -3.74719411e-01f, 1.11908257e-01f, 1.86946783e-02f, -3.18338573e-02f, -9.10156814e-04f, -6.41616508e-02f, 1.67664103e-02f, -7.49820918e-02f, 4.52498607e-02f,
  -5.56185795e-03f, 8.38350356e-02f, -1.54089518e-02f, 7.04961792e-02f, -2.51426809e-02f, 8.50045905e-02f, -1.55265674e-01f, 5.38987331e-02f, 3.26714925e-02f, 9.11480747e-03f,
  -3.40161659e-02f, -6.35846406e-02f, -6.21988550e-02f, 1.90256871e-02f, -6.99682832e-02f, -6.60264771e-03f, -1.48345560e-01f, 1.35044672e-03f, 4.85011702e-03f, -2.51120310e-02f,
  -5.67026794e-01f, 3.44020307e-01f, 2.03436408e-02f, -2.37230554e-01f, 3.06193292e-01f, 3.21702510e-01f, 5.63217811e-02f, 1.91602483e-01f, 8.81232843e-02f, 1.05270237e-01f,
  9.04116631e-02f, 1.18940234e-01f, 8.64327922e-02f, 7.96107277e-02f, -2.77581453e-01f, 7.29974210e-02f, 2.41131913e-02f, -7.47668417e-03f, 2.56855130e-01f, 5.16002811e-03f,
  -1.25556499e-01f, 8.23306590e-02f, -2.36453101e-01f, 2.03422293e-01f, -6.67624176e-02f, -2.69513596e-02f, -2.99278557e-01f, 1.25222072e-01f, -1.24154598e-01f, 1.70833096e-01f,
  -1.45581458e-02f, 1.00698307e-01f, -1.39164897e-02f, 3.25594395e-02f, -1.16059683e-01f, -2.47583948e-02f, -7.24090040e-02f, 1.57046858e-02f, 8.97410065e-02f, 9.46971700e-02f,
  -1.72932737e-03f, -4.32001613e-02f, 1.00109046e-02f, 1.23645656e-01f, 7.92305693e-02f, 3.15311775e-02f, 4.23397794e-02f, -4.41406779e-02f, 1.05245866e-01f, 3.59147750e-02f,
  -9.78172272e-02f, -6.29218742e-02f, -1.28832921e-01f, -3.96402366e-02f, -4.85198461e-02f, 5.64094586e-03f, 4.19575395e-03f, -2.72099804e-02f, 2.29889583e-02f, 7.92980380e-03f,
  -3.54162790e-02f, 1.35518601e-02f, 4.04705405e-02f, -2.47423351e-02f, -7.16915801e-02f, -8.93306285e-02f, -6.29587173e-02f, -3.75135392e-02f, 8.13645963e-03f, -8.89003128e-02f,
  5.13894707e-02f, -1.45360623e-02f, 2.49827392e-02f, -9.33335815e-03f, 8.83157626e-02f, -1.03261113e-01f, 2.26194263e-02f, -2.73912176e-02f, -4.65208143e-02f, -6.68866038e-02f,
  8.45711753e-02f, 8.46634284e-02f, 3.91719677e-03f, 4.10501324e-02f, 5.92180714e-02f, -2.78235581e-02f, 1.47541044e-02f, -7.52544850e-02f, 6.27722889e-02f, -3.07756197e-02f,
  1.68515742e-01f, 8.58053118e-02f, 1.16238192e-01f, -3.35847796e-03f, -2.29317509e-02f, 5.84142879e-02f, 1.11716678e-02f, 5.92472665e-02f, 9.81740281e-02f, 4.59054820e-02f,
  -2.99879424e-02f, 5.06149000e-03f, -7.43416101e-02f, -6.35325834e-02f, -3.01963985e-02f, 2.19489839e-02f, -5.20238914e-02f, -4.54715975e-02f, 2.10752171e-02f, 4.34623435e-02f,
  -8.47399384e-02f, 8.73972699e-02f, -1.52746234e-02f, -1.93858165e-02f, -1.28339464e-02f, -8.95715579e-02f, -3.79086472e-02f, 6.44963607e-02f, 6.48616701e-02f, 8.33410397e-02f,
  2.45660022e-01f, 1.37121249e-02f, -9.25437659e-02f, 1.12515673e-01f, -6.37940913e-02f, 9.04017594e-03f, -6.43781200e-03f, 4.48884405e-02f, -1.57665342e-01f, 2.74512032e-03f,
  -4.28734869e-02f, 5.35924977e-04f, 2.26475373e-02f, -6.16550744e-02f, -1.10915728e-01f, -1.62221581e-01f, 8.55705068e-02f, -4.91942503e-02f, -1.01995366e-02f, 2.53743947e-01f,
  -3.09913475e-02f, 1.06698237e-01f, -1.65508732e-01f, 1.13818824e-01f, 1.37472138e-01f, 8.53938907e-02f, 9.28440392e-02f, -2.83061881e-02f, 1.14449188e-01f, -1.16144054e-01f,
  2.03545112e-02f, 2.85320263e-02f, 6.47711381e-02f, -7.52048055e-03f, 1.09802760e-01f, 7.53557384e-02f, -5.46716824e-02f, -1.28728554e-01f, -8.68330896e-02f, -1.72199365e-02f,
  -5.60220331e-02f, -9.88385081e-03f, -6.97096065e-03f, -5.58923446e-02f, -2.33381434e-05f, -2.09156461e-02f, -1.09143339e-01f, -6.19713636e-03f, -1.65293664e-01f, 1.18823219e-02f,
  -3.99271995e-02f, -3.84855121e-02f, -3.86232547e-02f, -4.55952436e-02f, 8.52158517e-02f, -3.49082686e-02f, -1.26232401e-01f, 4.01034094e-02f, -1.41566515e-01f, -2.71115284e-02f,
  1.22276455e-01f, -3.24367397e-02f, 5.16473763e-02f, -1.23021208e-01f, 4.53486387e-03f, 6.39744028e-02f, -1.26570657e-01f, -2.99219787e-02f, 1.79729089e-02f, 7.77127072e-02f,
  1.74208302e-02f, -1.64677221e-02f, -8.20626095e-02f, -8.20632875e-02f, 1.24100797e-01f, -1.01275422e-01f, -1.32973408e-02f, 1.55244976e-01f, 1.97052266e-02f, -9.12589058e-02f,
  -1.09291509e-01f, 1.72107387e-02f, 6.95497692e-02f, -2.02433877e-02f, -2.84585040e-02f, 1.61960125e-02f, 1.27003388e-02f, 3.63292592e-03f, -7.50158280e-02f, 2.76453532e-02f,
  1.35310395e-02f, 6.04406036e-02f, -7.08190575e-02f, -1.24528602e-01f, 3.21018584e-02f, 1.03202865e-01f, -1.69046327e-01f, 9.02887210e-02f, -6.45446405e-02f, 1.25282621e-02f,
  1.80566832e-01f, -1.82817996e-01f, 1.08395256e-01f, 5.88436238e-02f, -2.27598712e-01f, 1.65843174e-01f, 1.32068042e-02f, -2.85856202e-02f, 3.38196866e-02f, 3.07193380e-02f,
  1.17503770e-01f, 7.52272755e-02f, -2.21141335e-02f, 2.57868972e-02f, 8.68773758e-02f, 1.50852008e-02f, 7.92447478e-02f, -4.92834076e-02f, 1.57004420e-03f, -5.42746149e-02f,
  -1.57854795e-01f, 9.90483090e-02f, -1.00578867e-01f, -9.63514745e-02f, 1.60139576e-01f, -1.34334400e-01f, -4.39608656e-02f, 6.28781021e-02f, -2.06657752e-01f, 1.44514099e-01f,
  3.72747034e-02f, 2.57376954e-03f, -1.76007181e-01f, -3.14004153e-01f, -4.33184803e-01f, -3.45582485e-01f, -2.24252760e-01f, -3.13973166e-02f, -2.01304063e-01f, 1.29419252e-01f,
  -6.79217800e-02f, -2.02419668e-01f, -1.12914532e-01f, 7.19423220e-02f, 2.34486591e-02f, 2.89510787e-01f, 2.48891249e-01f, 2.32398316e-01f, 1.75866753e-01f, -1.73218444e-01f,
  -1.54307950e-02f, -1.79308876e-01f, 4.94059250e-02f, -6.01042099e-02f, 1.07020430e-01f, 1.58910587e-01f, 1.03833877e-01f, -6.31531775e-02f, 5.15112840e-02f, -1.92442965e-02f,
  1.08900100e-01f, 4.70328182e-02f, -1.87635217e-02f, -1.76851749e-02f, 7.81346634e-02f, 1.10469656e-02f, -5.77863716e-02f, 1.33851901e-01f, -4.15109843e-02f, -3.57037708e-02f,
  5.02089690e-03f, 4.27627489e-02f, -3.82182486e-02f, 5.42998984e-02f, -8.56416300e-02f, -6.22080900e-02f, -1.88171063e-02f, 1.01462834e-01f, -4.30987263e-03f, -5.18494435e-02f,
  5.97331412e-02f, 3.57464515e-02f, -4.23906110e-02f, -4.23452742e-02f, -5.96846528e-02f, 2.55020875e-02f, 5.06933546e-03f, -5.28639480e-02f, 4.50430252e-03f, -3.78412642e-02f,
  8.87217745e-02f, 1.13448757e-03f, -1.32084489e-01f, 1.29255652e-01f, -1.01280622e-02f, 3.04098222e-02f, 1.18332535e-01f, 4.84471023e-03f, 3.96145955e-02f, -1.06297456e-01f,
  -5.45240045e-02f, 1.11998981e-02f, 5.98169044e-02f, 3.81409749e-02f, -1.06304109e-01f, 7.87372515e-02f, 9.76026282e-02f, 3.30871940e-02f, 5.67589402e-02f, 3.94983776e-02f,
  1.35227337e-01f, 4.06388454e-02f, -2.22439654e-02f, -5.69718666e-02f, -3.28543968e-02f, 9.05160308e-02f, -1.37164935e-01f, -1.11746723e-02f, 3.94247882e-02f, -5.85499890e-02f,
  1.73010916e-01f, 2.49466635e-02f, 3.78614143e-02f, -3.77646647e-02f, 3.43337692e-02f, 9.74896625e-02f, 1.33529425e-01f, 1.34327933e-01f, 6.95612878e-02f, 1.25614077e-01f,
  1.66514784e-01f, 1.61363125e-01f, -2.96294559e-02f, 7.94591606e-02f, 4.67083566e-02f, 6.14332147e-02f, 2.40724031e-02f, 1.47730485e-01f, 4.02346961e-02f, 4.39524129e-02f,
  2.15345278e-01f, 5.24605662e-02f, 1.69606999e-01f, 3.94513190e-01f, 8.51245001e-02f, -6.71593845e-02f, 1.72279656e-01f, 2.09522232e-01f, 3.25442165e-01f, -2.19409227e-01f,
  5.74307330e-02f, -2.32841492e-01f, 4.92843017e-02f, 7.59714395e-02f, 5.11111729e-02f, 1.35785043e-01f, 2.57707596e-01f, -2.07528416e-02f, 2.17047647e-01f, 1.06918462e-01f,
  5.45734875e-02f, 9.59821343e-02f, 2.59225890e-02f, -6.71935305e-02f, -6.87322319e-02f, 6.58488646e-02f, -3.60075640e-03f, 3.49736400e-02f, -2.47928679e-01f, 4.11214344e-02f,
  -1.03432266e-02f, 3.23367417e-01f, 5.83110079e-02f, -9.28377733e-03f, 1.46492481e-01f, 7.34269470e-02f, -1.10440545e-01f, -5.82519434e-02f, 1.13684967e-01f, -6.86740316e-03f,
  -8.16576183e-02f, -1.50740370e-01f, 8.69332701e-02f, -1.32866964e-01f, 6.51834533e-02f, 6.22013118e-03f, 3.77550423e-02f, 9.09681469e-02f, -6.62178025e-02f, 7.16411099e-02f,
  2.06650631e-03f, -3.25416727e-03f, 6.93544820e-02f, 4.79437932e-02f, 1.59498051e-01f, 2.09366888e-01f, 5.41669428e-02f, 8.93407594e-03f, 1.11444453e-02f, 7.20796287e-02f,
  -2.33611818e-02f, 9.75042805e-02f, -2.19735652e-02f, 1.62595743e-03f, 1.25338465e-01f, -2.64135227e-02f, -7.84423351e-02f, -1.18623100e-01f, 8.31084326e-02f, -6.15972430e-02f,
  1.30593562e-02f, 1.20078079e-01f, 5.73415235e-02f, 1.95853715e-03f, -9.79439691e-02f, 5.21708876e-02f, 7.44821727e-02f, 9.65651870e-02f, 6.31711707e-02f, 2.54250504e-02f,
  -1.07629336e-02f, 3.48326862e-02f, -1.62265189e-02f, -7.10134730e-02f, 3.00737843e-02f, -3.66905928e-02f, 1.59529457e-03f, 4.78073582e-02f, -6.84724674e-02f, 7.29025081e-02f,
  1.85033366e-01f, 2.53465205e-01f, 7.19696581e-02f, -1.90385506e-02f, -4.24988344e-02f, -8.05784538e-02f, 8.24480131e-02f, 1.02723591e-01f, 9.10831764e-02f, 3.68793979e-02f,
  -3.91806737e-02f, 4.70634028e-02f, -2.12279018e-02f, -6.54843599e-02f, 5.39203081e-03f, 1.20306108e-02f, -2.43870318e-02f, 1.92992866e-01f, 2.40128320e-02f, 2.12182458e-02f,
  -9.70462188e-02f, -6.67420477e-02f, 4.87387553e-02f, 1.05546370e-01f, 6.07054830e-02f, -8.36030673e-03f, -7.94636607e-02f, 1.50472015e-01f, 9.76212602e-03f, -3.36626209e-02f,
  7.81130120e-02f, 9.47222114e-02f, 3.41319084e-01f, -1.05043605e-01f, -1.12270497e-01f, 2.02551901e-01f, 1.71590388e-01f, -6.55116737e-02f, -1.16939493e-01f, -8.79211277e-02f,
  -1.02548063e-01f, 3.06504488e-01f, 1.62673876e-01f, 1.98297743e-02f, -1.84352584e-02f, -7.29390979e-02f, -5.78608587e-02f, -4.31817062e-02f, -1.55511901e-01f, 4.60223667e-02f,
  -9.60653126e-02f, -2.60414243e-01f, 7.77826551e-03f, -2.15433106e-01f, 8.97008926e-02f, 1.18532643e-01f, -1.89164251e-01f, 7.48155117e-02f, 6.59248233e-02f, 1.53565496e-01f,
  -1.13380291e-01f, -1.04204766e-01f, 7.00590387e-02f, 3.94666381e-03f, -1.01521268e-01f, 3.22231390e-02f, 7.82515928e-02f, 1.44591555e-01f, -2.60855965e-02f, 4.13777828e-02f,
  -2.11930349e-02f, -4.33130413e-02f, -8.76843929e-02f, 6.12682663e-02f, -9.40590501e-02f, 1.30366340e-01f, 6.77741785e-03f, -2.44496260e-02f, 1.08034886e-01f, 4.86358330e-02f,
  1.04694642e-01f, 1.27280921e-01f, 1.71847176e-02f, 9.66208726e-02f, -2.15049530e-03f, -1.57765392e-02f, -3.40910926e-02f, 1.85964882e-01f, 7.38896579e-02f, -6.69245124e-02f,
  -1.35765865e-01f, -1.85302913e-01f, 8.47796127e-02f, 6.55860677e-02f, 3.69175375e-02f, -1.36572570e-01f, 1.91317312e-02f, 2.42047813e-02f, -1.02756381e-01f, -1.97458398e-02f,
  2.11590994e-02f, 9.97640043e-02f, -9.73467678e-02f, -5.57968840e-02f, -1.66249171e-01f, 2.33079027e-02f, 4.31557521e-02f, 2.22484618e-02f, -1.11060567e-01f, 1.26073475e-03f,
  -9.21190158e-02f, 3.95698771e-02f, 7.94476550e-03f, -2.66422573e-02f, 5.02020530e-02f, 8.88648629e-02f, -3.59821692e-02f, 1.75969020e-01f, -1.11672625e-01f, 6.41836300e-02f,
  -3.50893199e-01f, -3.34934026e-01f, -9.44721550e-02f, -9.25021097e-02f, 1.39818368e-02f, -4.11473066e-02f, -1.31338963e-03f, 4.81526330e-02f, -1.50821805e-01f, -5.06097684e-03f,
  -2.03795340e-02f, 9.40824466e-05f, -3.03879250e-02f, 4.81292466e-03f, 1.46513528e-04f, -7.61172846e-02f, 3.69569995e-02f, 1.57182869e-02f, 1.19159054e-02f, 8.23169947e-03f,
  -4.12460975e-02f, -7.46818334e-02f, 4.53773588e-02f, -2.38040201e-02f, -1.07858911e-01f, 3.36415842e-02f, -2.21620202e-02f, 6.26514107e-02f, -2.88769901e-02f, -5.54723628e-02f,
  1.66407987e-01f, -1.00333974e-01f, -2.46010587e-01f, -7.51011670e-02f, -3.04450363e-01f, 3.66995126e-01f, 3.52963597e-01f, -2.39348158e-01f, 6.44699335e-02f, 2.86790937e-01f,
  1.99516401e-01f, -3.24958637e-02f, 1.80858701e-01f, 3.38996321e-01f, 2.41042674e-01f, 3.91656786e-01f, 3.34924847e-01f, 2.52813995e-01f, -1.43730715e-01f, 1.44152686e-01f,
  2.06474327e-02f, 2.11991951e-01f, -1.29318405e-02f, -1.55785874e-01f, -4.16691676e-02f, -3.16850394e-01f, -2.06234112e-01f, -2.41567433e-01f, -9.35742855e-02f, 1.73962098e-02f,
  -4.65655364e-02f, 1.71801671e-02f, -5.44882901e-02f, 9.35377851e-02f, -8.20340887e-02f, -8.27323645e-02f, -8.22332725e-02f, 3.86799946e-02f, -5.27010784e-02f, 1.69064254e-02f,
  7.65259564e-02f, -6.92854446e-05f, 6.81039095e-02f, -1.32759929e-01f, -3.00055835e-02f, -1.10732131e-01f, -7.58069605e-02f, -6.72081187e-02f, -4.46277205e-04f, 1.71571691e-02f,
  -3.06484606e-02f, -5.07771708e-02f, 2.74199583e-02f, 4.60731946e-02f, -7.72232190e-02f, 3.42967957e-02f, 2.86922455e-02f, -1.27354302e-02f, -2.25122701e-02f, -7.51229599e-02f,
  -3.24238166e-02f, 6.85942695e-02f, 9.03335586e-02f, -1.86828878e-02f, -2.55889408e-02f, -8.54839757e-02f, 8.73981938e-02f, -1.00424858e-02f, -5.06363548e-02f, 1.73315685e-02f,
  -3.49563942e-03f, -3.61514241e-02f, -8.07804465e-02f, 6.54797629e-02f, 1.42922953e-01f, 1.26705855e-01f, -1.13987051e-01f, -2.33679749e-02f, -4.48269304e-03f, -3.28930095e-02f,
  5.49293216e-03f, 9.51029658e-02f, -2.99256034e-02f, 3.72795737e-03f, -5.38346395e-02f, -8.11690092e-03f, 6.97394535e-02f, 7.19617605e-02f, 7.92693123e-02f, -5.49246967e-02f,
  7.10649043e-02f, 4.22814526e-02f, 2.68127248e-02f, -8.67585279e-03f, -1.22842200e-01f, -1.98547672e-02f, -4.30092961e-02f, 2.12454945e-02f, -5.52097000e-02f, 9.82277393e-02f,
  -6.19833954e-02f, 1.51263792e-02f, 4.70144115e-02f, -2.53339973e-03f, -1.29931092e-01f, 9.37790610e-03f, 1.35876879e-01f, -8.05221573e-02f, 4.71284501e-02f, -1.38632685e-01f,
  2.63300370e-02f, 8.70114416e-02f, 6.68855682e-02f, 9.22084693e-03f, -5.11542745e-02f, 1.07398666e-01f, 1.26076639e-02f, -1.41913205e-01f, -1.40509918e-01f, 2.42986274e-03f,
  -3.17725986e-01f, -1.37031868e-01f, -1.21955432e-01f, -2.25869462e-01f, 5.88444956e-02f, -1.89712822e-01f, -1.55554891e-01f, 1.69490442e-01f, 1.16305076e-01f, 7.53010213e-02f,
  6.60181092e-03f, -2.79519647e-01f, 1.27431601e-01f, -2.59496391e-01f, -3.64843845e-01f, -4.46794108e-02f, -3.40703756e-01f, -2.08607659e-01f, -8.10927227e-02f, -1.30324185e-01f,
  -1.85863703e-01f, -1.36078030e-01f, -2.17533484e-01f, 1.47526413e-01f, -5.87229393e-02f, 2.87018418e-02f, 1.73918754e-02f, 5.42776845e-02f, -2.23344877e-01f, -5.36681339e-02f,
  -2.17733949e-01f, 6.50527850e-02f, -7.36264810e-02f, 2.54616234e-02f, 1.27349906e-02f, 7.87008256e-02f, -9.21727493e-02f, 1.54177693e-03f, -9.36639458e-02f, 1.02381907e-01f,
  -3.18768546e-02f, 1.45467706e-02f, -1.10940058e-02f, 1.64432421e-01f, 1.29514948e-01f, -1.47595052e-02f, -3.09247002e-02f, -2.06949592e-01f, -3.48041765e-02f, -1.08102553e-01f,
  -3.79615463e-02f, 4.40594964e-02f, 9.01647210e-02f, 1.06696030e-02f, -1.61453318e-02f, -6.18593246e-02f, -6.52400553e-02f, -9.59330350e-02f, -4.32800129e-02f, -1.52633101e-01f,
  -9.71603766e-03f, -1.90157145e-02f, -4.71888855e-03f, 5.44299483e-02f, 3.73422317e-02f, -2.37564426e-02f, 9.96712670e-02f, -6.20924458e-02f, 4.85896878e-02f, 6.42120317e-02f,
  -1.56797413e-02f, -1.33576049e-02f, 9.95358229e-02f, -3.92352156e-02f, -7.87065476e-02f, 4.64076884e-02f, -1.32179916e-01f, 8.91150534e-02f, 1.06775807e-02f, -9.71155241e-03f,
  9.68088433e-02f, 4.55942936e-02f, 1.19815938e-01f, 3.95419858e-02f, 2.05359552e-02f, 9.49365199e-02f, 9.37380642e-03f, -5.88794658e-03f, 6.94785267e-02f, -3.09632178e-02f,
  -1.83109716e-01f, 5.46262860e-02f, -5.21126613e-02f, -4.43235273e-03f, -1.26854241e-01f, 9.33232345e-03f, 4.46548611e-02f, -1.18321702e-01f, 8.89258087e-03f, 1.46965578e-01f,
  -4.25070822e-02f, 9.21182893e-03f, -7.25636184e-02f, 4.43022661e-02f, -1.08512361e-02f, -5.49636129e-03f, 2.67144386e-02f, -6.85853511e-02f, -2.63605863e-02f, 5.33214435e-02f,
  -2.93424744e-02f, 6.76191971e-02f, 3.37805413e-02f, 1.00601450e-01f, 7.36963674e-02f, 4.25863490e-02f, -3.87849547e-02f, 2.14931853e-02f, -1.02301583e-01f, -1.82301793e-02f,
  -1.84835255e-01f, 1.67777985e-02f, 7.26705045e-02f, -2.76964009e-01f, -2.01583028e-01f, 7.91347325e-02f, -6.07992001e-02f, -7.43504241e-02f, -5.12602255e-02f, 1.04869887e-01f,
  -1.33387640e-01f, -2.03602072e-02f, 1.47848278e-01f, -2.52244890e-01f, 2.78275937e-01f, 3.06556135e-01f, -1.27283856e-02f, -2.93687149e-03f, -1.65860921e-01f, -1.92856863e-01f,
  -7.96187818e-02f, -2.74345487e-01f, 2.33330950e-02f, -2.26717800e-01f, -2.34490111e-01f, -2.19145998e-01f, -3.24786361e-03f, -2.23174334e-01f, -2.26155639e-01f, -1.51945516e-01f,
  -6.65817633e-02f, -2.98124969e-01f, 5.76551221e-02f, 2.27738172e-01f, 8.62815883e-03f, -4.32287976e-02f, -3.85242440e-02f, -1.06537879e-01f, -6.49933144e-02f, 3.40166539e-02f,
  2.14629006e-02f, -5.64464442e-02f, -1.50516525e-01f, 8.52009878e-02f, -1.23792008e-01f, -4.28109244e-02f, -2.19645128e-02f, -1.15201175e-01f, 1.32613163e-02f, 3.75131257e-02f,
  1.48557499e-01f, 5.02966270e-02f, -5.51783806e-03f, 6.78112209e-02f, 6.83263242e-02f, -8.74939933e-02f, 1.01332359e-01f, 1.51668442e-02f, 2.09349953e-02f, -7.00858608e-02f,
  -2.77602673e-02f, 2.99714506e-02f, 2.64894012e-02f, 3.36215496e-02f, -1.05432317e-01f, -2.02451088e-02f, 9.42321196e-02f, -5.49541228e-02f, -1.38996691e-01f, 1.86557835e-03f,
  -1.30636945e-01f, 4.82485704e-02f, 2.02438142e-02f, 1.20530203e-01f, -4.40856256e-02f, 6.56424165e-02f, 8.25899839e-03f, -4.74079810e-02f, 6.20961376e-02f, -2.51391213e-02f,
  -1.12187512e-01f, 4.11477126e-02f, -6.58872500e-02f, -1.88018680e-02f, 1.12973057e-01f, -2.85268929e-02f, -1.02359038e-02f, 6.78164959e-02f, -3.73056531e-02f, 1.49466377e-02f,
  -1.71007574e-01f, -2.32613802e-01f, -3.55792232e-02f, -7.08353519e-02f, 8.52041841e-02f, -1.07366387e-02f, 2.84461565e-02f, 6.05867766e-02f, -6.10845350e-02f, 9.01679993e-02f,
  1.15061074e-01f, -9.27514303e-03f, -4.36988063e-02f, -2.52984520e-02f, 6.21905737e-02f, 6.00515492e-02f, -1.50796726e-01f, 6.84719086e-02f, 3.13380770e-02f, -4.08335170e-03f,
  -1.83220599e-02f, 2.77217804e-03f, 4.69608344e-02f, 3.73651236e-02f, -1.88296139e-02f, 4.94925566e-02f, -8.78671184e-02f, -3.46323289e-02f, -7.81081989e-03f, -5.26252575e-02f,
  -1.88758880e-01f, 4.75103930e-02f, 3.60312670e-01f, 3.82937700e-01f, -2.78597593e-01f, -8.67862701e-02f, -2.67397873e-02f, -2.32087821e-01f, -1.46327123e-01f, -1.44383654e-01f,
  -4.81034815e-03f, 1.82374507e-01f, -1.48764297e-01f, 1.64118037e-01f, 3.12190861e-01f, 9.55877975e-02f, 1.64465114e-01f, 2.84692086e-02f, 1.14818126e-01f, 2.72650458e-02f,
  1.04001746e-01f, 1.30184248e-01f, 2.77395755e-01f, -1.99483000e-02f, 1.69061437e-01f, 1.74294621e-01f, 1.71835780e-01f, 1.54906660e-01f, 2.38768667e-01f, 1.68702841e-01f,
  -1.54214844e-01f, -1.56567916e-02f, 3.84540297e-02f, 1.21231079e-01f, -9.67594162e-02f, -8.25750735e-03f, 1.63746402e-01f, 1.51475385e-01f, 6.23785779e-02f, 1.16417192e-01f,
  -9.28710252e-02f, -1.24018779e-02f, 8.67543928e-03f, -6.30152002e-02f, -2.84803007e-02f, 8.40319879e-03f, -1.00503653e-01f, -3.59644368e-02f, 9.22005400e-02f, -1.35608882e-01f,
  -6.20511025e-02f, -2.14190632e-02f, -1.16616160e-01f, 1.06538646e-01f, 1.53497741e-01f, 6.25244752e-02f, 6.12444170e-02f, 4.90620434e-02f, 1.35775253e-01f, 1.89978778e-02f,
  -1.00672469e-01f, 1.42906979e-02f, -9.08148810e-02f, -5.72106568e-03f, -1.75480712e-02f, 3.83918695e-02f, -2.10397225e-02f, -7.86723197e-02f, 1.27062693e-01f, 2.93163713e-02f,
  -6.23317882e-02f, 7.72443563e-02f, -6.22247159e-02f, -3.44385542e-02f, -1.42526906e-02f, -1.22554386e-02f, 4.57414649e-02f, 3.24271768e-02f, -6.84453174e-02f, 4.94046789e-03f,
  5.39606139e-02f, 1.13001063e-01f, -5.43031432e-02f, -4.20981795e-02f, -1.30988481e-02f, 1.35770991e-01f, 1.47879981e-02f, -4.00863141e-02f, 5.22807091e-02f, 6.57581538e-02f,
  6.08720072e-02f, 2.74768800e-01f, -7.13766888e-02f, 5.20404205e-02f, 7.34911487e-02f, -6.40269816e-02f, 7.43966103e-02f, 5.95614091e-02f, 1.18194170e-01f, 1.88343022e-02f,
  -3.17926109e-02f, 4.42469567e-02f, 1.57779995e-02f, 7.29572102e-02f, 1.04718864e-01f, 5.03961295e-02f, 4.22743186e-02f, 1.30180940e-01f, 7.31183812e-02f, -9.65348035e-02f,
  7.91691244e-02f, -2.00146306e-02f, -2.11490691e-02f, -6.64051296e-03f, 1.97064355e-02f, 4.18285234e-03f, -2.90949512e-02f, -7.82795716e-03f, 8.64348412e-02f, 8.66890773e-02f,
  1.25330001e-01f, -2.99621314e-01f, 2.76177144e-03f, -7.24087059e-02f, 7.97737986e-02f, 2.93961931e-02f, -7.72688165e-02f, -1.65750787e-01f, -9.09608379e-02f, -1.56689078e-01f,
  -1.71006247e-01f, -5.20739853e-02f, 1.34049028e-01f, -2.99445331e-01f, 3.66410583e-01f, 2.03591868e-01f, -1.34230629e-01f, -1.28429353e-01f, 4.36924435e-02f, -2.85792470e-01f,
  -5.35648018e-02f, -2.88627505e-01f, -1.23937847e-02f, -3.13452750e-01f, -3.03147674e-01f, -1.94866121e-01f, -9.59132090e-02f, -7.21728057e-03f, -2.69397676e-01f, -4.69732620e-02f,
  7.81501234e-02f, -1.39759481e-01f, -1.13769747e-01f, -5.76202236e-02f, -4.15799655e-02f, 2.02492718e-02f, -2.27676537e-02f, 5.21755498e-03f, -3.12047228e-02f, 2.10367814e-02f,
  7.63819888e-02f, -1.05308611e-02f, -1.67127848e-01f, 1.28333382e-02f, -3.72617878e-02f, 5.36449626e-02f, 2.21324153e-02f, 1.50805861e-01f, -1.12948738e-01f, -3.86262201e-02f,
  7.55291490e-04f, 1.42120034e-01f, 9.27814394e-02f, -1.01798251e-02f, -3.13291065e-02f, 2.02532727e-02f, -3.57663608e-03f, 1.25170395e-01f, 7.67575800e-02f, -4.23003687e-03f,
  -1.64842770e-01f, 4.31578346e-02f, 5.14800800e-03f, -9.71652493e-02f, -3.27893794e-02f, 3.55662815e-02f, -1.53569365e-02f, 2.64365412e-02f, 2.00544596e-02f, 5.46166003e-02f,
  4.63984124e-02f, 3.70675959e-02f, 5.95502518e-02f, -7.37562254e-02f, -8.55758563e-02f, 3.95318307e-02f, 1.14031851e-01f, 1.01836619e-03f, -6.83318377e-02f, 1.03224041e-02f,
  1.08840995e-01f, 1.00567892e-01f, 2.82077827e-02f, -5.27103171e-02f, -8.42829049e-02f, 4.49461266e-02f, 2.20652986e-02f, 4.83899564e-02f, 3.92015500e-04f, -2.94187274e-02f,
  -3.34323272e-02f, -1.42591402e-01f, -5.45020439e-02f, 1.06762804e-01f, 9.42212995e-03f, 3.57968686e-03f, -5.76594956e-02f, -9.06639621e-02f, 1.09398425e-01f, -1.07362241e-01f,
  4.80862781e-02f, -6.79380968e-02f, -1.08293697e-01f, 7.10268691e-02f, -2.58421209e-02f, 5.86521886e-02f, -1.77890792e-01f, -4.24208306e-02f, -1.89851169e-02f, 7.27739260e-02f,
  8.46972573e-04f, -5.46732470e-02f, 1.89553015e-02f, -1.34848714e-01f, -8.02327972e-03f, 6.17821552e-02f, 4.50052992e-02f, -3.55020091e-02f, 3.76284570e-02f, -2.91949045e-03f,
  -1.38800908e-02f, 1.85183734e-01f, -9.05107781e-02f, -5.91983087e-02f, -1.93597466e-01f, -4.05265093e-01f, -2.55949497e-01f, -1.60363093e-01f, 2.29760423e-01f, 1.37528747e-01f,
  -8.95094201e-02f, 3.27133775e-01f, 4.72917408e-02f, -8.60922858e-02f, -3.07434946e-01f, 1.53583707e-02f, -2.33069211e-01f, -4.86866608e-02f, 9.09357592e-02f, -1.05988994e-01f,
  -1.35823980e-01f, -3.10192816e-02f, -1.63442314e-01f, 8.64374265e-02f, -1.89968571e-01f, 4.72596437e-02f, -6.79501379e-03f, -7.76540413e-02f, -9.13398713e-02f, -1.80119023e-01f,
  -2.94749945e-01f, 2.05291398e-02f, 1.45073831e-01f, 2.86023300e-02f, -1.32864669e-01f, -1.00625545e-01f, -1.26856774e-01f, -8.34168494e-02f, 1.43838804e-02f, 6.62668347e-02f,
  1.12675130e-01f, 1.09128263e-02f, 3.29994224e-02f, 6.00663647e-02f, -8.06551147e-03f, 4.32620989e-03f, -1.58275850e-02f, -2.14919001e-02f, 2.13519670e-02f, -5.14641255e-02f,
  1.79511495e-03f, 1.08157080e-02f, -8.56207609e-02f, 3.97814550e-02f, -4.84382287e-02f, -3.55296396e-02f, -1.40829712e-01f, -3.29287834e-02f, -4.67158519e-02f, -2.08868794e-02f,
  -1.55651104e-03f, 2.07361579e-02f, 5.02758361e-02f, 7.14012310e-02f, 1.30116416e-03f, -5.01273833e-02f, -2.73244772e-02f, -1.27461970e-01f, 3.66779268e-02f, -7.99515918e-02f,
  3.68239321e-02f, -1.20861148e-02f, 7.83422682e-03f, -6.89511150e-02f, 4.05171551e-02f, 7.59904608e-02f, 6.21092953e-02f, 6.02373630e-02f, -8.27764198e-02f, -4.63744849e-02f,
  8.07648674e-02f, -1.39826074e-01f, 3.43384035e-02f, -1.59629121e-01f, -3.40467170e-02f, 4.31591235e-02f, -3.91975045e-02f, -7.98163265e-02f, -5.37408441e-02f, -3.80955786e-02f,
  -3.81507277e-01f, -1.70828775e-01f, 3.04562990e-02f, 4.72917780e-02f, -3.70265916e-02f, -1.02508955e-01f, 5.02492487e-02f, 4.24152128e-02f, -1.20197512e-01f, -3.45060676e-02f,
  -6.16025999e-02f, -2.33052298e-02f, -1.53146997e-01f, 1.10319471e-02f, 3.07301674e-02f, -3.06644607e-02f, -2.76254024e-02f, 7.80536085e-02f, -9.45534408e-02f, -8.26344714e-02f,
  2.59898901e-02f, -2.22212896e-02f, -6.64343834e-02f, -5.83812073e-02f, 3.31202894e-02f, -1.62245557e-02f, 9.70382839e-02f, 8.41138232e-03f, -8.18320177e-03f, 1.46648679e-02f,
  -8.47605914e-02f, -2.84256935e-01f, -3.80467512e-02f, -7.61446729e-02f, -2.47316454e-02f, -5.45118749e-02f, 4.04368788e-02f, -2.46885225e-01f, -4.50716391e-02f, -2.60912836e-01f,
  -1.64158002e-01f, 1.57429755e-01f, 1.11188650e-01f, -3.49318713e-01f, 4.06614929e-01f, 1.42219335e-01f, -1.98066786e-01f, -4.52533476e-02f, 7.32368836e-03f, -1.32591009e-01f,
  -1.56395510e-02f, -2.63942778e-01f, -6.28210679e-02f, -3.23726356e-01f, -2.52065092e-01f, -2.74593979e-01f, 1.17875576e-01f, 1.37115819e-02f, -2.22235769e-01f, 1.33992776e-01f,
  -1.88974198e-02f, 3.58815640e-02f, -6.46941811e-02f, -2.98044011e-02f, -1.49266168e-01f, 7.05791116e-02f, 6.99659809e-02f, 1.30261391e-01f, 8.32942203e-02f, 2.14795787e-02f,
  1.13480296e-02f, -2.63026841e-02f, -1.33484662e-01f, 1.68275125e-02f, -7.13514909e-02f, -2.13724896e-01f, 2.71900501e-02f, -1.14547916e-01f, -6.03228249e-02f, 5.84899448e-02f,
  2.17086803e-02f, -6.24463893e-02f, -5.09263277e-02f, 1.05078280e-01f, 6.55358359e-02f, -2.76238266e-02f, 9.06692669e-02f, 8.07331055e-02f, 6.89860210e-02f, 7.14182407e-02f,
  7.47260228e-02f, 9.37745571e-02f, 3.07898186e-02f, -5.52983545e-02f, -1.09275766e-02f, -4.51208428e-02f, -7.15692863e-02f, 7.34052584e-02f, -1.59947798e-02f, -9.63952020e-02f,
  5.45483865e-02f, -2.25722659e-02f, 7.20107273e-05f, -9.87611432e-03f, -6.41440377e-02f, 8.32900181e-02f, -1.85148988e-03f, -3.71554606e-02f, -6.22180291e-03f, -8.70060921e-02f,
  6.09591305e-02f, 4.28236201e-02f, -9.99133214e-02f, -1.37682091e-02f, 4.41021584e-02f, 8.88114572e-02f, -1.47870272e-01f, -2.39852220e-02f, -8.25577378e-02f, 3.15584578e-02f,
  3.36413607e-02f, 5.90829877e-04f, 3.58092319e-03f, -9.21967402e-02f, 3.81656885e-02f, -8.20197240e-02f, -8.98808762e-02f, -5.76193109e-02f, 1.06502865e-02f, -5.51525317e-02f,
  -1.32485092e-01f, 9.51118488e-03f, 3.31015401e-02f, 1.04159474e-01f, 4.88527026e-03f, -7.55525157e-02f, 6.10483959e-02f, 4.09584641e-02f, 1.43946765e-03f, -4.67684492e-02f,
  -9.24365595e-02f, -4.17675264e-02f, 1.32482192e-02f, -1.38579328e-02f, 1.48061980e-02f, 6.29744753e-02f, 6.92296699e-02f, 3.62363122e-02f, 1.06183924e-01f, 7.19515309e-02f,
  1.93606466e-01f, 3.43175918e-01f, 2.40274370e-01f, 1.49424389e-01f, -1.18643448e-01f, -7.29418322e-02f, 1.22824661e-01f, -8.02856684e-02f, 2.81087428e-01f, 1.38476983e-01f,
  -2.07707524e-01f, 2.30506346e-01f, -2.24918529e-01f, 1.72999948e-01f, -2.32677847e-01f, -2.21470654e-01f, 9.69579294e-02f, 1.72660381e-01f, 7.65776113e-02f, 1.64850995e-01f,
  -8.74677375e-02f, -1.54329896e-01f, -1.19906522e-01f, -1.50293216e-01f, 1.87294692e-01f, 2.01420024e-01f, -2.23477408e-01f, -4.84587066e-02f, 1.03613950e-01f, -1.08524546e-01f,
  7.34413713e-02f, 6.10791333e-02f, 6.71454752e-03f, 5.46686649e-02f, 1.13166897e-02f, 8.55322704e-02f, 3.15443426e-02f, -3.16780210e-02f, -9.87838730e-02f, 8.52947459e-02f,
  1.03660867e-01f, -2.77792546e-03f, 8.49662274e-02f, 7.40451440e-02f, 1.22168086e-01f, 1.10508436e-02f, 1.07017480e-01f, 3.19834724e-02f, 1.48394242e-01f, 2.01909598e-02f,
  9.75331590e-02f, 1.30119234e-01f, 1.63109466e-01f, 9.55236182e-02f, -6.37704283e-02f, -5.85622452e-02f, 9.04290155e-02f, 1.69181734e-01f, 6.10728115e-02f, 1.51362494e-01f,
  -1.16326544e-03f, 5.73583469e-02f, -4.55107801e-02f, 1.79824773e-02f, -1.05782144e-01f, -9.14248005e-02f, -3.37937772e-02f, -2.77485941e-02f, 9.75536630e-02f, 1.88243128e-02f,
  3.36673744e-02f, 6.28164634e-02f, -1.20898737e-02f, 1.04729138e-01f, -6.28020987e-02f, 1.65448129e-01f, 6.14581397e-03f, 1.71202719e-02f, 9.97412056e-02f, 3.96597944e-02f,
  -1.53433457e-01f, -6.86715543e-02f, -5.85178249e-02f, 3.84554341e-02f, -1.01957045e-01f, 2.33471151e-02f, -5.15673496e-02f, -3.86457145e-02f, -6.69060275e-02f, -4.04507853e-02f,
  9.11256000e-02f, 1.74825355e-01f, -5.21275476e-02f, -6.30267337e-02f, -2.03248598e-02f, -6.48016557e-02f, -3.97258298e-03f, 7.70275295e-02f, 8.33668411e-02f, 1.21174641e-02f,
  -4.94190305e-02f, -6.88127950e-02f, 5.66692688e-02f, 2.69976575e-02f, -5.40436730e-02f, 9.46936707e-05f, 9.98010039e-02f, -5.02088368e-02f, -3.92029360e-02f, 4.70028669e-02f,
  8.38802138e-04f, -1.07546791e-01f, 4.07915749e-02f, 6.82309270e-02f, 5.15989736e-02f, 8.41156542e-02f, 3.46836671e-02f, 1.36605287e-02f, -2.07718648e-02f, -6.57102391e-02f,
  2.33777165e-01f, 2.70179749e-01f, 1.97846502e-01f, 2.65709996e-01f, -1.41372820e-02f, 1.33852080e-01f, 4.61767577e-02f, 2.12057997e-02f, 3.39247435e-01f, 4.69909422e-02f,
  -2.28407234e-01f, 3.73064667e-01f, -1.62046582e-01f, 1.22632250e-01f, -1.21537782e-01f, -4.46954109e-02f, 1.55702725e-01f, 1.17297135e-01f, 5.22761643e-02f, 1.38414145e-01f,
  6.62963986e-02f, -1.85541227e-01f, -5.66991791e-02f, -1.50584430e-01f, -7.50549091e-03f, 1.45868324e-02f, -3.60595673e-01f, -1.47177175e-01f, -2.66787019e-02f, -1.22387066e-01f,
  1.22238155e-02f, 8.69300738e-02f, 5.34349456e-02f, -1.45204151e-02f, 3.43639255e-02f, -9.80361328e-02f, -2.21273173e-02f, -1.68663673e-02f, 2.81593017e-02f, 5.94360493e-02f,
  8.30805972e-02f, -3.82587197e-03f, 8.23436156e-02f, -1.26269251e-01f, 1.09158218e-01f, 4.37028259e-02f, 2.58475617e-02f, -4.29480383e-03f, 1.54517684e-03f, 3.83926481e-02f,
  6.92544831e-03f, -2.47182157e-02f, 4.51693274e-02f, 3.54436971e-02f, 9.40385908e-02f, 4.03530821e-02f, 9.26930755e-02f, -3.14462706e-02f, 5.85161410e-02f, 9.12564024e-02f,
  6.19923957e-02f, -5.44913523e-02f, -5.12841269e-02f, -9.89051834e-02f, 2.94037946e-02f, -1.28233312e-02f, 3.93969603e-02f, -1.48039274e-02f, 1.55494988e-01f, -5.45938946e-02f,
  -1.78183261e-02f, 3.93816046e-02f, 1.06844559e-01f, 4.56032641e-02f, 7.18853772e-02f, 7.84718394e-02f, 2.27461662e-02f, -3.58919590e-03f, -2.65495572e-02f, -2.00316980e-02f,
  2.37628315e-02f, 2.37616205e-05f, -7.00864643e-02f, -1.22055896e-01f, 4.80398573e-02f, -6.87910020e-02f, 2.57494207e-02f, 1.13095328e-01f, -2.19060443e-02f, -5.36156930e-02f,
  3.52200158e-02f, 1.89943179e-01f, 3.32112648e-02f, 7.71959946e-02f, 2.54348991e-03f, -1.26398876e-02f, 7.58592859e-02f, 2.86717098e-02f, 7.03443885e-02f, 4.58605168e-03f,
  3.93798202e-02f, 8.80118310e-02f, 3.18589099e-02f, -9.55603793e-02f, 7.48097673e-02f, -1.11474641e-01f, -1.53030092e-02f, 8.25017989e-02f, 1.43450601e-02f, -1.81688461e-02f,
  -4.07704851e-03f, 1.15799904e-01f, 5.39499074e-02f, 4.35039476e-02f, 6.52174652e-02f, -5.51996008e-02f, 4.44242507e-02f, 1.07934237e-01f, -8.49974528e-02f, 2.61237584e-02f,
  -2.60405093e-01f, 1.76293463e-01f, 7.36687556e-02f, -1.64744273e-01f, -6.33873418e-02f, 3.54893645e-03f, -1.04689948e-01f, 1.51815847e-01f, -8.99549797e-02f, 1.07649714e-01f,
  4.53988127e-02f, -3.56401280e-02f, 1.28885910e-01f, -1.94651678e-01f, -4.26981449e-01f, -2.41103932e-01f, -1.01695545e-01f, 4.05965783e-02f, -7.83586726e-02f, 2.34621316e-01f,
  -1.70131981e-01f, -1.45200074e-01f, -1.51646897e-01f, 1.58136487e-01f, 9.62886214e-02f, 2.92927206e-01f, 1.68947414e-01f, 1.00035943e-01f, 1.03583165e-01f, -1.30581096e-01f,
  1.41048944e-02f, 1.45867527e-01f, 1.29084423e-01f, 1.14673130e-01f, 1.16123985e-02f, 3.21040601e-02f, 1.67119235e-01f, -1.17486984e-01f, -6.34414479e-02f, -6.02662936e-02f,
  7.55582526e-02f, -6.91473782e-02f, -3.15714441e-02f, -1.80120230e-01f, -1.43671073e-02f, -4.04387079e-02f, -8.42080861e-02f, -2.74887923e-02f, 1.29238833e-02f, -1.61471933e-01f,
  2.56760698e-02f, -1.28386006e-01f, 2.07563397e-02f, -1.14600116e-03f, -7.02642500e-02f, 1.75832585e-02f, 9.47121084e-02f, -5.25749885e-02f, -1.17001999e-02f, -1.32704945e-03f,
  -8.53568241e-02f, -5.12062050e-02f, 8.82942900e-02f, -2.90879011e-02f, -8.53629112e-02f, 1.46506339e-01f, -5.93966804e-03f, 9.10295323e-02f, 5.30716889e-02f, -2.38722153e-02f,
  1.75629482e-02f, 1.14801571e-01f, 7.68569708e-02f, 7.18370005e-02f, -1.16753958e-01f, 3.27544706e-03f, -1.18853532e-01f, 5.48283644e-02f, -7.45543698e-03f, -2.89891250e-02f,
  1.53298110e-01f, -6.61561787e-02f, 1.05406316e-02f, 2.60895099e-02f, 1.87250844e-04f, -4.42467891e-02f, -4.60573146e-03f, -9.87439156e-02f, -5.84748760e-02f, 1.04292696e-02f,
  9.46832299e-02f, 1.77012607e-01f, 1.15592554e-01f, 8.44550654e-02f, 8.55115894e-03f, 1.87092251e-03f, -1.53123690e-02f, 5.17843962e-02f, -5.30204773e-02f, -8.11806768e-02f,
  7.99417421e-02f, 3.07330806e-02f, 1.44238845e-01f, -1.01056546e-01f, -2.42301989e-02f, 3.35867004e-03f, 7.67729208e-02f, 6.13989308e-03f, 7.87169263e-02f, 4.24688943e-02f,
  -2.15587225e-02f, 8.12221691e-02f, -1.36683345e-01f, 1.05171457e-01f, -8.85537863e-02f, 8.74305144e-02f, 2.17709821e-02f, -3.56078409e-02f, 1.00265797e-02f, 1.53161943e-01f,
  3.25524896e-01f, -3.46845031e-01f, 2.58969486e-01f, 2.70454228e-01f, 2.60731310e-01f, -3.81066650e-03f, 3.17085296e-01f, -8.38249400e-02f, 3.14918719e-02f, -3.54637563e-01f,
  -4.53361049e-02f, -4.00850885e-02f, -1.97858483e-01f, 4.96464521e-02f, 4.00066823e-01f, -2.21882630e-02f, 4.88613620e-02f, 1.69284686e-01f, 6.68977574e-02f, 1.73414603e-01f,
  2.37158075e-01f, 1.58607617e-01f, 1.36716768e-01f, -8.97932202e-02f, 4.42778766e-02f, 3.78591157e-02f, 8.82956311e-02f, 1.61503360e-01f, -1.44653507e-02f, 9.88497287e-02f,
  -2.17539415e-01f, 2.94969138e-02f, -3.58750299e-02f, -5.68444505e-02f, -6.52123615e-02f, 8.79782625e-03f, -1.20579749e-02f, 1.20096080e-01f, 6.49526417e-02f, -6.77432492e-02f,
  -8.60192031e-02f, 1.02275819e-01f, -6.65043341e-03f, 4.22324426e-02f, -1.10123709e-01f, -6.20084330e-02f, -2.99619026e-02f, -1.19350217e-01f, 5.60213439e-02f, 6.69790432e-02f,
  3.67472731e-02f, -1.38164729e-01f, -2.54278118e-03f, -1.53820971e-02f, 1.50213093e-01f, -8.24680924e-02f, -5.29254368e-03f, 3.11379060e-02f, -1.56599760e-01f, -2.94822128e-03f,
  5.77202700e-02f, -7.95756429e-02f, -5.49881198e-02f, 6.27357687e-04f, 5.24279699e-02f, -2.71357596e-03f, 4.20392975e-02f, 4.16717529e-02f, 2.03148648e-03f, -4.32721041e-02f,
  8.66361894e-03f, -6.09163791e-02f, 3.96569967e-02f, -1.66532528e-02f, 7.38638937e-02f, -4.08140682e-02f, 1.19858399e-01f, 1.38311505e-01f, -3.89765725e-02f, 1.87807549e-02f,
  7.37431794e-02f, 3.81515361e-03f, -7.97120407e-02f, -7.10028177e-03f, 6.75643981e-02f, 1.94980428e-02f, -3.18974000e-03f, 2.15864461e-02f, -2.86636036e-02f, 8.14388767e-02f,
  -4.43641186e-01f, -2.05227688e-01f, -9.36920419e-02f, -1.29838392e-01f, 3.18681262e-02f, -3.00454088e-02f, 1.16221122e-02f, -4.74745445e-02f, -7.79327974e-02f, 1.73682813e-02f,
  -9.01866034e-02f, -4.24892828e-02f, -9.24178138e-02f, -4.45104903e-03f, 3.25799733e-02f, 1.29119949e-02f, 1.04647368e-01f, -1.10572852e-01f, 1.39900828e-02f, -4.78183590e-02f,
  2.69259680e-02f, 7.51499981e-02f, 3.03197242e-02f, 5.55830002e-02f, 1.99910235e-02f, 1.47197889e-02f, 1.20386891e-02f, -3.41129140e-03f, -6.08023442e-02f, -1.34575116e-02f,
  -2.08005175e-01f, 1.09108731e-01f, -1.49802670e-01f, -1.38020515e-01f, 7.54986033e-02f, -3.29040408e-01f, -1.78208977e-01f, 2.27382965e-02f, 1.50898218e-01f, 1.28727332e-01f,
  1.24253891e-01f, 2.07410648e-01f, 2.07741544e-01f, -8.26206356e-02f, -2.41122931e-01f, 3.79725322e-02f, -3.06829304e-01f, -2.64575958e-01f, -1.93897765e-02f, -1.08978555e-01f,
  -4.94542085e-02f, -1.29396051e-01f, -1.76387101e-01f, 1.09500423e-01f, -7.78589323e-02f, -2.42929012e-02f, -1.36680588e-01f, 1.65211916e-01f, -9.06521901e-02f, 1.62275419e-01f,
  -1.65277764e-01f, -1.05401669e-02f, -9.88372043e-02f, -3.54389325e-02f, -1.70333087e-01f, -8.88381675e-02f, -1.12090603e-01f, 3.50240953e-02f, -6.45833611e-02f, -1.08824059e-01f,
  2.99531519e-02f, 2.90006995e-02f, -3.92665081e-02f, 7.93814585e-02f, 1.88492462e-02f, 1.82084348e-02f, -1.89671095e-03f, -1.79777667e-01f, 3.14308926e-02f, 6.39693141e-02f,
  -3.52961905e-02f, -1.58479102e-02f, -1.04069173e-01f, -1.09401748e-01f, 6.39040247e-02f, 9.98782143e-02f, -1.32444695e-01f, 5.18969744e-02f, -9.21402425e-02f, -8.51590633e-02f,
  4.71183918e-02f, -9.98589918e-02f, 5.93420444e-03f, 8.00353736e-02f, 6.23813570e-02f, 1.15895264e-01f, 6.62507936e-02f, 2.89629884e-02f, -4.85827103e-02f, -6.64485171e-02f,
  -7.67875463e-02f, 4.28058952e-03f, 7.31236786e-02f, -7.03761429e-02f, -6.68195039e-02f, -4.66640145e-02f, -1.42328739e-01f, 1.21813461e-01f, -1.58922330e-01f, 3.68183367e-02f,
  7.24758655e-02f, 5.27034551e-02f, 1.16554402e-01f, -8.69016051e-02f, -8.64253473e-03f, 3.91014665e-03f, 3.19304690e-02f, 1.33235837e-04f, 6.00502416e-02f, -9.41339508e-03f,
  -3.58423740e-01f, -1.67641819e-01f, 2.19134446e-02f, 2.16813125e-02f, -4.85311784e-02f, -1.22739390e-01f, -9.32149142e-02f, 5.14369970e-03f, -4.83737998e-02f, -6.56711683e-02f,
  -1.17522135e-01f, -3.14182974e-02f, -5.81110232e-02f, -4.88096289e-02f, 3.30294967e-02f, -3.67685705e-02f, -8.66022706e-02f, 3.46318074e-02f, -4.10859883e-02f, -4.00899276e-02f,
  6.24255762e-02f, -3.89686674e-02f, -5.06466366e-02f, 5.47461072e-03f, -9.06832218e-02f, -6.46625534e-02f, -1.11020915e-01f, 1.17068656e-01f, -9.08739567e-02f, 2.80921254e-03f,
  2.07410216e-01f, -1.40625760e-01f, -1.04265109e-01f, 2.35084131e-01f, 1.51254773e-01f, -6.47969916e-02f, -2.50840753e-01f, 6.00125715e-02f, 6.41739964e-02f, -1.65230617e-01f,
  1.22395314e-01f, 1.00857049e-01f, -3.21293771e-01f, 3.63630205e-01f, 3.71852428e-01f, -2.59781927e-01f, 1.72958463e-01f, 4.99061216e-03f, 6.75462782e-02f, 2.16987282e-01f,
  2.38418609e-01f, 3.36823463e-01f, 1.05899669e-01f, 7.39753246e-02f, 1.70957088e-01f, -6.49122894e-02f, 7.80841932e-02f, -2.13624835e-01f, 1.45672411e-01f, 1.18003801e-01f,
  2.49192584e-02f, 7.44732693e-02f, 5.26871718e-03f, -5.55757806e-03f, 6.00768114e-03f, 2.62510851e-02f, 1.49430139e-02f, -2.80596744e-02f, -3.97456810e-02f, 3.12343845e-03f,
  -7.03404099e-02f, 1.49114072e-01f, 4.37781475e-02f, -7.16698682e-03f, 3.13289985e-02f, 3.50955576e-02f, 4.37226705e-02f, 5.89156933e-02f, -5.61893880e-02f, 4.18436453e-02f,
  -2.48412322e-02f, -7.58359805e-02f, -7.17793405e-03f, -1.44979609e-02f, -2.71849204e-02f, 2.62047313e-02f, 2.98826862e-02f, -4.26956452e-02f, -2.15411466e-02f, 3.08719166e-02f,
  -8.94296542e-03f, -8.64400994e-03f, -1.11992285e-01f, -4.62598652e-02f, -8.41293950e-03f, -5.13918139e-02f, -4.95259976e-03f, -6.17515668e-02f, -6.14620447e-02f, -5.37881395e-03f,
  -5.24182506e-02f, -3.03822961e-02f, 3.14682201e-02f, -3.17908525e-02f, 1.37132734e-01f, 2.85236090e-02f, -5.67260310e-02f, 1.54005243e-02f, -6.36629909e-02f, -8.17039907e-02f,
  -3.71498652e-02f, 4.94520366e-02f, -3.64510678e-02f, -1.20149627e-01f, -5.07106036e-02f, 3.55972201e-02f, 1.81898158e-02f, -1.39488177e-02f, 3.49607542e-02f, -3.17963660e-02f,
  1.00413281e-02f, 6.74790815e-02f, -4.45695687e-03f, -3.83815169e-02f, -1.17228210e-01f, 5.85439987e-02f, -3.68600376e-02f, 1.02859877e-01f, -5.08781038e-02f, -6.88326135e-02f,
  7.09391683e-02f, -6.91301003e-02f, 2.23570429e-02f, 1.36567369e-01f, 6.49103671e-02f, 6.05072416e-02f, 5.34450561e-02f, -1.32520106e-02f, 6.53529540e-02f, 4.20216992e-02f,
  -2.39453278e-02f, -2.95376517e-02f, -4.57572229e-02f, 2.67552715e-02f, 4.81940918e-02f, 6.04064353e-02f, 9.11702663e-02f, -4.47164178e-02f, -7.18509555e-02f, -6.50054775e-03f,
  1.04518168e-01f, -1.34570688e-01f, -2.29048178e-01f, -1.85917944e-01f, -1.02470815e-01f, -1.56717658e-01f, -3.13136101e-01f, -1.56895861e-01f, -1.14673696e-01f, -2.14751676e-01f,
  -1.39034167e-01f, -2.75941044e-02f, -2.41933972e-01f, -1.21726915e-01f, 2.91808337e-01f, 1.23283103e-01f, -1.09799534e-01f, 4.07440327e-02f, 6.29076287e-02f, -1.97587669e-01f,
  4.54421341e-02f, -6.52180240e-02f, -6.50490299e-02f, -4.22841981e-02f, -1.30349636e-01f, 4.03905623e-02f, 1.44153014e-01f, -8.64712745e-02f, 1.53906336e-02f, 9.39428881e-02f,
  6.12146445e-02f, 1.98569782e-02f, -1.65965006e-01f, 2.74810456e-02f, 1.97883160e-03f, -2.55517066e-02f, -6.16610004e-03f, -1.16526345e-02f, 9.76186767e-02f, -4.85887416e-02f,
  4.57120277e-02f, 3.39430408e-03f, 2.98284106e-02f, 2.85280049e-02f, 2.80220006e-02f, -1.58977695e-02f, -3.47496185e-04f, 5.03769494e-04f, -1.28842250e-01f, -4.60780822e-02f,
  -1.80773467e-01f, -8.91694892e-03f, 2.07478721e-02f, -4.51913290e-02f, -8.33573937e-02f, -8.17325264e-02f, -8.81200954e-02f, -1.87041700e-01f, 9.02692303e-02f, -2.91391220e-02f,
  1.39956418e-02f, 3.21265426e-03f, -3.22422013e-02f, 3.85878491e-03f, -1.18939662e-02f, -1.39653787e-01f, 5.45809828e-02f, -1.39524881e-02f, 4.79124226e-02f, -9.54929460e-03f,
  -6.12079762e-02f, -1.67033210e-01f, 4.32727858e-02f, 3.74936424e-02f, 1.87475737e-02f, 6.51415884e-02f, 5.96632250e-02f, -3.01570911e-02f, -1.49156585e-01f, -3.31970826e-02f,
  -2.64920313e-02f, 5.65728880e-02f, -1.66233763e-01f, 1.37513101e-01f, 6.48115501e-02f, -1.02627620e-01f, -1.49065675e-02f, -6.50155395e-02f, 5.33168502e-02f, 5.69173172e-02f,
  -6.12874702e-02f, -9.38661695e-02f, -5.81756383e-02f, 4.06384803e-02f, -3.44023667e-02f, 8.39505643e-02f, 1.01901956e-01f, -4.17760834e-02f, -8.16360712e-02f, 1.76767446e-02f,
  -2.84952670e-02f, -2.03463491e-02f, 9.34692919e-02f, -6.88492060e-02f, -8.79734661e-03f, -1.64442092e-01f, -3.31386626e-02f, 3.36201862e-03f, 7.91702569e-02f, 3.53200994e-02f,
  -9.84544829e-02f, -9.59483907e-03f, 3.56339552e-02f, -8.50901827e-02f, 8.56063236e-03f, -1.04916774e-01f, 4.21635527e-03f, 4.15422628e-03f, 8.95918012e-02f, -3.50040719e-02f,
  1.16953567e-01f, 1.85591578e-01f, 9.69775096e-02f, 2.31791183e-01f, -1.12379283e-01f, -2.44714841e-01f, -2.82866389e-01f, 1.55453861e-01f, 1.28300145e-01f, -1.32216558e-01f,
  -3.69290486e-02f, 1.41659647e-01f, -6.27116039e-02f, 1.23540051e-01f, 2.77424186e-01f, -1.82133652e-02f, 9.36836973e-02f, -1.03234407e-02f, 9.30407345e-02f, 7.17396811e-02f,
  1.64027154e-01f, 4.19228487e-02f, 1.69013232e-01f, 1.32796884e-01f, 6.45191297e-02f, 1.70449361e-01f, 2.77219325e-01f, -1.11377597e-01f, 2.42315903e-02f, -1.43667310e-01f,
  -6.54662699e-02f, 1.67507872e-01f, 1.14252172e-01f, -7.80528933e-02f, 2.81341914e-02f, -1.14396296e-01f, -7.39700906e-03f, -7.06432834e-02f, 4.41224966e-03f, 2.46003289e-02f,
  5.65549470e-02f, 7.82873854e-02f, -1.50958821e-03f, 2.93877218e-02f, -1.62860259e-01f, 2.49199811e-02f, 3.82948630e-02f, -1.19820364e-01f, 1.68892387e-02f, -4.77554016e-02f,
  -7.37095065e-03f, -4.57726233e-02f, 1.02125041e-01f, 4.90913577e-02f, 3.54262665e-02f, -6.80215880e-02f, -1.08953230e-01f, -1.54225752e-02f, 1.15979217e-01f, 2.98309512e-02f,
  -5.91993369e-02f, -5.99276647e-02f, -5.68743534e-02f, -1.91856956e-03f, -7.73562212e-03f, -2.23179311e-02f, -7.91826844e-02f, -4.32809163e-03f, -4.25801314e-02f, 4.07547168e-02f,
  8.25928599e-02f, -5.62305897e-02f, -6.37104511e-02f, -1.13605894e-01f, -1.17424112e-02f, -8.46168026e-02f, -5.49624600e-02f, -3.11333151e-03f, -2.09414046e-02f, 4.77118045e-02f,
  -1.14012361e-02f, -1.61427498e-01f, 6.46609738e-02f, -2.44745389e-02f, -3.86620574e-02f, 1.09395906e-02f, -5.77831417e-02f, -2.03304701e-02f, -8.55110511e-02f, -4.45656814e-02f,
  1.73913091e-01f, 2.10512847e-01f, 6.96804747e-02f, -9.74029768e-03f, 1.36311948e-01f, 5.00827283e-03f, 3.35793085e-02f, 6.30162656e-02f, 7.42990226e-02f, 3.29526886e-02f,
  4.87515926e-02f, 4.51808162e-02f, 5.08086532e-02f, -1.10383384e-01f, 8.77403654e-03f, 5.43041267e-02f, -6.80648210e-03f, 9.52347144e-02f, 7.06990883e-02f, 9.06190351e-02f,
  1.03103548e-01f, -4.24945820e-03f, -2.90336497e-02f, 3.95229906e-02f, -5.77120334e-02f, 6.42459542e-02f, 1.65681280e-02f, -3.06491703e-02f, -3.91332991e-02f, 3.29104066e-02f,
  -1.93878919e-01f, 4.00227875e-01f, -1.64416537e-01f, 2.15640306e-01f, -1.42932050e-02f, -2.26479396e-02f, -4.41228934e-02f, 1.68424502e-01f, -4.78322692e-02f, 1.90942675e-01f,
  2.43784338e-01f, -3.07097961e-03f, 2.26336136e-01f, 3.74511033e-01f, 2.50171483e-01f, 1.84430003e-01f, 1.47364125e-01f, 1.22435264e-01f, 2.60872897e-02f, 2.27077425e-01f,
  9.80822518e-02f, 2.91493654e-01f, 1.61859810e-01f, 1.41532570e-01f, 6.62150830e-02f, -4.98840772e-02f, 1.64434746e-01f, 2.10158410e-03f, 1.52928889e-01f, -7.47226104e-02f,
  -7.36343488e-02f, 1.03141300e-01f, -1.68693662e-02f, -1.26884267e-01f, -5.13511598e-02f, -1.72376469e-01f, 7.00094271e-03f, -1.57708570e-01f, -9.11722630e-02f, 4.70717438e-02f,
  -2.66459696e-02f, -4.95174229e-02f, -4.82766926e-02f, -1.38573279e-03f, -9.43242684e-02f, -9.66229662e-03f, 3.56226577e-03f, 4.93267439e-02f, 4.52187955e-02f, 7.01696351e-02f,
  -9.92449277e-05f, 6.25917017e-02f, 9.61534083e-02f, -3.04997992e-02f, -6.90822024e-03f, 6.19747303e-02f, -5.65784089e-02f, -5.13019860e-02f, 3.15891169e-02f, 9.15274173e-02f,
  -5.68713471e-02f, -1.84860788e-02f, -3.02770603e-02f, 5.95497303e-02f, 7.58669078e-02f, -1.20860357e-02f, 2.10324991e-02f, -7.43207112e-02f, 4.35430855e-02f, 7.90925324e-02f,
  9.80093926e-02f, 5.92901446e-02f, 8.36010873e-02f, 5.00576980e-02f, 1.89325381e-02f, 3.69621478e-02f, -3.63596119e-02f, -1.43531738e-02f, 8.06566030e-02f, 8.22905079e-02f,
  2.25232970e-02f, 8.00313130e-02f, 3.50387916e-02f, -4.93843704e-02f, 2.57624369e-02f, 8.27066004e-02f, 7.59928823e-02f, 1.02873407e-01f, -8.55293125e-03f, -6.54641464e-02f,
  1.14951290e-01f, 2.24311471e-01f, -2.29206346e-02f, -1.32327089e-02f, -3.69769968e-02f, -2.81530712e-02f, 2.10669059e-02f, -2.46116146e-02f, 7.81045035e-02f, 2.63053440e-02f,
  1.59824435e-02f, -1.39869563e-02f, -6.24969676e-02f, -1.05449557e-01f, -7.32161477e-02f, 1.18630655e-01f, 1.10490352e-01f, -2.82206219e-02f, 9.22951475e-02f, 1.07389584e-01f,
  1.24154678e-02f, -5.96698448e-02f, -1.77148003e-02f, -1.19744658e-01f, -1.02331817e-01f, 6.50683120e-02f, 6.36868477e-02f, -9.31160599e-02f, 5.62518910e-02f, -2.95168422e-02f,
  -1.04089104e-01f, -1.25057027e-02f, 3.01964134e-01f, 1.40989080e-01f, -6.99384436e-02f, -3.32376003e-01f, -1.99489087e-01f, 7.73590952e-02f, -3.78598571e-02f, -2.06971318e-01f,
  -1.30962715e-01f, 1.76703960e-01f, -1.11304626e-01f, 1.23533115e-01f, 3.36904913e-01f, -3.34535539e-02f, 7.56429434e-02f, 1.24689773e-01f, 1.11935295e-01f, 1.43025532e-01f,
  2.18676329e-01f, 9.16369781e-02f, 3.20338279e-01f, 1.51668340e-01f, 1.79376662e-01f, 3.25484276e-01f, 3.60927135e-01f, 2.06998408e-01f, 3.31699252e-01f, 5.55334426e-02f,
  -1.16761237e-01f, -3.45445797e-02f, -6.93000387e-04f, -5.45524284e-02f, 1.20786741e-01f, 2.09807102e-02f, 4.19922061e-02f, -5.71440682e-02f, -5.17901331e-02f, 6.77236468e-02f,
  8.41986239e-02f, 1.01538114e-02f, 1.14439717e-02f, -2.30415780e-02f, -8.79515633e-02f, 8.74126703e-02f, 8.15257505e-02f, -4.04051021e-02f, -1.24150636e-02f, -2.92015951e-02f,
  5.96915781e-02f, -4.49184589e-02f, 1.81930494e-02f, -8.67330506e-02f, 2.61566788e-02f, -1.61284328e-01f, -1.04312506e-02f, 3.49921137e-02f, -1.30005060e-02f, 9.42737460e-02f,
  -1.26979619e-01f, 7.47039914e-03f, 5.85700125e-02f, -5.83133399e-02f, -8.27869475e-02f, 9.69485380e-03f, 4.30677086e-02f, -8.07161704e-02f, 1.37304803e-02f, -9.49120298e-02f,
  -1.22164853e-01f, 7.45007992e-02f, -7.01793134e-02f, -2.02440377e-02f, 5.40178195e-02f, -8.45669284e-02f, 1.22716807e-01f, -2.95280963e-02f, 7.95770362e-02f, -5.18157892e-02f,
  -1.47522837e-01f, -3.26495781e-03f, 1.06476262e-01f, 4.28013057e-02f, -7.29491934e-02f, -3.94439213e-02f, -7.62471557e-02f, 1.03857387e-02f, -3.01448554e-02f, 2.22773731e-01f,
  -1.13302864e-01f, 1.05915032e-01f, -5.18533178e-02f, 8.85528699e-03f, 2.20376141e-02f, 2.36329623e-02f, 3.69540714e-02f, -1.10424705e-01f, 4.98148240e-02f, 1.36348248e-01f,
  5.14744110e-02f, 4.61264886e-02f, -4.36209254e-02f, -2.47957744e-02f, 5.10803657e-03f, -7.13861287e-02f, -1.78335793e-02f, 1.99846365e-02f, -3.85567062e-02f, 3.69681008e-02f,
  4.82793106e-03f, -8.26535374e-03f, 1.62826374e-01f, -6.38500005e-02f, -3.93844768e-02f, 6.18089084e-03f, -1.64555475e-01f, -9.54499766e-02f, 2.81713102e-02f, 7.15015754e-02f,
  -4.19450164e-01f, 3.08616370e-01f, -9.83273685e-02f, 1.49083212e-01f, -2.48138774e-02f, 3.97624612e-01f, 2.30977997e-01f, 7.85450116e-02f, 2.57183492e-01f, 2.75946170e-01f,
  5.53193875e-02f, -6.22661747e-02f, 1.03477854e-02f, 2.23585725e-01f, -5.04729822e-02f, 1.53261408e-01f, 1.86587647e-01f, 2.35592291e-01f, 7.25398287e-02f, -1.56715706e-01f,
  -8.07670802e-02f, 6.92110062e-02f, -2.58408836e-03f, -1.48758799e-01f, -6.87580258e-02f, -1.12603232e-01f, -1.23216853e-01f, -4.18188684e-02f, -1.01620341e-02f, 7.55027235e-02f,
  -1.38634801e-01f, -5.95683679e-02f, -6.05955496e-02f, -7.49585181e-02f, -1.86202556e-01f, -6.95805550e-02f, -6.88727424e-02f, -4.36288454e-02f, -1.32226929e-01f, 9.70519893e-03f,
  -1.27725348e-01f, -1.18290484e-01f, 2.94302758e-02f, 4.90497723e-02f, 4.41861860e-02f, -5.26386425e-02f, 6.01935908e-02f, 3.77139449e-02f, -2.04199133e-03f, -8.46703947e-02f,
  -1.74608976e-02f, 2.03571394e-02f, -1.04535736e-01f, 1.35847792e-01f, -5.68300895e-02f, 1.01337440e-01f, -2.07643397e-03f, 3.83031331e-02f, -6.63252398e-02f, 8.69236290e-02f,
  2.30668094e-02f, 1.11339852e-01f, 9.81409252e-02f, 5.37413694e-02f, 3.81588377e-02f, -6.32250635e-03f, 7.83551559e-02f, 4.81826477e-02f, -9.08221863e-03f, -1.36702294e-02f,
  -4.38590981e-02f, -2.81439032e-02f, -3.19176391e-02f, -3.28289047e-02f, 2.14958545e-02f, -7.12679476e-02f, 3.55233066e-02f, -2.02962551e-02f, 5.77173103e-03f, -9.63019878e-02f,
  1.09410651e-01f, -6.87146094e-03f, -4.89245281e-02f, -2.74948813e-02f, 9.66064334e-02f, 9.28755701e-02f, 1.40628675e-02f, 3.78512293e-02f, -5.51477335e-02f, -4.04330976e-02f,
  2.21777886e-01f, 2.04182878e-01f, -4.05037329e-02f, -8.19852725e-02f, -4.60440591e-02f, 9.55473334e-02f, 1.08391270e-02f, -6.54259324e-02f, 1.39891252e-01f, 3.69390361e-02f,
  1.01379082e-02f, -3.20083797e-02f, -1.00609265e-01f, -2.57327221e-02f, 3.54701430e-02f, 4.12165001e-02f, -7.49853328e-02f, 1.71550959e-02f, 4.91079725e-02f, -3.31415944e-02f,
  -1.77620515e-01f, -5.28900251e-02f, -8.61430634e-03f, -5.83526259e-03f, 9.56249016e-04f, -9.98480693e-02f, -1.16331801e-02f, -4.12176251e-02f, -7.37679303e-02f, 1.09821938e-01f,
  -1.14654144e-02f, -3.85621816e-01f, -2.99241185e-01f, -3.40455510e-02f, 4.43346232e-01f, 2.97743648e-01f, 8.14245641e-02f, 3.11198980e-01f, -7.95895904e-02f, -2.11647656e-02f,
  2.00854033e-01f, -2.04977870e-01f, -3.19381058e-01f, 7.04109594e-02f, 1.45067707e-01f, -3.64192724e-01f, 8.61819908e-02f, -2.93713287e-02f, -1.31391481e-01f, 1.31567150e-01f,
  1.14596367e-01f, 3.55348468e-01f, -4.16578054e-02f, 2.80568242e-01f, 3.44083458e-02f, 5.84084690e-02f, 1.21597402e-01f, -1.58058167e-01f, 1.97533056e-01f, 6.19417280e-02f,
  6.81975633e-02f, -4.07104678e-02f, -6.60012364e-02f, -1.11488132e-02f, 9.17016491e-02f, -4.84610088e-02f, -1.06187649e-01f, -3.73773500e-02f, 6.78882673e-02f, -6.92017078e-02f,
  -3.18592675e-02f, -2.07417505e-03f, 2.23612059e-02f, -1.53601933e-02f, 1.58036798e-01f, 9.33314711e-02f, -1.77768413e-02f, -2.18650815e-03f, 1.20898604e-01f, -1.42210126e-01f,
  -9.17419791e-02f, 3.93780880e-03f, -7.19011128e-02f, -7.08190426e-02f, 1.84380338e-02f, 9.97366458e-02f, -1.83105972e-02f, 1.13384560e-01f, -1.12754658e-01f, 1.71498179e-01f,
  -1.54951122e-02f, -1.04461133e-01f, 2.19654068e-02f, -8.01306888e-02f, -6.34449199e-02f, 1.16883092e-01f, 1.99877955e-02f, 5.27599221e-03f, 3.86474770e-03f, 1.02530964e-01f,
  -1.30240927e-02f, 4.29827459e-02f, 7.55922943e-02f, -9.17977169e-02f, -6.54227063e-02f, 4.09291722e-02f, 2.49935612e-02f, -6.49219751e-02f, -6.80920258e-02f, 6.04030385e-04f,
  -1.35340407e-01f, 6.67971447e-02f, 8.66164714e-02f, -1.11927902e-02f, -1.02332206e-02f, -5.26626147e-02f, -1.07738469e-03f, -2.02383138e-02f, -9.22997445e-02f, -1.05737962e-01f,
  8.11663643e-03f, -2.04067379e-01f, 1.54555002e-02f, 6.05214313e-02f, -1.50038647e-02f, -4.69399570e-03f, 2.14976743e-02f, 2.00758576e-02f, -5.89955822e-02f, -4.66935337e-02f,
  1.53216943e-01f, -2.91163232e-02f, -1.16085701e-01f, 7.27959722e-02f, -4.38876860e-02f, 1.80652797e-01f, -7.49627352e-02f, 1.07398085e-01f, 2.05518126e-01f, 6.61366731e-02f,
  -4.56958003e-02f, -1.07443638e-01f, 2.59289704e-02f, 9.05523822e-02f, 1.33711705e-02f, -6.82062507e-02f, -2.35870834e-02f, 1.33117080e-01f, -2.17771102e-02f, 9.41097438e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.53074765e-01f, 2.19040930e-01f, 2.33848035e-01f, 2.84381241e-01f, 1.58826426e-01f, 2.69671291e-01f, 3.09000492e-01f, 2.80255556e-01f, 2.86318958e-01f, 3.47895235e-01f,
  2.33080059e-01f, 1.32978156e-01f, 2.46904075e-01f, 3.33741128e-01f, 2.44047239e-01f, 3.75568390e-01f, 1.50902063e-01f, 2.74363458e-01f, 3.37337583e-01f, 2.89720029e-01f,
  3.39881867e-01f, 2.05148712e-01f, 1.38239995e-01f, 2.59974569e-01f, 2.96369582e-01f, 2.38937557e-01f, 3.24310809e-01f, 2.87679106e-01f, 4.04502958e-01f, 2.11265981e-01f,
  2.59053677e-01f, 2.10997313e-01f, 2.64502585e-01f, 2.49543309e-01f, 2.95265257e-01f, 2.13209733e-01f, 3.00353438e-01f, 1.91829517e-01f, 3.03598136e-01f, 2.96687186e-01f,
  2.03269348e-01f, 1.97835207e-01f, 3.12916040e-01f, 3.09582829e-01f, 1.07030720e-01f, 3.16347897e-01f, 1.65530026e-01f, 2.11000204e-01f, 2.62700915e-01f, 3.41351628e-01f,
  1.76129714e-01f, 2.09855333e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.63011505e-02f, -3.22010629e-02f, 8.59699994e-02f, 3.70007530e-02f, -7.62158707e-02f, -2.43105013e-02f, 2.20428985e-02f, -1.05993427e-01f, -1.51926950e-01f, 1.36464760e-01f,
  1.49524987e-01f, 1.31210968e-01f, -1.25662297e-01f, 1.14132002e-01f, 1.10359192e-01f, -2.76874099e-02f, -8.48358572e-02f, 7.03811273e-02f, -2.16727793e-01f, -2.43314520e-01f,
  -9.97540355e-02f, 2.12600175e-02f, 5.72594143e-02f, -6.90693036e-02f, 1.47522494e-01f, 1.07563674e-01f, -6.39530942e-02f, -4.46619764e-02f, -3.55770551e-02f, -1.21001549e-01f,
  -2.32754722e-01f, 1.78887427e-01f, -9.93760079e-02f, -5.58177270e-02f, 4.98375930e-02f, 1.40303075e-01f, -6.44767582e-02f, -6.21587969e-02f, -1.59699902e-01f, -2.68636458e-02f,
  4.26172931e-03f, 7.95005485e-02f, 1.48403421e-01f, -2.31259674e-01f, -1.01262987e-01f, -1.21449552e-01f, 1.87306955e-01f, -1.02959841e-01f, 7.27679133e-02f, 8.43258649e-02f,
  1.73618510e-01f, 2.24893436e-01f, -1.14080599e-02f, 1.18032228e-02f, 1.61558792e-01f, 8.60241055e-02f, 4.91678454e-02f, 1.23083733e-01f, 2.07748249e-01f, -1.22403920e-01f,
  -1.34097651e-01f, 9.73351300e-02f, -2.01288804e-01f, 1.14781439e-01f, 1.20665878e-01f, -9.55640599e-02f, -6.64329231e-02f, 2.65162718e-02f, 1.51608676e-01f, 7.41170868e-02f,
  8.65287930e-02f, 6.86184019e-02f, 1.72701180e-01f, -1.32688597e-01f, -1.31691173e-01f, -2.53936052e-01f, 1.14212535e-01f, 2.12470237e-02f, -1.17752723e-01f, 2.27958068e-01f,
  -1.12519436e-01f, -1.32047176e-01f, 1.03811264e-01f, -1.51212998e-02f, -2.14636073e-01f, -2.90690572e-03f, 7.33267888e-03f, -1.98089316e-01f, -8.58847518e-03f, 3.66668100e-03f,
  1.83130175e-01f, -3.96278538e-02f, 1.11250475e-01f, 5.45311645e-02f, -3.63145322e-02f, 1.01842634e-01f, 9.39060599e-02f, -1.50190845e-01f, 7.36010000e-02f, 7.98535347e-02f,
  3.48405242e-02f, -7.11872056e-02f, -1.53944030e-01f, -6.23932928e-02f, -2.52581257e-02f, -2.48761568e-02f, -1.20766714e-01f, 4.35553677e-02f, 3.81496437e-02f, 1.64056137e-01f,
  -9.96612012e-03f, -2.35449970e-01f, -1.39225781e-01f, 9.16575491e-02f, 2.88607210e-01f, 2.92360969e-02f, 1.50488960e-02f, 9.40281600e-02f, -9.40990821e-02f, 1.45355329e-01f,
  2.21184075e-01f, 1.42977253e-01f, -5.90396710e-02f, -1.31697040e-02f, -9.91428271e-02f, -3.56440693e-02f, 4.34635114e-03f, -6.39400482e-02f, -8.36817846e-02f, 7.71799535e-02f,
  -1.53663710e-01f, 3.20873447e-02f, -6.12770393e-03f, 1.01306036e-01f, 1.64033920e-01f, 9.15407538e-02f, 1.60472795e-01f, -1.46682739e-01f, 5.98432943e-02f, -2.75250915e-02f,
  -6.37944639e-02f, -5.85298240e-02f, 8.29733834e-02f, 2.05933645e-01f, 2.45742518e-02f, -1.61950558e-03f, 2.64557954e-02f, -1.19802125e-01f, -1.44507170e-01f, -1.44869104e-01f,
  9.76577699e-02f, 1.17045492e-01f, 1.35506773e-02f, 1.13273494e-01f, 2.05022350e-01f, -2.63529330e-01f, 1.54687107e-01f, 1.63702965e-01f, -1.20382279e-01f, 2.26561114e-01f,
  -1.00947782e-01f, 3.03076386e-01f, 1.56614363e-01f, -1.17520265e-01f, 1.89349905e-01f, -1.16479680e-01f, -1.29033014e-01f, -5.32587543e-02f, -1.00062033e-02f, -1.72353853e-02f,
  6.65152594e-02f, -9.63666737e-02f, -1.33329764e-01f, 1.85095653e-01f, 4.55029495e-02f, -1.46008641e-01f, -4.96348590e-02f, -6.39768597e-03f, 8.55178013e-02f, 2.12752581e-01f,
  -1.59093291e-01f, -2.12486237e-01f, -1.01457678e-01f, 9.06585157e-02f, 1.63201228e-01f, 1.46395430e-01f, 1.31948262e-01f, -2.04977691e-01f, -1.52413413e-01f, -1.31608292e-01f,
  -9.16778389e-03f, 9.10062268e-02f, 7.86293298e-02f, 5.61171435e-02f, -5.31630851e-02f, -1.17603421e-01f, -1.35974035e-01f, 8.24446306e-02f, -7.93774128e-02f, -9.38694701e-02f,
  -1.74109891e-01f, -7.39050657e-03f, -2.35179484e-01f, -6.94298148e-02f, -8.41089860e-02f, -3.44403088e-02f, -1.77843556e-01f, -1.44763127e-01f, 1.96448803e-01f, -2.30484590e-01f,
  1.36954308e-01f, 3.93718146e-02f, 8.75209421e-02f, 1.03998549e-01f, -1.06072590e-01f, 2.00528532e-01f, -2.01435830e-03f, -1.85196608e-01f, 2.01745555e-01f, 1.54108241e-01f,
  -1.97562754e-01f, 1.97281331e-01f, -3.11458744e-02f, -1.86331764e-01f, 1.36232853e-01f, -1.26168013e-01f, 1.04722343e-01f, 9.46800038e-02f, -2.66334921e-01f, 1.68805853e-01f,
  -5.80421835e-02f, 1.65818736e-01f, -2.49704644e-02f, 5.73073104e-02f, -5.11032306e-02f, 2.50531673e-01f, -2.14916021e-02f, 2.25340482e-02f, -2.29673721e-02f, 1.11431412e-01f,
  8.74609873e-02f, -1.21944420e-01f, 2.11303368e-01f, -4.76874299e-02f, 1.43493250e-01f, 2.32037783e-01f, -3.73214670e-02f, -4.01848294e-02f, 1.65719524e-01f, -5.94843403e-02f,
  -8.97751302e-02f, 1.72954798e-01f, -1.04267448e-02f, 6.19480461e-02f, 1.06344126e-01f, -1.16404407e-01f, -3.23599279e-02f, 6.81783259e-02f, 3.57218049e-02f, 2.23065436e-01f,
  1.49558395e-01f, -8.36488977e-02f, 1.38983242e-02f, 1.05021313e-01f, -1.17094256e-01f, 1.18038552e-02f, -8.96698385e-02f, -2.82467417e-02f, 4.74155843e-02f, -1.45862275e-03f,
  -2.54163593e-02f, 2.47370568e-03f, 1.38558865e-01f, -1.07139595e-01f, 3.81355546e-02f, 7.86807984e-02f, 4.04924303e-02f, -1.00699224e-01f, 1.02858916e-01f, 1.37999713e-01f,
  -1.03958443e-01f, -9.71707702e-02f, 1.34357929e-01f, 4.41720113e-02f, 1.91114545e-01f, -6.80825114e-02f, 2.63392720e-02f, 6.68946933e-03f, 1.32650614e-01f, -1.28494650e-01f,
  -9.09125656e-02f, -7.20793530e-02f, 1.34635940e-01f, 1.90464243e-01f, -7.77333528e-02f, 2.11084321e-01f, 2.24100500e-01f, -9.18076187e-02f, -1.52274175e-02f, 1.57501370e-01f,
  9.55391228e-02f, 4.64024730e-02f, -2.38870531e-02f, -1.30680814e-01f, 1.08433135e-01f, -1.99146852e-01f, 7.74264857e-02f, -1.43243775e-01f, 1.58221219e-02f, 1.50152138e-02f,
  -1.36487231e-01f, 1.01574749e-01f, 1.28133997e-01f, -1.26306623e-01f, -1.16283529e-01f, -1.97744727e-01f, -1.43242851e-01f, -1.95032194e-01f, 1.87029198e-01f, -1.65231749e-01f,
  -3.12025081e-02f, 6.21382482e-02f, -5.74881323e-02f, 1.08154975e-01f, -9.99136567e-02f, -1.09554693e-01f, 2.11618379e-01f, 9.13507119e-02f, 1.09365486e-01f, 1.56456441e-01f,
  -2.00633839e-01f, -2.57828981e-01f, 5.78691177e-02f, 1.51807427e-01f, -1.99290708e-01f, 2.05154389e-01f, -3.67052970e-03f, -2.86658853e-02f, 1.63386822e-01f, 5.36326617e-02f,
  1.57254398e-01f, -3.29415835e-02f, -5.60851507e-02f, -1.63616776e-01f, -1.51568782e-02f, -3.84361595e-02f, -2.93058343e-02f, 2.25400195e-01f, -1.79037765e-01f, 1.45371661e-01f,
  1.04319602e-01f, -1.06097842e-02f, 1.93794906e-01f, -1.07123889e-01f, 8.45831558e-02f, -1.17501989e-01f, 5.84944226e-02f, 1.27356023e-01f, 1.13826729e-01f, -3.76054011e-02f,
  1.40532181e-01f, 1.93742245e-01f, -1.91901028e-01f, 5.01615927e-02f, 9.23317745e-02f, 7.69332647e-02f, -5.24141304e-02f, -2.42150128e-01f, -1.75985307e-01f, -3.05205658e-02f,
  1.10553816e-01f, -2.70798683e-01f, 2.48371497e-01f, 2.20676720e-01f, -4.30989973e-02f, -2.07018867e-01f, -1.21937782e-01f, -8.18220377e-02f, -3.70138697e-02f, -1.06865369e-01f,
  1.38864353e-01f, -9.23723727e-02f, 1.73148245e-01f, -8.48881155e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.39288053e-01f, 1.75016746e-01f, 6.62328899e-02f, 5.93999811e-02f, 1.62639931e-01f, 1.11296251e-01f, -1.94230050e-01f, -8.59584212e-02f, -3.59214425e-01f, 1.08485021e-01f,
  -4.03594375e-02f, 3.34523246e-02f, -1.89379960e-01f, 3.05952966e-01f, 3.73913385e-02f, -3.30384374e-01f, 1.84163645e-01f, -1.27773911e-01f, -1.24959536e-01f, -3.20845395e-02f,
  2.92907447e-01f, 2.94082277e-02f, -6.71980530e-02f, 1.77887946e-01f, -1.85255688e-02f, 2.55165786e-01f, 1.48004629e-02f, 1.68164328e-01f, -4.88547310e-02f, 6.63015097e-02f,
  -4.29823361e-02f, 2.64957756e-01f, 9.81255472e-02f, 2.94838697e-01f, 1.16048470e-01f, -2.00089917e-01f, -1.20180152e-01f, -2.42324218e-01f, 2.23185569e-01f, 2.95851856e-01f,
  1.85167104e-01f, -1.09236188e-01f, 3.66495907e-01f, -1.13507017e-01f, 1.32889688e-01f, 2.41493937e-02f, 2.34171063e-01f, 3.32814068e-01f, -1.19069286e-01f, 1.03100337e-01f,
  2.98304796e-01f, 9.84219238e-02f, 2.49971196e-01f, -4.42328565e-02f, 4.30563301e-01f, -2.57226467e-01f, 7.25250095e-02f, -3.19717973e-01f, 1.66079283e-01f, -1.35762632e-01f,
  -8.32771137e-02f, 1.01292446e-01f, 1.73035607e-01f, -5.11831790e-02f, 1.02195822e-01f, 1.99137237e-02f, 7.68332109e-02f, 2.94415802e-01f, 1.81097627e-01f, 5.17013744e-02f,
  3.29782754e-01f, 3.93143505e-01f, -1.04771413e-01f, -6.62401542e-02f, -7.63023039e-03f, -2.61558920e-01f, 1.24446094e-01f, 1.56184390e-01f, 1.60383940e-01f, 3.93104732e-01f,
  -4.28973556e-01f, 3.37912172e-01f, 1.64277151e-01f, -1.59751400e-02f, -6.95628226e-02f, -8.79389641e-04f, 5.46265133e-02f, -2.25313842e-01f, 7.88196772e-02f, 2.57881731e-01f,
  7.10986331e-02f, 9.87424105e-02f, -1.66461557e-01f, 1.90419406e-01f, -2.43615862e-02f, 6.43363148e-02f, 1.79036468e-01f, 3.42278361e-01f, -1.54621318e-01f, 2.61024714e-01f,
  -6.28407151e-02f, -1.44603074e-01f, 4.88158129e-02f, -2.13566795e-01f, -8.89346451e-02f, 1.29690498e-01f, 2.08088174e-01f, -1.64506108e-01f, -2.74926014e-02f, 1.41758710e-01f,
  2.42676176e-02f, -6.91174790e-02f, -1.55247957e-01f, -5.87448888e-02f, -2.19908338e-02f, -2.80438423e-01f, 2.53153622e-01f, 2.96148211e-01f, 1.20627820e-01f, 2.22641900e-02f,
  -7.34935179e-02f, 8.55329186e-02f, 3.04317832e-01f, -7.13569447e-02f, -8.00972506e-02f, 3.66464779e-02f, -5.37067279e-02f, 4.39533740e-01f, -7.47001097e-02f, 1.15334310e-01f,
  9.53165144e-02f, 9.17861462e-02f, 1.41167641e-01f, 8.90044868e-02f, -1.22913875e-01f, -1.16744854e-01f, -6.67693540e-02f, -6.63918257e-02f, -4.87848893e-02f, -8.78871083e-02f,
  -4.92883660e-02f, 8.37531835e-02f, 1.57485694e-01f, 5.85765690e-02f, 1.87503025e-02f, -2.11474970e-01f, 1.03748493e-01f, 1.93390518e-01f, -5.95922284e-02f, 9.89463031e-02f,
  -1.09540991e-01f, 8.44722539e-02f, -1.31917194e-01f, 4.02723029e-02f, 2.94828683e-01f, 2.89671123e-01f, -3.31169628e-02f, 3.06486636e-01f, 1.04390554e-01f, -1.84389755e-01f,
  4.16994214e-01f, -2.35667884e-01f, 2.35223144e-01f, 5.31620812e-03f, -4.86051738e-01f, 1.56189859e-01f, 2.65426785e-02f, 2.45161578e-01f, 3.17640811e-01f, -1.37408674e-01f,
  -2.10476473e-01f, 3.85137230e-01f, -2.10660189e-01f, -3.41992527e-01f, 3.14972073e-01f, 1.97782680e-01f, -1.03296585e-01f, 1.87507376e-01f, 4.37142998e-02f, -1.58200134e-02f,
  -2.35783849e-02f, 2.06189916e-01f, 1.10602915e-01f, -3.49199176e-02f, 1.54727325e-01f, 2.77763754e-01f, 1.04239874e-01f, 1.84144363e-01f, -3.15345861e-02f, 1.59907371e-01f,
  1.59745857e-01f, 1.31337687e-01f, 1.46684831e-03f, 1.07977860e-01f, 1.12908706e-01f, 1.04523696e-01f, 2.18877450e-01f, 1.79818466e-01f, 1.92154661e-01f, 4.47429493e-02f,
  -5.33174090e-02f, 1.22398682e-01f, 9.99654084e-03f, -3.18033695e-02f, 1.09663814e-01f, 4.52720821e-02f, 1.42872930e-01f, 1.32497057e-01f, 2.52843779e-02f, -2.54136212e-02f,
  1.21354185e-01f, -6.09750487e-03f, 9.54427049e-02f, 5.46610765e-02f, -1.41849905e-01f, 7.59699643e-02f, 1.56578094e-01f, -5.80895841e-02f, 3.22129160e-01f, -2.40082428e-01f,
  -1.22630268e-01f, 1.60471499e-01f, 8.41092765e-02f, 3.91887605e-01f, 1.90709934e-01f, 8.63348022e-02f, 2.72728801e-01f, -1.50455058e-01f, -1.05749346e-01f, -1.31668255e-01f,
  2.82335766e-02f, 9.80376750e-02f, 3.37262243e-01f, 2.28022382e-01f, 2.24060789e-01f, 2.24727780e-01f, -2.33661488e-01f, -1.97169095e-01f, 4.98956949e-01f, -5.37731759e-02f,
  -3.20304900e-01f, 3.20998952e-02f, 9.82801914e-02f, 1.94896117e-01f, -1.06666796e-01f, -1.33296877e-01f, 5.98439053e-02f, -1.42458394e-01f, 3.41330111e-01f, 1.14876859e-01f,
  2.99294144e-01f, -4.56097536e-02f, 1.01584624e-02f, -4.46659364e-02f, 4.59443554e-02f, 1.44895002e-01f, 7.35279843e-02f, 5.86429425e-03f, 6.21652044e-03f, 1.95096508e-01f,
  1.84963286e-01f, 1.00611053e-01f, -7.61589259e-02f, -1.85948461e-01f, 2.36112386e-01f, -8.65529254e-02f, -2.62508124e-01f, 4.59210351e-02f, 2.16961756e-01f, 1.55745104e-01f,
  -1.75934523e-01f, 6.90206289e-02f, 6.38810843e-02f, -2.38163739e-01f, 1.90046906e-01f, -8.96851569e-02f, -1.22253641e-01f, 2.11097509e-01f, -7.64772817e-02f, -4.29930091e-02f,
  -7.77088776e-02f, -1.78907931e-01f, 1.60331681e-01f, 5.01354411e-02f, -1.03149325e-01f, 1.65696323e-01f, -4.52246480e-02f, 1.44234061e-01f, 1.50884360e-01f, -3.28888685e-01f,
  3.09806943e-01f, -1.79758549e-01f, 6.83890358e-02f, 2.05839276e-01f, -3.31139892e-01f, 1.02995209e-01f, 2.77983636e-01f, -1.30108505e-01f, -1.84124127e-01f, 3.30976903e-01f,
  1.68197230e-02f, 2.01267824e-02f, 1.94917694e-01f, -1.26602303e-03f, 1.95709690e-01f, -1.63318634e-01f, 3.02510113e-01f, 1.76701009e-01f, 1.29971698e-01f, 2.22997114e-01f,
  1.18738182e-01f, 2.40346566e-01f, 2.56021917e-01f, -1.54744551e-01f, -1.14721656e-01f, 7.36997053e-02f, -1.53976958e-02f, -6.41609132e-02f, -1.87926833e-02f, -9.60933343e-02f,
  1.21717341e-01f, 1.35580838e-01f, 8.39793161e-02f, 9.85642672e-02f, 2.20124349e-01f, 1.01691782e-01f, -3.74489613e-02f, 4.19686809e-02f, 3.45466256e-01f, -1.37051389e-01f,
  6.81483597e-02f, -2.20797509e-01f, 2.53998786e-01f, -3.06699425e-01f, -2.45220542e-01f, 1.50687039e-01f, -6.30934685e-02f, 9.74067673e-02f, 1.85226411e-01f, 1.61432233e-02f,
  1.68172732e-01f, 2.85886079e-01f, 2.16451958e-01f, -1.55134484e-01f, 1.10914983e-01f, -1.45108491e-01f, -1.53553067e-02f, 2.53689826e-01f, 1.97195739e-01f, -1.52396441e-01f,
  7.11195245e-02f, -4.99673141e-03f, -1.90728456e-01f, -1.18215252e-02f, -1.03459194e-01f, 2.49439385e-02f, 4.33179140e-01f, 2.50315458e-01f, 6.84137791e-02f, 3.16163898e-02f,
  6.94288984e-02f, 2.38668069e-01f, -1.67071283e-01f, 1.86051592e-01f, 9.45669264e-02f, 3.97067368e-01f, -2.84793466e-01f, 7.13974088e-02f, 2.72165418e-01f, 2.58904725e-01f,
  -1.18239254e-01f, 2.29879513e-01f, 1.24283440e-01f, -3.03273052e-02f, -6.41971603e-02f, 1.45210415e-01f, -5.42432778e-02f, 9.11520198e-02f, 7.38440529e-02f, 1.07165113e-01f,
  1.37030914e-01f, 1.77309901e-01f, 2.55106062e-01f, -3.14515650e-01f, 1.71582520e-01f, 1.38395354e-02f, 1.95245259e-02f, 3.87753546e-03f, 2.98889820e-02f, 1.34103149e-01f,
  1.83804646e-01f, -2.58001626e-01f, -3.64384468e-04f, 2.96856731e-01f, -6.60722405e-02f, -8.16894323e-02f, 7.74114334e-04f, 5.59635349e-02f, -1.79644555e-01f, -1.88546181e-02f,
  5.47872521e-02f, -8.63896832e-02f, -9.39547922e-03f, -1.74635738e-01f, 3.15524101e-01f, 1.48202349e-02f, -6.41966611e-02f, 7.82312825e-02f, 2.08145723e-01f, -2.39760280e-01f,
  -5.49834669e-02f, 5.41964509e-02f, -2.98850715e-01f, -9.77176875e-02f, 6.13682112e-03f, 1.55945793e-01f, -7.47321174e-02f, 2.18749687e-01f, 9.26697776e-02f, 2.35557511e-01f,
  1.51964188e-01f, 3.77827138e-01f, 1.53501287e-01f, 1.72284976e-01f, 2.77048856e-01f, -2.04794798e-02f, -7.57483244e-02f, 3.03886324e-01f, -1.65376678e-01f, 1.34335712e-01f,
  1.93282917e-01f, -1.38482884e-01f, 1.31001472e-01f, -2.86511958e-01f, 2.47352019e-01f, -1.48356959e-01f, 2.40121037e-01f, 2.29763046e-01f, 1.55612290e-01f, -1.87261254e-01f,
  1.89184323e-01f, 1.16337582e-01f, -1.36032850e-01f, 2.81407446e-01f, 2.99986750e-01f, 1.09998733e-01f, 2.41035983e-01f, -2.06757307e-01f, 1.62231773e-01f, -8.08506012e-02f,
  -5.79595417e-02f, -6.85411021e-02f, 6.32446706e-02f, 5.60031794e-02f, 2.49842759e-02f, 1.44995907e-02f, -4.42658961e-02f, -1.81365877e-01f, 1.48195669e-01f, 1.30976796e-01f,
  -2.37784442e-03f, -2.34799832e-01f, -4.96129831e-03f, 1.34327754e-01f, -2.72077858e-01f, 6.01774873e-03f, 2.83468127e-01f, -1.78057671e-01f, 4.10689153e-02f, -1.72181532e-01f,
  8.79815742e-02f, -8.69034603e-03f, -6.12212494e-02f, 1.31938666e-01f, 3.64301622e-01f, -2.58013885e-02f, 4.96608429e-02f, 3.87080878e-01f, 1.40759230e-01f, -1.15634687e-01f,
  1.14284210e-01f, -8.01057741e-02f, 1.53002098e-01f, 1.62084773e-01f, -1.71653241e-01f, -3.74323223e-03f, -1.37315094e-01f, -1.99771434e-01f, -4.44474280e-01f, -5.03687654e-03f,
  4.76678424e-02f, 1.22837886e-01f, 1.64040864e-01f, -4.57511209e-02f, 1.24349445e-01f, -2.86942478e-02f, 1.48430347e-01f, 3.33179295e-01f, 2.50608891e-01f, 2.00428724e-01f,
  -8.67431909e-02f, 2.77208015e-02f, -7.36814514e-02f, 3.59466285e-01f, 1.53670209e-02f, 3.02040666e-01f, 1.96731627e-01f, 2.41433427e-01f, -1.20169448e-03f, 2.55881935e-01f,
  -3.44942451e-01f, 1.34292468e-01f, 8.92790034e-02f, 1.29078954e-01f, -1.55363586e-02f, 1.73858657e-01f, 1.72943532e-01f, 1.16414033e-01f, 3.44212592e-01f, 2.59271264e-01f,
  1.71006367e-01f, -1.65722650e-02f, 2.85944462e-01f, 1.87577680e-01f, 8.79034922e-02f, -1.07368603e-01f, 2.08029032e-01f, 2.34367073e-01f, -3.29145670e-01f, 2.74378091e-01f,
  2.36140415e-02f, 3.04801971e-01f, -9.81106088e-02f, -9.36364755e-02f, 1.01846069e-01f, -2.52375782e-01f, 4.42728139e-02f, 2.34415293e-01f, 1.14511520e-01f, -1.53372377e-01f,
  2.26004958e-01f, 1.93227962e-01f, 2.08934881e-02f, 3.23667824e-01f, 2.25875795e-01f, 4.51261908e-01f, -1.34588242e-01f, 1.05882797e-03f, 3.55041623e-01f, -1.52493089e-01f,
  2.00466186e-01f, -7.05548525e-02f, -1.39862955e-01f, 9.85301211e-02f, 3.84104043e-01f, -5.67521527e-02f, -8.42773467e-02f, 2.20134005e-01f, 1.19245067e-01f, -2.04295650e-01f,
  -2.76369721e-01f, 3.04397970e-01f, -3.56619775e-01f, 1.21804506e-01f, -2.44715005e-01f, -2.18649864e-01f, 1.20140709e-01f, 1.42841637e-01f, -1.95918605e-01f, 1.56317595e-02f,
  1.76507980e-01f, -9.78932083e-02f, -1.52553380e-01f, 2.29996275e-02f, -1.66664749e-01f, 3.06801766e-01f, 2.71425694e-01f, 3.95273902e-02f, 1.71227574e-01f, 1.13678217e-01f,
  1.28182757e-03f, -5.51570915e-02f, 4.07488383e-02f, 1.57145366e-01f, -2.82928795e-01f, 6.40736669e-02f, -2.33553246e-01f, -2.32940793e-01f, 2.38209575e-01f, 2.47670591e-01f,
  -1.55054927e-01f, 2.69552507e-02f, 3.28091383e-02f, 1.54541451e-02f, 3.93076628e-01f, 6.73819631e-02f, 4.57032435e-02f, 9.17822868e-02f, 1.31038308e-01f, -1.55776247e-01f,
  8.78571644e-02f, 5.70269227e-02f, 3.22321475e-01f, 2.03101337e-01f, 1.60101339e-01f, 3.44015658e-01f, 1.79148600e-01f, 6.84879348e-02f, 2.55767494e-01f, -3.88319850e-01f,
  6.82352856e-02f, 2.57789463e-01f, -1.47641525e-01f, 2.67689198e-01f, -1.32880077e-01f, 1.34344250e-01f, 3.12272310e-01f, 5.12788631e-02f, -2.88871545e-02f, 2.67219156e-01f,
  1.78484932e-01f, -1.06476724e-01f, 2.46217355e-01f, -1.41727388e-01f, 1.59725189e-01f, -1.66386038e-01f, 1.96910977e-01f, -1.60489425e-01f, 2.77945578e-01f, 3.58390182e-01f,
  8.74877200e-02f, -6.91664368e-02f, 2.24259034e-01f, -2.43507996e-02f, -1.10182390e-01f, 1.13692172e-01f, -1.73722263e-02f, 2.66156476e-02f, 4.62252125e-02f, -6.48566037e-02f,
  2.04350755e-01f, 2.04890653e-01f, 4.95643318e-02f, 1.63114548e-01f, 3.69792208e-02f, 4.51458693e-02f, 1.87035769e-01f, 8.93811584e-02f, -7.83471763e-02f, 1.49749145e-01f,
  -9.48549062e-02f, -1.19258434e-01f, 6.75045978e-03f, 3.75204831e-01f, -1.14000499e-01f, 9.04049873e-02f, 1.57627851e-01f, -2.82197576e-02f, -7.06708580e-02f, 1.87054679e-01f,
  1.60371974e-01f, 2.20189810e-01f, 3.97038832e-02f, 1.26021817e-01f, 1.40062019e-01f, 6.94786161e-02f, -2.89951235e-01f, 3.00991148e-01f, -3.37405852e-03f, -1.53732598e-01f,
  -6.24902658e-02f, 1.96476147e-01f, -2.52298582e-02f, 3.18302482e-01f, -5.87102026e-02f, 1.82028953e-02f, 1.53858438e-01f, 1.59107745e-01f, 3.02845091e-01f, 1.69124141e-01f,
  3.10222954e-01f, 1.17576383e-01f, 3.12408060e-01f, -3.87088470e-02f, 1.46376938e-01f, 8.14058408e-02f, 6.07977286e-02f, 8.21784288e-02f, 2.04174947e-02f, -1.89794376e-01f,
  2.07871512e-01f, -3.46785188e-01f, 3.61068934e-01f, 2.57188946e-01f, 3.82503361e-01f, -3.80153239e-01f, 5.34959920e-02f, -6.93297386e-02f, -1.30028471e-01f, -3.71738058e-03f,
  1.77880421e-01f, -4.06631418e-02f, 2.81639665e-01f, -1.01156808e-01f, -3.42714298e-03f, -1.11443801e-02f, 7.46526271e-02f, 4.85624298e-02f, -2.20474638e-02f, 1.72437951e-01f,
  1.17525503e-01f, 1.82651326e-01f, -1.33500183e-02f, 1.89103968e-02f, -3.18885356e-01f, -1.77224979e-01f, 1.80958167e-01f, 2.52684522e-02f, -1.81691051e-01f, 1.10329213e-02f,
  -1.36720240e-01f, -4.58544493e-02f, 3.25081021e-01f, -2.97329035e-02f, 2.22620159e-01f, 1.45453960e-01f, -1.30428851e-01f, 3.30530614e-01f, 3.34460586e-02f, -1.54214546e-01f,
  2.82529235e-01f, 3.54824096e-01f, -2.26007447e-01f, 2.56579161e-01f, 6.38932809e-02f, -1.94252163e-01f, 2.17001736e-01f, -8.38465116e-04f, 2.22651914e-01f, 9.76406187e-02f,
  -2.12134928e-01f, 3.00003678e-01f, 1.46423325e-01f, -7.50785023e-02f, -2.27654781e-02f, 2.45821446e-01f, 1.26403915e-02f, 3.20181072e-01f, -6.25154702e-03f, -4.19398677e-03f,
  7.11157545e-02f, -4.11701538e-02f, 1.85426436e-02f, 2.29635835e-02f, 3.76326330e-02f, -2.91271418e-01f, 4.28651124e-01f, 2.49431282e-01f, 2.49123201e-01f, 6.75604045e-02f,
  -1.91999137e-01f, 1.41912373e-02f, -2.26786509e-01f, 3.47461820e-01f, 2.02997297e-01f, 1.37664601e-01f, 2.31305853e-01f, -8.17835033e-02f, 1.86731502e-01f, 1.06421150e-01f,
  2.04459637e-01f, 1.84135184e-01f, 1.15276963e-01f, 1.61854997e-01f, -1.10565625e-01f, -2.03994840e-01f, -2.19527081e-01f, 7.09846690e-02f, -2.46040344e-01f, 1.48349583e-01f,
  -9.78768840e-02f, 1.65795088e-01f, 1.08792201e-01f, -2.20632032e-01f, 1.23019576e-01f, -1.16921738e-01f, 1.70336679e-01f, -1.62973389e-01f, 5.81750646e-02f, 2.42570922e-01f,
  -9.00635943e-02f, 8.33829492e-02f, 1.31333694e-01f, -1.31892234e-01f, 9.01243240e-02f, 1.62134886e-01f, -1.87340513e-01f, -9.90775079e-02f, 3.35101224e-02f, -4.69620563e-02f,
  3.45113054e-02f, -2.77034473e-02f, 7.65546691e-03f, 1.38688579e-01f, -5.03388308e-02f, 2.99667358e-01f, -3.54261743e-03f, 2.41611406e-01f, 2.21948609e-01f, 1.46097708e-02f,
  1.78611815e-01f, 3.13473970e-01f, 1.40223265e-01f, -5.56573831e-02f, 9.39435586e-02f, -3.10886353e-02f, 3.11279804e-01f, -1.30553037e-01f, 8.64049494e-02f, -2.46595830e-01f,
  2.55691856e-01f, 2.23577991e-01f, 3.39702219e-01f, 1.27180070e-02f, 6.46188706e-02f, -4.24566306e-02f, -2.29864985e-01f, 9.62789580e-02f, -6.58732653e-03f, 1.18831508e-01f,
  1.86457440e-01f, -2.24941038e-02f, 1.27894148e-01f, 2.25524217e-01f, 1.00265890e-01f, 3.23374718e-02f, 7.06698895e-02f, 2.47142911e-01f, 1.47905052e-01f, -9.63983461e-02f,
  -2.64227507e-03f, 1.07506797e-01f, 1.12165466e-01f, -2.83296928e-02f, 9.30548459e-02f, -1.38644993e-01f, 1.17422894e-01f, 7.29342178e-03f, 6.30436987e-02f, 8.32740813e-02f,
  -1.33213773e-01f, -2.44369194e-01f, 3.99841294e-02f, 1.55042112e-01f, -1.67831317e-01f, 1.51369423e-01f, 1.30062640e-01f, -2.57368058e-01f, 8.43075216e-02f, 2.62651350e-02f,
  -3.38528275e-01f, -1.99501067e-01f, -8.96761790e-02f, 2.96260953e-01f, -1.77602023e-01f, 1.37078971e-01f, 1.93107694e-01f, -4.75442559e-02f, 2.53577560e-01f, 3.53280127e-01f,
  -3.59368399e-02f, 3.69338728e-02f, 1.31365418e-01f, 2.03590170e-01f, 2.16259956e-01f, 1.79785743e-01f, -4.42387998e-01f, 2.96410978e-01f, 3.61566037e-01f, 9.34351608e-02f,
  2.57780045e-01f, -1.46641135e-01f, 9.89985764e-02f, 1.80734470e-01f, 1.14733435e-01f, -6.13046251e-03f, 2.14964494e-01f, -1.87972561e-01f, -2.49493849e-02f, 1.61682099e-01f,
  -6.10356443e-02f, 5.27283698e-02f, 2.26025477e-01f, 1.40146017e-01f, 2.02581853e-01f, 6.10775910e-02f, 1.44184353e-02f, 1.60648733e-01f, -1.62489396e-02f, 2.26291195e-01f,
  8.05179868e-03f, 9.17163193e-02f, 1.09266914e-01f, 4.54888213e-03f, -2.40957797e-01f, 1.43050820e-01f, 2.08362877e-01f, 1.31136477e-01f, 3.26165743e-02f, -1.51958361e-01f,
  3.64157826e-01f, 1.61597936e-03f, -1.86303392e-01f, 1.06122583e-01f, 6.25111088e-02f, 9.73221660e-03f, 7.61025026e-02f, -1.04793243e-01f, -3.56895715e-01f, 3.82009707e-02f,
  -9.40800458e-02f, 1.66996926e-01f, -2.76598632e-02f, -6.99298680e-02f, -1.95534751e-01f, 5.18241711e-02f, 5.09243906e-02f, 7.04032229e-03f, 2.71899790e-01f, 1.97582379e-01f,
  -1.83101203e-02f, 1.29284248e-01f, -2.92254657e-01f, 1.83332518e-01f, 1.63592726e-01f, -6.76555634e-02f, -7.15820640e-02f, 7.21536651e-02f, 2.80704260e-01f, 1.45783320e-01f,
  -3.17936093e-01f, -3.21608156e-01f, 9.33909342e-02f, -1.13405935e-01f, 2.02844784e-01f, 9.88825038e-02f, -4.29714434e-02f, -1.75951451e-01f, -1.07070819e-01f, -5.98292165e-02f,
  9.16707367e-02f, 2.92433530e-01f, -2.21707180e-01f, 2.22142369e-01f, 1.81492776e-01f, 2.69870371e-01f, 1.86539128e-01f, 3.24238449e-01f, -2.21915111e-01f, 2.50671774e-01f,
  -2.52103191e-02f, -2.57444642e-02f, 7.67191127e-02f, 2.17752293e-01f, 1.20657012e-01f, 3.66205536e-02f, -1.35494187e-01f, -1.00044742e-01f, -1.18304856e-01f, -1.28046662e-01f,
  -1.06890537e-01f, 2.34997600e-01f, 1.97027966e-01f, 3.79243851e-01f, 1.03186138e-01f, 2.02881992e-01f, 2.12451443e-01f, -2.83701019e-03f, 1.06943905e-01f, 2.91797996e-01f,
  -1.34317502e-01f, -1.83520734e-01f, 3.39907348e-01f, -4.09313515e-02f, -5.20922616e-03f, 2.08266154e-01f, 2.16308042e-01f, -5.30706458e-02f, 3.28510106e-01f, 3.78458470e-01f,
  9.13695395e-02f, -8.43751281e-02f, 2.90345907e-01f, -2.13640243e-01f, 8.62147138e-02f, 1.35222346e-01f, 6.95465952e-02f, -1.53334364e-01f, 8.08329438e-04f, 2.12780178e-01f,
  -1.29141202e-02f, -1.96651325e-01f, 2.42804494e-02f, -3.46051641e-02f, 3.72719795e-01f, -2.33759552e-01f, 2.09337533e-01f, -2.23566949e-01f, -6.83734715e-02f, 8.37086812e-02f,
  5.41081578e-02f, -2.35278774e-02f, 2.01819018e-02f, 7.13304430e-02f, 5.39113861e-03f, 1.90075397e-01f, 3.34664851e-01f, 6.73841089e-02f, -6.09377436e-02f, -1.11155391e-01f,
  -1.56853467e-01f, -4.15629558e-02f, -1.97791114e-01f, 6.28032759e-02f, -6.22761995e-02f, 1.95495293e-01f, 1.01386495e-01f, -2.15528626e-03f, 1.96885258e-01f, -6.48366213e-02f,
  -3.85209560e-01f, -2.40519598e-01f, -9.47744921e-02f, 2.22213063e-02f, 2.15878025e-01f, 3.44950199e-01f, -1.42002121e-01f, 8.51156786e-02f, 3.37380677e-01f, 9.53877196e-02f,
  1.98815972e-01f, 2.29579404e-01f, -2.05894168e-02f, 1.50188640e-01f, 2.42162004e-01f, -1.69419106e-02f, 1.41242921e-01f, 3.01032156e-01f, -2.53762364e-01f, 3.14584643e-01f,
  -1.67092204e-01f, 1.14171077e-02f, 2.68708706e-01f, -2.65209883e-01f, 9.62629244e-02f, -2.11645905e-02f, 1.34109169e-01f, 2.79967129e-01f, -6.37426674e-02f, -1.36504784e-01f,
  1.95305645e-01f, -3.07500005e-01f, 3.27703118e-01f, 3.86440486e-01f, 2.34166265e-01f, -1.47929162e-01f, -1.05989330e-01f, -3.16801995e-01f, 1.50047854e-01f, 6.44654781e-02f,
  8.09960067e-02f, 1.88974410e-01f, 7.90426061e-02f, 2.31116951e-01f, 3.68170924e-02f, 1.62838086e-01f, -1.59544796e-01f, -4.68381822e-01f, 1.20691679e-01f, 1.90479159e-01f,
  2.41138965e-01f, -1.16447564e-02f, 7.30970874e-02f, -9.91736278e-02f, 7.16098994e-02f, 7.35255405e-02f, 4.41036299e-02f, 9.44908559e-02f, 1.38596818e-01f, -9.35377926e-03f,
  4.27884012e-02f, 2.19961718e-01f, 1.13049448e-01f, -9.30173844e-02f, -1.94575205e-01f, -3.05901542e-02f, -1.67152390e-01f, -1.18595831e-01f, -2.81618595e-01f, -4.15243628e-03f,
  8.82756412e-02f, 3.02166164e-01f, -4.03598212e-02f, 2.48309702e-01f, 2.80962557e-01f, -1.85786471e-01f, 2.85937101e-01f, 2.14417070e-01f, -8.03211778e-02f, 7.68765882e-02f,
  -2.05966905e-01f, 1.70724317e-02f, 1.33298188e-01f, -4.78637926e-02f, 1.44435048e-01f, 5.93271889e-02f, 3.65463160e-02f, 2.72518575e-01f, 2.02269524e-01f, -9.27771479e-02f,
  3.45316380e-01f, -4.01356250e-01f, 2.33171493e-01f, 7.20379725e-02f, -3.23863983e-01f, 4.60646302e-02f, -1.09701052e-01f, 2.49418467e-01f, 3.78298342e-01f, -1.06509008e-01f,
  -2.25599200e-01f, 2.84954637e-01f, -9.42009781e-03f, -2.84310222e-01f, 2.87624598e-01f, 1.90801192e-02f, -1.22774608e-01f, 3.71354558e-02f, 1.15353063e-01f, -7.64181688e-02f,
  6.77987840e-03f, 3.48585397e-01f, 1.13011025e-01f, 7.60852778e-03f, 3.04152340e-01f, -5.28277503e-03f, -5.01554832e-02f, 1.46248579e-01f, -1.53495908e-01f, -7.78768212e-02f,
  1.56355575e-01f, 8.11926648e-02f, 5.96942939e-02f, 6.79836934e-03f, 1.27678707e-01f, 1.42561913e-01f, 2.24848121e-01f, 6.40675426e-02f, -5.42053506e-02f, 3.52663882e-02f,
  3.46055686e-01f, -4.41127829e-03f, -1.33682787e-01f, -2.44188592e-01f, 1.94144711e-01f, -2.99658448e-01f, -1.51821211e-01f, 2.95651168e-01f, 8.77179801e-02f, 1.52734146e-01f,
  8.21258575e-02f, 2.08498150e-01f, 1.72224760e-01f, 2.76151985e-01f, -4.96565849e-02f, 1.34875417e-01f, -9.10071880e-02f, -1.96617335e-01f, 1.79543450e-01f, 2.42111236e-01f,
  2.00999249e-02f, 4.16965410e-02f, 2.38416538e-01f, -1.96139310e-02f, 8.76111239e-02f, 3.14423501e-01f, 7.11735785e-02f, 1.49513572e-01f, 2.19585568e-01f, 2.32851356e-01f,
  1.70807824e-01f, 1.47939071e-01f, 1.49434492e-01f, 8.03989097e-02f, -2.94021010e-01f, 2.96803802e-01f, -6.31459430e-02f, 3.84487987e-01f, -6.43979311e-02f, -5.37496582e-02f,
  -1.12714015e-01f, 5.00982627e-02f, -1.78449571e-01f, -3.03881764e-01f, -2.99777836e-02f, 6.57549053e-02f, -1.73386857e-01f, 1.78266503e-02f, -1.69810802e-01f, 1.93085238e-01f,
  -2.76618544e-02f, 1.29156157e-01f, 2.51171440e-01f, -2.18662903e-01f, 3.26256096e-01f, 3.13382931e-02f, 9.92465317e-02f, 8.72344598e-02f, 1.62305191e-01f, 2.33687073e-01f,
  2.08217815e-01f, 8.43502730e-02f, -7.70120770e-02f, -2.92288780e-01f, -1.52674362e-01f, -1.14397101e-01f, 2.42087170e-01f, 2.90867686e-01f, 6.73186481e-02f, 2.66770065e-01f,
  -1.77709479e-02f, -2.80135423e-01f, 2.42895141e-01f, -1.51537165e-01f, 1.86222315e-01f, 6.33439273e-02f, -1.23862676e-01f, -7.57379457e-02f, 1.21622950e-01f, 1.95502061e-02f,
  -1.39884744e-02f, 1.75804764e-01f, -3.85617428e-02f, -2.72131026e-01f, 3.93477917e-01f, 7.86398724e-02f, 1.82339281e-01f, 2.38521844e-01f, -3.05406861e-02f, -1.93016022e-01f,
  2.42154509e-01f, -3.49787474e-01f, -3.50444182e-03f, -2.76956081e-01f, 5.73010370e-02f, 1.91275552e-01f, 2.14634299e-01f, -9.23952237e-02f, 2.11710304e-01f, -1.51305780e-01f,
  -7.28919078e-03f, -1.47407874e-01f, 3.69945943e-01f, 3.18508685e-01f, -1.82396136e-02f, 3.46861571e-01f, 1.28137646e-02f, 3.79338145e-01f, -3.02889049e-01f, -1.88037694e-01f,
  1.32104620e-01f, 1.09462388e-01f, 3.32414299e-01f, -2.30682075e-01f, 1.55831143e-01f, -1.27612025e-01f, -1.93904549e-01f, 2.15113267e-01f, -3.05226296e-01f, 4.12463434e-02f,
  -5.08239903e-02f, 1.26492783e-01f, 7.94579983e-02f, 1.06142662e-01f, 3.49412784e-02f, 9.68484581e-02f, -3.22062582e-01f, -3.06365043e-01f, 8.91846642e-02f, -1.72329526e-02f,
  -2.78537907e-02f, 1.12896457e-01f, -6.96927011e-02f, -1.57117769e-02f, 3.25265378e-02f, -1.74915884e-02f, 1.95370167e-01f, -1.79552421e-01f, -1.02221996e-01f, 2.82264762e-02f,
  1.05654083e-01f, 3.25467020e-01f, -1.03428215e-01f, 2.94673711e-01f, 5.09331841e-03f, -1.52173504e-01f, -1.37681291e-01f, 1.71211362e-01f, -1.49173886e-01f, -2.92638987e-01f,
  3.35573286e-01f, -2.30582058e-01f, 2.45436698e-01f, 1.58559799e-01f, 1.35910019e-01f, -8.72657076e-02f, 1.42813951e-01f, 2.10977942e-01f, 2.98305303e-01f, 2.94979185e-01f,
  2.06767887e-01f, -2.28418618e-01f, -1.38872921e-01f, 2.71457247e-02f, -2.07652356e-02f, 2.28500292e-01f, 1.50153160e-01f, 2.57708758e-01f, 2.17405856e-01f, 1.38524741e-01f,
  -1.33500760e-02f, 1.77670494e-01f, -1.38580156e-02f, -6.03441447e-02f, 4.72365133e-02f, 5.40796630e-02f, 3.98802757e-02f, -7.15017766e-02f, -4.53877337e-02f, -5.95105365e-02f,
  1.46945894e-01f, 6.28532693e-02f, 3.17519069e-01f, -2.56731510e-01f, -8.08506534e-02f, 1.52092092e-02f, -6.89605922e-02f, 7.15269819e-02f, 1.14190757e-01f, -1.01577848e-01f,
  1.16315838e-02f, -1.39881879e-01f, -2.50659753e-02f, 2.29856566e-01f, 1.86701640e-01f, -3.45239528e-02f, -1.05199322e-01f, 7.46508390e-02f, 3.03074658e-01f, 4.77866642e-02f,
  1.94212109e-01f, 3.46622705e-01f, 2.69976240e-02f, 3.65575731e-01f, 2.73101449e-01f, -7.97824711e-02f, -2.23243296e-01f, 3.87760252e-02f, 1.81715876e-01f, 2.27309242e-01f,
  -3.84039670e-01f, 3.64157259e-02f, 2.82495772e-03f, -1.79005042e-01f, 1.49531797e-01f, 7.25037307e-02f, 2.54255742e-01f, 1.40978917e-01f, 1.86899398e-02f, 3.63927484e-01f,
  -9.48679261e-03f, 3.59900184e-02f, 4.28714126e-01f, 3.24008346e-01f, 8.92438591e-02f, 1.47686332e-01f, -2.58567959e-01f, 9.68906730e-02f, -1.58226356e-01f, 6.74564317e-02f,
  -2.30499282e-01f, 3.51583678e-03f, 9.95780155e-02f, 1.51351929e-01f, -1.73994645e-01f, -1.91507995e-01f, -1.02972053e-01f, -6.23716153e-02f, -1.12639986e-01f, -6.10954016e-02f,
  -7.72454813e-02f, 2.60414124e-01f, 3.13760579e-01f, 2.67680168e-01f, 2.43412793e-01f, 1.93851531e-01f, 7.48842508e-02f, 3.11319143e-01f, 1.63494140e-01f, 6.34660199e-02f,
  1.28726289e-01f, 4.55599129e-02f, -3.11623141e-02f, 7.14730620e-02f, -1.22983441e-01f, -3.05398405e-01f, -1.70358688e-01f, -3.35859582e-02f, -1.89583585e-01f, 5.99674135e-02f,
  -2.45061085e-01f, 3.34193945e-01f, 1.81984380e-01f, -2.74919748e-01f, 3.25435936e-01f, -1.43591404e-01f, 9.41829849e-03f, -7.34552518e-02f, 1.00156456e-01f, 5.00919111e-02f,
  1.76922992e-01f, 2.98738182e-01f, 2.39455197e-02f, 1.18209183e-01f, 2.08860114e-02f, -1.07441545e-01f, 1.84324756e-01f, 9.87488031e-02f, -1.55087829e-01f, -6.09462336e-03f,
  8.33333060e-02f, -1.23055510e-01f, 2.05498680e-01f, 2.21389800e-01f, -1.90646946e-01f, 6.37553334e-02f, 7.36175999e-02f, 1.04417667e-01f, -1.27148414e-02f, -2.02757418e-01f,
  1.03640802e-01f, 1.72308445e-01f, 2.29388550e-01f, -1.37792230e-01f, 2.07682997e-01f, 1.70370772e-01f, 3.73868585e-01f, 1.43125892e-01f, 3.46214354e-01f, 1.90737829e-01f,
  5.64070717e-02f, -1.70021076e-02f, 7.44411200e-02f, 1.91882566e-01f, 3.01880896e-01f, 2.43844137e-01f, 1.14556015e-01f, 2.10275412e-01f, 2.29870737e-01f, 3.68077815e-01f,
  -2.00204879e-01f, -1.80303827e-01f, 1.57634124e-01f, 9.70229805e-02f, 2.04961628e-01f, 5.66130467e-02f, 2.24076271e-01f, 8.78385305e-02f, -1.80941805e-01f, -1.95934787e-01f,
  2.45323092e-01f, -2.29404837e-01f, 1.69156060e-01f, 1.48840517e-01f, 4.73285131e-02f, -2.23023906e-01f, -2.18240052e-01f, -1.18214767e-02f, 3.00857157e-01f, -1.84484243e-01f,
  1.94765806e-01f, 1.49053961e-01f, 1.75928697e-02f, 1.56680956e-01f, 2.86982924e-01f, 1.21170752e-01f, -3.34619880e-02f, 4.81198262e-03f, 2.86951959e-01f, 6.18355386e-02f,
  9.36282799e-02f, 1.82624981e-01f, 1.50795966e-01f, -1.31100476e-01f, -6.41110465e-02f, -9.43643972e-02f, 2.63136894e-01f, -1.18362874e-01f, 2.19797745e-01f, -1.86252117e-01f,
  -7.05557615e-02f, 1.90170184e-01f, -1.19150594e-01f, -1.76509321e-01f, -4.81008701e-02f, 1.22501597e-01f, 1.23915151e-01f, 2.75459558e-01f, 1.92595854e-01f, 3.03285718e-01f,
  2.01000631e-01f, 2.92058080e-01f, 2.33379126e-01f, 3.65858257e-01f, -1.93741366e-01f, -1.67646095e-01f, -1.40193775e-01f, 3.11772615e-01f, 1.20333657e-01f, -2.39298180e-01f,
  -1.14190653e-02f, 1.85628608e-01f, -1.82800163e-02f, 1.24069780e-01f, 4.42824923e-02f, -3.23265880e-01f, 2.10284621e-01f, 1.02467701e-01f, 2.60512978e-01f, 1.27946913e-01f,
  1.19622961e-01f, 1.38912022e-01f, -2.51946986e-01f, -1.06523745e-01f, -1.85574710e-01f, -2.49446124e-01f, -8.18413496e-02f, 2.94474751e-01f, 1.17808305e-01f, 2.52025306e-01f,
  1.98695928e-01f, -6.57122657e-02f, 3.47449258e-02f, 3.86226387e-03f, 2.48313025e-01f, 2.16429025e-01f, -1.01722673e-01f, -7.34806657e-02f, 2.89230615e-01f, -5.31161539e-02f,
  -1.28046006e-01f, 2.80609965e-01f, -5.53879850e-02f, 2.16816306e-01f, 3.02466959e-01f, 2.00856075e-01f, 1.31023005e-01f, -2.48001575e-01f, 2.18165785e-01f, -2.07395896e-01f,
  -8.25459436e-02f, 3.06320369e-01f, 1.59814134e-02f, 1.60325170e-02f, -8.64625797e-02f, 5.55183403e-02f, -4.23170626e-02f, -1.32376596e-01f, 2.73063481e-02f, -7.27288201e-02f,
  4.25246805e-01f, -2.50769168e-01f, -2.84795791e-01f, 2.22383484e-01f, 3.22938293e-01f, 9.55947042e-02f, 7.42928609e-02f, 2.15680942e-01f, 2.90691406e-01f, 1.99159414e-01f,
  1.70816466e-01f, 1.27165347e-01f, 3.09321244e-04f, 2.12614775e-01f, 2.80806720e-02f, 1.72361434e-01f, -1.25579864e-01f, 3.44659597e-01f, -1.66833341e-01f, -4.67946790e-02f,
  2.73074843e-02f, 8.22458342e-02f, 1.59074605e-01f, 1.87908277e-01f, 1.66329533e-01f, 6.61889613e-02f, 2.84413069e-01f, 2.13879034e-01f, 2.93440312e-01f, -2.63232857e-01f,
  4.37165685e-02f, -5.74207082e-02f, 2.03219727e-01f, -3.03892404e-01f, 1.51531786e-01f, 2.08142385e-01f, -2.27655470e-01f, 1.48326516e-01f, 8.58996212e-02f, 2.10818350e-01f,
  -1.94523886e-01f, 2.25010857e-01f, 8.29161778e-02f, -3.20006609e-01f, -2.33235620e-02f, -3.66507471e-02f, 2.08203956e-01f, 1.96898594e-01f, 3.21296841e-01f, 2.22995684e-01f,
  3.29385586e-02f, -1.15915202e-01f, 1.22352965e-01f, 7.63295442e-02f, -5.30436300e-02f, 2.89967686e-01f, 2.70949543e-01f, 2.78505564e-01f, -5.98577894e-02f, -4.21804413e-02f,
  8.53059664e-02f, 1.82613522e-01f, -2.46039391e-01f, 8.76720846e-02f, 8.50649700e-02f, 2.85797387e-01f, -2.13383749e-01f, -9.24619958e-02f, 1.56060070e-01f, 1.25400737e-01f,
  -3.29363346e-01f, 1.98068202e-01f, -5.68622909e-02f, 2.13022023e-01f, -2.71601617e-01f, 3.29852164e-01f, -1.86425492e-01f, 2.91829228e-01f, 4.67481464e-02f, -1.20226890e-01f,
  9.43092182e-02f, 6.84214681e-02f, -4.24508117e-02f, 1.88236997e-01f, 2.07408801e-01f, 9.25514773e-02f, 8.51909593e-02f, 2.23961249e-02f, 1.89948261e-01f, 3.01699400e-01f,
  1.15790814e-01f, 2.67690271e-01f, 2.59117573e-01f, -2.14565009e-01f, 1.64478958e-01f, 2.93809623e-02f, 1.59724131e-01f, -5.37340343e-02f, -2.32676324e-02f, 2.90569842e-01f,
  -2.25161165e-01f, -4.55049910e-02f, 1.08924121e-01f, -6.02222681e-02f, -2.43223861e-01f, -3.67424972e-02f, 1.65733695e-01f, -1.41471729e-01f, -1.29398052e-03f, 1.56625465e-01f,
  2.47743860e-01f, 9.19780508e-02f, 6.30191863e-02f, 2.14965284e-01f, 6.15955032e-02f, 1.94606334e-01f, -8.17380100e-02f, 2.18357056e-01f, 1.00087330e-01f, -6.73383102e-02f,
  3.70227218e-01f, -7.53817260e-02f, -7.73500791e-03f, -2.93537378e-01f, -2.22169906e-01f, 2.15362981e-02f, 3.10588449e-01f, 6.50262758e-02f, 8.35736170e-02f, 3.60316247e-01f,
  3.18409204e-02f, 1.16679512e-01f, 1.15654573e-01f, 3.28143626e-01f, 1.14002928e-01f, 3.08206588e-01f, 7.18632266e-02f, 2.50203144e-02f, -1.72691643e-01f, 3.46233040e-01f,
  3.33342664e-02f, 1.44000784e-01f, 1.34526640e-01f, -6.06075786e-02f, -1.52325034e-01f, -1.23485336e-02f, -2.80740321e-01f, 1.72841012e-01f, 6.40554428e-02f, 1.05411150e-01f,
  7.74113461e-02f, -6.86858827e-03f, 7.18777254e-02f, 5.27462400e-02f, 1.53436065e-01f, 1.75032899e-01f, 1.95057943e-01f, 2.23795697e-01f, 2.11990759e-01f, -1.76592276e-01f,
  9.37393680e-02f, -1.93960607e-01f, 1.39472052e-01f, 1.60974309e-01f, 9.09433365e-02f, 2.02328473e-01f, -1.86620250e-01f, 1.49283130e-02f, 2.97460526e-01f, 2.09287971e-01f,
  -2.82812119e-01f, 1.66278437e-01f, 6.42689839e-02f, -7.11337011e-03f, -1.90106690e-01f, 1.04286529e-01f, -6.00851253e-02f, -2.20521942e-01f, -1.25024840e-01f, 1.51728019e-01f,
  -2.10438475e-01f, 3.56990933e-01f, 2.76371054e-02f, 1.76051125e-01f, 2.63389230e-01f, 1.44219294e-01f, 3.73977870e-01f, 6.56436086e-02f, -1.04704835e-01f, 4.09051441e-02f,
  1.89363077e-01f, 8.08160380e-02f, -2.16426432e-01f, 2.78605372e-01f, -1.05087146e-01f, 6.58434927e-02f, 1.83813438e-01f, -1.01700267e-02f, -9.35702100e-02f, -1.90176234e-01f,
  5.19212224e-02f, -1.33785933e-01f, 1.71678305e-01f, -1.43790757e-02f, -2.73710042e-01f, 2.09937081e-01f, 2.04202950e-01f, 8.62850025e-02f, 3.07656199e-01f, 6.73291087e-02f,
  1.89788207e-01f, 2.56776035e-01f, 5.65903634e-02f, 2.67530352e-01f, 1.59611166e-01f, 4.04705554e-02f, 1.34032249e-01f, 1.49596810e-01f, 1.09517530e-01f, -1.00888588e-01f,
  -1.70924112e-01f, 4.56084609e-02f, 2.42740110e-01f, 3.24113488e-01f, 2.07545057e-01f, 3.55199799e-02f, 5.46372421e-02f, 1.67524442e-02f, -1.08694740e-01f, -6.73502460e-02f,
  1.38598695e-01f, -5.45731187e-02f, -1.38176933e-01f, -1.57149732e-01f, 6.04385659e-02f, 4.09630239e-02f, -2.17886250e-02f, 2.77869314e-01f, 4.50526357e-01f, -1.58984795e-01f,
  2.08561271e-01f, 2.80111194e-01f, -1.29927263e-01f, 2.11394876e-01f, 8.58873948e-02f, 1.69515967e-01f, -3.02186422e-02f, -1.40512556e-01f, 1.19699322e-01f, -1.35651343e-02f,
  2.31340844e-02f, -2.68208906e-02f, -2.88583916e-02f, 1.99614968e-02f, 3.85071129e-01f, 8.97508636e-02f, -9.32473019e-02f, 3.17888483e-02f, 3.12098116e-01f, -2.17162415e-01f,
  -5.98491728e-03f, -2.86504403e-02f, -7.25822970e-02f, 2.29377925e-01f, 3.60872187e-02f, -1.79007873e-01f, 4.34148401e-01f, 4.75928962e-01f, -1.14903236e-02f, 5.45726344e-02f,
  -3.02412271e-01f, -7.80535117e-02f, -2.49585673e-01f, -4.82642604e-03f, -3.70276749e-01f, 2.19271556e-01f, 6.08706586e-02f, 1.85434103e-01f, 5.28270416e-02f, 7.27344826e-02f,
  2.72334993e-01f, 1.79115229e-03f, -2.48875216e-01f, -3.02668452e-01f, -9.47893411e-03f, 2.62338847e-01f, -9.63945836e-02f, 5.71671352e-02f, -1.04955286e-01f, 1.25362024e-01f,
  2.82361060e-02f, 5.55597283e-02f, 2.87261009e-01f, 8.51839781e-02f, -5.43271489e-02f, 2.59354681e-01f, 1.68303639e-01f, 2.35002160e-01f, -1.69233948e-01f, 3.17376614e-01f,
  -1.06897749e-01f, -9.82109830e-02f, -2.90057123e-01f, 1.55079842e-01f, -9.82452109e-02f, -3.20973784e-01f, 1.60399586e-01f, 1.67707324e-01f, 1.38390690e-01f, 2.73696303e-01f,
  3.87861617e-02f, -1.92828834e-01f, 3.03849995e-01f, 3.79126929e-02f, 3.68739694e-01f, 3.63031834e-01f, 3.58080119e-01f, -1.81952436e-02f, -3.32632624e-02f, 2.00864330e-01f,
  3.76282297e-02f, 1.87665910e-01f, 2.49316007e-01f, 8.16939250e-02f, -4.99882139e-02f, -2.58735538e-01f, -5.58755510e-02f, -3.13769281e-01f, -3.04597486e-02f, -6.52241856e-02f,
  3.08904737e-01f, -1.21824399e-01f, 1.79304153e-01f, -2.58107692e-01f, -9.31255296e-02f, -1.24860197e-01f, 2.95684010e-01f, -1.84112594e-01f, 4.05425549e-01f, 5.31443097e-02f,
  1.85763970e-01f, 3.65668274e-02f, -3.92070673e-02f, 1.83125779e-01f, 1.86684966e-01f, 7.74939219e-03f, 1.63237020e-01f, -1.00668319e-01f, 5.67397624e-02f, 3.18401694e-01f,
  -6.46343902e-02f, -8.27053487e-02f, -1.12626895e-01f, 1.58564955e-01f, -1.66994244e-01f, 1.04599498e-01f, 2.40563214e-01f, 1.60847846e-02f, -2.76513696e-02f, -4.84467484e-02f,
  2.37085164e-01f, 1.28822207e-01f, -4.18468937e-02f, 1.52651563e-01f, 1.76963478e-01f, -2.69759238e-01f, 1.22478455e-02f, -5.01290783e-02f, -1.60675421e-01f, -1.79538727e-01f,
  -1.94062710e-01f, 2.97040313e-01f, -2.51232266e-01f, 2.66745627e-01f, 7.03476444e-02f, 3.34019549e-02f, 2.00814411e-01f, 1.72474504e-01f, 2.95633167e-01f, 2.57089376e-01f,
  1.83783025e-01f, 1.39229536e-01f, 2.19018117e-01f, 2.07455963e-01f, -1.91169813e-01f, 3.34586561e-01f, 1.61176741e-01f, -6.18863627e-02f, 1.23171769e-01f, -3.81814301e-01f,
  2.87836671e-01f, -4.55729291e-02f, 1.98500991e-01f, 8.78417194e-02f, 2.74000943e-01f, -2.80701548e-01f, 2.26935700e-01f, 2.74010133e-02f, -2.33067110e-01f, 6.71785325e-02f,
  2.10698858e-01f, -2.01143503e-01f, 2.41173178e-01f, -1.06984302e-01f, 1.89136155e-02f, 1.19254738e-01f, -2.05149539e-02f, 2.32201606e-01f, 3.65366451e-02f, -2.41476987e-02f,
  2.91721523e-01f, 3.06661934e-01f, -7.73597732e-02f, 9.24842060e-02f, 2.63519771e-02f, -4.36657250e-01f, 1.02180041e-01f, 3.64625782e-01f, 6.35057921e-03f, 2.38580987e-01f,
  1.29447095e-02f, 2.03757599e-01f, 2.21192837e-01f, 3.95082682e-01f, -2.60886241e-04f, -3.59246023e-02f, -2.91922055e-02f, -2.33751312e-01f, 1.35974526e-01f, 1.82959080e-01f,
  -2.79096097e-01f, 8.14503357e-02f, 5.29617444e-02f, 1.84651390e-01f, 8.17416906e-02f, 5.41015640e-02f, 2.83185959e-01f, 7.27213547e-02f, -2.45520398e-02f, 8.12726468e-02f,
  -1.33576768e-03f, 1.07290216e-01f, 2.25914940e-01f, 7.48580396e-02f, 2.51665175e-01f, 1.47215351e-01f, -1.66185014e-02f, -1.42493740e-01f, 2.08362848e-01f, 1.05711348e-01f,
  -1.03144929e-01f, -2.22578481e-01f, -1.34197369e-01f, 4.11555842e-02f, -8.74406025e-02f, -3.09746623e-01f, 1.19014315e-01f, 7.09954277e-02f, -8.76133889e-02f, -2.96099991e-01f,
  1.56917330e-02f, 1.62503228e-01f, 2.90414184e-01f, -6.12382926e-02f, -2.41026673e-02f, -9.27995816e-02f, 5.43146692e-02f, 2.26846129e-01f, -1.29771829e-02f, 1.17630668e-01f,
  -2.00880505e-03f, 2.26593822e-01f, 1.60623640e-02f, 2.05389395e-01f, 1.02436692e-01f, 5.47041446e-02f, 3.58265817e-01f, 5.90742677e-02f, 2.57241875e-01f, -6.68897554e-02f,
  2.10797921e-01f, -1.40067339e-01f, 2.02195361e-01f, 3.81217360e-01f, -5.60921058e-02f, 2.73562014e-01f, -1.54540226e-01f, 1.02476209e-01f, -5.91150708e-02f, 3.54245156e-01f,
  -5.35287410e-02f, 1.82688117e-01f, 1.64496154e-01f, 8.38027075e-02f, 7.85503015e-02f, 5.58997281e-02f, -1.60602033e-01f, -3.28717083e-02f, 1.66221097e-01f, 2.08086558e-02f,
  -9.47039723e-02f, 3.08869779e-01f, 2.37057671e-01f, 6.75729364e-02f, 4.13333178e-01f, 2.11120974e-02f, 4.74452339e-02f, -5.79599813e-02f, 2.02209391e-02f, 9.17330757e-02f,
  1.34483308e-01f, 6.27158955e-02f, -2.79630601e-01f, 3.69938970e-01f, 1.50963277e-01f, 2.93571472e-01f, 1.27196088e-02f, 1.89383611e-01f, -2.56534014e-02f, 1.42722562e-01f,
  -1.16397053e-01f, -4.28220034e-02f, -1.04008712e-01f, 3.97955105e-02f, -1.79033056e-01f, 9.91895422e-02f, 3.71879101e-01f, 3.45967570e-03f, -7.69949052e-03f, -1.94254369e-01f,
  2.18594089e-01f, 2.56953597e-01f, -1.37245273e-02f, 1.85759678e-01f, 7.93162286e-02f, 1.75180927e-01f, 5.23096956e-02f, 1.78145140e-01f, 3.00884187e-01f, 2.91900486e-01f,
  6.69976845e-02f, -6.02359464e-03f, 1.93776548e-01f, 5.73008470e-02f, 1.09329782e-01f, 1.05791293e-01f, 1.29966930e-01f, 2.33477890e-01f, -1.78871661e-01f, 2.07951084e-01f,
  2.74828404e-01f, 3.21209989e-02f, -1.36663958e-01f, -1.39983483e-02f, -2.69884411e-02f, -2.68740151e-02f, -7.84047991e-02f, 1.91341206e-01f, 2.51018584e-01f, -1.62471995e-01f,
  -4.85284664e-02f, 4.00433153e-01f, -5.99180385e-02f, 2.07617909e-01f, 2.34598488e-01f, 1.99045718e-01f, -1.77007299e-02f, 6.60491288e-02f, 1.64280340e-01f, -9.70897526e-02f,
  -6.76142871e-02f, -2.05146015e-01f, -1.35123760e-01f, -1.09172285e-01f, 3.47342372e-01f, 7.39945620e-02f, 7.96696264e-03f, -4.79274094e-02f, 3.24274242e-01f, -2.93606550e-01f,
  -2.44595781e-01f, -3.09473425e-02f, -9.90955681e-02f, 6.98213950e-02f, -7.26876482e-02f, -4.04429287e-02f, 1.17442884e-01f, 2.32923388e-01f, -1.19485989e-01f, 1.50020570e-01f,
  -1.49825990e-01f, -2.02526107e-01f, -2.48227447e-01f, -1.95445754e-02f, -3.25902492e-01f, 4.42499936e-01f, 1.22668043e-01f, 9.25914422e-02f, 8.21883008e-02f, -1.37865040e-02f,
  9.14013460e-02f, 8.18184763e-02f, -2.27416515e-01f, -1.43759072e-01f, -1.67255506e-01f, -2.46466950e-01f, 8.54136795e-02f, 3.01818192e-01f, -7.69693553e-02f, -6.62554707e-03f,
  3.56038839e-01f, -5.52033037e-02f, 1.16477586e-01f, 1.44721448e-01f, 3.16747040e-01f, 5.83444461e-02f, 5.88528104e-02f, 1.56543225e-01f, 3.01310010e-02f, -1.17871845e-02f,
  8.18330124e-02f, 1.84280634e-01f, 2.47632131e-01f, -3.18073519e-02f, 5.87384775e-02f, 2.24991068e-01f, 2.71357566e-01f, -1.58816203e-01f, 3.66468608e-01f, -2.05816969e-01f,
  1.66465446e-01f, 1.63552016e-01f, -2.67477870e-01f, 6.61407551e-03f, -9.57281142e-02f, -4.65455174e-04f, 5.95463887e-02f, -2.55709514e-02f, -1.92196056e-01f, 2.12306425e-01f,
  4.76308689e-02f, -2.87172645e-01f, 7.16937110e-02f, 3.06741059e-01f, 1.40542954e-01f, 9.62939635e-02f, 4.97262850e-02f, 3.54634166e-01f, -1.57533288e-01f, -5.05199982e-03f,
  -1.24903247e-01f, 4.05344993e-01f, 1.47154421e-01f, 2.56233126e-01f, 1.36090845e-01f, 2.89027005e-01f, 2.59870533e-02f, 4.74608898e-01f, -5.92571162e-02f, 2.45737031e-01f,
  5.45132086e-02f, 2.11699665e-01f, 2.15289697e-01f, 1.14894867e-01f, 1.23747207e-01f, 2.67157316e-01f, -1.42895758e-01f, 1.46429807e-01f, 4.76774201e-02f, -2.81082451e-01f,
  2.44560823e-01f, 1.55919164e-01f, 1.59409761e-01f, -3.88580300e-02f, 3.23232770e-01f, 1.34163380e-01f, 1.13313459e-01f, 6.67907149e-02f, 2.13988930e-01f, 1.86097339e-01f,
  -1.57563359e-01f, 1.43504784e-01f, 2.18230858e-01f, 9.83306617e-02f, -3.77746746e-02f, 2.19955891e-01f, 1.96348131e-01f, 2.32106701e-01f, 3.33561972e-02f, 2.28744105e-01f,
  2.50948071e-01f, -1.33693948e-01f, 2.96861827e-01f, 1.93586916e-01f, -2.51233429e-01f, -6.97345212e-02f, 6.31948654e-03f, -1.50959983e-01f, -3.68951671e-02f, 7.58930370e-02f,
  2.47025434e-02f, -1.20561153e-01f, 2.02146947e-01f, 1.01748556e-01f, 8.45377445e-02f, 3.67073668e-03f, 1.75882906e-01f, 1.00537874e-01f, -2.53921431e-02f, 1.89542472e-01f,
  -3.51794034e-01f, 8.37607682e-02f, 1.96070988e-02f, 9.48998034e-02f, -4.14132178e-02f, 1.21938415e-01f, -2.28536114e-01f, 1.66192316e-02f, 3.52715738e-02f, -1.12359658e-01f,
  -1.14591308e-01f, 1.45585507e-01f, -1.80685185e-02f, 3.14646333e-01f, 4.24081199e-02f, 1.60233319e-01f, 2.70121515e-01f, 9.75931510e-02f, 9.27073658e-02f, 1.91309690e-01f,
  -3.80512476e-02f, 1.84524745e-01f, 2.47821853e-01f, -2.62725025e-01f, -1.92165360e-01f, -5.38917705e-02f, 1.47802249e-01f, -1.75549202e-02f, 2.28162304e-01f, 2.10359424e-01f,
  1.40195396e-02f, -3.64318192e-02f, 1.99960634e-01f, 7.89496899e-02f, -1.11181416e-01f, 2.42896184e-01f, 2.72124529e-01f, -8.58024061e-02f, -1.46328166e-01f, 2.82447308e-01f,
  2.46821776e-01f, 2.27721661e-01f, 2.03812700e-02f, 2.35597461e-01f, 2.70206183e-01f, -4.22640681e-01f, 3.31330627e-01f, -5.58249690e-02f, 1.85395554e-02f, 1.03442408e-01f,
  -6.44726306e-02f, 1.20272972e-01f, -3.08782429e-01f, -2.30987087e-01f, -1.58829868e-01f, -8.48493725e-02f, 5.49588166e-02f, 1.21910565e-01f, 3.30959767e-01f, 7.98248574e-02f,
  2.28158068e-02f, 2.43314490e-01f, 2.26018444e-01f, 2.97069311e-01f, 2.17797324e-01f, 1.49785206e-01f, 3.16519469e-01f, 3.55619848e-01f, -6.70590922e-02f, 2.78954625e-01f,
  -1.16570350e-02f, 2.67393887e-01f, 6.16640449e-02f, -4.97560389e-02f, -2.75074214e-01f, 1.00875504e-01f, -8.01506042e-02f, 7.27375895e-02f, 1.20298117e-01f, 1.48917571e-01f,
  1.19381147e-02f, 1.86388984e-01f, 1.64816231e-02f, 1.47520795e-01f, 2.44921833e-01f, 7.71620199e-02f, -2.10546941e-01f, 1.53445825e-01f, 1.02109678e-01f, -1.16284102e-01f,
  -1.14185832e-01f, 2.55870819e-01f, -4.70053917e-03f, -1.45411268e-01f, -1.72122732e-01f, -5.38149737e-02f, 1.06319100e-01f, -1.80874258e-01f, 4.10184227e-02f, -4.27824520e-02f,
  -5.95682114e-02f, 4.37391363e-02f, 1.80709153e-01f, 2.39216443e-02f, -1.71366520e-02f, -4.00553755e-02f, -1.80777535e-01f, 2.11457789e-01f, -3.96589339e-01f, 3.61255616e-01f,
  -2.27782249e-01f, 9.25557241e-02f, 2.35087469e-01f, -1.23657547e-01f, -5.95252588e-02f, 9.92519408e-02f, 6.92840433e-03f, -5.21228872e-02f, 4.01839539e-02f, -1.00477608e-02f,
  2.81709880e-01f, -1.02460697e-01f, -3.66431996e-02f, -1.73585981e-01f, 2.05706000e-01f, 5.00142798e-02f, -1.54250814e-02f, 1.69994816e-01f, 3.90012175e-01f, 1.95534810e-01f,
  2.71654487e-01f, 1.99620575e-01f, 8.27822611e-02f, -2.50053585e-01f, 2.88468152e-01f, 9.48118269e-02f, 2.68735468e-01f, -5.77001795e-02f, 1.70474537e-02f, 6.48608133e-02f,
  -2.81015784e-01f, 3.13627496e-02f, 1.35539040e-01f, 1.23303071e-01f, 1.34187266e-01f, 2.08752692e-01f, 1.54873282e-01f, 1.77280024e-01f, 1.06587969e-01f, 2.82293171e-01f,
  2.24519074e-01f, -1.54739797e-01f, -3.13041806e-01f, -5.98952249e-02f, 2.44043723e-01f, 3.14024575e-02f, -3.62087041e-01f, 1.68712184e-01f, -2.38045260e-01f, -3.05461049e-01f,
  3.53100717e-01f, -2.59118417e-04f, -1.90442964e-01f, 3.08061808e-01f, 1.92099378e-01f, -9.38036293e-02f, -8.57163817e-02f, 8.39470774e-02f, 4.16536510e-01f, 1.04368366e-01f,
  5.21263443e-02f, 3.23032230e-01f, 1.63599521e-01f, -1.75371200e-01f, 1.01362869e-01f, -3.68109584e-01f, -7.07968175e-02f, -1.09714143e-01f, 1.08838277e-02f, 2.00665578e-01f,
  -3.73928905e-01f, -1.43885642e-01f, -5.94100635e-03f, 1.13845877e-01f, -3.09970323e-02f, 1.82691574e-01f, 2.66146570e-01f, 1.67108402e-01f, -1.07418448e-01f, -1.89137142e-02f,
  5.46850339e-02f, -4.03021835e-02f, 1.10147968e-01f, 5.12450412e-02f, 3.02377284e-01f, 3.66193563e-01f, 9.42221959e-04f, 2.10480556e-01f, -8.51536244e-02f, 2.98979748e-02f,
  -1.98292241e-01f, 4.59900200e-02f, -1.05067022e-01f, 1.04264997e-01f, 1.73291732e-02f, -1.04346283e-01f, 2.94339303e-02f, 1.74875125e-01f, 4.27587181e-02f, 1.39729410e-01f,
  1.26871392e-01f, 3.46982889e-02f, -1.49704844e-01f, -4.48397212e-02f, -9.30965766e-02f, -2.11334273e-01f, 1.47572011e-01f, -3.03310025e-02f, 3.18283476e-02f, 1.00842200e-01f,
  1.12124771e-01f, -5.71423993e-02f, -6.08131438e-02f, 1.28010854e-01f, 3.35474789e-01f, 3.34181517e-01f, 1.83906034e-01f, -2.26630971e-01f, 2.07163870e-01f, 1.72137320e-02f,
  1.47332892e-01f, -8.55437666e-02f, 2.10923422e-02f, 1.01675101e-01f, 4.04721439e-01f, 2.18668416e-01f, 2.48200119e-01f, 3.70901749e-02f, 1.74947500e-01f, -3.40464234e-01f,
  6.70509413e-02f, 1.06061183e-01f, -2.17919841e-01f, -2.53997110e-02f, 2.53307391e-02f, 1.18244633e-01f, -1.29457220e-01f, 2.14176536e-01f, -1.43058077e-01f, 4.54599261e-02f,
  1.54833615e-01f, -1.12359777e-01f, -4.50439565e-02f, 2.15296969e-01f, -1.00145554e-02f, 4.41560894e-01f, -1.17133558e-01f, 1.40195116e-01f, -4.23640236e-02f, -6.13806397e-02f,
  -1.71638712e-01f, 2.90440142e-01f, 1.44768357e-01f, 6.78046374e-03f, 8.75832662e-02f, 6.02328405e-02f, 1.45690292e-01f, 2.23433748e-01f, -2.22268194e-01f, -1.05221644e-01f,
  2.25675121e-01f, 9.09848437e-02f, -5.62839173e-02f, 1.40963376e-01f, 1.33825183e-01f, -4.42038402e-02f, 2.71416456e-01f, 1.47586465e-01f, -1.14799738e-01f, 1.70035720e-01f,
  1.52357072e-01f, -1.56616732e-01f, 1.53120190e-01f, 2.87526935e-01f, 2.69682527e-01f, 1.42879114e-01f, -1.47973508e-01f, 3.54606152e-01f, 1.80967152e-01f, 1.99139833e-01f,
  8.00639465e-02f, -6.54724240e-02f, 1.55534133e-01f, -3.60437810e-01f, 1.73148021e-01f, 4.58139554e-02f, -9.99232531e-02f, 1.53153883e-02f, 1.86542809e-01f, 3.70743945e-02f,
  5.89312129e-02f, 6.42600432e-02f, -1.27045631e-01f, -4.56841886e-02f, -1.25732750e-01f, 2.57263720e-01f, 6.57042414e-02f, 1.13744907e-01f, 2.19522417e-01f, -8.68919566e-02f,
  -3.39830257e-02f, -1.22049470e-02f, 8.29848647e-02f, -2.83342414e-02f, 1.44408524e-01f, 9.31857303e-02f, -3.59796613e-01f, -9.25528854e-02f, 1.22121193e-01f, 7.03850463e-02f,
  -1.25592723e-01f, -2.56763343e-02f, 1.89631611e-01f, 9.47499201e-02f, -1.62305743e-01f, 1.83000147e-01f, 1.04849786e-01f, 2.88184404e-01f, 2.17143506e-01f, 1.56386141e-02f,
  2.14522019e-01f, 9.86752957e-02f, -9.46854725e-02f, 6.05242550e-02f, -4.77847084e-02f, -6.23709988e-03f, 1.00253001e-01f, 1.54277414e-01f, 2.60712169e-02f, 6.93368763e-02f,
  -1.91032737e-01f, -3.51292863e-02f, 1.20410167e-01f, 5.05924858e-02f, 5.98616675e-02f, 1.41608581e-01f, 7.16314018e-02f, -1.03902474e-01f, 1.39332796e-02f, -8.47081691e-02f,
  3.02509785e-01f, 1.58988759e-01f, -5.47721870e-02f, 2.70533890e-01f, 1.73431695e-01f, -1.03156723e-01f, 8.69570971e-02f, 2.53369182e-01f, -2.13820964e-01f, 7.28411674e-02f,
  -1.54523507e-01f, 3.08546219e-02f, 2.87616432e-01f, 3.47260535e-02f, 1.92993298e-01f, -1.73881978e-01f, 1.44172683e-01f, 1.96574658e-01f, 7.90150613e-02f, -1.27930669e-02f,
  2.84709096e-01f, -1.44391090e-01f, 3.54951203e-01f, 2.99849659e-01f, -9.30753276e-02f, -1.76761821e-01f, -1.36050910e-01f, -2.39093285e-02f, 2.25101337e-01f, 1.71173155e-01f,
  7.27919023e-03f, 1.29149929e-01f, 1.95977110e-02f, 2.79265672e-01f, -2.07810953e-01f, -3.45484018e-02f, -9.07597691e-02f, -2.91988790e-01f, -5.85008375e-02f, 1.94921255e-01f,
  1.06564343e-01f, -2.17507511e-01f, -7.00214952e-02f, -1.41227037e-01f, 2.69477427e-01f, -7.82309920e-02f, 2.15678021e-01f, 8.52389261e-02f, 1.16500065e-01f, 1.16851106e-01f,
  1.01625293e-01f, 8.43180120e-02f, 1.40370518e-01f, 2.27946103e-01f, 1.39622077e-01f, 3.16758007e-01f, 3.10990334e-01f, -2.28898157e-03f, 9.03061181e-02f, -2.76119292e-01f,
  1.38392419e-01f, -2.52685726e-01f, -1.31157145e-01f, 3.47916812e-01f, -1.61041588e-01f, 1.80706650e-01f, -2.25175289e-03f, 2.17386559e-01f, 9.40682143e-02f, 2.58791506e-01f,
  -1.13552421e-01f, -2.75012404e-02f, -1.09458588e-01f, -1.56545117e-01f, 2.46133849e-01f, 1.11142792e-01f, -7.14070946e-02f, 2.31371596e-01f, 2.29678050e-01f, 1.02575026e-01f,
  4.23762575e-02f, 1.80132180e-01f, -1.16223462e-01f, 2.13847205e-01f, 1.84360772e-01f, 1.55432150e-01f, 1.35219902e-01f, 1.52662069e-05f, -8.03250596e-02f, 5.09574637e-02f,
  1.07761696e-02f, 3.60337496e-01f, -1.38206214e-01f, 2.47536972e-01f, 1.40659884e-01f, -1.16599783e-01f, -1.01220876e-01f, 9.63455215e-02f, -8.98982733e-02f, -5.91610521e-02f,
  -2.00060263e-01f, -3.49833630e-02f, -1.54502317e-01f, 1.47185549e-01f, -2.19480664e-01f, 2.97043443e-01f, 9.15675759e-02f, 1.75310045e-01f, 1.98326811e-01f, -9.86446291e-02f,
  2.63987392e-01f, 3.04080009e-01f, 1.59233175e-02f, 8.71655494e-02f, 3.39024425e-01f, 1.56170964e-01f, 1.74464211e-01f, 1.03771240e-01f, -3.97664279e-01f, -3.02870989e-01f,
  -3.80554534e-02f, -9.31704324e-03f, -1.18388973e-01f, 7.15367869e-02f, -5.32394201e-02f, -4.01352495e-02f, -1.23039514e-01f, -1.55116647e-01f, 3.95750701e-01f, -2.87483543e-01f,
  1.84363313e-02f, 1.96434855e-01f, 1.44624203e-01f, 2.33383849e-01f, 1.75278515e-01f, 3.89180452e-01f, -1.40402243e-01f, -1.77449780e-03f, -6.60622790e-02f, 5.36412112e-02f,
  9.68948230e-02f, -2.40058944e-01f, 3.46557528e-01f, -2.32798029e-02f, 5.93180358e-02f, -1.04128309e-01f, 6.86620027e-02f, -2.05743819e-01f, 4.16551232e-02f, 2.71218531e-02f,
  1.06369285e-02f, 3.27924311e-01f, 2.69788414e-01f, -2.44085342e-01f, -1.10957436e-01f, 1.78210095e-01f, 1.06802963e-01f, 1.44287154e-01f, 1.88326463e-01f, 3.58964652e-01f,
  3.43663067e-01f, 1.34385258e-01f, 1.82282671e-01f, 3.67530912e-01f, -1.18140213e-01f, -3.20383348e-02f, 3.44403200e-02f, -6.06680587e-02f, 2.19374239e-01f, -2.70867139e-01f,
  1.67078778e-01f, 4.57036607e-02f, -8.09380668e-04f, 1.15457468e-01f, 2.74613738e-01f, -3.78552079e-01f, 1.14298940e-01f, 2.11448908e-01f, 2.34925106e-01f, 1.17278755e-01f,
  2.20419779e-01f, 1.07624181e-01f, -3.15908015e-01f, -1.72763586e-01f, -7.02238008e-02f, -1.66380465e-01f, -9.29823518e-02f, 2.04474092e-01f, 1.63698401e-02f, 1.34509996e-01f,
  -1.05947025e-01f, -8.63279700e-02f, 2.02823743e-01f, 7.49869347e-02f, 2.58885086e-01f, 3.47220421e-01f, 6.99699521e-02f, 8.82719606e-02f, 3.24092686e-01f, -4.92963009e-02f,
  -2.14380786e-01f, 1.79242983e-01f, -1.08423069e-01f, 3.18491608e-01f, 1.91417739e-01f, -6.95823804e-02f, 3.51620406e-01f, -3.26752603e-01f, 2.63099521e-01f, -3.33766699e-01f,
  -2.58679807e-01f, -2.44147703e-01f, 4.85973395e-02f, 2.02958081e-02f, 1.86878275e-02f, 1.50913551e-01f, 7.95599148e-02f, -1.60769597e-01f, -1.77396238e-01f, 9.82223824e-02f,
  1.64874434e-01f, 7.24992305e-02f, -1.34840637e-01f, 1.83017746e-01f, 1.79549798e-01f, 1.66327834e-01f, -3.51822048e-01f, 1.03358448e-01f, 1.22499848e-02f, 1.09927617e-01f,
  5.97269796e-02f, 1.25670433e-01f, -1.16658159e-01f, -3.32516789e-01f, -4.33626473e-02f, -1.45238698e-01f, -1.46327317e-02f, 1.72105357e-01f, 1.70294926e-01f, -1.92726567e-01f,
  6.72424659e-02f, 2.00382732e-02f, 2.00444534e-01f, 6.88584149e-02f, 3.75593752e-02f, 3.23789418e-01f, 9.79549512e-02f, 3.31257790e-01f, 2.19638020e-01f, -1.61695868e-01f,
  -3.58392783e-02f, -7.19798505e-02f, 2.51650125e-01f, 5.43514453e-03f, -3.33433628e-01f, -2.72837169e-02f, -1.09651387e-01f, -7.67486095e-02f, 3.23850274e-01f, -2.38917351e-01f,
  -7.77491704e-02f, 2.83200175e-01f, 9.21384916e-02f, 1.05686963e-01f, 1.37079313e-01f, 5.15082926e-02f, 2.98600197e-01f, 1.69726431e-01f, -2.50557512e-01f, 2.86716968e-01f,
  2.41053831e-02f, -1.89494371e-01f, -1.37585193e-01f, -1.23996869e-01f, 6.41455036e-03f, -7.71998167e-02f, 1.75918024e-02f, 2.00378999e-01f, -2.41468415e-01f, -1.71197608e-01f,
  -1.98481798e-01f, 7.55318627e-02f, 1.77749023e-01f, 2.81414211e-01f, 7.41949007e-02f, 1.91224620e-01f, -1.17265172e-01f, 3.46219152e-01f, 6.56358749e-02f, 1.84681386e-01f,
  2.86100775e-01f, 2.57595867e-01f, 3.11701924e-01f, 3.40219378e-01f, 4.82958555e-02f, 1.17168620e-01f, -1.07163370e-01f, -1.45410553e-01f, 8.23977515e-02f, 2.03680277e-01f,
  -2.00039774e-01f, 9.74453688e-02f, -2.13968605e-02f, -1.14460982e-01f, 2.58035094e-01f, 2.32549936e-01f, 4.54666875e-02f, 2.46223465e-01f, 1.27025977e-01f, 1.12270571e-01f,
  3.84005129e-01f, 4.26083386e-01f, 1.58084318e-01f, 7.18608946e-02f, -2.24977002e-01f, -2.95134246e-01f, 1.59993187e-01f, 5.54201081e-02f, -1.78978994e-01f, 2.80911893e-01f,
  -2.15645924e-01f, -1.26342541e-02f, 1.47624716e-01f, 1.42218649e-01f, 1.31674660e-02f, 2.12930858e-01f, 1.11967482e-01f, -1.27610713e-01f, 1.03769571e-01f, 3.01003736e-02f,
  2.18650639e-01f, 1.34649903e-01f, 5.73081933e-02f, 3.37043442e-02f, 1.49137974e-02f, 9.22789127e-02f, -5.37808277e-02f, 1.01321891e-01f, -3.55311334e-02f, 2.13234080e-03f,
  1.89484060e-01f, -3.09001226e-02f, 6.26644567e-02f, -1.36529119e-03f, 1.67604476e-01f, 8.55179876e-02f, 2.02337354e-01f, 3.74773890e-02f, -9.47084054e-02f, 2.33009264e-01f,
  9.80118811e-02f, -1.47707731e-01f, -1.99411780e-01f, -6.84792772e-02f, 1.48318052e-01f, -1.26539081e-01f, 1.22159429e-01f, 3.12202483e-01f, 1.50102481e-01f, -2.58034557e-01f,
  -2.02819914e-01f, -7.72798732e-02f, -1.63798686e-02f, -1.58538193e-01f, 1.78263839e-02f, -1.52167127e-01f, 1.09179914e-01f, 4.23584320e-02f, 2.27536768e-01f, 4.81180511e-02f,
  1.70182645e-01f, 3.41320425e-01f, 6.32651746e-02f, -4.08391766e-02f, -6.70390278e-02f, 1.78693593e-01f, -1.46676302e-01f, -4.83825356e-02f, -1.36313690e-02f, -1.34420022e-01f,
  1.33534133e-01f, 1.25344843e-01f, 1.15188539e-01f, 1.69691652e-01f, -8.57348070e-02f, 3.42532426e-01f, 2.49214724e-01f, 1.56261936e-01f, 1.88317969e-01f, 8.08426291e-02f,
  2.92566955e-01f, -2.21780136e-01f, 5.03796749e-02f, 1.46084294e-01f, -2.60495484e-01f, 2.02912197e-01f, 3.12089115e-01f, -1.87879745e-02f, 2.08544493e-01f, 7.25418376e-03f,
  2.78719038e-01f, -2.21011490e-01f, -1.58062845e-01f, 2.86094129e-01f, -3.47255766e-02f, 3.62918466e-01f, 9.64758694e-02f, 4.80357409e-02f, 1.32686198e-01f, 7.40624070e-02f,
  -1.40296325e-01f, -4.13891226e-02f, 4.24463898e-01f, -6.37542680e-02f, -2.30729535e-01f, 2.09257305e-01f, 2.04854876e-01f, 6.65333867e-02f, -3.68826985e-02f, -6.07242137e-02f,
  3.24440390e-01f, 3.52970004e-01f, -1.21354789e-01f, 1.36913404e-01f, -1.30728364e-01f, 1.80276379e-01f, -3.90242413e-02f, 2.17329189e-01f, 1.07011937e-01f, 3.87066096e-01f,
  5.00051975e-02f, -1.99920703e-02f, 4.41092858e-03f, 1.74841598e-01f, 1.52743250e-01f, 9.48491395e-02f, -1.98087492e-03f, 1.59756720e-01f, -2.46064171e-01f, -3.26765180e-01f,
  -1.34471372e-01f, -4.43483368e-02f, 1.94948286e-01f, 3.49411339e-01f, -1.48678780e-01f, 2.97239304e-01f, 1.21822715e-01f, -3.04401189e-01f, 3.60059202e-01f, -1.98023230e-01f,
  -7.04076281e-03f, 2.18456104e-01f, 4.28232364e-02f, -1.03575192e-01f, 2.11345211e-01f, 1.82750612e-01f, 5.95730618e-02f, 1.34114221e-01f, 5.52863777e-02f, -1.02322809e-01f,
  1.61996618e-01f, 7.22919870e-03f, 1.64980218e-01f, 2.27157593e-01f, 3.25036980e-02f, 5.46835475e-02f, 2.50899434e-01f, -2.73187280e-01f, 1.88670099e-01f, -2.71397799e-01f,
  9.23848450e-02f, 1.54704034e-01f, 3.79794426e-02f, -1.87599614e-01f, -9.65616573e-03f, -1.83048114e-01f, 2.36479327e-01f, -4.48918045e-02f, 2.05820858e-01f, 2.06801206e-01f,
  -8.18635896e-03f, 2.90281564e-01f, 2.11541414e-01f, 3.95812511e-01f, -7.93028995e-02f, -3.52703869e-01f, 2.03701258e-01f, 7.93923512e-02f, 3.32891643e-01f, -3.64550427e-02f,
  1.33394688e-01f, -1.48067549e-02f, 5.52715175e-02f, -5.43123446e-02f, -9.83048528e-02f, -7.48403966e-02f, 1.43086970e-01f, 1.52889773e-01f, 1.33740559e-01f, 1.08660653e-01f,
  8.48025233e-02f, 9.42612961e-02f, -8.18559080e-02f, -1.06664650e-01f, -2.51690656e-01f, 1.78174339e-02f, 9.78918821e-02f, 3.79592925e-01f, -1.23591214e-01f, -1.68066308e-01f,
  3.31635445e-01f, -6.90921843e-02f, -8.23957771e-02f, 1.36540368e-01f, -4.70998092e-03f, -6.91297203e-02f, 1.59015909e-01f, -1.88283071e-01f, -5.85199222e-02f, 8.64098966e-02f,
  1.77798301e-01f, 3.27467889e-01f, -3.14751059e-01f, 9.33733508e-02f, -1.13617495e-01f, -1.44257754e-01f, 2.62781382e-02f, 1.39528811e-02f, -1.95802841e-02f, 5.71835153e-02f,
  -1.57188289e-02f, 1.63477689e-01f, -9.76775438e-02f, 1.62080526e-01f, 1.88466072e-01f, -4.43573967e-02f, 2.86794058e-03f, -6.00784458e-02f, 1.99265078e-01f, -3.82808149e-02f,
  -6.94030896e-04f, -2.85687476e-01f, -2.98175905e-02f, 5.65594174e-02f, 3.19269627e-01f, 2.12584287e-02f, -1.33566827e-01f, 1.72939256e-01f, -6.93318201e-03f, -2.29039276e-03f,
  3.06084633e-01f, 2.47980803e-01f, -2.70723015e-01f, 2.54377991e-01f, 1.49462745e-01f, 1.39048502e-01f, 5.56286275e-02f, 4.16062474e-01f, -3.21516469e-02f, 2.19247699e-01f,
  1.56938836e-01f, 2.47964457e-01f, 1.58281490e-01f, 1.56854406e-01f, 1.33128583e-01f, 7.90461749e-02f, -2.06982374e-01f, -2.50425132e-04f, -3.05870026e-01f, 1.12458028e-01f,
  -1.80619165e-01f, 2.05420461e-02f, 1.45390090e-02f, 3.05039406e-01f, 1.87795326e-01f, -3.69476676e-01f, 3.72619092e-01f, -5.31146713e-02f, 6.31857961e-02f, 9.07898173e-02f,
  1.79332897e-01f, 2.76951581e-01f, 8.76850858e-02f, 3.66574496e-01f, 4.58901562e-02f, 1.13479860e-01f, -1.36583775e-01f, 3.05487484e-01f, 7.80231431e-02f, -6.66303188e-02f,
  2.74612844e-01f, 1.09733120e-01f, 1.54574476e-02f, -9.26399678e-02f, 6.79837465e-02f, -2.75668234e-01f, -1.45727679e-01f, 1.16912574e-01f, 9.99997854e-02f, 1.63962826e-01f,
  3.85778427e-01f, 9.48618054e-02f, 3.14701468e-01f, -1.73131809e-01f, 2.64993668e-01f, -1.69082344e-01f, 2.83323944e-01f, 4.20580178e-01f, 9.73616466e-02f, 1.68742135e-01f,
  3.13129455e-01f, 1.17816985e-01f, 3.47977221e-01f, 1.50279686e-01f, 3.25933605e-01f, -2.42591962e-01f, 1.50112212e-01f, -8.94755572e-02f, -6.83881640e-02f, 1.95326656e-01f,
  -1.48356542e-01f, 1.40985832e-01f, 2.00987011e-02f, -1.57213405e-01f, 1.11367546e-01f, 8.68053511e-02f, -9.37491935e-03f, 2.46915698e-01f, 6.21141493e-02f, 1.17222920e-01f,
  3.43452066e-01f, 3.56576502e-01f, -1.39463916e-01f, 9.12969038e-02f, 8.40432476e-03f, -2.46517748e-01f, -1.02779940e-01f, 3.06330651e-01f, 1.61154270e-01f, 5.18047772e-02f,
  -3.43807936e-01f, 2.73577183e-01f, 9.52238217e-02f, 1.19001612e-01f, 1.10859595e-01f, -8.00106972e-02f, 7.92431235e-02f, -1.19471848e-01f, 1.04112029e-01f, 1.05782755e-01f,
  -1.83192521e-01f, 2.40256190e-02f, -7.99466074e-02f, 9.65606421e-02f, -2.09977716e-01f, 2.35057116e-01f, 6.19994104e-02f, 1.82213888e-01f, -1.05007350e-01f, 3.24322343e-01f,
  8.84663984e-02f, 1.05996698e-01f, 1.48684353e-01f, -1.26440719e-01f, 4.22646478e-02f, 2.51056314e-01f, 2.47938812e-01f, -1.69228569e-01f, 2.56885737e-02f, -1.61380053e-01f,
  -9.94247422e-02f, -2.17097282e-01f, -7.11119547e-03f, 6.51848912e-02f, -1.59086753e-02f, -9.68264192e-02f, 2.51865327e-01f, 8.49227086e-02f, 1.08184487e-01f, -8.26817006e-02f,
  6.06519096e-02f, 6.89526349e-02f, -2.40250826e-02f, -9.59614590e-02f, 2.61457115e-01f, 1.55376688e-01f, -2.60076709e-02f, 1.64333761e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  3.78038287e-02f, 8.97655934e-02f, 7.54529834e-02f, 1.12155698e-01f, 7.35447556e-02f, 1.90459281e-01f, 2.26792227e-02f, 2.16204710e-02f, 6.18684143e-02f, 6.70866147e-02f,
  2.84013391e-01f, 1.83559477e-01f, 8.52206796e-02f, 1.80821478e-01f, 2.02574193e-01f, 2.08023056e-01f, 8.61170441e-02f, 1.29157141e-01f, 1.75745904e-01f, 1.17922112e-01f,
  2.18492925e-01f, 2.43061669e-02f, -1.09492689e-02f, 4.94452454e-02f, 2.62726516e-01f, 1.15905046e-01f, 1.96223989e-01f, 1.21274762e-01f, 8.27540234e-02f, 2.18296617e-01f,
  1.31211698e-01f, 4.88457233e-02f, 2.08749026e-01f, 1.05130143e-01f, 1.00227185e-02f, 1.84104051e-02f, 9.30066407e-02f, 1.80333450e-01f, 1.76201880e-01f, -3.69195342e-02f,
  -5.48062101e-03f, 5.22447079e-02f, 2.22910531e-02f, 9.75742489e-02f, 2.10623711e-01f, 2.39891976e-01f, 1.45705819e-01f, 9.59109142e-02f, 9.85898152e-02f, 1.27033114e-01f,
  3.15177351e-01f, 1.93447515e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.06915096e-02f, -1.24420159e-01f, -7.15553761e-02f, -1.20823085e-01f, -7.21209645e-02f, 1.04486205e-01f, -1.75839618e-01f, -3.19355845e-01f, 1.48021113e-02f, 1.98435083e-01f,
  5.24360463e-02f, 1.17657848e-01f, 2.86311120e-01f, -3.70303631e-01f, -2.64553607e-01f, -1.61308154e-01f, -2.04876304e-01f, -1.08567486e-02f, 1.60344228e-01f, -3.72927748e-02f,
  -1.32081136e-01f, -5.13396978e-01f, 2.03105241e-01f, 1.09872460e-01f, 1.02528527e-01f, 7.78753385e-02f, -2.01384604e-01f, -2.79039085e-01f, 2.76157379e-01f, -2.06398249e-01f,
  1.96250603e-01f, -3.21052909e-01f, 2.75753707e-01f, 7.97473267e-02f, -4.98073734e-02f, 7.41675273e-02f, -3.63153130e-01f, -3.63799393e-01f, -2.15386748e-01f, 2.78691232e-01f,
  -9.76010412e-02f, 3.43166918e-01f, 2.94619471e-01f, -1.98690563e-01f, 1.39270872e-01f, -2.84994960e-01f, -3.85481149e-01f, -3.29675935e-02f, -2.97495306e-01f, -3.41062009e-01f,
  -5.01333296e-01f, -4.64478314e-01f, -3.54107350e-01f, 2.76538700e-01f, 6.28059357e-03f, 2.39370152e-01f, -4.45497558e-02f, -1.06199495e-01f, -9.48859155e-02f, -2.90381551e-01f,
  4.24011908e-02f, -9.47414786e-02f, -2.74273343e-02f, -3.53744775e-01f, -9.41988826e-03f, 3.92279103e-02f, -4.47396971e-02f, -6.51938319e-02f, 1.68330327e-01f, 1.63217522e-02f,
  -5.64497076e-02f, 1.20982863e-01f, 1.16033666e-01f, -2.26832360e-01f, -6.25323653e-02f, 2.83799857e-01f, -4.90425557e-01f, 2.10041553e-01f, -3.46530914e-01f, 9.98739377e-02f,
  -3.06175262e-01f, 2.07860112e-01f, 6.81314319e-02f, -2.70694405e-01f, 1.99707955e-01f, -1.07302688e-01f, 1.66924372e-01f, -8.71119425e-02f, -1.77542105e-01f, 2.29245983e-02f,
  -1.24252990e-01f, -6.19662814e-02f, -6.18962944e-03f, -1.33058608e-01f, 2.06608385e-01f, -1.63601354e-01f, -6.21708483e-02f, 2.50850976e-01f, -4.71584201e-01f, -4.43465084e-01f,
  -3.95688444e-01f, 2.35930845e-01f, 7.24760443e-02f, 2.69946724e-01f, -4.53376889e-01f, 1.20801702e-01f, 1.22835785e-01f, 4.07859355e-01f, 2.16688320e-01f, -1.13426968e-01f,
  -3.23691905e-01f, -1.33428201e-01f, -1.88468933e-01f, 1.33379279e-02f, -2.83646077e-01f, 7.44412094e-02f, 2.38904312e-01f, 9.69028920e-02f, 2.29655430e-01f, -3.68299931e-01f,
  -3.07004184e-01f, -2.83798128e-01f, 2.60867864e-01f, 1.52369127e-01f, -2.17803493e-01f, -2.40964442e-01f, -5.12695909e-01f, 2.23140150e-01f, -1.35079667e-01f, 1.44496828e-01f,
  1.52238244e-02f, -1.27161369e-01f, 3.26892659e-02f, -1.07115239e-01f, 2.29968265e-01f, -1.87185898e-01f, 2.39714622e-01f, -1.99064836e-01f, -9.21040028e-02f, -1.56977668e-01f,
  -2.24730477e-01f, 2.56508052e-01f, -6.55812621e-02f, -1.98116198e-01f, -2.04053655e-01f, -2.60388106e-01f, -3.61868948e-01f, 1.98537469e-01f, 2.11999580e-01f, -4.64014471e-01f,
  -3.00034553e-01f, -3.90720546e-01f, -5.50746247e-02f, -1.04035079e-01f, 2.92508066e-01f, 7.19843209e-02f, 2.25262389e-01f, -1.27480313e-01f, -1.02201544e-01f, -3.97436380e-01f,
  -1.01302005e-01f, 2.36055568e-01f, -3.26154567e-02f, -3.29837114e-01f, 1.61650553e-01f, 1.48198038e-01f, 1.08522132e-01f, 1.40784472e-01f, 1.54078767e-01f, -3.87031704e-01f,
  -4.06663090e-01f, -2.96276920e-02f, 1.79836392e-01f, 2.82325357e-01f, 2.24350303e-01f, 2.56888479e-01f, 2.40651369e-01f, -1.94027990e-01f, -3.85766327e-01f, -1.55010879e-01f,
  1.36062086e-01f, -9.22937989e-02f, 5.58137447e-02f, -1.31814018e-01f, -2.89804757e-01f, -3.28278035e-01f, -3.25370580e-01f, 7.12335780e-02f, -1.43253043e-01f, 2.93247730e-01f,
  -4.26613927e-01f, -9.30449646e-03f, -8.69125035e-03f, 8.59203488e-02f, -8.01855931e-04f, 3.95190604e-02f, -1.36512384e-01f, -4.07189801e-02f, 3.13986868e-01f, 1.10311031e-01f,
  1.88309714e-01f, 2.16436028e-01f, 2.77922720e-01f, 3.21683437e-02f, 6.52445927e-02f, -5.01004696e-01f, 1.00330263e-01f, 2.33478978e-01f, 3.28793019e-01f, -3.70333940e-01f,
  2.42298841e-01f, -3.30462486e-01f, -5.42976797e-01f, 2.98964709e-01f, 1.36863410e-01f, -1.38242409e-01f, 1.94671020e-01f, 1.07231170e-01f, -3.62073511e-01f, 2.42496967e-01f,
  1.24934398e-01f, 2.23724082e-01f, -4.38871503e-01f, 1.94078147e-01f, -6.37617111e-02f, -1.76056042e-01f, 2.73967445e-01f, -8.40101540e-02f, -1.41299888e-01f, -2.29933932e-01f,
  -4.29511577e-01f, -3.87270033e-01f, 1.43189773e-01f, 1.64437741e-01f, 3.35049599e-01f, -1.14192970e-01f, -3.26407254e-01f, -6.83103576e-02f, -1.18624978e-01f, -5.58029294e-01f,
  -4.11095291e-01f, 1.23763837e-01f, -1.75556451e-01f, -3.71900916e-01f, -2.35641375e-01f, -1.45432413e-01f, -3.66377115e-01f, 1.20448582e-01f, -3.89211833e-01f, -3.28603774e-01f,
  -1.34397298e-02f, -4.09281850e-01f, 2.37343162e-01f, -3.88060600e-01f, 1.65074468e-01f, -1.54384404e-01f, 5.12782335e-02f, 1.17548570e-01f, -9.37679596e-03f, -1.39375813e-02f,
  1.34573421e-02f, 6.17767051e-02f, -2.08664536e-01f, -2.28666380e-01f, -3.17800999e-01f, 9.51025859e-02f, 1.93146154e-01f, 5.92107959e-02f, 9.27920863e-02f, -1.03990845e-01f,
  3.42953324e-01f, -6.42325589e-03f, -8.29422250e-02f, -2.76788354e-01f, -2.94628382e-01f, -3.55019331e-01f, -7.45209157e-02f, 1.21749289e-01f, -1.72373541e-02f, -2.12047528e-02f,
  1.88583881e-02f, -4.33010697e-01f, 1.63714662e-01f, 2.06529990e-01f, 3.10563892e-01f, 2.41636112e-01f, -1.04050942e-01f, 1.38531253e-01f, 2.14496732e-01f, 2.80028760e-01f,
  -3.23608741e-02f, -4.69195880e-02f, 2.07626373e-01f, -2.21506327e-01f, -5.75571299e-01f, -2.62440026e-01f, -2.40349948e-01f, 1.72545686e-01f, -2.86834061e-01f, 1.82551757e-01f,
  -1.85987756e-01f, -2.05621451e-01f, 2.53959239e-01f, 1.53390199e-01f, -1.25217745e-02f, -5.34857392e-01f, -2.15531215e-01f, 1.91305175e-01f, -4.87597287e-02f, 1.51110277e-01f,
  -2.70003051e-01f, 2.14956358e-01f, 3.33243370e-01f, -3.79397899e-01f, -1.12310655e-01f, 1.67720616e-01f, 1.37848943e-01f, 1.46070316e-01f, 1.98564783e-01f, -1.59299001e-01f,
  2.15821564e-02f, 6.66685253e-02f, 5.69083951e-02f, -2.09845882e-02f, -1.27641737e-01f, -3.97200026e-02f, -1.71266466e-01f, 1.75060779e-01f, -3.45664889e-01f, 2.48312324e-01f,
  1.18554823e-01f, 2.33896688e-01f, -3.52524728e-01f, -1.35176912e-01f, 1.10736042e-01f, -1.60761863e-01f, 2.89714545e-01f, 3.18922251e-01f, 6.66062683e-02f, -3.62177044e-01f,
  -4.53691661e-01f, 1.10832058e-01f, 6.68319613e-02f, 1.14499711e-01f, 1.88425973e-01f, 1.67658091e-01f, -1.34051055e-01f, -2.48735517e-01f, -3.62162203e-01f, 4.70239930e-02f,
  1.73160851e-01f, -3.00255179e-01f, 1.97299033e-01f, -2.15520233e-01f, -3.64470541e-01f, 6.82750670e-03f, -3.82072479e-02f, 1.99885666e-01f, -3.59207392e-02f, -5.13834767e-02f,
  -2.58222014e-01f, 3.72927040e-02f, 1.13876089e-02f, -1.95747450e-01f, 9.79400426e-02f, -5.13920784e-01f, -8.71459097e-02f, 4.41671088e-02f, 2.29929596e-01f, -3.01405936e-01f,
  3.22155327e-01f, -3.45493466e-01f, -1.49209142e-01f, -2.34067619e-01f, 8.76388997e-02f, 2.47009769e-01f, 1.99520692e-01f, 3.03349555e-01f, 2.03676611e-01f, 1.25420973e-01f,
  -3.80239427e-01f, -1.69562846e-01f, 7.93671981e-03f, -3.06129396e-01f, -1.44999981e-01f, -2.47170627e-01f, -2.18747277e-02f, 1.25302905e-02f, 6.93651065e-02f, 7.80989379e-02f,
  -1.38800249e-01f, -1.82880480e-02f, 1.92670360e-01f, 2.61597991e-01f, 1.64945856e-01f, 3.15305501e-01f, -3.25238347e-01f, 1.93508312e-01f, 2.44817302e-01f, 9.31760073e-02f,
  8.61635283e-02f, -1.03825606e-01f, -4.10726666e-01f, 3.17123950e-01f, 1.30403087e-01f, 1.85623795e-01f, -4.20115441e-01f, 2.70127714e-01f, -1.71255440e-01f, -2.89300799e-01f,
  5.81366532e-02f, 1.80367172e-01f, -4.78289306e-01f, 1.59639284e-01f, 1.89160764e-01f, -2.68449992e-01f, -2.85588861e-01f, -2.46138230e-01f, -3.72641772e-01f, 1.51453139e-02f,
  -5.80320843e-02f, 1.63796633e-01f, 2.08142057e-01f, -2.13858083e-01f, 2.41904348e-01f, -3.15629303e-01f, -3.54971379e-01f, -1.16007760e-01f, -4.32080738e-02f, 3.72451782e-01f,
  8.79686475e-02f, 1.77175239e-01f, 1.99396536e-01f, -3.12233984e-01f, 2.81208426e-01f, 5.80863617e-02f, -1.24833047e-01f, -7.83112943e-02f, 2.89585263e-01f, -2.97566026e-01f,
  -1.03146881e-01f, 1.71904460e-01f, 1.35662913e-01f, -7.79567659e-02f, -3.21967244e-01f, -4.51283395e-01f, -4.95068371e-01f, -1.66160360e-01f, -4.96304408e-02f, 2.25605201e-02f,
  -1.90151870e-01f, -4.82267477e-02f, -1.49012329e-02f, -1.77596837e-01f, 7.54754543e-02f, 9.05316919e-02f, 1.90872103e-01f, 1.13265283e-01f, -2.83207864e-01f, -1.92788735e-01f,
  1.34413704e-01f, -3.06909084e-02f, 2.53339827e-01f, 1.82481721e-01f, 6.44994378e-02f, -1.06291980e-01f, -1.58110335e-01f, 3.33425909e-01f, -2.03387946e-01f, -2.12858647e-01f,
  -4.43789035e-01f, -7.54685551e-02f, -3.29335213e-01f, 2.15135999e-02f, 3.95456608e-03f, -1.08224243e-01f, 3.56676541e-02f, 4.60025035e-02f, -2.14148402e-01f, 2.15410233e-01f,
  8.46975371e-02f, 2.86597206e-04f, 2.39523873e-01f, 2.58001864e-01f, -5.37775308e-02f, -2.75105834e-01f, 2.51891404e-01f, -4.60901745e-02f, -3.66373777e-01f, -3.29361051e-01f,
  -1.80979341e-01f, -6.59512505e-02f, 2.32601792e-01f, -3.05593491e-01f, 2.66359001e-01f, -2.15935320e-01f, 6.64963499e-02f, 2.69915938e-01f, -1.69481352e-01f, 7.94211254e-02f,
  -1.21368952e-01f, -5.90321869e-02f, -1.28393799e-01f, 1.89475715e-01f, -3.56533885e-01f, 2.22138897e-01f, -2.20738351e-01f, -2.33906284e-01f, 2.38809109e-01f, 4.15262878e-02f,
  1.06098160e-01f, -2.65250117e-01f, -6.12473954e-03f, 1.19686276e-02f, -1.91114664e-01f, -1.12099998e-01f, -4.69820835e-02f, -1.32095531e-01f, 9.32769701e-02f, -2.62204945e-01f,
  -2.40058094e-01f, 1.63784549e-01f, -1.58620358e-01f, -7.01323450e-02f, -2.89670169e-01f, -1.73687309e-01f, -2.88624913e-02f, -1.62220925e-01f, -1.80046022e-01f, 1.42830014e-01f,
  2.80499369e-01f, 3.06164205e-01f, -3.54891658e-01f, 1.05285265e-01f, -3.39100845e-02f, 2.23781019e-01f, 2.33127162e-01f, 2.12227255e-01f, 3.09946746e-01f, -3.14606190e-01f,
  -3.03145289e-01f, -1.69250265e-01f, -7.91938081e-02f, -2.71080256e-01f, -1.39932811e-01f, 1.79127693e-01f, 3.04033697e-01f, -1.85438991e-01f, 8.61385688e-02f, -4.51630019e-02f,
  -2.16242850e-01f, 1.87236354e-01f, -3.19793448e-02f, -3.02374125e-01f, 6.49271831e-02f, -2.53476799e-01f, -3.38062346e-01f, -2.88138896e-01f, 2.47758821e-01f, -3.37518960e-01f,
  -1.93003848e-01f, -1.51378224e-02f, -1.69193327e-01f, 2.21305028e-01f, 1.49716526e-01f, -1.55366316e-01f, 6.23484235e-03f, -1.51582628e-01f, -2.24905774e-01f, -2.93361563e-02f,
  -3.06404024e-01f, 2.84140468e-01f, -2.34121561e-01f, 2.76609480e-01f, -8.47579688e-02f, 1.45659268e-01f, 1.10160790e-01f, -6.18332438e-02f, -1.02980755e-01f, -2.77728830e-02f,
  5.76422028e-02f, 3.98295000e-02f, -9.99718085e-02f, 7.56000727e-02f, 2.28118673e-01f, -3.78320903e-01f, 1.26712233e-01f, -3.11068505e-01f, -3.43924284e-01f, -2.51792908e-01f,
  -3.24987054e-01f, -5.04468262e-01f, -5.44186123e-02f, 2.72475570e-01f, -3.11068594e-01f, 1.26013994e-01f, 2.40612984e-01f, -1.43722057e-01f, -3.31635147e-01f, -5.45084834e-01f,
  -2.72958666e-01f, -3.36029142e-01f, -3.32652122e-01f, 2.28679389e-01f, 2.60269165e-01f, -2.28239596e-01f, -1.28732026e-01f, 2.88207829e-01f, -8.29745904e-02f, -2.81076163e-01f,
  -6.06172718e-03f, 3.32319468e-01f, 2.43623167e-01f, 1.94912359e-01f, 2.65508175e-01f, -3.09720725e-01f, 2.61043370e-01f, -4.30282593e-01f, -1.35223567e-01f, -4.59242642e-01f,
  -9.73797292e-02f, -1.13138529e-02f, 9.41088870e-02f, 1.13215193e-01f, 1.08403817e-01f, -3.09499592e-01f, 4.48607951e-02f, 1.56021371e-01f, 2.07465291e-02f, 1.96947768e-01f,
  -6.57064989e-02f, 1.36389002e-01f, 2.93248117e-01f, -9.30545181e-02f, -1.68391213e-01f, 6.82318285e-02f, 2.59636164e-01f, -1.39781952e-01f, -1.65030167e-01f, -2.36238450e-01f,
  -5.43760620e-02f, 8.07869658e-02f, -2.33712234e-02f, 1.25504717e-01f, 2.14183666e-02f, -1.59378648e-02f, 2.15889737e-01f, -2.96264827e-01f, 1.27073228e-01f, -3.00213754e-01f,
  -1.37082860e-01f, -1.06730960e-01f, 2.77735829e-01f, 2.49862611e-01f, -2.67318994e-01f, 2.59451896e-01f, -2.90600359e-01f, -3.20755690e-01f, -1.21690139e-01f, -2.94367164e-01f,
  3.88487130e-01f, -2.29330704e-01f, 2.10144341e-01f, -1.12454161e-01f, -1.02927936e-02f, 2.92945296e-01f, 1.03817388e-01f, -3.30569685e-01f, -6.21892400e-02f, -3.19537371e-01f,
  -3.77532780e-01f, 1.68868557e-01f, -1.88279018e-01f, -2.60417879e-01f, -3.18846971e-01f, -3.13380539e-01f, -2.98814178e-01f, -2.89726406e-01f, 2.11953416e-01f, 1.52489692e-01f,
  3.90197784e-01f, 6.79916367e-02f, 1.33219451e-01f, -9.52898618e-03f, 1.28157586e-01f, 3.18083316e-01f, -3.89451891e-01f, 8.69661346e-02f, -3.07294011e-01f, 2.82686710e-01f,
  -1.98475361e-01f, -3.37973952e-01f, -1.54210344e-01f, -2.36108080e-01f, -1.25456199e-01f, -2.85808921e-01f, -2.28100136e-01f, 8.54911953e-02f, 2.19949946e-01f, -3.37584138e-01f,
  -3.21262772e-03f, 1.75017983e-01f, 2.25557476e-01f, 2.09681302e-01f, 9.10041556e-02f, -1.47454031e-02f, 4.75589037e-02f, -5.80264218e-02f, 1.54607939e-02f, -3.56100425e-02f,
  5.43016903e-02f, 6.61160573e-02f, -2.15122402e-01f, 9.70623568e-02f, 8.83975774e-02f, 2.19764262e-01f, 1.59073547e-01f, 2.82850295e-01f, -8.64331946e-02f, -3.34011167e-01f,
  -8.11418518e-03f, -1.09842606e-01f, -8.70486870e-02f, -9.26601067e-02f, -3.26196402e-01f, 3.52744281e-01f, 3.22444201e-01f, 2.02446774e-01f, 1.58258095e-01f, -3.46459866e-01f,
  -3.50927174e-01f, 1.23391919e-01f, -3.53298932e-01f, 6.97293654e-02f, -3.38555545e-01f, -2.78683633e-01f, -3.98459703e-01f, -3.58148336e-01f, 1.55878976e-01f, -3.27157736e-01f,
  2.57580996e-01f, -1.48347840e-01f, 2.47486643e-02f, -2.70819128e-01f, -1.85054541e-01f, -3.58819544e-01f, -1.90161355e-02f, 2.84816116e-01f, -4.82374430e-01f, -7.81228170e-02f,
  -2.13783458e-01f, -9.44611803e-02f, 2.27238923e-01f, 1.79435790e-01f, 2.83529609e-01f, -1.05563030e-01f, 1.17987178e-01f, -3.22587341e-01f, -4.80085284e-01f, -1.49158835e-01f,
  2.00883280e-02f, 2.27624044e-01f, 2.20244735e-01f, 2.49241889e-01f, -1.56158224e-01f, -9.34255123e-02f, 2.86115259e-01f, 2.41380885e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.04040012e-01f, -8.47692862e-02f, -8.23218152e-02f, -9.43421293e-03f, 8.39774534e-02f, -1.32994158e-02f, -1.61003526e-02f, -1.17765941e-01f, -4.36225012e-02f, 3.43527980e-02f,
  1.32107943e-01f, 1.03401043e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    