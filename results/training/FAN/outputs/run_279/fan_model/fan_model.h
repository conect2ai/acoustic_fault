/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.22369215e-01f, 3.01771790e-01f, -1.88810378e-01f, 3.26341331e-01f, -1.86440244e-01f, 5.24958931e-02f, 1.32739335e-01f, 6.41343817e-02f, 4.42856401e-02f, 3.72669905e-01f,
  6.59247339e-02f, 2.98914667e-02f, 2.38660723e-02f, 3.04205567e-01f, 7.81897269e-03f, 1.25085339e-01f, 1.64755791e-01f, 1.67397976e-01f, 5.06390333e-02f, 1.03214188e-02f,
  3.71255539e-02f, 2.54970074e-01f, 4.04015295e-02f, -1.47058545e-02f, 9.43237320e-02f, 4.06253012e-03f, 8.24456215e-02f, -7.22116455e-02f, 3.96081656e-02f, 1.57345664e-02f,
  -9.78558441e-04f, 1.01980671e-01f, -5.88506088e-02f, 5.43922707e-02f, -2.39556488e-02f, -4.95401621e-02f, -3.72632104e-03f, -5.48228957e-02f, -2.49222778e-02f, -2.03875657e-02f,
  -9.44581628e-03f, -3.08331698e-02f, 6.03715703e-02f, 1.68133096e-03f, -1.10693090e-03f, -1.32628428e-02f, -5.08100949e-02f, -7.74955601e-02f, -5.24759181e-02f, -6.26889020e-02f,
  -9.30603128e-03f, 2.95846555e-02f, 3.20236534e-02f, 2.17350386e-02f, -4.51302007e-02f, 7.04175048e-03f, 6.28873780e-02f, -1.06050611e-01f, -1.89863238e-02f, 4.28054333e-02f,
  4.75832028e-03f, -9.18266475e-02f, -1.47897825e-02f, 1.97214466e-02f, 4.43367213e-02f, -6.07718453e-02f, 1.25716561e-02f, -6.60988986e-02f, -4.77806153e-03f, 7.26971328e-02f,
  -2.03077812e-02f, 1.12374425e-02f, 2.04140004e-02f, 4.71258797e-02f, 2.99342610e-02f, 4.70132045e-02f, 7.90097862e-02f, 6.76571345e-03f, 1.62252188e-02f, -8.08079168e-03f,
  -4.15110923e-02f, 3.60306688e-02f, 2.14462709e-02f, 5.90125192e-03f, -2.74548903e-02f, 5.40461317e-02f, 1.59847103e-02f, 5.51227666e-02f, -4.85066138e-02f, 2.55676042e-02f,
  2.96758890e-01f, 3.08539748e-01f, 4.90384595e-03f, 1.68264005e-02f, 4.25346009e-02f, 6.03672899e-02f, -2.38545015e-02f, -7.68647646e-04f, 1.07018761e-01f, 9.11998227e-02f,
  6.76950626e-03f, 1.17939441e-02f, -1.94927882e-02f, -6.27226084e-02f, 5.07548004e-02f, 5.88617474e-02f, 3.67538608e-03f, 7.37341940e-02f, 8.44215378e-02f, -4.76401392e-03f,
  3.56849618e-02f, 9.21648834e-03f, -1.67037379e-02f, -8.45172070e-03f, 1.99173987e-02f, 4.63159867e-02f, -4.22026366e-02f, -1.89455207e-02f, -3.97333801e-02f, 2.43608151e-02f,
  -4.56552714e-01f, -5.48136272e-02f, 9.90157053e-02f, -3.25538553e-02f, -9.79744866e-02f, 7.26105354e-04f, 5.03956191e-02f, -1.24378502e-01f, -1.05204005e-02f, -3.17348614e-02f,
  -8.95209089e-02f, -1.83312793e-03f, 4.78830487e-02f, -4.41473797e-02f, -1.82900634e-02f, 9.34966430e-02f, -1.08948700e-01f, -4.73675616e-02f, -2.71592978e-02f, -1.20516710e-01f,
  -4.86235693e-02f, -2.35943541e-01f, -6.10730909e-02f, -1.06729031e-01f, 9.74131573e-04f, 5.29905595e-02f, 9.05645266e-02f, 2.03774706e-01f, -4.08044495e-02f, 5.84281571e-02f,
  -1.54546887e-01f, -8.05636942e-02f, -4.19979729e-02f, 5.33233359e-02f, -1.06484126e-02f, 1.42674390e-02f, 1.23862512e-02f, 8.02863240e-02f, 1.77365337e-02f, -1.19271360e-01f,
  2.64558736e-02f, -2.34290697e-02f, -1.23002596e-01f, 7.85076320e-02f, 1.01279607e-02f, 5.46925375e-03f, -9.46427323e-03f, 5.73322736e-02f, -2.68877130e-02f, -1.21542551e-02f,
  1.41552053e-02f, -4.04061601e-02f, 7.99320638e-02f, 2.42207833e-02f, 3.42428102e-05f, -2.65255086e-02f, 1.31479371e-02f, -7.05042109e-02f, -1.70537848e-02f, -2.07619332e-02f,
  2.37407461e-02f, 3.23371477e-02f, -3.86403911e-02f, -2.50923205e-02f, -3.26238424e-02f, -4.75444049e-02f, 6.71807900e-02f, -4.68050912e-02f, 3.88872921e-02f, 9.32011753e-03f,
  -2.52641421e-02f, 1.15414010e-03f, 5.86763807e-02f, -6.77690515e-03f, -6.67280257e-02f, 3.69852707e-02f, -2.92229708e-02f, 8.63644667e-03f, -1.01102777e-02f, 2.98185498e-02f,
  7.56900236e-02f, 5.66081554e-02f, -3.33319381e-02f, 5.72292358e-02f, 3.74344550e-02f, -2.94889025e-02f, 4.92642149e-02f, 5.43479435e-02f, -7.75957629e-02f, 2.06829868e-02f,
  -1.29445049e-03f, -8.59948500e-07f, -6.29841834e-02f, -5.35074770e-02f, 1.63145885e-02f, -4.37792428e-02f, 7.78718442e-02f, -4.23646197e-02f, -3.44342776e-02f, -3.03722955e-02f,
  8.36624671e-03f, 1.16791343e-02f, 4.96596172e-02f, 3.63291949e-02f, 6.97284788e-02f, -5.87755665e-02f, -4.35990132e-02f, -9.41550359e-02f, 9.14147794e-02f, -4.44024317e-02f,
  -5.59944659e-02f, -3.16653401e-02f, -2.39175223e-02f, -6.68871850e-02f, 3.86382602e-02f, 6.49175569e-02f, 7.90196843e-03f, -8.49994365e-03f, 2.78263148e-02f, 8.25426262e-03f,
  3.76832277e-01f, -2.55204350e-01f, -2.19349097e-02f, -2.21260116e-01f, 1.06115192e-01f, -5.19103818e-02f, -4.06252183e-02f, -2.11764410e-01f, 2.84486115e-02f, -1.75874606e-01f,
  -1.48623466e-01f, 1.08878464e-01f, -4.28498760e-02f, -1.87474906e-01f, 6.47591054e-02f, -5.00693172e-02f, -2.79331170e-02f, -2.62305439e-02f, -3.02287955e-02f, -6.59675375e-02f,
  -2.70876177e-02f, -1.08833663e-01f, -5.55053242e-02f, -8.45688358e-02f, -1.16923936e-02f, -4.24786210e-02f, 6.13887757e-02f, -3.37471109e-04f, -6.07768856e-02f, -4.51948456e-02f,
  -1.16466500e-01f, 1.23906406e-02f, 6.00741133e-02f, 4.63052914e-02f, -2.13798769e-02f, 1.77977979e-02f, -9.85207618e-04f, 2.03516968e-02f, 2.32529659e-02f, -6.25891238e-03f,
  2.12564990e-02f, 5.00253886e-02f, -3.69193107e-02f, 5.70414774e-02f, 3.57311219e-02f, -1.45910596e-02f, 2.96411160e-02f, -5.46544418e-02f, -4.41694111e-02f, 1.67397484e-02f,
  -6.87004998e-04f, 3.20624076e-02f, -7.42499297e-03f, -1.61055811e-02f, 2.12476365e-02f, 2.75035761e-02f, -2.60369200e-02f, -4.13114466e-02f, -1.68652530e-03f, -2.25904621e-02f,
  5.73145486e-02f, -2.23986544e-02f, 2.31841914e-02f, -5.73725402e-02f, 4.48037311e-02f, -5.25390655e-02f, 1.54241268e-02f, -2.13609710e-02f, -8.63840990e-03f, -2.40168907e-02f,
  1.12331696e-02f, 2.34460719e-02f, 8.71585011e-02f, 1.31803155e-02f, -5.37271798e-02f, 6.22797348e-02f, 5.16337715e-02f, 6.33005844e-03f, -3.00378427e-02f, 1.28792338e-02f,
  -2.71754432e-02f, 6.85592294e-02f, -1.65564977e-02f, -3.44819538e-02f, 6.47669807e-02f, -2.39676088e-02f, 9.40284110e-04f, 5.77879101e-02f, -5.68138249e-02f, 7.04457052e-03f,
  -8.87960419e-02f, -4.02766559e-03f, -1.02241829e-01f, 1.56898927e-02f, 6.91018403e-02f, 6.13999888e-02f, -5.04118018e-02f, -4.95377146e-02f, 1.81268379e-02f, 7.80648086e-03f,
  3.25782709e-02f, -2.04327386e-02f, -1.81139819e-02f, -5.79001606e-02f, -1.20662143e-02f, -4.56477515e-02f, 6.40826439e-03f, -1.73920039e-02f, -5.43574756e-03f, -3.04151364e-02f,
  -4.86722328e-02f, 4.31850404e-02f, 5.20432517e-02f, -3.28435027e-03f, 3.38612795e-02f, 4.15107347e-02f, -2.23866533e-02f, -1.50813209e-02f, 4.35162708e-02f, -2.16490012e-02f,
  -1.92501977e-01f, -1.38814628e-01f, 7.61627480e-02f, -6.73520118e-02f, -1.44067675e-01f, 5.89754321e-02f, 1.97718412e-01f, -1.63430661e-01f, -1.65854067e-01f, -1.29266633e-02f,
  -6.41671047e-02f, -3.33743729e-02f, 5.61328419e-02f, -3.93805616e-02f, -1.51262525e-02f, 1.06466478e-02f, -9.42092612e-02f, 2.84691304e-02f, -1.22677274e-02f, -6.68250695e-02f,
  -5.20185642e-02f, 7.37923663e-03f, 6.31964393e-03f, -4.81506400e-02f, -1.13190956e-01f, -9.53725725e-02f, -4.16531898e-02f, -3.96686373e-03f, 1.23531530e-02f, -3.27792466e-02f,
  -4.25626943e-03f, -2.86122262e-02f, -1.56989209e-02f, 1.46871269e-01f, 7.37934411e-02f, 4.39117104e-02f, 4.02082875e-02f, 7.35910162e-02f, 1.68869123e-02f, -8.60062242e-02f,
  4.31161188e-03f, 2.59958748e-02f, -4.37628888e-02f, -5.39860502e-02f, 6.81957901e-02f, -3.90774272e-02f, -2.27096528e-02f, -8.30842629e-02f, -1.37586810e-03f, -3.79822589e-02f,
  -1.55062526e-02f, -4.93496917e-02f, -5.04897609e-02f, 8.28578044e-03f, 4.72521968e-02f, -6.40801638e-02f, 1.40968725e-01f, 9.01612863e-02f, -8.36076681e-03f, -7.07085356e-02f,
  -3.16555202e-02f, 4.39230585e-03f, -1.77393353e-03f, 8.78433697e-03f, -9.25546698e-03f, -9.49471537e-03f, -6.96262047e-02f, -1.04994096e-01f, -5.99940959e-03f, -3.44817564e-02f,
  -7.43331090e-02f, -1.35406014e-02f, -8.78810212e-02f, -3.13481875e-02f, -2.15176847e-02f, 2.29609143e-02f, -3.93631309e-02f, -7.19221607e-02f, -1.12172447e-01f, -6.04523942e-02f,
  -3.77564132e-02f, -2.19499730e-02f, 3.69482413e-02f, 7.70503730e-02f, 4.59217168e-02f, 4.77804095e-02f, -1.04808416e-02f, -8.36689696e-02f, -2.26188377e-02f, 1.05500862e-01f,
  2.26647146e-02f, -1.35836646e-01f, -1.03223079e-04f, -5.36455587e-02f, -2.34644916e-02f, 5.09658083e-02f, -2.59019751e-02f, 5.15115857e-02f, -1.16659060e-01f, 7.51084909e-02f,
  2.75956430e-02f, -3.64456326e-02f, 6.87867031e-02f, -5.99436183e-03f, -1.26647400e-02f, -1.10239731e-02f, 1.92580801e-02f, 3.85229252e-02f, -1.10122077e-01f, -2.35790275e-02f,
  1.34936031e-02f, 2.62354985e-02f, -7.41508454e-02f, -1.13022193e-01f, -7.78435543e-02f, -5.13554402e-02f, -2.72885077e-02f, 1.08788107e-02f, 1.46231763e-02f, -7.69811636e-03f,
  -1.75138757e-01f, 1.64898083e-01f, 2.93244720e-02f, 1.11652154e-03f, 3.58719155e-02f, -1.05842806e-01f, -1.30154818e-01f, 1.28575727e-01f, 1.58196613e-01f, -1.19719431e-01f,
  -1.62583247e-01f, -1.47071645e-01f, -7.95208961e-02f, -7.88645446e-02f, -3.05204779e-01f, -6.92436285e-03f, -6.95188120e-02f, 2.23852806e-02f, 1.02417566e-01f, 3.51735577e-02f,
  1.12227656e-01f, -1.65302992e-01f, -8.11267719e-02f, -2.00775228e-02f, -8.92129168e-02f, 8.65665227e-02f, -2.59106249e-01f, -5.26252985e-02f, -1.21457003e-01f, -1.59063458e-01f,
  6.64012805e-02f, 1.55883804e-01f, 2.09970158e-02f, -1.84664575e-04f, -1.60322040e-02f, 9.62198079e-02f, -3.80137525e-02f, -1.12178616e-01f, 1.85610838e-02f, 6.01066314e-02f,
  6.88662101e-03f, 8.03957041e-03f, 7.30361193e-02f, -2.63526700e-02f, 3.04946471e-02f, 6.01210631e-02f, -1.57935228e-02f, 1.48762697e-02f, 2.57678097e-03f, 3.77371255e-03f,
  -6.07406674e-03f, 4.95454222e-02f, -2.06445274e-03f, 6.94924593e-02f, -3.07293851e-02f, 4.56923880e-02f, 6.83966801e-02f, -3.26240957e-02f, 3.30266468e-02f, 2.02373751e-02f,
  -4.20151162e-04f, -3.15233618e-02f, -3.61565985e-02f, 1.79172785e-03f, -8.09686184e-02f, 6.91689551e-02f, -1.44846458e-02f, -1.08145820e-02f, -2.03342307e-02f, -6.74097538e-02f,
  -5.38584851e-02f, -1.92913730e-02f, -7.85249099e-02f, -2.07483745e-03f, 3.55279399e-03f, -6.13891594e-02f, -5.82127310e-02f, 1.86125915e-02f, 4.09089960e-02f, 6.43566772e-02f,
  -3.03627737e-02f, -1.00411717e-02f, -5.21983765e-03f, 3.01890913e-02f, -4.81305178e-03f, -5.28323203e-02f, -5.65144196e-02f, -2.08265558e-02f, 3.65523286e-02f, -1.19530195e-02f,
  2.04997789e-02f, 2.24019270e-02f, 5.48554817e-03f, -7.17864232e-03f, 2.37449668e-02f, -7.80770332e-02f, 3.37601826e-02f, 4.30519804e-02f, 7.67836571e-02f, 1.11211464e-03f,
  2.79751662e-02f, 2.46554743e-02f, -2.76309974e-03f, -4.67905076e-03f, -3.34614106e-02f, 5.78168407e-02f, 4.82167341e-02f, 1.82538275e-02f, 2.43975446e-02f, 4.21604812e-02f,
  -7.16541633e-02f, -2.63222437e-02f, -9.21628624e-03f, -2.66480222e-02f, 4.81939092e-02f, 5.01125259e-03f, 3.53026167e-02f, -4.68919612e-03f, 3.81696410e-02f, -7.22480426e-03f,
  4.52096492e-01f, -3.63888502e-01f, -1.88604549e-01f, 2.87910495e-02f, 3.22641969e-01f, -1.92499347e-02f, 2.44173005e-01f, -2.20365133e-02f, 5.61632067e-02f, -2.25482643e-01f,
  8.30133110e-02f, -5.47308028e-02f, 4.11733147e-03f, 8.16756114e-02f, 2.00254008e-01f, -6.43045455e-02f, 1.42132804e-01f, 5.31188510e-02f, -5.10987686e-03f, -7.96707720e-02f,
  -4.61317264e-02f, 1.20691836e-01f, -1.40054360e-01f, -1.03998341e-01f, 3.97217534e-02f, -1.63526759e-01f, -1.05923088e-02f, 7.01164920e-03f, -8.26552957e-02f, 3.32580358e-02f,
  1.12561010e-01f, 6.39518052e-02f, 4.56518605e-02f, -9.19938236e-02f, -1.00880656e-02f, 5.60124256e-02f, 4.27021086e-03f, -1.30184833e-02f, 6.08531386e-02f, -6.84159100e-02f,
  -5.30439019e-02f, -7.30149681e-03f, -4.56124060e-02f, 4.83299084e-02f, -4.33078893e-02f, -8.73446092e-03f, 9.52908583e-03f, 9.51553807e-02f, -2.31759027e-02f, -4.02498022e-02f,
  -6.49738386e-02f, -3.25212330e-02f, -6.23398460e-02f, -4.60822731e-02f, -8.71504005e-03f, -5.04269153e-02f, -1.16252890e-02f, -2.50290576e-02f, 2.33205650e-02f, -7.72848306e-03f,
  6.84336424e-02f, -5.13989218e-02f, -3.81310582e-02f, -8.83302186e-03f, -4.84108180e-02f, 2.82585602e-02f, 1.04513876e-02f, 1.48977470e-02f, -3.57492417e-02f, 3.94157507e-03f,
  -1.42794801e-02f, 5.43027297e-02f, -2.43835095e-02f, -1.00077782e-03f, 6.62976280e-02f, 5.32235242e-02f, -6.33720458e-02f, 2.59152390e-02f, -6.44079968e-03f, 2.03063395e-02f,
  5.81671717e-03f, 1.99711835e-03f, -2.81977318e-02f, -5.18367961e-02f, 7.27083394e-03f, -2.09798068e-02f, -6.10773871e-03f, -2.50286758e-02f, -1.25866262e-02f, 1.32932179e-02f,
  -6.73296452e-02f, -1.09547220e-01f, 9.02457861e-04f, 9.49697569e-03f, -4.55524474e-02f, -3.68503220e-02f, 4.47747335e-02f, 5.57321012e-02f, -7.82769844e-02f, 7.29907528e-02f,
  4.01538855e-04f, -3.01601999e-02f, 1.10498713e-02f, -2.30443552e-02f, 8.68842006e-03f, -2.48707198e-02f, -7.61380047e-02f, -9.38171223e-02f, 5.00473231e-02f, -2.81536933e-02f,
  -2.45094337e-02f, -6.92608133e-02f, 2.25904305e-02f, -5.10383397e-02f, 5.25974147e-02f, 1.91670954e-02f, 3.96195054e-02f, -3.89477462e-02f, -9.51701123e-03f, -6.19510338e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.13693532e-02f, 2.70573080e-01f, -6.02939352e-03f, 4.25886661e-02f, -1.16884515e-01f, -3.07646304e-01f, -1.58276424e-01f, -3.39041725e-02f, -5.26983142e-02f, 2.31872469e-01f,
  -1.58126503e-01f, 5.12130499e-01f, -1.78551257e-01f, -7.80161694e-02f, -4.87345487e-01f, -3.28356534e-01f, -1.11890025e-01f, 1.25428751e-01f, -9.57625508e-02f, 9.33354422e-02f,
  -1.08454831e-01f, -2.13377923e-01f, -1.12194233e-01f, 1.10350503e-02f, 7.61550292e-02f, 2.68020570e-01f, -1.40277864e-02f, -2.29234956e-02f, 1.29641339e-01f, -2.75723394e-02f,
  -4.01534438e-02f, 7.19015440e-03f, 1.10110849e-01f, 2.94819437e-02f, -9.92703289e-02f, 1.12029426e-01f, 3.88213284e-02f, -2.91242022e-02f, -2.57089771e-02f, -1.58685874e-02f,
  1.00683376e-01f, 1.21382158e-02f, 3.28514464e-02f, 1.39627866e-02f, 6.02326728e-02f, 9.36230347e-02f, 7.23799467e-02f, 3.04310787e-02f, 9.02761593e-02f, 3.33076417e-02f,
  6.60304576e-02f, 3.80241452e-03f, -2.87461318e-02f, 1.03745535e-02f, -1.79183912e-02f, -4.45471257e-02f, -2.50718910e-02f, 3.47742997e-02f, 9.76398811e-02f, 7.17131868e-02f,
  -4.73332442e-02f, -5.96808195e-02f, 2.29692971e-03f, 8.50001946e-02f, -4.16009501e-03f, 3.94467302e-02f, 1.46665294e-02f, 2.99614426e-02f, 4.02857289e-02f, -7.20723867e-02f,
  1.94886774e-02f, 9.88918468e-02f, -1.82727482e-02f, -4.52525318e-02f, -8.37808102e-02f, 6.55890480e-02f, -3.52062471e-02f, 1.21730454e-02f, -3.62592191e-02f, 1.07963113e-02f,
  -1.75174139e-02f, 2.95087099e-02f, -7.02251447e-03f, 1.09121442e-01f, -7.50630274e-02f, -3.99323851e-02f, 2.22037155e-02f, 1.67392101e-02f, 2.69819591e-02f, -5.54966368e-02f,
  -1.87224507e-01f, -1.55658588e-01f, -2.26784069e-02f, 5.26294746e-02f, 6.47893474e-02f, -1.77141502e-02f, -2.09067594e-02f, 2.29619201e-02f, -5.58228791e-02f, 6.69706729e-04f,
  3.22477035e-02f, -1.17465900e-02f, 2.44065467e-02f, -1.08837085e-02f, -5.26519977e-02f, -1.41801694e-02f, -5.19320630e-02f, -4.34374064e-02f, -3.86912301e-02f, 5.06780148e-02f,
  5.75265624e-02f, 2.04093438e-02f, 4.20112945e-02f, -5.92195429e-02f, -2.45325547e-02f, 3.66333574e-02f, 2.70513985e-02f, 1.12361349e-01f, -1.82110891e-02f, -5.51433712e-02f,
  -1.15644909e-01f, -3.74677777e-02f, 2.22603157e-02f, -2.93718837e-02f, 2.65116431e-02f, -4.70051691e-02f, 5.97283766e-02f, -3.76780145e-02f, 4.62368280e-02f, -3.50250974e-02f,
  -4.73178215e-02f, -6.53464049e-02f, 3.07341572e-02f, -8.63617584e-02f, 4.65425588e-02f, -1.16824498e-02f, 5.43654338e-02f, -5.22105023e-02f, 4.50717881e-02f, -4.83049937e-02f,
  -6.15582131e-02f, 1.13822110e-01f, -8.31029266e-02f, 3.98085490e-02f, -5.08804061e-02f, -1.94797739e-02f, 1.25430807e-01f, -6.70527071e-02f, 9.29548778e-03f, 2.03435905e-02f,
  4.35838737e-02f, 1.24669299e-01f, -4.03282270e-02f, 5.93893556e-03f, -9.65783522e-02f, -6.44854456e-02f, -2.93786582e-02f, -3.09261605e-02f, 6.58623949e-02f, 5.85021861e-02f,
  -2.80102529e-02f, 2.31784359e-02f, 6.30062148e-02f, -6.58032671e-02f, -6.86829351e-03f, 1.22019842e-01f, 1.55320682e-03f, 1.18358366e-01f, 8.73303041e-02f, 5.91137214e-03f,
  -9.24039725e-03f, 6.20866381e-02f, -7.43627027e-02f, 9.87194711e-04f, 7.11557716e-02f, 1.88309867e-02f, -3.36336009e-02f, 4.45364416e-02f, 7.56597146e-02f, -3.20763774e-02f,
  6.21513613e-02f, -1.63714439e-01f, 2.84208450e-02f, 1.91011485e-02f, -2.38165595e-02f, -3.46756354e-02f, -4.34428453e-02f, -1.14215374e-01f, -1.60008147e-02f, -2.60660369e-02f,
  7.49083683e-02f, 3.57614309e-02f, -9.50352475e-02f, -3.65823619e-02f, 4.29421701e-02f, 6.36964291e-02f, 5.61874025e-02f, 2.29425002e-02f, 4.01678234e-02f, -1.83089804e-02f,
  1.22117989e-01f, -5.73401786e-02f, -3.03128455e-02f, -3.71534415e-02f, -1.03324518e-01f, 1.78909451e-02f, -6.49451688e-02f, -4.51307092e-03f, 7.94240460e-02f, 4.65905182e-02f,
  5.05403280e-02f, 1.47710845e-01f, 1.04001239e-01f, 8.63914639e-02f, 2.56489776e-02f, -2.97448505e-02f, -6.60071373e-02f, -5.24341948e-02f, 8.31019208e-02f, 8.23585168e-02f,
  -1.09712789e-02f, -3.63371223e-02f, -3.44392471e-02f, -1.11568552e-02f, -1.33822769e-01f, -8.56113136e-02f, 8.81939456e-02f, 9.66448784e-02f, 6.42995313e-02f, 2.88719926e-02f,
  -4.71478179e-02f, -9.20131803e-02f, 6.70734867e-02f, -6.29861802e-02f, -3.19703668e-02f, 1.16231225e-01f, -1.42479679e-02f, 2.07724120e-03f, -1.87705997e-02f, -2.50553265e-02f,
  -1.48225561e-01f, 1.95506439e-01f, -7.90350437e-02f, -5.17544784e-02f, -6.54974878e-02f, 2.40786538e-01f, 2.13515118e-01f, 3.60832252e-02f, 1.05455965e-02f, 1.91638917e-01f,
  -5.11465482e-02f, -6.76494837e-02f, 8.44959468e-02f, -7.05515826e-03f, 6.23384640e-02f, 2.16327738e-02f, 1.54759318e-01f, 1.65017575e-01f, -1.23377539e-01f, 5.74551374e-02f,
  -7.69913718e-02f, 9.40518156e-02f, -1.78152218e-01f, 2.70225815e-02f, -1.07555114e-01f, -1.45375937e-01f, -2.64876466e-02f, -1.77971289e-01f, -7.76480958e-02f, -5.47695495e-02f,
  2.77770683e-02f, -2.66580526e-02f, 1.46001056e-01f, -8.21922943e-02f, 5.44175208e-02f, 2.17992738e-02f, -6.28154948e-02f, -1.06998518e-01f, -4.18968219e-03f, 6.50839657e-02f,
  7.09992722e-02f, 4.47836369e-02f, 5.97255267e-02f, 7.04355761e-02f, -6.05189502e-02f, 1.00571709e-03f, 3.75613347e-02f, -8.14351737e-02f, -1.65978745e-02f, 8.89032483e-02f,
  -5.56921773e-02f, 1.65674463e-02f, -6.00934736e-02f, 1.95687134e-02f, -8.22444931e-02f, -7.80968834e-03f, 4.62191962e-02f, -8.16770867e-02f, 5.39618731e-02f, 5.19921705e-02f,
  2.17105239e-03f, 8.96259174e-02f, 2.31715981e-02f, 3.26333381e-02f, -1.26429172e-02f, 5.79482056e-02f, 2.50733830e-02f, 5.83303384e-02f, -1.24451086e-01f, -4.05308791e-02f,
  5.20242788e-02f, 5.61077567e-03f, 2.36021192e-03f, 6.83301538e-02f, -4.45036069e-02f, 7.53668174e-02f, 2.57488228e-02f, -1.19690578e-02f, 2.51033697e-02f, -1.03355234e-03f,
  3.67827117e-02f, -4.75402623e-02f, 8.75645727e-02f, 2.34134658e-03f, 4.73957807e-02f, -7.73572102e-02f, 2.07728539e-02f, -7.39448657e-03f, 8.39771423e-03f, 3.82203981e-02f,
  1.53553978e-01f, -5.48423417e-02f, -4.93428893e-02f, 4.92161252e-02f, 1.40825007e-02f, 3.15691531e-03f, -1.22715924e-02f, -7.78636485e-02f, -6.72653466e-02f, 1.41422835e-03f,
  -1.59149547e-03f, -3.55205983e-02f, -8.34720582e-03f, -4.63425443e-02f, -5.09641580e-02f, -7.21788267e-03f, 5.60855381e-02f, -8.19016844e-02f, 1.99284777e-02f, -2.20048074e-02f,
  5.31220101e-02f, 1.60651486e-02f, 7.68347159e-02f, 7.97064006e-02f, 1.00959316e-01f, 6.77692667e-02f, -1.06532335e-01f, -4.03125683e-04f, 2.58610807e-02f, -1.42368218e-02f,
  7.67584518e-02f, -9.32768434e-02f, 1.04738913e-01f, 5.93601689e-02f, 9.03759450e-02f, -2.85357237e-02f, 6.84028342e-02f, 6.53114542e-02f, 1.85938761e-01f, -6.55022566e-04f,
  -9.99847725e-02f, -1.09148286e-01f, -6.98457956e-02f, -6.78497851e-02f, 7.84823596e-02f, -7.96892568e-02f, -2.87030954e-02f, -7.52292713e-03f, 1.00096866e-01f, -2.65566800e-02f,
  6.29037321e-02f, -1.76196806e-02f, 8.86425152e-02f, 4.15867008e-02f, 2.76846476e-02f, 1.47417346e-02f, -4.49128225e-02f, 7.25305313e-03f, -2.64200866e-02f, -6.17481507e-02f,
  -1.80638544e-02f, 4.62649725e-02f, -1.20433435e-01f, 6.14403337e-02f, 5.15545979e-02f, 2.72659841e-03f, -1.09078206e-01f, 7.38194734e-02f, -7.25967390e-03f, -6.08771406e-02f,
  -1.19451858e-01f, -2.39558257e-02f, -2.17944314e-03f, -1.84716601e-02f, 9.40493941e-02f, -3.27750854e-02f, -5.08058742e-02f, -2.96865292e-02f, 2.69465614e-02f, 5.90184517e-03f,
  7.91083276e-02f, -2.94804275e-02f, 7.77223557e-02f, 4.64317501e-02f, -9.77557674e-02f, 2.75403243e-02f, -4.75921817e-02f, 2.54544634e-02f, -1.02625294e-02f, 1.92133952e-02f,
  -6.38515279e-02f, -1.01167625e-02f, 3.06592602e-02f, 1.01804875e-01f, 3.21740774e-03f, -5.72366931e-04f, 5.27317859e-02f, 2.31904592e-02f, 9.52718779e-02f, -4.83621936e-03f,
  7.35169873e-02f, 5.63466065e-02f, 1.97370965e-02f, 5.60198501e-02f, 8.61747283e-03f, 4.23192903e-02f, 6.04440235e-02f, -8.11169297e-02f, 2.36748420e-02f, 3.55243571e-02f,
  5.37944064e-02f, -5.86078353e-02f, 6.24049194e-02f, 1.12253778e-01f, 3.33696045e-02f, 3.26149352e-02f, -1.04007915e-01f, -1.04914028e-02f, 9.09444038e-03f, 7.99654275e-02f,
  -1.38611738e-02f, -8.82818103e-02f, -5.56581840e-02f, -6.27948567e-02f, 5.17216995e-02f, -5.57798110e-02f, 6.38876855e-02f, -3.06135621e-02f, -5.47991544e-02f, -4.28523961e-03f,
  -6.40522763e-02f, 4.95334640e-02f, 1.29522858e-02f, 2.60575600e-02f, -3.54327634e-02f, 1.18546523e-01f, 3.69749479e-02f, -4.95979823e-02f, -3.16759832e-02f, 8.78216885e-03f,
  2.79337242e-02f, -4.38858904e-02f, -3.43668684e-02f, 1.52394176e-02f, 1.92935276e-03f, 1.80034917e-02f, -9.54044610e-02f, -1.06292829e-01f, -2.16815919e-02f, -3.98250334e-02f,
  5.10427132e-02f, -2.53600092e-03f, 8.45210254e-02f, -2.73566786e-02f, -4.98670936e-02f, -1.21558299e-02f, -6.14999905e-02f, 3.33785154e-02f, -1.24100395e-01f, -3.34017128e-02f,
  -1.00015551e-02f, 3.74728628e-02f, 7.81682879e-02f, 7.14697689e-02f, -2.88112964e-02f, -4.29713912e-03f, -4.13126312e-02f, 3.44731733e-02f, -4.82568443e-02f, -5.10629602e-02f,
  -1.03159938e-02f, -9.73786339e-02f, -5.75889833e-02f, -1.46816047e-02f, 6.49372488e-02f, -9.08798259e-03f, -8.67647752e-02f, 1.80040742e-03f, 3.94390710e-03f, -9.04424265e-02f,
  -7.73615614e-02f, -9.79771391e-02f, -9.01807025e-02f, -1.73166282e-02f, -1.97552703e-02f, -1.80676486e-02f, -4.89172041e-02f, -6.44267052e-02f, -6.64522573e-02f, 4.86831032e-02f,
  6.62792325e-02f, -5.15555404e-03f, -4.45779823e-02f, -9.92181450e-02f, 1.01601027e-01f, 4.93792258e-02f, 4.64864746e-02f, 4.10028128e-03f, 6.29665889e-03f, -5.42963408e-02f,
  -1.23856566e-03f, -5.65771647e-02f, 1.71824265e-02f, 4.73082624e-02f, -3.68833914e-02f, -3.92873921e-02f, -2.97816247e-02f, -5.59482388e-02f, 8.34005103e-02f, -4.76247370e-02f,
  8.98270831e-02f, -5.15790805e-02f, 1.93097871e-02f, -8.61616582e-02f, -3.85695584e-02f, -1.26528759e-02f, -1.12725519e-01f, 3.53276581e-02f, 6.34862855e-02f, -9.22348201e-02f,
  -2.03651795e-03f, 2.16399692e-02f, 1.33772660e-02f, 7.72801414e-02f, 6.23963587e-02f, 8.96276757e-02f, -6.67747632e-02f, -4.86433357e-02f, 9.07340869e-02f, -7.01791942e-02f,
  -5.89711629e-02f, -2.89108455e-02f, 3.91691625e-02f, 1.04675651e-01f, -6.82130605e-02f, -3.69836316e-02f, -8.26006755e-02f, -1.16677135e-02f, -3.38936001e-02f, -2.68849488e-02f,
  -1.17060758e-01f, -1.12557366e-01f, -1.03545293e-01f, -7.14294612e-02f, -1.76087972e-02f, 3.71785499e-02f, -2.76921447e-02f, 8.34614709e-02f, -5.66538656e-03f, -4.19698134e-02f,
  3.16326283e-02f, -6.66377917e-02f, 9.10660028e-02f, 1.65483952e-02f, 2.05320567e-02f, 3.91274095e-02f, 2.27200706e-02f, 5.68389818e-02f, -3.86020318e-02f, 5.98641261e-02f,
  8.78363028e-02f, -5.83336279e-02f, 5.09834252e-02f, 5.80906197e-02f, -6.29568994e-02f, 4.36140932e-02f, 1.35393860e-03f, -1.59876961e-02f, -1.50659755e-02f, 6.10417835e-02f,
  -3.84278148e-01f, 1.68118000e-01f, 1.01471148e-01f, -3.20927054e-01f, 1.20258138e-01f, 5.11186011e-02f, 3.06161549e-02f, 1.99475318e-01f, -1.20604776e-01f, 1.08247213e-02f,
  -1.28424149e-02f, -2.07482800e-01f, 1.77173644e-01f, -1.27898693e-01f, -2.82168210e-01f, -6.45316169e-02f, -4.87275533e-02f, -3.74224670e-02f, 6.26180321e-02f, -4.70166132e-02f,
  -1.24690291e-02f, 1.01340860e-02f, -5.57795819e-03f, 2.28950247e-01f, 8.85707960e-02f, 1.01428494e-01f, 2.84550507e-02f, 1.34568855e-01f, -5.12737744e-02f, 2.98189279e-02f,
  -8.93430114e-02f, -5.95540032e-02f, 7.46092796e-02f, -1.31173444e-03f, -4.65664864e-02f, 1.15341507e-01f, -7.68080577e-02f, -1.09527893e-01f, -4.30183671e-02f, 3.46018299e-02f,
  -6.41331375e-02f, 5.09373769e-02f, -5.42543903e-02f, 1.69877838e-02f, 1.37269888e-02f, -5.07954434e-02f, -5.15334308e-02f, -9.53810960e-02f, 7.00451341e-03f, 1.05789460e-01f,
  2.86814980e-02f, 4.14363928e-02f, 4.52756621e-02f, -7.18534961e-02f, -5.96443266e-02f, -2.60222219e-02f, -8.21582600e-02f, -4.02753428e-02f, 1.14377274e-03f, -8.49446207e-02f,
  2.67486908e-02f, -7.11217076e-02f, 6.48118258e-02f, -2.07934063e-02f, 6.75792918e-02f, -7.71267712e-02f, -2.64447723e-02f, 2.56190132e-02f, 2.05425415e-02f, 6.18502777e-03f,
  -7.89706782e-02f, 1.97962895e-02f, 5.72423004e-02f, 1.21279899e-02f, 5.48625886e-02f, -3.29566970e-02f, 6.89837337e-02f, -1.88111998e-02f, -2.00676341e-02f, 2.47614309e-02f,
  -3.36760245e-02f, -1.14114368e-02f, -1.19532589e-02f, -4.51233909e-02f, 7.44733512e-02f, 4.23985980e-02f, 6.67549297e-02f, -9.11752582e-02f, -5.19331917e-02f, 9.89769101e-02f,
  -3.42136808e-02f, -1.72509611e-01f, 8.08318183e-02f, 1.38435920e-03f, -5.15139773e-02f, -2.57312842e-02f, -1.75131764e-02f, 2.19793394e-02f, 2.08374821e-02f, 5.41400388e-02f,
  9.48778689e-02f, -4.17049117e-02f, -1.10029113e-02f, 3.64010520e-02f, 6.11233301e-02f, 6.05024770e-02f, 3.19606848e-02f, 2.87317764e-02f, -2.17951275e-02f, -1.72179695e-02f,
  7.99934119e-02f, 5.37761115e-02f, -5.93881607e-02f, 9.93330032e-02f, 7.79409260e-02f, 4.72534895e-02f, 1.37071218e-03f, -2.20489874e-02f, 2.58787666e-02f, -8.71206373e-02f,
  3.32961343e-02f, -1.23679571e-01f, -4.01335619e-02f, 5.22125550e-02f, -6.23528771e-02f, -6.72162026e-02f, -7.64293075e-02f, -5.27272373e-02f, 5.75214736e-02f, -4.04264480e-02f,
  -5.82277067e-02f, -7.96015933e-02f, 7.14176744e-02f, -5.02827615e-02f, 8.04536343e-02f, -7.33050257e-02f, -5.30778617e-03f, 4.10985649e-02f, -5.68945184e-02f, -8.33641291e-02f,
  2.23825090e-02f, 3.48905399e-02f, -1.20768748e-01f, -1.38821200e-01f, 3.64003293e-02f, -2.08322555e-02f, -2.87330244e-02f, -5.43533117e-02f, 2.71040890e-02f, -4.61508818e-02f,
  -3.02844290e-02f, -4.31617834e-02f, 5.32058664e-02f, -1.54248253e-02f, 7.54856244e-02f, 4.92071547e-02f, 7.48083517e-02f, 7.23402053e-02f, -6.42134100e-02f, -9.21677146e-03f,
  9.03160200e-02f, -5.27913012e-02f, 5.17096147e-02f, 9.05286521e-02f, -1.11729130e-02f, -3.07659339e-02f, 3.98327410e-03f, 7.68298134e-02f, 7.46133998e-02f, -1.27487127e-02f,
  -4.13369723e-02f, 3.85709591e-02f, 2.56544743e-02f, 2.43403874e-02f, -2.68161688e-02f, 1.54313147e-02f, -2.67121159e-02f, 3.67860422e-02f, -3.98210883e-02f, 7.05992281e-02f,
  2.37399191e-02f, -4.83410582e-02f, -1.03753852e-02f, -1.39625659e-02f, -5.07925972e-02f, 3.02704945e-02f, 5.61551228e-02f, -6.49423078e-02f, 1.55015383e-02f, -3.13125923e-02f,
  3.17424834e-02f, -4.69031781e-02f, -1.08589104e-03f, -4.79880460e-02f, 3.81839909e-02f, 4.95660119e-02f, -3.69541376e-04f, -6.76560178e-02f, 4.69737761e-02f, -2.47393805e-03f,
  2.95833722e-02f, -6.32206798e-02f, -5.47200479e-02f, -5.94934188e-02f, -1.96932014e-02f, 8.82207789e-03f, -1.65021978e-02f, 1.23693896e-02f, -5.41685559e-02f, 6.26054257e-02f,
  8.50322917e-02f, 4.22769971e-02f, -1.59218404e-02f, 2.80373394e-02f, -1.16976434e-02f, 9.73669887e-02f, -8.98393020e-02f, 2.07292587e-02f, 6.62256777e-02f, -5.16137630e-02f,
  -7.32411593e-02f, -5.39231598e-02f, -4.07432169e-02f, -4.29789089e-02f, -4.70697321e-02f, -4.23322096e-02f, -5.05013280e-02f, -6.16431572e-02f, -5.52118830e-02f, -8.90840869e-03f,
  4.16018255e-02f, 7.60248229e-02f, -3.60049531e-02f, -3.56536470e-02f, -8.61394927e-02f, 6.07532002e-02f, 1.86336541e-03f, 4.38346490e-02f, -7.39018247e-03f, -4.71569598e-02f,
  -1.90362617e-01f, 8.97792280e-02f, -2.00938098e-02f, -2.30438516e-01f, 2.60747727e-02f, 1.36520555e-02f, -6.24559335e-02f, 1.11872211e-01f, -7.31290430e-02f, 1.38601273e-01f,
  -2.17621382e-02f, -1.17231809e-01f, 3.94200459e-02f, -2.50014573e-01f, -2.16538355e-01f, -1.93703502e-01f, -2.45099962e-01f, -1.66114971e-01f, -1.07465163e-01f, -8.36694092e-02f,
  -1.64104432e-01f, -9.48815197e-02f, -7.28009120e-02f, 1.61556780e-01f, 3.06200329e-02f, 1.21214576e-01f, -3.60397659e-02f, 1.98071480e-01f, 9.46026936e-04f, -2.17294879e-02f,
  7.89998621e-02f, 1.24682665e-01f, 1.32637918e-01f, 6.41928986e-02f, 1.18845247e-01f, -3.79747078e-02f, 7.95626175e-03f, 5.97408786e-02f, -1.22715756e-02f, -3.50502990e-02f,
  -1.45005453e-02f, 2.92820279e-02f, -5.27196899e-02f, 3.43606882e-02f, 4.10591587e-02f, -1.12911817e-02f, -9.19476599e-02f, 3.58316489e-02f, 9.52845290e-02f, 4.39427719e-02f,
  -7.01877698e-02f, 2.68978328e-02f, 2.79628462e-03f, -6.91450313e-02f, -1.65990926e-02f, 3.81610589e-03f, -7.84348547e-02f, -7.70395100e-02f, -1.17814029e-02f, -4.68880534e-02f,
  9.66169965e-03f, 1.22862598e-02f, 4.39694077e-02f, 7.65198469e-02f, 4.56531793e-02f, 3.95673662e-02f, 9.98488907e-03f, -6.67241216e-02f, -3.57817300e-02f, 2.85362806e-02f,
  -1.81727149e-02f, 2.44497452e-02f, -7.25633353e-02f, -1.13387108e-02f, -1.44066224e-02f, -2.98293978e-02f, -6.08738177e-02f, -2.14136802e-02f, 1.08158225e-02f, 1.39483903e-02f,
  2.26795115e-02f, -1.35904282e-01f, 8.58432800e-02f, 2.49648523e-02f, 5.41663133e-02f, 2.53656432e-02f, 4.30281982e-02f, 5.46340756e-02f, 7.74495013e-04f, -6.62171394e-02f,
  -5.79618774e-02f, -1.96607877e-02f, 4.51931059e-02f, -2.25638878e-02f, -3.83093790e-03f, 6.84916750e-02f, -3.83540802e-02f, 2.49223467e-02f, 2.38586497e-02f, 6.76648915e-02f,
  3.12111480e-03f, 4.58237007e-02f, 3.90314274e-02f, -6.75705224e-02f, 1.09760491e-02f, -5.07663675e-02f, -4.79634590e-02f, 5.99703705e-03f, 8.66272599e-02f, -1.06931934e-02f,
  7.42461439e-03f, -2.57127872e-03f, -8.10221434e-02f, -3.64143960e-02f, 5.74494898e-02f, 1.61401350e-02f, 4.46608327e-02f, -2.98145041e-02f, -3.58116105e-02f, 4.50577848e-02f,
  -6.31941557e-02f, -3.06274235e-01f, -2.67465562e-01f, 4.49526422e-02f, 1.38698041e-01f, 2.97398004e-03f, -8.18850547e-02f, -2.60548526e-03f, -9.59697738e-02f, 1.43075526e-01f,
  4.45403829e-02f, -2.20642418e-01f, -2.82343119e-01f, -3.10579807e-01f, -2.20627546e-01f, -3.20320517e-01f, -1.52269736e-01f, -7.81474784e-02f, -9.82513875e-02f, 1.56035153e-02f,
  1.08579053e-02f, 8.14779568e-03f, -1.32232219e-01f, 2.52355069e-01f, 7.83196688e-02f, 2.57833511e-01f, 4.16576058e-01f, 3.61378212e-03f, 1.17454164e-01f, -6.74071759e-02f,
  -4.01058681e-02f, -1.75291538e-01f, -6.78520277e-02f, -3.92606109e-02f, 1.26661509e-01f, 5.03358617e-02f, 1.01662152e-01f, 3.35665941e-02f, 2.74195429e-02f, -5.06316237e-02f,
  -4.36244160e-03f, 1.53264552e-02f, -6.28608093e-02f, 6.37483671e-02f, 2.92505845e-02f, -1.91994980e-02f, -5.68890348e-02f, -3.89147252e-02f, -3.56875244e-04f, -1.61162108e-01f,
  -6.65544346e-02f, 9.43219662e-03f, 9.31460876e-04f, 2.05948185e-02f, -3.19397226e-02f, -4.39180620e-02f, 1.04811899e-01f, 8.59920233e-02f, -1.17793903e-02f, 6.51782006e-02f,
  6.32184371e-02f, 3.30846384e-02f, -5.57307862e-02f, -8.46711025e-02f, -2.71586925e-02f, -5.15098237e-02f, -5.50166704e-02f, 8.74062162e-03f, -3.81242707e-02f, 6.20603329e-03f,
  -3.21607925e-02f, 3.04932464e-02f, -1.23026140e-01f, 6.18836209e-02f, 2.59912536e-02f, -4.53745574e-03f, 6.33508526e-03f, -2.49071494e-02f, 3.36854048e-02f, -1.12143569e-02f,
  2.58411691e-02f, 3.78843807e-02f, 3.15306596e-02f, 9.59044416e-03f, -1.86043438e-02f, 4.86176796e-02f, 7.78240263e-02f, -4.92553189e-02f, 9.01418626e-02f, 3.64856347e-02f,
  -4.74015076e-04f, 1.19044974e-01f, 5.44178486e-02f, 8.59097578e-03f, -2.17215735e-02f, -1.42462719e-02f, -1.75528899e-01f, -1.04594111e-01f, -8.73496849e-03f, -4.85627875e-02f,
  1.53944865e-01f, 7.15693682e-02f, -9.43856034e-03f, 2.23415457e-02f, -3.01738363e-02f, -9.04195756e-02f, 4.29734401e-02f, 8.87618810e-02f, 1.02060728e-01f, 2.37843748e-02f,
  5.91179132e-02f, 3.14790234e-02f, -4.45224606e-02f, 1.45514095e-02f, 1.28992185e-01f, 1.54780030e-01f, 2.26815534e-03f, 8.08735788e-02f, -2.93205399e-02f, -1.05426535e-01f,
  -3.84129822e-01f, -2.46167168e-01f, -5.45507610e-01f, -1.53576612e-01f, -1.74276188e-01f, -5.03726661e-01f, -3.58555526e-01f, -1.33135885e-01f, 3.63880768e-02f, 7.40027726e-02f,
  5.86242117e-02f, -1.24392711e-01f, 1.47621810e-01f, -2.07459137e-01f, -1.07659250e-01f, 1.86995581e-01f, -3.50383162e-01f, -1.84627771e-01f, 3.50050107e-02f, -2.59992063e-01f,
  -2.78101675e-03f, -1.60309374e-02f, -2.19686747e-01f, 4.70890803e-03f, -2.82430500e-01f, -3.53027172e-02f, 1.48123443e-01f, -6.54206574e-02f, -3.74739096e-02f, 1.04107214e-02f,
  -1.06834903e-01f, 1.27837598e-01f, -4.48590703e-02f, -4.19557095e-02f, -4.68979813e-02f, -7.89936185e-02f, -9.71350148e-02f, 7.14246109e-02f, 8.10228512e-02f, -6.34878203e-02f,
  2.41997782e-02f, 4.97742044e-03f, 2.16483809e-02f, 8.00419077e-02f, -4.90408614e-02f, 5.40024079e-02f, -6.29741848e-02f, -8.94111395e-02f, 1.12134768e-02f, -6.58224970e-02f,
  -4.79051806e-02f, -1.65653918e-02f, -9.21829268e-02f, 6.86291978e-02f, -2.67091040e-02f, -1.23798437e-02f, 4.60970588e-02f, 5.38121536e-02f, -6.61290884e-02f, -4.28518057e-02f,
  -1.03755221e-01f, 6.12508617e-02f, 3.09800953e-02f, -7.04949275e-02f, 1.44569445e-02f, -4.48042266e-02f, 5.41862147e-03f, 3.79812717e-02f, -1.25563182e-02f, 3.12142516e-03f,
  -6.86138794e-02f, -1.67491250e-02f, -2.54847705e-02f, -4.71363179e-02f, -4.82484177e-02f, -4.72508110e-02f, 9.52448547e-02f, -2.09180098e-02f, -5.62483594e-02f, 5.49420528e-03f,
  1.14737041e-01f, -1.12269130e-02f, 6.28084764e-02f, -3.82445119e-02f, 2.75538843e-02f, 6.34094551e-02f, -1.60535891e-02f, -9.35242418e-03f, 3.53251323e-02f, -2.03130729e-02f,
  -1.33058906e-01f, -2.05367655e-01f, 5.29392771e-02f, 2.55564600e-02f, 4.55182604e-02f, -3.33916955e-02f, -9.99697670e-03f, -2.05515791e-02f, -1.00590467e-01f, -5.38355485e-02f,
  -6.79279566e-02f, 3.58605906e-02f, -1.45963416e-01f, 2.64478121e-02f, 6.56058192e-02f, -2.08194219e-02f, 2.82856580e-02f, 3.58776301e-02f, -9.41712931e-02f, -1.37206365e-03f,
  -2.20455024e-02f, 5.16063021e-03f, 9.49929655e-02f, -4.61716764e-03f, 3.81550454e-02f, -1.59699209e-02f, -4.54747602e-02f, -6.10112166e-03f, 2.01440370e-03f, -5.77107705e-02f,
  5.28200455e-02f, 4.82500112e-03f, 1.44910282e-02f, -1.16234664e-02f, 5.33438511e-02f, -4.21438292e-02f, 8.01282451e-02f, 1.63596105e-02f, -5.52498922e-02f, -1.35515500e-02f,
  6.48498116e-03f, -2.60098204e-02f, 7.91857466e-02f, -2.59662722e-03f, 2.11836025e-01f, 1.01298548e-01f, 1.31817549e-01f, 1.18962377e-01f, -8.01036656e-02f, 3.31006460e-02f,
  3.32010537e-02f, 3.61690880e-03f, 9.40609872e-02f, -2.13916488e-02f, -1.57427695e-02f, -4.36462276e-02f, -1.33707169e-02f, 3.69505323e-02f, 8.23258683e-02f, -5.15654916e-03f,
  6.57629892e-02f, -1.48883299e-03f, 4.67348807e-02f, -2.34067952e-03f, -5.47045134e-02f, 3.43467831e-03f, -6.02155365e-02f, 1.67406872e-02f, 7.82225952e-02f, -6.66084588e-02f,
  5.45027331e-02f, 5.24350703e-02f, 3.37148295e-03f, 6.21426255e-02f, 3.00235767e-02f, -2.49684267e-02f, -5.93711399e-02f, -9.84761566e-02f, 6.31706342e-02f, 5.56913652e-02f,
  2.33015604e-02f, 6.03100471e-02f, 9.42529142e-02f, -4.11589220e-02f, 4.49668169e-02f, 6.54776469e-02f, -1.01792077e-02f, -1.99102107e-02f, 2.55765133e-02f, 7.80419959e-03f,
  9.06983204e-03f, -7.83515647e-02f, -1.41188297e-02f, -7.59367123e-02f, 8.17237515e-03f, 1.77454855e-02f, 8.17768276e-02f, 6.45596161e-02f, 1.15742106e-02f, 6.32937485e-03f,
  -8.96984562e-02f, 8.71624127e-02f, -3.51179503e-02f, 2.45287586e-02f, -5.74163869e-02f, -9.41152684e-03f, 2.62423251e-02f, -5.59355728e-02f, -1.79623011e-02f, 8.00939798e-02f,
  9.78189707e-03f, 8.97282735e-02f, -3.65385376e-02f, 5.37665598e-02f, 6.52795332e-03f, -5.80430441e-02f, 9.43433202e-04f, 5.33129554e-03f, 8.09465200e-02f, 2.22539753e-02f,
  -6.24215007e-02f, -3.16892229e-02f, -3.13342921e-02f, 2.10187398e-02f, 5.00700399e-02f, 1.38965175e-02f, -2.81444024e-02f, -1.30373957e-02f, -5.37261404e-02f, 7.80211575e-03f,
  -2.30249166e-02f, -2.96060238e-02f, 3.82499471e-02f, -9.18606818e-02f, 1.71024185e-02f, -5.87533824e-02f, 5.60750552e-02f, 7.76785240e-02f, -2.75442898e-02f, 3.82694341e-02f,
  -7.13719055e-02f, 9.11018327e-02f, 6.00589104e-02f, -7.23278597e-02f, -4.73224558e-02f, 1.93036832e-02f, 2.87543163e-02f, 4.19631489e-02f, 6.60354123e-02f, 5.01780212e-02f,
  2.14703251e-02f, 8.07145238e-02f, 9.36930627e-02f, 2.05590382e-01f, -6.32096361e-03f, -4.48747724e-01f, -4.35366213e-01f, 2.26627812e-02f, 3.54317613e-02f, -1.13485672e-01f,
  -9.76968035e-02f, 2.48685312e-02f, -2.48086117e-02f, 1.82242482e-03f, 9.77840796e-02f, 6.17841666e-04f, -1.39155298e-01f, -1.83967054e-01f, 1.33372769e-01f, 1.22866206e-01f,
  1.54009536e-01f, 5.04109636e-02f, 2.48018399e-01f, 1.08151011e-01f, 7.61786103e-02f, 1.72929019e-01f, 3.63380641e-01f, 7.19603151e-02f, 3.12195928e-03f, -3.13798636e-02f,
  4.08840813e-02f, 1.00265585e-01f, 5.92797920e-02f, 3.82241793e-02f, 1.64900417e-03f, -6.15425818e-02f, -3.15451734e-02f, -7.69100785e-02f, -4.12185714e-02f, 2.42521632e-02f,
  -2.87823789e-02f, 7.19898343e-02f, -4.86511216e-02f, 5.43460548e-02f, -4.05485183e-02f, 5.77659020e-03f, -1.96671151e-02f, 2.76372228e-02f, 2.22367086e-02f, 3.00966054e-02f,
  -2.63253488e-02f, 2.30911598e-02f, -2.26688702e-02f, 2.44664233e-02f, 1.31953531e-03f, 1.95118207e-02f, -5.05597033e-02f, -1.61693450e-02f, 6.74473122e-02f, -1.19077554e-02f,
  6.65666983e-02f, 6.20784350e-02f, -1.98270679e-02f, -7.45190457e-02f, 4.55193743e-02f, 2.55500525e-02f, -3.04236077e-02f, 3.61518599e-02f, 5.46540022e-02f, 6.17016368e-02f,
  1.93858109e-02f, 3.74304615e-02f, 1.21435837e-03f, -3.00114248e-02f, 5.26472088e-03f, 5.37431873e-02f, 2.81436311e-04f, 2.51453202e-02f, -4.77617197e-02f, 8.06557164e-02f,
  5.82144372e-02f, 2.32831249e-03f, 1.76203996e-02f, -5.52425049e-02f, 5.58913834e-02f, 3.79907675e-02f, 1.44677227e-02f, 8.54100361e-02f, 5.03162704e-02f, -7.37318620e-02f,
  2.59002615e-02f, 3.24735373e-01f, -3.07007693e-02f, -8.52244869e-02f, 7.57298619e-02f, -2.57743392e-02f, 1.42453145e-02f, -9.02693346e-02f, 4.60224301e-02f, -4.28122357e-02f,
  3.12873498e-02f, 3.01366877e-02f, 1.69106442e-02f, 3.41692218e-03f, -4.85913493e-02f, -8.12025741e-03f, 1.30543947e-01f, 1.75256059e-02f, 7.85831213e-02f, 8.72652605e-03f,
  3.22208852e-02f, -1.53636206e-02f, 3.30412835e-02f, 2.90496391e-03f, 2.68628895e-02f, 6.32951558e-02f, 7.73917884e-04f, -4.98966798e-02f, 5.91928326e-03f, -2.49536522e-02f,
  5.91820069e-02f, -5.16186841e-02f, -6.99825063e-02f, -4.13326509e-02f, -3.37780491e-02f, -3.33011746e-02f, -3.43098529e-02f, 3.77252400e-02f, -4.25623208e-02f, 1.31011158e-01f,
  -2.06319243e-02f, 3.81279327e-02f, -4.89945188e-02f, -9.29267928e-02f, 1.14884060e-02f, -7.20708026e-03f, -3.40259671e-02f, -4.78123240e-02f, -1.11938298e-01f, -2.87258998e-02f,
  -4.59920354e-02f, -1.38245925e-01f, -9.64007750e-02f, 3.04434113e-02f, 2.50671320e-02f, 6.36191443e-02f, 5.93650108e-03f, -6.40253425e-02f, 3.31420973e-02f, 6.01309426e-02f,
  1.01014942e-01f, 6.62842616e-02f, -6.69252798e-02f, 4.12974656e-02f, -1.58931892e-02f, 2.79503176e-04f, 9.58475992e-02f, 1.57608222e-02f, 1.09959312e-01f, 5.55687547e-02f,
  -1.12873185e-02f, 4.88156080e-02f, -1.58251096e-02f, 5.36649600e-02f, -6.68209419e-02f, -8.44268501e-02f, -9.50264856e-02f, 7.03804046e-02f, -6.09557219e-02f, -5.70351817e-02f,
  -3.56885907e-03f, 2.33069621e-02f, -8.17724690e-02f, -5.18351346e-02f, -3.45924087e-02f, 2.61557288e-02f, -2.00788435e-02f, -4.53223940e-03f, 7.26278499e-03f, -7.09517226e-02f,
  -8.15313533e-02f, 4.81833098e-03f, 3.35988849e-02f, 3.66619788e-03f, 2.85546668e-03f, 6.32141083e-02f, -6.46107942e-02f, -2.26663537e-02f, -8.19184817e-03f, 5.49863279e-02f,
  -4.31153700e-02f, 1.15346359e-02f, -5.29699922e-02f, 4.51952294e-02f, -1.05550550e-01f, 7.55881965e-02f, -5.92846423e-02f, 5.17679751e-02f, 2.38853637e-02f, -1.25701372e-02f,
  -6.59720078e-02f, -1.28061082e-02f, 6.19724132e-02f, -8.96129236e-02f, 8.98062363e-02f, -2.02747956e-02f, 5.78408316e-02f, 3.15810330e-02f, 7.30188042e-02f, 7.66916275e-02f,
  -1.01251295e-02f, 3.50134224e-02f, 8.90815109e-02f, 2.37340108e-02f, -4.07666489e-02f, -6.16693683e-02f, 1.20270737e-02f, 3.06433719e-03f, -7.08694384e-02f, -3.85835581e-02f,
  -7.97048397e-03f, -8.06927308e-02f, 1.94155667e-02f, 4.92287725e-02f, 7.74723291e-02f, 9.09116790e-02f, -3.36076063e-03f, -4.82702330e-02f, 2.63339914e-02f, 3.13728340e-02f,
  -5.85285425e-02f, 1.15359351e-02f, 2.39418056e-02f, -2.86775432e-03f, 6.36774078e-02f, -6.50077686e-02f, 4.68339883e-02f, 4.98459712e-02f, -1.21006882e-02f, -7.60082109e-03f,
  3.25719684e-01f, -1.71234235e-02f, -1.07286483e-01f, 3.16972882e-01f, -3.46903205e-02f, -2.05539852e-01f, -2.76393056e-01f, 6.66724592e-02f, -1.04294881e-01f, -1.12289853e-01f,
  5.83151020e-02f, -1.43732697e-01f, -1.34811863e-01f, 8.53210464e-02f, 1.32573649e-01f, -2.02779174e-01f, 1.87891573e-01f, -5.51851690e-02f, -5.69480620e-02f, 1.11318365e-01f,
  1.65497497e-01f, 2.64180869e-01f, 1.17402963e-01f, 3.48023981e-01f, 1.56633705e-01f, 2.36176714e-01f, 3.78456593e-01f, 1.82329433e-03f, 3.56092006e-01f, 4.22321111e-02f,
  -9.01272520e-02f, 2.03845631e-02f, 3.30670066e-02f, 1.04523087e-02f, 6.58185929e-02f, 1.09079279e-01f, -2.00773310e-02f, -4.65066376e-04f, -4.39556167e-02f, -5.04324511e-02f,
  3.70837003e-02f, 2.37492770e-02f, 3.23247649e-02f, 2.45749280e-02f, 9.18692444e-03f, 9.08868760e-02f, -8.04461613e-02f, 5.24115574e-04f, -6.55079037e-02f, 2.00111419e-02f,
  -3.64062712e-02f, -7.58826360e-02f, 4.08522934e-02f, 6.07522763e-03f, 3.66211571e-02f, -3.97046022e-02f, -7.85790682e-02f, -3.29366326e-02f, 2.80824248e-02f, -2.43531764e-02f,
  4.53076437e-02f, -3.28744501e-02f, 1.87832303e-02f, 9.74347740e-02f, 7.17771500e-02f, 4.30083014e-02f, 6.54924959e-02f, -8.14454183e-02f, -4.33336161e-02f, -2.05938816e-02f,
  2.51672305e-02f, 6.34090304e-02f, 2.42875628e-02f, -1.02322504e-01f, 1.03461826e-02f, -9.45185870e-02f, -6.57060998e-04f, 6.63644983e-04f, -5.72976470e-02f, -2.45949868e-02f,
  -3.18270065e-02f, 2.70476826e-02f, 1.27157336e-02f, 1.39457986e-01f, -1.89719361e-03f, 2.06229035e-02f, 5.64947873e-02f, -7.04823155e-03f, -6.23179562e-02f, 1.07736783e-02f,
  -5.07514328e-02f, 1.46344095e-01f, -7.85726756e-02f, 4.54462320e-02f, -6.56893253e-02f, -1.81188516e-03f, 2.80062184e-02f, 5.13540544e-02f, 1.12915285e-01f, 1.04884177e-01f,
  3.99875902e-02f, 1.49790095e-02f, 5.85849769e-02f, 5.27649093e-03f, 1.15445100e-01f, 3.54483612e-02f, 1.09365601e-02f, 8.97996873e-02f, 5.92268482e-02f, -5.60604036e-03f,
  -1.03877969e-02f, 4.03209329e-02f, 4.28273454e-02f, -7.05917319e-03f, -9.21305083e-03f, 1.66017320e-02f, 1.80513356e-02f, -9.88889579e-03f, 7.91654177e-03f, -1.04452692e-01f,
  9.14894193e-02f, 1.32375918e-02f, 1.30290300e-01f, 1.64251253e-01f, -2.27375906e-02f, -4.14478630e-02f, -1.19729890e-02f, -1.74511671e-02f, 9.26803574e-02f, -4.59133275e-02f,
  -3.76707353e-02f, 6.74444344e-03f, 7.38842366e-03f, 5.57170138e-02f, -4.73387949e-02f, -6.16963804e-02f, -5.46224937e-02f, 9.85634793e-03f, 3.51263843e-02f, -5.83544374e-03f,
  -9.99914191e-05f, 8.95994436e-03f, 3.84148248e-02f, -3.46861184e-02f, 7.19738305e-02f, 1.51329562e-02f, -5.75290807e-02f, -6.81657568e-02f, 1.75323654e-02f, -1.03079185e-01f,
  1.14649557e-01f, 2.87214238e-02f, 2.98538264e-02f, 7.98224956e-02f, -1.21386051e-01f, 3.26114222e-02f, -3.07469610e-02f, -2.33191755e-02f, 3.32913175e-03f, -2.78459527e-02f,
  4.55332175e-02f, 1.15190784e-03f, -7.96888396e-03f, 4.33658548e-02f, 9.07479972e-02f, 1.08298957e-01f, 4.15829420e-02f, -6.65912628e-02f, -6.47950023e-02f, 2.27649994e-02f,
  2.17955355e-02f, 7.90342763e-02f, 9.73296762e-02f, -3.86575732e-04f, 1.05579540e-01f, -5.84416427e-02f, 1.37400255e-02f, -8.35703388e-02f, -7.63752311e-03f, 4.09932658e-02f,
  -3.32499444e-02f, -2.60616578e-02f, 1.96536835e-02f, -3.15772071e-02f, 3.63112241e-02f, 1.52342319e-02f, -3.37536298e-02f, -3.15374173e-02f, 6.97783604e-02f, 7.11233541e-02f,
  6.12928867e-02f, -4.32280861e-02f, 8.87824371e-02f, -8.52465332e-02f, -3.50386240e-02f, 1.32542282e-01f, -4.20420840e-02f, -3.48257013e-02f, -3.15680541e-02f, -3.92824113e-02f,
  2.98106484e-02f, 2.65325159e-02f, 2.84037832e-02f, 3.03272922e-02f, 9.67138261e-02f, 4.41669784e-02f, -3.39019001e-02f, -4.14925907e-03f, -2.48473529e-02f, -3.05135269e-03f,
  2.12035608e-03f, -9.06408206e-02f, 1.47774238e-02f, -5.25701940e-02f, -7.02903494e-02f, 4.39852290e-02f, 2.77304444e-02f, -2.56091375e-02f, -8.99283588e-02f, 3.90491486e-02f,
  4.06236202e-02f, 2.20979284e-02f, 6.79185688e-02f, 7.42153078e-02f, 5.49824499e-02f, -9.10258889e-02f, -7.00326404e-03f, 6.46693334e-02f, 6.91837519e-02f, -8.85439441e-02f,
  5.31458333e-02f, -2.53699627e-02f, 3.68000381e-02f, 2.97591686e-02f, 3.25362980e-02f, -6.79908693e-02f, -7.00266659e-03f, -1.14395104e-01f, -8.09246153e-02f, -5.47873564e-02f,
  -3.01985770e-01f, 1.75575837e-01f, -5.93333691e-02f, -1.76088646e-01f, 1.30621269e-01f, -2.33765151e-02f, -4.23021466e-02f, 1.40583934e-02f, -7.22684115e-02f, 6.04269542e-02f,
  -3.49461883e-02f, -3.55989784e-02f, 2.35771220e-02f, 3.64036746e-02f, -1.48465961e-01f, 5.31751700e-02f, -4.23824675e-02f, 1.70225073e-02f, 1.21903181e-01f, -3.00214114e-03f,
  -1.02293305e-01f, 1.07577838e-01f, 1.29741207e-01f, 1.97640702e-01f, -3.25883105e-02f, -7.83684626e-02f, -2.70326082e-02f, 1.12067729e-01f, -3.18992957e-02f, -1.75182484e-02f,
  -1.89994171e-01f, -8.22526366e-02f, -1.23209924e-01f, -1.05462715e-01f, -7.93876126e-02f, 4.97792549e-02f, -5.78155592e-02f, -2.94535533e-02f, 1.90773662e-02f, -5.83189214e-03f,
  -4.38096225e-02f, 1.18412990e-02f, -1.04915071e-02f, 8.96817669e-02f, -5.34655266e-02f, -6.41960353e-02f, 4.83180322e-02f, -1.33839948e-02f, -2.50453465e-02f, -2.07333337e-03f,
  -9.33665223e-03f, 5.44509105e-02f, -8.75984803e-02f, -3.78851639e-03f, -3.37035842e-02f, -1.48151377e-02f, -2.44472865e-02f, -4.25367430e-02f, -1.20517850e-01f, -6.46042377e-02f,
  9.21314433e-02f, -8.73327069e-03f, -4.54442687e-02f, 2.55828518e-02f, 6.88062832e-02f, 1.05900235e-01f, 4.03314754e-02f, 4.09175120e-02f, -4.74608205e-02f, -3.50234914e-04f,
  4.45806086e-02f, 1.98034123e-02f, 2.96402704e-02f, 2.11607269e-03f, -2.43142918e-02f, -1.71382073e-02f, -1.04445722e-02f, -5.94996214e-02f, 6.03231639e-02f, 1.67529397e-02f,
  -8.84540677e-02f, 5.63491918e-02f, 5.19379713e-02f, -9.29498300e-02f, -7.99402297e-02f, -4.04530615e-02f, 8.86854890e-04f, 7.37703815e-02f, -2.01109201e-02f, -4.11712639e-02f,
  -2.50529528e-01f, -2.48951524e-01f, -7.19672740e-02f, -7.76451305e-02f, 1.59157999e-02f, -6.40716702e-02f, -7.84630142e-03f, -9.40973237e-02f, -5.56382537e-02f, -5.01797572e-02f,
  -1.14530981e-01f, -1.02785580e-01f, -5.35605326e-02f, -5.80844246e-02f, 1.38154440e-03f, -1.16139948e-01f, 4.67305332e-02f, -2.32902151e-02f, -6.84992522e-02f, -6.58472776e-02f,
  -2.89413482e-02f, 4.16017547e-02f, 7.78913572e-02f, 4.43902947e-02f, 5.94441080e-03f, -1.95143316e-02f, -1.77459978e-02f, -3.38502526e-02f, -6.52387738e-02f, 3.87712345e-02f,
  7.96935521e-03f, 3.99288237e-02f, 1.72768742e-01f, -7.51335127e-03f, -3.58579271e-02f, -9.71623734e-02f, -4.78768488e-03f, -6.84547275e-02f, -2.15212721e-02f, -2.68923044e-02f,
  -3.75006497e-02f, 2.03497689e-02f, 5.00538163e-02f, 4.41539548e-02f, -1.65570185e-01f, -1.05902389e-01f, -4.60108146e-02f, -7.07733333e-02f, 3.42123583e-02f, 7.72082135e-02f,
  -5.16970223e-03f, -8.11510980e-02f, -4.42823693e-02f, 7.06679821e-02f, 8.61256868e-02f, -2.98241968e-03f, -1.33551881e-01f, 7.42310751e-03f, 7.08529120e-03f, 4.65049744e-02f,
  7.17750713e-02f, -4.65257689e-02f, 6.85454085e-02f, -3.00766919e-02f, 6.75107166e-02f, -6.45046681e-02f, -4.00059409e-02f, -9.91383120e-02f, -7.10117966e-02f, 9.29557532e-03f,
  7.66846240e-02f, -1.39364209e-02f, -7.65502900e-02f, 4.75739390e-02f, -5.81496395e-02f, -2.35446971e-02f, 9.89259183e-02f, -5.96373007e-02f, -1.96788386e-02f, 7.04732165e-02f,
  6.72442690e-02f, -1.15553178e-01f, 8.34056288e-02f, -1.08444951e-02f, 8.56913533e-03f, -6.15026951e-02f, 1.80605091e-02f, 7.57124573e-02f, 3.59222032e-02f, -5.05765639e-02f,
  6.80099428e-02f, 7.47983158e-02f, -3.40229794e-02f, 6.03745729e-02f, -7.86740426e-03f, 6.73500597e-02f, -5.92104867e-02f, 7.21473759e-03f, -6.59569502e-02f, 3.06313671e-02f,
  4.79277363e-03f, 3.93190235e-02f, -2.40370189e-03f, 6.89752996e-02f, -9.30162966e-02f, -7.96478689e-02f, -7.82755539e-02f, -4.71722446e-02f, -5.88831045e-02f, 5.51903546e-02f,
  -6.63591027e-02f, 1.61198527e-02f, 5.32775596e-02f, -7.45557174e-02f, -3.73560861e-02f, -3.01616266e-02f, 1.38119478e-02f, -8.88380930e-02f, -3.42916623e-02f, -1.05403271e-02f,
  -3.99110876e-02f, -6.55922890e-02f, 8.53768140e-02f, 1.55372461e-02f, -7.44048581e-02f, -3.42051429e-03f, -2.18499433e-02f, -8.61640200e-02f, -3.86809111e-02f, -5.70444874e-02f,
  -7.49979317e-02f, -1.12206675e-02f, -1.16102703e-01f, 2.27674134e-02f, -2.45034900e-02f, -1.24506848e-02f, -5.14739156e-02f, 1.06322803e-02f, -7.07097426e-02f, 7.24319369e-02f,
  7.57613853e-02f, -7.28744268e-02f, -3.42792124e-02f, 6.61427677e-02f, -6.33765981e-02f, -2.26267744e-02f, -2.43923673e-03f, 1.18731730e-01f, -1.51442317e-02f, -3.77960084e-03f,
  2.06763804e-01f, -1.84348628e-01f, -3.57222483e-02f, -2.64652669e-02f, -1.26274675e-02f, -1.15847707e-01f, 1.03617162e-02f, -4.51951139e-02f, 9.77620184e-02f, -8.12183768e-02f,
  -9.29321796e-02f, -8.87888148e-02f, -3.49965617e-02f, 9.08623822e-03f, 1.31295264e-01f, 2.37261131e-02f, -7.88509399e-02f, 2.99982785e-04f, -7.06198812e-03f, -3.43635455e-02f,
  1.00564890e-01f, -7.66733103e-03f, -9.50881243e-02f, -1.26869202e-01f, -8.22342411e-02f, -8.38603452e-02f, 3.76171507e-02f, -5.74481450e-02f, -5.68681546e-02f, 8.99449512e-02f,
  3.43553089e-02f, -3.69938686e-02f, -2.26571988e-02f, -5.44175580e-02f, -2.47984119e-02f, 4.23352346e-02f, 2.63847243e-02f, 2.96987295e-02f, 5.00268154e-02f, 6.24292865e-02f,
  7.39536285e-02f, -6.28710017e-02f, 5.53340465e-02f, -3.04252328e-03f, -9.15345401e-02f, 5.49806245e-02f, -1.44800246e-02f, -8.53519130e-04f, -9.87682398e-03f, -5.70788682e-02f,
  -1.48182968e-02f, -2.86495127e-02f, -6.08468894e-03f, -2.73871534e-02f, -4.94351201e-02f, 6.72582239e-02f, 5.64118214e-02f, -9.14024189e-02f, -2.42250245e-02f, -2.69543063e-02f,
  -2.54308302e-02f, 2.47695334e-02f, -7.03953207e-02f, 3.71410027e-02f, 1.93070769e-02f, 2.58426666e-02f, -5.92179447e-02f, -3.43224332e-02f, 1.06315371e-02f, 5.56872003e-02f,
  -1.00497976e-01f, 2.14237394e-03f, 2.14696638e-02f, 7.00614527e-02f, 2.90372167e-02f, -7.89741054e-02f, 8.16095099e-02f, -4.88028117e-02f, 8.62096027e-02f, -1.24536233e-03f,
  -4.37830649e-02f, 8.61864761e-02f, 2.28942074e-02f, 7.42227808e-02f, -7.07963184e-02f, -4.87483293e-02f, 8.16726312e-02f, 1.00263208e-02f, -5.62455580e-02f, 6.99432567e-02f,
  -5.13182767e-02f, -8.14075172e-02f, -5.05294390e-02f, -4.97180112e-02f, 3.67696881e-02f, 2.91938875e-02f, -9.46668535e-02f, -5.01798242e-02f, -4.01397347e-02f, 5.20945974e-02f,
  -8.51182546e-03f, 3.71615179e-02f, 6.91510588e-02f, 4.70056050e-02f, 9.91069898e-03f, -1.00741036e-01f, 8.03778023e-02f, 6.47072047e-02f, 7.85478801e-02f, -7.06137642e-02f,
  -3.26713808e-02f, -2.58386619e-02f, 1.94351412e-02f, 4.81719524e-02f, 2.40991209e-02f, -4.00393642e-02f, 6.27934188e-03f, -5.45572315e-04f, -3.88836153e-02f, 9.60236937e-02f,
  1.64311498e-01f, -9.10245106e-02f, -2.90837307e-02f, 7.20059499e-02f, -1.34531632e-01f, -1.54814407e-01f, -3.82544436e-02f, -1.18252300e-01f, -4.96392511e-02f, -6.00311942e-02f,
  5.41919246e-02f, 4.62292656e-02f, 7.30864480e-02f, 9.59280804e-02f, 7.86265731e-02f, -3.76706272e-02f, 2.56111454e-02f, -1.10547632e-01f, -2.32062303e-02f, 1.09296523e-01f,
  1.19647197e-01f, 1.51162475e-01f, 7.34113976e-02f, 9.58578810e-02f, 7.51851052e-02f, 1.35246992e-01f, 7.09629878e-02f, 3.66072506e-02f, 1.35036036e-02f, -1.45592168e-02f,
  -9.12629962e-02f, 7.60430247e-02f, 3.26297246e-02f, 3.68762086e-03f, 3.36736031e-02f, -3.30173923e-03f, 2.23776028e-02f, 7.11920261e-02f, -4.37977351e-02f, 5.07255420e-02f,
  -8.15091506e-02f, 1.58027802e-02f, -1.96193065e-02f, -3.48140858e-03f, 1.07459603e-02f, -3.45797315e-02f, 2.64625847e-02f, 4.07772362e-02f, -6.31142333e-02f, 1.95639301e-02f,
  -3.71895805e-02f, 4.03451547e-02f, -4.35255952e-02f, 6.53162152e-02f, 5.70973083e-02f, 6.55014515e-02f, 4.71561588e-02f, -6.31275848e-02f, -2.76542250e-02f, 1.03088263e-02f,
  8.68698210e-03f, -1.24557987e-02f, -1.60962157e-02f, 2.73817070e-02f, 7.71017978e-03f, 3.35911140e-02f, -8.87403730e-03f, 6.49164915e-02f, 3.72133218e-02f, 6.97394758e-02f,
  4.16549779e-02f, -4.57571726e-03f, 5.46244830e-02f, -8.73208791e-03f, 3.96587476e-02f, 2.97071580e-02f, -2.11630147e-02f, -5.27957268e-03f, 7.02547878e-02f, 5.87780401e-02f,
  -9.82365906e-02f, 9.97517481e-02f, -1.02632660e-02f, 4.63309288e-02f, 5.07422425e-02f, -4.15276885e-02f, 4.71856222e-02f, -3.45504582e-02f, -8.02525878e-03f, 4.06417437e-02f,
  -4.56360020e-02f, 7.40697458e-02f, -3.26767005e-02f, -7.57656693e-02f, 6.21931441e-02f, -7.90688619e-02f, -5.68717606e-02f, -9.41743255e-02f, -5.81204239e-03f, 3.75189334e-02f,
  5.77818938e-02f, -7.48228468e-03f, -3.14732641e-03f, 6.94187507e-02f, 5.93989156e-03f, -8.08564201e-02f, 1.10852025e-01f, -7.92751312e-02f, 1.50983073e-02f, 9.12761241e-02f,
  5.70675768e-02f, 1.81439950e-03f, -3.56157906e-02f, -7.72833778e-03f, 1.96876079e-02f, 4.36314754e-02f, 3.69889550e-02f, 3.94864343e-02f, 7.73603618e-02f, 4.17465083e-02f,
  8.16120505e-02f, -2.89377809e-01f, -1.07992932e-01f, 4.05217223e-02f, 1.52536407e-01f, -2.52160765e-02f, -1.30153850e-01f, 1.13812476e-01f, 2.45259888e-02f, -3.92301939e-02f,
  -3.14234421e-02f, -2.30403900e-01f, -1.79332271e-01f, -1.14009501e-02f, 2.90619526e-02f, -2.47770008e-02f, 1.17651097e-01f, -2.02396996e-02f, -2.57385038e-02f, -9.66239423e-02f,
  7.09071830e-02f, 1.49710745e-01f, 4.84143607e-02f, 1.64110854e-01f, 1.83674805e-02f, 2.75761709e-02f, -2.93496773e-02f, 1.08408218e-03f, 1.41538396e-01f, 1.85575113e-01f,
  -5.58733568e-02f, 4.98182476e-02f, -1.11820765e-01f, 5.48583455e-02f, -2.17804201e-02f, -7.07520545e-02f, -2.05060076e-02f, -2.24282723e-02f, 3.11096329e-02f, -3.32294069e-02f,
  -1.42339155e-01f, 4.67483327e-02f, 5.97213060e-02f, -1.56048611e-02f, 1.51299557e-03f, 5.76082580e-02f, 5.54582439e-02f, -9.45897698e-02f, 6.42144214e-03f, -2.79007237e-02f,
  -8.66710991e-02f, 6.34398758e-02f, -2.34239399e-02f, 5.30797280e-02f, -2.99955513e-02f, -7.93091804e-02f, 4.48788935e-03f, -1.00628905e-01f, 1.43370805e-02f, 2.42147781e-02f,
  -5.41208824e-03f, 6.09571636e-02f, 3.62258889e-02f, 9.33148116e-02f, 5.36436662e-02f, 4.39311825e-02f, 5.42759150e-03f, -1.45473117e-02f, -8.71826857e-02f, -2.90622618e-02f,
  3.81114893e-02f, -2.12386828e-02f, -1.90448891e-02f, -4.31642160e-02f, -2.93897483e-02f, 6.76267371e-02f, 2.29057055e-02f, 6.69011697e-02f, -5.28561138e-02f, 1.76830180e-02f,
  2.75388286e-02f, -6.00137413e-02f, 8.80327597e-02f, 1.22425750e-01f, -7.27351978e-02f, -1.02346344e-02f, -3.01384367e-02f, 1.01398610e-01f, -8.44151825e-02f, 2.39041355e-02f,
  -2.03554183e-02f, -1.77037418e-01f, -2.45850440e-02f, 5.74972741e-02f, -1.08306587e-01f, 1.55344245e-03f, -1.60360988e-02f, 1.48361307e-02f, -6.47604242e-02f, -5.91487549e-02f,
  -3.34077515e-02f, 3.71105783e-03f, 5.09667434e-02f, 8.10781419e-02f, 1.06779775e-02f, -1.57922283e-02f, 1.17969126e-01f, -4.85888757e-02f, 2.50661280e-02f, 4.56198305e-03f,
  3.77868824e-02f, -7.14349374e-02f, 5.93493469e-02f, 5.16457483e-02f, -5.14826179e-02f, 2.23386250e-02f, 1.12649007e-02f, 6.74897432e-02f, 8.22881907e-02f, 1.58877913e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  5.52981459e-02f, -1.38612716e-02f, 5.82408942e-02f, 4.15511876e-02f, -8.14492702e-02f, 1.85705423e-01f, -6.75249249e-02f, 1.73085064e-01f, 1.55782476e-01f, -1.36470377e-01f,
  3.97051759e-02f, -1.31286934e-01f, -3.14616002e-02f, -6.35814965e-02f, -3.71729955e-03f, 1.08879849e-01f, -4.45122831e-02f, 8.91429707e-02f, -9.62834358e-02f, -1.09782787e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.09499747e-01f, -1.86398327e-01f, -2.21018031e-01f, -1.51011318e-01f, 1.73572432e-02f, 4.45150062e-02f, 1.20181121e-01f, 9.82988998e-02f, -3.45039219e-01f, 2.36846656e-01f,
  -2.51679540e-01f, -8.04546997e-02f, -4.83983278e-01f, -1.62943359e-02f, 1.58004776e-01f, -1.22023471e-01f, 4.22864081e-03f, 9.18523669e-02f, -1.14961378e-01f, -1.09763920e-01f,
  2.97507849e-02f, -3.49796027e-01f, 1.37927353e-01f, -2.97432840e-02f, -4.47144844e-02f, 2.26000622e-01f, -8.03982392e-02f, 4.53156121e-02f, -2.13288680e-01f, -1.41073093e-01f,
  8.22724104e-02f, 6.18885905e-02f, 1.06013425e-01f, -5.45799918e-02f, 3.53569031e-01f, 1.30193532e-01f, -4.97507192e-02f, -4.63863136e-03f, -2.39329636e-01f, -3.10274333e-01f,
  2.59708136e-01f, 7.84127787e-03f, 9.27275941e-02f, 4.26531397e-02f, 1.87407717e-01f, -2.41226181e-01f, -2.41956234e-01f, 4.83002067e-02f, 3.94311249e-02f, -2.18616650e-01f,
  -1.30099103e-01f, -1.18430052e-02f, 3.15103173e-01f, -4.14100707e-01f, 8.36932287e-02f, -3.55494201e-01f, 1.47287875e-01f, -5.07747289e-03f, 1.73735768e-01f, -2.16414481e-01f,
  1.83220536e-01f, 6.34065270e-02f, -4.80300412e-02f, 2.11522207e-01f, 1.05232939e-01f, -2.00726792e-01f, 1.09129757e-01f, 1.42838851e-01f, -9.37115923e-02f, 7.95956776e-02f,
  -5.70853949e-02f, -4.94508408e-02f, -1.78892799e-02f, -1.46761507e-01f, 5.84974810e-02f, 1.52115390e-01f, -4.26527709e-01f, -1.56641245e-01f, -9.63301882e-02f, 1.57873020e-01f,
  -1.40843242e-01f, 7.29022846e-02f, -1.20609468e-02f, -4.41603921e-02f, 3.08534980e-01f, -1.46138191e-01f, 1.59308568e-01f, 1.38608797e-03f, -1.93095040e-02f, 3.02427024e-01f,
  3.74173420e-03f, 3.00439987e-02f, 1.27316266e-01f, -7.15448558e-02f, 2.05797315e-01f, 5.83164990e-02f, -1.06377207e-01f, 9.02995169e-02f, -5.96351363e-02f, 3.61966006e-02f,
  1.77302286e-01f, 9.04993936e-02f, -2.21925676e-01f, 4.69663460e-03f, -9.72018286e-04f, -2.98812557e-02f, 2.09603980e-01f, -2.12897852e-01f, 1.43635362e-01f, 8.84420723e-02f,
  -2.51155019e-01f, -2.20591482e-03f, -1.05857991e-01f, 7.35822916e-02f, 1.21341459e-01f, 1.98107719e-01f, -1.78199843e-01f, 1.29667848e-01f, -7.20389858e-02f, -1.42556965e-01f,
  -1.32484198e-01f, -3.12364131e-01f, 6.74082115e-02f, 1.92252114e-01f, 1.60294726e-01f, -7.59776458e-02f, 9.28744674e-03f, 6.58100843e-02f, -1.44996688e-01f, 1.35395020e-01f,
  -6.06455989e-02f, -2.63967544e-01f, -6.07317351e-02f, 1.84956253e-01f, 2.00831279e-01f, 1.52079254e-01f, -1.26862779e-01f, 1.49280995e-01f, 8.45720544e-02f, -1.38132840e-01f,
  7.23795369e-02f, 7.66338557e-02f, 2.09607720e-01f, 1.71809252e-02f, 9.41808000e-02f, 2.68465001e-02f, 6.89866617e-02f, -1.20280467e-01f, -1.92521393e-01f, 2.63170928e-01f,
  -1.91573918e-01f, 1.65422693e-01f, 2.10568514e-02f, 8.09720457e-02f, -1.25573561e-01f, 6.63905367e-02f, -9.60823968e-02f, 2.92956699e-02f, 3.15980352e-02f, -1.58833101e-01f,
  -2.22021341e-01f, -1.22034036e-01f, -1.73502430e-01f, 3.54741029e-02f, -4.54169698e-02f, 2.15569273e-01f, 3.22125673e-01f, 6.11185990e-02f, 5.14708757e-02f, 8.12046602e-02f,
  1.00051593e-02f, -1.31699210e-02f, 1.27077932e-02f, 2.78304387e-02f, 6.75354749e-02f, -2.41860047e-01f, -8.39204118e-02f, -2.76158571e-01f, -3.19686346e-02f, -1.15581252e-01f,
  -5.15423380e-02f, 3.87159824e-01f, 2.21725628e-02f, 1.87118128e-01f, 1.95577011e-01f, 2.36712396e-02f, 5.42618670e-02f, -1.65741369e-01f, -2.65722245e-01f, 2.96362676e-02f,
  -9.78288278e-02f, 1.12819247e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.65592577e-02f, 2.17988059e-01f, -8.83846581e-02f, 1.28519505e-01f, 2.96158008e-02f, 1.58692181e-01f, 8.52877200e-02f, 1.27162114e-01f, 2.92095304e-01f, -3.31341922e-02f,
  4.97185178e-02f, -1.32655010e-01f, 3.16581368e-01f, 1.90201759e-01f, 1.77237298e-02f, -7.45742843e-02f, 1.24002583e-02f, 2.56950334e-02f, 9.89449769e-02f, 1.31980866e-01f,
  3.62932056e-01f, 4.68169183e-01f, -6.57517985e-02f, 1.34381250e-01f, 1.18753858e-01f, -7.10926950e-02f, -1.97384939e-01f, 7.85921514e-02f, 3.54579352e-02f, 1.56725049e-01f,
  -1.10073924e-01f, -8.28689486e-02f, 2.01186463e-01f, 1.12955384e-01f, -1.37497827e-01f, 2.77877331e-01f, 2.11744696e-01f, 4.00349855e-01f, 3.04982603e-01f, 2.82224983e-01f,
  -1.37051448e-01f, 1.29407058e-02f, 5.14887050e-02f, -1.83283493e-01f, 2.91825473e-01f, 2.30446793e-02f, -3.97250205e-02f, -1.55358672e-01f, 2.90403813e-02f, 2.15395510e-01f,
  -4.44300510e-02f, 1.66425891e-02f, 1.02119908e-01f, 5.47289252e-01f, 5.72225638e-02f, 2.20551237e-01f, 6.88428199e-03f, -1.84577350e-02f, -1.57082647e-01f, 1.80304989e-01f,
  1.13473069e-02f, 5.81204183e-02f, 5.48386760e-02f, -2.09911510e-01f, 2.10161954e-01f, 2.58421659e-01f, 1.91442594e-01f, 2.10020617e-01f, 7.57698342e-02f, 3.62631947e-01f,
  6.87500536e-02f, 1.95255116e-01f, 1.81297418e-02f, 2.78090179e-01f, 1.80885330e-01f, -3.57864588e-01f, 3.04476023e-01f, 1.84339494e-01f, 1.60823353e-02f, -1.38532385e-01f,
  2.23238766e-01f, 2.61912167e-01f, -1.05752595e-01f, 2.57706910e-01f, -7.31507093e-02f, 5.14212012e-01f, -1.17310872e-02f, 2.36237377e-01f, 1.33455902e-01f, -2.42047936e-01f,
  -8.68020803e-02f, 2.89970040e-01f, -3.31111439e-02f, -1.92458257e-01f, -1.85775876e-01f, 3.71124875e-03f, -1.16272017e-01f, 2.01060593e-01f, -7.59172589e-02f, 1.08848915e-01f,
  -6.66027069e-02f, 1.27993282e-02f, 1.88934490e-01f, -8.07805434e-02f, -6.17044931e-03f, -1.07991084e-01f, -1.61891967e-01f, -2.07785711e-01f, -1.45701602e-01f, 1.22279651e-01f,
  1.82469040e-01f, 7.70012587e-02f, -7.07562119e-02f, -1.19181052e-01f, -1.82131767e-01f, -1.76010624e-01f, 1.09126410e-02f, -9.27548334e-02f, 3.59146693e-03f, 3.42020094e-01f,
  -1.62566170e-01f, 4.99407947e-01f, -7.20427036e-02f, 5.30909821e-02f, -1.57854617e-01f, -2.10549876e-01f, 6.85408562e-02f, 1.16638571e-01f, 3.61942500e-02f, 7.72121176e-02f,
  1.22530824e-02f, 9.47392136e-02f, -4.26873602e-02f, 2.62522370e-01f, 2.42556959e-01f, -9.61768925e-02f, -6.30219877e-02f, -1.78291544e-01f, 2.07069684e-02f, -2.94130836e-02f,
  -1.59124374e-01f, -6.34068325e-02f, 9.19309109e-02f, -9.98109281e-02f, 1.89442039e-02f, -6.53281882e-02f, -4.48737219e-02f, -2.22617149e-01f, -4.24056873e-02f, -1.42502978e-01f,
  4.61328700e-02f, 4.33709204e-01f, -1.12736233e-01f, 3.54130268e-01f, -3.58215719e-02f, -1.47158235e-01f, 1.04486309e-02f, -2.31294245e-01f, 1.98620394e-01f, -1.21883541e-01f,
  6.19753450e-02f, 1.61593676e-01f, -1.47114456e-01f, 1.57882631e-01f, 9.82396007e-02f, 1.46891817e-01f, 2.81417757e-01f, -4.82972478e-03f, -3.14278424e-01f, -2.19942946e-02f,
  -3.16134244e-01f, 4.72167917e-02f, -1.65239170e-01f, 4.26269621e-02f, 2.48972639e-01f, -1.18745804e-01f, -1.23302221e-01f, -1.45919085e-01f, 1.82058305e-01f, -2.87984341e-01f,
  1.61079481e-01f, 8.49671811e-02f, 5.24984226e-02f, 3.84730428e-01f, 2.93087419e-02f, 4.79818285e-01f, 7.25640729e-02f, -1.95149463e-02f, -1.49244234e-01f, -7.10820332e-02f,
  2.77962107e-02f, -9.52643901e-02f, -1.72917232e-01f, -2.35745814e-02f, -1.54995874e-01f, 1.06763855e-01f, -1.53951764e-01f, 1.19283609e-01f, -1.63663238e-01f, 4.63349782e-02f,
  -5.18978462e-02f, 2.63342839e-02f, -1.32469475e-01f, 6.31087944e-02f, 2.13716924e-03f, 1.53074056e-01f, 8.69945213e-02f, -9.49308425e-02f, -1.49543941e-01f, 3.16429436e-02f,
  3.91502716e-02f, 6.61617368e-02f, -5.88039570e-02f, -3.53591517e-02f, -6.86768666e-02f, 8.35622177e-02f, -7.23183379e-02f, -1.69512331e-01f, -7.98941627e-02f, 2.65596174e-02f,
  -3.01834904e-02f, -1.53289795e-01f, -2.85982750e-02f, -4.14364086e-03f, 1.06498837e-01f, -9.02967644e-04f, 4.18834351e-02f, 7.42162243e-02f, 3.15194130e-01f, -1.02687001e-01f,
  8.36644918e-02f, -2.76447237e-01f, 1.62394017e-01f, -2.10876942e-01f, 4.48157899e-02f, 1.93281934e-01f, 7.16825873e-02f, -7.19030425e-02f, 1.42373309e-01f, 2.24355727e-01f,
  -1.28748819e-01f, 1.91537604e-01f, -1.45256275e-03f, 8.27153474e-02f, 3.68426055e-01f, -5.83829880e-02f, 6.82879686e-02f, 1.72382906e-01f, -1.53603926e-01f, 3.12320799e-01f,
  4.19808812e-02f, -2.05499828e-01f, -1.26903370e-01f, 7.87623748e-02f, 1.56732380e-01f, 1.77802414e-01f, -3.35727744e-02f, -5.99521995e-02f, -1.43395275e-01f, -7.21667632e-02f,
  1.44602984e-01f, -7.98936486e-02f, 2.87396349e-02f, 2.84674913e-02f, -2.07225397e-01f, 6.90724850e-02f, -1.40238568e-01f, 3.73385027e-02f, -1.68147162e-01f, -1.34960040e-01f,
  1.67689621e-01f, -1.31930247e-01f, 4.18858714e-02f, 1.51907071e-01f, 1.06947064e-01f, -9.15877372e-02f, 8.37362856e-02f, -3.81494761e-02f, -1.35273755e-01f, 1.20276794e-01f,
  3.55426893e-02f, 3.15181841e-03f, 1.40995026e-01f, 5.08043636e-03f, 9.06977728e-02f, -4.82757911e-02f, 1.40133619e-01f, 1.80038139e-01f, 2.00876147e-01f, 2.06978366e-01f,
  9.77794677e-02f, 2.45529637e-01f, 1.54334471e-01f, 5.16778268e-02f, -3.43244344e-01f, 7.73208067e-02f, -2.41946608e-01f, -9.40857157e-02f, 1.36406139e-01f, -4.25210506e-01f,
  3.22270282e-02f, -1.31098241e-01f, -7.56090581e-02f, -1.87256727e-02f, 1.19223865e-02f, 3.66751879e-01f, -1.75795764e-01f, 1.56982288e-01f, -8.35770965e-02f, 2.59664208e-02f,
  -1.37531608e-01f, 6.07300699e-02f, 6.62526637e-02f, -2.13152975e-01f, -2.39662305e-02f, 3.35990280e-01f, 1.25876427e-01f, -1.88443854e-01f, -1.96652219e-01f, 9.92866158e-02f,
  -7.22079203e-02f, -1.63487732e-01f, 7.73570454e-03f, -6.83372701e-03f, -1.59670394e-02f, -1.56142846e-01f, -4.53036133e-04f, -1.21009223e-01f, -1.41324118e-01f, -1.58561647e-01f,
  1.56482890e-01f, 5.71431108e-02f, 2.17478782e-01f, -9.53185931e-02f, 1.58770040e-01f, 4.69010472e-02f, 5.34301288e-02f, -3.55450213e-02f, 1.61926135e-01f, 8.41528177e-02f,
  -7.10358173e-02f, -1.00180097e-01f, 6.13171905e-02f, 7.16844648e-02f, 8.77007023e-02f, -1.19027786e-01f, 1.63121283e-01f, 3.67909186e-02f, -1.09507795e-02f, -2.81103067e-02f,
  -9.51048508e-02f, 9.13189352e-03f, -1.22655958e-01f, -3.50533798e-02f, -1.70168474e-01f, -1.59396246e-01f, -1.85059328e-02f, -1.21487789e-02f, 8.93492103e-02f, 1.58947214e-01f,
  3.22719775e-02f, -6.54848740e-02f, 3.51090133e-02f, 1.54464424e-01f, 1.71881661e-01f, -1.07344445e-02f, -1.41915930e-02f, 1.01708092e-01f, 1.54086696e-02f, -8.00678954e-02f,
  -4.76761684e-02f, -8.24994668e-02f, -6.78249970e-02f, -2.31368672e-02f, -1.44803450e-01f, -2.85455119e-02f, -2.78331060e-02f, -1.77031487e-01f, 1.10922225e-01f, -1.28601536e-01f,
  -4.66488525e-02f, 7.10832141e-03f, 4.75963540e-02f, -1.17533207e-01f, 8.43604356e-02f, -8.81900340e-02f, 4.63716872e-02f, -6.31152019e-02f, 2.33853251e-01f, 1.63723707e-01f,
  7.63658248e-03f, 2.14785084e-01f, -6.91262539e-05f, 1.49274141e-01f, -1.02084197e-01f, 4.59013358e-02f, -7.49038309e-02f, 1.83976919e-03f, -9.42877866e-03f, -1.60020776e-02f,
  2.60002259e-02f, 2.41174176e-01f, -3.33764218e-02f, 1.12785213e-01f, 1.29537642e-01f, -6.23063929e-02f, -2.38067359e-02f, 1.16457663e-01f, -4.19142917e-02f, 8.69763866e-02f,
  1.42191142e-01f, 2.22294822e-01f, -9.18017030e-02f, -1.40540987e-01f, 9.55053233e-03f, 5.58521412e-02f, 2.34997556e-01f, 6.92110658e-02f, 3.01870793e-01f, 1.20390363e-01f,
  1.69718951e-01f, 1.70636773e-01f, -5.52724451e-02f, 1.51991054e-01f, -2.07888156e-01f, 5.14872558e-02f, -3.07293478e-02f, -5.71706556e-02f, -1.38954669e-01f, -7.05927536e-02f,
  1.90746352e-01f, 3.04381400e-02f, -1.67099223e-01f, 2.61207730e-01f, 8.47745612e-02f, 2.42386982e-01f, 2.69868642e-01f, -4.74803820e-02f, 1.87731031e-02f, -1.56276494e-01f,
  -1.44778401e-01f, 7.95927942e-02f, -1.22673959e-01f, -4.82022278e-02f, -5.53096421e-02f, 4.14471664e-02f, -7.25040436e-02f, 2.25518718e-01f, -4.43583131e-02f, 2.30877861e-01f,
  5.92656508e-02f, 7.29047135e-02f, -6.66279206e-03f, 1.12878405e-01f, -8.17938372e-02f, 2.61350691e-01f, -1.00207053e-01f, 3.19605917e-02f, -1.75780714e-01f, -2.07603604e-01f,
  -7.52845779e-02f, 9.97641124e-03f, -1.00775950e-01f, -4.12773993e-03f, -1.70557443e-02f, 1.04333349e-01f, -2.94439569e-02f, 1.75195187e-01f, -1.33199513e-01f, 1.98052675e-01f,
  2.00603306e-01f, 8.72080855e-04f, 1.27780020e-01f, -5.10635301e-02f, -6.59297854e-02f, 2.30113640e-01f, 1.27160147e-01f, 1.61420837e-01f, -1.32801265e-01f, -3.77206467e-02f,
  1.62106588e-01f, -3.96880135e-02f, 2.08834391e-02f, 4.15862259e-03f, 5.01184873e-02f, -6.46912167e-03f, -1.09862342e-01f, -1.96167961e-01f, 1.43608600e-01f, -3.63108963e-02f,
  -2.60211527e-01f, 7.12384656e-02f, -1.86426431e-01f, -1.25363460e-02f, 1.61356509e-01f, -8.71452242e-02f, -1.87577784e-01f, 1.36613116e-01f, -8.55009407e-02f, 6.40835389e-02f,
  2.78386265e-01f, -5.38629666e-02f, -8.42393283e-03f, -3.70403356e-03f, 1.05429597e-01f, 2.35009447e-01f, -1.04578421e-01f, -1.44543409e-01f, 3.80793922e-02f, 1.17613904e-01f,
  1.32836014e-01f, 3.07242990e-01f, 7.95446485e-02f, -1.35766730e-01f, 2.62616277e-01f, 2.47160971e-01f, 1.16118968e-01f, -8.04931670e-02f, -5.59796877e-02f, 2.18972564e-02f,
  1.40192777e-01f, -1.98651105e-01f, -5.35111278e-02f, 2.15100229e-01f, 3.17007750e-02f, 1.08344406e-01f, -1.58040255e-01f, -1.02588445e-01f, 5.91346473e-02f, -3.04804388e-02f,
  -2.51047201e-02f, 2.85376469e-03f, 2.50187367e-01f, 1.64699867e-01f, 3.45982723e-02f, 6.81039467e-02f, -3.05544306e-02f, -5.50489053e-02f, 3.37080210e-02f, -3.82253826e-02f,
  -1.49123520e-02f, 1.57079458e-01f, -9.32799652e-03f, -1.05365947e-01f, 1.24390073e-01f, -8.72172788e-02f, 1.24156572e-01f, -1.37481466e-01f, -6.92659020e-02f, -1.98179539e-02f,
  1.79077595e-01f, 4.92446311e-02f, 4.85162027e-02f, 2.12810934e-01f, 9.26458165e-02f, 1.17230795e-01f, -1.03029877e-01f, 1.31623400e-02f, 5.71004078e-02f, -2.55328212e-02f,
  9.35338140e-02f, 1.69039324e-01f, -1.52716890e-01f, -1.91511307e-02f, -1.21614799e-01f, -4.09292337e-03f, -1.01169042e-01f, -9.06599909e-02f, -1.73813641e-01f, 1.57460161e-02f,
  -6.76270276e-02f, 1.94419667e-01f, 1.13977738e-01f, 1.58697262e-01f, 9.30978581e-02f, -1.52697369e-01f, 4.07013953e-01f, 2.97301114e-01f, 3.24562788e-01f, 1.45669848e-01f,
  2.58840114e-01f, -2.52909306e-03f, -5.11923805e-02f, 1.13425016e-01f, 1.01572633e-01f, -1.43902674e-01f, 3.27876717e-01f, -2.52207369e-01f, 3.59655380e-01f, -4.66158567e-03f,
  -1.10859796e-01f, 1.59311339e-01f, -2.11708192e-02f, 2.90235788e-01f, -2.60011503e-03f, 4.13680851e-01f, 3.32974434e-01f, 2.25156724e-01f, -7.68535286e-02f, 3.21237296e-02f,
  1.72879219e-01f, -1.60695687e-01f, 1.74052104e-01f, -3.67454924e-02f, -6.20619999e-03f, -1.35309890e-01f, -1.82096899e-01f, 1.51399106e-01f, 2.55403608e-01f, 1.46196961e-01f,
  1.45776212e-01f, 1.13678083e-01f, 1.14094943e-01f, 1.32468611e-01f, 9.52293724e-02f, -1.40157476e-01f, 2.65690237e-01f, -1.24643669e-01f, 3.25319767e-01f, 5.95198050e-02f,
  3.13960701e-01f, 7.61557445e-02f, -1.65356800e-01f, -1.05694473e-01f, 2.18280945e-02f, 6.16806075e-02f, 5.44684790e-02f, -6.70057312e-02f, 1.43417120e-01f, 1.50797576e-01f,
  -1.73518240e-01f, 3.53041552e-02f, -6.71143234e-02f, -2.19935132e-03f, 7.41774291e-02f, -2.39483520e-01f, -6.95349500e-02f, 4.91867512e-02f, -1.48125350e-01f, 5.10145240e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.73306684e-02f, 3.18884552e-01f, 4.12541986e-01f, 1.55899853e-01f, -6.87337443e-02f, 1.22629898e-02f, -1.09084032e-01f, 1.05725601e-01f, -2.23992933e-02f, 1.31406263e-01f,
  2.48483494e-02f, 1.25631243e-01f, 1.18825823e-01f, 3.27181429e-01f, 3.40703921e-03f, 2.29484916e-01f, 7.31128827e-02f, -1.49744436e-01f, 1.45696318e-02f, 1.15068085e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -8.75415504e-02f, -1.67018101e-01f, -1.65866673e-01f, -2.31973335e-01f, 1.03920745e-02f, -2.44470723e-02f, 2.52296418e-01f, -4.94339675e-01f, 3.21346633e-02f, 1.80781469e-01f,
  3.71352226e-01f, 9.06752422e-02f, -6.60040155e-02f, 2.49819160e-01f, 3.20159234e-02f, 4.77264784e-02f, 2.47918129e-01f, 1.14383005e-01f, 7.34600201e-02f, -6.89521953e-02f,
  1.67218313e-01f, 1.91377014e-01f, -2.02525291e-03f, 6.24641627e-02f, 4.33212006e-03f, -1.04037479e-01f, 1.24421585e-02f, -1.90306127e-01f, -6.93825483e-02f, 3.20299678e-02f,
  -3.78440209e-02f, 3.55940461e-02f, 1.92059383e-01f, 1.04093412e-02f, -1.11463957e-01f, 4.34604622e-02f, 9.95368361e-02f, 5.77488802e-02f, 1.34308208e-02f, 3.60560566e-01f,
  1.82711482e-01f, 1.43949002e-01f, -2.97707468e-01f, -2.42522553e-01f, -1.73665702e-01f, -2.37595409e-01f, 1.95134152e-02f, 8.39612409e-02f, -2.61498183e-01f, -8.98968726e-02f,
  1.00927480e-01f, 1.08424380e-01f, 1.58914834e-01f, 2.27358326e-01f, -1.21433511e-01f, -1.08754188e-01f, 1.57406047e-01f, 8.82686973e-02f, -5.81689700e-02f, 2.13459074e-01f,
  -9.65011269e-02f, 1.30813763e-01f, 2.07295030e-01f, -7.25914165e-02f, 1.56607464e-01f, -5.06425723e-02f, -1.64586172e-01f, 1.73746929e-01f, -1.23942912e-01f, -6.16251752e-02f,
  1.04035057e-01f, 5.66988766e-01f, 3.18964899e-01f, -1.53778806e-01f, -2.62009323e-01f, -1.06651738e-01f, 5.56239374e-02f, -2.52906561e-01f, -2.85666913e-01f, -1.59562185e-01f,
  -2.27213040e-01f, -2.55706608e-01f, 4.93365861e-02f, 3.41199934e-02f, -2.19848063e-02f, 3.89758833e-02f, 1.57885775e-01f, -1.67643234e-01f, 1.07357599e-01f, 1.02648713e-01f,
  -1.10728487e-01f, 2.13917628e-01f, 7.44721368e-02f, -1.52635902e-01f, 2.27428824e-01f, 1.68832421e-01f, -2.31269464e-01f, 1.12709478e-01f, 1.46224320e-01f, 3.67506407e-02f,
  4.33911905e-02f, -3.02224576e-01f, -5.75977825e-02f, 1.60415739e-01f, -2.14187741e-01f, 2.98589915e-01f, -7.11213872e-02f, -1.17849119e-01f, 2.82509267e-01f, 4.47159559e-02f,
  1.38947606e-01f, -1.49251103e-01f, -2.82384515e-01f, -2.27028996e-01f, 1.24664091e-01f, 5.74414544e-02f, -1.58305287e-01f, 4.32169512e-02f, 3.29842828e-02f, 1.85113341e-01f,
  8.79525095e-02f, -1.17429607e-01f, 7.37855360e-02f, 1.76345985e-02f, 2.11290091e-01f, -9.61585864e-02f, 7.27825016e-02f, 1.65026650e-01f, 1.93786889e-01f, -8.70486796e-02f,
  -1.27018858e-02f, -1.93061769e-01f, -5.51874228e-02f, 2.48856377e-02f, 1.61917150e-01f, -8.90708864e-02f, 1.24063894e-01f, -1.42964527e-01f, -6.97706565e-02f, 8.54275599e-02f,
  1.29137591e-01f, 2.78240480e-02f, -2.26799101e-01f, 2.59151757e-01f, -1.06436908e-01f, 2.78740734e-01f, -8.75152200e-02f, -6.22384809e-02f, 9.45745558e-02f, 1.37658119e-02f,
  9.83520895e-02f, -3.71881239e-02f, 6.78294152e-02f, 2.21329004e-01f, 4.31949906e-02f, 1.61833718e-01f, 9.75651219e-02f, 1.64832830e-01f, 5.66234030e-02f, -1.48613676e-01f,
  3.35836917e-01f, 5.28446697e-02f, -9.80863422e-02f, -2.00426415e-01f, 1.66272223e-01f, 1.30497843e-01f, 3.02652061e-01f, -1.29120335e-01f, 1.00476786e-01f, -1.68484136e-01f,
  -7.93845654e-02f, -1.30257115e-01f, -3.67331356e-01f, -4.48308326e-02f, 1.59069505e-02f, 1.37167156e-01f, 1.22744784e-01f, 1.57070234e-01f, 1.39871284e-01f, -1.36372030e-01f,
  1.39306918e-01f, 7.78328031e-02f, -1.23161428e-01f, -1.27918705e-01f, 2.12989852e-01f, 1.47624925e-01f, 1.88969195e-01f, 2.80802809e-02f, -1.66653395e-01f, 3.24000493e-02f,
  -2.62852877e-01f, -2.40331173e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.24483593e-01f, 2.65504662e-02f, -1.78339146e-02f, 2.31793419e-01f, 2.24765673e-01f, 1.70580477e-01f, 1.77858233e-01f, -2.79234871e-02f, -6.73107356e-02f, -9.96555686e-02f,
  -1.19642243e-01f, -1.11851387e-01f, 9.25400704e-02f, 5.37490845e-02f, 4.44482602e-02f, 2.11531907e-01f, 2.90076375e-01f, 3.31821293e-01f, -6.95146471e-02f, 1.76064357e-01f,
  -1.62562691e-02f, -8.93711150e-02f, 6.71014339e-02f, -1.11634750e-02f, 1.03233933e-01f, 2.33671173e-01f, -6.30349619e-03f, 1.11568004e-01f, 1.60784900e-01f, -1.32335275e-01f,
  -1.61771879e-01f, 3.14145125e-02f, 1.36850804e-01f, 5.69856949e-02f, 1.77460015e-01f, -9.84765962e-02f, 1.51577108e-02f, 9.46080387e-02f, -8.01428035e-03f, -3.01099688e-01f,
  -1.62817568e-01f, 2.33405456e-01f, 1.35937795e-01f, -9.64209512e-02f, -1.30011156e-01f, 2.93335259e-01f, 3.83580476e-01f, 1.71719179e-01f, 1.09073035e-01f, -1.08986214e-01f,
  -1.16280563e-01f, 5.42825423e-02f, 1.85775369e-01f, 4.29688990e-01f, -3.43445390e-02f, -1.85447097e-01f, 1.76724687e-01f, 2.19554201e-01f, 2.71226555e-01f, -1.21911012e-01f,
  -1.72786921e-01f, 3.59907188e-02f, 6.49981648e-02f, -2.54737258e-01f, -1.44565448e-01f, -6.20762445e-02f, -1.02141075e-01f, -2.02808324e-02f, 2.27745213e-02f, 1.20094374e-01f,
  -8.44399706e-02f, -1.07785307e-01f, 4.44770269e-02f, 1.93338856e-01f, -1.05869003e-01f, -1.72110394e-01f, 1.52896449e-01f, 1.60731301e-02f, -5.11762761e-02f, -8.81820470e-02f,
  6.52388111e-02f, -1.71995506e-01f, 8.57335478e-02f, -1.33106291e-01f, -1.49409264e-01f, -5.98918833e-02f, -7.51162171e-02f, -1.16264112e-01f, 1.48613602e-01f, -6.39716163e-02f,
  1.64755628e-01f, 5.38868122e-02f, -1.56514235e-02f, 6.83050826e-02f, 5.96557111e-02f, -3.95475067e-02f, 1.50761127e-01f, 1.00078717e-01f, 2.25149021e-01f, 6.89554214e-02f,
  1.11023702e-01f, -8.52049589e-02f, 2.14931555e-03f, 4.11308855e-02f, -6.24110624e-02f, -2.17999339e-01f, -2.03429341e-01f, -1.58536866e-01f, -1.45441622e-01f, 7.17288107e-02f,
  -1.01563312e-01f, -9.74723473e-02f, -9.86055434e-02f, 4.91893962e-02f, -8.26039165e-03f, -1.27845734e-01f, -5.03155366e-02f, 8.19687769e-02f, 1.43553123e-01f, 9.78199095e-02f,
  -1.14462152e-01f, 1.71960130e-01f, 1.40272960e-01f, 2.21080139e-01f, -1.33123174e-01f, -6.85858727e-02f, -2.33676061e-01f, -1.61008202e-02f, -4.64714132e-02f, -3.64733003e-02f,
  -9.50886607e-02f, 7.53905177e-02f, -1.08829901e-01f, -4.06184644e-02f, -4.85217851e-03f, -4.06698062e-04f, 1.82494581e-01f, -9.45576355e-02f, -1.64380044e-01f, -1.48528323e-01f,
  -1.08329579e-02f, 1.15484871e-01f, 1.84732210e-02f, 2.66750842e-01f, 1.80111915e-01f, 1.15446448e-01f, -1.13330580e-01f, 2.42643237e-01f, 1.14064604e-01f, -8.91109034e-02f,
  5.31644486e-02f, 6.41708523e-02f, -2.19739191e-02f, -6.15785457e-02f, -9.69330892e-02f, 2.20906343e-02f, -7.13702738e-02f, -1.78191304e-01f, -6.73061535e-02f, 6.03812784e-02f,
  -1.76962227e-01f, 3.49652395e-02f, 8.14598054e-02f, 1.88638698e-02f, -1.21182511e-02f, -1.71988890e-01f, 1.22155901e-02f, -1.50915384e-01f, 7.60663226e-02f, 4.72538397e-02f,
  1.06000304e-01f, 1.75362259e-01f, 5.65698482e-02f, 3.32163274e-02f, 1.57463402e-01f, -8.14865306e-02f, -1.51274443e-01f, 9.75396037e-02f, -9.87561643e-02f, 1.13497928e-01f,
  1.55495107e-01f, -1.14774130e-01f, 1.06013976e-01f, 1.55469507e-01f, 3.31425481e-02f, 8.57354403e-02f, -1.87767930e-02f, -1.32233173e-01f, -2.97586736e-03f, -1.10387214e-01f,
  2.88494937e-02f, -1.42944068e-01f, 1.73251659e-01f, 1.51857913e-01f, 5.07361293e-02f, 2.94915983e-03f, 1.28771388e-03f, 2.13695750e-01f, 1.36381492e-01f, -4.90205921e-02f,
  -1.10615604e-01f, 1.01745194e-02f, -4.79618013e-02f, 6.75854012e-02f, 9.19685811e-02f, -1.37246311e-01f, -1.06148243e-01f, -1.43734545e-01f, 3.20526399e-02f, 4.34330478e-02f,
  1.20379671e-01f, 1.43326491e-01f, -1.22283891e-01f, -2.29787827e-02f, -8.04999098e-02f, 5.37274182e-02f, -1.39753491e-01f, 1.44160509e-01f, -2.45749075e-02f, 1.23839015e-02f,
  -3.36262770e-02f, 4.88014445e-02f, -1.18846260e-01f, -1.76730946e-01f, -1.90039590e-01f, 7.20487908e-02f, 6.15732446e-02f, -1.54028445e-01f, -1.23216614e-01f, -1.59036845e-01f,
  1.52087748e-01f, 1.08309723e-01f, -1.21491648e-01f, -4.30564173e-02f, -1.05572149e-01f, -3.26272249e-02f, 1.25820637e-01f, 6.38901889e-02f, 2.35596094e-02f, -5.68725318e-02f,
  7.91829303e-02f, 7.27485120e-02f, 7.77665619e-03f, -6.68740571e-02f, 1.02425195e-01f, 2.02611182e-02f, -1.03182912e-01f, 9.47243124e-02f, 1.45460293e-01f, -1.18138745e-01f,
  -5.92869259e-02f, -1.10464074e-01f, -1.65223509e-01f, -6.61738813e-02f, 6.72806427e-02f, -2.71164943e-02f, 5.78827381e-01f, 4.67757851e-01f, 5.03692865e-01f, 3.53611588e-01f,
  2.81727225e-01f, 4.53141451e-01f, 7.61872455e-02f, -3.68314087e-01f, 1.94256974e-03f, 3.89267923e-03f, -2.11009122e-02f, -2.31613472e-01f, -1.89885437e-01f, 1.84460491e-01f,
  2.59632975e-01f, 1.53294846e-01f, 9.67729017e-02f, 1.31208241e-01f, -1.63737610e-02f, -1.80644110e-01f, 6.36321232e-02f, 1.91893026e-01f, -5.41657694e-02f, -2.29880244e-01f,
  1.56634197e-01f, 3.21450025e-01f, 2.77304709e-01f, 5.76058365e-02f, -1.34423211e-01f, 1.33660093e-01f, -6.63114153e-03f, -3.17144305e-01f, 2.03254253e-01f, 1.19554467e-01f,
  1.95538700e-01f, -8.44662823e-03f, 8.65578875e-02f, 2.83706516e-01f, -3.01474631e-01f, 5.20021796e-01f, 3.20820510e-01f, 2.48230278e-01f, -3.42639714e-01f, -3.36826265e-01f,
  -5.63992537e-04f, -6.93533719e-02f, 1.31546378e-01f, 6.67390227e-02f, -2.11745515e-01f, -3.37408394e-01f, -3.58286127e-02f, 9.41524431e-02f, 1.48057053e-02f, 4.05402720e-01f,
  -5.99566624e-02f, -8.33700746e-02f, 2.35077277e-01f, 2.32084230e-01f, 5.10471174e-03f, 1.69332802e-01f, -5.36585078e-02f, -1.45256057e-01f, 4.75520760e-01f, 1.04345985e-01f,
  3.13342184e-01f, 5.57400100e-02f, 1.29560351e-01f, 2.93969154e-01f, 3.42163414e-01f, 8.78932402e-02f, -2.60824651e-01f, 4.57751453e-01f, 3.45385045e-01f, -7.58899748e-02f,
  -3.44652057e-01f, -2.34991401e-01f, 1.03942782e-01f, -1.61346942e-01f, -1.94524050e-01f, 1.63875613e-02f, -1.38831243e-01f, 1.98692968e-03f, -8.14130828e-02f, 3.04814488e-01f,
  -6.78894073e-02f, -1.88953310e-01f, -2.01104075e-01f, -7.25364313e-02f, -1.10933118e-01f, 2.28281155e-01f, 3.58363800e-02f, 3.58223729e-02f, 2.11063102e-01f, -1.15775086e-01f,
  1.02970459e-01f, -3.54065560e-02f, -3.42825204e-01f, 5.64037375e-02f, 2.26809010e-01f, 3.42518575e-02f, 9.71289501e-02f, -6.15455909e-03f, -5.43218732e-01f, 1.02703720e-01f,
  -3.24281007e-01f, 4.82015610e-01f, 1.09213144e-02f, 5.59122041e-02f, 4.70390409e-01f, 6.22750998e-01f, 7.61240005e-01f, -2.30583996e-01f, -2.13876620e-01f, -2.38772765e-01f,
  -1.36380091e-01f, 3.44033130e-02f, -2.10704684e-01f, 3.97575706e-01f, -1.15180776e-01f, -1.87181652e-01f, 3.04162502e-02f, 1.18879713e-01f, 1.08774386e-01f, -2.73550242e-01f,
  1.70894504e-01f, 1.31374314e-01f, 6.70290411e-01f, 3.08512330e-01f, 2.73741752e-01f, 7.06590265e-02f, 4.77630123e-02f, 1.00183055e-01f, 1.17826916e-01f, 1.29602432e-01f,
  1.66581750e-01f, 1.62335292e-01f, 9.13379248e-03f, -2.01057047e-01f, -6.49916157e-02f, 1.22864522e-01f, -1.41023204e-01f, 1.69835970e-01f, -1.39605314e-01f, 2.40603849e-01f,
  1.80844948e-01f, 1.83428332e-01f, -1.05404466e-01f, 2.19023064e-01f, -2.31163818e-02f, 6.98979273e-02f, 1.09926522e-01f, 1.23841576e-01f, -1.32994533e-01f, 9.92159173e-02f,
  5.83679751e-02f, 2.69356906e-01f, 7.19284117e-02f, -6.64653704e-02f, -6.42761961e-02f, 1.25225276e-01f, 3.55948925e-01f, 5.30015528e-02f, 3.04507583e-01f, 9.72161666e-02f,
  1.67132646e-01f, 3.74466062e-01f, 5.15217967e-02f, -5.46985388e-01f, -1.65566146e-01f, 6.40909821e-02f, 4.83927578e-01f, 2.97320068e-01f, 4.44992125e-01f, 5.38810968e-01f,
  5.58840990e-01f, 1.55572668e-01f, 7.19927177e-02f, 1.30109444e-01f, -1.20373346e-01f, -9.61790681e-02f, 1.39976934e-01f, 5.06424159e-03f, -1.67549744e-01f, 2.50662826e-02f,
  1.58368349e-01f, 7.69428760e-02f, 2.47467533e-01f, -1.64873153e-01f, -5.91578372e-02f, 4.16367576e-02f, 2.58906424e-01f, -3.45291272e-02f, 1.16529331e-01f, -1.03411257e-01f,
  -5.22955731e-02f, 3.02770846e-02f, -1.67031825e-01f, -1.70439154e-01f, 1.41234189e-01f, 5.12626320e-02f, 6.68728445e-03f, -9.01704878e-02f, 1.82202742e-01f, 1.06408857e-01f,
  -1.91768464e-02f, -7.85326883e-02f, 3.27803642e-02f, 1.06939778e-01f, 3.26336399e-02f, -1.38242871e-01f, -1.38481721e-01f, 9.68823358e-02f, 1.51221193e-02f, 1.57527059e-01f,
  1.05497852e-01f, 9.50295255e-02f, 3.59476656e-02f, 4.71665747e-02f, -1.14714190e-01f, 3.72355990e-02f, -1.57999903e-01f, 6.46803379e-02f, -1.81796089e-01f, 2.13689804e-02f,
  3.83969992e-01f, 1.45380750e-01f, 1.00826584e-01f, 2.73403764e-01f, 3.29750001e-01f, 4.35405433e-01f, -1.50132135e-01f, 3.78170699e-01f, 4.73980159e-01f, -4.10089910e-01f,
  -3.74181956e-01f, -7.42295086e-02f, 3.29192393e-02f, -8.46799016e-02f, -1.84544638e-01f, -5.88454157e-02f, 7.98735395e-02f, -3.13036479e-02f, -6.14238940e-02f, 4.25690800e-01f,
  -3.46500538e-02f, -2.92939574e-01f, -2.51290888e-01f, -1.09899491e-01f, 1.98514089e-01f, 3.02940607e-01f, -1.91984847e-01f, 3.12516123e-01f, 2.04444572e-01f, -1.70064287e-03f,
  1.19689889e-01f, 9.03718024e-02f, -1.49079204e-01f, -1.02488093e-01f, 1.58821315e-01f, 2.08342880e-01f, 5.34978695e-02f, -3.54190208e-02f, -2.51394749e-01f, -1.14814386e-01f,
  -3.88091663e-03f, 6.91148490e-02f, -2.35504746e-01f, -2.08214164e-01f, -2.40124632e-02f, 8.11638609e-02f, 4.19224389e-02f, -1.56063408e-01f, -1.63424462e-01f, -6.96241036e-02f,
  -1.36573568e-01f, -4.92174402e-02f, 3.55052650e-02f, -2.63831206e-02f, 1.15217395e-01f, -9.99656990e-02f, 2.45677326e-02f, 8.08150247e-02f, -5.65940980e-03f, 1.07282475e-01f,
  1.74069017e-01f, -5.46505488e-02f, 5.76999858e-02f, -3.24814171e-02f, 1.75099522e-01f, -6.66873623e-03f, -2.52409130e-02f, 1.30679995e-01f, 1.79266661e-01f, 2.31808156e-01f,
  9.68217701e-02f, -3.70506078e-01f, -5.10625467e-02f, -1.39199436e-01f, 1.91466287e-01f, 7.86710531e-02f, 1.24867029e-01f, 1.26578867e-01f, -5.49375974e-02f, 4.52594101e-01f,
  2.62777478e-01f, 4.82969046e-01f, -1.61148027e-01f, 1.58328459e-01f, 1.07966274e-01f, -1.54436857e-01f, 1.56993940e-02f, -1.82895921e-02f, 1.56865329e-01f, -3.89307812e-02f,
  -1.41428694e-01f, 1.70870826e-01f, -1.70460403e-01f, -1.21493071e-01f, -8.52287263e-02f, -1.03053033e-01f, 1.30605400e-01f, -9.36973933e-03f, -7.15528652e-02f, 8.06006491e-02f,
  4.52731699e-02f, -1.16710879e-01f, 1.70184612e-01f, -1.18499190e-01f, 1.72517732e-01f, -7.00671524e-02f, -5.10545447e-02f, 1.82726439e-02f, -6.68672547e-02f, -1.62110068e-02f,
  -1.74774021e-01f, 9.83964279e-03f, -4.66623567e-02f, -1.02076761e-01f, 1.39036879e-01f, 1.65861651e-01f, -5.44059239e-02f, 1.20285437e-01f, -8.83437395e-02f, 1.25152633e-01f,
  8.66831765e-02f, -1.28108487e-01f, 1.58083647e-01f, -1.63146421e-01f, 3.46043669e-02f, 1.03476740e-01f, 4.54482399e-02f, -1.77189428e-02f, 1.10290840e-01f, 1.48649886e-01f,
  -5.29239289e-02f, 1.24125548e-01f, 2.26953775e-01f, 5.05680256e-02f, -5.27145192e-02f, 3.74290764e-01f, -1.20158438e-02f, 1.94203556e-01f, -8.64097103e-02f, -3.16047877e-01f,
  -6.67872205e-02f, 1.25244111e-02f, -1.14251655e-02f, 1.35675862e-01f, -1.75533667e-02f, -2.07634017e-01f, -1.36835814e-01f, 2.77419209e-01f, 9.14865285e-02f, 3.40144128e-01f,
  1.94978550e-01f, -4.75437455e-02f, 3.50245228e-03f, 1.19857445e-01f, -1.37130812e-01f, -1.77691996e-01f, 1.32346973e-01f, -1.00292645e-01f, 4.25539702e-01f, 2.19667599e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  3.53734680e-02f, 8.82559344e-02f, 2.07201168e-01f, 2.04998255e-01f, -2.67898515e-02f, 4.48399447e-02f, 2.00955719e-01f, 1.80134363e-02f, 3.87566328e-01f, 3.33657444e-01f,
  4.47280467e-01f, 3.38449746e-01f, 2.41577923e-01f, 2.91156113e-01f, -1.12919681e-01f, 2.57255971e-01f, 1.03817834e-02f, 1.94562167e-01f, -2.73129158e-02f, 2.25965545e-01f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -2.44872496e-01f, -1.61504000e-01f, -1.11680292e-01f, -2.46923521e-01f, -2.22320557e-02f, -1.82091936e-01f, -1.78076759e-01f, 2.47567981e-01f, 4.18196529e-01f, -7.05862269e-02f,
  6.65104389e-02f, 1.24608256e-01f, 5.80349416e-02f, 1.68822776e-03f, 2.13598218e-02f, -1.95291370e-01f, 1.81688175e-01f, -9.05645862e-02f, -1.57236502e-01f, 8.77624676e-02f,
  -1.15397997e-01f, 2.62950897e-01f, 1.73369288e-01f, -1.76651344e-01f, 5.67611791e-02f, -1.54023588e-01f, -1.61262210e-02f, 2.59039462e-01f, -1.23447970e-01f, -1.36700183e-01f,
  4.81355153e-02f, 1.87902331e-01f, -1.25461534e-01f, 1.95123151e-01f, 2.26970434e-01f, 2.01142058e-01f, 5.34871221e-02f, 7.35501647e-02f, -2.55378097e-01f, 3.10874611e-01f,
  3.40805590e-01f, 4.09508636e-03f, -2.07097545e-01f, -2.59398758e-01f, -4.04787436e-03f, -2.23000705e-01f, -1.01456359e-01f, 4.15600091e-03f, 8.07265267e-02f, -1.17980205e-01f,
  -3.53788175e-02f, -5.13013564e-02f, -2.29845792e-01f, 1.34787425e-01f, 8.77970681e-02f, 1.09199576e-01f, 1.25630900e-01f, -3.07782710e-01f, -1.46786377e-01f, 4.62723449e-02f,
  1.77134480e-02f, -8.10331553e-02f, 7.27447495e-02f, 3.39235395e-01f, 1.37907401e-01f, -1.13897230e-02f, -5.19115515e-02f, -1.08133033e-01f, -6.32543564e-02f, -4.19091918e-02f,
  9.62578133e-02f, -2.60946065e-01f, -3.76385272e-01f, -8.03136006e-02f, -9.62281153e-02f, 9.09588635e-02f, 8.34480673e-02f, 1.14140123e-01f, 1.02411903e-01f, 1.24896504e-02f,
  1.42249823e-01f, 1.81697875e-01f, -8.04680139e-02f, -9.20342505e-02f, 1.03924207e-01f, -3.36863786e-01f, -9.58525687e-02f, -3.69296037e-02f, -1.93649992e-01f, 3.20615411e-01f,
  -2.50430480e-02f, -3.43197733e-01f, 1.79795489e-01f, 6.72173966e-03f, 4.27765399e-02f, -9.64627489e-02f, 5.61741069e-02f, -1.07418254e-01f, 1.51156902e-01f, 3.70459296e-02f,
  -1.23134211e-01f, 1.11287251e-01f, -8.51938650e-02f, -7.20977411e-02f, 3.59711726e-03f, 1.84510946e-01f, -2.05175713e-01f, 1.01127669e-01f, 4.79448326e-02f, 2.58484453e-01f,
  1.31365597e-01f, 2.61161625e-02f, 1.17408559e-02f, -7.97487050e-02f, -1.71729624e-01f, 8.08163136e-02f, 5.63962311e-02f, -9.55947265e-02f, -3.00641209e-01f, 2.70932108e-01f,
  -9.08072740e-02f, 4.63139899e-02f, 1.43070072e-01f, -2.96710610e-01f, 5.33184335e-02f, -2.54481018e-01f, -1.94921240e-01f, -8.20919424e-02f, -2.57112533e-01f, -1.69851184e-01f,
  -2.56372720e-01f, -3.18152942e-02f, -8.80360603e-02f, -2.32454315e-02f, -8.24059546e-02f, -8.27649534e-02f, 1.11599475e-01f, -1.23435082e-02f, -1.21390419e-02f, -3.55580866e-01f,
  3.78427841e-02f, -2.13192359e-01f, 1.88657656e-01f, 7.35703632e-02f, 1.42153561e-01f, 5.88817969e-02f, -5.96688548e-03f, 2.26333831e-03f, -1.80860028e-01f, 1.26938999e-01f,
  1.85915112e-01f, 3.55566323e-01f, 4.54109646e-02f, -2.30230957e-01f, -1.30020142e-01f, 2.18774080e-01f, 1.46486878e-01f, -2.99639553e-01f, -8.22851732e-02f, 1.45682916e-01f,
  6.71305805e-02f, 8.58618170e-02f, -2.03822330e-01f, -2.67181545e-02f, -1.01032769e-02f, -6.51425915e-03f, 7.41024911e-02f, -1.51718557e-01f, -1.15664996e-01f, -2.46893570e-01f,
  2.24564746e-01f, -5.10612689e-02f, 1.39070854e-01f, 3.58511433e-02f, -2.67014150e-02f, 1.32263258e-01f, 8.39977637e-02f, -8.86437520e-02f, 2.30963096e-01f, -1.15783758e-01f,
  -5.39259128e-02f, -4.40353423e-01f, -2.51062009e-02f, -2.00725734e-01f, 2.16462851e-01f, 4.79872257e-01f, -8.69011655e-02f, 2.80250460e-01f, -1.51429670e-02f, 1.09305829e-02f,
  -9.65069532e-02f, -3.83065045e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  3.78292091e-02f, 3.53033431e-02f, 2.15241879e-01f, 1.16562001e-01f, 8.70370679e-03f, 2.97451645e-01f, -7.20422119e-02f, 1.38108373e-01f, -3.48606706e-02f, 2.54133046e-01f,
  -1.73459947e-01f, 5.86799979e-02f, -2.32280850e-01f, 1.94572628e-01f, 1.50276378e-01f, -5.55641577e-03f, -5.09832278e-02f, -1.17297530e-01f, 1.03889957e-01f, -8.62793475e-02f,
  2.58260686e-02f, 2.48736769e-01f, 7.49727339e-02f, 9.92982090e-02f, 8.99094194e-02f, -1.26262277e-01f, -6.79289326e-02f, -7.02796131e-02f, 1.47827104e-01f, -1.35136425e-01f,
  -1.23236641e-01f, 1.50551707e-01f, 2.74693936e-01f, 1.16566226e-01f, 3.77379417e-01f, 3.53025496e-01f, 6.09366670e-02f, 2.67915964e-01f, 5.84060000e-03f, 1.67557299e-01f,
  -3.50573838e-01f, 3.38461250e-02f, 9.59404930e-02f, 4.20692772e-01f, 7.33439326e-02f, 4.14014250e-01f, -2.95593701e-02f, 7.61865973e-02f, -1.79746717e-01f, 1.28668770e-01f,
  1.68747827e-01f, -7.61497766e-02f, 6.42292976e-01f, 5.27427122e-02f, -6.93269521e-02f, -1.40342221e-01f, -2.46521458e-02f, 4.13895398e-02f, -7.93065727e-02f, -2.30269030e-01f,
  -1.81347597e-02f, -8.05483609e-02f, -3.49903516e-02f, -9.88524929e-02f, 1.58590466e-01f, -2.42707014e-01f, 3.42495292e-02f, -6.70914575e-02f, 2.59855352e-02f, 2.70793103e-02f,
  -2.94396449e-02f, -3.08272511e-01f, 1.01119459e-01f, 1.25607461e-01f, 4.34357785e-02f, -1.49806559e-01f, 9.18343216e-02f, -1.73365250e-01f, -5.31288162e-02f, 9.42843258e-02f,
  -9.32027847e-02f, 7.57721141e-02f, -1.48564279e-01f, -4.02408578e-02f, -1.18798882e-01f, -2.10805476e-01f, -7.63366371e-02f, 3.69301260e-01f, -6.05531335e-02f, 1.65385813e-01f,
  1.20942943e-01f, 2.64606774e-01f, 1.31122261e-01f, 1.01672724e-01f, 3.93371843e-02f, -1.53476968e-01f, 9.36693475e-02f, -2.37592719e-02f, -1.63374424e-01f, -1.98885854e-02f,
  5.65071367e-02f, -1.86424494e-01f, 2.26634607e-01f, -9.89980549e-02f, 1.92574352e-01f, -2.80670196e-01f, 2.71961093e-01f, 2.40692466e-01f, 3.42742115e-01f, 2.05649287e-01f,
  8.60465318e-02f, -1.14240982e-01f, 1.89839676e-01f, -4.68530357e-02f, 3.90539095e-02f, -5.77162392e-02f, 2.30346173e-01f, 1.81202993e-01f, 2.98737824e-01f, -2.28211626e-01f,
  3.89183670e-01f, 5.05892932e-02f, -1.18372366e-01f, 2.06974089e-01f, 7.42380768e-02f, 4.39420730e-01f, -4.92600203e-02f, 2.59686530e-01f, -6.25149980e-02f, -1.66434441e-02f,
  -2.36054640e-02f, 5.75783141e-02f, -4.91126701e-02f, 2.09300116e-01f, -5.51066920e-02f, 2.28653595e-01f, 1.76577270e-01f, -6.41458333e-02f, 1.59394249e-01f, 1.13101698e-01f,
  6.46037655e-03f, -6.07853290e-03f, 3.10802832e-02f, -5.63713685e-02f, 2.94493958e-02f, 6.33529155e-03f, -5.68094887e-02f, -1.88646376e-01f, -3.79367210e-02f, 2.31564224e-01f,
  2.89883733e-01f, -1.36615321e-01f, 5.01708388e-02f, 1.32102609e-01f, -6.10112073e-03f, 2.50522047e-01f, -1.28667438e-02f, 4.43326980e-02f, 1.04072168e-02f, 1.03261128e-01f,
  1.45233378e-01f, -9.63739455e-02f, -7.45652542e-02f, -3.64084840e-02f, -1.82259995e-02f, 1.46173928e-02f, 3.15334350e-02f, 1.52308002e-01f, -1.54378191e-01f, 2.47926544e-02f,
  3.60865630e-02f, 1.92887053e-01f, 9.36422572e-02f, -1.66140473e-03f, -1.28188133e-01f, -7.03271031e-02f, -6.20148592e-02f, -2.42674071e-02f, 1.39492422e-01f, -3.62379737e-02f,
  3.19347441e-01f, 1.40190303e-01f, -1.69994876e-01f, -5.85325323e-02f, -1.64192528e-01f, 1.04135036e-01f, 4.08540368e-02f, 1.36507317e-01f, 5.21739423e-02f, -7.31128901e-02f,
  7.03751147e-02f, 5.70057929e-02f, 1.98716391e-02f, 1.82859600e-02f, 1.87873706e-01f, -1.23448998e-01f, -1.71976499e-02f, 8.76837000e-02f, -1.96013391e-01f, -1.13473468e-01f,
  -1.41675547e-01f, -1.75350502e-01f, 2.07061842e-01f, 3.08404807e-02f, -5.74404821e-02f, 2.48871837e-02f, -3.88097949e-02f, -2.23906133e-02f, -1.32136554e-01f, -3.93216871e-02f,
  8.51925835e-02f, 2.83435900e-02f, 4.44941036e-02f, -5.73857799e-02f, 2.97352411e-02f, -2.03637272e-01f, 2.30088934e-01f, -1.25045568e-01f, 1.14161707e-03f, 2.66753912e-01f,
  -9.14600641e-02f, 3.03235557e-02f, 1.66159615e-01f, -1.01252027e-01f, 7.92396665e-02f, -1.47879839e-01f, 1.73809335e-01f, -1.91495150e-01f, -1.39659077e-01f, -7.67958164e-02f,
  2.17673890e-02f, -1.77921847e-01f, 1.07408725e-01f, 2.09742397e-01f, -2.26797745e-01f, 6.48156255e-02f, 1.12091236e-01f, -2.12242648e-01f, 3.79051529e-02f, 4.36892314e-03f,
  -2.36947853e-02f, 1.42650202e-01f, 6.74541965e-02f, -1.21728480e-01f, 6.29590228e-02f, -1.87620223e-01f, -7.43469819e-02f, 1.95454851e-01f, 9.48025659e-02f, 5.12424298e-02f,
  -1.45439640e-01f, -1.65713236e-01f, -1.28483381e-02f, 1.01463370e-01f, -1.60226420e-01f, -6.45119101e-02f, 4.31952439e-02f, 3.70713323e-01f, 1.69983298e-01f, 2.06814259e-01f,
  2.78914660e-01f, 2.50595719e-01f, 9.17443037e-02f, -1.10385813e-01f, -2.31051341e-01f, -4.54027683e-01f, 7.50709176e-02f, 2.67066240e-01f, 3.48045737e-01f, 7.63353705e-02f,
  -1.83127493e-01f, -2.37351377e-02f, 6.79339170e-02f, 9.03161895e-03f, 8.60787630e-02f, -1.97402865e-01f, 5.15571594e-01f, -2.57475406e-01f, 7.43480399e-02f, -5.89406431e-01f,
  2.22785071e-01f, 4.26772356e-01f, 1.33333027e-01f, 1.45322099e-01f, -1.83165148e-01f, 5.21510780e-01f, 1.94085643e-01f, -9.55102816e-02f, -7.11573660e-02f, -1.49554938e-01f,
  1.63481504e-01f, 1.36082008e-01f, 3.57956961e-02f, -1.61904290e-01f, 4.68100198e-02f, 8.71554911e-02f, -1.59423113e-01f, -7.85390735e-02f, -6.21923525e-03f, 1.10693701e-01f,
  1.13385849e-01f, 1.89038038e-01f, 7.26215690e-02f, -1.56820312e-01f, 1.80067927e-01f, 1.78420857e-01f, 1.31287321e-01f, 1.63343653e-01f, -1.16641551e-01f, 4.21885215e-02f,
  -1.80031717e-01f, -1.29917219e-01f, 9.68961641e-02f, -8.69430602e-02f, -8.69186521e-02f, 2.92699300e-02f, 1.73811559e-02f, 3.87810804e-02f, -1.61691040e-01f, -1.24894269e-01f,
  5.53089201e-01f, 3.89990836e-01f, 3.64833713e-01f, 3.05350095e-01f, 2.33231217e-01f, 1.89849824e-01f, 1.62686538e-02f, -2.30443627e-01f, -5.52187979e-01f, -6.10679127e-02f,
  -1.64062530e-01f, -1.10956602e-01f, 1.77539196e-02f, 3.65729690e-01f, -1.45949081e-01f, -1.17155947e-01f, -2.48999000e-01f, -1.10093981e-03f, -2.97061950e-02f, -5.18378057e-03f,
  4.70926046e-01f, -3.58708873e-02f, -2.47679114e-01f, 4.46934462e-01f, -9.20311809e-02f, 6.41542435e-01f, 2.94964463e-02f, -3.55204821e-01f, -2.04063669e-01f, -1.19493380e-02f,
  -6.32076710e-03f, 7.64875934e-02f, -4.32025231e-02f, 2.28861108e-01f, -9.14113820e-02f, -3.09139700e-03f, 1.62844896e-01f, 4.23495546e-02f, 2.88394064e-01f, -1.54730350e-01f,
  -3.25792640e-01f, -5.51921763e-02f, 1.33820876e-01f, 1.45693555e-01f, -3.66503671e-02f, 1.90298766e-01f, 1.03256200e-02f, 4.57952321e-02f, -4.60238419e-02f, -9.05552208e-02f,
  1.13006428e-01f, -5.48043177e-02f, 5.09145677e-01f, -3.95902097e-02f, -2.51405686e-01f, -1.57336548e-01f, 7.05046346e-04f, 3.96147341e-01f, -1.36387393e-01f, -1.26156613e-01f,
  1.65999085e-02f, 2.39887595e-01f, -6.63989708e-02f, -8.99141058e-02f, -9.50431228e-02f, -1.24208808e-01f, 1.63699031e-01f, 4.27725054e-02f, -7.13342205e-02f, 2.21125871e-01f,
  -1.60081312e-01f, 2.00649381e-01f, 9.50607806e-02f, -1.56934679e-01f, 2.07130775e-01f, 1.99673876e-01f, 2.24890009e-01f, -1.54744849e-01f, -8.93371105e-02f, 1.61588654e-01f,
  1.53600380e-01f, 1.33128062e-01f, 8.25786293e-02f, 9.36592594e-02f, -7.53981149e-05f, -3.43478424e-03f, 2.26475522e-01f, -4.15049464e-01f, 2.27591991e-01f, -5.88470474e-02f,
  -1.15797594e-01f, 3.52816045e-01f, -3.68106887e-02f, -1.98090374e-02f, -1.43009260e-01f, -1.62782252e-01f, -3.22742090e-02f, 2.04467140e-02f, -5.65969199e-02f, -6.12379052e-02f,
  1.46935090e-01f, -3.11809685e-02f, -2.52499208e-02f, -4.82062101e-02f, 1.19151315e-02f, 2.37475574e-01f, -1.08653195e-01f, -4.27190870e-01f, 4.55328636e-02f, 8.71399119e-02f,
  5.69585897e-02f, -8.13068300e-02f, 7.01885065e-03f, 1.34794369e-01f, 1.07988566e-01f, -1.21143587e-01f, 1.34380281e-01f, 3.83694500e-01f, -1.45332709e-01f, 8.67214859e-01f,
  -1.01026341e-01f, 2.92439073e-01f, -1.68759190e-02f, -7.63019621e-02f, 6.96832165e-02f, -2.75213659e-01f, -1.00217775e-01f, 5.54902703e-02f, 2.26328373e-01f, -1.53608201e-02f,
  -3.28024507e-01f, -1.11665718e-01f, 1.98104054e-01f, 4.41584587e-02f, 4.40025806e-01f, -3.73166054e-01f, -3.52207839e-01f, -4.31063324e-02f, -2.02031806e-01f, -4.55571041e-02f,
  -7.05655813e-02f, 4.37956363e-01f, 1.77448407e-01f, -2.41723582e-01f, -7.62095451e-02f, 1.74975768e-01f, -1.93812355e-01f, 2.50825696e-02f, 7.92104937e-03f, -2.12735794e-02f,
  -3.89506251e-01f, 7.63787508e-01f, -6.25397786e-02f, 7.11292624e-01f, 3.58508453e-02f, -1.99734896e-01f, 2.85030380e-02f, 1.02711327e-01f, -1.15801599e-02f, 2.60320026e-02f,
  2.02891499e-01f, 3.11851174e-01f, 1.07639112e-01f, 1.64321035e-01f, 2.32457846e-01f, 2.77164698e-01f, 1.70313969e-01f, -1.67572305e-01f, -3.88331385e-03f, -1.52616039e-01f,
  1.71263412e-01f, 1.39620062e-02f, 2.83832937e-01f, -1.95000574e-01f, 3.69834602e-02f, 1.76299781e-01f, 6.82870150e-02f, -1.01598449e-01f, 3.66947614e-02f, -1.36549592e-01f,
  4.31294650e-01f, -2.43419290e-01f, -2.24470235e-02f, -2.93785185e-01f, 2.82138973e-01f, 6.33943379e-02f, -1.44053355e-01f, 3.10228944e-01f, -1.57149389e-01f, 3.29526037e-01f,
  -1.51603386e-01f, -4.79693450e-02f, -2.14752793e-01f, -4.95702215e-03f, -1.13648966e-01f, -2.08033189e-01f, 1.83734626e-01f, -8.00468773e-02f, 1.16546810e-01f, 1.24213055e-01f,
  1.78729668e-02f, 2.18535125e-01f, 1.23722754e-01f, -1.83405861e-01f, 2.65237167e-02f, 1.76763147e-01f, -7.19537362e-02f, -2.78309397e-02f, -8.86358991e-02f, -1.68692484e-01f,
  9.52277631e-02f, 1.81560516e-02f, 1.19531259e-01f, 3.67875129e-01f, 1.57842815e-01f, 5.02220511e-01f, -1.09912962e-01f, 1.04505770e-01f, -9.09482390e-02f, 3.88711244e-02f,
  1.94823802e-01f, -1.27717704e-01f, 6.43761382e-02f, 2.98190862e-01f, 2.71679342e-01f, 3.00935417e-01f, 6.06087089e-01f, 5.64177930e-01f, 4.29272711e-01f, 6.26625776e-01f,
  -3.91598195e-01f, 4.18775797e-01f, 4.39775258e-01f, 7.37085193e-02f, -1.94640145e-01f, 1.11998223e-01f, 2.44120713e-02f, -7.83500597e-02f, 1.74500063e-01f, 1.98252454e-01f,
  -4.07086238e-02f, 2.92637572e-02f, 1.07073076e-01f, -1.90881282e-01f, 5.49015403e-01f, 8.26025188e-01f, 7.49716043e-01f, 3.29338759e-02f, 6.31701993e-03f, -1.14381537e-01f,
  -1.83350965e-01f, 8.02477658e-01f, 2.09406376e-01f, -2.98967421e-01f, 3.92107517e-02f, 4.41192180e-01f, -7.94835314e-02f, 1.85851827e-01f, -1.48432583e-01f, -1.84342802e-01f,
  -1.23697154e-01f, 4.13425313e-03f, 2.07302883e-01f, -1.49588019e-01f, -1.38228508e-02f, -3.23658437e-02f, -3.94584760e-02f, -1.02319874e-01f, 2.26665571e-01f, -4.61307466e-02f,
  1.51506066e-01f, -1.27420321e-01f, 7.47972280e-02f, -4.91855741e-02f, 1.14416584e-01f, -6.63546920e-02f, -8.35469812e-02f, 1.07103139e-01f, -1.57316700e-01f, 9.87474546e-02f,
  2.05443516e-01f, -7.22195581e-02f, -1.42611057e-01f, 7.75275528e-02f, 1.64500982e-01f, 1.93391383e-01f, 1.28415719e-01f, 1.76626280e-01f, 2.98366528e-02f, 1.25285029e-01f,
  1.42255992e-01f, 1.67692956e-02f, 3.72760482e-02f, 1.15316249e-01f, -1.31983086e-01f, 4.32631783e-02f, -1.07607275e-01f, -1.57983422e-01f, 9.39833745e-02f, 2.08144963e-01f,
  6.81664199e-02f, 1.22783678e-02f, 5.39830960e-02f, 1.32846609e-01f, -2.26788327e-01f, -2.84042284e-02f, 1.14131257e-01f, -1.47665650e-01f, 4.57018048e-01f, 1.33712113e-01f,
  1.20269589e-01f, -2.33457685e-01f, 1.70055017e-01f, 2.95196682e-01f, 1.73991211e-02f, 1.43047929e-01f, -3.57243009e-02f, -1.07110105e-01f, 1.17030002e-01f, -3.47919501e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  -4.06378880e-02f, -7.65800942e-03f, 6.34553581e-02f, 9.94789079e-02f, -3.23602892e-02f, 4.81891185e-02f, -8.52997154e-02f, -5.04750945e-02f, 1.78054497e-01f, -9.13850218e-02f,
  4.48678285e-01f, 2.07729578e-01f, 6.59660473e-02f, 1.64309874e-01f, 1.70617148e-01f, 2.23176807e-01f, -1.03678271e-01f, 3.53470653e-01f, -1.61641706e-02f, -4.75236811e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -4.97184545e-01f, -4.51767951e-01f, -3.77656519e-01f, 1.82782546e-01f, -2.51920879e-01f, -2.57188398e-02f, -4.15384680e-01f, -7.05475211e-02f, 3.80920231e-01f, 2.84699082e-01f,
  -3.68119627e-01f, 3.45035285e-01f, -3.00654583e-02f, 3.25404465e-01f, -1.00147426e-01f, -1.38438106e-01f, -1.02993384e-01f, 9.54991952e-02f, 6.00072667e-02f, -1.31090701e-01f,
  4.12742943e-01f, 1.58935219e-01f, 3.37973833e-01f, 5.61141670e-01f, 2.10453477e-02f, -2.13727221e-01f, 5.32536805e-01f, 6.83776066e-02f, 5.50432019e-02f, -7.07489371e-01f,
  1.10886460e-02f, 2.86531020e-02f, 2.85269797e-01f, 2.24703118e-01f, 3.81971002e-01f, -1.14455350e-01f, -5.61302062e-03f, 5.12713678e-02f, -8.25431570e-02f, -2.03123063e-01f,
  -2.34184712e-01f, -3.98510069e-01f, -5.78311145e-01f, 3.12157214e-01f, -1.42732829e-01f, 3.40798378e-01f, 1.51811332e-01f, 1.12090074e-01f, -4.27716970e-02f, 2.92227622e-02f,
  2.32213914e-01f, 2.08228752e-02f, 6.88013911e-01f, -1.09730512e-01f, 5.14237806e-02f, 1.37845978e-01f, 2.36134693e-01f, -5.86528242e-01f, -7.05841243e-01f, 5.38753092e-01f,
  -4.89440709e-01f, 1.27759770e-01f, -2.29202092e-01f, 2.67080456e-01f, -5.32893062e-01f, 3.30789527e-03f, -2.95704514e-01f, -4.28186238e-01f, 1.10958386e-02f, 9.98767316e-02f,
  3.00904185e-01f, 3.36163729e-01f, -6.99104294e-02f, -3.05553943e-01f, 3.61804813e-01f, 3.93911809e-01f, -1.62499949e-01f, -1.83268562e-01f, -1.28416969e-02f, 4.72705096e-01f,
  4.29091305e-01f, 8.53555510e-04f, 2.47175023e-01f, -4.49827351e-02f, 1.78680152e-01f, -1.30739138e-01f, -8.09647441e-01f, -1.13969110e-01f, 5.60648680e-01f, -5.29444516e-01f,
  -2.41893783e-01f, 1.04210250e-01f, -1.07056610e-01f, 3.83442909e-01f, -2.95456173e-03f, 9.09421667e-02f, -3.70537281e-01f, 1.36833012e-01f, -6.87032416e-02f, 1.44955851e-02f,
  1.59560759e-02f, -6.61680847e-02f, -3.41807812e-01f, -4.33811218e-01f, 3.25576127e-01f, -1.87991038e-01f, -1.70063134e-03f, -2.96646833e-01f, -2.24473421e-02f, 1.38052497e-02f,
  -3.05335894e-02f, -2.65672714e-01f, -2.64308989e-01f, 4.22709696e-02f, 1.12954244e-01f, -1.82562858e-01f, -4.04687434e-01f, -1.29804403e-01f, 3.46277237e-01f, 1.56891808e-01f,
  -5.01265489e-02f, 3.40490162e-01f, 4.06676054e-01f, -3.09440285e-01f, 3.24965954e-01f, -5.02243698e-01f, 1.01041635e-02f, -2.79774904e-01f, 5.93045093e-02f, 2.06809059e-01f,
  2.52473921e-01f, -2.44829461e-01f, 6.56914651e-01f, 1.70805259e-04f, -2.03944832e-01f, -1.77711606e-01f, -3.99502032e-02f, 4.86156791e-01f, -1.01864852e-01f, -5.49146712e-01f,
  2.16148406e-01f, 6.44752979e-01f, -3.18007827e-01f, -6.55187294e-02f, 6.47011697e-02f, 2.58213222e-01f, 2.89794116e-04f, 5.69778448e-03f, -4.42320287e-01f, 1.42615102e-02f,
  4.72899050e-01f, 1.56043053e-01f, -3.33331414e-02f, 1.31177502e-02f, 1.32009864e-01f, -3.96129429e-01f, 6.70868764e-03f, 1.07035540e-01f, -9.93178487e-02f, 9.58681479e-02f,
  1.20415285e-01f, 4.12930101e-01f, 2.80579120e-01f, 6.90873027e-01f, 4.37007785e-01f, 2.93492854e-01f, -5.71582437e-01f, -3.16298634e-01f, -7.06497878e-02f, 2.29859531e-01f,
  -2.28789032e-01f, 1.84877679e-01f, 2.19352022e-02f, 1.84459642e-01f, -7.42331669e-02f, -1.39635131e-01f, 6.95376322e-02f, 1.75867274e-01f, -1.17384642e-01f, 6.41876226e-03f,
  2.60799527e-01f, -1.97959214e-01f, 4.61906105e-01f, 1.54138118e-01f, -3.11762065e-01f, -7.63037279e-02f, -1.77653991e-02f, 3.61242205e-01f, -2.86732912e-01f, 2.73982733e-01f,
  3.15087102e-02f, 1.94630027e-01f, -2.02839747e-01f, -4.63063359e-01f, -3.29077601e-01f, -2.90276739e-03f, -3.15785408e-01f, -3.43640685e-01f, 7.18331158e-01f, 1.60012484e-01f,
  -2.20065683e-01f, -3.30769747e-01f, 3.46247226e-01f, -3.78269047e-01f, 3.13708961e-01f, -4.31440592e-01f, -3.38144787e-02f, 1.61566846e-02f, 1.87972099e-01f, -1.29270315e-01f,
  -2.12717086e-01f, 1.50172338e-01f, -3.74998838e-01f, -7.62144551e-02f, -8.77370715e-01f, -2.45274618e-01f, -1.36569634e-01f, -1.06904916e-01f, -4.95049030e-01f, -1.05546005e-01f,
  2.91448176e-01f, 8.94593239e-01f, -1.72049895e-01f, -2.49386430e-01f, -6.02807522e-01f, -2.30165929e-01f, -2.11073041e-01f, -2.96442479e-01f, 2.04769839e-02f, 1.29348440e-02f,
  -1.90719977e-01f, 9.16594826e-03f, 1.86000153e-01f, -1.28378943e-01f, 1.00004442e-01f, 5.14717579e-01f, -3.52255374e-01f, -3.45351934e-01f, 4.76438433e-01f, -1.16549224e-01f,
  -1.09941429e-02f, -1.54363677e-01f, 9.34826024e-03f, 2.29293004e-01f, -3.57714921e-01f, -5.77993020e-02f, 3.40927869e-01f, -3.60549241e-02f, -7.39638284e-02f, 3.20210993e-01f,
  6.91749334e-01f, -2.06808731e-01f, -9.20575187e-02f, -1.24302137e+00f, -3.55122536e-02f, -2.62430102e-01f, 6.92102984e-02f, -4.84211683e-01f, -2.23443225e-01f, -3.07207793e-01f,
  -3.51167738e-01f, -1.73853710e-03f, -1.42517731e-01f, -1.21589407e-01f, 2.24131659e-01f, -3.18698227e-01f, -3.94290060e-01f, -4.59803268e-02f, -1.15093021e-02f, -5.66683449e-02f,
  -4.38023498e-03f, 5.82908750e-01f, 1.02677338e-01f, 7.31778741e-02f, -1.23125777e-01f, -1.15385614e-01f, 6.64558768e-01f, 1.14429429e-01f, -1.55554622e-01f, 3.92789006e-01f,
  -4.95460667e-02f, -3.47778946e-01f, 3.20843607e-02f, 3.79639328e-01f, -1.88104287e-01f, -4.94644344e-01f, 2.89050251e-01f, -3.05529255e-02f, 5.64445198e-01f, 2.60378510e-01f,
  1.51473224e-01f, 3.53505701e-01f, 5.29741824e-01f, 4.77006435e-01f, 4.45674986e-01f, 2.49785766e-01f, -6.66630983e-01f, -2.96713084e-01f, 4.26288992e-01f, -9.18375403e-02f,
  1.06493175e-01f, 2.61940420e-01f, -6.00109750e-04f, -3.42717290e-01f, 1.74953658e-02f, -5.99694736e-02f, -5.91961890e-02f, 6.91676233e-03f, 6.18711412e-02f, -1.47085473e-01f,
  -2.59309828e-01f, -1.91809103e-01f, 3.30233872e-02f, -2.39636019e-01f, -5.96843779e-01f, 8.28133821e-02f, -2.81568188e-02f, 8.90790939e-01f, -1.76476687e-01f, 2.86459953e-01f,
  3.34215611e-01f, 1.11270465e-01f, -9.95578915e-02f, 2.91001379e-01f, -3.44612479e-01f, 7.48898974e-03f, 3.46058130e-01f, 4.58021462e-02f, -2.74029374e-01f, 3.20888489e-01f,
  1.30967811e-01f, -3.05915654e-01f, -1.92664891e-01f, -3.35278153e-01f, 2.85640091e-01f, -8.35057572e-02f, 9.57673118e-02f, 9.69182551e-02f, -4.88079824e-02f, -1.84229776e-01f,
  -3.21825653e-01f, 3.38080749e-02f, -1.95541307e-01f, -1.06447145e-01f, -3.22648466e-01f, 3.10643673e-01f, 1.35824597e-02f, -2.55744010e-01f, 4.36191976e-01f, 4.74943787e-01f,
  -1.16295330e-01f, 8.56083259e-02f, 5.64837515e-01f, 3.40282246e-02f, 5.29882193e-01f, -2.29953036e-01f, -2.54967719e-01f, -3.23892802e-01f, -3.93042892e-01f, 7.04029799e-01f,
  -2.30372399e-01f, 3.88952315e-01f, 4.36863780e-01f, -1.78899631e-01f, 2.16469035e-01f, -2.69081980e-01f, 1.26179364e-02f, -5.06103814e-01f, -1.24386162e-01f, -2.45855272e-01f,
  -1.99723393e-01f, 1.65190592e-01f, -3.83222759e-01f, -2.68942155e-02f, 3.58184576e-01f, -4.67809647e-01f, 8.09179898e-03f, 4.67169881e-01f, 1.86238781e-01f, -2.80813187e-01f,
  1.80127203e-01f, -8.15711617e-02f, 1.30206034e-01f, -3.52198958e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -8.12627152e-02f, -3.32957841e-02f, -9.52573307e-03f, -1.60572633e-01f, -1.03620604e-01f, 1.02402285e-01f, 9.26773176e-02f, -4.30875421e-02f, -1.85003445e-01f, 7.89372399e-02f,
  -1.52680472e-01f, 5.51441722e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    