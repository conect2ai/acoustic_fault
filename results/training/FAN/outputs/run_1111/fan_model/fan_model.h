/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.28438944e-01f, 6.42654533e-03f, 2.54799575e-01f, 1.94154114e-01f, -1.47621349e-01f, -2.08462626e-01f, -3.72812927e-01f, -7.43235573e-02f, 1.79717168e-01f, 3.78108174e-02f,
  2.34519113e-02f, 1.27007857e-01f, 7.69698694e-02f, 7.35044405e-02f, -6.18027151e-02f, -5.17830066e-02f, 1.27928987e-01f, 8.91005546e-02f, 6.49104267e-02f, -4.19437923e-02f,
  -1.65708233e-02f, 9.06641409e-02f, 1.13087714e-01f, 5.51558435e-02f, 2.23743707e-01f, 9.77200717e-02f, 1.03690729e-01f, 1.55803382e-01f, 4.15693931e-02f, 3.27422023e-01f,
  4.49493796e-01f, 1.63300276e-01f, -7.80819952e-02f, 1.39258251e-01f, 1.35229126e-01f, 1.30839795e-01f, 7.73785561e-02f, 1.51813164e-01f, 9.38370004e-02f, 1.76370427e-01f,
  6.30580187e-02f, 1.15649581e-01f, 6.26077950e-02f, 8.11978951e-02f, 1.77015200e-01f, 4.87876162e-02f, 7.55717605e-02f, 1.40522256e-01f, 6.78501278e-02f, 7.71335959e-02f,
  7.84900561e-02f, 8.58787149e-02f, 8.47449433e-03f, 8.99116993e-02f, 8.87760073e-02f, 1.53973430e-01f, -3.13744880e-02f, 1.95564076e-01f, 2.93612033e-02f, 2.26847351e-01f,
  3.40317580e-04f, -6.14147186e-02f, 7.36166211e-03f, -6.33605197e-02f, -1.00313835e-01f, -6.89306185e-02f, 4.57186438e-03f, -7.42298365e-02f, -1.07158579e-01f, -3.81598063e-02f,
  -6.91382438e-02f, -8.82907659e-02f, 9.88800451e-03f, -5.25375903e-02f, -7.22202733e-02f, -1.24899140e-02f, -2.04486735e-02f, -1.04322754e-01f, -1.39591083e-01f, -4.30105440e-02f,
  -5.88532947e-02f, -9.35649648e-02f, -8.89752060e-02f, -4.03847313e-04f, -6.20116517e-02f, -1.06445581e-01f, -7.93406069e-02f, -7.51140192e-02f, -4.41058092e-02f, -9.90049243e-02f,
  3.09628937e-02f, -1.90793067e-01f, 2.01222017e-01f, 7.58730620e-02f, 1.35928631e-01f, 6.16192892e-02f, 4.68375236e-02f, 9.21506621e-03f, 3.46469358e-02f, 1.55727312e-01f,
  5.84960878e-02f, 9.58215967e-02f, 3.17768008e-02f, 1.14437528e-01f, -5.27581945e-02f, 7.34181553e-02f, 3.04239374e-02f, 1.32748425e-01f, 9.81246959e-03f, 1.11673102e-01f,
  -2.99811568e-02f, -9.32616834e-03f, -6.54116943e-02f, -5.95257282e-02f, 6.04947358e-02f, 3.19212601e-02f, 4.54066209e-02f, -5.36341295e-02f, -1.14942966e-02f, -1.14526965e-01f,
  -3.53808880e-01f, 5.26352972e-02f, -2.02399656e-01f, 1.94396321e-02f, 6.65380433e-02f, -3.85324992e-02f, 1.24000654e-01f, 2.19761238e-01f, 2.24017769e-01f, 3.40880901e-02f,
  -2.60577407e-02f, -1.75944436e-02f, -8.10038298e-02f, -9.14997160e-02f, -1.56515375e-01f, -6.40580356e-02f, -9.20450985e-02f, -3.09994727e-01f, -2.22844094e-01f, -1.19276114e-01f,
  5.37469536e-02f, 2.71693226e-02f, -1.54181257e-01f, -1.16331391e-01f, -6.26405552e-02f, -8.43382776e-02f, -1.63472280e-01f, -1.89998835e-01f, -2.03582734e-01f, -2.90004283e-01f,
  -2.02965260e-01f, -2.34302948e-03f, -8.32885802e-02f, -8.14048797e-02f, -8.88991356e-02f, -2.43636221e-02f, -6.46054596e-02f, -4.58014607e-02f, 4.09981348e-02f, -3.26580778e-02f,
  -7.11543560e-02f, 2.20363736e-02f, -3.35557386e-02f, 9.21405628e-02f, -1.19066484e-01f, 4.98790145e-02f, -5.44944033e-02f, -8.45857114e-02f, -1.13576867e-01f, -1.61356176e-03f,
  4.52572219e-02f, -1.26874641e-01f, -5.93591966e-02f, -4.35385481e-02f, -6.50293306e-02f, -1.62749872e-01f, -1.12149797e-01f, -2.66087241e-02f, -8.19364861e-02f, -2.16706038e-01f,
  -5.63186854e-02f, -5.72559498e-02f, 9.02793109e-02f, 2.59853266e-02f, 1.48324341e-01f, 7.57710263e-02f, 1.01576440e-01f, -9.26446244e-02f, -1.72666356e-03f, -3.48559581e-02f,
  1.09012179e-01f, 9.21245888e-02f, -4.46009077e-02f, 6.38836101e-02f, 7.75146410e-02f, 3.84354442e-02f, 4.59267050e-02f, 1.10141281e-03f, 6.11562654e-02f, 1.14204481e-01f,
  7.26877674e-02f, -6.55143848e-03f, 7.57119153e-04f, 8.84307921e-02f, -3.84031646e-02f, 6.96647242e-02f, 7.97719359e-02f, 5.76880388e-02f, 7.59125203e-02f, 1.02412507e-01f,
  2.30593588e-02f, -1.91595510e-01f, -1.68763250e-01f, -5.72625771e-02f, -1.10689700e-01f, -1.07843801e-02f, -1.49348423e-01f, -3.68390381e-02f, 3.51850502e-03f, -3.92695107e-02f,
  -1.27843916e-01f, -5.10521047e-02f, -7.72359446e-02f, -7.12576583e-02f, -5.76794073e-02f, -6.23889640e-02f, -2.63657630e-03f, -1.72172725e-01f, -3.76740731e-02f, 4.22982424e-02f,
  3.02100927e-02f, -2.13645339e-01f, -1.99226931e-01f, -6.42671660e-02f, -8.57512653e-02f, -2.17776537e-01f, -2.14386731e-01f, -2.13585317e-01f, -2.04693675e-01f, -5.62885925e-02f,
  -2.64168233e-01f, -1.41218841e-01f, -1.30380690e-01f, -8.57540444e-02f, 3.00843883e-02f, 2.39513233e-01f, 1.49002656e-01f, 1.16349347e-01f, 1.09940380e-01f, -4.15710211e-02f,
  1.85880348e-01f, 2.52765685e-01f, 2.35015169e-01f, 2.32651159e-01f, 7.77005106e-02f, -3.85163985e-02f, -1.44866303e-01f, -3.60668413e-02f, 1.95777938e-01f, 4.12400924e-02f,
  -2.14996524e-02f, -1.52348593e-01f, -1.98854044e-01f, -1.08107172e-01f, -1.53439924e-01f, -6.49382249e-02f, -6.37249351e-02f, -1.23362467e-01f, -1.30275592e-01f, -3.35850567e-01f,
  -4.57014851e-02f, -8.02093819e-02f, 1.71113744e-01f, -1.94618609e-02f, -2.76498143e-02f, -7.83554018e-02f, 4.59741306e-04f, -6.75563887e-02f, -8.55385214e-02f, -2.50674039e-03f,
  -5.32168895e-02f, -3.75231057e-02f, -5.77342100e-02f, 9.86119267e-04f, 2.33784113e-02f, -6.71875663e-04f, -9.26423073e-03f, -3.81510258e-02f, -4.50515822e-02f, 2.96587422e-02f,
  -9.78894606e-02f, 4.80734371e-02f, 1.04437405e-02f, 1.27890006e-01f, 9.01762992e-02f, 1.05626300e-01f, -3.82662006e-02f, 3.52007374e-02f, 4.71212529e-02f, -1.30499616e-01f,
  7.23416582e-02f, -3.30725424e-02f, 9.54367965e-03f, -8.02591443e-02f, 6.19995929e-02f, 1.54745141e-02f, 6.72684098e-03f, -7.69964084e-02f, -5.77932484e-02f, -1.63773056e-02f,
  1.18767425e-01f, 2.71061249e-02f, 6.49362663e-03f, 2.51118597e-02f, -4.88176569e-02f, -3.54953445e-02f, 7.20143095e-02f, -1.28942868e-02f, -3.29015851e-02f, -4.32764925e-02f,
  2.16408912e-02f, -1.70633942e-02f, -3.28243896e-02f, 6.81621581e-02f, 6.64622709e-02f, 7.35338256e-02f, 8.21586046e-03f, 1.83032993e-02f, -2.91503128e-03f, -8.13873857e-02f,
  -1.49500445e-02f, 2.89740175e-01f, 1.81740371e-03f, 3.64584699e-02f, -5.89826480e-02f, 2.81247366e-02f, -5.75032495e-02f, 1.48292410e-03f, -3.95374596e-02f, -4.06841971e-02f,
  -2.75561959e-02f, 6.89346194e-02f, 4.66404557e-02f, 2.46780775e-02f, 1.05039753e-01f, 3.54890688e-03f, -6.67588115e-02f, 2.37565655e-02f, 1.29830420e-01f, -4.96867672e-02f,
  -2.07510069e-02f, 4.10114750e-02f, 1.70941651e-01f, 8.74390602e-02f, 7.14339986e-02f, 7.22156614e-02f, -1.06395397e-03f, 1.03143826e-01f, 1.08468749e-01f, 7.32779726e-02f,
  -4.15896773e-01f, 1.58030346e-01f, 3.12498897e-01f, -1.22064818e-02f, 3.51515085e-01f, 2.95456380e-01f, 4.28326786e-01f, 1.52909353e-01f, 4.27203067e-02f, -1.95798986e-02f,
  -5.85572561e-03f, -1.85895562e-01f, -1.92495510e-01f, -1.20000742e-01f, -1.38399199e-01f, 2.42518574e-01f, 2.13975951e-01f, -3.14817801e-02f, -1.69735432e-01f, 3.66986617e-02f,
  8.36865697e-03f, -1.69156149e-01f, -2.17100725e-01f, -1.19780272e-01f, 2.62725484e-02f, -1.19734742e-01f, 1.59312114e-01f, 8.09726343e-02f, 9.22780931e-02f, -5.54255843e-02f,
  -1.83574259e-01f, 1.75419331e-01f, -5.94244748e-02f, -9.35261622e-02f, 1.81712843e-02f, -6.54365346e-02f, 8.51902738e-02f, -5.29405884e-02f, 9.84811410e-02f, 7.03709607e-04f,
  -9.84913297e-03f, -4.75680754e-02f, -3.53927352e-02f, 6.67794421e-02f, 5.65090543e-03f, 9.03466493e-02f, -7.71308914e-02f, -3.39400358e-02f, 1.31904498e-01f, 5.81605546e-02f,
  -4.15443145e-02f, 1.43154368e-01f, 1.52682915e-01f, 1.93057254e-01f, 1.42076388e-02f, 1.91204287e-02f, 6.12424463e-02f, 1.45144954e-01f, 2.92700082e-02f, -6.62738755e-02f,
  -1.32390931e-01f, 8.47071931e-02f, -3.51544209e-02f, -4.92772534e-02f, -1.16412744e-01f, 2.52603292e-02f, -2.09255852e-02f, 3.35741006e-02f, -4.53086086e-02f, -3.67620997e-02f,
  5.70873450e-03f, -1.01273663e-01f, 4.38924916e-02f, -3.86996455e-02f, -1.68254599e-02f, -3.24570131e-03f, 6.90632612e-02f, -1.61940455e-02f, 2.56750751e-02f, -3.88203077e-02f,
  -1.36325493e-01f, 7.72868982e-03f, -4.90173697e-02f, -1.98904146e-03f, 2.04719435e-02f, -7.75865242e-02f, -6.20586127e-02f, -6.10683262e-02f, -4.69065942e-02f, -5.61336093e-02f,
  -1.87588438e-01f, 5.19059859e-02f, -1.14111118e-01f, -1.13319993e-01f, 1.08881541e-01f, 1.80957876e-02f, -1.00680925e-01f, 7.65853301e-02f, -8.57553910e-03f, 8.48978087e-02f,
  -1.15956366e-02f, 3.44434530e-02f, -4.63653821e-04f, -5.15967309e-02f, -4.65858951e-02f, -7.98152834e-02f, -7.00054467e-02f, 6.81915358e-02f, -1.68713182e-02f, 1.36745736e-01f,
  7.16631040e-02f, 1.57473579e-01f, -4.78602983e-02f, 1.01902626e-01f, 6.48325384e-02f, -8.79582837e-02f, 8.85898434e-03f, 3.27724926e-02f, -1.39312102e-02f, -1.25281975e-01f,
  -2.06036210e-01f, -5.90547398e-02f, -4.22119915e-01f, 1.12741619e-01f, 7.11371675e-02f, -1.14522025e-01f, 3.75186764e-02f, 1.29382133e-01f, 1.11269668e-01f, 4.85303476e-02f,
  -5.69398403e-02f, 1.19733037e-02f, -7.90793914e-03f, -4.76209298e-02f, 2.81355381e-02f, -1.00469120e-01f, -9.05377045e-02f, -2.10490376e-01f, -2.11030990e-01f, -7.87423477e-02f,
  1.83095261e-01f, 3.79583836e-02f, 1.19804116e-02f, -3.39872763e-02f, 3.15194242e-02f, 3.70382182e-02f, -1.40157685e-01f, -1.98679253e-01f, -2.29149833e-01f, -1.33500338e-01f,
  -3.17463875e-01f, -2.78111011e-01f, -1.74791683e-02f, -1.11607155e-02f, -1.10480085e-01f, -6.36963248e-02f, -1.45062193e-01f, -1.15472943e-01f, -5.09467721e-02f, -5.46230339e-02f,
  -1.31225646e-01f, -3.24093737e-02f, -2.74729775e-03f, -9.65570211e-02f, -1.42231733e-01f, -3.35796773e-02f, -1.10744223e-01f, -2.35915527e-01f, -1.90002277e-01f, -1.62534252e-01f,
  9.90452897e-03f, -1.25156090e-01f, -2.61402547e-01f, -1.53055325e-01f, -7.31390268e-02f, -2.11236954e-01f, -1.62713870e-01f, -1.73657030e-01f, -2.57894427e-01f, -4.35975293e-04f,
  -6.64771488e-03f, 1.11227538e-02f, 7.64081851e-02f, 1.36115372e-01f, 1.37483135e-01f, 3.20442654e-02f, 9.54136532e-03f, 4.03769836e-02f, 9.26826447e-02f, 1.24574676e-01f,
  1.17322862e-01f, 4.91742268e-02f, 1.50183752e-01f, 1.63295045e-01f, 1.50679097e-01f, 1.76549237e-02f, 4.85705771e-02f, 1.48968577e-01f, 3.98574434e-02f, 1.56412289e-01f,
  2.21601445e-02f, -3.93595360e-02f, 1.38848841e-01f, 1.16498232e-01f, -7.80051714e-03f, -1.60668697e-02f, 2.17123237e-02f, 3.37864123e-02f, 1.30487457e-01f, 8.42393711e-02f,
  3.47234935e-01f, -1.10684104e-01f, -2.77152359e-02f, -1.32652462e-01f, -5.67114390e-02f, -1.27508685e-01f, -7.83285573e-02f, -6.98824897e-02f, -1.63661838e-01f, -1.48149997e-01f,
  -6.05301671e-02f, -1.34085268e-01f, 1.55969597e-02f, -1.39119560e-02f, -1.30068764e-01f, -1.30121872e-01f, -2.25275643e-02f, -1.42244846e-01f, -8.16803426e-02f, -1.29167899e-01f,
  -9.26695839e-02f, -1.01847954e-01f, -7.87148401e-02f, 8.32408946e-03f, -9.13211703e-02f, -4.83747311e-02f, 1.67247653e-02f, -1.01764098e-01f, -2.66440641e-02f, 9.75354761e-03f,
  -3.47983390e-01f, 1.70937061e-01f, 1.28071122e-02f, -1.61466151e-01f, 2.33583197e-01f, 2.71616429e-01f, 3.24216485e-01f, 4.73592691e-02f, -9.40697640e-02f, 4.25118357e-02f,
  -3.35578658e-02f, -1.53892785e-01f, -1.83407173e-01f, -2.49475259e-02f, 4.68301512e-02f, 2.51469553e-01f, 1.07169472e-01f, -1.03663318e-01f, -1.10031120e-01f, 1.09316267e-01f,
  1.08984269e-01f, -6.79809600e-02f, -1.58255324e-01f, -1.44226104e-01f, -1.37954131e-01f, -1.22186065e-01f, -2.00063679e-02f, -1.49373546e-01f, 9.20274332e-02f, -1.14114452e-02f,
  6.18283916e-03f, -1.91657737e-01f, 3.62913385e-02f, -2.19302207e-01f, -5.52292839e-02f, -2.10409681e-03f, -6.12920821e-02f, -1.96289793e-01f, -1.21750357e-02f, 9.02665183e-02f,
  -9.60743353e-02f, -4.98785339e-02f, -1.38475135e-01f, -3.09807900e-02f, -7.88590610e-02f, -5.08568715e-03f, -1.04021206e-01f, -9.01292562e-02f, -9.99856368e-02f, 6.73171580e-02f,
  2.85539497e-02f, 3.82465348e-02f, -7.84388110e-02f, -2.28124503e-02f, -2.59797787e-03f, -4.94554192e-02f, -7.24312365e-02f, 2.11949814e-02f, -1.13281205e-01f, -6.61383420e-02f,
  9.11094025e-02f, 1.50033962e-02f, 4.58341613e-02f, 4.93231975e-02f, -5.57209458e-03f, -1.05822161e-02f, 4.30269018e-02f, 5.74246570e-02f, 6.02854267e-02f, 8.29219446e-02f,
  -1.92605704e-02f, 7.97771066e-02f, 4.95657213e-02f, 8.80618095e-02f, 1.98202003e-02f, 2.34716595e-03f, 1.04028862e-02f, 5.66405840e-02f, 8.88732169e-03f, -2.95322202e-02f,
  -2.96072569e-02f, -2.22029556e-02f, -4.90430407e-02f, -6.49749115e-02f, 5.81075661e-02f, -7.94382095e-02f, 5.16029596e-02f, -9.01948661e-02f, 7.07344478e-03f, -1.21192178e-02f,
  1.07367694e-01f, -9.41134468e-02f, -4.31422628e-02f, -8.31122249e-02f, -1.31853700e-01f, -1.52692914e-01f, 6.49897568e-03f, -1.19463757e-01f, -5.52909747e-02f, 5.68627454e-02f,
  -6.42405674e-02f, -8.57742801e-02f, 3.60728838e-02f, -6.70493543e-02f, 1.01860225e-01f, 5.79601489e-02f, -2.66475435e-02f, -8.38994905e-02f, -9.22885239e-02f, -8.97990242e-02f,
  -5.34957387e-02f, 6.44965172e-02f, 1.26557380e-01f, 1.39742807e-01f, -1.05994269e-02f, 2.94006374e-02f, 1.41655937e-01f, -1.97970569e-02f, 1.67611644e-01f, 2.20899940e-01f,
  -2.07358509e-01f, -1.38813749e-01f, 1.55753314e-01f, -2.92918444e-01f, -2.99843028e-02f, 5.55869415e-02f, -5.89751825e-02f, -1.29022315e-01f, -8.04844797e-02f, -4.29863818e-02f,
  1.44164875e-01f, 1.55214608e-01f, 2.04207808e-01f, 2.45982707e-01f, 1.74323395e-01f, -7.19916895e-02f, -1.45034701e-01f, 9.45235938e-02f, 1.38047889e-01f, -5.50731597e-03f,
  -1.34700298e-01f, -2.04353273e-01f, -1.69914544e-01f, -5.86256431e-03f, -2.53883868e-01f, -4.35595252e-02f, -4.43481095e-02f, -1.35763004e-01f, 1.10378191e-01f, -2.43911937e-01f,
  2.23688498e-01f, -5.03017791e-02f, 1.70049220e-02f, 7.29222000e-02f, 1.81271173e-02f, -5.78019693e-02f, -4.55851182e-02f, -1.23563394e-01f, 3.23421396e-02f, -1.40199080e-01f,
  -6.03248971e-03f, -5.53082973e-02f, 1.66087896e-02f, 1.27718458e-02f, -7.55978152e-02f, -6.09735772e-02f, -1.73343942e-02f, -3.49458568e-02f, 2.12334264e-02f, -4.96298969e-02f,
  1.69309676e-02f, 4.32581827e-02f, 8.79963711e-02f, 3.43026929e-02f, -4.45065349e-02f, 1.34660870e-01f, 5.28388359e-02f, -6.20818324e-02f, -3.98524031e-02f, -1.15013219e-01f,
  -1.56119540e-01f, -1.63533073e-02f, 8.02860707e-02f, 5.22250757e-02f, -4.98094074e-02f, 6.86249137e-02f, -3.92511003e-02f, -6.53175861e-02f, 3.26040573e-03f, -1.06860779e-01f,
  8.51595029e-02f, 3.90262082e-02f, 3.48266885e-02f, -1.66289881e-02f, 5.30024990e-02f, 4.47404943e-02f, -5.05670719e-02f, 2.98905801e-02f, -1.01776365e-02f, 6.00043498e-02f,
  3.83977219e-02f, -2.97811325e-03f, -1.76615675e-03f, -3.08433529e-02f, 8.42853934e-02f, 8.85132328e-02f, -2.84594484e-02f, 9.30826142e-02f, 7.80195445e-02f, -2.33320054e-02f,
  -8.42081532e-02f, 2.54958183e-01f, -4.56842408e-02f, -3.00605278e-02f, -1.52937531e-01f, -8.16979483e-02f, 4.28650947e-03f, -6.84407651e-02f, -5.21530062e-02f, -6.46020770e-02f,
  7.05404431e-02f, -4.31011245e-02f, -6.90609291e-02f, -6.63097724e-02f, 5.79995699e-02f, -9.93494838e-02f, -1.89669952e-01f, -9.24158320e-02f, -3.76502164e-02f, -1.11443968e-02f,
  -9.55722407e-02f, -1.60967447e-02f, -6.54700547e-02f, -8.15168992e-02f, -1.02112576e-01f, 9.15529132e-02f, -1.61652993e-02f, -1.17083490e-01f, -3.37665826e-02f, -1.60866916e-01f,
  -1.80245221e-01f, -9.31817517e-02f, -2.71830082e-01f, -2.18410552e-01f, -5.55884466e-02f, 2.37931103e-01f, 4.06506449e-01f, 3.16333950e-01f, 9.72749293e-02f, 3.92616019e-02f,
  -1.16839997e-01f, -1.08321875e-01f, 1.45138772e-02f, 9.77333821e-03f, 2.52902985e-01f, 2.57473532e-02f, 3.81710753e-02f, -1.04237467e-01f, 1.03526868e-01f, 1.64514348e-01f,
  1.10380404e-01f, -6.18905835e-02f, -6.79175258e-02f, -1.09949633e-01f, -7.19359219e-02f, -1.80242043e-02f, -1.28283828e-01f, -2.56142676e-01f, -1.16849981e-01f, -3.39424253e-01f,
  -5.58525771e-02f, -1.89074218e-01f, 1.27914816e-01f, 3.93947363e-02f, -4.00733575e-03f, 3.37236263e-02f, 1.08128957e-01f, -1.10032940e-02f, -6.67684302e-02f, 7.84174167e-03f,
  -1.46827698e-01f, -2.11408269e-02f, -1.99026708e-02f, -3.72742154e-02f, 1.57193206e-02f, 7.53413513e-02f, -4.68111299e-02f, -7.43198246e-02f, 7.52944723e-02f, 8.31203256e-03f,
  -1.07971784e-02f, -9.94030386e-02f, -5.32064959e-02f, 1.16504192e-01f, 2.14489251e-02f, 5.92626026e-03f, 9.37686935e-02f, 3.90413180e-02f, 7.43495254e-03f, -3.28999721e-02f,
  1.01592280e-01f, 3.00915241e-02f, 2.14246637e-03f, 1.64434668e-02f, 9.02993511e-03f, -6.42023375e-03f, -3.68053690e-02f, 5.91323599e-02f, 7.56108239e-02f, 6.73081502e-02f,
  3.60771790e-02f, -3.22305486e-02f, 7.78307393e-02f, -4.77330200e-03f, -1.45119838e-02f, 7.24673644e-03f, -2.51976084e-02f, 9.95423831e-03f, 2.73470916e-02f, -4.27940562e-02f,
  1.35700535e-02f, 1.06250374e-02f, -1.13117984e-02f, -2.16548592e-02f, 5.05828671e-02f, -1.61698405e-02f, -1.17075266e-02f, 6.20833486e-02f, -1.09825432e-01f, 2.10973155e-03f,
  2.04258323e-01f, 8.11752304e-02f, -2.15396355e-03f, -6.65916828e-03f, -8.53561759e-02f, -8.57710931e-03f, -1.10902533e-01f, -3.43155563e-02f, -6.86371326e-02f, 1.24646358e-01f,
  3.47780325e-02f, -3.99165750e-02f, -3.27618532e-02f, 4.89345454e-02f, 9.78149399e-02f, 4.85090427e-02f, -4.10796283e-03f, 5.69926128e-02f, 4.04002815e-02f, 7.37043023e-02f,
  1.37902126e-01f, 1.78663254e-01f, 2.30673671e-01f, 1.87742412e-01f, 1.12503983e-01f, 6.50465563e-02f, 1.16106614e-01f, 5.39045334e-02f, 2.26674795e-01f, 3.01664591e-01f,
  -3.71323764e-01f, 1.23078011e-01f, -3.41439635e-01f, -3.10857296e-01f, 1.24025932e-02f, 8.92717168e-02f, 1.09582804e-01f, 4.33221459e-02f, -1.45616278e-01f, 3.66780832e-02f,
  4.71723899e-02f, -1.20463837e-02f, -9.50480029e-02f, -6.56560883e-02f, -9.46723595e-02f, -4.34048809e-02f, -3.33427548e-01f, -2.77773768e-01f, -2.51419961e-01f, 8.83993208e-02f,
  -1.44973053e-02f, -9.57341865e-02f, -1.89050883e-01f, -2.15011418e-01f, 1.51548870e-02f, -1.09395392e-01f, -2.63700545e-01f, -9.14539471e-02f, -4.70459051e-02f, -1.01826049e-01f,
  -5.65969981e-02f, -8.93980861e-02f, -1.75359249e-01f, -1.53895766e-01f, -1.37021095e-01f, -1.54571503e-01f, -1.14736766e-01f, -1.66664436e-01f, -1.20949253e-01f, -5.36813326e-02f,
  -1.87792853e-01f, -9.43184048e-02f, -9.84011963e-02f, -3.17014530e-02f, -7.43849948e-02f, -1.54355437e-01f, -1.88991487e-01f, -2.02306256e-01f, -2.33771026e-01f, 6.66920915e-02f,
  1.40021518e-02f, -5.77237196e-02f, -9.06661302e-02f, -7.28476644e-02f, -8.88377428e-02f, -1.94976851e-01f, -1.05656654e-01f, -4.94387969e-02f, -1.29805729e-01f, -1.44803584e-01f,
  -8.71189535e-02f, 4.43883128e-02f, 2.29890319e-03f, 3.18703838e-02f, 1.55317619e-01f, 7.06980452e-02f, 3.80296707e-02f, 9.06587765e-02f, 4.05768976e-02f, -2.28078198e-02f,
  4.51356098e-02f, 1.83788147e-02f, 1.94370449e-02f, -7.05043525e-02f, 5.58888353e-02f, 9.34176892e-03f, 6.35812506e-02f, 8.38308781e-02f, 6.79400265e-02f, 7.00364485e-02f,
  3.97515520e-02f, 9.90645066e-02f, -4.63266484e-02f, 1.49171591e-01f, 5.67950904e-02f, 7.49586299e-02f, 2.08741520e-02f, 8.27016681e-02f, 8.06455910e-02f, 2.43289955e-02f,
  -1.12571001e-01f, -1.92071095e-01f, -6.76745325e-02f, -2.56249681e-03f, -6.97140694e-02f, -5.77562004e-02f, -6.74980730e-02f, -1.71977252e-01f, -2.81113535e-02f, -4.70133945e-02f,
  8.88941959e-02f, -8.23751464e-02f, -2.14986447e-02f, -3.29090282e-02f, -1.02275573e-01f, -2.08019279e-02f, -3.11815571e-02f, -1.64820805e-01f, -6.43354058e-02f, -3.41385640e-02f,
  -7.69714043e-02f, -1.10092402e-01f, -4.71070111e-02f, -1.63790092e-01f, -7.61527345e-02f, -1.62598714e-01f, -7.77613968e-02f, -2.29276177e-02f, -1.60611778e-01f, -1.94083363e-01f,
  2.07370088e-01f, -2.64470249e-01f, -1.22998446e-01f, 1.34151474e-01f, 4.03900668e-02f, 1.20027021e-01f, 1.00051388e-01f, 1.48383036e-01f, 1.68197349e-01f, -7.65677840e-02f,
  -1.59674495e-01f, 5.35148308e-02f, 8.13377351e-02f, 1.47637889e-01f, 1.52644366e-01f, -4.55938466e-03f, 1.93859100e-01f, 7.81995654e-02f, 2.44975746e-01f, 2.29706652e-02f,
  3.08416765e-02f, 1.49815902e-01f, 3.07143535e-02f, 1.95916891e-01f, -2.72401236e-02f, 9.50279310e-02f, -1.14676632e-01f, -1.18109927e-01f, -1.30580530e-01f, -1.29824802e-02f,
  -2.06204742e-01f, -5.07700071e-02f, 2.29422346e-01f, 1.58948526e-01f, -5.69895878e-02f, 9.29170325e-02f, 7.15295086e-04f, 1.13589913e-01f, 9.26321745e-02f, -8.76233389e-04f,
  5.55104539e-02f, 1.49763569e-01f, 1.51894977e-02f, 5.88172302e-02f, 1.46572754e-01f, 5.74397147e-02f, 8.30417573e-02f, 1.92935467e-01f, 1.11124516e-01f, -2.61179097e-02f,
  4.90526902e-04f, -4.92246822e-03f, -2.40848158e-02f, 7.02720955e-02f, -3.24161425e-02f, 4.03357446e-02f, 8.24177861e-02f, -2.11789962e-02f, 1.43985868e-01f, 1.08691521e-01f,
  -2.16700900e-02f, -6.08643070e-02f, 4.79340777e-02f, -2.75863968e-02f, -5.08177020e-02f, -9.69313085e-02f, 1.53422253e-02f, -8.81089345e-02f, 6.37583807e-02f, -2.52167322e-02f,
  5.90623124e-03f, -1.03384465e-01f, 1.71800498e-02f, -5.41755036e-02f, -2.60288101e-02f, 3.65051851e-02f, 1.12051740e-02f, -1.19517550e-01f, -5.14326878e-02f, -2.51757931e-02f,
  -1.46805877e-02f, -7.73013532e-02f, -1.73820555e-02f, -3.60283293e-02f, -6.21038154e-02f, 8.46244693e-02f, -1.56637542e-02f, 1.24685187e-02f, -6.70979451e-03f, -6.39135689e-02f,
  3.98839675e-02f, 1.64293453e-01f, 7.26646632e-02f, 1.62474990e-01f, 1.24227084e-01f, 1.46274837e-02f, 5.21006212e-02f, 1.01454660e-01f, 9.73106846e-02f, 1.55079574e-03f,
  -1.48982452e-02f, 1.13706499e-01f, 5.33312261e-02f, 9.83129442e-03f, 4.59841266e-03f, 4.79052924e-02f, 3.07384674e-02f, 9.47376937e-02f, 2.44674720e-02f, -3.37913558e-02f,
  -3.41902450e-02f, 9.87924710e-02f, 4.98580188e-02f, 7.37529621e-02f, 3.20307463e-02f, 1.13353923e-01f, 4.25491035e-02f, 1.18955128e-01f, 1.77057475e-01f, 1.78889483e-01f,
  2.54026026e-01f, -1.23537466e-01f, -4.48693335e-02f, -1.25506938e-01f, -1.09032914e-02f, 2.29213998e-01f, 2.02879533e-01f, 2.30109781e-01f, -1.11326188e-01f, -3.00162035e-04f,
  4.48630005e-02f, -3.66609031e-03f, -8.71870592e-02f, -6.51907623e-02f, 2.44230881e-01f, -6.89203292e-02f, -1.55284971e-01f, 2.26288233e-02f, 3.06966960e-01f, 3.20544183e-01f,
  -4.00767177e-02f, 7.22326338e-02f, 4.82915007e-02f, -5.19212857e-02f, -1.77444786e-01f, -8.78438279e-02f, -2.80183494e-01f, -1.90879866e-01f, -1.11844696e-01f, -3.81265849e-01f,
  4.27665040e-02f, 1.85584649e-01f, 1.31529778e-01f, -6.40637204e-02f, -9.35031101e-02f, 9.91076902e-02f, 1.11730978e-01f, -7.60781690e-02f, 2.85302345e-02f, 3.60832922e-02f,
  1.20279670e-03f, 9.87615734e-02f, 1.78153384e-02f, -3.31148505e-02f, 6.01573251e-02f, 7.84096308e-03f, 7.79019967e-02f, -9.05075693e-04f, 3.18011455e-02f, 9.44449604e-02f,
  -8.77220556e-03f, 1.10016301e-01f, 1.25736609e-01f, 2.69519053e-02f, 4.99861427e-02f, -1.13614118e-02f, -5.10492995e-02f, 4.41419482e-02f, 7.09390491e-02f, 3.47616263e-02f,
  7.92583078e-02f, -4.06939685e-02f, -6.61863834e-02f, -8.91291630e-03f, -1.88790914e-02f, -3.49963419e-02f, 4.73611541e-02f, -4.51103831e-03f, -9.31868516e-03f, -1.40958741e-01f,
  2.89346967e-02f, -2.05875263e-02f, 8.76192525e-02f, -2.45059505e-02f, 8.51152167e-02f, 5.25978953e-02f, 6.57664984e-02f, -1.42413173e-02f, 5.43894507e-02f, 1.17449619e-01f,
  3.32779214e-02f, -5.26115261e-02f, -1.14763498e-01f, -7.19957054e-02f, -3.24797779e-02f, -4.97540161e-02f, -1.67211201e-02f, -4.31215763e-02f, 1.39366938e-02f, 9.21183005e-02f,
  -7.57075101e-02f, 3.12187999e-01f, 5.40948212e-02f, 1.02198951e-01f, -7.31512532e-02f, 5.05216084e-02f, -9.84470826e-03f, 1.07691482e-01f, 7.53283203e-02f, 1.30015701e-01f,
  1.80426478e-01f, 6.50277585e-02f, 2.10597888e-02f, -2.70858742e-02f, 1.94941591e-02f, 1.56323001e-01f, 5.81470616e-02f, -3.00495122e-02f, 6.99824095e-02f, 2.08883025e-02f,
  3.93992066e-02f, 1.97139040e-01f, 2.04964235e-01f, 1.06202513e-01f, 4.55770269e-02f, 1.79882511e-01f, 3.03623192e-02f, -1.22371037e-02f, 2.05911264e-01f, 1.50414318e-01f,
  1.24011427e-01f, 1.94913417e-01f, 2.57741772e-02f, 5.30069917e-02f, 9.16254520e-02f, 7.38920197e-02f, 1.56015337e-01f, -5.53253666e-02f, -2.31872257e-02f, 4.07710820e-02f,
  -1.67491913e-01f, -1.35931641e-01f, -2.22996980e-01f, -1.89005494e-01f, -2.87585795e-01f, 3.47431302e-02f, 2.51898337e-02f, -5.28375320e-02f, -2.47001559e-01f, -1.31939724e-01f,
  2.57088188e-02f, 1.07836574e-01f, -7.41052115e-03f, -1.21981360e-01f, 1.68681130e-01f, -7.95046464e-02f, -1.80039331e-02f, 1.13081902e-01f, 8.63399431e-02f, 2.90655017e-01f,
  -8.96750242e-02f, 1.16643310e-01f, -2.15859652e-01f, -1.38425887e-01f, -7.10089430e-02f, -4.71889339e-02f, -5.68564469e-03f, -1.19418770e-01f, -1.23662036e-02f, 2.10360140e-02f,
  -2.20078453e-02f, 7.19271041e-03f, -5.03308773e-02f, -9.03142896e-03f, -2.45182514e-02f, -5.89154363e-02f, -1.34870252e-02f, -1.17576070e-01f, -1.87937975e-01f, -1.20262973e-01f,
  5.95134459e-02f, 1.41341879e-03f, -1.89123936e-02f, -7.38860071e-02f, -1.89362466e-01f, -1.07606336e-01f, -9.61130783e-02f, -1.01355072e-02f, -1.42921999e-01f, 2.05045603e-02f,
  2.84671001e-02f, -7.53904507e-02f, -2.81021465e-02f, 1.13352381e-01f, -1.26976166e-02f, 3.90498824e-02f, 1.32920250e-01f, -1.09010125e-02f, -2.26691160e-02f, 4.81339842e-02f,
  3.89350206e-02f, 4.54812869e-02f, 2.68071648e-02f, 2.32874602e-02f, -4.18049395e-02f, 5.00794686e-02f, 1.01707250e-01f, -7.33692795e-02f, 2.04295246e-03f, -5.58558330e-02f,
  8.47600251e-02f, 5.65087534e-02f, 2.17222143e-02f, 5.69424033e-02f, 3.61305438e-02f, 1.08433655e-02f, 8.52553248e-02f, 1.61837414e-02f, 7.37344921e-02f, 5.29703312e-02f,
  -2.28137046e-01f, -2.14933649e-01f, 4.30356078e-02f, -6.33926168e-02f, -1.31047172e-02f, -9.62193832e-02f, -5.27051315e-02f, -8.46843868e-02f, 1.11669558e-03f, -2.57264171e-02f,
  -1.10660508e-01f, -1.83968246e-01f, -1.35339543e-01f, -3.55153903e-03f, 2.00223252e-02f, 1.39760626e-02f, -1.55946407e-02f, -6.57365471e-02f, -3.98278274e-02f, -8.56005400e-02f,
  1.66925248e-02f, -7.04407766e-02f, -9.60205793e-02f, -1.32870272e-01f, -3.09204422e-02f, -1.12502344e-01f, -6.94286600e-02f, -6.56105131e-02f, -1.61714807e-01f, -1.12179555e-01f,
  -1.05390437e-01f, 8.59642308e-03f, -4.45699573e-01f, -7.73462579e-02f, -1.12163872e-01f, -1.65437400e-01f, -2.68145114e-01f, -1.31744295e-01f, 8.04667324e-02f, 1.16992794e-01f,
  6.73721433e-02f, 3.21624666e-01f, 1.39018476e-01f, 7.97635317e-02f, 1.29945362e-02f, -1.06729530e-01f, -2.17585191e-01f, -1.45741031e-01f, -1.59619719e-01f, -5.59787527e-02f,
  9.55154151e-02f, -2.24073734e-02f, -1.50448680e-02f, -6.18864633e-02f, 3.09001263e-02f, 1.09417133e-01f, -4.49028686e-02f, -1.01948872e-01f, -1.40953690e-01f, -7.97326043e-02f,
  -6.11984357e-02f, -2.37478897e-01f, -7.48300413e-03f, 2.76988391e-02f, -1.02201201e-01f, -1.58415198e-01f, -1.76950231e-01f, -1.49160326e-01f, -1.51328892e-01f, -1.17502511e-01f,
  -1.60927698e-01f, -1.22524006e-02f, -3.58141470e-03f, -1.63796861e-02f, -6.98226392e-02f, -1.59437135e-01f, -3.95823643e-02f, -7.95284808e-02f, -1.43600106e-01f, -1.56099737e-01f,
  -9.08646453e-03f, -1.73448592e-01f, -2.47070536e-01f, -1.85414627e-01f, -7.57105350e-02f, -1.36364466e-02f, -2.09465802e-01f, -1.18137389e-01f, -2.12541118e-01f, -6.34774044e-02f,
  6.24755248e-02f, 9.75811258e-02f, 9.26515982e-02f, 3.51478234e-02f, 1.73165455e-01f, -5.42395003e-03f, 1.27307335e-02f, 1.19225219e-01f, 1.04052536e-01f, 4.01396528e-02f,
  5.97910099e-02f, 1.59405649e-01f, -6.07804582e-03f, 7.75075983e-03f, 1.17694922e-01f, 1.99742094e-02f, -1.07873436e-02f, 1.19192064e-01f, 1.10331401e-01f, 1.37885418e-02f,
  1.13448994e-02f, 4.35331799e-02f, 1.28636472e-02f, 1.15141086e-02f, 4.28542420e-02f, 5.99851739e-03f, 6.12494349e-03f, 1.14368662e-01f, 5.16305268e-02f, -2.51932088e-02f,
  2.29761541e-01f, -1.68741018e-01f, 6.30947202e-02f, 1.08880019e-02f, -9.91251320e-02f, -1.00222327e-01f, 3.49727459e-02f, -8.01321641e-02f, -7.30794072e-02f, -1.45784795e-01f,
  -5.85482977e-02f, -5.81816696e-02f, -1.22228399e-01f, -1.03323407e-01f, -9.15544257e-02f, -1.12310313e-01f, -5.08634374e-02f, -2.02694931e-03f, -6.59316895e-04f, 4.42733541e-02f,
  4.68973555e-02f, -3.66064459e-02f, 6.10099584e-02f, 3.24542336e-02f, -2.69885734e-02f, -7.62744024e-02f, -6.02806360e-02f, 9.74346418e-04f, -9.94534791e-02f, -7.82721117e-02f,
  5.12593091e-01f, 1.64877251e-01f, 2.33788475e-01f, 1.28893435e-01f, 1.29608616e-01f, 2.04935387e-01f, 2.77122706e-01f, 1.43054277e-01f, 5.78252152e-02f, 1.59692794e-01f,
  5.49780503e-02f, 1.33415133e-01f, 2.34157071e-02f, 1.79128766e-01f, 2.41997316e-01f, 1.00932993e-01f, 5.18344305e-02f, 1.33846775e-01f, 1.73888624e-01f, 6.90652058e-02f,
  -1.01218577e-02f, 9.17175561e-02f, 2.23942518e-01f, 7.12822154e-02f, -3.34506072e-02f, -1.29139394e-01f, 1.40495539e-01f, -1.62504148e-02f, 4.86366525e-02f, -1.60905331e-01f,
  1.37443855e-01f, 3.40143532e-01f, 1.29605487e-01f, 3.73260528e-02f, 1.27899200e-01f, 1.01012528e-01f, 1.36771202e-01f, 2.12579429e-01f, 1.00447156e-01f, 9.25956294e-02f,
  8.10551047e-02f, 6.68147802e-02f, 1.41359702e-01f, 2.52174065e-02f, 1.95268676e-01f, 8.44100490e-02f, 6.33559749e-02f, 1.21625274e-01f, 1.58867478e-01f, 1.62677050e-01f,
  1.22653581e-01f, 2.00459689e-01f, 3.06936979e-01f, 2.19450071e-01f, 1.20021604e-01f, 1.98474854e-01f, 1.30922794e-01f, 1.07923321e-01f, 1.91072255e-01f, 2.07259227e-03f,
  1.04670406e-04f, -1.76867992e-01f, -1.90834612e-01f, -1.28442034e-01f, -2.67193019e-01f, -1.28385663e-01f, -2.38022059e-01f, -1.60184413e-01f, -2.20360845e-01f, -1.45509735e-01f,
  -1.07518636e-01f, -5.99567853e-02f, -2.15132982e-01f, -8.26196820e-02f, -1.40213460e-01f, -1.88655823e-01f, -1.12461694e-01f, -2.05803663e-01f, -1.88103884e-01f, -1.88948765e-01f,
  -1.36333182e-01f, -8.21724460e-02f, -2.03306571e-01f, -2.10636526e-01f, -2.20400676e-01f, -1.42295331e-01f, -1.61265031e-01f, -1.20728843e-01f, -2.44552180e-01f, -8.68461877e-02f,
  6.85817823e-02f, 3.15940142e-01f, 1.30368084e-01f, 1.47242159e-01f, 1.70350820e-01f, 1.34065971e-01f, 1.23768941e-01f, 2.06643552e-01f, 1.76085576e-01f, 5.21641634e-02f,
  1.79388881e-01f, 1.02363698e-01f, 8.62035677e-02f, -5.27977338e-03f, 4.95433696e-02f, 4.00059531e-03f, 1.17664494e-01f, 7.30677396e-02f, 1.75960124e-01f, 1.15649933e-02f,
  9.30815656e-03f, 2.28936985e-01f, 2.51548797e-01f, 1.53341323e-01f, 1.63199037e-01f, 2.03881770e-01f, 1.32172450e-01f, 1.25239268e-01f, 2.52349168e-01f, 3.49139608e-02f,
  -9.11225528e-02f, -4.28334445e-01f, -5.71250357e-02f, -2.64156628e-02f, -2.30751093e-02f, -9.24096107e-02f, -3.12205195e-01f, -1.76616177e-01f, -4.68169264e-02f, -1.64130747e-01f,
  -3.93653661e-01f, -9.46331546e-02f, -1.81449518e-01f, -4.07279804e-02f, -2.34369636e-01f, -1.21033795e-01f, 1.29309475e-01f, 1.67241365e-01f, 1.92500710e-01f, 1.75176114e-02f,
  -1.36023974e-02f, 1.12316813e-02f, 1.07667632e-01f, 3.24948728e-02f, -1.17723212e-01f, -3.98072191e-02f, -1.21922672e-01f, 2.86571607e-02f, -1.56499580e-01f, 1.11711383e-01f,
  -8.54133517e-02f, -2.14530736e-01f, -2.23208219e-03f, -2.17451677e-01f, -2.06045911e-01f, -8.27924684e-02f, -1.57235086e-01f, -1.33030221e-01f, -1.79893076e-01f, -1.52781025e-01f,
  -1.04523204e-01f, -1.55228391e-01f, -8.61732736e-02f, -5.60018905e-02f, -1.43322021e-01f, -5.55733480e-02f, -5.48023582e-02f, -8.08866471e-02f, -3.56075056e-02f, -7.25049898e-02f,
  -1.97796449e-01f, -5.24078533e-02f, -1.62142843e-01f, -2.21472710e-01f, -8.59965086e-02f, -6.40531033e-02f, -2.77375400e-01f, -6.61064014e-02f, -9.64798555e-02f, -4.49349396e-02f,
  4.92443293e-02f, 4.09274250e-02f, 5.48610985e-02f, -3.74943800e-02f, 2.26319651e-03f, 7.66626149e-02f, 1.25540704e-01f, 1.42958164e-01f, 6.80223778e-02f, 4.49775159e-02f,
  -6.83736941e-03f, 9.86538380e-02f, -8.83157086e-03f, 5.69515154e-02f, 5.19996602e-03f, 3.51442955e-02f, 4.92604859e-02f, 4.75870259e-03f, 8.21015686e-02f, 5.46814613e-02f,
  1.01805195e-01f, 9.36787203e-02f, 8.30377489e-02f, 1.34414122e-01f, -2.17942707e-02f, 1.71254463e-02f, 8.96199197e-02f, -4.35822979e-02f, -1.80135816e-02f, 8.62863436e-02f,
  -2.85452455e-01f, -2.93239325e-01f, -7.70917609e-02f, -1.01287171e-01f, -8.30907673e-02f, -8.96763876e-02f, -2.47411206e-01f, -5.90201728e-02f, -2.06021145e-01f, -1.40299410e-01f,
  -2.22830057e-01f, -5.09583466e-02f, -1.38091519e-01f, -1.35185540e-01f, -7.17415661e-02f, -1.21618912e-01f, -2.42680013e-01f, -1.01891711e-01f, -3.20902579e-02f, -8.87138844e-02f,
  -1.75655439e-01f, -5.14245257e-02f, -1.38909847e-01f, -1.20521635e-01f, -1.64745390e-01f, -1.11645949e-03f, -2.06663296e-01f, -1.65390819e-01f, -1.06711015e-01f, -2.75200248e-01f,
  -1.16990082e-01f, -8.25532526e-02f, -1.62928268e-01f, 1.92279205e-01f, 2.03121006e-01f, 5.87501749e-02f, -5.59524037e-02f, -1.04258554e-02f, 1.96731091e-01f, 8.33874047e-02f,
  6.87292069e-02f, 7.88550172e-03f, -6.53680339e-02f, -5.46297990e-02f, -2.02552930e-01f, 1.30929314e-02f, -1.51234224e-01f, -1.91517428e-01f, -1.31798699e-01f, 1.05182409e-01f,
  1.94630429e-01f, 5.64591289e-02f, 6.34370465e-03f, 1.00911446e-02f, 2.92042106e-01f, 1.82696193e-01f, -2.82890275e-02f, 8.43063816e-02f, 1.28463984e-01f, 2.04447031e-01f,
  1.08958907e-01f, 1.27807155e-01f, 1.22243732e-01f, 1.03020400e-01f, -4.24806625e-02f, 1.74414292e-01f, 4.65273075e-02f, 1.15628622e-01f, 7.93104768e-02f, 9.00581181e-02f,
  3.40623930e-02f, 1.34750202e-01f, 2.35175597e-03f, 1.88783199e-01f, 3.92709598e-02f, 7.10477829e-02f, 7.86498040e-02f, -4.10956666e-02f, -4.21725847e-02f, 6.69418946e-02f,
  1.45285830e-01f, 1.08112492e-01f, 7.44365901e-02f, 6.08371347e-02f, -2.56426889e-03f, 8.18458572e-02f, 1.39281541e-01f, 1.81972027e-01f, 8.26368928e-02f, 1.52749971e-01f,
  -5.60083687e-02f, -1.10040553e-01f, -8.45504031e-02f, -1.32977795e-02f, -1.09757856e-01f, -3.08957994e-02f, -5.71094863e-02f, -8.35906118e-02f, -1.09418601e-01f, 4.26213443e-02f,
  -2.79754307e-03f, -7.40242377e-02f, -8.29988495e-02f, -4.86489665e-03f, -1.10144801e-02f, -6.95348755e-02f, 3.94647121e-02f, -8.57390091e-02f, 2.33931690e-02f, -9.63692218e-02f,
  -8.89670476e-02f, -7.29438737e-02f, -2.37471741e-02f, -6.94340318e-02f, -4.94869873e-02f, -4.61108200e-02f, -3.58156394e-03f, 6.12694472e-02f, -1.89881586e-02f, 2.97392830e-02f,
  1.43838301e-01f, -7.48593062e-02f, 1.80007756e-01f, 1.25008568e-01f, 9.28145945e-02f, 1.27835035e-01f, 1.56014293e-01f, 9.76746604e-02f, 4.38483730e-02f, 8.72237459e-02f,
  5.79058751e-02f, 3.05370968e-02f, 1.07304387e-01f, 1.70981705e-01f, 1.45814076e-01f, 1.47474080e-01f, 3.48511823e-02f, 1.12394676e-01f, 8.50863382e-02f, 1.45816237e-01f,
  8.60864073e-02f, 1.08721733e-01f, -2.03780569e-02f, 1.12583255e-03f, 7.06542134e-02f, 1.12497360e-01f, 4.90006879e-02f, 1.04731977e-01f, -7.25867748e-02f, 1.59903839e-01f,
  4.45195287e-01f, 2.50633270e-01f, 1.58932298e-01f, 1.58771545e-01f, -3.44371907e-02f, 7.92644247e-02f, 7.50013068e-02f, 3.24939527e-02f, -3.45967114e-02f, 2.37104982e-01f,
  1.27682000e-01f, -1.08124733e-01f, -3.85282066e-04f, 4.01972421e-03f, 4.34823409e-02f, 1.34385750e-01f, 8.49860907e-02f, 9.94591638e-02f, -1.56163037e-01f, -1.26025379e-01f,
  2.22171806e-02f, -2.33658664e-02f, 9.55681056e-02f, -9.78462249e-02f, 2.30637426e-03f, -9.67876688e-02f, -2.81314049e-02f, -2.70992015e-02f, 2.47017797e-02f, 1.36689097e-01f,
  8.39205608e-02f, 2.04459280e-01f, -3.92220868e-03f, 8.25004503e-02f, 1.33436192e-02f, 1.50161497e-02f, 4.13523661e-03f, -7.64107555e-02f, 5.19865341e-02f, 3.90840732e-02f,
  9.68208164e-03f, 1.16836540e-02f, 2.95120012e-03f, 3.22683863e-02f, 6.12603575e-02f, 8.47355053e-02f, -2.62438487e-02f, -2.72527263e-02f, -3.95476781e-02f, 7.95642361e-02f,
  -6.57852218e-02f, 1.39405608e-01f, 2.80007138e-03f, 6.36015534e-02f, 2.28718519e-02f, 2.51637809e-02f, 5.31587452e-02f, -3.80684212e-02f, 1.17286138e-01f, 3.31430361e-02f,
  -1.46891531e-02f, -6.06070459e-03f, 2.79532168e-02f, 1.03812953e-02f, -1.64749436e-02f, -4.18180041e-03f, -6.76137209e-02f, -4.43960242e-02f, -8.05737898e-02f, 3.38497013e-03f,
  -1.23387724e-01f, 5.88598028e-02f, -8.33294392e-02f, 4.48763110e-02f, -6.11008592e-02f, 2.82474328e-02f, 7.32070282e-02f, -2.86880285e-02f, 5.50648160e-02f, -6.94844872e-02f,
  -4.57624206e-03f, -4.56486270e-02f, 3.52322571e-02f, -1.09505579e-01f, -2.96765156e-02f, -3.98299918e-02f, 7.99695481e-05f, -7.21984431e-02f, -6.48472607e-02f, 7.97666907e-02f,
  -6.88945083e-03f, -2.60686986e-02f, 1.65147945e-01f, -4.45636362e-02f, 6.03137240e-02f, -2.06469372e-02f, 4.06262204e-02f, 5.89822903e-02f, 4.13781889e-02f, 1.31513461e-01f,
  1.70718599e-03f, 7.43479431e-02f, 1.03186749e-01f, 3.36178616e-02f, -2.76329974e-03f, 1.44331291e-01f, 1.10981748e-01f, 7.22411722e-02f, 3.25657316e-02f, 9.66019407e-02f,
  7.82742724e-02f, 3.22679505e-02f, 2.04814836e-01f, -7.00157415e-03f, 8.65881965e-02f, 1.19189359e-01f, -1.43442405e-02f, -2.89995093e-02f, 2.88852472e-02f, 1.93823025e-01f,
  1.11367829e-01f, 4.42560405e-01f, -1.05516747e-01f, 1.70741141e-01f, 5.91304712e-02f, -1.26490578e-01f, -7.94229805e-02f, 1.87432207e-02f, 4.61612223e-03f, 3.96810435e-02f,
  1.83241844e-01f, 7.35568106e-02f, -7.65328258e-02f, 2.93903798e-02f, -6.23899475e-02f, 6.49752468e-03f, -9.30729434e-02f, -1.85751602e-01f, -2.83759534e-01f, -9.48282927e-02f,
  1.32002681e-01f, 8.15807506e-02f, 7.35081509e-02f, 4.14258242e-02f, 1.18114255e-01f, -1.63029972e-02f, -1.15517385e-01f, -4.03714627e-02f, -5.44274449e-02f, -3.51549573e-02f,
  -1.11773774e-01f, 1.58892691e-01f, -1.72104731e-01f, 1.69753563e-02f, 1.57105234e-02f, 4.57207389e-05f, -1.03583515e-01f, -4.42581512e-02f, 8.32279623e-02f, 3.10359639e-03f,
  4.70260642e-02f, 3.49548757e-02f, 3.96732800e-02f, -8.80763903e-02f, 2.86013987e-02f, -1.21386155e-01f, 5.55668063e-02f, -9.32928547e-02f, 2.59835441e-02f, 2.17069294e-02f,
  2.10524872e-02f, 2.30628271e-02f, 3.65226110e-03f, 7.16678239e-03f, -4.37626876e-02f, -8.35504010e-02f, -8.86981562e-02f, -1.03019156e-01f, -1.27586484e-01f, -1.27636611e-01f,
  -4.47065607e-02f, 8.16556532e-03f, 2.88535282e-02f, 2.85820626e-02f, 4.80773952e-03f, -5.71099259e-02f, -3.73441018e-02f, -7.32717738e-02f, 7.05355927e-02f, -1.59431715e-02f,
  -5.62615469e-02f, 3.67485285e-02f, -9.95454937e-02f, -3.24496366e-02f, -7.47590810e-02f, -4.54248395e-03f, -8.42501894e-02f, -4.45426367e-02f, 7.81547278e-03f, -7.14694755e-03f,
  3.66219841e-02f, -2.72466112e-02f, 2.79671121e-02f, -7.69251138e-02f, 2.74887197e-02f, -7.02222437e-02f, -1.94673408e-02f, -1.71800684e-02f, 5.13269790e-02f, 2.06879787e-02f,
  -1.72943428e-01f, -7.81599656e-02f, -1.88491747e-01f, -8.95938352e-02f, -4.51515168e-02f, -1.89708825e-02f, 4.41934280e-02f, 9.91311967e-02f, 1.23094566e-01f, -1.00510545e-01f,
  -2.49295104e-02f, -7.03225508e-02f, -8.90910551e-02f, 7.66070858e-02f, -1.45498395e-01f, -1.12761974e-01f, 7.69491959e-03f, 1.33706490e-02f, -7.92493671e-02f, -7.02421553e-03f,
  3.55895562e-03f, -9.64643136e-02f, -1.36715204e-01f, -1.31073281e-01f, -1.41532257e-01f, -1.99295491e-01f, -9.22097266e-02f, -2.17237055e-01f, -1.69391617e-01f, -1.61904484e-01f,
  2.60291453e-02f, -2.87772715e-01f, 1.09157301e-01f, -7.26191849e-02f, 7.77751356e-02f, 1.60780609e-01f, 6.75521344e-02f, 9.68992431e-03f, 1.04357705e-01f, -4.86353599e-02f,
  -5.40797822e-02f, 1.57859147e-01f, 1.40255064e-01f, 9.83424857e-02f, 5.69389462e-02f, -8.38048682e-02f, -8.40602145e-02f, 6.39350861e-02f, 2.98480600e-01f, 1.56012565e-01f,
  6.55061975e-02f, -9.04147997e-02f, -2.05318723e-03f, -6.20198585e-02f, -3.78872901e-02f, 2.44662929e-02f, -1.57406002e-01f, -3.63458395e-02f, -7.02507645e-02f, -2.82506347e-01f,
  8.30528513e-02f, -9.88479704e-02f, 1.10674612e-01f, -9.41374674e-02f, -2.81646904e-02f, 5.10840863e-02f, -9.49446764e-03f, 6.82259127e-02f, -3.52364592e-02f, 3.35219540e-02f,
  -8.08229893e-02f, 1.49704926e-02f, -6.01251423e-02f, -1.14327120e-02f, 7.98219368e-02f, 1.16991317e-02f, -6.24551065e-02f, 7.56097771e-03f, 1.92560516e-02f, -2.74786260e-02f,
  1.96322259e-02f, 8.22037384e-02f, 1.57854840e-01f, -3.42696495e-02f, 5.40641546e-02f, 1.23509094e-01f, 3.17138284e-02f, 9.12626907e-02f, 1.60185352e-01f, 5.23547046e-02f,
  -1.14436865e-01f, -1.61839291e-01f, -6.48427233e-02f, -8.22062045e-02f, -5.34407347e-02f, -9.44433659e-02f, -1.26280293e-01f, -5.48745915e-02f, -8.58005323e-03f, -8.21338594e-03f,
  -9.33789015e-02f, 4.02023047e-02f, 7.03507289e-03f, 3.95423807e-02f, -3.41283269e-02f, 1.23447571e-02f, -1.02640897e-01f, 1.62674338e-02f, 6.37364686e-02f, 2.92024817e-02f,
  2.39060223e-02f, 3.54579128e-02f, 9.08548664e-03f, 2.69825812e-02f, 2.78306678e-02f, 2.21097469e-02f, -8.71764123e-02f, -2.10978892e-02f, 1.05737314e-01f, -6.90615773e-02f,
  5.15879616e-02f, 9.99539420e-02f, 1.31610013e-03f, 3.35144587e-02f, -3.89552675e-02f, 4.47438806e-02f, 9.03798547e-03f, 2.45140940e-02f, 2.80173663e-02f, 2.19075494e-02f,
  4.01377194e-02f, 3.09321769e-02f, -3.13264057e-02f, 2.60226429e-02f, 1.02398619e-01f, 1.75545551e-02f, -6.77938759e-02f, 2.81017050e-02f, 1.22316107e-01f, -3.14147957e-03f,
  8.12253952e-02f, 1.21669687e-01f, 2.33685449e-01f, 1.53970718e-01f, 6.88930079e-02f, 2.18027934e-01f, 1.53987795e-01f, 1.87338516e-01f, 2.32506245e-01f, 1.35189533e-01f,
  -4.02045369e-01f, -9.90577564e-02f, -2.56487429e-02f, -2.45346744e-02f, 8.24586824e-02f, -8.25117454e-02f, -2.77846493e-02f, 2.33653057e-02f, 1.42403394e-01f, -9.23008174e-02f,
  -4.69382331e-02f, 4.47243638e-02f, 2.93796975e-02f, 1.40708797e-02f, 7.75200129e-02f, 4.80111055e-02f, 1.10178716e-01f, 4.85997163e-02f, 3.88396457e-02f, 1.05147257e-01f,
  7.71152973e-02f, 3.16948853e-02f, 3.92713584e-02f, 2.84650866e-02f, 1.24868192e-01f, 1.86505876e-02f, -6.06617220e-02f, 1.00211687e-01f, -5.14201187e-02f, -2.03405390e-03f,
  -2.76094526e-01f, -1.68073863e-01f, 7.66046494e-02f, 7.05560611e-04f, -2.17067041e-02f, -5.21707945e-02f, 1.61348693e-02f, 9.29040611e-02f, 6.93146735e-02f, -4.22269888e-02f,
  2.39701942e-02f, -5.42737804e-02f, 5.24901599e-02f, -9.65804886e-03f, 3.36726233e-02f, 4.37719561e-02f, 1.13033965e-01f, 8.39720573e-03f, 6.35221973e-02f, 3.36455740e-03f,
  1.07335731e-01f, -1.82382285e-03f, -1.46505296e-01f, -8.74220654e-02f, 4.02711816e-02f, 2.79099904e-02f, -1.19725801e-01f, 2.80360505e-02f, -9.24400240e-02f, -1.18895672e-01f,
  -4.80942093e-02f, 1.43568665e-01f, 1.22493215e-01f, 5.82388304e-02f, 5.47515973e-03f, 5.12364358e-02f, 7.55435750e-02f, -1.57654788e-02f, 1.06565729e-01f, -4.63001654e-02f,
  3.63268405e-02f, -7.42928609e-02f, 1.06047735e-01f, -4.33860607e-02f, 8.56943578e-02f, 1.39935641e-03f, 6.65827096e-02f, -1.15535595e-03f, 6.57398999e-03f, -6.74024820e-02f,
  -1.31958434e-02f, 2.82848291e-02f, -2.16531027e-02f, 7.13710673e-03f, 1.56107079e-02f, 9.87427756e-02f, 1.05849475e-01f, 3.42134610e-02f, 1.30235059e-02f, 5.07491529e-02f,
  -1.80484220e-01f, 6.50856569e-02f, -1.84937999e-01f, -2.74817906e-02f, -2.56379321e-02f, -5.82212918e-02f, -2.22299956e-02f, -1.58174988e-02f, -4.76232953e-02f, -1.41848922e-01f,
  -6.99254647e-02f, -1.14541210e-01f, -4.14037220e-02f, -6.73195198e-02f, -9.19086020e-03f, -8.93450528e-02f, -7.84593299e-02f, 1.13138212e-02f, -1.03389867e-01f, -6.54020458e-02f,
  1.57556515e-02f, -1.43087074e-01f, -1.41510785e-01f, -2.79609244e-02f, -2.96208858e-02f, -5.16054891e-02f, -2.03306377e-01f, -1.96925655e-01f, -2.17032343e-01f, -2.48223037e-01f,
  6.71784654e-02f, 1.69565782e-01f, 2.20222175e-01f, 1.30890100e-03f, 6.56454451e-03f, -5.69401979e-02f, -1.75435826e-01f, -1.00151092e-01f, -1.74444504e-02f, -4.21382859e-02f,
  4.69994023e-02f, -1.32666916e-01f, -7.83749893e-02f, -5.51663302e-02f, -1.26481771e-01f, -1.22513227e-01f, -1.80008188e-01f, -1.61187336e-01f, -9.00466144e-02f, -1.40871946e-02f,
  -2.79673301e-02f, -4.47425619e-02f, -3.11825350e-02f, -1.26130775e-01f, 1.50871247e-01f, 4.20137607e-02f, 1.03170991e-01f, 8.79100040e-02f, 1.32643878e-01f, 2.71858126e-01f,
  1.82659701e-01f, 2.30574384e-01f, -8.24645385e-02f, -9.71568897e-02f, 3.49305235e-02f, 9.86652002e-02f, 1.49674146e-02f, 1.08478226e-01f, 1.01647623e-01f, -5.44923693e-02f,
  2.76930053e-02f, 4.63773124e-02f, 9.74106863e-02f, 3.11261620e-02f, -3.99278402e-02f, -6.74231872e-02f, 6.25353205e-05f, 9.75842327e-02f, -1.16243251e-01f, 9.04525667e-02f,
  1.70012023e-02f, -1.90768465e-02f, -2.03871466e-02f, 3.37703973e-02f, 4.30665985e-02f, -5.72378524e-02f, -9.04013403e-04f, 5.90119436e-02f, 3.29245105e-02f, 1.64787188e-01f,
  8.66242349e-02f, 9.59368274e-02f, -4.94414233e-02f, -6.18107021e-02f, -5.76723740e-02f, -8.57041925e-02f, -1.37741297e-01f, -1.16437040e-01f, -6.45002872e-02f, -3.94837148e-02f,
  -1.07037380e-01f, 1.76958628e-02f, 6.59343647e-03f, -8.21833313e-02f, -4.93782349e-02f, -6.22596219e-03f, -9.20855105e-02f, -1.62319690e-01f, -1.38818815e-01f, -5.52415624e-02f,
  -5.24304621e-02f, -1.07241474e-01f, -8.66029710e-02f, -1.12689592e-01f, -1.24358915e-01f, -1.97644718e-02f, -6.36021607e-03f, -3.86337973e-02f, -6.62204176e-02f, -8.46937746e-02f,
  8.94623026e-02f, -9.17857513e-02f, 1.72758829e-02f, 4.35137525e-02f, 1.13523446e-01f, 5.03823832e-02f, 7.37104490e-02f, 1.08490095e-01f, 1.04386322e-01f, -1.06134254e-03f,
  4.87789623e-02f, 2.08827872e-02f, 3.80809456e-02f, 2.60221194e-02f, -2.55448390e-02f, -3.00895553e-02f, -1.00552261e-01f, -1.08206011e-01f, -3.92477550e-02f, 6.31226376e-02f,
  -8.17941725e-02f, -5.78624606e-02f, -2.00930476e-01f, -1.25814527e-01f, 1.86037901e-03f, -9.74242836e-02f, 2.48259213e-02f, 3.49290557e-02f, -9.32142213e-02f, -1.53672308e-01f,
  -2.23491877e-01f, -2.20981866e-01f, -2.19171837e-01f, 5.25935851e-02f, 2.38811806e-01f, 1.17916368e-01f, -1.41716853e-03f, -7.58535564e-02f, 1.20591819e-01f, -3.59672047e-02f,
  -1.30047441e-01f, 1.16812286e-03f, 9.24817026e-02f, 5.95570635e-03f, -9.19739231e-02f, 3.59620079e-02f, 1.20961301e-01f, -1.35515230e-02f, 1.18070230e-01f, 1.15401067e-01f,
  2.27252394e-01f, 2.09636614e-02f, -1.51218429e-01f, -4.11579907e-02f, 4.63793203e-02f, 2.92018265e-01f, -1.47196548e-02f, -2.56087296e-02f, 2.38306597e-01f, 2.51763433e-01f,
  -2.36111339e-02f, -2.63679534e-01f, 1.89967938e-02f, 7.94687793e-02f, -1.01870328e-01f, -1.08502194e-01f, 4.47672233e-02f, -6.70044273e-02f, -9.06699970e-02f, 3.14686783e-02f,
  1.12929512e-02f, -5.39012440e-02f, 5.42196631e-02f, -7.56457150e-02f, -7.77305290e-02f, -2.46984325e-02f, -9.89786461e-02f, -3.65087166e-02f, -4.68598977e-02f, -6.05829712e-03f,
  1.24403924e-01f, 3.01810205e-02f, -5.51699065e-02f, 1.64342858e-02f, -2.08504852e-02f, 1.53108895e-01f, 3.00585702e-02f, 7.76336566e-02f, 7.96665475e-02f, -3.20749506e-02f,
  -2.30875276e-02f, 3.34042050e-02f, 6.65108338e-02f, 5.87990880e-02f, 1.45987198e-02f, -4.23725508e-02f, 2.41457839e-02f, -4.87682447e-02f, -2.86623910e-02f, -8.51749405e-02f,
  -4.68512140e-02f, 7.66089484e-02f, -9.82725844e-02f, -7.79852271e-02f, 3.50967213e-03f, -2.19620094e-02f, 5.60712330e-02f, 1.92845997e-03f, 3.07445247e-02f, -1.43639790e-02f,
  -1.17072929e-02f, -5.61226830e-02f, 1.88301299e-02f, 5.03582768e-02f, -4.13061082e-02f, 1.37113715e-02f, 6.51112646e-02f, -3.14765722e-02f, -8.86110738e-02f, 4.63690795e-02f,
  4.95751016e-02f, -1.20715819e-01f, 1.55999169e-01f, 6.07809192e-03f, 1.13375708e-01f, -7.45708570e-02f, -8.22361857e-02f, -6.83874413e-02f, -3.28578204e-02f, 6.77361786e-02f,
  -1.15501015e-02f, 3.59328166e-02f, -3.76393683e-02f, 8.51339847e-02f, 6.06134683e-02f, 1.06733963e-01f, 7.91847035e-02f, 2.93176919e-02f, 5.78715764e-02f, -3.31678391e-02f,
  -1.87695492e-02f, 7.16187134e-02f, 1.59831509e-01f, 7.52775744e-02f, 1.42268807e-01f, 1.30877942e-01f, 5.73624596e-02f, 1.83990687e-01f, 2.02738330e-01f, 1.18938886e-01f,
  9.90973264e-02f, 1.69852123e-01f, 5.88693917e-02f, 9.81281102e-02f, -9.92018804e-02f, -1.66406468e-01f, -2.38525823e-01f, -1.22624509e-01f, -8.22398812e-02f, 1.26808807e-01f,
  2.93624580e-01f, 2.58131057e-01f, 2.22176120e-01f, 5.41927703e-02f, -7.92071819e-02f, 2.73708794e-02f, 5.13871200e-02f, -5.15169138e-03f, -2.19954133e-01f, -1.96333990e-01f,
  -8.63121822e-02f, -1.15900896e-01f, -8.24216455e-02f, -1.77251715e-02f, 8.21995661e-02f, 1.17822073e-01f, 9.78880301e-02f, 9.87588167e-02f, 1.56562626e-01f, 8.61134008e-02f,
  2.15397090e-01f, 2.38110274e-02f, -1.51103362e-01f, 1.16302907e-01f, 1.05158828e-01f, -1.03658453e-01f, -1.04089506e-01f, -1.24863841e-01f, -5.75987622e-02f, -2.92330012e-02f,
  1.07984714e-01f, -2.44261138e-02f, -9.37173218e-02f, -4.49383296e-02f, -6.78091049e-02f, -4.27743867e-02f, -6.08254746e-02f, -1.34082794e-01f, -7.23025277e-02f, -9.14598349e-03f,
  7.22565725e-02f, 6.93597421e-02f, 7.63782784e-02f, -7.60730356e-02f, -8.09436943e-03f, -1.33788036e-02f, 1.48579315e-03f, -8.68902728e-02f, -1.08054727e-01f, -9.55969840e-02f,
  -3.98514234e-03f, 5.84179796e-02f, 5.65352105e-02f, 2.30969545e-02f, 6.99093267e-02f, 1.50389802e-02f, 1.42345112e-02f, 1.10523336e-01f, -1.05985561e-02f, 6.38241991e-02f,
  -1.62762944e-02f, 9.88023579e-02f, 1.82082818e-03f, 7.11470097e-02f, 3.01023237e-02f, 8.97376835e-02f, 8.66457224e-02f, -4.75902307e-05f, 1.34020016e-01f, 4.75104116e-02f,
  5.03348820e-02f, 1.26180425e-01f, 2.74963081e-02f, 1.00957185e-01f, 7.85205290e-02f, 1.06176250e-01f, -1.96324810e-02f, 4.71634641e-02f, -1.02271722e-03f, 1.59897506e-02f,
  -6.95244446e-02f, -1.95813365e-02f, 9.49169043e-03f, -1.36687592e-01f, -5.96771277e-02f, 5.14689460e-02f, -2.99791037e-03f, 2.46133618e-02f, -5.33438660e-02f, 2.71336120e-02f,
  -1.02002844e-01f, -2.91358326e-02f, 8.45480040e-02f, -5.06517999e-02f, -8.44028071e-02f, -5.13571277e-02f, -1.54969944e-02f, 7.16610029e-02f, 3.57825793e-02f, 4.64910902e-02f,
  -3.20056304e-02f, -7.51605555e-02f, -8.81753787e-02f, 1.76484305e-02f, -8.74557942e-02f, -2.41597686e-02f, -8.74643847e-02f, -1.07208632e-01f, -3.71007882e-02f, -2.90620402e-02f,
  -3.81580830e-01f, 4.07833993e-01f, 1.75398529e-01f, -1.77321821e-01f, -1.22217052e-01f, -1.74010154e-02f, 5.28016426e-02f, -1.68631166e-01f, -1.85114607e-01f, 1.87614784e-01f,
  2.80681401e-01f, -7.19767734e-02f, -7.86829740e-03f, -1.48176983e-01f, -6.87730759e-02f, -3.02109262e-03f, -5.16284741e-02f, -3.57972622e-01f, -3.66162479e-01f, -2.25423902e-01f,
  -7.85104483e-02f, -1.69882417e-01f, -1.93376482e-01f, -1.62313372e-01f, -6.76554516e-02f, -1.42333403e-01f, 1.05008118e-01f, 9.28843841e-02f, 1.15247622e-01f, -8.36216733e-02f,
  1.00100487e-01f, 2.82638837e-02f, -1.81299686e-01f, -4.26074825e-02f, -9.39098559e-03f, -1.22022741e-02f, 6.86546043e-02f, -5.38156405e-02f, -8.31711516e-02f, -3.33271213e-02f,
  7.81354960e-03f, -2.25177836e-02f, -9.61591005e-02f, -4.67283465e-02f, -2.45459434e-02f, -1.39527306e-01f, -4.92763072e-02f, -1.71410933e-01f, -9.90092084e-02f, 4.87605017e-03f,
  5.22873923e-02f, 6.97432831e-02f, -3.55195180e-02f, 2.59679835e-02f, -8.34377483e-03f, -1.73502311e-01f, 1.91481654e-02f, -5.50006740e-02f, 4.08336818e-02f, 8.93626958e-02f,
  -3.31856683e-02f, 2.91826408e-02f, 9.03477520e-03f, 7.52309188e-02f, 1.02577113e-01f, 5.60504906e-02f, -4.32697125e-03f, 5.96396141e-02f, -3.03163081e-02f, 7.25454241e-02f,
  -7.58275436e-03f, -7.06067681e-03f, 1.78531930e-02f, 6.13132268e-02f, 5.13483398e-02f, 3.71533297e-02f, 6.52175993e-02f, -8.68174527e-03f, 9.19282287e-02f, -1.79941524e-02f,
  -8.37244187e-03f, 6.81866929e-02f, 3.41696851e-02f, -1.71778928e-02f, 4.70804907e-02f, 5.50027527e-02f, 2.69875042e-02f, 1.07005179e-01f, -8.18413310e-03f, 1.21519975e-01f,
  2.72518769e-02f, -3.81544270e-02f, -5.04252687e-02f, -1.44896567e-01f, -3.83232906e-02f, -5.11715859e-02f, 6.21358529e-02f, -5.65861464e-02f, -3.22635897e-04f, -6.33626655e-02f,
  -5.40847611e-03f, -6.76479638e-02f, 1.33608989e-02f, -1.07353278e-01f, -1.05601259e-01f, -7.77616352e-02f, -1.49686318e-02f, -1.33845985e-01f, -1.62502244e-01f, -4.25333343e-02f,
  3.69525217e-02f, -1.73294395e-01f, -1.59653246e-01f, 1.00682285e-02f, -2.14076154e-02f, -8.94383937e-02f, 2.66863825e-03f, -9.00559872e-02f, -1.59410998e-01f, -9.29345042e-02f,
  6.34200275e-01f, 5.75176477e-02f, -1.33496508e-01f, 1.54022783e-01f, 2.68555321e-02f, -1.54955965e-02f, 1.46080330e-01f, 1.11463465e-01f, 9.65022296e-03f, 7.21927509e-02f,
  1.55281246e-01f, 2.14116871e-01f, -1.67670846e-02f, 9.29624885e-02f, 9.12873149e-02f, -1.95241898e-01f, -1.23612277e-01f, -1.44041881e-01f, 6.56210408e-02f, 1.07179448e-01f,
  -3.12369037e-02f, 1.19877234e-01f, 1.80987790e-01f, 1.53148733e-02f, -2.14821342e-02f, -1.02080666e-01f, -1.29639551e-01f, 2.27482039e-02f, -1.01062432e-01f, -2.27217883e-01f,
  6.07461371e-02f, 2.27005452e-01f, 7.78464600e-02f, 1.94033295e-01f, 1.88848190e-02f, 1.60790443e-01f, 3.48843895e-02f, 1.06133558e-01f, 1.74907789e-01f, -7.19747273e-03f,
  1.49809182e-01f, 3.99768390e-02f, 2.01507032e-01f, 1.82598997e-02f, 1.79560021e-01f, 9.11882147e-02f, 6.03772737e-02f, 1.00143671e-01f, 9.52779800e-02f, 7.47947767e-02f,
  1.03699535e-01f, 6.58962429e-02f, 1.03406847e-01f, 2.35640611e-02f, -3.89432511e-03f, 1.72632471e-01f, 1.53135762e-01f, 3.74643356e-02f, 9.94192958e-02f, 9.30872280e-03f,
  -1.73815370e-01f, -9.71272215e-02f, -1.63994074e-01f, 2.45180191e-03f, -3.98200564e-02f, -1.60839275e-01f, -9.27681625e-02f, -3.19009349e-02f, -4.24717627e-02f, -8.89134482e-02f,
  -1.21832993e-02f, -1.51053548e-01f, -1.36525789e-02f, -2.89857090e-02f, -3.00042070e-02f, -4.83590644e-03f, -1.06695779e-01f, -1.12636119e-01f, -8.65684673e-02f, -5.95912598e-02f,
  -8.04352537e-02f, -1.51480166e-02f, -9.95374247e-02f, -3.18640284e-02f, -1.64832741e-01f, -1.02011278e-01f, 6.11545937e-03f, 4.70314873e-03f, 8.84724606e-04f, -6.72003254e-03f,
  1.27849076e-02f, 1.77809685e-01f, 4.25493680e-02f, 2.05901414e-01f, 1.45097226e-01f, 9.39898118e-02f, 1.17877141e-01f, 7.49221891e-02f, 5.67120984e-02f, 1.79901958e-01f,
  2.12905973e-01f, 1.28952995e-01f, 6.12608232e-02f, 7.46677220e-02f, 1.22242473e-01f, 6.71558678e-02f, 1.37088910e-01f, 5.77959698e-03f, -1.11776954e-02f, 7.15237670e-03f,
  5.68552949e-02f, 5.03774881e-02f, 5.46035506e-02f, 1.77110806e-02f, 9.19632912e-02f, 1.86591640e-01f, 4.45676632e-02f, 1.08541481e-01f, 7.95072988e-02f, 3.55520397e-02f,
  -1.11848876e-01f, -1.33643582e-01f, 1.97371453e-01f, 1.19304910e-01f, -1.96950268e-02f, -7.88854137e-02f, -6.27342537e-02f, 2.20542755e-02f, -2.61444300e-02f, -1.96189303e-02f,
  -9.70838070e-02f, -2.63627805e-02f, 7.97624290e-02f, 1.14356823e-01f, 5.99271851e-03f, 5.68473600e-02f, 1.63795166e-02f, -2.39728279e-02f, 8.70411769e-02f, -1.33251175e-02f,
  -9.06672776e-02f, -7.79432356e-02f, 4.62247618e-03f, -4.21035066e-02f, 3.48557010e-02f, 2.11350694e-02f, 1.50951147e-01f, 3.08846943e-02f, 9.05769095e-02f, 3.76811288e-02f,
  1.58819616e-01f, -1.15654401e-01f, 1.83973014e-01f, -5.77437617e-02f, -1.59306712e-02f, 8.37730840e-02f, -4.69392948e-02f, -1.03416583e-02f, -9.04382840e-02f, 2.79708784e-02f,
  6.70524761e-02f, -6.44065514e-02f, -9.15391073e-02f, 5.85219525e-02f, -2.90760975e-02f, 4.54770327e-02f, 9.24834013e-02f, 9.90777090e-02f, 9.66004804e-02f, 1.00123897e-01f,
  -1.04672819e-01f, -1.09907478e-01f, 2.62650233e-02f, 8.96185637e-03f, -2.91678775e-02f, 9.37810242e-02f, 5.74358925e-02f, 3.71812433e-02f, 2.73094214e-02f, 3.77127156e-02f,
  6.45828620e-02f, -1.74925566e-01f, -1.59210842e-02f, -1.28403246e-01f, -1.58891026e-02f, -9.68717318e-03f, -1.41899794e-01f, -7.16702864e-02f, -1.06204912e-01f, -2.49012858e-02f,
  -3.71244624e-02f, 8.32346082e-03f, -1.19422581e-02f, 1.19168591e-03f, 4.23984826e-02f, -1.24961108e-01f, -4.53147665e-02f, -9.42074060e-02f, 1.30177699e-02f, -4.03256416e-02f,
  -6.15446866e-02f, -8.16702396e-02f, 3.41362022e-02f, -4.00352590e-02f, -3.69905680e-02f, -4.86458763e-02f, -9.84908044e-02f, -2.78349724e-02f, -4.02018689e-02f, -5.84873818e-02f,
  2.48274162e-01f, -2.42969412e-02f, 1.65440723e-01f, -6.32129833e-02f, 1.37288943e-02f, 1.12871155e-01f, 9.35785100e-02f, 7.98704773e-02f, -5.00884168e-02f, 1.68632418e-02f,
  1.04247341e-02f, 5.32192923e-02f, 4.19309102e-02f, 1.13944806e-01f, 1.09343968e-01f, 1.38241872e-01f, -6.38250168e-03f, 9.30900350e-02f, 6.55044243e-02f, -2.96426173e-02f,
  1.89432129e-02f, 6.82657883e-02f, 2.08840922e-01f, 2.07291260e-01f, 7.53913298e-02f, 8.43260214e-02f, 8.70757997e-02f, 1.44312486e-01f, -4.25442122e-03f, 2.32859284e-01f,
  3.33136797e-01f, 3.30259740e-01f, 1.65195793e-01f, 2.51816094e-01f, 1.17146410e-01f, 1.81166932e-01f, 2.77958363e-01f, 2.13701069e-01f, 1.91895664e-01f, 2.50284642e-01f,
  1.18006945e-01f, -8.59203860e-02f, 5.82966283e-02f, -3.32936831e-02f, 4.07649390e-03f, 2.34559119e-01f, 9.11675617e-02f, -1.97878759e-02f, -1.92359999e-01f, -3.83909717e-02f,
  -3.22111659e-02f, 4.05069999e-02f, -4.09836322e-03f, 5.81144691e-02f, 5.20941131e-02f, 6.87373355e-02f, 8.49611536e-02f, 3.90491337e-02f, 3.67456190e-02f, 1.24136344e-01f,
  -2.09264774e-02f, 1.76962540e-01f, 1.02442428e-01f, 5.84019013e-02f, 1.08636156e-01f, 8.48975480e-02f, 1.05233505e-01f, 1.21654734e-01f, 1.81623101e-01f, 1.59277454e-01f,
  8.00095871e-03f, 1.42303586e-01f, 1.62070185e-01f, 5.63732209e-03f, 1.50429815e-01f, 7.29371607e-02f, 4.74801324e-02f, 1.61512375e-01f, 1.53331637e-01f, -7.74908438e-03f,
  9.16895866e-02f, 9.10024941e-02f, 8.50070789e-02f, 1.61817744e-01f, 9.49824303e-02f, 5.50694056e-02f, 1.06159270e-01f, -1.08812870e-04f, 3.38825770e-02f, 2.57390320e-01f,
  -5.30156866e-02f, -1.31369591e-01f, -9.37817022e-02f, -3.24276872e-02f, -1.46191835e-01f, -6.91894367e-02f, -8.92538950e-02f, -1.45620435e-01f, -9.98792723e-02f, -1.35671541e-01f,
  -1.48955777e-01f, -9.56649706e-02f, -9.46159139e-02f, -9.30772200e-02f, -1.18436038e-01f, -4.83764559e-02f, -1.07557729e-01f, -8.63096491e-02f, -5.08684739e-02f, -1.42391384e-01f,
  -3.14187407e-02f, -1.24186806e-01f, -1.19061649e-01f, -9.84129608e-02f, -1.28713921e-01f, -4.43181507e-02f, -1.02961421e-01f, -1.41815186e-01f, -1.41460672e-01f, -1.34884849e-01f,
  3.69178534e-01f, -9.99520868e-02f, 9.64269564e-02f, 1.47222757e-01f, 1.29782379e-01f, 6.29624501e-02f, 2.18831226e-01f, 6.01075739e-02f, 3.28892097e-02f, 1.32433802e-01f,
  1.31782100e-01f, 9.81693938e-02f, 1.63564861e-01f, 6.07031137e-02f, 1.33590192e-01f, 8.36964622e-02f, 2.15599433e-01f, 7.73898140e-02f, -4.21349378e-03f, 1.65764689e-01f,
  2.39190131e-01f, 1.83660001e-01f, 2.23327368e-01f, 1.43675402e-01f, 6.44115731e-02f, 5.67753166e-02f, 6.34156689e-02f, 2.29270384e-01f, 1.10208571e-01f, 2.30665728e-01f,
  -3.05933833e-01f, 2.10773875e-03f, -8.39214921e-02f, -2.01547801e-01f, -5.73191531e-02f, -5.29264957e-02f, -3.42717804e-02f, -7.32152686e-02f, -7.62345344e-02f, -3.58315036e-02f,
  -1.48508989e-03f, 5.04924916e-02f, 1.65804625e-01f, 9.81376916e-02f, 1.27855558e-02f, -9.57373809e-03f, 1.26918986e-01f, 1.48168445e-01f, 5.06299827e-03f, -3.09376623e-02f,
  1.15736416e-02f, -1.26998141e-01f, -7.71498680e-02f, 3.04624531e-02f, -7.01768622e-02f, -4.26568501e-02f, -1.70412228e-01f, -4.75091189e-02f, -8.83246772e-03f, 1.86936557e-01f,
  -3.37100029e-02f, -2.32567102e-01f, 5.31275235e-02f, 7.43412003e-02f, 3.22437845e-02f, -3.64297852e-02f, 8.08202326e-02f, -3.86959314e-02f, -1.13908239e-01f, -1.14584506e-01f,
  -6.65110946e-02f, -1.93032203e-03f, -7.82170743e-02f, -6.63923025e-02f, -1.10891186e-01f, -3.33862938e-02f, -8.90952796e-02f, -2.46099941e-02f, -1.14695407e-01f, 5.01485588e-03f,
  9.61662680e-02f, -7.60047436e-02f, -6.17213733e-02f, -1.36938006e-01f, -9.58254561e-02f, -1.55429421e-02f, -1.01833768e-01f, -1.01614580e-01f, -1.66369364e-01f, -9.81411338e-02f,
  1.31310314e-01f, 2.35548592e-03f, 5.24317808e-02f, -4.11115028e-02f, -2.84565380e-03f, 1.24059562e-02f, 8.89915787e-03f, 3.65103930e-02f, 8.87780860e-02f, 2.41528228e-02f,
  2.38523465e-02f, 7.65055045e-02f, 1.59232586e-03f, 3.53741720e-02f, 9.85085741e-02f, 1.08236797e-01f, -1.09328097e-02f, 4.04939428e-02f, -4.36566174e-02f, -1.53111825e-02f,
  1.66319706e-03f, 2.11609360e-02f, -5.78938387e-02f, 1.13719575e-01f, -8.85548908e-03f, 2.59618945e-02f, 1.06996462e-01f, 6.05750829e-02f, 8.67529884e-02f, -6.31380379e-02f,
  -2.27618337e-01f, -3.56654935e-02f, 7.53664523e-02f, 6.06738171e-03f, -3.08482982e-02f, -5.48294596e-02f, -4.85738441e-02f, -2.95609348e-02f, 4.72696126e-02f, -3.51132229e-02f,
  3.04416716e-02f, 6.54259250e-02f, 2.49084458e-02f, 1.66959185e-02f, -1.12060159e-01f, -2.31375583e-02f, 4.47478481e-02f, 7.12937117e-02f, -2.66383365e-02f, 3.92908938e-02f,
  1.84486061e-02f, -6.21990561e-02f, -1.69225633e-02f, -9.90395807e-03f, 3.73508520e-02f, 1.22031227e-01f, 1.25806611e-02f, -1.18619852e-01f, -4.67881337e-02f, -5.29988818e-02f,
  4.65938061e-01f, 8.85744300e-03f, -2.60257661e-01f, 4.07596538e-03f, -1.76387578e-01f, -3.34338516e-01f, -4.41261828e-01f, -1.20753780e-01f, 9.41622555e-02f, 6.81864172e-02f,
  5.63361533e-02f, 1.15695812e-01f, 4.08535860e-02f, 2.27844641e-02f, -1.78976804e-01f, -2.28357479e-01f, -2.84386337e-01f, 1.80119704e-02f, -1.58468485e-02f, 6.53931946e-02f,
  6.34133443e-02f, 1.81443498e-01f, 2.37938449e-01f, 2.63165068e-02f, 1.58903271e-01f, 4.20579650e-02f, -8.43544230e-02f, -9.94556304e-03f, -2.59072036e-02f, 4.23090979e-02f,
  2.07789525e-01f, 6.76754862e-02f, -2.67247520e-02f, 8.87781084e-02f, 5.72222732e-02f, 1.02496400e-01f, 9.00420249e-02f, 1.44631773e-01f, -3.46003212e-02f, -6.62796348e-02f,
  -1.60506144e-02f, 9.39398333e-02f, -6.49741711e-03f, 6.35679215e-02f, -8.32958799e-03f, 3.84725444e-02f, 1.17430963e-01f, 3.75266075e-02f, 1.53861456e-02f, -6.78749010e-02f,
  -9.04837698e-02f, 5.66238444e-03f, -2.67176237e-02f, -1.13490395e-01f, -6.42733797e-02f, 3.23320292e-02f, 8.64866972e-02f, 3.60639878e-02f, -5.52123860e-02f, 1.13545507e-01f,
  7.84600154e-03f, -5.68337403e-02f, -3.38936821e-02f, 6.97964132e-02f, -2.93470155e-02f, 3.27663049e-02f, -2.43927538e-02f, -9.19467360e-02f, -4.95495275e-02f, 6.76352978e-02f,
  1.65967699e-02f, -6.92441985e-02f, -4.70404793e-03f, 1.59643707e-03f, 6.02988489e-02f, -6.36824146e-02f, 1.48565241e-03f, -5.06991660e-03f, -2.13442557e-03f, 4.16083261e-02f,
  -1.86589714e-02f, -6.55207923e-03f, 4.00858931e-02f, 6.42001852e-02f, 2.80539431e-02f, 2.78209057e-02f, 4.35675271e-02f, 2.17951331e-02f, 3.74994241e-02f, 3.91906425e-02f,
  2.00256541e-01f, -2.31514275e-01f, 4.37428541e-02f, 8.56855214e-02f, -6.19680621e-02f, 8.39827657e-02f, 2.06250716e-02f, -1.51961874e-02f, -7.23771378e-03f, -2.33306382e-02f,
  -5.89947551e-02f, 9.49324667e-02f, 5.13396934e-02f, 5.65605201e-02f, 3.02206408e-02f, -1.18249953e-02f, 2.88888272e-02f, 7.45597780e-02f, -1.44732654e-01f, 2.72630323e-02f,
  -3.68794799e-02f, -1.62100922e-02f, -9.16508120e-03f, -8.05245042e-02f, -7.17904493e-02f, -7.40295742e-03f, -8.09272826e-02f, 3.67546193e-02f, -1.21655509e-01f, -6.34587090e-03f,
  -3.53915453e-01f, 4.08807367e-01f, 6.80085495e-02f, -9.22897905e-02f, 7.62870815e-03f, 8.37224163e-03f, 2.96139926e-01f, 5.72339259e-03f, 1.83862597e-02f, 6.19396381e-03f,
  1.12196162e-01f, -1.40586207e-02f, 1.63994759e-01f, 7.34146312e-02f, 1.34883896e-01f, 1.41544804e-01f, 2.51939863e-01f, 1.76518578e-02f, -1.14796102e-01f, -1.10591292e-01f,
  -4.63030450e-02f, -1.58934668e-01f, -6.33590519e-02f, 2.55212542e-02f, 6.22412469e-03f, -9.32657048e-02f, 1.28657848e-01f, -1.80533901e-02f, 1.09432340e-01f, 1.54482484e-01f,
  5.89011461e-02f, -9.00857598e-02f, -7.02309757e-02f, -8.35929289e-02f, -8.99153128e-02f, 6.89705163e-02f, -2.00956259e-02f, -1.16477311e-01f, 3.38364653e-02f, -6.81591853e-02f,
  -1.33803980e-02f, 6.25584796e-02f, 8.54003206e-02f, -1.09613612e-02f, -2.85867378e-02f, -3.03716455e-02f, 4.59829904e-02f, 1.50652397e-02f, 7.71570802e-02f, -4.23275940e-02f,
  3.65674123e-02f, -1.93183441e-02f, -1.07906558e-01f, -8.78733024e-03f, 6.26997207e-04f, 3.14317159e-02f, 6.56355470e-02f, -1.01896107e-01f, 2.45107245e-02f, 1.85141247e-02f,
  -7.13543221e-02f, -1.42290831e-01f, -4.46779653e-02f, 5.53370602e-02f, -1.28794285e-02f, -4.15243208e-02f, 1.95483342e-02f, 7.03414381e-02f, -1.50059490e-02f, 1.34269185e-02f,
  4.30936925e-02f, -7.90583417e-02f, 3.11029367e-02f, -4.69956771e-02f, 1.34023987e-02f, 1.59643814e-02f, 3.75805460e-02f, 7.00919479e-02f, 3.88874337e-02f, 7.77195990e-02f,
  -8.72161239e-02f, 4.98404205e-02f, -1.31003326e-02f, 1.26265824e-01f, 9.17210616e-03f, 3.81910279e-02f, 5.41985780e-03f, 7.51723573e-02f, 4.92690615e-02f, 8.95441622e-02f,
  -1.35249853e-01f, -3.97231542e-02f, 6.69512227e-02f, 8.18119943e-02f, 3.33168246e-02f, -4.67631705e-02f, 7.26149008e-02f, -2.13442966e-02f, 4.06772085e-02f, -1.27138607e-02f,
  -6.91659981e-03f, 2.23558918e-02f, 1.23580985e-01f, 2.40220204e-02f, 2.51662196e-03f, 8.62212479e-03f, -3.48878615e-02f, 6.95699751e-02f, 5.94873838e-02f, -1.83927119e-02f,
  1.05754144e-01f, -7.93886092e-03f, -1.14158481e-01f, 1.00205041e-01f, -6.19664975e-02f, -6.25241548e-02f, -4.70448062e-02f, -9.91079137e-02f, -1.12082651e-02f, 3.95607203e-03f,
  1.03270046e-01f, 4.33520347e-01f, -1.28845662e-01f, -1.28866062e-01f, -7.96689242e-02f, 9.17268172e-02f, 2.78452486e-01f, 2.96986639e-01f, 9.11966264e-02f, 1.32435322e-01f,
  3.50328498e-02f, -1.83444917e-01f, -1.13170877e-01f, 2.72566751e-02f, 2.01622412e-01f, 7.45127350e-02f, -8.76574218e-02f, -2.38335088e-01f, -6.49323761e-02f, 1.56611130e-02f,
  -3.86856087e-02f, 9.34227630e-02f, 2.48041879e-02f, 1.54571027e-01f, 1.49029851e-01f, -1.20971203e-02f, 1.69008523e-01f, 9.40496027e-02f, 1.72658637e-01f, -9.43374261e-02f,
  -2.29052812e-01f, 2.57430583e-01f, -1.66094050e-01f, -1.27586573e-02f, 1.00510046e-01f, 4.85964008e-02f, 2.70201806e-02f, 1.05101272e-01f, 1.64744794e-01f, 7.04899132e-02f,
  1.29399020e-02f, 1.38998553e-01f, 9.84176770e-02f, 1.57064468e-01f, 1.01326309e-01f, 1.46909431e-01f, 1.40768036e-01f, 1.08114168e-01f, 2.27716621e-02f, 1.58280224e-01f,
  7.38477381e-03f, 9.23938304e-02f, 2.56222226e-02f, 2.05815464e-01f, 2.00044751e-01f, 2.44483612e-02f, 1.76036924e-01f, 1.09601319e-01f, 1.74762800e-01f, 5.09777814e-02f,
  -9.67328250e-02f, -8.08838308e-02f, -8.44770223e-02f, -2.55912775e-03f, -1.06586948e-01f, -3.20367701e-03f, -1.16771042e-01f, -1.20018914e-01f, -4.67412136e-02f, -6.42711520e-02f,
  -8.65553245e-02f, -9.75392461e-02f, -1.44690126e-01f, -1.34096265e-01f, -1.63828462e-01f, -1.07284434e-01f, -8.02442208e-02f, -9.45687070e-02f, -1.19816676e-01f, -1.98843423e-02f,
  -1.72342241e-01f, -1.77546695e-01f, -5.24430498e-02f, -2.46998779e-02f, -2.43405383e-02f, -6.06208332e-02f, -1.00202374e-01f, -7.82221630e-02f, -5.81480153e-02f, -1.93101928e-01f,
  -9.92272347e-02f, 7.95895830e-02f, -1.48515210e-01f, 6.96093440e-02f, 2.23566666e-02f, 1.45587265e-01f, -9.77820624e-03f, -2.71064490e-02f, 6.69440851e-02f, 4.74443622e-02f,
  6.17166907e-02f, 1.00055560e-01f, 9.39093530e-02f, 1.24416120e-01f, 1.31182512e-02f, 7.79030658e-03f, 1.57891452e-01f, 1.10401614e-02f, 1.54576406e-01f, 1.20734684e-01f,
  9.23816264e-02f, 2.30444148e-02f, -6.52735531e-02f, 3.54834506e-03f, 1.37637421e-01f, -9.44564864e-02f, -5.50574586e-02f, 2.36448292e-02f, 2.13789977e-02f, 7.42339939e-02f,
  3.62963080e-01f, 2.08983883e-01f, 1.34913385e-01f, 2.07374513e-01f, 1.93138063e-01f, 2.19782531e-01f, 3.44722748e-01f, 1.44102886e-01f, 2.54376084e-01f, 1.54515237e-01f,
  1.48256883e-01f, 7.08808452e-02f, 2.24855512e-01f, 6.19227365e-02f, 2.14831889e-01f, 1.33020252e-01f, 2.78801084e-01f, 1.63165286e-01f, 1.34712636e-01f, 2.17300788e-01f,
  1.22007228e-01f, 1.81101993e-01f, 1.22486375e-01f, 1.62487328e-01f, 2.99349904e-01f, 1.69486329e-01f, 1.54013589e-01f, 1.43011361e-01f, 2.70893425e-01f, 3.14060122e-01f,
  1.87785253e-01f, 7.23448843e-02f, 1.77921250e-01f, 1.34642094e-01f, 7.39438683e-02f, 1.52006254e-01f, 1.39266372e-01f, 5.53137623e-02f, 1.19032614e-01f, 1.45648554e-01f,
  1.30482599e-01f, 7.03857020e-02f, 2.02335656e-01f, 1.88829556e-01f, 9.86267999e-02f, 9.60502699e-02f, 1.14432327e-01f, 9.57722217e-02f, 1.25916258e-01f, 9.09652784e-02f,
  8.44319090e-02f, 9.91314054e-02f, 2.01497540e-01f, 1.61190882e-01f, 1.44847780e-01f, 4.93128225e-02f, 9.11084712e-02f, 1.88390985e-01f, 2.22569287e-01f, 2.72394836e-01f,
  -8.56609084e-03f, -1.11368619e-01f, -1.65212452e-01f, -9.77695286e-02f, -1.74954474e-01f, -1.40910208e-01f, -1.61856860e-01f, -1.27842709e-01f, -1.79423466e-02f, -2.04002693e-01f,
  -2.21291296e-02f, -7.26811811e-02f, -8.85441303e-02f, -1.42412916e-01f, -5.20371273e-02f, -1.28515437e-02f, -1.59735724e-01f, -1.38725899e-02f, -1.65199876e-01f, -4.14625704e-02f,
  -1.30339190e-01f, -8.90965983e-02f, -8.99161100e-02f, -8.58151019e-02f, -1.39378294e-01f, -1.75578862e-01f, -3.76625918e-02f, -1.34159863e-01f, -1.65031940e-01f, -1.11573108e-01f,
  1.42519742e-01f, -5.15072942e-02f, 1.84716508e-01f, 1.96365878e-01f, 6.65685162e-02f, 1.37700707e-01f, 1.27510978e-02f, 9.41023827e-02f, 7.19133615e-02f, 1.00947678e-01f,
  8.90934765e-02f, 1.99733242e-01f, 1.56266838e-01f, 1.32495046e-01f, 1.02686003e-01f, 1.28995359e-01f, 1.10571310e-01f, 1.75094187e-01f, 1.18138589e-01f, 1.43752679e-01f,
  1.90042064e-01f, 1.52056202e-01f, 1.17818192e-01f, 1.41515121e-01f, 1.15074791e-01f, 2.16178358e-01f, 1.60906687e-01f, 2.46424839e-01f, 1.80322036e-01f, 3.11827272e-01f,
  5.24784029e-02f, 2.59480745e-01f, 2.09115729e-01f, -6.32315949e-02f, 5.04211746e-02f, 1.25864893e-01f, 3.99848551e-01f, 1.52277321e-01f, -2.19001919e-01f, 1.11215957e-01f,
  -2.51915082e-02f, -2.25254685e-01f, -1.81615666e-01f, -5.72078414e-02f, 6.62085637e-02f, 2.47295231e-01f, 1.53062344e-01f, 2.06136882e-01f, 5.04599810e-02f, 1.71843410e-01f,
  -4.79041450e-02f, 8.84950310e-02f, 4.91130948e-02f, -5.43908253e-02f, -1.86779872e-01f, -1.93360716e-01f, -3.11078168e-02f, 9.38870534e-02f, 1.44286305e-01f, -9.33934227e-02f,
  -7.82335326e-02f, 6.27042502e-02f, 3.99184413e-02f, -9.82526094e-02f, -3.40876095e-02f, -7.08832443e-02f, -4.99103516e-02f, -9.41517670e-03f, -1.03081707e-02f, 6.89640865e-02f,
  4.80839498e-02f, -1.19422011e-01f, 1.30411452e-02f, -1.01955868e-01f, -5.19541875e-02f, 3.09218112e-02f, -1.24272667e-02f, 9.38343704e-02f, 3.19499597e-02f, 2.11529676e-02f,
  -4.15917858e-02f, 2.03184545e-01f, 1.54166013e-01f, 1.02349341e-01f, 2.15272270e-02f, -1.45118311e-02f, 2.43145577e-03f, -5.56248873e-02f, -1.42534338e-02f, 6.87199831e-02f,
  -5.95190749e-02f, 2.62746252e-02f, -6.69327676e-02f, -1.62495971e-02f, -5.05397916e-02f, -4.37221155e-02f, -1.48023581e-02f, -1.61531917e-03f, -2.74773370e-02f, 3.73750106e-02f,
  2.26490181e-02f, 9.77313612e-03f, -5.51607199e-02f, 1.20519139e-02f, 1.57357473e-02f, 1.39436156e-01f, 8.02631453e-02f, 7.47235641e-02f, 7.09933043e-02f, 2.32044328e-02f,
  3.99466455e-02f, 9.00248289e-02f, 4.50253375e-02f, -3.74519639e-02f, 4.54885773e-02f, 1.35589475e-02f, 2.60034995e-03f, 8.16166052e-04f, -3.88416112e-03f, 6.87938780e-02f,
  -2.27365941e-01f, 2.30627194e-01f, -2.94371322e-02f, 3.90560441e-02f, -1.89734679e-02f, -5.38780168e-02f, 3.71486843e-02f, 2.04284713e-02f, 1.80425886e-02f, 5.13288043e-02f,
  3.40340100e-02f, 6.81635812e-02f, 3.79107818e-02f, -1.37987705e-02f, 9.23034400e-02f, 5.28708994e-02f, 6.97246119e-02f, 1.19198829e-01f, 2.03966051e-02f, -1.29153673e-02f,
  1.90132726e-02f, 1.84747666e-01f, 7.37384036e-02f, 7.75195956e-02f, 3.99552733e-02f, 6.18971214e-02f, 1.32326767e-01f, -2.32206769e-02f, 8.77722949e-02f, 8.84956419e-02f,
  -1.35278240e-01f, -2.65346706e-01f, -1.87474847e-01f, -2.57159650e-01f, -4.58692610e-01f, -3.15033585e-01f, -1.46339774e-01f, -1.80442840e-01f, -1.63879797e-01f, -1.37242019e-01f,
  -2.51046121e-01f, -8.80895182e-02f, 2.45752614e-02f, 4.24903296e-02f, 2.18149677e-01f, -1.13084853e-01f, -1.86450824e-01f, 1.57006755e-01f, 1.74397349e-01f, 8.73368140e-03f,
  -2.26342991e-01f, -7.61806443e-02f, -2.62227003e-02f, 5.99324554e-02f, -2.21921131e-01f, -7.17420131e-02f, -9.40546691e-02f, -2.50662208e-01f, -1.90860450e-01f, -2.37516582e-01f,
  5.87782860e-02f, -1.03936002e-01f, 7.28842318e-02f, 6.85845912e-02f, 8.23774636e-02f, 6.85213432e-02f, -5.09563694e-03f, 6.94971904e-02f, 1.19593972e-02f, 7.26681873e-02f,
  -7.95634612e-02f, 5.29441908e-02f, 3.39832120e-02f, -2.70010532e-05f, 5.76144904e-02f, 7.09903240e-02f, 4.35121991e-02f, 1.51724964e-01f, 6.72482401e-02f, -3.67947221e-02f,
  -5.81187457e-02f, -2.42089629e-01f, -1.91227004e-01f, 6.39798120e-02f, -4.64679077e-02f, 4.19806130e-02f, -1.88527033e-02f, 8.13361444e-03f, 2.30365843e-02f, 4.31539752e-02f,
  1.95873436e-03f, -5.29965721e-02f, -1.04444139e-01f, 5.19308932e-02f, 1.89512819e-02f, -1.12654090e-01f, 2.12021992e-02f, -8.47257972e-02f, 1.66673493e-02f, 9.20264125e-02f,
  -1.32444184e-02f, 2.45261472e-02f, 1.51978862e-02f, 3.93192917e-02f, -1.20569058e-02f, -1.24914974e-01f, -3.82897407e-02f, 6.19818121e-02f, 3.32902037e-02f, 3.09349913e-02f,
  -7.79010579e-02f, -5.37299700e-02f, -3.55439521e-02f, 9.43243951e-02f, 8.77416227e-03f, -6.84569478e-02f, -2.68945992e-02f, -1.03219196e-01f, -1.31713212e-01f, -2.35057604e-02f,
  -2.72853673e-02f, 4.50127274e-02f, 9.79511300e-04f, 5.74401878e-02f, -1.03666961e-01f, 4.86913435e-02f, 9.66456532e-03f, -1.72739923e-02f, -1.16995327e-01f, -4.91488799e-02f,
  -6.35640174e-02f, 8.09726641e-02f, -2.34779785e-03f, 9.36660264e-03f, 4.91558537e-02f, -2.05536690e-02f, -1.16358772e-02f, -1.54752627e-01f, -6.42237514e-02f, -6.07379377e-02f,
  -1.34836689e-01f, -2.10743427e-01f, -1.80885956e-01f, -1.13336325e-01f, -6.79095387e-02f, -1.37893543e-01f, 3.90370414e-02f, -5.21197878e-02f, 5.85397258e-02f, -2.58767400e-02f,
  5.51274605e-02f, 3.41275901e-01f, 3.43741030e-01f, 2.52445787e-01f, 7.21444143e-04f, -1.86283112e-01f, -1.16302006e-01f, -4.94144522e-02f, -3.54047120e-02f, 3.91088100e-03f,
  -5.76083064e-02f, -1.71583161e-01f, -1.01909451e-01f, -1.41853541e-01f, -5.48645621e-03f, 1.75900340e-01f, 2.13528126e-01f, 1.42935753e-01f, -1.42211346e-02f, -1.12427719e-01f,
  6.37346506e-02f, 2.37510562e-01f, 2.23349854e-01f, 1.51769549e-01f, 3.24478745e-01f, 9.49424431e-02f, 3.25438470e-01f, 2.00501978e-01f, 9.65825319e-02f, 4.33339268e-01f,
  1.81100085e-01f, -3.10301688e-02f, -8.00796300e-02f, -1.33599034e-02f, 1.42600134e-01f, -6.26393184e-02f, 1.21617299e-02f, 7.20654279e-02f, 8.67746584e-03f, 6.36980012e-02f,
  5.04644178e-02f, -4.65844013e-02f, 4.18560691e-02f, 1.88302826e-02f, 1.28058940e-01f, 1.22852027e-02f, 3.72197255e-02f, 8.85165483e-02f, 1.11854903e-01f, 9.46915746e-02f,
  2.11010017e-02f, 1.17730983e-01f, 1.52959630e-01f, 1.47027701e-01f, 7.65720895e-03f, -4.86816652e-03f, 1.31505772e-01f, 3.41355167e-02f, 3.81677710e-02f, 2.32832447e-01f,
  7.27644116e-02f, 8.29666778e-02f, -4.36448120e-02f, -3.98032367e-02f, 9.68419667e-03f, -9.76270884e-02f, 5.08243889e-02f, -8.44080970e-02f, 1.71222221e-02f, 3.15236971e-02f,
  5.27892858e-02f, -9.38851014e-02f, -4.15405966e-02f, 5.69493361e-02f, 5.09790890e-02f, -1.16472831e-02f, 5.55766486e-02f, -1.87627273e-03f, -6.06678613e-02f, -8.63374248e-02f,
  -6.29015341e-02f, -7.67736882e-02f, -1.77793596e-02f, -2.72019915e-02f, 1.07130064e-02f, -4.85830642e-02f, -3.09608951e-02f, -1.02575853e-01f, -1.87098756e-01f, -8.57066140e-02f,
  1.16648115e-01f, -1.51027828e-01f, -1.45884240e-02f, -4.64602634e-02f, -1.84837691e-02f, 7.34970048e-02f, 1.28828436e-02f, 2.90915053e-02f, 1.23179788e-02f, 3.24580856e-02f,
  -2.82027721e-02f, -1.66359991e-02f, 1.46054775e-02f, 5.47798835e-02f, 5.17869517e-02f, -8.80938098e-02f, -3.81251471e-03f, 8.87544230e-02f, 4.04495820e-02f, 5.33146858e-02f,
  3.35415490e-02f, -3.09285242e-02f, -5.83828911e-02f, 3.75525802e-02f, 4.28150594e-02f, 2.91346982e-02f, 9.91647467e-02f, -1.87794715e-02f, -1.81714116e-04f, 2.14361385e-01f,
  5.58610857e-01f, 3.75110805e-02f, -3.03656876e-01f, 2.40371615e-01f, -2.52068788e-01f, -3.82377565e-01f, -3.53183985e-01f, 3.77771668e-02f, 2.02091679e-01f, -2.31473800e-02f,
  -9.06385481e-02f, 1.49313539e-01f, 1.12182491e-01f, 2.39010453e-02f, 6.62759878e-03f, -2.77351826e-01f, -2.58091211e-01f, -4.62974645e-02f, -8.44188333e-02f, 8.73810947e-02f,
  5.53407893e-02f, 1.14331312e-01f, 1.68555513e-01f, 6.32841364e-02f, 7.40871727e-02f, 4.47428338e-02f, -1.78833738e-01f, 2.74699535e-02f, -1.37319401e-01f, -6.33106604e-02f,
  -1.36295885e-01f, 2.31931627e-01f, -8.90845582e-02f, 1.13459006e-01f, -7.92641491e-02f, 8.72930512e-02f, 7.60811940e-02f, 5.64129651e-02f, 8.47928822e-02f, 2.27368772e-02f,
  -5.87086044e-02f, 4.35565598e-02f, 3.30841877e-02f, -5.32175601e-02f, 4.65103146e-03f, 3.71395983e-02f, 9.23834518e-02f, 1.30824640e-01f, 6.47960603e-02f, -3.15182842e-02f,
  -4.95299734e-02f, -3.02981101e-02f, -2.80215908e-02f, -1.46913320e-01f, 8.95060822e-02f, -1.51519462e-01f, -8.34270031e-04f, 9.77687910e-02f, -5.16425297e-02f, 1.58525363e-01f,
  -1.02473814e-02f, -5.04621491e-02f, -6.72409078e-03f, 6.90608174e-02f, -3.89718488e-02f, 3.72016318e-02f, -1.21766776e-02f, -5.36342412e-02f, 7.36839473e-02f, -8.40503909e-03f,
  5.10174520e-02f, -7.64589459e-02f, 7.53310919e-02f, -1.61336008e-02f, 1.01380525e-02f, -3.51632270e-03f, -5.29394150e-02f, 1.02971429e-02f, 3.25311199e-02f, 3.21167521e-02f,
  5.64339384e-02f, -5.33656366e-02f, 7.30790570e-02f, -7.05380291e-02f, -9.64157842e-03f, -9.66140907e-03f, 4.19803970e-02f, 2.20152009e-02f, 3.39376107e-02f, 8.98068398e-02f,
  2.14903623e-01f, -2.60224491e-01f, 9.48307216e-02f, 8.15133452e-02f, -1.82418916e-02f, -6.34267461e-03f, -7.45275319e-02f, 3.17679867e-02f, -8.04805979e-02f, 6.53067827e-02f,
  6.23227768e-02f, 7.70113152e-03f, -4.72551771e-02f, -1.51417600e-02f, -9.43750143e-02f, -1.47965280e-02f, -4.55885753e-02f, -2.64883246e-02f, 1.60428565e-02f, 1.08886743e-02f,
  2.26645898e-02f, -5.91501370e-02f, -1.47361040e-01f, -1.38753384e-01f, -7.23115280e-02f, -4.35011871e-02f, -1.24189325e-01f, -7.60345086e-02f, -2.01087639e-01f, 6.24476224e-02f,
  1.77195936e-01f, -2.43522361e-01f, -2.93033868e-01f, -2.08353519e-01f, -2.86809146e-01f, -1.70670092e-01f, -1.80088893e-01f, -3.79357152e-02f, -1.06492355e-01f, -2.17853561e-01f,
  -3.16272527e-02f, 1.10679708e-01f, 6.02935515e-02f, 5.40270358e-02f, -3.45453387e-03f, -2.05028132e-01f, -2.23343760e-01f, -3.84572381e-03f, -6.59878775e-02f, -2.98902802e-02f,
  8.20221205e-04f, -9.61355194e-02f, 1.61066093e-02f, -5.37424833e-02f, -1.96784362e-02f, -3.76782417e-02f, -2.28493642e-02f, -4.67548966e-02f, -1.17634580e-01f, -9.70125869e-02f,
  -1.22357287e-01f, -8.09804350e-02f, 1.37531593e-01f, 1.33099854e-01f, 4.83844094e-02f, 2.04297137e-02f, 2.18376666e-02f, -3.62188905e-03f, 1.51787549e-01f, 8.16709995e-02f,
  7.25103021e-02f, 7.95087144e-02f, 1.01799302e-01f, 2.63197962e-02f, 7.64749721e-02f, 9.25253257e-02f, 1.71824805e-02f, 9.17936191e-02f, 4.99578044e-02f, -5.06185740e-02f,
  6.71464857e-03f, -5.71282096e-02f, 5.74855246e-02f, 4.54260595e-02f, -6.07334822e-02f, 1.10138237e-01f, 1.01381548e-01f, 7.54367411e-02f, 1.34206519e-01f, 5.41827865e-02f,
  -1.37796909e-01f, -8.14204514e-02f, -1.56040369e-02f, -6.90218657e-02f, -2.54217181e-02f, 2.34991405e-02f, -1.19081929e-01f, -5.75892068e-02f, -7.30312392e-02f, -7.54471421e-02f,
  -7.99774081e-02f, -1.27973810e-01f, -1.17902659e-01f, -1.23122178e-01f, -4.85779196e-02f, -7.35421181e-02f, -1.15703136e-01f, -7.96447247e-02f, -5.68838529e-02f, -1.29444391e-01f,
  -7.97969382e-03f, -6.39527887e-02f, -4.25283723e-02f, -1.03768267e-01f, -1.24080643e-01f, -1.05952196e-01f, -6.40831888e-02f, -3.39459628e-02f, -8.53050873e-02f, -1.13800049e-01f,
  1.37493283e-01f, 4.46501896e-02f, 1.22747980e-02f, 1.66050062e-01f, 4.52959761e-02f, 1.50406852e-01f, 6.95181042e-02f, 1.44197345e-01f, 7.87800401e-02f, 8.79732296e-02f,
  3.21205892e-02f, 4.71316241e-02f, 8.01121071e-02f, 1.05579589e-02f, 1.07929416e-01f, 1.33364558e-01f, 5.32225966e-02f, 2.26129568e-03f, 1.25900432e-01f, 2.69430466e-02f,
  5.39892055e-02f, 1.22810863e-01f, 1.55032203e-01f, 1.39841422e-01f, 3.62956151e-02f, 1.05782978e-01f, 1.45593539e-01f, 1.82347432e-01f, 7.87878186e-02f, 8.42162669e-02f,
  2.74800450e-01f, 4.55330173e-03f, -8.46342072e-02f, 6.73111975e-02f, 1.39967039e-01f, 1.99996158e-02f, -6.95792912e-03f, 7.50919580e-02f, -5.27540445e-02f, -6.94799274e-02f,
  -5.45766158e-03f, -1.60312474e-01f, -9.92344692e-02f, -1.06386214e-01f, -8.96418989e-02f, -1.26587912e-01f, -1.47636816e-01f, -5.89186288e-02f, 1.23502955e-01f, 2.20845163e-01f,
  -3.22536230e-02f, 2.16278419e-01f, 2.04876289e-01f, -2.31996831e-02f, -1.34359635e-02f, -7.56755322e-02f, -1.15777239e-01f, 1.33354098e-01f, 3.28815803e-02f, -4.32238840e-02f,
  -2.25069374e-01f, 1.81172535e-01f, 5.30957943e-03f, -4.39187549e-02f, -3.25340382e-03f, 4.30255793e-02f, 9.31842700e-02f, 3.38697433e-02f, 2.51810215e-02f, -6.33256957e-02f,
  -1.08775524e-02f, 9.34890509e-02f, 1.03744052e-01f, 1.24613553e-01f, 9.77276713e-02f, 7.27859586e-02f, 9.32549015e-02f, -3.02215386e-02f, 1.42869689e-02f, -1.35427900e-02f,
  -4.81956899e-02f, 8.57687742e-02f, 1.63222045e-01f, 4.70236167e-02f, 3.92038049e-03f, 2.20375564e-02f, 1.20177409e-02f, 1.05232932e-01f, 1.80801973e-02f, -1.52482271e-01f,
  -1.28175706e-01f, -1.22560766e-02f, 9.07407552e-02f, -6.29279902e-03f, 2.89080814e-02f, -2.03024931e-02f, -2.32399572e-02f, 6.21122196e-02f, -2.13562492e-02f, 4.53949533e-02f,
  -2.59027332e-02f, -4.09630388e-02f, -6.07439922e-03f, -1.60012189e-02f, -8.86684731e-02f, 1.17749646e-01f, 2.98790373e-02f, 3.04534789e-02f, -6.10686140e-03f, 4.78052273e-02f,
  1.01958262e-03f, 6.62241653e-02f, 6.05676994e-02f, -2.28431989e-02f, 3.01646590e-02f, 5.18000349e-02f, -2.84440145e-02f, -2.78612301e-02f, 7.31342733e-02f, 1.07884072e-01f,
  -1.21449657e-01f, 1.07014365e-01f, -1.97826311e-01f, -3.12724411e-02f, -3.53247412e-02f, 1.43818092e-02f, -1.18412636e-01f, -2.98239645e-02f, -2.46129204e-02f, -2.34271139e-02f,
  2.18269485e-03f, -1.15073197e-01f, -2.02960223e-02f, 2.78076087e-03f, -1.27243041e-03f, -6.18569069e-02f, -2.44928687e-03f, -3.36740464e-02f, -2.28923261e-02f, -1.75961275e-02f,
  -2.02491414e-02f, -8.13801140e-02f, -1.14500351e-01f, -1.46550551e-01f, 2.15519648e-02f, -1.30484685e-01f, -1.23716682e-01f, -1.62705094e-01f, -1.87771708e-01f, -2.74931103e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.04094011e-01f, -4.30768222e-01f, -2.66517490e-01f, 2.27338642e-01f, -3.74544114e-01f, -3.91541064e-01f, -2.46418059e-01f, 2.17337102e-01f, 1.72302127e-01f, -3.47503275e-01f,
  -3.15570176e-01f, -3.20542246e-01f, -2.90650606e-01f, -8.69233906e-02f, -1.43403083e-01f, -1.49812505e-01f, -8.11530948e-02f, -3.95962894e-02f, 9.55343693e-02f, -4.01198417e-02f,
  -8.91758353e-02f, 1.19496703e-01f, 1.79183200e-01f, 1.83826536e-01f, -1.78514853e-01f, -2.21445397e-01f, -5.70294335e-02f, -4.11065714e-03f, -2.37929359e-01f, -3.78308594e-01f,
  -4.06320363e-01f, -2.37106904e-01f, 8.25237706e-02f, -1.48363203e-01f, -9.00204629e-02f, -7.84053355e-02f, -8.31554085e-02f, 6.17841892e-02f, -2.25953117e-01f, -5.35779335e-02f,
  -2.56787598e-01f, -4.00298685e-02f, -9.92248952e-02f, -1.71623275e-01f, 6.52228445e-02f, -2.15567589e-01f, 3.91373128e-01f, 2.31723920e-01f, 1.87336460e-01f, -2.77538132e-02f,
  -2.94058263e-01f, -5.27136624e-01f, -2.07750678e-01f, 2.48052463e-01f, 3.39773834e-01f, 8.17266926e-02f, 9.12268087e-03f, -9.77303949e-04f, 1.22031212e-01f, -1.93487778e-01f,
  2.16653258e-01f, -4.28700186e-02f, 7.38060568e-03f, -1.80784930e-02f, -3.44116502e-02f, 8.26998577e-02f, 9.06883925e-02f, 2.85371765e-02f, -1.67900413e-01f, -1.03630655e-01f,
  2.41176113e-01f, 5.86957820e-02f, 1.30153865e-01f, -4.72403280e-02f, -3.16923298e-02f, -8.76656771e-02f, -8.21351409e-02f, 6.23620450e-02f, -2.43228991e-02f, -7.85834193e-02f,
  -2.35149503e-01f, -4.63689007e-02f, 3.59090418e-02f, 7.21307844e-02f, -1.54422000e-01f, 5.64343967e-02f, -1.37517676e-01f, -1.33391377e-03f, 1.97074607e-01f, -1.20554902e-02f,
  1.55879334e-01f, 6.70690760e-02f, -2.64466494e-01f, -7.07668141e-02f, -1.52939692e-01f, 9.54712778e-02f, -2.41537809e-01f, 5.20270839e-02f, -1.75275147e-01f, -1.70848668e-01f,
  -2.37467065e-01f, 1.08755499e-01f, -3.64256017e-02f, -7.86062181e-02f, -5.65441651e-03f, -7.59898126e-02f, 4.40345779e-02f, -1.89608425e-01f, -1.15190089e-01f, 2.16122121e-02f,
  2.10168675e-01f, -4.24206853e-01f, -4.56793755e-01f, -2.18348756e-01f, -9.14363936e-02f, -2.68109292e-01f, -3.66928577e-01f, -1.94646686e-01f, -2.14822546e-01f, -1.36534393e-01f,
  5.55947661e-01f, -3.55161309e-01f, -4.42923993e-01f, -1.37012582e-02f, 2.70952702e-01f, 3.48560810e-01f, 4.64596123e-01f, 2.26326585e-01f, 1.35676697e-01f, -1.73255160e-01f,
  -1.37249202e-01f, -1.66722506e-01f, -3.02600980e-01f, -2.43393481e-01f, 1.44673452e-01f, -1.30165994e-01f, -1.41950607e-01f, -1.05836347e-01f, 1.52385831e-01f, 3.01373392e-01f,
  4.66423370e-02f, -1.55777320e-01f, -8.73040408e-02f, -1.04121648e-01f, -4.26177770e-01f, -3.45681190e-01f, -4.96004373e-01f, -3.86101693e-01f, -1.41515151e-01f, -5.33254147e-01f,
  -4.06044662e-01f, 9.79569703e-02f, 4.02238257e-02f, 5.39557368e-04f, -2.30705932e-01f, 1.03746705e-01f, -8.60021561e-02f, -2.17619181e-01f, 6.82021976e-02f, -1.19837336e-01f,
  -1.14470288e-01f, -2.67825002e-04f, -1.15467466e-01f, -4.16563265e-02f, 5.62486351e-02f, -6.73621595e-02f, -1.10621296e-01f, 8.29699356e-03f, -1.48044452e-01f, -1.27734974e-01f,
  -1.59674719e-01f, 1.83260709e-01f, 2.80948311e-01f, 9.87384766e-02f, -5.02753351e-03f, 1.06746480e-01f, 4.76958714e-02f, 4.35062274e-02f, 4.69232351e-02f, 8.95275921e-02f,
  -8.61117840e-02f, 5.56759350e-02f, 3.67837376e-04f, -8.47366974e-02f, 1.66865140e-01f, 1.07902192e-01f, 2.84515899e-02f, 1.58542600e-02f, -3.77012528e-02f, -4.63085361e-02f,
  -1.53101841e-02f, 3.11296768e-02f, -2.15581413e-02f, -8.85027573e-02f, -8.68574828e-02f, -8.51852670e-02f, 1.23142838e-01f, -4.07163538e-02f, -9.84354690e-02f, -8.65081325e-02f,
  -2.49657184e-02f, 3.89547758e-02f, -1.74929500e-01f, -1.09727874e-01f, -9.68005285e-02f, 8.24650284e-03f, -1.17163107e-01f, -1.02034606e-01f, -3.21329720e-02f, -5.95966429e-02f,
  -3.99545580e-01f, 1.29620075e-01f, 1.74761694e-02f, -1.12036511e-01f, -1.64573476e-01f, -1.21287733e-01f, -2.56892979e-01f, -1.02870837e-01f, -9.92346331e-02f, -4.15188111e-02f,
  -5.31726666e-02f, 6.29731715e-02f, -1.40658304e-01f, -1.06101066e-01f, 9.96858776e-02f, -1.48839429e-02f, -5.90474494e-02f, 9.82744545e-02f, -7.18269274e-02f, -1.28120437e-01f,
  -1.77500099e-02f, 2.38226295e-01f, 2.85651922e-01f, 5.96913770e-02f, 1.25253439e-01f, 7.26450980e-02f, -4.40329686e-02f, 5.90476505e-02f, 2.23362848e-01f, 1.49821416e-01f,
  -3.25389802e-01f, -3.48546267e-01f, 2.10777611e-01f, 1.46757513e-01f, 1.67202458e-01f, -8.23597163e-02f, -1.13986537e-01f, -1.52222618e-01f, -3.74758914e-02f, 5.33807464e-02f,
  4.04096441e-03f, -1.00284085e-01f, -4.47983071e-02f, -5.12220599e-02f, -2.18576014e-01f, 9.28727090e-02f, 3.23271453e-02f, -8.38746801e-02f, -1.27015352e-01f, -1.03165850e-01f,
  -4.89051417e-02f, 8.72666687e-02f, -6.33990616e-02f, -1.01832666e-01f, 1.87217042e-01f, 1.56734899e-01f, 2.31502473e-01f, 4.52909693e-02f, -6.91661090e-02f, 1.91219687e-01f,
  4.24568504e-01f, -2.01726809e-01f, -1.03417918e-01f, -1.21162541e-01f, -2.62865722e-02f, -1.90195724e-01f, -3.48376594e-02f, 8.96643847e-02f, -6.51099831e-02f, 1.59092575e-01f,
  2.11517769e-03f, -3.98488566e-02f, 2.41918899e-02f, 9.70622003e-02f, 5.92669323e-02f, 8.57707039e-02f, -4.92986403e-02f, -1.52500689e-01f, -4.10716832e-02f, -7.22548068e-02f,
  -5.22985868e-02f, -5.01959510e-02f, 4.29797592e-03f, -7.73470178e-02f, -1.05413377e-01f, -1.21438615e-02f, -9.45125744e-02f, -5.82639761e-02f, -4.42578755e-02f, 1.21095970e-01f,
  2.90540536e-03f, 2.23989367e-01f, 7.93367997e-02f, 2.13428214e-02f, -2.74484791e-02f, 1.19524524e-01f, 1.13441408e-01f, 1.86603501e-01f, 1.06192127e-01f, 3.84260565e-02f,
  3.09481602e-02f, -2.27039726e-03f, 7.13622421e-02f, -6.18522987e-02f, -1.41888000e-02f, 2.09522396e-02f, -8.58313218e-03f, 5.77994026e-02f, 3.57701902e-05f, 6.59519508e-02f,
  1.92181710e-02f, 3.27659100e-02f, 1.72726676e-01f, -7.73302391e-02f, -2.83984467e-02f, 1.48547385e-02f, 5.53354323e-02f, 1.91185158e-02f, -1.73255596e-02f, -1.11272736e-02f,
  3.86600405e-01f, -3.39389473e-01f, 6.00894317e-02f, -7.94360116e-02f, 8.85771662e-02f, -5.85655943e-02f, -4.09841985e-02f, -5.80251925e-02f, 1.89452738e-01f, 1.14565648e-01f,
  7.52640283e-03f, 4.51521352e-02f, -6.68656006e-02f, 6.58842325e-02f, 1.22557938e-01f, 6.74655959e-02f, -9.23610106e-02f, 8.12311247e-02f, -5.47797158e-02f, 4.83392971e-03f,
  -4.47084121e-02f, 6.76154792e-02f, 1.09685667e-01f, 1.58333018e-01f, -1.01182953e-01f, -6.91790786e-03f, 2.07811505e-01f, -4.83554276e-03f, 9.99035165e-02f, 2.60017842e-01f,
  -6.77807450e-01f, -3.54349852e-01f, 2.19644651e-01f, -2.15888068e-01f, -5.19332439e-02f, 2.98692826e-02f, -4.18712534e-02f, -1.07206553e-01f, -1.25353202e-01f, -1.42321318e-01f,
  -1.38178334e-01f, 9.23647452e-03f, -2.89969351e-02f, 2.44292840e-02f, -1.88458920e-01f, -3.10384691e-01f, -1.57022238e-01f, 5.98469004e-02f, 3.37282240e-01f, 1.84865087e-01f,
  -4.04459573e-02f, -1.46543264e-01f, -2.00198933e-01f, -1.59402058e-01f, -7.65368715e-02f, 7.75072305e-03f, -1.41661420e-01f, -1.40875414e-01f, -5.84453717e-02f, -1.78010300e-01f,
  4.88222331e-01f, 8.05367678e-02f, 4.79068048e-02f, -1.23600215e-01f, 4.42599133e-02f, -1.35732576e-01f, 3.23042437e-03f, -1.58115011e-02f, -1.20517395e-01f, -5.05511500e-02f,
  -3.03790756e-02f, -2.07824586e-03f, 2.56055221e-02f, 8.86153802e-02f, 1.53224081e-01f, 4.38866131e-02f, 1.01044007e-01f, 7.69441947e-02f, 6.36029541e-02f, 1.19702201e-02f,
  2.72609368e-02f, 5.83586544e-02f, 1.61934584e-01f, 1.35841459e-01f, 1.03935543e-02f, 2.60992609e-02f, 1.07668996e-01f, 1.33513972e-01f, 1.36488602e-01f, 1.97485462e-03f,
  -8.19367245e-02f, -1.84905171e-01f, 8.51970464e-02f, 1.11524463e-01f, 6.05077343e-03f, 9.88100097e-02f, 1.74658168e-02f, -1.74698979e-02f, -9.43265781e-02f, 5.47401747e-03f,
  2.96945646e-02f, 1.70661241e-01f, 6.40540570e-02f, -8.52946043e-02f, 1.99816078e-02f, -2.01967917e-02f, 2.64689233e-02f, -9.28634778e-03f, 1.12360835e-01f, -2.66021732e-02f,
  5.17806076e-02f, 4.20234129e-02f, 2.03913264e-02f, 1.35192171e-01f, 1.06228299e-01f, 1.51901720e-02f, 9.27244052e-02f, 1.44516081e-02f, 6.01197146e-02f, -1.78821608e-01f,
  4.20042872e-01f, 8.23915452e-02f, 6.49707913e-02f, 2.77014039e-02f, -2.23278180e-02f, -1.47843078e-01f, 4.14619409e-03f, 3.68526056e-02f, -2.09443215e-02f, 1.43680245e-01f,
  2.00923473e-01f, -6.58919588e-02f, 1.06141113e-01f, 1.02761433e-01f, 5.49785942e-02f, 1.19645990e-01f, -9.41367298e-02f, -3.88784707e-02f, 2.44679973e-02f, -3.44678611e-02f,
  -6.09979481e-02f, -1.04496680e-01f, 4.98909242e-02f, 4.71918918e-02f, 3.42085324e-02f, 2.09004059e-02f, 1.90180182e-01f, 1.51699632e-01f, 1.85002044e-01f, -5.29606305e-02f,
  -7.67240047e-01f, -9.86371562e-03f, -1.30530223e-01f, 2.30900068e-02f, -1.23013869e-01f, -2.12125659e-01f, -8.50630030e-02f, 1.18362345e-01f, 2.20304608e-01f, 1.80233613e-01f,
  -3.89228538e-02f, -1.39282703e-01f, -6.49739280e-02f, -3.51924717e-01f, -3.89455676e-01f, -1.92612872e-01f, -2.17864946e-01f, -5.89399636e-01f, -6.97080016e-01f, -3.38692188e-01f,
  -4.21563447e-01f, -5.28286755e-01f, -4.39229667e-01f, -1.84208095e-01f, 1.55179277e-01f, -1.23772882e-01f, -6.22222722e-02f, -3.02122593e-01f, -3.85814816e-01f, -1.81481540e-01f,
  2.62903929e-01f, -9.03550237e-02f, -1.06389143e-01f, -7.48232827e-02f, 4.43265662e-02f, 9.68606845e-02f, -8.28625783e-02f, 4.10993733e-02f, -2.52442155e-02f, 1.35596141e-01f,
  -1.14782685e-02f, 9.98548195e-02f, 3.42558548e-02f, 3.39871645e-02f, 4.05929238e-02f, -3.92878056e-02f, 2.11625341e-02f, -4.72218022e-02f, -5.09474911e-02f, 2.11542785e-01f,
  1.19939279e-02f, -1.81895375e-01f, -6.42320886e-02f, 1.56658202e-01f, 1.29802838e-01f, -1.61632165e-01f, 7.56309479e-02f, 7.83867463e-02f, -4.10196185e-02f, 1.98637113e-01f,
  6.52035177e-02f, 1.03408411e-01f, 2.48822453e-03f, 3.95083316e-02f, -4.29869965e-02f, -2.00740509e-02f, 2.13563796e-02f, -1.26217643e-03f, -7.24681169e-02f, 2.69948207e-02f,
  1.59134626e-01f, 9.47899669e-02f, 5.73553853e-02f, -4.68435176e-02f, 3.59823778e-02f, -7.06933215e-02f, -5.90907522e-02f, 8.66544098e-02f, -3.75896022e-02f, 7.88813904e-02f,
  3.85418795e-02f, 2.99419332e-02f, -5.75734826e-04f, -5.70750423e-03f, 4.71150428e-02f, 4.75281216e-02f, -1.92034487e-02f, 4.39377241e-02f, 2.73593571e-02f, -5.16631752e-02f,
  3.26421112e-01f, -4.43604320e-01f, 9.78645980e-02f, -8.94523114e-02f, 1.54522538e-01f, 1.62815362e-01f, -1.96786579e-02f, -6.99136555e-02f, 8.11768789e-03f, -6.30369084e-03f,
  -1.12827756e-01f, -3.02424300e-02f, -1.40742473e-02f, 1.06009558e-01f, 8.75989255e-03f, -3.98564339e-02f, 9.22397524e-02f, 2.71494426e-02f, 5.22389524e-02f, 2.59229511e-01f,
  1.45211414e-01f, 3.10186129e-02f, -5.16702123e-02f, 1.42685771e-01f, 1.09528191e-01f, -1.22156151e-01f, 4.66636308e-02f, 1.89397871e-01f, -1.04408734e-01f, 2.07752123e-01f,
  -2.16973364e-01f, -3.33907425e-01f, 7.11070895e-02f, 1.55432582e-01f, 2.83338606e-01f, 2.81004459e-01f, 3.15669209e-01f, 1.72576666e-01f, 3.12878400e-01f, 2.04736590e-01f,
  1.71998903e-01f, 2.66957521e-01f, 3.08706254e-01f, 2.11047202e-01f, 1.62004635e-01f, 3.12316060e-01f, 3.11183423e-01f, 9.18041617e-02f, 2.15949342e-01f, 2.14415759e-01f,
  2.48322517e-01f, -4.95788343e-02f, -1.21872671e-01f, -5.27886376e-02f, 4.60634492e-02f, 2.89147437e-01f, 2.43608020e-02f, -7.09915906e-02f, -4.75869775e-02f, -5.51332086e-02f,
  4.16992903e-02f, -2.27760345e-01f, 2.72001140e-02f, -8.98774341e-02f, -1.81584999e-01f, -1.34784043e-01f, -2.60131452e-02f, -1.19893298e-01f, -1.78110868e-01f, -4.62703481e-02f,
  -1.72589689e-01f, -1.64927885e-01f, -1.14193164e-01f, -6.58537298e-02f, -1.24761045e-01f, -1.64341196e-01f, -2.11209491e-01f, 3.57024483e-02f, -3.82076539e-02f, 1.87575091e-02f,
  -1.13369085e-01f, -6.33064732e-02f, 1.04257599e-01f, 2.11988255e-01f, -1.77373160e-02f, -3.42075899e-02f, 4.37108241e-02f, 2.92771729e-03f, -4.59587108e-03f, 7.29024187e-02f,
  2.49909893e-01f, 1.40081942e-01f, 8.16665739e-02f, 1.91470146e-01f, 1.65871233e-01f, 6.37971610e-02f, 3.15659940e-02f, 1.18299015e-01f, 1.74013227e-01f, 1.00431545e-02f,
  1.59180522e-01f, 1.96124837e-01f, 1.27826497e-01f, 6.63455650e-02f, 8.38582590e-02f, -3.82356346e-02f, -1.14532731e-01f, 2.44813282e-02f, -8.07604566e-02f, -1.19204611e-01f,
  -1.82018727e-02f, -1.00819983e-01f, -2.01485589e-01f, -2.22768057e-02f, 2.23443769e-02f, 2.84924582e-02f, -3.72394323e-02f, 3.59425098e-02f, -1.06674358e-01f, -3.63592133e-02f,
  3.49165499e-01f, 4.17526253e-02f, 1.21915907e-01f, -5.41037470e-02f, -1.29780903e-01f, -1.54207960e-01f, 2.82926541e-02f, -6.40280768e-02f, -2.51566738e-01f, -1.86793450e-02f,
  -9.99151990e-02f, -1.59443006e-01f, -8.81735533e-02f, 6.85154796e-02f, 4.99062091e-02f, 2.04887111e-02f, -3.76820415e-02f, 1.56828761e-01f, 1.09645844e-01f, 4.79764827e-02f,
  4.27903496e-02f, 1.15534581e-01f, 2.94543177e-01f, 2.01766625e-01f, 2.21756697e-01f, 2.49625862e-01f, 9.42365155e-02f, 9.34362188e-02f, 1.83271065e-01f, 1.75378159e-01f,
  7.87826777e-01f, 5.71110360e-02f, -5.79281390e-01f, 2.14865610e-01f, -2.67412156e-01f, -4.93260473e-01f, -6.19039655e-01f, -3.54457885e-01f, 3.39898437e-01f, -1.55790253e-02f,
  6.41513392e-02f, 5.71045101e-01f, 2.37579465e-01f, -1.63139775e-01f, -5.39608777e-01f, -6.13262594e-01f, -4.66097027e-01f, -5.29607832e-01f, -6.22110307e-01f, -5.09273887e-01f,
  -5.86362071e-02f, -9.74795893e-02f, -7.50302821e-02f, -2.16107413e-01f, -2.62508802e-02f, 1.00890309e-01f, -3.10050517e-01f, -2.06808805e-01f, -4.18361098e-01f, 5.66232018e-02f,
  -3.63324523e-01f, -9.95449051e-02f, -3.01277429e-01f, 1.14752121e-01f, -8.43975097e-02f, 1.41108513e-01f, -1.05743118e-01f, 4.82169315e-02f, 2.09960237e-01f, -2.17675447e-01f,
  -2.52257008e-02f, -9.38217267e-02f, -1.98072251e-02f, -1.40823191e-02f, -1.71970472e-01f, -8.88272151e-02f, -1.04172178e-01f, -2.22681716e-01f, -9.52777192e-02f, -2.36142293e-01f,
  9.61217210e-02f, -2.04274684e-01f, -2.15261906e-01f, -2.05669031e-01f, -3.19369286e-01f, -4.59554680e-02f, -4.58797336e-01f, -3.25748265e-01f, -4.18044478e-01f, 6.47308305e-02f,
  1.86446086e-02f, -6.03398457e-02f, -1.23107517e-02f, 3.83072942e-02f, 7.04876089e-04f, 1.27127811e-01f, 5.07059656e-02f, -4.36909916e-03f, 2.77904849e-02f, -3.34878154e-02f,
  -1.86073277e-02f, -3.02641634e-02f, 6.80742115e-02f, -8.65908116e-02f, -2.46472016e-01f, -5.64768305e-03f, 8.79440978e-02f, -1.85021058e-01f, -8.90433881e-03f, 1.19982630e-01f,
  -4.31606807e-02f, -1.20674565e-01f, 1.08963251e-01f, -1.45069314e-02f, -8.98396447e-02f, -7.77377635e-02f, -2.89682541e-02f, -3.23898084e-02f, -4.43540737e-02f, -5.60952276e-02f,
  1.70234591e-01f, -2.26396248e-01f, 1.19004488e-01f, -1.96740821e-01f, -7.38899931e-02f, 1.64012074e-01f, 1.24928460e-01f, 1.11851208e-02f, 2.01823801e-01f, -3.59709151e-02f,
  -2.51577467e-01f, -9.13261995e-02f, -3.64663848e-03f, 6.16142787e-02f, -6.16979972e-02f, 8.04941356e-02f, 7.85863772e-02f, 7.86406398e-02f, -1.17887519e-01f, 2.10527942e-01f,
  -4.99406829e-02f, -5.40852584e-02f, 3.46625626e-01f, 3.65479067e-02f, 3.02986096e-04f, 1.48994386e-01f, -1.25298664e-01f, -1.37370303e-01f, -7.76826218e-02f, 8.56417045e-02f,
  4.37306225e-01f, 2.23989949e-01f, 3.51090282e-01f, 1.16707548e-01f, -3.10090572e-01f, -1.06568530e-01f, -2.08490729e-01f, 1.61879554e-01f, 2.03119889e-01f, 8.50892067e-02f,
  2.72403890e-03f, 1.55355871e-01f, 2.07159355e-01f, 1.68082327e-01f, 6.46608993e-02f, 1.06596746e-01f, 2.04309821e-01f, 2.55735815e-01f, 9.34470147e-02f, -1.25569720e-02f,
  -4.86626476e-03f, -6.37055039e-02f, 1.77669063e-01f, 2.03629017e-01f, 1.20880760e-01f, 5.22436239e-02f, -2.14115344e-02f, -1.52249843e-01f, -5.64038679e-02f, 2.99659856e-02f,
  -2.84694098e-02f, 1.32763445e-01f, 1.36663660e-01f, 1.80383846e-01f, -1.73835212e-03f, 1.85458347e-01f, 1.03743285e-01f, 9.41379145e-02f, 8.11958984e-02f, 7.93320313e-02f,
  3.09590460e-03f, 1.30674630e-01f, 9.50180963e-02f, -3.03622731e-03f, 5.89761026e-02f, 1.24779902e-01f, 1.26558065e-01f, 5.66877797e-02f, 1.24879241e-01f, 1.48907155e-01f,
  4.68285307e-02f, -8.53876844e-02f, -7.26796985e-02f, 6.88626319e-02f, 9.68886614e-02f, 1.53623894e-02f, 2.87005939e-02f, 5.77291884e-02f, 1.14699692e-01f, 5.92143163e-02f,
  2.17438653e-01f, 1.77905187e-01f, 2.28242688e-02f, 6.01866730e-02f, -6.79433048e-02f, -7.75499418e-02f, 2.47182418e-02f, -5.19863069e-02f, -2.35336833e-02f, -1.64311063e-02f,
  -6.56007305e-02f, -7.35407099e-02f, 7.91577026e-02f, 4.85804118e-02f, 2.17922330e-01f, 1.37470379e-01f, 3.61064188e-02f, 3.06848045e-02f, 5.62074769e-04f, 4.67900708e-02f,
  -5.45086712e-02f, 4.54352461e-02f, 4.77105975e-02f, 1.20215051e-01f, 4.88234162e-02f, 1.54305562e-01f, 1.23596691e-01f, -1.60597805e-02f, 3.68184298e-02f, -3.15413773e-02f,
  -1.60224184e-01f, -6.18042387e-02f, 1.84576884e-02f, 1.23882815e-01f, 5.58834113e-02f, 1.31811991e-01f, 1.14390336e-01f, 3.90576981e-02f, -7.52183124e-02f, 1.22953273e-01f,
  3.24426107e-02f, 2.27013096e-01f, 1.07242577e-01f, 4.54414189e-02f, -5.23030013e-02f, -5.79595007e-02f, 4.64580357e-02f, -3.26008648e-02f, -2.09377967e-02f, 1.54488280e-01f,
  1.64221674e-01f, 3.39619033e-02f, 3.81408026e-03f, 6.02763556e-02f, -4.95785959e-02f, -8.74614269e-02f, -1.43813461e-01f, -2.79822829e-03f, -1.20032951e-02f, -1.07718512e-01f,
  -7.57830381e-01f, 5.49299181e-01f, 6.50653899e-01f, -5.57119071e-01f, 3.95494491e-01f, 6.04104102e-01f, 6.61789834e-01f, 2.81643480e-01f, -1.16972625e-01f, 8.43774676e-02f,
  2.85371929e-01f, -3.91618431e-01f, -1.22514337e-01f, -2.24665418e-01f, -1.11529872e-01f, 2.92511612e-01f, -1.37447184e-02f, -2.18945354e-01f, -3.37348640e-01f, -1.51190937e-01f,
  -2.29801252e-01f, -3.72568846e-01f, -6.11876249e-01f, -2.61780202e-01f, -2.37134829e-01f, -3.05163741e-01f, 1.48593992e-01f, -2.21501678e-01f, -7.22901970e-02f, -5.33025384e-01f,
  -4.91023421e-01f, 1.92244545e-01f, 2.34371498e-01f, -1.63726494e-01f, 8.58108103e-02f, -2.73868501e-01f, 1.08778654e-02f, 4.40785997e-02f, -9.97014269e-02f, 1.13502011e-01f,
  5.07149883e-02f, 4.19292599e-02f, -8.50897655e-03f, -1.75409671e-02f, -3.97332124e-02f, -3.26785706e-02f, 5.72490208e-02f, -1.31873861e-01f, -1.66675881e-01f, 8.14738497e-02f,
  -3.06129932e-01f, -2.21483245e-01f, 9.82113704e-02f, 2.47184098e-01f, 9.85178649e-02f, -3.61599892e-01f, 2.27628238e-02f, -2.71005869e-01f, -8.22962373e-02f, -6.50907934e-01f,
  -1.44351274e-01f, 4.46218699e-02f, 5.89328334e-02f, 5.51998802e-02f, -1.52371779e-01f, 1.84138329e-03f, -3.34145650e-02f, -2.04124585e-01f, 1.79004401e-03f, -1.71974212e-01f,
  9.03607830e-02f, 1.57486781e-01f, 1.15527868e-01f, 1.52387410e-01f, -1.83892339e-01f, 8.72802734e-02f, -9.85323638e-02f, -1.16216213e-01f, -1.29525317e-02f, -3.23354267e-02f,
  1.15605906e-01f, -4.73818928e-03f, 1.85079381e-01f, -1.27928585e-01f, -3.41514722e-02f, 1.08178928e-02f, -2.11082235e-01f, 3.66006196e-02f, 8.78748074e-02f, 1.84721887e-01f,
  -3.41409624e-01f, 1.62792072e-01f, -3.27766925e-01f, -1.05718777e-01f, -2.52899677e-01f, -2.74882130e-02f, -8.80317166e-02f, 6.38582259e-02f, 1.82915375e-01f, -1.45720318e-01f,
  2.86148250e-01f, 1.65897366e-02f, -7.77380029e-03f, 1.03706188e-01f, -2.28669986e-01f, 1.57531817e-02f, -2.38248646e-01f, -1.07657507e-01f, -2.77441796e-02f, -2.37070937e-02f,
  -1.19221300e-01f, -2.96925038e-01f, -5.29543936e-01f, -1.61455274e-01f, -3.70314747e-01f, -5.02091825e-01f, -4.55274850e-01f, -3.70768785e-01f, -3.98509383e-01f, -7.36214697e-01f,
  -8.06338668e-01f, 1.94089636e-01f, -6.08920395e-01f, 1.18478864e-01f, 3.69649291e-01f, -1.93490207e-01f, -2.35749215e-01f, -1.88448265e-01f, 4.21609264e-03f, -8.76745805e-02f,
  1.75164178e-01f, 3.84846739e-02f, -1.41300395e-01f, 6.24352023e-02f, -2.52162129e-01f, -1.09088860e-01f, 1.91920862e-01f, -9.24905837e-02f, -7.60532692e-02f, 2.52684355e-01f,
  5.44913888e-01f, 3.03698033e-01f, 1.02271780e-01f, 1.36203617e-01f, 3.17505181e-01f, 4.38066423e-01f, 1.27622709e-01f, 3.33905518e-01f, 2.63454497e-01f, -2.62411255e-02f,
  -4.74368870e-01f, -5.76976836e-01f, 1.91947415e-01f, 4.53800857e-01f, 1.87511727e-01f, -2.96194732e-01f, -2.75340348e-01f, -1.09336767e-02f, -1.83419794e-01f, -3.23855653e-02f,
  1.50492027e-01f, -6.34635836e-02f, 2.89065503e-02f, 3.94783467e-02f, -1.12429731e-01f, -4.32245255e-01f, 8.27496052e-02f, -3.61413419e-01f, -4.71949786e-01f, -3.30498040e-01f,
  3.58070552e-01f, 2.58215100e-01f, -5.65313995e-01f, -1.67545602e-01f, -5.72908878e-01f, 7.87637755e-02f, -1.59483120e-01f, -2.69343436e-01f, -3.61062020e-01f, -5.50347090e-01f,
  1.74150858e-02f, -6.79682046e-02f, -7.61898160e-02f, -2.22318023e-02f, 5.83141260e-02f, 4.03265692e-02f, 1.45712242e-01f, 2.12381721e-01f, -1.58765055e-02f, -1.10561587e-01f,
  -1.81878746e-01f, -8.71111155e-02f, -1.29689515e-01f, -1.29187241e-01f, 4.57875691e-02f, 1.64135352e-01f, -1.70669630e-02f, 1.59520850e-01f, 5.72030582e-02f, -1.09460510e-01f,
  5.06800041e-02f, -1.81100979e-01f, 2.61058718e-01f, -7.47321695e-02f, 1.05448849e-01f, 2.90559437e-02f, 8.62037614e-02f, 5.29513359e-02f, -1.14363454e-01f, 9.57427621e-02f,
  2.30452746e-01f, 3.31147969e-01f, -1.73348814e-01f, 4.03781757e-02f, 5.25538772e-02f, 4.51428629e-03f, 9.04320832e-03f, 1.34900063e-01f, -2.17471078e-01f, -2.06603512e-01f,
  -4.93558943e-02f, -1.04422055e-01f, 1.21170856e-01f, -6.72309995e-02f, -2.68701941e-01f, -3.21492583e-01f, 2.29258820e-01f, 7.42575675e-02f, 3.87622975e-02f, -1.37404412e-01f,
  2.03295797e-01f, 2.11255290e-02f, -2.87670612e-01f, -3.05385619e-01f, -9.58665237e-02f, 9.66736600e-02f, -1.12382337e-01f, -6.52743271e-03f, -1.17336459e-01f, -8.70371163e-02f,
  -4.57452148e-01f, -1.66494980e-01f, -7.55839348e-02f, 4.06652302e-01f, 3.53279382e-01f, 5.05758673e-02f, -2.84533529e-03f, -2.33454388e-02f, 1.40715539e-01f, 1.53611973e-01f,
  3.09473813e-01f, 3.61469865e-01f, 2.29799151e-01f, 2.02947512e-01f, -1.07727768e-02f, 1.22436978e-01f, 2.13191167e-01f, -1.17353402e-01f, -3.95798050e-02f, 9.80427265e-02f,
  2.64667153e-01f, 8.65623057e-02f, -5.49262650e-02f, 6.23983890e-02f, 3.72877032e-01f, 3.83394152e-01f, 1.94337383e-01f, 3.57076138e-01f, 2.89596915e-01f, 4.30947185e-01f,
  3.95373613e-01f, -4.36586607e-03f, 9.94372293e-02f, 2.55257692e-02f, 3.72364484e-02f, -2.28630096e-01f, 3.15351076e-02f, -8.84583145e-02f, 2.88055278e-03f, -9.01319832e-02f,
  9.53067765e-02f, 3.24929412e-03f, -1.03047467e-03f, -9.04347822e-02f, -1.59532875e-01f, -4.82008979e-02f, -1.50497749e-01f, 8.80095456e-03f, -2.70940326e-02f, 5.46235740e-02f,
  1.74686059e-01f, 1.89191565e-01f, 2.04377137e-02f, -8.77739787e-02f, -4.43455689e-02f, 1.18312657e-01f, 5.03835119e-02f, 4.70044985e-02f, -2.62730867e-02f, -1.28256083e-01f,
  1.23421848e-01f, -4.50104810e-02f, 1.11915447e-01f, 6.43342733e-02f, 5.95510267e-02f, 5.56115247e-02f, 8.69068280e-02f, 1.61432754e-02f, 9.83079970e-02f, -1.93535816e-02f,
  1.22398406e-01f, 1.14204071e-01f, -7.19746426e-02f, 4.19327430e-02f, 4.75010723e-02f, 1.81405753e-01f, 5.80123961e-02f, -4.40289406e-03f, 6.34742975e-02f, 5.56560829e-02f,
  1.86565116e-01f, -4.40072492e-02f, 6.20891824e-02f, 1.72537956e-02f, 5.32212965e-02f, -1.58067662e-02f, -3.01898289e-02f, -1.55222733e-02f, 7.33908489e-02f, 1.46023240e-02f,
  3.52909535e-01f, 1.73799515e-01f, 1.45105824e-01f, 6.08910471e-02f, 1.06833622e-01f, -7.99485818e-02f, 1.47100016e-01f, -1.84347201e-02f, 6.73026964e-02f, -1.18811615e-02f,
  -9.35270712e-02f, -1.48317754e-01f, -5.20645343e-02f, -9.54401344e-02f, -9.48946550e-02f, -2.49418318e-02f, -1.07124476e-02f, 8.12231898e-02f, 8.44539627e-02f, 4.05280888e-02f,
  -1.15405351e-01f, -1.37021631e-01f, -9.95713100e-02f, -1.16421767e-01f, 9.56501514e-02f, 9.48840678e-02f, -1.23429529e-01f, -8.64039212e-02f, -1.05782486e-01f, -1.65057227e-01f,
  -9.21215653e-01f, -1.95895374e-01f, 2.00503424e-01f, -9.20050442e-02f, 4.88314122e-01f, -1.83732212e-01f, -5.90233922e-01f, -6.86535239e-01f, -2.37615198e-01f, -9.69501138e-02f,
  2.19896123e-01f, 2.86614597e-01f, 9.81475413e-02f, 1.43811569e-01f, -3.39055985e-01f, 6.39495552e-02f, 4.15634841e-01f, 1.32159084e-01f, -8.80649760e-02f, -3.70846540e-02f,
  2.06738383e-01f, -8.05662349e-02f, -1.28468111e-01f, -8.53467509e-02f, 6.50841147e-02f, 2.57070392e-01f, 1.84618667e-01f, 9.70048606e-02f, 3.36997062e-01f, 4.63940889e-01f,
  -6.49329647e-02f, -5.05177021e-01f, 1.83864176e-01f, 2.91424155e-01f, 3.17391425e-01f, -2.69153088e-01f, -1.01557545e-01f, -2.69438773e-02f, 1.27161890e-01f, -1.71405415e-03f,
  2.95204014e-01f, -4.51561138e-02f, 3.07623386e-01f, 5.32652549e-02f, -1.06653385e-01f, -3.75090390e-01f, -1.72785297e-01f, -3.79541308e-01f, -3.25070590e-01f, -1.21120371e-01f,
  6.70668840e-01f, 4.15968746e-01f, -1.27351522e-01f, -2.85872430e-01f, -4.97618407e-01f, 4.93278690e-02f, -2.69779980e-01f, -4.67353851e-01f, -7.12103248e-01f, -6.61967337e-01f,
  -8.05456489e-02f, 1.47716761e-01f, -1.33113746e-04f, -1.65426463e-01f, 2.24977545e-03f, 8.27933550e-02f, 1.19140506e-01f, -2.92145889e-02f, 8.12166557e-02f, -1.48422539e-01f,
  3.38907875e-02f, 5.48927486e-02f, -1.29722491e-01f, -1.10888951e-01f, 1.27134293e-01f, -1.08256102e-01f, 1.41432911e-01f, -1.55180961e-01f, 2.83569954e-02f, -7.28751719e-02f,
  -6.43770536e-03f, -1.71719328e-01f, 6.38584048e-02f, -3.18068415e-01f, 6.03083260e-02f, -4.36468311e-02f, -7.82894567e-02f, -8.26737285e-02f, -1.74038216e-01f, -6.51203915e-02f,
  -2.73342520e-01f, 2.01568812e-01f, -7.49181435e-02f, -1.61848068e-02f, 7.45613649e-02f, 8.18626285e-02f, 1.08353579e-02f, -4.82096002e-02f, -1.25141651e-03f, -2.47573495e-01f,
  -1.55945078e-01f, -2.31965587e-01f, 6.82677627e-02f, -1.94691923e-02f, -1.86294760e-03f, -1.03858188e-02f, 2.62576491e-01f, -4.04995941e-02f, 8.27960894e-02f, 6.05517104e-02f,
  1.11310676e-01f, -1.80671826e-01f, -2.18453825e-01f, -2.84553915e-01f, 2.11941637e-02f, -1.97476313e-01f, -1.44427225e-01f, -3.81181985e-01f, -2.71117747e-01f, -7.14191675e-01f,
  -3.69655222e-01f, -1.73487484e-01f, -1.76841110e-01f, -2.83315897e-01f, 2.28834093e-01f, 6.07507229e-02f, -3.25499922e-01f, -3.60086828e-01f, 1.26511259e-02f, -2.04704598e-01f,
  2.17443824e-01f, 1.42763376e-01f, -3.20649803e-01f, -2.98417151e-01f, -8.15943658e-01f, -6.85256362e-01f, -5.62604845e-01f, -5.07354379e-01f, -3.02963197e-01f, 8.69181976e-02f,
  9.13642868e-02f, -2.57131070e-01f, -3.78977418e-01f, -2.13195428e-01f, 3.17522317e-01f, 7.94491097e-02f, 5.79456538e-02f, 1.03573374e-01f, 1.56944260e-01f, 7.87026510e-02f,
  2.33987849e-02f, 1.48536295e-01f, 2.93378588e-02f, -4.65220064e-02f, 2.50635087e-01f, -1.18482746e-02f, -1.25690661e-02f, 1.27534913e-02f, 8.25788230e-02f, -1.93028450e-01f,
  6.97774738e-02f, 1.17097273e-01f, 4.37312201e-02f, 6.20517172e-02f, -7.57129341e-02f, -6.99182451e-02f, -2.27514595e-01f, -2.31715575e-01f, -2.32537732e-01f, 2.21290722e-01f,
  3.05745840e-01f, 6.79942593e-02f, -2.97588170e-01f, -3.59814502e-02f, -9.41524357e-02f, -9.33595970e-02f, 2.06985012e-01f, 2.79873639e-01f, -3.17304321e-02f, -7.81670958e-02f,
  -2.88770981e-02f, -7.48118013e-03f, 1.26111194e-01f, 5.39264195e-02f, -2.09793240e-01f, 6.57721087e-02f, 5.00197709e-02f, -1.41125754e-01f, 2.39050910e-02f, 4.15296294e-03f,
  -6.72288910e-02f, 5.58768697e-02f, -5.44116385e-02f, 2.34153420e-02f, 5.09031452e-02f, -7.77940601e-02f, -7.88599029e-02f, 1.95832755e-02f, -7.54299238e-02f, 1.19140074e-01f,
  -8.01473707e-02f, -1.91592369e-02f, 6.83147013e-02f, -1.71284378e-01f, 4.67074253e-02f, -1.53728113e-01f, 1.67926446e-01f, -1.04470346e-02f, 5.82740381e-02f, 4.22216617e-02f,
  -1.53389439e-01f, -5.20906560e-02f, -4.88695987e-02f, -2.99245894e-01f, -1.16595484e-01f, 2.70006746e-01f, 8.78009126e-02f, -6.28042966e-02f, 2.41042003e-01f, -5.41124307e-02f,
  2.93444544e-02f, -8.93361047e-02f, -1.49522170e-01f, -1.78277679e-02f, -2.42303908e-01f, -8.46844539e-03f, -1.94859430e-01f, -1.87275872e-01f, -1.54762655e-01f, 2.13621661e-01f,
  -3.43396813e-01f, -4.37956542e-01f, -5.62954009e-01f, -3.66276264e-01f, 1.41373789e-02f, -2.94556141e-01f, -3.09484750e-01f, -7.86602572e-02f, -3.84482712e-01f, -6.03193521e-01f,
  9.87832725e-01f, 6.12106860e-01f, 3.89605910e-02f, 6.26232773e-02f, -1.08283363e-01f, 1.20980784e-01f, 3.34249198e-01f, 2.75987029e-01f, 1.50453448e-01f, 1.60251752e-01f,
  2.01782912e-01f, -6.19036006e-03f, 9.35498774e-02f, 9.96599868e-02f, 2.20281631e-01f, 7.18111098e-02f, 2.82757469e-02f, -7.14593306e-02f, 5.47774211e-02f, -2.84032859e-02f,
  -3.63010615e-02f, 2.81856246e-02f, 1.45463843e-03f, -2.59227697e-02f, 1.24149397e-01f, -1.36687279e-01f, 3.95038389e-02f, 7.30842501e-02f, 1.30898312e-01f, 1.44970068e-03f,
  -2.78421789e-01f, 2.33077660e-01f, -2.28584424e-01f, -8.23090002e-02f, 3.48023660e-02f, 3.19437049e-02f, 3.53564732e-02f, 3.15111428e-02f, -9.64754596e-02f, -4.33117673e-02f,
  -8.20260420e-02f, -9.99857113e-02f, -3.71370912e-02f, -1.69143975e-02f, -4.69358917e-03f, -2.51144841e-02f, 1.05176173e-01f, -1.84989441e-02f, -5.78899868e-02f, -4.33673337e-02f,
  -1.09724686e-01f, -1.37264892e-01f, -1.83124751e-01f, 1.95674896e-02f, -7.04369992e-02f, -1.66299388e-01f, 1.00331500e-01f, -8.96915048e-03f, 1.09388418e-01f, 1.33290470e-01f,
  -2.16192245e-01f, 5.37353829e-02f, -3.97348478e-02f, -8.47808048e-02f, 1.87045969e-02f, -4.73550335e-02f, -8.49584267e-02f, 1.84839871e-02f, -2.64084768e-02f, -6.90811351e-02f,
  -1.17280431e-01f, -1.27263039e-01f, -4.01330702e-02f, -1.74030110e-01f, -1.17004640e-01f, 5.55939190e-02f, 5.18284887e-02f, 2.92349625e-02f, -1.49330348e-01f, -1.68832988e-02f,
  -6.25340790e-02f, -1.38180703e-01f, -4.94097434e-02f, -3.47088650e-02f, -1.18640572e-01f, -6.41981140e-02f, -2.01409087e-01f, 3.82488817e-02f, -7.37232715e-02f, 9.07409284e-03f,
  -3.39145064e-01f, -1.46015674e-01f, 7.31973872e-02f, 1.50476679e-01f, 1.18630998e-01f, 9.06676203e-02f, 6.88211471e-02f, -4.26292196e-02f, -1.32203251e-01f, -5.59421033e-02f,
  -3.07997670e-02f, 1.15734003e-01f, -4.28635664e-02f, 3.59559655e-02f, -1.59858450e-01f, -1.06651388e-01f, 3.88096459e-02f, 1.28101513e-01f, -1.02008283e-01f, -1.24183660e-02f,
  -2.69287229e-02f, -1.00689568e-01f, -1.85835227e-01f, -1.21002801e-01f, -8.25036541e-02f, -1.26956195e-01f, -1.32574439e-01f, -3.60986078e-03f, -1.32558823e-01f, -2.52484493e-02f,
  2.20195442e-01f, 3.98901463e-01f, 3.39850664e-01f, -1.80031106e-01f, -4.87888716e-02f, -1.56966075e-01f, -3.03137481e-01f, -2.65589654e-01f, -3.23391527e-01f, -2.75517255e-02f,
  1.53564394e-01f, -1.14039503e-01f, -1.04181677e-01f, -2.12585017e-01f, -1.80454001e-01f, -2.24667042e-01f, 1.50511665e-02f, 7.19267279e-02f, 2.89479122e-02f, -4.19765562e-02f,
  -1.82430103e-01f, 4.85626385e-02f, 1.86208576e-01f, 5.37847951e-02f, 1.04144268e-01f, 2.17834096e-02f, 2.64569193e-01f, 3.01908374e-01f, 2.16189325e-01f, 2.77998120e-01f,
  3.03694010e-01f, 2.56989270e-01f, -4.01959926e-01f, -8.15083608e-02f, 2.41075367e-01f, -1.88080724e-02f, -9.35218334e-02f, 1.82357728e-01f, -6.95567131e-02f, 1.76754519e-02f,
  1.40214592e-01f, -3.70665938e-02f, 4.66858260e-02f, -1.47935107e-01f, -1.33381113e-01f, -4.54123765e-02f, 2.81615648e-02f, -2.78188754e-02f, -1.11142650e-01f, 4.98359762e-02f,
  -1.42189544e-02f, 1.61836669e-01f, 1.91129610e-01f, -6.16770871e-02f, 8.54977593e-02f, 1.04783602e-01f, 1.28791288e-01f, 1.50151432e-01f, -7.12251011e-03f, -9.72358510e-03f,
  -1.86513752e-01f, 5.25341853e-02f, 1.02291577e-01f, 3.31664234e-02f, -1.00362852e-01f, -1.83372006e-01f, 1.77558232e-02f, 3.70620266e-02f, -1.80771172e-01f, -3.59863676e-02f,
  2.72030872e-03f, 8.12292397e-02f, 4.17434014e-02f, 6.54086247e-02f, 4.53709625e-02f, 1.92592248e-01f, -4.66728173e-02f, 9.42378342e-02f, 1.56922147e-01f, 7.92843848e-02f,
  5.88724762e-02f, 7.73075148e-02f, 1.08027026e-01f, -7.27356151e-02f, -4.81168536e-04f, -2.67523602e-02f, -3.90229709e-02f, 9.58996732e-03f, 3.80684324e-02f, 2.78060101e-02f,
  -2.14142948e-01f, -1.13179281e-01f, -2.94391364e-01f, -1.46601424e-01f, 1.11908242e-02f, 1.25431523e-01f, 1.13648130e-02f, 2.89698597e-02f, 3.55523117e-02f, 9.82072726e-02f,
  8.44862610e-02f, 1.21116906e-01f, 2.23448183e-02f, -8.34776610e-02f, -1.83649004e-01f, 2.23979615e-02f, -4.31925058e-02f, -4.31776047e-03f, -1.44987792e-01f, 2.54379194e-02f,
  -4.62941341e-02f, -3.04993212e-01f, -1.60389006e-01f, -2.74992377e-01f, -7.16111157e-03f, -2.04400659e-01f, -3.21364850e-02f, -3.92727964e-02f, -1.95150018e-01f, -3.11843276e-01f,
  -4.94357608e-02f, -9.41811204e-01f, 3.96901578e-01f, -5.25961220e-01f, -2.40578681e-01f, -1.50378063e-01f, -6.51012361e-01f, -3.83097827e-01f, -1.98643580e-01f, -6.37027264e-01f,
  -2.23692074e-01f, 4.05699670e-01f, 5.20458877e-01f, 4.76664990e-01f, 4.55722421e-01f, -5.35280645e-01f, -3.33622210e-02f, 7.35967398e-01f, 8.29629242e-01f, -2.85550386e-01f,
  -5.23970962e-01f, -3.50176059e-02f, 3.60216171e-01f, 1.95733383e-01f, -8.18880320e-01f, 1.01061679e-01f, -7.28875026e-02f, -1.61633596e-01f, -2.57223010e-01f, -6.59252107e-01f,
  -2.26450339e-01f, -2.41469532e-01f, 2.67973334e-01f, 1.59977853e-01f, -8.34580734e-02f, 5.51904067e-02f, 8.72211810e-03f, 1.19866051e-01f, 1.30868226e-01f, -5.22260703e-02f,
  3.53855267e-02f, 1.11946069e-01f, 7.25145712e-02f, -3.39292288e-02f, -1.66328043e-01f, 6.07298799e-02f, 1.33302659e-01f, 2.51186311e-01f, 1.18222028e-01f, -1.88944012e-01f,
  -1.71399444e-01f, -6.07934184e-02f, 1.76629961e-01f, -2.67994329e-02f, -2.97056045e-03f, 4.24941778e-01f, -1.90456122e-01f, -1.70753494e-01f, 3.11863542e-01f, -5.94971657e-01f,
  -3.22630256e-02f, 5.19300699e-02f, -3.09459176e-02f, 3.85879874e-02f, 2.78356150e-02f, 6.64490685e-02f, 6.09499142e-02f, 3.02249491e-02f, 5.94123676e-02f, -8.55895691e-03f,
  -3.55704762e-02f, -6.11058548e-02f, -3.04264054e-02f, -3.34829255e-03f, 5.27980588e-02f, 2.39211619e-02f, -6.77073970e-02f, -7.52985105e-02f, 8.17242786e-02f, 7.37755522e-02f,
  8.80117118e-02f, 4.22578044e-02f, 5.75922336e-03f, 2.74382271e-02f, -2.01969966e-02f, 6.09001592e-02f, 9.61562255e-05f, -4.60174009e-02f, -6.56790137e-02f, 7.03765918e-03f,
  -3.34646367e-02f, 4.90955800e-01f, -3.44636381e-01f, 6.64352626e-02f, -4.95550595e-02f, 1.63097054e-01f, -4.93575446e-02f, 7.72150531e-02f, 3.40827890e-02f, -1.14595488e-01f,
  -5.96524660e-05f, -1.32013485e-01f, -1.05552711e-01f, -6.94679394e-02f, 1.42974164e-02f, 2.32916512e-02f, -5.93940094e-02f, 7.42971674e-02f, 2.32148737e-01f, -1.36718601e-01f,
  -2.95416154e-02f, 7.54915252e-02f, 3.27261873e-02f, 4.00867648e-02f, -1.51793078e-01f, 2.54526228e-01f, -2.72002034e-02f, -9.31361020e-02f, 2.23044127e-01f, -5.81973493e-01f,
  1.22339129e+00f, -5.57327211e-01f, -4.14510667e-01f, 3.24772656e-01f, -5.50011754e-01f, -3.34538311e-01f, -4.67316210e-01f, 1.26308545e-01f, 1.96349651e-01f, -3.94843370e-01f,
  -1.17800124e-01f, 4.15937006e-01f, 4.77165729e-01f, 2.39094839e-01f, 3.71195227e-01f, -4.07257885e-01f, -4.20153052e-01f, 3.50548834e-01f, 4.13152635e-01f, -9.49435905e-02f,
  -3.05662155e-01f, 2.28493795e-01f, 5.44204414e-01f, 2.19938919e-01f, -4.15028155e-01f, -1.57006122e-02f, -2.99611598e-01f, -1.80009648e-01f, -3.17176342e-01f, -4.95716214e-01f,
  -3.27795923e-01f, -1.39575467e-01f, -6.58152178e-02f, 1.86019674e-01f, -3.62245329e-02f, 2.33198196e-01f, -6.98403046e-02f, -1.36593625e-01f, 2.46569631e-04f, -1.19515896e-01f,
  -6.93641528e-02f, 9.00548026e-02f, 1.38274744e-01f, -2.90191881e-02f, -8.82327929e-02f, 4.36851047e-02f, -4.22356464e-02f, 1.96078122e-01f, 1.39152497e-01f, -2.34887656e-02f,
  -2.96261936e-01f, -2.36176208e-01f, -2.03190684e-01f, -1.73946425e-01f, 2.97097880e-02f, 1.26869142e-01f, -2.41312608e-01f, -9.77172405e-02f, -6.44786749e-03f, -2.80316502e-01f,
  -2.86197364e-02f, -7.30891004e-02f, 5.44670075e-02f, 3.03202663e-02f, 8.66263136e-02f, -1.67101230e-02f, -4.30911668e-02f, -5.57205267e-02f, -3.49143194e-03f, -6.80482537e-02f,
  -5.11293896e-02f, -4.51146364e-02f, 2.55533885e-02f, -1.11474074e-01f, 1.05420932e-01f, 4.95250002e-02f, -9.90634784e-02f, 3.57195586e-02f, -8.11725482e-03f, 8.62996206e-02f,
  1.36680827e-01f, -5.15424721e-02f, -2.07109805e-02f, 9.13209543e-02f, 1.25217959e-02f, 1.17064625e-01f, 6.18675686e-02f, 7.78607056e-02f, 6.72785714e-02f, -9.94089618e-02f,
  2.99628437e-01f, 1.12419024e-01f, -6.67720586e-02f, 1.06181346e-01f, -7.29264021e-02f, -1.44438088e-01f, -2.67165601e-01f, -1.55159766e-02f, -6.64693713e-02f, -1.04448386e-02f,
  -1.43322334e-01f, 1.02187224e-01f, -5.91812544e-02f, -1.13194674e-01f, -1.01033397e-01f, -9.61762965e-02f, -1.13402382e-01f, -6.45251796e-02f, -3.83808091e-02f, -2.41231471e-01f,
  -4.80318181e-02f, -8.21819156e-02f, 1.13752253e-01f, -1.78588375e-01f, -1.61711052e-01f, 2.74627894e-01f, -2.73075670e-01f, -2.48497248e-01f, 1.00371562e-01f, -2.07781821e-01f,
  5.71798623e-01f, 6.38399303e-01f, -3.45155329e-01f, -2.98482971e-03f, -4.16361600e-01f, -4.12651837e-01f, 2.19890505e-01f, 2.10290208e-01f, 3.80714834e-02f, 3.12680513e-01f,
  -1.35345925e-02f, -2.87586957e-01f, -5.55575192e-02f, -1.86725333e-01f, 1.03023194e-01f, 3.37615281e-01f, 1.26200289e-01f, -1.55785933e-01f, -3.56433839e-01f, -2.47353449e-01f,
  1.11127891e-01f, 3.76407325e-01f, 3.33229631e-01f, 7.76732042e-02f, -4.89527956e-02f, -2.02975661e-01f, -1.92885869e-03f, 1.08523248e-02f, -6.93888441e-02f, 1.75303832e-01f,
  -2.13104799e-01f, 5.17816506e-02f, -4.06476259e-01f, 4.89496477e-02f, -7.05880821e-02f, 3.05507839e-01f, 1.41771197e-01f, 1.01472348e-01f, 3.23288850e-02f, 1.30151510e-01f,
  -6.06855936e-02f, 8.72500390e-02f, 3.23692560e-02f, 1.32770678e-02f, 1.65856242e-01f, -1.09721437e-01f, 8.24774727e-02f, 6.57377765e-02f, 5.78908212e-02f, -1.05341353e-01f,
  3.36986892e-02f, -2.37372026e-01f, -2.29808301e-01f, -1.84560940e-01f, -1.59658775e-01f, -3.91606420e-01f, -1.12747252e-01f, -1.18225068e-01f, -1.27064884e-01f, 2.21558332e-01f,
  -1.84705630e-01f, 6.92018345e-02f, 2.11193580e-02f, 4.40601632e-02f, 1.20626584e-01f, 3.50828655e-02f, -5.23185544e-02f, 5.16548641e-02f, 6.71972856e-02f, 3.63205224e-02f,
  -7.05518574e-02f, 7.78104365e-02f, 6.77402988e-02f, 1.93413928e-01f, -8.89290217e-03f, -2.08803378e-02f, -3.18836682e-02f, 8.34898204e-02f, -6.05841018e-02f, 1.34347156e-01f,
  -1.61184996e-01f, -5.34952804e-02f, 3.38016972e-02f, 6.49014339e-02f, -3.05842888e-02f, -1.15917936e-01f, 2.96861399e-03f, 1.28988586e-02f, 3.27269994e-02f, -2.11331937e-02f,
  4.86744076e-01f, -2.23514289e-01f, 7.00010285e-02f, -7.33716041e-02f, -2.68646423e-02f, -5.38455211e-02f, -6.95815906e-02f, -2.70718392e-02f, -2.09504366e-02f, 1.12847552e-01f,
  -6.86451942e-02f, 1.01847418e-01f, 1.63497642e-01f, 1.51514575e-01f, 2.51224544e-02f, -2.57460438e-02f, 2.07268491e-01f, -1.86338410e-01f, 2.33406201e-02f, 1.49962651e-02f,
  1.03272729e-01f, -8.92893784e-03f, -3.40451598e-02f, -8.43721852e-02f, -5.08218370e-02f, -1.85402289e-01f, 1.17046004e-02f, -5.40273152e-02f, -3.40767242e-02f, 4.35661376e-01f,
  3.21005166e-01f, 8.86914209e-02f, -8.80946591e-02f, 2.97188997e-01f, -2.36835144e-02f, -1.61330357e-01f, -1.97895750e-01f, 4.69891280e-02f, 1.94608316e-01f, 2.82170415e-01f,
  1.54553488e-01f, 3.68622214e-01f, 3.47290605e-01f, 3.18222731e-01f, 1.50149584e-01f, 8.81105736e-02f, 1.77642122e-01f, 2.35145107e-01f, 8.23450089e-02f, 1.58245429e-01f,
  2.95162618e-01f, 6.54804558e-02f, 9.38928053e-02f, 1.26549125e-01f, 2.81555414e-01f, 3.41791004e-01f, 2.06604190e-02f, 4.25888523e-02f, 1.23213008e-01f, 4.39788401e-01f,
  4.39023346e-01f, -9.27953646e-02f, 4.88025434e-02f, 5.52590229e-02f, 5.79087937e-04f, -2.48837452e-02f, 3.67073119e-02f, -1.39503658e-01f, 1.05365105e-02f, -1.26503021e-01f,
  4.62820157e-02f, 2.98866108e-02f, -5.18530682e-02f, 1.21266823e-02f, -2.07950294e-01f, -1.84028178e-01f, -1.51341602e-01f, -7.75209628e-03f, -9.60127334e-04f, 3.54952253e-02f,
  1.17908269e-01f, -9.24066231e-02f, -2.56553560e-01f, -1.60048351e-01f, 4.77155438e-03f, 6.27706721e-02f, -8.82109851e-02f, -6.69345073e-03f, -1.80498853e-01f, 1.85194165e-02f,
  1.07043378e-01f, -1.45037532e-01f, -1.87413637e-02f, 1.24399245e-01f, 1.62424892e-01f, 9.34348926e-02f, 2.49217288e-03f, -8.01361166e-03f, 8.42858925e-02f, -1.48747891e-01f,
  1.17181391e-01f, 5.17769046e-02f, -1.96497869e-02f, 3.45848054e-02f, 2.27311358e-01f, -7.70861357e-02f, -8.36805478e-02f, 1.09349219e-02f, 2.50247940e-02f, -7.98806101e-02f,
  8.90830234e-02f, 1.87427979e-02f, 1.31663857e-02f, 2.41713692e-02f, 1.56755261e-02f, -3.60723771e-02f, 1.34881452e-01f, 2.72185020e-02f, 1.84487291e-02f, -7.36232847e-02f,
  -1.15000986e-01f, -3.08995515e-01f, 1.70212001e-01f, -9.45163518e-02f, -4.80313450e-02f, -4.11523879e-02f, 1.00376718e-02f, -5.06086014e-02f, -1.06224030e-01f, 1.10503547e-02f,
  -8.63649249e-02f, -2.19387021e-02f, -3.96936201e-03f, -1.59224018e-01f, -3.51796076e-02f, -7.66011029e-02f, -3.82524729e-02f, 3.03135831e-02f, -4.33199517e-02f, -1.42419294e-01f,
  -1.14240818e-01f, -1.01995088e-01f, -2.30320051e-01f, -1.72278121e-01f, 6.66235611e-02f, 7.54214451e-02f, -5.70113771e-02f, -1.23314075e-01f, -1.07721798e-01f, -2.59749383e-01f,
  4.81717065e-02f, 2.66524613e-01f, -6.75462261e-02f, 1.05778895e-01f, -3.27666546e-03f, -1.42042655e-02f, 5.49842902e-02f, 2.05843911e-01f, 2.14670330e-01f, 4.51131724e-02f,
  -7.60130072e-03f, 2.03809306e-01f, 1.89134955e-01f, 1.50045633e-01f, 2.61985540e-01f, 3.21066201e-01f, 2.21450821e-01f, 8.94061401e-02f, -1.21379927e-01f, 1.11002661e-01f,
  1.08298615e-01f, 5.50773181e-02f, -6.21777736e-02f, 1.69486597e-01f, 1.91451862e-01f, 1.91498056e-01f, 1.74976632e-01f, 1.17924921e-01f, 1.78876907e-01f, 2.32523307e-01f,
  1.73802674e-02f, -4.95460257e-02f, 1.48647754e-02f, 1.93196479e-02f, -1.04096577e-01f, 5.51662333e-02f, 9.99591872e-03f, -5.78454956e-02f, -9.99796670e-03f, -1.00651691e-02f,
  -1.05865419e-01f, -1.13717318e-01f, -4.26717028e-02f, -1.44442976e-01f, -2.04766050e-01f, -1.71906099e-01f, 3.60350474e-03f, 1.20270729e-01f, 1.18365012e-01f, 1.11861406e-02f,
  -5.12047522e-02f, -7.68481940e-02f, -1.50889575e-01f, 9.68139805e-03f, 1.09790213e-01f, -7.05457851e-03f, -1.51898965e-01f, -9.70790163e-02f, -2.54679918e-02f, -7.96472952e-02f,
  7.68432245e-02f, 9.16873813e-02f, -3.06086466e-02f, -1.31420121e-01f, -1.21417239e-01f, -9.57106054e-02f, -1.44275784e-01f, -4.77551781e-02f, 1.17508685e-02f, 4.78288950e-03f,
  -1.00169435e-01f, -6.51890561e-02f, -2.79633272e-02f, -7.56504759e-02f, 5.40449517e-03f, -3.04158181e-02f, 1.98046938e-02f, -1.30651012e-01f, -6.27323017e-02f, -2.10869275e-02f,
  -3.16318795e-02f, 7.65390927e-03f, -6.44980520e-02f, -8.68313611e-02f, -6.01195581e-02f, -5.28542101e-02f, -2.97246072e-02f, -1.05995432e-01f, 4.62057404e-02f, -1.57540466e-03f,
  1.84466630e-01f, -7.67544005e-03f, 2.46583223e-01f, 2.80175507e-01f, 9.74492580e-02f, -8.80098157e-03f, 5.64441308e-02f, 4.64455672e-02f, -1.88618954e-02f, 8.41135567e-04f,
  -9.19150934e-03f, 4.65011857e-02f, -5.70903346e-02f, 2.81534847e-02f, -2.10490331e-01f, -1.28631189e-01f, -3.95063236e-02f, 9.69240665e-02f, 5.97731061e-02f, -2.34627016e-02f,
  4.69491780e-02f, -8.07261392e-02f, -9.96254086e-02f, -9.13978294e-02f, -3.45378146e-02f, -7.37919658e-02f, -1.90568026e-02f, -7.00849220e-02f, -1.06973901e-01f, -6.43674582e-02f,
  -5.25406122e-01f, -1.65810198e-01f, 4.35355574e-01f, -5.13261020e-01f, 1.79341987e-01f, 2.68447846e-01f, 2.91392386e-01f, 3.07857748e-02f, 1.52744249e-01f, 3.41485947e-01f,
  -4.41478565e-02f, -5.50260961e-01f, -1.74711302e-01f, -3.33138764e-01f, -3.37970316e-01f, 2.50658572e-01f, 2.92313069e-01f, -9.44784135e-02f, -5.64261019e-01f, -4.95533705e-01f,
  -4.02539194e-01f, -4.82620478e-01f, -4.97015297e-01f, -2.46172801e-01f, 5.10088019e-02f, -8.36165547e-02f, 1.83988482e-01f, -1.39432237e-01f, -3.25789452e-02f, 1.42697453e-01f,
  4.29520220e-01f, -1.42067596e-01f, 5.48554696e-02f, -2.31269345e-01f, -1.02631047e-01f, -6.07547946e-02f, -2.56238487e-02f, -4.34416486e-03f, -1.37348548e-01f, 1.72995150e-01f,
  -3.89207393e-01f, -2.19029173e-01f, -2.98644274e-01f, -2.51760542e-01f, -2.48802260e-01f, 9.97390784e-03f, -2.19236240e-01f, -1.75682142e-01f, 1.11925922e-01f, -4.58992273e-03f,
  -1.65440425e-01f, -1.60516307e-01f, 5.94263785e-02f, 2.66359657e-01f, 1.16405204e-01f, -1.97124198e-01f, 1.77199654e-02f, 6.79810196e-02f, 2.05426276e-01f, 2.98209786e-01f,
  -1.65084321e-02f, 4.41758670e-02f, 1.80009604e-02f, 3.50720845e-02f, -7.76886269e-02f, 1.12774119e-01f, -1.08073710e-03f, -2.17365995e-02f, -1.19586602e-01f, -1.78683862e-01f,
  -5.69489636e-02f, 1.14891410e-01f, -5.35466447e-02f, -8.36908072e-02f, -3.66140306e-02f, -8.18364844e-02f, -1.69726312e-02f, -2.74131224e-02f, 8.50902423e-02f, -1.09359492e-02f,
  -2.68675517e-02f, 6.14344254e-02f, -2.89437603e-02f, -1.62940882e-02f, 1.41676009e-01f, -1.40363453e-02f, -1.23953680e-03f, -1.99515726e-02f, -1.89623699e-01f, -1.38098029e-02f,
  -2.06737280e-01f, 7.71836424e-03f, -4.67376783e-02f, -5.06803356e-02f, 4.38016169e-02f, 6.19952753e-02f, -1.47496685e-02f, 5.28296307e-02f, 6.20425120e-03f, -1.54942468e-01f,
  -3.25702459e-01f, -2.47367918e-01f, -1.01953760e-01f, 5.98145127e-02f, -6.04478568e-02f, -1.86317097e-02f, -1.12740666e-01f, -3.93187776e-02f, 9.94349867e-02f, -9.42797458e-04f,
  3.16884741e-02f, 2.06280962e-01f, 1.13426253e-01f, 2.39785925e-01f, 8.53451341e-02f, 1.81729291e-02f, 1.22039527e-01f, -2.15678290e-02f, 1.43612489e-01f, 3.36762935e-01f,
  -5.69524229e-01f, -5.66707969e-01f, 1.35099944e-02f, -4.30873126e-01f, -2.69016325e-01f, -1.03306442e-01f, -6.21834338e-01f, -2.42573127e-01f, -1.27563342e-01f, -7.32313693e-01f,
  -3.96214575e-01f, 2.76442379e-01f, -6.16568662e-02f, 1.23089679e-01f, -1.23354331e-01f, -8.19214582e-01f, -3.64659458e-01f, 1.03182189e-01f, 3.80084336e-01f, -1.53241202e-01f,
  -2.64799833e-01f, -2.06430808e-01f, 1.03912190e-01f, 3.10907289e-02f, -3.66405696e-01f, -1.66472849e-02f, -7.35679716e-02f, -2.33722702e-01f, -2.69993722e-01f, -3.91203910e-01f,
  -3.25732112e-01f, 5.55935549e-03f, 4.21211004e-01f, 2.32069924e-01f, -1.44635439e-01f, 3.95912975e-02f, -1.24875493e-01f, 3.54126692e-01f, 8.38200450e-02f, -1.17289893e-01f,
  -5.26219420e-02f, -6.15299307e-02f, 1.69672430e-01f, 3.56226005e-02f, -1.47203118e-01f, -5.45800738e-02f, 5.34552671e-02f, 4.23199423e-02f, 1.01516187e-01f, -1.55978948e-01f,
  -3.69873732e-01f, -1.10354595e-01f, 1.67723879e-01f, 1.51810810e-01f, 1.62421346e-01f, 1.86057493e-01f, 9.94851515e-02f, 3.23953062e-01f, 2.65512854e-01f, -3.30586880e-01f,
  -1.31917849e-01f, 1.13576174e-01f, 4.48170193e-02f, 9.26834047e-02f, 3.93207595e-02f, 9.07635912e-02f, -8.15176368e-02f, -7.18306005e-02f, 1.85897797e-01f, -8.31079036e-02f,
  -3.16233933e-02f, -1.12732850e-01f, -6.39465749e-02f, -7.99588114e-02f, 8.36682599e-03f, -2.75291316e-02f, -1.07077159e-01f, -6.91895932e-02f, 7.82908052e-02f, -4.12111804e-02f,
  9.72503275e-02f, 5.77580137e-03f, 1.06416866e-01f, 6.88225105e-02f, -8.05188492e-02f, 1.17150940e-01f, 3.29061374e-02f, 4.75443602e-02f, 2.35457812e-02f, 1.47222737e-02f,
  -9.94645506e-02f, 2.47641847e-01f, -3.65053862e-01f, 1.07776865e-01f, -1.23816669e-01f, 1.36828214e-01f, 8.45565498e-02f, 2.83422507e-02f, 6.33723438e-02f, -2.13372007e-01f,
  2.18329635e-02f, -2.60777354e-01f, -1.41346352e-02f, 1.62450120e-01f, -5.33235595e-02f, 7.63778985e-02f, -2.95711935e-01f, -1.08360879e-01f, 2.52846003e-01f, -9.95422900e-02f,
  -8.64370838e-02f, -2.38392889e-01f, -1.82276681e-01f, -4.11000773e-02f, 1.46972239e-01f, 1.19370304e-01f, -6.88791648e-02f, 2.17871424e-02f, 9.53522511e-03f, -6.25781476e-01f,
  -2.58319099e-02f, 2.86796987e-01f, 7.01048315e-01f, -3.96304309e-01f, -1.83817297e-01f, -2.83225536e-01f, -4.33272183e-01f, -2.93004900e-01f, -1.83719158e-01f, 1.24110132e-01f,
  1.45353585e-01f, -2.19572753e-01f, -2.49324869e-02f, 5.86041249e-03f, -7.90299997e-02f, 1.18739419e-01f, 1.96772605e-01f, 2.30333954e-01f, -1.63998678e-01f, -4.90602136e-01f,
  -3.16532105e-01f, -1.63142249e-01f, 6.32603988e-02f, -4.47142869e-02f, 1.89277902e-01f, -2.24274307e-01f, 4.64077115e-01f, 2.69354522e-01f, 1.19132295e-01f, 3.96223783e-01f,
  4.80895787e-01f, 4.39573348e-01f, -1.57547504e-01f, 1.65083379e-01f, 3.52931857e-01f, -4.09105644e-02f, -3.14551443e-02f, 3.66130412e-01f, 6.22267537e-02f, 2.74933398e-01f,
  1.50889575e-01f, 1.30968243e-01f, -1.40410826e-01f, 1.05056334e-02f, 2.33315211e-02f, -1.33336738e-01f, 2.81666815e-01f, 1.71433300e-01f, 7.26412535e-02f, 2.90698797e-01f,
  -3.59970570e-01f, -7.29197357e-03f, 7.49539658e-02f, -2.12847888e-01f, -4.01800051e-02f, -2.59032011e-01f, -2.34979019e-02f, -1.32833853e-01f, -4.80582453e-02f, 1.08677842e-01f,
  -2.19615161e-01f, 2.25431055e-01f, 2.54082173e-01f, 2.16885358e-01f, -1.63247183e-01f, 1.60939530e-01f, 7.51982927e-02f, -5.75722195e-02f, 5.63856512e-02f, 6.73242286e-02f,
  -1.02596283e-01f, -5.76582551e-02f, 1.97858974e-01f, 7.74883926e-02f, -1.88334897e-01f, -3.77025106e-03f, -1.29361684e-02f, -5.51672094e-02f, 2.18236260e-02f, -8.66822749e-02f,
  -9.40358192e-02f, -4.56814729e-02f, -6.65637851e-02f, -1.22898661e-01f, 8.03142413e-02f, 1.46073371e-01f, 6.09227940e-02f, -1.30995400e-02f, 1.08847674e-02f, 1.54241532e-01f,
  -2.10568070e-01f, 1.74468622e-01f, 1.41383022e-01f, -3.68408896e-02f, 1.38233677e-01f, 1.45039499e-01f, 8.87418166e-03f, -9.09682661e-02f, -2.88944542e-02f, -4.93095629e-02f,
  -4.31106053e-02f, -1.30038604e-01f, -2.98674218e-02f, -1.96422711e-02f, -1.82463020e-01f, -4.71059829e-02f, -1.12188570e-01f, -1.24936759e-01f, -1.04913667e-01f, 4.84082922e-02f,
  -2.98508406e-01f, -4.66368735e-01f, -5.11089563e-01f, -5.26784539e-01f, -3.16037446e-01f, -6.41753495e-01f, -2.45882303e-01f, -2.89978564e-01f, -4.65869039e-01f, -4.55800116e-01f,
  -5.63459694e-01f, -4.47591215e-01f, -3.37634474e-01f, -5.66900611e-01f, 1.30181313e-01f, 4.71108407e-01f, 3.93649101e-01f, 5.04439026e-02f, -2.03057557e-01f, -2.14341760e-01f,
  1.85353346e-02f, 7.72768334e-02f, -2.06163805e-02f, 2.51891822e-01f, 4.65090066e-01f, 1.17090479e-01f, 1.17600851e-01f, 2.22131848e-01f, 3.46923620e-01f, 5.02089202e-01f,
  1.33740529e-01f, -1.93991289e-01f, -2.59357274e-01f, -9.12794843e-02f, -3.09094042e-01f, -5.04999198e-02f, -4.66701299e-01f, -2.42650881e-01f, 1.51223481e-01f, -1.89079959e-02f,
  -4.26258951e-01f, -4.32495832e-01f, 4.01845515e-01f, 1.43418491e-01f, -9.08653736e-02f, -3.35095897e-02f, -1.22997470e-01f, -1.29075795e-01f, 1.01469502e-01f, -6.55102208e-02f,
  -1.52685255e-01f, 9.45548117e-02f, -2.28866398e-01f, 7.45656714e-03f, -5.58770262e-02f, 3.39863300e-02f, -1.37825608e-01f, 1.13766538e-02f, -1.39040381e-01f, -1.34474874e-01f,
  3.22867274e-01f, -1.14950404e-01f, -4.28172916e-01f, -1.57728102e-02f, -2.81307638e-01f, -1.10697776e-01f, -3.45743746e-01f, -1.40789330e-01f, -1.52892187e-01f, -3.14730644e-01f,
  1.78566370e-02f, -4.35075955e-03f, -3.12580951e-02f, -1.11174554e-01f, 6.36028200e-02f, 1.18517868e-01f, -7.09604770e-02f, 1.66452989e-01f, 1.84597343e-01f, -2.74973102e-02f,
  2.78738532e-02f, 1.38199821e-01f, 6.99185356e-02f, -5.60361966e-02f, 5.59218600e-03f, -2.01350048e-01f, 7.03028450e-03f, 3.64270322e-02f, -9.54856798e-02f, -4.67330739e-02f,
  1.34827690e-02f, -1.05239011e-01f, -3.08598191e-01f, 1.96820959e-01f, 1.42578095e-01f, -4.33921218e-02f, -8.87177065e-02f, 1.94499746e-01f, -3.33383411e-01f, -8.57388228e-02f,
  -5.62989652e-01f, 4.24432099e-01f, -1.73400983e-01f, -4.82137278e-02f, -5.05750254e-02f, 3.61940986e-03f, -8.60992223e-02f, 1.34176817e-02f, -1.78119525e-01f, 1.52140468e-01f,
  1.18162103e-01f, -9.22717378e-02f, -3.72059226e-01f, 1.13907747e-01f, 1.90530971e-01f, 1.67168360e-02f, 5.73867373e-02f, 1.53377935e-01f, 1.60690814e-01f, -1.83360577e-01f,
  -1.27418861e-01f, 1.53972045e-01f, -1.24853127e-01f, 1.02727652e-01f, -1.73547909e-01f, -9.92648378e-02f, -2.65266389e-01f, 3.35369371e-02f, -6.93551227e-02f, -2.40367040e-01f,
  -8.46635252e-02f, 6.02019727e-02f, 2.71138370e-01f, 4.47587609e-01f, 5.64930364e-02f, -1.76518917e-01f, -1.03129856e-01f, 6.80551976e-02f, -1.39103672e-02f, -4.88618240e-02f,
  -2.77052879e-01f, -1.69205487e-01f, 6.88197464e-02f, 1.79771513e-01f, 7.74716958e-02f, 1.90755233e-01f, 4.00539696e-01f, 3.67450595e-01f, 1.61440372e-01f, -5.76855689e-02f,
  2.04360723e-01f, 1.40871555e-01f, 3.62393446e-02f, 3.10373813e-01f, 3.60819310e-01f, 2.71158665e-01f, 1.32274210e-01f, 1.76833585e-01f, 7.75271207e-02f, 5.45554996e-01f,
  -1.93068102e-01f, -2.94149220e-01f, -3.09048966e-02f, -1.66664615e-01f, -1.10677473e-01f, 5.90922795e-02f, -2.12391769e-03f, 3.56563218e-02f, -4.19685012e-03f, -6.89644599e-03f,
  -5.62531427e-02f, -1.77754596e-01f, 4.70193550e-02f, 7.59733766e-02f, -1.36093691e-01f, -1.73767254e-01f, 6.28928691e-02f, 6.56373352e-02f, 3.14277597e-02f, -7.53861144e-02f,
  1.22820459e-01f, -2.62487859e-01f, -2.20226526e-01f, -2.86301710e-02f, -1.17340228e-02f, 3.42438482e-02f, -1.51571289e-01f, -1.04906216e-01f, -3.18236828e-01f, -6.96225911e-02f,
  -1.90202296e-01f, -7.58117735e-02f, -2.89157834e-02f, 8.43299255e-02f, 1.00355782e-01f, -8.02958831e-02f, 5.61935380e-02f, 5.95289953e-02f, 6.28605336e-02f, -6.60901666e-02f,
  4.19274438e-03f, -1.67778190e-02f, 1.12854213e-01f, -1.00408174e-01f, -1.20223321e-01f, -9.14193690e-02f, 9.45758149e-02f, -1.26647741e-01f, -9.63996947e-02f, -2.08405614e-01f,
  -1.46321684e-01f, 2.22685605e-01f, -4.87185968e-03f, 2.20887810e-01f, -8.47644508e-02f, 9.92850140e-02f, -4.25962918e-02f, -1.85273781e-01f, -8.04449692e-02f, -1.23815335e-01f,
  -3.99722219e-01f, -4.70422029e-01f, 5.56386448e-02f, -5.35632968e-02f, -1.50472850e-01f, -2.09578782e-01f, -9.84619558e-03f, -2.24529564e-01f, -1.53170060e-02f, 4.45486531e-02f,
  -1.50244474e-01f, -3.06616630e-02f, -1.02222143e-02f, 3.49505842e-02f, 7.60662705e-02f, -2.69468486e-01f, 1.61458217e-02f, 1.67078182e-01f, -6.66531026e-02f, 8.19902588e-03f,
  1.37544453e-01f, -5.34927621e-02f, -1.79865628e-01f, 2.91499551e-02f, -1.35881573e-01f, -2.76536733e-01f, -1.68053001e-01f, -1.63185298e-01f, -3.73339921e-01f, -2.19026461e-01f,
  1.27722006e-02f, 1.23858705e-01f, -7.07323030e-02f, -2.35619694e-01f, -3.60589564e-01f, -2.87658721e-01f, 1.21018313e-01f, -2.34674543e-01f, -2.75966763e-01f, 1.96583167e-01f,
  -1.03109330e-02f, -1.87604830e-01f, 8.60699937e-02f, -1.08203307e-01f, 2.46353410e-02f, 5.09898543e-01f, 2.67204583e-01f, -4.45547327e-02f, -5.27880967e-01f, -6.07205689e-01f,
  -1.77624777e-01f, -2.48614803e-01f, -3.85767668e-01f, -2.86008388e-01f, -6.78307861e-02f, -8.12333226e-02f, 8.55168477e-02f, -1.74720094e-01f, -1.60588264e-01f, 8.67897868e-02f,
  3.65350425e-01f, -4.45073068e-01f, -8.77506100e-03f, -1.23163752e-01f, -7.87625685e-02f, 5.07166535e-02f, 2.36176774e-02f, -5.71532957e-02f, 5.34152277e-02f, 1.19129149e-02f,
  -1.16815746e-01f, -1.13049604e-01f, -1.70598924e-01f, 5.89744784e-02f, -1.23941951e-01f, -9.96903926e-02f, -2.42673866e-02f, -2.09108189e-01f, -5.15624732e-02f, -3.93559225e-03f,
  -2.66080517e-02f, -1.37529179e-01f, 5.56474086e-03f, -1.08150356e-01f, -2.82517284e-01f, -5.74698895e-02f, -1.79488525e-01f, -2.15996489e-01f, -3.09566885e-01f, 1.54828608e-01f,
  1.67118594e-01f, 1.57160297e-01f, 8.01431835e-02f, -2.68710482e-05f, 1.32984877e-01f, 2.22228736e-01f, -1.02515807e-02f, -2.24300493e-02f, -6.04764745e-02f, -5.27077075e-03f,
  5.53482361e-02f, 2.18010154e-02f, 1.65141840e-02f, 2.49210835e-01f, -3.37648131e-02f, -1.63880631e-01f, 8.21341798e-02f, 1.78734571e-01f, 8.74493197e-02f, 3.58300772e-03f,
  -1.02941869e-02f, 1.78740814e-03f, 4.73648869e-02f, 6.65923655e-02f, 5.48203029e-02f, 5.59856407e-02f, 7.86533952e-02f, 4.16531153e-02f, -7.52774328e-02f, 4.62014154e-02f,
  2.91605592e-01f, -5.02305850e-02f, 2.92330176e-01f, -1.19442910e-01f, 3.40179377e-03f, -9.44313109e-02f, -1.02427127e-02f, 3.66961733e-02f, 6.48885891e-02f, -5.27402833e-02f,
  -1.10921681e-01f, 8.30126852e-02f, 6.35159984e-02f, 3.91528606e-02f, -4.39981334e-02f, 3.04158852e-02f, 1.93684548e-01f, 1.54328868e-01f, -7.61288330e-02f, 1.05215244e-01f,
  2.08081469e-01f, 1.69535369e-01f, 3.66592735e-01f, 2.84368962e-01f, -1.07197143e-01f, 8.99054259e-02f, 1.44443557e-01f, 1.23328008e-01f, 1.50014281e-01f, 5.57733536e-01f,
  4.19006526e-01f, -1.60642982e-01f, 3.26515377e-01f, 9.18811411e-02f, -2.55260229e-01f, -3.09331685e-01f, -6.85890198e-01f, -3.21865022e-01f, -1.37489572e-01f, -1.47601381e-01f,
  -2.39280406e-02f, 5.85995555e-01f, 8.65177035e-01f, 4.09920782e-01f, 2.17001796e-01f, -1.76912338e-01f, -1.22592695e-01f, 1.47664815e-01f, -5.71040660e-02f, -6.36238277e-01f,
  -5.55414796e-01f, -3.04203182e-01f, -1.43034086e-01f, 6.36095973e-03f, -1.68976739e-01f, 7.10143289e-03f, 2.25846574e-01f, -5.17293513e-02f, -1.70997813e-01f, -8.85321051e-02f,
  4.54409808e-01f, -1.26813790e-02f, 6.03584312e-02f, -4.23873551e-02f, -1.29990503e-01f, 1.24703079e-01f, -6.37533003e-03f, -1.37773246e-01f, -1.64020923e-03f, 2.13985424e-02f,
  2.53339056e-02f, -7.86573812e-02f, -7.07659358e-03f, -1.19990446e-01f, -2.35280588e-01f, -2.44454637e-01f, -3.01249474e-01f, -2.78584063e-01f, -1.79531779e-02f, -1.22508124e-01f,
  -3.83500874e-01f, -2.75917530e-01f, 3.20460171e-01f, -4.33702320e-02f, 1.29089523e-02f, 2.56503224e-01f, -3.75153944e-02f, -1.86946660e-01f, 2.51749139e-02f, -2.98890293e-01f,
  -1.85307354e-01f, 5.49832918e-02f, -7.95967877e-02f, -1.09001175e-01f, -1.15003206e-01f, -2.02707853e-02f, 8.31445754e-02f, 2.88457572e-02f, 4.38908897e-02f, -1.30939381e-02f,
  1.46794906e-02f, 7.53065720e-02f, -7.50445500e-02f, -1.14057111e-04f, 7.78247491e-02f, -5.05892560e-02f, 2.00678091e-02f, -4.99407686e-02f, 2.30968744e-02f, -1.00695170e-01f,
  9.32176877e-03f, -5.39061613e-03f, 1.16967380e-01f, -9.20730606e-02f, -1.06028512e-01f, 2.00542491e-02f, 1.59690920e-02f, -2.86100507e-02f, -1.76753837e-03f, -2.73695558e-01f,
  5.19501746e-01f, 3.92991722e-01f, 3.68633777e-01f, -5.29808588e-02f, -1.68152288e-01f, -1.47198439e-01f, -9.36730206e-02f, -1.88150883e-01f, 1.55452490e-01f, 5.99052496e-02f,
  -1.29732817e-01f, 7.50336647e-02f, 8.95242766e-02f, -1.93793595e-01f, -2.09480077e-01f, -2.05091342e-01f, -1.62533805e-01f, 3.67869660e-02f, -1.66370988e-01f, -2.56042749e-01f,
  -1.53196439e-01f, -2.32486606e-01f, 2.89497256e-01f, 3.57164264e-01f, -1.49529457e-01f, 3.63593996e-01f, 1.93132952e-01f, -3.42539176e-02f, 3.48833472e-01f, -1.00982167e-01f,
  2.38725111e-01f, -1.59338504e-01f, -4.28041905e-01f, 5.94315166e-03f, -2.65248209e-01f, -4.11913484e-01f, -4.78454858e-01f, -4.20477509e-01f, 6.74556494e-02f, -3.42740536e-01f,
  -2.05307286e-02f, 1.05606019e-01f, -1.62367970e-01f, -3.41219157e-01f, -4.24668223e-01f, -6.20623350e-01f, -5.38542747e-01f, -4.53147948e-01f, -4.61327434e-01f, -2.37154797e-01f,
  -2.26683989e-01f, -3.50335449e-01f, -3.11338574e-01f, -1.48008719e-01f, -5.33719398e-02f, -6.06375635e-02f, -2.04309121e-01f, -2.44822934e-01f, -3.28813374e-01f, -1.02634482e-01f,
  -3.26466054e-01f, 1.87528253e-01f, -5.00008725e-02f, 9.32641774e-02f, 5.16938884e-03f, 1.24340281e-01f, -5.09873666e-02f, 2.50930227e-02f, 2.03446716e-01f, -3.17187943e-02f,
  1.53763458e-01f, 1.63400441e-01f, 2.28125732e-02f, 7.68685043e-02f, -8.53773728e-02f, -7.82674085e-03f, -1.58990800e-01f, -6.15806766e-02f, -1.37099072e-01f, 1.17867485e-01f,
  8.25244188e-02f, 7.31461868e-02f, -1.86945707e-01f, 1.27398479e-03f, 3.29810474e-03f, 6.11245595e-02f, -1.34953439e-01f, 8.81594792e-02f, -7.37713501e-02f, 2.41851993e-03f,
  -1.12593137e-01f, 1.05437264e-02f, -9.64068174e-02f, -9.83636733e-03f, -7.21425470e-03f, 9.84610803e-03f, -3.87296937e-02f, -3.76407728e-02f, 4.71099243e-02f, -7.98097178e-02f,
  -7.99441263e-02f, 4.78884391e-02f, 1.06159210e-01f, -1.49456233e-01f, -1.74608693e-01f, -4.49113324e-02f, -1.67936504e-01f, -1.02615781e-01f, -8.28346834e-02f, -3.63137275e-02f,
  8.26486852e-03f, 2.71297898e-03f, -3.10582910e-02f, -5.61783426e-02f, -8.56371596e-03f, -1.30614787e-01f, -3.02344766e-02f, -1.95203573e-02f, -6.22399151e-02f, 2.08100863e-02f,
  -1.66600868e-01f, -7.12167025e-02f, 3.52123589e-03f, 1.94599088e-02f, 5.10945655e-02f, -3.38771124e-03f, 1.30794615e-01f, 2.78113075e-02f, 8.57015029e-02f, -7.36641288e-02f,
  -5.41297533e-02f, -4.17569559e-03f, -2.07240149e-01f, -3.80678661e-02f, -2.37894114e-02f, -2.24105809e-02f, 4.05936502e-02f, -1.16623722e-01f, 2.65462026e-02f, 1.20992146e-01f,
  2.83011841e-03f, -1.38980404e-01f, -1.44250944e-01f, -1.02398939e-01f, -4.78691086e-02f, -6.06943034e-02f, -1.59820497e-01f, -1.10291891e-01f, -2.20259562e-01f, -3.15516204e-01f,
  7.61782765e-01f, -1.91019878e-01f, -1.72485977e-01f, 2.93802708e-01f, 1.20525263e-01f, 4.32686061e-02f, -5.08172102e-02f, 9.17576328e-02f, 2.06648305e-01f, 1.33246496e-01f,
  -1.68095469e-01f, -1.22268483e-01f, 5.03119491e-02f, -3.09922006e-02f, -6.79118037e-02f, 3.13526653e-02f, 1.08735301e-01f, 1.15347058e-01f, 1.90874189e-02f, 1.54603634e-03f,
  7.12378696e-02f, 1.21973448e-01f, 1.17456250e-01f, -2.79775821e-02f, -1.13365725e-01f, 2.45161913e-02f, -2.55641732e-02f, -1.87207833e-01f, -2.97927916e-01f, -2.77030230e-01f,
  -3.34777951e-01f, -3.11096549e-01f, -1.97271444e-02f, -8.11486766e-02f, -1.55219868e-01f, 7.46033341e-02f, 1.43608917e-02f, 1.23278983e-02f, 3.35321133e-03f, 1.42635286e-01f,
  -9.00810435e-02f, 2.53238417e-02f, -2.19206400e-02f, -1.10173292e-01f, 8.22623298e-02f, -1.29648289e-02f, -1.51313305e-01f, -7.98752531e-02f, -1.01170465e-01f, -1.56017408e-01f,
  -1.64051712e-01f, -1.05638474e-01f, -1.68351129e-01f, 3.30749489e-02f, -1.28925338e-01f, -7.46697858e-02f, -1.75709039e-01f, -1.13804832e-01f, -4.04846593e-04f, 5.99895529e-02f,
  -7.48360902e-03f, -1.13359138e-01f, -1.39324352e-01f, -1.78421915e-01f, -2.38802824e-02f, 1.40255298e-02f, 1.03509739e-01f, -5.23239598e-02f, -1.00974485e-01f, -5.01837209e-02f,
  -3.22503746e-02f, -1.08318791e-01f, -5.29919975e-02f, 4.30731289e-02f, -5.86975105e-02f, -1.54664546e-01f, -1.02695357e-02f, -1.50101230e-01f, -9.37645361e-02f, -3.20972092e-02f,
  -1.03043944e-01f, 2.83648707e-02f, -1.02328897e-01f, -1.80888548e-01f, -2.12349460e-01f, -3.34822014e-02f, -4.59882133e-02f, -1.12984404e-01f, 1.21782087e-01f, 9.52436998e-02f,
  -2.88819633e-02f, -2.59945840e-01f, 1.79081261e-01f, -1.15434349e-01f, -8.78508464e-02f, -8.43133330e-02f, -1.42347038e-01f, -7.02571124e-02f, 8.68261978e-02f, -1.96061675e-02f,
  3.65394354e-02f, 1.32558970e-02f, -6.23520873e-02f, -4.00296636e-02f, 2.94309646e-01f, 1.61228776e-01f, -8.41216967e-02f, -6.46703467e-02f, 5.47203841e-03f, -1.43660530e-01f,
  1.46581624e-02f, 1.87828511e-01f, 1.83696195e-01f, 1.79236576e-01f, 6.25223741e-02f, 2.00656027e-01f, 5.63953891e-02f, 1.31897464e-01f, 1.97914287e-01f, 4.68144953e-01f,
  6.06931567e-01f, -4.44153994e-01f, -1.48590893e-01f, 2.18745708e-01f, -1.53159620e-02f, 1.48683831e-01f, -7.38834441e-02f, 1.32638052e-01f, 1.92583025e-01f, -5.32404035e-02f,
  -4.50855903e-02f, 1.35587186e-01f, 2.37790029e-02f, 2.39126757e-02f, 5.02170138e-02f, -5.16910711e-03f, -5.49521483e-02f, 7.83228129e-02f, 1.46684811e-01f, 1.03010759e-01f,
  -6.71021864e-02f, 2.39146245e-03f, 6.47513866e-02f, -1.09488413e-01f, -1.95743620e-01f, -1.20814890e-01f, -1.00572087e-01f, -2.20355287e-01f, -3.27480465e-01f, -2.83862114e-01f,
  -4.96852219e-01f, -2.13669753e-03f, 8.17075893e-02f, -1.29518053e-02f, -7.58532807e-02f, 6.95899501e-02f, 1.02415428e-01f, 4.84760590e-02f, 4.69844788e-03f, 5.70220426e-02f,
  5.88318100e-03f, -1.22288577e-01f, -7.58427307e-02f, -6.28123283e-02f, -5.03811650e-02f, -4.70760986e-02f, -7.34127080e-03f, -6.36360124e-02f, -3.79236266e-02f, -1.56250298e-01f,
  -4.23233286e-02f, 3.09765134e-02f, 2.60592513e-02f, 1.38605207e-01f, 1.25799805e-01f, -2.85416506e-02f, 3.43149751e-02f, 5.23113497e-02f, 2.59232074e-02f, 1.10994801e-01f,
  6.38958961e-02f, -1.45407766e-02f, 2.69517477e-04f, 7.54728839e-02f, 2.16332704e-01f, 1.60616502e-01f, 5.68915084e-02f, 5.65963686e-02f, 2.11958081e-01f, 3.10507976e-02f,
  -3.59651595e-02f, 5.59360422e-02f, 3.94033343e-02f, 3.96189503e-02f, -5.13498262e-02f, -2.05584645e-01f, -4.85064201e-02f, -1.31392300e-01f, -6.58873096e-02f, -1.16506457e-01f,
  2.14465857e-02f, -4.88733537e-02f, -1.10532843e-01f, -1.74853936e-01f, -1.30834714e-01f, -4.24791016e-02f, -8.87719244e-02f, 5.74657973e-03f, 2.71375086e-02f, 5.46440519e-02f,
  -3.37940782e-01f, 1.73685074e-01f, 1.73040181e-01f, -1.17594540e-01f, -1.49141895e-02f, -1.02177672e-01f, -5.95654473e-02f, -6.11611120e-02f, -2.09626153e-01f, -4.84534912e-02f,
  -9.62918624e-02f, 4.39943001e-02f, -8.16736668e-02f, 1.15086712e-01f, 2.40600944e-01f, 8.03445727e-02f, 1.76437330e-02f, 1.34047233e-02f, -1.65351436e-01f, -6.34918287e-02f,
  -1.21013224e-01f, 5.95399700e-02f, 8.70135054e-02f, 1.55086562e-01f, 2.15542674e-01f, 1.44837826e-01f, 9.50855687e-02f, -3.80463228e-02f, 1.30871639e-01f, 3.01585317e-01f,
  9.91061449e-01f, -1.22072205e-01f, -9.52442050e-01f, 4.75025237e-01f, -3.98798406e-01f, -6.30053699e-01f, -7.87697375e-01f, -8.91332924e-02f, 4.88635093e-01f, -1.46400288e-01f,
  -2.31518775e-01f, 4.11994010e-01f, 2.25657776e-01f, -1.52140319e-01f, -2.91384339e-01f, -6.60297275e-01f, -5.83637536e-01f, -4.78679389e-01f, -4.28499520e-01f, -3.16251814e-01f,
  1.77291818e-02f, 1.54583827e-01f, 1.65295020e-01f, -2.22292375e-02f, -4.00840677e-02f, -5.79960309e-02f, -5.05101204e-01f, -1.70121178e-01f, -4.96410638e-01f, -4.14969265e-01f,
  -5.71053863e-01f, -1.23679847e-01f, -3.35165918e-01f, 2.88865298e-01f, -8.31773654e-02f, 1.15114935e-01f, -1.52563825e-01f, -2.34436914e-02f, 1.12190910e-01f, 1.20596634e-02f,
  -2.03078110e-02f, -8.60304236e-02f, 1.44003019e-01f, -1.88413635e-01f, -6.22750213e-03f, 9.32903066e-02f, -3.25834788e-02f, -4.53390367e-02f, -5.11076935e-02f, -1.03411898e-01f,
  -7.00237602e-02f, -1.74419954e-01f, -1.50899291e-01f, -3.33473206e-01f, -2.68299043e-01f, -8.95760804e-02f, -3.81624788e-01f, -2.86672950e-01f, -4.19732720e-01f, 8.54742378e-02f,
  -3.52441450e-03f, -4.68237028e-02f, -1.63953230e-01f, 9.34120938e-02f, 2.32891932e-01f, 1.38256373e-02f, 4.81103435e-02f, -9.40057561e-02f, -5.01333773e-02f, 8.27695578e-02f,
  -1.23889334e-01f, -7.39829615e-02f, 5.61815873e-02f, 3.21012177e-02f, -9.42807123e-02f, -1.67354524e-01f, -4.48396206e-02f, -7.08910450e-02f, 2.18835156e-02f, -1.01726651e-02f,
  -9.92332995e-02f, -5.25028780e-02f, 8.97385851e-02f, 1.78346738e-01f, -8.69987309e-02f, -1.23495691e-01f, -1.70640368e-02f, -6.14377186e-02f, 1.17928930e-01f, -1.03756674e-01f,
  3.21796596e-01f, -2.87989169e-01f, 1.31853148e-01f, -1.16196750e-02f, -1.72236249e-01f, -1.13721028e-01f, 4.64180410e-02f, -8.61784667e-02f, 7.98866674e-02f, -1.27427831e-01f,
  -2.57114291e-01f, 7.04943165e-02f, -3.27758025e-03f, -9.53239873e-02f, -7.38308951e-02f, 7.15209113e-04f, -6.37086574e-03f, 7.31457211e-03f, 7.28089875e-03f, -6.75818697e-02f,
  1.69794664e-01f, 6.79731369e-02f, 3.35218757e-01f, 1.33562639e-01f, 4.89869602e-02f, 2.33417109e-01f, -2.18050495e-01f, -1.64947867e-01f, -7.65998513e-02f, 3.03336471e-01f,
  -8.15520361e-02f, -2.66002029e-01f, -3.73500794e-01f, -4.58326370e-01f, -3.77095670e-01f, -1.72945738e-01f, -2.22107708e-01f, 4.33040336e-02f, -4.56809960e-02f, -3.12176079e-01f,
  -1.24921072e-02f, -2.30225902e-02f, -1.42638594e-01f, -1.20199460e-03f, 6.81430921e-02f, -3.38141918e-01f, -3.56913507e-01f, -2.38710240e-01f, -2.83164680e-02f, 4.98134829e-02f,
  -1.41216785e-01f, -2.43864834e-01f, -1.20021820e-01f, -1.60536289e-01f, -3.23683441e-01f, -2.26697937e-01f, -3.16139549e-01f, -1.77098528e-01f, -1.42836913e-01f, -4.63982671e-01f,
  -3.60076219e-01f, 8.81075487e-03f, 1.49016798e-01f, 2.84207731e-01f, -1.15475364e-01f, 2.06337988e-01f, -3.78560163e-02f, 7.43438751e-02f, 9.86802876e-02f, -1.00867115e-01f,
  -4.43475368e-03f, 7.88898692e-02f, -4.90622334e-02f, 9.63681936e-03f, -1.19469434e-01f, 9.12639350e-02f, 1.80522844e-01f, 1.07678279e-01f, 1.41370207e-01f, 5.54383397e-02f,
  1.52988374e-01f, 1.33880764e-01f, 1.57322437e-01f, 2.01436296e-01f, 3.91335458e-01f, 1.70491681e-01f, 5.17965555e-02f, 2.03462169e-01f, 1.26920491e-01f, 7.99364373e-02f,
  2.00908139e-01f, 2.48778239e-02f, -2.77111642e-02f, 1.45532563e-01f, 8.47643763e-02f, 2.29223408e-02f, -2.93170940e-02f, -4.06564288e-02f, 1.40033051e-01f, -2.05728356e-02f,
  2.00266507e-03f, 9.08664167e-02f, 2.58734897e-02f, -3.60606685e-02f, -2.99501028e-02f, 8.98964703e-03f, 8.94792974e-02f, 4.27698717e-02f, 8.43916386e-02f, 4.58486229e-02f,
  7.91582987e-02f, -6.11346662e-02f, -1.89029843e-01f, -5.00310287e-02f, 8.11050758e-02f, 6.36255518e-02f, -3.33625488e-02f, 7.46789351e-02f, -6.10457547e-02f, 4.39115567e-03f,
  -2.75871277e-01f, 1.33295253e-01f, -1.33970171e-01f, 1.54804572e-01f, -9.41120237e-02f, 1.00403570e-01f, -9.95808169e-02f, -5.63801713e-02f, -9.03324112e-02f, -4.51584347e-02f,
  7.28798285e-02f, -1.17888510e-01f, -5.60676791e-02f, 3.44955339e-03f, 1.77223030e-02f, 1.89883616e-02f, 2.11909965e-01f, 7.33954981e-02f, 9.39404219e-02f, 6.72361180e-02f,
  3.44271287e-02f, 1.96428463e-01f, 3.43729369e-02f, 5.69594651e-02f, 1.73602700e-01f, 4.87733856e-02f, -1.74723696e-02f, -2.10154857e-02f, 3.26872133e-02f, -1.41020669e-02f,
  -6.84901476e-01f, -3.82515073e-01f, -2.39420861e-01f, -6.15952015e-01f, -2.23882988e-01f, 2.05978319e-01f, 2.00790301e-01f, 9.62272957e-02f, -3.62257689e-01f, -3.98778349e-01f,
  -7.49890804e-02f, 2.96045691e-01f, -7.70810023e-02f, 1.10834211e-01f, 9.88461524e-02f, -1.83994055e-01f, -4.59517390e-01f, 3.73081267e-02f, 5.81261814e-01f, 5.38028896e-01f,
  2.12331101e-01f, -8.65514278e-02f, -2.09864423e-01f, -4.66251001e-02f, -2.37436756e-01f, -2.20134035e-02f, -4.47681546e-01f, -2.93545157e-01f, -1.54114008e-01f, -6.03124738e-01f,
  2.86226898e-01f, -1.59487471e-01f, 1.13623135e-01f, -2.58856658e-02f, -1.24189310e-01f, -8.85860398e-02f, -5.66900000e-02f, -9.08884928e-02f, -1.66426867e-01f, -1.46808863e-01f,
  -7.30494484e-02f, 9.53155160e-02f, 5.01243398e-03f, -2.93341652e-02f, -2.03697290e-03f, 5.46793267e-02f, -4.62615453e-02f, -5.29054180e-02f, -1.59335703e-01f, 1.29103258e-01f,
  3.07502858e-02f, 2.84353122e-02f, 3.60291526e-02f, 3.26550268e-02f, 1.47054523e-01f, 1.25351891e-01f, 1.27678514e-01f, 1.11285321e-01f, 8.10545385e-02f, -1.63775519e-01f,
  6.57801628e-02f, -1.25919431e-02f, 6.97305202e-02f, 9.75968987e-02f, 1.32811666e-02f, -4.38065603e-02f, -4.23756056e-02f, -5.15749604e-02f, 7.63828680e-02f, 9.83678084e-03f,
  -3.46742831e-02f, -1.34292185e-01f, 9.33259428e-02f, -1.34434938e-01f, -1.08124800e-01f, -6.23361245e-02f, 3.53133790e-02f, 1.06907310e-02f, -1.28756002e-01f, -1.48467347e-01f,
  -9.48741063e-02f, -5.71042299e-02f, -1.89167842e-01f, 8.70134160e-02f, -3.52758989e-02f, -1.39310658e-01f, -1.18723124e-01f, 1.76531579e-02f, 2.99757291e-02f, -6.72979429e-02f,
  1.97657600e-01f, -3.24230455e-03f, -1.59632608e-01f, -1.06591895e-01f, -4.90655415e-02f, -7.84217715e-02f, -4.14565615e-02f, -4.64975052e-02f, -3.80591638e-02f, 1.37511343e-01f,
  5.86100556e-02f, 2.45542042e-02f, -6.76401053e-03f, 5.89429997e-02f, 1.40769213e-01f, 5.15150018e-02f, -6.90876320e-02f, -1.63507298e-01f, 1.00654177e-02f, 3.44667234e-03f,
  -1.23605669e-01f, 1.61038004e-02f, 1.06407598e-01f, 3.10018305e-02f, 4.54113372e-02f, 1.92543134e-01f, 1.28954679e-01f, 2.11476296e-01f, 8.44199434e-02f, 2.34386083e-02f,
  3.44884127e-01f, -4.85170409e-02f, 4.17147428e-01f, 1.44122168e-01f, 2.45502368e-01f, 2.27072611e-01f, -2.28010006e-02f, -7.64406621e-02f, -3.32237929e-02f, -1.59656554e-01f,
  -2.82126725e-01f, -3.39611918e-01f, -3.63721967e-01f, -2.75607497e-01f, -7.72340745e-02f, 7.79300779e-02f, 2.38310769e-01f, 2.98512876e-01f, 2.48879567e-01f, 9.71412361e-02f,
  4.29702178e-02f, 2.44737148e-01f, 2.53789872e-01f, 1.74647674e-01f, 5.18558770e-02f, -1.36398454e-03f, 1.68717827e-03f, 8.92737582e-02f, 5.85821047e-02f, 2.38901034e-01f,
  1.66128188e-01f, 9.31785628e-02f, -8.18711817e-02f, -2.66931981e-01f, 1.22498935e-02f, 5.30286618e-02f, 8.60540420e-02f, 1.94743183e-02f, -1.07410714e-01f, -5.46740070e-02f,
  -3.54170315e-02f, -2.19267253e-02f, -3.29460651e-02f, 6.21169470e-02f, 6.94360733e-02f, -1.38924941e-02f, 2.62341239e-02f, 3.50274183e-02f, -7.84235671e-02f, -8.05095434e-02f,
  -2.05801040e-01f, 8.62260982e-02f, 9.90045071e-02f, -1.54059157e-01f, -5.08079119e-02f, -2.99981982e-02f, -7.43883997e-02f, 1.46125732e-02f, -8.30595791e-02f, -2.38613673e-02f,
  -5.58145642e-02f, -5.37603013e-02f, 7.57812411e-02f, 1.10918440e-01f, 1.95413250e-02f, 5.36725968e-02f, 1.19819410e-01f, 1.50832534e-01f, 9.55027193e-02f, 1.66162983e-01f,
  -1.91074598e-03f, 1.09622873e-01f, 8.23301151e-02f, 1.57930493e-01f, -1.08027197e-01f, 7.60651827e-02f, 1.93827704e-01f, -8.51617157e-02f, 9.77867190e-03f, 9.38320719e-03f,
  9.49508995e-02f, 2.52043083e-02f, 5.72828650e-02f, 3.50746363e-02f, 9.77310911e-02f, 9.60208029e-02f, 1.10676378e-01f, 2.32947730e-02f, -6.42441213e-02f, 7.74316415e-02f,
  -1.35926008e-01f, -1.11766256e-01f, -2.15908419e-02f, 3.99710611e-02f, 1.49796233e-01f, -7.89836943e-02f, -8.44947025e-02f, -3.32235429e-03f, 7.37048239e-02f, -4.78232913e-02f,
  -8.50948840e-02f, -4.48479317e-03f, 1.36891957e-02f, 2.92282216e-02f, 9.81336981e-02f, -2.54580230e-02f, -3.89362574e-02f, 7.86521286e-02f, -1.36376545e-01f, 3.97071466e-02f,
  -3.73524874e-02f, -1.25358778e-03f, 1.24460965e-01f, -6.74178973e-02f, 1.93903409e-02f, 5.92691451e-02f, 2.39195805e-02f, 6.87853545e-02f, 3.10317166e-02f, 4.00550961e-02f,
  7.13602364e-01f, 2.67306834e-01f, 3.74469042e-01f, 2.33486757e-01f, 2.20518455e-01f, 1.80559173e-01f, 2.39483342e-01f, 5.28167039e-02f, -2.92143561e-02f, 1.72989368e-01f,
  2.18877032e-01f, 6.79494739e-02f, 8.06346536e-02f, -2.17925720e-02f, 3.62761579e-02f, -6.31250590e-02f, -1.90540716e-01f, 1.02004968e-01f, 4.34195846e-02f, 8.25149417e-02f,
  -1.11159449e-02f, 4.47895899e-02f, 5.95417581e-02f, -1.10907339e-01f, -7.57797435e-02f, -4.57529612e-02f, 2.54806653e-02f, -8.40910710e-03f, 4.36480194e-02f, -1.78043127e-01f,
  1.14378454e-02f, 2.86080122e-01f, -8.93117040e-02f, -7.25287646e-02f, 1.34292871e-01f, -8.50606859e-02f, -4.49880883e-02f, -1.77568540e-01f, -1.63158074e-01f, -2.73178875e-01f,
  -1.26039147e-01f, 9.85720456e-02f, 1.06542282e-01f, -2.39698701e-02f, 5.46758138e-02f, 4.67439294e-02f, 5.12904022e-03f, -1.16781563e-01f, -7.58700743e-02f, 2.66004484e-02f,
  -1.06239624e-01f, 1.79721683e-01f, 1.90634444e-01f, 4.86409515e-02f, 6.42146170e-02f, 6.13428978e-03f, 8.60087126e-02f, 6.81993514e-02f, 1.40219033e-01f, 5.48458435e-02f,
  -9.34477821e-02f, 3.15614343e-01f, 2.50380397e-01f, 5.58575266e-06f, -2.81145442e-02f, -7.18585625e-02f, -8.93421024e-02f, 6.21585585e-02f, 4.39177603e-02f, 2.03274459e-01f,
  -1.59928352e-02f, -3.59019148e-03f, -3.87199931e-02f, -1.56185376e-02f, 5.46719655e-02f, 6.97089061e-02f, 1.67326443e-02f, 4.25261296e-02f, 1.65342301e-01f, -4.75580655e-02f,
  1.05784554e-03f, -2.06675623e-02f, 4.30024825e-02f, -7.23788806e-04f, -1.65898710e-01f, 8.98433030e-02f, -4.04296555e-02f, 8.99773240e-02f, 6.98121786e-02f, -1.59910575e-01f,
  -3.42033595e-01f, 1.89851284e-01f, -1.40891513e-02f, -1.64754599e-01f, 5.00361882e-02f, -5.66651002e-02f, 8.31335783e-02f, -7.22720027e-02f, -2.42260933e-01f, -2.99416393e-01f,
  4.92119882e-03f, 2.35561049e-03f, 1.72225684e-01f, 4.74225543e-02f, -1.22035377e-01f, -8.59563127e-02f, 5.85048413e-03f, 1.51700517e-02f, -3.37919518e-02f, -1.50585428e-01f,
  6.79477770e-03f, 4.77432609e-02f, -3.25937122e-02f, 2.72943713e-02f, -3.82103026e-02f, -1.27458408e-01f, -5.03482111e-02f, -4.39937375e-02f, 9.42005962e-02f, 1.77366920e-02f,
  -7.57340312e-01f, 5.18622756e-01f, -1.63112849e-01f, -2.89540738e-01f, -3.26299109e-02f, 8.32519308e-02f, 3.69440615e-01f, 8.59642476e-02f, -8.41208473e-02f, 3.29335093e-01f,
  1.17482498e-01f, -2.14722157e-01f, -4.88127582e-02f, 6.60311058e-02f, 1.67688251e-01f, 5.69372356e-01f, 4.57804114e-01f, -1.69711336e-01f, -4.48921263e-01f, -5.35140149e-02f,
  2.68978149e-01f, -2.79117465e-01f, -5.00447989e-01f, -1.49727941e-01f, -4.10045870e-02f, -1.26340136e-01f, 9.12215337e-02f, -2.02514809e-02f, 2.62618542e-01f, 2.51978099e-01f,
  -1.89627916e-01f, -4.11601871e-01f, -1.17347151e-01f, -4.36264068e-01f, -3.21824789e-01f, -1.63645633e-02f, 1.30092781e-02f, -2.99172729e-01f, -8.68134797e-02f, -1.61194485e-02f,
  -2.77985543e-01f, -1.71672344e-01f, -3.17077041e-01f, -4.02422212e-02f, -2.34298542e-01f, -5.19169450e-01f, -2.01905295e-01f, -3.45796824e-01f, -2.84521461e-01f, -3.95073861e-01f,
  4.12062556e-01f, -7.73931667e-02f, -3.26858431e-01f, 1.70840263e-01f, -5.78326657e-02f, -1.34818137e-01f, -2.55037993e-01f, -2.63543189e-01f, -2.30368614e-01f, -9.03954953e-02f,
  4.17000130e-02f, -8.82922709e-02f, 1.01049021e-01f, 1.46333292e-01f, 1.38530061e-01f, 2.40895171e-02f, -3.67475711e-02f, -3.92321777e-03f, -8.25981423e-03f, -4.24375422e-02f,
  -7.80830532e-02f, -1.89666986e-01f, -2.22021773e-01f, -1.42209604e-01f, -2.25533396e-01f, -2.94482857e-02f, -1.91113893e-02f, 1.79537773e-01f, 1.99663922e-01f, 4.54177819e-02f,
  -1.15080938e-01f, -4.56412323e-03f, -5.35442196e-02f, -1.08500374e-02f, 2.11666167e-01f, 5.62621430e-02f, 7.77338073e-02f, -5.52186705e-02f, -1.09980576e-01f, -7.16618299e-02f,
  -6.91887049e-04f, 4.00873721e-01f, -1.46716267e-01f, -1.27288550e-01f, -5.59764728e-02f, -1.20499216e-01f, 4.70231883e-02f, -1.19129144e-01f, -2.22077630e-02f, -3.36902857e-01f,
  -8.87374282e-02f, -1.70072898e-01f, 7.28305057e-03f, -1.32092712e-02f, -2.57333070e-01f, -1.81929573e-01f, 3.01176399e-01f, -8.87835845e-02f, 4.02511470e-02f, -2.09537223e-01f,
  3.27501237e-01f, 1.36230901e-01f, -3.30422148e-02f, 1.95872914e-02f, 1.75251693e-01f, 2.41303258e-02f, -1.02325216e-01f, -2.22251102e-01f, -1.09056428e-01f, 3.31943572e-01f,
  -1.93635523e-01f, -2.71692425e-01f, -5.11158526e-01f, -3.34913492e-01f, 8.07622150e-02f, -7.80695677e-02f, -3.71886283e-01f, -4.18725491e-01f, -2.18107656e-01f, -2.46666342e-01f,
  4.69435304e-01f, 4.30599481e-01f, -2.41685048e-01f, -6.19284771e-02f, -2.73963213e-01f, -4.47774619e-01f, -5.82018852e-01f, -3.38988602e-01f, 1.67016789e-01f, 7.18729198e-01f,
  3.95605952e-01f, 9.78665203e-02f, 6.40988424e-02f, -1.40617743e-01f, -9.32852924e-02f, 1.87647656e-01f, -1.82794645e-01f, 4.58345283e-03f, 5.71399108e-02f, -1.27050310e-01f,
  5.55465696e-03f, -2.72009194e-01f, 9.74991694e-02f, 3.14867914e-01f, 1.95049733e-01f, -1.39907390e-01f, -4.28532287e-02f, -3.15225899e-01f, 1.11139506e-01f, -9.70800370e-02f,
  1.69647500e-01f, 1.23605035e-01f, 1.83061376e-01f, 1.47990599e-01f, 7.24244416e-02f, -4.28742543e-02f, -2.11591959e-01f, -3.09661984e-01f, -3.78594309e-01f, 2.82924622e-03f,
  3.16125065e-01f, 1.21669292e-01f, -4.14493710e-01f, -2.86860883e-01f, -1.64157853e-01f, 7.22499713e-02f, -7.80316889e-02f, -1.68634966e-01f, -4.24747288e-01f, -4.18703586e-01f,
  -6.93744570e-02f, 6.05323724e-02f, 6.95851967e-02f, -1.77498013e-02f, 7.25299353e-03f, -8.96692127e-02f, -1.27896547e-01f, -9.17388499e-02f, 7.24977180e-02f, -2.02513918e-01f,
  -2.51912307e-02f, 5.99712646e-03f, 6.58595040e-02f, -1.07463710e-01f, 3.93957272e-02f, -1.02585733e-01f, -1.12929210e-01f, -2.35357866e-01f, -7.17638135e-02f, 6.94283564e-03f,
  -6.73483312e-02f, 6.61997590e-03f, 1.50566444e-01f, 5.39427958e-02f, -1.97027475e-01f, -3.50344896e-01f, -5.24456166e-02f, 4.54255417e-02f, 5.08246161e-02f, -7.75236115e-02f,
  1.21955778e-02f, 1.87912539e-01f, -2.71783352e-01f, -1.41774535e-01f, 8.43586475e-02f, 7.37166703e-02f, -6.24308847e-02f, -9.22137648e-02f, -5.72873540e-02f, -2.41958573e-02f,
  7.52713755e-02f, 3.04722395e-02f, 2.38792654e-02f, 1.85483366e-01f, 1.81572273e-01f, 1.32957567e-02f, -1.35077491e-01f, -8.42693597e-02f, -7.25359097e-02f, 2.33702928e-01f,
  -2.49253541e-01f, -2.99254358e-01f, -2.58173794e-01f, -3.43052804e-01f, -9.48893428e-02f, -2.98498243e-01f, -1.58845916e-01f, -2.24953964e-01f, -4.17636603e-01f, -4.86953229e-01f,
  -5.62839031e-01f, -2.26862893e-01f, -5.95570743e-01f, -8.81385386e-01f, -6.25003517e-01f, -2.07479283e-01f, -6.23325966e-02f, -2.58111805e-01f, -6.33028030e-01f, -4.84057605e-01f,
  1.73986614e-01f, 7.02658236e-01f, 1.91268399e-01f, 5.07548928e-01f, 7.27022827e-01f, -4.19774771e-01f, -6.66479945e-01f, -1.22975474e-02f, 5.93572319e-01f, 4.38414901e-01f,
  2.11755693e-01f, -3.02790493e-01f, -1.57894731e-01f, -2.36275285e-01f, -4.40052241e-01f, -1.14035912e-01f, -7.18802691e-01f, -4.16623592e-01f, -7.03254044e-02f, -7.20110416e-01f,
  3.72128427e-01f, -4.95563090e-01f, 1.11928387e-02f, 1.21075464e-02f, -5.83832823e-02f, 1.34417966e-01f, 6.37262091e-02f, -1.14837863e-01f, -1.71527833e-01f, -1.14200227e-01f,
  -1.81420356e-01f, -2.91287098e-02f, 1.18041456e-01f, 7.66548738e-02f, -8.35257471e-02f, -5.48011363e-02f, -1.45052716e-01f, -2.13746473e-01f, -6.65059835e-02f, 1.22804619e-01f,
  6.63046315e-02f, -8.84923190e-02f, 1.53619125e-02f, 5.00277542e-02f, -1.65784769e-02f, -1.17501460e-01f, 5.18045314e-02f, -7.23041967e-02f, 1.40103400e-02f, -3.24005395e-01f,
  7.10584503e-03f, 1.01903260e-01f, -6.09491467e-02f, 1.73046049e-02f, -2.23684385e-02f, -3.54895890e-02f, -5.50929978e-02f, -5.80096059e-03f, 1.50468931e-01f, 2.07415223e-01f,
  -7.74152949e-02f, -9.80759114e-02f, 6.84264675e-02f, 1.65914372e-02f, -6.78138435e-02f, -9.43961367e-02f, 1.16334327e-01f, 1.55548096e-01f, 1.43668139e-02f, -8.64779055e-02f,
  2.40137074e-02f, -1.51977360e-01f, -5.46700917e-02f, 7.73567706e-02f, -1.81354478e-01f, -8.74366984e-02f, -1.37505174e-01f, 2.49070182e-01f, 6.93096071e-02f, -7.99877569e-02f,
  4.08120871e-01f, -6.35429099e-02f, -1.38699273e-02f, -2.56624236e-03f, -2.14791149e-01f, -5.84312268e-02f, -1.26226366e-01f, -9.48998984e-03f, -1.25010610e-01f, -8.82289261e-02f,
  4.53691334e-02f, 1.22766562e-01f, 1.06877372e-01f, -4.14266139e-02f, 9.08928141e-02f, 7.00046495e-03f, -2.97824517e-02f, -9.76632535e-03f, -6.66410848e-03f, -3.61697190e-02f,
  -4.89757098e-02f, -4.52210242e-03f, 3.46691966e-01f, 9.69929770e-02f, 3.21179926e-02f, 1.37308687e-01f, 1.81759000e-01f, 2.45703191e-01f, 1.88875377e-01f, 2.74652615e-02f,
  4.19212162e-01f, 1.73320964e-01f, 1.40311912e-01f, 2.23000258e-01f, 5.04066348e-01f, 4.16676968e-01f, 5.09467244e-01f, 2.04647601e-01f, 3.43529768e-02f, 5.79402372e-02f,
  1.10600680e-01f, -1.27632871e-01f, -2.18228832e-01f, -1.86876431e-01f, -1.74604475e-01f, -3.09558921e-02f, -1.00897700e-01f, -1.04011551e-01f, -9.42493230e-03f, 3.61590348e-02f,
  -9.79104340e-02f, 1.03173748e-01f, 1.85586914e-01f, -1.63831804e-02f, 1.39998924e-02f, -4.06518504e-02f, 1.22976720e-01f, 2.28184432e-01f, 5.91811687e-02f, -3.60926539e-01f,
  -7.47281760e-02f, 3.55935574e-01f, -4.83325794e-02f, -3.17580812e-02f, 1.33510411e-01f, -9.73851681e-02f, -3.16387713e-02f, -1.04673423e-01f, -2.44299844e-02f, -2.07053259e-01f,
  4.74553294e-02f, -2.73290221e-02f, 1.89562246e-01f, -1.19409561e-02f, 9.60840732e-02f, 6.20022602e-02f, 6.32133409e-02f, -5.44092692e-02f, -1.04590796e-01f, -1.46595329e-01f,
  -8.58655795e-02f, 2.27948368e-01f, 1.50182515e-01f, 1.03437170e-01f, 1.50621636e-02f, 1.02219701e-01f, 3.15936543e-02f, -4.76369485e-02f, 1.33987861e-02f, -7.42506459e-02f,
  2.27816507e-01f, 1.40787572e-01f, 2.22913846e-02f, -4.15878259e-02f, -1.10075548e-01f, -6.25146180e-02f, -9.13641676e-02f, 9.43102911e-02f, 1.62432551e-01f, 1.24711171e-01f,
  9.51481536e-02f, 4.49867137e-02f, 1.03785008e-01f, 1.79971471e-01f, -1.05265509e-02f, 1.25983551e-01f, 9.14547965e-02f, 1.17790245e-01f, 1.14747688e-01f, 3.80570255e-02f,
  1.62741199e-01f, -1.74042191e-02f, 8.54469612e-02f, 8.04104805e-02f, -2.30419869e-03f, 1.08008765e-01f, 1.21898316e-01f, 9.69258398e-02f, 1.18357345e-01f, 2.64197916e-01f,
  -1.72372698e-03f, 4.82885838e-01f, -1.14144631e-01f, -8.41337591e-02f, 9.41822603e-02f, 7.54288957e-02f, 1.99191362e-01f, -4.04835939e-02f, -1.13272600e-01f, -1.53881684e-01f,
  -1.09675946e-02f, -5.15142158e-02f, 2.21740350e-01f, 4.56012040e-02f, 1.09073311e-01f, 3.96732278e-02f, -8.81605595e-02f, -7.70010129e-02f, -2.13390559e-01f, -9.81466174e-02f,
  -7.07551315e-02f, -3.74626485e-03f, -7.11659342e-02f, 5.98762138e-03f, 7.71048889e-02f, 1.76597442e-02f, -1.23825325e-02f, -1.00437284e-01f, 2.05627307e-02f, -2.75570117e-02f,
  2.65709460e-01f, -3.82189512e-01f, -7.31036723e-01f, 2.73640990e-01f, 7.02558905e-02f, 8.33270550e-02f, 4.61555928e-01f, 5.33717632e-01f, 3.81051898e-01f, 1.03780657e-01f,
  -5.51399112e-01f, -5.63165128e-01f, -6.69257760e-01f, -5.21524549e-01f, -2.49658644e-01f, -2.44953483e-02f, -1.71341524e-01f, -3.81574124e-01f, 2.20607966e-02f, 6.51589990e-01f,
  5.15024483e-01f, 4.61748093e-01f, 3.09405476e-01f, 1.17376521e-01f, 1.33284643e-01f, -9.31269899e-02f, -2.36287311e-01f, -2.00082928e-01f, -3.47499073e-01f, -5.90932846e-01f,
  -2.83188611e-01f, -3.09526026e-01f, 8.48482475e-02f, -2.49030337e-01f, -1.81636497e-01f, 2.55912803e-02f, 1.76876947e-01f, -1.63400210e-02f, -2.70085841e-01f, -9.24265832e-02f,
  -2.82203883e-01f, -1.06232636e-01f, -4.56713557e-01f, -1.76463038e-01f, 7.29801133e-02f, 1.39285251e-01f, 2.87757325e-03f, -2.33866066e-01f, -3.21200430e-01f, -1.08948201e-01f,
  -3.56310844e-01f, -3.44073236e-01f, -3.00825924e-01f, 3.31791155e-02f, -1.34551689e-01f, -3.40495229e-01f, -1.78313162e-02f, -2.00953513e-01f, -3.12272906e-01f, 2.21320674e-01f,
  1.47882298e-01f, 1.09330297e-01f, 3.51718217e-02f, 1.42256483e-01f, 3.77197489e-02f, -8.05403814e-02f, -7.50097409e-02f, -2.44733263e-02f, 1.56438187e-01f, 1.63164869e-01f,
  -6.69099912e-02f, -1.23030566e-01f, -8.44359770e-02f, 7.72045106e-02f, -8.64450857e-02f, -9.71465036e-02f, -1.42714277e-01f, -3.68786417e-02f, -8.66313465e-03f, -1.38216270e-02f,
  -2.11252701e-02f, 4.27275635e-02f, -9.25268233e-02f, -1.86419785e-02f, -1.83662459e-01f, -1.00246698e-01f, 1.40810236e-02f, 1.88557934e-02f, -8.12055916e-03f, 1.03568844e-01f,
  5.09257376e-01f, -1.57158494e-01f, 1.65673614e-01f, 5.71210682e-02f, 7.99023453e-03f, -1.56425923e-01f, -7.57848769e-02f, 1.08767271e-01f, -1.53398976e-01f, -3.44983824e-02f,
  -1.01472229e-01f, -1.80056632e-01f, -2.33304784e-01f, 5.41047379e-02f, 7.25491419e-02f, 1.83713920e-02f, 1.22829698e-01f, -1.84676483e-01f, 1.07841864e-01f, 2.32139304e-01f,
  1.14736855e-01f, 3.66698474e-01f, 2.17937827e-01f, 1.57052368e-01f, 2.72442460e-01f, 2.17643514e-01f, 3.07983339e-01f, 2.41262272e-01f, -4.87588719e-02f, 8.80191684e-01f,
  3.78533006e-01f, 2.19298393e-01f, -4.63138640e-01f, 4.74820346e-01f, 2.56327838e-02f, -3.07522655e-01f, -2.53272623e-01f, -8.78399685e-02f, 2.54050136e-01f, 2.74390519e-01f,
  8.13448876e-02f, -6.41975477e-02f, -1.20581359e-01f, -3.61504257e-01f, -6.44550622e-01f, -4.25630212e-01f, -3.70961815e-01f, -6.69504344e-01f, -5.94743848e-01f, -4.08379972e-01f,
  -1.01454794e-01f, 1.29781365e-01f, -5.01062796e-02f, -3.11880857e-02f, 3.07025284e-01f, -1.11663893e-01f, 8.12715068e-02f, 7.93142542e-02f, -3.57303947e-01f, 1.06986806e-01f,
  -1.00711942e-01f, -1.36743680e-01f, -2.00158194e-01f, 9.51334089e-02f, 2.58008599e-01f, 2.21944656e-02f, -9.95153654e-03f, 1.65612400e-01f, 1.45216167e-01f, 1.21141382e-01f,
  1.32002562e-01f, 1.36268334e-02f, 4.40575033e-02f, -6.90033436e-02f, 9.76685807e-02f, -1.21201016e-01f, 1.03977837e-01f, -1.40505299e-01f, -1.32667214e-01f, 6.98263645e-02f,
  2.00265124e-01f, -2.38802023e-02f, -8.25115666e-02f, -1.00367770e-01f, -9.16782469e-02f, -1.05351396e-02f, 5.74041791e-02f, -5.57036698e-02f, -3.41434896e-01f, 2.49710053e-01f,
  -2.59626135e-02f, 5.16155809e-02f, -1.68284925e-04f, 1.25439679e-02f, 6.52557909e-02f, 6.18649721e-02f, 9.99442860e-02f, 9.01983753e-02f, 1.01660024e-02f, 1.04992516e-01f,
  7.04449788e-02f, -1.18288919e-02f, -5.46814613e-02f, 2.46225530e-03f, 5.54451579e-03f, 5.44388629e-02f, -9.08323526e-02f, 3.07064094e-02f, -6.80686161e-03f, 2.82170177e-02f,
  -1.36954626e-02f, 8.91603250e-03f, 8.54983255e-02f, 8.63416195e-02f, -5.62522672e-02f, 1.41961360e-02f, -9.15392786e-02f, -3.16023342e-02f, -2.38112621e-02f, 1.43639278e-02f,
  2.39855260e-01f, -4.13537323e-01f, 2.23039553e-01f, -1.46122649e-01f, 3.99953946e-02f, 3.20924893e-02f, 9.04819965e-02f, -1.61845481e-03f, 1.50454774e-01f, -1.45473899e-02f,
  -1.45175785e-01f, -2.50957198e-02f, 8.83603990e-02f, 7.90875256e-02f, -8.38312954e-02f, -9.91624817e-02f, 1.20981522e-01f, 6.82689101e-02f, -7.01815858e-02f, 2.43624210e-01f,
  3.45289737e-01f, 2.00239085e-02f, 1.13283299e-01f, 4.51363362e-02f, 9.66530815e-02f, -1.60504952e-01f, -5.94968721e-02f, 2.34258175e-02f, -3.28222424e-01f, 3.45149308e-01f,
  -6.19537652e-01f, 6.82329297e-01f, 2.63297647e-01f, -4.72842395e-01f, 1.88068882e-01f, 4.42063898e-01f, 8.45777094e-01f, 2.70587206e-01f, -2.15722010e-01f, 2.79330164e-01f,
  2.50632375e-01f, -3.21485072e-01f, -8.99471492e-02f, -5.39203137e-02f, 1.88389793e-01f, 4.34865296e-01f, 2.79846370e-01f, -2.52271116e-01f, -4.66446549e-01f, -6.80506378e-02f,
  -4.89806011e-02f, -3.03341657e-01f, -4.51976806e-01f, -2.19579265e-01f, -1.25391245e-01f, -1.96969837e-01f, 8.10898915e-02f, -1.96696501e-02f, 3.48588526e-01f, -7.15334574e-03f,
  -9.88547578e-02f, 1.18785992e-01f, -3.16870779e-01f, -2.35249653e-01f, -2.12110747e-02f, -1.32839471e-01f, -7.96296895e-02f, -1.94642395e-01f, -5.81146479e-02f, -9.03039500e-02f,
  -5.35502285e-02f, -5.91693865e-03f, 1.06663713e-02f, 1.38669908e-01f, -2.57477034e-02f, 3.72565747e-03f, 2.38835718e-02f, -8.29037949e-02f, -8.17557350e-02f, 1.35450795e-01f,
  3.03308129e-01f, -1.08194789e-02f, 1.45700378e-02f, 2.16666341e-01f, 8.71624425e-02f, -3.39737147e-01f, 1.14628658e-01f, -8.74893442e-02f, 1.18035227e-02f, -1.54479623e-01f,
  -1.53910175e-01f, 4.18743789e-02f, 1.25179887e-01f, 3.20298411e-02f, 6.56974018e-02f, 4.18909639e-02f, 3.08927149e-02f, 1.25789801e-02f, -6.22464204e-03f, -5.96885867e-02f,
  -2.56614853e-02f, -4.61535081e-02f, -1.49256170e-01f, 9.13889706e-03f, -1.83417797e-01f, -2.76796669e-02f, -2.92737763e-02f, -6.40415996e-02f, -3.79369445e-02f, -2.05912031e-02f,
  -1.07965976e-01f, 7.12327436e-02f, -8.47658217e-02f, 3.75775583e-02f, 8.89198333e-02f, -7.11773112e-02f, -8.35059285e-02f, -1.62299573e-01f, -2.07153693e-01f, 3.65869813e-02f,
  -3.88622671e-01f, 2.67505199e-01f, -2.50460893e-01f, 3.78001146e-02f, 1.14515409e-01f, 1.06069155e-01f, 1.30815962e-02f, 4.00310419e-02f, 6.03867024e-02f, 2.36344952e-02f,
  1.33277163e-01f, 3.28991637e-02f, 9.84521657e-02f, 1.43852785e-01f, -1.23202473e-01f, 6.42917752e-02f, 9.55757797e-02f, -5.77047765e-02f, 3.83458100e-02f, -9.09245200e-03f,
  1.39178500e-01f, -1.26159012e-01f, -3.60373229e-01f, -6.58675879e-02f, -1.27184585e-01f, -3.62615973e-01f, -5.16453274e-02f, -1.61377996e-01f, -3.19215693e-02f, -2.18061477e-01f,
  3.22605520e-02f, 4.80699211e-01f, -9.93415490e-02f, 2.55578160e-01f, 4.22058016e-01f, 3.30467403e-01f, 4.96539354e-01f, 4.04746920e-01f, 2.40738556e-01f, 2.80519634e-01f,
  3.56328607e-01f, 3.53971809e-01f, 1.85162500e-01f, 1.80109859e-01f, 1.04684241e-01f, 4.47076373e-02f, 1.13165386e-01f, -1.56722113e-01f, -1.51884973e-01f, 7.18701780e-02f,
  2.41048679e-01f, 2.51897544e-01f, 2.67699938e-02f, 4.15020203e-03f, 2.94930656e-02f, 1.29197076e-01f, 2.63655216e-01f, 3.74011397e-01f, 1.43979043e-01f, -1.82207406e-01f,
  -2.86415190e-01f, 7.57641345e-02f, -2.71827370e-01f, 6.87159002e-02f, 2.62671951e-02f, -2.02696219e-01f, -9.86975729e-02f, -1.21822767e-01f, 7.39679411e-02f, -1.15241155e-01f,
  7.13840947e-02f, -4.47272584e-02f, 3.28592025e-02f, -1.33691239e-03f, 1.18389595e-02f, -7.37544224e-02f, -3.17117982e-02f, -3.34753394e-02f, 1.10551063e-02f, -7.35749006e-02f,
  1.25637636e-01f, 1.84171960e-01f, -2.54064216e-04f, -1.27197886e-02f, 6.02941029e-02f, -8.06365721e-03f, 5.96506521e-02f, -6.62735850e-02f, -7.07618818e-02f, -7.95785114e-02f,
  3.43559384e-02f, -8.19117725e-02f, 2.58359667e-02f, -4.81227301e-02f, -7.76304752e-02f, -1.16898254e-01f, -5.63104078e-03f, 6.08964413e-02f, 4.29037958e-02f, -1.02857873e-01f,
  -5.00196218e-02f, 1.77112769e-03f, -4.64052521e-02f, 1.16881775e-02f, -9.61192772e-02f, 1.48162739e-02f, -3.70565243e-02f, -1.76962800e-02f, -4.85014506e-02f, -3.44043151e-02f,
  -7.40873292e-02f, -1.06436111e-01f, 5.35233468e-02f, -5.33244535e-02f, -1.74915418e-02f, -9.09096226e-02f, -8.94736797e-02f, 2.20728051e-02f, 1.19177625e-01f, 6.19994998e-02f,
  3.03739637e-01f, 3.88942510e-02f, -2.74793953e-01f, -2.23976016e-01f, -8.13356340e-02f, -1.21578477e-01f, -1.32376805e-01f, -8.90425667e-02f, 7.11412877e-02f, -4.41856682e-02f,
  5.48254400e-02f, -2.10024461e-01f, -2.36975644e-02f, -8.44329670e-02f, 6.37999782e-03f, -7.93160051e-02f, 1.53412635e-03f, 2.41911486e-02f, -2.07258165e-02f, -9.89450365e-02f,
  2.93225404e-02f, -6.87087700e-02f, -1.36994207e-02f, 1.45610068e-02f, -1.03198461e-01f, 3.16768214e-02f, 1.97096486e-02f, -7.13199824e-02f, -4.29923423e-02f, 3.64141762e-02f,
  4.09946322e-01f, 2.92283684e-01f, -7.40444064e-01f, -4.07394171e-01f, -2.90180475e-01f, -2.36318991e-01f, 3.25543791e-01f, 3.47286947e-02f, -2.58110166e-01f, 1.84185967e-01f,
  3.19803059e-01f, 1.80856436e-02f, -1.78590968e-01f, -1.80510864e-01f, 1.42364427e-01f, 2.14839071e-01f, -2.75758356e-01f, -2.00317591e-01f, -1.51121661e-01f, -2.39152107e-02f,
  2.50797987e-01f, -7.18582869e-02f, -1.05441593e-01f, -2.68183678e-01f, -4.15653437e-01f, -3.69153708e-01f, -4.42463517e-01f, -2.32724935e-01f, 1.13356665e-01f, -1.75844520e-01f,
  -3.72559160e-01f, -1.22424848e-01f, -3.10051646e-02f, 5.97448796e-02f, -8.95757973e-03f, 3.12842093e-02f, 1.15436800e-01f, 2.25992259e-02f, 2.03065336e-01f, -1.64923035e-02f,
  -1.58135220e-01f, 1.13079198e-01f, -1.96803764e-01f, -6.05340339e-02f, -2.21895680e-01f, -2.72627044e-02f, -2.13890955e-01f, -2.74810903e-02f, 1.20689899e-01f, 9.61781666e-02f,
  1.20588228e-01f, 1.06620535e-01f, -8.73570889e-02f, 8.06627125e-02f, -6.18767180e-02f, -4.25997563e-02f, 2.92639853e-03f, -2.93297879e-02f, -1.00733504e-01f, 3.75352353e-02f,
  4.09850664e-02f, 9.53321829e-02f, 1.07479833e-01f, 1.29130319e-01f, 1.22335665e-01f, 8.58277455e-02f, 2.33324710e-02f, 5.11684492e-02f, 7.38334060e-02f, -2.50768270e-02f,
  1.31241316e-02f, 1.80845782e-01f, 2.97569968e-02f, 1.24126107e-01f, -1.10184625e-01f, 4.25640773e-03f, 1.24781467e-01f, 2.16738179e-01f, 1.31924739e-02f, 1.13423400e-01f,
  6.66196495e-02f, 1.00721801e-02f, -8.04223716e-02f, 1.07506365e-02f, 1.82664260e-01f, -6.95093796e-02f, -4.45506498e-02f, 1.74650088e-01f, -1.23171099e-01f, -9.20779654e-04f,
  -3.81882668e-01f, 2.70208031e-01f, -1.19378965e-03f, -9.17530432e-02f, -1.05541162e-01f, -1.42110124e-01f, -1.53803658e-02f, 2.88664624e-02f, 3.49171348e-02f, -1.16571948e-01f,
  -7.95990452e-02f, -2.80304030e-02f, -1.57117203e-01f, 2.91000605e-02f, -6.94656149e-02f, -1.09279044e-01f, 2.09234357e-01f, 7.44234100e-02f, 2.99924221e-02f, 2.60921828e-02f,
  1.80672318e-01f, 3.11427921e-01f, 1.42276436e-01f, 9.93720517e-02f, 8.50621387e-02f, 6.13845512e-02f, -1.19845815e-01f, -3.11829820e-02f, 2.20129207e-01f, 2.49519527e-01f,
  -3.53153586e-01f, -7.19810352e-02f, 3.08317810e-01f, -9.39644575e-02f, -8.94141272e-02f, -1.61493316e-01f, -3.32133293e-01f, -3.96255463e-01f, -3.86315495e-01f, -2.10044589e-02f,
  -1.28233001e-01f, -8.49685147e-02f, 8.40635970e-02f, -1.02460057e-01f, -1.40345275e-01f, 4.65951934e-02f, -2.22666003e-02f, 5.98242506e-02f, -1.04957439e-01f, -3.61631662e-01f,
  -2.35110417e-01f, -2.50640690e-01f, -2.25056306e-01f, -1.22563526e-01f, -1.53607100e-01f, -1.52376920e-01f, 1.12365209e-01f, -1.27530769e-01f, -1.55941486e-01f, 8.39343444e-02f,
  2.03455657e-01f, -1.81392029e-01f, -2.79325023e-02f, -4.32429537e-02f, -5.28419577e-02f, -7.92450309e-02f, -1.01658143e-02f, -2.94396617e-02f, -6.21020189e-03f, -1.09405935e-01f,
  -5.33077009e-02f, -6.00772537e-03f, -1.18278161e-01f, -8.56564939e-02f, -8.31059366e-02f, -7.52775520e-02f, -2.05797926e-02f, -1.66121721e-01f, -7.99983814e-02f, -1.26939774e-01f,
  1.87782440e-02f, -1.05489023e-01f, -1.32815778e-01f, 6.05887268e-03f, -1.74146622e-01f, -7.42095038e-02f, -4.10810634e-02f, -1.84106812e-01f, -1.37102172e-01f, 4.94775660e-02f,
  9.71851777e-03f, -8.27457085e-02f, -2.93958336e-01f, -7.44864941e-02f, -1.40144721e-01f, -1.76176831e-01f, -1.58561110e-01f, -1.42550886e-01f, -1.99238390e-01f, -8.72091725e-02f,
  -1.17158726e-01f, 4.61969152e-03f, -7.70073831e-02f, -2.21834611e-02f, 6.23435341e-02f, -1.57963112e-01f, -1.37889951e-01f, -7.59728253e-02f, -1.12898216e-01f, -1.94697380e-01f,
  -2.72442967e-01f, -1.87714204e-01f, -2.34404067e-03f, -6.01979829e-02f, -1.67897671e-01f, -1.33372834e-02f, -5.31746857e-02f, -5.16503267e-02f, -2.96111125e-02f, -1.45307899e-01f,
  -7.77776018e-02f, 9.59654897e-02f, 1.41036585e-01f, -5.90016544e-02f, 4.97797243e-02f, 8.71453583e-02f, -1.98464300e-02f, 3.86013240e-02f, 1.10479956e-02f, -1.01180725e-01f,
  3.72840203e-02f, 5.67809455e-02f, 9.15677547e-02f, -3.80277522e-02f, 3.71612832e-02f, 2.72023529e-02f, 9.96476486e-02f, 5.55482730e-02f, -8.42786431e-02f, -1.12598822e-01f,
  -5.07377163e-02f, 1.00113936e-01f, 1.67999759e-01f, 2.18530089e-01f, -3.53225842e-02f, 2.00830519e-01f, 2.57223397e-01f, 5.18460944e-02f, 1.30613148e-01f, 2.35186309e-01f,
  5.65408051e-01f, -1.22438505e-01f, 7.24524492e-03f, -3.45929787e-02f, -1.51989520e-01f, -1.51408002e-01f, -1.88270718e-01f, 2.82016397e-02f, 1.34796306e-01f, -9.53164068e-04f,
  1.59514770e-01f, 3.27834129e-01f, 2.21623570e-01f, 1.61445573e-01f, 1.85715199e-01f, -1.77407041e-02f, -1.59751866e-02f, 2.53560573e-01f, 2.57160157e-01f, 1.60702188e-02f,
  -4.98659851e-04f, 2.54045380e-03f, 7.64852911e-02f, 9.66887325e-02f, -1.02391578e-01f, 6.19368628e-02f, 1.03607019e-02f, -7.08171204e-02f, -1.05061866e-01f, -1.02979243e-01f,
  -2.51479417e-01f, -7.51950443e-02f, 9.45812538e-02f, 1.03314385e-01f, -3.74881923e-02f, -4.16429825e-02f, 7.45046660e-02f, -8.31850693e-02f, -5.25636375e-02f, -8.30634162e-02f,
  -1.34531736e-01f, -8.65213294e-03f, 5.27871251e-02f, 1.40767230e-03f, -8.74911919e-02f, -8.36891010e-02f, -4.41311747e-02f, 4.25497778e-02f, -5.66986762e-02f, 2.73217466e-02f,
  2.20470838e-02f, -1.24636948e-01f, -5.94340526e-02f, -5.25725521e-02f, 1.62039399e-01f, 1.03468433e-01f, 5.12420759e-02f, -1.32520394e-02f, 8.99870023e-02f, -6.93438873e-02f,
  1.36170730e-01f, 1.78432390e-01f, 8.40813592e-02f, 1.20850377e-01f, 9.49194953e-02f, 7.65151307e-02f, 4.02783155e-02f, -9.74972025e-02f, 2.18244985e-01f, -1.63166430e-02f,
  -9.28247496e-02f, 1.31604165e-01f, 5.26522323e-02f, -1.46008572e-02f, 1.00157887e-01f, -1.83227044e-02f, -3.83276232e-02f, -4.33940478e-02f, 1.16465256e-01f, 7.96984062e-02f,
  4.06278335e-02f, -1.92343332e-02f, -1.76167134e-02f, 1.01611111e-02f, -2.36632954e-02f, -4.17491831e-02f, -6.85543194e-02f, -6.42669201e-02f, -5.16013354e-02f, -5.47778644e-02f,
  -3.25079113e-01f, 4.26775038e-01f, 2.22313568e-01f, 2.71079950e-02f, -4.74627949e-02f, -1.58272672e-03f, 1.43430024e-01f, -9.49126184e-02f, -1.11659512e-01f, -1.68588102e-01f,
  -9.79025736e-02f, -6.13434501e-02f, -1.03698364e-02f, 1.73742305e-02f, 3.03914975e-02f, -3.29281837e-02f, 7.76337981e-02f, -4.50496972e-02f, -7.99978077e-02f, -1.43925399e-01f,
  -7.31116831e-02f, 1.48855122e-02f, 5.97415259e-03f, 3.64300683e-02f, 8.47707838e-02f, 1.09806783e-01f, 1.46056294e-01f, 1.16952255e-01f, 6.84040710e-02f, 7.11141825e-02f,
  4.72751796e-01f, -3.99341471e-02f, 4.13358092e-01f, -1.87732726e-01f, -4.60064590e-01f, -3.21076989e-01f, -4.38174725e-01f, -4.11515422e-02f, -3.46381247e-01f, -4.44481283e-01f,
  -3.49034458e-01f, -1.92249283e-01f, -2.52006680e-01f, -1.46818101e-01f, 2.63471246e-01f, -1.62048891e-01f, -9.29966941e-02f, 5.45533478e-01f, 7.23076880e-01f, 1.15691155e-01f,
  -1.09133184e-01f, 2.24341437e-01f, 5.88035643e-01f, 4.81963307e-01f, -2.48353302e-01f, -1.59591839e-01f, -2.04542130e-01f, 4.77034599e-02f, 1.99855268e-02f, -1.05646774e-01f,
  -3.57185900e-01f, 3.79092455e-01f, -3.38403210e-02f, -8.87786001e-02f, -1.89081490e-01f, -1.71568133e-02f, -2.14046407e-02f, 1.04753420e-01f, -4.62384783e-02f, 4.87613678e-02f,
  -2.90491521e-01f, -1.09467991e-02f, -1.79541200e-01f, -1.14932366e-01f, -1.03180140e-01f, 6.05960228e-02f, 1.52165085e-01f, 4.81897771e-01f, 1.94070682e-01f, 5.34401163e-02f,
  -3.01256031e-01f, -1.00050181e-01f, 2.24375144e-01f, 7.53502101e-02f, 2.16351181e-01f, 5.85949905e-02f, 1.31999031e-01f, 1.95772544e-01f, 2.34902322e-01f, -8.43470842e-02f,
  -1.29637614e-01f, -1.92331653e-02f, -1.12495646e-01f, 9.29139555e-02f, -2.92096704e-01f, -2.18850195e-01f, 3.60735022e-02f, 2.87320931e-02f, -2.26359572e-02f, -1.93254258e-02f,
  2.00359356e-02f, 1.10747173e-01f, 1.49684936e-01f, 7.34451786e-02f, -6.98741376e-02f, -5.52784279e-02f, -9.74496827e-02f, 1.61336511e-01f, 8.03323537e-02f, -1.69465635e-02f,
  4.32492606e-02f, -5.95578253e-02f, 9.39050540e-02f, 2.88200945e-01f, 3.30142602e-02f, 9.54622477e-02f, -6.10716827e-02f, 1.24219336e-01f, -1.41898334e-01f, 2.22203713e-02f,
  -6.74064875e-01f, 1.19644374e-01f, -3.39165598e-01f, -6.79754466e-02f, -6.56116307e-02f, 7.26386532e-02f, -1.04123287e-01f, -6.79202080e-02f, -1.01254769e-01f, 7.98046514e-02f,
  -2.99999006e-02f, -4.24916409e-02f, -2.45055601e-01f, 7.30988309e-02f, -2.54875481e-01f, -1.36205241e-01f, -3.63502622e-01f, -1.95699766e-01f, 4.05905880e-02f, -8.27248693e-02f,
  -2.39368770e-02f, -2.30331764e-01f, -4.18721795e-01f, -3.90695155e-01f, -2.68700927e-01f, -2.52526462e-01f, -3.70109320e-01f, -7.43579641e-02f, -3.68360668e-01f, -6.42535329e-01f,
  5.41761279e-01f, 1.90750211e-01f, 1.95246458e-01f, 2.11716965e-01f, 1.04968958e-02f, 1.11531377e-01f, 3.92510176e-01f, 3.46939206e-01f, 9.85007137e-02f, 2.02261046e-01f,
  -5.13599291e-02f, 8.72896314e-02f, 5.67530543e-02f, 8.89153555e-02f, 2.01619700e-01f, 2.26877466e-01f, 8.59960914e-02f, 1.37208462e-01f, 2.27700159e-01f, 1.26386225e-01f,
  1.48939297e-01f, 1.40015669e-02f, 1.56167164e-01f, 1.26322865e-01f, 2.47214548e-02f, 5.64415678e-02f, 1.65974423e-01f, 9.81751680e-02f, 1.43837616e-01f, 2.05402672e-01f,
  -1.39279038e-01f, 2.72021800e-01f, -1.59449875e-01f, -1.07962251e-01f, -2.07392111e-01f, -5.95498681e-02f, 3.59947910e-03f, -4.57529984e-02f, -1.12152033e-01f, 1.48835480e-02f,
  -1.95396319e-01f, -6.85021728e-02f, -8.47214684e-02f, 2.41137389e-02f, -3.91958058e-02f, -6.35405481e-02f, 1.20470263e-01f, 1.59226224e-01f, 2.30525322e-02f, 3.96483764e-02f,
  -1.23715691e-01f, -2.26219624e-01f, -1.38219431e-01f, 2.16984749e-02f, 2.50541359e-01f, -8.41808394e-02f, 2.18832195e-02f, 1.44541580e-02f, 3.86740565e-02f, 1.38499022e-01f,
  -5.88182509e-02f, -2.28576246e-03f, 1.32488564e-01f, 2.20505774e-01f, 3.45880538e-01f, 3.19312438e-02f, 2.60170549e-02f, 4.28310782e-02f, 1.38193682e-01f, -2.11485289e-03f,
  -8.91529247e-02f, 5.90641908e-02f, 1.53179601e-01f, -1.45340851e-02f, 1.05191721e-02f, -1.26363963e-01f, -1.52132273e-01f, -1.20481722e-01f, 6.57696649e-02f, -4.77965456e-03f,
  8.06143135e-02f, 6.83043376e-02f, -4.02981602e-02f, 1.13678947e-01f, -1.06818430e-01f, 2.78895367e-02f, 3.30466926e-02f, -1.73918739e-01f, -5.88451922e-02f, -4.46160771e-02f,
  -4.87139881e-01f, -2.82913521e-02f, 1.75463319e-01f, 4.58046682e-02f, -1.33149952e-01f, -3.24823707e-02f, 3.10106575e-02f, -1.43422514e-01f, 1.41447410e-02f, -5.49593307e-02f,
  -1.60652280e-01f, -8.50179568e-02f, 2.15439051e-02f, -3.85315903e-02f, -7.42648020e-02f, -1.02163628e-01f, -5.11234999e-02f, -2.58166604e-02f, 4.25790949e-03f, -1.35032728e-01f,
  -1.53287724e-01f, -1.59348458e-01f, -2.42703333e-01f, -1.70507133e-02f, -1.24617800e-01f, -1.92391410e-01f, -1.01512685e-01f, -1.67599022e-01f, -3.07166427e-02f, -1.35042414e-03f,
  -8.22914168e-02f, 6.11179233e-01f, 1.71295777e-01f, -3.81662130e-01f, -5.58815181e-01f, -4.15820330e-01f, -4.34337929e-03f, 2.31453821e-01f, -1.37959033e-01f, 1.64805427e-01f,
  -2.12559164e-01f, -3.67671400e-01f, -3.51849720e-02f, 3.02288514e-02f, 3.44042063e-01f, 5.67668855e-01f, 1.86225429e-01f, -3.49810719e-02f, -2.84718305e-01f, -2.81202406e-01f,
  -2.03206584e-01f, -2.89381057e-01f, -1.18431255e-01f, 6.93144128e-02f, 1.28927469e-01f, -3.52071859e-02f, 1.81787401e-01f, -1.80442274e-01f, 7.83126578e-02f, 3.44131291e-01f,
  2.89960474e-01f, -3.96428183e-02f, -9.79748741e-02f, -1.44864246e-01f, -2.31234226e-02f, 1.13515491e-02f, -9.52542275e-02f, -5.51653141e-03f, -1.36385009e-01f, 5.20724244e-02f,
  -1.91140339e-01f, -1.24650553e-01f, -1.84593201e-01f, -4.58948035e-03f, -1.31353855e-01f, -2.56604552e-02f, 5.95353357e-02f, 1.35961503e-01f, 2.95869894e-02f, 1.68225810e-01f,
  3.21825445e-02f, -2.75701046e-01f, 3.15943919e-03f, -1.52412197e-02f, 1.07980110e-01f, -2.44316176e-01f, 3.99654917e-02f, -6.88359328e-03f, 4.46938761e-02f, 2.27870941e-01f,
  6.38153404e-02f, 1.98806092e-01f, 5.17399516e-03f, -4.37671617e-02f, -7.36044198e-02f, -7.33572096e-02f, -7.42242411e-02f, -3.26152705e-02f, -8.44713300e-02f, -5.63079156e-02f,
  6.72213791e-04f, -7.53726587e-02f, -7.42164999e-02f, -6.64226189e-02f, -4.02875170e-02f, 2.89665759e-02f, -5.79033270e-02f, 1.20451167e-01f, 6.16603019e-03f, -1.21810861e-01f,
  -1.49336249e-01f, 5.73448204e-02f, -7.88934901e-02f, 1.08539738e-01f, -6.95043355e-02f, -2.81202085e-02f, -1.54595509e-01f, -7.29051083e-02f, -2.40588933e-02f, -4.58655087e-03f,
  9.99416783e-02f, -4.68407124e-01f, 1.41756013e-01f, 2.22268745e-01f, 5.48646264e-02f, 9.20507684e-02f, -9.05135125e-02f, -1.17418543e-01f, -1.28326222e-01f, -7.41173029e-02f,
  -3.09887249e-02f, -1.61885880e-02f, 1.33683398e-01f, 1.28209144e-01f, -1.46117404e-01f, -8.50917920e-02f, 9.07906219e-02f, 6.52687326e-02f, -1.83906988e-03f, 9.30838138e-02f,
  1.90670028e-01f, -3.97336408e-02f, -4.69465032e-02f, 9.17550623e-02f, 7.66576231e-02f, -1.68939218e-01f, 1.82169657e-02f, -6.50343746e-02f, -7.90415481e-02f, 1.84136033e-01f,
  7.07543552e-01f, -2.76293784e-01f, 2.38237709e-01f, 3.90415519e-01f, 2.17634156e-01f, 2.29597628e-01f, 2.95856874e-02f, 1.16364121e-01f, 1.96294323e-01f, 1.66609123e-01f,
  -2.61477865e-02f, -6.21248446e-02f, -9.36633050e-02f, -1.06145859e-01f, -2.64918059e-02f, -2.25976277e-02f, 9.06568691e-02f, 1.58697203e-01f, 2.60756761e-01f, 2.05168113e-01f,
  1.90719426e-01f, 1.92821726e-01f, 2.73388773e-01f, 7.50926062e-02f, 2.03416143e-02f, 1.09387256e-01f, -2.10948493e-02f, 1.38545990e-01f, 5.82867563e-02f, 1.49983406e-01f,
  6.12713993e-02f, -2.19866000e-02f, 2.56542116e-02f, -1.02752224e-01f, -3.11181997e-03f, -1.06495172e-01f, 3.25597115e-02f, 3.62324603e-02f, 5.21647409e-02f, 4.42869440e-02f,
  -1.30976826e-01f, -7.54983053e-02f, 2.36958526e-02f, -8.48465264e-02f, 3.90494466e-02f, -2.85279821e-03f, -9.93069932e-02f, -5.48101142e-02f, -1.56483471e-01f, -1.17720343e-01f,
  -8.83513615e-02f, 2.26072874e-03f, -5.99712320e-02f, -1.35567710e-01f, -1.09629788e-01f, 8.02615434e-02f, -5.90173341e-02f, -1.16578542e-01f, -1.44717246e-01f, 2.39336733e-02f,
  3.28303248e-01f, -3.11767124e-02f, 1.08572751e-01f, 1.80265367e-01f, 8.80486891e-02f, 1.35422975e-01f, 1.33291841e-01f, 4.12634909e-02f, 1.92954585e-01f, 1.69077083e-01f,
  -1.17872357e-02f, 6.51773214e-02f, 8.99095014e-02f, 2.44303167e-01f, 1.10380940e-01f, 2.28083745e-01f, 5.25585897e-02f, -8.31327662e-02f, 1.43276364e-01f, 1.76882818e-01f,
  2.79219776e-01f, 1.46986008e-01f, 1.54323846e-01f, -7.57950619e-02f, 1.41758889e-01f, -8.24592449e-03f, 1.49159238e-01f, 1.52156428e-02f, 6.90155402e-02f, 1.07169740e-01f,
  -3.02189976e-01f, -1.80957869e-01f, 3.30607928e-02f, -1.05978109e-01f, -2.03291397e-03f, -1.70345098e-01f, -3.31338756e-02f, -1.03638045e-01f, -7.74087161e-02f, -1.08544976e-01f,
  -1.15383759e-01f, 2.28501335e-02f, -5.42850494e-02f, -2.01258622e-02f, 1.81428656e-01f, 2.99818739e-02f, -9.17062387e-02f, 5.42617291e-02f, -1.75442129e-01f, -1.45557627e-01f,
  -1.44688144e-01f, 2.33831946e-02f, 1.02018965e-02f, 1.38054881e-02f, -1.44150006e-02f, 1.81329846e-01f, 3.77555215e-03f, 5.40895090e-02f, -7.84462318e-02f, 4.71633263e-02f,
  -1.96461543e-01f, 3.53616416e-01f, 2.55714267e-01f, 2.36169338e-01f, 7.35273510e-02f, -1.51594996e-01f, -1.01060271e-01f, -1.17786385e-01f, 2.31542811e-01f, 1.50278270e-01f,
  -2.21665546e-01f, -1.55887231e-01f, 1.22053705e-01f, -1.37694895e-01f, -2.50046730e-01f, 7.05801025e-02f, 2.78270155e-01f, -1.69645861e-01f, -5.95170975e-01f, -7.17624009e-01f,
  -1.83750913e-01f, -1.51075155e-01f, -1.80372983e-01f, -1.38930231e-01f, 5.08414745e-01f, 1.60625637e-01f, 3.65574121e-01f, 2.96993226e-01f, 4.91958149e-02f, 4.95492637e-01f,
  1.10631455e-02f, 4.11971509e-01f, -2.23831728e-01f, -2.15399221e-01f, -2.51464602e-02f, -1.76938325e-01f, -1.68132812e-01f, 3.27105343e-01f, -1.07036784e-01f, 2.59210430e-02f,
  7.87184164e-02f, -1.80312663e-01f, 2.49752805e-01f, -2.83347373e-03f, -9.35161188e-02f, -3.59075248e-01f, -6.09472357e-02f, -2.83039451e-01f, -6.46794885e-02f, -1.83033884e-01f,
  -2.02862650e-01f, -8.71295780e-02f, 9.51934382e-02f, 1.25151694e-01f, 1.84238419e-01f, -1.99659079e-01f, 1.60481170e-01f, -2.52333973e-02f, 2.68907612e-03f, 2.62082249e-01f,
  7.54233524e-02f, 6.26184940e-02f, 3.48543674e-02f, 2.16076955e-01f, -1.65038571e-01f, 1.28270864e-01f, 2.31273100e-01f, -7.87659362e-02f, 6.35781288e-02f, 5.40292785e-02f,
  9.21099819e-03f, -1.36771142e-01f, -1.26555860e-01f, 1.06972829e-01f, 1.74890324e-01f, 1.86541334e-01f, 3.24496552e-02f, -1.94643870e-01f, -6.40031844e-02f, 1.20751284e-01f,
  -3.06797754e-02f, -8.08058679e-02f, -2.04277039e-02f, -8.89135525e-02f, 1.01730853e-01f, 8.12177062e-02f, -7.71417543e-02f, -8.19447711e-02f, -4.31948081e-02f, 6.34645373e-02f,
  -1.89708188e-01f, -3.93815726e-01f, 1.06030904e-01f, -2.02669635e-01f, 2.73080498e-01f, -4.37779315e-02f, 1.68941930e-01f, -1.60502002e-01f, -2.17274632e-02f, -2.73207247e-01f,
  -2.15756997e-01f, -1.43264309e-01f, 3.88261050e-01f, 2.34254412e-02f, -3.02220076e-01f, -9.42182839e-02f, -2.72556156e-01f, -2.38102794e-01f, -2.03628823e-01f, -4.76801619e-02f,
  6.05583563e-03f, -4.53709453e-01f, -3.41143459e-01f, -1.16825901e-01f, 9.49444696e-02f, -3.01948488e-01f, -7.88010806e-02f, -1.66719660e-01f, -2.98025280e-01f, -2.62327790e-01f,
  -6.23149931e-01f, 3.40702862e-01f, 3.07254106e-01f, -4.07411009e-01f, -3.09830196e-02f, 3.78761292e-01f, 6.18072033e-01f, 5.70070781e-02f, -3.60763937e-01f, 1.79288909e-01f,
  9.78157073e-02f, -5.25900841e-01f, -3.42141926e-01f, -3.14745069e-01f, -8.96935388e-02f, 5.02566814e-01f, 2.68797159e-01f, -2.69381821e-01f, -6.45461857e-01f, -4.16310072e-01f,
  -2.39795893e-01f, -3.64489555e-01f, -3.78271908e-01f, -3.26722980e-01f, -2.06976458e-01f, -4.85093743e-01f, 8.32232982e-02f, 3.32822725e-02f, 2.67542839e-01f, -9.07155573e-02f,
  9.12562013e-02f, 2.46640146e-02f, -2.09178701e-01f, -2.56802320e-01f, -4.46062163e-03f, 7.20840245e-02f, -4.92666475e-02f, 8.12026560e-02f, -3.56909521e-02f, 8.34434628e-02f,
  4.60123941e-02f, 3.93744707e-02f, 1.03224546e-01f, -3.00812293e-02f, -2.47082394e-02f, -1.42971212e-02f, 8.15150440e-02f, -6.42840862e-02f, 3.08597293e-02f, 3.12790245e-01f,
  2.19810247e-01f, 1.05320312e-01f, 1.12438194e-01f, 1.60986319e-01f, 1.34914532e-01f, -1.61444973e-02f, 1.26333326e-01f, 3.49754542e-02f, 1.29153505e-01f, -9.60922539e-02f,
  7.47025087e-02f, -6.99998289e-02f, -8.34228098e-02f, -1.32333741e-01f, -1.79360360e-02f, 3.58619615e-02f, -5.01011685e-02f, 1.05315551e-01f, 1.01854429e-01f, -9.39053521e-02f,
  6.58272505e-02f, 1.59217611e-01f, 3.51963155e-02f, 9.16672051e-02f, -2.08203178e-02f, 5.95723912e-02f, 2.35864520e-01f, 1.08446889e-01f, 1.46807581e-01f, -3.67663614e-02f,
  -1.99105646e-02f, 3.43911089e-02f, 9.86422449e-02f, 6.27030656e-02f, 2.30549246e-01f, 7.00603276e-02f, 9.61925313e-02f, -2.38083172e-04f, 7.79730966e-03f, 9.32301655e-02f,
  -5.58256209e-01f, 3.22738856e-01f, -1.92298308e-01f, -1.06407605e-01f, 7.89564773e-02f, 1.02180190e-01f, -9.49398205e-02f, 1.59990266e-02f, -2.74684187e-02f, 4.11870629e-02f,
  1.65596962e-01f, -8.23190212e-02f, 1.61920756e-01f, -5.17884642e-02f, -2.18979999e-01f, -6.27680495e-02f, 7.50152394e-02f, -8.41286406e-02f, 2.23261803e-01f, 1.12895146e-01f,
  2.71520883e-01f, 9.19468999e-02f, -7.22997859e-02f, -5.79326227e-02f, 4.45274785e-02f, -2.10846558e-01f, -1.06428787e-02f, -7.24864304e-02f, 3.02662980e-02f, 6.52676856e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  4.50944960e-01f, 4.64248776e-01f, 4.55433398e-01f, 2.05183536e-01f, 4.92340505e-01f, 3.96959186e-01f, 4.86679822e-01f, 1.02545274e-02f, 4.26086187e-01f, 3.81670743e-01f,
  1.44178733e-01f, 3.19391400e-01f, 2.09587693e-01f, 2.72389144e-01f, 6.38754904e-01f, 3.43322605e-01f, 7.26927280e-01f, 6.57655656e-01f, 3.72834653e-01f, 1.05539337e-01f,
  5.90399802e-01f, 2.60857344e-01f, 5.89486599e-01f, 4.07270551e-01f, 3.74713480e-01f, 4.10688758e-01f, 3.38554114e-01f, 2.17163399e-01f, 6.61977410e-01f, 5.26611209e-01f,
  3.51873726e-01f, 4.12418768e-02f, 2.47177869e-01f, 5.70503116e-01f, 2.67827392e-01f, 5.78983486e-01f, 2.78398722e-01f, 3.65400255e-01f, 3.54419798e-01f, 5.11721134e-01f,
  3.93683642e-01f, 3.82715225e-01f, 1.74351931e-01f, 4.21260506e-01f, 4.29049045e-01f, 3.88646364e-01f, 5.66041112e-01f, 2.65460312e-01f, 6.88932300e-01f, 4.75191355e-01f,
  3.00834864e-01f, 5.05736828e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -4.04543951e-02f, -2.71468341e-01f, -1.20988935e-01f, -2.21062191e-02f, 4.99095675e-03f, 1.50156207e-02f, -2.70064455e-02f, 2.07095351e-02f, -3.28437239e-02f, 4.79039690e-03f,
  8.04501399e-02f, -1.82682961e-01f, -8.68242085e-02f, -5.25280684e-02f, -5.54345129e-03f, -1.41324744e-01f, -3.60879213e-01f, -1.44574672e-01f, 1.51711285e-01f, -1.27723992e-01f,
  2.87585426e-02f, -1.05457917e-01f, -2.00070471e-01f, -2.82622706e-02f, -3.73010524e-02f, 1.85991619e-02f, -1.60585210e-01f, -1.35730267e-01f, -2.12918594e-01f, -3.19292694e-02f,
  2.46785302e-02f, -2.58685797e-02f, -2.22272560e-01f, -2.71778464e-01f, -1.91962346e-01f, -1.24530718e-01f, -2.40453973e-01f, -3.49260047e-02f, -6.06876612e-02f, -3.08451261e-02f,
  1.53773576e-01f, -1.66187346e-01f, 2.24683419e-01f, -1.61246479e-01f, -1.43400341e-01f, 2.99924195e-01f, -2.46343240e-02f, 7.18420446e-02f, 4.89381760e-01f, -1.93032473e-01f,
  1.26886498e-02f, 7.41140917e-03f, 7.71621019e-02f, 5.74924797e-02f, -1.89350858e-01f, 7.27408901e-02f, 8.86246786e-02f, 6.87457696e-02f, 4.65167873e-02f, 6.32152632e-02f,
  -3.23622227e-01f, -3.13097417e-01f, 1.41697973e-01f, -1.37059912e-01f, -1.81111440e-01f, -1.24606222e-01f, 1.68295547e-01f, -2.99629569e-01f, 1.77434888e-02f, -1.00068279e-01f,
  -8.55376273e-02f, 4.18512374e-02f, 1.08712271e-01f, 4.21307892e-01f, 4.75804955e-02f, 3.28530699e-01f, 2.48131976e-01f, 2.23806426e-01f, -3.46222103e-01f, 1.56013086e-01f,
  -5.70230223e-02f, -3.47898215e-01f, 8.18102881e-02f, 1.18025877e-01f, 2.55434588e-02f, 2.24230021e-01f, -4.02629554e-01f, -2.50572562e-01f, 2.39462152e-01f, -2.09586054e-01f,
  -3.35110188e-01f, 3.71412113e-02f, 2.05832198e-01f, -6.01147115e-01f, -1.30802825e-01f, -3.48517179e-01f, -4.18013662e-01f, 2.92327076e-01f, -5.72636068e-01f, 3.11358362e-01f,
  -9.38142538e-02f, -5.55069029e-01f, -6.00451410e-01f, 1.78439319e-01f, -3.04591566e-01f, 7.58241937e-02f, 2.07934454e-01f, 2.49374837e-01f, 3.54535401e-01f, -1.64284959e-01f,
  -1.98428020e-01f, -3.88043314e-01f, 3.82450312e-01f, 3.12668145e-01f, -1.27497613e-01f, 4.75353599e-01f, -5.83218373e-02f, -5.10926723e-01f, -3.27074826e-01f, -2.78228018e-02f,
  -6.16226494e-01f, -1.30192995e-01f, 2.64388323e-01f, -1.59517020e-01f, -3.65970463e-01f, -4.02692288e-01f, -9.17904496e-01f, -5.13670564e-01f, 7.38075674e-02f, 1.02253761e-02f,
  -1.01536900e-01f, -1.15021907e-01f, 4.46865335e-02f, -5.18891662e-02f, 1.06156401e-01f, 5.53761348e-02f, 1.17954627e-01f, -2.07124092e-02f, -5.43227307e-02f, -6.53014779e-02f,
  -5.19787967e-02f, 2.09968835e-02f, 6.41864836e-02f, -4.92973849e-02f, -9.69850644e-03f, 5.70004359e-02f, 1.98097117e-02f, 1.14968985e-01f, -6.34030253e-02f, -1.38255283e-02f,
  -6.28377572e-02f, -3.49540524e-02f, 6.16830215e-03f, 2.60122210e-01f, -3.76313254e-02f, 3.33910435e-02f, -6.01914451e-02f, -5.77110164e-02f, -6.67576045e-02f, -1.35347053e-01f,
  8.93237293e-02f, -4.41919714e-02f, -8.08388591e-02f, -8.33615139e-02f, -2.14428365e-01f, 9.25640166e-02f, -1.11734018e-01f, -2.12454706e-01f, 2.91322649e-01f, -4.74134028e-01f,
  7.94667080e-02f, -1.22768261e-01f, 2.98028022e-01f, 1.29582256e-01f, -2.83830464e-01f, 1.35238916e-01f, 2.66644448e-01f, -2.51587063e-01f, 1.07959256e-01f, 2.70962209e-01f,
  4.83894795e-02f, -2.11955965e-01f, 1.13008417e-01f, -1.99173629e-01f, 2.20332533e-01f, -1.78468868e-01f, -6.85629249e-02f, 4.64196242e-02f, 1.36793360e-01f, -2.95269996e-01f,
  2.63225824e-01f, -7.18216971e-03f, -7.89419189e-03f, 9.29214135e-02f, 1.63323104e-01f, -8.73489305e-02f, -1.15074307e-01f, 1.61410421e-02f, -7.38552287e-02f, 9.58688483e-02f,
  -2.89810807e-01f, 5.52049764e-02f, 1.02103399e-02f, -2.05840185e-01f, -3.00231665e-01f, 7.88171962e-02f, -2.66893655e-01f, -2.26948991e-01f, -4.94762778e-01f, 1.13835409e-01f,
  2.94349074e-01f, 5.59960678e-03f, -7.46201336e-01f, -8.92909229e-01f, -5.60391657e-02f, -7.48478532e-01f, -6.64024949e-01f, 8.62699524e-02f, -4.49165106e-01f, 6.25438094e-01f,
  7.67608881e-01f, -4.05862391e-01f, 3.85230392e-01f, -4.95615490e-02f, -5.93656778e-01f, 3.36378962e-01f, -8.13614488e-01f, 1.93053901e-01f, -1.19000040e-02f, 6.41490147e-02f,
  8.16563010e-01f, 1.23637199e-01f, 9.81207937e-02f, 2.23760456e-01f, 3.52419615e-01f, 2.07337037e-01f, -1.13428898e-01f, -3.02769065e-01f, 4.05608058e-01f, -1.01085842e+00f,
  -4.12757576e-01f, 3.89009923e-01f, 6.74957186e-02f, -6.60969079e-01f, -4.28106189e-01f, -4.08136189e-01f, -3.65677401e-02f, 2.11624309e-01f, 1.49358064e-02f, 4.03466254e-01f,
  -3.42684716e-01f, 3.95197719e-01f, -3.75869453e-01f, 1.58894807e-01f, -3.10520887e-01f, -3.28311205e-01f, 7.94712901e-02f, 1.80745780e-01f, 2.50512958e-01f, 5.82360551e-02f,
  8.45947638e-02f, -6.68684021e-02f, 8.12059417e-02f, 2.64701396e-01f, 5.08247614e-02f, 1.31789461e-01f, 5.66280559e-02f, 1.75554916e-01f, 1.34342045e-01f, -8.35738033e-02f,
  -7.05549866e-02f, -9.47618037e-02f, -3.79260629e-02f, 1.53888404e-01f, 1.24646097e-01f, -7.92553555e-03f, 9.00271460e-02f, -2.23655552e-02f, 7.20882863e-02f, 2.65808441e-02f,
  3.07763275e-03f, 5.54017387e-02f, -7.29398951e-02f, -1.02561809e-01f, 6.87812120e-02f, 5.45495264e-02f, 8.60597100e-03f, 9.88535956e-02f, 1.21608943e-01f, 5.07040955e-02f,
  -4.76075336e-02f, 1.98766693e-01f, 2.35623449e-01f, 5.85039742e-02f, 6.05546944e-02f, -1.90505773e-01f, 1.08452654e-02f, -2.24364847e-01f, -2.19560400e-01f, -3.15465897e-01f,
  4.27476794e-01f, -3.24224234e-01f, -3.30551177e-01f, 1.70800194e-01f, -1.96782947e-01f, -3.42496157e-01f, 6.70063198e-02f, 3.02935634e-02f, 7.38569498e-02f, -2.07397625e-01f,
  -2.67293513e-01f, 1.32993534e-01f, 5.95223671e-03f, 3.42137456e-01f, -2.04118267e-01f, -2.58363277e-01f, -3.94940302e-02f, -1.85444728e-01f, -7.71316886e-02f, 1.38613313e-01f,
  -1.17557973e-01f, 1.41058534e-01f, 4.18249406e-02f, -8.37404802e-02f, 2.32594422e-04f, -3.21908057e-01f, -6.25157952e-02f, 3.02446187e-01f, 1.73732847e-01f, -8.18748474e-02f,
  4.28514294e-02f, -2.75146868e-02f, 3.92180294e-01f, -3.53294343e-01f, -7.50703439e-02f, 2.97958087e-02f, -4.55990314e-01f, -4.11495298e-01f, -3.52928191e-01f, 1.79592043e-01f,
  -5.36368228e-02f, 1.84400111e-01f, -2.66566686e-03f, 2.73896426e-01f, -2.74250656e-01f, -3.38849336e-01f, 1.20511718e-01f, 7.85149872e-01f, 4.28643972e-01f, -5.11284769e-01f,
  -3.45890045e-01f, -2.89012432e-01f, -3.15707505e-01f, 5.05703986e-01f, 1.86659127e-01f, 2.23532081e-01f, 1.09729983e-01f, -3.99873912e-01f, 1.65885463e-01f, -4.27082479e-01f,
  1.08204139e-02f, -5.15609682e-02f, -5.69115877e-01f, -4.10618223e-02f, -6.67669773e-02f, 9.42525640e-02f, -1.55743912e-01f, -7.32270852e-02f, -9.42198709e-02f, -1.63307205e-01f,
  1.33412361e-01f, -5.28135419e-01f, -3.61777097e-01f, -3.65991682e-01f, -3.99956405e-01f, -3.80750299e-01f, 1.88689768e-01f, 1.89865857e-01f, 6.11884475e-01f, -3.38135958e-01f,
  -1.46864504e-01f, -2.68055916e-01f, -2.45199859e-01f, -4.50675100e-01f, -7.98616409e-02f, -3.02306544e-02f, -1.68214545e-01f, -1.78218871e-01f, 1.18971236e-01f, -9.60266814e-02f,
  -2.86292166e-01f, -3.53593230e-02f, -1.17883489e-01f, -3.85723226e-02f, 2.28660569e-01f, 6.00454807e-02f, -1.66659746e-02f, 2.19093766e-02f, -7.96287879e-02f, -2.34838221e-02f,
  -1.11791328e-01f, 1.69958636e-01f, -9.38695669e-02f, 3.62974801e-03f, -5.67483082e-02f, -6.46140054e-02f, 2.83708535e-02f, 2.79356353e-03f, -8.26398432e-02f, -5.27160950e-02f,
  -4.39676866e-02f, 8.62175375e-02f, -2.20799390e-02f, -7.64770210e-02f, 8.25113133e-02f, -8.14493224e-02f, 2.30048776e-01f, -8.61649290e-02f, -2.60432214e-01f, -1.73156261e-01f,
  1.97530732e-01f, 2.55871210e-02f, -1.96842119e-01f, 1.62343979e-01f, 1.28906995e-01f, 4.46035177e-01f, -2.59828925e-01f, 5.07459998e-01f, 2.49118343e-01f, 2.21836254e-01f,
  1.51462555e-01f, -9.11728963e-02f, 1.17635809e-01f, -1.83492064e-01f, -5.61535284e-02f, -1.57027692e-01f, -1.24823064e-01f, 7.94889852e-02f, -3.23262177e-02f, 7.87965879e-02f,
  4.61635627e-02f, 9.67171639e-02f, -2.43742913e-02f, 1.01399399e-01f, -1.34311870e-01f, 1.80357337e-01f, -1.27217740e-01f, -4.43096384e-02f, 3.65542322e-02f, 2.22461209e-01f,
  -7.87055552e-01f, 3.47333938e-01f, 1.79788902e-01f, -1.08897850e-01f, 1.99760254e-02f, 9.22451615e-02f, -7.51798553e-03f, -6.97574794e-01f, -1.58838093e-01f, -2.43057922e-01f,
  -8.27388391e-02f, 1.03699133e-01f, -5.94442189e-01f, -3.85866165e-02f, -5.78370935e-04f, -1.77943349e-01f, -2.22284213e-01f, -4.18507367e-01f, 3.72198999e-01f, -2.40839440e-02f,
  -6.33458674e-01f, 1.94500044e-01f, 1.44709557e-01f, -1.62890092e-01f, -2.40071431e-01f, -5.17551191e-02f, -1.12784398e+00f, -3.21199656e-01f, -4.46553618e-01f, -3.28182250e-01f,
  4.87530529e-01f, 2.06536464e-02f, 2.79867768e-01f, 5.48387706e-01f, -4.79835570e-01f, 1.11611173e-01f, -5.90381622e-01f, -6.39625490e-02f, -7.93716371e-01f, -3.24990541e-01f,
  -8.40807021e-01f, 1.68627739e-01f, 2.64861375e-01f, -2.60133058e-01f, -2.32988492e-01f, 4.94946688e-01f, 8.21857005e-02f, 1.00234434e-01f, -2.01301709e-01f, -4.08403069e-01f,
  -6.90408230e-01f, 6.30581915e-01f, -6.63626552e-01f, 4.25403029e-01f, 7.14300275e-02f, 2.41877101e-02f, -2.17784807e-01f, -3.19823712e-01f, 1.85481429e-01f, -4.32026118e-01f,
  -2.71374673e-01f, 7.07189798e-01f, 9.17281881e-02f, -2.42691755e-01f, 1.41322628e-01f, 6.04075566e-02f, 4.18181121e-02f, 1.57771260e-01f, -8.15706700e-02f, 2.56709848e-02f,
  -1.77910641e-01f, -1.43220797e-01f, -4.33218002e-01f, -3.63637172e-02f, -1.48249334e-02f, -2.04688367e-02f, 1.02915645e-01f, -2.55692881e-02f, 6.09725788e-02f, -1.96997643e-01f,
  -1.24110423e-01f, 6.30006120e-02f, -2.13333443e-01f, -1.11524500e-01f, 4.85481210e-02f, -1.09228738e-01f, 4.22855727e-02f, 1.96007993e-02f, 8.50730836e-02f, -5.24299182e-02f,
  2.06478581e-01f, -3.08613386e-02f, -6.49180859e-02f, -1.03838757e-01f, -2.82127500e-01f, 7.21777827e-02f, 1.82721540e-01f, 2.56348461e-01f, 4.43616882e-02f, 1.33912072e-01f,
  2.28916898e-01f, 6.85456991e-02f, -4.71572531e-03f, 1.85237110e-01f, 1.47688627e-01f, -3.24167788e-01f, 6.89607719e-03f, -3.91110957e-01f, 1.23098210e-01f, -5.46337105e-02f,
  -3.85093778e-01f, -3.73724699e-02f, 3.27270888e-02f, -1.00725800e-01f, -1.93300903e-01f, 8.81782994e-02f, -4.39969674e-02f, 1.73259620e-02f, -1.95602268e-01f, 1.15320966e-01f,
  2.89865464e-01f, -1.83039438e-02f, 1.96843714e-01f, 1.09047800e-01f, -2.76616439e-02f, 2.12584004e-01f, -3.07599660e-02f, -1.31791070e-01f, 2.38053337e-01f, -8.01925659e-02f,
  1.35724530e-01f, 6.67287633e-02f, -7.13240132e-02f, 1.37842432e-01f, -4.56927985e-01f, 1.67302474e-01f, 1.96875602e-01f, -1.39194563e-01f, 1.01666547e-01f, -4.14036512e-01f,
  1.60672486e-01f, -1.90071598e-01f, 4.53312725e-01f, 4.60140705e-02f, 1.77083358e-01f, 8.76381472e-02f, 1.94883451e-01f, -2.45998815e-01f, 6.03339188e-02f, 5.15389219e-02f,
  2.63884097e-01f, 1.24973588e-01f, 4.08937931e-02f, -8.96490067e-02f, -3.08276594e-01f, -1.95406124e-01f, -5.88969052e-01f, -3.13092768e-03f, 3.10216010e-01f, 1.12299770e-01f,
  4.38423574e-01f, -7.62597263e-01f, -7.37823963e-01f, 1.29581057e-02f, 2.92017639e-01f, 2.13385135e-01f, -2.85422623e-01f, -1.59061655e-01f, 5.43797128e-02f, -1.24010429e-01f,
  -3.60536903e-01f, -4.09623355e-01f, -7.78973624e-02f, -1.80817544e-01f, -1.41401783e-01f, -4.35574412e-01f, -6.44381717e-02f, -3.55284691e-01f, 4.20657337e-01f, -1.38285771e-01f,
  1.47316054e-01f, -3.88507426e-01f, -6.30499870e-02f, -7.09374323e-02f, -3.53074521e-01f, -1.46955922e-01f, 1.26014113e-01f, -1.85452744e-01f, 6.11088872e-01f, 1.85809270e-01f,
  2.55104136e-02f, 9.90227386e-02f, 2.09797978e-01f, 6.46686032e-02f, -1.57805040e-01f, 7.17455894e-03f, 2.86271758e-02f, 7.12210461e-02f, 1.16109475e-01f, 1.80624947e-01f,
  2.05878496e-01f, 1.81108087e-01f, -6.21550679e-02f, 2.36580297e-02f, -1.35481777e-03f, 6.46736519e-03f, 9.51488763e-02f, 2.90289402e-01f, 2.47245222e-01f, 8.52682665e-02f,
  1.46953583e-01f, 7.36649930e-02f, 1.69592530e-01f, 1.74198121e-01f, 1.67451173e-01f, -3.99443246e-02f, 6.58862516e-02f, 8.72752815e-02f, 1.73675463e-01f, 3.47263329e-02f,
  4.47016433e-02f, 1.87891260e-01f, 1.41991198e-01f, 4.58750203e-02f, 3.03576618e-01f, 1.90331116e-02f, 7.58465827e-02f, 2.36646030e-02f, -1.91875160e-01f, 3.75433505e-01f,
  -1.29568696e-01f, -2.41985574e-01f, 3.61098975e-01f, 1.16817780e-01f, -3.84888053e-01f, 1.82217762e-01f, 9.72402319e-02f, 1.13088220e-01f, -7.43397372e-03f, 1.72046069e-02f,
  4.02181655e-01f, -1.22101501e-01f, -2.64816523e-01f, 1.18942559e-01f, 1.56127244e-01f, 1.41459376e-01f, -9.77105722e-02f, -1.14601739e-01f, -2.15782046e-01f, -1.71088964e-01f,
  -7.16846585e-02f, 6.33928031e-02f, -2.04006713e-02f, -7.32022226e-02f, 1.77035585e-01f, -2.64362991e-01f, 2.89463103e-01f, 3.49633358e-02f, 7.93820992e-02f, 5.40030561e-02f,
  8.36509839e-02f, -4.70145419e-02f, -9.60421413e-02f, 3.31335187e-01f, 1.17876753e-01f, -1.29926950e-01f, 1.82300106e-01f, 1.38202280e-01f, 2.15603355e-02f, -4.70254987e-01f,
  8.49550590e-02f, -9.30006430e-02f, 3.20330739e-01f, 5.28690852e-02f, -6.44536853e-01f, 5.21622658e-01f, -2.51559436e-01f, -3.01840067e-01f, -3.75836283e-01f, 8.80724639e-02f,
  -8.18509638e-01f, -6.59288585e-01f, 1.05530508e-01f, 8.55776250e-01f, 3.94885018e-02f, 3.17886584e-02f, -5.89268766e-02f, -5.42978942e-01f, -6.70028985e-01f, -6.95444405e-01f,
  -3.47670406e-01f, 3.30237389e-01f, -2.94359416e-01f, -1.19352363e-01f, 2.86958545e-01f, 1.10224359e-01f, 4.99491692e-01f, 3.10853287e-03f, -4.76872951e-01f, -3.94309074e-01f,
  -5.06266177e-01f, 4.05331701e-01f, 4.23820913e-02f, -1.87881485e-01f, 8.32203589e-03f, 7.06673443e-01f, 4.34785247e-01f, -5.91927946e-01f, 1.74026504e-01f, 4.10367370e-01f,
  -1.30047679e-01f, -1.99559495e-01f, -8.64052236e-01f, -1.19383544e-01f, 7.15998188e-02f, -2.33319844e-03f, -2.58162051e-01f, -1.62677407e-01f, -1.66930392e-01f, -5.92101775e-02f,
  -2.39148498e-01f, 1.57186151e-01f, 9.36873704e-02f, 2.55187461e-03f, 3.14691961e-02f, -9.08254236e-02f, -5.17350563e-04f, 7.51874670e-02f, 7.30965957e-02f, -1.43115699e-01f,
  4.84637357e-02f, 3.57841440e-02f, -1.40413210e-01f, 2.02694032e-02f, -7.97685818e-04f, 7.84219876e-02f, -1.03407159e-01f, 7.13646486e-02f, 3.05945892e-02f, 7.48280585e-02f,
  6.39707893e-02f, -3.56581286e-02f, 1.77931920e-01f, 7.63626844e-02f, -9.00826044e-03f, 9.03010145e-02f, 5.06338216e-02f, 9.79661755e-03f, 1.04485527e-01f, 1.07896425e-01f,
  1.64568335e-01f, 2.56467819e-01f, -3.40990990e-01f, -2.22254992e-01f, 4.52884994e-02f, -9.00604725e-02f, 3.03524762e-01f, -1.94845095e-01f, -2.28969932e-01f, -4.11932915e-01f,
  -2.32152954e-01f, -2.69405723e-01f, -3.26283008e-01f, -1.33793518e-01f, -1.47906139e-01f, -2.09220424e-01f, -1.62449211e-01f, 1.18099719e-01f, -2.67030537e-01f, -2.17246953e-02f,
  1.88498273e-01f, -1.14243843e-01f, 1.18744738e-01f, 1.46346405e-01f, -1.54854670e-01f, -5.86151034e-02f, 2.76919931e-01f, -2.99033582e-01f, 7.49811456e-02f, -9.93623063e-02f,
  2.83395946e-02f, -1.46794885e-01f, 2.94541549e-02f, 2.94356402e-02f, 5.48391998e-01f, 1.26621068e-01f, 5.78981824e-02f, 1.24895148e-01f, 2.47062325e-01f, 2.90545747e-02f,
  2.24836767e-01f, 3.92434329e-01f, -1.92895502e-01f, 7.61945546e-02f, -1.48927510e-01f, -4.39056903e-01f, -3.71048301e-01f, -5.42174637e-01f, -3.23331416e-01f, -5.24820805e-01f,
  -5.61855555e-01f, 1.77507177e-01f, -7.35616148e-01f, -9.23047900e-01f, -1.21897988e-01f, -6.80589795e-01f, -5.15157104e-01f, 2.44321167e-01f, 3.55031013e-01f, -4.94684041e-01f,
  1.82251260e-01f, 6.87304556e-01f, 1.71803832e-01f, 2.27802351e-01f, -3.16398799e-01f, -4.21192497e-01f, 5.25478303e-01f, -2.67566264e-01f, 2.65698373e-01f, -2.64173448e-01f,
  -2.83918917e-01f, -4.01819140e-01f, -7.69157009e-03f, -2.10027069e-01f, -4.38906491e-01f, -2.10614473e-01f, -2.41715208e-01f, 3.83512050e-01f, -2.35708967e-01f, -1.82980359e-01f,
  -8.42945933e-01f, -1.40510738e-01f, -5.82635581e-01f, -2.19975635e-01f, -3.24930310e-01f, -3.91535878e-01f, -3.46483499e-01f, -3.47597182e-01f, 5.65088466e-02f, -8.88196900e-02f,
  7.27668405e-01f, 3.27289015e-01f, 7.02653408e-01f, 1.30907506e-01f, 1.87920928e-01f, -5.53133368e-01f, -4.42458987e-02f, 1.42541766e-01f, -8.83808956e-02f, 4.46556062e-02f,
  -1.91591576e-01f, -9.59922671e-02f, 4.68392260e-02f, 7.36975744e-02f, 2.72121094e-03f, -3.56527045e-02f, -2.36833632e-01f, -1.30259216e-01f, 5.01125343e-02f, -8.83327350e-02f,
  1.09002497e-02f, 3.41224074e-02f, -1.26930177e-01f, -4.91051422e-03f, -1.10879906e-01f, -7.23479614e-02f, -1.32523909e-01f, -2.07192406e-01f, 1.05937989e-02f, 1.44092906e-02f,
  -1.59447238e-01f, -2.05697358e-01f, -6.69672564e-02f, -5.60222901e-02f, -4.19516474e-01f, -2.51598895e-01f, -9.41683501e-02f, -5.90787306e-02f, 8.71533155e-02f, -4.26075794e-02f,
  -1.05390046e-02f, -2.57332981e-01f, -1.20938651e-01f, 4.85320054e-02f, -1.53830767e-01f, 2.63681740e-01f, -1.14923082e-02f, 2.65439838e-01f, 2.02646211e-01f, 2.39617735e-01f,
  -1.38014212e-01f, 1.38134897e-01f, 2.35104203e-01f, 5.86232729e-02f, -7.49127865e-02f, 4.08620536e-02f, 1.03152826e-01f, -2.23588198e-01f, 1.94884613e-01f, 1.12759098e-02f,
  -2.10825339e-01f, 1.25073949e-02f, -6.97614625e-02f, 1.09355755e-01f, -1.75985232e-01f, 1.71031117e-01f, -4.17866856e-02f, 1.32149562e-01f, -1.97536811e-01f, -2.13439897e-01f,
  5.72050810e-02f, -3.11213266e-02f, -4.29520935e-01f, 1.45516098e-01f, -1.66878700e-02f, 9.57799479e-02f, -4.52948734e-02f, -5.75556494e-02f, 4.65174615e-02f, -1.07579090e-01f,
  -1.47393897e-01f, 4.42013144e-02f, -8.67011622e-02f, -3.64054501e-01f, 1.44285411e-01f, -2.79009547e-02f, -2.96709687e-01f, 2.23374069e-01f, -2.57294208e-01f, -3.37051749e-02f,
  3.73346716e-01f, 4.81710941e-01f, 2.41462022e-01f, 3.39125425e-01f, -2.56466657e-01f, -1.59933776e-01f, -3.58340710e-01f, -3.23154002e-01f, -7.40079224e-01f, -1.60759315e-01f,
  -3.30706574e-02f, 1.37413412e-01f, -3.38436663e-01f, -1.65516078e-01f, -7.40051985e-01f, 3.99706185e-01f, 2.87174821e-01f, -3.98691863e-01f, -3.59558493e-01f, -2.76780546e-01f,
  -2.77922392e-01f, -1.81319714e-01f, -7.67900795e-02f, -3.93772006e-01f, -1.37605086e-01f, -1.56305060e-01f, -4.34738278e-01f, 5.43556392e-01f, -3.34805906e-01f, -2.81218410e-01f,
  -8.78267139e-02f, -4.38226938e-01f, -2.73818880e-01f, 4.00229901e-01f, 9.89878327e-02f, -5.07970572e-01f, -5.19080497e-02f, -2.44579524e-01f, -5.46442688e-01f, -9.62807983e-02f,
  2.60755509e-01f, -3.17646354e-01f, 2.92092085e-01f, -1.34359643e-01f, 1.36163414e-01f, -1.35379136e-01f, 2.09917352e-01f, 5.44459634e-02f, 1.41093805e-01f, 2.19785050e-02f,
  -3.12466957e-02f, -1.38829276e-01f, -2.85156518e-01f, 1.86182428e-02f, -1.10228658e-01f, 1.22922204e-01f, -6.89165061e-03f, 2.47760713e-02f, 2.16402009e-01f, 8.09754431e-02f,
  1.40903264e-01f, -1.85052618e-01f, -1.20824091e-01f, 7.06320331e-02f, 1.09152913e-01f, -1.39526978e-01f, 8.57796520e-02f, 5.30549232e-03f, 1.89788997e-01f, 3.62045616e-02f,
  4.19756845e-02f, 5.52628525e-02f, 5.25203981e-02f, -3.98022495e-02f, 2.01117992e-02f, -1.50203854e-01f, -1.42943949e-01f, -4.84118797e-03f, -1.31465327e-02f, 2.98868734e-02f,
  4.04004678e-02f, 2.18128487e-01f, -8.96996483e-02f, -2.32584119e-01f, 5.28107658e-02f, 4.90065813e-01f, -1.31711990e-01f, 3.37470740e-01f, -3.62886637e-01f, 9.31253433e-02f,
  -2.03632042e-01f, 1.62146077e-01f, 1.18608303e-01f, 1.32340521e-01f, -4.58968252e-01f, 7.84704611e-02f, 3.34899604e-01f, 5.75613156e-02f, 2.50033915e-01f, -2.49994487e-01f,
  1.70055792e-01f, -1.12954125e-01f, -1.94079116e-01f, 3.81762028e-01f, -4.57491666e-01f, -3.63390326e-01f, -3.87401842e-02f, 2.75031418e-01f, 9.36640203e-02f, -6.15911521e-02f,
  -4.49774802e-01f, -2.66316265e-01f, -2.12995037e-01f, 6.27381727e-02f, 3.58197808e-01f, -3.15420240e-01f, 1.54089496e-01f, -4.42876846e-01f, -8.64586234e-02f, -2.16387268e-02f,
  -3.26020092e-01f, 6.34239554e-01f, 2.10152552e-01f, 1.32502202e-04f, -3.22126150e-01f, 1.41711801e-01f, -5.25413990e-01f, -1.95817322e-01f, 1.66568847e-03f, -5.31994775e-02f,
  -7.87488371e-02f, 1.51926786e-01f, -2.00675279e-01f, -2.48469070e-01f, -5.00967503e-01f, 2.72034258e-02f, -3.01644355e-01f, -3.14157844e-01f, -2.58442968e-01f, -2.84870148e-01f,
  3.11354786e-01f, -2.27916658e-01f, -1.41883478e-01f, 1.79121912e-01f, 1.39038503e-01f, 1.03932351e-01f, -3.82693261e-01f, -3.73022854e-01f, 5.20236671e-01f, 1.74789056e-01f,
  -5.52138150e-01f, -4.79342341e-01f, 2.41387099e-01f, 4.95896727e-01f, -7.31200874e-02f, -2.67783374e-01f, -4.42702115e-01f, -5.17740011e-01f, 1.62381247e-01f, 9.71421480e-01f,
  -7.34195948e-01f, -5.41909218e-01f, -3.56065959e-01f, -3.91540587e-01f, 1.70019671e-01f, -1.15038045e-01f, 6.76579475e-02f, -3.31082419e-02f, -5.90261459e-01f, 3.59200954e-01f,
  -2.82729864e-01f, -1.69810817e-01f, -1.32374838e-01f, 3.39938700e-02f, -3.26439328e-02f, -8.81101117e-02f, 1.26565531e-01f, 1.43024409e-02f, -4.82901223e-02f, -3.61816525e-01f,
  9.46961641e-02f, -9.84076336e-02f, -1.73207000e-01f, 1.55544326e-01f, -4.89576953e-03f, -1.41644888e-02f, -3.13823558e-02f, 5.64190783e-02f, 1.86995953e-01f, -9.75895599e-02f,
  -8.71023461e-02f, 7.35145062e-02f, -7.58049637e-02f, 1.17236398e-01f, -2.84922928e-01f, 1.07783414e-02f, -7.44986814e-03f, -1.50104761e-01f, -4.99189422e-02f, 4.43182029e-02f,
  -1.13302797e-01f, 1.24554776e-01f, 1.27467096e-01f, 1.00024886e-01f, -5.71627207e-02f, -1.18872374e-01f, 2.36587189e-02f, 6.01884015e-02f, 2.75743064e-02f, 6.74478635e-02f,
  3.42071086e-01f, -1.28299475e-01f, -2.92875618e-01f, -4.75089878e-01f, -3.31017151e-02f, -3.82206142e-01f, -4.53220382e-02f, -3.45612317e-01f, 1.96653247e-01f, -1.84000045e-01f,
  -1.95605233e-01f, 2.44361475e-01f, 3.97894859e-01f, -1.49607062e-01f, 6.16681352e-02f, 2.98862785e-01f, 2.29587778e-02f, 2.81204313e-01f, -1.48064598e-01f, 3.20013016e-02f,
  3.42996329e-01f, 1.94502339e-01f, 3.34612459e-01f, 1.06586695e-01f, 4.60605696e-02f, -1.58050492e-01f, 3.37688513e-02f, 3.19826931e-01f, 5.41913569e-01f, -5.04118614e-02f,
  -4.26669270e-01f, -1.03391200e-01f, -3.09150070e-01f, -2.10861176e-01f, 3.95127922e-01f, 2.13523865e-01f, -3.99770625e-02f, 2.13727131e-01f, -6.15254641e-01f, -3.11346829e-01f,
  1.41518965e-01f, 1.15610346e-01f, -5.91582179e-01f, -4.08680499e-01f, 4.71032351e-01f, -4.60613072e-02f, -9.25121427e-01f, 4.26570058e-01f, 2.95047551e-01f, 6.99071527e-01f,
  5.25127053e-01f, -1.61622062e-01f, 3.82783443e-01f, -7.61006534e-01f, -4.58772659e-01f, -3.74853283e-01f, 2.75545478e-01f, 3.39271687e-02f, -5.84321320e-01f, -6.39903069e-01f,
  2.29021817e-01f, -1.02446573e-02f, -9.04880278e-03f, -1.54633656e-01f, -1.82739049e-01f, 2.49278441e-01f, 4.68126386e-02f, -3.57427657e-01f, 2.34091073e-01f, -3.30994517e-01f,
  -5.15614033e-01f, 1.52417302e-01f, -3.94333601e-02f, -2.29334924e-02f, 5.99654615e-01f, -6.48274601e-01f, -6.15085512e-02f, -6.01306558e-01f, 5.28707325e-01f, -6.21941507e-01f,
  -1.63273975e-01f, 2.85515338e-01f, 3.35192561e-01f, -9.42039788e-02f, -2.89659739e-01f, -4.01270568e-01f, -5.35188437e-01f, 1.42376408e-01f, 6.97734132e-02f, -2.23873883e-01f,
  1.16570480e-01f, 1.79546699e-01f, 2.08477005e-02f, 7.04729706e-02f, 1.12782702e-01f, -1.07479647e-01f, 4.96069193e-02f, -1.28227308e-01f, 4.70061228e-02f, 8.78470764e-02f,
  1.89569190e-01f, -1.14364482e-01f, -2.38266047e-02f, 2.17993255e-03f, 2.50382558e-03f, 7.35188201e-02f, 1.69753671e-01f, -1.19307302e-01f, -4.74248007e-02f, -3.82892005e-02f,
  7.98674896e-02f, 1.61634833e-01f, 9.43201408e-02f, -5.09354621e-02f, 1.85651463e-02f, -1.40684083e-01f, -3.92066836e-02f, 1.07369207e-01f, 1.11780405e-01f, 4.41369079e-02f,
  -4.96887229e-03f, 9.02171656e-02f, 2.16962397e-01f, 6.57841042e-02f, 1.19420022e-01f, -5.41994497e-02f, 1.57289490e-01f, -2.63003856e-01f, -9.78024602e-02f, -6.30816892e-02f,
  2.91769505e-01f, -1.82844564e-01f, 2.38005444e-01f, 3.97697031e-01f, 2.94763595e-01f, 2.57914603e-01f, 1.88806549e-01f, -2.08266392e-01f, 1.10770382e-01f, -2.45681986e-01f,
  2.48320222e-01f, 1.83186959e-02f, -2.04265177e-01f, -8.30372330e-03f, -1.33667052e-01f, -3.36631685e-01f, 2.80156761e-01f, -2.03927517e-01f, -2.47156639e-02f, 2.47222975e-01f,
  6.95025101e-02f, 3.72444332e-01f, -1.68481767e-01f, 1.66284263e-01f, -4.16962393e-02f, 2.03214228e-01f, 3.07337251e-02f, 2.58618504e-01f, -3.86187255e-01f, -5.70939779e-02f,
  -6.23004362e-02f, 1.87930390e-01f, -3.66475396e-02f, -3.88398677e-01f, 1.58563137e-01f, -2.71084398e-01f, -4.50840384e-01f, -4.85932559e-01f, 3.55218142e-01f, 3.25431556e-01f,
  2.63955116e-01f, 3.04996878e-01f, -3.89925122e-01f, -6.12430394e-01f, -1.49659440e-01f, -1.02932729e-01f, -2.71555990e-01f, -2.17148393e-01f, -3.69143188e-01f, -3.18325281e-01f,
  4.53229509e-02f, -2.16806889e-01f, -3.74370337e-01f, -1.92520488e-02f, 3.52370515e-02f, -2.82140374e-01f, 7.24404231e-02f, -1.30041391e-01f, -2.47626439e-01f, -1.63415298e-01f,
  -2.87127141e-02f, 4.43602473e-01f, 4.52958256e-01f, -5.48778653e-01f, -2.73784012e-01f, -3.93123358e-01f, -5.96213281e-01f, -4.12701279e-01f, 6.18196905e-01f, -2.59723932e-01f,
  -1.34631768e-01f, -1.24769043e-02f, -2.72462189e-01f, 7.42628276e-01f, -4.45633382e-01f, 9.94757712e-02f, -2.65286177e-01f, -2.21653000e-01f, -2.02072546e-01f, -3.35696757e-01f,
  4.00661469e-01f, -9.38329175e-02f, -3.23710233e-01f, -1.90630525e-01f, 4.13342208e-01f, -4.65603411e-01f, -3.80650282e-01f, -3.64354610e-01f, 1.77037209e-01f, 9.79353413e-02f,
  1.92941546e-01f, -1.67125538e-01f, -8.06470215e-02f, 6.33281022e-02f, 8.63761306e-02f, 1.76880017e-01f, 1.23472616e-01f, 1.95275899e-02f, -7.53341019e-02f, -7.20641837e-02f,
  -1.71489477e-01f, -1.16615430e-01f, 7.78949186e-02f, -1.31605506e-01f, -1.30830452e-01f, 1.54761113e-02f, 1.63822532e-01f, -1.04376808e-01f, 9.17297527e-02f, 5.48807159e-02f,
  2.20595412e-02f, 6.11796305e-02f, 2.74509247e-02f, 4.23762165e-02f, 1.26259588e-02f, 5.15071712e-02f, 2.52621233e-01f, 1.04810186e-01f, -1.29049614e-01f, 2.33976152e-02f,
  -2.72574723e-01f, -9.77953672e-02f, 1.27633035e-01f, 1.34007707e-01f, -4.81528752e-02f, -9.72364023e-02f, -1.85845628e-01f, -6.96288049e-02f, -1.78031921e-01f, 5.08074820e-01f,
  -1.35315478e-01f, 5.14424741e-02f, 1.24194600e-01f, -7.95591548e-02f, 1.42359510e-01f, -2.23782301e-01f, 4.72658604e-01f, 1.44836381e-01f, -1.88180402e-01f, 3.06590408e-01f,
  -3.67285699e-01f, -1.27685398e-01f, 3.75758201e-01f, 2.19742268e-01f, -1.27649188e-01f, -2.60255039e-01f, 1.35009766e-01f, -3.57689351e-01f, 4.56338609e-03f, 4.85379010e-01f,
  3.10221791e-01f, -2.49376804e-01f, 6.76027387e-02f, -3.03358346e-01f, -4.25811201e-01f, -1.12276576e-01f, 3.83391887e-01f, 5.58032282e-02f, 3.38776022e-01f, -1.13928430e-01f,
  1.80988222e-01f, -2.73147285e-01f, -1.84501812e-01f, 3.36720794e-01f, -4.65854973e-01f, 1.89696729e-01f, -2.82145709e-01f, 1.21931911e-01f, -3.25197607e-01f, -5.33973455e-01f,
  -4.85093147e-01f, -2.41950825e-01f, 5.67087352e-01f, -4.05401826e-01f, -1.39266759e-01f, -4.92241591e-01f, -6.84374720e-02f, 3.41462046e-01f, 4.48088914e-01f, -2.06453815e-01f,
  -3.16162467e-01f, 1.92691326e-01f, -6.02186084e-01f, -8.59924704e-02f, -4.09780145e-02f, -3.48558307e-01f, 2.69598782e-01f, -5.56737125e-01f, -2.37814859e-01f, -4.44907576e-01f,
  2.98596118e-02f, -5.29073961e-02f, -3.00920427e-01f, -3.86036485e-01f, -4.68665689e-01f, -2.66384721e-01f, -1.46267548e-01f, 1.67796746e-01f, 4.97080982e-01f, -2.82245785e-01f,
  -1.50873989e-01f, -8.20920244e-02f, 5.43848753e-01f, -4.58692014e-01f, -4.44341116e-02f, 6.73306346e-01f, 4.11934078e-01f, 2.89253257e-02f, -3.41383487e-01f, -3.48897755e-01f,
  1.31355807e-01f, 1.59100324e-01f, -1.58761501e-01f, -5.92472479e-02f, 7.72363544e-02f, 5.30886650e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.98956981e-01f, -7.43413344e-02f, 1.04850061e-01f, -1.78237613e-02f, -3.97307277e-02f, 1.69065204e-02f, -4.02225107e-02f, 3.03135514e-02f, 7.83090964e-02f, 1.76110014e-01f,
  -4.65150550e-02f, 8.78998712e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    