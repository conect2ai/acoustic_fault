/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.25903356e-01f, -9.49449986e-02f, 1.82158768e-01f, 5.71701638e-02f, 5.23698255e-02f, 1.39118880e-01f, 1.72004789e-01f, 3.53173390e-02f, -1.59561589e-01f, -3.89856957e-02f,
  9.75296497e-02f, 2.72563733e-02f, 1.26795337e-01f, -4.36111353e-02f, 3.74827445e-01f, -1.86037347e-01f, 1.00006826e-01f, 2.13975832e-02f, -1.55430630e-01f, 1.74531117e-01f,
  -3.33400108e-02f, 1.67911917e-01f, 1.17448732e-01f, 7.08262548e-02f, 1.06473401e-01f, -3.27347293e-02f, 2.03131124e-01f, 2.24169530e-02f, 1.57125428e-01f, -1.42093888e-02f,
  -1.58253238e-01f, -1.42176762e-01f, 4.86744158e-02f, 5.62651129e-03f, 1.07242741e-01f, 6.54181093e-02f, 5.26971780e-02f, 3.15099284e-02f, -4.31355797e-02f, 2.15348769e-02f,
  1.50472242e-02f, 7.99758453e-03f, -5.58531284e-02f, 5.00925668e-02f, 1.40587362e-02f, -5.45261502e-02f, -4.64698076e-02f, -7.10539445e-02f, 2.20954251e-02f, 2.91779488e-02f,
  2.63311919e-02f, -3.70956436e-02f, 1.13284132e-02f, -6.30408451e-02f, 1.24664409e-02f, 2.82418970e-02f, 4.89519164e-02f, 7.69074559e-02f, -8.63696113e-02f, -1.18722143e-02f,
  2.29730979e-02f, 8.18769708e-02f, -3.93830650e-02f, -4.13543917e-02f, 1.35159213e-02f, -1.58962840e-03f, -1.65864432e-04f, -5.53123653e-03f, -2.81409267e-02f, -7.14787655e-03f,
  -4.96898778e-02f, 1.13198292e-02f, -1.05525121e-01f, -1.69410906e-03f, 1.37094017e-02f, -4.66451757e-02f, 2.16417052e-02f, -6.90153539e-02f, -2.34596822e-02f, -1.10937646e-02f,
  1.16356947e-02f, -2.11404134e-02f, 2.83674663e-03f, 1.36293285e-02f, 2.05920786e-02f, 1.07499519e-02f, 3.51385847e-02f, -9.85691417e-03f, -8.49441625e-03f, 2.13422608e-02f,
  9.39481705e-02f, 1.55979410e-01f, -5.20633459e-02f, -2.53084693e-02f, -1.00971147e-01f, -2.58908644e-02f, -3.16387042e-02f, 3.05968691e-02f, 5.81976958e-02f, 3.10464259e-02f,
  4.08825614e-02f, -5.81309386e-03f, 1.20113408e-02f, -6.23537879e-03f, -1.89951621e-02f, 3.88172455e-02f, 5.81050664e-02f, 3.16403881e-02f, 8.62332433e-02f, 2.20743883e-02f,
  8.91683549e-02f, 4.82566096e-03f, -3.82398255e-02f, 2.87317857e-02f, 3.74472998e-02f, 1.83598120e-02f, 1.93004007e-03f, -4.16597463e-02f, 7.85459429e-02f, -4.77199908e-03f,
  -3.41560543e-01f, 6.35982379e-02f, -1.84350789e-01f, -1.32488742e-01f, 8.38466063e-02f, -3.15293968e-01f, -3.51803690e-01f, 4.21184413e-02f, -1.66742295e-01f, -6.14306517e-02f,
  1.04616858e-01f, -1.85646281e-01f, 1.72236040e-01f, -9.06237736e-02f, 1.13106772e-01f, 4.68858108e-02f, -1.20335177e-01f, -1.33877292e-01f, 9.77564454e-02f, -5.76652028e-02f,
  5.83509691e-02f, 1.07473545e-01f, -2.10818667e-02f, 1.28799826e-01f, -1.56381115e-01f, 1.09448740e-02f, 1.95845291e-01f, 4.36743088e-02f, -6.04582764e-03f, 5.58424294e-02f,
  -1.05289556e-01f, 3.87669690e-02f, 6.94671348e-02f, -2.21600533e-02f, -6.26563430e-02f, -2.54367981e-02f, -9.95807797e-02f, -3.76794934e-02f, -1.42375594e-02f, -6.67341501e-02f,
  -1.03882300e-02f, -4.64278786e-03f, -5.09719737e-02f, 7.55224330e-03f, -2.83764564e-02f, -1.53872964e-03f, -3.72492149e-02f, -1.25664175e-02f, -4.33623977e-02f, -3.41347866e-02f,
  -4.30921391e-02f, -5.63371889e-02f, -5.05163625e-04f, -4.27580774e-02f, 2.33568735e-02f, -1.68381762e-02f, -9.28315446e-02f, -1.35125788e-02f, -4.06888835e-02f, -6.15076236e-02f,
  5.90224843e-03f, 2.55427640e-02f, 2.70884410e-02f, 1.63254924e-02f, -1.83976199e-02f, 1.12965452e-02f, 1.30053069e-02f, -1.12687573e-02f, -5.41198738e-02f, 3.41072083e-02f,
  -2.55121179e-02f, 2.48715151e-02f, 3.24323587e-02f, -6.61819950e-02f, 4.78758700e-02f, 3.71031091e-02f, -6.87684631e-03f, -1.78542081e-02f, 2.61983145e-02f, -4.55333740e-02f,
  -9.96681629e-04f, 9.03884228e-03f, 6.61629736e-02f, -3.93805504e-02f, 4.81398962e-03f, 3.77807431e-02f, 1.13464762e-02f, 8.71760771e-04f, -2.63421759e-02f, -2.06407066e-02f,
  2.27773637e-02f, 2.48320118e-01f, 4.85166162e-02f, 2.95510348e-02f, -8.29794910e-03f, 2.27872841e-02f, 5.10510691e-02f, 1.03424154e-02f, 1.59052119e-03f, 2.78632250e-03f,
  6.00700732e-03f, -8.41184780e-02f, 1.64623521e-02f, -5.29595427e-02f, 3.61507684e-02f, 1.69650614e-02f, 4.61880378e-02f, 7.83089641e-03f, 2.60477439e-02f, 6.96949288e-02f,
  4.14638221e-02f, -2.48506777e-02f, -6.13843044e-03f, 9.53217037e-03f, -2.55128127e-02f, -1.98494513e-02f, -3.46590579e-02f, 1.79125853e-02f, 3.86335589e-02f, 9.53126978e-03f,
  5.48163429e-02f, 3.02693527e-02f, -1.12694494e-01f, -5.58872111e-02f, -1.93756714e-01f, 3.49277072e-02f, 2.76211560e-01f, -1.77963838e-01f, 1.67793818e-02f, 5.07254638e-02f,
  1.75121844e-01f, 1.06503889e-01f, 3.61763626e-01f, 1.25194728e-01f, 2.61261731e-01f, 3.06502402e-01f, 1.91042259e-01f, 7.71915093e-02f, 2.35757940e-02f, -9.48727876e-02f,
  -3.23700644e-02f, 2.55549010e-02f, 1.43037409e-01f, -2.51357138e-01f, -1.28640130e-01f, -2.27062792e-01f, -6.62914664e-02f, 4.58684117e-02f, -1.38560876e-01f, 2.48987209e-02f,
  1.38036050e-02f, -5.01147583e-02f, -6.91203028e-02f, 3.65073420e-02f, -4.42413352e-02f, -3.21100168e-02f, -4.78684418e-02f, 5.33250012e-02f, -2.68814284e-02f, 1.79252797e-03f,
  -5.41560631e-03f, -8.71695131e-02f, 1.31809367e-02f, -4.55532148e-02f, -7.69188777e-02f, -9.63218659e-02f, -3.49304080e-02f, 2.51120515e-02f, -5.67645058e-02f, 2.60163825e-02f,
  7.61690782e-03f, -2.91546099e-02f, 5.04663289e-02f, 6.53558163e-05f, 9.12567973e-03f, -1.17576849e-02f, 4.94683199e-02f, -1.36085963e-02f, -3.51645164e-02f, -8.05704668e-03f,
  2.51684077e-02f, 6.55402467e-02f, 3.13261859e-02f, 1.41014694e-03f, -4.83218282e-02f, -1.60541628e-02f, 4.72805975e-03f, 3.28734778e-02f, -5.12798652e-02f, 2.46073399e-02f,
  -3.15542147e-02f, 3.78562417e-03f, 2.14519780e-02f, -7.51754455e-03f, 3.54465656e-02f, -7.61166885e-02f, 3.09081860e-02f, 2.52218954e-02f, 1.88742951e-02f, -1.56299379e-02f,
  7.24833980e-02f, 1.17370263e-02f, 1.77897867e-02f, 4.13588099e-02f, -4.36174171e-03f, 3.17608304e-02f, 7.08567444e-03f, -1.14776026e-02f, 1.16557684e-02f, 2.61080060e-02f,
  1.44347753e-02f, 8.20173472e-02f, 3.30273435e-02f, -2.95285955e-02f, -7.99681619e-03f, -3.56609039e-02f, 6.66262135e-02f, -2.81640496e-02f, 2.33091284e-02f, 4.00991552e-02f,
  -5.99815026e-02f, -6.11611195e-02f, -1.38382427e-02f, -1.17371939e-02f, 2.43841112e-02f, 3.32258381e-02f, 1.45360995e-02f, -4.03086916e-02f, 3.53991687e-02f, -4.55024876e-02f,
  -2.91039627e-02f, -2.10742876e-02f, -1.40687171e-03f, -8.13280046e-02f, -4.57727872e-02f, -1.17418740e-03f, -5.56574985e-02f, 1.52411740e-02f, 3.14296633e-02f, 2.99163349e-02f,
  -4.27849859e-01f, -1.67153075e-01f, -1.93108782e-01f, -2.67494917e-01f, -1.25711709e-02f, 8.47745612e-02f, -1.09258913e-01f, -8.15083385e-02f, -3.19194376e-01f, 1.48299843e-01f,
  7.30200410e-02f, -1.33311287e-01f, 2.16922425e-02f, -1.46558434e-01f, 7.88004026e-02f, 3.07049751e-02f, -1.28681079e-01f, -2.99256984e-02f, -1.07922658e-01f, -1.07343877e-02f,
  -6.29591420e-02f, 5.44287376e-02f, -1.18423365e-01f, 1.21650256e-01f, -1.47469699e-01f, -5.13844192e-02f, 1.85446814e-01f, 1.04446061e-01f, 9.73373875e-02f, 1.02116756e-01f,
  -9.25929472e-02f, -1.86329201e-01f, -4.58276346e-02f, 1.80417877e-02f, -1.74097698e-02f, 7.14844093e-02f, 4.85153012e-02f, 9.06281099e-02f, -2.76435427e-02f, -8.34473001e-04f,
  -1.79683380e-02f, 4.59614247e-02f, -2.52658855e-02f, -1.92897003e-02f, -4.72425371e-02f, -3.49913538e-02f, -3.63080613e-02f, -6.48662746e-02f, -2.63989717e-02f, -1.58151556e-02f,
  -1.06359154e-01f, -4.14411090e-02f, -1.23770516e-02f, 5.41913956e-02f, -3.19248624e-02f, -3.31485085e-02f, 1.54784909e-02f, 5.14623709e-02f, 6.82457071e-03f, 9.13953234e-04f,
  4.43419889e-02f, 1.19522749e-03f, 1.76062975e-02f, -2.93821245e-02f, -9.65644885e-03f, 1.81845650e-02f, -1.22984918e-02f, 6.04827292e-02f, -9.98831540e-02f, 2.39009541e-02f,
  -9.00693797e-03f, -1.84056126e-02f, 2.39979848e-02f, -2.51520034e-02f, -4.09025291e-04f, -7.70314131e-03f, 2.91119944e-02f, 1.42919784e-02f, -3.69892344e-02f, -3.62427570e-02f,
  3.27599868e-02f, 2.92779747e-02f, -2.39501521e-02f, 2.69502942e-02f, 6.44746283e-03f, 3.55275199e-02f, 1.90344695e-02f, -2.18825992e-02f, -1.34567833e-02f, 5.15694991e-02f,
  1.46292895e-01f, 2.51369864e-01f, -1.36157116e-02f, -4.23182510e-02f, 1.21132885e-04f, -5.88933565e-02f, -1.75572559e-03f, -2.82118097e-02f, 1.26501089e-02f, -1.85282174e-02f,
  1.40755782e-02f, -1.05510857e-02f, 5.51325306e-02f, 4.63793539e-02f, 3.38758007e-02f, 6.35836050e-02f, 5.62315099e-02f, 2.17776354e-02f, 5.45365661e-02f, 3.66822854e-02f,
  -7.52519863e-03f, 4.16299626e-02f, 3.44401896e-02f, 3.82442988e-04f, 3.98270041e-02f, 5.94458729e-02f, -7.10577564e-03f, -1.97403766e-02f, 8.91481191e-02f, 1.82777122e-02f,
  -1.88764811e-01f, -3.47717434e-01f, 1.36727527e-01f, 1.30663410e-01f, -3.57565405e-05f, -1.61257774e-01f, -7.93731213e-03f, -9.39652920e-02f, -4.73416597e-02f, -2.13891566e-01f,
  -4.40159515e-02f, -7.76890293e-03f, -2.75200624e-02f, -2.23731082e-02f, 1.47088021e-01f, -5.70448712e-02f, -1.33425549e-01f, -1.37368575e-01f, 4.65947203e-02f, 6.20032102e-03f,
  4.70572487e-02f, -1.07778884e-01f, 1.10194422e-01f, -9.50362813e-03f, -8.66632387e-02f, 1.15632832e-01f, 8.02975595e-02f, 1.10357858e-01f, 1.11704292e-02f, 1.05434090e-01f,
  -5.38976230e-02f, 8.51893499e-02f, 1.70802902e-02f, -2.95425598e-02f, -3.02396957e-02f, 3.49363289e-03f, 5.50624914e-02f, 7.10005090e-02f, 6.15129657e-02f, -2.10470445e-02f,
  -3.82600911e-02f, -4.04797643e-02f, 2.23127558e-04f, 3.59756611e-02f, -4.63887677e-02f, 8.24032445e-03f, -1.09220045e-02f, 6.71610562e-03f, -1.25512807e-02f, -5.07134385e-02f,
  -2.87541049e-03f, 1.40754040e-04f, -4.08378110e-04f, -3.33289243e-02f, 2.52982844e-02f, -1.01492815e-02f, 5.29378168e-02f, 1.94239952e-02f, -2.24931650e-02f, -4.44039283e-03f,
  4.66814600e-02f, -8.18852044e-04f, -1.83322057e-02f, -3.98237668e-02f, -9.67266783e-03f, 1.30636198e-02f, -5.09377867e-02f, 3.74623312e-04f, -2.55465005e-02f, -4.73056920e-02f,
  -5.54395840e-02f, -1.00741982e-02f, 3.82312499e-02f, -7.02450648e-02f, -1.71559602e-02f, -2.37667859e-02f, -1.42174838e-02f, -1.92186553e-02f, -2.81565003e-02f, 1.13373343e-02f,
  5.54090850e-02f, -2.24189814e-02f, 1.90734547e-02f, -2.27174014e-02f, 1.15572996e-02f, 5.46076819e-02f, 2.49050912e-02f, -2.94126058e-03f, 5.15453592e-02f, -2.30407482e-03f,
  -4.21958238e-01f, -2.15928733e-01f, -1.62398312e-02f, -7.74256606e-03f, -4.92972359e-02f, -2.48523094e-02f, 2.64877290e-03f, -1.27333235e-02f, 4.22263332e-03f, 2.84056622e-03f,
  -8.21711961e-03f, -1.96968298e-02f, -3.40765081e-02f, -3.49742547e-03f, 3.26062143e-02f, -4.32506576e-02f, 1.52992560e-02f, -3.76856402e-02f, -6.57247007e-02f, 6.43012207e-03f,
  -2.74674688e-02f, -1.12984395e-02f, 7.77755454e-02f, -2.91452301e-03f, 2.09506582e-02f, -8.94906651e-03f, -5.43679623e-03f, 5.41935004e-02f, 1.23723212e-03f, 2.93779243e-02f,
  -3.77139539e-01f, 2.05358922e-01f, 2.05114409e-01f, -1.29087165e-01f, -8.49608630e-02f, -3.92665476e-01f, -3.75562161e-01f, 7.89044127e-02f, -2.85034359e-01f, 9.73719656e-02f,
  -9.63875726e-02f, 8.08018520e-02f, 9.92801562e-02f, -2.46959284e-01f, -2.08260864e-01f, -5.75804412e-02f, -2.36117437e-01f, -7.21814632e-02f, -4.99289259e-02f, 3.95244211e-02f,
  -4.32941280e-02f, -2.09889293e-01f, -6.60565775e-03f, 1.64230213e-01f, -4.02210951e-02f, 1.41824752e-01f, 1.92759112e-01f, 1.36513993e-01f, 7.56078884e-02f, -4.54180017e-02f,
  -1.84785143e-01f, -2.83132773e-02f, 3.40289413e-03f, -2.35445853e-02f, 1.44486232e-02f, 1.88715924e-02f, 4.38994914e-02f, 5.29199094e-03f, 2.95786764e-02f, -2.30904832e-03f,
  3.93003151e-02f, -3.05330893e-03f, -9.34540480e-02f, -1.21570483e-03f, -9.32708606e-02f, -1.64492838e-02f, 4.69475910e-02f, -1.54248038e-02f, 2.16285810e-02f, -5.68626858e-02f,
  6.12534359e-02f, 3.01480144e-02f, -8.81963875e-03f, 8.09853896e-02f, 5.09906113e-02f, -7.99725056e-02f, -5.65385155e-04f, 7.93603510e-02f, -2.40806546e-02f, -8.70678388e-03f,
  2.12574210e-02f, 1.51898433e-02f, 1.32974156e-03f, -2.91986000e-02f, -1.95543971e-02f, -6.16530888e-03f, -3.85862142e-02f, 1.08722290e-02f, -1.48043141e-03f, -2.07145140e-02f,
  -3.20657045e-02f, -1.97004154e-02f, -8.37812051e-02f, 2.45241132e-02f, -3.55115794e-02f, -4.63846000e-03f, 2.81123202e-02f, 5.33771142e-03f, 1.03780637e-02f, 1.98149458e-02f,
  -2.09209006e-02f, -3.41642387e-02f, 1.64956469e-02f, 1.22531783e-02f, -1.03471074e-02f, 5.61216427e-03f, 8.68250895e-03f, 1.81042086e-02f, -1.34776132e-02f, -2.50124522e-02f,
  1.28071740e-01f, 2.42392063e-01f, 2.96773762e-02f, -4.52662669e-02f, 2.83007622e-02f, 6.79415390e-02f, -1.38051836e-02f, -1.07868630e-02f, 4.67095040e-02f, -1.05246138e-02f,
  3.33726220e-02f, 1.53047750e-02f, 4.18562740e-02f, 3.87097709e-02f, 1.78841930e-02f, 3.89098015e-04f, 4.22152430e-02f, 5.25154583e-02f, 1.67790074e-02f, 6.37725890e-02f,
  6.97147548e-02f, -2.31943168e-02f, -4.37474586e-02f, 8.30909237e-03f, -2.90147727e-04f, 3.42067629e-02f, 5.94561622e-02f, 3.00837751e-03f, -2.17189663e-03f, 4.00676318e-02f,
  -2.23230034e-01f, -3.99121419e-02f, -3.20490226e-02f, -2.13111192e-01f, -1.84633330e-01f, 2.38943875e-01f, 1.66903868e-01f, -2.22004671e-02f, -3.94553274e-01f, 6.48063272e-02f,
  1.97686046e-01f, -1.60398200e-01f, 1.45478651e-01f, 1.18265808e-01f, 3.38484198e-01f, 1.57376051e-01f, 1.99808806e-01f, 1.03633553e-02f, -1.45031482e-01f, -1.73989207e-01f,
  -1.14701405e-01f, 1.48607433e-01f, 3.27296853e-01f, 1.02809407e-01f, -3.74624878e-02f, -9.87337083e-02f, 1.23009980e-01f, -6.30300492e-02f, 1.68609947e-01f, 9.56580043e-02f,
  1.31871253e-01f, -1.54348791e-01f, 2.33237818e-02f, 6.20951727e-02f, 1.98889785e-02f, 5.63620180e-02f, 8.16008151e-02f, 5.52075393e-02f, -3.09201945e-02f, -7.34796282e-03f,
  -3.68518680e-02f, 6.26873076e-02f, -3.45769525e-03f, 7.96716474e-03f, -7.18045309e-02f, -3.21942903e-02f, -2.59430916e-03f, -3.30847166e-02f, -3.03873140e-02f, -6.83227628e-02f,
  -2.19071824e-02f, -1.92231555e-02f, -3.36424522e-02f, 2.03174558e-02f, -3.48036587e-02f, -5.45877358e-03f, 2.67912466e-02f, -1.67444535e-02f, 2.56699771e-02f, -5.49094938e-02f,
  4.10582125e-02f, -2.57198792e-02f, 5.00641763e-02f, 8.91105384e-02f, 7.08311126e-02f, 1.52248256e-02f, -3.26631241e-04f, 9.46950540e-03f, 4.88393102e-03f, 1.35076866e-02f,
  3.69889960e-02f, -1.91491265e-02f, 1.46363936e-02f, -2.31811926e-02f, -4.22088802e-02f, 9.04012844e-03f, 4.23652157e-02f, -1.10939983e-02f, -3.09507176e-02f, -4.54894900e-02f,
  -5.98544106e-02f, 1.38532305e-02f, 4.09453263e-04f, 1.41550386e-02f, 3.57598588e-02f, 2.23196950e-02f, -5.13344482e-02f, -4.07662131e-02f, -5.13159782e-02f, -1.21779516e-02f,
  1.35113643e-02f, -1.19162261e-01f, -1.73685700e-02f, -7.49315089e-03f, 2.87339650e-02f, 2.50071716e-02f, -2.99263187e-02f, -2.86515411e-02f, -4.49198820e-02f, -4.48762672e-03f,
  4.57528010e-02f, -1.22472197e-02f, -1.45101128e-02f, -2.20433343e-02f, 4.88935895e-02f, 2.02542022e-02f, 4.71285284e-02f, -2.11639032e-02f, -4.12542708e-02f, -7.51484139e-03f,
  -1.62899494e-02f, 2.06092019e-02f, -3.18694301e-02f, -4.80599478e-02f, -1.44518847e-02f, 3.73597294e-02f, -9.52224359e-02f, 1.46142505e-02f, -3.84676494e-02f, 4.39050049e-02f,
  -2.34833121e-01f, -2.57848531e-01f, 3.78888957e-02f, 1.43758804e-02f, 5.37135713e-02f, 1.61916673e-01f, 2.21639752e-01f, -3.11754402e-02f, 1.32692708e-02f, -2.87609012e-03f,
  9.63717997e-02f, -1.58304393e-01f, -3.92892472e-02f, 3.12444925e-01f, -2.58975159e-02f, -3.20658870e-02f, 1.92891538e-01f, 2.07582135e-02f, -4.89094947e-03f, -1.10845782e-01f,
  4.00048867e-03f, 1.34207323e-01f, 1.48434758e-01f, 1.52300177e-02f, 3.71590964e-02f, -8.32195878e-02f, -1.11856438e-01f, -1.00920968e-01f, 1.57720655e-01f, 5.45373634e-02f,
  2.41118386e-01f, -1.34750068e-01f, 1.23261787e-01f, -1.67706069e-02f, -9.29518137e-03f, -4.36972268e-03f, -2.96266228e-02f, 4.92026247e-02f, 4.16199267e-02f, -3.29877920e-02f,
  -4.80310433e-02f, -1.40607841e-02f, 7.11682513e-02f, -2.59362981e-02f, -5.35597689e-02f, -2.63035484e-02f, 4.94694039e-02f, 4.44394834e-02f, -6.82831928e-03f, 5.69079556e-02f,
  5.06430417e-02f, 4.40428481e-02f, 6.58617243e-02f, 5.12173399e-03f, 3.96702671e-03f, 3.85865048e-02f, 2.93161497e-02f, -1.28629748e-02f, -7.09927827e-02f, 2.02117953e-03f,
  -6.20698407e-02f, -4.47964258e-02f, -3.86531055e-02f, 2.92733051e-02f, -1.65575836e-02f, 1.09182186e-02f, 2.61592977e-02f, 1.49264121e-02f, -2.14434080e-02f, 1.03044126e-03f,
  2.72687096e-02f, -3.62961963e-02f, -3.67357917e-02f, 1.63391810e-02f, -5.58715826e-03f, 1.13239717e-02f, -7.28416676e-03f, -7.01694936e-02f, 2.70639118e-02f, 5.81610575e-02f,
  -3.59451175e-02f, -5.20280376e-02f, -2.55261716e-02f, 3.41833220e-03f, -1.72731758e-03f, -4.29435372e-02f, -6.77320734e-03f, -2.17844043e-02f, 3.73942107e-02f, 6.08319789e-03f,
  -4.86972332e-01f, -5.71976662e-01f, 2.40469053e-02f, 1.61908772e-02f, 1.54222257e-03f, -3.26019898e-02f, -1.04292771e-02f, -2.40123109e-03f, -9.71425846e-02f, -5.47014847e-02f,
  -3.39100249e-02f, 3.61991897e-02f, -4.13564332e-02f, 3.55621204e-02f, 2.44981833e-02f, 8.91071279e-03f, -4.35157344e-02f, -5.11498004e-02f, -1.38550224e-02f, -3.80503573e-02f,
  -7.65172541e-02f, -7.86725953e-02f, 3.58808538e-05f, 4.80276234e-02f, 4.32741921e-03f, 1.20882019e-02f, -6.15028813e-02f, 1.04947314e-02f, -5.49496599e-02f, -1.58019755e-02f,
  1.78986624e-01f, 2.65989721e-01f, -2.07003728e-02f, 1.95487037e-01f, -2.39454359e-01f, 4.29367181e-03f, 7.77406991e-03f, 1.79091692e-02f, 1.72428757e-01f, 2.46187508e-01f,
  -7.46768937e-02f, 3.08045775e-01f, -4.74969037e-02f, 1.14102967e-01f, -2.48299316e-01f, -1.79616897e-03f, 3.64718698e-02f, 1.44370899e-01f, -1.65313028e-03f, 3.50502208e-02f,
  -5.01556136e-02f, -8.25649574e-02f, -1.88621178e-01f, -1.24202847e-01f, -1.86286971e-01f, 2.71070730e-02f, -1.83618143e-01f, -1.20584764e-01f, 4.11285013e-02f, -2.30895635e-02f,
  -2.12313738e-02f, 1.11726470e-01f, -2.18291059e-02f, 3.04710884e-02f, -7.05405697e-02f, -2.74783727e-02f, 1.26009006e-02f, -5.89510128e-02f, -4.07025740e-02f, -5.55122271e-03f,
  -9.06194467e-03f, -7.81903043e-02f, 2.37969700e-02f, 9.15989000e-03f, 4.23851684e-02f, -2.30703671e-02f, -4.57737520e-02f, -3.02226227e-02f, -5.07884063e-02f, -9.28531140e-02f,
  -2.77348664e-02f, -7.39792436e-02f, -2.43884753e-02f, 2.99583413e-02f, -9.77009833e-02f, 5.33506349e-02f, 1.59998704e-02f, -8.58956296e-03f, 1.60295088e-02f, 3.42333391e-02f,
  5.21955006e-02f, -1.10320821e-02f, -2.77005378e-02f, -1.06234625e-02f, 5.27159125e-02f, -8.16159602e-03f, 5.64737897e-03f, -1.02603165e-02f, 9.12963785e-03f, -2.96140071e-02f,
  2.56727282e-02f, 1.08720846e-02f, 3.18936370e-02f, -2.49761250e-03f, 6.53180480e-02f, 1.57383587e-02f, 9.01960768e-03f, -1.41291711e-02f, 5.75405406e-03f, -1.20661464e-02f,
  7.03610899e-03f, 1.31083317e-02f, 2.17786282e-02f, -5.77342883e-02f, 1.21094398e-02f, -4.89153760e-03f, 2.36891583e-02f, 3.04286946e-02f, -2.59017777e-02f, -3.75743024e-02f,
  1.54738188e-01f, 2.80211776e-01f, 3.36601734e-02f, -1.81230064e-02f, 7.45120570e-02f, 5.66259818e-03f, -1.22402599e-02f, 2.30530966e-02f, 5.31804189e-02f, -3.77735496e-02f,
  1.12404758e-02f, -1.81361455e-02f, 7.53006712e-03f, -1.17016220e-02f, -3.57942879e-02f, 5.04810661e-02f, 2.16830280e-02f, 3.16511467e-02f, -4.07150500e-02f, 2.88051888e-02f,
  -3.80798168e-02f, 2.38893996e-03f, -6.57157460e-03f, -7.99536407e-02f, 1.90709084e-02f, -4.23993357e-03f, 2.82946248e-02f, 5.67395873e-02f, -6.32771105e-02f, 4.99887690e-02f,
  1.78706408e-01f, -7.35488385e-02f, 2.92588115e-01f, -1.47982329e-01f, 5.04729301e-02f, 1.39388770e-01f, 5.03549464e-02f, -5.86074032e-02f, 2.50648465e-02f, -2.95405596e-01f,
  -1.33750349e-01f, 1.40295491e-01f, 8.20678622e-02f, -2.79592186e-01f, 1.91014901e-01f, 4.74728048e-02f, -1.92321390e-01f, -1.07717104e-01f, 8.00526589e-02f, -1.81322321e-01f,
  1.95193831e-02f, -3.36181611e-01f, 6.77330643e-02f, -1.24641709e-01f, -1.30513117e-01f, 7.63776824e-02f, -2.15108037e-01f, 1.92667812e-01f, -1.78282812e-01f, 1.53093366e-02f,
  9.35615525e-02f, 4.90810052e-02f, 5.87457307e-02f, 3.64079326e-02f, -5.76384477e-02f, -3.02758929e-03f, 4.79318900e-04f, 1.16130419e-01f, 7.10242838e-02f, 3.06554846e-02f,
  2.17188392e-02f, 2.76837330e-02f, -4.46325652e-02f, 1.88242663e-02f, 1.47501985e-02f, -9.93322581e-04f, 4.68469150e-02f, -3.65436263e-02f, -3.71223353e-02f, 9.14687291e-02f,
  5.21552637e-02f, 3.45356651e-02f, -4.82752435e-02f, -7.48805404e-02f, 6.95260242e-02f, 1.49962883e-02f, -5.13310358e-02f, 7.48981163e-02f, -2.69655846e-02f, -2.23334413e-02f,
  -2.26168744e-02f, 5.12174256e-02f, -2.02683639e-02f, -2.00192425e-02f, -3.54225398e-03f, -2.06420943e-02f, -6.83836825e-03f, -4.30766717e-02f, 3.64575647e-02f, -8.86062384e-02f,
  3.33337188e-02f, -2.45182980e-02f, -2.78435182e-02f, -2.69366242e-02f, -8.84049237e-02f, -7.13760927e-02f, 2.81922463e-02f, -3.35151479e-02f, -3.54779884e-02f, 2.09702719e-02f,
  -1.73120142e-03f, 6.77695777e-03f, -1.07886847e-02f, -4.99203277e-04f, -9.22032353e-03f, 1.06925350e-02f, -5.11338748e-02f, -4.90129814e-02f, 1.65705457e-02f, 1.71382762e-02f,
  -1.73100054e-01f, -2.02423081e-01f, -9.85487271e-03f, -4.95227752e-03f, 5.96926920e-02f, 9.13708750e-03f, -1.67842191e-02f, -4.07981575e-02f, -2.68249810e-02f, -3.21026146e-02f,
  -3.53195965e-02f, -6.49406463e-02f, -1.96006820e-02f, -1.41908890e-02f, 2.14971844e-02f, -2.24711583e-03f, -3.51176038e-02f, -3.27761360e-02f, -5.82897998e-02f, -4.23748791e-02f,
  -2.94708963e-02f, -3.42223160e-02f, 1.93251595e-02f, -6.43919930e-02f, -9.30499434e-02f, -7.86529575e-03f, -2.78051617e-03f, 6.19015051e-03f, 3.20861936e-02f, -3.05975191e-02f,
  -2.06594884e-01f, 2.57147074e-01f, 9.45421755e-02f, -2.01967448e-01f, -1.03466801e-01f, 2.31928840e-01f, 3.50574821e-01f, -8.28968808e-02f, 3.35021392e-02f, 2.05337942e-01f,
  -4.22749668e-02f, -4.85001467e-02f, 1.91202924e-01f, -1.80218160e-01f, -2.37837777e-01f, 1.16044462e-01f, -1.03132881e-01f, -3.00239492e-02f, -3.90222780e-02f, -1.00961104e-01f,
  -2.12405831e-01f, -1.80702791e-01f, -1.56088367e-01f, -8.18286389e-02f, -1.09119024e-02f, -2.25659162e-02f, -1.39586166e-01f, 1.42608941e-01f, -8.25425163e-02f, -1.83323007e-02f,
  1.35143623e-02f, -5.79288006e-02f, 2.05020681e-02f, 3.26248668e-02f, -4.31458391e-02f, 2.92818677e-02f, 4.68660556e-02f, 4.78544785e-03f, -9.76106077e-02f, -9.36076324e-03f,
  7.39283189e-02f, -2.68574487e-02f, -7.14591704e-03f, -5.68910409e-03f, -1.22875627e-02f, 3.44904065e-02f, -4.41975147e-03f, 1.11659626e-02f, 5.20244204e-02f, 3.00921146e-02f,
  6.13702275e-02f, -6.92798384e-03f, -4.32596244e-02f, 6.38888357e-03f, 8.53694510e-03f, 4.02439013e-02f, 3.36633660e-02f, 4.64645475e-02f, 1.54017219e-02f, -2.90153101e-02f,
  -1.31392768e-02f, 5.34620918e-02f, 2.72341631e-02f, 7.50706997e-03f, -1.09452810e-02f, 3.33342776e-02f, -1.71452446e-03f, -2.98648048e-02f, -2.25689821e-02f, -1.97503287e-02f,
  -3.56672406e-02f, -4.84603867e-02f, -2.24629194e-02f, -1.92888826e-02f, -9.53011774e-03f, 3.49631533e-02f, -2.74370611e-02f, -2.31164079e-02f, -2.30313186e-02f, -3.21170613e-02f,
  4.94045988e-02f, -3.37817371e-02f, 2.50451826e-02f, 2.35907529e-02f, 1.76028144e-02f, -2.74568927e-02f, -8.54267552e-03f, 4.31448184e-02f, 1.28494762e-02f, 2.23016143e-02f,
  3.13795432e-02f, -1.44643825e-03f, 7.19080269e-02f, -4.90726791e-02f, 1.18708685e-02f, -3.07523552e-02f, 1.33885872e-02f, -1.71843786e-02f, 5.69224805e-02f, -2.55468450e-02f,
  -7.30115473e-02f, 4.36425721e-03f, -2.41889595e-03f, -6.77440017e-02f, -1.10681988e-02f, 1.84551999e-02f, 2.92411335e-02f, 3.16969156e-02f, -5.22727109e-02f, -4.94728722e-02f,
  -2.97973603e-02f, 2.60097347e-02f, 2.72383410e-02f, 5.50304120e-03f, -2.72001550e-02f, 1.49403773e-02f, -8.42991192e-03f, 2.29941700e-02f, -3.83050404e-02f, 2.85420194e-02f,
  -2.14509442e-01f, 6.10972941e-02f, 1.76154643e-01f, -2.21751243e-01f, -1.89890862e-01f, -1.19818516e-01f, 6.29421100e-02f, -1.55861035e-01f, 9.75204259e-02f, -1.32994540e-02f,
  -2.74959188e-02f, 2.76777167e-02f, 2.45021075e-01f, -6.83029667e-02f, -6.56476840e-02f, 2.80944824e-01f, -1.27339706e-01f, 6.43255338e-02f, 5.31644188e-02f, -1.51203364e-01f,
  -3.88868339e-02f, -2.13877723e-01f, 1.78219065e-01f, -1.51006401e-01f, -2.31038749e-01f, -8.19988623e-02f, -1.93242311e-01f, 1.19132269e-02f, -2.83583432e-01f, -4.54106592e-02f,
  -1.45376837e-02f, 6.86069578e-02f, 1.47968177e-02f, 1.69594574e-03f, -6.72877207e-02f, 2.45683696e-02f, -3.03628854e-02f, 7.94577133e-03f, -1.55033171e-02f, 5.56448437e-02f,
  2.97376048e-03f, -4.85717738e-03f, -6.57883659e-02f, 6.21375144e-02f, -2.01053685e-03f, -1.98198622e-03f, 6.17600163e-04f, 2.77452748e-02f, 4.28839475e-02f, 2.71373391e-02f,
  1.45833984e-01f, 2.58308761e-02f, 2.29424331e-03f, -2.47290246e-02f, 3.63620669e-02f, -3.42120038e-04f, 8.98799896e-02f, 1.12300785e-02f, -6.60579503e-02f, -1.14051364e-02f,
  2.24019848e-02f, 5.13647646e-02f, 3.78602445e-02f, 8.86806939e-03f, 2.71299407e-02f, -8.64302646e-03f, -2.27339510e-02f, 5.06878980e-02f, 5.10234982e-02f, -3.94489523e-03f,
  -8.55021998e-02f, -1.00430120e-02f, 6.12549484e-03f, 8.86087939e-02f, -2.04661470e-02f, 3.66525445e-03f, -2.20504384e-02f, -2.85139270e-02f, 2.96332203e-02f, -9.08479374e-03f,
  7.11172521e-02f, -3.33103724e-02f, 4.00464889e-03f, 1.32503815e-03f, 5.99382259e-02f, 4.23385128e-02f, 2.39658318e-02f, 6.04298860e-02f, 9.27546527e-03f, -5.62819168e-02f,
  -2.72026002e-01f, -3.57492656e-01f, -2.80021802e-02f, -3.88094261e-02f, -4.91277389e-02f, -7.04184026e-02f, 6.19596243e-03f, 8.16145986e-02f, -3.82862128e-02f, -3.11166532e-02f,
  1.38732530e-02f, 5.86426351e-03f, -8.91549513e-02f, -5.62118664e-02f, -1.92597862e-02f, -7.02148583e-03f, -6.59685358e-02f, -7.09220916e-02f, -1.13209091e-01f, -6.83329031e-02f,
  -5.90401404e-02f, -8.98632035e-02f, -1.29110990e-02f, -5.32991178e-02f, -4.53351513e-02f, -4.91530858e-02f, -1.16401814e-01f, 4.56493497e-02f, -2.71861330e-02f, -7.50502199e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.90626785e-01f, 2.31506661e-01f, 1.97713986e-01f, 2.81043109e-02f, -3.02404650e-02f, 5.53299449e-02f, 1.33085445e-01f, -1.50155202e-01f, 6.15221225e-02f, 5.97548969e-02f,
  -7.14705288e-02f, 3.04779291e-01f, -1.66250765e-01f, -2.11251881e-02f, -2.58040786e-01f, -8.41555595e-02f, -6.24417439e-02f, 6.15390614e-02f, -3.08606238e-03f, 1.20357193e-01f,
  -6.59595802e-02f, -2.41660938e-01f, -7.78760463e-02f, -1.69271156e-01f, 4.88351174e-02f, 1.36080921e-01f, -1.04931280e-01f, -1.90721508e-02f, 1.07839763e-01f, -8.62501040e-02f,
  6.00106530e-02f, -6.78612813e-02f, 1.30945951e-01f, 6.28170520e-02f, 4.27536704e-02f, 7.22710043e-02f, 4.68901545e-02f, 9.38980654e-03f, 2.82665640e-02f, 1.05442494e-01f,
  1.30111232e-01f, -1.61233507e-02f, -2.84488928e-02f, -6.94878846e-02f, 3.59256938e-02f, 2.87030693e-02f, 1.40830679e-02f, 1.31593913e-01f, 1.07387580e-01f, 3.59043665e-02f,
  1.43660948e-01f, 2.26732269e-02f, 9.44364965e-02f, 6.98060617e-02f, 4.44409363e-02f, -1.80708282e-02f, 6.31489381e-02f, 5.83290532e-02f, 9.84262004e-02f, 2.80668051e-03f,
  -8.18117857e-02f, 1.39935557e-02f, -3.45213115e-02f, -2.42167171e-02f, 1.74719561e-02f, 2.03916002e-02f, 2.33946685e-02f, -3.57153639e-02f, 8.24757759e-03f, 3.21537368e-02f,
  -5.46237268e-02f, 2.16039742e-04f, -7.98803717e-02f, 7.76918232e-03f, 1.36576938e-02f, 8.49144161e-02f, 8.65487531e-02f, -2.15469301e-02f, -3.67453275e-03f, 1.62109695e-02f,
  -2.87540369e-02f, -6.41354620e-02f, 4.68560075e-03f, -1.26254596e-02f, 6.22599050e-02f, 1.63654995e-03f, 4.25767805e-03f, 3.50242369e-02f, 2.02157367e-02f, -9.84798148e-02f,
  -5.10379151e-02f, -1.65492501e-02f, 1.10935885e-02f, 1.91453025e-02f, -2.03844402e-02f, -2.82107145e-02f, 4.93226387e-02f, 5.96188903e-02f, -3.07006389e-02f, -9.60036442e-02f,
  3.83587815e-02f, 6.51173443e-02f, 4.24614847e-02f, 4.83570015e-03f, -2.86498666e-02f, -1.84376109e-02f, 6.49847016e-02f, -9.22646257e-04f, 2.14883145e-02f, 3.61403599e-02f,
  1.08546056e-01f, 4.92925197e-02f, 7.20969960e-03f, 8.74179751e-02f, -3.16997385e-03f, -6.53871447e-02f, -2.82742199e-03f, 5.95528521e-02f, 4.65745814e-02f, 3.57802920e-02f,
  -2.18286365e-02f, -1.07421964e-01f, -1.37853902e-02f, -2.01333612e-01f, -2.13141963e-01f, -2.11266220e-01f, -2.12225527e-01f, -8.50355104e-02f, 1.08010329e-01f, -6.13226965e-02f,
  -2.77500540e-01f, 2.59537280e-01f, 1.57674089e-01f, -2.37071693e-01f, 2.13366151e-01f, 2.01019421e-01f, -1.88840285e-01f, 1.65713299e-02f, -5.62424250e-02f, -2.68691093e-01f,
  1.31198363e-02f, -1.98393583e-01f, -1.26431569e-01f, -2.49393925e-01f, -3.56646806e-01f, -1.24790333e-01f, 2.90402658e-02f, -2.01750994e-01f, -1.76309630e-01f, -8.14393833e-02f,
  -9.40752178e-02f, 9.60284248e-02f, -5.97948506e-02f, 7.86956176e-02f, -3.64358984e-02f, 2.27358416e-02f, -1.67268403e-02f, 6.69939965e-02f, 1.88625660e-02f, 4.39248495e-02f,
  5.86210191e-02f, 8.45273882e-02f, -5.55418245e-02f, 7.76425824e-02f, -1.11591622e-01f, -8.97670686e-02f, -1.73903685e-02f, -6.49734586e-02f, 4.52539250e-02f, -9.94736329e-03f,
  -5.85964732e-02f, -5.54479435e-02f, -3.56188193e-02f, 7.05252513e-02f, -2.98774727e-02f, -1.44354338e-02f, 3.33595350e-02f, -3.08343023e-02f, -7.11065531e-02f, 1.45852733e-02f,
  3.04144062e-02f, 8.42426729e-04f, -4.08441946e-02f, -7.27555752e-02f, -2.19958741e-02f, -8.26027617e-02f, -2.65467702e-03f, 3.06664910e-02f, 5.98771870e-03f, -3.62265483e-02f,
  2.75414623e-02f, -2.07808837e-02f, -6.85516819e-02f, -5.55805564e-02f, -1.99523084e-02f, -1.37906102e-03f, -1.78429838e-02f, 3.08624525e-02f, -1.10445525e-02f, 2.92694625e-02f,
  1.45762134e-02f, 1.17700724e-02f, 1.87982041e-02f, -1.61502548e-02f, -4.25552391e-02f, -4.57275547e-02f, -1.41070373e-02f, 2.26413943e-02f, 2.65370756e-02f, -5.80607615e-02f,
  2.76313610e-02f, 6.49962127e-02f, 5.17924242e-02f, 4.09719013e-02f, 1.03607275e-01f, -6.30696490e-02f, 6.34543225e-03f, -2.82541607e-02f, 4.08421233e-02f, -7.48185348e-03f,
  -5.42917587e-02f, 4.95140441e-02f, -5.52601786e-03f, -4.82887700e-02f, 4.07452434e-02f, -2.88961921e-02f, -7.03421095e-03f, -1.67511310e-02f, 6.18586354e-02f, -2.26778332e-02f,
  1.10503538e-02f, 1.06756277e-01f, 1.14138320e-01f, -1.12404199e-02f, -3.61597538e-03f, -5.83718158e-02f, 6.22958913e-02f, 2.08257493e-02f, -3.47931869e-02f, 4.86443602e-02f,
  -2.65882581e-01f, 3.67074788e-01f, 5.62195331e-02f, -2.82707334e-01f, 9.02703926e-02f, -2.15641242e-02f, -1.17991298e-01f, 1.42673388e-01f, -1.28129244e-01f, -5.75461239e-02f,
  1.21391714e-02f, -2.68584080e-02f, 1.06223047e-01f, -2.55325139e-01f, -2.78966516e-01f, -7.09334016e-02f, -3.28428179e-01f, -2.03602344e-01f, -1.46880224e-02f, -2.15814169e-02f,
  -1.80218548e-01f, -1.15327664e-01f, -3.37374508e-02f, 2.61388958e-01f, -1.68953314e-02f, -6.00705808e-03f, -2.47236624e-01f, 1.66431829e-01f, -3.82821099e-03f, 2.95680426e-02f,
  -1.74195319e-01f, -3.45309563e-02f, -8.39226041e-03f, -5.43942191e-02f, -1.16959102e-01f, -4.02246751e-02f, -1.14842862e-01f, -1.45805450e-02f, -7.31802508e-02f, 4.36461531e-02f,
  7.48325139e-02f, 4.02111672e-02f, 3.91041897e-02f, 5.65363746e-03f, -6.68772729e-03f, -1.06592830e-02f, 1.28261233e-02f, -3.26453112e-02f, -1.78300142e-02f, 8.75944570e-02f,
  9.35356468e-02f, 3.47427614e-02f, -9.19789448e-02f, -1.22612126e-01f, -4.45336290e-02f, 4.32169288e-02f, -1.59182698e-02f, -8.02019387e-02f, 9.98413470e-03f, -7.79930279e-02f,
  2.11131871e-02f, -9.72827896e-02f, 1.40739363e-02f, 5.43837473e-02f, -4.63154865e-03f, -1.74484402e-02f, 1.40919548e-03f, -6.28791451e-02f, 1.16633112e-02f, -3.17543596e-02f,
  -1.52725941e-02f, -4.05248217e-02f, -1.72103464e-03f, -2.34226827e-02f, -7.82953128e-02f, -6.10511713e-02f, -8.74600746e-03f, 5.98729886e-02f, -4.49752286e-02f, 1.95985977e-02f,
  -5.35131730e-02f, -6.86949268e-02f, 8.14876184e-02f, -2.74338741e-02f, 1.42778894e-02f, -1.78602003e-02f, 2.41630431e-02f, -3.72144245e-02f, -3.53232287e-02f, -4.15575579e-02f,
  -2.32217208e-01f, -2.23132029e-01f, -3.65732349e-02f, -2.99429260e-02f, -1.74857676e-02f, 2.75858473e-02f, 1.41672641e-02f, -2.90915649e-02f, -1.12941109e-01f, -6.08960055e-02f,
  -4.08491045e-02f, -7.40746260e-02f, -7.47161806e-02f, 5.67141622e-02f, -2.68946644e-02f, -4.11988720e-02f, -5.64483069e-02f, -6.71813190e-02f, -7.34082013e-02f, 7.17580318e-03f,
  -3.73089351e-02f, -3.42003675e-03f, -1.40000612e-01f, 2.00532321e-02f, -8.19689035e-02f, -4.88919728e-02f, -1.11516781e-01f, -5.13647590e-03f, 1.02166310e-02f, 4.32755463e-02f,
  -3.73207331e-02f, 1.92081407e-01f, -3.06686293e-02f, -9.21446159e-02f, 1.41586214e-01f, -1.26496732e-01f, 9.88704115e-02f, 1.27673283e-01f, 5.99198695e-03f, 2.08123162e-01f,
  -4.04812992e-02f, 6.96626157e-02f, -2.17596907e-02f, -1.54644415e-01f, -6.11719847e-01f, -3.80367815e-01f, -2.42954403e-01f, -1.61116391e-01f, -2.10789561e-01f, -1.25646532e-01f,
  -1.66886613e-01f, -4.45473045e-02f, -4.13612602e-03f, 1.53379053e-01f, 1.13707341e-01f, 2.69267827e-01f, -2.05376633e-02f, 1.40313476e-01f, 2.09484957e-02f, -6.24193288e-02f,
  5.91714010e-02f, 9.13519338e-02f, 1.12415396e-01f, 1.14798985e-01f, 2.93737035e-02f, 4.73263934e-02f, 1.28986202e-02f, 8.18004608e-02f, -5.13824746e-02f, 3.08674481e-02f,
  -6.09957352e-02f, 1.45007372e-02f, 3.94188277e-02f, 4.99096289e-02f, 1.39818966e-01f, -5.32901613e-03f, 8.31446983e-03f, 2.19461583e-02f, 1.17684454e-01f, 3.17240618e-02f,
  -3.05910241e-02f, -1.40168937e-02f, -1.67680741e-03f, -2.32910663e-02f, -2.35907808e-02f, 5.68251833e-02f, 9.90246981e-03f, -5.68211041e-02f, -1.08957328e-02f, -5.96520193e-02f,
  7.12102186e-03f, 5.96444570e-02f, -5.89040630e-02f, 1.06217384e-01f, 7.93493353e-03f, -2.03869082e-02f, -2.87203211e-03f, -2.12475918e-02f, -2.52049733e-02f, -4.19955440e-02f,
  2.84101740e-02f, 7.99435005e-02f, 2.48103235e-02f, -3.38249952e-02f, -3.20672542e-02f, 4.31643203e-02f, -6.65084571e-02f, -8.15645829e-02f, 4.29130755e-02f, -3.11207455e-02f,
  -3.37365572e-03f, -5.06302975e-02f, 9.17045921e-02f, 3.25389318e-02f, -7.33487308e-02f, 4.68341745e-02f, -1.74487159e-02f, -3.04218736e-02f, -5.52726723e-03f, -1.73000097e-02f,
  -1.08625285e-01f, -2.03436822e-01f, 2.86902431e-02f, 4.15216088e-02f, -3.08352020e-02f, -5.72779253e-02f, -2.72460021e-02f, -6.13918640e-02f, -4.56013493e-02f, 1.10829594e-02f,
  5.89294136e-02f, 2.22676583e-02f, -7.36013725e-02f, -5.02101965e-02f, -3.21829915e-02f, 1.46480389e-02f, -1.77005380e-02f, -7.48489890e-03f, 8.86223763e-02f, -8.28454122e-02f,
  6.64669499e-02f, 2.29504402e-03f, 3.45243886e-02f, 1.75444351e-04f, 2.80548763e-02f, -3.64683233e-02f, -4.72176895e-02f, 6.05162270e-02f, 4.64757718e-03f, -4.15163413e-02f,
  2.01754138e-01f, -1.65005401e-01f, 1.21080942e-01f, 8.84806141e-02f, 2.67352849e-01f, 2.46667057e-01f, 2.79544622e-01f, -6.69884980e-02f, 4.20836918e-02f, -2.63488233e-01f,
  1.05295600e-02f, 1.55174002e-01f, 1.10223264e-01f, -2.37096623e-02f, 2.08157182e-01f, -9.55754593e-02f, -3.05514969e-02f, 2.57582162e-02f, 1.44598316e-02f, 6.33793399e-02f,
  4.26770337e-02f, -5.00770621e-02f, -9.84051898e-02f, -2.32453391e-01f, 8.35506096e-02f, -5.57471700e-02f, -4.05587219e-02f, 9.31053683e-02f, -2.21116871e-01f, 5.38379736e-02f,
  8.76997691e-03f, -2.50736903e-02f, -3.93741392e-03f, -9.67174172e-02f, -2.66388487e-02f, -8.59258175e-02f, 6.86952323e-02f, 1.29966393e-01f, 3.52991819e-02f, -5.15733548e-02f,
  4.89060916e-02f, 6.51466399e-02f, -1.12712629e-01f, 1.08004780e-02f, -5.34252562e-02f, -7.25224838e-02f, -8.41757655e-02f, -7.65293511e-03f, 2.68519539e-02f, 4.51970883e-02f,
  -1.27366446e-02f, -3.21358033e-02f, -2.95831775e-03f, -2.21697474e-03f, 1.27839865e-02f, 6.17554178e-03f, -4.21386585e-02f, 5.83020337e-02f, -4.16010171e-02f, -4.51631770e-02f,
  -3.05243675e-02f, -5.29761650e-02f, 5.25913760e-03f, 1.09052854e-02f, -4.97207418e-02f, -4.14165072e-02f, -6.71092346e-02f, 5.72772361e-02f, 3.41422744e-02f, 9.18120891e-02f,
  4.04097065e-02f, 2.21205875e-03f, 5.04986718e-02f, -3.49164498e-03f, -8.06045085e-02f, 7.61574581e-02f, -2.68945489e-02f, 5.49559370e-02f, 1.76304660e-03f, -3.17684114e-02f,
  -6.47491589e-02f, 1.47384368e-02f, 8.73139128e-02f, -2.54420750e-02f, -6.25213534e-02f, 4.34115864e-02f, -4.09757122e-02f, -3.43665518e-02f, -9.43034291e-02f, 7.10285679e-02f,
  -6.23901468e-03f, 6.81248382e-02f, -6.96351563e-05f, -1.90467406e-02f, -4.11594361e-02f, 1.38969952e-02f, 5.30202575e-02f, -8.73953626e-02f, -4.00006026e-02f, 6.96509629e-02f,
  -3.95933948e-02f, 2.45230235e-02f, 3.36465202e-02f, 2.37249192e-02f, 1.04026531e-03f, -5.33599593e-02f, 4.72997203e-02f, 7.74542848e-03f, -4.55700569e-02f, -4.40250151e-02f,
  -7.18305930e-02f, -5.74305071e-04f, 7.63995126e-02f, -2.07990147e-02f, -8.16758424e-02f, -4.85512987e-02f, -5.72467782e-02f, 7.47589045e-04f, -1.94225628e-02f, -2.80342856e-03f,
  1.74428914e-02f, -5.14177084e-02f, 1.07184248e-02f, 4.17155102e-02f, -1.99431423e-04f, 1.26354575e-01f, 4.68274429e-02f, -5.23434579e-02f, -9.99203846e-02f, -1.77003723e-02f,
  6.13010153e-02f, -1.79542266e-02f, -9.26441401e-02f, -6.64935410e-02f, -1.22965403e-01f, -1.31163731e-01f, -1.20433029e-02f, 1.98065788e-02f, -1.03531301e-01f, -7.15961978e-02f,
  8.33883062e-02f, -1.92167237e-01f, -5.20586260e-02f, -1.07426219e-01f, 8.46566036e-02f, -1.42543223e-02f, 5.48552237e-02f, -8.65625292e-02f, 1.05667107e-01f, -4.86495234e-02f,
  -3.09302974e-02f, -1.13560803e-01f, 6.11538477e-02f, 4.95386915e-03f, 1.53149124e-02f, 9.11346152e-02f, 8.92370716e-02f, -7.65447617e-02f, 6.96493536e-02f, -5.61314449e-02f,
  -2.57613580e-03f, -1.87950283e-02f, -6.08971268e-02f, 2.44305143e-03f, -3.24153006e-02f, -6.01689704e-02f, -3.59061803e-03f, 2.21220218e-02f, 1.27360430e-02f, 3.28198895e-02f,
  -5.12782298e-02f, -3.89465392e-02f, 8.67387801e-02f, 2.00933274e-02f, -4.97100465e-02f, 1.09096520e-01f, 6.59973249e-02f, 6.66315705e-02f, -1.71103310e-02f, -8.23405161e-02f,
  -5.82047887e-02f, -7.90239573e-02f, -3.48319821e-02f, -6.18043691e-02f, -5.69401458e-02f, 7.31469616e-02f, -5.09924479e-02f, -5.06871417e-02f, -7.12369233e-02f, 5.56086488e-02f,
  9.21100087e-04f, 5.98834679e-02f, -8.30736384e-02f, 2.44569127e-02f, 4.73092459e-02f, 1.13454973e-03f, -4.33653295e-02f, 6.57723919e-02f, -1.09603966e-03f, 6.35084137e-03f,
  5.72810508e-02f, 1.04973927e-01f, -8.29630271e-02f, -5.85375279e-02f, -8.58557150e-02f, 5.53136803e-02f, 9.02721751e-03f, 6.19546250e-02f, -7.22919181e-02f, -1.38299968e-02f,
  -7.76864812e-02f, -1.27667561e-01f, -6.95681274e-02f, 9.13546607e-02f, -1.83918718e-02f, -1.60516296e-02f, -3.46071608e-02f, -4.47388180e-02f, -8.57850984e-02f, 2.11170707e-02f,
  1.19293965e-01f, 5.69785899e-03f, -8.31127763e-02f, -7.24246353e-02f, 5.74081317e-02f, 2.76694093e-02f, -1.41887581e-02f, 1.12401778e-02f, 5.41397966e-02f, -1.30948657e-02f,
  -1.06300395e-02f, 5.62776923e-02f, 4.60121259e-02f, -6.04477562e-02f, 3.87538411e-02f, -1.62465181e-02f, 3.01094279e-02f, 2.09311000e-03f, -4.81681637e-02f, 6.84226921e-04f,
  1.69501603e-01f, -1.51091307e-01f, -4.22882944e-01f, -1.14597805e-01f, 1.87761962e-01f, 2.59288102e-01f, 2.08065026e-02f, 2.44507734e-02f, -2.84012854e-01f, 1.50018975e-01f,
  8.71960074e-02f, -8.74674991e-02f, -1.77572772e-01f, -1.70592312e-03f, -2.23972440e-01f, -3.28202486e-01f, 6.79200143e-02f, 4.60576499e-03f, -1.62466124e-01f, 1.71954006e-01f,
  -6.00065861e-04f, 4.31338549e-02f, -2.11617276e-01f, 1.26836911e-01f, 8.23473185e-02f, 6.58208057e-02f, 1.34229168e-01f, 2.58220807e-02f, 1.37628779e-01f, 3.95464972e-02f,
  5.94472438e-02f, -6.40738532e-02f, -3.01654786e-02f, -1.00355081e-01f, 8.77494290e-02f, 1.86800987e-01f, 1.43629415e-02f, -1.94341857e-02f, -1.41066045e-01f, -3.17050926e-02f,
  2.34190263e-02f, -4.66283895e-02f, -2.22099442e-02f, -4.84114029e-02f, 4.35705669e-03f, -4.71954979e-02f, -8.10771510e-02f, -8.03879499e-02f, -1.46331340e-01f, -8.10278431e-02f,
  -2.49598250e-02f, 3.80772725e-02f, -1.53433708e-02f, -2.82085110e-02f, -4.37490419e-02f, 7.16075487e-03f, 2.66426392e-02f, -4.24645469e-02f, 1.47360358e-02f, 1.53828401e-03f,
  6.02178834e-02f, 2.61084456e-02f, 1.50833316e-02f, -1.13160834e-02f, -1.21150380e-02f, -5.48820607e-02f, -3.94244641e-02f, -3.63111682e-02f, 1.86282396e-02f, 2.47456469e-02f,
  1.44953029e-02f, -5.76772615e-02f, -2.39000190e-02f, 6.20065667e-02f, -3.14677879e-02f, -7.74973854e-02f, 4.50136624e-02f, -1.84766063e-03f, -3.24856676e-03f, -1.73191540e-02f,
  -6.87382743e-02f, -7.86591135e-03f, 6.06676340e-02f, 5.88056669e-02f, -3.81930210e-02f, -2.44294815e-02f, 2.90420298e-02f, -3.09207216e-02f, 2.08516326e-02f, -5.29726036e-03f,
  1.39607936e-01f, 7.24953935e-02f, 7.10465619e-03f, -1.14832341e-03f, -7.34625906e-02f, 1.09186299e-01f, -2.83875633e-02f, 5.58471866e-02f, 4.74579558e-02f, 9.62515827e-03f,
  1.03500128e-01f, -6.24804944e-03f, 5.62840961e-02f, -4.40610684e-02f, -8.64450634e-02f, 1.00190528e-01f, -7.38436654e-02f, -4.77197766e-02f, 4.07157466e-03f, 3.38958204e-02f,
  -4.81972583e-02f, 3.70319486e-02f, 2.70821416e-04f, 5.25705479e-02f, 6.36193901e-02f, 6.64874688e-02f, 5.83269671e-02f, 3.79923061e-02f, -3.93028967e-02f, -7.54110813e-02f,
  -1.26456812e-01f, 1.13136284e-01f, -2.14749113e-01f, -1.61584601e-01f, -1.12449057e-01f, -1.68934479e-01f, -9.21741724e-02f, -4.97203646e-03f, -6.87249517e-03f, 2.55149961e-01f,
  4.59649786e-02f, -8.01720619e-02f, 1.66466653e-01f, 4.67563756e-02f, -3.28633636e-01f, 2.59364843e-02f, -1.22799337e-01f, 5.84522188e-02f, -1.88638605e-02f, -9.55200419e-02f,
  -7.17612952e-02f, -1.90809742e-02f, -1.07291691e-01f, -3.98606360e-02f, -3.52519043e-02f, -3.54057103e-02f, 5.88839576e-02f, 3.41356620e-02f, -6.08075224e-02f, -3.32059897e-02f,
  -1.90902442e-01f, -6.29181042e-02f, -5.97639754e-02f, 2.85783373e-02f, -4.65411693e-03f, -5.28137982e-02f, 5.06771691e-02f, -3.18105780e-02f, 1.25319818e-02f, 6.58606121e-04f,
  3.81590310e-03f, -3.76697443e-02f, -4.75328863e-02f, -5.95895899e-03f, 4.18139510e-02f, -9.46898237e-02f, -2.69625932e-02f, -8.00931901e-02f, -4.45428230e-02f, -1.10888571e-01f,
  -5.40420134e-03f, 3.60626727e-02f, 9.18450877e-02f, -2.50885673e-02f, -6.03419095e-02f, 1.15882620e-04f, 1.79644451e-02f, -7.75473565e-02f, -1.47174984e-01f, -7.85859302e-02f,
  6.56920522e-02f, 5.89570869e-03f, 7.20221475e-02f, 1.99209023e-02f, -6.07715622e-02f, 5.21545124e-04f, -3.10120136e-02f, -2.17141211e-02f, 9.66243595e-02f, 5.85121587e-02f,
  -4.57465313e-02f, 3.44631518e-03f, -5.49241602e-02f, -3.30387615e-02f, -4.78696898e-02f, -2.73092929e-02f, -4.45628576e-02f, 4.34735119e-02f, -8.71034861e-02f, -7.65374349e-03f,
  5.16394451e-02f, -1.07273068e-02f, 1.14327315e-02f, 7.65725179e-03f, -2.24133544e-02f, -4.29848954e-02f, -1.04604531e-02f, -8.18253160e-02f, -4.08674106e-02f, 2.66018361e-02f,
  1.84035450e-02f, -7.28032738e-02f, -5.26545197e-02f, 3.38766444e-03f, 7.20300376e-02f, -6.95654452e-02f, 1.52753480e-02f, 3.96329425e-02f, -3.11962124e-02f, 8.09152424e-02f,
  1.44131910e-02f, 1.22185173e-02f, -3.65701169e-02f, 3.32451351e-02f, 3.58319543e-02f, -7.09978119e-02f, 7.02392235e-02f, -5.28233014e-02f, -3.80407535e-02f, 3.11208959e-03f,
  6.03526197e-02f, -5.58469631e-03f, 5.25491163e-02f, 4.16184701e-02f, -2.66800467e-02f, 4.31621261e-02f, -6.82129636e-02f, -3.32888030e-02f, -2.63785664e-02f, -1.50008406e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -7.05363378e-02f, 1.34787679e-01f, 1.34129882e-01f, 2.30261147e-01f, 1.71764582e-01f, -1.05471658e-02f, 1.14217512e-01f, 1.37486473e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -3.09167150e-02f, -1.85472354e-01f, -2.34015778e-01f, -2.84400612e-01f, -2.84447163e-01f, -1.61956966e-01f, -1.12561351e-02f, 2.80938864e-01f, -1.37370735e-01f, -4.32351455e-02f,
  2.07960755e-01f, 4.38423902e-02f, 3.17011833e-01f, -1.14447236e-01f, 1.02674685e-01f, 1.72080576e-01f, -4.26229864e-01f, -2.18587294e-01f, 2.06343159e-02f, -5.30654848e-01f,
  3.46294820e-01f, -5.46077900e-02f, 1.69603735e-01f, -5.03010333e-01f, 2.88271517e-01f, 4.78733778e-02f, -2.91179150e-01f, -7.79003054e-02f, 1.72635630e-01f, 1.26220495e-01f,
  3.18181694e-01f, 7.38030970e-02f, 5.48233762e-02f, 9.78532732e-02f, -2.85289496e-01f, -2.59496808e-01f, 1.80756324e-04f, -6.51679933e-02f, -2.41049589e-03f, -1.64739475e-01f,
  5.08814342e-02f, -3.20715874e-01f, 3.96235026e-02f, -1.27380505e-01f, 4.09044057e-01f, -4.75901753e-01f, 1.02835573e-01f, -8.79053958e-03f, 9.98655930e-02f, -2.38169864e-01f,
  4.00794774e-01f, 4.01589185e-01f, -4.57543284e-01f, 1.87933534e-01f, -2.16535270e-01f, -6.75797239e-02f, 5.68817891e-02f, -3.03168684e-01f, -2.45711803e-01f, 2.10477069e-01f,
  1.33884892e-01f, 2.53851861e-01f, 1.96463197e-01f, -2.08441764e-01f, 1.75942570e-01f, 2.89598554e-01f, -2.67480612e-01f, 2.22730592e-01f, -2.60908045e-02f, 4.30489630e-01f,
  -1.41776726e-02f, -7.64746815e-02f, 1.88143685e-01f, -4.76895049e-02f, 3.17026436e-01f, -9.79258046e-02f, -4.22422625e-02f, -4.04400885e-01f, 3.67712110e-01f, 1.59036860e-01f,
  1.90204084e-02f, -4.71695065e-01f, 3.69392157e-01f, 9.11689624e-02f, -2.37652034e-01f, 3.20445985e-01f, 3.20474565e-01f, 4.92844135e-01f, -8.32067523e-03f, 2.36480594e-01f,
  -1.10615611e-01f, -2.38234594e-01f, 1.30385756e-01f, 1.93990871e-01f, -1.93338633e-01f, -1.14204906e-01f, 3.34326215e-02f, -1.24193907e-01f, 1.50277287e-01f, -2.01421469e-01f,
  1.06723450e-01f, -2.57144183e-01f, -4.66130264e-02f, 4.10253763e-01f, -1.46407291e-01f, -1.80435088e-02f, 4.48477983e-01f, 3.07143927e-01f, -5.53360693e-02f, 9.33201537e-02f,
  -1.44436266e-02f, -3.97221476e-01f, -5.45738451e-02f, -2.29327325e-02f, -6.25587776e-02f, 9.03446786e-03f, 1.73950136e-01f, 6.65308475e-01f, 2.07061172e-01f, 3.61125857e-01f,
  4.63587157e-02f, -1.29977956e-01f, 1.23626865e-01f, 2.56997824e-01f, 2.00012952e-01f, -6.31165579e-02f, -5.01292273e-02f, 3.36553119e-02f, 2.59700686e-01f, 8.67602527e-02f,
  -3.39791328e-01f, 5.56957582e-03f, -1.01961963e-01f, -5.47834486e-02f, -2.19271123e-01f, 1.77893981e-01f, -6.24197014e-02f, 2.57261574e-01f, 9.74786729e-02f, 2.85397023e-01f,
  -5.06526753e-02f, -5.64306498e-01f, 1.17118128e-01f, -1.48998797e-01f, 4.70714197e-02f, -5.26214838e-01f, 9.25540626e-02f, 3.72963160e-01f, 9.53436643e-02f, -4.56267819e-02f,
  2.55880296e-01f, 1.74730822e-01f, 5.76052628e-03f, -2.16210723e-01f, -1.26929209e-01f, 1.99243069e-01f, 5.71784377e-02f, 2.01259673e-01f, 4.49825153e-02f, 1.04406424e-01f,
  -6.84266761e-02f, 2.38405213e-01f, 4.26824484e-03f, -9.30530429e-02f, -2.73012072e-01f, 8.39546844e-02f, 8.07640254e-02f, 2.09808037e-01f, -2.24893883e-01f, -1.63751263e-02f,
  5.48951566e-01f, 5.56488000e-02f, 2.62692153e-01f, -4.65002984e-01f, 4.60638493e-01f, 1.06613547e-01f, -4.99603271e-01f, -4.40691084e-01f, 1.33305132e-01f, -4.61435199e-01f,
  1.82848126e-01f, 2.37907663e-01f, 3.57798070e-01f, -8.46014097e-02f, 2.80976415e-01f, 3.59130055e-02f, -4.63970713e-02f, -3.67839277e-01f, 2.19887704e-01f, -2.18086746e-02f,
  1.45047233e-01f, -1.49462074e-01f, -1.39036238e-01f, 1.67871416e-01f, 5.23956083e-02f, 4.88679409e-01f, -8.82951170e-02f, 5.86235104e-03f, -5.23456447e-02f, -1.26742199e-01f,
  7.74066746e-02f, -3.74124885e-01f, -2.28865594e-01f, -9.62688625e-02f, 4.13255781e-01f, 2.19121963e-01f, 3.38529915e-01f, 1.68671086e-01f, 9.05074477e-02f, -2.42993683e-01f,
  4.76104796e-01f, 2.31586233e-01f, -3.04454327e-01f, -2.96404600e-01f, -1.28386877e-02f, -1.54792387e-02f, -2.16842771e-01f, -2.70771235e-02f, -6.12400137e-02f, -2.39616811e-01f,
  4.99976473e-03f, -2.05224454e-01f, -1.06748333e-02f, 1.08698562e-01f, -1.07664518e-01f, 6.91189244e-02f, 4.77866381e-02f, 1.77596137e-01f, -6.03323653e-02f, 1.87927321e-01f,
  1.32828243e-02f, -2.10066378e-01f, -2.92086422e-01f, 7.98055530e-02f, -3.35122377e-01f, -1.43987760e-01f, -1.25279486e-01f, -3.33617896e-01f, -6.76363260e-02f, -1.53872207e-01f,
  4.32606846e-01f, -5.15118003e-01f, 1.33570626e-01f, 2.23345980e-01f, -2.98076659e-01f, 5.28141797e-01f, 7.71043450e-02f, 2.26694405e-01f, -1.44534349e-01f, 3.30215722e-01f,
  -7.55002797e-02f, -1.92178607e-01f, 1.64467186e-01f, 1.00071341e-01f, -2.45420560e-01f, -9.44774449e-02f, -3.74362022e-01f, -6.29503876e-02f, 2.59655297e-01f, 4.81605232e-01f,
  -2.19178855e-01f, 1.19665913e-01f, 2.42176622e-01f, -8.11046362e-02f, -8.83076116e-02f, -1.89002380e-01f, -4.74200219e-01f, -3.40198904e-01f, 2.42623478e-01f, 2.82697678e-01f,
  1.29613712e-01f, 1.92027137e-01f, 2.66401082e-01f, 7.12070391e-02f, 2.36811727e-01f, -1.73574701e-01f, -5.09291470e-01f, 4.09159869e-01f, -2.15552449e-01f, -5.96144944e-02f,
  -2.04792902e-01f, 1.98805705e-01f, 3.24081965e-02f, -2.50179529e-01f, 1.57179922e-01f, -4.19332646e-02f, -2.13426784e-01f, -3.29630613e-01f, -5.34395166e-02f, -1.52256578e-01f,
  1.16714805e-01f, 4.59447175e-01f, 1.60862133e-01f, 7.05881938e-02f, 1.70692224e-02f, -1.28594562e-01f, 1.75499409e-01f, -1.79748133e-01f, 5.83790801e-02f, -5.91047108e-02f,
  2.30907574e-01f, 4.05196339e-01f, 4.29099232e-01f, 6.11639880e-02f, -3.27330887e-01f, -6.18744642e-02f, 1.95140287e-01f, -4.58638757e-01f, 2.89228976e-01f, -4.28223699e-01f,
  1.18775479e-01f, -3.35264462e-03f, -2.35304371e-01f, 3.33262175e-01f, -1.63138285e-01f, -2.34165534e-01f, -1.03164390e-01f, -2.28041470e-01f, -1.29824847e-01f, 1.67235881e-01f,
  -2.41910413e-01f, -3.07538331e-01f, -1.58298612e-01f, -3.35953623e-01f, 1.72112867e-01f, -7.41436556e-02f, -6.51461408e-02f, 3.94905917e-02f, -4.42316949e-01f, 1.98142469e-01f,
  1.36660054e-01f, 1.29888371e-01f, -4.35264796e-01f, 1.37835383e-01f, -2.39910915e-01f, 2.18911171e-01f, 1.79784998e-01f, 4.42261010e-01f, -4.14461225e-01f, -2.08393887e-01f,
  2.29421586e-01f, 3.03487033e-01f, 3.93033594e-01f, 3.42955798e-01f, 1.89012110e-01f, 1.63808659e-01f, 2.17547536e-01f, 8.32775906e-02f, -1.88812464e-01f, 1.18652850e-01f,
  -2.92668432e-01f, 5.52826673e-02f, 2.37872109e-01f, 1.79214910e-01f, -1.92717016e-01f, 3.92030507e-01f, -1.22609049e-01f, 1.58722587e-02f, 1.92578626e-03f, -1.68272436e-01f,
  7.96002224e-02f, -3.20560694e-01f, -9.89463702e-02f, -6.78616017e-02f, 3.43282521e-01f, 1.39584467e-01f, 4.11296576e-01f, -7.47430027e-02f, 1.70261756e-01f, -2.17435896e-01f,
  4.17449117e-01f, 3.50114167e-01f, -2.31845945e-01f, -2.21195877e-01f, -1.60714954e-01f, 6.48116842e-02f, -7.94451237e-02f, -1.34653553e-01f, -1.95849523e-01f, -2.58135438e-01f,
  1.52038932e-01f, 9.48187336e-02f, 1.89178046e-02f, 1.27954874e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.38822645e-01f, 7.71016777e-02f, 1.01899959e-01f, 1.03619970e-01f, 3.75524253e-01f, -1.50043577e-01f, 1.51374444e-01f, 2.69748755e-02f, 1.30750209e-01f, 1.22200817e-01f,
  3.47145740e-03f, -4.39420119e-02f, 2.59590805e-01f, 8.64119604e-02f, -3.55461165e-02f, 2.83997566e-01f, 1.70329079e-01f, 4.16156262e-01f, -2.55506933e-01f, -4.94896472e-01f,
  -2.25514416e-02f, -2.53371179e-01f, -6.66616336e-02f, -4.83380616e-01f, -1.38381988e-01f, -6.02901913e-02f, -1.09182298e-01f, 1.09602347e-01f, 1.13576055e-01f, 4.55584824e-02f,
  1.47660509e-01f, 1.96495615e-02f, 1.79917868e-02f, -9.27511007e-02f, -6.14052936e-02f, 2.01923698e-02f, 8.08188543e-02f, 1.50199965e-01f, -1.41020358e-01f, 1.00135066e-01f,
  -8.36709216e-02f, 2.85139173e-01f, 1.87745363e-01f, 2.35742852e-01f, -1.75570175e-01f, -3.62712204e-01f, -8.06314424e-02f, -3.92583460e-01f, -2.41889223e-01f, 1.24077901e-01f,
  -3.19916755e-01f, 1.54074933e-03f, 3.34238291e-01f, 5.43327108e-02f, 2.40838438e-01f, 7.30127618e-02f, 4.29233402e-01f, 4.37407605e-02f, 1.29139006e-01f, 1.84916899e-01f,
  -9.29012150e-02f, -5.05995527e-02f, -5.51595539e-02f, 7.85568506e-02f, 1.84511170e-01f, 1.44915044e-01f, 3.86022568e-01f, 3.36169928e-01f, 3.82544339e-01f, 5.51117718e-01f,
  -3.22601199e-02f, 1.95454106e-01f, -8.76266584e-02f, 1.29490599e-01f, 3.01993906e-01f, 1.12678729e-01f, -5.06618321e-01f, -4.97606844e-02f, 9.85325500e-02f, -9.22406539e-02f,
  -1.04043134e-01f, 4.94971797e-02f, -9.03096646e-02f, 1.15986634e-02f, 4.43007201e-01f, 2.69951165e-01f, 5.61191142e-01f, 5.01975358e-01f, 1.24875553e-01f, 5.15833616e-01f,
  4.33937311e-01f, 3.64230275e-02f, -2.34818399e-01f, -3.23018357e-02f, -3.53685170e-01f, 2.27033973e-01f, 9.80828404e-02f, 5.65419123e-02f, 1.17685236e-01f, -4.15984765e-02f,
  5.10777347e-02f, -1.05096459e-01f, 2.25448713e-01f, 1.15366593e-01f, 3.72321121e-02f, 3.03352624e-01f, 6.24964479e-03f, -9.45542529e-02f, 2.08987668e-01f, -1.68152139e-01f,
  -9.28287655e-02f, 3.38663086e-02f, 1.33521110e-01f, -2.12811768e-01f, 2.32125193e-01f, 1.96367502e-01f, 1.47485599e-01f, -7.17950426e-03f, -2.25631028e-01f, -2.76893616e-01f,
  -1.23008348e-01f, -1.29244342e-01f, 1.31192282e-01f, 4.02522124e-02f, 6.00805646e-03f, -1.74829196e-02f, 3.93226206e-01f, -1.35287049e-03f, 3.85398328e-01f, -2.92040333e-02f,
  2.25636810e-01f, 1.10154361e-01f, 3.52020562e-01f, -1.98719762e-02f, 3.68572533e-01f, 5.54520249e-01f, -6.56120181e-02f, 2.39821017e-01f, 5.31468034e-01f, 2.54207999e-01f,
  2.61608243e-01f, -4.93751913e-01f, 7.29538351e-02f, -6.19098008e-01f, 1.32272795e-01f, -2.59060323e-01f, -2.96954691e-01f, 1.01842806e-01f, -5.59397563e-02f, 8.08598876e-01f,
  1.97334319e-01f, -5.31635433e-02f, 3.32694530e-01f, 3.04322410e-02f, 1.49999205e-02f, -1.43033624e-01f, 4.82247621e-01f, 5.74333481e-02f, -1.36805251e-01f, -3.81175578e-01f,
  1.76231503e-01f, 4.33255643e-01f, 1.15530834e-01f, 3.01087171e-01f, 4.16119128e-01f, 1.25046015e-01f, 4.30807732e-02f, 6.57674223e-02f, -4.64468636e-03f, 3.06921005e-01f,
  -3.15660872e-02f, 5.02145849e-02f, -3.18330556e-01f, 1.98470771e-01f, -2.10812166e-01f, 4.61620897e-01f, 1.92790404e-01f, 5.89029312e-01f, -2.61985871e-04f, 1.59930423e-01f,
  -3.75863165e-01f, 2.02096522e-01f, 2.81919718e-01f, 1.59120902e-01f, -3.88586447e-02f, -2.01546744e-01f, 6.14013672e-01f, 4.79333371e-01f, -2.17376441e-01f, 1.19163148e-01f,
  3.08510274e-01f, 2.79643357e-01f, -6.82872981e-02f, 1.24082580e-01f, -9.20786038e-02f, 1.76180929e-01f, 2.67757177e-02f, -1.16927765e-01f, 6.02056421e-02f, -7.93914273e-02f,
  2.49016341e-02f, 1.68533817e-01f, -1.51034325e-01f, 1.55413136e-01f, 2.66781598e-01f, -1.73863590e-01f, -1.48542181e-01f, 6.59192950e-02f, 3.45761389e-01f, -3.54565233e-02f,
  -1.95391905e-02f, 2.55126357e-01f, -2.51968894e-02f, -1.47699043e-01f, -2.12423146e-01f, 7.84832984e-03f, 2.33899187e-02f, -4.23696823e-02f, -1.03144966e-01f, -2.62356568e-02f,
  8.39901492e-02f, -9.13662240e-02f, 1.49644157e-02f, -9.12795216e-02f, 1.37830839e-01f, 9.46318433e-02f, -7.90458918e-02f, 1.95667773e-01f, 8.73897746e-02f, 1.30433172e-01f,
  2.12782189e-01f, 1.72508106e-01f, 4.85374592e-02f, 1.98281765e-01f, 1.12222508e-01f, -5.44875162e-03f, 8.51161033e-02f, -1.45046234e-01f, 3.31467927e-01f, 1.99247062e-01f,
  -3.64655137e-01f, -1.83044687e-01f, 2.75581956e-01f, -1.74518764e-01f, 4.45856333e-01f, -3.60445708e-01f, -2.18823571e-02f, -2.28068784e-01f, -1.45497039e-01f, 2.73525387e-01f,
  -1.73177898e-01f, -2.46248811e-01f, 7.22642317e-02f, -3.18960436e-02f, 2.71585017e-01f, 1.27385184e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.73574054e-01f, -1.49336131e-02f, 2.75632977e-01f, 2.78715976e-02f, 3.40860307e-01f, 2.92592287e-01f, 8.07182714e-02f, 2.53428370e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  9.04125422e-02f, 3.31436098e-01f, -6.49007142e-01f, 4.43887353e-01f, -1.91267490e-01f, 4.03717130e-01f, 1.73783720e-01f, 3.10493916e-01f, -4.26129848e-01f, -6.07821010e-02f,
  1.24236383e-01f, -3.22688930e-02f, -4.26941276e-01f, 2.67675798e-02f, 6.08946383e-01f, -2.27399230e-01f, 4.73407090e-01f, 2.38055646e-01f, 5.89848220e-01f, -2.39029825e-01f,
  -8.10325265e-01f, 4.13133115e-01f, -6.18642449e-01f, 5.72647750e-01f, -3.07558268e-01f, -5.37703931e-03f, 3.53146702e-01f, -2.66350240e-01f, -7.19676733e-01f, -5.69847375e-02f,
  3.84280086e-02f, 1.83102235e-01f, 9.85181332e-02f, 3.01098049e-01f, 5.63978195e-01f, 1.65198848e-01f, 2.40268454e-01f, -1.97099403e-01f, -8.77243280e-02f, 6.27471805e-02f,
  4.13353741e-01f, -2.23249216e-02f, -7.49039531e-01f, 2.83780303e-02f, 6.93829596e-01f, 5.14818311e-01f, 2.97792286e-01f, -1.80305436e-01f, -5.32678999e-02f, 8.18260789e-01f,
  7.57358551e-01f, -5.16801834e-01f, -1.48566246e-01f, 5.62710047e-01f, 2.31633335e-01f, 3.89484167e-01f, -8.55718255e-02f, -4.98948991e-02f, -5.64072907e-01f, 3.86191100e-01f,
  -1.73058078e-01f, -5.00594616e-01f, -5.24324887e-02f, 6.25427961e-01f, 6.60901442e-02f, -2.22337544e-02f, 4.58312124e-01f, -3.94684672e-01f, 2.65271097e-01f, 8.38533044e-02f,
  -1.26858190e-01f, 2.07607791e-01f, 3.29986304e-01f, 1.01094484e-01f, -5.76766551e-01f, -6.06417879e-02f, -4.85325694e-01f, 6.78267241e-01f, 1.41805366e-01f, -7.16043591e-01f,
  4.88165289e-01f, -7.14508176e-01f, 2.99611509e-01f, 6.94825649e-01f, 3.89071584e-01f, -5.14512002e-01f, -1.07481711e-01f, 6.27242804e-01f, 5.89458384e-02f, -2.43866444e-01f,
  -5.88403761e-01f, 4.35634196e-01f, -3.69492769e-01f, 1.14288829e-01f, 4.79698688e-01f, -1.23494186e-01f, -2.90863067e-01f, -7.87216187e-01f, -3.27038080e-01f, -2.47943714e-01f,
  2.45847374e-01f, -5.52239001e-01f, -4.63452414e-02f, -3.03620964e-01f, 1.42829403e-01f, 2.04424411e-01f, -3.04019243e-01f, -3.92753452e-01f, -4.36590314e-01f, -1.66405067e-01f,
  -6.91344917e-01f, 3.45132738e-01f, -2.64991134e-01f, -4.47388619e-01f, -2.52020687e-01f, -6.04695380e-01f, -4.54724938e-01f, -7.83881396e-02f, 5.39014816e-01f, -2.13202029e-01f,
  -1.49194255e-01f, 2.31123820e-01f, 3.23434800e-01f, 7.34051764e-02f, -5.11872649e-01f, 6.64187372e-01f, 1.45050153e-01f, -4.47858907e-02f, -6.29737020e-01f, 3.55971873e-01f,
  -6.20181561e-02f, 1.18629523e-01f, 5.65883040e-01f, 4.80192810e-01f, 1.97668731e-01f, 1.46007076e-01f, 4.42487657e-01f, 4.38743353e-01f, 4.09331411e-01f, 2.00292021e-01f,
  -4.53933269e-01f, -3.54699254e-01f, 5.36386251e-01f, 3.74920607e-01f, -2.45507896e-01f, -5.62661439e-02f, -5.22433482e-02f, 2.91725874e-01f, 4.10353601e-01f, -2.73011565e-01f,
  9.36407298e-02f, 8.17460567e-03f, -4.15493011e-01f, -3.96167748e-02f, 4.90827322e-01f, 7.81915560e-02f, 1.50437191e-01f, 5.25723636e-01f, -1.26004502e-01f, -4.72570151e-01f,
  1.73202470e-01f, -1.81842580e-01f, -2.09676288e-02f, 1.24299489e-02f, -8.36839527e-02f, -8.53296936e-01f, 2.58232743e-01f, 2.37465799e-01f, -7.66407773e-02f, 2.10901685e-02f,
  4.60552871e-01f, 3.56094360e-01f, 4.69343543e-01f, -7.59760976e-01f, 4.57544476e-01f, 1.95152685e-01f, 1.97162315e-01f, 6.66216731e-01f, -4.31537092e-01f, 9.93579477e-02f,
  -4.90243375e-01f, 4.39510912e-01f, -1.74627870e-01f, -2.27642536e-01f, 8.00053999e-02f, 3.52705538e-01f, 4.39803004e-01f, 1.03010014e-01f, 4.41705704e-01f, -6.64247096e-01f,
  -6.75776182e-03f, 3.88288587e-01f, -9.59784836e-02f, 3.27748597e-01f, 1.56463042e-01f, -2.18067899e-01f, -3.73042785e-02f, 2.07880139e-01f, 1.43841177e-01f, 1.85257480e-01f,
  -1.84419693e-03f, -3.77710253e-01f, 2.49637291e-01f, 4.12867963e-01f, -3.37677777e-01f, 6.08110547e-01f, 3.53127897e-01f, 4.57216084e-01f, 5.02628982e-01f, -2.30934039e-01f,
  -8.27116668e-01f, 3.83416414e-01f, -5.61651826e-01f, -8.43754053e-01f, -4.82287258e-01f, -8.31529275e-02f, -1.18497968e-01f, 7.85813704e-02f, -3.89785856e-01f, 1.05896853e-01f,
  8.25011849e-01f, -4.64285702e-01f, 1.53418362e-01f, -4.15555507e-01f, -9.40082595e-02f, -6.55997694e-01f, 1.27034873e-01f, 2.97073662e-01f, -6.50496960e-01f, 7.61811882e-02f,
  2.90612131e-01f, 2.70656079e-01f, -5.15048690e-02f, -4.99578357e-01f, 2.77450401e-02f, -4.01590429e-02f, -3.82169247e-01f, -1.06973387e-01f, 1.37565300e-01f, -1.74799338e-01f,
  -6.03511930e-01f, -2.61549145e-01f, -3.07069659e-01f, 4.38842028e-01f, 8.45568180e-01f, 5.81796169e-01f, 7.42182255e-01f, -3.67389351e-01f, -1.30267330e-02f, -8.47797766e-02f,
  6.62312925e-01f, -2.88343847e-01f, -4.23324287e-01f, 4.91389222e-02f, -2.54592359e-01f, 2.83489637e-02f, 3.11517268e-01f, 2.54415631e-01f, -5.12388721e-03f, 1.07351497e-01f,
  -3.50295573e-01f, 5.26380092e-02f, 1.47424161e-01f, -2.34611288e-01f, 1.86260045e-01f, -3.76624346e-01f, 7.90659115e-02f, 3.16640198e-01f, -1.94287881e-01f, -3.57518613e-01f,
  -9.46864545e-01f, -2.53372848e-01f, -7.09855020e-01f, -8.78764808e-01f, 4.59047765e-01f, -6.03498042e-01f, 4.77655351e-01f, 5.96425593e-01f, -5.86861134e-01f, 2.89857775e-01f,
  6.24921858e-01f, -1.29240900e-01f, -4.60882515e-01f, -1.77134812e-01f, -9.01545510e-02f, -1.27517760e-01f, 1.09761946e-01f, 3.81676741e-02f, 1.35179341e-01f, -1.73902705e-01f,
  -8.27482522e-01f, -5.27869463e-02f, -1.09195925e-01f, -4.89024937e-01f, 8.08861852e-02f, -2.66034126e-01f, 2.25606129e-01f, 1.86773881e-01f, 3.26939262e-02f, -2.48121634e-01f,
  -1.03603870e-01f, 4.68205631e-01f, -1.96620915e-02f, 4.57311481e-01f, 1.72773063e-01f, 5.98239660e-01f, 5.46603918e-01f, 7.76978552e-01f, 9.49225307e-01f, -1.01886936e-01f,
  -4.11172867e-01f, 2.80580580e-01f, -7.82946795e-02f, -8.75715986e-02f, -2.05826610e-01f, -9.33927074e-02f, 7.61922300e-01f, -2.80242294e-01f, 1.27842128e-01f, -1.98311880e-02f,
  2.14841321e-01f, 1.51114956e-01f, 1.07875533e-01f, 9.64317024e-02f, 1.68825448e-01f, 2.20204756e-01f, -6.78365305e-02f, -7.67318785e-01f, -3.91573429e-01f, 1.95194289e-01f,
  6.10945463e-01f, 4.26665656e-02f, 6.15147591e-01f, -7.99947418e-03f, -4.77623224e-01f, -1.95713148e-01f, -2.45768249e-01f, -5.68589568e-02f, -4.28120762e-01f, -2.80819893e-01f,
  -4.98898536e-01f, -6.01709783e-02f, 2.74343073e-01f, -5.68639100e-01f, 5.33639371e-01f, -6.30651787e-02f, -4.12428141e-01f, 1.61857277e-01f, -3.33381534e-01f, 6.97629929e-01f,
  -1.17347918e-01f, 6.37389123e-02f, -4.28116787e-03f, 2.27509201e-01f, 3.57137501e-01f, -3.41016114e-01f, 5.46556860e-02f, 9.34418589e-02f, -7.63001382e-01f, 1.05645336e-01f,
  -6.91428661e-01f, -6.74182028e-02f, -1.12788260e-01f, -3.94195020e-01f, 2.24553451e-01f, -2.89573759e-01f, -2.91696131e-01f, -8.41057301e-02f, 3.19077045e-01f, 1.72369137e-01f,
  -2.13855356e-01f, -4.88398731e-01f, -2.62318730e-01f, -5.64314127e-01f, 5.44204175e-01f, -3.46111059e-01f, -1.42483562e-01f, 8.03716898e-01f, 4.14950877e-01f, -1.35416072e-02f,
  3.53944242e-01f, -9.01599303e-02f, -5.83838560e-02f, -2.32642710e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.44463697e-01f, 1.54052407e-01f, 2.02883095e-01f, -1.57884896e-01f, -2.03533456e-01f, -3.33813801e-02f, -1.13076810e-02f, -1.67123731e-02f, 2.02244252e-01f, 9.65614542e-02f,
  -2.33613234e-02f, -1.58867482e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    