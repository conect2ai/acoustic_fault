/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.30245280e-01f, 1.80522963e-01f, -1.76136926e-01f, 5.48779257e-02f, 2.88430154e-01f, 2.73621589e-01f, 1.13191884e-02f, 1.05191976e-01f, 2.26786345e-01f, -5.52397259e-02f,
  -8.93596467e-03f, -6.46177977e-02f, -1.47691235e-01f, 6.28600270e-02f, -1.27489015e-01f, -2.14683309e-01f, -8.57632142e-03f, -2.55335160e-02f, 1.35344714e-01f, 9.94359106e-02f,
  -8.05402473e-02f, 1.66375801e-01f, -1.78890407e-01f, 7.55106881e-02f, 4.45377342e-02f, 1.58326346e-02f, -1.35837480e-01f, -4.88449726e-03f, 5.94582930e-02f, 6.58859015e-02f,
  8.82416219e-02f, -7.20239058e-02f, 3.61422040e-02f, -9.90242511e-02f, 8.04933235e-02f, -1.41094625e-02f, -4.54109088e-02f, -4.17918414e-02f, 1.97504181e-02f, 1.65294614e-02f,
  1.33320782e-02f, -3.66866738e-02f, 3.82146500e-02f, -2.89251767e-02f, 5.39363623e-02f, -5.69605082e-02f, 1.62922759e-02f, 2.67364588e-02f, 4.73526716e-02f, -3.48605327e-02f,
  8.69235117e-03f, 5.30496240e-02f, -3.58880050e-02f, 5.20814434e-02f, 2.67259199e-02f, 3.50303464e-02f, -7.23558068e-02f, 2.89620049e-02f, 2.52304170e-02f, 6.31745458e-02f,
  1.69567261e-02f, -8.15461762e-03f, -1.45178493e-02f, 3.73594761e-02f, 3.47666852e-02f, 1.25710410e-03f, 7.11322576e-02f, -3.07886358e-02f, 2.49865502e-02f, -2.91339606e-02f,
  3.33431698e-02f, -1.05001060e-02f, 6.25463054e-02f, -2.45395936e-02f, 1.03556979e-02f, 3.59629989e-02f, -3.25146806e-03f, 4.72303331e-02f, 3.10992282e-02f, -1.52612338e-02f,
  2.04389216e-03f, -2.12308653e-02f, -3.12460568e-02f, 1.42667368e-02f, 1.30980471e-02f, -2.41716541e-02f, -2.51868702e-02f, 2.56380904e-02f, 3.15770172e-02f, -1.14806974e-02f,
  3.09041500e-01f, 1.43880904e-01f, 6.93322867e-02f, 5.65028600e-02f, 1.50867617e-02f, -2.48241872e-02f, -1.54249202e-02f, -7.66591169e-03f, -2.23485995e-02f, -1.08257914e-02f,
  2.01449543e-02f, 2.21758839e-02f, -1.57903391e-03f, 1.29495841e-02f, -6.95915241e-03f, -2.65351385e-02f, -2.75578187e-03f, 5.53601608e-02f, 5.82407415e-02f, 8.35552365e-02f,
  2.76440498e-03f, 5.70942126e-02f, -5.78146335e-03f, -1.49051156e-02f, -5.57255447e-02f, 1.66057628e-02f, 9.61127952e-02f, -3.01018590e-03f, -2.31746193e-02f, -6.20852970e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.38340101e-01f, -3.50713670e-01f, 3.34196180e-01f, 4.53669503e-02f, 4.05685842e-01f, 1.57578424e-01f, 4.18528169e-01f, -1.43296748e-01f, -7.17787519e-02f, -5.43561995e-01f,
  -2.05297843e-01f, -3.58356535e-02f, 5.19820228e-02f, -1.09176509e-01f, 3.08572471e-01f, 8.29761252e-02f, -5.79692312e-02f, -1.18538037e-01f, 1.15516089e-01f, 1.22207217e-02f,
  8.12797397e-02f, 7.13030919e-02f, 2.72482157e-01f, -1.99254990e-01f, 3.38225253e-02f, -4.99533042e-02f, 7.73045719e-02f, 2.39384040e-01f, -2.11441264e-01f, 6.86069801e-02f,
  3.20858248e-02f, -4.88691740e-02f, 6.51747128e-03f, -1.01698153e-01f, 1.50140338e-02f, -4.75692414e-02f, 7.87474662e-02f, 1.86216414e-01f, 3.20653468e-02f, -2.62309629e-02f,
  -2.48063859e-02f, 6.54923916e-03f, -1.78057384e-02f, 7.77621381e-03f, 3.14268358e-02f, -5.43279797e-02f, 8.28532577e-02f, 1.17189121e-02f, -2.89274305e-02f, 6.65490627e-02f,
  5.94578274e-02f, 3.87532562e-02f, 4.40505482e-02f, -5.77146634e-02f, 3.78897376e-02f, -2.51567233e-02f, 9.02839378e-02f, 6.68714941e-02f, -6.49618432e-02f, -5.09816641e-03f,
  -5.43769188e-02f, -7.16452599e-02f, -4.82173637e-02f, -1.06443670e-02f, -4.34003919e-02f, -1.06500842e-01f, 5.27174436e-02f, -3.74494381e-02f, 5.22652566e-02f, -2.00156160e-02f,
  1.21907713e-02f, 2.10423134e-02f, 4.41819318e-02f, -1.89485922e-02f, -2.07708012e-02f, -5.64042367e-02f, 1.73718408e-02f, 1.73224881e-02f, 6.24898039e-02f, 5.72650470e-02f,
  -5.21614291e-02f, 2.14422718e-02f, 8.73526745e-03f, 1.54558560e-02f, -1.73561163e-02f, 9.07962024e-02f, 6.37911362e-05f, -6.93552848e-03f, 8.42759535e-02f, 2.20881868e-03f,
  -1.16733059e-01f, -3.72588843e-01f, 5.77538274e-03f, -3.21972221e-02f, 3.66022922e-02f, -2.37356704e-02f, -1.34468814e-02f, -4.97305579e-02f, -4.02355716e-02f, -2.98609268e-02f,
  -3.15891542e-02f, 2.47999821e-02f, 4.10725735e-02f, 3.34689617e-02f, 2.95390468e-02f, -4.62980792e-02f, 4.67075072e-02f, -1.42830964e-02f, 3.91470343e-02f, -6.83329999e-02f,
  -7.60423765e-03f, -5.99031220e-04f, 9.53797903e-03f, 1.77412760e-02f, -1.34837267e-03f, -1.78303532e-02f, -6.24893866e-02f, -5.45627512e-02f, 1.81549264e-03f, -2.88193058e-02f,
  4.19937551e-01f, 2.07786616e-02f, 1.94619656e-01f, 1.11595601e-01f, -1.84658289e-01f, 3.88945937e-02f, 2.12814808e-01f, -9.82516333e-02f, 7.11105689e-02f, 2.38927808e-02f,
  -3.10271326e-02f, 3.02086323e-01f, -1.02156233e-02f, 3.95745523e-02f, -4.51930799e-02f, -4.83928248e-02f, 5.23952171e-02f, 1.14983231e-01f, -6.56269640e-02f, 1.41210601e-01f,
  5.17006181e-02f, -8.92278776e-02f, -6.03731535e-02f, -2.60405779e-01f, 5.59303863e-03f, 2.24067140e-02f, -2.48455718e-01f, -2.27884986e-02f, -7.62574822e-02f, 1.53931025e-02f,
  4.96580899e-02f, -4.93407287e-02f, -4.44893576e-02f, 4.90845256e-02f, -2.90451776e-02f, -1.44128520e-02f, 4.69793007e-02f, 1.83839910e-02f, -1.96603313e-02f, 1.59133095e-02f,
  3.96425575e-02f, -5.57066761e-02f, 8.28898400e-02f, -1.49793085e-02f, 1.93987116e-02f, 5.38844801e-02f, 3.36122625e-02f, 1.45516349e-02f, 8.31307173e-02f, 4.67726886e-02f,
  8.04973394e-02f, -1.50910830e-02f, 4.66374308e-02f, -3.86135317e-02f, -1.26158791e-02f, -6.22255616e-02f, -1.76874697e-02f, 7.07492158e-02f, 4.74693216e-02f, -2.01642048e-02f,
  -1.12379454e-01f, -1.18654864e-02f, 2.86130272e-02f, -5.02309762e-02f, 9.93685201e-02f, -1.56565644e-02f, 3.08118947e-02f, -4.39551175e-02f, 3.79699320e-02f, 5.51738292e-02f,
  1.54047027e-01f, -5.55860773e-02f, 7.67500699e-02f, 2.81638857e-02f, -5.31805344e-02f, 3.84219165e-04f, 7.78766125e-02f, 6.71340059e-03f, -1.16995983e-01f, -2.25394648e-02f,
  -5.34441099e-02f, 1.95007361e-02f, -7.14687333e-02f, -3.37878689e-02f, -1.80423241e-02f, 2.62559596e-02f, 2.67417263e-02f, -4.26302478e-03f, -2.43144035e-02f, 4.50519100e-02f,
  7.63628781e-02f, 8.17550272e-02f, 6.43464997e-02f, 6.59894496e-02f, -4.51250039e-02f, -1.88893881e-02f, 2.91126166e-02f, 3.25001553e-02f, 8.24257880e-02f, 9.70629156e-02f,
  -6.96826167e-03f, -1.90926890e-03f, -1.31534114e-01f, 3.74534391e-02f, 5.68693466e-02f, 2.61657350e-02f, -4.56606932e-02f, -1.34422490e-02f, -4.42974977e-02f, 6.32732362e-02f,
  2.67177336e-02f, 7.63061494e-02f, 8.73021185e-02f, -9.70566645e-03f, -3.21377181e-02f, 3.09270173e-02f, -6.38636947e-02f, 1.28567098e-02f, -2.28639133e-02f, 2.30973288e-02f,
  6.65885285e-02f, 4.35921282e-01f, 2.37347022e-01f, 1.08992672e-02f, -7.43113905e-02f, -4.65388417e-01f, -2.62717068e-01f, 2.85718869e-02f, 8.17968994e-02f, 2.60301773e-02f,
  -1.05209373e-01f, 4.20078307e-01f, -1.11761592e-01f, 1.32925436e-01f, -5.67961156e-01f, -3.79237890e-01f, -2.06484482e-01f, -1.92632116e-02f, -4.51597571e-02f, -3.67536768e-02f,
  -1.42330408e-01f, -2.82045275e-01f, -2.18374990e-02f, 2.71976329e-02f, 8.29406232e-02f, 2.16256648e-01f, -1.93599254e-01f, -8.52290392e-02f, 1.80942938e-01f, 2.15124525e-02f,
  3.17705497e-02f, 1.09712943e-01f, 1.70710951e-01f, 1.23145439e-01f, -7.50144124e-02f, 2.88120024e-02f, 4.04113643e-02f, 6.58324733e-02f, -4.47094860e-03f, -2.26570927e-02f,
  -1.51695767e-02f, 1.24598704e-02f, 7.67062828e-02f, -4.58166078e-02f, -4.15839907e-03f, 1.56315938e-01f, 1.74554903e-02f, 5.74151501e-02f, 9.53435376e-02f, 1.50216430e-01f,
  5.64548112e-02f, -1.55169973e-02f, -8.84877797e-03f, -7.91868716e-02f, -3.74128446e-02f, 7.47829899e-02f, 6.20743632e-02f, 5.08673340e-02f, 1.77576188e-02f, 3.95310260e-02f,
  -1.85660552e-03f, -2.08352327e-01f, -9.16760042e-02f, 8.52399021e-02f, -9.74292215e-03f, 9.58310068e-02f, 5.38909622e-03f, 6.15793131e-02f, -2.04984043e-02f, -4.13389951e-02f,
  6.15068618e-03f, -4.95478511e-02f, -1.26592619e-02f, -4.36500832e-02f, -2.07100920e-02f, -2.37660557e-02f, -4.96007986e-02f, 3.89617719e-02f, -4.03590687e-02f, -3.06672286e-02f,
  4.04470116e-02f, -2.35407259e-02f, 7.44513124e-02f, 1.24224443e-02f, -2.03679368e-01f, 2.47992761e-02f, 1.18048750e-01f, 2.72253994e-02f, 6.97459430e-02f, -9.82206017e-02f,
  -2.29180485e-01f, -2.57661521e-01f, -4.45799418e-02f, 3.08313146e-02f, -2.76973005e-02f, -7.75021091e-02f, -5.17579401e-03f, 4.30944413e-02f, -5.98825403e-02f, -8.04189965e-02f,
  4.94416477e-03f, -3.48153077e-02f, -6.02985993e-02f, 3.99418734e-02f, -8.05961192e-02f, 6.86109578e-03f, -2.07484365e-02f, -6.23157248e-02f, -3.54515314e-02f, 2.23724917e-02f,
  7.10084289e-02f, -1.09194424e-02f, 3.88447009e-02f, 1.77650061e-02f, -4.60180920e-03f, -1.29499927e-01f, -2.37763617e-02f, 6.32492527e-02f, -1.38396947e-02f, -1.03134185e-01f,
  -2.12530032e-01f, -2.25630343e-01f, 2.17837647e-01f, 5.00184536e-01f, -5.30685782e-02f, -4.69517320e-01f, -4.60248172e-01f, 8.73156711e-02f, -1.88921243e-01f, -2.54296333e-01f,
  -1.62146062e-01f, -6.62674755e-03f, -2.62819409e-01f, 1.48939043e-01f, 2.67081410e-01f, -2.84245104e-01f, 1.05265796e-01f, -1.02513365e-01f, 4.70867008e-02f, 9.46382061e-02f,
  2.20963538e-01f, 1.98977724e-01f, 3.31794620e-01f, 1.69078693e-01f, 6.97870180e-02f, 3.00609261e-01f, 3.92662644e-01f, 3.29351388e-02f, 3.03510249e-01f, 7.00465813e-02f,
  -1.06401466e-01f, -8.28352049e-02f, 2.59831678e-02f, 5.97739182e-02f, 3.01954504e-02f, -7.84773827e-02f, -6.58732355e-02f, 1.18509308e-02f, -3.27058248e-02f, 3.48290522e-03f,
  -1.01235352e-01f, 9.48120430e-02f, 1.12411290e-01f, 7.63200074e-02f, -3.15672196e-02f, 7.86061063e-02f, 3.60337086e-02f, -8.71027932e-02f, -1.54278437e-02f, 4.04852815e-02f,
  4.33879606e-02f, 4.14850265e-02f, 6.06761761e-02f, 1.33531094e-02f, 9.45210084e-02f, -2.39425506e-02f, 2.69742012e-02f, -5.54421730e-02f, -1.97525006e-02f, 1.10458434e-01f,
  -1.16656609e-01f, -8.86547193e-02f, -9.39388722e-02f, 4.78744842e-02f, -6.64122105e-02f, 4.35319170e-02f, -6.96573481e-02f, -6.31487742e-02f, 1.78896897e-02f, 5.37913619e-03f,
  4.46601994e-02f, 3.66039239e-02f, 5.30108474e-02f, 3.55432779e-02f, -1.76827435e-03f, -7.41248727e-02f, -2.29563564e-03f, -7.59108132e-03f, 9.10115801e-03f, -5.90998828e-02f,
  -3.34290080e-02f, -7.13499486e-02f, -2.92866398e-02f, -1.11390404e-01f, 4.87556942e-02f, 4.95236414e-03f, 4.82640266e-02f, -6.50144964e-02f, 5.45042604e-02f, -6.24393597e-02f,
  -4.87613156e-02f, 1.53226435e-01f, -2.52110083e-02f, -2.91227158e-02f, 1.12635016e-01f, -1.74616072e-02f, 4.68850359e-02f, 6.11913279e-02f, -1.20357051e-02f, 1.33438604e-02f,
  4.06170152e-02f, 1.72756705e-03f, -5.19609079e-02f, 6.54426664e-02f, 1.35298878e-01f, -6.04508072e-02f, 7.82634392e-02f, 1.21287189e-01f, 1.21397272e-01f, 9.43144709e-02f,
  -1.66282412e-02f, -5.98925129e-02f, 8.28610808e-02f, -1.54658081e-03f, 7.62405631e-04f, -1.49771683e-02f, -5.32699861e-02f, 3.61500569e-02f, 8.53291675e-02f, -3.14578041e-02f,
  -2.69301295e-01f, 6.56740293e-02f, -2.37826675e-01f, -2.93487340e-01f, 8.17413330e-02f, -2.99866438e-01f, -3.84121746e-01f, -6.08927943e-02f, -4.14714217e-02f, -2.48336077e-01f,
  -3.09053600e-01f, 1.51492566e-01f, -2.72425059e-02f, -2.52593189e-01f, -1.39936611e-01f, -6.32692594e-03f, -3.60750705e-01f, -1.61798075e-01f, 1.89679638e-01f, -1.20444946e-01f,
  -8.61428827e-02f, -1.29894435e-01f, -1.17193565e-01f, 9.91238430e-02f, -2.19478175e-01f, -5.52064516e-02f, -6.29795566e-02f, 5.72448485e-02f, -1.46813497e-01f, 9.55625549e-02f,
  -3.45961899e-02f, -2.85320252e-01f, -7.95727372e-02f, 4.10038419e-02f, -1.06359832e-01f, 2.68532503e-02f, -8.29761289e-03f, -5.12179881e-02f, -6.74084947e-02f, -1.33809745e-01f,
  1.38138365e-02f, -7.51489252e-02f, 2.42956113e-02f, 3.59279811e-02f, -2.74599288e-02f, -5.09464629e-02f, 5.47541268e-02f, 3.83040756e-02f, -2.30813473e-02f, 1.61555223e-02f,
  -4.73318622e-03f, 1.23608988e-02f, -4.64157760e-02f, -1.87602434e-02f, 6.46495596e-02f, -8.06400552e-02f, -7.33544305e-02f, -7.59562105e-02f, -6.86034933e-02f, -7.04912469e-02f,
  5.44993803e-02f, -5.71930110e-02f, -3.70258205e-02f, 5.74227422e-02f, 3.27411070e-02f, -1.44048138e-02f, 4.85812947e-02f, 4.99105006e-02f, -4.34699953e-02f, -4.71197143e-02f,
  -1.54965483e-02f, 9.74651799e-02f, -1.00650694e-02f, -7.74955601e-02f, 6.48555830e-02f, -1.91721469e-02f, -1.56954341e-02f, 2.06810161e-02f, -6.34339778e-03f, -6.31280756e-03f,
  -3.04316636e-03f, -1.05896650e-03f, -1.00010060e-01f, 1.49702522e-04f, -8.30067508e-03f, 3.00294929e-03f, -1.62156373e-02f, -2.99603883e-02f, 2.23464984e-02f, -1.45544503e-02f,
  -7.57951140e-02f, -1.20740980e-01f, 1.35216676e-02f, 2.60556154e-02f, -6.47133887e-02f, -1.06427543e-01f, 4.84349765e-02f, 2.03905702e-02f, -4.47406918e-02f, 9.88776162e-02f,
  -1.44837230e-01f, -4.30431850e-02f, -2.41330068e-04f, -4.39893119e-02f, 9.25580971e-03f, -5.85108288e-02f, -7.19280541e-02f, -1.64390672e-02f, -5.69032729e-02f, -2.59219240e-02f,
  9.96998772e-02f, 7.12353736e-02f, -2.65875440e-02f, 2.72965431e-02f, 8.88716951e-02f, -6.65098503e-02f, 5.16038053e-02f, 2.82768775e-02f, -4.82732877e-02f, 5.74307851e-02f,
  -1.63725778e-01f, 2.83191592e-01f, 2.09038332e-01f, -1.38401210e-01f, 1.86834246e-01f, 6.00844957e-02f, -1.02934554e-01f, 1.39439374e-01f, -9.06137377e-02f, -1.36645287e-01f,
  -1.69540182e-01f, 9.33732167e-02f, -1.15595832e-01f, -1.93329707e-01f, -1.59930035e-01f, -1.59308374e-01f, -1.30443290e-01f, -2.16882542e-01f, 1.03067286e-01f, -1.29452407e-01f,
  4.21875007e-02f, -1.88021269e-02f, 7.38808140e-02f, 1.59127042e-01f, 1.06056601e-01f, 7.61179253e-02f, -1.35966450e-01f, 1.95527181e-01f, 1.28511354e-01f, 1.28300741e-01f,
  -7.71810859e-02f, 1.02537433e-02f, 1.09159797e-01f, -5.76263741e-02f, -6.77662566e-02f, -3.84882800e-02f, -7.42619783e-02f, 4.24361452e-02f, -4.79463115e-02f, 1.00864461e-02f,
  1.03419475e-01f, -4.71477844e-02f, 4.85398248e-02f, -5.75679392e-02f, 3.25148180e-02f, 7.81150460e-02f, 4.68081766e-04f, 5.39982654e-02f, 8.68561119e-02f, -1.08072069e-02f,
  -1.75222903e-02f, 8.19889233e-02f, -1.48255706e-01f, -7.87752196e-02f, -4.27866727e-02f, 2.61231717e-02f, -7.85860494e-02f, -4.61612195e-02f, 5.31188725e-03f, -5.15632331e-02f,
  1.69706732e-01f, 1.10573536e-02f, 1.35987297e-01f, -2.21112613e-02f, 1.14571080e-02f, -6.67568892e-02f, -4.07310389e-02f, -1.06930114e-01f, -5.31444289e-02f, 1.48276743e-02f,
  2.66468972e-02f, 9.37959328e-02f, 1.94001645e-02f, -2.24941000e-02f, 8.56326893e-02f, -2.71022189e-02f, 5.89651894e-03f, -1.18330523e-01f, 6.08395413e-02f, 8.83454550e-03f,
  -3.80641334e-02f, -1.22790396e-01f, 3.92386131e-03f, -2.72696931e-02f, 6.88147768e-02f, -3.94915901e-02f, -9.58743691e-02f, -5.21080429e-03f, -8.15595090e-02f, -2.90901866e-02f,
  -3.86321127e-01f, -3.13766122e-01f, -6.32339865e-02f, -4.63427827e-02f, 3.39220762e-02f, 7.07588494e-02f, -3.07913702e-02f, -1.50831938e-01f, -7.97156617e-02f, -3.74942422e-02f,
  -7.41045773e-02f, 5.62212728e-02f, -2.97900811e-02f, -8.58149454e-02f, 7.25945085e-02f, -7.40600377e-02f, -1.08085023e-02f, 5.17369397e-02f, -5.25707752e-02f, -4.80334796e-02f,
  -2.03761235e-02f, -9.21645835e-02f, 1.13003822e-02f, 2.74131875e-02f, 2.65536457e-03f, 4.63217124e-02f, -2.23359317e-02f, 6.43169694e-03f, -6.66504949e-02f, 7.35944808e-02f,
  -3.63193065e-01f, -1.50423288e-01f, 4.71141674e-02f, -1.77482948e-01f, 2.26317178e-02f, 7.01843528e-03f, -8.92078727e-02f, 1.17010251e-01f, -4.25517187e-02f, -4.05567475e-02f,
  6.46206364e-02f, -2.20005751e-01f, -1.41923632e-02f, -1.88670620e-01f, -9.29051191e-02f, -1.99856326e-01f, -9.40373465e-02f, -6.10960238e-02f, 1.71170775e-02f, -7.12806999e-04f,
  -6.47361204e-02f, -3.28769237e-02f, -7.88076967e-02f, 5.94173744e-02f, -6.61324302e-04f, 1.17358111e-01f, 8.09137151e-02f, 7.30591714e-02f, 2.28577368e-02f, 3.31925824e-02f,
  -6.76522106e-02f, 9.64961722e-02f, 5.96455969e-02f, 9.68896374e-02f, 1.02994591e-01f, -4.16402332e-02f, 1.62719786e-02f, 2.35552955e-02f, 1.12397924e-01f, 5.89671880e-02f,
  -8.49716961e-02f, -8.08929726e-02f, -8.67155194e-02f, 8.17277208e-02f, 3.87778021e-02f, 3.31370272e-02f, 3.68361846e-02f, -3.94911021e-02f, 2.76636295e-02f, 5.84879667e-02f,
  -3.08670681e-02f, -6.83543831e-02f, -6.08143471e-02f, -6.87419474e-02f, 3.58090214e-02f, 7.39045069e-02f, -1.50582373e-01f, -6.19958080e-02f, -3.84071469e-02f, -5.07777836e-03f,
  -3.56228687e-02f, 3.84828523e-02f, 9.06186625e-02f, -3.40390503e-02f, -1.07273124e-02f, -1.92339942e-02f, 2.03249399e-02f, -1.65764894e-02f, -2.11961623e-02f, 2.97320029e-03f,
  -4.98358198e-02f, 2.16565877e-02f, 3.95385139e-02f, -2.40361504e-02f, -9.30212289e-02f, 3.24955136e-02f, -9.83798727e-02f, -6.59350259e-03f, -7.13502690e-02f, 2.68048793e-02f,
  1.28767928e-02f, 1.82249025e-02f, -1.29462108e-01f, 3.17078047e-02f, 3.65954861e-02f, -1.05857952e-02f, 3.43339238e-03f, -9.58233327e-02f, 1.01772383e-01f, 4.45974544e-02f,
  -4.96343933e-02f, 1.13264531e-01f, 1.32245019e-01f, -3.55938300e-02f, -4.43897285e-02f, 7.70025998e-02f, 4.84223589e-02f, 1.46848261e-02f, 3.24442908e-02f, -4.07064520e-02f,
  7.77090713e-02f, 3.99147719e-02f, -6.44557923e-02f, -1.00056194e-01f, -1.06835432e-01f, 4.26239520e-03f, 1.63383260e-02f, 1.18188066e-02f, -5.54098897e-02f, -1.54303843e-02f,
  -1.12311736e-01f, -2.77855974e-02f, 4.87667061e-02f, 6.51779771e-02f, -4.43349034e-02f, -4.94128875e-02f, 5.75334504e-02f, -3.33302878e-02f, 9.04728100e-03f, -1.32404462e-01f,
  -5.58456182e-01f, -1.02536315e-02f, -1.45014271e-01f, -2.25865319e-01f, 1.36052370e-01f, -1.19892016e-01f, -3.15624326e-02f, 1.20004348e-01f, -7.82224461e-02f, 2.10077148e-02f,
  1.39187828e-01f, -2.93327332e-01f, 1.40045032e-01f, -3.26550037e-01f, -3.14981580e-01f, -2.74382830e-01f, -3.93874496e-01f, -2.57059485e-01f, -9.62948948e-02f, 1.17053181e-01f,
  -2.47325450e-01f, -1.75302014e-01f, -2.97519565e-01f, 1.48561075e-01f, 1.09352041e-02f, 5.71595393e-02f, -2.21823081e-02f, 1.57756701e-01f, -4.89827991e-02f, 1.07116746e-02f,
  9.21519250e-02f, 8.34597796e-02f, 2.44358610e-02f, -9.56350267e-02f, 1.89734194e-02f, 3.30340974e-02f, -1.18331416e-02f, 1.12064831e-01f, -1.01613756e-02f, 1.08075187e-01f,
  -2.87805907e-02f, -1.06869610e-02f, -6.72702445e-03f, -8.96233483e-04f, 8.10333248e-03f, -6.46924376e-02f, 1.71869248e-02f, 3.38420421e-02f, -1.45542631e-02f, 5.97206242e-02f,
  1.14488751e-01f, -2.48071346e-02f, -1.31160766e-02f, -2.62232460e-02f, -1.33117825e-01f, 7.16753304e-02f, -5.73118962e-02f, 1.14134371e-01f, 8.08117073e-03f, 1.19493797e-03f,
  -1.27822980e-01f, -4.33840789e-02f, -1.57317687e-02f, -6.96939742e-03f, 9.15284082e-02f, 2.22801995e-02f, -4.64296639e-02f, -7.05070503e-04f, -1.84344593e-02f, -6.52224123e-02f,
  -3.84975448e-02f, -5.82526438e-02f, -1.49399061e-02f, -2.01974716e-02f, -1.18226096e-01f, -5.59549220e-02f, -3.95552702e-02f, 9.08379182e-02f, -8.31223205e-02f, 5.11640869e-03f,
  -2.43165009e-02f, -7.91962221e-02f, 2.21980531e-02f, 1.55404257e-02f, 9.42489505e-02f, 6.18489534e-02f, -3.54909003e-02f, 9.19877440e-02f, 2.28447914e-02f, 8.88302829e-03f,
  9.36912969e-02f, 2.53253151e-02f, -3.35094333e-02f, -3.13929245e-02f, 8.16206336e-02f, -7.94445649e-02f, -1.61304653e-01f, -8.42615739e-02f, 5.24581969e-02f, -1.52649041e-02f,
  7.06108436e-02f, -2.53628287e-02f, -2.16442123e-02f, 7.61274397e-02f, 7.48936310e-02f, 1.26652354e-02f, 1.53132938e-02f, 3.44119854e-02f, 9.01887491e-02f, -5.14563844e-02f,
  5.21603413e-02f, 7.34449597e-04f, 7.48186335e-02f, -5.26920892e-02f, -1.28916234e-01f, 5.83033785e-02f, -5.47758900e-02f, -4.62161424e-03f, 1.36792036e-02f, -1.17243379e-02f,
  2.94976026e-01f, -2.46949151e-01f, 3.90654147e-01f, 2.92185128e-01f, -1.91739146e-02f, 3.08811888e-02f, 1.66769102e-01f, 2.10753679e-02f, 1.98260918e-01f, -9.74433124e-02f,
  -6.36944994e-02f, 1.94768205e-01f, -3.14944535e-01f, 3.25196721e-02f, -1.26603320e-01f, -3.58049303e-01f, -1.26609758e-01f, 1.16648041e-01f, 4.92924638e-02f, 7.99413547e-02f,
  9.31369960e-02f, -2.33059883e-01f, -1.51843309e-01f, -2.07805514e-01f, 1.91442817e-01f, 2.08171725e-01f, 3.40534784e-02f, -6.84408396e-02f, 5.25069647e-02f, -1.22855403e-01f,
  5.17973378e-02f, 1.28142953e-01f, -2.60845646e-02f, 3.11151706e-02f, 6.55213371e-02f, 6.99773580e-02f, -8.64775628e-02f, -6.04364686e-02f, 8.06982741e-02f, 5.24099767e-02f,
  -6.31781816e-02f, 3.61251198e-02f, 9.83821154e-02f, 9.20718834e-02f, 2.50215381e-02f, 6.63468614e-02f, 8.92694518e-02f, 4.90785353e-02f, 6.95245340e-02f, 7.98619390e-02f,
  -3.57055441e-02f, 6.46998314e-03f, 9.02197435e-02f, 5.15239500e-02f, 4.66243401e-02f, 1.09076723e-01f, 5.84700145e-02f, 4.56102826e-02f, 7.02963099e-02f, -1.09033408e-02f,
  -4.45236526e-02f, 1.27940800e-03f, 3.85516025e-02f, 7.20615173e-03f, -1.04459217e-02f, 9.11977738e-02f, -4.43979055e-02f, -2.05413513e-02f, 8.88369046e-03f, 3.54594849e-02f,
  -6.03267774e-02f, -2.94768339e-04f, -3.49117778e-02f, -1.90120768e-02f, -6.88813487e-03f, 3.68384575e-03f, -2.08064932e-02f, 2.22939309e-02f, 7.21849352e-02f, -9.45072342e-03f,
  2.89153829e-02f, -3.08419708e-02f, -6.10302351e-02f, 4.46523875e-02f, 6.87105656e-02f, -3.74685265e-02f, -1.41352668e-01f, -6.33095484e-03f, 2.57570930e-02f, 7.00325593e-02f,
  -2.67751634e-01f, -1.74762249e-01f, 6.74262047e-02f, 4.77736741e-02f, -4.55217957e-02f, -3.34277414e-02f, -2.41317973e-02f, -4.37433571e-02f, -5.88681661e-02f, -7.72821829e-02f,
  1.32844031e-01f, -3.18142921e-02f, -2.25764662e-02f, -1.41427368e-02f, -2.12473627e-02f, -1.11364283e-01f, -5.18191233e-02f, -2.14250404e-02f, 9.93151125e-03f, -5.70911856e-04f,
  -1.75260436e-02f, -4.57442785e-03f, 1.17051760e-02f, 2.16398183e-02f, 5.82309738e-02f, -3.31832841e-03f, 5.66764437e-02f, 7.25313202e-02f, 4.20671143e-02f, -3.54835130e-02f,
  -2.35007614e-01f, -1.45429581e-01f, -2.28302419e-01f, -1.60826892e-01f, 5.34272101e-03f, -1.59052581e-01f, -1.12484999e-01f, -6.69030398e-02f, 9.31410864e-02f, 1.99937771e-04f,
  -3.52554545e-02f, -4.46754918e-02f, -6.02889694e-02f, -2.30408490e-01f, -2.23377973e-01f, -1.30407466e-02f, -1.74006835e-01f, -5.34640290e-02f, 1.88815609e-01f, -8.48408118e-02f,
  8.12227726e-02f, -5.15457615e-03f, -1.68336317e-01f, -1.09016402e-02f, -1.13500021e-02f, 1.26440212e-01f, 7.43012875e-02f, -6.08756691e-02f, 4.04553637e-02f, 1.06970314e-02f,
  -3.47736813e-02f, 1.31457791e-01f, -2.77474876e-02f, -3.03741209e-02f, -8.87434110e-02f, -8.41929689e-02f, -3.35152373e-02f, -4.43156902e-03f, 7.12780654e-02f, 4.49935570e-02f,
  1.09594300e-01f, 3.50989737e-02f, -4.96874750e-02f, -4.71456274e-02f, -6.67030411e-03f, 1.41028706e-02f, -7.83762187e-02f, 9.58899036e-02f, -1.82112008e-02f, -1.19562604e-01f,
  -1.05562016e-01f, 2.45988816e-02f, -6.34086132e-02f, 5.17734066e-02f, -8.75973403e-02f, 7.66005069e-02f, 6.24483684e-03f, 5.96237592e-02f, 5.76291345e-02f, 1.25400666e-02f,
  -3.44288386e-02f, 6.71544895e-02f, 4.09448799e-03f, 3.23695131e-02f, -4.63175289e-02f, -3.78105193e-02f, -5.50155751e-02f, 4.20197919e-02f, 1.01706050e-01f, 5.55069633e-02f,
  5.93717135e-02f, -6.89180791e-02f, 1.17284767e-01f, -2.93111354e-02f, -8.36376324e-02f, 6.26705140e-02f, 1.48055673e-01f, -7.46454019e-03f, 1.08001448e-01f, 4.31165099e-02f,
  1.99856516e-03f, 2.10232325e-02f, 1.59732506e-01f, 7.24695399e-02f, -1.27915025e-01f, -1.52701838e-02f, -1.03498949e-02f, 1.93424076e-02f, -1.69662703e-02f, -9.36366152e-03f,
  -2.33672913e-02f, -5.59233166e-02f, 5.20246997e-02f, 4.37252708e-02f, -1.68689732e-02f, -6.78415969e-02f, 4.81814891e-03f, 3.59514542e-02f, -7.87150413e-02f, -5.25275655e-02f,
  3.97463143e-02f, 5.34881726e-02f, 2.76070740e-03f, 7.36279488e-02f, 1.87133681e-02f, 4.17490862e-02f, 4.04459238e-02f, -2.56231818e-02f, 1.00769043e-01f, 9.37094912e-02f,
  3.09467241e-02f, 9.78940725e-02f, -5.56379370e-02f, 1.20120928e-01f, 2.01209802e-02f, -8.52761231e-03f, 1.24146521e-01f, 9.02217533e-03f, 4.84361984e-02f, -7.99361393e-02f,
  -8.82381871e-02f, 9.54254195e-02f, 6.41130432e-02f, 6.80868030e-02f, -3.02458294e-02f, 1.98386326e-01f, 1.67980507e-01f, 1.91058502e-01f, 3.81913573e-01f, 5.56052439e-02f,
  -8.01924467e-02f, 1.49883196e-01f, -6.01530541e-03f, -9.59941745e-02f, -1.03893699e-02f, 9.52999294e-02f, 1.58489794e-01f, -3.62203047e-02f, 7.75264949e-02f, -5.09464890e-02f,
  -9.88471359e-02f, -1.17700817e-02f, -1.17549717e-01f, -6.55223876e-02f, -1.63127825e-01f, -7.92326480e-02f, -9.97372791e-02f, -1.27318382e-01f, -1.00358844e-01f, 8.74451697e-02f,
  2.48461682e-02f, 1.27561599e-01f, -1.06100388e-01f, 8.29760507e-02f, 6.35058293e-03f, -9.35069621e-02f, -4.32570688e-02f, 8.94599408e-02f, 7.37209171e-02f, 8.66311342e-02f,
  7.02475980e-02f, -9.43221226e-02f, 3.68450284e-02f, -6.64652511e-03f, -5.58614396e-02f, -2.76661944e-02f, -7.75355920e-02f, 4.08384502e-02f, -2.00168341e-02f, 3.12823057e-02f,
  4.50820364e-02f, 6.05801381e-02f, 3.70655693e-02f, -7.09497109e-02f, 2.25368403e-02f, 5.67711964e-02f, -4.65431251e-02f, -7.33834552e-03f, -5.11448868e-02f, -8.90184008e-03f,
  -6.20853007e-02f, 6.56493455e-02f, -7.15965778e-02f, 7.19876029e-04f, -2.65394002e-02f, -1.20727807e-01f, -1.37608983e-02f, -1.15999626e-03f, 1.27222585e-02f, -8.80542845e-02f,
  -4.71761897e-02f, 2.17923764e-02f, 6.93457387e-03f, 1.54651245e-02f, 1.03561461e-01f, -3.53212953e-02f, -3.21817137e-02f, -8.73067752e-02f, 7.53449723e-02f, 1.74243581e-02f,
  4.26934287e-03f, -1.49773723e-02f, -1.73479505e-02f, 8.49536881e-02f, 2.80501209e-02f, 1.10558316e-01f, -3.82560790e-02f, 7.68240988e-02f, 2.15671863e-02f, 2.34254915e-02f,
  1.51188478e-01f, 1.29885107e-01f, -1.13318702e-02f, -3.13660800e-02f, 2.26742513e-02f, -4.83108163e-02f, 1.58289187e-02f, -2.76523326e-02f, -2.65321974e-02f, 1.58939064e-02f,
  -8.39376543e-03f, 2.17739362e-02f, -8.77619442e-03f, -6.42556846e-02f, 1.98663305e-03f, 3.69349681e-02f, 8.59606788e-02f, -2.43352391e-02f, 4.90134768e-02f, -4.80492376e-02f,
  -5.81992343e-02f, -8.55561439e-03f, -3.19074286e-04f, -3.17811524e-03f, 6.25678897e-02f, -5.38416728e-02f, 5.38033694e-02f, 2.86762398e-02f, -3.20997313e-02f, 6.86119944e-02f,
  3.82786602e-01f, -4.23445374e-01f, -2.18902025e-02f, 3.27635199e-01f, 3.53489161e-01f, 2.69871235e-01f, 2.32077524e-01f, 1.63085997e-01f, 3.08509260e-01f, -1.65377155e-01f,
  5.49584217e-02f, -9.48874727e-02f, -4.31351632e-01f, 6.11927658e-02f, 2.57734478e-01f, -2.14799419e-01f, 1.61096826e-01f, 1.37643833e-02f, 7.77300745e-02f, 7.29482993e-02f,
  1.51801944e-01f, 1.75046518e-01f, -1.66936904e-01f, 1.19309880e-01f, 9.63483378e-02f, 6.01172745e-02f, -6.45079836e-02f, -2.60106355e-01f, 8.72701705e-02f, 1.01692580e-01f,
  1.14134543e-01f, 9.48301554e-02f, 6.46289736e-02f, 9.55929235e-02f, -1.29528306e-02f, 2.66842335e-03f, -1.79963857e-02f, -5.01016900e-02f, -1.09197751e-01f, -3.80130112e-02f,
  -1.73978880e-02f, 1.86245609e-02f, 1.17836274e-01f, 5.75658567e-02f, -7.87610468e-03f, 4.85541075e-02f, 8.02883133e-02f, 2.16575563e-02f, -2.09214296e-02f, -1.92696266e-02f,
  2.31446996e-02f, -7.31536672e-02f, 3.76098156e-02f, -1.36132762e-01f, -8.23884830e-02f, 1.13231204e-01f, 5.50442189e-02f, -9.19164345e-02f, 2.28983518e-02f, 1.38461128e-01f,
  -5.92053495e-02f, 7.28816725e-03f, -1.37515906e-02f, 6.68513030e-02f, 1.06774326e-02f, -5.39448112e-02f, -4.16605957e-02f, -9.19858553e-03f, 4.56346534e-02f, -1.55370794e-02f,
  5.48678227e-02f, 4.84575033e-02f, -4.77887169e-02f, 8.07163268e-02f, -3.39773521e-02f, -1.65643524e-02f, 1.48301506e-02f, 9.32653435e-03f, 5.40925451e-02f, 6.22675456e-02f,
  -4.69343178e-02f, 3.23411077e-02f, -4.44933027e-02f, -2.15279553e-02f, -8.60183835e-02f, 3.69690657e-02f, 2.63550016e-03f, -4.63813394e-02f, 3.59200385e-05f, -6.72949925e-02f,
  -1.28973737e-01f, -1.30752653e-01f, -7.48679638e-02f, 1.93695594e-02f, -9.59932879e-02f, 2.97865029e-02f, 1.24795884e-02f, 4.51846719e-02f, -6.26605824e-02f, 4.19255048e-02f,
  -3.99725996e-02f, -1.16446260e-02f, 1.79451816e-02f, 4.77032699e-02f, -4.43867259e-02f, 1.72636002e-01f, -7.91058913e-02f, -1.24247549e-02f, -9.10407975e-02f, -1.39779910e-01f,
  -5.82609512e-02f, -4.96716015e-02f, -2.22088788e-02f, 8.81607458e-02f, 3.30098458e-02f, -8.48648846e-02f, -6.48436993e-02f, 8.50152504e-03f, -1.04004636e-01f, 5.88532165e-03f,
  -7.19089881e-02f, -1.91520557e-01f, -1.84743166e-01f, 6.50195265e-03f, 8.54883790e-02f, -1.52155057e-01f, -2.53978878e-01f, 7.97052756e-02f, -2.80890554e-01f, 9.77627710e-02f,
  5.65772764e-02f, 4.99286652e-02f, -1.71102688e-01f, 3.53611112e-02f, 2.48124450e-02f, -3.67725641e-01f, 1.84553400e-01f, 1.69448908e-02f, -1.31650344e-01f, 1.85224354e-01f,
  -9.15878732e-03f, 3.63461792e-01f, -4.81504994e-03f, 2.21503988e-01f, 1.46477833e-01f, 8.06813017e-02f, 3.23324293e-01f, 1.38643952e-02f, 2.74962693e-01f, 2.47352999e-02f,
  -4.59375568e-02f, -1.24985859e-01f, -3.66773419e-02f, 2.24549770e-02f, 6.13386706e-02f, 1.03126802e-01f, 4.76012751e-02f, -2.18740609e-02f, 2.00906061e-02f, -1.43538127e-02f,
  3.57344374e-02f, -3.71778905e-02f, -4.81454358e-02f, -5.04520200e-02f, 3.12960744e-02f, 7.09675485e-03f, 5.37943700e-03f, 5.44604920e-02f, -3.92975798e-03f, -2.69957054e-02f,
  -5.96945658e-02f, -3.97077352e-02f, 2.16237605e-02f, 2.28887983e-03f, -4.96410578e-02f, 5.66317253e-02f, -6.31637797e-02f, 9.00815520e-03f, -2.52309870e-02f, -4.37826514e-02f,
  4.47454974e-02f, 8.50037113e-03f, 6.91836402e-02f, -6.36458918e-02f, -5.46208620e-02f, -1.09162834e-02f, 3.82180065e-02f, -6.04090281e-03f, -4.73044328e-02f, 3.69186625e-02f,
  5.98396584e-02f, -3.28642763e-02f, 6.73650904e-03f, 1.05087794e-02f, 4.33562845e-02f, 1.53603321e-02f, 5.33275597e-04f, -2.33247201e-03f, -1.06303755e-03f, -6.91727400e-02f,
  -2.35610679e-02f, 6.19585812e-02f, 1.83467176e-02f, 8.36140513e-02f, -1.27340192e-02f, 6.64899349e-02f, 8.82344618e-02f, -2.89707072e-02f, 5.05982840e-04f, 4.26890850e-02f,
  2.00608253e-01f, 1.45566449e-01f, -6.49451762e-02f, -3.02221365e-02f, -1.00533828e-01f, 7.35714659e-02f, -9.37724207e-03f, 3.13511491e-02f, 3.84978354e-02f, -4.90220487e-02f,
  6.50667325e-02f, 5.18809035e-02f, 9.44893211e-02f, -4.18215021e-02f, 2.71159410e-02f, -5.54276723e-03f, -6.36889338e-02f, -6.61935657e-02f, 3.92102562e-02f, 2.57795993e-02f,
  1.00612454e-01f, 8.58624745e-03f, 1.75624341e-02f, -3.22461873e-02f, 5.51799778e-03f, -4.83595021e-02f, 2.88889632e-02f, 2.28210613e-02f, 5.37636019e-02f, -7.53999352e-02f,
  -1.14701957e-01f, -3.13189149e-01f, -1.38494313e-01f, -9.03147534e-02f, -3.11185569e-02f, -2.18820989e-01f, -7.95141906e-02f, -4.57061753e-02f, 5.77532202e-02f, 1.65966049e-01f,
  -5.89756593e-02f, 4.55632657e-02f, 3.47836316e-02f, -1.18315645e-01f, 1.03024960e-01f, -9.20985416e-02f, -2.34904662e-01f, -6.96363524e-02f, -7.90005624e-02f, -2.37264588e-01f,
  -5.51428599e-03f, -2.15073347e-01f, -2.73298502e-01f, -1.88847095e-01f, -1.70172900e-01f, -3.36959660e-02f, 1.16564102e-01f, -8.74851942e-02f, -5.47194853e-02f, -5.24011664e-02f,
  -6.45099906e-04f, 1.46870703e-01f, 1.17311561e-02f, -6.82109371e-02f, 3.25879753e-02f, -3.97660248e-02f, -9.37587991e-02f, -1.14477202e-02f, 2.10574772e-02f, -7.99902603e-02f,
  -1.77250523e-02f, -2.88675744e-02f, 5.63592203e-02f, 1.54013010e-02f, -3.72957736e-02f, 5.07594571e-02f, 3.62778716e-02f, 3.02461348e-02f, -4.98075150e-02f, -5.71348192e-03f,
  9.89803206e-03f, 9.00099203e-02f, -2.04311423e-02f, 7.16298521e-02f, 8.00013319e-02f, 9.83126555e-03f, 5.23148067e-02f, 3.15311365e-02f, -4.27304246e-02f, 9.44108367e-02f,
  -3.30424570e-02f, -2.36372817e-02f, -5.89841977e-02f, -4.03830372e-02f, -7.31521379e-03f, 2.41226936e-03f, 3.40125449e-02f, -1.08226843e-01f, 1.98923424e-02f, -1.93839222e-02f,
  -2.28988063e-02f, -6.28663823e-02f, -6.78440556e-03f, -4.07876913e-03f, -1.01393566e-01f, 5.83746806e-02f, -9.47955772e-02f, -2.11941749e-02f, 2.55110078e-02f, -3.84059809e-02f,
  3.85764204e-02f, -1.49283716e-02f, 1.81031134e-02f, 1.14013441e-03f, -2.47863829e-02f, 7.43380785e-02f, 3.08531597e-02f, -6.81079328e-02f, -1.20957410e-02f, -1.58716608e-02f,
  -1.93755291e-02f, 6.10174797e-02f, -8.11734051e-02f, 2.88742501e-03f, 5.86800016e-02f, -5.64546175e-02f, 1.54023403e-02f, -1.18921325e-02f, 4.07975316e-02f, 1.28514543e-02f,
  -5.36744334e-02f, 5.12771448e-03f, -5.18260710e-02f, -1.82660650e-02f, 1.53812775e-02f, 4.13708985e-02f, 1.11984620e-02f, -2.25619301e-02f, -5.55564798e-02f, 9.46225002e-02f,
  -6.94924518e-02f, -9.03935581e-02f, 1.10981703e-01f, -1.01163678e-01f, -2.80638244e-02f, 5.26778847e-02f, -9.76616666e-02f, -2.61907857e-02f, 3.00618354e-02f, 1.48021774e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.73711622e-01f, 2.52762940e-02f, 5.80303818e-02f, -4.28910613e-01f, -7.16216490e-02f, 2.95395792e-01f, 1.27028361e-01f, 2.79757917e-01f, 3.11024457e-01f, 7.50364512e-02f,
  5.60771266e-04f, 1.67013183e-01f, 2.21624732e-01f, -1.91915348e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -8.67973641e-02f, -4.80861552e-02f, 2.78014332e-01f, -3.04206401e-01f, -2.08025873e-01f, 9.75845456e-02f, 2.38371015e-01f, -1.28055826e-01f, 1.83953553e-01f, 2.76525300e-02f,
  -4.38945144e-01f, 3.88272107e-01f, -1.47126332e-01f, -3.12730074e-02f, -1.79825038e-01f, 3.66695404e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.94845730e-01f, -3.55853856e-01f, 4.30721641e-01f, 3.88758987e-01f, 9.73541141e-01f, -4.40927893e-01f, 1.08448684e-01f, 3.59975398e-01f, -3.02292675e-01f, -2.12564558e-01f,
  6.39743686e-01f, -1.46018073e-01f, 4.10004333e-02f, -5.10486402e-02f, -4.15778905e-01f, -3.11382383e-01f, 2.68904537e-01f, -6.07836962e-01f, -3.41480792e-01f, -5.03297210e-01f,
  3.43270808e-01f, 1.79080606e-01f, 7.12074697e-01f, 3.67084175e-01f, 2.19206646e-01f, 6.53110445e-01f, -5.29378839e-02f, 5.46692908e-01f, -1.02315173e-02f, -3.25899363e-01f,
  1.76556841e-01f, 2.41625592e-01f, -2.15345562e-01f, 1.39957532e-01f, -1.84820578e-01f, -4.20782194e-02f, 4.35746834e-02f, 4.28909920e-02f, -1.01251893e-01f, -1.57632813e-01f,
  1.30526364e-01f, 1.28571942e-01f, -1.37392655e-01f, 3.10453996e-02f, -1.90559343e-01f, 1.22875348e-01f, 1.13877296e-01f, 1.89839393e-01f, 4.85427737e-01f, 4.74028289e-01f,
  5.29737353e-01f, 1.52572423e-01f, 1.83578655e-01f, -4.26172614e-01f, -1.21104747e-01f, 4.67410535e-01f, 6.75726011e-02f, 2.51857579e-01f, 5.74759364e-01f, 8.22183043e-02f,
  5.26709378e-01f, 7.45971262e-01f, 4.55333926e-02f, -3.23773444e-01f, -7.92235136e-02f, -2.39504501e-01f, -9.38022807e-02f, -9.62474965e-04f, -1.77744851e-01f, -1.44076794e-01f,
  -1.76977783e-01f, -3.20135131e-02f, -1.95814386e-01f, -6.06328435e-02f, -5.07303253e-02f, 9.97348055e-02f, -7.75684938e-02f, 1.64725214e-01f, 3.00091326e-01f, -1.07432693e-01f,
  3.02009791e-01f, -2.24682182e-01f, -2.92392552e-01f, -1.61201268e-01f, 6.13547802e-01f, 4.63829339e-01f, 3.95660669e-01f, 1.70830488e-01f, 1.00221381e-01f, 4.45480496e-01f,
  2.37652838e-01f, 2.40416154e-02f, -8.04581046e-02f, -2.10212573e-01f, 1.98842242e-01f, 1.73844293e-01f, 3.40419233e-01f, -4.42125946e-01f, 7.10031033e-01f, -1.86502784e-01f,
  3.95777345e-01f, -1.46210387e-01f, 3.88698697e-01f, 6.68741226e-01f, 5.45379698e-01f, 8.42927277e-01f, 4.88075346e-01f, 2.64652759e-01f, -3.35412204e-01f, 4.42855477e-01f,
  -1.29272819e-01f, 8.25132579e-02f, 1.27726659e-01f, -7.47955637e-03f, -3.62681337e-02f, -9.77528393e-02f, -1.42591953e-01f, 6.33147657e-02f, -6.42534643e-02f, 2.56402511e-02f,
  -1.62581474e-01f, -2.77060606e-02f, -1.64827377e-01f, 1.05001174e-01f, 1.29280522e-01f, -2.16694862e-01f, 2.03446940e-01f, -1.70341447e-01f, -7.45660812e-02f, -1.47249863e-01f,
  -1.07317917e-01f, -2.01246411e-01f, -1.82424545e-01f, 8.67903456e-02f, 1.32789671e-01f, 1.43084168e-01f, 5.78727154e-03f, 1.24497965e-01f, -2.97727762e-03f, -1.22738555e-01f,
  4.35381243e-03f, -2.50912663e-02f, -8.64183754e-02f, -5.24666421e-02f, 3.47091794e-01f, 7.80249953e-01f, -5.31892896e-01f, 2.91645397e-02f, -3.43580633e-01f, 9.99083340e-01f,
  -2.06607848e-01f, -2.56886810e-01f, -1.16856888e-01f, 4.36318778e-02f, 2.26074979e-01f, 4.16568518e-02f, -1.39506146e-01f, 8.68871093e-01f, 7.24599779e-01f, -2.34842300e-01f,
  -1.10372625e-01f, -2.14260697e-01f, 2.39881948e-02f, -1.63746662e-02f, -1.45117790e-01f, 1.02417417e-01f, 1.35373965e-01f, -9.25280675e-02f, -1.06091239e-01f, 2.09132899e-02f,
  -1.81981966e-01f, -8.23186934e-02f, -3.72436047e-02f, -4.96164784e-02f, -2.40121409e-01f, 3.11289281e-01f, -5.81961451e-03f, -1.79129437e-01f, 9.12345648e-02f, -4.19070572e-02f,
  -7.87543729e-02f, -1.21607952e-01f, 2.60497406e-02f, 9.61049870e-02f, 1.09577708e-01f, 1.81523729e-02f, -1.16954565e-01f, -1.39067784e-01f, 2.26624653e-01f, 8.07891488e-02f,
  -2.09530696e-01f, -1.58688501e-01f, -9.16703120e-02f, 2.72479594e-01f, 1.01514943e-01f, -1.78915039e-01f, -1.19723134e-01f, 6.35364294e-01f, 4.40658242e-01f, 1.15276955e-01f,
  1.79050133e-01f, 1.97697103e-01f, 4.87390421e-02f, 4.00878817e-01f, -1.91976875e-01f, -1.65019203e-02f, 1.33850053e-01f, 3.46118063e-01f, -2.41851568e-01f, 1.45729706e-01f,
  2.04426304e-01f, -1.68438852e-01f, 1.12794347e-01f, -1.33629099e-01f, -1.86635584e-01f, -1.26512861e-02f, -7.32940156e-03f, 1.08988099e-01f, -2.51363635e-01f, -2.54510380e-02f,
  -6.78727552e-02f, 8.02635327e-02f, -8.49785060e-02f, -5.21463202e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.33601823e-01f, 5.41192114e-01f, -1.44228622e-01f, 7.08523214e-01f, 1.21182099e-01f, 4.86401655e-02f, 4.56393249e-02f, -1.21908963e-01f, -1.38173133e-01f, 3.84803146e-01f,
  -1.26404501e-02f, 3.63682687e-01f, -5.68219908e-02f, -1.32988505e-02f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  2.17654388e-02f, -4.77144301e-01f, 1.51192188e-01f, -2.87020922e-01f, -1.04677260e-01f, 2.65670657e-01f, 1.83376849e-01f, -1.06848381e-01f, -1.05676286e-01f, 7.50734210e-02f,
  -4.10085358e-02f, 3.50326568e-01f, 5.35903424e-02f, 2.37818845e-02f, -5.18199131e-02f, 2.28251621e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.49808300e-01f, 1.32851243e-01f, -2.35563040e-01f, 2.72898287e-01f, 1.88864306e-01f, 1.83811158e-01f, 2.51451075e-01f, -8.11312050e-02f, -2.56146695e-02f, -1.03267431e-01f,
  -5.93740903e-02f, 1.15868986e-01f, 1.38420239e-01f, 3.14626127e-01f, -2.25834046e-02f, -2.23683104e-01f, 5.74552678e-02f, 1.51317433e-01f, 3.30737561e-01f, 3.84660333e-01f,
  -2.06048414e-01f, 3.67722541e-01f, 3.41874026e-02f, 3.89644116e-01f, 4.69679892e-01f, 2.58475900e-01f, -1.78737089e-01f, -2.37196550e-01f, -1.86308533e-01f, -2.81396229e-03f,
  -1.58194393e-01f, -2.18295567e-02f, -1.95080191e-01f, 4.61206496e-01f, -8.69165063e-02f, 1.05063009e+00f, 2.71850452e-02f, -1.37065515e-01f, -1.46805290e-02f, 4.05586690e-01f,
  5.05655587e-01f, 1.57817960e-01f, 3.30902822e-02f, 2.08736852e-01f, 1.31112203e-01f, 1.13299005e-01f, 5.54655969e-01f, 1.39240563e-01f, -2.64635514e-02f, 1.85859933e-01f,
  -2.74885744e-01f, 6.13381684e-01f, -9.75646377e-02f, -9.72753018e-02f, -1.79987550e-01f, 2.07479373e-01f, 8.24679255e-01f, -9.47657302e-02f, 1.02176301e-01f, 4.85735744e-01f,
  1.54426530e-01f, 4.06200327e-02f, 3.10490549e-01f, -2.78875651e-03f, 2.52490193e-01f, -4.08345520e-01f, -1.00146092e-01f, 4.16011304e-01f, -1.90528795e-01f, -2.08913073e-01f,
  2.87569046e-01f, 1.52487755e-01f, -3.72793913e-01f, -7.66002014e-02f, -9.20190942e-03f, 6.02565706e-01f, 2.85507202e-01f, 2.11231783e-01f, 8.62953439e-02f, 1.71774283e-01f,
  2.82042078e-03f, -1.25000879e-01f, 1.32823288e+00f, 3.81874204e-01f, 4.49333899e-02f, 8.54364097e-01f, -2.29759380e-01f, 1.99595526e-01f, 1.26391542e+00f, -6.03255741e-02f,
  9.59359184e-02f, -3.48370731e-01f, -2.50266999e-01f, -9.88098904e-02f, 2.01059319e-02f, 2.92098820e-02f, 9.88421589e-03f, 1.21858018e-02f, 8.79720524e-02f, 4.90218848e-01f,
  -2.19206661e-01f, -1.62493065e-01f, 1.93828046e-01f, 4.42483604e-01f, 2.62700841e-02f, 2.18248248e-01f, -1.94163457e-01f, 5.25006950e-01f, 1.22586563e-01f, -1.61703452e-01f,
  3.31649393e-01f, 1.90438122e-01f, 5.20313621e-01f, -3.06695759e-01f, 5.99587142e-01f, 1.44769430e-01f, -1.46376759e-01f, 6.50674939e-01f, 1.02482270e-02f, -2.45923862e-01f,
  -1.04094759e-01f, -2.23967507e-02f, -1.95643708e-01f, -2.29229450e-01f, 1.53724533e-02f, 6.97150305e-02f, -2.01268867e-01f, 7.42143905e-03f, 9.14106369e-02f, -3.11740994e-01f,
  -1.89577445e-01f, -1.91296991e-02f, -1.98458508e-01f, 3.25369865e-01f, -1.51920721e-01f, 3.73598427e-01f, -1.92654207e-01f, -1.82779372e-01f, 2.10233629e-01f, 1.13798714e+00f,
  -6.58300370e-02f, -1.33100525e-01f, 4.44666117e-01f, -1.37056395e-01f, 6.25539362e-01f, -2.54773349e-03f, -1.73098788e-01f, -2.53845751e-01f, 1.15224116e-01f, 8.11865449e-01f,
  1.47286383e-03f, -6.05279148e-01f, 4.16705936e-01f, -1.68424714e-02f, 1.82785332e-01f, 3.55726242e-01f, 6.07524775e-02f, 2.25549012e-01f, -4.94216522e-03f, 1.02364197e-01f,
  6.53003216e-01f, -6.46535337e-01f, -2.89662123e-01f, 7.47411251e-02f, -5.09199724e-02f, 8.34923267e-01f, -8.42555314e-02f, -1.35062754e-01f, -1.78660378e-01f, -1.39852524e-01f,
  2.08052248e-01f, 9.71715569e-01f, -4.37356755e-02f, 8.59462097e-02f, 1.11216888e-01f, -1.76832929e-01f, -1.19039536e-01f, 1.22739755e-01f, 1.27993345e-01f, 5.86626470e-01f,
  -1.42315790e-01f, -1.83283776e-01f, -1.90467522e-01f, 4.27516937e-01f, 2.15635106e-01f, 3.43692116e-02f, -1.96343675e-01f, 1.41710863e-01f, 8.52723941e-02f, 2.52315432e-01f,
  1.70367166e-01f, -1.86351642e-01f, 1.16026893e-01f, -2.07880959e-01f, -4.73577864e-02f, -9.08761993e-02f, 2.06137612e-01f, -2.37349924e-02f, 9.61307138e-02f, 2.06656843e-01f,
  -2.22711101e-01f, -2.02252209e-01f, 4.13952321e-02f, -4.05326188e-02f, 2.11075962e-01f, 1.00313395e-01f, 1.97184592e-01f, -1.54273778e-01f, -6.66759983e-02f, 2.16389552e-01f,
  8.38030055e-02f, 2.04173878e-01f, -7.99494907e-02f, -1.85261853e-02f, 2.30328456e-01f, -1.13619462e-01f, -7.43055791e-02f, -2.98690256e-02f, 1.14537343e-01f, -1.23687282e-01f,
  -4.35711145e-02f, -9.80537087e-02f, 2.06513688e-01f, 8.82512331e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  6.14988267e-01f, 1.02588907e-01f, 2.86906920e-02f, -2.18166590e-01f, 6.84548378e-01f, 3.23599637e-01f, 1.26429543e-01f, 5.27935207e-01f, 2.86001951e-01f, 6.66761577e-01f,
  7.81630814e-01f, -2.04940308e-02f, -2.47791350e-01f, -2.50278711e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  3.00234646e-01f, -3.84953111e-01f, 1.97695881e-01f, 2.26394370e-01f, 3.30802888e-01f, 2.17542186e-01f, -1.02663174e-01f, -2.59997815e-01f, 5.94930798e-02f, 2.06731632e-02f,
  -1.31806061e-01f, 3.98966298e-02f, -2.55335182e-01f, 2.68374104e-02f, 1.65816024e-01f, -8.36023018e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -7.22136125e-02f, 6.09602332e-01f, 1.28751367e-01f, -4.35936451e-03f, -3.81253213e-01f, 7.44166747e-02f, 4.42413777e-01f, -3.80007118e-01f, 2.77001917e-01f, 4.42827120e-02f,
  7.71147072e-01f, 8.49157870e-01f, 1.28154385e+00f, -2.48330027e-01f, -2.12112114e-01f, -3.09634302e-02f, -2.61952400e-01f, 1.92283079e-01f, 1.79104224e-01f, 3.07091735e-02f,
  -9.17729810e-02f, 4.62328531e-02f, -8.33454877e-02f, -3.03706080e-01f, -9.10968781e-02f, -1.52814642e-01f, 3.74893427e-01f, 2.28760853e-01f, 4.14804995e-01f, 1.23076573e-01f,
  -2.39065781e-01f, -9.25198372e-04f, -2.99014062e-01f, -6.00242876e-02f, -2.66872179e-02f, -8.86853188e-02f, 1.61749259e-01f, 2.56997436e-01f, 2.49222823e-04f, 2.22618833e-01f,
  -6.87848851e-02f, -6.21150946e-03f, -5.43716550e-02f, 7.86546792e-04f, 2.45554551e-01f, -2.60048479e-01f, -2.10872516e-02f, -2.51195520e-01f, -1.19511075e-02f, -1.15165912e-01f,
  1.07356489e-01f, 5.53072505e-02f, -2.04966545e-01f, -1.01333708e-01f, -2.49468893e-01f, -9.83713567e-02f, 8.16081241e-02f, 6.32448494e-02f, 7.04420432e-02f, -1.92460530e-02f,
  -8.12252536e-02f, -1.62827864e-01f, -1.00888848e-01f, 1.05686516e-01f, -1.15202904e-01f, -6.12999201e-01f, 9.41501856e-02f, 5.71845114e-01f, 9.06213462e-01f, 5.52331328e-01f,
  -2.60958791e-01f, 6.05764210e-01f, 1.40712947e-01f, -3.92602503e-01f, -1.53948024e-01f, -2.32623339e-01f, -2.26028472e-01f, 4.11553860e-01f, 2.06608608e-01f, 8.84918645e-02f,
  -1.68593332e-01f, -2.25778475e-01f, -4.59297985e-01f, 3.47402871e-01f, 2.55057395e-01f, 3.24650198e-01f, 2.99137253e-02f, 7.13601410e-01f, 1.78214908e-01f, -7.77788833e-02f,
  4.19487983e-01f, -6.28898084e-01f, -2.31991664e-01f, 4.02000576e-01f, -2.18855366e-01f, -1.71141148e-01f, 4.21739280e-01f, -3.43947820e-02f, -3.14116925e-01f, 4.70182955e-01f,
  -8.83797929e-02f, -1.61821857e-01f, -2.71140575e-01f, 1.08903205e+00f, -2.40943491e-01f, 4.85813975e-01f, -4.27294850e-01f, -1.06684111e-01f, -3.80600020e-02f, 6.43185899e-02f,
  2.52746958e-02f, -2.28916556e-01f, -1.52954534e-01f, -8.84867534e-02f, 2.34397173e-01f, -4.43588383e-03f, 5.11031598e-02f, -1.58100218e-01f, 7.46475086e-02f, -1.08781725e-01f,
  2.03668371e-01f, -9.99850035e-02f, -2.31205493e-01f, -2.06915196e-02f, 8.15362483e-02f, -1.19599797e-01f, 2.86673121e-02f, 4.84878197e-02f, 1.27520829e-01f, -5.04647017e-01f,
  4.29695807e-02f, 6.24812618e-02f, 5.20944595e-01f, 7.37802207e-01f, -1.87493980e-01f, 6.82862937e-01f, -1.25294194e-01f, -2.19998926e-01f, 6.93209022e-02f, 2.67040730e-01f,
  -3.83269876e-01f, 3.74051988e-01f, 1.86788086e-02f, 5.54075986e-02f, 8.27101588e-01f, -5.34016527e-02f, 9.52152833e-02f, 2.92221010e-01f, -3.74764085e-01f, 2.06611663e-01f,
  -4.47645247e-01f, 6.59480155e-01f, -4.35100526e-01f, 3.80265117e-01f, -4.75480229e-01f, 6.93949580e-01f, 3.71172518e-01f, -7.90286511e-02f, 1.98456392e-01f, -3.31504732e-01f,
  6.45286143e-01f, 2.40646973e-01f, 2.57477015e-01f, 2.81539798e-01f, -5.29664576e-01f, -4.66108859e-01f, 2.40124419e-01f, 5.55279553e-01f, -3.05400997e-01f, 6.92889094e-01f,
  -3.64148706e-01f, 4.95984972e-01f, 1.73707873e-01f, -4.30322550e-02f, 2.07537264e-01f, 1.80458948e-01f, 8.06372344e-01f, 6.51534721e-02f, 5.31525493e-01f, 1.79670930e-01f,
  3.32527459e-01f, -2.59505422e-03f, 7.39597499e-01f, -3.70941967e-01f, 3.72065872e-01f, 2.91273236e-01f, 2.28272021e-01f, -1.31644204e-01f, 1.63032517e-01f, 2.65938580e-01f,
  -3.30000184e-02f, 3.00345533e-02f, 7.20111728e-02f, -3.27701718e-02f, 3.52614909e-01f, -1.58917606e-01f, 5.26999772e-01f, 3.45372498e-01f, 5.51391900e-01f, -3.99910480e-01f,
  4.83674318e-01f, 1.63586829e-02f, 7.71013439e-01f, 2.14019895e-01f, 7.75206506e-01f, 1.40569717e-01f, 8.84635281e-03f, -9.73440111e-02f, 5.50791740e-01f, 5.25883019e-01f,
  3.49600911e-01f, 1.23205997e-01f, -2.63238043e-01f, -4.07887816e-01f, -1.94161817e-01f, 8.74771118e-01f, -4.30655479e-01f, 6.85046256e-01f, 1.16792277e-01f, 5.56102395e-01f,
  5.91489136e-01f, -3.60296428e-01f, -1.03171498e-01f, -2.31815994e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  5.67234039e-01f, -1.79863289e-01f, -3.71024072e-01f, -4.05315347e-02f, 2.83701867e-01f, -1.80997878e-01f, 3.77478242e-01f, -1.92163780e-01f, -2.03647956e-01f, 2.85694718e-01f,
  3.75932992e-01f, 5.20555377e-01f, 4.70761567e-01f, 4.41360533e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  8.04160774e-01f, 9.54722613e-02f, -6.05659671e-02f, -4.34614360e-01f, -1.96380302e-01f, 4.77901250e-02f, -1.13957725e-01f, -3.49974394e-01f, 4.35080081e-01f, 1.36334553e-01f,
  -1.94307655e-01f, 2.00806513e-01f, 4.58676189e-01f, 9.42725718e-01f, 2.98838973e-01f, 3.03034037e-01f, 4.98309582e-02f, 3.27627361e-02f, 9.21781063e-01f, 3.40382248e-01f,
  -2.99289912e-01f, 2.24716246e-01f, -4.88978833e-01f, -4.05880988e-01f, -7.32008934e-01f, 2.48553932e-01f, -7.74735391e-01f, -3.39819282e-01f, 9.90470871e-02f, 7.54522011e-02f,
  4.46345598e-01f, 3.59444320e-01f, -9.24510583e-02f, -5.20081818e-01f, 8.79700303e-01f, 3.56811285e-01f, 8.07452723e-02f, -6.53297231e-02f, -2.27908790e-01f, -1.62748292e-01f,
  -5.10128260e-01f, 4.04727533e-02f, 3.36236894e-01f, -4.93730843e-01f, -5.21667540e-01f, -2.80728728e-01f, 6.17994189e-01f, 8.98794085e-03f, -2.18605936e-01f, 1.99553147e-02f,
  -5.23259878e-01f, 5.86960092e-02f, 5.99473678e-02f, -2.16198534e-01f, 8.78180385e-01f, 4.74936366e-01f, 2.80932486e-01f, -2.32284233e-01f, 1.21616483e-01f, -8.70767981e-02f,
  -3.19064528e-01f, -4.05298501e-01f, -3.87544483e-01f, -3.20058674e-01f, 1.81768149e-01f, 7.76529491e-01f, -6.56985223e-01f, 3.13608646e-02f, -1.05220810e-01f, 9.00834873e-02f,
  3.50512922e-01f, -6.05048761e-02f, 2.05730110e-01f, -2.10521281e-01f, 5.33574283e-01f, 5.22497296e-01f, 2.51971364e-01f, -2.29997873e-01f, -1.90106302e-01f, 1.18928134e-01f,
  -9.37848985e-02f, -2.52717674e-01f, 5.94332337e-01f, -2.06007108e-01f, -2.33541965e-01f, -1.80487141e-01f, -8.50114226e-01f, -4.03693557e-01f, -9.21056122e-02f, 5.81845418e-02f,
  -7.45265305e-01f, 2.77021170e-01f, 6.53033972e-01f, 6.55792207e-02f, -3.17887753e-01f, 8.68702173e-01f, -5.04277647e-01f, -1.07652545e-02f, 3.77110660e-01f, 1.11793568e-02f,
  3.48699093e-01f, 7.99801201e-03f, -2.08448604e-01f, -1.54855654e-01f, 3.99704903e-01f, 1.40124276e-01f, -2.60279346e-02f, 4.88184094e-01f, 1.22785032e-01f, -5.73339641e-01f,
  -1.66764289e-01f, 4.61916208e-01f, -4.95675683e-01f, 1.20432734e-01f, -5.96807361e-01f, 4.94500771e-02f, -1.95333764e-01f, 1.80212304e-01f, 8.28212738e-01f, 5.02719343e-01f,
  -1.37204915e-01f, -2.16504008e-01f, 4.76056844e-01f, -1.12316906e+00f, -3.96705985e-01f, -1.71643481e-01f, -6.29299730e-02f, -9.29969907e-01f, 2.05546901e-01f, -7.82489032e-02f,
  4.45323914e-01f, 1.48422062e-01f, -2.45806322e-01f, -1.95160620e-02f, -3.40659097e-02f, 1.26871452e-01f, -5.28391242e-01f, 1.61478538e-02f, -2.89372414e-01f, -4.21580732e-01f,
  -7.71231771e-01f, 6.67427182e-01f, 8.17028522e-01f, -9.08608794e-01f, 2.02646554e-01f, -3.62926811e-01f, -5.24422467e-01f, 2.12443359e-02f, 3.33174169e-02f, 2.05767602e-01f,
  -2.86844254e-01f, -5.22912621e-01f, 5.53508282e-01f, -2.29145631e-01f, 1.63026854e-01f, 5.92679143e-01f, 6.56809628e-01f, -4.65880185e-01f, -8.16034496e-01f, 4.63367164e-01f,
  -1.31587144e-02f, 4.35059577e-01f, 1.99668631e-01f, -1.43066958e-01f, 2.21620634e-01f, 2.26831913e-01f, 3.51549417e-01f, 9.88528356e-02f, -1.66549683e-01f, -1.88097209e-01f,
  4.52389807e-01f, 8.86512622e-02f, -4.10578996e-01f, 1.70092545e-02f, 4.13805783e-01f, -1.58456638e-01f, 1.14728287e-01f, -3.62899780e-01f, -6.81613922e-01f, 1.96062982e-01f,
  -4.67726178e-02f, 2.43381143e-01f, -6.76563382e-02f, 8.17556262e-01f, 7.55422056e-01f, -1.82316527e-01f, -8.06751549e-02f, -8.74367133e-02f, 3.83613825e-01f, -5.27137220e-01f,
  -4.80808824e-01f, 3.89857441e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.93298095e-01f, 2.10546821e-01f, -3.18905979e-01f, 1.27663746e-01f, 4.84360576e-01f, 2.29015332e-02f, -2.91843981e-01f, -4.95494306e-02f, 1.12123363e-01f, 2.98102889e-02f,
  1.25990147e-02f, -5.07231712e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    