/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.07619935e-02f, 3.03195238e-01f, -2.29791895e-01f, -7.91193619e-02f, -1.41322151e-01f, 1.87426269e-01f, 3.01054083e-02f, 1.22779131e-01f, -1.41037339e-02f, 2.25999177e-01f,
  5.83147891e-02f, 3.65359299e-02f, 1.25916213e-01f, 2.34294102e-01f, -2.53577232e-01f, 4.82272543e-02f, 1.15625590e-01f, 4.47648279e-02f, -6.91753849e-02f, 4.94736396e-02f,
  -7.63544021e-03f, 1.88209683e-01f, -1.49352457e-02f, 8.75967462e-03f, 4.10728604e-02f, -2.12895796e-01f, -7.10388348e-02f, -1.88221857e-01f, 8.63472596e-02f, -1.11104682e-01f,
  1.28979221e-01f, -2.49663331e-02f, 2.97778584e-02f, -3.61021236e-02f, 8.70558918e-02f, 8.02745298e-02f, -4.89481091e-02f, -4.83871549e-02f, -7.23231584e-02f, -2.70095672e-02f,
  -5.52731613e-03f, -9.12576041e-04f, 2.48856400e-03f, -5.58835678e-02f, 1.07408531e-01f, -2.64544375e-02f, -8.37358311e-02f, 4.49360274e-02f, -3.95693853e-02f, 3.13987471e-02f,
  -3.11586987e-02f, 1.89048972e-03f, -1.79825965e-02f, -3.20834899e-03f, -1.06098220e-01f, -5.30529488e-03f, -4.30737287e-02f, -2.60223653e-02f, 2.36197878e-02f, 1.64286084e-02f,
  -3.08531523e-02f, 5.77937998e-02f, 2.32124701e-02f, 2.76397094e-02f, -2.20289342e-02f, 4.66199545e-03f, -5.20404149e-03f, 5.15404418e-02f, 3.36970575e-03f, 4.19587567e-02f,
  7.48267248e-02f, -8.69863387e-03f, 6.84898868e-02f, -9.71383322e-03f, 6.17746301e-02f, 2.56155953e-02f, -3.16448063e-02f, 2.61432901e-02f, 6.40683174e-02f, -5.94515353e-02f,
  -1.70369782e-02f, 2.23965850e-02f, 3.16779055e-02f, 2.39011552e-02f, 1.38184577e-02f, -5.08021191e-02f, 5.76393940e-02f, -5.61216921e-02f, -4.84471582e-02f, -8.34131055e-03f,
  3.27930033e-01f, 2.79232085e-01f, 8.73699933e-02f, 2.18186043e-02f, -7.77469482e-03f, -4.66562174e-02f, -5.06304689e-02f, 2.13827174e-02f, 1.26805365e-01f, -6.72091469e-02f,
  2.23601032e-02f, 2.34807562e-02f, 8.06169137e-02f, -1.89069994e-02f, 2.03440618e-02f, -3.15987282e-02f, 1.01015590e-01f, 9.28242207e-02f, 1.19474530e-01f, 2.27847900e-02f,
  4.31403965e-02f, 2.51824409e-02f, -6.33449554e-02f, -8.27397853e-02f, 1.09830108e-02f, -3.50379609e-02f, -1.35754086e-02f, -1.08953364e-01f, -7.79573470e-02f, 3.49128731e-02f,
  -2.83241183e-01f, 1.46331385e-01f, -7.57334530e-02f, 6.09002113e-02f, -1.71090901e-01f, -7.43648559e-02f, -1.35493353e-01f, 4.99910340e-02f, -1.72111899e-01f, 1.08870283e-01f,
  1.31173041e-02f, -4.71671037e-02f, 1.36540923e-02f, 1.94100097e-01f, -3.06722909e-01f, 1.37313217e-01f, 6.11239411e-02f, 4.29956876e-02f, 6.81804419e-02f, -2.15394832e-02f,
  -5.21598682e-02f, 7.16526955e-02f, 3.66241783e-02f, 1.62946165e-01f, -1.40673339e-01f, -4.17013057e-02f, 1.01071000e-01f, -5.66510409e-02f, 3.38110290e-02f, 8.18502042e-04f,
  2.82533579e-02f, 7.53203183e-02f, -3.05374488e-02f, 7.30306795e-03f, -2.27444433e-02f, -6.69213533e-02f, -2.16720216e-02f, -9.60945059e-03f, -3.51337455e-02f, -2.71277074e-02f,
  1.53592313e-02f, 5.51896654e-02f, 3.23031917e-02f, 1.40965395e-02f, -1.82673391e-02f, -2.24638339e-02f, 4.75017801e-02f, -3.71235982e-02f, 6.07839935e-02f, -5.75496666e-02f,
  -4.94535826e-03f, -6.23333789e-02f, 3.93683314e-02f, -1.68184973e-02f, -6.27304465e-02f, -1.56653710e-02f, -2.48912014e-02f, 4.53892443e-03f, -3.19827460e-02f, 3.49803641e-02f,
  3.61571810e-03f, -6.16529249e-02f, -5.58785209e-03f, 7.67510291e-03f, 2.16662213e-02f, -3.23293321e-02f, -1.49685219e-02f, 2.65947916e-02f, -6.08472154e-02f, -4.85533588e-02f,
  -2.45760027e-02f, -4.35013212e-02f, 4.38659452e-02f, -4.47399504e-02f, -3.34919128e-03f, 1.93952844e-02f, 3.81610766e-02f, -1.88113544e-02f, -4.35263664e-02f, -7.09329545e-02f,
  5.28021976e-02f, 4.14880104e-02f, 1.21997939e-02f, 2.45070700e-02f, 5.57623580e-02f, -2.36159819e-03f, 5.57696931e-02f, 4.05938886e-02f, 3.68979643e-03f, -3.67018841e-02f,
  -4.17393260e-03f, 1.71798721e-01f, 7.03098699e-02f, 4.59069498e-02f, -1.34436376e-02f, 5.48181944e-02f, 2.13699117e-02f, -2.57220659e-02f, 2.50522960e-02f, 6.81772828e-03f,
  -1.52336853e-02f, -4.53877933e-02f, -6.12778496e-03f, -2.78033689e-02f, -2.57908087e-02f, 2.89017782e-02f, -1.89628340e-02f, -5.98010570e-02f, -4.08870019e-02f, 3.11192553e-02f,
  -5.10159582e-02f, -1.94904804e-02f, -5.11958189e-02f, 1.03461649e-02f, 8.98589566e-03f, -3.43438648e-02f, -6.33023083e-02f, -1.50923170e-02f, 2.88169570e-02f, -8.87717772e-03f,
  4.46747065e-01f, 1.27319172e-01f, 6.07743077e-02f, 2.76966363e-01f, -3.48065384e-02f, -1.76776692e-01f, -5.98897636e-02f, 6.00392185e-02f, 2.76160955e-01f, -5.33248261e-02f,
  -6.07364327e-02f, 1.49528503e-01f, -6.83948817e-03f, -7.92745352e-02f, 7.36847371e-02f, 1.35290800e-02f, -3.55060026e-02f, -1.75832119e-02f, 8.08039084e-02f, 9.67203230e-02f,
  5.25157675e-02f, -1.65741116e-01f, -2.12687589e-02f, -1.20703189e-03f, 1.04673445e-01f, 1.86111238e-02f, -1.61811382e-01f, -1.16702825e-01f, -2.01407611e-01f, -1.63381081e-02f,
  -2.90399306e-02f, 1.81432232e-01f, -5.80671616e-03f, 1.07642310e-02f, -2.83746398e-03f, -1.66140050e-02f, -1.01831868e-01f, -1.01587892e-01f, 7.38059282e-02f, -8.88474472e-03f,
  5.05762510e-02f, -9.59985331e-02f, 2.21559778e-03f, 2.29222439e-02f, -2.59557292e-02f, 3.25892940e-02f, 7.95866847e-02f, 7.63463527e-02f, 3.52408215e-02f, 9.00235325e-02f,
  5.43363243e-02f, -5.39076189e-03f, 1.22075155e-02f, -2.79915798e-02f, -3.28075215e-02f, 4.77251597e-03f, 1.20966043e-02f, -6.99733123e-02f, 1.86219849e-02f, 1.04899444e-01f,
  -5.28943539e-02f, -2.52850587e-03f, -3.00095882e-03f, -1.71444495e-03f, 4.54185717e-03f, -2.58935653e-02f, -1.25473775e-02f, -2.01439019e-02f, -3.26065570e-02f, 6.82093389e-03f,
  1.66442450e-02f, 6.85289968e-03f, 1.37151247e-02f, 6.43474162e-02f, 4.92004342e-02f, 5.84746599e-02f, -1.42972162e-02f, 3.41038033e-03f, 4.99042496e-02f, 1.21903177e-02f,
  -1.05477253e-03f, -4.81095500e-02f, -2.21666917e-02f, -4.89015579e-02f, -1.80648058e-03f, 3.17902565e-02f, 8.11706930e-02f, -2.87757479e-02f, -4.11657840e-02f, 1.38077792e-02f,
  -1.20484918e-01f, -1.23471551e-01f, 1.84766501e-02f, -5.67356125e-02f, -1.31773809e-03f, -7.05190822e-02f, -3.00294273e-02f, -2.11356152e-02f, -4.75750566e-02f, -1.28469886e-02f,
  -2.54165549e-02f, 2.90636215e-02f, -6.46575317e-02f, 1.75839774e-02f, 1.12803644e-02f, -3.45419184e-03f, -1.75679419e-02f, -7.93793052e-02f, -3.49999592e-02f, -1.09386683e-01f,
  -6.98565319e-02f, -6.77028112e-03f, -3.08530638e-03f, 2.24852767e-02f, -1.08408136e-02f, -5.42015620e-02f, -3.12518515e-02f, -1.31077089e-04f, -1.05694704e-01f, -6.47195354e-02f,
  -3.82471919e-01f, -6.64512590e-02f, 2.17663795e-02f, -1.61054119e-01f, -2.58609772e-01f, 2.84707278e-01f, 2.68943906e-01f, -2.21454278e-01f, -5.78498729e-02f, 1.95618749e-01f,
  -9.81750414e-02f, -1.31600454e-01f, 1.69379294e-01f, -9.35031697e-02f, -5.00865504e-02f, 2.35691518e-01f, -5.07545210e-02f, 5.33243641e-02f, 5.13718501e-02f, -1.85216516e-01f,
  -1.03179524e-02f, -1.81366473e-01f, -2.59219389e-02f, -1.05460383e-01f, -5.92713319e-02f, -1.11659668e-01f, 1.45468814e-02f, 5.67695983e-02f, -7.18527287e-02f, 7.14033619e-02f,
  -5.05231097e-02f, -1.27420902e-01f, -2.45191976e-02f, 6.87066838e-02f, -5.83749525e-02f, 3.07387095e-02f, 6.75783306e-02f, 1.50088668e-01f, 4.69022617e-02f, 2.15573572e-02f,
  7.95508102e-02f, -8.82289633e-02f, -3.14738192e-02f, 1.51892796e-01f, 6.22772723e-02f, 8.97631608e-03f, -8.48326925e-03f, 6.34583412e-03f, -1.14776455e-01f, 6.29637688e-02f,
  2.10081339e-02f, 2.17935611e-02f, 2.40870677e-02f, 4.05134335e-02f, -7.51782395e-03f, 2.75084767e-02f, 2.00364646e-02f, -1.53078800e-02f, 5.75907901e-02f, -1.12526044e-01f,
  9.74697024e-02f, 7.98715092e-03f, 4.42549959e-02f, -4.90814298e-02f, -4.87172278e-03f, -5.88697717e-02f, 4.47485037e-02f, -2.68411078e-02f, 1.17468443e-02f, -2.60122810e-02f,
  -4.80652153e-02f, -3.89075875e-02f, -8.58760402e-02f, 9.31820646e-02f, -2.48570405e-02f, -7.30468705e-02f, 1.07169896e-01f, 1.35517903e-02f, -7.42647052e-02f, -2.80905757e-02f,
  2.17647273e-02f, -6.96930150e-03f, -5.12951845e-03f, 2.49091070e-02f, -4.70464155e-02f, 2.05855314e-02f, 2.12280452e-02f, -3.27942520e-02f, 2.09270213e-02f, 1.16720069e-02f,
  -6.15797862e-02f, -1.30278945e-01f, 7.00912159e-03f, -4.84995730e-02f, 1.15678674e-02f, 1.13153569e-01f, -1.05950665e-02f, -4.06086035e-02f, 9.33353752e-02f, 5.62101752e-02f,
  2.41830070e-02f, 3.42253223e-02f, -6.12515323e-02f, 4.53236550e-02f, 3.37086655e-02f, -3.34676504e-02f, -3.61608490e-02f, 1.09965559e-02f, -1.46426447e-02f, 3.26998271e-02f,
  -6.96914345e-02f, -5.39621152e-03f, 1.75465643e-02f, -1.10849157e-01f, 7.46782422e-02f, -5.78868464e-02f, -8.09870437e-02f, 5.20881601e-02f, 7.40918070e-02f, 9.41835716e-02f,
  2.14282155e-01f, -1.00941613e-01f, -9.99063030e-02f, -1.62560105e-01f, 2.67252445e-01f, 8.38435516e-02f, -2.96655983e-01f, 6.28696829e-02f, -1.29378244e-01f, -1.79454982e-01f,
  1.19366981e-01f, -1.80628285e-01f, -1.25201300e-01f, -2.12213434e-02f, 1.81203082e-01f, -2.34056830e-01f, 1.16616637e-01f, -1.81820944e-01f, -5.60093820e-02f, 9.31845978e-02f,
  1.01709273e-02f, 1.70537755e-01f, 3.94257391e-03f, 1.04793712e-01f, 6.82018772e-02f, -1.16078675e-01f, 1.57540023e-01f, -5.25782295e-02f, 8.03009942e-02f, 1.21597432e-01f,
  -6.63972422e-02f, -5.63741848e-02f, -7.93331042e-02f, -9.11595449e-02f, 6.23440593e-02f, -4.55094799e-02f, -5.65834381e-02f, -6.63663493e-03f, -1.93535425e-02f, -4.79156859e-02f,
  -2.52969749e-02f, -1.98086370e-02f, -9.01821405e-02f, -4.68553640e-02f, -2.20918730e-02f, -6.79570511e-02f, 1.91778671e-02f, 6.36047646e-02f, -5.01835681e-02f, 8.08766037e-02f,
  -6.43691197e-02f, -2.85680667e-02f, 2.12255195e-02f, -3.51134799e-02f, 9.49180871e-02f, -2.28633992e-02f, -8.78226534e-02f, -6.11390686e-03f, 1.10186217e-02f, 1.03386333e-02f,
  8.78878832e-02f, -9.79328975e-02f, 2.06839908e-02f, -3.81150693e-02f, 3.68782505e-02f, 4.29850966e-02f, -3.80938239e-02f, -5.31411916e-02f, -4.90787849e-02f, -1.29842723e-03f,
  4.77131307e-02f, -2.26607453e-02f, -1.71217751e-02f, -2.20834631e-02f, -5.59324399e-02f, -4.07464989e-02f, -2.19444539e-02f, 1.01849530e-02f, -2.88261902e-02f, 5.31086549e-02f,
  -7.60475174e-02f, 5.97878136e-02f, -5.03731817e-02f, -1.97686758e-02f, 3.31178978e-02f, 2.15498526e-02f, 3.72334570e-02f, 4.95587550e-02f, -1.71335749e-02f, 3.89217883e-02f,
  1.14815444e-01f, 1.85021654e-01f, -9.59224179e-02f, -1.53255910e-02f, -5.64872473e-02f, 1.31809190e-01f, -1.23458818e-01f, 5.14268279e-02f, 2.16807909e-02f, 7.72836208e-02f,
  1.47750098e-02f, -8.10572878e-03f, 3.69370580e-02f, 2.53549777e-02f, -7.34396838e-03f, -1.80045199e-02f, 1.24962674e-02f, -7.20157176e-02f, 4.61822823e-02f, 3.67859118e-02f,
  6.17127344e-02f, 4.71819602e-02f, -4.54183668e-02f, 1.38432980e-02f, 6.43968657e-02f, 6.47089817e-03f, 1.01358242e-01f, -7.82048032e-02f, 4.80352715e-02f, -9.36615989e-02f,
  -6.37918115e-02f, -3.41222316e-01f, -5.39063551e-02f, 6.21709451e-02f, 6.71724230e-02f, 1.20672487e-01f, 1.19905666e-01f, -1.61990285e-01f, -2.91092157e-01f, -7.85610899e-02f,
  2.71380782e-01f, 3.72191542e-03f, 1.06499441e-01f, 9.02432874e-02f, 4.57854271e-02f, -7.89724588e-02f, 2.83150766e-02f, 3.28999124e-02f, -1.01029389e-01f, -2.91470215e-02f,
  -3.44842710e-02f, 1.54133916e-01f, 9.61172581e-02f, -9.68996137e-02f, 2.89559867e-02f, -8.98975357e-02f, 1.18712336e-01f, 1.11926146e-01f, 1.71249583e-01f, 5.99790290e-02f,
  1.16652593e-01f, -1.43366724e-01f, 3.78922857e-02f, -6.26110211e-02f, -5.60856536e-02f, 8.48876089e-02f, 3.38600762e-02f, 6.71117529e-02f, 8.58622417e-02f, -3.64115578e-03f,
  -4.05801497e-02f, -4.43540439e-02f, -4.76555862e-02f, -5.67658478e-03f, -2.65885424e-02f, -7.73689598e-02f, 3.43587585e-02f, 1.58603564e-02f, -1.58205722e-02f, -8.44958499e-02f,
  2.49255961e-03f, 1.91875622e-02f, 2.94105224e-02f, 3.59721780e-02f, -1.17236534e-02f, -7.01835155e-02f, 3.81030818e-03f, 3.94750647e-02f, -8.13348740e-02f, -2.45749559e-02f,
  -2.92641129e-02f, -1.80638675e-03f, -1.66870914e-02f, 3.22680245e-03f, 9.84373037e-03f, 7.07442909e-02f, 2.32407153e-02f, 5.56173436e-02f, -1.10634984e-02f, -3.55546884e-02f,
  -2.57453024e-02f, 5.11336839e-03f, 1.45596860e-03f, -2.70280931e-02f, 3.96987312e-02f, -8.60753749e-03f, 6.17887340e-02f, 4.72568581e-03f, 2.70145889e-02f, 5.21261692e-02f,
  2.82041542e-02f, 3.00426651e-02f, -2.26819795e-03f, 8.30407068e-02f, -2.28672270e-02f, 5.58755882e-02f, -3.18261497e-02f, 7.01836729e-03f, 3.59683596e-02f, -2.46500946e-03f,
  -2.33463123e-02f, -1.84900090e-01f, -3.65857594e-02f, 3.82524803e-02f, 6.97114393e-02f, -5.39416149e-02f, -4.75030914e-02f, -9.47785154e-02f, -2.56208964e-02f, -1.83319952e-02f,
  1.52467797e-02f, 2.36175638e-02f, -2.50877943e-02f, 1.26438132e-02f, 7.61806080e-03f, -2.24853642e-02f, 6.09062873e-02f, 5.59212975e-02f, 1.71356630e-02f, 5.02840281e-02f,
  -1.19734993e-02f, -2.43983995e-02f, -1.07791685e-02f, -2.05718838e-02f, 2.06189174e-02f, 7.54884854e-02f, -4.23268080e-02f, -3.63477655e-02f, -9.80705721e-04f, -6.17419509e-03f,
  3.23189534e-02f, -1.09768920e-01f, -9.64817181e-02f, 1.46372274e-01f, -1.90316945e-01f, -1.10938028e-01f, 1.25158876e-01f, -1.51205122e-01f, 9.32850838e-02f, 2.12673340e-02f,
  1.00714423e-01f, 1.58984348e-01f, 1.71787247e-01f, -3.59003316e-03f, 1.79807350e-01f, 1.93966374e-01f, -1.78583078e-02f, -3.02454494e-02f, -6.96488246e-02f, -1.21282421e-01f,
  -1.26635497e-02f, 1.31108612e-02f, 1.45378605e-01f, -2.48204648e-01f, -1.44673869e-01f, -1.06086574e-01f, 2.16129780e-01f, 3.07862163e-02f, -8.66389424e-02f, 1.04015008e-01f,
  -7.23025948e-02f, 4.93884049e-02f, -9.70327631e-02f, 5.07676564e-02f, -6.17815070e-02f, 5.59031684e-03f, -4.02905419e-02f, 6.35563657e-02f, 6.25756457e-02f, -2.70968191e-02f,
  1.29272304e-02f, -3.17683518e-02f, 4.12886553e-02f, 6.24938197e-02f, -5.38443439e-02f, -4.13105860e-02f, -6.95978403e-02f, 6.52168412e-03f, -7.15240687e-02f, -2.26319265e-02f,
  3.05862515e-04f, -6.28736392e-02f, -5.93829202e-03f, 7.75698945e-02f, -1.68719087e-02f, -1.78497341e-02f, -9.21833515e-03f, -7.12938234e-03f, 2.09636763e-02f, -6.77959323e-02f,
  -3.62763531e-03f, -1.48117188e-02f, 8.13729987e-02f, -7.29814023e-02f, 3.34194070e-03f, -3.91757004e-02f, 3.17830816e-02f, 5.73734678e-02f, 1.10635161e-02f, -1.78257450e-02f,
  -5.48318326e-02f, 1.98391248e-02f, -6.26476780e-02f, -2.46144515e-02f, 2.46565286e-02f, 5.08135259e-02f, 5.75221749e-03f, -5.62670790e-02f, -5.88633753e-02f, -7.53631815e-03f,
  5.06601147e-02f, -1.28435284e-01f, 7.95485750e-02f, 2.25630421e-02f, -3.61572169e-02f, 6.20714463e-02f, -4.19507548e-02f, -9.39326733e-03f, 3.77537310e-02f, 3.93290222e-02f,
  -9.30014849e-02f, 1.08361803e-01f, 7.21341074e-02f, -8.58662464e-03f, 9.89501551e-03f, 1.21416012e-02f, 3.03910375e-02f, -3.04146782e-02f, 4.04881947e-02f, -4.04714532e-02f,
  -2.65281890e-02f, 2.40693607e-05f, -4.32107896e-02f, -3.12873237e-02f, 1.12673633e-01f, -3.66013125e-02f, 9.53053609e-02f, 2.47978512e-02f, 1.36165954e-02f, 1.65632106e-02f,
  1.07175270e-02f, 2.93030832e-02f, 6.91791857e-03f, -1.72353052e-02f, 3.77679057e-02f, 8.90833363e-02f, -1.02740988e-01f, -1.01024136e-02f, 1.60066113e-02f, -3.66729051e-02f,
  2.21978903e-01f, -1.11657619e-01f, -1.40088931e-01f, -8.82460028e-02f, 4.35025096e-02f, 9.55940634e-02f, 3.69109027e-03f, -1.16997957e-01f, 1.65759534e-01f, -1.81132808e-01f,
  -1.44979447e-01f, 1.82497516e-01f, -3.77018414e-02f, -7.61559606e-02f, 3.93262386e-01f, 3.10770627e-02f, -1.20489802e-02f, 1.34055734e-01f, 5.08374105e-05f, -4.44971472e-02f,
  -7.00902268e-02f, 3.74898873e-02f, -1.68032736e-01f, -5.06152958e-02f, -1.51301801e-01f, -6.60229474e-02f, -4.74907830e-02f, 5.40640205e-02f, -1.42149046e-01f, 1.80556968e-01f,
  -6.45065233e-02f, -8.39863122e-02f, -7.32896551e-02f, -1.03116948e-02f, 5.72738424e-03f, -6.42699227e-02f, -2.83045936e-02f, 4.48483340e-02f, -1.27158668e-02f, -2.75473837e-02f,
  7.88035020e-02f, -9.94314998e-03f, -2.28865407e-02f, 3.67808412e-03f, -2.33371672e-03f, -1.34672252e-02f, -9.37440433e-03f, -8.19087103e-02f, -9.78290439e-02f, -3.62638868e-02f,
  -2.15116441e-02f, -2.93473899e-02f, 4.67816144e-02f, 4.12743688e-02f, 1.76676121e-02f, 7.11958564e-04f, 2.47877110e-02f, -7.58479116e-03f, 1.23086087e-02f, 9.28254277e-02f,
  2.21288390e-02f, 9.06344801e-02f, -3.18818949e-02f, -5.75564839e-02f, 7.12768361e-02f, -1.03051759e-01f, 5.19900434e-02f, -1.73073448e-02f, -2.45707072e-02f, -1.49485245e-02f,
  6.02666326e-02f, -3.12405638e-02f, 3.51653285e-02f, -5.86667918e-02f, -5.07946350e-02f, -4.04606313e-02f, 6.76186532e-02f, 1.68431234e-02f, -7.42119774e-02f, -3.77593189e-02f,
  -3.38083841e-02f, 1.22231707e-01f, -1.55298868e-02f, -5.62147051e-02f, 5.90107776e-02f, -5.06929830e-02f, -9.32017528e-03f, 2.05813013e-02f, -1.09562948e-02f, 3.03328149e-02f,
  5.99740297e-02f, 1.49120800e-02f, -6.34766966e-02f, 3.59771065e-02f, 1.38747683e-02f, -2.02148426e-02f, 5.37456311e-02f, 5.63228913e-02f, -5.25579555e-03f, 2.77824551e-02f,
  -3.45427580e-02f, 2.17318516e-02f, 1.00653104e-01f, 2.44962052e-02f, -8.36145319e-03f, -5.15186787e-02f, 4.12411727e-02f, 9.33026075e-02f, 5.51686399e-02f, 3.82013433e-02f,
  4.33129258e-02f, -7.19418144e-03f, -5.52842841e-02f, -1.70131791e-02f, -1.85478702e-02f, 3.33822928e-02f, 1.17999256e-01f, -2.10231766e-02f, 6.60913661e-02f, 6.04779162e-02f,
  -7.11809173e-02f, -2.54754752e-01f, -1.06592834e-01f, -2.94022739e-01f, 4.39264402e-02f, 3.76642704e-01f, 4.77418564e-02f, -9.39687807e-03f, -2.66703993e-01f, 6.26017377e-02f,
  9.53196287e-02f, -2.66939372e-01f, 1.07786944e-02f, 1.23683318e-01f, 3.59941006e-01f, 2.00178847e-01f, 7.01330006e-02f, -6.97271749e-02f, -1.47328570e-01f, -2.06339583e-01f,
  -7.55364075e-02f, 1.12190507e-01f, 2.07205489e-02f, -4.53890068e-03f, -4.33400422e-02f, -1.15773357e-01f, 1.35334894e-01f, -6.85848817e-02f, 2.28592530e-01f, 7.84947351e-02f,
  9.03508216e-02f, -1.82168275e-01f, -7.49921724e-02f, 9.95479897e-02f, 8.96706581e-02f, -4.53179106e-02f, 9.56649631e-02f, 6.30818903e-02f, 4.43688147e-02f, 6.14758208e-02f,
  5.11386134e-02f, 1.59010038e-01f, -4.83786166e-02f, 3.95553522e-02f, -6.04817122e-02f, -3.74500155e-02f, -4.84481901e-02f, 3.02423928e-02f, -9.46326032e-02f, -4.53803167e-02f,
  -4.30196151e-02f, -2.08093356e-02f, -2.82864757e-02f, 8.29827189e-02f, -4.32239026e-02f, -2.91995909e-02f, 5.96361570e-02f, 1.44850016e-02f, 6.39716536e-02f, -2.16415599e-02f,
  6.37963861e-02f, -5.08340076e-02f, -4.33681719e-02f, 1.29779698e-02f, 3.60836983e-02f, 9.75977629e-03f, 2.60878075e-02f, 3.27636488e-02f, -4.77194153e-02f, 1.87091641e-02f,
  2.16450207e-02f, 3.74845229e-02f, 3.51085328e-02f, -1.18559925e-02f, -4.38622050e-02f, -4.97769266e-02f, 4.05870080e-02f, 4.29636315e-02f, -3.29075232e-02f, 4.99924123e-02f,
  -6.14527017e-02f, 6.83576334e-03f, -1.64303444e-02f, 1.49150976e-04f, 7.09137395e-02f, 5.67033552e-02f, 1.85845848e-02f, -2.45701727e-02f, -8.11245367e-02f, -6.39605969e-02f,
  -6.76301047e-02f, -1.89902738e-01f, -8.72408152e-02f, -1.57166421e-02f, -3.19920667e-02f, 6.24975152e-02f, -2.16980372e-02f, -1.13368146e-02f, -4.50119413e-02f, 2.65496448e-02f,
  1.74079165e-02f, -7.83702657e-02f, 9.11675766e-03f, 8.52732062e-02f, 2.36019585e-02f, 7.85719156e-02f, -1.09411273e-02f, 7.65687972e-02f, 1.44009786e-02f, 2.57965252e-02f,
  -9.53109190e-02f, 2.81363353e-02f, -8.42424482e-02f, -6.76383078e-02f, 4.60850336e-02f, -7.50936493e-02f, -3.03757191e-02f, 2.03294102e-02f, 3.91091630e-02f, -2.25717630e-02f,
  1.40907587e-02f, 2.64133632e-01f, 9.21673104e-02f, 1.11470511e-02f, -2.80590076e-02f, -1.21962391e-01f, -9.11255851e-02f, 1.42503167e-02f, 1.27626639e-02f, 4.01727669e-02f,
  -2.73925453e-01f, 3.61379027e-01f, -1.29291847e-01f, -8.21314976e-02f, -1.93430945e-01f, -7.13311061e-02f, -1.53885871e-01f, 9.03435051e-02f, 3.98278385e-02f, 1.13986515e-01f,
  -5.59097342e-02f, -4.75612432e-02f, -2.28204817e-01f, 8.37403238e-02f, 7.51269087e-02f, 1.10302769e-01f, -7.98627883e-02f, 2.75923703e-02f, 9.20784026e-02f, 4.31173444e-02f,
  -1.36922941e-01f, 4.65831645e-02f, 4.63322140e-02f, 9.46872868e-03f, -9.72539708e-02f, -7.91481510e-02f, 7.62718078e-03f, 1.37913236e-02f, -5.05932495e-02f, 5.95275592e-03f,
  2.79148072e-02f, -1.12810936e-02f, 8.39884486e-03f, -1.10120419e-02f, 2.99796741e-03f, 1.01251667e-02f, -1.36580439e-02f, -9.88764167e-02f, 4.06735502e-02f, -6.61653951e-02f,
  1.74407791e-02f, -9.40335244e-02f, -9.27534699e-02f, -2.71478891e-02f, -1.44797552e-03f, 2.08074674e-02f, 2.40367670e-02f, -6.03727177e-02f, -5.22989500e-03f, 7.02898856e-03f,
  5.33322357e-02f, -1.18911602e-02f, -5.02846576e-02f, 6.95205247e-03f, -3.67941149e-02f, -2.03242283e-02f, 2.01880876e-02f, -2.68856231e-02f, 7.70878345e-02f, 6.25059707e-03f,
  -6.22605458e-02f, -2.00578268e-03f, -4.84843506e-03f, 9.92581528e-03f, -8.54912102e-02f, 4.71438468e-02f, 2.29194462e-02f, 4.82272990e-02f, -6.72259033e-02f, -9.85123403e-03f,
  1.48009770e-02f, 5.18913195e-02f, 1.17433779e-02f, -9.78362784e-02f, -3.46366912e-02f, 1.50351478e-02f, -4.47069220e-02f, -4.57054973e-02f, -4.60351855e-02f, -5.66155352e-02f,
  6.99880049e-02f, 2.10092813e-01f, -8.32588971e-02f, 3.42635103e-02f, 5.72180562e-02f, -3.72684449e-02f, 2.15105433e-02f, 4.56319824e-02f, 5.07063083e-02f, -3.02921683e-02f,
  -1.88476946e-02f, -4.66997772e-02f, 5.72798448e-03f, 4.00103331e-02f, -8.63716230e-02f, -1.70605984e-02f, 1.57722495e-02f, 1.46778608e-02f, 4.37945276e-02f, 2.63723321e-02f,
  -1.12189278e-01f, 7.22248480e-02f, -3.42754349e-02f, -8.65221992e-02f, -5.07751256e-02f, -8.94564856e-03f, 6.61249384e-02f, 5.76075949e-02f, 6.45653112e-03f, 8.24390724e-02f,
  2.65790820e-01f, -7.71707967e-02f, 6.76102117e-02f, -9.76526365e-02f, 2.13250190e-01f, 1.81209445e-01f, 9.82329696e-02f, 1.68930367e-01f, 2.78063536e-01f, -9.67571959e-02f,
  2.12217513e-02f, -8.86575803e-02f, 4.96328436e-02f, -1.74318790e-01f, -1.49459824e-01f, -6.44271895e-02f, -6.75839633e-02f, -1.16658255e-01f, 1.11907452e-01f, 6.24718666e-02f,
  -1.79333948e-02f, -8.35176036e-02f, -1.65983871e-01f, 9.02663246e-02f, -3.90943550e-02f, -5.64340055e-02f, -1.13500193e-01f, 9.86722186e-02f, -2.97672004e-01f, 9.67179798e-03f,
  4.21572849e-02f, 4.87943403e-02f, 1.01447627e-02f, -6.00320883e-02f, -2.00213995e-02f, 2.38229856e-02f, -4.06385027e-03f, -3.54646482e-02f, 5.24747185e-02f, -4.09426019e-02f,
  -1.03420354e-01f, 2.49175113e-02f, -3.83212045e-02f, 3.67130712e-02f, 1.18865497e-01f, -3.31488736e-02f, 5.65321110e-02f, 4.32434939e-02f, -7.60674104e-03f, 2.20666807e-02f,
  2.60929950e-02f, 3.03544980e-02f, 4.60959214e-04f, -7.99903423e-02f, -7.21592084e-02f, 2.78022718e-02f, -8.09705928e-02f, -1.01462239e-02f, -1.28125884e-02f, 9.51228738e-02f,
  2.64586937e-02f, 6.69755861e-02f, 7.64257610e-02f, -4.36913129e-03f, -1.22207720e-02f, 3.88007313e-02f, -2.44527254e-02f, -5.07076755e-02f, 2.29069330e-02f, -7.41135776e-02f,
  -2.51424648e-02f, -2.89774463e-02f, 1.91683378e-02f, 3.22639383e-02f, 2.77556274e-02f, -8.74857232e-03f, -8.24087393e-03f, -4.23660725e-02f, 7.38281161e-02f, 2.19511054e-03f,
  2.47419905e-02f, 4.63987403e-02f, -3.22602503e-02f, -1.32087115e-02f, 8.32252428e-02f, 4.13421951e-02f, 1.45750064e-02f, 5.46218194e-02f, 4.65604924e-02f, 3.05209163e-04f,
  -9.56370011e-02f, -5.57102486e-02f, 2.49924837e-03f, -1.21567696e-02f, 1.59754418e-02f, 6.70123920e-02f, -5.76380901e-02f, -2.39924751e-02f, 5.69447055e-02f, 5.58209233e-02f,
  -2.13139802e-02f, -7.04583600e-02f, -7.28233233e-02f, 4.01740037e-02f, 5.52550936e-03f, 4.46171407e-03f, -5.97308613e-02f, -3.05593777e-02f, -2.50533838e-02f, 4.00409009e-03f,
  -9.21015292e-02f, -2.97161024e-02f, 1.20027568e-02f, -2.62067262e-02f, -4.15818095e-02f, -4.21459451e-02f, 1.04555756e-01f, 3.35822627e-02f, -9.46702529e-03f, 2.53791120e-02f,
  7.04384372e-02f, 1.50884479e-01f, 2.33929932e-01f, -1.51211083e-01f, -8.89102742e-03f, 2.01501563e-01f, 1.10762812e-01f, -2.02719662e-02f, 1.10963665e-01f, -1.39496326e-01f,
  -1.99857444e-01f, 3.05485159e-01f, 1.17386200e-01f, -2.69363940e-01f, 2.14433730e-01f, 1.73297197e-01f, -1.08266212e-01f, -8.59721974e-02f, 1.81404725e-01f, 2.51717810e-02f,
  -2.51064319e-02f, -1.16343267e-01f, -6.67910501e-02f, -1.14606172e-01f, -4.09474932e-02f, -5.37537336e-02f, -2.47780815e-01f, 1.09806657e-01f, -1.79544210e-01f, 4.22242843e-02f,
  5.60481846e-02f, 9.93658155e-02f, -3.27684954e-02f, -3.69547829e-02f, -2.23780125e-02f, -5.13620563e-02f, -4.73427363e-02f, 4.36760969e-02f, 1.74107254e-02f, 4.69313115e-02f,
  1.01653993e-01f, -2.74176151e-02f, -1.42382113e-02f, -6.09017536e-03f, 6.22194633e-02f, -2.60792803e-02f, -2.78653242e-02f, -6.99871108e-02f, 1.92786213e-02f, 1.98443998e-02f,
  2.42356528e-02f, -3.33154760e-02f, -4.13497910e-02f, 9.16310120e-03f, 7.98764974e-02f, -8.85772984e-03f, 1.45153571e-02f, 8.67758468e-02f, 1.61108859e-02f, 3.03863566e-02f,
  -8.83759290e-04f, -1.84155330e-02f, -4.92612384e-02f, -6.31464049e-02f, 7.83325061e-02f, -1.28826290e-01f, 3.60695235e-02f, -1.84417963e-02f, 4.40155901e-02f, 1.29069993e-02f,
  6.70631602e-03f, -4.15393785e-02f, 3.15275081e-02f, -7.19480217e-02f, -8.30580518e-02f, 4.20276448e-03f, -2.37719826e-02f, 1.83221530e-02f, 2.11857036e-02f, -1.11392708e-02f,
  4.96108532e-02f, 6.54730350e-02f, -8.78445059e-03f, -5.00194542e-02f, 3.17139104e-02f, 7.80040473e-02f, -7.24817216e-02f, 1.33582465e-02f, -1.92649830e-02f, -1.33236945e-02f,
  1.05364926e-01f, 1.43867088e-02f, 7.09862337e-02f, 1.16411403e-01f, 2.97595076e-02f, -3.87067050e-02f, -1.31935766e-02f, 1.87744554e-02f, 5.02652824e-02f, -3.72761041e-02f,
  -7.35073611e-02f, -5.01502343e-02f, -1.75097156e-02f, -2.39873528e-02f, 3.31556052e-02f, -4.18837108e-02f, 2.09275596e-02f, 7.35689327e-02f, -1.23414705e-02f, -2.28047222e-02f,
  -4.59270030e-02f, 2.49709692e-02f, -8.90011527e-03f, -5.41220531e-02f, -7.96677247e-02f, -1.24301743e-02f, -1.29700368e-02f, 1.20548112e-02f, -3.50136720e-02f, 6.00343235e-02f,
  2.13462397e-01f, 8.63183066e-02f, 9.37573910e-02f, 1.62704721e-01f, 3.92136164e-02f, 1.09007895e-01f, 5.42534292e-02f, 7.02855224e-03f, -6.38567433e-02f, -2.24125739e-02f,
  -1.05990797e-01f, 1.96503624e-01f, -2.34887108e-01f, 1.30922943e-01f, -2.07117293e-03f, -2.40481094e-01f, 1.85980231e-01f, 1.05832800e-01f, -1.20584048e-01f, 1.69385716e-01f,
  5.62037304e-02f, -8.25289171e-03f, -8.28082021e-03f, -3.32668908e-02f, 1.74629793e-01f, 7.22543672e-02f, -5.27498946e-02f, -1.03355266e-01f, 2.86306828e-01f, 9.28579420e-02f,
  1.14790969e-01f, -1.94897372e-02f, -2.70148627e-02f, 6.43514171e-02f, 9.60010216e-02f, 4.59027626e-02f, 9.07472372e-02f, -7.34863579e-02f, 7.61881704e-03f, 5.75155020e-02f,
  5.03550749e-03f, 5.15167303e-02f, 6.47764504e-02f, -5.82899377e-02f, 4.53281850e-02f, -5.89073449e-03f, 5.28325327e-02f, 1.48303423e-03f, 7.85436761e-03f, 2.86186188e-02f,
  -2.67676059e-02f, 7.50041828e-02f, 6.06171899e-02f, 4.77566719e-02f, 3.21030580e-02f, 7.99126085e-03f, 7.11234510e-02f, 5.26325330e-02f, 9.27239880e-02f, -3.84626212e-03f,
  -1.93362180e-02f, 5.19734062e-02f, -5.39272837e-02f, 2.99863126e-02f, -2.71351598e-02f, -1.03932833e-02f, -3.05252839e-02f, -9.47934762e-03f, -3.55897751e-03f, -1.93010457e-02f,
  7.94407278e-02f, 1.35936658e-03f, 5.07788956e-02f, 5.06548695e-02f, 2.12135501e-02f, 2.16472335e-03f, 3.05858608e-02f, -7.62129156e-03f, 6.59215748e-02f, 1.80196147e-02f,
  -5.78472875e-02f, 2.29824390e-02f, -3.29541154e-02f, 1.49003752e-02f, -3.89619507e-02f, -3.10047697e-02f, 2.48839874e-02f, 5.09166298e-03f, -2.14850120e-02f, 4.12315838e-02f,
  6.36848435e-02f, 3.68519053e-02f, -6.68583810e-02f, 3.57336923e-02f, -7.93207362e-02f, -3.59714925e-02f, -2.25461870e-02f, 3.07282396e-02f, -2.66445298e-02f, -4.34408570e-03f,
  6.00813590e-02f, 6.25729887e-03f, 4.90914248e-02f, -1.37250591e-02f, 5.28140226e-03f, 5.16752191e-02f, 3.01013682e-02f, 6.36970475e-02f, 1.64068803e-01f, 2.82800570e-02f,
  1.19805345e-02f, 6.53457828e-03f, -6.62583858e-02f, 4.90181670e-02f, 1.66740660e-02f, 3.43458317e-02f, -4.69442224e-03f, 8.25493538e-04f, 3.39540467e-02f, 3.13163698e-02f,
  2.49023259e-01f, 3.51323700e-03f, 2.87296027e-01f, 2.82109678e-01f, -1.75873250e-01f, 1.16456904e-01f, 2.26821855e-01f, -8.30770656e-02f, 2.67304748e-01f, -1.87278882e-01f,
  -6.86269104e-02f, 1.78773567e-01f, 6.27764836e-02f, 4.10208246e-03f, 1.34176970e-01f, 2.46336237e-01f, 1.21267341e-01f, 3.17195021e-02f, 3.50631140e-02f, -5.22868708e-02f,
  1.23458050e-01f, -1.81592271e-01f, 5.99352531e-02f, -2.55876839e-01f, -1.31241187e-01f, 8.03297237e-02f, -1.25971690e-01f, -8.61201622e-03f, -2.52726406e-01f, -6.10992350e-02f,
  -7.22346976e-02f, 8.15111697e-02f, -6.09364025e-02f, 5.83779775e-02f, -1.06213130e-02f, -2.45041996e-02f, -3.32542993e-02f, 3.14424676e-03f, -4.86288853e-02f, -4.00682651e-02f,
  2.17261929e-02f, 1.69317089e-02f, -3.29757370e-02f, 7.05869570e-02f, 5.06523699e-02f, -4.76843165e-03f, -8.48612413e-02f, 7.47350138e-03f, 3.15200016e-02f, 5.31398766e-02f,
  7.81954899e-02f, 5.12555130e-02f, 3.79163586e-02f, -2.76494212e-02f, 4.44907397e-02f, 8.25563353e-03f, 2.83246990e-02f, -9.55029204e-03f, -3.92997302e-02f, 2.96265762e-02f,
  5.67886094e-03f, 2.28715409e-02f, 2.51960326e-02f, -6.54404983e-02f, 1.45608662e-02f, -2.41907742e-02f, -2.91522755e-03f, -7.88225085e-02f, -8.58351961e-03f, -5.47169056e-03f,
  -2.04522330e-02f, 2.45306082e-03f, 3.15144025e-02f, 1.36689413e-02f, -4.74635698e-02f, 5.76411374e-02f, 4.80698422e-02f, -6.18703030e-02f, 8.15239698e-02f, -5.47712371e-02f,
  -6.67736679e-03f, 2.95548216e-02f, -4.03657034e-02f, 4.23834147e-03f, -3.80437449e-02f, -9.23457672e-04f, 3.84801440e-02f, 2.14454979e-02f, -6.89989945e-04f, -1.21636149e-02f,
  -1.67115957e-01f, -4.48951945e-02f, -4.59004380e-02f, -8.02073553e-02f, -2.00792514e-02f, -2.42801588e-02f, 7.28597417e-02f, -3.74278314e-02f, -2.00559534e-02f, -5.44264540e-03f,
  -2.72949208e-02f, -6.37249872e-02f, 9.74139571e-03f, -7.08624199e-02f, 1.23569462e-03f, 2.98704561e-02f, 6.87992275e-02f, -3.56890485e-02f, -8.29793215e-02f, -4.45028991e-02f,
  -3.94216999e-02f, -2.06975415e-02f, 1.12384278e-02f, -3.05403322e-02f, -1.24661978e-02f, -2.41503082e-02f, 2.26870012e-02f, 1.06791835e-02f, -1.20597724e-02f, -6.07441133e-03f,
  -1.89419836e-01f, -2.96224087e-01f, -1.81484502e-02f, -3.08743894e-01f, 2.14802414e-01f, -2.12847576e-01f, -2.42408440e-01f, 2.89287101e-02f, -2.02291012e-01f, -2.83356756e-01f,
  -5.11805490e-02f, 5.22908978e-02f, 4.29224372e-02f, -3.42736691e-01f, 5.92007376e-02f, -8.39987546e-02f, -2.33488783e-01f, -2.06492126e-01f, -1.33938910e-02f, -8.74578580e-03f,
  -5.82797155e-02f, -7.78895244e-02f, -7.85114244e-02f, 7.75278732e-02f, -1.07437946e-01f, 3.62634771e-02f, 9.24928933e-02f, 1.46112233e-01f, -3.92833538e-02f, 1.88050851e-01f,
  -9.09335837e-02f, -1.13789879e-01f, -3.81338671e-02f, 2.84470487e-02f, -1.04592286e-01f, 1.91116501e-02f, -5.88777624e-02f, 7.63271675e-02f, 6.89617693e-02f, -1.31630683e-02f,
  -1.34214209e-02f, 4.78032269e-02f, -2.04295367e-02f, 2.88836099e-02f, -2.13405974e-02f, 6.01188280e-03f, -1.75474193e-02f, -4.60188612e-02f, 5.17047644e-02f, 3.16101196e-03f,
  -6.24875538e-03f, 2.53432039e-02f, 3.44666429e-02f, 3.10960747e-02f, 2.88571864e-02f, 2.18558833e-02f, 3.67613919e-02f, 4.26369719e-02f, -3.72640267e-02f, -4.31075394e-02f,
  -9.98987779e-02f, -1.45854848e-02f, -3.55308782e-03f, 1.02505842e-02f, -2.79338285e-02f, 8.22693855e-03f, -2.82765720e-02f, 5.83091080e-02f, -2.25481950e-02f, -4.41345423e-02f,
  3.52503918e-02f, -2.01941421e-03f, 2.57165842e-02f, -6.62674475e-03f, -1.51118794e-02f, -5.95651148e-03f, 5.28502017e-02f, 3.84426042e-02f, -2.06290372e-02f, 5.74988276e-02f,
  3.75692919e-02f, 2.01723203e-02f, -4.09074277e-02f, 4.80263978e-02f, -6.69839159e-02f, 3.64190936e-02f, -2.82964464e-02f, -2.22673863e-02f, -7.45372439e-04f, 3.09663396e-02f,
  -2.98247393e-02f, -5.46738468e-02f, -4.46890760e-03f, 2.39981413e-02f, -3.57049145e-02f, 2.01702993e-02f, 2.14489680e-02f, -9.06521529e-02f, 9.26633272e-03f, -6.78711608e-02f,
  1.24161523e-02f, 1.01662530e-02f, -2.31847875e-02f, -3.66388038e-02f, 4.98579405e-02f, -2.68692560e-02f, 1.47331133e-02f, 6.07374161e-02f, 9.51309036e-03f, -3.37754339e-02f,
  1.34321279e-04f, -6.42462671e-02f, -2.62751337e-03f, -2.32069548e-02f, 3.94725427e-02f, -2.56784763e-02f, 3.87360230e-02f, -6.60756454e-02f, 2.82347854e-02f, -5.23171062e-03f,
  2.93192029e-01f, -4.83858809e-02f, -1.20125808e-01f, 2.04076380e-01f, 1.18713737e-01f, -1.29033551e-02f, 1.20092578e-01f, -5.65760992e-02f, 1.97693277e-02f, 7.55569339e-02f,
  3.09712309e-02f, 5.25355525e-02f, -1.27761755e-02f, 1.69188008e-01f, 1.53706446e-01f, -2.01836973e-01f, 2.67133802e-01f, 1.01149894e-01f, -5.10510132e-02f, 1.39658436e-01f,
  6.70056511e-03f, 5.54605573e-02f, -1.44207170e-02f, -1.61945075e-01f, 8.94950926e-02f, -1.84344754e-01f, 2.13193074e-02f, -6.84882402e-02f, 9.76655912e-03f, -1.79519821e-02f,
  5.58210537e-02f, -3.06257252e-02f, -6.57389238e-02f, -5.49576469e-02f, 7.88114816e-02f, 4.51535769e-02f, 1.91842169e-02f, -3.31849122e-04f, -6.51157424e-02f, -5.03209345e-02f,
  4.94118743e-02f, 6.44483045e-02f, 2.13678181e-02f, -3.06367408e-02f, 5.44983223e-02f, -1.74174812e-02f, -2.41857041e-02f, 4.34680469e-02f, -3.07269972e-02f, 3.09434184e-03f,
  1.24032120e-03f, -1.53039279e-03f, 7.01302886e-02f, 2.94650216e-02f, -1.74972899e-02f, 4.21582460e-02f, -3.40185524e-03f, -1.61195416e-02f, -6.38548401e-04f, 1.20678479e-02f,
  3.40856537e-02f, 5.04805706e-02f, 1.48151862e-03f, 8.62727407e-03f, 2.96649267e-03f, -5.59793264e-02f, 8.49507451e-02f, -4.72733658e-03f, -1.76618174e-02f, 5.40768094e-02f,
  7.08972663e-02f, -4.30029854e-02f, 4.50958721e-02f, 1.40755419e-02f, -4.15631086e-02f, 9.17430818e-02f, 4.71685231e-02f, -5.94805880e-03f, 4.30205092e-02f, -5.21806218e-02f,
  7.07311630e-02f, 4.16176300e-03f, 2.48662215e-02f, 1.07344855e-02f, 2.59326603e-02f, -3.17079984e-02f, 8.53612274e-03f, -4.09019515e-02f, 4.83113825e-02f, 6.24842010e-02f,
  -1.00809038e-02f, 3.74923646e-02f, 1.74760390e-02f, -8.82752147e-03f, -1.28824944e-02f, -2.81128120e-02f, 3.63856144e-02f, 1.83131546e-02f, 7.31546804e-03f, -6.83232471e-02f,
  4.06583436e-02f, -6.14149822e-03f, -1.78985428e-02f, -2.27276664e-02f, -2.13908684e-02f, -2.60986220e-02f, 7.62533024e-02f, 8.10159929e-03f, 1.15109704e-01f, 9.09803137e-02f,
  6.30338043e-02f, 3.68685797e-02f, 4.89208959e-02f, 8.82497802e-03f, 3.52079831e-02f, 1.74553990e-02f, -7.15520745e-03f, -5.77058755e-02f, -4.44135740e-02f, 3.09455562e-02f,
  -4.77983570e-03f, -1.01447798e-01f, -2.02929322e-02f, -3.12546939e-01f, 5.85768186e-02f, 8.62532556e-02f, 1.17137745e-01f, -2.03865513e-01f, -1.31284118e-01f, 1.23604545e-02f,
  -1.14518702e-01f, -1.91032607e-02f, 2.84851164e-01f, -2.27254048e-01f, 2.21034333e-01f, 1.26885101e-01f, -3.20821375e-01f, -1.05520077e-01f, -4.45039906e-02f, -1.34535238e-01f,
  -7.31512755e-02f, -1.80916607e-01f, -2.60425266e-02f, -1.09347992e-01f, -1.55542672e-01f, -9.80338082e-02f, -1.92824937e-02f, 1.08025648e-01f, -2.40070418e-01f, 1.13581531e-01f,
  -6.58826088e-04f, 2.69178636e-02f, -2.44950838e-02f, 3.53673324e-02f, -3.19320820e-02f, 7.67376050e-02f, 7.13773593e-02f, 5.16709685e-02f, 6.79009557e-02f, -8.15584585e-02f,
  1.19053721e-01f, 1.16433408e-02f, -2.36080308e-02f, -5.71177416e-02f, -6.95405602e-02f, -2.44767638e-04f, 7.99218118e-02f, 2.44493708e-02f, -3.00753526e-02f, -2.36836057e-02f,
  1.43930335e-02f, -6.35446385e-02f, -5.60379662e-02f, 6.77330345e-02f, 9.76859629e-02f, 3.39798018e-04f, -9.90621187e-03f, -7.62916403e-03f, -4.03161868e-02f, -1.00157477e-01f,
  2.90784352e-02f, -2.30273008e-02f, -4.08622846e-02f, -1.00174872e-03f, -6.26057461e-02f, -4.42433991e-02f, 2.06601042e-02f, 5.43924235e-03f, -5.73640503e-03f, -1.70102865e-02f,
  -7.12205544e-02f, -8.52333903e-02f, 1.14636477e-02f, -2.52915062e-02f, -4.06276807e-02f, -9.68145654e-02f, 9.82308760e-02f, -5.04216030e-02f, -3.06557142e-03f, -4.73498777e-02f,
  2.58908048e-02f, 6.22080313e-03f, -4.95954789e-02f, 1.01485394e-01f, 2.60939561e-02f, 1.10828809e-01f, -6.48829564e-02f, 1.39694717e-02f, 7.89477304e-02f, 4.16151918e-02f,
  1.60021801e-02f, -4.30049784e-02f, 1.60284415e-02f, 2.49421224e-02f, 9.55232531e-02f, -4.86481376e-02f, -1.95741076e-02f, -2.02771253e-03f, 7.69352391e-02f, -7.40495846e-02f,
  8.92545730e-02f, 2.67899944e-03f, -4.30038907e-02f, -5.94493821e-02f, 7.52428994e-02f, 2.10615005e-02f, 8.61456059e-03f, 7.36727379e-03f, -4.75602895e-02f, -8.82408023e-02f,
  -1.02212820e-02f, 4.46700789e-02f, 1.10302873e-01f, -1.44881876e-02f, 5.73790120e-03f, 2.92446651e-02f, -1.90196298e-02f, 1.72627915e-03f, 8.32882449e-02f, -4.79440059e-04f,
  1.33134112e-01f, -1.68449402e-01f, -3.24755460e-01f, 3.47157270e-02f, 8.16204995e-02f, 1.50231406e-01f, 7.19736936e-03f, -8.31994191e-02f, -1.50087342e-01f, 8.01327173e-03f,
  2.48635560e-01f, -9.33078080e-02f, -1.89596325e-01f, 2.36243844e-01f, 1.84483051e-01f, -3.08937281e-01f, 1.73425645e-01f, 9.52593908e-02f, -1.75187618e-01f, 1.12675512e-02f,
  -1.00216635e-01f, 2.51235753e-01f, -3.14626545e-02f, 8.21091980e-02f, 9.42627862e-02f, -6.43750876e-02f, 2.58502394e-01f, -1.15634002e-01f, 1.25818074e-01f, 1.74118262e-02f,
  2.59654485e-02f, -2.33207606e-02f, 4.56986129e-02f, -3.96431014e-02f, -2.34580450e-02f, 7.40291700e-02f, -9.87084489e-03f, -1.93413571e-02f, 2.23424584e-02f, -7.79517442e-02f,
  -7.00590238e-02f, -3.29040969e-03f, -2.58779507e-02f, -1.96771864e-02f, 1.75276976e-02f, -2.09424272e-03f, -1.33319274e-02f, -2.96618622e-02f, 5.02113311e-04f, -3.94459479e-02f,
  -5.77134565e-02f, -3.43045592e-02f, 7.69219175e-02f, 4.70347516e-02f, -1.05360851e-01f, -3.54805812e-02f, -3.11592259e-02f, -6.10105053e-04f, 7.72951869e-03f, -2.43766457e-02f,
  -1.03188856e-02f, -9.59013179e-02f, 1.71779487e-02f, -1.74279623e-02f, 3.20459041e-03f, 3.71509045e-02f, 4.54525836e-02f, 6.08917996e-02f, -2.60555092e-02f, 7.29505718e-02f,
  -2.31654961e-02f, 2.44977102e-02f, -7.29497299e-02f, 4.11293134e-02f, 4.50869501e-02f, 9.94295254e-03f, -3.70003916e-02f, -1.81634463e-02f, -1.50690172e-02f, 1.76390596e-02f,
  -3.53305079e-02f, 2.36642398e-02f, 3.55104282e-02f, 4.15683612e-02f, -2.59277411e-04f, 1.19882245e-02f, -3.00501124e-03f, 3.45310681e-02f, -9.18993652e-02f, 5.39410263e-02f,
  8.25582165e-03f, -9.51897055e-02f, -1.40641630e-01f, -2.83711944e-02f, -4.63475324e-02f, 2.31221560e-02f, -1.89855658e-02f, -5.11517189e-02f, 3.22001404e-03f, 1.37702450e-02f,
  -3.70259839e-03f, 8.81731361e-02f, 1.56692080e-02f, 7.84821734e-02f, 6.95920363e-02f, 5.58917038e-02f, -7.33177662e-02f, -1.57286953e-02f, 9.72356796e-02f, 7.42787495e-02f,
  8.52511439e-04f, -4.91042994e-03f, -5.48540568e-03f, 1.28665157e-02f, 7.46423975e-02f, 2.55335029e-02f, 4.72619664e-03f, -6.24454767e-02f, 1.82753652e-02f, -4.21829857e-02f,
  -3.06830019e-01f, -1.27550036e-01f, 1.21068135e-02f, -1.32985562e-01f, -1.58347383e-01f, -4.51966822e-01f, -3.36593717e-01f, -2.47036919e-01f, -3.12419683e-01f, 2.24838611e-02f,
  -1.38272762e-01f, 1.38155520e-01f, -3.86694074e-02f, -2.06002414e-01f, -2.18967929e-01f, -1.30710512e-01f, -1.62922114e-01f, -2.87131257e-02f, -1.20241813e-01f, -5.39440699e-02f,
  -9.03302133e-02f, -3.07636231e-01f, 6.22759154e-03f, -8.39387327e-02f, -1.33992180e-01f, 1.46442518e-01f, 2.26307228e-01f, 6.00943677e-02f, 8.32527205e-02f, 6.66458765e-03f,
  -7.94782788e-02f, -8.19531679e-02f, -2.96579418e-03f, -4.42839302e-02f, -2.03742292e-02f, 6.93502128e-02f, 1.24868385e-01f, 9.08695981e-02f, -4.25322838e-02f, -2.56186556e-02f,
  1.01058120e-02f, -6.56442046e-02f, -8.01466256e-02f, -5.82675338e-02f, -4.61371690e-02f, -3.49912979e-02f, -2.93088378e-03f, 4.38967980e-02f, -1.85156018e-02f, -7.83429518e-02f,
  -2.30793152e-02f, 2.16632858e-02f, 2.49005817e-02f, 3.53763737e-02f, 1.57844704e-02f, -5.51797487e-02f, 1.90709159e-02f, 7.84374774e-02f, -6.54196599e-03f, -6.29255772e-02f,
  -2.13663634e-02f, -9.52897221e-03f, -8.62398371e-03f, 3.55466940e-02f, -1.10056706e-01f, 5.51451035e-02f, 2.08695289e-02f, 8.70044306e-02f, 2.68381983e-02f, -1.03141479e-02f,
  -1.65047608e-02f, -1.25721786e-02f, -4.57504652e-02f, -7.18149021e-02f, 3.38611342e-02f, -1.62089791e-03f, 5.35376146e-02f, 1.83744659e-03f, 8.10767338e-03f, 2.47595813e-02f,
  -1.72954635e-03f, -3.52950208e-02f, 1.51986275e-02f, 8.76011848e-02f, -1.04940115e-02f, -1.28913997e-02f, 4.59135650e-03f, -3.83500829e-02f, 3.32810730e-02f, -1.04845054e-02f,
  -5.84440641e-02f, -7.30418786e-02f, -8.85508955e-02f, 5.72964959e-02f, 8.87975246e-02f, 1.35053797e-02f, -8.62851646e-03f, -3.83110568e-02f, 3.01678590e-02f, -5.66798523e-02f,
  5.19839711e-02f, 2.12634765e-02f, 7.68974051e-02f, 5.50182052e-02f, 3.29655595e-02f, -2.84854379e-02f, 3.31689604e-02f, 3.88177633e-02f, 6.43735826e-02f, 3.05734016e-02f,
  2.35263761e-02f, -2.17651129e-02f, 1.08345496e-02f, -2.77851410e-02f, 5.03225587e-02f, 1.84853617e-02f, 3.01253353e-03f, -1.57564431e-02f, 8.63316283e-02f, -7.39555899e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.62609690e-01f, -2.57819425e-02f, 1.73994094e-01f, 4.10086393e-01f, -3.13850790e-02f, -2.60876626e-01f, -2.35137209e-01f, 1.65651947e-01f, 6.48276731e-02f, -1.50061846e-01f,
  2.87576262e-02f, 3.88922915e-02f, -1.44788355e-01f, 2.27285877e-01f, 3.11751693e-01f, -1.20944791e-01f, 2.49345750e-01f, -1.38580352e-02f, -3.35391089e-02f, 2.47910053e-01f,
  2.17942789e-01f, 2.71086991e-01f, 2.32286543e-01f, 2.09362939e-01f, 8.10029730e-02f, 1.61615774e-01f, 1.92465484e-01f, -1.07912034e-01f, 9.18052718e-02f, -1.17342278e-01f,
  -4.78279777e-02f, 1.86425164e-01f, 2.23849639e-02f, -1.04736976e-01f, 1.43653557e-01f, -5.19449003e-02f, 5.42589789e-03f, -1.25417829e-01f, 5.56160957e-02f, -4.16817889e-03f,
  -7.05684274e-02f, 4.46737483e-02f, 5.99320279e-03f, -1.93550196e-02f, -8.11044797e-02f, -5.30416258e-02f, -3.65573843e-03f, 4.68950793e-02f, -2.62325928e-02f, 5.27176373e-02f,
  8.77649039e-02f, -2.92099509e-02f, 1.69841424e-02f, -8.22217837e-02f, 1.79082617e-01f, 7.59298950e-02f, 1.01394668e-04f, 6.73743039e-02f, -5.87343536e-02f, 3.06671411e-02f,
  1.30187586e-01f, -3.72197363e-03f, -3.97693180e-02f, -1.66239832e-02f, -1.19510777e-02f, -7.25867897e-02f, -1.54008041e-03f, -5.90574853e-02f, 2.44884659e-02f, 2.71191783e-02f,
  -4.69093248e-02f, 1.27381131e-01f, 2.10584048e-03f, -2.61986032e-02f, 2.47384701e-03f, 1.36350812e-02f, -2.07257573e-03f, -5.64857051e-02f, 1.08462097e-02f, 6.56571388e-02f,
  -4.63650450e-02f, -3.89296338e-02f, -2.05366723e-02f, -9.94024500e-02f, -1.44776329e-01f, 6.01514280e-02f, -1.57818738e-02f, -2.50525586e-03f, 6.34251609e-02f, -6.49402961e-02f,
  8.13171417e-02f, 1.51235729e-01f, 5.47096580e-02f, 6.21954026e-03f, -6.33545369e-02f, -2.79445443e-02f, -1.04314469e-01f, 6.01233505e-02f, -2.14983970e-02f, -7.08261728e-02f,
  1.15297548e-01f, -9.98264402e-02f, -6.54016733e-02f, -1.36564346e-02f, 2.27189977e-02f, 3.92334349e-02f, -6.60430565e-02f, 3.77700366e-02f, 1.35469763e-02f, 1.46921962e-01f,
  1.41866714e-01f, -1.13410883e-01f, -1.56328138e-02f, -3.25974897e-02f, 5.34977093e-02f, -1.40297532e-01f, 2.31216918e-03f, 9.28713903e-02f, 5.69172911e-02f, 3.38653801e-03f,
  6.00382462e-02f, 4.95042026e-01f, 3.17263693e-01f, -1.10668510e-01f, -1.96631268e-01f, 2.54437532e-02f, -1.35161683e-01f, -6.58031031e-02f, -5.78074134e-04f, 2.60859691e-02f,
  -2.64543682e-01f, 3.56950104e-01f, 4.30406556e-02f, 5.28512709e-03f, -1.66941062e-01f, -1.62218586e-01f, -2.47603014e-01f, -1.66920558e-01f, -7.45370286e-03f, -2.39038289e-01f,
  -1.13805488e-01f, -4.55393106e-01f, -4.23132181e-02f, -2.29408816e-01f, -2.13845521e-02f, 1.14414565e-01f, -4.52310711e-01f, -2.54200269e-02f, -1.87596679e-02f, -1.45987608e-02f,
  1.77370608e-01f, 6.42382056e-02f, 2.29646146e-01f, 8.50324556e-02f, 3.98313478e-02f, 5.31496406e-02f, 5.84883615e-03f, -7.33290240e-02f, 2.64367592e-02f, 3.87581438e-02f,
  -5.87241426e-02f, -1.60027631e-02f, 4.19886410e-03f, 9.50838625e-03f, -2.88299955e-02f, 1.43299520e-01f, 1.13459630e-02f, 4.13523018e-02f, 1.54010206e-01f, 8.26301277e-02f,
  1.29610956e-01f, 1.64416924e-01f, -6.38118759e-02f, -9.75225586e-03f, -1.49110630e-02f, -7.72402855e-03f, 4.60278913e-02f, 8.80808011e-02f, 1.25625506e-01f, 2.26380639e-02f,
  -1.38244778e-01f, -1.03517026e-01f, 7.26207218e-04f, 1.30771827e-02f, -2.91564930e-02f, -2.16949079e-03f, 1.06906980e-01f, -1.37398606e-02f, -1.33565832e-02f, -8.08908865e-02f,
  -4.96690255e-03f, 1.43804729e-01f, -7.25355670e-02f, 9.23676044e-02f, -1.37708664e-01f, 1.34966783e-02f, -9.97057185e-02f, 5.16624078e-02f, -5.13535691e-03f, 1.21277660e-01f,
  -3.82687747e-02f, -1.48806050e-01f, 1.28380865e-01f, -5.89317689e-03f, 4.24595624e-02f, 1.98138058e-02f, 1.08992152e-01f, 1.43531486e-01f, -2.35836636e-02f, -1.22233301e-01f,
  6.50367960e-02f, -3.00349414e-01f, -1.13488231e-02f, 8.62137824e-02f, -2.51194555e-02f, -2.37347167e-02f, -1.07070334e-01f, 9.77693647e-02f, -1.13853462e-01f, -1.32836699e-01f,
  -1.35372326e-01f, -2.05615032e-02f, -5.34055345e-02f, -7.38591887e-03f, -1.96450129e-02f, 4.44636587e-03f, -1.55292585e-01f, -3.11564356e-02f, -5.95239364e-02f, 8.41942802e-02f,
  9.53879356e-02f, -1.23250440e-01f, -8.07389989e-03f, -3.28133330e-02f, -6.52032793e-02f, -8.29745159e-02f, 3.45505588e-02f, 1.17089242e-01f, -9.04109776e-02f, 6.74857106e-03f,
  2.95706898e-01f, -2.28395090e-02f, 9.41077396e-02f, 2.06380650e-01f, -1.20259181e-01f, -4.82417613e-01f, -3.91535848e-01f, -6.41213059e-02f, -1.50325418e-01f, -1.59471139e-01f,
  -1.17519468e-01f, 1.03386700e-01f, -1.42846689e-01f, 2.52847224e-01f, 2.40279764e-01f, -1.56919003e-01f, 1.47872329e-01f, 7.81484600e-03f, 3.13326418e-02f, 2.10947618e-01f,
  2.21567586e-01f, 8.34519118e-02f, 3.18910152e-01f, 2.44700938e-01f, 3.11311558e-02f, 3.16329688e-01f, 3.45860422e-01f, -2.40227655e-02f, 2.92143822e-01f, 2.96170525e-02f,
  3.93567272e-02f, 4.42806557e-02f, 8.14044625e-02f, 3.37498337e-02f, 9.70787778e-02f, -3.49197723e-02f, 8.72633308e-02f, 1.29706599e-02f, -7.76646957e-02f, -1.27642723e-02f,
  8.55526328e-02f, 1.12260625e-01f, -3.29554379e-02f, 2.00507920e-02f, -3.65611631e-03f, 2.80205533e-02f, 1.15288775e-02f, -8.09390768e-02f, -7.30923638e-02f, 5.45445345e-02f,
  -6.75722361e-02f, -8.25822446e-03f, 6.52202144e-02f, 4.68851328e-02f, 1.54844327e-02f, 2.33222395e-02f, -7.19297770e-03f, 4.11095060e-02f, 2.40542740e-02f, 4.45058867e-02f,
  1.01270325e-01f, -4.87623289e-02f, -7.58947656e-02f, -2.12132521e-02f, -4.03472036e-02f, 5.15140267e-03f, -2.18167230e-02f, -3.14343870e-02f, 6.37535751e-02f, -6.86916858e-02f,
  7.29218051e-02f, -2.18431354e-02f, -2.36540250e-02f, -8.00431371e-02f, 8.96085724e-02f, -2.60919183e-02f, -2.13572942e-03f, -2.88365092e-02f, -3.33914720e-02f, 2.38655806e-02f,
  1.85611285e-02f, -4.74956930e-02f, -9.38103795e-02f, 2.58957148e-02f, 7.97081273e-03f, 6.65731207e-02f, 2.67144851e-02f, 2.82907728e-02f, -2.76527389e-05f, -3.00814454e-02f,
  -4.75722970e-03f, 1.80539474e-01f, -3.49754989e-02f, -5.10425493e-02f, 1.68242753e-02f, 7.86083862e-02f, 1.14542976e-01f, 1.27948835e-01f, 2.15172097e-02f, -2.35651433e-02f,
  2.01521754e-01f, 5.94615471e-03f, -8.40079635e-02f, -2.07009744e-02f, -1.22411307e-02f, 7.42499828e-02f, 5.47214299e-02f, 3.21434326e-02f, 1.34109810e-01f, 5.13971709e-02f,
  2.04197448e-02f, -1.32505745e-01f, 1.35921791e-01f, -1.32081911e-01f, 3.65672517e-04f, -4.26847897e-02f, -2.36829426e-02f, 6.39814362e-02f, 3.44941509e-03f, 3.72319221e-02f,
  2.83934653e-01f, -9.14107189e-02f, -4.96350490e-02f, 2.87904114e-01f, 1.82492793e-01f, -8.42251033e-02f, -9.24489871e-02f, -8.73668864e-03f, 5.16139746e-01f, -2.04903901e-01f,
  -2.03812018e-01f, -7.16204643e-02f, -2.22830027e-01f, -2.15374321e-01f, -1.93238288e-01f, -9.52276215e-02f, 9.97891426e-02f, -5.41372895e-02f, 1.33833021e-01f, -1.24172509e-01f,
  2.02597395e-01f, -3.39150816e-01f, -2.99075365e-01f, -2.64425159e-01f, -2.11482763e-01f, 1.10634305e-01f, -9.95000154e-02f, -1.52663544e-01f, -1.31621584e-01f, -9.25656632e-02f,
  -9.88421589e-03f, -4.47478816e-02f, 1.16066307e-01f, 3.19161043e-02f, 4.45469841e-02f, -7.17018312e-03f, 2.85532456e-02f, -1.76485404e-01f, 1.07426114e-01f, -5.56931943e-02f,
  -3.84451002e-02f, 2.33534370e-02f, -2.48937532e-02f, -1.45140275e-01f, 6.64460808e-02f, -1.45980984e-01f, 1.64781004e-01f, 2.42183283e-01f, -4.78524342e-02f, -1.30949572e-01f,
  -6.35504499e-02f, 3.34631503e-02f, 1.94990501e-01f, 2.08970994e-01f, 1.67573646e-01f, 1.17665723e-01f, -6.45679906e-02f, -8.43775719e-02f, 1.14458442e-01f, 8.19893554e-02f,
  -8.32605362e-02f, 4.02181484e-02f, -1.04846887e-01f, -3.09315138e-02f, -4.92987260e-02f, 1.71624571e-01f, -1.94630586e-02f, 7.91772604e-02f, 1.93536535e-01f, -4.25810367e-02f,
  -9.56475958e-02f, 2.55762357e-02f, 1.26739740e-01f, 6.25835881e-02f, 3.83633412e-02f, 6.31302968e-02f, 9.95537266e-02f, 7.75213987e-02f, 2.02530578e-01f, -3.92188989e-02f,
  -1.59874663e-01f, 1.30239278e-01f, -2.02884182e-01f, 5.83347827e-02f, -9.92181748e-02f, 1.34652182e-02f, -5.82640916e-02f, 3.14235874e-02f, 1.63840204e-02f, -1.51080191e-01f,
  5.26904054e-02f, 2.20049955e-02f, -4.15339060e-02f, -5.96544854e-02f, 3.03326771e-02f, -9.03692469e-02f, 1.17002316e-01f, -9.34457686e-03f, 5.62371314e-02f, -9.37094986e-02f,
  1.33319154e-01f, -1.25965118e-01f, 1.41908079e-01f, -7.27421269e-02f, 5.63576631e-03f, -1.21310994e-01f, 2.60238759e-02f, 1.88899145e-01f, 7.75736794e-02f, 9.56638083e-02f,
  -4.59576882e-02f, 2.90327277e-02f, -5.69732785e-02f, 7.41489828e-02f, 9.43141952e-02f, 2.03374811e-02f, -2.12240480e-02f, -2.18869299e-02f, -5.80129363e-02f, 7.93384537e-02f,
  -6.46218002e-01f, 2.44728595e-01f, -3.23700786e-01f, -2.58460671e-01f, 5.14869168e-02f, -2.97564507e-01f, -2.24946350e-01f, -1.21910423e-01f, -5.82626415e-03f, 1.25860915e-01f,
  -7.61738271e-02f, 1.78411156e-02f, 2.25500986e-01f, 1.04909688e-01f, -2.06218123e-01f, 2.33291954e-01f, -2.56537527e-01f, -1.81226924e-01f, 9.10228267e-02f, -1.55586898e-01f,
  -1.23656362e-01f, 1.10578939e-01f, -1.27921656e-01f, 1.13327809e-01f, -2.16711432e-01f, -1.08964965e-01f, -1.54112399e-01f, -2.00884007e-02f, -1.60206527e-01f, 8.93977880e-02f,
  -4.48120266e-01f, -3.06055129e-01f, -2.07640201e-01f, -1.77242026e-01f, -2.15095058e-01f, -9.06025842e-02f, -1.57799810e-01f, 6.26582950e-02f, -5.29522337e-02f, -2.97544897e-02f,
  4.76864986e-02f, 4.58068177e-02f, 2.37827040e-02f, 2.74151880e-02f, -5.13441525e-02f, -8.57922900e-03f, 4.83720489e-02f, -1.23540901e-01f, -3.32632177e-02f, 3.08083612e-02f,
  1.81351863e-02f, 9.71001573e-03f, -1.88066334e-01f, -4.17483486e-02f, 4.45043435e-03f, -4.44744527e-02f, -1.83657408e-02f, -5.80681041e-02f, -3.31597887e-02f, -1.95539057e-01f,
  1.57317519e-01f, 1.12472422e-01f, -1.20880343e-02f, 4.32185307e-02f, 6.95373416e-02f, -3.87001149e-02f, -2.35212594e-02f, 1.30606983e-02f, 6.63344935e-02f, 1.05933644e-01f,
  -2.41832938e-02f, -6.10535443e-02f, -1.53871514e-02f, -6.02586567e-02f, 1.60912406e-02f, -4.31958772e-02f, 4.52188104e-02f, -1.32403046e-01f, 4.46394011e-02f, -3.73363458e-02f,
  -1.09197162e-01f, 7.06008915e-03f, 5.24595194e-03f, 4.84865159e-03f, -5.08965179e-02f, -3.76111604e-02f, -9.24799312e-03f, -8.01722333e-02f, -3.27651016e-02f, -7.61897117e-02f,
  -6.06114089e-01f, -5.65448940e-01f, -9.19010341e-02f, -8.14646184e-02f, -3.38523909e-02f, -1.42544746e-01f, 3.02185621e-02f, -8.08339119e-02f, -1.80393144e-01f, -1.19956933e-01f,
  -2.09184159e-02f, -4.85193729e-02f, -8.88566524e-02f, 4.76457216e-02f, 5.71720898e-02f, 2.76591405e-02f, -2.27156393e-02f, 1.54615454e-02f, -2.03415215e-01f, -5.09446263e-02f,
  -1.19935609e-01f, 3.96839865e-02f, -1.38053391e-02f, -1.35827484e-02f, -7.43492544e-02f, -3.64740752e-02f, -9.26650241e-02f, -7.21543375e-03f, -1.41466960e-01f, 5.38676530e-02f,
  1.71583250e-01f, 3.90755504e-01f, 2.63571888e-01f, 1.82343215e-01f, 1.04509585e-03f, -2.02451378e-01f, -8.10306966e-02f, 2.00929880e-01f, 1.94236562e-01f, 1.85150698e-01f,
  -6.33370951e-02f, 2.76767880e-01f, -2.27613170e-02f, 8.28020647e-02f, -5.06860197e-01f, -2.85679042e-01f, -1.22937053e-01f, 1.01752833e-01f, -3.46081257e-02f, 5.86388856e-02f,
  -1.68153495e-01f, -2.44313896e-01f, -1.62238210e-01f, -7.03390762e-02f, 2.48727262e-01f, 2.55738735e-01f, -3.08850735e-01f, 6.68485463e-02f, 5.39246127e-02f, -7.89932311e-02f,
  -2.09859237e-01f, 1.56061247e-01f, 2.15989172e-01f, 6.15712181e-02f, -3.28769274e-02f, 8.17922056e-02f, 9.17885173e-03f, 3.80671918e-02f, -9.80371386e-02f, 6.29761815e-02f,
  1.44924894e-01f, -1.55898370e-02f, -5.83767220e-02f, 8.76569375e-02f, 1.15411654e-01f, 6.49171770e-02f, 1.67588502e-01f, 2.75115930e-02f, 1.17397308e-01f, 1.13703385e-01f,
  1.48008227e-01f, 2.13931780e-02f, -8.45915696e-04f, 6.10627830e-02f, -6.08238578e-02f, 2.49867719e-02f, -5.59548140e-02f, -1.28836986e-02f, 3.56907658e-02f, 1.04478365e-02f,
  7.07162395e-02f, -8.28392431e-02f, -2.35977285e-02f, 5.55273853e-02f, 9.72232744e-02f, 5.58071285e-02f, -3.76618952e-02f, -8.84920582e-02f, -9.08971280e-02f, 4.26207781e-02f,
  -5.70944101e-02f, 3.94807197e-02f, -8.08872506e-02f, 5.50153852e-03f, 6.10553136e-04f, 3.76771428e-02f, 1.49346497e-02f, 6.17338382e-02f, -5.04754446e-02f, 3.04485057e-02f,
  -9.92693566e-03f, -8.22799578e-02f, 8.38189721e-02f, -7.73000345e-02f, -1.03494957e-01f, -7.97846168e-03f, -3.31941847e-05f, 1.82369530e-01f, -4.11619944e-03f, -1.44611046e-01f,
  -5.40213823e-01f, -3.68877351e-01f, -9.79137793e-02f, 2.02114321e-02f, -2.64685526e-02f, 1.12516191e-02f, 1.23234501e-03f, 7.46942032e-03f, -5.99554442e-02f, 1.02227628e-01f,
  -5.94973424e-03f, 2.58984324e-02f, -1.83641940e-01f, -4.29130271e-02f, -1.46928206e-01f, -1.80511802e-01f, -1.23105951e-01f, -6.86784312e-02f, -1.91243991e-01f, -9.14120488e-03f,
  8.59470442e-02f, -5.05318418e-02f, -4.08403091e-02f, -4.38290238e-02f, -4.68366686e-03f, -4.13379669e-02f, 2.18181731e-03f, 3.15759368e-02f, 5.51113002e-02f, -1.67881563e-01f,
  -7.19332516e-01f, 1.86383009e-01f, 1.68043494e-01f, -2.60218322e-01f, -5.52472994e-02f, 4.93955970e-01f, 2.44983986e-01f, 9.71693173e-02f, -2.52564460e-01f, 1.44210368e-01f,
  1.27558857e-01f, -2.84031361e-01f, 1.73943609e-01f, 2.20681176e-01f, 2.14141577e-01f, 1.20564207e-01f, 2.20732570e-01f, 5.94513379e-02f, -9.83889177e-02f, -9.11366343e-02f,
  -1.23539314e-01f, 4.24382091e-02f, 1.68568000e-01f, 2.48745503e-03f, -1.01501577e-01f, -2.59644151e-01f, -1.45814806e-01f, 7.80582428e-02f, 1.01197004e-01f, 1.23755351e-01f,
  -6.15517646e-02f, -3.85917097e-01f, -1.50816292e-02f, -7.52236918e-02f, -9.45330784e-03f, 1.08066283e-03f, -4.67079021e-02f, -4.50053401e-02f, -1.02117896e-01f, -2.24551875e-02f,
  -4.87654731e-02f, 3.65151726e-02f, 1.50327431e-02f, -4.36686687e-02f, -1.26179934e-01f, 1.26740960e-02f, 7.61691332e-02f, 1.09686792e-01f, 5.71350120e-02f, 1.44868031e-01f,
  1.70630902e-01f, 7.16855973e-02f, 3.38477269e-02f, 8.66279155e-02f, 8.04105476e-02f, 6.98481128e-02f, -6.89906329e-02f, 7.29672685e-02f, -2.99525056e-02f, 4.09040302e-02f,
  -9.71687734e-02f, -3.41501124e-02f, -5.61409146e-02f, 5.30092381e-02f, -5.94881997e-02f, 6.41357154e-02f, 2.37336140e-02f, -3.72973606e-02f, -5.79883754e-02f, 6.12387024e-02f,
  -1.19878516e-01f, 8.70654266e-03f, -1.53267300e-02f, 4.85797897e-02f, -2.14455482e-02f, -2.04288866e-02f, -5.86731173e-02f, 2.11142544e-02f, -3.59622054e-02f, 9.68681499e-02f,
  1.92136858e-02f, -2.66070329e-02f, 1.10887084e-03f, 1.50663760e-02f, 6.59228861e-02f, 4.84239869e-02f, -3.36540639e-02f, 4.08154279e-02f, -5.51985689e-02f, 3.81707475e-02f,
  -2.28921711e-01f, -4.38345432e-01f, -1.46557353e-02f, -2.75167786e-02f, -2.67937630e-02f, 8.12212229e-02f, -8.82079080e-02f, 4.23587821e-02f, -8.89410153e-02f, -6.06810972e-02f,
  -1.19834729e-01f, -1.02052286e-01f, -1.19758926e-01f, -5.75056262e-02f, 1.61876380e-02f, 1.02895133e-01f, -5.42147011e-02f, -7.78352916e-02f, 1.33741777e-02f, -6.94451034e-02f,
  -5.00233471e-03f, -7.05638453e-02f, 6.51152208e-02f, -4.17739898e-02f, -1.20512359e-01f, 8.52042157e-03f, -1.15821794e-01f, -8.92413780e-02f, 4.71727885e-02f, 4.93956059e-02f,
  -3.60700607e-01f, 2.13146552e-01f, -1.49087220e-01f, 2.53443271e-01f, -2.28443369e-01f, 3.90791118e-01f, 4.35957134e-01f, 8.15481879e-03f, 3.07578921e-01f, 3.63811523e-01f,
  1.25991598e-01f, -1.08979814e-01f, 1.83013022e-01f, 3.73255044e-01f, -1.02096543e-01f, 3.28631848e-01f, 3.02482784e-01f, 2.55820602e-01f, 6.62110373e-02f, -5.28147034e-02f,
  -1.01640366e-01f, 1.64334893e-01f, -1.08116463e-01f, -2.15682596e-01f, -1.84325293e-01f, -1.34608477e-01f, -2.80622154e-01f, -1.48563311e-01f, -3.80069800e-02f, 7.57733360e-02f,
  3.48035321e-02f, -4.81655747e-02f, -1.13284467e-02f, 5.14920019e-02f, 3.37506570e-02f, -9.48663801e-03f, -8.07890147e-02f, -6.05345704e-02f, -1.01613291e-01f, 1.15768589e-01f,
  -3.11761461e-02f, 1.69525295e-03f, 2.05967784e-01f, -8.86322632e-02f, -4.76987697e-02f, -8.61958414e-02f, -5.29592969e-02f, -3.86548825e-02f, 6.61813235e-03f, -1.07310221e-01f,
  -7.98799023e-02f, 9.75875091e-03f, -1.93707198e-02f, 1.37317598e-01f, -5.67472503e-02f, 1.56282466e-02f, 1.15400001e-01f, -1.09207943e-01f, -3.14963376e-03f, -1.70762978e-05f,
  -7.53108189e-02f, 9.14651453e-02f, 6.54985905e-02f, -6.46827072e-02f, -6.13557138e-02f, -2.86779664e-02f, -5.49361743e-02f, 1.56355500e-02f, 3.06079593e-02f, 1.51751917e-02f,
  7.34187290e-02f, 3.55999209e-02f, -4.13366780e-03f, 5.46459705e-02f, 1.32650072e-02f, 4.00086157e-02f, -4.17700456e-03f, 7.70033803e-03f, 7.13250339e-02f, 3.93672213e-02f,
  4.12583351e-02f, 5.94955264e-03f, 4.86397557e-02f, 1.07366301e-01f, 9.51060560e-03f, -3.56085114e-02f, 3.72787751e-02f, 1.77092664e-02f, -9.72111803e-03f, -5.33803068e-02f,
  1.25614956e-01f, 3.17079157e-01f, 5.18657826e-02f, 1.07166260e-01f, 1.66037437e-02f, -8.11865926e-02f, -1.54644744e-02f, 4.61578630e-02f, 3.42876911e-02f, 1.39645264e-01f,
  3.41900159e-03f, 9.87644121e-02f, -5.98884895e-02f, 6.24804466e-04f, -1.60741415e-02f, 2.88966373e-02f, 4.20901664e-02f, 4.98173907e-02f, 5.34993708e-02f, -1.23790756e-01f,
  -8.71930718e-02f, 6.14655903e-03f, 8.21440760e-03f, 3.90434675e-02f, 1.02294832e-01f, -3.48946713e-02f, -3.02806869e-03f, -6.12123013e-02f, -4.55735214e-02f, 7.55063519e-02f,
  2.46497720e-01f, 3.31457285e-03f, -2.97044158e-01f, -1.23460568e-01f, -3.37736378e-03f, 2.36500710e-01f, 1.77104548e-01f, -2.15683311e-01f, -3.94715756e-01f, 2.88922340e-01f,
  1.04673535e-01f, -7.29080709e-03f, -1.24997064e-01f, -1.02045707e-01f, -2.82724708e-01f, -1.78092092e-01f, 8.19911137e-02f, 2.29252174e-01f, -2.34630406e-01f, 2.46023938e-01f,
  -2.73912735e-02f, 1.44954711e-01f, -1.82644427e-01f, 1.13494337e-01f, 2.15153530e-01f, 1.61226571e-01f, 7.77980387e-02f, -9.57025811e-02f, 2.36991853e-01f, -5.53986058e-02f,
  -7.78428325e-03f, -3.15291360e-02f, -1.43570621e-02f, -1.04449131e-01f, 9.74096805e-02f, 1.58279955e-01f, 2.07479283e-01f, -1.07966922e-01f, -1.28309757e-01f, -2.89993379e-02f,
  8.45433250e-02f, -2.31638327e-02f, 2.94097029e-02f, -5.66607825e-02f, 7.59492740e-02f, 3.77488844e-02f, -4.71362360e-02f, -6.69838786e-02f, -1.10853650e-01f, 1.48373563e-03f,
  -2.05486026e-02f, 7.85788968e-02f, 1.29324123e-01f, -8.31110999e-02f, -5.37171513e-02f, 1.11557329e-02f, 6.54886737e-02f, 1.03946313e-01f, 5.14595397e-03f, 3.64644341e-02f,
  9.72901806e-02f, 1.62214935e-01f, 1.03134662e-01f, 2.90240590e-02f, -1.11993484e-01f, -5.26446709e-03f, 9.48640227e-04f, 1.15230521e-02f, -3.30040716e-02f, -1.25020677e-02f,
  -1.86460502e-02f, -3.61727700e-02f, -1.09186403e-01f, 1.06044030e-02f, 6.06162623e-02f, -7.00078756e-02f, 3.70453186e-02f, 3.13145891e-02f, -2.98451651e-02f, -8.07235092e-02f,
  -9.75158587e-02f, 4.01938893e-02f, -6.83063418e-02f, 7.46234357e-02f, -1.09280877e-01f, -9.79580358e-02f, 1.20501323e-02f, 6.22041114e-02f, -7.55522475e-02f, -5.73175885e-02f,
  2.88438257e-02f, -6.43939450e-02f, -2.26296447e-02f, 1.07351691e-02f, 1.21861883e-02f, 9.62816030e-02f, -9.20231715e-02f, -1.68653596e-02f, 6.52614459e-02f, -8.84037837e-02f,
  1.63289905e-01f, 1.09318599e-01f, 3.88781726e-02f, 3.54066864e-02f, -7.05487356e-02f, 5.13636991e-02f, 6.34510070e-02f, 4.06159908e-02f, -6.17387556e-02f, -8.53311941e-02f,
  1.13877513e-01f, 1.08701967e-01f, 1.06410449e-02f, 3.57457511e-02f, 2.51910519e-02f, 7.07444623e-02f, 2.49332227e-02f, 1.39767647e-01f, -6.48675784e-02f, -8.72452557e-02f,
  1.72907874e-01f, -2.97257990e-01f, 1.47044495e-01f, -3.67365658e-01f, 6.40304585e-04f, 1.22264594e-01f, 1.31794631e-01f, -3.64233255e-01f, -5.12034357e-01f, -3.55143666e-01f,
  -5.76374754e-02f, 7.09593818e-02f, 3.01987737e-01f, -2.27100804e-01f, 4.26456660e-01f, 1.45867050e-01f, -2.60733008e-01f, -2.27839383e-03f, -3.28128152e-02f, -7.29627982e-02f,
  -3.73166017e-02f, -1.51807204e-01f, 4.06298667e-01f, -2.03420967e-01f, -5.87952174e-02f, -1.69094473e-01f, -6.89317361e-02f, 2.66188264e-01f, -1.62370831e-01f, 1.52626559e-01f,
  1.14278674e-01f, -8.56391862e-02f, 5.62716089e-02f, -1.63241883e-03f, 8.79610553e-02f, 9.74422395e-02f, 1.92463011e-01f, 2.78639853e-01f, -9.07698181e-03f, -2.71861330e-02f,
  3.37805562e-02f, -6.08056691e-03f, -1.92185357e-01f, 1.09167866e-01f, -1.61593527e-01f, -2.22219959e-01f, 5.35931177e-02f, -7.53933340e-02f, 3.08897942e-02f, 7.98111483e-02f,
  4.13705893e-02f, -7.59598315e-02f, -1.19271792e-01f, -1.54934034e-01f, -1.15765430e-01f, -9.74451602e-02f, 5.84886558e-02f, 8.34275708e-02f, -7.77107179e-02f, -1.28148392e-01f,
  -3.10692545e-02f, 8.69335607e-02f, 5.91615736e-02f, -4.90552327e-03f, 2.19700895e-02f, 2.14637611e-02f, -4.15773429e-02f, 1.14853263e-01f, -4.61037923e-03f, -2.11061276e-02f,
  -1.28793001e-01f, -2.48891208e-02f, -9.45810601e-02f, -8.55913162e-02f, 2.64716521e-02f, -5.93188368e-02f, 1.27843082e-01f, 5.80422394e-02f, -9.36449990e-02f, -4.79641445e-02f,
  -2.65317224e-02f, -6.97958246e-02f, -8.89772102e-02f, -1.19671099e-01f, -3.47359814e-02f, -4.04163413e-02f, -1.35643169e-01f, -1.15255572e-01f, -1.89867262e-02f, 1.80087700e-01f,
  -2.58592740e-02f, -1.83823735e-01f, 2.26994120e-02f, -1.05840296e-01f, 4.63100560e-02f, -5.43191880e-02f, 6.13993369e-02f, -6.52288944e-02f, 2.20345370e-02f, -8.44762623e-02f,
  5.52860647e-03f, 1.76914074e-02f, -8.99619982e-03f, 1.75300185e-02f, -3.48603316e-02f, -8.92680064e-02f, -5.64396335e-03f, -4.47828732e-02f, -3.11596803e-02f, -2.98607312e-02f,
  1.24938395e-02f, -2.19521858e-02f, 5.74019812e-02f, -1.05691366e-01f, -9.25963670e-02f, -3.70385088e-02f, -7.61905089e-02f, 5.30334860e-02f, -9.78691429e-02f, -3.87450829e-02f,
  4.36772108e-01f, -4.82617527e-01f, 1.06221624e-01f, 2.54772276e-01f, 3.67343098e-01f, 1.08562365e-01f, 2.21503198e-01f, 1.55738801e-01f, 3.37158710e-01f, -2.91405588e-01f,
  3.48641514e-03f, -2.60184169e-01f, -3.23167354e-01f, 9.12228227e-02f, 2.43022367e-01f, -1.12207182e-01f, 9.07564089e-02f, 4.47467603e-02f, 7.23305866e-02f, 1.05869666e-01f,
  2.41334409e-01f, 1.20502293e-01f, 9.40879062e-02f, -8.84677917e-02f, 1.05322987e-01f, 7.61082396e-02f, 5.45468926e-02f, -9.77771729e-02f, 4.19972949e-02f, 5.66227175e-02f,
  1.41716162e-02f, 6.84712529e-02f, -1.13248870e-01f, -1.32960588e-01f, 2.11945958e-02f, -7.74546573e-03f, -8.59466642e-02f, 1.84566099e-02f, 3.49944197e-02f, 4.36251909e-02f,
  -1.56227842e-01f, 9.68184322e-02f, -1.02454787e-02f, 1.02463104e-01f, -2.64643803e-02f, 1.35186747e-01f, 3.21093649e-02f, -1.61482334e-01f, 6.11733682e-02f, 4.61373478e-02f,
  9.21476334e-02f, -9.37235281e-02f, -5.91886789e-03f, -9.37237218e-02f, -1.06390171e-01f, 7.00025931e-02f, 7.75331631e-02f, -1.00453176e-01f, 9.08597838e-03f, -2.11974587e-02f,
  -1.41751757e-02f, -1.14670299e-01f, -1.05451075e-02f, 1.65597349e-02f, 1.24722626e-02f, 1.50081649e-01f, -6.68927878e-02f, -3.86564992e-02f, -9.17778760e-02f, -2.33020093e-02f,
  6.44457042e-02f, -1.29014000e-01f, -3.89949046e-02f, 4.47575189e-02f, -6.55862363e-03f, 5.90656465e-03f, -4.01509255e-02f, 1.23476963e-02f, -5.54559529e-02f, 1.56139676e-02f,
  6.32062107e-02f, -6.24368228e-02f, -8.32844749e-02f, 1.41687989e-01f, 2.18771561e-03f, -8.89628660e-03f, 4.39746566e-02f, -8.94898847e-02f, 6.55846447e-02f, 1.59217380e-02f,
  -4.34339076e-01f, -2.46039197e-01f, -2.00324789e-01f, -8.97400081e-02f, -8.31287876e-02f, -4.04886045e-02f, -5.09252734e-02f, 7.74542466e-02f, 2.81298510e-03f, -1.53026022e-02f,
  -4.96490002e-02f, 1.36587575e-01f, -1.97330728e-01f, 8.24387297e-02f, -5.61286807e-02f, 2.14930135e-03f, 3.97809409e-02f, -1.43476963e-01f, -9.38174352e-02f, -1.58014879e-01f,
  -3.77972461e-02f, 2.41543651e-02f, 1.62528399e-02f, 7.18808686e-03f, -9.28852409e-02f, -8.82848874e-02f, -6.02499535e-03f, 3.65960971e-02f, -6.88408166e-02f, 3.40878963e-02f,
  2.93082356e-01f, -2.23230541e-01f, 3.55730683e-01f, 2.45760813e-01f, 5.65270036e-02f, -9.59360674e-02f, 2.11408898e-01f, -2.94692725e-01f, 6.62519857e-02f, -1.84793606e-01f,
  -1.21096142e-01f, 2.82639623e-01f, -1.51279718e-01f, -1.42922322e-03f, 5.82914576e-02f, -2.03629985e-01f, -8.56269971e-02f, 2.82468885e-01f, -2.40542032e-02f, 7.25300014e-02f,
  -5.71299456e-02f, -2.49279067e-01f, 9.31671858e-02f, -3.66205961e-01f, 2.37875879e-01f, 1.54091388e-01f, -2.22845420e-01f, 1.35436142e-02f, 1.07500900e-03f, -1.82925239e-02f,
  7.82939717e-02f, -1.44127324e-01f, 8.94996077e-02f, -6.61634803e-02f, -1.36476263e-01f, -2.84100864e-02f, -9.58363619e-03f, 4.26161252e-02f, -1.75774042e-02f, 9.43015330e-03f,
  1.07143007e-01f, 5.36288805e-02f, -6.12325333e-02f, 4.10619974e-02f, 2.51888502e-02f, -4.73387241e-02f, 7.52739459e-02f, 8.90088454e-02f, 7.65083805e-02f, -5.07416390e-03f,
  1.18378855e-01f, 8.32069293e-02f, -6.19700039e-03f, -1.89079065e-03f, 9.29050669e-02f, 1.08128553e-02f, -1.23311067e-02f, 1.93075359e-01f, 3.68857682e-02f, 9.20232087e-02f,
  -9.71136168e-02f, -5.72393164e-02f, -1.21827796e-01f, -1.29601443e-02f, 7.88271651e-02f, 3.39345634e-02f, -9.19667408e-02f, -5.75368963e-02f, 1.25967294e-01f, 9.91039872e-02f,
  7.87506551e-02f, 1.41982108e-01f, -7.33503178e-02f, 8.18153545e-02f, -3.42452638e-02f, 3.71233597e-02f, 1.45960867e-01f, -3.48859318e-02f, 4.70687598e-02f, -1.45535066e-03f,
  -8.48687813e-02f, -1.69646740e-02f, 6.49772733e-02f, 6.51236176e-02f, -8.73252749e-03f, -4.73891795e-02f, -8.46811458e-02f, 7.51111656e-02f, -6.52828887e-02f, -7.79103711e-02f,
  -3.77346985e-02f, -3.04894984e-01f, -1.78603865e-02f, 9.62356403e-02f, -7.69021511e-02f, 4.71114032e-02f, -8.35648924e-03f, -1.83385573e-02f, 5.21492772e-02f, -1.12650231e-01f,
  -6.05143458e-02f, 1.09066688e-01f, 1.12055182e-01f, 5.72469421e-02f, -8.12388808e-02f, -5.83958924e-02f, 2.56628566e-03f, 2.43771654e-02f, -6.90830648e-02f, -1.09762616e-01f,
  9.39318463e-02f, 6.77224100e-02f, 1.10096827e-01f, 8.49341154e-02f, 8.67798030e-02f, 2.48064287e-03f, 5.17946072e-02f, 4.13968302e-02f, -1.55988960e-02f, -1.15814013e-02f,
  1.82844713e-01f, -1.45434722e-01f, -2.82084018e-01f, -1.49376065e-01f, -1.88154817e-01f, -3.87375534e-01f, -3.19393367e-01f, -1.87226966e-01f, 1.10139713e-01f, 1.97163895e-02f,
  -4.22706157e-02f, -1.00139324e-02f, 9.96735618e-02f, -3.49069357e-01f, 5.94944730e-02f, 1.47633344e-01f, -3.11802149e-01f, -1.26516044e-01f, 1.65295109e-01f, -1.37294590e-01f,
  -2.03671921e-02f, -9.72299948e-02f, -1.74882069e-01f, -1.33550093e-01f, -2.73420960e-01f, -8.92963931e-02f, 5.70369735e-02f, -2.40011010e-02f, -2.41316512e-01f, 8.66046026e-02f,
  6.10179501e-03f, 7.54804686e-02f, -9.68226865e-02f, 2.81267241e-02f, -5.63272368e-03f, -5.77397160e-02f, -1.39099568e-01f, -7.20185786e-02f, 7.86015764e-02f, -1.19610522e-02f,
  4.58283313e-02f, 6.41979575e-02f, 4.74924222e-02f, 1.27646238e-01f, 4.14634719e-02f, -1.19311243e-01f, 7.90874586e-02f, -9.63540003e-02f, -1.09080747e-01f, 2.33921222e-02f,
  9.37891193e-03f, 3.93936485e-02f, -7.21886456e-02f, 5.19588441e-02f, -1.91900996e-03f, 3.44142281e-02f, -1.01243146e-01f, -2.16522664e-02f, -5.90544529e-02f, 9.08316746e-02f,
  4.16368917e-02f, 1.04813784e-01f, -6.36296943e-02f, 1.11937970e-01f, 2.56784330e-03f, -8.07739943e-02f, 4.86086309e-02f, -5.22557609e-02f, -2.60441285e-02f, -1.07740723e-01f,
  -3.77583597e-03f, 5.01470789e-02f, 4.28183302e-02f, -6.64424226e-02f, -2.10478436e-02f, 8.39723721e-02f, -4.84494753e-02f, -2.01753192e-02f, -6.89413995e-02f, 5.48949353e-02f,
  5.28495163e-02f, -4.07819115e-02f, 1.01780742e-02f, 1.13574658e-02f, -1.11918598e-01f, 6.58948794e-02f, -1.99469123e-02f, 2.58795246e-02f, 4.45107222e-02f, -4.94258367e-02f,
  -1.50241330e-01f, -4.95321415e-02f, 7.03439163e-03f, 3.60234790e-02f, -8.67362171e-02f, 8.54465514e-02f, -1.43473595e-01f, 8.57070927e-03f, -1.16511635e-01f, -7.90002756e-03f,
  -8.87492225e-02f, -8.01690891e-02f, -3.82234948e-03f, 1.56228263e-02f, -6.10382669e-02f, -1.17409080e-01f, -5.04877120e-02f, 1.16287462e-01f, -9.79305133e-02f, 1.07126378e-01f,
  5.37377000e-02f, 4.44697253e-02f, -3.10460310e-02f, 1.48598319e-02f, 3.91482785e-02f, -3.18399370e-02f, -5.65320402e-02f, 3.50841880e-02f, 7.39216059e-02f, -2.07576565e-02f,
  -2.26673372e-02f, -1.61526501e-01f, -2.54801035e-01f, -1.39349014e-01f, -3.37951392e-01f, -1.87837288e-01f, -1.37763664e-01f, -3.20000201e-01f, -1.89642400e-01f, 1.35920122e-01f,
  6.70251548e-02f, 3.02162915e-02f, 3.84041488e-01f, -7.34263957e-02f, 1.91387221e-01f, 3.79791379e-01f, -1.78921714e-01f, 7.40941167e-02f, -1.08090073e-01f, -2.60442317e-01f,
  -1.39794186e-01f, -3.66988406e-02f, 2.51117706e-01f, -3.25367421e-01f, -1.50506809e-01f, -7.55420178e-02f, 1.57421172e-01f, -1.22925043e-01f, -1.80812821e-01f, -4.59045693e-02f,
  1.16268530e-01f, -5.17447153e-03f, -1.10735774e-01f, -2.27677822e-02f, 5.25445938e-02f, 2.60562804e-02f, -2.00545117e-02f, 9.33061838e-02f, -5.41317388e-02f, -1.91974957e-02f,
  -1.79469269e-02f, 7.96130076e-02f, -1.67124253e-02f, -3.09377238e-02f, -1.32114604e-01f, -9.69578326e-02f, -4.44997773e-02f, 4.81788218e-02f, -7.67321587e-02f, 6.18524104e-02f,
  -3.02125625e-02f, -3.14068235e-02f, 6.46002917e-03f, 1.01042740e-01f, -2.91118454e-02f, -4.82638553e-02f, -2.35655881e-03f, 2.20382884e-02f, -3.47048603e-02f, -3.49270329e-02f,
  -6.62403554e-02f, 4.97971661e-02f, 8.65135156e-03f, -3.59796360e-02f, 2.78501529e-02f, 6.19514845e-02f, -1.10308863e-02f, 6.23572618e-02f, -8.21454972e-02f, 8.16753954e-02f,
  -1.75054818e-02f, -2.88521443e-02f, 3.22334506e-02f, -1.99789624e-03f, -1.03176989e-01f, 4.34630550e-03f, 7.56625757e-02f, 9.84555762e-03f, 1.26177287e-02f, 8.14162418e-02f,
  1.06214330e-01f, -2.98481677e-02f, -2.51476839e-02f, 6.81053177e-02f, 1.39639052e-02f, 7.61195347e-02f, 2.05269642e-02f, 3.65467146e-02f, 2.46561076e-02f, -7.92781264e-02f,
  -7.22140521e-02f, -1.79573372e-01f, 2.64222175e-03f, -3.96190807e-02f, -9.68875084e-03f, -5.98894916e-02f, 1.43498154e-02f, -1.67997584e-01f, -8.47529471e-02f, -1.89727381e-01f,
  -1.55386031e-01f, 3.11443601e-02f, -1.29864573e-01f, -5.84901311e-02f, 2.32606623e-02f, -7.12530985e-02f, -1.12220254e-02f, -4.91236299e-02f, -1.82312224e-02f, -2.54850257e-02f,
  6.73106387e-02f, -2.33323500e-02f, 1.28453478e-01f, 2.36911085e-02f, 7.65820965e-02f, 2.89683696e-02f, -1.78125836e-02f, -1.61987226e-02f, -6.82366565e-02f, -7.27461278e-02f,
  -5.97243547e-01f, -1.13221645e-01f, -5.28386645e-02f, 1.60397097e-01f, -5.60698137e-02f, 8.61965679e-03f, -3.40454638e-01f, 2.03265935e-01f, -2.93882281e-01f, -3.44703287e-01f,
  8.85972306e-02f, -6.39380841e-03f, -1.97915211e-01f, 3.79997581e-01f, 3.18815202e-01f, 8.58085901e-02f, 2.60589212e-01f, 1.08798698e-01f, 1.99466631e-01f, 2.08904281e-01f,
  1.61746785e-01f, 4.31144685e-01f, 4.13670987e-01f, 4.84683096e-01f, 9.35701802e-02f, 1.57215625e-01f, 2.50469565e-01f, 1.33467451e-01f, 3.77879679e-01f, 2.01706037e-01f,
  -1.23057708e-01f, -9.38785970e-02f, 1.34675903e-02f, 3.26022357e-02f, 9.23986062e-02f, -6.88709766e-02f, -1.06274769e-01f, -1.69321231e-03f, 6.24161921e-02f, 5.43038473e-02f,
  -9.75295827e-02f, 8.27544406e-02f, 1.60829827e-01f, 2.28164848e-02f, -8.99998322e-02f, 1.72441592e-03f, 1.15322298e-03f, -2.45167105e-03f, 1.34536633e-02f, -1.27122486e-02f,
  2.34621931e-02f, 6.45599291e-02f, -4.18427028e-02f, 1.29927546e-01f, 5.90481386e-02f, -5.45019619e-02f, -2.35436019e-02f, 4.67516519e-02f, 7.73381293e-02f, 8.47945586e-02f,
  -5.37177660e-02f, 4.61900495e-02f, 3.82096171e-02f, 4.48480882e-02f, 9.49803665e-02f, 7.21087828e-02f, 3.46532986e-02f, 1.46703480e-03f, 4.36222367e-02f, -8.39889348e-02f,
  8.58486295e-02f, -5.30979931e-02f, -1.40467966e-02f, -5.39463162e-02f, -2.94692032e-02f, 4.93933298e-02f, -5.89206815e-02f, 8.22852254e-02f, 3.98790836e-02f, -4.31896560e-02f,
  -6.47817850e-02f, 1.23330625e-02f, -1.37023181e-02f, 1.07593155e-02f, 3.98394372e-03f, -3.72469388e-02f, 1.19981781e-01f, -4.45058849e-03f, 1.80969387e-02f, 8.33896846e-02f,
  5.89579949e-03f, 1.27301633e-01f, 8.47153142e-02f, 1.63574070e-02f, 4.21438813e-02f, 2.77822055e-02f, -1.00309895e-02f, 4.09139842e-02f, -1.99365262e-02f, 8.32676217e-02f,
  -4.16508224e-03f, 2.05194131e-02f, -1.11993231e-01f, -1.51103863e-03f, 1.78332448e-01f, -5.88845238e-02f, -5.39223142e-02f, -1.39696345e-01f, 2.02568471e-02f, 7.85068944e-02f,
  -4.82508205e-02f, -5.18409163e-02f, -3.25013674e-03f, 1.61828876e-01f, -3.74372415e-02f, -2.45075300e-02f, 5.84404282e-02f, -1.16793565e-01f, 9.23822820e-02f, 3.14645804e-02f,
  -5.44624984e-01f, 3.73218238e-01f, -1.08479097e-01f, 7.56172985e-02f, 6.32726923e-02f, -3.45846742e-01f, -1.57279432e-01f, -2.29026377e-02f, -1.62636846e-01f, 7.65505657e-02f,
  2.77014077e-03f, -9.13680270e-02f, 1.50830552e-01f, 1.67923450e-01f, -1.86125696e-01f, 2.21599653e-01f, -9.34952050e-02f, -1.51378155e-01f, 1.95541888e-01f, 8.68449807e-02f,
  1.20010532e-01f, 1.22968085e-01f, 1.93064734e-01f, 2.56042749e-01f, -2.75292434e-02f, 5.45775145e-02f, -5.62948585e-02f, 1.57895744e-01f, -1.08489677e-01f, 1.16093189e-01f,
  -4.61268276e-01f, -8.07675496e-02f, -1.31033391e-01f, -2.00485334e-01f, -2.16869801e-01f, -1.39892697e-01f, -1.44022167e-01f, -5.02078533e-02f, 4.26515453e-02f, -5.90836778e-02f,
  -1.33520693e-01f, 3.52927335e-02f, 9.08462629e-02f, 1.25492290e-01f, -1.47276506e-01f, 2.08325274e-02f, 5.35302050e-02f, -1.30772823e-02f, 2.14094426e-02f, 1.79731660e-02f,
  -1.72817111e-02f, 1.28255626e-02f, 4.92192013e-03f, 3.29533555e-02f, 4.78351042e-02f, 4.83311825e-02f, 3.28288600e-02f, -6.13392666e-02f, -5.59484623e-02f, -5.91149516e-02f,
  1.17462568e-01f, 1.47277797e-02f, 3.63061316e-02f, -5.29512428e-02f, -9.20902193e-03f, 8.45402107e-02f, -2.29186025e-02f, -4.22640219e-02f, -4.48037544e-03f, 1.00329276e-02f,
  -5.71798906e-02f, 4.84928256e-03f, 1.56898364e-01f, -5.42105958e-02f, -1.27626453e-02f, -6.49065301e-02f, 5.66085726e-02f, 1.27038481e-02f, 5.45602329e-02f, -6.01112507e-02f,
  2.08907444e-02f, 7.67311677e-02f, 2.29913592e-02f, -6.90198615e-02f, -6.51968867e-02f, 8.72430801e-02f, 5.94099015e-02f, 1.35038927e-01f, -5.11484742e-02f, 9.60486103e-03f,
  -4.32037711e-01f, -7.31672868e-02f, -1.77551344e-01f, -1.73358351e-01f, -1.38017358e-02f, -8.91593546e-02f, 3.17565650e-02f, -9.25830100e-03f, 2.29912587e-02f, -5.43600917e-02f,
  -9.78327841e-02f, -8.30120519e-02f, -7.72682205e-02f, -1.21446354e-02f, -1.49365729e-02f, -6.27266988e-02f, 3.29024680e-02f, 5.74485958e-02f, -1.75870478e-01f, -5.13480790e-02f,
  6.15831688e-02f, -8.26076344e-02f, 8.19393694e-02f, 1.24951592e-02f, 2.74958611e-02f, -1.01765461e-01f, -8.24666992e-02f, -3.67570259e-02f, -9.96611565e-02f, 1.61780231e-02f,
  1.90752476e-01f, -4.33886975e-01f, 1.00319788e-01f, 7.17726117e-03f, 4.19413805e-01f, 2.43320435e-01f, 2.52045304e-01f, 3.95139121e-02f, -1.05137527e-01f, -3.72798085e-01f,
  -5.98558113e-02f, -1.99129701e-01f, -1.73230007e-01f, 7.53477514e-02f, 2.79533297e-01f, -3.83976325e-02f, 4.98412661e-02f, 1.25888991e-03f, 1.12508222e-01f, 2.05794945e-02f,
  1.76649660e-01f, 1.88959137e-01f, 2.55250245e-01f, 8.19827840e-02f, 9.30453613e-02f, -1.81146916e-02f, -8.68284404e-02f, 2.19305586e-02f, 4.74114344e-02f, 1.94549173e-01f,
  -1.22834064e-01f, -7.52897635e-02f, 1.81064397e-01f, 5.26184142e-02f, 8.48708209e-03f, -1.27108991e-01f, 7.26873726e-02f, 5.35710379e-02f, -5.15332781e-02f, -4.02320251e-02f,
  1.41368108e-02f, 8.33911449e-02f, 1.23288728e-01f, 3.16377878e-02f, 5.12049235e-02f, -1.31048765e-02f, 2.86863302e-03f, 1.74905937e-02f, -1.85624119e-02f, 3.57528739e-02f,
  1.35295549e-02f, 1.03936248e-01f, -8.96782242e-03f, -2.84511335e-02f, 1.06686853e-01f, -6.99629858e-02f, -6.35164278e-03f, 5.75899407e-02f, -2.51235012e-02f, 9.72568393e-02f,
  2.39023611e-01f, 6.13371804e-02f, -7.13014752e-02f, -2.44527608e-02f, -6.70479238e-02f, -2.33039912e-02f, -8.40449855e-02f, 1.26824332e-02f, 3.39661427e-02f, 4.45571244e-02f,
  -2.97609139e-02f, 1.57980435e-03f, 1.01524824e-02f, -1.25921607e-01f, -4.08492014e-02f, -6.03188984e-02f, 1.40656168e-02f, -4.81171161e-02f, -5.87224215e-02f, 1.10461846e-01f,
  -1.42752111e-01f, 4.68186215e-02f, 9.73700061e-02f, -3.49660255e-02f, -7.31937587e-03f, -1.96400826e-04f, -4.03096601e-02f, 2.52984818e-02f, 5.18190600e-02f, 4.34377193e-02f,
  -4.87801582e-01f, -3.59033167e-01f, -5.49556548e-03f, -4.20027375e-02f, -1.00475609e-01f, -4.85942326e-02f, 4.71582934e-02f, -3.99199547e-03f, -9.48080346e-02f, 1.39414389e-02f,
  -1.09382778e-01f, -5.46517596e-02f, -2.05302507e-01f, 5.51545173e-02f, -3.20024230e-02f, -3.62842828e-02f, -3.23786028e-02f, -5.44588603e-02f, 1.35878390e-02f, -5.67345954e-02f,
  -6.48817569e-02f, -2.75712442e-02f, 4.29335982e-02f, 1.21690877e-01f, -8.49478021e-02f, -3.42924558e-02f, -4.27112505e-02f, 1.38549507e-02f, -1.02219479e-02f, -2.86088102e-02f,
  -3.45198929e-01f, 2.92570025e-01f, -3.61863434e-01f, 1.92727089e-01f, -1.65792853e-02f, -5.20756207e-02f, 6.15907758e-02f, 4.72592283e-03f, -7.74078071e-02f, 3.84746671e-01f,
  2.70215929e-01f, -1.74611419e-01f, 2.16455653e-01f, 4.26439732e-01f, -1.88623413e-01f, 2.61120588e-01f, 2.87978798e-01f, 7.36868605e-02f, -1.53675541e-01f, 2.85981651e-02f,
  -9.93298814e-02f, 3.91107887e-01f, -1.08295763e-02f, 1.15206368e-01f, 1.15844980e-01f, -1.34362385e-01f, 2.15661258e-01f, -1.75593123e-01f, 1.58373162e-01f, 1.52809974e-02f,
  1.74721017e-01f, 1.95581377e-01f, -2.71745287e-02f, -8.28038305e-02f, -1.34056091e-01f, -1.77199319e-02f, -9.04951766e-02f, -1.41390279e-01f, -1.12071432e-01f, -3.32163386e-02f,
  -1.14657439e-01f, -1.33345619e-01f, -2.44541597e-02f, -1.54193938e-02f, -2.98368968e-02f, 5.87002328e-03f, -1.70538221e-02f, -3.65335457e-02f, 9.18692052e-02f, 6.91684037e-02f,
  -1.53695128e-03f, 4.75879945e-02f, 9.41805765e-02f, 7.58637264e-02f, 4.76956405e-02f, 2.76125483e-02f, 5.87934628e-03f, -6.81051165e-02f, 2.74894238e-02f, -4.87449430e-02f,
  -1.03761725e-01f, -7.81077072e-02f, 6.55978322e-02f, 7.97651485e-02f, 6.50282949e-02f, 1.11631401e-01f, 2.21895166e-02f, 1.93072706e-02f, -5.93837537e-02f, 9.71378386e-02f,
  8.63226131e-02f, -4.34945524e-02f, -3.02298721e-02f, 2.70957910e-02f, -7.22992560e-03f, 1.97244491e-02f, -9.62881371e-02f, -4.11440106e-03f, -5.61044589e-02f, -3.32814418e-02f,
  -6.49013519e-02f, -1.07149795e-01f, 3.02234907e-02f, -3.00464150e-03f, 8.59876126e-02f, 2.51484439e-02f, 6.51975162e-03f, -3.63726076e-03f, 1.42725095e-01f, -1.72422882e-02f,
  1.02177806e-01f, 5.25872894e-02f, -4.43166979e-02f, -9.90118831e-02f, -2.18757577e-02f, 5.96362120e-03f, 4.05892208e-02f, -7.63604243e-04f, -7.34437630e-02f, 1.62578356e-02f,
  -3.54067027e-03f, 9.54541378e-03f, 5.87326661e-03f, 2.79304124e-02f, -5.77697493e-02f, 4.52186950e-02f, 1.26963109e-01f, -1.76149048e-02f, 2.50389669e-02f, -8.32393914e-02f,
  2.29979102e-02f, -3.13793914e-03f, -1.52636454e-01f, -2.18804404e-02f, 5.51617146e-02f, 1.18121058e-01f, -3.30583900e-02f, -7.17352182e-02f, 6.89366087e-02f, -3.46597843e-02f,
  3.41515899e-01f, 2.29098946e-02f, -3.13752443e-01f, -1.63597628e-01f, 3.12506668e-02f, 2.82220483e-01f, 2.51582801e-01f, 1.25031427e-01f, -3.85918468e-02f, 1.73067376e-01f,
  2.61570185e-01f, -5.49744582e-03f, -1.16846142e-02f, 2.78396487e-01f, 3.57911915e-01f, 1.20844588e-01f, 2.72361636e-01f, 1.02277450e-01f, -1.02465115e-02f, 1.06356084e-01f,
  2.10854150e-02f, 4.72076267e-01f, -2.33627006e-01f, -2.93147434e-02f, 1.65172741e-01f, -3.04873705e-01f, -1.63652852e-01f, -2.86900938e-01f, -2.59311888e-02f, 2.20995903e-01f,
  7.34180585e-03f, 8.92231464e-02f, -3.08054779e-02f, 1.94995608e-02f, -1.09660208e-01f, 1.79037228e-02f, -1.10775456e-01f, 4.07279767e-02f, -4.53911088e-02f, 7.84622207e-02f,
  -2.69605722e-02f, -2.94368938e-02f, 1.54151797e-01f, 4.72784378e-02f, -1.28572630e-02f, -3.43280882e-02f, -2.80777682e-02f, -8.51781592e-02f, -4.84109260e-02f, 4.43078019e-02f,
  -8.29422921e-02f, -7.55667090e-02f, -8.27963278e-02f, -9.45159644e-02f, -1.36209041e-01f, -1.64096449e-02f, -8.27496648e-02f, -1.36699468e-01f, 4.62124385e-02f, 7.50322081e-03f,
  8.15216079e-02f, -6.29175082e-02f, 7.92006776e-02f, -4.42367571e-04f, 1.07958272e-01f, -5.02181835e-02f, 2.38526985e-02f, -4.42411080e-02f, -6.14928305e-02f, 1.11947593e-03f,
  -3.88227776e-02f, -6.15596734e-02f, 7.84236416e-02f, 3.65762115e-02f, 1.23821355e-01f, -1.56885404e-02f, -3.97257879e-02f, 6.83251917e-02f, -8.11773017e-02f, -5.42744249e-02f,
  2.82366555e-02f, 2.43342910e-02f, 8.16500932e-02f, 4.82754186e-02f, 6.95603564e-02f, 4.17464711e-02f, 1.07881889e-01f, -2.31611468e-02f, -9.08673406e-02f, -4.88199629e-02f,
  1.17845900e-01f, 9.35825333e-02f, -2.42040157e-02f, 8.89238417e-02f, -5.66013530e-02f, 1.49346411e-01f, -3.27957049e-02f, 9.23105776e-02f, 2.21044328e-02f, 5.65868877e-02f,
  -3.62987481e-02f, -8.25216472e-02f, 1.61624514e-02f, -1.30548850e-01f, -1.14567712e-01f, 1.13722749e-01f, -5.67127094e-02f, -9.23635960e-02f, -9.70984325e-02f, 3.00862528e-02f,
  1.71996430e-02f, 5.92995286e-02f, -3.90925705e-02f, 3.65609787e-02f, 4.81581278e-02f, 3.50292102e-02f, 4.74576131e-02f, -1.10315315e-01f, 7.31774196e-02f, -4.18626033e-02f,
  -3.61819297e-01f, 6.09046258e-02f, -1.86900407e-01f, -2.82500535e-01f, 1.38209492e-01f, -1.70057863e-01f, -1.11098647e-01f, 1.19541220e-01f, -1.41593456e-01f, 2.54442066e-01f,
  1.76704973e-01f, -2.16961697e-01f, 2.50365287e-01f, -1.86864838e-01f, -3.76447469e-01f, -2.04609752e-01f, -4.24815774e-01f, -2.55691320e-01f, -1.61253348e-01f, -1.01118691e-01f,
  -2.50088006e-01f, -5.72399832e-02f, -3.82192820e-01f, 1.46738783e-01f, -8.48634616e-02f, 4.20513228e-02f, 1.53004289e-01f, 2.52074122e-01f, -2.14512095e-01f, -7.84642249e-02f,
  3.44472043e-02f, 7.79483020e-02f, 3.11401300e-02f, 5.02330810e-02f, -6.14822693e-02f, -6.50033820e-03f, 1.13294413e-03f, -1.03369523e-02f, -3.87770534e-02f, 1.57987829e-02f,
  8.54298566e-03f, -8.93049464e-02f, -1.36464611e-01f, -4.51130345e-02f, -2.60258690e-02f, -7.88281783e-02f, 1.09048914e-02f, -7.94902593e-02f, -6.15822040e-02f, -9.84355360e-02f,
  -8.00525025e-02f, -1.30552843e-01f, -1.32686347e-01f, -1.37937125e-02f, -7.73627609e-02f, -1.22488318e-02f, -8.90986249e-02f, -6.26224428e-02f, -1.22583300e-01f, -9.47865173e-02f,
  -2.59577855e-02f, -3.36143263e-02f, 5.13157398e-02f, 9.81362257e-03f, 6.41712397e-02f, 5.20455539e-02f, 4.54352759e-02f, -1.42846890e-02f, -9.63686705e-02f, 1.12483036e-02f,
  3.90768275e-02f, 2.22885683e-02f, 9.51375142e-02f, -1.06199391e-01f, -7.20462129e-02f, 2.37663854e-02f, -6.62523657e-02f, 9.18704346e-02f, -1.17299154e-01f, -1.83819178e-02f,
  1.51974887e-01f, 3.38054709e-02f, 9.43729188e-03f, 8.27663541e-02f, 8.10787603e-02f, -3.32631506e-02f, -1.17877275e-02f, -4.06205282e-02f, 3.77570316e-02f, -1.13855852e-02f,
  8.45905766e-02f, 1.50376722e-01f, 6.81691691e-02f, 1.05930604e-01f, 7.13184401e-02f, 5.89367300e-02f, -6.79028705e-02f, -9.13918763e-02f, 3.07929702e-02f, 2.65544076e-02f,
  -2.59070713e-02f, 2.69365106e-02f, -7.67668709e-02f, -3.86535972e-02f, -1.14383427e-02f, -1.92191731e-02f, 4.83572297e-03f, 1.09006867e-01f, 5.48525527e-02f, -3.30805108e-02f,
  1.31293219e-02f, 1.92295574e-02f, -1.61853079e-02f, 3.12617049e-02f, -4.74150963e-02f, 8.26504901e-02f, 8.30929540e-03f, -2.35272031e-02f, -7.29082078e-02f, 2.53964681e-02f,
  -3.93902093e-01f, 2.10263997e-01f, 1.71904147e-01f, -3.81763041e-01f, 6.73841452e-03f, -9.72398296e-02f, -2.46955067e-01f, 1.28016859e-01f, 2.60605067e-02f, 3.11752260e-01f,
  -5.44896610e-02f, 1.39946729e-01f, 7.33446889e-03f, -6.73408285e-02f, -3.06563109e-01f, -3.04605842e-01f, -3.41900200e-01f, -1.36747733e-01f, -1.24996305e-01f, -2.43197426e-01f,
  -2.28795037e-01f, -2.59534538e-01f, -1.19170755e-01f, 1.07227720e-01f, 8.97517242e-03f, 2.54459530e-01f, -2.99446862e-02f, 9.45432037e-02f, 4.26352881e-02f, 2.34164167e-02f,
  -7.23759606e-02f, 6.45900965e-02f, 1.37204155e-01f, 1.33379862e-01f, 4.15969128e-03f, 1.37570515e-01f, -3.78954336e-02f, 7.12649003e-02f, -6.24585934e-02f, 9.48830787e-03f,
  -2.21712440e-02f, 1.17143065e-01f, -7.12488741e-02f, -4.25841957e-02f, 1.13330424e-01f, 3.79676484e-02f, 5.15471026e-02f, 4.99773712e-04f, 1.40782028e-01f, 7.51829371e-02f,
  5.64977676e-02f, 8.97571594e-02f, 2.96708103e-02f, 8.46649811e-04f, -3.10328472e-02f, -2.09986791e-03f, -1.89940687e-02f, 9.28381607e-02f, 3.57882753e-02f, 3.19445878e-02f,
  3.95008037e-03f, 1.90827157e-02f, 9.59944203e-02f, 7.81364143e-02f, -2.01331757e-04f, 2.87399590e-02f, -6.56494349e-02f, 3.07269096e-02f, 3.77427861e-02f, -2.15364732e-02f,
  5.24895415e-02f, 7.89469406e-02f, -2.28078626e-02f, -2.96341050e-02f, -9.58456025e-02f, 1.06302150e-01f, -2.78547890e-02f, -4.25613970e-02f, -1.36835977e-01f, -3.68327051e-02f,
  -3.61673022e-03f, -8.56574476e-02f, 1.12354241e-01f, 4.66599166e-02f, 3.64307687e-02f, 7.47680888e-02f, 1.29977614e-02f, 1.24367073e-01f, 2.19568610e-02f, -5.22702523e-02f,
  -2.05758959e-01f, -1.98913999e-02f, 5.79525530e-02f, 9.22186673e-02f, 2.09555179e-02f, -2.17156000e-02f, -6.99972361e-02f, 6.90604746e-02f, -9.63057131e-02f, -2.97149811e-02f,
  6.03589639e-02f, 5.00189438e-02f, 1.07950298e-02f, 1.46949999e-02f, -1.09551465e-02f, -7.59145394e-02f, -4.51297462e-02f, -3.20532136e-02f, 1.95898823e-02f, 5.62404208e-02f,
  -1.96112841e-02f, 1.93549339e-02f, 6.18391521e-02f, 6.50646687e-02f, -3.57801765e-02f, 1.81338936e-02f, -7.51354247e-02f, 1.39396742e-01f, -3.70692164e-02f, -2.28329320e-02f,
  3.76748174e-01f, -4.86639977e-01f, -1.64311260e-01f, 2.27291107e-01f, 3.48838985e-01f, 1.42114878e-01f, 1.50369806e-02f, 8.87347832e-02f, 4.44473736e-02f, -2.40012765e-01f,
  2.33654734e-02f, -2.80983984e-01f, -3.21779042e-01f, 1.57110959e-01f, 2.89338678e-01f, -2.15121463e-01f, 1.58108786e-01f, -5.11830486e-02f, 9.58056003e-02f, -4.67004441e-02f,
  9.95970443e-02f, 3.53510201e-01f, -8.59919265e-02f, -1.95158906e-02f, 1.29962228e-02f, -8.85375887e-02f, -8.99177138e-03f, -1.52690306e-01f, 1.36834636e-01f, 1.05673395e-01f,
  6.11472279e-02f, 7.95460194e-02f, 1.27110751e-02f, -2.28808038e-02f, 1.51853552e-02f, -3.86498496e-02f, -3.19821388e-02f, -2.36609410e-02f, 1.11888513e-01f, -7.41232634e-02f,
  -1.56240270e-01f, 1.09649198e-02f, 1.51752353e-01f, -8.75782571e-04f, 1.22760385e-01f, 1.74819663e-01f, 9.77319404e-02f, 7.17373639e-02f, -7.33112767e-02f, -5.36462478e-02f,
  -1.46791935e-01f, -3.79027687e-02f, 1.22159675e-01f, -1.11916652e-02f, -4.77544032e-02f, 7.96238631e-02f, -4.59102765e-02f, -1.72567606e-01f, -3.80965434e-02f, -5.09144887e-02f,
  -1.16954438e-01f, -1.54745176e-01f, 8.86987299e-02f, 1.07085807e-02f, -1.07737817e-02f, 1.22236528e-01f, 1.05872408e-01f, 8.28877166e-02f, -5.06481119e-02f, 5.91024905e-02f,
  1.03519216e-01f, 6.67474419e-02f, 5.56524992e-02f, 4.26932462e-02f, -7.51750097e-02f, 5.03069200e-02f, -2.76548415e-02f, -7.72207836e-03f, 1.46498228e-03f, 9.04381275e-03f,
  1.02538310e-01f, 7.68205225e-02f, -7.00532719e-02f, 4.54560705e-02f, 1.22365199e-01f, -2.95113567e-02f, 3.75799835e-02f, -2.68263184e-02f, -6.77800626e-02f, -1.18328650e-02f,
  -1.54037714e-01f, -3.77735794e-01f, -6.84381574e-02f, 4.02423851e-02f, -1.57794487e-02f, -2.65962295e-02f, 4.55525555e-02f, 5.20317592e-02f, -4.76985574e-02f, 4.46015894e-02f,
  -8.21117982e-02f, -6.18362539e-02f, -1.29393991e-02f, 1.41542435e-01f, 9.81858820e-02f, -4.48576733e-02f, -1.39075816e-01f, -8.21646154e-02f, 3.59765142e-02f, -9.43510383e-02f,
  -8.21308643e-02f, -1.05689712e-01f, -2.43473202e-02f, 7.78804533e-05f, 2.62826756e-02f, 1.60375927e-02f, -3.02605592e-02f, 3.89697403e-03f, 9.91566293e-03f, -4.40325104e-02f,
  3.04315370e-02f, -3.46184224e-02f, -9.56680775e-02f, -1.50309518e-01f, -2.47128800e-01f, -2.72959441e-01f, -3.03180516e-01f, -1.05843000e-01f, 9.53746438e-02f, 5.74720949e-02f,
  -1.14785321e-01f, 2.13186011e-01f, 1.79427654e-01f, -3.15380812e-01f, 1.91181347e-01f, 2.10929126e-01f, -2.45025769e-01f, -9.32975635e-02f, -3.02226357e-02f, -9.17978063e-02f,
  2.29317788e-02f, -3.39961164e-02f, -1.72615442e-02f, -2.08033800e-01f, -2.90376574e-01f, -1.51045159e-01f, 3.60608771e-02f, -2.38938540e-01f, -3.52159500e-01f, -1.10213593e-01f,
  -2.14964896e-01f, 1.42802581e-01f, 1.57095380e-02f, 1.41126942e-03f, -1.34465262e-01f, -8.93520340e-02f, -5.86856306e-02f, 2.20285896e-02f, 7.24662989e-02f, 8.86873305e-02f,
  5.61893620e-02f, 9.20034423e-02f, -6.73181638e-02f, 1.44647971e-01f, -1.12628073e-01f, -7.95185938e-03f, 3.37002240e-03f, -1.92010581e-01f, 1.28066286e-01f, -9.29252505e-02f,
  -1.65898465e-02f, -5.18977158e-02f, 2.13839486e-02f, 4.23844270e-02f, 1.24185532e-02f, -1.31747657e-02f, -4.42876741e-02f, 2.94878315e-02f, -5.95893003e-02f, -7.59641677e-02f,
  1.48091624e-02f, -5.55663854e-02f, -1.26170123e-03f, 1.41446553e-02f, -5.47188409e-02f, -2.26144101e-02f, 1.97936445e-02f, -4.35248986e-02f, 7.33764544e-02f, -5.40568819e-03f,
  1.18171396e-02f, 8.89654234e-02f, -2.98455991e-02f, 3.11670844e-02f, -4.60925698e-02f, 1.26919463e-01f, -4.92244400e-02f, 4.12083901e-02f, -6.90296441e-02f, -4.67052311e-02f,
  1.47871166e-01f, -8.69997144e-02f, 9.07201022e-02f, -5.85766695e-03f, 2.75723003e-02f, 8.11386257e-02f, 6.04432598e-02f, -1.08211106e-02f, 9.12710186e-03f, 4.68648598e-02f,
  -8.61310288e-02f, 4.03043292e-02f, 3.85110565e-02f, 1.38694063e-01f, 2.36232746e-02f, 6.83338866e-02f, -4.75744046e-02f, 6.60248026e-02f, -1.20836839e-01f, 4.64668348e-02f,
  -1.13873342e-02f, -2.70649064e-02f, -1.00653939e-01f, 6.59230351e-02f, 2.08015572e-02f, 2.20467262e-02f, -4.90422957e-02f, 6.41310820e-03f, -2.91227438e-02f, -1.00152679e-01f,
  4.13404703e-02f, 2.06712410e-02f, 2.39248186e-01f, 5.75937219e-02f, 6.67865947e-02f, 8.07359740e-02f, -2.61801742e-02f, 6.77935258e-02f, -3.31759849e-03f, -4.42408882e-02f,
  -2.73901492e-01f, 2.78726906e-01f, 2.11987182e-01f, 4.67825502e-01f, -3.15249294e-01f, -1.91819519e-01f, 2.14103341e-01f, 9.32663977e-02f, 2.51247525e-01f, 2.25456849e-01f,
  -8.70778710e-02f, 1.58588439e-01f, -4.53680120e-02f, 2.20037729e-01f, 1.85405120e-01f, 1.35073707e-01f, 2.21379876e-01f, 1.64113760e-01f, -6.51051942e-03f, 2.00021803e-01f,
  5.50094694e-02f, 1.76200151e-01f, 1.78354129e-01f, -1.41268328e-01f, -5.92966042e-02f, 4.34440561e-03f, 2.53704697e-01f, -4.27836739e-02f, 9.08638351e-03f, -1.01144597e-01f,
  -1.53697059e-01f, 4.88501824e-02f, -1.45815238e-01f, -9.79378745e-02f, -1.06000550e-01f, -1.37935326e-01f, 8.18755031e-02f, -1.28961071e-01f, 5.69632463e-02f, -4.21606004e-02f,
  -1.07373759e-01f, -7.59910792e-02f, -1.34164900e-01f, -4.16376144e-02f, 1.53220724e-02f, 1.18245594e-01f, 1.12479459e-03f, 1.18922153e-02f, 4.37149890e-02f, -9.96524617e-02f,
  -9.25512463e-02f, -5.09412810e-02f, -1.64581536e-04f, 7.06772879e-02f, -3.36940624e-02f, 1.01331957e-02f, 9.81034636e-02f, -5.56001961e-02f, -6.87005073e-02f, 6.01819791e-02f,
  1.10314071e-01f, -1.07377283e-01f, -7.30001181e-03f, 1.82319582e-02f, 6.40334412e-02f, -2.12901141e-02f, 1.60530970e-01f, -7.94755518e-02f, -1.07030282e-02f, -2.93726213e-02f,
  -6.51298314e-02f, 4.37571928e-02f, -3.79426554e-02f, -4.51016426e-02f, 8.53572041e-02f, 6.67663291e-02f, -5.84760085e-02f, -3.43657769e-02f, 2.20783390e-02f, 6.22175634e-02f,
  8.20782259e-02f, 5.14761209e-02f, -1.33595699e-02f, -1.15231097e-01f, 7.94122815e-02f, -1.45029631e-02f, 9.99050140e-02f, 1.32676914e-01f, 2.10262858e-03f, -9.66671202e-03f,
  1.01192668e-01f, 2.12185875e-01f, -3.96020897e-02f, -2.12325260e-01f, 1.12810418e-01f, 5.64989932e-02f, 1.00659303e-01f, -6.01688924e-04f, 1.96488187e-01f, -9.82511137e-03f,
  -1.01253651e-01f, -7.62785524e-02f, -9.00460929e-02f, -3.11563108e-02f, 1.17342561e-01f, 4.42991704e-02f, 7.92274997e-02f, 4.48334217e-02f, 3.63279432e-02f, -1.60971861e-02f,
  6.58130050e-02f, 7.42033646e-02f, 3.57865356e-02f, 4.02887072e-03f, -1.38164699e-01f, -2.32672710e-02f, 9.36784968e-02f, -4.23995256e-02f, -1.34636536e-01f, 9.28088501e-02f,
  1.66550577e-01f, -1.96974009e-01f, 3.12928259e-01f, 1.11409947e-02f, -1.18356887e-02f, 5.85346669e-02f, 2.08529234e-01f, -1.50114089e-01f, 9.06958338e-03f, -2.01819077e-01f,
  1.14846695e-02f, 1.66776806e-01f, 3.54806811e-01f, -2.36425638e-01f, 5.53628147e-01f, 1.56511441e-01f, -1.13197036e-01f, -7.72020444e-02f, -1.29821986e-01f, -9.16912034e-02f,
  -3.85265099e-04f, -2.90179402e-01f, 3.16876099e-02f, -3.88540775e-01f, -2.00220764e-01f, -2.27609366e-01f, -9.52953696e-02f, 1.02000244e-01f, -3.09663922e-01f, 1.02220528e-01f,
  -3.76628965e-01f, -2.63518423e-01f, -8.14675316e-02f, -6.96388930e-02f, -4.89579141e-02f, -3.12632956e-02f, 3.98860909e-02f, 1.26670420e-01f, -4.24343422e-02f, 6.49896264e-02f,
  2.72052102e-02f, -2.12113137e-05f, -8.02395791e-02f, -1.65121967e-03f, -1.55230179e-01f, -4.89473790e-02f, -6.60892576e-02f, -1.22898728e-01f, -1.72654856e-02f, 2.44309288e-02f,
  2.04550605e-02f, -5.28833456e-02f, -3.31367329e-02f, -7.79988393e-02f, 2.30874736e-02f, -1.53760195e-01f, 1.09612599e-01f, 2.28783324e-01f, -3.13530378e-02f, -6.52045831e-02f,
  -4.50094491e-02f, -1.94253412e-03f, 2.07431000e-02f, -7.56011754e-02f, -6.24318467e-03f, -9.57708955e-02f, -6.03672639e-02f, 4.94790189e-02f, -2.20125206e-02f, 2.30025891e-02f,
  9.96218156e-03f, -4.88981567e-02f, -1.01665772e-01f, 1.52101703e-02f, -7.92477131e-02f, 2.06824765e-02f, -3.69087458e-02f, -5.52686118e-02f, -4.09568101e-02f, -5.47161661e-02f,
  9.58989561e-03f, 5.32668605e-02f, -4.49532866e-02f, 1.22925416e-02f, -2.20304145e-03f, 9.38091055e-02f, -1.67057559e-01f, 8.01475495e-02f, -4.07491475e-02f, 1.13766544e-01f,
  -3.26541483e-01f, -3.05274814e-01f, -7.74514899e-02f, -1.78411603e-01f, -1.10312216e-02f, -1.01163127e-01f, 4.77702403e-03f, -1.01486534e-01f, -4.70848493e-02f, 1.14908546e-01f,
  -3.69507894e-02f, -9.57538411e-02f, -3.30744497e-02f, -5.34259602e-02f, -1.03442557e-01f, -1.17033571e-01f, -6.06121235e-02f, -1.43439590e-03f, 1.19556393e-02f, -8.85224044e-02f,
  -1.20967850e-01f, -8.62698853e-02f, 1.85742918e-02f, -1.31435562e-02f, -5.02128899e-02f, 5.88129535e-02f, -9.32902992e-02f, 1.43846599e-02f, 6.00769073e-02f, 2.95158736e-02f,
  -4.09616619e-01f, -5.41981608e-02f, -2.76275963e-01f, -1.99824020e-01f, 5.17374836e-02f, -1.43981591e-01f, -5.83043136e-02f, 1.26240969e-01f, -2.23478571e-01f, 2.01755568e-01f,
  3.58829759e-02f, -2.35065356e-01f, 4.48972695e-02f, -3.15510213e-01f, -4.83083427e-01f, -3.75226796e-01f, -3.73520821e-01f, -2.40447015e-01f, -2.06485897e-01f, 5.05229644e-02f,
  -1.69197783e-01f, -3.06436326e-04f, -1.35780737e-01f, 2.66319126e-01f, 7.08926320e-02f, 1.88607469e-01f, 3.88446093e-01f, 2.52700359e-01f, 1.28302574e-01f, -2.29208842e-02f,
  -1.30298764e-01f, -3.12238615e-02f, 9.10702720e-03f, -1.11934170e-01f, 1.14950649e-01f, 1.06659025e-01f, 6.93457797e-02f, 2.86681689e-02f, -8.39413553e-02f, -3.02834455e-02f,
  3.29267681e-02f, -8.36886540e-02f, 1.49262929e-02f, 9.04280785e-03f, -1.90643054e-02f, -6.83738664e-02f, -1.18452519e-01f, -7.83271622e-03f, -6.33527413e-02f, -2.27361560e-01f,
  -1.25107348e-01f, -8.57835785e-02f, 3.09034325e-02f, 4.12251614e-02f, -7.73026496e-02f, -7.53608048e-02f, -3.83104198e-02f, 1.92760408e-03f, 3.54168043e-02f, -1.05761169e-02f,
  1.44221708e-01f, 6.23626709e-02f, -9.38038751e-02f, -1.70297295e-01f, -2.53708716e-02f, -4.06849571e-02f, 5.15392013e-02f, -2.59127468e-02f, 7.81490356e-02f, 4.35272343e-02f,
  3.19573656e-02f, 5.53161241e-02f, -5.49226142e-02f, 9.05915722e-02f, -3.50820012e-02f, -1.93254985e-02f, 4.29631136e-02f, 1.43433912e-02f, -3.22123384e-03f, 1.40663888e-02f,
  -9.69250128e-03f, -4.68376726e-02f, 2.51344442e-02f, 9.23174843e-02f, -1.70383602e-01f, 8.88868347e-02f, 9.11158845e-02f, -6.23930953e-02f, -1.82002224e-02f, 7.56088719e-02f,
  1.00733988e-01f, 2.58451164e-01f, 4.03292179e-02f, -5.19944355e-02f, 6.56656874e-03f, 3.09558250e-02f, -8.89992788e-02f, -3.21258605e-02f, 1.51066650e-02f, 1.83394831e-03f,
  1.13611236e-01f, 1.18355818e-01f, 7.78817907e-02f, 1.66277625e-02f, 6.22491017e-02f, 7.64838830e-02f, -2.11339816e-02f, 3.33788171e-02f, 1.47765473e-01f, 1.18685238e-01f,
  1.36058375e-01f, 5.16865551e-02f, -1.31022586e-02f, 4.29850630e-02f, 1.17528662e-01f, 1.14368394e-01f, 1.13476686e-01f, 2.76104510e-02f, 2.04481091e-02f, 8.49241838e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.11335972e-01f, 4.39294100e-01f, 1.63745984e-01f, 2.67475843e-01f, 2.34545082e-01f, 3.45893532e-01f, 3.35112572e-01f, 2.93986976e-01f, 3.12573582e-01f, 1.78959966e-01f,
  1.95009708e-01f, 3.79759848e-01f, -4.67990898e-03f, 6.83276877e-02f, 2.79662788e-01f, 2.95840442e-01f, 2.25010723e-01f, 2.27151841e-01f, 2.31050625e-01f, 1.98916450e-01f,
  2.91925013e-01f, 1.96282268e-01f, 1.52289122e-01f, 1.98451266e-01f, 3.07971388e-01f, 2.45522469e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  7.10074380e-02f, 1.95029955e-02f, -3.51395048e-02f, -3.66250388e-02f, 2.31806505e-02f, 1.14284702e-01f, -6.08600862e-02f, -3.34307589e-02f, -2.65891720e-02f, -6.72871768e-02f,
  -1.36919737e-01f, 5.44082671e-02f, 1.47422431e-02f, -6.97314832e-03f, 1.75731465e-01f, -1.49737328e-01f, -2.34157685e-02f, 2.90326923e-02f, 2.42804512e-02f, -1.34947449e-01f,
  8.65894407e-02f, 2.43928745e-01f, -1.52649388e-01f, -3.62567194e-02f, -1.22898705e-01f, 4.53948826e-02f, -1.87318891e-01f, -1.47907972e-01f, 1.55631319e-01f, 2.82756448e-01f,
  1.69105873e-01f, -8.86263251e-02f, 2.02879518e-01f, 4.82343622e-02f, -1.15472093e-01f, -6.48976192e-02f, -2.14951202e-01f, -2.12298542e-01f, 1.30134538e-01f, 2.92709053e-01f,
  2.90398858e-02f, 3.93772013e-02f, 6.91882893e-02f, 2.72725403e-01f, -1.92561761e-01f, 1.62551478e-02f, -1.89248085e-01f, -1.68656394e-01f, 1.23806544e-01f, -5.70675395e-02f,
  -6.11295700e-02f, -2.93832839e-01f, 1.19296052e-01f, 1.63989156e-01f, 5.43133803e-02f, -2.84226149e-01f, -1.75388157e-01f, -1.80973798e-01f, 1.93468437e-01f, -6.54833168e-02f,
  2.34570548e-01f, 1.22611172e-01f, -2.37837303e-02f, -2.25219697e-01f, 1.48047462e-01f, 3.25696990e-02f, 4.60864380e-02f, -4.00167406e-02f, -3.68603319e-02f, 1.43896878e-01f,
  5.14924759e-03f, -7.97899961e-02f, 4.63538356e-02f, 6.44389167e-02f, -8.40206966e-02f, -2.97352411e-02f, -1.28317729e-01f, 6.01731651e-02f, -4.20997255e-02f, 1.23693198e-02f,
  9.80360508e-02f, 3.16619724e-02f, 1.45310715e-01f, 3.31579745e-02f, 1.75414175e-01f, -2.56295979e-01f, 1.97606444e-01f, -7.01552406e-02f, 6.18174560e-02f, -8.14031437e-02f,
  -1.15286909e-01f, -4.77814861e-02f, 1.64501101e-01f, -8.60648081e-02f, 8.79959837e-02f, -1.78684399e-01f, -1.36078253e-01f, -6.57103360e-02f, -1.17634356e-01f, 1.72498447e-04f,
  -1.25501052e-01f, -1.75544783e-01f, -2.27794915e-01f, -1.41054288e-01f, -1.90520152e-01f, -8.13010707e-02f, 1.06515974e-01f, -3.59814577e-02f, 1.68706819e-01f, 3.05456936e-01f,
  2.20101662e-02f, -2.10879883e-03f, -2.06163242e-01f, -2.45858207e-01f, -2.03894094e-01f, 6.41689301e-02f, -3.18205208e-02f, 1.56934366e-01f, -8.87802690e-02f, 1.08922534e-01f,
  -2.64448058e-02f, 2.69758284e-01f, 1.29397735e-01f, -1.72882393e-01f, -1.22019403e-01f, 9.62486193e-02f, -1.62775367e-01f, 7.46699199e-02f, -5.64544182e-03f, 1.15144581e-01f,
  6.53376430e-02f, 8.13221633e-02f, 3.03958729e-02f, -1.35395557e-01f, -1.09979697e-01f, -9.44449231e-02f, 3.71073596e-02f, 9.97987986e-02f, 5.31387329e-02f, 1.38891321e-02f,
  1.22203305e-01f, 7.39109963e-02f, 2.78275721e-02f, 1.38042448e-02f, -2.37059668e-02f, -2.36137569e-01f, 5.21029159e-02f, -1.05663583e-01f, -1.68874398e-01f, -1.22524366e-01f,
  8.11861530e-02f, 2.80019999e-01f, 1.45895615e-01f, -7.27683082e-02f, 1.08442292e-01f, 2.57207453e-01f, -2.12779447e-01f, -1.85481682e-02f, -4.60944921e-02f, 4.10372354e-02f,
  -3.03208441e-01f, 2.64770031e-01f, 3.41764987e-02f, 1.39990762e-01f, 1.81450620e-01f, 5.54841459e-02f, -9.32794213e-02f, -1.41314030e-01f, -4.42543961e-02f, 6.17717393e-02f,
  -7.96465054e-02f, -2.63459653e-01f, 1.49596453e-01f, -2.41031244e-01f, -1.52870081e-02f, 2.51830578e-01f, 1.08913966e-01f, -1.02078386e-01f, 2.09255427e-01f, 5.37338294e-02f,
  8.67974684e-02f, -2.20510826e-01f, 1.96031123e-01f, -2.05019172e-02f, 4.76638414e-03f, -3.05824354e-02f, -5.34807108e-02f, 7.17366934e-02f, 1.02145420e-02f, -2.02049270e-01f,
  1.16510510e-01f, -1.30072339e-02f, -5.80792390e-02f, 1.50902644e-01f, -5.36985807e-02f, 3.03033561e-01f, -3.44336629e-02f, -5.37996888e-02f, 1.13978453e-01f, 1.51616290e-01f,
  -1.41426519e-01f, 4.32641134e-02f, 2.35446438e-01f, 1.64549395e-01f, 1.34914927e-02f, 2.50834855e-03f, -1.18631572e-02f, 9.88273025e-02f, 4.42340821e-02f, -1.58163264e-01f,
  3.25694651e-04f, 1.61502153e-01f, -3.09532564e-02f, -4.63379957e-02f, -2.24049628e-01f, 2.51385659e-01f, 2.67301381e-01f, -8.86712596e-02f, 1.13159418e-01f, 1.91217944e-01f,
  7.96973631e-02f, 9.41091925e-02f, 4.00591157e-02f, 1.23991929e-01f, -3.24230969e-01f, 1.47194386e-01f, 1.08291231e-01f, -4.58095334e-02f, 2.37308908e-02f, 2.36082613e-01f,
  -3.10162604e-02f, 6.28858581e-02f, -3.40997763e-02f, -7.43211508e-02f, -1.39728531e-01f, 1.97862670e-01f, -2.11648513e-02f, -1.99252337e-01f, 1.94886029e-01f, 1.23929426e-01f,
  -1.04957491e-01f, 1.32397771e-01f, -1.67851627e-01f, -2.21538603e-01f, 8.96451101e-02f, -1.22835927e-01f, 6.29116446e-02f, -8.45598150e-03f, 9.18927565e-02f, -2.98921224e-02f,
  6.98848665e-02f, 2.02173367e-03f, -5.21070510e-02f, -2.34092548e-01f, 5.60919978e-02f, 2.66303271e-01f, -2.09023550e-01f, 4.22796011e-02f, 6.22931831e-02f, 1.54778108e-01f,
  -5.83515093e-02f, 4.26480845e-02f, 9.28698853e-03f, 7.78887346e-02f, 8.37750882e-02f, 1.48525953e-01f, -3.84192467e-02f, -3.74370888e-02f, 1.43388569e-01f, -1.79775506e-02f,
  1.99387092e-02f, 1.46005442e-02f, 5.61855547e-02f, 1.52873024e-01f, -1.85975939e-01f, 2.75586307e-01f, -1.44833207e-01f, 1.00272283e-01f, 9.67783779e-02f, 8.07928517e-02f,
  1.47612011e-02f, 1.01037376e-01f, 1.80248037e-01f, 1.71811879e-01f, 1.49436016e-02f, 1.25134036e-01f, -5.22710849e-03f, 4.82909344e-02f, 2.05468554e-02f, -2.16910601e-01f,
  1.74193397e-01f, 3.46657485e-02f, 1.04601659e-01f, -1.12710379e-01f, -1.19459696e-01f, -4.17458080e-02f, -7.47744739e-02f, -1.34681419e-01f, -2.05636159e-01f, -1.24158800e-01f,
  7.52472654e-02f, 2.52705127e-01f, 1.98527738e-01f, 1.71120986e-01f, 1.88119784e-02f, 3.50917093e-02f, -2.08041463e-02f, 1.82790726e-01f, -2.27581635e-01f, -8.08606446e-02f,
  1.42136943e-02f, 4.03658897e-02f, 1.01003222e-01f, -1.97243392e-01f, -1.94717184e-01f, -2.48891041e-02f, -5.75684756e-02f, -9.20588523e-02f, 1.14711471e-01f, -1.86324239e-01f,
  7.94041604e-02f, 8.78788158e-02f, 5.97461574e-02f, 1.31672531e-01f, -5.38145751e-02f, 1.15281992e-01f, -5.74086607e-03f, 9.77994800e-02f, 3.65782417e-02f, 1.51674569e-01f,
  -4.27104793e-02f, 1.95513200e-02f, 9.58158672e-02f, 1.64046243e-01f, -8.98521319e-02f, 1.10505335e-01f, -1.02964379e-01f, 2.44962405e-02f, -2.11512268e-01f, 1.84185117e-01f,
  -1.27224281e-01f, 3.34465951e-01f, -7.40771741e-02f, 5.44621386e-02f, -2.87673473e-01f, 3.42940018e-02f, 1.58843324e-01f, -1.32261977e-01f, 2.10656583e-01f, 7.21810982e-02f,
  1.72704965e-01f, 1.84483826e-01f, 2.65873104e-01f, -2.30619743e-01f, 1.12613991e-01f, -1.51119247e-01f, -1.60551861e-01f, -1.79449335e-01f, 2.42297024e-01f, 7.93150887e-02f,
  4.72482992e-03f, 1.68488353e-01f, -1.27753124e-01f, 8.07171166e-02f, -1.68801039e-01f, 3.54451896e-03f, 1.44934580e-02f, -3.77354212e-02f, -1.00106075e-01f, 1.83481108e-02f,
  2.30857149e-01f, -1.20205106e-02f, -2.20713779e-01f, -7.33830184e-02f, -7.44224340e-02f, -1.08922325e-01f, 3.59533690e-02f, -2.32080057e-01f, -2.03128397e-01f, 2.19587833e-02f,
  2.26928458e-01f, 7.55263120e-02f, -7.81644583e-02f, -1.59935936e-01f, -9.45895016e-02f, 2.94677876e-02f, 9.62085575e-02f, 1.15781523e-01f, 1.51599109e-01f, 3.03300563e-02f,
  -5.66109195e-02f, -3.09304018e-02f, -5.46950940e-03f, 1.18212346e-02f, -6.24780394e-02f, -1.62611771e-02f, -1.11102186e-01f, 4.72212918e-02f, 1.72110945e-01f, 1.25201672e-01f,
  -4.25263941e-02f, 1.16214678e-01f, 9.99428518e-03f, -1.69418857e-01f, 8.10011569e-03f, 1.81285411e-01f, 2.47567803e-01f, -1.76848471e-01f, -5.09025231e-02f, 1.59227937e-01f,
  2.10300460e-01f, -6.25688136e-02f, 5.56508042e-02f, -8.46741498e-02f, 2.40563944e-01f, -6.91214278e-02f, 2.40943745e-01f, -1.92377582e-01f, 1.08190477e-01f, 9.68207642e-02f,
  -2.20239073e-01f, -3.23234834e-02f, -1.64641201e-01f, 1.62419111e-01f, 3.23295631e-02f, 1.19530395e-01f, -8.04006532e-02f, 1.49714932e-01f, -1.18535623e-01f, -7.51122981e-02f,
  -1.71983108e-01f, 1.96562707e-01f, -5.94309457e-02f, 1.37749642e-01f, 6.08429536e-02f, 9.32018459e-02f, -9.57222879e-02f, -1.05115019e-01f, -4.86735888e-02f, -1.53157711e-01f,
  -1.27790585e-01f, -3.54122639e-01f, -1.19218290e-01f, -1.54355153e-01f, 1.23533390e-01f, 1.36926565e-02f, 1.40968844e-01f, -1.98573202e-01f, -1.50303170e-01f, 7.17321858e-02f,
  1.22652121e-01f, 7.73248076e-02f, -1.00599237e-01f, 1.36713143e-02f, 1.88958853e-01f, 5.66821322e-02f, 9.27127227e-02f, 2.25451395e-01f, -5.47215194e-02f, -6.37225658e-02f,
  1.15845844e-01f, -1.23046860e-01f, -5.09170294e-02f, -8.18513185e-02f, 1.44091636e-01f, -1.77666515e-01f, -8.08611438e-02f, 1.47412848e-02f, -1.09714538e-01f, 1.18745975e-01f,
  -1.56119794e-01f, 2.41941839e-01f, -7.39521012e-02f, -8.13698396e-02f, 2.71088421e-01f, 2.55434424e-01f, -1.14803903e-01f, 1.81813255e-01f, 1.31437063e-01f, 1.03612401e-01f,
  -1.75636895e-02f, -2.39265323e-01f, 1.65519148e-01f, 9.90782455e-02f, 1.95533678e-01f, -2.60364920e-01f, -3.77615192e-03f, -4.31919768e-02f, -4.04359028e-02f, -4.73438315e-02f,
  -1.84291914e-01f, -1.61968291e-01f, 4.67998944e-02f, 1.67568639e-01f, -3.09914630e-02f, 6.54185191e-02f, 1.76082611e-01f, -1.08684100e-01f, -9.15092304e-02f, 1.51957767e-02f,
  -3.95083316e-02f, -1.08381003e-01f, 2.58459061e-01f, -1.72617778e-01f, 2.04250649e-01f, -2.46746793e-01f, -9.23029706e-02f, 2.17960462e-01f, 2.05874220e-02f, -1.38058841e-01f,
  1.96774136e-02f, -1.44139156e-01f, -1.18194513e-01f, 8.21959376e-02f, 1.05465911e-01f, 2.10752115e-02f, -1.61463037e-01f, 8.06606188e-02f, -2.92287599e-02f, -2.02827621e-02f,
  1.63391218e-01f, 2.08256632e-01f, -1.65900484e-01f, -1.54273048e-01f, 1.02142878e-02f, 6.90160319e-02f, 4.00143154e-02f, -1.23690583e-01f, -1.07995942e-01f, -1.99616745e-01f,
  4.50137407e-02f, 1.84912518e-01f, 1.84865639e-01f, -1.93056092e-01f, 1.07721895e-01f, -2.76110079e-02f, 1.53495446e-02f, 7.43326172e-02f, 1.38595691e-02f, 1.99035600e-01f,
  1.04511008e-01f, -1.60298586e-01f, 8.42966884e-02f, 8.55914131e-02f, 1.06361426e-01f, -1.84490770e-01f, 5.71197346e-02f, -1.27760485e-01f, 1.28161892e-01f, -2.04779208e-01f,
  1.69116899e-01f, 3.86270019e-03f, 2.88531557e-02f, -1.40194222e-01f, -1.47203151e-02f, -1.97702244e-01f, 2.45015815e-01f, 2.64988422e-01f, -6.67239055e-02f, -6.89387023e-02f,
  -1.32325262e-01f, -3.23365003e-01f, -2.35425338e-01f, -5.86511344e-02f, 3.03652138e-01f, -1.44381505e-02f, -9.13807899e-02f, 1.29063353e-01f, 1.45740464e-01f, -4.75529544e-02f,
  -1.97705552e-01f, -6.51790798e-02f, -8.25180709e-02f, 1.93960026e-01f, -9.63793769e-02f, -1.59529731e-01f, -7.76711777e-02f, -1.09481364e-01f, 1.84877235e-02f, 1.06142789e-01f,
  5.25128134e-02f, -9.92010757e-02f, -7.50433514e-03f, -1.03096880e-01f, -1.54966516e-02f, -3.51163037e-02f, -2.36970372e-02f, 6.33830503e-02f, -3.47211175e-02f, 1.19968288e-01f,
  1.47831544e-01f, 6.59566000e-02f, 2.49053668e-02f, 1.07655540e-01f, 1.05566651e-01f, -2.86124736e-01f, -1.67236507e-01f, 5.04861660e-02f, 1.13689035e-01f, -4.95074724e-04f,
  1.00888811e-01f, 5.33882454e-02f, -2.30053186e-01f, 1.67987972e-01f, -1.24336712e-01f, 1.39974773e-01f, 1.26565725e-01f, -1.49859004e-02f, 3.97214070e-02f, 2.37409472e-01f,
  -6.67323098e-02f, 1.68436959e-01f, -1.81244612e-01f, -4.55908291e-02f, -1.79566126e-02f, 1.16703480e-01f, 6.57814965e-02f, 3.44597676e-04f, -2.20873058e-02f, 9.77703333e-02f,
  2.04566736e-02f, -3.15491199e-01f, -1.35393903e-01f, -8.64433404e-03f, 5.96221462e-02f, 1.64660782e-01f, -2.64851265e-02f, -7.39318356e-02f, 9.94652286e-02f, -9.04860795e-02f,
  2.43454844e-01f, -1.89073771e-01f, -2.91368842e-01f, -2.48527274e-01f, 1.71847805e-01f, 1.52654529e-01f, 9.86070558e-02f, -2.13384911e-01f, 2.59334236e-01f, -1.27336621e-01f,
  2.18044907e-01f, -8.55066180e-02f, 9.87721607e-03f, -6.87193945e-02f, 3.70565094e-02f, 1.17477342e-01f, 7.26248175e-02f, 6.10574707e-02f, -7.91952386e-02f, -5.99801466e-02f,
  1.66555233e-02f, 1.08116053e-01f, 6.90328553e-02f, 3.21519524e-02f, -5.57228178e-02f, -5.25484607e-03f, -3.35754827e-02f, 1.89335644e-01f, -1.26087256e-02f, 1.12728246e-01f,
  1.05483495e-01f, 3.41711566e-02f, 1.18099257e-01f, -2.65935272e-01f, -2.00304836e-01f, -8.30063522e-02f, 1.37728993e-02f, -1.37199372e-01f, 2.50634283e-01f, 1.01622298e-01f,
  1.03722066e-01f, -1.29121780e-01f, 8.66711959e-02f, 9.18052625e-03f, -2.27819741e-01f, 9.65134501e-02f, -2.04843894e-01f, 8.64315778e-02f, -7.21878931e-02f, 7.67973810e-02f,
  -1.92005664e-01f, 3.89720201e-02f, 2.62976676e-01f, 1.00177616e-01f, 9.01390538e-02f, 2.25530952e-01f, 1.48171261e-01f, -1.40343174e-01f, -5.82284331e-02f, -2.67206002e-02f,
  8.76351669e-02f, 1.23656869e-01f, -1.21650815e-01f, 9.74516720e-02f, -1.64637059e-01f, 4.58032452e-02f, -2.10125506e-01f, 6.21514246e-02f, 8.18960965e-02f, -1.66533157e-01f,
  1.24882653e-01f, 8.29991922e-02f, -1.01475976e-01f, -8.74798968e-02f, -1.03041172e-01f, -9.32443067e-02f, -4.81214980e-03f, 1.03801183e-01f, -6.60915673e-02f, 8.94066505e-03f,
  1.00727923e-01f, 2.14966442e-02f, 7.31422156e-02f, 1.21282078e-01f, -6.90842867e-02f, -7.20828306e-03f, 1.56353697e-01f, -8.39952473e-03f, -9.95690674e-02f, 1.18210822e-01f,
  -9.04529616e-02f, -7.21058473e-02f, -9.89455208e-02f, 9.64662284e-02f, -2.18998969e-01f, 1.74482211e-01f, -1.24525681e-01f, 8.74876082e-02f, 7.43558928e-02f, 1.54414818e-01f,
  -2.62294300e-02f, 5.96219338e-02f, -6.44357800e-02f, 6.52859360e-03f, 3.25267799e-02f, 5.05217239e-02f, 1.02398090e-01f, -1.24167658e-01f, 1.80474862e-01f, 5.62790632e-02f,
  8.93835425e-02f, -2.53001750e-01f, 1.71992272e-01f, -1.17939733e-01f, 1.49290189e-01f, -4.81289327e-02f, -1.98766798e-01f, -1.33609865e-02f, -1.65638283e-01f, 2.16371357e-01f,
  -8.44140649e-02f, -1.26496591e-02f, 2.13165179e-01f, -6.72736317e-02f, -1.53794825e-01f, 6.54850900e-02f, 3.82321095e-03f, -1.84272796e-01f, 1.51233181e-01f, -7.39671988e-03f,
  2.57248461e-01f, -2.35439122e-01f, -2.01221064e-01f, 1.48890331e-01f, -3.73933552e-04f, 5.14140166e-02f, 1.46787196e-01f, -1.57509685e-01f, 4.07728776e-02f, 1.85019299e-02f,
  -5.25231697e-02f, -3.70115153e-02f, 1.39374241e-01f, -2.85924170e-02f, 6.50182664e-02f, 2.11401395e-02f, -4.76455688e-03f, 5.83215654e-02f, 5.10459691e-02f, 4.34420109e-02f,
  -7.20711201e-02f, 8.29976052e-02f, 9.90366265e-02f, 1.31165057e-01f, -3.26167839e-03f, 5.89320958e-02f, 1.00381367e-01f, -2.02221662e-01f, -9.01886225e-02f, 7.68552199e-02f,
  1.93030134e-01f, -3.03078115e-01f, -1.94158569e-01f, -4.98971604e-02f, -7.38440380e-02f, -2.14016929e-01f, 4.47693355e-02f, 1.81721166e-01f, 1.15554042e-01f, -1.37659341e-01f,
  3.37603062e-01f, -3.09639405e-02f, -1.86517671e-01f, 1.63901821e-01f, -2.46813074e-01f, -1.60342678e-01f, -1.04889952e-01f, 1.24892287e-01f, -6.58942163e-02f, 3.71002965e-02f,
  1.35302991e-01f, 9.11585093e-02f, -4.95450199e-02f, -1.19807608e-01f, -2.32927099e-01f, 4.12221849e-02f, 5.90559207e-02f, 2.05932006e-01f, -6.09705746e-02f, 4.88855615e-02f,
  -4.23828438e-02f, 5.25946394e-02f, 2.69611552e-02f, -1.62722930e-01f, -1.16268381e-01f, 7.50014409e-02f, 9.40843374e-02f, -2.66032852e-02f, 2.89759248e-01f, 8.30618069e-02f,
  2.51109302e-01f, -3.31483364e-01f, -1.02296649e-02f, 1.19438827e-01f, 9.46158692e-02f, 9.07777697e-02f, 4.97262664e-02f, 1.43720955e-02f, 1.46788478e-01f, 6.36726618e-02f,
  2.56952167e-01f, 2.77927130e-01f, -8.03861469e-02f, 3.80829349e-02f, 1.33976728e-01f, 1.01263396e-01f, 1.90736093e-02f, -5.77802286e-02f, 8.82935971e-02f, -5.53138033e-02f,
  -5.19706123e-02f, -1.42494723e-01f, -2.14588553e-01f, 1.29061555e-02f, -1.52097613e-01f, 3.15099299e-01f, -1.99856892e-01f, -1.14793524e-01f, 2.76960909e-01f, 2.16638759e-01f,
  -2.19815135e-01f, 1.58563301e-01f, 2.13978752e-01f, -5.35732284e-02f, 5.66537529e-02f, -2.90513504e-02f, -4.19990607e-02f, 8.81894082e-02f, 6.05115816e-02f, -3.54343623e-01f,
  5.99876046e-02f, -2.26778686e-02f, -1.61770359e-01f, 1.71604469e-01f, 4.14146185e-02f, -1.84201375e-01f, -1.05852947e-01f, -2.37612650e-02f, -5.07790446e-02f, 1.75256327e-01f,
  2.03141049e-01f, -1.34266049e-01f, 4.95295897e-02f, -9.53795910e-02f, -1.47088587e-01f, -4.72727865e-02f, 2.40598500e-01f, -2.21755475e-01f, 2.38438532e-01f, -1.03002883e-01f,
  -7.40578473e-02f, 1.25329167e-01f, 1.47698045e-01f, -1.28924474e-01f, 7.47004822e-02f, -8.45801085e-03f, -1.16719782e-01f, 1.36289999e-01f, -1.05784662e-01f, 9.42280293e-02f,
  -3.16340029e-02f, 1.38871565e-01f, 1.66623741e-01f, -1.19373677e-02f, 9.51023772e-02f, -1.76774850e-03f, 1.08367465e-01f, -2.71520577e-03f, 1.15848646e-01f, 5.95775135e-02f,
  1.20190755e-01f, -6.31788522e-02f, 1.65869266e-01f, -2.47652214e-02f, -8.36419538e-02f, 1.21824875e-01f, -1.87826902e-01f, 1.78491637e-01f, -2.69528002e-01f, 2.50873268e-01f,
  1.13876417e-01f, -9.10016522e-02f, -3.63243632e-02f, -3.37854214e-03f, -5.90095408e-02f, 2.62342095e-01f, -1.53928816e-01f, 8.17404762e-02f, -8.80273581e-02f, -7.08265156e-02f,
  5.89804910e-02f, -7.13895559e-02f, 1.28432035e-01f, -6.83734939e-02f, -6.36889786e-02f, -1.23234197e-01f, -8.44443275e-04f, 2.14513332e-01f, -3.04562002e-01f, -8.25087726e-02f,
  -2.09185869e-01f, -7.27444366e-02f, 1.57088801e-01f, -1.34101614e-01f, 1.55341938e-01f, 9.19271037e-02f, 1.74249373e-02f, -2.68317144e-02f, -1.75119221e-01f, -2.61072069e-01f,
  6.06102236e-02f, 2.81345900e-02f, 5.80464192e-02f, -1.57671630e-01f, -1.01851270e-01f, 2.23993644e-01f, -2.31806159e-01f, 2.44114250e-02f, -1.45921618e-01f, 1.66088790e-01f,
  6.11200407e-02f, 1.04877783e-03f, 1.15721099e-01f, -7.96218589e-02f, 5.33561073e-02f, -7.79093429e-02f, -1.31588519e-01f, 2.06129551e-02f, -3.16255018e-02f, -9.05443430e-02f,
  1.01009212e-01f, -1.03105545e-01f, -1.22067528e-02f, 3.91834192e-02f, -2.33669989e-02f, -7.72014121e-03f, -1.33003607e-01f, -2.31320411e-02f, 3.19739729e-01f, -2.19818816e-01f,
  1.83629751e-01f, -2.28463635e-01f, 1.50132895e-01f, 2.13124184e-03f, 2.69107640e-01f, 1.58185400e-02f, 3.18566076e-02f, 6.67317957e-02f, -5.87216988e-02f, -2.51837224e-01f,
  6.14318112e-03f, -1.76872984e-01f, 1.79536995e-02f, 3.40420514e-01f, -1.32286936e-01f, 2.04357356e-01f, -1.08575732e-01f, 1.70287237e-01f, 6.02674522e-02f, -6.35479689e-02f,
  -4.98514660e-02f, -1.90621108e-01f, 1.69714719e-01f, -9.00468901e-02f, 2.96052337e-01f, -1.55422026e-02f, -2.35569701e-01f, 1.97962150e-01f, -4.64595668e-02f, -1.28985614e-01f,
  -1.65638313e-01f, 4.36266214e-02f, 2.80051947e-01f, 1.27814293e-01f, 1.22277714e-01f, 8.06262121e-02f, -2.04030544e-01f, 1.60675451e-01f, 1.81670487e-01f, 7.77045786e-02f,
  4.85912189e-02f, 9.62202847e-02f, 1.00795673e-02f, 1.79962322e-01f, 1.04549341e-01f, 7.91268498e-02f, -8.96513462e-02f, -5.51059060e-02f, 3.85704264e-02f, 8.82765502e-02f,
  2.01002490e-02f, 1.01040870e-01f, 1.30400687e-01f, 7.88114369e-02f, 1.11431973e-02f, -2.79423757e-03f, 1.20732710e-01f, 5.75388141e-04f, 4.69441935e-02f, -1.02289818e-01f,
  3.40740271e-02f, 4.65059746e-03f, 1.68196023e-01f, 2.07603592e-02f, 2.09081382e-03f, -1.74373329e-01f, 7.95524269e-02f, -6.55412078e-02f, 1.90425247e-01f, -2.56113827e-01f,
  -2.04148382e-01f, 1.31654605e-01f, -1.12414531e-01f, -7.35282600e-02f, -7.99199343e-02f, -9.70558673e-02f, 1.09216377e-01f, 5.56611605e-02f, -2.07491919e-01f, -9.45591601e-04f,
  3.89684667e-03f, -8.44044685e-02f, -8.19102451e-02f, 1.48756921e-01f, -2.54857272e-01f, 1.53974324e-01f, -6.03967123e-02f, 3.81321684e-02f, 2.48207718e-01f, -9.18828547e-02f,
  1.61795482e-01f, -1.37662008e-01f, -4.99288440e-02f, -1.50789563e-02f, -2.58568287e-01f, -5.86485900e-02f, -1.06828220e-01f, -6.61435574e-02f, 2.11038187e-01f, 1.02499090e-01f,
  -6.22451790e-02f, -8.49812180e-02f, 1.45579830e-01f, 1.47177368e-01f, -6.03825040e-02f, -1.93874806e-01f, -3.15886848e-02f, -2.10040417e-02f, 3.38532031e-02f, -4.25282791e-02f,
  7.74263293e-02f, 1.16893172e-01f, 5.41621931e-02f, 1.05834499e-01f, 1.20306015e-01f, 7.43206143e-02f, 1.82499707e-01f, 1.20721512e-01f, 4.97309305e-02f, 4.34761457e-02f,
  1.59562021e-01f, -1.51338369e-01f, 1.91092312e-01f, 1.70725528e-02f, 2.80426532e-01f, 4.70697731e-02f, 3.05829197e-02f, -9.40129012e-02f, -1.38077155e-01f, 2.84013990e-02f,
  1.56160131e-01f, -8.70324150e-02f, -3.78379896e-02f, -2.18633890e-01f, -6.20948859e-02f, -2.80003637e-01f, 7.88929611e-02f, 2.42141321e-01f, 2.04485625e-01f, -2.44255573e-01f,
  4.12124582e-02f, 2.33417433e-02f, -1.52983278e-01f, 2.21815467e-01f, -1.31486878e-01f, -2.72896349e-01f, -1.23762511e-01f, -8.31203461e-02f, -2.40092427e-01f, 6.51589110e-02f,
  -7.27590322e-02f, 9.46651101e-02f, -1.16631202e-01f, -4.06038985e-02f, -8.31416324e-02f, 6.36881636e-03f, 5.52098379e-02f, -5.26750647e-02f, -5.32770157e-02f, -1.68718994e-01f,
  -6.66462630e-02f, -9.00290087e-02f, 7.10487813e-02f, -2.16977298e-01f, 2.46746819e-02f, 1.13010146e-01f, 6.41512647e-02f, 9.77035686e-02f, -8.07132944e-02f, -2.18593270e-01f,
  -5.57950102e-02f, 6.33027926e-02f, -1.11914061e-01f, 2.81520728e-02f, 4.66085300e-02f, 1.10941291e-01f, -2.94435099e-02f, 9.81973037e-02f, 1.56067580e-01f, 7.76376054e-02f,
  1.06577694e-01f, 8.68848264e-02f, -1.31611899e-01f, -1.15356028e-01f, -8.93673897e-02f, 2.82065645e-02f, 2.89035402e-02f, -1.41118720e-01f, -8.06282908e-02f, -2.69093096e-01f,
  -1.71203852e-01f, 1.19634241e-01f, 1.16172425e-01f, -2.87306197e-02f, -2.96699405e-01f, 1.56393319e-01f, 2.22229678e-02f, 2.56698728e-02f, 1.72150955e-01f, -7.31879398e-02f,
  3.24262567e-02f, 1.53758377e-01f, -1.96785510e-01f, -1.11946650e-01f, -2.37044960e-01f, 5.01179285e-02f, -3.04243993e-02f, -2.18547344e-01f, 1.37700001e-02f, -1.60909116e-01f,
  2.23142236e-01f, -7.95507431e-02f, 6.39401525e-02f, 8.13819319e-02f, 8.50524828e-02f, -6.30214661e-02f, -1.57526433e-01f, 1.04167931e-01f, -1.50696009e-01f, -9.15988982e-02f,
  5.87163121e-02f, -1.67693138e-01f, 1.38888493e-01f, -2.15125710e-01f, 1.26193032e-01f, 5.37029207e-02f, 8.05661231e-02f, 1.45002559e-01f, 1.94573700e-01f, 1.98765516e-01f,
  -3.55716906e-02f, 1.96335495e-01f, -3.84598747e-02f, 6.87701479e-02f, -1.77919865e-01f, 2.44101286e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.35525018e-01f, 3.03777400e-02f, 2.68622190e-01f, 3.28456722e-02f, 1.16453022e-02f, 1.34728715e-01f, 5.65097965e-02f, 8.55769217e-02f, -7.13625476e-02f, -1.16061978e-01f,
  3.10596414e-02f, 2.30086640e-01f, -7.91312978e-02f, 2.17402756e-01f, 8.76729563e-02f, 6.28098175e-02f, -5.73399961e-02f, 6.30566254e-02f, 1.84950382e-01f, 1.86640412e-01f,
  3.16245288e-01f, 2.99456090e-01f, -2.69769341e-01f, -1.48987576e-01f, -1.85275227e-01f, 2.87622690e-01f, -1.46646976e-01f, -3.75350267e-01f, 3.80327374e-01f, -6.14675432e-02f,
  1.29760399e-01f, 5.61921336e-02f, -8.36450234e-02f, 1.22737847e-02f, -1.42723173e-01f, -1.09232716e-01f, -2.28954256e-01f, 3.17007333e-01f, 4.02869880e-01f, 3.19841236e-01f,
  3.78197461e-01f, 1.61093334e-03f, 4.43075567e-01f, 4.38699931e-01f, -3.94810468e-01f, 3.60260084e-02f, -1.88569605e-01f, -2.54122242e-02f, -2.44009078e-01f, 2.26236973e-02f,
  3.47560257e-01f, 1.76993713e-01f, 1.95980608e-01f, 4.66283113e-01f, -4.52606291e-01f, 3.18508297e-01f, 3.01639773e-02f, 1.78539574e-01f, 2.04745725e-01f, -3.20020229e-01f,
  5.36376476e-01f, 3.08689415e-01f, -2.18652096e-02f, 8.95342454e-02f, 1.50257528e-01f, 2.35742763e-01f, 1.99444920e-01f, 2.78917283e-01f, 3.02313473e-02f, 1.25265226e-01f,
  1.98478714e-01f, 2.32637689e-01f, 8.21510330e-03f, 2.50713199e-01f, 3.10085773e-01f, 1.96875453e-01f, 1.11497127e-01f, 8.39489698e-02f, 2.50828624e-01f, 1.28709599e-01f,
  4.62433286e-02f, -2.43334770e-01f, 1.74902275e-01f, 2.31749371e-01f, 1.59034893e-01f, -9.94034037e-02f, -2.54502743e-01f, 3.06934178e-01f, 5.16678430e-02f, -1.80834889e-01f,
  -1.24692217e-01f, 1.65068239e-01f, 2.75409847e-01f, -7.58210421e-02f, -8.70251283e-02f, 1.44144610e-01f, -3.60247701e-01f, 4.26375717e-02f, -7.94735700e-02f, -8.62927660e-02f,
  1.07569106e-01f, 1.47965282e-01f, -8.81341174e-02f, 3.32347870e-01f, 8.55504423e-02f, -7.56986141e-02f, 1.77110270e-01f, 3.48018467e-01f, 2.73150742e-01f, -2.41209596e-01f,
  4.17037666e-01f, 6.65911585e-02f, -2.43216842e-01f, 1.29269762e-02f, -1.86767746e-02f, -2.31589511e-01f, 2.00581640e-01f, 9.36864689e-02f, 1.11114025e-01f, 2.48946607e-01f,
  1.92291677e-01f, 1.09678335e-01f, 3.31875980e-01f, 1.63348883e-01f, -2.90787131e-01f, -2.88691431e-01f, -2.99181908e-01f, 6.82801753e-02f, 1.78155810e-01f, 3.10990810e-01f,
  9.38381851e-02f, 1.40399486e-01f, 2.10130617e-01f, 1.66411459e-01f, 3.02296072e-01f, 1.21654175e-01f, 2.46640816e-01f, 1.57106966e-01f, 8.85418802e-02f, 2.55482167e-01f,
  6.46700636e-02f, 2.26848006e-01f, 2.75315523e-01f, 2.28452146e-01f, 1.91449761e-01f, 1.24014020e-01f, 8.11323002e-02f, -2.52391547e-01f, -1.09150440e-01f, 4.30372566e-01f,
  -3.58670056e-01f, -9.15250555e-02f, -4.21098530e-01f, -3.07380259e-01f, -2.72193849e-01f, -2.33389363e-01f, -8.53901282e-02f, 1.80680409e-01f, 2.51284033e-01f, 1.71438530e-01f,
  1.81077391e-01f, -3.87020439e-01f, 1.48574607e-02f, -1.31808236e-01f, -1.17455497e-01f, -3.09778571e-01f, 4.37767923e-01f, 4.39470291e-01f, 4.50194865e-01f, 4.18965042e-01f,
  -1.58098534e-01f, 3.91484261e-01f, 2.18608826e-02f, -5.79495616e-02f, -2.04029039e-01f, -3.39336246e-01f, 2.69912720e-01f, 2.13751882e-01f, -2.51811504e-01f, -4.74882334e-01f,
  3.54265183e-01f, 2.15208203e-01f, 1.98217437e-01f, -2.61955529e-01f, 2.82673091e-02f, -4.39806581e-01f, 1.61767721e-01f, 3.78202111e-01f, -5.06122634e-02f, 1.94384918e-01f,
  9.01172087e-02f, -1.82591647e-01f, -2.57776324e-02f, 1.21278390e-01f, 2.69617915e-01f, 2.65096098e-01f, 2.10226595e-01f, 3.57612997e-01f, 2.96402633e-01f, 1.24158621e-01f,
  1.74706712e-01f, 1.06897525e-01f, 2.74358273e-01f, 3.07576120e-01f, 2.14918897e-01f, 1.06172785e-01f, 1.72687769e-01f, 2.44770005e-01f, 2.90805846e-01f, 8.02787915e-02f,
  -2.20712140e-01f, 2.79039621e-01f, -2.74493903e-01f, 4.00187284e-01f, -3.54121059e-01f, -7.76852667e-02f, -3.28488111e-01f, -1.42159179e-01f, 2.56045282e-01f, -2.33305320e-01f,
  8.95275101e-02f, 3.13461930e-01f, 2.53050476e-01f, 3.51955414e-01f, 1.95870638e-01f, -5.08200943e-01f, 3.75827134e-01f, -2.39143208e-01f, 2.04624645e-02f, -4.15362775e-01f,
  1.21565863e-01f, 2.89808586e-02f, -1.42432258e-01f, 3.14518332e-01f, -3.38738263e-01f, 2.29321375e-01f, -3.48010600e-01f, 2.67249167e-01f, 3.98610711e-01f, -2.03335196e-01f,
  2.13471159e-01f, 1.63578212e-01f, -2.20045205e-02f, -2.55592972e-01f, -2.43365228e-01f, -4.14291829e-01f, -9.35323313e-02f, 2.86944751e-02f, 4.31533366e-01f, -2.18480751e-01f,
  -2.80948788e-01f, 8.85009468e-02f, 2.07278170e-02f, 1.81929797e-01f, -1.44210279e-01f, -2.51447320e-01f, 7.23194629e-02f, 2.18011275e-01f, -2.73650289e-02f, -6.58701286e-02f,
  9.67772231e-02f, 1.61764488e-01f, 1.62357450e-01f, 1.85024261e-01f, 1.39346823e-01f, -1.20058237e-02f, 1.68492123e-02f, 3.59886745e-03f, -1.37048721e-01f, 4.33042943e-02f,
  4.33523841e-02f, 1.51388854e-01f, 4.01821025e-02f, -6.90515060e-03f, 1.10039890e-01f, -4.58246142e-01f, -9.66258496e-02f, 4.68401939e-01f, -3.42016518e-01f, -4.05611932e-01f,
  -3.08131427e-02f, 1.77147686e-01f, -9.42900404e-02f, -3.44818473e-01f, -2.83822641e-02f, 7.14178160e-02f, -1.51637599e-01f, 1.18252290e-02f, 1.86244592e-01f, -9.46022049e-02f,
  -4.82295714e-02f, -3.95582825e-01f, 5.27559631e-02f, -5.11990823e-02f, 5.07328331e-01f, 4.54701215e-01f, 2.56762922e-01f, 5.46256185e-01f, 4.07611728e-01f, 6.07554376e-01f,
  -3.30413878e-01f, 4.35817614e-03f, -3.76208156e-01f, -2.84897685e-01f, 4.20662910e-01f, 3.55988026e-01f, 2.47978061e-01f, 1.87666923e-01f, 3.85600120e-01f, 2.68518716e-01f,
  4.54612046e-01f, -2.68390447e-01f, -1.82454824e-01f, 1.10223234e-01f, 2.51512289e-01f, 4.32273209e-01f, 3.90957952e-01f, 1.60677180e-01f, 8.80481377e-02f, 5.65553308e-02f,
  -4.31285240e-02f, 2.64169872e-01f, 1.10223815e-01f, 3.65907967e-01f, 2.44813949e-01f, 5.91466613e-02f, 2.56585479e-01f, 9.43648294e-02f, 1.77959621e-01f, 2.53586441e-01f,
  3.07716846e-01f, 1.04941204e-01f, 3.07243675e-01f, 1.52056694e-01f, 2.77899235e-01f, 1.66191459e-01f, 1.61981732e-01f, 7.95714855e-02f, -4.54770774e-02f, -2.25110352e-01f,
  -4.12364662e-01f, -5.35323098e-02f, -3.76429647e-01f, 3.64783376e-01f, 4.03912485e-01f, 1.56093046e-01f, 1.17866188e-01f, 1.66945443e-01f, -4.23066467e-01f, 2.24683359e-01f,
  -2.03883737e-01f, 1.52565822e-01f, -2.95462191e-01f, 6.32334873e-02f, 2.84305215e-01f, 1.98049620e-02f, 2.48812571e-01f, -2.07931623e-01f, 2.42879570e-01f, -2.19931498e-01f,
  -2.25110520e-02f, 2.67320126e-01f, -3.86987329e-01f, -2.55609602e-01f, -2.44182438e-01f, -1.53421000e-01f, 3.32361877e-01f, 5.66280894e-02f, 4.37364846e-01f, 4.31090087e-01f,
  2.47123279e-02f, 1.43971182e-02f, -1.22438498e-01f, -4.06876117e-01f, 3.42973620e-01f, 1.66596286e-02f, 3.18590641e-01f, -8.80848989e-02f, 1.09969936e-02f, 4.43563312e-01f,
  -1.83533266e-01f, -1.36818722e-01f, 2.58844674e-01f, 5.34856677e-01f, 2.99928963e-01f, 1.92191690e-01f, 6.69204146e-02f, 2.18981341e-01f, 2.53358096e-01f, 1.85816780e-01f,
  2.11162046e-01f, 2.63050079e-01f, 8.15482512e-02f, 1.41149923e-01f, 3.34901154e-01f, 3.50838035e-01f, 2.49685422e-01f, 1.97069392e-01f, 1.37946367e-01f, 2.07953602e-01f,
  2.19212323e-01f, 2.41525292e-01f, 1.33206919e-01f, 4.93195206e-01f, 1.54613495e-01f, -9.21311229e-02f, 9.36357230e-02f, -1.14144288e-01f, -2.55785495e-01f, -4.14262950e-01f,
  -2.55655706e-01f, 6.75029308e-02f, 3.84245127e-01f, -1.51998207e-01f, -1.58459902e-01f, 2.62597531e-01f, -1.44279510e-01f, -1.86553925e-01f, -1.17772765e-01f, -2.38706797e-01f,
  4.86899689e-02f, 3.23197752e-01f, -1.91676512e-01f, 4.55068856e-01f, -1.77732155e-01f, 3.62716734e-01f, -9.34195966e-02f, 3.58532816e-01f, 4.61030453e-01f, 4.96160030e-01f,
  5.77124655e-01f, -1.11910038e-01f, -2.75615901e-01f, 2.04049990e-01f, -2.21195459e-01f, 1.07700422e-01f, -8.08655545e-02f, 4.99519072e-02f, -4.54235345e-01f, 2.43014053e-01f,
  1.53884187e-01f, 1.12773247e-01f, 1.51374027e-01f, -4.04715449e-01f, -2.55281806e-01f, 1.52412757e-01f, -9.36064944e-02f, 1.76823303e-01f, -7.41764903e-03f, 2.19620168e-01f,
  1.32842571e-01f, 2.71102875e-01f, 2.32891947e-01f, 1.74891457e-01f, 1.01177052e-01f, 1.84492573e-01f, 2.54788339e-01f, 3.88402641e-01f, 1.11470006e-01f, 2.53532410e-01f,
  2.83111274e-01f, 2.07448274e-01f, 3.12179059e-01f, 4.20408957e-02f, 6.90916181e-02f, -5.44486493e-02f, 2.82094311e-02f, -2.62265205e-01f, -2.63068914e-01f, 2.32575506e-01f,
  3.45763424e-03f, 2.76181698e-01f, -9.72794145e-02f, 7.38491416e-02f, 2.78679937e-01f, 3.37957352e-01f, -2.84138709e-01f, 2.99809992e-01f, 2.70017833e-01f, -3.10767833e-02f,
  7.14732036e-02f, -1.42167792e-01f, -7.85354301e-02f, 2.40037784e-01f, 1.16540767e-01f, -4.35966700e-01f, -1.07987389e-01f, 2.14912012e-01f, 4.26169187e-02f, 1.05228983e-01f,
  9.61590409e-02f, -3.52890909e-01f, 3.59494150e-01f, 7.03743519e-03f, -3.87041457e-02f, 3.70543897e-01f, 2.85061479e-01f, 1.44484922e-01f, 2.97677100e-01f, 3.31565857e-01f,
  7.34892115e-02f, -1.46783531e-01f, 3.74862760e-01f, -7.88275748e-02f, 3.62380326e-01f, -1.45748809e-01f, -1.88216567e-01f, 4.36013192e-01f, 2.09701508e-01f, -1.90868452e-01f,
  4.33265358e-01f, -2.85422921e-01f, 5.42534180e-02f, 4.44160141e-02f, 3.64015736e-02f, 1.53334942e-02f, 1.53140262e-01f, 1.50030300e-01f, 1.61188841e-01f, 2.28141099e-01f,
  1.66094467e-01f, 1.51647730e-02f, 3.03096604e-02f, 1.26144230e-01f, 1.67291358e-01f, 1.84710115e-01f, 7.49689266e-02f, 1.74796760e-01f, 1.49423435e-01f, 1.85342774e-01f,
  3.33263695e-01f, -4.40652370e-01f, -1.90321133e-02f, 8.97937361e-03f, 3.22396368e-01f, -2.55833745e-01f, 6.29324317e-02f, -1.20860875e-01f, -2.44144037e-01f, 1.09885089e-01f,
  -2.21576378e-01f, 3.17846924e-01f, 2.08419085e-01f, -3.61400843e-01f, 2.80300472e-02f, 1.86604410e-01f, -4.21839446e-01f, 1.94635481e-01f, -2.02234089e-01f, -2.01497450e-01f,
  -9.46103707e-02f, 3.68821591e-01f, -2.58119375e-01f, 1.07342906e-01f, 4.39776599e-01f, 2.19394222e-01f, 3.42126489e-01f, -5.10735363e-02f, -4.46608156e-01f, 2.92525828e-01f,
  1.91386476e-01f, 1.09730653e-01f, 3.65649238e-02f, 1.44401491e-01f, 4.34279852e-02f, 4.30842638e-01f, 3.52654189e-01f, 1.21486709e-01f, -8.91220123e-02f, 2.07020640e-01f,
  2.12746605e-01f, 7.61426762e-02f, 1.64549172e-01f, -3.05404037e-01f, 3.84076893e-01f, -2.40920871e-01f, -1.96113181e-03f, 2.95358449e-01f, 1.79931536e-01f, 3.67217898e-01f,
  1.26581252e-01f, 1.95428561e-02f, 1.88027009e-01f, 1.67135254e-01f, 2.29555331e-02f, 3.00743073e-01f, 1.83457524e-01f, 9.43224132e-02f, 2.60260385e-02f, 1.62583649e-01f,
  3.03975046e-01f, 6.39964119e-02f, 1.65455952e-01f, -2.17757061e-01f, 3.04103851e-01f, -2.09170371e-01f, -2.32506528e-01f, -2.76611477e-01f, -1.63182616e-01f, 4.12356526e-01f,
  2.34760433e-01f, -1.62730202e-01f, 3.68637256e-02f, 4.45017099e-01f, 8.91614519e-03f, 8.82077068e-02f, -6.34872392e-02f, 1.74910754e-01f, -3.80523354e-01f, 2.42790103e-01f,
  -3.53005715e-02f, 1.22368082e-01f, 2.25396499e-01f, -1.11912422e-01f, -9.87665281e-02f, 2.06385463e-01f, -3.61609198e-02f, -9.67607126e-02f, -2.52726092e-03f, -4.30078665e-03f,
  2.06866786e-01f, -2.06222504e-01f, 1.43339589e-01f, 3.70844364e-01f, 1.51550621e-01f, 2.13493049e-01f, -1.59817651e-01f, -2.33309582e-01f, 1.51767433e-01f, 5.59007451e-02f,
  4.44494665e-01f, -5.79176173e-02f, 2.74347723e-01f, 6.65443912e-02f, 2.67239064e-01f, 4.50253874e-01f, -1.98680297e-01f, -3.31326962e-01f, 6.20302372e-02f, 1.04221903e-01f,
  1.63822725e-01f, 1.88294858e-01f, 2.75384188e-01f, 2.35695705e-01f, 2.78387964e-01f, 2.16778651e-01f, 2.83836454e-01f, 1.87145740e-01f, 1.93061545e-01f, 2.21019924e-01f,
  2.81688988e-01f, 4.36139666e-02f, 1.64741486e-01f, 8.46232623e-02f, 1.51104003e-01f, 3.13936770e-01f, 1.56589866e-01f, 4.95449565e-02f, -9.86634567e-02f, -4.58527543e-02f,
  -2.63191551e-01f, 4.40265417e-01f, -1.95819259e-01f, -5.41362129e-02f, -3.56181234e-01f, 1.74352258e-01f, 3.18312615e-01f, -9.52372234e-03f, 5.70017993e-02f, 2.60277152e-01f,
  3.42511207e-01f, 2.42737293e-01f, 3.08092058e-01f, -3.10013473e-01f, 2.42983997e-01f, 1.50689073e-02f, -9.39087272e-02f, -2.54423261e-01f, -2.21723896e-02f, 2.95630306e-01f,
  1.16177894e-01f, 3.02936941e-01f, -2.67513487e-02f, 9.27950889e-02f, -2.68423080e-01f, 8.92127901e-02f, 4.86931838e-02f, 1.64328758e-02f, 3.42045218e-01f, 2.15201378e-01f,
  4.32157069e-01f, 1.02335788e-01f, -3.24743062e-01f, -2.75613666e-01f, 4.80786897e-02f, -2.91655183e-01f, 3.10507029e-01f, -3.27955157e-01f, 1.60439834e-02f, 1.25591978e-01f,
  3.56996059e-01f, 5.54240942e-02f, 3.59630197e-01f, -3.10269266e-01f, -4.99353569e-04f, 7.55591020e-02f, 9.94491130e-02f, 9.14009437e-02f, 3.35437320e-02f, 9.92572978e-02f,
  1.53472349e-01f, 2.13236004e-01f, 1.79522067e-01f, 2.22606659e-01f, 4.74873781e-02f, 1.18430845e-01f, 3.18023413e-01f, 4.08798680e-02f, 1.79336801e-01f, 9.97796804e-02f,
  2.09799662e-01f, 2.57827789e-01f, 2.74688691e-01f, 1.20518602e-01f, -3.87280993e-02f, -4.51429188e-02f, 1.76733851e-01f, -2.07866460e-01f, 1.83538452e-01f, 1.26851857e-01f,
  -1.07759170e-01f, 1.18206210e-01f, -3.04895103e-01f, 4.26274166e-02f, 1.09706759e-01f, -2.40500614e-01f, 3.53807449e-01f, -7.26052746e-02f, -1.24091670e-01f, 2.85391361e-01f,
  -4.20048051e-02f, -3.83858174e-01f, -1.53638154e-01f, -3.32037918e-03f, -3.29796731e-01f, -3.12835962e-01f, 1.12007163e-01f, -4.16259766e-02f, 4.02466059e-01f, 4.03625190e-01f,
  -8.23354647e-02f, 4.01019394e-01f, 1.62951514e-01f, 4.09373119e-02f, -1.48249894e-01f, 1.26238205e-02f, -1.25055462e-02f, 4.55382764e-02f, 2.19182372e-01f, 3.05345774e-01f,
  2.19433685e-03f, -7.80923814e-02f, -2.31205523e-01f, 2.06229202e-02f, -1.70783307e-02f, 1.39359564e-01f, 3.92554164e-01f, -3.07964802e-01f, 4.07756686e-01f, 2.53122181e-01f,
  9.67769995e-02f, 3.27888480e-03f, 2.44612917e-01f, 3.19426715e-01f, 2.59379536e-01f, 1.27813295e-01f, 1.25611231e-01f, 8.70871320e-02f, 1.72486007e-01f, 1.20321207e-01f,
  1.21133342e-01f, 2.27141276e-01f, 1.08763240e-01f, 3.77177536e-01f, 3.15363228e-01f, 2.83994466e-01f, 3.43467832e-01f, 2.32693270e-01f, 2.17661589e-01f, -2.28356235e-02f,
  3.86316001e-01f, -3.76169950e-01f, -2.35433295e-01f, -3.81539762e-01f, -1.18744463e-01f, -3.91077876e-01f, 3.65013331e-01f, 3.20366770e-01f, 1.35825202e-01f, -5.46938041e-03f,
  2.70152569e-01f, -2.99628735e-01f, -1.78027526e-01f, -5.68155460e-02f, -3.55438858e-01f, -2.48773500e-01f, -2.49561384e-01f, 4.70031083e-01f, -1.58234537e-01f, 3.16771507e-01f,
  3.68770152e-01f, 4.87210751e-01f, 2.92957306e-01f, 4.27966624e-01f, 2.62599085e-02f, -3.50836724e-01f, -7.05619752e-02f, 5.93929738e-02f, -3.43985975e-01f, -2.64459491e-01f,
  3.82911824e-02f, 3.73697013e-01f, -1.37061104e-01f, 3.84046175e-02f, -1.73800260e-01f, 2.65586048e-01f, 2.90811479e-01f, -2.20839128e-01f, -4.97041903e-02f, 1.56164333e-01f,
  -9.08778757e-02f, 8.66079256e-02f, 7.04474896e-02f, 1.41127735e-01f, 1.67783603e-01f, -7.94569924e-02f, -1.12979770e-01f, 2.22670108e-01f, 1.64438426e-01f, 2.06009462e-01f,
  -4.01349440e-02f, 7.32218102e-02f, -2.93443985e-02f, 7.44463876e-02f, 1.85555056e-01f, 1.95783421e-01f, 8.90735388e-02f, 1.65320579e-02f, 2.45204289e-02f, -5.32173887e-02f,
  -1.83756873e-02f, 3.57884794e-01f, 3.44300479e-01f, -1.90964729e-01f, -1.10530265e-01f, 3.02929908e-01f, 1.59699783e-01f, 1.32731497e-01f, -1.83021173e-01f, 3.30203384e-01f,
  -3.12501937e-01f, -1.89848587e-01f, -3.85038704e-01f, 2.11516246e-01f, -3.06639314e-01f, -3.22356343e-01f, 1.05161428e-01f, -3.11845511e-01f, 3.81879866e-01f, -2.11066976e-01f,
  2.40426481e-01f, -2.89602309e-01f, 3.12503517e-01f, -3.98348629e-01f, 3.05775572e-02f, -2.03910038e-01f, 3.70205075e-01f, 1.31602243e-01f, 2.52928346e-01f, 1.43479109e-01f,
  -1.13717504e-01f, -3.21130544e-01f, -6.43087551e-02f, 2.19050840e-01f, 4.43778455e-01f, 2.74286538e-01f, -2.71490384e-02f, 4.98521060e-01f, 3.47605526e-01f, -1.26766771e-01f,
  -3.26053947e-01f, 2.01295733e-01f, -1.29824802e-01f, 2.35822529e-01f, -3.53658706e-01f, -1.50439233e-01f, 7.88349956e-02f, 9.79657397e-02f, 2.47326896e-01f, 6.54212087e-02f,
  -3.17704305e-02f, 2.47860283e-01f, 4.55168523e-02f, 2.22152516e-01f, 2.01037094e-01f, 2.62177229e-01f, 2.51208335e-01f, 2.18153968e-01f, 2.94350535e-01f, 1.16554923e-01f,
  4.55457270e-02f, 3.31391618e-02f, 7.63898492e-02f, 1.72851369e-01f, -5.70662459e-03f, 4.72522229e-01f, 3.07445645e-01f, -2.56201893e-01f, -6.09577112e-02f, 3.38839829e-01f,
  2.24349678e-01f, -2.00418979e-01f, -2.76488245e-01f, -1.01742707e-02f, -1.67155638e-01f, -1.28328562e-01f, -3.30666035e-01f, -9.10269246e-02f, -4.47078288e-01f, 1.53090522e-01f,
  -6.80377334e-02f, -1.27677903e-01f, 2.59752721e-01f, 1.62498161e-01f, 1.63311064e-01f, -7.82720596e-02f, 2.20907122e-01f, -3.54154527e-01f, 5.85362203e-02f, 8.93842801e-02f,
  3.68927658e-01f, -4.83426228e-02f, 2.30463147e-01f, 2.46100321e-01f, -3.90406549e-01f, -3.95039678e-01f, 1.57143548e-01f, -6.02753647e-02f, 2.99092174e-01f, 2.49950781e-01f,
  -1.33416027e-01f, 4.43104833e-01f, 1.75613612e-01f, 3.76053393e-01f, 3.26174647e-01f, -2.75161564e-01f, -2.33081996e-01f, 6.05391935e-02f, -3.85136187e-01f, 2.92196602e-01f,
  -3.74829099e-02f, 2.46734377e-02f, 3.17952633e-02f, -3.25513929e-02f, -1.58540323e-01f, -2.45498233e-02f, -3.25424336e-02f, 1.59206033e-01f, -5.64063957e-04f, 4.21583615e-02f,
  1.68111309e-01f, 2.43632287e-01f, -1.79641712e-02f, 1.67125881e-01f, -7.97143131e-02f, 3.08808517e-02f, 2.20928825e-02f, 1.38455555e-01f, -9.03374609e-03f, 2.27696478e-01f,
  1.19002007e-01f, 5.65748662e-02f, 9.64455381e-02f, 2.09366181e-03f, 3.35096925e-01f, 2.54825771e-01f, -1.64338320e-01f, 9.28855166e-02f, -1.47421747e-01f, -2.53512800e-01f,
  -3.02604258e-01f, 1.07672252e-01f, -8.99567381e-02f, -2.87134618e-01f, 2.10375980e-01f, -1.93518654e-01f, 3.81328344e-01f, -8.25504884e-02f, -7.77755901e-02f, 6.45358562e-02f,
  -4.10639122e-02f, -4.72473562e-01f, 3.17470461e-01f, 3.88827831e-01f, 2.80359894e-01f, 3.04712772e-01f, 4.21724737e-01f, 9.25951600e-02f, -3.00691903e-01f, 7.88436309e-02f,
  -7.55969360e-02f, 3.03296059e-01f, -1.68486193e-01f, 1.69436693e-01f, -1.95856303e-01f, 5.35196960e-01f, 2.94751763e-01f, 5.33721596e-02f, 5.22047542e-02f, -5.05726635e-02f,
  -1.49102077e-01f, 2.20615007e-02f, -2.01130375e-01f, -2.19820872e-01f, 9.99987647e-02f, 2.28535891e-01f, 1.97876975e-01f, -6.74287183e-03f, 4.00254279e-02f, 2.60301858e-01f,
  2.53649563e-01f, 2.72615850e-01f, 1.54233202e-01f, 1.42342970e-01f, 1.40318349e-01f, 6.97719455e-02f, -4.62624654e-02f, 1.77779391e-01f, 7.46947974e-02f, -2.57057548e-02f,
  2.92813592e-02f, -9.03579816e-02f, 3.03160518e-01f, 2.86121339e-01f, 3.69571000e-01f, -2.61170924e-01f, 2.69793272e-01f, 5.44662103e-02f, -1.82906583e-01f, -1.30108684e-01f,
  -4.33571413e-02f, 2.41842687e-01f, -9.56792831e-02f, -2.16458023e-01f, 5.85119799e-02f, -1.25891030e-01f, -6.27928525e-02f, -3.36236596e-01f, -1.22243725e-01f, -1.42841280e-01f,
  -1.97425280e-02f, -3.54180694e-01f, 1.31237224e-01f, 1.12204060e-01f, 3.11784536e-01f, -1.04749382e-01f, 3.34415495e-01f, -4.16008756e-02f, 5.69474459e-01f, 3.96957785e-01f,
  -9.66764316e-02f, 8.10696185e-02f, -9.98533890e-02f, -4.04049575e-01f, 6.75898269e-02f, 1.70938149e-01f, 7.11018622e-01f, 4.10491914e-01f, 5.12972055e-03f, 3.96724582e-01f,
  2.18111619e-01f, 4.68477234e-02f, -5.46462536e-02f, -9.14656669e-02f, -5.59458174e-02f, 5.07882774e-01f, -1.35403052e-01f, -4.35239136e-01f, 1.37316957e-01f, 2.11199299e-01f,
  2.45064437e-01f, 2.46748552e-01f, 1.21749118e-02f, -2.15368606e-02f, 1.84219867e-01f, 2.48932600e-01f, -3.18552740e-02f, 1.81481987e-01f, 1.99025318e-01f, 1.12523451e-01f,
  -6.15335722e-03f, 2.93931276e-01f, 2.17868447e-01f, 2.42882684e-01f, -4.43834476e-02f, 4.25237641e-02f, 4.52525526e-01f, -1.35547876e-01f, -1.90708026e-01f, -3.28249425e-01f,
  2.72416919e-01f, 1.39459819e-01f, 3.11159879e-01f, 6.00288138e-02f, 2.66427100e-01f, 3.70488524e-01f, 8.06474015e-02f, -1.56568497e-01f, 2.88193017e-01f, 9.80711207e-02f,
  2.50559986e-01f, 1.47785962e-01f, 7.16670463e-03f, 3.58141780e-01f, 1.34044141e-01f, 8.59327689e-02f, -8.29140022e-02f, 5.10554790e-01f, 6.75903410e-02f, -4.11445081e-01f,
  -4.61155958e-02f, 1.41828939e-01f, 3.88878912e-01f, -3.02286685e-01f, 4.34339494e-02f, 5.05477369e-01f, 4.50878628e-02f, 3.70003700e-01f, -3.95805627e-01f, -4.88178544e-02f,
  4.91693258e-01f, -1.44897759e-01f, 2.19708815e-01f, -3.19277197e-01f, -3.75308916e-02f, -3.05847853e-01f, 1.09857254e-01f, 1.96685255e-01f, -1.44657284e-01f, -2.15810202e-02f,
  2.48877764e-01f, -3.49730909e-01f, 2.20707133e-01f, 2.38522634e-01f, 2.32547775e-01f, 2.78233647e-01f, 2.48775154e-01f, -4.28324379e-03f, 1.78743571e-01f, 4.20361310e-02f,
  2.14253962e-01f, 2.33953193e-01f, 2.19112262e-01f, 1.29340678e-01f, 2.33373046e-01f, 1.47010148e-01f, 6.67883381e-02f, 3.50719452e-01f, 1.12357795e-01f, 3.26255262e-01f,
  1.48399606e-01f, 2.94935256e-01f, 1.32237613e-01f, -3.05461407e-01f, 5.03961921e-01f, -2.29062513e-02f, -3.72799188e-02f, 2.39638850e-01f, 3.77432853e-01f, 3.51774305e-01f,
  -7.83138424e-02f, -2.92562842e-01f, 1.06088221e-01f, 9.94271412e-02f, 2.05344856e-01f, -3.51529419e-02f, 1.23958781e-01f, 1.64291739e-01f, 4.76834327e-02f, 6.29793201e-03f,
  -3.85320395e-01f, -8.97805691e-02f, -8.49029049e-02f, 5.96271232e-02f, 7.69257098e-02f, -6.24072611e-01f, 1.58812642e-01f, 5.06830096e-01f, 3.76635224e-01f, 3.80333304e-01f,
  -1.41813725e-01f, -7.44444039e-03f, 7.94443786e-02f, 3.44444513e-01f, -9.18984413e-02f, -1.25339970e-01f, -1.86983824e-01f, 2.17660204e-01f, 1.30532876e-01f, 8.51728842e-02f,
  -1.37171537e-01f, -1.63175315e-01f, 2.50679851e-01f, 2.57261872e-01f, 2.35298321e-01f, -5.77398725e-02f, 2.54300863e-01f, 2.02969864e-01f, 1.10588387e-01f, 1.45982519e-01f,
  2.46464178e-01f, 3.66465934e-02f, 2.64826715e-01f, 9.71638262e-02f, 8.37651268e-02f, 2.24734321e-01f, 2.04929247e-01f, -2.56710369e-02f, 3.67771357e-01f, -2.01818324e-03f,
  2.96309561e-01f, 9.34939384e-02f, 2.30124205e-01f, 1.00775614e-01f, 2.71919578e-01f, -3.20224345e-01f, -1.46493837e-01f, -4.26416874e-01f, 7.86873549e-02f, 2.79771954e-01f,
  4.57640179e-02f, -2.64952362e-01f, -5.23138344e-02f, 1.80391669e-01f, -1.15093149e-01f, 2.30586827e-01f, 1.50665238e-01f, -2.01672927e-01f, -8.23708773e-02f, 4.72684562e-01f,
  -3.65154296e-01f, 3.79721642e-01f, -2.69241750e-01f, -8.57906044e-03f, 2.10729823e-01f, 2.22263150e-02f, 1.47030532e-01f, -4.23831865e-02f, 8.43596756e-02f, -3.87523090e-03f,
  2.85920560e-01f, -4.32055205e-01f, -1.70607775e-01f, 2.25810632e-01f, 2.50536174e-01f, -2.13166744e-01f, -3.20682377e-01f, -3.76287848e-01f, 4.76804018e-01f, 1.12026602e-01f,
  4.60055262e-01f, -7.66786784e-02f, -2.45025635e-01f, 3.49572212e-01f, 2.59006649e-01f, 3.00370514e-01f, -2.16293529e-01f, -2.91299880e-01f, 7.44481459e-02f, 4.42797512e-01f,
  1.86378226e-01f, 2.04069540e-01f, 9.41801220e-02f, 5.80665059e-02f, 4.69841585e-02f, 2.40137368e-01f, 2.62626618e-01f, 1.34323418e-01f, 1.88457556e-02f, 8.06296468e-02f,
  9.43002775e-02f, 7.50515759e-02f, 9.54185203e-02f, 3.09292406e-01f, 2.41476461e-01f, 1.37295619e-01f, -7.18568861e-02f, 1.47116214e-01f, 2.59223342e-01f, -9.17091072e-02f,
  2.99072444e-01f, -1.09600022e-01f, 8.43832362e-03f, 3.94812711e-02f, -3.73743773e-01f, -1.74804732e-01f, -3.36952448e-01f, -3.80448729e-01f, 2.10837334e-01f, 7.27577060e-02f,
  -9.79004502e-02f, -4.10377145e-01f, -3.33891988e-01f, 4.73609060e-01f, -4.12559003e-01f, -2.61332914e-02f, -3.40510666e-01f, 2.93038785e-01f, 2.19541520e-01f, 3.64176303e-01f,
  3.86598587e-01f, 3.58240008e-02f, 4.62982386e-01f, 3.53977561e-01f, 1.29650980e-01f, -4.42744464e-01f, -3.40006709e-01f, 1.49122536e-01f, -2.46472225e-01f, -3.26764613e-01f,
  2.68009037e-01f, 1.44421503e-01f, 3.24600428e-01f, 3.13622892e-01f, -1.53334051e-01f, 1.30101770e-01f, -1.82519794e-01f, 4.45615590e-01f, 4.80124533e-01f, -2.54822701e-01f,
  2.59991020e-01f, 4.30178531e-02f, -1.31613478e-01f, 3.83483171e-01f, 1.81429222e-01f, 2.94060916e-01f, -4.46703844e-02f, 1.28666893e-01f, 1.25189796e-01f, 1.22272253e-01f,
  1.82818353e-01f, 1.51929080e-01f, 1.79208905e-01f, 2.20150173e-01f, 5.27409427e-02f, -2.25945879e-02f, 2.27528229e-01f, -1.37053668e-01f, 2.75788039e-01f, 2.20492288e-01f,
  1.99848749e-02f, 1.30652040e-01f, 2.29628205e-01f, -1.88004836e-01f, -1.60449296e-01f, -8.25258270e-02f, -2.98572153e-01f, 1.53735772e-01f, 9.60337222e-02f, -7.77276158e-02f,
  -3.89722176e-02f, -2.89753944e-01f, 1.51738092e-01f, -1.00887038e-01f, -2.58987308e-01f, 3.01985025e-01f, 3.91782038e-02f, 2.31664300e-01f, 2.40597770e-01f, -3.04933369e-01f,
  2.05111593e-01f, 4.33553010e-01f, 2.69986987e-01f, 6.54592365e-02f, 2.75937140e-01f, 5.47284901e-01f, -5.13514459e-01f, 1.16618700e-01f, -4.75808829e-01f, -2.92675883e-01f,
  2.18237862e-01f, -2.21025363e-01f, 4.09693927e-01f, 3.61122608e-01f, -2.70552725e-01f, -3.50981563e-01f, 2.81805813e-01f, -7.34238252e-02f, 1.04759663e-01f, -1.98994055e-01f,
  -3.19027841e-01f, 1.90968309e-02f, 2.10681915e-01f, 2.24691674e-01f, -1.68858737e-01f, 2.40881041e-01f, 1.21952891e-01f, 3.20992500e-01f, 1.02724433e-01f, 2.36192539e-01f,
  3.94613057e-01f, -2.55031958e-02f, 4.69966605e-02f, 8.53699073e-02f, 1.50988117e-01f, 6.35961816e-02f, 2.35769808e-01f, 2.88304925e-01f, 1.32754996e-01f, 1.55293092e-01f,
  2.37647384e-01f, 3.42991173e-01f, 9.08931345e-02f, 3.56510341e-01f, 7.14074671e-02f, 3.86208236e-01f, 3.41904134e-01f, 3.12090814e-01f, -1.92444846e-02f, -2.69998789e-01f,
  3.58181983e-01f, -2.43309379e-01f, 3.18209082e-02f, 4.57694918e-01f, 1.43276244e-01f, 5.72049171e-02f, 7.39125069e-04f, -2.37508342e-01f, 1.47208944e-01f, 7.68767893e-02f,
  4.79430497e-01f, -2.82487094e-01f, 1.54153630e-01f, 8.80305991e-02f, 8.10703039e-02f, -1.23387463e-01f, 1.49695635e-01f, 1.88146811e-02f, 4.53172952e-01f, -3.06684256e-01f,
  -7.09523931e-02f, -2.53348529e-01f, 5.38891971e-01f, 5.28040409e-01f, 1.07221594e-02f, 3.90964866e-01f, -1.63417250e-01f, -5.63003297e-04f, -3.00400376e-01f, 2.76412338e-01f,
  2.61614561e-01f, 2.76171565e-01f, -5.03413640e-02f, 2.63444990e-01f, 5.68792783e-02f, -4.03302044e-01f, -2.93114841e-01f, -3.51090223e-01f, 1.51178449e-01f, 4.95297343e-01f,
  3.66155326e-01f, -2.24453539e-01f, 1.54433072e-01f, 2.15723380e-01f, 8.94494262e-03f, 1.70124084e-01f, 2.92992413e-01f, 3.14021796e-01f, 3.15598726e-01f, 2.15588599e-01f,
  2.15027213e-01f, 2.05310985e-01f, 1.28349513e-01f, 7.98215568e-02f, 1.95071414e-01f, 3.71050090e-02f, 1.94226548e-01f, 2.77065057e-02f, 2.16581658e-01f, -2.11739391e-02f,
  -1.26375809e-01f, 3.57254222e-02f, -1.65175274e-02f, -1.38965711e-01f, -4.48433965e-01f, 4.49391335e-01f, -4.61503305e-02f, -1.37793109e-01f, 1.24353871e-01f, -4.50440869e-02f,
  -1.48220003e-01f, 1.42306253e-01f, -3.87903541e-01f, 2.22544432e-01f, -1.45803511e-01f, 1.47873074e-01f, 2.78382391e-01f, -1.68345258e-01f, 3.29024494e-01f, 8.22561607e-02f,
  3.44287217e-01f, -4.15844768e-01f, 3.52587432e-01f, 6.18944526e-01f, -4.19796735e-01f, -2.43960932e-01f, -4.34086353e-01f, 7.80906901e-02f, 3.64375144e-01f, -2.72249192e-01f,
  3.91907036e-01f, 6.52741864e-02f, 4.11162600e-02f, -3.01230013e-01f, 2.39841312e-01f, -1.55866280e-01f, 5.11776879e-02f, 9.24571306e-02f, 1.55693084e-01f, 1.75165832e-01f,
  3.16862343e-03f, 4.71525699e-01f, -4.00680929e-01f, 2.00417012e-01f, -2.94866711e-01f, 4.51639742e-01f, 9.76406876e-03f, -6.79126531e-02f, 5.51785640e-02f, 2.42441595e-01f,
  2.64837354e-01f, 2.83805579e-01f, 2.10601896e-01f, 2.22484723e-01f, 3.00924629e-01f, 1.37627572e-01f, 3.45149487e-02f, 2.77191222e-01f, 4.12677765e-01f, 1.20725729e-01f,
  2.32007071e-01f, 2.70960927e-01f, 3.53021324e-01f, 1.93824783e-01f, 2.22947776e-01f, -2.82909244e-01f, -3.36524189e-01f, 2.98623562e-01f, 9.80191231e-02f, -1.18751563e-01f,
  1.25560969e-01f, -9.89852771e-02f, -1.43595159e-01f, -9.56342965e-02f, -3.05503100e-01f, 4.61855590e-01f, 1.53281331e-01f, -1.12953261e-01f, 3.73944372e-01f, -1.22006491e-01f,
  -6.87294826e-02f, 2.92108893e-01f, -4.55490649e-02f, -3.55982244e-01f, -1.16091862e-01f, 2.82811016e-01f, -4.45856810e-01f, 1.41414136e-01f, -2.54843622e-01f, 1.93960473e-01f,
  2.52853930e-01f, 1.02697201e-02f, 1.64145216e-01f, 2.75236279e-01f, 3.43791097e-01f, 3.02983195e-01f, -2.87676811e-01f, 6.11575581e-02f, -5.22560418e-01f, -3.40663046e-01f,
  3.18774164e-01f, -2.14910150e-01f, -1.07921712e-01f, -1.78335443e-01f, -1.27565771e-01f, 5.19380607e-02f, -5.18894792e-02f, -1.85965419e-01f, 3.32169145e-01f, -1.06537431e-01f,
  1.84434190e-01f, 2.32145891e-01f, 3.64673585e-01f, 2.90677249e-01f, 1.79379731e-01f, 3.64929736e-02f, 1.95117742e-02f, 2.02467322e-01f, 1.49615988e-01f, 2.01492399e-01f,
  1.37217358e-01f, 7.39785507e-02f, 5.86301573e-02f, 2.83711642e-01f, 1.14254281e-01f, 2.82737434e-01f, -3.94629762e-02f, 3.64243150e-01f, 1.14923269e-01f, -1.93104059e-01f,
  -4.48185019e-02f, -1.60988778e-01f, 4.87586290e-01f, -2.27219984e-01f, -1.79986849e-01f, 3.89143407e-01f, 2.11674735e-01f, -1.01677924e-01f, 1.78486615e-01f, 1.70805287e-02f,
  4.15218085e-01f, -3.27440172e-01f, 3.40896785e-01f, 3.20406288e-01f, -6.83222665e-03f, 3.79913658e-01f, -1.68325126e-01f, 1.84586551e-02f, -1.20904528e-01f, 2.59390436e-02f,
  -9.31843072e-02f, -8.76262784e-02f, 5.05771279e-01f, -2.81411916e-01f, 3.10767502e-01f, 1.83151007e-01f, -2.55797088e-01f, 2.58759171e-01f, -1.50177106e-01f, 6.94737062e-02f,
  9.06779692e-02f, 2.82775879e-01f, -7.75645077e-02f, 2.32198194e-01f, -9.35304968e-04f, -8.89781490e-02f, 5.34333810e-02f, 2.95476019e-01f, 1.16494574e-01f, -3.78286272e-01f,
  3.30387473e-01f, 1.40029430e-01f, 2.93219328e-01f, 4.73733060e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.37200081e-01f, 8.84375870e-02f, 1.05073340e-01f, 2.49780580e-01f, 1.44695401e-01f, 3.29778403e-01f, 1.56090230e-01f, 1.88750729e-01f, 1.11584015e-01f, 1.32090494e-01f,
  2.23671585e-01f, 7.05313310e-02f, 2.81072080e-01f, 2.04763874e-01f, 8.82547796e-02f, 1.46124408e-01f, 2.33842283e-01f, 8.51155445e-02f, 3.10915411e-01f, 1.76120132e-01f,
  1.23231508e-01f, 9.28749666e-02f, 1.38191372e-01f, 1.39525756e-01f, 1.02283478e-01f, 1.81471154e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -2.72433758e-01f, -2.61208415e-01f, 5.78853264e-02f, -1.83888435e-01f, 1.04920901e-01f, 9.64261405e-03f, 1.20530114e-01f, 2.63381377e-02f, 2.54775360e-02f, -2.39436120e-01f,
  -1.41283795e-02f, 5.14361523e-02f, 1.71025619e-01f, 6.05431125e-02f, 6.55827150e-02f, -9.63553563e-02f, -1.40585691e-01f, -9.71405730e-02f, 1.42993614e-01f, -2.05358833e-01f,
  5.80811799e-02f, -2.70866722e-01f, -3.34611773e-01f, 3.14260632e-01f, -4.18386489e-01f, -2.22750515e-01f, -6.93267211e-02f, 2.54739702e-01f, -2.27378577e-01f, 1.87959060e-01f,
  -9.05464813e-02f, -2.25584015e-01f, -4.93975312e-01f, -2.98827380e-01f, 1.79186195e-01f, 1.61064699e-01f, -4.03010756e-01f, -1.10690773e-01f, -7.17816576e-02f, -1.62276015e-01f,
  -6.61608696e-01f, -2.51534849e-01f, -1.33687764e-01f, -5.35175741e-01f, 2.17142582e-01f, -1.17679112e-01f, -6.42541274e-02f, -4.42797095e-01f, -5.97805083e-01f, 2.88274109e-01f,
  1.83667749e-01f, 2.97165990e-01f, 7.82952607e-02f, 4.18445468e-01f, 3.23485821e-01f, -1.90854415e-01f, 2.79689997e-01f, -5.01565933e-01f, -2.64971405e-01f, -2.46001288e-01f,
  2.74948329e-01f, -3.61008018e-01f, -6.26183897e-02f, 1.05338460e-02f, -2.43475705e-01f, 2.16488287e-01f, 5.56923375e-02f, -7.56114870e-02f, -1.46671966e-01f, 2.19321832e-01f,
  -4.27734144e-02f, -1.96011066e-01f, -1.64683014e-01f, -1.80175707e-01f, 5.65295899e-03f, -1.27784133e-01f, -2.59762347e-01f, -1.26090320e-03f, 1.06034040e-01f, 7.53213093e-02f,
  -8.51631910e-02f, 9.87583399e-02f, -2.09391549e-01f, -2.70697057e-01f, 1.16385974e-01f, 1.25597060e-01f, 3.28826010e-01f, 2.60924965e-01f, 1.89750642e-01f, -1.95109978e-01f,
  2.19971836e-01f, 8.22471175e-03f, -2.51209825e-01f, -3.71600956e-01f, 1.78940520e-01f, -2.96954900e-01f, 1.87901706e-01f, 3.42893153e-01f, -3.09849560e-01f, -1.45275280e-01f,
  -3.32492769e-01f, 1.72445461e-01f, -1.06708959e-01f, 2.81283915e-01f, -2.01874733e-01f, 2.89103836e-01f, -6.91748261e-01f, 1.62212387e-01f, -2.07343372e-03f, 2.06075013e-01f,
  -5.66210866e-01f, 2.07080722e-01f, 4.64766100e-02f, -1.19072357e-02f, -3.91964436e-01f, 3.66172969e-01f, 2.90001452e-01f, 2.91121244e-01f, 1.93617299e-01f, -2.19470053e-03f,
  6.32353127e-02f, -3.50624114e-01f, -2.19551906e-01f, -4.34802741e-01f, 9.68826264e-02f, 1.02434397e-01f, -1.93633065e-01f, -2.62359917e-01f, 1.00662440e-01f, -1.63905323e-02f,
  -2.08594382e-01f, -1.48231223e-01f, 1.38789579e-01f, -1.47789540e-02f, -1.47510394e-01f, -9.65133831e-02f, 1.45083427e-01f, 2.11573243e-02f, -2.15496406e-01f, 8.50131363e-02f,
  -2.50599757e-02f, 4.71557789e-02f, -3.96014415e-02f, -1.28908008e-01f, 1.34357125e-01f, 1.54428244e-01f, -1.99026093e-01f, -1.74998105e-01f, -2.63294011e-01f, 2.45903805e-01f,
  1.05365619e-01f, -1.91672146e-01f, -4.13910568e-01f, -1.75178319e-01f, 2.06821531e-01f, 1.85280308e-01f, 5.09382337e-02f, -4.11988385e-02f, 1.09610319e-01f, -2.59411126e-01f,
  2.87783474e-01f, 2.29609877e-01f, 1.55898452e-01f, 3.28713693e-02f, -3.76966447e-01f, 1.78692669e-01f, -4.77163136e-01f, 1.66714564e-01f, 1.13068216e-01f, -1.33029610e-01f,
  2.65693873e-01f, 2.33840212e-01f, -5.63111186e-01f, 1.55281564e-02f, -3.47743452e-01f, 3.49994987e-01f, -9.65342671e-02f, -3.03684264e-01f, -4.81689125e-01f, 6.75413311e-02f,
  -3.30758929e-01f, -2.82886326e-01f, 5.09448629e-03f, 3.13483298e-01f, -2.93570369e-01f, 2.36424685e-01f, -3.16959918e-01f, 2.50241458e-01f, -1.56394228e-01f, 2.82795429e-01f,
  -4.19434756e-01f, -3.15549284e-01f, 1.87953219e-01f, -2.24046037e-01f, -1.06240481e-01f, 4.29268889e-02f, -2.80245602e-01f, -8.33849683e-02f, -4.88058710e-03f, -1.64659187e-01f,
  -1.39763027e-01f, 5.97204864e-02f, -2.72492766e-01f, -1.75365537e-01f, 1.51241437e-01f, 9.28044766e-02f, -1.22977488e-01f, -1.32505879e-01f, 3.91549096e-02f, -8.78332108e-02f,
  8.51741210e-02f, 1.77625716e-01f, 6.23965673e-02f, -3.30223143e-01f, 2.20100254e-01f, -1.96479261e-01f, -3.06710750e-01f, -3.15421075e-01f, 4.38412279e-02f, -2.35204473e-01f,
  -2.14485377e-01f, 7.81217664e-02f, 3.14207561e-02f, 3.40387523e-01f, -2.14890763e-01f, -2.51958013e-01f, 2.17263460e-01f, -1.04587279e-01f, 1.49212882e-01f, 3.42221439e-01f,
  4.32319224e-01f, 1.55927703e-01f, -4.71841037e-01f, -1.86954618e-01f, 1.43025815e-01f, -4.56308872e-01f, -7.12429266e-03f, -4.84524995e-01f, 2.24516794e-01f, -3.39706875e-02f,
  -5.48087955e-01f, -2.20817223e-01f, 2.86932528e-01f, -2.81056821e-01f, 1.74473047e-01f, 1.55709356e-01f, -1.63048897e-02f, -6.14501476e-01f, -3.39203924e-01f, 1.50382474e-01f,
  4.17117655e-01f, -4.57214773e-01f, -6.62377179e-01f, -4.17761773e-01f, -4.58064705e-01f, 1.90214396e-01f, 3.35208774e-02f, 8.59776810e-02f, 1.15193687e-01f, 9.27805249e-03f,
  1.99171901e-01f, 1.19300783e-01f, 2.33671322e-01f, 2.53473282e-01f, 2.92765468e-01f, -4.17938419e-02f, 8.74580443e-02f, -7.42504150e-02f, -6.40212670e-02f, 9.22612697e-02f,
  -5.81694208e-02f, -1.64183065e-01f, -2.19837427e-01f, 3.71025577e-02f, 4.45689671e-02f, 2.77351171e-01f, 3.29062551e-01f, 1.62812755e-01f, -9.44747627e-02f, -1.78385347e-01f,
  -1.81489915e-01f, 7.60111287e-02f, -1.99565947e-01f, 8.07165354e-02f, 2.49643266e-01f, 1.26261026e-01f, -4.32955682e-01f, 9.07619223e-02f, 1.98154777e-01f, -2.24622995e-01f,
  2.56998688e-01f, 1.85225770e-01f, 2.24977955e-01f, -1.91889897e-01f, -2.31393173e-01f, 1.12817980e-01f, 1.86315283e-01f, -4.78731543e-01f, -1.33496195e-01f, -4.81376648e-01f,
  -1.78405531e-02f, 1.43579349e-01f, 3.34885448e-01f, 2.27487653e-01f, -1.99540228e-01f, 1.73883274e-01f, 1.86011627e-01f, -7.48881772e-02f, -6.78582303e-03f, -2.25881025e-01f,
  2.89052933e-01f, 2.68264890e-01f, -1.49450421e-01f, 3.49294424e-01f, 1.07653081e-01f, -4.49500620e-01f, -4.90793884e-02f, -4.03806120e-01f, 9.07515436e-02f, 6.49171025e-02f,
  1.62549376e-01f, 1.73244894e-01f, -7.95333609e-02f, 1.44039795e-01f, 3.13342325e-02f, -2.13565409e-01f, 1.32397234e-01f, 8.98757055e-02f, 2.42612123e-01f, 6.24074079e-02f,
  3.50419395e-02f, 8.04609284e-02f, 1.85606703e-01f, 1.64305810e-02f, 6.60243332e-02f, 1.21989056e-01f, 2.03142419e-01f, 1.57186225e-01f, 1.28256023e-01f, 1.24587648e-01f,
  2.11686701e-01f, -4.28517491e-01f, -3.72842491e-01f, 2.37413839e-01f, 3.38444799e-01f, 3.48946720e-01f, 3.97006780e-01f, 4.70813721e-01f, -4.44183737e-01f, 2.79408008e-01f,
  4.30125356e-01f, 2.68191725e-01f, 3.44096035e-01f, -6.18587853e-03f, -3.53000760e-01f, -1.91329047e-01f, 2.52075106e-01f, -1.69795454e-02f, 9.84573178e-03f, -3.25904697e-01f,
  7.92428181e-02f, 3.64119411e-01f, -1.26468629e-01f, -2.18064263e-01f, 1.17526233e-01f, 6.89400062e-02f, -3.09746027e-01f, -4.41593945e-01f, 3.62227499e-01f, 4.16015051e-02f,
  3.69295090e-01f, -2.18028843e-01f, -6.02226913e-01f, -1.28837481e-01f, 9.41390395e-02f, -6.28203899e-02f, 3.34502339e-01f, -4.21976417e-01f, -6.20884836e-01f, -5.96187636e-02f,
  2.75845468e-01f, -1.77086145e-02f, 3.50079425e-02f, 2.46505782e-01f, 6.71861367e-03f, -1.40925884e-01f, 2.75883108e-01f, 1.20332018e-01f, 1.23130798e-01f, 2.11325698e-02f,
  1.87782988e-01f, -7.16200396e-02f, 6.71627447e-02f, 4.38694581e-02f, 1.44648299e-01f, -1.13715202e-01f, 1.68813661e-01f, -2.17588574e-01f, -2.43016332e-01f, -1.95698231e-03f,
  1.19812354e-01f, -1.29781663e-01f, 1.12427846e-01f, 3.26600432e-01f, -2.28943169e-01f, 1.00535750e-01f, -9.06855315e-02f, 1.78051025e-01f, 3.06638122e-01f, -6.74693286e-02f,
  1.25630096e-01f, -2.88471192e-01f, 2.60158092e-01f, -3.45560521e-01f, 2.76388466e-01f, 2.94618607e-01f, 8.73953849e-03f, 2.09853947e-01f, -4.40055311e-01f, 1.60927698e-01f,
  2.44980291e-01f, 1.53605789e-01f, -3.12565565e-01f, -3.34401608e-01f, 3.29086274e-01f, 2.74532497e-01f, 3.84350300e-01f, 2.86098719e-01f, -4.43430036e-01f, 1.70881227e-01f,
  6.92745745e-02f, -4.10879292e-02f, 2.32769892e-01f, 5.56998625e-02f, -1.23934649e-01f, -2.98323780e-01f, -2.92198986e-01f, -2.31671527e-01f, -5.13589621e-01f, -3.01049739e-01f,
  -5.25387287e-01f, -3.67201716e-02f, -1.75627410e-01f, 1.60376012e-01f, -3.72295856e-01f, 1.91214934e-01f, 3.12171638e-01f, -2.87376344e-01f, 9.73233208e-02f, 8.64489749e-02f,
  2.71757916e-02f, -1.13493875e-01f, 1.45657957e-01f, -1.56247705e-01f, -7.66350999e-02f, 2.00637355e-02f, -1.52667807e-02f, 6.25384450e-02f, 3.00144702e-02f, -1.50277287e-01f,
  -1.51915297e-01f, 1.81500968e-02f, -3.62879336e-02f, 8.92732590e-02f, -5.06443679e-02f, 3.11048739e-02f, 8.10015425e-02f, -3.16120870e-02f, -2.41309047e-01f, 2.10878327e-01f,
  -2.57303059e-01f, 2.56647877e-02f, 1.86370164e-01f, 2.32638940e-01f, -2.08015397e-01f, -1.95461586e-01f, 1.29747078e-01f, 1.65177956e-01f, -2.13997483e-01f, 1.03246681e-01f,
  2.11016253e-01f, -1.33659512e-01f, 7.12859035e-02f, -1.97728693e-01f, -3.08856487e-01f, -7.84487650e-02f, 2.82438904e-01f, -2.76354313e-01f, -2.42611945e-01f, -2.24521205e-01f,
  4.36762124e-01f, -2.54051656e-01f, -2.31414482e-01f, 2.68776596e-01f, 2.48153090e-01f, -2.85110772e-01f, 2.96930075e-01f, -2.81882465e-01f, -4.47309822e-01f, -2.45016545e-01f,
  -2.36624748e-01f, -1.91158772e-01f, -1.72452647e-02f, -3.75847906e-01f, 2.29160443e-01f, -3.90382618e-01f, 2.76844174e-01f, -1.47384629e-01f, -1.78257868e-01f, -1.26355633e-01f,
  -3.52683425e-01f, 3.01171124e-01f, 8.02482143e-02f, 9.06570628e-02f, 8.02444294e-02f, 1.35758470e-04f, -8.62280279e-03f, -3.81270275e-02f, 9.38242301e-02f, 1.21707298e-01f,
  5.01026493e-03f, -2.43246630e-02f, -1.24073535e-01f, -9.74770403e-04f, 1.26042799e-03f, -4.21173088e-02f, 1.06942998e-02f, 3.51286232e-02f, -8.39699060e-02f, -2.12551489e-01f,
  -1.45127729e-01f, 3.06228280e-01f, -2.35892713e-01f, -2.89586127e-01f, -7.98019916e-02f, -2.67739981e-01f, 5.10646068e-02f, -1.95786923e-01f, -3.05778712e-01f, 1.82081163e-01f,
  -1.98754504e-01f, -2.49092191e-01f, 1.91874489e-01f, -8.52808654e-02f, -2.20838591e-01f, 1.81208178e-02f, 3.28329280e-02f, -2.55668521e-01f, -2.50069380e-01f, 1.76503837e-01f,
  3.57100457e-01f, -1.51077598e-01f, 2.49919713e-01f, -6.85385168e-02f, 1.93427846e-01f, -1.04227044e-01f, -2.71968693e-01f, -4.58063096e-01f, -2.99607903e-01f, -3.68855387e-01f,
  -2.39395738e-01f, -1.77497566e-01f, -2.81993657e-01f, 1.84172869e-01f, 2.38293394e-01f, -2.09815368e-01f, 1.22441776e-01f, -3.01052660e-01f, -3.78851891e-01f, -4.88020759e-03f,
  2.62679338e-01f, 3.23917300e-01f, 3.81307036e-01f, 1.83910698e-01f, -2.49152467e-01f, -1.49113566e-01f, 1.14352562e-01f, -2.97697377e-03f, -1.43583834e-01f, 1.24691175e-02f,
  -5.93926236e-02f, 1.63846582e-01f, -2.06049457e-01f, 1.25507459e-01f, 3.25976014e-02f, -1.97486401e-01f, 1.13043815e-01f, -2.18445901e-02f, -7.39654154e-02f, 1.31208505e-02f,
  2.09865868e-01f, 2.66700145e-02f, 8.22781846e-02f, 4.29028533e-02f, -1.84401348e-01f, -1.96593106e-01f, -3.15008372e-01f, 2.55221963e-01f, 1.94400758e-01f, 3.19233149e-01f,
  -1.13975212e-01f, 1.84753597e-01f, 6.28921986e-02f, -1.00469261e-01f, 1.48968160e-01f, -3.37020159e-01f, 1.90441072e-01f, 1.30157545e-02f, 5.82423508e-02f, -1.39642376e-02f,
  3.44399065e-01f, 2.37022955e-02f, 1.27576485e-01f, -3.50347966e-01f, -3.71300131e-01f, -3.00934523e-01f, -2.44337752e-01f, -2.17858970e-01f, -1.46909580e-01f, 2.34854236e-01f,
  -5.11207461e-01f, 2.57343799e-01f, 1.57562315e-01f, 1.44001484e-01f, 2.94552166e-02f, 3.06045741e-01f, -5.41383922e-01f, -4.24428642e-01f, -3.75449121e-01f, -7.29679167e-02f,
  -5.19912183e-01f, 4.54692096e-01f, 1.87932700e-01f, 1.26385778e-01f, -5.42300344e-01f, -1.39034867e-01f, 3.40243191e-01f, -4.23916072e-01f, 2.89219350e-01f, 2.65742302e-01f,
  -1.50059775e-01f, 3.68858650e-02f, 2.25047454e-01f, -2.51785547e-01f, 9.95092392e-02f, -1.00330412e-01f, -1.10367462e-01f, -1.03627749e-01f, -6.84639141e-02f, 1.11536525e-01f,
  1.61918685e-01f, -1.86221257e-01f, 3.93634588e-02f, 1.67541817e-01f, 1.68266609e-01f, 4.13946882e-02f, -4.17392813e-02f, 8.81239101e-02f, 1.27050042e-01f, -3.04530203e-01f,
  3.25377017e-01f, 7.67323747e-02f, 1.76103100e-01f, -2.10428819e-01f, -2.61715233e-01f, -1.13143541e-01f, -3.14667374e-01f, -1.23418815e-01f, -2.08041161e-01f, 2.04600185e-01f,
  -2.55660087e-01f, -2.51260370e-01f, -1.24247476e-01f, 3.07776183e-01f, 5.35515882e-02f, 2.44108096e-01f, 2.40071625e-01f, 1.52527809e-01f, -1.90872982e-01f, 2.22063020e-01f,
  -3.69330198e-01f, -2.21678205e-02f, -5.61095655e-01f, 2.91239381e-01f, 3.69360328e-01f, -3.75276655e-01f, -2.88236618e-01f, 1.56818688e-01f, -3.29867333e-01f, -3.59224945e-01f,
  8.66717100e-02f, -2.07903609e-01f, 2.48657420e-01f, -2.59494245e-01f, -3.95368636e-01f, -4.43749398e-01f, 2.27772549e-01f, 2.79334277e-01f, 1.16441302e-01f, 3.12488645e-01f,
  -4.00967062e-01f, 3.92719269e-01f, -2.58525033e-02f, -4.11684662e-02f, -7.94054270e-02f, 3.68385836e-02f, -1.85922444e-01f, -2.05850884e-01f, 1.36813849e-01f, -1.01304777e-01f,
  -3.54739949e-02f, -5.15149087e-02f, -6.55396357e-02f, 8.93274918e-02f, 5.80839626e-02f, 1.50362492e-01f, 4.42652218e-02f, 1.11998171e-01f, 1.15893058e-01f, 6.41624406e-02f,
  7.08836168e-02f, 8.40628520e-02f, -3.67120927e-04f, 1.54943675e-01f, -1.81088656e-01f, -2.09708899e-01f, 2.66354471e-01f, -1.90597475e-01f, 2.28081793e-01f, 2.09625140e-01f,
  -3.74790221e-01f, -8.63883495e-02f, 1.69279486e-01f, 1.75701544e-01f, -3.39471102e-01f, 2.31068507e-01f, -3.65530521e-01f, 3.72791998e-02f, -3.78918588e-01f, 1.43525705e-01f,
  -1.41326264e-02f, -3.65534723e-01f, 2.12543726e-01f, 2.57606536e-01f, 3.44910026e-01f, 2.05511764e-01f, 2.83817053e-01f, -1.58208683e-01f, 3.65760922e-01f, -3.85662138e-01f,
  -1.82393402e-01f, 9.52421455e-04f, 2.17218608e-01f, -4.38896507e-01f, 2.38136351e-01f, -3.82087022e-01f, -2.11070538e-01f, 1.66949391e-01f, -4.13739860e-01f, 2.46062875e-01f,
  -4.50402647e-01f, -3.79506022e-01f, -7.76065961e-02f, 2.04928711e-01f, -2.62787372e-01f, -3.59429032e-01f, 5.03959768e-02f, -2.62058645e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.05344178e-02f, 9.51582417e-02f, -5.46938851e-02f, -4.56461012e-02f, 1.57228461e-03f, 6.03167079e-02f, -9.37708691e-02f, -6.09632023e-02f, 5.37375696e-02f, -3.63622326e-03f,
  1.49726912e-01f, -1.17833465e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    