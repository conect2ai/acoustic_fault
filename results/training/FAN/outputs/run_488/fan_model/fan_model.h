/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.58953744e-01f, 2.42751062e-01f, 1.48795798e-01f, -2.37339094e-01f, 1.60059825e-01f, 4.67150480e-01f, -8.15452635e-02f, 1.42638087e-01f, 7.98800141e-02f, -2.04533920e-01f,
  2.09476408e-02f, -9.36369598e-03f, 1.54185265e-01f, -2.00999439e-01f, 5.55709600e-01f, 5.21671847e-02f, -2.75006164e-02f, -1.80429801e-01f, 4.36360538e-02f, 1.40169010e-01f,
  2.85003912e-02f, -1.42409001e-02f, 2.31113527e-02f, 6.24562101e-03f, 2.86016967e-02f, -6.92899674e-02f, -5.58248311e-02f, 4.08417396e-02f, -8.53445679e-02f, -2.96286158e-02f,
  1.22666411e-01f, -9.42380428e-02f, -7.95602798e-02f, -5.59022017e-02f, 1.28685564e-01f, -1.09651476e-01f, -4.08144258e-02f, -2.73702070e-02f, -1.70739070e-02f, 8.71348660e-03f,
  -3.37436125e-02f, 1.19465984e-01f, -3.94466855e-02f, -3.50268348e-03f, -2.07448192e-02f, -2.50316635e-02f, -4.14636359e-02f, -6.17798567e-02f, 2.85561364e-02f, 7.57177025e-02f,
  3.18808854e-02f, -1.84024572e-02f, 3.40802372e-02f, -4.78963815e-02f, 1.04037143e-01f, -1.90685708e-02f, -4.68810685e-02f, -2.56299018e-03f, 1.07500255e-01f, -1.65941119e-02f,
  -3.02149877e-02f, 1.00414911e-02f, -4.63430434e-02f, 8.59833229e-03f, 7.68211437e-03f, -8.54847282e-02f, -2.96965055e-02f, -6.80601075e-02f, 2.32509710e-02f, 6.22918271e-02f,
  6.55980185e-02f, -8.41899961e-02f, -4.91251573e-02f, 2.10167356e-02f, -7.96375722e-02f, -6.20286241e-02f, -4.99123298e-02f, 1.66841056e-02f, 2.92119589e-02f, 2.29715891e-02f,
  -5.52018778e-03f, 4.34750132e-02f, -2.90714158e-03f, -6.60316125e-02f, -2.70793084e-02f, 1.40202627e-01f, -1.01055969e-02f, 1.98346227e-02f, -1.04591688e-02f, 9.10374150e-02f,
  3.33994806e-01f, 3.86646539e-01f, -7.45112151e-02f, -3.01585514e-02f, -1.24528229e-01f, 3.36900027e-03f, -5.32354899e-02f, 2.65642833e-02f, 9.85569432e-02f, 5.42246886e-02f,
  3.98027860e-02f, -1.97569907e-01f, 2.73822304e-02f, 2.89026229e-03f, -2.59230882e-02f, 1.05114311e-01f, -1.45901972e-02f, -2.14074813e-02f, 5.79590956e-03f, 5.68002611e-02f,
  4.12228853e-02f, -4.95336130e-02f, -1.07127152e-01f, 4.96540405e-03f, -7.80368224e-02f, 6.50192564e-03f, 9.17010605e-02f, -3.45646814e-02f, 8.90318491e-03f, 1.85505673e-02f,
  -2.13036820e-01f, 3.93384993e-01f, -5.39437950e-01f, -3.35381716e-01f, -1.96449049e-02f, 1.07673347e-01f, -2.41621599e-01f, -7.00175688e-02f, -3.33228439e-01f, 3.37719887e-01f,
  2.68223673e-01f, 1.70572400e-02f, -2.54307948e-02f, 2.25094378e-01f, -1.87971875e-01f, -5.21126278e-02f, 7.68505037e-02f, 8.36216286e-02f, -1.25209495e-01f, -3.04846615e-01f,
  -3.00655186e-01f, 2.43941784e-01f, -1.14994414e-01f, 2.66934395e-01f, 7.71407932e-02f, -3.94881666e-02f, 1.41764954e-01f, -1.16370738e-01f, 3.38796765e-01f, 9.60183367e-02f,
  1.90428987e-01f, -7.88913295e-02f, 5.99542074e-02f, 8.60053822e-02f, 1.91410016e-02f, 1.38153993e-02f, -1.31501593e-02f, -3.86019051e-02f, -3.25512700e-02f, 1.21334970e-01f,
  3.02076969e-05f, -1.41682606e-02f, 8.34403560e-02f, -2.80836616e-02f, -1.11046910e-01f, 3.81974690e-02f, 3.20539414e-03f, 2.51047257e-02f, 3.81892398e-02f, -6.37431741e-02f,
  -2.85142157e-02f, 2.62083635e-02f, -1.10922374e-01f, 1.62547771e-02f, -4.57453988e-02f, -8.95480532e-03f, -1.16945222e-01f, -4.54178266e-02f, 1.17043778e-01f, -9.18589253e-03f,
  -9.96862873e-02f, -1.20119222e-01f, 4.42066826e-02f, -9.89899859e-02f, 3.79235782e-02f, 5.58112003e-02f, 3.35416608e-02f, 2.31720563e-02f, -3.05449981e-02f, -6.84812143e-02f,
  1.74090676e-02f, 2.57536210e-02f, -3.82657573e-02f, -4.62565124e-02f, -2.13459972e-02f, -3.70214731e-02f, -1.10329442e-01f, 2.59370301e-02f, 1.00322273e-02f, 4.46503721e-02f,
  1.29498718e-02f, -7.91156590e-02f, 1.79242209e-01f, -1.77419297e-02f, 4.02216613e-03f, -1.30275115e-01f, -8.26856643e-02f, -1.24649376e-01f, -2.91313268e-02f, -3.21612470e-02f,
  1.47728801e-01f, -1.55207396e-01f, 8.27719793e-02f, 1.54294312e-01f, 4.21680994e-02f, 1.56561092e-01f, -9.46324393e-02f, 6.11122474e-02f, -1.98809020e-02f, -6.64989650e-02f,
  2.45395955e-02f, 7.29566813e-02f, 3.26103531e-02f, -2.56181601e-02f, 2.57417690e-02f, 5.35343699e-02f, -8.70546475e-02f, 9.58957616e-03f, 8.31485018e-02f, 5.06760329e-02f,
  4.04808782e-02f, -3.60530168e-02f, -4.01173942e-02f, 8.40276256e-02f, 5.99697903e-02f, 7.27716237e-02f, -5.03984205e-02f, 3.55462730e-03f, -3.40204686e-03f, 5.47622070e-02f,
  9.24272537e-02f, -2.60482490e-01f, -4.63536918e-01f, -1.26435637e-01f, 2.82124788e-01f, -1.33983612e-01f, -3.31414670e-01f, 5.02003208e-02f, -1.88389599e-01f, -2.15850733e-02f,
  2.63661683e-01f, -2.50211716e-01f, -5.09359837e-02f, 9.81472209e-02f, 2.92620450e-01f, -7.24201575e-02f, 1.05308034e-01f, -1.55493319e-01f, -7.13013336e-02f, 5.76143898e-02f,
  -2.43882183e-02f, 3.52727383e-01f, -7.43463561e-02f, 6.88754171e-02f, -6.92231953e-03f, -2.29038447e-01f, 3.49573791e-01f, -1.10981129e-01f, 2.27788314e-01f, 8.05037767e-02f,
  -5.44006750e-02f, 2.27272008e-02f, -1.78424373e-01f, -1.83433175e-01f, 1.00930817e-01f, -3.83638917e-03f, -1.08820491e-01f, -4.31084745e-02f, 6.67326525e-02f, 1.56143317e-02f,
  -6.50644079e-02f, -5.89672057e-03f, -5.85508868e-02f, 1.33264074e-02f, -5.95670007e-02f, -1.18456647e-01f, 4.86444607e-02f, 2.66655767e-03f, -1.15950383e-01f, -6.81599453e-02f,
  -7.43421614e-02f, -6.12885877e-02f, -1.93554908e-02f, -2.70113330e-02f, -7.81126097e-02f, -1.11529842e-01f, -1.01066016e-01f, -8.84722471e-02f, 6.03479780e-02f, -4.86850664e-02f,
  1.43989250e-01f, -7.02015609e-02f, 1.42918974e-02f, -3.40810604e-02f, -4.72881570e-02f, -5.43580204e-03f, -3.54335457e-02f, -2.42025238e-02f, -5.45810014e-02f, 1.96529701e-02f,
  1.21690929e-01f, -4.55503613e-02f, -5.06060570e-03f, -3.83997411e-02f, -3.26342247e-02f, -1.10359892e-01f, -1.12643979e-01f, 6.04575239e-02f, -7.10983872e-02f, -3.40907350e-02f,
  -7.02200085e-02f, -4.50311750e-02f, -7.10620657e-02f, -1.57486368e-02f, -3.71705592e-02f, -6.70093596e-02f, -3.05652730e-02f, -3.98155414e-02f, 6.48007095e-02f, 4.92820963e-02f,
  8.56804177e-02f, 1.58630505e-01f, -6.99204579e-02f, 1.98365618e-02f, -3.88717949e-02f, 1.55439362e-01f, -1.28725365e-01f, 7.17836022e-02f, 3.90860550e-02f, 1.11228451e-01f,
  2.62165610e-02f, -5.76479882e-02f, 7.47268721e-02f, 5.57779074e-02f, -2.93797418e-03f, 6.12004064e-02f, 7.93667231e-03f, -2.31495909e-02f, 2.51938328e-02f, 1.40125863e-02f,
  5.97504415e-02f, 2.20761672e-02f, -1.33606195e-01f, 6.55230507e-02f, 1.13907278e-01f, 7.80481175e-02f, 5.48470542e-02f, -8.64887685e-02f, 1.47306293e-01f, 4.86852194e-04f,
  7.07028657e-02f, -2.60973275e-01f, 4.35827766e-03f, 6.68419823e-02f, 1.39172703e-01f, 3.67870092e-01f, 2.65851766e-01f, 3.23950052e-02f, -2.92744160e-01f, -2.84206793e-02f,
  2.27328688e-01f, -3.31766397e-01f, 4.40334864e-02f, 2.31963828e-01f, -1.72831491e-02f, -1.03274330e-01f, 5.93082570e-02f, 1.00832516e-02f, -8.82454887e-02f, 4.38253134e-02f,
  7.87936226e-02f, -1.94758680e-02f, 3.51228654e-01f, 5.38736135e-02f, 4.08906221e-01f, 3.95005196e-02f, 1.51803810e-02f, 7.67762512e-02f, 2.05007344e-01f, -2.98979450e-02f,
  1.80872068e-01f, -1.10041648e-01f, 5.25495075e-02f, -1.82272587e-02f, 2.10694566e-01f, 7.72420615e-02f, 2.89351083e-02f, -1.96261052e-02f, -1.14299290e-01f, 9.29143373e-03f,
  -3.44834700e-02f, -1.39420956e-01f, -1.32236868e-01f, -9.84879136e-02f, -3.20960255e-03f, 3.50070396e-03f, 1.24319635e-01f, 1.58517554e-01f, 2.42784806e-02f, 1.26775816e-01f,
  7.97546729e-02f, 3.57237458e-02f, 6.48461804e-02f, -1.29442755e-02f, -3.88826840e-02f, -9.07977298e-02f, -1.05257938e-02f, 8.22175443e-02f, -5.38912714e-02f, -1.08052501e-02f,
  -9.19882655e-02f, -8.34398866e-02f, 5.43341450e-02f, 3.22840028e-02f, 1.47450389e-02f, 6.69791400e-02f, -3.53762396e-02f, 5.49226329e-02f, -3.11058350e-02f, 3.00512426e-02f,
  8.15833807e-02f, -1.33617222e-02f, -1.03274919e-01f, 4.36440185e-02f, 5.77696376e-02f, -2.59068478e-02f, 4.36561666e-02f, -9.15970951e-02f, 6.34477735e-02f, 9.67547596e-02f,
  -1.22271389e-01f, 9.06643458e-03f, -2.37571960e-03f, 2.97935843e-03f, -2.08704956e-02f, 1.03397937e-02f, -5.20261563e-02f, -1.41611916e-03f, 6.55217767e-02f, -4.28467244e-02f,
  -6.20515198e-02f, -2.32113317e-01f, -5.15176058e-02f, -2.42847092e-02f, -9.78881270e-02f, 6.48816526e-02f, -1.38307899e-01f, 1.16653675e-02f, -1.40594076e-02f, -7.73519874e-02f,
  1.02118298e-01f, 4.63761874e-02f, -1.21703602e-01f, 7.71638900e-02f, -6.77578151e-02f, 5.83727807e-02f, -1.63597167e-01f, -6.24675564e-02f, 1.81818455e-02f, -4.59664781e-03f,
  -8.63537118e-02f, 6.97456822e-02f, -1.09534875e-01f, -5.80073260e-02f, -6.03604242e-02f, 5.57305403e-02f, -5.41900881e-02f, 1.22933522e-01f, -3.08961198e-02f, -6.87861666e-02f,
  -3.25452268e-01f, 3.87639701e-01f, 6.29908666e-02f, -1.56253248e-01f, -3.33221465e-01f, 4.64777261e-01f, 3.27462293e-02f, 1.79825455e-01f, -3.81959714e-02f, 2.97851235e-01f,
  -3.17663729e-01f, 1.55312717e-01f, 8.41728747e-02f, -1.14046209e-01f, 1.52388718e-02f, 9.08428952e-02f, 1.53056011e-01f, 3.63961570e-02f, 6.76158518e-02f, 1.85243949e-01f,
  -1.29232109e-01f, -2.05063626e-01f, -7.01127425e-02f, 4.58016135e-02f, -1.05206139e-01f, -1.59965288e-02f, 1.91904865e-02f, 8.16277862e-02f, -4.52880040e-02f, -9.25058499e-02f,
  -4.05414170e-03f, 8.28592181e-02f, -9.44195911e-02f, 7.58210793e-02f, 6.37547299e-02f, 5.22516575e-03f, 5.32702804e-02f, -5.76978996e-02f, -6.42121732e-02f, 7.19446391e-02f,
  3.75990942e-03f, -9.49739441e-02f, -7.97881857e-02f, -3.33353579e-02f, 2.02309079e-02f, -2.52333451e-02f, 6.63097352e-02f, -4.10940871e-02f, -3.33750956e-02f, -1.13076214e-02f,
  -1.67633239e-02f, 2.45074108e-02f, -3.77046242e-02f, 4.45248857e-02f, 3.67188007e-02f, -5.34421951e-02f, -1.95226551e-03f, 9.66468768e-04f, 9.14011672e-02f, 4.43899147e-02f,
  3.44666541e-02f, 7.22949952e-02f, 5.74180558e-02f, -8.87274817e-02f, 8.64401087e-02f, -8.01043585e-02f, 1.01070859e-01f, -5.07771373e-02f, 8.31097737e-02f, 7.48166963e-02f,
  -1.25701437e-02f, -7.83949438e-03f, -6.06695861e-02f, 6.62456080e-02f, 1.81990396e-02f, 4.07472886e-02f, 1.93188414e-02f, -4.85414974e-02f, -6.10728143e-03f, -1.39542609e-01f,
  1.69135053e-02f, 7.74129704e-02f, 5.20987585e-02f, 1.62044633e-02f, 9.58311483e-02f, 9.71636847e-02f, 3.78316157e-02f, 7.27064162e-02f, 7.33110085e-02f, -5.83220497e-02f,
  3.43662888e-01f, 3.68119776e-01f, 6.19304506e-03f, 1.06315585e-02f, 7.42423832e-02f, 7.73599818e-02f, -4.48517166e-02f, -1.80123691e-02f, 2.10384145e-01f, 9.18111578e-02f,
  -1.40972454e-02f, 1.14515983e-01f, 1.01033129e-01f, 5.97802689e-03f, 8.07481110e-02f, -3.60955484e-02f, 4.30011787e-02f, -1.55608980e-02f, 6.42938167e-02f, 2.87048686e-02f,
  4.71868832e-03f, -1.36831170e-02f, 9.42937061e-02f, -1.16064632e-02f, 7.01290276e-03f, 1.09164631e-02f, -4.23926488e-02f, -2.02555489e-02f, 2.16169767e-02f, -1.38889649e-03f,
  -2.61776596e-01f, -6.69843331e-02f, 2.45174006e-01f, -2.26237029e-01f, -2.43007794e-01f, 1.37840480e-01f, 4.48106021e-01f, -2.73971051e-01f, 1.18402652e-01f, -5.75873591e-02f,
  -3.33422646e-02f, -4.95514795e-02f, 3.43273848e-01f, -3.07258427e-01f, 1.90554976e-01f, 4.05060291e-01f, -1.24913476e-01f, -3.25447656e-02f, -4.95209731e-02f, -1.35902151e-01f,
  -6.96342587e-02f, -2.75628954e-01f, 7.09859133e-02f, -1.86948135e-01f, -1.99710414e-01f, -6.46798089e-02f, -2.50169516e-01f, 2.18774810e-01f, -2.05925092e-01f, -2.11042538e-02f,
  1.01710200e-01f, -5.74699640e-02f, -5.90870082e-02f, -1.56412646e-02f, -3.61441672e-02f, -5.51377311e-02f, 7.99899250e-02f, 1.20938331e-01f, 7.16268197e-02f, 3.30995675e-03f,
  2.86093671e-02f, -1.25901133e-01f, -9.39458683e-02f, 2.40821149e-02f, -1.34257451e-01f, -4.65176143e-02f, -8.22307765e-02f, -6.60103858e-02f, -3.17033902e-02f, -1.66925669e-01f,
  1.93112884e-02f, 3.16477986e-03f, 3.46434042e-02f, 2.72976551e-02f, 3.49902548e-02f, 4.64319065e-02f, 5.44461794e-02f, 2.12154295e-02f, 1.36377327e-02f, -1.11104116e-01f,
  -1.04328237e-01f, 1.36369048e-02f, 3.95192839e-02f, -1.00168176e-02f, 6.19119853e-02f, -5.24339452e-02f, 6.37814626e-02f, -4.59790155e-02f, 1.34480977e-02f, -2.84171514e-02f,
  1.28414240e-02f, -9.72930640e-02f, -1.18915305e-01f, -9.13157500e-03f, 1.15321325e-02f, -4.54514772e-02f, 1.32015809e-01f, -5.50197810e-02f, -1.06724910e-02f, -4.00022119e-02f,
  9.95783582e-02f, 5.28212935e-02f, 1.87093322e-03f, 1.54475616e-02f, 6.96436241e-02f, 2.46998598e-03f, -1.25034139e-01f, 1.11700315e-02f, 6.65625483e-02f, 3.05621438e-02f,
  -3.46941128e-02f, -4.13106233e-02f, 7.28568286e-02f, 8.45483020e-02f, 7.16816038e-02f, -6.71087429e-02f, 8.42614844e-03f, -7.81302154e-02f, 9.55945104e-02f, 1.41581139e-02f,
  -1.06939502e-01f, 1.70963574e-02f, 9.73915234e-02f, -3.58005837e-02f, 1.14587136e-01f, -4.12044786e-02f, 8.14372078e-02f, 1.40908003e-01f, -3.20236348e-02f, -1.59284174e-01f,
  -4.05991003e-02f, 5.54368757e-02f, -3.92374769e-02f, -6.78409711e-02f, -8.20077509e-02f, 2.74726450e-02f, -5.65427728e-02f, 1.71527918e-02f, 6.57095760e-02f, 8.29315782e-02f,
  5.26260555e-01f, 2.72115648e-01f, 2.96405479e-02f, 1.32647648e-01f, 1.87487245e-01f, 2.28626311e-01f, 1.39077485e-01f, 9.18860361e-02f, 1.08657755e-01f, 7.73379803e-02f,
  1.64235327e-02f, 1.99542105e-01f, -3.00775021e-01f, 2.46959478e-01f, -3.68503034e-01f, -3.42062682e-01f, 7.11614937e-02f, 1.03399038e-01f, -1.38024420e-01f, 1.46549776e-01f,
  -5.41663282e-02f, 6.82346299e-02f, -2.06019163e-01f, 7.62464702e-02f, 1.92755207e-01f, 2.04738915e-01f, -3.33220661e-01f, -1.69700477e-02f, 1.43717274e-01f, 1.92090531e-03f,
  7.01912493e-02f, -2.98082288e-02f, 1.62583768e-01f, 4.85487282e-02f, -6.17639609e-02f, 5.92026040e-02f, 6.79015601e-03f, -7.51918107e-02f, -1.57984085e-02f, -4.87038568e-02f,
  5.72248995e-02f, -5.35702780e-02f, 4.21288684e-02f, -3.93743664e-02f, 1.80614606e-01f, 2.36026682e-02f, 2.93137040e-02f, -5.27354293e-02f, 5.61168008e-02f, 5.51154744e-03f,
  1.31429443e-02f, -6.66644424e-02f, 2.44211126e-02f, -6.66154251e-02f, -1.03346324e-02f, 9.87223983e-02f, -3.14617828e-02f, 3.41974162e-02f, -1.72858965e-02f, 8.19174349e-02f,
  -3.60476896e-02f, -4.75639179e-02f, -9.07872990e-03f, -2.47233305e-02f, 1.96038596e-02f, -4.68300693e-02f, 4.56068777e-02f, -6.20581023e-02f, -3.62737365e-02f, 1.16394581e-02f,
  1.28675308e-02f, 4.91549149e-02f, 3.96312438e-02f, 1.41668646e-02f, -7.11712710e-06f, 7.85301477e-02f, -4.00016941e-02f, -3.88726629e-02f, 5.51339686e-02f, -2.86264289e-02f,
  -2.42134873e-02f, 6.58317581e-02f, -9.15727858e-03f, 1.09881803e-03f, -3.36462297e-02f, -1.17810607e-01f, 2.50067171e-02f, -3.61335017e-02f, 1.83330346e-02f, -1.14943683e-01f,
  -1.08491503e-01f, -1.16294034e-01f, -8.23426396e-02f, 1.29887415e-02f, 1.09721478e-02f, 3.90761085e-02f, 2.46834978e-02f, 4.29469384e-02f, -7.31444657e-02f, -1.11723552e-02f,
  -3.88711132e-02f, 1.84732657e-02f, -2.96044513e-03f, 6.50805011e-02f, -6.61632270e-02f, -6.07845373e-02f, -4.85007465e-02f, 3.11036780e-02f, 5.04969794e-04f, -3.77794243e-02f,
  -2.87598781e-02f, 3.67236137e-02f, 6.93978183e-03f, -1.90007791e-03f, 5.80942072e-03f, -7.35284016e-02f, 2.47544851e-02f, 1.17558151e-01f, -1.20788835e-01f, -2.71063950e-02f,
  1.44244909e-01f, -3.73877794e-01f, -1.67105034e-01f, 1.58454686e-01f, 1.16198160e-01f, 2.09349379e-01f, 3.02376062e-01f, -5.57571836e-02f, -2.68984586e-01f, -1.71995282e-01f,
  2.51913816e-01f, -1.57834291e-01f, -1.87873691e-01f, 2.86344916e-01f, 3.62652034e-01f, -2.25008905e-01f, 2.04952851e-01f, 8.73442441e-02f, -2.16068715e-01f, 1.32052675e-01f,
  2.23016436e-03f, 2.72881389e-01f, 1.44416183e-01f, -1.16645217e-01f, 8.69771391e-02f, -2.34356686e-01f, 2.30267271e-01f, -1.06663764e-01f, 2.88314700e-01f, 4.51719314e-02f,
  7.26492479e-02f, -8.85460749e-02f, -1.82075333e-02f, -1.00678943e-01f, 1.03022635e-01f, 4.43246700e-02f, 4.75518070e-02f, 5.88768050e-02f, 9.26519856e-02f, -1.55923376e-02f,
  -5.35966530e-02f, 1.01043426e-01f, -3.84380557e-02f, -5.57595082e-02f, 4.92093712e-02f, -8.38758275e-02f, -1.54929617e-02f, 6.13175966e-02f, -3.30769271e-02f, 4.43104394e-02f,
  -2.36940267e-03f, -1.48613984e-03f, 3.31607535e-02f, -1.37131466e-02f, -6.52399436e-02f, 4.05123159e-02f, 7.47510511e-03f, -5.31863458e-02f, -5.59796169e-02f, -1.36132548e-02f,
  -3.62391062e-02f, -3.97229791e-02f, 1.15218889e-02f, -4.19153050e-02f, 6.63956329e-02f, -5.77033358e-03f, 4.28041779e-02f, 1.13984030e-02f, -9.63517185e-03f, 4.73713614e-02f,
  6.06637448e-02f, 3.90092209e-02f, 3.24848145e-02f, 2.86833439e-02f, 3.09501365e-02f, -2.53000832e-03f, 3.09539866e-02f, -4.86410335e-02f, -4.92845811e-02f, 3.18637900e-02f,
  -4.78741750e-02f, 5.83912767e-02f, -2.55033243e-02f, 1.93304233e-02f, 9.55688581e-03f, -4.98989746e-02f, 7.91378412e-03f, 3.84896621e-02f, -9.76141095e-02f, -3.72882863e-03f,
  1.20283067e-02f, -1.41123950e-01f, -8.98631811e-02f, 5.91979660e-02f, -9.06636268e-02f, -2.69527361e-02f, 1.67434919e-03f, -9.35557932e-02f, -3.85898282e-03f, 5.35211246e-03f,
  8.65688920e-02f, -6.13523833e-02f, -5.88105209e-02f, 5.87209500e-02f, 6.49816170e-02f, 7.13917091e-02f, 6.06202260e-02f, -1.82172898e-02f, 9.20188054e-02f, 6.87463861e-03f,
  5.73664270e-02f, -2.17386279e-02f, 4.34591211e-02f, -9.05411988e-02f, 6.06494583e-02f, 1.00992378e-02f, -5.89872524e-02f, 3.21335010e-02f, 7.61721805e-02f, -1.18053675e-01f,
  5.87238651e-03f, -1.11286744e-01f, 1.01834863e-01f, -2.66407281e-01f, 4.11555246e-02f, -2.99444258e-01f, -3.50636125e-01f, 1.36617780e-01f, 9.17378962e-02f, -2.37873420e-01f,
  -1.54030189e-01f, -2.90347248e-01f, -3.34531926e-02f, -3.51587415e-01f, -3.80128354e-01f, -1.21483006e-01f, -3.47006798e-01f, -2.94793695e-01f, 3.71390432e-02f, -7.62268975e-02f,
  7.25186337e-03f, -3.39727104e-01f, -1.84368938e-02f, 1.58151627e-01f, -1.14548735e-01f, 2.06930965e-01f, 4.84800376e-02f, 1.64557636e-01f, -1.15737505e-01f, -8.97772796e-03f,
  -1.20911993e-01f, 1.91021748e-02f, 1.53183602e-02f, 1.04034364e-01f, -6.32922053e-02f, -1.05708726e-01f, -1.22667000e-01f, -1.14832195e-02f, 7.32307136e-02f, 4.57172543e-02f,
  -9.46430638e-02f, -2.46803518e-02f, -1.23334907e-01f, -4.20330614e-02f, 3.43305767e-02f, 5.54069914e-02f, 1.03490390e-01f, 1.59547813e-02f, -5.74168488e-02f, -8.40074569e-02f,
  -9.36609134e-03f, -2.85821874e-02f, 3.99797456e-03f, -5.62079586e-02f, -3.69648635e-02f, -3.26671712e-02f, -1.24887032e-02f, 1.95546560e-02f, 4.87044193e-02f, 1.98618267e-02f,
  1.47484494e-02f, -6.62201792e-02f, 6.31654561e-02f, 1.49286147e-02f, -4.46468741e-02f, 3.47646810e-02f, -4.51034382e-02f, -1.00330196e-01f, 1.45307690e-01f, -4.78104018e-02f,
  4.20552231e-02f, -4.29310575e-02f, 4.35245559e-02f, -4.56538089e-02f, -8.15658364e-03f, -8.45144019e-02f, 2.84676980e-02f, 2.22901627e-02f, 2.73479633e-02f, -7.58585567e-03f,
  -2.99138892e-02f, 2.27226261e-02f, 2.27570217e-02f, 3.02562509e-02f, 2.67681591e-02f, 1.70019548e-02f, -3.07250470e-02f, 6.10197112e-02f, 1.27534866e-01f, -1.04839943e-01f,
  -1.28839970e-01f, -8.34038556e-02f, 6.06528074e-02f, -4.00022529e-02f, 2.30002832e-02f, 1.56242952e-01f, 1.25924489e-02f, 2.00181156e-02f, 5.83497472e-02f, 6.21714778e-02f,
  4.79060635e-02f, 2.58684475e-02f, 7.10938424e-02f, 3.57848257e-02f, -2.13602781e-02f, -2.20432431e-02f, -1.04269452e-01f, 3.68725322e-02f, -2.18843427e-02f, -6.09421059e-02f,
  -1.22992001e-01f, -4.55937944e-02f, 7.46968240e-02f, 7.33081847e-02f, -7.50469491e-02f, 2.72832066e-02f, -4.21614647e-02f, 7.96458218e-03f, 7.58081151e-04f, -3.79603021e-02f,
  9.86238476e-03f, -1.63855463e-01f, -3.23918581e-01f, -3.10386032e-01f, 3.36645395e-01f, 1.40700027e-01f, 2.39865005e-01f, -4.06202115e-02f, -9.38338786e-02f, -7.42750838e-02f,
  2.72509158e-01f, -1.61504671e-01f, 3.54914904e-01f, -3.51021081e-01f, 1.66197732e-01f, 3.10743861e-02f, -4.10496980e-01f, -1.77835643e-01f, 2.46428344e-02f, -2.97038555e-02f,
  -1.71737984e-01f, 1.92404184e-02f, -1.62027240e-01f, 1.54053699e-02f, 2.33368296e-02f, -1.86484098e-01f, -4.66510318e-02f, 2.78923035e-01f, -2.38200545e-01f, 1.26288563e-01f,
  -9.54649970e-02f, 9.81156006e-02f, -4.43886258e-02f, -8.24924111e-02f, -4.92688380e-02f, 6.46852627e-02f, -1.59940179e-02f, 1.94202974e-01f, 5.21024019e-02f, -3.81386094e-02f,
  1.94165669e-02f, -7.06970245e-02f, -3.78396586e-02f, 4.41991538e-02f, 5.75373471e-02f, -4.32623215e-02f, 1.85941942e-02f, -5.11141531e-02f, 8.75366852e-02f, 2.40511522e-02f,
  3.11572198e-02f, -7.56346714e-03f, -3.43031734e-02f, -8.48391429e-02f, 3.92373325e-03f, -3.08355559e-02f, -1.05211265e-01f, 1.22397088e-01f, -3.02379597e-02f, -2.92919129e-02f,
  -2.61688717e-02f, 1.15938764e-02f, 3.21771950e-02f, -1.10442787e-02f, 1.36426777e-01f, -2.45018490e-02f, 1.20794838e-02f, 3.30610685e-02f, 7.89519995e-02f, 7.31161609e-02f,
  -5.88095710e-02f, 2.15388685e-02f, 8.59508961e-02f, 4.43300158e-02f, 9.38083138e-03f, 2.61244625e-02f, 1.37853390e-02f, -1.64993515e-03f, -1.43103361e-01f, -1.94046414e-03f,
  8.71992707e-02f, -3.40413698e-03f, 6.98478147e-02f, -1.31486151e-02f, -6.44593593e-03f, 1.32829258e-02f, -5.42993993e-02f, -1.36073828e-01f, 3.90643589e-02f, 3.09904031e-02f,
  7.11701810e-02f, -1.05786562e-01f, -2.52815504e-02f, -2.81681959e-02f, 8.34386330e-03f, 4.70081568e-02f, -3.32400762e-02f, -1.20138183e-01f, -5.28678261e-02f, 7.68524930e-02f,
  -9.69899520e-02f, -4.87662889e-02f, 2.12502982e-02f, 3.25803533e-02f, -8.84895101e-02f, 1.06570654e-01f, -5.01878150e-02f, -8.73487517e-02f, -1.03869691e-01f, -8.30319896e-02f,
  1.25699982e-01f, 3.38220559e-02f, 2.84656342e-02f, 1.36860117e-01f, -8.51089880e-02f, 9.77011696e-02f, 9.63351205e-02f, 7.75448084e-02f, 1.03304029e-01f, -1.12694934e-01f,
  6.60970032e-01f, -4.42142129e-01f, -5.12101762e-02f, 2.70704180e-01f, -1.04511462e-01f, 2.57459879e-01f, 2.51879841e-01f, -2.03327581e-01f, 3.27825606e-01f, -3.55802447e-01f,
  -2.13049859e-01f, 1.68961570e-01f, -2.48151571e-01f, -1.67744488e-01f, 3.89952242e-01f, -1.28847109e-02f, 1.57111540e-01f, 1.41478270e-01f, 3.55832204e-02f, -1.40058011e-01f,
  7.16041550e-02f, -2.13612348e-01f, -8.68168473e-02f, -2.00917587e-01f, 1.90412961e-02f, 9.10340473e-02f, -2.01721236e-01f, -4.11510803e-02f, -1.69390395e-01f, 1.98706016e-02f,
  3.03178988e-02f, -7.22238868e-02f, -4.64415587e-02f, -1.59993581e-02f, 9.56674293e-03f, -8.65196157e-03f, 2.76043359e-02f, 7.73884654e-02f, 9.85128954e-02f, -3.47605124e-02f,
  4.08303365e-02f, -6.49063429e-03f, -4.66974899e-02f, 3.57727520e-02f, 5.23680747e-02f, 1.55727416e-02f, -4.09989432e-02f, -9.12122149e-03f, -2.13400964e-02f, 2.20259316e-02f,
  1.04076285e-02f, -1.13375913e-02f, 2.21245829e-02f, -5.87612055e-02f, 9.87086594e-02f, 5.28883711e-02f, -4.57016751e-03f, 4.99393307e-02f, 1.73368473e-02f, 1.10571392e-01f,
  -4.18936908e-02f, 7.85705149e-02f, 5.59635507e-03f, -6.55064285e-02f, 6.95329905e-02f, -1.03050873e-01f, 1.21290190e-03f, -7.80047402e-02f, 1.26725286e-01f, -5.13685048e-02f,
  1.32572055e-02f, 1.26080913e-02f, -1.30632613e-02f, 1.99755747e-02f, -3.65469567e-02f, 3.76891494e-02f, 5.42911403e-02f, -5.81303537e-02f, 5.18017337e-02f, -3.13714035e-02f,
  -3.25149260e-02f, 5.08982949e-02f, -1.11138346e-02f, 1.08913025e-02f, -3.37804593e-02f, 2.72172317e-02f, -6.55160695e-02f, -5.88166788e-02f, -9.28988401e-03f, 9.44349021e-02f,
  -1.40726849e-01f, -2.32547879e-01f, -3.77332233e-02f, -2.46838816e-02f, 1.22195203e-02f, -2.49765385e-02f, 2.83165631e-04f, -5.59376972e-03f, 5.59516950e-03f, -2.69193314e-02f,
  3.86116095e-02f, 1.20734528e-03f, 2.76935473e-02f, 4.15954068e-02f, -1.54098785e-02f, -9.88931581e-02f, 1.86450556e-02f, 5.59415445e-02f, 4.73389402e-02f, -3.73307802e-02f,
  -2.34033056e-02f, 4.97386046e-02f, 2.57605202e-02f, -1.16203018e-02f, -5.83937429e-02f, -2.53168270e-02f, 5.12660481e-02f, -5.88069856e-03f, -1.98040158e-02f, -3.63737158e-02f,
  -4.80039746e-01f, 1.37191549e-01f, 2.97087789e-01f, -2.66411126e-01f, -2.38415837e-01f, 2.06897378e-01f, 1.88856408e-01f, -2.64149249e-01f, -2.13210553e-01f, 1.26123309e-01f,
  -2.77544200e-01f, 2.20244005e-01f, 2.92121433e-04f, 9.41232294e-02f, -5.33750914e-02f, 1.38379380e-01f, 2.89262608e-02f, 1.15216531e-01f, -6.91100359e-02f, -1.10391922e-01f,
  -2.35919759e-01f, -2.34486356e-01f, 1.57990739e-01f, -1.68438450e-01f, -8.43578130e-02f, -2.32876446e-02f, -2.02656716e-01f, 1.23573236e-01f, 6.39146566e-02f, 3.46266404e-02f,
  -3.83503810e-02f, -1.91298038e-01f, 7.34511539e-02f, 8.00398961e-02f, -7.84967095e-02f, 8.12138766e-02f, 3.85885648e-02f, 8.51286054e-02f, 5.31670228e-02f, 8.08941722e-02f,
  6.10336624e-02f, -7.61172920e-02f, -5.35335466e-02f, 5.17615341e-02f, -2.38698293e-02f, 1.80893466e-02f, 5.65498881e-02f, 7.09035620e-02f, -1.64440144e-02f, 2.12898087e-02f,
  4.84616570e-02f, 8.14698339e-02f, -1.17684435e-02f, -6.12102449e-03f, -3.76802273e-02f, 4.48319204e-02f, 1.00360960e-01f, 4.38166261e-02f, 9.64345131e-03f, -8.49283040e-02f,
  -1.00741729e-01f, -6.94123213e-04f, -3.54582630e-02f, 2.31082505e-03f, -6.51088506e-02f, -4.19220626e-02f, 7.73711801e-02f, 4.42736708e-02f, 2.85036750e-02f, -3.55225317e-02f,
  -1.64641347e-02f, -5.08949533e-02f, -9.82606336e-02f, 4.22121249e-02f, -3.84764224e-02f, -7.41730407e-02f, 1.10665306e-01f, -5.10074422e-02f, -4.13967818e-02f, -5.40944263e-02f,
  -5.90941776e-03f, -4.86528724e-02f, 8.90819915e-03f, 7.45280879e-03f, -1.69947576e-02f, -1.91439409e-02f, -4.19269688e-02f, 7.82806333e-03f, -8.91180336e-03f, 3.13217565e-02f,
  -1.88479260e-01f, -2.63039380e-01f, 4.71131802e-02f, -6.92669228e-02f, 8.15928429e-02f, 5.56874648e-02f, 3.52150341e-03f, -2.57236091e-03f, 6.35772869e-02f, -5.50233051e-02f,
  -5.45133166e-02f, 1.39857074e-02f, 5.29194437e-03f, -4.30111215e-02f, 4.93595302e-02f, -7.09885359e-02f, -3.38247255e-03f, -8.68340731e-02f, -8.68769363e-02f, -6.13106042e-02f,
  -7.76307285e-02f, 2.89505571e-02f, 5.58660328e-02f, -9.02138874e-02f, -1.75012294e-02f, -7.17474893e-02f, -6.22463822e-02f, 2.50757094e-02f, 2.52878144e-02f, 7.07613975e-02f,
  -2.41250724e-01f, -2.10678447e-02f, -1.36048600e-01f, -1.64150149e-01f, -1.16450340e-01f, -1.15144685e-01f, 4.21255916e-01f, -3.56457978e-01f, 3.34568590e-01f, -9.60631482e-03f,
  1.09952735e-02f, 3.45854834e-02f, 2.53713220e-01f, -1.39089718e-01f, -1.27488926e-01f, 3.43217462e-01f, -1.89574286e-01f, -3.31528927e-03f, 7.12136179e-02f, -2.15952441e-01f,
  -1.06963553e-01f, -6.69050887e-02f, -9.58523480e-04f, -2.30808139e-01f, -2.02799201e-01f, -2.08951339e-01f, -1.52409300e-01f, 9.62636024e-02f, -3.72375339e-01f, 2.41923295e-02f,
  -3.12504247e-02f, 6.39677644e-02f, 1.49548814e-01f, 1.43040996e-02f, -8.53218585e-02f, -2.76183523e-02f, -2.76924726e-02f, 3.60480472e-02f, 9.47278440e-02f, 2.28740349e-02f,
  -8.97676498e-03f, -5.38665168e-02f, -3.97620127e-02f, 1.24382526e-01f, -2.22262293e-02f, 4.73059826e-02f, 4.39722538e-02f, -2.18080226e-02f, 1.89726204e-02f, 6.88925833e-02f,
  -7.43777072e-03f, -1.10026620e-01f, -8.19122270e-02f, 5.38090151e-03f, -1.00955656e-02f, 1.94051713e-02f, 2.02776883e-02f, -4.94593531e-02f, -7.91133717e-02f, -3.36319879e-02f,
  -1.80643294e-02f, 1.45105179e-02f, -1.16836745e-02f, -8.16017315e-02f, 1.48944229e-01f, 2.47229114e-02f, -5.39487526e-02f, -9.72618759e-02f, 2.77014393e-02f, 6.74595535e-02f,
  -9.14755315e-02f, -4.40844297e-02f, 1.80841759e-02f, -6.20985180e-02f, 1.04987510e-02f, 9.76709872e-02f, 9.85107385e-03f, -1.52639505e-02f, 8.60286132e-03f, 2.66500376e-02f,
  1.21445656e-02f, -3.79049852e-02f, 7.10091144e-02f, -5.55320755e-02f, 4.36239652e-02f, 9.51646715e-02f, -6.80137947e-02f, 9.43348482e-02f, 1.22081889e-02f, -2.04520356e-02f,
  -1.87959507e-01f, -1.26180783e-01f, 5.35689220e-02f, -9.75503549e-02f, 9.46351960e-02f, -3.40292342e-02f, 6.18402101e-02f, -7.01985210e-02f, -5.94482459e-02f, 5.04657850e-02f,
  -1.67815670e-01f, -7.57382363e-02f, -1.48360655e-01f, -7.90720247e-03f, -6.45664558e-02f, 2.62197051e-02f, -1.08942039e-01f, -7.40608424e-02f, -8.79988000e-02f, -5.15259765e-02f,
  -1.80895045e-01f, -2.76331101e-02f, 2.44410746e-02f, -2.50976477e-02f, -1.46231316e-02f, -7.05470890e-02f, 2.32603177e-02f, -1.41466400e-04f, -1.69900209e-01f, 7.23216161e-02f,
  8.33664276e-03f, 5.48764057e-02f, 2.29382783e-01f, 1.18652105e-01f, -3.98009121e-02f, -5.26859909e-02f, -1.80640548e-01f, 6.29338175e-02f, 4.38013285e-01f, -2.79959828e-01f,
  -3.45141619e-01f, 2.77070105e-02f, -8.32569748e-02f, -2.77332693e-01f, 1.74010262e-01f, 1.96405262e-01f, -1.67841494e-01f, -2.14430287e-01f, 1.40334234e-01f, -1.40441835e-01f,
  6.32039681e-02f, -2.21303970e-01f, 6.92275986e-02f, 2.54277396e-03f, -1.81010067e-01f, 4.86398377e-02f, -1.76833063e-01f, 7.28726164e-02f, -3.05842519e-01f, -9.56628695e-02f,
  9.57288872e-03f, 9.30335149e-02f, -8.52847099e-02f, 4.15695198e-02f, -9.90947559e-02f, -8.87969211e-02f, -1.04175620e-01f, -7.18213171e-02f, 7.75547698e-02f, -6.34035096e-02f,
  -1.11978285e-01f, 5.82620986e-02f, 2.94540133e-02f, 2.12515034e-02f, 8.32139552e-02f, -6.83632791e-02f, 2.77522635e-02f, -9.52939596e-03f, -4.84230109e-02f, 3.06353122e-02f,
  -7.93288127e-02f, -1.18364871e-03f, -2.05441285e-02f, -1.98534057e-02f, -8.40729661e-03f, 1.45538999e-02f, 7.25432560e-02f, -5.39224334e-02f, -1.82245206e-02f, 1.28747419e-01f,
  -3.98593508e-02f, -2.07002927e-03f, 5.01363166e-02f, -8.90538096e-03f, -4.90429513e-02f, -1.43470794e-01f, 2.59501580e-02f, -8.75461921e-02f, 2.26577409e-02f, -1.30468562e-01f,
  2.07565520e-02f, 5.19808084e-02f, 3.34891640e-02f, -1.18575366e-02f, -4.16600481e-02f, 7.74076581e-02f, -6.80423155e-02f, -4.81283180e-02f, 8.35118592e-02f, 1.82750225e-02f,
  3.89485396e-02f, 1.19883753e-02f, -1.55181838e-02f, -3.91428843e-02f, -1.01978832e-03f, 3.66083942e-02f, 2.97033438e-03f, 2.65701655e-02f, -3.27055785e-03f, -1.33248180e-01f,
  5.38323596e-02f, 1.84712887e-01f, -3.76144871e-02f, -1.92103926e-02f, -2.17493367e-03f, -4.41729538e-02f, 7.42100924e-02f, -3.61646004e-02f, 9.64566693e-02f, 7.82183837e-04f,
  -5.03638349e-02f, -1.01515457e-01f, -9.45598073e-03f, -1.54431118e-02f, 1.04265176e-01f, 7.84626529e-02f, -6.53835088e-02f, 3.64174843e-02f, -8.04138090e-03f, -4.68570292e-02f,
  -1.27234936e-01f, -7.92973489e-02f, -1.93727147e-02f, -2.69197375e-02f, -3.04981135e-02f, -4.62903082e-02f, 6.10846914e-02f, 5.68391867e-02f, 3.27486498e-03f, -1.93596762e-02f,
  1.87346876e-01f, -1.79175362e-02f, 3.59452851e-02f, -1.85270663e-02f, 1.41391039e-01f, 3.74986708e-01f, -8.49307701e-02f, 1.73774615e-01f, -1.28361508e-01f, -1.47927746e-01f,
  -1.44563794e-01f, 7.81260282e-02f, -9.79288742e-02f, -1.56132594e-01f, 4.93204713e-01f, -2.58490890e-01f, 1.53776675e-01f, -5.97833842e-02f, -1.09869517e-01f, 2.49851510e-01f,
  4.17766385e-02f, 8.65384564e-02f, 7.77851650e-03f, 1.71603590e-01f, 9.59647447e-02f, 6.17060997e-02f, 5.80829009e-02f, 1.21721320e-01f, 1.21451512e-01f, 4.25833045e-03f,
  1.90978777e-02f, -1.22125559e-01f, -7.02108368e-02f, 6.39375905e-03f, 4.73669432e-02f, -1.12224422e-01f, -2.25718808e-03f, -1.11452177e-01f, -5.03987423e-04f, -3.90212499e-02f,
  -8.46680030e-02f, 3.68842902e-03f, 3.15547474e-02f, -3.12754698e-02f, -7.77201355e-02f, 4.32149619e-02f, -3.41069922e-02f, -1.70385484e-02f, -7.03802779e-02f, -5.26420511e-02f,
  -3.14565524e-02f, -3.53183374e-02f, 2.02903952e-02f, -3.12231835e-02f, -4.43561282e-03f, -5.90834171e-02f, 1.00721046e-02f, 6.88459352e-02f, 2.92588882e-02f, 6.02109767e-02f,
  -1.51026934e-01f, 1.74099095e-02f, 4.30217236e-02f, -2.12415848e-02f, 6.53890818e-02f, -8.55470002e-02f, -2.15696618e-02f, -3.90910544e-02f, 4.56747226e-03f, 3.69220637e-02f,
  -4.08308096e-02f, -8.32289755e-02f, -8.11882541e-02f, -3.34213190e-02f, -8.05707052e-02f, -8.48665386e-02f, 5.44438809e-02f, 5.94193116e-02f, -7.21521489e-03f, -6.09568059e-02f,
  -5.33898138e-02f, 6.41227216e-02f, -2.18270235e-02f, 1.71180256e-02f, -7.03310668e-02f, 4.64565679e-02f, -3.98756303e-02f, 7.78655428e-03f, 3.00240032e-02f, 5.79759032e-02f,
  3.36734951e-01f, 3.16256851e-01f, 2.09446829e-02f, -6.07269704e-02f, -8.04430246e-03f, 4.03871126e-02f, -2.30795192e-03f, -2.07427759e-02f, 1.08866304e-01f, 1.58560984e-02f,
  2.58741267e-02f, -2.99133286e-02f, 1.05829738e-01f, -7.40695596e-02f, 1.11754678e-01f, 7.14870775e-03f, 5.61275855e-02f, -1.30068790e-02f, 1.57831863e-01f, 4.89967763e-02f,
  3.21400389e-02f, -1.55731868e-02f, -6.37667403e-02f, 2.30002925e-02f, -8.49029645e-02f, 7.21390247e-02f, 1.12497643e-01f, -5.39210811e-02f, 7.82517195e-02f, -1.05123511e-02f,
  7.57702366e-02f, -3.72906446e-01f, -1.56347960e-01f, 4.02003169e-01f, 3.27559300e-02f, 2.58500874e-01f, 4.37016159e-01f, 9.59467068e-02f, 1.28072724e-01f, 2.57201567e-02f,
  2.87721843e-01f, -1.17831104e-01f, -2.04154546e-03f, 3.60783666e-01f, 5.14956951e-01f, 1.06995836e-01f, 2.85956174e-01f, 1.46937951e-01f, -1.28963470e-01f, -5.05321622e-02f,
  1.15055576e-01f, 3.35840255e-01f, 1.20461345e-01f, -1.11382045e-01f, 2.69333944e-02f, -1.92979008e-01f, 1.02314234e-01f, -6.99595213e-02f, 5.20465970e-02f, 5.21754734e-02f,
  7.91921560e-03f, 1.05534807e-01f, -2.95314249e-02f, 1.15346508e-02f, 2.96382401e-02f, -7.47959316e-02f, -1.61567163e-02f, 5.24890460e-02f, 3.05395871e-02f, 2.49228589e-02f,
  -9.27999243e-03f, -1.51754087e-02f, 1.31813958e-01f, -6.33578375e-02f, -5.98526979e-03f, -4.69553731e-02f, 2.35868637e-02f, -1.04084179e-01f, 5.94031904e-03f, -4.56415787e-02f,
  -4.07775119e-02f, -3.48924547e-02f, 1.05697429e-02f, 9.60221607e-03f, 4.07723337e-02f, 6.98906630e-02f, -4.09140177e-02f, -6.63046241e-02f, -4.35206443e-02f, 9.83828772e-03f,
  2.33953130e-02f, -5.45137422e-03f, -4.30155033e-03f, -2.99531855e-02f, -9.58941877e-03f, -6.78772032e-02f, 5.29143810e-02f, 9.97813139e-03f, -5.23566417e-02f, -2.24698391e-02f,
  1.29997646e-02f, 3.40055488e-02f, 8.96845609e-02f, 5.52128553e-02f, 4.88529317e-02f, -7.82536902e-03f, 1.50953708e-02f, 7.64024165e-03f, -2.27374230e-02f, 1.08914994e-01f,
  -3.86668891e-02f, 6.09931834e-02f, -1.09290490e-02f, -5.62500507e-02f, 3.99977900e-02f, 3.47031243e-02f, 9.32449475e-03f, -3.38896848e-02f, -4.78126332e-02f, 1.06432423e-01f,
  9.72014368e-02f, 2.46480361e-01f, 5.96394651e-02f, -3.83223519e-02f, -4.61936891e-02f, 4.12961505e-02f, -3.53841633e-02f, -2.18176059e-02f, 5.43629751e-02f, 2.23529804e-03f,
  -1.01041542e-02f, 2.25878563e-02f, -7.90506974e-02f, -5.15724625e-03f, -7.63953775e-02f, 6.47935793e-02f, -2.40914844e-04f, 2.67460551e-02f, 1.04404911e-01f, -5.53757437e-02f,
  3.97185460e-02f, -5.46973012e-03f, 6.43065572e-02f, -4.83408347e-02f, -8.96936357e-02f, 2.07055989e-03f, 3.55987088e-03f, -6.52858168e-02f, 3.61075178e-02f, -2.61161551e-02f,
  3.56825471e-01f, 3.26037139e-01f, -1.09073795e-01f, 6.11698814e-02f, -1.72331378e-01f, -4.67625469e-01f, -1.86525509e-01f, -2.45084055e-02f, -7.24546835e-02f, 1.22204028e-01f,
  -1.80115774e-01f, -1.40970021e-01f, -4.28233296e-02f, -1.24255508e-01f, -5.29905856e-01f, -1.00965686e-01f, -3.61310512e-01f, -2.29227990e-02f, 7.21523985e-02f, -6.99676350e-02f,
  -6.50577247e-02f, -8.32930207e-02f, -8.66556466e-02f, 1.05894744e-01f, 7.91225806e-02f, 3.28311265e-01f, -8.35288409e-03f, -2.56391075e-02f, -5.56107908e-02f, -3.51102464e-02f,
  1.02312773e-01f, 2.41261840e-01f, 8.01052749e-02f, -2.25479398e-02f, -4.27071899e-02f, 6.48768842e-02f, 2.79567372e-02f, -6.85541183e-02f, 6.63151667e-02f, -8.03801939e-02f,
  -2.80726105e-02f, -2.29522586e-02f, 1.08647123e-01f, 2.20937449e-02f, 8.30422342e-02f, 1.16714261e-01f, 4.08338383e-02f, -1.39403027e-02f, 5.09533547e-02f, 5.03142700e-02f,
  -4.46588472e-02f, 2.21672263e-02f, -4.58699539e-02f, -3.80710475e-02f, 5.32323346e-02f, 1.74457126e-03f, -1.14464976e-01f, -6.79877177e-02f, -6.19620234e-02f, -3.24866809e-02f,
  1.41801536e-02f, -6.48236200e-02f, 1.07520096e-01f, 1.29012093e-01f, -8.34895074e-02f, 1.43088952e-01f, 2.37335404e-03f, 1.17572919e-01f, 7.17298985e-02f, -2.78991070e-02f,
  -1.19740933e-01f, 9.85432193e-02f, 8.66024867e-02f, -3.45641375e-02f, -3.39179523e-02f, 3.20755281e-02f, 3.91161703e-02f, 5.31069413e-02f, -1.06396034e-01f, 9.38605219e-02f,
  -3.64479795e-02f, -1.59749344e-01f, -6.97113872e-02f, 6.54753968e-02f, -9.55164135e-02f, -8.56939852e-02f, -1.19873956e-01f, -9.61457659e-03f, -8.54125395e-02f, -1.61479697e-01f,
  -2.00346097e-01f, -1.81391835e-01f, 1.35689713e-02f, 1.03859335e-01f, -3.63017507e-02f, -1.19216464e-01f, -1.24375649e-01f, -4.79288353e-03f, 1.33777375e-03f, -5.62920719e-02f,
  1.00493610e-01f, 8.39189440e-02f, -1.00388840e-01f, 4.58309986e-02f, -1.03071444e-01f, -2.01967433e-01f, -6.95819035e-02f, -2.84686089e-02f, -5.90233058e-02f, -5.88340685e-02f,
  -1.93655472e-02f, -6.05306439e-02f, -1.37662992e-01f, 6.11993037e-02f, -8.78526941e-02f, -7.54336417e-02f, -1.45954965e-02f, -2.18928121e-02f, 4.53713387e-02f, 5.72180096e-03f,
  -4.06710446e-01f, 2.30930328e-01f, 8.41747038e-03f, -1.07056446e-01f, -4.22883779e-01f, -1.45407870e-01f, 7.51796514e-02f, -1.81735560e-01f, 2.50640482e-01f, 1.47452906e-01f,
  -1.96171671e-01f, -1.21665984e-01f, 1.16401635e-01f, -1.28709283e-02f, -2.16313109e-01f, 4.92281556e-01f, -1.61169749e-02f, -3.16351838e-02f, 1.21865205e-01f, -3.35543513e-01f,
  -1.24628143e-02f, -1.63629889e-01f, -5.20482007e-03f, -7.05625191e-02f, -3.31194788e-01f, -1.58813044e-01f, -1.39330134e-01f, 1.32815987e-01f, -2.94447482e-01f, -4.59079444e-02f,
  -6.93471432e-02f, 6.24720426e-03f, -9.21938047e-02f, 5.30589707e-02f, -2.47839287e-01f, -4.44392376e-02f, -4.60412726e-02f, 1.11157419e-02f, -2.61341725e-02f, -2.52285339e-02f,
  8.51107314e-02f, -7.30311051e-02f, -4.29660231e-02f, 1.08530439e-01f, -1.66767556e-02f, -1.41033507e-03f, 1.73601205e-03f, -2.67897863e-02f, -2.07498334e-02f, -2.14107744e-02f,
  7.63668045e-02f, 1.70013541e-03f, 2.40081158e-02f, 2.47126687e-02f, -4.88493778e-02f, -3.63131501e-02f, -7.38059059e-02f, -1.35655135e-01f, 1.03551820e-02f, -9.79558304e-02f,
  5.45020141e-02f, 4.81755566e-03f, -3.08091529e-02f, 3.82497013e-02f, 3.08391079e-02f, -3.99316214e-02f, 8.84595290e-02f, -3.97278443e-02f, 1.46809081e-03f, -2.66938265e-02f,
  -9.19449478e-02f, -3.22032832e-02f, 2.46184878e-02f, 8.19682900e-04f, -1.48300640e-02f, -9.04950127e-03f, 1.07415561e-02f, -1.17656969e-01f, -4.09526937e-02f, -3.11978534e-02f,
  1.49461046e-01f, 2.35131253e-02f, -9.66109261e-02f, -1.53492084e-02f, 1.75990127e-02f, -5.20427115e-02f, 6.06232062e-02f, 9.17533115e-02f, -5.28164543e-02f, -9.76198527e-04f,
  -1.75118729e-01f, 7.70485029e-02f, 5.59049658e-04f, -4.78987321e-02f, 1.85365811e-01f, 6.47410154e-02f, 1.26683161e-01f, -1.45076159e-02f, -1.84058063e-02f, 1.57479495e-02f,
  -2.75759306e-02f, -4.20893207e-02f, -2.12957105e-03f, -7.46197253e-02f, 6.95561916e-02f, -7.46560399e-04f, 3.25512746e-03f, -3.76278311e-02f, -5.56502603e-02f, -8.66802782e-02f,
  -4.51995209e-02f, -6.96014315e-02f, 8.05436745e-02f, -1.23029284e-01f, -9.49938316e-03f, 1.01849828e-02f, -9.73475799e-02f, 1.25628128e-03f, 6.26018047e-02f, 4.99741025e-02f,
  -3.48349959e-01f, 3.72886866e-01f, -4.00430828e-01f, -6.51746765e-02f, 6.94499388e-02f, 3.21886331e-01f, 1.57687455e-01f, 3.32291499e-02f, -4.50053103e-02f, 3.68501335e-01f,
  1.67767808e-01f, -1.40974924e-01f, 1.64665282e-02f, 3.71722728e-01f, 2.91709844e-02f, 1.33902669e-01f, 3.61643970e-01f, 1.54980674e-01f, -1.13715574e-01f, 1.16224252e-01f,
  -1.20522611e-01f, 4.48370069e-01f, -1.43884435e-01f, 3.35662872e-01f, 3.60151529e-02f, -1.43772706e-01f, 1.39280722e-01f, -4.97337468e-02f, 1.28777310e-01f, 2.17359737e-02f,
  -7.79278204e-02f, -1.01554081e-01f, -1.29082337e-01f, -8.16313475e-02f, 5.07554896e-02f, 2.21491959e-02f, -9.21570286e-02f, -4.37350869e-02f, -9.77259651e-02f, -1.62524870e-03f,
  -3.69861238e-02f, 4.40041572e-02f, 5.82377166e-02f, 5.16848639e-02f, -3.66168693e-02f, -5.26928417e-02f, -8.62771198e-02f, -1.43184692e-01f, 5.19033521e-02f, -6.13943525e-02f,
  -5.58486767e-02f, -5.28596081e-02f, -1.17360309e-01f, 3.44754420e-02f, -6.35422468e-02f, -5.38554937e-02f, -2.37086527e-02f, -6.17026240e-02f, -1.40531026e-02f, 7.06515536e-02f,
  4.63008061e-02f, 3.92081663e-02f, -6.92297295e-02f, -3.92363546e-03f, 7.87356049e-02f, -5.30195162e-02f, 6.05707616e-02f, 4.84965257e-02f, -6.27320185e-02f, 6.60385713e-02f,
  9.31673497e-03f, -6.50047585e-02f, -4.50788718e-03f, 3.50225531e-03f, 3.20052430e-02f, -4.18814085e-02f, -1.02254279e-01f, 5.29473349e-02f, 1.72008830e-03f, -2.41298899e-02f,
  -5.91800772e-02f, 1.03294952e-02f, 4.54363297e-04f, -4.06655669e-02f, 6.63745329e-02f, -4.30312827e-02f, 6.83800727e-02f, -7.02905580e-02f, -4.60201167e-02f, 1.40018491e-02f,
  2.28187621e-01f, 4.12099510e-01f, 3.34054455e-02f, 2.76738238e-02f, 2.75290571e-02f, -4.79709078e-03f, 4.84115891e-02f, 8.98740962e-02f, -8.52338411e-03f, 9.44086015e-02f,
  -2.98921950e-02f, 6.68320758e-03f, -6.27401322e-02f, -4.86867279e-02f, 6.08181879e-02f, 4.39114757e-02f, 1.35865882e-01f, 8.00117180e-02f, 4.61537763e-02f, 5.64518049e-02f,
  4.80914824e-02f, 2.72748508e-02f, -1.22733330e-02f, 4.43727896e-02f, 7.37348869e-02f, 6.91243485e-02f, 5.35005890e-02f, -4.21989225e-02f, 4.04334143e-02f, 3.95851322e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.12564802e-01f, 7.47324228e-01f, 5.14034152e-01f, -6.21175885e-01f, 2.04484001e-01f, 1.19569778e-01f, -4.96500343e-01f, 1.95114046e-01f, -1.04907908e-01f, -1.24334879e-01f,
  -2.63911754e-01f, 2.65604407e-01f, 2.64883459e-01f, -1.79455072e-01f, -3.37523252e-01f, 4.75303903e-02f, -4.02956247e-01f, -3.99772704e-01f, 9.59204063e-02f, -3.61011416e-01f,
  -3.22038978e-01f, -4.98358667e-01f, -4.42663915e-02f, 1.63541168e-01f, -2.86850873e-02f, 5.20196594e-02f, -4.77692991e-01f, 1.70544565e-01f, -9.24720243e-02f, 5.10898978e-02f,
  -1.39514461e-01f, -3.67592871e-01f, 1.46097407e-01f, 5.47350645e-02f, -1.41113251e-01f, -2.98374426e-02f, -8.17489326e-02f, 6.40449524e-02f, -4.63418476e-02f, 1.15689367e-01f,
  2.33225040e-02f, 1.18004389e-01f, -2.82756016e-02f, -1.99085642e-02f, 6.63958341e-02f, 1.40786260e-01f, 1.95702463e-01f, 1.16745874e-01f, 1.45166859e-01f, 2.08581895e-01f,
  1.98244572e-01f, 1.28814906e-01f, 1.97766759e-02f, 7.97197397e-04f, 8.74690488e-02f, -1.84619911e-02f, -1.86340511e-02f, 5.90547803e-04f, 8.99744853e-02f, -5.02471738e-02f,
  -9.70943272e-02f, -1.54735550e-01f, 4.33087572e-02f, -1.97571106e-02f, 3.32437791e-02f, 1.15216807e-01f, 3.96080278e-02f, -3.02663893e-02f, -1.49513036e-02f, 2.60256454e-02f,
  -4.11166064e-02f, 8.48346949e-02f, -1.00457296e-01f, -7.54484013e-02f, -2.00322643e-01f, -8.39246586e-02f, -3.13300043e-02f, 7.32686967e-02f, 1.03983022e-02f, 2.72179022e-03f,
  -7.82360211e-02f, -1.19679831e-01f, 1.31815914e-02f, -2.25884025e-03f, -1.14877783e-02f, 3.58078280e-03f, 5.78516684e-02f, 9.21774581e-02f, 3.40473764e-02f, -8.66211578e-02f,
  -4.63871747e-01f, -7.77687728e-01f, -9.26034376e-02f, 2.20485218e-03f, -5.78103997e-02f, -3.48318219e-02f, 1.38537725e-02f, 2.20829006e-02f, -1.71192110e-01f, -1.45874709e-01f,
  -6.56672418e-02f, -1.20633312e-01f, -1.97236478e-01f, -3.27361561e-02f, -1.13635220e-01f, 3.43116820e-02f, -1.84666917e-01f, -1.19893216e-01f, -2.19725549e-01f, 8.36791247e-02f,
  3.78293879e-02f, -1.31966233e-01f, -3.49713266e-02f, -1.19057834e-01f, -1.44603118e-01f, -7.18213916e-02f, -1.33071959e-01f, 6.29706755e-02f, -4.76293750e-02f, 1.53535027e-02f,
  3.76062661e-01f, 2.27426112e-01f, -3.34073156e-01f, -1.16013633e-02f, -8.39407444e-02f, -1.27339274e-01f, -6.78082287e-01f, 4.38799933e-02f, -5.57577491e-01f, -1.71066388e-01f,
  8.11335966e-02f, -1.92789897e-01f, -2.58476108e-01f, 5.57430387e-01f, 4.54575926e-01f, 2.53180623e-01f, 5.26596010e-01f, 3.57115090e-01f, 2.88168669e-01f, 4.01348263e-01f,
  4.49202478e-01f, 6.80821121e-01f, 4.46147203e-01f, 6.24549747e-01f, 4.77263123e-01f, 2.02342093e-01f, 2.92176932e-01f, -1.26312524e-01f, 3.64848524e-01f, 1.35444030e-01f,
  9.02603939e-02f, 8.07988644e-02f, 6.20572791e-02f, -7.58196339e-02f, 9.20540616e-02f, -1.32904887e-01f, -2.29328216e-04f, -6.51862025e-02f, -2.11356401e-01f, -1.00831687e-01f,
  -3.21000889e-02f, 2.15016752e-01f, 8.87870565e-02f, -7.25269318e-02f, -5.60754836e-02f, 1.40674170e-02f, 1.97337195e-02f, -1.08205311e-01f, -1.22731484e-01f, 1.01578072e-01f,
  -1.53013587e-01f, -3.99709307e-02f, -1.58534180e-02f, -7.50635639e-02f, -1.71182886e-01f, -1.41465813e-01f, -1.17477298e-01f, -1.75820455e-01f, 3.68446931e-02f, -2.22690194e-03f,
  1.58365414e-01f, -2.00670902e-02f, 8.26446414e-02f, 1.96923781e-02f, 4.79658321e-02f, -3.89995947e-02f, 4.19190124e-04f, -3.05006169e-02f, -4.67246510e-02f, 5.16559407e-02f,
  -1.98564809e-02f, -1.63435712e-02f, -5.77653535e-02f, -4.08634096e-02f, 1.54331177e-01f, 9.97021347e-02f, 2.49076840e-02f, 5.25593646e-02f, -1.41034096e-01f, -9.66321677e-03f,
  -9.15525109e-02f, -1.07445782e-02f, -1.79627631e-02f, 1.00329876e-01f, 9.15564001e-02f, -1.54857144e-01f, 5.42308576e-03f, -5.92450704e-03f, -3.54020819e-02f, 6.11767508e-02f,
  1.60343334e-01f, 3.19694310e-01f, -1.97729934e-02f, -3.59384418e-02f, 9.18360800e-02f, 1.86374053e-01f, 6.84769675e-02f, 1.05022117e-01f, 1.19323745e-01f, 5.41398712e-02f,
  9.02468711e-02f, -7.74077550e-02f, 3.71837541e-02f, -1.80856101e-02f, 3.44923958e-02f, 1.43093541e-02f, -9.21870396e-03f, -6.67094961e-02f, -1.59474649e-02f, 1.76076978e-01f,
  6.78832084e-02f, 4.87825312e-02f, 8.37968960e-02f, -1.71847671e-01f, -2.71133124e-03f, -2.06050605e-01f, 6.46373257e-02f, 5.47057688e-02f, 1.33404508e-01f, -1.29135493e-02f,
  -4.15916771e-01f, 5.04307687e-01f, -2.01077402e-01f, -3.61623755e-03f, 2.36663908e-01f, -5.69721878e-01f, -1.65074930e-01f, 1.57848731e-01f, -2.87365317e-01f, 4.65636671e-01f,
  1.54136136e-01f, 6.70245811e-02f, 2.35857978e-01f, -2.38992512e-01f, -6.91838682e-01f, -4.06714857e-01f, -1.68280214e-01f, -1.62199721e-01f, -1.25661612e-01f, 3.62711251e-01f,
  -2.15339422e-01f, 1.89967170e-01f, -1.15241170e-01f, 3.85716081e-01f, 2.05259696e-01f, 2.97514588e-01f, 5.15846193e-01f, 1.89064205e-01f, 1.48837954e-01f, -1.41762584e-01f,
  -1.60789371e-01f, 2.32906699e-01f, 3.51071842e-02f, -1.72801286e-01f, -7.17604533e-02f, 5.86931594e-02f, 8.58471170e-02f, -9.23213661e-02f, -7.01667815e-02f, -4.03098166e-02f,
  6.57589883e-02f, -1.06793747e-03f, -2.66590016e-03f, -7.41746649e-02f, -5.35475556e-03f, 2.79117525e-02f, -1.66849673e-01f, -6.72073811e-02f, 4.87414524e-02f, -1.01905480e-01f,
  -2.41068944e-01f, -8.86721388e-02f, 5.14549129e-02f, -3.94441038e-02f, 2.15071067e-02f, -9.02978480e-02f, -1.10672973e-01f, 4.56828158e-03f, -5.36650456e-02f, 3.12512484e-03f,
  7.91300014e-02f, 5.08832149e-02f, -4.93314974e-02f, -1.68873593e-02f, 5.18992953e-02f, 8.37217495e-02f, 2.57340148e-02f, 1.74616575e-02f, 4.03533913e-02f, 1.30659282e-01f,
  -3.90929207e-02f, -5.57638472e-03f, 3.97718959e-02f, 5.63017689e-02f, -3.85923460e-02f, -5.60027994e-02f, -2.74093188e-02f, 9.72639956e-03f, -4.28978056e-02f, -1.89980954e-01f,
  8.25525895e-02f, 4.59951162e-02f, 1.84742250e-02f, 7.60986060e-02f, -6.68862388e-02f, 3.10726017e-02f, 2.40500122e-01f, -6.70308694e-02f, 7.98542500e-02f, 1.40615115e-02f,
  3.08147315e-02f, 3.48394513e-01f, 5.43334968e-02f, -2.75697242e-02f, 8.55108723e-03f, -1.62972063e-02f, -1.63724676e-01f, -4.48750630e-02f, 1.00959189e-01f, -3.58891417e-03f,
  2.15454251e-01f, 8.63618255e-02f, 2.14011390e-02f, 1.07184127e-01f, -3.62595380e-03f, 9.59552601e-02f, 2.19561994e-01f, 1.66766599e-01f, 6.35714680e-02f, 1.29146621e-01f,
  2.88325578e-01f, 1.74302518e-01f, -4.55434714e-03f, -6.89836070e-02f, 1.30938962e-01f, 1.25285378e-02f, 1.22864716e-01f, 2.53235847e-02f, 7.71241263e-02f, 6.60802722e-02f,
  3.65136504e-01f, -6.74334168e-01f, 3.63745928e-01f, 1.17808484e-01f, 4.37091649e-01f, 2.91994900e-01f, 4.62618470e-01f, -1.31450936e-01f, -1.53879344e-01f, -6.03372633e-01f,
  -1.71825260e-01f, 1.01721957e-01f, -1.06914863e-01f, 6.58679241e-03f, 6.80954933e-01f, -1.21811807e-01f, -1.16092814e-02f, 8.67311507e-02f, 1.83345508e-02f, -1.79128386e-02f,
  7.06069022e-02f, 1.26430774e-02f, 2.13876218e-01f, -4.20407206e-01f, 1.81821093e-01f, -1.44841626e-01f, -1.52586296e-01f, 2.25700125e-01f, -6.47629574e-02f, 3.83375883e-01f,
  -1.79466769e-01f, -2.58782357e-01f, -1.00689661e-03f, -4.12374772e-02f, -2.14032263e-01f, 4.67395261e-02f, 1.22579439e-02f, 2.09279805e-01f, 2.32104272e-01f, 3.82604748e-02f,
  -1.94686260e-02f, 1.14670143e-01f, 7.36036524e-03f, 1.29802257e-01f, 6.78613968e-03f, -1.43312272e-02f, 1.26529969e-02f, -1.00965954e-01f, -6.80461671e-05f, 8.27710181e-02f,
  9.28548500e-02f, 1.27784936e-02f, -7.65787810e-02f, -6.20554164e-02f, -1.18516371e-01f, -5.81790246e-02f, -7.26523204e-03f, 1.39749289e-01f, -5.53560592e-02f, 4.02929857e-02f,
  -3.01612001e-02f, -7.09566474e-02f, -1.22759156e-01f, 6.85396343e-02f, 7.56437927e-02f, 6.90624639e-02f, -7.30297267e-02f, -4.17163633e-02f, -5.75438328e-02f, -3.61232162e-02f,
  7.77312741e-02f, -5.27775101e-02f, -2.01386455e-02f, 1.30957201e-01f, -9.05123502e-02f, -5.45440689e-02f, 9.71293151e-02f, 6.33623749e-02f, -9.55963060e-02f, 4.31533493e-02f,
  5.52784093e-02f, -2.61499872e-03f, 4.38657701e-02f, 1.36455700e-01f, -1.17053417e-03f, -1.50177712e-02f, -9.61011797e-02f, 7.50786960e-02f, -7.09941983e-02f, 8.74677971e-02f,
  -5.21766305e-01f, -5.23653209e-01f, -1.92753077e-01f, -8.96807462e-02f, -5.43105602e-02f, -1.43229946e-01f, -3.89712416e-02f, 2.22091191e-02f, -1.27998352e-01f, 8.16929154e-03f,
  -2.04176754e-01f, 2.46541239e-02f, -1.09677345e-01f, 1.08792968e-01f, -1.54141188e-01f, -1.05945945e-01f, 4.45988141e-02f, -8.58478546e-02f, -5.90314120e-02f, -1.87617689e-01f,
  -5.94924092e-02f, -2.02351093e-01f, -3.66768567e-03f, -1.16366379e-01f, -2.44927511e-01f, -1.93060692e-02f, -8.01719949e-02f, -8.15910175e-02f, 9.42591354e-02f, -3.48356776e-02f,
  -6.12539768e-01f, 4.11055058e-01f, 1.86142683e-01f, 1.75720841e-01f, -2.13803556e-02f, -5.80239713e-01f, -1.09163314e-01f, 1.58313394e-01f, -2.71049410e-01f, 3.85593057e-01f,
  4.78482425e-01f, -3.20951380e-02f, 4.75177139e-01f, 1.43608063e-01f, -3.04337054e-01f, 3.71100754e-01f, -3.21866304e-01f, -1.14116140e-01f, 4.76913676e-02f, -5.28169656e-03f,
  3.13038826e-02f, 7.18762055e-02f, 2.82780230e-01f, 1.94580883e-01f, -4.97049242e-02f, 8.67719352e-02f, 4.03792650e-01f, 3.68738949e-01f, -5.90035841e-02f, 6.06906228e-02f,
  2.75087468e-02f, 1.65759161e-01f, 1.10540427e-01f, -1.02117673e-01f, -8.81051347e-02f, -1.63289830e-01f, -1.43357709e-01f, 7.42482916e-02f, -4.56161797e-02f, -6.90469444e-02f,
  -1.58207655e-01f, 6.55476898e-02f, -5.01607172e-02f, 3.47921550e-02f, -2.20127776e-01f, 1.16799697e-01f, -4.99263182e-02f, -1.41384214e-01f, -2.83497781e-03f, -8.88813734e-02f,
  7.06294477e-02f, -9.16167200e-02f, -5.05994596e-02f, -7.30259567e-02f, -2.21638158e-02f, 8.36984590e-02f, -1.44696012e-01f, -8.38672444e-02f, -1.60221308e-01f, -1.69840455e-01f,
  -2.75644600e-01f, -6.18721358e-02f, 6.20748140e-02f, 2.30887920e-01f, 1.28778756e-01f, 5.94342351e-02f, -5.82042485e-02f, -4.78117876e-02f, 9.15356874e-02f, 1.23719402e-01f,
  -3.64703909e-02f, -1.10636968e-02f, 2.81042997e-02f, -1.70210570e-01f, -8.03889930e-02f, -8.47997665e-02f, 1.73879787e-01f, 4.82414812e-02f, -1.44351810e-01f, 2.50216931e-01f,
  2.18644947e-01f, -9.25201401e-02f, -1.22978715e-02f, 7.41772875e-02f, -3.81444022e-02f, 4.99483682e-02f, -3.96137349e-02f, 9.19785500e-02f, 6.70712739e-02f, 1.35887451e-02f,
  3.72287668e-02f, 1.07476130e-01f, 2.22721234e-01f, -2.96983272e-02f, 1.54186487e-01f, 4.88715582e-02f, 4.13717702e-02f, -6.43212497e-02f, -1.34758297e-02f, -8.79668891e-02f,
  -9.93494987e-02f, -4.78908233e-02f, -4.75883037e-02f, -4.14281189e-02f, -2.49695906e-04f, -4.59541641e-02f, 8.78754910e-03f, -3.61456797e-02f, -5.40123656e-02f, 1.08639419e-01f,
  1.48896277e-01f, -3.96938529e-03f, -6.37104064e-02f, -6.45148009e-02f, -8.40650573e-02f, 8.07920173e-02f, -1.81305781e-01f, -6.65817559e-02f, -8.65288377e-02f, 1.14823304e-01f,
  5.79275906e-01f, 4.95669581e-02f, 2.95712590e-01f, 5.63112497e-01f, -4.63644534e-01f, 4.41129133e-02f, 6.76356927e-02f, 1.32612899e-01f, 8.18782389e-01f, 1.50382578e-01f,
  -4.27723378e-01f, 4.34902400e-01f, -1.31643862e-01f, -7.92657882e-02f, -1.71978459e-01f, 2.65635997e-01f, 9.35043097e-02f, 2.13830456e-01f, 2.39030659e-01f, 1.11680657e-01f,
  7.32544810e-02f, -4.90202159e-01f, -4.51965243e-01f, -4.50825065e-01f, -4.15992022e-01f, 2.38373056e-02f, -5.49286127e-01f, -3.14158916e-01f, -3.04665893e-01f, -3.31874371e-01f,
  3.88632454e-02f, 7.99134597e-02f, -9.72085297e-02f, 4.68157977e-02f, 6.65685013e-02f, -1.03099771e-01f, -1.08097896e-01f, -1.66921914e-01f, 2.72172000e-02f, 2.25827157e-01f,
  1.99148461e-01f, 8.44322816e-02f, 6.44469336e-02f, -7.95561522e-02f, 9.82467383e-02f, 4.32122946e-02f, 3.03181522e-02f, 8.08381364e-02f, 2.95078363e-02f, -7.98816979e-02f,
  5.79114184e-02f, 8.92866552e-02f, -4.76999860e-03f, 1.51337698e-01f, 6.89277425e-02f, 3.33720609e-03f, -1.44986967e-02f, -1.01628236e-01f, 1.21190608e-01f, 5.97925484e-02f,
  -7.88383260e-02f, 1.28373966e-01f, -7.44760931e-02f, -8.25740844e-02f, 8.23542383e-03f, -1.32793382e-01f, 2.24470440e-02f, 1.56953614e-02f, 1.92701817e-01f, -3.16697657e-02f,
  1.96397249e-02f, -2.63410397e-02f, 2.09159832e-02f, 5.42327715e-03f, -7.73766786e-02f, 1.82619765e-01f, -6.08192980e-02f, 8.49114805e-02f, 1.28565446e-01f, -7.18275085e-02f,
  -1.61268964e-01f, 2.39328966e-02f, -5.78050315e-02f, -8.70181695e-02f, -6.02057613e-02f, -1.06090322e-01f, -3.46225426e-02f, 5.54687418e-02f, 9.31536332e-02f, -1.54515624e-01f,
  1.01207517e-01f, -9.20562744e-02f, 1.21507473e-01f, 1.64191902e-01f, 8.87999833e-02f, -1.09067075e-01f, 1.08548425e-01f, 8.85438770e-02f, -1.32915050e-01f, 7.18338531e-04f,
  7.31607620e-03f, 1.40559047e-01f, 9.93133802e-03f, -5.22720255e-03f, 3.34584825e-02f, -7.82069489e-02f, 6.69441521e-02f, 3.50345410e-02f, -8.33831578e-02f, -4.78033200e-02f,
  -2.97380872e-02f, 1.53709635e-01f, 5.96146323e-02f, 2.18088366e-02f, -3.15691541e-05f, 7.32976571e-03f, 1.30819470e-01f, 9.49187353e-02f, -1.79544106e-01f, 6.64376915e-02f,
  -3.91958028e-01f, -2.25908428e-01f, 6.62573457e-01f, -5.63380837e-01f, 2.80841142e-01f, 7.33834147e-01f, 3.68025392e-01f, -2.44550601e-01f, -7.21642137e-01f, -1.66714191e-01f,
  6.47943020e-02f, 1.28141895e-01f, 3.56265336e-01f, -5.18718600e-01f, 7.41813937e-03f, -3.53398025e-01f, -5.84433377e-01f, -1.59168497e-01f, -3.03342849e-01f, -9.28654000e-02f,
  -1.69755012e-01f, -5.82517266e-01f, 1.66790441e-01f, -4.09707904e-01f, -1.41369656e-03f, 6.10283948e-02f, 3.20405178e-02f, 3.60175073e-01f, 9.05007645e-02f, 5.51574714e-02f,
  -1.33205980e-01f, -4.48089719e-01f, 2.54530869e-02f, 2.39806119e-02f, 1.98983729e-01f, 2.82148451e-01f, 2.19229326e-01f, 1.97328150e-01f, 4.07845750e-02f, -3.66997905e-02f,
  1.80633470e-01f, 6.47477359e-02f, -2.06877097e-01f, 1.02236666e-01f, -9.48233381e-02f, -3.82711962e-02f, 1.45218387e-01f, 1.45785809e-01f, 6.64502457e-02f, 1.32693276e-01f,
  9.37414393e-02f, 2.44344428e-01f, 1.44292442e-02f, -5.87605685e-02f, 8.63702521e-02f, -7.91076943e-02f, 7.80399740e-02f, 3.01013798e-01f, -6.63590804e-02f, 1.07847424e-02f,
  -1.03733148e-02f, -6.85716793e-02f, 1.86070785e-01f, -1.05348334e-01f, -8.84488970e-02f, 4.41347882e-02f, -6.79496080e-02f, -4.57475781e-02f, 7.86438286e-02f, 6.21290542e-02f,
  -7.91694298e-02f, 2.54784897e-02f, -1.47001967e-01f, -1.19429089e-01f, 2.02061888e-02f, -1.41812906e-01f, 1.95853218e-01f, 4.75677177e-02f, -1.92614347e-02f, 7.34641701e-02f,
  -1.36793941e-01f, -9.14368480e-02f, 8.29192027e-02f, 4.05486766e-03f, 1.66874640e-02f, 7.08936676e-02f, -5.63665805e-03f, 1.50014937e-01f, -1.42276257e-01f, 1.00750044e-01f,
  6.73257709e-02f, -3.01300496e-01f, -1.11102059e-01f, -6.58530369e-02f, -2.32281648e-02f, 1.38711572e-01f, -1.56276137e-01f, -7.05695078e-02f, 2.05960628e-02f, -8.38301554e-02f,
  1.80118904e-01f, -3.16759534e-02f, 6.99598417e-02f, -7.98509344e-02f, -6.81647509e-02f, 4.80492823e-02f, 1.24122063e-02f, 1.13927267e-01f, 1.28855675e-01f, 1.89883299e-02f,
  6.48389384e-02f, -5.83750382e-02f, -3.32351513e-02f, -1.15072064e-01f, -8.44990984e-02f, 9.44831669e-02f, 5.30072376e-02f, 2.70306459e-03f, 4.14343551e-02f, 5.63510582e-02f,
  9.55209136e-02f, -4.63269889e-01f, -6.57711148e-01f, -8.79816934e-02f, 1.55175731e-01f, 4.05189753e-01f, -1.38639852e-01f, -6.22900799e-02f, -5.69455922e-01f, 3.45558494e-01f,
  4.29668397e-01f, -4.03471082e-01f, -3.75840157e-01f, 4.79402959e-01f, -1.18565097e-01f, -4.46883619e-01f, 5.62934875e-01f, 2.91348904e-01f, -3.45220149e-01f, 1.05326697e-02f,
  -7.15601817e-02f, 6.02368474e-01f, -2.19126880e-01f, 5.05013049e-01f, 2.76215941e-01f, 9.26164351e-03f, 4.94357467e-01f, -1.34727344e-01f, 6.22487426e-01f, 2.55221993e-01f,
  -1.03673860e-02f, -1.28399730e-01f, -1.28281370e-01f, 2.71488745e-02f, 3.94852720e-02f, 1.18871272e-01f, 1.95433363e-01f, 7.07383603e-02f, -2.18388200e-01f, -1.06482022e-01f,
  1.84732035e-01f, -2.32448354e-02f, 1.17313430e-01f, -1.54675424e-01f, 6.34212792e-02f, -6.40367195e-02f, -2.95900494e-01f, -1.22601926e-01f, -2.74339795e-01f, -1.44066483e-01f,
  -3.86726081e-01f, -2.83294264e-02f, 1.01066038e-01f, 1.04642294e-01f, -1.22059777e-01f, -6.59319088e-02f, 3.11771478e-03f, -1.17593430e-01f, 1.32572949e-01f, 4.06016363e-03f,
  1.11354083e-01f, 1.00357495e-01f, 6.33188635e-02f, 4.94310409e-02f, -1.25637069e-01f, 3.29656117e-02f, 7.19486028e-02f, 5.55844717e-02f, -1.56055763e-01f, -4.53154705e-02f,
  1.75082660e-03f, -4.86380383e-02f, 6.38727993e-02f, 9.92548466e-02f, 6.23716302e-02f, 5.39967930e-03f, 7.60293677e-02f, 1.28424820e-02f, -4.68959734e-02f, -1.42430499e-01f,
  -6.82557076e-02f, -6.56880662e-02f, -1.60710067e-02f, 1.28662482e-01f, 5.06224409e-02f, -2.74250675e-02f, 1.71780542e-01f, -5.93432933e-02f, -4.72531319e-02f, 1.89433202e-01f,
  1.57361224e-01f, -2.29819696e-02f, -1.19673796e-01f, 3.54946144e-02f, -1.80655196e-02f, 6.03595562e-02f, 3.75113785e-02f, 4.82129008e-02f, 6.66276440e-02f, -1.10835150e-01f,
  2.10120231e-01f, 3.20133157e-02f, 1.47125721e-01f, -6.05452806e-02f, 6.96134418e-02f, 1.19919434e-01f, 7.17625841e-02f, 5.78487525e-03f, 8.67307335e-02f, 2.13046134e-01f,
  1.73303679e-01f, -5.46072498e-02f, 7.37450346e-02f, -6.95783868e-02f, 1.75588772e-01f, 1.15284666e-01f, 1.05278246e-01f, -4.28107195e-02f, 4.98569869e-02f, -1.07967094e-01f,
  1.61372811e-01f, -1.57471582e-01f, -6.06409907e-01f, -3.42688739e-01f, -1.83252677e-01f, -5.54345667e-01f, -4.50732023e-01f, -2.24020913e-01f, -9.43559632e-02f, 2.55622357e-01f,
  1.60950571e-01f, 7.72057027e-02f, 4.56970423e-01f, -1.84213459e-01f, -4.11721952e-02f, 5.67600131e-01f, -5.18357396e-01f, -1.04991555e-01f, 1.53847650e-01f, -1.45857587e-01f,
  -5.01856953e-02f, 1.87301897e-02f, -9.53982845e-02f, 5.06675150e-03f, -1.11027375e-01f, -6.40067682e-02f, 3.44586849e-01f, -6.27568737e-03f, -2.89914757e-01f, 9.43961516e-02f,
  5.81441261e-02f, 4.99163829e-02f, -1.41146049e-01f, 7.41144419e-02f, -1.93290293e-01f, 3.40768285e-02f, 4.52866405e-02f, -5.37761450e-02f, 5.34766726e-02f, -1.03061654e-01f,
  8.21271092e-02f, 1.08208202e-01f, -6.05835281e-02f, 1.49498284e-01f, -6.21166900e-02f, -4.70786579e-02f, 7.48526305e-03f, -8.35019723e-02f, -5.45905419e-02f, 7.83612654e-02f,
  -6.55504689e-02f, -2.68880576e-02f, -5.60244583e-02f, 9.99774560e-02f, 3.57305980e-03f, 3.21748331e-02f, -6.18547834e-02f, 5.56669720e-02f, -2.68251752e-03f, -6.95494423e-03f,
  4.74848486e-02f, 9.91107300e-02f, 1.04138158e-01f, -9.64460745e-02f, -7.12970421e-02f, 4.64207307e-03f, 1.85272787e-02f, 3.48100439e-02f, 2.73406059e-02f, 1.34727404e-01f,
  -7.17805400e-02f, -7.78333545e-02f, 1.35072351e-01f, -1.30375251e-01f, -3.37415673e-02f, 1.08000219e-01f, -1.23060361e-01f, 9.45755839e-02f, -1.84579268e-01f, -1.23345070e-01f,
  9.25704688e-02f, -3.71272266e-02f, 1.08653484e-02f, 5.04179634e-02f, 6.13528751e-02f, 2.75557656e-02f, 1.19783014e-01f, 9.89549085e-02f, -2.07374189e-02f, -8.54156911e-02f,
  -3.01319491e-02f, -5.57831079e-02f, -4.92123235e-03f, -3.86401750e-02f, -1.39172092e-01f, 1.14130229e-02f, -2.56481599e-02f, -1.68490514e-01f, -1.55369177e-01f, -9.68884081e-02f,
  -1.45955712e-01f, 6.85582012e-02f, -9.08312351e-02f, -2.58494597e-02f, -1.59286901e-01f, -1.96493447e-01f, 4.74573076e-02f, -1.26062026e-02f, -1.16361916e-01f, -2.43166611e-02f,
  -6.31047711e-02f, 4.01192568e-02f, 8.64923149e-02f, -1.13753185e-01f, -3.15911248e-02f, 1.52981311e-01f, -1.20220263e-03f, 1.19122155e-01f, 2.50621941e-02f, -7.91251212e-02f,
  -4.33988541e-01f, -2.63732791e-01f, -4.68463272e-01f, -1.36666492e-01f, 3.54068726e-01f, -3.68376404e-01f, -1.18389860e-01f, 6.59791660e-03f, 1.27161309e-01f, 2.08506972e-01f,
  -8.73985216e-02f, -2.60229707e-01f, -8.02784041e-02f, -7.28664994e-01f, -7.29206800e-01f, -6.13495767e-01f, -5.77544808e-01f, -4.12830293e-01f, -3.04994658e-02f, -4.15095687e-03f,
  -1.12166293e-01f, 1.23946764e-01f, -5.07550240e-01f, 5.32231271e-01f, 6.59014983e-03f, 2.98924983e-01f, 3.40219975e-01f, 3.49350035e-01f, 7.79505912e-03f, -9.55893099e-02f,
  -2.35109851e-01f, 5.22883125e-02f, -7.65181780e-02f, -1.94840636e-02f, 2.91610900e-02f, 1.36407211e-01f, -1.47436941e-02f, -7.57002234e-02f, 6.79715872e-02f, 3.09239998e-02f,
  4.45356034e-02f, 6.22540638e-02f, -1.27172723e-01f, 2.25671548e-02f, 1.35112852e-01f, -1.44278712e-03f, -1.85573742e-01f, -9.26110893e-02f, 1.39102051e-02f, -3.13477129e-01f,
  -1.37537673e-01f, -1.96944728e-01f, 7.19320104e-02f, -1.48230838e-02f, -1.92121384e-04f, -1.00788347e-01f, -1.79792717e-02f, -1.03567541e-01f, 3.67730074e-02f, -1.05864577e-01f,
  -3.57071683e-02f, 9.73034799e-02f, -6.21291026e-02f, 1.39590707e-02f, -6.95549920e-02f, 1.58692580e-02f, 6.71315044e-02f, 1.09008536e-01f, 8.93229991e-02f, -3.93430851e-02f,
  1.55969962e-01f, -3.72640975e-02f, -5.92900962e-02f, -3.98517819e-03f, -7.36526325e-02f, 2.77400948e-02f, 6.79705516e-02f, -4.11672927e-02f, 6.52730986e-02f, -2.47272775e-02f,
  1.20263193e-02f, -3.64591479e-02f, -2.39912216e-02f, 1.37950674e-01f, -1.91285640e-01f, 1.01032173e-02f, 9.09353271e-02f, -1.73607498e-01f, -8.79449695e-02f, 1.24397628e-01f,
  9.49937701e-02f, 7.05580562e-02f, 5.23204394e-02f, 1.17418349e-01f, -1.61636304e-02f, -2.72103772e-02f, -1.06840260e-01f, -8.66933912e-02f, 1.03639327e-01f, 4.90082763e-02f,
  4.60946746e-03f, 1.71161503e-01f, 1.49885476e-01f, -6.41501993e-02f, 6.93566129e-02f, -1.39050007e-01f, 8.05345923e-02f, 1.20634474e-01f, 2.24602550e-01f, 4.60437201e-02f,
  1.57708794e-01f, 2.39857495e-01f, 1.28250003e-01f, 1.76764950e-01f, 5.80864623e-02f, 6.54896721e-02f, 1.16626404e-01f, -1.79951098e-02f, 2.61859223e-02f, 9.65572521e-02f,
  5.92926852e-02f, 3.63451093e-01f, 6.10886812e-01f, 3.81649345e-01f, 1.89556599e-01f, -2.01548114e-01f, -3.05197686e-01f, 5.31723797e-01f, 3.70825678e-01f, 4.00795639e-02f,
  -2.68923998e-01f, -2.82927841e-01f, 8.34184736e-02f, 7.70839155e-02f, -3.63405526e-01f, -2.69441456e-01f, -3.33848029e-01f, -3.11195165e-01f, 7.38102049e-02f, 1.33006677e-01f,
  6.66601285e-02f, -3.23839873e-01f, 4.26801503e-01f, 2.67444253e-01f, 5.78178644e-01f, 4.16119754e-01f, -1.90355107e-01f, 1.68012857e-01f, -1.89023167e-01f, -3.59730810e-01f,
  -6.90877140e-02f, 4.25075293e-01f, 2.97364891e-01f, 1.99323818e-01f, 1.54813349e-01f, -1.20161444e-01f, -6.94995821e-02f, -1.07862689e-01f, 6.66194409e-02f, 5.99016610e-04f,
  -1.29614890e-01f, 8.12529549e-02f, -5.47872223e-02f, 4.99218889e-03f, 1.10016614e-01f, 2.66656399e-01f, 2.06234246e-01f, 1.54228196e-01f, 2.32266426e-01f, 1.69216409e-01f,
  1.98054239e-01f, 7.55584165e-02f, 8.05604383e-02f, -2.26075217e-01f, 2.10776329e-01f, -2.58052372e-03f, -7.21965451e-03f, -9.56355557e-02f, 6.47829771e-02f, -6.82118861e-03f,
  3.45808640e-02f, -9.53194574e-02f, 1.14924856e-01f, 1.24166764e-01f, -6.93693236e-02f, 1.04327127e-01f, -4.02590968e-02f, -9.94826406e-02f, -7.61744455e-02f, -7.37407357e-02f,
  -4.92276140e-02f, -2.63575204e-02f, 1.79443464e-01f, -4.07385230e-02f, -7.08417147e-02f, 1.31214321e-01f, -1.67026430e-01f, -1.13797002e-01f, -9.60226357e-03f, 8.82339943e-03f,
  -3.03836484e-02f, -1.68390974e-01f, 1.30032673e-01f, -1.14238774e-02f, -4.26172838e-02f, 3.77300419e-02f, 1.57074258e-01f, 1.81878939e-01f, -4.12872955e-02f, -2.42832527e-02f,
  -4.72951710e-01f, -2.01610029e-01f, -1.41397472e-02f, -4.90000024e-02f, -1.41552463e-01f, -1.47317320e-01f, -2.11710427e-02f, 6.03863224e-02f, -1.65427383e-02f, -3.39265876e-02f,
  -1.28261438e-02f, -2.86770370e-02f, -1.90240800e-01f, -8.60073045e-02f, -9.17594135e-02f, -1.19157024e-01f, -2.33682051e-01f, -1.58199534e-01f, -4.83631566e-02f, -5.95066790e-03f,
  1.16494909e-01f, -1.31511793e-01f, -4.10579108e-02f, 1.26659080e-01f, 6.02933653e-02f, -1.70158491e-01f, -1.49904355e-01f, 8.94691944e-02f, 1.02008224e-01f, -2.49683652e-02f,
  8.21300209e-01f, 3.14279735e-01f, 9.63413641e-02f, 5.67484498e-01f, 5.60133934e-01f, 5.19587040e-01f, 3.85595441e-01f, 5.44941783e-01f, 8.35368693e-01f, -1.58807427e-01f,
  -1.14419594e-01f, 2.03371242e-01f, -4.44951117e-01f, 4.35028791e-01f, -4.13944647e-02f, -2.58098036e-01f, 4.85511422e-01f, 2.91805983e-01f, 3.43784779e-01f, 3.50173652e-01f,
  3.97560745e-01f, 5.98635040e-02f, -5.09254217e-01f, -2.24355638e-01f, 2.19997764e-01f, -4.79358025e-02f, -6.76111162e-01f, -4.27410632e-01f, -3.44736904e-01f, -1.98620036e-02f,
  5.80521263e-02f, 2.94544518e-01f, 4.93648276e-02f, -1.76212668e-01f, 5.56006134e-02f, 9.57489852e-03f, -6.67997599e-02f, -1.59596890e-01f, -3.18156742e-02f, 7.32562551e-03f,
  -4.31104563e-02f, -1.63631812e-01f, 7.98839778e-02f, -8.94932672e-02f, 8.84526074e-02f, 7.91053660e-03f, 1.08139977e-01f, 1.85933948e-01f, 2.77584102e-02f, 9.28720385e-02f,
  1.18158855e-01f, 6.79573715e-02f, 1.30646273e-01f, -5.08820452e-02f, 7.10432976e-02f, 1.39468849e-01f, -4.02095020e-02f, -1.20365163e-02f, -7.72244483e-02f, 2.66202480e-01f,
  5.92769645e-02f, -4.16330285e-02f, -5.85560240e-02f, -3.32097150e-02f, 9.13406014e-02f, 1.16350412e-01f, -3.91261186e-03f, -1.08787864e-01f, 6.36130720e-02f, -6.48247218e-03f,
  -2.89522321e-03f, 7.97359571e-02f, 3.54638509e-02f, 1.03078866e-02f, 1.88752890e-01f, 7.73428231e-02f, -5.33762574e-02f, -8.94810557e-02f, 9.33084339e-02f, 9.83068570e-02f,
  4.98145260e-02f, -5.66303395e-02f, -9.34376661e-03f, 1.18599774e-03f, -3.92600372e-02f, 1.70866661e-02f, -6.51489198e-02f, 4.46977578e-02f, -3.69619168e-02f, -4.13632207e-03f,
  1.09178267e-01f, 2.51473635e-01f, -1.19190081e-03f, -1.03058457e-01f, -5.47502898e-02f, 1.08907662e-01f, 3.70921493e-02f, 2.30490416e-01f, 5.00370711e-02f, 2.33793352e-02f,
  1.14492737e-01f, 1.57409348e-02f, 2.84457710e-02f, -8.13793764e-02f, -1.53530985e-01f, 1.36371449e-01f, -2.05201864e-01f, 8.65974929e-03f, 3.43765654e-02f, -8.54388028e-02f,
  -8.42859745e-02f, 7.99854323e-02f, -8.17773268e-02f, 1.76206276e-01f, 4.27438021e-02f, -1.41663730e-01f, 1.78249061e-01f, -1.38313532e-01f, -3.13439630e-02f, -4.21803771e-03f,
  2.83118635e-01f, 2.74254024e-01f, 4.53154474e-01f, 3.42670053e-01f, -3.88622582e-01f, -3.51536751e-01f, 1.46269724e-01f, -3.39926273e-01f, -1.66606322e-01f, -1.30123049e-01f,
  -2.20770895e-01f, 5.50916672e-01f, -3.92428607e-01f, 1.18918680e-01f, 6.50755242e-02f, -4.44037527e-01f, 1.27716959e-01f, 1.27416551e-01f, -1.63651705e-01f, 6.73377961e-02f,
  -1.29269525e-01f, -4.31943744e-01f, 1.36404142e-01f, -2.68668205e-01f, 2.73216575e-01f, 5.57110488e-01f, -4.33632620e-02f, 1.57667339e-01f, 5.55531561e-01f, 1.22491986e-01f,
  -3.15555595e-02f, -7.90845826e-02f, 1.38995111e-01f, 1.16360970e-01f, -1.13381527e-01f, 7.56122032e-03f, 3.09026837e-01f, 3.45833190e-02f, -2.47624591e-02f, 4.27903607e-02f,
  -1.42790638e-02f, 7.91621208e-02f, 1.33305073e-01f, -5.36057167e-03f, 7.53219053e-02f, 1.30571693e-01f, 8.51363540e-02f, 1.36608437e-01f, 1.06768772e-01f, -4.66770772e-03f,
  1.56395048e-01f, 9.60799772e-03f, 2.88239634e-03f, 1.68259457e-01f, 2.49286562e-01f, -1.30302748e-02f, 7.16769248e-02f, 2.42765203e-01f, 6.35805428e-02f, 6.47299886e-02f,
  -1.94740724e-02f, -1.19479381e-01f, -9.68571678e-02f, -1.08837172e-01f, -1.70609474e-01f, -4.69888598e-02f, -3.06615774e-02f, -1.64641157e-01f, 8.51112381e-02f, -4.09790576e-02f,
  6.13401197e-02f, 7.16537684e-02f, -1.67327002e-01f, -2.06821989e-02f, -1.33266240e-01f, -5.06742634e-02f, 1.67369977e-01f, 1.89775899e-02f, 9.45526361e-02f, -2.41635144e-02f,
  -4.07562107e-02f, 5.04620932e-02f, 2.20328048e-02f, -1.42681487e-02f, -1.37342691e-01f, 3.25783975e-02f, 9.22368467e-02f, 1.49235427e-01f, -1.89526901e-01f, 7.94394463e-02f,
  9.98572037e-02f, 9.57629085e-02f, 6.49167970e-03f, 5.85169764e-03f, -7.80436173e-02f, 7.63829574e-02f, -3.25075760e-02f, 1.24272794e-01f, 1.32114932e-01f, -1.13343231e-01f,
  6.55103549e-02f, 1.35020360e-01f, 8.50641355e-02f, 6.36053905e-02f, 5.20633757e-02f, 5.17058447e-02f, 5.40624522e-02f, 7.54376799e-02f, 3.36510614e-02f, 1.10796802e-01f,
  8.31273645e-02f, -8.41086954e-02f, 7.00058322e-03f, 5.02029210e-02f, 1.17934458e-01f, 4.94652800e-02f, 4.99493405e-02f, 5.65824211e-02f, 1.26882598e-01f, 1.74648166e-01f,
  -7.59477556e-01f, 6.43032014e-01f, 1.32476345e-01f, -1.48262680e-01f, -3.55606794e-01f, 1.11210895e+00f, 7.42859006e-01f, 3.36226106e-01f, 3.03707987e-01f, 7.08610535e-01f,
  2.89223075e-01f, -3.15609455e-01f, 4.91498470e-01f, 6.48838878e-01f, 1.75783068e-01f, 7.40140378e-01f, 4.75451469e-01f, 3.26909006e-01f, -3.40286568e-02f, -9.10338610e-02f,
  -1.83080450e-01f, 2.84394801e-01f, -6.10524230e-02f, -2.04407245e-01f, -1.55076638e-01f, -4.20561910e-01f, -3.50191802e-01f, -3.26315075e-01f, 4.71223705e-03f, 2.33803000e-02f,
  2.21666798e-01f, 1.14735007e-01f, 4.74951677e-02f, 1.71897605e-01f, 7.37506747e-02f, -1.65217221e-01f, -2.46204175e-02f, -8.39988887e-02f, -1.58347473e-01f, 2.83609498e-02f,
  -5.94853833e-02f, 3.42551097e-02f, 1.29046619e-01f, -1.53480425e-01f, -1.78475410e-01f, -5.13690640e-04f, -1.20054400e-02f, -6.56708032e-02f, 1.92396641e-01f, 2.33043320e-02f,
  6.45503178e-02f, 1.09125549e-05f, -7.98646882e-02f, 4.50035594e-02f, -5.92104755e-02f, 2.97319423e-02f, 1.83055520e-01f, -3.20640393e-02f, 7.84502402e-02f, 8.18999037e-02f,
  -7.20923245e-02f, 7.92037249e-02f, 1.83655933e-01f, 2.16762945e-02f, 2.24358853e-04f, 1.73837077e-02f, -7.07443804e-02f, -3.94406915e-03f, -1.85372069e-01f, 1.23694234e-01f,
  1.03118701e-03f, -1.26764998e-01f, -1.83742326e-02f, 6.41298443e-02f, -8.08928460e-02f, 1.11693041e-02f, -1.38185501e-01f, 2.48415093e-03f, -9.87122767e-03f, 4.43328395e-02f,
  -4.40187715e-02f, 5.16037606e-02f, 3.90693657e-02f, -8.69119912e-02f, 2.90958378e-02f, -7.39901662e-02f, 9.82402861e-02f, -7.23935887e-02f, 2.18962189e-02f, -9.33197960e-02f,
  3.99017155e-01f, 3.62557739e-01f, 2.25677103e-01f, 6.49043024e-02f, 1.24189623e-01f, 1.91371217e-02f, 2.90120263e-02f, 9.16810334e-02f, 1.84553638e-01f, 2.06999391e-01f,
  -1.57275960e-01f, 4.05701110e-03f, -1.11587986e-01f, -9.55714360e-02f, -8.19243118e-02f, 3.13566983e-01f, 1.94050632e-02f, -6.24539740e-02f, 2.27605179e-02f, -3.26438062e-02f,
  -4.36156280e-02f, -6.47086501e-02f, -4.39600125e-02f, -5.70451189e-03f, -1.93836942e-01f, 5.77840172e-02f, -5.03596663e-02f, -7.70615190e-02f, -3.73000130e-02f, 1.49556637e-01f,
  -4.12080228e-01f, 2.14107201e-01f, -3.67770225e-01f, 4.49009329e-01f, -3.35496277e-01f, 3.13580185e-01f, 5.24387717e-01f, -3.15985739e-01f, 7.12314099e-02f, 3.83219332e-01f,
  6.56779110e-01f, -1.23423047e-01f, 2.39950761e-01f, 7.00169325e-01f, -3.96002024e-01f, 4.35614645e-01f, 4.78775889e-01f, 4.74274248e-01f, -2.99869627e-01f, 1.20031714e-01f,
  -9.91885066e-02f, 4.32389528e-01f, 1.69740841e-01f, -4.21503454e-01f, 2.93007076e-01f, -2.78459847e-01f, 8.14165920e-02f, -4.42107856e-01f, 3.52488816e-01f, -1.37951508e-01f,
  -1.21311054e-01f, -1.49687186e-01f, 8.54225084e-03f, -9.63854790e-02f, -2.65629590e-02f, -1.05229989e-02f, -5.51885106e-02f, -3.68906483e-02f, -1.41460344e-01f, -8.14893693e-02f,
  4.30219509e-02f, -7.24312961e-02f, -8.29375163e-03f, -5.51400036e-02f, 2.85931472e-02f, -7.77628198e-02f, 1.09689355e-01f, 9.32204127e-02f, 5.25769265e-03f, -1.23762190e-02f,
  1.99174419e-01f, 6.57619834e-02f, 1.99302435e-01f, 1.05068080e-01f, -3.43043916e-02f, 3.43486071e-02f, -1.95242595e-02f, -2.09018178e-02f, 1.49370760e-01f, 1.25678326e-03f,
  -9.36681032e-02f, -6.10159859e-02f, 7.34648854e-02f, 9.64730233e-02f, -1.02584846e-01f, 4.46624197e-02f, 2.85762660e-02f, 1.25776371e-02f, -7.25146681e-02f, 4.58852276e-02f,
  3.35547999e-02f, -6.22954406e-02f, -1.73959192e-02f, 3.51506472e-02f, 5.99454269e-02f, 7.78677389e-02f, 2.80194283e-02f, -1.05464482e-03f, 9.99116302e-02f, 5.76535799e-02f,
  -1.70022510e-02f, -8.95774812e-02f, 1.85893536e-01f, 9.06417239e-03f, 4.62792106e-02f, -6.77598044e-02f, 7.83937722e-02f, 1.23798043e-01f, 6.48280680e-02f, -1.11467823e-01f,
  -2.53695607e-01f, -4.56933051e-01f, -3.72540615e-02f, -8.55678022e-02f, -1.22242503e-01f, 1.17312763e-02f, -3.96075100e-02f, 1.88149065e-02f, -1.94051534e-01f, -8.16260204e-02f,
  -7.85520896e-02f, -3.39065045e-02f, -1.81349695e-01f, 1.39355762e-02f, -6.18295856e-02f, 5.66756986e-02f, 8.35183337e-02f, -3.86802591e-02f, -3.24164936e-03f, -1.70980439e-01f,
  2.35404465e-02f, -2.46620495e-02f, -3.62582691e-02f, 2.71989945e-02f, 6.37729913e-02f, -2.20579803e-02f, -1.63954318e-01f, -1.20905504e-01f, 3.28271985e-02f, 4.14819792e-02f,
  -4.28584963e-01f, -3.33844990e-01f, -3.53652984e-01f, -1.22427694e-01f, -5.43240786e-01f, -3.27911228e-01f, -2.05515653e-01f, -4.33141530e-01f, -1.53226942e-01f, 3.07016134e-01f,
  -6.53827786e-02f, -2.89352894e-01f, 3.83807778e-01f, -2.00760111e-01f, 1.15019351e-01f, 6.09233618e-01f, 1.78908870e-01f, 3.17576140e-01f, -6.71492741e-02f, -4.47658122e-01f,
  -2.72818059e-01f, -4.22001392e-01f, 1.45659894e-01f, -4.84750152e-01f, -5.50192297e-01f, -2.43661180e-01f, 4.23928559e-01f, -3.53550106e-01f, -2.23165601e-01f, -3.00105572e-01f,
  -1.77414238e-01f, -4.00660634e-01f, -1.45402044e-01f, -6.00511432e-02f, -3.76450531e-02f, 6.14715368e-02f, 8.22009668e-02f, -1.05284847e-01f, -9.36930627e-02f, -1.73542932e-01f,
  3.25637460e-02f, -1.40021324e-01f, -1.95267275e-01f, 8.31113309e-02f, -5.58786727e-02f, -2.26977468e-01f, -1.40806079e-01f, 1.23368822e-01f, -2.01473251e-01f, -1.18620852e-02f,
  -8.10220540e-02f, 5.68734482e-02f, 3.74072157e-02f, 2.44943097e-01f, -3.60241160e-02f, -1.13304570e-01f, 1.63535669e-01f, 5.82301468e-02f, 3.99761274e-02f, -1.26635849e-01f,
  1.40472511e-02f, 4.53466773e-02f, -4.09762375e-02f, -2.20743772e-02f, -1.50137484e-01f, 2.61400198e-03f, 5.48100658e-02f, 3.81506644e-02f, -4.65776119e-03f, -4.51136716e-02f,
  -1.92328632e-01f, -1.10064156e-01f, -1.65128373e-02f, 1.05591379e-01f, 7.01966286e-02f, 1.05997503e-01f, 2.46373191e-03f, -1.65931478e-01f, 6.66307509e-02f, 1.57896176e-01f,
  4.38090926e-03f, -8.03961754e-02f, 3.29353809e-02f, 1.52327463e-01f, -1.04180843e-01f, 1.20432772e-01f, -5.64529970e-02f, 2.05717552e-02f, 2.23375484e-02f, -3.57003137e-02f,
  -2.69559864e-02f, -1.71530515e-01f, -1.91294402e-01f, -2.03748524e-01f, 1.95375055e-01f, 2.00732760e-02f, -5.98175377e-02f, -2.22016349e-02f, 1.89682040e-02f, -5.43695800e-02f,
  5.39298095e-02f, 1.50533482e-01f, 1.20025359e-01f, -4.13324721e-02f, -8.66564661e-02f, -6.24396559e-03f, 4.75563332e-02f, 1.04068711e-01f, 5.88713735e-02f, -9.43573564e-02f,
  1.16278552e-01f, 3.87939997e-02f, 8.00554007e-02f, 7.87087828e-02f, 1.61708415e-01f, 7.52703100e-02f, -5.02399914e-02f, -1.19856194e-01f, 1.87879149e-02f, 4.52460125e-02f,
  1.37898952e-01f, 6.66395605e-01f, 2.32849687e-01f, 4.67739463e-01f, -3.03063691e-01f, -5.69920182e-01f, -1.91530198e-01f, 1.22112282e-01f, 2.95895576e-01f, 3.53136450e-01f,
  -4.17824276e-02f, 6.91548884e-01f, 5.45274429e-02f, 2.90858060e-01f, -6.73290610e-01f, -2.69484997e-01f, -2.64415026e-01f, 5.52470423e-02f, 1.80472821e-01f, 2.02933282e-01f,
  -1.51661143e-01f, 1.09141879e-01f, -2.07542881e-01f, 4.71486636e-02f, 1.76945582e-01f, 2.82474548e-01f, -1.66689590e-01f, 1.87259197e-01f, 1.44943252e-01f, 4.07188050e-02f,
  -1.66171879e-01f, 4.18179572e-01f, 3.44832875e-02f, 1.61017943e-02f, -2.02926636e-01f, -1.87354654e-01f, -1.24437451e-01f, 2.71437410e-02f, -9.21386480e-03f, 5.29259816e-02f,
  4.58549336e-02f, -6.91795498e-02f, 1.05503477e-01f, 1.16611175e-01f, 1.80583775e-01f, 6.94617331e-02f, 1.02638165e-02f, -8.98563787e-02f, 2.06961930e-01f, -1.31873101e-01f,
  1.63559258e-01f, 3.46197374e-02f, -3.43391970e-02f, 1.09052047e-01f, -1.88566685e-01f, 1.57467753e-01f, -4.22310159e-02f, -7.67056271e-02f, 2.47728620e-02f, 8.67379829e-02f,
  -1.06134042e-02f, 1.22054681e-01f, 9.11531672e-02f, 9.12721083e-02f, 8.26948360e-02f, -6.62274435e-02f, 9.46846083e-02f, -1.86487902e-02f, -8.54267180e-03f, 3.42484773e-03f,
  -3.12702693e-02f, 2.13380605e-01f, 2.12314003e-03f, 4.91888523e-02f, -1.23504689e-02f, 1.87512308e-01f, -2.10788161e-01f, 1.05998166e-01f, -1.65712252e-01f, 1.03771232e-01f,
  1.69018403e-01f, -5.94772212e-02f, 1.37268916e-01f, -1.92196116e-01f, -9.00357962e-02f, 8.10798779e-02f, 9.69123244e-02f, 1.17864601e-01f, -1.35627610e-03f, -1.54607505e-01f,
  -2.25340411e-01f, 3.00989866e-01f, -4.10275683e-02f, 1.29124388e-01f, 1.61213711e-01f, -1.56264603e-02f, -1.21534839e-02f, 2.01150440e-02f, 5.42754717e-02f, -5.26925083e-03f,
  -3.96978147e-02f, -8.97638202e-02f, -1.26418009e-01f, -9.76781361e-03f, -9.57087334e-03f, -3.50184888e-02f, 6.98798969e-02f, 5.81650808e-02f, -5.80532551e-02f, -1.18177971e-02f,
  3.34321335e-02f, 8.26479718e-02f, -1.03294104e-01f, -5.54438494e-02f, -2.09021896e-01f, -5.13889715e-02f, 1.20595373e-01f, 4.34019081e-02f, -7.30966963e-03f, -1.57123342e-01f,
  1.04614049e-02f, -2.85053998e-01f, -3.35727751e-01f, 1.02497064e-01f, 4.83192921e-01f, 4.63989764e-01f, -3.93413216e-01f, 3.35074872e-01f, -9.16049555e-02f, -5.89913964e-01f,
  -1.16440304e-01f, -3.86667579e-01f, -5.07297516e-01f, 2.43809462e-01f, 3.93532485e-01f, -1.62080780e-01f, 3.95598680e-01f, -1.60713896e-01f, 3.73461455e-01f, 1.09431669e-01f,
  3.62249434e-01f, 4.25383091e-01f, 2.00429872e-01f, 3.86562258e-01f, 1.60761386e-01f, 1.49749711e-01f, -5.97850978e-02f, -1.04768850e-01f, 1.54670462e-01f, 6.10565916e-02f,
  2.90356785e-01f, -1.59479067e-01f, -6.30520061e-02f, -8.66505802e-02f, 1.16207581e-02f, -1.48997545e-01f, -1.50642335e-01f, -1.00479156e-01f, 1.79258943e-01f, 8.05054232e-02f,
  -1.01361752e-01f, 1.49860084e-01f, 1.96430579e-01f, 8.58656392e-02f, 1.63821951e-01f, 1.33900210e-01f, 1.87359020e-01f, 9.07346159e-02f, -2.08498854e-02f, 2.78907679e-02f,
  4.08176035e-02f, 1.50099536e-02f, 9.75297838e-02f, 1.58782810e-01f, 9.84829888e-02f, 1.83014721e-01f, -2.00278927e-02f, -2.01853156e-01f, 1.45903632e-01f, 1.00996315e-01f,
  2.40781959e-02f, 1.50945336e-02f, -9.10264030e-02f, 3.99606638e-02f, -1.25775412e-01f, 1.89495325e-01f, 5.92958815e-02f, 5.25592826e-02f, -1.14024259e-01f, -3.60497758e-02f,
  1.90621652e-02f, 6.92809299e-02f, 1.03052810e-01f, -2.15417007e-03f, -6.37594238e-02f, 3.36847864e-02f, -9.89647508e-02f, 1.48596969e-02f, 5.54612987e-02f, 8.73155445e-02f,
  -3.46364416e-02f, 1.39350533e-01f, -5.16695641e-02f, 1.28233492e-01f, 6.25121295e-02f, -7.07484856e-02f, -9.85966101e-02f, -1.73749626e-02f, 7.58439600e-02f, -4.73285355e-02f,
  -2.47437164e-01f, -6.44308090e-01f, 6.73215613e-02f, 1.98516756e-01f, -6.34722635e-02f, -2.57824268e-02f, 5.67053724e-03f, 1.79754227e-01f, -1.31303206e-01f, -6.29790127e-02f,
  2.15067789e-02f, -9.45209488e-02f, -1.31843388e-01f, 9.21792910e-02f, 1.44664664e-02f, 7.73286587e-03f, -1.11300796e-01f, -9.79923755e-02f, -1.03300564e-01f, 3.14719565e-02f,
  -6.84927776e-02f, -6.06324635e-02f, -1.97360888e-02f, 2.79211998e-01f, 1.08916499e-01f, -6.47414029e-02f, 5.38703846e-03f, -4.96006981e-02f, 1.17696129e-01f, 2.10455731e-02f,
  5.70301175e-01f, -8.00984204e-01f, 2.87412763e-01f, 8.65075052e-01f, 2.48050258e-01f, -3.50855142e-01f, 4.03919071e-01f, -5.96435107e-02f, 1.60373271e-01f, -6.34680986e-01f,
  2.42068961e-01f, -2.43932217e-01f, -1.56487431e-02f, 6.99371919e-02f, 6.96856260e-01f, -8.34689438e-02f, -2.21499172e-03f, -1.53292313e-01f, 2.23858982e-01f, 1.10113114e-01f,
  5.11619031e-01f, 1.35556221e-01f, 5.26000142e-01f, -4.07581359e-01f, 8.88974369e-02f, 2.93257902e-03f, 1.56105682e-01f, -5.19188878e-04f, -1.57926798e-01f, -5.63515089e-02f,
  -1.71124175e-01f, 3.16471547e-01f, 2.07722783e-01f, -1.54918700e-01f, 2.04687975e-02f, -2.88185431e-03f, 6.36445284e-02f, 9.25474092e-02f, 2.35062405e-01f, -8.10147151e-02f,
  -4.49133217e-02f, 4.72288355e-02f, -6.88374341e-02f, -2.66762376e-02f, 1.12486007e-02f, -2.74933316e-02f, -3.94766480e-02f, 1.31434221e-02f, 5.59125394e-02f, 8.73411000e-02f,
  8.40438157e-02f, -4.11639214e-02f, 1.96481705e-01f, -1.34804040e-01f, 2.21024856e-01f, 3.51240449e-02f, 2.45230421e-02f, 7.08010234e-03f, -8.70320871e-02f, 5.68002276e-02f,
  -1.94121122e-01f, -5.72906099e-02f, 1.30047463e-03f, 2.10052449e-02f, 4.08624159e-03f, 1.73247218e-01f, -3.12596150e-02f, -5.58106601e-02f, 6.34333491e-02f, -2.76430193e-02f,
  8.81639123e-02f, 7.54307657e-02f, -5.22865057e-02f, 2.72276755e-02f, 5.22954799e-02f, 9.20971856e-03f, 3.19022685e-02f, -7.91333392e-02f, 8.49190131e-02f, 1.93727165e-02f,
  4.22767475e-02f, -2.62324810e-02f, -9.34095383e-02f, 3.48569117e-02f, -1.41122758e-01f, 1.05186708e-01f, 6.02586605e-02f, -7.74491429e-02f, 8.52046236e-02f, 2.59958729e-02f,
  -3.89574379e-01f, -5.55503309e-01f, -2.85747484e-03f, -1.35335341e-01f, -1.86669514e-01f, -1.53993905e-01f, -5.28850183e-02f, -9.88772660e-02f, -1.58818781e-01f, -1.76124088e-02f,
  -9.38993022e-02f, 3.89911607e-02f, -1.27363250e-01f, -6.77114800e-02f, -6.73088729e-02f, 1.54987152e-03f, 1.85319185e-02f, -1.35866985e-01f, 2.24349089e-02f, -5.82830757e-02f,
  4.55752686e-02f, -6.69680983e-02f, 1.87169909e-02f, 7.28588626e-02f, -4.07076068e-02f, 3.05223912e-02f, -1.20577753e-01f, -6.23081326e-02f, -3.84296402e-02f, -6.66149929e-02f,
  -9.06586170e-01f, 5.99395871e-01f, -2.90713221e-01f, -2.89906353e-01f, 5.62550314e-02f, 2.23162726e-01f, 1.53247595e-01f, 2.89657265e-01f, -1.71114169e-02f, 4.41068709e-01f,
  2.80851662e-01f, -2.34407037e-01f, 6.03404582e-01f, 5.13454854e-01f, -4.77587223e-01f, 2.49872118e-01f, -8.73421039e-03f, -3.97802666e-02f, 1.25696003e-01f, -3.66993286e-02f,
  -1.09245360e-01f, 2.62876123e-01f, -1.02099314e-01f, 3.96220982e-01f, -2.48195052e-01f, -2.40086079e-01f, -3.91317099e-01f, 5.98429330e-02f, -1.12114057e-01f, 3.90809408e-04f,
  -5.48007011e-01f, -3.95693660e-01f, -4.04356658e-01f, -2.93466240e-01f, -3.98929238e-01f, -1.80133045e-01f, -2.88138509e-01f, -2.67857276e-02f, -1.02995537e-01f, 1.90409571e-02f,
  -1.91231947e-02f, 4.50531989e-02f, 1.27415672e-01f, 1.92128226e-01f, -7.01097399e-02f, -3.92580628e-02f, 1.36251852e-01f, 1.13280090e-02f, 1.37410685e-01f, 6.88812435e-02f,
  1.42353833e-01f, 9.35488753e-03f, -3.64465937e-02f, 8.25156271e-02f, -8.85588303e-02f, 3.45152132e-02f, -6.68357089e-02f, -2.30448678e-01f, -2.09026024e-01f, -1.37144521e-01f,
  -5.61582576e-03f, 4.81516235e-02f, -1.21139232e-02f, 1.25008281e-02f, 8.72532651e-02f, 1.14536658e-02f, 1.39015436e-01f, -4.09788825e-02f, -5.07753082e-02f, -1.69083651e-03f,
  -5.88313006e-02f, -1.07521102e-01f, -5.23989601e-03f, -7.23784268e-02f, -1.25218472e-02f, -1.29308149e-01f, -3.26126534e-03f, -1.68556813e-02f, 9.78424624e-02f, -1.66889518e-01f,
  -2.97406968e-02f, 6.04948169e-03f, -6.02287659e-03f, -9.42544546e-03f, 1.13880644e-02f, -4.01541777e-02f, 5.91595471e-02f, 4.43614945e-02f, -6.35952055e-02f, -2.86187772e-02f,
  -7.14017570e-01f, -5.74993730e-01f, -1.20671824e-01f, -2.32547030e-01f, -4.24282812e-02f, 1.67149417e-02f, -2.07403302e-02f, -5.42677380e-02f, -1.72433779e-01f, -6.23027794e-02f,
  -5.79420514e-02f, 6.60133809e-02f, -1.65973932e-01f, -1.93662308e-02f, 1.00761522e-02f, -6.42114505e-02f, -1.91388540e-02f, -5.31481355e-02f, -2.06915364e-01f, -8.27388987e-02f,
  -5.20471893e-02f, 1.10168224e-02f, 7.33759701e-02f, -1.15797238e-03f, 2.82966215e-02f, -1.57936513e-01f, -1.57022595e-01f, -3.36981826e-02f, -8.33054632e-02f, 1.46837205e-01f,
  6.66183412e-01f, -4.11491185e-01f, -4.73444253e-01f, 1.41954511e-01f, 4.01665151e-01f, 4.83135164e-01f, 3.85531038e-01f, 6.94330186e-02f, 2.98879534e-01f, 2.57486869e-02f,
  1.38215214e-01f, -3.90613943e-01f, -4.36587334e-01f, 1.30687520e-01f, -3.60360555e-02f, -4.23585892e-01f, 2.20516026e-01f, 7.90570304e-02f, -6.92906231e-02f, 1.84048787e-01f,
  1.00235462e-01f, 4.31055814e-01f, -4.76243615e-01f, 1.70102762e-03f, 5.54562092e-01f, 4.83325273e-02f, -6.33781683e-03f, -2.42623970e-01f, 1.59877203e-02f, -2.33822409e-02f,
  7.93310776e-02f, 1.98433120e-02f, 4.65283394e-02f, -2.24987809e-02f, -7.20903603e-03f, 1.74069241e-01f, 3.70138437e-02f, -2.62056202e-01f, -1.48021042e-01f, 1.19997542e-02f,
  -1.38763472e-01f, -2.33109929e-02f, 7.04226866e-02f, -6.78472891e-02f, 2.30670363e-01f, 1.09167121e-01f, 7.69039392e-02f, 9.45637375e-02f, -7.14095458e-02f, -1.86072484e-01f,
  -2.54379343e-02f, 7.63804615e-02f, 1.33484349e-01f, -1.28991306e-01f, 7.23423138e-02f, 1.12950362e-01f, 5.27452715e-02f, -2.06311092e-01f, 4.20882106e-02f, 4.91002239e-02f,
  -4.19699810e-02f, 6.13841861e-02f, 1.88479260e-01f, 7.94696063e-03f, 1.09470531e-01f, 1.51236355e-03f, 9.53640714e-02f, -1.48127601e-01f, 2.75267288e-02f, 2.03945767e-02f,
  1.09036945e-01f, 5.99814928e-04f, 1.31146982e-02f, 5.69504686e-02f, 8.51677284e-02f, 1.36029914e-01f, -1.85381826e-02f, 1.28618047e-01f, 1.14889927e-01f, 1.40429959e-02f,
  -3.00492942e-02f, 3.55110690e-02f, -4.01341952e-02f, -1.20105051e-01f, -8.00634697e-02f, -6.63859248e-02f, 7.31066912e-02f, 1.59824252e-01f, -1.01525754e-01f, -1.21745828e-03f,
  3.16267535e-02f, -4.41313982e-02f, -6.22082427e-02f, -1.60241574e-01f, -1.93538219e-01f, 2.27069840e-01f, 3.23917754e-02f, 3.52831068e-03f, -1.13505544e-03f, 1.74058348e-01f,
  5.75357266e-02f, 1.02389529e-01f, 3.23633462e-01f, 7.91345816e-03f, -3.44062783e-02f, 7.21877813e-02f, -2.20390186e-02f, 8.39444175e-02f, 9.91504416e-02f, -1.41953817e-02f,
  1.18854202e-01f, 2.65051633e-01f, 9.14547741e-02f, 1.62249357e-01f, 7.47617707e-02f, -3.05659734e-02f, 1.90554217e-01f, 1.11115328e-03f, 5.49538881e-02f, 1.70100704e-02f,
  -6.98356703e-02f, 5.50001919e-01f, 4.95732188e-01f, 3.53651851e-01f, -3.47925723e-01f, -4.30265576e-01f, -1.92230821e-01f, 3.14220637e-02f, 3.46223563e-02f, 2.23151371e-01f,
  -1.47313565e-01f, 2.66536474e-01f, 7.76735619e-02f, 1.90136790e-01f, -4.28975374e-01f, -2.20862895e-01f, 4.26185697e-01f, -3.30868829e-03f, -1.46155193e-01f, 4.21773583e-01f,
  1.87146798e-01f, -1.95625782e-01f, 3.01442653e-01f, -5.33003658e-02f, 2.96207964e-01f, 3.95160407e-01f, 2.30497926e-01f, -2.15870775e-02f, 3.48684609e-01f, -3.45342666e-01f,
  1.03326783e-01f, 6.83932453e-02f, 1.66952208e-01f, 2.76023336e-02f, 1.42366141e-01f, 6.71133772e-02f, 7.46721029e-02f, -1.67541042e-01f, -1.16277598e-01f, 9.42265391e-02f,
  -4.79505137e-02f, -8.21194574e-02f, 6.50604144e-02f, -1.70681864e-01f, -7.45579898e-02f, 1.50593286e-02f, 6.64927959e-02f, 1.36084676e-01f, 6.45363778e-02f, 1.84477493e-01f,
  2.27690160e-01f, 1.37373194e-01f, 7.18792677e-02f, 2.11007044e-01f, 1.05713896e-01f, -7.19310641e-02f, -4.30805888e-03f, 1.68912962e-01f, 8.67265314e-02f, -5.44814542e-02f,
  3.23795080e-02f, -4.47044931e-02f, -5.83116300e-02f, 6.58056960e-02f, -1.21104494e-01f, 6.95797848e-03f, -8.15502107e-02f, -7.79716820e-02f, -1.24469854e-01f, -4.00100425e-02f,
  2.92192213e-02f, 2.41945051e-02f, -1.03886552e-01f, 3.62991951e-02f, -1.85349386e-03f, 9.20243934e-03f, -9.97226834e-02f, 7.83937126e-02f, 1.80782109e-01f, 8.86354968e-02f,
  -9.24086198e-02f, -1.28031611e-01f, 2.68981364e-02f, 6.71023205e-02f, -4.07291204e-02f, -4.46801214e-03f, 5.70770651e-02f, -2.06324775e-02f, -4.41482011e-03f, -5.72505035e-02f,
  1.61585569e-01f, 2.28023633e-01f, 1.16312332e-01f, -1.14539914e-01f, 3.31815444e-02f, -7.54333586e-02f, -6.60755336e-02f, 1.03240162e-01f, 4.03619893e-02f, -8.98914561e-02f,
  3.84760052e-02f, 8.18638727e-02f, 4.15058769e-02f, -1.08254455e-01f, -4.17613462e-02f, 5.53425327e-02f, 1.24786176e-01f, 5.30496687e-02f, 7.20774531e-02f, 1.38796702e-01f,
  1.95777729e-01f, -1.78416949e-02f, 1.33238584e-01f, 2.99715884e-02f, 3.84599008e-02f, 1.53373778e-01f, 6.20325608e-03f, 1.06240651e-02f, 8.77437368e-02f, 1.32740587e-01f,
  -9.18780327e-01f, -1.29195243e-01f, -4.47116643e-01f, -6.46708906e-01f, 4.01018739e-01f, -1.32890744e-02f, -4.33346719e-01f, 1.38087109e-01f, -2.37036869e-01f, 1.55794531e-01f,
  -3.18585820e-02f, -6.14072323e-01f, -4.52350117e-02f, -6.36457086e-01f, -5.86209178e-01f, -5.28049231e-01f, -5.07727981e-01f, -4.29302752e-01f, -3.42321306e-01f, -2.34620929e-01f,
  -2.03561708e-01f, 2.27405876e-02f, -2.93691844e-01f, 6.13382220e-01f, 4.39289113e-04f, 2.49281853e-01f, 3.07945758e-01f, 4.15187389e-01f, 2.66800784e-02f, 4.20447662e-02f,
  -6.01462200e-02f, -1.17259711e-01f, 2.15270021e-03f, 1.07981458e-01f, 9.74359140e-02f, 7.94878528e-02f, 1.20620169e-01f, 7.31617808e-02f, -6.82815462e-02f, -9.57923010e-02f,
  -1.34646753e-02f, 1.58392359e-02f, -1.73435897e-01f, 7.01178238e-02f, 7.94199109e-02f, -5.88922650e-02f, -6.57766312e-02f, 5.88603131e-02f, 4.84920107e-03f, -2.48640314e-01f,
  -3.37815732e-01f, -4.19542566e-02f, -1.70989767e-01f, -8.40510577e-02f, -7.34835342e-02f, -1.86789874e-02f, -8.15785006e-02f, 1.05621172e-02f, -7.56875873e-02f, -1.16348766e-01f,
  4.53481041e-02f, -4.93238308e-02f, 1.33739458e-02f, -1.39482215e-01f, -1.38867155e-01f, 1.33544877e-01f, -1.02430366e-01f, 3.75432968e-02f, -9.32488367e-02f, 3.25566120e-02f,
  2.10923046e-01f, -7.64097869e-02f, 2.50576646e-03f, 2.80256476e-02f, -6.00401945e-02f, -6.26794845e-02f, 1.33399069e-01f, -5.57992905e-02f, -1.33670107e-01f, 1.35777667e-01f,
  9.77811515e-02f, 3.85186523e-02f, 1.30201178e-02f, 9.68379155e-02f, -6.49706796e-02f, -3.94050255e-02f, 9.65025946e-02f, -5.44815212e-02f, -2.37133331e-03f, 7.66693130e-02f,
  1.13953240e-01f, 1.19066067e-01f, 1.67661339e-01f, 2.25254059e-01f, -5.32066226e-02f, -3.35897580e-02f, -2.99115069e-02f, -1.39011105e-03f, 7.61454999e-02f, -5.36911152e-02f,
  6.75125048e-02f, 1.05767429e-01f, 9.53649431e-02f, -1.17033198e-02f, 1.36843801e-01f, -1.77374817e-02f, 6.59994483e-02f, 1.67642355e-01f, 2.11559772e-01f, 1.25286475e-01f,
  1.39089942e-01f, 1.13334186e-01f, -1.11679472e-01f, 1.00092545e-01f, 3.65021043e-02f, 3.82241444e-03f, -3.27304155e-02f, -8.25748369e-02f, -3.95987220e-02f, -5.00687025e-02f,
  4.85177428e-01f, -2.50986606e-01f, -2.00802550e-01f, -3.79477024e-01f, -2.64543802e-01f, -2.68890262e-01f, -1.80785637e-02f, -4.82534438e-01f, -4.20742422e-01f, -4.30193156e-01f,
  -4.18353736e-01f, 2.17827529e-01f, 6.64577186e-01f, -5.01101196e-01f, 6.42565787e-01f, 4.03584957e-01f, -3.51435900e-01f, -1.98227018e-01f, -1.70039937e-01f, 7.19558855e-04f,
  6.39438629e-02f, -5.44667020e-02f, 2.51164407e-01f, -4.21174616e-01f, -2.94027835e-01f, -3.51840824e-01f, 1.32806584e-01f, 5.16753681e-02f, -5.53510249e-01f, -1.96253546e-02f,
  -1.83817074e-01f, -1.59460660e-02f, -8.12011063e-02f, 3.66937853e-02f, -1.15655914e-01f, 7.21954331e-02f, -1.00460285e-02f, 2.92325824e-01f, 5.63687123e-02f, 1.25156000e-01f,
  2.87805706e-01f, 5.04248478e-02f, -2.70928502e-01f, 1.94167450e-01f, -5.56111261e-02f, -2.28526846e-01f, -1.11792445e-01f, -2.79626310e-01f, 9.23772454e-02f, 6.12883717e-02f,
  6.33270107e-03f, -1.33354351e-01f, -1.59453049e-01f, 1.61469117e-01f, 8.86970237e-02f, -1.89677864e-01f, 1.95846424e-01f, 1.25130713e-01f, 2.66175531e-02f, -5.72481491e-02f,
  1.08094946e-01f, 1.25112683e-01f, 5.48953675e-02f, -3.35383713e-02f, 6.62666699e-03f, -1.27841443e-01f, 4.22753952e-02f, 3.40960622e-02f, -1.48409590e-01f, -8.64067674e-02f,
  -1.45770878e-01f, 1.98057964e-02f, -2.36174818e-02f, -1.03143528e-01f, -6.39185542e-03f, 1.83992356e-01f, 1.05788700e-01f, 5.58158979e-02f, -9.91171598e-02f, -2.53773749e-01f,
  -1.02584630e-01f, 4.27418575e-02f, -1.12079782e-02f, 1.96463708e-02f, -2.44530533e-02f, 5.03576472e-02f, -1.42724186e-01f, 9.78378728e-02f, -1.65207341e-01f, 1.70804054e-01f,
  -3.58654298e-02f, 4.31972407e-02f, -1.29456326e-01f, -6.45283759e-02f, -6.13394678e-02f, 2.22883336e-02f, 3.28398421e-02f, -1.24161921e-01f, -8.49776939e-02f, -2.45613530e-02f,
  -1.48663551e-01f, 9.14297625e-02f, -2.79121488e-01f, 9.57671031e-02f, 8.44619703e-03f, -1.75498798e-01f, 1.66260749e-01f, -9.45039745e-03f, 9.16958973e-02f, -6.02801517e-02f,
  -4.25709374e-02f, 8.23929980e-02f, 1.37710854e-01f, -1.40250444e-01f, 7.65518239e-03f, 4.06420305e-02f, 8.82483497e-02f, -9.17830765e-02f, 2.72262573e-01f, -1.14927903e-01f,
  -6.89321637e-01f, -5.25887311e-01f, 6.29546344e-01f, -3.46330166e-01f, 2.31424645e-01f, 5.20248950e-01f, -3.52731012e-02f, -9.32438374e-02f, -4.00230914e-01f, -3.26944530e-01f,
  -1.26204118e-01f, -1.56711906e-01f, -1.39944151e-01f, 8.02847818e-02f, 6.65606976e-01f, 1.67625770e-01f, -8.70569646e-02f, -9.76851061e-02f, 1.36463135e-01f, -1.57388911e-01f,
  8.97001326e-02f, -5.03153764e-02f, 3.33426654e-01f, 1.71592474e-01f, 2.02647239e-01f, -1.43791050e-01f, 4.14642170e-02f, 2.82518923e-01f, 8.72640312e-02f, 3.80274892e-01f,
  -4.55867916e-01f, -4.00826901e-01f, -1.48103833e-01f, -7.69501105e-02f, -1.18335404e-01f, 1.67774111e-02f, 4.74756248e-02f, 2.09430262e-01f, -9.23973471e-02f, -3.50455530e-02f,
  -1.11477323e-01f, 7.57599995e-02f, 2.70875134e-02f, -5.42853866e-03f, -1.83845192e-01f, 6.91923220e-03f, 1.99348330e-02f, -4.72597405e-02f, 7.33705238e-02f, 1.43292293e-01f,
  9.98067707e-02f, 9.81266648e-02f, 1.10440385e-02f, 4.98016477e-02f, 1.72355846e-01f, 8.90079979e-03f, 5.23016490e-02f, 1.09765686e-01f, -1.21587083e-01f, -1.76864229e-02f,
  1.52033031e-01f, 2.31214568e-01f, -1.41679449e-02f, -9.75784957e-02f, 2.33989186e-03f, -8.86322409e-02f, -2.45414302e-02f, 7.93361217e-02f, 1.00988233e-02f, -4.39583249e-02f,
  -8.77910480e-02f, -9.97926854e-03f, -1.75664231e-01f, -1.21325679e-01f, -1.19860105e-01f, -6.06749989e-02f, 1.51898235e-01f, -1.33420631e-01f, 1.58236735e-02f, 1.47252381e-01f,
  3.08367591e-02f, 1.99705064e-02f, -1.25799207e-02f, -4.40472830e-03f, -7.65002593e-02f, 5.68293370e-02f, -2.22538859e-02f, 6.81827916e-03f, -7.43593276e-02f, 7.22486079e-02f,
  -6.75053835e-01f, -6.34334743e-01f, -4.33287546e-02f, -2.13474438e-01f, 2.06326451e-02f, -6.45379201e-02f, 1.23791531e-01f, -1.56968012e-01f, -2.32449725e-01f, -5.92478039e-03f,
  -1.10236913e-01f, 1.25725940e-02f, -1.47254065e-01f, 7.05708787e-02f, 1.51590988e-01f, -1.10745475e-01f, -1.51909441e-01f, -9.70486253e-02f, -1.15419425e-01f, -9.49445441e-02f,
  -1.30093053e-01f, -6.49657920e-02f, 1.69239566e-01f, 8.88798982e-02f, 9.34003294e-02f, -7.19070658e-02f, -9.36882570e-02f, -1.17779858e-02f, 1.11671530e-01f, -1.18283145e-02f,
  -1.98760197e-01f, -2.92695850e-01f, 3.11771840e-01f, 5.06095409e-01f, -2.37328738e-01f, -5.70528746e-01f, -3.53875607e-01f, -4.77236092e-01f, 1.33270994e-01f, -4.01737750e-01f,
  -4.66863692e-01f, 3.41986239e-01f, -5.67454040e-01f, 3.94853979e-01f, 6.04334891e-01f, 7.16581419e-02f, 1.57324135e-01f, 1.22146726e-01f, 1.56274468e-01f, -1.77741334e-01f,
  3.12316716e-01f, 3.29262167e-01f, 3.38031471e-01f, 1.49986014e-01f, 8.79342780e-02f, 4.63236928e-01f, 6.57451510e-01f, 2.70580769e-01f, 7.16098309e-01f, 3.77469957e-01f,
  -1.73006088e-01f, -1.61229130e-02f, -1.26519069e-01f, 8.98687914e-02f, -9.05882344e-02f, -1.71863109e-01f, 3.06015946e-02f, 7.55169615e-02f, 1.32738724e-01f, 6.16649538e-02f,
  -1.27671570e-01f, 7.13752359e-02f, 2.15371966e-01f, 4.67564277e-02f, -8.80370811e-02f, 1.87922567e-01f, 5.61609119e-02f, -2.62224019e-01f, -7.86488429e-02f, -1.62365392e-01f,
  -1.24028184e-01f, -1.10446446e-01f, 6.96253404e-02f, 1.35829300e-01f, 2.37656027e-01f, -1.74510162e-02f, 1.80186927e-01f, 6.48682788e-02f, 2.13272735e-01f, 2.70063192e-01f,
  -1.66389167e-01f, 7.83179253e-02f, 5.97775765e-02f, 8.03182200e-02f, 1.09040640e-01f, 1.28979906e-01f, 7.77484209e-04f, 2.83431006e-03f, 1.26927689e-01f, -8.07313100e-02f,
  1.14698693e-01f, -1.51641201e-02f, 4.31292830e-03f, -8.81276652e-02f, 6.97955787e-02f, -1.11928001e-01f, -8.47308263e-02f, 4.02114503e-02f, -1.71302911e-02f, 1.98973455e-02f,
  2.93709952e-02f, 2.93444116e-02f, 3.96604352e-02f, -1.09833881e-01f, -1.90513097e-02f, -2.85319183e-02f, 5.43400049e-02f, -2.35200617e-02f, -9.55380052e-02f, -1.10697269e-01f,
  -1.13414839e-01f, 4.06042159e-01f, -3.17044221e-02f, -1.26207232e-01f, 6.16553240e-02f, -3.38077322e-02f, 1.95851743e-01f, 3.75865474e-02f, 1.80906430e-01f, 2.31197681e-02f,
  -1.60926804e-01f, 1.39283258e-02f, 2.24836729e-02f, 3.74823250e-02f, 9.63159204e-02f, -5.98220117e-02f, 9.67644453e-02f, 1.41927108e-01f, 1.64479658e-01f, -1.04727149e-02f,
  -6.16428666e-02f, -1.43251061e-01f, 3.73037905e-02f, -1.12341717e-02f, -1.55584112e-01f, -9.93023887e-02f, 9.79691297e-02f, -3.76252532e-02f, 8.26859698e-02f, 9.95574966e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.16251147e-01f, 4.47985321e-01f, 4.72464114e-01f, 5.87718546e-01f, 5.57373524e-01f, 6.24372125e-01f, 7.40099907e-01f, 5.24952471e-01f, 3.06148767e-01f, 4.82889503e-01f,
  7.05729604e-01f, 6.03709221e-01f, 6.02738440e-01f, 7.15810239e-01f, 1.28018305e-01f, 4.06832337e-01f, 4.36046064e-01f, 3.34555686e-01f, 4.55431670e-01f, 4.26923394e-01f,
  5.88683188e-01f, 4.72344995e-01f, 6.40000343e-01f, 4.44804221e-01f, 4.01104271e-01f, 2.58366823e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.27835327e-01f, -7.64423087e-02f, 1.22125067e-01f, -2.32291482e-02f, -6.83823302e-02f, 7.07311183e-02f, -2.19607249e-01f, 1.76031440e-01f, -2.86867023e-01f, 8.06439817e-02f,
  -2.66844392e-01f, -2.06366688e-01f, -9.45654511e-02f, -1.47375077e-01f, -2.77970225e-01f, 8.96873102e-02f, -1.39613137e-01f, -2.97743678e-01f, -1.96845323e-01f, -6.87627137e-01f,
  3.19430172e-01f, -3.26032750e-02f, 3.95979971e-01f, 5.89584112e-02f, 3.66419017e-01f, -3.63629252e-01f, 1.89523473e-01f, -3.26941669e-01f, -2.87626237e-01f, -4.23410177e-01f,
  4.55644429e-01f, 3.46285820e-01f, -4.59866613e-01f, -5.90550721e-01f, 4.10598576e-01f, 1.37458578e-01f, 4.62261140e-01f, 5.21087274e-02f, -3.88068676e-01f, -8.56269002e-02f,
  -4.50671613e-02f, -5.16982973e-01f, 2.66513616e-01f, -2.87700474e-01f, -4.35169548e-01f, 8.10483694e-02f, 9.93498340e-02f, -3.09835196e-01f, -3.82067561e-01f, -8.41067135e-01f,
  -5.22536278e-01f, 5.03232718e-01f, 6.59422159e-01f, 5.85007071e-01f, -2.53145069e-01f, -5.00153303e-01f, -3.66876870e-02f, 5.12505531e-01f, -3.30408573e-01f, 2.27947757e-01f,
  -4.36532825e-01f, -7.38905013e-01f, -2.07624316e-01f, -2.77154326e-01f, 2.08615754e-02f, -2.53134549e-01f, -2.04446346e-01f, -1.42474202e-02f, 2.72459149e-01f, 1.50962576e-01f,
  6.31236807e-02f, -2.31847510e-01f, -4.07781124e-01f, 3.05853009e-01f, 2.43908778e-01f, -4.88823950e-02f, 9.05929133e-02f, -1.83696285e-01f, 2.27535293e-01f, -3.10968816e-01f,
  -1.73899114e-01f, 6.67401552e-02f, -3.90486121e-01f, 6.49944007e-01f, 7.47371137e-01f, 4.94845748e-01f, 2.65036285e-01f, 2.31477425e-01f, -7.22739339e-01f, 3.19399834e-01f,
  5.46594620e-01f, -2.97034860e-01f, 2.34307960e-01f, -5.09357043e-02f, -4.05401587e-01f, -5.04765153e-01f, -5.20319283e-01f, 5.74942946e-01f, -2.93586235e-02f, 8.94090682e-02f,
  -7.35599041e-01f, 2.63640106e-01f, -3.60367477e-01f, 5.10585725e-01f, 8.97696475e-04f, -3.87321532e-01f, -5.20857275e-01f, -8.49590778e-01f, -3.35812390e-01f, 5.49617410e-01f,
  2.29815006e-01f, -4.62452978e-01f, -4.81428385e-01f, 4.36726898e-01f, -5.53628445e-01f, 2.34387413e-01f, 2.83326328e-01f, -4.59609151e-01f, -1.94652900e-01f, 3.68447192e-02f,
  -6.86240494e-01f, -1.05979763e-01f, 5.29855669e-01f, -3.63453656e-01f, -7.22345293e-01f, 2.77265459e-01f, -5.99495649e-01f, -5.71828604e-01f, -2.29449034e-01f, 1.43553630e-01f,
  -1.59399942e-01f, 1.12889763e-02f, -2.34003231e-01f, -2.56316304e-01f, -1.77114561e-01f, -5.40094316e-01f, -6.68230280e-02f, -1.50331095e-01f, -1.15350150e-01f, 4.79499996e-02f,
  -3.77305984e-01f, 5.23006395e-02f, -1.22202948e-01f, -1.17300943e-01f, -4.05858606e-02f, -3.32605809e-01f, 6.69411495e-02f, -4.46141958e-01f, 1.91251561e-01f, 1.59287930e-01f,
  -3.87251042e-02f, -2.87609667e-01f, -2.01812208e-01f, 1.55970499e-01f, -2.50707678e-02f, -2.02355936e-01f, -4.68450218e-01f, 3.18887502e-01f, 2.29857173e-02f, -2.35985056e-01f,
  -1.92706093e-01f, 1.76101610e-01f, 1.63808480e-01f, -1.21738724e-01f, -1.52213186e-01f, 1.98121980e-01f, -3.93396020e-01f, 1.52266085e-01f, -3.68780881e-01f, 2.26648599e-01f,
  -5.55260003e-01f, -3.54632884e-01f, -5.84101617e-01f, 5.36152542e-01f, -5.38733423e-01f, 1.75699830e-01f, -4.16670501e-01f, -4.14909840e-01f, 1.42113730e-01f, -6.38543606e-01f,
  -4.51038510e-01f, -2.62723178e-01f, -4.11984503e-01f, 5.15587211e-01f, 1.93343595e-01f, -2.85098284e-01f, 6.13714419e-02f, -5.96253455e-01f, 3.93565446e-01f, -4.95300382e-01f,
  3.94422770e-01f, 5.28098524e-01f, -2.03128785e-01f, -2.34217629e-01f, 4.82098460e-02f, -9.94455442e-02f, -3.20422500e-01f, 1.37374729e-01f, 1.54135376e-01f, -3.68313789e-01f,
  -1.80477008e-01f, -2.60764539e-01f, -4.91872907e-01f, -4.90376577e-02f, -1.47961080e-01f, -1.14819035e-01f, -1.93509221e-01f, -2.83480406e-01f, -3.32595140e-01f, 3.36168408e-02f,
  1.33148253e-01f, -3.87615502e-01f, 2.07205281e-01f, -2.46458985e-02f, -5.43835521e-01f, -3.51218790e-01f, -1.82323589e-03f, 9.42979939e-03f, -3.05319011e-01f, 2.66319126e-01f,
  3.64219308e-01f, -1.96382299e-01f, -9.89128128e-02f, 5.58885574e-01f, 3.57924774e-02f, -4.53808337e-01f, 1.70070648e-01f, 2.53556550e-01f, 5.73199332e-01f, -2.35704519e-03f,
  3.39186966e-01f, -5.20618975e-01f, 4.06740546e-01f, -3.62104923e-01f, 5.08647978e-01f, -4.31628466e-01f, -2.83576161e-01f, -7.14961410e-01f, 1.69086590e-01f, 3.37583810e-01f,
  3.15725982e-01f, -4.40653354e-01f, -6.47437513e-01f, -5.21950066e-01f, -3.01063895e-01f, -5.50805628e-01f, 6.32849514e-01f, -3.11981797e-01f, -1.50743783e-01f, 6.17138445e-01f,
  -5.01551270e-01f, -4.45032299e-01f, 3.83302957e-01f, -1.99244171e-01f, -3.69641095e-01f, -2.90865958e-01f, -1.65056475e-02f, 1.72265872e-01f, -1.07129542e-02f, 1.39124617e-01f,
  4.69325557e-02f, 9.61068198e-02f, 2.71618329e-02f, 2.81299233e-01f, 1.98455855e-01f, 2.50139147e-01f, 3.14492583e-01f, -1.67360544e-01f, 2.07571328e-01f, -1.43874623e-02f,
  7.05290213e-02f, 3.72445017e-01f, 3.26837331e-01f, -7.16924742e-02f, 2.91471690e-01f, 3.63540888e-01f, -8.54908526e-02f, -2.36567512e-01f, 3.07660699e-01f, 3.91272783e-01f,
  2.95178860e-01f, -2.81536937e-01f, -5.52107453e-01f, 5.73778629e-01f, 2.68420786e-01f, -6.13898277e-01f, 4.74108547e-01f, 1.45004541e-01f, 3.80852044e-01f, 1.32563651e-01f,
  -7.38393068e-01f, -4.34592605e-01f, 2.67960072e-01f, -2.53201723e-01f, 7.13614047e-01f, 4.20167625e-01f, -7.88870335e-01f, -9.51061398e-02f, 1.90880597e-01f, -4.13637847e-01f,
  4.18145925e-01f, -4.73465085e-01f, -2.31168002e-01f, -7.13213801e-01f, 4.18205082e-01f, -4.41875935e-01f, -4.75936472e-01f, 1.94912508e-01f, -4.72400010e-01f, -3.43150884e-01f,
  -5.20272136e-01f, 4.82506901e-01f, -6.11132085e-01f, 4.80482787e-01f, -5.10355711e-01f, -2.05741808e-01f, 6.69554621e-02f, -1.77011937e-01f, 6.73126876e-01f, -3.25203508e-01f,
  2.31008768e-01f, 4.47775096e-01f, 3.59978288e-01f, 1.33895561e-01f, -1.46276504e-01f, 2.30365053e-01f, 1.96777314e-01f, 3.53270829e-01f, 1.04100101e-01f, 1.36181161e-01f,
  2.22821742e-01f, 2.06924945e-01f, 2.88994551e-01f, 1.64103404e-01f, 1.36678576e-01f, 3.40849161e-01f, -1.14846453e-02f, 5.49114533e-02f, 3.33094239e-01f, 4.64354247e-01f,
  -7.71129906e-01f, -3.75630617e-01f, -6.65714025e-01f, 6.00827694e-01f, 5.37280619e-01f, 9.48495418e-02f, -3.72554183e-01f, -6.13635421e-01f, -2.70561546e-01f, 6.25940979e-01f,
  1.88545227e-01f, 2.79241353e-01f, 5.25248706e-01f, 3.74928385e-01f, 4.63169962e-01f, -6.85810745e-01f, 3.08895677e-01f, 7.73198783e-01f, -5.09829342e-01f, -3.22289646e-01f,
  -3.88286680e-01f, -2.23066673e-01f, -6.07286990e-01f, 6.17604792e-01f, -6.40215039e-01f, -5.48817933e-01f, -3.01110715e-01f, -4.81504314e-02f, -6.02112651e-01f, 4.57888693e-01f,
  2.28128269e-01f, 4.08122659e-01f, -1.86771452e-01f, -6.33883625e-02f, 1.06788084e-01f, -4.23455924e-01f, -8.41110229e-01f, 6.34157807e-02f, 6.51529580e-02f, -8.12445283e-02f,
  -5.05461395e-01f, 1.11462802e-01f, -6.43592060e-01f, 4.24440116e-01f, -1.28811132e-02f, -5.06487191e-01f, 7.00474754e-02f, -6.79712296e-02f, -1.39458448e-01f, 3.29870403e-01f,
  1.57467708e-01f, 1.42155826e-01f, 1.09978236e-01f, 8.87712464e-02f, -3.44083250e-01f, -1.25694901e-01f, 6.69424981e-02f, 6.08189590e-02f, 7.36060143e-02f, 1.28570139e-01f,
  4.20257524e-02f, 1.38263926e-01f, -1.16479941e-01f, 2.49562617e-02f, -2.39946574e-01f, -5.80215678e-02f, 3.59919786e-01f, -5.55296838e-01f, -2.36479089e-01f, 4.27000582e-01f,
  8.08774680e-02f, 4.87347484e-01f, 1.92663297e-02f, 2.77397454e-01f, -5.91160834e-01f, 1.88761815e-01f, 4.10960585e-01f, -1.59736127e-01f, 3.50839764e-01f, 2.09411174e-01f,
  -4.30825770e-01f, -5.68836093e-01f, -4.38251346e-01f, -4.26730007e-01f, -4.59203213e-01f, 2.07312822e-01f, -4.65982437e-01f, 4.65187162e-01f, -6.44844830e-01f, -6.80768371e-01f,
  -2.39385292e-01f, 2.64725298e-01f, 5.49265623e-01f, 6.10727251e-01f, -3.52738917e-01f, -5.10857463e-01f, 2.34379992e-02f, -6.00259781e-01f, -6.52223051e-01f, 3.43740642e-01f,
  7.09989607e-01f, -5.21636009e-01f, 5.75346351e-01f, -3.68655860e-01f, -4.95667197e-03f, -6.24393225e-01f, -2.37015948e-01f, -4.41751868e-01f, -7.42778853e-02f, 4.39049825e-02f,
  8.34598020e-02f, -3.92012328e-01f, 8.89902469e-03f, -1.77162573e-01f, -4.86983925e-01f, -2.99270898e-01f, -3.00596297e-01f, -2.77157187e-01f, 9.14387628e-02f, 1.64435104e-01f,
  -2.00773895e-01f, -2.87577242e-01f, -1.70175955e-01f, -2.96585947e-01f, -1.49324760e-01f, -3.15855220e-02f, -3.27648252e-01f, 4.84979711e-02f, -5.23230471e-02f, 3.16874772e-01f,
  -2.55349904e-01f, -1.11779369e-01f, -3.70840617e-02f, -3.34669560e-01f, -3.22939157e-01f, 1.14860654e-01f, -1.19562656e-01f, 2.33323842e-01f, -2.39323154e-01f, 1.75412104e-01f,
  3.17761570e-01f, -2.81915903e-01f, -2.21153408e-01f, 3.47427756e-01f, 2.93231338e-01f, -2.69059032e-01f, 2.88240731e-01f, -5.25864735e-02f, -3.55974615e-01f, -3.08331311e-01f,
  -6.65206090e-03f, 4.16471511e-01f, -2.19531320e-02f, -5.99789977e-01f, 4.15121198e-01f, 1.00109935e-01f, -3.72310489e-01f, -4.47297424e-01f, -1.27584085e-01f, -5.16883373e-01f,
  -5.10914266e-01f, 5.18159628e-01f, -2.11798579e-01f, -3.34232479e-01f, -2.96282381e-01f, -3.85132104e-01f, -2.10394174e-01f, -4.16924983e-01f, -3.13907526e-02f, 5.23229182e-01f,
  -1.83817565e-01f, 4.01451081e-01f, 6.32217005e-02f, 6.82411529e-03f, 7.71098863e-03f, -1.78824022e-01f, -1.10802807e-01f, -3.64404470e-01f, 1.31160319e-02f, 9.96657163e-02f,
  -1.03559509e-01f, -2.47359410e-01f, -2.06091732e-01f, -2.62594998e-01f, -2.90470481e-01f, 8.25072601e-02f, -2.41065979e-01f, 7.03662336e-02f, 1.51301950e-01f, -9.70905647e-02f,
  -7.33164698e-02f, 2.31567457e-01f, -3.63171786e-01f, 2.37847313e-01f, -2.72142649e-01f, 1.02818504e-01f, -1.91587925e-01f, -4.69718307e-01f, 4.01142053e-02f, 1.13733798e-01f,
  -3.10711741e-01f, -3.65072161e-01f, -4.61659610e-01f, -1.14174247e-01f, 6.35232776e-02f, 2.48926103e-01f, 3.60957146e-01f, -1.24974407e-01f, -1.98874414e-01f, 8.31476226e-03f,
  -3.51479918e-01f, 4.03653055e-01f, 3.80303025e-01f, -6.53467357e-01f, 4.30372357e-01f, -3.85670453e-01f, -4.83981788e-01f, -8.67798775e-02f, -3.71696234e-01f, -2.84807116e-01f,
  2.88890541e-01f, -2.25099791e-02f, 2.96457618e-01f, -4.72544879e-01f, -4.70234573e-01f, -2.57901609e-01f, 2.82498896e-01f, -2.87511766e-01f, 3.67602229e-01f, -3.72627109e-01f,
  -7.08450079e-01f, 5.41271269e-01f, -3.45387280e-01f, 3.75482291e-02f, -2.44184002e-01f, 4.96133029e-01f, 1.57071993e-01f, -6.04919568e-02f, -2.60670893e-02f, 1.06583707e-01f,
  8.59557390e-02f, -3.13604921e-01f, 2.62226135e-01f, -1.24219954e-02f, 2.62611777e-01f, -1.85811464e-02f, -2.81575620e-01f, 1.00464083e-01f, -7.28563666e-02f, 2.50184268e-01f,
  8.31391290e-02f, 1.09202981e-01f, -4.78631556e-02f, 1.35956988e-01f, -5.65181971e-02f, 1.60736322e-01f, -3.29835504e-01f, -6.27665594e-02f, 3.30985934e-01f, -4.03579503e-01f,
  5.07724047e-01f, -4.01436180e-01f, 4.71799433e-01f, -4.37962353e-01f, 5.29268503e-01f, 4.06892478e-01f, 4.14320171e-01f, 3.33289981e-01f, -1.45601764e-01f, 1.80389553e-01f,
  2.55825192e-01f, -4.29792613e-01f, -2.00903431e-01f, -3.90491754e-01f, -2.79863089e-01f, -7.19859481e-01f, -2.70855635e-01f, 6.22769177e-01f, 9.77397785e-02f, -5.34310341e-01f,
  6.00920141e-01f, -3.11221659e-01f, -1.82459742e-01f, -4.80236560e-01f, -8.50837290e-01f, -6.29889309e-01f, 2.15862647e-01f, -4.31132674e-01f, -3.55791599e-01f, 7.64604136e-02f,
  -3.69386017e-01f, -4.50548023e-01f, 5.38612008e-01f, -6.97730124e-01f, -4.29867059e-01f, -4.22268718e-01f, -5.78098953e-01f, 7.04007387e-01f, 5.95704556e-01f, -1.39757350e-01f,
  8.61412510e-02f, 7.69732296e-02f, 1.71951398e-01f, 9.83371865e-03f, 2.69877732e-01f, 8.05947036e-02f, 2.39621088e-01f, 1.46413326e-01f, 3.24612893e-02f, -3.76747064e-02f,
  -2.27470491e-02f, 1.16469190e-01f, 1.32844433e-01f, -1.21911867e-02f, 1.63254961e-01f, 1.68619767e-01f, 2.58658975e-01f, 1.06954202e-01f, -3.03461533e-02f, -1.03282079e-01f,
  2.25617647e-01f, 4.06063050e-01f, 2.78221756e-01f, 3.31522256e-01f, -2.06853092e-01f, -3.90015133e-02f, -5.33181056e-03f, 3.67461950e-01f, 1.20425791e-01f, -4.35826153e-01f,
  -3.42902809e-01f, -5.04285157e-01f, -3.56421500e-01f, 3.07274878e-01f, -3.93043220e-01f, 1.67519927e-01f, -4.52115119e-01f, 2.00814515e-01f, -6.46810830e-01f, -6.04150295e-01f,
  5.23727298e-01f, -4.51370537e-01f, 5.78714209e-03f, -5.16558111e-01f, 5.09574652e-01f, 5.08125126e-01f, -1.57885641e-01f, 6.19285166e-01f, -1.52152121e-01f, -3.44341159e-01f,
  -1.91290110e-01f, -6.38594091e-01f, -4.51103747e-01f, 2.30368331e-01f, -4.62975442e-01f, -4.20936316e-01f, -4.29142982e-01f, -8.07609975e-01f, 3.57556373e-01f, 1.42294064e-01f,
  6.10287488e-01f, -4.91119951e-01f, -5.83970964e-01f, -5.43017209e-01f, 1.10409483e-01f, 7.33870864e-02f, -2.96090037e-01f, 6.78837597e-02f, 1.19674921e-01f, 2.34649908e-02f,
  -4.75466043e-01f, -8.86755735e-02f, 2.07561716e-01f, -1.02177747e-01f, 1.08472772e-01f, 6.47780076e-02f, 1.12057529e-01f, 1.37531936e-01f, 4.53917384e-02f, -2.34264418e-01f,
  -8.68136510e-02f, 8.31465349e-02f, -4.73133400e-02f, -3.72040749e-01f, 8.36258382e-02f, -4.05819178e-01f, 4.07597199e-02f, 8.56072903e-02f, -2.46456116e-01f, 4.86868799e-01f,
  -3.56823951e-01f, -5.82629852e-02f, -3.91333520e-01f, 1.50793180e-01f, 4.51597631e-01f, -2.80030817e-01f, -1.29424080e-01f, -1.06854349e-01f, -5.28142929e-01f, 5.68129599e-01f,
  -2.87220895e-01f, -4.37813342e-01f, 3.70860636e-01f, -4.00280505e-01f, 1.45165687e-02f, -2.58890241e-01f, -1.87414825e-01f, 5.14586926e-01f, 2.07434297e-01f, -2.96357065e-01f,
  -3.78545761e-01f, -2.04546571e-01f, 4.57651168e-01f, 3.13131779e-01f, 6.46151960e-01f, -7.04020917e-01f, -4.58369218e-02f, -3.29961449e-01f, 5.50461173e-01f, -5.17948806e-01f,
  -5.64436495e-01f, -5.48880875e-01f, -1.81310877e-01f, 5.74061871e-01f, -6.03096902e-01f, -3.60888749e-01f, -4.94661152e-01f, -2.89301395e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.23551425e-02f, 1.61232769e-01f, -8.34183767e-02f, 4.39536292e-03f, 1.22801580e-01f, 1.62197307e-01f, 1.00536987e-01f, 1.05312206e-01f, -2.09568083e-01f, -6.05380274e-02f,
  6.69751167e-02f, -2.04078574e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    