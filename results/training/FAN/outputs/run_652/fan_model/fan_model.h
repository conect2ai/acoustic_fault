/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.37091291e-01f, -9.37481076e-02f, 1.44468933e-01f, -1.59405321e-01f, 3.14685047e-01f, 4.63260382e-01f, 2.90238529e-01f, 2.14032382e-01f, -1.11107737e-01f, -3.94578092e-02f,
  1.01793841e-01f, -4.35390100e-02f, -1.47000551e-01f, -4.22102809e-02f, 1.38647616e-01f, 6.57982752e-02f, -1.94593577e-03f, 5.32234181e-03f, 2.07648247e-01f, 3.37732345e-01f,
  1.72775045e-01f, -8.45778435e-02f, -1.10290661e-01f, 1.27360702e-01f, -1.60913855e-01f, 6.55101165e-02f, -4.74732704e-02f, 3.45966592e-02f, 3.37229930e-02f, -4.02295947e-01f,
  -1.66331947e-01f, 2.70457054e-03f, 2.80193180e-01f, 8.39938298e-02f, 3.02806459e-02f, 2.22423160e-03f, 5.81682809e-02f, -6.49730116e-02f, 6.10712916e-02f, -3.17096785e-02f,
  -7.29558431e-03f, 1.49439676e-02f, 2.15709414e-02f, 5.68005405e-02f, 4.20568623e-02f, 2.42091771e-02f, 6.50470778e-02f, 4.90639918e-02f, 1.47465174e-03f, 1.11682422e-01f,
  -1.16541516e-03f, 6.54979646e-02f, 1.66189075e-02f, 1.79080039e-01f, 1.78344548e-01f, 8.94996524e-02f, 1.79983526e-01f, 9.08334702e-02f, 2.44094923e-01f, -2.35362262e-01f,
  2.24927720e-02f, -8.18772316e-02f, 3.67257074e-02f, 6.07589679e-03f, -4.68126424e-02f, -7.08050653e-02f, -2.97251735e-02f, -5.85585684e-02f, -4.60978895e-02f, -1.08282894e-01f,
  1.56716704e-02f, -1.54527118e-02f, -2.88273413e-02f, 2.49135271e-02f, -3.32852863e-02f, -6.16961624e-04f, 6.28488883e-02f, 1.57751907e-02f, -1.26426974e-02f, -5.20530939e-02f,
  1.94579002e-03f, -4.36123945e-02f, -7.15456903e-02f, -9.15675703e-03f, 5.55206165e-02f, -5.37588634e-02f, 1.71890575e-02f, 1.11785708e-02f, -4.38147821e-02f, -3.85790430e-02f,
  -1.00379609e-01f, 3.70161653e-01f, -1.55788347e-01f, 6.96727857e-02f, -4.60098684e-02f, 1.48706567e-02f, -7.40785748e-02f, 2.40231231e-02f, -9.22797024e-02f, 5.43522835e-02f,
  1.38914898e-01f, 2.13149004e-02f, -2.36749765e-03f, -2.51360126e-02f, 5.29016219e-02f, 3.96944731e-02f, 1.46763530e-02f, -4.79067191e-02f, 1.26822546e-01f, 7.61224376e-03f,
  -2.79892460e-02f, -1.18640419e-02f, -3.90961543e-02f, -2.52495762e-02f, 1.96333439e-03f, 9.37363692e-03f, 2.07565017e-02f, -1.47660868e-02f, 7.90619180e-02f, 1.13584083e-02f,
  4.82567847e-01f, 1.00267872e-01f, 4.33615781e-02f, 3.04464906e-01f, 2.89594382e-01f, 2.16354594e-01f, 3.57769191e-01f, 6.19901195e-02f, 8.35347250e-02f, 3.01161051e-01f,
  -5.66449240e-02f, -1.76214263e-01f, -6.35021776e-02f, -9.54305604e-02f, -2.37029456e-02f, 4.38214213e-01f, 3.42277765e-01f, 1.53151184e-01f, -9.72302184e-02f, -7.39828348e-02f,
  -2.90248003e-02f, 5.44630215e-02f, -7.83402249e-02f, -1.43059343e-01f, 8.66612568e-02f, -1.47359207e-01f, 5.98295704e-02f, -3.28801684e-02f, -1.23464890e-01f, 3.96806598e-02f,
  5.58323115e-02f, 4.47572991e-02f, -7.97938779e-02f, -9.80612077e-03f, 3.00330482e-02f, -6.09389879e-02f, -1.96077046e-03f, -3.80605608e-02f, -1.40523249e-02f, 2.91845910e-02f,
  -5.13290502e-02f, -6.04219474e-02f, 2.67309733e-02f, -2.54560560e-02f, -1.43569140e-02f, -7.75708025e-03f, -1.94133613e-02f, -3.09051555e-02f, 4.70566638e-02f, 2.07860805e-02f,
  -6.43861219e-02f, -1.11627184e-01f, -5.37467338e-02f, -6.46861494e-02f, -5.35112396e-02f, -1.00758724e-01f, -6.45366684e-02f, -1.78174242e-01f, -1.31790310e-01f, -6.67511374e-02f,
  -1.09878302e-01f, -1.94527674e-02f, 5.63015305e-02f, -5.18653821e-03f, 4.83106263e-02f, 1.79710928e-02f, 7.35106617e-02f, 4.57906872e-02f, 5.33322096e-02f, -4.95540500e-02f,
  4.36615804e-03f, -8.13020300e-03f, 5.07939868e-02f, 2.42320029e-03f, 1.24077881e-02f, 5.83106093e-02f, 4.32660244e-02f, 3.67875695e-02f, 2.68080179e-02f, -2.61036698e-02f,
  8.18542540e-02f, -5.97038865e-02f, 7.56618753e-02f, -5.16641065e-02f, 1.49021059e-01f, 1.76065583e-02f, -8.17193463e-02f, -6.39498979e-02f, -6.47045998e-03f, 2.17388757e-02f,
  -1.29405171e-01f, -6.22337610e-02f, 1.12409145e-01f, -8.30225572e-02f, -3.88846099e-02f, -4.04236317e-02f, -2.48893397e-03f, 5.50450049e-02f, -1.11936806e-02f, -3.38548496e-02f,
  -5.01815639e-02f, 4.53937314e-02f, 4.41462100e-02f, -1.78158581e-01f, 1.82448532e-02f, -2.69193705e-02f, -7.53312260e-02f, -5.02288155e-02f, -1.15584023e-01f, -9.72844362e-02f,
  -1.92665495e-02f, 8.24823752e-02f, 8.38637445e-03f, -4.91339341e-02f, 1.47136301e-03f, -6.25674799e-02f, -6.24491274e-02f, -3.03053204e-03f, 8.52676034e-02f, 1.18958123e-01f,
  3.51302296e-01f, -1.56613588e-02f, 1.70129258e-02f, 1.06379285e-01f, 5.31613640e-02f, -7.54708946e-02f, -2.94425666e-01f, -1.12393260e-01f, -1.05253467e-02f, -1.71466738e-01f,
  1.74556553e-01f, 2.90245533e-01f, 1.97260231e-02f, -7.27437660e-02f, -5.25282286e-02f, -4.01711494e-01f, -3.04163933e-01f, -1.91361681e-01f, 4.26119268e-02f, 5.27800694e-02f,
  7.87459686e-02f, -3.79138044e-03f, 1.24081485e-02f, -3.44688212e-03f, -4.91031483e-02f, -8.11969042e-02f, -2.25434348e-01f, -4.12082784e-02f, 1.75928120e-02f, -3.40869129e-01f,
  6.61310479e-02f, 1.36106595e-01f, -8.85035545e-02f, -1.08954214e-01f, 9.06092823e-02f, -5.99925369e-02f, -4.59151827e-02f, -1.47374719e-01f, -2.70701256e-02f, -9.95240808e-02f,
  8.13100189e-02f, -1.89465210e-02f, -4.15277556e-02f, -4.65288311e-02f, -1.60900727e-01f, -5.11908829e-02f, -1.51609674e-01f, -4.53840680e-02f, -1.42518044e-01f, -1.11070916e-01f,
  4.44322117e-02f, 1.08773723e-01f, 4.68966551e-02f, -9.75086764e-02f, -1.15103044e-01f, 9.19766948e-02f, -4.71604653e-02f, -8.01310018e-02f, -8.98640826e-02f, -1.70132369e-01f,
  -4.29880172e-02f, 4.41295542e-02f, 1.06738374e-01f, 9.09262747e-02f, 2.21282430e-02f, -3.38171422e-02f, -3.49389650e-02f, 1.05959009e-02f, -2.43329853e-02f, -3.25686820e-02f,
  1.83354616e-02f, -9.25689004e-03f, -1.31468242e-02f, 2.00878419e-02f, -9.29076970e-02f, 1.05541609e-01f, -5.98540623e-03f, -5.64951031e-03f, -3.28887291e-02f, 5.24828248e-02f,
  -1.97847821e-02f, 5.21091893e-02f, 5.77443056e-02f, -6.54373616e-02f, 4.27968316e-02f, 1.14584276e-02f, -5.38869575e-03f, 7.89407268e-02f, 9.62694176e-03f, -1.56968851e-02f,
  -7.35117402e-03f, 6.63253516e-02f, -1.26536161e-01f, -6.27705604e-02f, 3.23329680e-03f, -8.93284678e-02f, 1.61698535e-02f, -3.73723507e-02f, 8.06676969e-02f, -9.39019248e-02f,
  4.08758856e-02f, 4.48562088e-04f, 5.84523985e-03f, -5.68929650e-02f, -6.43779291e-03f, -9.71043631e-02f, -1.38684109e-01f, 4.11993638e-03f, -8.60756170e-03f, 9.66743827e-02f,
  -3.66841890e-02f, -6.74402416e-02f, 6.16290979e-03f, -2.77031902e-02f, -2.80103460e-02f, -5.43552376e-02f, -1.05640806e-01f, -5.07762097e-02f, -8.23938698e-02f, -2.80562788e-01f,
  -4.68085110e-01f, -9.25319567e-02f, 1.88117057e-01f, 8.71063024e-03f, -1.34930164e-01f, -3.98011386e-01f, -3.28670025e-01f, -3.02614659e-01f, 3.10171600e-02f, -9.58756134e-02f,
  -9.74436924e-02f, 1.35089368e-01f, 1.65705308e-01f, 1.58491418e-01f, 1.92375667e-02f, -1.89083368e-02f, 5.35925217e-02f, 2.21305877e-01f, 8.61784890e-02f, -1.67467743e-01f,
  9.93341058e-02f, 7.29806125e-02f, 1.46012843e-01f, 1.25350550e-01f, 1.72004402e-01f, 1.53638512e-01f, 7.74505362e-02f, 9.63070020e-02f, 4.46342863e-02f, 4.29979682e-01f,
  5.70887513e-02f, -3.25522512e-01f, 9.00343508e-02f, 3.29566933e-02f, 1.24100320e-01f, -1.24995997e-02f, -9.03056636e-02f, 2.95452159e-02f, 8.25296715e-02f, -4.99388613e-02f,
  1.02674358e-01f, 1.08323134e-02f, 1.10473717e-02f, 2.27304711e-03f, 3.84563860e-03f, -5.13523221e-02f, -7.54143447e-02f, 1.40618399e-01f, 1.74652562e-01f, -2.18387446e-04f,
  5.21216840e-02f, -6.17666133e-02f, -6.54722974e-02f, -1.74429435e-02f, -5.00252545e-02f, -9.17068031e-03f, 1.70750413e-02f, 3.02039497e-02f, 2.98279524e-02f, 1.26346156e-01f,
  1.67509571e-01f, -4.02661227e-02f, -5.89366071e-02f, -3.94165590e-02f, -2.72264201e-02f, 2.10170299e-02f, 5.45698553e-02f, 3.54287736e-02f, 1.40819373e-02f, -3.63490880e-02f,
  1.05419578e-02f, -5.20570315e-02f, -3.98778729e-02f, -9.82028991e-02f, 3.36851738e-02f, -3.10433917e-02f, -5.56715615e-02f, -4.99520488e-02f, -5.15398793e-02f, -1.42222745e-02f,
  7.65201151e-02f, 3.36464755e-02f, -3.31777558e-02f, 8.31467584e-02f, -5.62552512e-02f, -1.78755242e-02f, -1.31658129e-02f, -1.32217988e-01f, -5.45041822e-02f, -8.66127908e-02f,
  9.64698419e-02f, -3.79618928e-02f, 8.39293450e-02f, 3.46538797e-02f, -2.18356419e-02f, 2.36503109e-02f, -4.92586335e-03f, 1.74376797e-02f, -3.62863578e-02f, -3.63761857e-02f,
  -6.87824860e-02f, -7.38760009e-02f, 5.96428141e-02f, 1.85293183e-02f, 2.28697509e-02f, -2.52059568e-02f, -2.51342393e-02f, 3.22182733e-03f, 3.19999643e-02f, -4.39328440e-02f,
  -3.26608419e-02f, -8.16161931e-02f, -7.07762465e-02f, -8.43048021e-02f, -2.73630321e-02f, -1.26944691e-01f, -7.08145695e-03f, 4.55250926e-02f, -6.95138872e-02f, -9.34535116e-02f,
  -3.40059489e-01f, -2.02107295e-01f, -1.79896161e-01f, 5.41980974e-02f, -7.72725195e-02f, -3.15311700e-01f, -3.06320786e-01f, -2.52245307e-01f, 3.49112041e-02f, -2.25083515e-01f,
  -2.25083232e-01f, -7.51807690e-02f, -5.84429726e-02f, -1.93442777e-02f, -2.19807193e-01f, -1.13051891e-01f, 1.65749133e-01f, -8.18219855e-02f, -2.22144425e-01f, -2.19427526e-01f,
  6.06653914e-02f, 2.10255253e-04f, -1.26928598e-01f, -1.20339952e-01f, 6.58707097e-02f, -2.90407240e-02f, -1.39408067e-01f, -5.96500076e-02f, -2.51134038e-02f, 1.18525475e-01f,
  -2.74214685e-01f, -1.92045406e-01f, -2.07514957e-01f, -7.47966692e-02f, -2.65160557e-02f, -1.58335552e-01f, -1.09165259e-01f, -6.50045574e-02f, -1.62871793e-01f, -8.90059397e-02f,
  -5.61644509e-02f, -9.14539099e-02f, -1.25358641e-01f, -6.35285899e-02f, -1.37909532e-01f, -1.40811309e-01f, -6.16766661e-02f, -1.57088742e-01f, -1.53793186e-01f, -7.47308210e-02f,
  -3.76192629e-02f, -9.70279127e-02f, -2.50402451e-01f, -9.98728201e-02f, -9.92496610e-02f, -1.78580228e-02f, -1.76512286e-01f, -1.92332074e-01f, -2.54943073e-01f, -2.45011777e-01f,
  3.62802297e-02f, 9.45281237e-02f, 1.12369344e-01f, 7.97504745e-03f, 2.72451304e-02f, 4.09113914e-02f, 1.91569120e-01f, 1.32450797e-02f, 5.91149069e-02f, -7.52532557e-02f,
  2.72759497e-02f, 3.10196672e-02f, -2.06970032e-02f, 5.27091287e-02f, 1.88144427e-02f, 4.77133431e-02f, 1.25479596e-02f, -4.04414050e-02f, 8.56496468e-02f, -7.36524118e-03f,
  -5.50743043e-02f, 4.50422056e-02f, 9.64625999e-02f, 4.80662808e-02f, 1.09076694e-01f, 8.76488686e-02f, -3.44474101e-03f, 2.69206539e-02f, 5.03222644e-02f, 9.69436839e-02f,
  -2.29334846e-01f, -5.39643988e-02f, -2.38226905e-01f, -1.99453622e-01f, -1.75669938e-01f, -1.26085714e-01f, -1.31901562e-01f, -8.22921097e-02f, -6.30686656e-02f, -2.13179201e-01f,
  -1.87544748e-01f, -1.65180951e-01f, -1.68429881e-01f, -1.33117169e-01f, -1.68357357e-01f, -2.11121485e-01f, -4.18146513e-02f, -9.60962102e-02f, -1.10288009e-01f, -1.20814033e-01f,
  -1.14307471e-01f, -2.04199538e-01f, -3.14725190e-01f, -2.80774146e-01f, -1.41262159e-01f, -3.17620367e-01f, -2.42731154e-01f, -3.34259629e-01f, -3.72101337e-01f, -4.57839608e-01f,
  -5.52091360e-01f, 1.98906325e-02f, -3.30733120e-01f, -4.90816496e-02f, 1.28355980e-01f, 7.03926980e-02f, 2.13128418e-01f, 3.69065627e-02f, -1.89984124e-02f, -4.83707935e-02f,
  4.45120931e-02f, 2.02105865e-02f, -8.19229484e-02f, -2.59381384e-02f, -4.34928797e-02f, 3.45652588e-02f, 1.30682752e-01f, -1.57827735e-01f, -2.21774399e-01f, 1.12594917e-01f,
  2.93760270e-01f, 4.39578034e-02f, -2.25403845e-01f, 6.24364093e-02f, 1.77063331e-01f, 2.88740136e-02f, -4.25914712e-02f, 1.19367531e-02f, 1.31772459e-01f, 2.65169770e-01f,
  -3.33515078e-01f, -1.62103474e-01f, -6.43639192e-02f, -5.28329648e-02f, -2.47647315e-02f, -8.57951120e-02f, -2.81037912e-02f, -6.96952408e-03f, 5.65476567e-02f, 2.51604337e-02f,
  -4.12630737e-02f, -1.34172672e-02f, 5.08153997e-02f, -3.80318761e-02f, -7.85664469e-02f, -3.78163122e-02f, -7.51827359e-02f, -1.10985041e-01f, -1.21354379e-01f, -6.69918880e-02f,
  1.45704746e-01f, -1.71075035e-02f, -1.31498814e-01f, -6.13254234e-02f, -6.56854883e-02f, -1.35733679e-01f, -2.75577437e-02f, -1.22326523e-01f, -1.99416816e-01f, -8.54150951e-02f,
  -2.82587297e-02f, -3.89598645e-02f, -5.53796589e-02f, -5.28189987e-02f, 1.70520563e-02f, 5.94515875e-02f, -2.66363081e-02f, 8.76671970e-02f, 2.66004950e-02f, 6.70212731e-02f,
  -1.08955666e-01f, 2.39339825e-02f, -4.83855531e-02f, 3.34019773e-02f, -9.71244369e-03f, -1.88181251e-02f, 4.56547253e-02f, 9.36545618e-03f, -2.22712010e-02f, -2.09144503e-02f,
  -9.69879553e-02f, -9.82025564e-02f, -4.51837890e-02f, 2.97447275e-02f, -8.18309200e-04f, -2.25841217e-02f, -1.54566467e-02f, -1.43170124e-02f, -9.52901840e-02f, -4.71116677e-02f,
  -7.93228447e-02f, -8.91316161e-02f, 2.62374114e-02f, -4.24086303e-02f, 2.30501182e-02f, 4.68103215e-02f, 2.24546976e-02f, -3.77929881e-02f, -7.34330639e-02f, 4.00225334e-02f,
  5.00649922e-02f, -4.65156659e-02f, -2.22487636e-02f, 1.10799158e-02f, 7.60718957e-02f, 4.90885936e-02f, 6.17608614e-02f, 1.30704250e-02f, 8.08802396e-02f, 3.05041857e-02f,
  3.68540697e-02f, 4.28542010e-02f, -1.04476690e-01f, -5.64395823e-02f, -3.07961181e-02f, -1.29094258e-01f, -1.36608630e-01f, -9.75525100e-03f, -9.50366631e-02f, -2.53858976e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.39129335e-02f, 1.52149051e-01f, 6.46549463e-02f, 3.10557596e-02f, -1.53882459e-01f, -3.34456086e-01f, -2.98596442e-01f, -3.70823443e-01f, -1.30108401e-01f, 7.23581761e-02f,
  5.94449453e-02f, 1.19930297e-01f, 2.43796885e-01f, 8.30430165e-02f, -1.06824160e-01f, 1.21139325e-01f, 8.73836428e-02f, -7.57530332e-02f, -3.05936128e-01f, -2.03843072e-01f,
  9.83155072e-02f, -1.80752166e-02f, -1.16209291e-01f, -2.05557585e-01f, 3.10650766e-01f, 1.80691689e-01f, 1.47547707e-01f, 8.86121020e-02f, 6.53085187e-02f, 6.34045780e-01f,
  5.30425489e-01f, 1.64863525e-03f, 4.05978896e-02f, -1.52346864e-01f, -3.94594371e-02f, 5.68183176e-02f, 5.85670657e-02f, 5.83765656e-02f, -6.68603480e-02f, -1.31558646e-02f,
  -5.85709326e-02f, -2.60714162e-02f, -4.20672745e-02f, 2.49440838e-02f, -8.18432719e-02f, -1.21386304e-01f, -5.60023971e-02f, -2.77212029e-03f, 7.31437579e-02f, 2.07322091e-01f,
  3.95812206e-02f, -6.54452816e-02f, -7.96326920e-02f, -1.37876198e-01f, -2.07976535e-01f, -1.23411946e-01f, -3.36194597e-02f, -3.72863337e-02f, -1.98508173e-01f, 4.79725823e-02f,
  -2.70705968e-01f, 1.67425334e-01f, -2.03922596e-02f, 1.00141333e-03f, -8.22375491e-02f, 1.35574313e-02f, -4.16135117e-05f, 6.18536957e-04f, -1.57516658e-01f, 2.28100270e-02f,
  -5.95863862e-03f, 4.62820530e-02f, 1.54572651e-02f, -2.89930105e-02f, 1.23135960e-02f, 1.18324980e-02f, -1.63792744e-02f, -7.55575225e-02f, -3.36008407e-02f, 4.17997278e-02f,
  1.62597429e-02f, -8.68125353e-03f, 9.42594707e-02f, 8.56574103e-02f, -5.19036502e-02f, -6.75524026e-02f, 2.00867467e-02f, -1.02760661e-02f, 7.90096521e-02f, 4.30917256e-02f,
  2.36146078e-01f, -2.89415359e-01f, 2.94737905e-01f, 1.82554334e-01f, 7.73429796e-02f, 6.31259978e-02f, 1.08581610e-01f, 5.44196144e-02f, 6.65218532e-02f, 1.45575702e-02f,
  2.56474912e-02f, -2.07360703e-02f, 9.00861025e-02f, -2.07625423e-02f, -1.14343062e-01f, -1.63137004e-01f, -3.39086317e-02f, 9.93269533e-02f, 6.46137167e-03f, 9.59985629e-02f,
  -5.06705940e-02f, -8.07314813e-02f, -4.09210995e-02f, 1.52827287e-03f, 2.23109648e-02f, -9.94158722e-03f, 1.01470970e-01f, 3.06629036e-02f, -1.97499394e-02f, -6.81014732e-03f,
  4.51489836e-02f, -1.61049858e-01f, 3.16950440e-01f, 2.28970453e-01f, 4.24422234e-01f, 5.08778751e-01f, 5.54381013e-01f, 1.12912565e-01f, 7.65777379e-02f, 6.72193617e-02f,
  -2.94637054e-01f, -3.64416301e-01f, -2.48006582e-01f, -2.06787989e-01f, -2.08263853e-04f, 3.11122447e-01f, 3.35647970e-01f, 1.10283665e-01f, 1.10560134e-01f, 1.18886627e-01f,
  -6.50588870e-02f, -1.00494459e-01f, -2.63162494e-01f, -8.53341892e-02f, 1.10862665e-01f, -2.34179962e-02f, -1.94824822e-02f, 3.37674581e-02f, -8.82023014e-03f, -9.34644863e-02f,
  -1.00480892e-01f, -7.16961622e-02f, -5.87978065e-02f, -2.02361405e-01f, -1.28781334e-01f, -1.92556918e-01f, -5.31915762e-02f, -3.11376542e-01f, -1.18069090e-01f, -6.68472126e-02f,
  -2.55040862e-02f, -1.02337137e-01f, -3.58819589e-02f, -4.40642312e-02f, -2.57796906e-02f, -6.11879565e-02f, -8.29160810e-02f, -1.64437339e-01f, -1.04680687e-01f, -7.17149079e-02f,
  -1.10487022e-01f, 2.28020921e-02f, -9.57122538e-03f, 7.92329106e-03f, 3.70118506e-02f, 4.85394895e-03f, -9.04857069e-02f, 5.40164374e-02f, 2.55266409e-02f, -9.39524323e-02f,
  2.88526136e-02f, -9.53246802e-02f, 5.79641957e-04f, -4.24632914e-02f, 3.97296958e-02f, 3.53381932e-02f, 1.79018248e-02f, -5.03476411e-02f, -1.35158971e-02f, -1.36697173e-01f,
  -7.35324323e-02f, 3.33021767e-02f, -3.29277217e-02f, -6.14998899e-02f, -1.51190013e-01f, -6.10052943e-02f, 2.13023592e-02f, -1.34681627e-01f, -8.47026333e-02f, 2.23134663e-02f,
  -7.46588930e-02f, 6.93999827e-02f, -8.59164074e-02f, -3.21837813e-02f, -1.42957166e-01f, -8.32484737e-02f, -1.64771099e-02f, -2.42180675e-01f, -4.05362621e-02f, -5.10153137e-02f,
  -2.18406722e-01f, 7.01269209e-02f, -4.94074412e-02f, -7.59981349e-02f, 1.31781055e-02f, -8.03660676e-02f, 8.84781331e-02f, 1.96653809e-02f, 5.50564639e-02f, 1.26259640e-01f,
  1.37595674e-02f, -3.05573940e-02f, -3.13629657e-02f, -7.78176859e-02f, 1.02981672e-01f, 3.92482691e-02f, -1.53510675e-01f, 3.49556096e-02f, -4.64594327e-02f, 5.34630753e-03f,
  -2.98672840e-02f, 5.83272800e-02f, 9.64301154e-02f, 9.56956446e-02f, -5.57612330e-02f, 1.24373235e-01f, 9.02655870e-02f, 1.21731214e-01f, 3.81087102e-02f, 1.04708366e-01f,
  -3.39463234e-01f, 5.61425127e-02f, -1.69501752e-01f, 1.06777564e-01f, 2.68173456e-01f, 8.77611861e-02f, -2.83541590e-01f, 1.88473985e-02f, 2.45178416e-01f, -5.18613495e-02f,
  1.30802482e-01f, 4.05097634e-01f, 2.27933019e-01f, 1.36635140e-01f, -7.67715499e-02f, -1.71964914e-01f, -3.87723409e-02f, -1.31507814e-01f, -7.50489999e-03f, 9.61239785e-02f,
  2.01338783e-01f, -3.92017774e-02f, -2.48177409e-01f, -1.05697140e-02f, -3.75684388e-02f, 9.08489227e-02f, -1.46536514e-01f, -1.32764503e-01f, -9.45747271e-02f, -1.13440417e-01f,
  -1.24976173e-01f, -1.76653996e-01f, -6.25707582e-02f, 1.23014182e-01f, 1.21481903e-01f, -1.55953869e-01f, -1.05528720e-01f, -1.41562462e-01f, 4.07983474e-02f, -1.56207696e-01f,
  -1.93909165e-02f, -1.44669309e-01f, 6.69043735e-02f, -5.05528636e-02f, -1.23729490e-01f, -2.17497647e-01f, -1.00941621e-01f, -2.45408282e-01f, -2.30227649e-01f, -1.58511207e-01f,
  1.27038136e-01f, 9.44081917e-02f, -2.26792455e-01f, -1.11690603e-01f, -1.10968567e-01f, -4.78954911e-02f, -2.70447314e-01f, -1.28276974e-01f, -2.62098759e-01f, -4.76489991e-01f,
  4.44667041e-02f, 5.35327420e-02f, 3.42389643e-02f, 6.16902746e-02f, 1.30135924e-01f, 2.27156188e-02f, 6.08589835e-02f, 1.63128208e-02f, 1.10782914e-01f, -8.18821564e-02f,
  1.32711157e-01f, 9.55726877e-02f, -7.41176829e-02f, -1.22397272e-02f, 1.34495031e-02f, -8.96303877e-02f, 1.11797440e-03f, -1.57334968e-01f, -1.99097097e-01f, -2.58672740e-02f,
  -1.64859947e-02f, -6.87911808e-02f, 7.82100558e-02f, 7.50412270e-02f, -5.79716638e-02f, -2.09531561e-01f, -7.54617527e-02f, -7.52922073e-02f, -3.88331600e-02f, -1.22953594e-01f,
  1.70807004e-01f, 1.97655171e-01f, -1.34107053e-01f, 4.86106537e-02f, 4.21753041e-02f, 1.10334828e-01f, 3.44208218e-02f, -7.51810055e-03f, 5.26421443e-02f, -1.10949069e-01f,
  -1.64253473e-01f, -1.62294999e-01f, -1.54079739e-02f, 6.38091937e-03f, -7.19850212e-02f, -1.10915057e-01f, -8.60672966e-02f, -3.89389060e-02f, -1.87787320e-02f, 6.42614858e-03f,
  3.55922617e-03f, -4.69489396e-02f, -8.38346705e-02f, -1.45561546e-01f, -1.43927475e-02f, -1.14186481e-01f, -1.79764882e-01f, -1.69687018e-01f, -2.82923341e-01f, -4.09828246e-01f,
  -2.26770431e-01f, -4.65324879e-01f, -1.97616056e-01f, 3.03273380e-01f, 2.49744713e-01f, -3.43550056e-01f, -7.31584668e-01f, -4.66453046e-01f, 1.59952641e-01f, -1.80147842e-01f,
  5.19085899e-02f, 2.21918494e-01f, 1.87093075e-02f, 2.37138085e-02f, -3.12440306e-01f, -3.59768093e-01f, -8.97586271e-02f, -3.75830866e-02f, 6.24408051e-02f, 2.31639504e-01f,
  1.97798997e-01f, 2.11733803e-01f, 2.46630982e-01f, 8.87442455e-02f, 1.80008605e-01f, 1.76411584e-01f, -5.45479776e-03f, 2.04722419e-01f, -7.59219453e-02f, 6.37806058e-02f,
  5.07029481e-02f, -8.11003968e-02f, 1.54207377e-02f, 2.02746451e-01f, 6.09380566e-02f, -1.57476097e-01f, -6.38965517e-02f, 3.28270569e-02f, 2.37328149e-02f, 7.73503482e-02f,
  2.67172605e-01f, 2.03622058e-01f, 9.13357660e-02f, 1.42334044e-01f, 9.54245031e-02f, 2.48479377e-02f, -2.72012651e-02f, -1.27750874e-01f, -1.32915661e-01f, -1.07130617e-01f,
  7.23955259e-02f, 1.87205806e-01f, -9.05119032e-02f, -1.02886081e-01f, -1.36965483e-01f, 6.40841797e-02f, 2.08047796e-02f, 8.06027129e-02f, -1.25022650e-01f, -2.08004579e-01f,
  -4.85493690e-02f, 8.50795861e-03f, 4.17582784e-03f, -1.47072509e-01f, 5.38862795e-02f, -1.79543078e-03f, 1.66541845e-01f, 3.28411907e-02f, 3.78914401e-02f, -7.70165473e-02f,
  -3.12392116e-02f, 3.09350248e-02f, 3.56417559e-02f, 2.94455588e-02f, 7.08104074e-02f, 8.69511962e-02f, 4.91951592e-02f, 1.97745711e-02f, 1.27553403e-01f, -1.84913240e-02f,
  3.65544222e-02f, 3.27739082e-02f, 1.29229113e-01f, -7.14621097e-02f, -4.53863107e-02f, 2.27254368e-02f, 1.34043366e-01f, -9.92357358e-02f, 2.08683852e-02f, 5.25020109e-03f,
  7.57452324e-02f, -8.69478360e-02f, -6.74139932e-02f, 8.90554264e-02f, 5.93199357e-02f, 6.23670965e-02f, 2.57042367e-02f, 7.19723850e-02f, 1.50316939e-01f, -8.40982944e-02f,
  -2.56450363e-02f, -1.56151876e-01f, 3.89154255e-02f, 1.80895682e-02f, 9.16158110e-02f, 3.31605114e-02f, -4.38235188e-03f, 4.07324061e-02f, -5.43265752e-02f, 1.04853518e-01f,
  -1.12309754e-01f, -1.55842081e-01f, -2.74144232e-01f, -3.80268723e-01f, 1.59393752e-03f, -9.75463539e-02f, -1.11068256e-01f, -2.65162811e-02f, -2.15487942e-01f, -5.35931647e-01f,
  5.97922802e-01f, -5.99087216e-02f, -6.61131620e-01f, 1.39826968e-01f, -2.93405116e-01f, -3.47209007e-01f, -4.50410247e-01f, 7.85893053e-02f, 2.26785004e-01f, -2.27779791e-01f,
  -6.59895986e-02f, 4.10189241e-01f, 1.58070728e-01f, 9.14490074e-02f, 7.58040994e-02f, -4.94539410e-01f, -4.98139292e-01f, -9.42280889e-02f, 1.64620593e-01f, 1.63181454e-01f,
  7.51462281e-02f, 8.72666240e-02f, 2.06087038e-01f, 4.03520316e-02f, -1.24488128e-02f, -3.34795304e-02f, -3.85364503e-01f, -2.40317956e-01f, -2.32341617e-01f, -5.66370249e-01f,
  -2.74547338e-01f, -1.73022114e-02f, -1.07762031e-01f, 1.76746592e-01f, -2.37099752e-01f, 7.29361773e-02f, 2.68852115e-02f, -1.03215136e-01f, 9.61654186e-02f, -4.49028015e-02f,
  -5.72332107e-02f, 1.50403064e-02f, 1.51697457e-01f, -4.40809829e-03f, -7.91490823e-02f, -7.44811371e-02f, -1.71354264e-02f, -5.56579034e-04f, -4.62799221e-02f, -1.70335874e-01f,
  -7.53594562e-02f, -2.73516417e-01f, -2.56233841e-01f, -1.26159653e-01f, -1.57347053e-01f, -1.43462777e-01f, -1.79710299e-01f, -1.15311444e-01f, -2.15613857e-01f, -2.03248426e-01f,
  2.86071096e-02f, -1.44711182e-01f, -2.17107266e-01f, -7.80668110e-02f, 5.00229336e-02f, -1.64790004e-02f, -9.26401839e-02f, -1.17332958e-01f, 6.43643811e-02f, 1.10997772e-03f,
  2.99989004e-02f, -1.05659746e-01f, -1.04764409e-01f, 4.73680310e-02f, -1.03307255e-01f, -7.92581812e-02f, -5.19311018e-02f, -8.41997713e-02f, -4.34977673e-02f, 1.73418112e-02f,
  -5.28244041e-02f, -5.02899736e-02f, -9.91817191e-02f, 1.13837190e-01f, -1.70754761e-01f, -7.72541612e-02f, -4.30780090e-02f, 8.22706372e-02f, 1.49698732e-02f, -1.87992770e-02f,
  4.59686816e-01f, -1.97311848e-01f, 2.31105443e-02f, -3.83959524e-02f, -3.43790770e-01f, -1.56189784e-01f, -1.07593209e-01f, -2.15424195e-01f, 3.52714807e-02f, 7.02066869e-02f,
  -3.78488824e-02f, 1.63183779e-01f, 2.66249795e-02f, 7.88285211e-02f, -4.63714525e-02f, 1.31255209e-01f, -4.35521528e-02f, -1.64675247e-02f, -3.32101285e-02f, -8.44011083e-02f,
  2.49775946e-02f, -1.13013284e-02f, 2.81412750e-01f, -4.12676595e-02f, 6.89595416e-02f, 1.46387905e-01f, 3.28302532e-02f, -4.87372093e-02f, 7.06993043e-02f, 2.42770433e-01f,
  -2.36958921e-01f, -1.15933836e-01f, -4.92692530e-01f, -2.10067362e-01f, -2.61401415e-01f, -3.72218415e-02f, -2.69801170e-01f, 1.98829725e-01f, 1.56280354e-01f, -2.39745975e-01f,
  -8.42830986e-02f, -1.64009840e-03f, -3.24036837e-01f, -1.95233867e-01f, -1.08150557e-01f, -3.16515803e-01f, -2.89914876e-01f, -2.81978726e-01f, 9.83597338e-03f, 3.24317902e-01f,
  2.51478404e-02f, -2.38107011e-01f, -1.21254265e-01f, -3.14833373e-02f, -6.71703815e-02f, -4.43363450e-02f, -4.59361762e-01f, -1.75004885e-01f, 2.97392681e-02f, -3.93352956e-01f,
  -2.82812297e-01f, -9.46057066e-02f, -2.13090442e-02f, -8.72553512e-02f, -1.89182967e-01f, 1.16312295e-01f, -6.91020265e-02f, -1.18867427e-01f, 6.09865226e-03f, 7.54573569e-02f,
  -2.59736236e-02f, 1.22739874e-01f, -1.28004223e-01f, -9.00007039e-02f, -9.97208711e-03f, 5.33050485e-02f, 3.29937004e-02f, -3.22850496e-02f, -2.31583584e-02f, 8.69085118e-02f,
  1.29354030e-01f, -3.80415916e-02f, 4.79440279e-02f, 8.41361955e-02f, 9.39103290e-02f, -1.00101694e-01f, 1.07544318e-01f, 9.44505334e-02f, 5.19877560e-02f, -9.63272378e-02f,
  -1.04321167e-02f, -9.75005552e-02f, -4.52867411e-02f, 3.63388695e-02f, 3.54253650e-02f, -1.81768052e-02f, -8.18590969e-02f, -1.49836451e-01f, -8.17292258e-02f, -6.32120594e-02f,
  1.85703263e-02f, 1.31601542e-02f, 1.14980169e-01f, -8.25504437e-02f, -3.23526300e-02f, -2.59326082e-02f, 5.35483845e-02f, 1.00373760e-01f, 1.15540437e-01f, 7.00990297e-03f,
  7.73712695e-02f, 7.22692208e-03f, 4.79575768e-02f, 3.74101452e-03f, -2.30083782e-02f, -8.66146013e-03f, 6.88681006e-02f, 1.32733002e-01f, 5.06488383e-02f, 1.19407162e-01f,
  -1.63143262e-01f, -1.90681607e-01f, -1.15183532e-01f, 7.54528493e-02f, -7.06930831e-02f, 2.53024716e-02f, -4.76981550e-02f, -1.66273341e-02f, -9.47259292e-02f, 6.79387897e-02f,
  2.82673955e-01f, 4.55130450e-02f, -1.54386565e-01f, 6.15405552e-02f, -3.22678313e-02f, 1.08316578e-01f, 1.39814511e-01f, -1.85079008e-01f, 1.40340820e-01f, 1.53422341e-01f,
  1.95268810e-01f, 9.15382430e-02f, 1.66199952e-02f, 2.41370462e-02f, 1.86917886e-01f, -1.04902677e-01f, -8.25941786e-02f, 1.22531042e-01f, 2.46533044e-02f, 2.12800950e-02f,
  -4.59000200e-01f, -5.14214933e-01f, 2.17137203e-01f, -7.75333703e-01f, -5.47378957e-01f, -2.01958030e-01f, -2.78445601e-01f, -3.01935703e-01f, -4.08472210e-01f, -3.98987383e-01f,
  7.06249326e-02f, 3.23869705e-01f, 2.53781945e-01f, 4.73793298e-01f, 4.82067585e-01f, -1.89231038e-01f, -1.57300293e-01f, 4.62371320e-01f, 7.95957506e-01f, 1.93102494e-01f,
  -1.58297762e-01f, -2.06938803e-01f, 2.12166950e-01f, 7.39552453e-02f, -6.52667820e-01f, 5.62069006e-02f, -2.37782747e-01f, -2.37443060e-01f, 9.46213603e-02f, -5.68878412e-01f,
  1.55347168e-01f, -2.91301101e-01f, 1.54311836e-01f, 1.45777436e-02f, -1.79348126e-01f, 1.09593280e-01f, 9.67847630e-02f, -1.07435569e-01f, 3.15692239e-02f, -6.08362518e-02f,
  -1.58146963e-01f, 8.67446586e-02f, -6.12056367e-02f, 5.11665940e-02f, -1.84205398e-01f, -2.24903156e-03f, -6.82620183e-02f, 2.19610363e-01f, 1.07334092e-01f, -1.53571628e-02f,
  -1.01429962e-01f, -1.58075422e-01f, 1.19484682e-02f, -1.19346887e-01f, 1.35697603e-01f, 1.30623847e-01f, -9.37785313e-04f, -1.84649751e-01f, 1.34795219e-01f, -4.35228288e-01f,
  -9.99171138e-02f, 9.32770371e-02f, 3.16576310e-03f, -4.51428071e-02f, 4.99913506e-02f, 5.96613903e-03f, -3.18329558e-02f, 4.94804680e-02f, 4.54887711e-02f, -1.01557083e-01f,
  6.03010179e-03f, 8.85197707e-03f, 1.23553559e-01f, 2.27007028e-02f, -1.10774050e-02f, -7.76985064e-02f, -7.34413192e-02f, -6.36289716e-02f, 4.50761942e-03f, -1.05690010e-01f,
  5.27050123e-02f, -9.35325027e-02f, -5.54198064e-02f, 1.31318614e-01f, -4.38166037e-02f, 1.03436252e-02f, 8.23336747e-03f, 8.79008248e-02f, -1.12927780e-01f, -6.69993907e-02f,
  -3.03070862e-02f, 2.62962967e-01f, -1.97630122e-01f, 9.75332856e-02f, -9.45431739e-02f, 6.41764998e-02f, -5.72818741e-02f, 1.89627469e-01f, -7.88371786e-02f, -9.54638794e-02f,
  4.43328097e-02f, -3.64962965e-02f, -2.74722986e-02f, -2.93704728e-03f, 4.46711779e-02f, 5.65219186e-02f, -4.76429462e-02f, -3.94691788e-02f, 3.58334556e-02f, -1.48790538e-01f,
  -1.17877729e-01f, -1.85426958e-02f, 3.19095515e-02f, -3.73882204e-02f, -1.68400422e-01f, 1.90132469e-01f, 1.09355204e-01f, 7.60065252e-03f, 2.39130005e-01f, -1.29524022e-01f,
  -5.06189287e-01f, -1.69016406e-01f, -1.14718862e-01f, -3.37211251e-01f, -1.07897818e-01f, -1.20134875e-01f, -2.52509624e-01f, -1.17387749e-01f, -1.81847054e-03f, -1.16533078e-01f,
  -1.31106963e-02f, -1.50609175e-02f, -1.35702386e-01f, -2.29476348e-01f, -2.45572597e-01f, -2.22958252e-01f, -1.21753722e-01f, -2.71725267e-01f, -1.21253632e-01f, 4.97114658e-02f,
  8.42907000e-03f, -1.59894377e-01f, -1.02119580e-01f, -3.42949331e-02f, -1.48226507e-02f, -1.20910548e-01f, -5.17047942e-02f, -2.45181322e-01f, -8.99497718e-02f, -3.72182429e-01f,
  -1.64549395e-01f, -1.88015461e-01f, 5.30638099e-02f, -2.58712471e-01f, -1.96687933e-02f, 8.80534574e-02f, -6.72231168e-02f, -1.42867919e-02f, 1.43704638e-01f, -2.06305515e-02f,
  -2.89333194e-01f, -3.82976681e-02f, 1.29216034e-02f, -4.20545302e-02f, -4.38365415e-02f, -3.85166742e-02f, 1.08086646e-01f, 6.96653128e-02f, -9.79206245e-03f, -3.47727872e-02f,
  -1.04936101e-01f, -2.52363950e-01f, -2.52631873e-01f, -8.14762488e-02f, -1.12912640e-01f, -1.26458496e-01f, -3.33554409e-02f, -4.84114103e-02f, -3.48190516e-02f, -2.26816908e-01f,
  -2.31277253e-02f, 9.07417461e-02f, 1.00766033e-01f, 1.19946439e-04f, -1.12515680e-01f, 1.27450258e-01f, -1.48338526e-01f, -9.12393183e-02f, 7.74017349e-02f, -4.95702401e-02f,
  -6.77733198e-02f, 5.29566593e-02f, 1.04864880e-01f, -6.91675320e-02f, 2.75804959e-02f, 7.80130103e-02f, -6.02933802e-02f, -6.61109611e-02f, -3.18930321e-03f, 1.08504854e-01f,
  -1.06321521e-01f, -3.41784656e-02f, 8.38782117e-02f, -3.28157726e-03f, -7.13868886e-02f, -9.11266804e-02f, 5.79004996e-02f, -7.14650378e-02f, -6.56351075e-02f, -3.60268280e-02f,
  -1.71305627e-01f, 7.20580518e-02f, -1.79723322e-01f, -7.90722892e-02f, 1.41835408e-02f, 5.03426231e-02f, 5.88682853e-03f, -3.20276693e-02f, -1.63603663e-01f, -1.37752101e-01f,
  -1.47569388e-01f, -8.98630992e-02f, -1.07191704e-01f, 6.63635693e-03f, -9.78678092e-02f, -5.98285981e-02f, 1.32658100e-02f, -6.15825765e-02f, -9.84647423e-02f, 2.10915565e-01f,
  -1.16351649e-01f, -2.89480716e-01f, -3.20381731e-01f, -2.19092563e-01f, -1.01291940e-01f, -2.08163112e-01f, -1.14710256e-01f, -2.24244744e-01f, -1.78932905e-01f, -2.71452725e-01f,
  7.49589920e-01f, -4.58396763e-01f, -3.81243438e-01f, 9.33838934e-02f, -1.58192143e-01f, -7.96181113e-02f, -2.13308185e-01f, 1.00624084e-01f, 1.85904384e-01f, -1.19064100e-01f,
  1.02827936e-01f, 3.86378527e-01f, 2.99985528e-01f, 2.32032523e-01f, 1.51056141e-01f, -1.53006271e-01f, -2.19910219e-01f, 1.53749928e-01f, 3.21687400e-01f, 1.96835011e-01f,
  8.01836178e-02f, -1.16368294e-01f, 3.70421894e-02f, 6.59431368e-02f, -2.06261203e-01f, 1.58766642e-01f, -4.01065767e-01f, -3.25549304e-01f, -1.26136824e-01f, -4.60670680e-01f,
  9.67017263e-02f, -2.33833477e-01f, 7.50914887e-02f, -1.13524139e-01f, -2.67645735e-02f, -1.93934869e-02f, -9.03341547e-03f, -1.72682375e-01f, -5.20006903e-02f, -1.48234248e-01f,
  -1.17892660e-02f, -1.08957708e-01f, -1.84133332e-02f, -1.49921387e-01f, -1.25260726e-01f, -2.95729488e-02f, -2.17098355e-01f, -1.61293447e-01f, -4.64832187e-02f, -1.26954421e-01f,
  -2.16394126e-01f, -1.28210932e-01f, -5.11078797e-02f, -7.17486516e-02f, -2.53719818e-02f, -2.63980497e-03f, -1.71561241e-01f, -1.51648551e-01f, -6.30479455e-02f, -1.53725177e-01f,
  -5.89069389e-02f, 4.42425087e-02f, 3.35671455e-02f, 5.78576103e-02f, 1.57250986e-01f, 3.96336429e-02f, 5.52935190e-02f, 4.80249971e-02f, 9.61331949e-02f, 5.21052368e-02f,
  2.26566009e-02f, 4.93098609e-02f, -4.43111621e-02f, 1.01761021e-01f, -1.66497740e-03f, -8.49069878e-02f, 4.96901497e-02f, -6.14475168e-04f, 1.32460259e-02f, 3.87696922e-02f,
  9.58530754e-02f, 1.20561317e-01f, -4.94493581e-02f, 9.82405096e-02f, -1.60677031e-01f, -4.13425863e-02f, -3.39520797e-02f, 1.15632918e-02f, 2.64474079e-02f, -1.98711315e-03f,
  1.45710409e-01f, -2.08527595e-02f, 2.75618821e-01f, 1.07401088e-01f, 2.24776473e-02f, -1.70785133e-02f, 1.22994557e-02f, 1.97567139e-02f, -9.61637422e-02f, 3.64777111e-02f,
  4.91659669e-03f, 6.01702332e-02f, -4.92282659e-02f, -2.47010812e-02f, 5.28679974e-02f, 1.81355122e-02f, -5.35283908e-02f, 1.20018505e-01f, -2.08945852e-02f, -1.84215475e-02f,
  -1.17696963e-01f, 1.16614647e-01f, 3.20663571e-01f, 1.87626854e-01f, 8.37028623e-02f, 2.00501516e-01f, 8.74650106e-02f, -3.45363244e-02f, 2.28208482e-01f, 1.94735542e-01f,
  -1.62441030e-01f, -9.50770080e-02f, -4.75199759e-01f, -1.23666562e-01f, -4.35716569e-01f, -3.29573184e-01f, -3.57818812e-01f, -2.51067113e-02f, 8.58441517e-02f, -1.92154497e-01f,
  -1.53126836e-01f, 8.42720792e-02f, 6.58742413e-02f, -1.44474506e-01f, -1.84489906e-01f, -5.97427964e-01f, -6.10435605e-01f, -4.89462793e-01f, -2.17584148e-01f, -1.41713932e-01f,
  -2.79955655e-01f, -4.41232800e-01f, -2.74282128e-01f, -1.91039681e-01f, 4.95086871e-02f, 5.67280091e-02f, -2.27757752e-01f, -2.66287327e-01f, -2.42740706e-01f, -2.95478761e-01f,
  -1.47730738e-01f, 4.05917726e-02f, -2.77124234e-02f, -7.89994448e-02f, -1.64522842e-01f, 3.68503518e-02f, -8.80611017e-02f, 6.01072274e-02f, 1.83607191e-01f, 4.41486649e-02f,
  -7.70030543e-02f, -7.54740909e-02f, 2.15363298e-02f, 1.01494268e-02f, 3.53137739e-02f, -2.73430496e-02f, 6.46287128e-02f, 1.17898837e-01f, 1.00382887e-01f, 1.74471065e-01f,
  5.30163571e-03f, -6.51200637e-02f, 2.18763113e-01f, 2.41283536e-01f, 1.88113883e-01f, 8.10077116e-02f, 1.21534795e-01f, 2.62398183e-01f, 1.32426456e-01f, 2.17906132e-01f,
  -2.93125629e-01f, 1.92063719e-01f, 1.18786119e-01f, -1.48943039e-02f, 8.11854526e-02f, 7.64795542e-02f, -9.69556347e-03f, 7.17883483e-02f, 4.67421301e-02f, -1.20137319e-01f,
  7.10067675e-02f, -3.66795957e-02f, 2.19876003e-02f, -5.32265864e-02f, -7.72408675e-03f, 8.98170751e-03f, -9.46100205e-02f, -4.35439907e-02f, 8.61894712e-02f, 3.63510698e-02f,
  1.67653020e-02f, 5.34745604e-02f, -1.43150404e-01f, -1.06426232e-01f, -9.09778401e-02f, -1.86189276e-03f, -1.15481000e-02f, -2.44274307e-02f, -2.25289743e-02f, 3.17528844e-02f,
  2.51562148e-01f, -2.43473932e-01f, 1.04851350e-02f, 1.35527164e-01f, -1.59570128e-02f, 8.92235339e-02f, 3.07144038e-02f, 2.31354162e-02f, 1.54429013e-02f, 1.16192794e-03f,
  -8.58479142e-02f, -6.10651672e-02f, -4.81030270e-02f, 1.71971723e-01f, -1.12342346e-03f, -5.62752448e-02f, -6.46857452e-03f, -2.76375911e-03f, 6.60429746e-02f, 4.51333039e-02f,
  -5.06343693e-02f, 2.24191006e-02f, 1.31814376e-01f, 1.80137590e-01f, -2.28405576e-02f, -4.66802418e-02f, 1.14963822e-01f, 6.19299337e-02f, -1.11998627e-02f, 1.21082351e-01f,
  4.44298148e-01f, -6.43406868e-01f, -3.75617109e-02f, 1.54789448e-01f, 2.81395793e-01f, 1.59865811e-01f, -1.16951177e-02f, -9.39664394e-02f, 5.60034476e-02f, -1.76773906e-01f,
  -4.46503341e-01f, -2.90379763e-01f, -2.54417300e-01f, -2.09578201e-01f, -1.15752906e-01f, 1.47829356e-03f, 2.70139098e-01f, 3.48956198e-01f, 3.94256443e-01f, 2.25974619e-01f,
  -9.22179222e-02f, 2.88421437e-02f, 1.16998613e-01f, 1.28840849e-01f, -6.37856573e-02f, 1.11655429e-01f, -1.96979627e-01f, -1.51838511e-01f, -2.35866591e-01f, -1.36775896e-01f,
  -6.66254610e-02f, -2.75351793e-01f, 1.38921559e-01f, -5.65329231e-02f, -6.22814484e-02f, -1.03912957e-01f, 3.25314030e-02f, -1.34943575e-01f, -5.29493131e-02f, -6.53103665e-02f,
  5.97480545e-03f, -3.49430144e-02f, -1.20038532e-01f, -1.03381164e-01f, 5.22209108e-02f, 2.21631657e-02f, -1.51654214e-01f, -1.25671834e-01f, -4.92890999e-02f, -1.34463549e-01f,
  -2.34696537e-01f, 1.63166430e-02f, 9.15383771e-02f, -1.88741069e-02f, -5.22003844e-02f, 6.23111129e-02f, -1.21562704e-01f, -4.35403809e-02f, -3.91257107e-02f, -8.50442871e-02f,
  -7.57147223e-02f, -5.42384200e-02f, 2.39230487e-02f, -6.28969073e-02f, 2.36039087e-02f, -2.55642347e-02f, 3.69338691e-02f, -1.31218741e-02f, 9.51343551e-02f, 5.06854691e-02f,
  4.25404198e-02f, -1.17835840e-02f, 5.24481805e-03f, -1.61065441e-02f, -4.73168790e-02f, -4.97711748e-02f, 1.64103089e-03f, -5.04022650e-02f, -3.17756906e-02f, 4.76373360e-02f,
  -2.57079136e-02f, 4.74064145e-03f, 8.22100788e-02f, 5.12186065e-03f, -6.55527636e-02f, 9.68957916e-02f, 6.27006814e-02f, -8.08009356e-02f, -2.08419319e-02f, 4.93727215e-02f,
  9.42921042e-02f, -2.51122504e-01f, 9.05153379e-02f, 1.37757789e-02f, 9.11439490e-03f, -1.49742723e-01f, -7.73569793e-02f, -1.02041312e-01f, -6.16499670e-02f, -1.16503770e-02f,
  -1.39856860e-01f, 3.43988650e-02f, -6.88345283e-02f, -6.06948435e-02f, 1.13575034e-01f, 1.09034434e-01f, -7.49965161e-02f, 9.47584361e-02f, -4.84697260e-02f, -5.00983410e-02f,
  -1.28104657e-01f, 2.17408344e-01f, 2.96922654e-01f, 1.38912305e-01f, -8.76524374e-02f, 3.56943130e-01f, -1.63345225e-02f, 9.92024913e-02f, 2.01713651e-01f, 2.95280099e-01f,
  3.72695178e-01f, 1.78889260e-02f, -1.48668051e-01f, 4.02032256e-01f, 2.00354949e-01f, 3.67019922e-02f, 2.90986188e-02f, 1.53189585e-01f, 1.64748713e-01f, 2.26152450e-01f,
  1.58037499e-01f, 3.38097036e-01f, 2.40926027e-01f, 8.62819776e-02f, 5.37205562e-02f, 1.12852298e-01f, 2.04750001e-01f, 9.02571436e-03f, 1.24183670e-01f, 1.38169676e-01f,
  3.16511959e-01f, 1.97238564e-01f, 4.51058382e-03f, -2.58464273e-02f, 1.68643579e-01f, 2.84664214e-01f, 4.11538444e-02f, -2.92912271e-04f, 1.09487437e-01f, 2.82659709e-01f,
  -2.33750299e-01f, -3.61847840e-02f, 7.09450394e-02f, 5.04758805e-02f, -1.08010732e-01f, -2.29870807e-02f, -3.17862816e-02f, -1.47898406e-01f, -8.15723240e-02f, 3.67946289e-02f,
  -5.18009961e-02f, 1.30851725e-02f, -9.00283605e-02f, -6.51955977e-02f, -1.14529535e-01f, -6.52403831e-02f, -9.05604884e-02f, -2.30031073e-01f, -7.90845603e-02f, -1.96589708e-01f,
  2.81105414e-02f, -6.06457554e-02f, -2.71672964e-01f, -1.44256562e-01f, -1.34628415e-01f, 7.26813674e-02f, -1.62604511e-01f, -3.39070223e-02f, -2.71289289e-01f, 3.07916515e-02f,
  2.82134742e-01f, -2.44018868e-01f, 3.46553093e-03f, 7.43477121e-02f, 1.35452896e-01f, 2.57233530e-02f, -6.44519180e-02f, -1.04520120e-01f, -3.40530798e-02f, -1.20415896e-01f,
  1.81613471e-02f, -1.11127697e-01f, -1.56793356e-01f, 7.89759622e-04f, -1.03163384e-02f, -1.56810895e-01f, -5.06563112e-02f, -6.57613799e-02f, -1.45306647e-01f, 2.09039263e-02f,
  -4.52680029e-02f, -7.30291456e-02f, 5.84108308e-02f, -1.18730560e-01f, 1.27723485e-01f, 8.41303822e-03f, 1.33548051e-01f, -9.52710304e-03f, 1.16600223e-01f, 4.57071140e-02f,
  -1.06038168e-01f, -1.38094366e-01f, 2.14108512e-01f, -6.65517226e-02f, -1.58300757e-01f, -4.53535765e-02f, 9.25269164e-03f, -9.76011828e-02f, -8.38451982e-02f, 3.68483714e-04f,
  -1.14541799e-01f, 4.43827137e-02f, -4.77511920e-02f, -1.21571824e-01f, -1.78592633e-02f, 4.21801284e-02f, 2.25520413e-02f, 3.09663289e-03f, -1.62001729e-01f, -1.35379925e-01f,
  -3.25641781e-02f, -5.39924167e-02f, 4.01116833e-02f, -6.56740915e-04f, -4.90861349e-02f, 1.59976393e-01f, 1.15736825e-02f, -2.15130066e-03f, -1.66117415e-01f, 4.34894934e-02f,
  -1.57993957e-02f, 1.63821414e-01f, 1.39886916e-01f, 1.02400510e-02f, -2.17343375e-01f, -4.14682627e-01f, -2.92573571e-01f, -1.16873011e-01f, -5.91515042e-02f, 8.04770961e-02f,
  -1.41468868e-01f, -2.32447416e-01f, -2.35797036e-02f, 3.75291593e-02f, -3.63416702e-01f, -7.83917382e-02f, 5.03536798e-02f, -6.65805638e-02f, -5.49364269e-01f, -4.66031820e-01f,
  -1.63476810e-01f, 4.51171510e-02f, -1.89651892e-01f, -2.54609078e-01f, 1.07353136e-01f, 9.71186385e-02f, 4.23638970e-01f, 6.83571324e-02f, -9.83784907e-03f, 3.98455113e-01f,
  2.68630087e-01f, -6.07851036e-02f, -1.42634273e-01f, -1.69192791e-01f, 1.65637699e-03f, 3.45305763e-02f, -1.21301450e-01f, 9.28656906e-02f, -1.49683863e-01f, 7.30605349e-02f,
  -1.07901171e-01f, -1.29036665e-01f, -1.03143007e-01f, -9.83136520e-02f, -2.25954354e-01f, -1.06763065e-01f, 1.48099363e-02f, -4.98872995e-02f, -7.73155615e-02f, -9.81587730e-03f,
  -1.51630968e-01f, -1.80324510e-01f, -1.87277079e-01f, 3.28389928e-02f, 3.53367962e-02f, -2.78733876e-02f, 1.28312362e-02f, -5.20288460e-02f, -3.94577347e-03f, 4.98332053e-01f,
  7.03912154e-02f, 4.13456075e-02f, 2.15419047e-02f, 7.17880130e-02f, 2.02476270e-02f, 1.24476798e-01f, 1.18445717e-01f, 5.72839603e-02f, -7.47527853e-02f, -6.64077699e-02f,
  6.75699711e-02f, 7.72186741e-02f, 5.95676526e-02f, 7.92183056e-02f, 1.59703121e-02f, -7.19881728e-02f, -2.90863775e-02f, 4.81771231e-02f, -8.23608264e-02f, -4.66008373e-02f,
  -1.22962154e-01f, -3.72441299e-02f, 2.08728071e-02f, -1.53240319e-02f, 4.83156182e-03f, -3.46058607e-02f, -1.55957669e-01f, -1.55371577e-01f, -1.01055488e-01f, -9.50508863e-02f,
  1.75888650e-02f, -3.60554606e-01f, 4.33474407e-02f, -3.32929373e-01f, -4.61353995e-02f, 8.65503177e-02f, 6.01134002e-02f, -1.78041460e-03f, -4.75606583e-02f, -1.18007146e-01f,
  -2.40296960e-01f, 5.54628894e-02f, 1.03136770e-01f, -1.11775383e-01f, -6.76447004e-02f, 9.77803618e-02f, -1.26492798e-01f, -6.98716864e-02f, -1.20691121e-01f, -9.70255136e-02f,
  -6.25189841e-02f, -9.12407339e-02f, 1.31148234e-01f, 2.04959750e-01f, -4.74790484e-02f, 3.31754386e-02f, 7.51972347e-02f, -1.63881764e-01f, -4.54269275e-02f, 2.42968693e-01f,
  -8.10823813e-02f, 5.12035489e-02f, 5.20729460e-02f, 3.32033783e-01f, 7.98933804e-02f, 1.06111541e-01f, -1.36178546e-02f, 1.79525897e-01f, 2.73296177e-01f, 2.00096384e-01f,
  9.65257585e-02f, 2.37730950e-01f, 2.28958368e-01f, 3.01376879e-01f, 3.10276985e-01f, 3.37692440e-01f, 4.03663605e-01f, 1.78619683e-01f, 1.91849083e-01f, 1.24367341e-01f,
  2.88692296e-01f, 1.65122792e-01f, 9.86224338e-02f, 1.39613673e-01f, 2.74229437e-01f, 2.34391794e-01f, 6.20669983e-02f, 4.07921299e-02f, 1.66093692e-01f, 3.51576030e-01f,
  5.37152849e-02f, -2.13857695e-01f, 9.33306441e-02f, -3.75198014e-02f, -9.87713560e-02f, 5.45992851e-02f, -9.82679576e-02f, -3.93321142e-02f, -8.04515034e-02f, -5.80981039e-02f,
  -1.02311730e-01f, -1.36871591e-01f, -1.04830578e-01f, -9.36612263e-02f, -8.37308988e-02f, -1.10882036e-01f, -3.65134552e-02f, 1.49814948e-01f, 1.37379065e-01f, 3.75138666e-03f,
  4.81134020e-02f, -6.09545857e-02f, -9.07911509e-02f, 1.09820724e-01f, 4.22473438e-02f, -5.51508591e-02f, -7.40999654e-02f, 1.30251586e-03f, -3.17933299e-02f, 6.33492097e-02f,
  1.95874721e-01f, 1.28020242e-01f, -2.73798686e-02f, -1.53631587e-02f, -1.69813499e-01f, -4.87135947e-02f, -2.05734968e-02f, -8.51631612e-02f, 4.54127900e-02f, -2.04921067e-01f,
  -5.31223640e-02f, 1.65645763e-01f, -7.57139921e-03f, -5.55425845e-02f, 8.04621428e-02f, 3.21872085e-02f, -1.21902488e-01f, -9.87641066e-02f, -6.94768801e-02f, -7.07336515e-02f,
  -2.79703923e-02f, -8.31440687e-02f, -1.72683001e-01f, -4.61882539e-02f, 4.97411862e-02f, -1.94992181e-02f, 3.90390679e-02f, -2.59394683e-02f, -6.70094416e-02f, 1.11444378e-02f,
  1.08901404e-01f, -7.07696974e-02f, 2.84057289e-01f, 1.61954343e-01f, -1.04805991e-01f, -5.24004996e-02f, 6.74769059e-02f, 9.61641781e-03f, -1.48318097e-01f, 1.24797195e-01f,
  -2.16274679e-01f, -1.36701427e-02f, -1.59667179e-01f, -2.19822034e-01f, -2.72408724e-01f, -8.55254233e-02f, -1.10748656e-01f, 1.73022181e-01f, 3.93986963e-02f, 2.40311511e-02f,
  1.58564164e-03f, -9.79284644e-02f, 9.19985101e-02f, -6.96125329e-02f, -4.64286609e-03f, 1.53279984e-02f, -1.57159001e-01f, -2.01961637e-01f, -7.74058625e-02f, -2.26211116e-01f,
  -5.61864674e-01f, 1.90915272e-01f, 2.23641470e-02f, -5.53525925e-01f, -1.86119825e-01f, 7.80360773e-02f, 6.18891895e-01f, 1.60718933e-02f, -1.91389158e-01f, 4.12567139e-01f,
  1.75095916e-01f, -2.16041833e-01f, 1.13132391e-02f, -9.67855155e-02f, 1.01017848e-01f, 3.91258359e-01f, 9.85675156e-02f, -7.69465342e-02f, -3.66316319e-01f, -1.87833086e-01f,
  -3.98942083e-02f, -1.04962170e-01f, -4.10682470e-01f, -4.13508475e-01f, -2.10854053e-01f, -1.42982110e-01f, 6.71595708e-02f, -9.85756963e-02f, -1.91935211e-01f, 2.56580990e-02f,
  3.08270991e-01f, -3.88515025e-01f, 4.89970967e-02f, -3.82406503e-01f, -1.95300862e-01f, -7.12067708e-02f, 5.35874255e-03f, -2.89468408e-01f, -2.26402164e-01f, -5.37941195e-02f,
  -1.69771805e-01f, -4.42280732e-02f, -2.04572499e-01f, 9.63420942e-02f, -9.01060328e-02f, -6.13699965e-02f, -1.68762933e-02f, -2.81898141e-01f, -2.64746308e-01f, 4.13345955e-02f,
  -7.24768918e-03f, -1.14358775e-01f, -1.44100815e-01f, 1.68541465e-02f, -2.31334463e-01f, -1.52714729e-01f, 2.46297512e-02f, -2.77198166e-01f, -8.31570402e-02f, 2.05308273e-01f,
  1.04720294e-01f, -3.80603690e-03f, -9.48297232e-03f, 7.21402243e-02f, 1.21216357e-01f, 1.36123989e-02f, -5.14620878e-02f, 3.59793939e-02f, 8.25676247e-02f, 4.62929867e-02f,
  1.16071977e-01f, 7.61332139e-02f, -6.18629390e-03f, 7.71343112e-02f, 6.36098906e-02f, -8.68482813e-02f, -5.45572639e-02f, 1.05610974e-01f, -6.52542338e-02f, -6.38955981e-02f,
  -4.10252623e-02f, 7.24671409e-02f, -5.04183657e-02f, 3.92705426e-02f, 6.12320099e-03f, -6.63280934e-02f, 8.28692913e-02f, -3.40499245e-02f, -1.79065596e-02f, 9.20843985e-03f,
  2.85243601e-01f, -2.45073095e-01f, 2.47130170e-01f, 9.29449126e-02f, -8.73252302e-02f, -8.85891095e-02f, 5.24178781e-02f, -3.99200730e-02f, -8.03263634e-02f, 3.25273834e-02f,
  -2.77496390e-02f, -6.69054091e-02f, -1.27837434e-02f, 7.69448951e-02f, 2.37051211e-03f, -8.41594581e-03f, 1.29520774e-01f, -1.44743696e-01f, 3.20664532e-02f, 7.80137926e-02f,
  2.10151792e-01f, 2.36837149e-01f, 1.65243670e-01f, 2.12005496e-01f, 3.60325500e-02f, 1.61301225e-01f, 3.36911768e-01f, 1.51049554e-01f, -9.75309685e-03f, 6.19826972e-01f,
  5.17231882e-01f, 1.48172900e-01f, 2.71037132e-01f, 9.79628265e-02f, -4.15384136e-02f, -8.31777677e-02f, 4.80653457e-02f, 2.18229949e-01f, 2.00947002e-02f, 9.71040353e-02f,
  -7.80753493e-02f, -9.52553302e-02f, 8.30049738e-02f, 2.06285819e-01f, 2.19341695e-01f, 1.55115768e-01f, 2.50611633e-01f, 4.38697726e-01f, 3.18364412e-01f, 1.82292640e-01f,
  8.77807811e-02f, 3.72044116e-01f, 4.01965350e-01f, 1.58471271e-01f, 1.09605752e-01f, -7.91077316e-02f, 1.75631121e-01f, 1.88967258e-01f, 1.62326425e-01f, 2.24322617e-01f,
  -1.42186344e-01f, 2.48055562e-01f, -1.65299531e-02f, -1.41070843e-01f, -7.34421909e-02f, 3.25183943e-02f, -9.75978225e-02f, -4.34486233e-02f, -1.01018660e-01f, 1.02067836e-01f,
  -2.30555907e-01f, 6.11496828e-02f, 1.87472954e-01f, 1.53168052e-01f, -6.50489926e-02f, -1.26877595e-02f, 1.82881162e-01f, 3.57386917e-01f, 1.87312797e-01f, -1.41991051e-02f,
  -6.54268684e-03f, -1.06679089e-01f, 4.02767360e-02f, 3.50280255e-02f, 2.47442424e-01f, -4.90997098e-02f, 1.25975497e-02f, -2.60202754e-02f, -4.21643781e-05f, 1.65027052e-01f,
  5.99219056e-04f, 7.87317455e-02f, 1.38653994e-01f, 1.06035180e-01f, 2.30260223e-01f, -7.61358440e-02f, 4.95091081e-02f, 3.14485691e-02f, 2.88714141e-01f, 1.51269585e-01f,
  4.04172353e-02f, 1.96856961e-01f, 1.29130423e-01f, 1.38277888e-01f, -4.53432538e-02f, 2.51115486e-02f, 5.89720160e-02f, 4.13730256e-02f, -6.16162121e-02f, 9.98511761e-02f,
  9.51697975e-02f, 1.19549900e-01f, -6.08233623e-02f, 1.13875084e-01f, -4.51090112e-02f, 3.73217240e-02f, 1.59986392e-02f, 4.01754119e-02f, -6.73173890e-02f, -4.63016927e-02f,
  -3.10406834e-01f, 1.02815561e-01f, 7.53519684e-02f, 4.65568714e-02f, -6.03689924e-02f, -1.29455104e-02f, 4.52385321e-02f, -7.03078061e-02f, -1.81098744e-01f, -4.98248562e-02f,
  -9.53901857e-02f, -6.06818730e-03f, 1.22577719e-01f, 1.11907326e-01f, -2.86608618e-02f, -1.22714669e-01f, -1.80040076e-01f, -1.90481003e-02f, 7.95339514e-03f, -7.52359405e-02f,
  4.08229157e-02f, -5.69430329e-02f, -1.71133190e-01f, -1.15897633e-01f, 2.32126992e-02f, -1.68081537e-01f, -2.74926752e-01f, -1.85018107e-01f, -1.18695013e-01f, -1.29080400e-01f,
  4.23816830e-01f, -3.33776593e-01f, 1.65886581e-01f, 3.35424602e-01f, 4.07487266e-02f, 9.79161859e-02f, -2.63570566e-02f, 3.78794558e-02f, 1.70059413e-01f, 5.71722947e-02f,
  1.50975913e-01f, 4.02274519e-01f, 3.05627912e-01f, 2.02606097e-01f, 1.24430656e-01f, -4.07082820e-03f, -7.76852444e-02f, 1.80404291e-01f, 3.78721476e-01f, 3.13004881e-01f,
  1.02944031e-01f, -1.03032738e-01f, -6.48840368e-02f, 1.13570029e-02f, -1.34051025e-01f, 2.41055638e-01f, 1.62092242e-02f, -7.67957270e-02f, -1.71671048e-01f, -1.59852535e-01f,
  3.49302649e-01f, -6.07966594e-02f, 2.50156254e-01f, -6.46674037e-02f, -1.26150757e-01f, -6.01277594e-03f, 1.84448928e-01f, -2.00381521e-02f, 4.54017892e-02f, 2.76759304e-02f,
  -1.75358616e-02f, -1.74717963e-01f, -1.29925132e-01f, -9.15158689e-02f, -1.42119685e-02f, -6.71735927e-02f, -2.28583571e-02f, 6.36207983e-02f, 1.33524343e-01f, -3.21038403e-02f,
  -6.39941394e-02f, -4.72130328e-02f, 1.61265090e-01f, 1.27779424e-01f, 1.33940026e-01f, 1.35005414e-01f, -6.84604235e-03f, -8.14647228e-03f, 6.12356961e-02f, 2.42810752e-02f,
  1.27938718e-01f, 1.27919540e-01f, 8.69740397e-02f, 6.91173878e-03f, 1.21954437e-02f, 9.32386294e-02f, 4.96570356e-02f, 4.85612117e-02f, 3.61961201e-02f, -7.86297098e-02f,
  8.12233519e-03f, 1.57796651e-01f, 1.55409828e-01f, 1.12749159e-01f, 4.53841053e-02f, -9.19655487e-02f, -1.99780092e-02f, 1.23082602e-03f, -3.27316225e-02f, -4.74967575e-03f,
  -1.02803990e-01f, -3.95394936e-02f, 1.29185279e-03f, -9.46904793e-02f, -1.13063827e-02f, 1.39011532e-01f, 1.79364979e-02f, -1.29274979e-01f, -2.56090183e-02f, -1.13008894e-01f,
  1.70363650e-01f, 1.77300707e-01f, 4.22128588e-02f, -5.77859282e-02f, -3.41728777e-02f, -5.37480153e-02f, 8.00478309e-02f, 1.89893208e-02f, -7.78895523e-03f, 6.89042434e-02f,
  -1.17314821e-02f, 1.18752882e-01f, -1.10834040e-01f, -1.19626172e-01f, 8.06469321e-02f, 3.07679754e-02f, -9.28143039e-02f, 1.60163477e-01f, 7.53414929e-02f, 2.35451795e-02f,
  -1.10993363e-01f, 1.96078345e-01f, 3.02364647e-01f, 1.48490787e-01f, 1.54305503e-01f, 2.29744464e-01f, 1.21236779e-01f, -3.01204864e-02f, 1.77730262e-01f, 1.42128333e-01f,
  7.09373713e-01f, 3.65351737e-01f, 2.49929696e-01f, 1.24118835e-01f, -2.60105461e-01f, -1.76241189e-01f, -2.12327719e-01f, -1.26811862e-01f, -4.69166003e-02f, 1.26287699e-01f,
  -5.07399738e-02f, -1.58250660e-01f, -9.98512283e-02f, 3.91557626e-02f, 4.07443903e-02f, -3.49543542e-02f, 4.40319665e-02f, 2.11897284e-01f, 8.53513479e-02f, -7.99804088e-03f,
  -1.04462609e-01f, 2.29240015e-01f, 5.00172913e-01f, 1.70083776e-01f, -9.43574533e-02f, -1.11299485e-01f, 2.83908583e-02f, 2.73304194e-01f, 1.72607034e-01f, 5.75762466e-02f,
  6.45949543e-02f, 2.93763280e-01f, -4.34594482e-01f, 7.69609818e-03f, 3.60705666e-02f, 1.40003577e-01f, -8.62323307e-03f, 1.70136973e-01f, 2.00501140e-02f, -9.27631333e-02f,
  -2.15297774e-03f, 1.98378451e-02f, -1.04494713e-01f, -1.11763798e-01f, -3.93010005e-02f, -1.88593194e-02f, 1.08489521e-01f, 8.83467495e-02f, -1.42918937e-02f, 2.83413101e-02f,
  -1.20948642e-01f, 1.42212346e-01f, 4.91636135e-02f, -2.84283221e-01f, -1.52414992e-01f, -1.40251815e-01f, -1.02108769e-01f, -5.66917583e-02f, 1.94689166e-02f, 1.31042153e-01f,
  -4.45507392e-02f, -6.64761066e-02f, -7.15744719e-02f, -5.16606085e-02f, -6.37527183e-02f, -1.59222335e-01f, -1.12320445e-01f, -1.34503722e-01f, -6.58222288e-02f, -3.91508713e-02f,
  -1.46468982e-01f, -4.94428501e-02f, -1.22092046e-01f, 4.41620424e-02f, -5.50325513e-02f, 4.07283893e-03f, -1.32614598e-01f, -9.01422724e-02f, -4.58320305e-02f, 2.28556916e-02f,
  -1.54415831e-01f, -1.40588328e-01f, -2.32078950e-03f, -3.23894918e-02f, -5.69916964e-02f, -1.30798459e-01f, -1.31332457e-01f, -1.76144958e-01f, -1.02713248e-02f, 1.18705571e-01f,
  -1.29935607e-01f, -1.69942565e-02f, -2.85226882e-01f, 1.02629468e-01f, 1.07634641e-01f, 1.32374510e-01f, -4.11066134e-03f, -1.04195587e-01f, -7.20942989e-02f, -9.35459789e-03f,
  1.37263149e-01f, -1.16181023e-01f, 8.10585916e-03f, -2.71367989e-02f, -5.84707633e-02f, -1.22600533e-01f, 7.46762455e-02f, -1.23626232e-01f, -2.24585030e-02f, 1.86953358e-02f,
  -3.30228396e-02f, -1.74154162e-01f, -2.09697992e-01f, -1.51360840e-01f, -1.08089015e-01f, -2.99695790e-01f, -2.98868716e-01f, -1.71240196e-01f, -1.16924174e-01f, -1.62297592e-01f,
  -1.45641826e-02f, 1.81955650e-01f, 1.43203944e-01f, 1.41263574e-01f, 1.07221633e-01f, -6.71831146e-02f, 1.14384852e-01f, 3.01936064e-02f, 2.33975761e-02f, 5.81012061e-03f,
  -1.66321754e-01f, 6.56682998e-02f, 2.62772702e-02f, 5.79349622e-02f, 9.97443125e-02f, 2.02075318e-01f, 2.60176629e-01f, 1.60064012e-01f, 1.45213353e-02f, 1.01098962e-01f,
  1.36189073e-01f, 6.13356270e-02f, -1.59154102e-01f, -6.27170899e-04f, 2.11072683e-01f, 6.69390634e-02f, -3.89748402e-02f, 1.09739430e-01f, -2.83181164e-02f, 3.54047060e-01f,
  -1.86381698e-01f, -1.86672900e-02f, 4.67659347e-02f, 7.35939220e-02f, -4.17429656e-02f, -1.03628635e-01f, 4.84156199e-02f, -7.84284323e-02f, 9.76858959e-02f, -2.18286198e-02f,
  1.22236967e-01f, 1.37786428e-02f, 2.43004840e-02f, 5.61600924e-03f, -1.49018774e-02f, 1.04770616e-01f, 8.92700776e-02f, 3.56757045e-02f, 2.24990193e-02f, 2.48063039e-02f,
  1.22306630e-01f, -5.87773025e-02f, -1.10388525e-01f, -2.43292954e-02f, 1.17202900e-01f, 5.32058533e-03f, -1.07832644e-02f, 6.47657067e-02f, -1.45668194e-01f, -1.09355832e-02f,
  -8.86414386e-03f, 5.21959029e-02f, 6.08043075e-02f, 1.39564469e-01f, 1.28777906e-01f, 1.39376028e-02f, 1.84056431e-01f, 3.98904458e-02f, 1.18482634e-01f, 7.81952441e-02f,
  2.12205946e-02f, -1.36173114e-01f, 1.98247489e-02f, -3.82588990e-02f, 4.33646925e-02f, -7.08125457e-02f, 7.59246945e-02f, 5.73098697e-02f, -4.29405756e-02f, 2.97359806e-02f,
  5.36727495e-02f, -6.29655123e-02f, -9.61986929e-02f, 8.42888057e-02f, -7.23544657e-02f, 1.34681925e-01f, 5.31574078e-02f, 9.21393000e-03f, 6.95650280e-02f, 6.96074218e-02f,
  -5.18038929e-01f, -2.57990301e-01f, 8.52888152e-02f, 2.64306180e-02f, -1.40888661e-01f, -1.78941280e-01f, -3.69008966e-02f, -1.06607974e-01f, -2.44822167e-03f, 4.78950702e-02f,
  -9.26016793e-02f, 2.81776376e-02f, 1.81445945e-02f, -2.78103184e-02f, -8.86908844e-02f, -2.52992809e-02f, 1.08573295e-01f, 8.45136270e-02f, -1.08817875e-01f, 9.49748419e-03f,
  -3.28553393e-02f, -4.52394374e-02f, -7.65254796e-02f, -8.69301483e-02f, -2.70382278e-02f, -4.76969518e-02f, -8.66190046e-02f, -1.23000182e-01f, -2.75386572e-01f, -2.55648702e-01f,
  7.93057501e-01f, -1.22922823e-01f, -5.50607264e-01f, 3.25423717e-01f, -2.51717627e-01f, -1.53145775e-01f, -3.39776427e-02f, 5.35132065e-02f, 3.07786524e-01f, -3.75904664e-02f,
  -4.07902777e-01f, -2.25514174e-01f, -1.19919851e-01f, -2.58248776e-01f, -5.25952466e-02f, -4.41817977e-02f, -4.25745621e-02f, -7.43380189e-02f, -1.32876383e-02f, -6.31969422e-02f,
  7.76685178e-02f, 2.66296387e-01f, 2.35428706e-01f, 3.95610183e-02f, -3.32574435e-02f, -3.44594121e-02f, -1.37076020e-01f, -1.78331733e-01f, -2.49522597e-01f, -1.60508499e-01f,
  -3.37562978e-01f, -4.39671099e-01f, -2.81717107e-02f, 5.01565523e-02f, -1.03532754e-01f, 2.84698993e-01f, 6.12375326e-02f, -7.90087059e-02f, -8.35735947e-02f, -1.28671825e-01f,
  -2.30705157e-01f, -1.21056512e-02f, -2.27341041e-01f, -2.08133161e-01f, -1.12728067e-02f, 2.91362032e-02f, 1.72941238e-02f, -3.56631936e-03f, 5.61306253e-02f, -9.03583094e-02f,
  -9.19708759e-02f, -1.52560920e-01f, -2.48979092e-01f, -1.90217733e-01f, -2.21545741e-01f, -1.65461540e-01f, -2.38841102e-01f, -2.99614608e-01f, -2.05469638e-01f, 1.40875593e-01f,
  7.05499053e-02f, 1.31823402e-02f, 7.03024194e-02f, 5.14500923e-02f, 2.41699725e-01f, -2.67508882e-03f, 3.71120535e-02f, 8.47132429e-02f, -3.72473001e-02f, 1.16376124e-01f,
  -6.60016481e-03f, 3.62979225e-03f, -5.82306972e-03f, 2.25044377e-02f, -8.43765400e-03f, -4.47711721e-02f, 6.77613020e-02f, 4.45038453e-02f, -7.58037567e-02f, 1.07722566e-01f,
  -3.39359306e-02f, -4.19858359e-02f, -5.31254224e-02f, 1.00042671e-01f, -6.92662969e-03f, -1.78714529e-01f, -1.32812466e-02f, -5.09364903e-02f, -7.91238025e-02f, 2.78086904e-02f,
  4.42689717e-01f, -1.44411713e-01f, 1.72038421e-01f, 3.04677915e-02f, -3.34858820e-02f, -1.26892943e-02f, -7.30779991e-02f, 7.92188644e-02f, 5.82905822e-02f, 4.64206748e-02f,
  -1.33901834e-01f, 1.01780392e-01f, -3.65206599e-02f, -1.03732631e-01f, 1.13652959e-01f, 3.88143845e-02f, 8.69527310e-02f, 5.84479719e-02f, 2.52219662e-02f, 1.42947257e-01f,
  1.87781602e-01f, 2.55313337e-01f, 2.60615081e-01f, 1.65115431e-01f, 1.24259420e-01f, 1.47074655e-01f, 1.50300741e-01f, 1.72705695e-01f, 1.26894385e-01f, 5.09129941e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  5.10869503e-01f, 2.82210916e-01f, 3.54791641e-01f, 1.21637307e-01f, 4.78631258e-01f, 1.07251115e-01f, 6.54554605e-01f, 2.78634995e-01f, 3.47160548e-01f, 2.70157069e-01f,
  3.23351890e-01f, 4.69424576e-01f, 2.12970197e-01f, 2.60521293e-01f, 2.25794703e-01f, 4.90477949e-01f, -8.09533522e-02f, 4.91430789e-01f, 3.03000838e-01f, 3.72874588e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -6.91109970e-02f, 1.26460761e-01f, -2.32133996e-02f, -6.57690875e-03f, -2.00608999e-01f, -7.22979158e-02f, 2.38253456e-02f, -1.83568448e-01f, 1.71818659e-02f, 2.47574896e-01f,
  2.81007849e-02f, 2.09758908e-01f, 2.07836524e-01f, -1.44726530e-01f, -9.96316150e-02f, -1.07216135e-01f, -3.23309243e-01f, -3.38899553e-01f, 1.87750459e-01f, 3.09886336e-02f,
  -2.50781298e-01f, 1.27973437e-01f, 5.18478863e-02f, 8.90746117e-02f, 2.72140235e-01f, -2.04863567e-02f, 2.96867549e-01f, 2.19593450e-01f, -2.75787890e-01f, 3.19788717e-02f,
  9.49438959e-02f, -3.07049811e-01f, -2.28169113e-02f, 1.65042460e-01f, 1.02227390e-01f, 2.81198183e-03f, 4.76874120e-04f, 1.04878440e-01f, 1.91575184e-01f, 8.88230130e-02f,
  1.18026314e-02f, -5.47272898e-02f, -7.73185445e-03f, 9.38094184e-02f, -1.07642516e-01f, 1.95391662e-02f, 1.19096182e-01f, 1.08920582e-01f, -2.98523188e-01f, 6.23953715e-03f,
  -3.53514940e-01f, 1.07162155e-01f, -1.80698946e-01f, -1.13368504e-01f, 2.74696320e-01f, 1.68047398e-01f, 9.89872590e-02f, 3.06239754e-01f, 1.37626797e-01f, -9.50468630e-02f,
  1.13600977e-01f, 2.71742225e-01f, 8.22858140e-02f, -5.80186956e-02f, -1.07697204e-01f, -5.36626317e-02f, -1.61714286e-01f, -3.52397524e-02f, -1.09993741e-01f, -1.33445084e-01f,
  1.72872305e-01f, -4.26374301e-02f, -6.05477653e-02f, -1.20825440e-01f, -2.09938791e-02f, 1.57204852e-01f, -2.56893218e-01f, -1.07898517e-02f, 2.58195251e-01f, 3.20355386e-01f,
  1.90351214e-02f, 2.19631374e-01f, -6.77182615e-01f, 1.93544984e-01f, -3.75709563e-01f, 2.12667435e-01f, -2.13754013e-01f, 6.65003434e-02f, 6.57597631e-02f, 6.15438037e-02f,
  -2.45959666e-02f, 7.67843574e-02f, -2.70410448e-01f, -9.34107378e-02f, -7.96339959e-02f, 1.78570017e-01f, -1.62648819e-02f, 1.84364751e-01f, -1.51237873e-02f, -8.15552548e-02f,
  -4.80891541e-02f, 6.43032938e-02f, -2.34446585e-01f, -7.97358006e-02f, -2.13975415e-01f, 7.52718225e-02f, 9.84102264e-02f, 1.34581566e-01f, 5.35768926e-01f, 1.75515816e-01f,
  9.59559157e-02f, -5.01643717e-02f, -2.80616730e-01f, -1.86466932e-01f, -3.44470888e-01f, 6.84801638e-02f, -3.90848279e-01f, -7.08662719e-03f, 1.84377227e-02f, 2.30017919e-02f,
  3.37987214e-01f, -5.97471185e-02f, 3.91431093e-01f, -9.80938971e-02f, -1.11736998e-01f, -1.99163705e-01f, 2.07727477e-01f, -1.69074520e-01f, 1.91691201e-02f, 2.25007022e-03f,
  -1.48743927e-01f, -8.57969820e-02f, -2.52301097e-02f, -4.54474151e-01f, 2.10000664e-01f, 1.69171795e-01f, 1.29515473e-02f, -2.72673041e-01f, 1.10190041e-01f, 1.07700191e-01f,
  -1.52001381e-01f, 3.58665049e-01f, 1.41116157e-01f, -4.72227186e-02f, -2.52659649e-01f, -1.33183897e-01f, -2.93453783e-01f, 1.87740680e-02f, -2.31494695e-01f, -2.03797773e-01f,
  2.78417110e-01f, 2.69548828e-03f, 5.76384598e-03f, -1.89152639e-02f, -9.35845971e-02f, -4.83139679e-02f, -9.89930704e-02f, -8.76365006e-02f, 1.51274232e-02f, 2.05255449e-01f,
  2.86983736e-02f, -9.10111144e-02f, -6.91968724e-02f, -1.73031539e-01f, -6.70279041e-02f, -1.89544931e-02f, 4.00165856e-01f, -5.38204163e-02f, 2.00540526e-05f, 8.98642316e-02f,
  2.99645185e-01f, 6.14211299e-02f, -3.89554709e-01f, 1.98513031e-01f, 2.48164207e-01f, 8.48585293e-02f, -3.21315527e-01f, 1.33254468e-01f, 2.39417970e-01f, 1.48812801e-01f,
  -1.65847585e-01f, -1.73895687e-01f, 2.75824159e-01f, 4.97947671e-02f, -2.39465341e-01f, -1.21906489e-01f, 1.59442574e-01f, -1.20668463e-01f, -6.08029962e-02f, -3.21799032e-02f,
  1.14963301e-01f, -1.08694717e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.79021387e-02f, 4.56811875e-01f, 1.79409295e-01f, -4.61819069e-03f, 5.21885753e-02f, 5.02540052e-01f, -5.80361128e-01f, 8.31633881e-02f, 1.40606254e-01f, 2.20480226e-02f,
  7.90617168e-02f, 2.89257336e-02f, 4.85105127e-01f, -1.14793681e-01f, 8.76314566e-02f, 3.96772683e-01f, 5.19933812e-02f, -1.44792944e-01f, -3.79608423e-01f, 1.58159092e-01f,
  -2.42103979e-01f, -8.48395526e-02f, -2.32694104e-01f, 2.33782768e-01f, 4.32720929e-01f, -1.38715088e-01f, 5.59886806e-02f, 3.32730740e-01f, -3.87728661e-01f, 4.57266718e-01f,
  2.35101923e-01f, 2.35776454e-01f, 5.48093468e-02f, 2.22852737e-01f, 5.95874861e-02f, 1.99296281e-01f, -1.09423108e-01f, -2.62667805e-01f, -3.48977327e-01f, -3.39644700e-02f,
  2.20510557e-01f, 1.06484182e-01f, 1.83732226e-01f, 7.84888193e-02f, 3.61586481e-01f, 8.27572569e-02f, 3.07467282e-01f, 3.27604532e-01f, 2.91292548e-01f, 1.10232994e-01f,
  -7.19708264e-01f, 2.27617428e-01f, 1.45090837e-02f, -1.55843869e-01f, -1.17642082e-01f, 3.35074455e-01f, 5.87531105e-02f, 4.01754737e-01f, -3.46508592e-01f, -6.87154457e-02f,
  1.68793667e-02f, -1.54979154e-01f, 3.35971057e-01f, -1.49107143e-01f, -1.18753985e-02f, 3.26709688e-01f, 2.29175702e-01f, 1.09241130e-02f, 3.75902206e-01f, 4.69940066e-01f,
  -2.77235746e-01f, -5.78235202e-02f, 1.10171422e-01f, -3.25710744e-01f, 1.34530097e-01f, -1.15825534e-01f, -1.53544113e-01f, -3.07365954e-01f, 3.42244267e-01f, 6.68062329e-01f,
  3.15795183e-01f, 3.48312706e-01f, -5.92576325e-01f, 1.96391061e-01f, -8.54416937e-02f, 2.72073567e-01f, -2.13722512e-01f, 3.42971116e-01f, 3.81057113e-01f, 2.41578855e-02f,
  -7.56077692e-02f, 2.04541475e-01f, -1.38090342e-01f, 3.50581437e-01f, -6.88151568e-02f, 3.19455326e-01f, 2.80932635e-01f, -4.57142033e-02f, 9.41254422e-02f, -3.38725634e-02f,
  -2.75423750e-02f, -1.91374514e-02f, -8.15071836e-02f, -2.30755389e-01f, 2.88746119e-01f, -8.13522656e-03f, -1.86075553e-01f, -2.11868405e-01f, -1.71951920e-01f, 4.22524750e-01f,
  5.67631721e-02f, -5.13093174e-01f, 9.60351825e-02f, -7.92768374e-02f, 7.55556285e-01f, -1.17947072e-01f, 3.81067932e-01f, 1.44513369e-01f, 2.69629776e-01f, 2.42443904e-01f,
  -2.91007698e-01f, -8.85202065e-02f, 1.47648240e-02f, 1.60097495e-01f, 1.20519958e-01f, 5.13537899e-02f, -4.02692892e-02f, 1.04201742e-01f, -1.46003336e-01f, 3.84889767e-02f,
  1.80025250e-01f, -3.35807726e-02f, 2.71127969e-01f, -1.50171250e-01f, 8.99241924e-01f, 6.70632571e-02f, 1.95790846e-02f, -3.46944958e-01f, 5.59247211e-02f, 5.43958008e-01f,
  -2.24986583e-01f, 3.60642672e-01f, 3.86108428e-01f, -2.34845541e-02f, -1.77360892e-01f, 4.17929620e-01f, 2.50330061e-01f, 2.92330235e-01f, -3.31561774e-01f, 2.98652630e-02f,
  -1.79937825e-01f, 9.73468125e-02f, -4.16233726e-02f, 9.84172001e-02f, 6.26835644e-01f, 6.63463697e-02f, -2.92896837e-01f, 1.86333582e-02f, 1.15897931e-01f, -5.09151101e-01f,
  1.67191640e-01f, 1.38971463e-01f, 1.45893976e-01f, 7.53601491e-02f, 1.32691994e-01f, 3.10048521e-01f, -2.24988550e-01f, -3.56509387e-01f, 1.00442264e-02f, 2.59317458e-01f,
  7.54516497e-02f, 1.74720258e-01f, 3.97780329e-01f, -4.64892864e-01f, 3.99835080e-01f, 4.13517654e-01f, 5.81988156e-01f, 3.16989928e-01f, 3.02529365e-01f, 1.35375544e-01f,
  3.56642127e-01f, 4.02978301e-01f, -1.30972371e-01f, 2.44139120e-01f, 4.02940422e-01f, -2.19355896e-01f, 3.22787203e-02f, -1.00980379e-01f, 3.64611216e-04f, -1.99550062e-01f,
  -1.41970292e-01f, 2.08279341e-01f, 1.99022397e-01f, 1.19132943e-01f, 2.33580381e-01f, 3.32216918e-01f, 1.42586216e-01f, -2.71753818e-01f, -1.85234159e-01f, -9.53940153e-02f,
  9.12624374e-02f, 1.86337337e-01f, 2.14892343e-01f, 1.20944940e-02f, 3.15322727e-01f, 8.36490840e-02f, 4.45905238e-01f, 4.94673401e-01f, 2.74813205e-01f, 1.00105114e-01f,
  4.40480322e-01f, 1.62928239e-01f, 3.72728258e-01f, 7.51702413e-02f, 2.40108758e-01f, 2.62290478e-01f, -2.08937019e-01f, 2.06364602e-01f, -4.67563242e-01f, 1.36009470e-01f,
  -1.18240088e-01f, -2.70714790e-01f, 2.43754640e-01f, -7.29034394e-02f, 1.73450470e-01f, -2.57943749e-01f, -8.62543806e-02f, -3.75058390e-02f, -1.16073966e-01f, 2.12771576e-02f,
  8.58678594e-02f, -2.99231529e-01f, -1.15996398e-01f, 2.45677438e-02f, -2.38493368e-01f, -9.12012234e-02f, 6.59787595e-01f, -4.74920720e-02f, 6.51119053e-02f, -1.57495141e-01f,
  -2.44083330e-01f, 7.17719086e-03f, 2.28437588e-01f, -4.66863811e-02f, 3.12370472e-02f, 1.37331486e-01f, -1.60057724e-01f, -3.76044691e-01f, 5.30687571e-01f, 2.80672371e-01f,
  6.60735250e-01f, -1.74148127e-01f, 3.70544307e-02f, -1.62285373e-01f, -1.51969403e-01f, -5.31257391e-01f, 1.05704471e-01f, 2.88606174e-02f, -1.89100113e-02f, 4.10979271e-01f,
  -2.81325877e-02f, -2.75891703e-02f, -8.11830461e-02f, 2.23827273e-01f, -3.94864142e-01f, 1.72763094e-01f, 1.00060152e-02f, 1.19513541e-01f, -1.42217591e-01f, 5.64703703e-01f,
  -1.61549211e-01f, -2.87450105e-01f, 1.28206655e-01f, -2.88314819e-01f, 2.78458446e-01f, -1.20482095e-01f, 2.59586930e-01f, 3.33000451e-01f, 6.52844369e-01f, 2.71740943e-01f,
  -2.83211656e-02f, -7.42276981e-02f, 2.41327643e-01f, 3.51197332e-01f, -1.42197847e-01f, -8.99285078e-02f, 1.76394105e-01f, 6.78334653e-01f, 1.03025638e-01f, 2.03728341e-02f,
  1.00541227e-01f, 3.94762158e-02f, 1.69974014e-01f, 1.17656887e-01f, -3.97199811e-03f, 4.92540672e-02f, 3.31151009e-01f, -4.88478929e-01f, -2.92768609e-02f, -2.82308221e-01f,
  2.64801923e-03f, 1.64714262e-01f, -6.25542998e-02f, -5.47629893e-01f, -3.68716598e-01f, 3.57412314e-03f, -3.60615820e-01f, -2.72617131e-01f, 1.13101564e-01f, -3.66532296e-01f,
  -2.58789837e-01f, -6.84556412e-03f, -1.61207709e-02f, 2.15852454e-01f, -1.17961340e-01f, 3.97284806e-01f, 3.18694748e-02f, 5.89462221e-01f, 4.17762369e-01f, -1.93972215e-01f,
  2.37491533e-01f, 3.12130064e-01f, 4.08867002e-01f, 7.36568198e-02f, 1.63855448e-01f, 4.22195733e-01f, -2.49450877e-01f, -1.02835752e-01f, -8.95561129e-02f, 3.40841591e-01f,
  3.22086252e-02f, -3.48898411e-01f, 4.27642345e-01f, -1.90714106e-01f, 1.70421526e-01f, 3.55487317e-01f, -1.05735417e-02f, -4.23730642e-01f, 3.69303852e-01f, 8.58984068e-02f,
  -2.11337611e-01f, -1.96133298e-03f, -1.94405869e-01f, -1.14188209e-01f, 4.44983423e-01f, 1.95607275e-01f, 4.68582213e-01f, 2.23712757e-01f, 5.64522222e-02f, 4.46119100e-01f,
  -1.30727189e-02f, -1.06665783e-01f, 1.38397679e-01f, 6.54268786e-02f, -1.02306075e-01f, 1.33900598e-01f, 1.42607138e-01f, -7.14181960e-02f, 3.37501734e-01f, -1.73930213e-01f,
  -3.07456069e-02f, 2.67337784e-02f, -4.13211584e-02f, -1.42499983e-01f, -4.89131153e-01f, 1.67217851e-01f, 3.15941155e-01f, -1.30772412e-01f, 3.14923584e-01f, 4.27659780e-01f,
  4.85390127e-01f, 3.52970600e-01f, 4.27601933e-01f, 3.84194583e-01f, 3.16085368e-01f, 8.09284374e-02f, -1.01738118e-01f, 2.31340289e-01f, 7.85106793e-02f, 8.90831500e-02f,
  2.34607071e-01f, -1.54526189e-01f, 6.41385019e-02f, 1.02714248e-01f, 3.17597270e-01f, 3.31237644e-01f, 3.18996787e-01f, 3.69768858e-01f, -1.89477384e-01f, 1.40176013e-01f,
  -7.35632423e-03f, 8.70216861e-02f, -1.72713593e-01f, 1.39849424e-01f, -7.41301253e-02f, 1.09245569e-01f, 2.02806652e-01f, 3.98991197e-01f, 8.30093622e-02f, -6.42379895e-02f,
  4.09445643e-01f, -1.82890892e-01f, 3.33682030e-01f, 1.23239784e-02f, 2.06533998e-01f, 1.16116973e-02f, 4.17862773e-01f, 1.13790877e-01f, 4.89085652e-02f, 2.52138436e-01f,
  5.13078928e-01f, 3.00887525e-01f, -2.23923430e-01f, -1.29279524e-01f, 1.10673837e-01f, 6.24914706e-01f, 3.68619621e-01f, -1.15591839e-01f, 2.65414268e-01f, -1.33545935e-01f,
  1.98162962e-02f, 3.05107147e-01f, 1.82879586e-02f, 2.33546108e-01f, 3.23554307e-01f, -5.37006199e-01f, 4.52488624e-02f, -5.84457517e-01f, -2.90734977e-01f, 3.11711311e-01f,
  -2.81432748e-01f, 8.55608359e-02f, -4.12107617e-01f, -3.22717965e-01f, 3.34568769e-01f, 1.78646058e-01f, -1.13135763e-02f, -2.56258935e-01f, 2.86517352e-01f, -4.47306829e-03f,
  6.97965249e-02f, -8.42487141e-02f, -9.53055471e-02f, 3.68383318e-01f, -8.80408213e-02f, 4.66236204e-01f, 3.06405667e-02f, -2.28971820e-02f, 3.16411138e-01f, -6.41158819e-02f,
  -2.88562085e-02f, 1.52146757e-01f, 1.37143955e-01f, 1.01101823e-01f, 3.94095838e-01f, -2.09285781e-01f, 1.98019911e-02f, 2.44661599e-01f, 3.20218116e-01f, 1.66215226e-01f,
  -1.55910432e-01f, 1.96086287e-01f, 4.51471120e-01f, 4.92218047e-01f, 7.61552900e-02f, 3.15845639e-01f, 3.01067717e-03f, 4.29268986e-01f, -2.37515196e-01f, 9.27823484e-02f,
  -7.39945993e-02f, -2.66208686e-02f, 8.88154805e-02f, 1.61327243e-01f, -2.07502559e-01f, -1.21044092e-01f, -2.26353258e-01f, -2.21318439e-01f, 1.07126921e-01f, -1.20884679e-01f,
  -1.30086169e-01f, 1.79777384e-01f, 1.73840523e-02f, 3.78939569e-01f, 2.84589995e-02f, -2.32548282e-01f, -2.67124325e-01f, 2.27845326e-01f, -1.78041771e-01f, 4.30291802e-01f,
  1.67404890e-01f, 1.01285212e-01f, 4.37100977e-01f, -5.48199266e-02f, -5.44099398e-02f, -1.87482193e-01f, 1.82370678e-01f, 1.50912896e-01f, -1.36554152e-01f, -1.95560917e-01f,
  1.09793479e-02f, -5.21505848e-02f, 3.08184661e-02f, 2.12400496e-01f, -1.84664384e-01f, 3.39681894e-01f, -3.92655755e-04f, 2.91111290e-01f, -4.94504943e-02f, 6.49717450e-02f,
  3.25025856e-01f, 3.03894877e-02f, -6.37030974e-02f, -1.40535966e-01f, -1.52554542e-01f, 1.51987150e-01f, -9.67912450e-02f, 1.13853551e-02f, -2.74689764e-01f, 2.83477139e-02f,
  7.21213222e-02f, 8.77197534e-02f, -1.48274392e-01f, 1.11182094e-01f, 4.38053936e-01f, -1.48486406e-01f, 2.72769421e-01f, 6.29566848e-01f, 3.47872019e-01f, 2.68546522e-01f,
  -7.56175935e-01f, -6.97504878e-02f, 2.86762297e-01f, 1.33881807e-01f, -3.06458592e-01f, 3.71269673e-01f, 2.04281017e-01f, 4.46273595e-01f, -3.51163357e-01f, -8.62200037e-02f,
  1.75978732e-03f, 1.25148654e-01f, 1.35135904e-01f, 3.31691384e-01f, 2.29123130e-01f, 7.94353858e-02f, 3.76574606e-01f, -8.55588242e-02f, 2.79476732e-01f, 5.50120890e-01f,
  -3.11615705e-01f, -6.93113506e-02f, 7.53375068e-02f, -1.73666340e-03f, -4.32382524e-02f, -3.31673503e-01f, 1.15419693e-01f, -2.10778221e-01f, -2.48714522e-01f, -6.68746084e-02f,
  1.90099120e-01f, -4.81879488e-02f, 1.55672491e-01f, -6.99835122e-02f, -7.52127394e-02f, 3.56928051e-01f, -2.58182436e-01f, 1.78130463e-01f, 4.08428520e-01f, 1.23201907e-01f,
  4.64906007e-01f, 1.99221030e-01f, -1.28391355e-01f, 6.41056359e-01f, 2.57670563e-02f, 2.93213367e-01f, 1.13412932e-01f, -8.90972689e-02f, -9.97672677e-02f, 9.36192423e-02f,
  4.78288308e-02f, 9.33872163e-02f, 7.06435516e-02f, -3.22542116e-02f, 1.88676298e-01f, -2.39828333e-01f, -3.74013335e-02f, -7.66297709e-03f, 1.53769329e-01f, -3.34739238e-02f,
  3.49420011e-01f, 5.21088019e-02f, 1.36588112e-01f, 5.36507547e-01f, 1.34139895e-01f, 3.29569370e-01f, -2.39725649e-01f, 4.33464676e-01f, -1.62988365e-01f, 1.02822527e-01f,
  5.04706621e-01f, -2.35779956e-01f, -2.78127462e-01f, 7.29879662e-02f, 2.96104383e-02f, -1.77259609e-01f, -1.30784318e-01f, -2.35997707e-01f, -1.87508501e-02f, 1.26417950e-01f,
  7.74028301e-02f, 1.58616856e-01f, 7.11407736e-02f, 3.59590113e-01f, -1.74475849e-01f, 4.53907885e-02f, -2.90033132e-01f, -2.16306746e-01f, -2.72885889e-01f, 3.44311506e-01f,
  -2.58686751e-01f, 2.66611487e-01f, -2.48831540e-01f, -2.73519784e-01f, 4.10872340e-01f, 2.27919836e-02f, -1.78250656e-01f, -6.09587394e-02f, 2.74437070e-01f, 1.32673755e-01f,
  4.46736723e-01f, 3.39769542e-01f, 1.10319853e-01f, -1.40161440e-02f, 4.55751240e-01f, -6.15512580e-02f, 6.11238144e-02f, 1.24110840e-01f, -2.18746305e-01f, 7.89837778e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.92220592e-01f, -6.25013635e-02f, 2.45491743e-01f, 2.43244782e-01f, 4.64638174e-02f, 2.35972464e-01f, 1.37462830e-02f, 1.64140925e-01f, 2.30297923e-01f, 1.31917536e-01f,
  2.49825269e-01f, 3.24405357e-02f, 3.32102805e-01f, 3.11151624e-01f, 1.28554642e-01f, -4.28562090e-02f, 2.46149436e-01f, 1.15047671e-01f, 2.94330508e-01f, 8.29852372e-02f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.59007818e-01f, 2.41443783e-01f, 3.67728114e-01f, -5.91211200e-01f, 2.31630906e-01f, -1.48736900e-02f, -1.56571284e-01f, -3.81726205e-01f, 2.34302118e-01f, -2.02614322e-01f,
  -1.86282963e-01f, 1.99915439e-01f, -3.29057127e-01f, -6.65566102e-02f, 1.43335298e-01f, -2.79293414e-02f, -1.07783675e-01f, 1.40495539e-01f, -2.86254678e-02f, -2.72185728e-02f,
  -1.20083712e-01f, 1.32523224e-01f, -1.30279213e-01f, 1.16861254e-01f, 5.88190779e-02f, 4.76403581e-03f, 1.33407921e-01f, -1.21014796e-01f, 2.21865878e-01f, -1.11197248e-01f,
  3.33150476e-02f, -3.06001361e-02f, -3.39343287e-02f, 1.96266189e-01f, -2.03122750e-01f, -1.04768902e-01f, -8.73446241e-02f, 1.76726222e-01f, -5.67150153e-02f, 6.47651181e-02f,
  2.67234355e-01f, 2.40115583e-01f, 1.17567226e-01f, 1.25277936e-01f, -7.59685710e-02f, 2.74169058e-01f, 5.75638302e-02f, 1.12325117e-01f, -1.02511741e-01f, 1.66037306e-02f,
  1.42512709e-01f, -1.72918737e-01f, -2.53655553e-01f, 3.34650166e-02f, -1.15119033e-01f, 2.89895356e-01f, -8.92822444e-02f, 1.17323380e-02f, 2.04831898e-01f, -1.52719885e-01f,
  1.82457477e-01f, -2.13830978e-01f, 2.20853716e-01f, -1.51688680e-01f, -3.72434556e-02f, 3.83532085e-02f, 1.98852375e-01f, 5.58680534e-01f, -3.16615030e-02f, 6.43977448e-02f,
  -1.49010584e-01f, -1.39754936e-01f, 6.27185851e-02f, -1.69915125e-01f, 2.32662916e-01f, 3.97220440e-02f, 4.14148301e-01f, -1.54281735e-01f, 1.86061174e-01f, -1.57658830e-01f,
  -1.37746617e-01f, -3.41950543e-02f, -2.15882078e-01f, -1.61604226e-01f, -2.08422560e-02f, -2.04822108e-01f, 9.14343446e-02f, -2.87812650e-01f, 1.08549535e-01f, 1.42408699e-01f,
  4.38671261e-02f, -5.03087975e-03f, 1.04057707e-01f, 1.10305473e-01f, 3.63867059e-02f, 7.64643103e-02f, -4.10117805e-01f, 1.97614301e-02f, 3.66946131e-01f, -3.48668218e-01f,
  2.74278581e-01f, -1.62390336e-01f, -4.03206170e-01f, -3.00946832e-01f, 4.55816276e-02f, -2.58325964e-01f, -1.42361268e-01f, 2.02794578e-02f, -3.57296504e-02f, -2.45458275e-01f,
  1.94550246e-01f, -2.00537473e-01f, 2.06385523e-01f, -2.11130828e-02f, 8.07967484e-02f, -6.29392713e-02f, 2.59632133e-02f, -1.99927717e-01f, -1.35555610e-01f, 1.46373183e-01f,
  -1.28183380e-01f, -6.13939650e-02f, 1.73714712e-01f, -8.34078491e-02f, 1.25946328e-01f, 1.52720109e-01f, 8.80401880e-02f, 2.93311514e-02f, 1.97180986e-01f, 3.74148667e-01f,
  9.53429565e-02f, -8.40935484e-03f, 1.19564250e-01f, 1.22955911e-01f, 3.77863377e-01f, 1.73236266e-01f, 3.44407298e-02f, -5.31206466e-02f, 8.45808759e-02f, 3.22901189e-01f,
  4.57563326e-02f, -1.62670061e-01f, -6.80113072e-03f, 1.41076028e-01f, 3.63008052e-01f, -1.03564285e-01f, -1.16736643e-01f, -8.52456838e-02f, 1.05088383e-01f, -3.55760045e-02f,
  4.24920246e-02f, 1.05781313e-02f, -1.58616096e-01f, 3.68006527e-01f, -4.05004472e-02f, -1.63897917e-01f, -3.22371960e-01f, -1.06528647e-01f, 1.10363536e-01f, -7.75086582e-02f,
  3.09167564e-01f, -1.23231851e-01f, -1.49460807e-01f, 2.46404558e-01f, -4.41979393e-02f, -4.01841134e-01f, 5.16154826e-01f, -4.44208458e-02f, 2.47424155e-01f, -2.29775663e-02f,
  3.64742786e-01f, 8.19211677e-02f, 5.63243851e-02f, -1.80678591e-02f, -6.73543885e-02f, -2.62619913e-01f, -4.53628898e-02f, -1.57805845e-01f, -1.24600992e-01f, -3.99956480e-02f,
  1.07702322e-01f, 9.41084474e-02f, 1.83435187e-01f, 2.54445765e-02f, 9.75551605e-02f, -1.06843196e-01f, -2.63802558e-01f, 2.16243148e-01f, -1.19737461e-01f, -1.55494511e-01f,
  -7.70844743e-02f, 2.39293516e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.69994131e-01f, -5.04965067e-01f, -4.17820588e-02f, 1.98956177e-01f, 3.14256936e-01f, 1.98850688e-02f, 4.08315957e-01f, 2.95684665e-01f, 2.64829516e-01f, 7.91127607e-02f,
  -7.09282085e-02f, -2.15413749e-01f, 4.86085862e-01f, 3.59568238e-01f, 1.49097487e-01f, -1.63920477e-01f, 1.54622599e-01f, -4.48443830e-01f, 2.59949088e-01f, 5.73182963e-02f,
  1.03060633e-01f, 3.11955214e-01f, 1.17537901e-01f, -1.39596879e-01f, 2.06801891e-01f, 1.93284974e-01f, 2.46017287e-03f, 2.89262891e-01f, 3.52267623e-01f, -3.65754962e-02f,
  -3.82438600e-01f, -4.68536049e-01f, -6.33068234e-02f, -4.64532673e-02f, -5.08096740e-02f, 7.46937171e-02f, -1.27245918e-01f, -9.23332125e-02f, -2.94036686e-01f, -2.45691493e-01f,
  -2.15349317e-01f, -6.91395346e-03f, -5.27009964e-01f, -5.36778986e-01f, 2.76363224e-01f, 5.79677284e-01f, 2.33201146e-01f, 9.67191905e-02f, -7.70818770e-01f, 3.00556779e-01f,
  4.47165221e-01f, -3.08410943e-01f, 2.99633324e-01f, -1.45683497e-01f, 3.47715527e-01f, -5.92644624e-02f, 2.44404316e-01f, -4.46880370e-01f, -1.28849745e-01f, 3.74005526e-01f,
  4.83054727e-01f, -4.61074291e-03f, -2.57489145e-01f, 1.56439275e-01f, -6.13841534e-01f, -4.08209383e-01f, -3.49298656e-01f, -9.00632977e-01f, -2.83092856e-01f, -1.46233976e-01f,
  -5.73191345e-01f, 1.39730141e-01f, -4.22343701e-01f, -1.94939911e-01f, -1.95644811e-01f, -1.48814484e-01f, -5.36891878e-01f, 6.16053678e-02f, 9.08877850e-02f, 2.93436468e-01f,
  -3.58831018e-01f, 9.39593315e-02f, 3.05852145e-01f, -3.60879034e-01f, 1.48036852e-02f, -3.28221023e-02f, -1.68580636e-01f, 3.83852601e-01f, 1.29861832e-01f, 9.70946178e-02f,
  4.61665913e-02f, 9.87245589e-02f, 1.75538957e-01f, 2.13967031e-03f, 1.28617391e-01f, 4.87537533e-02f, -1.36021239e-40f, -5.46512006e-40f, 4.97608091e-40f, 5.01952116e-40f,
  -2.90735380e-39f, 4.97204517e-40f, 3.73224636e-40f, -4.94897980e-40f, 1.36671599e-37f, -4.72812944e-37f, -4.93901657e-40f, 3.39191300e-40f, 4.93967518e-40f, 8.67467345e-25f,
  1.68154414e-40f, -1.66243064e-09f, 5.00428905e-40f, -4.59549176e-10f, -4.94088029e-40f, -8.32070375e-16f, 1.39001695e-28f, -2.18683561e-11f, -4.28653234e-13f, -1.94074637e-05f,
  -4.38281318e-40f, 4.94490202e-40f, -5.04673438e-40f, -2.96697261e-15f, -8.72835688e-15f, 4.13109934e-39f, -1.17384555e-08f, -7.97532474e-18f, -1.08922245e-02f, -5.01624167e-01f,
  -3.60785007e-01f, -3.87160182e-01f, -2.82623321e-01f, -2.54209220e-01f, -2.39680901e-01f, -4.94666517e-01f, -5.70504665e-01f, 3.50915790e-01f, 1.12328373e-01f, -3.11501622e-01f,
  -4.60783303e-01f, 1.89830542e-01f, -8.73529613e-02f, 3.26938182e-01f, -5.11586487e-01f, 2.82438576e-01f, 3.58286917e-01f, 1.40460342e-01f, 1.88916475e-01f, 6.71480447e-02f,
  1.21000923e-01f, 1.15277022e-01f, 1.88517258e-01f, -9.29713845e-02f, -1.44143909e-01f, 2.29903474e-01f, 2.03155100e-01f, 2.23719284e-01f, -1.72239915e-01f, 1.36401162e-01f,
  2.47636959e-01f, 1.51884094e-01f, 3.54770333e-01f, 1.11628756e-01f, 1.14658676e-01f, -7.42714778e-02f, -7.52898529e-02f, -2.66316593e-01f, 1.58083588e-01f, -6.16391599e-01f,
  3.31357121e-02f, 4.15012054e-02f, -4.73003946e-02f, -3.82282674e-01f, 1.11589611e-01f, 1.77452654e-01f, 3.40677440e-01f, 2.08212182e-01f, -3.92950714e-01f, 2.02389628e-01f,
  1.24090806e-01f, 2.59570461e-02f, 4.00817603e-01f, 3.61476958e-01f, 1.97900087e-01f, 4.67685550e-01f, 2.02885419e-01f, -2.84428209e-01f, -3.76296788e-01f, 3.57534528e-01f,
  1.44759625e-01f, 3.20231497e-01f, 6.53293073e-01f, 7.46095657e-01f, 3.47291231e-02f, 4.28539872e-01f, 2.65485734e-01f, 2.45200008e-01f, 2.38201872e-01f, 4.81927276e-01f,
  -5.01111865e-01f, -5.37376963e-02f, -6.63820207e-01f, -2.70855278e-01f, 5.28521299e-01f, 4.57279757e-02f, 2.43822917e-01f, 4.04491983e-02f, 3.55475694e-01f, 8.79698470e-02f,
  -9.16041061e-02f, -2.73789316e-02f, -2.62426198e-01f, 2.19650686e-01f, 4.61226106e-01f, -1.37593850e-01f, 4.05829437e-02f, 4.70821410e-01f, -1.40539765e-01f, -7.15164393e-02f,
  8.58352482e-02f, 3.84398431e-01f, 1.60134315e-01f, -1.96240410e-01f, 1.05462551e-01f, -4.84102778e-03f, 4.27758545e-01f, -1.20392283e-02f, 7.54392669e-02f, 1.42417438e-02f,
  -4.72586304e-01f, -4.05145735e-01f, -2.74458557e-01f, 1.76880792e-01f, 3.38460505e-01f, -2.65226394e-01f, -1.72505692e-01f, -6.26362041e-02f, -1.13349579e-01f, 2.02203125e-01f,
  3.76803756e-01f, -5.68703283e-03f, 4.83459756e-02f, 1.17093557e-02f, 6.16463840e-01f, -1.92394242e-01f, -1.99697822e-01f, 2.36169204e-01f, 5.46439052e-01f, -3.20715874e-01f,
  -1.27268672e-01f, 6.69530109e-02f, -1.55896679e-01f, -6.90022111e-02f, -3.50771770e-02f, 6.92981899e-01f, -6.51493669e-01f, -3.95817816e-01f, -1.47920877e-01f, -3.63785207e-01f,
  2.04550654e-01f, -3.22487988e-02f, -5.47420196e-02f, 3.79984796e-01f, 2.88708866e-01f, -1.34131283e-01f, -6.68385923e-02f, 3.60770196e-01f, -1.45198852e-01f, 1.69162914e-01f,
  1.46087855e-01f, 6.63904548e-02f, 1.94899857e-01f, 1.01249870e-02f, 4.08634037e-01f, -1.90037936e-01f, 2.29854628e-01f, -1.40346766e-01f, -9.24558863e-02f, 3.98618430e-01f,
  1.57245427e-01f, -9.23095122e-02f, 3.06414157e-01f, 1.00787431e-01f, -1.10235140e-01f, -1.40246749e-01f, 2.09614545e-01f, -1.07493557e-01f, 2.47198686e-01f, 4.16731417e-01f,
  7.01906145e-01f, 2.41480693e-01f, 1.47401080e-01f, 2.28788778e-01f, 1.84401020e-01f, -7.43869552e-03f, 5.85085392e-01f, -5.14288485e-01f, -3.66823614e-01f, 8.55315506e-01f,
  1.79053675e-02f, -9.99590289e-03f, 3.14909935e-01f, -2.87385285e-01f, 8.48064840e-01f, 2.13251069e-01f, 2.61184186e-01f, -4.80166078e-01f, -1.83445677e-01f, -3.24241728e-01f,
  1.79219291e-01f, 1.41929626e-01f, 1.47592500e-01f, -1.64513797e-01f, 5.48908353e-01f, -1.61630958e-01f, 6.15369715e-02f, -1.24090370e-02f, 2.94184461e-02f, 3.34203765e-02f,
  -4.26028460e-01f, -7.28888929e-01f, -5.41371584e-01f, -4.15947229e-01f, -6.04341254e-02f, 1.68844476e-01f, 2.51836836e-01f, 1.31373525e-01f, 4.05170284e-02f, 4.97829109e-01f,
  5.53342223e-01f, 1.76568016e-01f, -3.78322303e-01f, -6.52704341e-03f, -9.66365263e-02f, 1.31087899e-01f, 4.69357044e-01f, 1.58729210e-01f, 3.08702767e-01f, 2.56036073e-01f,
  1.63445503e-01f, -2.70402688e-03f, -2.32054777e-02f, 9.99472216e-02f, 2.06673980e-01f, -1.87451333e-01f, 1.37459323e-01f, 1.29320830e-01f, -1.27602182e-02f, 2.98297442e-02f,
  1.54964745e-01f, -4.83502541e-03f, 2.61562973e-01f, 2.04799790e-03f, -2.62736287e-02f, -2.13634968e-01f, 2.43260083e-03f, -2.60502845e-01f, -2.88077623e-01f, -3.71534675e-01f,
  -7.82450259e-01f, -5.20786762e-01f, -4.58909810e-01f, -4.67670336e-02f, -2.35521659e-01f, -1.61392465e-01f, 6.88204691e-02f, 4.62049544e-01f, -1.96334958e-01f, -6.64720964e-03f,
  -1.43575191e-01f, -1.05618499e-01f, 3.58682334e-01f, 1.47015482e-01f, 2.83277005e-01f, 2.94202983e-01f, 3.33869606e-01f, 3.92678648e-01f, -4.41265404e-01f, -4.64087799e-02f,
  -3.68746310e-01f, 6.05433702e-01f, 9.14197862e-02f, 3.03514600e-01f, -3.37976605e-01f, -1.90248773e-01f, -1.49748236e-01f, -4.34782207e-02f, -5.57067692e-02f, -1.37229636e-01f,
  1.83834974e-03f, 3.56237441e-01f, 3.90516728e-01f, -3.02312702e-01f, -2.59323746e-01f, -4.69689071e-01f, -1.19831204e-01f, 1.79988593e-01f, -4.28839438e-02f, 2.04242364e-01f,
  -1.14796348e-01f, -6.62910715e-02f, -2.18994364e-01f, 2.95342743e-01f, -2.92667031e-01f, 1.53358221e-01f, -3.69468816e-02f, 2.25130126e-01f, -3.21080983e-01f, -2.88799942e-01f,
  7.19875917e-02f, -8.03130642e-02f, 2.61719227e-01f, -2.96885878e-01f, 2.45947931e-02f, -2.94832475e-02f, -3.23850632e-01f, -5.05312562e-01f, -2.88818270e-01f, -6.89379275e-01f,
  -2.54636258e-01f, -8.43902677e-02f, 4.17722873e-02f, 1.00227907e-01f, 2.08461061e-01f, 3.06809425e-01f, 3.33248377e-01f, -3.13441396e-01f, 1.22239113e-01f, 1.35195211e-01f,
  2.08382785e-01f, -1.65977702e-01f, -3.30120355e-01f, 2.89488077e-01f, 2.37087771e-01f, -3.08274142e-02f, 5.04397899e-02f, -3.90262902e-02f, -2.35352553e-02f, 9.01808664e-02f,
  5.34070991e-02f, -1.23476394e-01f, -1.32481987e-03f, 1.42060310e-01f, 7.16253698e-01f, -3.94873135e-03f, 2.47278541e-01f, -7.95466900e-02f, 5.00433408e-02f, 2.03126594e-01f,
  -5.16166389e-01f, 5.52097082e-01f, -4.23911184e-01f, 1.76012143e-01f, 9.75133777e-01f, 6.96164742e-02f, 1.75578400e-01f, 4.36429232e-01f, -6.29115462e-01f, 1.48230642e-01f,
  3.57809722e-01f, -1.00327477e-01f, -3.75369675e-02f, 1.85444430e-02f, 2.18012426e-02f, 3.81093860e-01f, 3.89247179e-01f, 4.87547189e-01f, 2.86898706e-02f, -1.48854434e-01f,
  6.14970744e-01f, 1.00774132e-01f, 1.94658414e-01f, -4.10294741e-01f, 3.13277692e-01f, 7.92368278e-02f, -1.16438925e-01f, 1.40410602e-01f, 2.15356037e-01f, -3.45863342e-01f,
  -2.04825420e-02f, -2.52213746e-01f, -2.28230760e-01f, 1.11748241e-01f, 8.27559531e-02f, 5.68691492e-01f, -3.60060960e-01f, 3.63248110e-01f, -8.58759787e-03f, 3.03137898e-01f,
  5.58636606e-01f, 4.88621175e-01f, -3.64188910e-01f, 1.06643336e-02f, -2.94188168e-02f, 2.97045231e-01f, 7.05844581e-01f, -7.72726983e-02f, 3.84734035e-01f, -3.14947218e-01f,
  1.46015197e-01f, 3.90768647e-01f, -1.04023941e-01f, 4.40964520e-01f, 3.43469270e-02f, 2.46557131e-01f, 4.91557062e-01f, 3.21898431e-01f, -1.22817017e-01f, -2.67936617e-01f,
  5.92943370e-01f, -2.02098846e-01f, 1.00211717e-01f, 5.97487330e-01f, 6.01458311e-01f, 2.41600335e-01f, 1.07717603e-01f, -1.23227596e-01f, 2.54912794e-01f, 7.16647655e-02f,
  3.39385062e-01f, -7.51208961e-02f, -5.18845737e-01f, -5.46597958e-01f, 6.63663566e-01f, 2.56315976e-01f, 5.05272746e-01f, -4.02259231e-01f, -6.48215115e-01f, 7.35076740e-02f,
  3.20692174e-02f, 9.33725312e-02f, 5.59922121e-02f, 1.52878046e-01f, 3.41400087e-01f, -1.51299819e-01f, 5.28975651e-02f, 7.51562342e-02f, -1.40348822e-01f, 1.31025061e-01f,
  6.69828594e-01f, 4.74793762e-01f, 2.66358405e-02f, -5.08274660e-02f, -1.26483664e-03f, -8.31284672e-02f, 7.53852054e-02f, -1.94057524e-02f, 3.15927982e-01f, 2.68308163e-01f,
  -4.64051276e-01f, 4.89349097e-01f, -7.32593060e-01f, -8.89970839e-01f, 5.68912663e-02f, -4.17169958e-01f, 4.02015030e-01f, -2.04906806e-01f, 2.34695241e-01f, 3.30393493e-01f,
  -5.12960792e-01f, -1.19195074e-01f, 5.99856824e-02f, -5.36462188e-01f, 5.77457070e-01f, 2.27043167e-01f, 2.49188635e-02f, 3.91349150e-03f, 1.90980300e-01f, 8.13286722e-01f,
  -2.80339479e-01f, 2.59276368e-02f, -2.03675479e-02f, 2.57280350e-01f, -1.55246451e-01f, 3.18695068e-01f, 1.45851701e-01f, 4.57132339e-01f, 3.81278336e-01f, -3.06451440e-01f,
  1.42961675e-02f, 1.05969846e-01f, -9.15402353e-01f, -1.79253936e-01f, 3.11235994e-01f, 3.15821841e-02f, -3.07059616e-01f, -2.63320774e-01f, 3.10418047e-02f, 1.98605031e-01f,
  4.63262767e-01f, -1.07690632e-01f, -3.38916510e-01f, 5.61825216e-01f, 1.10810041e-01f, -1.54993176e-01f, -1.90137357e-01f, -1.10391140e-01f, -2.46732756e-01f, 1.00014001e-01f,
  -2.48428341e-02f, -5.27640224e-01f, 2.87459314e-01f, -2.27095962e-01f, 4.56743509e-01f, 1.11027502e-01f, 4.95426565e-01f, 3.52187842e-01f, 7.06157744e-01f, 5.57720959e-01f,
  8.43170524e-01f, 7.00327337e-01f, 4.01041895e-01f, 6.51074052e-02f, -2.09670499e-01f, -3.95746827e-01f, 2.98708916e-01f, 4.13189948e-01f, 4.56989467e-01f, 4.96839248e-02f,
  1.45020500e-01f, 1.61353573e-01f, 1.45192891e-01f, 1.50480680e-02f, 5.92267394e-01f, -1.75732881e-01f, -3.14143598e-01f, 4.61499363e-01f, 7.72632957e-02f, 2.56639540e-01f,
  -2.82382779e-02f, 1.48541883e-01f, -1.12391748e-02f, -6.53238967e-02f, -8.70515183e-02f, 2.18026042e-01f, 2.59204209e-01f, 2.28947535e-01f, 1.88980147e-01f, 2.57750839e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  9.16692019e-02f, 2.42843270e-01f, -6.36170432e-02f, -7.86682411e-37f, -2.25526094e-01f, 2.71921724e-01f, 3.15251827e-01f, -2.81112660e-02f, 4.77449968e-02f, 5.13717011e-02f,
  -4.14137319e-02f, 1.63884863e-01f, 3.48373383e-01f, 5.17816022e-02f, -4.16129595e-03f, 1.74205482e-01f, 3.04052770e-01f, 3.72512430e-01f, -1.75391100e-02f, 1.12432756e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.46569261e-01f, -7.72458836e-02f, -2.71868527e-01f, 2.51666039e-01f, 5.93997799e-02f, 2.68821836e-01f, -5.16828179e-01f, 5.43160457e-03f, -1.98530018e-01f, -1.75767615e-01f,
  6.81623444e-02f, 2.06145436e-01f, -7.02967405e-01f, -4.32970852e-01f, 2.96739846e-01f, -3.13795645e-05f, -5.32220453e-02f, 1.96018174e-01f, -5.73024273e-01f, -2.34610856e-01f,
  2.73137003e-01f, 1.95203960e-01f, 2.82209754e-01f, -1.54214039e-01f, -3.93106975e-02f, 3.94966036e-01f, -1.02915987e-02f, 1.17164880e-01f, -1.62122130e-01f, -5.37416160e-01f,
  1.52308404e-01f, -5.01402497e-01f, 3.68071012e-02f, 3.03994864e-01f, -3.60591143e-01f, 3.74586582e-02f, -1.56268731e-01f, -4.66995269e-01f, 3.17886531e-01f, 4.10332590e-01f,
  -8.33839297e-01f, 3.48815769e-02f, -4.37211365e-01f, -2.48327851e-01f, -2.33576910e-04f, 1.18052952e-01f, 4.00444776e-01f, 7.76374713e-04f, 3.83837789e-01f, -1.78581893e-01f,
  -1.73838437e-01f, 7.03816041e-02f, -2.86753606e-02f, -7.99505055e-01f, 2.97627114e-02f, 3.12551826e-01f, -1.98386967e-01f, 6.86649326e-03f, -2.71939844e-01f, 3.20189372e-02f,
  -3.02566558e-01f, 2.14206427e-02f, 4.12590355e-02f, -3.58095080e-01f, 4.52989280e-01f, 3.88316453e-01f, -4.41015773e-02f, 4.39512879e-01f, 8.18182454e-02f, 4.60525714e-02f,
  4.29597050e-02f, 5.65679073e-01f, 1.65643677e-01f, -1.81107208e-01f, 4.76039261e-01f, -3.39390993e-01f, -2.67109990e-01f, 1.22954689e-01f, 1.51287898e-01f, -5.98957149e-06f,
  -3.23198974e-01f, 2.91135639e-01f, 2.34086946e-01f, -7.14191020e-01f, 2.55108088e-01f, 3.81046265e-01f, -3.14960271e-01f, 1.86171860e-01f, 3.50006700e-01f, -5.15207410e-01f,
  4.91267800e-01f, -1.01923846e-01f, 5.57628162e-02f, 9.62332636e-02f, -3.14060628e-01f, -1.18813288e+00f, -3.43631953e-02f, -2.61242837e-01f, 2.81481385e-01f, -3.77838910e-01f,
  -1.50302261e-01f, -2.09732667e-01f, 4.22108203e-01f, 2.41166681e-01f, -5.28055489e-01f, 2.73610085e-01f, 7.81574547e-01f, -1.84553742e-01f, -3.21264476e-01f, -9.24766779e-01f,
  -2.31080234e-01f, -4.95927934e-40f, -5.35554707e-01f, 1.46888524e-01f, 4.77225408e-02f, -4.04187143e-02f, 1.04921207e-01f, 3.83318216e-01f, 4.69553545e-02f, 2.28831172e-02f,
  -7.78288841e-01f, -4.79191452e-01f, 1.36805356e-01f, 2.33220562e-01f, -3.17008972e-01f, -3.94341558e-01f, 6.48177713e-02f, 2.74400204e-01f, -2.09117815e-01f, -4.24221069e-01f,
  1.66996807e-01f, -6.32679105e-01f, 4.78511602e-02f, -3.78903866e-01f, 5.23708999e-01f, -5.27805746e-01f, 7.37003744e-01f, 3.46149415e-01f, -6.20486856e-01f, 7.97223821e-02f,
  -3.53162944e-01f, -1.32378608e-01f, -1.58879831e-01f, 7.49954430e-04f, -1.41782522e-01f, -8.84341076e-03f, 7.51372278e-02f, -4.23497349e-01f, -7.15733543e-02f, -6.25786483e-02f,
  -1.91349730e-01f, -2.00308651e-01f, -2.21125007e-01f, 9.72768068e-02f, 2.45327294e-01f, 1.50973678e-01f, 2.43712336e-01f, -7.35253334e-01f, 2.68247932e-01f, 2.31189594e-01f,
  -6.93335831e-02f, 4.51379791e-02f, 1.97321996e-01f, -1.71338059e-02f, -1.12548254e-01f, 1.63629532e-01f, 2.83597082e-01f, -1.27517655e-01f, 8.10492635e-01f, 3.91977400e-01f,
  2.84354817e-02f, -2.99430728e-01f, -2.88120210e-01f, 2.45355353e-01f, -9.83184353e-02f, -8.81806095e-09f, -5.92925288e-02f, 1.99673101e-01f, -1.88692406e-01f, 2.62206942e-01f,
  -1.80352688e-01f, 5.60854282e-03f, -4.46018636e-01f, 1.72973976e-01f, 1.30534559e-01f, -2.28346020e-01f, -4.64675844e-01f, -5.26656628e-01f, 1.78636983e-01f, 3.08386292e-02f,
  2.86126584e-01f, 1.48790732e-01f, -4.76646394e-01f, -3.23102832e-01f, 1.29695218e-02f, -5.67309521e-02f, -1.34177804e-01f, 4.84281592e-03f, 6.28569946e-02f, -4.02706802e-01f,
  -1.65608078e-01f, -2.45333523e-01f, -4.72833693e-01f, 6.86915994e-01f, 1.71248734e-01f, 1.35458693e-01f, -3.88640821e-01f, 1.01761612e-08f, -1.97210819e-01f, -2.04157636e-01f,
  1.54882222e-01f, -2.61854619e-01f, -4.45691973e-01f, -1.02175128e+00f, -4.53252912e-01f, -4.70665917e-02f, 1.77416876e-01f, -7.82519504e-02f, 1.09222688e-01f, -7.05222487e-01f,
  3.75410825e-01f, 1.16694681e-01f, -6.65759325e-01f, 6.07373565e-02f, 7.00456649e-03f, 3.39871719e-02f, 1.70559898e-01f, -1.32269999e-02f, -5.45794815e-02f, 1.03637548e-02f,
  -2.72495627e-01f, 4.01871979e-01f, -3.36192012e-01f, -8.49097818e-02f, -1.00461738e-02f, 2.45631039e-01f, 3.40787679e-01f, 8.15472379e-02f, -8.81385952e-02f, -2.81553704e-11f,
  5.42938821e-02f, -5.40077269e-01f, -4.69935119e-01f, 6.44132420e-02f, 2.58724868e-01f, -3.72578539e-02f, 3.44895124e-01f, -5.33219695e-01f, -3.01877521e-02f, 1.61302820e-01f,
  8.75958055e-02f, 2.23791778e-01f, -1.10590033e-01f, -4.77310628e-01f, -4.31482583e-01f, 9.14686173e-03f, 9.85097662e-02f, 1.82697430e-01f, 4.45623785e-01f, 1.02529451e-02f,
  2.56517380e-01f, -1.55355439e-01f, -4.91741091e-01f, -2.11240262e-01f, -8.76648054e-02f, -6.07034341e-02f, 5.79453051e-01f, 5.44698656e-01f, -2.10971981e-01f, -1.15393914e-01f,
  -5.45194782e-02f, 9.53302785e-39f, 1.60819087e-02f, -4.27217260e-02f, -5.39886177e-01f, 5.35679817e-01f, 6.44350126e-02f, -4.58402663e-01f, 5.49786389e-02f, 1.95663229e-01f,
  -2.73555815e-01f, -8.57592165e-01f, -5.38504541e-01f, 2.71017015e-01f, -7.14186966e-01f, 4.85928625e-01f, -7.03570485e-01f, 1.20825298e-01f, 3.30902636e-01f, 3.39504689e-01f,
  1.03292316e-02f, 1.13391213e-01f, -1.74610078e-01f, 5.85583039e-02f, -3.06210905e-01f, 6.48425817e-01f, 1.02030657e-01f, -1.69506446e-01f, -3.45761806e-01f, -5.03939092e-01f,
  3.21177170e-02f, 2.52642214e-01f, -3.45103711e-01f, -2.46554386e-32f, -2.20266670e-01f, -8.26301217e-01f, 3.32464784e-01f, -6.76486790e-01f, -3.20651650e-01f, 1.43625483e-01f,
  -2.09031299e-01f, -7.90513813e-01f, -1.22434571e-01f, 1.66407049e-01f, 6.20347150e-02f, -3.58229399e-01f, 1.53084666e-01f, -1.66613817e-01f, 3.40786576e-01f, -2.05205649e-01f,
  -1.02569297e-01f, -2.16523603e-01f, 7.87159503e-02f, 1.34282261e-01f, -7.21383169e-02f, 1.81558400e-01f, -3.03620398e-01f, -4.14767802e-01f, -1.40396789e-01f, -4.01695251e-01f,
  -1.49762928e-01f, -7.93300346e-02f, -5.15538335e-01f, -4.05584499e-02f, -6.21564984e-01f, -5.04651017e-40f, 2.66188323e-01f, 3.21713477e-01f, 6.93581253e-02f, 2.60887086e-01f,
  -6.03759289e-01f, -6.10431194e-01f, 4.31175590e-01f, 2.58603007e-01f, -7.64629126e-01f, -4.20454651e-01f, 4.59640771e-01f, -4.23235357e-01f, -2.20839962e-01f, -2.62130916e-01f,
  -3.90868783e-01f, -5.59540316e-02f, 3.75365436e-01f, 3.25375170e-01f, 1.35350168e-01f, 2.32927546e-01f, -1.11959480e-01f, 4.39610183e-01f, -3.57881129e-01f, -3.58691990e-01f,
  6.55551910e-01f, -4.05297965e-01f, 6.65716946e-01f, -7.53491148e-02f, 9.41755921e-02f, -4.48912293e-01f, -5.71471214e-01f, -2.00357787e-15f, -4.69703197e-01f, 3.41164380e-01f,
  3.84519339e-01f, -1.88727081e-01f, -4.10032600e-01f, -1.44729778e-01f, -3.65172744e-01f, 1.53766394e-01f, -3.70829940e-01f, -5.98715603e-01f, -7.72898853e-01f, 4.06745970e-02f,
  3.46441455e-02f, 3.67878467e-01f, -3.24624300e-01f, 2.71403998e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -4.05844152e-02f, -2.14725837e-01f, 3.62011865e-02f, -5.95651306e-02f, 3.18856612e-02f, -9.61699560e-02f, 4.47433926e-02f, -3.40658203e-02f, -1.31287845e-02f, 1.58898547e-01f,
  -1.86896399e-01f, 2.55244583e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    