/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.23193741e-01f, 2.23229885e-01f, 6.99555576e-02f, -1.23000890e-01f, -3.23216021e-02f, -1.98040545e-01f, -1.62955523e-01f, -2.15602756e-01f, -9.26098973e-02f, 1.20158270e-02f,
  7.74000445e-03f, 4.83192205e-02f, -6.70782328e-02f, 1.64559775e-03f, -7.68630803e-02f, 2.06979830e-02f, 1.80017263e-01f, -2.70913915e-05f, -2.57362038e-01f, -1.32820472e-01f,
  7.51136467e-02f, -2.06929352e-02f, -1.64998233e-01f, -4.96899411e-02f, 2.40439132e-01f, 1.70494914e-01f, 2.52319634e-01f, 2.18682885e-01f, 1.47895247e-01f, 5.51217020e-01f,
  2.75474936e-01f, -1.19622901e-01f, -1.36579379e-01f, -5.60817346e-02f, 1.07958943e-01f, 2.92515326e-02f, -1.98596772e-02f, 8.91559124e-02f, -6.53528888e-03f, 8.36730003e-02f,
  8.80976394e-03f, -2.29334645e-02f, 2.05560438e-02f, 9.89051834e-02f, -6.46895617e-02f, -8.01360533e-02f, 6.55038655e-02f, -5.19419871e-02f, -5.58742657e-02f, 9.56423208e-02f,
  1.49406612e-01f, 1.35578839e-02f, -7.09365308e-02f, -2.22116057e-02f, -4.37599234e-02f, -9.62265432e-02f, 4.05374123e-03f, -3.65932249e-02f, -1.12588726e-01f, 5.81055395e-02f,
  2.07943823e-02f, -6.21103570e-02f, 9.34123248e-03f, -2.19579991e-02f, -5.85639067e-02f, 8.07831157e-03f, 5.22661135e-02f, -3.60784605e-02f, -2.22594012e-02f, 6.83452561e-02f,
  -5.89391217e-02f, 1.58919804e-02f, -2.02315934e-02f, -5.46106026e-02f, 4.41727936e-02f, -2.78845499e-03f, 4.92598787e-02f, 1.63322035e-02f, 4.52970248e-03f, 4.58303206e-02f,
  -1.64525155e-02f, -7.62618631e-02f, 1.17862169e-02f, 2.24413481e-02f, 5.38441315e-02f, 2.79739946e-02f, 3.95582616e-03f, -2.29162276e-02f, -4.55690324e-02f, -2.89870296e-02f,
  -1.49014026e-01f, -1.14201456e-01f, -5.15957251e-02f, -7.66691938e-02f, 3.56416516e-02f, 5.39923608e-02f, 1.98591687e-02f, 4.49254662e-02f, -3.48326750e-03f, -8.80765244e-02f,
  -2.76644379e-02f, -6.82045445e-02f, -9.36016068e-03f, 4.78478484e-02f, -1.29356403e-02f, -7.36482069e-02f, 3.34357098e-02f, 3.60108986e-02f, -3.02896257e-02f, -5.03762811e-02f,
  3.59628312e-02f, -1.59614086e-01f, -2.05991939e-01f, -3.49394791e-03f, -1.31498873e-01f, -2.62080282e-01f, -2.28963103e-02f, -5.78053594e-02f, -2.73606122e-01f, -1.52304903e-01f,
  3.05611998e-01f, 2.79428720e-01f, 5.45146456e-03f, 5.70893958e-02f, 3.89672294e-02f, -1.21885985e-01f, -2.13988796e-01f, -1.65033668e-01f, -4.12478410e-02f, 4.01575677e-03f,
  2.07203418e-01f, 9.54386815e-02f, -4.00782824e-02f, -5.89183345e-02f, -1.59258515e-01f, -7.61202350e-02f, -1.52764767e-01f, -1.81396753e-01f, -2.80755222e-01f, -9.34686363e-02f,
  -3.80434133e-02f, 4.88166772e-02f, 2.50544772e-02f, -7.63614178e-02f, 2.45824099e-01f, -5.87855317e-02f, 1.24056213e-01f, 1.62739143e-01f, 7.70680159e-02f, 2.98393697e-01f,
  2.39563152e-01f, 4.57223505e-01f, -2.17599213e-01f, -2.42567365e-03f, 1.52206197e-01f, -1.55443582e-03f, -4.19040397e-03f, 5.80471568e-02f, 3.34797464e-02f, 3.95549014e-02f,
  1.23673722e-01f, 5.61874956e-02f, 6.07048534e-02f, 3.77301835e-02f, 1.13619827e-01f, -3.67780067e-02f, -7.44229034e-02f, -7.63344541e-02f, -9.12986398e-02f, -2.16813032e-02f,
  6.58466201e-03f, 1.18871376e-01f, -3.09951454e-02f, -5.59529588e-02f, -1.87254772e-02f, -2.40848586e-02f, 9.82951373e-02f, 6.55726017e-03f, -4.49837232e-03f, 2.04672143e-01f,
  -3.39694917e-02f, 5.92225082e-02f, -1.05077457e-02f, 4.55330722e-02f, -5.16868569e-02f, 2.10223980e-02f, 2.99981404e-02f, 1.34388255e-02f, 3.02438885e-02f, -4.82500084e-02f,
  -1.68654174e-02f, -8.00128188e-03f, 2.18497701e-02f, -6.01291656e-03f, -4.04592343e-02f, 5.29543124e-02f, 3.07156909e-02f, -1.95494220e-02f, -8.01618770e-02f, 7.28120096e-03f,
  1.06665473e-02f, 9.47832037e-03f, 2.16995104e-04f, 5.72809344e-03f, -5.12466803e-02f, 2.19236426e-02f, -5.25306538e-02f, 5.19413464e-02f, -3.59313637e-02f, 2.82779224e-02f,
  -5.82384206e-02f, -2.66530812e-01f, 1.13396257e-01f, -4.06662263e-02f, 5.74176162e-02f, -4.24775928e-02f, 4.67538387e-02f, -6.87809810e-02f, 1.21134765e-01f, -1.32604698e-02f,
  4.86755092e-03f, -2.16836911e-02f, 3.91333401e-02f, -1.02115646e-01f, -3.46629322e-02f, -4.56489287e-02f, -6.05528057e-02f, -1.49825856e-01f, -8.80753249e-02f, 2.05109343e-02f,
  -5.93272112e-02f, -1.83354154e-01f, -1.94462582e-01f, -1.83611080e-01f, 3.22932936e-02f, -1.31003216e-01f, -8.77042860e-02f, -8.08294639e-02f, -2.04704508e-01f, -9.81880203e-02f,
  -7.13796392e-02f, 4.73128200e-01f, 2.53493160e-01f, 8.29378292e-02f, -1.55688465e-01f, -2.44259655e-01f, -5.20165153e-02f, -1.40425518e-01f, -1.09979101e-01f, 1.61338449e-01f,
  -1.45538419e-01f, -1.50383830e-01f, -1.63017109e-01f, 7.01328320e-03f, -3.18037495e-02f, 2.61529684e-01f, 3.54407310e-01f, 1.01271629e-01f, -1.88967615e-01f, -2.97641546e-01f,
  -7.84194320e-02f, 3.67418453e-02f, 1.34097785e-01f, -4.64865426e-03f, 1.77837104e-01f, -5.33391722e-03f, 2.94352978e-01f, 9.66155902e-02f, 4.18467075e-02f, 3.50423962e-01f,
  -9.91291925e-02f, 1.30186304e-01f, -1.68749332e-01f, -3.19655822e-03f, -5.35813197e-02f, 4.51487266e-02f, 2.77547799e-02f, 3.85957249e-02f, -1.73956493e-03f, 1.34380236e-01f,
  5.93651412e-03f, -6.03691749e-02f, 1.49590233e-02f, 8.67236704e-02f, 1.52316261e-02f, 4.01090793e-02f, 1.69717297e-01f, 8.84436741e-02f, 5.35332179e-03f, 5.49387299e-02f,
  1.25927478e-01f, 8.81060883e-02f, 7.49399066e-02f, 9.53978151e-02f, -4.29433174e-02f, -1.22578837e-01f, 3.25550362e-02f, 2.28702314e-02f, 1.27105564e-01f, 1.93445519e-01f,
  3.68706584e-02f, -1.09337401e-02f, -1.68645140e-02f, -9.92790982e-03f, 1.50422296e-02f, -2.88427267e-02f, -2.36059930e-02f, 3.58851925e-02f, -1.82291511e-02f, -3.35047953e-02f,
  2.69343611e-02f, -2.22486258e-02f, 4.79090475e-02f, 1.04833543e-02f, -1.99180475e-04f, 5.14798723e-02f, 1.28312176e-02f, 6.70072287e-02f, -2.71836556e-02f, -5.39983399e-02f,
  -7.37745389e-02f, 2.45799986e-03f, -1.84829608e-02f, -1.00692529e-02f, 7.60242268e-02f, 4.35186997e-02f, 1.74640808e-02f, -4.01038975e-02f, -9.42688212e-02f, -5.11649847e-02f,
  -4.99533191e-02f, -1.21317670e-01f, 7.79205095e-03f, -4.77790795e-02f, 3.75252590e-02f, -2.44475957e-02f, 3.98943089e-02f, -1.88310165e-02f, -6.38697967e-02f, -6.10718057e-02f,
  -4.64669652e-02f, -3.21120061e-02f, 7.57801980e-02f, 5.16041629e-02f, -9.99144018e-02f, -1.91503428e-02f, 6.35159910e-02f, -1.64699368e-02f, -3.29102613e-02f, -4.19177493e-04f,
  3.25003937e-02f, -1.93280317e-02f, -2.12748826e-01f, -9.23444284e-04f, -3.45479953e-03f, -1.58496574e-01f, -1.09521285e-01f, -1.11182846e-01f, -2.18494520e-01f, 6.40498772e-02f,
  2.16723710e-01f, -1.78907290e-01f, 1.37093470e-01f, 1.43705517e-01f, -1.97612286e-01f, -2.36296296e-01f, -4.39128816e-01f, -1.59349054e-01f, -5.86674623e-02f, -6.94404021e-02f,
  -4.26289206e-03f, 1.12137683e-01f, 1.74466461e-01f, 4.90693413e-02f, 3.40284742e-02f, -4.51046415e-02f, 5.44406511e-02f, 1.93063870e-01f, -8.72328971e-03f, -9.01312009e-02f,
  -1.64636657e-01f, 6.49107769e-02f, 8.61065611e-02f, 3.06992773e-02f, -7.26232678e-02f, 5.71925193e-02f, 1.67464808e-01f, 1.00063510e-01f, -5.05468249e-02f, 6.48103058e-02f,
  1.25546008e-01f, -2.07052268e-02f, 2.78314650e-02f, -3.06371623e-03f, 7.60788517e-03f, 7.10619241e-02f, 1.12783005e-02f, 5.70876114e-02f, 7.52781034e-02f, 9.97065678e-02f,
  -2.24202834e-02f, 9.92639549e-03f, -6.02862649e-02f, -2.40476523e-02f, -5.87374792e-02f, 2.57945955e-02f, 2.32587708e-03f, 1.76456273e-01f, 1.46116957e-01f, -7.34874979e-02f,
  -2.97477599e-02f, -8.04762989e-02f, 7.36960098e-02f, 4.07756045e-02f, 9.89688281e-03f, 4.35393378e-02f, -6.59441128e-02f, 3.60943563e-02f, 4.89023849e-02f, 1.66326072e-02f,
  3.05727515e-02f, 8.52058902e-02f, 6.37734383e-02f, -4.25320864e-03f, -5.92605881e-02f, 6.67542219e-02f, -2.00130511e-03f, 6.28303289e-02f, -7.61688724e-02f, -3.93021340e-03f,
  5.04749455e-02f, -1.35811657e-04f, 4.15489217e-03f, 5.19183315e-02f, 5.97043522e-02f, 3.93193252e-02f, -4.46416773e-02f, 4.72153947e-02f, -3.68130729e-02f, 4.37261490e-03f,
  2.02957122e-03f, -2.55145207e-02f, 9.06372145e-02f, 3.14453766e-02f, 1.21273138e-02f, 1.44500136e-02f, -1.75600592e-02f, -3.15742381e-02f, -4.74466160e-02f, 1.96069572e-02f,
  1.73012480e-01f, 4.25699130e-02f, -4.92229648e-02f, -8.64603184e-03f, 5.49815521e-02f, 7.07158260e-03f, 1.50530273e-02f, 1.27898619e-01f, 5.02061062e-02f, 4.01487537e-02f,
  6.49713874e-02f, -2.88488287e-02f, 8.72812197e-02f, -8.56298283e-02f, -5.88040650e-02f, -1.53034292e-02f, -3.83406319e-02f, 7.89230019e-02f, 1.61840450e-02f, -1.05919000e-02f,
  -5.40840924e-02f, -1.50579005e-01f, -5.39855883e-02f, -1.56723626e-03f, 4.75364812e-02f, -7.23407865e-02f, -6.40099868e-02f, -1.98579933e-02f, 4.98556606e-02f, -1.57347426e-01f,
  -2.05011405e-02f, 2.52750516e-01f, -4.45394635e-01f, 5.64728715e-02f, 1.54346198e-01f, -6.26809895e-02f, 1.29989222e-01f, -2.21226038e-03f, 1.00609884e-01f, 1.27381727e-01f,
  2.91706890e-01f, 3.71389449e-01f, 1.86282426e-01f, 1.25043262e-02f, -7.69355893e-02f, -1.65670678e-01f, -2.43602917e-01f, -3.31085026e-01f, -1.65864378e-01f, 6.72687963e-02f,
  1.30854309e-01f, 8.51668566e-02f, -4.60544340e-02f, -1.94951184e-02f, 4.56380770e-02f, -1.23467380e-02f, -7.49413148e-02f, -5.35211936e-02f, -2.51760576e-02f, -1.75611302e-01f,
  -8.60311091e-02f, 9.33713454e-04f, 1.45519376e-02f, 9.43267271e-02f, 1.63560491e-02f, -3.18521485e-02f, 4.38114814e-02f, -7.23828599e-02f, 5.17969057e-02f, -3.48302014e-02f,
  1.04429215e-01f, 4.81151566e-02f, 1.41421497e-01f, -4.67185071e-03f, 7.61122182e-02f, 2.93651801e-02f, -6.41416237e-02f, -2.10098818e-01f, -2.45614387e-02f, 1.64562687e-02f,
  2.33173653e-01f, 4.24028076e-02f, 3.68413106e-02f, -4.88623753e-02f, -1.49428854e-02f, -6.28727954e-03f, 7.67630190e-02f, -1.22575171e-01f, -1.59539312e-01f, -1.34678721e-01f,
  -1.45420386e-02f, -7.69906864e-02f, 6.30735680e-02f, -2.13881321e-02f, 6.29551038e-02f, -4.07918878e-02f, -1.16616227e-02f, 5.46064749e-02f, 2.90074740e-02f, -3.26719582e-02f,
  6.81665838e-02f, -7.63336271e-02f, 5.07369377e-02f, 5.02249636e-02f, -1.67511608e-02f, 3.49823013e-02f, 9.62542742e-03f, 6.10282682e-02f, -2.87438035e-02f, -5.97846694e-03f,
  6.76782206e-02f, -3.81867960e-02f, 2.74194684e-02f, -6.44428879e-02f, 8.47720075e-03f, -1.34300247e-01f, 5.53098284e-02f, -4.88219522e-02f, 1.60659067e-02f, 6.57252744e-02f,
  1.67232692e-01f, -2.88296081e-02f, -6.47334680e-02f, -5.49473660e-03f, -3.37388515e-02f, 3.53832990e-02f, 9.21222046e-02f, -5.22603765e-02f, 2.59166528e-02f, 2.11090874e-02f,
  6.18892275e-02f, 1.10514192e-02f, 4.28388193e-02f, -6.40012696e-03f, -5.09231836e-02f, -2.52730437e-02f, 7.61297643e-02f, 1.92066841e-02f, 8.65077600e-03f, 7.95841739e-02f,
  3.58821973e-02f, -5.25782630e-02f, 1.54361185e-02f, 5.71103860e-03f, -3.54397185e-02f, -5.22881076e-02f, -8.38774629e-03f, -1.15911150e-02f, -9.47332233e-02f, 5.62476888e-02f,
  -9.02436897e-02f, 6.25952035e-02f, 2.90362835e-01f, 1.15787625e-01f, 1.24593943e-01f, 7.80285969e-02f, 1.72137886e-01f, 2.77471356e-02f, -5.75688630e-02f, -1.23377740e-02f,
  5.20863570e-02f, 8.94808471e-02f, 6.00065403e-02f, 1.24737680e-01f, 1.94945276e-01f, 2.12122157e-01f, 2.23996565e-01f, 2.18523055e-01f, 1.91071369e-02f, 8.45024809e-02f,
  7.68711790e-02f, 1.70953408e-01f, 1.36955112e-01f, -4.12435122e-02f, -4.86961491e-02f, -2.14464054e-03f, 2.04486027e-02f, 1.10876873e-01f, 7.12048784e-02f, -4.30545723e-03f,
  1.04905136e-01f, 3.95384133e-02f, -2.58952957e-02f, -8.43498576e-03f, 2.65066307e-02f, -1.93618611e-02f, 4.67491150e-03f, 2.48160902e-02f, -1.10087834e-01f, -2.54311570e-04f,
  4.77408133e-02f, 2.69041564e-02f, 1.18163921e-01f, -5.78490831e-02f, -6.47903681e-02f, -3.42226587e-02f, 3.25869657e-02f, -4.06578276e-03f, 2.51311436e-02f, -5.42843305e-02f,
  -3.96398604e-02f, 1.26148045e-01f, -2.35433169e-02f, 3.93903023e-03f, -2.99365465e-02f, 1.81575641e-02f, 7.30311796e-02f, -1.03276730e-01f, 6.26601949e-02f, -5.80576621e-02f,
  -5.25352806e-02f, 1.43714743e-02f, -1.03520103e-01f, -7.76186585e-02f, -6.56008348e-02f, -2.03538816e-02f, 6.39438406e-02f, 1.87991522e-02f, -1.10897589e-02f, -1.20258391e-01f,
  7.65187815e-02f, 1.14872279e-02f, 7.06741437e-02f, 6.21300749e-02f, 5.67789562e-02f, 2.07792856e-02f, 3.61634344e-02f, 3.97919156e-02f, -1.84627511e-02f, -2.48757601e-02f,
  2.21464355e-02f, 3.49518247e-02f, -4.83249612e-02f, 4.09847610e-02f, 3.42672169e-02f, 2.25530565e-02f, 2.48334277e-03f, -3.69213745e-02f, 3.74894626e-02f, -3.70153785e-02f,
  -2.67678112e-01f, 2.34995797e-01f, -4.37791087e-02f, -7.16957971e-02f, -6.76107258e-02f, -4.60091159e-02f, 5.32636717e-02f, -9.28593650e-02f, 2.67293770e-02f, 4.23509665e-02f,
  7.08254287e-03f, 2.57454030e-02f, 3.21829040e-03f, -2.45421454e-02f, 5.84539063e-02f, 1.13196475e-02f, -4.23203073e-02f, -2.69887969e-02f, -5.55225229e-03f, 1.30596068e-02f,
  3.97489555e-02f, 4.48239669e-02f, -1.21485911e-01f, -9.66924522e-03f, -2.94166226e-02f, 1.11875147e-01f, 1.16599258e-04f, -1.24259539e-01f, -5.56800589e-02f, -1.36956796e-01f,
  -4.44503650e-02f, -1.18123069e-01f, -2.17801318e-01f, -1.93528607e-02f, -9.27512795e-02f, -2.58024305e-01f, -2.97491848e-01f, -1.14427440e-01f, 1.07969113e-01f, -1.15397125e-01f,
  1.97458640e-01f, 2.16608986e-01f, 2.16245651e-01f, -9.59771127e-03f, -2.91411519e-01f, -2.95186609e-01f, -3.33715528e-01f, -2.77382880e-01f, -2.00258091e-01f, -1.43675879e-01f,
  -8.31389278e-02f, -1.09226301e-01f, -1.64233655e-01f, -1.22874111e-01f, 1.15011416e-01f, 2.25066409e-01f, -5.57112098e-02f, 4.23641317e-02f, 3.53437141e-02f, -3.72381918e-02f,
  1.61823288e-01f, -2.00587604e-02f, -6.38101026e-02f, 4.71318066e-02f, 1.20652325e-01f, 6.61192909e-02f, -2.95218173e-03f, -6.49060756e-02f, 1.23771958e-01f, -2.77638808e-02f,
  8.77912864e-02f, 6.25094026e-02f, -8.26367550e-03f, 1.24242328e-01f, -4.67616953e-02f, -5.86848408e-02f, -4.05766331e-02f, -1.49832860e-01f, 1.86863504e-02f, -2.98857992e-03f,
  1.78878173e-01f, -3.74656208e-02f, -7.70161999e-03f, -8.60650837e-02f, -2.29565930e-02f, 3.59304212e-02f, -9.11879539e-03f, 9.45633203e-02f, 1.78093486e-03f, -1.65345799e-02f,
  3.12019959e-02f, -4.64916304e-02f, -1.29204271e-02f, 7.48931020e-02f, 5.09158745e-02f, 3.28751765e-02f, -3.40994522e-02f, -3.88753437e-03f, -4.08980660e-02f, 6.30258303e-03f,
  4.24476078e-04f, 1.19449180e-02f, -7.23708840e-03f, -5.84313460e-02f, -4.49597696e-03f, -8.38801786e-02f, -1.77565310e-02f, -5.39721064e-02f, -4.53632046e-03f, -5.71178980e-02f,
  -5.43992408e-03f, -2.08546128e-02f, 2.64305025e-02f, 6.47250414e-02f, 1.32354703e-02f, -4.29016091e-02f, 2.48309001e-02f, 3.76416966e-02f, 4.81418930e-02f, -7.93486834e-02f,
  2.26988927e-01f, -7.77249709e-02f, 4.49311547e-03f, 5.60697075e-03f, 2.03200411e-02f, 2.31628660e-02f, 6.66243881e-02f, -1.21625401e-02f, 2.32741386e-02f, -1.84620898e-02f,
  1.32652307e-02f, -5.70850819e-03f, 6.19203690e-03f, 3.74018699e-02f, -6.66387081e-02f, 2.93605123e-02f, -5.52727394e-02f, 3.22754346e-02f, -4.78994995e-02f, 9.63806435e-02f,
  6.48469850e-03f, -1.58480644e-01f, -1.14228047e-01f, -8.70910846e-03f, 4.45796037e-03f, -1.57182775e-02f, -3.32734324e-02f, -1.84191950e-02f, -9.67880711e-02f, -1.33149818e-01f,
  -6.12455085e-02f, -1.01422511e-01f, -5.58377132e-02f, -1.17716081e-01f, 4.74738702e-02f, -1.48799986e-01f, -3.02160174e-01f, -1.54586852e-01f, -2.57965699e-02f, -9.17801782e-02f,
  2.63282180e-01f, 3.00361693e-01f, 1.85476273e-01f, 6.99976236e-02f, -1.19268112e-01f, -2.79278100e-01f, -1.75896093e-01f, -1.97242245e-01f, -1.18372642e-01f, -2.10642722e-02f,
  -2.84503177e-02f, -1.36539862e-01f, 5.31362742e-02f, -7.00448677e-02f, -4.50993404e-02f, 3.73391062e-03f, -1.41111434e-01f, -1.38711138e-02f, -3.06970365e-02f, -1.70714259e-01f,
  -1.92494214e-01f, 7.12440312e-02f, 6.64000260e-03f, 1.53608590e-01f, 1.38864756e-01f, -8.72375444e-03f, -2.26913095e-02f, 6.49013296e-02f, 4.30801548e-02f, -1.13569573e-01f,
  9.27822292e-02f, 1.44375507e-02f, 9.54008102e-03f, 3.03622857e-02f, -5.78554533e-02f, 2.95895915e-02f, -4.72037345e-02f, -9.56989229e-02f, -1.19982837e-02f, -1.99642847e-03f,
  3.94478403e-02f, -8.20641033e-03f, -5.80226369e-02f, -1.10254347e-01f, -9.33236182e-02f, -2.23958902e-02f, -1.16617262e-01f, -1.75981760e-01f, -9.29716751e-02f, -2.60371476e-01f,
  3.59782192e-04f, 2.28276625e-02f, 6.13603331e-02f, -1.25380158e-02f, -5.68478256e-02f, 3.05617116e-02f, -2.97369547e-02f, 4.41493616e-02f, -2.51673032e-02f, -7.76834264e-02f,
  3.99914421e-02f, 1.93497195e-04f, -8.80321953e-03f, -2.16605067e-02f, 1.27828931e-02f, -4.18145098e-02f, -1.19396299e-02f, -4.36532646e-02f, -5.53165609e-03f, 3.66740003e-02f,
  -3.96577083e-02f, 1.97917204e-02f, 4.15328238e-03f, 5.29712141e-02f, 8.58932920e-03f, 1.82397496e-02f, -1.98330749e-02f, 1.13428524e-02f, -7.09533542e-02f, -7.41386041e-03f,
  -5.13141677e-02f, 3.32401007e-01f, -2.51078401e-02f, -1.05533160e-01f, -2.35263295e-02f, 5.77173717e-02f, 4.60920483e-02f, -3.71763222e-02f, 1.81433529e-01f, -6.14364892e-02f,
  -3.25857699e-02f, -1.79566387e-02f, 5.07224016e-02f, -2.48556286e-02f, -3.08141112e-02f, -6.86586499e-02f, -6.25457540e-02f, 2.12610103e-02f, -4.26489525e-02f, -2.29516886e-02f,
  -1.05324306e-01f, -5.21473140e-02f, -1.00800276e-01f, -1.27377152e-01f, -1.07420031e-02f, -2.37953998e-02f, -6.10748902e-02f, -7.03894272e-02f, -1.46330699e-01f, -3.87987047e-01f,
  5.04549861e-01f, -4.80744466e-02f, -2.59484321e-01f, 3.73629779e-01f, -5.36451377e-02f, -3.51918906e-01f, -3.70525986e-01f, -1.38206273e-01f, 7.66713843e-02f, -9.42104608e-02f,
  -3.38377059e-02f, 1.59583017e-01f, 1.05030462e-01f, 2.39234511e-02f, -1.25561208e-01f, -1.21340454e-01f, -7.61455148e-02f, -6.45424891e-03f, 2.08667526e-03f, 1.18379788e-02f,
  1.31016269e-01f, 2.56954014e-01f, 1.41581953e-01f, 5.92437051e-02f, 1.62063047e-01f, 8.46617594e-02f, -4.00854200e-02f, -3.25044319e-02f, -4.05099802e-02f, 2.13302687e-01f,
  6.62545934e-02f, 1.17609903e-01f, -9.12887603e-02f, 1.09403774e-01f, -6.65258244e-02f, 4.99311127e-02f, -6.37776479e-02f, 3.30580734e-02f, 1.53571907e-02f, -5.08777872e-02f,
  6.30650297e-02f, 1.94605011e-02f, 2.59870533e-02f, 4.53546569e-02f, -2.85691619e-02f, 1.31247775e-03f, -6.51346669e-02f, -4.12665084e-02f, -4.30964790e-02f, -2.90927235e-02f,
  -7.09138140e-02f, 3.26550417e-02f, -7.22281858e-02f, -1.67792872e-01f, -1.49335697e-01f, 4.74248547e-03f, -9.22132358e-02f, 9.51459259e-03f, -1.82918623e-01f, 7.86585361e-02f,
  -1.80794317e-02f, 1.15292873e-02f, 6.73781103e-03f, -2.49574482e-02f, 1.04122488e-02f, 3.89005207e-02f, -4.04294617e-02f, 1.20567260e-02f, 2.76377518e-03f, 6.18473329e-02f,
  -2.16112472e-02f, -5.77164777e-02f, 4.64936456e-04f, 2.01076940e-02f, 5.08464910e-02f, -4.56652939e-02f, 4.27971929e-02f, -8.38564113e-02f, -3.66414078e-02f, 9.39207058e-03f,
  4.78615090e-02f, -7.11270645e-02f, -1.06586842e-02f, -2.39367802e-02f, -1.04439911e-02f, 2.50547901e-02f, 5.79204261e-02f, -1.77527945e-02f, -2.76990198e-02f, 6.82992041e-02f,
  1.68389648e-01f, -2.61032283e-01f, 1.13010898e-01f, 1.03386402e-01f, 9.63085517e-02f, -5.75486012e-02f, 7.05997348e-02f, -1.44539038e-02f, 5.57138622e-02f, 1.89019497e-02f,
  -8.26063454e-02f, 1.02584116e-01f, -5.14917634e-02f, 4.31477241e-02f, 7.90787116e-02f, -2.13242490e-02f, 4.54097837e-02f, 9.99186933e-02f, -3.25230323e-02f, 7.42745306e-03f,
  -4.27340679e-02f, 6.94740340e-02f, 1.88393518e-02f, -2.17234865e-02f, -1.10663017e-02f, 1.43228546e-01f, -5.69177829e-02f, 3.10223810e-02f, -3.47296745e-02f, 2.98870634e-02f,
  -4.91045326e-01f, 3.60061944e-01f, 4.37367946e-01f, -6.04438744e-02f, 1.86257929e-01f, 2.89148003e-01f, 4.29739475e-01f, -2.85099894e-02f, -3.87919955e-02f, 9.93240625e-02f,
  5.12503237e-02f, -1.93354666e-01f, -1.26837328e-01f, -1.82986900e-01f, -4.36855331e-02f, 1.80950448e-01f, 1.77133277e-01f, -2.19810307e-01f, -2.92905897e-01f, -1.55930504e-01f,
  -1.60289466e-01f, -1.80654362e-01f, -2.39640027e-01f, -2.32999012e-01f, 7.69275576e-02f, -8.72281119e-02f, 2.20394954e-01f, 9.06320009e-03f, 6.07981682e-02f, -1.00850323e-02f,
  2.35544503e-01f, 7.10962191e-02f, -7.72401020e-02f, -1.90020770e-01f, 7.47081712e-02f, -5.19226603e-02f, -2.52693836e-02f, -5.37214130e-02f, -2.33563827e-03f, 1.49277924e-03f,
  4.58924882e-02f, -3.18107866e-02f, -4.45112865e-03f, -6.19640797e-02f, 2.51505021e-02f, 9.36802477e-03f, 4.28506918e-02f, -1.39146820e-01f, 1.31032560e-02f, 4.61975560e-02f,
  2.05154046e-02f, 2.89303828e-02f, 6.72075525e-02f, 6.88599721e-02f, 3.10272351e-02f, -8.23489875e-02f, 9.41597745e-02f, 8.43456686e-02f, 5.15907183e-02f, 5.18232659e-02f,
  -8.90557617e-02f, 3.74855213e-02f, 3.56177166e-02f, 1.46835502e-02f, -7.41638690e-02f, 8.09409171e-02f, 1.13868630e-02f, -6.81635784e-03f, -1.10674664e-01f, 4.65075150e-02f,
  -4.67643328e-02f, 3.42637934e-02f, -3.86032648e-02f, 4.96450067e-02f, -3.80380824e-03f, 4.95804921e-02f, 2.29672976e-02f, -2.08014692e-03f, -1.34125855e-02f, 1.48932720e-02f,
  -1.20977703e-02f, -6.78428682e-03f, -2.56051961e-03f, -1.58669185e-02f, -1.04989437e-02f, 3.02947741e-02f, -5.16070724e-02f, 5.92352543e-03f, 4.09554392e-02f, -6.02829307e-02f,
  -6.14493228e-02f, 1.75492037e-02f, -5.75557351e-02f, -6.67681992e-02f, 7.98240155e-02f, -5.55399433e-03f, 1.99128315e-02f, -5.00475839e-02f, 2.32966114e-02f, -2.37696040e-02f,
  -8.41805339e-03f, -1.26254922e-02f, 8.00845549e-02f, 1.26644382e-02f, -1.00603029e-01f, -2.62378827e-02f, 1.91838667e-02f, -4.22897674e-02f, -5.94508983e-02f, 5.11626042e-02f,
  6.45046830e-02f, -1.85665153e-02f, 1.13983266e-02f, 4.51138392e-02f, 1.94521192e-02f, -7.61625692e-02f, 1.39095783e-01f, 8.96691605e-02f, -4.76888800e-03f, 3.55567373e-02f,
  3.31398398e-01f, -2.27910727e-01f, -3.24836105e-01f, -1.35324091e-01f, -3.51297200e-01f, -2.41645068e-01f, -1.16909072e-01f, 1.82038639e-02f, 1.46203011e-01f, -1.51203126e-01f,
  -2.22881064e-01f, -1.20240659e-01f, -1.24420576e-01f, 2.23322790e-02f, 2.41568647e-02f, 8.08426179e-03f, -8.54944512e-02f, 5.04900403e-02f, 3.56660672e-02f, -1.06758706e-01f,
  -1.76250950e-01f, -6.15596138e-02f, 1.38770685e-01f, 1.16452545e-01f, -3.41181494e-02f, -1.16413675e-01f, -1.07697636e-01f, 2.26138514e-02f, -9.77010876e-02f, -2.18974620e-01f,
  -3.94680321e-01f, 2.92505529e-02f, -4.38907333e-02f, -2.44308747e-02f, -1.50479674e-01f, 5.89326546e-02f, -1.31147400e-01f, 9.12016481e-02f, 5.91601245e-02f, 5.49269803e-02f,
  -1.81398407e-01f, 1.48817040e-02f, -6.86597303e-02f, -8.13647434e-02f, -2.34180642e-03f, -1.43703576e-02f, 1.25164688e-01f, 8.51502866e-02f, 1.04251511e-01f, -8.41281861e-02f,
  -1.97769433e-01f, -1.04869425e-01f, 1.00946993e-01f, 1.08707316e-01f, 2.57852320e-02f, -3.40917222e-02f, -5.34795970e-03f, 6.67762756e-03f, 1.05939638e-02f, 1.21910259e-01f,
  -6.39366135e-02f, 1.59174372e-02f, 5.21970317e-02f, 1.02702938e-02f, 2.26030294e-02f, 6.95040077e-02f, 6.34048600e-03f, 5.24776354e-02f, 2.81559527e-02f, -4.77062427e-02f,
  2.70982813e-02f, -5.00013679e-02f, -1.06485665e-03f, 1.57757942e-02f, -5.17897382e-02f, 3.58395954e-03f, 2.44677663e-02f, -1.46220345e-02f, 4.74099256e-02f, -7.45142624e-03f,
  5.23274243e-02f, -1.35728735e-02f, -5.73203042e-02f, 1.97598548e-03f, 2.64494051e-03f, -4.54821847e-02f, 5.03520528e-03f, -5.09608760e-02f, 8.32891092e-03f, 4.18186188e-02f,
  1.31369084e-01f, -4.86130416e-02f, -2.58616991e-02f, 1.36737496e-01f, 1.78610627e-02f, 5.10360859e-02f, -8.91958550e-02f, 9.10985991e-02f, -3.94253433e-02f, -9.05561298e-02f,
  -4.44252772e-04f, -3.50182177e-03f, -6.42362535e-02f, -3.71101405e-03f, -1.21483169e-02f, -3.25620435e-02f, 5.05243652e-02f, -7.84511492e-02f, -9.44134593e-03f, -1.14582921e-03f,
  7.98750967e-02f, 1.67151585e-01f, 2.06784174e-01f, 1.07844971e-01f, -1.30409831e-02f, 9.12893191e-02f, 1.41165042e-02f, 3.19119841e-02f, 7.28082657e-02f, 2.20186308e-01f,
  2.63891399e-01f, 3.71603638e-01f, 5.38905561e-02f, 2.06259310e-01f, 2.11853787e-01f, 2.15306059e-01f, 3.77629131e-01f, 1.57546476e-01f, 3.37199420e-02f, 1.54751241e-01f,
  -6.98080361e-02f, -3.77881885e-01f, -3.49449605e-01f, -3.95975292e-01f, -1.53634027e-01f, 2.22329333e-01f, 1.76259592e-01f, -1.74566075e-01f, -2.68589944e-01f, -9.44145247e-02f,
  -4.46720310e-02f, 1.24706164e-01f, -2.17127260e-02f, 4.42154445e-02f, 1.50792390e-01f, 1.79279298e-02f, 9.88196805e-02f, 1.40040323e-01f, -3.64344828e-02f, 2.46513173e-01f,
  -2.36334071e-01f, 2.19576374e-01f, -2.12255925e-01f, -1.16276719e-01f, -2.46721823e-02f, -1.43637732e-01f, -1.88228469e-02f, 2.95850243e-02f, -1.00249890e-02f, 4.51494046e-02f,
  -6.79772645e-02f, -2.58499570e-02f, 5.36992028e-03f, -8.22824240e-02f, 5.07398844e-02f, 4.73871753e-02f, 6.55224249e-02f, -6.78152442e-02f, -6.28076345e-02f, -7.13401139e-02f,
  1.28580900e-02f, 1.51977152e-01f, 4.00259113e-03f, -3.37011516e-02f, -1.04340099e-01f, -3.28116268e-02f, 1.85142606e-02f, 3.09655573e-02f, -6.32578656e-02f, 8.20529312e-02f,
  2.74972823e-02f, 4.67759483e-02f, 2.33125929e-02f, 6.42496953e-03f, 2.31018774e-02f, -1.83275323e-02f, 3.36058736e-02f, 3.82825434e-02f, -4.52966578e-02f, 8.82141590e-02f,
  -5.63748404e-02f, -2.45234203e-02f, -3.84232812e-02f, -7.60082621e-03f, -5.77137619e-02f, 7.06302449e-02f, 1.10293645e-02f, -1.29568297e-02f, -1.11691825e-01f, 4.06595394e-02f,
  -6.41756281e-02f, -5.16934432e-02f, 7.07765743e-02f, 1.11319881e-03f, -1.99470371e-02f, 4.98702924e-04f, 3.23893987e-02f, -3.05443481e-02f, 2.99273506e-02f, 8.52262974e-02f,
  -1.61437914e-01f, -1.93674386e-01f, 3.63737438e-03f, -7.15729892e-02f, 7.93193728e-02f, 2.48828158e-03f, -6.12401403e-02f, -3.80996466e-02f, -1.90980695e-02f, 4.82180715e-02f,
  -3.89259756e-02f, -9.95956175e-03f, 1.26343984e-02f, -4.20483239e-02f, -1.72511842e-02f, -5.07079959e-02f, 3.83062959e-02f, -3.55690159e-02f, -8.95964727e-02f, 4.16240059e-02f,
  9.25855413e-02f, 4.28874567e-02f, -4.26155813e-02f, -1.72515847e-02f, -1.75819080e-02f, -1.20847866e-01f, -1.03555277e-01f, -9.98793021e-02f, -6.87693730e-02f, 1.09443992e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.91140938e-01f, 1.81404024e-01f, -2.88665175e-01f, -1.20328441e-02f, -2.63552397e-01f, -2.25296855e-01f, 6.21320009e-02f, 1.25078574e-01f, 1.07758753e-01f, 1.61488429e-02f,
  -1.00709714e-01f, -7.67094567e-02f, -5.69316894e-02f, -5.84621243e-02f, 1.19699627e-01f, -1.98360216e-02f, -1.29727885e-01f, -8.27433541e-02f, -1.22501381e-01f, 3.33627947e-02f,
  6.54312298e-02f, 1.01152502e-01f, 2.28688359e-01f, 7.09486678e-02f, -5.48228696e-02f, -1.46736979e-01f, -2.54521556e-02f, -1.10243939e-01f, -3.65718342e-02f, -3.08194850e-02f,
  -1.97820976e-01f, 1.03781244e-03f, -1.18236043e-01f, 6.78665414e-02f, -2.03937486e-01f, 3.37994099e-02f, -1.00102641e-01f, -7.07123801e-02f, -2.35237870e-02f, -3.66363265e-02f,
  -1.37690842e-01f, -7.17114136e-02f, 1.00224838e-02f, 6.73776353e-03f, 8.82845521e-02f, -5.09154461e-02f, 3.36028710e-02f, 5.99620938e-02f, -9.20139253e-02f, -3.10970973e-02f,
  -9.32237878e-02f, -1.69197232e-01f, -1.57074735e-01f, -1.14114061e-01f, -6.42768592e-02f, -4.55285124e-02f, -8.91636312e-02f, -1.35318682e-01f, -8.57115090e-02f, 8.01270902e-02f,
  -7.91998953e-02f, -6.41984269e-02f, -7.86994770e-02f, 3.35871102e-03f, 6.80685118e-02f, 3.21100641e-04f, -4.93787080e-02f, 2.43681110e-02f, 6.80320933e-02f, 2.15956978e-02f,
  4.81766015e-02f, -6.70368373e-02f, 2.49757003e-02f, 8.92752931e-02f, 3.80362757e-02f, -6.28801286e-02f, 6.04826063e-02f, 1.23047326e-02f, 7.33834952e-02f, 2.52217017e-02f,
  -3.63084823e-02f, -9.98160020e-02f, 1.71419643e-02f, 7.08371997e-02f, -1.77209601e-02f, 9.36805829e-03f, 3.35824117e-02f, 2.46509979e-03f, -8.78449529e-03f, -2.66352408e-02f,
  2.48808414e-01f, -4.30100150e-02f, -5.52173741e-02f, 1.09694846e-01f, -1.39756292e-01f, 4.28574942e-02f, -1.12914085e-01f, -5.30395843e-02f, -3.19247246e-02f, 1.31121534e-03f,
  -1.28482983e-01f, -3.10824234e-02f, -6.60748454e-04f, -2.55780518e-02f, -1.36980508e-02f, 6.87292591e-02f, 1.73803359e-01f, -2.13475935e-02f, 5.95784821e-02f, -1.22841438e-02f,
  9.22028720e-02f, 6.66342825e-02f, 1.69635266e-02f, 6.52486905e-02f, -4.99249510e-02f, -1.30147636e-01f, 3.38071468e-03f, -5.28279208e-02f, -4.02096435e-02f, 3.02179873e-01f,
  -1.34690970e-01f, -1.11227475e-01f, -1.60983011e-01f, -9.91081521e-02f, 6.82797059e-02f, 2.62445211e-02f, 1.34377435e-01f, 6.29711896e-02f, -6.50514439e-02f, -2.24457216e-02f,
  -2.90758349e-02f, 9.52984847e-04f, -2.89552659e-02f, -5.11452481e-02f, 3.36483978e-02f, 1.03701144e-01f, -1.30619276e-02f, -2.24172603e-02f, 7.26617873e-02f, 1.91477478e-01f,
  -1.35307657e-02f, -6.99960440e-02f, -7.30671734e-02f, -1.77961588e-02f, 4.41716239e-02f, -2.67680455e-02f, -1.27075970e-01f, -2.07086243e-02f, -3.02107120e-03f, -6.26890734e-02f,
  -1.94004819e-01f, 4.44313809e-02f, 1.08652592e-01f, -4.77186590e-02f, -1.26135513e-01f, 5.27677424e-02f, -3.54314642e-03f, -5.78837981e-03f, 5.74811883e-02f, -1.65338386e-02f,
  -4.56370711e-02f, 7.28123784e-02f, -6.96698949e-02f, 1.12867497e-01f, -2.41273604e-02f, 5.08052148e-02f, -2.92535741e-02f, 5.80917783e-02f, -1.10427300e-02f, 7.25860847e-03f,
  1.07015081e-01f, -2.15909667e-02f, -2.62601413e-02f, -3.84075455e-02f, 7.94095993e-02f, -1.16914056e-01f, -9.22598466e-02f, 4.40550875e-03f, 6.00714758e-02f, -1.15427218e-01f,
  9.42863990e-03f, -1.88428462e-02f, 4.58774492e-02f, 7.15149194e-02f, 4.34323736e-02f, 7.16123953e-02f, 7.61895999e-02f, 2.45670658e-02f, -5.68939112e-02f, 6.12931885e-02f,
  -3.98317724e-02f, -3.54347117e-02f, 1.89069510e-02f, -7.48419613e-02f, 1.43796520e-03f, -6.78191409e-02f, 4.35068421e-02f, -2.26118155e-02f, -9.64435264e-02f, -3.17529589e-02f,
  -5.41217113e-03f, -1.50244252e-03f, 5.96343763e-02f, -1.22252796e-02f, -2.72409082e-03f, 6.08686283e-02f, -9.80415102e-03f, 2.60733850e-02f, 2.89547499e-02f, 2.32002027e-02f,
  -2.90169388e-01f, -6.55124784e-02f, -8.94748867e-02f, 4.68791462e-02f, -7.99977481e-02f, -7.96851739e-02f, -7.00636953e-02f, -9.33163688e-02f, -6.21314198e-02f, 7.99785629e-02f,
  -2.54474599e-02f, -9.24743414e-02f, 9.71803442e-03f, 7.15129822e-02f, 1.72633417e-02f, 2.69225277e-02f, -7.34134540e-02f, -1.01468608e-01f, -1.78341276e-03f, -4.19928394e-02f,
  6.10345118e-02f, 2.47325655e-02f, -1.10659838e-01f, -1.00436741e-02f, 7.97017291e-02f, -1.08779974e-01f, -5.61718456e-03f, 3.24831493e-02f, -1.30787879e-01f, -1.67194054e-01f,
  -1.59421176e-01f, -2.28758141e-01f, -2.62176037e-01f, -3.49772841e-01f, -5.90008684e-02f, 1.98016465e-01f, 1.43474728e-01f, -3.02226823e-02f, -4.12822179e-02f, -1.97167456e-01f,
  4.24248241e-02f, 6.86670654e-03f, -1.57988414e-01f, -1.17010877e-01f, -8.22409522e-03f, -8.05472285e-02f, -2.74689704e-01f, -4.83846217e-02f, 1.74453586e-01f, 2.54259199e-01f,
  -1.07877180e-02f, -4.56299968e-02f, -1.49496526e-01f, -1.52101487e-01f, -2.11556002e-01f, -9.40298438e-02f, -2.69861966e-01f, -1.18127100e-01f, 3.91597413e-02f, -2.49612674e-01f,
  -5.88967800e-02f, 6.66963086e-02f, 1.15906671e-01f, -4.34573144e-02f, -3.21832709e-02f, 7.99523219e-02f, 1.74828209e-02f, -1.19648397e-01f, -5.13978936e-02f, 5.46454415e-02f,
  -1.06112389e-02f, 2.91775893e-02f, -6.87677115e-02f, 8.28021616e-02f, 3.66819836e-02f, 9.46241245e-02f, -4.24973145e-02f, 9.61063430e-03f, -8.91715437e-02f, 5.24291843e-02f,
  -3.24362069e-02f, -1.09517453e-02f, -1.70634426e-02f, 2.33962238e-02f, -3.52922231e-02f, -5.87070137e-02f, 1.45523902e-02f, 1.07842907e-01f, -4.89812642e-02f, -1.22493252e-01f,
  3.80356200e-02f, -3.66857089e-02f, 5.47448620e-02f, 6.51105121e-02f, 8.03807154e-02f, -6.64424449e-02f, -4.03800942e-02f, 4.95457463e-02f, -2.86391284e-02f, -4.80625741e-02f,
  2.04110937e-03f, -4.42199148e-02f, -4.08125743e-02f, -1.22904629e-02f, -9.85602587e-02f, -3.57059315e-02f, 8.91728252e-02f, 5.55171221e-02f, -6.93497807e-02f, -6.00583702e-02f,
  -3.62492092e-02f, 6.00812212e-02f, -6.69369102e-02f, 3.87695245e-02f, -1.36798397e-02f, 1.73079688e-02f, 9.19701979e-02f, 7.14642704e-02f, -5.96972182e-02f, -1.05952425e-02f,
  -3.10688049e-01f, 1.85502276e-01f, -1.11433461e-01f, 1.82023887e-02f, -4.47312295e-02f, -5.52041903e-02f, -9.90098044e-02f, -3.37506421e-02f, -8.63928795e-02f, 1.16938576e-02f,
  9.96614769e-02f, 4.76469360e-02f, -1.24043494e-01f, -1.78795774e-02f, 1.11127786e-01f, 3.97297852e-02f, 5.07094413e-02f, -5.00025339e-02f, 8.85374025e-02f, -1.58111416e-02f,
  -6.17141090e-02f, 3.19333449e-02f, 3.67001221e-02f, -4.40422781e-02f, -5.53104691e-02f, -8.12763162e-03f, 1.42901819e-02f, -3.98049429e-02f, 2.48846430e-02f, -4.73219492e-02f,
  -1.98011696e-02f, -1.04255408e-01f, -1.92962006e-01f, 5.65252490e-02f, 4.62095253e-03f, -1.75928161e-01f, -3.01770061e-01f, -1.66018128e-01f, 2.37428602e-02f, -3.31581496e-02f,
  -6.17509894e-02f, -1.21637033e-02f, -1.08636476e-01f, -2.21809521e-01f, -3.39813203e-01f, -3.70523632e-01f, -1.70231104e-01f, -2.50116259e-01f, -5.84949777e-02f, -3.19506973e-02f,
  -1.33988671e-02f, -4.51113395e-02f, -3.28801293e-03f, -5.39077111e-02f, 7.51968008e-03f, 6.53995126e-02f, 1.70839410e-02f, 8.73781517e-02f, 1.17711127e-02f, 3.33653390e-02f,
  -3.37366685e-02f, 9.17583108e-02f, -6.57922402e-02f, -5.27037159e-02f, 1.12536564e-01f, -3.82145611e-03f, -1.39128622e-02f, 9.69657972e-02f, 4.79587279e-02f, -1.24373823e-01f,
  -2.87738200e-02f, 8.83497968e-02f, -3.77979688e-02f, -3.10310815e-02f, 4.56903130e-02f, 2.32127868e-02f, -1.17522009e-01f, -4.60952148e-02f, -4.33150232e-02f, -7.34319817e-03f,
  -8.56121182e-02f, -5.47108091e-02f, -1.56215623e-01f, -1.62205249e-02f, -4.08581644e-02f, 4.83036116e-02f, 2.96360105e-02f, 9.48299989e-02f, -1.76777784e-02f, -1.15755007e-01f,
  -1.34682050e-02f, -2.57132333e-02f, 2.62259077e-02f, -4.27455604e-02f, -3.12735401e-02f, 2.13102484e-03f, 5.76919615e-02f, 5.14057800e-02f, -3.36198062e-02f, 5.39488383e-02f,
  -7.67129054e-03f, -1.01253480e-01f, 2.21121497e-02f, -4.56742570e-03f, -5.95806632e-04f, 4.18854691e-02f, -8.86150301e-02f, -6.86419755e-02f, -8.00583437e-02f, 2.20456123e-02f,
  1.63200926e-02f, 4.42206897e-02f, 1.37465037e-02f, 7.40743196e-03f, -6.83559328e-02f, -7.24806357e-03f, -4.93265465e-02f, 8.59092399e-02f, -7.12147774e-03f, 1.11623183e-02f,
  -1.38884792e-02f, -8.29021037e-02f, -4.41051237e-02f, -5.34104444e-02f, -2.87252944e-02f, 9.45196860e-03f, 3.31935212e-02f, -3.31875868e-03f, -3.99417244e-02f, -9.22663230e-03f,
  6.23077108e-03f, -9.51876938e-02f, 1.34451985e-02f, 7.29097612e-03f, -1.15126990e-01f, -3.96748260e-02f, -6.43480942e-02f, -1.37497857e-01f, -5.95548861e-02f, 6.44821301e-02f,
  -6.95824027e-02f, -1.41965747e-01f, -2.29374424e-01f, -1.73955441e-01f, -3.88945863e-02f, -1.91814333e-01f, -2.36375988e-01f, -1.52471766e-01f, -2.53493965e-01f, -3.27498406e-01f,
  3.49954665e-01f, 3.24176669e-01f, 1.66068405e-01f, 1.79275259e-01f, 2.79581308e-01f, 3.02707613e-01f, 3.66898626e-01f, 1.80638000e-01f, -1.46230301e-02f, 2.35134453e-01f,
  2.36373320e-01f, 1.29729748e-01f, 1.10853009e-01f, 8.95858333e-02f, 1.37906000e-01f, 4.55869399e-02f, -1.58619732e-01f, -3.11897863e-02f, -5.19842207e-02f, -2.17966363e-02f,
  -1.34723531e-02f, 1.52061111e-04f, 7.12406859e-02f, 5.13954237e-02f, -1.64322536e-02f, -4.73968834e-02f, 5.71965501e-02f, 2.70832498e-02f, 1.33004323e-01f, -5.76573573e-02f,
  5.34202252e-03f, 3.90090466e-01f, -1.44657984e-01f, -3.75611633e-02f, 1.18953548e-01f, -5.61202355e-02f, -7.02543408e-02f, -1.26964703e-01f, 7.12470859e-02f, -5.36916852e-02f,
  -3.39959972e-02f, 6.77612564e-03f, 1.13187209e-02f, -3.25644463e-02f, -4.54735570e-02f, 1.77027080e-02f, -1.90259665e-02f, 2.05994751e-02f, -2.69782972e-02f, 3.06305196e-03f,
  -8.26550499e-02f, 1.08405821e-01f, 1.35872990e-01f, 1.08072944e-02f, 3.76964919e-02f, -1.68455467e-02f, 9.76961926e-02f, 7.00576173e-04f, 2.32904125e-02f, -1.21180119e-03f,
  4.74054040e-03f, -8.69446609e-04f, 8.67504403e-02f, 4.33083996e-02f, 6.40843883e-02f, 5.38058616e-02f, -2.95268297e-02f, 3.77666466e-02f, 5.83570041e-02f, -5.42370155e-02f,
  5.75577021e-02f, 6.20155297e-02f, 9.43905935e-02f, -5.68179563e-02f, 4.38353159e-02f, -3.25630344e-02f, 5.61139844e-02f, -1.00617390e-03f, 9.57140774e-02f, 5.09670787e-02f,
  -4.10755388e-02f, -3.35704647e-02f, 2.84103304e-02f, 1.25870202e-02f, 4.91357110e-02f, 6.00772575e-02f, 1.04794344e-02f, 3.62731181e-02f, -1.69492830e-02f, 8.01051222e-03f,
  -1.42565757e-01f, 1.15754768e-01f, -1.31555647e-01f, -1.75417081e-01f, 1.81376040e-02f, -4.31684852e-02f, 3.91506366e-02f, -7.16284364e-02f, -1.37904629e-01f, -1.49047300e-01f,
  5.68610318e-02f, -3.78161967e-02f, 3.74661162e-02f, -4.09949459e-02f, -5.69580868e-02f, 1.79011021e-02f, 2.84443181e-02f, -2.37483159e-02f, -4.04119119e-02f, -7.17501435e-03f,
  -2.22755801e-02f, -1.30967930e-01f, -9.41064283e-02f, -1.19004786e-01f, -8.26948415e-03f, -3.10120992e-02f, -9.31523144e-02f, -1.27966464e-01f, -5.20152450e-02f, -1.60444915e-01f,
  -5.97654700e-01f, -1.63726360e-01f, 2.47875661e-01f, -2.90593028e-01f, -5.84428478e-03f, 1.88946024e-01f, 5.62344752e-02f, -8.34945291e-02f, -1.31825164e-01f, -3.74808721e-02f,
  -7.93403685e-02f, -2.03415588e-01f, -1.61725998e-01f, -7.95204788e-02f, 1.58251133e-02f, 1.45133641e-02f, 9.26213786e-02f, -8.51854235e-02f, 1.10914089e-01f, -3.95681746e-02f,
  -6.60548508e-02f, -1.86621755e-01f, -2.44179636e-01f, -1.29229829e-01f, -4.69178110e-02f, -1.29656076e-01f, 7.80982105e-03f, -5.88012524e-02f, 2.67206021e-02f, -1.72018148e-02f,
  2.82127589e-01f, -2.34630466e-01f, -2.85603721e-02f, -8.53146315e-02f, 8.88845325e-03f, -7.38403797e-02f, -2.36369800e-02f, 3.36216670e-03f, -1.33778095e-01f, -5.24772480e-02f,
  -5.71753755e-02f, 4.10555899e-02f, -1.15937382e-01f, -2.69337073e-02f, -9.70668718e-02f, 9.29224044e-02f, -1.04163319e-01f, -2.90366393e-02f, 1.09018661e-01f, 8.57176855e-02f,
  3.66645642e-02f, 6.04511937e-03f, 3.36373635e-02f, 4.06352244e-02f, 1.75448377e-02f, -6.85572475e-02f, 3.12990807e-02f, -4.55035679e-02f, 4.91418839e-02f, -4.84016798e-02f,
  6.56702593e-02f, -8.20532627e-03f, 4.52068560e-02f, -1.08763166e-01f, 2.27341875e-02f, -4.88855038e-03f, -4.94003445e-02f, 6.14458658e-02f, -5.85659333e-02f, -6.55065849e-02f,
  2.42365822e-02f, -2.74057053e-02f, -7.55564570e-02f, -9.21225268e-03f, 4.68240492e-02f, -5.79561805e-03f, -1.02371968e-01f, -6.76537827e-02f, 6.53219670e-02f, -1.07245386e-01f,
  -1.09276818e-02f, -3.76147218e-02f, -8.49229991e-02f, 2.72331890e-02f, 7.55972490e-02f, 1.94510128e-02f, 1.53483236e-02f, 4.85532694e-02f, 2.24121492e-02f, -1.37884719e-02f,
  1.10419661e-01f, 1.46616828e-02f, -8.40378329e-02f, -6.70773387e-02f, 1.09508082e-01f, -1.05017126e-02f, 1.31555805e-02f, -7.35831037e-02f, 3.61396968e-02f, 4.83482424e-03f,
  -1.73199065e-02f, -7.87624419e-02f, 6.23139814e-02f, 2.26757899e-02f, 4.05980311e-02f, 1.24758177e-01f, 1.70771759e-02f, 3.35148424e-02f, 7.64397457e-02f, 3.00145410e-02f,
  -3.21475565e-02f, 5.86635955e-02f, -1.43814292e-02f, 5.61504923e-02f, 4.13231291e-02f, 2.02031992e-02f, 2.21739367e-01f, 9.27723721e-02f, 1.53094321e-01f, 6.22134320e-02f,
  -2.06427157e-01f, -4.73864004e-02f, 5.78736067e-02f, 2.82105245e-02f, 1.48204684e-01f, 5.27418628e-02f, 1.55450612e-01f, 3.51964720e-02f, 7.29265157e-03f, 1.13427475e-01f,
  -5.63040413e-02f, 8.06845799e-02f, 1.36093825e-01f, 1.15463689e-01f, -3.80421914e-02f, 1.95295632e-01f, 4.55850922e-02f, -2.78489050e-02f, 4.08845358e-02f, -1.48622347e-02f,
  1.15472026e-01f, -4.12342101e-02f, -1.42830402e-01f, 2.63484214e-02f, 7.34316558e-02f, 3.58804874e-02f, 1.18015848e-01f, -3.10806222e-02f, 2.40670126e-02f, 9.76196006e-02f,
  -5.65737188e-02f, -2.16954455e-01f, 6.92318985e-03f, -7.86107630e-02f, -8.56724083e-02f, -1.14931852e-01f, 5.83365746e-02f, -7.80547932e-02f, 3.25633958e-02f, 1.13901429e-01f,
  -3.29654291e-02f, 2.00826339e-02f, 1.18884658e-02f, 1.50904078e-02f, -3.86491641e-02f, 4.48951311e-03f, 5.38751762e-03f, -1.04497217e-01f, 5.77234142e-02f, -4.28415686e-02f,
  -1.13728821e-01f, -8.07509106e-03f, 6.81609884e-02f, 6.45710453e-02f, 3.15805519e-05f, -8.55916813e-02f, -2.53515020e-02f, -1.01904251e-01f, 4.50787842e-02f, 7.01058954e-02f,
  -1.13186529e-02f, -3.44062448e-02f, 5.41311502e-02f, -7.42104428e-04f, 5.41650616e-02f, -1.65758003e-02f, -2.38694325e-02f, 6.84193373e-02f, 6.11239225e-02f, -2.32485943e-02f,
  -6.55750707e-02f, 2.13956591e-02f, -1.65618155e-02f, -1.39012635e-02f, 2.88284905e-02f, 5.72924092e-02f, -9.89690274e-02f, 6.64734617e-02f, 2.72841081e-02f, -1.35392311e-05f,
  -2.73895245e-02f, -5.88192884e-03f, -1.65678486e-02f, 2.86132796e-03f, -4.03970387e-03f, -3.43353339e-02f, -1.47602579e-03f, -5.38181812e-02f, 5.27612194e-02f, -1.67083908e-02f,
  2.07043558e-01f, -1.07383979e-02f, 9.25364122e-02f, -3.16157332e-03f, 2.26001013e-02f, -9.67473015e-02f, -8.07275549e-02f, -1.09353133e-01f, 5.11702560e-02f, -1.27294566e-02f,
  -4.35495712e-02f, -7.60060623e-02f, -7.99114034e-02f, -3.75335179e-02f, 1.35095507e-01f, -5.84686399e-02f, 2.75426395e-02f, 9.30326656e-02f, 1.02149118e-02f, -1.29093798e-02f,
  -2.05859020e-02f, 2.57586502e-02f, 2.21980754e-02f, 1.95534497e-01f, 1.31037071e-01f, -3.25457333e-03f, 2.08159685e-02f, -2.65396815e-02f, 3.87381800e-02f, 1.19380280e-01f,
  -3.20702046e-02f, -8.20918828e-02f, 5.94068654e-02f, 4.57266010e-02f, 1.13902809e-02f, 9.12687927e-03f, -5.76303490e-02f, -4.65145819e-02f, -4.17302288e-02f, -3.41701284e-02f,
  1.24222711e-02f, 1.46761373e-01f, 2.33735949e-01f, 2.01360747e-01f, 9.73573402e-02f, 1.29037246e-01f, 5.85849434e-02f, 5.33044897e-02f, 1.32232994e-01f, -5.79535775e-02f,
  -8.21726397e-02f, 1.67534165e-02f, -6.76303431e-02f, -6.39931336e-02f, -2.21494790e-02f, -2.12755539e-02f, 4.82217818e-02f, -6.69779629e-02f, -6.05243482e-02f, -3.50396521e-02f,
  1.41873255e-01f, -2.96968132e-01f, 9.47495475e-02f, -8.48382339e-02f, -5.22393547e-03f, -3.85482982e-02f, 3.42935659e-02f, 4.05914038e-02f, -1.04938231e-01f, -8.91503692e-02f,
  -1.13069721e-01f, -5.82093894e-02f, -5.18772565e-02f, -3.97800468e-02f, -4.35014628e-02f, -1.07743189e-01f, -6.63185641e-02f, -4.02392931e-02f, 3.75916436e-02f, -1.62746370e-01f,
  -1.39878169e-01f, -1.19950794e-01f, -1.60841495e-02f, -5.85479327e-02f, -8.70822743e-02f, -9.56787728e-03f, -5.41769676e-02f, -1.17993884e-01f, -3.86511348e-02f, -6.21338636e-02f,
  2.91596912e-02f, 1.10550504e-02f, -4.42767069e-02f, 1.66308340e-02f, 1.19856879e-01f, 5.93233928e-02f, 1.36261890e-02f, 7.29414076e-02f, 4.60968874e-02f, 1.58836972e-02f,
  -6.87601417e-03f, -9.28134378e-03f, 4.34029438e-02f, 4.96053323e-02f, 3.06118727e-02f, -7.10990652e-02f, -4.05410044e-02f, 2.76490878e-02f, -1.73405372e-02f, -1.06022410e-01f,
  -1.66708604e-02f, -3.61622050e-02f, 3.33356112e-02f, -5.96491136e-02f, -7.86892772e-02f, 1.96599346e-02f, 4.11814936e-02f, 2.45049433e-03f, -4.00464460e-02f, -1.90665610e-02f,
  3.02687019e-01f, 9.81087983e-02f, 1.26307741e-01f, 2.65100617e-02f, -2.58819684e-02f, -4.66368645e-02f, 5.72690479e-02f, 1.03140268e-02f, -9.44017395e-02f, -3.49763148e-02f,
  -3.91863100e-02f, -2.33496968e-02f, 5.90564124e-02f, -8.25211685e-03f, 2.21916977e-02f, 1.64128910e-03f, 5.41734956e-02f, 2.74735522e-02f, 5.05140871e-02f, -4.02305909e-02f,
  -7.71972314e-02f, 1.36910319e-01f, 2.59104073e-01f, 1.83495343e-01f, 4.26975228e-02f, 1.96417645e-01f, 1.02089494e-01f, 8.08246955e-02f, 1.42953098e-01f, 1.58048883e-01f,
  3.46304253e-02f, -1.45682484e-01f, -9.77424607e-02f, -1.50357485e-01f, -1.43916830e-01f, -1.01651326e-01f, -7.30294660e-02f, -9.93580073e-02f, -1.78499058e-01f, -1.47229865e-01f,
  -4.71281679e-03f, 7.63087273e-02f, 7.04386607e-02f, 1.29739165e-01f, 7.00490084e-03f, -3.49929221e-02f, -6.96198046e-02f, 1.40404120e-01f, 9.15501788e-02f, 1.57758519e-02f,
  -1.41683549e-01f, -7.80041739e-02f, -3.57190445e-02f, -3.56205441e-02f, -2.11864173e-01f, 2.10979711e-02f, -8.66430253e-02f, -6.27213418e-02f, -9.21355560e-02f, -2.25624666e-01f,
  -3.83109599e-02f, 3.69784348e-02f, 3.44776213e-02f, 7.38662332e-02f, -8.64890590e-02f, -7.01429471e-02f, 6.24495074e-02f, 1.35742305e-02f, -3.84499058e-02f, -1.00078098e-01f,
  4.22428437e-02f, -1.38725368e-02f, 6.63212761e-02f, -3.27349603e-02f, -3.73313576e-02f, -2.29370501e-02f, 5.81919029e-02f, -3.51016666e-03f, 5.30077405e-02f, -9.70291197e-02f,
  -1.29755199e-01f, -9.45055410e-02f, -4.28854264e-02f, 3.19914334e-02f, -2.24330891e-02f, 1.01485997e-01f, 2.41835471e-02f, -9.50590670e-02f, 1.40469586e-02f, -6.77619725e-02f,
  -1.08895134e-02f, 1.27007039e-02f, -3.20475437e-02f, -5.35106510e-02f, 6.31196722e-02f, -5.21654300e-02f, 5.34957554e-03f, 2.39780694e-02f, -2.47624721e-02f, -8.51895213e-02f,
  2.90565845e-02f, 4.74668071e-02f, -6.66546300e-02f, -1.08236551e-01f, -7.86063448e-02f, -6.03080057e-02f, 4.94045578e-02f, -1.19314184e-02f, -4.88582514e-02f, 8.48553032e-02f,
  6.96306676e-02f, -2.69835908e-02f, -7.56820962e-02f, 4.54511084e-02f, 1.64567418e-02f, 2.93219630e-02f, -1.69257745e-02f, 1.75861139e-02f, -3.86190377e-02f, -4.81177606e-02f,
  -7.55048990e-02f, 2.34714553e-01f, 2.86871567e-02f, 2.60377657e-02f, 4.52599078e-02f, -7.80832022e-02f, 1.90051068e-02f, 1.98329501e-02f, 4.62788530e-02f, -4.85924259e-02f,
  1.08231291e-01f, 1.13236494e-02f, -6.55554682e-02f, 6.07663952e-02f, -9.67863351e-02f, 3.65120471e-02f, -1.06240928e-01f, -3.43045890e-02f, -3.52361836e-02f, -7.13903084e-02f,
  -6.31668121e-02f, -4.20103483e-02f, -3.80348712e-02f, -7.33462572e-02f, -1.02332197e-01f, 1.10625461e-01f, 6.91364855e-02f, -3.07080951e-02f, -9.17724054e-03f, -1.25359431e-01f,
  2.45559350e-01f, 5.12592169e-03f, 2.85793304e-01f, 7.20262155e-02f, -2.43352696e-01f, -2.47869402e-01f, -3.09429914e-01f, -2.46412735e-02f, 2.83450857e-02f, -9.23209488e-02f,
  -7.81110749e-02f, -1.08870126e-01f, 4.47414331e-02f, 1.07260779e-01f, 3.65253687e-02f, -3.02154887e-02f, 1.28093911e-02f, 1.87866613e-01f, 4.61543687e-02f, 5.13968244e-02f,
  -7.86613896e-02f, 1.40103728e-01f, 2.15253726e-01f, 1.84574336e-01f, 1.80539917e-02f, -1.80489849e-02f, 7.82811940e-02f, 1.28256857e-01f, -5.21189086e-02f, 1.36387900e-01f,
  6.61070570e-02f, 1.57087013e-01f, 9.38515924e-03f, -1.31844014e-01f, 3.97130586e-02f, -4.17821966e-02f, -9.68074203e-02f, 1.45232290e-01f, -6.19292594e-02f, -4.93226349e-02f,
  1.70204472e-02f, 7.82097206e-02f, 4.72259186e-02f, -1.41328722e-02f, -6.33172318e-03f, 6.21566065e-02f, 3.03859962e-03f, 1.29319817e-01f, 1.47585928e-01f, 7.36285150e-02f,
  -1.15389705e-01f, -8.01525712e-02f, -2.19131149e-02f, -2.48388182e-02f, -5.66649623e-02f, -2.51665059e-02f, 3.58495973e-02f, 2.14502495e-02f, 3.68729569e-02f, -4.72730249e-02f,
  -1.78456884e-02f, 8.72004032e-03f, -2.25410797e-02f, -2.09483821e-02f, 2.46495530e-02f, 3.22025381e-02f, 1.34624774e-02f, -5.44231310e-02f, -1.51751135e-02f, 7.25951493e-02f,
  -2.38279644e-02f, -1.00866249e-02f, 1.78365149e-02f, 4.41688336e-02f, -5.51449247e-02f, 7.34638646e-02f, -4.21073623e-02f, 3.06744538e-02f, 3.24199796e-02f, 7.54098371e-02f,
  2.54807100e-02f, 1.12065345e-01f, -5.82282580e-02f, 1.13372639e-01f, -4.31583598e-02f, -3.26185040e-02f, -4.34308797e-02f, -2.95147300e-02f, 5.89534082e-02f, 7.19012469e-02f,
  -1.83565900e-01f, 9.35849547e-03f, -7.79905096e-02f, 6.18188307e-02f, -7.15815276e-02f, 8.35121721e-02f, -4.00175788e-02f, -2.95076333e-02f, 4.61216569e-02f, -5.05558811e-02f,
  -1.98215246e-02f, -4.03180458e-02f, -7.63019547e-02f, -6.21606857e-02f, -8.96393880e-02f, -8.84664059e-02f, 1.24381650e-02f, -7.89854489e-03f, -3.80868316e-02f, -1.18044592e-01f,
  -1.14563882e-01f, -1.39489919e-01f, -1.65847212e-01f, -1.78108618e-01f, -9.66384411e-02f, -6.69965893e-02f, -1.27528861e-01f, -1.38142914e-01f, -2.04534590e-01f, -1.97418034e-01f,
  1.84273049e-01f, -1.34489487e-03f, 6.26725554e-02f, 3.62152979e-03f, -1.45358875e-01f, 2.36469228e-02f, -6.72025904e-02f, -3.29009853e-02f, 2.55499799e-02f, 1.15760274e-01f,
  -1.03232805e-02f, 2.37351228e-02f, 2.58211531e-02f, 2.01822519e-02f, 1.06301583e-01f, 1.20038450e-01f, 1.31871994e-03f, 9.27414149e-02f, 8.93278643e-02f, 9.52491611e-02f,
  8.48545507e-02f, 2.49395296e-02f, 1.14770412e-01f, 1.61905870e-01f, 1.18287489e-01f, 1.19381867e-01f, -1.04908505e-02f, 1.46650691e-02f, -3.55389453e-02f, 6.90799505e-02f,
  -3.28358673e-02f, -6.92320541e-02f, -2.70731859e-02f, -5.98457940e-02f, -1.00318290e-01f, 1.29172519e-01f, 6.90194685e-03f, 6.28364906e-02f, 4.01375070e-02f, -3.74314785e-02f,
  -3.74776609e-02f, 9.66744497e-03f, 3.00243776e-02f, 2.95366831e-02f, 2.97462177e-02f, -1.12597756e-01f, -2.60430593e-02f, 5.54607213e-02f, 6.65446669e-02f, -2.16130801e-02f,
  3.65409665e-02f, -1.14788212e-01f, -9.00463089e-02f, -1.53915703e-01f, 1.56828593e-02f, -1.14282660e-01f, -1.34239778e-01f, -4.15761322e-02f, -8.40223432e-02f, 5.32117449e-02f,
  -6.19425476e-02f, 1.75787751e-02f, 7.13624358e-02f, 3.57905701e-02f, 7.33026415e-02f, -1.87161304e-02f, -4.18430902e-02f, -3.26128341e-02f, 6.65893480e-02f, -6.45106584e-02f,
  6.46904111e-02f, -7.22596794e-02f, 1.96203170e-03f, 5.78604639e-03f, 9.36860517e-02f, -3.52504849e-02f, -1.40651632e-02f, -4.25372608e-02f, -3.33016515e-02f, -7.83600882e-02f,
  4.16003056e-02f, 8.01734254e-02f, -3.40683423e-02f, -1.11470679e-02f, -1.91068614e-03f, -4.34615500e-02f, 7.60962516e-02f, -9.22349393e-02f, 3.18648741e-02f, -6.70225322e-02f,
  9.85204242e-03f, -1.42457947e-01f, 1.53704882e-01f, 5.87303378e-02f, 4.82619144e-02f, 1.89540237e-02f, -6.89290911e-02f, -1.09140366e-01f, 6.73570065e-03f, 2.84041315e-02f,
  -5.61948791e-02f, 6.81182817e-02f, -2.25260053e-02f, -4.10428271e-02f, -4.26049903e-02f, 3.38533483e-02f, -3.02526983e-03f, 5.29498011e-02f, 1.79214962e-03f, -5.95239103e-02f,
  -1.49885716e-03f, 8.31814110e-02f, -4.87905368e-02f, -2.75161006e-02f, 6.45277128e-02f, 3.36056352e-02f, 4.98698615e-02f, 7.18866438e-02f, 1.49200633e-02f, 1.37378931e-01f,
  1.91121191e-01f, -2.11401701e-01f, -2.99312651e-01f, -2.96008866e-02f, -1.66031659e-01f, -2.42494971e-01f, -3.00720096e-01f, -1.03932463e-01f, 2.17200425e-02f, -2.01774091e-01f,
  7.31067918e-03f, 7.01821670e-02f, -2.40628682e-02f, -8.75160918e-02f, -9.89970937e-02f, -3.42739552e-01f, -2.70266473e-01f, -2.07339197e-01f, -1.65094644e-01f, -6.89672008e-02f,
  -8.61224532e-02f, 5.47576733e-02f, 2.72023352e-03f, -5.95271727e-03f, 9.01487470e-02f, 2.25872197e-03f, -2.57387962e-02f, -3.15954536e-02f, -9.37892646e-02f, -7.82143325e-02f,
  1.91021301e-02f, -2.01459192e-02f, -1.26280189e-02f, 6.78199232e-02f, 4.30092365e-02f, 5.19693196e-02f, -1.00770213e-01f, -1.11551825e-02f, -2.03624945e-02f, -6.42350540e-02f,
  -4.56831083e-02f, -3.64187546e-02f, 1.12409838e-01f, -7.28259906e-02f, -8.18207487e-02f, 4.09785360e-02f, 2.63955407e-02f, -1.08289860e-01f, -1.39942646e-01f, -5.39565720e-02f,
  2.07488947e-02f, 3.41185443e-02f, -1.69680696e-02f, -6.51256293e-02f, 1.68415271e-02f, 5.24397381e-02f, -3.70159447e-02f, 3.53434496e-02f, 9.07896738e-03f, -5.97426109e-02f,
  -4.39897254e-02f, -2.40174402e-02f, -7.46299773e-02f, 1.15046119e-02f, 2.09086519e-02f, -2.91750934e-02f, -1.51932742e-02f, -5.13342731e-02f, 2.36310754e-02f, -3.84679064e-02f,
  4.65985499e-02f, -1.36912372e-02f, 6.55667409e-02f, -3.01644485e-02f, -4.31280769e-02f, 2.08982490e-02f, -1.13507941e-01f, 2.48044133e-02f, -1.05228936e-02f, -7.23520070e-02f,
  -4.21174727e-02f, 3.77827883e-02f, -5.11586480e-02f, -3.53681110e-02f, -4.13078889e-02f, -3.18924598e-02f, 5.09133227e-02f, -1.95161458e-02f, 9.43310708e-02f, 1.50580574e-02f,
  2.08355039e-01f, -1.44727647e-01f, 4.31102365e-02f, -4.28054072e-02f, -7.84360524e-03f, 3.86216156e-02f, -6.15534633e-02f, 1.25557417e-02f, 8.92029852e-02f, -7.65356347e-02f,
  6.77296221e-02f, 7.13580251e-02f, 1.91141963e-02f, 1.65061082e-03f, 5.20012267e-02f, -4.01882874e-03f, -7.58575350e-02f, 5.45245670e-02f, -2.31231339e-02f, -7.84236193e-02f,
  -9.94628072e-02f, -5.92024513e-02f, 3.58040817e-03f, -2.72955038e-02f, -2.98168510e-02f, 2.67974362e-02f, 5.96109405e-02f, -5.51317446e-02f, -7.52141103e-02f, -3.86105739e-02f,
  4.27600324e-01f, 3.36900949e-02f, 1.71941176e-01f, -3.98083143e-02f, -1.19580343e-01f, -9.44273099e-02f, -4.98092547e-02f, 1.38409194e-02f, 1.18316837e-01f, 1.14431649e-01f,
  6.07692078e-02f, -4.92969975e-02f, 3.60349156e-02f, 1.39026463e-01f, 2.11368814e-01f, 1.39686037e-02f, -2.64101066e-02f, 2.26340353e-01f, 7.19543993e-02f, 2.91015338e-02f,
  2.92054992e-02f, 8.48421305e-02f, 9.62731019e-02f, 1.59944445e-01f, -3.34851108e-02f, -4.00100499e-02f, 3.25779407e-03f, 2.63662226e-02f, 5.13380840e-02f, 7.90273845e-02f,
  4.46334034e-02f, 2.34396547e-01f, 1.11976694e-02f, 8.39844048e-02f, 4.19783220e-02f, 1.34265020e-01f, 8.73434357e-03f, 1.18606716e-01f, -2.56747175e-02f, 1.19135166e-02f,
  4.48428355e-02f, 3.40539776e-02f, -4.14845563e-04f, 8.54263157e-02f, -6.11042716e-02f, -1.96052399e-02f, 5.22174127e-02f, 1.29058406e-01f, 1.21952876e-01f, 7.88382068e-02f,
  -1.14209034e-01f, -1.23930566e-01f, -1.77224483e-02f, -1.15139168e-02f, -1.67452230e-03f, 3.41284797e-02f, 5.60229383e-02f, -3.22632641e-02f, 4.70079295e-02f, 7.16123506e-02f,
  -4.32630442e-02f, 3.02586034e-02f, 8.51300731e-02f, -6.15284145e-02f, -1.03159621e-02f, 9.11842659e-03f, -1.23557113e-01f, -5.15825755e-04f, -7.38334656e-02f, 5.84064722e-02f,
  2.12122705e-02f, -9.37925950e-02f, 4.29751091e-02f, -4.71246652e-02f, 1.56211127e-02f, -5.95742390e-02f, -3.50823142e-02f, -7.62033314e-02f, 4.72194934e-03f, -4.51607034e-02f,
  8.07249770e-02f, 3.78059484e-02f, -8.02709609e-02f, -5.63257411e-02f, -9.00515821e-03f, 2.02473532e-02f, -1.46700228e-02f, -5.53293005e-02f, -2.13585310e-02f, 6.89265726e-04f,
  -1.63385227e-01f, -1.23365097e-01f, 1.51664549e-02f, 2.11334433e-02f, -3.80884074e-02f, 3.47029194e-02f, 5.09812534e-02f, 4.22457531e-02f, -8.66760463e-02f, 7.27849677e-02f,
  -1.18628472e-01f, 1.23077691e-01f, 7.00001419e-02f, 2.35398505e-02f, 2.58201297e-04f, -1.09582864e-01f, -6.26827776e-02f, -1.47104068e-02f, -1.43177910e-02f, -8.42844043e-03f,
  -5.88126630e-02f, -1.07526578e-01f, -7.87733961e-03f, -1.20216474e-01f, -1.04377665e-01f, -1.37958014e-02f, -4.48974706e-02f, -5.62432371e-02f, 3.36076319e-02f, -1.00779638e-01f,
  1.05968632e-01f, 1.47004128e-01f, -2.07824200e-01f, -3.66040766e-02f, -1.45913467e-01f, -1.55013815e-01f, -5.88061810e-02f, 3.26171964e-02f, 1.21024869e-01f, 8.21217075e-02f,
  -3.48563259e-03f, -4.07053828e-02f, -7.62998909e-02f, 8.12500715e-02f, -1.27588762e-02f, -2.50996370e-02f, -2.17521526e-02f, -9.00941044e-02f, -1.42511114e-01f, 6.23832494e-02f,
  9.17230025e-02f, 1.38099045e-01f, 7.62888789e-02f, 6.77888244e-02f, 1.46517605e-01f, 9.00711119e-03f, -8.28988627e-02f, -4.63684872e-02f, -1.04924567e-01f, 7.18538389e-02f,
  -1.29974186e-01f, -1.52380094e-01f, 2.84177475e-02f, -3.53064127e-02f, 3.48104909e-02f, 8.65318328e-02f, -6.43232092e-02f, 3.89506370e-02f, -6.15028888e-02f, 1.00976355e-01f,
  -2.52839699e-02f, -6.51381537e-02f, -5.57875447e-02f, 1.27607444e-02f, -7.61110112e-02f, 5.10407239e-03f, 1.15760580e-01f, -4.00475189e-02f, -5.95093891e-02f, -7.23673552e-02f,
  8.53138790e-02f, -9.34017152e-02f, -1.98570341e-01f, -7.77075216e-02f, 1.78209934e-02f, -1.47288531e-01f, -2.49317754e-02f, -2.53132917e-02f, -2.56109107e-02f, 7.58102611e-02f,
  -1.86092919e-03f, -3.26762050e-02f, -6.67977482e-02f, 2.63478374e-03f, 1.21205226e-01f, 6.79675862e-02f, 7.56529905e-03f, 9.53982472e-02f, 4.28902656e-02f, 1.07051902e-01f,
  -3.18375230e-02f, 2.54281051e-02f, -4.12109420e-02f, -2.35000737e-02f, 8.97058938e-03f, 2.35191323e-02f, 2.82108672e-02f, 6.72705099e-02f, 7.72562623e-02f, -5.50796166e-02f,
  5.73247857e-03f, -7.08742961e-02f, 2.34325062e-02f, -9.38358344e-03f, -4.15857248e-02f, 7.48525113e-02f, -4.50014509e-02f, 8.26095045e-02f, -4.12561651e-03f, -1.00547746e-01f,
  8.01078379e-02f, -2.06415325e-01f, -1.98053420e-02f, -2.31629275e-02f, -1.36642950e-03f, -7.40873022e-03f, 6.36258274e-02f, -8.63286387e-03f, -6.85137436e-02f, -6.65679052e-02f,
  4.10476103e-02f, 2.27215551e-02f, 5.48279583e-02f, 8.07484612e-02f, -5.63714281e-02f, 3.13223340e-02f, 5.03974333e-02f, -3.42425816e-02f, 4.62265387e-02f, 3.45924025e-04f,
  1.13624044e-01f, -6.21531941e-02f, -1.03481703e-01f, -1.08820513e-01f, 4.47508022e-02f, -5.27856052e-02f, 4.46217395e-02f, -3.14316563e-02f, -1.79942567e-02f, 5.36525622e-02f,
  -1.01334333e-01f, -2.68591065e-02f, -8.49289000e-02f, -7.23764375e-02f, -8.02863538e-02f, -4.48488630e-02f, -1.15524316e-02f, -7.08224550e-02f, -1.60058245e-01f, -6.43899888e-02f,
  -2.95096096e-02f, -1.47314332e-02f, 1.32759763e-02f, 8.88244435e-02f, 7.99412727e-02f, 2.42586769e-02f, -6.36192784e-02f, -1.49003202e-02f, -5.38888201e-02f, -1.01989485e-01f,
  -1.17130689e-02f, -1.30179390e-01f, 1.17879352e-02f, -2.12044362e-02f, -8.97903144e-02f, -8.98835286e-02f, -7.49313179e-03f, -6.60647750e-02f, -4.03735153e-02f, -1.03658922e-01f,
  -7.90451095e-02f, -9.19382721e-02f, -3.64950299e-02f, 4.70565259e-02f, 8.99493694e-03f, -5.20690903e-02f, 2.75950227e-02f, -6.96586967e-02f, -3.90450731e-02f, -2.07291413e-02f,
  -2.93784793e-02f, -1.20768845e-02f, -5.98266944e-02f, 5.51382788e-02f, -4.62964363e-02f, 3.62742059e-02f, 3.42403427e-02f, -1.00283474e-02f, 1.35463923e-02f, 7.85612240e-02f,
  -9.66965221e-03f, 7.74096400e-02f, 2.90193558e-02f, -4.95924987e-02f, 3.70491855e-02f, 1.03859052e-01f, -9.27208364e-03f, -8.08257014e-02f, -3.19320746e-02f, -8.64565894e-02f,
  3.06854248e-02f, 2.94813272e-02f, 7.44207799e-02f, 3.01434491e-02f, -1.35430275e-02f, 2.47490965e-02f, 5.94295152e-02f, -5.69915399e-02f, 2.61842199e-02f, 2.05101632e-02f,
  -3.07272505e-02f, 7.10073337e-02f, 1.59394871e-02f, -3.13229859e-02f, 7.32207969e-02f, 2.92351525e-02f, 7.07555339e-02f, 9.86296833e-02f, 5.24005853e-02f, 8.84981826e-03f,
  -5.81895597e-02f, 8.02753270e-02f, -7.85714611e-02f, -3.35275419e-02f, 4.57456410e-02f, -4.05602381e-02f, 3.77805382e-02f, -3.63639966e-02f, 8.95029828e-02f, 9.62272845e-03f,
  -1.86191142e-01f, 2.62553275e-01f, -7.33090192e-02f, -5.66142164e-02f, -2.96538067e-03f, 6.81575909e-02f, -5.55356331e-02f, -5.23079447e-02f, -1.02852814e-01f, 1.51396021e-02f,
  -6.79512024e-02f, -8.16430822e-02f, 4.03742194e-02f, 5.40485196e-02f, 4.25720327e-02f, -3.60887498e-02f, 7.58161843e-02f, 4.43529114e-02f, 2.99665201e-02f, 7.68328551e-03f,
  5.56618199e-02f, 8.47482160e-02f, -5.25164306e-02f, 1.01049282e-01f, 5.50705567e-02f, 1.83889142e-03f, -4.73904945e-02f, 4.15703747e-04f, 3.59455645e-02f, -6.96732942e-03f,
  -5.59616089e-02f, 7.24998638e-02f, -1.68736856e-02f, 6.04979694e-02f, 6.64207488e-02f, -1.43732028e-02f, 2.95229331e-02f, 1.24332376e-01f, 1.12476470e-02f, 7.18493015e-02f,
  1.19935960e-01f, 5.55571504e-02f, 1.97905988e-01f, 3.35408561e-02f, 2.67770141e-02f, 3.22770327e-02f, 4.51420248e-02f, 9.59914774e-02f, 1.12263761e-01f, 8.67158622e-02f,
  6.11263663e-02f, 4.08584401e-02f, 4.26037312e-02f, -3.05162892e-02f, -1.18915951e-02f, 1.05000854e-01f, -4.13963273e-02f, -3.04742232e-02f, 2.25238018e-02f, -1.13782786e-01f,
  2.20624000e-01f, 4.75606062e-02f, 5.03413845e-03f, -2.41288487e-02f, 7.26797245e-03f, 2.41482593e-02f, 1.29222550e-04f, -1.40670508e-01f, -1.26819342e-01f, -5.35175875e-02f,
  5.05928695e-02f, 5.64559959e-02f, -8.25999007e-02f, -1.22639805e-01f, -6.98342696e-02f, 6.02150187e-02f, -1.59906801e-02f, 4.67232205e-02f, 2.24945657e-02f, 1.62078310e-02f,
  -7.30887502e-02f, -2.93992693e-03f, -4.31257114e-02f, -4.62265089e-02f, 9.13665593e-02f, -1.49644061e-03f, 8.16337541e-02f, -6.03455603e-02f, 6.69669658e-02f, 1.60260424e-02f,
  1.02785334e-01f, 7.14337006e-02f, 3.97487879e-02f, 8.16662237e-03f, -3.08258794e-02f, -4.93363775e-02f, 1.02441804e-02f, 6.65058270e-02f, 2.19030306e-02f, -1.44053204e-03f,
  2.24293638e-02f, -1.22324927e-02f, 1.17235534e-01f, -2.79174484e-02f, -4.10564281e-02f, -7.58299455e-02f, -4.00785729e-02f, -2.87424028e-02f, -1.74710788e-02f, -4.61595245e-02f,
  -4.67752386e-03f, 7.86174729e-04f, 2.91599855e-02f, -5.48237562e-02f, 2.28459816e-02f, -5.50477300e-03f, -1.64959636e-02f, -9.29128510e-05f, 6.50868937e-02f, -1.08052939e-01f,
  4.46903855e-02f, 7.42679313e-02f, 1.55421980e-02f, -6.12432323e-02f, -1.17593162e-01f, -3.59291285e-02f, 1.01808779e-01f, -1.25072062e-01f, -5.15679196e-02f, 2.57214569e-02f,
  1.26599502e-02f, -2.56631081e-03f, -3.21630202e-02f, 5.40877283e-02f, -8.17027390e-02f, -4.43814620e-02f, -1.15440592e-01f, 7.67636150e-02f, -1.24867186e-01f, -1.06695911e-03f,
  3.87493670e-02f, -1.57805048e-02f, -4.41474579e-02f, -9.24516411e-04f, 1.42359212e-02f, 9.00098607e-02f, -3.94013114e-02f, 2.96145622e-02f, 9.21944678e-02f, 1.15286512e-02f,
  3.71729314e-01f, -4.47777480e-01f, -5.99789806e-02f, -2.93402523e-02f, -6.62562698e-02f, 6.27541840e-02f, -5.60460202e-02f, -1.09836990e-02f, 8.38587433e-03f, -1.99819371e-01f,
  -1.54382229e-01f, 7.69108385e-02f, 9.49944258e-02f, 1.09070562e-01f, 1.36623532e-01f, -1.49677768e-01f, -8.66835341e-02f, 1.33094847e-01f, 3.66182446e-01f, 1.72680318e-02f,
  -2.91550830e-02f, -2.26285271e-02f, 6.86755776e-02f, 6.53186291e-02f, -2.38871187e-01f, -7.43200406e-02f, -1.42855436e-01f, -1.28517926e-01f, -1.54005930e-01f, -2.19262645e-01f,
  -1.55624732e-01f, -7.17511848e-02f, 1.23490751e-01f, 4.63656560e-02f, -1.29895195e-01f, -7.18493760e-03f, 2.90841963e-02f, 2.82854903e-02f, -7.04127327e-02f, -4.52449620e-02f,
  -7.41238967e-02f, 4.20346856e-02f, 2.25343704e-02f, -7.51280189e-02f, -2.43107975e-02f, 7.07562417e-02f, -1.51168159e-03f, 7.39059523e-02f, -8.84222463e-02f, -1.88972458e-01f,
  -1.92889631e-01f, -3.63757089e-02f, 5.55056073e-02f, 1.36893811e-02f, 9.07648876e-02f, 7.06320480e-02f, -1.86073463e-02f, -4.07236442e-02f, 4.16228212e-02f, -2.35602502e-02f,
  -8.92098397e-02f, 5.87908849e-02f, -3.67135555e-03f, -2.79696961e-03f, 6.03402890e-02f, -3.90097164e-02f, 8.55688155e-02f, 2.20931005e-02f, 9.47631299e-02f, -3.11336573e-02f,
  4.14203070e-02f, -8.24782997e-02f, 4.69557494e-02f, -1.50105695e-03f, -5.34284003e-02f, 9.03457627e-02f, -3.23212370e-02f, -4.67130020e-02f, -2.96976008e-02f, 2.97226086e-02f,
  -3.33147906e-02f, 1.80629566e-02f, -2.53994856e-02f, -3.56464311e-02f, -5.10466695e-02f, -3.12867127e-02f, -5.94744831e-02f, 4.45245616e-02f, 2.09936011e-03f, 3.56572792e-02f,
  -4.04509977e-02f, 1.91768065e-01f, 8.66995528e-02f, 8.44533890e-02f, 1.17947254e-02f, -2.26293746e-02f, 2.07941327e-02f, -8.71388316e-02f, -5.37958555e-02f, -4.77715731e-02f,
  -1.02409080e-01f, 4.75912131e-02f, -8.89897794e-02f, -7.81246498e-02f, 8.94305781e-02f, 1.48492321e-01f, -8.87201875e-02f, 1.78300384e-02f, 5.30996509e-02f, -8.13522860e-02f,
  -1.15782708e-01f, 1.79456875e-01f, 2.01898128e-01f, 1.54738396e-01f, 8.72329995e-02f, 2.19145209e-01f, 7.37795159e-02f, 7.24527463e-02f, 1.63201734e-01f, 3.31598856e-02f,
  -4.23168480e-01f, -3.05939138e-01f, -6.61138911e-03f, 6.47837743e-02f, 1.99996657e-03f, -1.70287877e-01f, -1.40471309e-01f, -1.40283361e-01f, -7.53010735e-02f, -5.22017144e-02f,
  -4.47979197e-02f, -2.22859923e-02f, 1.08005114e-01f, 8.53503644e-02f, 9.24691260e-02f, -4.95192483e-02f, 1.69223100e-01f, 2.30458871e-01f, 9.86324176e-02f, -5.05488031e-02f,
  5.16616851e-02f, 1.48351640e-01f, 1.94169819e-01f, 2.05175862e-01f, 1.38533980e-01f, 7.86006600e-02f, 1.57507598e-01f, 1.14529870e-01f, -5.14606684e-02f, 1.05335619e-02f,
  -2.43897662e-01f, -3.16135973e-01f, 1.22252874e-01f, 1.32516101e-02f, 5.98531626e-02f, -5.71725443e-02f, -1.35948926e-01f, 4.80679981e-02f, 1.94496363e-02f, -2.18443479e-02f,
  6.86320513e-02f, -4.24181931e-02f, -3.69952596e-03f, -7.78992921e-02f, -2.77555995e-02f, -8.89063105e-02f, 7.04717562e-02f, 1.58609748e-02f, -5.13069853e-02f, -1.68017164e-01f,
  -8.07269756e-03f, 1.76134668e-02f, -1.10239908e-01f, -1.72439460e-02f, -1.32795647e-01f, 8.45924541e-02f, -7.02386051e-02f, -1.76339671e-01f, -1.52368084e-01f, -2.36627758e-01f,
  -2.87449993e-02f, 4.54819575e-02f, -4.76545431e-02f, -3.43261436e-02f, 6.33847564e-02f, 2.89137568e-02f, 4.92169820e-02f, 4.73452499e-03f, -6.04759790e-02f, 3.39599024e-03f,
  5.18629514e-02f, -6.22668043e-02f, 6.47091344e-02f, 6.75849430e-03f, 1.12479463e-01f, 6.39330596e-02f, 3.73791829e-02f, 4.80995933e-03f, 1.03487968e-01f, -6.02239892e-02f,
  -6.12297542e-02f, -6.39687255e-02f, 5.87548241e-02f, 2.21979916e-02f, -3.05552091e-02f, 1.43178795e-02f, -7.66522512e-02f, -3.72759178e-02f, -5.35404049e-02f, 2.36838590e-02f,
  -5.36560193e-02f, 1.83079377e-01f, -1.47312820e-01f, -4.27195691e-02f, 8.71178601e-03f, 3.57491821e-02f, -1.89403128e-02f, -3.49907838e-02f, -2.89285332e-02f, -5.83983473e-02f,
  -1.26475871e-01f, -7.01441467e-02f, -9.10232440e-02f, 2.31896713e-02f, -6.28915557e-04f, -7.41197318e-02f, 2.08895747e-02f, 3.50547470e-02f, -7.65464082e-02f, -1.34834990e-01f,
  -1.46408696e-02f, -1.61957681e-01f, -2.42587760e-01f, -1.91926628e-01f, -1.40835747e-01f, -7.83823580e-02f, -7.63707086e-02f, -5.72930053e-02f, -1.41219005e-01f, -1.61567837e-01f,
  1.10139363e-01f, -1.08607449e-01f, 5.52493855e-02f, 1.03375100e-01f, 1.02450855e-01f, 8.19582939e-02f, 1.26109540e-01f, 3.89718227e-02f, -3.71391289e-02f, 1.25256494e-01f,
  -6.75219893e-02f, -1.06136195e-01f, -1.76548570e-01f, -8.67145509e-02f, -1.50865465e-01f, 1.09780736e-01f, 1.05731860e-01f, -2.36429088e-02f, 6.35167509e-02f, 6.74023554e-02f,
  2.20605265e-02f, 8.94241873e-03f, -2.97661331e-02f, -3.32282186e-02f, 6.48590028e-02f, 4.78245728e-02f, -3.80322449e-02f, -9.47267339e-02f, -1.70480102e-01f, 7.98428133e-02f,
  2.77250916e-01f, -1.74882397e-01f, 6.65877238e-02f, -2.14673772e-01f, -1.58376306e-01f, 3.53056341e-02f, -1.34832934e-02f, -1.24489948e-01f, -7.03317523e-02f, 1.08740814e-01f,
  -1.42935663e-01f, -9.69933048e-02f, -1.20037720e-01f, 4.48305234e-02f, -8.00331216e-03f, 7.87676722e-02f, -9.81832892e-02f, -3.99534404e-02f, -1.34248704e-01f, -5.86806461e-02f,
  -1.21679038e-01f, -3.60428840e-02f, 2.01661494e-02f, -9.34387073e-02f, -1.99934319e-01f, -2.84033772e-02f, -4.38101180e-02f, -1.08527288e-01f, -8.05802643e-02f, 1.68364853e-01f,
  7.73683004e-03f, 3.65753248e-02f, -3.87942418e-02f, -2.19784193e-02f, 6.39077574e-02f, -3.54608558e-02f, 1.17007688e-01f, 8.10648277e-02f, 5.56418635e-02f, -9.51382425e-03f,
  8.80630105e-04f, 5.63134626e-03f, 4.66630943e-02f, 6.36979714e-02f, 4.41467017e-02f, -7.46125951e-02f, 4.48447280e-02f, 3.39384526e-02f, -6.43299595e-02f, 8.28929711e-03f,
  -6.41165525e-02f, -3.87907773e-02f, 8.30700547e-02f, -2.57034041e-03f, -8.65280554e-02f, -1.27626896e-01f, 4.79775108e-02f, -7.60961920e-02f, -5.50487377e-02f, 3.51302661e-02f,
  4.16476935e-01f, -3.20404410e-01f, 5.48516475e-02f, -7.73224384e-02f, 6.69506490e-02f, -4.51765880e-02f, 3.24680507e-02f, 1.79748901e-03f, -2.79523637e-02f, 3.00035514e-02f,
  -1.28634825e-01f, -3.57799456e-02f, 9.85410213e-02f, 7.51397526e-03f, 1.75943300e-01f, 1.37214512e-01f, -9.52854082e-02f, 1.36740766e-02f, -6.53798133e-02f, -6.20595217e-02f,
  1.70300156e-02f, 1.55990228e-01f, 2.61405647e-01f, 5.32789938e-02f, -5.49790263e-02f, 5.19187599e-02f, 1.15473092e-01f, 1.94951579e-01f, 1.39555171e-01f, 4.70687449e-01f,
  -2.58845508e-01f, 1.53616173e-02f, -2.17414841e-01f, -2.03615159e-01f, -1.18711464e-01f, 1.41045451e-01f, 2.88483441e-01f, 1.33845598e-01f, -7.01701865e-02f, 3.28065120e-02f,
  -1.09895673e-02f, -7.65774325e-02f, -1.37037277e-01f, 7.70915300e-02f, 1.44966677e-01f, 1.14095978e-01f, -9.74717364e-02f, -1.33461446e-01f, -1.03827499e-01f, 2.09619328e-02f,
  3.13934051e-02f, -8.22936669e-02f, -2.67141685e-02f, -1.19898822e-02f, -3.73861305e-02f, -7.05944523e-02f, -1.74453139e-01f, -1.29242823e-01f, -5.10736294e-02f, -1.08274519e-01f,
  -6.33090064e-02f, -1.28329471e-01f, -4.64465469e-02f, -4.63367589e-02f, -1.06209420e-01f, 6.90472312e-03f, 1.59668196e-02f, -9.69276503e-02f, -3.72501872e-02f, -5.26769869e-02f,
  -3.64419892e-02f, 6.89525949e-03f, -1.93697605e-02f, -1.73587855e-02f, 3.82960401e-02f, 2.20297631e-02f, -3.90637927e-02f, 2.60931607e-02f, -8.32239613e-02f, 5.26202582e-02f,
  2.39442680e-02f, -1.13563918e-01f, -1.62249193e-01f, -6.32917881e-02f, -7.24654719e-02f, 7.47783124e-05f, 7.08179995e-02f, -1.16578303e-01f, 3.04138977e-02f, -3.18220258e-02f,
  1.50780365e-01f, -7.93031901e-02f, 5.67210056e-02f, 2.89890300e-02f, -3.83126512e-02f, -6.15026895e-03f, 4.34559472e-02f, -5.41037135e-03f, 2.10872944e-02f, -9.73858964e-03f,
  -3.66716944e-02f, -4.75435741e-02f, 6.09143898e-02f, -9.56097394e-02f, 2.49637682e-02f, -2.89245136e-02f, 6.36986718e-02f, 4.27538566e-02f, -9.00184177e-03f, 6.17213733e-03f,
  9.75755323e-03f, -3.75504829e-02f, -1.07169069e-01f, 7.30812773e-02f, 3.72208543e-02f, 5.57183661e-03f, 5.48048541e-02f, -6.05071634e-02f, -6.36617839e-03f, -6.58079311e-02f,
  2.84895189e-02f, 8.34942758e-02f, -1.05646335e-01f, -2.41395812e-02f, -1.33889094e-01f, 4.84932363e-02f, -4.58335243e-02f, 6.24848269e-02f, -2.28917133e-02f, -3.27420272e-02f,
  9.94358063e-02f, 6.02323599e-02f, -3.06658410e-02f, 1.09359019e-01f, 7.85228461e-02f, 7.63446316e-02f, 1.48193508e-01f, -1.17863812e-01f, -6.64352626e-02f, -6.00612946e-02f,
  1.87760182e-02f, 3.23271602e-02f, -3.81555259e-02f, 4.35600318e-02f, 1.92671195e-02f, -1.37775704e-01f, -7.53261968e-02f, -1.39097404e-02f, -2.22332347e-02f, 1.33082658e-01f,
  1.40744343e-01f, 1.18767023e-01f, 1.79269701e-01f, 1.37578443e-01f, 2.01633856e-01f, 8.00470188e-02f, 1.43588066e-01f, -2.24790145e-02f, 2.97587141e-02f, -3.28284539e-02f,
  4.80552611e-04f, -8.24553054e-03f, -8.89452398e-02f, -3.56815383e-02f, -2.27164682e-02f, -7.69234002e-02f, -4.80931289e-02f, 9.56573337e-02f, -2.55722795e-02f, -1.64934378e-02f,
  7.23618045e-02f, 8.35158899e-02f, -1.78179797e-02f, 2.44824681e-02f, 9.88846198e-02f, 5.13677299e-02f, 8.76843557e-02f, 1.60791948e-02f, 6.86725695e-03f, -4.68997732e-02f,
  7.77108073e-02f, 1.23588450e-01f, -6.67365119e-02f, -1.43976077e-01f, 3.47732827e-02f, -6.10855557e-02f, 6.10068887e-02f, 1.51522234e-02f, -2.23406255e-02f, -4.02537808e-02f,
  2.99340505e-02f, 4.05702256e-02f, -9.87924933e-02f, -7.37143904e-02f, -4.26364131e-02f, -5.85692413e-02f, 3.31993252e-02f, -1.20419882e-01f, -1.45903140e-01f, -5.79612628e-02f,
  -5.91472909e-02f, 2.45588664e-02f, 1.17159463e-01f, -2.58176662e-02f, 2.54561543e-03f, 1.99734233e-02f, -3.38571845e-03f, -9.65460241e-02f, 1.67957619e-02f, 4.12696078e-02f,
  -1.26109878e-03f, 1.92797650e-02f, 1.29824048e-02f, -4.40913662e-02f, -6.07230291e-02f, 2.11986247e-02f, -7.50964954e-02f, -3.22279744e-02f, 3.46734934e-03f, 9.67831016e-02f,
  -6.25090450e-02f, -2.72222739e-02f, 4.84088361e-02f, -2.59062108e-02f, -8.61997679e-02f, 4.87526208e-02f, 2.86988299e-02f, 5.14676124e-02f, 1.52989924e-02f, 4.34679277e-02f,
  3.73980813e-02f, -3.27410847e-02f, 2.75855828e-02f, -3.23510990e-02f, -2.90972888e-02f, -3.79739814e-02f, 4.21846397e-02f, 3.15311402e-02f, -4.85677272e-02f, 7.23227486e-02f,
  -4.30477373e-02f, 7.46926591e-02f, 2.90534794e-02f, -4.84802537e-02f, 1.16300412e-01f, -4.89537902e-02f, 4.86902185e-02f, 4.68405113e-02f, 4.08929847e-02f, -9.57593992e-02f,
  -1.25071630e-02f, 7.36915246e-02f, 3.90683338e-02f, -2.31838636e-02f, -5.54166660e-02f, -5.78077920e-02f, -4.73238192e-02f, 1.65026039e-02f, -3.91504616e-02f, -3.35059687e-02f,
  -1.32740721e-01f, 1.00357540e-01f, 4.41930927e-02f, -4.02367897e-02f, 6.34767488e-02f, 5.95602207e-02f, 8.69861916e-02f, -4.28428575e-02f, -5.09307496e-02f, -9.50078759e-03f,
  3.45467687e-01f, 1.22703403e-01f, -3.68904918e-01f, 1.72536016e-01f, -1.73658967e-01f, -1.82935908e-01f, -6.78269714e-02f, 1.13979422e-01f, 1.28102049e-01f, 1.04204491e-02f,
  2.76252441e-02f, 7.86332041e-02f, -9.67773423e-02f, -6.27424493e-02f, 3.92281357e-03f, -9.39143971e-02f, -2.06412420e-01f, -2.15825215e-01f, -1.35678956e-02f, 9.13364813e-02f,
  2.88143884e-02f, 7.86274374e-02f, 6.16614446e-02f, 1.13799423e-01f, -5.91889210e-02f, -5.66074513e-02f, -1.76072136e-01f, -7.07498118e-02f, -1.56101122e-01f, -1.11595988e-01f,
  -2.26035997e-01f, -1.06888615e-01f, -5.77497706e-02f, 5.06343581e-02f, 1.98813491e-02f, 5.98034710e-02f, 9.71184820e-02f, 1.95037462e-02f, 5.92379458e-02f, 6.82659522e-02f,
  -2.94046924e-02f, 3.50085795e-02f, -6.77090660e-02f, 2.76678149e-02f, 1.24194279e-01f, 2.59577949e-02f, 5.31444140e-03f, -4.99192365e-02f, -3.53207402e-02f, 5.62424865e-03f,
  8.41286182e-02f, -8.69392902e-02f, -1.42307460e-01f, 7.45562762e-02f, -8.44874531e-02f, -1.30118519e-01f, -1.05562046e-01f, 4.67593335e-02f, -1.28371239e-01f, 1.40109196e-01f,
  7.90663213e-02f, -7.61684999e-02f, -5.22172004e-02f, 1.06626660e-01f, 5.09629725e-03f, -2.09356621e-02f, 1.56629854e-03f, 6.59659505e-02f, -4.57996875e-02f, -7.51551287e-03f,
  2.11868938e-02f, -1.09715343e-01f, 1.30667854e-02f, -2.92482344e-03f, -4.30328995e-02f, -1.59207603e-03f, -8.50238502e-02f, 1.16715990e-01f, -4.51321863e-02f, 4.45294417e-02f,
  8.44255369e-03f, 4.89519127e-02f, -3.21534835e-02f, -4.11911160e-02f, -7.67139494e-02f, -7.73041397e-02f, -6.75459206e-02f, 2.32480559e-02f, -5.13609080e-03f, -3.91950794e-02f,
  1.87609196e-01f, -1.95895925e-01f, 2.72012856e-02f, 9.86414403e-02f, -1.03290109e-02f, -2.91482229e-02f, 5.73570281e-02f, 6.67478442e-02f, -5.08630387e-02f, 5.98436631e-02f,
  -3.33548663e-03f, 8.81706364e-03f, -4.33940487e-03f, 4.24442068e-02f, -5.34726195e-02f, -4.79324758e-02f, 1.62394106e-01f, 2.14090552e-02f, -5.71041368e-02f, 9.78594422e-02f,
  9.03055519e-02f, 1.14418551e-01f, 6.28049672e-02f, 7.65084177e-02f, 3.78900170e-02f, 2.07379907e-02f, -7.89456535e-03f, -5.56885526e-02f, -1.12381384e-01f, 3.18106920e-01f,
  -2.22436845e-01f, 1.92949086e-01f, -4.30256911e-02f, -1.15401655e-01f, -1.55432045e-01f, 2.91234199e-02f, 2.74306070e-02f, -2.97621526e-02f, -6.51834607e-02f, 1.06161281e-01f,
  -3.41684222e-02f, 5.05031832e-03f, 1.01507388e-01f, -9.30038281e-03f, 5.16535006e-02f, 8.27320963e-02f, 5.63969873e-02f, 6.11262955e-02f, 2.31222324e-02f, 7.27419788e-03f,
  5.95666207e-02f, -8.46439376e-02f, -1.00608565e-01f, -4.94225733e-02f, -8.96275230e-03f, 1.00903399e-01f, 1.68181509e-02f, -2.89865602e-02f, 1.42845243e-01f, 1.00688882e-01f,
  1.88435391e-01f, -2.14892447e-01f, -1.30084962e-01f, -4.76399399e-02f, -1.05084002e-01f, -7.26718456e-02f, -2.89902203e-02f, -4.76873033e-02f, -9.55375507e-02f, -6.13464303e-02f,
  -9.42737609e-02f, -5.65282926e-02f, -4.65849414e-02f, -7.60035515e-02f, -8.58922526e-02f, -2.58288458e-02f, -1.26150087e-01f, -1.26510143e-01f, -9.12919417e-02f, 6.14726059e-02f,
  -1.67294350e-02f, 3.53901344e-03f, -1.55688360e-01f, -7.87212923e-02f, -6.03688508e-02f, 2.29168478e-02f, 5.99587373e-02f, 2.03679483e-02f, -1.28262281e-01f, 4.71275337e-02f,
  -2.75867619e-02f, 7.43776709e-02f, 3.38371806e-02f, -6.82561249e-02f, -5.93502000e-02f, 1.03913493e-01f, 3.93552370e-02f, 1.19479470e-01f, 3.11062317e-02f, 1.85298342e-02f,
  6.71222731e-02f, -6.08395226e-02f, -6.72056973e-02f, 5.85996732e-02f, 1.15622599e-02f, -6.67916611e-02f, 4.77941297e-02f, 2.25519091e-02f, -4.05363776e-02f, -5.08075953e-02f,
  -8.26899856e-02f, -2.48262640e-02f, 1.74731202e-02f, 6.02784529e-02f, -6.66005164e-02f, -9.89831239e-02f, 6.65178970e-02f, 4.66459710e-03f, -6.66308403e-03f, -6.04418255e-02f,
  8.67140889e-02f, -9.59934965e-02f, 5.05785495e-02f, -6.76682666e-02f, -8.28696713e-02f, -1.94982272e-02f, 1.02390721e-01f, -4.84827533e-02f, -6.29627556e-02f, 8.74356702e-02f,
  -6.75791278e-02f, -2.37820391e-02f, 6.54121563e-02f, 4.87402529e-02f, -2.51802392e-02f, 3.80338393e-02f, 5.82109503e-02f, -6.98181987e-02f, -3.85532081e-02f, 5.12935072e-02f,
  8.08126479e-02f, -6.39359951e-02f, -4.71103564e-02f, 6.75778016e-02f, -1.11692451e-01f, -1.08941860e-01f, -3.62667106e-02f, 2.50583626e-02f, -5.74238263e-02f, -1.41106872e-02f,
  3.37985493e-02f, 1.66758019e-02f, 7.99673870e-02f, 1.37236565e-01f, 8.95828977e-02f, -2.47649732e-03f, 5.35334758e-02f, 6.74015582e-02f, 2.44988073e-02f, 7.26979151e-02f,
  5.89992711e-03f, 6.21826127e-02f, 9.58888233e-02f, -1.92768462e-02f, -1.68426819e-02f, 9.53281671e-02f, 6.29860861e-03f, 5.28541394e-02f, -1.03116326e-01f, -2.94071883e-02f,
  2.13635527e-02f, -7.97203556e-02f, -1.13361105e-01f, -9.13495049e-02f, 8.08033273e-02f, 1.68283712e-02f, 6.92699924e-02f, 3.93273011e-02f, -6.79474175e-02f, -2.17058118e-02f,
  -9.20369178e-02f, -1.21166622e-02f, -8.21370166e-03f, -5.41222207e-02f, -1.02812171e-01f, 3.01791690e-02f, 2.55719721e-02f, 3.74575295e-02f, -3.55888531e-02f, 2.27659233e-02f,
  3.66220474e-02f, -1.09272422e-02f, -5.54020889e-02f, -4.42164950e-02f, -6.60450011e-02f, 8.56220052e-02f, -5.34274466e-02f, 2.47177538e-02f, 4.57746498e-02f, 1.01966128e-01f,
  5.95610254e-02f, 8.44590075e-04f, 1.31534800e-01f, 1.21688046e-01f, -4.50154133e-02f, 7.83324987e-02f, 4.75025922e-02f, -7.07636252e-02f, 1.43829346e-01f, -2.57906895e-02f,
  1.43916264e-01f, -8.45487230e-03f, 4.42276672e-02f, -1.22399740e-02f, 4.28706668e-02f, 4.72876541e-02f, -4.11899164e-02f, -2.19915956e-02f, 8.56487900e-02f, 3.77399474e-02f,
  1.50501616e-02f, 5.73436320e-02f, -4.17325795e-02f, 5.76998666e-02f, 6.52825534e-02f, -4.48113345e-02f, 2.89651137e-02f, 1.41304945e-05f, 7.85009786e-02f, 7.77697638e-02f,
  9.79343504e-02f, 3.60475369e-02f, 2.85979677e-02f, 7.84013346e-02f, 1.08159609e-01f, 1.23281702e-01f, 5.00707589e-02f, -3.99421826e-02f, -2.51333416e-02f, 1.88804790e-02f,
  -1.43544763e-01f, 1.20503843e-01f, -5.92171513e-02f, -4.09276113e-02f, 5.26130572e-02f, 3.25439982e-02f, -4.19331565e-02f, -1.31163925e-01f, -2.17893030e-02f, -1.39586449e-01f,
  5.28520811e-03f, -5.09994179e-02f, -8.19495246e-02f, -2.60416456e-02f, -2.40899455e-02f, 4.40711640e-02f, -2.08407417e-02f, 4.13326398e-02f, 3.54549922e-02f, 1.27995694e-02f,
  4.48877886e-02f, 1.04886703e-01f, 4.37645838e-02f, 2.23599058e-02f, 5.25326282e-02f, 1.16371229e-01f, 4.17475551e-02f, 6.07794076e-02f, 8.35429877e-02f, 3.58474143e-02f,
  -1.95560917e-01f, -1.97433501e-01f, 5.72057962e-02f, 3.07312720e-02f, 1.54543623e-01f, -8.56160000e-02f, -1.80172205e-01f, -3.44453901e-02f, 1.51706219e-03f, 9.59019437e-02f,
  4.84274961e-02f, 1.87558278e-01f, 1.98372066e-01f, 4.32081521e-02f, 6.82694986e-02f, 5.59416376e-02f, 1.54764235e-01f, 3.78743969e-02f, -5.43444324e-03f, 4.65832651e-02f,
  1.31619677e-01f, -3.21596004e-02f, 2.22440436e-02f, 8.39779675e-02f, 8.14098641e-02f, 2.09814355e-01f, 1.47795662e-01f, 1.04993107e-02f, 9.45999995e-02f, 2.27076188e-02f,
  -2.01018900e-01f, -1.38265252e-01f, 1.47339508e-01f, 7.28957057e-02f, -2.88961139e-02f, -5.55418022e-02f, -1.04183089e-02f, -1.84271503e-02f, -6.53667152e-02f, 7.04508275e-02f,
  8.32398012e-02f, 4.06644568e-02f, 5.15052937e-02f, -5.95341176e-02f, -7.04086646e-02f, -7.18102604e-02f, 1.16045801e-02f, -2.24781893e-02f, 1.01012237e-01f, 4.25625853e-02f,
  1.27031431e-01f, 2.43429337e-02f, -5.67964241e-02f, 4.38306704e-02f, 5.82443513e-02f, 4.12151515e-02f, 3.22425589e-02f, -7.33498111e-02f, 7.54487440e-02f, 3.72266420e-03f,
  5.00581935e-02f, 5.16992994e-02f, -9.70170554e-03f, 7.72503912e-02f, 5.90375217e-04f, 4.78142202e-02f, 9.61330086e-02f, 4.31126263e-03f, 8.62060562e-02f, -2.06972323e-02f,
  5.71623705e-02f, -1.61685813e-02f, 8.10775533e-03f, 6.51377216e-02f, -4.73274961e-02f, -5.04929461e-02f, -8.32362995e-02f, -6.23954237e-02f, -4.76639457e-02f, -1.76288970e-02f,
  7.17880800e-02f, 7.22759664e-02f, -7.16772377e-02f, -6.71236515e-02f, -2.74114758e-02f, 1.02487251e-01f, -6.90970710e-03f, -4.83979024e-02f, -5.00962883e-02f, -7.15214759e-02f,
  2.55052131e-02f, 1.96126699e-01f, -5.69891222e-02f, -7.53994733e-02f, -7.35491738e-02f, -4.30291612e-03f, 4.74333055e-02f, 6.05142973e-02f, -3.19429450e-02f, 8.77005979e-04f,
  3.12047694e-02f, 8.38606060e-03f, 1.60943624e-02f, 2.65102126e-02f, -4.58108215e-03f, 2.84991320e-02f, 4.85456772e-02f, 8.37064609e-02f, 7.86682218e-03f, -2.16776505e-02f,
  7.06670955e-02f, -2.57061720e-02f, -6.31193444e-02f, 1.05436541e-01f, -3.79437581e-02f, 1.70219451e-01f, 3.88532318e-02f, 6.03701063e-02f, 8.64373371e-02f, -9.83611047e-02f,
  1.61073014e-01f, 3.83472629e-02f, 1.33474603e-01f, 4.94822524e-02f, 2.76105683e-02f, -6.81485534e-02f, -2.06105694e-01f, -1.58593580e-01f, 6.34520948e-02f, 2.59195492e-02f,
  6.30359799e-02f, -4.91929054e-02f, -2.49564797e-02f, -1.10617243e-01f, -7.67764077e-02f, -1.16426766e-01f, 9.01063755e-02f, 3.01707759e-02f, 1.27176970e-01f, 7.94329941e-02f,
  7.68874809e-02f, 1.06668919e-02f, 1.77885532e-01f, 6.86622933e-02f, 4.32998203e-02f, -3.97126712e-02f, 1.30301848e-01f, 1.25421941e-01f, 2.46537160e-02f, 7.50867501e-02f,
  9.48663056e-02f, 2.20014900e-02f, -6.81615099e-02f, -1.97957139e-02f, 2.25230027e-02f, -2.19311025e-02f, 9.10134465e-02f, -6.51139626e-03f, 8.21359977e-02f, 1.30763464e-02f,
  8.70004222e-02f, 2.03803591e-02f, 1.43705923e-02f, 1.87780312e-03f, -3.99713218e-02f, 6.68068901e-02f, 6.93554617e-03f, 8.91538784e-02f, -7.13936612e-02f, -2.74589453e-02f,
  5.22149503e-02f, -4.10860553e-02f, 7.70312324e-02f, -8.92649144e-02f, -9.46033373e-02f, -1.98542718e-02f, 6.27632812e-02f, -1.22163203e-02f, 1.88774746e-02f, 6.08170629e-02f,
  4.92316000e-02f, -3.61413695e-02f, 4.46564928e-02f, 5.00008464e-02f, 8.94137770e-02f, -4.04364243e-02f, 1.36054037e-02f, -2.71362774e-02f, -5.21064587e-02f, 1.10391729e-01f,
  5.32199629e-02f, 8.28209072e-02f, 1.18758887e-01f, 6.56934530e-02f, 3.46545991e-03f, -2.93676388e-02f, 8.10997114e-02f, 4.03334796e-02f, 1.05911449e-01f, -1.84964910e-02f,
  2.15664040e-02f, 5.64942174e-02f, 1.41393155e-01f, 7.48324580e-03f, 7.74486810e-02f, 7.21406639e-02f, 1.28267527e-01f, -2.49563344e-02f, -3.67691815e-02f, 1.61227398e-02f,
  -7.87718035e-03f, -1.39192743e-02f, -5.86921349e-02f, 3.55922244e-03f, 1.29674777e-01f, 3.88373574e-03f, 1.22473255e-01f, -5.81121333e-02f, 5.69153242e-02f, -8.10058862e-02f,
  -4.79968190e-02f, 8.01153257e-02f, 2.09186208e-02f, 8.08895305e-02f, 1.31777555e-01f, 7.05888122e-02f, 5.91546223e-02f, -7.46144280e-02f, -6.89796209e-02f, -6.77356124e-03f,
  1.12239476e-02f, -6.26899153e-02f, -4.24081646e-02f, -1.33132085e-01f, 6.64719613e-03f, -4.19779047e-02f, -8.24648887e-02f, 6.03015162e-02f, -4.59916219e-02f, -5.95433265e-02f,
  -1.72032759e-01f, -1.92438349e-01f, -2.00300459e-02f, -1.32891126e-02f, -1.44188711e-02f, -1.13362987e-02f, -9.01301876e-02f, 1.39787802e-02f, 6.70842007e-02f, -2.78873965e-02f,
  -2.01349426e-02f, 1.18450433e-01f, 1.18852176e-01f, 1.38253868e-01f, 8.33825916e-02f, 1.87770799e-02f, 1.20002836e-01f, 9.71503034e-02f, 4.05895747e-02f, 4.58401777e-02f,
  2.65781414e-02f, 5.93189783e-02f, -8.42203200e-03f, 2.94572711e-02f, -1.67989209e-02f, 1.64058194e-01f, -6.18666261e-02f, 2.79404838e-02f, -4.19658050e-02f, 1.19118646e-01f,
  -8.89705792e-02f, -1.83094233e-01f, 1.45062506e-01f, -3.01457904e-02f, -8.79293215e-03f, -4.23965827e-02f, -1.12975925e-01f, -8.37632716e-02f, 5.98147251e-02f, -7.99456537e-02f,
  -9.51837283e-03f, 1.23197576e-02f, 4.09821160e-02f, 9.71461460e-03f, 4.35931012e-02f, -1.55691439e-02f, -1.14731744e-01f, 6.35793135e-02f, -2.08535399e-02f, -1.27974957e-01f,
  -2.01836675e-02f, -1.01458468e-01f, -1.21031143e-01f, -7.69676268e-02f, -3.11744139e-02f, -1.17182708e-03f, -6.13760389e-02f, 1.44811962e-02f, -1.31633684e-01f, -1.17577784e-01f,
  -3.39320228e-02f, -1.25335837e-02f, -7.29558170e-02f, 8.05628821e-02f, -1.48880966e-02f, -2.48648804e-02f, 2.27966495e-02f, 2.25375816e-02f, 1.59530304e-02f, 1.69343362e-03f,
  3.95153798e-02f, -4.90738004e-02f, 4.62915227e-02f, -3.35483477e-02f, -4.58143763e-02f, -7.09867775e-02f, 4.33302373e-02f, 2.68173851e-02f, 7.61717111e-02f, -1.48655660e-02f,
  5.19079491e-02f, 2.83148661e-02f, 8.40658322e-02f, 1.30180895e-01f, -3.80637348e-02f, -2.60094050e-02f, 3.87843996e-02f, -5.94966449e-02f, -1.60217602e-02f, -5.87075353e-02f,
  4.07979218e-03f, -5.48337400e-02f, -7.45954812e-02f, -5.85578084e-02f, -6.55446351e-02f, 5.15547022e-02f, -6.60830736e-02f, -8.71922523e-02f, -6.24806657e-02f, 8.39157496e-03f,
  -9.53525677e-02f, 3.97195406e-02f, 3.72140482e-02f, -6.51601478e-02f, -7.07384422e-02f, -9.18526277e-02f, 4.54520434e-03f, 1.60820428e-02f, 7.49349520e-02f, -3.88895022e-03f,
  -1.71096250e-02f, -1.05336250e-03f, -8.25157687e-02f, -1.33856880e-02f, 3.48522440e-02f, -9.18073803e-02f, -6.83541968e-02f, -2.39439458e-02f, -1.33037508e-01f, -3.47095877e-02f,
  1.35489240e-01f, 1.25348061e-01f, 3.42489988e-01f, -1.30019158e-01f, -1.80073887e-01f, 6.82580620e-02f, 9.53153241e-04f, 2.43378319e-02f, -6.56949952e-02f, -1.23040877e-01f,
  -2.70991534e-01f, -1.27131283e-01f, -1.58201307e-01f, -5.46117537e-02f, 1.50363877e-01f, 8.07232410e-02f, 2.00362548e-01f, 2.70795733e-01f, 7.14464560e-02f, -2.98950560e-02f,
  -1.20790981e-01f, 8.33496004e-02f, 1.88461706e-01f, 1.09899975e-01f, 4.46739197e-02f, -1.58182159e-01f, 1.39584184e-01f, 1.14769071e-01f, 5.93184642e-02f, -9.60306148e-04f,
  -4.98930700e-02f, 1.63116053e-01f, -6.07770830e-02f, -3.55912223e-02f, 8.76228884e-03f, -5.99853834e-03f, -7.33907893e-02f, 7.12131932e-02f, -5.90484738e-02f, 8.64931569e-02f,
  -1.90980826e-02f, -6.86635599e-02f, -6.86378703e-02f, -7.33509511e-02f, 7.55603015e-02f, -4.17727493e-02f, 3.05263139e-02f, 2.37269506e-01f, 1.15047708e-01f, -6.64074346e-02f,
  -1.43562153e-01f, -1.05191812e-01f, -1.32741574e-02f, 2.07971944e-03f, 1.55459374e-01f, -1.58341359e-02f, 3.41730490e-02f, 7.35850558e-02f, 8.81669894e-02f, -5.54030053e-02f,
  -4.15041260e-02f, -4.77166921e-02f, -3.77425738e-02f, 2.03667376e-02f, -9.76016745e-02f, -7.76376501e-02f, -3.99665982e-02f, 2.11333716e-03f, 6.79827034e-02f, 2.01129261e-02f,
  5.02598137e-02f, 6.87454070e-04f, 5.73216528e-02f, -8.79085623e-03f, -2.59564891e-02f, -4.54334766e-02f, 1.57043501e-03f, 3.53646874e-02f, 2.98958439e-02f, 6.99877962e-02f,
  1.57699324e-02f, -4.98412549e-02f, -2.14407723e-02f, -2.05563661e-03f, -7.86119886e-03f, 6.78300932e-02f, -2.03963723e-02f, -4.85480316e-02f, -8.11581910e-02f, -1.31911216e-02f,
  -2.95272082e-01f, 7.69713242e-03f, -1.90703005e-01f, -3.53896245e-02f, -2.16448084e-02f, 8.52855965e-02f, -1.33548304e-01f, -2.09856848e-03f, -3.26298103e-02f, -6.58643618e-02f,
  1.33339292e-03f, 1.65601179e-03f, -9.14074853e-02f, -7.84285739e-02f, -6.71270266e-02f, -1.10764749e-01f, -6.23058714e-02f, -4.43081036e-02f, -4.87758452e-03f, 5.70878871e-02f,
  -1.47389853e-02f, -1.28291681e-01f, -1.99629277e-01f, -1.57331094e-01f, -1.31575674e-01f, -1.51171282e-01f, -1.89574226e-03f, -1.70749515e-01f, -1.11123592e-01f, -1.14923514e-01f,
  -2.69832850e-01f, 6.31353185e-02f, 1.86824441e-01f, -1.52942881e-01f, -6.12229258e-02f, -9.86940339e-02f, -6.79248571e-02f, -7.92605802e-02f, 1.09532010e-02f, -6.63711131e-02f,
  6.68820878e-03f, -3.15388441e-02f, -1.88824367e-02f, -1.51605513e-02f, -1.44825786e-01f, -7.75858536e-02f, -2.01925226e-02f, -1.11444123e-01f, -2.20817834e-01f, -2.18460813e-01f,
  -6.71526790e-02f, -1.08574733e-01f, -1.54819354e-01f, -1.12012453e-01f, -5.26201762e-02f, 4.88703027e-02f, 7.32162446e-02f, 3.63907255e-02f, -1.13473665e-02f, -7.30649233e-02f,
  3.60080227e-02f, -1.37317851e-02f, -5.59118502e-02f, 1.80499554e-02f, -3.88354138e-02f, 6.36890996e-03f, -8.80059078e-02f, 1.59336198e-02f, 7.56491348e-02f, -1.99437723e-04f,
  -2.62176078e-02f, -2.92466804e-02f, 2.90171597e-02f, -8.70479494e-02f, 3.67745236e-02f, -1.16239965e-01f, -1.13057755e-01f, -1.89623628e-02f, -1.54032381e-02f, -9.53645855e-02f,
  -8.62100944e-02f, -1.24669317e-02f, -1.34876072e-01f, -3.10857352e-02f, 9.29138884e-02f, 1.18424585e-02f, -4.89827665e-03f, 1.92752182e-02f, -3.01821381e-02f, -2.75606550e-02f,
  -1.17780261e-01f, 5.67446575e-02f, -4.58522886e-03f, 3.10488064e-02f, 7.27619827e-02f, -3.51623632e-02f, 7.79516399e-02f, 1.04803834e-02f, 3.91005091e-02f, -5.84013909e-02f,
  -4.54965569e-02f, -5.21310642e-02f, -4.45198864e-02f, 2.30054855e-02f, -6.93919659e-02f, 3.33116464e-02f, -6.40696064e-02f, 6.72843307e-02f, 3.04751992e-02f, 1.19255914e-03f,
  -6.35905191e-02f, 1.98178608e-02f, 6.89119399e-02f, 1.16591733e-02f, 4.87738550e-02f, 3.17160995e-03f, 4.41585220e-02f, 4.32685502e-02f, 7.01941252e-02f, 2.11472996e-03f,
  5.16252294e-02f, -2.04063840e-02f, -4.33127806e-02f, -1.74405351e-02f, 8.71388689e-02f, -3.76165248e-02f, 1.04064923e-02f, -4.95216511e-02f, -2.48151030e-02f, 2.75295693e-02f,
  -5.29398099e-02f, -1.10203929e-01f, 2.74152271e-02f, 2.01056227e-02f, -8.80455971e-02f, -2.85890736e-02f, 1.31306052e-02f, 5.45670511e-03f, 5.29898666e-02f, -8.58448632e-03f,
  2.89982688e-02f, -5.46360463e-02f, -8.35155919e-02f, -3.94068174e-02f, 2.94167791e-02f, -1.95915289e-02f, -7.74004534e-02f, -8.90383795e-02f, -1.11436449e-01f, -3.53058204e-02f,
  1.14047319e-01f, 1.27287015e-01f, -4.68984172e-02f, 6.52762800e-02f, -1.96153492e-01f, -1.99093834e-01f, -9.18533280e-02f, 4.27482948e-02f, 1.20752536e-01f, -1.71323549e-02f,
  -3.67575116e-03f, -6.95806667e-02f, -8.16067157e-04f, -5.09481691e-02f, 3.01338788e-02f, -4.24439125e-02f, 7.57708549e-02f, -1.23119287e-01f, -4.27572615e-02f, -8.03383961e-02f,
  -1.43428609e-01f, 3.66450474e-02f, 1.14979245e-01f, 1.26010915e-02f, 1.19099170e-01f, -1.00109251e-02f, 7.94396996e-02f, -3.86021249e-02f, -1.66551583e-02f, 1.58891916e-01f,
  1.36016175e-01f, 2.10180283e-01f, -1.03862822e-01f, -5.22792973e-02f, -1.23540081e-01f, 1.19836114e-01f, -5.43476045e-02f, 1.03790842e-01f, -7.86969811e-02f, -4.49049249e-02f,
  -1.17982246e-01f, -3.53545770e-02f, -4.76975851e-02f, 5.16856611e-02f, -5.23983352e-02f, 6.55114800e-02f, 5.30313118e-05f, 6.56477958e-02f, -7.69473799e-03f, 5.95701002e-02f,
  -4.21852767e-02f, -1.55523658e-01f, 3.02415155e-02f, 1.28206424e-03f, -2.72466429e-03f, -1.14710577e-01f, 8.81888941e-02f, 8.25180709e-02f, -5.10423705e-02f, 2.37215906e-01f,
  4.95641418e-02f, -1.78724527e-03f, -5.27983382e-02f, 7.97545239e-02f, 4.25254591e-02f, 2.09059510e-02f, -2.66153575e-03f, -2.78025158e-02f, -9.82978046e-02f, -8.23402330e-02f,
  1.64127275e-02f, 3.75816482e-03f, 5.52517595e-03f, -3.03528979e-02f, -1.43064875e-02f, -7.60226399e-02f, 2.51377262e-02f, 6.47080615e-02f, -9.15967003e-02f, 4.91391048e-02f,
  -2.46431828e-02f, -4.63828258e-03f, 6.01813272e-02f, -3.56308222e-02f, 7.74095058e-02f, 1.01072462e-02f, -8.07033479e-02f, 3.68521065e-02f, 6.55067414e-02f, 6.97789043e-02f,
  7.53108263e-02f, -3.11903298e-01f, 9.05868858e-02f, -1.37609700e-02f, 2.09091622e-02f, 7.68690258e-02f, 2.92935073e-02f, -6.73137084e-02f, -3.57701033e-02f, 4.53648902e-02f,
  -6.23405240e-02f, 7.29497299e-02f, -7.38990754e-02f, -7.70183280e-02f, -1.19417571e-01f, -3.74589004e-02f, -1.10782415e-01f, -9.28246230e-02f, -8.19837078e-02f, 8.14926326e-02f,
  -1.41628116e-01f, -2.78866962e-02f, -1.59025684e-01f, -4.52889241e-02f, 4.73343544e-02f, -1.91482037e-01f, -7.49283750e-03f, 5.51900500e-03f, -1.13768771e-01f, 9.40130502e-02f,
  -5.02112389e-01f, 5.30139767e-02f, -6.29848689e-02f, 6.18000031e-02f, 2.74751008e-01f, 3.50491256e-01f, 4.44696218e-01f, 2.04230219e-01f, 9.27559510e-02f, 4.80749309e-02f,
  8.77795741e-03f, 1.39791463e-02f, 1.41018644e-01f, 1.88673735e-02f, 1.62798867e-01f, 2.89888948e-01f, 2.86192268e-01f, 3.34004425e-02f, -5.11263423e-02f, 8.27956498e-02f,
  1.94613919e-01f, -1.57285705e-01f, -2.67949373e-01f, -6.23711348e-02f, -7.29668140e-03f, 9.45430771e-02f, -7.93703794e-02f, -3.44398022e-02f, 5.34448735e-02f, 8.86817127e-02f,
  -2.45775715e-01f, -1.72999725e-01f, 5.98993860e-02f, 1.84302106e-02f, -2.60949973e-03f, -1.26387700e-01f, -1.00768246e-02f, -1.75962806e-01f, -1.54504329e-02f, -3.81316654e-02f,
  -4.94423993e-02f, -7.17434958e-02f, 1.89356152e-02f, -1.53955640e-02f, -9.91166383e-02f, -3.76702696e-02f, -2.53697932e-02f, -1.16713032e-01f, 1.09992102e-01f, -6.97443932e-02f,
  1.02918044e-01f, -4.48417646e-04f, -2.17867969e-03f, 5.03512844e-02f, 1.91224944e-02f, -8.32739472e-02f, -5.61864302e-02f, -1.18200056e-01f, 2.01459993e-02f, -3.96497585e-02f,
  1.03894649e-02f, -2.23572832e-02f, 4.00627553e-02f, -4.92194705e-02f, 2.59595700e-02f, 9.28663707e-04f, -7.05990766e-04f, 8.94398242e-02f, -1.90602113e-02f, -4.76733446e-02f,
  -3.95190232e-02f, 1.81674920e-02f, 5.77664003e-02f, 2.32930225e-03f, 4.22644839e-02f, 4.91009243e-02f, 1.02486555e-02f, 4.08709235e-02f, -1.69464108e-02f, -4.76095080e-02f,
  6.92317635e-02f, -9.89865884e-03f, -1.36318833e-01f, 2.37857345e-02f, 6.03775047e-02f, -3.22083458e-02f, -7.45332837e-02f, -3.86879630e-02f, -9.56886038e-02f, 5.75552396e-02f,
  -9.94087756e-02f, 2.89930776e-03f, 1.09087184e-01f, -7.02089071e-03f, 8.11458230e-02f, -1.19785339e-01f, 9.94737223e-02f, 4.32648435e-02f, 7.28395209e-02f, -3.76864783e-02f,
  6.43606260e-02f, -2.90812105e-02f, -3.94134335e-02f, 3.85151058e-02f, -6.87642395e-02f, -7.59109408e-02f, -9.22777653e-02f, -4.93389815e-02f, 5.67933917e-02f, 6.85804188e-02f,
  2.12133694e-02f, 6.34424910e-02f, -9.13164169e-02f, 9.71455798e-02f, 2.42088232e-02f, 3.40038575e-02f, -2.88178734e-02f, -2.10542921e-02f, -6.04718029e-02f, -1.39418080e-01f,
  3.84383351e-02f, -1.43446657e-03f, -7.85748765e-04f, 2.42795587e-01f, 3.76408882e-02f, -1.08376957e-01f, -1.36199042e-01f, -9.96885225e-02f, 2.71671005e-02f, 1.23227105e-01f,
  3.54155898e-02f, 5.12543172e-02f, -2.65211016e-02f, -2.45146155e-02f, -1.44389078e-01f, -5.56257293e-02f, 1.02387942e-01f, -5.86133823e-02f, -8.87415856e-02f, -8.49649757e-02f,
  9.49283019e-02f, 8.11531097e-02f, 1.15008943e-01f, 1.35179177e-01f, 1.24295115e-01f, 1.16865382e-01f, 6.79956675e-02f, 1.40546113e-01f, 4.11659144e-02f, 1.62659034e-01f,
  -1.50178522e-01f, -1.16533563e-01f, -9.22358558e-02f, 8.70784000e-02f, -7.05248117e-02f, -2.36930326e-02f, -2.57700682e-02f, -5.25474884e-02f, 2.28561815e-02f, 6.46587983e-02f,
  -8.27401038e-03f, 5.32752685e-02f, 2.96971924e-03f, 4.12942246e-02f, 3.24349627e-02f, 6.86531290e-02f, -8.08203891e-02f, -4.95651141e-02f, 3.07523087e-02f, -1.29972056e-01f,
  -7.66352490e-02f, 6.84207156e-02f, -1.05255887e-01f, -1.16889395e-01f, -5.70743456e-02f, -8.64064544e-02f, 1.08079724e-02f, -5.28296307e-02f, -1.17745757e-01f, 7.03855529e-02f,
  6.19224980e-02f, 7.51778781e-02f, 2.18716227e-02f, 7.76325092e-02f, -1.64765902e-02f, -8.21777731e-02f, 4.58550975e-02f, -4.78943288e-02f, 2.47680512e-03f, 1.01934476e-02f,
  -9.00503919e-02f, 4.38806824e-02f, 5.34754945e-04f, -4.32182178e-02f, -3.42999399e-02f, 3.11599188e-02f, -2.68155360e-03f, -7.54077062e-02f, -1.05200022e-01f, 8.98793265e-02f,
  1.36689777e-02f, 4.77535874e-02f, 4.22502588e-03f, -2.66583841e-02f, 8.89389887e-02f, 1.00166611e-02f, 3.97654064e-02f, -4.48763147e-02f, -9.35537647e-03f, 8.70023817e-02f,
  1.76544711e-01f, -6.83822110e-02f, 9.78120118e-02f, 8.87387618e-02f, 1.06425092e-01f, -5.42460792e-02f, 1.07393675e-01f, -3.56267169e-02f, 4.72343341e-02f, 5.64903319e-02f,
  7.71495774e-02f, -2.62903818e-03f, -8.54363069e-02f, 3.03739235e-02f, 4.73730490e-02f, 4.57381420e-02f, 1.39395580e-01f, 5.84959500e-02f, 7.79451802e-02f, 8.42547640e-02f,
  4.52029444e-02f, -1.79597531e-02f, -2.26540565e-02f, -6.51558787e-02f, 3.63725722e-02f, -1.25281764e-02f, 5.96714243e-02f, -6.81587402e-03f, -2.59784721e-02f, 7.64339790e-02f,
  -3.97891700e-02f, 4.35106419e-02f, -3.95808145e-02f, -3.68912965e-02f, -1.28303409e-01f, -1.53219178e-01f, -3.10300961e-02f, -3.43131386e-02f, 1.43370517e-02f, -1.81922987e-02f,
  3.42847668e-02f, -1.58562779e-01f, -5.50572621e-03f, -5.42066246e-02f, -2.34335050e-01f, -1.47537701e-02f, -1.33476272e-01f, -2.61189401e-01f, -2.69725502e-01f, -2.02819601e-01f,
  -1.61740571e-01f, -2.41761342e-01f, -2.60507703e-01f, -1.18365690e-01f, -9.82803628e-02f, -1.93683073e-01f, -2.66794171e-02f, -1.85971975e-01f, -1.83985651e-01f, -1.63405836e-02f,
  -1.44949093e-01f, 6.87354431e-02f, -1.15610324e-01f, -6.94672763e-02f, 4.61334959e-02f, -5.33555038e-02f, -5.54884039e-02f, 1.10510044e-01f, -2.79527139e-02f, -6.95090508e-03f,
  -9.66763496e-03f, 1.10028600e-02f, 7.26110861e-02f, -9.30903032e-02f, -3.56209953e-03f, -3.70788425e-02f, -5.02232686e-02f, -1.11048527e-01f, -2.69123279e-02f, -6.01023026e-02f,
  6.22136693e-04f, -1.06027775e-01f, -6.44319877e-02f, -5.86040951e-02f, -7.28043392e-02f, 1.15658902e-02f, -8.55800975e-03f, -3.12041901e-02f, -8.97984728e-02f, -7.13592544e-02f,
  4.85889949e-02f, 1.69256609e-02f, -7.30283558e-02f, 1.26837194e-02f, -3.18943560e-02f, 6.30200207e-02f, 2.07224749e-02f, -1.63195692e-02f, 4.33861353e-02f, 7.17740087e-03f,
  -4.93866503e-02f, -1.17567526e-02f, -4.17955853e-02f, 5.87129928e-02f, 7.21797496e-02f, 2.58284109e-03f, 4.25501429e-02f, -1.32209612e-02f, 4.34242934e-02f, -6.37228414e-02f,
  -6.85753971e-02f, -1.16275242e-02f, -4.30608317e-02f, -6.00120388e-02f, -1.65059250e-02f, 2.58942135e-02f, -3.63895223e-02f, -7.56074563e-02f, 1.20617487e-01f, -2.27870308e-02f,
  -4.94874381e-02f, -1.07362591e-01f, 6.75816685e-02f, 8.93334299e-03f, -6.93284199e-02f, 6.63540661e-02f, 7.69272074e-02f, -4.23819236e-02f, 2.02811658e-02f, -4.31505889e-02f,
  -7.13541731e-02f, -7.09840581e-02f, 6.21584617e-02f, 8.46361741e-03f, -1.18522100e-01f, 5.73392063e-02f, -7.74883316e-04f, -5.28510809e-02f, -5.92547432e-02f, -2.86001414e-02f,
  -6.47851750e-02f, -9.51647460e-02f, -3.78877744e-02f, -7.00125992e-02f, 4.44403328e-02f, 3.36026016e-04f, -5.74974641e-02f, -7.55026191e-02f, -1.45670459e-01f, 2.55191699e-04f,
  -4.82561767e-01f, -2.19557628e-01f, -2.30585232e-01f, -1.84621468e-01f, -7.59990071e-04f, 1.63165461e-02f, -6.63458370e-03f, 1.41100168e-01f, 4.05659676e-02f, -3.85168158e-02f,
  -4.56860624e-02f, -7.22983032e-02f, -1.31534040e-01f, 1.00797173e-02f, 2.47193011e-03f, -2.18998138e-02f, -1.28868297e-01f, -1.82105944e-01f, -9.27807391e-02f, 7.48096704e-02f,
  4.12078202e-02f, -8.19017962e-02f, -2.29997054e-01f, 7.73152057e-03f, 1.52982185e-02f, -1.41443118e-01f, -1.25681937e-01f, -2.10042700e-01f, -4.66772132e-02f, -3.05605918e-01f,
  -3.70795816e-01f, -1.54146075e-01f, 1.15167983e-01f, -8.13170746e-02f, 2.39846744e-02f, -6.56798705e-02f, -4.78515355e-03f, -7.86287785e-02f, 5.85243292e-02f, -6.83566555e-02f,
  -1.13249697e-01f, 3.23153250e-02f, -1.24035522e-01f, 1.56647712e-02f, -7.63595998e-02f, -7.18479827e-02f, 6.38039932e-02f, -6.87857792e-02f, -6.51454329e-02f, 6.08941503e-02f,
  6.20925426e-02f, -1.33811206e-01f, -1.24107569e-01f, -9.18321386e-02f, -7.17377365e-02f, -9.68695655e-02f, -6.00716583e-02f, -1.29929855e-01f, -1.80338830e-01f, -2.40298897e-01f,
  7.63904974e-02f, -1.45457722e-02f, -3.95472441e-03f, 1.23995291e-02f, 3.74561967e-03f, 2.41076853e-02f, -7.48998597e-02f, -1.20352050e-02f, 7.33806342e-02f, 1.31281503e-02f,
  -7.90680107e-03f, -5.81890484e-03f, -2.28269026e-02f, 1.30064171e-02f, -4.79239272e-03f, -4.86532040e-02f, -2.60904841e-02f, -1.71634071e-02f, -2.26769336e-02f, 4.63853069e-02f,
  -9.59883481e-02f, 4.97726686e-02f, -8.19144472e-02f, 1.44507205e-02f, 2.75573283e-02f, 3.74807953e-03f, 3.58904153e-02f, 4.44531925e-02f, -7.63682052e-02f, 7.67266527e-02f,
  -1.54975966e-01f, 1.43036433e-02f, -1.99540839e-01f, -4.47347015e-02f, -5.49185909e-02f, 3.22579220e-02f, -3.96835729e-02f, -2.45460663e-02f, -4.31352369e-02f, -2.21580360e-02f,
  1.41041931e-02f, -2.95050871e-02f, -7.66635761e-02f, -3.48599441e-03f, 3.76067832e-02f, -3.14360298e-02f, 3.75050828e-02f, -1.39301598e-01f, 4.22750302e-02f, 7.76729137e-02f,
  -1.65894143e-02f, -1.57510236e-01f, -3.59840631e-01f, -2.17195988e-01f, -7.12562427e-02f, -2.92867869e-01f, -2.07999438e-01f, -2.25933358e-01f, -2.73051381e-01f, -2.43825421e-01f,
  1.01664513e-01f, 1.85511187e-01f, -1.60118759e-01f, 2.23424852e-01f, 1.35231107e-01f, -8.13014731e-02f, -1.10413373e-01f, -8.72979090e-02f, 1.38672784e-01f, 8.25001672e-02f,
  7.33677745e-02f, 2.25776345e-01f, 3.34535241e-02f, 1.96696054e-02f, -7.40085840e-02f, -8.71168450e-03f, 9.59373266e-02f, -9.15996730e-02f, -7.31430724e-02f, -2.65838727e-02f,
  1.83684215e-01f, 1.60228655e-01f, -3.89402211e-02f, -3.74112390e-02f, 1.46083668e-01f, 1.95773020e-01f, 1.28176704e-01f, 1.92642838e-01f, 5.20795472e-02f, 3.55311811e-01f,
  4.40616533e-02f, -1.29119113e-01f, -4.22605015e-02f, 8.75278264e-02f, -1.37616703e-02f, -8.42702165e-02f, -9.52492803e-02f, -8.98792595e-02f, -9.15936902e-02f, 2.24111732e-02f,
  5.51469764e-03f, 3.65884863e-02f, -3.53181362e-02f, -4.01376486e-02f, -7.80362710e-02f, -1.52137861e-01f, -5.76550737e-02f, -4.87446338e-02f, -1.24235526e-01f, -2.75895335e-02f,
  1.51396424e-01f, -4.98654973e-03f, -1.98247358e-01f, -9.29752067e-02f, -2.01242313e-01f, -3.54115143e-02f, -4.19534519e-02f, -8.17060545e-02f, -2.21250758e-01f, -2.14513373e-02f,
  -5.30325919e-02f, -9.10962000e-03f, -9.01874006e-02f, -2.21103001e-02f, 4.62022685e-02f, -2.85736448e-03f, -1.21154785e-02f, 1.60248633e-02f, -3.49372849e-02f, -6.85173199e-02f,
  -9.95959342e-02f, 1.96767878e-03f, -1.52091011e-02f, 4.61758524e-02f, 1.29831061e-01f, -7.19486699e-02f, 6.99945074e-03f, 2.77773216e-02f, 5.17812446e-02f, 4.66904417e-02f,
  6.05183132e-02f, -4.03008722e-02f, -9.62951332e-02f, 2.04184800e-02f, -3.26524377e-02f, 1.79431383e-02f, -2.54795030e-02f, 2.66594198e-02f, 5.40273227e-02f, 1.51775340e-02f,
  7.74644688e-02f, -2.22015798e-01f, -3.96683030e-02f, -3.99677157e-02f, -8.96299630e-03f, 3.68793644e-02f, 5.15167415e-03f, -1.13713436e-01f, 8.27919971e-03f, -1.00596167e-01f,
  -1.74017940e-02f, -1.14358820e-01f, -1.57454014e-02f, -1.14758462e-01f, -1.06724404e-01f, -8.35030433e-03f, 3.52214538e-02f, -2.11621188e-02f, -6.51900023e-02f, -2.73949709e-02f,
  -3.23285572e-02f, -7.90758133e-02f, -9.95543078e-02f, -1.23644032e-01f, -1.15418158e-01f, 1.56074576e-02f, -2.04946101e-01f, -1.03049137e-01f, -2.68226653e-01f, -3.16046290e-02f,
  2.64489859e-01f, 2.60178477e-01f, -2.20486727e-02f, 4.79698926e-02f, 1.04326084e-01f, 9.80956331e-02f, 4.60591279e-02f, -6.84071612e-03f, -1.03355251e-01f, 8.85734111e-02f,
  4.70011123e-02f, 7.80263469e-02f, 4.43700477e-02f, -3.14035490e-02f, 1.15742527e-01f, 1.99989579e-03f, -5.92704080e-02f, -1.21414252e-01f, 2.96403021e-02f, -1.45808037e-04f,
  -4.29539233e-02f, 8.15450996e-02f, 8.44149888e-02f, 4.36812490e-02f, -2.86893249e-02f, -3.60672288e-02f, -3.58105600e-02f, 4.99758869e-02f, 5.66169880e-02f, 3.64267156e-02f,
  9.49835405e-02f, 2.13798568e-01f, -1.71046942e-01f, -1.06532872e-01f, 4.02268134e-02f, -2.38875709e-02f, -2.79993061e-02f, 6.11089841e-02f, 3.76636647e-02f, 5.29853329e-02f,
  8.53110254e-02f, -4.36484739e-02f, 7.56990016e-02f, -4.40194830e-02f, 6.77922592e-02f, -3.25958543e-02f, 8.17143545e-02f, 1.50612127e-02f, -1.00833159e-02f, 7.59726390e-02f,
  3.43161337e-02f, 7.15663359e-02f, -1.67437382e-02f, -1.06712133e-01f, -4.11380939e-02f, -1.31947696e-01f, -4.58378159e-02f, -4.31525074e-02f, 4.59121307e-03f, 2.96766367e-02f,
  6.46817312e-02f, -2.70714797e-02f, 6.70534968e-02f, 2.24170573e-02f, 8.87276977e-02f, 3.51494178e-03f, -4.18314151e-02f, 4.14691679e-02f, -6.83563203e-02f, 2.74319085e-03f,
  -4.00434844e-02f, -6.98613934e-03f, 3.73106152e-02f, 7.92819783e-02f, -1.99523736e-02f, 9.23830867e-02f, -6.42996505e-02f, -3.23316967e-03f, 7.41376579e-02f, -2.54074261e-02f,
  -3.11562344e-02f, -2.58439146e-02f, 3.11723701e-03f, 3.76711003e-02f, -2.72494368e-02f, -3.07661965e-02f, 7.32299536e-02f, 4.25140746e-02f, 5.50297238e-02f, 1.17296748e-01f,
  -1.15111068e-01f, 8.38894174e-02f, -6.59986511e-02f, -4.24011685e-02f, -3.57995741e-02f, -3.58957648e-02f, 6.39949664e-02f, -3.23396288e-02f, 6.70514032e-02f, 1.00510251e-02f,
  7.29307458e-02f, 4.42987084e-02f, 2.13519298e-02f, -7.04576150e-02f, -2.22331136e-02f, -1.14843786e-01f, -3.59578915e-02f, -6.84341937e-02f, 4.28664079e-03f, -7.81698599e-02f,
  1.09637473e-02f, 1.26474015e-02f, -5.88322058e-02f, -7.25541860e-02f, 2.66968068e-02f, 8.34880583e-03f, -9.91083011e-02f, -4.46661785e-02f, -2.05678493e-02f, -3.13870497e-02f,
  -4.44538414e-01f, 1.84894457e-01f, -9.73029956e-02f, -2.95338154e-01f, -1.95179939e-01f, -1.19184136e-01f, -5.25351726e-02f, -8.73769745e-02f, -6.41948208e-02f, 1.22077666e-01f,
  5.27440831e-02f, -3.28699276e-02f, -4.92410399e-02f, -1.20070986e-01f, -1.23618118e-01f, 9.04782638e-02f, -1.30512312e-01f, -3.12779695e-01f, -3.07068944e-01f, -2.76779234e-01f,
  -1.63759828e-01f, -2.89109886e-01f, -1.75477624e-01f, -7.55205080e-02f, -1.57449255e-03f, -1.43850997e-01f, -1.54563887e-02f, -1.84282675e-01f, -2.16895919e-02f, 1.68640792e-04f,
  2.10938796e-01f, -1.59244701e-01f, -5.31543158e-02f, -7.49989823e-02f, -1.51016945e-02f, 6.26327172e-02f, 3.08428444e-02f, 2.35817321e-02f, 4.93356474e-02f, -3.27727944e-02f,
  -6.09983169e-02f, -1.29143782e-02f, -5.64681739e-02f, 1.98702142e-02f, -1.25071127e-02f, -9.89015251e-02f, 1.11900903e-02f, -1.11543000e-01f, -4.41386066e-02f, 1.24264285e-01f,
  -2.81916521e-02f, -1.44792840e-01f, -1.00212604e-01f, 8.77935961e-02f, -4.33399342e-02f, -7.50391707e-02f, 8.82474482e-02f, 5.65759791e-03f, -4.81850989e-02f, 2.12471768e-01f,
  4.72512245e-02f, 1.05745859e-01f, -8.92961100e-02f, 3.49115506e-02f, 1.39239337e-02f, 6.02196045e-02f, 8.07773205e-04f, -5.84948435e-02f, 6.42531961e-02f, -4.40521585e-03f,
  1.12688258e-01f, 7.78898522e-02f, 2.58498290e-03f, -1.31014613e-02f, 7.35627711e-02f, -3.94713692e-02f, 9.84776579e-03f, 6.07085228e-02f, 2.86729336e-02f, -4.97742146e-02f,
  -3.41474004e-02f, 1.17591294e-02f, 6.01777155e-03f, 8.35817382e-02f, -3.03156972e-02f, 1.48130895e-03f, 1.48733556e-02f, -2.46538650e-02f, -1.42598748e-01f, -1.14593422e-02f,
  3.21609437e-01f, -1.61360547e-01f, 1.27282679e-01f, -1.06986851e-01f, -3.62751633e-02f, 1.05393492e-02f, 1.25496447e-01f, 2.09307764e-02f, -3.14973146e-02f, -3.31763215e-02f,
  1.91678095e-03f, 5.40130027e-02f, 4.89700073e-03f, 2.93742809e-02f, -9.00156572e-02f, 1.56170558e-02f, 9.01068598e-02f, -4.72059328e-05f, -8.18291903e-02f, 1.49608180e-01f,
  9.10507068e-02f, 6.82923347e-02f, 9.41110402e-02f, 1.22306511e-01f, 2.71908715e-02f, 1.16467103e-02f, 1.36352688e-01f, 5.05711548e-02f, 4.14635539e-02f, 2.17159316e-01f,
  2.16886237e-01f, 5.47216721e-02f, 9.42335650e-02f, 4.20126021e-02f, 2.10462376e-01f, 2.94551790e-01f, 2.16598809e-01f, 1.73461497e-01f, -6.94507062e-02f, -5.32000326e-03f,
  8.30788240e-02f, -2.24477462e-02f, -1.77355453e-01f, -8.79160091e-02f, -9.31607336e-02f, 7.04896823e-02f, -7.14079216e-02f, -9.80089381e-02f, 8.43174681e-02f, 7.40117356e-02f,
  -1.00013390e-02f, -1.08115803e-02f, 1.13733090e-01f, -9.25346166e-02f, -2.15468071e-02f, -2.33016647e-02f, -4.84830886e-02f, 7.49628320e-02f, 5.95645048e-03f, -9.17265788e-02f,
  -1.48026748e-02f, 9.97461528e-02f, -7.24565461e-02f, -4.04450446e-02f, -5.32444492e-02f, 2.35375147e-02f, 7.14518055e-02f, 5.57729639e-02f, -9.57493261e-02f, -3.61419097e-02f,
  -8.87092054e-02f, 1.81012843e-02f, -1.28302909e-02f, -4.20855619e-02f, 9.49105620e-02f, -1.48193920e-02f, -4.97995578e-02f, -1.34996012e-01f, -2.50531361e-02f, -5.02009504e-03f,
  -1.18454680e-01f, 9.10337195e-02f, 1.92702994e-01f, -4.70049074e-03f, 1.27271442e-02f, -3.53669911e-03f, -1.08889006e-02f, -3.61514539e-02f, 2.39442699e-02f, -3.16737294e-02f,
  -6.47022650e-02f, 3.76233645e-02f, -7.24094883e-02f, -9.16255340e-02f, -1.37647763e-02f, 4.79417257e-02f, -1.30937146e-02f, 5.73898703e-02f, 4.54970486e-02f, 4.10669446e-02f,
  -1.25147728e-02f, -8.77550542e-02f, -9.00042355e-02f, -1.96615770e-03f, -6.31376356e-02f, 4.21947762e-02f, -2.93661300e-02f, -8.21498688e-03f, -2.76992302e-02f, -7.51029626e-02f,
  -8.28856230e-03f, -8.65387321e-02f, -1.02662832e-01f, -1.28220409e-01f, -6.39529526e-02f, 2.03983262e-02f, 3.13639380e-02f, -1.08836718e-01f, 2.82880068e-02f, -1.85580757e-02f,
  -1.56183258e-01f, -3.92838893e-03f, -7.59652108e-02f, -1.12896286e-01f, 5.34808971e-02f, -1.24506429e-02f, 2.99878418e-03f, -1.18197650e-01f, 7.27097318e-02f, -5.72876930e-02f,
  -3.54949459e-02f, -1.01724133e-01f, -8.33108742e-03f, -3.00277118e-02f, 1.08432911e-01f, -4.77068685e-02f, -2.80875806e-02f, -3.20913196e-02f, -9.69936177e-02f, -4.77509536e-02f,
  -1.74788814e-02f, 1.74940705e-01f, 1.24470852e-01f, 6.90778941e-02f, 4.26899120e-02f, -6.22749701e-02f, 3.22747007e-02f, -4.88254763e-02f, 4.01951093e-03f, 2.88882386e-02f,
  1.31900847e-01f, -1.93879962e-01f, -1.63003847e-01f, 6.59904331e-02f, -2.59062313e-02f, -5.18442094e-02f, -1.60616770e-01f, -6.58057928e-02f, 1.22602552e-01f, -6.14181124e-02f,
  -7.48633444e-02f, -8.78948420e-02f, -9.17715803e-02f, -3.15046795e-02f, -5.37072979e-02f, -1.40363425e-01f, 9.97410342e-03f, 2.88141519e-03f, -1.38164526e-02f, -4.26533027e-03f,
  -1.55823529e-02f, 1.60800572e-02f, 8.27217251e-02f, -5.59992082e-02f, -7.22880065e-02f, -8.76022950e-02f, -1.07437931e-01f, -5.06470539e-02f, -2.02650547e-01f, -1.46163687e-01f,
  -2.33268782e-01f, 3.98660228e-02f, 5.56918457e-02f, -1.01721170e-03f, -6.80150837e-02f, 6.22625055e-04f, 3.84521931e-02f, -1.47014894e-02f, 9.08935368e-02f, 5.75361140e-02f,
  1.96181852e-02f, 6.14359938e-02f, -1.00009196e-01f, 1.63262244e-02f, 4.90226410e-02f, 1.71481147e-02f, -3.63725983e-03f, -2.55474839e-02f, -1.99385993e-02f, -9.13075805e-02f,
  -4.21001352e-02f, -2.28205714e-02f, -6.55166507e-02f, -2.05973387e-02f, -2.20053941e-02f, -5.25852665e-02f, -1.18228666e-01f, -2.35825777e-02f, 3.56440507e-02f, -1.03796013e-01f,
  -4.66194414e-02f, -6.17801026e-02f, 4.75343019e-02f, -2.30078194e-02f, -5.29202148e-02f, 5.02195917e-02f, 1.95405465e-02f, -8.96325558e-02f, -3.29334550e-02f, -7.75102992e-03f,
  1.70608032e-02f, -4.30555120e-02f, -9.31012332e-02f, 8.71089473e-03f, 7.45711178e-02f, 2.86110528e-02f, 4.27047424e-02f, -1.66907962e-02f, 6.49701059e-02f, -8.73569865e-03f,
  -1.12629198e-02f, 3.05164512e-03f, -2.86629740e-02f, 3.80348489e-02f, -4.35403995e-02f, -1.24896402e-02f, 5.43906875e-02f, 7.70036951e-02f, -4.96285148e-02f, 1.89175811e-02f,
  8.81836116e-02f, 9.26207565e-03f, 5.51178120e-02f, -5.11778109e-02f, -6.57616258e-02f, 1.16456859e-02f, -1.06408052e-01f, -2.07354594e-03f, 2.62089875e-02f, -3.23763452e-02f,
  -3.77450772e-02f, -4.14436273e-02f, 1.35587445e-02f, 1.23973219e-02f, -2.97501683e-02f, 7.71051869e-02f, 1.18346298e-02f, 7.01618334e-03f, -1.05586452e-02f, 7.66803622e-02f,
  -1.23418048e-02f, 1.17410302e-01f, 1.11240119e-01f, 2.91253682e-02f, 6.91079944e-02f, -2.01746374e-02f, 2.17818879e-02f, -2.34830361e-02f, -6.67599402e-03f, 1.36600569e-01f,
  2.87328660e-01f, 2.66233515e-02f, 1.65157393e-01f, -8.91526863e-02f, -2.29304153e-02f, 7.79729858e-02f, 8.26052055e-02f, 1.04072116e-01f, 4.86131199e-02f, 2.32639667e-02f,
  3.91927175e-02f, -8.07641894e-02f, -9.07395408e-02f, -7.18542859e-02f, 7.54885375e-02f, -2.75770444e-02f, -8.84888843e-02f, 3.95090058e-02f, 1.85080748e-02f, -7.85702374e-03f,
  -1.34655774e-01f, 7.62691945e-02f, 1.07104622e-01f, -4.79188226e-02f, 1.64057128e-02f, -1.40180051e-01f, 7.58005977e-02f, -2.65857507e-03f, 1.91776343e-02f, -5.16349003e-02f,
  5.08722244e-03f, 2.45502204e-01f, -5.96884713e-02f, -1.00641683e-01f, -4.06995676e-02f, -6.38238564e-02f, 6.48851693e-02f, 2.57003624e-02f, 5.53801283e-02f, 5.92762157e-02f,
  1.91370472e-02f, 1.53915479e-03f, -7.09590018e-02f, 4.19267602e-02f, 4.77489233e-02f, -4.42925747e-03f, 8.28878358e-02f, -1.33013232e-02f, 4.86070476e-02f, 1.66877154e-02f,
  1.84237640e-02f, -4.43849014e-03f, 1.00258797e-01f, 8.31487998e-02f, 1.16399355e-01f, -6.57717511e-02f, 5.16488813e-02f, 9.38846990e-02f, 4.57814112e-02f, -7.57297948e-02f,
  4.81934194e-03f, -3.40530351e-02f, -2.62071379e-02f, -6.11583032e-02f, 1.71111580e-02f, 5.29761128e-02f, 4.33187895e-02f, -5.39382845e-02f, -5.69313057e-02f, -1.90710109e-02f,
  -9.78903994e-02f, 2.51036864e-02f, -3.46487202e-02f, 6.77909181e-02f, -5.26077524e-02f, -1.87110137e-02f, 5.51496819e-02f, 4.48459685e-02f, 6.86380342e-02f, -8.30258708e-03f,
  -3.80887091e-02f, 1.17100932e-01f, -3.01155634e-02f, 8.11454281e-02f, -4.70588282e-02f, 7.79970288e-02f, -5.83526902e-02f, -4.92617004e-02f, 2.89857816e-02f, -3.61765660e-02f,
  -1.57811344e-01f, 7.32491724e-03f, -7.05883726e-02f, -9.43432152e-02f, -6.06495030e-02f, -9.44744423e-03f, -5.76765053e-02f, -4.97600660e-02f, 1.93370581e-02f, 6.37074932e-02f,
  -1.28007913e-02f, -6.34024739e-02f, 6.66926280e-02f, -4.79561649e-02f, 1.35871563e-02f, 2.90082525e-02f, 3.54211405e-02f, 2.94352882e-02f, -4.70522828e-02f, 1.74933188e-02f,
  -1.29472107e-01f, -6.16481639e-02f, 2.34623086e-02f, -1.35254115e-01f, -6.36130571e-02f, -7.25961924e-02f, -1.22666784e-01f, -3.26730423e-02f, 4.17585857e-02f, -1.15837194e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.41864464e-01f, 1.15014523e-01f, 4.82790321e-02f, 1.22408390e-01f, 1.39209419e-01f, 1.96261615e-01f, 2.10367292e-02f, 3.38274628e-01f, 1.56203896e-01f, 1.44885182e-01f,
  1.39727935e-01f, 2.06033453e-01f, 7.58630782e-02f, 1.35121316e-01f, -2.39714421e-02f, -2.46640407e-02f, 3.29501301e-01f, 1.89451635e-01f, 3.24332714e-01f, 1.25067234e-01f,
  5.33155464e-02f, 1.43511236e-01f, 1.65734172e-01f, -4.11467766e-03f, 1.00892000e-01f, 9.72341150e-02f, 6.52157143e-02f, 1.51574090e-01f, 1.17017075e-01f, 1.74138710e-01f,
  1.54983282e-01f, 2.07247451e-01f, 1.22958690e-01f, 2.58765936e-01f, 2.29680449e-01f, 7.39088953e-02f, 3.23782742e-01f, 1.29632190e-01f, 5.71076050e-02f, 8.81864429e-02f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  1.40518323e-01f, -6.37739152e-02f, -6.64649069e-01f, -1.46947235e-01f, -1.71077117e-01f, -3.84707928e-01f, -3.47586125e-01f, -1.70687318e-01f, -8.98973942e-02f, -3.20600063e-01f,
  -2.72526592e-01f, -4.17365134e-01f, -4.54195291e-01f, -1.09805483e-02f, -2.61390001e-01f, -1.26423270e-01f, 3.46685648e-01f, 2.84735616e-02f, 1.63975865e-01f, -3.58864218e-02f,
  -2.95927655e-02f, -5.38520753e-01f, 2.95301467e-01f, -2.89420784e-01f, 1.51979432e-01f, 2.91944325e-01f, 5.44758976e-01f, 4.35718566e-01f, -1.23786159e-01f, -8.21082946e-03f,
  -7.04890564e-02f, -3.24925482e-01f, 9.34983790e-02f, -1.27511799e-01f, -1.35803953e-01f, 3.77384216e-01f, 1.07927993e-01f, 1.57861918e-01f, -3.86384316e-02f, -1.28285572e-01f,
  2.05642834e-01f, 1.48774952e-01f, -1.77778333e-01f, 2.00713903e-01f, -2.91274749e-02f, 3.70923221e-01f, -2.60991126e-01f, -8.16946104e-02f, 9.69592184e-02f, -2.76034810e-02f,
  1.08427778e-01f, -1.12130232e-01f, -1.35046646e-01f, -5.90709373e-02f, -7.66092539e-02f, -3.21400613e-02f, -4.03976403e-02f, 6.72279656e-01f, -2.53317237e-01f, -3.80345210e-02f,
  -9.72589999e-02f, 1.55600971e-02f, 2.16498911e-01f, 9.38270763e-02f, -3.48338813e-01f, 7.76977688e-02f, -1.88097253e-01f, 2.33392462e-01f, 1.77351907e-01f, -1.53186202e-01f,
  3.25103134e-01f, 2.78035730e-01f, 1.69080704e-01f, 4.04246226e-02f, -5.99066377e-01f, -1.48225918e-01f, -5.16292155e-01f, -4.79852051e-01f, -6.16266310e-01f, 2.95556933e-01f,
  2.14637309e-01f, -2.18643900e-02f, 2.03593478e-01f, 3.83258134e-01f, 2.34013095e-01f, -6.10980272e-01f, 5.49487434e-02f, -6.95551753e-01f, 5.48028238e-02f, -7.29669183e-02f,
  1.56725332e-01f, -1.46677107e-01f, 5.53559005e-01f, -2.95724452e-01f, -6.54044375e-02f, 4.01897997e-01f, 3.62461060e-01f, -9.99316275e-02f, 6.53450340e-02f, 2.89740831e-01f,
  1.23627007e-01f, -2.82098055e-01f, 1.81173548e-01f, 2.27439329e-01f, 7.53127873e-01f, -2.91108549e-01f, -2.15055078e-01f, -2.46510163e-01f, 4.27418984e-02f, 2.59020329e-02f,
  -1.70665443e-01f, 1.80214033e-01f, 9.00336429e-02f, -5.93291074e-02f, 2.97684632e-02f, -3.35320741e-01f, -4.86923419e-02f, -1.75628409e-01f, 1.80692479e-01f, -1.69303268e-01f,
  7.00573325e-02f, -3.61291111e-01f, 2.46913563e-02f, 1.02918223e-01f, -6.84385896e-02f, -3.28621268e-02f, 2.32590511e-01f, 7.65107200e-02f, 2.69663274e-01f, 4.51868504e-01f,
  2.32274741e-01f, -1.98610008e-01f, -1.74825341e-01f, 4.88901623e-02f, 1.62894428e-01f, 9.36433375e-02f, 2.44402885e-01f, 5.18278033e-02f, 4.19681221e-01f, 2.58524626e-01f,
  4.01750207e-01f, -3.23782027e-01f, 2.85617411e-01f, 4.61907864e-01f, -3.72384787e-01f, 2.23357812e-01f, -6.70195371e-02f, 3.98292452e-01f, -1.78659871e-01f, -4.27778095e-01f,
  1.31645769e-01f, -6.34639800e-01f, -5.83630288e-03f, -1.38991758e-01f, -1.70093074e-01f, 8.30161422e-02f, -4.06521022e-01f, 8.40397626e-02f, -1.08622044e-01f, 1.17884859e-01f,
  2.17897132e-01f, 3.35452527e-01f, -5.67801334e-02f, -1.14445239e-01f, 6.70148432e-02f, -5.23938611e-02f, 1.69188768e-01f, -1.33887082e-01f, 2.03324631e-01f, 6.66633308e-01f,
  -3.48705739e-01f, -3.65562625e-02f, -1.81841403e-01f, -2.43498564e-01f, -1.56164214e-01f, -5.59872575e-02f, 3.05426180e-01f, 1.72928035e-01f, 1.92713439e-01f, 3.99092704e-01f,
  9.49571058e-02f, -2.19175443e-01f, -3.09836924e-01f, -6.39154911e-02f, -3.14147502e-01f, 1.39419779e-01f, -2.98401684e-01f, -2.36137286e-01f, -2.61124790e-01f, -2.44687721e-01f,
  -1.63702350e-02f, -5.34667447e-02f, -5.02412654e-02f, 1.95229333e-02f, 2.42155984e-01f, -7.56132603e-02f, 1.27635077e-02f, 1.27015546e-01f, 2.30224609e-01f, -2.71261871e-01f,
  -7.83892810e-01f, -2.44426966e-01f, 3.38778257e-01f, 1.07172504e-01f, 2.38498554e-01f, -2.09446996e-01f, -2.04264775e-01f, -4.79038745e-01f, -1.54125750e-01f, -6.22789487e-02f,
  1.64029717e-01f, 1.69697642e-01f, -6.30175233e-01f, 4.53649580e-01f, 2.74034869e-02f, -1.87208295e-01f, -2.17153788e-01f, 2.26391315e-01f, 5.13022244e-01f, -5.76545708e-02f,
  -1.35631412e-01f, 6.16663635e-01f, -3.22604440e-02f, -2.72635043e-01f, 9.88304019e-02f, -3.15562844e-01f, -6.03166297e-02f, -4.39994812e-01f, -1.42253801e-01f, -1.03182256e-01f,
  2.55494356e-01f, -1.72954559e-01f, -2.11378649e-01f, -1.23014346e-01f, -3.15914094e-01f, 4.17760938e-01f, -8.70110542e-02f, -3.06457043e-01f, 1.41960636e-01f, 1.58800766e-01f,
  3.81009690e-02f, -1.95384800e-01f, -8.23430941e-02f, 9.76468325e-02f, 1.53224126e-01f, -2.19792873e-01f, 2.91515708e-01f, -2.36340851e-01f, 1.45385116e-01f, 6.41153514e-01f,
  -2.13817880e-01f, -1.80591010e-02f, 3.70680243e-01f, 4.68081012e-02f, -1.75480515e-01f, 7.43753910e-02f, 7.19846040e-03f, -3.92065912e-01f, 1.62711889e-01f, -9.48710181e-03f,
  -2.07579821e-01f, -2.14446694e-01f, -6.06385589e-01f, -4.32547718e-01f, 3.32936674e-01f, 1.86394006e-01f, 2.22925127e-01f, 4.75493558e-02f, 4.31694835e-01f, 5.53991914e-01f,
  7.20680598e-03f, 2.99035698e-01f, -1.01864770e-01f, -2.85587639e-01f, 2.77780980e-01f, 3.32137823e-01f, -2.49014646e-01f, 5.31363845e-01f, 3.04988533e-01f, 1.88365698e-01f,
  -1.74837828e-01f, -2.08167538e-01f, -4.20098722e-01f, 5.36730289e-01f, -5.94465137e-02f, 9.93458256e-02f, 1.02700181e-01f, -1.76216856e-01f, -1.80271670e-01f, -7.74280354e-02f,
  -1.42287374e-01f, 1.90875232e-01f, -1.57352798e-02f, 7.72326812e-03f, -1.64725080e-01f, -7.25685805e-02f, -3.52348775e-01f, -1.13039404e-01f, -3.99931669e-02f, -3.13828230e-01f,
  -9.27324593e-02f, -7.38325119e-02f, -1.25687689e-01f, 2.13255450e-01f, 1.89948931e-01f, 1.05010495e-01f, -9.34383348e-02f, -1.08732007e-01f, 3.73873919e-01f, 3.71236861e-01f,
  -2.34755233e-01f, 1.59685284e-01f, 5.48564851e-01f, 3.24958682e-01f, -5.49598299e-02f, -1.01766005e-01f, 4.67953503e-01f, -8.55784565e-02f, 5.08792251e-02f, 5.00589721e-02f,
  2.74789095e-01f, 2.94319987e-01f, 4.93116200e-01f, 1.65322825e-01f, -6.45195544e-02f, -1.19077384e-01f, 2.31678635e-01f, 5.12937129e-01f, 9.01816338e-02f, 3.44237179e-01f,
  -4.72536206e-01f, 5.58760047e-01f, -6.47115588e-01f, -1.53209791e-01f, -4.44624238e-02f, -1.61296904e-01f, 3.73366654e-01f, -3.64442766e-01f, -1.18316673e-01f, -2.06562683e-01f,
  1.20815709e-01f, -4.23022985e-01f, 5.43761551e-01f, 3.05248529e-01f, 7.61370361e-01f, -1.66142821e-01f, -1.98515862e-01f, -1.76532522e-01f, -9.74477753e-02f, -3.39220256e-01f,
  2.27944851e-02f, 9.08344015e-02f, -2.57682681e-01f, -3.35850984e-01f, 1.44687817e-01f, 6.04821928e-02f, -1.11837313e-01f, 3.72113645e-01f, -1.52201476e-02f, -8.18542466e-02f,
  -1.49719536e-01f, -1.46052286e-01f, 3.74737769e-01f, 2.89359957e-01f, -7.34885037e-02f, 6.42157137e-01f, 2.85132006e-02f, -3.28102708e-02f, -2.14760005e-03f, -4.31642169e-03f,
  -1.15452960e-01f, -2.38260895e-01f, -1.02833994e-01f, 8.64997953e-02f, -1.69771567e-01f, 2.90345639e-01f, 1.67526394e-01f, 8.54353085e-02f, 1.79596633e-01f, 9.80419591e-02f,
  4.17331159e-01f, 1.42901495e-01f, 2.02610433e-01f, -1.31451681e-01f, 1.11161016e-01f, 3.09762489e-02f, -5.76807380e-01f, 1.20212212e-02f, -1.94402233e-01f, -9.81268194e-03f,
  1.27660722e-01f, -3.56751354e-03f, -2.44277492e-01f, 1.59183562e-01f, 3.56969684e-01f, 7.03248978e-02f, 5.04218817e-01f, 4.24269259e-01f, 4.17347640e-01f, 2.74234802e-01f,
  -4.08313155e-01f, 6.76195398e-02f, -4.51139361e-01f, -5.04285157e-01f, 3.41046929e-01f, -3.73989165e-01f, -1.11019477e-01f, 5.04432380e-01f, 2.87316710e-01f, 1.27524808e-01f,
  -2.19520822e-01f, -1.50947914e-01f, -8.32458511e-02f, -1.35497183e-01f, -1.74896821e-01f, -1.56069443e-01f, -1.43702284e-01f, 5.41288912e-01f, 3.27857226e-01f, -2.76651233e-01f,
  5.25606215e-01f, 1.34234786e-01f, -1.43072173e-01f, -9.94601771e-02f, -6.68526962e-02f, -3.15165043e-01f, 4.82478458e-03f, -1.39998898e-01f, -8.20837095e-02f, 1.44101769e-01f,
  6.74695447e-02f, -2.03909382e-01f, -2.87505388e-01f, 2.08644524e-01f, -8.34723637e-02f, 5.74060857e-01f, -2.34963939e-01f, 4.26291287e-01f, -3.84179205e-01f, 7.76235238e-02f,
  -1.69630110e-01f, -4.33917552e-01f, -1.23510109e-02f, 1.00584053e-01f, -3.38301122e-01f, -1.74286857e-01f, -9.10801515e-02f, 1.98006168e-01f, -2.46515781e-01f, -1.16819434e-01f,
  -1.76476687e-01f, -2.98985541e-01f, -1.03689671e-01f, -2.03899711e-01f, -8.34213346e-02f, -6.29370958e-02f, -4.30520140e-02f, -9.79134664e-02f, -3.65174085e-01f, -3.81100506e-01f,
  3.93411994e-01f, -3.08091283e-01f, 2.43796960e-01f, -2.62640983e-01f, 2.18445823e-01f, 2.21331209e-01f, -3.26411784e-01f, -1.93815857e-01f, -2.09405203e-03f, 1.51239485e-01f,
  -2.94029891e-01f, 3.00518274e-01f, -4.47423719e-02f, 2.79414475e-01f, -9.20914263e-02f, -1.58255816e-01f, -1.15486868e-01f, 5.09367976e-03f, 3.50809991e-01f, 1.41261294e-01f,
  -1.85329318e-01f, -2.09631190e-01f, -4.80318107e-02f, -1.29767925e-01f, -3.23627263e-01f, 1.73819512e-01f, -3.51927429e-02f, -1.73581596e-02f, -1.28464131e-02f, 3.92718583e-01f,
  -1.03001207e-01f, 1.44069850e-01f, -1.44250467e-01f, -1.20468535e-01f, 2.17651069e-01f, 9.55516249e-02f, 3.03652465e-01f, -2.46736646e-01f, 3.08794290e-01f, -1.99943092e-02f,
  -1.69256981e-02f, -1.58440843e-01f, 8.43620121e-01f, 1.03120081e-01f, -7.39635825e-02f, 2.67483771e-01f, 2.72745579e-01f, -1.92740217e-01f, -1.08255781e-01f, -1.31431594e-01f,
  -6.35913461e-02f, -2.55037129e-01f, -1.76593259e-01f, -9.12251025e-02f, 1.47507504e-01f, 3.35441306e-02f, -4.57522310e-02f, 1.35772586e-01f, -3.38283300e-01f, -4.49009091e-01f,
  3.54714274e-01f, 2.16673255e-01f, 1.81178704e-01f, 1.09598257e-01f, -4.62286800e-01f, -5.37916481e-01f, -2.72069573e-01f, -1.64507851e-01f, -5.87144613e-01f, 2.73188576e-02f,
  -6.70305490e-01f, -4.65094507e-01f, -1.03460722e-01f, 1.45959079e-01f, 3.50056648e-01f, 5.72358608e-01f, -2.33300164e-01f, 5.18346950e-02f, 3.83095443e-02f, -2.25552067e-01f,
  -7.83787519e-02f, 1.95803925e-01f, 1.73239648e-01f, 2.29790285e-01f, -2.50462621e-01f, -1.87205389e-01f, 1.11921199e-01f, -3.60842288e-01f, -1.85485587e-01f, -2.76544929e-01f,
  -1.99531704e-01f, -1.23646006e-01f, 5.25178671e-01f, -8.28903839e-02f, 6.45782411e-01f, -1.61758110e-01f, 2.03453064e-01f, -2.57948667e-01f, -1.91199973e-01f, 1.33330747e-01f,
  -2.12231129e-02f, 2.06108078e-01f, -9.70898196e-02f, 3.93778980e-02f, -2.84454495e-01f, -1.04289941e-01f, 1.13779157e-01f, 1.35033116e-01f, -2.39302441e-01f, -2.36229509e-01f,
  -1.86219528e-01f, -1.75239533e-01f, -4.06707406e-01f, 3.63624215e-01f, 1.04295515e-01f, 3.83243896e-02f, -4.10444438e-01f, -3.67699921e-01f, 2.08200142e-01f, 6.75189421e-02f,
  2.54886389e-01f, 2.42165357e-01f, 7.27899969e-02f, -7.39900162e-03f, -3.25279564e-01f, -5.29649667e-02f, -1.47984356e-01f, 4.28167015e-01f, 4.47144061e-01f, 6.97298229e-01f,
  3.82874399e-01f, 1.77603960e-01f, 3.70152086e-01f, -6.43083453e-02f, 6.62990570e-01f, 5.11709154e-01f, 6.69879019e-01f, -2.98413277e-01f, -4.45247680e-01f, 1.83974043e-01f,
  -2.31817797e-01f, -6.76620677e-02f, -6.72560781e-02f, 4.71316189e-01f, -3.90041247e-02f, -2.47953057e-01f, -1.86150730e-01f, -1.42731249e-01f, -1.12840734e-01f, 8.01688880e-02f,
  3.74758728e-02f, 1.83466122e-01f, -1.51156485e-01f, 7.58078918e-02f, -7.78978392e-02f, -9.14888903e-02f, -2.98480093e-01f, 2.08629921e-01f, -6.48128390e-02f, -2.53582299e-01f,
  7.51612708e-02f, 4.08104025e-02f, 1.70030892e-01f, -8.71237591e-02f, 1.31902561e-01f, 3.55916381e-01f, 7.97261372e-02f, -2.63146937e-01f, -4.96850275e-02f, -3.17919366e-02f,
  -1.68613225e-01f, 3.67352366e-01f, -6.69732913e-02f, -1.30449444e-01f, 6.79615557e-01f, 7.89232254e-02f, -1.47389650e-01f, -5.99355586e-02f, -1.90723181e-01f, -1.09731205e-01f,
  3.93050462e-01f, 4.05719094e-02f, -1.25281647e-01f, 7.29459003e-02f, 1.08849801e-01f, 1.58530876e-01f, 1.12913482e-01f, 1.75195605e-01f, 7.91604910e-03f, -7.28080645e-02f,
  1.93392083e-01f, -5.44684827e-01f, 1.94901347e-01f, -1.69763565e-02f, -2.13266343e-01f, 1.38478382e-02f, 1.21513180e-01f, -1.91617250e-01f, 3.89685780e-01f, -4.79676872e-01f,
  -2.19003469e-01f, 4.22562808e-01f, -8.27679336e-02f, -5.50889134e-01f, -1.35322899e-01f, -2.54812956e-01f, -8.05140436e-02f, -3.28009665e-01f, -2.15196416e-01f, 5.27356863e-01f,
  2.22303584e-01f, 4.86645430e-01f, -4.76682633e-02f, -3.14133734e-01f, 3.80010605e-02f, 1.30015938e-02f, -2.01307520e-01f, -2.88287736e-02f, -1.09402359e-01f, 1.72531649e-01f,
  -6.02391809e-02f, -2.14432701e-01f, 5.14124453e-01f, 1.09696157e-01f, -8.99895579e-02f, -1.93460017e-01f, 3.15821916e-01f, -2.44836971e-01f, -7.11478963e-02f, -5.92809776e-03f,
  6.55561835e-02f, -2.01711804e-01f, 9.74226668e-02f, 3.43634263e-02f, -1.52165100e-01f, -1.81291342e-01f, -1.57654256e-01f, -3.75388086e-01f, -1.67359129e-01f, -7.11337179e-02f,
  6.44633949e-01f, -8.15997347e-02f, -2.56991833e-01f, -1.31807536e-01f, 4.89438623e-01f, 1.05539914e-02f, 1.00922041e-01f, 1.48303419e-01f, 5.03115989e-02f, 1.57258436e-02f,
  3.00206579e-02f, 8.29012394e-02f, 1.16855659e-01f, -4.16859835e-02f, 1.72080830e-01f, -5.50561666e-01f, -3.13129455e-01f, 3.69021386e-01f, 2.25613415e-01f, -1.93254203e-01f,
  2.48371407e-01f, 3.70802820e-01f, -2.82868505e-01f, 1.92796141e-02f, -2.86485523e-01f, 6.34172618e-01f, -3.42581719e-01f, 4.90917414e-01f, -1.20739732e-02f, -2.58479873e-03f,
  1.22117847e-01f, -3.28399939e-03f, 6.55750036e-01f, -1.46164656e-01f, -2.16823652e-01f, -2.63675660e-01f, -9.24578781e-05f, -1.26688031e-03f, -3.28329593e-01f, -5.05688861e-02f,
  3.11452840e-02f, -2.27057263e-01f, 4.83676381e-02f, -7.23727867e-02f, -9.78739113e-02f, -3.13947558e-01f, -2.39535898e-01f, 3.82891521e-02f, 2.55306870e-01f, -1.32365763e-01f,
  -2.35390142e-01f, 6.09930381e-02f, -3.58510435e-01f, 1.25426784e-01f, -3.44889432e-01f, 2.98840791e-01f, -5.71024567e-02f, -1.36096925e-01f, -5.49392402e-02f, -1.85648263e-01f,
  -1.15086816e-01f, -9.50784832e-02f, -2.43477717e-01f, 3.77031028e-01f, -1.46462634e-01f, 4.26065892e-01f, -1.51078656e-01f, 4.08503026e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.21371740e-01f, 2.08127901e-01f, 1.18013114e-01f, -1.06354125e-01f, 2.32993858e-03f, 2.62503400e-02f, -1.56492442e-01f, -1.16934828e-01f, 3.92145291e-02f, -3.07716746e-02f,
  -6.57867044e-02f, 8.82858783e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    