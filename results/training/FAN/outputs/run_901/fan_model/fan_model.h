/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.24765515e-01f, 1.33960128e-01f, 9.90037471e-02f, 3.10102534e-02f, 5.57861803e-03f, -1.32984325e-01f, 7.67765865e-02f, -1.13083154e-01f, -1.97350860e-01f, 8.35312828e-02f,
  -2.36306451e-02f, -2.93950558e-01f, -1.72830582e-01f, -6.49643689e-02f, -9.61854979e-02f, 9.82026234e-02f, 1.35940149e-01f, 4.89897057e-02f, -7.56113231e-02f, -1.45421684e-01f,
  -5.56938201e-02f, 8.37508515e-02f, -3.77316661e-02f, 6.01500319e-03f, -8.64683278e-03f, -1.23620667e-01f, 1.36453569e-01f, 6.94629848e-02f, 1.49016064e-02f, 3.28183144e-01f,
  2.64722016e-02f, 8.81028324e-02f, -1.07877932e-01f, -5.58267944e-02f, 4.97847460e-02f, -9.18316375e-03f, -5.63219190e-02f, 5.12120053e-02f, 4.93252650e-02f, 5.54987602e-02f,
  6.85569122e-02f, -4.48752940e-02f, -1.02256075e-01f, -4.08008099e-02f, 7.78319612e-02f, -8.83107819e-03f, 1.03037141e-01f, 4.39984724e-02f, -4.51287590e-02f, -5.27210571e-02f,
  2.66115032e-02f, -1.42231137e-02f, 1.87638663e-02f, 3.69410105e-02f, 1.27852997e-02f, -3.11932974e-02f, 8.54721218e-02f, 9.84493867e-02f, 5.65365888e-02f, 6.71317801e-02f,
  1.16537453e-03f, -1.97377838e-02f, -8.59469175e-03f, 4.09586392e-02f, 4.71417010e-02f, 8.33428837e-03f, -3.07804849e-02f, -3.87563705e-02f, 3.27291549e-03f, 5.79691194e-02f,
  -1.29051670e-01f, 4.09981869e-02f, 1.54551193e-02f, 1.78627558e-02f, -4.26815189e-02f, 7.71512762e-02f, -2.60428730e-02f, -2.41964702e-02f, -1.22069214e-02f, -4.57651615e-02f,
  6.05934951e-03f, -1.52183902e-02f, -2.90683173e-02f, 1.41542312e-02f, -3.07375193e-02f, 8.40224475e-02f, 5.55891506e-02f, 1.08119838e-01f, -2.63919104e-02f, 7.36194178e-02f,
  -2.21723989e-01f, -1.99297905e-01f, -8.76038745e-02f, -1.39274560e-02f, 1.54767642e-02f, -1.20935263e-02f, -5.55592217e-03f, 1.72795821e-02f, -1.07171247e-02f, 4.57773469e-02f,
  -7.88036808e-02f, 1.33252526e-02f, -4.95601483e-02f, -6.60694996e-03f, 2.62046568e-02f, 3.90729215e-03f, 2.86084656e-02f, -6.91815019e-02f, -4.80640009e-02f, -5.51415458e-02f,
  3.42460200e-02f, -3.13278548e-02f, -4.63487245e-02f, -2.94649582e-02f, 6.47806842e-03f, -6.89916164e-02f, -2.03572512e-02f, 2.67717801e-02f, -3.68924029e-02f, -8.44997838e-02f,
  -3.42777558e-02f, -2.81362906e-02f, -2.75105610e-02f, -1.24564447e-01f, -1.36300474e-01f, -9.20975506e-02f, -2.10092247e-01f, 2.28291918e-02f, -3.27546336e-02f, -1.21805526e-01f,
  4.88216914e-02f, 4.32510599e-02f, 1.74313597e-02f, 7.68155754e-02f, 1.26639947e-01f, 2.25112196e-02f, -4.12135459e-02f, 1.36136368e-01f, 1.61434591e-01f, -2.04801112e-02f,
  6.24408983e-02f, 1.39911519e-02f, 8.05132389e-02f, 7.43252113e-02f, -6.81878477e-02f, -1.76673802e-03f, 8.05640072e-02f, -1.47602027e-02f, -6.72439784e-02f, -1.50341168e-01f,
  1.22830331e-01f, -1.10258602e-01f, 2.55090892e-02f, -7.20262825e-02f, -7.74034187e-02f, 4.23590001e-03f, -8.80169347e-02f, -1.66644622e-02f, 5.62772863e-02f, 6.43577278e-02f,
  7.68530369e-02f, -1.15455519e-02f, -2.60297935e-02f, -5.26210964e-02f, -5.69154173e-02f, -2.57027838e-02f, 1.50961513e-02f, -1.54917100e-02f, 3.84537764e-02f, -1.96787361e-02f,
  -7.32504055e-02f, -7.34330267e-02f, 3.08866594e-02f, 4.64166626e-02f, -5.46138473e-02f, 1.41652133e-02f, -5.15506826e-02f, 2.18217634e-02f, 8.12399462e-02f, 3.05709895e-02f,
  1.27121406e-02f, 1.22670196e-02f, -2.59593017e-02f, -6.77631004e-03f, 1.09365946e-02f, 2.34842878e-02f, 5.46864085e-02f, 2.81285569e-02f, 3.88914458e-02f, 3.20675112e-02f,
  1.70186143e-02f, 3.29104923e-02f, -5.31147309e-02f, 9.42600146e-02f, 1.02246171e-02f, 4.37637419e-02f, 3.31557281e-02f, -2.38714647e-02f, 4.28326018e-02f, 2.65219472e-02f,
  -5.14035933e-02f, 1.48724318e-02f, -9.69215762e-03f, 5.76307215e-02f, -3.46339345e-02f, 1.59615725e-02f, -5.49889803e-02f, 9.07304808e-02f, -7.15023428e-02f, -1.03123955e-01f,
  1.16389450e-02f, 1.32760197e-01f, -5.42422161e-02f, -3.28569524e-02f, 1.85596552e-02f, -1.24632446e-02f, -8.31579715e-02f, 3.59064043e-02f, -1.42107280e-02f, -5.48921973e-02f,
  5.96115738e-02f, -4.83807884e-02f, -2.63619069e-02f, 9.90736037e-02f, 5.70109934e-02f, 7.96921626e-02f, -5.69313206e-02f, 1.82548519e-02f, 5.83821796e-02f, 1.61240175e-02f,
  -3.73320580e-02f, -1.36604249e-01f, -7.36593679e-02f, 2.44203792e-03f, 6.79097027e-02f, -4.66483906e-02f, -4.33036219e-03f, -2.56301351e-02f, -1.24282921e-02f, -9.10151899e-02f,
  1.79180205e-01f, 2.81434227e-02f, 1.74661338e-01f, 1.71226665e-01f, 2.04370156e-01f, 1.81692347e-01f, 3.08430016e-01f, 1.45450428e-01f, 2.32808702e-02f, 1.47963181e-01f,
  6.35385588e-02f, -1.22190498e-01f, -1.50795728e-01f, -6.92065358e-02f, -1.08432509e-01f, 1.65179893e-01f, 1.58527136e-01f, -1.05313204e-01f, -1.12737924e-01f, 1.61009014e-01f,
  5.60628809e-02f, 2.26158146e-02f, -1.36184990e-01f, -7.13595748e-02f, 2.22514063e-01f, -7.38860518e-02f, 5.64614981e-02f, 2.22055195e-03f, -3.09571903e-03f, 1.32541761e-01f,
  1.04246594e-01f, 5.73287942e-02f, 2.85015199e-02f, -5.26394472e-02f, -5.67952171e-04f, 2.68319529e-02f, 8.56306031e-03f, 1.14796986e-03f, -3.87196280e-02f, -4.39999886e-02f,
  -6.90404028e-02f, 1.54897738e-02f, -2.48736199e-02f, -1.26733705e-01f, 3.41691189e-02f, -2.64538620e-02f, -4.00097203e-03f, -2.14731842e-02f, -4.08515930e-02f, 1.13374688e-01f,
  2.96920035e-02f, 3.43506224e-02f, 7.85918012e-02f, 8.07163939e-02f, -2.12454069e-02f, 5.17412946e-02f, 6.89218789e-02f, 1.36779957e-02f, -1.50678502e-02f, 1.00609869e-01f,
  6.13251328e-03f, -1.48926089e-02f, -5.45584485e-02f, 4.77496162e-02f, -1.08571492e-01f, 3.93923596e-02f, 2.67517678e-02f, -3.49346474e-02f, 4.47274595e-02f, -5.57945669e-02f,
  -2.96148378e-02f, 1.19737964e-02f, -4.55158427e-02f, -2.97437813e-02f, 1.87010206e-02f, 3.38594727e-02f, -6.95214700e-03f, -1.17400754e-02f, -5.87112196e-02f, -5.51301315e-02f,
  2.81493943e-02f, 2.05180142e-02f, 4.78956476e-02f, -2.91014812e-03f, -3.92998680e-02f, -4.63719219e-02f, 3.87507081e-02f, -1.96177214e-02f, -2.25435197e-02f, -8.50623325e-02f,
  4.12794203e-03f, -5.04047144e-03f, 9.58383679e-02f, 6.22920170e-02f, -6.11036457e-02f, -1.76888648e-02f, 5.47541603e-02f, -8.87962803e-03f, 4.18240391e-02f, 7.16791824e-02f,
  3.49966995e-02f, 2.11034827e-02f, -5.21731265e-02f, 3.77924405e-02f, -4.09570895e-02f, 6.52006492e-02f, -3.72390337e-02f, 3.02125383e-02f, -1.35465562e-02f, 7.67261013e-02f,
  9.16657038e-03f, -6.33957833e-02f, -2.68872064e-02f, 2.24817265e-02f, 8.30526836e-03f, 7.48909712e-02f, 7.27635920e-02f, 6.54917061e-02f, -2.34607421e-02f, 1.74708962e-02f,
  1.05868258e-01f, -1.05053090e-01f, 8.06419458e-03f, 1.41663000e-01f, -7.95176532e-03f, -2.51746140e-02f, -7.84968063e-02f, -2.42824424e-02f, 1.59414172e-01f, 6.12323638e-03f,
  3.61853801e-02f, 1.12389103e-01f, 2.15499941e-02f, 3.39374170e-02f, -8.19371492e-02f, -8.18285942e-02f, -8.09722543e-02f, 8.32733214e-02f, 4.75774854e-02f, 4.71953265e-02f,
  -7.68878460e-02f, 1.10536546e-01f, 1.04976453e-01f, 1.10051289e-01f, 1.20212406e-01f, 6.92990944e-02f, -8.32844675e-02f, -1.41306398e-02f, -1.10345423e-01f, 3.29688974e-02f,
  5.15540801e-02f, -4.05906141e-02f, 4.28843871e-02f, 5.54903783e-02f, -4.11135033e-02f, -2.43102461e-02f, 6.64497865e-03f, -4.08263691e-03f, 6.97035715e-02f, 4.00986262e-02f,
  4.91021834e-02f, 3.11537143e-02f, -1.09440070e-02f, -5.78521974e-02f, 9.80133470e-03f, -6.23010136e-02f, 1.38619291e-02f, 2.35718749e-02f, 9.20480490e-03f, -3.27944644e-02f,
  -7.16904625e-02f, -6.52091503e-02f, 1.92004815e-02f, -1.03191592e-01f, 7.84264877e-03f, -5.17670177e-02f, 3.44508477e-02f, -1.41088320e-02f, -5.17232753e-02f, 4.75105606e-02f,
  1.40207196e-02f, 1.02243274e-02f, -3.25191510e-03f, -2.27374397e-02f, 5.02038896e-02f, 1.77440308e-02f, 5.27324341e-02f, 3.90645042e-02f, -5.89025430e-02f, 5.96458241e-02f,
  4.98919189e-02f, 3.77257094e-02f, 3.37054394e-02f, -2.36853138e-02f, -4.60892171e-02f, 4.09282744e-02f, -1.34640262e-02f, 9.42146257e-02f, -2.03709118e-02f, 1.86799448e-02f,
  -1.04285982e-02f, -1.15647959e-02f, 9.25634708e-03f, -4.06962726e-03f, -3.64719257e-02f, -3.09781320e-02f, 2.62120776e-02f, 6.16377278e-04f, 7.25424439e-02f, 1.97830703e-03f,
  -2.55208667e-02f, -1.59480795e-01f, -1.64771434e-02f, -9.33605731e-02f, -1.14507414e-02f, -4.27433066e-02f, 6.19897153e-04f, 7.77394092e-03f, -9.90922302e-02f, -2.42170412e-02f,
  -2.88116075e-02f, 4.06758226e-02f, -8.59055296e-02f, 1.18538346e-02f, 1.25041241e-02f, -9.28518549e-02f, 3.90990190e-02f, -5.56510827e-03f, -5.27062863e-02f, 3.58647667e-02f,
  -4.97128107e-02f, -3.87328342e-02f, -3.33750509e-02f, 9.23322439e-02f, 2.41449513e-02f, 7.50400797e-02f, 6.29436225e-03f, -1.16574569e-02f, -3.83244716e-02f, 7.00433403e-02f,
  -1.14105716e-01f, 2.43582875e-01f, -3.81000526e-02f, -1.58856153e-01f, -7.31100142e-02f, 5.01690283e-02f, 1.54935196e-01f, 8.76796618e-03f, -2.49029174e-02f, 1.14557132e-01f,
  2.82309204e-02f, -2.32216984e-01f, -1.73853815e-01f, -1.43712878e-01f, -1.54121414e-01f, 5.37485965e-02f, 1.40676484e-01f, -1.30072653e-01f, -1.84072733e-01f, -4.84158322e-02f,
  4.50462336e-03f, -5.11675738e-02f, -5.66867255e-02f, -5.29486276e-02f, 1.00144438e-01f, -7.33220652e-02f, 1.30802453e-01f, 1.29254594e-01f, 1.15422450e-01f, 1.68501750e-01f,
  1.34925973e-02f, 9.78137851e-02f, -1.56522647e-01f, -7.38293305e-02f, 6.73181117e-02f, 8.29660222e-02f, -6.60095289e-02f, 1.80419278e-03f, -6.14592694e-02f, -2.64393305e-03f,
  4.77998983e-03f, -2.91919596e-02f, -1.19854789e-02f, 5.66730052e-02f, 1.09355330e-01f, -5.58513664e-02f, 1.36012599e-01f, -4.10440788e-02f, -1.20090032e-02f, 1.60386395e-02f,
  2.72371694e-02f, -2.37938855e-02f, -9.47706122e-03f, 5.72725199e-02f, 4.02045213e-02f, 5.48286326e-02f, 1.90087818e-02f, 7.15299323e-02f, -3.80243622e-02f, 1.89741701e-01f,
  -5.70497923e-02f, 2.46541165e-02f, -5.75408973e-02f, -1.93909202e-02f, 3.70198786e-02f, -1.44059919e-02f, -3.64783243e-03f, 1.57721469e-03f, 7.49114901e-03f, 8.67142230e-02f,
  5.80071332e-03f, -1.79435760e-02f, -2.86015924e-02f, 4.98904660e-02f, 1.13736158e-02f, 7.94289112e-02f, 8.21864381e-02f, -4.03258093e-02f, -3.30763757e-02f, 6.21625558e-02f,
  9.46695879e-02f, -5.98372333e-03f, 5.57830334e-02f, -3.82845029e-02f, -3.74525934e-02f, -7.35610649e-02f, -4.89762761e-02f, -4.21643071e-02f, -4.85887900e-02f, 8.07425380e-03f,
  6.96075186e-02f, -1.42306715e-01f, -7.64808878e-02f, -4.59419675e-02f, 5.00611588e-02f, -5.22874072e-02f, -2.86041526e-03f, -2.00479385e-02f, 3.27558555e-02f, -2.84177959e-02f,
  -6.60145655e-02f, -9.16992649e-02f, 3.89525108e-02f, 2.72550005e-02f, -2.72876285e-02f, -1.13423303e-01f, 1.08308017e-01f, -3.53389904e-02f, 3.64867337e-02f, 3.18198539e-02f,
  4.26047854e-03f, -8.05658475e-03f, -4.40169834e-02f, -3.64872739e-02f, 1.28340041e-02f, -9.83946994e-02f, -2.27225292e-02f, -3.93535234e-02f, -7.04036430e-02f, -1.54688014e-02f,
  -6.03703260e-02f, 4.03369851e-02f, 1.58077121e-01f, -4.79262397e-02f, -1.17066376e-01f, -3.88887264e-02f, -1.33561477e-01f, -5.18084727e-02f, -6.08925857e-02f, -7.90537447e-02f,
  2.32656323e-03f, 4.35152836e-02f, 8.49517211e-02f, 6.32631779e-02f, -2.38248203e-02f, -5.24805747e-02f, -1.39733776e-01f, -1.32751158e-02f, -1.17931617e-02f, -9.20869783e-02f,
  3.78350541e-02f, -7.47492025e-03f, 1.02225661e-01f, 9.83344465e-02f, 1.95187319e-03f, 1.12579420e-01f, 6.71983436e-02f, 5.81030846e-02f, -2.43311729e-02f, -7.50126094e-02f,
  2.01921254e-01f, -1.20838992e-01f, -7.61560500e-02f, 5.79768280e-03f, 2.99772564e-02f, -4.48560081e-02f, -1.32833468e-02f, -6.46567345e-02f, -5.98484874e-02f, -8.26083869e-03f,
  -5.73175773e-02f, -1.06538020e-01f, 3.64467874e-03f, 6.26576692e-02f, 2.00339295e-02f, -7.41033033e-02f, 3.37448157e-02f, 5.79611994e-02f, -2.81073007e-05f, 1.63340122e-02f,
  1.04052182e-02f, -7.91033581e-02f, -1.22322321e-01f, -5.69343790e-02f, -5.96875474e-02f, -1.35987893e-01f, -8.70227069e-02f, 3.35174077e-03f, -8.07011500e-02f, 2.96668503e-02f,
  5.84402978e-02f, -6.89888000e-02f, -3.81198041e-02f, 6.70446530e-02f, 1.99861526e-02f, 1.35147450e-02f, -3.56356730e-03f, -1.20243030e-02f, -4.96310415e-03f, 2.10488867e-02f,
  -2.21635066e-02f, -1.67178921e-02f, -1.28008612e-02f, 3.21847871e-02f, 3.73721868e-02f, 2.32399441e-02f, -6.60765469e-02f, -3.63707468e-02f, 2.40218434e-02f, -8.55182558e-02f,
  -1.15794484e-02f, -6.09078333e-02f, 5.30529097e-02f, 3.77111584e-02f, -2.77759917e-02f, -1.34692490e-02f, 4.54541259e-02f, -9.88902971e-02f, 1.02342635e-01f, -5.80767132e-02f,
  2.67752022e-01f, -1.42835200e-01f, -1.53194927e-02f, -2.55509485e-02f, 3.65157537e-02f, 1.21297073e-02f, 5.49926870e-02f, -1.12534557e-02f, -2.16860678e-02f, -3.08599900e-02f,
  -9.50548425e-03f, 5.52969500e-02f, 8.84075016e-02f, -5.33111058e-02f, 8.17286782e-04f, -4.59081167e-03f, 1.15629174e-02f, 4.14857529e-02f, -7.00069666e-02f, 8.18282440e-02f,
  4.15638797e-02f, -8.12251940e-02f, 1.12136388e-02f, 1.04653416e-02f, 4.74353582e-02f, -7.51999095e-02f, 8.97976309e-02f, 9.39388350e-02f, -9.94767323e-02f, 8.04653913e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.38961685e-02f, 1.99108906e-02f, -1.14723602e-02f, -7.00682476e-02f, -2.94595212e-02f, -5.07167466e-02f, -7.31808320e-02f, 9.07812864e-02f, -1.02805607e-02f, -4.49766368e-02f,
  -6.04739971e-02f, -1.70017667e-02f, -2.43496932e-02f, 1.27094956e-02f, 3.96933295e-02f, 7.61661902e-02f, -2.31320541e-02f, 5.11008538e-02f, 2.62008049e-02f, -3.29846404e-02f,
  5.07638603e-02f, 3.05057713e-03f, 4.93416702e-03f, 4.24387529e-02f, 5.08263558e-02f, 3.29236165e-02f, -1.11338533e-01f, 1.91866222e-03f, 5.16879447e-02f, -8.05985481e-02f,
  1.88132357e-02f, 1.33075163e-01f, 7.84220174e-02f, -4.42509837e-02f, 4.31397520e-02f, 8.81775767e-02f, -4.97573651e-02f, -1.17598781e-02f, -6.54101670e-02f, 3.85584235e-02f,
  -7.23162442e-02f, 3.66478041e-02f, -6.79902360e-02f, -7.45038539e-02f, -2.23783515e-02f, -7.24411756e-02f, -8.56057554e-03f, 2.07811594e-02f, -5.70277348e-02f, -8.85933563e-02f,
  2.21907888e-02f, 7.77815133e-02f, 1.03236862e-01f, -3.72231193e-02f, -6.72905371e-02f, -6.53985515e-02f, -4.46243733e-02f, 2.42567081e-02f, -3.46924271e-03f, 6.25771433e-02f,
  -1.25936419e-01f, -3.88863496e-02f, -6.60292655e-02f, 7.73164630e-02f, 3.31440009e-02f, 6.52084127e-02f, 5.76138794e-02f, 7.64343813e-02f, -6.91634268e-02f, 6.19076146e-03f,
  -4.41370867e-02f, 1.73579119e-02f, -8.58634114e-02f, -3.69514525e-02f, -2.51370948e-02f, 6.78180605e-02f, 7.32252747e-02f, -7.55826831e-02f, -2.72333212e-02f, -5.34311831e-02f,
  -7.27965012e-02f, 4.13008332e-02f, -9.74758789e-02f, 4.37588692e-02f, -5.58185987e-02f, 3.20879743e-02f, -7.57758170e-02f, 1.70983672e-02f, -5.48789511e-04f, 5.73161058e-02f,
  5.94000425e-03f, 6.94074854e-02f, 9.05378833e-02f, 1.01362377e-01f, -3.77161638e-03f, 5.98397218e-02f, 5.17494753e-02f, -5.99518493e-02f, 6.21595196e-02f, -6.41124770e-02f,
  5.43631762e-02f, -2.10673641e-02f, -2.47421563e-02f, -2.43470445e-02f, -4.11119461e-02f, 6.55265749e-02f, 5.03177606e-02f, 2.66652405e-02f, 8.23154375e-02f, 4.70263837e-03f,
  -1.94251363e-04f, -2.44029500e-02f, -1.44906417e-02f, -2.65377061e-03f, 1.08343273e-01f, 1.17254771e-01f, 3.89451417e-03f, -1.82078648e-02f, 5.38980253e-02f, -1.78264081e-03f,
  -8.08259919e-02f, -8.02258104e-02f, -9.50903594e-02f, -7.05266148e-02f, -1.50946360e-02f, -1.67040844e-02f, 2.92138639e-03f, 4.55149896e-02f, 4.42855991e-02f, -4.69473712e-02f,
  -1.98520664e-02f, 4.06127200e-02f, -5.12703918e-02f, -7.35829249e-02f, 7.85818100e-02f, -1.90274306e-02f, 1.19394951e-01f, 3.40696722e-02f, 3.57687771e-02f, -5.93160875e-02f,
  2.34595951e-04f, -1.06962346e-01f, -5.45683168e-02f, -2.26903725e-02f, -6.69125170e-02f, -3.01894313e-03f, -1.70471184e-02f, -5.03452681e-02f, -1.11630142e-01f, -7.79197589e-02f,
  -1.01009421e-01f, -1.08343670e-02f, 1.87276434e-02f, -3.52262370e-02f, -1.48447452e-03f, 1.10763339e-02f, -1.35181956e-02f, 1.34782055e-02f, 2.33568046e-02f, -1.51953651e-02f,
  -9.49449167e-02f, -1.04470141e-02f, -2.11912338e-02f, -3.22337821e-02f, 5.76770417e-02f, 7.79739618e-02f, -2.55618505e-02f, 5.72618246e-02f, 4.41245809e-02f, -7.45609403e-02f,
  -7.51978979e-02f, -2.65216511e-02f, -1.28542436e-02f, 1.36187105e-02f, 8.37774277e-02f, 9.76911038e-02f, -6.59613162e-02f, -6.94425851e-02f, 5.71365133e-02f, -5.68492711e-02f,
  -8.45509171e-02f, 2.12376635e-03f, 6.36602193e-02f, -7.59978220e-03f, 2.97218096e-02f, -4.96053323e-02f, 2.24479903e-02f, 6.12885877e-02f, 1.78225990e-02f, -5.54647818e-02f,
  -4.79735397e-02f, 8.76120925e-02f, 1.12841523e-03f, 2.28999723e-02f, 3.10829952e-02f, 3.39983292e-02f, 5.45623526e-02f, -5.55309802e-02f, -4.06127088e-02f, 2.04011854e-02f,
  5.59812412e-02f, 7.98642486e-02f, 2.68014520e-02f, -9.27000307e-03f, 4.44412567e-02f, -8.09272006e-02f, 1.37424804e-02f, -2.23204028e-02f, -1.72050726e-02f, 5.44396713e-02f,
  -8.32762569e-03f, 7.35394433e-02f, 3.20764296e-02f, -4.66945805e-02f, 4.88382950e-02f, -4.49253693e-02f, -2.39463281e-02f, 1.47286532e-02f, -5.63647486e-02f, -8.33356194e-03f,
  -4.35997061e-02f, 3.07790283e-02f, 3.63474376e-02f, -2.02234350e-02f, -5.89558575e-03f, -2.73269638e-02f, -2.05436610e-02f, 5.54132741e-03f, 1.09414481e-01f, -4.18271571e-02f,
  6.45554662e-02f, 2.36083847e-02f, 1.24087017e-02f, 9.84666273e-02f, 7.29006454e-02f, 1.41249269e-01f, 8.71328935e-02f, -1.55170094e-02f, -2.52349358e-02f, 5.22340201e-02f,
  1.82942972e-01f, 2.63067335e-02f, 9.60884243e-02f, 1.47062074e-02f, 7.10022682e-03f, 6.38195500e-02f, -5.56730386e-03f, 7.74178654e-02f, 9.37368944e-02f, 3.29609998e-02f,
  1.41686536e-02f, -1.48755144e-02f, 4.82288338e-02f, -1.38794386e-03f, -5.51273972e-02f, -3.26846056e-02f, 8.62302780e-02f, 1.60665959e-01f, 1.48155749e-01f, 1.32199511e-01f,
  -7.13930279e-02f, -5.44407731e-03f, 4.70068119e-02f, 2.10380722e-02f, 4.63068299e-02f, -3.34530510e-03f, -7.16430973e-03f, -3.59781124e-02f, -5.82746081e-02f, 8.63667354e-02f,
  1.64645200e-03f, 1.43988594e-01f, 3.05758640e-02f, 4.39600274e-02f, -1.96645446e-02f, 2.87991576e-02f, -5.03636599e-02f, 3.61799379e-03f, -2.49340907e-02f, -2.83956248e-02f,
  -9.40848291e-02f, 3.36287580e-02f, -7.55917579e-02f, 3.13148089e-02f, -7.64394226e-03f, -6.64587468e-02f, -6.22176901e-02f, 7.40032941e-02f, 4.47008759e-02f, 3.57090533e-02f,
  -1.04404949e-01f, -1.32295266e-02f, 5.63393869e-02f, 2.79651117e-02f, -3.59501652e-02f, -3.61101143e-02f, 1.36117144e-02f, 4.49486673e-02f, 9.28687863e-03f, 9.74386260e-02f,
  1.00926524e-02f, -4.88771610e-02f, 6.34088889e-02f, 2.52231285e-02f, -5.94645329e-02f, -5.13435416e-02f, -1.60287619e-02f, -1.54716205e-02f, -5.85228810e-03f, -2.15376895e-02f,
  -1.13115780e-01f, 2.48723291e-02f, 4.34083827e-02f, 6.10923357e-02f, -1.02916673e-01f, -5.91959246e-02f, 2.92379763e-02f, 2.13626977e-02f, 1.86500326e-02f, -6.15382381e-02f,
  -9.70261544e-02f, -3.71673144e-02f, -6.91106170e-02f, -1.42548503e-02f, -3.20073552e-02f, -3.83863486e-02f, -4.92966510e-02f, 1.30870810e-03f, 7.23547414e-02f, -3.16496603e-02f,
  -1.30539373e-01f, -4.38854657e-02f, 1.28721399e-02f, 9.84289944e-02f, -6.60876855e-02f, -2.21039504e-02f, -2.83282883e-02f, 2.17698999e-02f, -7.01561794e-02f, -3.46983857e-02f,
  -3.08600458e-04f, 4.89875264e-02f, -9.31839123e-02f, -3.15593071e-02f, -1.92900412e-02f, 3.78237478e-02f, -4.68844101e-02f, -1.90692488e-02f, 5.58943525e-02f, -6.24521971e-02f,
  -9.25278887e-02f, 9.02016759e-02f, -7.25918785e-02f, -1.94458179e-02f, 5.17562255e-02f, -4.81029190e-02f, -6.55595139e-02f, -3.97047549e-02f, 2.19834261e-02f, -5.19608632e-02f,
  -1.43464193e-01f, 6.46122126e-03f, -6.67783618e-02f, -6.15590177e-02f, 6.17742445e-03f, 8.46327022e-02f, 4.07230929e-02f, 1.00129917e-01f, 7.54550248e-02f, 8.15977226e-04f,
  3.18711326e-02f, -2.77884137e-02f, -9.83634815e-02f, 1.58315804e-02f, -9.08841044e-02f, -4.47114743e-02f, -1.49625123e-01f, -1.60137922e-01f, -1.26203552e-01f, 1.97477099e-02f,
  -8.67025033e-02f, -1.23036548e-01f, -1.66391641e-01f, -6.40814677e-02f, -3.47007327e-02f, 1.26717240e-01f, 7.22206682e-02f, 6.20527789e-02f, 1.35586172e-01f, 7.55279977e-03f,
  -6.14212379e-02f, 1.34761985e-02f, 7.69632161e-02f, -1.98530722e-02f, 8.07015449e-02f, 8.92212242e-02f, -1.93208717e-02f, -5.35761937e-03f, -4.01901267e-02f, -1.02354968e-02f,
  -1.02685392e-01f, -3.98918651e-02f, -4.16191109e-02f, -2.81625986e-02f, -5.22923432e-02f, -5.49542420e-02f, -5.42124659e-02f, -1.19151391e-01f, -1.06678501e-01f, 6.96725398e-02f,
  -2.26671174e-02f, -9.60563123e-02f, -6.13127016e-02f, 9.13323686e-02f, 4.47470509e-02f, -5.31484000e-02f, 2.97914110e-02f, 1.22452259e-01f, 1.13868207e-01f, -4.22533751e-02f,
  -2.78293062e-03f, -9.23198760e-02f, -7.08260089e-02f, -7.83299506e-02f, -1.05781272e-01f, 4.35774811e-02f, -3.37557644e-02f, -7.03200921e-02f, -8.84068087e-02f, -3.97416539e-02f,
  4.85732779e-02f, 1.83235705e-02f, -4.16727960e-02f, -7.01393336e-02f, -1.02666423e-01f, -5.26393130e-02f, 7.42104799e-02f, 1.40270004e-02f, -9.01124999e-02f, 5.96588440e-02f,
  2.83526219e-02f, -2.85010133e-02f, -1.00634821e-01f, 5.27378991e-02f, 4.05261964e-02f, -1.02157081e-02f, -2.00149044e-02f, 6.59212247e-02f, -2.87024002e-03f, 4.62662615e-02f,
  1.00500710e-01f, 3.44291851e-02f, -1.22615665e-01f, -9.80485752e-02f, 5.20537868e-02f, -2.59536728e-02f, 4.43244874e-02f, 7.01896548e-02f, 2.99608465e-02f, -6.01656921e-02f,
  9.47664771e-03f, -1.05085686e-01f, 4.16920893e-02f, -3.38148177e-02f, 2.84156594e-02f, -6.41157627e-02f, 1.49093885e-02f, -8.38231072e-02f, -3.42021659e-02f, -7.62164742e-02f,
  2.12506186e-02f, -1.21727735e-01f, -4.20165509e-02f, -3.61318402e-02f, -8.54328647e-02f, -9.37626213e-02f, 4.78096912e-03f, 6.79703429e-02f, -1.06505468e-01f, -2.08796784e-02f,
  2.58312430e-02f, -2.72596418e-03f, 2.26951167e-02f, -2.17771418e-02f, 1.25535920e-01f, 7.32753873e-02f, 4.32297699e-02f, 9.83277634e-02f, 1.10397868e-01f, -7.07345605e-02f,
  2.53949016e-02f, -3.83540429e-02f, 4.75847162e-02f, 3.84430774e-02f, -7.09507475e-03f, 7.69877285e-02f, 1.45175057e-02f, 1.23210279e-02f, -5.13775507e-03f, 6.85998052e-02f,
  1.37900740e-01f, 5.54473251e-02f, -1.03899300e-01f, -7.15443268e-02f, -1.08189424e-02f, -5.61546944e-02f, 6.51130676e-02f, 1.34593725e-01f, 2.67129648e-03f, 1.51301652e-01f,
  -9.25668180e-02f, -4.71148007e-02f, 8.00389424e-02f, -5.45270648e-03f, 9.55887511e-03f, -1.03529438e-01f, 2.42523775e-02f, -6.11960255e-02f, -6.23097457e-02f, -3.55198025e-03f,
  -5.77990934e-02f, -9.47660487e-03f, -1.42680109e-02f, -4.59384099e-02f, 1.48180407e-02f, -2.70735659e-02f, -1.14140110e-02f, -6.50816336e-02f, -8.40746164e-02f, -1.44788651e-02f,
  -5.07182553e-02f, 5.35188764e-02f, -3.48474160e-02f, -5.25546223e-02f, 8.94808918e-02f, 9.09154043e-02f, -4.09485400e-02f, 8.26735273e-02f, 1.32321073e-02f, -8.18778276e-02f,
  5.21454774e-02f, 7.53841549e-02f, 1.08687654e-01f, -5.86061217e-02f, -1.10018104e-01f, 3.34288143e-02f, 4.15723287e-02f, 9.77262016e-03f, 9.92262885e-02f, 7.25795701e-02f,
  2.51278467e-02f, 4.65991460e-02f, 7.48374313e-02f, 5.65398335e-02f, 6.44963086e-02f, 7.31889307e-02f, -6.32770918e-03f, -4.07533497e-02f, -3.15746362e-03f, 8.04450735e-02f,
  2.68757772e-02f, 4.46251221e-02f, 3.68717574e-02f, -5.75047508e-02f, 3.03893518e-02f, 5.60505269e-03f, 2.71198209e-02f, 2.18502283e-02f, 7.27561042e-02f, -6.40292019e-02f,
  -6.67891428e-02f, 5.10624982e-02f, -2.48004422e-02f, 4.99108210e-02f, 1.08648688e-01f, 8.35095197e-02f, -9.79418531e-02f, 1.10140638e-02f, 2.98526660e-02f, -4.54315506e-02f,
  -5.76968789e-02f, 1.31041510e-02f, 1.03203773e-01f, 5.72742112e-02f, 1.79609433e-02f, 4.60976996e-02f, -3.85762975e-02f, 7.02944472e-02f, 6.75391927e-02f, 7.80674741e-02f,
  -9.62035805e-02f, 6.86720982e-02f, -6.02776967e-02f, -1.33944089e-02f, -3.88201065e-02f, 1.49010971e-01f, 5.62559217e-02f, 2.63820235e-02f, 4.84059788e-02f, -8.00117180e-02f,
  1.39583454e-01f, 1.00214081e-02f, -2.56276224e-02f, 4.40365560e-02f, 2.87167784e-02f, -1.53941721e-01f, -1.33622572e-01f, -1.07852578e-01f, 4.47649583e-02f, -3.26868221e-02f,
  -5.12792878e-02f, -6.89012557e-02f, -6.11719675e-03f, -5.78216463e-02f, -6.47798032e-02f, 8.89055282e-02f, 9.52515081e-02f, 1.04165643e-01f, 5.73667735e-02f, -5.90186082e-02f,
  -7.03721792e-02f, 9.76032913e-02f, 5.87181002e-02f, 7.58827850e-02f, -2.72293407e-02f, 8.92750174e-02f, 5.41339666e-02f, -1.23934066e-02f, -5.43185212e-02f, 1.11810185e-01f,
  1.63757741e-01f, 4.78843562e-02f, -4.99437377e-02f, 3.14476304e-02f, -2.80929767e-02f, 3.98180597e-02f, 6.38821861e-03f, 4.04900052e-02f, -7.26140514e-02f, 7.48607367e-02f,
  5.29668704e-02f, 6.58275336e-02f, 2.12863553e-02f, -2.44052261e-02f, 7.36713707e-02f, -2.81736478e-02f, -2.17349846e-02f, 2.02853873e-04f, 4.99905348e-02f, -1.45554356e-02f,
  -4.44690101e-02f, -2.04926003e-02f, -1.28169239e-01f, -1.49189457e-01f, 3.39307152e-02f, -1.61524629e-03f, -9.31599662e-02f, 9.64321382e-03f, -1.10322282e-01f, 9.40867662e-02f,
  -3.05795372e-02f, -3.40011530e-02f, -1.69179554e-03f, -5.48264757e-02f, 4.23014760e-02f, -9.11029130e-02f, -7.46868625e-02f, -4.68945503e-02f, -4.33797762e-02f, -1.76980924e-02f,
  -3.98098938e-02f, -5.15263714e-02f, 1.49395112e-02f, -3.88503484e-02f, 3.12180314e-02f, -7.93157667e-02f, -1.59340445e-02f, 4.45930026e-02f, -2.21799277e-02f, -6.20546751e-03f,
  -4.43703979e-02f, 9.99751016e-02f, -1.95106734e-02f, 6.47092760e-02f, -3.80827785e-02f, 4.75610495e-02f, 1.55443260e-02f, -5.37156686e-02f, -5.32525294e-02f, 1.86664537e-02f,
  7.09854588e-02f, -6.53083175e-02f, -8.30564648e-03f, 8.36643055e-02f, -1.45030431e-02f, 7.96138570e-02f, -9.52570587e-02f, -7.02201426e-02f, -6.34839409e-04f, 7.10225478e-02f,
  8.85686576e-02f, 7.09364936e-03f, 7.63676614e-02f, 7.46580139e-02f, 1.69458967e-02f, 7.13826269e-02f, -6.81795254e-02f, 6.75792694e-02f, 3.97721790e-02f, -1.34385033e-02f,
  5.53796515e-02f, -1.14562074e-02f, -1.17899068e-01f, -1.09586585e-02f, 6.43406063e-02f, -8.48378614e-02f, -6.39188364e-02f, -4.53069247e-02f, -9.00144652e-02f, -3.55589698e-04f,
  -1.17438078e-01f, 6.53395280e-02f, 7.74483755e-02f, -9.63305235e-02f, -4.81230877e-02f, -2.61449646e-02f, 2.48302501e-02f, 4.60294709e-02f, -8.37499723e-02f, -6.92371726e-02f,
  2.87520769e-03f, 1.71744488e-02f, -7.85279367e-03f, -5.18634357e-02f, -1.15824372e-01f, -7.45256469e-02f, -6.40424341e-02f, -1.27022922e-01f, -8.76693346e-04f, 1.65889040e-02f,
  -1.41878668e-02f, -1.07998639e-01f, -3.84327173e-02f, -3.41922883e-03f, 4.83845063e-02f, 5.83287999e-02f, 5.25301397e-02f, -8.38938430e-02f, -3.83619778e-02f, -1.70285888e-02f,
  1.93525359e-01f, -2.08326980e-01f, 4.94604744e-02f, -6.41751215e-02f, 3.58925696e-04f, 5.56711443e-02f, 7.59834945e-02f, 5.95240295e-02f, 7.23052174e-02f, 9.07547120e-03f,
  2.77570523e-02f, -8.66102725e-02f, 1.22875841e-02f, -2.90087145e-02f, -5.20830005e-02f, -1.66624673e-02f, 9.73491520e-02f, -9.39563736e-02f, -2.82783899e-02f, -1.85487717e-02f,
  -1.06022647e-02f, -1.93986055e-02f, -4.97320071e-02f, -4.08352129e-02f, -1.03131391e-01f, -3.14851440e-02f, 2.60060169e-02f, -8.41637626e-02f, 3.02810241e-02f, 9.85960737e-02f,
  1.33552486e-02f, 1.35143532e-03f, -5.91890067e-02f, -4.04977128e-02f, 1.38386795e-02f, 7.06102923e-02f, 8.75779167e-02f, 5.97962737e-02f, 5.17208837e-02f, 3.78670990e-02f,
  2.58376487e-02f, -2.64361314e-02f, -9.82348546e-02f, 2.27833893e-02f, -6.45461977e-02f, -5.16956449e-02f, -1.13936830e-02f, -4.64239344e-02f, 1.55738955e-02f, 4.32582945e-03f,
  -9.40522775e-02f, -1.06303677e-01f, -1.08347158e-03f, 6.98962212e-02f, -6.54754192e-02f, -3.53939421e-02f, -7.16570532e-03f, -8.09158236e-02f, -3.51695996e-03f, -2.69250069e-02f,
  1.39566138e-01f, -1.97513118e-01f, 2.72069592e-02f, 3.08977682e-02f, 3.80322747e-02f, -2.28726678e-02f, -4.01236415e-02f, -7.05914050e-02f, 2.73907706e-02f, 6.73186556e-02f,
  -9.64189006e-04f, 4.61805612e-02f, -8.29667505e-03f, 1.18575804e-02f, 1.02034397e-01f, 2.88622193e-02f, -2.39723101e-02f, 9.76480842e-02f, -2.87042297e-02f, 7.65390545e-02f,
  8.43913257e-02f, 5.47310971e-02f, -1.73347071e-02f, 8.42384808e-03f, -3.43427807e-02f, 1.82004366e-02f, 3.31350043e-02f, 1.11102566e-01f, -1.57330912e-02f, 1.00661926e-01f,
  -4.61309850e-02f, 5.73716350e-02f, 7.81299621e-02f, 5.18770404e-02f, 8.28100815e-02f, -2.18033761e-01f, -1.14092022e-01f, -2.43215606e-01f, -1.38997331e-01f, 3.84382010e-02f,
  1.73176434e-02f, -2.65701003e-02f, -8.79347604e-03f, -7.19917715e-02f, -2.77678780e-02f, 7.54190162e-02f, 6.33427054e-02f, -4.82237339e-02f, -2.82766283e-01f, -1.29409358e-01f,
  8.54732562e-03f, 4.39626984e-02f, -1.49780931e-02f, -2.69086962e-03f, 1.50229320e-01f, -5.36920317e-02f, -5.02656139e-02f, -1.83834024e-02f, 1.86943710e-02f, 3.50644857e-01f,
  1.15219213e-01f, -1.87090654e-02f, 4.77168597e-02f, -5.51141752e-03f, 1.35757029e-01f, -1.04787238e-01f, 3.13951895e-02f, 4.89448868e-02f, 5.79516813e-02f, -4.16251384e-02f,
  3.93378660e-02f, 6.34277314e-02f, 9.64405201e-03f, -2.00847592e-02f, -1.12492487e-01f, -8.45998675e-02f, -3.70364785e-02f, -9.88418758e-02f, -1.14260942e-01f, 2.23081782e-02f,
  1.08611897e-01f, -4.25844043e-02f, -1.06370196e-01f, -1.69236213e-01f, -6.11441173e-02f, -2.68001575e-02f, -2.12953407e-02f, -6.63120346e-03f, -3.99353243e-02f, 7.59500191e-02f,
  -2.31507421e-02f, 3.95650417e-03f, -5.52368946e-02f, 5.48571683e-02f, -1.19909495e-02f, -1.02780744e-01f, 8.56599063e-02f, -2.38791443e-02f, 1.45600149e-02f, -3.67120355e-02f,
  6.82289004e-02f, -4.74666245e-02f, -3.41929570e-02f, 4.27462459e-02f, -2.02167081e-03f, 3.53202783e-03f, -9.83892977e-02f, -4.85485457e-02f, 3.94163840e-02f, -7.86183327e-02f,
  -7.98730105e-02f, 1.26220301e-01f, 9.46483389e-02f, 7.19415769e-02f, 8.25216249e-02f, -9.77445692e-02f, -1.20379748e-02f, -2.86504738e-02f, -1.08992383e-01f, -5.90050891e-02f,
  3.04284561e-02f, -9.26282629e-02f, -1.43791037e-02f, -1.84512995e-02f, 3.22080813e-02f, 1.63565129e-02f, 1.27325073e-01f, -3.12826522e-02f, 8.42746813e-03f, 4.15647682e-03f,
  -4.96659167e-02f, 2.27437951e-02f, -2.13598218e-02f, 5.59882214e-03f, -4.94772531e-02f, 3.49812694e-02f, -7.80460387e-02f, 1.00514023e-02f, -1.13304399e-01f, -1.06704928e-01f,
  1.54423350e-02f, -2.01799765e-01f, -1.60360098e-01f, -3.56987454e-02f, -3.13965268e-02f, -1.17510334e-01f, -2.11552426e-01f, -1.86452195e-01f, -2.26933002e-01f, -1.65012911e-01f,
  3.89048994e-01f, -2.52965931e-02f, -6.45222068e-02f, 9.06532779e-02f, -1.55937091e-01f, -1.14162788e-01f, -9.15664583e-02f, -4.24724929e-02f, 7.90008083e-02f, 4.45281267e-02f,
  -3.55811119e-02f, 5.12532592e-02f, 3.83297354e-02f, -2.40256116e-02f, 4.55985181e-02f, -6.86868429e-02f, 3.51511277e-02f, 8.83193240e-02f, 1.02651246e-01f, -1.85718201e-02f,
  3.44969332e-02f, -5.79453036e-02f, 1.44037098e-01f, 6.76503330e-02f, -1.17001772e-01f, -2.89420933e-02f, -3.23371850e-02f, -1.26168296e-01f, -6.84577823e-02f, 1.58822760e-02f,
  6.22133799e-02f, 3.77187692e-02f, 5.65768071e-02f, 1.44310705e-02f, -7.35467970e-02f, -2.43679285e-02f, 6.21323399e-02f, 6.70472980e-02f, -5.25361970e-02f, 3.96198779e-02f,
  -9.31372792e-02f, -7.97297340e-03f, 7.53176631e-03f, -7.61653930e-02f, -8.97605196e-02f, -5.67373000e-02f, -7.91169927e-02f, 4.78456467e-02f, 1.02762148e-01f, 6.02504425e-02f,
  -5.52484132e-02f, -6.16247170e-02f, -7.00029358e-02f, 4.54215817e-02f, 5.00964634e-02f, 1.45637849e-02f, -2.43123109e-03f, -2.72060055e-02f, 3.55286757e-03f, -3.77045316e-03f,
  2.35151779e-02f, 5.54919206e-02f, -5.51872142e-02f, -2.31299326e-02f, 3.55859380e-03f, 5.68487421e-02f, 3.59896272e-02f, -1.60374795e-03f, -3.26179229e-02f, -1.71554219e-02f,
  -3.93434092e-02f, 4.28746194e-02f, -4.32328694e-02f, 7.47084841e-02f, -6.21995553e-02f, 5.41958446e-03f, -4.50028218e-02f, 5.69456816e-02f, -3.30729783e-02f, 7.61367828e-02f,
  3.79435644e-02f, -2.15947330e-02f, -2.37114299e-02f, 4.02010605e-02f, -1.55197957e-03f, 3.37371574e-04f, 2.21600309e-02f, -8.29315409e-02f, -5.20290211e-02f, 2.64151376e-02f,
  -8.31336379e-02f, -5.08104172e-03f, 3.46658081e-02f, 1.19510770e-01f, 7.14462847e-02f, 3.99217643e-02f, -9.37859062e-03f, -1.00127878e-02f, -8.40421859e-03f, 3.50064784e-02f,
  -3.00834142e-02f, 4.08321358e-02f, 8.38351715e-03f, 1.38700139e-02f, 2.30673552e-02f, -1.67122819e-02f, -2.93670525e-03f, 7.79942498e-02f, 8.54164883e-02f, -5.62155396e-02f,
  -2.17238404e-02f, -2.95352843e-02f, 5.16743399e-02f, 2.09512487e-02f, -1.64644653e-03f, 9.24579427e-02f, 1.16083017e-02f, -1.21963769e-02f, 1.91464704e-02f, 3.98656577e-02f,
  -2.53446922e-02f, -1.44034192e-01f, 1.86241075e-01f, -4.12926041e-02f, 9.18992609e-02f, 1.14032850e-01f, 2.15543270e-01f, 1.03036180e-01f, 1.43635012e-02f, 5.04008401e-03f,
  -1.01466961e-01f, -9.92679670e-02f, -1.07337631e-01f, -4.19893004e-02f, 4.91971821e-02f, -3.67957391e-02f, 8.85533243e-02f, 2.75445003e-02f, 1.73386976e-01f, 1.04112312e-01f,
  -5.09044714e-02f, 1.13904126e-01f, -1.67154782e-02f, -1.19569436e-01f, -5.56875207e-02f, 9.37772617e-02f, 4.00799178e-02f, -1.08410642e-01f, 4.80669290e-02f, -1.13308154e-01f,
  2.74590105e-01f, -1.75726742e-01f, 1.27367213e-01f, -1.22356124e-01f, -1.49019863e-02f, -2.14600340e-02f, 5.40321507e-02f, 8.63343757e-03f, -9.49154347e-02f, -7.91024789e-03f,
  -2.96979975e-02f, 4.59594745e-03f, -7.90340379e-02f, -2.05733534e-03f, 2.03756839e-02f, 4.32825238e-02f, -6.19881041e-02f, -4.83742729e-02f, -2.87639312e-02f, -7.48067349e-02f,
  -7.64977857e-02f, -1.27096042e-01f, -8.62487033e-02f, 1.34213436e-02f, -6.21675095e-03f, -1.30367437e-02f, -1.16961515e-02f, -4.59436402e-02f, -3.55651453e-02f, -4.26928736e-02f,
  -5.07891886e-02f, 1.35073662e-02f, 5.08370735e-02f, -1.12468069e-02f, 6.02263026e-02f, -3.03421170e-02f, 3.59831713e-02f, -1.37704154e-02f, 6.23094402e-02f, -1.62072461e-02f,
  -3.18113528e-02f, -5.73280752e-02f, 3.09169553e-02f, 8.22842792e-02f, -4.83298637e-02f, -2.02109609e-02f, 1.00949176e-01f, 3.44243571e-02f, 8.35120678e-03f, 6.40816540e-02f,
  5.74628375e-02f, -1.07145878e-02f, -4.63053845e-02f, -7.21447496e-03f, -6.10423088e-02f, -7.14596212e-02f, 4.87819836e-02f, 8.40429275e-04f, 2.56676115e-02f, -3.03206723e-02f,
  1.11662745e-01f, -7.73902312e-02f, 1.83620736e-01f, -8.16198438e-02f, -1.19298492e-02f, -6.97415508e-03f, -4.83392850e-02f, -1.98562983e-02f, -6.73359036e-02f, 7.72191286e-02f,
  -6.67426586e-02f, 2.39952374e-02f, 5.60455285e-02f, 2.57410146e-02f, 9.34508517e-02f, 4.28380482e-02f, -1.81485545e-02f, -6.08187774e-03f, -2.93538589e-02f, -8.06058869e-02f,
  -6.76671974e-03f, 1.30562484e-01f, 7.06428885e-02f, 1.07313976e-01f, 8.14798400e-02f, 6.54704869e-02f, 6.95557147e-02f, 1.11333616e-01f, 1.54123781e-02f, 1.31500691e-01f,
  -1.13154031e-01f, 1.15713172e-01f, -8.07031915e-02f, -5.56836370e-03f, 8.17080364e-02f, 1.17704600e-01f, 9.82850194e-02f, 5.32251224e-02f, 8.17051679e-02f, 1.20255172e-01f,
  5.15594222e-02f, 8.38116407e-02f, 1.11985572e-01f, 9.41167399e-03f, -7.03544840e-02f, 6.37094080e-02f, 4.74525280e-02f, -6.49104714e-02f, -1.34454787e-01f, -2.44645737e-02f,
  1.81183666e-02f, -1.35378353e-02f, -1.33076996e-01f, 5.10450192e-02f, 1.10281959e-01f, -1.29426718e-02f, 6.85210153e-03f, 4.03224193e-02f, 7.15976879e-02f, 1.16132364e-01f,
  -4.98586111e-02f, -7.98656717e-02f, -2.50373408e-02f, 5.21180183e-02f, 2.47556381e-02f, -1.20575521e-02f, -2.30397127e-04f, -3.80593240e-02f, -6.57028630e-02f, 7.70899132e-02f,
  -1.40101155e-02f, -2.90997811e-02f, 9.30346474e-02f, -1.03843629e-01f, 3.00440937e-03f, -3.28495950e-02f, 1.70914233e-02f, -1.10214651e-01f, -7.40127489e-02f, -7.40049183e-02f,
  8.02872702e-02f, 3.77095789e-02f, -3.84813454e-03f, 5.11949323e-03f, -5.51652275e-02f, -2.17292011e-02f, 5.15072234e-02f, 1.42778652e-02f, -9.52809677e-02f, -9.14849862e-02f,
  -6.36308938e-02f, 6.00692779e-02f, 4.36249450e-02f, -6.64972584e-04f, -5.01925685e-02f, 7.31432438e-02f, -2.88391206e-02f, 6.83212280e-02f, -4.29407582e-02f, -7.33105838e-02f,
  -6.55463561e-02f, -1.20254159e-01f, -8.71938765e-02f, -1.11836560e-01f, -9.89014953e-02f, 8.81205201e-02f, -6.10634014e-02f, 2.25739647e-02f, 2.42727380e-02f, -8.07068720e-02f,
  1.18732601e-02f, -4.99093831e-02f, 2.60695219e-02f, -3.68453749e-03f, -7.78207630e-02f, -1.21315971e-01f, -7.02282712e-02f, -5.86412735e-02f, -3.18679810e-02f, 6.43087327e-02f,
  1.47660123e-02f, -9.24377292e-02f, -4.02038693e-02f, 1.15847647e-01f, -3.73541862e-02f, 4.43453118e-02f, -2.09691729e-02f, -1.02703661e-01f, -2.30658837e-02f, 8.63151252e-02f,
  -2.21443009e-02f, -9.94297583e-03f, 1.12582117e-01f, -8.04518312e-02f, 1.06753774e-01f, 1.74636871e-03f, 2.55737337e-03f, -3.74213271e-02f, -4.48952196e-03f, 3.60831395e-02f,
  1.85593683e-02f, -2.98103187e-02f, -6.72630072e-02f, 2.72228438e-02f, -2.44913287e-02f, -1.57405995e-02f, -1.12973973e-01f, -1.17322020e-01f, -6.43270239e-02f, -1.29999861e-01f,
  9.02883559e-02f, 8.37895349e-02f, -1.27302200e-01f, 8.14122334e-02f, 2.61512492e-02f, -1.68385357e-01f, -4.00856398e-02f, -1.54298127e-01f, 6.09164685e-02f, -5.34405373e-02f,
  -4.82711755e-02f, -1.18178446e-02f, 4.90655079e-02f, -8.80182236e-02f, -2.00281084e-01f, 1.23348096e-02f, 4.39619236e-02f, -1.41052201e-01f, -1.88826069e-01f, -1.39983892e-01f,
  -5.23210801e-02f, 8.32384303e-02f, -6.31080940e-02f, -4.31056917e-02f, 6.53543100e-02f, 2.44749896e-02f, 6.89327940e-02f, 4.77454858e-03f, -5.26670218e-02f, 8.36241804e-03f,
  5.39206229e-02f, -9.85018611e-02f, -2.22495440e-02f, 1.22348681e-01f, -1.72003750e-02f, -5.36292382e-02f, 3.18552256e-02f, -5.22645190e-02f, -3.41711454e-02f, 6.07797615e-02f,
  -3.03147268e-02f, -4.95439172e-02f, 4.62643318e-02f, -2.09556688e-02f, -9.75366682e-02f, -4.93101329e-02f, -5.43679595e-02f, -1.10984016e-02f, -2.86891963e-02f, -7.93862194e-02f,
  2.10187491e-02f, 4.50317487e-02f, -1.40525952e-01f, -8.41214880e-02f, -1.06428102e-01f, -8.69035348e-02f, -6.35458082e-02f, -8.98288190e-02f, -3.16941477e-02f, -1.60608860e-03f,
  4.34583463e-02f, -5.52172512e-02f, -3.91073488e-02f, 2.05915011e-02f, -5.52785955e-02f, 7.92623535e-02f, 1.12557001e-02f, 1.81699451e-02f, 2.14120727e-02f, -5.44587942e-03f,
  -4.50839177e-02f, 2.39862408e-02f, -5.13253510e-02f, -5.91490418e-03f, -1.76460184e-02f, 1.01465425e-02f, -1.75079592e-02f, 3.13627869e-02f, 2.20112735e-03f, 6.59402534e-02f,
  -3.95933799e-02f, -7.97381252e-02f, 8.76332968e-02f, 6.57558534e-03f, 2.26052329e-02f, 7.56349340e-02f, -8.04628134e-02f, 1.77999516e-03f, 7.54557848e-02f, 1.92138422e-02f,
  1.39586121e-01f, -1.67898033e-02f, 8.84284675e-02f, -3.29193398e-02f, -2.51593571e-02f, 5.80436029e-02f, -3.13806646e-02f, -2.90925219e-03f, -3.00935395e-02f, -4.21014987e-02f,
  2.90365200e-02f, -5.08733988e-02f, 6.23236410e-02f, 3.54115441e-02f, -1.05228484e-01f, -4.78335656e-02f, 9.06350538e-02f, -6.35121949e-04f, -4.60541435e-02f, 2.67953426e-03f,
  2.22433228e-02f, 1.27665857e-02f, -5.12856208e-02f, -4.25487980e-02f, -3.32652894e-03f, -7.33778030e-02f, -3.89798917e-02f, -5.29974438e-02f, -3.50741260e-02f, 4.80561107e-02f,
  3.25251906e-03f, -1.02689527e-01f, 1.12842359e-02f, 1.07915498e-01f, -9.22103897e-02f, -8.25548992e-02f, -2.26126865e-01f, -1.66146725e-01f, 7.49391364e-03f, 1.70033220e-02f,
  -7.70532787e-02f, -4.22218721e-03f, 4.43925336e-02f, 6.44486248e-02f, 1.55461207e-02f, 3.42602842e-02f, 1.23557650e-01f, 2.12097079e-01f, 1.33839354e-01f, -7.55788758e-02f,
  6.29534349e-02f, 4.40635085e-02f, 1.14193819e-01f, 1.17262788e-01f, 1.72000229e-02f, 4.24920321e-02f, 9.73483920e-02f, 9.08481404e-02f, -3.71659808e-02f, 2.83953726e-01f,
  5.99204898e-02f, -1.04791790e-01f, -2.20883992e-02f, -9.45637748e-03f, 2.97238901e-02f, -2.61879880e-02f, -6.15469702e-02f, 1.12714376e-02f, 5.80529869e-02f, -7.67097771e-02f,
  -4.57212701e-02f, 6.43669516e-02f, -3.46848592e-02f, 4.32077684e-02f, -3.93030122e-02f, -1.70846730e-02f, 4.71522287e-02f, 4.26792763e-02f, 8.79500359e-02f, 2.19121762e-02f,
  -4.29420322e-02f, -6.14592694e-02f, 7.46926013e-03f, -1.03516825e-01f, -9.68218297e-02f, 8.04611892e-02f, -9.27526504e-02f, 5.56440046e-03f, 4.26683426e-02f, -7.03281984e-02f,
  -4.75603379e-02f, -1.53253237e-02f, -3.81058306e-02f, 8.35327953e-02f, 8.99221282e-03f, 3.39692533e-02f, 1.09510515e-02f, -1.77718066e-02f, 7.63163809e-03f, 2.42552385e-04f,
  2.05906015e-03f, -7.85520524e-02f, -6.71796687e-03f, 2.57682558e-02f, 8.75601619e-02f, 3.88171561e-02f, -1.89179555e-02f, 5.04109673e-02f, -7.57805184e-02f, -4.25219685e-02f,
  8.23028833e-02f, 4.82207090e-02f, -2.73644198e-02f, 7.00886324e-02f, 5.80115290e-03f, 4.77669761e-02f, -9.08021554e-02f, -4.42072526e-02f, 1.96504369e-02f, 5.81819285e-03f,
  -3.25541571e-02f, -4.22096215e-02f, -9.13736001e-02f, 6.56080944e-03f, -7.64682591e-02f, 6.16235100e-02f, -3.91168445e-02f, 2.77155098e-02f, -4.01063357e-03f, -9.73875448e-02f,
  4.04673666e-02f, -5.33124544e-02f, -3.57385948e-02f, 9.17621925e-02f, -7.04738647e-02f, -2.80776620e-02f, -4.26684916e-02f, 2.84314975e-02f, 2.22630892e-02f, -3.92696820e-03f,
  -3.29675749e-02f, -1.53216809e-01f, -1.39610380e-01f, -1.23358570e-01f, -7.28948414e-02f, -9.70575511e-02f, -1.03599086e-01f, -4.50923517e-02f, -1.44711643e-01f, -1.42848805e-01f,
  7.66575858e-02f, 8.36507380e-02f, 5.12071103e-02f, 1.38132647e-01f, 1.30628750e-01f, 1.01542152e-01f, -2.07608677e-02f, 1.59542337e-01f, 1.01430945e-01f, 1.44174159e-01f,
  1.42045736e-01f, 1.09674320e-01f, 1.42677858e-01f, 8.39099884e-02f, 5.21410443e-02f, 1.09076612e-01f, 1.47899389e-01f, -1.10776480e-02f, 9.96707976e-02f, 5.22752218e-02f,
  9.10165086e-02f, 3.29588912e-02f, -9.10904109e-02f, 1.21884393e-02f, 1.15713589e-01f, 1.71729159e-02f, 6.14386871e-02f, -8.62261094e-03f, 5.23785017e-02f, -9.52851865e-03f,
  1.12698479e-02f, 9.66387093e-02f, -1.52891930e-02f, 1.14839012e-02f, 4.05219868e-02f, -1.49801567e-01f, -1.06618263e-01f, 4.00274880e-02f, -3.39723565e-02f, -5.09914802e-03f,
  3.87173258e-02f, 1.04271667e-02f, 1.64439231e-02f, -2.81352494e-02f, -3.96499522e-02f, -1.38581237e-02f, 7.05485046e-02f, 1.49097294e-02f, 3.12348478e-04f, 6.34890869e-02f,
  -1.29168648e-02f, 2.66326351e-05f, -1.21418267e-01f, 5.59323728e-02f, -2.07193615e-03f, -4.51793447e-02f, 7.31206015e-02f, -7.53536075e-02f, 8.67483839e-02f, -6.68063089e-02f,
  -5.98403811e-02f, -3.44713815e-02f, 2.43924204e-02f, 3.26116160e-02f, 3.49850481e-04f, 9.92459431e-02f, 2.34837551e-03f, -6.34266734e-02f, -2.69916002e-02f, -4.51578610e-02f,
  8.39537382e-02f, 5.53164780e-02f, -2.47274004e-02f, 7.85947368e-02f, 1.85303669e-02f, -3.42886820e-02f, 4.46633548e-02f, 5.43575734e-03f, -2.95336712e-02f, 4.11185585e-02f,
  2.66474932e-02f, 1.17546422e-02f, -8.29419866e-02f, -4.08864059e-02f, -4.16700058e-02f, 1.17659099e-01f, 4.49828245e-02f, 4.30908985e-02f, 4.66538891e-02f, 2.60463860e-02f,
  7.37719685e-02f, 3.64452340e-02f, 8.61805826e-02f, -1.54381366e-02f, -5.64896353e-02f, -5.02369693e-03f, 1.53498445e-02f, -9.22265947e-02f, -3.26730609e-02f, -5.40415384e-02f,
  -1.16274983e-01f, -4.24492843e-02f, 8.20331201e-02f, -4.18914575e-03f, -5.50650321e-02f, -1.17181435e-01f, -2.62963139e-02f, 7.25460052e-02f, 4.70421948e-02f, 1.68482624e-02f,
  -7.42200911e-02f, -3.46424915e-02f, 2.66899075e-02f, 4.00514454e-02f, -2.68628318e-02f, -2.71436274e-02f, -9.64362547e-03f, -1.01649851e-01f, 2.95035616e-02f, -1.10940866e-01f,
  -2.83394098e-01f, 1.67766109e-01f, 1.33790135e-01f, -1.61423981e-01f, 1.65352270e-01f, 2.31252179e-01f, 4.15421009e-01f, 1.26221612e-01f, -6.67659789e-02f, -3.92836519e-02f,
  -3.24558537e-03f, -5.14662191e-02f, -1.18603677e-01f, -8.29661563e-02f, 8.74992684e-02f, 1.04224265e-01f, 1.36713341e-01f, -7.70268664e-02f, -1.07126251e-01f, -2.06601322e-02f,
  1.02678817e-02f, 3.90700921e-02f, 2.70881467e-02f, -6.21025031e-03f, -7.60565698e-02f, -9.96927172e-02f, 5.34044467e-02f, 8.91867206e-02f, -3.60077769e-02f, -5.82954735e-02f,
  -1.16721746e-02f, 1.53603166e-01f, 1.85071118e-02f, -1.40557602e-01f, -6.44679442e-02f, -8.13719109e-02f, -1.04164235e-01f, 9.53929946e-02f, -3.45093645e-02f, -6.87184185e-02f,
  6.09884150e-02f, -1.18929567e-02f, -2.23182123e-02f, 3.36340629e-02f, -3.12886089e-02f, 4.50103655e-02f, -1.24147283e-02f, 3.96380313e-02f, -3.20239067e-02f, -5.95604777e-02f,
  4.86600101e-02f, 6.76796436e-02f, 9.77555066e-02f, 2.16582175e-02f, -4.54091802e-02f, -6.61087781e-02f, 1.13072433e-01f, 6.96542710e-02f, 9.15993527e-02f, -3.38999107e-02f,
  -1.32280840e-02f, -1.01066746e-01f, -3.39452624e-02f, -3.56610771e-03f, -6.58192039e-02f, -6.85987920e-02f, 6.52883351e-02f, 1.59510933e-02f, 1.20518850e-02f, -6.76889047e-02f,
  3.48044895e-02f, 5.84320650e-02f, -3.69969234e-02f, -3.91674303e-02f, -2.81083267e-02f, -5.57254516e-02f, 2.99860407e-02f, 2.61452831e-02f, 2.26135366e-02f, 4.15471867e-02f,
  -5.13888262e-02f, -4.62820679e-02f, 3.12212091e-02f, -2.24497356e-02f, 2.45850496e-02f, 5.32793514e-02f, -1.25517873e-02f, 4.74017346e-03f, 6.16773404e-02f, -1.13853052e-01f,
  -4.81792493e-03f, 1.17156424e-01f, -7.98035488e-02f, -8.73486549e-02f, 2.08895653e-03f, -7.88326263e-02f, -1.76559575e-02f, 4.30581998e-03f, 5.15616965e-03f, -4.06173654e-02f,
  1.02052458e-01f, -4.49588895e-02f, 2.28985073e-03f, 3.15487050e-02f, -6.49840534e-02f, -1.24121457e-02f, 5.89205399e-02f, -7.17801377e-02f, 1.06970118e-02f, -5.24728745e-02f,
  -2.65664812e-02f, -5.35048954e-02f, -6.20668419e-02f, -9.71185043e-02f, -3.36762182e-02f, -5.54223023e-02f, 7.88285658e-02f, 2.08166167e-02f, 1.84836220e-02f, -7.43096396e-02f,
  -1.72823384e-01f, -9.25272778e-02f, -7.30613917e-02f, 1.23159662e-01f, -4.79936339e-02f, -8.39660540e-02f, -7.44897425e-02f, -9.76208225e-02f, 4.50447388e-02f, 5.65649662e-03f,
  -2.82896440e-02f, -9.63467173e-03f, -8.39784369e-03f, 1.46591170e-02f, 6.56854436e-02f, 9.72882733e-02f, 4.57063019e-02f, -2.67510265e-02f, -4.94856648e-02f, 4.96670119e-02f,
  1.03374682e-01f, -6.37567639e-02f, -4.83550169e-02f, 3.60627547e-02f, 7.88448080e-02f, 5.72257936e-02f, 1.39025003e-01f, 9.73840654e-02f, 2.85073160e-03f, 1.87454700e-01f,
  1.12199768e-01f, 2.31401697e-02f, -1.75166428e-02f, 1.59274451e-02f, 9.18938741e-02f, 7.06791058e-02f, -2.83925254e-02f, 2.79299151e-02f, -6.41520992e-02f, 2.68654451e-02f,
  7.96958432e-02f, 2.70421673e-02f, 2.70336960e-02f, 2.04463080e-02f, 1.44224903e-02f, -3.63818998e-03f, 1.86925419e-02f, -9.01267026e-03f, -2.89447443e-03f, 8.18405747e-02f,
  8.86473656e-02f, -4.27480601e-02f, 1.00372016e-01f, 3.69446119e-03f, -8.20963159e-02f, 7.85892904e-02f, 5.01158796e-02f, 7.91536123e-02f, 1.65384132e-02f, -6.34326190e-02f,
  -4.37311828e-02f, -7.75351524e-02f, 3.90437990e-02f, -8.02771226e-02f, -8.76708403e-02f, -1.13484003e-02f, 7.30917184e-03f, 1.58932917e-02f, 2.27174998e-04f, -4.86369990e-02f,
  7.35552087e-02f, 6.60813898e-02f, 2.56805811e-02f, -9.89263803e-02f, -5.50346747e-02f, -1.12511013e-02f, -9.16471332e-02f, 6.47543743e-02f, -1.69635769e-02f, 9.66282040e-02f,
  -7.65876621e-02f, 7.92096034e-02f, 6.55366853e-02f, 1.38824470e-02f, 1.47283841e-02f, 2.83480622e-02f, 2.56341677e-02f, 2.85920613e-02f, -4.55976435e-04f, -2.41350792e-02f,
  1.09156452e-01f, -2.58502513e-02f, 1.36462050e-02f, 7.01826587e-02f, -1.96990967e-02f, 3.15983258e-02f, 5.82870580e-02f, 4.13079113e-02f, 1.45114049e-01f, 2.56968284e-04f,
  2.75870953e-02f, -8.68329108e-02f, 9.19674896e-03f, 3.65862921e-02f, -8.50542188e-02f, -4.27700505e-02f, -1.56190544e-02f, 6.55932575e-02f, 3.61572169e-02f, 5.25316074e-02f,
  8.14753175e-02f, -6.94165304e-02f, -7.04305694e-02f, 1.13490354e-02f, -3.46074253e-02f, -5.39126359e-02f, -2.81931628e-02f, 5.54861166e-02f, 7.60279819e-02f, 1.07483463e-02f,
  7.05847815e-02f, 1.15545422e-01f, 1.04947925e-01f, 9.45913140e-03f, 2.16569155e-02f, 1.30366221e-01f, 1.51671186e-01f, 7.38513097e-02f, 1.53661698e-01f, 1.48886934e-01f,
  1.05097950e-01f, 8.02450255e-02f, 1.89422611e-02f, 5.81962653e-02f, 1.01823788e-02f, 1.41009912e-01f, 1.43351793e-01f, 5.17925732e-02f, 1.36642948e-01f, 8.13980401e-02f,
  3.95823419e-02f, 4.75668767e-03f, 1.19639069e-01f, -3.59655581e-02f, -6.25369791e-03f, 3.38151567e-02f, 1.00628138e-02f, -1.50360372e-02f, 4.87184338e-02f, 1.13910854e-01f,
  -2.36984286e-02f, 1.34097889e-01f, 4.83707935e-02f, -9.10378024e-02f, -1.61615089e-02f, -4.46798243e-02f, -1.22396778e-02f, -7.34259095e-03f, -4.75430489e-02f, 2.28308905e-02f,
  -1.37737617e-02f, 4.90521453e-03f, -5.91300875e-02f, -1.05955347e-01f, 6.29979223e-02f, -6.65819878e-03f, -1.85332261e-02f, 3.12494915e-02f, 7.73429722e-02f, -5.81841320e-02f,
  -8.25221762e-02f, -1.99996494e-02f, 4.23068032e-02f, -7.98469130e-03f, 1.12261176e-01f, -2.52259374e-02f, 5.22229411e-02f, -8.42483249e-03f, -5.59316091e-02f, 4.84149531e-02f,
  -1.61915831e-02f, -5.02016880e-02f, 5.73246516e-02f, -3.22731882e-02f, -7.04312883e-03f, -5.37959710e-02f, 4.19474673e-03f, 3.81685495e-02f, 3.63967866e-02f, -4.31964584e-02f,
  -3.00658103e-02f, 3.05995275e-03f, 1.33766890e-01f, -2.70625390e-02f, 4.10627127e-02f, -7.47580528e-02f, -3.08023319e-02f, 9.26012024e-02f, -1.55957416e-02f, 2.28062458e-02f,
  1.39553398e-02f, -3.95146683e-02f, 7.65784783e-03f, 6.62043765e-02f, 1.12498719e-02f, 5.30043337e-03f, -2.36647632e-02f, -9.14622769e-02f, -6.04489036e-02f, -7.72527084e-02f,
  1.48402816e-02f, 1.20251909e-01f, -8.58461186e-02f, -2.26141047e-02f, 6.88413605e-02f, -1.20838732e-01f, -1.85512770e-02f, 4.59369384e-02f, 3.72090265e-02f, 3.69466878e-02f,
  -1.82465352e-02f, -4.79236543e-02f, -4.00992595e-02f, 2.49981526e-02f, 4.06506658e-02f, -8.64171330e-03f, 5.06429262e-02f, 1.63130257e-02f, -2.58056242e-02f, 4.47040088e-02f,
  5.12840860e-02f, 7.35651851e-02f, 6.09476045e-02f, 2.14273925e-03f, 2.72788312e-02f, -3.98846343e-02f, 6.64623966e-03f, 3.11700553e-02f, -6.50189891e-02f, -1.07097149e-01f,
  -4.66856137e-02f, -2.65580751e-02f, 7.64100179e-02f, -2.75458694e-02f, 9.49876532e-02f, 7.34129250e-02f, 3.12706716e-02f, -6.40830174e-02f, 8.48680213e-02f, 6.03166893e-02f,
  5.48475645e-02f, 1.33610014e-02f, 1.07540168e-01f, 4.42088656e-02f, 4.12500128e-02f, -3.44642401e-02f, 6.85039982e-02f, 2.87717506e-02f, -4.23430242e-02f, 7.46047795e-02f,
  6.66285232e-02f, 4.99826930e-02f, -4.81753722e-02f, 8.25729314e-03f, -2.41251811e-02f, 1.10860169e-01f, -7.50796050e-02f, -8.24981108e-02f, 6.30087033e-02f, -7.07790032e-02f,
  -5.26789315e-02f, -1.35509282e-01f, -4.26444598e-02f, 4.18025181e-02f, 3.02543677e-02f, 5.53448424e-02f, -3.17066833e-02f, -6.93993568e-02f, -9.09523740e-02f, -1.07275926e-01f,
  -3.81123535e-02f, 8.16716999e-02f, -6.13020733e-02f, -4.13816795e-02f, -4.51439135e-02f, -1.02903336e-01f, 8.06621537e-02f, -1.46886166e-02f, 1.83899365e-02f, 4.37562540e-02f,
  6.24490306e-02f, -7.89870545e-02f, -6.04697205e-02f, -2.52018254e-02f, -9.78481621e-02f, 5.84032871e-02f, 1.57041848e-02f, -1.34585230e-02f, -1.06600851e-01f, -1.42708614e-01f,
  9.88202691e-02f, -6.36279443e-03f, 9.85322148e-02f, -3.57807204e-02f, 1.85636394e-02f, 4.22712080e-02f, 1.67106614e-02f, -8.61091539e-02f, -1.04158064e-02f, -5.20272329e-02f,
  6.65861145e-02f, -1.78634115e-02f, -2.56172176e-02f, 3.47035937e-02f, -3.48424949e-02f, 3.06665804e-02f, -8.07985067e-02f, 4.49356027e-02f, 3.06130690e-03f, -7.91397132e-03f,
  -3.80664319e-02f, 6.92229345e-02f, 1.22324266e-02f, -8.90323594e-02f, 8.40119738e-03f, -1.29479049e-02f, 6.50942186e-03f, -7.01616053e-03f, -5.50010726e-02f, -2.88541000e-02f,
  -1.94934849e-02f, -3.75435967e-03f, 4.15000692e-02f, -2.61879638e-02f, -1.03988014e-01f, 1.01265907e-01f, 3.42143066e-02f, 8.10205713e-02f, 3.50886844e-02f, 4.84153740e-02f,
  -2.20462419e-02f, -7.92165324e-02f, -2.24203914e-02f, -1.06757954e-01f, -1.77782755e-02f, -8.66743103e-02f, 1.06622865e-02f, 2.65663303e-02f, -3.32423635e-02f, 7.37817362e-02f,
  2.43784748e-02f, -9.67939422e-02f, -4.38079014e-02f, -9.05488804e-02f, -9.71311033e-02f, 7.35954270e-02f, 5.12910783e-02f, 2.53583286e-02f, 3.54448780e-02f, -8.45684484e-02f,
  4.69724163e-02f, 3.95980962e-02f, -3.57577354e-02f, -5.60709611e-02f, -4.59857322e-02f, 1.12098746e-01f, 1.13042518e-01f, 3.39138024e-02f, -6.03693761e-02f, 6.38185395e-03f,
  1.12754256e-01f, 4.14539129e-02f, -4.63105030e-02f, -7.15035349e-02f, -8.58857930e-02f, 1.90147082e-03f, 7.61410370e-02f, 4.99750637e-02f, 6.46306481e-03f, 7.25873560e-02f,
  -1.95147041e-02f, 4.90924343e-02f, -2.42098812e-02f, -7.32166693e-02f, 2.05731243e-02f, 3.83430123e-02f, -9.08972174e-02f, 7.68095702e-02f, 1.04508959e-02f, -1.03036389e-01f,
  2.26199571e-02f, 1.53514342e-02f, -6.48040771e-02f, 1.12615321e-02f, 9.37619731e-02f, 1.52050750e-02f, -1.85208116e-02f, 3.23243290e-02f, 8.04580152e-02f, -3.32502136e-03f,
  1.85415521e-02f, 6.64543286e-02f, 7.52852336e-02f, 9.03572142e-02f, 8.55370462e-02f, 7.07913488e-02f, 1.53270280e-02f, -2.88565475e-02f, -5.53849898e-03f, 4.43673320e-02f,
  6.99561536e-02f, -3.59298475e-03f, -3.43829244e-02f, 2.60793660e-02f, -2.95692012e-02f, 8.63566250e-02f, 1.83925945e-02f, -5.53119592e-02f, 7.34588206e-02f, 8.53409618e-02f,
  -2.14619525e-02f, -7.47521818e-02f, 1.83456335e-02f, 4.44852374e-02f, 7.76629299e-02f, -1.86170749e-02f, 1.85651388e-02f, 1.08216584e-01f, 2.14842185e-02f, -5.35662919e-02f,
  9.01999772e-02f, -3.75259705e-02f, -4.18568179e-02f, 1.45800533e-02f, 6.90897135e-03f, -4.39829454e-02f, 4.66119200e-02f, -4.80493382e-02f, -5.91340996e-02f, -4.53194752e-02f,
  -4.74748239e-02f, -6.51680753e-02f, 2.68860180e-02f, -9.70079843e-03f, -3.06853239e-04f, 3.00615784e-02f, -7.06533790e-02f, 9.32588577e-02f, 6.99208751e-02f, -5.92599288e-02f,
  2.16720235e-02f, -4.38712649e-02f, -5.93549944e-02f, 1.62083600e-02f, 2.87673064e-02f, -6.82860836e-02f, -3.21420394e-02f, -1.14310160e-01f, 2.34075449e-02f, 2.61376817e-02f,
  -8.66821930e-02f, 1.82671752e-02f, -1.91537514e-02f, -6.95441812e-02f, 9.73091647e-02f, -3.57219279e-02f, -5.56881577e-02f, 5.67084290e-02f, 4.70046811e-02f, 4.22950685e-02f,
  -1.96180549e-02f, -6.90397844e-02f, 3.03145200e-02f, -2.97135524e-02f, -3.39797419e-03f, 3.21937986e-02f, 8.58838186e-02f, -4.79261093e-02f, -6.89490512e-02f, 5.81201212e-03f,
  -2.09785387e-01f, 4.54742424e-02f, -1.18477054e-01f, -1.34145457e-03f, 1.00878231e-01f, 2.23844070e-02f, 6.88707782e-03f, 2.40223892e-02f, 1.07560143e-01f, -4.94096205e-02f,
  1.43074781e-01f, 2.25232542e-02f, 4.85355295e-02f, 1.33371070e-01f, 6.99331388e-02f, 3.69528718e-02f, 2.84299385e-02f, -7.33601768e-03f, 2.24627350e-02f, 1.25534302e-02f,
  1.25292659e-01f, 4.46223828e-04f, -3.34889293e-02f, -3.49908099e-02f, -2.71227956e-02f, -1.87318251e-02f, -3.83147923e-03f, -1.43434424e-02f, 4.98948107e-03f, -5.89631610e-02f,
  4.03901488e-02f, -1.90499872e-01f, -5.77113666e-02f, 4.36467864e-02f, 3.23714614e-02f, -1.06455036e-01f, -7.90368617e-02f, -9.60717425e-02f, -4.35601547e-02f, 8.28611106e-02f,
  3.01710889e-02f, -2.28163917e-02f, 3.24543715e-02f, -4.16848585e-02f, -5.45049608e-02f, -7.68499374e-02f, -1.35817051e-01f, -8.69538188e-02f, -7.53899664e-02f, -5.24485968e-02f,
  -2.89154444e-02f, -7.93186203e-02f, -3.61013375e-02f, 2.37168986e-02f, -2.64132023e-02f, 6.69556633e-02f, -7.91875198e-02f, -1.34227127e-01f, -1.47265792e-01f, -1.15893409e-01f,
  -9.51847136e-02f, 1.05476920e-02f, 7.61531666e-03f, 3.08906585e-02f, 3.73655558e-02f, -4.66238931e-02f, -3.31691429e-02f, 6.53601810e-02f, -3.02069937e-03f, -6.89670220e-02f,
  -1.14107793e-02f, 8.71794671e-03f, 4.63958867e-02f, -9.27425548e-03f, 2.83295345e-02f, 4.33816761e-02f, -5.29441349e-02f, 1.61482207e-02f, -4.55573425e-02f, -3.00640147e-02f,
  4.83573880e-03f, 1.05068041e-02f, 1.26538882e-02f, 5.12309782e-02f, -9.69410464e-02f, 5.74009158e-02f, 4.48173694e-02f, 4.66063581e-02f, 2.28909589e-02f, 2.91379355e-02f,
  2.20969953e-02f, -7.88406581e-02f, -1.64662078e-02f, 2.67918650e-02f, -6.04355894e-02f, -1.69567131e-02f, 2.97479704e-02f, -1.50466785e-02f, -5.78806084e-03f, -6.97878003e-02f,
  -3.56772356e-02f, -3.80554385e-02f, -5.74611723e-02f, 6.44427687e-02f, 1.11601591e-01f, -9.95950773e-03f, -7.96307698e-02f, 4.74559888e-02f, -2.01746300e-02f, -1.11763947e-01f,
  1.88764594e-02f, 7.75670409e-02f, -6.76641837e-02f, -2.67987885e-02f, -9.50229019e-02f, 7.52943605e-02f, 1.25570744e-02f, -9.99482647e-02f, -1.21008798e-01f, -8.60938206e-02f,
  1.79678708e-01f, -6.22589961e-02f, -1.31195843e-01f, -4.84291278e-02f, -1.78674191e-01f, -1.28250364e-02f, -7.21787512e-02f, -3.66645604e-02f, -9.73966792e-02f, -6.10513147e-04f,
  -1.24537110e-01f, 1.23111596e-02f, -4.47506756e-02f, 3.32330056e-02f, -5.72426245e-02f, -2.86567360e-02f, -9.58871394e-02f, 2.47229654e-02f, -8.17620084e-02f, -1.19314767e-01f,
  -7.18574151e-02f, -7.49658048e-02f, -3.33410949e-02f, -4.44823653e-02f, -1.12936720e-01f, -1.18906967e-01f, -5.33968545e-02f, -1.11880131e-01f, 1.38265509e-02f, -1.04562305e-01f,
  -1.50775969e-01f, 5.08421101e-02f, 8.40480477e-02f, 1.14136808e-01f, -1.19424015e-01f, 7.91334733e-02f, 6.24044873e-02f, -8.94970819e-02f, -5.67362970e-03f, -3.00017446e-02f,
  -1.53126298e-02f, 7.69354869e-03f, 9.12005175e-03f, -2.79427543e-02f, -2.01185551e-02f, -7.13490769e-02f, -6.12361170e-02f, -2.23676525e-02f, -9.26646497e-03f, -9.44949463e-02f,
  -2.60614119e-02f, 9.03018564e-02f, 6.04093373e-02f, 6.80458769e-02f, -1.84052438e-02f, -4.67249639e-02f, -5.56472056e-02f, 6.98943958e-02f, -1.40781123e-02f, -9.68720689e-02f,
  1.28111728e-02f, -4.16817367e-02f, 1.04217559e-01f, -4.87079173e-02f, 5.51201515e-02f, 7.83291906e-02f, -6.77126553e-03f, -3.71889025e-02f, 6.82691559e-02f, -5.06602712e-02f,
  -2.77732909e-02f, -8.38163272e-02f, 6.37466758e-02f, 6.52062148e-02f, -5.78285046e-02f, 5.97713375e-03f, 4.70318086e-02f, -1.74419973e-02f, -1.77395027e-02f, -6.15720339e-02f,
  4.22305278e-02f, -2.40534265e-02f, -3.45945009e-03f, -4.26548123e-02f, -6.79972246e-02f, 2.95440909e-02f, 3.13713513e-02f, -6.64690062e-02f, -7.20728710e-02f, 6.22455850e-02f,
  4.89048585e-02f, 5.77434488e-02f, -1.82361081e-02f, 8.49491451e-03f, -2.62631495e-02f, -8.00254196e-03f, -5.92588112e-02f, -1.05524160e-01f, -1.37892347e-02f, -7.48060867e-02f,
  4.95936908e-02f, 2.32400093e-02f, -1.59163438e-02f, 4.05738652e-02f, 7.40998834e-02f, 3.93921807e-02f, 5.85292764e-02f, -7.78343482e-03f, -3.83795202e-02f, -4.00541127e-02f,
  1.46000711e-02f, 6.07171617e-02f, 3.67870554e-02f, 7.47439563e-02f, 1.50218252e-02f, 1.18860222e-01f, 6.79955408e-02f, 9.68315825e-02f, 1.26672417e-01f, -4.41430993e-02f,
  -2.17376798e-01f, 7.19930977e-02f, 2.70882845e-02f, -1.06515832e-01f, 7.02025741e-02f, 1.56445242e-02f, -9.91579331e-03f, -1.53695066e-02f, -7.55573586e-02f, 1.66621793e-03f,
  5.28909229e-02f, -5.74879861e-03f, -5.77720888e-02f, 1.17612280e-01f, -8.75161029e-03f, -8.59275833e-02f, -2.53149476e-02f, -1.34305298e-01f, -5.85765205e-02f, 4.09943238e-02f,
  -4.39776778e-02f, -6.58200607e-02f, -1.49729908e-01f, -4.70004044e-02f, 6.56277910e-02f, -2.97697149e-02f, 9.66808945e-02f, 6.84484020e-02f, 5.23271188e-02f, 4.09780852e-02f,
  1.46085635e-01f, -1.75594892e-02f, 4.47323620e-02f, -1.18689448e-01f, 5.55357039e-02f, -6.75357655e-02f, -6.63357154e-02f, -1.10158071e-01f, 6.59177676e-02f, -2.95507126e-02f,
  7.74233416e-02f, -5.06347604e-02f, 3.49632539e-02f, 1.05760179e-01f, 5.00271060e-02f, 4.61495481e-02f, -6.26752004e-02f, -5.82211651e-02f, 5.86191043e-02f, -3.20695043e-02f,
  -2.56828479e-02f, -5.95133603e-02f, 7.00394586e-02f, 1.10345438e-01f, -5.01882210e-02f, -5.86562566e-02f, 2.71008946e-02f, 8.29776078e-02f, -6.39880970e-02f, 3.61654237e-02f,
  -3.12747713e-03f, 1.00156642e-01f, -3.47703248e-02f, -3.04946695e-02f, 2.96868347e-02f, -4.09906954e-02f, -1.73476860e-02f, -5.60180284e-03f, -1.20357994e-03f, 4.90916185e-02f,
  6.45419583e-03f, -5.85393608e-03f, 3.22001171e-03f, -1.42575894e-02f, 3.50823104e-02f, 2.72394177e-02f, -7.88559169e-02f, 4.78687175e-02f, 6.24731146e-02f, -3.88701223e-02f,
  2.57877577e-02f, 8.32024515e-02f, -5.53374216e-02f, 5.53880371e-02f, 3.95986140e-02f, -4.54581864e-02f, 2.78510321e-02f, -5.62980920e-02f, 4.40036580e-02f, -7.45411813e-02f,
  1.19653203e-01f, -9.45176482e-02f, 1.65667310e-02f, -7.40898252e-02f, 8.76950473e-03f, -1.08183967e-02f, 1.81347728e-02f, 2.38073058e-02f, 1.60969831e-02f, 7.63902487e-03f,
  6.09859787e-02f, -7.17276474e-03f, 5.73452264e-02f, 1.14329644e-01f, 6.09541982e-02f, 4.45630141e-02f, -4.07115296e-02f, 8.98053870e-03f, 3.67814414e-02f, 1.16247728e-01f,
  1.62247494e-02f, 2.49600429e-02f, -3.91459763e-02f, 1.01621293e-01f, -3.39408852e-02f, 5.09761646e-02f, -9.48463660e-03f, 8.94615725e-02f, 8.74728058e-03f, -1.38149196e-02f,
  -1.84423059e-01f, -1.31980535e-02f, 1.05940580e-01f, 1.14696130e-01f, 4.10359241e-02f, -1.35102859e-02f, 1.45706935e-02f, -1.21995308e-01f, -1.46131471e-01f, 9.67979655e-02f,
  -5.48002198e-02f, 3.61203663e-02f, -2.98784999e-03f, -8.71126354e-02f, -6.82490245e-02f, 7.77177438e-02f, 2.40693148e-02f, 5.04537486e-02f, -1.48025174e-02f, -4.78857346e-02f,
  6.16762005e-02f, 1.96689516e-02f, -6.58308417e-02f, -1.46885887e-02f, 1.12265073e-01f, -8.71819928e-02f, 7.45485201e-02f, 6.37529641e-02f, -2.52642184e-02f, 1.94306195e-01f,
  -1.31232897e-02f, 6.46378994e-02f, -4.48194519e-02f, -3.60808335e-03f, 1.83472708e-02f, -1.12109259e-01f, -6.11454546e-02f, -9.34411660e-02f, -1.14334852e-01f, -5.89596108e-02f,
  -3.80128110e-03f, -4.71007675e-02f, 4.07253616e-02f, -8.54402408e-02f, 5.20150214e-02f, -2.75584054e-03f, -6.81664422e-02f, 3.40221450e-02f, -7.99710080e-02f, 4.88459654e-02f,
  -5.81931770e-02f, 6.97951689e-02f, -1.38197867e-02f, -1.66557413e-02f, 5.44544030e-03f, -3.66570950e-02f, -5.29899895e-02f, 1.45895407e-02f, -7.65119940e-02f, 3.32097150e-03f,
  3.19489427e-02f, 1.05105683e-01f, 9.91412699e-02f, 9.28746257e-03f, 5.78401126e-02f, 5.23136072e-02f, -3.76791097e-02f, 5.37861623e-02f, 2.55769603e-02f, 9.29612666e-03f,
  -8.82321745e-02f, -5.33520132e-02f, 7.02105789e-03f, -7.88261071e-02f, -4.87726294e-02f, -8.46461672e-03f, 2.49964464e-02f, 3.87301631e-02f, 7.16772601e-02f, 5.45468517e-02f,
  3.22988927e-02f, -8.48939121e-02f, -1.13704406e-01f, -4.83919755e-02f, 9.20184776e-02f, 3.55597958e-02f, -4.25930979e-04f, -2.44838893e-02f, -4.99081537e-02f, 1.05030246e-01f,
  4.11230791e-03f, 1.02140926e-01f, 7.99357332e-03f, -7.55815506e-02f, 7.41847456e-02f, 3.59140970e-02f, -2.88307983e-02f, -3.74691375e-02f, -2.26769578e-02f, -1.23292804e-01f,
  -1.32078528e-01f, -7.89431855e-03f, 3.38269472e-02f, -5.92437349e-02f, 7.21798511e-03f, -7.62158185e-02f, 5.40923029e-02f, -4.38504852e-03f, -1.95721146e-02f, -9.65152904e-02f,
  -8.77807885e-02f, -4.95873801e-02f, -1.34956867e-01f, -3.84758716e-03f, -8.41399282e-02f, -7.83863664e-02f, 8.34732840e-04f, 4.36198935e-02f, -1.50534064e-01f, -4.97361757e-02f,
  -4.12491024e-01f, -1.58091202e-01f, 2.92598065e-02f, -1.63801000e-01f, -5.13398610e-02f, 1.11084051e-01f, 9.96932760e-02f, -5.75234555e-02f, -1.32224515e-01f, -6.43878011e-03f,
  -4.59133387e-02f, -5.55564463e-02f, -4.26517474e-03f, 7.37220719e-02f, 1.29297644e-01f, 8.93415213e-02f, 7.40164444e-02f, 9.30997059e-02f, 2.51205210e-02f, 4.48605418e-03f,
  -4.64537507e-03f, -8.81623402e-02f, 2.26881187e-02f, -8.03286061e-02f, -5.36805354e-02f, -2.62321497e-04f, -3.69151570e-02f, 5.27629815e-02f, 8.39292333e-02f, -2.57850885e-02f,
  -6.05049804e-02f, -5.67632243e-02f, 1.37477545e-02f, 1.72132012e-02f, 9.11386497e-03f, 1.30300159e-02f, -4.49347235e-02f, 3.69443446e-02f, -2.02449076e-02f, 7.46984500e-03f,
  3.92142422e-02f, -2.21227407e-02f, 3.12302448e-02f, -1.94883384e-02f, 3.07583641e-02f, -1.69774909e-02f, -6.73168385e-03f, -4.57070507e-02f, 1.38899624e-01f, 3.27443853e-02f,
  9.33271423e-02f, 8.49195942e-02f, -6.25152737e-02f, 1.19644277e-01f, 1.50834406e-02f, 3.70181724e-02f, 8.00626278e-02f, -2.00605504e-02f, -2.45134961e-02f, -1.44895300e-01f,
  3.38693149e-02f, -3.07491757e-02f, -4.71047685e-02f, -5.79558313e-02f, 3.42015475e-02f, -9.52594504e-02f, 5.14855124e-02f, 6.03215490e-03f, -5.87876029e-02f, -1.10550128e-01f,
  7.61566758e-02f, 9.04066861e-02f, -3.97758633e-02f, -7.59611502e-02f, 3.76652181e-02f, 2.95990088e-04f, -7.56385848e-02f, 6.15461729e-02f, 1.18769363e-01f, 5.58331888e-03f,
  -1.89328904e-03f, 1.09324820e-01f, -3.36924456e-02f, 3.03814281e-02f, 3.64259444e-02f, -5.50186634e-02f, 4.65860851e-02f, -5.24258614e-02f, 1.48595218e-03f, -4.08190899e-02f,
  -2.17857897e-01f, 1.47549927e-01f, -3.58560681e-02f, -3.52758169e-02f, -4.84894253e-02f, 1.62970331e-02f, -4.34155762e-02f, 3.54740992e-02f, -3.65931503e-02f, 4.25045192e-02f,
  -4.23316844e-02f, -6.48648962e-02f, -8.58149678e-02f, 2.04152130e-02f, 2.82267276e-02f, 6.29172334e-03f, 8.69231820e-02f, 8.27203467e-02f, 9.16863382e-02f, 5.53556867e-02f,
  4.84441072e-02f, 5.65967411e-02f, -1.38059571e-01f, -4.36560623e-02f, -1.97070148e-02f, -2.57791821e-02f, -1.26146510e-01f, 5.57004847e-03f, 3.70763056e-02f, -1.45194069e-01f,
  -2.37411350e-01f, -5.17165139e-02f, 1.15660205e-01f, -2.46490203e-02f, -3.85697633e-02f, -4.03170288e-02f, -1.28308475e-01f, -5.06953187e-02f, -6.11161627e-02f, -5.99114075e-02f,
  -5.44128790e-02f, -5.72337322e-02f, -9.97258276e-02f, -3.25315110e-02f, 9.46333408e-02f, 4.01378237e-02f, 7.02268779e-02f, -2.68601459e-02f, 7.19336718e-02f, -1.32241864e-02f,
  -9.31670219e-02f, 2.26411540e-02f, -4.79381830e-02f, -4.69521657e-02f, -1.50392979e-01f, -8.92940685e-02f, -5.96087649e-02f, -6.73729852e-02f, 3.61355692e-02f, -1.29872812e-02f,
  -6.20332658e-02f, -4.65014726e-02f, 1.13318250e-01f, 8.03355966e-03f, 8.69684445e-04f, 2.74116751e-02f, 5.54162264e-02f, -7.03854188e-02f, 8.49299598e-03f, -6.26470000e-02f,
  -4.65482213e-02f, 3.12460996e-02f, -8.40801075e-02f, -4.32251170e-02f, -5.02294488e-02f, 1.03759831e-02f, 2.81654000e-02f, -1.57035924e-02f, 2.82263588e-02f, -2.24583019e-02f,
  -5.61064556e-02f, 1.71645023e-02f, -6.15672506e-02f, 7.64480978e-02f, -1.68116800e-02f, -2.09886953e-02f, 5.49322143e-02f, -8.30101296e-02f, -7.30229318e-02f, -1.24558151e-01f,
  2.88447123e-02f, 2.48425175e-02f, 8.07174109e-03f, 6.29919097e-02f, -5.01538254e-02f, -2.33514477e-02f, -6.30387217e-02f, -2.76975837e-02f, -1.34916473e-02f, 2.22696550e-02f,
  -1.03758983e-02f, 5.67943649e-03f, -6.92085102e-02f, 2.27343198e-02f, -1.27654606e-02f, -1.19111482e-02f, 2.58486047e-02f, -4.36629765e-02f, 7.67937824e-02f, -8.64184424e-02f,
  1.72530990e-02f, 4.39293608e-02f, -1.04404442e-01f, 4.26731855e-02f, 6.30066171e-02f, 5.03424481e-02f, -7.64561966e-02f, 3.37601863e-02f, 1.75782032e-02f, 5.59934340e-02f,
  -1.35347560e-01f, 4.96444069e-02f, -8.63633305e-02f, 1.05460705e-02f, -4.93703000e-02f, 8.00155774e-02f, 5.50034866e-02f, -3.72445695e-02f, 2.93556657e-02f, -8.09644756e-04f,
  -5.25021255e-02f, -6.58158362e-02f, 6.04465455e-02f, 2.78856400e-02f, 5.06210625e-02f, 3.04008462e-02f, -4.27081399e-02f, 2.54153013e-02f, 5.01541160e-02f, 7.17154443e-02f,
  -3.03649604e-02f, -7.66848177e-02f, -9.43802372e-02f, 5.46483509e-02f, -2.44873818e-02f, -1.02106974e-01f, -2.02316884e-02f, -3.88566256e-02f, 3.44269611e-02f, -6.28973246e-02f,
  -3.58182639e-01f, -4.40772250e-02f, 1.72494739e-01f, -9.07308832e-02f, -3.09723765e-02f, 1.35221243e-01f, 9.69673973e-03f, 2.69685779e-02f, -7.90716633e-02f, -1.77497447e-01f,
  -2.78116781e-02f, -5.99508695e-02f, -7.98864737e-02f, -8.98389611e-03f, -2.22019665e-02f, -1.30239397e-01f, -2.78462432e-02f, 8.60263556e-02f, 9.24861580e-02f, 1.42634183e-01f,
  -3.38791572e-02f, 1.15533909e-02f, -9.69368294e-02f, 5.94198890e-02f, -1.34889200e-01f, -1.36676565e-01f, -3.22644003e-02f, -1.37420177e-01f, 2.76603624e-02f, -2.13801131e-01f,
  -7.87521228e-02f, -1.30305037e-01f, 9.06010196e-02f, 2.34916992e-02f, -2.71818247e-02f, -6.39330521e-02f, 3.16344537e-02f, -4.75896224e-02f, -4.68355045e-02f, -2.83940360e-02f,
  -1.13438293e-02f, 1.20200180e-01f, -7.03684539e-02f, 4.34137657e-02f, -7.73903681e-03f, 1.29960906e-02f, 8.03510249e-02f, 1.51172644e-02f, 9.81977768e-03f, 5.94602451e-02f,
  3.32109518e-02f, 2.53856741e-02f, -8.03519115e-02f, -2.95266323e-03f, 3.69607918e-02f, 1.05621545e-02f, -5.24657406e-03f, 7.95066953e-02f, 7.01342523e-03f, -2.08149627e-01f,
  5.35156950e-02f, -2.86312704e-03f, -4.49579507e-02f, 4.14426066e-02f, -1.51396422e-02f, 8.56858306e-03f, -8.11238121e-03f, 3.26374471e-02f, 7.34920278e-02f, -6.75222501e-02f,
  -5.07201515e-02f, 7.14226684e-04f, 1.97164295e-03f, 3.06306407e-02f, 1.49395838e-02f, 4.94301412e-03f, -3.40987295e-02f, -7.49206915e-02f, -4.37694564e-02f, -6.79791793e-02f,
  -7.08702803e-02f, 2.92877555e-02f, -7.44688511e-02f, 6.33564293e-02f, 3.79827283e-02f, -6.21760599e-02f, -2.95170554e-04f, 1.04337201e-01f, 6.07727803e-02f, 8.51391703e-02f,
  -7.66190141e-02f, 1.20954290e-01f, -1.25319079e-01f, 3.79201095e-03f, -2.56824158e-02f, 2.79979445e-02f, -8.64017382e-02f, 3.18178125e-02f, -7.86533430e-02f, -4.66822572e-02f,
  -2.79732831e-02f, 8.21808446e-03f, -3.57023650e-03f, 5.28130457e-02f, -3.44935842e-02f, 3.12773995e-02f, -6.50938302e-02f, -5.14167212e-02f, 9.79512781e-02f, -3.35488766e-02f,
  6.73463494e-02f, -7.41550401e-02f, -2.03148574e-01f, -1.21141411e-01f, 2.14852169e-02f, -1.34296685e-01f, -1.18216589e-01f, -3.02567426e-02f, -4.99344803e-02f, -1.54748857e-01f,
  -2.12948933e-01f, -1.27589643e-01f, 1.06022224e-01f, 3.93311307e-02f, -1.88839287e-02f, -4.54776920e-02f, -1.51812434e-01f, -1.42154649e-01f, 5.12571931e-02f, -1.08759120e-01f,
  3.50868255e-02f, 6.18642457e-02f, -2.07560342e-02f, 1.74609125e-02f, -5.64471819e-02f, -2.68733241e-02f, 1.11504927e-01f, 1.25765070e-01f, 3.82860713e-02f, -5.39137945e-02f,
  -4.47145244e-03f, 2.09050011e-02f, 1.09870574e-02f, 4.11008634e-02f, -1.37581043e-02f, 4.92907455e-03f, -1.91883687e-02f, -1.02917082e-03f, 1.08596757e-02f, 1.24646528e-02f,
  6.08966835e-02f, -8.07105526e-02f, 1.39531232e-02f, -8.03093836e-02f, 1.31141383e-03f, -6.07092157e-02f, 5.32010272e-02f, 3.95091921e-02f, 2.32819598e-02f, -4.94940206e-02f,
  1.54685406e-02f, 4.60569970e-02f, -6.43478036e-02f, 1.90989429e-03f, 4.49472293e-02f, 2.46625710e-02f, 9.41742659e-02f, 1.24193048e-02f, -7.20848748e-03f, -8.74251574e-02f,
  -5.20285219e-02f, 8.45177695e-02f, -1.66795310e-02f, 4.97883596e-02f, -8.42641592e-02f, -5.81956655e-03f, -1.30384443e-02f, -1.07114293e-01f, 7.08259940e-02f, -1.18379921e-01f,
  3.60726826e-02f, -5.36870770e-02f, 1.05412106e-03f, 3.96270119e-02f, 3.40386555e-02f, -4.85182926e-02f, 7.96608776e-02f, -8.04381445e-02f, 5.42298034e-02f, -2.24774610e-02f,
  7.76146054e-02f, -6.34604171e-02f, 7.60507062e-02f, 5.25140688e-02f, 1.59079544e-02f, 1.77771755e-04f, 5.67078171e-03f, -1.11370320e-02f, 7.54322186e-02f, -2.52572130e-02f,
  -3.45492139e-02f, 2.09895987e-02f, 5.33396341e-02f, 3.24728340e-02f, -2.20062509e-02f, 2.63927989e-02f, 1.80408917e-02f, -7.60823041e-02f, -2.64809132e-02f, -3.31041180e-02f,
  -3.07912007e-03f, 1.46016493e-01f, -5.90320863e-02f, 3.03925071e-02f, -2.11535580e-02f, 1.07290009e-02f, 5.35163321e-02f, -3.34516801e-02f, -5.41703105e-02f, -4.16444838e-02f,
  -2.20831819e-02f, 7.14765536e-03f, -5.94344810e-02f, 6.91149384e-02f, -8.58717188e-02f, -6.43996075e-02f, 4.02004607e-02f, -8.69827196e-02f, -1.02897687e-02f, -8.56965259e-02f,
  -1.56096276e-02f, -8.70763063e-02f, -4.18299623e-02f, -1.11612910e-03f, -6.40373975e-02f, -1.03586698e-02f, -8.72849375e-02f, -5.79521293e-04f, -5.76805584e-02f, -1.11777738e-01f,
  1.41866371e-01f, -6.42256811e-02f, -1.46060616e-01f, 5.97383715e-02f, 1.02150571e-02f, -1.19289197e-01f, -3.48965637e-02f, -6.60095066e-02f, -6.37543201e-03f, -7.30572864e-02f,
  -4.43969890e-02f, 6.80162981e-02f, 1.16640306e-03f, 3.43746208e-02f, -9.37250704e-02f, -1.65189803e-02f, -2.69550066e-02f, 1.63735263e-02f, -1.61240331e-03f, -1.38412774e-01f,
  -1.58648118e-02f, 7.51245916e-02f, -1.64103974e-02f, -5.09686135e-02f, 5.33906408e-02f, -7.48724267e-02f, -4.62575108e-02f, -4.74586859e-02f, 1.09637026e-02f, -4.96752262e-02f,
  -1.31706432e-01f, -6.30495995e-02f, 7.88453519e-02f, 1.24251902e-01f, -8.39135498e-02f, -3.04699223e-02f, -3.40159349e-02f, -5.31828515e-02f, -7.84301609e-02f, -4.45750877e-02f,
  5.60138151e-02f, -4.44065668e-02f, 4.03433181e-02f, -9.13484991e-02f, -2.76071187e-02f, -6.87035471e-02f, 3.54154184e-02f, 3.81172374e-02f, -1.56226130e-02f, -1.20387174e-01f,
  -9.75253507e-02f, -2.15222072e-02f, -2.70767808e-02f, -6.32970482e-02f, -1.14800259e-01f, -2.88950000e-02f, -1.08092114e-01f, -2.47181896e-02f, 5.36724031e-02f, 3.91192064e-02f,
  -1.07504874e-01f, -4.71601263e-03f, -6.60848394e-02f, -1.46780480e-02f, -4.41655889e-02f, -9.40845534e-02f, -3.91457267e-02f, -3.93998064e-02f, -2.01906022e-02f, -6.57931864e-02f,
  2.24175490e-02f, -5.98079599e-02f, -6.01385273e-02f, -3.26429009e-02f, -2.88224258e-02f, 4.60553877e-02f, -7.20061660e-02f, -4.57053147e-02f, -3.30414101e-02f, -1.39683140e-02f,
  -3.05785276e-02f, -1.82741378e-02f, -9.36331414e-03f, -4.75334898e-02f, 7.61221442e-03f, -6.73464909e-02f, 5.14276288e-02f, 2.74431538e-02f, -8.21036547e-02f, 8.88549164e-03f,
  1.14500662e-02f, 5.11845350e-02f, 7.71640847e-03f, 1.00955024e-01f, -1.01602316e-01f, 2.40103565e-02f, -5.33550493e-02f, -7.84104466e-02f, 8.39207321e-02f, 5.33196852e-02f,
  -5.50148673e-02f, 8.95205978e-03f, -8.02152827e-02f, 1.22465761e-02f, -9.00096074e-02f, 2.75889691e-02f, -2.63078557e-03f, -4.68361489e-02f, 6.21780679e-02f, 4.18034121e-02f,
  8.72205272e-02f, -5.42359427e-02f, 2.89126784e-02f, -5.35296984e-02f, -1.67728122e-02f, -2.29340699e-02f, -9.18741450e-02f, 4.89934571e-02f, 1.13354176e-02f, -2.34702714e-02f,
  -6.42647445e-02f, -5.54905757e-02f, -4.91010249e-02f, 1.00853167e-01f, 1.80701882e-01f, 1.74342498e-01f, 7.47850612e-02f, 2.21852977e-02f, 1.23126164e-01f, 1.15891568e-01f,
  1.00267261e-01f, 1.75431773e-01f, 8.43609497e-02f, 9.91065502e-02f, 1.66568365e-02f, 1.29077788e-02f, 1.38960883e-01f, -5.44905514e-02f, 3.87310758e-02f, 1.32714421e-01f,
  1.83728859e-01f, 9.86568481e-02f, -9.37524159e-03f, 4.58777584e-02f, -3.75588425e-02f, 8.22672769e-02f, -2.51861066e-02f, -7.68245608e-02f, -1.79601845e-03f, -5.37265018e-02f,
  -1.88840237e-02f, -6.83374107e-02f, 4.26989757e-02f, -3.38344127e-02f, -3.60335223e-02f, -8.11430514e-02f, 1.63209923e-02f, 4.50620707e-03f, -5.64024039e-02f, -7.15457201e-02f,
  2.53173523e-02f, -3.67586501e-02f, 5.25880046e-02f, -3.77454683e-02f, -4.44559157e-02f, -3.07579096e-02f, -4.21873517e-02f, -5.13264872e-02f, -7.18982220e-02f, -3.09158508e-02f,
  1.42497674e-01f, -7.02605844e-02f, -1.00312889e-01f, -3.43003310e-03f, -6.03875443e-02f, 1.31897209e-02f, -3.66155952e-02f, 5.26179597e-02f, 4.88018729e-02f, 4.27615494e-02f,
  7.96343684e-02f, 2.90392805e-03f, -6.46044151e-04f, 5.74773690e-03f, 9.99122486e-02f, -7.70802349e-02f, 5.53115346e-02f, -1.05579162e-03f, 1.05460221e-02f, 1.00304978e-03f,
  2.88752615e-02f, 7.29365125e-02f, -3.81459333e-02f, -1.12837749e-02f, -3.49864475e-02f, 8.07889104e-02f, -5.38492296e-03f, 4.51337770e-02f, 7.06489459e-02f, -8.82813483e-02f,
  -2.75295563e-02f, 4.88819741e-02f, 1.62775218e-02f, -6.73211291e-02f, 4.74472977e-02f, 7.68137863e-03f, 2.15161294e-02f, 1.25037497e-02f, -5.88756353e-02f, 2.58902293e-02f,
  9.92050171e-02f, 6.21179603e-02f, 1.03421427e-01f, -7.20382258e-02f, 6.61156476e-02f, -7.15179220e-02f, -1.12746917e-02f, 6.09730221e-02f, -7.92290568e-02f, 8.06518570e-02f,
  -9.37325582e-02f, 8.81328899e-03f, -9.67703983e-02f, -3.93351540e-02f, -4.10266034e-03f, -8.27715248e-02f, 2.66191829e-02f, 7.71702975e-02f, 4.91532087e-02f, 3.04705668e-02f,
  -3.15872841e-02f, 6.69124797e-02f, 7.28910416e-02f, 3.26757953e-02f, 8.37367624e-02f, 7.99529545e-04f, -1.18286937e-01f, -6.99605346e-02f, -5.35452692e-03f, -7.87545592e-02f,
  -4.95293140e-01f, 5.07333316e-02f, -1.86073687e-02f, -2.04503074e-01f, -1.03293911e-01f, -2.75704963e-03f, -1.46516055e-01f, -4.24892679e-02f, -8.06597844e-02f, -1.68124944e-01f,
  4.21287268e-02f, -7.42010772e-02f, -1.24659631e-02f, -3.91785130e-02f, -1.18537210e-01f, -2.13364497e-01f, -2.51517922e-01f, -1.33141980e-01f, -1.13336064e-01f, -2.09292327e-03f,
  5.08711077e-02f, -1.83736786e-01f, -1.60314292e-01f, -2.35950351e-02f, 5.89489639e-02f, 9.42292362e-02f, 1.37985703e-02f, 1.21441692e-01f, 6.75094575e-02f, -4.16806005e-02f,
  1.72807828e-01f, 1.07323095e-01f, -4.70139384e-02f, -7.21224546e-02f, 3.44443880e-02f, -6.09147362e-02f, -8.96193534e-02f, 4.11701724e-02f, -6.97271749e-02f, -2.82811597e-02f,
  4.39892076e-02f, 9.61866230e-02f, -4.62481752e-02f, 4.73039038e-02f, -7.14187771e-02f, -8.13358650e-02f, 9.49149136e-04f, -9.49700773e-02f, -8.32183212e-02f, 3.33393516e-04f,
  -1.01192623e-01f, -5.03861867e-02f, 1.13581736e-02f, 1.29564315e-01f, 1.36950135e-01f, 1.88088026e-02f, 1.86159298e-01f, 7.82154873e-02f, 1.14263237e-01f, 1.54039592e-01f,
  -3.82041968e-02f, 1.03084363e-01f, 3.16539370e-02f, 1.38444044e-02f, -9.51423123e-03f, -1.74747896e-03f, 3.26735564e-02f, -6.13897257e-02f, -7.26795122e-02f, 5.04544452e-02f,
  2.68522953e-03f, 1.63591728e-02f, 2.90327370e-02f, -3.20315026e-02f, 1.75188351e-02f, -2.37648375e-02f, 2.60728747e-02f, 5.14706746e-02f, -1.84028838e-02f, 2.32928116e-02f,
  6.38908744e-02f, 8.48211907e-03f, 3.49310674e-02f, -1.26996031e-03f, -9.89331771e-03f, -1.22531718e-02f, -5.56879863e-03f, 3.11416201e-02f, -2.14772988e-02f, 2.25789119e-02f,
  -1.78971272e-02f, -1.54628471e-01f, 2.43473407e-02f, 4.69664000e-02f, -7.05248937e-02f, 2.58708093e-03f, -1.75972283e-02f, -6.60075992e-02f, 2.62653921e-02f, 7.01634958e-02f,
  7.16691837e-02f, -5.01616905e-03f, -1.93349794e-02f, -2.33376250e-02f, -4.33422290e-02f, -2.66508758e-02f, -6.29742164e-03f, -3.28280330e-02f, 6.51670247e-02f, 9.81300250e-02f,
  4.01485674e-02f, -3.94866057e-02f, -4.39687222e-02f, -2.51551904e-02f, 3.38284969e-02f, -1.81166142e-01f, 2.80546118e-02f, 7.73031190e-02f, 1.36933774e-02f, -7.28460401e-02f,
  6.97339997e-02f, -1.21205017e-01f, -2.02901632e-01f, -1.34922117e-01f, -5.49595132e-02f, 1.37704343e-03f, 3.79001312e-02f, -3.37581560e-02f, -3.95028032e-02f, -1.26864552e-01f,
  6.72183335e-02f, -3.70288081e-02f, -7.62468204e-02f, -7.45235234e-02f, 3.79086938e-03f, -1.54561445e-01f, -1.51440650e-01f, -9.14824605e-02f, -3.12160645e-02f, -1.03943236e-02f,
  -5.63132055e-02f, -8.37028679e-03f, -1.00904778e-01f, -3.01103722e-02f, -1.69280931e-01f, -1.19730711e-01f, -1.52606890e-02f, -7.92009383e-02f, -6.41087741e-02f, -6.05752841e-02f,
  -1.30727708e-01f, 1.15225121e-01f, 4.30044159e-02f, -7.51431799e-03f, -1.12027064e-01f, -4.60003689e-02f, -8.27522501e-02f, -3.08711617e-03f, 7.30283791e-03f, 4.49664220e-02f,
  -5.73709048e-02f, 7.03788325e-02f, -2.91059986e-02f, 6.26667589e-02f, 2.83941720e-02f, 1.17521875e-01f, -1.26077095e-02f, 9.41511169e-02f, 2.98371073e-02f, 1.33149661e-02f,
  5.18755019e-02f, 5.95838530e-04f, 8.60213563e-02f, 3.59556153e-02f, 1.20692328e-01f, 6.30946457e-02f, 4.87468988e-02f, 9.89974439e-02f, 3.34150642e-02f, 2.12250394e-03f,
  -4.35211025e-02f, -8.76704976e-02f, 4.80041802e-02f, -3.44034992e-02f, 9.96057689e-02f, 4.12201174e-02f, -3.49063575e-02f, -4.39455407e-03f, 8.60285088e-02f, -7.08262101e-02f,
  3.31415012e-02f, -2.20360551e-02f, -1.54983923e-02f, -6.02713339e-02f, -1.32715598e-01f, 2.31735911e-02f, 4.26509082e-02f, 7.11439177e-02f, 3.55235417e-03f, 3.23042683e-02f,
  -3.21939662e-02f, -4.27094772e-02f, 9.75981168e-03f, -1.00740546e-03f, -4.95021194e-02f, -2.93569099e-02f, -2.50179227e-02f, 1.42035961e-01f, 2.65446696e-02f, 5.22030368e-02f,
  -6.23273663e-02f, 2.42845509e-02f, -2.22998112e-02f, 1.68354437e-02f, -8.62588640e-03f, 4.45312401e-03f, -6.29049866e-03f, -7.90388603e-03f, 1.36608686e-02f, -1.45005742e-02f,
  5.45839369e-02f, -4.77758981e-02f, 7.17474660e-03f, 9.90765467e-02f, 7.23567978e-02f, 6.78931251e-02f, 1.17633060e-01f, 6.66075945e-02f, -2.27211323e-02f, -6.87259287e-02f,
  9.55810547e-02f, 4.17471752e-02f, 1.09612323e-01f, 3.45914960e-02f, 5.07159084e-02f, 5.49189635e-02f, 4.89586629e-02f, 2.32075565e-02f, 2.84516625e-02f, -9.93089303e-02f,
  -1.41279265e-01f, -1.96627006e-02f, 2.43465584e-02f, -6.55136257e-02f, 7.50553012e-02f, 5.87097406e-02f, 6.75979629e-02f, -6.36016577e-02f, -1.52574152e-01f, 1.44208670e-01f,
  7.49356300e-02f, -1.17396459e-01f, -1.02459162e-01f, 3.07554360e-02f, 2.95132259e-03f, 4.29000370e-02f, 9.76508334e-02f, -5.14560789e-02f, -2.08894759e-01f, -4.33205292e-02f,
  2.85594873e-02f, -1.45999923e-01f, -1.95168987e-01f, -1.26011312e-01f, 5.39475493e-02f, -1.08106516e-01f, 3.57758738e-02f, -5.60251661e-02f, -5.22567006e-03f, 4.18128632e-02f,
  9.39299688e-02f, -8.74588042e-02f, -1.03711225e-01f, 1.59181189e-02f, -2.15237793e-02f, 8.83451253e-02f, 1.05065005e-02f, -8.30826163e-02f, -4.73191552e-02f, -3.43042798e-02f,
  -5.79213388e-02f, -6.96128681e-02f, -3.43147330e-02f, -4.18225452e-02f, -1.00580275e-01f, -8.76653939e-02f, -8.29923600e-02f, 2.70879436e-02f, 4.54065576e-02f, 5.31882606e-03f,
  -4.34360141e-03f, 9.69392657e-02f, 1.02706686e-01f, 5.05611813e-03f, -8.38257298e-02f, -3.57613862e-02f, -5.79265282e-02f, -3.04347277e-02f, -5.56814000e-02f, 6.35699630e-02f,
  6.30620569e-02f, -1.35660805e-02f, 6.13089837e-02f, -7.59788230e-03f, 1.07708022e-01f, 1.73604153e-02f, -5.14303520e-02f, -5.88220842e-02f, -4.69047464e-02f, 7.97977820e-02f,
  8.97028744e-02f, -7.08963070e-03f, 7.43719339e-02f, -1.81025565e-02f, 8.61889869e-02f, -8.22315272e-03f, -2.70514376e-03f, -1.14685632e-02f, -5.74299134e-02f, -1.08929013e-03f,
  -8.28796923e-02f, -3.25462818e-02f, 2.19981484e-02f, -6.74049556e-02f, 2.26752385e-02f, -8.97439346e-02f, 7.63648450e-02f, -1.29047064e-02f, 1.03871539e-01f, 2.10940745e-02f,
  -1.34992480e-01f, 7.46857077e-02f, -5.68022486e-03f, 7.98198022e-03f, 7.63051510e-02f, 1.16379894e-02f, 3.92274669e-05f, 1.43535417e-02f, -3.86825576e-02f, 7.59096593e-02f,
  4.01992165e-02f, 1.31701827e-02f, 2.61932928e-02f, 4.97562513e-02f, -6.84336722e-02f, 4.14358731e-03f, 5.58932237e-02f, 1.19673423e-02f, 8.11806768e-02f, 1.02325771e-02f,
  -2.07133759e-02f, -3.69305424e-02f, 1.65352300e-02f, -2.69671553e-03f, 7.64970556e-02f, -6.78005815e-02f, -7.57077336e-02f, -9.18511592e-04f, -1.06453255e-01f, -1.26448020e-01f,
  -1.59814581e-01f, -5.39884679e-02f, -8.98167565e-02f, -1.00413777e-01f, 4.97984514e-02f, 5.67482114e-02f, 9.05680731e-02f, -6.14400171e-02f, -8.19728076e-02f, 6.44953698e-02f,
  -2.53043305e-02f, -4.38460037e-02f, -6.59762546e-02f, 2.71802978e-03f, -4.09872793e-02f, 1.90417692e-02f, 2.74347030e-02f, -9.30094570e-02f, 3.52071822e-02f, -1.96687318e-02f,
  1.01215526e-01f, 9.30866040e-03f, 5.03200740e-02f, -8.33621025e-02f, -3.47507112e-02f, -1.29479989e-01f, -6.08014911e-02f, -1.06226474e-01f, -1.24012399e-02f, -6.31843060e-02f,
  6.54312372e-02f, -3.54742445e-02f, 1.26995757e-01f, 4.08577137e-02f, 4.30979952e-02f, -5.17026987e-03f, 1.89314838e-02f, 5.20126633e-02f, -4.05100957e-02f, -6.96357265e-02f,
  3.30846123e-02f, 3.43678482e-02f, -7.65463114e-02f, 6.07577153e-02f, -7.57081583e-02f, 7.24793375e-02f, 3.65482531e-02f, -4.58522439e-02f, -6.11204207e-02f, -4.91217524e-02f,
  9.44540650e-02f, -2.00150460e-02f, 3.34718265e-02f, -3.82017456e-02f, 4.88657244e-02f, -8.49840119e-02f, -7.74125233e-02f, 8.80466774e-03f, -3.81096303e-02f, -1.35529131e-01f,
  5.40845767e-02f, 1.14440797e-02f, 1.07274307e-02f, 3.53202187e-02f, 1.26873106e-02f, 4.67415042e-02f, 5.69957532e-02f, -1.11555075e-02f, 4.50134352e-02f, -5.49713038e-02f,
  -3.55561674e-02f, -7.46837482e-02f, 5.81687205e-02f, -2.26033945e-02f, -2.63447817e-02f, 3.61770354e-02f, 7.92808905e-02f, 9.20207947e-02f, 5.36961108e-02f, -4.10406962e-02f,
  8.54339004e-02f, 7.29662105e-02f, 5.75121753e-02f, 6.93596229e-02f, -9.00595274e-04f, -4.18438874e-02f, 2.18313430e-02f, -2.29631513e-02f, 3.13883163e-02f, -2.15238836e-02f,
  -2.57840808e-02f, 5.54040559e-02f, -5.45758344e-02f, -3.23364511e-02f, 1.17397733e-01f, -5.66101372e-02f, -4.86647151e-03f, -6.79164240e-03f, -1.14966547e-02f, -1.11151673e-01f,
  -1.74842365e-02f, -9.89918225e-03f, -8.17083870e-04f, -3.80540192e-02f, -1.28005748e-03f, -2.20178720e-02f, -7.29726553e-02f, -8.09246227e-02f, -5.76055748e-03f, -3.39372382e-02f,
  -1.22083258e-02f, -2.57402547e-02f, -5.08859865e-02f, -4.02045958e-02f, -6.66892454e-02f, -4.91988510e-02f, -1.11186124e-01f, 3.79041396e-02f, -2.24437788e-02f, -7.42543489e-02f,
  1.45879000e-01f, -9.41639543e-02f, 1.54363275e-01f, 8.79290551e-02f, -1.65997267e-01f, -1.59378156e-01f, -7.38783851e-02f, -1.18143996e-02f, 1.59783419e-02f, -9.00877267e-02f,
  3.32087278e-02f, -1.64481737e-02f, 7.14317784e-02f, 5.53290881e-02f, 6.74444139e-02f, -7.65676945e-02f, -2.09701173e-02f, 1.07484665e-02f, 7.43379593e-02f, -7.02885836e-02f,
  -7.58174136e-02f, 1.10342890e-01f, 1.07160449e-01f, 9.55151916e-02f, 5.72672039e-02f, 1.32007316e-01f, -1.95380133e-02f, 6.00693785e-02f, 8.16946328e-02f, 1.75026491e-01f,
  5.06164730e-02f, 7.36691523e-03f, 6.70161322e-02f, 2.02249028e-02f, 4.86968346e-02f, -6.61060065e-02f, -2.91942377e-02f, 9.16043743e-02f, -7.93019384e-02f, -1.01708926e-01f,
  -4.97276708e-02f, 4.27160561e-02f, -1.76034998e-02f, -1.52379973e-02f, 8.24276060e-02f, 6.76508099e-02f, 4.79880832e-02f, 2.48385947e-02f, 7.72644654e-02f, -2.77656969e-02f,
  5.60141429e-02f, -2.34473553e-02f, -3.85222025e-02f, -3.97362150e-02f, 8.24676305e-02f, 1.01041347e-01f, -5.43373730e-03f, 4.62482907e-02f, 2.29741614e-02f, 2.19920389e-02f,
  4.67375517e-02f, 4.87772524e-02f, -4.44659218e-02f, -4.53496017e-02f, -1.78216435e-02f, -5.69639392e-02f, 1.41431065e-02f, 3.96444462e-02f, -1.49178589e-02f, 1.00008294e-01f,
  -4.78411317e-02f, 8.26706439e-02f, -8.75775889e-02f, -8.24135616e-02f, 9.19020623e-02f, -8.95011332e-03f, 4.52419482e-02f, 1.59419235e-02f, -3.29054408e-02f, 3.39925811e-02f,
  3.27221048e-03f, -5.99794351e-02f, 1.85232684e-02f, 6.64327145e-02f, 7.45980814e-02f, -5.17074764e-02f, 2.38042697e-02f, -7.74610043e-02f, 2.52012946e-02f, 8.92604664e-02f,
  -1.62914261e-01f, -4.68688868e-02f, 7.51580894e-02f, -8.23514462e-02f, 2.84619699e-03f, 2.11697221e-02f, -7.11094439e-02f, 1.06224023e-01f, 1.96868610e-02f, 5.38182110e-02f,
  4.71430235e-02f, -1.30222237e-03f, -5.85445762e-03f, -1.78021826e-02f, -7.37532303e-02f, -5.76782674e-02f, -2.66300384e-02f, -2.74072047e-02f, 2.16966309e-02f, 3.30118872e-02f,
  -8.78782272e-02f, -6.09071180e-02f, -3.74867395e-02f, -3.68409343e-02f, -1.20384313e-01f, 2.92126741e-02f, -1.20003626e-01f, 2.59019211e-02f, -1.36941880e-01f, -3.53105664e-02f,
  1.53977945e-01f, -1.28699511e-01f, 1.97701082e-02f, 8.36076885e-02f, 7.71221146e-02f, 6.38078526e-02f, 1.04456641e-01f, 5.24842218e-02f, 1.23194307e-01f, -5.78926934e-04f,
  6.59547970e-02f, 6.24575652e-02f, 7.93844238e-02f, 7.42687508e-02f, -4.74272035e-02f, 1.23194419e-02f, 5.19858487e-02f, -4.22531962e-02f, 2.64994185e-02f, 9.87452641e-02f,
  6.70135394e-02f, -4.88314517e-02f, 1.59105547e-02f, -6.45693066e-03f, -3.00893895e-02f, 4.81135137e-02f, 1.11693852e-02f, -7.38637289e-03f, 6.42449409e-02f, -1.93027426e-02f,
  -4.97305319e-02f, 4.27822396e-02f, -2.64396872e-02f, 7.16356635e-02f, -2.32700654e-03f, 7.03932643e-02f, -2.43408717e-02f, -5.71686663e-02f, 4.42656875e-02f, 7.91421719e-03f,
  7.22416118e-02f, -6.52834624e-02f, -7.97349066e-02f, 6.78720251e-02f, 5.91553226e-02f, -1.69502683e-02f, -3.04987654e-02f, -4.45712432e-02f, -3.61805782e-02f, -4.72099669e-02f,
  2.91712265e-02f, -8.11304227e-02f, 5.36114536e-02f, -6.76837489e-02f, 5.27030490e-02f, -1.18549205e-01f, -1.33905575e-01f, -5.08019365e-02f, 5.03800176e-02f, -4.83860448e-02f,
  -6.20083846e-02f, -4.73224707e-02f, 2.97669992e-02f, -6.83972538e-02f, -2.26073135e-02f, -2.49885302e-02f, -1.23293102e-02f, 6.88194335e-02f, 4.98354547e-02f, 4.99620587e-02f,
  9.18733329e-02f, 1.04895405e-01f, 5.30564003e-02f, 8.21110234e-02f, -1.97985880e-02f, 5.16015068e-02f, -6.86004460e-02f, -1.79501008e-02f, 7.83963427e-02f, -6.74661174e-02f,
  6.24125376e-02f, -3.63954939e-02f, -9.22272913e-03f, 3.46163101e-02f, -2.99911965e-02f, 6.38740957e-02f, 4.21462394e-02f, 3.53320017e-02f, 4.86971624e-02f, 1.12719685e-02f,
  -4.94408496e-02f, -1.46338984e-03f, 1.83326732e-02f, -2.39502061e-02f, -8.03047270e-02f, -4.45710346e-02f, 1.64835546e-02f, -1.35680497e-01f, -1.09499708e-01f, 2.95300912e-02f,
  -1.02133229e-02f, 1.21756690e-02f, 5.50179258e-02f, -8.50676298e-02f, 6.19511193e-05f, 2.65721343e-02f, -8.66812244e-02f, -9.10119414e-02f, 4.36012596e-02f, 4.18023095e-02f,
  -1.57750733e-02f, 6.93258792e-02f, 5.08931093e-02f, 8.96354988e-02f, -1.02391383e-02f, -9.59784910e-02f, 4.28028870e-03f, 4.49727774e-02f, -3.16150039e-02f, 8.24215338e-02f,
  -1.83877394e-01f, 6.30456060e-02f, -7.03813061e-02f, 1.81061387e-01f, 8.68407413e-02f, -6.03886284e-02f, -9.13548470e-02f, 3.38356271e-02f, 1.40816763e-01f, 5.05339094e-02f,
  -2.65055045e-04f, 1.24941982e-01f, 6.74462020e-02f, 1.12035535e-01f, 9.66174006e-02f, 8.21901336e-02f, 1.05211437e-01f, 3.25933285e-02f, 4.90070842e-02f, -3.49468999e-02f,
  1.73189957e-02f, 1.21033512e-01f, 4.54048179e-02f, 4.49546017e-02f, 1.61686212e-01f, 2.43905112e-02f, 5.36720492e-02f, 4.48373482e-02f, 6.58562705e-02f, 1.39757618e-01f,
  4.31903871e-03f, -3.10344175e-02f, 1.47998124e-01f, 1.87302157e-02f, 2.08573882e-02f, 1.94900967e-02f, -6.98833615e-02f, 9.67682712e-03f, -5.08359373e-02f, -4.83338721e-02f,
  3.90908867e-02f, -1.11772746e-01f, -3.24407034e-02f, -4.34227958e-02f, -1.01906709e-01f, -5.33711538e-02f, -5.30346334e-02f, 3.09957992e-02f, 4.71317992e-02f, 3.23426016e-02f,
  1.56209432e-02f, -2.39898190e-02f, -3.83486524e-02f, -6.20008856e-02f, -3.63048315e-02f, 3.63791995e-02f, -3.70621718e-02f, -3.07243951e-02f, -3.81736122e-02f, 5.99622428e-02f,
  -3.25330906e-02f, -3.52262594e-02f, -7.71683920e-03f, -1.03250735e-01f, 6.17623106e-02f, 5.85505813e-02f, -5.55631146e-03f, 8.27531368e-02f, 1.28263626e-02f, 6.83744485e-03f,
  -4.65021431e-02f, -3.55578102e-02f, -3.31376493e-02f, 7.98121169e-02f, 1.82651263e-02f, 5.49611337e-02f, 2.41635703e-02f, -2.09755823e-02f, -7.32890330e-03f, -5.77113591e-03f,
  -2.25609727e-02f, 2.15861052e-02f, 2.84669623e-02f, 1.17540248e-02f, 3.92731540e-02f, -3.51839662e-02f, -4.78916653e-02f, -2.39479449e-02f, 1.23824216e-02f, -8.04333314e-02f,
  3.03487759e-02f, -5.78404590e-02f, 1.34437472e-01f, 8.52636471e-02f, -3.43734212e-02f, 2.42226664e-02f, 8.24429691e-02f, -4.37866263e-02f, -7.68654346e-02f, 5.43560684e-02f,
  -1.11563414e-01f, -5.79719013e-03f, 6.31790459e-02f, -3.09137497e-02f, -7.03536943e-02f, -1.63609926e-02f, 2.26116441e-02f, 4.55480441e-02f, 2.24511661e-02f, -8.67853686e-02f,
  2.79362388e-02f, -5.71793877e-02f, -3.76476645e-02f, -9.62174609e-02f, 3.86093594e-02f, 9.93491635e-02f, -1.27651364e-01f, -4.10680994e-02f, -1.00494280e-01f, -5.21742031e-02f,
  2.11724907e-01f, 8.23445097e-02f, 1.15895137e-01f, 1.95771437e-02f, -1.04695238e-01f, -1.76273778e-01f, -2.34588429e-01f, -1.83507279e-01f, -4.69891690e-02f, -7.02603832e-02f,
  3.61355431e-02f, 9.09824073e-02f, 5.12296781e-02f, 3.89785729e-02f, 1.37863960e-02f, -1.29503403e-02f, 7.79920146e-02f, 1.77385852e-01f, 4.75629494e-02f, -8.70285463e-03f,
  1.15788579e-01f, 1.67111143e-01f, 1.56148002e-01f, 5.09238243e-02f, 1.35249600e-01f, 1.58976793e-01f, 2.76560653e-02f, 6.71405494e-02f, 1.14943415e-01f, 2.24023446e-01f,
  -1.19131096e-02f, 5.31918481e-02f, 3.54623981e-02f, 6.23358935e-02f, 5.34794666e-02f, -6.84046512e-03f, 4.36603418e-03f, 7.43145570e-02f, -3.47705595e-02f, -6.83338568e-02f,
  6.97062612e-02f, -2.04627141e-02f, -2.56136637e-02f, 7.62869641e-02f, -8.90957117e-02f, -1.89510807e-02f, -7.01958537e-02f, 1.05086759e-01f, -3.35453860e-02f, 1.28315424e-03f,
  2.39237007e-02f, -9.78257391e-04f, -1.23657227e-01f, -1.71720013e-01f, 1.26710683e-02f, 7.76113346e-02f, 1.36707053e-02f, 9.18930173e-02f, -5.84088564e-02f, 1.01722963e-02f,
  -3.59008908e-02f, 3.67903747e-02f, 6.16554804e-02f, 6.86516723e-05f, -3.60782519e-02f, 2.76812706e-02f, -7.04198750e-03f, -4.27176952e-02f, 4.17136168e-03f, 5.39099164e-02f,
  -1.15594156e-02f, -2.83484124e-02f, -6.18949793e-02f, -3.49103846e-02f, 5.11489548e-02f, -3.97001335e-04f, 4.07463610e-02f, -5.66178299e-02f, 2.81314272e-02f, 4.22609784e-02f,
  3.32956761e-02f, -6.67954087e-02f, -2.84205116e-02f, 4.29516332e-03f, -4.21437174e-02f, 5.55271208e-02f, 1.56684183e-02f, 5.80254272e-02f, -4.51071793e-03f, -7.24866092e-02f,
  -3.36507410e-02f, 5.39198816e-02f, 9.96125638e-02f, -5.68816699e-02f, -5.11785746e-02f, 6.53460845e-02f, 9.76920426e-02f, 3.10073402e-02f, 8.26748833e-02f, -6.32614642e-02f,
  5.14471252e-03f, 5.27717844e-02f, 7.04526231e-02f, 6.86990693e-02f, 4.84918505e-02f, -1.09319665e-01f, 3.06209587e-02f, 4.43787826e-03f, 1.92295685e-02f, -5.15350141e-02f,
  4.47384976e-02f, -1.85858607e-01f, -1.64081424e-01f, -6.48510903e-02f, -5.42482063e-02f, -1.20244250e-01f, -1.68040525e-02f, -7.39825368e-02f, -9.95576978e-02f, -1.35105982e-01f,
  -3.20340097e-01f, -1.21515589e-02f, -1.21560186e-01f, -8.53970945e-02f, -6.31636335e-03f, -4.26729815e-03f, -7.46611804e-02f, 6.21919695e-04f, 6.64508864e-02f, -1.00510821e-01f,
  4.27358672e-02f, 1.02199207e-03f, -1.56846583e-01f, -1.49121836e-01f, -1.44482017e-01f, -1.82750717e-01f, -1.70075625e-01f, -1.49404898e-01f, -6.32001311e-02f, 6.28043339e-02f,
  2.37898342e-02f, -3.86851802e-02f, 2.14215517e-02f, 1.81442052e-01f, 6.15300760e-02f, 1.36779860e-01f, 1.98169220e-02f, 1.61548741e-02f, -1.59385130e-02f, -1.90600038e-01f,
  -1.80862039e-01f, 5.31640165e-02f, 8.74370150e-03f, -2.08239891e-02f, 4.11400013e-02f, 3.01190484e-02f, -2.46299915e-02f, -3.00103035e-02f, 5.55954315e-02f, -3.46488245e-02f,
  -4.66184095e-02f, -2.19448768e-02f, 2.38563363e-02f, 9.11987796e-02f, -3.36407544e-03f, -1.01202084e-02f, 3.42072658e-02f, 9.21454951e-02f, -5.89523418e-03f, 3.60733755e-02f,
  -2.27185823e-02f, 5.03012724e-02f, 1.41283367e-02f, 3.94427069e-02f, 1.23724826e-01f, -2.01290175e-02f, 8.10425729e-02f, 7.28708804e-02f, 9.53107551e-02f, -1.65616581e-03f,
  -2.88738695e-04f, 2.04550829e-02f, 1.20652542e-02f, -8.60171800e-04f, 4.65933494e-02f, 1.54552832e-02f, 3.07746194e-02f, -7.51907080e-02f, 3.62842567e-02f, 5.08974865e-02f,
  -4.29685675e-02f, -3.27807963e-02f, -8.08758214e-02f, -3.58202346e-02f, 1.33405114e-02f, 1.45214841e-01f, -7.27133602e-02f, -4.50684987e-02f, -2.85234321e-02f, -1.17820902e-02f,
  -1.24486513e-01f, 4.44322117e-02f, 4.41014767e-02f, 4.33848873e-02f, -9.94685888e-02f, -7.07662757e-03f, -4.40231450e-02f, -4.40393202e-02f, -7.24369213e-02f, -4.78118397e-02f,
  -1.28171742e-01f, -3.56820039e-02f, -1.19524814e-01f, 1.05522806e-02f, 2.00406462e-03f, 1.38528447e-03f, 5.30089438e-02f, 4.67564575e-02f, 6.15526922e-02f, 5.45431226e-02f,
  -3.99551690e-02f, 1.82207711e-02f, -1.05688013e-01f, -9.16641653e-02f, -6.76690042e-02f, 4.74605262e-02f, -8.89187381e-02f, -3.82220112e-02f, -5.78155834e-03f, 9.23842285e-03f,
  -1.62084475e-01f, -1.19015075e-01f, -1.47859707e-01f, -8.70268494e-02f, 5.88291511e-02f, -9.60621238e-02f, -3.07516381e-02f, -3.18571292e-02f, -9.39532593e-02f, -1.94797993e-01f,
  -2.22886220e-01f, 1.27484158e-01f, -4.95232753e-02f, -1.67848125e-01f, 1.92962721e-01f, 2.07813203e-01f, 3.78535599e-01f, 3.39470953e-02f, -1.22504652e-01f, 1.07519582e-01f,
  2.83253826e-02f, 2.46139746e-02f, -2.14390736e-02f, -6.70015663e-02f, 4.71847169e-02f, 1.14229508e-01f, 7.07982033e-02f, -4.49808054e-02f, -1.00768238e-01f, -3.40197682e-02f,
  2.18062066e-02f, 1.06846327e-02f, -1.16483025e-01f, -8.79819170e-02f, -5.65514080e-02f, -1.51931092e-01f, -6.94692582e-02f, -6.28812388e-02f, 1.53703228e-01f, 1.00238785e-01f,
  -2.12410167e-02f, 2.61049960e-02f, -9.04414356e-02f, 1.10725267e-02f, 5.28284051e-02f, -1.11497708e-01f, 8.68150592e-02f, -4.68581095e-02f, 4.54222448e-02f, -3.47026698e-02f,
  -5.91597846e-03f, 4.69394997e-02f, 8.23389441e-02f, -7.82867242e-03f, -3.53805125e-02f, 7.77854845e-02f, -2.63478030e-02f, -2.42288020e-02f, -4.11407538e-02f, -3.54227610e-02f,
  1.44428033e-02f, 2.75287647e-02f, 6.18762225e-02f, -7.38230422e-02f, -6.87001720e-02f, -7.09769502e-02f, 7.17427284e-02f, 2.25066859e-02f, 8.27020928e-02f, -4.48123664e-02f,
  4.57916521e-02f, 8.85984823e-02f, 3.50783952e-02f, 7.02692866e-02f, -5.55996336e-02f, 4.17521447e-02f, 5.03238924e-02f, -5.37337288e-02f, 3.81276794e-02f, 1.75721515e-02f,
  -2.42564045e-02f, -9.63272601e-02f, -9.20114759e-03f, -5.32336999e-03f, -5.95467538e-02f, 8.60370472e-02f, -3.98764499e-02f, -2.07882579e-02f, -3.74374464e-02f, 2.34021265e-02f,
  -3.99542972e-02f, -4.72049639e-02f, 1.30962273e-02f, 2.02823672e-02f, -3.83037925e-02f, 3.70103419e-02f, -3.45932208e-02f, -4.40710969e-02f, -8.84727463e-02f, 7.00937808e-02f,
  -5.69987707e-02f, 6.93746060e-02f, -5.13641611e-02f, -4.04126123e-02f, -3.60632390e-02f, -7.93987215e-02f, 1.35158701e-02f, 1.80144794e-02f, 9.81002003e-02f, 3.33738811e-02f,
  1.72044039e-01f, 8.23217034e-02f, 4.34413068e-02f, -8.60104635e-02f, -6.90657347e-02f, 3.22861713e-03f, -8.80777091e-03f, -9.19366106e-02f, -1.15816511e-01f, 8.53426289e-03f,
  -4.95972894e-02f, -4.73021567e-02f, -1.58101127e-01f, 5.47297578e-03f, -2.65771616e-03f, -2.23380420e-02f, -8.03803131e-02f, -8.19809511e-02f, -1.90412924e-02f, -8.38527530e-02f,
  -8.20711032e-02f, 5.76464087e-03f, -9.12649184e-02f, -3.50257680e-02f, -1.29506052e-01f, -1.12175979e-01f, -4.08733822e-02f, -7.30184317e-02f, -4.45690565e-02f, -5.00984155e-02f,
  -9.34063550e-03f, 9.63587016e-02f, -2.17493400e-02f, 8.48669675e-04f, -2.38217097e-02f, -1.29749492e-01f, -7.36710802e-02f, -5.76084778e-02f, 9.86722186e-02f, -1.09572299e-01f,
  1.97847858e-02f, -2.17751274e-03f, 1.32496776e-02f, -3.72222662e-02f, -8.08279142e-02f, -3.24369930e-02f, -8.68592132e-03f, -1.17008254e-01f, 1.95195843e-02f, -1.85000286e-01f,
  2.33771913e-02f, 8.90124366e-02f, -1.34573430e-01f, -7.32926792e-03f, -3.57952118e-02f, 1.60893332e-02f, 5.25115207e-02f, -7.12340623e-02f, -1.71941929e-02f, 7.87263140e-02f,
  6.46720901e-02f, -5.46389259e-02f, 9.97514650e-02f, -2.30487082e-02f, -9.84429289e-03f, -5.10584749e-02f, 3.22110429e-02f, -3.64558175e-02f, 3.62833664e-02f, -3.50005142e-02f,
  -6.44500647e-03f, -1.05316073e-01f, -6.11139238e-02f, -5.05332313e-02f, -3.75008851e-04f, 9.98888790e-05f, -2.00929549e-02f, 4.71367836e-02f, -1.15343248e-02f, 4.56901751e-02f,
  -4.86044437e-02f, 4.65890439e-03f, -8.83158669e-02f, 6.27110302e-02f, -1.78856105e-02f, -2.97244061e-02f, 4.85581793e-02f, -9.00002290e-03f, 4.50845435e-02f, -5.40920068e-03f,
  -7.48420060e-02f, -7.71254525e-02f, -5.05646430e-02f, -3.95191349e-02f, -8.26416444e-03f, 2.41795722e-02f, 4.06847186e-02f, -6.71571046e-02f, 2.39571240e-02f, 2.21825857e-03f,
  2.24949159e-02f, 7.28466138e-02f, 8.62519071e-02f, -3.68638635e-02f, 7.67903915e-03f, -6.31380528e-02f, 9.21544880e-02f, -2.60971338e-02f, 8.54345560e-02f, 1.75277790e-04f,
  1.39622524e-01f, -1.75065473e-01f, -3.88383418e-02f, 7.42180720e-02f, 1.41553078e-02f, 7.74774607e-03f, -3.62013956e-03f, 5.56525961e-03f, 1.02750644e-01f, -2.32196879e-02f,
  -5.65170869e-03f, 8.05647671e-02f, -6.12527281e-02f, -6.12876862e-02f, -8.10199156e-02f, -1.02126740e-01f, 2.15637907e-02f, -2.87187658e-02f, 3.67191248e-02f, -7.50679448e-02f,
  -1.09193943e-01f, -2.97238529e-02f, 5.47584426e-03f, 4.67116497e-02f, 1.49979703e-02f, 3.38963158e-02f, -7.71476375e-03f, 6.70641735e-02f, 7.74482861e-02f, -3.31689566e-02f,
  -4.29388970e-01f, -1.41123489e-01f, -6.97346628e-02f, -4.90314476e-02f, 1.82276115e-01f, -3.20990309e-02f, -8.47984478e-02f, -6.51371330e-02f, 4.84592319e-02f, 4.01813462e-02f,
  2.57037356e-02f, 9.14917365e-02f, 5.42732924e-02f, 1.05713174e-01f, -3.90243419e-02f, 1.51988547e-02f, 9.24801677e-02f, -7.14724064e-02f, -1.02684528e-01f, 1.22630619e-01f,
  1.64489329e-01f, 2.45001223e-02f, -1.74032032e-01f, 7.34720975e-02f, 6.32992312e-02f, 3.97503637e-02f, -4.70835231e-02f, -9.24633592e-02f, -2.66214777e-02f, 1.07895039e-01f,
  -8.87606218e-02f, -8.60393196e-02f, 3.06088608e-02f, -2.79509090e-02f, -3.15841637e-03f, -3.13056000e-02f, 4.91748936e-02f, -3.43283340e-02f, 7.13479593e-02f, -5.09334244e-02f,
  4.19447422e-02f, -4.31745127e-02f, -3.18158604e-02f, -1.76072177e-02f, -8.73436928e-02f, -6.82723001e-02f, -1.27535716e-01f, -8.48139748e-02f, -2.03207717e-03f, -7.05555677e-02f,
  1.34147286e-01f, 8.33226666e-02f, -1.53728977e-01f, 2.01864671e-02f, -7.11426884e-02f, -1.61746945e-02f, -7.76776597e-02f, -7.60924593e-02f, -1.00428753e-01f, -1.96911588e-01f,
  4.01975177e-02f, -4.82516550e-02f, -1.80620153e-03f, -1.22058548e-01f, -1.58934109e-02f, -2.61279736e-02f, -6.19212985e-02f, 1.18450671e-01f, 6.67748451e-02f, 9.52543318e-03f,
  6.67055622e-02f, 6.52752668e-02f, 3.28585245e-02f, -8.23022202e-02f, -1.09880678e-02f, -5.09309545e-02f, 4.24430668e-02f, -3.25090699e-02f, -3.28546464e-02f, 4.84142713e-02f,
  2.49104574e-02f, -2.93470118e-02f, -3.70302387e-02f, 2.67679747e-02f, -9.94194373e-02f, 5.30832075e-02f, -2.93596741e-02f, -1.02070041e-01f, -3.76461446e-02f, -1.07280491e-02f,
  -1.35605872e-01f, -3.02793998e-02f, -3.91160809e-02f, 6.97477395e-03f, 2.98867177e-04f, -3.54602449e-02f, -2.48616636e-02f, 6.47321716e-03f, 6.76855966e-02f, 3.74150872e-02f,
  1.19670881e-02f, 2.08432004e-02f, -4.04804535e-02f, -2.86140721e-02f, 1.22133724e-01f, 2.40598619e-02f, -7.24152550e-02f, 1.03243008e-01f, -2.10120138e-02f, 1.43695809e-02f,
  -1.08431660e-01f, -4.43112589e-02f, -1.51419804e-01f, -5.03426380e-02f, -1.43892854e-03f, -5.51299416e-02f, -1.30610883e-01f, -7.06927180e-02f, -7.10371733e-02f, -1.89146101e-01f,
  -1.68277830e-01f, 9.77953076e-02f, -8.31671581e-02f, 1.04305848e-01f, 1.64037168e-01f, 5.76154850e-02f, 1.55908689e-02f, 1.52080180e-03f, -5.40163778e-02f, -5.41289635e-02f,
  7.83939660e-02f, -5.91405928e-02f, 8.82618651e-02f, 3.28731574e-02f, 5.15609570e-02f, 5.38395233e-02f, 1.06602550e-01f, -8.50130394e-02f, -6.41723797e-02f, -5.12485020e-02f,
  5.93601866e-03f, 2.19682930e-03f, -4.27109115e-02f, 5.34118526e-02f, 2.92984489e-02f, 7.92329982e-02f, -8.71752948e-02f, -4.82824724e-03f, 3.79214645e-03f, 1.69001937e-01f,
  -1.73859745e-02f, -1.00281432e-01f, -4.10052203e-02f, 6.01528659e-02f, -7.15195313e-02f, -3.43006961e-02f, 5.58505505e-02f, -4.08045352e-02f, 9.60832927e-03f, 6.84707463e-02f,
  4.84488271e-02f, -8.20412859e-03f, 9.83038768e-02f, -1.29385209e-02f, 4.62924875e-02f, 5.21374792e-02f, 4.18035835e-02f, -1.18861713e-01f, -4.46429588e-02f, -1.99454967e-02f,
  -1.06202317e-02f, 7.08327591e-02f, 5.52980229e-02f, -8.14496800e-02f, -4.41687070e-02f, 5.69760837e-02f, -7.18608350e-02f, -9.73138884e-02f, 2.10900549e-02f, 5.14737219e-02f,
  1.61107764e-01f, 9.22484472e-02f, 6.90453649e-02f, 6.03673458e-02f, 3.31898592e-02f, 1.89396590e-02f, 1.11643642e-01f, -2.32703220e-02f, 5.38861342e-02f, -6.92926943e-02f,
  -3.16887051e-02f, 4.34522368e-02f, -7.70492479e-02f, 8.69562998e-02f, -5.11927269e-02f, 1.87610704e-02f, -6.78504724e-03f, 5.38477786e-02f, -4.25857008e-02f, -2.73387488e-02f,
  -3.46222222e-02f, -6.07917197e-02f, 3.35298516e-02f, 2.72437725e-02f, 5.61920740e-02f, -1.10962130e-02f, 1.10067733e-01f, 8.60656202e-02f, 5.64406812e-02f, 1.75995752e-02f,
  -2.16994900e-02f, -7.10390732e-02f, -7.17020482e-02f, -2.10118517e-02f, -2.10861806e-02f, -3.11043430e-02f, -1.64621081e-02f, -7.39225820e-02f, 4.32976149e-02f, -4.93673012e-02f,
  8.50581452e-02f, 6.68598115e-02f, -6.17360547e-02f, -2.55047940e-02f, -2.49800682e-02f, 1.20310914e-02f, 1.32555747e-02f, -2.19881181e-02f, -1.14502266e-01f, -1.58513747e-02f,
  -2.48976685e-02f, 4.51363511e-02f, -3.34068388e-02f, -7.65718445e-02f, 2.65038759e-02f, -7.73066282e-02f, -7.54043907e-02f, -1.20000876e-01f, -5.47620049e-03f, 2.79033817e-02f,
  1.98256031e-01f, -1.49832010e-01f, 3.73684126e-03f, 1.03904955e-01f, -1.28654120e-02f, 1.64929718e-01f, 6.34826496e-02f, 3.98573838e-02f, -2.85811890e-02f, 5.11619896e-02f,
  -1.22062758e-01f, 5.81515906e-03f, -1.01920016e-01f, -9.94439647e-02f, 4.86055091e-02f, 1.05730064e-01f, 5.85097447e-02f, 1.14454620e-01f, 4.96311039e-02f, 1.41098678e-01f,
  8.76467600e-02f, 6.49779439e-02f, 4.23142985e-02f, -6.74231425e-02f, -6.38061017e-02f, 1.25634242e-02f, 8.16793591e-02f, -3.00936494e-02f, 4.89599928e-02f, -6.76373439e-03f,
  5.15770838e-02f, -7.08512068e-02f, -4.56128679e-02f, -5.43298125e-02f, 2.38635577e-02f, -1.64744984e-02f, 1.20012045e-01f, -6.16275379e-03f, -7.74137974e-02f, 3.01045040e-03f,
  5.97062288e-03f, 6.83761835e-02f, -7.85022154e-02f, -7.81709999e-02f, 7.31048128e-03f, -5.51531557e-03f, -4.79866937e-02f, 3.39422375e-02f, 3.10356915e-02f, -3.49205807e-02f,
  -4.84649427e-02f, -8.60653743e-02f, -1.21427542e-02f, -8.54759440e-02f, -3.53708826e-02f, 4.72897477e-02f, 2.85198330e-03f, 6.41220734e-02f, -5.41072637e-02f, -5.24836779e-02f,
  1.12189464e-02f, 1.08552836e-02f, 4.18369398e-02f, 7.83689227e-03f, 6.90829754e-02f, -1.70743633e-02f, 5.11666685e-02f, -1.21922669e-04f, 1.63942371e-02f, 5.80746196e-02f,
  4.75644581e-02f, -6.88556805e-02f, -1.05277404e-01f, 3.85598131e-02f, -6.52842596e-02f, -5.64320832e-02f, -2.32187435e-02f, -6.02280088e-02f, 8.32286011e-03f, 6.88012391e-02f,
  2.44139638e-02f, -3.68675217e-02f, -4.31555323e-02f, 1.60457864e-02f, 9.87756159e-03f, -4.27851416e-02f, 9.63467348e-04f, -6.69697672e-02f, 6.52950779e-02f, 7.40349442e-02f,
  -1.56534955e-01f, -2.11592857e-02f, 1.37541071e-01f, -1.98155697e-02f, 1.99955562e-03f, -8.67995173e-02f, 1.13184666e-02f, -1.08863510e-01f, -6.83048321e-03f, 1.49734812e-02f,
  7.56602138e-02f, 1.99155156e-02f, -5.21719307e-02f, -2.12886967e-02f, 9.61647183e-02f, 9.16507654e-03f, 5.05873673e-02f, -1.39082654e-03f, 5.71437888e-02f, 5.04934080e-02f,
  -1.94132626e-02f, 5.18024787e-02f, 7.80205950e-02f, -6.29002452e-02f, 4.11150940e-02f, -1.78824109e-03f, 3.15292664e-02f, 7.97056630e-02f, -4.90488708e-02f, 6.92404583e-02f,
  -1.23055242e-01f, 1.68544769e-01f, 8.22542086e-02f, -1.04651526e-01f, 1.83762535e-02f, 7.47416764e-02f, 2.32062504e-01f, 6.63262680e-02f, -9.57273319e-02f, 1.07728474e-01f,
  7.68249780e-02f, -5.92653416e-02f, -7.55333602e-02f, -7.64497891e-02f, 4.89559881e-02f, 9.30232927e-03f, -4.17726524e-02f, -5.86507143e-03f, 6.08196307e-04f, 8.45951438e-02f,
  -8.67059156e-02f, -2.34356504e-02f, -5.57420701e-02f, -9.76223778e-03f, -1.07811011e-01f, -1.39899582e-01f, -1.53894583e-02f, 6.59080744e-02f, -5.81024855e-04f, -1.27489150e-01f,
  9.45915356e-02f, 1.18198037e-01f, -1.20331578e-01f, -1.12650357e-01f, 9.42660943e-02f, -2.47604642e-02f, 9.82436165e-02f, -4.94641177e-02f, 8.19501132e-02f, 3.52715887e-02f,
  1.42431688e-02f, -2.12869216e-02f, 5.44900894e-02f, -4.77275178e-02f, 6.54628128e-02f, 3.45595879e-03f, -8.14274624e-02f, -9.18347575e-03f, -3.67242061e-02f, -3.35127153e-02f,
  -3.33887115e-02f, -7.24704179e-04f, 7.29991272e-02f, -6.83074817e-03f, -4.41878513e-02f, -7.09288940e-02f, 5.01461588e-02f, 3.44367772e-02f, 2.68067401e-02f, 2.19191238e-02f,
  -6.41452149e-02f, -1.02520235e-01f, -2.69629676e-02f, -1.87052172e-02f, -5.66104837e-02f, -4.01172712e-02f, 4.88233902e-02f, -2.73734350e-02f, 1.42464053e-03f, -6.82543730e-03f,
  1.02051953e-02f, 3.06861685e-03f, 6.35392889e-02f, 1.42250927e-02f, 1.77603681e-02f, -2.67997421e-02f, 1.64347086e-02f, 3.34232375e-02f, 6.85227737e-02f, -8.70578736e-03f,
  -2.90851537e-02f, 2.00795233e-02f, 3.92664671e-02f, 3.14947553e-02f, 8.39371905e-02f, 4.39368822e-02f, 6.97475672e-02f, -5.88420779e-02f, -4.57823277e-02f, 6.86861053e-02f,
  -1.21509798e-01f, 6.79787323e-02f, 1.14735244e-02f, -1.13423839e-02f, -6.78927451e-02f, 1.12140859e-02f, -6.93357841e-04f, -2.72357054e-02f, 2.12078448e-02f, -2.56785620e-02f,
  -3.45431417e-02f, 8.02571252e-02f, 6.34216592e-02f, 2.99208965e-02f, -4.84896600e-02f, 1.52540384e-02f, -9.85194817e-02f, -4.65715630e-03f, 6.21029027e-02f, 8.83614421e-02f,
  3.22493017e-02f, -1.49690872e-02f, 2.99180169e-02f, -4.79080826e-02f, 5.00759333e-02f, 1.93863306e-02f, 2.22254125e-03f, -8.67999345e-02f, -2.48642676e-02f, -5.60872220e-02f,
  1.97189808e-01f, -1.53476194e-01f, -2.61524296e-03f, 8.70624185e-02f, -1.74396988e-02f, 1.05162956e-01f, -1.21687666e-01f, 1.51995108e-01f, 1.37206107e-01f, -5.20631745e-02f,
  -8.25115666e-02f, 8.70613754e-02f, 9.99060497e-02f, 8.80518407e-02f, -4.19791490e-02f, -1.80505380e-01f, -1.47025630e-01f, 6.94269389e-02f, 1.19425721e-01f, -3.06068007e-02f,
  -9.36501101e-02f, -8.15732554e-02f, -1.65407229e-02f, 1.09752215e-01f, -9.15466920e-02f, -1.30185187e-02f, -8.95594507e-02f, -1.44441068e-01f, -1.64549887e-01f, -1.42407343e-01f,
  -1.89721227e-01f, 3.99344191e-02f, 2.97886580e-02f, 6.48960769e-02f, 4.11228426e-02f, 5.81781343e-02f, 2.96610799e-02f, -2.11202223e-02f, 8.05619806e-02f, -1.04689866e-01f,
  -6.92794099e-02f, 5.09780720e-02f, -2.02613603e-02f, -3.20039280e-02f, 4.80627688e-03f, -4.46355417e-02f, 8.79049227e-02f, -3.56730223e-02f, -5.37702739e-02f, -1.08447455e-01f,
  6.34971112e-02f, -4.85571986e-03f, -7.92000815e-02f, -1.12957254e-01f, -6.22853450e-02f, 1.17042288e-01f, -1.12871617e-01f, -6.73042834e-02f, -7.42062852e-02f, -1.60906628e-01f,
  -4.63551171e-02f, 3.85438688e-02f, -4.81207781e-02f, 1.48366317e-02f, -4.35595326e-02f, -2.04406064e-02f, -6.34092540e-02f, -8.43521133e-02f, 1.21993959e-01f, -2.04577930e-02f,
  -1.06469588e-02f, -5.15277870e-02f, 2.55936235e-02f, -5.10068759e-02f, 6.97141662e-02f, -1.30479753e-01f, 2.62550972e-02f, -7.81611577e-02f, 1.66797880e-02f, 1.10057853e-02f,
  7.28134364e-02f, -9.13337544e-02f, -6.40717000e-02f, 4.37125191e-02f, -2.15032399e-02f, 2.97659449e-02f, 4.87057343e-02f, 2.86249146e-02f, 3.56831178e-02f, 5.38444370e-02f,
  3.36053744e-02f, 8.66442174e-02f, -1.50170168e-02f, -4.46640700e-02f, 3.64602320e-02f, 5.78752311e-04f, 1.88268591e-02f, 2.12818440e-02f, 8.11227411e-03f, 7.20260888e-02f,
  3.93756293e-02f, 4.99048941e-02f, 4.45115007e-02f, -2.68453024e-02f, 8.73304345e-03f, -9.62647423e-02f, -1.32617133e-03f, 8.69757030e-03f, -1.05449401e-01f, 7.37183243e-02f,
  -4.10800837e-02f, -2.93638706e-02f, -4.16974016e-02f, -1.04581133e-01f, 7.61490911e-02f, 9.77405533e-02f, -7.92530924e-02f, -9.86910760e-02f, -1.60050821e-02f, -1.87791228e-01f,
  2.22697551e-03f, 9.20508429e-02f, -7.00616390e-02f, -7.39195049e-02f, 5.29568531e-02f, -8.08157101e-02f, -3.39765735e-02f, -2.87844390e-02f, 5.84671311e-02f, -7.89526477e-02f,
  -1.78418178e-02f, -2.19980814e-02f, -4.50098179e-02f, 4.22935486e-02f, -2.71943416e-02f, -3.72046717e-02f, -1.17681175e-01f, -1.07763521e-01f, -1.17586143e-01f, -1.22515969e-01f,
  -2.23770458e-02f, 6.42278939e-02f, -8.80428478e-02f, -1.38145154e-02f, -3.03237587e-02f, -4.29680496e-02f, 5.84303029e-02f, 4.08586450e-02f, -4.66720574e-02f, -1.44689493e-02f,
  5.31582534e-03f, -1.20062448e-01f, -9.89518166e-02f, -1.39924679e-02f, 1.11123562e-01f, -5.27986772e-02f, 4.91134077e-02f, 5.38813844e-02f, 7.90851414e-02f, 1.81525387e-02f,
  5.01774624e-02f, 7.40203112e-02f, 6.35800138e-02f, -4.76298667e-02f, -3.26701067e-02f, -4.13201526e-02f, -4.07028086e-02f, -1.59465577e-02f, 4.38413993e-02f, 5.30966707e-02f,
  -2.85435412e-02f, -8.75667781e-02f, 4.94251624e-02f, 4.66646478e-02f, -9.63680372e-02f, -1.10268798e-02f, 1.65563803e-02f, 3.59542109e-02f, -1.17031366e-01f, -7.23451152e-02f,
  5.13125062e-02f, -9.54398662e-02f, 2.79412121e-02f, -5.19245341e-02f, -3.94093841e-02f, -3.58832651e-03f, 5.34969680e-02f, 8.37593377e-02f, 9.07938853e-02f, -5.31961657e-02f,
  -3.38190310e-02f, 9.51334555e-03f, 4.42402437e-02f, 7.90576562e-02f, -1.21867955e-02f, 1.88176963e-03f, 5.17282970e-02f, -3.03706750e-02f, 6.87840730e-02f, -5.34765869e-02f,
  1.76783483e-02f, 1.72230359e-02f, -4.33316417e-02f, -4.58401889e-02f, -1.67983137e-02f, 3.28594982e-03f, -2.00930145e-02f, -3.61194424e-02f, 6.57865480e-02f, -2.96050105e-02f,
  7.52149746e-02f, -1.90893523e-02f, 9.24648345e-02f, 1.00700051e-01f, -5.91092035e-02f, 7.33354092e-02f, 2.52848286e-02f, -1.17955944e-02f, 1.04262158e-01f, -6.35753870e-02f,
  7.81662688e-02f, 8.48541409e-02f, 4.28781696e-02f, -3.26088481e-02f, 4.02800143e-02f, -5.92171140e-02f, 3.74988094e-02f, -1.02432236e-01f, -1.74991097e-02f, -3.03897336e-02f,
  6.16874062e-02f, 2.00322759e-03f, -9.99184176e-02f, -3.49373035e-02f, 8.40646622e-04f, -4.14597206e-02f, -2.98723672e-03f, 7.98800439e-02f, -3.70258018e-02f, -7.34271631e-02f,
  -5.09889387e-02f, -1.40702322e-01f, 1.31872386e-01f, -1.26368374e-01f, 1.54735461e-01f, 1.95549384e-01f, 6.83454797e-02f, 2.12276075e-02f, -1.10138571e-02f, 6.69577494e-02f,
  1.11448755e-02f, 3.28631350e-03f, -6.48185611e-02f, -2.11563874e-02f, 5.49682491e-02f, -9.56630707e-03f, 4.74413252e-03f, 9.90699679e-02f, 1.23706765e-01f, 5.47516979e-02f,
  -7.40879774e-02f, -4.79084663e-02f, -9.95375291e-02f, -7.24739730e-02f, 6.23383224e-02f, 2.11592149e-02f, -1.68938842e-02f, -6.02873713e-02f, 2.87474003e-02f, -1.09833822e-01f,
  8.10902417e-02f, -1.05794646e-01f, 6.98649138e-03f, -1.49395972e-01f, 1.10087261e-01f, 6.67963177e-03f, 9.51631293e-02f, 7.53570953e-03f, -9.53266621e-02f, 3.07260337e-03f,
  -6.47461340e-02f, 3.38596255e-02f, -2.99508944e-02f, 1.54258553e-02f, -3.52149084e-02f, 1.14188697e-02f, -1.11971915e-01f, -5.27976640e-02f, 2.08496512e-03f, -6.96666241e-02f,
  -1.40783191e-01f, 3.03907134e-03f, 4.44236435e-02f, -8.33763480e-02f, -5.95217124e-02f, -5.84022924e-02f, -4.08128016e-02f, -5.13020158e-02f, -5.56929037e-02f, -5.03889867e-04f,
  6.88936710e-02f, 5.70213050e-02f, 2.32198481e-02f, -1.75587684e-02f, 7.68271834e-02f, -4.41468991e-02f, 4.94734105e-03f, 3.90476584e-02f, -3.20301764e-02f, 8.57264549e-02f,
  -7.66469026e-03f, 5.18230870e-02f, 6.76479191e-02f, -4.63320799e-02f, -1.11786379e-02f, 4.34648171e-02f, 5.19234268e-03f, 6.54894114e-02f, -5.67845292e-02f, 3.50523591e-02f,
  1.02786650e-03f, 5.16469963e-02f, -3.10775358e-02f, 5.81272282e-02f, -4.03593220e-02f, 4.22241762e-02f, -1.34819020e-02f, 3.71178873e-02f, -5.29652797e-02f, 6.81372806e-02f,
  7.66203627e-02f, -1.11971766e-01f, 3.61119658e-02f, -6.41747192e-02f, -5.56081301e-03f, -2.27774587e-02f, -9.69893038e-02f, 3.59197642e-04f, 3.91662754e-02f, 6.09130897e-02f,
  4.45234999e-02f, -3.08074113e-02f, 3.03133316e-02f, -1.74302235e-02f, 8.01180974e-02f, 2.80634798e-02f, 1.16857542e-02f, -3.51026319e-02f, -4.72304858e-02f, 7.64891282e-02f,
  2.73130648e-02f, 1.31525382e-01f, 5.81347868e-02f, 7.38596320e-02f, -4.27524075e-02f, 3.53611968e-02f, 5.43160476e-02f, 1.35467410e-01f, 2.31045373e-02f, 1.71062529e-01f,
  3.07446569e-01f, -2.78836358e-02f, 2.04390943e-01f, -1.09729543e-02f, 6.80672377e-02f, 6.47121519e-02f, 5.50143011e-02f, 8.12411755e-02f, 1.35351345e-01f, -5.00163510e-02f,
  -1.48008943e-01f, -9.81726870e-02f, -2.28448100e-02f, 7.87454844e-03f, 1.02468207e-01f, 1.30207315e-01f, 6.45234734e-02f, 1.86399445e-01f, 1.68841019e-01f, 1.33138090e-01f,
  2.85963174e-02f, -4.07634117e-03f, 1.09038062e-01f, -1.03188856e-02f, 8.30042958e-02f, -1.13637984e-01f, 6.64301217e-02f, 7.78473094e-02f, 2.80277859e-02f, 6.93005770e-02f,
  -8.91531911e-03f, 1.95717305e-01f, 1.78348050e-02f, -1.81345388e-01f, -6.29108995e-02f, 3.54377776e-02f, 4.97820266e-02f, 4.30887975e-02f, -4.44764597e-03f, -2.99778860e-02f,
  -8.21936652e-02f, -4.77850847e-02f, -3.97131667e-02f, -8.58107768e-03f, -6.22447059e-02f, 1.11672871e-01f, 2.29597818e-02f, 6.83378279e-02f, -3.73153738e-03f, -6.60817400e-02f,
  -1.67238504e-01f, -2.37001758e-02f, -4.58376389e-03f, 2.10777391e-02f, -2.26944759e-02f, -1.13606386e-01f, -2.98434347e-02f, 1.74124911e-02f, 2.17400063e-02f, 1.81889217e-02f,
  -1.25519773e-02f, 1.02235027e-01f, -2.17690524e-02f, -5.92984818e-02f, -3.61430608e-02f, -8.93065426e-03f, -2.71064658e-02f, -6.57799914e-02f, 4.55326438e-02f, -2.97288913e-02f,
  4.09314036e-02f, 4.56768796e-02f, -1.23841511e-02f, 2.19427031e-02f, -3.55953583e-03f, -2.60814442e-03f, 1.87681653e-02f, 1.95667893e-02f, 2.42094398e-02f, -5.38309396e-04f,
  -2.16644723e-03f, 6.70490339e-02f, 5.53798899e-02f, -7.98967183e-02f, -2.61268020e-02f, 2.04389654e-02f, -4.07519341e-02f, -3.09846904e-02f, -6.92610964e-02f, 4.98177595e-02f,
  -2.08140031e-01f, -2.00007796e-01f, -6.66060224e-02f, -3.15461541e-03f, 7.76447803e-02f, -1.45155517e-02f, -2.76195612e-02f, 4.66965847e-02f, -3.35954083e-03f, 4.45648395e-02f,
  1.26882615e-02f, 6.44142702e-02f, 3.85316499e-02f, -9.44394842e-02f, 6.34555146e-02f, -2.47925874e-02f, -3.05702537e-02f, 4.90797460e-02f, 3.53360996e-02f, 4.11919765e-02f,
  -1.82529464e-02f, -2.65405048e-02f, 6.02586642e-02f, 2.23416407e-02f, -1.84413791e-02f, -1.02388859e-01f, -4.15011309e-02f, 7.01621324e-02f, 9.34470147e-02f, 3.42236497e-02f,
  7.01463968e-02f, -1.06759528e-02f, 4.91016209e-02f, 7.22653791e-02f, 3.50420810e-02f, 1.54602557e-01f, 8.93045068e-02f, -6.49627205e-03f, -5.02111167e-02f, -5.20379059e-02f,
  2.64147599e-03f, -6.16886467e-02f, 6.10569958e-03f, -3.33146192e-02f, 4.17802185e-02f, 1.11148003e-02f, 5.78042828e-02f, -3.63828838e-02f, 8.01305696e-02f, 1.09260052e-01f,
  7.66905397e-02f, 7.97039270e-02f, -2.36640553e-04f, -1.78504325e-02f, -6.99470937e-02f, 1.64855309e-02f, 7.53979906e-02f, -3.21144611e-02f, 5.10813389e-03f, -2.29373258e-02f,
  1.52194828e-01f, -5.00538014e-02f, 8.10253695e-02f, 3.65473405e-02f, 8.24267492e-02f, -7.20149279e-02f, 4.26173434e-02f, 1.88556570e-03f, -2.63294987e-02f, 2.95461155e-02f,
  -1.03494152e-01f, 6.50998354e-02f, 3.86609770e-02f, 4.72983979e-02f, 2.12567300e-03f, 4.77982014e-02f, -1.48132183e-02f, 4.91333455e-02f, 6.94632903e-02f, 4.54769135e-02f,
  1.63756907e-02f, 6.05997816e-02f, 1.10038266e-01f, -3.39622200e-02f, 1.70965400e-02f, -8.63385126e-02f, 5.65786697e-02f, 4.60681599e-03f, 3.75759527e-02f, 4.25462760e-02f,
  4.52330410e-02f, -6.49352148e-02f, -6.71273321e-02f, 2.56114826e-02f, -6.21659756e-02f, 2.16801441e-03f, 4.11178097e-02f, 2.78285686e-02f, 3.10095828e-02f, 1.48132583e-02f,
  2.95571890e-02f, -1.06068188e-02f, -7.17071518e-02f, -3.84232439e-02f, 2.92909816e-02f, 4.53707315e-02f, -4.35804017e-03f, -6.05455637e-02f, 6.30751774e-02f, -3.99717651e-02f,
  -6.00535795e-02f, 1.72226690e-02f, 6.47840789e-03f, -6.44843429e-02f, 6.35738857e-03f, -3.96615006e-02f, -2.39652265e-02f, 8.57454445e-03f, -8.07352439e-02f, 3.86294387e-02f,
  -1.80407297e-02f, 4.11609299e-02f, -5.85613213e-02f, 1.54052870e-02f, 3.45821716e-02f, -4.03327122e-02f, -7.28551745e-02f, -7.72109106e-02f, -2.75724870e-03f, -4.65763286e-02f,
  2.61563212e-02f, -8.01040977e-02f, -4.68083937e-03f, 1.65812168e-02f, 5.19356579e-02f, -5.71716353e-02f, -1.31153604e-02f, 7.71068707e-02f, 8.06201473e-02f, -1.08291686e-01f,
  -4.53657210e-02f, 6.49082139e-02f, -7.80314949e-05f, -4.11293469e-02f, -3.24000716e-02f, 6.45265803e-02f, 1.18107550e-01f, 6.17958792e-02f, 6.86980113e-02f, -2.65188683e-02f,
  1.62314381e-02f, -3.90036847e-03f, -8.32164586e-02f, 8.94228965e-02f, -5.44573180e-02f, -1.55218199e-01f, -3.66738476e-02f, 9.75586101e-03f, -6.42009676e-02f, -1.14453614e-01f,
  -1.60710722e-01f, -5.46538830e-02f, -6.80603832e-02f, -3.65697267e-03f, 3.57427523e-02f, -7.72695169e-02f, -1.13028824e-01f, -5.23330122e-02f, 5.41604869e-02f, -1.01452827e-01f,
  -1.32114112e-01f, -2.21695676e-02f, -1.54787553e-02f, -1.88186672e-02f, -1.30311072e-01f, -4.08293046e-02f, -1.43535733e-01f, -2.67680697e-02f, -1.45592034e-01f, -6.47557899e-02f,
  -9.88089144e-02f, -5.34328399e-04f, -1.00354478e-01f, -2.60787345e-02f, -8.29006662e-04f, 5.91783114e-02f, 4.40300368e-02f, 6.90283179e-02f, 1.25799313e-01f, -4.89633866e-02f,
  -3.54038738e-02f, -5.52879684e-02f, 1.36076704e-01f, -2.05518696e-02f, -2.55325176e-02f, 5.48767820e-02f, 6.00936003e-02f, -1.30600240e-02f, -3.38573679e-02f, -1.05784498e-01f,
  -6.24249503e-02f, 3.04450397e-03f, -3.05953696e-02f, -6.70403838e-02f, -2.34414823e-02f, 3.18461768e-02f, 1.54603645e-02f, -2.49990728e-02f, -4.04474558e-03f, -5.61022535e-02f,
  -1.21071182e-01f, 1.14488173e-02f, -1.90156177e-02f, 1.16982805e-02f, 3.82249542e-02f, -8.86403248e-02f, 6.22063130e-02f, 2.32855673e-03f, -4.36527692e-02f, -6.41879020e-03f,
  1.69832874e-02f, -1.50180329e-02f, -6.72374070e-02f, 8.26092586e-02f, 1.70303211e-02f, -3.48384306e-02f, 3.82945240e-02f, 3.99898849e-02f, -8.04350078e-02f, 1.57662798e-02f,
  7.89737608e-03f, -2.79557947e-02f, 7.14899376e-02f, 1.06089480e-01f, -4.17288095e-02f, 3.90323699e-02f, -4.18618508e-02f, -2.52706837e-02f, 5.19809313e-03f, 2.28674822e-02f,
  -5.15852608e-02f, 1.67935248e-02f, -1.77206770e-02f, 6.01047799e-02f, 2.30692383e-02f, -4.01809514e-02f, -7.92668983e-02f, -5.07532619e-02f, -3.07457428e-02f, 1.18480623e-02f,
  -1.16089471e-02f, 5.52794859e-02f, 8.79012197e-02f, 9.69379842e-02f, 7.06432834e-02f, -8.51388052e-02f, 4.69263606e-02f, -1.90626492e-03f, -4.99433987e-02f, -4.94845323e-02f,
  7.51586482e-02f, 6.42635301e-02f, 1.02900058e-01f, 7.32130334e-02f, -3.24138664e-02f, -6.21102490e-02f, 1.50850909e-02f, -4.20893691e-02f, -5.10591194e-02f, -1.26030331e-03f,
  -3.08399796e-02f, 6.41974760e-03f, -3.98456529e-02f, -2.21747793e-02f, 5.15829436e-02f, 7.82604441e-02f, -7.09182620e-02f, -3.73188592e-02f, 1.56574938e-02f, -3.70155908e-02f,
  -7.87442252e-02f, -3.74949276e-02f, 1.06270760e-02f, 1.97077803e-02f, -1.26503512e-01f, 2.79437029e-03f, -1.36123776e-01f, -6.71975017e-02f, -2.58510634e-02f, 1.17449507e-01f,
  -6.57639652e-02f, 6.48984034e-03f, -2.22211368e-02f, 5.49449809e-02f, -1.61820091e-02f, -5.91883510e-02f, -2.78663263e-02f, -9.82415900e-02f, 4.05605286e-02f, -1.56466961e-01f,
  -9.65673551e-02f, 1.04685284e-01f, 5.16360849e-02f, 4.87034395e-03f, -1.15262978e-02f, -5.49700297e-02f, 8.86256993e-02f, -2.11027917e-02f, -6.20095246e-03f, 4.37359698e-02f,
  -6.79534068e-03f, 2.05535833e-02f, 2.78599598e-02f, 6.19404428e-02f, 1.32928761e-02f, -6.91074952e-02f, -2.74920985e-02f, 9.30847879e-03f, -4.65694368e-02f, -3.92652936e-02f,
  -7.10784197e-02f, -7.75864720e-02f, -1.65456831e-02f, 4.71723042e-02f, -8.76605660e-02f, -2.12314911e-03f, -5.25997095e-02f, 2.17989199e-02f, -9.69591811e-02f, -3.10778935e-02f,
  -8.84279236e-02f, -5.79046607e-02f, 1.20175667e-02f, 7.27130324e-02f, -3.73076983e-02f, 8.68962612e-03f, -1.22043388e-02f, -7.04819150e-03f, -7.48168677e-02f, -7.47294053e-02f,
  -2.60002762e-02f, -8.52144510e-02f, -2.34337319e-02f, 7.74647370e-02f, 3.15962881e-02f, -4.77099642e-02f, -6.91654831e-02f, 4.48257141e-02f, 7.15377331e-02f, 1.44627364e-02f,
  2.58664768e-02f, 2.25268956e-02f, 8.25081319e-02f, -7.18630403e-02f, -4.31672968e-02f, -7.15978220e-02f, 6.30457997e-02f, 1.58449784e-02f, -6.38203248e-02f, -3.51381004e-02f,
  -6.00073263e-02f, -1.76764913e-02f, -5.01432717e-02f, -5.93491606e-02f, 1.10261105e-01f, 9.91030931e-02f, -2.76220925e-02f, -5.46853468e-02f, 1.12769708e-01f, 6.07030280e-02f,
  -1.23112733e-02f, -6.06896579e-02f, 4.06014770e-02f, 3.55576463e-02f, -3.45812812e-02f, 4.15613353e-02f, 5.45538552e-02f, -3.38505879e-02f, -4.04798286e-03f, 1.55760422e-02f,
  -3.92060075e-03f, 1.56181566e-02f, -7.75579885e-02f, -9.17772278e-02f, -2.70010978e-02f, -9.37061831e-02f, -3.19400728e-02f, -1.03388578e-01f, -9.70435441e-02f, -5.10261394e-02f,
  7.89213553e-02f, -1.17651656e-01f, -1.72790606e-02f, 3.13935578e-02f, 2.39001289e-02f, -4.81286682e-02f, -1.51290029e-01f, -2.12995373e-02f, -2.31380761e-02f, -7.63960704e-02f,
  5.81398513e-03f, 7.02700019e-02f, -7.21447468e-02f, -4.47852910e-02f, -1.09256610e-01f, -5.46879806e-02f, -5.03115095e-02f, -5.53290583e-02f, 5.55213131e-02f, -2.51279995e-02f,
  -5.13014384e-02f, 5.41801490e-02f, 4.93701398e-02f, -9.25854817e-02f, -4.73578833e-02f, -4.32289653e-02f, -8.86346996e-02f, 4.75512519e-02f, -5.73832318e-02f, -1.45207969e-02f,
  -1.49777070e-01f, -5.90382069e-02f, -6.65728450e-02f, -5.52685075e-02f, -1.00262478e-01f, -7.51351044e-02f, -1.61314309e-02f, 5.28665297e-02f, -4.32938449e-02f, -2.26505883e-02f,
  -7.08226413e-02f, 8.18520188e-02f, 9.10072681e-03f, -6.62848875e-02f, -5.91062987e-03f, -1.13224518e-03f, 1.28490692e-02f, -5.32211438e-02f, 1.77959260e-02f, 7.73933600e-04f,
  -1.58604141e-02f, -1.19338147e-02f, 7.01856837e-02f, -4.10482250e-02f, -8.18807334e-02f, -4.30813134e-02f, 1.10579012e-02f, -5.93300071e-03f, -7.80520961e-02f, 5.75051969e-03f,
  3.82965766e-02f, 4.56547812e-02f, 3.99453044e-02f, 1.38725601e-02f, 7.56767914e-02f, -2.65238490e-02f, 8.42588302e-03f, 2.26227590e-03f, 5.54338060e-02f, 9.14505944e-02f,
  3.74277160e-02f, 6.29166663e-02f, 5.10664247e-02f, 2.53280662e-02f, -6.55975640e-02f, 3.47493701e-02f, 9.73553807e-02f, -5.67652211e-02f, 6.33512735e-02f, 5.44675067e-02f,
  5.27998693e-02f, -3.32843363e-02f, 9.09553915e-02f, -6.37172833e-02f, 8.52874294e-02f, 1.39488317e-02f, 1.00692809e-02f, -4.12235521e-02f, 1.73764229e-02f, 8.37144405e-02f,
  -1.53883183e-02f, 6.12598956e-02f, -1.07539341e-01f, 4.94885854e-02f, 5.77393025e-02f, 4.87159379e-02f, -6.76990300e-02f, 1.03761762e-01f, 6.93667009e-02f, -3.90403867e-02f,
  1.75764188e-02f, 4.12126034e-02f, 7.87664652e-02f, -7.72940069e-02f, 4.77273054e-02f, -4.79320325e-02f, -2.69933225e-04f, -6.60216659e-02f, 4.76080738e-03f, 7.10121263e-03f,
  -9.91307497e-02f, 3.81757766e-02f, -7.30810761e-02f, -2.28240732e-02f, 6.65854290e-02f, -5.75908460e-02f, -9.62905064e-02f, -5.86612429e-03f, 1.50341336e-02f, -1.18895888e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  6.01360388e-02f, -1.16245458e-02f, 8.18530247e-02f, 2.19039753e-01f, 1.09485649e-01f, 1.20715044e-01f, 1.52952045e-01f, 2.16277495e-01f, 2.06108749e-01f, 2.77604591e-02f,
  -9.65549238e-03f, 1.05194665e-01f, 1.02211431e-01f, 7.69281760e-02f, 1.07902281e-01f, 1.69801250e-01f, 7.68550113e-02f, 5.52576454e-03f, 4.80296509e-03f, 5.11693768e-02f,
  4.64025475e-02f, 1.48666287e-02f, 5.32037169e-02f, 1.18165225e-01f, 1.51330099e-01f, 7.52576888e-02f, -1.55693274e-02f, 1.02814659e-02f, 9.15211141e-02f, 2.16099173e-01f,
  1.13382593e-01f, 1.82496578e-01f, -1.46293957e-02f, 1.70531347e-01f, 1.53514799e-02f, 5.85259870e-02f, 1.70703948e-01f, -7.27616400e-02f, 1.58057585e-01f, -3.03298030e-02f,
  1.44998789e-01f, 2.51762196e-02f, -2.87588835e-02f, -5.57587994e-03f, 9.08610970e-02f, -4.33868263e-03f, 9.93376076e-02f, -6.10348163e-03f, 7.58139789e-02f, 6.88484460e-02f,
  -5.82701415e-02f, 6.65162364e-03f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  7.66586214e-02f, -1.20272124e-02f, 1.25378678e-02f, 8.10645893e-02f, 6.41396940e-02f, -1.75907314e-01f, -2.33533442e-01f, 2.11750087e-03f, -2.78083365e-02f, 2.25090794e-02f,
  2.15867497e-02f, 1.40804738e-01f, 6.84727728e-02f, -3.99654433e-02f, 7.73989260e-02f, -1.49957640e-02f, -1.38400614e-01f, 4.48048338e-02f, -3.67472209e-02f, -2.06209973e-01f,
  -5.61555736e-02f, 4.28327918e-02f, -6.04254492e-02f, -3.91524378e-03f, -1.33476779e-01f, -2.43793800e-02f, 4.95013967e-02f, -1.74815461e-01f, -7.93508068e-02f, 9.70553532e-02f,
  1.02282055e-01f, 6.42371029e-02f, 1.75955426e-02f, 1.95799395e-02f, 2.87540369e-02f, -5.13356924e-02f, 4.65875603e-02f, 2.92365719e-02f, -9.17132273e-02f, -1.01607859e-01f,
  1.52291590e-02f, -3.28707956e-02f, -6.25445992e-02f, -1.16536900e-01f, -7.94930831e-02f, -1.60749450e-01f, 7.57733211e-02f, -1.05358928e-01f, 8.80888291e-03f, -6.94315955e-02f,
  -5.67009896e-02f, -2.57171169e-02f, -1.41921237e-01f, 4.19415534e-02f, 3.61342952e-02f, 2.94002164e-02f, -2.37317905e-02f, 3.01266722e-02f, 1.12511516e-01f, 1.15657121e-01f,
  -9.12743732e-02f, 1.52104452e-01f, -6.89286590e-02f, -6.79221675e-02f, 1.34423986e-01f, 6.18757643e-02f, 1.30977079e-01f, -2.04845667e-02f, -1.03238714e-03f, -9.86918062e-02f,
  -1.53485447e-01f, -1.22623295e-01f, -1.21268228e-01f, 1.27104729e-01f, -1.13766111e-01f, 1.14293853e-02f, -1.30498167e-02f, -8.52442458e-02f, -1.11827388e-01f, -2.06239726e-02f,
  -3.78675796e-02f, -6.06318004e-02f, 9.99623910e-02f, 7.07083270e-02f, 1.00141978e-02f, 2.46379226e-02f, 9.21781659e-02f, -1.30216196e-01f, 8.62722769e-02f, 8.24249163e-02f,
  6.20741472e-02f, 3.78134362e-02f, -1.55842677e-01f, 1.69737294e-01f, -6.21177405e-02f, 2.16864362e-01f, 2.80848164e-02f, 6.74448088e-02f, 8.72000977e-02f, 2.20051944e-01f,
  -2.95620020e-02f, 2.23828137e-01f, 7.62881525e-03f, 4.87738550e-02f, 1.90737739e-01f, 2.51567185e-01f, 1.31575763e-01f, 2.28093248e-02f, -1.09176049e-02f, -1.03029437e-01f,
  7.89482817e-02f, 1.75336346e-01f, -7.41258711e-02f, 1.07312910e-01f, 3.26245800e-02f, -1.08775988e-01f, 3.07010889e-01f, 8.75303522e-02f, -2.85910722e-02f, -1.08502634e-01f,
  1.38476908e-01f, 7.86362737e-02f, 7.37558976e-02f, -2.15282202e-01f, -1.39600202e-01f, -2.50754803e-02f, -1.81417800e-02f, -1.06195696e-02f, 4.71113287e-02f, 1.71407521e-01f,
  -9.55160558e-02f, -4.53474969e-02f, 1.43884063e-01f, -6.75269344e-04f, 1.06965199e-01f, -7.44928271e-02f, 7.37895444e-02f, -6.34756833e-02f, 1.42052561e-01f, 9.03745145e-02f,
  1.20854452e-02f, -2.64629740e-02f, 1.37575716e-01f, -1.06302053e-01f, -5.48834652e-02f, 1.07978135e-01f, 1.08711302e-01f, 2.55072620e-02f, 1.24157049e-01f, 5.70131466e-02f,
  2.58745104e-02f, -9.03478414e-02f, -1.39411837e-01f, 5.41886315e-02f, 3.27380784e-02f, -5.82372658e-02f, -1.42383743e-02f, 3.58843803e-02f, 3.53926560e-03f, 5.63960671e-02f,
  2.56411564e-02f, 6.30878806e-02f, 1.72396563e-02f, -4.29015085e-02f, -5.59676923e-02f, -2.49629584e-03f, -2.83440631e-02f, 8.48802626e-02f, 1.11247130e-01f, 7.11053982e-02f,
  -1.06020607e-01f, -1.57142114e-02f, -5.20972013e-02f, 5.26174828e-02f, 6.95774779e-02f, 1.02820851e-01f, 2.23308317e-02f, -1.08279265e-01f, 8.13431963e-02f, 7.17475042e-02f,
  -1.51006043e-01f, 5.71512692e-02f, 1.29359156e-01f, 3.30892042e-03f, -9.95578319e-02f, 6.64044917e-02f, 1.98882878e-01f, -1.13673732e-02f, 4.97184657e-02f, -1.05969593e-01f,
  -1.13371953e-01f, -3.70971188e-02f, -6.47383332e-02f, 9.64706838e-02f, 1.75700895e-02f, -5.11141792e-02f, -3.62629001e-03f, 8.41641147e-03f, -1.39779346e-02f, 1.94908917e-01f,
  -3.94612513e-02f, 1.00213818e-01f, -2.96698827e-02f, -9.60359070e-03f, -3.71876843e-02f, -3.39893252e-02f, 1.42082632e-01f, -3.12230811e-02f, -1.03321239e-01f, -5.35035767e-02f,
  2.77969055e-02f, -6.04715720e-02f, -1.17723659e-01f, 1.50793105e-01f, -9.32223275e-02f, -7.45208487e-02f, -3.12615968e-02f, -1.20550945e-01f, 9.80377644e-02f, -1.07916072e-01f,
  -4.18005772e-02f, -1.98287051e-02f, -8.75839815e-02f, -1.71663146e-02f, 1.40706599e-01f, -9.25125405e-02f, -3.82275619e-02f, -1.14676766e-01f, 3.67370360e-02f, 1.95003953e-02f,
  -2.22550482e-02f, -1.65581759e-02f, -1.68544427e-01f, -1.36260033e-01f, 3.55039351e-02f, 3.48248482e-02f, -1.09600291e-01f, -1.82399638e-02f, -9.28231776e-02f, -9.27309245e-02f,
  9.75724310e-02f, 4.17987787e-04f, -1.11898623e-01f, 5.59544675e-02f, -2.07456559e-01f, -3.30786034e-02f, 8.63268524e-02f, 3.47013138e-02f, 6.75140917e-02f, 1.93108469e-02f,
  1.38616681e-01f, 2.25982338e-01f, 6.01787865e-02f, 1.15776308e-01f, -3.48656178e-02f, -4.20387089e-02f, 6.10524379e-02f, -1.44691309e-02f, -1.22617014e-01f, -1.22773312e-02f,
  -5.15039451e-02f, 7.84207210e-02f, 3.13131767e-03f, 1.29560068e-01f, -1.32077530e-01f, 4.55464795e-03f, 6.83224797e-02f, -1.93927810e-01f, 1.34670045e-02f, 1.43766746e-01f,
  1.96884181e-02f, -1.49222255e-01f, 4.42598797e-02f, -3.52950729e-02f, -6.96141273e-02f, 3.13835666e-02f, 7.49362111e-02f, -8.44758973e-02f, 2.29789782e-02f, -9.05781537e-02f,
  3.28315794e-02f, 1.69664044e-02f, 8.55302513e-02f, -1.47605628e-01f, -2.69503072e-02f, 8.37162808e-02f, -7.99382105e-02f, 6.30303994e-02f, 6.16773553e-02f, -8.32752064e-02f,
  5.12577482e-02f, 8.36214572e-02f, 1.18169956e-01f, 8.41187313e-02f, -3.09670754e-02f, -2.11845338e-02f, 1.18217714e-01f, -1.14538349e-01f, 5.97686693e-02f, -1.75897237e-02f,
  -2.02426091e-02f, 8.66088867e-02f, -4.87098023e-02f, -5.40083870e-02f, -1.53527055e-02f, 6.88524544e-02f, -4.30254004e-04f, -1.13449404e-02f, 1.64755046e-01f, 8.35598931e-02f,
  -7.06186369e-02f, -1.00895256e-01f, -4.15913351e-02f, 1.76470987e-02f, -5.27981110e-02f, 3.10793240e-02f, -1.39091566e-01f, 6.67698085e-02f, 1.77251119e-02f, -9.11899954e-02f,
  -7.33810589e-02f, -7.84297511e-02f, 1.06456958e-01f, 1.07647806e-01f, -1.08291686e-01f, 6.51114881e-02f, -7.94847384e-02f, 7.07470477e-02f, -3.06221936e-02f, 2.13659033e-02f,
  2.11778227e-02f, 1.86575755e-01f, -6.78009912e-02f, -1.55205786e-01f, 3.06516849e-02f, 1.49868369e-01f, -7.72440359e-02f, -8.68639536e-03f, 3.32058705e-02f, -1.25808835e-01f,
  1.75241884e-02f, 1.24610588e-01f, -1.50574982e-01f, -1.40793741e-01f, 7.17297022e-04f, -6.55666590e-02f, -1.20127819e-01f, -1.04286082e-01f, -1.05359010e-01f, 5.97141460e-02f,
  -5.17256036e-02f, 1.40546365e-02f, 5.65069355e-02f, 4.93533090e-02f, -1.38352280e-02f, -1.26418248e-01f, -7.92301819e-03f, 9.40092504e-02f, -1.04017384e-01f, -4.75202873e-02f,
  8.16837326e-02f, 7.27380663e-02f, -1.55052871e-01f, -3.94699089e-02f, 8.01601857e-02f, 4.26566601e-02f, 1.41235873e-01f, -6.18353952e-03f, -1.26957342e-01f, 1.64324909e-01f,
  -1.61955252e-01f, -1.37429098e-02f, 2.55735335e-03f, -1.21385202e-01f, 2.74762828e-02f, -7.87909180e-02f, 1.29100485e-02f, -8.96968246e-02f, 1.41287103e-01f, -3.99220772e-02f,
  -7.14527816e-02f, 1.23694651e-01f, 1.43417388e-01f, 4.26631421e-03f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.09967835e-01f, 1.37954624e-03f, -3.83467115e-02f, -1.13497496e-01f, 9.09720734e-02f, -8.69991109e-02f, 9.43820998e-02f, 1.15129843e-01f, 2.15035006e-02f, 6.77714795e-02f,
  6.18307851e-02f, -1.46244492e-04f, 1.68885477e-02f, -1.13795936e-01f, -1.18058696e-01f, -5.46217933e-02f, 5.22724390e-02f, -1.58960279e-02f, -5.47177829e-02f, 8.69200826e-02f,
  4.45306627e-03f, 1.73063185e-02f, -9.90058631e-02f, -2.26257462e-02f, 4.59867790e-02f, -2.53484454e-02f, -1.18612915e-01f, -3.73035073e-02f, -3.81899849e-02f, -1.36917178e-02f,
  -9.98680145e-02f, -6.83204755e-02f, -1.14579098e-02f, 4.26678620e-02f, 1.11124121e-01f, -1.23853937e-01f, -1.55328703e-03f, -1.25928208e-01f, -8.89033452e-02f, 1.27579197e-01f,
  -1.73363015e-02f, 2.78203171e-02f, 2.59194728e-02f, -8.75355452e-02f, 1.49652818e-02f, 1.05117984e-01f, 9.41682160e-02f, -8.64246413e-02f, 7.85901323e-02f, 2.61583980e-02f,
  -5.34671694e-02f, 1.27657518e-01f, -1.49689922e-02f, -8.57797191e-02f, -2.29814369e-02f, -6.24227151e-02f, -7.19520524e-02f, 7.47670904e-02f, 1.00712314e-01f, 1.16551779e-01f,
  -1.32376188e-02f, -1.01127028e-01f, 4.28747870e-02f, 1.85747072e-02f, 3.64290550e-02f, 1.16263129e-01f, -1.25763044e-02f, -6.34414554e-02f, -4.34870869e-02f, -8.10019150e-02f,
  -6.49370998e-02f, 4.16503437e-02f, 6.87891021e-02f, 3.22039463e-02f, -1.24427572e-01f, -3.12930197e-02f, 2.54065040e-02f, -1.06898502e-01f, -2.72449702e-02f, -7.58630782e-03f,
  2.26761941e-02f, 1.12996362e-01f, 3.51726487e-02f, -9.24691260e-02f, -5.86964972e-02f, -6.02013757e-03f, -8.69342536e-02f, 2.58871447e-02f, 2.15746127e-02f, -9.93122011e-02f,
  -6.43050671e-02f, -6.68878108e-02f, 9.19626877e-02f, -3.83704267e-02f, -5.84976450e-02f, 9.63126719e-02f, 7.11054578e-02f, -8.46109912e-02f, -6.11926764e-02f, 5.21412864e-02f,
  4.37570587e-02f, 1.06631052e-02f, 7.51947686e-02f, 3.75999399e-02f, 9.33229551e-02f, -1.12669460e-01f, -9.73042175e-02f, 5.53823672e-02f, -6.47348613e-02f, -1.13012694e-01f,
  -3.67638618e-02f, -1.06336698e-01f, 7.72370631e-03f, -9.85085070e-02f, 1.18032821e-01f, 1.97596150e-03f, 4.14565718e-03f, 6.68449774e-02f, 7.79846832e-02f, -8.91459212e-02f,
  -3.96500416e-02f, 3.71935708e-03f, -7.12163225e-02f, 1.84907466e-02f, -4.91477251e-02f, -1.06968684e-02f, -9.05026123e-02f, -9.59876850e-02f, 2.40665041e-02f, -3.99327055e-02f,
  9.72795933e-02f, 8.08398202e-02f, 5.64098842e-02f, -1.10241830e-01f, 7.73721337e-02f, 4.04804498e-02f, -9.24146324e-02f, -1.35627866e-01f, 8.00643191e-02f, -1.59672368e-02f,
  -1.37298345e-03f, -9.18655619e-02f, -5.73583581e-02f, -1.67110525e-02f, 2.50395816e-02f, -9.05868113e-02f, 4.93917689e-02f, 1.08786598e-01f, -1.36590088e-02f, -9.43870936e-03f,
  -1.22354418e-01f, -3.53591540e-03f, -4.78766263e-02f, 1.33678406e-01f, 1.59082562e-02f, 9.39782187e-02f, 4.17185873e-02f, 4.63711955e-02f, -3.58454622e-02f, -6.85045198e-02f,
  -1.17695168e-01f, 1.17449954e-01f, 1.22942030e-01f, 2.73684487e-02f, 5.13819559e-03f, 7.80363604e-02f, 4.83537093e-02f, 7.85114169e-02f, -2.34802323e-03f, 3.81793454e-02f,
  4.67331409e-02f, -2.44542398e-02f, 6.90478310e-02f, 1.50539845e-01f, -7.96338841e-02f, 9.97144207e-02f, 7.92768449e-02f, -9.32897329e-02f, -8.17266926e-02f, -1.04202116e-02f,
  5.60072111e-03f, 7.41861314e-02f, 2.68157627e-02f, 2.02353168e-02f, -2.97132432e-02f, -1.21207304e-01f, -5.08569777e-02f, 1.22490868e-01f, -1.68355983e-02f, 3.02015319e-02f,
  -4.25108336e-02f, 7.50540122e-02f, -7.10549057e-02f, -5.62412329e-02f, -1.67594433e-01f, 1.66074634e-01f, -6.84378892e-02f, 1.43045276e-01f, -1.50097877e-01f, -4.49392237e-02f,
  5.38877361e-02f, -7.31723607e-02f, -6.05077073e-02f, -5.13975974e-03f, 1.13233931e-01f, 1.19002707e-01f, 3.63339297e-02f, -9.92254838e-02f, 1.79439098e-01f, 4.18978482e-02f,
  6.59077987e-02f, -8.68301764e-02f, 1.58392027e-01f, 4.92292531e-02f, -1.01544179e-01f, -1.62545398e-01f, 4.86720912e-02f, 1.54837042e-01f, -4.39672060e-02f, 1.01933461e-02f,
  1.28380910e-01f, 9.61273387e-02f, -1.17691264e-01f, -9.38123837e-02f, 1.76329449e-01f, -3.10228541e-02f, -5.69241047e-02f, 1.18226081e-01f, 1.26852006e-01f, 1.12063363e-01f,
  -7.98426941e-02f, -5.24730422e-02f, 1.74442038e-01f, -1.22250453e-01f, 1.86197683e-01f, -3.89319248e-02f, 7.63025433e-02f, 3.76590453e-02f, 5.84805086e-02f, 1.76090479e-01f,
  1.41425103e-01f, -3.39723267e-02f, 1.92111824e-02f, -1.69996098e-02f, -1.89382546e-02f, -5.47394902e-02f, 8.86858348e-03f, -1.14198532e-02f, 6.80313781e-02f, 9.80661344e-03f,
  9.62880403e-02f, 1.52129889e-01f, 7.10056946e-02f, 1.26610205e-01f, 9.11966935e-02f, 1.40987754e-01f, 7.65012950e-02f, 2.08563060e-01f, 1.91014484e-01f, 1.66192874e-01f,
  2.05890790e-01f, -7.53390491e-02f, -2.60583878e-01f, -1.28144339e-01f, 6.00220524e-02f, 1.04029328e-01f, -2.92502921e-02f, 2.93039382e-01f, -1.23025719e-02f, -4.03965190e-02f,
  1.38394712e-02f, 5.88141121e-02f, -1.83148663e-02f, -3.78920510e-02f, 2.68961370e-01f, -1.19731605e-01f, -1.59278944e-01f, 3.45625848e-01f, 1.91514660e-02f, 1.12565756e-01f,
  -1.16075262e-01f, -8.58634934e-02f, -1.39473841e-01f, 5.97378872e-02f, -1.60783082e-01f, 8.67288485e-02f, 1.26932189e-01f, 9.13459957e-02f, 5.06677479e-02f, 7.20482767e-02f,
  -1.28305852e-01f, -2.00033635e-01f, 4.30417135e-02f, -1.37628868e-01f, -1.20344400e-01f, 1.19471058e-01f, 1.28075927e-01f, 1.20138742e-01f, 6.02513589e-02f, -5.88338599e-02f,
  1.18382256e-02f, -1.88460439e-01f, 1.17868446e-01f, -1.41059309e-01f, -2.30329096e-01f, -1.88327711e-02f, -7.16243535e-02f, 2.41574436e-01f, 1.71185192e-02f, -1.27862722e-01f,
  8.15341547e-02f, -8.61249417e-02f, 8.14213008e-02f, 1.08292416e-01f, 1.01179048e-01f, 7.03612864e-02f, 1.07084081e-01f, 1.02479130e-01f, -3.73884700e-02f, -5.26529104e-02f,
  -1.30069882e-01f, -1.19868889e-01f, -8.43766890e-03f, 6.97741732e-02f, -3.11580393e-02f, -3.05183157e-02f, -5.28244637e-02f, 1.15593903e-01f, 1.20167889e-01f, -2.45971121e-02f,
  -1.70421898e-02f, 1.84548441e-02f, 5.14388233e-02f, -6.85423985e-02f, -1.72202848e-02f, -3.43907392e-03f, 7.23282546e-02f, 2.96223210e-03f, 2.10491177e-02f, 5.08826077e-02f,
  -8.54507312e-02f, -1.06686875e-01f, 3.44209857e-02f, -1.00372538e-01f, -2.98248027e-02f, -4.71368656e-02f, 9.65845212e-02f, -1.19064804e-02f, 1.54409245e-01f, 2.98075471e-02f,
  1.42307490e-01f, 1.03223999e-03f, 1.62690063e-03f, 1.24005608e-01f, -1.11020945e-01f, -8.38502198e-02f, -3.25816460e-02f, -7.25555420e-03f, -6.06186502e-02f, 8.55452791e-02f,
  -1.74941942e-02f, -9.13436189e-02f, 1.27604261e-01f, -6.01976849e-02f, -5.25313579e-02f, 9.30900946e-02f, 4.54823747e-02f, -5.97456023e-02f, -1.07738674e-01f, 1.16361298e-01f,
  -2.30916515e-02f, 2.21157018e-02f, 4.74315211e-02f, -2.32208520e-02f, -7.77170360e-02f, 2.27107313e-02f, 2.37613600e-02f, -4.57166247e-02f, 8.77480507e-02f, 8.21177140e-02f,
  -3.51464981e-03f, -1.40675111e-03f, -1.21832639e-01f, 8.61044005e-02f, 6.06091581e-02f, -2.67521869e-02f, -1.01127643e-02f, -1.13947600e-01f, -3.82806621e-02f, 5.05023524e-02f,
  -5.88273481e-02f, 9.95110944e-02f, 1.07527569e-01f, -5.45916371e-02f, 1.80812087e-02f, 3.30918804e-02f, -9.25152376e-03f, 1.06872469e-01f, 9.43586156e-02f, -2.76135672e-02f,
  -8.74765664e-02f, 2.90006585e-02f, -1.05320252e-01f, -7.52586126e-03f, -2.11695321e-02f, 8.18441957e-02f, -9.53197777e-02f, -6.93944469e-02f, 1.13041230e-01f, -8.84934440e-02f,
  -3.32129672e-02f, 1.00720031e-02f, -1.58661641e-02f, -9.09954589e-03f, -9.56008211e-02f, -7.65765980e-02f, 1.14310399e-01f, 1.08453013e-01f, -5.98898456e-02f, -1.07549392e-01f,
  -1.70239285e-02f, -2.31197067e-02f, -4.63297144e-02f, -2.91036200e-02f, 1.03239335e-01f, -5.17102852e-02f, -4.25101109e-02f, 1.03484981e-01f, -8.51285681e-02f, -1.12455934e-01f,
  -1.06828377e-01f, -4.45834957e-02f, 8.79497454e-02f, 6.54053036e-03f, -8.45096819e-03f, 3.19618471e-02f, 2.36390997e-02f, -4.45050411e-02f, -7.70589486e-02f, 6.16308749e-02f,
  -1.09386168e-01f, -4.39449698e-02f, -4.07396350e-03f, -1.16383329e-01f, 2.42522433e-02f, -9.99188349e-02f, -7.56654441e-02f, 6.79848194e-02f, -1.29501984e-01f, -6.57435274e-03f,
  -5.28394654e-02f, -4.09910977e-02f, -2.77729053e-02f, -5.93701340e-02f, 9.57837626e-02f, 7.88816884e-02f, 4.30863909e-02f, 5.89611977e-02f, -2.87424382e-02f, -6.83951899e-02f,
  -3.21845226e-02f, 9.49545130e-02f, -5.80425337e-02f, 3.92157584e-02f, -2.81431247e-02f, -1.30710140e-01f, 5.63168153e-02f, -4.10615206e-02f, -6.53376803e-02f, 2.00393200e-02f,
  1.03382997e-01f, 3.17840651e-02f, 1.09480150e-01f, 4.79195639e-02f, 9.13145095e-02f, 1.27772808e-01f, -4.43699323e-02f, 9.80055630e-02f, -5.82874455e-02f, 1.13888204e-01f,
  3.40435617e-02f, -4.50968593e-02f, -1.28512373e-02f, -3.36233005e-02f, -7.00429231e-02f, -2.84934472e-02f, 6.79110363e-02f, -1.13127925e-01f, 7.81607479e-02f, -3.13705914e-02f,
  -2.38374015e-03f, -5.92410639e-02f, -8.71284679e-02f, -9.92322527e-03f, -1.71248745e-02f, 8.80248845e-02f, -7.04682171e-02f, 2.96319053e-02f, 9.68337283e-02f, -2.32488592e-03f,
  1.19571291e-01f, 7.89282620e-02f, -3.14031728e-02f, -5.60400486e-02f, 6.66213185e-02f, -3.62310708e-02f, 5.41478172e-02f, 4.84797396e-02f, 3.22182575e-04f, 6.57009184e-02f,
  -9.76378024e-02f, -1.17785335e-01f, -5.13264202e-02f, 1.45264342e-01f, 1.50150731e-01f, -6.44823313e-02f, 8.65290612e-02f, 1.59028038e-01f, 1.94155157e-01f, -9.27575976e-02f,
  -5.81536116e-03f, 6.06338270e-02f, 2.19145998e-01f, 1.54422875e-02f, 6.42226562e-02f, 3.50826532e-02f, -1.01773940e-01f, 3.34027931e-02f, -3.41721736e-02f, -2.26430055e-02f,
  1.44660566e-02f, 7.83651471e-02f, 1.50306478e-01f, -1.61600620e-01f, 7.95711800e-02f, -6.49803057e-02f, -1.15899332e-02f, 1.14541280e-03f, 1.29784539e-01f, -1.25139281e-01f,
  3.16315243e-04f, -5.45903854e-02f, 2.40561254e-02f, 7.31263906e-02f, 1.77605301e-01f, -9.51790959e-02f, 1.94828119e-02f, 1.38544098e-01f, 1.32836759e-01f, 2.35248618e-02f,
  -4.58234213e-02f, 5.66613264e-02f, -8.12780112e-02f, -2.22613830e-02f, 8.43995512e-02f, 1.42644390e-01f, 9.85758603e-02f, -2.23591402e-02f, 4.91380654e-02f, 3.76343355e-02f,
  6.36472777e-02f, -1.45853266e-01f, 1.80095658e-01f, 5.05846776e-02f, 5.53694367e-02f, 3.71785350e-02f, 3.24293338e-02f, 1.74118191e-01f, -1.35391206e-01f, -3.45431678e-02f,
  -9.91466194e-02f, 1.42616123e-01f, 1.81582496e-02f, 9.31396673e-04f, -4.25278731e-02f, 9.79439616e-02f, 3.81171517e-02f, 5.64476810e-02f, 1.30392283e-01f, -3.69606167e-02f,
  2.80653000e-01f, 1.92303821e-01f, 1.66550130e-01f, -7.27716833e-02f, 8.22497755e-02f, -1.77972659e-01f, 2.05105886e-01f, -2.31106896e-02f, -5.80459014e-02f, 3.75664122e-02f,
  2.25634500e-02f, 1.97839543e-01f, -8.04895610e-02f, -1.22479081e-01f, -6.01218268e-03f, 1.76772192e-01f, -1.51021183e-01f, -1.60228953e-01f, 1.70532107e-01f, 1.25713535e-02f,
  1.07905529e-01f, 1.14073969e-01f, 3.03499758e-01f, 1.87423676e-01f, 5.80007508e-02f, -7.61904269e-02f, -4.15964052e-02f, 5.14328033e-02f, 5.53396158e-02f, -3.65958139e-02f,
  1.40693590e-01f, 2.16072932e-01f, 2.40650132e-01f, 2.08393604e-01f, 1.11059390e-01f, -6.78277984e-02f, 4.96572554e-02f, 5.04641011e-02f, 8.88264328e-02f, 2.81594008e-01f,
  1.99296519e-01f, -1.21729709e-01f, -1.11857690e-01f, 7.77857052e-03f, -2.22274773e-02f, -1.07860016e-02f, 2.97985286e-01f, -1.31659806e-01f, 1.69633090e-01f, 1.68140307e-01f,
  -1.18121706e-01f, 2.34774068e-01f, -1.58794597e-01f, 1.05335809e-01f, -4.96452441e-03f, -1.49150610e-01f, -6.96148872e-02f, -1.15281180e-01f, 8.11109915e-02f, -2.18693670e-02f,
  -1.54090030e-02f, -4.52843234e-02f, -3.05232704e-02f, -1.15953073e-01f, -1.03668042e-01f, 3.62906717e-02f, -1.12106606e-01f, 7.44213685e-02f, -1.73111651e-02f, 4.34377603e-02f,
  -3.55657078e-02f, -3.55258510e-02f, 2.95266751e-02f, -9.43234861e-02f, 5.70374206e-02f, -1.05493151e-01f, 6.45548180e-02f, -5.60865328e-02f, 1.33626377e-02f, -1.64704081e-02f,
  -1.01852581e-01f, 6.94791228e-02f, -3.56496796e-02f, 5.96805066e-02f, 6.50842041e-02f, 4.64832522e-02f, 8.24957862e-02f, 6.31778091e-02f, 5.44372201e-02f, -3.38448137e-02f,
  3.13093700e-02f, 4.90157828e-02f, -1.08728513e-01f, -3.43597941e-02f, -1.13086104e-01f, 6.39608223e-03f, -9.35183023e-04f, 6.25004098e-02f, -1.43347019e-02f, -8.95554572e-02f,
  1.06935777e-01f, -1.22557618e-01f, -7.86582530e-02f, -3.75761241e-02f, -5.25916070e-02f, 4.72365618e-02f, -1.10333167e-01f, -7.03874156e-02f, -5.75733371e-02f, 5.80324866e-02f,
  -8.14739093e-02f, -9.58549902e-02f, -1.02263913e-01f, -9.97069106e-02f, -1.03498533e-01f, 7.84427449e-02f, 3.69744711e-02f, 3.77993993e-02f, 2.14405358e-02f, 5.75988665e-02f,
  -3.82012539e-02f, 9.37057212e-02f, -3.31919156e-02f, -1.18056364e-01f, -2.89354734e-02f, 1.55154526e-01f, 8.76802206e-02f, 3.16387117e-02f, 1.06278822e-01f, -3.29915918e-02f,
  9.76068377e-02f, -8.24822932e-02f, 1.31164670e-01f, 5.51144034e-02f, -2.46074749e-03f, -8.81106853e-02f, 7.79677927e-02f, 1.14492394e-01f, 1.37229368e-01f, -4.45493646e-02f,
  5.26758432e-02f, 1.05943024e-01f, -6.67855367e-02f, 1.35863885e-01f, 8.80972520e-02f, -1.03177801e-02f, -2.54489165e-02f, 6.68061012e-03f, -8.52163061e-02f, -1.49113968e-01f,
  5.70231453e-02f, 1.82742253e-02f, -1.23369649e-01f, 7.43777752e-02f, -5.22541068e-02f, 5.37264384e-02f, -9.35436934e-02f, -1.07851446e-01f, 1.07737854e-01f, -5.21018505e-02f,
  -1.08650200e-01f, -9.45049301e-02f, -1.14110775e-01f, 1.85996909e-02f, -1.38585255e-01f, -9.29862037e-02f, 3.19743007e-02f, -9.54062566e-02f, -1.98708884e-02f, 5.21179140e-02f,
  4.42700870e-02f, 5.98500408e-02f, -4.09494676e-02f, -6.98795021e-02f, 1.93132050e-02f, -1.22317888e-01f, 1.04205675e-01f, -4.79871184e-02f, 3.83290020e-03f, 5.59708178e-02f,
  -2.30779052e-02f, -7.10641667e-02f, 3.50533389e-02f, 1.47178829e-01f, 1.05314448e-01f, 8.62951949e-02f, -9.69413370e-02f, 1.39174983e-01f, 4.20191474e-02f, -8.05356577e-02f,
  9.73829329e-02f, 1.29122466e-01f, 1.09094262e-01f, 9.74136889e-02f, -1.88293103e-02f, 1.31820804e-02f, 1.33095175e-01f, -1.04876235e-01f, 7.92712613e-04f, 1.05770662e-01f,
  -1.00809053e-01f, 9.11487043e-02f, 1.45959243e-01f, 3.03149112e-02f, 1.18746132e-01f, 4.09008786e-02f, -8.91960487e-02f, 1.94429734e-03f, 2.00358648e-02f, 1.19691119e-01f,
  -8.02144408e-02f, -1.49984658e-01f, 4.12423238e-02f, -4.15517315e-02f, 1.81266710e-01f, 7.56969228e-02f, 1.85319334e-01f, -1.05449252e-01f, -6.12697890e-03f, -4.05447185e-03f,
  -7.76513740e-02f, 1.48898497e-01f, -3.00825550e-03f, 7.94713274e-02f, 7.42734745e-02f, -3.15554230e-03f, -5.01857810e-02f, -1.31230041e-01f, -9.54835340e-02f, 1.36779010e-01f,
  -5.29827289e-02f, 4.53391485e-02f, -5.70063014e-03f, 2.69316100e-02f, 1.04775488e-01f, -3.25064547e-02f, -1.27546564e-01f, -7.91696906e-02f, 1.07922323e-01f, -4.49414141e-02f,
  8.65903497e-02f, -7.43202046e-02f, 1.00783050e-01f, 7.83553421e-02f, -9.80686098e-02f, -1.14864901e-01f, 7.38493204e-02f, 1.20867036e-01f, 1.67052478e-01f, -1.17347218e-01f,
  1.47267841e-02f, -5.27303386e-03f, -8.10406730e-02f, -4.39878777e-02f, -3.56155001e-02f, -1.21952608e-01f, 5.05308732e-02f, 6.17383085e-02f, 7.27193132e-02f, 7.51019418e-02f,
  1.41800893e-03f, 7.37681538e-02f, -3.30578499e-02f, -3.05714700e-02f, -6.99168518e-02f, -9.72711816e-02f, -6.58740699e-02f, -7.33685344e-02f, -3.82396914e-02f, 5.70800453e-02f,
  -8.76308531e-02f, 7.69446269e-02f, -3.39788082e-03f, -7.83088952e-02f, -1.20985419e-01f, 6.63868487e-02f, -9.91942212e-02f, -1.13424517e-01f, -3.29595506e-02f, 4.10135975e-03f,
  -9.16641653e-02f, 1.25221899e-02f, -1.93233117e-02f, -2.16878839e-02f, 2.78817303e-02f, 7.54361898e-02f, -1.16129547e-01f, 2.17822492e-02f, 4.46172245e-02f, -6.72622025e-02f,
  -9.32804123e-02f, 9.46396813e-02f, -5.14786057e-02f, -3.02827135e-02f, -1.03402361e-01f, 1.02760598e-01f, -9.36207026e-02f, 1.33035323e-02f, -6.24201186e-02f, 8.79510939e-02f,
  6.23275861e-02f, 6.86160475e-02f, 5.91216460e-02f, -4.32177074e-02f, 8.72345641e-02f, -1.07507728e-01f, 6.76147640e-02f, 9.68389586e-02f, 3.66772264e-02f, -3.32168341e-02f,
  -8.82671028e-03f, -2.68371310e-03f, 7.32442504e-03f, -8.95393714e-02f, 5.88470288e-02f, 8.62685144e-02f, 7.99069628e-02f, 1.06628902e-01f, 2.28472631e-02f, 1.50549307e-01f,
  1.91743344e-01f, 2.55485196e-02f, 2.54770547e-01f, -1.99649930e-01f, 1.81169942e-01f, 8.69946107e-02f, 1.72787473e-01f, -1.73508450e-01f, 5.01767658e-02f, 9.97440051e-03f,
  -4.57443893e-02f, -7.66672492e-02f, 1.93407476e-01f, 1.17685236e-01f, -4.20702398e-02f, 2.97474414e-01f, -1.32585154e-03f, -1.11714520e-01f, 1.42355591e-01f, 2.06177250e-01f,
  1.05224445e-01f, 1.23702236e-01f, 2.37963662e-01f, 3.20706107e-02f, 5.94503209e-02f, 1.01788394e-01f, 4.15642299e-02f, 1.35541424e-01f, 6.29058629e-02f, 1.04173020e-01f,
  1.14424735e-01f, -8.18670727e-03f, -5.86844794e-02f, -3.29232588e-02f, 7.05211237e-02f, 5.06646335e-02f, 1.08889744e-01f, 8.15621689e-02f, -7.72155961e-03f, 1.60459697e-01f,
  -4.01716642e-02f, -1.49726158e-03f, -1.28369451e-01f, 1.79905310e-01f, 2.10228860e-01f, 5.46334200e-02f, 1.44263789e-01f, -8.46437216e-02f, 2.40753159e-01f, 1.79114729e-01f,
  2.67809611e-02f, 2.01080181e-02f, -1.53753772e-01f, 1.37987942e-01f, -2.06982177e-02f, 5.61222294e-03f, 8.33165087e-03f, -1.06396049e-01f, 4.90593351e-02f, -3.01225837e-02f,
  1.44794092e-01f, 8.68149251e-02f, 8.60540494e-02f, 3.11108511e-02f, 4.49278802e-02f, 2.38584191e-01f, 1.79730013e-01f, -1.39215544e-01f, 1.97520591e-02f, -1.24478541e-01f,
  1.01104021e-01f, 2.79317088e-02f, 1.20504059e-01f, 2.71915197e-02f, 1.63519699e-02f, -1.18503263e-02f, -8.80826712e-02f, 7.77906105e-02f, -8.21026936e-02f, 5.71186878e-02f,
  5.76363765e-02f, -1.18331529e-01f, 1.61745712e-01f, -4.52926159e-02f, 1.43563598e-01f, -5.73360436e-02f, -9.18232463e-03f, -2.52284599e-03f, 1.11064240e-01f, 8.12947080e-02f,
  -1.26084954e-01f, -6.12397194e-02f, 1.47813648e-01f, -1.28637612e-01f, 1.51605681e-01f, -6.79325089e-02f, -2.31435839e-02f, -1.03952214e-02f, -7.05093816e-02f, 1.41619161e-01f,
  -6.48475885e-02f, -1.94885079e-02f, 1.53279360e-02f, 5.48927411e-02f, 1.46987498e-01f, -1.69281196e-02f, -6.91394275e-03f, -3.32685858e-02f, 1.78414419e-01f, -1.71953261e-01f,
  1.28619121e-02f, -1.09046921e-02f, 3.86784747e-02f, 3.75251807e-02f, -1.58542171e-02f, -4.82842438e-02f, 5.31131513e-02f, 5.95629029e-02f, 3.79412696e-02f, 1.68146402e-01f,
  -6.24400191e-03f, 5.36885820e-02f, -4.90104109e-02f, -4.94677871e-02f, 1.37335107e-01f, 1.57444611e-01f, 1.96903720e-01f, 1.16055891e-01f, 1.80550754e-01f, -4.11312766e-02f,
  1.41155943e-01f, 2.93485783e-02f, 9.68019515e-02f, 1.24844961e-01f, -8.15628469e-03f, 6.33308142e-02f, 8.75210837e-02f, 9.05643851e-02f, 1.19244538e-01f, 3.30485590e-02f,
  5.98955974e-02f, 1.88389108e-01f, 2.21909732e-01f, 1.77643239e-01f, -7.92718306e-02f, 1.32700533e-01f, 4.51031998e-02f, 1.66688696e-01f, 4.59364727e-02f, -1.49729788e-01f,
  3.88289243e-02f, 6.47991076e-02f, -5.55217452e-02f, -1.47701735e-02f, 1.63654350e-02f, -9.98986885e-02f, -6.84891343e-02f, -1.67027805e-02f, 1.58809915e-01f, -1.56859178e-02f,
  -1.82293188e-02f, -1.07896328e-01f, -9.49549526e-02f, 4.80407663e-02f, -1.97241381e-01f, 1.17417395e-01f, -1.12758659e-01f, 1.52114287e-01f, -4.71470319e-03f, 1.49437472e-01f,
  -8.14514309e-02f, -1.29789621e-01f, 1.43841296e-01f, -2.86122356e-02f, 9.32135507e-02f, -2.74071433e-02f, -1.01461045e-01f, 6.39114827e-02f, 3.78943831e-02f, 1.41577289e-01f,
  -1.57449186e-01f, 1.50246128e-01f, 1.13196753e-01f, 4.52469997e-02f, 1.22365162e-01f, 9.06761065e-02f, 4.20253761e-02f, -9.93361026e-02f, 1.02434702e-01f, 1.07987657e-01f,
  3.88152339e-02f, -2.41322499e-02f, 1.94441974e-02f, 8.30791518e-02f, -4.84054014e-02f, -9.03758109e-02f, 5.35681397e-02f, 1.12120077e-01f, -2.37421528e-03f, 1.29506528e-01f,
  -3.04585490e-02f, -3.97434346e-02f, -1.59998648e-02f, 9.46504474e-02f, 8.44120011e-02f, -8.85705799e-02f, 4.23868187e-02f, -5.52936308e-02f, 9.57068130e-02f, -6.11996092e-03f,
  -1.14864938e-01f, 8.95344689e-02f, -3.26302946e-02f, -1.19060554e-01f, 1.36914790e-01f, -1.46975461e-02f, 6.11824915e-02f, 8.82028565e-02f, -5.30143790e-02f, -5.34175262e-02f,
  -1.11879312e-01f, 1.44790456e-01f, 5.59091792e-02f, -7.85285160e-02f, -9.11337733e-02f, -1.02704562e-01f, 5.06217703e-02f, 5.36189154e-02f, 9.22911689e-02f, -6.56833351e-02f,
  -8.94621909e-02f, 8.85415524e-02f, -6.88637346e-02f, -4.19884436e-02f, 8.31634030e-02f, 1.15474667e-02f, -1.34471744e-01f, 1.05273232e-01f, -2.20926236e-02f, -9.99790207e-02f,
  6.43510222e-02f, -2.96098739e-02f, 6.76787347e-02f, -6.33316040e-02f, 3.57749797e-02f, 3.27779576e-02f, -1.75865125e-02f, 1.05823085e-01f, 6.52336180e-02f, 5.15110232e-02f,
  -1.18443549e-01f, -5.77797554e-02f, 7.68742189e-02f, 6.72038943e-02f, 5.83357923e-02f, 2.00485215e-02f, -3.90829481e-02f, 6.36964440e-02f, 5.55707142e-02f, -3.87830399e-02f,
  -1.21912055e-01f, -2.33008899e-02f, -8.88428465e-02f, 7.71925896e-02f, -6.76169768e-02f, 1.23360902e-01f, -3.89325917e-02f, -1.24561666e-02f, -9.59135443e-02f, 5.82718588e-02f,
  -6.39018044e-02f, 5.56916855e-02f, 1.89347789e-01f, 4.31081355e-02f, -1.07014976e-01f, -2.10006498e-02f, 1.19881533e-01f, 6.37677014e-02f, 7.26683438e-02f, 2.79414412e-02f,
  -1.04458071e-01f, 5.17879054e-02f, -9.22262222e-02f, 5.73828705e-02f, 3.70339267e-02f, 3.30504999e-02f, 1.07130788e-01f, 2.33384110e-02f, -2.56857835e-02f, -1.09728843e-01f,
  -3.55543830e-02f, -1.72875263e-02f, -4.53705341e-02f, -1.10044964e-01f, -1.57715362e-02f, 1.39643922e-02f, -2.90819779e-02f, 1.22887127e-01f, -9.19738505e-03f, -5.67299500e-02f,
  6.26883209e-02f, -7.44925365e-02f, -6.89629756e-04f, 8.72986838e-02f, -1.13043420e-01f, 2.07318645e-02f, 3.16488929e-02f, 2.05221809e-02f, 5.13514318e-02f, 7.56940339e-03f,
  1.29814938e-01f, 1.23471379e-01f, 2.16477867e-02f, 6.35471344e-02f, -9.36258212e-03f, 1.39789939e-01f, -1.00746512e-01f, -8.59687477e-02f, -9.76607725e-02f, 2.77881362e-02f,
  -1.17653422e-03f, -1.00894375e-02f, -1.07621424e-01f, -1.14658279e-02f, 4.21892442e-02f, 1.04735261e-02f, 6.18016236e-02f, 1.75430644e-02f, 4.22617942e-02f, 1.12449974e-02f,
  -9.79855005e-03f, 7.30379224e-02f, -2.92545576e-02f, 9.32921562e-03f, -2.93356366e-03f, -6.21407032e-02f, 1.81159265e-02f, -4.09396142e-02f, -1.04067959e-01f, -3.30847017e-02f,
  -9.18782502e-02f, -3.95361520e-02f, 3.76102538e-03f, 9.87461060e-02f, -1.67186465e-02f, 3.94753329e-02f, -2.02870183e-02f, 4.29696776e-02f, -5.70562072e-02f, -4.53642569e-02f,
  -6.51232898e-02f, -9.67023969e-02f, 1.21821307e-01f, -5.64193167e-02f, -2.79453788e-02f, 4.18495536e-02f, 2.70369388e-02f, -4.46278937e-02f, 1.19052410e-01f, -2.34966222e-02f,
  2.95470860e-02f, -1.06254786e-01f, 5.82645163e-02f, -1.06391951e-01f, -7.35653238e-03f, 4.21094224e-02f, -3.40759638e-04f, 5.95266409e-02f, -1.07483365e-01f, -7.44828209e-02f,
  -6.27013147e-02f, -3.41857411e-02f, -4.84083071e-02f, 7.00456202e-02f, 6.96002506e-03f, -7.18707070e-02f, 7.88330659e-02f, -2.89977416e-02f, 1.17159650e-01f, 5.63055873e-02f,
  9.47130173e-02f, 1.13567553e-01f, 4.91614789e-02f, 1.12655386e-01f, 2.03726470e-01f, 1.97958440e-01f, 4.07178812e-02f, -1.37614161e-01f, -4.65629213e-02f, -4.41097617e-02f,
  -5.93409352e-02f, -9.88097414e-02f, 4.08244953e-02f, -3.88813578e-02f, -9.37514901e-02f, 1.21180840e-01f, 1.29413530e-01f, -1.33860767e-01f, 9.93832201e-02f, 1.56225860e-01f,
  -4.01377454e-02f, -3.96114402e-02f, 1.88557640e-01f, 8.37129280e-02f, -5.26876263e-02f, 7.87623748e-02f, 8.48774165e-02f, -1.33997768e-01f, -5.29829226e-02f, 5.48139215e-03f,
  1.10955723e-01f, 5.76977879e-02f, 6.56666160e-02f, 3.72448787e-02f, 1.05498232e-01f, 1.44813567e-01f, -2.93457843e-02f, 7.09170327e-02f, -1.05672821e-01f, -8.63431301e-03f,
  -2.92957220e-02f, 6.26837537e-02f, 1.93925053e-01f, 4.30987217e-02f, 1.53206483e-01f, -7.64606055e-03f, 1.26606405e-01f, -9.45285335e-02f, 7.15403482e-02f, 8.68126675e-02f,
  1.19203612e-01f, 6.66019246e-02f, 8.51756856e-02f, -3.76573554e-03f, 1.15073875e-01f, -5.85852079e-02f, 7.16857091e-02f, 1.07343785e-01f, 1.30532593e-01f, -1.08126260e-01f,
  1.06352687e-01f, 1.38792366e-01f, 1.54252186e-01f, 2.13026125e-02f, 7.93350786e-02f, 1.77178815e-01f, 1.87845193e-02f, -2.15663780e-02f, -7.81337246e-02f, -6.09331764e-02f,
  -1.32464781e-01f, 7.77731538e-02f, 7.38458335e-02f, 3.05145066e-02f, -2.79672015e-02f, 1.35853663e-01f, -1.09053846e-03f, -8.57522190e-02f, 2.67442763e-02f, 1.35317922e-01f,
  -1.60379540e-02f, 1.40501205e-02f, -4.41984273e-02f, 1.16489053e-01f, 1.63338650e-02f, 1.09549575e-01f, -4.27609421e-02f, 6.26055747e-02f, -1.37322262e-01f, 1.19438894e-01f,
  -1.00757338e-01f, 2.94905202e-03f, 6.12520836e-02f, 7.48099536e-02f, 8.29136744e-02f, -2.40614712e-02f, 1.10348776e-01f, -1.04778863e-01f, -1.30857080e-01f, -1.36372939e-01f,
  1.05869677e-02f, -3.22533138e-02f, 1.87344779e-03f, 1.28763467e-01f, -3.95458043e-02f, 1.68926299e-01f, 7.83985630e-02f, 6.98198378e-02f, -1.11139163e-01f, 1.00351535e-01f,
  1.25094503e-01f, -5.43197580e-02f, -1.02203764e-01f, 6.34989366e-02f, 7.97755197e-02f, 1.59251407e-01f, 3.85743044e-02f, 1.21794352e-02f, -7.47829899e-02f, 6.58037588e-02f,
  4.69101742e-02f, -7.01279268e-02f, 1.36583187e-02f, -3.26141082e-02f, 3.85818421e-04f, 1.12228595e-01f, -2.21056212e-03f, 7.83400610e-03f, 8.18917081e-02f, 8.96533653e-02f,
  2.04174936e-01f, 1.68318018e-01f, -1.62278097e-02f, -1.81492302e-03f, 7.33203366e-02f, 2.29465449e-03f, -1.19891383e-01f, 2.94440500e-02f, 1.31925672e-01f, 1.21266529e-01f,
  -4.76894714e-02f, 6.56095967e-02f, -1.34229418e-02f, 8.45483989e-02f, -1.32093161e-01f, 1.81323931e-01f, 1.58048123e-01f, -5.15327463e-03f, -2.69276872e-02f, 2.36255564e-02f,
  -4.42607291e-02f, 3.15953866e-02f, 1.09946858e-02f, -8.56764093e-02f, 7.19547197e-02f, 1.60174221e-01f, 6.79634064e-02f, 6.08952418e-02f, 1.24590710e-01f, -1.16529509e-01f,
  -1.19280085e-01f, 1.17128663e-01f, 4.45245253e-03f, 2.35430095e-02f, 1.16920583e-01f, 1.31786624e-02f, -2.79961694e-02f, -7.70141333e-02f, -8.72866437e-02f, 1.50679201e-01f,
  -4.53979000e-02f, 4.60322276e-02f, -6.21423014e-02f, 8.11652392e-02f, -7.61445612e-02f, -1.98313631e-02f, 1.36715651e-01f, -2.83549447e-02f, 7.03755915e-02f, -4.96075712e-02f,
  -2.02314816e-02f, 1.06547847e-01f, -7.38112405e-02f, -1.52435582e-02f, 1.14451490e-01f, 1.38863653e-01f, -3.78018990e-02f, 4.87982035e-02f, -3.19947712e-02f, -8.65987912e-02f,
  5.10371774e-02f, 1.27001122e-01f, -1.38090854e-03f, -4.07550782e-02f, -2.18165517e-02f, -1.14191696e-02f, 1.24860331e-01f, 9.44790319e-02f, 4.71134782e-02f, -1.38939783e-01f,
  -1.07077911e-01f, -2.11728662e-02f, -1.00410953e-01f, -1.82602689e-01f, -5.27510270e-02f, -3.76225859e-02f, 7.07312375e-02f, 7.34025240e-02f, 5.40047996e-02f, -1.47428423e-01f,
  -1.58721909e-01f, 7.06086680e-02f, -2.34823823e-02f, -5.67240156e-02f, 1.09964609e-01f, -1.48959130e-01f, -1.17619246e-01f, 6.35861531e-02f, 5.76102473e-02f, 5.78852929e-02f,
  1.27804413e-01f, 5.49060665e-02f, -1.54982191e-02f, 1.91701502e-01f, -3.92385460e-02f, -1.81343453e-03f, 8.27715546e-02f, 2.07682148e-01f, -2.49726679e-02f, 4.63328846e-02f,
  8.50224718e-02f, -8.49524066e-02f, 1.33041292e-01f, 2.52971798e-01f, 1.30347714e-01f, -9.59077701e-02f, 1.63579106e-01f, -5.11490852e-02f, 1.11036599e-01f, 9.63971913e-02f,
  -1.07148848e-01f, 1.24928765e-01f, -6.34889025e-03f, -2.14811061e-02f, 8.91822055e-02f, 1.37912720e-01f, -8.67011175e-02f, -5.23633100e-02f, -4.67349254e-02f, -2.63156276e-02f,
  -1.22635141e-01f, -8.84757191e-02f, 1.11972652e-01f, -1.03082798e-01f, 9.46293250e-02f, 4.67274226e-02f, 9.27334726e-02f, 7.91579559e-02f, 1.45246368e-02f, 1.44312918e-01f,
  5.01607992e-02f, -3.25283371e-02f, 1.08304992e-02f, 1.82247296e-01f, -2.06849426e-01f, 1.71087846e-01f, -1.82457492e-01f, 6.93191662e-02f, -7.76560009e-02f, -8.99690762e-02f,
  3.63843851e-02f, -4.00713496e-02f, -4.93126661e-02f, -2.61549912e-02f, 2.45877206e-02f, 6.48508593e-02f, -7.72255287e-02f, -2.10837908e-02f, 2.91647669e-02f, 1.41039550e-01f,
  -1.60759389e-02f, 1.32877631e-02f, -9.50303152e-02f, 6.42733574e-02f, 6.17090873e-02f, -5.56394737e-03f, 9.16255489e-02f, 6.81318790e-02f, -1.15103044e-01f, 8.07418153e-02f,
  -1.69761553e-02f, 3.93957049e-02f, 4.44266908e-02f, 9.88675002e-03f, -5.09528145e-02f, -3.09281498e-02f, 2.00196549e-01f, 2.27173582e-01f, 1.52776971e-01f, -1.17653899e-01f,
  4.66562808e-02f, 9.50544029e-02f, 1.45239234e-02f, 1.43214568e-01f, 1.47984833e-01f, 1.97907731e-01f, -1.49637982e-01f, 1.50305167e-01f, 2.95639317e-02f, -1.03964610e-02f,
  -1.11574955e-01f, -2.54736245e-02f, 9.86935124e-02f, -1.34541793e-02f, -1.01148397e-01f, -1.49117038e-01f, 1.40710324e-01f, -1.75113883e-02f, 1.23073786e-01f, 8.93954933e-02f,
  1.23109236e-01f, 1.45855933e-01f, -1.18192196e-01f, -7.71915466e-02f, 1.02168396e-01f, -8.78510065e-04f, -8.14581290e-02f, 1.08731128e-02f, -3.98292728e-02f, -8.39895159e-02f,
  6.87546516e-03f, -1.32358551e-01f, 9.99125242e-02f, 1.03030831e-01f, -6.39709160e-02f, 1.18982762e-01f, -4.85186391e-02f, -5.48315048e-02f, 2.30257269e-02f, -8.45541358e-02f,
  -3.03800181e-02f, 5.42927906e-02f, 9.25591066e-02f, -1.09095015e-01f, -2.04533003e-02f, 7.61085078e-02f, -2.93252598e-02f, -5.85471243e-02f, 9.46396664e-02f, -6.65362179e-02f,
  -1.07418925e-01f, -2.49415394e-02f, 1.30739838e-01f, -6.18367344e-02f, -1.73893012e-02f, 8.70957077e-02f, 6.91875000e-04f, -1.38372919e-02f, 1.35230748e-02f, -6.36004051e-03f,
  9.36649181e-03f, -2.08028089e-02f, 6.84061423e-02f, 3.26364674e-02f, 1.73346996e-02f, -9.73127037e-02f, 7.44191632e-02f, -8.93918891e-03f, -9.92512330e-02f, 7.89282024e-02f,
  -8.41343850e-02f, 6.56911731e-02f, -3.31733935e-02f, 3.45110968e-02f, 6.97952732e-02f, 5.11724651e-02f, -8.26880336e-02f, 8.92161876e-02f, 1.09645627e-01f, 1.72059424e-02f,
  -1.31086567e-02f, -2.78945751e-02f, -3.71073969e-02f, 9.43266675e-02f, -4.10131970e-03f, 6.00506254e-02f, 1.13497473e-01f, 1.35095820e-01f, -3.92520800e-03f, 2.30881535e-02f,
  -6.48910105e-02f, -1.04859345e-01f, 1.80892095e-01f, 1.12132505e-01f, -3.87958437e-02f, 2.17199698e-02f, 7.81070665e-02f, -4.09277417e-02f, 4.31668870e-02f, -5.19297197e-02f,
  3.70649956e-02f, 8.00689235e-02f, -1.28299758e-01f, -1.22572623e-01f, 6.16466925e-02f, 7.98564628e-02f, 5.50771467e-02f, 4.59828712e-02f, 4.34231684e-02f, 1.12585157e-01f,
  8.96621421e-02f, -1.38871074e-01f, 7.35860318e-03f, -8.34258944e-02f, -1.09505452e-01f, -2.11496688e-02f, 7.54584675e-04f, 5.27961142e-02f, -9.40200388e-02f, 8.50816630e-03f,
  -2.66390927e-02f, -3.68752703e-02f, 4.74164076e-03f, -8.22104365e-02f, 1.02917805e-01f, -1.31211758e-01f, 3.96300741e-02f, 1.28292218e-01f, -3.14565077e-02f, 1.37804911e-01f,
  9.36483368e-02f, -3.07069048e-02f, -4.85651568e-02f, -1.10847041e-01f, -1.17112644e-01f, -6.81159124e-02f, -1.21053778e-01f, 1.30609080e-01f, 5.44176362e-02f, 4.59614657e-02f,
  1.25882193e-01f, -1.20594390e-01f, -6.89091384e-02f, 1.95345566e-01f, 9.33029875e-02f, -7.61861429e-02f, 8.43209401e-02f, -3.54663804e-02f, 8.55299458e-02f, -8.22968796e-05f,
  9.66203734e-02f, 6.80298284e-02f, -2.35101636e-02f, -4.56777960e-02f, 1.38256019e-02f, -2.49059368e-02f, -3.74625586e-02f, -4.07187901e-02f, 7.78137520e-02f, 1.60892934e-01f,
  5.74798137e-02f, 5.28220609e-02f, -2.59898975e-02f, 3.07954242e-03f, 9.91596207e-02f, 1.18968673e-01f, -6.91287667e-02f, 2.60934085e-01f, 8.11715871e-02f, -1.32606357e-01f,
  -3.33032422e-02f, 1.30929843e-01f, 2.24074945e-01f, -9.94481221e-02f, -3.94334756e-02f, 1.34276405e-01f, -5.49093559e-02f, 5.10257781e-02f, -1.30942792e-01f, 5.65687306e-02f,
  2.63410378e-02f, -3.84046994e-02f, 8.08870047e-02f, -9.25754011e-03f, 1.29307970e-01f, -7.13044107e-02f, 1.22894108e-01f, 1.38512984e-01f, -1.36644030e-02f, -1.28161997e-01f,
  -9.03092772e-02f, 6.45811036e-02f, -1.69700906e-02f, 1.23786204e-01f, 2.16509663e-02f, 1.50270723e-02f, 9.15816575e-02f, -8.88029858e-02f, -5.72318919e-02f, 9.06674117e-02f,
  -8.55978765e-03f, 9.19654220e-02f, -9.21972245e-02f, -1.74195290e-01f, 1.43660188e-01f, 1.13221250e-01f, -5.93760945e-02f, -1.85329802e-02f, -1.40984654e-02f, 1.86818056e-02f,
  1.05447039e-01f, -4.57923450e-02f, 1.91493988e-01f, -2.02176236e-02f, -2.07745507e-02f, 2.85470039e-01f, 7.02588260e-02f, 1.58666104e-01f, -2.30535254e-01f, 1.73714831e-01f,
  -2.45858029e-01f, 3.95461097e-02f, -2.49551117e-01f, 1.70543224e-01f, 1.14099987e-01f, 2.51638815e-02f, 4.61917594e-02f, 2.23448366e-01f, 4.39777635e-02f, 3.35442834e-02f,
  -7.55808204e-02f, -7.76823014e-02f, 8.84650350e-02f, -1.81134306e-02f, -6.11900389e-02f, -6.75602779e-02f, 1.77574921e-02f, 2.02906460e-01f, -2.29192108e-01f, -1.31133702e-02f,
  1.02087110e-01f, 1.59834668e-01f, 1.54226333e-01f, 2.09085062e-01f, 1.40060231e-01f, -5.75755574e-02f, -4.45121787e-02f, -7.85721540e-02f, -6.70191720e-02f, 1.30026087e-01f,
  -4.93840836e-02f, 8.66459087e-02f, 2.25245938e-01f, 3.26430887e-01f, 7.25099668e-02f, -9.18425322e-02f, 4.41133752e-02f, 1.37282744e-01f, 2.60812491e-02f, 1.25631332e-01f,
  6.75239936e-02f, 1.51774690e-01f, -8.17593411e-02f, 2.24971771e-01f, 1.84752151e-01f, -4.25864244e-03f, 3.30052786e-02f, -1.66330844e-01f, 2.78715849e-01f, 1.22804634e-01f,
  -1.10306665e-02f, -1.38436630e-01f, -2.95301545e-02f, 2.00033605e-01f, 1.95423186e-01f, 1.23674184e-01f, -9.10634398e-02f, 5.76239964e-03f, -1.16834797e-01f, -1.09610304e-01f,
  -1.19070232e-01f, 1.14634305e-01f, 1.93462931e-02f, -6.62494302e-02f, 1.14430010e-01f, 1.07719265e-02f, -9.02985707e-02f, 8.27552453e-02f, -3.96756418e-02f, 1.02721050e-01f,
  -3.94305885e-02f, 1.68084744e-02f, 4.17603441e-02f, 8.55470449e-02f, 5.15646711e-02f, 7.33235478e-02f, -7.49950260e-02f, 6.48680478e-02f, -9.53801349e-02f, 8.25617313e-02f,
  7.45387524e-02f, -1.87626779e-02f, 1.39810517e-02f, 5.62102832e-02f, -7.83518553e-02f, 4.68464345e-02f, 7.61703448e-03f, -1.66029893e-02f, -1.02436185e-01f, -2.65457705e-02f,
  -5.47432639e-02f, 6.79523051e-02f, 5.40734194e-02f, -5.98595366e-02f, 7.45432377e-02f, -5.57409003e-02f, -3.78649347e-02f, -6.82957768e-02f, -6.65605888e-02f, 7.93002322e-02f,
  1.05298549e-01f, -6.16293289e-02f, 1.01474831e-02f, -4.50911559e-02f, 1.04828715e-01f, 1.12701558e-01f, 5.19928224e-02f, -8.07783380e-02f, -5.25661418e-03f, -1.13899559e-01f,
  -1.92175210e-02f, -1.07288308e-01f, 1.15248814e-01f, -7.94501901e-02f, 2.99458690e-02f, 3.80640961e-02f, 5.82316667e-02f, -1.01273686e-01f, 4.46967743e-02f, 8.54307506e-03f,
  6.69300929e-02f, 2.42596790e-02f, 3.59036922e-02f, 9.60746929e-02f, -8.32421891e-03f, 1.29859492e-01f, -1.21808603e-01f, -9.24440250e-02f, -1.12124361e-01f, 2.25200970e-02f,
  -1.63924322e-01f, -1.77425176e-01f, 1.01807415e-01f, 1.18575193e-01f, -7.18207285e-02f, 5.90189535e-04f, 1.33330673e-01f, 4.35066335e-02f, -8.94183293e-02f, -6.27356842e-02f,
  9.46521163e-02f, 4.30337042e-02f, -1.75999869e-02f, -1.01430006e-01f, 4.50862013e-02f, 1.03680015e-01f, 1.32150531e-01f, -1.09529980e-01f, 1.09731421e-01f, 8.54430795e-02f,
  1.01886066e-02f, 3.81569378e-02f, 1.98883787e-01f, -2.15190873e-02f, 7.41527379e-02f, 7.01994374e-02f, 1.21692598e-01f, 1.60916060e-01f, -4.89778556e-02f, 1.26187831e-01f,
  1.60229802e-01f, -1.16153575e-01f, 1.67439267e-01f, 1.18202470e-01f, -7.97203779e-02f, 5.75502738e-02f, 8.14095289e-02f, -9.77012739e-02f, 9.87404659e-02f, -2.04524510e-02f,
  7.69170448e-02f, 6.16816059e-02f, 2.99739279e-02f, 1.14063561e-01f, -3.70171070e-02f, 2.14034654e-02f, -4.48141843e-02f, -9.91923809e-02f, 3.90028730e-02f, 7.26601528e-03f,
  5.00349477e-02f, 9.74847227e-02f, -9.81960818e-02f, 4.56987470e-02f, 1.55966178e-01f, 1.40834525e-01f, -5.24371676e-02f, 8.56287628e-02f, -7.91117623e-02f, -3.90556641e-02f,
  -9.80675146e-02f, 1.38915017e-01f, 3.97280492e-02f, -8.43076259e-02f, -1.92945302e-01f, -8.41181651e-02f, 7.34559074e-02f, 5.61503246e-02f, -4.81698103e-02f, -7.53325373e-02f,
  1.34942785e-01f, 7.27123814e-03f, 4.01119404e-02f, -1.40985414e-01f, -1.10222073e-02f, -1.27142280e-01f, 3.19772102e-02f, -4.58176844e-02f, 5.87445609e-02f, 1.28550574e-01f,
  -9.52377319e-02f, 2.80147530e-02f, 1.04338095e-01f, -4.21105325e-02f, -7.79817998e-02f, 1.18441544e-01f, 5.30110784e-02f, -5.31968586e-02f, -3.13373096e-02f, -2.12025978e-02f,
  1.04722781e-02f, 1.55676082e-01f, -3.54870572e-03f, 3.51302810e-02f, 1.33462042e-01f, 1.80853829e-01f, 1.08978182e-01f, -1.26424566e-01f, 1.51612341e-01f, 1.84713230e-02f,
  -2.81237792e-02f, 6.05309121e-02f, -7.84323830e-03f, 9.90156233e-02f, -6.91288384e-03f, 9.75221545e-02f, 1.23616137e-01f, 1.14232481e-01f, 3.97383384e-02f, 7.46330321e-02f,
  2.18476266e-01f, 8.52133483e-02f, -1.48182094e-01f, -6.26740605e-02f, 8.89493674e-02f, 2.67812815e-02f, 1.55529529e-01f, 9.97275952e-03f, 1.76132947e-01f, 1.76615432e-01f,
  1.08828023e-01f, 6.09989278e-02f, 1.98716149e-01f, 1.69131145e-01f, 5.33888154e-02f, -1.04994781e-01f, 2.38941580e-01f, -1.48410231e-01f, 2.92291850e-01f, -1.34814069e-01f,
  -2.55801361e-02f, 5.46581261e-02f, -1.23905120e-02f, 1.30080327e-01f, 1.37096331e-01f, -1.00488789e-01f, 9.63433906e-02f, 2.40658700e-01f, -1.09853655e-01f, 1.43537149e-01f,
  5.24643138e-02f, 9.03725252e-02f, -1.91187114e-01f, -6.68740794e-02f, 3.46863329e-01f, -6.65989965e-02f, -4.02570702e-02f, -4.35166582e-02f, 1.47897512e-01f, 4.40057442e-02f,
  -4.48802747e-02f, 1.28575280e-01f, 2.00088739e-01f, -8.28209668e-02f, 7.24974722e-02f, -1.36987090e-01f, -1.42910928e-01f, -3.37885991e-02f, -1.33288689e-02f, -3.13642323e-02f,
  4.74085994e-02f, 1.49484232e-01f, 9.42192897e-02f, -5.56508005e-02f, 7.22335726e-02f, 1.26218225e-03f, -8.61134678e-02f, 1.90536007e-02f, 3.09339076e-01f, 2.67712492e-03f,
  -6.08250313e-03f, 1.38319597e-01f, -6.26014546e-02f, 2.39316836e-01f, -1.10656835e-01f, 6.20124675e-02f, 1.89635009e-01f, 3.52461562e-02f, -5.99155575e-02f, -8.83530900e-02f,
  -3.28238308e-02f, 1.86226629e-02f, -9.52665433e-02f, -7.07640722e-02f, -2.46560723e-02f, 6.89478666e-02f, 7.14273974e-02f, -6.72188029e-02f, 8.10937881e-02f, -2.30147820e-02f,
  5.86828887e-02f, 2.08440814e-02f, 1.10605031e-01f, 2.19745189e-02f, 1.31325915e-01f, 1.04121909e-01f, 2.72760410e-02f, 1.30507708e-01f, -1.09068463e-02f, 1.17226742e-01f,
  -9.61637199e-02f, 2.02275235e-02f, 5.16817681e-02f, 1.55686261e-02f, 5.48449643e-02f, 4.69710343e-02f, -6.40679225e-02f, 2.27583628e-02f, -6.17060326e-02f, 1.12343803e-01f,
  1.37422055e-01f, -3.99141423e-02f, 3.82234044e-02f, 1.03336819e-01f, 1.92100415e-03f, 1.54233808e-02f, 7.62573928e-02f, -4.38219570e-02f, -1.10752888e-01f, -1.75971049e-03f,
  -1.10365655e-02f, 4.90759537e-02f, 1.49313912e-01f, -5.95612936e-02f, -5.59228845e-03f, 2.51169316e-02f, 8.65783170e-02f, -2.88123600e-02f, -8.45404193e-02f, 1.25535533e-01f,
  8.33487958e-02f, 1.82256009e-02f, 1.72002077e-01f, -7.47588202e-02f, 1.35019675e-01f, 1.55811325e-01f, -6.77248016e-02f, -1.13670304e-02f, 4.02112380e-02f, 2.73922514e-02f,
  -8.55449662e-02f, 4.85263728e-02f, -1.03676260e-01f, -8.09747949e-02f, 1.57060754e-02f, -1.11899592e-01f, -2.21773097e-03f, 1.49843901e-01f, -1.27203474e-02f, -7.71664456e-02f,
  2.21226439e-02f, 4.99923453e-02f, -7.88894668e-03f, -1.44405589e-01f, -6.55210838e-02f, -9.76454541e-02f, 1.80291325e-01f, -5.10037243e-02f, -1.09890342e-01f, 3.16351913e-02f,
  5.02319634e-02f, 1.64181650e-01f, 2.79875845e-02f, -7.34503344e-02f, 1.19286209e-01f, -2.53270492e-02f, 7.55092055e-02f, -2.90167686e-02f, 1.42566979e-01f, 5.36750853e-02f,
  -6.77428022e-02f, -5.97427525e-02f, 2.11361215e-01f, 8.09558406e-02f, -8.77213776e-02f, 7.67393559e-02f, -2.77567059e-02f, 1.07809767e-01f, 1.22335114e-01f, 1.28097862e-01f,
  -4.49772440e-02f, 1.84801072e-01f, 6.13900684e-02f, 1.30792245e-01f, -1.60574205e-02f, 9.33641866e-02f, 1.25550240e-01f, 1.40287559e-02f, 6.08956441e-02f, 1.02351412e-01f,
  3.31722423e-02f, 7.08070211e-03f, 6.48157746e-02f, -1.27424449e-02f, -6.23276234e-02f, -7.31166452e-02f, 1.79042980e-01f, -1.19031288e-01f, -6.65191188e-02f, 1.08214952e-01f,
  -1.21904269e-01f, 8.92169774e-02f, -3.81311364e-02f, 7.91792348e-02f, 5.48227392e-02f, 1.11652024e-01f, -2.69909576e-02f, -6.45076577e-03f, -4.91976775e-02f, -9.95091274e-02f,
  8.49915762e-03f, -4.72926088e-02f, 7.88942575e-02f, -3.34967813e-03f, 1.30844384e-01f, 2.41047498e-02f, 7.85448849e-02f, -9.65874717e-02f, -5.68530224e-02f, 9.69265923e-02f,
  3.79427820e-02f, -6.56960085e-02f, -9.20572206e-02f, -6.03022128e-02f, -4.43749912e-02f, 5.59494179e-03f, -3.84967253e-02f, -6.56347051e-02f, 9.97022390e-02f, -9.72010661e-03f,
  2.23035435e-03f, -7.12029040e-02f, 4.02568541e-02f, 9.23852623e-02f, 1.46031708e-01f, 1.75356612e-01f, 3.60949598e-02f, -8.07628706e-02f, 1.02882788e-01f, 1.14316449e-01f,
  -1.14560008e-01f, -7.57039934e-02f, 1.27091035e-01f, -6.08462505e-02f, -3.59663018e-03f, 1.88307129e-02f, 1.16541989e-01f, -6.45490587e-02f, 1.32384570e-02f, -2.83287354e-02f,
  1.29014194e-01f, 1.79072432e-02f, -2.77844388e-02f, 8.72006714e-02f, -9.90405008e-02f, 6.67056218e-02f, 8.23022053e-02f, 1.66226864e-01f, 1.73099399e-01f, -7.20330328e-02f,
  -9.62661058e-02f, 2.00012643e-02f, 3.97054898e-03f, 3.59455049e-02f, 6.65924922e-02f, -9.25724506e-02f, 1.57896549e-01f, -4.82585393e-02f, -9.23882574e-02f, -1.91896036e-02f,
  4.31827232e-02f, 1.61924765e-01f, -1.03529789e-01f, 2.87389047e-02f, 1.87524483e-01f, 1.51327893e-01f, 4.94798981e-02f, 1.41138777e-01f, 9.78925154e-02f, 1.60937980e-01f,
  -3.11897546e-02f, -6.34611472e-02f, -1.69421762e-01f, 7.41626928e-03f, 2.62634885e-02f, -1.42059729e-01f, 1.69624593e-02f, 1.14547655e-01f, -1.42829612e-01f, -6.70674536e-03f,
  2.84825899e-02f, -8.59669819e-02f, -4.15934622e-02f, 2.60134071e-01f, -6.56327307e-02f, -2.10118234e-01f, 1.10551380e-01f, 1.10862412e-01f, 1.99587226e-01f, -1.01440385e-01f,
  4.23431247e-02f, 8.31341967e-02f, -1.42494813e-01f, 3.10384762e-02f, -3.79343797e-03f, 7.92014152e-02f, 1.33582011e-01f, -9.06685442e-02f, 8.49846900e-02f, 1.87511325e-01f,
  1.70798406e-01f, 6.98190853e-02f, 1.27156094e-01f, 1.02989696e-01f, -3.68687809e-02f, 5.06039783e-02f, 2.89830156e-02f, 3.87677588e-02f, -5.69449998e-02f, 1.19243644e-01f,
  -2.91979895e-03f, -3.46723758e-02f, 2.47978792e-01f, 6.67443722e-02f, 1.44092605e-01f, -1.01692937e-01f, 2.29403406e-01f, 1.98800907e-01f, -4.15142579e-03f, -4.48203981e-02f,
  1.12183005e-01f, -6.12200089e-02f, -1.87505096e-01f, -5.80822267e-02f, -1.56700447e-01f, 1.13534480e-01f, 2.39792075e-02f, -5.82958683e-02f, -5.29386289e-03f, -4.27137390e-02f,
  2.99418233e-02f, 1.66419715e-01f, 1.47537127e-01f, -1.19463690e-02f, 1.98084652e-01f, -1.00299446e-02f, -1.19272090e-01f, -1.52605297e-02f, 1.39143448e-02f, -3.64169478e-02f,
  6.11210987e-02f, -5.83941564e-02f, -6.76733553e-02f, 3.53093371e-02f, 1.48664579e-01f, 2.01111063e-01f, -1.63344294e-02f, 3.08162898e-01f, 8.03224966e-02f, -1.20100401e-01f,
  1.96461335e-01f, 1.31690472e-01f, 1.26654789e-01f, -5.12756687e-03f, 2.72173546e-02f, 2.59404778e-01f, -4.47316058e-02f, -2.61236764e-02f, -6.74574748e-02f, 4.89242151e-02f,
  3.70666310e-02f, -1.32328528e-03f, 9.23974440e-02f, 1.80932581e-01f, 5.80773503e-02f, -2.90416237e-02f, 1.33852094e-01f, 1.82111021e-02f, 3.63188423e-02f, -8.91257972e-02f,
  -5.07824048e-02f, 1.45385534e-01f, 1.48421496e-01f, 1.35132924e-01f, -3.30036320e-02f, 1.41156852e-01f, 2.46384218e-01f, -9.54500660e-02f, 1.18301556e-01f, 7.01236874e-02f,
  1.05037764e-01f, 1.85923412e-01f, -4.93298508e-02f, -1.07201435e-01f, -1.34864733e-01f, 6.21958897e-02f, -1.71813622e-01f, -1.34973735e-01f, -2.55122818e-02f, -1.31690368e-01f,
  -2.08740011e-02f, -1.73091423e-02f, 2.75698990e-01f, 9.41615626e-02f, 1.70831665e-01f, 1.37881294e-01f, -7.86316930e-04f, 6.99328855e-02f, -2.03957647e-01f, 7.28984550e-02f,
  -2.48230636e-01f, -8.60327110e-02f, -1.19042590e-01f, 1.26237586e-01f, -7.39681423e-02f, -1.08192787e-01f, -1.30918801e-01f, 2.62332469e-01f, 8.82992819e-02f, -3.39495726e-02f,
  1.19687049e-02f, -4.92421016e-02f, 1.51949357e-02f, -4.73517366e-02f, -5.00341654e-02f, -4.82547879e-02f, -3.60219404e-02f, 4.95285839e-02f, 6.98348433e-02f, 1.08500853e-01f,
  2.60426700e-02f, 1.86501607e-01f, -7.28817433e-02f, 1.14328109e-01f, 9.01420265e-02f, 1.29470006e-01f, -5.46176285e-02f, 1.42925605e-01f, 2.07997695e-01f, 3.15301955e-01f,
  2.16604412e-01f, -1.58390570e-02f, -2.76279561e-02f, 2.53712028e-01f, 5.28010763e-02f, -5.51417954e-02f, 9.95130539e-02f, -5.40271327e-02f, -3.00593972e-02f, 1.14332765e-01f,
  2.09557768e-02f, 3.12212855e-01f, -1.46388356e-02f, 1.20586284e-01f, 2.00995922e-01f, -2.87831929e-02f, -2.01178834e-01f, -3.80094610e-02f, 2.04812661e-01f, 1.36886686e-02f,
  -1.71791241e-02f, -2.11202860e-01f, -1.15847014e-01f, -3.98419760e-02f, -1.23288017e-02f, -1.78541504e-02f, 3.68584767e-02f, -1.55679043e-02f, 5.27354889e-02f, -3.65010835e-02f,
  1.53315708e-03f, -2.67114379e-02f, 3.71032618e-02f, 1.02741376e-01f, 1.07549001e-02f, -6.04673810e-02f, -4.12002057e-02f, 5.88604212e-02f, -2.74192374e-02f, 8.89931992e-02f,
  1.16982982e-01f, -9.11797136e-02f, -1.58662647e-02f, -9.00322124e-02f, 6.90100491e-02f, -1.54249249e-02f, 7.80839771e-02f, 9.57271680e-02f, 1.41282445e-02f, 6.35898188e-02f,
  7.09117278e-02f, 9.73155200e-02f, -8.47728476e-02f, -6.70075938e-02f, 4.18688096e-02f, -4.07207981e-02f, 6.17398247e-02f, 3.83454934e-02f, -7.06203803e-02f, -1.10706888e-01f,
  -3.39823775e-02f, -1.18588097e-01f, -1.10627875e-01f, -1.07655093e-01f, -8.30419138e-02f, 1.20627910e-01f, -3.33333425e-02f, -4.11795937e-02f, -3.94576862e-02f, -7.40332380e-02f,
  -1.14484861e-01f, -9.23588648e-02f, 5.81432804e-02f, -8.51382241e-02f, -3.54350805e-02f, -3.86032127e-02f, -7.44913891e-02f, -8.62713978e-02f, 1.25891984e-01f, 4.15036716e-02f,
  4.90982234e-02f, -5.68930851e-03f, 1.06226526e-01f, -7.54314587e-02f, -7.37979487e-02f, 5.71158528e-02f, -1.31855190e-01f, 8.60900730e-02f, -1.24241903e-01f, -5.50345667e-02f,
  1.75057575e-01f, 1.27001837e-01f, 1.43306866e-01f, 2.55838126e-01f, 2.05747515e-01f, 2.02589408e-02f, -5.40638268e-02f, 4.39669490e-02f, -1.66605189e-01f, 1.85758606e-01f,
  -8.41882005e-02f, 2.38760725e-01f, -4.95365821e-03f, -3.64148729e-02f, 4.67834584e-02f, -8.44374672e-02f, 1.03153605e-02f, 1.90729320e-01f, 8.07504356e-03f, 2.83606112e-01f,
  1.30735502e-01f, 1.23555958e-01f, 5.89639544e-02f, 1.92093566e-01f, 1.90166682e-01f, -9.11325738e-02f, -2.49154288e-02f, -7.68188015e-02f, -7.79778808e-02f, -4.30535227e-02f,
  -7.13775456e-02f, -2.59089787e-02f, 1.74550012e-01f, -1.91857647e-02f, -3.67394425e-02f, -8.69984776e-02f, -1.10735230e-01f, -1.82902947e-01f, 1.10973462e-01f, 1.13852248e-01f,
  3.75488885e-02f, -7.68275410e-02f, -1.22482991e-02f, -1.13221407e-01f, -8.83371290e-03f, 7.26426840e-02f, 1.17569953e-01f, 8.02217796e-02f, 2.58209080e-01f, -5.78861162e-02f,
  -2.18546137e-01f, 1.49680421e-01f, -8.37923959e-02f, -4.18035425e-02f, 8.77909213e-02f, -8.05362090e-02f, 5.23509346e-02f, 1.53866231e-01f, 5.83859384e-02f, 3.89792142e-03f,
  1.00970343e-01f, 1.21830642e-01f, 2.09216052e-03f, 2.21961051e-01f, 8.91100839e-02f, 2.23562196e-01f, -7.36614466e-02f, 9.14751738e-02f, 5.42634241e-02f, 1.95515171e-01f,
  8.25792458e-03f, -1.00471735e-01f, 9.48991105e-02f, 9.06436145e-02f, -2.04604808e-02f, -1.65776275e-02f, -4.13010828e-02f, 1.57715037e-01f, 2.13402703e-01f, 1.21670626e-02f,
  6.06326424e-02f, 3.81735479e-03f, -5.84142283e-02f, 6.20494150e-02f, 1.41425356e-01f, 1.54984385e-01f, 1.20642306e-02f, 3.88219170e-02f, -6.84728026e-02f, 1.97116613e-01f,
  1.44635037e-01f, -9.00992006e-02f, 1.59257874e-01f, 7.05735805e-03f, 1.00601189e-01f, -7.33552650e-02f, 1.75846621e-01f, -2.06780806e-02f, 9.07380730e-02f, -9.81202275e-02f,
  -1.15753964e-01f, -1.65624380e-01f, -1.42517045e-01f, 1.52999252e-01f, -5.35752811e-02f, -1.95247114e-01f, 8.52062479e-02f, 1.26806438e-01f, 6.08524419e-02f, 2.54868604e-02f,
  2.18990386e-01f, -1.08765168e-02f, 1.82803944e-01f, -1.14229776e-01f, 1.31781012e-01f, 1.55690685e-02f, -2.20014360e-02f, 7.94273168e-02f, 1.94045380e-01f, -1.47446617e-02f,
  -1.54579366e-02f, -7.10574538e-02f, 3.84868006e-03f, 2.31902942e-01f, -1.24570780e-01f, 7.95427524e-03f, 3.68707404e-02f, 1.25239491e-01f, 4.62955236e-02f, 2.00839534e-01f,
  7.90437460e-02f, 2.59378612e-01f, 1.76295131e-01f, 7.09326565e-02f, -2.45865807e-01f, 9.79453400e-02f, -2.78126419e-01f, -6.63004443e-02f, -1.07564665e-01f, -3.71951871e-02f,
  -3.49020362e-02f, -7.93220624e-02f, -1.19681269e-01f, 2.69883901e-01f, -5.70621304e-02f, -1.16313040e-01f, 3.06820255e-02f, -8.75746161e-02f, -5.23541961e-03f, -8.49734843e-02f,
  -7.44560957e-02f, -8.01602900e-02f, -1.12147011e-01f, 7.26556359e-03f, -1.31211311e-01f, 2.68493947e-02f, 4.09256592e-02f, 8.39858279e-02f, -8.84764344e-02f, 2.22674161e-01f,
  2.78231874e-03f, 1.60232872e-01f, -1.01006292e-01f, 2.30896905e-01f, 1.69458658e-01f, 3.27232867e-01f, 1.07463785e-02f, 1.52580217e-01f, 5.08764200e-02f, 3.87195021e-01f,
  6.17065094e-02f, -1.64484363e-02f, 1.85637861e-01f, -1.35206312e-01f, -7.74054155e-02f, 1.18944600e-01f, -1.70548242e-02f, 3.56863111e-01f, 1.39389271e-02f, 5.72962351e-02f,
  2.11874813e-01f, 1.06947899e-01f, -1.36610508e-01f, 9.48034078e-02f, 1.59463719e-01f, 1.47707567e-01f, -1.06282607e-01f, -1.08397350e-01f, -2.98166703e-02f, 8.91964734e-02f,
  1.42748281e-02f, 7.71320686e-02f, -1.26305684e-01f, 7.15143532e-02f, 7.92946815e-02f, 1.07987702e-01f, -7.39267841e-02f, -5.94265833e-02f, -5.21606430e-02f, -6.49999827e-03f,
  -4.34875228e-02f, -1.94725785e-02f, 9.59001631e-02f, 8.16748068e-02f, -7.28288069e-02f, -5.52310720e-02f, -4.18409966e-02f, -1.06300540e-01f, 2.77896281e-02f, 1.00455709e-01f,
  5.32654561e-02f, -5.24157919e-02f, 4.28001367e-04f, -1.13122568e-01f, -5.05622029e-02f, 1.22291811e-01f, -1.48194060e-02f, -1.91923813e-04f, 1.15370294e-02f, -9.89118591e-03f,
  -9.57280472e-02f, -4.09821346e-02f, -6.79710358e-02f, -1.94938444e-02f, -3.51321027e-02f, 1.01370707e-01f, 1.92852356e-02f, -2.07464513e-03f, 1.11887706e-02f, -9.53310430e-02f,
  4.30985503e-02f, 7.52434283e-02f, 1.18346266e-01f, -9.51672420e-02f, -2.18994617e-02f, 4.28097509e-02f, 1.15999475e-01f, 1.26902098e-02f, 3.95633504e-02f, 1.10934913e-01f,
  -5.33209406e-02f, 3.54249105e-02f, -9.57326069e-02f, -1.48314480e-02f, -9.43843126e-02f, -3.36939804e-02f, 4.91313264e-02f, 5.21967129e-04f, 5.87714203e-02f, 8.79846066e-02f,
  -1.30446535e-02f, -4.61880043e-02f, -3.02806366e-02f, -6.42086491e-02f, 2.88347900e-02f, 1.06692396e-03f, 1.23388685e-01f, 3.60458605e-02f, 7.35734925e-02f, -1.01968408e-01f,
  1.91883706e-02f, 1.71101734e-01f, -3.14856768e-02f, 5.38496003e-02f, -1.07828252e-01f, -1.25152037e-01f, -2.26175636e-02f, -1.50988445e-01f, -6.74722856e-03f, 7.10808411e-02f,
  -5.36533147e-02f, -5.98087274e-02f, -4.59389724e-02f, 4.23775762e-02f, -1.03015855e-01f, -1.22765459e-01f, 1.41669825e-01f, 1.15370974e-02f, 1.03599012e-01f, 7.84328952e-02f,
  -1.35688350e-01f, -6.30325973e-02f, 2.95517556e-02f, -1.21913947e-01f, 1.39668018e-01f, -1.16311818e-01f, -5.86005002e-02f, -1.18491404e-01f, 1.77043322e-02f, -1.87420696e-02f,
  1.17811440e-02f, 1.41039222e-01f, 1.23070493e-01f, -8.91745836e-02f, -4.89152549e-03f, -1.19314902e-02f, 7.74622932e-02f, 8.07410032e-02f, 1.70878582e-02f, -6.77624391e-03f,
  4.49803174e-02f, -8.17173049e-02f, -3.99363190e-02f, 9.71412584e-02f, -9.75482985e-02f, -3.11838444e-02f, 1.35804296e-01f, 2.07381882e-02f, -3.67910936e-02f, 5.64982668e-02f,
  -2.19021048e-02f, 1.42700791e-01f, 9.39425901e-02f, 1.33448476e-02f, -1.17065527e-01f, -4.98627536e-02f, -9.47482809e-02f, 3.42558958e-02f, 3.54766846e-02f, 1.25948815e-02f,
  1.48471862e-01f, -4.41503851e-03f, 2.13606268e-01f, 5.82497604e-02f, 1.71961293e-01f, 9.98668279e-03f, 1.17551938e-01f, -9.20614600e-03f, 1.19395904e-01f, -4.96063307e-02f,
  9.37430263e-02f, 8.79488885e-02f, -4.71714213e-02f, 6.21002764e-02f, -5.16276136e-02f, 1.26773581e-01f, -4.49597090e-02f, -8.17065835e-02f, 2.01671541e-01f, -8.96386281e-02f,
  -1.28653064e-01f, 5.11856712e-02f, -2.24335687e-04f, 1.29011944e-01f, -6.86713904e-02f, 4.27045152e-02f, 1.74153626e-01f, -6.95802867e-02f, 1.12342846e-03f, 1.01499029e-01f,
  7.33759329e-02f, 3.34268287e-02f, -5.32721840e-02f, 1.78475261e-01f, -5.37629798e-02f, 3.65976989e-02f, -3.90438475e-02f, 1.25611290e-01f, 6.70022666e-02f, -8.02947441e-04f,
  1.03819326e-01f, 2.18963489e-01f, 8.03414825e-03f, 2.08597109e-01f, 1.39980450e-01f, -1.40355811e-01f, -1.14684336e-01f, -7.69228116e-02f, -2.39177514e-02f, 1.28637090e-01f,
  5.11101298e-02f, -6.45087436e-02f, 4.80225198e-02f, 1.18438050e-01f, -3.73112969e-02f, 6.71249703e-02f, -1.28639504e-01f, 1.55623883e-01f, 1.73520908e-01f, 1.08426660e-01f,
  1.21779544e-02f, 1.49784923e-01f, -5.44401146e-02f, -6.27409741e-02f, 1.24845989e-01f, 1.52338088e-01f, 8.84419233e-02f, 1.40669286e-01f, -2.77628517e-03f, 1.98146775e-01f,
  -2.35813498e-01f, 5.93771972e-02f, -2.30358899e-01f, 4.13969867e-02f, -7.60056078e-02f, 1.26053497e-01f, 1.45926818e-01f, 3.23304394e-03f, 1.04316520e-02f, -2.43235771e-02f,
  7.18218135e-03f, -6.68939352e-02f, -1.05496950e-01f, 5.58873871e-04f, -4.19659074e-03f, -1.52704924e-01f, 1.95319299e-02f, 8.07120837e-03f, -3.78814898e-02f, -2.01900788e-02f,
  -1.27367869e-01f, 3.44346464e-02f, -8.21205750e-02f, 1.55763417e-01f, -5.09013273e-02f, 7.76321739e-02f, 1.22325636e-01f, 1.24220200e-01f, -8.79507735e-02f, 4.69204634e-02f,
  1.03551768e-01f, 1.94155514e-01f, 5.72075099e-02f, 1.13985665e-01f, -6.29936308e-02f, 1.30383253e-01f, 2.01991588e-01f, 5.02402596e-02f, 7.19433129e-02f, -4.13794033e-02f,
  1.21740922e-01f, -1.30119383e-01f, -1.29335627e-01f, 2.11627573e-01f, 1.70870330e-02f, 5.52695757e-03f, 9.47032571e-02f, -1.15607955e-01f, -1.28551379e-01f, -1.90981664e-02f,
  3.51681039e-02f, -1.94459409e-02f, -1.27929389e-01f, -5.70485778e-02f, -2.05585957e-02f, 1.42823339e-01f, 1.54013947e-01f, 8.43213424e-02f, 2.05046460e-01f, 1.09893918e-01f,
  2.04796627e-01f, 1.61508530e-01f, 1.72866851e-01f, -9.87352654e-02f, 1.58237666e-01f, -3.82967107e-02f, -1.35714263e-01f, 3.65423337e-02f, 2.61530802e-02f, 1.17387243e-01f,
  -9.41780955e-02f, -3.57856266e-02f, -1.51837990e-01f, 8.48700926e-02f, -5.79583123e-02f, 1.38288096e-01f, 1.93169966e-01f, 7.85608813e-02f, -1.88348785e-01f, -4.45467494e-02f,
  3.22397389e-02f, 2.01996237e-01f, -8.39739107e-03f, 2.64113881e-02f, -5.66961318e-02f, 6.25158772e-02f, -1.26194790e-01f, -2.47647315e-02f, -8.46442729e-02f, 1.38136685e-01f,
  -1.67461976e-01f, 1.60254091e-01f, 1.69165596e-01f, -5.29414974e-02f, 3.71769853e-02f, 1.11529566e-01f, 1.21555798e-01f, 3.83580662e-02f, 8.69483277e-02f, 2.24917516e-01f,
  -1.31110445e-01f, 1.72574475e-01f, -2.91909813e-03f, 1.19922891e-01f, -4.63687144e-02f, 6.51311353e-02f, -8.71377066e-03f, 1.94527492e-01f, 2.89463270e-02f, 1.13861695e-01f,
  9.72884148e-03f, -8.38138834e-02f, -2.57091336e-02f, 1.06979541e-01f, 9.29607227e-02f, -3.81724276e-02f, 1.10540297e-02f, -1.39673486e-01f, 7.06479177e-02f, -1.14436075e-02f,
  1.83945626e-01f, 1.57118440e-01f, 6.90106377e-02f, -1.19268894e-02f, -4.66340370e-02f, 1.82186127e-01f, 8.29332322e-02f, 9.51430649e-02f, -5.83547950e-02f, 1.74349114e-01f,
  -2.57660747e-01f, 1.33299559e-01f, -2.05100819e-01f, 8.80057961e-02f, 1.59173980e-02f, 1.33453533e-01f, 9.24861282e-02f, 6.25143424e-02f, -9.34407264e-02f, 5.21600097e-02f,
  -2.46885829e-02f, 7.99072459e-02f, 8.09917375e-02f, -9.37909484e-02f, -1.12332419e-01f, -6.31306544e-02f, -1.99120250e-02f, 7.23355412e-02f, -1.62912369e-01f, 4.31617275e-02f,
  -2.94598322e-02f, 3.33382078e-02f, 8.52231085e-02f, -1.11652307e-01f, -1.57894045e-02f, -6.32739514e-02f, -7.09275855e-03f, 1.55804291e-01f, 4.98664826e-02f, 1.43095432e-02f,
  1.14695132e-01f, 1.66528031e-01f, -7.07917884e-02f, -7.39857703e-02f, 1.04623884e-01f, -1.88142538e-01f, -5.37119210e-02f, 7.34594762e-02f, 4.06501666e-02f, -4.65619117e-02f,
  8.08540732e-02f, 1.99977964e-01f, -1.42210469e-01f, -5.79121076e-02f, 1.81440804e-02f, 7.03037381e-02f, -1.23235330e-01f, 5.37761375e-02f, 1.74522758e-01f, -1.18839383e-01f,
  -1.81970164e-01f, 7.35655352e-02f, 1.16306044e-01f, 6.64189085e-02f, -6.00395761e-02f, 1.73477516e-01f, 1.09782942e-01f, 2.32921243e-01f, 1.59860298e-01f, 2.10660979e-01f,
  1.84857234e-01f, 1.99838415e-01f, 7.96201229e-02f, -8.94301385e-02f, -1.73732638e-01f, 5.76782934e-02f, 6.65153414e-02f, 4.38766405e-02f, -5.54826111e-02f, 1.04246056e-02f,
  1.44078851e-01f, -6.60279319e-02f, 1.10080376e-01f, 8.12315792e-02f, -3.15012485e-02f, 3.84947479e-01f, 1.87150985e-01f, 2.14975160e-02f, -3.80735546e-02f, 8.16616267e-02f,
  3.13419729e-01f, 1.83421299e-02f, -8.72491077e-02f, 1.18561052e-01f, -3.77070978e-02f, -3.27339470e-02f, -2.89037861e-02f, -1.00758873e-01f, 1.37111425e-01f, -1.61375299e-01f,
  2.07735717e-01f, -1.30446672e-01f, 5.09836227e-02f, -1.25710800e-01f, 6.99317902e-02f, 9.52876136e-02f, 7.31792673e-02f, -1.41543984e-01f, -4.10791002e-02f, -5.86583018e-02f,
  -6.07778467e-02f, 2.46011093e-01f, 9.92807373e-02f, 1.54549673e-01f, 2.91637450e-01f, -1.91066012e-01f, -2.92659625e-02f, -4.05114889e-02f, 8.70275646e-02f, 4.14559208e-02f,
  -8.28708336e-02f, -1.45197511e-01f, -3.51423249e-02f, 8.48384798e-02f, -9.93863046e-02f, 2.84010004e-02f, -1.35806680e-01f, -2.02036183e-03f, -1.11533418e-01f, 1.11491144e-01f,
  -2.24750265e-02f, 1.11304119e-01f, 7.53120109e-02f, 1.77689224e-01f, -4.58745211e-02f, 1.25057265e-01f, 4.53659743e-02f, 1.51042894e-01f, -2.07363084e-01f, 7.89338723e-03f,
  -1.44664615e-01f, 4.29668613e-02f, -4.23487648e-03f, -2.14840332e-03f, 4.09441032e-02f, 6.88652992e-02f, 6.36458248e-02f, 2.27806624e-02f, -1.64807718e-02f, 3.29674706e-02f,
  2.16366336e-01f, -1.04591101e-01f, -7.92603195e-02f, -6.11709543e-02f, 2.44309425e-01f, 1.02557719e-01f, 5.73697453e-03f, -8.37670118e-02f, -1.33494688e-02f, -5.79357482e-02f,
  -1.13115266e-01f, -7.39987567e-02f, -6.72781020e-02f, -8.69233608e-02f, -8.51119459e-02f, 4.13434543e-02f, 1.48850828e-01f, -3.93479168e-02f, -3.22422534e-02f, 1.50933519e-01f,
  -8.96498412e-02f, -8.23991597e-02f, 1.05554834e-01f, -1.21343665e-01f, -2.17896365e-02f, 8.36764276e-02f, -6.16038665e-02f, 8.17176402e-02f, 2.09066197e-01f, -1.18194312e-01f,
  -1.70446306e-01f, -6.35658484e-03f, 2.26526372e-02f, 4.28020060e-02f, 3.83150093e-02f, -8.56947824e-02f, 1.36005640e-01f, -2.21714756e-04f, -6.91912994e-02f, 1.86279058e-01f,
  -6.25997633e-02f, 8.12251568e-02f, -8.93319249e-02f, -7.23348036e-02f, 1.53190047e-01f, 1.34596184e-01f, 1.74899504e-01f, 9.32527408e-02f, 4.98771295e-02f, 6.25122264e-02f,
  1.74966291e-01f, 2.08722092e-02f, 2.44130399e-02f, -4.78130393e-02f, 2.15826258e-01f, -6.81327507e-02f, -2.24757381e-02f, 1.36825591e-01f, -6.02835976e-02f, 2.05620334e-01f,
  1.55722588e-01f, 6.67253211e-02f, -7.80646969e-03f, 2.10055798e-01f, -1.51201069e-01f, -2.54032701e-01f, 2.46060446e-01f, -1.04344562e-02f, 1.57567173e-01f, 1.43326968e-01f,
  2.39421129e-01f, -3.43417525e-02f, -8.88349563e-02f, 5.90206706e-04f, -8.23622644e-02f, 3.50651667e-02f, 7.63732791e-02f, -4.99885529e-02f, 1.93964615e-01f, 2.91767061e-01f,
  1.05778731e-01f, 1.93957552e-01f, 1.95129856e-01f, -5.96473180e-02f, -9.08035263e-02f, 1.60646811e-01f, -1.05087422e-01f, 1.87240645e-01f, 1.88769940e-02f, -2.47743633e-02f,
  1.35837868e-02f, 1.01139650e-01f, 1.82826724e-03f, -1.13957442e-01f, 2.38841817e-01f, -1.06547691e-01f, 1.85284793e-01f, 2.45522112e-02f, -5.49324490e-02f, 1.27584353e-01f,
  -1.78443775e-01f, -5.94817288e-02f, -1.64061308e-01f, -1.53220832e-01f, -1.04412839e-01f, -1.25159860e-01f, -2.04838105e-02f, 2.91046072e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  6.22609556e-02f, -1.15637183e-01f, -1.30293053e-02f, 1.04647249e-01f, 1.26984224e-01f, -1.30491853e-01f, 7.97703192e-02f, 6.81413859e-02f, 1.78237766e-01f, 1.25006944e-01f,
  7.41536990e-02f, -4.43868488e-02f, -1.56292580e-02f, -3.23630944e-02f, 1.48840761e-02f, 8.11070651e-02f, -4.37475070e-02f, 3.28654377e-03f, 1.31592005e-01f, -6.38635680e-02f,
  1.15076989e-01f, 1.85153894e-02f, 1.12494580e-01f, 1.34880483e-01f, 1.37612924e-01f, 1.75690427e-02f, -5.25529385e-02f, 9.62878019e-02f, 4.76898290e-02f, -4.48103957e-02f,
  6.59393892e-02f, -5.33955023e-02f, 2.17379302e-01f, 7.47751864e-03f, -6.08916990e-02f, 1.35440469e-01f, -1.91583652e-02f, 4.02515978e-02f, 1.31446287e-01f, -6.11183979e-02f,
  1.09546661e-01f, 6.99273869e-02f, 2.71650046e-01f, -1.03942625e-01f, 1.50848240e-01f, 1.63783222e-01f, 1.92521721e-01f, 1.33580238e-01f, 1.68141276e-01f, 2.48852193e-01f,
  1.59232333e-01f, 1.06469288e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  3.28764170e-02f, -4.27485369e-02f, -3.47825065e-02f, 2.77199037e-02f, 3.65471542e-02f, 2.94620506e-02f, -1.31197304e-01f, 2.81614941e-02f, 1.27881944e-01f, -3.40028219e-02f,
  -6.03874959e-02f, 3.47853005e-02f, -2.27626208e-02f, -1.00458860e-01f, -3.66808623e-02f, -9.88227949e-02f, 4.73168939e-02f, -9.00704488e-02f, 1.92391817e-02f, 8.04117769e-02f,
  2.07076848e-01f, 2.46634975e-01f, 5.68955764e-03f, -8.60548951e-03f, -1.22895733e-01f, 7.01834187e-02f, 1.75113365e-01f, 4.72255796e-02f, 1.74671203e-01f, -2.15422176e-02f,
  -2.41879690e-02f, -9.93599072e-02f, 1.30577907e-01f, -1.47668898e-01f, -5.02250493e-02f, -7.21824244e-02f, -1.20709129e-01f, -1.64696779e-02f, -3.65500413e-02f, 1.92204937e-02f,
  -2.45808274e-01f, 2.35992465e-02f, -1.15166411e-01f, -1.14434369e-01f, 2.75499970e-01f, 1.73803587e-02f, 1.68449879e-01f, -7.48193040e-02f, 1.80465579e-02f, 4.51215245e-02f,
  -3.95678692e-02f, 2.48507150e-02f, -1.07389905e-01f, -8.30512028e-03f, -1.35687932e-01f, 3.56131941e-02f, -5.13759330e-02f, 2.01830193e-01f, -1.57563701e-01f, 1.78501338e-01f,
  -2.05032662e-01f, 1.53314704e-02f, -1.64945602e-01f, 2.08314970e-01f, -4.16299477e-02f, 2.14227885e-02f, -1.14715705e-02f, 4.60876375e-02f, -8.70262310e-02f, -2.26063468e-02f,
  9.29339081e-02f, 8.96290019e-02f, -1.05932958e-01f, 9.45732817e-02f, -1.92406587e-02f, 2.23047286e-01f, 4.52578446e-04f, -2.60763522e-02f, 1.62320640e-02f, -1.57444775e-01f,
  8.78638253e-02f, -7.61873350e-02f, -4.25028540e-02f, -1.56011153e-02f, -1.43871069e-01f, 8.83926600e-02f, 3.14203426e-02f, -1.89572980e-03f, -5.19315079e-02f, 5.01567610e-02f,
  -5.23619242e-02f, -1.64575428e-01f, 1.70748055e-01f, 1.02550201e-01f, 1.63930673e-02f, 5.98676577e-02f, 1.05548635e-01f, 3.02327983e-03f, 2.03110173e-01f, 4.00313325e-02f,
  1.31061137e-01f, 3.87591831e-02f, -3.99112403e-02f, 2.36633178e-02f, 8.34899545e-02f, -6.09046444e-02f, -2.50246316e-01f, -1.67757601e-01f, -9.37785283e-02f, -1.50081515e-01f,
  2.47212946e-02f, -1.02706090e-01f, -1.61882564e-01f, -1.00597166e-01f, 1.63895562e-01f, 2.72911880e-02f, -1.67050049e-01f, -1.31557137e-01f, 8.54316950e-02f, -1.17351383e-01f,
  -1.33646831e-01f, 3.28692198e-02f, 1.18553139e-01f, 2.00406075e-01f, -1.37303621e-01f, -1.58683509e-01f, -6.82255626e-02f, 4.44411673e-02f, 4.62859757e-02f, 8.16160142e-02f,
  1.01403788e-01f, 7.28882328e-02f, 1.24515248e-02f, 1.21351406e-01f, -2.09287331e-02f, -7.48329163e-02f, 1.27340421e-01f, 1.35703370e-01f, -6.75846403e-03f, 9.31503624e-03f,
  6.21453151e-02f, 3.07695512e-02f, -3.46999802e-02f, -9.24563035e-02f, 1.71723530e-01f, 5.85166067e-02f, 2.06056423e-02f, -1.30080283e-01f, -1.23103879e-01f, -6.33737743e-02f,
  -4.08857837e-02f, 1.25662476e-01f, -6.08055182e-02f, -8.14018846e-02f, -6.93497658e-02f, 1.23143449e-01f, 1.97078705e-01f, 1.53293945e-02f, -1.61076244e-02f, -5.61156869e-02f,
  -1.00629620e-01f, -8.84002890e-04f, 1.09530136e-01f, -1.89385623e-01f, 9.61752981e-02f, 1.09637961e-01f, -1.25299752e-01f, 1.36840224e-01f, -7.90745392e-02f, 5.54247275e-02f,
  1.52105810e-02f, -4.82231900e-02f, 1.24765396e-01f, -4.64071035e-02f, -1.45147517e-01f, -4.12582271e-02f, -1.53016910e-01f, -5.27106375e-02f, -9.52709839e-02f, 7.35938773e-02f,
  2.69250005e-01f, -8.45004842e-02f, -1.76239058e-01f, 8.99994969e-02f, -1.18611366e-01f, -3.01921126e-02f, -4.63652834e-02f, -3.37904952e-02f, -2.53710081e-04f, 9.70941409e-02f,
  1.15352198e-01f, 6.27301186e-02f, 5.00459038e-02f, 1.52492449e-01f, -3.32772434e-02f, 1.75082415e-01f, 9.73848179e-02f, 7.19479397e-02f, 1.01869889e-01f, -1.20191023e-01f,
  4.85578738e-02f, 8.46679583e-02f, -1.79549813e-01f, 7.66935125e-02f, 7.19231069e-02f, 1.24757916e-01f, 5.69092780e-02f, -1.93995640e-01f, 2.10892856e-01f, 8.68596956e-02f,
  -7.56179243e-02f, -4.07973342e-02f, -2.38352809e-02f, -3.91301233e-03f, -6.91251233e-02f, 9.73709747e-02f, -2.19510403e-02f, -1.17444307e-01f, 3.92231792e-02f, -1.68581717e-02f,
  2.38303855e-01f, 1.09131131e-02f, 8.06615800e-02f, 6.77460060e-02f, 1.15898764e-02f, -3.08382213e-02f, 1.50453091e-01f, -7.31885359e-02f, 8.79023746e-02f, -1.69258174e-02f,
  -1.99781414e-02f, -5.04432581e-02f, -1.54555336e-01f, 9.91425514e-02f, -2.11655408e-01f, -1.09443655e-02f, 1.17538638e-01f, -7.25599527e-02f, 7.74563923e-02f, 3.44388410e-02f,
  -1.38628185e-01f, -8.53507742e-02f, -3.36944610e-02f, -8.32337365e-02f, 1.32488742e-01f, -7.02011213e-02f, -1.48478210e-01f, -6.46405220e-02f, 6.60567284e-02f, 1.39030650e-01f,
  -5.02425916e-02f, 1.39231145e-01f, -5.95098250e-02f, -4.16706055e-02f, -1.38537109e-01f, -8.12887400e-02f, 1.65772978e-02f, -2.76076291e-02f, -5.05643943e-03f, 7.73994206e-03f,
  3.27548198e-02f, 7.57798851e-02f, 7.97938276e-03f, -1.16293043e-01f, 1.11207344e-01f, 9.72605199e-02f, -5.37569411e-02f, -7.18716383e-02f, 4.60570119e-02f, 5.25783859e-02f,
  -5.09138778e-02f, 1.85416698e-01f, -4.48533967e-02f, -5.35878316e-02f, -4.50528935e-02f, 1.31809235e-01f, -5.82828522e-02f, -5.96965216e-02f, -6.11979701e-02f, 1.66265890e-01f,
  -6.21174239e-02f, 6.36345670e-02f, 7.01177269e-02f, 1.18963726e-01f, -5.25699705e-02f, 1.38994511e-02f, 9.21975300e-02f, -8.49905387e-02f, 7.16221035e-02f, 7.06546977e-02f,
  -1.64852485e-01f, 2.88423821e-02f, -1.17818356e-01f, 1.17697351e-01f, 8.50726441e-02f, 4.77485321e-02f, -5.99928424e-02f, 5.78370802e-02f, 8.41410016e-04f, 5.65481111e-02f,
  -2.26927400e-02f, 1.17905978e-02f, -2.38607954e-02f, 1.56887203e-01f, 6.22258186e-02f, 5.99041395e-02f, -1.37330770e-01f, 9.37811623e-04f, 2.40774415e-02f, 2.41977379e-01f,
  -7.89743960e-02f, -2.73001939e-02f, 1.89431161e-02f, -8.17386433e-02f, -1.70985132e-01f, -1.44733846e-01f, -9.78996903e-02f, 1.47999033e-01f, 6.62723929e-02f, -1.08471319e-01f,
  -1.61717325e-01f, -1.28403500e-01f, -9.01991427e-02f, -1.99878246e-01f, 1.30634438e-02f, -6.86290255e-03f, -1.67973772e-01f, -2.13736296e-02f, 1.17238566e-01f, -4.87207919e-02f,
  -9.55757648e-02f, -1.85095906e-01f, 3.29321809e-02f, 1.16535045e-01f, 1.41523600e-01f, -6.24111779e-02f, -1.86146736e-01f, -1.05700985e-01f, 1.00189194e-01f, -4.39108498e-02f,
  -3.14304270e-02f, 1.56571805e-01f, -8.11530091e-03f, -4.22174782e-02f, 2.41692737e-02f, -2.20584385e-02f, 2.42789060e-01f, 1.64245442e-02f, 1.00071542e-01f, -8.12818184e-02f,
  7.43156672e-02f, -9.66590419e-02f, -7.50069916e-02f, -1.17231250e-01f, -4.84527051e-02f, -1.19119301e-01f, -2.32921783e-02f, -9.18388069e-02f, 9.39375982e-02f, 1.92204848e-01f,
  -2.11493477e-01f, 9.11040418e-03f, -1.36869207e-01f, 2.05055568e-02f, -7.98773840e-02f, 9.30091590e-02f, -2.03285031e-02f, 1.49087563e-01f, 9.09180641e-02f, 2.28706792e-01f,
  -1.60588086e-01f, 7.81313553e-02f, 1.33997798e-01f, 8.39499931e-04f, -2.66461462e-01f, 2.19694735e-03f, -7.75749534e-02f, -9.71814692e-02f, -2.21511662e-01f, 7.24006221e-02f,
  -7.02740103e-02f, 1.85312882e-01f, 4.72243540e-02f, 1.23901747e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.02609806e-01f, -1.59409065e-02f, 7.46024475e-02f, 1.10907704e-01f, -1.13092422e-01f, -9.14188698e-02f, 1.15585670e-01f, -1.60753187e-02f, -9.67228878e-03f, 4.48709391e-02f,
  5.87998778e-02f, -7.83526301e-02f, 1.43394321e-02f, 8.91858488e-02f, 6.84242696e-02f, -6.68528527e-02f, -6.04274273e-02f, -8.58349949e-02f, -4.52490263e-02f, 9.59974602e-02f,
  -1.03320852e-02f, 2.15794495e-03f, 1.58886686e-02f, -8.97832662e-02f, -1.05411440e-01f, 8.78920853e-02f, 6.32414594e-02f, -5.97661957e-02f, 3.11114155e-02f, -8.25722218e-02f,
  1.26534030e-01f, -6.19737953e-02f, -7.47501627e-02f, -3.51382494e-02f, 6.43833578e-02f, -6.83551058e-02f, 1.13734722e-01f, -6.05366081e-02f, -3.25537100e-02f, 1.12126723e-01f,
  -9.32261124e-02f, 4.38497914e-03f, 7.08740726e-02f, -5.06666303e-02f, -6.67680129e-02f, -2.46925224e-02f, 9.76157561e-02f, 1.18308201e-01f, -4.39951830e-02f, -1.29352342e-02f,
  -2.25309469e-02f, 7.38304481e-02f, 1.04104459e-01f, -3.21026519e-02f, 5.74852824e-02f, 1.03117950e-01f, -6.11617938e-02f, -1.12766558e-02f, -1.17453925e-01f, 6.03486747e-02f,
  -8.97697657e-02f, -1.10668708e-02f, 8.36308524e-02f, -9.77604017e-02f, -7.96985533e-03f, -6.66656648e-04f, -5.84670417e-02f, 1.32510260e-01f, -2.03207973e-02f, 2.06715222e-02f,
  -1.15757830e-01f, -9.73691791e-02f, 1.01778945e-02f, 1.26411989e-01f, 1.10116340e-01f, 1.10017350e-02f, -2.59064836e-03f, 1.15117595e-01f, 3.58076878e-02f, 9.39235166e-02f,
  -8.71276036e-02f, 3.70393827e-04f, -6.16157614e-02f, 5.86920269e-02f, 5.00432355e-03f, -1.00817770e-01f, -4.48709205e-02f, -8.28994885e-02f, -6.95948526e-02f, -1.97917093e-02f,
  -7.74612352e-02f, 9.11158547e-02f, 3.38736437e-02f, -1.00696154e-01f, -5.78278042e-02f, 1.19215939e-02f, -3.30911912e-02f, -1.22927010e-01f, 5.84021993e-02f, 9.04030502e-02f,
  1.07414104e-01f, 3.33635360e-02f, 1.27697540e-02f, 3.71687375e-02f, -2.75218822e-02f, 8.27913806e-02f, 4.95535620e-02f, -1.24979774e-02f, -7.16610998e-02f, -9.16307494e-02f,
  -1.92802697e-02f, -1.77316263e-03f, 3.18941437e-02f, 1.53448224e-01f, 5.22273555e-02f, -5.49141131e-02f, 6.84563220e-02f, -5.46251051e-02f, 1.26995221e-01f, -1.24469765e-01f,
  -2.06662361e-02f, -9.95963812e-02f, 5.03285155e-02f, -1.11027367e-01f, 1.27164781e-01f, 1.18015401e-01f, 2.98957117e-02f, -2.12337971e-02f, -5.04813418e-02f, -1.27167359e-01f,
  1.98588497e-03f, 2.16663047e-03f, -7.39507303e-02f, -4.83370572e-02f, -5.50478548e-02f, -1.09316289e-01f, 3.70369852e-02f, 4.18918356e-02f, 2.52154674e-02f, 4.47145663e-03f,
  4.56563458e-02f, -6.71742931e-02f, -1.15094520e-01f, 7.59744570e-02f, 9.22845080e-02f, -7.53481612e-02f, 8.12915154e-03f, -1.13497987e-01f, -9.54282936e-03f, 3.45396176e-02f,
  -1.25090271e-01f, 3.10588703e-02f, -2.05472024e-04f, 1.00969210e-01f, -3.57410610e-02f, -1.06086716e-01f, 3.76350135e-02f, 5.87644465e-02f, -1.82602927e-02f, -1.19057246e-01f,
  -5.16816825e-02f, -6.64169900e-03f, -9.54374969e-02f, -1.00913510e-01f, 7.31060728e-02f, -2.28146724e-02f, -4.73880097e-02f, -8.03338662e-02f, 1.13722481e-01f, 1.17557652e-01f,
  5.66169284e-02f, 8.20913762e-02f, -5.78568615e-02f, 1.16918474e-01f, 4.24990989e-02f, 3.81163135e-02f, 1.25857964e-02f, -1.33222938e-01f, -6.59125298e-02f, 3.52995098e-02f,
  8.22855979e-02f, -1.05094805e-01f, 1.19920649e-01f, 6.04827292e-02f, 6.58818558e-02f, 8.38399753e-02f, 9.47104767e-02f, 1.07859693e-01f, -9.96488854e-02f, 4.75868061e-02f,
  -4.78908010e-02f, -6.54738583e-03f, 1.31209016e-01f, -4.86495458e-02f, -1.11034513e-02f, 1.05396956e-01f, 1.85271755e-01f, -5.33056399e-03f, 1.51440457e-01f, 2.07501590e-01f,
  -1.06483139e-01f, 5.60428202e-02f, -1.55239999e-01f, 1.25384167e-01f, 8.25010464e-02f, 1.16828330e-01f, 5.97148240e-02f, -1.30741090e-01f, 3.26328993e-01f, -1.09739237e-01f,
  -8.67685899e-02f, 1.25968819e-02f, 3.14277001e-02f, -1.58278808e-01f, -2.09146068e-02f, 8.75296295e-02f, -8.10893625e-02f, -1.66051872e-02f, 3.77655327e-02f, -1.40967518e-01f,
  -8.21363404e-02f, 1.38785932e-02f, -2.21295431e-02f, 1.10173374e-01f, 5.71951419e-02f, 2.12673977e-01f, 1.24495000e-01f, -8.12533274e-02f, 9.39071253e-02f, 8.80892873e-02f,
  -5.92545420e-02f, 3.62010766e-03f, 2.35819563e-01f, -1.00548171e-01f, -1.44388139e-01f, 6.43927455e-02f, 1.19053818e-01f, -1.25029266e-01f, -6.83274344e-02f, 4.71204426e-03f,
  -5.47436066e-02f, -1.32995620e-01f, 7.72915706e-02f, 6.12502657e-02f, 1.43910170e-01f, -4.75808047e-02f, 2.40207598e-01f, -1.61819123e-02f, -1.27930403e-01f, 1.55026928e-01f,
  8.67344216e-02f, 2.17606783e-01f, -8.13432503e-03f, -4.18627821e-02f, -7.15340599e-02f, -8.48186687e-02f, -7.12449551e-02f, 1.18789840e-02f, 8.75954404e-02f, -8.88875425e-02f,
  1.30910203e-01f, -3.62624712e-02f, -2.07717165e-01f, 2.43140355e-01f, -9.44984406e-02f, -2.38354400e-01f, -6.29502833e-02f, -2.26831045e-02f, -6.96567297e-02f, -7.99784288e-02f,
  -5.68932630e-02f, -3.41407619e-02f, -1.53467283e-01f, 8.79274681e-02f, 5.40864579e-02f, 5.85781001e-02f, -1.48262694e-01f, 2.93072723e-02f, -6.14516996e-03f, -1.00619882e-01f,
  -1.88058287e-01f, -7.75419176e-02f, 2.39854872e-01f, -4.09830213e-02f, 8.64450783e-02f, 7.49647478e-03f, -1.37047954e-02f, 3.17828171e-02f, -2.43901624e-03f, 1.11526847e-01f,
  9.13489237e-02f, 1.46522552e-01f, 2.27345541e-01f, -9.05018747e-02f, -1.87446430e-01f, 1.82384968e-01f, 1.97908387e-01f, 1.19232237e-01f, 1.89624820e-02f, 1.58355519e-01f,
  -1.64473243e-02f, 1.77017018e-01f, 4.53536138e-02f, -8.21239427e-02f, 2.13086605e-01f, 1.99898958e-01f, 8.59436020e-02f, -2.23132735e-03f, 1.70212179e-01f, -1.69499278e-01f,
  1.28814161e-01f, 2.32831594e-02f, -4.85644154e-02f, -1.17060646e-01f, 6.22505769e-02f, 2.40522712e-01f, 1.31450757e-01f, 1.89925909e-01f, -2.13722941e-02f, 1.64099514e-01f,
  1.96294278e-01f, 2.51949787e-01f, 1.58039570e-01f, 2.35678732e-01f, 2.51343846e-01f, 2.70410359e-01f, 9.28459223e-03f, 7.98899606e-02f, 5.90539798e-02f, 1.63051605e-01f,
  -3.50141600e-02f, 2.10186794e-01f, 1.13883428e-01f, -1.90267097e-02f, -6.33115545e-02f, 5.52635901e-02f, 1.52019173e-01f, 1.22938938e-01f, 3.84556763e-02f, 6.86507374e-02f,
  -3.81877981e-02f, -2.55034804e-01f, -1.28755987e-01f, -5.09134680e-03f, -7.27867186e-02f, -4.72159460e-02f, -1.28282115e-01f, 1.58622842e-02f, 6.70276722e-03f, -1.52081368e-03f,
  9.06706750e-02f, -2.26041116e-02f, 1.93739980e-01f, 1.46344140e-01f, 2.14436520e-02f, -1.54619366e-01f, 1.46539286e-01f, -1.10935703e-01f, 1.19099423e-01f, 1.33444937e-02f,
  1.36850789e-01f, -1.35209309e-02f, 7.59031624e-02f, 8.01840052e-02f, -1.30243599e-01f, -3.99829857e-02f, -3.90610844e-02f, 1.21277429e-01f, 4.42268439e-02f, -1.37851566e-01f,
  8.52125362e-02f, 1.11045048e-01f, 2.77478784e-01f, 6.58652857e-02f, 2.05825031e-01f, -3.88654396e-02f, 9.42359120e-03f, 1.49309278e-01f, 3.68408822e-02f, 1.93591103e-01f,
  1.65257096e-01f, 8.91366526e-02f, 2.01896891e-01f, -2.20482931e-01f, -1.54073566e-01f, 4.70498614e-02f, 2.99526695e-02f, -1.65610492e-01f, -1.03549704e-01f, -8.94819647e-02f,
  -1.48501500e-01f, 1.03697814e-01f, -3.61251906e-02f, -1.03122748e-01f, 4.82931733e-02f, -4.59916219e-02f, -5.97987361e-02f, 5.80416285e-02f, 8.86613056e-02f, 9.93746519e-02f,
  -6.20635040e-02f, 9.66609791e-02f, 4.26700152e-02f, 9.78172198e-02f, -6.18487038e-02f, -1.14068337e-01f, 7.49048069e-02f, 8.82886201e-02f, -1.64447963e-01f, 2.55026435e-03f,
  2.13222578e-01f, 8.62065107e-02f, -1.80746481e-01f, 2.61433218e-02f, -1.19990781e-01f, 7.12916208e-03f, 1.41771004e-01f, -1.78958289e-02f, -8.45618472e-02f, 1.68456107e-01f,
  1.57821104e-01f, 1.13545731e-01f, 2.49551143e-02f, -3.29387188e-02f, 2.19717175e-01f, -7.03445971e-02f, 7.73388613e-03f, -1.18989162e-02f, -7.21880272e-02f, 2.06468239e-01f,
  3.93401459e-02f, 1.72999892e-02f, 1.95996091e-01f, 2.30149310e-02f, 1.35946825e-01f, 1.26653492e-01f, -4.74803410e-02f, 1.74740463e-01f, -5.87394051e-02f, 7.12596476e-02f,
  3.18277074e-04f, 1.52139005e-03f, -5.36003476e-03f, 8.23421478e-02f, -6.93511069e-02f, 1.81672946e-01f, 7.46917576e-02f, 3.54328081e-02f, 3.96574549e-02f, 3.48619721e-03f,
  1.07265204e-01f, 6.62179571e-03f, 1.98070128e-02f, -4.02255990e-02f, -1.92825124e-02f, 1.24490201e-01f, -9.72852111e-02f, 8.22626948e-02f, 1.32470895e-02f, 1.69432946e-02f,
  -9.36823860e-02f, 1.13227755e-01f, 1.21048830e-01f, -4.49206531e-02f, -6.05897121e-02f, -5.28901890e-02f, 3.14709917e-02f, -6.70532882e-02f, 2.70239208e-02f, -7.91386962e-02f,
  1.23959787e-01f, 3.06802802e-02f, -7.25720674e-02f, 1.45153496e-02f, -7.22298250e-02f, 7.85102025e-02f, 1.27805974e-02f, -5.37345670e-02f, -6.48009926e-02f, 3.46091688e-02f,
  1.62716910e-01f, 4.62850593e-02f, 1.02909422e-02f, 5.51744811e-02f, 9.11643356e-02f, -1.31750870e-02f, -1.09406993e-01f, 2.72349901e-02f, 7.68204853e-02f, 1.05567962e-01f,
  1.27233103e-01f, -8.12957734e-02f, -1.11611933e-02f, 5.88771291e-02f, -3.16745304e-02f, -8.40184093e-02f, 6.73713163e-02f, 4.70054336e-02f, 8.79112482e-02f, 1.12359338e-01f,
  -9.01448354e-02f, -1.01238951e-01f, 7.23131672e-02f, 6.96392655e-02f, 1.52188927e-01f, -1.09541521e-03f, 1.21829942e-01f, 3.47155258e-02f, 4.97799292e-02f, 1.02200039e-01f,
  9.43296999e-02f, 7.76493102e-02f, -2.54924726e-02f, -2.84615736e-02f, -2.01120824e-02f, -1.10497102e-01f, 1.37128934e-01f, -1.50887677e-02f, -1.10730112e-01f, -1.02884859e-01f,
  -5.01788035e-02f, -5.16370162e-02f, 1.15038909e-01f, -9.31151658e-02f, 6.27117306e-02f, 1.19898707e-01f, -4.08945512e-03f, 6.59359619e-02f, -9.29421484e-02f, 2.28456277e-02f,
  9.36685354e-02f, 6.99235350e-02f, -7.99140986e-03f, -9.67577845e-02f, -1.02431901e-01f, -1.83384668e-03f, 1.26140654e-01f, -9.04557630e-02f, 1.32758141e-01f, -2.10785307e-02f,
  -8.47821161e-02f, -1.11995146e-01f, 3.61051038e-02f, -1.15823969e-01f, -5.70215471e-03f, 9.77886692e-02f, 1.74254719e-02f, 8.80507827e-02f, 5.14913909e-02f, -3.80770788e-02f,
  1.00765944e-01f, -4.10502404e-02f, -9.31111500e-02f, 8.49403515e-02f, -1.05474023e-02f, -1.09454036e-01f, -7.54586363e-05f, 8.88116658e-02f, 1.14823908e-01f, 3.62385400e-02f,
  4.64098565e-02f, -3.23262066e-02f, 1.04589351e-01f, -2.03649029e-02f, -1.07551031e-01f, 1.38395682e-01f, -8.17689151e-02f, -2.07925104e-02f, 1.11263864e-01f, 1.04090653e-01f,
  2.16000453e-02f, 4.37538698e-02f, -4.34854291e-02f, -2.45198607e-02f, 1.00226015e-01f, -8.32024291e-02f, 8.03218484e-02f, -5.82458228e-02f, 1.44984096e-01f, 1.08983114e-01f,
  -3.30244340e-02f, 1.21402442e-01f, 5.58168180e-02f, -5.21747358e-02f, -6.44863443e-03f, -2.45149229e-02f, 4.56437394e-02f, 8.62709805e-02f, 2.81014573e-02f, -5.41008413e-02f,
  7.18279928e-02f, -4.02090177e-02f, 2.74843886e-04f, -9.12720859e-02f, -1.67993531e-02f, 6.07957691e-02f, 6.50484264e-02f, 1.81600556e-01f, 8.29964429e-02f, -1.42944843e-01f,
  -9.14621353e-02f, 7.75746778e-02f, -1.48710897e-02f, 4.27149646e-02f, -8.13812613e-02f, -5.35733141e-02f, 1.15403362e-01f, -1.06877707e-01f, 3.31767090e-02f, -4.11149533e-03f,
  -2.37726066e-02f, 1.11830056e-01f, 4.08633240e-02f, 1.08236574e-01f, 8.17026347e-02f, -1.18256427e-01f, 1.24833375e-01f, -7.66415894e-02f, 2.58646719e-02f, 1.67675465e-01f,
  -6.38263971e-02f, -3.77467251e-03f, -1.07739614e-02f, -5.53417318e-02f, 1.58265933e-01f, -1.08747244e-01f, 2.37799078e-01f, 9.89984870e-02f, -1.52315795e-01f, -1.22788567e-02f,
  2.85931736e-01f, -7.22576380e-02f, 1.52305663e-01f, -4.43928242e-02f, 7.35537559e-02f, 1.56439394e-01f, 8.49525779e-02f, -1.33394375e-01f, 4.36995067e-02f, 3.90874110e-02f,
  3.30303004e-03f, -9.48744491e-02f, 3.17817852e-02f, 6.13485686e-02f, 1.71220873e-03f, -2.75043454e-02f, -1.45918969e-02f, 1.62965450e-02f, 3.95997567e-03f, -8.44939053e-02f,
  6.91541284e-03f, -4.13544104e-02f, 3.04385237e-02f, -5.88251762e-02f, -2.72915531e-02f, -7.04804510e-02f, -9.36266258e-02f, -8.95477161e-02f, 1.76690966e-02f, -1.00262888e-01f,
  3.30199720e-03f, 4.02372479e-02f, 1.20654128e-01f, -4.90419799e-03f, -1.00720182e-01f, 7.31355976e-03f, 9.10467058e-02f, 7.40839988e-02f, 3.84652689e-02f, -1.14250846e-01f,
  -1.05147339e-01f, 1.54907005e-02f, -1.00605130e-01f, -8.08059797e-02f, 6.19612560e-02f, 6.15853705e-02f, -2.66264956e-02f, -2.21548509e-02f, -9.85513404e-02f, -6.11109361e-02f,
  -5.31043224e-02f, 1.10819355e-01f, -9.81825590e-02f, -4.81294543e-02f, 1.20597772e-01f, 4.26876843e-02f, 7.95375928e-02f, -9.51653123e-02f, -1.19006462e-01f, -2.74261720e-02f,
  -1.25430822e-01f, 8.29535797e-02f, -6.31822273e-02f, -7.19084963e-02f, 1.05859846e-01f, -3.48818265e-02f, -8.89679715e-02f, -2.52706222e-02f, 7.72896335e-02f, -2.96530733e-03f,
  1.06320366e-01f, -2.99887322e-02f, -3.71905603e-02f, -1.75557146e-03f, 1.98911577e-02f, 2.19839439e-01f, 1.58346161e-01f, 7.33835697e-02f, 2.15320542e-01f, 1.74592465e-01f,
  -1.98941696e-02f, -1.46664754e-01f, 4.33983281e-02f, 1.11496799e-01f, 1.12047493e-01f, -1.49040058e-01f, 1.04856208e-01f, -3.64285111e-02f, -8.52935761e-02f, 1.12040587e-01f,
  -9.14420560e-02f, -2.80598067e-02f, 7.62480274e-02f, 1.09957613e-01f, 2.51722485e-01f, -2.91072447e-02f, 6.76539615e-02f, 5.73116988e-02f, -5.88527173e-02f, -1.94719434e-02f,
  2.37312093e-01f, 1.54188663e-01f, 2.21728925e-02f, 3.95006128e-02f, 7.75352940e-02f, -3.73531245e-02f, 6.65336549e-02f, 8.72137323e-02f, 6.29642140e-03f, -1.18178122e-01f,
  -6.07240312e-02f, 1.36113986e-01f, -1.55180618e-02f, 5.15788458e-02f, -1.46179080e-01f, -7.40505531e-02f, 6.33638054e-02f, -2.35147756e-02f, 2.05034748e-01f, 1.26545414e-01f,
  -9.68424901e-02f, 1.04251385e-01f, 3.88681591e-02f, 8.13388526e-02f, -1.35879040e-01f, 3.54063846e-02f, 2.20341295e-01f, 2.72104383e-01f, -1.07553251e-01f, 1.07693590e-01f,
  -1.16635133e-02f, -8.12698454e-02f, -1.07880518e-01f, 1.04761347e-02f, 5.96274659e-02f, 3.26449513e-01f, 1.26555324e-01f, 1.30613819e-01f, 4.07694243e-02f, -4.24268283e-02f,
  6.36720806e-02f, -8.44246000e-02f, -3.64158005e-02f, -6.68546408e-02f, 2.67676581e-02f, -7.04951631e-03f, -9.54429284e-02f, 1.15758516e-01f, 1.12834446e-01f, 5.74398302e-02f,
  1.25356495e-01f, -6.96147084e-02f, 1.08727984e-01f, -6.75028265e-02f, -1.02854781e-01f, -3.15354280e-02f, -5.05689718e-03f, 5.83254993e-02f, -1.20741665e-01f, 9.83069390e-02f,
  -8.06490555e-02f, -1.90825276e-02f, -7.27880280e-04f, 3.24707888e-02f, 6.55895695e-02f, -9.49631929e-02f, 6.27594739e-02f, -8.99969190e-02f, 9.38678458e-02f, 5.55213206e-02f,
  -3.08912154e-02f, -5.65105155e-02f, -1.25407472e-01f, 8.79613012e-02f, -7.90007561e-02f, -6.31645694e-02f, 1.32069131e-02f, 5.05852588e-02f, -6.75115660e-02f, 1.68895982e-02f,
  6.74712583e-02f, -7.87845999e-02f, 8.77820253e-02f, 9.38176364e-02f, 1.11070774e-01f, -8.77764747e-02f, -3.55982669e-02f, 1.47488574e-02f, 5.55356257e-02f, -4.05584462e-02f,
  -6.17370829e-02f, 1.21604346e-01f, 2.84481198e-02f, 1.08050495e-01f, -6.42817691e-02f, 1.83777176e-02f, -1.23860277e-01f, -2.45296843e-02f, -8.54803529e-03f, -6.57550097e-02f,
  9.07397792e-02f, -1.01887770e-01f, 1.06881717e-02f, 1.87297780e-02f, -1.51369106e-02f, 1.11008324e-01f, 1.73824936e-01f, -8.55279863e-02f, -9.48733017e-02f, 3.56017910e-02f,
  1.68361187e-01f, -8.42851177e-02f, -2.50074416e-02f, -1.77205279e-01f, 8.81851912e-02f, -6.09658938e-03f, -3.82564776e-02f, -2.14221887e-02f, -2.22713389e-02f, -1.35511294e-01f,
  -1.07040785e-01f, 7.92809054e-02f, 2.04176083e-01f, 9.90875140e-02f, 1.09043913e-02f, 4.82441112e-02f, 9.58479345e-02f, 8.95344168e-02f, 2.53085196e-01f, -3.11074704e-02f,
  -4.20550890e-02f, 4.69723828e-02f, -7.71214366e-02f, -7.82115664e-03f, 1.95934922e-01f, -1.05273267e-02f, 2.88929883e-03f, 6.70355260e-02f, -1.14113055e-01f, 1.15028374e-01f,
  -9.22073126e-02f, -9.77807716e-02f, -1.29748806e-01f, -3.65085043e-02f, 6.57440051e-02f, 1.20346211e-02f, 2.27326348e-01f, 7.02481158e-03f, 8.00029095e-03f, 4.83197384e-02f,
  8.24403018e-03f, 2.63965465e-02f, -1.78814396e-01f, 8.98912475e-02f, -1.34620816e-01f, 1.71436042e-01f, -7.69409817e-03f, 6.84368983e-02f, 1.04779184e-01f, 5.52002490e-02f,
  -1.39498502e-01f, -8.54939818e-02f, -8.28819573e-02f, 3.95340845e-02f, 1.18281664e-02f, 1.62916705e-01f, -9.54676792e-02f, 3.06917112e-02f, -7.84342438e-02f, 3.65812168e-03f,
  -1.15911253e-01f, 1.00382388e-01f, 1.09644271e-01f, 1.57529846e-01f, -7.14038759e-02f, -1.07426845e-01f, -1.19309183e-02f, -1.51151288e-02f, 7.60397390e-02f, 1.02159880e-01f,
  -7.93765485e-02f, -1.51364505e-01f, -9.77454614e-03f, -4.23560850e-02f, -5.87295815e-02f, -4.18975465e-02f, 9.46412981e-02f, 1.01948567e-01f, -7.38570765e-02f, 8.12915936e-02f,
  -5.63563555e-02f, -5.97173609e-02f, 7.55006224e-02f, -9.81315598e-02f, 1.13093033e-01f, 1.28099725e-01f, -1.63434807e-03f, -1.52029051e-02f, 1.64248794e-01f, -2.25746110e-02f,
  1.09160423e-01f, 3.56798545e-02f, -6.84767887e-02f, -3.16383019e-02f, 7.61521906e-02f, 1.53797399e-02f, -8.29351842e-02f, -7.77466744e-02f, 9.63037182e-03f, -1.24235660e-01f,
  1.11891374e-01f, 1.40834674e-02f, 6.73376769e-02f, 3.16509269e-02f, -5.68338633e-02f, 5.04751131e-02f, 1.49655819e-01f, 2.37214044e-02f, -1.84076407e-03f, 4.42818515e-02f,
  1.49052352e-01f, -4.19357643e-02f, 2.22926792e-02f, 2.33757809e-01f, 9.72627476e-02f, 3.46016102e-02f, -7.28807747e-02f, -3.04865092e-02f, -3.74902375e-02f, 1.05517529e-01f,
  1.41844153e-01f, 5.38121797e-02f, 1.64296806e-01f, 1.60758033e-01f, 1.70554861e-01f, 8.79763290e-02f, -1.45990893e-01f, -2.40636896e-02f, 7.50849620e-02f, -1.99596863e-02f,
  2.32523819e-03f, -2.29344264e-01f, -8.16686228e-02f, -1.14929840e-01f, 1.28340647e-01f, 3.79793346e-02f, -7.98120722e-02f, -5.00207022e-02f, -1.07582100e-01f, 5.53842299e-02f,
  1.60390824e-01f, 3.99629444e-01f, 9.38905329e-02f, 1.18953452e-01f, 7.05359504e-02f, 1.03789866e-01f, 2.61856735e-01f, 1.87369347e-01f, 2.99784809e-01f, 8.21905434e-02f,
  -9.40371752e-02f, -6.68496788e-02f, 2.51661867e-01f, -6.14134073e-02f, 1.07978426e-01f, 9.23036560e-02f, -2.09626406e-01f, -7.90174156e-02f, 1.34460419e-01f, -1.84602458e-02f,
  -3.23625535e-01f, -3.22663598e-02f, 1.51380897e-01f, -2.64083799e-02f, 4.32753146e-01f, -4.01889384e-02f, 2.20808670e-01f, -8.63029286e-02f, 1.09261990e-01f, 4.37781960e-02f,
  -8.72087479e-02f, -9.48937088e-02f, -1.46501601e-01f, 1.73368350e-01f, -1.34707063e-01f, -1.42547470e-02f, 8.49268660e-02f, 2.03687400e-01f, -1.20365217e-01f, 6.62443489e-02f,
  -1.60927579e-01f, 5.99350929e-02f, -2.16458932e-01f, 2.71818936e-01f, 5.29121943e-02f, 3.53611168e-03f, 5.10630310e-02f, 2.10417613e-01f, 1.68144554e-01f, 1.19761907e-01f,
  4.35352363e-02f, 1.98094591e-01f, 5.21915928e-02f, 2.92552840e-02f, -4.76396568e-02f, 7.52073899e-02f, -1.39411747e-01f, 1.76141632e-03f, -7.23482221e-02f, 1.03038259e-01f,
  1.91861227e-01f, -1.01122014e-01f, -3.71911936e-02f, 1.12628806e-02f, -4.59534526e-02f, 1.87710196e-01f, -1.97016895e-02f, -1.17117099e-01f, 1.64993219e-02f, 2.73847822e-02f,
  5.92389219e-02f, -1.81534532e-02f, -1.40046746e-01f, 7.44704381e-02f, -1.07560456e-01f, 8.60841051e-02f, 2.20662445e-01f, 1.90918949e-02f, 1.48371756e-02f, 1.77359089e-01f,
  2.31608465e-01f, -1.98863186e-02f, 1.02523841e-01f, -1.38068900e-01f, 3.01068455e-01f, 7.18553737e-02f, 1.18988007e-01f, 1.33468226e-01f, 5.99084534e-02f, -1.11719348e-01f,
  1.02945566e-02f, 8.57587233e-02f, -9.98467878e-02f, -1.60309970e-01f, 3.10502559e-01f, 8.63085538e-02f, -1.60595521e-01f, -1.83214340e-02f, 4.64064091e-01f, 6.90050423e-02f,
  -4.37969007e-02f, 2.07997978e-01f, 1.51927620e-01f, 1.35195017e-01f, 1.13541886e-01f, -8.11706409e-02f, -8.79290327e-02f, 6.21310286e-02f, 5.74575551e-02f, 1.79445118e-01f,
  -1.50700407e-02f, 1.59927726e-01f, -3.32238115e-02f, 1.60136372e-01f, -1.28566504e-01f, -1.24977909e-01f, 4.05946970e-02f, -8.00863747e-03f, 1.18154891e-01f, -1.56600937e-01f,
  4.92428849e-03f, -1.04102064e-02f, 1.82612389e-02f, -1.29236624e-01f, -1.29516765e-01f, -1.40732015e-02f, -2.56328452e-02f, 2.72041447e-02f, 2.14920104e-01f, 1.75567374e-01f,
  -7.63873309e-02f, 1.52866438e-01f, -1.27875403e-01f, 1.09889343e-01f, 2.14603633e-01f, 2.35955670e-01f, 1.28939077e-01f, -1.23821110e-01f, 7.26379454e-02f, 1.17749244e-01f,
  2.87890192e-02f, -1.56350404e-01f, 1.11704469e-01f, -1.55044958e-01f, 2.46435814e-02f, -1.06541425e-01f, -8.90005752e-02f, 5.40491156e-02f, -1.75593406e-01f, -1.06175229e-01f,
  -1.85729954e-02f, -1.34825200e-01f, 8.52019116e-02f, 1.17411286e-01f, -1.11256704e-01f, 1.10522300e-01f, 1.46489829e-01f, 3.07416707e-01f, -6.43461719e-02f, 2.13683210e-03f,
  2.14632556e-01f, 5.92422523e-02f, -1.56591073e-01f, -1.13884799e-01f, -4.48760986e-02f, -8.63882899e-02f, -8.26664269e-02f, 1.07851379e-01f, 1.29719317e-01f, 3.10136884e-01f,
  1.60575256e-01f, 2.32240513e-01f, -1.82365011e-02f, -4.98853289e-02f, 1.80009287e-02f, -1.03516802e-02f, -2.61270236e-02f, -9.24201757e-02f, 1.00182220e-01f, 1.96752362e-02f,
  -6.57538101e-02f, -6.38029948e-02f, 6.12111092e-02f, 7.77062774e-02f, -1.91022619e-03f, 2.62487866e-02f, 9.28155426e-03f, 1.18689671e-01f, 4.61919419e-02f, 1.73448138e-02f,
  -4.28414997e-03f, -1.62332300e-02f, 3.44576910e-02f, 6.56304508e-02f, -2.23311055e-02f, 1.03437848e-01f, 3.59791592e-02f, -1.04746334e-01f, -2.91065518e-02f, 2.08547916e-02f,
  8.56814813e-03f, -1.18949726e-01f, 1.82016566e-03f, 7.83373788e-02f, 3.77519950e-02f, -1.39006404e-02f, -1.07227573e-02f, 8.38069543e-02f, 4.27358635e-02f, -6.94806054e-02f,
  9.13891867e-02f, -5.12383878e-04f, 1.20964438e-01f, -2.09333445e-03f, 1.95072740e-02f, 1.24958001e-01f, -1.83323883e-02f, 1.21516354e-01f, -2.62460224e-02f, -9.32358205e-03f,
  -6.08707629e-02f, 3.48604061e-02f, 6.37294501e-02f, -1.00387178e-01f, 2.23892946e-02f, 1.09537236e-01f, -3.77356410e-02f, 9.62686613e-02f, -7.23302364e-02f, -1.09796219e-01f,
  9.54703316e-02f, -1.13190144e-01f, -4.54216078e-02f, -8.92246738e-02f, -6.32897690e-02f, 2.05015689e-02f, -1.70956701e-02f, -1.82521474e-02f, 2.41028722e-02f, 7.41288140e-02f,
  3.74915265e-02f, 8.99947807e-02f, -1.25724614e-01f, 2.15919279e-02f, -1.05867080e-01f, -7.48940706e-02f, 5.30028827e-02f, 1.13978721e-02f, 6.35769870e-03f, -1.00096971e-01f,
  9.52918530e-02f, -9.25906003e-02f, -1.85155064e-01f, 5.27208745e-02f, -4.14083079e-02f, -7.49945194e-02f, 3.07122245e-03f, 2.24049807e-01f, -7.36339241e-02f, -4.70647626e-02f,
  1.19884431e-01f, -9.87474341e-03f, 5.78331947e-02f, -5.60367964e-02f, -1.14434725e-02f, -3.28014418e-02f, 9.08675268e-02f, 5.42138405e-02f, -8.58468264e-02f, -2.37581283e-02f,
  1.44428298e-01f, -3.18126678e-02f, -1.03444323e-01f, -7.77037069e-02f, -1.19315013e-01f, 9.49779674e-02f, -1.28961116e-01f, -9.06711817e-02f, 7.89208189e-02f, 2.60822047e-02f,
  6.55548275e-02f, 2.16086600e-02f, -3.52204107e-02f, -7.97180384e-02f, 3.08207404e-02f, 1.67280942e-01f, 1.22427367e-01f, 7.13755563e-02f, -2.40998305e-02f, 3.13864984e-02f,
  6.88654855e-02f, 5.63105531e-02f, -8.59552845e-02f, 1.04310684e-01f, 2.09497567e-02f, 1.18694320e-01f, 5.69430739e-02f, 5.08766659e-02f, 8.46076608e-02f, 2.08881319e-01f,
  6.25423938e-02f, -1.37496293e-01f, 1.57879516e-01f, -6.61742836e-02f, -2.21423749e-02f, 5.53106256e-02f, 9.13181342e-03f, 2.59411573e-01f, -9.94917378e-02f, -2.30219021e-01f,
  6.83947057e-02f, -8.45465958e-02f, 5.80307767e-02f, -2.21191049e-02f, 1.76993441e-02f, -7.88889155e-02f, -7.66057074e-02f, -2.32334118e-02f, 2.12537572e-02f, 6.83522969e-02f,
  5.46838418e-02f, 1.89562172e-01f, 4.17975299e-02f, -1.55469611e-01f, -2.08111972e-01f, 3.80572653e-03f, 8.63893256e-02f, -4.67717163e-02f, -5.74670807e-02f, -8.63261074e-02f,
  -1.30184948e-01f, -1.09002389e-01f, 1.88895226e-01f, 1.47150502e-01f, 4.65668086e-03f, 3.03402841e-01f, 2.25353032e-01f, 6.56140745e-02f, -1.41621411e-01f, 1.39752969e-01f,
  2.98684657e-01f, -1.04436755e-01f, -2.03190092e-02f, 2.36060008e-01f, 8.53649601e-02f, 1.41063079e-01f, 6.50145486e-02f, 1.41151547e-01f, 2.70895898e-01f, 1.30444273e-01f,
  4.51447755e-01f, 4.66255993e-02f, 1.72129497e-02f, -2.60961771e-01f, 5.19054830e-01f, -8.51070806e-02f, -6.30990556e-03f, 1.15838163e-01f, 2.29941621e-01f, 1.66005701e-01f,
  6.49065897e-02f, -1.77472696e-01f, -1.39821962e-01f, 2.41354764e-01f, 6.77348673e-02f, -4.99719381e-02f, 3.28771882e-02f, 5.69058470e-02f, 8.79650097e-03f, -7.94135034e-02f,
  -7.89784044e-02f, 1.06217153e-02f, 9.27287489e-02f, 6.94040209e-02f, 5.19127883e-02f, 6.65152520e-02f, -9.70166922e-02f, 9.86693799e-02f, 5.80515936e-02f, -1.04960456e-01f,
  -6.04257658e-02f, 9.17447135e-02f, 2.87554022e-02f, 9.24520381e-03f, -8.70276615e-02f, 2.19260696e-02f, 3.74806635e-02f, -1.98751781e-02f, 6.32729009e-02f, 9.32384878e-02f,
  -8.36326554e-02f, -7.78254718e-02f, -2.64753997e-02f, -6.07685857e-02f, -1.05658822e-01f, 8.16438571e-02f, -1.02057189e-01f, -7.01275766e-02f, -1.00869082e-01f, 7.97039736e-03f,
  3.96627933e-02f, -6.97151944e-02f, -5.05686924e-02f, -1.03818320e-01f, 1.97194722e-02f, -5.66929169e-02f, -4.52314317e-03f, -8.47368836e-02f, -2.73313485e-02f, -8.16924050e-02f,
  3.85311544e-02f, -4.60718013e-02f, -9.63995047e-03f, 1.41981952e-02f, 6.04829490e-02f, -1.10764273e-01f, -1.73701383e-02f, 1.17378362e-01f, -1.05572715e-01f, -9.43916142e-02f,
  2.49497220e-02f, -4.77749594e-02f, -6.51120543e-02f, 6.91813752e-02f, 9.38676223e-02f, 3.42104584e-02f, 1.23496056e-01f, -3.89825366e-02f, 1.45670369e-01f, 2.82172468e-02f,
  -1.40824970e-02f, 1.63266212e-01f, -3.77580561e-02f, 5.80305681e-02f, 1.94997769e-02f, -4.62204367e-02f, -9.92243439e-02f, 3.04184482e-02f, 1.23558557e-02f, 1.24330893e-01f,
  -1.06022887e-01f, -9.14518014e-02f, -3.00316587e-02f, 9.12249759e-02f, 4.32753339e-02f, -1.11527584e-01f, 4.53642234e-02f, -1.28375888e-01f, -4.20049466e-02f, -2.85562151e-03f,
  -7.78475031e-02f, 2.64529306e-02f, -1.41481474e-01f, 1.86749659e-02f, -2.03625590e-01f, 1.05966054e-01f, -6.44362271e-02f, -9.29910690e-02f, 5.75878583e-02f, 1.23033486e-01f,
  -3.83107597e-03f, -8.52940790e-03f, 7.18987137e-02f, 1.05857365e-01f, -8.58750418e-02f, 9.96223465e-02f, 4.47312668e-02f, 1.07350178e-01f, 1.51900664e-01f, 6.47348687e-02f,
  1.45702720e-01f, 8.96827281e-02f, -1.77564293e-01f, -1.53254464e-01f, 6.26070425e-02f, 3.35313827e-02f, 1.43604532e-01f, 9.68234539e-02f, 1.91568941e-01f, 6.73922524e-02f,
  1.06447808e-01f, -7.63728342e-04f, -4.93204920e-03f, 5.31299412e-03f, 8.91296100e-03f, -4.15527038e-02f, 1.23165853e-01f, 6.77825734e-02f, 2.12943405e-01f, 3.26941535e-02f,
  8.81028734e-03f, -9.98483151e-02f, 1.76695913e-01f, 1.63259417e-01f, 5.68179674e-02f, 9.67840180e-02f, 1.17592946e-01f, 1.59361482e-01f, 1.33262470e-01f, 4.10774276e-02f,
  1.09784380e-01f, -5.10157198e-02f, 1.10159218e-01f, 1.05101809e-01f, 3.91457640e-02f, -1.10722609e-01f, -9.62644536e-03f, 5.61208427e-02f, -6.46289885e-02f, -1.05491847e-01f,
  -7.25066513e-02f, 1.87909568e-03f, -2.79643778e-02f, 3.17102224e-02f, -9.16212574e-02f, -7.24123418e-02f, -9.07519311e-02f, -3.25159803e-02f, -1.06685422e-01f, 3.70272733e-02f,
  -6.35709986e-02f, 2.77051814e-02f, 1.14549719e-01f, -6.59933910e-02f, -3.68428417e-02f, 9.37335715e-02f, 4.58086468e-02f, -6.81256354e-02f, -5.60680851e-02f, -9.38082561e-02f,
  1.46303773e-01f, -5.19468971e-02f, 1.26930490e-01f, -5.31226508e-02f, 4.04728390e-02f, -2.95755547e-02f, -1.37680862e-02f, -3.01555102e-03f, -3.62560712e-02f, -2.84786010e-03f,
  -3.03314365e-02f, -5.57553619e-02f, -3.02015953e-02f, 8.17185044e-02f, 1.43178597e-01f, 1.63567096e-01f, 1.58015609e-01f, 7.53612071e-02f, 1.12347297e-01f, -1.08065285e-01f,
  1.98467448e-01f, -1.19696960e-01f, 1.52570426e-01f, 1.17108464e-01f, 1.38439626e-01f, -1.42433256e-01f, -1.11166067e-01f, 5.14787398e-02f, -1.04537807e-01f, -9.27437916e-02f,
  -9.03994516e-02f, -1.04800031e-01f, -1.38304576e-01f, 1.09452635e-01f, 2.22988389e-02f, -8.61804113e-02f, 1.29119635e-01f, -7.26250336e-02f, 4.98559605e-03f, 1.01701483e-01f,
  3.59751023e-02f, 7.96127245e-02f, -2.25916854e-03f, 1.41501864e-02f, 5.85353598e-02f, 1.17707305e-01f, -6.60026968e-02f, -3.16565507e-03f, -3.01589333e-02f, 6.73040450e-02f,
  9.06806886e-02f, 4.13596556e-02f, 1.75435141e-01f, 2.55340375e-02f, -6.91163763e-02f, 3.95439304e-02f, 8.52750763e-02f, 7.04735443e-02f, -2.58574169e-02f, -9.26371068e-02f,
  7.00985417e-02f, 6.08921945e-02f, 1.39607042e-01f, 1.93715896e-02f, -3.59729566e-02f, -5.66325895e-02f, -2.68068854e-02f, 1.01721566e-02f, 9.68483835e-02f, -1.66506432e-02f,
  -1.16373837e-01f, 3.48092765e-02f, -9.67221260e-02f, 1.32565543e-01f, 9.20660198e-02f, 1.41897455e-01f, 3.87924351e-02f, -1.61936283e-02f, 1.52732074e-01f, 2.26103943e-02f,
  -7.65067488e-02f, 1.90563984e-02f, 8.05487856e-02f, -1.44288823e-01f, -3.20265479e-02f, 9.46598649e-02f, 4.20427695e-02f, 1.05201647e-01f, -7.07933828e-02f, 1.02240272e-01f,
  1.25901610e-01f, 2.99522616e-02f, 1.51673883e-01f, -5.11920862e-02f, 3.46352160e-02f, 7.75653869e-02f, 8.75653103e-02f, 2.17553042e-02f, -8.98322463e-03f, 5.93241164e-03f,
  5.12976274e-02f, 1.93576096e-03f, 1.82881877e-02f, -1.16059437e-01f, 5.57191782e-02f, -1.39214754e-01f, 1.16302468e-01f, -7.35471174e-02f, 2.25433502e-02f, 1.10816516e-01f,
  4.33159843e-02f, 6.14705719e-02f, -9.02722925e-02f, -1.28221765e-01f, 5.68019971e-02f, -3.52335237e-02f, 3.28916274e-02f, -1.23671003e-01f, -1.85168479e-02f, 3.90469842e-02f,
  -9.99002978e-02f, 4.21707742e-02f, 2.41583474e-02f, -5.60161993e-02f, -2.72194520e-02f, -5.94332479e-02f, 6.84936857e-03f, -5.13222665e-02f, -1.06077179e-01f, 4.18487936e-02f,
  -4.28486895e-03f, 7.22057223e-02f, 3.15243229e-02f, 6.57988563e-02f, 6.20891750e-02f, -2.49524023e-02f, 1.35421038e-01f, 9.38483402e-02f, 6.40657470e-02f, 9.58403274e-02f,
  1.71250626e-01f, -2.72764042e-02f, -6.17285222e-02f, -1.57725260e-01f, 1.89407438e-01f, 9.00081173e-02f, 6.99817687e-02f, 4.22409624e-02f, -5.37825860e-02f, 4.24176231e-02f,
  -5.56235537e-02f, 5.59363179e-02f, -2.15837210e-02f, 8.40017274e-02f, -9.22564119e-02f, -9.56741199e-02f, 7.94479158e-03f, 8.17975327e-02f, 1.10235579e-01f, 9.14997458e-02f,
  -1.18559018e-01f, -2.52170917e-02f, -1.09955810e-01f, -2.52044983e-02f, 2.05692686e-02f, 1.02473237e-01f, 9.15816948e-02f, -1.99218374e-02f, 9.29456353e-02f, -9.93222669e-02f,
  -4.20244969e-02f, 1.00674197e-01f, 5.84899187e-02f, 3.04125231e-02f, 3.15836146e-02f, -9.07633305e-02f, -8.94763470e-02f, -4.07393128e-02f, 8.74739438e-02f, 1.15373641e-01f,
  1.01330541e-01f, 2.09426973e-02f, -9.86536220e-02f, 5.71490452e-03f, 7.48949647e-02f, 6.90467134e-02f, -1.88153628e-02f, -1.54042337e-02f, -1.20955095e-01f, -1.10237926e-01f,
  3.92167307e-02f, 6.49683177e-02f, 7.70313814e-02f, -1.64403357e-02f, 9.37405303e-02f, 5.64588159e-02f, 6.56506941e-02f, 6.31569251e-02f, -4.80977893e-02f, 9.00366977e-02f,
  -1.17442727e-01f, -1.14445463e-02f, -1.18409857e-01f, 5.76171577e-02f, -7.81405494e-02f, -7.19684437e-02f, -1.06645562e-02f, -6.28301948e-02f, -5.60770333e-02f, -3.82002778e-02f,
  1.07707135e-01f, -1.22895978e-01f, -1.19911730e-01f, -1.09627709e-01f, -9.09128264e-02f, 9.35890824e-02f, -1.37989344e-02f, -7.24686682e-02f, -1.04238890e-01f, -8.46516192e-02f,
  1.61974743e-01f, 6.87624663e-02f, -9.02268514e-02f, 1.72243826e-02f, -1.24010198e-01f, 1.31492391e-01f, -3.40196714e-02f, -9.34462771e-02f, 5.50872907e-02f, 8.62258971e-02f,
  3.23894583e-02f, -2.37151142e-02f, -4.44417866e-03f, 8.35913420e-02f, -1.25696182e-01f, 6.66996539e-02f, 4.90105413e-02f, -4.53071371e-02f, -8.47284645e-02f, 1.79596711e-02f,
  1.06003664e-01f, 6.67158887e-02f, -1.48017079e-01f, 5.58405817e-02f, 3.48368213e-02f, -2.48281602e-02f, -5.73646426e-02f, -1.04937874e-01f, -8.31339657e-02f, -5.23371175e-02f,
  1.07754931e-01f, -1.41596898e-01f, -5.78242280e-02f, -9.51443836e-02f, 8.57197046e-02f, -1.14720151e-01f, -5.12354188e-02f, 1.38349935e-01f, 2.70642210e-02f, 5.84132783e-02f,
  1.10079035e-01f, 4.33672443e-02f, -1.78646997e-01f, -1.09500617e-01f, -2.57145404e-03f, -3.93480323e-02f, 2.02762127e-01f, 1.74571127e-01f, 1.42148569e-01f, 1.66049134e-02f,
  1.92965820e-01f, -1.88180983e-01f, 1.25381788e-02f, -2.38500331e-02f, 4.21145279e-03f, 5.18190712e-02f, -1.01432074e-02f, 1.70979008e-01f, 1.37280256e-01f, 2.16717839e-01f,
  8.70399997e-02f, 3.40290107e-02f, 1.19915053e-01f, -9.24592838e-02f, 1.14051931e-01f, -9.73247215e-02f, 3.41709284e-03f, 1.14116713e-01f, 6.50868565e-02f, -8.29075798e-02f,
  6.11916855e-02f, -7.09144995e-02f, 9.34149846e-02f, -1.85508281e-01f, 1.36253446e-01f, -5.30569330e-02f, -6.03939667e-02f, -7.69752190e-02f, -9.01047960e-02f, 2.20253002e-02f,
  -1.04623705e-01f, -1.03929676e-02f, 3.65336053e-02f, -1.80365592e-02f, -4.79600094e-02f, 1.02238706e-03f, -6.94365352e-02f, 4.76266257e-02f, 9.26980600e-02f, -1.52056459e-02f,
  -6.15284443e-02f, 3.07372846e-02f, -5.26084490e-02f, 5.96653856e-02f, 1.88397802e-02f, -6.86397329e-02f, 1.86675396e-02f, 2.65491568e-02f, -7.89925307e-02f, -3.77761945e-02f,
  5.52921332e-02f, 1.43768996e-01f, 1.49868000e-02f, 1.22240327e-01f, -1.40335271e-02f, -2.84449253e-02f, 1.61234692e-01f, 1.13890477e-01f, 9.26597416e-02f, 7.61250630e-02f,
  1.94334965e-02f, 1.67340577e-01f, -4.73982133e-02f, -7.73051158e-02f, -3.79715189e-02f, 2.43473649e-02f, 2.22933684e-02f, -6.07445017e-02f, 3.28213461e-02f, -7.04869330e-02f,
  -1.79993242e-01f, -1.31770805e-01f, -1.41855776e-01f, 1.97470427e-01f, -2.89421808e-02f, 4.65552136e-02f, 7.58383200e-02f, 4.99070771e-02f, 1.60129413e-01f, -3.92034799e-02f,
  2.93616168e-02f, 3.42397057e-02f, -2.96536125e-02f, -1.16851702e-02f, -2.29648463e-02f, 2.36581266e-02f, 6.89726695e-02f, -1.22171640e-01f, 8.26075226e-02f, -9.53830220e-03f,
  -3.63152735e-02f, 9.05749016e-03f, -1.59115776e-01f, -8.49978924e-02f, 4.48581250e-03f, 6.45302609e-02f, 2.01882958e-01f, 1.15468390e-01f, -1.08663112e-01f, 5.54823950e-02f,
  -8.55204612e-02f, -1.12251736e-01f, 9.57095530e-03f, 1.29228175e-01f, 9.08470675e-02f, -1.18377268e-01f, 4.95007262e-02f, 4.73385453e-02f, 1.85259972e-02f, 7.70421233e-03f,
  -3.40050901e-03f, 1.43656626e-01f, -1.07493788e-01f, 1.07272372e-01f, -1.16067044e-01f, -5.03766835e-02f, -1.04484655e-01f, -9.84174758e-02f, 3.90897393e-02f, -5.03138490e-02f,
  -8.72135758e-02f, -4.39604297e-02f, 1.71875253e-01f, -5.19597642e-02f, 2.62763649e-01f, 1.41773686e-01f, -2.79060844e-02f, -7.72761106e-02f, -1.50593922e-01f, -5.34636639e-02f,
  2.14000240e-01f, 6.10234402e-02f, 1.93883568e-01f, 1.58334360e-01f, 1.82108551e-01f, -3.28176394e-02f, -5.59385531e-02f, 1.10515349e-01f, 4.20336723e-02f, 2.56117880e-01f,
  6.75164014e-02f, 9.71725434e-02f, 1.20722674e-01f, 1.18123449e-01f, 1.40630916e-01f, 2.49394134e-01f, 1.49039239e-01f, 2.62940854e-01f, 7.51926377e-02f, -1.88371744e-02f,
  -1.45826668e-01f, 2.48139277e-01f, -2.87465993e-02f, 8.63024890e-02f, -4.09562550e-02f, -5.69623858e-02f, 3.88313949e-01f, 1.27489328e-01f, -8.51544067e-02f, -1.10001907e-01f,
  -9.18727741e-02f, -1.44320786e-01f, 4.19350192e-02f, 3.63962650e-02f, -1.05589367e-01f, -4.72683460e-02f, -1.48076519e-01f, 4.23875079e-02f, 9.87098459e-03f, 1.17172591e-01f,
  1.38485068e-02f, 1.23025104e-01f, 1.04017802e-01f, 2.99761090e-02f, 1.22396521e-01f, 6.72781691e-02f, 2.01642096e-01f, 3.17499414e-02f, 7.95585737e-02f, -3.02555300e-02f,
  2.90264964e-01f, 1.08023405e-01f, 9.21786502e-02f, 9.89236385e-02f, -3.50390598e-02f, -2.99134888e-02f, -4.86298651e-02f, 2.59292871e-02f, -1.29969493e-01f, -1.85393989e-01f,
  1.74557433e-01f, -1.14673570e-01f, 2.73038357e-01f, 1.03827417e-01f, 7.70309418e-02f, 7.72518739e-02f, -3.14634629e-02f, 1.77243739e-01f, 2.45818481e-01f, 1.76474705e-01f,
  1.75484776e-01f, 1.62734061e-01f, 5.40598333e-02f, -2.12925121e-01f, -2.94251349e-02f, 1.01136342e-01f, -7.36730546e-02f, 8.39678049e-02f, 1.20674364e-01f, 7.96872154e-02f,
  -6.07141070e-02f, 1.56641036e-01f, 1.27881721e-01f, 9.47684646e-02f, -2.52078939e-02f, -1.00153014e-02f, -4.07690592e-02f, -1.93082541e-02f, -1.29372761e-01f, 8.63891444e-04f,
  2.10298583e-01f, 5.91957616e-03f, -4.44014631e-02f, 7.64619410e-02f, 1.16514571e-01f, 7.03187808e-02f, 6.37957156e-02f, 1.18681476e-01f, 4.84275445e-02f, -3.29616331e-02f,
  -1.19050510e-01f, -8.60036612e-02f, -2.27563251e-02f, -7.37013519e-02f, -7.99069554e-02f, 6.71705604e-02f, -2.46718973e-02f, 1.75764505e-02f, -1.16057962e-01f, 1.13200903e-01f,
  -8.00353587e-02f, 8.60618353e-02f, 1.25485852e-01f, -9.71153602e-02f, 1.97561234e-01f, 3.72977704e-02f, 3.35727222e-02f, 8.86442363e-02f, 1.64056093e-01f, 6.38647750e-02f,
  9.38823000e-02f, -9.41668916e-03f, -1.53100550e-01f, -7.96402171e-02f, 1.71325535e-01f, 8.55682343e-02f, 1.96654499e-02f, -5.76279648e-02f, 2.17965078e-02f, -8.13760906e-02f,
  5.75902574e-02f, 1.36053562e-01f, 1.68278426e-01f, 2.91550090e-03f, -1.24909826e-01f, -8.55096877e-02f, -1.04492251e-02f, -3.79103422e-02f, 1.07317604e-01f, -1.13279052e-01f,
  1.10103674e-01f, 6.85313419e-02f, 6.81881681e-02f, -5.41731231e-02f, 3.76330279e-02f, 4.91519496e-02f, -5.44997603e-02f, 1.92618202e-02f, 1.71182573e-01f, -1.30299467e-03f,
  -1.09267598e-02f, -9.31314752e-02f, 4.75947075e-02f, 2.48346180e-01f, -2.53990162e-02f, -7.32666180e-02f, 1.45894624e-02f, 9.49652046e-02f, -8.23582243e-03f, -1.57951564e-01f,
  -4.78895977e-02f, -6.14862330e-02f, -1.53859630e-01f, 1.21983238e-01f, 4.70429212e-02f, 3.98327261e-02f, -2.18021840e-01f, -9.54054743e-02f, -2.23361980e-02f, -3.17554139e-02f,
  2.02560350e-01f, -7.33471736e-02f, -1.99806988e-01f, 1.36270493e-01f, 1.40704095e-01f, 1.47177950e-01f, 6.29800335e-02f, -2.61272546e-02f, 2.18850091e-01f, -8.99787992e-02f,
  2.46984482e-01f, 2.39203021e-01f, -9.53086093e-02f, -1.36953657e-02f, 2.00342312e-02f, 5.04524931e-02f, -6.29899651e-02f, -1.55408874e-01f, 1.67386457e-01f, 9.94098634e-02f,
  -1.05972430e-02f, 1.07554883e-01f, 1.15704313e-01f, -5.38827432e-03f, 1.67463884e-01f, -1.72677621e-01f, 2.60911793e-01f, -2.84435242e-01f, 2.24774584e-01f, -1.25870958e-01f,
  2.62411535e-02f, -1.45392837e-02f, 1.24318562e-02f, -1.03007704e-01f, 9.81343836e-02f, 9.76995677e-02f, -5.30923717e-02f, 4.92897108e-02f, -9.13118199e-02f, 1.60038128e-01f,
  -8.02736208e-02f, -1.06050745e-01f, -3.76217552e-02f, 2.32605711e-02f, 2.36318707e-02f, -1.21947313e-02f, 3.70348580e-02f, -5.82304187e-02f, 5.55385761e-02f, 8.65819752e-02f,
  -4.38907184e-02f, -4.46225069e-02f, 7.77476057e-02f, 1.06154546e-01f, 4.19732332e-02f, 3.46118510e-02f, -1.19507149e-01f, -9.24212858e-02f, -8.74569342e-02f, 9.02040005e-02f,
  7.83888251e-02f, 1.03172600e-01f, -8.62324163e-02f, 6.47057146e-02f, 5.25751011e-03f, -5.62957907e-03f, 7.97985494e-02f, -7.63952360e-03f, 2.81884298e-02f, -1.30522000e-02f,
  6.17697313e-02f, 1.20469265e-01f, 1.29341796e-01f, 4.65638973e-02f, -6.13004975e-02f, 4.93702814e-02f, -1.42214298e-01f, 4.79742885e-02f, -2.80583426e-02f, 1.08275801e-01f,
  2.05561489e-01f, 1.64160490e-01f, 1.31268248e-01f, -4.71912790e-03f, 1.08095542e-01f, -5.29882684e-02f, 1.98998228e-01f, 5.64804822e-02f, -6.16294481e-02f, 4.75361384e-02f,
  -4.01373804e-02f, 1.43690526e-01f, -1.41814293e-03f, 2.42382865e-02f, -6.31691441e-02f, -8.66915211e-02f, -8.22449699e-02f, -7.41123036e-02f, 7.67680481e-02f, 1.44004852e-01f,
  1.40932560e-01f, -4.96137254e-02f, 4.53038253e-02f, -3.33994552e-02f, 6.00641221e-03f, -8.20516795e-02f, 1.17164232e-01f, -1.32841263e-02f, 9.12439171e-03f, -9.45943817e-02f,
  -1.53189115e-02f, -7.36107817e-03f, -1.22621305e-01f, -7.36651197e-03f, -5.19185513e-02f, -6.84140921e-02f, 9.17128175e-02f, 1.75509807e-02f, 1.17297590e-01f, 8.10943767e-02f,
  1.03834637e-01f, -8.70155767e-02f, 6.23225681e-02f, 8.47864896e-03f, -9.37499925e-02f, 5.65735474e-02f, -1.06299438e-01f, -7.96032920e-02f, 2.93033168e-04f, 4.77881059e-02f,
  -8.14610347e-02f, 9.51241329e-02f, -2.72848308e-02f, -5.90014234e-02f, -4.33988795e-02f, -9.84056816e-02f, 2.87054442e-02f, -3.38674150e-02f, -3.01418491e-02f, 1.25786424e-01f,
  2.78709549e-02f, -7.09984973e-02f, 5.31107672e-02f, 1.16656311e-01f, 7.84950554e-02f, 4.43795398e-02f, -1.02004863e-01f, 7.12174103e-02f, -3.25514823e-02f, 1.13127023e-01f,
  -8.59853029e-02f, -1.18324190e-01f, -8.86748880e-02f, 1.38626188e-01f, 5.16769178e-02f, -4.10742387e-02f, -1.19793303e-01f, -5.78337424e-02f, -9.96006802e-02f, -2.41791569e-02f,
  -3.84351574e-02f, -1.16084717e-01f, 1.87321659e-02f, 5.08692069e-03f, -3.63722141e-03f, -6.30230755e-02f, -5.43020526e-03f, -9.13411379e-02f, 1.04947567e-01f, 4.51810807e-02f,
  8.97817314e-02f, 4.19299072e-03f, 9.98898819e-02f, -1.13211408e-01f, 4.85063009e-02f, 1.05228886e-01f, 4.90722992e-02f, 1.10231265e-01f, 9.16373059e-02f, 2.99408939e-02f,
  -7.29309097e-02f, -1.01184070e-01f, 1.77615974e-02f, -7.62162060e-02f, 1.46917641e-01f, 7.92520195e-02f, -8.95303767e-03f, 1.14387691e-01f, 6.33754134e-02f, 7.23829269e-02f,
  -1.18206911e-01f, -1.32460585e-02f, -9.69314948e-02f, 8.51603448e-02f, 4.46512029e-02f, -2.50669681e-02f, 1.21614762e-01f, 1.93515718e-02f, 4.57968935e-02f, 9.72910842e-04f,
  -2.77761668e-02f, 1.01122573e-01f, -2.80451663e-02f, 1.02431014e-01f, 9.51301157e-02f, -3.35261486e-02f, 8.40538815e-02f, -1.27965398e-02f, 6.11791871e-02f, 3.89959104e-02f,
  3.20902243e-02f, -7.70452842e-02f, 1.81603115e-02f, -5.57957441e-02f, 3.52473892e-02f, 2.98373494e-03f, 4.32687718e-03f, -1.11791790e-01f, -1.22288972e-01f, -6.74026310e-02f,
  8.85423869e-02f, -1.07020043e-01f, -9.43996198e-03f, -7.24679977e-02f, -8.75284523e-02f, 7.68138021e-02f, 6.99227601e-02f, -1.03461675e-01f, -3.93717289e-02f, 6.79817572e-02f,
  7.16139153e-02f, -1.03090845e-01f, 8.20318907e-02f, 1.50646204e-02f, -6.04219250e-02f, -8.66319910e-02f, -1.12820424e-01f, 1.23456351e-01f, -1.28342826e-02f, 1.09089203e-02f,
  -1.07434742e-01f, -4.41894215e-03f, 5.72217964e-02f, 1.24585561e-01f, 9.60960612e-02f, 1.84725672e-01f, 1.28629625e-01f, 5.69278449e-02f, -2.22636689e-03f, -3.25803608e-02f,
  1.88918978e-01f, 7.71387368e-02f, -8.10226128e-02f, 6.91334764e-03f, 2.95854341e-02f, 4.06962913e-03f, 1.69059355e-02f, -2.15344075e-02f, -8.00256208e-02f, 1.33043751e-01f,
  -3.47373858e-02f, -8.51996541e-02f, 7.01778289e-03f, 2.17200723e-02f, -9.29826051e-02f, 3.28051182e-03f, 3.87053862e-02f, 4.57401872e-02f, 3.68075483e-02f, 2.42989114e-03f,
  6.18150905e-02f, 1.36051536e-01f, -1.00914061e-01f, -4.00637053e-02f, 1.68599710e-02f, 1.53058534e-02f, -7.32795075e-02f, 6.28053471e-02f, -2.64744069e-02f, -9.93447825e-02f,
  -1.05336852e-01f, -4.67956178e-02f, 6.69710040e-02f, 8.86462722e-03f, -5.93532026e-02f, -3.72858755e-02f, 8.77387226e-02f, 1.05534911e-01f, 2.49977093e-02f, 1.49260774e-01f,
  6.66674003e-02f, 2.22687032e-02f, 9.00733545e-02f, -4.23768312e-02f, -8.07316005e-02f, -5.37441559e-02f, -1.05253398e-01f, -9.40648094e-02f, -4.30375757e-03f, -1.17323168e-01f,
  1.08988874e-01f, -3.28384824e-02f, 4.54791375e-02f, -6.37147278e-02f, -2.08333567e-01f, -6.10288233e-02f, -6.65403157e-02f, 8.82197693e-02f, 3.24977450e-02f, 4.36093062e-02f,
  4.35784571e-02f, -2.73526981e-02f, -1.30668372e-01f, -3.71176414e-02f, 1.28651068e-01f, 9.89675075e-02f, -5.99314421e-02f, 2.76006870e-02f, 2.24645976e-02f, 3.94529179e-02f,
  -3.50000821e-02f, -8.36397558e-02f, 5.93256690e-02f, 1.12120852e-01f, 8.37045982e-02f, -9.29618105e-02f, 7.05901161e-02f, 1.82935342e-01f, 7.78147653e-02f, -3.85103263e-02f,
  1.15046516e-01f, 5.78342006e-02f, -5.55019118e-02f, -6.55056676e-03f, -1.06288671e-01f, 3.42540769e-03f, 2.49411628e-01f, 9.61099938e-02f, 8.26404691e-02f, 1.15008384e-01f,
  1.20692328e-01f, 1.56245187e-01f, -3.65740322e-02f, 1.10315822e-01f, -9.66718607e-03f, -1.28896432e-02f, 1.26002133e-02f, -1.00236923e-01f, 1.00375876e-01f, 2.27695778e-01f,
  8.93072709e-02f, 1.09516233e-01f, 1.61994621e-01f, 3.14392775e-01f, 1.34556383e-01f, 1.87438995e-01f, 5.49692959e-02f, 1.81784183e-01f, 4.86750491e-02f, -1.55218923e-02f,
  6.21211752e-02f, 2.67707314e-02f, -1.84565783e-01f, 4.10232730e-02f, -5.04950732e-02f, 1.08684912e-01f, 1.28101408e-01f, 2.92949770e-02f, 2.66928166e-01f, -8.71155486e-02f,
  2.44827084e-02f, 6.82412833e-02f, 8.13385472e-03f, -2.05003768e-01f, -2.33490318e-02f, -2.04219632e-02f, -1.25843138e-01f, -7.34197721e-02f, 1.03798240e-01f, 2.21738629e-02f,
  2.77981043e-01f, 4.80273999e-02f, 1.43466100e-01f, -3.26663367e-02f, 7.15160444e-02f, 1.54736087e-01f, 1.71922028e-01f, -2.07867190e-01f, 8.91949162e-02f, -1.39921769e-01f,
  4.37424853e-02f, 1.92200601e-01f, 1.76276103e-01f, -9.95621085e-02f, -1.28786474e-01f, -1.22857548e-01f, -1.05100926e-02f, -3.59897017e-02f, -1.28172040e-01f, 1.24669313e-01f,
  -2.17440315e-02f, -2.66745463e-02f, -1.76160648e-01f, -8.40664133e-02f, 3.25130165e-01f, 2.15549693e-01f, -9.78579447e-02f, -1.07550718e-01f, 5.01663424e-02f, 5.07226288e-02f,
  2.29676515e-02f, 2.14619964e-01f, 5.08677326e-02f, 3.13904166e-01f, 2.25791574e-01f, -1.55799881e-01f, 1.91142380e-01f, 2.01288685e-01f, 6.72410503e-02f, 1.31636113e-01f,
  2.30471432e-01f, 1.36688232e-01f, 6.89337328e-02f, 9.08227861e-02f, 1.25434205e-01f, -8.93209055e-02f, -1.68431431e-01f, -8.79907310e-02f, 1.42106377e-02f, -3.85385528e-02f,
  -1.19199254e-01f, -1.86452687e-01f, 1.53782263e-01f, 6.33014143e-02f, 4.87370230e-02f, 2.37415042e-02f, 1.95617136e-02f, 2.39116073e-01f, 7.28795975e-02f, 2.84338575e-02f,
  2.96100248e-02f, 9.41009447e-02f, 2.44645044e-01f, 2.17779666e-01f, 5.99821471e-02f, -6.87015727e-02f, 3.05435061e-02f, 1.01285383e-01f, 1.36581317e-01f, 6.05589375e-02f,
  -7.38961771e-02f, -1.95922032e-02f, -4.68925200e-02f, 1.02224216e-01f, -9.77928191e-02f, -7.26985857e-02f, -2.18047485e-01f, 9.76776406e-02f, 5.89491688e-02f, -1.65268987e-01f,
  3.92487884e-01f, 8.32502022e-02f, 1.12581521e-01f, 5.71685750e-03f, 1.56457067e-01f, 3.98597494e-02f, -1.30448639e-01f, 2.65887342e-02f, 1.70555592e-01f, 2.53805164e-02f,
  -9.05604437e-02f, 8.67638215e-02f, -9.85230356e-02f, 2.09080756e-01f, -5.61547652e-02f, -2.10054079e-03f, -8.07454288e-02f, -3.67437154e-02f, -1.41196176e-01f, 2.55098015e-01f,
  1.06496729e-01f, 6.57049417e-02f, 1.22063095e-02f, 7.61781409e-02f, 1.49740567e-02f, 2.53119022e-02f, -1.14047945e-01f, -6.70345798e-02f, -8.73070583e-03f, -1.11623406e-01f,
  1.86788514e-02f, -1.81648917e-02f, -4.97516850e-03f, 5.46680279e-02f, -7.22483471e-02f, 3.94191258e-02f, 1.39764637e-01f, 3.84022593e-02f, 8.58454704e-02f, -1.68606080e-02f,
  -1.35759693e-02f, 2.01268032e-01f, -2.36329399e-02f, -9.57801640e-02f, 6.38972409e-03f, 4.40272763e-02f, 2.19980121e-01f, -1.07032806e-02f, -5.19896708e-02f, 1.00455225e-01f,
  -1.19353220e-01f, -1.46453474e-02f, 6.83738366e-02f, 1.54029187e-02f, -1.03128925e-01f, -2.20838226e-02f, -1.28649235e-01f, 5.87054342e-02f, -5.33330142e-02f, 9.19024572e-02f,
  -4.64059822e-02f, 4.41580303e-02f, 5.15832640e-02f, -4.55772839e-02f, 1.86505154e-01f, 8.02170299e-03f, -2.99342796e-02f, -4.56471108e-02f, 4.86099049e-02f, 1.74678341e-01f,
  2.27825847e-02f, 8.97952542e-02f, -3.99763323e-02f, 6.68373145e-03f, -2.66867727e-02f, -1.21808752e-01f, 5.41357063e-02f, 1.27067506e-01f, -4.80801351e-02f, 1.08026057e-01f,
  -1.52836353e-01f, 1.02466062e-01f, -4.68132794e-02f, 1.06720747e-02f, 7.40829483e-02f, -9.76825356e-02f, 9.95812714e-02f, 1.20947205e-01f, 2.95321625e-02f, 9.63283554e-02f,
  5.02119586e-03f, -2.42907014e-02f, -4.35646586e-02f, -5.33588082e-02f, 1.64542332e-01f, -1.65407553e-01f, 3.59701551e-02f, 9.55489501e-02f, 1.53233707e-01f, -1.05739109e-01f,
  -2.03298658e-01f, 1.00081965e-01f, -7.05899969e-02f, 1.55409705e-02f, 2.01166794e-01f, 3.85801286e-01f, 2.77149919e-02f, 9.56970230e-02f, 6.18002713e-02f, 3.11891995e-02f,
  2.21692368e-01f, 3.90652008e-02f, -1.66872758e-02f, -5.47203049e-02f, 1.57024292e-03f, -9.04068947e-02f, 4.91572171e-02f, -2.04157103e-02f, 1.35595813e-01f, 2.54430585e-02f,
  -1.28841884e-02f, -1.10036686e-01f, -1.49860620e-01f, 2.34922711e-02f, -7.14903995e-02f, 7.26563856e-02f, -1.14919245e-02f, -1.00256056e-01f, 2.19218686e-01f, 1.32783264e-01f,
  1.20445468e-01f, 2.85299215e-02f, 1.78999454e-01f, 2.18959644e-01f, 2.06498221e-01f, 1.24718696e-02f, -1.60207808e-01f, -1.41930476e-01f, 5.00490107e-02f, 6.50537685e-02f,
  -2.17852313e-02f, 1.87262192e-01f, 1.28510654e-01f, 2.03928232e-01f, -1.18048452e-01f, -4.07302454e-02f, 1.66781135e-02f, 3.88763517e-01f, -9.26897377e-02f, 9.20153037e-02f,
  -4.98008803e-02f, -4.26948294e-02f, -1.19170070e-01f, 7.78587759e-02f, -9.76282507e-02f, -3.57347205e-02f, -3.50066982e-02f, -1.04775183e-01f, -7.25347102e-02f, -3.27424109e-02f,
  -7.74416625e-02f, 3.94774191e-02f, 1.40246034e-01f, 1.87367201e-01f, -3.48277539e-02f, 7.71304667e-02f, 2.58029392e-03f, 6.12292700e-02f, 1.20741926e-01f, -2.39287317e-02f,
  1.04255721e-01f, -9.68962312e-02f, 1.01315230e-02f, -4.15395796e-02f, 1.37938097e-01f, -9.04675201e-02f, -9.24086273e-02f, -6.31574020e-02f, -9.99226421e-02f, -1.12535663e-01f,
  -1.32014202e-02f, 2.37355661e-02f, 7.22702667e-02f, -7.41469637e-02f, 9.91332754e-02f, 1.60699349e-03f, 2.75590867e-02f, -5.63251339e-02f, 2.68731676e-02f, -7.25319311e-02f,
  8.31451714e-02f, 1.32079311e-02f, -1.31008640e-01f, -1.45612918e-02f, -2.00373512e-02f, 1.60273388e-01f, -1.45810261e-01f, -6.78035170e-02f, -7.34518617e-02f, -9.68103483e-02f,
  -8.89460295e-02f, 1.64678350e-01f, 5.87620325e-02f, 1.15025699e-01f, -8.95632878e-02f, 5.89222610e-02f, -1.48562640e-01f, 6.77658096e-02f, -1.03669398e-01f, 1.40653566e-01f,
  3.09502836e-02f, -3.04569062e-02f, 2.79648248e-02f, 3.37943956e-02f, 4.23604846e-02f, -7.99279753e-03f, -4.42490466e-02f, -1.13224924e-01f, -6.92934496e-03f, -1.17807299e-01f,
  1.00506648e-01f, -6.73998371e-02f, -9.86171886e-02f, 6.99428841e-02f, -4.89691161e-02f, -5.53216599e-02f, 6.77551627e-02f, -3.43540311e-02f, -9.07028466e-02f, -2.44493913e-02f,
  -6.56897873e-02f, -8.66664350e-02f, 1.65422410e-02f, 5.00740111e-02f, -1.20242029e-01f, -1.07756115e-01f, -6.16709217e-02f, -2.98131648e-02f, 1.98139399e-02f, -2.81823426e-02f,
  9.96952597e-03f, 1.79953931e-03f, -6.71572834e-02f, 7.35095441e-02f, -8.89052600e-02f, 6.39406324e-04f, -1.07767627e-01f, 1.05055518e-01f, -9.96256154e-03f, -1.24514222e-01f,
  7.82059580e-02f, 7.19627291e-02f, 9.22200531e-02f, -2.50771027e-02f, 1.13735534e-01f, -2.95752548e-02f, -1.18544310e-01f, 6.00974821e-02f, -6.95950910e-02f, 1.05164990e-01f,
  5.13369255e-02f, -1.06318012e-01f, -6.54747486e-02f, -6.39554337e-02f, -2.22170744e-02f, -1.18998766e-01f, -3.98166962e-02f, 8.31438899e-02f, -1.21403448e-01f, -2.32814569e-02f,
  1.15871713e-01f, -1.18134856e-01f, -5.22089526e-02f, 4.64863591e-02f, 9.24576148e-02f, -5.02115153e-02f, 1.90275125e-02f, -5.78004643e-02f, 1.12363353e-01f, -1.16451368e-01f,
  -1.10593274e-01f, 6.02712482e-03f, 2.38757823e-02f, -1.82338990e-03f, -3.11086737e-02f, 1.15495265e-01f, 1.02618568e-01f, 3.51436138e-02f, -3.89300063e-02f, -7.88957439e-03f,
  -1.10709958e-01f, 3.81846055e-02f, -7.81277269e-02f, 6.34177774e-02f, -1.04379155e-01f, -4.00234908e-02f, 1.14875615e-01f, 6.79032430e-02f, -1.55984685e-02f, -3.09141260e-02f,
  -6.16294565e-03f, -7.97713995e-02f, -2.26527974e-02f, 5.70330136e-02f, 3.02250981e-02f, -8.98517147e-02f, -6.13936894e-02f, -2.41407715e-02f, -1.20244160e-01f, -7.38337487e-02f,
  -9.96527076e-02f, 1.06238395e-01f, 7.47400895e-02f, -4.70940806e-02f, 1.56967025e-02f, -5.97951980e-03f, -4.67282087e-02f, -1.13258459e-01f, 9.35119092e-02f, -7.98210576e-02f,
  5.46716750e-02f, 7.81316012e-02f, -6.35607317e-02f, 6.57698885e-02f, -1.20320469e-01f, 7.43983537e-02f, -9.60785598e-02f, 6.01545013e-02f, 2.83455066e-02f, -5.69889359e-02f,
  -4.98881638e-02f, -6.66302769e-03f, 1.13193832e-01f, 1.17716819e-01f, -2.12993547e-02f, 7.23970681e-02f, -1.26730099e-01f, -1.22673266e-01f, -1.21444725e-02f, 3.86123220e-03f,
  7.43091777e-02f, 8.79150480e-02f, 2.19112299e-02f, 3.41199450e-02f, -4.85264026e-02f, 5.39904349e-02f, -9.20681134e-02f, 1.80216685e-01f, -2.90804747e-02f, -1.08243212e-01f,
  7.16362745e-02f, 5.06940298e-02f, -1.19082049e-01f, 1.08423397e-01f, -4.29908670e-02f, -5.13036735e-02f, -1.86668381e-01f, -7.28811771e-02f, 6.34126142e-02f, -9.80864987e-02f,
  1.31314859e-01f, 1.74164698e-01f, 1.01991273e-01f, 5.67036644e-02f, -1.73866406e-01f, -7.30984658e-02f, 4.54486534e-02f, 9.17683318e-02f, -1.21557685e-02f, 5.35624884e-02f,
  8.23293999e-03f, 9.89743546e-02f, 4.52617072e-02f, 8.52966756e-02f, 1.46798760e-01f, -6.43847659e-02f, 1.10127769e-01f, 3.48687917e-02f, -2.08217781e-02f, 1.62505329e-01f,
  7.56022856e-02f, 4.32430543e-02f, -5.65530770e-02f, 4.43125702e-02f, -1.25639990e-01f, -7.85044506e-02f, 9.76900905e-02f, 8.78639054e-03f, 1.80911317e-01f, 1.03467412e-01f,
  2.09126621e-02f, 5.35509773e-02f, 5.20770252e-03f, -1.44583642e-01f, 1.58909857e-01f, 9.64761712e-03f, -5.34855127e-02f, -5.10606021e-02f, 1.15123391e-01f, -1.53786605e-02f,
  1.60279855e-01f, 1.10693753e-01f, 1.85629293e-01f, 1.57558471e-01f, 7.96043575e-02f, 1.51696475e-02f, 2.10080743e-02f, 9.29332003e-02f, 1.48712710e-01f, 1.38379365e-01f,
  2.32087914e-02f, 1.33250281e-01f, -4.08621430e-02f, 8.40272680e-02f, -1.15365066e-01f, -7.94212520e-03f, 6.02927757e-04f, 1.04337908e-01f, 8.68014917e-02f, -8.76337010e-03f,
  1.55464694e-01f, 2.22416259e-02f, 1.14743419e-01f, -2.73331702e-02f, 1.97450276e-02f, -1.15096778e-01f, 5.33154234e-02f, 2.56719124e-02f, 1.45815045e-03f, -9.84910280e-02f,
  -4.26857360e-02f, 7.19984947e-03f, 2.03269467e-01f, -6.25029355e-02f, 1.58831879e-01f, -4.55461182e-02f, -1.89629551e-02f, 1.10907048e-01f, 6.92735016e-02f, -6.75462233e-03f,
  4.93307635e-02f, 4.49043997e-02f, -1.92374717e-02f, 2.21182600e-01f, 1.19255088e-01f, 2.10743658e-02f, -1.65197521e-01f, -3.27703618e-02f, -1.65830716e-01f, -9.75996628e-02f,
  -7.83078671e-02f, 6.70763403e-02f, 1.18834223e-03f, 1.22279726e-01f, 7.58123621e-02f, 8.20481479e-02f, 5.47186956e-02f, -1.33315563e-01f, -8.08506161e-02f, 1.04324721e-01f,
  -1.13780335e-01f, 3.18581536e-02f, -3.68868969e-02f, -7.74205197e-03f, 2.64219958e-02f, 2.38953605e-01f, 5.48305102e-02f, 8.03464185e-03f, -1.21461250e-01f, 7.99241439e-02f,
  1.06560163e-01f, -6.63118362e-02f, -1.11859865e-01f, -4.50879037e-02f, -1.16505414e-01f, 9.30783823e-02f, 3.83803323e-02f, -4.48968187e-02f, 7.67451618e-03f, 1.67874387e-03f,
  1.10656187e-01f, 7.84698650e-02f, 2.96437778e-02f, 8.26965943e-02f, -5.19461334e-02f, 2.51071118e-02f, 6.02035411e-02f, 6.43873215e-02f, -1.33376867e-01f, 1.36910200e-01f,
  9.55513194e-02f, 5.58601506e-03f, 9.44604352e-02f, 6.30988404e-02f, 7.45592564e-02f, 8.20582733e-02f, 9.73234177e-02f, -3.23819965e-02f, -8.44620317e-02f, -4.45741601e-02f,
  1.11907400e-01f, -6.97520077e-02f, 1.84666347e-02f, 8.46251473e-02f, -2.47871410e-02f, 1.03633702e-01f, -8.22406337e-02f, -1.43380135e-01f, 6.03113100e-02f, -8.73474181e-02f,
  -1.39037237e-01f, 3.62313502e-02f, 1.61804065e-01f, -9.95616093e-02f, -4.51379642e-02f, 8.29344541e-02f, -9.30509239e-04f, 3.04156952e-02f, 1.88979372e-01f, 1.15621902e-01f,
  -3.02441102e-02f, -6.48333728e-02f, 4.79838848e-02f, 1.23329796e-01f, -5.33659607e-02f, 1.70927033e-01f, -9.09606665e-02f, 1.51760265e-01f, 6.59841448e-02f, -1.50357500e-01f,
  -5.35118803e-02f, 8.57905820e-02f, 7.39188045e-02f, 1.42647669e-01f, 9.58266035e-02f, 1.23920761e-01f, 2.11311594e-01f, 1.57210037e-01f, -1.16497360e-01f, 9.58083123e-02f,
  1.68848969e-03f, 8.91891718e-02f, 1.36508763e-01f, -2.26400539e-01f, 1.43848062e-02f, -2.08866317e-02f, -3.10472418e-02f, 1.68469056e-01f, -4.69557792e-02f, -1.09448940e-01f,
  -1.09485663e-01f, 9.63878632e-02f, 1.82883143e-01f, -7.51299039e-02f, 6.72720894e-02f, 7.33527914e-02f, -3.51383612e-02f, -1.10516744e-02f, 1.80199370e-01f, 1.70509040e-01f,
  1.36932597e-01f, 1.30432308e-01f, 1.95105851e-01f, -3.84245180e-02f, 1.79401740e-01f, 5.56954835e-03f, -7.77181983e-02f, -5.38083129e-02f, -7.96712935e-02f, 8.79892036e-02f,
  9.84470695e-02f, 7.02917129e-02f, 8.51183385e-02f, 4.38952930e-02f, 2.10958257e-01f, -3.94678265e-02f, 2.21534580e-01f, -3.53330746e-03f, -1.81100350e-02f, 1.64499506e-01f,
  1.16720125e-01f, 2.23834574e-01f, -1.93011045e-01f, -1.32850241e-02f, 2.48387620e-01f, 1.68749645e-01f, -2.40768373e-01f, 5.94613217e-02f, 4.24831100e-02f, -2.34926697e-02f,
  -1.83955058e-02f, -6.89042956e-02f, -4.86699119e-02f, 3.17995816e-01f, 5.83716780e-02f, -5.42504154e-02f, 7.29509164e-03f, -4.03215326e-02f, 1.09708861e-01f, 9.67678204e-02f,
  4.96452190e-02f, 1.16196290e-01f, 1.57078374e-02f, 6.27980605e-02f, 1.12715423e-01f, 9.39480066e-02f, -9.82663631e-02f, -3.04994993e-02f, 1.86106861e-02f, -4.84691374e-02f,
  -1.25329390e-01f, -8.94213244e-02f, 2.53605187e-01f, 7.33600929e-02f, 7.08090933e-03f, -6.07470691e-04f, -2.78049279e-02f, -1.70833960e-01f, 1.05795208e-02f, 2.86411587e-02f,
  1.13820165e-01f, 9.23126489e-02f, -4.66820337e-02f, -1.16507094e-02f, 1.59104332e-01f, -6.06754422e-02f, 1.50543794e-01f, 7.75271654e-03f, 9.52441618e-02f, -2.51852609e-02f,
  8.58317409e-03f, -5.12546189e-02f, 3.63600180e-02f, -2.65510771e-02f, 2.93090753e-02f, -6.18606657e-02f, 1.61071084e-02f, 1.04996450e-01f, -7.64887333e-02f, 4.20517772e-02f,
  1.71331931e-02f, 4.80640605e-02f, -9.39163789e-02f, -1.23042487e-01f, 3.84009443e-02f, 4.75308970e-02f, -7.30754659e-02f, 9.13289189e-02f, 2.03931078e-01f, 1.56655625e-01f,
  1.15874551e-01f, 6.29949942e-02f, -1.27473012e-01f, -2.25708801e-02f, 1.08647943e-01f, -5.67602590e-02f, 6.58483291e-03f, 1.58463284e-01f, -1.21475697e-01f, -1.02138825e-01f,
  3.54668754e-03f, -5.65315299e-02f, 7.03219650e-03f, -3.14894691e-02f, -4.28812429e-02f, -9.08067450e-02f, -1.13974728e-01f, 1.56474650e-01f, -1.40948623e-01f, -1.28233561e-03f,
  4.47964519e-02f, -1.06539153e-01f, -2.88221929e-02f, 4.39659841e-02f, -2.64123883e-02f, -1.38799036e-02f, -2.57491440e-01f, 1.00825295e-01f, -1.05026305e-01f, -7.33309016e-02f,
  -9.14281905e-02f, 1.96404550e-02f, 6.66947290e-02f, -1.27889499e-01f, -8.61745968e-04f, 8.42865258e-02f, 1.29285187e-01f, 4.16272208e-02f, -1.52891010e-01f, -7.98446462e-02f,
  -3.55564542e-02f, 5.92980608e-02f, 1.26100466e-01f, -1.36089250e-01f, 5.91023418e-05f, 6.22612908e-02f, 1.96326613e-01f, 7.71184489e-02f, -1.05039775e-01f, 5.71967214e-02f,
  2.20710531e-01f, 4.48013954e-02f, 5.85433505e-02f, 1.44137904e-01f, -8.77749845e-02f, 2.37157792e-02f, -1.56887457e-01f, 1.64625689e-01f, 2.03487411e-01f, 1.04121372e-01f,
  8.08070600e-02f, -1.07281722e-01f, 1.59254596e-01f, -3.58585678e-02f, 4.41233292e-02f, 5.52805290e-02f, 8.20975006e-02f, -1.28822550e-01f, 2.10560605e-01f, -9.91743058e-02f,
  2.52712905e-01f, 2.22480953e-01f, 1.50930658e-01f, 1.34819210e-01f, -6.30394295e-02f, 1.11125134e-01f, -9.23224017e-02f, -1.20295901e-02f, 3.92299853e-02f, 4.85509746e-02f,
  -1.19784199e-01f, -1.39826879e-01f, 7.63254389e-02f, 1.13087334e-01f, -6.44137412e-02f, 7.93849118e-03f, -9.83441770e-02f, 6.25453219e-02f, 5.05241193e-02f, 4.03063819e-02f,
  -8.36607888e-02f, -2.89042704e-02f, 7.52553567e-02f, -5.14398180e-02f, 7.94162527e-02f, 1.49366111e-01f, -8.60837996e-02f, -2.41189897e-02f, 9.67442170e-02f, 7.74824843e-02f,
  -3.09879631e-02f, 1.00521840e-01f, 8.12743679e-02f, 1.07709870e-01f, 7.41134807e-02f, 1.12283289e-01f, -3.26016620e-02f, -1.49797983e-02f, 9.91547853e-02f, 5.52614182e-02f,
  -3.91706266e-02f, -1.10751219e-01f, -9.53606069e-02f, -4.47198637e-02f, 3.13644372e-02f, -3.37567478e-02f, -3.52936946e-02f, 4.87545580e-02f, 1.61885079e-02f, 3.73851955e-02f,
  -2.43541766e-02f, -6.92022070e-02f, 9.41166058e-02f, 3.41598354e-02f, 5.74042760e-02f, 6.12142775e-03f, 1.71933230e-02f, 1.03138901e-01f, -6.57157600e-02f, 2.41976399e-02f,
  1.08380347e-01f, -4.91445437e-02f, -1.11619867e-01f, -3.25579420e-02f, -3.94889079e-02f, -3.84936519e-02f, -9.17997658e-02f, 9.35111120e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -8.32643211e-02f, 1.23837188e-01f, 4.16217521e-02f, 1.74567565e-01f, 1.33371530e-02f, 2.69011050e-01f, 1.84000712e-02f, -4.15570885e-02f, -8.66224431e-03f, 1.58511847e-01f,
  -8.81537199e-02f, 1.35736898e-01f, -1.14558704e-01f, 7.09991232e-02f, 4.66646277e-04f, 6.56031072e-02f, 7.83694535e-02f, -3.57160456e-02f, -9.38424096e-02f, -5.85466176e-02f,
  -5.45023866e-02f, -4.42417599e-02f, 1.28758237e-01f, 1.18897587e-01f, 9.28972512e-02f, 6.16648979e-02f, -2.22004130e-02f, 1.29387781e-01f, 6.18146919e-02f, -8.36589038e-02f,
  1.07129179e-01f, 6.95458706e-03f, 1.29944488e-01f, 1.27430752e-01f, 4.17286269e-02f, -1.34318473e-03f, 6.30924478e-02f, 2.07450353e-02f, 1.07606679e-01f, 1.02192469e-01f,
  7.16456398e-02f, 1.02183081e-01f, 9.17137563e-02f, 2.32555512e-02f, -6.43554777e-02f, 1.41604722e-01f, -2.57750656e-02f, -3.89748327e-02f, 1.59708560e-01f, 9.96822193e-02f,
  9.51409265e-02f, -6.60925359e-02f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -4.14109118e-02f, 4.00458388e-02f, 1.22267880e-01f, -1.16952471e-01f, 1.21081240e-01f, 7.42588714e-02f, 2.35288754e-01f, 3.57510373e-02f, 8.32459852e-02f, 1.53982326e-01f,
  -4.70225997e-02f, 5.96462972e-02f, -1.16315030e-01f, 4.82407622e-02f, 6.14710432e-03f, 7.61508942e-02f, 1.31595433e-01f, -1.39576718e-01f, -8.40418413e-02f, -1.14989959e-01f,
  -1.45211695e-02f, -1.63392752e-01f, 8.91053583e-03f, 9.64176655e-02f, -9.37334169e-03f, 8.66658539e-02f, -1.04585484e-01f, 2.30098560e-01f, -1.13470601e-02f, 1.09582581e-01f,
  -8.56347084e-02f, 1.07151056e-02f, -7.19586015e-02f, -1.10538214e-01f, -1.03657104e-01f, -1.22081749e-01f, 5.03569655e-03f, 1.00127541e-01f, -1.09254986e-01f, -6.96120560e-02f,
  2.76529379e-02f, -4.70230654e-02f, -1.65223535e-02f, -1.25323668e-01f, -2.26859003e-01f, 1.04465045e-01f, 8.68312493e-02f, -1.04639463e-01f, 5.43420650e-02f, 8.75850394e-02f,
  -6.12587593e-02f, 2.46700287e-01f, 7.41533712e-02f, 1.38436615e-01f, -1.66876256e-01f, 4.76682447e-02f, 1.17287794e-02f, -1.30469307e-01f, 1.21873468e-01f, 4.14136425e-02f,
  9.50828195e-02f, 1.20966695e-01f, -1.08062714e-01f, 1.09373376e-01f, -9.52921137e-02f, -5.16491234e-02f, 6.11923561e-02f, 1.01363204e-01f, 4.71740924e-02f, 2.11779878e-01f,
  -4.26402502e-02f, 1.17241889e-01f, -7.82009736e-02f, 6.48445487e-02f, -1.83913738e-01f, 5.72757162e-02f, -3.38435248e-02f, 2.20270194e-02f, -2.85960222e-03f, -2.20156550e-01f,
  1.65452957e-01f, 1.87577866e-02f, -6.23717494e-02f, 1.65621981e-01f, -4.76627089e-02f, -2.90835891e-02f, 8.82386640e-02f, -6.92644343e-02f, 6.71847761e-02f, 7.56983878e-03f,
  2.78501548e-02f, 1.72535464e-01f, 1.21710852e-01f, 1.43572137e-01f, 5.75368591e-02f, 1.10646047e-01f, 1.80434883e-02f, -8.17929804e-02f, -3.82997934e-03f, -1.15104154e-01f,
  -1.63098484e-01f, 1.56118413e-02f, 3.19688729e-06f, 1.19472086e-01f, -1.40389040e-01f, 1.66736707e-01f, -2.23374337e-01f, -1.94800317e-01f, -5.26478291e-02f, 7.88085014e-02f,
  9.38077867e-02f, 3.56780961e-02f, 4.51531680e-03f, 5.81547581e-02f, -1.32071003e-01f, -1.36977866e-01f, 7.61499107e-02f, 2.55470395e-01f, -1.43667206e-01f, 3.93874757e-02f,
  5.59048206e-02f, 6.67696819e-02f, -1.22419782e-01f, 1.28009394e-01f, -2.45737821e-01f, -1.82310417e-01f, 1.54018432e-01f, 6.63159788e-02f, -2.32162122e-02f, -1.32053435e-01f,
  -1.51833162e-01f, -2.47456934e-02f, 2.11859625e-02f, -6.70351908e-02f, -1.07193857e-01f, 1.72884285e-01f, -1.14867873e-01f, -6.93362653e-02f, -1.35230854e-01f, -1.19429052e-01f,
  9.37411860e-02f, 6.78348988e-02f, 5.91945201e-02f, -3.90355475e-02f, 2.12618932e-01f, -6.64826930e-02f, 5.36591141e-03f, 1.16436295e-01f, -2.28307880e-02f, 6.22924529e-02f,
  8.11395142e-03f, -1.27444431e-01f, 4.84197885e-02f, 2.67702118e-02f, 8.94705504e-02f, -1.30602211e-01f, 1.53175414e-01f, -1.79432377e-01f, 1.16675878e-02f, 1.22575544e-01f,
  1.52071267e-01f, 7.59720281e-02f, -4.00377531e-03f, -8.04229081e-02f, 1.50323614e-01f, 1.30832881e-01f, -4.77250740e-02f, 4.72401418e-02f, -1.30103063e-02f, -1.00861430e-01f,
  -7.70559683e-02f, 3.63201229e-03f, -5.15232235e-02f, -2.37554703e-02f, 7.35029252e-03f, 1.12778306e-01f, 1.32659689e-01f, -2.48408616e-02f, -2.11868569e-01f, -3.09637263e-02f,
  1.70166343e-02f, 8.94221067e-02f, 9.63179097e-02f, -1.12142712e-01f, 3.97661589e-02f, -1.67390276e-02f, -1.07481368e-01f, 1.58615291e-01f, -4.85534631e-02f, -1.40928209e-01f,
  1.79689705e-01f, 9.13166441e-03f, 3.93955633e-02f, -6.34270236e-02f, 1.28995180e-01f, 8.22937191e-02f, -1.12372898e-01f, -8.87487829e-02f, -5.19764721e-02f, 2.10758120e-01f,
  2.10472569e-02f, -5.99283278e-02f, -1.62590936e-01f, -1.44876391e-01f, 7.11872876e-02f, -2.21115686e-02f, -2.95802616e-02f, 1.43130213e-01f, -1.25683760e-02f, 9.15769339e-02f,
  -3.16262357e-02f, -6.13514856e-02f, -1.15255062e-02f, 9.43866000e-02f, 9.40932482e-02f, -8.54254737e-02f, -3.86367887e-02f, -3.73586058e-03f, -4.85762917e-02f, 8.61929953e-02f,
  2.91256309e-01f, -2.61310875e-01f, 1.20110810e-01f, -5.90918511e-02f, 2.05767900e-02f, 3.22004631e-02f, 5.65558895e-02f, 8.04875642e-02f, -1.64560869e-01f, -9.83455554e-02f,
  3.94498967e-02f, -1.39150796e-02f, -1.43144906e-01f, 2.98611410e-02f, 1.22625858e-01f, 6.31878227e-02f, 7.18495920e-02f, -6.71771839e-02f, 7.80028403e-02f, -9.44512039e-02f,
  -6.58367723e-02f, -3.67954783e-02f, -1.14347301e-01f, -1.21340156e-02f, -6.29167855e-02f, -1.06131636e-01f, -6.48318008e-02f, 6.76500574e-02f, 4.14723158e-02f, -1.42316436e-02f,
  7.54985362e-02f, 4.68783565e-02f, -1.22409627e-01f, -3.78742330e-02f, -1.13164730e-01f, -1.23422615e-01f, -6.05457909e-02f, -1.59098968e-01f, -3.14527005e-02f, 6.35485724e-02f,
  -7.65445903e-02f, -2.60615826e-01f, -8.00951794e-02f, -2.35942677e-02f, -2.89870888e-01f, -2.20891550e-01f, 1.10851593e-01f, -5.69652952e-02f, -7.29470253e-02f, -1.33095503e-01f,
  -1.03449278e-01f, 2.76552234e-02f, 3.67300138e-02f, -1.59657344e-01f, 1.45775810e-01f, 1.12715483e-01f, 6.24321252e-02f, 1.33757696e-01f, -7.82597065e-02f, -6.29634038e-02f,
  -3.07277534e-02f, 1.04896203e-01f, -5.91280833e-02f, 9.80811566e-02f, 8.79562870e-02f, -2.09566981e-01f, -9.40417051e-02f, -2.45929677e-02f, 1.95198596e-01f, 1.01364322e-01f,
  -4.35534567e-02f, -1.09005675e-01f, 6.00803308e-02f, 9.66240242e-02f, -9.38862488e-02f, -1.59157634e-01f, -9.83749144e-03f, -2.02312693e-02f, 4.68275733e-02f, 1.75414652e-01f,
  2.65541852e-01f, -1.51304364e-01f, -6.50552362e-02f, -2.49805134e-02f, 5.26441224e-02f, 1.13690116e-01f, -2.29947999e-01f, -8.51880237e-02f, 2.48613507e-02f, -9.49718710e-03f,
  5.41503504e-02f, 5.71777485e-02f, -1.18845537e-01f, 2.43920577e-03f, -8.89333412e-02f, -3.55780981e-02f, -1.67149201e-01f, -9.90268365e-02f, 6.39481917e-02f, 2.72074360e-02f,
  2.17214506e-02f, -8.61300975e-02f, 8.68653506e-02f, -4.07010354e-02f, -1.50561044e-02f, -2.07735822e-02f, 7.11515322e-02f, 5.94438277e-02f, -1.69349611e-01f, -1.61381990e-01f,
  -7.43228048e-02f, 6.64677620e-02f, -1.11075468e-01f, -6.36202544e-02f, -9.20941979e-02f, -2.61372235e-02f, 1.48340032e-01f, -1.51336282e-01f, 3.90232392e-02f, 4.16583084e-02f,
  -4.98421490e-02f, -7.33693987e-02f, 8.73248279e-02f, -1.48228213e-01f, -5.13041578e-02f, -7.17608184e-02f, -6.45861179e-02f, -1.24719441e-01f, 2.00939588e-02f, -5.30168600e-02f,
  -1.39195304e-02f, -8.43082815e-02f, 2.23773360e-01f, -3.46903093e-02f, 9.06735063e-02f, 4.11176719e-02f, 1.25309259e-01f, 2.11075339e-02f, 1.06590807e-01f, 6.42733052e-02f,
  1.59435749e-01f, 1.16403908e-01f, -6.15548082e-02f, -8.57482627e-02f, -4.97670248e-02f, 1.60686560e-02f, 9.99702290e-02f, 1.06434368e-01f, -3.83353233e-02f, 4.27785404e-02f,
  2.38821339e-02f, -7.79606774e-02f, 5.24402484e-02f, 1.66633606e-01f, -2.89506279e-03f, -5.87485842e-02f, -9.53556132e-03f, -1.28058502e-02f, -4.55817766e-02f, -5.93715161e-02f,
  -1.12177357e-01f, -1.18728183e-01f, 1.86993346e-01f, -6.37778565e-02f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -1.34591982e-01f, 3.45453098e-02f, -3.81979719e-02f, -7.43953586e-02f, -1.05982363e-01f, -7.47500956e-02f, 8.43018945e-03f, 7.81016946e-02f, -1.15022175e-01f, -1.31851330e-01f,
  6.46048784e-02f, 8.32020044e-02f, -3.50253023e-02f, 1.55380480e-02f, -5.09391651e-02f, 2.07910221e-02f, -3.57400365e-02f, 5.70418239e-02f, 4.50449344e-03f, 1.08843543e-01f,
  -2.48794518e-02f, 7.85128102e-02f, -6.97264299e-02f, -6.39218539e-02f, -8.93910751e-02f, -9.41164494e-02f, -3.38205546e-02f, -7.24798217e-02f, -1.28857559e-02f, 5.73100187e-02f,
  8.71657804e-02f, -4.19007875e-02f, 1.51208356e-01f, 1.95484771e-03f, -8.17729831e-02f, -8.89822748e-03f, 6.19916134e-02f, -1.17895864e-01f, 2.95329839e-02f, -3.49046849e-02f,
  8.99107847e-03f, 1.08145557e-01f, -1.34903401e-01f, 3.04650106e-02f, 1.36562854e-01f, 4.12850641e-02f, -4.48036380e-02f, 1.22890256e-01f, 1.00790136e-01f, -2.49345489e-02f,
  -3.62600461e-02f, -1.18360475e-01f, -4.68312874e-02f, -7.37295151e-02f, 2.76663806e-02f, 3.28648239e-02f, -7.42431059e-02f, -4.37181406e-02f, -3.75036597e-02f, 3.63780446e-02f,
  6.27263859e-02f, 9.10448357e-02f, -5.23800869e-03f, -1.10720314e-01f, 9.96225327e-02f, -9.59758530e-04f, 2.59661525e-02f, -4.30497201e-03f, -5.71909025e-02f, 1.83471799e-01f,
  -9.94285494e-02f, -3.50994095e-02f, 6.06408156e-02f, 3.34603190e-02f, 1.09452512e-02f, -3.10619660e-02f, -6.54697865e-02f, -9.02891234e-02f, -1.16183057e-01f, -1.21530453e-02f,
  -1.20717116e-01f, 1.63203686e-01f, -1.20855868e-01f, -5.66021129e-02f, 9.30249691e-02f, 1.28814518e-01f, 2.47264002e-02f, 2.17537526e-02f, -8.69192462e-03f, -4.54142503e-02f,
  -1.03095904e-01f, -9.57851559e-02f, 1.53448403e-01f, -1.33467279e-02f, 8.72986764e-02f, 5.21932282e-02f, -7.63253495e-02f, 9.64483153e-03f, 8.12924504e-02f, 7.81906322e-02f,
  -1.08210696e-02f, 5.37512712e-02f, 4.99297753e-02f, 6.22045510e-02f, -9.40144658e-02f, -1.40884109e-02f, 9.01803970e-02f, -1.06714211e-01f, -7.16397315e-02f, -7.77847767e-02f,
  -1.08062729e-01f, 5.22985682e-02f, 2.40915846e-02f, 9.64357853e-02f, -3.12421303e-02f, 9.64829326e-03f, 1.91912279e-02f, -6.58999905e-02f, -1.04746647e-01f, 7.66637623e-02f,
  -2.60032769e-02f, -5.56332134e-02f, 8.22704583e-02f, -6.94150031e-02f, 1.44719362e-01f, 1.12955071e-01f, -1.29440855e-02f, 5.99265378e-03f, 1.72796071e-01f, 3.78640997e-03f,
  8.63078088e-02f, 1.92352861e-01f, -5.44200540e-02f, 5.47018759e-02f, 2.83274911e-02f, -2.71761835e-01f, 1.92341462e-01f, 1.33143663e-01f, 2.73735911e-01f, -5.65987229e-02f,
  -2.06607468e-02f, 1.05429314e-01f, 1.10087842e-01f, -3.94336879e-02f, -2.77827561e-01f, 2.16239274e-01f, -5.08441217e-03f, -1.62198558e-01f, 5.02477102e-02f, -9.60014835e-02f,
  7.20304390e-03f, 4.10374939e-01f, -9.05191824e-02f, 3.04514557e-01f, -1.41324416e-01f, 3.69783282e-01f, 4.40262333e-02f, 1.95458576e-01f, -8.61409679e-02f, 4.68406174e-03f,
  -3.03885609e-01f, -6.97953925e-02f, -1.32429406e-01f, 2.49222927e-02f, -5.73527142e-02f, -1.67864725e-01f, -1.35746412e-02f, -1.87415928e-01f, 1.74546212e-01f, -1.15450643e-01f,
  -6.34702742e-02f, 2.93069687e-02f, 1.61256298e-01f, 7.29187159e-03f, 5.97982481e-02f, -4.33288608e-03f, 1.33033127e-01f, 1.07266726e-02f, 2.61615366e-01f, 3.04766089e-01f,
  2.51036417e-02f, -3.28349620e-02f, 1.13858633e-01f, 6.84830174e-02f, 4.63116951e-02f, -1.35840923e-01f, -7.83089995e-02f, -9.85886604e-02f, 4.21245664e-01f, 9.86670256e-02f,
  -1.31558970e-01f, 1.17253207e-01f, 9.30465087e-02f, 1.27683073e-01f, -1.21568307e-01f, 1.39887467e-01f, 2.31861863e-02f, 1.51064500e-01f, 1.10440381e-01f, -3.70821618e-02f,
  -1.23516031e-01f, -1.03268996e-01f, 2.54708808e-03f, -8.68403986e-02f, -6.07790425e-02f, 4.65865098e-02f, 7.33436570e-02f, -5.93419671e-02f, -1.37908265e-01f, 1.17365025e-01f,
  6.47123680e-02f, 7.59450346e-02f, 1.20077111e-01f, 9.33125168e-02f, 1.64140332e-02f, -5.62773682e-02f, 1.07500076e-01f, -2.07731524e-03f, 1.03292011e-01f, 9.39656198e-02f,
  2.21901432e-01f, -9.92223993e-02f, -5.51227778e-02f, 1.66000519e-02f, 1.44165680e-01f, 2.41002291e-02f, 5.34154512e-02f, 1.81023702e-02f, -3.83051001e-02f, 2.06798557e-02f,
  5.04606403e-02f, 5.56658916e-02f, 2.69647930e-02f, 1.06642567e-01f, 1.06886193e-01f, -6.20475970e-02f, 1.15529612e-01f, -3.00469045e-02f, 7.62540624e-02f, -9.80737731e-02f,
  -1.87758524e-02f, -1.19362436e-01f, -8.54843408e-02f, 8.08430836e-02f, -5.11679314e-02f, 1.55069560e-01f, -4.67790179e-02f, -7.92133138e-02f, 6.92913681e-02f, 3.68036702e-02f,
  -1.09383665e-01f, 1.26653053e-02f, 8.76221433e-02f, -6.84554279e-02f, -8.32498297e-02f, 3.33651528e-02f, 2.64819004e-02f, 5.87328412e-02f, -4.39652354e-02f, 7.69183859e-02f,
  1.49861842e-01f, 1.27945155e-01f, 8.18741992e-02f, -7.92301819e-02f, 1.06563354e-02f, 4.28155437e-02f, 1.58096384e-02f, -3.38871442e-02f, -3.02097350e-02f, 5.24589792e-02f,
  -3.44938897e-02f, -1.65976867e-01f, 5.99521324e-02f, -1.91734746e-01f, -4.73336801e-02f, 7.65869692e-02f, 1.21167928e-01f, 1.25922322e-01f, -1.08165801e-01f, 1.00909084e-01f,
  -1.55132618e-02f, 2.18032509e-01f, 1.69098899e-01f, 2.73045719e-01f, 9.11779925e-02f, 2.47802258e-01f, -9.34010074e-02f, 1.19964421e-01f, 2.49632940e-01f, 5.22867590e-02f,
  -1.58461705e-01f, 5.11752348e-03f, -5.04907221e-02f, 1.96944937e-01f, 2.69333441e-02f, 2.86859814e-02f, 2.25038696e-02f, 2.38298073e-01f, -2.44014189e-01f, -7.88497627e-02f,
  -1.90623686e-01f, 3.61942090e-02f, 5.23333773e-02f, 7.02221692e-02f, -6.66127503e-02f, 7.71332085e-02f, -4.57256660e-02f, 2.25997612e-01f, 6.55226782e-02f, 2.38494441e-01f,
  1.34824181e-03f, 1.51495626e-02f, 2.23545940e-03f, 1.87736794e-01f, -1.02794118e-01f, 6.17974885e-02f, 8.81702676e-02f, -1.23635665e-01f, 1.09890942e-04f, 9.11635309e-02f,
  -3.84873375e-02f, 2.43687816e-02f, -1.10773139e-01f, -4.16500792e-02f, 2.79516000e-02f, -1.01560727e-01f, -1.15057737e-01f, -5.44217266e-02f, -2.14942149e-03f, -9.84158590e-02f,
  1.53187588e-02f, 7.71244615e-02f, 9.16205868e-02f, 1.17623918e-01f, 4.84610274e-02f, -5.12059219e-03f, 8.11825618e-02f, 9.54971686e-02f, 3.62502784e-02f, -3.69253233e-02f,
  9.93569940e-02f, 4.04623263e-02f, 7.90706947e-02f, -2.64913458e-02f, -1.04800746e-01f, 3.01209334e-02f, -1.28090724e-01f, -6.66551292e-02f, -1.05709821e-01f, 8.11694637e-02f,
  2.83819647e-03f, -8.94642249e-02f, -1.51359975e-01f, 1.24546319e-01f, 6.15341216e-02f, 1.37481406e-01f, -6.57109842e-02f, -1.38349816e-01f, -3.31684276e-02f, -1.73872132e-02f,
  5.41769043e-02f, 8.42317194e-02f, -4.80733141e-02f, -1.18425503e-01f, 1.09274790e-01f, 1.31783355e-02f, -1.01388231e-01f, -6.75060079e-02f, 6.83242679e-02f, -5.50880618e-02f,
  1.43730134e-01f, -1.57013386e-01f, 7.32627064e-02f, 9.89205670e-03f, 1.73740380e-03f, 8.87823328e-02f, 8.78326409e-03f, 2.74897479e-02f, 5.59205040e-02f, 2.04612259e-02f,
  1.17307521e-01f, -1.45126628e-02f, -8.31230730e-02f, 8.50334987e-02f, -8.47674012e-02f, -6.26936108e-02f, -5.25061078e-02f, 7.58926049e-02f, -4.57232632e-03f, 7.63921887e-02f,
  1.08933434e-01f, 1.12204656e-01f, -1.03865772e-01f, -5.68606369e-02f, -1.11348145e-01f, 3.15742544e-03f, -5.92866093e-02f, 6.95993975e-02f, -1.06279731e-01f, 3.16737816e-02f,
  -1.65630376e-03f, -1.24251679e-01f, 4.63253520e-02f, 3.03778443e-02f, -5.94783574e-02f, -5.11960573e-02f, -3.77336815e-02f, 1.13557139e-02f, 9.08925682e-02f, -7.32476488e-02f,
  -8.29189569e-02f, -9.42238495e-02f, 6.14462346e-02f, 2.56736241e-02f, -2.52086222e-02f, -5.72241768e-02f, -5.05981408e-02f, -9.68451947e-02f, 1.00062571e-01f, 1.32775670e-02f,
  -2.06420347e-02f, -1.14415474e-01f, -1.82660557e-02f, -2.16643754e-02f, 3.67192067e-02f, 1.07779332e-01f, -8.69844779e-02f, -4.61860895e-02f, 2.73153428e-02f, -5.96365184e-02f,
  7.58575574e-02f, -8.84191506e-03f, -9.50001404e-02f, 8.99501219e-02f, 1.21673129e-01f, -1.03163868e-01f, -2.21155994e-02f, -6.87671006e-02f, 1.27812058e-01f, -5.92045560e-02f,
  -4.40101847e-02f, 2.54085325e-02f, 8.05383027e-02f, 7.24637136e-02f, 9.34624076e-02f, -6.52298843e-03f, 5.07884100e-02f, 5.46100065e-02f, -2.10551219e-03f, 1.59449577e-01f,
  1.48002645e-02f, -9.39658750e-03f, 8.08464289e-02f, 1.77447274e-02f, 2.53907233e-01f, -6.46607876e-02f, -8.09780732e-02f, 1.74456537e-01f, -7.14652836e-02f, -2.92670559e-02f,
  -1.13475986e-01f, -1.34329543e-01f, -6.42937124e-02f, 5.85645251e-02f, -1.13973089e-01f, -1.14792898e-01f, -1.05320305e-01f, -1.02739669e-01f, 1.09528258e-01f, 1.39602602e-01f,
  9.88402218e-02f, 1.52396977e-01f, -8.89137611e-02f, 1.37580022e-01f, 1.41807780e-01f, 4.57970500e-01f, 1.96504280e-01f, 2.24766042e-02f, 1.30523685e-02f, 4.88744974e-02f,
  3.38230729e-02f, -1.46737080e-02f, -1.69982105e-01f, -1.31006828e-02f, -7.75334612e-02f, 1.89431742e-01f, -3.20315845e-02f, -3.39966454e-02f, 5.08823618e-02f, 9.81366783e-02f,
  -5.26782386e-02f, 1.23728037e-01f, 4.82422449e-02f, -5.24764806e-02f, -9.20350999e-02f, -6.47207499e-02f, 1.17031746e-01f, 2.94434913e-02f, -1.27393067e-01f, 2.46103480e-01f,
  1.21529438e-01f, 3.42100531e-01f, -8.04019272e-02f, -5.41717187e-02f, 4.99388166e-02f, -1.29671231e-01f, -4.34711426e-02f, 1.19234905e-01f, 1.24838144e-01f, -2.12159881e-04f,
  -6.54622614e-02f, -4.62023690e-02f, 7.14361891e-02f, 1.66331992e-01f, 2.14839444e-01f, 1.67759205e-03f, 1.92783132e-01f, 1.90571681e-01f, -3.34239490e-02f, 3.88061069e-02f,
  1.00584395e-01f, 1.45096496e-01f, -1.06093772e-01f, -1.64517239e-01f, -8.14533904e-02f, 2.48989780e-02f, 1.35913357e-01f, 9.68877748e-02f, -1.09858969e-02f, 7.95415193e-02f,
  -1.84050307e-01f, -2.69595273e-02f, -8.09827894e-02f, -7.51046464e-02f, 1.45331845e-02f, 2.27856159e-01f, 1.22818545e-01f, 5.42390272e-02f, 1.39083624e-01f, 3.07261944e-01f,
  -4.12341282e-02f, -1.84640214e-02f, -5.68481050e-02f, -1.25443935e-01f, -1.46361902e-01f, 1.09239593e-01f, -2.42249351e-02f, -7.76253194e-02f, -1.26260892e-01f, 8.88438430e-03f,
  -6.21103756e-02f, -5.71785234e-02f, 4.81993565e-03f, -1.40326172e-01f, 1.92464843e-01f, 1.17008634e-01f, -7.01226369e-02f, -1.20200180e-01f, -2.90548094e-02f, 1.15879208e-01f,
  -4.58863825e-02f, -1.14134215e-01f, 1.77843913e-01f, 3.45226705e-01f, 1.60026014e-01f, 1.60216298e-02f, -6.09664358e-02f, 2.67552342e-02f, 8.28580558e-02f, -1.11092091e-01f,
  -9.26487520e-02f, -9.47278813e-02f, 1.16084337e-01f, 1.20942473e-01f, -1.88477352e-01f, 4.95789899e-03f, 1.06635578e-01f, 1.10630579e-01f, 1.74222648e-01f, 1.45545900e-01f,
  -5.91708682e-02f, -5.23109958e-02f, 5.90627715e-02f, 1.81240425e-01f, 5.99671304e-02f, -3.73664647e-02f, -1.24264315e-01f, -9.38335285e-02f, -1.43920099e-02f, -1.28970399e-01f,
  -1.08100817e-01f, 1.63425311e-01f, 3.12510878e-01f, 2.05522627e-01f, 9.69138145e-02f, 9.61545780e-02f, 7.68761383e-03f, 1.30932033e-01f, 5.58663160e-02f, 1.13740843e-02f,
  1.75852459e-02f, -1.34964287e-01f, 1.11106351e-01f, -4.65619266e-02f, 8.25158507e-02f, -3.79165038e-02f, 2.85034329e-02f, -1.01243190e-01f, 3.32088679e-01f, -3.77369858e-02f,
  -6.66021705e-02f, -8.18727538e-02f, 9.83670074e-03f, -4.72591557e-02f, -1.06553063e-01f, 1.04624502e-01f, -6.79390803e-02f, -9.81931314e-02f, 2.60445356e-01f, 5.53241298e-02f,
  -7.43794739e-02f, 1.62653312e-01f, -5.98806031e-02f, 1.14573829e-01f, -1.23962261e-01f, 1.72385480e-02f, 1.84101641e-01f, -6.99534789e-02f, -7.29529262e-02f, 2.51967423e-02f,
  7.36168027e-02f, -4.93204338e-04f, -5.06071411e-02f, 2.05061838e-01f, 9.29069519e-02f, 7.82042965e-02f, -1.00958921e-01f, 8.06414410e-02f, -2.40803529e-02f, -6.25460446e-02f,
  -7.76934028e-02f, -5.75801432e-02f, -7.73177892e-02f, 8.37432127e-03f, -1.01022989e-01f, 2.48884093e-02f, 5.18556014e-02f, 3.66423242e-02f, -6.66517299e-03f, -2.53815134e-03f,
  -1.42723899e-02f, 8.15845057e-02f, 8.76372978e-02f, 2.48463601e-02f, 1.53275784e-02f, -2.67180353e-02f, -1.19293533e-01f, 6.75017089e-02f, -1.72059778e-02f, -5.11036292e-02f,
  1.12503156e-01f, -5.31415902e-02f, -8.94310400e-02f, 1.17487669e-01f, 4.24500406e-02f, 2.25855410e-02f, 9.94746834e-02f, -8.87937471e-02f, 1.32253775e-02f, -1.90000366e-02f,
  -5.68803726e-03f, -3.71689387e-02f, -5.16268723e-02f, -7.09647611e-02f, 1.22203022e-01f, -8.56846513e-04f, 9.22634006e-02f, -1.17556915e-01f, 8.19119141e-02f, 9.70647931e-02f,
  6.70113713e-02f, -1.23091877e-01f, 7.28322640e-02f, 4.07483242e-02f, -1.01474896e-01f, -4.58692051e-02f, -1.12248980e-01f, 9.17886347e-02f, 9.05732512e-02f, -4.79935221e-02f,
  -6.33789599e-02f, 6.27309531e-02f, 8.33926052e-02f, 5.40146679e-02f, -7.26694092e-02f, 9.65887331e-04f, 9.10104588e-02f, -1.24634355e-01f, -7.22929835e-02f, -1.34251053e-02f,
  -1.26573041e-01f, -1.23787224e-02f, -7.55048683e-03f, -3.08282450e-02f, -4.23865207e-02f, 1.43908843e-01f, 1.56104028e-01f, 1.59039274e-01f, -4.22042683e-02f, -1.92195117e-01f,
  -2.11719959e-03f, 1.49676502e-01f, 4.63689566e-02f, 5.79725131e-02f, -1.03383407e-01f, -2.45408610e-01f, -1.01316772e-01f, -1.24111073e-02f, 1.20530568e-01f, 2.43757650e-01f,
  -5.72921149e-02f, 2.95264274e-01f, -7.93427974e-02f, 7.58479014e-02f, -1.28471022e-02f, 7.30749443e-02f, 9.90257598e-04f, -4.65465570e-03f, 1.07340075e-01f, -9.54840034e-02f,
  8.85839835e-02f, -1.80024758e-01f, 2.66410291e-01f, -1.82745427e-01f, -1.80145092e-02f, -2.03927070e-01f, -7.84076843e-03f, 8.02630484e-02f, 5.53015769e-02f, 2.18987525e-01f,
  -1.01775713e-01f, -6.11198358e-02f, -9.41273570e-02f, -6.49987757e-02f, 4.53468263e-02f, -1.94486439e-01f, 3.66187632e-01f, 2.17109501e-01f, 1.69530153e-01f, 4.49540615e-02f,
  9.57125276e-02f, 1.08066827e-01f, -1.99018233e-02f, -1.52082622e-01f, 2.05715984e-01f, 6.37883246e-02f, 6.22693039e-02f, -1.50107145e-01f, 1.26823694e-01f, 1.07196055e-01f,
  2.27648020e-02f, 3.04280072e-02f, 1.26256216e-02f, -2.87828930e-02f, 5.71501032e-02f, 1.27750859e-01f, -1.36725485e-01f, -2.76764631e-02f, 4.05057184e-02f, 8.29665214e-02f,
  1.04257450e-01f, 1.47050574e-01f, 1.41108677e-01f, -7.26292953e-02f, 1.65801346e-01f, -1.90816849e-01f, 1.87192127e-01f, 1.36986986e-01f, 8.98236409e-02f, 2.04524294e-01f,
  1.80377753e-03f, 1.66452080e-02f, 9.31666568e-02f, -7.74642900e-02f, -1.06545366e-01f, 1.09912820e-01f, -1.19405843e-01f, -8.48521292e-02f, -1.00163192e-01f, -8.60511139e-02f,
  5.72423078e-02f, 2.56048530e-01f, 8.79442617e-02f, 6.83034211e-02f, 1.07420376e-02f, 2.91534305e-01f, -2.64850795e-01f, 1.05586432e-01f, -1.19567901e-01f, -6.44693598e-02f,
  -2.32050359e-01f, -4.67402115e-03f, -7.34618977e-02f, 1.42676439e-02f, 7.08899880e-03f, -1.46975100e-01f, -8.06320906e-02f, -9.40173343e-02f, 8.49030018e-02f, -6.62593991e-02f,
  3.36971739e-03f, 5.51006161e-02f, -1.59585908e-01f, 7.35413283e-02f, 6.84269369e-02f, -1.11228064e-01f, 6.03030697e-02f, 1.24498174e-01f, 1.62909940e-01f, 3.76244187e-02f,
  3.26841772e-02f, -6.11804835e-02f, -2.26993132e-02f, 1.09787688e-01f, 3.58454995e-02f, 5.19686081e-02f, 3.05161793e-02f, 9.85865667e-03f, 1.98614284e-01f, 1.03539370e-01f,
  -2.47254223e-02f, 2.87565626e-02f, 1.80906996e-01f, 1.83325291e-01f, -4.46816124e-02f, 5.40940985e-02f, 8.14187154e-02f, 2.57800281e-01f, -9.80226547e-02f, -2.09577709e-01f,
  8.51045735e-03f, -2.38073096e-02f, 9.72341448e-02f, -1.00883886e-01f, -1.11355804e-01f, 5.10143265e-02f, -8.99894089e-02f, -1.33326566e-02f, -8.47799331e-03f, 1.75779581e-01f,
  -1.15370803e-01f, 1.64160386e-01f, 2.10683197e-02f, 1.24148950e-01f, 1.03980638e-01f, 2.16852680e-01f, 4.81769219e-02f, -1.26420185e-01f, -1.61579847e-02f, -1.93392690e-02f,
  -3.79893705e-02f, 9.49433371e-02f, -9.67303216e-02f, 1.15042841e-02f, -1.18569747e-01f, 2.96740308e-02f, 1.56952232e-01f, 1.52017787e-01f, -2.77805608e-02f, -4.67403457e-02f,
  5.85978813e-02f, 8.43448043e-02f, -4.96183559e-02f, 5.36343865e-02f, -4.34312262e-02f, -1.23644657e-01f, 1.53705776e-01f, 9.97123569e-02f, -7.11449087e-02f, 5.16848005e-02f,
  -1.45558551e-01f, 9.36547816e-02f, 1.51171669e-01f, -1.57012463e-01f, -6.28886372e-02f, -5.29856272e-02f, 1.50879705e-02f, 1.06144398e-01f, 1.11839280e-01f, 4.90033776e-02f,
  6.69987593e-03f, -5.27258776e-02f, -2.93844758e-04f, -9.45866480e-02f, 1.45918190e-01f, -9.84921455e-02f, 8.56434088e-03f, -2.47639623e-02f, -3.83166298e-02f, 2.23290026e-02f,
  1.06872946e-01f, -6.00882806e-02f, -1.02791293e-02f, -1.83850735e-01f, 1.26291126e-01f, -1.63552742e-02f, 1.23067863e-01f, 2.51167446e-01f, 6.63826466e-02f, -1.27557456e-01f,
  8.96649435e-02f, -8.60013887e-02f, 1.44678161e-01f, -1.50421381e-01f, 1.54313117e-01f, 5.18361628e-02f, 1.22390017e-01f, -4.62040715e-02f, -4.82211970e-02f, 1.19187564e-01f,
  -1.13496572e-01f, 1.20956950e-01f, -7.29423612e-02f, 1.88664973e-01f, -1.10125169e-01f, 1.46886274e-01f, 3.41468751e-02f, -1.10251512e-02f, -1.65909566e-02f, -1.11628965e-01f,
  -8.79068449e-02f, -4.13902961e-02f, 8.86304956e-03f, 8.71590376e-02f, -2.22096164e-02f, -1.26407936e-01f, 1.45934895e-01f, 9.02634338e-02f, 1.55179412e-03f, 6.53797165e-02f,
  -1.09504379e-01f, -2.18826383e-02f, -1.12734057e-01f, 8.59009102e-02f, 3.92529480e-02f, 3.08361445e-02f, -2.71120314e-02f, 1.68751910e-01f, -5.77951185e-02f, -5.13655581e-02f,
  6.31623492e-02f, 7.64297545e-02f, -9.94606465e-02f, -1.11875154e-01f, -4.39773649e-02f, -6.10847920e-02f, 1.37255654e-01f, 3.44548933e-02f, -8.01562965e-02f, 1.10768154e-02f,
  2.19806045e-01f, 1.26062840e-01f, 2.35939428e-01f, 2.01311707e-01f, -2.82777846e-03f, 1.85204949e-03f, -2.24236041e-01f, -6.96638748e-02f, 9.66679677e-02f, 1.04183689e-01f,
  7.48621821e-02f, -1.37889311e-01f, -5.27329333e-02f, 1.58887863e-01f, 3.49873789e-02f, 1.51692480e-01f, 9.06188712e-02f, 3.68824869e-01f, 9.39743593e-02f, 7.64296353e-02f,
  -4.35133725e-02f, -1.16005242e-01f, 3.39749269e-02f, 8.95973668e-02f, 8.93271789e-02f, -2.16609672e-01f, -1.71199098e-01f, -2.49821410e-01f, 1.01013735e-01f, 9.75352079e-02f,
  5.36362752e-02f, 2.62238197e-02f, -1.34922087e-01f, 2.13435348e-02f, 1.85317233e-01f, 2.73744583e-01f, 8.41878206e-02f, 2.04359535e-02f, 5.79272769e-02f, 1.42745867e-01f,
  8.67189914e-02f, -1.36365503e-01f, 3.28982443e-01f, -4.53069210e-02f, 1.55208319e-01f, 1.25799581e-01f, -1.06888458e-01f, -9.74054784e-02f, 6.56552240e-02f, 1.49189085e-01f,
  4.03376997e-01f, -1.33428618e-01f, -2.12330874e-02f, -1.07409060e-01f, 9.37673897e-02f, 8.26055259e-02f, -6.79063424e-02f, -5.41671105e-02f, 1.61645859e-01f, -1.15855880e-01f,
  1.18614212e-01f, 4.58706059e-02f, 6.91613182e-02f, 4.44100462e-02f, 1.23438962e-01f, -7.86558241e-02f, -4.26181145e-02f, -3.44223492e-02f, 8.82840380e-02f, -8.93564597e-02f,
  1.02937609e-01f, -9.42601264e-02f, -6.93486705e-02f, -1.12125702e-01f, -9.04985592e-02f, 2.73977574e-02f, -8.71142820e-02f, 4.23267968e-02f, -4.82151806e-02f, 8.00129697e-02f,
  -5.42035066e-02f, 2.85302531e-02f, -1.04737610e-01f, 5.59952408e-02f, 5.45325987e-02f, 8.48715380e-02f, -8.76078829e-02f, 5.20024598e-02f, 1.03504851e-01f, -6.18341900e-02f,
  -1.04514122e-01f, 2.73026135e-02f, -9.13053155e-02f, -8.05373564e-02f, -8.97898749e-02f, 9.93081778e-02f, -1.21523440e-01f, 6.44042790e-02f, -3.64914164e-02f, -9.31325853e-02f,
  -8.80190507e-02f, -7.97586218e-02f, -4.50197197e-02f, -9.90955085e-02f, 2.21713577e-04f, 1.68029647e-02f, -8.11980441e-02f, -7.68503696e-02f, -1.54505307e-02f, -7.88464099e-02f,
  9.88360196e-02f, -6.37363195e-02f, 6.45703971e-02f, -9.39071327e-02f, 9.22760926e-03f, -1.16811469e-01f, -7.51339942e-02f, 8.05690810e-02f, -3.69461700e-02f, 4.28261934e-03f,
  -8.73231515e-02f, -7.44547844e-02f, 2.44807228e-02f, 9.30323899e-02f, 3.35673355e-02f, -1.06982902e-01f, 7.96707347e-02f, -9.61199403e-02f, 1.15120597e-01f, 1.66816801e-01f,
  1.77605927e-01f, 2.04679132e-01f, 7.83827528e-02f, 1.83437154e-01f, -1.75163269e-01f, -2.91283160e-01f, 1.74317986e-01f, -1.94376588e-01f, 1.54977769e-01f, 1.67409077e-01f,
  3.55642326e-02f, 1.30000664e-02f, -1.06376454e-01f, -1.35731459e-01f, 9.63961408e-02f, 1.25878066e-01f, -6.79680482e-02f, 3.31857912e-02f, -7.05985129e-02f, 1.00412760e-02f,
  1.02062829e-01f, 1.71741471e-01f, 1.12255290e-01f, -1.07288072e-02f, -1.19725831e-01f, -1.18189700e-01f, -1.16750650e-01f, 1.11165658e-01f, 3.07253972e-02f, 5.29541001e-02f,
  -2.59462912e-02f, 1.23256512e-01f, 2.09348813e-01f, 7.80788213e-02f, 4.44171429e-02f, 9.20365378e-02f, -6.95641637e-02f, 2.32458830e-01f, -3.05814645e-03f, 1.30441457e-01f,
  -6.09216541e-02f, -1.23172991e-01f, -1.26475487e-02f, 9.32893828e-02f, 6.22189743e-03f, -9.09409374e-02f, -1.19903862e-01f, 1.39021814e-01f, 1.18766114e-01f, -1.40438199e-01f,
  -1.25603363e-01f, 8.50073025e-02f, -6.80447444e-02f, 9.99579355e-02f, 7.83079714e-02f, 1.19240142e-01f, 7.59648457e-02f, -1.84768900e-01f, 2.54996151e-01f, 1.40996933e-01f,
  1.55747518e-01f, -8.30096528e-02f, -1.28972962e-01f, -1.71609912e-02f, 2.88065523e-02f, 2.53532734e-02f, -5.80353141e-02f, 6.80198893e-02f, 1.11748248e-01f, -6.32257834e-02f,
  -1.74762085e-02f, -1.44067794e-01f, -7.85556957e-02f, -1.32861752e-02f, 6.12221956e-02f, -1.13204852e-01f, 8.60805735e-02f, 1.06913418e-01f, 1.07323490e-01f, -1.08349033e-01f,
  1.84711874e-01f, -7.76697174e-02f, 7.01189935e-02f, -3.33092548e-02f, 1.07186504e-01f, -3.98255028e-02f, -7.42389560e-02f, -9.92093794e-03f, 4.45872508e-02f, 3.14957686e-02f,
  1.63718253e-01f, -8.78510028e-02f, -3.27407732e-03f, 1.23694628e-01f, 3.65587592e-01f, -6.10684194e-02f, -9.07565281e-02f, -1.49616778e-01f, 1.36419132e-01f, 4.00215611e-02f,
  -7.53287524e-02f, 5.44312689e-03f, 7.12999478e-02f, 1.91699252e-01f, 8.47529247e-02f, -9.67719853e-02f, 1.10783599e-01f, 1.39255151e-01f, 1.02927722e-01f, 5.19093052e-02f,
  1.35452390e-01f, 1.54713646e-01f, -2.80118525e-01f, 1.25713870e-01f, 1.42255530e-01f, 1.72662601e-01f, -2.40417868e-02f, 6.32745326e-02f, 5.52149415e-02f, 1.04289688e-01f,
  -6.62059058e-03f, 9.10324156e-02f, -1.18785433e-01f, -8.41601491e-02f, 5.69840260e-02f, 7.99059942e-02f, 2.18404710e-01f, 1.14573471e-01f, 1.46005958e-01f, 1.44247964e-01f,
  1.24530621e-01f, 1.00459725e-01f, -1.72187999e-01f, 2.57743001e-01f, -5.25420718e-02f, 1.73348039e-01f, -8.41694325e-02f, -3.07380944e-01f, -7.95251206e-02f, -1.34539485e-01f,
  -3.41378786e-02f, 3.59641194e-01f, 1.74385458e-01f, 3.79835516e-01f, 9.16811451e-02f, 2.46265810e-02f, 5.82623668e-02f, -1.22538317e-04f, -3.09681986e-02f, -7.91470055e-03f,
  -6.27262816e-02f, -1.61778837e-01f, 9.90274549e-02f, -2.42628619e-01f, 3.01719457e-01f, -9.61503610e-02f, 6.08248524e-02f, -8.65664184e-02f, 2.59135485e-01f, -7.11789653e-02f,
  7.51142427e-02f, 7.58056417e-02f, 1.13603488e-01f, 1.59631953e-01f, 1.29581690e-01f, -5.05645350e-02f, -1.07271232e-01f, -1.89696983e-01f, 4.71743464e-01f, -6.34327382e-02f,
  -6.54930919e-02f, 1.75122231e-01f, -3.82870398e-02f, 6.00568131e-02f, -1.25168398e-01f, 1.69532746e-02f, 2.88727820e-01f, -9.39071029e-02f, 6.68885633e-02f, -1.97074369e-01f,
  8.06625336e-02f, 1.29687423e-02f, -1.49406248e-03f, -3.39573584e-02f, 6.88803196e-02f, -5.63464351e-02f, 8.88551492e-03f, 2.02022851e-01f, 1.01716526e-01f, -8.23871717e-02f,
  9.08635780e-02f, 4.31822427e-02f, 6.29972368e-02f, -1.29239392e-02f, 2.03368589e-02f, -4.79033701e-02f, -1.62505627e-01f, 3.01397681e-01f, -1.53962344e-01f, 7.10457787e-02f,
  -2.02409834e-01f, -2.24572539e-01f, 1.89787652e-02f, -1.37515277e-01f, 2.27131285e-02f, 1.77556917e-01f, -6.38271421e-02f, 1.86141640e-01f, 3.84151228e-02f, -3.16485576e-02f,
  3.88690606e-02f, 2.53894240e-01f, 1.05827495e-01f, -1.99766815e-01f, -3.08706313e-02f, 5.33260591e-02f, 9.81040951e-03f, -1.81394234e-01f, 1.33447289e-01f, -1.93254739e-01f,
  5.16057611e-02f, 1.00591667e-01f, 3.54106963e-01f, -9.24124196e-02f, 1.19101733e-01f, 4.90996465e-02f, -1.31885007e-01f, 9.47807953e-02f, 2.85891108e-02f, 5.69969490e-02f,
  -3.66913341e-02f, 3.05681350e-03f, 2.36536399e-01f, 2.74639204e-02f, -4.70797531e-02f, 1.80382296e-01f, -2.90718745e-03f, -1.21491514e-01f, 4.00010981e-02f, -1.43796504e-01f,
  2.92178597e-02f, 4.80626449e-02f, -1.04228720e-01f, 1.46737039e-01f, -8.74159634e-02f, -9.70474705e-02f, -1.92599986e-02f, 4.98378836e-02f, -9.24007297e-02f, -9.97234583e-02f,
  -1.33958191e-01f, 4.32847887e-02f, -1.96927204e-03f, -9.33919922e-02f, -3.44999395e-02f, -9.67597291e-02f, -9.49060470e-02f, -9.63118970e-02f, -6.74146190e-02f, 1.31429195e-01f,
  1.06104821e-01f, 9.89132002e-02f, -9.15110335e-02f, -1.65327992e-02f, 2.68519521e-02f, 1.06876202e-01f, 1.56640746e-02f, 3.60652357e-02f, -1.10336006e-01f, 4.83321305e-03f,
  -1.16228029e-01f, 3.89965884e-02f, -9.05389041e-02f, 1.00525565e-01f, 9.81036425e-02f, 8.46690685e-02f, -9.61612836e-02f, -3.68372835e-02f, 1.03728004e-01f, 1.29371136e-01f,
  8.24650526e-02f, 8.10577255e-03f, 3.04419138e-02f, -1.05626263e-01f, -2.40304843e-02f, 6.48813024e-02f, 1.76642518e-02f, 6.44798726e-02f, 6.96618855e-02f, 2.10537459e-03f,
  -5.87955043e-02f, -1.11849040e-01f, -5.86708933e-02f, -1.61794778e-02f, 9.62740779e-02f, 7.69463927e-02f, -7.35103190e-02f, -1.02709539e-01f, -4.35524695e-02f, 9.08341706e-02f,
  1.08560562e-01f, -4.02883962e-02f, 4.69089486e-02f, -4.20512930e-02f, 2.97609083e-02f, 5.21397032e-02f, 1.38169438e-01f, -8.30612555e-02f, 1.57508664e-02f, -2.82708108e-02f,
  -1.20066926e-01f, -1.19697131e-01f, -2.35895403e-02f, 2.97576431e-02f, 1.20368764e-01f, 9.53218415e-02f, 3.07836570e-02f, -6.33776709e-02f, 3.71015817e-01f, 1.30281776e-01f,
  2.49461144e-01f, 2.00993732e-01f, 1.75604433e-01f, 3.03056180e-01f, 1.82124540e-01f, 1.20900184e-01f, 2.53687918e-01f, 1.85768351e-01f, -5.45151122e-02f, -2.24413291e-01f,
  -9.53325182e-02f, -8.95672143e-02f, -1.14689589e-01f, 5.28189242e-02f, -7.73988515e-02f, 2.06407756e-01f, -2.25010172e-01f, 6.38455898e-02f, -1.40292585e-01f, -1.16567150e-01f,
  -8.41032788e-02f, 1.11613154e-01f, 1.07680522e-01f, -1.31825637e-02f, 1.24571994e-01f, 1.68683067e-01f, -3.64026278e-02f, 2.53868937e-01f, -1.55291349e-01f, -1.91415027e-02f,
  -1.56018242e-01f, 2.92252135e-02f, 1.36851981e-01f, 9.12329108e-02f, -9.78377983e-02f, 3.49992625e-02f, -1.15281455e-01f, 1.05631240e-01f, -5.91750592e-02f, -3.42177153e-02f,
  1.73169792e-01f, 2.35965662e-02f, -2.67341137e-01f, 4.42612804e-02f, -4.51539047e-02f, 3.40744965e-02f, -6.29286245e-02f, -4.89171967e-02f, 3.30268234e-01f, 2.88268149e-01f,
  -5.97150356e-04f, -1.09105874e-02f, -2.51390669e-03f, 2.96343770e-02f, -6.40874505e-02f, 1.80035472e-01f, 2.27545530e-01f, 4.11945544e-02f, 1.77007709e-02f, 1.52210966e-01f,
  4.32260931e-02f, -3.52190211e-02f, 1.14667267e-01f, -3.12058758e-02f, -7.55738541e-02f, 1.70684978e-02f, 1.29479663e-02f, 1.04441784e-01f, 2.49991342e-01f, 3.63344066e-02f,
  -2.04238147e-01f, 3.85860838e-02f, -2.80267950e-02f, 4.88881096e-02f, 5.49216233e-02f, -2.60723173e-03f, 9.42850411e-02f, -1.41071096e-01f, 3.62432718e-01f, -1.94395930e-01f,
  8.59989300e-02f, 1.24407955e-01f, -9.95507091e-02f, 1.36168003e-01f, -7.39509836e-02f, 1.34842515e-01f, -1.15553468e-01f, -3.24756689e-02f, 1.71349108e-01f, 1.93652943e-01f,
  -4.55202628e-03f, 1.48349643e-01f, -7.26926476e-02f, 1.83473915e-01f, 3.06720346e-01f, -1.12651303e-01f, -1.16454987e-02f, -9.72435623e-02f, 1.12963706e-01f, -1.01614883e-02f,
  -6.14442341e-02f, 1.53173521e-01f, -1.36278979e-02f, 2.15951189e-01f, -1.77763209e-01f, -4.99055535e-02f, -1.67536080e-01f, 1.78606451e-01f, 3.28061096e-02f, 1.13760866e-01f,
  1.75253619e-02f, 9.73147377e-02f, 3.52517776e-02f, 1.07121110e-01f, 1.57847017e-01f, 3.15676600e-01f, -1.43746957e-02f, 5.05356193e-02f, -6.97650537e-02f, 1.73916280e-01f,
  6.78971931e-02f, 3.91718782e-02f, -5.23291938e-02f, -1.13663234e-01f, 1.46088585e-01f, 1.93156172e-02f, -8.39736536e-02f, 2.58210097e-02f, 2.08361506e-01f, 1.46858037e-01f,
  1.23943523e-01f, 7.66505301e-02f, -1.01957917e-01f, -1.86483130e-01f, -1.04097210e-01f, -1.83120787e-01f, 8.08373541e-02f, 1.86585709e-01f, -6.41757026e-02f, 5.64350234e-03f,
  -8.69451240e-02f, -1.41914994e-01f, 1.99590698e-01f, -1.08740732e-01f, 2.32403353e-01f, 5.80036379e-02f, 1.22905791e-01f, -3.29829045e-02f, 5.79167269e-02f, 2.77853072e-01f,
  -3.46736535e-02f, 5.00882864e-02f, -7.76062757e-02f, 1.94027737e-01f, -1.53021082e-01f, 2.37384632e-01f, -1.37684882e-01f, 8.24220926e-02f, 1.72675118e-01f, 1.07044645e-01f,
  -7.06566423e-02f, -7.32172802e-02f, 4.95973378e-02f, -5.56773739e-03f, -5.76277375e-02f, 1.16412170e-01f, 1.64651915e-01f, 6.77658096e-02f, -1.50845453e-01f, -2.60310806e-02f,
  9.44893062e-02f, -5.59601821e-02f, 5.07778674e-02f, -6.39759302e-02f, 1.11643828e-01f, 3.33040506e-01f, 3.36825997e-02f, 1.25410438e-01f, 1.41119286e-01f, 1.80732325e-01f,
  -2.78947521e-02f, 4.36845198e-02f, -1.40145505e-02f, 2.26871386e-01f, 1.14170581e-01f, -5.45486361e-02f, 3.54961991e-01f, -4.70904708e-02f, 2.32426375e-01f, 9.02054831e-02f,
  1.09033789e-02f, -7.18267309e-03f, -1.15391344e-01f, -5.77892251e-02f, -1.14673860e-01f, -8.10546800e-02f, -2.33383136e-04f, 1.07049830e-01f, 8.54753051e-03f, 5.59685305e-02f,
  2.39974000e-02f, 8.35926384e-02f, 1.11740686e-01f, 9.27500427e-02f, 2.65064370e-02f, 2.51007196e-03f, -5.08107431e-02f, -1.05403222e-01f, 8.62408951e-02f, 1.25846028e-01f,
  -6.76146150e-02f, 8.74563083e-02f, -6.54546842e-02f, -3.41511369e-02f, -4.34000082e-02f, 1.48276612e-02f, 3.09187565e-02f, -1.70702897e-02f, 8.75862837e-02f, -4.75339964e-02f,
  -6.24144971e-02f, 9.76056755e-02f, -3.08858100e-02f, 2.35825293e-02f, 8.71546045e-02f, -3.51906866e-02f, -1.21082060e-01f, 7.45942742e-02f, 5.68025894e-02f, -1.20525518e-02f,
  -9.26927328e-02f, 1.43921264e-02f, 9.51450597e-03f, -5.37301041e-02f, 1.25693217e-01f, -1.02949835e-01f, -3.85468230e-02f, -7.75438696e-02f, 7.34870732e-02f, -8.08281004e-02f,
  -1.05402634e-01f, 5.06688915e-02f, -2.81429589e-02f, 6.02700524e-02f, 9.81984362e-02f, 9.65138301e-02f, 1.04980268e-01f, 2.68893247e-03f, -1.77904665e-02f, -5.28231636e-02f,
  3.20496894e-02f, 3.36298272e-02f, -1.05340600e-01f, -6.25031963e-02f, 7.00543681e-03f, -1.22362398e-01f, 2.89580710e-02f, 6.88746721e-02f, 1.12631377e-02f, -4.60053496e-02f,
  6.73511699e-02f, -1.16631560e-01f, -4.29539531e-02f, -1.49713652e-02f, 1.13772884e-01f, 2.99089625e-02f, 2.72098146e-02f, 6.32310510e-02f, 6.70465454e-02f, 1.10736467e-01f,
  -3.95667888e-02f, -1.21406570e-01f, 2.09209193e-02f, -5.92343993e-02f, -9.76492092e-02f, -5.15109450e-02f, 9.64268595e-02f, -9.15433764e-02f, 6.56420663e-02f, -1.08338736e-01f,
  9.23660696e-02f, -1.13313705e-01f, 1.19330630e-01f, 8.70963559e-02f, -2.03167014e-02f, -6.38997182e-02f, -1.47572001e-02f, 9.55865085e-02f, 7.97275156e-02f, 2.62299683e-02f,
  4.20409907e-03f, -6.44454882e-02f, -4.86428551e-02f, -3.08740344e-02f, -1.09544441e-01f, 8.82284995e-03f, -1.01598814e-01f, -1.52291749e-02f, -4.33151722e-02f, 1.38456840e-03f,
  -6.35830462e-02f, -3.69261429e-02f, 2.25691348e-02f, -4.54152934e-03f, -6.32765368e-02f, 2.82046515e-02f, -6.90226927e-02f, -1.92469228e-02f, 2.88050203e-03f, -1.70779899e-02f,
  2.12807674e-02f, -1.02762938e-01f, -7.24135265e-02f, -1.01292528e-01f, 3.72865908e-02f, -1.23183891e-01f, 8.73187333e-02f, -1.08847715e-01f, 3.76501307e-02f, 1.98494151e-01f,
  -3.37600298e-02f, 9.58318785e-02f, 5.31142391e-02f, 1.34773418e-01f, -1.55836731e-01f, 1.00578517e-01f, -1.20811127e-02f, -5.05874045e-02f, -8.29798430e-02f, -4.16827165e-02f,
  -7.75333047e-02f, -9.43534728e-03f, 1.27500743e-02f, 3.18410471e-02f, 8.32451656e-02f, 2.24754214e-01f, -8.50614533e-02f, 1.68062434e-01f, -1.19712658e-01f, 5.76894768e-02f,
  5.61312325e-02f, 6.65277019e-02f, -1.86203178e-02f, -5.88959865e-02f, -7.21011981e-02f, -2.06798650e-02f, 2.28691235e-01f, -8.91520604e-02f, -2.57786200e-03f, -1.00588828e-01f,
  1.74576283e-01f, 9.90020670e-03f, 2.65291054e-02f, 7.56596997e-02f, -9.68478248e-03f, 1.93566903e-02f, -3.51458080e-02f, 1.82018518e-01f, -8.65531266e-02f, -9.27699506e-02f,
  1.78956047e-01f, 3.64383012e-02f, 2.10892037e-01f, 6.59914017e-02f, 8.11313689e-02f, -7.71870986e-02f, 7.51659367e-03f, 1.07738569e-01f, -1.00667663e-01f, 2.82602683e-02f,
  -9.67437122e-03f, -1.53578311e-01f, 4.28062975e-02f, -3.49188782e-02f, 4.52395566e-02f, 4.45892289e-02f, -9.80619565e-02f, 2.76979664e-03f, -9.42278802e-02f, 1.24469720e-01f,
  1.82691082e-01f, 2.34204214e-02f, -1.80106699e-01f, -7.23397285e-02f, 3.53157632e-02f, 1.62718836e-02f, -4.01460938e-02f, -1.75947413e-01f, -1.59373477e-01f, 8.23911652e-02f,
  -4.81586643e-02f, -4.35038954e-02f, 2.28655990e-02f, 1.20516710e-01f, -1.10237569e-01f, 4.05664667e-02f, -1.00134080e-02f, 7.55271539e-02f, 1.41076639e-01f, 8.27226713e-02f,
  1.61959484e-01f, -3.53630446e-02f, -1.01666763e-01f, -2.98267771e-02f, -1.20546915e-01f, -9.74129587e-02f, 1.20160514e-02f, 7.34673440e-02f, 1.10646807e-01f, -2.85837171e-03f,
  1.13037281e-01f, -3.34915034e-02f, 8.92552510e-02f, -6.60440102e-02f, 1.87163144e-01f, -1.23930713e-02f, 7.73715153e-02f, -6.40092641e-02f, -9.38286781e-02f, 4.73112464e-02f,
  -2.12224405e-02f, 1.10647939e-01f, -1.07063819e-02f, -4.62436378e-02f, -7.82643035e-02f, 9.39074010e-02f, 2.00530320e-01f, 1.11514710e-01f, -6.49913624e-02f, -7.11967573e-02f,
  1.07105874e-01f, -7.80665204e-02f, -1.49518237e-01f, -4.64643687e-02f, -6.45358930e-04f, -1.44430017e-02f, -6.51189359e-04f, 3.17585021e-02f, -3.19435000e-02f, 7.44832754e-02f,
  -1.76325649e-01f, 3.59441414e-02f, 9.62564722e-02f, -3.93867530e-02f, 1.78246528e-01f, -3.31033729e-02f, -1.25699237e-01f, -1.09612815e-01f, 5.22303954e-02f, -1.14435086e-03f,
  -7.09574446e-02f, -1.69678144e-02f, 7.93854743e-02f, 7.40448609e-02f, -1.05605006e-01f, -4.34926637e-02f, 1.00436874e-01f, 8.14528912e-02f, -3.93298361e-03f, -3.79813872e-02f,
  5.29724546e-02f, 2.55920701e-02f, -8.60534012e-02f, -8.32863301e-02f, -6.39095604e-02f, -1.52905879e-04f, 1.22334741e-01f, 7.37936199e-02f, -8.56679231e-02f, -3.96575034e-02f,
  6.85180575e-02f, -6.16886094e-03f, -1.10583575e-02f, 7.59566575e-02f, -1.42328965e-04f, -5.65617979e-02f, 9.88749042e-02f, -8.84434655e-02f, -2.50239857e-02f, -3.01518403e-02f,
  8.27512741e-02f, 5.10344375e-03f, 2.98898201e-02f, 7.48993158e-02f, 8.25368017e-02f, -7.99341351e-02f, 6.07524924e-02f, -9.00415182e-02f, 2.96289697e-02f, 1.21397279e-01f,
  -3.41310054e-02f, -8.53189901e-02f, -2.81221736e-02f, 9.86169577e-02f, 2.16328502e-02f, 6.40110299e-02f, -5.79669774e-02f, 7.59417862e-02f, 5.26698120e-02f, -4.92310226e-02f,
  9.89565030e-02f, 8.50734115e-02f, 6.77516982e-02f, 1.02593601e-02f, 1.20611966e-01f, -5.90918511e-02f, -5.80158792e-02f, -1.25925660e-01f, -3.39744613e-02f, -3.69643345e-02f,
  -7.81868324e-02f, 1.98784173e-02f, -3.65412235e-02f, -1.87858008e-02f, -1.03507847e-01f, 4.18410674e-02f, -3.56276147e-02f, -8.82783383e-02f, -1.18866965e-01f, -1.51404098e-01f,
  4.85839769e-02f, 2.76630111e-02f, -2.82454072e-03f, -7.72133395e-02f, 5.48147969e-02f, -7.75171891e-02f, -1.74734704e-02f, -1.11022115e-01f, 4.15975489e-02f, 8.92106742e-02f,
  -1.03758857e-01f, 2.49064565e-02f, 1.14490099e-01f, 1.22772068e-01f, 8.43026787e-02f, 1.25505254e-01f, -1.53654683e-02f, 9.22666490e-02f, 1.75799906e-01f, -7.38125145e-02f,
  -1.11954056e-01f, -8.18541497e-02f, -1.96213853e-02f, 1.07715175e-01f, -1.15135387e-01f, -1.11036755e-01f, 6.02166839e-02f, -8.15473273e-02f, 8.61777961e-02f, -3.63322683e-02f,
  1.28035396e-01f, -1.17136873e-01f, 1.35643303e-01f, 1.16391651e-01f, -4.25835997e-02f, -1.13656700e-01f, 1.14351146e-01f, -4.62793820e-02f, -7.64022321e-02f, 8.39514937e-03f,
  -7.29060769e-02f, 9.84239876e-02f, 5.25057316e-02f, -4.76762727e-02f, 2.79863626e-02f, -4.47389856e-02f, -2.31261179e-02f, -9.08164307e-02f, -1.14486270e-01f, 4.82614078e-02f,
  9.36713666e-02f, 3.17291506e-02f, 8.17735214e-03f, -9.33664367e-02f, 2.20274895e-01f, 3.43694836e-02f, -3.46615948e-02f, 3.96080650e-02f, -2.04035849e-03f, 1.83281958e-01f,
  2.33075410e-01f, 3.29746827e-02f, 9.07524824e-02f, -4.92305830e-02f, -9.46696550e-02f, -1.40373722e-01f, -4.36772667e-02f, 3.24869864e-02f, -1.23133846e-01f, 1.15305223e-01f,
  5.06001711e-02f, 3.79345268e-02f, -3.26592848e-02f, -9.79498625e-02f, -1.16044104e-01f, -7.78845176e-02f, 6.09263703e-02f, -6.48213401e-02f, -4.45170924e-02f, -6.78410986e-03f,
  1.40120253e-01f, 2.18747750e-01f, 8.66171438e-03f, 2.02594101e-01f, -6.84269592e-02f, 1.08773522e-01f, 1.10403284e-01f, 1.19307242e-01f, -3.01647075e-02f, -1.02767177e-01f,
  8.12394023e-02f, 1.47923440e-01f, 1.87173672e-02f, 3.58771160e-02f, -5.53966239e-02f, 1.26210600e-01f, 3.36018465e-02f, -1.56885639e-01f, -2.49722913e-01f, 2.01820675e-02f,
  -6.19188733e-02f, 9.25120413e-02f, 8.30163360e-02f, -4.43992876e-02f, 2.95895841e-02f, 2.02265412e-01f, 1.29721954e-01f, 2.98431456e-01f, -1.23151891e-01f, 1.79512408e-02f,
  6.58933166e-03f, 2.63527203e-02f, -1.05539635e-01f, 1.23716012e-01f, 1.10319860e-01f, -4.12836717e-03f, -8.94088969e-02f, -9.81905218e-03f, 1.51384860e-01f, 1.15768492e-01f,
  1.01267412e-01f, 1.18558638e-01f, 1.98586375e-01f, 1.87057003e-01f, 8.07754546e-02f, 1.60226166e-01f, 1.18159913e-01f, 1.19777195e-01f, -1.73345014e-01f, -2.47462168e-01f,
  2.33339574e-02f, -8.05899203e-02f, 8.13769475e-02f, 1.97502717e-01f, 1.86459333e-01f, 7.80355930e-02f, 4.32177534e-04f, -2.26552635e-02f, 3.76852006e-02f, -3.48453899e-03f,
  1.06873356e-01f, -1.64904252e-01f, -2.15913560e-02f, 8.39913636e-03f, 9.34341997e-02f, 1.40972054e-02f, 1.77352697e-01f, -1.32068917e-01f, -9.73840132e-02f, 4.17903662e-02f,
  2.39863425e-01f, -5.13364328e-03f, -6.55103773e-02f, -1.35360345e-01f, -6.57542795e-02f, 1.00495741e-01f, 4.95134480e-02f, 5.80066182e-02f, -1.11521795e-01f, -1.97781414e-01f,
  1.58638030e-01f, -1.25745004e-02f, -2.74213433e-01f, 1.27881676e-01f, -7.63883218e-02f, 1.64318774e-02f, -1.02929719e-01f, -5.42847477e-02f, 2.68535733e-01f, 2.29224265e-01f,
  1.55777246e-01f, 1.28109017e-02f, -1.45765409e-01f, -1.46451676e-02f, 4.37327176e-02f, -8.24235380e-02f, 1.85584933e-01f, -9.99450404e-03f, -1.01220809e-01f, 1.77486330e-01f,
  -1.96684331e-01f, -1.19186506e-01f, 1.05115451e-01f, 1.52931754e-02f, 3.73765305e-02f, 3.78194153e-02f, -1.19579444e-02f, -6.31242692e-02f, -1.42385840e-01f, -2.35790104e-01f,
  1.69891521e-01f, -1.46049811e-02f, 1.87232614e-01f, 9.85852852e-02f, -3.83734666e-02f, 1.14581831e-01f, 3.57872359e-02f, -1.15766294e-01f, 1.61466926e-01f, -8.21665768e-03f,
  1.62415087e-01f, 1.14160562e-02f, 7.20068952e-03f, -1.37011662e-01f, -1.61737315e-02f, 2.13010967e-01f, -4.10244204e-02f, 6.75064772e-02f, -1.53573096e-01f, -1.42310649e-01f,
  -1.82780743e-01f, 3.11534792e-01f, -1.14827871e-01f, -8.83099139e-02f, -1.83535379e-03f, -6.20035827e-02f, -2.42058909e-03f, 7.11126998e-02f, 3.74809504e-02f, -2.29346305e-02f,
  -4.79691587e-02f, 1.81376606e-01f, 8.83305669e-02f, 8.23950991e-02f, 9.23689008e-02f, -4.17505242e-02f, 4.02549319e-02f, -2.13982854e-02f, -1.43946826e-01f, -1.14877276e-01f,
  -1.69505365e-02f, 1.69254884e-01f, 2.80393898e-01f, 1.15123205e-01f, 9.10224542e-02f, -1.16063073e-01f, -1.05993614e-01f, 1.96256395e-02f, -1.15816653e-01f, 1.12987421e-01f,
  1.44143760e-01f, -1.45761147e-01f, 3.01779807e-01f, -5.19309193e-02f, 2.04656422e-01f, 8.58091842e-03f, -4.72239293e-02f, 8.20555836e-02f, 6.93877488e-02f, 1.41886026e-01f,
  4.09565046e-02f, -9.57495198e-02f, -1.19126551e-01f, 1.87006313e-03f, -2.28830323e-01f, -9.60921720e-02f, -1.20089039e-01f, -9.00494773e-03f, -1.03155347e-02f, 1.04557052e-01f,
  8.09980705e-02f, 1.41529813e-01f, 2.72643745e-01f, 1.70586050e-01f, 2.14589849e-01f, 3.79710831e-02f, -8.73926505e-02f, 1.54443562e-01f, 1.10577174e-01f, -6.66685104e-02f,
  -1.21827871e-01f, -6.98655099e-02f, -5.07242717e-02f, -2.80189961e-01f, 2.55014896e-01f, -1.12575181e-02f, -2.27536429e-02f, -2.47860490e-03f, 3.98220569e-01f, -7.61522800e-02f,
  7.16933683e-02f, 1.67019978e-01f, 2.62407027e-03f, 5.50564118e-02f, 8.93547460e-02f, 1.28243193e-01f, 1.00235511e-02f, 1.12333074e-01f, 2.06884593e-02f, -8.10071528e-02f,
  2.79407650e-01f, 1.83015689e-01f, 6.10056594e-02f, 8.09517503e-02f, -1.22672364e-01f, 7.28208870e-02f, -1.18945152e-01f, -2.22903505e-01f, -1.34321511e-01f, -9.60122868e-02f,
  -1.02337822e-01f, 1.22448556e-01f, 5.03220819e-02f, 2.03080982e-01f, 3.43104154e-02f, -1.06509402e-01f, 2.76152194e-02f, -2.64228564e-02f, 2.79119432e-01f, -2.01336155e-03f,
  -4.46286723e-02f, -6.84309229e-02f, -4.38656397e-02f, 1.07741401e-01f, -8.00158307e-02f, -1.03274593e-02f, 8.51337537e-02f, 1.29455864e-01f, 8.89251307e-02f, 6.22885041e-02f,
  3.66447419e-02f, 3.26923877e-02f, 1.07778627e-02f, 1.07865850e-03f, -8.69645104e-02f, -6.48316368e-02f, 6.30950136e-03f, -6.37266859e-02f, 1.12557247e-01f, 9.54910517e-02f,
  -6.43954128e-02f, 2.92361490e-02f, -4.36142273e-02f, 1.12883382e-01f, 7.80394003e-02f, -9.26267132e-02f, 9.18749049e-02f, 4.15538289e-02f, -6.26585111e-02f, -2.19126604e-02f,
  6.37047887e-02f, 3.19859982e-02f, -1.10226244e-01f, 7.36628622e-02f, -9.80310515e-02f, 2.67371838e-03f, 5.77510372e-02f, -1.18934423e-01f, 8.34181905e-02f, -5.29190935e-02f,
  -1.05162315e-01f, 8.06671381e-02f, 7.08176494e-02f, 9.20687057e-03f, 1.08348630e-01f, -4.86931466e-02f, 4.39188741e-02f, -3.32878642e-02f, -6.65379316e-02f, -9.82327312e-02f,
  9.13266614e-02f, -3.74888182e-02f, -3.69012132e-02f, -3.63609493e-02f, 1.30917028e-01f, -7.53054693e-02f, -6.63758889e-02f, -5.19562326e-02f, 6.46611378e-02f, -9.67363566e-02f,
  -3.69190387e-02f, 4.55729887e-02f, -5.43227307e-02f, -8.26617628e-02f, 1.02479286e-01f, -1.90369319e-02f, 1.53717130e-01f, -1.50996994e-03f, 1.09455124e-01f, 1.49237365e-01f,
  -8.23501125e-02f, -2.50672996e-02f, 7.51888659e-03f, -8.96789208e-02f, -3.40835154e-02f, -5.65583184e-02f, 9.65801254e-02f, -2.69438662e-02f, -1.11024514e-01f, -1.37540981e-01f,
  3.00531220e-02f, -3.31795737e-02f, -5.59783773e-03f, 7.34047033e-03f, -1.03666358e-01f, 2.27853972e-02f, 8.73021334e-02f, 2.83469483e-02f, -8.68358165e-02f, -5.20210415e-02f,
  -7.84687623e-02f, 5.48959523e-02f, -9.19389874e-02f, 2.14866608e-01f, -7.66092315e-02f, 1.53692871e-01f, -6.00818321e-02f, 1.33628333e-02f, 5.99030629e-02f, 1.19970523e-01f,
  1.37213230e-01f, 5.63357435e-02f, -1.01028131e-02f, 9.03696716e-02f, 2.54937261e-02f, 9.10363421e-02f, -1.59502644e-02f, -5.66926450e-02f, -4.27656509e-02f, -6.34115562e-02f,
  -2.10379474e-02f, 8.01145379e-03f, 3.23877931e-02f, 2.14048266e-01f, -7.36070098e-03f, 1.70173235e-02f, -3.34649794e-02f, 2.01198742e-01f, 1.00176588e-01f, 2.81972047e-02f,
  9.38501507e-02f, 1.26579612e-01f, 9.56478566e-02f, -8.05054903e-02f, 3.08866668e-02f, -8.53511468e-02f, 1.82136476e-01f, -1.53607894e-02f, 8.32419749e-03f, 4.92001362e-02f,
  9.23384428e-02f, 4.69193831e-02f, -1.26402289e-01f, -1.93508323e-02f, 1.02810927e-01f, -9.95765254e-02f, -6.90170676e-02f, 1.14499144e-02f, 1.61020562e-01f, 8.20202604e-02f,
  5.56841940e-02f, -5.14527969e-03f, -1.69197582e-02f, -2.25299131e-02f, -6.81829676e-02f, -6.55813143e-02f, 1.40537113e-01f, -1.28271580e-01f, 7.22313896e-02f, -9.40394253e-02f,
  -1.12941610e-02f, -6.20915517e-02f, -1.13644384e-01f, 8.91128033e-02f, -1.44055793e-02f, 1.52969077e-01f, -2.61130393e-03f, 4.73232865e-02f, 1.05526440e-01f, -9.13727582e-02f,
  5.82458787e-02f, 4.89017889e-02f, 5.21242560e-04f, 9.61896181e-02f, 1.16921635e-02f, -5.49612455e-02f, 1.48648787e-02f, 9.57013220e-02f, -2.05373336e-02f, 1.25589652e-03f,
  -9.88367721e-02f, 2.09791008e-02f, -9.52379219e-03f, -1.40797108e-01f, 9.60548222e-02f, -1.06740311e-01f, -3.85665596e-02f, 5.25982194e-02f, 5.51050007e-02f, -7.89252222e-02f,
  1.40946239e-01f, 6.07009940e-02f, 9.27918330e-02f, -3.87596898e-03f, 7.60971531e-02f, -1.66160017e-02f, -1.35850072e-01f, -2.81744841e-02f, 1.17043242e-01f, 1.27301052e-01f,
  -2.85088103e-02f, -6.80021346e-02f, -1.10462144e-01f, -8.20354372e-02f, 5.53631112e-02f, 1.12153575e-05f, 5.20419888e-02f, -2.49170996e-02f, -3.18087637e-02f, 7.00853541e-02f,
  -3.94712500e-02f, -1.13333806e-01f, 8.11253414e-02f, 1.20023057e-01f, 1.77389104e-02f, 5.94702996e-02f, 3.67775443e-03f, -8.86621177e-02f, 2.87042058e-04f, -2.08409369e-01f,
  1.59718677e-01f, -1.11687660e-01f, -9.87550914e-02f, -2.46082153e-02f, -7.32970685e-02f, -1.90412067e-03f, -6.91436231e-02f, -3.92089710e-02f, 7.37720206e-02f, -2.64616739e-02f,
  1.16922528e-01f, -3.36302817e-02f, 2.37434451e-02f, -8.54812264e-02f, -3.01837046e-02f, 5.24386875e-02f, -1.22797891e-01f, 1.31815402e-02f, 1.38519391e-01f, -8.60829204e-02f,
  -6.35884479e-02f, -1.18180521e-01f, 7.60927349e-02f, 1.30772650e-01f, -1.16922595e-01f, 8.97331014e-02f, 2.66846046e-02f, 1.45153049e-02f, -8.54983628e-02f, 1.05678149e-01f,
  -2.54927054e-02f, 9.48751345e-02f, -6.13601357e-02f, 1.09118000e-01f, -5.74345626e-02f, 1.23489246e-01f, 3.89405712e-02f, -1.17829606e-01f, 1.10916635e-02f, -1.13619231e-01f,
  -6.35226220e-02f, -6.64123148e-02f, -3.28548811e-02f, -5.52657805e-03f, 1.25466079e-01f, -3.88906673e-02f, -3.86835597e-02f, -1.57881994e-02f, 7.91152492e-02f, -3.21345441e-02f,
  4.05769385e-02f, -1.34916306e-02f, -6.74343109e-03f, -3.86744626e-02f, -1.10200047e-01f, 4.91393320e-02f, -1.32650686e-02f, 7.55510032e-02f, -1.67854410e-02f, -3.07011325e-02f,
  4.91012409e-02f, 2.66120583e-02f, -7.30634853e-03f, -6.31688759e-02f, 3.47938854e-03f, 7.79482478e-04f, 5.37541546e-02f, 9.79422927e-02f, -5.29345423e-02f, -8.18331912e-02f,
  -2.33495608e-02f, -3.37252691e-02f, -9.06465426e-02f, 3.02807838e-02f, 4.44731712e-02f, -1.23505645e-01f, 3.34674455e-02f, 9.49116722e-02f, -5.10202460e-02f, -1.12790585e-01f,
  -1.02884278e-01f, -6.54576952e-03f, -1.18735760e-01f, -9.30119157e-02f, 1.12407841e-01f, 6.59478009e-02f, -3.90080996e-02f, -9.06918123e-02f, 1.00897923e-01f, -7.58846775e-02f,
  -7.06759421e-03f, 8.84584710e-02f, -8.83905366e-02f, 8.56561959e-02f, 1.50446559e-03f, -1.11390561e-01f, 8.90699308e-03f, -9.89083201e-02f, -2.87921336e-02f, -5.76430298e-02f,
  -5.51894270e-02f, 8.33990946e-02f, 3.02374084e-02f, -1.06251821e-01f, -2.65972018e-02f, 7.57733956e-02f, -3.97745743e-02f, -4.38487232e-02f, 5.72424047e-02f, -4.47312370e-03f,
  1.15427166e-01f, 4.01106253e-02f, 9.97102112e-02f, -1.86488219e-03f, 8.19453374e-02f, 1.66864961e-01f, 2.25517750e-01f, 7.39789056e-03f, 4.47673127e-02f, -5.91778271e-02f,
  7.56940618e-02f, 6.78068772e-02f, -4.24917638e-02f, 5.02672605e-02f, -1.29948303e-01f, -1.43647846e-02f, 3.47491689e-02f, -7.59319589e-02f, 5.46597242e-02f, 1.14659905e-01f,
  -6.70452192e-02f, -1.64530240e-02f, -4.64056879e-02f, 8.26116726e-02f, 8.56637582e-02f, 1.56365588e-01f, 9.11384448e-03f, 3.47081065e-01f, -1.44958943e-01f, 2.35560596e-01f,
  3.55417356e-02f, 1.11366056e-01f, 1.53552711e-01f, 7.86416307e-02f, 1.38799213e-02f, -5.31409569e-02f, -2.38985103e-02f, -4.90211174e-02f, 3.23550105e-02f, -3.43030766e-02f,
  3.62909772e-02f, 5.56999445e-02f, -1.66725978e-01f, -7.35343108e-03f, 1.09585579e-02f, 9.20888409e-02f, 9.22164246e-02f, 2.67788917e-02f, -8.61611217e-02f, 9.43315923e-02f,
  -5.93639687e-02f, 1.77835450e-01f, 1.33269206e-01f, 2.50653684e-01f, -1.31134644e-01f, -7.58479089e-02f, -4.93896157e-02f, 1.70534223e-01f, -6.26690984e-02f, 2.53987368e-02f,
  2.33531579e-01f, -1.22907609e-01f, -5.57805076e-02f, 4.49903086e-02f, -6.08500056e-02f, -8.49072784e-02f, -2.96213832e-02f, -7.21773729e-02f, -6.44740611e-02f, -1.42406002e-01f,
  -3.47653776e-02f, 4.47313786e-02f, 3.63952853e-03f, 6.35845661e-02f, 9.44425538e-02f, 2.03117821e-02f, 1.23821557e-01f, -6.26416504e-02f, -2.83933394e-02f, 7.09397569e-02f,
  1.41054511e-01f, -1.44769877e-01f, 1.42705902e-01f, -1.24781393e-01f, 7.65817836e-02f, -1.66412830e-01f, -5.47980554e-02f, 1.31510288e-01f, 1.94230732e-02f, 1.64820537e-01f,
  1.58177279e-02f, 1.30177855e-01f, 3.18668485e-02f, 4.94594015e-02f, -4.25657667e-02f, 5.19997738e-02f, 2.22285893e-02f, 1.12150416e-01f, -2.93329060e-02f, -5.89083321e-02f,
  4.61297892e-02f, -1.39184356e-01f, -9.61657763e-02f, 5.64405993e-02f, 1.60036117e-01f, -2.53435541e-02f, -1.58624947e-01f, -7.95334280e-02f, -5.20348400e-02f, 5.52831814e-02f,
  -8.85785446e-02f, 7.51784146e-02f, 3.68872061e-02f, -8.57675597e-02f, 1.09132394e-01f, 4.95315753e-02f, 3.11749019e-02f, -3.31147611e-02f, -1.27822468e-02f, -6.61804248e-03f,
  -1.03470467e-01f, 2.20629517e-02f, 4.63259220e-02f, -3.10356095e-02f, 8.73171911e-02f, 2.02836916e-02f, 1.65139232e-02f, -1.07214779e-01f, -3.51688340e-02f, 1.42661303e-01f,
  1.46167010e-01f, -2.65728887e-02f, 1.56111687e-01f, 1.79889664e-01f, 9.92092416e-02f, -1.54408170e-02f, -8.68410245e-02f, 2.49562133e-02f, 9.75168943e-02f, -1.95765898e-01f,
  2.49614269e-02f, -5.06140403e-02f, 5.82965044e-03f, -4.78212498e-02f, -5.45433946e-02f, 8.16212744e-02f, -8.75844657e-02f, -8.78078640e-02f, -1.98303256e-02f, 1.65536795e-02f,
  -1.15447706e-02f, 7.83692896e-02f, 4.59395684e-02f, -1.78113244e-02f, 7.57410079e-02f, 2.00882996e-03f, -9.25866794e-03f, -1.69398952e-02f, 1.24160431e-01f, -9.42215547e-02f,
  3.49377329e-03f, -9.59180202e-03f, -1.64200477e-02f, 5.31168059e-02f, 3.27698402e-02f, 3.47655267e-02f, -9.24688131e-02f, -8.37657005e-02f, -3.18061076e-02f, -1.60708074e-02f,
  7.19086304e-02f, 7.57821882e-03f, -7.92217404e-02f, -5.48055470e-02f, 7.49992281e-02f, 1.18434720e-01f, 2.36441623e-02f, 6.58945218e-02f, -2.11518239e-02f, 4.28910851e-02f,
  1.33401752e-01f, 2.18635909e-02f, 1.08011745e-01f, 8.50145891e-02f, 2.76280046e-02f, -3.67512144e-02f, -9.99443904e-02f, -1.16687499e-01f, 1.89300969e-01f, -9.28775445e-02f,
  -8.39040428e-02f, 7.62523264e-02f, 2.33748704e-02f, -1.22625060e-01f, 5.16755432e-02f, -8.77277553e-02f, 1.07182652e-01f, 3.93267162e-02f, 1.29019707e-01f, 5.70163094e-02f,
  7.92335346e-02f, -5.14340512e-02f, -8.89934320e-03f, -3.87095474e-02f, -3.61957699e-02f, -5.91003299e-02f, -2.81746197e-03f, -9.07887444e-02f, -1.15857899e-01f, 6.53999150e-02f,
  8.47234130e-02f, 6.10507838e-02f, -3.05515341e-03f, -8.79342780e-02f, -8.51573721e-02f, 2.74626929e-02f, 6.55592838e-03f, -5.58121987e-02f, -1.08591206e-01f, -7.79485628e-02f,
  4.50804681e-02f, -8.88562016e-03f, 5.25658987e-02f, -4.32980396e-02f, 1.81568321e-02f, 1.61590725e-02f, 4.48564477e-02f, 5.23996167e-02f, -9.59685817e-02f, 7.93729648e-02f,
  3.31384316e-02f, 8.66991803e-02f, -1.36929937e-02f, 2.63297278e-02f, 1.15131773e-01f, 7.80707151e-02f, -5.78205250e-02f, -3.19925286e-02f, -4.32767048e-02f, -3.78650427e-02f,
  2.19187811e-02f, -1.20480932e-01f, -5.38148843e-02f, -1.01262778e-01f, 1.19364217e-01f, -3.26250792e-02f, 6.05134629e-02f, -5.60599416e-02f, -7.76190236e-02f, -4.05262187e-02f,
  8.25602263e-02f, -2.00817715e-02f, 2.99539026e-02f, 1.03077047e-01f, -9.84496027e-02f, -6.60344735e-02f, 2.34817024e-02f, 4.54560202e-03f, -4.10811305e-02f, -4.62155491e-02f,
  -5.43321669e-02f, -7.03807473e-02f, -5.23455366e-02f, 2.34834617e-03f, -1.75935313e-01f, -3.13644893e-02f, 9.98241268e-03f, -5.88074476e-02f, 3.30293737e-03f, -1.51383979e-02f,
  6.02419898e-02f, 9.60754901e-02f, 5.64288385e-02f, -8.45730454e-02f, 1.24558777e-01f, -6.45941049e-02f, -2.37420090e-02f, 6.83106035e-02f, 6.56424910e-02f, -6.46457598e-02f,
  3.98655375e-03f, -4.78249006e-02f, 1.46249589e-02f, -1.37262255e-01f, 9.68868434e-02f, -8.55211839e-02f, 5.10483161e-02f, 8.09071288e-02f, 1.06903106e-01f, -1.09848350e-01f,
  6.55675456e-02f, -3.51116323e-05f, -7.84387216e-02f, -1.19773179e-01f, 4.00612205e-02f, -7.86494184e-03f, 1.02170877e-01f, -9.50321257e-02f, -1.90196745e-02f, 1.85112841e-02f,
  1.87588841e-01f, 1.58539899e-02f, 1.52865415e-02f, 4.20449376e-02f, 1.25954971e-01f, 1.27320603e-01f, -4.51851673e-02f, -3.35993730e-02f, -2.00616457e-02f, -6.35286868e-02f,
  -6.14244957e-03f, -6.66360110e-02f, -1.15669936e-01f, -2.11767275e-02f, 7.23540485e-02f, -1.05899185e-01f, -7.40204975e-02f, 1.00848526e-01f, 1.04306906e-01f, 4.90984544e-02f,
  3.60117760e-03f, 6.83813468e-02f, 1.53008536e-01f, -5.83957136e-02f, 1.22006647e-01f, -4.44975384e-02f, -2.04090863e-01f, 1.87888205e-01f, -1.34504154e-01f, 1.65039441e-03f,
  -2.02233315e-01f, -2.61264876e-03f, -1.04533546e-01f, 4.28874083e-02f, 7.82848820e-02f, 1.84484839e-01f, 1.31518662e-01f, 1.17020518e-01f, -1.14811353e-01f, -2.47567650e-02f,
  1.04656331e-01f, 2.47153178e-01f, -1.13563687e-01f, -9.62189361e-02f, -4.04971838e-02f, -1.55615538e-01f, -4.40800600e-02f, -6.80447221e-02f, 2.81649947e-01f, -1.31217847e-02f,
  -3.76131050e-02f, -4.68754135e-02f, 1.47996753e-01f, 4.67120446e-02f, 1.62337437e-01f, 9.78441313e-02f, 9.81023759e-02f, 1.06326967e-01f, 7.16441944e-02f, -1.31356856e-02f,
  -1.06366962e-01f, 4.44038250e-02f, 1.53952166e-01f, 1.12761430e-01f, 1.13469951e-01f, -2.30657943e-02f, 5.73139824e-02f, -2.83626169e-02f, -1.22781858e-01f, 1.16781346e-01f,
  -6.71082363e-02f, -2.02789947e-01f, -1.46595567e-01f, 1.21677861e-01f, 4.36358936e-02f, 8.96537006e-02f, -3.45296902e-03f, 8.96710008e-02f, 1.81611683e-02f, 4.71724086e-02f,
  -8.24739560e-02f, -1.27139881e-01f, 1.68265030e-01f, 8.19762349e-02f, -9.71498117e-02f, -6.06709383e-02f, 6.50713965e-02f, 6.94681257e-02f, 1.41174555e-01f, -5.95508143e-02f,
  -2.79077142e-02f, 5.13595119e-02f, -8.35650861e-02f, 8.22540447e-02f, 1.22472830e-01f, -5.20921350e-02f, -3.32556963e-02f, -7.68632665e-02f, 4.58492897e-02f, -3.14692408e-03f,
  -9.03353244e-02f, 1.82306826e-01f, -6.30890653e-02f, 8.16457868e-02f, -3.50045785e-02f, 1.80292949e-02f, -1.24977712e-04f, 5.14902361e-02f, -8.40619057e-02f, 8.08473900e-02f,
  -1.69669185e-02f, -6.78945780e-02f, -8.29531625e-02f, -7.12400749e-02f, 7.47716203e-02f, 2.32056435e-02f, -1.19536221e-01f, 3.02734249e-03f, 1.34714097e-01f, 9.62148458e-02f,
  9.53125209e-02f, -8.64975303e-02f, 1.23027436e-01f, -9.33436006e-02f, 8.53708610e-02f, 9.59783345e-02f, 1.58311084e-01f, 1.39519259e-01f, 6.23660907e-02f, -5.82392607e-03f,
  -3.80523279e-02f, 5.09380996e-02f, -1.13744631e-01f, 6.18606471e-02f, 1.25053719e-01f, -6.57234043e-02f, -2.81902757e-02f, -5.30239791e-02f, -6.00111373e-02f, -4.35323827e-02f,
  -5.71348071e-02f, -6.73145242e-03f, 8.62338170e-02f, 4.97352006e-03f, 3.09906658e-02f, 9.83406305e-02f, -9.22237560e-02f, -5.21973930e-02f, -6.88497722e-02f, 4.25693654e-02f,
  5.32514267e-02f, 1.92498602e-02f, -2.95263361e-02f, -3.03936936e-02f, -9.53629613e-02f, 1.04651405e-02f, -2.37465817e-02f, -1.52136860e-02f, -2.88536604e-02f, -1.97398409e-01f,
  -1.20849602e-01f, -1.27365608e-02f, 2.69597489e-02f, -6.55378550e-02f, -1.92699321e-02f, -1.94487981e-02f, -1.21901467e-01f, 1.68197393e-01f, 9.20123532e-02f, 1.82854563e-01f,
  -1.19414076e-01f, -1.61040112e-01f, -1.18866354e-01f, -7.23171532e-02f, 1.45298883e-01f, 2.20850967e-02f, 2.56905317e-01f, -1.61855802e-01f, 2.47074701e-02f, -1.95177626e-02f,
  2.52504885e-01f, -1.00638784e-01f, 2.16583505e-01f, 1.81284949e-01f, -1.47528961e-01f, -1.86014790e-02f, -5.76898903e-02f, -9.34207737e-02f, -3.95806246e-02f, 2.45511547e-01f,
  1.33608818e-01f, 1.26338229e-01f, 2.33788475e-01f, 1.67761892e-01f, 5.56850210e-02f, -4.61957268e-02f, -4.27581817e-02f, -6.63875416e-02f, -2.27615580e-01f, 1.55389495e-02f,
  9.79131013e-02f, 1.68108597e-01f, 2.75663063e-02f, 3.49481478e-02f, 7.00405985e-02f, 1.67859569e-01f, 1.13205826e-02f, 6.06198981e-03f, -1.50505170e-01f, 1.47529887e-02f,
  -7.83390030e-02f, -6.94361776e-02f, 1.04070112e-01f, -1.61118805e-02f, -3.07443477e-02f, 1.40910894e-01f, 1.63774982e-01f, 1.32177234e-01f, 1.41619670e-03f, 6.04587570e-02f,
  -5.29909059e-02f, -1.05348393e-01f, -1.19301945e-01f, -1.31679490e-01f, 1.01453297e-01f, -4.40540835e-02f, 3.64550538e-02f, 1.06273085e-01f, 7.19963387e-02f, 8.35185200e-02f,
  -1.32066086e-01f, -5.15505448e-02f, 4.32397984e-02f, 1.07441477e-01f, -1.79043114e-02f, -1.73427507e-01f, -1.22566037e-01f, -1.59975171e-01f, -1.02838427e-01f, -1.09639719e-01f,
  1.92337483e-01f, -1.73571259e-01f, -1.09905332e-01f, 1.87112875e-02f, 2.63126194e-01f, 5.33479489e-02f, 8.27709362e-02f, -3.15685868e-02f, -1.18099898e-01f, 1.83208302e-01f,
  6.07797503e-02f, 6.74308510e-04f, -2.71872971e-02f, 4.07967716e-02f, 1.79560445e-02f, 1.74231127e-01f, 2.82183886e-02f, 9.34353285e-03f, -3.67146134e-02f, 8.74655768e-02f,
  -1.25375688e-01f, 9.75021496e-02f, -7.40998238e-02f, -8.62022713e-02f, -5.14693595e-02f, 3.41864713e-02f, -5.74611053e-02f, 5.89956939e-02f, 5.13429902e-02f, 7.04965293e-02f,
  6.54881224e-02f, 7.80553594e-02f, -1.45397009e-02f, -5.80894500e-02f, 1.26143247e-01f, 9.60590318e-02f, 9.08426195e-02f, -1.25043333e-01f, -1.51891291e-01f, -1.69079989e-01f,
  -5.18421046e-02f, -2.72160750e-02f, -1.09635003e-01f, 7.30383694e-02f, 1.00580208e-01f, -8.34277868e-02f, -5.13325334e-02f, 1.46309242e-01f, 1.12403512e-01f, 1.28378779e-01f,
  7.52621666e-02f, 1.00342222e-01f, 2.46176049e-01f, 9.16783959e-02f, 3.69755551e-02f, -6.62833452e-02f, 9.54297855e-02f, 8.32117125e-02f, -8.53427798e-02f, -1.70344129e-01f,
  -2.84703095e-02f, -8.65501091e-02f, -8.22018757e-02f, -1.55189320e-01f, -6.93666860e-02f, 1.11991428e-01f, 1.06834181e-01f, 1.09747685e-01f, 2.67224699e-01f, -1.02760874e-01f,
  -9.85395163e-02f, -1.38893485e-01f, 1.22004956e-01f, -6.49916232e-02f, 1.46398954e-02f, 2.27112770e-01f, 1.22682929e-01f, -9.46909934e-02f, 1.39190480e-01f, 9.50431265e-03f,
  -5.00985831e-02f, 2.12443098e-01f, -1.09335363e-01f, 9.75549817e-02f, -6.64826110e-02f, 3.65652926e-02f, -9.56450477e-02f, 3.56572941e-02f, 7.35079199e-02f, 1.44811958e-01f,
  -6.42109662e-02f, 1.20318793e-01f, -5.40161170e-02f, 1.07833743e-01f, 1.78030044e-01f, 1.50116578e-01f, 6.63954243e-02f, 8.38260576e-02f, 1.96042508e-01f, 2.02267244e-03f,
  -7.88456202e-02f, 3.04192938e-02f, 6.25099540e-02f, -4.71559130e-02f, 5.08665852e-02f, -1.85431421e-01f, -1.55442789e-01f, -4.64481674e-02f, 2.26240121e-02f, 1.06124863e-01f,
  3.95258516e-02f, -1.70790985e-01f, 2.71532629e-02f, -8.83586183e-02f, -6.35792762e-02f, 1.57120094e-01f, -1.91202492e-01f, 2.14606792e-01f, -1.32022426e-02f, 4.96826507e-02f,
  6.42982349e-02f, -3.97404619e-02f, 3.90500613e-02f, -9.44460109e-02f, 9.05806050e-02f, -2.40448490e-02f, 7.37962648e-02f, -6.50086030e-02f, 1.06189527e-01f, -2.69362554e-02f,
  4.23665829e-02f, -1.00634858e-01f, 5.38553623e-03f, -9.48405936e-02f, -1.52268596e-02f, 1.23940796e-01f, 7.81050175e-02f, 8.17807540e-02f, 8.10633525e-02f, -1.41905084e-01f,
  -9.55256522e-02f, 5.36568798e-02f, 1.49088409e-02f, -2.00159885e-02f, 1.52048558e-01f, -3.02643962e-02f, -4.38209884e-02f, 4.33605611e-02f, -7.63326883e-02f, -1.10587761e-01f,
  2.00759888e-01f, 2.15365477e-02f, 5.39061911e-02f, -1.83224097e-01f, 2.56328825e-02f, 3.73481289e-02f, 1.16279893e-01f, -1.80988628e-02f, 1.38390899e-01f, -1.18146405e-01f,
  1.46486908e-01f, -5.70738353e-02f, -5.55667579e-02f, -5.42329391e-03f, -9.77057815e-02f, -7.77324587e-02f, 1.75630763e-01f, 1.43224373e-01f, 1.09248720e-01f, 3.95978801e-02f,
  -9.21237841e-02f, -2.42178917e-01f, 6.77811820e-03f, -4.25657891e-02f, 1.94257960e-01f, -4.43318821e-02f, 2.93684937e-02f, 1.25845075e-01f, 4.97466139e-02f, -1.35564998e-01f,
  9.53253806e-02f, 9.65213105e-02f, -2.07513962e-02f, 4.41851355e-02f, -8.54272023e-02f, -1.99970640e-02f, 8.59265849e-02f, 1.37231976e-01f, -1.09728090e-01f, 8.57193246e-02f,
  -3.04719992e-02f, -2.27549095e-02f, -1.86559469e-01f, 4.41745557e-02f, 2.13570092e-02f, -5.81369847e-02f, -1.75734237e-01f, 6.93842722e-03f, 3.64431813e-02f, -4.27022800e-02f,
  6.48764595e-02f, -3.23833078e-02f, 4.76086140e-02f, -5.53496368e-02f, -2.42202524e-02f, -2.62803063e-02f, 8.74731243e-02f, 1.03676662e-01f, 1.55194476e-01f, 8.02793279e-02f,
  -1.26858801e-01f, -7.62463659e-02f, -9.39128995e-02f, 1.75697953e-01f, 1.33042049e-03f, 1.64371505e-01f, 1.24047406e-01f, -8.03458542e-02f, 8.09652149e-04f, -2.51491871e-02f,
  7.29160979e-02f, 5.35892993e-02f, -8.53077248e-02f, -9.34685841e-02f, 2.56291479e-01f, 1.68990910e-01f, 1.08007848e-01f, -1.16838462e-04f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  -5.71214072e-02f, 7.79654533e-02f, 2.32475638e-01f, 6.78171888e-02f, 3.21950205e-02f, 9.89720002e-02f, -7.53348991e-02f, -1.53608760e-02f, 1.47061050e-01f, 8.59095156e-02f,
  1.19679026e-01f, 2.11643465e-02f, 6.18193001e-02f, 1.54254869e-01f, 7.51634017e-02f, 9.36417878e-02f, -1.13390774e-01f, -5.50572947e-02f, -8.01644325e-02f, 2.48698965e-01f,
  1.41246393e-01f, -9.21356156e-02f, 2.06233077e-02f, 1.19649030e-01f, 2.13525202e-02f, 8.63129348e-02f, 6.37189001e-02f, 9.14839432e-02f, -8.89131278e-02f, 8.14420581e-02f,
  9.14490819e-02f, 8.16276446e-02f, 1.25099197e-01f, 4.91191782e-02f, 3.42107192e-02f, 1.13102175e-01f, 1.08769819e-01f, -4.28241976e-02f, -5.05575612e-02f, -9.56272259e-02f,
  3.89206745e-02f, -1.41893625e-01f, -1.10585196e-02f, -1.16829522e-01f, 1.13724142e-01f, 7.72075206e-02f, 9.59815457e-02f, 1.53234333e-01f, 8.19000229e-02f, 6.60306215e-02f,
  7.70738572e-02f, 7.99077228e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -3.88322502e-01f, -2.16538444e-01f, -9.32030380e-02f, -8.34367126e-02f, -2.95810848e-01f, -2.14310467e-01f, -1.90633833e-01f, 1.31803036e-01f, 7.78954700e-02f, 1.05163626e-01f,
  1.20534778e-01f, -3.99662890e-02f, 1.79148570e-01f, -1.79525511e-03f, -2.11713046e-01f, 1.75530910e-01f, -3.44422221e-01f, 9.62375849e-02f, -9.48132500e-02f, -2.71895736e-01f,
  -7.21788555e-02f, 2.17566475e-01f, 3.66873592e-02f, 1.40487716e-01f, -1.46722168e-01f, -2.19100881e-02f, -1.46254525e-01f, 5.73134865e-04f, 1.22321352e-01f, -2.71839321e-01f,
  1.53014734e-01f, 2.17619404e-01f, 3.40005100e-01f, -8.92283022e-02f, -4.60333467e-01f, -1.28537953e-01f, -3.81848693e-01f, 1.16374336e-01f, -1.05009511e-01f, 2.56363481e-01f,
  2.46260241e-01f, 4.55368869e-03f, -5.45024611e-02f, -2.78765112e-01f, -4.64594513e-02f, -1.44940674e-01f, 5.03849030e-01f, -1.16079345e-01f, -3.02554548e-01f, 3.54414657e-02f,
  2.06412300e-02f, -5.78759722e-02f, -3.71359468e-01f, -4.13745455e-02f, -5.40739186e-02f, 7.42497444e-02f, 2.26957053e-01f, 3.56426865e-01f, -7.75300041e-02f, 2.07586929e-01f,
  1.34806961e-01f, 2.51736432e-01f, -1.14522316e-01f, -5.73330447e-02f, -1.60792600e-02f, 1.73831806e-01f, 2.18221247e-01f, 3.71278152e-02f, 4.11057919e-01f, 1.75434649e-01f,
  -5.59156835e-01f, -3.40633750e-01f, 5.90473525e-02f, 2.49686763e-01f, 3.86734128e-01f, -4.10118476e-02f, -8.44936669e-02f, 1.04205534e-01f, -2.43719555e-02f, -7.67663419e-02f,
  -3.88675213e-01f, 1.45433784e-01f, 1.73666328e-02f, -3.97107780e-01f, -1.83760434e-01f, 1.05822338e-02f, 5.63509762e-02f, 4.26113516e-01f, -1.71341777e-01f, 1.42918989e-01f,
  -1.11018233e-01f, 4.90437210e-01f, 9.68247205e-02f, 2.35677779e-01f, -2.97155440e-01f, 3.02511513e-01f, 8.12602788e-02f, -2.35996395e-02f, -2.50316560e-01f, -5.31577289e-01f,
  2.95075867e-02f, -1.06776632e-01f, -1.82809550e-02f, 2.87088960e-01f, 1.79994956e-01f, -1.46965027e-01f, 1.59719899e-01f, -5.69373429e-01f, -2.36389220e-01f, 1.80431306e-01f,
  4.01456237e-01f, -1.29288971e-01f, -3.86952050e-02f, 1.06245480e-01f, -7.73047209e-02f, -3.47367786e-02f, -3.27219099e-01f, 5.43916672e-02f, -1.13142215e-01f, -3.73789892e-02f,
  5.28172366e-02f, 1.57723248e-01f, 2.20478743e-01f, 1.48291945e-01f, 1.24311484e-01f, -1.79984599e-01f, 3.13905656e-01f, 2.57836431e-01f, 3.90479326e-01f, -6.01635203e-02f,
  1.70618445e-01f, 1.63690940e-01f, 5.38704358e-02f, 7.54972920e-02f, 4.85963188e-02f, 5.39299667e-01f, 8.68088529e-02f, -4.03719723e-01f, -3.11130971e-01f, 1.31846160e-01f,
  8.03769976e-02f, 1.75446108e-01f, -4.94769990e-01f, 6.91349506e-02f, 5.07834228e-03f, -1.38820577e-02f, -1.08757839e-01f, -2.00230196e-01f, -1.46639317e-01f, 2.32468657e-02f,
  -3.40046883e-02f, -3.25229168e-01f, -2.32678473e-01f, 3.96883667e-01f, -2.60576099e-01f, 2.37124518e-01f, 5.17447889e-02f, 4.35111642e-01f, -3.15970257e-02f, 9.84781459e-02f,
  -4.14419472e-02f, 1.10632099e-01f, 2.16284871e-01f, 6.66222945e-02f, 1.54936552e-01f, 9.77615491e-02f, 7.72717446e-02f, 2.50070959e-01f, -1.31843194e-01f, 1.45191401e-02f,
  2.63277963e-02f, 1.45947695e-01f, 4.01755087e-02f, 5.32173589e-02f, 1.86481103e-01f, 5.49757369e-02f, 3.06135774e-01f, -2.52545655e-01f, 3.24337371e-02f, 9.44878459e-02f,
  -3.44214216e-02f, -3.31768006e-01f, -1.41131595e-01f, 9.93093774e-02f, -2.94614937e-02f, 1.92112610e-01f, -1.39297262e-01f, -1.81542411e-01f, 9.43168029e-02f, 1.74956143e-01f,
  -2.73241550e-01f, -1.36125207e-01f, 1.20900981e-01f, -2.27580428e-01f, 6.05984591e-02f, 7.10779130e-02f, -1.24376446e-01f, -1.07526265e-01f, -2.27735087e-01f, 1.63772032e-02f,
  1.76464766e-01f, 3.13896164e-02f, 2.30801538e-01f, 2.14233190e-01f, 7.37632960e-02f, 3.49709243e-02f, -3.41546714e-01f, 3.26519340e-01f, 3.40953052e-01f, -4.21240069e-02f,
  5.30629754e-02f, 3.09694290e-01f, -1.03932410e-01f, 8.64723173e-04f, 5.79354540e-02f, -1.47110000e-01f, -1.71803981e-01f, -2.13485621e-02f, -1.93481490e-01f, -4.73421782e-01f,
  8.62425193e-02f, -1.07085809e-01f, 1.63939342e-01f, -2.86220700e-01f, 2.83766091e-01f, 1.01927757e-01f, -2.00491160e-01f, 2.77069062e-01f, -1.06556654e-01f, 1.42523721e-01f,
  3.52832563e-02f, 4.85100187e-02f, 1.40161127e-01f, 1.09395549e-01f, 3.96445505e-02f, 1.06600232e-01f, -6.34822026e-02f, -3.22079748e-01f, 5.38685322e-02f, 3.86901163e-02f,
  8.01170915e-02f, -6.04353435e-02f, -3.88303176e-02f, 4.59490493e-02f, 1.61972076e-01f, -4.66353260e-02f, -4.87676403e-03f, -5.25420420e-02f, -5.54182269e-02f, 5.02766185e-02f,
  -1.42945275e-02f, 4.63485837e-01f, 2.49771059e-01f, -1.14696965e-01f, -4.83120158e-02f, -1.13614090e-01f, 1.49326295e-01f, -4.00550634e-01f, -3.47126842e-01f, 6.74534217e-02f,
  8.83026235e-03f, -4.74192761e-02f, -1.63145319e-01f, 2.23626181e-01f, 2.28975043e-01f, 1.80281207e-01f, 5.78553617e-01f, 1.64144307e-01f, 1.16686113e-02f, -1.34909451e-01f,
  -2.74032116e-01f, -2.25846078e-02f, -2.85151117e-02f, -6.76406547e-02f, 6.32862672e-02f, -2.13519949e-02f, -2.12148488e-01f, 3.40774596e-01f, -2.31594648e-02f, -5.14029711e-02f,
  -4.17403504e-03f, -1.39320433e-01f, 1.97848286e-02f, 7.80851766e-02f, -1.11759283e-01f, -2.57418185e-01f, 8.78187343e-02f, 3.41367722e-01f, 1.41212419e-01f, -1.23700507e-01f,
  1.04563951e-01f, 2.87706405e-01f, 6.23365082e-02f, -1.24562018e-01f, -9.21248645e-02f, -2.45289830e-03f, -4.15796880e-03f, -9.92265344e-02f, -8.14605728e-02f, 2.18741149e-01f,
  3.03070486e-01f, -1.59810305e-01f, 1.86675146e-01f, 1.09007388e-01f, -2.24903561e-02f, 1.03227340e-01f, 3.44130062e-02f, 5.89585789e-02f, -4.86677177e-02f, 2.37384830e-02f,
  7.96678439e-02f, 4.20453511e-02f, 1.04234017e-01f, 1.24386773e-01f, -1.58197418e-01f, -1.38097405e-01f, 9.25961509e-02f, 3.21215093e-02f, -1.79403841e-01f, -2.20561177e-01f,
  2.99642295e-01f, 3.94244224e-01f, 2.07295045e-01f, 1.68032616e-01f, 2.16070786e-01f, 2.56697964e-02f, -1.31180644e-01f, -2.10944220e-01f, -1.91214964e-01f, -1.86503921e-02f,
  -6.36855140e-02f, -4.25070375e-02f, -5.13625517e-02f, 1.10909261e-01f, -1.22891469e-02f, 1.92869797e-01f, -6.80804998e-02f, -9.41031054e-02f, -1.17076486e-01f, 1.09098228e-02f,
  2.15456620e-01f, 1.26668364e-01f, 6.37611598e-02f, 2.44509920e-01f, -7.13397115e-02f, 1.07749350e-01f, 1.42268697e-02f, 2.47690409e-01f, 1.97173618e-02f, 3.45715135e-02f,
  -1.25011742e-01f, 3.53028625e-01f, 2.34542936e-01f, 4.82542180e-02f, 3.99189651e-01f, -7.84162134e-02f, -1.18811056e-02f, 1.01872362e-01f, 1.22353785e-01f, 1.08628005e-01f,
  -1.73711017e-01f, -5.31824455e-02f, -3.91410440e-02f, 8.80516097e-02f, 8.72985180e-03f, 1.10434115e-01f, 8.08628425e-02f, 3.04297991e-02f, -7.37769082e-02f, -4.10845987e-02f,
  -1.00297516e-03f, 4.34684055e-03f, -1.01098344e-02f, 1.68163199e-02f, 1.46516085e-01f, -4.12123166e-02f, -1.99222878e-01f, -4.03977223e-02f, 1.38588384e-01f, 7.48622715e-02f,
  -1.00300135e-02f, -1.40085831e-01f, 1.85822651e-01f, 2.30120239e-03f, 4.03340533e-02f, 1.60935983e-01f, -1.74330816e-01f, -1.54345304e-01f, -2.13420793e-01f, 5.04325237e-03f,
  2.85812050e-01f, -1.50659636e-01f, -2.67122507e-01f, -4.73483466e-03f, -2.77083665e-01f, -3.25582683e-01f, 2.98536327e-02f, -9.00570750e-02f, 4.32732761e-01f, -2.77460039e-01f,
  4.56963014e-03f, 1.23500369e-01f, 1.07574359e-01f, -1.57566220e-01f, -4.46067005e-02f, -1.65517569e-01f, 5.02062030e-02f, -2.94829994e-01f, 4.58048612e-01f, 9.82434228e-02f,
  2.73519188e-01f, 2.01325506e-01f, 5.93955405e-02f, 2.28270024e-01f, -4.08203095e-01f, -4.51427072e-01f, -1.95343807e-01f, -1.02509819e-01f, 2.27058306e-01f, -8.93142968e-02f,
  2.09884569e-01f, -4.04333547e-02f, 9.40457731e-02f, -3.76635224e-01f, -1.86929524e-01f, 9.12720338e-02f, -1.87863693e-01f, -9.58931893e-02f, -4.03078020e-01f, 4.84174013e-01f,
  -2.53922880e-01f, -5.06127104e-02f, 2.16968089e-01f, -1.19826771e-01f, -7.98456371e-02f, 9.68512893e-02f, 2.35135294e-02f, 7.63623640e-02f, -2.04155162e-01f, -6.67675883e-02f,
  1.42558170e-02f, -3.53925228e-01f, 9.88184959e-02f, -1.49925306e-01f, -5.93482144e-02f, 5.10343313e-02f, 1.41709531e-02f, 2.14342371e-01f, -3.10597420e-01f, -1.51384637e-01f,
  3.16453911e-02f, -2.28720918e-01f, -8.61201733e-02f, -1.45968765e-01f, 9.70539376e-02f, -1.66402087e-01f, 5.80734983e-02f, -1.21083975e-01f, 3.57219934e-01f, 1.90103129e-01f,
  -6.42891452e-02f, 2.29813606e-02f, -1.20096296e-01f, -3.55769247e-02f, 2.29509637e-01f, -9.65612829e-02f, 8.04614127e-02f, 2.12763593e-01f, -3.62803459e-01f, -2.07653105e-01f,
  -5.11724241e-02f, -6.19533211e-02f, -1.00684173e-01f, -3.71603996e-01f, 2.57113487e-01f, -4.21121329e-01f, 1.52399186e-02f, -1.22542679e-02f, 3.23276460e-01f, -4.03107524e-01f,
  -2.88663745e-01f, 1.11363471e-01f, -5.40056348e-01f, 2.58147061e-01f, 4.58816648e-01f, -4.54631187e-02f, -8.73441994e-02f, -1.45649798e-02f, 2.26686642e-01f, 1.32981673e-01f,
  1.85791135e-01f, 1.44984052e-01f, -2.21536547e-01f, 6.35162443e-02f, 1.06949016e-01f, -1.25432551e-01f, 6.28287941e-02f, 5.50407879e-02f, 2.71699756e-01f, 6.09603263e-02f,
  2.45462671e-01f, 1.47550642e-01f, -1.20930023e-01f, 5.82085960e-02f, -3.76641452e-02f, -1.10549808e-01f, -1.04264334e-01f, -4.50458713e-02f, -1.26605377e-01f, 2.41530925e-01f,
  -1.63652673e-02f, 2.00693496e-02f, 8.74196291e-02f, -7.79326558e-02f, -1.57625243e-01f, 2.87569135e-01f, -1.38614923e-01f, -2.46883929e-01f, 2.58912057e-01f, -3.17154884e-01f,
  -1.40625581e-01f, -3.26479897e-02f, -2.82899678e-01f, -3.44111830e-01f, 8.06587934e-02f, 1.99427396e-01f, 6.39250040e-01f, 1.60380557e-01f, -1.99755356e-01f, -1.21712096e-01f,
  2.33999770e-02f, 2.13550091e-01f, 4.50409502e-01f, -2.19482988e-01f, -1.98296215e-02f, 5.02469353e-02f, 3.75823140e-01f, 6.42976686e-02f, 5.83422184e-02f, 1.48361251e-01f,
  -5.37348688e-02f, 3.71692851e-02f, -1.37058452e-01f, 2.11182460e-02f, -3.09532404e-01f, 8.86445940e-02f, 3.40997547e-01f, -3.70780140e-01f, -1.70879334e-01f, 2.03088820e-02f,
  -1.59989775e-03f, 1.20707452e-01f, -1.05817728e-01f, 5.82025852e-03f, 1.83500662e-01f, 1.15669660e-01f, 2.12691978e-01f, 1.11440003e-01f, -5.01673222e-01f, 1.33667782e-01f,
  -1.42713428e-01f, 1.70466285e-02f, -1.56129330e-01f, -1.13487788e-01f, 2.85463333e-02f, -4.51021176e-03f, 1.26562625e-01f, 1.06032096e-01f, 9.84016433e-02f, -3.09086055e-01f,
  3.32960077e-02f, -2.36107618e-01f, -2.91173041e-01f, -2.46834815e-01f, 7.16079250e-02f, 8.47832561e-02f, -1.38280407e-01f, 2.38878150e-02f, 1.95979014e-01f, -1.25466198e-01f,
  -3.90966423e-02f, -7.02450704e-03f, 2.24303320e-01f, 1.08252548e-01f, -9.81932729e-02f, -3.74229439e-02f, -2.69801348e-01f, 1.50981203e-01f, -1.47944883e-01f, -2.05465525e-01f,
  -2.28826255e-01f, -1.02967851e-01f, 1.60951257e-01f, -1.56636834e-01f, -1.09975517e-01f, -7.85372779e-02f, 3.56199344e-05f, 1.83721617e-01f, 2.50098538e-02f, -3.20147544e-01f,
  1.28166035e-01f, -5.62047698e-02f, 1.51357025e-01f, -5.06101735e-02f, 5.04144877e-02f, 2.54038990e-01f, 8.15439504e-03f, -6.16100021e-02f, -3.21527988e-01f, -4.61591370e-02f,
  1.48205131e-01f, 3.08000058e-01f, 2.27095410e-01f, 3.12325805e-02f, 4.41605113e-02f, 3.78848501e-02f, -3.95761617e-02f, -4.94213440e-02f, -1.38069719e-01f, 3.77807990e-02f,
  1.28389999e-01f, 2.50890136e-01f, 8.24960545e-02f, -5.69638275e-02f, -4.33781035e-02f, -5.87963462e-02f, -1.79094717e-01f, -1.39295440e-02f, 2.72109479e-01f, 1.48218885e-01f,
  -1.33805677e-01f, 1.21951953e-01f, -1.26863018e-01f, -2.76669651e-01f, -1.64392784e-01f, -4.04252261e-01f, -2.77405411e-01f, 2.82988280e-01f, -6.76666200e-03f, 1.34313881e-01f,
  2.36265421e-01f, 1.50942847e-01f, 1.88383132e-01f, -7.86430240e-02f, 2.52005845e-01f, 9.23364908e-02f, 8.58675092e-02f, -1.83002353e-01f, 1.32910222e-01f, 1.29836231e-01f,
  -1.50882602e-01f, -1.33802816e-01f, -7.64866620e-02f, 1.07615553e-01f, -2.89426357e-01f, -5.43258153e-02f, -1.52610496e-01f, -4.58202958e-02f, -5.95852099e-02f, 1.12364031e-01f,
  3.47222388e-01f, 3.01733613e-01f, 4.70055491e-02f, 4.53836411e-01f, -2.03829452e-01f, -2.79197872e-01f, 1.44107239e-02f, 1.16010584e-01f, -6.58710524e-02f, -4.92970794e-01f,
  -1.43009335e-01f, 5.13150752e-01f, 3.55586112e-01f, 4.29703929e-02f, 3.39882642e-01f, -3.05819273e-01f, -6.64054036e-01f, -5.75195476e-02f, 1.11611374e-01f, 2.42231507e-02f,
  -1.17620781e-01f, -9.88034233e-02f, -1.58126876e-02f, 4.04531807e-02f, 6.22062027e-01f, -4.50420916e-01f, -1.88238144e-01f, 2.99167223e-02f, -2.60857671e-01f, -7.62856239e-03f,
  -6.50829598e-02f, 1.22962996e-01f, -2.83115089e-01f, 6.17194995e-02f, -1.43070713e-01f, 8.52458328e-02f, -1.56268403e-01f, 1.13512143e-01f, 7.28113800e-02f, -5.41555509e-02f,
  1.06028251e-01f, 1.07998915e-01f, 1.79587707e-01f, -3.49229783e-01f, -3.31089795e-01f, -1.12347096e-01f, -1.10359967e-01f, -1.10754363e-01f, 1.30179211e-01f, 2.87407506e-02f,
  1.91600144e-01f, 1.91137031e-01f, -1.17710434e-01f, -2.71858662e-01f, -1.12482533e-01f, -1.49056688e-01f, 3.65671888e-02f, -8.68702456e-02f, 4.54178214e-01f, 3.68646421e-02f,
  3.93053770e-01f, -1.53815761e-01f, 4.88593616e-02f, 4.89100218e-01f, 2.40530401e-01f, -4.75375205e-01f, 1.20804034e-01f, -2.20751479e-01f, 1.98392794e-01f, -1.11010879e-01f,
  2.37349570e-01f, -4.17082459e-01f, 1.34653635e-02f, -1.36246264e-01f, -7.60590881e-02f, -5.45606732e-01f, -1.16519727e-01f, 1.20646305e-01f, 2.64832284e-02f, 1.67135838e-02f,
  2.26845637e-01f, 8.14675689e-02f, -1.30624138e-02f, -1.68772623e-01f, -4.94476371e-02f, 7.90896267e-02f, 8.25103465e-03f, 1.42569289e-01f, -3.02244633e-01f, -1.78025708e-01f,
  -2.80473500e-01f, 3.65517475e-02f, -1.17045483e-02f, 8.03860947e-02f, -9.18454491e-03f, 1.15231737e-01f, 3.29329878e-01f, 1.60688590e-02f, -1.73188522e-02f, 8.86933431e-02f,
  -8.85761715e-03f, -7.54712746e-02f, -6.77572237e-03f, 1.35460421e-02f, -1.08216599e-01f, -3.53536576e-01f, -7.90334865e-03f, 1.74481452e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.09709524e-01f, -3.93467303e-03f, 1.62834078e-01f, -7.28234872e-02f, 4.12805751e-02f, -2.13806033e-02f, 8.97110850e-02f, -1.17770635e-01f, 1.74958363e-01f, 5.43776155e-02f,
  3.28303967e-03f, 6.42129183e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    