/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.04564041e-01f, -1.24093719e-01f, 9.60452035e-02f, 7.27558732e-02f, -9.37269479e-02f, 8.60067084e-02f, -4.43360396e-02f, 8.86475965e-02f, 1.92794818e-02f, 3.07774842e-02f,
  4.72709946e-02f, 1.79967374e-01f, 2.09653318e-01f, 5.83134182e-02f, 2.11386755e-01f, -1.02249995e-01f, -1.12715244e-01f, 5.93830533e-02f, 2.27293968e-01f, 7.65621616e-03f,
  -1.72876865e-01f, -1.01326749e-01f, -9.38226469e-03f, -6.59114867e-03f, -1.59221262e-01f, 4.27284986e-02f, -1.70426637e-01f, -7.26809874e-02f, -9.21372138e-03f, -1.55523092e-01f,
  6.26311451e-02f, -4.74273972e-02f, 5.31949364e-02f, 4.70537730e-02f, 3.33929844e-02f, -3.42863239e-02f, -3.65454741e-02f, -2.49257572e-02f, -1.64043047e-02f, -3.90617810e-02f,
  3.07189710e-02f, -6.58928528e-02f, 1.96262505e-02f, -4.52471338e-02f, -2.96697170e-02f, 5.24649583e-02f, -1.37239829e-01f, 6.92908838e-03f, -2.82912911e-03f, -2.09145993e-02f,
  1.98002551e-02f, 1.43236686e-02f, -1.78075116e-02f, 3.02544013e-02f, 6.43346161e-02f, -6.75704852e-02f, -5.88302081e-03f, -1.19154491e-02f, 6.80026934e-02f, -3.32540870e-02f,
  8.25574994e-02f, -5.93547262e-02f, 3.78543735e-02f, -6.95964769e-02f, 4.03235247e-03f, 1.93530489e-02f, -4.44958769e-02f, -4.99162190e-02f, 2.15797499e-02f, 6.89811707e-02f,
  -1.56826898e-02f, -7.84716085e-02f, 4.36417833e-02f, 3.43291722e-02f, -1.86976027e-02f, 2.40007904e-03f, -4.31933738e-02f, 7.15803728e-03f, -6.39199466e-02f, 6.89427368e-03f,
  7.86288902e-02f, 2.86058579e-02f, -4.28613182e-03f, 4.02357019e-02f, 9.43410397e-02f, 4.63752411e-02f, 4.78682145e-02f, 1.01724617e-01f, 1.00138925e-01f, -2.44353898e-03f,
  1.88825205e-02f, -9.57077369e-02f, 8.48657861e-02f, 4.22230586e-02f, 4.74182889e-02f, -1.14486217e-01f, -6.21448308e-02f, -1.42013812e-02f, -2.52246335e-02f, -6.24626363e-03f,
  1.00058310e-01f, 7.52332360e-02f, -1.39473146e-02f, -1.28346663e-02f, 5.65312468e-02f, 6.08735867e-02f, 5.42733062e-04f, 4.64534946e-02f, -3.05992402e-02f, 3.45396902e-03f,
  9.14826840e-02f, 1.00029275e-01f, 1.93798825e-01f, 1.09525904e-01f, -4.68782661e-03f, 1.22378506e-01f, 8.10575671e-03f, 7.94012770e-02f, 8.36696103e-02f, 1.82966173e-01f,
  3.82625014e-02f, -9.70473960e-02f, 2.87012309e-01f, -3.29361744e-02f, -3.88292372e-02f, 1.40225351e-01f, -6.10104436e-03f, -2.47110911e-02f, -2.56671924e-02f, 2.12157965e-02f,
  7.49424249e-02f, -6.16012551e-02f, 3.58055136e-03f, 1.23910487e-01f, 1.68367073e-01f, 2.56878193e-02f, 1.29534572e-01f, 8.14629942e-02f, 2.10485518e-01f, 7.60275349e-02f,
  -1.94144808e-02f, -4.79105711e-02f, -2.06181351e-02f, 2.94871675e-03f, -1.97252762e-02f, 1.79959387e-01f, 5.30275740e-02f, -7.16695702e-03f, 1.47862777e-01f, -2.10699886e-02f,
  2.75103360e-01f, 1.45179918e-02f, -2.56648306e-02f, 1.12108765e-02f, -4.49813940e-02f, -6.04044087e-02f, -1.67476293e-02f, -2.67874096e-02f, -9.80372801e-02f, 1.90920895e-03f,
  2.68542841e-02f, -6.30132407e-02f, 2.85854600e-02f, -4.43932489e-02f, -8.83626863e-02f, -8.61579701e-02f, -1.57664314e-01f, -5.72039858e-02f, -6.54583201e-02f, 3.15245730e-03f,
  -1.23935133e-01f, -9.99721661e-02f, -4.58444767e-02f, 9.32590365e-02f, 1.27290115e-01f, -2.70520225e-02f, 7.03681111e-02f, 5.73486276e-02f, 4.83048894e-02f, 1.24214426e-01f,
  3.25771235e-02f, 6.46414384e-02f, -7.07003102e-02f, 3.62027027e-02f, 7.33603816e-03f, 1.00742858e-02f, -3.69460955e-02f, 7.06732497e-02f, -2.47434061e-03f, -2.19739303e-02f,
  -7.96614308e-03f, 5.92648163e-02f, -2.11820565e-02f, -3.91710773e-02f, -3.27798165e-02f, 4.02146718e-03f, -3.36876251e-02f, -1.09700896e-01f, -8.28975905e-03f, 5.10073733e-03f,
  -4.85270619e-02f, 2.28875577e-02f, 6.45003021e-02f, 5.86130545e-02f, 5.38906157e-02f, 6.17707632e-02f, 3.28887738e-02f, -6.46551028e-02f, -1.62976664e-02f, -5.46998903e-02f,
  1.24034815e-01f, -7.01646283e-02f, 9.46087763e-03f, -2.00538225e-02f, 8.53438452e-02f, -2.77963541e-02f, -4.57929224e-02f, -9.15677927e-04f, 4.87663001e-02f, 9.06486064e-02f,
  8.60582218e-02f, -2.58080773e-02f, -8.36580098e-02f, -8.69546384e-02f, -8.39884579e-03f, 3.59860510e-02f, -1.17851049e-01f, 8.03008974e-02f, 4.62224856e-02f, -1.32229239e-01f,
  1.79070551e-02f, 1.18176766e-01f, 5.43345809e-02f, 1.38799012e-01f, -4.18483615e-02f, 6.86137825e-02f, 5.51095903e-02f, 3.11355684e-02f, 1.30248681e-01f, 5.51252328e-02f,
  -6.24290258e-02f, 1.57760277e-01f, 6.05751686e-02f, 3.16833779e-02f, 8.09089106e-04f, -2.63354671e-03f, 2.13177782e-02f, -6.50933385e-02f, -1.02682792e-01f, -2.13001799e-02f,
  -8.19663927e-02f, -1.05342872e-01f, -1.42031074e-01f, -3.09768077e-02f, -1.33935794e-01f, -2.01628655e-02f, 1.40156612e-01f, -1.51420385e-02f, 2.09575519e-02f, -2.82296129e-02f,
  7.79795572e-02f, -3.46644744e-02f, 4.61253822e-02f, -5.44839203e-02f, 8.90459716e-02f, -9.23767164e-02f, 3.45418230e-02f, 6.45570680e-02f, -3.54895331e-02f, 8.71619135e-02f,
  -5.88816702e-02f, -4.87729646e-02f, -1.12503562e-02f, -3.68392989e-02f, -1.67545967e-03f, -1.45125305e-02f, -9.28443149e-02f, -4.73897420e-02f, 6.76277652e-03f, 5.11714481e-02f,
  -5.61764613e-02f, 7.73221999e-02f, 1.95041951e-02f, -7.39858449e-02f, 8.72440636e-02f, 7.72325620e-02f, -1.43534532e-02f, -4.55119796e-02f, -4.92109079e-03f, -2.37708688e-02f,
  2.00249888e-02f, 7.41046015e-03f, -1.80361364e-02f, 4.49898951e-02f, 6.25108555e-02f, -1.03182368e-01f, -6.48325160e-02f, -9.60035156e-03f, -6.92660138e-02f, -4.10953984e-02f,
  6.51784167e-02f, -4.65036258e-02f, 7.86785856e-02f, 2.21698619e-02f, -2.96311229e-02f, -5.84866526e-03f, -3.87637019e-02f, 1.85284298e-02f, -5.49491197e-02f, 5.15674800e-02f,
  2.44850460e-02f, 7.16815144e-02f, 9.33387596e-03f, 6.35333508e-02f, -6.72799423e-02f, 5.66346273e-02f, -1.26985639e-01f, -6.25653788e-02f, 4.61361520e-02f, 4.71215807e-02f,
  3.99170443e-02f, -6.44004717e-02f, 9.12229493e-02f, 1.47840967e-02f, 8.41879323e-02f, 3.14694643e-02f, 5.87719232e-02f, 4.77695391e-02f, 3.62869799e-02f, -1.14367418e-02f,
  -2.09719837e-02f, 4.37257588e-02f, -5.82491271e-02f, 1.04780635e-02f, 1.47851910e-02f, 2.05574650e-02f, 1.08361319e-02f, 1.36832222e-02f, 6.02118038e-02f, -1.53772980e-02f,
  -4.02941816e-02f, -2.81971488e-02f, 3.17226574e-02f, 1.48771191e-02f, 6.71552941e-02f, 8.35570693e-02f, 4.44081426e-02f, -9.40077454e-02f, 1.92563068e-02f, 4.68031131e-02f,
  4.28225659e-02f, -5.99438809e-02f, -2.88529415e-02f, -5.68143018e-02f, -6.23055957e-02f, -8.71104747e-02f, -9.85669717e-02f, -1.10983156e-01f, -8.85854214e-02f, -1.59319296e-01f,
  3.34647387e-01f, -1.45966718e-02f, 8.79964307e-02f, 1.47572279e-01f, 1.20703150e-02f, -2.84755062e-02f, -1.39547735e-02f, 1.15663134e-01f, -2.03875881e-02f, 1.53313756e-01f,
  5.29916584e-02f, -2.10656561e-02f, 9.18959528e-02f, 3.26858051e-02f, 7.73693621e-02f, 1.61688298e-01f, 2.12912261e-01f, 1.08991958e-01f, -6.94711283e-02f, -1.26034811e-01f,
  4.96125780e-02f, 1.48927286e-01f, -6.07472472e-02f, 3.95389600e-03f, 1.17465379e-02f, -1.13218069e-01f, 9.67107192e-02f, 1.01847313e-01f, -1.17523000e-01f, 1.69118177e-02f,
  -2.02862322e-02f, -4.18550847e-03f, -4.04762402e-02f, 6.66161180e-02f, 4.81667258e-02f, -2.51606070e-02f, 3.65438834e-02f, -8.74236822e-02f, -2.09721420e-02f, 3.19993719e-02f,
  1.71053428e-02f, -1.57347340e-02f, 5.04203960e-02f, -9.00242925e-02f, 5.50938956e-02f, 3.44829783e-02f, -2.94103157e-02f, 1.24445930e-01f, -6.73699304e-02f, -5.17006628e-02f,
  6.84267357e-02f, -5.61833894e-03f, -1.10653847e-01f, 4.41644080e-02f, -1.64121166e-02f, -2.32239831e-02f, -1.48341451e-02f, -1.01950072e-01f, -9.72707123e-02f, -1.81528423e-02f,
  -4.12637554e-02f, 1.22600691e-02f, -1.48354070e-02f, 7.39103630e-02f, -1.64755471e-02f, -7.45913340e-03f, -1.11632645e-01f, -1.63747799e-02f, -1.32704433e-03f, -4.79223356e-02f,
  6.96042329e-02f, -1.20034605e-01f, 1.18672960e-01f, -5.25493771e-02f, -8.55156407e-02f, -9.24817622e-02f, -7.96734318e-02f, -3.62275243e-02f, -1.04662396e-01f, -1.06689319e-01f,
  1.35593610e-02f, -8.22635293e-02f, -6.41542720e-04f, 1.78459566e-02f, -1.20626036e-02f, 2.83443592e-02f, 7.86424614e-03f, -4.36342470e-02f, 4.10277992e-02f, -3.79082412e-02f,
  9.80440974e-02f, 3.75759564e-02f, 1.18964016e-01f, -4.74725738e-02f, 7.87838846e-02f, -2.90200394e-02f, 4.17955481e-02f, 1.08816318e-01f, -5.48977330e-02f, 1.20363154e-01f,
  -1.05858007e-02f, 7.24236108e-03f, 4.31545302e-02f, 1.87279675e-02f, -1.54080405e-03f, -8.84201005e-02f, 1.19364448e-01f, 5.49082272e-02f, -1.32219166e-01f, -9.50315793e-04f,
  6.41719252e-02f, -5.05055748e-02f, -3.46764410e-03f, 2.70799417e-02f, -2.91466862e-02f, 1.15131892e-01f, -3.33669968e-02f, 4.08100849e-03f, 7.45661929e-02f, 1.78116053e-01f,
  1.48971409e-01f, -1.86213478e-01f, -3.18889081e-01f, 8.93557593e-02f, 2.89588561e-03f, 1.72854200e-01f, 6.36142716e-02f, 1.86242595e-01f, 1.09676600e-01f, 8.69694725e-02f,
  -2.15325924e-03f, 1.20900013e-01f, 2.51018200e-02f, -3.28352526e-02f, 2.63415538e-02f, -6.79954588e-02f, -7.82478079e-02f, -3.71279269e-02f, 9.02358815e-02f, 7.76598975e-02f,
  -4.95584346e-02f, 4.32308875e-02f, -5.90550900e-02f, -5.93512170e-02f, -1.07474051e-01f, 5.82454987e-02f, -7.28191584e-02f, -1.98338881e-01f, -9.73266512e-02f, -3.16083968e-01f,
  -1.18319787e-01f, -2.43841618e-01f, 4.81344312e-02f, 9.06033747e-05f, -4.25901711e-02f, 2.29706485e-02f, 5.71318008e-02f, -1.78431757e-02f, -8.57373849e-02f, -1.73117090e-02f,
  -1.31921381e-01f, -2.74918210e-02f, -1.95055194e-02f, -3.92583311e-02f, 8.93400982e-02f, 6.75253943e-02f, -1.83839165e-02f, -1.01902783e-01f, -2.99852993e-02f, -3.65849435e-02f,
  -9.21903104e-02f, -1.36545554e-01f, -7.30143264e-02f, -7.04858303e-02f, 1.76067557e-02f, 5.37874699e-02f, -1.59274086e-01f, -1.56367376e-01f, -5.16163781e-02f, -3.76258977e-02f,
  1.37237860e-02f, -2.91270064e-03f, -5.70014454e-02f, 1.91772282e-02f, 6.81865737e-02f, 4.36563194e-02f, 2.80743893e-02f, 4.51927744e-02f, -4.97714896e-03f, 2.08731107e-02f,
  3.04838773e-02f, 2.80321832e-03f, 4.54905853e-02f, -6.64670691e-02f, -5.57705341e-03f, -8.69423077e-02f, 4.01780158e-02f, -3.97562422e-02f, -4.66212481e-02f, 2.36919932e-02f,
  1.42771506e-03f, -3.05312657e-04f, -9.72037762e-03f, 7.47826546e-02f, -4.02474552e-02f, -2.87895091e-02f, 4.85095270e-02f, 1.56241795e-03f, -6.77850703e-03f, -1.24180637e-01f,
  3.31879854e-01f, 6.92270882e-03f, 1.33748829e-01f, 7.07272813e-02f, -1.07095856e-02f, -4.78279404e-02f, 1.82735305e-02f, 7.59765971e-04f, -4.86847274e-02f, 3.31844799e-02f,
  6.18714020e-02f, -1.42703857e-02f, 1.98272225e-02f, -9.76546258e-02f, 1.18258275e-01f, 7.96626732e-02f, 1.98506825e-02f, 1.43380880e-01f, 1.07642431e-02f, 9.48007256e-02f,
  9.04747620e-02f, 1.53443992e-01f, 3.07954311e-01f, 1.68864742e-01f, 1.32442027e-01f, 2.72876710e-01f, 1.37265772e-01f, 1.08195737e-01f, 1.58453062e-01f, 3.88921469e-01f,
  -1.46384999e-01f, 2.52917439e-01f, -1.62092850e-01f, -1.46931678e-01f, -2.69265980e-01f, -4.19940889e-01f, -4.33832824e-01f, -8.53733420e-02f, -6.26576412e-03f, 2.47550961e-02f,
  4.67949435e-02f, 2.11850092e-01f, 2.19049335e-01f, 2.05236182e-01f, 1.36269256e-01f, -4.57541980e-02f, -5.61451986e-02f, -4.49957028e-02f, -6.34985045e-02f, -1.18917920e-01f,
  1.68308109e-01f, -4.96829264e-02f, -5.23723522e-03f, 2.86651477e-02f, 2.74212882e-02f, 8.40016603e-02f, -8.86545330e-02f, -1.28991514e-01f, 2.62425579e-02f, 2.11587951e-01f,
  -4.15681154e-02f, -1.19328886e-01f, 7.67212138e-02f, 8.37054029e-02f, -1.10057801e-01f, 3.22401035e-03f, 1.46687718e-03f, 5.16623445e-02f, -2.85196770e-03f, -6.70198575e-02f,
  -3.84662077e-02f, 2.30637901e-02f, 2.68768258e-02f, -1.49876559e-02f, -1.31605193e-01f, -5.27042150e-02f, 5.49282469e-02f, 4.37923186e-02f, 1.03694662e-01f, -5.82098868e-03f,
  1.19536303e-01f, -1.71149313e-01f, -1.52979463e-01f, -1.42436877e-01f, -1.05186505e-02f, -6.37558997e-02f, -1.54388964e-01f, -4.49409988e-03f, -2.03021858e-02f, 1.23376280e-01f,
  9.79882758e-03f, -4.75634634e-02f, -3.62176374e-02f, -3.01897097e-02f, 9.26762596e-02f, -3.75387259e-02f, 1.84451770e-02f, -2.41439864e-02f, -4.11214679e-02f, 5.66567183e-02f,
  1.29773663e-02f, 4.69655246e-02f, -6.63591623e-02f, 3.53310145e-02f, 7.93062672e-02f, -1.08239397e-01f, -5.02517037e-02f, 3.47149596e-02f, -2.32361621e-04f, -5.88044524e-03f,
  2.39847023e-02f, -4.90638167e-02f, -4.00717668e-02f, -1.09160794e-02f, -7.75473472e-03f, 7.75204003e-02f, 4.77844756e-03f, -1.27471350e-02f, 3.60655077e-02f, 1.37902452e-02f,
  1.36129513e-01f, -5.76374307e-02f, 9.80746225e-02f, 8.53248537e-02f, -4.72209007e-02f, 1.42207429e-01f, 1.69213582e-02f, -2.82889865e-02f, 2.51661669e-02f, 1.97813287e-02f,
  -1.42148584e-01f, 1.11508757e-01f, -2.22831462e-02f, 1.84822828e-02f, 5.11421785e-02f, 2.01021525e-04f, 4.10351641e-02f, 2.76095029e-02f, -2.11631078e-02f, 2.90084407e-02f,
  5.72082140e-02f, -9.04691126e-03f, -5.94670279e-03f, -2.36987304e-02f, 3.90609005e-03f, -1.01070009e-01f, -4.32943273e-03f, -9.51302797e-02f, -1.28513798e-01f, 1.85723063e-02f,
  -5.04957974e-01f, 6.66541234e-02f, 2.52184216e-02f, -1.78776667e-01f, -1.12258263e-01f, -3.24093644e-03f, 3.87260802e-02f, 1.06186676e-03f, -9.13425386e-02f, 3.40009965e-02f,
  1.20498791e-01f, -5.53561375e-02f, -2.51621138e-02f, 5.71913011e-02f, -1.09522007e-01f, -2.90988442e-02f, -2.18919635e-01f, -1.73326358e-01f, -1.26499057e-01f, -8.51316750e-02f,
  -6.93690851e-02f, -1.21812373e-01f, -1.13150716e-01f, -5.88599034e-02f, -9.69025120e-03f, -6.31179735e-02f, -7.27400358e-04f, -1.14837073e-01f, -3.45101114e-03f, -9.55723133e-03f,
  1.16378419e-01f, -1.33666113e-01f, -9.63159129e-02f, -1.79483026e-01f, 2.81312950e-02f, 4.44016308e-02f, 3.82709391e-02f, -4.83179092e-02f, -4.74418178e-02f, -4.64772694e-02f,
  5.47162071e-02f, -7.79697075e-02f, 2.91725132e-03f, 6.33039773e-02f, 3.98496948e-02f, 2.42497120e-02f, -3.03354431e-02f, -6.29967377e-02f, -7.57129490e-02f, 2.97801588e-02f,
  2.83814711e-03f, -9.20803845e-03f, -4.28530537e-02f, 7.25842938e-02f, 7.91306980e-03f, -9.58543494e-02f, 4.09716852e-02f, 9.65092406e-02f, 6.08370714e-02f, -4.18019965e-02f,
  -1.06189847e-01f, 7.11925477e-02f, 1.55612398e-02f, 3.98806185e-02f, 2.62550684e-03f, -2.27685180e-02f, 2.43897624e-02f, -2.10427437e-02f, -9.87936184e-02f, 1.07185714e-01f,
  1.63046345e-02f, 7.54349260e-03f, 5.51220998e-02f, -4.27553505e-02f, -4.22293879e-02f, -4.24017422e-02f, 1.67746190e-02f, 4.54025529e-02f, -7.23762363e-02f, -7.56479800e-02f,
  9.10590589e-02f, -2.60482132e-02f, -2.96786893e-02f, 8.16693902e-02f, -9.89529788e-02f, -4.46138307e-02f, 2.41027046e-02f, -5.00795469e-02f, 1.43064121e-02f, 1.11100040e-02f,
  1.07559383e-01f, -1.40117109e-01f, 3.30863632e-02f, 4.96859923e-02f, -3.81047018e-02f, 5.10350391e-02f, -3.88145968e-02f, -3.82277071e-02f, -3.10525727e-02f, 2.17872281e-02f,
  2.85346434e-02f, -1.00916624e-02f, 5.81386313e-03f, 8.40212032e-02f, -4.97208983e-02f, -6.93182051e-02f, 2.68278085e-02f, -3.67088877e-02f, -1.13925245e-02f, 1.21996075e-01f,
  1.68314613e-02f, -4.18671332e-02f, -5.21626044e-03f, -4.38192487e-03f, 2.67538279e-02f, -1.35049537e-01f, 8.09994433e-03f, 8.28139558e-02f, 7.32934894e-03f, 1.50475726e-01f,
  -6.41015649e-01f, -2.62209803e-01f, 3.38533446e-02f, -6.09817617e-02f, 1.23981923e-01f, 3.99200320e-02f, -2.13146165e-01f, -1.74738839e-01f, -1.11617334e-01f, -1.20433785e-01f,
  5.19796312e-02f, 1.86085060e-01f, 3.74941267e-02f, 7.18537122e-02f, -5.72933778e-02f, -2.57932814e-03f, 5.39107472e-02f, 1.02433865e-03f, 1.16626851e-01f, -3.65841389e-02f,
  1.98833030e-02f, -1.43682718e-01f, -5.55173792e-02f, -5.10428995e-02f, 8.92637391e-03f, 1.86384186e-01f, 3.32503691e-02f, 1.09015271e-01f, 6.50725514e-02f, 3.13951559e-02f,
  2.20448345e-01f, -2.45908007e-01f, 1.71145782e-01f, -5.13680372e-03f, 1.17001057e-01f, -4.62571345e-02f, 4.74672951e-02f, -6.25316706e-03f, 6.83596916e-03f, -6.76352009e-02f,
  6.00548126e-02f, 3.82420048e-02f, -2.63014920e-02f, 7.80261904e-02f, -2.80048139e-03f, 2.71557160e-02f, -9.21835601e-02f, -1.05658494e-01f, 2.41573490e-02f, -1.55357733e-01f,
  2.30732933e-02f, -2.44833697e-02f, -9.20865014e-02f, -1.77139994e-02f, 1.19975507e-02f, 8.59203115e-02f, 3.58447954e-02f, 1.42671112e-02f, 3.76762301e-02f, 1.06511712e-02f,
  2.91738380e-02f, 8.78311321e-02f, 1.60489902e-02f, -1.24398634e-01f, -6.79308400e-02f, 8.35616216e-02f, 3.05664856e-02f, -1.10541927e-02f, -2.94991322e-02f, -9.80075542e-03f,
  1.25240639e-01f, -1.04753124e-02f, -2.29300130e-02f, -4.36360426e-02f, 6.45638108e-02f, 7.97662437e-02f, 1.72301866e-02f, -4.42936942e-02f, 7.18350261e-02f, -2.94390488e-02f,
  5.60765080e-02f, 3.32889962e-03f, -1.11978957e-02f, 2.77275369e-02f, -1.46366246e-02f, 5.00665940e-02f, -2.94649024e-02f, 7.84877390e-02f, 1.07250977e-02f, 2.56222542e-02f,
  6.64556175e-02f, 8.60986859e-02f, 1.39979757e-02f, -3.48640904e-02f, 2.39506140e-02f, 3.78294662e-02f, 5.77344336e-02f, 1.67839210e-02f, -7.06743961e-03f, -7.55523518e-02f,
  -4.51293662e-02f, -5.44999056e-02f, -5.06049655e-02f, 2.91963946e-02f, -1.64234322e-02f, -4.11380455e-02f, -1.52570888e-01f, -4.79966030e-02f, 3.80331352e-02f, -3.26533355e-02f,
  -8.57278630e-02f, -1.46895543e-01f, -1.80014804e-01f, -1.13133423e-01f, -1.12320006e-01f, 4.51974571e-02f, -5.40084355e-02f, -1.05956234e-01f, -9.47165210e-03f, -1.44828320e-01f,
  -5.14871180e-02f, 1.89142730e-02f, -2.20267139e-02f, -1.00137979e-01f, 1.34219006e-01f, 1.93040341e-01f, 3.48939896e-01f, 3.44050936e-02f, -1.04899064e-01f, 1.37985975e-01f,
  -3.92551441e-03f, -1.43828586e-01f, -2.36101538e-01f, -2.14093328e-01f, 1.22332545e-02f, 2.14478955e-01f, 7.33604804e-02f, -1.13049760e-01f, -1.59642011e-01f, -5.03524318e-02f,
  -4.33322378e-02f, -3.81978936e-02f, -1.12597667e-01f, -4.99238819e-02f, 5.01862094e-02f, -1.14420809e-01f, 7.08146691e-02f, 1.86525155e-02f, -2.03601774e-02f, 2.53810156e-02f,
  1.02396540e-01f, 7.49271065e-02f, 7.20813572e-02f, -4.49450463e-02f, -8.56881589e-03f, 9.00315568e-02f, -8.36909041e-02f, 1.58444233e-02f, -9.00166705e-02f, 4.10956405e-02f,
  -4.44488451e-02f, -7.36723319e-02f, -1.91735048e-02f, 3.42951380e-02f, 6.03345558e-02f, -2.11260803e-02f, 9.38853845e-02f, -1.02998167e-01f, 6.26298115e-02f, -2.39466242e-02f,
  -8.51973519e-02f, 1.26525890e-02f, 3.64406966e-02f, 6.04929356e-03f, 1.95548795e-02f, 6.66495562e-02f, 3.80858928e-02f, -5.01560792e-02f, -6.04989640e-02f, 1.69922635e-02f,
  -4.01872844e-02f, 1.47604868e-02f, 3.76801612e-03f, 6.06104955e-02f, -3.10408194e-02f, -1.23227574e-02f, 7.27500245e-02f, -1.37426676e-02f, -5.07877618e-02f, 4.28161174e-02f,
  -4.60303873e-02f, -4.68569156e-03f, 2.72927620e-03f, 3.38913985e-02f, 5.35355918e-02f, -4.87884060e-02f, -6.68708161e-02f, -4.65853103e-02f, -1.18529573e-02f, -6.31107064e-03f,
  -8.46852362e-02f, 1.24572180e-02f, -1.21831975e-03f, 1.69420838e-02f, -2.25368943e-02f, 4.10348661e-02f, -5.66911064e-02f, 6.77248612e-02f, 5.64344809e-04f, 1.76274567e-03f,
  1.07515939e-01f, -6.28130808e-02f, 1.09519660e-01f, -4.59903106e-02f, 5.12391105e-02f, -4.15812396e-02f, 7.80839799e-03f, -2.38450207e-02f, -1.06536448e-02f, -6.02822863e-02f,
  3.93846119e-03f, 4.26879935e-02f, -4.44854330e-03f, 5.09864138e-03f, -7.82713387e-03f, 7.30098709e-02f, 3.27918380e-02f, -8.94432142e-03f, 2.92894412e-02f, 8.80235657e-02f,
  5.46571128e-02f, 5.33408262e-02f, 3.36433575e-02f, 3.65056098e-02f, -5.30556589e-03f, -6.77450746e-03f, 3.55770588e-02f, 6.16308041e-02f, 6.04197159e-02f, 4.91817072e-02f,
  -3.82747740e-01f, 2.49604490e-02f, 4.53841239e-02f, -2.28357673e-01f, -4.34277244e-02f, 3.68464226e-03f, -1.26852289e-01f, -4.37573567e-02f, -1.15526475e-01f, -9.48086828e-02f,
  9.03586969e-02f, 2.23717153e-01f, 9.59696099e-02f, 1.30537704e-01f, -1.26246244e-01f, -9.06208381e-02f, -5.00697903e-02f, 5.54492734e-02f, 7.38835707e-02f, 1.19993068e-01f,
  1.66140109e-01f, 4.91812862e-02f, -9.56942886e-02f, 1.04373671e-01f, -2.60754507e-02f, 8.05152655e-02f, 9.74739145e-04f, 7.77314976e-02f, 1.30318567e-01f, 1.73533693e-01f,
  2.88836211e-01f, -8.92755166e-02f, 4.58661243e-02f, -7.13934749e-02f, 2.33429149e-02f, -6.50403574e-02f, 1.81059539e-02f, 7.02834204e-02f, -1.04252994e-01f, -1.81201613e-03f,
  -1.01322718e-02f, 1.67264100e-02f, 2.60464251e-02f, -1.82442944e-02f, -1.56734530e-02f, -5.79329915e-02f, -1.60432365e-02f, 3.63307334e-02f, -7.49355331e-02f, 4.93695699e-02f,
  8.51978511e-02f, 3.89232412e-02f, -4.48636971e-02f, 1.72066167e-02f, 3.68545018e-02f, 1.17250886e-02f, 1.09702773e-01f, -1.86832752e-02f, 5.27105145e-02f, 2.98716966e-02f,
  -2.58091427e-02f, -1.67985316e-02f, 1.86853055e-02f, 4.49680686e-02f, -4.13863398e-02f, -2.41568033e-02f, 1.85956210e-02f, 5.22713969e-03f, 8.65158960e-02f, 1.42971436e-02f,
  2.50565354e-02f, 6.23795241e-02f, 1.86872054e-02f, 4.97230515e-02f, 5.14704213e-02f, -4.18762937e-02f, 2.40377290e-03f, 6.20881580e-02f, -2.22026799e-02f, -9.53014418e-02f,
  -6.62672967e-02f, 4.39556018e-02f, -5.47343642e-02f, -1.77706985e-04f, -2.91976109e-02f, -1.00621385e-02f, 2.01851279e-02f, -2.29270030e-02f, 2.21054070e-02f, -1.50654148e-02f,
  -2.88977176e-02f, -2.98696067e-02f, -1.00158714e-02f, -3.54852080e-02f, -6.32474720e-02f, -7.31981248e-02f, 1.32930251e-02f, -6.93113636e-03f, 7.70146539e-03f, 1.67309381e-02f,
  5.42723807e-03f, 1.92563683e-02f, 3.58430184e-02f, 5.75163811e-02f, 3.49339545e-02f, -9.18589681e-02f, 1.51892090e-02f, 6.09082431e-02f, 3.31918970e-02f, 7.88349584e-02f,
  4.21901606e-02f, -1.41444400e-01f, 2.85275076e-02f, 7.74494931e-02f, 2.74513997e-02f, -9.29321349e-02f, 8.66350010e-02f, 3.23345996e-02f, -2.09257212e-02f, -1.27891943e-01f,
  9.95738618e-03f, -1.04374811e-02f, -5.88347800e-02f, -6.06345832e-02f, 3.21515575e-02f, -2.93164775e-02f, -1.66797936e-01f, 8.94422159e-02f, -5.02126031e-02f, -7.67723843e-02f,
  6.53453544e-02f, 1.96564257e-01f, 5.93576469e-02f, 1.22814901e-01f, 1.02570139e-01f, -1.53237224e-01f, -2.01127917e-01f, 8.17893595e-02f, 1.85950175e-01f, -1.01519311e-02f,
  6.97673345e-03f, -1.40181810e-01f, -4.01018113e-02f, 1.06738061e-01f, -8.32540244e-02f, 1.52901590e-01f, 1.16951829e-02f, -4.41171452e-02f, -5.23181856e-02f, -3.35325524e-02f,
  -8.85778740e-02f, 4.53645885e-02f, 4.68604565e-02f, -1.21111153e-02f, 8.54194909e-03f, 4.25025634e-02f, 3.79405394e-02f, -4.35687043e-02f, -4.68716435e-02f, -4.47208397e-02f,
  -5.67602292e-02f, 5.74060194e-02f, -7.71654099e-02f, 5.28147705e-02f, -6.19840398e-02f, -1.37260007e-02f, -3.04211471e-02f, 4.78860326e-02f, -2.41443496e-02f, 6.00142963e-03f,
  -4.22259606e-02f, 4.98030633e-02f, -5.64588532e-02f, -1.33275697e-02f, -4.31525707e-02f, 9.57908183e-02f, 3.24615836e-02f, 1.50449825e-02f, -4.94413897e-02f, -1.56279299e-02f,
  5.23101687e-02f, -1.46272443e-02f, 1.59932468e-02f, 3.43799517e-02f, 8.05836823e-03f, 9.07775760e-03f, 2.74256915e-02f, 7.03738332e-02f, 1.10000530e-02f, -6.67268783e-02f,
  -2.09082849e-02f, 1.87773667e-02f, 2.28230469e-02f, -8.84935912e-03f, -1.90714002e-02f, -6.19080290e-02f, -7.63132796e-02f, -3.41361351e-02f, 2.74528377e-02f, -3.38759236e-02f,
  -2.03955974e-02f, -4.75918800e-02f, 5.52850626e-02f, 6.46274025e-03f, 4.87050647e-03f, -2.09282860e-02f, 1.53141720e-02f, -1.53402397e-02f, -1.04043772e-02f, 2.03820914e-02f,
  -1.28326207e-01f, 2.38809194e-02f, 4.89489920e-02f, 6.99264649e-03f, 4.75453623e-02f, 4.93911579e-02f, 5.23504056e-02f, 5.14340363e-02f, -2.30412018e-02f, 8.71034060e-03f,
  -2.96864528e-02f, -1.93175506e-02f, 7.04112723e-02f, 4.04944038e-03f, -1.68425019e-03f, 9.26127564e-03f, -5.61510585e-02f, 1.38850994e-02f, -1.43911159e-02f, -3.29585858e-02f,
  -6.27653971e-02f, 8.18789452e-02f, 9.87087563e-02f, -4.31689657e-02f, 6.01115674e-02f, 4.47985716e-02f, 6.88106287e-03f, -1.69430915e-02f, 4.82580997e-02f, -8.65372941e-02f,
  -9.15070474e-02f, 1.73464805e-01f, -1.70446038e-01f, 2.43951213e-02f, 1.83230713e-01f, -6.75162598e-02f, 5.05422950e-02f, -9.44780186e-03f, 2.36690193e-02f, 2.24792305e-02f,
  2.38158759e-02f, -3.32442182e-03f, -1.40490785e-01f, -1.42368659e-01f, -1.84327111e-01f, 6.43465994e-03f, 8.85247160e-03f, -1.51671514e-01f, -2.76697904e-01f, -6.90931156e-02f,
  8.85393620e-02f, -6.95047975e-02f, -4.83738780e-02f, -4.26666439e-02f, 4.56642285e-02f, 3.75906713e-02f, -4.78288978e-02f, -1.01296678e-02f, 4.96020121e-03f, 4.16848361e-02f,
  -1.63735315e-01f, 1.03792608e-01f, -1.40251890e-01f, 7.68265426e-02f, 9.36927870e-02f, 4.24999781e-02f, 5.15548438e-02f, -5.10262214e-02f, 5.73310591e-02f, -2.29144990e-02f,
  -2.59231310e-02f, 8.75678137e-02f, -8.22216049e-02f, -6.14601048e-03f, 2.92668268e-02f, -8.32306594e-02f, 4.09279540e-02f, -4.96712588e-02f, -1.77466068e-02f, 3.46573219e-02f,
  1.22042466e-02f, 2.09492911e-02f, -3.10991593e-02f, 2.80099176e-02f, 9.97507796e-02f, 1.68850981e-02f, -4.80204187e-02f, 1.58709422e-01f, 5.71531989e-02f, 8.65733400e-02f,
  5.49400300e-02f, 3.76961157e-02f, -6.23354539e-02f, 1.02474712e-01f, 1.34172374e-02f, 2.96891239e-02f, -3.27247195e-02f, -6.83670212e-03f, -6.79342309e-03f, -2.11501680e-02f,
  -4.28137034e-02f, -2.59528048e-02f, 3.54663022e-02f, -3.55234444e-02f, -3.51503827e-02f, 1.61743760e-02f, 4.27042060e-02f, -6.57434165e-02f, -8.01941454e-02f, 9.64218304e-02f,
  2.54656877e-02f, 1.01528950e-02f, 7.01318611e-04f, -5.32952845e-02f, 6.81782663e-02f, -5.95776252e-02f, 9.38426703e-02f, 7.28818122e-03f, 4.74811234e-02f, -8.48418009e-03f,
  -1.12306863e-01f, -1.78447127e-01f, -8.10778141e-02f, -3.47956717e-02f, 7.33707100e-02f, -8.55184533e-03f, -5.96992373e-02f, 2.34464766e-03f, 1.74748786e-02f, -1.46660199e-02f,
  6.16075434e-02f, 9.32394341e-02f, -8.07566941e-02f, -3.66818300e-03f, 5.44756502e-02f, 1.23992339e-01f, 4.19212319e-03f, -3.38195898e-02f, -4.72962633e-02f, -4.32797475e-03f,
  -3.92075628e-02f, -1.45574778e-01f, -1.02482200e-01f, -9.28979218e-02f, 1.21766310e-02f, -8.30844119e-02f, -6.64383695e-02f, 1.64485462e-02f, -1.18937694e-01f, 2.90844943e-02f,
  -3.36490542e-01f, 2.40597665e-01f, -5.10514639e-02f, -2.39062652e-01f, 2.37682104e-01f, 1.47042617e-01f, 2.93435246e-01f, -4.61464562e-02f, -9.91614610e-02f, 1.22993439e-01f,
  1.11254439e-01f, 9.17476639e-02f, -6.24390952e-02f, 8.45194533e-02f, 3.41842920e-02f, 4.79930080e-02f, 1.29565910e-01f, -4.47735526e-02f, -7.94967860e-02f, 1.08329497e-01f,
  8.97646621e-02f, -6.42880350e-02f, -2.65211821e-01f, -1.52431056e-01f, 8.26349184e-02f, -1.85047746e-01f, -8.39425176e-02f, 4.14456539e-02f, 9.70501155e-02f, 1.14320658e-01f,
  2.45699715e-02f, -2.46334355e-02f, -1.00033820e-01f, 6.15333952e-02f, 6.24594837e-02f, -4.89705503e-02f, 6.68942481e-02f, -5.33841550e-03f, 7.33536407e-02f, -1.83115769e-02f,
  1.42736688e-01f, 2.97129303e-02f, 7.15338066e-02f, -1.68808512e-02f, 3.56837921e-02f, 1.00424677e-01f, -1.14430012e-02f, -1.17236197e-01f, -8.02026410e-03f, 3.84882167e-02f,
  1.26627952e-01f, 9.10983905e-02f, 9.26305056e-02f, 4.72608693e-02f, -5.58091626e-02f, -7.51217827e-02f, 3.36172730e-02f, 7.94910863e-02f, -2.58073751e-02f, -6.31577447e-02f,
  -1.83017533e-02f, 9.00809933e-03f, 1.70697197e-02f, -1.71166901e-02f, 4.88251746e-02f, -9.23676603e-03f, 2.22026724e-02f, -5.01461402e-02f, 4.44518551e-02f, -1.14734694e-01f,
  -1.44056818e-02f, -1.47515386e-02f, -3.37021686e-02f, -2.19076183e-02f, -7.03614727e-02f, 6.57910854e-02f, -3.62750292e-02f, -3.51904370e-02f, -3.07849776e-02f, -8.89544114e-02f,
  -1.64206326e-02f, 7.09584402e-03f, -3.62232770e-03f, 6.30913153e-02f, -1.83937908e-03f, -8.44478793e-03f, -7.65624223e-03f, 3.15064937e-02f, 6.59387745e-03f, 4.18067090e-02f,
  -1.71141773e-01f, 9.28366259e-02f, -1.20235465e-01f, 2.48327740e-02f, -1.83093380e-02f, 8.73393565e-03f, -1.87672880e-02f, 5.31237759e-03f, 1.62793174e-02f, 8.43965933e-02f,
  2.53366940e-02f, 7.57219968e-03f, 1.76906455e-02f, -1.87802948e-02f, -2.13330183e-02f, 1.70852002e-02f, -3.08049936e-02f, -2.55701728e-02f, 2.25057490e-02f, -7.02841440e-03f,
  -4.08598371e-02f, -3.03151105e-02f, 3.14119011e-02f, -4.41056974e-02f, 6.08804934e-02f, -3.43383551e-02f, 1.34200484e-01f, -2.44666412e-02f, 1.30417079e-01f, -8.51261020e-02f,
  -3.26589853e-01f, 1.08479466e-02f, -7.34618232e-02f, -7.41062760e-02f, 1.66540682e-01f, 2.49347314e-01f, 2.57068336e-01f, 4.22209240e-02f, 3.08227241e-02f, -2.80424841e-02f,
  7.51905143e-02f, -3.23594585e-02f, -3.28108966e-02f, -2.03707721e-02f, 8.16510245e-02f, 1.19186372e-01f, -4.91158627e-02f, -1.61665335e-01f, -4.87349853e-02f, 6.74450770e-02f,
  6.54999837e-02f, -5.10748886e-02f, -1.03515141e-01f, -2.66727898e-02f, -1.17891446e-01f, -7.76327923e-02f, -1.57248363e-01f, 8.52660276e-04f, -2.80958731e-02f, -1.71289161e-01f,
  -4.40637395e-02f, -6.93275928e-02f, -9.53189936e-03f, -9.74353403e-03f, 5.54130450e-02f, -1.61794089e-02f, -7.24309264e-03f, -5.90269603e-02f, 1.93988178e-02f, 4.48492169e-02f,
  2.47022789e-02f, -2.20981054e-02f, -1.11627907e-01f, -7.24559976e-03f, 7.73099577e-03f, -3.80149670e-02f, -3.68932565e-03f, -4.34374474e-02f, 5.13297319e-02f, 6.14848658e-02f,
  1.02912067e-02f, -5.25114536e-02f, 4.17734459e-02f, 2.34962497e-02f, 6.85707554e-02f, -8.46296474e-02f, 5.16608916e-02f, -4.88366187e-02f, -3.49771827e-02f, -3.25281802e-03f,
  -7.22991228e-02f, 4.92751598e-02f, -8.34082365e-02f, 1.04755037e-01f, -5.71765751e-02f, -2.48423237e-02f, -6.77645346e-03f, 5.18188886e-02f, 9.12979245e-03f, -9.45703164e-02f,
  6.93763420e-02f, 4.91179116e-02f, -3.04706749e-02f, -3.64724360e-02f, -3.70237343e-02f, 6.00726828e-02f, 5.27862906e-02f, 2.12950986e-02f, 6.63389489e-02f, -3.92533727e-02f,
  -4.57415283e-02f, -5.42152338e-02f, -7.81173259e-02f, -3.57839353e-02f, 7.27458159e-03f, -6.36492744e-02f, 4.61447872e-02f, 1.98651385e-02f, 2.68062726e-02f, -3.87423225e-02f,
  3.81106548e-02f, 1.96854491e-02f, -3.74076888e-02f, 4.04339097e-02f, -8.07988346e-02f, -8.93744677e-02f, 7.94450287e-03f, -8.42455998e-02f, -8.31551999e-02f, 7.05967098e-02f,
  1.71182994e-02f, 7.57312111e-04f, 1.41584431e-04f, 1.66605611e-03f, 3.64385471e-02f, 2.49063149e-02f, 2.60942634e-02f, 2.78985146e-02f, 2.28001773e-02f, 3.61314528e-02f,
  6.34802282e-02f, 3.29078138e-02f, 2.88193393e-02f, 3.80324423e-02f, -1.67814654e-03f, 4.97937668e-04f, 8.66327360e-02f, 8.86063837e-03f, -1.18829422e-02f, 5.32415658e-02f,
  -2.38546565e-01f, 2.35706359e-01f, -7.27129728e-02f, -8.59189034e-02f, 1.66068003e-01f, -1.34291798e-01f, -2.16900799e-02f, -3.98025475e-02f, 2.43316721e-02f, 1.19202629e-01f,
  4.40766066e-02f, 2.73143630e-02f, 1.26470998e-02f, 1.54026411e-02f, -1.70517862e-01f, -6.36872798e-02f, -3.66670149e-03f, -8.26996863e-02f, -2.28128836e-01f, -7.49446899e-02f,
  5.05090393e-02f, -6.79359436e-02f, -1.69011503e-01f, -5.10699581e-03f, 1.49124831e-01f, 4.50501740e-02f, -2.39067227e-02f, 1.26572344e-02f, 1.81344032e-01f, 2.40435511e-01f,
  3.56048206e-03f, 4.65179086e-02f, -5.78529723e-02f, 3.21646268e-03f, 2.97926385e-02f, -1.30802551e-02f, -9.24442336e-03f, -1.21232122e-01f, -2.82440577e-02f, -1.02124475e-01f,
  5.82916774e-02f, -2.64422446e-02f, -7.07693696e-02f, 4.00843211e-02f, -7.46850967e-02f, 4.52021696e-02f, -2.25925446e-02f, -3.40647213e-02f, -1.08770005e-01f, -3.65577601e-02f,
  8.82793218e-02f, 2.05604285e-01f, -2.91319448e-03f, -2.21763458e-03f, 1.51897990e-03f, -1.66308060e-02f, 5.07274978e-02f, -1.98447751e-03f, 7.40349665e-02f, 9.54950079e-02f,
  1.04272766e-02f, -5.17389998e-02f, -4.16360702e-03f, 9.37785394e-03f, 1.68807618e-02f, -4.05731332e-03f, 2.65849940e-02f, 3.99544612e-02f, 2.16742773e-02f, 1.50509095e-02f,
  1.00762613e-01f, 3.58886085e-02f, 1.52472379e-02f, 2.73262095e-02f, 4.49111573e-02f, 4.10561487e-02f, -3.73634622e-02f, -3.91624272e-02f, 1.19923651e-02f, 7.43551701e-02f,
  -1.81276861e-04f, -3.70736271e-02f, 3.60080041e-02f, 9.92284529e-03f, 1.55135524e-02f, 5.31768501e-02f, 4.72368486e-02f, -2.38008425e-02f, -7.49755874e-02f, 4.77684624e-02f,
  -8.66513774e-02f, -1.29294783e-01f, 3.68396081e-02f, -8.47857222e-02f, -2.12131366e-02f, 2.12740339e-02f, 1.97587535e-03f, 2.61957962e-02f, -7.54221082e-02f, -6.41753990e-03f,
  -7.20918830e-03f, -6.37937561e-02f, 1.37796914e-02f, -1.24297841e-02f, -1.93732455e-02f, -4.89457771e-02f, 1.62898645e-01f, 8.02359059e-02f, -1.38779312e-01f, -2.73585189e-02f,
  1.98215153e-02f, 1.93788204e-02f, -3.40551557e-03f, 1.98042411e-02f, 1.54182808e-02f, 5.14489077e-02f, -9.65069681e-02f, -3.68772969e-02f, -1.12800017e-01f, -6.15598299e-02f,
  -2.41685539e-01f, 1.57198206e-01f, -8.21494684e-03f, -2.26208344e-02f, 1.70162991e-01f, 2.69398615e-02f, 1.94548573e-02f, 5.19286208e-02f, 7.93109909e-02f, 5.20846732e-02f,
  1.34006666e-03f, 1.58711877e-02f, -6.87430948e-02f, 7.91425556e-02f, -3.02071329e-02f, -5.33206426e-02f, -1.16584671e-03f, -1.06623508e-01f, -1.07556261e-01f, 1.30968764e-01f,
  6.86503127e-02f, -9.68291536e-02f, -1.10606812e-01f, 6.90370239e-03f, -1.02757635e-02f, -8.51059854e-02f, -9.50481817e-02f, 1.14589781e-02f, 1.92087644e-03f, -5.53818652e-03f,
  6.15189224e-02f, 1.57277342e-02f, -1.94554403e-02f, -1.09460138e-01f, -9.63464901e-02f, -7.02972114e-02f, 1.15480844e-03f, -8.01106319e-02f, 7.62453489e-03f, 2.78603937e-02f,
  7.07538519e-03f, -2.87354197e-02f, -2.53252387e-02f, -8.35182611e-03f, -3.64105105e-02f, 7.73545504e-02f, 2.20018352e-04f, -2.49951932e-04f, 3.42892879e-03f, 7.55611062e-02f,
  3.10596637e-02f, 9.98552665e-02f, 6.48788288e-02f, -2.50167716e-02f, -7.23835900e-02f, -8.71585831e-02f, 1.00234754e-01f, 7.02772364e-02f, -6.51111081e-02f, -2.76202206e-02f,
  -6.69417754e-02f, 5.26742935e-02f, 7.91797414e-02f, -7.36250877e-02f, 2.81975977e-02f, 1.52226212e-02f, -4.84351218e-02f, -5.65322861e-02f, 1.55471172e-02f, -2.66553815e-02f,
  -1.72044209e-03f, -5.79586998e-02f, 8.63742977e-02f, -1.64253730e-02f, 3.55984382e-02f, -2.68533453e-02f, -3.54606435e-02f, 8.42021853e-02f, 6.20507337e-02f, -4.54848111e-02f,
  -4.58606891e-02f, 7.59907737e-02f, -8.72202888e-02f, 4.86622602e-02f, -4.03901674e-02f, 6.54345527e-02f, 2.69201752e-02f, 7.59905800e-02f, -2.03329679e-02f, -6.16187416e-02f,
  1.46011889e-01f, 5.45375273e-02f, 4.96449620e-02f, 1.01161003e-02f, -4.13338393e-02f, 2.73080021e-02f, -7.37737417e-02f, 1.61925294e-02f, -7.37866163e-02f, -6.45192862e-02f,
  9.27944854e-03f, -5.05503938e-02f, 7.55367510e-04f, 2.21467093e-02f, 2.76883021e-02f, -2.64591835e-02f, 3.93317156e-02f, -4.00066003e-02f, 3.59715410e-02f, 8.32984149e-02f,
  9.21813175e-02f, 1.01070918e-01f, 8.07994083e-02f, -4.60365089e-03f, -1.39632700e-02f, 5.08099981e-02f, -7.74642779e-03f, 7.13720247e-02f, 1.32189272e-03f, -7.05084056e-02f,
  2.32632428e-01f, -1.87797859e-01f, 8.00797045e-02f, 1.18580118e-01f, -4.55968343e-02f, -1.32718414e-01f, -1.65522307e-01f, -7.80763999e-02f, 6.58336356e-02f, 2.97955815e-02f,
  -6.31323978e-02f, -3.89844999e-02f, -5.09534292e-02f, -2.89772283e-02f, -4.66687828e-02f, -1.97881863e-01f, -1.53869420e-01f, 5.21753095e-02f, -8.53956502e-04f, -4.70534973e-02f,
  -6.13599531e-02f, 2.27080528e-02f, 1.35320738e-01f, 3.11507341e-02f, 4.71145995e-02f, 1.17728360e-01f, -5.35019562e-02f, -1.09317906e-01f, -7.14866593e-02f, -2.16876734e-02f,
  9.36965942e-02f, -8.05321336e-02f, 1.28399193e-01f, 8.90668556e-02f, 4.04247791e-02f, 8.74141827e-02f, 1.06923934e-02f, 6.72155768e-02f, 1.50032826e-02f, 7.17089027e-02f,
  7.67949522e-02f, 5.00073656e-02f, 2.88592596e-02f, 3.46779800e-03f, -2.99696997e-02f, 1.02951542e-01f, 8.73267204e-02f, -5.15478663e-04f, -6.16159812e-02f, 6.71796426e-02f,
  -1.13214202e-01f, 8.36760271e-03f, -8.95525962e-02f, 2.48888675e-02f, 6.86696544e-03f, -1.22773647e-01f, 6.38601333e-02f, 4.20019701e-02f, -8.79526436e-02f, -8.85921996e-03f,
  5.61535247e-02f, 6.92596436e-02f, -4.63900305e-02f, -8.48243758e-03f, 2.36853934e-03f, 4.65518013e-02f, 3.43968831e-02f, 6.16475865e-02f, 6.27342686e-02f, -2.64183823e-02f,
  7.42910104e-03f, -1.41290100e-02f, 1.58327539e-02f, 1.19630180e-01f, 1.81882624e-02f, -5.11134267e-02f, -5.64793423e-02f, -4.61180471e-02f, -8.58443696e-03f, -5.44366101e-03f,
  2.30399352e-02f, 8.26458540e-03f, 3.55613232e-02f, 4.35220525e-02f, -8.47882107e-02f, -2.99355132e-03f, 1.20354928e-01f, 2.51278635e-02f, -4.64871638e-02f, -5.04295751e-02f,
  1.74843788e-01f, 2.91778408e-02f, 3.72436978e-02f, 1.97914597e-02f, -7.96245486e-02f, -9.06392336e-02f, -5.69181778e-02f, -5.22506461e-02f, -1.00340791e-01f, 1.31298536e-02f,
  5.89474216e-02f, 2.84307562e-02f, 5.53887300e-02f, 1.25262871e-01f, 8.20654109e-02f, 1.39888003e-02f, -1.35987336e-02f, 1.72570609e-02f, -5.12873866e-02f, 5.36546810e-03f,
  -4.13724892e-02f, -9.46510434e-02f, -1.29568279e-01f, -9.27563533e-02f, -7.48632774e-02f, -1.12485267e-01f, -1.90249067e-02f, 4.36432920e-02f, 7.42830336e-02f, 6.32409677e-02f,
  4.77731049e-01f, -8.30690637e-02f, 1.08367056e-01f, 3.94104481e-01f, 1.43126279e-01f, -3.04399598e-02f, 4.59464453e-02f, 6.90974817e-02f, 9.80326012e-02f, 1.76285148e-01f,
  -7.77947307e-02f, -1.55965192e-02f, -1.65353507e-01f, -7.77195543e-02f, -1.51956886e-01f, 1.60481222e-02f, 2.07338840e-01f, 1.00379353e-02f, -8.24311823e-02f, 1.02702603e-01f,
  -1.16601298e-02f, 1.73004657e-01f, 1.06722713e-01f, 3.58873531e-02f, 8.02107602e-02f, -6.34775311e-02f, 1.08004451e-01f, 1.08014278e-01f, -1.59284975e-02f, 2.84833312e-01f,
  1.55642539e-01f, 1.48316264e-01f, 6.33850396e-02f, -2.98271105e-02f, 6.59724697e-02f, -4.81968746e-02f, -2.48941239e-02f, 3.21591855e-03f, 2.60936492e-03f, -5.33523560e-02f,
  3.35078910e-02f, -5.85085936e-02f, 2.08447948e-02f, -4.79002632e-02f, 1.46617014e-02f, -1.08704846e-02f, -1.11705959e-01f, -7.26366267e-02f, -5.39406203e-02f, 2.88963914e-02f,
  -7.76561946e-02f, 6.38219118e-02f, 4.48907577e-02f, -1.09217130e-01f, -6.47470180e-04f, -6.34936467e-02f, -7.73902163e-02f, 5.34109026e-02f, -1.30703002e-01f, -1.97832640e-02f,
  3.77833880e-02f, -5.62533997e-02f, 2.76983026e-02f, -1.59962326e-02f, -2.68232636e-03f, 2.73762159e-02f, 1.05378209e-02f, 5.19262068e-02f, 2.96198502e-02f, 1.12151932e-02f,
  -9.75522958e-03f, 6.82360306e-02f, -3.34734060e-02f, -9.67958570e-02f, -3.42680290e-02f, 5.98605424e-02f, 3.02953813e-02f, 2.41155885e-02f, 1.99227780e-02f, -6.11015372e-02f,
  3.15409079e-02f, 2.21403483e-02f, 4.27074097e-02f, -7.34277666e-02f, -4.17524949e-02f, 1.60206631e-02f, 6.21165261e-02f, 2.54789386e-02f, -2.10117679e-02f, -5.31572998e-02f,
  -5.28527535e-02f, -7.09284469e-02f, 1.64924100e-01f, 3.56517099e-02f, -4.49223723e-03f, -1.16706612e-02f, 3.38642718e-03f, 3.79913021e-03f, 1.92587432e-02f, 7.74989352e-02f,
  -2.23082267e-02f, 1.38102556e-02f, -1.58757418e-02f, 3.00491992e-02f, 5.98402582e-02f, 3.82270962e-02f, -3.27669345e-02f, -1.62287727e-02f, 2.04522330e-02f, 2.29876023e-04f,
  2.85974331e-02f, 4.60484363e-02f, -3.10853999e-02f, -7.65271932e-02f, -1.08709279e-02f, 5.74562475e-02f, -2.95200255e-02f, 1.35946572e-01f, 2.75972877e-02f, -6.63296208e-02f,
  -1.94690078e-01f, -2.19213981e-02f, -8.10027495e-02f, -2.92975549e-02f, -2.70183943e-02f, 5.34757376e-02f, 7.15646967e-02f, 4.65329736e-02f, 8.73577073e-02f, 3.23655307e-02f,
  9.17262807e-02f, 1.23532362e-01f, 1.68651789e-01f, 9.41685960e-02f, 3.25002261e-02f, 1.77778900e-02f, -9.14863721e-02f, 6.53838664e-02f, 1.34918280e-02f, 3.77756581e-02f,
  1.23504862e-01f, 1.98686812e-02f, 4.59244847e-02f, -5.81491319e-03f, -9.33028013e-02f, 5.58181442e-02f, -3.36372033e-02f, 4.44448702e-02f, 1.17413551e-01f, -3.76098752e-02f,
  1.14465103e-01f, -4.58908156e-02f, 6.98211268e-02f, -1.12904403e-02f, -1.83801148e-02f, 7.57981911e-02f, 2.09384467e-02f, -5.64395264e-02f, 5.39183542e-02f, -3.27027813e-02f,
  -3.03501301e-02f, -1.82487704e-02f, 1.33283496e-01f, 6.07713647e-02f, -6.81415200e-02f, 8.83828774e-02f, -7.31369331e-02f, 9.87939350e-03f, 9.46466625e-03f, 5.92265688e-02f,
  -3.24009731e-02f, 2.53487402e-03f, 8.40698853e-02f, -3.98270003e-02f, 1.01253264e-01f, -4.83366363e-02f, 5.82574643e-02f, -9.31743160e-02f, 1.00973649e-02f, 1.32873058e-02f,
  4.50467467e-02f, 3.71912532e-02f, 4.95935827e-02f, -9.90166888e-02f, 4.60565053e-02f, -5.93592636e-02f, 9.46849212e-03f, -4.88511212e-02f, 3.38062271e-02f, -9.25764591e-02f,
  3.64022888e-03f, -3.89744416e-02f, 2.89908983e-02f, -1.18400324e-02f, 1.05516817e-02f, 2.32998654e-02f, -7.05837691e-03f, 8.12823847e-02f, 5.48506007e-02f, -1.94749970e-03f,
  1.69819556e-02f, 2.20958795e-03f, -2.48915609e-02f, -7.30695352e-02f, -5.87606430e-02f, -1.54042635e-02f, 3.04234996e-02f, 7.77071416e-02f, 1.24112209e-02f, -2.51915175e-02f,
  1.56769469e-01f, 1.87780723e-01f, 1.83898702e-01f, 2.14026608e-02f, -1.92808602e-02f, 4.86354083e-02f, 8.08561593e-02f, 3.44109572e-02f, -6.59906818e-03f, -2.41662376e-02f,
  7.69541711e-02f, 1.14536904e-01f, 6.89792633e-02f, -1.51302833e-02f, 1.78776551e-02f, 8.06161612e-02f, -4.74763140e-02f, 2.53036022e-02f, 6.24255873e-02f, -5.03289700e-02f,
  1.71823781e-02f, -2.67529357e-02f, 1.91863123e-02f, -5.51549792e-02f, -5.73563650e-02f, 2.58899145e-02f, 3.53558175e-02f, -8.30620974e-02f, 5.70083745e-02f, 4.58131582e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.54879782e-02f, -1.35792851e-01f, -2.35686496e-01f, -1.58331282e-02f, 8.28359127e-02f, 5.23253344e-02f, -9.30025987e-03f, 1.79254308e-01f, 1.84835404e-01f, -6.72168061e-02f,
  -5.68506718e-02f, 1.11169197e-01f, -1.85699873e-02f, 2.59941518e-02f, -9.37264860e-02f, -2.00877845e-01f, -1.77098110e-01f, -1.06444992e-01f, 6.12638555e-02f, 9.71605480e-02f,
  4.82226610e-02f, 1.11450717e-01f, -1.56005463e-02f, 1.59503594e-01f, -8.89620483e-02f, -3.64288613e-02f, -1.52028665e-01f, -5.90866525e-03f, -1.71421975e-01f, -2.99408078e-01f,
  -2.24229723e-01f, 8.69442075e-02f, 3.22801732e-02f, -6.10656738e-02f, -3.82542387e-02f, 5.82493506e-02f, -3.39474790e-02f, -5.72799705e-02f, -2.31896415e-02f, 5.66080138e-02f,
  -4.04034257e-02f, -2.41544303e-02f, -7.51486719e-02f, 1.24445580e-01f, -5.64800985e-02f, -6.06791228e-02f, 4.56045531e-02f, -8.35900605e-02f, -7.48113617e-02f, 7.88816288e-02f,
  -8.70371088e-02f, -4.72683460e-02f, -5.18766530e-02f, -6.38485104e-02f, -2.53810249e-02f, -4.28501330e-02f, -9.73499194e-02f, -3.90587514e-03f, -1.39221519e-01f, -1.64809480e-01f,
  -9.55661088e-02f, -6.04243837e-02f, -1.76229291e-02f, 7.22567141e-02f, 1.19755296e-02f, -1.19744390e-02f, -2.60693207e-02f, 3.07021774e-02f, 2.78657279e-03f, 3.77280265e-02f,
  3.29955555e-02f, 1.70223843e-02f, 1.93188321e-02f, -8.11292306e-02f, 1.31823905e-02f, 3.81364450e-02f, -5.23139462e-02f, -1.50432363e-01f, -5.90796545e-02f, -1.87787774e-03f,
  -3.26410197e-02f, -3.67307030e-02f, 2.96483468e-02f, -3.38710584e-02f, -1.03039071e-01f, 8.14502127e-03f, -1.53009212e-02f, 3.67003419e-02f, 2.00408362e-02f, 6.52224198e-02f,
  -5.01315780e-02f, 2.44134385e-02f, 5.32884849e-03f, 7.14501515e-02f, -4.27780068e-03f, 2.56995894e-02f, -2.06667259e-02f, 6.88561574e-02f, 9.43235308e-02f, 4.76457365e-02f,
  -9.75670889e-02f, 4.46763448e-02f, -9.79743972e-02f, -3.93142626e-02f, -2.16199104e-02f, -4.27154787e-02f, 2.07144115e-02f, -4.16494980e-02f, -5.86333722e-02f, 9.54486057e-03f,
  -4.04995270e-02f, 7.66078383e-02f, -1.01630755e-01f, -7.53434971e-02f, 3.45599763e-02f, 1.64394379e-02f, -1.78825855e-01f, -1.91139829e-04f, -3.93356346e-02f, -1.85982898e-01f,
  9.91459265e-02f, 1.35234371e-01f, 3.09400596e-02f, -9.79002044e-02f, 1.03425793e-01f, -1.03718296e-01f, -1.35754207e-02f, 5.07197017e-03f, -7.48745203e-02f, 9.24862921e-02f,
  8.64254981e-02f, -2.82930937e-02f, 3.01172975e-02f, -4.76806937e-03f, -2.14535985e-02f, -1.36843380e-02f, -1.23265535e-02f, -5.51563799e-02f, 1.98869221e-02f, 8.74780864e-03f,
  5.42505160e-02f, 2.57698335e-02f, 2.17335820e-02f, 7.11977556e-02f, -5.93876131e-02f, -7.16343746e-02f, 3.47702153e-04f, -1.75856575e-02f, 4.99353856e-02f, 2.61822343e-02f,
  8.45528394e-02f, 8.77405480e-02f, 6.14809878e-02f, -7.06328452e-02f, 6.20818809e-02f, -7.24593103e-02f, 4.45346870e-02f, -1.05426133e-01f, 7.29603022e-02f, 2.02508434e-03f,
  -4.63018268e-02f, 4.08148915e-02f, -8.07502717e-02f, -6.15464337e-02f, -1.26813287e-02f, -6.15798198e-02f, -3.89028192e-02f, 1.19815413e-02f, -9.28533003e-02f, 7.64753576e-03f,
  -5.51337637e-02f, -4.04982362e-03f, -7.30199143e-02f, -9.72192083e-03f, -4.34238836e-02f, 5.65029457e-02f, -2.28964128e-02f, 3.62640955e-02f, 5.53621762e-02f, -5.96134737e-02f,
  -1.01754747e-01f, 1.00113573e-02f, -3.69244628e-02f, -2.00386271e-02f, -1.02102384e-01f, 8.09737891e-02f, -6.14219904e-02f, -2.31747255e-02f, -3.54819223e-02f, -7.94265270e-02f,
  -5.08954935e-02f, -3.84985767e-02f, -5.80060715e-03f, -1.11250505e-01f, -2.95839142e-02f, -1.64320390e-03f, 6.08470850e-02f, -1.74938831e-02f, -1.11347865e-02f, -2.74103805e-02f,
  6.99357986e-02f, -9.09493025e-03f, -7.07070902e-02f, 2.44911741e-02f, 5.52230887e-03f, -2.73071360e-02f, -6.50498345e-02f, 4.38114554e-02f, -1.12384044e-01f, -1.87243000e-02f,
  2.95836534e-02f, 1.14228437e-03f, -4.44280505e-02f, -6.91862330e-02f, -4.76597063e-02f, -7.51046911e-02f, 6.72683865e-02f, -5.83291799e-02f, 9.41845700e-02f, -7.45324939e-02f,
  -7.01138228e-02f, 3.24193109e-03f, -3.78352553e-02f, 6.52097240e-02f, 6.54293299e-02f, -7.86147192e-02f, -4.77232710e-02f, 2.00991500e-02f, 5.20723499e-02f, -1.49830952e-02f,
  3.40679511e-02f, -5.76137332e-03f, -9.54142306e-03f, -7.47597888e-02f, 3.20567824e-02f, -5.89366443e-02f, -9.48500633e-02f, -8.74595270e-02f, 2.25495510e-02f, -6.91397339e-02f,
  -1.46628112e-01f, 1.81662682e-02f, 3.91551889e-02f, -1.25507578e-01f, -6.35269880e-02f, -9.98664126e-02f, -1.20727614e-01f, -8.81127566e-02f, 6.64706752e-02f, -1.13188967e-01f,
  -7.26027489e-02f, -1.77840814e-02f, -9.40331519e-02f, 2.83530932e-02f, -8.36882591e-02f, -1.41359912e-02f, -4.59051207e-02f, 4.52716425e-02f, 3.86259742e-02f, 6.68238252e-02f,
  -8.90557654e-03f, 3.83241475e-02f, 4.38684635e-02f, 7.50620142e-02f, -4.10384312e-02f, -2.23011002e-02f, -4.71380800e-02f, 7.05357119e-02f, 6.76265061e-02f, 5.48346229e-02f,
  -9.15834606e-02f, -2.99659465e-02f, -3.80733749e-03f, -1.10130385e-02f, -3.72863561e-02f, -9.06774495e-03f, -1.09080523e-01f, 5.33386245e-02f, 6.41019568e-02f, 1.01813935e-02f,
  -5.31651452e-02f, -1.44124897e-02f, 3.01700383e-02f, -2.74818800e-02f, -2.83469539e-02f, 2.41984501e-02f, 7.43399411e-02f, -2.03954279e-02f, -7.71449995e-05f, 6.88946918e-02f,
  -3.06281429e-02f, 8.61918479e-02f, -2.22776309e-02f, 7.83556253e-02f, -9.13614556e-02f, 9.56576020e-02f, -7.92030245e-03f, -3.61444168e-02f, -4.37395560e-04f, 2.24758554e-02f,
  -7.53481165e-02f, -3.64907645e-02f, 6.54927194e-02f, 9.74473804e-02f, -8.10352042e-02f, 4.42004316e-02f, -4.10445593e-02f, -3.15896189e-03f, -4.02425937e-02f, -4.25922982e-02f,
  -6.14501722e-02f, -7.35699534e-02f, 3.87936318e-03f, -3.90462726e-02f, 1.52278505e-02f, 5.11345500e-03f, 7.31777027e-02f, 1.23190852e-02f, 1.55625120e-02f, -2.65385415e-02f,
  -3.23743820e-02f, 8.78161415e-02f, -6.42279610e-02f, 7.38321841e-02f, 3.44692841e-02f, 8.01136941e-02f, 3.50089348e-03f, 8.08313116e-02f, 4.45817001e-02f, -1.95209607e-02f,
  -1.33757606e-01f, 5.35668954e-02f, -7.62985870e-02f, 9.17180702e-02f, 8.68224204e-02f, -5.21677127e-03f, -6.88783079e-03f, 6.77636117e-02f, -3.89788486e-02f, -3.39451618e-02f,
  3.93576100e-02f, -2.14541778e-02f, 5.33611439e-02f, -3.50223184e-02f, 4.04021442e-02f, 8.13188553e-02f, 2.64812019e-02f, 9.05098692e-02f, 3.65158021e-02f, 2.19132379e-03f,
  -3.51120234e-02f, -1.66909713e-02f, -7.66696036e-02f, 7.01067736e-03f, -3.10096014e-02f, -5.67430723e-03f, 2.91733071e-02f, -8.06003436e-02f, -9.87527296e-02f, 1.88288912e-02f,
  7.87678361e-02f, -9.54455957e-02f, -1.01505360e-02f, 5.76586798e-02f, -3.49234454e-02f, -2.01871973e-02f, -7.80484229e-02f, 7.96203613e-02f, 6.39540777e-02f, 4.20696810e-02f,
  -1.10409729e-01f, -6.94423690e-02f, -1.52729740e-02f, -1.64461099e-02f, 2.29707081e-02f, 2.47722343e-02f, -2.02823300e-02f, 4.08399217e-02f, -1.75951347e-02f, -5.23750782e-02f,
  -9.89873633e-02f, 1.64022669e-02f, 1.89747550e-02f, 1.02965586e-01f, -9.65733230e-02f, 8.39372128e-02f, 6.31094277e-02f, -6.28972426e-03f, 3.10480385e-03f, -6.10193461e-02f,
  1.23394597e-02f, -1.86251365e-02f, 6.86495751e-02f, -4.89083081e-02f, -2.05074195e-02f, -6.03853837e-02f, 5.58202490e-02f, -6.11754432e-02f, 6.36912733e-02f, -2.16748449e-03f,
  1.12342080e-02f, 7.89176207e-03f, 7.51736537e-02f, 2.27750558e-02f, -3.10172886e-02f, -5.03806360e-02f, 5.27832769e-02f, -1.66000373e-05f, -7.92916864e-02f, -1.06063634e-01f,
  -1.00865945e-01f, -2.17068400e-02f, -6.60164654e-03f, -2.58598360e-03f, 2.68468307e-03f, -7.05229789e-02f, 1.95763763e-02f, 5.51387519e-02f, 6.10819869e-02f, -9.98731032e-02f,
  -2.68188138e-02f, -3.03880107e-02f, -1.13894278e-02f, -5.33351116e-02f, -6.48152232e-02f, 1.68602616e-02f, 6.12083264e-02f, -1.48125142e-02f, -3.40636820e-02f, -7.66938180e-02f,
  7.55572245e-02f, 7.86363930e-02f, 8.43657255e-02f, -4.69252355e-02f, -6.20408431e-02f, -3.96957509e-02f, 4.91437316e-02f, -3.53887081e-02f, -1.78490265e-03f, 8.25488940e-03f,
  -3.43632661e-02f, -1.02078713e-01f, -6.11332171e-02f, -4.18323539e-02f, -9.35627986e-03f, -5.28160483e-02f, 6.57844767e-02f, 2.07323637e-02f, 6.25178441e-02f, -4.22862619e-02f,
  -1.11369357e-01f, 1.34597644e-01f, 3.57072391e-02f, -6.21352494e-02f, -9.73607507e-03f, -4.11972292e-02f, -5.74829280e-02f, -9.41732153e-02f, 3.10272444e-02f, 1.96461082e-02f,
  -6.04639202e-02f, 4.51055467e-02f, -2.71950457e-02f, 6.33075237e-02f, 7.29887038e-02f, 8.58698934e-02f, -2.29660235e-02f, -6.38759285e-02f, 4.94362563e-02f, 5.90049736e-02f,
  1.04634715e-02f, -5.14062941e-02f, 1.68798771e-02f, 7.11968541e-02f, 5.86480349e-02f, 1.06135748e-01f, 3.97787876e-02f, -8.57387409e-02f, -2.92485617e-02f, 1.84185579e-02f,
  -1.12662509e-01f, -9.88113955e-02f, -3.51960510e-02f, -6.04308359e-02f, -7.42828846e-02f, 4.72324714e-02f, -1.26532078e-01f, 2.60674339e-02f, -4.55184840e-02f, -1.31020978e-01f,
  -1.23603716e-01f, -6.84674084e-03f, -1.59221627e-02f, 5.39196655e-02f, 5.20310029e-02f, -8.98939148e-02f, -9.39370319e-02f, -3.88881415e-02f, -4.21435572e-02f, -5.94798625e-02f,
  2.47907825e-02f, -5.09549305e-02f, 4.08238061e-02f, 9.40756127e-02f, -3.23647968e-02f, 4.41544615e-02f, -6.84878742e-03f, 2.70432774e-02f, -9.39966086e-03f, 2.29209079e-03f,
  -1.58971652e-01f, -2.40718126e-02f, 1.60486884e-02f, -6.17031157e-02f, -5.01980036e-02f, 3.69016174e-03f, -7.26264641e-02f, -7.22815022e-02f, -2.70582717e-02f, -4.15429659e-02f,
  -4.16920930e-02f, -7.11244857e-03f, -8.44865590e-02f, -6.07126839e-02f, -7.84405246e-02f, 2.68876143e-02f, 1.87612895e-03f, 7.83943459e-02f, 8.53942633e-02f, -4.98241708e-02f,
  2.84003522e-02f, -4.53214953e-03f, -3.20358127e-02f, 1.15061559e-01f, 6.83759525e-02f, 1.09405108e-01f, -1.54993183e-03f, 6.83027878e-03f, 6.22991771e-02f, -5.74496686e-02f,
  6.30275533e-02f, -3.51112001e-02f, 5.44740744e-02f, -1.62617508e-02f, -4.59789224e-02f, -3.26489434e-02f, 4.26575802e-02f, -3.32648982e-03f, -9.19793826e-03f, -1.04070321e-01f,
  1.50564117e-02f, -1.76053140e-02f, 4.14940482e-03f, -6.77167848e-02f, -3.02344300e-02f, -3.06213740e-02f, 4.92985658e-02f, 7.48159513e-02f, 5.99703267e-02f, 5.53860068e-02f,
  -9.80954468e-02f, -5.14582321e-02f, -3.08238640e-02f, 1.49383675e-02f, 3.68882492e-02f, -4.94518578e-02f, -1.32983504e-02f, 2.20308008e-04f, -6.26176000e-02f, 2.92563997e-02f,
  -1.16600864e-01f, 1.32392973e-01f, -7.72897911e-04f, 2.03908943e-02f, -9.20983404e-02f, 2.66408268e-03f, -3.73401567e-02f, -4.97106016e-02f, 2.90825684e-02f, -1.93850324e-02f,
  3.31010595e-02f, 1.43468371e-02f, 6.81895763e-02f, -1.30554438e-02f, -2.80810781e-02f, 5.65014556e-02f, 1.86861306e-02f, -3.78125906e-02f, 4.75350916e-02f, 9.75649133e-02f,
  -4.39841077e-02f, -5.08874878e-02f, 5.18226475e-02f, -3.50695699e-02f, 2.57161725e-02f, -5.60406260e-02f, -5.80818243e-02f, 9.68399718e-02f, 6.71419278e-02f, -6.66576996e-02f,
  1.80274248e-01f, 1.03545979e-04f, 6.42846823e-02f, 2.31386423e-02f, -4.48012054e-02f, -5.12328744e-02f, 2.06748564e-02f, 4.43772972e-02f, -2.49308012e-02f, 2.66905800e-02f,
  9.00792852e-02f, -2.35223044e-02f, 1.59165692e-02f, -2.97420230e-02f, 1.92164369e-02f, -2.91774757e-02f, 1.45824868e-02f, -3.42225730e-02f, -2.54817237e-03f, 6.79238960e-02f,
  -5.09456620e-02f, 3.67145315e-02f, 6.45697191e-02f, -5.09036966e-02f, -6.89071044e-02f, -4.26056832e-02f, 7.05146641e-02f, 1.03113599e-01f, -4.19658497e-02f, 3.37560140e-02f,
  8.87694210e-02f, 1.06660999e-01f, 5.52819930e-02f, -5.86646572e-02f, 7.36542866e-02f, -6.42071217e-02f, -3.08121964e-02f, -8.25489219e-03f, 3.92752886e-02f, 3.14010754e-02f,
  6.91578686e-02f, 1.61596034e-02f, 6.28440082e-02f, 6.15033545e-02f, 8.10579732e-02f, 4.50773649e-02f, 3.40367667e-02f, 7.36940354e-02f, -4.37176414e-02f, -3.29263811e-03f,
  3.28822657e-02f, -2.13612784e-02f, 8.86412933e-02f, 3.95620018e-02f, 6.62773550e-02f, 8.81226808e-02f, -4.96774120e-03f, 3.39120254e-02f, 2.95503344e-02f, -4.81859632e-02f,
  -8.58994648e-02f, 2.85773613e-02f, -4.61177677e-02f, -3.37219834e-02f, -6.46263883e-02f, 7.90609717e-02f, 2.33191773e-02f, -7.84597620e-02f, 4.30933461e-02f, 2.33813487e-02f,
  -2.89893206e-02f, -8.01693574e-02f, 2.51653083e-02f, -3.90550755e-02f, -5.86178228e-02f, 6.04295321e-02f, -9.58227962e-02f, -8.63664150e-02f, -1.05701745e-01f, -2.66329218e-02f,
  2.17949301e-02f, -6.93206117e-02f, 3.88995651e-03f, 6.31689578e-02f, 6.85873702e-02f, 7.56113827e-02f, -2.15483755e-02f, 6.80130273e-02f, 1.16956634e-02f, -5.87071478e-02f,
  -9.32231173e-02f, 7.61201084e-02f, 3.11576258e-02f, 4.96986173e-02f, -5.88692911e-02f, 7.76157528e-02f, 7.55561367e-02f, 3.76876589e-04f, 4.87789921e-02f, 6.01792056e-03f,
  -6.42255414e-03f, 4.24689278e-02f, 7.36463517e-02f, -3.57202478e-02f, -9.25127417e-02f, 3.95984128e-02f, -8.62648040e-02f, -8.55575353e-02f, -3.59862931e-02f, 5.97877353e-02f,
  1.21353827e-02f, 5.81871271e-02f, -1.96607746e-02f, 2.19460316e-02f, 1.42330574e-02f, -4.25098054e-02f, -3.37083712e-02f, 6.89009030e-04f, 1.78198447e-03f, -1.36985406e-02f,
  -3.35006490e-02f, 8.89532864e-02f, 6.33491250e-03f, -6.53682789e-03f, -2.62786541e-02f, -5.17466068e-02f, 1.57439157e-01f, 6.13598451e-02f, 3.61386780e-03f, 1.74247976e-02f,
  6.55522197e-02f, -1.16118699e-01f, 6.20030575e-02f, 6.85303658e-02f, 4.74591367e-02f, -4.73954296e-03f, 1.14275599e-02f, -5.80460466e-02f, -8.18766654e-02f, -5.88193983e-02f,
  3.73993139e-03f, -7.58572519e-02f, -6.58309236e-02f, -2.35619862e-02f, -9.20090533e-04f, -1.15227804e-01f, -1.70568228e-02f, -9.72389728e-02f, -7.03287423e-02f, -1.46272387e-02f,
  6.71991184e-02f, -1.14342421e-01f, -7.40133645e-03f, 1.12745352e-03f, 8.73859748e-02f, -7.03946501e-02f, -8.25796276e-02f, -3.77953313e-02f, 3.43361795e-02f, 2.08008960e-02f,
  -7.73261935e-02f, -8.54581743e-02f, -2.38174349e-02f, 4.64841239e-02f, -1.40554272e-02f, 2.28293389e-02f, 7.42138997e-02f, 6.63878992e-02f, -5.25431596e-02f, 1.08882740e-01f,
  5.09319790e-02f, 4.37334403e-02f, -1.71624478e-02f, 1.11550853e-01f, -3.59579101e-02f, -2.29987893e-02f, -4.63276803e-02f, 1.99216809e-02f, -5.06351143e-02f, 5.71208261e-02f,
  1.18866548e-01f, -1.00470977e-02f, -1.19435433e-02f, 4.93495204e-02f, -1.12123163e-02f, -1.08121410e-01f, 1.05730936e-01f, 7.06323385e-02f, -3.45302187e-02f, 5.51335812e-02f,
  -7.06748962e-02f, 6.63941205e-02f, 2.65118666e-02f, -3.48845907e-02f, 6.10941164e-02f, -2.19386420e-03f, 7.00740144e-02f, 3.38552892e-02f, 1.36480592e-02f, 2.55687255e-02f,
  6.54901490e-02f, -3.06416228e-02f, 7.43493065e-02f, 4.17580195e-02f, 3.77660505e-02f, -2.96074320e-02f, 7.73743242e-02f, -4.11891937e-03f, 5.97648956e-02f, -5.20666316e-03f,
  -6.75257593e-02f, 4.95312735e-02f, -6.19245600e-03f, -2.28324421e-02f, -9.04778093e-02f, -5.90175539e-02f, 3.84858884e-02f, -7.62118921e-02f, 4.94864546e-02f, -2.81924605e-02f,
  -9.73539054e-02f, -7.01545104e-02f, -1.70755312e-02f, -8.91782045e-02f, -5.34406789e-02f, -4.21695560e-02f, -5.14940824e-04f, -7.32556432e-02f, 1.08514037e-02f, 2.07287632e-02f,
  -9.93961282e-03f, 4.76724654e-02f, -1.67073812e-02f, 6.80323243e-02f, -2.39586215e-02f, 7.76438266e-02f, -9.07320678e-02f, -7.97335654e-02f, 3.54937352e-02f, -8.71381722e-03f,
  2.73460478e-01f, -3.11969649e-02f, 1.52183115e-01f, 4.80391271e-02f, 1.26491532e-01f, 1.55006498e-01f, 2.00544417e-01f, 5.87658063e-02f, 7.24925846e-02f, 7.57984146e-02f,
  6.82445914e-02f, -3.37929688e-02f, -4.03568149e-02f, -1.87526762e-01f, -1.21789135e-03f, -2.52470654e-02f, -5.20972274e-02f, 5.21960258e-02f, 1.40724719e-01f, 7.94229656e-02f,
  -1.01494186e-01f, 8.45013335e-02f, 9.71176699e-02f, 6.32684529e-02f, -3.91959660e-02f, 3.65799926e-02f, -1.20760947e-02f, -7.22124875e-02f, 1.34585053e-02f, -7.06516281e-02f,
  4.90841977e-02f, 1.51552051e-01f, -3.95631939e-02f, -1.40676990e-01f, 6.60257339e-02f, -4.30435082e-03f, 8.07227567e-02f, -3.41442861e-02f, -7.53130913e-02f, -8.81830454e-02f,
  -8.59973431e-02f, -8.26982185e-02f, 3.45501117e-02f, -7.11480156e-02f, 3.85981090e-02f, 4.22861334e-03f, 3.57722752e-02f, -1.35935759e-02f, 1.43306172e-02f, 3.25162075e-02f,
  -1.07074164e-01f, 7.58160651e-02f, -3.40126152e-03f, -2.31084395e-02f, 1.06989630e-01f, -5.15213199e-02f, -3.91674414e-02f, -3.91018502e-02f, 7.23982677e-02f, -7.78486580e-02f,
  -2.62033790e-02f, 1.31256599e-02f, 9.58323106e-02f, -3.55701111e-02f, 7.38050491e-02f, -6.06122725e-02f, 3.79426219e-02f, -2.50627846e-02f, 4.75599505e-02f, -3.27460617e-02f,
  -6.94960207e-02f, 2.37750658e-03f, 8.71365983e-03f, 3.96681903e-03f, 4.54612412e-02f, -2.81806011e-02f, 3.79738212e-02f, -2.69269217e-02f, -1.61061306e-02f, 2.14449037e-02f,
  1.32662252e-01f, 1.35848466e-02f, 5.90742305e-02f, -1.08780950e-01f, -4.91158513e-04f, -1.50062069e-02f, 3.44571359e-02f, 3.02988961e-02f, 1.68256052e-02f, 9.09680277e-02f,
  -1.88793227e-01f, 1.05674110e-01f, -4.28090878e-02f, -1.05977647e-01f, -7.92850405e-02f, 3.15979905e-02f, 1.83395520e-02f, 7.19019538e-03f, -1.29709721e-01f, -8.97974968e-02f,
  -9.31295827e-02f, 3.44207510e-02f, -9.09753051e-03f, 5.53056933e-02f, 5.69484159e-02f, 8.46580565e-02f, 2.57635452e-02f, 4.72845919e-02f, -8.27524886e-02f, 4.83028926e-02f,
  -1.96982715e-02f, -1.84495226e-02f, 1.16679810e-01f, 5.47576919e-02f, 5.53919487e-02f, -7.43151382e-02f, -2.02803053e-02f, -5.96259423e-02f, 1.11377664e-01f, 6.16863482e-02f,
  1.75177548e-02f, -5.27485535e-02f, -1.00932412e-01f, 5.18612703e-03f, -1.02446370e-01f, 5.05756810e-02f, 3.85982543e-02f, 5.01727350e-02f, 1.68391690e-02f, -1.22087859e-02f,
  -8.83418545e-02f, -3.91899832e-02f, 3.00179962e-02f, 2.73036696e-02f, 5.02328388e-03f, -1.24267293e-02f, -6.74338415e-02f, 3.79184969e-02f, -5.42106889e-02f, -5.29813254e-03f,
  2.89384164e-02f, -3.13806795e-02f, 5.91104738e-02f, 4.49767243e-03f, 3.70347500e-03f, 1.09115327e-02f, -5.60042774e-03f, -5.05139492e-02f, -1.37129966e-02f, -4.80537415e-02f,
  -6.46091998e-02f, -2.77143791e-02f, 3.60228643e-02f, 4.28722799e-02f, 4.18996960e-02f, 1.84469242e-02f, 6.46579713e-02f, -7.20050856e-02f, -3.55802812e-02f, 7.95692205e-02f,
  6.19838908e-02f, 1.01986993e-03f, 7.68977180e-02f, -2.06266176e-02f, 5.20966342e-03f, -7.69957900e-02f, -2.51526274e-02f, -6.07781895e-02f, 5.23885805e-03f, 1.05065956e-05f,
  7.70144910e-02f, 6.15562499e-02f, 7.61292651e-02f, 2.95979045e-02f, -4.27642837e-02f, 4.11073789e-02f, -7.09790215e-02f, -4.55235750e-06f, -2.26824936e-02f, -7.46177211e-02f,
  5.60359284e-03f, 9.92956236e-02f, 6.96734432e-03f, -3.30947191e-02f, 1.12192174e-02f, 2.53911335e-02f, -8.30604807e-02f, 8.48444104e-02f, 5.91715500e-02f, 7.16332644e-02f,
  8.69342536e-02f, 7.86929950e-02f, -8.57452676e-02f, 9.15611386e-02f, 6.21920079e-02f, 9.79294032e-02f, 8.82683136e-03f, 8.11007321e-02f, 9.23829228e-02f, 9.90051776e-02f,
  5.99939898e-02f, -3.04023381e-02f, -6.60387129e-02f, -1.25807244e-02f, -3.02604977e-02f, 6.86036199e-02f, 1.05062403e-01f, 5.17507829e-02f, -5.55723868e-02f, 7.27423048e-03f,
  2.74595171e-02f, 5.24739325e-02f, 5.12616411e-02f, 1.35038374e-02f, 2.16385182e-02f, 3.84605154e-02f, -5.12594245e-02f, 6.25900179e-02f, -3.76490578e-02f, -5.23696356e-02f,
  -7.69413337e-02f, 7.58649632e-02f, 2.77209003e-02f, 8.27532411e-02f, -4.37815953e-03f, -6.59998134e-02f, -2.63110492e-02f, -2.99960840e-02f, 4.92243320e-02f, -9.69172549e-03f,
  9.89510268e-02f, 6.47120997e-02f, -3.83078121e-02f, -5.55087142e-02f, 4.64972779e-02f, -2.63504423e-02f, -9.93088931e-02f, 2.48960368e-02f, -3.15187424e-02f, 3.31944078e-02f,
  -8.54646116e-02f, -2.48525897e-03f, -1.02783300e-01f, -4.52494882e-02f, -2.43797153e-02f, 2.06006858e-02f, -1.48892969e-01f, -9.23783332e-02f, 1.03490930e-02f, 3.26996259e-02f,
  5.09613520e-03f, -8.29755422e-03f, 9.03491154e-02f, 1.12215862e-01f, -5.74945509e-02f, -1.64261144e-02f, -6.19652644e-02f, -7.79797509e-02f, 9.85082462e-02f, -9.82725248e-03f,
  4.64326590e-02f, -8.20816755e-02f, 1.47192897e-02f, 3.81057225e-02f, -6.71711266e-02f, -6.10158481e-02f, -2.28332747e-02f, -1.56972744e-02f, -1.49966637e-02f, -1.31427556e-01f,
  1.22026363e-02f, 9.09826532e-02f, -3.22614536e-02f, 8.84672105e-02f, 4.95570600e-02f, -3.89190651e-02f, -7.45958760e-02f, 9.33404118e-02f, -7.12214038e-02f, 7.92710036e-02f,
  1.97662394e-02f, 4.08815369e-02f, 8.81956443e-02f, -4.94101420e-02f, 4.07806970e-02f, -8.52152631e-02f, 1.64128598e-02f, 4.14262451e-02f, -7.70839453e-02f, -8.23131055e-02f,
  -7.34388456e-02f, 2.48816814e-02f, 8.88698697e-02f, 3.65485027e-02f, -6.76556453e-02f, -4.37435955e-02f, -9.96029899e-02f, 6.73364028e-02f, -8.72563347e-02f, -8.98814127e-02f,
  -8.62713382e-02f, 2.98424866e-02f, -8.09689686e-02f, 3.56454141e-02f, -8.20251405e-02f, -5.91984838e-02f, -6.04663230e-02f, 3.52632217e-02f, -4.57033254e-02f, -6.94961250e-02f,
  2.50115581e-02f, 2.52754129e-02f, -3.48280147e-02f, 6.43891692e-02f, -2.06908081e-02f, 2.75613628e-02f, -1.21236928e-02f, -2.34049875e-02f, -9.34351236e-03f, 6.98791742e-02f,
  5.42362146e-02f, 6.29219040e-02f, 1.22870998e-02f, 3.19929197e-02f, 3.16581316e-02f, 5.01994276e-03f, -7.14646354e-02f, 2.81626061e-02f, -1.48920752e-02f, -1.60211790e-02f,
  -9.25222039e-03f, -1.52208097e-02f, 5.66389412e-02f, -4.31837849e-02f, -4.41077128e-02f, 2.21774653e-02f, -4.27391715e-02f, -4.06410545e-02f, 2.96802502e-02f, -2.56602652e-02f,
  -5.38552739e-03f, -7.17056096e-02f, 1.28270118e-02f, 1.73474476e-02f, -1.55186132e-02f, 9.64640453e-02f, 2.24186014e-02f, -1.40927825e-02f, -1.96513422e-02f, 4.16077003e-02f,
  -1.88593275e-03f, 7.73245916e-02f, 2.75485497e-02f, -8.22516307e-02f, -1.89093407e-02f, 2.51732245e-02f, 5.58205741e-03f, 8.27433243e-02f, 6.24774359e-02f, -2.55340468e-02f,
  -1.25114888e-01f, -1.82146430e-02f, -4.56731506e-02f, -1.21543914e-01f, -7.23347366e-02f, -4.85461839e-02f, -8.11424777e-02f, 1.16142079e-01f, 4.06380557e-02f, -1.46396697e-01f,
  -4.28329706e-02f, 9.08835083e-02f, -1.09437816e-01f, 7.21134469e-02f, -5.40606864e-02f, -1.52534321e-01f, -1.83604196e-01f, -1.25310328e-02f, -4.91216406e-03f, 3.57473083e-02f,
  3.53375077e-02f, -8.08572695e-02f, -8.50958191e-03f, 4.57143262e-02f, 4.93054427e-02f, -1.60245318e-02f, 1.03153312e-03f, -1.21512398e-01f, -5.50085939e-02f, -1.71667337e-01f,
  -1.20427489e-01f, 3.94810401e-02f, 9.98497475e-04f, 9.75616723e-02f, -6.59949929e-02f, 2.90878490e-02f, 5.50202392e-02f, 2.00316627e-02f, -1.06621012e-02f, -7.21435770e-02f,
  6.17113225e-02f, 6.38682991e-02f, 5.35224490e-02f, -3.20101380e-02f, 6.99483603e-02f, 4.46682051e-02f, 7.88642913e-02f, 1.46627463e-02f, 4.02090847e-02f, 5.27291261e-02f,
  4.64041494e-02f, 8.49684179e-02f, -7.83960160e-04f, 2.70497985e-02f, 1.21149331e-01f, -1.91688389e-02f, 1.20224906e-02f, 1.48384929e-01f, 3.73113081e-02f, -4.92037348e-02f,
  -6.75795153e-02f, -4.20292504e-02f, -2.39084903e-02f, 3.52265090e-02f, 7.19853342e-02f, 9.99814048e-02f, -4.52573076e-02f, -9.40811634e-02f, 2.56511196e-02f, 2.01923214e-02f,
  1.56410094e-02f, -2.31633317e-02f, 7.84083381e-02f, -1.39339641e-03f, -2.26831939e-02f, -4.46147583e-02f, 3.61878350e-02f, 3.37411724e-02f, -1.49064818e-02f, -4.51123267e-02f,
  4.49495614e-02f, 4.92014410e-03f, -6.98303506e-02f, 1.02921836e-01f, 3.77149656e-02f, 1.02057785e-01f, -7.23047033e-02f, -2.40522195e-02f, 2.32291259e-02f, 5.44294342e-03f,
  -6.46407008e-02f, -4.03273180e-02f, -9.69246551e-02f, -5.55683076e-02f, -4.74743880e-02f, 4.37216759e-02f, -7.71161467e-02f, 9.60985292e-03f, -3.79167125e-02f, 4.84049134e-02f,
  1.10859066e-01f, -3.85557651e-03f, -4.20844853e-02f, -1.20020788e-02f, 1.24052651e-01f, 9.58544537e-02f, -3.12477164e-02f, 1.13413809e-02f, 1.33826677e-02f, -9.83421691e-03f,
  1.03244454e-01f, 6.03804365e-02f, -3.89397591e-02f, -1.74366180e-02f, 1.32196881e-02f, -2.23570280e-02f, 2.27274969e-02f, -5.08424304e-02f, -7.85465688e-02f, 3.77256498e-02f,
  -5.00338897e-02f, 6.86883032e-02f, -3.37692425e-02f, 4.20040451e-02f, 6.18539974e-02f, 5.00231003e-03f, 1.94504391e-02f, -6.25288114e-02f, 4.16765548e-02f, 6.73791841e-02f,
  -1.94636397e-02f, -5.48864491e-02f, 9.91754886e-03f, 7.16727749e-02f, 8.33646804e-02f, 1.78065128e-03f, -1.63428008e-03f, -4.63602692e-03f, 9.18906182e-02f, 1.15839705e-01f,
  -9.27992463e-02f, -6.60128966e-02f, 3.91887799e-02f, -9.49170813e-02f, -3.16056348e-02f, -1.27231767e-02f, -3.30106765e-02f, 8.12441483e-02f, 8.48068856e-04f, 1.15506155e-02f,
  1.13128856e-01f, -9.92925614e-02f, -2.31427550e-02f, -6.84258789e-02f, 5.98426163e-02f, -8.20353329e-02f, -4.46947105e-02f, 4.59992513e-02f, 2.55499016e-02f, -4.13355343e-02f,
  5.83051778e-02f, -8.04115385e-02f, 2.33116318e-02f, -1.01305395e-01f, 2.90447660e-02f, -6.38265237e-02f, -5.86919067e-03f, -7.93208405e-02f, 3.65533419e-02f, -9.32193324e-02f,
  -9.99162719e-02f, 4.40501794e-02f, 4.93329428e-02f, -8.55057910e-02f, 2.24689897e-02f, -1.60146337e-02f, 3.87242027e-02f, 2.56567840e-02f, -2.44965684e-02f, 6.06426131e-03f,
  -1.31274093e-04f, 5.25572076e-02f, 2.14437693e-02f, 2.47462485e-02f, 6.98066130e-02f, -7.66466409e-02f, 6.52296320e-02f, -2.59315372e-02f, -7.15822205e-02f, 3.17396820e-02f,
  5.50262928e-02f, 1.80897824e-02f, 1.54504459e-02f, 3.12397052e-02f, -2.85874009e-02f, 3.03339995e-02f, 7.04476312e-02f, -4.31074016e-02f, 6.33861199e-02f, -3.46449986e-02f,
  -5.78849204e-02f, -3.85057591e-02f, 7.53448531e-02f, -8.55559409e-02f, 6.19035065e-02f, 5.00883050e-02f, -6.50094915e-03f, -1.72335338e-02f, -1.79782100e-02f, 1.71006825e-02f,
  2.31363103e-02f, -2.20804159e-02f, 9.49097350e-02f, 5.87863959e-02f, -3.33508328e-02f, -8.58156309e-02f, 9.00346935e-02f, 4.29755151e-02f, -7.05394614e-03f, 3.72743309e-02f,
  4.07856852e-02f, -9.74316336e-03f, 2.01377645e-02f, 3.73051465e-02f, -4.70118076e-02f, 3.05755939e-02f, -2.56338902e-02f, -5.40619418e-02f, 7.54827335e-02f, 3.78005244e-02f,
  -9.40937698e-02f, 6.91989809e-02f, 1.68134421e-02f, 8.04293975e-02f, 5.84616363e-02f, 5.42147234e-02f, 9.84742939e-02f, 3.00913397e-02f, 7.30962232e-02f, 1.04870379e-01f,
  1.50318310e-01f, -8.19031075e-02f, -4.83477535e-03f, 6.01557642e-03f, -1.79166086e-02f, 1.60387427e-01f, 1.38540581e-01f, 7.09640086e-02f, -1.24805784e-02f, 6.41503185e-02f,
  1.18116206e-02f, -8.04251581e-02f, 3.02218576e-03f, 7.36313611e-02f, -1.40507249e-02f, -1.20924525e-02f, 4.32350002e-02f, 2.38969550e-02f, 1.61153659e-01f, -5.65903680e-03f,
  -7.88495541e-02f, -1.79416705e-02f, 1.09731212e-01f, 5.49515784e-02f, 6.09694049e-02f, -5.67922071e-02f, -7.59260133e-02f, -7.47086480e-02f, -1.00866430e-01f, 1.20547386e-02f,
  1.00225464e-01f, -8.08270201e-02f, 1.41712213e-02f, -2.49693114e-02f, -9.17983577e-02f, -6.96407035e-02f, 7.58354887e-02f, -4.24561556e-03f, 8.21561273e-03f, 1.44982161e-02f,
  -1.57772787e-02f, 1.03269927e-02f, -1.13972984e-01f, -3.35434191e-02f, -5.92237413e-02f, 1.18007520e-02f, -4.37740982e-02f, 3.16684283e-02f, -3.35824639e-02f, -4.63455990e-02f,
  -7.48827159e-02f, 8.43753517e-02f, 4.60774191e-02f, 7.15287328e-02f, -5.61859459e-02f, -2.30564978e-02f, 3.52214724e-02f, 7.10699856e-02f, 4.45916355e-02f, -6.09898679e-02f,
  -2.98729930e-02f, 1.03640452e-01f, 3.30355577e-02f, -6.48721009e-02f, -6.31748885e-02f, 8.58982876e-02f, -8.08526054e-02f, -6.01097420e-02f, 2.13810615e-02f, 8.48057717e-02f,
  -3.17028165e-02f, 8.88594538e-02f, 1.40641341e-02f, 2.07669511e-02f, -1.37852998e-02f, 7.43420096e-03f, -2.96399649e-02f, -4.45930026e-02f, -1.06221035e-01f, -1.04357488e-01f,
  -4.21982184e-02f, -7.10708499e-02f, 1.50103290e-02f, -1.14687597e-02f, -4.16429043e-02f, 6.18023910e-02f, 5.90772107e-02f, -5.56679219e-02f, -1.02330007e-01f, 3.75348777e-02f,
  -1.08869955e-01f, -7.95473531e-02f, 1.60180286e-01f, -3.11894976e-02f, 4.28476520e-02f, -3.62343574e-03f, -3.52411009e-02f, -2.96421647e-02f, -1.16221182e-01f, 2.03812262e-03f,
  1.45803643e-02f, 8.63177776e-02f, -7.93445855e-02f, 5.50475493e-02f, 7.49250129e-02f, -4.19169590e-02f, 2.17764508e-02f, 2.21957229e-02f, -7.56708458e-02f, -2.94355508e-02f,
  5.44273388e-03f, -1.74583755e-02f, 1.24614179e-01f, 4.33606794e-03f, 2.59351954e-02f, 3.12276720e-03f, 8.70588869e-02f, -2.74469052e-02f, -7.90286735e-02f, 1.03828773e-01f,
  -8.30927491e-02f, 1.21091947e-01f, -6.66474178e-02f, -1.22113198e-01f, -1.09420121e-01f, -3.92589755e-02f, 4.37592454e-02f, 2.34967507e-02f, 4.73675914e-02f, -9.76366252e-02f,
  3.41576338e-02f, 6.35986552e-02f, 1.31642371e-02f, 5.02807721e-02f, -3.93246002e-02f, -1.07895128e-01f, -5.63718565e-02f, -7.33163115e-03f, -5.25336191e-02f, 7.71735460e-02f,
  8.26808214e-02f, -1.59799419e-02f, 2.60326546e-02f, -1.04927672e-02f, 4.65241112e-02f, -1.55674778e-02f, -3.26934680e-02f, -3.83981504e-02f, 5.52671291e-02f, -7.51476139e-02f,
  2.16494694e-01f, -1.52462423e-01f, -1.00703567e-01f, -7.88491666e-02f, -1.11723086e-02f, -5.66798039e-02f, 3.76443826e-02f, -5.63996360e-02f, -6.51697144e-02f, -1.34618832e-02f,
  -6.30122945e-02f, 6.70118704e-02f, 6.47252426e-02f, -1.75214410e-02f, 5.28560877e-02f, -3.05385888e-02f, -5.55604473e-02f, -6.66358024e-02f, 1.33901611e-02f, -5.34678344e-04f,
  1.71075203e-02f, -7.50045804e-03f, -3.02816946e-02f, 1.98428966e-02f, -5.70130497e-02f, -7.40716308e-02f, -1.24105401e-02f, -4.84802723e-02f, -6.16338290e-02f, 1.06818020e-01f,
  3.95074263e-02f, 7.24305138e-02f, -7.32558444e-02f, -2.54488010e-02f, 7.12085068e-02f, 1.83189083e-02f, 3.25794220e-02f, 1.41772524e-01f, 1.19039845e-02f, 6.34482354e-02f,
  -6.55716434e-02f, -9.03584883e-02f, -8.50208625e-02f, 5.78015894e-02f, 2.42510885e-02f, -1.34183690e-02f, 2.11385898e-02f, 5.37982956e-02f, 3.37898098e-02f, -2.81655602e-02f,
  1.88758001e-02f, 4.56966981e-02f, -4.42216508e-02f, 9.33172777e-02f, -1.46483168e-01f, 2.77509093e-02f, 2.12665126e-02f, -3.60859819e-02f, 1.20452866e-02f, -7.62486532e-02f,
  2.94129521e-01f, -1.76361576e-01f, -1.15435638e-01f, 3.86065952e-02f, -1.84778515e-02f, -4.25073542e-02f, -1.92610528e-02f, -3.62491384e-02f, 1.61620099e-02f, 4.51096566e-03f,
  -5.84499836e-02f, 1.07308561e-02f, 5.75026013e-02f, -2.68948097e-02f, 2.13774163e-02f, 2.43352298e-02f, 6.66637942e-02f, -1.54330311e-02f, -4.53622006e-02f, -1.02166422e-02f,
  -4.24641967e-02f, 3.75626646e-02f, 2.16664914e-02f, 3.80371176e-02f, 2.04317644e-02f, 7.57953152e-02f, 7.26466402e-02f, 8.63478035e-02f, 5.32333106e-02f, 1.09032199e-01f,
  1.18428148e-01f, 6.48513809e-02f, -1.67194560e-01f, -3.82674336e-02f, -8.91860276e-02f, -1.41335681e-01f, -1.22003011e-01f, 2.58866772e-02f, 5.61060198e-02f, -7.01541593e-03f,
  -7.38671571e-02f, -1.21488720e-02f, 2.51553394e-02f, -6.03014641e-02f, -6.04494885e-02f, 4.89221746e-03f, -5.20810075e-02f, -8.14892873e-02f, -1.29866555e-01f, -4.44051847e-02f,
  -6.95803091e-02f, 6.32657930e-02f, 7.57645369e-02f, -3.32728848e-02f, -6.50059655e-02f, -1.02083780e-01f, -1.03197537e-01f, 4.64772657e-02f, -6.53847605e-02f, -8.09027031e-02f,
  -1.34576499e-01f, -9.31547135e-02f, -8.88826419e-03f, -2.10531261e-02f, -2.10227817e-02f, 3.84993404e-02f, -5.51059619e-02f, -1.48678850e-02f, -1.01909801e-01f, -2.36270297e-02f,
  -5.31268902e-02f, -1.12113990e-01f, -1.02595771e-02f, 3.70019972e-02f, -1.13673015e-02f, 1.62792560e-02f, 2.28384398e-02f, 1.34718772e-02f, -9.20766965e-02f, -1.59833431e-02f,
  3.91962789e-02f, -3.28944065e-02f, -6.96072960e-03f, -8.20510015e-02f, -5.18441834e-02f, -1.02018923e-01f, -4.32063406e-03f, -1.03109494e-01f, -6.93253800e-02f, 9.55773331e-03f,
  3.54536697e-02f, 7.63727576e-02f, 3.66997272e-02f, -3.09340321e-02f, 9.04923379e-02f, 1.28964605e-02f, 5.35892658e-02f, -4.95820530e-02f, 7.99550563e-02f, 7.38244429e-02f,
  1.45965395e-02f, -7.46287704e-02f, -4.07334454e-02f, 7.92059675e-02f, 6.21408224e-03f, 2.62156818e-02f, 8.86709914e-02f, 3.81755307e-02f, 1.51291350e-02f, 3.43299620e-02f,
  2.55771764e-02f, -4.42229547e-02f, 3.05300504e-02f, 5.35988528e-03f, 4.85561304e-02f, -5.87030910e-02f, -1.21502187e-02f, -7.48771578e-02f, 9.88383964e-03f, -5.96673787e-02f,
  -6.87131435e-02f, -1.48134887e-01f, -2.90586539e-02f, -9.37227160e-02f, 7.20332051e-03f, 8.28871951e-02f, 9.83461272e-03f, -3.36618535e-02f, -8.32316950e-02f, -5.87458462e-02f,
  -4.11717258e-02f, 1.59834977e-02f, 4.92590815e-02f, -4.88077337e-03f, -1.11914724e-01f, 6.71258345e-02f, 3.16290185e-03f, -1.46783795e-02f, 9.88267176e-03f, -3.55553776e-02f,
  1.03408529e-03f, 9.01393071e-02f, 1.03317304e-02f, -6.57947436e-02f, -4.80516367e-02f, -1.36082824e-02f, 3.34799550e-02f, -6.75229952e-02f, -2.02959552e-02f, 1.53346792e-01f,
  -9.52994674e-02f, 1.28310233e-01f, -1.36069041e-02f, -2.26585418e-02f, 1.43242963e-02f, -5.32981753e-02f, -7.13166520e-02f, -1.61747977e-01f, -6.04566336e-02f, -9.07857418e-02f,
  6.81202784e-02f, 2.86523602e-03f, -2.35786960e-02f, 3.37322541e-02f, -4.05580327e-02f, -8.55516493e-02f, 3.04200910e-02f, 9.47587285e-03f, -8.35040584e-02f, -1.04500009e-02f,
  7.69010484e-02f, -4.33012620e-02f, -7.43300319e-02f, -1.06156401e-01f, 8.55438039e-02f, -1.51301268e-02f, 3.51183489e-02f, -5.52058872e-03f, -1.85346343e-02f, 1.46378636e-01f,
  7.62270391e-02f, 3.31834108e-02f, 7.21106753e-02f, 4.11713496e-02f, -1.19804507e-02f, -7.21584186e-02f, -1.59463175e-02f, 3.33341546e-02f, -3.52004506e-02f, -3.97105701e-02f,
  2.22422127e-02f, 1.32620437e-02f, 5.17297685e-02f, 5.87146692e-02f, 1.82935642e-03f, 2.14585233e-02f, -1.09470107e-01f, -8.51923153e-02f, -8.61288980e-02f, -1.95779391e-02f,
  -8.40782970e-02f, -2.15969644e-02f, -2.07645539e-03f, 2.63240170e-02f, -3.49592194e-02f, -9.03033987e-02f, -1.08365588e-01f, -7.34767243e-02f, -1.09504767e-01f, 6.64730668e-02f,
  -9.60633457e-02f, 5.89097850e-02f, -1.75828021e-02f, 2.12564338e-02f, -3.10430117e-02f, -3.66785489e-02f, -6.74655885e-02f, -5.23624681e-02f, -5.39406799e-02f, 3.22615094e-02f,
  -5.00427857e-02f, 6.77248323e-03f, 4.53883372e-02f, 1.01654697e-02f, -4.59544063e-02f, -2.55892966e-02f, 3.24880369e-02f, -3.79513316e-02f, -1.14171922e-01f, 2.31558587e-02f,
  -5.20359501e-02f, 7.77255371e-02f, 2.21237000e-02f, 6.24300027e-03f, -1.27304435e-01f, -3.38562317e-02f, -5.93930185e-02f, -7.31657967e-02f, -1.20816492e-02f, -1.85034741e-02f,
  -6.98949471e-02f, 2.85514537e-02f, -1.41019942e-02f, 2.85838284e-02f, 6.79222941e-02f, -7.79535528e-03f, -2.55295634e-02f, -7.78987929e-02f, 4.99192276e-04f, 4.72122356e-02f,
  -5.98050244e-02f, 2.17636935e-02f, 8.71155038e-03f, 2.84781829e-02f, 2.02450119e-02f, -6.24272414e-02f, -3.18339653e-02f, 6.16337247e-02f, 3.21282633e-02f, -1.06598660e-01f,
  -1.08954318e-01f, -6.34750277e-02f, -2.67127343e-02f, 2.78858058e-02f, 8.09177663e-03f, -8.44636038e-02f, -9.38141048e-02f, -5.37502952e-02f, -1.78091170e-03f, -1.25689462e-01f,
  3.29354554e-02f, -8.51242170e-02f, -1.98242858e-01f, 4.88460809e-02f, -8.15183371e-02f, 4.48593013e-02f, -9.42582712e-02f, 7.91436285e-02f, -4.45257649e-02f, -1.59712195e-01f,
  3.87544334e-02f, -5.46973459e-02f, -4.93744127e-02f, 3.20989527e-02f, -1.15810446e-01f, -1.94454804e-01f, -1.99076310e-01f, -8.63187239e-02f, 1.64462589e-02f, -5.88622801e-02f,
  -6.78770430e-03f, 7.22454637e-02f, -1.49982600e-02f, -3.84038910e-02f, 1.09436944e-01f, 1.12910084e-01f, -2.67740097e-02f, -7.73347020e-02f, -1.79054867e-02f, -6.57109022e-02f,
  -1.25344381e-01f, -1.05583968e-04f, 6.90374821e-02f, -6.70051202e-02f, -3.96746285e-02f, -2.78985538e-02f, 4.48122956e-02f, -5.68143092e-02f, 6.69146925e-02f, -3.98267023e-02f,
  7.86555484e-02f, -4.22709472e-02f, -2.41739750e-02f, -1.43528637e-02f, 6.20159991e-02f, -1.03627332e-01f, 7.32795298e-02f, -9.62603837e-02f, 3.63696776e-02f, -2.54658628e-02f,
  -1.46141089e-02f, -5.51844835e-02f, 3.50665189e-02f, -5.31631447e-02f, 2.29965802e-02f, 1.21733705e-02f, -4.79401797e-02f, 1.01940274e-01f, -5.60419075e-02f, 4.18356471e-02f,
  -4.33036536e-02f, 3.63138430e-02f, -2.74500865e-02f, 7.29915053e-02f, -7.51816928e-02f, -4.70364541e-02f, 7.68204452e-03f, -1.14260070e-01f, -2.25888961e-03f, 4.03996147e-02f,
  -5.56243658e-02f, -1.04041524e-01f, -9.34158489e-02f, -4.92031761e-02f, 3.77659090e-02f, -9.04187337e-02f, -4.85711619e-02f, -5.79475351e-02f, 7.65797198e-02f, 1.34983268e-02f,
  -3.09253782e-02f, 2.64141592e-03f, -1.14304852e-02f, 1.24103865e-02f, -3.08053326e-02f, -3.81033681e-02f, 3.98259796e-02f, -5.93420258e-03f, -3.87899652e-02f, -6.75476389e-03f,
  2.73609422e-02f, -7.18770474e-02f, -5.49932010e-03f, -4.17161873e-03f, 6.57327846e-02f, 2.13320497e-02f, -3.60581018e-02f, -8.31129774e-02f, 9.66648683e-02f, 1.16855195e-02f,
  -2.05177292e-02f, -8.27833265e-03f, -7.57320523e-02f, 3.20247747e-02f, -3.54161039e-02f, 2.47221123e-02f, 2.06250101e-02f, -2.13101748e-02f, 1.29459919e-02f, 6.68943152e-02f,
  3.11103668e-02f, -1.04792804e-01f, -4.06345651e-02f, 3.44395079e-02f, -8.55972990e-03f, -6.30215108e-02f, -2.36786045e-02f, -8.69158432e-02f, -1.21560581e-01f, -1.43569753e-01f,
  -8.51290748e-02f, 4.60795872e-02f, -9.24513638e-02f, -1.00213718e-02f, 1.67976156e-01f, 1.19666316e-01f, 1.42420515e-01f, 8.31285194e-02f, 4.06336710e-02f, 1.27591804e-01f,
  -4.29690741e-02f, -4.70438972e-02f, -2.19710544e-02f, -1.85409132e-02f, 1.24786697e-01f, 1.13555066e-01f, 1.26233011e-01f, 6.59529194e-02f, 7.53427371e-02f, 1.22887954e-01f,
  -6.26856508e-03f, 8.21822360e-02f, -1.93178244e-02f, 3.39211449e-02f, -1.92724878e-03f, 2.90521402e-02f, 1.33964233e-02f, 6.06755130e-02f, 5.33603653e-02f, 5.57507910e-02f,
  -2.61862706e-02f, -2.70166937e-02f, -3.06251775e-02f, -7.09494352e-02f, 3.45435031e-02f, -2.20662560e-02f, -4.19202112e-02f, 4.90792878e-02f, -5.13419360e-02f, -7.03521892e-02f,
  -6.21857867e-02f, -2.18150802e-02f, 6.85663223e-02f, -9.42881331e-02f, -5.44786900e-02f, 7.92297199e-02f, 1.29657444e-02f, 2.94427257e-02f, -3.64013314e-02f, 3.23856771e-02f,
  -4.52180542e-02f, -5.37324585e-02f, 8.87352824e-02f, 1.19495884e-01f, -1.21159879e-02f, -3.51062883e-03f, 2.85159014e-02f, -8.51298720e-02f, 3.40891592e-02f, -1.19631842e-01f,
  9.66878459e-02f, 1.08847067e-01f, -2.88953241e-02f, -1.35086346e-02f, -5.34388684e-02f, 6.66656643e-02f, 1.10968165e-01f, 2.61305063e-03f, -1.00544486e-02f, -3.93003114e-02f,
  5.69053814e-02f, 1.18365936e-01f, 1.05952576e-01f, 8.03923532e-02f, 1.32188916e-05f, 1.52437678e-02f, 1.49254799e-02f, -5.07658944e-02f, -3.79813351e-02f, 8.62294585e-02f,
  -1.09927198e-02f, 5.32213263e-02f, 3.08258255e-04f, 7.01758489e-02f, 3.35247777e-02f, 6.60322458e-02f, 6.20650165e-02f, 3.49117513e-03f, 8.15244839e-02f, 1.07791729e-01f,
  -4.46709841e-02f, 4.91291322e-02f, -9.41508077e-03f, 5.51088937e-02f, 8.02152455e-02f, -1.40773191e-03f, 6.14480637e-02f, 8.12694877e-02f, -1.91506390e-02f, 4.98429611e-02f,
  -3.35848443e-02f, -6.80508018e-02f, 5.62111735e-02f, 7.34197348e-02f, 2.86155790e-02f, -4.20765840e-02f, 6.58017024e-03f, 2.08183993e-02f, 9.12426487e-02f, -7.33529305e-05f,
  3.65658738e-02f, -1.75443143e-02f, 2.81456821e-02f, 4.40721698e-02f, 7.46749565e-02f, 5.60619831e-02f, -5.88747021e-03f, 1.53839691e-02f, 1.90967433e-02f, 1.89884268e-02f,
  -2.00798586e-01f, -3.54087837e-02f, -1.49890006e-01f, 4.75347489e-02f, 5.64205050e-02f, -3.40164900e-02f, 3.01155616e-02f, 2.03955267e-02f, 7.42143914e-02f, -4.65059616e-02f,
  3.21667679e-02f, 6.64391369e-02f, 9.48364884e-02f, 1.04732782e-01f, 4.70798686e-02f, 6.09509349e-02f, 5.51323071e-02f, -3.46334055e-02f, -1.31696790e-01f, 3.28335376e-03f,
  1.91956371e-01f, 6.48329332e-02f, -1.34588718e-01f, 2.33431999e-03f, 8.20579454e-02f, -2.47311946e-02f, 6.84677064e-02f, -1.52906440e-02f, -5.94551023e-03f, 6.82266429e-02f,
  -1.17220238e-01f, 9.69199929e-03f, -3.88463028e-02f, -9.57434103e-02f, -6.66935602e-03f, -1.01089366e-01f, -1.07650436e-01f, 7.09326118e-02f, -5.02862744e-02f, 5.25036454e-02f,
  -5.12069277e-02f, 1.10577848e-02f, -5.30301183e-02f, 3.81371030e-03f, -3.84667069e-02f, -8.49798024e-02f, -6.44613355e-02f, -4.92939912e-02f, -1.20379508e-01f, -5.57669066e-02f,
  3.21819559e-02f, -4.27779509e-03f, -8.80488232e-02f, -2.33263094e-02f, -8.58043730e-02f, -6.52009919e-02f, -9.52194333e-02f, -8.78825709e-02f, -7.19031543e-02f, 5.29204383e-02f,
  3.96459550e-02f, 8.06187764e-02f, 1.80998817e-02f, -7.19697550e-02f, 4.41032536e-02f, -5.44669181e-02f, 1.84255078e-01f, 8.96904469e-02f, 3.59128565e-02f, 6.18359670e-02f,
  -6.44415691e-02f, -1.03734687e-01f, -9.50854970e-04f, 5.40089607e-02f, -6.79594949e-02f, -8.83242637e-02f, 3.58722657e-02f, -5.57823703e-02f, 7.37133995e-02f, -6.49397746e-02f,
  2.91787758e-02f, -1.17034145e-01f, 4.41391580e-02f, 6.01858832e-02f, 7.96360150e-02f, 7.04866052e-02f, -5.81253041e-03f, -1.20485961e-01f, -5.11910692e-02f, -9.34379920e-02f,
  8.06234106e-02f, -9.43717267e-03f, 9.24477130e-02f, 8.35702792e-02f, 9.18535739e-02f, -1.81801915e-02f, 1.24003440e-02f, -8.04536045e-02f, 2.55054589e-02f, -2.48688459e-02f,
  -5.25440052e-02f, 1.14854518e-02f, -4.14224640e-02f, -5.75297326e-03f, -1.39507949e-01f, -9.17424262e-02f, -3.13516967e-02f, -8.47737491e-02f, -8.85473043e-02f, -1.17003076e-01f,
  -1.85873883e-03f, -1.48947770e-02f, -1.03917405e-01f, 1.79061182e-02f, 1.13406982e-02f, -3.74767371e-03f, -5.51943630e-02f, 6.65527508e-02f, -7.42109269e-02f, 6.93028560e-03f,
  -1.78472251e-01f, 9.83804017e-02f, -7.50619769e-02f, 9.58057716e-02f, 1.58472359e-03f, -2.30599195e-02f, 1.36834770e-01f, -1.28549552e-02f, 4.05447632e-02f, 9.70849069e-04f,
  6.68795705e-02f, -5.17663686e-03f, 3.17650363e-02f, 1.49101615e-01f, 1.12605497e-01f, 1.25709206e-01f, 1.89574465e-01f, 3.12416209e-03f, 7.18477555e-03f, 8.65195170e-02f,
  5.13170175e-02f, 3.12312543e-02f, -3.37175131e-02f, -3.86917032e-02f, 7.59187788e-02f, -2.62393449e-02f, 3.49152535e-02f, 1.21516837e-02f, 3.33723538e-02f, 5.83531000e-02f,
  -1.39518410e-01f, -5.87814599e-02f, -4.46559377e-02f, 6.77424893e-02f, -3.81978936e-02f, -4.77930605e-02f, -8.01498815e-02f, -9.98901390e-03f, -7.10514337e-02f, -5.92250302e-02f,
  3.58684957e-02f, -5.53948432e-02f, 7.16827363e-02f, -4.75759432e-02f, -6.12466186e-02f, -8.46685842e-02f, -8.37443769e-02f, 5.01793325e-02f, 1.40971001e-02f, -1.61630288e-02f,
  5.15452661e-02f, -5.76756150e-02f, -4.40823399e-02f, 1.60269160e-02f, -8.64720903e-03f, -1.99477486e-02f, -1.38447629e-02f, -3.31304595e-02f, -1.26262262e-01f, 1.36061804e-02f,
  -6.88178688e-02f, 2.65460722e-02f, -3.01636066e-02f, -6.03928082e-02f, 6.53142016e-03f, 1.31278232e-01f, -5.07722981e-02f, 6.23997822e-02f, 4.53466177e-02f, 1.25438375e-02f,
  -1.60682071e-02f, -9.83545110e-02f, -9.08750966e-02f, -1.43077582e-01f, 2.85463943e-03f, -1.33413775e-03f, 4.32264283e-02f, 7.80466245e-03f, -2.41733417e-02f, -4.44219001e-02f,
  -2.02355050e-02f, -1.15735773e-02f, 3.71201691e-04f, 9.60380286e-02f, -4.93621603e-02f, -8.90944228e-02f, -5.59766889e-02f, -9.04955417e-02f, -2.06518956e-02f, -7.11059570e-02f,
  1.03923984e-01f, -1.76117364e-02f, 4.29817997e-02f, 2.87154466e-02f, -1.56534128e-02f, -1.94669925e-02f, 4.84733609e-03f, -7.48247355e-02f, -6.40721526e-03f, 3.49993352e-03f,
  7.00355917e-02f, 6.01441376e-02f, 3.50365601e-02f, -5.76671399e-02f, 8.19777790e-03f, 5.86920157e-02f, 7.06805289e-02f, 8.68750457e-03f, 4.88256440e-02f, 1.91502329e-02f,
  -9.51834861e-03f, 5.98529726e-02f, -6.08829781e-02f, 6.41803741e-02f, 8.46971944e-03f, -6.55080676e-02f, -3.02742478e-02f, -3.85004319e-02f, 1.25171291e-02f, -6.80772960e-02f,
  1.64403811e-01f, -1.19397521e-01f, 8.85718241e-02f, 6.09328859e-02f, 5.65199889e-02f, -3.18618417e-02f, -6.75858408e-02f, 2.03514602e-02f, 1.16431296e-01f, 1.05922610e-01f,
  1.50341883e-01f, 1.91063479e-01f, 1.49989828e-01f, 1.02653906e-01f, 4.54795621e-02f, 2.27432474e-02f, 2.52122264e-02f, 2.28880458e-02f, 8.72743875e-02f, 3.42953242e-02f,
  4.36127149e-02f, 3.48234698e-02f, -6.76939711e-02f, 3.13585661e-02f, -7.43240491e-02f, 9.40049887e-02f, -1.89055540e-02f, -3.71426321e-03f, -1.00689471e-01f, -9.48007628e-02f,
  -4.61886777e-03f, 3.22329514e-02f, -3.46687576e-03f, 4.98559624e-02f, -8.14999864e-02f, -2.45941132e-02f, 9.09418985e-02f, 4.82144468e-02f, -3.71958166e-02f, 2.58645769e-02f,
  -2.04790011e-02f, -7.59823769e-02f, -8.83788336e-03f, -1.74825210e-02f, -1.30604252e-01f, -2.79730670e-02f, -1.87567994e-02f, 1.76409483e-02f, 6.39527440e-02f, 3.30485627e-02f,
  2.35666744e-02f, 2.23301537e-02f, 1.09291226e-02f, 7.86474571e-02f, 1.10865803e-02f, 1.81638878e-02f, 3.35412398e-02f, 9.79022682e-03f, 6.98795468e-02f, 4.76583019e-02f,
  -4.31071445e-02f, 8.90607294e-03f, 4.45502475e-02f, -1.79680332e-03f, 7.88188055e-02f, 7.52782077e-02f, -4.63501289e-02f, -7.29739591e-02f, 1.37742264e-02f, 5.30621447e-02f,
  1.90987941e-02f, -5.13936393e-02f, 1.18742980e-01f, 2.04622070e-03f, -1.44918431e-02f, 2.72279512e-02f, 1.88803189e-02f, 2.43385267e-02f, 3.03387977e-02f, -5.09225354e-02f,
  9.97165591e-02f, -5.10706790e-02f, 4.87770513e-02f, 2.33813561e-02f, 6.11112602e-02f, -2.04925947e-02f, 1.56237604e-02f, 7.88896345e-03f, 2.55773347e-02f, -7.83934295e-02f,
  -1.46994088e-02f, 1.01906702e-01f, -3.73869762e-02f, -1.91305820e-02f, 3.38117294e-02f, 6.95933700e-02f, -1.14083774e-02f, -6.72496781e-02f, -1.28798872e-01f, -1.10061439e-02f,
  -5.96424984e-03f, 1.45593705e-02f, 3.35894041e-02f, -4.67962250e-02f, -8.24249908e-02f, 6.70496300e-02f, 3.50925028e-02f, -6.89347908e-02f, 3.10581662e-02f, -3.16283889e-02f,
  -6.13024421e-02f, 8.94611776e-02f, 3.91652659e-02f, 7.69138634e-02f, 8.20962563e-02f, 1.22181997e-01f, 1.74868219e-02f, 2.58131623e-02f, 1.16879635e-01f, -1.23071773e-02f,
  -1.45838149e-02f, 5.49016185e-02f, 5.05155064e-02f, 1.12425415e-02f, 3.59691940e-02f, 3.96029931e-03f, -1.00769207e-01f, -1.59562856e-01f, 6.45987391e-02f, 4.01318930e-02f,
  -7.33424723e-02f, 1.02503253e-02f, 1.35741988e-03f, 5.72634116e-02f, -3.62028368e-03f, -8.68929550e-02f, -2.33109687e-02f, 1.07876830e-01f, -5.75116351e-02f, -9.87815112e-02f,
  6.29718155e-02f, 6.88062385e-02f, 9.57653373e-02f, -3.11771855e-02f, 4.07191142e-02f, 2.47838739e-02f, -4.33658529e-03f, 1.26119824e-02f, -4.95961010e-02f, 7.90015906e-02f,
  -2.44903229e-02f, -2.70753410e-02f, -4.12235707e-02f, 1.02353871e-01f, 1.02032147e-01f, -6.54955059e-02f, 2.33163545e-03f, 5.15472032e-02f, -2.39766967e-02f, -2.66416557e-02f,
  -4.33934554e-02f, -1.56082176e-02f, 1.87627934e-02f, -2.52737608e-02f, -5.91395088e-02f, -6.66836798e-02f, 9.24373232e-03f, -8.39883313e-02f, 4.84568737e-02f, -4.52027172e-02f,
  2.84254737e-02f, 7.80489221e-02f, -1.06939130e-01f, 3.89854237e-02f, -1.06871091e-01f, 3.24500762e-02f, 6.13872819e-02f, -3.49868350e-02f, -6.94450736e-02f, -9.23623443e-02f,
  2.80374195e-02f, -5.79770878e-02f, -4.32410724e-02f, 2.06352137e-02f, 6.39716685e-02f, -6.19922131e-02f, 8.25574845e-02f, -5.66944741e-02f, -9.05606151e-02f, 1.32934507e-02f,
  -7.22659454e-02f, 1.01660518e-02f, -5.51495813e-02f, -3.74831147e-02f, 4.50816415e-02f, -8.60440880e-02f, 3.19189802e-02f, 8.42558965e-02f, 4.68731746e-02f, 1.30946068e-02f,
  5.60249202e-02f, 2.76644528e-02f, -3.77687924e-02f, -8.67521092e-02f, 4.20063883e-02f, 5.74216479e-03f, -8.61569569e-02f, -3.94865759e-02f, 9.99416411e-03f, 6.06717505e-02f,
  -1.10651730e-02f, 3.46577615e-02f, 9.92681980e-02f, -2.35061273e-02f, 7.96545222e-02f, 2.46160384e-02f, -3.28245610e-02f, -1.67919993e-02f, 8.63800868e-02f, -3.49691398e-02f,
  -5.35007529e-02f, -8.75129923e-02f, -1.09549277e-02f, 4.03692015e-03f, -1.92213375e-02f, 9.37540666e-04f, -6.72655404e-02f, 3.17330435e-02f, -2.61966581e-03f, -2.21366007e-02f,
  6.76557571e-02f, -1.11512482e-01f, -1.07784100e-01f, -6.61962703e-02f, -6.10015392e-02f, 4.03274521e-02f, -9.58116874e-02f, 2.50260197e-02f, -8.69892240e-02f, -8.29683989e-02f,
  -2.75108129e-01f, -4.98724589e-03f, 1.33629451e-02f, -1.31783307e-01f, 1.76141020e-02f, 1.71657339e-01f, 1.90809831e-01f, 1.09207690e-01f, -1.16483653e-02f, 7.28707239e-02f,
  2.07397845e-02f, 2.54212525e-02f, -9.49378461e-02f, 1.10979378e-01f, 7.99842998e-02f, 7.96270184e-03f, -5.68228513e-02f, -1.15636453e-01f, 1.33864470e-02f, 9.04882103e-02f,
  -1.97190065e-02f, -2.09569007e-01f, -1.90220863e-01f, -1.10321909e-01f, -8.33548307e-02f, -1.87243551e-01f, -1.95641503e-01f, -1.59468070e-01f, -5.28726019e-02f, -2.24835858e-01f,
  -3.62349860e-02f, 4.23318706e-02f, 1.90409273e-01f, -2.67643481e-02f, -9.66807231e-02f, -1.84382964e-02f, -2.76700947e-02f, 4.56810580e-04f, -4.85147070e-03f, 4.36295792e-02f,
  -1.19535305e-01f, 8.40229616e-02f, -3.80188674e-02f, -2.06740946e-02f, 3.40389758e-02f, -3.96405272e-02f, -8.90023410e-02f, 2.35165767e-02f, 1.73710417e-02f, -6.21055113e-03f,
  -5.06683849e-02f, -1.00211091e-01f, 9.68677923e-03f, 1.31274096e-03f, 3.83702591e-02f, -2.07610801e-02f, 8.41426775e-02f, -7.20455647e-02f, -3.80639546e-02f, -5.39337769e-02f,
  1.01151146e-01f, 2.42740214e-02f, 3.83354053e-02f, -5.53907752e-02f, -4.07637283e-02f, 9.51212123e-02f, -4.26666401e-02f, 6.90072216e-03f, 8.61914083e-02f, -1.67951491e-02f,
  9.52739716e-02f, -5.32740019e-02f, -4.82205860e-02f, -2.80959904e-02f, -4.59210463e-02f, -8.69885087e-02f, -3.61806266e-02f, -1.00195006e-01f, -2.27767807e-02f, -4.11413424e-02f,
  7.46023208e-02f, 2.97710970e-02f, 3.31500098e-02f, -2.26045642e-02f, 2.84846779e-02f, 1.43955126e-02f, 2.18218863e-02f, 1.71384383e-02f, -1.06300883e-01f, -4.49707825e-03f,
  -1.97020113e-01f, 2.13697001e-01f, -4.92597520e-02f, 3.74288261e-02f, 6.87114596e-02f, -3.52360755e-02f, 1.23134302e-02f, -1.73226353e-02f, -4.39108275e-02f, -1.40251191e-02f,
  -2.72911172e-02f, -4.27173190e-02f, -1.14914950e-03f, 2.44965237e-02f, 1.94199812e-02f, 7.08797649e-02f, -8.31327289e-02f, 2.05861572e-02f, 8.10397565e-02f, 2.48246882e-02f,
  -1.03373108e-02f, -1.95684042e-02f, -3.34660672e-02f, 5.24091609e-02f, 9.35826227e-02f, -2.08222698e-02f, 4.00888659e-02f, -8.96161795e-02f, 3.00041847e-02f, -1.04143940e-01f,
  4.85136881e-02f, 3.08739003e-02f, 9.45763737e-02f, -1.04348384e-01f, -4.82407436e-02f, 1.49109599e-03f, 1.03939578e-01f, 4.33338694e-02f, -7.76394531e-02f, 6.00735284e-02f,
  7.70877004e-02f, -1.65055729e-02f, 9.46443751e-02f, -6.80101588e-02f, -2.90912297e-02f, -4.31571640e-02f, 1.08773252e-02f, -1.83940753e-02f, 3.43131907e-02f, -4.90621068e-02f,
  2.39592399e-02f, -9.43810716e-02f, -2.53447685e-02f, 6.17743134e-02f, -9.35103446e-02f, -1.13642905e-02f, 3.75893041e-02f, 2.93883458e-02f, 2.88141817e-02f, -5.15414961e-02f,
  -1.52612329e-02f, -3.89467701e-02f, 4.57986481e-02f, -2.09121834e-02f, 1.12829991e-02f, 6.14083037e-02f, -6.68485835e-02f, 2.47479361e-02f, -3.37548144e-02f, 5.80495372e-02f,
  8.56469967e-04f, 2.73273569e-02f, -3.32267722e-03f, 7.00362250e-02f, 5.32954000e-02f, -7.77460635e-02f, -9.32058096e-02f, -7.83082023e-02f, 6.85105994e-02f, -1.15650333e-02f,
  -5.09373620e-02f, 9.01520774e-02f, -2.70378985e-03f, 2.09494475e-02f, 1.48715042e-02f, 5.23669235e-02f, -3.64130028e-02f, 4.39762883e-02f, 5.93708307e-02f, 6.30942499e-03f,
  -6.78406050e-03f, 1.77534688e-02f, 1.58359632e-02f, -6.94199279e-02f, 8.69809091e-03f, 5.28434888e-02f, -8.69344512e-04f, -1.61102042e-02f, 4.55350168e-02f, 4.27064896e-02f,
  6.85593635e-02f, 1.86699145e-02f, 3.73506397e-02f, -4.98150922e-02f, 7.42188692e-02f, 1.60433899e-03f, 8.79184380e-02f, -1.11760749e-02f, 3.75613347e-02f, 1.09482966e-02f,
  3.46134603e-02f, 8.37303028e-02f, -7.90282339e-02f, 7.11632371e-02f, 7.33692497e-02f, -6.17972063e-03f, -4.84153107e-02f, -8.29230249e-02f, -8.78863558e-02f, 1.78592335e-02f,
  -2.43038428e-03f, 7.70062059e-02f, -5.42908423e-02f, -1.10622972e-01f, 5.66719994e-02f, -4.86108847e-03f, -6.50355294e-02f, 1.20375976e-02f, 1.96221881e-02f, 4.68417108e-02f,
  -3.96039709e-03f, -7.15246871e-02f, 9.44562554e-02f, -8.58837217e-02f, -2.39555705e-02f, 1.95111725e-02f, -1.04502931e-01f, -2.86090095e-02f, 2.18297495e-03f, -8.20950195e-02f,
  -7.65496939e-02f, -9.34445858e-02f, 7.02490807e-02f, -4.46084067e-02f, -3.21062431e-02f, -8.64640251e-02f, 5.44915050e-02f, -9.34860706e-02f, 1.05901351e-02f, -8.45627114e-02f,
  1.94790974e-01f, -1.16301924e-01f, -3.33206207e-02f, 1.08103603e-01f, 4.64602141e-03f, 6.85411319e-02f, 4.44555357e-02f, 5.86582832e-02f, 5.64047359e-02f, 9.25063156e-03f,
  -3.09483912e-02f, 1.01830244e-01f, -4.94226776e-02f, -1.31295538e-02f, 7.49724451e-03f, 5.63981303e-04f, -6.70849532e-02f, 1.05115555e-01f, 8.92276689e-02f, 7.94973299e-02f,
  5.29859401e-02f, 5.00669666e-02f, 2.13641971e-02f, -2.86043938e-02f, -3.02125048e-02f, 4.21844497e-02f, -5.80295436e-02f, -6.77372590e-02f, -9.17788371e-02f, -1.13870203e-01f,
  -1.78784475e-01f, -6.51047602e-02f, 9.72309485e-02f, 9.27270800e-02f, 2.77728569e-02f, -1.31561253e-02f, 4.48733121e-02f, 7.32632130e-02f, -3.31524573e-02f, -1.12946920e-01f,
  -1.01519540e-01f, 4.70528454e-02f, 5.51671758e-02f, -8.77797157e-02f, 7.33567998e-02f, -4.91679870e-02f, 2.71136258e-02f, -1.08576221e-02f, -3.61148529e-02f, -7.18460083e-02f,
  -1.15433030e-01f, -1.68587659e-02f, -2.03153510e-02f, -1.41265793e-02f, 4.69963364e-02f, 1.88852176e-02f, 6.94550527e-03f, 4.53263186e-02f, 6.29562885e-02f, 3.31085324e-02f,
  -4.13570553e-02f, 3.23636159e-02f, 3.52958106e-02f, 1.15625098e-01f, 3.12710926e-02f, 4.33493592e-02f, 6.63740188e-02f, 1.21201389e-02f, 7.38939121e-02f, -5.35197854e-02f,
  -3.50019000e-02f, 1.32642567e-01f, -4.92372774e-02f, -7.22929835e-02f, -7.11449087e-02f, 2.06594784e-02f, -9.23531204e-02f, 4.90713716e-02f, -7.41964504e-02f, 7.84916878e-02f,
  -3.18030342e-02f, 6.06442206e-02f, -1.88847259e-02f, -4.72002104e-03f, -7.55191818e-02f, -4.04647850e-02f, -6.89558834e-02f, -7.20085129e-02f, -4.34169732e-02f, 1.69397462e-02f,
  -7.29630366e-02f, 1.26158088e-01f, 1.42076509e-02f, 2.65238318e-03f, 4.11768183e-02f, -2.88290083e-02f, -1.27726886e-02f, -8.86940509e-02f, -5.53014725e-02f, -5.40681966e-02f,
  -6.30999058e-02f, 1.24198222e-03f, -7.98022822e-02f, -2.45015062e-02f, 9.26175416e-02f, 5.89705557e-02f, 2.27224920e-02f, -2.45574526e-02f, 3.85551527e-02f, -2.57411394e-02f,
  -6.12241961e-02f, 9.62915346e-02f, 1.21363662e-01f, 7.66643062e-02f, -2.54019871e-02f, 4.41406853e-02f, 3.05554122e-02f, 9.45181027e-03f, 8.45370516e-02f, -1.06058912e-02f,
  -4.47844528e-03f, -8.15126598e-02f, -1.08967401e-01f, 6.10682964e-02f, -7.84961283e-02f, -2.89794076e-02f, -7.20618069e-02f, -4.91185486e-02f, 3.65886651e-02f, 7.15098083e-02f,
  8.41106921e-02f, -4.48885411e-02f, -7.40022585e-02f, -9.78749767e-02f, -6.41462132e-02f, 5.19501884e-03f, -1.21518441e-01f, -8.02673772e-02f, -1.02627732e-01f, -2.04353705e-02f,
  6.57448396e-02f, 5.50976172e-02f, -2.77983602e-02f, -2.48827860e-02f, -2.92944591e-02f, -3.40289436e-02f, 2.22958531e-02f, 2.55038608e-02f, -1.03312872e-01f, -8.20242167e-02f,
  3.68897542e-02f, -6.72215968e-02f, 1.63105000e-02f, 1.01526612e-02f, 2.93144025e-02f, 2.19210032e-02f, 9.55810100e-02f, 6.65796325e-02f, 4.85744737e-02f, 3.07263788e-02f,
  5.56233414e-02f, 3.13566811e-02f, 4.38117199e-02f, 4.04468253e-02f, 7.93638825e-02f, 1.69508513e-02f, 1.56868994e-02f, 3.39684412e-02f, -3.60660627e-02f, 8.30655992e-02f,
  7.90894479e-02f, -3.39786755e-03f, 1.33245420e-02f, 2.77046207e-02f, 4.59274836e-02f, -7.42431507e-02f, -8.83997381e-02f, 4.83912639e-02f, -4.05462608e-02f, -6.88698664e-02f,
  -5.20437844e-02f, -1.02549329e-01f, 6.38233796e-02f, -6.66056797e-02f, 4.27205674e-03f, -5.78301735e-02f, 1.63697470e-02f, -4.77203652e-02f, -8.25041905e-02f, 4.04391848e-02f,
  -4.63585928e-02f, -1.16427820e-02f, 2.82902531e-02f, -7.17428848e-05f, -6.29932433e-02f, -3.80855054e-02f, -5.89840161e-03f, 1.21945851e-02f, 4.64786962e-02f, -1.49731738e-02f,
  3.48302126e-02f, 1.24407420e-02f, -6.67043552e-02f, 8.53243694e-02f, -1.09501399e-01f, -1.07042789e-01f, -2.38468107e-02f, -6.23423085e-02f, 4.39275913e-02f, 5.37797287e-02f,
  -8.07779841e-03f, -1.33503541e-01f, 6.82236478e-02f, -5.82392514e-02f, 2.71744877e-02f, 2.57131383e-02f, 1.49521381e-02f, 4.30178717e-02f, 1.24661505e-01f, -1.88071392e-02f,
  1.39858685e-02f, -3.29606757e-02f, 6.90331534e-02f, 4.38797884e-02f, 8.37535188e-02f, -5.36869243e-02f, 8.80705565e-02f, -2.49877782e-03f, 7.21067712e-02f, -2.35770736e-02f,
  1.01384141e-01f, -8.21276903e-02f, 1.95392407e-02f, 7.49665080e-03f, -4.50750850e-02f, -1.92806199e-02f, 5.24705313e-02f, 2.50596832e-02f, -5.69643043e-02f, 9.74618569e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  6.38870150e-02f, -4.52388227e-02f, -6.82624290e-03f, 7.69320056e-02f, -9.76489950e-03f, -3.53155620e-02f, 9.63258930e-03f, 5.16824946e-02f, 9.47755799e-02f, -9.86847002e-03f,
  1.08299144e-01f, 6.56151175e-02f, 1.41803473e-02f, 5.28712720e-02f, 1.18375960e-04f, 6.02980964e-02f, 1.14200182e-01f, -7.58394077e-02f, -4.92007025e-02f, -2.90746428e-02f,
  1.06501635e-02f, -1.63636971e-02f, -1.52731063e-02f, 1.93446374e-03f, -6.96980488e-03f, 1.44325094e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.48703950e-03f, 1.42875731e-01f, -7.22121745e-02f, 1.33674398e-01f, 4.11541387e-02f, 6.68096691e-02f, 3.21701057e-02f, -6.97551295e-02f, -9.18174833e-02f, 8.60308781e-02f,
  -1.09425012e-03f, 3.33340988e-02f, 5.76240644e-02f, 2.15430669e-02f, 6.19616285e-02f, 3.19629014e-02f, 1.13738418e-01f, 9.05393362e-02f, 6.37097880e-02f, -9.62458476e-02f,
  -7.45572820e-02f, 1.30576026e-02f, -9.79946107e-02f, -7.36790001e-02f, 1.00483954e-01f, -2.16172084e-01f, -4.73892651e-02f, -2.02592723e-02f, 2.22206507e-02f, -4.63571027e-03f,
  -2.83856653e-02f, -6.26367554e-02f, 1.41501026e-02f, 7.99574852e-02f, 3.98065373e-02f, -1.09845206e-01f, -2.53132768e-02f, -1.58719085e-02f, -2.25039065e-01f, 8.99603143e-02f,
  -4.48917970e-02f, -5.19149425e-03f, -1.08671822e-01f, 7.36279860e-02f, 1.28465265e-01f, 1.69158187e-02f, 1.03583381e-01f, -6.33720160e-02f, -1.32747084e-01f, -1.81858093e-02f,
  -4.91023436e-02f, -1.48566579e-02f, 3.99638526e-02f, 4.20472957e-02f, -1.12045333e-01f, 8.14881101e-02f, -7.23798722e-02f, 1.00997806e-01f, -7.69721791e-02f, 1.11552663e-01f,
  -1.18887790e-01f, 8.67180899e-02f, 4.84479293e-02f, 1.62406806e-02f, -7.82733485e-02f, 5.13499491e-02f, 1.64201744e-02f, 3.09640095e-02f, 1.24272900e-02f, -1.39554944e-02f,
  -2.78540868e-02f, -1.62049219e-01f, -1.98192522e-02f, -4.35607098e-02f, 5.21063805e-02f, -1.10644564e-01f, -1.52404187e-02f, -1.14416324e-01f, 2.91945506e-03f, -1.37854084e-01f,
  -1.20754264e-01f, -8.94180164e-02f, -6.13720156e-03f, -1.56179652e-01f, -2.21047565e-01f, 2.44912673e-02f, 5.56361191e-02f, -2.27443770e-01f, -6.61973059e-02f, -1.22106604e-01f,
  6.64912979e-04f, 1.94167376e-01f, -5.49049228e-02f, -1.05612166e-01f, 2.20213592e-01f, 1.92997336e-01f, -3.41409817e-03f, 1.60814106e-01f, 5.34845293e-02f, -1.51863649e-01f,
  -3.70319225e-02f, -4.37100567e-02f, -1.73906330e-02f, 1.46004602e-01f, 3.37770469e-02f, -1.12302177e-01f, 3.88407297e-02f, 5.74395023e-02f, 1.30780131e-01f, -9.72284153e-02f,
  4.72637527e-02f, -1.10749573e-01f, -1.15927607e-01f, -2.64495704e-02f, 6.06206283e-02f, -1.65615723e-01f, -1.28967715e-02f, -2.74828095e-02f, 4.64957859e-03f, 1.17918968e-01f,
  4.35915180e-02f, 5.83051369e-02f, -9.06177163e-02f, 2.93087494e-02f, 1.66330114e-01f, 9.50425044e-02f, -1.64455160e-01f, 1.20468169e-01f, -1.06971934e-01f, -7.96205625e-02f,
  1.06205322e-01f, 1.41201109e-01f, -4.73752618e-02f, -7.02068210e-02f, -1.19846709e-01f, 6.69495016e-02f, 2.12278543e-03f, -9.32168663e-02f, -1.53030474e-02f, -1.29790932e-01f,
  1.24713704e-02f, 1.20004579e-01f, 6.59855828e-02f, 5.51562384e-03f, 3.61226723e-02f, -5.06183468e-02f, -1.42774612e-01f, 2.17497021e-01f, 1.73210040e-01f, 7.00282166e-03f,
  9.01050791e-02f, 3.15525442e-01f, -2.31427681e-02f, 1.01430081e-01f, -1.37995794e-01f, 6.92408206e-03f, -2.40880758e-01f, 6.36549518e-02f, -4.48557138e-02f, -2.51459405e-02f,
  1.58442020e-01f, -1.02509722e-01f, -9.71833691e-02f, -8.52259174e-02f, -8.79569538e-03f, -1.51831200e-02f, 2.21682712e-02f, -1.37140244e-01f, -1.62232384e-01f, -8.67919181e-04f,
  -1.63200259e-01f, -5.38146198e-02f, 5.96623160e-02f, 1.39181122e-01f, -1.07517287e-01f, -9.73762497e-02f, -8.60897526e-02f, 2.66168192e-02f, 1.25431597e-01f, 2.06851602e-01f,
  -1.66291222e-02f, -1.45816043e-01f, -1.20880097e-01f, -1.39300942e-01f, -1.96454614e-01f, -1.06063699e-02f, -4.38672043e-02f, -1.38129070e-01f, -1.03226289e-01f, 6.10682033e-02f,
  -3.26861581e-03f, 8.56582299e-02f, -1.92922786e-01f, -1.49598703e-01f, -8.64046961e-02f, 1.46775112e-01f, -7.93843120e-02f, 3.22532579e-02f, 2.62610335e-02f, 3.22489887e-02f,
  -2.18455289e-02f, -1.43517733e-01f, 2.60358024e-02f, -7.58578703e-02f, 1.34085521e-01f, 1.96441248e-01f, 5.54649010e-02f, 1.58198938e-01f, 2.17683434e-01f, 6.87566698e-02f,
  -1.26632124e-01f, 1.04106955e-01f, 1.59745023e-01f, -1.43220484e-01f, 7.77322724e-02f, 3.69166106e-01f, -4.58471328e-02f, 2.46905163e-01f, 8.91857743e-02f, -3.18165845e-03f,
  -2.40993366e-01f, 3.81362773e-02f, -1.79025203e-01f, -2.69332498e-01f, 1.78123116e-01f, -2.52534389e-01f, 1.68727916e-02f, 1.56076401e-01f, -2.33443305e-01f, -1.24363020e-01f,
  2.09247470e-01f, -9.19948295e-02f, -1.08299345e-01f, 1.14652906e-02f, -7.12798685e-02f, -3.71686742e-02f, -1.26774326e-01f, -2.02726703e-02f, 7.39365071e-02f, -1.20792270e-01f,
  -2.57047154e-02f, 1.54408842e-01f, 2.11983800e-01f, 2.99819916e-01f, -3.32105625e-03f, -1.43075645e-01f, -8.19915757e-02f, -8.60310495e-02f, -1.85103014e-01f, -1.16004795e-01f,
  5.66216782e-02f, 2.13377737e-02f, -2.57815033e-01f, -2.16278341e-02f, 1.36837274e-01f, 6.44133687e-02f, 6.04963973e-02f, -7.44227320e-02f, 6.36800006e-02f, -3.78512219e-02f,
  1.32921591e-01f, 9.10036862e-02f, -9.18623284e-02f, -1.03474557e-01f, 1.17449947e-01f, 7.37097561e-02f, -1.00667521e-01f, 6.74728910e-03f, -8.22801664e-02f, -4.35610348e-03f,
  -6.43533394e-02f, 5.50294481e-03f, -1.22933395e-01f, -1.94995645e-02f, 5.61326034e-02f, -1.02310598e-01f, -3.35379839e-02f, -1.76228094e-03f, -2.39368975e-02f, -1.09189153e-01f,
  1.47855461e-01f, 1.42208651e-01f, 1.20767236e-01f, 1.14463434e-01f, 2.22151786e-01f, 6.63578212e-02f, 2.55713966e-02f, 3.31237584e-01f, 1.34642527e-01f, 2.37888888e-01f,
  1.76460430e-01f, -1.80344924e-01f, 5.66100217e-02f, 8.42550211e-03f, -1.37237176e-01f, -1.78638194e-02f, 6.24112450e-02f, -9.07998681e-02f, 9.74786095e-03f, 9.03929994e-02f,
  9.28450972e-02f, -6.56141043e-02f, -6.45011067e-02f, -7.18711317e-02f, -1.25941336e-01f, 8.71327221e-02f, -1.30339041e-01f, 7.44259730e-02f, -1.02597646e-01f, 1.76145539e-01f,
  -1.73064694e-01f, -8.07435736e-02f, 9.96316448e-02f, 6.13400154e-02f, 5.13036326e-02f, -3.96704823e-02f, 1.19907893e-01f, 9.87955108e-02f, -1.32243201e-01f, -8.49151462e-02f,
  -5.87320402e-02f, 1.10958482e-03f, 3.91020253e-02f, -6.21909276e-02f, 1.36227712e-01f, 1.32402733e-01f, 2.64831763e-02f, 1.13381982e-01f, -7.97110647e-02f, 1.15331545e-01f,
  4.82079610e-02f, -8.51413980e-02f, 9.70202964e-03f, -1.27790824e-01f, -9.96319056e-02f, -2.86390278e-02f, 6.50322363e-02f, -1.31955132e-01f, 3.04300748e-02f, 4.76340652e-02f,
  -7.40471110e-02f, -1.07120067e-01f, -1.17413253e-01f, -5.31349294e-02f, 7.55778998e-02f, 1.06867969e-01f, 1.25401452e-01f, 4.74612974e-03f, 7.59020373e-02f, 4.53150906e-02f,
  6.84782490e-02f, 1.57187149e-01f, 4.46364135e-02f, 1.19181879e-01f, 1.19483992e-01f, -3.08367163e-02f, -1.61500322e-03f, 1.20337149e-02f, 1.72940582e-01f, -3.42108272e-02f,
  1.08511649e-01f, -6.00843877e-02f, -3.77052128e-02f, 1.12539725e-02f, -5.54022007e-02f, -2.26844531e-02f, 1.70943346e-02f, -2.54244893e-03f, -3.54530551e-02f, 7.90370181e-02f,
  6.34748265e-02f, 2.14861464e-02f, -9.35954899e-02f, -1.68073121e-02f, -7.57402629e-02f, -3.64347287e-02f, 1.59694254e-01f, 2.16073114e-02f, -6.78666756e-02f, -8.25739726e-02f,
  1.59561299e-02f, -4.29046117e-02f, -5.33044077e-02f, -2.69238502e-02f, -8.69600102e-02f, -9.37455893e-02f, -1.54168218e-01f, 7.70835280e-02f, 6.03391156e-02f, 9.70496386e-02f,
  1.03534617e-01f, 1.10381410e-01f, -1.17865287e-01f, -6.64284229e-02f, 3.74115147e-02f, 5.89047335e-02f, -2.50581373e-02f, 9.20980647e-02f, -1.41015828e-01f, 8.66409242e-02f,
  4.74609472e-02f, -1.10637948e-01f, 4.66087535e-02f, -1.08024031e-01f, -1.72242656e-01f, -9.60664544e-03f, -1.15919508e-01f, -1.24603838e-01f, -3.20159160e-02f, -1.65675968e-01f,
  3.41562368e-02f, -1.80662945e-01f, -3.71014252e-02f, 1.61104258e-02f, 1.35908648e-01f, -2.22757623e-01f, -1.86038435e-01f, 1.86477955e-02f, -1.46554545e-01f, 1.14042863e-01f,
  1.58851338e-03f, -1.18808448e-01f, 9.94721353e-02f, -7.30185583e-02f, -6.97575212e-02f, -3.75100933e-02f, -1.47822052e-02f, 7.11053163e-02f, -9.53973010e-02f, 7.23205507e-02f,
  -9.00978670e-02f, -1.07098572e-01f, 6.77109212e-02f, 4.11133142e-03f, -9.18306932e-02f, -1.19161703e-01f, 4.25909236e-02f, 1.09772690e-01f, 5.50131267e-03f, -3.23447585e-02f,
  -1.55785590e-01f, -7.64516816e-02f, 4.09704968e-02f, 3.72104570e-02f, 2.85432842e-02f, -1.17869861e-02f, 1.41855339e-02f, 1.98974796e-02f, 3.28269042e-02f, -8.59991089e-02f,
  6.09073639e-02f, -1.17645912e-01f, -7.39156902e-02f, 9.04655978e-02f, -2.21973509e-02f, 3.35999802e-02f, 8.19443613e-02f, -3.93704735e-02f, -1.30198166e-01f, -5.44185862e-02f,
  -3.56183834e-02f, 4.40218858e-02f, -1.02079948e-02f, -5.51093966e-02f, 1.63146138e-01f, -5.34416996e-02f, 5.36639579e-02f, 7.80571178e-02f, -1.03422336e-01f, -1.24944754e-01f,
  6.73311576e-02f, 1.52901649e-01f, 4.90544252e-02f, 5.82039058e-02f, -1.19085975e-01f, -3.21050249e-02f, -8.44282135e-02f, 2.40739770e-02f, 3.52678299e-02f, -3.13477427e-01f,
  -1.13593303e-01f, -1.41917706e-01f, 4.63904403e-02f, 1.51687697e-01f, -3.26236486e-02f, -1.13382988e-01f, 6.76096976e-02f, 4.09795232e-02f, 3.99091877e-02f, 3.08907628e-02f,
  4.97500002e-02f, -2.57898532e-02f, -3.87000032e-02f, 9.33092162e-02f, -2.72496492e-02f, 3.99847552e-02f, 1.21567026e-01f, -4.67236601e-02f, -6.96500987e-02f, 1.01760603e-01f,
  5.99400625e-02f, -9.94904265e-02f, 1.39206097e-01f, 5.72906211e-02f, -1.52827455e-02f, -8.58974606e-02f, -5.93383275e-02f, 1.51318638e-02f, -1.81091234e-01f, -3.62708047e-02f,
  9.35053825e-02f, 1.03952132e-01f, -3.46607529e-02f, 8.12683105e-02f, -1.11507632e-01f, -1.83075905e-01f, 1.93897873e-01f, 2.49024540e-01f, -2.65394915e-02f, 6.75368980e-02f,
  -4.41454770e-03f, 3.61329168e-02f, -1.40719078e-02f, -9.17256624e-02f, 8.43484178e-02f, 2.67281942e-02f, 1.38911055e-02f, 8.11434239e-02f, -3.87327932e-02f, 5.27739003e-02f,
  -9.72402170e-02f, -7.63053149e-02f, 1.65849835e-01f, -7.16512948e-02f, -4.59941477e-03f, -4.26184833e-02f, 7.80075714e-02f, 1.72860190e-01f, 2.37001583e-01f, -5.59804924e-02f,
  1.54611424e-01f, 9.98057052e-02f, -7.65088797e-02f, 1.45107552e-01f, 2.60798559e-02f, 1.55616000e-01f, 5.48411421e-02f, -1.21783810e-02f, -2.31584758e-01f, 1.89240307e-01f,
  1.87261730e-01f, 5.11399545e-02f, 3.58165912e-02f, -1.47062555e-01f, 5.68592027e-02f, -1.23992428e-01f, -1.26089245e-01f, -1.34609565e-01f, -7.81200603e-02f, 4.89855558e-02f,
  5.43547682e-02f, 1.33129686e-01f, -1.39456078e-01f, 1.07952744e-01f, -1.52006298e-01f, 8.36631563e-03f, 1.66796640e-01f, 6.43992703e-03f, -5.58337476e-03f, -2.84174904e-02f,
  -4.13411558e-02f, 6.46483749e-02f, 6.09036535e-02f, -1.23643950e-01f, -1.61431074e-01f, 6.70040175e-02f, -8.08360707e-03f, -5.82836419e-02f, -1.15424074e-01f, -1.34565637e-01f,
  1.89971492e-01f, 2.02199116e-01f, -6.59638867e-02f, 7.29717761e-02f, 8.78626257e-02f, 7.56939948e-02f, -4.13751304e-02f, -9.58686173e-02f, -1.80272445e-01f, -1.01347435e-02f,
  3.77592929e-02f, -4.86878306e-03f, -1.15562484e-01f, -5.16947433e-02f, 7.60374516e-02f, -8.84255692e-02f, 1.39823988e-01f, -3.12116351e-02f, -1.07483730e-01f, -1.04514927e-01f,
  4.52292189e-02f, -7.37536279e-03f, 1.59197748e-01f, 7.05585107e-02f, 1.73673719e-01f, 1.18915597e-02f, -1.17578425e-01f, 2.62416750e-01f, 4.56625894e-02f, 1.96045011e-01f,
  -3.28840204e-02f, -1.05843849e-01f, 1.64589342e-02f, 1.78612918e-01f, 8.45886916e-02f, 5.67962825e-02f, 2.10869387e-02f, -5.68948984e-02f, 1.11126021e-01f, -4.02161777e-02f,
  2.51806132e-03f, -4.09683250e-02f, -1.08531006e-01f, -1.28138438e-02f, -9.55032036e-02f, 7.75081515e-02f, -3.10229789e-02f, -9.98948216e-02f, -1.54994339e-01f, -1.27031449e-02f,
  -9.84981135e-02f, 2.24212352e-02f, 2.13669464e-01f, 4.32687579e-03f, 1.29262768e-02f, -8.43731165e-02f, 2.27270916e-01f, 9.75537151e-02f, -5.97105511e-02f, 2.39398256e-02f,
  8.39160904e-02f, 4.16524969e-02f, -1.06317457e-02f, -8.83300900e-02f, 4.74414006e-02f, 1.70731455e-01f, -6.80494830e-02f, 1.19698063e-01f, -4.61691953e-02f, 2.93700080e-02f,
  7.62886330e-02f, 4.75730374e-02f, 1.31497264e-01f, 1.77278761e-02f, -1.30942956e-01f, 1.01097099e-01f, -2.27666833e-02f, 1.12876646e-01f, -5.18366881e-02f, -6.50993809e-02f,
  1.52069656e-02f, -2.05262825e-02f, -1.12136692e-01f, -9.77488756e-02f, 1.86687782e-02f, 1.78751945e-01f, 2.07340062e-01f, 7.61643797e-02f, 1.55427262e-01f, -5.12802750e-02f,
  8.87834206e-02f, 1.68629512e-01f, 1.68529488e-02f, 1.38521522e-01f, 2.42227111e-02f, 3.64372623e-03f, -4.59286086e-02f, 3.85610797e-02f, -3.05074956e-02f, 3.22214747e-03f,
  1.15378454e-01f, 4.07065600e-02f, -8.09663460e-02f, -1.64954543e-01f, -1.41779138e-02f, -9.72627327e-02f, 3.36476602e-02f, -2.32608635e-02f, 1.07852876e-01f, 5.96692190e-02f,
  -1.24100177e-02f, 1.12295277e-01f, -5.04822694e-02f, -2.23091934e-02f, 1.22376792e-01f, 1.14935357e-02f, 1.24859393e-01f, -8.26849863e-02f, -1.03151180e-01f, 1.37884513e-01f,
  1.04403906e-01f, -5.86740719e-03f, 3.78323905e-02f, 7.53596276e-02f, -1.33264542e-01f, -1.88046917e-02f, -2.31320448e-02f, -8.53487626e-02f, -8.99278671e-02f, 1.35766298e-01f,
  1.40800914e-02f, -8.01308900e-02f, 9.65092182e-02f, 5.15629575e-02f, 5.70703596e-02f, -9.98629928e-02f, -3.59720625e-02f, -6.22800812e-02f, 9.78097692e-03f, -1.05784275e-02f,
  -5.57131432e-02f, -6.44189343e-02f, 1.01852663e-01f, 2.98709422e-02f, -1.18397512e-01f, -4.83996458e-02f, -8.87260735e-02f, 9.35718790e-02f, 2.53007799e-01f, 1.32299304e-01f,
  -1.10663295e-01f, -1.96807727e-01f, -3.12828049e-02f, -4.08368297e-02f, 3.24605629e-02f, -2.17890337e-01f, -2.14639291e-01f, 1.38008952e-01f, -1.51758343e-02f, 9.44736749e-02f,
  -7.99565613e-02f, 5.30137867e-02f, 9.92007777e-02f, -1.29740402e-01f, 1.57624245e-01f, -1.01513095e-01f, 6.05693553e-03f, -2.70691812e-02f, -4.21136692e-02f, -2.16125965e-01f,
  1.05688177e-01f, 1.00941807e-01f, 1.85911506e-02f, -1.29419923e-01f, -9.55998003e-02f, 1.00589529e-01f, 1.19337678e-01f, 1.03901975e-01f, 1.61263973e-01f, -2.46083170e-01f,
  5.92094027e-02f, -1.28479928e-01f, -8.40545148e-02f, 1.11651488e-01f, -2.20760077e-01f, -8.98533836e-02f, -1.14646152e-01f, 1.13988057e-01f, 9.08204690e-02f, -1.70213692e-02f,
  -4.47673649e-02f, 6.42871931e-02f, -3.03030927e-02f, -3.16210806e-01f, -5.66721670e-02f, -8.19293433e-04f, 1.29658007e-03f, -3.27345468e-02f, 8.06929097e-02f, 1.00074440e-01f,
  -9.45558995e-02f, 6.69850186e-02f, 8.03809613e-02f, 2.80790199e-02f, -9.27340314e-02f, 4.45725657e-02f, 5.02381008e-03f, -1.39749289e-01f, 7.16668963e-02f, 8.78057778e-02f,
  5.93461841e-02f, -1.28730267e-01f, -1.57479018e-01f, 5.42573258e-02f, -1.49131939e-01f, 2.08263829e-01f, -8.97184387e-02f, -1.05667770e-01f, -4.77295481e-02f, 7.66835213e-02f,
  1.88261792e-02f, -5.58744185e-02f, -7.26769492e-02f, -1.11997854e-02f, 2.36649841e-01f, 3.08363028e-02f, -2.19820485e-01f, -6.35870770e-02f, -8.26356485e-02f, -6.35866076e-02f,
  -4.31322493e-02f, 5.93101569e-02f, 2.55628163e-03f, 3.15846764e-02f, -8.85977373e-02f, -1.10775076e-01f, -1.52758911e-01f, -7.74927810e-02f, 1.09756455e-01f, -9.63590890e-02f,
  3.49819921e-02f, -1.89562328e-02f, -1.45923242e-01f, -1.76154189e-02f, -2.49411985e-02f, -3.35896723e-02f, -1.14525013e-01f, 7.19376467e-03f, -3.14194970e-02f, 3.08128223e-02f,
  -6.86769038e-02f, 6.32661358e-02f, -1.34257138e-01f, -2.87838858e-02f, 3.70905325e-02f, -6.92747086e-02f, -2.89103016e-02f, 1.78389996e-01f, 6.67641917e-03f, 3.57955545e-02f,
  4.06013466e-02f, -5.51180877e-02f, -5.06608412e-02f, 3.96462455e-02f, 5.04466742e-02f, 1.01767890e-01f, 1.01845771e-01f, -7.71370158e-02f, 1.03894867e-01f, 4.84990254e-02f,
  2.78114481e-03f, 1.91874936e-01f, 1.94135100e-01f, 4.83942364e-04f, -4.17749844e-02f, 8.76938086e-03f, -3.43159912e-03f, 1.64451033e-01f, 2.99770441e-02f, -1.40241608e-01f,
  1.53534591e-01f, 1.23641871e-01f, -1.60758078e-01f, 9.12355781e-02f, 1.22877546e-01f, -1.54365480e-01f, 7.55586326e-02f, -1.58133414e-02f, -2.08903611e-01f, 2.06347510e-01f,
  -7.05341771e-02f, 2.69883517e-02f, 7.99416900e-02f, 1.10348329e-01f, 3.92374098e-02f, -6.33698776e-02f, -2.75501348e-02f, -1.76135618e-02f, 3.53890434e-02f, 2.73173302e-02f,
  7.30271116e-02f, -2.98698135e-02f, 6.63141385e-02f, 9.42009985e-02f, -1.56590506e-01f, 2.72986814e-02f, 2.51554530e-02f, -1.15063779e-01f, -1.27320141e-01f, -1.17717266e-01f,
  1.16352580e-01f, 4.45803925e-02f, 1.39896065e-01f, -5.05308658e-02f, 2.63080117e-03f, -1.31868526e-01f, 8.05339590e-02f, -5.35371341e-03f, -1.03870258e-01f, -3.22865695e-02f,
  -8.37864056e-02f, 2.77852714e-02f, 2.28476245e-02f, -1.18618477e-02f, 9.69203264e-02f, -1.44254118e-01f, -9.05923918e-02f, -6.23264238e-02f, 1.73681051e-01f, 1.02033831e-01f,
  5.67134805e-02f, 6.57312274e-02f, 1.26598224e-01f, -4.63307127e-02f, -8.31120536e-02f, 2.50180997e-02f, 1.40731990e-01f, 1.17559150e-01f, 1.07505776e-01f, 1.33773223e-01f,
  3.55960578e-02f, -8.03195909e-02f, -6.13013692e-02f, -1.58769608e-01f, -6.88370988e-02f, -1.12683155e-01f, -5.99847473e-02f, -7.53885508e-02f, -1.20612554e-01f, -1.97807506e-01f,
  -1.92210004e-01f, 1.16315566e-01f, 9.35649150e-04f, -5.07850461e-02f, -1.49938772e-02f, -1.11396722e-01f, -3.85824312e-03f, 1.31872922e-01f, 9.69108492e-02f, 9.29980427e-02f,
  -2.63235364e-02f, 1.68198213e-01f, -6.78643435e-02f, -3.81697267e-02f, 9.16332379e-02f, 3.13444063e-02f, 1.00626670e-01f, -2.65472569e-02f, -2.81728301e-02f, -1.30708560e-01f,
  8.13211575e-02f, -1.76741481e-01f, -1.69063658e-01f, -8.91061351e-02f, -8.15755799e-02f, -1.00363448e-01f, -1.05315030e-01f, 1.22359902e-01f, -6.91972300e-02f, 1.14307843e-01f,
  3.24416868e-02f, 4.03280929e-02f, -8.68497565e-02f, -3.97036634e-02f, -7.02601746e-02f, 6.76632673e-02f, 7.38042742e-02f, 4.58544213e-03f, 6.39367402e-02f, 2.95534115e-02f,
  5.83935119e-02f, -5.08743823e-02f, -4.25671823e-02f, 6.26146197e-02f, 3.67067009e-02f, -1.07661106e-01f, -1.06399223e-01f, -1.17354058e-01f, 8.80024657e-02f, 6.40872493e-02f,
  1.66627154e-01f, -4.81644794e-02f, -3.77212279e-02f, -4.93422188e-02f, -2.07371786e-02f, -1.39801025e-01f, -6.11668860e-04f, 5.10433540e-02f, 1.07577436e-01f, 1.98094130e-01f,
  -2.12132782e-02f, 3.98993418e-02f, -9.95195583e-02f, -2.47572339e-03f, 1.13073207e-01f, -4.02403399e-02f, -1.31508246e-01f, 6.98031634e-02f, 5.45591004e-02f, -1.01084579e-02f,
  1.20684162e-01f, 2.02781428e-03f, -8.02995935e-02f, 1.18399262e-01f, -5.94105273e-02f, -1.56022916e-02f, -1.47155933e-02f, 1.33177802e-01f, 5.15148342e-02f, 3.57971265e-04f,
  6.01582378e-02f, -1.51075304e-01f, -6.95914105e-02f, -5.07220104e-02f, 6.76473007e-02f, 3.35831046e-02f, -2.89607625e-02f, 1.35982363e-02f, 8.98422226e-02f, 6.35599941e-02f,
  3.39144804e-02f, 9.38016921e-02f, 1.19542532e-01f, 9.64645147e-02f, -1.14677288e-01f, -9.68007743e-02f, -1.61399812e-01f, -1.27096355e-01f, 6.40683323e-02f, 1.96114764e-01f,
  -1.70667022e-01f, -2.92133037e-02f, 4.89226803e-02f, -1.15110853e-03f, 1.82993654e-02f, -1.78250045e-01f, 8.60393271e-02f, -1.28612742e-01f, -1.79149229e-02f, 1.85478367e-02f,
  -7.46898204e-02f, -1.90946952e-01f, 6.66028215e-03f, 3.96045856e-02f, 1.72781944e-01f, -1.86313346e-01f, -1.17415696e-01f, -4.71227951e-02f, 5.51925078e-02f, 1.64186493e-01f,
  2.47476369e-01f, -1.41881451e-01f, 1.16925277e-01f, 4.19025719e-02f, 2.29400266e-02f, 1.91847965e-01f, -5.50252721e-02f, -9.19541791e-02f, 1.71702132e-01f, -6.44902810e-02f,
  -2.82089710e-02f, 1.58840775e-01f, 1.76687449e-01f, -8.35909024e-02f, 8.61727148e-02f, 6.14791475e-02f, -1.28566772e-02f, -2.70828139e-02f, -4.74677011e-02f, -6.55904189e-02f,
  -1.15655139e-01f, 1.36028707e-01f, 7.00754672e-02f, 4.89723869e-02f, -7.62372091e-02f, 7.39891678e-02f, -1.76598430e-01f, -2.78336331e-02f, 1.78046618e-02f, -9.26004127e-02f,
  1.05225015e-02f, -1.51515543e-01f, 9.50820148e-02f, 4.54418398e-02f, 6.28495514e-02f, 1.13571502e-01f, -6.57898486e-02f, -1.60351738e-01f, 1.82967082e-01f, -4.92821746e-02f,
  4.10953388e-02f, 2.52062947e-01f, -1.29731642e-02f, -2.40539610e-01f, 1.23064265e-01f, -3.14772837e-02f, -1.18452080e-01f, 1.33785561e-01f, 1.97254382e-02f, -5.63381538e-02f,
  -1.71818748e-01f, 1.46308616e-01f, 9.40013975e-02f, 1.01678550e-01f, 7.28990138e-02f, 1.82280436e-01f, -1.13571147e-02f, -1.77716643e-01f, -8.78294334e-02f, -1.97035335e-02f,
  1.14018470e-01f, -5.95093630e-02f, -3.38007510e-02f, -1.47892088e-01f, -1.62520707e-01f, 1.50810853e-01f, -1.29083753e-01f, -9.06544104e-02f, 1.22275807e-01f, -3.56171802e-02f,
  -1.81154206e-01f, 6.28422201e-02f, -5.95176145e-02f, -7.44668022e-02f, 2.80732512e-01f, -2.17246473e-01f, -8.62873122e-02f, 1.25512481e-01f, -8.15570448e-03f, -7.14741498e-02f,
  -1.66976929e-01f, 8.72700363e-02f, -7.39760771e-02f, -1.60262417e-02f, 7.75812492e-02f, 4.32066247e-02f, -1.49587780e-01f, 6.56983852e-02f, -2.82855015e-02f, 1.58374593e-01f,
  1.99116334e-01f, 7.98566863e-02f, 2.28794422e-02f, 5.13682924e-02f, 1.40235186e-01f, 2.02963546e-01f, -1.73098058e-01f, 1.36108875e-01f, -2.15021461e-01f, -8.37359503e-02f,
  4.62296559e-03f, 8.13076794e-02f, -6.05924316e-02f, 9.82154682e-02f, 8.74566510e-02f, -2.28493959e-01f, 2.92590968e-02f, -3.08558140e-02f, 1.15093395e-01f, 5.40597364e-02f,
  -6.38435781e-02f, 1.73011795e-01f, -1.02277614e-01f, -5.38326539e-02f, -1.63812354e-01f, -1.86887644e-02f, -3.62228267e-02f, -1.34757936e-01f, -2.13220209e-01f, -1.44385368e-01f,
  2.83245984e-02f, -6.36972412e-02f, -2.00344533e-01f, 8.85848105e-02f, 3.40153426e-02f, -7.83975050e-02f, 2.52013989e-02f, 1.92375824e-01f, -3.38301510e-02f, 1.45743832e-01f,
  9.45770964e-02f, -1.20796174e-01f, 2.02170148e-01f, 2.42213175e-01f, 1.62273869e-01f, 2.10619643e-01f, 1.40839413e-01f, -1.01764135e-01f, 3.76112461e-02f, 8.69113114e-03f,
  1.56313986e-01f, 1.40736187e-02f, -1.59568235e-01f, -9.18098614e-02f, -7.20609352e-02f, 1.05760783e-01f, 5.04327146e-03f, -7.55797476e-02f, -6.50140631e-04f, -1.31845549e-01f,
  6.25431985e-02f, 9.93581563e-02f, -3.58550958e-02f, -3.31007540e-02f, 4.97702435e-02f, 3.09433066e-03f, -3.14575695e-02f, -5.32612018e-02f, 1.34492340e-02f, 2.39818208e-02f,
  -6.15826994e-02f, -2.13293992e-02f, 2.31515750e-01f, -1.11723103e-01f, -9.89029258e-02f, 2.03290597e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  8.08822215e-02f, -9.29156467e-02f, 6.98106503e-03f, -6.05020225e-02f, -1.29328817e-01f, 1.72696505e-02f, 7.26432428e-02f, 7.91298598e-02f, 1.02551818e-01f, 4.88639697e-02f,
  4.33326550e-02f, 9.64732245e-02f, 3.50303762e-02f, -3.29642929e-02f, 1.14344448e-01f, -7.15071410e-02f, -1.18490905e-01f, 2.89163319e-04f, -6.63985386e-02f, -9.50858518e-02f,
  8.72877389e-02f, 9.46233645e-02f, -4.91038896e-03f, 2.09919270e-02f, 3.37626692e-03f, -5.86379431e-02f, 6.75775930e-02f, -6.43006116e-02f, -1.26553252e-01f, 1.03228830e-01f,
  4.24794741e-02f, 1.41384929e-01f, -4.77538295e-02f, -1.22523591e-01f, 4.85701151e-02f, -3.38187441e-02f, 4.74992245e-02f, 8.14893842e-02f, -8.83253217e-02f, 1.36181116e-01f,
  9.02165398e-02f, 9.12160352e-02f, 1.02200387e-02f, -1.06415436e-01f, -9.23266709e-02f, -1.38874957e-02f, -1.03376750e-02f, 1.07151106e-01f, 9.12348479e-02f, 1.27324417e-01f,
  -4.40024696e-02f, -1.25455156e-01f, -1.17703199e-01f, 1.23163454e-01f, 1.52357109e-02f, -5.50768264e-02f, 9.07076225e-02f, -3.38842301e-03f, -1.17389396e-01f, -9.73461345e-02f,
  -7.34470710e-02f, 4.94270027e-02f, 6.70176446e-02f, 6.72640875e-02f, -8.53854492e-02f, -1.21346362e-01f, 1.36982054e-01f, -8.90154094e-02f, 6.66849464e-02f, -7.81442299e-02f,
  5.78302369e-02f, 3.65115516e-02f, 2.51353253e-03f, 1.17907070e-01f, 5.78586943e-02f, 4.54052538e-02f, -2.30760165e-02f, 1.04592554e-01f, 7.58872852e-02f, -2.33235937e-02f,
  -1.22843524e-02f, -2.86176391e-02f, 4.96376231e-02f, -5.08803464e-02f, -6.63904846e-02f, -4.25843075e-02f, 3.17366719e-02f, 4.25902009e-02f, -7.87386969e-02f, 9.37442705e-02f,
  -2.44367085e-02f, -2.89575309e-02f, -1.47531718e-01f, 6.33905306e-02f, -6.91288784e-02f, 2.11400501e-02f, -2.19551288e-02f, -1.08092591e-01f, -4.02348228e-02f, -1.22298926e-01f,
  -3.56979761e-03f, 4.10771444e-02f, -6.85037374e-02f, 9.36827883e-02f, -5.77895679e-02f, 9.47502255e-02f, 8.84107649e-02f, -6.07344098e-02f, 1.05144575e-01f, 1.56548753e-01f,
  -3.89412232e-03f, -1.05868742e-01f, -6.30341321e-02f, 1.00073807e-01f, 1.36937588e-01f, -3.73238213e-02f, 7.71609694e-02f, 1.08043104e-02f, 1.72352493e-02f, 1.25039846e-01f,
  -4.44014892e-02f, -8.91802926e-03f, -6.94249347e-02f, -1.94934185e-03f, 5.18559711e-03f, 1.26176178e-01f, -5.02039045e-02f, -6.56340495e-02f, -5.77697083e-02f, -1.61924027e-02f,
  9.68222767e-02f, 1.44949206e-03f, -7.77345300e-02f, -6.56353459e-02f, 1.17363609e-01f, 3.82770412e-02f, 6.10551201e-02f, 1.32510543e-01f, 7.86145777e-02f, 1.40315548e-01f,
  8.34288821e-02f, -6.35510236e-02f, 7.63402227e-03f, 1.55758694e-01f, 1.17887944e-01f, -5.64452214e-03f, 1.51811719e-01f, 2.76821069e-02f, 8.77875462e-02f, 1.33683989e-02f,
  -1.32338256e-01f, -7.98314586e-02f, 6.08568527e-02f, -4.74330559e-02f, 1.45558149e-01f, -1.62441179e-01f, 6.01116121e-02f, 1.08273037e-01f, -1.85225144e-01f, -9.95222256e-02f,
  -1.59479365e-01f, -1.04901090e-01f, -2.83447709e-02f, 1.14736166e-02f, -2.14108154e-02f, -3.49064097e-02f, -1.14215463e-01f, 7.25924820e-02f, 1.09549016e-01f, 1.16244756e-01f,
  6.23286366e-02f, 1.15660287e-01f, -4.67056818e-02f, 1.10730447e-01f, -9.00977254e-02f, 7.41350204e-02f, -5.47038671e-03f, -1.13270590e-02f, 2.78607979e-02f, 1.09767010e-02f,
  -1.10848740e-01f, -5.49384877e-02f, -1.41686857e-01f, -1.31274546e-02f, -8.24516490e-02f, -1.12983227e-01f, 1.36657819e-01f, -5.32464162e-02f, -1.22039638e-01f, -1.73255298e-02f,
  3.39603908e-02f, 3.20728309e-02f, -7.80048072e-02f, 2.13655573e-03f, -7.20214173e-02f, -3.53906676e-02f, 3.98915785e-04f, 1.70650836e-02f, -2.01549847e-02f, -7.90236592e-02f,
  -6.77964464e-02f, 4.30358760e-02f, -3.46024856e-02f, -6.51515927e-03f, 1.16995303e-02f, 8.62345248e-02f, -6.87513687e-03f, 2.38620657e-02f, 1.23476923e-01f, 6.74827397e-02f,
  -7.60710537e-02f, 1.66683607e-02f, -3.20224464e-02f, 4.17874791e-02f, -9.74652767e-02f, 3.43708768e-02f, -8.24230313e-02f, 2.61206795e-02f, 6.36341795e-02f, -1.19485535e-01f,
  -1.17843874e-01f, 1.79639179e-02f, 7.58064017e-02f, -1.25345021e-01f, -4.19005752e-02f, -2.21198276e-02f, 2.66022291e-02f, 2.55655739e-02f, 7.92811066e-02f, -1.06956027e-01f,
  -8.45495686e-02f, -1.21596426e-01f, -1.03933014e-01f, -9.94034559e-02f, 1.06450349e-01f, 1.73045136e-02f, 1.15576223e-01f, 6.06922284e-02f, -4.69893068e-02f, -9.86686647e-02f,
  1.31617308e-01f, -8.51322256e-04f, 8.17014873e-02f, 1.20017387e-01f, 3.35789882e-02f, 2.91340221e-02f, 2.49231383e-02f, -1.94034632e-03f, 1.18611038e-01f, 3.43655981e-02f,
  1.04706667e-01f, -1.05204985e-01f, -1.01926059e-01f, 6.41610771e-02f, -3.32224295e-02f, -4.30861786e-02f, 8.26376453e-02f, 1.09214403e-01f, -1.14277164e-02f, 9.13325548e-02f,
  -4.30850722e-02f, -1.73669048e-02f, -5.67655498e-03f, -2.22356282e-02f, 3.05579100e-02f, 6.87972084e-02f, 5.63632473e-02f, 7.48434896e-03f, 4.36753072e-02f, 1.13775842e-01f,
  4.89026979e-02f, 1.38555735e-01f, 1.51197493e-01f, -6.14253581e-02f, -2.85385605e-02f, 1.08691245e-01f, 4.64008972e-02f, -8.20009112e-02f, -9.34937522e-02f, 1.20344544e-02f,
  -5.65083474e-02f, 2.14366708e-02f, 9.90035236e-02f, -5.76272570e-02f, 1.10940477e-02f, -1.31159099e-02f, -1.41597152e-01f, 1.26796188e-02f, 4.74899970e-02f, -1.20722530e-02f,
  8.82766545e-02f, -6.28532320e-02f, 2.00697165e-02f, 1.14179410e-01f, 4.96768877e-02f, -2.17847228e-02f, 1.06821314e-01f, -3.12235318e-02f, -8.00463371e-03f, 7.91660696e-02f,
  -8.64293799e-02f, 8.89226347e-02f, 1.34575188e-01f, 5.26677892e-02f, 5.36109507e-03f, 1.15983047e-01f, -3.09176743e-02f, -1.05984248e-01f, -1.24520632e-02f, 3.24786194e-02f,
  -3.04167606e-02f, 9.70514342e-02f, -6.15206212e-02f, -2.92565189e-02f, -1.41911939e-01f, -1.10542849e-01f, -2.54350286e-02f, 4.92745228e-02f, 1.03075178e-02f, -8.72756988e-02f,
  -9.01806355e-02f, 3.51464190e-02f, 5.46343923e-02f, -3.77471582e-03f, -6.47093505e-02f, 6.23728782e-02f, -1.29048392e-01f, 6.36364222e-02f, -3.73921953e-02f, 1.27031535e-01f,
  1.67630315e-02f, 1.22085348e-01f, -1.74773559e-02f, -4.03283462e-02f, 4.55124583e-03f, -6.79662377e-02f, 1.43086851e-01f, -1.35081783e-01f, -9.45456997e-02f, 2.18903814e-02f,
  1.20971367e-01f, -1.44889653e-01f, 5.36525622e-03f, 9.95363370e-02f, 5.12153096e-02f, 3.11573390e-02f, 9.63186612e-04f, 5.53882457e-02f, 9.81900319e-02f, 1.27404761e-02f,
  1.61775481e-02f, -2.69335676e-02f, 9.52452868e-02f, -1.00608487e-02f, -1.22973263e-01f, -3.39838602e-02f, 1.25340611e-01f, 1.09169818e-01f, 1.26816079e-01f, -2.11210065e-02f,
  -2.90890839e-02f, -1.06393330e-01f, 1.04933925e-01f, 1.20762721e-01f, -9.93525982e-02f, 1.29297122e-01f, -3.16223726e-02f, -6.53312653e-02f, 3.94996479e-02f, 1.10955402e-01f,
  1.16419703e-01f, -7.07768574e-02f, 6.86779320e-02f, -9.49517488e-02f, -1.08856507e-01f, 1.57351390e-01f, 7.36402953e-03f, 9.81637686e-02f, 1.92433178e-01f, -6.54462166e-03f,
  -1.11869648e-01f, 1.09562658e-01f, 1.82034492e-01f, -1.56616911e-01f, -7.11687207e-02f, 1.91575244e-01f, 1.15125217e-01f, 3.22763547e-02f, 1.76034346e-01f, 3.57152641e-01f,
  -8.20470229e-02f, 1.00549035e-01f, 2.78917998e-02f, 3.27795334e-02f, 2.01464444e-01f, 7.51333088e-02f, 2.61306792e-01f, 1.89526528e-01f, 2.13600338e-01f, -2.43342835e-02f,
  8.39567930e-02f, 1.21488847e-01f, 1.33789912e-01f, -9.22969952e-02f, 1.05547920e-01f, -1.34484723e-01f, 4.40357998e-02f, -2.53403615e-02f, 1.76602393e-01f, 1.28374770e-01f,
  8.16076249e-02f, -2.06019878e-01f, -3.02824751e-02f, 1.77469626e-01f, -1.74011320e-01f, -2.25884661e-01f, -9.88519341e-02f, -3.20281181e-03f, -4.30301912e-02f, 1.31817684e-01f,
  -2.27193981e-01f, 1.02633268e-01f, 1.51405081e-01f, -9.98524874e-02f, -5.27172126e-02f, -7.03484416e-02f, 1.45069689e-01f, -6.84969574e-02f, -1.19832121e-01f, -5.35210818e-02f,
  4.66079712e-02f, 1.17685288e-01f, 1.34571448e-01f, 1.48765240e-02f, 7.09413663e-02f, -5.67007177e-02f, -5.52577956e-04f, 5.71439192e-02f, -2.52087452e-02f, -1.17604367e-01f,
  7.96158612e-02f, -1.87508583e-01f, -6.41256943e-03f, 9.12229270e-02f, -9.02060140e-03f, 1.08132213e-01f, 4.85278219e-02f, 9.00596753e-02f, -9.73678157e-02f, -9.20660272e-02f,
  -1.87024921e-02f, -4.67226729e-02f, 6.88160257e-03f, 7.02787340e-02f, 9.29358304e-02f, -5.89897633e-02f, 9.26490650e-02f, -1.33057266e-01f, -1.76403113e-02f, 1.27946392e-01f,
  1.56619653e-01f, -4.49862368e-02f, 1.10204183e-01f, 8.40789229e-02f, 1.53306723e-01f, 9.85596031e-02f, 3.77758741e-02f, 1.30608141e-01f, 3.03527564e-02f, -1.26740932e-02f,
  -8.84577036e-02f, 1.47478446e-01f, 5.68611315e-03f, 1.64980486e-01f, 9.88468062e-03f, -1.81342527e-01f, -4.79742419e-03f, 5.34902886e-02f, -2.55534295e-02f, -3.51999663e-02f,
  6.16448037e-02f, -1.79413065e-01f, 1.48327902e-01f, 2.48311143e-02f, -9.81539786e-02f, -2.99120918e-02f, 2.17626005e-01f, -9.66508165e-02f, -5.57468608e-02f, -5.94757944e-02f,
  3.98552231e-03f, 1.30644664e-01f, -1.62294377e-02f, 6.35351539e-02f, 2.81372648e-02f, 1.15824714e-01f, 3.34481373e-02f, -1.97045617e-02f, 1.34339049e-01f, 1.84909239e-01f,
  2.92739980e-02f, -5.84913045e-02f, 1.79573908e-01f, -3.36286053e-02f, 5.34599684e-02f, 8.13128334e-03f, -5.40657938e-02f, -7.65688419e-02f, 9.89768356e-02f, -1.40571728e-01f,
  6.65246397e-02f, 1.13734767e-01f, 1.39059424e-01f, 9.40779895e-02f, 8.62332657e-02f, -3.65120694e-02f, -3.69586656e-03f, -1.55158103e-01f, 2.23290194e-02f, 1.27909854e-01f,
  -6.82374462e-02f, 1.35750785e-01f, 2.67296210e-02f, 1.10280886e-02f, 6.24861866e-02f, 6.13175482e-02f, -7.71712363e-02f, 1.82852782e-02f, 7.50069767e-02f, -7.58727863e-02f,
  2.40829401e-02f, 1.03748359e-01f, 2.24112552e-02f, 1.11429028e-01f, 1.25593215e-01f, 4.73115705e-02f, -7.18465820e-02f, -1.36412159e-01f, -1.84239790e-01f, 1.23967446e-01f,
  3.54388938e-03f, 4.73403037e-02f, -9.20986384e-02f, 5.19971438e-02f, -1.17478468e-01f, -1.29868567e-01f, 1.67463557e-03f, -9.37323421e-02f, 1.06876604e-01f, 3.84820700e-02f,
  3.12824883e-02f, 1.39591664e-01f, -6.19247966e-02f, 8.58591348e-02f, -1.16633974e-01f, 4.18083277e-03f, 1.14508264e-01f, 1.63079083e-01f, 1.97782852e-02f, -1.20607868e-01f,
  -1.19041987e-01f, 9.82029736e-02f, 7.28096515e-02f, -5.04717715e-02f, -6.75503388e-02f, -1.73002835e-02f, 8.92731994e-02f, 9.19151008e-02f, -1.45226568e-01f, -8.57265517e-02f,
  1.04441509e-01f, -1.18827567e-01f, -9.72466469e-02f, -9.37905610e-02f, 8.44245180e-02f, -4.70177047e-02f, 1.49745613e-01f, -4.28343266e-02f, 5.41654602e-02f, -2.54751146e-02f,
  1.77764446e-01f, 7.09519088e-02f, 5.60350344e-02f, -5.26188388e-02f, 9.88052040e-02f, 1.08108155e-01f, 1.45036221e-01f, 2.95858327e-02f, 9.96519625e-02f, 8.39122087e-02f,
  8.93333107e-02f, 5.93803041e-02f, -3.76559123e-02f, -6.28552865e-03f, 1.59246355e-01f, -1.82296857e-01f, -1.35226533e-01f, 5.16615510e-02f, 2.68805176e-02f, -4.01274674e-02f,
  1.10784031e-01f, 6.11814149e-02f, -1.56824678e-01f, 6.22707307e-02f, -4.96872514e-02f, -1.20044813e-01f, 1.82729065e-01f, 1.91440701e-01f, 9.25672054e-02f, 7.13954642e-02f,
  1.45284519e-01f, -1.07567362e-01f, -3.56692442e-04f, 4.20166999e-02f, 9.33992565e-02f, 1.10445499e-01f, -7.08715841e-02f, 3.15862074e-02f, 9.01026279e-02f, -1.51506335e-01f,
  1.16660342e-01f, 3.10565927e-03f, 8.89791325e-02f, 9.89026055e-02f, 9.08501446e-02f, -9.89369676e-02f, -3.10030468e-02f, 6.01181015e-02f, 1.93931893e-01f, -8.36840495e-02f,
  1.49939552e-01f, 1.09699197e-01f, 2.28930369e-01f, -5.25251450e-03f, -9.28416755e-03f, 7.39514455e-02f, -1.10802532e-03f, 5.80091923e-02f, -3.58541496e-02f, 9.92586464e-02f,
  5.38089201e-02f, -6.06905259e-02f, 1.03856646e-01f, -1.34801017e-02f, 4.61179316e-02f, -1.27110705e-01f, 1.75395906e-01f, 4.73993160e-02f, 2.97768321e-02f, 3.56735177e-02f,
  1.00773543e-01f, 1.52321801e-01f, 1.48221329e-01f, 7.65734315e-02f, 1.55850798e-01f, 1.61939338e-01f, 7.68521652e-02f, -1.46763399e-02f, -6.15468919e-02f, 7.82421082e-02f,
  -4.24610712e-02f, -6.81827068e-02f, -5.20665608e-02f, 1.33782640e-01f, -1.40711993e-01f, 2.17438191e-02f, -1.34627372e-01f, 1.15055501e-01f, -1.07196495e-01f, 1.83126312e-02f,
  -4.35388759e-02f, -5.03973849e-02f, -4.91209216e-02f, -1.25376463e-01f, -1.43110141e-01f, -4.45447117e-02f, -4.12879959e-02f, -1.03279367e-01f, 1.29760206e-01f, 4.02764454e-02f,
  5.32561950e-02f, 1.22845367e-01f, -7.46709388e-03f, 4.67471816e-02f, 3.66786437e-04f, 1.16720118e-01f, 9.65401828e-02f, 8.42736363e-02f, -9.74133536e-02f, 1.17620798e-02f,
  1.11572549e-01f, -1.17740653e-01f, 3.34849060e-02f, 6.52851909e-02f, 1.70228612e-02f, -8.90778378e-02f, -3.87148634e-02f, -1.26593053e-01f, 2.01573465e-02f, 2.85021756e-02f,
  -8.60274956e-02f, 4.95197214e-02f, 2.34412812e-02f, -1.16356708e-01f, -8.36480930e-02f, -1.27169657e-02f, 2.33773831e-02f, 6.11851215e-02f, -7.82022402e-02f, 1.74114004e-01f,
  1.69696465e-01f, 1.70126691e-01f, 5.47062196e-02f, 9.24562812e-02f, -6.19185083e-02f, -2.09629014e-02f, 1.21871214e-02f, -2.79694535e-02f, -7.28530586e-02f, 1.04898557e-01f,
  1.82175577e-01f, 1.27549723e-01f, -3.75261810e-03f, 6.25818819e-02f, -7.62799680e-02f, 1.02043256e-01f, -1.23543695e-01f, -1.08038038e-01f, 1.10978134e-01f, 9.87568349e-02f,
  1.05957918e-01f, -1.56673819e-01f, 1.05758496e-02f, 1.04577117e-01f, 6.39338419e-02f, -2.02788427e-01f, -1.63267791e-01f, -1.10977925e-01f, -9.21873823e-02f, 6.75175292e-03f,
  -4.37158998e-03f, -4.02301513e-02f, 2.32152231e-02f, 1.08639793e-02f, 8.11401755e-02f, 1.44007877e-01f, -2.22450681e-03f, -5.06002940e-02f, -5.67270480e-02f, -1.14255428e-01f,
  -2.46525463e-02f, 1.39390647e-01f, 1.31736726e-01f, 9.47515443e-02f, -7.09800795e-02f, -7.70553350e-02f, 8.43919665e-02f, 1.08977176e-01f, 1.07183121e-01f, -1.00721695e-01f,
  4.81084734e-02f, 4.72046807e-02f, -6.54613748e-02f, 9.40325186e-02f, 4.45114672e-02f, 3.65107087e-03f, -9.16135833e-02f, -6.84938580e-02f, 2.05265030e-01f, 3.17243375e-02f,
  1.33709535e-01f, 9.15825292e-02f, 1.24067843e-01f, -4.28530425e-02f, 2.04349458e-01f, 3.02779246e-02f, 1.44344032e-01f, 6.71771541e-02f, 1.25587150e-01f, 1.26121283e-01f,
  -5.35096824e-02f, 1.06290884e-01f, 1.38560981e-01f, 9.09905136e-02f, -6.06807359e-02f, 1.91515535e-01f, -2.51643993e-02f, -1.27792850e-01f, -2.56210268e-02f, 1.17784061e-01f,
  1.46043003e-01f, -6.96485192e-02f, -5.64491339e-02f, -4.56069447e-02f, -1.00201227e-01f, 1.11582562e-01f, 7.71557866e-03f, -1.61759406e-01f, 9.18227360e-02f, 1.77441329e-01f,
  1.49199739e-01f, 1.67710662e-01f, -4.94522341e-02f, 5.37890419e-02f, 1.86887681e-01f, 4.47304314e-03f, -1.55283168e-01f, -3.95132639e-02f, -8.42475966e-02f, -9.43195969e-02f,
  -1.30086184e-01f, 5.49664795e-02f, 8.62947330e-02f, -4.57950607e-02f, -3.78091559e-02f, 4.09755632e-02f, -1.07118227e-01f, -5.19533940e-02f, -6.48559928e-02f, -4.89399321e-02f,
  1.36769369e-01f, 1.73574373e-01f, 2.32723877e-02f, 2.00227439e-01f, 1.11147180e-01f, 1.50309518e-01f, -8.53527561e-02f, 4.80054170e-02f, -3.12893055e-02f, -2.88782120e-02f,
  -5.43309115e-02f, 4.00744230e-02f, 6.81909025e-02f, 1.18445486e-01f, -5.99770769e-02f, -5.10887243e-02f, 6.56265914e-02f, 2.57945031e-01f, 1.65886730e-02f, 6.43871650e-02f,
  1.82249486e-01f, 1.18504085e-01f, 4.29819897e-02f, -7.67003968e-02f, 1.53120771e-01f, 7.63766393e-02f, 4.87366542e-02f, 5.07679433e-02f, 2.72484645e-02f, 3.25822271e-02f,
  3.78760584e-02f, 3.97947021e-02f, -1.95831701e-01f, 9.73196104e-02f, 5.73214255e-02f, -2.49639968e-04f, -5.00314459e-02f, -4.66047600e-02f, 3.37339640e-02f, -1.54506937e-01f,
  4.21381406e-02f, 1.26699507e-01f, 1.65947497e-01f, -2.27971554e-01f, -5.04225194e-02f, 1.46632865e-01f, 1.18628100e-01f, 1.43488273e-01f, 5.93361482e-02f, 4.68693599e-02f,
  2.81748056e-01f, 2.18060482e-02f, 1.03085011e-01f, -9.16012377e-02f, 1.56881303e-01f, 5.48026636e-02f, 1.08620554e-01f, -1.47707149e-01f, -2.59155650e-02f, 8.59828442e-02f,
  1.59161180e-01f, -5.43090515e-02f, 9.47289355e-03f, -8.67337212e-02f, 9.90060121e-02f, 1.00147575e-01f, 2.46946722e-01f, -9.83192101e-02f, 1.10208862e-01f, -1.78560898e-01f,
  1.34963632e-01f, -5.52561097e-02f, 8.07811543e-02f, -7.61205256e-02f, 4.82388446e-03f, 1.67944059e-01f, -6.80207461e-02f, 1.71048671e-01f, 1.20011121e-01f, -6.06995076e-02f,
  -6.12766109e-02f, 1.32157393e-02f, -6.66360930e-02f, 7.69833997e-02f, -4.41115424e-02f, -3.96700092e-02f, -7.05885962e-02f, 4.70902771e-03f, 3.85773554e-02f, 1.25854081e-02f,
  3.56747620e-02f, -3.21734510e-02f, -3.94627154e-02f, -6.29734620e-02f, -2.14105239e-03f, 4.41249944e-02f, 9.03751403e-02f, -7.95210004e-02f, -2.64768060e-02f, 5.07348701e-02f,
  3.35429758e-02f, -8.65244716e-02f, 6.93177432e-02f, 4.95402282e-03f, -5.69249839e-02f, 1.63258970e-01f, -1.40442759e-01f, -9.62406099e-02f, -1.14485271e-01f, -7.11229965e-02f,
  -1.46348268e-01f, 1.25369370e-01f, 9.80466455e-02f, 3.97483073e-02f, -8.89938101e-02f, 1.21774003e-01f, 3.89865227e-02f, 1.21128194e-01f, 9.94482413e-02f, 1.55622616e-01f,
  -2.08858531e-02f, 1.59182876e-01f, 1.51490912e-01f, -1.01920657e-01f, -9.47754085e-02f, -7.80982384e-03f, 8.67985841e-03f, -1.15157574e-01f, 5.84623814e-02f, -1.63083766e-02f,
  -7.65267611e-02f, 1.75414488e-01f, -1.10915408e-01f, -9.02088173e-03f, 2.44148105e-01f, 8.86535421e-02f, 9.74412076e-03f, 7.16375783e-02f, 1.85632855e-01f, -1.35289028e-01f,
  5.33374697e-02f, -1.20338656e-01f, -9.52877775e-02f, -1.39852047e-01f, 9.92734507e-02f, 1.54968679e-01f, 8.02598149e-02f, -4.01434787e-02f, -3.63171697e-02f, -6.63388893e-02f,
  2.98492555e-02f, 9.70227942e-02f, -4.99126650e-02f, 9.52200145e-02f, 8.04624259e-02f, 1.78082697e-02f, 4.22605034e-03f, -1.37235969e-01f, -3.75796817e-02f, -1.57347322e-02f,
  -1.09363817e-01f, 9.86116901e-02f, -2.87963767e-02f, 5.92950173e-02f, 4.64574173e-02f, -4.82450724e-02f, -8.68630931e-02f, -1.22750990e-01f, 9.04522091e-02f, 1.24287210e-01f,
  7.02196360e-02f, -8.44031125e-02f, -2.63195280e-02f, -1.31377608e-01f, 1.11813635e-01f, 2.45932601e-02f, -1.19575560e-01f, 4.74831602e-03f, 1.83568969e-01f, -4.00155745e-02f,
  -5.33123165e-02f, -5.39378785e-02f, 1.36395767e-01f, 1.09662779e-01f, 3.89761217e-02f, -4.96869460e-02f, -2.89686453e-02f, -1.00950666e-01f, 1.29797950e-01f, 2.39854120e-02f,
  1.33961380e-01f, -1.97261628e-02f, -7.33022392e-02f, 4.81654331e-02f, 6.88203331e-03f, 1.07247248e-01f, 1.11428209e-01f, 1.12258449e-01f, 1.28177330e-01f, 2.68828925e-02f,
  1.79832771e-01f, 2.74158288e-02f, 1.56549692e-01f, -6.96215183e-02f, 1.44979581e-01f, 5.02165817e-02f, 1.67734757e-01f, 1.64494753e-01f, -2.53481418e-03f, -1.83720708e-01f,
  1.88205674e-01f, -1.15460269e-01f, 1.58262715e-01f, 3.55244651e-02f, 1.45066932e-01f, 1.83394402e-02f, 8.74805599e-02f, 3.57113816e-02f, 1.55776426e-01f, 1.40131116e-01f,
  1.73262209e-01f, 8.82436261e-02f, -1.60220768e-02f, -1.98906381e-02f, 4.95652780e-02f, -3.29656303e-02f, 6.72373101e-02f, -1.33868396e-01f, -1.33276761e-01f, -6.13070093e-02f,
  -8.46415758e-02f, 1.96191192e-01f, -3.79900448e-02f, -1.59175396e-01f, 8.43003243e-02f, 1.23651087e-01f, -1.09147280e-02f, 1.68336499e-02f, 1.13366894e-01f, 5.82669582e-03f,
  1.80537418e-01f, -1.29911363e-01f, -1.30101532e-01f, -2.49337088e-02f, -4.78579365e-02f, -1.31224886e-01f, -1.49951696e-01f, -7.58383870e-02f, -7.41003007e-02f, 2.08305210e-01f,
  -1.22287005e-01f, -9.88817215e-02f, -5.39553165e-02f, 7.76716769e-02f, -3.79468389e-02f, 1.44143600e-03f, -5.04585877e-02f, 2.73058657e-02f, -7.93935806e-02f, -3.34379561e-02f,
  2.67867651e-02f, -5.14391251e-02f, -1.26019895e-01f, -1.02579921e-01f, 1.17684662e-01f, 2.91284756e-03f, 1.08011849e-02f, 9.26333144e-02f, 2.57320646e-02f, -1.25016183e-01f,
  -6.54718652e-02f, 4.97138966e-03f, -8.05434659e-02f, 1.74909886e-02f, 9.06243771e-02f, -8.21876749e-02f, 1.27976879e-01f, 1.21463828e-01f, 1.17598429e-01f, -6.11541495e-02f,
  -7.70479441e-02f, -1.11633696e-01f, 1.03535898e-01f, 1.65478960e-02f, -5.45728728e-02f, -9.12708044e-02f, -3.97967827e-03f, -4.45259698e-02f, -1.01274773e-01f, -7.15923533e-02f,
  -1.28652677e-01f, 1.32437870e-01f, 1.93328392e-02f, 1.29851997e-01f, -6.24127313e-02f, -1.09561354e-01f, 6.81749508e-02f, 1.97056346e-02f, -5.87742031e-02f, -1.00670695e-01f,
  1.45492092e-01f, -1.16012424e-01f, -7.99135491e-02f, -5.63307777e-02f, -1.32558793e-01f, 4.74965982e-02f, -3.22532631e-03f, -3.08947079e-02f, 5.25608752e-03f, 6.43173233e-02f,
  1.13421485e-01f, -6.79730028e-02f, 4.29780297e-02f, 1.09583348e-01f, 6.95464909e-02f, 6.27942011e-02f, 3.73731405e-02f, 7.56552070e-02f, -5.61406324e-03f, -1.63824987e-02f,
  -5.59264235e-03f, 8.31483975e-02f, 4.70691100e-02f, -9.64163244e-02f, -1.09184347e-01f, -5.63992038e-02f, 1.52893379e-01f, -3.21118115e-03f, -8.31347629e-02f, -5.49128205e-02f,
  2.30153184e-02f, -9.64223221e-03f, -2.49509830e-02f, 1.22684143e-01f, 6.04234450e-03f, -8.83773789e-02f, 1.14201449e-01f, 8.54899958e-02f, -3.01804096e-02f, 9.17635337e-02f,
  -5.18337712e-02f, 3.93909253e-02f, 2.42223348e-02f, 1.11780576e-01f, -4.99904752e-02f, 1.64627191e-02f, 1.52032197e-01f, 1.58225745e-01f, 1.36540025e-01f, 1.40440255e-01f,
  5.36375903e-02f, 9.12344903e-02f, -8.48651212e-03f, -6.89350888e-02f, -8.68893340e-02f, 2.26980820e-01f, 1.02231443e-01f, -1.45617470e-01f, -1.23787962e-01f, -7.26325065e-02f,
  -1.09875411e-01f, 1.06456615e-02f, -1.66220292e-01f, -1.15574680e-01f, 7.59958252e-02f, -3.33741568e-02f, -9.54719111e-02f, -9.46222916e-02f, -1.96753666e-01f, 1.18050665e-01f,
  1.65098161e-01f, -5.33014014e-02f, 9.78184044e-02f, -1.31413201e-02f, -1.31671848e-02f, -1.23734482e-01f, 1.33144697e-02f, 8.88957828e-02f, 1.16541557e-01f, 2.00908203e-02f,
  1.14528406e-02f, -6.54337034e-02f, -2.68122349e-02f, 7.44700572e-03f, 9.33081433e-02f, -8.75950009e-02f, -1.91437174e-02f, -4.72367443e-02f, -8.02582428e-02f, -1.05206510e-02f,
  -8.01580548e-02f, -4.19235602e-02f, 5.00243865e-02f, 2.60443147e-02f, 7.29228631e-02f, -1.10199705e-01f, 3.70923914e-02f, 2.03143409e-03f, 1.39715657e-01f, -7.28939399e-02f,
  1.19647093e-01f, 9.09151211e-02f, -5.32396324e-02f, 1.42375931e-01f, 1.54450402e-01f, -1.34763140e-02f, 1.43958360e-01f, -3.86267491e-02f, 1.24829471e-01f, 8.80165994e-02f,
  -1.73214555e-03f, 1.83096714e-03f, 1.10018596e-01f, 1.31717265e-01f, 1.81115717e-01f, -1.20404355e-01f, -1.49755508e-01f, 1.35478020e-01f, 1.68087985e-03f, -2.59989530e-01f,
  1.43956184e-01f, -7.06757456e-02f, 1.25019416e-01f, -1.77644700e-01f, 1.35662571e-01f, -1.24707092e-02f, 1.46182969e-01f, -7.85529986e-03f, -1.76242486e-01f, 2.91414652e-02f,
  -1.27650931e-01f, 4.83448990e-02f, 4.48366888e-02f, -1.46264046e-01f, 8.34267288e-02f, 1.08812772e-01f, -2.98071895e-02f, 1.01198018e-01f, 3.63442451e-02f, 1.61464423e-01f,
  -6.24743197e-03f, -1.05922788e-01f, 3.13632353e-03f, 5.91664352e-02f, -3.53742689e-02f, -7.89149627e-02f, -6.11814260e-02f, -1.55921623e-01f, 2.91297538e-03f, 1.15315631e-01f,
  9.48815644e-02f, -7.08042923e-03f, 2.20344998e-02f, 8.31407961e-03f, 5.10978177e-02f, 1.82550058e-01f, 1.33900372e-02f, -4.11608053e-04f, -1.24267235e-01f, -1.05049647e-02f,
  -1.60335526e-02f, -6.32805005e-03f, 6.34847879e-02f, 1.88707914e-02f, 4.67342604e-03f, -4.38376702e-02f, 4.50541936e-02f, -6.78671971e-02f, -3.20454091e-02f, -1.70403868e-02f,
  1.12893984e-01f, -8.02170783e-02f, 9.08069219e-03f, 3.00574135e-02f, 4.47991528e-02f, 6.73237965e-02f, 7.97980372e-03f, 9.56603959e-02f, -9.60635487e-03f, 1.51480809e-01f,
  -1.60319116e-02f, -2.83614825e-03f, 7.86193833e-02f, -3.20249163e-02f, 4.16629799e-02f, -1.56909693e-02f, 1.06246144e-01f, 1.22436203e-01f, 1.27328157e-01f, 6.31698892e-02f,
  -1.71398088e-01f, 1.18512467e-01f, 6.74726069e-02f, -9.56409127e-02f, -7.36011714e-02f, 3.40876393e-02f, -5.36376946e-02f, 5.76893575e-02f, 2.38904301e-02f, -1.70756783e-03f,
  6.45156205e-03f, 7.03178868e-02f, 3.94218192e-02f, 2.03043893e-02f, 7.87951350e-02f, 1.18240066e-01f, 9.38901454e-02f, 4.67655063e-02f, -2.09102854e-02f, -5.04830033e-02f,
  7.78737944e-03f, 1.04660697e-01f, -7.26173595e-02f, -1.05315477e-01f, -3.57999876e-02f, -7.46141374e-02f, -8.05454403e-02f, -3.31496112e-02f, 1.02658011e-01f, -4.19085771e-02f,
  -4.12859097e-02f, 5.03089987e-02f, 1.25750661e-01f, 4.85184602e-02f, 3.02773658e-02f, -3.67961563e-02f, 7.56058246e-02f, 3.63582559e-02f, 1.84175074e-01f, 1.30719826e-01f,
  -7.42715672e-02f, -4.98746634e-02f, -7.30629414e-02f, 1.53175876e-01f, 5.34884743e-02f, 1.16082005e-01f, 9.91961062e-02f, 2.03720909e-02f, 1.30267695e-01f, 6.22072592e-02f,
  9.28061828e-02f, 7.68283531e-02f, 3.00851464e-02f, -2.22779021e-01f, -1.44582063e-01f, 2.83724479e-02f, -8.09367001e-03f, -1.82008758e-01f, 5.11234924e-02f, -3.83741222e-02f,
  8.91638100e-02f, -3.07753030e-02f, -2.91560274e-02f, 2.81802402e-03f, 5.11573441e-02f, 1.70477450e-01f, 8.06230605e-02f, 1.98337719e-01f, 1.25017554e-01f, -6.47821501e-02f,
  -1.16966935e-02f, -7.03180358e-02f, -5.19507006e-02f, 9.58492085e-02f, -1.31434366e-01f, -8.15214366e-02f, -7.45049715e-02f, 3.95764299e-02f, 3.05858552e-02f, -3.87581550e-02f,
  -6.34915158e-02f, 1.73684508e-02f, 9.13730115e-02f, -2.15565432e-02f, -8.05747658e-02f, -1.38451070e-01f, -1.03630386e-01f, 3.61874700e-02f, 3.69278118e-02f, 1.22501245e-02f,
  2.77914945e-02f, 9.81158391e-02f, 1.31545901e-01f, -5.18366545e-02f, 1.68942690e-01f, 9.28998590e-02f, -5.87233081e-02f, 8.24044570e-02f, -5.09401001e-02f, 1.21545166e-01f,
  3.36928740e-02f, -1.33291543e-01f, 1.17344603e-01f, 1.28090024e-01f, 1.50498137e-01f, 1.34176686e-01f, -5.13991565e-02f, 7.79380351e-02f, 1.51097640e-01f, 5.40088639e-02f,
  -1.35578290e-01f, 7.40933865e-02f, -5.30260913e-02f, -8.95598531e-02f, -4.42542210e-02f, 5.08174591e-04f, 1.94589142e-02f, -5.49442833e-03f, -5.05179241e-02f, 1.11180931e-01f,
  -9.04574171e-02f, -3.67621891e-02f, -6.85825199e-02f, 5.48763350e-02f, 6.60521314e-02f, 2.54415050e-02f, 9.66372639e-02f, 2.67696343e-02f, 1.53477684e-01f, 1.27485707e-01f,
  1.70268387e-01f, 1.00744419e-01f, 1.54585624e-02f, 5.50899245e-02f, 1.16619617e-01f, 5.57314791e-02f, -1.38179250e-02f, -9.57494080e-02f, -6.47568554e-02f, 1.10485062e-01f,
  -7.19759539e-02f, -7.34377429e-02f, 8.06557760e-02f, -3.46152671e-02f, 1.32615017e-02f, 1.25747863e-02f, 1.08215682e-01f, -5.48346303e-02f, -1.06091194e-01f, -1.24234430e-01f,
  6.30867034e-02f, 1.16568908e-01f, 3.19662765e-02f, 7.74168968e-02f, 1.86022446e-01f, 1.13882884e-01f, 8.22649822e-02f, 1.33115277e-01f, 1.50642484e-01f, -1.51388384e-02f,
  7.43866712e-03f, 9.08167213e-02f, 5.81049956e-02f, -1.09887205e-01f, 5.97180799e-02f, -7.89402276e-02f, 1.66340277e-01f, 5.90027720e-02f, 1.59228504e-01f, -6.51029451e-03f,
  -1.78614669e-02f, 9.36839208e-02f, -4.88512591e-02f, -2.12320872e-02f, 7.44635239e-02f, 5.28035574e-02f, 5.87576218e-02f, -6.71224743e-02f, 1.20171510e-01f, -1.19348586e-01f,
  3.77422348e-02f, 2.39362121e-02f, -1.93424851e-01f, 7.36621693e-02f, 9.47733782e-03f, 1.12471350e-01f, 1.69023704e-02f, 9.29464102e-02f, -1.09627880e-01f, -6.34758323e-02f,
  2.42291503e-02f, 1.17566116e-01f, 1.20580383e-01f, 3.48129980e-02f, 2.18812004e-01f, 3.48299406e-02f, 7.98550993e-02f, -4.30928171e-02f, -1.36445031e-01f, -9.25766528e-02f,
  3.23012650e-01f, -3.43394242e-02f, 1.25096366e-01f, 6.16025813e-02f, 9.44574475e-02f, 2.43873708e-02f, 9.12305899e-03f, -3.92578617e-02f, 1.32921159e-01f, 1.40300602e-01f,
  1.27897739e-01f, 1.14258252e-01f, 2.70265564e-02f, -6.54504150e-02f, -7.21630007e-02f, 4.74824430e-03f, 9.63720903e-02f, -6.97205514e-02f, 9.41636693e-03f, -3.01038828e-02f,
  1.01683691e-01f, -1.24981619e-01f, 3.09592217e-01f, -1.40602160e-02f, -1.02182604e-01f, 2.10146252e-02f, 1.54273108e-01f, 1.46875575e-01f, 1.79990649e-01f, 2.09934801e-01f,
  -1.47142112e-01f, -9.47918221e-02f, 1.40516415e-01f, 6.37032613e-02f, -3.50333899e-02f, 2.07256988e-01f, -2.55531855e-02f, -3.06626856e-02f, -1.77997891e-02f, 7.95662776e-02f,
  -4.54213023e-02f, 2.12490782e-02f, -8.15010220e-02f, 1.52025223e-01f, 1.19828850e-01f, -1.00871623e-01f, 2.85603106e-02f, 4.97789085e-02f, -6.66309595e-02f, -1.26475394e-01f,
  -1.14049591e-01f, 6.11321721e-03f, -1.52359188e-01f, 1.20574236e-01f, -2.77025476e-02f, -6.75078034e-02f, 6.38095737e-02f, 1.26797035e-01f, 1.78466335e-01f, 6.80793226e-02f,
  1.04252681e-01f, -7.66382068e-02f, 2.00580031e-01f, -5.82481585e-02f, -8.80171955e-02f, 1.67395249e-01f, -1.05004169e-01f, -9.11016315e-02f, 1.03005052e-01f, 4.00676243e-02f,
  9.13277715e-02f, 6.81504086e-02f, 5.63124754e-02f, 8.82956013e-02f, -2.99594235e-02f, 5.58391213e-02f, 1.13693818e-01f, -7.20347762e-02f, -9.64762941e-02f, 9.97573417e-03f,
  -1.36068851e-01f, 9.27706733e-02f, -5.58582775e-04f, 4.01767828e-02f, 3.08035184e-02f, 1.00313857e-01f, -2.97158416e-02f, 1.23145878e-01f, -1.32037610e-01f, 7.14325309e-02f,
  1.39684796e-01f, 3.68404239e-02f, -1.05939817e-03f, 9.63732228e-02f, -1.61136023e-03f, -1.04587346e-01f, 1.50552064e-01f, 6.27947375e-02f, 1.34055272e-01f, -3.50178853e-02f,
  4.05489244e-02f, -1.00632133e-02f, 1.34153709e-01f, 1.41880110e-01f, 1.06825545e-01f, -2.62358412e-02f, -5.32645546e-02f, -8.10016692e-02f, 4.85796444e-02f, -8.12225416e-02f,
  9.58140492e-02f, 8.29797536e-02f, 5.38995340e-02f, 6.81351200e-02f, -8.65672752e-02f, -1.30474806e-01f, -2.19815359e-01f, 1.42968610e-01f, -1.77183360e-01f, -7.63357803e-02f,
  -4.84546162e-02f, -1.14991300e-01f, 4.72560292e-03f, -4.52742316e-02f, 7.72288674e-03f, -2.36800523e-03f, 1.03930660e-01f, 8.44591931e-02f, 8.04635212e-02f, 4.11349460e-02f,
  -1.21893823e-01f, 5.08487085e-03f, 1.03601076e-01f, -1.51606258e-02f, -6.36695921e-02f, 1.18209913e-01f, 1.11258894e-01f, 3.12038641e-02f, 4.85924892e-02f, 1.85691305e-02f,
  -2.94758531e-04f, -7.60311410e-02f, -1.02661781e-01f, -1.33231506e-01f, 1.07732847e-01f, -8.62679183e-02f, 4.04930674e-02f, -9.12263095e-02f, 1.12501673e-01f, -1.08396940e-01f,
  -8.46921876e-02f, 7.48768076e-02f, 1.34321004e-01f, 1.40844807e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -7.57719651e-02f, -5.38941361e-02f, 1.33319616e-01f, 8.79493821e-03f, -8.15623403e-02f, -6.85114563e-02f, 1.82789072e-01f, 6.68347999e-02f, 1.76412895e-01f, -2.74265241e-02f,
  1.03785217e-01f, 2.89076921e-02f, 3.41901332e-02f, 1.11270264e-01f, 4.80431952e-02f, -1.64508689e-02f, 1.97683528e-01f, -3.67402658e-02f, -3.28639746e-02f, 2.44843606e-02f,
  -1.11581974e-01f, 1.34925693e-01f, 3.22456360e-02f, 4.08930471e-03f, 1.53201465e-02f, -2.39273645e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.06201276e-01f, -8.23065415e-02f, 2.99870986e-02f, -9.93564650e-02f, 7.58932680e-02f, -3.20403837e-02f, 4.10681926e-02f, 1.87124256e-02f, -3.23408023e-02f, -3.65052149e-02f,
  -1.31854117e-01f, 5.41982390e-02f, 3.49897183e-02f, -1.03547685e-01f, -7.08959997e-04f, -2.04583164e-02f, 1.30216748e-01f, -8.84797052e-02f, 7.06714243e-02f, 4.43801796e-03f,
  8.61296356e-02f, -4.50288272e-03f, -8.58726632e-03f, -4.70488891e-02f, -4.08406258e-02f, -8.56412947e-02f, 5.49333468e-02f, 1.70837238e-01f, 4.24528830e-02f, -6.14289418e-02f,
  -5.02453260e-02f, -6.98161647e-02f, 1.06422976e-01f, -1.94327421e-02f, 1.01207174e-01f, 4.52334955e-02f, -1.18921377e-01f, -1.09860606e-01f, 9.62996706e-02f, -5.92295192e-02f,
  1.32963538e-01f, 7.26926774e-02f, -3.53320548e-03f, 1.34404540e-01f, 1.21695526e-01f, -1.38678011e-02f, -5.22685610e-02f, -1.86529502e-01f, -3.61330546e-02f, 2.91065350e-02f,
  3.54830436e-02f, -9.22386125e-02f, -8.79784971e-02f, -1.32895157e-01f, 7.49283358e-02f, 2.64501534e-02f, -1.01844564e-01f, -6.19557202e-02f, 5.80912493e-02f, 4.98864539e-02f,
  -6.65842146e-02f, -1.11640833e-01f, -9.87573192e-02f, -6.81644911e-03f, 4.12226319e-02f, 1.38626352e-01f, 7.46737374e-03f, -1.62434816e-01f, 1.38185307e-01f, 2.71349791e-02f,
  -1.59207489e-02f, 3.04493923e-02f, 1.36589065e-01f, 3.44581753e-02f, 7.00569674e-02f, -2.28449758e-02f, 1.48236603e-01f, -2.33491859e-03f, 7.40743279e-02f, 5.09175733e-02f,
  -8.94334689e-02f, -3.95643227e-02f, 6.71909750e-02f, 2.67375633e-03f, 7.75530711e-02f, 5.16729616e-02f, 1.43145323e-01f, -3.12791094e-02f, 5.65758534e-02f, -2.45270729e-01f,
  -1.30507708e-01f, -1.19560875e-01f, -1.49301183e-03f, 3.20181958e-02f, -1.73161536e-01f, 1.94469005e-01f, -7.54810944e-02f, -4.70627984e-03f, -1.48260742e-01f, -2.12810516e-01f,
  2.53941655e-01f, -7.25002363e-02f, -3.70040201e-02f, 5.78094237e-02f, 2.67863907e-02f, 1.05199091e-01f, -7.98243657e-02f, -6.90084323e-02f, -2.23237574e-02f, 5.55770881e-02f,
  -5.24423644e-02f, 2.77036298e-02f, -2.04237662e-02f, -1.85311422e-01f, 2.45694026e-01f, -2.70461023e-01f, -1.74843252e-01f, -1.27446195e-02f, 1.79581389e-01f, -1.36448592e-01f,
  2.01545767e-02f, -1.12004645e-01f, -7.21465498e-02f, -2.44339108e-02f, -7.62601271e-02f, -1.12092130e-01f, 2.67468393e-02f, 1.10616900e-01f, -3.09411045e-02f, 9.69903022e-02f,
  -2.85019744e-02f, -1.96972713e-01f, -5.29179815e-03f, 1.37458509e-02f, -9.98004247e-03f, 4.94087301e-02f, 1.27829343e-01f, 1.79805048e-02f, 1.15197577e-01f, -8.90534520e-02f,
  9.06352252e-02f, -4.02597710e-02f, -8.11932981e-02f, 1.19307481e-01f, -1.04152262e-01f, -4.37657386e-02f, -1.82900392e-02f, 1.76728576e-01f, 2.11305588e-01f, 6.90586045e-02f,
  -2.66661584e-01f, 1.59759775e-01f, 1.84354335e-02f, 3.10439523e-02f, -1.28588244e-01f, -9.81282890e-02f, -3.36067714e-02f, -4.41567264e-02f, 5.85938571e-03f, 8.54309797e-02f,
  -4.88289744e-02f, -1.26874253e-01f, -5.24959601e-02f, 3.59041914e-02f, -2.47163866e-02f, 8.58671218e-02f, 3.43540311e-02f, 2.83047855e-02f, -1.28385991e-01f, -4.31600586e-02f,
  -9.38363299e-02f, -6.99060857e-02f, -1.73384324e-02f, -1.83864132e-01f, 5.60447089e-02f, 1.56127587e-01f, 5.38101457e-02f, -1.20680384e-01f, 5.32164164e-02f, -6.81049824e-02f,
  -6.64361417e-02f, 8.13364750e-04f, 8.52644891e-02f, -7.84314945e-02f, -4.24256250e-02f, -1.20208347e-02f, 1.05603248e-01f, 1.16750799e-01f, 8.44610184e-02f, -1.16171986e-01f,
  1.47735998e-01f, -1.02189258e-01f, -4.76124324e-02f, -5.31108305e-03f, -2.06239633e-02f, 1.57461390e-01f, 1.62351355e-01f, 1.51144732e-02f, -8.90945941e-02f, 8.80678184e-03f,
  6.89786300e-02f, 2.37495564e-02f, -5.82083501e-02f, -1.40446415e-02f, -8.47710669e-02f, -2.63917148e-02f, 1.42762557e-01f, -9.01587754e-02f, 7.67743662e-02f, 1.88356683e-01f,
  4.91300337e-02f, -8.06525126e-02f, 1.59433819e-02f, 6.85059931e-03f, 2.86685407e-01f, -8.48892406e-02f, 6.43924847e-02f, -2.19981428e-02f, -2.61514597e-02f, 1.41030490e-01f,
  -8.79347399e-02f, 1.15433238e-01f, -3.21617462e-02f, -1.88982576e-01f, 3.46229295e-03f, 1.88462883e-02f, 9.30421725e-02f, 1.32130593e-01f, -2.07220286e-01f, -1.21055506e-01f,
  7.02365786e-02f, 1.18404984e-01f, -1.06709912e-01f, 1.22573219e-01f, 9.56550241e-02f, 1.37811467e-01f, 1.81832820e-01f, 1.74308732e-01f, 3.34293880e-02f, -1.39376208e-01f,
  -6.05645664e-02f, -1.05204592e-02f, -1.93197131e-01f, 1.89625427e-01f, -2.77104266e-02f, 1.04808711e-01f, -9.22543108e-02f, 1.34480372e-01f, 5.70482649e-02f, -3.18216160e-02f,
  8.05687532e-02f, -6.29322156e-02f, -1.03383049e-01f, 9.50510353e-02f, -2.05171019e-01f, -8.41206759e-02f, -5.70129752e-02f, 2.72892285e-02f, 4.62791361e-02f, -1.27813026e-01f,
  -9.60599557e-02f, 5.65760471e-02f, -7.35061169e-02f, -5.75841442e-02f, 1.18660673e-01f, -4.35920879e-02f, 5.23358062e-02f, 7.10536987e-02f, 7.92563111e-02f, 2.73968261e-02f,
  1.07389905e-01f, -6.49707913e-02f, 4.54270514e-03f, -6.58005551e-02f, 1.07558444e-01f, 2.81945858e-02f, 7.21918792e-02f, -6.92742467e-02f, -2.48585805e-01f, 2.26310372e-01f,
  1.43591285e-01f, -6.77344650e-02f, -1.35908559e-01f, -4.58320417e-02f, 5.91608994e-02f, 1.03481852e-01f, -4.97414544e-02f, 1.63151011e-01f, 8.59757662e-02f, -1.95962980e-01f,
  7.00143203e-02f, 9.05211270e-03f, 1.99807763e-01f, 1.81388021e-01f, -7.94231612e-03f, 6.57033697e-02f, -1.10962894e-02f, -8.07476565e-02f, -5.70005598e-03f, -2.35049222e-02f,
  -1.72088429e-01f, -1.39268875e-01f, 6.15509115e-02f, -3.62134837e-02f, 4.85630631e-02f, -1.25413612e-02f, 7.76405707e-02f, -1.07449509e-01f, -3.50667946e-02f, -1.09783530e-01f,
  2.22570434e-01f, -4.18377630e-02f, -1.41580641e-01f, 1.45470455e-01f, -4.68109660e-02f, 1.83405623e-01f, 1.27892673e-01f, -1.27474502e-01f, 1.69921204e-01f, 1.87686086e-02f,
  -1.13493331e-01f, 3.63937989e-02f, -4.72374223e-02f, 5.12854718e-02f, 6.38024360e-02f, -6.80804774e-02f, 1.75923819e-03f, 4.85336334e-02f, 2.89108939e-02f, 5.16116023e-02f,
  -7.32713714e-02f, -3.33985724e-02f, -1.04917856e-02f, -1.36171710e-02f, -9.07686651e-02f, 9.41887498e-02f, 5.68745360e-02f, 1.41116902e-01f, -5.99958263e-02f, 1.45785034e-01f,
  8.31414654e-04f, -1.10720791e-01f, -1.18534833e-01f, 2.37982601e-01f, -5.39200045e-02f, -9.74210203e-02f, -2.13732317e-01f, 1.87558308e-01f, 1.37237623e-01f, 3.11985463e-02f,
  -6.93860203e-02f, -1.25271231e-01f, 1.72034413e-01f, -6.80144429e-02f, 9.17094350e-02f, 4.91378568e-02f, -9.81107429e-02f, -6.71691224e-02f, 1.15532070e-01f, -5.00341393e-02f,
  1.70882761e-01f, -5.27085587e-02f, 1.08859919e-01f, -5.66547029e-02f, 8.35337397e-03f, -1.16245963e-01f, -9.85774323e-02f, -1.42802456e-02f, -1.09866209e-01f, 4.27949155e-04f,
  8.74409266e-03f, -1.55934498e-01f, -3.55664007e-02f, -1.02480896e-01f, -7.89449178e-03f, 3.55077535e-02f, -1.39753342e-01f, 1.58432290e-01f, 1.02700479e-02f, 1.07052825e-01f,
  4.58072731e-03f, -2.08535939e-01f, -8.24019685e-02f, -1.71885788e-01f, -2.26976722e-02f, 8.37807264e-03f, -9.27581489e-02f, 4.84124757e-02f, -1.19603820e-01f, 8.50701183e-02f,
  -4.89359163e-02f, -1.62685663e-02f, 6.97973669e-02f, 9.20920372e-02f, -1.61883757e-02f, 1.09711602e-01f, -4.46428172e-03f, -1.65512055e-01f, -1.45376116e-01f, 4.78138775e-03f,
  -5.36393300e-02f, 1.40917718e-01f, -1.22842126e-01f, 2.03601550e-02f, -1.73795700e-01f, -1.18341453e-01f, 4.05067764e-02f, -1.02127530e-01f, -3.25196497e-02f, 1.11317590e-01f,
  -3.16160992e-02f, 5.84605746e-02f, -2.27716416e-02f, -8.29462186e-02f, 2.62698485e-03f, -1.15332849e-01f, 9.18732136e-02f, 3.78042944e-02f, 1.24966703e-01f, 1.73677370e-01f,
  -1.35763004e-01f, -2.07858011e-01f, 7.22203478e-02f, -1.03011779e-01f, 9.96589586e-02f, -1.08329989e-01f, 3.78357545e-02f, 1.12299621e-02f, 2.07459182e-01f, -1.07529566e-01f,
  1.10286921e-01f, -1.86237544e-01f, -2.52365544e-02f, 9.87829566e-02f, -1.60369396e-01f, 8.32875073e-02f, 2.82317568e-02f, 4.43708934e-02f, -5.17232791e-02f, 7.79773667e-02f,
  1.29779235e-01f, 3.41764055e-02f, 1.36216447e-01f, -1.17260478e-01f, -1.40901551e-01f, -5.90889901e-02f, -9.80483890e-02f, 7.52589554e-02f, -6.03076722e-03f, 2.84249820e-02f,
  -1.44753130e-02f, -1.00034690e-02f, -4.68929186e-02f, -1.31112710e-01f, -3.79033387e-02f, -2.68034600e-02f, -1.15595050e-01f, -7.68308416e-02f, -1.34931728e-01f, -1.02409190e-02f,
  7.60070309e-02f, 3.66205014e-02f, -1.18498653e-01f, 1.00733347e-01f, -1.83682051e-03f, -1.84476063e-01f, 1.68599263e-01f, 4.22050357e-02f, 2.40604416e-01f, -3.35512161e-02f,
  -1.73887134e-01f, 2.13009179e-01f, -1.40309188e-04f, -1.31590426e-01f, 4.33324054e-02f, 5.43021411e-02f, 2.19328284e-01f, 1.25583291e-01f, -3.87885161e-02f, -9.41845179e-02f,
  -5.05480990e-02f, -7.80911669e-02f, -1.17335275e-01f, 4.02565412e-02f, -9.87445042e-02f, 1.75030679e-01f, -5.00022359e-02f, 1.32884141e-02f, -2.04172030e-01f, -3.07095423e-02f,
  -7.21456297e-03f, -1.07446790e-01f, -1.25209704e-01f, -6.08832948e-02f, -8.72240867e-03f, 1.65656969e-01f, -1.43346861e-01f, -3.64073664e-02f, 8.44622180e-02f, 6.07917793e-02f,
  -5.95738590e-02f, -1.86345670e-02f, 1.44891161e-02f, -7.23918378e-02f, -1.15814507e-01f, 4.46907394e-02f, -1.07426204e-01f, 2.68816836e-02f, 1.40519843e-01f, 1.26591220e-01f,
  4.43943702e-02f, -5.53412773e-02f, -1.01451054e-01f, 8.38799924e-02f, -9.81648862e-02f, 5.18936780e-04f, -7.94494972e-02f, 5.48117980e-03f, -2.11554766e-02f, -5.74459136e-02f,
  -3.58599685e-02f, -2.80424692e-02f, -8.22588205e-02f, -1.06413752e-01f, 1.01998009e-01f, -1.16243474e-01f, 5.53106237e-03f, 3.34056690e-02f, 2.78684236e-02f, -1.45748183e-01f,
  -6.31780699e-02f, -3.03677656e-02f, 7.40981251e-02f, -6.11857064e-02f, -3.77545357e-02f, 2.19326071e-03f, -1.95792858e-02f, 7.39837438e-02f, -3.10238842e-02f, -1.12774566e-01f,
  1.13032170e-01f, -1.67225718e-01f, -2.57218003e-01f, 1.99122503e-01f, -1.02295354e-01f, 2.02216022e-02f, 1.09267309e-01f, 5.07313870e-02f, 1.60066292e-01f, -1.12592451e-01f,
  2.89261434e-02f, 3.12759094e-02f, 3.06266770e-02f, 2.07514130e-02f, -6.45229369e-02f, -5.18572070e-02f, -1.64553732e-01f, -1.43666089e-01f, 1.94892257e-01f, -1.23295449e-01f,
  6.61572516e-02f, -4.50951327e-03f, 1.74381256e-01f, -2.33424231e-01f, 7.36704469e-02f, -5.22886515e-02f, 1.01814650e-01f, -1.27896979e-01f, -1.41065925e-01f, -1.31384745e-01f,
  7.37613589e-02f, 5.35501912e-03f, 5.66378571e-02f, -7.21773952e-02f, 1.19652838e-01f, 1.21061429e-01f, 1.97743550e-02f, 1.34011358e-01f, -1.99327562e-02f, 5.00200093e-02f,
  1.18889414e-01f, -7.48409107e-02f, 8.34314451e-02f, 6.87237307e-02f, -3.97690125e-02f, 4.35810089e-02f, -5.52612059e-02f, -8.91894847e-02f, -9.77217630e-02f, 8.14576074e-02f,
  2.66531929e-02f, 5.37780486e-02f, -3.31087410e-02f, 4.65607159e-02f, -4.03580293e-02f, -1.38855457e-01f, 1.07474193e-01f, -1.59380242e-01f, -1.86456054e-01f, 1.63823485e-01f,
  3.13884914e-02f, 1.74859585e-03f, -7.43041262e-02f, -4.08287905e-02f, 6.88282102e-02f, 7.77077600e-02f, -8.47276449e-02f, -4.84831445e-02f, -1.72509020e-03f, 4.10133116e-02f,
  8.30605179e-02f, -6.65357709e-02f, -1.53258964e-01f, 5.12418896e-02f, 1.09630320e-02f, 1.54114352e-03f, 1.79959927e-02f, -3.41173401e-03f, -1.02499083e-01f, 1.60809800e-01f,
  -9.56997350e-02f, -8.27226508e-03f, -2.01141443e-02f, -4.86385785e-02f, -8.44621286e-02f, 7.62635842e-02f, 2.84199044e-02f, 1.13446638e-01f, 2.56107636e-02f, 2.03402758e-01f,
  7.82837942e-02f, 7.12079480e-02f, -1.71701889e-02f, 1.91262551e-02f, 5.75201884e-02f, 1.04064859e-01f, 8.12763199e-02f, 3.07939779e-02f, 6.37563244e-02f, -6.56501055e-02f,
  1.15953818e-01f, 1.04156666e-01f, 1.84254237e-02f, 8.64832401e-02f, -8.56527686e-03f, 1.38002872e-01f, 5.95756583e-02f, 3.78796868e-02f, -1.18104387e-02f, -6.41091242e-02f,
  -3.10416264e-03f, 8.69665444e-02f, -8.49606097e-03f, -1.88348498e-02f, 2.17272472e-02f, -8.39895234e-02f, -1.56804621e-01f, 1.23334117e-01f, -1.27863988e-01f, 1.92366585e-01f,
  -1.09687269e-01f, 3.43051227e-03f, -7.03115063e-03f, -3.55829708e-02f, -2.04148859e-01f, 5.35124578e-02f, -8.33171830e-02f, -3.04879546e-01f, -2.21979365e-01f, -4.00020042e-03f,
  -1.12371139e-01f, 1.02777429e-01f, -1.46303385e-01f, 8.91922861e-02f, -1.08939104e-01f, -2.23113298e-01f, 1.08402103e-01f, -1.54942036e-01f, 1.13456868e-01f, -4.08855192e-02f,
  3.78066450e-02f, -7.81435892e-02f, 7.12911412e-02f, 6.64253309e-02f, -1.88487172e-01f, -1.32455647e-01f, 6.42753020e-02f, -1.92083362e-02f, 9.97490808e-02f, -4.25214693e-02f,
  -3.62395309e-02f, -5.66575676e-02f, -9.46657136e-02f, -1.29730731e-01f, 7.16968477e-02f, -4.58012111e-02f, 7.27786124e-02f, 6.32430539e-02f, 2.14231890e-02f, -8.60430859e-03f,
  -1.48215845e-01f, -1.21937461e-01f, 6.46524653e-02f, -2.19595935e-02f, 5.03888316e-02f, 9.03868601e-02f, -9.02697146e-02f, -1.15790339e-02f, -1.16575785e-01f, -1.41108632e-01f,
  -7.28360424e-03f, 1.49722230e-02f, 1.46442438e-02f, 9.86989122e-03f, -1.19018398e-01f, 1.90589018e-02f, -1.21070370e-01f, 1.08235985e-01f, 3.30533274e-02f, -9.57304686e-02f,
  1.22696213e-01f, -1.53964072e-01f, -4.91451239e-03f, -7.88438097e-02f, 2.28947803e-01f, -2.76026547e-01f, -3.40477228e-01f, 1.95991591e-01f, 2.01324187e-02f, 1.90061808e-01f,
  -9.76753160e-02f, 8.20039213e-02f, 2.18414500e-01f, 4.82988209e-02f, 9.39099267e-02f, -1.14142755e-02f, -1.81867614e-01f, -5.46889529e-02f, 1.20309442e-01f, 1.75857674e-02f,
  -9.09467228e-03f, 2.07886055e-01f, -4.93515320e-02f, 2.21738163e-02f, -3.45162302e-02f, -4.18610275e-02f, -3.51281874e-02f, -2.37425994e-02f, -1.54171392e-01f, -1.89690907e-02f,
  -1.01186052e-01f, 1.49770215e-01f, 4.77209315e-02f, 6.24696910e-02f, 1.62797898e-01f, 1.05586782e-01f, -1.07418254e-01f, 3.07096280e-02f, -1.27700672e-01f, -1.14700809e-01f,
  -1.55157253e-01f, 1.57840893e-01f, -1.76359843e-02f, 1.60005674e-01f, 1.25302181e-01f, 1.46212429e-01f, -5.99272810e-02f, 1.02639958e-01f, -1.01028740e-01f, 9.02729407e-02f,
  1.12414934e-01f, -5.94343431e-02f, 5.80465235e-03f, -9.51389130e-03f, 1.41100898e-01f, -1.17684990e-01f, -1.84805859e-02f, -1.00132786e-01f, 2.27939859e-02f, -1.33912012e-01f,
  -4.74846177e-02f, 1.04836628e-01f, 1.00789852e-02f, -1.31190652e-02f, -1.08307585e-01f, -8.94683301e-02f, 9.42161903e-02f, 1.06001906e-01f, -2.39262693e-02f, 4.20394465e-02f,
  -4.90356535e-02f, -5.26457839e-02f, 3.35651450e-02f, -1.43434495e-01f, -5.75035997e-02f, -8.68069194e-03f, 1.96302105e-02f, -6.87308833e-02f, -4.17045355e-02f, 1.90253600e-01f,
  -1.37934357e-01f, 1.13171317e-01f, -3.41968536e-02f, -7.43428394e-02f, 2.23821133e-01f, -1.37441441e-01f, 1.16818286e-01f, 7.27375224e-02f, 1.39180109e-01f, 8.41168463e-02f,
  -2.81258859e-03f, 5.85165843e-02f, -5.80650233e-02f, -3.09823882e-02f, 6.33204952e-02f, 6.59570191e-03f, 4.43602726e-02f, -1.14745170e-01f, 2.17871547e-01f, -1.81823134e-01f,
  -1.08470786e-02f, -1.36349961e-01f, 1.71471253e-01f, -2.96117440e-02f, -9.97673534e-03f, -1.10280350e-01f, -2.93442756e-02f, -9.38895643e-02f, 7.04266652e-02f, -1.67774245e-01f,
  1.46309331e-01f, -1.27929881e-01f, 7.08885677e-03f, -6.00486994e-02f, -1.91817395e-02f, -9.97572318e-02f, 1.09043889e-01f, 1.55211493e-01f, 1.31091446e-01f, 1.03865892e-01f,
  -9.35616568e-02f, 5.82149178e-02f, -6.05910905e-02f, 5.01507856e-02f, -6.44530281e-02f, 5.86280925e-03f, 2.17680130e-02f, 3.94544080e-02f, 8.64652991e-02f, -1.08387738e-01f,
  -1.08148068e-01f, -1.25339374e-01f, -3.90685722e-02f, -5.03395498e-02f, -2.02986822e-01f, 1.95887953e-01f, 2.92330165e-04f, -7.39299729e-02f, -1.37223393e-01f, 2.27179646e-01f,
  2.33928427e-01f, 1.21046327e-01f, -1.99245345e-02f, 1.02869840e-02f, 8.80642086e-02f, -3.16578113e-02f, -3.27820182e-02f, 1.71423808e-01f, -3.44352052e-02f, 1.46278292e-01f,
  5.50708408e-03f, -9.83941555e-02f, 5.62030897e-02f, 8.96806940e-02f, 8.30050856e-02f, 7.99540281e-02f, 5.35716861e-03f, -1.37430653e-01f, -5.79479942e-03f, -1.13327943e-01f,
  -1.41899362e-01f, -4.33221422e-02f, -5.45234196e-02f, 1.04643531e-01f, -1.38835050e-02f, -4.47491556e-02f, -1.83129515e-02f, -4.01517823e-02f, -7.94200599e-02f, 1.59697190e-01f,
  -1.37663903e-02f, 1.64758805e-02f, 4.09298576e-03f, 2.01719534e-02f, 2.15523448e-02f, -6.44028559e-02f, 3.06893438e-02f, 8.43509361e-02f, -1.48258209e-01f, -7.80642107e-02f,
  7.60823339e-02f, -9.28767025e-02f, -2.91971061e-02f, 6.84329635e-03f, -9.52987298e-02f, -1.63279071e-01f, 1.68594327e-02f, 1.20723128e-01f, 8.96043032e-02f, -8.59323144e-02f,
  -1.09656483e-01f, -3.83817032e-02f, 6.19378649e-02f, -5.77467270e-02f, -7.31766075e-02f, -1.30770626e-02f, 9.35375988e-02f, -2.78221488e-01f, -3.29941571e-01f, 1.12635279e-02f,
  9.97785926e-02f, 1.37835070e-02f, -1.03231534e-01f, 3.14506963e-02f, 1.56899169e-01f, 9.40854847e-02f, 1.22594118e-01f, 2.40438175e-03f, -7.57103339e-02f, -1.71520382e-01f,
  -3.22190449e-02f, 1.44232497e-01f, -1.84356458e-02f, 1.33400157e-01f, -3.57819535e-02f, -3.94518562e-02f, -1.31044775e-01f, -1.65001559e-03f, -7.07225725e-02f, -1.01934761e-01f,
  -4.46577109e-02f, -5.33326678e-02f, -3.69644389e-02f, 9.11824107e-02f, -2.07270801e-01f, 7.51939788e-02f, 1.04572214e-02f, 1.96944743e-01f, 4.07606130e-03f, -9.48868170e-02f,
  6.63899854e-02f, 2.97073238e-02f, -1.38813600e-01f, 8.00037682e-02f, -1.03209708e-02f, 6.08946802e-03f, 3.93590331e-02f, -9.66597162e-03f, 1.49018625e-02f, -1.32150263e-01f,
  -1.47139961e-02f, 5.86796105e-02f, -7.13593215e-02f, -8.31050798e-02f, 4.58600819e-02f, -9.66416001e-02f, -2.02379394e-02f, 3.68735529e-02f, -5.26348576e-02f, -3.26088481e-02f,
  -1.61118835e-01f, 1.20949060e-01f, -8.99256021e-02f, -1.60692826e-01f, -2.10163686e-02f, 3.63356881e-02f, 3.54136750e-02f, 1.06956236e-01f, 2.77915075e-02f, -4.98812832e-02f,
  -3.14375050e-02f, 1.53667293e-02f, 1.40033245e-01f, 9.42517594e-02f, 1.57660142e-01f, -1.69229731e-01f, 8.95638689e-02f, 1.23587564e-01f, 1.49796620e-01f, 9.85141546e-02f,
  2.92313583e-02f, 3.28340717e-02f, 1.42935082e-01f, 2.27727392e-03f, 1.18763242e-02f, 1.79247096e-01f, -2.06908882e-01f, 1.34585962e-01f, 7.88410380e-02f, -4.55272272e-02f,
  -5.11432514e-02f, 6.06735460e-02f, 2.90824920e-02f, 3.20341513e-02f, 1.98003367e-01f, 1.04203761e-01f, -1.54492661e-01f, 1.02586143e-01f, 6.55055866e-02f, 1.57859817e-03f,
  2.82125585e-02f, -5.59753515e-02f, -1.16690621e-01f, 1.22033335e-01f, -6.61924556e-02f, 1.18204139e-01f, -5.82539216e-02f, -3.31482328e-02f, 6.41587377e-02f, -1.17494807e-01f,
  -9.34628397e-02f, 1.90656334e-01f, -1.29618004e-01f, -1.50625333e-01f, -2.92831864e-02f, 6.11830540e-02f, -7.56789818e-02f, 8.72846320e-02f, -1.97935868e-02f, 9.86093134e-02f,
  1.23643562e-01f, 8.74635875e-02f, 1.11723863e-01f, 1.37703225e-01f, -8.11710581e-02f, 1.50267212e-02f, -4.20634411e-02f, 1.27080023e-01f, 5.56070060e-02f, -5.56100458e-02f,
  -9.44617614e-02f, 6.66501522e-02f, -1.08281069e-01f, 1.58000991e-01f, -9.65805501e-02f, 8.23011622e-02f, 1.32709160e-01f, -2.09070936e-01f, -1.54244406e-02f, 2.12777138e-01f,
  -4.39056642e-02f, -1.26684800e-01f, -8.72424990e-02f, -1.08716570e-01f, 1.30060703e-01f, -4.07816842e-03f, -8.36145803e-02f, -3.43105905e-02f, -2.46508010e-02f, -8.92155245e-02f,
  -1.33415898e-02f, -1.31709903e-01f, 3.51549201e-02f, -3.83544080e-02f, 9.58840176e-02f, 8.77693444e-02f, 2.62645595e-02f, 1.12422265e-01f, 2.36837398e-02f, -1.02551058e-02f,
  -3.39073576e-02f, -1.60452560e-01f, 6.58895746e-02f, -5.59401466e-03f, -9.42418799e-02f, 9.31803584e-02f, 1.44598454e-01f, 1.19670667e-01f, 4.30975258e-02f, 1.11592554e-01f,
  -1.10156432e-01f, 1.04139395e-01f, -8.50173309e-02f, 2.70204768e-02f, -9.33506489e-02f, -5.28256148e-02f, -1.47017697e-02f, 7.05456510e-02f, 1.02174811e-01f, -1.30761623e-01f,
  3.68879735e-02f, 8.88806134e-02f, -1.02140971e-01f, 1.72457732e-02f, 5.11400700e-02f, 9.59907696e-02f, 2.72720754e-02f, -5.20094344e-03f, -8.37220475e-02f, 1.38770286e-02f,
  1.00176193e-01f, 9.40338895e-02f, 1.22566320e-01f, -1.70850623e-02f, -1.36602437e-02f, 4.44613509e-02f, 8.12981278e-03f, 9.61905941e-02f, 3.43594290e-02f, 7.87838697e-02f,
  3.73418555e-02f, 2.45217700e-03f, -5.15936688e-02f, -6.77054701e-03f, -7.14120865e-02f, -1.42871439e-01f, -1.58371609e-02f, -8.47472772e-02f, 1.07505713e-02f, 8.46158862e-02f,
  -9.41784214e-03f, 1.54680684e-01f, 5.62348887e-02f, 2.92170923e-02f, 5.77446744e-02f, -6.74214065e-02f, 4.66554128e-02f, 6.62297010e-02f, 5.31546101e-02f, -1.89630780e-02f,
  1.47633433e-01f, -8.02585036e-02f, 1.12461917e-01f, -4.49845605e-02f, -2.01597195e-02f, -1.72669142e-01f, -6.61214814e-02f, 1.08229101e-01f, -3.79604138e-02f, -2.04512373e-01f,
  5.45764901e-02f, -1.11145243e-01f, 1.55367464e-01f, 1.19421892e-01f, 8.40551928e-02f, -3.21686566e-02f, 1.11561380e-01f, -3.63224894e-02f, -8.40390995e-02f, -2.49600261e-02f,
  1.15433477e-01f, 5.91724180e-02f, 1.54189533e-02f, -2.43872367e-02f, -1.02097690e-01f, -3.95851098e-02f, 5.15150391e-02f, -1.21232562e-01f, -1.00959204e-01f, -4.67759147e-02f,
  -6.77721277e-02f, 5.46529517e-02f, -3.22911628e-02f, -2.74580419e-02f, -1.30574331e-01f, -8.96105170e-02f, 8.86643678e-02f, -5.18624298e-02f, -1.18777998e-01f, -1.45655116e-02f,
  7.87447914e-02f, -6.21659420e-02f, -1.14167921e-01f, 1.97576120e-01f, -2.03009299e-03f, -1.15360685e-01f, -1.44034237e-01f, 1.05162829e-01f, 1.20653808e-01f, -1.13159053e-01f,
  -1.32945910e-01f, 5.96010759e-02f, 3.90190422e-03f, -3.56883407e-02f, 1.52229583e-02f, 3.71892452e-02f, -2.61605326e-02f, -6.18508682e-02f, 1.37848943e-01f, -1.51264984e-02f,
  -4.27417606e-02f, 7.26092383e-02f, -7.62185827e-02f, -9.65815634e-02f, 8.74920264e-02f, 4.16610986e-02f, -5.86598553e-02f, 9.30275023e-02f, -5.38052581e-02f, -2.54612155e-02f,
  1.45478874e-01f, 5.50441332e-02f, -4.76004258e-02f, 5.08527197e-02f, -4.61133271e-02f, 1.34052858e-01f, -6.71539530e-02f, -6.16606176e-02f, -1.88570023e-02f, 7.12363923e-04f,
  -3.07668652e-02f, -7.86819384e-02f, 9.83117968e-02f, -1.66868474e-02f, 1.12058260e-02f, -7.77776614e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.77444756e-01f, 3.94004658e-02f, 1.51615128e-01f, -1.21355094e-02f, -9.41682681e-02f, -7.67167360e-02f, 1.00732103e-01f, 2.35016122e-02f, -9.34895054e-02f, 1.44403845e-01f,
  1.39236078e-01f, 2.72604916e-02f, -6.84021134e-03f, 3.19544524e-02f, -7.09793791e-02f, 7.55762607e-02f, 3.54527831e-02f, -3.54952551e-02f, -3.12066283e-02f, 1.43489903e-02f,
  1.39998235e-02f, 7.56146535e-02f, 2.09512576e-01f, -8.35932940e-02f, -1.20683528e-01f, -4.60613854e-02f, 5.23778982e-02f, -4.17345166e-02f, -1.32277071e-01f, 3.09271030e-02f,
  -9.29379240e-02f, 7.81667754e-02f, 9.93642434e-02f, -2.63162144e-03f, -5.09958193e-02f, -7.81289041e-02f, 4.49747033e-02f, 8.82441550e-03f, 1.18946411e-01f, 1.52743652e-01f,
  9.34664458e-02f, 9.80974808e-02f, 1.05930887e-01f, 1.03237264e-01f, 1.11565456e-01f, 6.83647813e-03f, 1.29927760e-02f, 5.54670803e-02f, 4.90748249e-02f, 3.68380994e-02f,
  4.23539802e-02f, -1.59046456e-01f, 1.11825489e-01f, 7.09944889e-02f, 8.74001682e-02f, 2.73830593e-02f, -3.61901149e-02f, -1.88335970e-01f, 8.57502297e-02f, -1.09750912e-01f,
  -6.80981055e-02f, 8.16477537e-02f, -4.84878905e-02f, 1.33368030e-01f, -2.18015742e-02f, 5.09080850e-02f, 3.88112776e-02f, 9.78901610e-02f, 6.91251084e-02f, 1.05030045e-01f,
  -9.63438228e-02f, 7.57639185e-02f, -3.38528380e-02f, -7.58241070e-03f, -1.11344084e-01f, -7.14154541e-02f, 9.07258615e-02f, 7.90258870e-02f, 2.27481835e-02f, 3.94276530e-03f,
  9.20950323e-02f, 6.56163469e-02f, -6.09531999e-02f, -9.48576406e-02f, 4.27430384e-02f, 1.00196645e-01f, 1.00252964e-01f, -3.76183987e-02f, 6.42760694e-02f, -2.71485038e-02f,
  -1.82584543e-02f, 3.97811234e-02f, 1.26928855e-02f, -1.15427300e-01f, 6.46633506e-02f, 4.29593660e-02f, 1.06200904e-01f, 1.21699482e-01f, -1.14513285e-01f, -7.15483725e-02f,
  7.78911784e-02f, -8.66322890e-02f, -4.37893383e-02f, -3.92842777e-02f, -3.47429849e-02f, -3.84545140e-02f, -1.10499114e-01f, -1.21822670e-01f, 5.53832874e-02f, -6.47617057e-02f,
  -4.22330275e-02f, -4.78979992e-03f, -5.53449020e-02f, 1.36365995e-01f, 2.50342228e-02f, -2.43398249e-02f, 8.64251778e-02f, 1.30396873e-01f, -5.04376553e-02f, -9.59204584e-02f,
  -8.21280703e-02f, 1.34955406e-01f, 4.07507420e-02f, 1.01995789e-01f, 8.58843252e-02f, -1.22260218e-02f, -9.19823796e-02f, 4.88190763e-02f, 7.54164532e-02f, -5.05671576e-02f,
  -6.60740584e-02f, 6.15695901e-02f, 4.00001667e-02f, 1.34755507e-01f, -1.60611011e-02f, 9.21754017e-02f, -1.99151114e-02f, -7.87473768e-02f, 7.05496296e-02f, 7.29453862e-02f,
  1.88558213e-02f, 7.40181794e-03f, 3.63045298e-02f, -9.39343497e-02f, 9.91281420e-02f, 1.02133192e-01f, 7.59425983e-02f, -2.09969040e-02f, 7.11173862e-02f, -6.12736642e-02f,
  -9.94916335e-02f, 1.88967120e-02f, 3.81736942e-02f, 5.42258359e-02f, -9.17619616e-02f, 1.60197765e-01f, -1.85381360e-02f, 1.18376680e-01f, -8.77722353e-02f, -1.38697982e-01f,
  -8.69792327e-02f, -1.31945759e-01f, -8.26324075e-02f, -5.31218387e-02f, -6.46982267e-02f, 1.24169722e-01f, 6.63707778e-02f, -9.91081968e-02f, -9.51165259e-02f, 4.83462103e-02f,
  1.91592257e-02f, 1.31011754e-01f, 1.15731381e-01f, -6.24433495e-02f, -2.20912397e-02f, -5.14600910e-02f, -4.52820361e-02f, -7.72327185e-02f, -1.12554558e-01f, 1.76496655e-01f,
  1.44821480e-01f, 1.47231117e-01f, -1.96136348e-02f, 3.10400669e-02f, 7.37038031e-02f, 1.21651612e-01f, 8.63846913e-02f, 1.21185623e-01f, 1.17738307e-01f, 1.94860145e-01f,
  -4.89494093e-02f, 8.50666612e-02f, -3.34030669e-03f, 1.58093244e-01f, -4.60460484e-02f, -1.35477688e-02f, 1.61467830e-03f, -2.79241260e-02f, 1.17743909e-01f, 1.42694503e-01f,
  2.15865046e-01f, 3.58062685e-02f, -4.71240841e-02f, -3.80087644e-02f, 1.06609903e-01f, 1.29642263e-01f, -8.09175223e-02f, 1.59182519e-01f, 9.64158997e-02f, -1.96574461e-02f,
  2.73294244e-02f, 4.20218594e-02f, -2.08378825e-02f, -2.24225476e-01f, -3.05573940e-01f, 1.06753014e-01f, -1.57390034e-03f, 1.31454349e-01f, 1.33030936e-02f, -4.13943119e-02f,
  -3.79189216e-02f, 1.41800538e-01f, 8.48189965e-02f, -8.40993449e-02f, -1.71859652e-01f, 7.61224255e-02f, -2.53329128e-02f, -1.03957169e-01f, 2.11160019e-01f, -4.81806174e-02f,
  -1.83087550e-02f, -1.99656747e-02f, 9.93439034e-02f, -2.13193074e-02f, 2.36923005e-02f, 1.51749644e-02f, 1.06215112e-01f, -7.74096847e-02f, -1.08891793e-01f, 1.29897594e-01f,
  6.35554045e-02f, -1.27346991e-02f, 2.04101220e-01f, 3.76753435e-02f, 9.09016505e-02f, 4.34237793e-02f, 4.25144173e-02f, -1.39217541e-01f, -8.48134011e-02f, 2.15806276e-01f,
  -2.53259577e-02f, 2.23097410e-02f, -4.14816774e-02f, -2.05492094e-01f, 1.02891810e-01f, -1.10342689e-01f, 2.27814868e-01f, 1.29711658e-01f, 3.61998752e-02f, 2.19774336e-01f,
  6.67502284e-02f, 9.88003761e-02f, 1.73087612e-01f, 1.25999600e-01f, 5.52724451e-02f, 2.71280646e-01f, 4.05534953e-02f, -1.20253004e-02f, 1.30085692e-01f, 9.98696834e-02f,
  1.27715811e-01f, 7.98538998e-02f, -3.41318431e-03f, 2.49685854e-01f, 7.44636208e-02f, 1.60297155e-01f, -2.86881447e-01f, 1.81954101e-01f, 3.26322407e-01f, -2.97306985e-01f,
  -1.50960147e-01f, 2.10351974e-01f, 2.49569893e-01f, -6.51137531e-02f, -8.24576095e-02f, -1.57277822e-01f, 1.31179631e-01f, -6.03672639e-02f, -4.06073086e-05f, 2.42139637e-01f,
  1.15447175e-02f, -2.27159485e-01f, 1.82402566e-01f, -3.74157637e-01f, -1.49040483e-02f, -5.07079400e-02f, 9.81814936e-02f, 1.22716337e-01f, 4.46065189e-03f, 7.76924938e-02f,
  3.21124434e-01f, 1.45681165e-02f, 1.39206260e-01f, -1.29054591e-01f, 1.12450264e-01f, 1.26740232e-01f, 2.47933343e-02f, 9.31898728e-02f, 1.43240646e-01f, -1.28568307e-01f,
  8.78291726e-02f, -7.52969533e-02f, 1.18863605e-01f, 1.70264482e-01f, -5.35551719e-02f, -1.29157126e-01f, -5.74972183e-02f, -1.31943047e-01f, -1.20485984e-01f, 7.31237978e-02f,
  1.27844036e-01f, 1.40643388e-01f, 1.20031439e-01f, 1.14965374e-02f, 1.22085281e-01f, 4.52577472e-02f, -4.46941257e-02f, 1.24523630e-02f, 1.54838756e-01f, 9.74177718e-02f,
  1.70051098e-01f, -9.48524699e-02f, 8.41218978e-02f, 1.15920760e-01f, 8.88763964e-02f, 4.38878685e-02f, 1.44576682e-02f, -7.32709542e-02f, 8.77677128e-02f, 4.23551388e-02f,
  6.25335202e-02f, 7.10639134e-02f, 2.40836330e-02f, -3.05043831e-02f, 2.19696425e-02f, 3.78490984e-02f, -6.09759167e-02f, -1.76819310e-01f, -8.05577859e-02f, 4.90362104e-03f,
  9.66403931e-02f, 1.25683695e-01f, -1.83894888e-01f, 1.31782189e-01f, -1.51295781e-01f, -1.86602026e-01f, 9.55468491e-02f, 9.44896266e-02f, 9.38282758e-02f, 8.86575654e-02f,
  -9.53541696e-02f, -1.03588626e-01f, 6.34016916e-02f, -9.30993333e-02f, 1.65658735e-03f, -1.80248152e-02f, 1.35907814e-01f, -3.68220396e-02f, -3.56864603e-03f, 4.81676236e-02f,
  2.59928945e-02f, -1.32821575e-02f, 3.38031072e-03f, 1.76549349e-02f, 4.90205362e-02f, 3.81232500e-02f, 1.13341734e-01f, -6.83682784e-02f, -3.01945899e-02f, 2.85984334e-02f,
  5.43506444e-02f, -3.27482745e-02f, -2.84076612e-02f, 8.19027871e-02f, -9.55106318e-03f, 1.44981139e-03f, 1.98253505e-02f, 1.32704109e-01f, 4.79164086e-02f, 1.03747860e-01f,
  9.74263400e-02f, 2.03506202e-02f, -9.07035246e-02f, 9.26569626e-02f, -4.55553010e-02f, 8.81384313e-02f, 1.20254815e-01f, -7.10591674e-02f, 2.81683020e-02f, 1.02937236e-01f,
  -4.85631861e-02f, -3.03335171e-02f, 1.16071224e-01f, 9.92098525e-02f, -1.28667308e-02f, 1.03717521e-01f, 1.02713913e-01f, 4.77182604e-02f, -4.53405567e-02f, -1.10628285e-01f,
  5.16827963e-02f, -6.13538697e-02f, -2.81961262e-02f, 1.20764546e-01f, 1.22359246e-01f, -3.26291323e-02f, -9.09311324e-02f, -5.32552302e-02f, -9.81482863e-02f, 2.54727881e-02f,
  -4.20995876e-02f, -1.17541440e-01f, -1.30535051e-01f, -9.14475024e-02f, 1.03379697e-01f, 5.99457659e-02f, -1.32367179e-01f, -9.28022787e-02f, 8.03221986e-02f, -1.72291026e-02f,
  -9.02893767e-02f, 8.70492980e-02f, -1.13448001e-01f, -8.81052241e-02f, 1.38631985e-01f, 4.89951000e-02f, -1.43575639e-01f, 3.25195938e-02f, 4.61705998e-02f, -7.21556768e-02f,
  4.28801998e-02f, 9.19311307e-03f, 3.03943790e-02f, 1.37833819e-01f, 9.29963738e-02f, -1.07736722e-01f, 1.75069347e-02f, -2.39937026e-02f, 1.95219927e-02f, 8.95280764e-02f,
  1.18804000e-01f, 1.57573551e-01f, 7.15567842e-02f, 3.28307562e-02f, 5.47805019e-02f, 5.80685176e-02f, 4.13727714e-03f, 1.02057569e-01f, 2.61095226e-01f, -1.59684822e-01f,
  -7.54618272e-02f, 1.71422452e-01f, 8.98622870e-02f, 7.50897080e-02f, 1.91149935e-02f, -1.54786380e-02f, 1.22563958e-01f, 1.53862104e-01f, -6.68500885e-02f, 1.25163943e-02f,
  7.32437745e-02f, -2.64132887e-01f, -1.52948290e-01f, -1.33156637e-02f, 1.61618277e-01f, -2.89044321e-01f, -1.83265790e-01f, -2.32650280e-01f, -2.73159593e-01f, 1.49753109e-01f,
  6.01179413e-02f, 1.52870804e-01f, 1.03904307e-01f, -2.51179188e-01f, 1.49039641e-01f, -1.65204361e-01f, 4.72828411e-02f, 1.56340808e-01f, 1.25866368e-01f, -6.88480809e-02f,
  1.59461200e-01f, 1.37630031e-01f, -8.42053294e-02f, -9.43163261e-02f, 2.35752970e-01f, -1.39493123e-01f, 2.26913154e-01f, 4.08680625e-02f, -1.22051328e-01f, -1.26444325e-01f,
  2.20133945e-01f, -2.73913071e-02f, 5.58224767e-02f, -5.83690926e-02f, 2.03575147e-03f, -5.93200065e-02f, -3.37246284e-02f, -1.78549308e-02f, -1.75642390e-02f, -5.10503836e-02f,
  1.15482643e-01f, 2.32188150e-01f, -1.35850627e-02f, -6.63972870e-02f, 2.86843255e-02f, 3.33744660e-02f, 2.15944350e-02f, 4.05155942e-02f, 1.43241107e-01f, 1.17406987e-01f,
  1.48453163e-02f, -5.88949583e-02f, 5.73287085e-02f, 1.10532366e-01f, 6.62484542e-02f, -1.52736073e-02f, 8.65848362e-02f, 1.42905489e-01f, -3.76561619e-02f, 3.59319672e-02f,
  -6.04823008e-02f, -9.43466499e-02f, 2.62034908e-02f, -2.06418604e-01f, -1.72167957e-01f, 6.33653924e-02f, 1.38482049e-01f, -1.07305549e-01f, -6.95429370e-02f, 1.33380726e-01f,
  1.86257303e-01f, 8.79611596e-02f, -1.58694401e-01f, -1.21936481e-02f, -1.16953090e-01f, -1.01560792e-02f, -1.83117278e-02f, 5.22562675e-02f, -1.18074514e-01f, 7.86255971e-02f,
  -2.82177459e-02f, 8.36659074e-02f, 9.06912312e-02f, -8.98126587e-02f, -1.02747142e-01f, 6.21213429e-02f, 9.54380482e-02f, -1.06753334e-01f, 3.86365578e-02f, 1.80529386e-01f,
  3.14836949e-02f, -8.14908817e-02f, 1.44042060e-01f, -8.26156959e-02f, -4.08059172e-03f, 5.08857369e-02f, -5.96576482e-02f, -3.78456409e-03f, -8.63208845e-02f, -6.43234849e-02f,
  -1.29544258e-01f, 1.19819611e-01f, 1.35128498e-01f, 1.06683224e-01f, -5.90926930e-02f, -9.44916382e-02f, -1.00558139e-01f, -1.07617490e-01f, -5.37628382e-02f, 4.10673618e-02f,
  3.15677226e-02f, 4.28890847e-02f, -3.30088325e-02f, -1.13375112e-01f, 1.19497076e-01f, -1.07426442e-01f, 1.98496599e-02f, 1.14608333e-01f, 7.02763647e-02f, 7.74107873e-03f,
  -2.94005368e-02f, -3.01681422e-02f, -9.49140713e-02f, -1.14996903e-01f, 5.32709472e-02f, 7.39186108e-02f, 1.12328552e-01f, 4.37087640e-02f, -8.65296498e-02f, 3.53946462e-02f,
  -1.08386546e-01f, -1.22246765e-01f, 6.02996871e-02f, -3.38175893e-02f, 1.10901877e-01f, -9.04244035e-02f, -6.78021237e-02f, -7.77776614e-02f, -9.31913555e-02f, -6.71418160e-02f,
  8.97304863e-02f, 2.43986752e-02f, 1.39964610e-01f, 3.95210274e-03f, -5.59385829e-02f, -1.05417706e-01f, 1.37499105e-02f, -8.72284845e-02f, 9.55062285e-02f, 8.57416466e-02f,
  -3.18395309e-02f, -3.57177220e-02f, -2.55920645e-02f, -1.73556190e-02f, 1.23588689e-01f, -3.80151272e-02f, 1.36544093e-01f, 1.00790806e-01f, -2.48364732e-02f, 3.47292759e-02f,
  -5.89283183e-02f, 7.07125291e-02f, 1.20475098e-01f, -6.44105822e-02f, 6.50739372e-02f, -1.02614962e-01f, 4.80282828e-02f, 1.03938498e-01f, -8.43746290e-02f, -8.69074464e-03f,
  -3.60153951e-02f, 5.72272576e-02f, 7.12052137e-02f, -1.24134511e-01f, 1.22079380e-01f, -6.67120814e-02f, -6.07319400e-02f, -7.18346387e-02f, 9.08213481e-02f, -8.33158791e-02f,
  1.36636436e-01f, 1.55689279e-02f, 6.92784712e-02f, -8.55324417e-02f, 1.07715033e-01f, 5.00926673e-02f, 1.22702554e-01f, 7.10542351e-02f, 8.21519196e-02f, 4.43458417e-03f,
  -1.70486137e-01f, -3.10201403e-02f, 1.95064977e-01f, 9.28091630e-02f, -3.74006964e-02f, -6.69132471e-02f, -9.00880694e-02f, -5.94577566e-02f, -1.37651116e-01f, 1.95819121e-02f,
  -1.19152114e-01f, -4.56514359e-02f, 4.46153283e-02f, 6.66988492e-02f, -1.22266218e-01f, -4.09078263e-02f, -1.19401030e-01f, 6.98458925e-02f, -2.68845782e-02f, -1.46474671e-02f,
  -2.46193726e-02f, 2.19820980e-02f, 1.42133161e-01f, -6.54001161e-02f, 1.22946776e-01f, 8.71199891e-02f, 8.91527161e-02f, -4.72180806e-02f, 2.93825418e-02f, -8.88114944e-02f,
  -9.37957168e-02f, -1.53703457e-02f, -5.45224547e-02f, -2.00569071e-02f, 8.58065039e-02f, -1.44793699e-02f, -9.48954746e-02f, -1.52439132e-01f, -3.74069661e-02f, -3.37475836e-02f,
  7.34553486e-02f, 4.57954220e-02f, -6.16863780e-02f, 4.22278717e-02f, 6.26998544e-02f, 1.04704708e-01f, 1.96013182e-01f, 2.25007534e-01f, 2.91016668e-01f, 7.26959258e-02f,
  3.43641713e-02f, 1.28480285e-01f, 1.20891571e-01f, 2.84526646e-01f, 3.13706733e-02f, 3.08133662e-01f, 1.32340267e-01f, 4.95567918e-02f, 1.70094401e-01f, 2.01589484e-02f,
  2.25115791e-01f, 1.99949309e-01f, 1.59221798e-01f, 8.16144943e-02f, -2.41289705e-01f, -8.79913494e-02f, 7.07046613e-02f, 7.96491802e-02f, 8.72070491e-02f, 1.23284325e-01f,
  3.08780193e-01f, 3.07133198e-01f, -1.56640574e-01f, 1.98193297e-01f, 2.98477173e-01f, -3.26022476e-01f, 1.88641042e-01f, -1.92739780e-03f, -8.86771902e-02f, 1.26973331e-01f,
  -1.15021259e-01f, -1.39572024e-01f, -8.75980854e-02f, -9.36260968e-02f, 7.71642178e-02f, 9.98213291e-02f, -1.50092514e-02f, 1.72899514e-02f, 5.45143664e-01f, 9.61583033e-02f,
  3.78072895e-02f, -2.11891346e-02f, -7.32136741e-02f, 2.80596554e-01f, -2.48451129e-01f, 2.80734241e-01f, 1.41541809e-01f, -2.68672444e-02f, -2.79616743e-01f, -6.89888597e-02f,
  1.27389252e-01f, 1.53970957e-01f, -4.82631214e-02f, -1.86142419e-02f, -1.16263390e-01f, 6.79135025e-02f, -2.39946753e-01f, -9.04675648e-02f, 1.46865577e-01f, 9.10445303e-02f,
  1.12230144e-01f, 1.38061456e-02f, 1.59038559e-01f, 9.16285533e-03f, 7.21944943e-02f, 2.88621243e-02f, 1.10925138e-02f, 1.21019214e-01f, -4.74786572e-03f, 9.80544090e-02f,
  -8.22101235e-02f, -1.45759182e-02f, -3.95209789e-02f, -7.09199533e-02f, -8.47619213e-03f, -9.12183374e-02f, -2.17356011e-02f, -1.00609653e-01f, 5.21118604e-02f, 2.00727358e-02f,
  -6.24591345e-03f, 3.57008390e-02f, -3.26778963e-02f, -2.09420938e-02f, -5.24603166e-02f, -6.39441982e-02f, -3.60139506e-03f, 8.86641294e-02f, -1.11824811e-01f, 2.42335200e-02f,
  9.24131460e-03f, 8.01921412e-02f, -1.35742143e-01f, -7.23348334e-02f, 8.74368176e-02f, -4.48620841e-02f, -2.18351595e-02f, -1.17047571e-01f, 2.89684962e-02f, -4.33939584e-02f,
  9.83179957e-02f, -1.23674311e-01f, 2.92972885e-02f, 6.53959513e-02f, 6.48074597e-02f, 1.26186430e-01f, 9.34756398e-02f, -5.00416756e-02f, 1.32631034e-01f, 7.29295164e-02f,
  3.59151250e-04f, -9.97445211e-02f, 1.79797381e-01f, -1.27559215e-01f, -6.85079917e-02f, 1.36224508e-01f, 9.91108865e-02f, 8.35383311e-03f, -9.90146250e-02f, 7.81246945e-02f,
  1.29416764e-01f, -7.48597682e-02f, -4.03065309e-02f, 1.66483715e-01f, -6.81754425e-02f, 8.34041685e-02f, 1.10901833e-01f, 7.48563930e-02f, -6.76809102e-02f, 1.57491431e-01f,
  1.22955620e-01f, 6.26502484e-02f, 1.21695241e-02f, 1.83186188e-01f, 5.35072871e-02f, 1.77305356e-01f, 1.11004636e-01f, 1.42809093e-01f, 4.51382957e-02f, 2.42723543e-02f,
  -3.23223099e-02f, 9.72704813e-02f, 7.87997693e-02f, -2.10425735e-01f, -3.15437578e-02f, 1.30373180e-01f, -8.27657431e-02f, 3.99297513e-02f, 1.50321886e-01f, 1.73206583e-01f,
  -6.11882098e-02f, -2.14013495e-02f, 1.75000757e-01f, -1.48327231e-01f, -1.15073226e-01f, 7.46100768e-02f, -4.17062305e-02f, -1.48157373e-01f, 6.71351776e-02f, 9.54732373e-02f,
  -4.73218858e-02f, 5.68944216e-02f, 5.36841638e-02f, -1.11212648e-01f, -4.57100645e-02f, -9.54929739e-02f, 6.60429662e-03f, -1.51272044e-02f, -1.60169885e-01f, 1.74041882e-01f,
  7.29325339e-02f, 1.73938423e-01f, 9.46381837e-02f, 2.29884177e-01f, -1.33946225e-01f, 5.40023446e-02f, -5.67164347e-02f, 5.08778282e-02f, -1.82391740e-02f, 1.15351066e-01f,
  -1.32038549e-01f, 1.74148202e-01f, 8.20937678e-02f, 1.14616416e-01f, -1.37835667e-01f, -7.77932629e-02f, 6.24263659e-02f, 5.43004163e-02f, 9.67997909e-02f, -5.99785261e-02f,
  -3.85386497e-02f, 3.87857109e-02f, 1.42362520e-01f, 1.66921001e-02f, 8.72861296e-02f, -2.00895574e-02f, -5.13164699e-02f, -9.01341364e-02f, -1.37669891e-01f, 1.05635196e-01f,
  -1.70961320e-02f, 7.15490729e-02f, -4.72149253e-02f, 9.80184674e-02f, 1.96668301e-02f, -1.62146285e-01f, -9.64849442e-02f, -1.25922281e-02f, -3.55274267e-02f, -4.58078049e-02f,
  1.20655634e-01f, -1.94582753e-02f, 1.20832644e-01f, 6.39819354e-02f, -1.11734293e-01f, 5.25360182e-03f, 2.90373880e-02f, -1.68242797e-01f, -8.23928416e-02f, -1.22030884e-01f,
  -4.25918847e-02f, 8.38057846e-02f, 8.35377648e-02f, 7.99906626e-02f, 2.40987539e-02f, -7.69587308e-02f, 9.14865080e-03f, 1.30637184e-01f, -1.08719848e-01f, 7.16096386e-02f,
  2.43264679e-02f, 1.65308923e-01f, -9.55970660e-02f, 2.38642305e-01f, 1.20484613e-01f, 1.01064675e-01f, -2.65960693e-02f, 9.86245796e-02f, -4.03300747e-02f, 1.24676868e-01f,
  4.23509106e-02f, 6.08193874e-02f, 1.48093313e-01f, -5.79297952e-02f, -2.47106906e-02f, 1.08149797e-01f, 1.77374661e-01f, 2.96699286e-01f, 5.31344116e-03f, -1.97874904e-02f,
  3.93984914e-02f, 2.27948725e-02f, 1.48236960e-01f, 4.96071242e-02f, 1.54122412e-01f, 1.30188674e-01f, 5.81924766e-02f, 1.15588635e-01f, 4.53369580e-02f, 4.24209097e-03f,
  1.94116235e-02f, -1.06906483e-03f, 1.29779890e-01f, 1.55976430e-01f, 1.91251561e-01f, 5.40444963e-02f, -1.70825720e-01f, -1.49866000e-01f, 8.00034404e-02f, -7.26846382e-02f,
  3.04746237e-02f, 1.31843105e-01f, 1.32335052e-01f, -7.89027140e-02f, -1.02907732e-01f, -5.57503290e-02f, 1.63231999e-01f, -2.14339703e-01f, -2.20781237e-01f, 4.74953884e-03f,
  1.30733117e-01f, 1.65940985e-01f, -2.08890945e-01f, 1.29813869e-02f, -5.93712889e-02f, -2.00624451e-01f, 2.51178324e-01f, 1.15799710e-01f, 6.22534193e-02f, 7.19403625e-02f,
  -1.38286754e-01f, 4.16552201e-02f, 2.69581601e-02f, -6.67167678e-02f, -1.36043921e-01f, -2.63703265e-03f, 9.19922143e-02f, 1.59633815e-01f, 9.16244984e-02f, -4.76683713e-02f,
  1.34924382e-01f, 3.98104303e-02f, -2.24965021e-01f, -1.56181261e-01f, 2.87553638e-01f, 7.98573419e-02f, -1.20500363e-01f, -8.72845575e-02f, 1.52602582e-03f, 7.00207893e-03f,
  -1.07075997e-01f, 1.32656917e-01f, 2.13360846e-01f, 4.82912101e-02f, 1.68690369e-01f, 2.32786193e-01f, 5.98774105e-02f, 6.96246848e-02f, -2.38725590e-03f, 2.09097750e-02f,
  3.75347137e-02f, 1.34204030e-01f, 1.43847004e-01f, 1.63689479e-01f, 1.56459481e-01f, 8.08029994e-02f, 1.03786163e-01f, 2.13971019e-01f, 6.72486722e-02f, 1.79669529e-01f,
  -1.30729496e-01f, 4.78859432e-02f, 1.79746181e-01f, 1.93932220e-01f, 3.27935219e-02f, -1.41566500e-01f, -1.52885661e-01f, -4.95825335e-02f, -9.88903046e-02f, 1.75094232e-01f,
  9.67915207e-02f, -2.12997362e-01f, -2.13785619e-01f, 1.30680874e-01f, 4.95987609e-02f, 1.75687328e-01f, -1.64563924e-01f, 3.44845802e-02f, -1.25783384e-01f, -2.82133698e-01f,
  3.54435444e-01f, -1.03009157e-01f, 1.25554893e-02f, -2.99481228e-02f, 3.16777825e-03f, 3.52840610e-02f, 2.25302223e-02f, 4.51788626e-04f, -1.00022346e-01f, -1.86969712e-01f,
  -7.21210986e-02f, 9.54584852e-02f, -1.15058130e-04f, 9.43768471e-02f, 1.56528026e-01f, 6.23013414e-02f, -1.82528704e-01f, -7.05364048e-02f, 2.68981993e-01f, -6.69798702e-02f,
  -1.72612146e-01f, 4.11756188e-02f, -1.52055264e-01f, 1.67664990e-03f, -7.77922869e-02f, -1.07101962e-01f, 6.43794835e-02f, 1.22845158e-01f, 1.45627961e-01f, -2.28030831e-02f,
  -8.12175870e-02f, 1.00247338e-01f, -4.45888080e-02f, -6.48667365e-02f, 5.30829430e-02f, 6.71015531e-02f, -1.11562433e-02f, -6.27287999e-02f, -4.23866473e-02f, -1.13458455e-01f,
  2.24140519e-03f, 2.35345531e-02f, -4.94063012e-02f, 1.41341522e-01f, 1.07127130e-01f, 1.60956699e-02f, 1.38580292e-01f, 3.58038358e-02f, 1.04396299e-01f, -3.41796912e-02f,
  2.22939983e-04f, 1.42526120e-01f, -1.85109526e-02f, -7.40786716e-02f, -1.10197224e-01f, -2.92787459e-02f, 1.58608809e-01f, 1.49987042e-01f, -1.55656919e-01f, 1.11349644e-02f,
  4.13292237e-02f, -5.91666326e-02f, -4.55080457e-02f, -8.22798312e-02f, -1.14409856e-01f, -2.26944350e-02f, -5.61873354e-02f, 8.33650455e-02f, 4.29719724e-02f, -9.64849442e-02f,
  8.30289572e-02f, 8.65900889e-03f, -1.15498423e-03f, -1.04187250e-01f, -6.39242902e-02f, 2.59586889e-02f, 7.50812143e-02f, -4.93391268e-02f, 1.96163133e-01f, 1.00675076e-01f,
  4.41522785e-02f, 6.63214549e-03f, 1.11671522e-01f, -2.90619079e-02f, 9.29815173e-02f, -6.60132989e-02f, -1.85307153e-02f, 8.03337097e-02f, -8.83557741e-03f, 1.10426530e-01f,
  1.58847362e-01f, -2.12157648e-02f, 1.00287057e-01f, -5.66318072e-02f, 8.30192864e-03f, -1.37743559e-02f, 2.56968178e-02f, 1.40109032e-01f, 1.28007159e-01f, 4.87135909e-02f,
  -4.54738475e-02f, -2.36050934e-02f, 3.87110375e-02f, 1.71531230e-01f, -3.72993425e-02f, -8.75313208e-02f, 5.05877770e-02f, 1.54182250e-02f, 4.35957164e-02f, -3.82145308e-02f,
  1.26520127e-01f, 9.91220698e-02f, -4.40062247e-02f, 1.15876794e-01f, -1.21775433e-01f, 2.00976394e-02f, 3.59184705e-02f, -1.41022816e-01f, -8.95725191e-02f, 1.11262657e-01f,
  1.06678575e-01f, 6.42454624e-02f, 1.17992572e-01f, -8.05823877e-03f, 4.28737886e-02f, -9.05858427e-02f, -1.58920009e-02f, -7.63534978e-02f, -3.27153737e-03f, 5.08259833e-02f,
  8.09344873e-02f, -2.01123953e-02f, 5.28366044e-02f, 5.27319312e-02f, -8.65712687e-02f, 2.27258876e-02f, 5.52816615e-02f, 3.12990770e-02f, -6.02310188e-02f, 7.92018026e-02f,
  -8.98034796e-02f, -6.15742654e-02f, 8.06902722e-02f, -8.77258033e-02f, -3.18446867e-02f, -8.95251427e-03f, 1.15659432e-02f, 9.50674564e-02f, -1.24180309e-01f, -1.34873837e-02f,
  -3.99287641e-02f, 1.26308396e-01f, -2.41730809e-02f, -1.02566175e-01f, 7.98477307e-02f, 8.97176564e-02f, -4.27375548e-02f, -7.24919699e-03f, 5.38631789e-02f, -1.51976226e-02f,
  8.93361643e-02f, 1.30886987e-01f, -2.70941183e-02f, 2.97643002e-02f, 1.63623735e-01f, 1.08668068e-02f, 1.05744107e-02f, 9.52540860e-02f, -5.22829816e-02f, 9.02454183e-02f,
  6.46153688e-02f, -7.45514780e-02f, 1.07012495e-01f, 2.01482717e-02f, 4.96311411e-02f, 1.72144860e-01f, 2.58005727e-02f, 3.55752446e-02f, -2.81968623e-01f, 2.04176068e-01f,
  7.55361989e-02f, -1.00634657e-01f, -1.79533660e-01f, 5.23632318e-02f, -4.06849869e-02f, 2.89646480e-02f, -1.73415765e-01f, 3.15301083e-02f, -3.28956954e-02f, -2.15680256e-01f,
  4.55943458e-02f, -1.43263727e-01f, 6.87072650e-02f, 1.17674790e-01f, 1.06008753e-01f, 1.16455041e-01f, 2.52204295e-02f, -6.34405389e-02f, 1.38491109e-01f, 7.15861470e-02f,
  9.03598499e-03f, -1.12531647e-01f, 1.11644492e-01f, 1.65651992e-01f, -1.11179136e-01f, -3.28885764e-02f, 9.66776386e-02f, -2.77419351e-02f, -5.08865118e-02f, 9.26874280e-02f,
  1.73648924e-01f, -7.93470591e-02f, -6.77297860e-02f, -8.91359374e-02f, -3.59684117e-02f, 3.67665552e-02f, 1.10165119e-01f, 1.03306822e-01f, 2.45505236e-02f, -9.47129875e-02f,
  1.10617965e-01f, -1.13748917e-02f, 9.03271735e-02f, 7.56217539e-02f, -6.98530525e-02f, 6.60611317e-02f, -7.86488801e-02f, -6.35102466e-02f, 2.13170657e-03f, 9.04103555e-03f,
  -9.27723497e-02f, 5.12263440e-02f, -8.82230606e-03f, 8.88804942e-02f, 1.18456021e-01f, 1.18231393e-01f, 1.25482082e-01f, 1.13691695e-01f, -2.88184807e-02f, -1.14104837e-01f,
  -9.54418108e-02f, -4.21972573e-02f, 8.70411769e-02f, 4.15054634e-02f, -1.27066046e-01f, -1.22630700e-01f, 4.42839116e-02f, -2.24232450e-02f, 6.43889382e-02f, 7.92993531e-02f,
  -8.86863992e-02f, 8.34590103e-03f, 1.17082052e-01f, -4.14541066e-02f, 6.52935654e-02f, -4.91223671e-02f, -1.75576247e-02f, -3.00405268e-02f, 6.48188740e-02f, 3.33735757e-02f,
  7.11866468e-02f, 7.32223019e-02f, 1.43870153e-03f, -2.13806406e-02f, -5.43870181e-02f, 1.34417742e-01f, -1.57384668e-02f, -1.08663430e-02f, 1.35541916e-01f, 3.41820940e-02f,
  -6.31782189e-02f, 1.02477511e-02f, -3.37837962e-03f, -5.76979294e-02f, -8.45937133e-02f, 1.49519881e-02f, -5.31794205e-02f, -1.34945244e-01f, 1.35681018e-01f, -2.43372582e-02f,
  1.96741857e-02f, -8.59356150e-02f, -1.00548640e-01f, 5.43882027e-02f, 1.01870455e-01f, 2.52591103e-01f, 4.50591519e-02f, 1.65516973e-01f, 1.03238419e-01f, 2.11702138e-01f,
  2.22392511e-02f, 7.78979436e-02f, 2.91463375e-01f, 1.84456170e-01f, 8.54474083e-02f, 8.76425207e-02f, 2.57148951e-01f, 7.77951404e-02f, 6.00397624e-02f, 1.82611942e-01f,
  1.76176310e-01f, -8.41921344e-02f, 9.63812023e-02f, 2.31204093e-01f, 2.30630189e-01f, -3.38361979e-01f, -4.76398736e-01f, 2.23933712e-01f, -3.73268835e-02f, 6.65459409e-02f,
  -2.00644121e-01f, -7.42537305e-02f, 2.01779410e-01f, 8.69514048e-02f, -1.81177616e-01f, 1.03293791e-01f, -1.20881893e-01f, -2.49495208e-01f, 2.36300360e-02f, -1.86481521e-01f,
  1.97080031e-01f, 2.15837345e-01f, 8.91980901e-02f, -1.12137705e-01f, 5.91259040e-02f, 5.49604222e-02f, -1.27210796e-01f, -7.11144358e-02f, 5.81683815e-02f, -2.67877936e-01f,
  8.62653032e-02f, -2.38404470e-03f, -1.25521332e-01f, 1.87340528e-02f, 1.36405230e-01f, -5.04233614e-02f, 1.32205918e-01f, -6.86945319e-02f, 1.35529950e-01f, -1.12015441e-01f,
  -1.12624817e-01f, 2.94098049e-01f, -3.30041461e-02f, 2.62210011e-01f, 1.76849857e-01f, -5.41801341e-02f, 1.63035482e-01f, -5.39879240e-02f, -3.24142240e-02f, 1.27151102e-01f,
  4.62379716e-02f, 1.39237404e-01f, 2.64954902e-02f, 1.58844918e-01f, 1.47532538e-01f, 4.32615075e-03f, 1.84717491e-01f, 2.79606152e-02f, 6.32454827e-02f, 1.18747428e-01f,
  1.25483751e-01f, 1.32847294e-01f, -5.50540797e-02f, 4.71702926e-02f, -6.00671731e-02f, 1.82895094e-01f, -8.06638226e-03f, 5.50328083e-02f, 2.36607119e-02f, 2.51006000e-02f,
  -6.28418028e-02f, -2.04923525e-01f, -1.25541627e-01f, 4.27285992e-02f, 1.00420669e-01f, -4.93284203e-02f, -1.16649047e-01f, -7.29230866e-02f, -2.04493441e-02f, -5.86265698e-03f,
  -7.75195062e-02f, -6.18863292e-02f, -1.22065805e-01f, -2.65101373e-01f, 2.08213061e-01f, -6.49595484e-02f, -8.94975569e-03f, 1.95858534e-02f, 1.66734364e-02f, -1.99226779e-03f,
  -2.51744129e-02f, 6.03344925e-02f, -5.19258492e-02f, 3.41858603e-02f, 1.10704683e-01f, 5.33526391e-02f, 1.29695490e-01f, -5.23837246e-02f, -5.58912940e-02f, -1.94874220e-02f,
  -3.19070071e-02f, -5.24121337e-02f, -5.31455800e-02f, 3.64735983e-02f, 1.03431866e-01f, -3.04474365e-02f, -6.73651844e-02f, 7.71469623e-02f, 4.13437523e-02f, 1.51113058e-02f,
  -8.85785297e-02f, 6.08655289e-02f, 4.60701846e-02f, 2.28451118e-02f, 5.31131290e-02f, -3.74210849e-02f, -5.06354310e-02f, 1.26659468e-01f, 1.21434011e-01f, 6.91179000e-03f,
  -2.40674615e-02f, 8.11264515e-02f, 6.58369511e-02f, -1.55790150e-01f, -1.17667213e-01f, 3.10190730e-02f, 1.57434102e-02f, -3.40037867e-02f, 1.07453845e-01f, -1.10527642e-01f,
  1.41507670e-01f, 9.47475806e-03f, -6.45362660e-02f, 1.30256293e-02f, -5.98645536e-03f, 1.03444368e-01f, -1.00123547e-01f, -6.18647709e-02f, -6.61449432e-02f, 4.39613778e-03f,
  -5.14273420e-02f, -9.73958820e-02f, -2.06161886e-01f, 1.26069680e-01f, -2.81263459e-02f, -7.53500089e-02f, 1.14364460e-01f, -1.41568884e-01f, 1.42367423e-01f, 1.10106044e-01f,
  3.04971877e-02f, -8.21223632e-02f, 9.22351107e-02f, -3.06692421e-02f, -6.26699924e-02f, 1.72217235e-01f, -1.71467022e-03f, 9.38579217e-02f, 2.08672613e-01f, -8.25995579e-02f,
  -7.24108815e-02f, -1.17484763e-01f, 4.59279716e-02f, 3.38882878e-02f, 1.63928315e-01f, -1.98445637e-02f, 9.45366770e-02f, 1.06982984e-01f, 5.08588413e-03f, -4.92616510e-03f,
  7.88809806e-02f, 6.52697533e-02f, 1.42266273e-01f, -5.40912561e-02f, 1.45527944e-01f, -1.25788599e-02f, -9.19938162e-02f, 1.13441139e-01f, -8.09139684e-02f, 2.46870145e-02f,
  -6.00880459e-02f, 4.61414456e-02f, 7.14919865e-02f, 4.36224006e-02f, -7.73726553e-02f, -1.94074176e-02f, -9.75451618e-02f, 1.10984467e-01f, 1.34832203e-01f, -7.75480270e-02f,
  -9.56689939e-02f, 4.57786918e-02f, -9.56036225e-02f, -8.93024355e-02f, 7.66485408e-02f, -1.35437995e-02f, -2.76543237e-02f, -1.19032733e-01f, 9.09280106e-02f, 2.12385748e-02f,
  -5.57480045e-02f, -3.01609263e-02f, 3.75152975e-02f, 8.76408815e-02f, 3.12763043e-02f, -1.01606429e-01f, -9.61301178e-02f, -3.99983972e-02f, -7.76457712e-02f, 6.89830929e-02f,
  1.06571198e-01f, -2.66688764e-02f, -1.06031522e-01f, 1.59871392e-02f, 1.14037827e-01f, -1.05878823e-01f, 1.08615592e-01f, 1.82722136e-02f, -1.64542105e-02f, -9.40251201e-02f,
  -7.66503066e-02f, -4.79873568e-02f, -1.09401233e-01f, -7.04839975e-02f, -5.61339594e-02f, -5.75987361e-02f, 4.92389500e-02f, 1.19901277e-01f, -1.06143311e-01f, -1.83222853e-02f,
  9.04933289e-02f, 4.77140322e-02f, -5.12271151e-02f, 1.21282816e-01f, 2.51948908e-02f, -4.41627391e-02f, 1.89495143e-02f, 2.15633009e-02f, -9.57706347e-02f, 1.19022779e-01f,
  2.20215116e-02f, 5.05124778e-03f, 3.55202369e-02f, 1.10955581e-01f, -1.41730746e-02f, -2.90226582e-02f, -1.91109069e-03f, 1.47656575e-01f, 5.93492165e-02f, 6.56374767e-02f,
  -2.20310949e-02f, 1.85232371e-01f, 1.12095974e-01f, 2.93415859e-02f, 3.98866236e-02f, 1.84315339e-01f, 1.29018411e-01f, 7.71839172e-02f, 6.60680681e-02f, -4.05279361e-02f,
  1.01445936e-01f, -1.50492996e-01f, -4.59471121e-02f, 1.54385537e-01f, 9.02219564e-02f, 1.20627224e-01f, -3.22174430e-02f, 1.12870403e-01f, -2.11123191e-02f, 8.41910392e-02f,
  8.43800530e-02f, -4.24790122e-02f, 6.25492409e-02f, -1.41903564e-01f, 6.71912953e-02f, 1.62324607e-01f, -1.49706244e-01f, 6.79492876e-02f, -1.12708159e-01f, -8.99978057e-02f,
  -2.56811045e-02f, 1.51265347e-02f, 1.09748304e-01f, 4.11634780e-02f, 2.12701365e-01f, 6.47687316e-02f, -1.91054028e-03f, 1.83129646e-02f, 5.02611287e-02f, -4.04046699e-02f,
  -1.02022670e-01f, 3.31108272e-02f, 3.08990460e-02f, 9.08440575e-02f, -2.92243510e-02f, 8.35022777e-02f, 6.59946799e-02f, 1.00520318e-02f, -2.94737564e-03f, 7.61949122e-02f,
  5.94154559e-02f, 1.15362257e-01f, -5.93750812e-02f, -4.50880565e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.03922375e-01f, -1.08044185e-01f, 4.36712354e-02f, -7.83158168e-02f, 9.46597159e-02f, 5.12833446e-02f, 6.21749274e-02f, 2.88266297e-02f, 8.74450803e-02f, 8.45352858e-02f,
  1.12042643e-01f, 1.99012280e-01f, -1.46799143e-02f, 1.60358787e-01f, 3.09254304e-02f, -5.54566691e-03f, 2.20629219e-02f, 7.05424324e-02f, 1.37653410e-01f, -8.04629119e-04f,
  -2.61052996e-02f, 3.00634075e-02f, 8.96092653e-02f, -8.00493136e-02f, 4.91643101e-02f, 1.30155534e-01f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  3.76122184e-02f, 5.01769558e-02f, 5.05475402e-02f, 1.73255473e-01f, 1.26012594e-01f, 9.59226266e-02f, -1.36842281e-02f, -1.33113563e-01f, -9.14213359e-02f, -1.06121182e-01f,
  6.85260743e-02f, 7.50403628e-02f, -7.36743957e-02f, -7.91785344e-02f, 4.94430661e-02f, 1.06224962e-01f, 2.93481648e-02f, 4.65558246e-02f, 1.10013876e-02f, -4.17858474e-02f,
  -1.66270544e-03f, 4.46584523e-02f, -9.38885063e-02f, 1.83025911e-01f, 2.56510794e-01f, -5.33278883e-02f, 6.09528124e-02f, -2.12312918e-02f, 3.62067111e-02f, 9.27441791e-02f,
  2.46318474e-01f, 9.27102193e-02f, 6.55309670e-03f, 1.73820406e-01f, -1.57169923e-01f, 5.89409173e-02f, 8.14471319e-02f, -1.55262008e-01f, -1.87227994e-01f, 5.52131087e-02f,
  -7.60535970e-02f, 2.19640687e-01f, -2.74931014e-01f, 2.95625627e-02f, 8.89118761e-02f, -1.05305202e-01f, 7.88177997e-02f, 7.58107007e-02f, -4.72520217e-02f, -1.15312472e-01f,
  -3.10909580e-02f, 1.15750328e-01f, -1.32417306e-01f, -2.00049043e-01f, 1.28175825e-01f, 1.37497917e-01f, -3.08556668e-02f, 1.85098067e-01f, -5.16936928e-02f, 2.97299623e-01f,
  9.46216136e-02f, -2.51320656e-02f, 1.09017659e-02f, -3.44590768e-02f, 1.39621884e-01f, 4.43816781e-02f, 2.65392959e-02f, 6.98079318e-02f, 1.38731465e-01f, 1.35194913e-01f,
  1.34359241e-01f, 6.73539415e-02f, 1.48538515e-01f, 1.18795201e-01f, 1.14729002e-01f, 1.21996470e-01f, 1.01515986e-01f, 2.56000669e-03f, 1.78430334e-01f, 1.60093784e-01f,
  6.20396510e-02f, 2.94669587e-02f, 5.66550344e-02f, 2.68544648e-02f, -1.14292763e-01f, -1.29089970e-02f, 4.46024500e-02f, -1.62214458e-01f, 1.64326295e-01f, -2.21748576e-02f,
  2.87878122e-02f, -2.17600465e-01f, 1.42089903e-01f, -9.93787870e-02f, 6.88850433e-02f, -3.17309946e-02f, 1.86889350e-01f, 1.95995212e-01f, 1.02630682e-01f, -8.83457139e-02f,
  5.96401133e-02f, -1.55959919e-01f, -1.00729808e-01f, -2.26634294e-02f, 9.92885828e-02f, 1.63281128e-01f, 2.98158620e-02f, 6.37020618e-02f, 5.43359667e-02f, -1.84255674e-01f,
  5.40839806e-02f, -6.73069134e-02f, -2.20724028e-02f, 2.23326087e-01f, 7.73142353e-02f, 1.54466242e-01f, -1.55934349e-01f, -1.77371308e-01f, 1.83776803e-02f, -3.36441360e-02f,
  -7.30206296e-02f, -2.74200197e-02f, -9.84963123e-03f, 1.05908506e-01f, -1.44238457e-01f, 3.00854025e-03f, -2.99741086e-02f, -8.61936435e-02f, -9.30408165e-02f, 2.74205692e-02f,
  -5.56739047e-02f, 2.36310326e-02f, -5.83695807e-02f, -1.78113312e-01f, -6.96578901e-03f, -4.63460572e-03f, -4.45079878e-02f, -9.03624222e-02f, -1.27046555e-01f, 4.95681316e-02f,
  1.07328147e-01f, -1.13476850e-01f, -1.38096914e-01f, -8.06526020e-02f, -5.07048555e-02f, -4.46628667e-02f, -1.56333894e-02f, 7.79955685e-02f, 1.45293817e-01f, 7.18132630e-02f,
  -5.44692054e-02f, 2.15319078e-02f, -3.09947059e-02f, -1.48249403e-01f, -2.28267327e-01f, -4.53119166e-02f, -4.00705114e-02f, 9.44966152e-02f, -2.39883915e-01f, 6.16484135e-02f,
  -1.96298346e-01f, -2.65358657e-01f, -9.95022953e-02f, 1.22455992e-01f, 1.29481032e-01f, 1.06542118e-01f, 1.57079875e-01f, 8.39332342e-02f, -3.36136878e-03f, -1.45605463e-03f,
  1.90337539e-01f, -1.04006687e-02f, -8.52481127e-02f, 1.74890086e-01f, -1.43264458e-01f, -6.05901331e-02f, 8.13985765e-02f, -5.74121885e-02f, 3.55758965e-02f, -8.27168077e-02f,
  2.46573947e-02f, 2.35523716e-01f, 2.11192206e-01f, 1.05792806e-01f, -5.39419726e-02f, -1.82133578e-02f, 8.94311592e-02f, -2.67090380e-01f, 1.33591071e-01f, -4.08315584e-02f,
  3.03638000e-02f, -2.01883316e-01f, 6.09129807e-03f, 6.08737068e-03f, 7.65286982e-02f, 1.27470165e-01f, 1.88361138e-01f, -2.77739076e-04f, 5.30164652e-02f, 1.49755210e-01f,
  4.88761254e-02f, -7.99020603e-02f, 2.62487531e-02f, 2.19350755e-02f, -3.45917493e-02f, -9.13861692e-02f, 1.60923079e-01f, -7.16664046e-02f, -3.42511535e-02f, -2.20359638e-02f,
  -1.32307351e-01f, 4.05730382e-02f, -1.43310167e-02f, 8.65803584e-02f, -2.32279003e-01f, 2.18257964e-01f, -1.35839775e-01f, -2.28777066e-01f, 8.36614743e-02f, 1.17541976e-01f,
  1.39910355e-01f, -1.27106294e-01f, 1.21814668e-01f, 1.69594437e-02f, 1.49929628e-01f, 2.43639313e-02f, -1.35919765e-01f, -4.07082066e-02f, -3.88229429e-03f, 6.59461075e-04f,
  5.59602585e-03f, -6.17164820e-02f, 7.35587552e-02f, 7.86823109e-02f, -1.09290637e-01f, 1.69258695e-02f, 2.54355930e-02f, -6.45744130e-02f, 1.56909406e-01f, -6.54533058e-02f,
  -2.01328914e-03f, -2.48354390e-01f, 7.22168609e-02f, 7.56233260e-02f, 6.98143709e-03f, 2.22413436e-01f, 1.52618527e-01f, 4.90889736e-02f, 1.23310618e-01f, 1.34525612e-01f,
  -1.04965515e-01f, 2.21666381e-01f, -1.60438381e-02f, 3.21839750e-02f, -7.51557294e-04f, 9.71691683e-02f, -4.67665829e-02f, -4.62144762e-02f, -1.67963192e-01f, -8.25824887e-02f,
  -1.16010018e-01f, 1.23168556e-02f, 6.28788546e-02f, -1.59263477e-01f, -8.75446200e-02f, -7.84729794e-02f, -2.84983423e-02f, 5.67966811e-02f, -1.02373613e-02f, 9.21951085e-02f,
  -1.12782337e-01f, -2.09735725e-02f, -1.69268414e-01f, -1.03166774e-01f, -5.38430251e-02f, -7.62694702e-03f, -2.94168815e-02f, -6.30952045e-02f, 8.89914483e-02f, -1.40738323e-01f,
  -9.61280689e-02f, 1.97227404e-01f, -2.46969819e-01f, 1.80354401e-01f, -3.34275812e-02f, 5.48917018e-02f, -2.82538354e-01f, 1.30845279e-01f, 1.02159835e-03f, -1.67287633e-01f,
  -1.08760595e-01f, 4.78079589e-03f, 2.01443255e-01f, -4.65628505e-02f, 1.50303781e-01f, 2.77500842e-02f, -5.85807394e-03f, -1.19539812e-01f, 2.17476279e-01f, -3.90460044e-02f,
  -1.01736672e-01f, 1.59851581e-01f, -1.01194829e-01f, -8.76953229e-02f, 7.04127401e-02f, 4.99667153e-02f, -7.99770653e-02f, -1.20383881e-01f, -1.50969073e-01f, -1.77735060e-01f,
  -1.13907188e-01f, -7.22065121e-02f, -8.78638253e-02f, 5.22387307e-03f, 1.28031909e-01f, -2.65696049e-01f, -1.54213887e-02f, -5.69827184e-02f, -1.12505473e-01f, -5.82966767e-02f,
  -9.23122764e-02f, -2.14599133e-01f, -4.82355505e-02f, 4.19377834e-02f, 6.49000779e-02f, 3.95683162e-02f, -5.55204265e-02f, 2.72239354e-02f, 2.36633271e-02f, -4.71484885e-02f,
  -1.64517034e-02f, 2.28552520e-01f, -4.97081839e-02f, 7.90173188e-02f, 1.23816296e-01f, 3.31429020e-02f, -6.06719367e-02f, -4.26650494e-02f, 9.51613486e-02f, -1.42555639e-01f,
  1.99252367e-01f, 2.21012682e-02f, -1.36821195e-01f, 1.30539194e-01f, -1.67192310e-01f, -2.41707504e-01f, -5.78541867e-02f, -5.17307073e-02f, -1.04363933e-01f, 6.73244745e-02f,
  1.48630381e-01f, 2.20636398e-01f, -1.44264191e-01f, -4.24038544e-02f, -2.13651210e-01f, 1.40227109e-01f, -1.41121075e-01f, 1.45423725e-01f, -1.32918790e-01f, -3.38169262e-02f,
  5.74002601e-02f, 3.02367695e-02f, -3.18088010e-02f, 1.90430269e-01f, 1.45926490e-01f, -2.35753823e-02f, -5.24597876e-02f, 1.16761081e-01f, 4.16104831e-02f, -2.12557316e-01f,
  1.24902725e-01f, 1.37720972e-01f, -7.87722394e-02f, 2.36030713e-01f, 3.18801373e-01f, -8.93681049e-02f, 6.21857271e-02f, -3.31654884e-02f, -5.38816396e-03f, 4.90416884e-02f,
  1.57582849e-01f, -8.33584890e-02f, 6.09026439e-02f, -2.15499699e-01f, 9.93330702e-02f, 2.67839115e-02f, -5.00559136e-02f, 9.10317823e-02f, 1.46790594e-01f, 1.77504607e-02f,
  -7.67536312e-02f, 2.61331946e-02f, 1.41549900e-01f, -7.35080317e-02f, -5.58948666e-02f, -1.19344972e-01f, -1.80370186e-03f, 2.91228965e-02f, -1.27382517e-01f, -1.16153084e-01f,
  5.33992313e-02f, -6.92542344e-02f, -5.82649782e-02f, -1.34180754e-01f, 2.51611322e-02f, 1.81975469e-01f, -3.20989013e-01f, 2.25986540e-01f, 3.86368781e-02f, 1.89836491e-02f,
  -1.70865022e-02f, 1.70133755e-01f, 1.61363780e-01f, 1.89436555e-01f, -3.08651030e-02f, 3.01874161e-01f, -3.12359328e-03f, 7.48861358e-02f, -3.89470486e-03f, -1.91045459e-02f,
  1.22517243e-01f, -3.83739695e-02f, 2.33265962e-02f, -7.24912584e-02f, -9.95846167e-02f, 1.26482978e-01f, -1.52355790e-01f, -1.25821587e-02f, 9.52149332e-02f, 1.72903210e-01f,
  1.10378720e-01f, 9.06135365e-02f, -3.19061354e-02f, -3.37570429e-01f, 7.13059381e-02f, -3.62072550e-02f, -1.26199543e-01f, 1.06805287e-01f, 1.00958504e-01f, -5.90304583e-02f,
  1.48561448e-01f, -7.06221089e-02f, -4.88778315e-02f, 1.01862915e-01f, 1.15011856e-01f, 9.70483497e-02f, -4.54421714e-02f, -1.53007507e-01f, 1.11063607e-02f, -9.53252539e-02f,
  -1.04882710e-01f, 4.28497121e-02f, -3.58468220e-02f, -1.57846790e-02f, -4.08395305e-02f, -9.90940258e-02f, 1.22126527e-02f, 3.51193473e-02f, -1.47096083e-01f, -1.48330688e-01f,
  -3.60982418e-02f, -1.32101774e-02f, -4.87623848e-02f, -1.24990493e-01f, -7.57813752e-02f, -3.87244206e-03f, 7.53584057e-02f, 6.83412552e-02f, 1.28761139e-02f, 4.28511128e-02f,
  1.35445565e-01f, -6.82461560e-02f, -7.56795332e-02f, -4.76070829e-02f, -8.12992081e-02f, 6.36268854e-02f, -8.59671906e-02f, -1.10523269e-01f, 2.63784826e-02f, 5.20615764e-02f,
  -7.25116432e-02f, 4.41101491e-02f, 1.50456816e-01f, -3.15694325e-02f, 2.85771079e-02f, -8.56858492e-02f, -4.67401706e-02f, -1.22656889e-01f, 6.95655867e-02f, -1.98722884e-01f,
  -9.78315994e-02f, -8.56852308e-02f, 6.93435892e-02f, -3.12989391e-02f, 2.08646860e-02f, -1.38683274e-01f, 1.86350457e-02f, 2.84527186e-02f, -6.36949241e-02f, -3.47030014e-02f,
  -4.50005196e-03f, 6.80865124e-02f, -1.41573802e-01f, 8.00544024e-02f, -3.60116288e-02f, 7.06546605e-02f, 8.51010084e-02f, -2.31329679e-01f, -1.55484051e-01f, -1.03073744e-02f,
  -3.40885669e-02f, 8.07410628e-02f, 1.10425986e-01f, 5.05052432e-02f, 1.65565044e-01f, -5.30431718e-02f, 5.16624339e-02f, -1.33332849e-01f, 1.79783195e-01f, 9.62241441e-02f,
  -7.04981387e-02f, 1.12094656e-01f, -2.39809956e-02f, -3.83454859e-02f, 3.48348208e-02f, -1.11715361e-01f, 3.37350257e-02f, 8.54855329e-02f, -5.33480458e-02f, -1.11128151e-01f,
  -8.10062047e-03f, -1.45881772e-01f, 1.84173986e-01f, 9.21774714e-04f, -1.05693616e-01f, 2.94245873e-02f, 3.46172415e-02f, -2.33692497e-01f, -9.85520408e-02f, 9.23392028e-02f,
  -1.55468524e-01f, -2.54132748e-02f, -5.24318181e-02f, -1.13096461e-02f, -1.04425170e-01f, 8.90861899e-02f, 5.28295850e-03f, -8.82252753e-02f, -4.49499115e-02f, 8.97558257e-02f,
  4.77301404e-02f, -9.62912813e-02f, 2.98671126e-02f, -3.24169733e-02f, -2.29643807e-02f, 1.09989703e-01f, 7.58285895e-02f, 6.49155527e-02f, -1.07763074e-01f, 1.09914444e-01f,
  1.51038617e-01f, -2.57892698e-01f, 8.40273034e-03f, 2.89418660e-02f, -2.98380777e-02f, 2.46165633e-01f, 1.91534653e-01f, 1.15577526e-01f, 9.31794867e-02f, 7.61294812e-02f,
  1.64730046e-02f, -8.29633251e-02f, 8.95442534e-03f, 4.88597415e-02f, -4.13046451e-03f, -1.26247019e-01f, 1.07744604e-01f, 2.21547440e-01f, 2.67448407e-02f, 1.21830650e-01f,
  1.24800116e-01f, -2.28293128e-02f, -5.34750856e-02f, -2.58272067e-02f, -8.73050913e-02f, 4.42135185e-02f, 1.80307776e-01f, -8.58050361e-02f, 1.18615165e-01f, 1.20852657e-01f,
  -1.63441464e-01f, 1.83042213e-01f, 5.79709150e-02f, -3.22769359e-02f, 3.92206684e-02f, -5.95820928e-03f, 7.53304362e-02f, -1.65448889e-01f, 1.95260465e-01f, -2.20988214e-01f,
  1.09616481e-01f, 5.44198118e-02f, -2.00984225e-01f, -6.71790391e-02f, -1.44187748e-01f, 3.83714796e-04f, -2.33929947e-01f, -1.03899449e-01f, -1.30206421e-01f, -3.76901329e-02f,
  9.19072796e-03f, 1.59026086e-01f, -2.03093030e-02f, -5.82639277e-02f, -2.06725635e-02f, -4.93499599e-02f, -5.45472167e-02f, 7.82767683e-03f, 2.53531426e-01f, -8.39511231e-02f,
  -3.40768248e-02f, -4.58928049e-02f, -1.00902721e-01f, -8.48810524e-02f, -1.73996445e-02f, 2.31995687e-01f, -1.29328847e-01f, -1.09087810e-01f, -8.05060044e-02f, -2.17211917e-01f,
  -7.58644044e-02f, -8.21949095e-02f, 4.90018874e-02f, -8.51466954e-02f, 7.41635710e-02f, -6.58796653e-02f, 7.27054253e-02f, -4.86488603e-02f, 5.23047745e-02f, -1.07084632e-01f,
  -5.63961156e-02f, 2.15071049e-02f, 1.36982659e-02f, 1.52113438e-01f, 6.02209270e-02f, 1.10447444e-01f, -1.11911856e-01f, 1.49685936e-02f, 3.25474925e-02f, -3.97487916e-02f,
  -3.91629674e-02f, -6.08340949e-02f, -7.06635490e-02f, 1.14055099e-02f, 3.02411187e-02f, -2.99400873e-02f, -3.99158448e-02f, -7.84058869e-02f, -1.28942400e-01f, 1.08390473e-01f,
  -3.37279849e-02f, 9.04014409e-02f, -1.00390287e-02f, 2.12480009e-01f, 8.32944438e-02f, 4.15052511e-02f, 1.74622387e-01f, -7.09410682e-02f, 1.44915983e-01f, -2.07374059e-02f,
  3.32276970e-01f, 8.35875869e-02f, 1.04297169e-01f, 1.69992879e-01f, 9.79812667e-02f, -1.45348534e-01f, -1.29333571e-01f, -1.07592575e-01f, 5.96987493e-02f, -6.79374933e-02f,
  8.05086195e-02f, 1.37421608e-01f, -2.76612639e-01f, -8.89500231e-02f, -1.22314312e-01f, -1.79879129e-01f, 1.67050824e-01f, -2.34653167e-02f, -8.87459330e-03f, 4.55934852e-02f,
  -1.34144977e-01f, 1.70419812e-01f, 3.48835848e-02f, 3.28418091e-02f, 6.61961408e-03f, -1.36719560e-02f, 1.25330448e-01f, 7.98431635e-02f, 4.41647694e-02f, 2.20207781e-01f,
  -4.01074030e-02f, -5.46388701e-02f, -6.30617812e-02f, -4.96807471e-02f, 3.22251879e-02f, 1.76598467e-02f, 1.65121034e-02f, -5.28916642e-02f, 8.93876031e-02f, 4.54249755e-02f,
  1.36380941e-01f, -6.15493581e-03f, -5.02802292e-03f, -9.29812118e-02f, 6.92535192e-02f, 1.02549367e-01f, -1.36200428e-01f, 2.24363767e-02f, 1.32825216e-02f, -1.08697824e-01f,
  1.62685111e-01f, 5.29443957e-02f, 8.76184851e-02f, 1.17273353e-01f, -9.15404931e-02f, 6.48947358e-02f, -1.10640533e-01f, 2.15773024e-02f, 8.00368413e-02f, -1.16538271e-01f,
  2.54979968e-01f, 1.13699455e-02f, 7.74715170e-02f, -2.03587234e-01f, 1.15391582e-01f, -1.78535134e-01f, 2.41437823e-01f, 2.47311488e-01f, 5.36243506e-02f, -8.80915150e-02f,
  -9.29680616e-02f, -1.03166424e-01f, 7.71810189e-02f, -3.91211882e-02f, 1.05470769e-01f, 6.88319206e-02f, -2.70729065e-01f, 6.74795061e-02f, -1.08865649e-01f, -1.68054476e-01f,
  2.09921837e-01f, 1.26787975e-01f, -1.32667303e-01f, 3.17869708e-02f, 7.34060258e-02f, 1.33803815e-01f, -1.86528210e-02f, -7.51467329e-03f, -1.47034258e-01f, 7.10841790e-02f,
  2.16567796e-02f, 9.65680927e-02f, -6.84435144e-02f, 1.68298170e-01f, -1.10203579e-01f, 1.24860734e-01f, 3.80773619e-02f, 2.33466253e-02f, -8.29517692e-02f, -1.49984300e-01f,
  -2.82869171e-02f, 1.50789544e-01f, -3.88412774e-02f, -1.61360100e-01f, -5.38883954e-02f, 5.51255122e-02f, 1.56057570e-02f, -5.72414882e-02f, -4.94797714e-02f, -2.06355751e-01f,
  2.71075536e-02f, -5.62585741e-02f, -1.32426515e-01f, 6.84317052e-02f, 1.57815486e-01f, 1.10620700e-01f, -3.14241126e-02f, -1.12374477e-01f, 2.42266774e-01f, 1.09812357e-01f,
  -1.05654612e-01f, 1.23084106e-01f, -1.99178196e-02f, -1.08087786e-01f, 6.36344254e-02f, 7.04264641e-02f, 3.99152143e-03f, 2.76900865e-02f, -2.32003927e-02f, 1.86862960e-01f,
  -7.65876621e-02f, 3.07542235e-02f, 9.96348858e-02f, -1.70567974e-01f, -1.07718974e-01f, -1.12648547e-01f, 1.05699703e-01f, -4.01394740e-02f, -4.23822664e-02f, 2.56117266e-02f,
  -8.23083967e-02f, 2.98185833e-03f, -7.53195435e-02f, -6.85443878e-02f, -4.76372987e-02f, -3.22309416e-03f, -2.63287369e-02f, -3.89962763e-01f, 8.72330591e-02f, -1.25376597e-01f,
  -1.08050220e-02f, 1.94529518e-01f, 1.70570284e-01f, 7.24659637e-02f, -1.09498799e-02f, 1.08560175e-01f, -1.14035472e-01f, -5.22680171e-02f, -7.32424716e-03f, 1.31466240e-01f,
  1.03094704e-01f, 5.55435605e-02f, 4.39686365e-02f, -1.23327225e-01f, -6.10489361e-02f, -9.12149553e-04f, 3.89847979e-02f, -5.68940677e-02f, -9.55297202e-02f, -1.23406567e-01f,
  -5.19879907e-02f, 1.10689804e-01f, 8.50736871e-02f, 4.79325913e-02f, 1.47318989e-01f, 5.48259914e-02f, -2.34795008e-02f, -6.64248830e-04f, -8.39751437e-02f, 8.37156177e-03f,
  -1.12360097e-01f, 7.28444830e-02f, 7.67386481e-02f, -1.04511000e-01f, -2.38018766e-01f, 1.93590015e-01f, 5.82019463e-02f, 6.62853895e-03f, -1.21509150e-01f, 1.34934530e-01f,
  1.08418405e-01f, 6.97954223e-02f, -1.60100624e-01f, 2.33705848e-01f, -9.23519284e-02f, -6.96873963e-02f, -8.07338282e-02f, 9.94513631e-02f, -2.37949826e-02f, 4.00194246e-03f,
  -8.54752585e-02f, -1.39189111e-02f, -3.04823406e-02f, 2.47731078e-02f, -2.82732081e-02f, 1.16004638e-01f, -1.39017105e-01f, 2.63059169e-01f, -4.05041836e-02f, 8.29744786e-02f,
  3.68331163e-03f, -2.78939694e-01f, 9.43333134e-02f, -2.47050211e-01f, -9.80039015e-02f, -8.09285939e-02f, 1.55645251e-01f, 8.35537016e-02f, 7.78504275e-03f, 1.09762035e-01f,
  -6.83758780e-02f, 1.47366941e-01f, 4.72757705e-02f, 2.07213819e-01f, -2.47638952e-02f, -1.42928392e-01f, 1.25709653e-01f, -1.31068483e-01f, -1.24290004e-01f, 3.21762748e-02f,
  -8.66304189e-02f, -8.10009837e-02f, 1.18299790e-01f, -1.60722479e-01f, 1.47264510e-01f, -9.38642304e-03f, 4.24216921e-03f, 6.40109330e-02f, -2.56710611e-02f, -1.01241112e-01f,
  -1.49287298e-01f, 6.67540133e-02f, -5.27638011e-02f, -9.60299149e-02f, -3.83988954e-03f, -2.95645688e-02f, 1.97535276e-01f, -4.53965962e-02f, -9.20570567e-02f, 8.90920982e-02f,
  -1.62690759e-01f, 6.69417391e-03f, -2.00363353e-01f, -3.68791558e-02f, -1.73250750e-01f, 2.41777107e-01f, -2.84314692e-01f, 2.16725439e-01f, -1.83051869e-01f, -1.95811421e-01f,
  -2.36458167e-01f, 1.17026247e-01f, 1.80599332e-01f, 4.81415316e-02f, -3.17496993e-02f, 6.62982836e-02f, 2.06529051e-02f, -5.10099605e-02f, 1.91865295e-01f, 1.57561108e-01f,
  -3.34250368e-02f, 1.97986782e-01f, -9.46600661e-02f, 6.49052486e-02f, -5.28471619e-02f, -1.72825560e-01f, -8.57997313e-02f, -1.19420484e-01f, -2.83647254e-02f, 3.75880711e-02f,
  8.87797549e-02f, 8.33818242e-02f, -9.58700702e-02f, 7.68819228e-02f, 2.76726447e-02f, -2.79843714e-02f, 1.53570846e-01f, 1.38567746e-01f, 2.74105277e-02f, -2.08037585e-01f,
  6.06907234e-02f, 1.76866665e-01f, 9.87392887e-02f, -2.93800520e-04f, 8.12136605e-02f, 2.12304536e-02f, 9.85777676e-02f, 7.33249709e-02f, -7.61974305e-02f, -5.10800816e-02f,
  5.93899228e-02f, -1.18174411e-01f, -3.12098097e-02f, 4.40638848e-02f, 1.37854919e-01f, -2.95344628e-02f, 1.18210897e-01f, -3.26689752e-03f, 2.35750135e-02f, 9.85146035e-03f,
  -1.44415841e-01f, -3.19836428e-03f, 5.46525717e-02f, -4.07350510e-02f, 1.54362097e-01f, 7.17672482e-02f, 3.07607707e-02f, -1.92272380e-01f, 3.32450867e-02f, -5.61931878e-02f,
  9.46397111e-02f, -1.35149986e-01f, 3.28980871e-02f, 6.57364056e-02f, 1.39528453e-01f, 3.27084959e-02f, -1.88911092e-02f, -9.21346545e-02f, -1.23455122e-01f, 3.12898792e-02f,
  1.03222415e-01f, 8.56403410e-02f, -1.48359179e-01f, -1.13863356e-01f, 5.72603047e-02f, -2.86671728e-01f, -4.27127145e-02f, -6.61886483e-02f, 7.26683065e-02f, 2.41281897e-01f,
  2.68642744e-03f, 1.56906664e-01f, -8.30048695e-02f, -1.56798735e-01f, -9.95250493e-02f, -8.18150584e-03f, -5.53425588e-02f, -3.99587974e-02f, -2.04922189e-03f, 1.95181184e-02f,
  3.26998834e-03f, -1.53462589e-01f, -9.33770314e-02f, 1.34789824e-01f, 3.62029187e-02f, -3.66053805e-02f, 2.47659869e-02f, -1.27471030e-01f, -1.64411113e-01f, -8.20812136e-02f,
  1.06805131e-01f, 8.86661839e-03f, -1.13925368e-01f, 3.08633279e-02f, -8.25372059e-03f, -3.84479016e-02f, 5.55735305e-02f, 3.74392979e-02f, -1.29875228e-01f, 9.42152441e-02f,
  6.18945807e-02f, -1.27175868e-01f, 6.29140735e-02f, 3.61417942e-02f, 5.59639633e-02f, -2.50774324e-01f, -2.06795726e-02f, -2.26444751e-01f, 2.01001465e-02f, -5.59190735e-02f,
  2.05678977e-02f, -8.22771937e-02f, -1.17867589e-01f, 1.63600873e-02f, -3.30564022e-01f, -2.79253181e-02f, -5.66318743e-02f, -2.08065435e-01f, 1.26078457e-01f, -4.29207198e-02f,
  7.90095404e-02f, 2.52467673e-02f, 1.89417168e-01f, 1.16811790e-01f, -1.40500769e-01f, -8.17794353e-02f, 2.18488529e-01f, 1.30970418e-01f, 7.26835579e-02f, 1.38280556e-01f,
  -1.33885756e-01f, -4.48026322e-02f, 1.65964663e-01f, 7.80157149e-02f, 7.29706138e-02f, -6.96455091e-02f, 1.12239189e-01f, 3.38016599e-02f, -6.54417649e-02f, 1.07917219e-01f,
  -4.42000711e-03f, -2.11413875e-01f, 1.27450809e-01f, -4.08777922e-01f, 5.53442501e-02f, 7.37495497e-02f, -1.17427990e-01f, -7.09882006e-02f, -1.13219984e-01f, 1.08773731e-01f,
  -2.34364960e-02f, -6.11071326e-02f, -2.03631625e-01f, -5.39655872e-02f, 6.77358434e-02f, 5.66875115e-02f, -1.63201645e-01f, -1.21635884e-01f, -1.24673389e-01f, -2.11402029e-02f,
  9.34735686e-02f, -5.42652002e-03f, 8.40411114e-04f, -1.29308388e-01f, -1.41417146e-01f, 3.42283677e-03f, 3.31336893e-02f, 1.31764188e-01f, -2.32737839e-01f, -2.04703093e-01f,
  1.96826816e-01f, -1.76165998e-01f, -1.34336323e-01f, 4.62961495e-02f, -1.36607350e-03f, -1.44319504e-01f, 8.14464241e-02f, 2.07755249e-02f, -4.04102877e-02f, -6.73516467e-02f,
  -5.75342625e-02f, -8.48453939e-02f, 8.13468769e-02f, -8.42868313e-02f, -7.05603734e-02f, -5.31655736e-02f, -6.30004406e-02f, -6.74955174e-02f, -2.12216265e-02f, -1.53403133e-01f,
  2.91533861e-02f, 4.72961366e-03f, 8.08990672e-02f, -2.16487363e-01f, 8.84823799e-02f, -7.95732290e-02f, 6.68286011e-02f, 2.75471002e-01f, -8.42547119e-02f, 1.57045517e-02f,
  1.33033231e-01f, -1.74980223e-01f, -2.19028041e-01f, -9.34346691e-02f, 3.71830761e-02f, -1.62094563e-01f, 1.23709187e-01f, -1.69716328e-01f, -1.61623344e-01f, 8.63091424e-02f,
  -1.12632953e-01f, -1.15970047e-02f, 1.49227470e-01f, 1.41269475e-01f, 4.39948998e-02f, 3.57739464e-03f, -1.19080067e-01f, 1.55418411e-01f, -6.08501062e-02f, -3.02130636e-02f,
  -9.62499529e-02f, -5.55960499e-02f, 1.51705027e-01f, 5.74909896e-02f, 5.54247834e-02f, 3.90057825e-02f, 4.12075445e-02f, 1.50706563e-02f, -3.18284035e-02f, -5.39218448e-02f,
  -1.00944629e-02f, -1.07636712e-01f, -2.61084318e-01f, -2.15350632e-02f, 1.11154303e-01f, 1.16679922e-01f, -1.72249563e-02f, -6.37784377e-02f, 1.66161194e-01f, -7.81812221e-02f,
  8.17579627e-02f, -6.55737668e-02f, 2.19028786e-01f, -1.53909072e-01f, 1.05845757e-01f, 1.78543091e-01f, -1.52033456e-02f, 8.00945237e-02f, -1.62775535e-02f, -6.33798242e-02f,
  -2.58395504e-02f, -4.62675057e-02f, 1.13009334e-01f, 4.75056469e-02f, -8.72943327e-02f, -1.08399048e-01f, -1.47121295e-01f, 1.34271920e-01f, -6.89405650e-02f, 4.18935977e-02f,
  5.53380251e-02f, 1.19202487e-01f, -1.00498527e-01f, -1.10572074e-02f, 8.34120661e-02f, -9.12807658e-02f, -4.77160923e-02f, 5.55155799e-02f, -1.43592224e-01f, 6.45544454e-02f,
  7.76028484e-02f, 1.44619241e-01f, -8.87505263e-02f, 1.69877380e-01f, 6.34414554e-02f, 6.46482855e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -2.86661088e-03f, -8.13140273e-02f, 5.99515513e-02f, -8.26445892e-02f, 9.95896384e-02f, 5.30622229e-02f, 1.01299591e-01f, 9.12326947e-02f, -3.96256037e-02f, -9.77351740e-02f,
  3.62320580e-02f, -4.60495502e-02f, -5.37020564e-02f, 2.01975238e-02f, 1.63785532e-01f, -1.58525594e-02f, 2.01321207e-02f, -2.77081411e-02f, -2.06193868e-02f, -9.24779475e-02f,
  -1.91787750e-01f, -9.16154087e-02f, 6.05314691e-03f, 3.92780155e-02f, -9.36258882e-02f, 3.74675952e-02f, 1.48032844e-01f, -1.42065212e-01f, 1.95816487e-01f, -1.30411819e-01f,
  6.90068379e-02f, -1.36573330e-01f, 1.11356497e-01f, 1.26758546e-01f, 7.01114237e-02f, 5.98471053e-03f, -1.78216651e-01f, -9.84766111e-02f, -1.22068040e-01f, -9.81180649e-03f,
  1.97091371e-01f, -5.38634062e-02f, -9.34258103e-02f, -1.55075528e-02f, -8.13948885e-02f, -7.00616091e-02f, 4.26236391e-02f, -1.00420587e-01f, 6.99564721e-03f, 1.52032644e-01f,
  1.17143944e-01f, 2.74499245e-02f, 1.92353114e-01f, -3.21982540e-02f, -1.37193397e-01f, 8.19742028e-03f, 2.09177136e-02f, 1.17294945e-01f, 9.73076597e-02f, 9.81466621e-02f,
  -1.10957041e-01f, -1.13551922e-01f, 1.01077758e-01f, 6.21326119e-02f, 9.31335613e-02f, -6.47673085e-02f, 1.11802556e-02f, -3.44765186e-02f, 6.09188192e-02f, -9.82434526e-02f,
  -5.05431835e-03f, -8.81988555e-02f, 8.04770589e-02f, 4.14088182e-02f, 7.92722777e-02f, 9.32364464e-02f, -7.68297017e-02f, -1.55515075e-02f, 1.10676490e-01f, -9.77820083e-02f,
  1.20723762e-01f, -8.91386271e-02f, 1.30992278e-01f, 7.57809579e-02f, -5.69623560e-02f, 6.38446882e-02f, 1.02435954e-01f, 1.19568549e-01f, 1.88961402e-02f, 4.90546525e-02f,
  2.56512966e-02f, 2.00978611e-02f, 2.51499731e-02f, -6.05379306e-02f, 8.62058103e-02f, -4.75155264e-02f, 1.36573732e-01f, 8.16413015e-02f, 1.49467990e-01f, -8.93867090e-02f,
  -4.19021770e-02f, -2.03572307e-02f, -1.19153097e-01f, -1.84997940e-03f, 6.80715814e-02f, 4.90165092e-02f, 5.57846427e-02f, -3.97509076e-02f, -7.92024434e-02f, 1.00606037e-02f,
  5.61283492e-02f, -9.73254740e-02f, 4.93461154e-02f, -2.31210925e-02f, -6.46237433e-02f, 8.14335644e-02f, 3.81090529e-02f, 9.84710529e-02f, -8.52448791e-02f, 1.07493423e-01f,
  8.33074003e-02f, -6.82035238e-02f, -2.40141638e-02f, -8.80769268e-02f, -1.30515605e-01f, -4.19635400e-02f, -2.89744325e-02f, 4.01911996e-02f, 4.05832008e-02f, 7.03867823e-02f,
  3.14977057e-02f, -1.36206284e-01f, -6.89307647e-03f, -4.49734479e-02f, -1.83060337e-02f, -4.83585522e-03f, -1.48089021e-01f, 3.95108499e-02f, -8.92166644e-02f, -6.58502951e-02f,
  -8.56646448e-02f, 9.92507115e-02f, -5.21254092e-02f, 1.02338783e-01f, 9.14952457e-02f, -1.53091419e-02f, -8.10851436e-03f, 5.94600961e-02f, -1.25136018e-01f, 8.53484794e-02f,
  1.13321163e-01f, -1.37606442e-01f, -8.18949938e-03f, -1.07060321e-01f, 9.35923234e-02f, -1.05374604e-01f, 7.79207200e-02f, -1.15812749e-01f, -7.30275065e-02f, -1.28711686e-01f,
  4.04354110e-02f, -1.02184594e-01f, -6.75022602e-02f, 6.55722916e-02f, 7.05024635e-04f, -3.46973166e-03f, 1.02113582e-01f, 5.22143580e-02f, -6.82172328e-02f, -7.31463730e-02f,
  5.28064817e-02f, 1.05629653e-01f, -8.87858868e-02f, -8.76942202e-02f, -3.12842391e-02f, 7.31949136e-02f, -1.09588474e-01f, 2.11996809e-01f, -1.10204794e-01f, 3.15989703e-02f,
  4.41651233e-03f, 6.60047010e-02f, -1.12288490e-01f, -7.34083168e-03f, 3.19298133e-02f, -4.60913368e-02f, -6.12490363e-02f, -5.45690395e-02f, 5.70780486e-02f, -1.00380234e-01f,
  8.12839624e-03f, 1.05264291e-01f, -1.44430278e-02f, -7.44244009e-02f, 4.48090434e-02f, 5.63332364e-02f, 1.00341164e-01f, -2.16787588e-02f, 9.85921244e-04f, -7.84026831e-02f,
  1.42115608e-01f, -9.62833390e-02f, -5.21591455e-02f, 1.09597653e-01f, -1.71938520e-02f, 7.59969652e-02f, -2.47956347e-03f, -5.26368096e-02f, 2.95054633e-03f, 7.45125934e-02f,
  5.90374060e-02f, -1.43219149e-02f, 1.10281341e-01f, 1.42324269e-01f, -1.45733505e-01f, 2.18923151e-01f, 4.34888937e-02f, -1.34795994e-01f, 1.26912564e-01f, 8.46826434e-02f,
  4.68941629e-02f, -6.88129514e-02f, 7.82866180e-02f, -6.80840611e-02f, 1.19676203e-01f, -3.62462178e-02f, 4.28351164e-02f, -7.83587620e-02f, 3.24401483e-02f, -1.88299775e-01f,
  3.39669473e-02f, -9.52045023e-02f, 9.56224278e-03f, 2.13447556e-01f, -1.00677889e-02f, 6.21259771e-03f, 3.83835435e-02f, 1.28794879e-01f, 5.41111268e-03f, -1.16794363e-01f,
  -1.94270033e-02f, -1.18078694e-01f, 1.47500008e-01f, 2.75083128e-02f, 2.66532619e-02f, 1.18109835e-02f, 1.60778075e-01f, 1.56898126e-02f, 7.04320148e-02f, 1.11904904e-01f,
  -4.37947921e-03f, 3.86015058e-01f, -1.06505521e-01f, 2.33301409e-02f, -6.07488900e-02f, 1.45927012e-01f, 3.66425351e-03f, 8.42605066e-03f, -7.51122385e-02f, -1.17375404e-02f,
  1.54799998e-01f, 8.73670503e-02f, 2.37323735e-02f, 8.83173198e-02f, -9.11667794e-02f, 2.72742826e-02f, 1.80927552e-02f, 1.09734274e-01f, 5.26267849e-02f, 5.88404983e-02f,
  3.29806507e-02f, 1.28216371e-01f, -6.65245652e-02f, 9.66228470e-02f, -5.06146327e-02f, 5.27899601e-02f, 3.67796980e-02f, 4.82936902e-03f, -5.49059398e-02f, -1.00373052e-01f,
  -6.65285364e-02f, 8.58175829e-02f, -5.54710180e-02f, -9.07677710e-02f, -3.27117625e-03f, 1.10826358e-01f, -8.78930017e-02f, 1.30226567e-01f, 5.32060750e-02f, -3.14006954e-02f,
  -1.47333205e-01f, 1.34308517e-01f, -4.48695831e-02f, -9.08830687e-02f, -1.46494761e-01f, 7.44405314e-02f, -5.63396551e-02f, 1.15438871e-01f, -9.05701797e-03f, 4.47833799e-02f,
  -5.49459755e-02f, -1.00991979e-01f, -2.55198963e-03f, -3.51201221e-02f, -1.74363889e-02f, 9.35343429e-02f, 1.19207077e-01f, 7.93312714e-02f, -7.58152753e-02f, 1.54418042e-02f,
  8.36340562e-02f, -5.40131591e-02f, -5.78194782e-02f, -1.19850025e-01f, -1.16968028e-01f, 9.33644250e-02f, 1.49417147e-01f, -9.90364254e-02f, 6.68011652e-03f, -2.25709621e-02f,
  1.97820812e-02f, -5.08117490e-02f, 1.20802380e-01f, 7.26433843e-02f, 5.53709269e-02f, -1.44076264e-02f, 2.15617530e-02f, 1.15777574e-01f, 6.74088374e-02f, -3.31224054e-02f,
  -1.27823412e-01f, 9.93045345e-02f, 1.31699011e-01f, 6.79032952e-02f, 9.65100992e-03f, 3.45377475e-02f, -1.99029054e-02f, 4.93217148e-02f, 1.06999092e-01f, -3.03751531e-05f,
  5.89684248e-02f, -4.84951325e-02f, -6.80753583e-05f, 1.25943109e-01f, -1.20195471e-01f, -1.53164014e-01f, 1.40608298e-02f, 1.54029563e-01f, -4.65733521e-02f, 7.56594241e-02f,
  1.21870544e-02f, 1.64979905e-01f, 5.79179712e-02f, -1.30956471e-01f, -4.06482406e-02f, 1.27482370e-01f, 6.16531298e-02f, 1.13206364e-01f, 2.29902621e-02f, -3.76359746e-03f,
  -3.93094905e-02f, 4.48604748e-02f, 1.17026959e-02f, 1.64677024e-01f, -3.58119048e-02f, 7.65916333e-02f, -4.81139719e-02f, -4.05232757e-02f, 3.49480682e-03f, -1.08870231e-01f,
  1.69534609e-01f, -1.28344208e-01f, 7.55437687e-02f, 1.22517414e-01f, 1.78906009e-01f, 7.64246210e-02f, 1.17964379e-01f, -7.10226223e-03f, 2.12201476e-02f, 6.26924410e-02f,
  9.14135203e-02f, -1.86249579e-03f, 4.43796255e-02f, -8.16988945e-02f, 9.15618539e-02f, -1.25204012e-01f, -6.88915923e-02f, 8.39993879e-02f, 4.16918062e-02f, -9.40117389e-02f,
  1.54737234e-01f, 8.96184519e-02f, 1.14209108e-01f, 8.08032826e-02f, -9.68259126e-02f, 1.13730252e-01f, 9.40752402e-02f, 6.62269294e-02f, -4.48988453e-02f, -9.80584845e-02f,
  1.75457522e-01f, -6.41958192e-02f, 5.49475290e-02f, 2.07515880e-02f, 2.39751443e-01f, -1.07524339e-02f, -5.68310954e-02f, 8.12291726e-02f, -1.07998148e-01f, -1.32527232e-01f,
  -1.57391682e-01f, 1.13555603e-01f, -1.22450002e-01f, 1.20384045e-01f, -9.19720456e-02f, 1.67448357e-01f, -1.70621425e-01f, 1.36069972e-02f, -1.06660537e-01f, 8.84130970e-02f,
  8.28070417e-02f, -7.31689334e-02f, -6.17253669e-02f, -8.01756140e-03f, 4.82604355e-02f, -2.45593432e-02f, 1.17816284e-01f, 7.99324065e-02f, 1.16271630e-01f, -1.85765757e-03f,
  1.01637252e-01f, 1.18014440e-01f, 6.74793273e-02f, -1.47363365e-01f, -4.58967239e-02f, 8.02089870e-02f, 5.73897138e-02f, 2.29216278e-01f, 1.17854670e-01f, 3.37128900e-02f,
  -5.76682687e-02f, 1.53201088e-01f, 9.47007462e-02f, 1.64113790e-01f, 4.36922647e-02f, 1.50346205e-01f, -1.88624691e-02f, -1.86220184e-01f, 3.72360423e-02f, 3.13930307e-03f,
  1.14994086e-01f, -2.88897362e-02f, 1.10581711e-01f, 1.44369692e-01f, 1.99456662e-01f, 1.73546165e-01f, -5.97385922e-03f, 5.34154102e-02f, -6.19452782e-02f, -3.24868225e-02f,
  6.96134046e-02f, 6.51532188e-02f, 1.07127614e-01f, 1.79376885e-01f, 1.61137149e-01f, -1.83474980e-02f, 2.77340431e-02f, -4.58569564e-02f, -1.28583699e-01f, -1.08919755e-01f,
  1.60421878e-01f, -2.59349972e-01f, -3.23317088e-02f, 5.58178639e-03f, -4.30260785e-03f, -1.80392966e-01f, 8.38564187e-02f, 2.84179710e-02f, -8.45955834e-02f, -7.96476901e-02f,
  -1.11261792e-01f, -8.15109611e-02f, 1.34011731e-01f, -8.17783549e-02f, 1.82439759e-03f, -3.09371036e-02f, -1.02188781e-01f, -2.65669171e-02f, 4.06720079e-02f, -9.68154520e-02f,
  6.11066222e-02f, -1.56863108e-02f, -3.16136442e-02f, -5.74054345e-02f, -6.50018603e-02f, 8.58596414e-02f, 1.38779089e-01f, 3.75608146e-01f, 8.02737251e-02f, 1.49876073e-01f,
  1.07583418e-01f, -5.13712540e-02f, -1.58361971e-01f, 1.02790423e-01f, -2.44511757e-02f, -1.28754720e-01f, -3.83923985e-02f, -2.10968807e-01f, 1.04548290e-01f, 8.49193428e-03f,
  6.26809895e-02f, 3.12804319e-02f, 3.24101150e-02f, -1.17956869e-01f, 1.60813946e-02f, 5.23881763e-02f, -8.98449942e-02f, 1.91311371e-02f, 1.26382798e-01f, 5.88806346e-02f,
  -4.84014899e-02f, -7.37514496e-02f, 5.39730191e-02f, 2.04802841e-01f, 7.11525530e-02f, -1.69836432e-02f, -4.27634381e-02f, 1.67171583e-02f, -3.76126021e-02f, -1.01366460e-01f,
  6.34714514e-02f, -8.22673589e-02f, -1.26547903e-01f, -1.49681792e-01f, -2.63796020e-02f, -1.15148209e-01f, -5.78370579e-02f, 4.30416279e-02f, -1.04542360e-01f, -3.72983962e-02f,
  -4.84752748e-03f, 5.39408624e-02f, 6.32070750e-02f, 2.77823620e-02f, -2.12375104e-01f, -1.26303658e-01f, -1.87047757e-02f, 1.49686143e-01f, -3.82291302e-02f, 1.09498806e-01f,
  -1.05276378e-02f, 1.12156600e-01f, 1.00377977e-01f, 1.87747449e-01f, 1.46747038e-01f, 6.06871024e-02f, 4.80774269e-02f, -4.36041430e-02f, -1.32997140e-01f, -6.92827627e-02f,
  -9.71989855e-02f, 5.98430820e-02f, -4.23067622e-03f, 1.90385431e-01f, 1.40473261e-01f, 1.56996608e-01f, 2.81394839e-01f, -3.76595855e-02f, -1.34311244e-01f, -1.77981243e-01f,
  -1.07623190e-01f, 7.43420646e-02f, 1.25262052e-01f, 6.27040165e-03f, -4.83932309e-02f, -2.18401919e-03f, -7.53055438e-02f, -2.30013803e-02f, -8.38304311e-03f, 2.07989048e-02f,
  6.62095994e-02f, 1.10146152e-02f, 1.63775161e-01f, 4.91143800e-02f, -1.39676943e-01f, 7.04395911e-03f, 3.21084214e-03f, 6.05434142e-02f, 1.19869213e-03f, 1.05340764e-01f,
  1.29409775e-01f, -2.40353625e-02f, -4.07790281e-02f, 1.13034569e-01f, 1.09989628e-01f, -2.38289729e-01f, -1.27757430e-01f, -2.69900914e-02f, 1.35318071e-01f, -1.33744925e-01f,
  -1.37048066e-02f, -8.72562528e-02f, 2.55294442e-01f, -1.29862782e-02f, 6.06709644e-02f, -1.27758890e-01f, 2.86481589e-01f, -2.24793822e-01f, 1.64547905e-01f, 2.02021614e-01f,
  4.94696340e-03f, -2.41093803e-02f, -1.72754437e-01f, -4.12489064e-02f, -1.50655568e-01f, 1.29809128e-02f, 2.52118111e-01f, -5.24829794e-03f, -2.68167734e-01f, 7.30719194e-02f,
  3.12068891e-02f, -1.56806752e-01f, 1.44859493e-01f, 1.91182585e-03f, -1.45881400e-01f, 2.07768366e-01f, -1.47111993e-02f, 3.66521567e-01f, 2.81416684e-01f, -1.27356008e-01f,
  -5.06129451e-02f, 1.56135544e-01f, -3.46535258e-02f, -1.69713274e-02f, -1.03850424e-01f, 2.98392028e-01f, 4.09696475e-02f, 3.93487588e-02f, -6.07117563e-02f, 1.55306235e-01f,
  9.71175656e-02f, 6.25211522e-02f, -3.23068537e-02f, 1.44329786e-01f, 1.00226831e-02f, 6.19408041e-02f, 1.24901563e-01f, -1.96268544e-01f, 1.40365839e-01f, 8.95397589e-02f,
  -2.77129076e-02f, -1.51874050e-01f, 8.63409191e-02f, 8.75895619e-02f, -8.53746906e-02f, 1.26495212e-01f, -7.16764182e-02f, 5.76327257e-02f, -3.64471860e-02f, -8.50306526e-02f,
  -2.51669697e-02f, -6.34064898e-02f, 1.91988945e-01f, -1.95377678e-01f, -1.78272158e-01f, 2.22816467e-01f, -1.29080325e-01f, 6.57442212e-02f, -2.79278755e-02f, 1.80087730e-01f,
  -1.31214663e-01f, -3.33089940e-02f, -1.98251098e-01f, -1.95696563e-01f, -1.34925917e-01f, 1.48828685e-01f, 1.28614634e-01f, 2.39973273e-02f, 1.93472207e-01f, 7.48239011e-02f,
  7.12276176e-02f, -4.44681793e-02f, 2.37759307e-01f, -1.11696757e-02f, -5.07022366e-02f, 3.12966734e-01f, -1.24105528e-01f, -8.28438401e-02f, 1.49584368e-01f, 2.73702689e-03f,
  -3.82245295e-02f, -1.13904290e-01f, 7.64697567e-02f, -1.21165775e-01f, 8.34241230e-03f, -8.98969993e-02f, 1.47457272e-02f, -1.44281015e-01f, 6.38834685e-02f, -1.56757846e-01f,
  5.32765053e-02f, -4.82068323e-02f, -8.93567875e-02f, 1.09985963e-01f, 5.06604128e-02f, 2.95460015e-03f, 9.07882750e-02f, -6.60860687e-02f, 2.86497809e-02f, -2.74739340e-02f,
  1.16057359e-02f, 7.88177997e-02f, 1.38476208e-01f, 1.16678119e-01f, -9.29632783e-02f, 2.86152884e-02f, 5.17866574e-02f, -2.24243999e-02f, 3.12003139e-02f, -3.03344242e-02f,
  3.73000167e-02f, -8.46609622e-02f, 1.11031309e-01f, -3.70145962e-02f, 2.60298904e-02f, 9.53296050e-02f, 3.50816026e-02f, 6.18203394e-02f, 4.10841517e-02f, 1.52880430e-01f,
  -1.26786947e-01f, 8.67005810e-02f, 6.44174144e-02f, 1.47621185e-01f, 6.33836016e-02f, -1.25152767e-01f, -1.42399399e-02f, 8.79431665e-02f, -4.81026322e-02f, 1.10841058e-01f,
  3.87312584e-02f, 1.96013246e-02f, -9.82534960e-02f, -4.35993224e-02f, -5.19320816e-02f, 4.00905423e-02f, 1.65605053e-01f, 1.04727209e-01f, 5.43771237e-02f, 1.10709444e-02f,
  7.24191070e-02f, -9.41355228e-02f, -1.28797889e-01f, 1.92143023e-01f, -8.16869736e-02f, 1.63014993e-01f, 1.39895012e-03f, 6.08219951e-02f, 4.51444201e-02f, 7.42852129e-03f,
  6.55933544e-02f, -7.13686720e-02f, -8.15968588e-03f, -7.74063021e-02f, -7.17019215e-02f, -7.96975866e-02f, 9.67168435e-02f, -7.48765096e-02f, 1.46482825e-01f, -1.06144823e-01f,
  2.60885246e-02f, -1.25978425e-01f, -6.58120438e-02f, 1.71125889e-01f, -2.03435961e-03f, 9.30375382e-02f, 1.20642975e-01f, 1.14713095e-01f, 8.78784955e-02f, 1.75659955e-01f,
  -1.00698091e-01f, 1.22837581e-01f, -9.51809958e-02f, -4.22070511e-02f, 5.59170209e-02f, 7.67110847e-03f, 5.31526841e-02f, -9.04649049e-02f, -3.38721350e-02f, 1.94999233e-01f,
  -2.87238389e-01f, 2.04749510e-01f, 1.04929976e-01f, -1.91632912e-01f, -7.05788434e-02f, 2.34897062e-01f, 1.49812594e-01f, 2.10692450e-01f, 9.43298638e-02f, 1.87330291e-01f,
  -6.65469021e-02f, -1.45712063e-01f, -3.51550356e-02f, -2.72341818e-02f, 2.19779387e-02f, 7.12053776e-02f, 1.54609278e-01f, -7.07130730e-02f, 3.03804781e-02f, 1.56888366e-01f,
  7.08263740e-02f, 1.67210832e-01f, -6.16771542e-02f, 3.66293222e-01f, 5.93442246e-02f, -3.66131589e-02f, 6.82961568e-02f, -4.50432032e-01f, 3.11065074e-02f, -7.03008845e-02f,
  -1.07025608e-01f, 5.66080213e-02f, 9.31181908e-02f, 1.41552165e-01f, -9.21528637e-02f, 5.66268750e-02f, -6.81128278e-02f, 2.77173609e-01f, -4.98040207e-02f, 2.31594965e-01f,
  -8.16755146e-02f, 7.52275670e-03f, 5.53774647e-02f, 2.51372922e-02f, 1.70917735e-01f, 7.31831565e-02f, 8.44494030e-02f, 7.51102343e-02f, 1.88168213e-01f, 1.39954343e-01f,
  -8.62423405e-02f, 2.33790018e-02f, -2.52086502e-02f, -5.86849265e-02f, -4.10137214e-02f, 1.23454988e-01f, -8.04599598e-02f, 1.03301711e-01f, 1.47478715e-01f, 1.78610196e-03f,
  1.01329371e-01f, -2.34849136e-02f, 2.70270795e-01f, 6.42558783e-02f, -6.11861087e-02f, 6.56835958e-02f, -6.46433756e-02f, -2.09989287e-02f, -1.53463304e-01f, -5.21357656e-02f,
  -3.90699282e-02f, 4.05907854e-02f, -1.23105116e-01f, 7.21729547e-02f, -2.05703944e-01f, -8.93350840e-02f, -4.37493734e-02f, 8.03796872e-02f, 3.90200429e-02f, -7.95521364e-02f,
  1.48410425e-01f, -8.08908716e-02f, -1.46225482e-01f, -1.09603718e-01f, 1.40913323e-01f, 1.28225967e-01f, 1.09774224e-01f, 8.99081379e-02f, -5.72539382e-02f, -1.10371649e-01f,
  3.57190296e-02f, 1.34973880e-02f, 1.19709603e-01f, 1.27276387e-02f, 1.12532705e-01f, 2.15729058e-01f, 1.55556455e-01f, -2.77369097e-02f, 1.34410158e-01f, 2.49537602e-02f,
  -6.07444812e-03f, 2.24135979e-03f, 3.04880887e-02f, -1.01898335e-01f, -1.35580197e-01f, -6.90208972e-02f, -1.01063214e-01f, -1.52907800e-02f, 5.86462468e-02f, 1.59234963e-02f,
  -8.77621700e-04f, -4.53066491e-02f, -9.31699499e-02f, 9.49205384e-02f, 7.90796354e-02f, -3.32495905e-02f, 1.30671456e-01f, -5.09119891e-02f, -1.12304851e-01f, 6.43834174e-02f,
  7.92967156e-02f, 1.24198489e-01f, 1.08705565e-01f, -7.92251900e-02f, 1.19973049e-01f, 1.06775939e-01f, -1.02398470e-01f, 6.91402629e-02f, -9.14549157e-02f, -7.41087794e-02f,
  8.49376917e-02f, -8.45053494e-02f, 2.06582695e-02f, -3.55814807e-02f, -6.64713234e-02f, -8.79085883e-02f, -1.78843997e-02f, 9.27025732e-03f, 7.12778196e-02f, 8.91161636e-02f,
  1.13045521e-01f, -1.11648366e-02f, 7.12847486e-02f, 8.59628469e-02f, 2.73987744e-02f, 9.17255729e-02f, 4.61969413e-02f, -3.80849317e-02f, -2.54009552e-02f, 1.04314215e-01f,
  -1.12906508e-01f, -7.39550292e-02f, -3.67690921e-02f, 6.68502375e-02f, 9.61330831e-02f, -5.91701306e-02f, -1.06564173e-02f, -6.21083304e-02f, 5.10458499e-02f, 2.94257328e-03f,
  -6.54470474e-02f, -1.03274941e-01f, -2.66200062e-02f, -8.46825242e-02f, -7.18784928e-02f, 3.11258622e-02f, 6.31938204e-02f, 7.94856623e-02f, 1.04507096e-01f, -7.23037347e-02f,
  1.78168167e-03f, 1.07293665e-01f, 3.54606286e-02f, -3.95480320e-02f, -6.50797710e-02f, 4.30702716e-02f, 3.33440937e-02f, -1.22090273e-01f, 9.00247991e-02f, 1.35293556e-02f,
  8.31594411e-03f, -1.12174213e-01f, 6.66448772e-02f, -5.52395731e-02f, -9.96122230e-03f, 3.19112614e-02f, -8.42711627e-02f, -1.04325689e-01f, -3.32080759e-02f, 3.58591303e-02f,
  3.47529515e-03f, 9.19474587e-02f, -1.13688029e-01f, -3.18774842e-02f, 1.17506690e-01f, -9.38011855e-02f, 3.60833667e-02f, 8.80809724e-02f, -8.89474377e-02f, -1.06286429e-01f,
  -8.93347412e-02f, 3.23841609e-02f, -3.90706249e-02f, 1.03854597e-01f, -4.49617207e-02f, 2.77568940e-02f, -9.93943214e-02f, -1.11380078e-01f, -4.70448807e-02f, -5.86076640e-03f,
  4.49502654e-02f, -1.14833288e-01f, 6.08698316e-02f, -5.05553447e-02f, -7.49322474e-02f, -3.03636063e-02f, 2.93649901e-02f, 2.96536088e-02f, 1.08038977e-01f, -7.77455345e-02f,
  6.12338120e-03f, 2.76056118e-02f, -6.39985725e-02f, 4.81554344e-02f, -8.95533487e-02f, 1.84118971e-02f, -2.27269810e-02f, -1.16568699e-01f, -1.06430594e-02f, -9.32691172e-02f,
  -1.14520729e-01f, 5.84146008e-02f, 1.09253488e-01f, 4.90766391e-02f, -1.04935333e-01f, 1.33615118e-02f, 8.54872540e-02f, 6.63605481e-02f, 1.25046864e-01f, -6.65761009e-02f,
  7.27204001e-03f, -2.19107326e-02f, -1.08445615e-01f, 1.36267856e-01f, -1.22208014e-01f, 5.46361320e-02f, 2.23542354e-03f, -9.15499628e-02f, -5.78838475e-02f, -1.16335019e-01f,
  2.35724095e-02f, -1.65186301e-02f, 1.31568685e-01f, -9.02929679e-02f, 2.99213305e-02f, 9.61067975e-02f, -2.02859417e-02f, 4.86876629e-02f, 4.99152839e-02f, -3.36202830e-02f,
  8.69925469e-02f, 1.39334187e-01f, 4.69843298e-02f, 2.95835808e-02f, -5.49624264e-02f, 1.09318241e-01f, 5.86394705e-02f, -8.69363397e-02f, -4.96477447e-02f, -3.76460701e-02f,
  9.68595520e-02f, -6.58458248e-02f, 1.03974760e-01f, -1.01872217e-02f, -7.67971501e-02f, -5.78220561e-02f, 5.51795922e-02f, 1.31287530e-01f, -5.51912794e-03f, 2.48477831e-01f,
  -1.52475283e-01f, -8.90861675e-02f, -3.87385860e-02f, -1.86413363e-01f, 1.56438664e-01f, -1.10525377e-01f, -1.35959476e-01f, 1.22592844e-01f, 1.31528050e-01f, 1.27810985e-01f,
  2.58358605e-02f, 3.13288830e-02f, 3.51731852e-03f, 1.26917705e-01f, 2.08428223e-02f, -8.92516300e-02f, -1.01017496e-02f, -6.77830726e-02f, -2.08222829e-02f, 1.36034161e-01f,
  8.63294229e-02f, 5.28903194e-02f, 9.40156430e-02f, 6.45945743e-02f, 2.63523366e-02f, 2.66213678e-02f, 1.51942387e-01f, 9.67065319e-02f, 9.63096097e-02f, 1.59340650e-01f,
  7.55243823e-02f, 1.45966755e-02f, -1.53086320e-01f, -1.43064009e-02f, -1.67123675e-01f, 4.38156053e-02f, 1.29190058e-01f, -1.43298775e-01f, -1.07555948e-01f, -1.82180315e-01f,
  2.20977858e-01f, -1.29229724e-01f, -6.35790080e-02f, 4.78745438e-02f, -1.64727196e-01f, -6.31994829e-02f, -9.90275592e-02f, 1.48501620e-01f, -9.63849276e-02f, -5.69951534e-03f,
  -2.06786752e-01f, 1.91115774e-02f, -1.82094261e-01f, 2.30815664e-01f, -1.41574731e-02f, -1.84453726e-02f, 1.65925547e-02f, -6.25433773e-02f, 8.90117735e-02f, 1.09683484e-01f,
  4.53242451e-01f, 8.78554657e-02f, 6.55348673e-02f, 6.94737807e-02f, -5.10657355e-02f, 1.05376609e-01f, -1.18184574e-01f, 2.37980932e-01f, -7.71430507e-02f, 8.84541497e-02f,
  -1.23593070e-01f, 1.50094731e-02f, 1.74017146e-01f, -1.94200873e-01f, -5.91406412e-02f, -1.06008440e-01f, -2.17528734e-02f, 4.22690809e-03f, 1.35896295e-01f, 1.09002933e-01f,
  -3.34414244e-02f, -2.85905376e-02f, 1.13585718e-01f, 7.97520131e-02f, -4.92440499e-02f, -3.49195767e-03f, 1.08696688e-02f, -4.55808081e-02f, 7.11188912e-02f, 6.01937287e-02f,
  -6.21340647e-02f, -6.82674274e-02f, 1.15389470e-02f, 1.79857478e-01f, -1.23543162e-02f, 5.28371893e-02f, 1.27275676e-01f, 6.54869601e-02f, 7.52984658e-02f, 8.25287495e-03f,
  -6.56753704e-02f, -1.23567820e-01f, -2.28106409e-01f, -1.59879044e-01f, 1.66718617e-01f, -1.75886199e-01f, -1.12870902e-01f, 6.82040080e-02f, -8.43107998e-02f, -5.29248267e-02f,
  7.05573931e-02f, -7.01923817e-02f, 1.51474819e-01f, -2.08943427e-01f, 3.14052999e-02f, 1.29926682e-01f, -3.08924541e-02f, 1.81947038e-01f, -1.21921591e-01f, 3.53400037e-02f,
  2.87778452e-02f, 7.06423000e-02f, 7.56965652e-02f, 1.36129171e-01f, 2.51415998e-01f, 8.58667195e-02f, -1.14275254e-02f, 3.39041986e-02f, -1.09145857e-01f, -1.25095248e-01f,
  -1.19053870e-01f, 2.37841949e-01f, 1.15139829e-02f, 9.71616507e-02f, -1.48365824e-02f, -1.44349057e-02f, 4.04046737e-02f, 9.70956217e-03f, -1.40097681e-02f, -9.83297974e-02f,
  -1.13148704e-01f, -2.45746225e-02f, 1.26885340e-01f, 2.66689193e-02f, 1.09499320e-01f, 1.09460376e-01f, 8.26020613e-02f, 7.97231495e-02f, 9.06651840e-02f, 1.80733606e-01f,
  -1.14307962e-02f, 6.65643066e-02f, 1.45380363e-01f, -1.17643744e-01f, 4.69604470e-02f, 7.63027091e-03f, 1.76746711e-01f, 9.02763531e-02f, 2.13447899e-01f, 5.43882810e-02f,
  3.45302448e-02f, -5.14705963e-02f, 2.63363519e-03f, -1.86028779e-02f, 6.45972192e-02f, -1.60152279e-02f, 7.01876134e-02f, 1.04668893e-01f, -1.51278153e-01f, -5.15791886e-02f,
  2.62532774e-02f, 1.80770531e-02f, -8.62472281e-02f, -1.98167115e-02f, -8.43840465e-03f, 2.61099398e-01f, -1.39878199e-01f, 1.35150105e-01f, -1.47578850e-01f, -8.92469138e-02f,
  -1.76259339e-01f, 2.17213314e-02f, 6.65368140e-02f, -3.00675612e-02f, 3.98112908e-02f, -6.08883128e-02f, -1.20430820e-01f, 1.68873727e-01f, 3.25042665e-01f, 4.54645827e-02f,
  -1.37512937e-01f, 3.78544390e-01f, -3.14749852e-02f, 9.31783319e-02f, -1.24704674e-01f, -1.58626631e-01f, 2.73215561e-03f, 1.04670912e-01f, 3.41482311e-02f, -6.94657937e-02f,
  3.04457426e-01f, 2.87363771e-02f, -9.39773992e-02f, 1.28644228e-01f, -3.53587829e-02f, 2.06982285e-01f, 2.73775935e-01f, -6.36875927e-02f, 6.95154828e-04f, -1.90196589e-01f,
  1.54883325e-01f, 7.59772062e-02f, 1.04034223e-01f, 7.41924392e-03f, 1.14840731e-01f, 5.13868816e-02f, -1.70821715e-02f, -9.18593854e-02f, 9.61046740e-02f, 3.90737988e-02f,
  1.10320456e-01f, 5.61190546e-02f, 1.90592661e-01f, 1.10029496e-01f, -1.03264168e-01f, 1.96752306e-02f, 5.04979379e-02f, -8.05998500e-03f, 1.42547756e-01f, 2.16242507e-01f,
  -2.78901551e-02f, -1.30028605e-01f, 2.69201398e-01f, 2.99688522e-02f, 2.47064888e-01f, 1.17375061e-01f, -8.78387596e-03f, -1.12367412e-02f, 9.69661102e-02f, -2.15174273e-01f,
  -1.33587375e-01f, -1.99781194e-01f, 1.69622242e-01f, -1.36433214e-01f, 1.31142080e-01f, 5.06610386e-02f, 9.24283043e-02f, 3.28567182e-03f, 9.35959294e-02f, -1.19307913e-01f,
  1.17184013e-01f, -1.51808798e-01f, 1.50426686e-01f, -6.77447692e-02f, 7.91788753e-03f, -7.13572577e-02f, 1.36480421e-01f, -1.10309750e-01f, 2.92968135e-02f, 3.04024458e-01f,
  -6.64649010e-02f, -3.83944288e-02f, -1.54032558e-01f, -2.56322622e-01f, -2.61268675e-01f, 1.55715674e-01f, 8.85379389e-02f, 1.23242103e-01f, -3.27181928e-02f, 1.41552627e-01f,
  1.18536847e-02f, 5.04224412e-02f, -1.23516954e-02f, 2.04709992e-01f, -5.72125427e-03f, 2.55779803e-01f, 2.33027756e-01f, 3.18918914e-01f, 2.96931803e-01f, 1.61638081e-01f,
  9.42709446e-02f, 1.90674096e-01f, 1.93412423e-01f, 4.21258062e-02f, 2.96225786e-01f, 8.80236030e-02f, 1.23227090e-01f, -7.55658001e-02f, -2.28947103e-02f, 1.54683456e-01f,
  1.97489515e-01f, 2.05992609e-02f, -8.64508897e-02f, 4.02447619e-02f, 7.71571547e-02f, 1.62094131e-01f, -5.57505013e-03f, 2.15740532e-01f, 2.56377637e-01f, -1.50091857e-01f,
  1.43284395e-01f, -2.40785226e-01f, -2.34000497e-02f, 6.74344599e-02f, 1.63662776e-01f, -6.77357838e-02f, 1.07831635e-01f, 2.36293972e-01f, -3.86348218e-02f, -4.82205972e-02f,
  6.26477599e-02f, -2.01481909e-01f, -1.20193036e-02f, 1.15084667e-02f, 3.71214002e-02f, 2.27312446e-01f, -9.46320146e-02f, 4.94304597e-02f, 1.83030710e-01f, -2.07342803e-01f,
  6.00391254e-02f, -1.17088251e-01f, 1.06985550e-02f, 1.34057000e-01f, 2.28907149e-02f, 6.78289756e-02f, -1.56752080e-01f, -1.01912715e-01f, 2.31275827e-01f, 1.36364028e-01f,
  1.14806332e-01f, 1.16187081e-01f, 4.55198810e-02f, 5.05299926e-01f, -4.90767770e-02f, -8.38824734e-03f, 9.89139974e-02f, 7.49369040e-02f, 2.23482680e-03f, 2.02061296e-01f,
  -2.75331922e-02f, 2.32205346e-01f, 1.87253073e-01f, 1.23325422e-01f, 5.00427596e-02f, 1.29126489e-01f, -2.42876541e-02f, 4.87681068e-02f, 9.14554223e-02f, 4.32733111e-02f,
  1.29586250e-01f, -9.38254297e-02f, 1.72460094e-01f, 1.65617123e-01f, 9.03394725e-03f, -8.51538703e-02f, -1.26993701e-01f, 8.17161128e-02f, 9.23719406e-02f, 1.27801508e-01f,
  -1.92760781e-03f, 1.61548257e-02f, 2.05505520e-01f, 1.02081612e-01f, 5.87086082e-02f, -7.21332431e-02f, -6.30382746e-02f, 1.37759805e-01f, 9.14045274e-02f, 2.69561969e-02f,
  1.41470348e-02f, -9.25049707e-02f, -1.08060315e-01f, 9.03050080e-02f, 5.60438782e-02f, -1.34742158e-02f, -1.27826542e-01f, 2.79635247e-02f, -1.25593588e-01f, 1.95066988e-01f,
  1.24313109e-01f, -7.56043941e-02f, -3.30541171e-02f, -5.20266183e-02f, -3.99616174e-02f, -2.57287100e-02f, -7.75811076e-02f, 1.73171237e-01f, -4.63596843e-02f, 8.94172490e-02f,
  -2.03937337e-01f, 1.04579784e-01f, 1.91466585e-01f, -1.01872921e-01f, 2.93749738e-02f, -1.11988433e-01f, -1.35562360e-01f, 2.08240584e-01f, 8.22524354e-02f, -1.45524830e-01f,
  1.30086541e-01f, 6.56285584e-02f, 1.23205572e-01f, 2.29592219e-01f, 1.27178445e-01f, -1.89994369e-03f, 1.33514911e-01f, 1.67002067e-01f, 2.07284406e-01f, 1.03450842e-01f,
  4.35334481e-02f, 8.50935131e-02f, 1.86397910e-01f, 8.76471922e-02f, 2.09670916e-01f, -1.60104074e-02f, 1.71506435e-01f, -4.87848185e-02f, -5.19860834e-02f, -2.33436264e-02f,
  1.04092218e-01f, 6.59566000e-02f, -4.93287807e-03f, -2.20016599e-01f, 2.13482708e-01f, -1.41737655e-01f, 1.16384238e-01f, 6.15746938e-02f, -5.44998236e-02f, -2.46546865e-01f,
  -7.06938729e-02f, 9.87649783e-02f, -2.07165092e-01f, 1.46465190e-02f, 4.53642197e-02f, -4.58149686e-02f, 8.87295157e-02f, 1.03283539e-01f, -1.76225286e-02f, -2.14043837e-02f,
  -3.51225846e-02f, 4.18795533e-02f, -1.19040027e-01f, -6.46555126e-02f, 2.99083680e-01f, -1.61116291e-02f, 1.95029125e-01f, -1.43036157e-01f, -9.60361734e-02f, -8.04835781e-02f,
  6.26850501e-02f, 3.70948970e-01f, 1.41845003e-01f, 1.81675240e-01f, -2.14379281e-02f, 5.61407246e-02f, 1.05041042e-01f, -1.67919159e-01f, 1.66760515e-02f, -1.56990707e-01f,
  -4.78087477e-02f, -4.51817997e-02f, -1.95861962e-02f, -1.63854942e-01f, -1.13576069e-01f, 1.33669361e-01f, 6.69753104e-02f, -4.76111248e-02f, -4.93410267e-02f, -7.33736232e-02f,
  5.05639650e-02f, 1.85817078e-01f, -5.61822727e-02f, 1.07567742e-01f, -4.74823117e-02f, 6.55358210e-02f, 3.31173949e-02f, -6.89330399e-02f, 9.66733843e-02f, 1.88708119e-02f,
  1.38943449e-01f, -4.77438495e-02f, 1.89216331e-01f, 8.06584489e-03f, 1.24925010e-01f, -5.98877259e-02f, 6.78402558e-02f, 1.16977997e-01f, -1.88473731e-01f, 1.66698754e-01f,
  3.32252458e-02f, -1.44074395e-01f, -4.63201776e-02f, -7.53925517e-02f, 2.13518254e-02f, 6.57101348e-02f, 1.98918149e-01f, 1.07621811e-02f, 1.18535332e-01f, 9.84442234e-02f,
  -8.46345648e-02f, -1.54821754e-01f, -6.17010072e-02f, -1.03894114e-01f, 8.21674766e-05f, 7.56486580e-02f, -1.49131734e-02f, 7.70432688e-03f, -1.67167887e-01f, -3.44215222e-02f,
  8.55719298e-02f, 7.13270158e-02f, 9.60860848e-02f, -9.39881951e-02f, -1.19131915e-02f, -1.37171134e-01f, 1.44658953e-01f, -4.35811356e-02f, 8.65890682e-02f, 6.67854548e-02f,
  1.06197059e-01f, 1.21053621e-01f, 1.41067624e-01f, 1.98218554e-01f, 5.90951666e-02f, 3.07384849e-01f, 1.13440402e-01f, 5.97117282e-02f, -1.25975490e-01f, 7.99263194e-02f,
  -5.20059615e-02f, -1.10177621e-01f, -7.70852268e-02f, 2.91558206e-02f, -1.10593788e-01f, -7.21990764e-02f, -3.50185931e-02f, 2.33228207e-02f, -2.06648931e-02f, -9.59579572e-02f,
  3.84633131e-02f, -6.00853935e-02f, -3.24292108e-02f, 6.95501417e-02f, -1.02284320e-01f, -4.79144603e-02f, -3.09020188e-02f, 8.40002224e-02f, 5.76800928e-02f, -4.99413814e-03f,
  -3.80595843e-03f, 6.42856434e-02f, 6.41639978e-02f, 2.63112579e-02f, 3.86497341e-02f, 7.33151808e-02f, 1.15250744e-01f, 1.03984445e-01f, -2.37503219e-02f, 7.27383941e-02f,
  -8.79809633e-02f, 3.03031374e-02f, 2.73463316e-02f, -9.60143059e-02f, 5.37940636e-02f, 3.50490585e-02f, -8.04901645e-02f, 6.26907349e-02f, 4.47743535e-02f, 1.15432382e-01f,
  -7.37247765e-02f, 6.35861754e-02f, -1.19510181e-01f, -4.60146330e-02f, -4.88785915e-02f, -5.74595593e-02f, 4.38777357e-02f, -5.02699688e-02f, -7.50917345e-02f, -8.51174742e-02f,
  1.16803758e-02f, 1.19918197e-01f, -3.15926448e-02f, -1.41781149e-03f, 3.96191841e-03f, 3.03743165e-02f, -8.96612033e-02f, 8.79000947e-02f, 9.32913274e-02f, -1.17948748e-01f,
  -6.32634433e-03f, -5.75788207e-02f, 9.34682414e-02f, 1.01165809e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  7.77155310e-02f, 9.26854089e-02f, 1.35163307e-01f, 8.08454007e-02f, 1.24024697e-01f, 1.25247926e-01f, -6.71709254e-02f, 1.05909400e-01f, 3.44596733e-03f, 1.14638306e-01f,
  8.95735100e-02f, -2.02921741e-02f, -3.89762558e-02f, 1.08138807e-02f, -7.21873716e-02f, 9.48758647e-02f, 4.34493683e-02f, -6.37938902e-02f, -7.62730837e-02f, -3.06622796e-02f,
  1.11671098e-01f, 3.66052724e-02f, -1.34749413e-01f, 7.22900257e-02f, 1.07618876e-01f, 5.86358868e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.29132122e-01f, -2.18586579e-01f, -2.15402827e-01f, 8.36902484e-02f, 9.23049822e-02f, -5.57700880e-02f, -2.11896136e-01f, 3.11548710e-01f, -1.57970786e-01f, 1.83225647e-01f,
  2.34527811e-01f, -5.48578426e-02f, -2.23285351e-02f, -3.64667773e-01f, -2.40045488e-01f, -1.31445318e-01f, 2.75665313e-01f, -3.25959712e-01f, -9.35866237e-02f, -5.05760312e-01f,
  8.27113539e-02f, -1.22448698e-01f, -2.57237017e-01f, -2.21556008e-01f, -5.84821589e-02f, 7.21227974e-02f, 1.43599406e-01f, -9.41995755e-02f, -1.12494506e-01f, 2.07771331e-01f,
  3.16703439e-01f, 1.19646445e-01f, -6.22152872e-02f, -2.07209527e-01f, 2.50152320e-01f, 1.67496368e-01f, 3.62278461e-01f, 9.81886908e-02f, 3.63785833e-01f, 1.54043570e-01f,
  2.16785565e-01f, -2.68235624e-01f, -2.96814591e-02f, -3.79293151e-02f, -6.17446676e-02f, 3.25468451e-01f, 1.70639038e-01f, 4.29711670e-01f, 2.63727028e-02f, 9.68880951e-02f,
  -1.53374031e-01f, -2.16364220e-01f, 1.93605886e-03f, 4.93494747e-03f, 4.26794775e-02f, -8.58134180e-02f, 3.22146446e-01f, -3.45634788e-01f, -5.17307520e-02f, -5.24724066e-01f,
  -4.00476933e-01f, 1.10984534e-01f, -2.23230273e-01f, -4.12729159e-02f, -2.64460011e-03f, 3.51005942e-01f, 2.13883165e-02f, -3.15407157e-01f, -1.92836255e-01f, 2.69690305e-01f,
  -5.72608858e-02f, 1.25838339e-01f, 4.86003272e-02f, -2.06908897e-01f, -3.93835157e-01f, -2.37194464e-01f, -2.34498546e-01f, 2.98590269e-02f, 2.07029246e-02f, 2.22198695e-01f,
  -1.55598177e-02f, 1.20761879e-01f, 9.57616121e-02f, -4.33134101e-02f, 1.29028916e-01f, 5.25278032e-01f, -7.45505169e-02f, 4.43281502e-01f, -4.54456478e-01f, -2.11234875e-02f,
  -1.20867699e-01f, -2.17354536e-01f, -3.00223511e-02f, -3.09498191e-01f, -3.48126560e-01f, 3.72495875e-03f, 1.46024466e-01f, 3.96454930e-01f, -1.28541291e-01f, 9.24581662e-02f,
  1.68714076e-01f, 1.60961062e-01f, -1.65106088e-01f, 4.79130307e-03f, 1.04569949e-01f, -8.20157528e-02f, -1.80888116e-01f, -8.78722668e-02f, -2.24103153e-01f, 3.90951522e-02f,
  5.18466644e-02f, -3.89548838e-01f, 5.75500965e-01f, -3.57146226e-02f, 6.88160956e-02f, -4.64929678e-02f, -7.73496926e-03f, 1.41298054e-02f, -3.38207977e-03f, 3.80689949e-01f,
  1.76152691e-01f, 1.43855929e-01f, 3.03556621e-01f, -4.81944472e-01f, -1.33843377e-01f, 2.17126105e-02f, -2.74316408e-02f, -5.09934612e-02f, 2.63449073e-01f, -2.85590738e-01f,
  3.75533789e-01f, 2.83650905e-01f, 2.63283163e-01f, 2.55695134e-01f, -3.63064185e-02f, -1.30569145e-01f, -1.49411857e-01f, -2.08197489e-01f, 1.81395546e-01f, 3.22226375e-01f,
  -8.24750289e-02f, 3.28611523e-01f, 3.72806430e-01f, 9.92674977e-02f, 4.75634515e-01f, 3.07576895e-01f, -1.10185631e-02f, 3.18233848e-01f, -1.36934549e-01f, 5.21383844e-02f,
  -2.23163813e-01f, -2.80097991e-01f, 4.63303998e-02f, -3.95125180e-01f, -6.26164302e-02f, -2.30957016e-01f, 6.10772856e-02f, -8.66960138e-02f, -2.45916814e-01f, 2.38989338e-01f,
  -4.52806681e-01f, -3.62564176e-02f, 2.03519329e-01f, 2.18349863e-02f, -2.62619436e-01f, -8.91440958e-02f, -1.69403017e-01f, -1.14471897e-01f, -9.81544778e-02f, -5.64856827e-02f,
  1.93318531e-01f, -1.62212804e-01f, -1.81818351e-01f, 1.23096198e-01f, 1.25568360e-01f, -1.16672823e-02f, 1.25760689e-01f, 1.06538884e-01f, -3.13620925e-01f, -1.97334170e-01f,
  -8.69117007e-02f, 5.10999449e-02f, -8.82054344e-02f, 1.67584211e-01f, 1.33261353e-01f, 2.43804768e-01f, 1.24964014e-01f, 1.30333781e-01f, 2.67658383e-01f, 2.36336589e-01f,
  -1.55287623e-01f, 1.30805388e-01f, -1.10194184e-01f, -2.18694448e-01f, -4.01607901e-01f, -2.50644200e-02f, -1.03393413e-01f, -1.35765433e-01f, 7.58850574e-02f, 1.99848473e-01f,
  3.17965597e-02f, 8.44411999e-02f, -3.65077347e-01f, -3.93027693e-01f, 1.58076108e-01f, -1.70250416e-01f, -9.35353562e-02f, -8.79070237e-02f, -1.85371280e-01f, 2.74831831e-01f,
  -1.94566473e-01f, 2.52285928e-01f, -6.52038604e-02f, 1.40354214e-02f, 2.12703526e-01f, 1.23170927e-01f, -3.29662025e-01f, -1.80797413e-01f, 1.39174491e-01f, -9.74966139e-02f,
  -1.69648543e-01f, 1.47308424e-01f, 7.30139092e-02f, -2.46619239e-01f, -3.42275888e-01f, -2.20861271e-01f, 1.61713138e-01f, -2.38464370e-01f, -4.26720418e-02f, 2.49514505e-02f,
  3.68521392e-01f, 1.46297008e-01f, 1.82803832e-02f, 1.57766461e-01f, -2.02036813e-01f, -6.95214123e-02f, -1.73024714e-01f, 4.01853174e-02f, -2.99853474e-01f, 4.90790129e-01f,
  2.54887901e-02f, -1.25299469e-01f, -2.68524706e-01f, -2.64657974e-01f, 1.13711715e-01f, 1.18617518e-02f, -5.88424467e-02f, -4.66475368e-01f, -8.72844756e-02f, -2.96921402e-01f,
  2.22395137e-01f, 4.79315162e-01f, -4.74189129e-03f, -2.07659811e-01f, 1.10675752e-01f, 1.13730937e-01f, 3.47544998e-01f, -1.70191631e-01f, -2.22114116e-01f, 8.13476667e-02f,
  -3.73374820e-01f, 1.74111336e-01f, -3.27575594e-01f, -1.00965716e-01f, 3.17813009e-02f, 1.83131918e-01f, 2.08863452e-01f, -9.71374288e-02f, -1.30997121e-01f, -4.50967312e-01f,
  -2.80448943e-01f, -1.68718576e-01f, 1.87947541e-01f, 3.28613132e-01f, -2.13828534e-01f, 6.45950362e-02f, -1.67679697e-01f, -3.43471318e-01f, 2.00852349e-01f, -3.08227446e-02f,
  -6.93716928e-02f, -1.53319493e-01f, -1.80821382e-02f, -5.27057946e-02f, 2.49095783e-01f, 4.93831873e-01f, 4.84686852e-01f, -1.65009815e-02f, -2.59250849e-01f, -2.41146788e-01f,
  9.39187929e-02f, -3.04757416e-01f, 1.38115883e-01f, 1.17395900e-01f, 1.33007005e-01f, -2.24587768e-02f, 6.11753650e-02f, 2.21169274e-02f, 6.97930977e-02f, 4.53487188e-02f,
  -2.13255525e-01f, 7.83146098e-02f, 2.14689940e-01f, 2.22428888e-01f, -1.54859409e-01f, -6.49012402e-02f, -1.39139056e-01f, -8.04926902e-02f, -4.97486023e-03f, 8.48830566e-02f,
  -1.69329256e-01f, 2.12612197e-01f, 2.23609731e-01f, -3.23556662e-01f, -2.19601672e-02f, 3.15083385e-01f, 1.94054246e-01f, 7.19071403e-02f, 7.27694705e-02f, -7.46287778e-03f,
  7.87002146e-02f, 2.12411791e-01f, -1.43716797e-01f, 2.92387396e-01f, 4.80238140e-01f, 1.61620304e-01f, 1.74346909e-01f, -3.31493244e-02f, 2.55983267e-02f, -1.83850825e-01f,
  -1.93040177e-01f, -1.57387331e-02f, 1.48273662e-01f, 2.96924561e-01f, 3.30431089e-02f, 2.17891216e-01f, -1.95865631e-01f, 2.04829261e-01f, 1.14390964e-03f, -4.16542768e-01f,
  2.02215597e-01f, 1.66619807e-01f, -1.12253457e-01f, -1.92971490e-02f, 4.49462742e-01f, -3.22110116e-01f, 2.24897787e-02f, 3.39065105e-01f, 2.89244682e-01f, -3.03880781e-01f,
  -1.81626782e-01f, -2.30388805e-01f, -1.32331595e-01f, 8.41030478e-02f, -1.00419231e-01f, 3.62980306e-01f, -2.33121097e-01f, -3.45305651e-01f, -1.41583562e-01f, 6.39230013e-02f,
  6.50821701e-02f, -2.33189464e-01f, 3.66363823e-02f, 1.01020545e-01f, 2.05582008e-01f, 2.65588045e-01f, 2.94631004e-01f, 1.31979287e-01f, 8.58191028e-02f, -2.08811909e-02f,
  -3.39395136e-01f, 3.89000535e-01f, -9.35232490e-02f, -5.88541105e-02f, -5.42792343e-02f, 1.47991017e-01f, 8.32188129e-02f, 1.50846645e-01f, -2.60723948e-01f, -1.54568315e-01f,
  5.10182567e-02f, 2.37298980e-01f, -8.55070278e-02f, 6.15955330e-02f, 1.32129788e-01f, -1.11340649e-01f, 1.92590863e-01f, 1.14911087e-01f, 1.71315596e-01f, -1.55802518e-01f,
  1.28103733e-01f, -1.76290572e-01f, -3.75618204e-03f, 2.86614865e-01f, 2.31782660e-01f, 3.10030878e-01f, 9.23950449e-02f, 1.97486982e-01f, -1.46428426e-03f, 2.65169829e-01f,
  1.54624343e-01f, -3.23854238e-01f, 1.14532329e-01f, 3.59022230e-01f, 3.43305677e-01f, 2.81001896e-01f, 3.10998529e-01f, -2.02526599e-01f, 5.94817325e-02f, 3.73808116e-01f,
  1.27909616e-01f, -4.10412587e-02f, -3.36635374e-02f, -7.41612688e-02f, -1.85666785e-01f, -1.55729651e-01f, 5.65695643e-01f, 2.91709244e-01f, -3.43000531e-01f, -1.68660969e-01f,
  -1.89453408e-01f, -8.52674469e-02f, -5.60933836e-02f, 9.03925523e-02f, -1.18620008e-01f, 6.40361309e-02f, 2.18455642e-01f, 1.97283611e-01f, 1.33437186e-01f, -2.27027401e-01f,
  9.90941599e-02f, -3.48265171e-01f, -8.68782923e-02f, 1.92490339e-01f, 9.31617767e-02f, 1.09004542e-01f, -5.60795553e-02f, 8.13036337e-02f, -7.50155980e-03f, 1.29306361e-01f,
  2.64719222e-02f, 2.86281675e-01f, -2.22465426e-01f, -3.45934518e-02f, 3.12267780e-01f, 1.27216533e-01f, 1.37783894e-02f, -8.18855241e-02f, -2.01460421e-01f, -1.94650926e-02f,
  -1.92677584e-02f, -4.43343446e-02f, -1.45505860e-01f, 8.48077014e-02f, -1.51078524e-02f, -7.56570920e-02f, 1.43906444e-01f, 5.54879643e-02f, -1.68706849e-01f, -1.67290181e-01f,
  1.93994328e-01f, 2.21292287e-01f, 2.69532263e-01f, 2.18315065e-01f, -1.99219331e-01f, -1.53563634e-01f, -3.24888751e-02f, -1.99448075e-02f, -1.03445053e-02f, -3.46212000e-01f,
  5.36352918e-02f, -2.82383524e-02f, 2.45440736e-01f, 3.67970079e-01f, 1.68848801e-02f, -6.88460693e-02f, -3.64073157e-01f, 2.72352606e-01f, 2.48776674e-01f, 3.71178865e-01f,
  4.70966816e-01f, 2.20489991e-03f, -4.00995426e-02f, -1.06549904e-01f, -1.36754885e-01f, 1.37425130e-02f, 4.61087376e-02f, 1.05340913e-01f, -6.28691763e-02f, 3.28003675e-01f,
  3.70459743e-02f, 5.58202304e-02f, 1.53531030e-01f, -2.96473652e-01f, -1.41351998e-01f, 2.47027695e-01f, -2.36356750e-01f, -2.19718978e-01f, 3.27847153e-01f, -1.20078415e-01f,
  7.81842321e-02f, 5.66989556e-03f, -1.16746098e-01f, -3.70664656e-01f, -2.71361440e-01f, 1.60946265e-01f, -1.81495736e-03f, 3.10367435e-01f, -1.88913494e-01f, -4.72609878e-01f,
  4.81431633e-01f, -1.14947483e-01f, 2.63441540e-02f, 2.08335280e-01f, -1.05996259e-01f, 1.57590076e-01f, 4.02772948e-02f, -6.17981292e-02f, -1.22254983e-01f, 1.39680833e-01f,
  -2.96802312e-01f, 1.65636688e-01f, -4.83533978e-01f, -3.25495243e-01f, 1.15527369e-01f, -3.09129745e-01f, -9.97325033e-02f, -1.45465091e-01f, -3.39450926e-01f, -3.53656501e-01f,
  -8.25531259e-02f, -2.32372269e-01f, -3.03840667e-01f, 7.45315328e-02f, 1.76224351e-01f, 3.26157421e-01f, 1.60953298e-01f, 4.88676220e-01f, 1.16249926e-01f, 2.83849180e-01f,
  1.43820107e-01f, -1.84210315e-01f, -1.67118177e-01f, 2.43269056e-01f, 4.52273220e-01f, 1.29338264e-01f, -1.13435231e-01f, 3.56577843e-01f, 7.07412092e-03f, -3.95079136e-01f,
  -1.26728222e-01f, -9.76479519e-03f, 2.72044563e-03f, -2.69289967e-02f, -3.91635783e-02f, 2.86377192e-01f, 2.26342946e-01f, -1.04546249e-01f, 1.10901622e-02f, -3.21561098e-02f,
  3.86974931e-01f, -1.09842651e-01f, 2.24313453e-01f, 2.61952162e-01f, -1.71655091e-03f, 3.73895951e-02f, 2.39015400e-01f, 7.95790702e-02f, -2.21195325e-01f, 2.12446868e-01f,
  -2.24276364e-01f, -2.99874574e-01f, -1.67293951e-01f, -1.11116953e-01f, -4.86866422e-02f, -1.01425417e-01f, -2.67202049e-01f, -1.86154187e-01f, 1.08048066e-01f, -2.13530883e-02f,
  -3.58807355e-01f, -7.97333941e-02f, 4.06227827e-01f, -1.25665888e-01f, 1.57316133e-01f, 2.04723716e-01f, 1.12948895e-01f, 3.02372485e-01f, -1.59793273e-02f, 4.75741148e-01f,
  4.84196454e-01f, 2.05433950e-01f, -2.19669238e-01f, -1.65528342e-01f, -1.03985080e-02f, 3.57383311e-01f, -6.63751662e-02f, -2.90143460e-01f, 2.07070306e-01f, -1.34263217e-01f,
  1.79575294e-01f, -1.45537391e-01f, 1.16386130e-01f, 3.59296147e-03f, 1.30510563e-02f, 5.01935959e-01f, 2.93010980e-01f, -1.52009651e-01f, -2.37943187e-01f, -2.65086204e-01f,
  2.34089836e-01f, -3.85327756e-01f, -3.58924240e-01f, 1.49179041e-01f, -4.92819101e-02f, 7.38754794e-02f, -8.82257000e-02f, 1.28800884e-01f, 2.43757311e-02f, 6.61297441e-02f,
  -3.55040021e-02f, -3.19831073e-01f, 9.09209326e-02f, 4.12746295e-02f, -2.02406049e-01f, 1.00528993e-01f, -1.52487859e-01f, 2.28538234e-02f, 8.56806338e-02f, 9.00162533e-02f,
  -1.03981150e-02f, 6.65752441e-02f, 6.84864447e-02f, 1.21731006e-01f, -1.30941361e-01f, 4.97464091e-01f, 3.03353667e-01f, 7.95806125e-02f, 8.15173984e-02f, -5.98269748e-03f,
  3.41322348e-02f, -1.40193030e-01f, 2.25414857e-01f, 2.80318465e-02f, 2.48494789e-01f, -2.28227526e-01f, -3.61328870e-01f, 2.79207379e-01f, 8.47277418e-02f, -2.39188015e-01f,
  1.11542612e-01f, 4.59561467e-01f, -1.90446228e-01f, -1.29129082e-01f, 3.38767618e-02f, -9.87012535e-02f, 1.42906364e-02f, 8.13295308e-04f, 2.02820450e-01f, -3.87666255e-01f,
  6.40164167e-02f, -8.99107754e-02f, -3.48125935e-01f, 2.11752102e-01f, -3.95737737e-01f, -2.48746172e-01f, 1.33369207e-01f, -1.53567225e-01f, 1.81367427e-01f, -1.92982003e-01f,
  -4.99043763e-02f, -1.66408196e-01f, -4.14619178e-01f, -4.14908499e-01f, 1.27646789e-01f, 5.02088070e-01f, 2.79377818e-01f, -6.72183186e-02f, 1.26144318e-02f, 6.92078248e-02f,
  4.63011377e-02f, -1.24919049e-01f, -6.75461143e-02f, 1.52315311e-02f, -6.24335408e-02f, 2.59958625e-01f, -3.50991219e-01f, -2.67038673e-01f, -1.15567774e-01f, -5.78490384e-02f,
  -2.41532013e-01f, 9.83659178e-02f, 3.24818194e-02f, -8.65658149e-02f, -4.04691584e-02f, -1.62509516e-01f, -1.74629956e-01f, -4.25900877e-01f, 5.61378479e-01f, 1.37103349e-01f,
  7.20815267e-03f, 4.65292394e-01f, -1.13191023e-01f, -2.26701852e-02f, -2.35621650e-02f, 1.37512431e-01f, -8.87131989e-02f, -2.40641594e-01f, 1.15682324e-02f, -5.16040996e-02f,
  -1.55379429e-01f, -5.52069955e-03f, -1.74953341e-01f, -1.21636942e-01f, 2.03229561e-01f, 1.94691807e-01f, 2.20690984e-02f, -1.99690878e-01f, -2.06455499e-01f, -1.86669886e-01f,
  9.17366892e-02f, -5.34469858e-02f, -2.28254404e-02f, 2.93664396e-01f, -2.23934636e-01f, 2.85420626e-01f, 1.25932828e-01f, -1.29118606e-01f, 2.65261121e-02f, 2.29194134e-01f,
  5.05980328e-02f, 6.93728924e-02f, -3.45645607e-01f, -2.42564410e-01f, -1.59924060e-01f, 1.29828200e-01f, 2.25848600e-01f, 6.48678839e-02f, -1.22744627e-01f, -1.54338524e-01f,
  7.95753598e-02f, -4.43873852e-02f, -2.02623606e-02f, -6.80733696e-02f, -2.02172212e-02f, 2.54297733e-01f, -6.97660223e-02f, 3.24595064e-01f, 2.65366465e-01f, -1.85680419e-01f,
  1.33588379e-02f, -2.11685956e-01f, -2.30873987e-01f, -6.15866147e-02f, 5.62502861e-01f, 1.85460627e-01f, -6.11910189e-04f, -1.16263665e-01f, 3.82610232e-01f, -2.63525128e-01f,
  -2.74699211e-01f, 1.52048260e-01f, -3.46681833e-01f, -1.14809528e-01f, -4.38084006e-02f, -4.18981999e-01f, 2.48807326e-01f, 6.74002990e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.55598065e-02f, -6.07474074e-02f, -1.65566549e-01f, -7.05564320e-02f, -1.01843096e-01f, 4.46308702e-02f, 6.81673214e-02f, 1.45914495e-01f, 1.79665890e-02f, -8.69360268e-02f,
  1.23065606e-01f, 6.60529872e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    