/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.67537645e-01f, -2.16921851e-01f, -3.17541957e-02f, -3.49989921e-01f, 1.45566240e-01f, -1.53178886e-01f, -2.17650726e-01f, -1.63787186e-01f, 1.58798471e-02f, -7.02861547e-02f,
  -1.14111535e-01f, -5.30382320e-02f, 9.44235101e-02f, -3.98552626e-01f, -1.50823683e-01f, -5.75202778e-02f, -3.86287242e-01f, -2.56160885e-01f, 9.55774859e-02f, -6.82566389e-02f,
  -5.63137121e-02f, -2.67311215e-01f, -1.74156785e-01f, 3.73683907e-02f, -1.34383351e-01f, 3.85488756e-02f, -3.55138369e-02f, 1.67929336e-01f, -2.23241419e-01f, -5.58852516e-02f,
  6.25810549e-02f, 1.14985285e-02f, -1.49776153e-02f, 6.01812787e-02f, -8.71417597e-02f, -3.62657406e-03f, 4.52606976e-02f, 4.06026058e-02f, 2.40381975e-02f, -5.53563051e-02f,
  5.12650385e-02f, -1.75758842e-02f, -3.80409136e-02f, 5.20680547e-02f, -1.75005440e-02f, -7.02340901e-03f, -7.47953951e-02f, -5.04231341e-02f, 9.64152534e-03f, -8.27471688e-02f,
  5.01311570e-02f, 4.98524271e-02f, -9.07121692e-03f, -1.06366603e-02f, 5.04444540e-02f, -5.52314147e-02f, -7.37467706e-02f, 8.00933503e-03f, -5.80477295e-03f, 2.03463845e-02f,
  -5.81736900e-02f, 2.96884030e-02f, -5.73734567e-02f, 5.07784449e-02f, -4.33480367e-02f, 9.96457692e-03f, -5.97983822e-02f, 4.77217184e-03f, -1.07684478e-04f, 2.60780775e-03f,
  -3.48924994e-02f, -3.42370011e-02f, 1.25598919e-03f, -3.18384208e-02f, -1.98411681e-02f, 2.55470388e-02f, 5.54323010e-02f, 3.84376720e-02f, 5.26959300e-02f, -7.29750609e-03f,
  1.88826229e-02f, -3.07820784e-03f, 3.89669021e-03f, 2.09816583e-02f, 2.23453413e-03f, 3.06691881e-02f, -2.25149444e-03f, 4.91449796e-02f, 1.10637583e-02f, -6.74087629e-02f,
  -1.55674219e-01f, -1.92811906e-01f, 5.91103919e-02f, 1.84786264e-02f, 1.06271766e-02f, -1.77607720e-03f, -1.78059787e-02f, -3.63065004e-02f, 4.27541547e-02f, 4.52803932e-02f,
  9.28180441e-02f, -2.03081965e-02f, 1.13515936e-01f, -4.74236831e-02f, 7.50677520e-03f, -5.48457913e-02f, 6.27393350e-02f, 8.35287794e-02f, -1.32700071e-01f, -7.08392337e-02f,
  -8.15847516e-02f, 3.34495530e-02f, 6.84439251e-03f, 5.05609699e-02f, -3.28662209e-02f, 6.22096844e-02f, 1.45548079e-02f, 1.00026064e-01f, -3.97166871e-02f, -1.01007223e-02f,
  -1.93029836e-01f, -6.22971393e-02f, -2.21584346e-02f, -2.38000378e-01f, -8.23214054e-02f, 2.58658290e-01f, 3.94106179e-01f, -2.22829387e-01f, 5.94965443e-02f, 1.04657980e-02f,
  1.72103509e-01f, -1.89050183e-01f, 3.03048164e-01f, -1.22826152e-01f, 1.22458555e-01f, 2.81374007e-01f, -1.24104805e-02f, -4.69958894e-02f, 1.55644054e-02f, -1.70918688e-01f,
  -2.04524491e-02f, -1.58588350e-01f, 3.23387347e-02f, -1.54039159e-01f, -8.15146565e-02f, -1.16495453e-01f, -2.03692123e-01f, 2.15470642e-01f, -2.82890469e-01f, 1.43645108e-02f,
  1.36141300e-01f, 7.06886277e-02f, -5.61980121e-02f, 2.99820695e-02f, -2.18159854e-02f, -2.14021262e-02f, -4.30733934e-02f, 8.86918902e-02f, 1.46156847e-01f, 7.81714320e-02f,
  -1.44678936e-03f, -3.17700580e-02f, -5.61782084e-02f, -1.80442333e-02f, -1.70010589e-02f, -6.92447275e-02f, 6.51742972e-04f, -2.01901942e-02f, -9.04396549e-02f, -5.80661409e-02f,
  1.48378601e-02f, 2.64555495e-03f, -5.68797104e-02f, -1.77646689e-02f, -6.15039505e-02f, 4.06579860e-02f, 2.41345484e-02f, 3.17905396e-02f, 3.64711881e-02f, -1.10508487e-01f,
  -1.05595027e-04f, 2.87577696e-02f, 7.29029700e-02f, -2.71209013e-02f, 7.76960775e-02f, -7.19022751e-02f, -2.23823301e-02f, 3.15393205e-03f, -2.02923845e-02f, 3.46267223e-03f,
  2.22890880e-02f, -2.41310801e-02f, -3.37260403e-02f, 6.73195496e-02f, -7.02550076e-03f, -1.85132436e-02f, 1.35921100e-02f, 1.78437904e-02f, -5.91808707e-02f, -2.87931273e-03f,
  -1.58793461e-02f, -4.85595576e-02f, 4.62082364e-02f, -3.90487053e-02f, 7.80076683e-02f, 2.02869978e-02f, -4.26149890e-02f, -8.75335559e-02f, 8.85620266e-02f, 2.01752018e-02f,
  -2.65572891e-02f, -2.67812889e-02f, -4.57684547e-02f, -5.62037230e-02f, 2.81550717e-02f, 2.86427625e-02f, 4.40948159e-02f, -1.04620479e-01f, -1.39948875e-02f, 8.35557375e-03f,
  -3.64297554e-02f, -3.33620645e-02f, -7.01855794e-02f, 1.39112221e-02f, 2.88914759e-02f, 6.33350760e-02f, -2.36999355e-02f, 6.40735477e-02f, 8.75696889e-04f, 3.67279798e-02f,
  -4.64202650e-02f, 9.89765376e-02f, 3.03072836e-02f, -7.66124874e-02f, -8.61140117e-02f, 2.95795891e-02f, -1.77335329e-02f, 5.79075404e-02f, 2.39249226e-02f, 2.26703808e-02f,
  2.37125471e-01f, -2.68378824e-01f, 9.42994356e-02f, 1.82305932e-01f, 1.39942482e-01f, -1.25935331e-01f, 4.73907031e-02f, -4.66178469e-02f, -1.27599373e-01f, -2.24252209e-01f,
  1.52800139e-03f, 1.52398407e-01f, -1.80491000e-01f, -2.39066795e-01f, 2.72015929e-01f, -2.95815915e-01f, -1.02138460e-01f, -8.92178416e-02f, -3.37869227e-02f, 1.26460612e-01f,
  1.98535502e-01f, -1.17356338e-01f, 2.31813893e-01f, -7.69218281e-02f, 4.97894734e-02f, 2.07646579e-01f, 1.89172104e-01f, 1.55274168e-01f, 1.03903204e-01f, 2.96369515e-04f,
  -1.29295990e-01f, -1.20450504e-01f, 9.00855660e-02f, -1.14139199e-01f, 9.06834528e-02f, -2.62601878e-02f, -4.90599796e-02f, -1.87570173e-02f, 1.23705834e-01f, -6.59195855e-02f,
  -5.44231534e-02f, 3.77584919e-02f, 1.74783692e-02f, -2.03831177e-02f, -4.07144949e-02f, -3.45440581e-02f, 2.36868486e-02f, 1.73073332e-03f, -4.34124097e-02f, 8.97261128e-02f,
  1.37669093e-03f, -2.04768050e-02f, -2.14620586e-02f, -2.62605492e-02f, 1.15251429e-01f, 3.97754386e-02f, 7.59645253e-02f, 1.05946861e-01f, -3.65872197e-02f, 1.04966663e-01f,
  -1.62069604e-01f, -2.65452405e-03f, 2.09739394e-02f, -3.48942727e-02f, 1.14730559e-02f, 5.46553312e-03f, -7.94443563e-02f, 1.00045633e-02f, -2.15522982e-02f, -6.13920949e-02f,
  8.88507292e-02f, 2.63363533e-02f, -1.10092014e-01f, 4.70173731e-03f, 8.79971385e-02f, -2.85615921e-02f, 1.23760412e-02f, 7.05504641e-02f, 5.95184974e-02f, 1.81587394e-02f,
  -1.05656914e-01f, -2.96390941e-03f, -1.61868408e-02f, -3.74328606e-02f, -8.03528577e-02f, 7.75110200e-02f, -8.74713436e-02f, 4.23962101e-02f, -2.51789186e-02f, 3.91922817e-02f,
  -1.17181540e-01f, -3.60153578e-02f, 2.47402936e-02f, 6.28033206e-02f, -1.51007220e-01f, -2.64367480e-02f, -7.08393380e-02f, -5.12244068e-02f, -8.35966505e-03f, 1.66645125e-02f,
  -3.35418712e-03f, 3.00335251e-02f, -5.56880236e-02f, -6.47013634e-03f, 5.64830378e-03f, -1.45031074e-02f, 8.20401832e-02f, 1.62845701e-02f, -7.05000684e-02f, 1.92205161e-02f,
  3.44634168e-02f, 8.91232714e-02f, -3.44315520e-03f, 6.21206984e-02f, -1.01451706e-02f, -7.83148780e-03f, 1.93429440e-02f, 7.20413122e-03f, 1.91650409e-02f, -6.73719943e-02f,
  -1.80112556e-01f, -3.93556267e-01f, 2.52258778e-01f, -1.12353310e-01f, 4.14859131e-02f, 1.48313567e-01f, 4.14678305e-02f, 2.30129398e-02f, -1.68532744e-01f, -2.15445280e-01f,
  9.68176499e-02f, 4.82776128e-02f, -4.80471253e-02f, 4.49859388e-02f, -9.58849862e-02f, -1.40100330e-01f, -1.96723804e-01f, -8.59891698e-02f, 4.36140262e-02f, -1.30341113e-01f,
  9.85328183e-02f, -6.60117269e-02f, 1.37560323e-01f, 5.95008060e-02f, 9.15511027e-02f, 5.11772931e-02f, -1.81785375e-01f, 6.71664178e-02f, 6.56626448e-02f, 6.51667789e-02f,
  9.75910798e-02f, -1.62444972e-02f, 1.64260402e-01f, -7.17918128e-02f, 5.66915758e-02f, 1.45329788e-01f, 8.07205215e-02f, 1.79879054e-01f, 1.11487471e-01f, -1.56388450e-02f,
  7.89686218e-02f, 1.67197362e-01f, -2.13008970e-02f, -1.05466656e-02f, -2.33393665e-02f, 6.23483472e-02f, 7.50960186e-02f, 3.40548083e-02f, 1.03211813e-01f, 1.45791337e-01f,
  1.15143940e-01f, 8.96729231e-02f, 6.47582486e-02f, -2.54672226e-02f, 1.11211993e-01f, 6.10425547e-02f, 1.10348035e-02f, -1.66518874e-02f, -1.49169620e-02f, -1.01745419e-01f,
  -2.61197891e-02f, -2.68680565e-02f, 2.15151515e-02f, 4.23303284e-02f, -9.80716124e-02f, 4.51651290e-02f, -2.34608166e-02f, 7.04484284e-02f, -2.31536794e-02f, 1.81752201e-02f,
  2.96703284e-03f, 1.70945078e-02f, 5.36415214e-03f, -3.93489003e-03f, 2.62398589e-02f, -6.85525686e-02f, 9.72631052e-02f, -4.88154367e-02f, 9.78313107e-03f, 1.02610864e-01f,
  6.14589872e-03f, -3.23559418e-02f, -8.48028902e-03f, 4.96372357e-02f, -4.71647419e-02f, 1.72892362e-02f, 5.85138649e-02f, 2.52333544e-02f, -4.20890450e-02f, 6.91066608e-02f,
  -1.73994541e-01f, -4.80615616e-01f, -2.04703156e-02f, 2.18734648e-02f, -1.15343720e-01f, -4.34429832e-02f, -4.76553440e-02f, 2.57238578e-02f, -7.31342733e-02f, -1.14014372e-01f,
  6.45120740e-02f, 1.62597876e-02f, -3.24527919e-02f, 4.06467654e-02f, 3.92303914e-02f, -7.86287636e-02f, -3.25504094e-02f, -4.31956053e-02f, 1.69144536e-04f, -1.15532555e-01f,
  5.25393486e-02f, -7.79515505e-02f, 7.90870339e-02f, 1.40074044e-01f, -1.37722781e-02f, -5.21682054e-02f, -8.81555080e-02f, 6.44000173e-02f, 5.80720454e-02f, -4.73238565e-02f,
  3.79836917e-01f, 2.72770196e-01f, -5.26600480e-02f, 3.02714705e-01f, 8.67579654e-02f, -1.50852138e-02f, -2.44395956e-01f, 3.16795617e-01f, 2.20799878e-01f, -3.01618297e-02f,
  -4.09309901e-02f, 1.35363579e-01f, -2.31916681e-01f, -6.73218220e-02f, -1.50298461e-01f, -2.31873795e-01f, -4.03606147e-02f, 1.06777325e-01f, 1.04760773e-01f, 1.55255169e-01f,
  1.23328358e-01f, -1.05526000e-02f, -2.32060164e-01f, 1.88969046e-01f, 1.50483981e-01f, 1.84639171e-01f, -2.85610761e-02f, 1.34022674e-02f, 3.86729501e-02f, 1.69898886e-02f,
  7.90098459e-02f, 9.68938842e-02f, -6.42390177e-02f, -7.68796587e-03f, 1.32670440e-02f, -5.30693755e-02f, -5.00881337e-02f, -1.44084871e-01f, -8.44023824e-02f, -1.80978025e-03f,
  -7.60395005e-02f, 1.95062850e-02f, 4.07023635e-03f, 1.07675157e-02f, 8.60850960e-02f, 6.39721230e-02f, -2.35178359e-02f, -3.48402224e-02f, 7.26239458e-02f, -5.86318821e-02f,
  -6.37087971e-02f, -6.83861375e-02f, 1.36100426e-02f, -5.10265194e-02f, 3.32998903e-03f, 5.00773415e-02f, -4.57493588e-02f, -5.01055568e-02f, 3.17950663e-03f, 9.72799286e-02f,
  -2.00135354e-02f, 3.69303897e-02f, -5.83981238e-02f, -1.69362389e-02f, -6.26056269e-03f, -1.85745545e-02f, 1.03667444e-02f, -8.02182779e-02f, 4.87564616e-02f, 7.15698525e-02f,
  8.37647393e-02f, 1.08546920e-01f, 4.11019847e-02f, -3.97324823e-02f, -1.02484440e-02f, 1.54179113e-03f, -6.65755123e-02f, 7.40029216e-02f, 3.74343544e-02f, 7.00611472e-02f,
  3.44392136e-02f, 6.30057603e-02f, 1.20743781e-01f, -1.97381750e-02f, -3.26107033e-02f, -4.81446795e-02f, 7.30515495e-02f, -2.99436651e-04f, -7.46740326e-02f, -4.46246490e-02f,
  2.35113531e-01f, 3.63602251e-01f, -3.72160040e-02f, 7.21311569e-02f, -1.00496791e-01f, -1.73219126e-02f, -2.26053130e-02f, 1.95108280e-02f, 2.05993149e-02f, -2.81755440e-02f,
  -5.88725135e-02f, 4.69801128e-02f, 8.67705047e-02f, -1.37414308e-02f, -2.37522982e-02f, -3.66118029e-02f, -4.29197401e-02f, -2.00052913e-02f, -1.85659342e-02f, 1.29506990e-01f,
  5.47913276e-02f, 5.07466607e-02f, -8.15127715e-02f, 1.03243478e-01f, -2.74002124e-02f, -1.10437505e-01f, 1.34848520e-01f, -2.10711490e-02f, -5.97804524e-02f, -2.18376387e-02f,
  4.41740423e-01f, -1.74960151e-01f, 1.71070680e-01f, 1.93262529e-02f, 7.65645504e-02f, -3.43392193e-01f, -3.57629955e-01f, -8.93537402e-02f, -1.03732243e-01f, -3.77313852e-01f,
  -2.51258343e-01f, 1.45529199e-03f, -2.31855929e-01f, -2.11635932e-01f, 1.97204217e-01f, -2.30709642e-01f, -4.45527770e-02f, -1.18561924e-01f, 1.33854542e-02f, 3.97253148e-02f,
  1.28294915e-01f, -1.12713195e-01f, 2.16942616e-02f, -8.32297727e-02f, 1.52626392e-02f, 8.60135034e-02f, 8.88522640e-02f, -7.92188803e-04f, -1.12085596e-01f, -1.08895965e-01f,
  -4.80559282e-02f, -1.33422047e-01f, 9.77803841e-02f, -1.64132286e-03f, 4.10068175e-03f, 2.14720089e-02f, 2.29157060e-02f, 5.79698831e-02f, 3.77240181e-02f, -5.51901087e-02f,
  3.77929322e-02f, 5.23969457e-02f, -6.37268415e-03f, 4.90602851e-02f, 4.76584770e-02f, 2.29298398e-02f, -2.85182875e-02f, -2.64698677e-02f, -1.35051116e-01f, -3.28997858e-02f,
  -5.00811152e-02f, 4.73552160e-02f, 1.32858949e-02f, -7.68587412e-03f, 5.65957353e-02f, 2.26418767e-02f, 6.70311507e-03f, 1.19580636e-02f, -2.85503641e-02f, 5.34722172e-02f,
  -2.52740849e-02f, -4.76528518e-02f, 3.63840200e-02f, -3.99366133e-02f, 1.17492173e-02f, -2.13974994e-02f, -1.02518806e-02f, -9.05136112e-03f, 6.67365789e-02f, -4.95533459e-02f,
  3.50865349e-03f, 3.24759819e-02f, 5.07909693e-02f, -3.85718304e-03f, -3.10957711e-02f, -3.76374391e-03f, 2.25322768e-02f, -5.61414920e-02f, 4.43825461e-02f, 1.66746937e-02f,
  -7.40437256e-03f, 1.69597808e-02f, -1.31010786e-01f, -1.17789647e-02f, -8.06848928e-02f, 1.96696315e-02f, 2.44235597e-03f, -4.64247279e-02f, -1.45037398e-02f, 8.65325630e-02f,
  -1.74371377e-01f, -1.11987621e-01f, -1.09573387e-01f, -4.05481644e-02f, -4.37610447e-02f, 7.95820057e-02f, -2.37842910e-02f, -2.45408490e-02f, -1.53031573e-02f, 2.70292312e-02f,
  4.98563386e-02f, 2.11874060e-02f, -1.54882055e-02f, 1.99614055e-02f, -7.09219202e-02f, -4.28103358e-02f, -1.41937388e-02f, 1.06735900e-02f, 9.29605961e-02f, -7.18405098e-02f,
  -5.99832721e-02f, 2.86970614e-03f, 7.27170855e-02f, -4.26497161e-02f, 2.96731554e-02f, -6.75018728e-02f, 7.28547797e-02f, -2.52747331e-02f, 6.02226891e-02f, -8.67673829e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.96363416e-02f, -3.22293133e-01f, 2.37600192e-01f, 1.73626915e-02f, -3.57939601e-02f, 9.51869413e-02f, 4.15032744e-01f, -4.28087622e-01f, -2.84505129e-01f, -2.85524100e-01f,
  -7.28253722e-02f, 3.79107505e-01f, 1.16576426e-01f, -1.44275621e-01f, 6.49671078e-01f, 1.19928375e-01f, -2.40773320e-01f, 2.34861895e-01f, -2.13082939e-01f, -2.14748487e-01f,
  1.36329466e-02f, -2.88288534e-01f, 1.71083197e-01f, -3.24779749e-01f, -6.96829930e-02f, -2.47607276e-01f, 1.14585124e-01f, 1.71338975e-01f, -7.86339939e-02f, 2.69280106e-01f,
  -1.19592644e-01f, -3.02521408e-01f, -1.59234688e-01f, -3.57603207e-02f, -8.95631909e-02f, 1.78466961e-02f, 1.62444651e-01f, 2.30625302e-01f, 4.65618409e-02f, 1.35409161e-02f,
  4.55150194e-02f, -3.94193791e-02f, -7.94492438e-02f, -3.53467166e-02f, -1.01508044e-01f, -1.14267908e-01f, -1.03645198e-01f, -1.70821741e-01f, -2.59016789e-02f, 2.06697211e-02f,
  -6.95200190e-02f, -1.25445992e-01f, -3.60684134e-02f, -1.64852738e-02f, 2.33108271e-03f, -1.14085615e-01f, 3.80911306e-02f, 1.28683776e-01f, 9.87368356e-03f, -2.33330335e-02f,
  -6.39003376e-03f, -8.08824692e-03f, -1.92917809e-02f, 3.42343119e-03f, -3.25792655e-02f, -2.46538911e-02f, -8.43978673e-03f, 4.56318371e-02f, 3.71259302e-02f, -6.89239204e-02f,
  -5.83503023e-02f, 2.20039785e-02f, -1.24845736e-01f, -7.30134547e-02f, -8.28348398e-02f, 6.70180796e-03f, 9.76622254e-02f, 2.28328374e-03f, -6.73403740e-02f, -7.63539746e-02f,
  7.81716183e-02f, 6.24139458e-02f, -2.50567272e-02f, 7.93666318e-02f, -3.97398835e-03f, 7.26679191e-02f, -7.80534521e-02f, 7.23677501e-03f, -1.35943070e-01f, 1.89100504e-01f,
  -3.68674845e-02f, -9.02181491e-02f, -1.24726653e-01f, -1.34359717e-01f, 9.28373486e-02f, -2.96242051e-02f, -3.51300240e-02f, -1.05827644e-01f, -1.18694054e-02f, -2.56775152e-02f,
  -1.37616545e-01f, -7.24759027e-02f, 3.26431915e-02f, 1.48449163e-03f, 7.67171558e-04f, -2.55675009e-03f, 1.05224587e-01f, 1.27387922e-02f, 4.05427366e-02f, -1.02110840e-01f,
  -1.05469383e-01f, -5.94462967e-03f, -3.21254730e-02f, -9.61971432e-02f, -1.02352522e-01f, 1.11992203e-01f, 5.22113889e-02f, -6.02057837e-02f, 2.98184920e-02f, 2.85537262e-02f,
  -6.13684833e-01f, 5.57732522e-01f, 5.51673710e-01f, -5.29356480e-01f, 3.13826084e-01f, 3.00852716e-01f, -2.89938211e-01f, 4.17957366e-01f, -3.93962003e-02f, -1.09581828e-01f,
  -1.82969674e-01f, 1.38722077e-01f, 9.87821370e-02f, -9.77846682e-02f, -2.35861003e-01f, -6.18976764e-02f, -1.84023619e-01f, -2.01599061e-01f, 1.09265588e-01f, 3.52037847e-02f,
  -1.16257347e-01f, -2.35908240e-01f, 1.03567578e-01f, 2.52529442e-01f, 1.73809364e-01f, 3.26711684e-03f, -3.28383237e-01f, 2.80789793e-01f, 3.96509208e-02f, 1.70958564e-01f,
  -3.85089219e-01f, -1.95949554e-01f, -9.07255858e-02f, 7.57013867e-03f, 4.30404358e-02f, 3.75976562e-02f, -1.77500814e-01f, -4.50140648e-02f, 5.26099978e-03f, 6.41502216e-02f,
  -5.30340988e-03f, 9.00501013e-02f, 2.25898661e-02f, 7.98789188e-02f, 1.04042768e-01f, 7.88320601e-02f, 1.02468595e-01f, 7.97466782e-04f, 1.28099158e-01f, 1.39176026e-01f,
  1.29042313e-01f, 4.56231348e-02f, 2.94129271e-02f, -2.62754261e-02f, 1.94367934e-02f, 3.89122255e-02f, -1.11304680e-02f, 3.75318713e-02f, 3.55991833e-02f, 1.07458279e-01f,
  5.14630154e-02f, -9.58443433e-02f, 1.28736347e-03f, -1.35569433e-02f, -6.30457550e-02f, 6.84948638e-02f, 4.77243960e-02f, -1.06355034e-01f, -3.69521268e-02f, -3.23157646e-02f,
  -5.27280346e-02f, -2.15480048e-02f, -7.47287497e-02f, -1.11971386e-01f, -6.49206713e-02f, -9.04531330e-02f, -5.80748245e-02f, 1.98675711e-02f, -5.29789738e-02f, -3.60530019e-02f,
  -1.38106551e-02f, -8.13891441e-02f, 6.47189319e-02f, -5.57607524e-02f, 9.36860442e-02f, -7.14804530e-02f, 6.05270788e-02f, 7.65630081e-02f, -2.94343196e-02f, -2.58362591e-02f,
  -5.89621842e-01f, -3.72565210e-01f, -1.06016375e-01f, -3.67999859e-02f, -7.81770200e-02f, -4.53213677e-02f, -2.73546558e-02f, 1.27289116e-01f, -1.92211658e-01f, 2.76910942e-02f,
  5.47969621e-03f, -9.98234153e-02f, -5.99095738e-03f, -9.50594805e-03f, -9.28672925e-02f, 1.88281741e-02f, -1.83200687e-01f, -1.54200956e-01f, -2.08096638e-01f, 3.94269451e-02f,
  -1.00944258e-01f, -3.41388001e-03f, -6.99933618e-02f, -7.79672293e-03f, -1.10232636e-01f, -1.72455996e-01f, 8.24388582e-03f, 1.80150084e-02f, 1.93684641e-02f, 9.57750380e-02f,
  3.47711474e-01f, -5.71450412e-01f, 8.30850899e-02f, 2.02178225e-01f, 4.09421921e-01f, 7.62656284e-03f, 3.50326970e-02f, 1.09073758e-01f, 1.94140464e-01f, -4.92482543e-01f,
  -1.29083276e-01f, -3.45555127e-01f, -2.86562264e-01f, -3.54148224e-02f, 3.21777105e-01f, -7.74214789e-02f, 1.62570089e-01f, -1.19316936e-01f, 3.73181760e-01f, 1.20130509e-01f,
  3.15890729e-01f, 1.64603278e-01f, 1.98293507e-01f, 1.45460188e-01f, 1.43304706e-01f, 4.64305021e-02f, -4.16662730e-02f, -3.79769169e-02f, -1.60363838e-01f, 2.18097749e-03f,
  5.03924116e-02f, 1.27645284e-01f, 1.26522586e-01f, -8.54673702e-03f, 6.66662455e-02f, -1.01511322e-01f, 1.80960707e-02f, -4.70866077e-02f, 1.09108739e-01f, -3.39514799e-02f,
  -8.91957507e-02f, 7.02151880e-02f, 6.15110844e-02f, 1.02797061e-01f, 5.12808897e-02f, 5.66709451e-02f, 1.74880713e-01f, 4.08366807e-02f, -1.72152258e-02f, 1.20656611e-02f,
  9.37400609e-02f, -6.30952120e-02f, 1.14922941e-01f, -3.86819243e-02f, -3.50034572e-02f, 1.96255576e-02f, -3.30285877e-02f, -1.15368612e-01f, -1.11281872e-02f, -3.20043638e-02f,
  1.17046326e-01f, 4.40979041e-02f, 2.88306945e-03f, 7.69139528e-02f, -2.39496604e-02f, 1.19824028e-02f, 9.67845134e-03f, -3.31769288e-02f, -8.11284781e-02f, -1.22735642e-01f,
  -2.82730926e-02f, -2.68122796e-02f, 3.25617455e-02f, -5.13426289e-02f, -1.24566024e-02f, 1.26719177e-02f, -3.83932516e-02f, -5.06010372e-03f, -1.09537328e-02f, 8.08877591e-03f,
  -8.11330751e-02f, 9.46306065e-03f, -1.22240745e-02f, 4.42180224e-02f, 1.15797261e-03f, -7.20461980e-02f, -2.02676021e-02f, -1.19624183e-01f, 1.80473939e-01f, -6.85817190e-03f,
  -5.24417520e-01f, -5.96419275e-01f, -2.98927706e-02f, -5.86236455e-02f, -1.57709215e-02f, -1.26920762e-02f, 1.23161171e-02f, -6.99441433e-02f, -1.62244827e-01f, 1.06860116e-01f,
  -1.32135704e-01f, -6.42148703e-02f, -8.17407519e-02f, 1.32435992e-01f, -4.37831879e-02f, 2.16540452e-02f, -7.68426880e-02f, -2.77922690e-01f, -1.87421255e-02f, -7.70071894e-02f,
  -9.26314518e-02f, -5.60185350e-02f, 2.93921512e-02f, 7.75993168e-02f, 2.55202930e-02f, -5.20293452e-02f, -4.27163392e-02f, 2.68742000e-03f, -5.03265746e-02f, 2.28554029e-02f,
  6.16144478e-01f, -5.42256117e-01f, -3.41262579e-01f, 2.24538177e-01f, 3.70397925e-01f, 3.42915833e-01f, 4.20176387e-01f, 9.59599093e-02f, 9.98492017e-02f, -4.03378338e-01f,
  2.30520368e-01f, -9.92159173e-02f, -3.74511629e-01f, 2.28342175e-01f, 6.47199273e-01f, -2.60376155e-01f, 3.40126932e-01f, 9.97449309e-02f, -1.09324470e-01f, 3.98488156e-02f,
  2.36783832e-01f, 4.79198545e-01f, -1.49504766e-01f, -2.04750821e-01f, 2.09469423e-01f, -3.11107993e-01f, -1.03886552e-01f, -2.59866834e-01f, -4.67972383e-02f, 1.23094052e-01f,
  1.67097121e-01f, -4.35297377e-02f, 1.61578394e-02f, -3.51565480e-02f, -6.67028427e-02f, 3.20022330e-02f, 2.23498000e-03f, 1.98143627e-02f, 1.13861978e-01f, -2.98332274e-02f,
  -3.97260711e-02f, 1.28119484e-01f, 4.09555659e-02f, 9.72581282e-02f, 1.42809525e-01f, 8.95419195e-02f, -6.08280785e-02f, 4.95719463e-02f, -1.12571791e-01f, 4.26270962e-02f,
  -1.89867988e-02f, -2.96339151e-02f, 5.31539954e-02f, -1.43075168e-01f, -7.64163816e-03f, 9.29760486e-02f, -7.37536028e-02f, -8.51922408e-02f, -2.18337495e-02f, 5.14051244e-02f,
  4.50756922e-02f, -5.73090352e-02f, -1.72171351e-02f, 3.67186107e-02f, 8.71501192e-02f, 7.97992870e-02f, 3.04623581e-02f, -1.73890125e-02f, 1.77924205e-02f, 5.44459634e-02f,
  3.13324966e-02f, 8.32912028e-02f, 3.20327142e-03f, 8.42905119e-02f, 1.88362747e-02f, -5.19664697e-02f, 2.90894657e-02f, -4.85875234e-02f, -9.08774212e-02f, 6.46429509e-02f,
  -2.03557014e-02f, -5.62182209e-03f, 2.79502515e-02f, -8.53537768e-02f, 8.25421140e-03f, 1.15989090e-03f, -8.72523338e-02f, -1.16994977e-02f, -9.61728543e-02f, 8.01506937e-02f,
  -6.38571680e-02f, -5.06887078e-01f, -8.89039412e-02f, 6.50911182e-02f, -1.30875096e-01f, 2.04763040e-02f, -5.81591167e-02f, 1.01245843e-01f, -7.46116415e-02f, 3.33365910e-02f,
  -2.39448939e-02f, 3.00139375e-02f, 1.72931654e-03f, 2.28218548e-02f, -4.45418060e-03f, -5.58672054e-03f, -1.22187488e-01f, 7.21916696e-03f, 7.38921342e-03f, -1.20922402e-02f,
  4.18914482e-02f, 5.13709784e-02f, -2.68582702e-02f, 7.76797086e-02f, -3.90331051e-03f, -1.45184338e-01f, -1.88261773e-02f, -4.07867432e-02f, -7.08439350e-02f, -7.40530491e-02f,
  -5.76768443e-02f, -2.76442409e-01f, -3.79282534e-01f, -8.66793022e-02f, 2.19340175e-01f, 9.18558463e-02f, -1.70083687e-01f, 1.47253767e-01f, -4.69287604e-01f, 6.98860064e-02f,
  7.59376818e-03f, -3.21656466e-01f, -3.66561949e-01f, -2.57943183e-01f, -4.33361419e-02f, -4.59896654e-01f, 7.42596388e-02f, 3.48440930e-03f, -3.06063682e-01f, 1.61629707e-01f,
  4.42855507e-02f, 2.66513854e-01f, -1.54583529e-01f, 3.51269960e-01f, 1.61661729e-01f, 2.20697492e-01f, 5.43189466e-01f, 5.97054064e-02f, 3.95209193e-01f, 1.38907954e-01f,
  -5.93455993e-02f, -1.23122916e-01f, -5.88639565e-02f, -1.93045884e-02f, 5.38614728e-02f, 2.65971333e-01f, 1.67019725e-01f, 4.04596925e-02f, -1.22312950e-02f, -1.32331669e-01f,
  -5.80127239e-02f, -6.78499229e-03f, -1.70566384e-02f, 2.37258226e-02f, 5.94988130e-02f, 1.54765705e-02f, -1.14026599e-01f, -6.06520288e-02f, -1.54031157e-01f, -1.69100448e-01f,
  -1.06534973e-01f, 1.89801585e-02f, 4.70975861e-02f, 7.49898404e-02f, -6.00502752e-02f, -3.61384526e-02f, 1.24402307e-01f, 1.04975246e-01f, 3.83221060e-02f, -6.21937588e-03f,
  1.26140922e-01f, 1.17728435e-01f, 3.98822390e-02f, -1.86764300e-01f, -6.88521285e-03f, -1.13553092e-01f, -2.08065212e-02f, -5.53417904e-03f, -5.18601947e-02f, 4.63069193e-02f,
  5.09636812e-02f, -2.85843201e-02f, -2.73848344e-02f, 3.12019438e-02f, 9.57918763e-02f, -7.02742534e-03f, 3.19887884e-02f, 7.44293928e-02f, 9.63127762e-02f, -7.96428695e-02f,
  -9.15843397e-02f, 3.88659872e-02f, 7.87568986e-02f, 7.44694173e-02f, -5.47144413e-02f, 3.03697493e-02f, 5.26975207e-02f, -2.32631639e-02f, 3.23444754e-02f, 7.52878748e-03f,
  1.17807426e-01f, 1.48254976e-01f, -1.28844813e-01f, -4.21505123e-02f, -7.09488392e-02f, 1.31881181e-02f, -1.56011850e-01f, 8.97681981e-04f, 3.23576084e-03f, -1.28102660e-01f,
  2.00233728e-01f, 1.01614349e-01f, 9.89310294e-02f, -1.06592989e-02f, 5.23481108e-02f, 1.63495570e-01f, 1.21847659e-01f, 1.62033036e-01f, 7.95512125e-02f, 1.34616882e-01f,
  1.67723969e-01f, 2.83464361e-02f, -6.90076724e-02f, 2.20733602e-02f, 8.73610973e-02f, 1.18050501e-01f, 8.88058245e-02f, 6.82383925e-02f, -5.47839329e-02f, 2.52337120e-02f,
  6.56593263e-01f, 3.58169466e-01f, 2.80284733e-01f, 3.77261698e-01f, 1.41642988e-01f, 1.00102730e-01f, 2.22632006e-01f, 3.08190048e-01f, 5.55582464e-01f, -7.42151514e-02f,
  -8.46880227e-02f, -3.73727418e-02f, -2.64703333e-01f, 1.06811449e-01f, -2.91450560e-01f, -1.71548650e-01f, 1.75700486e-01f, -1.20198801e-01f, 2.12294653e-01f, 1.06880330e-02f,
  1.91206276e-01f, -3.15405011e-01f, -2.53487021e-01f, -3.71743232e-01f, 2.39341840e-01f, 1.61995456e-01f, -3.23028505e-01f, -2.98202038e-01f, -2.57153273e-01f, -1.52154207e-01f,
  1.34070992e-01f, 2.07126141e-01f, 2.24634204e-02f, 2.32792739e-02f, -8.15335487e-04f, -1.03343250e-02f, -1.01858363e-01f, -2.76416004e-01f, 9.45190266e-02f, 7.04278611e-03f,
  -6.33781105e-02f, -1.87506780e-01f, 1.26667440e-01f, -6.38273656e-02f, -1.50078982e-02f, 3.04536503e-02f, 1.49987459e-01f, 2.11898208e-01f, 3.72853945e-03f, 3.15630622e-02f,
  3.63688469e-02f, 5.79391718e-02f, 8.15608129e-02f, -9.92227867e-02f, 1.21180654e-01f, 7.86056817e-02f, 7.87086599e-03f, -9.30221900e-02f, 4.93977033e-03f, 1.05263181e-01f,
  -6.61363155e-02f, 4.60347049e-02f, -3.26430276e-02f, 3.97490673e-02f, 2.48964615e-02f, 7.32623711e-02f, -2.76977178e-02f, -6.39043376e-02f, 1.13393813e-01f, -9.82469320e-02f,
  5.56804761e-02f, 1.82810932e-01f, -6.18958334e-03f, 1.43915312e-02f, 2.56388783e-02f, 1.72175959e-01f, -1.12458251e-01f, -3.53852101e-02f, 9.37318653e-02f, 9.28030312e-02f,
  -5.69749810e-02f, -7.84218162e-02f, -7.25643989e-03f, 2.48048902e-02f, -7.76058659e-02f, -1.72110144e-02f, -8.42400268e-02f, 3.57560553e-02f, 3.74722714e-03f, -4.43573222e-02f,
  -4.09316197e-02f, -8.38794634e-02f, 6.06305338e-02f, -1.37586877e-01f, -1.36787100e-02f, 4.77225184e-02f, -5.48023209e-02f, 9.08895954e-02f, -7.86791518e-02f, -3.14114541e-02f,
  1.31788468e-02f, 3.94960567e-02f, -3.32419612e-02f, -3.33823487e-02f, -5.09886891e-02f, 9.83259007e-02f, -1.46194071e-01f, 3.32359448e-02f, -6.85546175e-02f, -6.11767583e-02f,
  -6.50267750e-02f, -5.04032569e-03f, 4.36177626e-02f, 1.61335859e-02f, -4.18142118e-02f, -1.24207772e-01f, 1.36976093e-01f, 4.02095504e-02f, -1.00627474e-01f, -7.27914423e-02f,
  4.81970944e-02f, 8.18210393e-02f, 4.27825600e-01f, 4.41637009e-01f, 2.29911685e-01f, 4.36996073e-01f, 5.23928046e-01f, 3.07262629e-01f, 7.30178237e-01f, 8.13230127e-02f,
  -1.36125773e-01f, -2.09050626e-01f, 3.03693060e-02f, -3.72251272e-02f, 1.53915852e-01f, 1.75260186e-01f, 3.79410297e-01f, 1.18360989e-01f, 2.02038631e-01f, -1.49462998e-01f,
  2.15191349e-01f, 9.30870604e-03f, -1.75680295e-01f, -1.72120914e-01f, -3.62576321e-02f, -2.03184441e-01f, -4.51741099e-01f, -5.06642424e-02f, -2.78741479e-01f, -2.23344937e-02f,
  -8.58816877e-02f, -1.12427734e-02f, -1.93173051e-01f, 2.41629127e-02f, -5.94582520e-02f, 2.58305259e-02f, -6.88098073e-02f, 9.92457150e-04f, -1.61249824e-02f, 1.53279826e-02f,
  -7.87145793e-02f, 9.31547731e-02f, -4.40646410e-02f, -2.45590303e-02f, 1.74002185e-01f, -8.15444663e-02f, -6.18526675e-02f, -4.34273444e-02f, -2.17730012e-02f, -2.88629811e-02f,
  2.20446717e-02f, 2.98349038e-02f, 1.20053768e-01f, 1.12582808e-02f, -4.03498113e-02f, -5.05019687e-02f, 4.25529815e-02f, -6.16835244e-02f, -1.13126189e-02f, 1.79415554e-01f,
  -2.13504359e-02f, 8.02119598e-02f, 7.62794958e-03f, 4.53656279e-02f, -1.08724611e-03f, -8.45511968e-04f, -3.88118103e-02f, -4.80622314e-02f, -2.01067626e-02f, -1.48998685e-02f,
  5.24927955e-03f, -5.94497211e-02f, 3.99123915e-02f, -1.67488214e-02f, 7.86653161e-02f, 5.82064763e-02f, -2.31014099e-02f, -8.46449658e-03f, -3.26729380e-02f, -1.47626460e-01f,
  3.03217582e-02f, 5.66551201e-02f, -1.01344965e-01f, 4.69193719e-02f, -1.14274338e-01f, -6.48168251e-02f, 1.66523680e-02f, 6.18733130e-02f, -9.82063450e-03f, 1.51314987e-02f,
  1.38692498e-01f, 9.78482589e-02f, -1.20765939e-01f, -7.79174715e-02f, -1.89466193e-01f, -9.58293229e-02f, 1.51389554e-01f, -3.20171850e-04f, 1.80164382e-01f, 6.21397085e-02f,
  -1.88016258e-02f, 1.28996924e-01f, -1.15687594e-01f, -2.57893708e-02f, -6.14139028e-02f, 6.41259551e-02f, 3.89361829e-02f, 2.53394842e-02f, 7.82432128e-03f, -1.80059820e-01f,
  -1.48348153e-01f, 1.49273444e-02f, 3.36422138e-02f, -2.29886714e-02f, -4.10565204e-04f, -7.95160085e-02f, -1.29229859e-01f, 4.09444682e-02f, -6.42997473e-02f, 2.35340558e-02f,
  2.04314396e-01f, 1.67923138e-01f, -3.64998996e-01f, 2.19385579e-01f, 5.58228269e-02f, 7.08488822e-01f, 4.64461178e-01f, 1.73373625e-01f, 3.98774147e-01f, 3.31667215e-01f,
  9.55428034e-02f, 2.20504701e-02f, -1.13534667e-02f, 3.59994799e-01f, 1.68754369e-01f, 2.24680454e-01f, 3.94815892e-01f, 2.32637957e-01f, -5.26417680e-02f, 2.71214724e-01f,
  -3.08639221e-02f, 3.55150878e-01f, -3.46106231e-01f, -8.51460546e-03f, -1.88651383e-02f, -2.76232153e-01f, -2.50008047e-01f, -2.70812035e-01f, -8.20894763e-02f, 4.25297767e-03f,
  -4.43409234e-02f, 1.02630191e-04f, -4.20550704e-02f, -1.21708736e-01f, -1.06674200e-02f, -1.14719987e-01f, -5.68317026e-02f, -1.60653085e-01f, -1.25629887e-01f, -1.76998414e-02f,
  7.54447952e-02f, -4.77254158e-03f, 1.27163261e-01f, -1.07753016e-02f, 4.71788868e-02f, -1.14863517e-03f, 1.97605565e-02f, -8.81214365e-02f, 1.41733913e-02f, -1.66089952e-01f,
  4.08268757e-02f, -6.66286498e-02f, 4.07239422e-02f, 1.04726300e-01f, -6.65334314e-02f, 5.70900030e-02f, 8.43853503e-02f, -1.00643886e-02f, 1.14788905e-01f, 2.14144409e-01f,
  8.42347369e-02f, -1.70472711e-02f, -2.29122117e-02f, -5.47249056e-02f, -1.94191597e-02f, -1.42732114e-01f, 2.28218678e-02f, -7.83634186e-02f, -2.22721626e-03f, 5.56767546e-02f,
  1.20434299e-01f, -9.21674520e-02f, 8.26796070e-02f, -2.02619787e-02f, 7.34699145e-02f, -6.52991980e-03f, -2.94827055e-02f, -1.71089708e-03f, 8.22636709e-02f, 4.04685251e-02f,
  6.91256719e-03f, 1.91694777e-02f, 4.11533192e-02f, -9.02978256e-02f, 5.27782626e-02f, -7.66916350e-02f, 8.64756629e-02f, -5.58330268e-02f, -1.48291672e-02f, -1.46868953e-03f,
  2.74377346e-01f, 2.54138350e-01f, 2.04056744e-02f, -7.34471157e-02f, 2.11179238e-02f, 4.85180244e-02f, -4.20374749e-03f, 9.12660211e-02f, 1.45665770e-02f, 9.20183957e-02f,
  8.68306682e-03f, -9.25988629e-02f, 1.15228072e-01f, 2.40335669e-02f, -8.59922264e-03f, 1.05261631e-01f, 2.58214138e-02f, -2.43880358e-02f, 3.93540934e-02f, -9.36313532e-03f,
  -2.58370265e-02f, 1.34872973e-01f, 7.89434537e-02f, -3.41512612e-03f, 1.26308799e-01f, -1.77926067e-02f, 2.19144106e-01f, -1.75167412e-01f, -6.40245378e-02f, 7.44131103e-04f,
  2.66256303e-01f, 3.84374447e-02f, -2.89936028e-02f, -2.36642770e-02f, -3.69926751e-01f, -3.45212787e-01f, -1.79440916e-01f, -2.57122606e-01f, 9.26236361e-02f, -6.72576725e-02f,
  -3.22776645e-01f, 4.53698128e-01f, 1.10965177e-01f, -3.01766664e-01f, 1.91585109e-01f, 9.44324210e-02f, -1.62025671e-02f, -9.92011502e-02f, -5.88753596e-02f, -7.67763108e-02f,
  3.48549336e-03f, -3.15890342e-01f, -3.82421492e-03f, -4.12430704e-01f, -2.84864962e-01f, -2.03315154e-01f, -2.23421782e-01f, -2.41537482e-01f, -2.47594610e-01f, -3.29496264e-02f,
  -9.45814848e-02f, 8.16591382e-02f, 6.16261996e-02f, 1.32615775e-01f, -8.71987315e-04f, 6.23005703e-02f, -8.21752660e-03f, 9.06895697e-02f, 6.86140284e-02f, 1.43283084e-01f,
  1.44929573e-01f, 1.37070775e-01f, 5.19018918e-02f, 1.64363999e-02f, -9.01847426e-03f, 5.69228269e-02f, 1.25418603e-02f, 2.82751769e-02f, -7.82291056e-04f, -2.89755743e-02f,
  -4.49397154e-02f, 6.94669085e-03f, -7.41437599e-02f, 2.48128816e-01f, 1.92592680e-01f, -3.79706286e-02f, 8.48332942e-02f, 1.36922479e-01f, 8.48498642e-02f, 1.09987594e-01f,
  1.68828852e-02f, 5.99343181e-02f, -6.55753016e-02f, -2.57819623e-01f, -1.73196733e-01f, -1.30040720e-01f, 6.95222095e-02f, 4.34932634e-02f, -6.79738894e-02f, -1.96715668e-01f,
  -2.85538775e-03f, 1.51089847e-01f, -3.41344588e-02f, 8.38503465e-02f, -4.47184257e-02f, 6.32518083e-02f, -1.56167476e-02f, -6.00789934e-02f, -7.11816549e-02f, 4.35635708e-02f,
  -7.45162517e-02f, -1.24323688e-01f, 1.08390590e-02f, -9.30305645e-02f, -2.65094399e-01f, 8.44137073e-02f, 1.29587919e-01f, -2.90583633e-02f, -3.50609934e-03f, 8.09686780e-02f,
  -7.14356452e-02f, 8.48294944e-02f, 3.82563844e-02f, 1.23175293e-01f, 2.74945945e-02f, 3.40520330e-02f, -1.47097647e-01f, -1.80868208e-02f, 1.07836965e-02f, 6.55934622e-04f,
  -8.15769732e-02f, 6.76895753e-02f, 4.94645797e-02f, -2.55365245e-04f, 5.05844839e-02f, -7.61719942e-02f, -1.35037154e-01f, 5.21167852e-02f, 5.88225313e-02f, 2.17940733e-02f,
  -2.66757738e-02f, 1.40279934e-01f, 1.86653763e-01f, 6.16389774e-02f, -3.36998738e-02f, 6.76588267e-02f, -7.85692036e-02f, 1.45873472e-01f, 1.95797265e-01f, 4.65908945e-02f,
  5.32214999e-01f, 3.32548246e-02f, 4.53588575e-01f, 4.13460314e-01f, -7.94316903e-02f, 2.21219137e-01f, 3.74564469e-01f, -1.25364974e-01f, 4.79272664e-01f, -2.17139915e-01f,
  -4.24952507e-01f, 4.73581582e-01f, -1.77610651e-01f, 9.37403888e-02f, 1.10698894e-01f, -9.80440974e-02f, 1.79155841e-01f, 3.30030948e-01f, 8.92658681e-02f, 1.88769743e-01f,
  2.50542890e-02f, -4.32971865e-01f, -2.73814917e-01f, -4.45083976e-01f, 1.97498943e-03f, 1.78683639e-01f, -4.27911639e-01f, 1.09050229e-01f, -8.08621719e-02f, 1.15145482e-02f,
  -1.51549559e-02f, -2.49667210e-03f, 3.56620029e-02f, 1.20212398e-02f, -2.14633942e-01f, 8.89996663e-02f, 1.91060584e-02f, -3.96140944e-03f, 1.25431167e-02f, -5.21652438e-02f,
  5.16446121e-02f, -6.25288486e-02f, 6.60328269e-02f, -5.60469478e-02f, 1.26968145e-01f, 3.81995514e-02f, 7.10951723e-03f, -1.00088976e-01f, 6.52192626e-03f, 8.57005641e-02f,
  1.77682396e-02f, 1.08095326e-01f, -5.93619142e-03f, 4.83777858e-02f, 5.28210998e-02f, 8.83745924e-02f, 1.31757006e-01f, 6.47496730e-02f, 1.30187729e-02f, -3.16976830e-02f,
  1.79915261e-02f, -2.44795289e-02f, -1.06101923e-01f, -2.93191485e-02f, 2.58352607e-02f, -5.16809672e-02f, 1.06631229e-02f, -1.65088892e-01f, 1.09038122e-01f, 4.64851186e-02f,
  6.51655113e-03f, -1.89061351e-02f, -2.15957756e-03f, 3.66440341e-02f, -9.60249305e-02f, -4.03051544e-03f, 1.48734808e-01f, 6.01620041e-03f, -1.58341527e-02f, -4.26701978e-02f,
  -1.55187463e-02f, 1.28118649e-01f, -1.08242847e-01f, -5.17972670e-02f, 1.13282867e-01f, -2.42789201e-02f, -6.76432848e-02f, 1.66663244e-01f, -6.67584389e-02f, -1.63031332e-02f,
  -1.47444323e-01f, -5.79325669e-03f, -1.54204750e-02f, 7.04358667e-02f, 6.26922920e-02f, -1.26027733e-01f, 7.20420331e-02f, 1.23461209e-01f, 6.47233725e-02f, -4.25099060e-02f,
  3.01761683e-02f, -1.00650294e-02f, 1.22390859e-01f, 8.16718116e-02f, 8.71121790e-03f, -9.17461812e-02f, 4.66296859e-02f, 3.73859555e-02f, -3.91587168e-02f, -4.70709763e-02f,
  9.05720443e-02f, -7.64855221e-02f, -3.69942188e-02f, -9.14551690e-02f, -8.12539533e-02f, 7.74876475e-02f, 8.53064358e-02f, 9.90227088e-02f, -7.31948987e-02f, -3.27299349e-02f,
  -1.76202238e-01f, -2.65654564e-01f, 5.32461047e-01f, -1.92072049e-01f, 1.36668518e-01f, 4.35712844e-01f, 3.41709644e-01f, 2.10479796e-01f, 4.65843640e-02f, -3.07474732e-01f,
  -1.09975427e-01f, -2.50785768e-01f, 3.13425153e-01f, -1.80927441e-01f, 5.65625370e-01f, 3.26631576e-01f, 1.13544717e-01f, -6.03110865e-02f, 4.30365391e-02f, -1.02991998e-01f,
  5.01446193e-03f, -2.61248857e-01f, 3.33524108e-01f, -2.36381769e-01f, -4.88515794e-02f, -2.55518436e-01f, -1.65661469e-01f, 2.83543020e-02f, -3.00866038e-01f, -1.37719922e-02f,
  -3.24329764e-01f, -2.50149995e-01f, -2.27068439e-01f, -8.97890404e-02f, 2.74457745e-02f, -2.96356231e-02f, 1.23113040e-02f, 6.21769913e-02f, -5.03813699e-02f, 1.06004179e-01f,
  -1.08999811e-01f, -4.77758348e-02f, -1.41364351e-01f, 5.91412857e-02f, -1.17726056e-02f, 3.55331264e-02f, 1.28481820e-01f, 8.59679058e-02f, -1.97202265e-02f, 2.26036698e-01f,
  2.37942755e-01f, 4.25101854e-02f, 9.19704512e-02f, -4.34675701e-02f, 6.27984256e-02f, -3.00188269e-02f, 3.18732634e-02f, 6.09041788e-02f, -3.61161530e-02f, -7.32773468e-02f,
  1.00672133e-01f, -2.25027017e-02f, 7.35223666e-02f, -1.14448689e-01f, 1.99137852e-02f, -3.45799625e-02f, -8.56293589e-02f, -8.09958857e-03f, 4.32313457e-02f, 8.71027932e-02f,
  -4.97158580e-02f, 4.20227973e-03f, 2.46176645e-02f, 1.08235426e-01f, -6.52210340e-02f, -5.32151535e-02f, -3.08127664e-02f, -6.92003295e-02f, 7.12283179e-02f, -5.69097139e-02f,
  -9.51933563e-02f, 2.57893335e-02f, 8.41937438e-02f, 2.23724525e-02f, -6.40728101e-02f, 4.77908477e-02f, -1.97888136e-01f, 8.21730271e-02f, 4.52182367e-02f, 1.18760392e-01f,
  -5.61540842e-01f, -3.73163313e-01f, -1.95617184e-01f, -1.27098635e-01f, -1.98643252e-01f, -4.83340770e-02f, -1.99593361e-02f, -3.82436477e-02f, -1.17018268e-01f, 2.06775833e-02f,
  1.34814642e-02f, -4.91457209e-02f, -1.05386883e-01f, -3.34303156e-02f, -3.25358547e-02f, -5.90026490e-02f, -1.59180269e-01f, -2.81638317e-02f, -2.28556380e-01f, -6.36268631e-02f,
  -4.18574363e-03f, -1.28530771e-01f, 3.92867215e-02f, -1.20793998e-01f, 4.60448787e-02f, -2.10453253e-02f, -8.29735994e-02f, -1.41190691e-02f, 6.28697574e-02f, 6.08274452e-02f,
  4.23902601e-01f, -1.36874929e-01f, -3.41641396e-01f, -4.10714179e-01f, -2.60481864e-01f, -1.55219883e-01f, -2.89824098e-01f, -2.51297057e-01f, -1.89392075e-01f, -9.03678462e-02f,
  -2.58199722e-01f, -1.93190258e-02f, -4.56851069e-03f, -2.19857708e-01f, 1.89243823e-01f, 2.87036836e-01f, -1.62609681e-01f, -6.67426810e-02f, 1.29752114e-01f, -5.07126823e-02f,
  7.90682659e-02f, -8.97451490e-02f, -1.37939051e-01f, -3.47882137e-02f, -2.29687840e-01f, -1.12368025e-01f, 4.96971756e-02f, -1.53274134e-01f, -3.25075567e-01f, -1.05839401e-01f,
  -2.55072173e-02f, -9.36265942e-03f, -1.22979239e-01f, 1.37446972e-03f, -2.88822316e-03f, 6.24146685e-02f, -7.50833303e-02f, 4.00558766e-03f, -6.14891574e-02f, -1.07238986e-01f,
  1.00916572e-01f, 9.32659730e-02f, -2.77855825e-02f, 8.05064738e-02f, -6.77973405e-02f, -1.05354242e-01f, 2.81470711e-03f, -6.63322136e-02f, -7.01451525e-02f, 1.14396378e-01f,
  -1.62292406e-01f, -2.98758782e-02f, -1.41051784e-01f, -2.71133184e-02f, -1.71853051e-01f, -5.90034947e-02f, 6.98191077e-02f, 6.20026886e-03f, 1.12997824e-02f, 9.10811871e-03f,
  1.96529571e-02f, 1.66597426e-01f, 2.34008599e-02f, -2.26493962e-02f, -4.43741726e-03f, -4.99378741e-02f, -4.91918065e-02f, -6.31238287e-03f, 4.74127829e-02f, -5.89544773e-02f,
  -1.63415879e-01f, -4.45778854e-02f, 7.43493438e-02f, 6.93130940e-02f, 6.64600730e-02f, 1.38231695e-01f, 6.40330464e-02f, 4.13328670e-02f, -9.43256468e-02f, -1.43706933e-01f,
  3.81089523e-02f, 3.19585502e-02f, -2.26401195e-01f, -1.36362210e-01f, -2.62298770e-02f, -4.30817083e-02f, -2.82997265e-02f, 3.93813141e-02f, -4.82879505e-02f, -2.48175655e-02f,
  -9.79713351e-02f, 1.32553443e-01f, -1.26505107e-01f, -1.22317456e-01f, 9.79570299e-03f, 2.90680081e-02f, 5.91211356e-02f, -7.31954277e-02f, -1.34386951e-02f, 7.88197368e-02f,
  5.49410842e-02f, -3.16011999e-03f, -2.41794288e-02f, -3.01215937e-03f, -5.82139641e-02f, -6.77452907e-02f, 6.22288324e-03f, -4.42571081e-02f, -4.02460285e-02f, -7.51478970e-02f,
  -9.61687565e-02f, 1.42018706e-01f, 1.21872880e-01f, -2.15012971e-02f, -2.96858046e-02f, -3.51433605e-02f, 7.18862563e-02f, -4.45111729e-02f, -2.32587568e-02f, -4.76289466e-02f,
  -6.85097575e-01f, -2.47972414e-01f, -3.20047230e-01f, 3.54622990e-01f, -2.50982698e-02f, 1.58656895e-01f, -4.76719886e-02f, -7.92020261e-02f, -2.38249108e-01f, 2.65972137e-01f,
  2.84941047e-01f, -2.45210886e-01f, -2.99131274e-01f, 6.18158579e-01f, -9.52615030e-03f, -5.35297617e-02f, 4.39333498e-01f, 2.88244754e-01f, -1.38947353e-01f, -1.95104152e-01f,
  4.28672098e-02f, 3.40089262e-01f, 7.69857168e-02f, 1.34084180e-01f, 1.45290447e-02f, -1.37955055e-01f, 2.11900342e-02f, -3.35888475e-01f, 4.43649203e-01f, 1.12718947e-01f,
  -2.12499186e-01f, -3.35589379e-01f, -1.95869878e-01f, -1.71701625e-01f, -1.56497300e-01f, -1.23211682e-01f, -4.74603325e-02f, -1.25371084e-01f, 6.44630287e-03f, -9.26653966e-02f,
  -5.66794351e-02f, -7.44242221e-03f, 1.85383156e-01f, 1.59892030e-02f, -4.65166122e-02f, -8.20263177e-02f, 9.31818970e-03f, 6.49181232e-02f, 2.21572397e-03f, -1.63961768e-01f,
  -4.82072644e-02f, 1.33423492e-01f, 1.43000498e-01f, 1.61864266e-01f, 5.44697307e-02f, 4.89231758e-02f, 1.61895558e-01f, -2.22579353e-02f, 1.05286539e-02f, -1.85046401e-02f,
  -6.92631677e-02f, 8.12070966e-02f, -1.31545231e-01f, 4.86120395e-02f, -8.95007774e-02f, 7.59060159e-02f, 2.05454797e-01f, 3.57683264e-02f, -9.36662778e-02f, -5.20478152e-02f,
  1.36495411e-01f, 7.75318593e-02f, -2.45194547e-02f, -2.02873852e-02f, 1.92070417e-02f, 1.32717237e-01f, 1.67870540e-02f, 7.56053701e-02f, 7.32859448e-02f, 1.66388854e-01f,
  -1.86236352e-02f, 2.75128614e-02f, -3.44743207e-02f, -3.95211950e-02f, 4.38677557e-02f, -2.22129896e-01f, 1.10087842e-01f, -2.37111226e-02f, 3.98660675e-02f, -3.83064337e-02f,
  -5.66641986e-01f, -6.01275623e-01f, -8.48333761e-02f, 9.92808715e-02f, -8.13539326e-02f, -4.37391177e-02f, -6.16550632e-02f, 5.98949678e-02f, -1.79403260e-01f, -1.38418436e-01f,
  -7.02799186e-02f, 1.49551213e-01f, -7.54721416e-03f, -1.73340719e-02f, 9.60189924e-02f, 3.19520682e-02f, -4.60215956e-02f, -3.75511833e-02f, -2.85108257e-02f, 8.04220736e-02f,
  4.39636633e-02f, -2.02413686e-02f, 6.93483977e-03f, 2.35041399e-02f, 7.45138973e-02f, 5.42975999e-02f, -7.01384172e-02f, 6.10607229e-02f, 4.04305831e-02f, 1.19459584e-01f,
  -1.60787210e-01f, 4.20720041e-01f, -1.79916143e-01f, -1.84323400e-01f, -3.05486828e-01f, -1.90101177e-01f, -2.34992057e-01f, -1.54103622e-01f, -1.05526544e-01f, 5.58806397e-02f,
  -4.43823725e-01f, 1.23031363e-01f, 1.93017900e-01f, -7.24494085e-02f, 1.26921851e-02f, 2.66969442e-01f, -1.06088864e-02f, 7.51431286e-02f, 1.13288738e-01f, -2.25870926e-02f,
  7.64403641e-02f, -2.76583731e-01f, 7.51938745e-02f, 1.39767828e-03f, -3.34518969e-01f, -1.45939872e-01f, -7.52174482e-02f, -3.01960558e-01f, -3.11443180e-01f, -2.10157812e-01f,
  -1.13157630e-01f, -5.45260131e-01f, -6.39809221e-02f, 6.20792881e-02f, -1.91843241e-01f, -4.14805561e-02f, -4.78670821e-02f, -1.38453543e-01f, -3.17951702e-02f, -8.56175795e-02f,
  4.40002158e-02f, 9.79621932e-02f, -4.12857905e-02f, 1.06153741e-01f, -7.69186616e-02f, 1.80131234e-02f, -9.25562624e-03f, -6.60562515e-02f, -1.60120577e-02f, 2.16584764e-02f,
  8.88923258e-02f, -7.60922069e-03f, -1.74314290e-01f, 7.43017346e-02f, -4.83510457e-02f, -1.72968403e-01f, 5.44613451e-02f, -6.42422587e-02f, 7.12280497e-02f, -7.69902617e-02f,
  -1.00289099e-01f, -3.58181037e-02f, 5.73770553e-02f, 6.31368428e-04f, -8.88155699e-02f, -1.22002184e-01f, -7.21926754e-03f, -1.06004588e-01f, -2.47715656e-02f, 3.76936160e-02f,
  -8.27559009e-02f, 1.49226282e-02f, -3.08407806e-02f, 1.87855400e-02f, -6.79330975e-02f, -7.83460401e-03f, -1.34030372e-01f, -5.34827672e-02f, 8.85013267e-02f, 1.08788110e-01f,
  -8.59784409e-02f, -5.77382930e-03f, 4.77996208e-02f, 7.03064678e-03f, 1.61588134e-04f, 1.29449472e-01f, 7.56282881e-02f, 9.55994129e-02f, -3.94198634e-02f, -1.44141749e-01f,
  -9.79317278e-02f, -5.04204035e-01f, -7.56197050e-02f, -6.61224276e-02f, 1.72665447e-01f, 2.74145454e-02f, -5.68314008e-02f, 5.92672117e-02f, -1.21274069e-01f, -3.54406312e-02f,
  -1.21517055e-01f, 5.56489751e-02f, -5.82404211e-02f, -2.16434672e-02f, 2.14001000e-01f, 3.06563830e-04f, -6.54126704e-02f, 1.62772927e-02f, -1.08741544e-01f, -3.31461132e-02f,
  2.55076145e-03f, 6.15829825e-02f, 5.51155955e-02f, 3.15429159e-02f, -3.58641986e-03f, -1.57657817e-01f, -1.32192140e-02f, -5.35078607e-02f, -1.90994918e-01f, -4.06736396e-02f,
  -3.91278177e-01f, 1.84661373e-02f, -2.94322073e-01f, -2.44312108e-01f, 2.75292486e-01f, -3.42724115e-01f, -3.24258417e-01f, 1.45208612e-01f, -9.22525749e-02f, 4.91421781e-02f,
  6.92020953e-02f, -3.19535613e-01f, 2.85615116e-01f, -5.67199886e-01f, -5.05676806e-01f, -2.16165170e-01f, -4.28690523e-01f, -3.37830037e-01f, -1.60145596e-01f, 1.15785487e-01f,
  -1.35171965e-01f, -2.17951417e-01f, -3.37556690e-01f, 2.04443857e-01f, -1.34853050e-01f, 2.67329901e-01f, 4.19716656e-01f, 1.43709376e-01f, 2.53465790e-02f, -2.33640656e-01f,
  -2.06850022e-01f, 1.10648973e-02f, -6.42706677e-02f, -1.22116491e-01f, 1.11455940e-01f, 1.13777399e-01f, 2.37748288e-02f, -8.23525339e-02f, -1.14107998e-02f, -3.10212490e-03f,
  4.98450734e-02f, 2.70339902e-02f, -8.52078274e-02f, -6.81149215e-02f, 9.37734097e-02f, -5.61583042e-02f, -9.09629837e-02f, -9.32321548e-02f, -1.28579244e-01f, -8.44982564e-02f,
  -3.63521688e-02f, 1.94736496e-02f, 1.58834308e-01f, -1.05353147e-01f, 1.10035539e-01f, 3.39687802e-03f, -1.14884511e-01f, 6.33553194e-04f, -2.31256825e-03f, -2.14844495e-02f,
  1.13239266e-01f, 3.90899554e-03f, -7.84522966e-02f, -1.15406491e-01f, -4.78457659e-02f, 2.08148286e-02f, 8.64891559e-02f, 1.09572411e-01f, 1.31497115e-01f, 5.29527329e-02f,
  6.55224100e-02f, 8.30940008e-02f, -7.46088335e-03f, -9.36035905e-03f, 1.09120272e-01f, 2.01462652e-03f, 3.76990736e-02f, -1.89801194e-02f, -4.71347645e-02f, -4.79379371e-02f,
  5.35605736e-02f, 2.04441650e-03f, -5.57838241e-03f, 1.01573691e-01f, 2.44520400e-02f, 7.66628906e-02f, 1.08812667e-01f, -5.47658317e-02f, -7.23003745e-02f, 9.88610387e-02f,
  1.10062107e-01f, 4.75613624e-01f, 2.54544914e-02f, -3.93589176e-02f, -1.42498761e-02f, -1.32906720e-01f, -7.36815780e-02f, -5.43479212e-02f, -3.38799506e-02f, 1.69278547e-01f,
  7.34490082e-02f, 4.25567776e-02f, 1.88449338e-01f, -9.81047601e-02f, -6.60860762e-02f, 1.51475929e-02f, 5.39156646e-02f, 7.30543286e-02f, 1.18944980e-01f, 7.76560530e-02f,
  1.42793238e-01f, 1.52112290e-01f, -7.31027722e-02f, 3.69254909e-02f, 1.54494002e-01f, 1.81069952e-02f, 1.15211062e-01f, -2.72013303e-02f, 1.08985074e-01f, 5.38843684e-02f,
  -6.73807859e-02f, -9.32035297e-02f, 3.28846984e-02f, -5.91852516e-02f, 1.00847453e-01f, -3.31170231e-01f, -1.62095234e-01f, -1.12025432e-01f, -5.90050332e-02f, -2.40595043e-01f,
  -1.02816476e-02f, 8.31504539e-02f, 3.26817334e-01f, -2.93238789e-01f, 4.46463376e-01f, 1.91105574e-01f, -5.22031188e-01f, -1.33301094e-01f, 4.01766337e-02f, -3.34551215e-01f,
  -8.29490349e-02f, -2.05035567e-01f, 1.49722189e-01f, -2.52427369e-01f, -2.53647447e-01f, -1.24309473e-01f, 2.35807687e-01f, 7.06275180e-02f, -2.48548791e-01f, 1.05584331e-01f,
  -1.10929005e-01f, -9.39484537e-02f, -4.99864407e-02f, -9.27851126e-02f, -1.77416191e-01f, -1.31083541e-02f, -7.61772990e-02f, 1.18434004e-01f, 4.22571264e-02f, -1.34133071e-01f,
  9.55082849e-02f, 3.53424549e-02f, -1.64854020e-01f, 2.69706428e-01f, -4.45384718e-02f, 2.97977608e-02f, 9.37699899e-02f, -1.15721606e-01f, -6.10591955e-02f, 7.33831897e-02f,
  -4.51292545e-02f, -9.84642729e-02f, -5.33456877e-02f, -2.43063867e-02f, 5.28588444e-02f, -9.36807096e-02f, -5.70288561e-02f, 4.08255719e-02f, -1.08746566e-01f, -1.33768678e-01f,
  -1.00781038e-01f, 1.86141431e-01f, -5.91256060e-02f, -2.65381509e-03f, -3.37410495e-02f, 9.05440599e-02f, -8.20694640e-02f, 1.12226687e-01f, 4.54824343e-02f, -3.48544419e-02f,
  -8.09764192e-02f, 3.94387469e-02f, -6.74867854e-02f, -2.62233913e-02f, -2.73146462e-02f, -5.68198971e-02f, 5.68184927e-02f, 4.11721841e-02f, -5.62394448e-02f, -6.21774718e-02f,
  8.87668952e-02f, 4.47722152e-02f, 1.07118689e-01f, 4.22036424e-02f, -1.95141677e-02f, -5.14397882e-02f, 1.46056386e-02f, -2.38759145e-02f, 1.03785649e-01f, 1.07891902e-01f,
  -7.40062073e-02f, -5.19076809e-02f, 8.28465540e-03f, -9.52010602e-02f, -2.15571914e-02f, -6.72399700e-02f, 5.70156202e-02f, -3.15777361e-02f, -3.99909131e-02f, -1.76931217e-01f,
  -9.93305147e-02f, 7.63493925e-02f, 5.93380071e-02f, 5.30641340e-03f, 6.93376139e-02f, -4.77387048e-02f, -5.78488633e-02f, 5.46660461e-02f, -2.99910046e-02f, -2.30539665e-02f,
  9.67180282e-02f, 9.43396892e-03f, 1.82167888e-01f, -1.40861854e-01f, 7.48531595e-02f, -8.86311010e-02f, -3.64167616e-02f, 6.86473399e-02f, -1.94793809e-02f, 1.69564188e-01f,
  2.34185517e-01f, 1.42583430e-01f, -2.19937041e-01f, 1.04707949e-01f, -2.99741775e-01f, -3.98494095e-01f, -3.18795890e-01f, -9.69629660e-02f, -2.55570441e-01f, 1.68177076e-02f,
  1.61491334e-01f, -1.51532844e-01f, 2.74807245e-01f, 4.53552872e-01f, 5.89479059e-02f, 5.10009766e-01f, 1.99808151e-01f, -3.43548656e-02f, 2.47211121e-02f, 1.83154389e-01f,
  2.40376905e-01f, 4.48327065e-01f, 5.14602423e-01f, 2.27459416e-01f, 1.09835237e-01f, 1.50011286e-01f, 3.09797078e-01f, 9.33965370e-02f, 4.95490655e-02f, -6.47483990e-02f,
  -8.01534057e-02f, 2.03985646e-01f, -3.69067676e-02f, -8.68739188e-02f, -2.76663937e-02f, -7.06760064e-02f, -2.74768285e-02f, -1.24183938e-01f, -1.76279061e-02f, 3.24619375e-02f,
  1.43971643e-03f, -5.36489300e-02f, -1.36992946e-01f, -1.54706398e-02f, -5.83280213e-02f, -1.25682920e-01f, 2.85683293e-02f, -1.61960587e-01f, -1.69304665e-02f, 1.43904835e-01f,
  -2.25050729e-02f, 3.22994888e-02f, 3.42729427e-02f, 5.24327299e-03f, 8.60007256e-02f, 5.85977808e-02f, -5.13912775e-02f, -1.58890784e-02f, -7.02723190e-02f, -8.90938044e-02f,
  1.42528992e-02f, -1.48564121e-02f, 1.20382994e-01f, -7.73971677e-02f, -8.10878202e-02f, 1.75781287e-02f, -6.98897615e-02f, -5.22940680e-02f, -8.82828087e-02f, 1.53347194e-01f,
  1.23836137e-02f, 2.27594320e-02f, 7.95378387e-02f, 8.67782980e-02f, 2.96732597e-02f, 4.55490910e-02f, -1.23374572e-03f, 1.05669245e-01f, -2.95490753e-02f, 1.18679809e-03f,
  -5.43816090e-02f, 7.46328309e-02f, -1.04272338e-02f, -2.00129319e-02f, -7.58104250e-02f, 2.83763930e-02f, 1.30972654e-01f, 1.37374431e-01f, -9.60998312e-02f, -3.51302437e-02f,
  -1.49327843e-02f, 2.78338432e-01f, -2.71562058e-02f, -7.05640391e-02f, 8.31870884e-02f, 2.02717003e-03f, 1.12436945e-02f, -4.64221910e-02f, 4.72409651e-02f, -5.81223331e-03f,
  1.21996552e-02f, -9.94250849e-02f, 6.75436780e-02f, 4.05688696e-02f, -1.82289720e-01f, 2.15312131e-02f, 1.89100385e-01f, -6.34117192e-03f, -5.59939444e-02f, -7.63107538e-02f,
  8.52722898e-02f, 5.93546685e-03f, -8.62974022e-03f, -2.02277973e-01f, -6.45729303e-02f, -2.08159126e-02f, -9.52716991e-02f, -6.45675659e-02f, 6.99049234e-02f, -1.78228728e-02f,
  -6.22099102e-01f, 2.52505571e-01f, -3.23751152e-01f, -2.78392196e-01f, 1.60277784e-02f, -4.59285378e-01f, -7.89635330e-02f, 2.39852853e-02f, 1.63066700e-01f, 5.23318172e-01f,
  1.89198732e-01f, -5.40573671e-02f, 3.00912827e-01f, -7.68070072e-02f, -5.40407240e-01f, 9.70641449e-02f, -3.73843580e-01f, -2.18992770e-01f, 2.32050307e-02f, -2.33304724e-01f,
  -2.81206369e-01f, -1.13707529e-02f, -3.60595018e-01f, 2.25185618e-01f, -2.48748437e-01f, -5.96203059e-02f, 7.51778409e-02f, 1.38578296e-01f, -2.91078746e-01f, -5.17733432e-02f,
  -2.39374235e-01f, 1.16034947e-01f, 1.47355802e-03f, -1.19039439e-01f, -4.20457274e-01f, -1.70288011e-01f, -1.17778584e-01f, -1.20443016e-01f, -8.64543766e-02f, -4.19635884e-02f,
  -1.18093461e-01f, -4.85796891e-02f, -1.54396519e-01f, 9.82357115e-02f, -9.11034793e-02f, 8.54991004e-03f, -8.89145136e-02f, -3.86005118e-02f, -4.24107537e-02f, -6.01970814e-02f,
  -1.14264049e-01f, -7.92821571e-02f, -5.90259396e-02f, -3.81467328e-03f, -5.93135990e-02f, 5.26934229e-02f, -7.43128210e-02f, 2.27889512e-02f, -8.14683139e-02f, -2.20619030e-02f,
  1.15839571e-01f, -8.10490102e-02f, 8.34821835e-02f, -4.63337936e-02f, -8.72656796e-03f, 2.48629600e-02f, -8.35935026e-02f, -1.94107424e-02f, 5.05839996e-02f, 2.80992910e-02f,
  -1.51633518e-02f, 6.67712688e-02f, 1.49901256e-01f, -6.24244427e-03f, -5.56472428e-02f, 8.39549154e-02f, -1.13849737e-01f, 3.76078226e-02f, -1.53719366e-01f, -4.66965772e-02f,
  1.41754687e-01f, -3.03458492e-03f, 8.96699131e-02f, -1.41947798e-03f, -3.47626656e-02f, 9.86906327e-03f, -1.56751741e-02f, -3.50700356e-02f, 4.27702479e-02f, -6.38176575e-02f,
  -4.22059149e-01f, -1.75784249e-02f, 1.02478936e-01f, 1.08739115e-01f, -2.06117937e-03f, -1.12175226e-01f, -8.26082155e-02f, -4.11772132e-02f, -2.04589553e-02f, -4.34022062e-02f,
  -3.94171365e-02f, 6.27482012e-02f, -1.41001284e-01f, 1.75485183e-02f, 5.26705496e-02f, -7.66647756e-02f, -3.24372947e-02f, -8.15079436e-02f, -3.01031005e-02f, -1.17179163e-01f,
  2.19147354e-02f, 2.77286507e-02f, -2.05073655e-02f, -8.33620355e-02f, 8.12360644e-03f, 3.24960351e-02f, -4.57790382e-02f, 6.16528792e-03f, -1.13577694e-01f, -6.82168528e-02f,
  1.17941223e-01f, 4.83343035e-01f, 4.52898175e-01f, 4.39805448e-01f, -1.24127448e-01f, -4.89646167e-01f, -2.96964288e-01f, 1.79357812e-01f, 8.10548216e-02f, 7.99514130e-02f,
  -1.33440897e-01f, 3.75021011e-01f, -5.23183160e-02f, 2.65742004e-01f, -4.56726164e-01f, -2.90940344e-01f, -9.43711400e-02f, 2.72172354e-02f, 5.43751158e-02f, 1.65317357e-01f,
  -2.73957159e-02f, -1.36164844e-01f, 1.42859116e-01f, 7.75434151e-02f, 1.61684334e-01f, 3.88313591e-01f, 1.65066794e-02f, 4.04479131e-02f, 1.54734135e-01f, -8.75295028e-02f,
  -1.18676707e-01f, 2.33570933e-01f, 1.32123813e-01f, 2.13484056e-02f, 1.28282607e-02f, -7.02990070e-02f, 1.76836271e-02f, -5.55037335e-03f, -4.84840684e-02f, -2.06293762e-02f,
  -3.50139737e-02f, -3.00032962e-02f, 2.85772216e-02f, -1.15672089e-02f, 2.96194758e-02f, 1.28226638e-01f, 8.74781460e-02f, 9.12607536e-02f, 6.47300482e-02f, 8.44699219e-02f,
  2.33818188e-01f, 1.41184807e-01f, 3.76740880e-02f, -4.44908664e-02f, 5.92867360e-02f, 3.61107886e-02f, -8.59774128e-02f, 9.46871266e-02f, 1.37745393e-02f, 6.44211918e-02f,
  4.59831208e-02f, -3.72059159e-02f, 3.80931087e-02f, 7.25493059e-02f, -1.67908892e-02f, 1.76197309e-02f, -3.22735757e-02f, -3.12010497e-02f, 4.04656865e-02f, -9.89341885e-02f,
  -1.47243738e-01f, 9.56087783e-02f, -7.59236366e-02f, -5.68180927e-04f, -3.99086811e-03f, 6.65408224e-02f, -6.02703840e-02f, 1.74277499e-02f, -2.65644919e-02f, 4.34409715e-02f,
  3.46599221e-02f, -1.37543112e-01f, 1.47549957e-01f, -9.22888145e-02f, -4.63711880e-02f, 1.09620690e-01f, 5.42829111e-02f, 7.51476586e-02f, 2.77874507e-02f, -1.36412755e-02f,
  -1.77508473e-01f, 2.24760845e-01f, -9.40831564e-03f, -8.96630064e-02f, -4.54988442e-02f, -4.54135202e-02f, 1.03702240e-01f, 4.13697697e-02f, -1.83322281e-02f, -2.20063180e-02f,
  4.68382426e-02f, -3.29473205e-02f, -1.30584121e-01f, -4.90673929e-02f, -6.42814813e-03f, -1.91928614e-02f, 7.75035098e-02f, -9.26602818e-03f, 6.20950200e-02f, 2.18645949e-02f,
  1.34343743e-01f, -4.03822735e-02f, -4.95399232e-04f, -7.56311268e-02f, -6.15601661e-03f, -6.36113137e-02f, 2.47159079e-02f, 4.59314957e-02f, 3.59067991e-02f, -8.03803429e-02f,
  3.01751703e-01f, 5.28779514e-02f, -2.14847043e-01f, 6.23189099e-02f, 1.28064364e-01f, 2.15770185e-01f, -8.46331120e-02f, 3.94473560e-02f, -3.14181775e-01f, 3.42600001e-03f,
  1.17476195e-01f, 8.06329027e-02f, -2.22732767e-01f, 4.30659175e-01f, 4.72556144e-01f, -1.83476061e-01f, 3.35299104e-01f, 1.00859754e-01f, -1.25081956e-01f, 3.17310244e-01f,
  7.66427815e-02f, 4.62694138e-01f, -9.21957046e-02f, 2.00114354e-01f, 4.47998792e-01f, -2.06836388e-01f, 2.48321012e-01f, -1.49662346e-01f, 1.82997137e-01f, 2.64352858e-01f,
  8.23148340e-02f, 7.26589411e-02f, -9.12958011e-03f, -4.84972075e-03f, 1.16049489e-02f, 2.94187795e-02f, -7.88598955e-02f, 1.40813459e-02f, -1.66702360e-01f, -1.53103960e-03f,
  7.01738149e-02f, 7.49827363e-03f, 2.26886701e-02f, -2.27249553e-03f, 1.09303892e-01f, -3.41340229e-02f, 1.40515519e-02f, -8.74170810e-02f, -1.92008451e-01f, 1.50756091e-01f,
  -5.10841087e-02f, -7.91091770e-02f, -2.03292854e-02f, -2.31341068e-02f, -9.66946632e-02f, -6.64452985e-02f, -1.41627071e-02f, 1.48320273e-02f, 1.12789720e-01f, 8.31901208e-02f,
  1.49156570e-01f, -3.24387103e-02f, 6.74322322e-02f, 1.92775894e-02f, 8.34837854e-02f, -5.13737947e-02f, -3.86028439e-02f, -7.83404056e-03f, -1.11239508e-01f, 1.79466605e-02f,
  -7.19884858e-02f, -7.56087601e-02f, 3.18228230e-02f, -5.77498041e-02f, 7.66664892e-02f, 1.27306627e-02f, 8.89254455e-03f, -4.19298522e-02f, -1.42051265e-01f, -1.23592012e-01f,
  -9.69993994e-02f, 6.28394634e-02f, -3.56728062e-02f, -1.06211649e-02f, 7.53563270e-02f, -6.55832216e-02f, 1.34137139e-01f, 6.52517453e-02f, -6.77467063e-02f, 4.54130247e-02f,
  5.93392402e-02f, 1.26656011e-01f, -4.36865874e-02f, -1.12776041e-01f, -3.44431959e-02f, 1.28221229e-01f, 7.59232119e-02f, 3.87522690e-02f, 3.51360887e-02f, 1.10044338e-01f,
  1.36747912e-01f, -8.92109424e-02f, -5.23147248e-02f, -7.66450306e-04f, -8.07391107e-03f, 1.14231065e-01f, -6.84996545e-02f, -1.21314846e-01f, 8.68423004e-03f, 1.44995540e-01f,
  -3.97816710e-02f, 2.51068641e-02f, 2.38032043e-02f, 7.57902488e-03f, -1.39640598e-02f, 7.51157776e-02f, 6.70790225e-02f, 6.02238774e-02f, 1.65189251e-01f, -1.74388550e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.84015328e-01f, 4.04576600e-01f, 2.46602461e-01f, 4.41727668e-01f, 2.60524601e-01f, 3.92616689e-01f, 3.71705174e-01f, 4.00207281e-01f, 5.04338384e-01f, 5.54831445e-01f,
  4.81166184e-01f, 1.15862340e-01f, 2.50203371e-01f, 5.04866838e-01f, 3.94824773e-01f, 2.43343934e-01f, 2.41054565e-01f, 4.69655305e-01f, 2.89804876e-01f, 2.38160416e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -3.44008774e-01f, -2.66957432e-01f, -9.30978358e-02f, -9.74362195e-02f, -1.23699538e-01f, -2.56288171e-01f, -2.39193961e-01f, -1.70946747e-01f, 2.12332830e-01f, -4.71492335e-02f,
  3.62509750e-02f, 8.07722732e-02f, 1.30718365e-01f, -1.12677567e-01f, -3.68164182e-01f, 6.93657622e-02f, 1.65480852e-01f, -1.95561811e-01f, -3.16885799e-01f, -5.15751690e-02f,
  7.98742175e-02f, -7.28467153e-03f, -1.80920795e-01f, -1.54895246e-01f, 2.37555847e-01f, 1.83964267e-01f, 2.33010918e-01f, 2.47145578e-01f, 1.27479238e-02f, 7.27976188e-02f,
  3.38908046e-01f, 6.77104965e-02f, -1.23691350e-01f, 9.11299065e-02f, 1.54217660e-01f, 6.29058480e-02f, 1.51825398e-01f, 1.93998277e-01f, 2.87053168e-01f, 1.72847942e-01f,
  -7.03739822e-02f, -1.42323837e-01f, 1.53856114e-01f, -2.74119794e-01f, 2.94377327e-01f, 1.22594042e-02f, -1.89174607e-01f, 8.87137651e-02f, 1.49928406e-01f, -4.29514527e-01f,
  -1.17442004e-01f, -1.79795660e-02f, -2.11661309e-01f, -5.93378302e-03f, -1.12132646e-01f, 1.27367616e-01f, -7.67891482e-02f, -1.68780480e-02f, 3.25059831e-01f, 9.71625447e-02f,
  -5.44812158e-02f, 1.79367885e-01f, -9.47132781e-02f, 2.66750157e-01f, -8.05624109e-03f, -1.47978410e-01f, -1.65149540e-01f, 1.92041636e-01f, -9.23032314e-02f, -2.64810920e-01f,
  -8.78427997e-02f, -7.92507231e-02f, 9.67700854e-02f, 3.17348957e-01f, -2.17343450e-01f, 1.92073569e-01f, -3.45350474e-01f, 2.08425239e-01f, 3.23515594e-01f, -4.26497962e-03f,
  -2.53649086e-01f, 2.57269979e-01f, -3.45566012e-02f, -1.64746284e-01f, -8.51662382e-02f, -9.15306062e-02f, -6.38756994e-03f, -2.10920051e-01f, 4.35201824e-01f, -2.16675282e-01f,
  -1.62445977e-01f, -1.62189573e-01f, 2.87410587e-01f, 1.10349871e-01f, 2.79656142e-01f, -4.08728607e-03f, -8.80906284e-02f, 6.38259649e-02f, 6.99279690e-03f, -1.22106187e-01f,
  2.48633862e-01f, 6.27723336e-02f, -2.71832645e-01f, -6.17837496e-02f, 1.14396282e-01f, -1.77300483e-01f, 8.99995938e-02f, -8.90765116e-02f, 2.05277696e-01f, -2.92261690e-01f,
  -1.16194464e-01f, 2.15227574e-01f, -8.81245136e-02f, -1.24722414e-01f, 1.72103822e-01f, 1.64160684e-01f, 3.03923428e-01f, 2.84664005e-01f, 2.66846139e-02f, 2.29712680e-01f,
  -1.43441990e-01f, 6.26599230e-03f, 2.78083347e-02f, 8.32374096e-02f, -1.41709596e-01f, -2.49592513e-01f, -4.23083961e-01f, 7.46636987e-02f, -2.50568539e-01f, -1.67968944e-01f,
  8.09759721e-02f, 8.88577774e-02f, 3.11210621e-02f, 1.48770824e-01f, -1.98291883e-01f, -2.61131644e-01f, 8.28440264e-02f, -2.79913366e-01f, 4.33455348e-01f, 2.61332750e-01f,
  -2.09482506e-01f, -1.03267528e-01f, -1.82211056e-01f, -3.97525638e-01f, 1.06130419e-02f, -3.22150216e-02f, 2.13141099e-01f, -4.58526872e-02f, 2.57595450e-01f, 2.61601329e-01f,
  -1.86691239e-01f, 6.39082342e-02f, -2.74977565e-01f, 1.44588098e-01f, 9.43951830e-02f, 5.91406673e-02f, -8.56740251e-02f, 2.74186190e-02f, 1.97689682e-01f, -1.91427857e-01f,
  -5.26692756e-02f, 1.03507459e-01f, -1.74831137e-01f, 4.21531238e-02f, -2.12505646e-02f, -9.17538069e-04f, -2.59246647e-01f, 1.07484289e-01f, -1.83460966e-01f, -5.47995195e-02f,
  -2.77909059e-02f, -1.44782484e-01f, -3.23420525e-01f, -5.17363399e-02f, 6.88273609e-02f, 9.81896296e-02f, -9.53318104e-02f, 1.61713928e-01f, 1.43466234e-01f, 3.17732036e-01f,
  -2.00318232e-01f, -3.37482065e-01f, 1.64633077e-02f, -1.92928702e-01f, 1.53483957e-01f, 1.02625653e-01f, -6.56645447e-02f, -3.33366655e-02f, 4.00402814e-01f, -2.79044509e-01f,
  -2.24918902e-01f, 1.78115934e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.08608794e-01f, 1.39664277e-01f, -1.05074726e-01f, -1.67647243e-01f, -3.03555369e-01f, -3.44072580e-01f, -2.91761488e-01f, 6.21089876e-01f, -9.99530703e-02f, -4.01920140e-01f,
  -5.19501567e-01f, -1.67300314e-01f, 6.38517261e-01f, -2.66405433e-01f, -1.34430602e-01f, -1.02170728e-01f, -4.48213339e-01f, -5.11139147e-02f, 4.67523843e-01f, 1.97019920e-01f,
  4.44258511e-01f, 3.30661595e-01f, 5.20930409e-01f, 2.67427206e-01f, 7.84109309e-02f, 4.73939240e-01f, -2.17326626e-01f, 4.95295554e-01f, 1.13966845e-01f, 9.85019580e-02f,
  -5.14268875e-01f, -4.17972147e-01f, 6.76476181e-01f, 1.70959890e-01f, 4.13739771e-01f, 1.88452661e-01f, 3.30178529e-01f, 6.80572927e-01f, 1.95724845e-01f, 2.99133897e-01f,
  4.71927851e-01f, 1.93800181e-01f, 8.52836445e-02f, 3.51988375e-01f, 4.41757552e-02f, 2.66575009e-01f, 2.84772217e-01f, -2.55899280e-01f, 3.13275039e-01f, 7.91338801e-01f,
  6.82130575e-01f, 2.07486719e-01f, 3.06152672e-01f, 6.09742463e-01f, 6.30860090e-01f, 2.19992340e-01f, -5.79708040e-01f, 1.61861569e-01f, 4.05715287e-01f, -8.47064257e-02f,
  -2.92309135e-01f, -2.79849678e-01f, -2.82266974e-01f, -4.69443142e-01f, 2.33521253e-01f, -1.51906982e-01f, -7.19886869e-02f, 1.09276280e-01f, 1.38489470e-01f, 3.18784118e-01f,
  -5.98580062e-01f, -4.19871777e-01f, 3.73325557e-01f, -3.04302245e-01f, 3.77201974e-01f, 3.03797543e-01f, 2.59135932e-01f, -2.96094000e-01f, 2.89918691e-01f, 6.31610036e-01f,
  4.92754504e-02f, 3.64506930e-01f, 5.10674834e-01f, 4.31767911e-01f, 3.03042978e-01f, 5.78813493e-01f, -5.62448725e-02f, -1.58661798e-01f, 2.13229492e-01f, -1.11869097e-01f,
  -1.68953493e-01f, -2.00271338e-01f, 1.16379611e-01f, -6.44616127e-01f, 5.04259348e-01f, 3.16281796e-01f, 5.21423578e-01f, 7.07919419e-01f, 2.47400612e-01f, 3.71708333e-01f,
  3.22184920e-01f, -2.17385039e-01f, -5.17984778e-02f, 5.54672003e-01f, -6.77016497e-01f, 2.77865045e-02f, -3.06809068e-01f, -6.63453758e-01f, 2.41852715e-03f, 2.75486261e-01f,
  2.18448848e-01f, 3.49863440e-01f, -5.60759678e-02f, 4.27073956e-01f, 5.57035685e-01f, 4.91974860e-01f, -1.44337431e-01f, -1.02285624e-01f, 3.86691809e-01f, 8.94480944e-02f,
  1.28803626e-01f, 1.04651965e-01f, -5.24290383e-01f, -3.64971817e-01f, 3.49695653e-01f, -1.87969863e-01f, -6.75463676e-01f, 4.45042878e-01f, -2.58571237e-01f, -3.61244678e-02f,
  3.13934237e-01f, -1.20844454e-01f, 2.08883047e-01f, 1.71436518e-01f, -3.70766610e-01f, -2.69763209e-02f, 4.75032955e-01f, -3.01938921e-01f, 3.32205206e-01f, 1.24304064e-01f,
  5.98123014e-01f, -4.94738609e-01f, 3.22284102e-02f, 4.48665023e-01f, -9.83598828e-02f, -3.75321805e-02f, 4.21664864e-01f, 4.34869081e-01f, 6.64263070e-01f, 3.73929858e-01f,
  2.21097529e-01f, 2.76073188e-01f, -5.56956232e-01f, 1.02451392e-01f, 3.24789286e-02f, 6.81156635e-01f, 3.93227518e-01f, -2.86532223e-01f, -1.48342445e-01f, 4.20068026e-01f,
  -3.86185199e-01f, 2.92303413e-01f, 3.13980639e-01f, 1.00538813e-01f, -1.93436211e-03f, -3.66107732e-01f, -3.10113490e-01f, -1.46308914e-01f, -2.84963071e-01f, -4.24016505e-01f,
  1.72460631e-01f, -4.28296387e-01f, -1.47508979e-01f, -3.04911792e-01f, -6.75822675e-01f, 1.06868535e-01f, 5.10376751e-01f, -3.11650723e-01f, 8.29203576e-02f, 2.75296062e-01f,
  1.33828774e-01f, -8.62887144e-01f, -4.59532142e-02f, 1.03228457e-01f, 4.08987314e-01f, 1.46771431e-01f, 6.81037307e-01f, 3.66769850e-01f, 6.24180436e-01f, 4.35342580e-01f,
  3.12710494e-01f, 3.98148388e-01f, 8.07712078e-02f, 3.73728812e-01f, 7.27314353e-02f, 2.56124884e-01f, -2.65360847e-02f, -2.64193535e-01f, 4.27558646e-02f, 5.05003572e-01f,
  -6.33538127e-01f, -3.10524195e-01f, -2.67760783e-01f, -4.81551558e-01f, -2.77468383e-01f, 1.45698160e-01f, -1.55696511e-01f, 2.43925098e-02f, -4.72335398e-01f, 3.05092752e-01f,
  4.22578186e-01f, 2.88819641e-01f, 1.58671707e-01f, -3.17572713e-01f, 1.54746294e-01f, 1.80451035e-01f, 3.98771077e-01f, 3.08120251e-01f, 5.96657991e-02f, 1.44765615e-01f,
  3.17398250e-01f, 6.25389516e-01f, -8.23566243e-02f, 2.36056209e-01f, 5.09801567e-01f, -1.58938777e-03f, 2.74211131e-02f, 9.38150361e-02f, -1.53382838e-01f, 3.05420049e-02f,
  -1.65319189e-01f, 2.15971425e-01f, -5.38106143e-01f, -1.26694053e-01f, -3.43944728e-01f, -6.13898277e-01f, 2.29421467e-01f, 5.44485390e-01f, -3.75871390e-01f, -5.18689036e-01f,
  -6.10385001e-01f, 5.82778454e-02f, 3.60116541e-01f, 2.23042905e-01f, 4.36813533e-01f, 3.57553244e-01f, 7.89801255e-02f, 1.78747624e-01f, 6.25151247e-02f, 7.11909056e-01f,
  -2.19360851e-02f, 4.05484885e-01f, 1.28759742e-01f, 5.64569652e-01f, 2.96573937e-01f, -6.77234605e-02f, 1.18485235e-01f, 6.19598150e-01f, 3.21126431e-01f, 2.54925072e-01f,
  4.01495308e-01f, -3.59246470e-02f, -3.81042421e-01f, 2.25129694e-01f, -5.16971111e-01f, -4.59014565e-01f, 8.43416303e-02f, -7.49576032e-01f, -8.49821270e-02f, -3.46338719e-01f,
  -4.28370744e-01f, 2.33052343e-01f, 1.34455010e-01f, 3.25692911e-03f, 2.89109856e-01f, 6.56152844e-01f, -4.49279360e-02f, 1.50334854e-02f, -1.96302146e-01f, 2.87429154e-01f,
  6.25337660e-01f, 4.97259991e-03f, 1.46016791e-01f, -5.22073925e-01f, 1.16902061e-01f, 3.96409810e-01f, -5.31708837e-01f, 3.45044971e-01f, 4.82323915e-01f, 6.65662512e-02f,
  3.16496432e-01f, 1.98933184e-01f, 1.57138690e-01f, 3.84292722e-01f, 2.87135363e-01f, 7.22531527e-02f, 4.42226529e-01f, 4.88376886e-01f, -9.00056511e-02f, 5.14761329e-01f,
  4.76271868e-01f, 3.23745459e-01f, 5.65016150e-01f, 3.92064363e-01f, -1.14836201e-01f, 6.51074350e-01f, 2.73605824e-01f, -2.01768607e-01f, 4.59697813e-01f, 5.04434049e-01f,
  5.69316387e-01f, 9.84394699e-02f, -1.58741802e-01f, 1.06751844e-01f, -3.86931241e-01f, 1.12241149e-01f, -3.31058711e-01f, -2.08906293e-01f, 6.88635111e-02f, -1.43707618e-01f,
  -1.10149860e-01f, 3.20820630e-01f, 1.69441625e-01f, 1.40294418e-01f, 2.51646310e-01f, 5.16388357e-01f, 7.56730884e-02f, -4.49556500e-01f, 2.72437096e-01f, -3.38009894e-02f,
  4.55843359e-01f, 3.77350040e-02f, -3.38688821e-01f, 4.74023372e-01f, -5.03644824e-01f, -5.31399488e-01f, 3.37146521e-01f, 1.41775280e-01f, -4.38796163e-01f, -1.67058975e-01f,
  9.45511907e-02f, 2.27794141e-01f, -3.93737018e-01f, -3.64075124e-01f, -3.50931823e-01f, 1.11657955e-01f, 8.97466600e-01f, 2.86673218e-01f, 1.84718326e-01f, 6.61968529e-01f,
  7.65005410e-01f, 8.89739245e-02f, -4.93803388e-03f, 3.72525305e-02f, 2.13445932e-01f, -7.50138387e-02f, 4.02142219e-02f, 2.86610693e-01f, 4.59832281e-01f, 4.25377935e-01f,
  -4.69834745e-01f, 4.61405516e-01f, -3.29758108e-01f, -3.19233894e-01f, 6.78254813e-02f, 6.48735642e-01f, 4.95439529e-01f, -2.87094176e-01f, -1.87367380e-01f, -6.46540746e-02f,
  -2.25029007e-01f, -5.66628635e-01f, 1.39205828e-01f, -3.26537728e-01f, 3.77774954e-01f, 5.32410264e-01f, -1.54701471e-01f, 4.27598804e-01f, 8.42570364e-02f, 3.29962522e-01f,
  5.12271404e-01f, 3.90256375e-01f, 1.00677662e-01f, 1.80532575e-01f, 8.94883424e-02f, 2.74712533e-01f, 3.75033110e-01f, 3.98341089e-01f, 4.77865845e-01f, 3.33341986e-01f,
  -3.32422823e-01f, -6.10887885e-01f, 3.37907761e-01f, -2.32478574e-01f, 5.16754985e-01f, 2.19804153e-01f, -4.24491465e-01f, -1.28265724e-01f, 6.93888590e-02f, 3.96721601e-01f,
  6.07766271e-01f, 5.85897326e-01f, 2.82395363e-01f, 3.92549127e-01f, 7.61446729e-02f, 2.49521568e-01f, -2.32865155e-01f, 1.67027369e-01f, 8.26092623e-03f, -1.77900344e-01f,
  1.27844512e-01f, -5.84791243e-01f, -9.46960896e-02f, -2.29900971e-01f, 3.11174303e-01f, 3.91845644e-01f, 1.19578801e-01f, 3.73505689e-02f, -2.28336692e-01f, 2.93675572e-01f,
  -1.42940715e-01f, 3.97847801e-01f, 1.63346436e-02f, 9.91578177e-02f, 5.74648798e-01f, 5.61781824e-01f, -3.81888658e-01f, 7.46551096e-01f, 7.00228453e-01f, -2.97004819e-01f,
  6.34136975e-01f, 6.08533740e-01f, 2.34661296e-01f, -3.98308337e-01f, -1.59036443e-01f, -3.30333859e-01f, 1.83861524e-01f, 4.76589918e-01f, 2.55250812e-01f, -9.91235077e-02f,
  4.07992631e-01f, -3.58175814e-01f, -3.44454288e-01f, -1.88416876e-02f, -1.39317930e-01f, -2.94447988e-01f, -1.52889520e-01f, 5.58908209e-02f, -5.22427410e-02f, 7.57189915e-02f,
  1.04180396e-01f, 1.74979419e-01f, 5.77266812e-01f, 4.76729214e-01f, -1.67817697e-01f, -5.95698833e-01f, 2.60944307e-01f, -1.26856580e-01f, 6.80807352e-01f, 2.91153252e-01f,
  -4.01333183e-01f, -3.27633530e-01f, 5.72998166e-01f, 6.26076519e-01f, 7.71133304e-01f, 3.38285476e-01f, 2.48684332e-01f, 5.82932830e-01f, -2.61640728e-01f, -2.49559596e-01f,
  -1.60299450e-01f, 4.65195738e-02f, 1.67927220e-01f, -6.14341855e-01f, 4.44116563e-01f, -4.69415516e-01f, 4.07826930e-01f, -3.37736398e-01f, 2.27701552e-02f, 2.43394315e-01f,
  2.59806037e-01f, -8.29877704e-03f, 4.82176006e-01f, -3.04253954e-05f, 2.17419237e-01f, 7.90334702e-01f, -4.56155896e-01f, -2.63232231e-01f, 7.52233267e-02f, -2.14562476e-01f,
  5.74596107e-01f, -2.18466166e-02f, -1.06662773e-01f, 3.87562752e-01f, -2.78170913e-01f, -6.25653744e-01f, -2.82403588e-01f, 4.99755174e-01f, 4.26896036e-01f, 1.40212774e-01f,
  5.04902422e-01f, 5.06487548e-01f, 8.59909728e-02f, -8.52463469e-02f, -1.83367476e-01f, 4.36521381e-01f, -2.29121879e-01f, -1.50468051e-01f, 2.16759339e-01f, -4.34515774e-01f,
  5.38660526e-01f, 1.53699413e-01f, 2.30155110e-01f, 3.92274112e-01f, 2.61486769e-01f, 2.91503847e-01f, 4.86988395e-01f, 3.05158645e-01f, 5.53446531e-01f, -1.32773444e-01f,
  -1.96391746e-01f, 4.63648707e-01f, 3.03603977e-01f, 2.12185085e-01f, -4.05078530e-01f, 7.41436958e-01f, 5.49935520e-01f, 5.12472261e-03f, -6.60628617e-01f, 7.96452761e-01f,
  1.78884730e-01f, -2.14842409e-02f, 2.89865375e-01f, 4.86159295e-01f, 1.87540069e-01f, -5.24255931e-01f, -4.07370962e-02f, 3.33466381e-02f, -2.96088699e-02f, -3.07275981e-01f,
  -2.80392230e-01f, 2.79283643e-01f, 4.83440340e-01f, -3.32057506e-01f, -2.01821670e-01f, 7.61195645e-02f, 2.82479674e-01f, -9.81359556e-02f, 1.67485192e-01f, 8.31772089e-02f,
  7.11702108e-02f, -2.70446867e-01f, -4.02720809e-01f, -7.89097697e-03f, 1.88792676e-01f, 1.24333858e-01f, -3.26891720e-01f, 7.21590519e-01f, -3.23640481e-02f, -3.73695254e-01f,
  -1.63743287e-01f, 2.91098863e-01f, -4.35934484e-01f, -4.26678449e-01f, 1.34976327e-01f, 2.28078626e-02f, 1.69194758e-01f, 4.53403920e-01f, 1.65029824e-01f, 4.09032881e-01f,
  -7.85141438e-02f, 3.68823975e-01f, 4.21776354e-01f, 1.79071441e-01f, 6.03360176e-01f, 3.67858320e-01f, 4.08330739e-01f, -1.31299168e-01f, -2.87751675e-01f, 2.03183800e-01f,
  -5.72094440e-01f, -4.72981423e-01f, -3.03337187e-01f, 4.33859885e-01f, 1.70950845e-01f, 1.52528137e-01f, -5.01269698e-01f, 8.52389485e-02f, 5.71182013e-01f, -3.03369090e-02f,
  -2.61588842e-01f, -2.13971511e-01f, 1.09707406e-02f, -7.17091467e-03f, 3.75426561e-02f, -2.49458730e-01f, 4.03477252e-01f, 6.28046542e-02f, 5.66409230e-01f, -2.65225530e-01f,
  5.23403823e-01f, 4.07365888e-01f, -3.27448040e-01f, 3.16973716e-01f, 5.24415195e-01f, 4.78853146e-03f, 5.56670010e-01f, 2.13970467e-01f, 5.55740118e-01f, 8.22073296e-02f,
  1.87331393e-01f, 1.79904923e-01f, 1.24826774e-01f, 5.07161260e-01f, 6.94766343e-01f, 2.03723714e-01f, 2.97161728e-01f, 5.41936517e-01f, -3.89784992e-01f, 6.26260400e-01f,
  4.06220794e-01f, 3.76226664e-01f, 7.81452060e-01f, 3.56132627e-01f, 6.49515688e-01f, -1.69666469e-01f, -1.67665392e-01f, -2.13578761e-01f, -9.88151059e-02f, 7.77276754e-02f,
  4.93345052e-01f, -4.00011092e-02f, 4.81007397e-01f, -3.06390852e-01f, 5.37831843e-01f, 1.84224620e-01f, -3.26702178e-01f, 2.56188303e-01f, -2.03879222e-01f, 2.44039401e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.82170713e-01f, 2.77556062e-01f, 2.48449221e-01f, 2.26324514e-01f, 1.73863217e-01f, 1.60835579e-01f, 3.52919966e-01f, 3.65660548e-01f, 1.27740800e-01f, 2.20723510e-01f,
  1.86573058e-01f, 3.14212561e-01f, 1.60673380e-01f, 9.42594409e-02f, 1.75858676e-01f, 2.99119830e-01f, 1.26304656e-01f, 1.47468433e-01f, 3.54558825e-01f, 4.82071400e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  1.94736362e-01f, 4.65880185e-02f, -3.15999165e-02f, 2.85262167e-01f, -9.87197682e-02f, -2.41796933e-02f, 1.14594633e-02f, -2.67744660e-01f, 4.68645334e-01f, -1.60760164e-01f,
  -4.68428284e-01f, 4.01696324e-01f, 3.85901719e-01f, -4.15314376e-01f, -2.53392041e-01f, 3.06471080e-01f, -5.31625032e-01f, 3.71021658e-01f, 4.59901392e-01f, 3.05904686e-01f,
  4.17279959e-01f, -5.08159220e-01f, -6.27005875e-01f, -1.82437479e-01f, -4.92373556e-01f, -1.92264482e-01f, -4.66149271e-01f, -8.16823423e-01f, -6.61165595e-01f, -2.03782097e-01f,
  6.77155733e-01f, -4.92516637e-01f, 2.72843003e-01f, -1.32852510e-01f, 1.52211025e-01f, -2.53068984e-01f, -1.51780367e-01f, -2.25189656e-01f, -5.60226403e-02f, 2.05984578e-01f,
  -1.68689907e-01f, 4.05598164e-01f, -2.05446273e-01f, 2.07075588e-02f, -5.17782867e-01f, -6.70287669e-01f, 1.20341159e-01f, 5.09868383e-01f, 3.39370668e-01f, 3.07333052e-01f,
  9.66417566e-02f, -4.66061622e-01f, 5.40213645e-01f, -4.89164352e-01f, -5.12784064e-01f, 5.22387102e-02f, 3.72344822e-01f, -3.43700171e-01f, 2.75607526e-01f, -3.52791131e-01f,
  -6.19883597e-01f, 1.49786726e-01f, -5.01164019e-01f, -5.95344067e-01f, 2.52582908e-01f, 9.32209715e-02f, -1.38643026e-01f, 6.72532618e-02f, -3.26696426e-01f, 2.04230040e-01f,
  2.38266245e-01f, 5.83958402e-02f, 1.30229875e-01f, -1.11238668e-02f, -3.12312514e-01f, 2.93101698e-01f, -5.39541006e-01f, -8.60897124e-01f, 3.72163534e-01f, -3.15894544e-01f,
  -1.94379866e-01f, -3.34210336e-01f, -5.04860163e-01f, -4.43588257e-01f, -1.87899265e-02f, 2.55977213e-02f, -5.71926653e-01f, -6.15844131e-01f, 2.15942264e-01f, 6.29175842e-01f,
  4.21697766e-01f, -6.19963109e-01f, -3.42264414e-01f, -2.56995589e-01f, -1.54521897e-01f, 5.84086716e-01f, 1.22807905e-01f, -3.29034448e-01f, 3.00886363e-01f, -2.71452188e-01f,
  1.57238990e-01f, 1.48402467e-01f, 7.87997618e-02f, 2.74328172e-01f, 1.95524264e-02f, -2.62529224e-01f, 1.94285691e-01f, -2.16518566e-01f, -5.41785955e-01f, -6.13354206e-01f,
  -2.79335499e-01f, -5.42696953e-01f, -5.76366603e-01f, 1.44777060e-01f, 4.30846781e-01f, 2.27997586e-01f, -3.75840366e-02f, -5.47417521e-01f, 4.67158198e-01f, 4.11364883e-01f,
  -5.54576039e-01f, -3.63665015e-01f, -6.16204143e-01f, -3.86903703e-01f, 4.02030647e-01f, 3.20959151e-01f, -6.01026773e-01f, 1.81007832e-02f, -1.95801497e-01f, 3.23190659e-01f,
  1.88165620e-01f, 1.54830009e-01f, 4.95678484e-02f, 4.15405005e-01f, -4.83722568e-01f, 8.90384689e-02f, 2.11848065e-01f, -4.11856711e-01f, -4.21643704e-01f, 4.87030223e-02f,
  -9.66607705e-02f, 3.16023856e-01f, -7.76177287e-01f, 3.55599105e-01f, -6.92221582e-01f, -5.58738828e-01f, 7.54141808e-02f, 1.10059455e-01f, -2.85407096e-01f, 1.83881789e-01f,
  -5.22515059e-01f, 5.53703427e-01f, -4.05096680e-01f, -2.45406181e-01f, -3.40409219e-01f, 6.87093437e-02f, 2.66329467e-01f, 2.21311241e-01f, 1.34440362e-01f, 3.32635850e-01f,
  -2.47382239e-01f, -1.99014321e-02f, -1.59136564e-01f, -2.96984494e-01f, 3.66644114e-01f, 3.33163708e-01f, -2.37973720e-01f, -1.62263229e-01f, -6.34019434e-01f, 4.30143952e-01f,
  5.13815761e-01f, 3.64690244e-01f, 2.25316331e-01f, 3.47906858e-01f, 1.92004621e-01f, 3.87124829e-02f, 2.46982843e-01f, -4.36400324e-01f, 5.97275421e-02f, 3.97806346e-01f,
  2.72592157e-01f, -7.11390451e-02f, -5.33190608e-01f, -4.11115974e-01f, 6.46934435e-02f, -4.50918257e-01f, -1.19795471e-01f, 5.32539666e-01f, -1.25694618e-01f, -4.53401506e-01f,
  -2.24989057e-01f, -9.86292601e-01f, -4.67347026e-01f, -4.73454297e-01f, -1.18504941e-01f, 7.88298324e-02f, 1.72293663e-01f, -5.14882058e-02f, 6.84537226e-03f, -3.74908298e-01f,
  5.61685741e-01f, -6.41686767e-02f, -2.72985816e-01f, 1.72937587e-01f, -2.35319465e-01f, 4.38679248e-01f, 1.47210985e-01f, 1.33007482e-01f, -1.20766349e-02f, -4.70662624e-01f,
  -1.75631255e-01f, -7.38664627e-01f, -4.20997173e-01f, 4.09515113e-01f, -5.96196771e-01f, -4.65106249e-01f, 2.44525254e-01f, 7.70720020e-02f, 1.53281868e-01f, -2.62653798e-01f,
  4.09139842e-01f, -4.05963093e-01f, -2.83656687e-01f, 3.16304043e-02f, 9.93948523e-03f, 1.13012202e-01f, -3.64907831e-01f, -2.37340182e-01f, -3.48617524e-01f, 1.23695051e-03f,
  3.55677605e-01f, 1.78863734e-01f, -2.58478403e-01f, 2.21418783e-01f, 3.31419200e-01f, -2.28226602e-01f, 4.35137182e-01f, 1.40570968e-01f, -5.42011321e-01f, -8.96007895e-01f,
  3.10721666e-01f, 2.13170514e-01f, 8.36883858e-02f, 2.87333399e-01f, -3.54648381e-01f, -5.36761694e-02f, -3.17627639e-01f, 2.72273451e-01f, -3.68376881e-01f, -4.08590198e-01f,
  -2.96835750e-01f, -1.44729093e-01f, -5.90849042e-01f, 3.26347202e-01f, 5.36783859e-02f, -2.57275403e-01f, -6.59442246e-02f, 1.16810076e-01f, -4.60011698e-02f, -1.02953151e-01f,
  -4.04321887e-02f, 1.02696538e-01f, 3.31399441e-01f, -1.82770321e-03f, 4.83415902e-01f, -3.86265099e-01f, 1.71740562e-01f, 3.60548913e-01f, -3.71915758e-01f, -5.36672950e-01f,
  4.54563349e-01f, -6.62675977e-01f, 3.61878425e-01f, 2.68668443e-01f, -5.57324588e-01f, -4.17507052e-01f, -6.16773188e-01f, -5.73836386e-01f, 3.21094990e-01f, -1.51972666e-01f,
  2.21158773e-01f, -2.95360357e-01f, 2.80916423e-01f, 3.67109358e-01f, -4.49074954e-01f, 3.12792927e-01f, 4.57890391e-01f, -4.61063594e-01f, 1.26197904e-01f, 1.65153649e-02f,
  2.37922847e-01f, -3.23599815e-01f, -1.42760038e-01f, -5.85516803e-02f, -2.35823929e-01f, 6.99117109e-02f, -4.84145045e-01f, 3.59502286e-01f, -9.96322632e-02f, -5.73777199e-01f,
  2.96629518e-01f, 1.59905180e-01f, -7.65192583e-02f, -7.23625571e-02f, 4.18580264e-01f, -3.91945511e-01f, -3.30800861e-01f, -1.82439774e-01f, -6.65939867e-01f, 3.17100078e-01f,
  -3.36283952e-01f, -1.17679052e-01f, -6.44395828e-01f, 4.87660646e-01f, -7.90592909e-01f, -7.66934276e-01f, -3.03878605e-01f, -6.37584150e-01f, 4.31379318e-01f, 3.89450669e-01f,
  2.05586165e-01f, -2.50235200e-01f, 6.27226979e-02f, 1.04183502e-01f, 2.24097252e-01f, 2.08821818e-01f, 2.26961792e-01f, 3.21178555e-01f, -5.06344974e-01f, -3.22185934e-01f,
  2.96902448e-01f, -3.37110937e-01f, -2.66202688e-01f, 5.86358249e-01f, -4.94225293e-01f, -3.72922361e-01f, -5.61093688e-01f, 3.02265257e-01f, -4.17231351e-01f, -5.15422285e-01f,
  1.81485578e-01f, -3.21106791e-01f, 4.63082850e-01f, -2.72116542e-01f, 3.76705945e-01f, -4.81753379e-01f, 4.07931864e-01f, -4.77668554e-01f, -3.15803558e-01f, -4.06745136e-01f,
  -6.15586758e-01f, 4.10041869e-01f, 1.43997967e-01f, -1.30482599e-01f, 1.25692919e-01f, 1.15592115e-01f, -6.88073859e-02f, -1.86344475e-01f, 3.04126561e-01f, -2.38232315e-01f,
  2.75465816e-01f, -1.13591209e-01f, 2.62933671e-01f, -3.53724360e-01f, -6.15851760e-01f, 9.56392437e-02f, 1.85261190e-01f, -5.12655258e-01f, -4.98763949e-01f, -6.57408357e-01f,
  -4.45173353e-01f, 1.76173180e-01f, -5.49019158e-01f, 2.63062209e-01f, 2.77845949e-01f, -5.47529280e-01f, 3.81794184e-01f, -1.14619792e-01f, -6.40970290e-01f, 6.09535098e-01f,
  3.53879452e-01f, 3.47041488e-01f, 1.91485420e-01f, -3.51511657e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.88496098e-01f, -5.67405345e-03f, 1.60332844e-01f, -6.24758899e-02f, 2.74346350e-03f, -8.01768750e-02f, -1.24329999e-01f, -2.11545825e-01f, 9.67978090e-02f, 1.53110042e-01f,
  1.58423841e-01f, 1.58470809e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    