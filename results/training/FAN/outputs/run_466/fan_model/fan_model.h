/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.62090480e-01f, -2.22255383e-02f, -7.11090937e-02f, 1.23947583e-01f, 3.18714939e-02f, 1.87777281e-01f, 1.60740614e-01f, 5.13582714e-02f, -8.29424560e-02f, 5.53702079e-02f,
  5.41567244e-02f, -5.19479774e-02f, -8.95671360e-03f, 1.15008920e-01f, 1.92643791e-01f, -1.60375759e-02f, 1.15138911e-01f, 4.49811742e-02f, -9.05688182e-02f, 4.40310389e-02f,
  5.14673702e-02f, 2.38855496e-01f, 2.34348699e-02f, 1.14483416e-01f, 2.32907180e-02f, -7.82089010e-02f, -8.02837312e-02f, -6.30661659e-03f, 1.14345297e-01f, 3.85260023e-02f,
  4.38169725e-02f, -1.14142410e-01f, 2.95875082e-03f, 1.66392010e-02f, -2.26380322e-02f, 5.94882891e-02f, 8.29831511e-02f, 6.23582192e-02f, -4.48304182e-03f, -3.10982931e-02f,
  3.53690982e-02f, 2.24798103e-03f, 1.54409846e-02f, -1.72899105e-02f, 6.49318397e-02f, -3.49748917e-02f, -9.26582068e-02f, -6.16730489e-02f, -2.38856897e-02f, 4.83411849e-02f,
  -1.97111480e-02f, 3.50074004e-03f, 3.18142176e-02f, -2.45053344e-03f, -1.37785524e-02f, -2.99119558e-02f, 6.30849823e-02f, -5.45191541e-02f, -2.96583492e-02f, -2.66879029e-03f,
  4.04767580e-02f, 7.11527169e-02f, 1.42062074e-02f, -4.28079441e-02f, 2.11148541e-02f, -1.56350583e-02f, 2.05939543e-02f, -6.95572933e-03f, 2.75955889e-02f, 1.39624905e-02f,
  -1.68567803e-03f, -2.77685281e-02f, -7.44419172e-03f, 6.80888519e-02f, 8.35241079e-02f, -2.22236328e-02f, -1.43546229e-02f, -1.43093513e-02f, -2.29403563e-02f, 4.71043400e-02f,
  -6.23632669e-02f, 2.82219797e-03f, -3.58616374e-02f, -2.66360734e-02f, 1.10598691e-02f, -1.98704167e-03f, 4.73475037e-03f, 2.04338953e-02f, -3.05014011e-02f, 6.57112077e-02f,
  -1.27496812e-02f, 3.81777063e-02f, -3.44837755e-02f, 1.15017230e-02f, -3.54340263e-02f, 2.35074684e-02f, -6.46982044e-02f, 4.96268272e-02f, -2.24012639e-02f, 9.38396715e-03f,
  5.31779453e-02f, 2.12458032e-03f, 1.13341901e-02f, 2.77910358e-03f, -3.34928520e-02f, -3.54358787e-03f, 8.08754265e-02f, -3.73263992e-02f, 4.04060297e-02f, -7.61541026e-03f,
  -3.56381759e-02f, 4.44920883e-02f, -4.93054241e-02f, 6.99361414e-03f, 2.58469936e-02f, 2.27226261e-02f, 1.82408746e-02f, 4.27073240e-02f, -4.72456813e-02f, -7.28868367e-03f,
  4.09507990e-01f, 2.56009966e-01f, -1.08355507e-01f, 1.99931219e-01f, -2.92102426e-01f, -3.32548805e-02f, 1.78343982e-01f, -9.19145048e-02f, -1.50481418e-01f, 1.26615450e-01f,
  2.12375537e-01f, -5.99857345e-02f, 1.55011088e-01f, 1.99238807e-01f, 7.35615715e-02f, 2.07773477e-01f, 1.13219894e-01f, 7.88710415e-02f, -2.48900801e-02f, -5.78741096e-02f,
  1.38020786e-02f, 1.34013444e-01f, 1.18140936e-01f, -5.96636385e-02f, 2.59662084e-02f, -6.59044459e-02f, 1.10734351e-01f, -9.22514498e-02f, -4.80423355e-03f, -2.21466413e-03f,
  4.53739502e-02f, -1.45767676e-03f, 1.31323915e-02f, -3.87533642e-02f, -1.18226502e-02f, -1.65818054e-02f, -1.54029150e-02f, 3.57139707e-02f, -6.45466447e-02f, 1.00406744e-02f,
  -1.30521152e-02f, -6.50818869e-02f, 2.86508873e-02f, -8.72125570e-03f, -3.11340503e-02f, -5.95494285e-02f, -1.10709807e-02f, 1.89450774e-02f, 1.72356772e-03f, -1.59776565e-02f,
  -1.04394175e-01f, -1.06912151e-01f, -2.24118754e-02f, -8.75913128e-02f, -6.04102463e-02f, -5.48200123e-02f, -2.70700287e-02f, -3.15056071e-02f, -2.48119980e-02f, -7.90148079e-02f,
  -1.65017135e-02f, -4.04611193e-02f, 2.84427945e-02f, -2.57144421e-02f, 3.29880677e-02f, 6.36351854e-02f, -7.00766826e-03f, 6.90546706e-02f, 2.15263646e-02f, 2.19773930e-02f,
  -2.27718446e-02f, 3.30241024e-02f, 1.95156783e-02f, -2.64394358e-02f, 3.11055835e-02f, 3.43475714e-02f, 2.31852978e-02f, -4.77264300e-02f, -4.69271727e-02f, 5.80902882e-02f,
  2.73948535e-02f, -7.13492632e-02f, -3.85721331e-03f, 2.15230938e-02f, -6.52507097e-02f, -3.36453430e-02f, -5.37805520e-02f, -2.84494995e-03f, 1.77552216e-02f, 8.59392155e-03f,
  2.89943870e-02f, -1.13740236e-01f, 3.67231220e-02f, -3.90617736e-02f, 3.29299197e-02f, 4.54516849e-03f, 1.01825818e-02f, -1.24337841e-02f, -1.59287285e-02f, 5.12393005e-02f,
  -1.13162014e-03f, 4.70685512e-02f, -4.47380394e-02f, 3.93698039e-03f, -1.78280286e-02f, 4.61834436e-03f, 1.01374965e-02f, -2.53095664e-02f, -4.55174483e-02f, -3.67288291e-02f,
  -2.87056975e-02f, -2.90168240e-03f, -2.83040083e-03f, 1.09856896e-01f, -4.58945557e-02f, 4.55479696e-02f, 1.06272986e-02f, -7.53388405e-02f, -7.32335895e-02f, -3.97238098e-02f,
  2.57420182e-01f, 1.46261469e-01f, 1.84280440e-01f, 1.96298003e-01f, -5.33653721e-02f, -2.10623711e-01f, -3.48605849e-02f, 1.18124746e-01f, 1.63859457e-01f, -7.55416155e-02f,
  -1.40717300e-02f, 8.24255645e-02f, 8.10204968e-02f, -3.28475237e-02f, 8.98343250e-02f, 8.85114074e-02f, -3.12030837e-02f, 4.04032767e-02f, 1.40491500e-01f, 8.10211226e-02f,
  1.24169864e-01f, -2.32386127e-01f, 1.52766123e-01f, -1.07160874e-01f, -9.24239382e-02f, 5.22875190e-02f, -5.31516112e-02f, -4.28337939e-02f, -5.17527387e-02f, -9.43931416e-02f,
  -1.56596512e-01f, 5.89885563e-02f, 1.24305002e-01f, -3.03552095e-02f, -1.56906489e-02f, -4.57463004e-02f, 6.10316992e-02f, 2.87713017e-03f, -2.74711102e-02f, -5.73295951e-02f,
  9.63128451e-03f, -4.14417870e-02f, -1.80321597e-02f, 1.18440948e-03f, -8.14987049e-02f, -7.37431599e-03f, 3.79085466e-02f, -1.14551121e-02f, 3.69462222e-02f, 6.20767251e-02f,
  -1.78213324e-02f, -2.25831028e-02f, -5.21203540e-02f, 9.09815636e-03f, 3.93098444e-02f, -2.43236888e-02f, 8.44319612e-02f, 2.61576343e-02f, 5.89076057e-03f, 4.28838804e-02f,
  -1.18846959e-02f, -3.40253883e-03f, 8.77523050e-02f, -4.12113741e-02f, -4.19267975e-02f, -3.77544388e-02f, -4.24549393e-02f, -5.28360195e-02f, -1.04151718e-01f, -1.93775687e-02f,
  4.19630259e-02f, 8.30962509e-02f, 2.84632668e-02f, 2.93507073e-02f, 2.86368709e-02f, -2.25181822e-02f, 1.22270780e-02f, 5.57193067e-04f, 2.37271320e-02f, 8.75440538e-02f,
  1.45582482e-02f, -1.10166585e-02f, -7.01679382e-03f, -4.28409092e-02f, -1.77510735e-02f, 1.51311830e-02f, -2.40938496e-02f, 1.29282577e-02f, 1.19074605e-01f, 7.25689903e-02f,
  -1.91799521e-01f, 4.91696484e-02f, -4.35080193e-02f, 7.99173042e-02f, -1.06368782e-02f, 3.63415689e-03f, -3.46778259e-02f, -1.28189586e-02f, -7.67697692e-02f, 4.02314439e-02f,
  3.96598093e-02f, 9.29653924e-03f, -6.81376308e-02f, -2.49343235e-02f, -2.35288925e-02f, 3.79136316e-02f, -8.29986390e-03f, -6.24352656e-02f, -2.25862954e-03f, 2.05541346e-02f,
  -4.82723974e-02f, -1.14862673e-01f, -8.45090300e-02f, 2.61255130e-02f, -1.51204765e-02f, -3.62547413e-02f, 2.73286970e-03f, 4.07664627e-02f, 3.10824122e-02f, -6.10890165e-02f,
  2.17280705e-02f, -2.85042167e-01f, -1.75237760e-01f, -6.93910867e-02f, 1.43233523e-01f, 5.46455443e-01f, 3.00867200e-01f, -5.26650399e-02f, 7.08072037e-02f, -1.50029659e-01f,
  1.25408739e-01f, -1.88124506e-03f, -5.22989109e-02f, 3.03765446e-01f, 4.24609005e-01f, 1.91731796e-01f, 2.60947227e-01f, 1.37258634e-01f, 4.85252813e-02f, -5.86873479e-02f,
  1.06463470e-01f, 1.49359211e-01f, 1.90268382e-02f, -5.42472005e-02f, -7.44612813e-02f, -2.43646026e-01f, -2.50182360e-01f, -1.34295762e-01f, -2.08077207e-01f, 1.45044863e-01f,
  1.56029642e-01f, -2.49061380e-02f, -5.39373383e-02f, 3.90518531e-02f, -3.69688310e-02f, -1.23422399e-01f, -9.70465038e-03f, 1.61558799e-02f, -1.88097600e-02f, 1.88531727e-02f,
  1.46860816e-02f, 7.43316486e-02f, 6.10600524e-02f, 3.83606292e-02f, -3.55189219e-02f, 5.41542890e-03f, -1.70936459e-04f, 8.28993414e-03f, 1.50535032e-02f, 4.60472777e-02f,
  5.78495115e-02f, -3.67019512e-02f, -4.70877625e-02f, -6.57717660e-02f, 2.69552488e-02f, 6.50351048e-02f, -1.94196999e-02f, 6.68001622e-02f, -1.72917638e-02f, 1.04816388e-02f,
  -5.78358211e-02f, -6.11501411e-02f, 5.96054904e-02f, -6.21171622e-03f, -3.10147237e-02f, -5.39149344e-03f, 2.36139516e-03f, 2.15265416e-02f, -3.20364274e-02f, 1.96878333e-02f,
  -1.04545439e-02f, -2.97910497e-02f, 6.94371611e-02f, -5.16111702e-02f, 2.47914642e-02f, 1.26169687e-02f, -9.55051854e-02f, 3.11048012e-02f, 4.19774093e-02f, 2.54134126e-02f,
  -5.84724545e-02f, 2.24961489e-02f, -5.97509183e-02f, -7.08437935e-02f, 4.71963659e-02f, -6.81148395e-02f, -2.60992423e-02f, -3.63390706e-02f, -1.63379442e-02f, 5.98854152e-04f,
  -4.16976884e-02f, -1.63161591e-01f, 1.10671744e-02f, 9.98083781e-03f, 1.18033122e-03f, 4.18008193e-02f, 5.80403619e-02f, 2.63131503e-02f, -7.07183555e-02f, -1.07004819e-03f,
  -4.96839918e-02f, -2.72546057e-02f, -1.18099675e-01f, -1.92503817e-02f, -3.33056925e-03f, 2.88189910e-02f, -1.97809245e-02f, -6.17020689e-02f, -8.38379636e-02f, -5.17191738e-03f,
  -1.10429540e-01f, 6.00037985e-02f, 3.00664436e-02f, 2.03229114e-02f, -4.64733914e-02f, -4.16767783e-02f, 4.78367805e-02f, -4.97702025e-02f, -2.25874898e-03f, 1.23636220e-02f,
  -4.57397729e-01f, 1.04863554e-01f, -2.29186803e-01f, -3.64015222e-01f, 5.79186901e-02f, 2.35646904e-01f, 6.66818917e-02f, -4.94437118e-04f, -1.49422750e-01f, 1.04607038e-01f,
  5.08223400e-02f, -2.56117284e-01f, 5.43091400e-03f, -2.41459571e-02f, -4.78832573e-02f, 7.38126710e-02f, -3.77877913e-02f, 1.63756944e-02f, -1.69997420e-02f, -8.12366605e-03f,
  -1.00235954e-01f, 1.34467855e-01f, -1.83869585e-01f, 1.81543320e-01f, -3.32733132e-02f, -1.16770431e-01f, 6.84355423e-02f, 6.90685362e-02f, 1.03261903e-01f, 1.06633350e-01f,
  5.84621243e-02f, -2.26205625e-02f, -6.21364731e-03f, 5.98966368e-02f, 3.57639454e-02f, 2.70703249e-02f, -2.07218565e-02f, 4.63382006e-02f, -9.60914493e-02f, -3.31119932e-02f,
  3.90059091e-02f, 1.49854952e-02f, 1.50720626e-02f, 8.16557482e-02f, -3.79922017e-02f, -4.78623509e-02f, 1.42517989e-03f, 2.84859706e-02f, 1.97432749e-02f, -9.31664649e-03f,
  -8.94041136e-02f, -1.81522742e-02f, 4.01354278e-04f, 3.12525406e-02f, -5.37574366e-02f, 5.96825145e-02f, 2.42815539e-02f, 8.10683891e-02f, 8.88713112e-04f, 2.18738262e-02f,
  1.19142555e-01f, -2.54429802e-02f, 1.44305425e-02f, 3.16902734e-02f, 4.03972417e-02f, -1.66457612e-02f, 1.47882104e-02f, -2.29289290e-02f, -3.75260375e-02f, -3.14827776e-03f,
  -5.18143624e-02f, -4.37536426e-02f, -4.24118266e-02f, -6.89399168e-02f, -8.45503435e-02f, -3.08603495e-02f, 4.04775813e-02f, -2.14549750e-02f, -7.76983146e-03f, -4.45047244e-02f,
  -9.36108157e-02f, -2.80811470e-02f, -2.99926046e-02f, -2.18075346e-02f, 1.48803939e-03f, -3.45920101e-02f, -3.79800722e-02f, 2.04488877e-02f, 2.99562681e-02f, 1.99793596e-02f,
  9.98032764e-02f, 8.23029429e-02f, 2.02173125e-02f, -4.33940999e-02f, 4.48202295e-03f, -6.18423410e-02f, -6.00539148e-02f, -8.98552965e-03f, -2.06944384e-02f, 7.59708658e-02f,
  3.62366363e-02f, -3.11857928e-02f, 4.68326919e-02f, -5.40378541e-02f, 5.95157370e-02f, 4.43234183e-02f, -3.15419994e-02f, 3.75126936e-02f, 4.48473766e-02f, 4.95459028e-02f,
  1.29567971e-03f, -7.41364881e-02f, 7.16744885e-02f, 6.67745396e-02f, 3.91345806e-02f, -1.34460740e-02f, -4.74845432e-02f, -6.39545545e-02f, 1.75875500e-02f, 3.51492316e-02f,
  -4.76475626e-01f, -8.09281617e-02f, 9.32764560e-02f, -1.53648853e-01f, -2.73632914e-01f, -8.53992812e-03f, 5.53183407e-02f, -1.68680295e-01f, 1.23639680e-01f, -1.38434479e-02f,
  -9.06398967e-02f, 2.61407733e-01f, 1.13637798e-01f, -3.08545935e-03f, 1.12492256e-01f, 2.69721866e-01f, -3.54494043e-02f, -2.88918009e-03f, -2.22712122e-02f, -8.86303186e-02f,
  -1.04014180e-03f, -8.58820528e-02f, 9.86451432e-02f, -1.88639864e-01f, -1.67063043e-01f, -1.54744923e-01f, -2.52721496e-02f, 4.66511771e-02f, -2.53805757e-01f, 2.86059012e-03f,
  -1.02734022e-01f, -8.27788264e-02f, -1.24498054e-01f, 9.89509821e-02f, -1.09254353e-01f, 1.38676986e-02f, 7.07969368e-02f, 9.12249386e-02f, 2.59749265e-03f, -3.63909523e-03f,
  3.12556587e-02f, -3.49316448e-02f, -3.00940182e-02f, 3.12874583e-03f, 5.69247939e-02f, -6.92358091e-02f, -5.37308268e-02f, -5.34805506e-02f, 1.49736414e-02f, 8.43677483e-03f,
  9.85831395e-03f, -2.86658984e-02f, -1.76467970e-02f, 3.23224664e-02f, -1.71400495e-02f, -1.29383001e-02f, -1.56515483e-02f, 2.49215495e-02f, -4.58157472e-02f, 1.02057913e-02f,
  1.30117200e-02f, 2.36411523e-02f, -6.49684155e-03f, 3.09582427e-03f, 2.75553539e-02f, -8.42125341e-02f, -1.73374973e-02f, 1.11666890e-02f, 6.89639598e-02f, 1.82233774e-03f,
  -8.04359987e-02f, 9.78400093e-03f, 7.84191862e-03f, 1.81223322e-02f, 2.56926497e-03f, -3.39885056e-02f, -3.08585521e-02f, 3.61356214e-02f, 1.69092901e-02f, 5.97643368e-02f,
  3.40187475e-02f, 4.97691967e-02f, -2.54264977e-02f, 4.95968536e-02f, 6.35421276e-02f, 7.68810362e-02f, 4.90969606e-02f, 2.52593830e-02f, -8.09126440e-03f, 2.22550835e-02f,
  -1.03046615e-02f, 1.13718053e-02f, -4.09700759e-02f, -4.28579226e-02f, 2.71084961e-02f, -4.57100058e-03f, 2.17201049e-03f, -5.11300052e-03f, 1.68993734e-02f, -7.26371929e-02f,
  -2.78365333e-02f, -5.61526697e-03f, -7.05600381e-02f, 1.02920443e-04f, 2.74848863e-02f, 4.67599705e-02f, 7.60736391e-02f, -3.79745103e-02f, -5.91293387e-02f, -2.22526630e-03f,
  -3.76032107e-02f, -4.77633849e-02f, 3.62160131e-02f, -6.21017478e-02f, -2.82850415e-02f, -6.21907972e-02f, -6.61650598e-02f, -6.33557141e-03f, 5.49906977e-02f, -1.55009599e-02f,
  1.26561269e-01f, -6.13561645e-02f, 1.08165599e-01f, 1.59326252e-02f, 4.86543551e-02f, -1.82580367e-01f, 2.35455632e-02f, 6.89248741e-02f, 3.16993505e-01f, 6.41942695e-02f,
  -1.08920738e-01f, 1.12219974e-01f, -1.12698294e-01f, -1.43464208e-01f, -1.17548019e-01f, -1.40814200e-01f, -1.71203360e-01f, -5.74134178e-02f, 2.05098819e-02f, -1.44232050e-01f,
  -4.00705226e-02f, -2.10223675e-01f, -2.18207553e-01f, -9.73588601e-03f, 2.72079501e-02f, 2.48186309e-02f, -2.38870606e-01f, -6.39111474e-02f, -7.47708157e-02f, -2.74417438e-02f,
  7.70008639e-02f, 1.56083152e-01f, -8.77501592e-02f, 3.10466494e-02f, -2.20306171e-03f, -5.20200878e-02f, -6.21370487e-02f, -7.12279752e-02f, 7.29201268e-03f, 3.20082046e-02f,
  -6.23856019e-03f, 5.40208891e-02f, 4.85835411e-02f, 2.33442225e-02f, 1.02562688e-01f, 1.43648297e-01f, -5.86588606e-02f, 2.38350909e-02f, 5.26198149e-02f, 3.49093117e-02f,
  4.38335538e-02f, 5.81969991e-02f, -1.01059279e-03f, -2.47274619e-02f, 1.84498094e-02f, 5.44378683e-02f, 2.53505502e-02f, -6.37807623e-02f, 6.03473336e-02f, 5.61716370e-02f,
  -1.14087597e-01f, -8.44655409e-02f, 6.99695498e-02f, 2.85055172e-02f, 8.64993781e-02f, 3.87650765e-02f, 5.82833886e-02f, 5.36762848e-02f, 1.35237664e-01f, 3.78151871e-02f,
  -2.22642478e-02f, -1.93598736e-02f, 4.75825556e-02f, 6.12732992e-02f, -2.22909693e-02f, -1.08202389e-02f, -4.23219084e-04f, 7.58016184e-02f, 5.98754408e-03f, -6.52684569e-02f,
  -4.14364934e-02f, 6.73000738e-02f, -2.41532680e-02f, -1.77248325e-02f, 6.82455227e-02f, 6.40573651e-02f, -2.82594059e-02f, 1.45149350e-01f, -1.07790731e-01f, -8.03053156e-02f,
  -2.28323013e-01f, -1.92144141e-01f, -1.29273674e-02f, 4.42653634e-02f, 6.14644727e-03f, -4.40320782e-02f, 5.15441876e-03f, 2.44127996e-02f, -5.09286486e-02f, -9.64848474e-02f,
  -3.21113877e-02f, 4.47401777e-02f, -6.93882555e-02f, 6.99566631e-03f, -9.98135731e-02f, 2.93587390e-02f, -1.29196821e-02f, -3.24072428e-02f, -1.38460591e-01f, -3.55154574e-02f,
  -3.42347138e-02f, -1.88269597e-02f, 5.02272956e-02f, -2.79440153e-02f, -3.87934558e-02f, 1.08307786e-03f, 5.43514527e-02f, 7.10095325e-03f, -6.81899786e-02f, -7.43008107e-02f,
  5.48150837e-01f, -4.88413095e-01f, 1.79757118e-01f, -5.11845164e-02f, -1.51365753e-02f, -1.23958580e-01f, 1.75143749e-01f, -2.51319051e-01f, 1.48651019e-01f, -2.62068570e-01f,
  -3.37188877e-02f, 3.66035500e-04f, -2.29638945e-02f, -1.81405067e-01f, 2.56244242e-01f, 4.29618917e-02f, 6.75985143e-02f, -7.25716874e-02f, -1.42145947e-01f, -7.12752342e-02f,
  -1.78679600e-02f, -1.24588743e-01f, 5.78159355e-02f, -1.49163902e-01f, -1.09309033e-01f, 1.84882972e-02f, 5.10720946e-02f, -6.24272488e-02f, -3.30062658e-02f, -1.82925481e-02f,
  5.89166246e-02f, -1.44950420e-01f, 1.11710593e-01f, 6.74847290e-02f, 1.20459124e-02f, 9.90224183e-02f, 2.22124495e-02f, 5.44316731e-02f, 1.40948994e-02f, -2.11382955e-02f,
  4.00298126e-02f, 2.57543623e-02f, 1.19997978e-01f, 5.46644144e-02f, -8.94603785e-03f, -1.42072141e-02f, -3.46717648e-02f, 3.82145005e-03f, 2.46826001e-03f, 1.21591529e-02f,
  -2.80479826e-02f, -2.47602072e-02f, 3.01872343e-02f, 8.89400616e-02f, 3.91014032e-02f, -6.95099914e-03f, 2.00362504e-03f, 3.01191360e-02f, 4.52726847e-03f, 1.66221764e-02f,
  6.05619475e-02f, -2.33174041e-02f, 3.86857279e-02f, 5.46476878e-02f, -5.80874532e-02f, 1.15317507e-02f, -6.91945255e-02f, -3.53886075e-02f, -2.94567319e-03f, 1.84406433e-02f,
  -6.73232309e-04f, -1.69413593e-02f, -1.90632250e-02f, -3.81797738e-02f, -4.04117070e-02f, 3.92132737e-02f, 6.63276240e-02f, -1.06218182e-01f, -1.50006954e-02f, 2.26735640e-02f,
  -5.05642481e-02f, -9.76727158e-02f, 5.78176742e-03f, 3.33437361e-02f, 1.39360689e-02f, -2.64890604e-02f, -7.49621838e-02f, 1.16303992e-02f, -5.46417944e-02f, -2.40108185e-02f,
  -1.03693314e-01f, -2.87337273e-01f, -2.96329707e-02f, -1.79690309e-02f, 3.08108069e-02f, -2.61344928e-02f, 1.88144445e-02f, 2.61898967e-04f, -4.01677489e-02f, -9.68559086e-02f,
  -3.57012823e-03f, -1.18462369e-03f, 1.74184460e-02f, -2.74742544e-02f, 8.20441265e-03f, -2.59486716e-02f, -1.56560214e-03f, 1.08540859e-02f, -2.23807991e-02f, -4.09063101e-02f,
  -4.61072102e-02f, 4.24747057e-02f, 4.65768017e-03f, 2.03688852e-02f, 2.53549758e-02f, 1.54171390e-02f, -3.58354151e-02f, -2.69043315e-02f, -5.48819825e-02f, -2.82277968e-02f,
  4.29851353e-01f, -2.53861427e-01f, -6.32378012e-02f, 2.50367939e-01f, 8.66999701e-02f, 1.48247974e-02f, 2.09405124e-01f, 7.46632591e-02f, 1.60866216e-01f, -2.13286772e-01f,
  7.77177066e-02f, 3.63590755e-02f, -1.68369394e-02f, -7.29965270e-02f, 3.53037238e-01f, 3.87155935e-02f, 1.23419270e-01f, 1.28047843e-03f, -6.02668077e-02f, -9.23171639e-02f,
  6.78311959e-02f, 8.06787089e-02f, 8.30402896e-02f, -2.58487929e-02f, -8.08052626e-03f, 3.15945670e-02f, 1.90039977e-01f, 3.90970111e-02f, -3.77792008e-02f, 1.64011091e-01f,
  -4.07537222e-02f, 6.33529713e-03f, 1.89641882e-02f, -8.20264518e-02f, 8.38135630e-02f, -4.00931686e-02f, -1.24850008e-03f, 1.43929943e-01f, 5.14716422e-03f, -1.53413473e-03f,
  5.46586849e-02f, 1.70465540e-02f, 6.27894923e-02f, 7.71428868e-02f, 7.62287853e-03f, -5.66561781e-02f, 6.87515736e-02f, -8.31442475e-02f, -1.13400500e-02f, -8.82697254e-02f,
  -9.92369503e-02f, -1.57268927e-01f, -6.43381625e-02f, -7.56962523e-02f, 3.00438255e-02f, 2.76777986e-02f, -9.23654437e-02f, 4.37838323e-02f, 2.82780342e-02f, 4.59706858e-02f,
  5.46450019e-02f, -1.02185398e-01f, -1.15467403e-02f, -6.26153424e-02f, -1.98541433e-02f, -3.56107615e-02f, 9.35809501e-03f, -3.88990082e-02f, -1.26561532e-02f, -4.33901325e-02f,
  5.10125421e-02f, 7.22463131e-02f, -8.73218570e-03f, 5.86069450e-02f, -6.71098083e-02f, -2.67221015e-02f, 7.98538849e-02f, -1.43585522e-02f, -4.55956645e-02f, -4.30429839e-02f,
  -1.30027831e-02f, 4.29292396e-02f, -2.58337893e-02f, 7.49089271e-02f, 2.04692595e-02f, 8.60255957e-02f, 4.31487560e-02f, 7.23661948e-03f, 5.95273413e-02f, 1.62485540e-01f,
  -3.61657590e-02f, -5.53569347e-02f, -4.41955961e-02f, -7.42589077e-03f, -4.22754623e-02f, -1.37385832e-05f, 1.22699465e-04f, -8.16241466e-03f, -1.44217880e-02f, 3.89484204e-02f,
  -1.02529041e-01f, -4.41436023e-02f, -2.97761541e-02f, 5.00169210e-02f, 3.42068598e-02f, 4.49075364e-02f, -3.49729620e-02f, 7.33391941e-02f, 7.63122216e-02f, -4.92646219e-03f,
  1.30261192e-02f, -3.35297026e-02f, 7.20554441e-02f, 6.37965184e-03f, -4.62259948e-02f, -8.83335397e-02f, 3.86162065e-02f, -3.71398106e-02f, 9.31588411e-02f, 4.72165062e-04f,
  1.03841364e-01f, 1.63073629e-01f, 2.70669401e-01f, 6.31841719e-02f, -7.09227696e-02f, -5.35797589e-02f, 2.37171233e-01f, -6.16839752e-02f, 3.86120558e-01f, -1.13798641e-01f,
  -1.18481897e-01f, 6.97444603e-02f, 2.06585303e-01f, -3.96030992e-02f, -1.64335132e-01f, 2.57515877e-01f, -1.00779086e-01f, -1.44786378e-02f, 2.41800487e-01f, -1.02957740e-01f,
  -1.07061479e-03f, -2.83324391e-01f, -4.55002971e-02f, -2.41162211e-01f, -5.71524687e-02f, -9.35452804e-02f, -4.42661077e-01f, 3.23913544e-02f, -3.44702244e-01f, -5.71004190e-02f,
  -3.50881405e-02f, 1.68220893e-01f, 6.25694245e-02f, 6.61615878e-02f, -1.17634498e-01f, -1.61533505e-02f, -5.81720024e-02f, 7.27325380e-02f, -1.09644420e-02f, 1.72371846e-02f,
  1.79046821e-02f, -4.09883298e-02f, -4.55441885e-02f, 1.22971132e-01f, 1.81294419e-02f, 4.80845058e-03f, 6.36930317e-02f, -4.76008393e-02f, 4.44063544e-03f, 1.93392709e-02f,
  5.51574351e-03f, 7.16211349e-02f, 4.08927947e-02f, 2.08721403e-02f, 1.94783080e-02f, 2.34406777e-02f, -3.07835848e-03f, -5.05771860e-02f, 2.08672904e-03f, -1.91196278e-02f,
  1.11988798e-01f, 2.69568935e-02f, -2.92802043e-02f, 8.19493365e-03f, -4.22738008e-02f, 4.05558832e-02f, -4.00392376e-02f, -3.97463627e-02f, 4.52235080e-02f, -2.19011921e-02f,
  -1.23026386e-01f, 7.29948878e-02f, 6.88958988e-02f, 7.27134198e-02f, 5.02985939e-02f, 2.03213077e-02f, 2.65748193e-03f, -3.29484791e-02f, -3.12308967e-02f, -3.29723507e-02f,
  6.78167418e-02f, -4.74623665e-02f, -1.17494851e-01f, 3.19343768e-02f, 3.69824097e-02f, 5.18737473e-02f, -1.35899484e-02f, 6.37684092e-02f, -1.84328109e-02f, -1.88037511e-02f,
  -3.72476935e-01f, -1.60184234e-01f, -2.36558337e-02f, 2.32815258e-02f, -8.32277071e-03f, -6.40739650e-02f, 4.22973596e-02f, -3.39432340e-03f, -5.51273227e-02f, 4.63324152e-02f,
  -1.44768897e-02f, -1.09000303e-01f, -2.31760256e-02f, -3.11622825e-02f, -2.76322826e-03f, -7.20671639e-02f, -6.09760806e-02f, -4.61928826e-03f, -1.02535561e-01f, -2.46733055e-02f,
  -8.28764662e-02f, -1.40884826e-02f, -1.39390919e-02f, -5.99512458e-02f, -9.59384628e-03f, -1.25111500e-02f, -1.02808610e-01f, 1.96070336e-02f, -5.33418804e-02f, 4.34515066e-02f,
  3.15800041e-01f, 2.26614073e-01f, 1.49632871e-01f, 2.12702870e-01f, 2.94177026e-01f, 6.68774992e-02f, 3.48181203e-02f, 2.04425037e-01f, 2.62577951e-01f, -1.08058430e-01f,
  3.57212615e-03f, 7.56657273e-02f, -2.49262303e-01f, 1.74021810e-01f, 1.06764272e-01f, -3.05509299e-01f, 2.95912564e-01f, 1.03135832e-01f, 6.03893362e-02f, 2.08082721e-01f,
  3.39132883e-02f, 2.13754326e-01f, -1.54397562e-01f, 9.79752764e-02f, 1.33864984e-01f, -3.12892422e-02f, -5.74601591e-02f, -1.03130445e-01f, -2.28028130e-02f, 1.12107862e-02f,
  -3.91352102e-02f, -7.19995126e-02f, 5.71539393e-03f, -2.01289151e-02f, 1.63211264e-02f, 8.78174230e-03f, -5.20459525e-02f, -7.12634772e-02f, -2.43769009e-02f, -3.39123346e-02f,
  -4.56682853e-02f, 3.73896286e-02f, 2.90570688e-02f, -5.89035898e-02f, 2.11159848e-02f, 3.10194362e-02f, -3.18419263e-02f, 2.47065015e-02f, -4.02059332e-02f, -8.21346715e-02f,
  8.84174090e-03f, -1.92240700e-02f, 4.99445982e-02f, 2.14696229e-02f, -1.83356530e-03f, 2.15696394e-02f, -2.44556479e-02f, 2.15014978e-03f, 1.91613045e-02f, 1.00830294e-01f,
  6.74885064e-02f, 3.13110463e-02f, -1.40020829e-02f, -2.09128894e-02f, 5.70511073e-02f, -1.52955167e-02f, -1.61208324e-02f, 1.31866205e-02f, 2.64825784e-02f, 7.09114820e-02f,
  -2.19120495e-02f, 7.53544969e-03f, 2.24386412e-03f, -4.83205244e-02f, 1.77300069e-02f, -1.78449675e-02f, -8.35823715e-02f, 1.90859032e-03f, 7.52183720e-02f, 2.16041971e-02f,
  -2.30189282e-02f, 6.46690950e-02f, -4.37573045e-02f, -1.53187383e-02f, -1.96619015e-02f, -3.53934579e-02f, 2.97453925e-02f, -2.52260882e-02f, 1.21223563e-02f, -8.36590864e-03f,
  1.45441815e-01f, 2.21639305e-01f, 1.40721928e-02f, 1.72548764e-03f, -1.12897316e-02f, 2.83041690e-02f, 4.10416238e-02f, 4.68150377e-02f, 5.66362031e-02f, 2.96284687e-02f,
  1.03761911e-01f, -2.81533394e-02f, 4.16624397e-02f, -2.73757940e-03f, 1.78542826e-02f, 3.56133208e-02f, 1.39841316e-02f, 8.15154344e-04f, 1.26858622e-01f, 3.06332950e-02f,
  5.03963977e-02f, -3.81751135e-02f, 5.93029289e-03f, 5.68348505e-02f, 8.18012878e-02f, -1.38524380e-02f, 1.05894580e-01f, -1.58416796e-02f, 1.56379361e-02f, 4.36183475e-02f,
  2.27342889e-01f, -1.60351798e-01f, 9.11977887e-02f, 8.27002898e-02f, 2.60018229e-01f, 2.66597897e-01f, 3.44743371e-01f, 5.83916083e-02f, 1.81604713e-01f, -2.50993520e-01f,
  -8.00821111e-02f, -4.04734194e-01f, -1.90561730e-02f, -1.78636268e-01f, 2.26325199e-01f, 8.39904025e-02f, -7.01417550e-02f, -1.06507853e-01f, 1.69695362e-01f, -6.57161996e-02f,
  4.41926122e-02f, -3.09288688e-02f, 1.64603349e-02f, -1.94923356e-01f, -7.89197013e-02f, -7.01493621e-02f, -1.45324275e-01f, 7.64869228e-02f, -1.65258855e-01f, -2.75647342e-02f,
  1.92429181e-02f, 1.57376807e-02f, -2.84468215e-02f, -1.28905386e-01f, -8.64141360e-02f, -3.85889076e-02f, 4.01160360e-04f, 6.64305687e-02f, 1.38606444e-01f, -3.22959274e-02f,
  -9.81879011e-02f, -8.82179663e-02f, 3.58983912e-02f, 8.89845192e-03f, 1.25329643e-01f, -3.58412489e-02f, 3.57638597e-02f, 7.80946091e-02f, -3.30657959e-02f, 3.45007447e-03f,
  -8.48211069e-03f, -5.70357926e-02f, -2.54827179e-02f, -7.14858547e-02f, -1.18085956e-02f, 5.30573726e-02f, 1.02359034e-01f, -4.06441353e-02f, -7.67665058e-02f, 4.30793082e-03f,
  8.47385451e-02f, 7.99337327e-02f, 3.27937747e-03f, -8.20249133e-03f, -9.90715530e-03f, 6.65860027e-02f, -2.84881927e-02f, -2.36081984e-02f, -1.44629097e-02f, 2.95572635e-02f,
  -8.33390933e-03f, -1.13536958e-02f, -5.86000830e-03f, 1.03774652e-01f, -3.95726301e-02f, 1.49025209e-02f, 5.82984136e-03f, -2.44753007e-02f, -3.48908119e-02f, 1.91208441e-02f,
  1.11121768e-02f, 6.59632757e-02f, -1.10831864e-01f, -2.02253032e-02f, 5.73844044e-03f, 7.74449483e-02f, -7.75697976e-02f, 3.44907194e-02f, 9.67049003e-02f, 2.92788018e-02f,
  -1.06078517e-02f, -1.24837145e-01f, -1.45081198e-02f, -1.17725261e-01f, 4.87065278e-02f, -9.66449603e-02f, 6.26378227e-03f, -5.48817068e-02f, 1.22305557e-01f, 5.99411689e-02f,
  -1.58938263e-02f, 2.73822062e-03f, -5.71782365e-02f, 3.82526815e-02f, 1.72470249e-02f, 4.93651032e-02f, 4.09364589e-02f, -1.95219964e-02f, 5.44187576e-02f, -6.45022932e-03f,
  -6.39114976e-02f, -5.21562137e-02f, -3.00883744e-02f, -6.01055659e-03f, -1.06980436e-01f, 1.77035090e-02f, -2.03813836e-02f, -3.18161747e-03f, -3.13369557e-02f, 1.01617901e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.59591627e-01f, 3.05938989e-01f, 3.89475316e-01f, 2.83977926e-01f, -9.53995734e-02f, -3.72282803e-01f, -1.32933065e-01f, 6.81914985e-02f, -5.70137128e-02f, -1.73661429e-02f,
  -9.95656401e-02f, 1.94555998e-01f, -1.45293847e-01f, 3.25658262e-01f, -2.57178456e-01f, -1.75844029e-01f, 7.23587647e-02f, 3.91164459e-02f, -9.73083358e-03f, 2.00802013e-01f,
  -6.62070699e-03f, -4.01036888e-02f, 1.78032339e-01f, -5.46101332e-02f, 2.06214562e-01f, 1.39994666e-01f, -2.15318017e-02f, 2.92809065e-02f, 1.44887477e-01f, -3.17777023e-02f,
  -7.51427412e-02f, 1.31794333e-01f, 9.02179629e-02f, 4.53997143e-02f, 2.82112658e-02f, 1.07555417e-02f, 1.23896049e-02f, -7.77049512e-02f, -5.02306893e-02f, 4.85807657e-03f,
  1.12224013e-01f, -5.54207787e-02f, -9.54113677e-02f, -3.04173436e-02f, 7.68394396e-02f, -3.51273525e-03f, 1.33641556e-01f, 1.16646521e-01f, 1.29098549e-01f, 1.11114621e-01f,
  8.80806521e-02f, -1.41057428e-02f, 1.24408975e-01f, -3.86964232e-02f, -4.60911617e-02f, 2.52017868e-03f, 3.25938710e-03f, 1.67972550e-01f, 4.80584316e-02f, 1.44756529e-02f,
  2.12646667e-02f, -2.76067271e-03f, -3.50800976e-02f, 4.06412333e-02f, 4.95477021e-02f, -6.71131909e-02f, -6.23535132e-03f, -7.06210360e-02f, -2.29293257e-02f, -7.81091973e-02f,
  3.24450806e-02f, 3.06414515e-02f, 5.10964915e-02f, 2.35585775e-02f, -2.97677107e-02f, 1.87032390e-02f, -7.72961788e-03f, -5.46726435e-02f, 2.33311635e-02f, 2.29926910e-02f,
  -8.28898475e-02f, -5.73296398e-02f, 8.04624185e-02f, 1.58392042e-02f, -9.57554504e-02f, -8.10783878e-02f, 1.16425626e-01f, 1.27914762e-02f, 4.59977612e-02f, 1.98487416e-02f,
  -6.53517544e-02f, 1.80592328e-01f, 4.15209755e-02f, -3.07441913e-02f, -9.71077569e-03f, -1.18056141e-01f, -7.57880062e-02f, 1.28143445e-01f, -7.59597346e-02f, -7.73471221e-02f,
  2.62441374e-02f, -5.17274998e-02f, -8.63649473e-02f, -7.07879290e-02f, 2.82735880e-02f, -9.30810273e-02f, 5.06338216e-02f, -5.39038815e-02f, 1.43356606e-01f, 1.04752734e-01f,
  4.90351394e-02f, -1.12860300e-01f, 5.69451675e-02f, -4.64618839e-02f, -8.35620612e-02f, -5.27415276e-02f, -6.99782670e-02f, 2.20580492e-02f, 3.60934921e-02f, -1.87533908e-02f,
  -2.93548048e-01f, 7.13218749e-02f, -3.06382418e-01f, -1.78566203e-01f, -8.03965032e-02f, -2.11301655e-01f, 4.03658785e-02f, 5.18908128e-02f, -3.40339363e-01f, 3.33213866e-01f,
  2.29348049e-01f, -3.24275613e-01f, 1.16856664e-01f, -1.32638663e-01f, -6.55722558e-01f, -1.39884263e-01f, -3.39796215e-01f, 3.90511155e-02f, -1.72853962e-01f, 6.36824891e-02f,
  -1.88642502e-01f, 1.58329308e-01f, -2.01235294e-01f, 3.15284908e-01f, -2.58264318e-02f, 6.89950138e-02f, 1.70427948e-01f, 1.37066990e-01f, 6.84277415e-02f, -1.44323289e-01f,
  3.68726961e-02f, 7.86754936e-02f, -1.48450220e-02f, -9.69288573e-02f, -1.49564799e-02f, 5.28257079e-02f, 1.03914738e-02f, -3.28206792e-02f, -5.11968159e-04f, -5.60470857e-02f,
  -1.88529899e-03f, -2.51064869e-03f, -3.38747539e-02f, -7.83079788e-02f, -8.44141915e-02f, 1.68291647e-02f, -7.03020692e-02f, -1.95824519e-01f, 2.08249483e-02f, -1.59348711e-01f,
  -8.73942375e-02f, -1.20640084e-01f, -9.55118462e-02f, 1.04351630e-02f, -7.90641308e-02f, 4.96841688e-03f, 2.18478905e-04f, 6.81046695e-02f, -7.39524141e-02f, 5.77171780e-02f,
  6.38221577e-02f, -2.06482410e-02f, 3.26291993e-02f, 8.78056698e-03f, -3.72819789e-02f, 1.32946804e-01f, -2.43120193e-02f, 6.22707270e-02f, -6.45294115e-02f, 1.54347450e-01f,
  3.89123112e-02f, -2.82431636e-02f, 4.91256714e-02f, -1.28246555e-02f, -5.61666116e-03f, 6.72062933e-02f, 1.01650417e-01f, 1.00210700e-02f, -9.25664827e-02f, -8.17244314e-03f,
  6.45368546e-02f, -6.19887235e-03f, 2.78531271e-03f, 3.42634656e-02f, -2.88628247e-02f, -1.02471560e-01f, -1.85885355e-02f, 3.86616737e-02f, 5.89666814e-02f, 5.90631217e-02f,
  1.29571304e-01f, 1.92320779e-01f, -2.05833558e-02f, -4.42703888e-02f, 8.56884196e-02f, 1.32469013e-02f, -3.57562006e-02f, -1.13843083e-01f, 9.29061417e-03f, -7.57852197e-02f,
  2.86528356e-02f, -6.27484592e-03f, -5.09212762e-02f, -1.01825736e-01f, -6.28896058e-02f, -6.13391679e-03f, 2.58158892e-01f, 4.59837429e-02f, 5.01449686e-03f, -2.18853485e-02f,
  4.79560569e-02f, -1.26767177e-02f, 6.40590489e-02f, -3.15893516e-02f, -3.50796729e-02f, 7.41098747e-02f, -1.51255131e-02f, 1.31839430e-02f, -5.99843301e-02f, -8.24186653e-02f,
  -3.48387361e-01f, -1.64544731e-01f, 4.95780945e-01f, -2.60977149e-01f, 2.01234281e-01f, 3.13749403e-01f, 2.37229735e-01f, -6.88539520e-02f, -3.44327807e-01f, -3.78584683e-01f,
  -6.92879781e-02f, 5.74525595e-02f, 1.75618500e-01f, -1.17474027e-01f, 5.06319404e-01f, 1.37604609e-01f, -8.55123326e-02f, 4.76291962e-02f, 1.58767983e-01f, 2.34216247e-02f,
  -2.96388976e-02f, -1.24646120e-01f, 3.98006976e-01f, -1.48847669e-01f, 9.48290154e-02f, -1.93901822e-01f, -1.85005054e-01f, 2.44903773e-01f, -1.29078835e-01f, 3.97505872e-02f,
  5.38192950e-02f, -2.13771686e-01f, 9.90124866e-02f, 2.80335452e-02f, 8.18929356e-03f, 8.03775713e-02f, 3.39866094e-02f, 1.72972113e-01f, -1.32661685e-02f, 7.11717457e-02f,
  6.22732863e-02f, 6.34920076e-02f, -6.11422658e-02f, -3.94650660e-02f, -5.75063191e-02f, -2.12363582e-02f, 9.12072510e-02f, -3.48799350e-03f, -5.99150360e-03f, 1.80316821e-01f,
  1.51493415e-01f, -6.12468878e-03f, -1.45036867e-02f, -1.09289713e-01f, 8.43420252e-02f, -1.21110804e-01f, -8.28797556e-03f, 1.14050835e-01f, 2.38744300e-02f, -1.77668482e-01f,
  1.17665520e-02f, 1.20092414e-01f, 3.32249366e-02f, -6.74626231e-02f, -1.96736399e-03f, -1.13566913e-01f, -2.43340135e-02f, 3.93852852e-02f, 1.06620109e-02f, 2.12913882e-02f,
  -9.87740681e-02f, 3.33064944e-02f, 2.00263318e-02f, 9.19620972e-03f, 8.88515729e-03f, -9.21036378e-02f, -6.32479265e-02f, -2.23930385e-02f, 1.07424678e-02f, 1.49149699e-02f,
  -1.17729701e-01f, -6.44690618e-02f, 2.50667650e-02f, 7.20803440e-02f, -5.82475737e-02f, 4.38341610e-02f, -1.08942345e-01f, -7.03560039e-02f, 6.23104833e-02f, 9.93379802e-02f,
  -2.22494304e-02f, -2.50301272e-01f, -4.54681292e-02f, -8.09299722e-02f, 4.75864895e-02f, -1.49790477e-02f, 1.22006536e-02f, -3.92032191e-02f, -7.66595155e-02f, 2.74686646e-02f,
  -8.79410747e-03f, -2.70956289e-03f, -4.72764932e-02f, 2.21079681e-02f, -1.45833075e-01f, -1.09211750e-01f, -2.55173109e-02f, -6.27660900e-02f, -5.13180234e-02f, -3.80742587e-02f,
  5.98638393e-02f, -4.29608896e-02f, -2.98014600e-02f, -3.98964547e-02f, -1.24535985e-01f, -8.77369791e-02f, 6.72400370e-02f, -8.07019696e-02f, 3.44641209e-02f, 2.06905007e-02f,
  4.22492951e-01f, 9.72130075e-02f, 3.38767357e-02f, 3.04660290e-01f, -2.74042875e-01f, -2.55162239e-01f, -2.25978449e-01f, 7.60254711e-02f, -1.63164705e-01f, -5.22392243e-02f,
  8.27760994e-02f, -1.45464242e-01f, 2.06498131e-01f, 1.96477056e-01f, 2.66318083e-01f, 5.98298088e-02f, 9.14096609e-02f, -2.50328649e-02f, 5.61122000e-02f, 2.62836874e-01f,
  1.72978804e-01f, 1.52851760e-01f, 2.81317472e-01f, 1.99070960e-01f, 1.41319722e-01f, 1.16578326e-01f, 1.74515188e-01f, 1.15869887e-01f, 1.27441570e-01f, -2.09245589e-02f,
  -4.64762412e-02f, 2.43179202e-02f, 2.53001545e-02f, -2.30860971e-02f, -1.47515414e-02f, 1.15348615e-01f, -8.25869441e-02f, -4.04222198e-02f, -2.79996602e-04f, -2.32539121e-02f,
  -5.66770248e-02f, 1.35976627e-01f, -1.94327943e-02f, -2.55838633e-02f, -6.99125379e-02f, -8.66128504e-02f, -2.88773477e-02f, -6.53154328e-02f, -1.41229078e-01f, 1.18572272e-01f,
  3.75012793e-02f, -1.27061307e-02f, -2.23454032e-02f, 9.49448422e-02f, 1.09775113e-02f, 7.17077404e-02f, -1.25280088e-02f, -7.76482746e-02f, -7.92338103e-02f, 2.65516993e-02f,
  5.99537008e-02f, 5.20406924e-02f, 7.60008469e-02f, 3.03127337e-03f, 3.41027156e-02f, 4.60776240e-02f, -6.95340410e-02f, 1.98392123e-02f, -3.37342471e-02f, 1.02756694e-01f,
  -3.36241163e-02f, -3.71844843e-02f, 3.96616088e-04f, 1.45564806e-02f, 5.63838705e-02f, -2.37547588e-02f, -5.46452701e-02f, 4.85733896e-02f, -7.88805485e-02f, -7.60796368e-02f,
  2.70150825e-02f, 1.23288125e-01f, -5.10737896e-02f, -1.37497894e-02f, 8.72773156e-02f, 3.14777233e-02f, -3.45136132e-03f, 5.11417240e-02f, -1.14656597e-01f, -1.16183944e-02f,
  5.57901897e-02f, 1.76342368e-01f, -4.99790199e-02f, -1.07357383e-01f, 9.25029721e-03f, -5.62435198e-05f, -1.20031536e-02f, 2.26588082e-02f, 2.14585468e-01f, -8.63161311e-03f,
  -1.34139089e-02f, -4.78268899e-02f, 1.11628987e-03f, 5.12159616e-02f, -6.18980005e-02f, 3.49236503e-02f, 3.57319266e-02f, 8.44368041e-02f, -4.02030535e-02f, 4.30639535e-02f,
  3.91952647e-03f, -6.47674408e-03f, -3.53510454e-02f, -2.19640315e-01f, 1.02403589e-01f, -1.51358053e-01f, -1.46267816e-01f, -1.33055681e-02f, 7.67532177e-03f, 3.02209705e-02f,
  2.23226085e-01f, -2.44027928e-01f, -6.03079759e-02f, -4.25887667e-03f, -3.49611118e-02f, 1.46664213e-02f, 1.64574891e-01f, -4.34175789e-01f, -3.86096120e-01f, -3.11907917e-01f,
  -2.71059535e-02f, 1.28335908e-01f, -5.58599159e-02f, -9.75002423e-02f, 4.18040186e-01f, 1.09864073e-02f, -1.18222110e-01f, 6.12809509e-03f, -7.19414279e-02f, -9.19177830e-02f,
  -6.66226372e-02f, 2.46126782e-02f, 1.01458237e-01f, -1.02642491e-01f, 1.17518529e-01f, -1.22418981e-02f, 9.05059949e-02f, 4.15922292e-02f, -1.33006333e-03f, 2.56539851e-01f,
  1.13492087e-01f, 2.33810581e-02f, -2.81307213e-02f, 5.84971067e-03f, 4.51567993e-02f, -5.09422384e-02f, 5.89923225e-02f, 1.74811393e-01f, -6.54765889e-02f, -8.47157538e-02f,
  -8.29220866e-04f, -1.14821922e-02f, -4.95224670e-02f, 3.74505334e-02f, -2.39335354e-02f, -1.30753502e-01f, -4.38244492e-02f, -1.75225344e-02f, -1.36960521e-01f, -1.08814212e-02f,
  -9.92270932e-02f, -8.50075670e-03f, 3.08331884e-02f, 6.19844943e-02f, -2.87499893e-02f, 8.39491375e-03f, 1.29417837e-01f, 1.50998861e-01f, -4.60703373e-02f, -9.31531712e-02f,
  -7.95002729e-02f, 7.59863779e-02f, -9.70308632e-02f, -2.21402291e-02f, 7.09307268e-02f, 4.94020432e-02f, 1.84020232e-02f, 4.35232483e-02f, -6.78863078e-02f, 4.30690171e-03f,
  4.49532047e-02f, -1.11917391e-01f, -8.28075707e-02f, -1.15988225e-01f, -2.76666805e-02f, -2.25649904e-02f, 1.10292556e-02f, -1.63570791e-02f, -5.26906848e-02f, -4.73064780e-02f,
  4.76670861e-02f, 1.52140260e-02f, 8.32684487e-02f, -9.10943840e-03f, -4.48544174e-02f, -2.57683937e-02f, -2.05216953e-03f, 1.53361624e-02f, 2.20924765e-02f, -2.25639679e-02f,
  5.01036495e-02f, 2.05470081e-02f, 1.26630617e-02f, -2.09247544e-02f, -1.19051794e-02f, -1.61656410e-01f, 2.91649289e-02f, -2.15130731e-01f, 1.31792761e-02f, 4.44064662e-02f,
  -1.19695805e-01f, 2.16504326e-03f, 4.36596908e-02f, -9.76713225e-02f, 8.75197500e-02f, -7.10176528e-02f, 5.23151644e-02f, 9.01938453e-02f, -2.89353430e-02f, 2.31041797e-02f,
  -3.31669673e-02f, 1.69637427e-02f, 1.36986086e-02f, -5.72167300e-02f, -1.77119598e-02f, 1.26405388e-01f, -7.83693641e-02f, 7.25617036e-02f, 7.35168457e-02f, 9.01106186e-03f,
  -2.35777780e-01f, 2.61150420e-01f, -2.41852865e-01f, -4.36555147e-01f, 5.04275523e-02f, -3.53984028e-01f, -3.58180135e-01f, -5.46772070e-02f, 2.34658252e-02f, -1.28463721e-02f,
  -2.06527933e-01f, 1.07435942e-01f, 1.53181061e-01f, -1.46011189e-01f, 2.03896649e-02f, 2.59491205e-01f, -3.71767819e-01f, -3.30496252e-01f, 1.55945063e-01f, -2.45598093e-01f,
  -2.59977933e-02f, -6.05564527e-02f, -8.03157166e-02f, 2.08151832e-01f, -2.82641083e-01f, -4.89771217e-02f, -9.65013579e-02f, 4.87081632e-02f, -2.36350864e-01f, 1.40750661e-01f,
  -2.13177606e-01f, -2.64641106e-01f, -5.03330259e-03f, -1.05215780e-01f, -2.59071261e-01f, -5.48051409e-02f, -1.46194160e-01f, 7.97447860e-02f, -4.26402055e-02f, 1.96980499e-02f,
  1.07901944e-02f, 2.72576418e-02f, -1.76010877e-02f, 1.29552856e-01f, -8.22483599e-02f, -1.36566687e-05f, 3.96775790e-02f, -1.24426797e-01f, -1.50134331e-02f, 3.17930244e-02f,
  8.10291097e-02f, -9.29715931e-02f, -1.49062634e-01f, -8.28885734e-02f, 6.05387315e-02f, -4.40541767e-02f, -7.35943243e-02f, 3.12441541e-03f, -8.52142051e-02f, -5.02644069e-02f,
  6.89901412e-02f, -7.97327049e-03f, -6.00798894e-03f, -4.80122901e-02f, -9.44391266e-03f, 1.50701692e-02f, 1.34680886e-03f, -5.10110110e-02f, 8.42723809e-03f, -4.32582758e-02f,
  1.43346367e-02f, -9.67413858e-02f, 4.79885284e-03f, -1.30514607e-01f, -4.99039143e-02f, -1.67950261e-02f, -7.69888908e-02f, -1.79245714e-02f, 7.70731345e-02f, 5.89088127e-02f,
  4.98239510e-02f, -5.18484265e-02f, 5.40966988e-02f, -1.27161711e-01f, -7.38224611e-02f, 3.17043811e-02f, 1.34015948e-01f, -1.43084517e-02f, 6.16053566e-02f, 7.45233819e-02f,
  -3.92431259e-01f, -4.48592335e-01f, 2.47353185e-02f, 3.27639207e-02f, -3.75611410e-02f, 1.36028640e-02f, -4.99549918e-02f, 9.50650722e-02f, 6.13075495e-03f, 2.76214583e-03f,
  -1.16410725e-01f, -6.35961965e-02f, -6.52492866e-02f, -6.45766454e-03f, 1.06704667e-01f, -2.21757647e-02f, -1.13421008e-01f, -4.01586927e-02f, -7.86413848e-02f, 3.58264730e-03f,
  -5.48172109e-02f, -2.08434816e-02f, -3.34548987e-02f, 3.07094622e-02f, -7.85839036e-02f, -8.47337469e-02f, -2.04813350e-02f, 9.64518078e-03f, -7.92344883e-02f, 4.23301198e-02f,
  -4.24259156e-01f, 1.80979550e-01f, -8.72317329e-02f, 1.71230122e-01f, -3.28051358e-01f, 3.98644865e-01f, 3.68627340e-01f, -4.20800671e-02f, 3.97196412e-01f, 3.26936305e-01f,
  4.74878550e-02f, 5.57686128e-02f, 1.28425628e-01f, 3.32442880e-01f, 7.54807964e-02f, 3.38335842e-01f, 3.89958531e-01f, 1.71070069e-01f, -5.32706734e-04f, 8.45731348e-02f,
  2.45961137e-02f, 7.06108287e-02f, -7.72250742e-02f, -2.91025311e-01f, -1.62447914e-01f, -2.27309033e-01f, -1.38068020e-01f, -2.26043746e-01f, -6.39552101e-02f, -8.11202750e-02f,
  -6.92935288e-02f, -1.16755523e-01f, -1.17893837e-01f, 6.13951236e-02f, 3.56964655e-02f, -3.30338143e-02f, -1.10129207e-01f, -1.02844626e-01f, -5.46686305e-03f, -1.71023048e-02f,
  1.68215111e-02f, -6.81463555e-02f, 1.03230000e-01f, 4.09217551e-02f, -8.92213825e-03f, -5.69826812e-02f, 2.91673969e-02f, 1.93241816e-02f, 1.30340084e-02f, -7.10245296e-02f,
  6.89315274e-02f, 2.07067970e-02f, 2.98474059e-02f, 1.94101837e-02f, -3.25936824e-02f, -4.93684672e-02f, 1.14857018e-01f, -3.74845117e-02f, 1.34874145e-02f, 6.06706105e-02f,
  5.90184927e-02f, -2.94752792e-02f, -8.95555888e-04f, -3.99184823e-02f, 2.08277907e-02f, -8.32152888e-02f, 3.35550345e-02f, 5.35130762e-02f, -1.77836493e-02f, 4.05599885e-02f,
  5.10198250e-02f, -4.18884493e-03f, 5.78402951e-02f, 1.82785373e-02f, 3.39802690e-02f, -2.10847948e-02f, 1.39719592e-02f, -1.54440487e-02f, 6.31281659e-02f, -2.89061852e-02f,
  3.36178243e-02f, 4.15225737e-02f, -1.70616750e-02f, -5.35281710e-02f, -4.68200408e-02f, -6.65294826e-02f, -2.36767456e-02f, -1.85455699e-02f, 5.01375757e-02f, -4.76034880e-02f,
  1.43982291e-01f, 1.81262225e-01f, 2.08363589e-02f, -2.17087772e-02f, -6.80871531e-02f, -7.13959411e-02f, -1.76837947e-02f, -1.09909000e-02f, 3.42273489e-02f, -6.67187497e-02f,
  -5.10803610e-02f, 8.60457793e-02f, -6.01759069e-02f, -9.16346014e-02f, -1.06341571e-01f, 6.86122999e-02f, -7.91453570e-03f, -4.13645282e-02f, 1.02952249e-01f, -1.22100217e-02f,
  -4.62255180e-02f, -4.27205190e-02f, 4.62522134e-02f, -6.39322624e-02f, 5.65939676e-03f, 2.42891740e-02f, -5.43598458e-02f, -4.28371355e-02f, -9.45654884e-02f, 7.76734501e-02f,
  -7.48784900e-01f, 3.43181998e-01f, 7.18062893e-02f, 9.24072340e-02f, -5.49351759e-02f, 3.23425710e-01f, 1.49291605e-01f, 1.39182836e-01f, 1.78405851e-01f, 2.43918970e-01f,
  9.52198878e-02f, -1.22000739e-01f, 5.16773835e-02f, 2.22489178e-01f, -4.71871841e-04f, 2.90728748e-01f, 3.59326899e-01f, 6.60684481e-02f, -1.30936969e-02f, -1.52788207e-01f,
  -7.17175975e-02f, 4.46256958e-02f, 1.13881230e-01f, -1.07361138e-01f, -2.22129934e-02f, -1.34322181e-01f, -6.55664653e-02f, -1.46709993e-01f, 5.50442971e-02f, 5.09294905e-02f,
  -1.24143623e-01f, -2.60929614e-01f, -7.63147976e-03f, -1.04238398e-01f, -3.55979875e-02f, -8.33193511e-02f, -8.87133274e-03f, -1.00362606e-01f, -5.02593108e-02f, 1.96235925e-02f,
  -2.85349675e-02f, -9.65416953e-02f, 6.20529316e-02f, 2.73107290e-02f, 1.34298299e-02f, 4.15461548e-02f, 4.47313599e-02f, 8.06245655e-02f, -3.98838185e-02f, 1.78864505e-02f,
  3.14706229e-02f, 3.49293090e-02f, 2.73919888e-02f, 1.53427154e-01f, 3.06423716e-02f, 9.74035338e-02f, 5.43503091e-02f, 4.34535332e-02f, 1.06221713e-01f, 5.86247556e-02f,
  2.39831060e-02f, -1.20997563e-01f, 7.85227790e-02f, 2.66518611e-02f, 7.68677145e-03f, -1.91467572e-02f, -2.21038019e-04f, -1.06365547e-01f, -6.17289320e-02f, 3.75735275e-02f,
  6.91287965e-02f, 9.88857355e-03f, -4.27711718e-02f, 1.16609029e-01f, -6.33866712e-02f, 5.64735457e-02f, -7.46134892e-02f, -2.75821425e-02f, 5.03998436e-02f, 4.10668515e-02f,
  -9.01925750e-03f, -1.36834627e-04f, 7.82630146e-02f, 8.46087858e-02f, 9.78416484e-03f, 1.26157664e-02f, 5.49078621e-02f, 6.90665022e-02f, 7.57060945e-03f, 6.68964088e-02f,
  2.86852092e-01f, 3.16459825e-03f, -1.24496249e-02f, 2.01174486e-02f, 4.71412651e-02f, 5.13663441e-02f, 8.55457559e-02f, 4.22448143e-02f, 6.31712750e-02f, -6.20955676e-02f,
  -5.35197146e-02f, -3.46574634e-02f, -6.65471628e-02f, 1.12889037e-02f, 1.78658068e-02f, 1.75773785e-01f, -9.51199159e-02f, -1.26970531e-02f, 3.88781242e-02f, -3.67994346e-02f,
  -1.34361368e-02f, -1.10621788e-01f, -1.07847728e-01f, -8.51363223e-03f, 1.03842793e-02f, -1.59951821e-02f, 2.05161572e-02f, -7.99593404e-02f, 2.87580695e-02f, -4.42334125e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.37695476e-01f, 2.63766617e-01f, 4.97896075e-02f, -2.30227441e-01f, 2.60570467e-01f, 1.75028041e-01f, 1.47519439e-01f, 1.88582718e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.95169005e-02f, 2.36775607e-01f, -9.91494656e-02f, -1.12224631e-01f, -1.58751503e-01f, 1.28786042e-01f, -6.35052146e-03f, 9.61974710e-02f, 1.58908337e-01f, -1.43418401e-01f,
  -2.38350108e-01f, -1.93655431e-01f, -2.20385745e-01f, 7.15220124e-02f, 2.05737635e-01f, -2.40336210e-01f, -3.21787000e-01f, -1.88434333e-01f, 3.87893647e-01f, 1.47984415e-01f,
  -2.27825325e-02f, 2.16719881e-02f, 5.20525336e-01f, -2.57264555e-01f, 2.39451304e-01f, -3.56107429e-02f, -4.04280126e-01f, 1.31492899e-03f, -2.41756395e-01f, 1.51893213e-01f,
  -2.95201670e-02f, -7.49706924e-02f, 6.58370629e-02f, 3.39443415e-01f, 8.62447023e-02f, 2.61824150e-02f, -4.48349863e-02f, 6.14203773e-02f, -9.00685489e-02f, 9.69200432e-02f,
  6.84287101e-02f, 5.34660071e-02f, -1.21379428e-01f, -2.56820410e-01f, 9.49791372e-02f, -1.52505161e-02f, 3.68692517e-01f, -2.48744115e-01f, -2.00384513e-01f, -3.23927671e-01f,
  2.80759245e-01f, 1.22591808e-01f, 2.79513866e-01f, 1.87740937e-01f, 4.96802777e-01f, 1.40815258e-01f, 1.43475071e-01f, -5.96455000e-02f, -3.35976213e-01f, -1.96520183e-02f,
  -2.93201685e-01f, 8.22709426e-02f, -2.47892328e-02f, -1.48928344e-01f, 2.67673194e-01f, 3.25411052e-01f, 8.67437348e-02f, -2.23153502e-01f, -1.98988561e-02f, -1.89754799e-01f,
  1.33968845e-01f, 8.78798962e-02f, -2.07533300e-01f, -1.41576216e-01f, 2.39334017e-01f, 6.24326654e-02f, 1.54715717e-01f, -1.10286742e-01f, -4.03976161e-03f, -8.46409425e-02f,
  -1.12233416e-03f, -4.90050577e-02f, 5.80248050e-02f, 2.28531793e-01f, 2.68699020e-01f, 6.49680123e-02f, 2.78350025e-01f, 1.03159636e-01f, -5.76994792e-02f, -1.68178365e-01f,
  1.88599646e-01f, -2.85745054e-01f, -1.35502042e-02f, -1.62850335e-01f, 1.88814923e-02f, -3.14121455e-01f, 1.67227969e-01f, 1.34866670e-01f, 2.33992696e-01f, 2.59631276e-01f,
  2.15800509e-01f, -3.41980010e-01f, 2.30584383e-01f, 2.08548039e-01f, -2.89951861e-01f, -2.19849739e-02f, 2.47565076e-01f, -1.76673889e-01f, 2.61170685e-01f, -1.94716305e-01f,
  -2.12390602e-01f, 2.62089014e-01f, 7.39720985e-02f, 3.05811688e-02f, -1.79138817e-02f, 2.80732214e-01f, 3.08548927e-01f, 9.34069082e-02f, 2.17681080e-01f, 4.02578294e-01f,
  -3.33064973e-01f, -7.46119618e-02f, 2.93294609e-01f, -1.04020275e-01f, 1.91059291e-01f, -1.50668934e-01f, -8.18192363e-02f, -1.50207490e-01f, -2.16843754e-01f, 2.14462906e-01f,
  -1.16121635e-01f, 8.59153718e-02f, 1.39018878e-01f, -2.55119711e-01f, 2.21913159e-01f, -1.69609964e-01f, -1.68797791e-01f, -5.26721217e-03f, -2.28102058e-01f, -2.03522429e-01f,
  -7.19911559e-03f, 2.39084989e-01f, 1.35557055e-01f, 3.78770120e-02f, -2.39194527e-01f, 1.86575741e-01f, -1.63480733e-03f, 6.22554243e-01f, 4.01462823e-01f, -1.25071764e-01f,
  1.81800529e-01f, 2.97713310e-01f, -2.95519233e-01f, -1.98610589e-01f, -6.44268328e-03f, -2.65649647e-01f, 2.71897107e-01f, -2.25540735e-02f, 1.24165811e-01f, -3.83831769e-01f,
  1.91938028e-01f, -4.42322284e-01f, -6.57860562e-02f, -1.76835895e-01f, 1.87712144e-02f, 8.82340595e-02f, -8.39063004e-02f, 2.48640507e-01f, -1.08345911e-01f, -6.85991794e-02f,
  1.77380159e-01f, 7.89086819e-02f, 2.03635171e-01f, 3.30500789e-02f, -1.78255215e-02f, -6.18636645e-02f, 2.87483811e-01f, 5.92837259e-02f, -1.57881841e-01f, -5.02445936e-01f,
  -2.19272316e-01f, -9.30228680e-02f, 4.37380075e-02f, -1.91302374e-01f, 1.11986339e-01f, 2.94924732e-02f, -5.02624922e-02f, 3.55882466e-01f, -1.23815924e-01f, -3.15242887e-01f,
  2.96559632e-01f, 2.74833947e-01f, 6.63477629e-02f, 4.92341727e-01f, -1.06905036e-01f, -1.37731999e-01f, -1.16552576e-01f, 3.74493718e-01f, -2.58205831e-01f, -1.42143086e-01f,
  1.56764761e-01f, -6.64771022e-03f, 4.08661887e-02f, -1.38134286e-01f, -1.23664528e-01f, 1.63727775e-01f, 3.26182604e-01f, -2.66883165e-01f, -6.43774942e-02f, -8.03421512e-02f,
  3.19785416e-01f, 2.49353275e-01f, 6.12123273e-02f, 4.09958810e-01f, -3.22011225e-02f, 1.48127973e-01f, 1.55321300e-01f, -4.44929302e-02f, 3.07121396e-01f, -3.11091971e-02f,
  9.42616165e-02f, 4.55023646e-01f, -4.60702181e-01f, -2.46520892e-01f, 4.29622121e-02f, -3.54547799e-01f, -4.18468453e-02f, 4.71635424e-02f, -1.73286214e-01f, 1.25871703e-01f,
  -8.31873938e-02f, 5.08108176e-02f, -2.99828589e-01f, 1.32875547e-01f, 8.42517018e-02f, 5.93792610e-02f, 2.36027256e-01f, -3.28719825e-01f, -2.12408394e-01f, 1.87378287e-01f,
  3.45160544e-01f, 1.38635963e-01f, -3.13955337e-01f, -5.20308137e-01f, -2.52440065e-01f, -5.58765605e-03f, -3.73413771e-01f, -1.76092789e-01f, -3.84910196e-01f, 2.21540123e-01f,
  1.60987988e-01f, -1.58718765e-01f, -2.42245153e-01f, -5.09157367e-02f, -1.72663644e-01f, 1.71688855e-01f, -1.98550865e-01f, -2.40073338e-01f, -5.01447506e-02f, -1.28857464e-01f,
  -5.80299459e-02f, -3.79949994e-02f, 1.65714353e-01f, -1.48472041e-01f, -7.11373463e-02f, -1.67278573e-02f, -1.18937112e-01f, 1.53640509e-01f, -7.02076256e-02f, 2.76482195e-01f,
  -3.11229348e-01f, -2.23127427e-03f, 3.58108550e-01f, 7.29764104e-02f, -3.94776195e-01f, -1.99056774e-01f, -9.45859179e-02f, -3.91974926e-01f, 6.95503354e-02f, -3.51739705e-01f,
  -9.49190184e-02f, 2.11533844e-01f, -3.42440128e-01f, 4.19709146e-01f, 1.65104374e-01f, -3.46044600e-01f, 1.29794389e-01f, 1.87689796e-01f, -2.86249548e-01f, 3.66944000e-02f,
  -1.84162036e-01f, -2.28102893e-01f, -7.48850629e-02f, 7.91061744e-02f, -8.75313133e-02f, 9.62672010e-02f, 2.30691563e-02f, -2.32592314e-01f, -2.94969659e-02f, 3.80687237e-01f,
  -3.81779075e-02f, 2.10294157e-01f, -1.25939310e-01f, -2.11585119e-01f, 7.88852572e-02f, -1.72770604e-01f, -1.47271410e-01f, -1.77377000e-01f, 1.72704235e-01f, -1.91200316e-01f,
  1.86713964e-01f, -1.93374351e-01f, 2.33806923e-01f, -1.54530764e-01f, -2.07578495e-01f, 2.17173949e-01f, -2.42627636e-02f, -1.59342706e-01f, -1.78290978e-01f, 4.33445163e-02f,
  5.88231757e-02f, 1.72040284e-01f, 1.91200227e-01f, -1.97958559e-01f, -3.64392698e-02f, 6.19461574e-02f, 5.08181304e-02f, -5.32604642e-02f, -9.74278599e-02f, -1.41352117e-01f,
  2.06632093e-01f, 1.16638923e-02f, 2.03295633e-01f, 9.58629400e-02f, 2.83747971e-01f, -1.75693184e-01f, -2.93537974e-01f, -3.64142060e-01f, 1.61691662e-02f, -1.17941312e-01f,
  4.62157309e-01f, -4.24541496e-02f, 2.46852204e-01f, 1.47602260e-01f, 2.50169337e-01f, -3.28954697e-01f, 9.72801745e-02f, 3.94335151e-01f, 2.29890198e-01f, -2.75526196e-01f,
  -7.01415539e-02f, 4.36676592e-02f, 2.97924150e-02f, -8.56265575e-02f, -5.00772595e-02f, -8.31120834e-02f, -8.76231957e-03f, -1.38096929e-01f, 3.18600625e-01f, 3.97092432e-01f,
  1.67278811e-01f, -5.32700002e-01f, 5.57004735e-02f, 3.09161395e-01f, 2.33418867e-01f, -2.84314245e-01f, -1.59971192e-02f, -1.46641433e-01f, 2.39051104e-01f, -3.69942710e-02f,
  -2.36254096e-01f, -2.09838495e-01f, 2.67849714e-01f, -4.38074678e-01f, 4.11015064e-01f, -1.36238649e-01f, -1.55901983e-02f, -5.53298146e-02f, -2.20835134e-01f, 2.88917065e-01f,
  -1.99589163e-01f, -2.25945264e-01f, -9.85372141e-02f, 9.41875428e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.35067344e-01f, 3.85392934e-01f, 2.47764736e-01f, 2.46701300e-01f, 2.02954561e-01f, 4.23799545e-01f, 7.82289207e-02f, 3.78462151e-02f, 3.17338258e-01f, 3.64286333e-01f,
  2.30091065e-01f, 3.12652528e-01f, -5.59600711e-01f, -4.26330447e-01f, 1.17661804e-01f, -4.10803407e-01f, 4.31822300e-01f, 2.23784879e-01f, 9.05406699e-02f, -1.90198511e-01f,
  -6.35132372e-01f, 1.53633311e-01f, -5.48663557e-01f, -4.15231228e-01f, 6.75026253e-02f, 5.67563355e-01f, 2.85898507e-01f, -2.69588195e-02f, 1.09848723e-01f, 6.83543861e-01f,
  -2.16260582e-01f, 2.13322788e-01f, 4.36823875e-01f, 2.13146791e-01f, 2.30077073e-01f, 7.59690166e-01f, 3.10231537e-01f, 2.53952704e-02f, 1.47410277e-02f, 4.84622605e-02f,
  3.40866685e-01f, 5.89435637e-01f, -4.32612412e-02f, -1.86901584e-01f, -4.60504711e-01f, -1.80727154e-01f, 4.34270263e-01f, 3.22757542e-01f, -3.14370573e-01f, 5.80792904e-01f,
  4.91852790e-01f, 3.17314059e-01f, -1.02767594e-01f, 5.67545712e-01f, -4.15776789e-01f, 4.11469877e-01f, -6.25512227e-02f, 7.53152892e-02f, 5.34557641e-01f, -2.11569697e-01f,
  1.62665591e-01f, 7.41074562e-01f, 4.35612798e-01f, 2.11079627e-01f, 1.65410638e-01f, 2.61177689e-01f, 3.28699857e-01f, -8.57247785e-02f, 3.63477051e-01f, -2.30602324e-02f,
  3.67125988e-01f, 1.87819809e-01f, 2.36678749e-01f, -3.91165167e-01f, -5.30082621e-02f, 2.48786151e-01f, 5.31758964e-01f, 2.65510350e-01f, -1.73599318e-01f, -9.01604723e-03f,
  9.93605182e-02f, -4.40366149e-01f, -5.13422072e-01f, -4.19788927e-01f, 5.64301550e-01f, -6.36063457e-01f, 6.71066821e-01f, -4.38749135e-01f, 2.48233005e-01f, 2.44560793e-01f,
  -2.95134366e-01f, 4.19535816e-01f, 2.15234309e-01f, -2.30772138e-01f, 3.76714855e-01f, 2.15716317e-01f, 3.31280172e-01f, 4.14105088e-01f, 1.72564745e-01f, 2.56791830e-01f,
  4.70255345e-01f, 1.01773031e-01f, 3.72492015e-01f, 3.83031458e-01f, -8.47466812e-02f, -8.28013271e-02f, 4.94227767e-01f, 2.98160017e-01f, 3.11086565e-01f, -7.96451569e-01f,
  -3.59263271e-01f, 4.46069866e-01f, 1.47899324e-02f, 1.26613051e-01f, 8.77466127e-02f, 4.71047238e-02f, 1.15563288e-01f, 2.63202310e-01f, 1.77027717e-01f, 3.14421207e-01f,
  -3.39641608e-02f, 2.56876856e-01f, 6.64470494e-01f, -1.75852329e-01f, 1.11213669e-01f, -1.04591087e-01f, 2.19139025e-01f, 1.02342747e-01f, 1.67466551e-01f, -1.64633691e-01f,
  2.25376904e-01f, 5.41781127e-01f, 3.44789386e-01f, 4.21352498e-02f, -3.18073928e-02f, 3.41196656e-01f, 1.87182099e-01f, 3.04844946e-01f, 2.76868492e-01f, 3.51732001e-02f,
  6.09514117e-02f, 9.91282240e-02f, 5.82755096e-02f, 4.49461251e-01f, 2.90698260e-01f, 5.62039316e-01f, -1.43945813e-01f, -4.81721431e-01f, -1.36632696e-01f, 1.61270812e-01f,
  -2.08381444e-01f, -3.09712440e-03f, -1.06556416e-01f, -3.38060111e-01f, 1.62524760e-01f, -9.40271765e-02f, -2.14504912e-01f, -4.07557636e-02f, 5.79300225e-01f, 6.47228479e-01f,
  3.52069467e-01f, 2.11323708e-01f, 3.08022976e-01f, -1.40883520e-01f, -2.02694371e-01f, 5.96719027e-01f, 7.98253193e-02f, 1.85008824e-01f, 9.89635363e-02f, 7.10111484e-02f,
  4.54529762e-01f, 2.07998127e-01f, -4.44137961e-01f, -5.39027631e-01f, -2.05475971e-01f, -4.92843658e-01f, 3.62023681e-01f, -8.26509371e-02f, 1.58974290e-01f, -4.45459038e-01f,
  -6.41808093e-01f, 2.32549027e-01f, -2.60642827e-01f, -3.16925853e-01f, 4.88419473e-01f, 4.65391189e-01f, 2.53422558e-01f, -1.44920021e-01f, -4.01041925e-01f, 3.98105502e-01f,
  -5.39835572e-01f, -3.24877724e-02f, 3.02333176e-01f, -3.78973812e-01f, 2.07986996e-01f, 5.14096320e-01f, 8.41672793e-02f, -4.51768711e-02f, 1.29093841e-01f, 1.92038715e-01f,
  2.60187715e-01f, 4.88524705e-01f, 1.06782101e-01f, 2.53190435e-02f, 3.03874850e-01f, 2.95368642e-01f, -9.19755921e-02f, 3.74530762e-01f, 1.04198948e-01f, 4.62056547e-01f,
  -2.93635368e-01f, -3.07624459e-01f, -4.59639505e-02f, -8.05784762e-02f, -5.08916676e-01f, 8.66784062e-03f, -4.24785614e-02f, -5.19002154e-02f, 2.61464715e-01f, 9.47124362e-02f,
  5.70241250e-02f, -1.43434674e-01f, 3.76788676e-01f, 6.69859588e-01f, 4.92802024e-01f, 6.42119169e-01f, 1.63104042e-01f, 1.94150686e-01f, 1.38204440e-01f, 2.99324691e-01f,
  1.05140880e-01f, 2.50851989e-01f, 1.54097170e-01f, 1.38889691e-02f, 2.96085984e-01f, -5.91883473e-02f, -1.09203562e-01f, 3.06075476e-02f, 5.98544896e-01f, 7.90253207e-02f,
  -5.11510372e-01f, -3.72798830e-01f, 3.80714118e-01f, 4.13140863e-01f, 1.46384880e-01f, 5.92682421e-01f, 7.57804811e-01f, 3.11641723e-01f, 5.56876004e-01f, -3.83030444e-01f,
  2.16015130e-01f, 2.63572633e-01f, 3.63741741e-02f, 8.44655186e-02f, 3.61505568e-01f, -3.31837777e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.16324791e-01f, 2.17642486e-01f, 4.21849012e-01f, 3.12868536e-01f, -1.46053517e-02f, 3.80523093e-02f, 2.84496918e-02f, 3.41791451e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  3.45763639e-02f, -4.32374701e-02f, 1.55665264e-01f, 6.33895323e-02f, -2.00428188e-01f, 1.88236475e-01f, 7.35105649e-02f, -4.62421104e-02f, -7.69812688e-02f, 3.35526653e-02f,
  -2.51302749e-01f, 9.66386124e-02f, 2.81447530e-01f, 3.91603053e-01f, 4.23621759e-02f, -5.49269915e-02f, -3.57620001e-01f, -5.60605712e-03f, 5.53595364e-01f, 2.57619798e-01f,
  -1.70491412e-01f, 3.18642296e-02f, 1.11130871e-01f, -2.54581086e-02f, 1.11194670e-01f, -1.81642249e-01f, -1.19295143e-01f, -4.73886058e-02f, -2.49181703e-01f, 2.54867345e-01f,
  -7.74253607e-02f, 2.19498783e-01f, 2.30671838e-01f, 9.47445445e-03f, -1.67934969e-01f, 1.10666104e-01f, 9.07838568e-02f, 1.85798988e-01f, -1.78738952e-01f, 1.32286295e-01f,
  -4.44075800e-02f, 9.88218263e-02f, 1.91300943e-01f, 2.70770878e-01f, -1.23208389e-01f, -1.76564559e-01f, -2.12004036e-01f, 4.48014766e-01f, -3.15869212e-01f, 2.64644891e-01f,
  -5.06903470e-01f, 3.43512654e-01f, 1.12349525e-01f, -3.24522406e-01f, -1.85074076e-01f, 3.91781211e-01f, -1.50252163e-01f, 1.00964338e-01f, 9.90732759e-02f, 2.15062380e-01f,
  2.70100176e-01f, -1.24971502e-01f, -6.10648505e-02f, -2.62355268e-01f, 5.64359948e-02f, -9.09042880e-02f, 1.60224825e-01f, -8.51401221e-03f, -1.04968414e-01f, 3.00732017e-01f,
  1.13623783e-01f, 1.23284638e-01f, 1.19174689e-01f, -5.46790771e-02f, 1.06577799e-01f, 7.23120347e-02f, 1.93154231e-01f, 2.60285825e-01f, -7.55673349e-02f, -5.14347889e-02f,
  -3.90581042e-01f, 1.02977924e-01f, 3.74677360e-01f, 2.26287171e-01f, -2.57738113e-01f, -1.01317525e-01f, -3.33436549e-01f, -1.03984617e-01f, 2.52170742e-01f, -1.91636741e-01f,
  -3.55158627e-01f, -1.10298512e-03f, 1.33698443e-02f, 2.37707332e-01f, -1.67446837e-01f, 1.47959098e-01f, 2.86456048e-01f, -1.29825041e-01f, 1.65919721e-01f, 4.93098237e-02f,
  2.66328543e-01f, 1.25024915e-01f, -1.34257302e-01f, -6.87936321e-02f, -2.75722027e-01f, -4.40670401e-02f, 6.15534149e-02f, 2.86290109e-01f, 1.12211695e-02f, 1.82646349e-01f,
  -1.24546781e-01f, 3.01066875e-01f, -2.10367844e-01f, 2.52642393e-01f, -3.41462642e-01f, -8.84229168e-02f, 1.92957297e-01f, 1.05480857e-01f, 2.28257984e-01f, 4.65016156e-01f,
  -1.17560059e-01f, -1.15086950e-01f, 2.42162883e-01f, 2.79370639e-02f, 8.78085122e-02f, -1.81615368e-01f, -1.42729163e-01f, 9.37226415e-02f, 3.35980579e-02f, 2.54125655e-01f,
  2.56843001e-01f, -1.64790332e-01f, 8.76315981e-02f, 4.44204003e-01f, 2.63950199e-01f, 2.27062386e-02f, 1.39890760e-01f, 1.24554306e-01f, 3.46066087e-01f, 2.76275426e-01f,
  -2.27643713e-01f, -3.46506312e-02f, 2.42260888e-01f, 3.87351871e-01f, -2.58243322e-01f, 1.57766566e-01f, -2.49758825e-01f, 2.25185111e-01f, -1.12711050e-01f, -1.62467644e-01f,
  -9.46372002e-02f, 3.56028497e-01f, -6.65920898e-02f, 6.88408688e-02f, -1.18416743e-02f, 2.91012615e-01f, 1.14583857e-01f, 2.92203873e-01f, -2.52915740e-01f, -9.40193385e-02f,
  2.07077652e-01f, 2.01537143e-02f, 3.65137830e-02f, -7.26405010e-02f, -3.35961908e-01f, 1.83992162e-01f, 8.75160992e-02f, -3.56696807e-02f, -2.72985190e-01f, -6.02595247e-02f,
  -1.19517148e-01f, 1.45766646e-01f, 1.19152188e-01f, 1.04821235e-01f, 5.39185293e-02f, -1.33345202e-01f, -4.26711529e-01f, 3.00683171e-01f, 1.81648791e-01f, 3.43398660e-01f,
  1.89147815e-01f, 2.48495743e-01f, -3.49572226e-02f, 3.53607565e-01f, -1.03704892e-02f, -1.65690348e-01f, -4.54701371e-02f, -1.34202123e-01f, 6.36238381e-02f, 3.67989480e-01f,
  -1.68811977e-01f, 6.43767938e-02f, -3.73173267e-01f, -1.35348618e-01f, -1.35378182e-01f, 9.63537896e-04f, -1.19773276e-01f, 1.10403989e-02f, -6.46392554e-02f, -1.33294147e-02f,
  2.60527544e-02f, 1.16713926e-01f, 2.63618052e-01f, 3.95100638e-02f, -2.45622937e-02f, 8.24942663e-02f, -6.45546317e-02f, -1.10299423e-01f, -1.19253740e-01f, -7.07968324e-02f,
  1.72694176e-01f, 6.45713583e-02f, -2.66886234e-01f, 4.39137314e-03f, -2.76899010e-01f, -3.38262826e-01f, 2.08113924e-01f, 1.32151157e-01f, -2.62019187e-01f, 9.73156244e-02f,
  1.04539096e-01f, 1.74698934e-01f, 1.38983980e-01f, -2.31814057e-01f, 2.83949554e-01f, 2.36605313e-02f, -4.19176146e-02f, -6.21143542e-02f, -2.26763994e-01f, 4.79727864e-01f,
  2.79226005e-01f, 8.50116313e-02f, 1.08179130e-01f, 1.82803407e-01f, 2.16305673e-01f, 1.49737999e-01f, -9.37055498e-02f, 1.59894794e-01f, 8.18745941e-02f, 4.58133608e-01f,
  8.19379911e-02f, -3.54110062e-01f, 3.41400176e-01f, 2.84191340e-01f, -3.55441988e-01f, -3.90391856e-01f, -4.06093486e-02f, -1.98248729e-01f, 8.27840418e-02f, 2.25263983e-02f,
  -3.31422091e-01f, 1.83543190e-01f, -6.57056496e-02f, 1.14638962e-01f, -2.47550998e-02f, 1.78616792e-01f, -2.74782777e-01f, -4.89200428e-02f, -1.54603511e-01f, 3.22675742e-02f,
  -1.57939293e-03f, -1.22193702e-01f, 8.47226307e-02f, 1.73764437e-01f, -2.69888490e-01f, -1.86951235e-01f, 1.02276497e-01f, 8.53691027e-02f, -3.86870265e-01f, -3.04420531e-01f,
  -1.74424469e-01f, 2.85878718e-01f, 1.25088776e-02f, 1.36476308e-02f, -2.64520973e-01f, 3.42865914e-01f, 1.81887358e-01f, -9.71927494e-02f, -1.16259128e-01f, -6.15752116e-02f,
  1.46569833e-01f, 1.66487962e-01f, 4.25383635e-03f, 3.98825705e-02f, 2.07651839e-01f, -1.67265430e-01f, 1.69352993e-01f, -1.70331895e-01f, 1.01068124e-01f, 1.39851257e-01f,
  2.62858391e-01f, -5.16501367e-02f, 3.50605696e-01f, -1.36917710e-01f, -8.34409669e-02f, -2.37425104e-01f, -2.21396208e-01f, 6.75491914e-02f, -4.43788357e-02f, 1.15999736e-01f,
  2.90185750e-01f, 1.99271083e-01f, 2.89066225e-01f, -3.18860292e-01f, -4.21700180e-02f, 1.35200709e-01f, 4.44576927e-02f, -1.46669939e-01f, 8.77666771e-02f, 3.08029860e-01f,
  1.36044025e-01f, 3.35754067e-01f, 7.08988681e-02f, -1.08893350e-01f, 2.07068264e-01f, -2.05606326e-01f, -1.97196871e-01f, -1.46814242e-01f, -2.34875247e-01f, 3.11381102e-01f,
  -1.11136377e-01f, 1.11926377e-01f, 1.02930464e-01f, 3.65350246e-02f, 1.23304874e-01f, -1.25866860e-01f, 9.21444446e-02f, 1.45250186e-01f, -2.98243195e-01f, 3.67993601e-02f,
  1.74110726e-01f, -1.75721258e-01f, -4.12396878e-01f, -2.45682687e-01f, 8.05102363e-02f, 4.10463773e-02f, -1.62863627e-01f, 3.75542253e-01f, -2.54198968e-01f, 1.39398813e-01f,
  2.15510279e-01f, -2.14223802e-01f, -1.50668412e-01f, 3.84033591e-01f, 1.03666365e-01f, -1.36695802e-01f, 4.86246757e-02f, 1.02522887e-01f, 1.35371074e-01f, -2.09218338e-01f,
  2.03587011e-01f, -2.48799264e-01f, 2.88582265e-01f, 3.71659733e-02f, 2.12217420e-01f, -1.84502061e-02f, 8.69842842e-02f, 1.77780986e-01f, 2.12310955e-01f, -7.07279593e-02f,
  1.93198174e-01f, 9.99912620e-02f, -1.35395527e-01f, 1.04173578e-01f, 8.78999308e-02f, 3.45522791e-01f, 2.56257832e-01f, 3.93997245e-02f, 4.24061529e-02f, 2.53465801e-01f,
  -1.53947130e-01f, -1.50439844e-01f, 1.78949520e-01f, -1.31737888e-01f, 8.38627219e-02f, 3.16754550e-01f, -2.22682163e-01f, -8.95353258e-02f, 7.38383159e-02f, -2.19366960e-02f,
  -1.93990469e-01f, 2.31873412e-02f, -2.12744385e-01f, 3.47323298e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -3.69126499e-01f, -5.32065868e-01f, -2.86712676e-01f, 5.21740615e-01f, -3.72967720e-02f, -7.78795421e-01f, -5.89171588e-01f, 1.62430301e-01f, -7.63577342e-01f, 3.40998799e-01f,
  1.53365470e-02f, -7.06598919e-04f, -2.94202477e-01f, -6.91244066e-01f, -6.50409818e-01f, -3.47304881e-01f, -4.72154200e-01f, 1.15214966e-01f, -4.26348388e-01f, 5.44920238e-03f,
  6.16110146e-01f, 3.86459798e-01f, 2.45771766e-01f, -9.52471793e-02f, -8.30901638e-02f, -1.22257940e-01f, 5.41987002e-01f, -1.84206396e-01f, 3.14767152e-01f, -4.26552624e-01f,
  6.15552187e-01f, -6.31781995e-01f, 3.87321621e-01f, 2.14648157e-01f, 2.06561223e-01f, 6.11385643e-01f, -3.35313492e-02f, -3.32505971e-01f, -3.98625806e-02f, 1.74984530e-01f,
  1.53186530e-01f, 1.47000477e-02f, 1.63104489e-01f, 2.62185752e-01f, -9.77744535e-02f, -6.44399822e-02f, -8.92360568e-01f, -3.25070053e-01f, -5.33326566e-01f, 6.27090275e-01f,
  -3.39093775e-01f, 3.74650955e-01f, 4.80260968e-01f, -4.03365284e-01f, -9.47728395e-01f, 2.22316518e-01f, 6.67459726e-01f, 4.30297256e-01f, 3.34060431e-01f, -2.46003792e-02f,
  4.66191649e-01f, 3.50225449e-01f, 3.69656384e-01f, -3.66732866e-01f, 1.67011529e-01f, 1.92599177e-01f, 4.25665319e-01f, 3.13064843e-01f, -5.88634796e-02f, -2.51621157e-01f,
  1.94874462e-02f, 1.32446289e-01f, -2.59386916e-02f, 1.23416416e-01f, -1.80878520e-01f, 6.58690110e-02f, 2.35118449e-01f, 1.50360703e-01f, -2.09583119e-01f, -7.49125659e-01f,
  -5.82975447e-01f, 5.39414763e-01f, -5.10554276e-02f, -3.68187159e-01f, 5.81492245e-01f, 6.11839950e-01f, 3.99353296e-01f, 6.35634124e-01f, 1.65395960e-02f, -4.98934776e-01f,
  6.74696207e-01f, -9.73116830e-02f, 1.99314747e-02f, 2.77605563e-01f, 2.17292473e-01f, 6.68604672e-01f, -3.09735566e-01f, 4.85056609e-01f, 3.32187861e-01f, -6.86194822e-02f,
  -5.23773074e-01f, 5.29764235e-01f, 1.83417365e-01f, 7.74046361e-01f, 3.55751514e-01f, 1.04525238e-01f, 3.16071123e-01f, 3.54143977e-02f, -7.50108361e-01f, -9.61079180e-01f,
  3.16083133e-01f, 3.55066985e-01f, -5.45846164e-01f, 1.60998821e-01f, -2.35947877e-01f, 5.89065790e-01f, 8.98890868e-02f, -2.05839023e-01f, 1.33627579e-01f, 3.43027115e-01f,
  3.56372714e-01f, -8.25634524e-02f, 1.62641332e-01f, 1.03076863e+00f, 3.99145842e-01f, 8.12794626e-01f, 5.17482102e-01f, -2.87824899e-01f, 2.38865265e-03f, -2.82049358e-01f,
  5.67913875e-02f, 3.68060499e-01f, 1.23491965e-01f, -8.47419500e-02f, -4.08023745e-02f, 1.28852457e-01f, -1.04709797e-01f, -1.16345786e-01f, 4.53071505e-01f, 4.34455514e-01f,
  -3.03657711e-01f, -1.11500517e-01f, -5.93115509e-01f, 2.26097792e-01f, -5.54704309e-01f, 4.33417976e-01f, -4.90107089e-01f, 1.68758541e-01f, -1.57239333e-01f, -3.15767914e-01f,
  -2.09601313e-01f, -9.02263224e-02f, -1.31388173e-01f, 4.32991177e-01f, -5.66975884e-02f, 1.36165932e-01f, 9.81630504e-01f, -3.84629130e-01f, 9.47111130e-01f, 3.98010582e-01f,
  -1.67420805e-01f, 3.06878060e-01f, 2.21372202e-01f, 4.42418098e-01f, -1.66873544e-01f, 1.60717607e-01f, -2.04163894e-01f, -1.51457056e-01f, 2.47105844e-02f, 2.21678451e-01f,
  2.58761734e-01f, -2.93545574e-02f, 3.84235889e-01f, 3.10298234e-01f, -7.19023168e-01f, -7.52338290e-01f, -4.86179978e-01f, 3.75263840e-02f, 6.34563863e-01f, -2.34104153e-02f,
  -5.47018111e-01f, 7.99476579e-02f, -6.04401767e-01f, -5.91310620e-01f, 8.86372685e-01f, 3.74515921e-01f, -1.58197135e-01f, -1.57310814e-01f, -5.20568788e-02f, 9.78763759e-01f,
  -2.39288688e-01f, -9.72921997e-02f, 3.15461367e-01f, 1.25497133e-01f, 2.63894856e-01f, 2.49220550e-01f, 6.60379171e-01f, 3.95046413e-01f, 4.86566573e-01f, -5.06338701e-02f,
  1.80298746e-01f, 3.22373033e-01f, 4.90387410e-01f, 2.19446912e-01f, 2.91926265e-01f, 5.22118866e-01f, 3.81087989e-01f, 6.53532505e-01f, 6.41400218e-01f, -6.13990605e-01f,
  4.07791227e-01f, -7.96109974e-01f, -8.39129269e-01f, -7.57580042e-01f, 6.45686269e-01f, -8.57961833e-01f, 2.25812316e-01f, 9.15944874e-01f, -2.45213702e-01f, 6.56184256e-01f,
  2.33057752e-01f, 6.33852854e-02f, 1.30469324e-02f, 8.85609925e-01f, 7.85859466e-01f, 6.05485618e-01f, 3.15470934e-01f, 2.39686668e-01f, 3.44657749e-01f, 2.79866695e-01f,
  3.83329272e-01f, 2.67123967e-01f, 3.12186658e-01f, 4.98642683e-01f, 3.85371000e-02f, 1.69455662e-01f, 2.95016944e-01f, 3.87655914e-01f, 3.60216290e-01f, 5.99961020e-02f,
  -2.97673315e-01f, 4.48088914e-01f, -5.44802189e-01f, -5.29699087e-01f, 3.78420919e-01f, 4.32012737e-01f, 4.95770335e-01f, 7.61848271e-01f, -1.44407302e-01f, -4.05692875e-01f,
  8.83162141e-01f, 3.41414452e-01f, -4.54227999e-02f, 2.13251933e-01f, -1.75537661e-01f, 6.60434902e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  2.51086086e-01f, 9.74579751e-02f, 2.09496289e-01f, 2.18137294e-01f, -3.44936959e-02f, 3.52007240e-01f, 5.22348523e-01f, 2.67893225e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -5.58006763e-02f, -1.73501641e-01f, 3.82978246e-02f, 7.05887750e-02f, 5.67711592e-01f, -6.80741593e-02f, -3.22634816e-01f, 2.13133514e-01f, -1.84814438e-01f, -4.53391820e-01f,
  -1.27289101e-01f, -4.20238793e-01f, -1.34405896e-01f, 1.66702762e-01f, -3.51278901e-01f, 2.64864042e-02f, -4.60753255e-02f, -6.49630651e-02f, 4.32076663e-01f, -4.77517128e-01f,
  -3.41456980e-01f, 8.42065550e-04f, 3.15743059e-01f, 9.31913853e-02f, 5.13814211e-01f, 3.71134818e-01f, -2.90872127e-01f, 7.69196600e-02f, 4.63772655e-01f, -4.79820609e-01f,
  -6.71777904e-01f, -9.00762379e-01f, 5.53755239e-02f, -2.84221023e-01f, -2.87318677e-01f, -4.78601426e-01f, 2.50496417e-01f, 2.26284098e-02f, 2.21835241e-01f, -4.44086611e-01f,
  -1.25093222e-01f, 3.97889525e-01f, -4.67970043e-01f, 4.04000372e-01f, -4.27058935e-01f, 2.82518715e-01f, -2.44479060e-01f, 2.14237124e-01f, 1.52794272e-01f, 1.70585126e-01f,
  -5.86492002e-01f, -4.09389615e-01f, 5.34578204e-01f, 2.87676394e-01f, 3.34448099e-01f, -4.19832200e-01f, 6.50913000e-01f, -9.11415219e-02f, 3.05166841e-01f, 1.10537305e-01f,
  6.43544570e-02f, -1.03207850e+00f, -8.27949405e-01f, 1.70083612e-01f, 3.35909516e-01f, 1.98133036e-01f, -2.59216100e-01f, -2.82045305e-01f, -5.82447588e-01f, 3.87433529e-01f,
  -2.40349665e-01f, 5.24113297e-01f, 3.63930464e-01f, 3.24654132e-02f, 2.79368043e-01f, -4.20712471e-01f, -3.88029128e-01f, 5.64273298e-01f, -5.04261434e-01f, 4.22017574e-01f,
  3.59242946e-01f, -6.01016343e-01f, -3.77419829e-01f, 2.42790636e-02f, -3.55466902e-01f, 4.05759335e-01f, 1.03346109e-01f, 4.40088660e-01f, -7.79636204e-01f, -7.92526245e-01f,
  1.02667227e-01f, 3.27045649e-01f, -7.64701545e-01f, -9.84741390e-01f, -1.57417297e-01f, 6.41520441e-01f, -3.30374330e-01f, 2.14140922e-01f, -3.23017299e-01f, -5.83538532e-01f,
  -2.51083434e-01f, -1.75710306e-01f, -4.25268620e-01f, -4.05989766e-01f, 2.83179015e-01f, -3.97100955e-01f, 1.54885873e-02f, -3.51563506e-02f, 3.53564292e-01f, -2.23497063e-01f,
  -3.84523302e-01f, 7.31899589e-02f, 3.59104425e-01f, 7.42965579e-01f, -3.29302587e-02f, -8.51807371e-03f, 1.30363211e-01f, -4.49639112e-01f, -5.12160957e-01f, -2.08146110e-01f,
  -6.95184708e-01f, 2.23202914e-01f, -7.59627521e-01f, 1.54056206e-01f, -9.17045653e-01f, 3.71289670e-01f, -2.64681131e-01f, -5.93976617e-01f, 5.49956560e-01f, -1.60628315e-02f,
  -2.82074124e-01f, 1.91068605e-01f, -4.65293199e-01f, 3.93682450e-01f, -3.95595819e-01f, -4.60856616e-01f, -5.29531837e-01f, -9.75586772e-02f, 1.35600239e-01f, -2.81709254e-01f,
  5.47353588e-02f, 7.47070372e-01f, 8.30984652e-01f, -5.56335390e-01f, -7.34996349e-02f, -2.86595672e-01f, -5.03698960e-02f, -7.09496588e-02f, -1.33331260e-02f, 4.48233820e-03f,
  1.25348300e-01f, -3.61672312e-01f, -5.36492944e-01f, 1.51459426e-01f, -7.12877750e-01f, 2.92692482e-01f, 1.81671932e-01f, -1.64649948e-01f, 1.01793874e-02f, -8.19498181e-01f,
  -2.97901481e-01f, -5.41967809e-01f, 1.95508227e-01f, 8.71095583e-02f, -5.75001478e-01f, -9.93236303e-02f, 4.56229597e-01f, 4.74093080e-01f, -2.43855212e-02f, 2.64739692e-01f,
  1.05585538e-01f, 3.64696056e-01f, -3.74938041e-01f, 3.74151528e-01f, -1.68882161e-01f, 6.55357778e-01f, -6.86774254e-02f, -3.65504295e-01f, -3.89470602e-03f, 4.09545660e-01f,
  3.97780150e-01f, -4.47300732e-01f, 4.29165810e-01f, 1.62816361e-01f, -5.34352303e-01f, 1.20137244e-01f, -2.47619942e-01f, 1.74592938e-02f, 3.63546044e-01f, -1.01625764e+00f,
  9.51828212e-02f, 1.60570089e-02f, 2.24242851e-01f, 3.80763948e-01f, 4.84003782e-01f, 1.88069895e-01f, 5.63815087e-02f, 6.80525526e-02f, 3.57119590e-01f, -3.52910280e-01f,
  3.44167411e-01f, 3.50701869e-01f, -5.25673509e-01f, -2.06825510e-01f, 4.86478955e-01f, -2.17611134e-01f, -5.93211129e-02f, 3.12064081e-01f, 8.01581368e-02f, -4.94302213e-01f,
  -6.31941676e-01f, -7.55854771e-02f, -7.01473415e-01f, 4.61380750e-01f, -4.97266859e-01f, 6.15128875e-01f, -3.54813010e-01f, -5.78429401e-01f, -5.04594028e-01f, -9.26175177e-01f,
  -1.42953247e-01f, -7.98715889e-01f, 6.32539332e-01f, 8.19985941e-02f, 3.66480947e-01f, 8.26643482e-02f, 1.78781629e-01f, -2.36973986e-01f, 4.61228281e-01f, -8.08777213e-02f,
  -2.55479187e-01f, 3.58372211e-01f, 2.50050902e-01f, 4.08016264e-01f, -8.36268812e-03f, 9.04442668e-02f, 5.64303100e-02f, -3.88127685e-01f, 3.15954775e-01f, -3.42427582e-01f,
  -6.08412027e-01f, -8.59116793e-01f, 2.76127338e-01f, 1.48635224e-01f, 9.27279741e-02f, 2.57430583e-01f, -2.88771063e-01f, -6.34400189e-01f, 2.59544313e-01f, 3.65726471e-01f,
  -4.39992934e-01f, -9.40836370e-01f, -3.23081762e-01f, 3.43510926e-01f, 2.46048301e-01f, -5.62907338e-01f, -1.17522180e-02f, -1.55658051e-01f, 3.40518057e-01f, -1.84361897e-02f,
  5.25038481e-01f, -2.29652867e-01f, -1.90630332e-01f, -3.03712040e-01f, 5.80829270e-02f, -4.96940821e-01f, 2.31565818e-01f, -1.26358852e-01f, 6.54136896e-01f, -7.35279202e-01f,
  -2.02686474e-01f, 2.79526114e-01f, -4.33341622e-01f, 6.65731072e-01f, -3.90448779e-01f, -3.97542417e-01f, -5.66548407e-01f, 1.61383331e-01f, -3.57182145e-01f, 1.19733021e-01f,
  -3.13285232e-01f, 3.28580812e-02f, 6.46591842e-01f, -4.79113102e-01f, -3.28610480e-01f, -2.85977930e-01f, -7.94702590e-01f, 4.06797171e-01f, 2.44326994e-01f, 4.80725378e-01f,
  3.25145602e-01f, -9.95044112e-02f, 2.49546528e-01f, -5.88726878e-01f, 9.65263993e-02f, -2.43730843e-01f, -6.10245904e-03f, 1.10538527e-01f, 4.43798333e-01f, 4.16759759e-01f,
  -6.31258726e-01f, -4.26009059e-01f, -5.48075616e-01f, -7.39670515e-01f, 3.93667936e-01f, -2.19214574e-01f, 2.94460982e-01f, 4.55344290e-01f, 4.70164239e-01f, -6.33238673e-01f,
  -4.57131952e-01f, -6.16397202e-01f, -8.33405614e-01f, -9.16347742e-01f, -4.17912811e-01f, 3.92791659e-01f, 6.76515698e-02f, -7.21324682e-01f, 4.28198487e-01f, -9.70950425e-01f,
  2.35658228e-01f, 1.06242290e-02f, -6.31919578e-02f, 1.20278046e-01f, -4.85546499e-01f, -3.08014184e-01f, 4.02843028e-01f, 3.24650824e-01f, 3.65570635e-01f, 1.87889278e-01f,
  -4.47922684e-02f, 3.40824395e-01f, 4.75627005e-01f, 3.54482561e-01f, 4.56432432e-01f, -8.91304761e-02f, -1.52255848e-01f, 5.29248476e-01f, 3.33672225e-01f, 1.62328750e-01f,
  1.51615232e-01f, -2.95536648e-02f, 5.72206378e-01f, 1.69031203e-01f, -6.20596111e-01f, 4.04643118e-01f, 4.90394309e-02f, 3.94473672e-01f, -5.78149438e-01f, -2.65246540e-01f,
  -7.06537187e-01f, 1.02491327e-01f, -4.65791285e-01f, -1.65082008e-01f, -5.55081666e-01f, 3.43947262e-01f, -6.38177479e-03f, 1.47862419e-01f, 1.99247807e-01f, 5.29325102e-03f,
  -1.89180657e-01f, -2.08225906e-01f, -4.43214089e-01f, 2.92148799e-01f, 2.21156199e-02f, -3.41827124e-01f, 2.50251442e-01f, -3.90831411e-01f, 3.07767153e-01f, 7.04933226e-01f,
  5.00316262e-01f, 2.85989642e-01f, -5.36782324e-01f, 6.11973226e-01f, -2.15932906e-01f, 3.39844584e-01f, -1.08147264e+00f, -5.69259048e-01f, 2.29588270e-01f, -1.70789793e-01f,
  -3.55088443e-01f, 3.70462835e-01f, 1.17647685e-01f, -2.60717124e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -7.56518394e-02f, -1.64922729e-01f, 3.48451547e-02f, -1.76322798e-03f, -1.37330905e-01f, -5.24884127e-02f, 7.11799115e-02f, -1.26900703e-01f, 6.18952326e-03f, 3.44963148e-02f,
  1.27070427e-01f, 1.50624020e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    