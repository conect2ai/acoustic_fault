/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.70745054e-02f, 9.35801864e-02f, 1.97996020e-01f, 6.73126802e-02f, -4.09462154e-02f, -1.65222157e-02f, 2.31437869e-02f, 4.53640968e-02f, -6.67278795e-03f, 3.91423292e-02f,
  -2.05147769e-02f, -7.79203549e-02f, 2.24346351e-02f, -9.11870506e-03f, 6.52981997e-02f, 1.17412684e-02f, 1.19020559e-01f, 1.99116394e-02f, 8.98824930e-02f, -1.23196773e-01f,
  -7.80016631e-02f, -4.09993110e-03f, 6.04907461e-02f, 5.96294366e-02f, -4.38343175e-03f, 2.29242239e-02f, 5.17730378e-02f, -5.94536588e-02f, 1.22260739e-04f, -1.99889317e-02f,
  1.04356155e-01f, 4.91821149e-04f, 6.83883131e-02f, -1.20312590e-02f, 7.61543959e-02f, -1.44347623e-02f, -5.30068092e-02f, -5.08949198e-02f, 1.79655869e-02f, 9.72080976e-03f,
  3.25723253e-02f, -1.27941772e-01f, -8.50403607e-02f, 5.20112403e-02f, -8.12836066e-02f, -2.82791201e-02f, -4.40995097e-02f, 8.75853226e-02f, -3.58259641e-02f, -1.87664535e-02f,
  -6.17954731e-02f, -2.20737197e-02f, 8.81547257e-02f, -9.26617812e-03f, 2.41971482e-02f, 3.79875675e-02f, -2.94685233e-02f, -1.05442353e-01f, 7.72563666e-02f, 8.23631808e-02f,
  1.09959450e-02f, -2.67781503e-02f, -8.11129808e-02f, -4.89834324e-02f, 4.02231701e-02f, -6.15123846e-03f, -2.37568002e-02f, 3.46484035e-02f, 4.05923463e-02f, 2.72801407e-02f,
  -2.11829189e-02f, -3.27045918e-02f, 8.84964243e-02f, -5.33766171e-04f, -3.60312052e-02f, 1.16425510e-02f, -2.67029554e-02f, -4.56242934e-02f, 3.37949283e-02f, 5.77815361e-02f,
  4.72396575e-02f, -1.01514040e-02f, 5.76179847e-02f, -1.16736218e-02f, 5.70085160e-02f, -7.13766068e-02f, -1.41691286e-02f, -3.95870283e-02f, 1.72011238e-02f, -1.06232483e-02f,
  1.01610944e-01f, -8.10201243e-02f, 7.52505735e-02f, 2.82992441e-02f, 1.82622913e-02f, -4.31216285e-02f, -9.08367150e-03f, 5.10517396e-02f, 5.31591140e-02f, 4.12018374e-02f,
  -1.70890968e-02f, 9.38317850e-02f, 5.61235175e-02f, -2.52397303e-02f, -1.47719309e-02f, -9.43482947e-03f, 1.59343276e-02f, -3.56439129e-02f, 6.10284097e-02f, 6.48986874e-03f,
  -8.04438591e-02f, 2.65489239e-02f, 1.61028970e-02f, 4.94613573e-02f, 5.32919280e-02f, 1.46669950e-02f, 4.28532436e-02f, 4.34186310e-03f, -2.45367326e-02f, 8.74288306e-02f,
  1.82601050e-01f, -8.05960000e-02f, -1.72305003e-01f, 2.05436334e-01f, 6.03032671e-02f, -2.15954438e-01f, -2.78705835e-01f, -7.16294646e-02f, 1.36235565e-01f, -2.89835297e-02f,
  2.54122410e-02f, -2.17618281e-03f, 4.65128049e-02f, -7.22702071e-02f, -9.33937579e-02f, -1.74158528e-01f, 1.79481413e-02f, -6.58009127e-02f, -1.14962980e-01f, -3.76028270e-02f,
  8.10627863e-02f, 7.56204920e-03f, 1.14178084e-01f, 6.28919303e-02f, 1.05525680e-01f, 1.42592192e-01f, -5.52359521e-02f, 2.22868398e-02f, 3.65003236e-02f, 2.22226471e-01f,
  -1.47739246e-01f, 7.57373171e-03f, -8.88172984e-02f, -1.45353964e-02f, -6.42275661e-02f, 1.52845606e-02f, -1.60464663e-02f, -4.20186520e-02f, 6.61661476e-02f, -2.84937192e-02f,
  8.58787671e-02f, -3.08516864e-02f, 9.14191529e-02f, 4.85282093e-02f, -2.74439603e-02f, 3.38672213e-02f, 1.01505928e-01f, 1.21516660e-01f, -8.92242417e-02f, -9.60560367e-02f,
  -6.41996637e-02f, -3.51159349e-02f, -9.37732160e-02f, 3.93168367e-02f, 6.45401478e-02f, 3.35399248e-02f, 5.76293329e-04f, 9.76642966e-02f, 4.50540669e-02f, -3.66854034e-02f,
  4.03112322e-02f, 4.81285900e-02f, 8.15131813e-02f, -5.31523116e-03f, -2.65075956e-02f, 6.19773418e-02f, -2.11603306e-02f, 2.87548192e-02f, 1.97347663e-02f, -2.68586017e-02f,
  2.88733970e-02f, -6.87333122e-02f, 1.12855807e-02f, 6.84880884e-03f, -1.63817964e-02f, -9.96187143e-03f, -7.67316744e-02f, -2.73021478e-02f, -8.15948546e-02f, 4.79798988e-02f,
  2.15356145e-02f, 1.59033556e-02f, 2.69250721e-02f, -2.62535065e-02f, 5.85397892e-02f, -4.73746397e-02f, 2.41876859e-02f, 7.26553202e-02f, 5.92367053e-02f, -6.43461198e-03f,
  -1.80736445e-02f, -5.38341254e-02f, -8.41262285e-03f, -3.19118723e-02f, 7.81887695e-02f, 6.46256283e-02f, -4.59101684e-02f, 4.83335694e-03f, -5.70022017e-02f, -7.72049427e-02f,
  -1.08084291e-01f, -5.82883060e-02f, -3.57659608e-02f, -5.48957549e-02f, -5.94306700e-02f, -7.26392269e-02f, -5.76099269e-02f, -1.50771085e-02f, -2.92261466e-02f, -1.14952857e-02f,
  -7.56438076e-02f, -4.84602526e-02f, -1.16143353e-01f, -4.13322449e-02f, -6.34683669e-02f, -9.30993706e-02f, -1.05813220e-01f, -9.91064906e-02f, -1.47718325e-01f, -6.43425882e-02f,
  9.80210230e-02f, -4.96711582e-02f, -2.14382112e-01f, 1.82069335e-02f, -4.14995514e-02f, -1.54516682e-01f, -4.91315648e-02f, -1.18243575e-01f, -1.98017359e-02f, -9.82384160e-02f,
  2.52359174e-02f, 1.10597294e-02f, -8.07551518e-02f, -5.26297465e-02f, -1.16572492e-01f, -1.80534959e-01f, -7.91571736e-02f, -1.50099158e-01f, -4.81265932e-02f, 4.43530641e-02f,
  8.99359002e-04f, 6.88978359e-02f, -3.12816575e-02f, 8.59825499e-03f, 6.57800138e-02f, 1.53566096e-02f, -7.92214423e-02f, -7.20892698e-02f, 7.60655180e-02f, 1.37590438e-01f,
  -6.24324903e-02f, 3.05802543e-02f, 5.77138774e-02f, -3.01596168e-02f, 8.65408257e-02f, -8.65122825e-02f, -1.87861267e-02f, -6.30997717e-02f, 5.21286577e-02f, 1.55662270e-02f,
  7.10067078e-02f, -1.26647139e-02f, -7.94981122e-02f, -4.26343866e-02f, 5.13092913e-02f, 4.53852750e-02f, -6.60516247e-02f, 4.12705913e-02f, -4.19912823e-02f, 4.62955050e-02f,
  4.30296846e-02f, 3.09526771e-02f, -8.31059739e-02f, -1.12099260e-01f, 3.20842825e-02f, -2.56818496e-02f, 2.64713857e-02f, 5.75433634e-02f, -5.03389211e-03f, 2.52078250e-02f,
  2.72023324e-02f, -5.06097861e-02f, -2.24009585e-02f, 1.08858094e-01f, 3.61423492e-02f, -3.15131731e-02f, -7.28821456e-02f, 1.96269490e-02f, 2.92283185e-02f, -7.66533092e-02f,
  -6.89699277e-02f, -1.43565959e-03f, 3.33774462e-02f, 3.18123586e-02f, 4.01031673e-02f, 3.67920063e-02f, -1.38939582e-02f, 1.52241876e-02f, -6.30128458e-02f, -5.59854060e-02f,
  -2.72404291e-02f, 6.02436624e-02f, 3.63893025e-02f, -3.20741571e-02f, 6.05453327e-02f, -4.97228913e-02f, 5.75412586e-02f, 6.33691102e-02f, 7.62525052e-02f, 6.55872449e-02f,
  -7.07553178e-02f, -1.35688901e-01f, 1.85314827e-02f, 5.21205254e-02f, 8.83117095e-02f, 6.02954999e-02f, 1.02901822e-02f, 1.73217654e-02f, 2.43908707e-02f, 7.16529414e-02f,
  1.02260530e-01f, 7.76170492e-02f, -3.70338671e-02f, 4.65672351e-02f, -2.49501988e-02f, 9.28856805e-02f, 6.09757453e-02f, 9.82576609e-03f, 1.40437260e-02f, -9.02731158e-03f,
  8.58774856e-02f, -7.10427091e-02f, -3.76292355e-02f, -3.71240228e-02f, 4.90951054e-02f, -9.02104229e-02f, -7.19579086e-02f, -5.71263805e-02f, -8.17380250e-02f, -1.11193769e-01f,
  -4.42939550e-02f, 1.09090023e-01f, 1.67065755e-01f, -1.01685852e-01f, -3.37100476e-02f, 1.48290887e-01f, 1.62945390e-01f, 8.52943212e-02f, -8.72921571e-02f, -7.91787282e-02f,
  -3.43068689e-02f, -4.29906361e-02f, 7.97100812e-02f, -5.67060784e-02f, 8.03198945e-03f, 9.27127451e-02f, -4.76169363e-02f, 1.01231515e-01f, 6.35470375e-02f, -5.72793856e-02f,
  3.37701887e-02f, -2.64544543e-02f, -1.03558511e-01f, 3.39017157e-03f, -6.04786575e-02f, -3.06801056e-03f, -9.73694548e-02f, 5.70922568e-02f, -5.44316545e-02f, -1.01355806e-01f,
  5.45975380e-02f, 9.40830857e-02f, -8.25182572e-02f, -6.14982273e-04f, 7.65873194e-02f, -8.00705422e-03f, 4.69475240e-02f, 7.51735121e-02f, -3.07491533e-02f, 6.97693601e-02f,
  5.84559403e-02f, 7.69810155e-02f, 2.57191788e-02f, -7.86773562e-02f, -1.87507272e-02f, 3.05745117e-02f, 3.93588394e-02f, 1.02503568e-01f, -2.64141019e-02f, 1.56955551e-02f,
  -2.34174803e-02f, -7.34864827e-03f, 9.32123438e-02f, -1.67155918e-02f, 4.67735045e-02f, -6.98628128e-02f, 4.72346842e-02f, -3.29395547e-03f, 1.09132417e-01f, -1.95735041e-03f,
  -6.16999418e-02f, 1.58985015e-02f, 4.19940986e-02f, -7.60969147e-02f, -2.01725354e-03f, -7.04807714e-02f, -2.58284155e-02f, -7.89668262e-02f, -1.13418382e-02f, 7.36768991e-02f,
  6.00716881e-02f, 4.46605273e-02f, 8.72094184e-02f, -6.12140633e-02f, -3.88642885e-02f, -2.84781475e-02f, -2.96717361e-02f, 1.94796436e-02f, 7.42463171e-02f, 3.81781124e-02f,
  2.20855456e-02f, 4.19920087e-02f, -2.54331622e-02f, -1.08849686e-02f, 8.21870845e-03f, 1.14319362e-02f, -7.74813369e-02f, 5.89043461e-02f, -2.95182727e-02f, 7.66494125e-02f,
  -1.34133443e-01f, 2.01034859e-01f, -1.33931652e-01f, -1.20915599e-01f, 4.75030951e-02f, -7.95036703e-02f, -4.16893922e-02f, 2.13020900e-03f, 4.98393886e-02f, 2.82205250e-02f,
  1.02509640e-01f, -2.32812180e-03f, 8.01472887e-02f, 6.16536550e-02f, -2.66237557e-02f, -4.76092212e-02f, -1.02808908e-01f, 1.29675996e-02f, -4.25829403e-02f, -5.23215309e-02f,
  -9.41720903e-02f, -6.35207593e-02f, -5.34749366e-02f, -2.50719115e-02f, -8.40164199e-02f, 3.40049677e-02f, -4.85419445e-02f, 1.75873581e-02f, -1.00954831e-01f, -1.93910345e-01f,
  1.07241705e-01f, -9.33915600e-02f, 1.68912396e-01f, 5.09199314e-02f, -6.86736703e-02f, 6.81122467e-02f, 1.52786728e-02f, -8.95440876e-02f, -2.83956211e-02f, 4.43719067e-02f,
  2.34395120e-04f, 1.19441517e-01f, -5.37972264e-02f, 7.81083852e-02f, 4.38529067e-02f, -2.66868398e-02f, 1.59740373e-02f, 1.25225142e-01f, 1.52712271e-01f, 6.38900846e-02f,
  6.02334850e-02f, 8.12918395e-02f, 1.41804144e-01f, 6.66425526e-02f, 4.08078842e-02f, 8.60271603e-02f, 9.36269611e-02f, -2.81485114e-02f, 9.70984399e-02f, 2.26254910e-02f,
  2.29186714e-01f, 1.17824957e-01f, -5.83022572e-02f, 6.00697733e-02f, 2.23319326e-02f, -3.18170004e-02f, 5.97334504e-02f, 1.03229154e-02f, -1.09546848e-01f, 1.69361513e-02f,
  1.26627550e-01f, 2.06682831e-03f, 4.08163369e-02f, -1.03691155e-02f, 3.26579213e-02f, 1.16063587e-01f, -4.44454439e-02f, -5.58376499e-02f, 5.62428162e-02f, 2.12383736e-02f,
  3.77563126e-02f, -1.69149530e-03f, 4.24463302e-03f, -2.87411734e-02f, -6.22758791e-02f, 4.64872010e-02f, -6.77945390e-02f, 1.44405216e-02f, -5.81228826e-03f, -1.94677468e-02f,
  1.50862923e-02f, 3.39837037e-02f, 1.45321870e-02f, -1.00011736e-01f, -2.54409574e-02f, -8.89929943e-03f, -3.97623032e-02f, 1.76894187e-03f, 6.17772005e-02f, 8.39784276e-03f,
  -1.36107916e-03f, -3.11679821e-02f, 1.98981874e-02f, -8.21808577e-02f, 2.23033782e-02f, 4.04464342e-02f, -1.56133603e-02f, -4.29260917e-02f, 4.37182188e-02f, 3.01985908e-02f,
  -2.43357364e-02f, -7.76167661e-02f, 6.77586943e-02f, -6.11969270e-02f, -6.80575613e-03f, 7.80572146e-02f, 6.07724749e-02f, 9.94354784e-02f, -6.80361092e-02f, 8.40757191e-02f,
  -1.61081970e-01f, 6.09053038e-02f, 6.07406534e-02f, -5.94744422e-02f, -4.21420410e-02f, -6.04899377e-02f, -2.37614792e-02f, -7.72050470e-02f, 6.29772693e-02f, -2.60322765e-02f,
  1.09310679e-01f, 2.97779962e-02f, 8.41633230e-03f, 1.98659245e-02f, 5.49934842e-02f, 2.71868054e-02f, -5.11946604e-02f, -4.68181632e-02f, 2.91684233e-02f, -8.27382598e-03f,
  -1.06329121e-01f, 5.39283901e-02f, -1.13944791e-01f, -6.14505857e-02f, -9.50903222e-02f, 7.43685514e-02f, 5.16338907e-02f, -2.40733214e-02f, 4.25380096e-02f, -1.72657430e-01f,
  -1.11979507e-01f, -1.61211848e-01f, -2.34371677e-01f, -1.51949078e-02f, -1.55058801e-02f, 2.50299815e-02f, -2.12929592e-01f, -4.14276905e-02f, 7.62079284e-02f, -1.08640060e-01f,
  9.83142257e-02f, 1.92521989e-01f, 1.63229793e-01f, 1.76796779e-01f, -4.79639247e-02f, -2.15089023e-01f, -1.51877359e-01f, -4.08075973e-02f, 1.48550421e-01f, 1.09473780e-01f,
  1.55736491e-01f, 2.28526462e-02f, -6.66239709e-02f, -1.53028080e-02f, 1.95211302e-02f, 1.37659565e-01f, -1.40932888e-01f, -6.94835782e-02f, 4.47543524e-02f, -5.33899069e-02f,
  -2.93604974e-02f, -2.25718826e-01f, 5.07875644e-02f, -1.41440481e-02f, 6.34340271e-02f, -4.00522463e-02f, -4.79612499e-02f, -3.55407335e-02f, 3.09716817e-02f, 3.97308320e-02f,
  2.06135418e-02f, -4.52514775e-02f, 1.22874700e-01f, -1.43934200e-02f, -8.37602317e-02f, 2.27681063e-02f, -2.99763912e-03f, -1.38815001e-01f, -6.37103915e-02f, -3.14605311e-02f,
  -2.30855010e-02f, -2.81334086e-03f, -8.61840919e-02f, -5.11200875e-02f, -6.53474107e-02f, 6.65366501e-02f, -6.14462718e-02f, 8.64773244e-02f, -6.85526803e-02f, -7.55879581e-02f,
  2.06259452e-02f, -2.63777021e-02f, 2.82746833e-02f, -1.22313108e-03f, -2.61434517e-03f, -1.84436738e-02f, -1.42979929e-02f, 4.80378121e-02f, -2.65339669e-02f, -6.02624938e-03f,
  1.30593395e-02f, 2.66449023e-02f, -4.29543145e-02f, -3.04257926e-02f, 8.40275213e-02f, -7.08861426e-02f, -6.38988763e-02f, 7.81218857e-02f, 5.45119122e-02f, -2.52310466e-02f,
  3.40942554e-02f, -2.11029984e-02f, -1.37435514e-02f, -9.63760633e-03f, -2.03760900e-02f, 3.63214985e-02f, 3.55874486e-02f, 6.13291152e-02f, -1.24233626e-02f, -3.18326578e-02f,
  9.17300358e-02f, 4.37545702e-02f, -1.85735617e-02f, -1.80612206e-02f, 2.53203558e-03f, 3.96370180e-02f, 9.99708697e-02f, -1.05391699e-03f, 4.02605943e-02f, -4.17501628e-02f,
  -1.71360634e-02f, -6.82139397e-02f, -1.25632593e-02f, -8.84632673e-03f, 1.06758336e-02f, -4.83922325e-02f, -1.72565202e-03f, -6.06721342e-02f, 7.77335539e-02f, 5.75079806e-02f,
  1.76043343e-02f, -3.16615887e-02f, 2.53048167e-02f, 2.75497884e-02f, 1.90210417e-02f, 1.02247216e-01f, 7.07911178e-02f, -2.08766684e-02f, 5.78562915e-02f, -9.26599056e-02f,
  -2.28151411e-01f, -1.65408462e-01f, -1.27786890e-01f, -9.83311161e-02f, -2.30051856e-03f, -9.67372283e-02f, -1.45668238e-01f, -2.41484065e-02f, -5.60130887e-02f, -8.66344199e-02f,
  -3.41140516e-02f, 5.42837791e-02f, 1.04337052e-01f, 3.64728719e-02f, -6.06984682e-02f, -8.22112262e-02f, -8.06743354e-02f, -6.03637211e-02f, -2.68049091e-02f, 4.26561087e-02f,
  -2.85429005e-02f, 4.76980805e-02f, 4.75470610e-02f, 1.19998239e-01f, -5.72972372e-02f, -1.81039684e-02f, 2.06419230e-02f, -1.53366886e-02f, -2.46624928e-02f, 4.59904894e-02f,
  -1.56107098e-01f, 1.11369956e-02f, 1.11179210e-01f, 7.09860250e-02f, 1.06246211e-01f, 5.18189818e-02f, -7.72614330e-02f, -2.54077911e-02f, -1.63784588e-03f, 4.62900922e-02f,
  -3.00660003e-02f, 1.08911730e-01f, -4.09974977e-02f, 5.36982110e-03f, -4.24032919e-02f, -7.41854236e-02f, 8.93032625e-02f, -2.61471178e-02f, -3.07145598e-03f, -4.38622124e-02f,
  4.77415994e-02f, -2.60627810e-02f, -1.37559086e-01f, -7.74124414e-02f, -1.49140684e-02f, -5.62937856e-02f, -3.80039960e-02f, -3.10022086e-02f, -4.23033535e-02f, 2.59800982e-02f,
  3.13859843e-02f, -6.65543042e-03f, -5.63541567e-03f, -2.58806199e-02f, 5.67668304e-03f, 2.32639611e-02f, 4.41043898e-02f, 8.21265429e-02f, -3.47408541e-02f, -4.63676639e-03f,
  9.38010961e-02f, -3.32442261e-02f, 1.08252585e-01f, -4.91716824e-02f, 4.80769277e-02f, -1.18739177e-02f, -5.81514277e-02f, 8.44401959e-03f, -4.05988693e-02f, -2.63574906e-02f,
  -8.25219750e-02f, -6.92398697e-02f, 4.33740653e-02f, 2.16816328e-02f, -4.45380472e-02f, 3.86969349e-03f, -3.21963383e-03f, -3.57722156e-02f, -6.82473555e-02f, 1.36429314e-02f,
  -1.08443521e-01f, 1.98529586e-01f, -1.42435342e-01f, -1.04026474e-01f, -3.84603851e-02f, -1.58628840e-02f, -1.53341070e-02f, 2.36554798e-02f, 8.06293488e-02f, -7.80643970e-02f,
  -7.04712942e-02f, -9.43246260e-02f, -4.49260399e-02f, 1.53005600e-01f, -4.32116762e-02f, 5.19343168e-02f, -7.41829863e-03f, -2.86726244e-02f, -4.89692502e-02f, -4.01726887e-02f,
  -1.05624661e-01f, -1.67003229e-01f, -1.51159927e-01f, -2.89419815e-02f, -8.19064453e-02f, -5.94965965e-02f, -1.20456323e-01f, -8.86901915e-02f, -4.59467701e-04f, -7.69942477e-02f,
  -1.98003948e-01f, 2.53214706e-02f, 1.08526319e-01f, 1.04489811e-02f, 8.51066038e-02f, -2.04403307e-02f, -7.47091025e-02f, -9.42855403e-02f, -1.31748170e-01f, -8.94525275e-02f,
  -5.95291816e-02f, -5.98894618e-02f, -6.52849004e-02f, 3.15094627e-02f, 5.53987622e-02f, 7.15780258e-02f, 8.01429749e-02f, 9.52789187e-02f, -5.34535572e-03f, -5.79969101e-02f,
  -6.34945557e-02f, -9.38448682e-02f, -1.32881969e-01f, 5.53277545e-02f, -2.45789941e-02f, -6.61104545e-03f, 9.80023071e-02f, -2.36094762e-02f, 7.26861283e-02f, 1.13802403e-01f,
  -1.01610892e-01f, 1.67865500e-01f, -3.99068370e-02f, -1.05716132e-01f, -3.47658172e-02f, -4.00023572e-02f, 1.95141435e-02f, 1.22280903e-02f, -3.72644253e-02f, -1.19518703e-02f,
  9.70890075e-02f, -3.59952487e-02f, 4.22764495e-02f, 8.59060383e-04f, 4.76302542e-02f, -4.10296060e-02f, 5.77261718e-03f, 3.95573378e-02f, 7.42474105e-04f, 2.89894231e-02f,
  1.26542393e-02f, 8.58372897e-02f, 5.04654050e-02f, 9.69680250e-02f, 3.34928557e-02f, 5.89812174e-02f, -6.82797842e-03f, -1.79193411e-02f, 7.19316304e-02f, -1.08485930e-01f,
  1.12544009e-02f, -5.64860255e-02f, 1.04612090e-01f, 5.82056642e-02f, 1.05511099e-02f, -6.22177962e-03f, -2.72746338e-03f, -6.41221851e-02f, -2.48570330e-02f, -3.20795327e-02f,
  1.25565985e-02f, -6.48575723e-02f, -1.71006620e-02f, -3.88488583e-02f, 1.05104335e-02f, 4.31257114e-02f, -3.16726454e-02f, -6.46100417e-02f, 5.57660535e-02f, 4.73509096e-02f,
  -7.67489001e-02f, 1.15779661e-01f, -5.28134443e-02f, -4.06205989e-02f, 6.19244762e-02f, 1.29341573e-01f, -1.00134881e-02f, -4.97998968e-02f, 2.55765598e-02f, -4.54990529e-02f,
  -3.11624914e-01f, 5.51096052e-02f, -9.82550234e-02f, 1.67475641e-02f, 1.01502322e-01f, 1.51074426e-02f, -6.28047287e-02f, 5.74842542e-02f, 4.87684831e-02f, -6.11210316e-02f,
  -3.53346393e-02f, -6.78523928e-02f, -7.33853504e-02f, -7.68177304e-03f, 3.64047824e-03f, -1.18576689e-02f, -4.83280718e-02f, -8.32508877e-03f, -1.86012611e-02f, 3.74609232e-02f,
  1.12442579e-02f, 2.12433413e-02f, -1.61570460e-01f, -6.69561327e-02f, 7.05163777e-02f, -9.45102423e-02f, -4.31803949e-02f, -1.23179905e-01f, -1.54584959e-01f, -2.61406332e-01f,
  -3.96816939e-01f, -2.18754604e-01f, -6.20274581e-02f, -1.99227259e-01f, 1.10922076e-01f, 1.89463034e-01f, 1.77642539e-01f, 8.84779554e-04f, -7.52816945e-02f, -7.08822310e-02f,
  -1.74778197e-02f, 1.19514316e-01f, 6.13603704e-02f, 2.76954845e-02f, 7.82628171e-03f, 1.41323835e-03f, -1.03762604e-01f, -2.76884623e-03f, 1.50357008e-01f, 4.67423387e-02f,
  1.34752929e-01f, 1.44862644e-02f, -1.55676544e-01f, -1.20644540e-01f, 2.84859166e-02f, 4.35971059e-02f, -1.13319904e-01f, 2.09615771e-02f, 5.52144460e-02f, -1.80761680e-01f,
  -5.99062815e-02f, -1.09464146e-01f, 1.58944786e-01f, 6.78845793e-02f, -6.87107965e-02f, 3.89873125e-02f, -1.88558232e-02f, -1.04080416e-01f, -5.49079999e-02f, 2.41774786e-02f,
  -3.22893336e-02f, -1.06738182e-03f, -8.17568451e-02f, 9.91574153e-02f, -9.55653563e-03f, -2.51901858e-02f, -1.47880660e-02f, 2.50959639e-02f, 1.23871993e-02f, -2.47479342e-02f,
  8.20188299e-02f, 6.06125481e-02f, 8.07908550e-02f, 6.82129636e-02f, 1.18842550e-01f, 1.77419465e-02f, 9.75660421e-03f, -3.47454043e-04f, -6.47567436e-02f, -2.37536822e-02f,
  2.26286463e-02f, 2.85684038e-02f, 3.06092352e-02f, -1.55054266e-03f, 1.54821770e-02f, -3.78586724e-02f, 7.86747187e-02f, -1.81464665e-02f, 2.55947560e-02f, -6.78518191e-02f,
  -5.40486984e-02f, -1.76456128e-03f, 8.08977112e-02f, -7.73436874e-02f, 2.24515833e-02f, 1.34578161e-02f, 6.65133446e-02f, -5.13297617e-02f, 6.95674568e-02f, 4.58178967e-02f,
  -5.88436425e-03f, 1.36471577e-02f, -9.01878532e-03f, -4.04379219e-02f, 2.62758080e-02f, -3.35888639e-02f, 6.47969544e-02f, 6.84670806e-02f, 2.51861364e-02f, -7.06910416e-02f,
  -7.56982900e-03f, 1.62277713e-01f, -6.38791770e-02f, 4.86993603e-02f, -6.64641187e-02f, -6.72835112e-02f, 1.72739103e-03f, 2.99781114e-02f, -2.40455251e-02f, 7.74390018e-03f,
  9.63884741e-02f, 1.80498930e-04f, 4.00889851e-02f, 2.35162210e-02f, -4.83890548e-02f, 4.73904572e-02f, 3.52611975e-03f, -2.67953873e-02f, 4.25197855e-02f, 4.15138565e-02f,
  -1.74478106e-02f, -1.81249082e-02f, 3.65848951e-02f, -2.93376576e-02f, -1.90682653e-02f, -3.79107456e-04f, -4.72269207e-02f, 7.70324320e-02f, -2.34561088e-03f, -8.94774944e-02f,
  3.27405632e-02f, -1.03100821e-01f, -1.50942113e-02f, 1.39598757e-01f, 1.59578979e-01f, 2.31809184e-01f, 1.99334294e-01f, 3.98592316e-02f, 8.05450231e-02f, 7.69956782e-02f,
  -2.26343423e-02f, -1.16054922e-01f, 1.09010544e-02f, -3.08004320e-02f, -9.25093368e-02f, 1.19624212e-01f, 9.37190503e-02f, 3.21927294e-02f, -4.68887854e-03f, 3.39556560e-02f,
  -4.60860766e-02f, 7.81532004e-02f, -4.43551727e-02f, 3.71098407e-02f, 1.13956025e-02f, 2.73418780e-02f, 3.15411873e-02f, -9.58369598e-02f, 2.81283502e-02f, 6.59457501e-03f,
  -7.34099671e-02f, -1.49721101e-01f, 1.01124734e-01f, -1.40206572e-02f, 6.11137003e-02f, -1.54209659e-02f, 4.31346484e-02f, -3.06323078e-02f, 5.01234084e-02f, -3.24244685e-02f,
  -1.07394429e-02f, 5.09860218e-02f, -5.36051728e-02f, -7.36410990e-02f, -5.06749041e-02f, -1.29100010e-02f, -7.34188259e-02f, -1.49153788e-02f, 4.29659635e-02f, -9.11012292e-02f,
  -7.87297636e-02f, 5.64408451e-02f, 6.63302243e-02f, 2.93080565e-02f, -1.24247208e-01f, -3.39053534e-02f, -5.30567020e-02f, -8.97994637e-03f, -2.84757791e-03f, -4.48509529e-02f,
  5.88494763e-02f, 2.84744911e-02f, -3.53237018e-02f, -1.59175787e-02f, 2.73378342e-02f, -6.91461377e-03f, -2.12094989e-02f, -3.92223075e-02f, 3.69167104e-02f, -6.55287579e-02f,
  5.51686715e-03f, 1.35487609e-03f, 3.72103006e-02f, 4.47652489e-02f, -6.52672201e-02f, -2.81102341e-02f, -3.52428667e-02f, 1.74004193e-02f, -4.17435579e-02f, 1.67837087e-02f,
  6.57415539e-02f, -9.08136275e-03f, -2.25351304e-02f, 2.25709956e-02f, 5.43631017e-02f, 6.13629073e-02f, -4.85735163e-02f, 1.94441609e-03f, 1.22495240e-03f, -7.02458546e-02f,
  -6.08490407e-02f, 4.56015207e-02f, -6.95909234e-03f, -7.03816488e-02f, 7.90364891e-02f, -1.38468919e-02f, -4.77874242e-02f, -5.33850081e-02f, 2.07686443e-02f, -1.59635376e-02f,
  -3.02004535e-02f, -6.46360517e-02f, -4.26363721e-02f, -1.96251981e-02f, 6.03807196e-02f, 3.72739285e-02f, -5.05468920e-02f, -3.55175547e-02f, -9.28058550e-02f, -3.59403752e-02f,
  -6.94480464e-02f, 1.21474206e-01f, 7.69197568e-02f, 9.57823768e-02f, 3.22761908e-02f, 1.54398844e-01f, -2.62365825e-02f, -1.51248109e-02f, 1.43084973e-01f, 1.49304852e-01f,
  -2.62097538e-01f, -1.67350695e-01f, -1.56111345e-01f, -1.34303823e-01f, -1.55995548e-01f, -5.73607087e-02f, -2.62411386e-01f, -3.39802429e-02f, -8.37803334e-02f, -3.39803360e-02f,
  3.81987728e-02f, 7.07808286e-02f, 5.24741672e-02f, 6.30024746e-02f, -7.57496953e-02f, -1.23721540e-01f, -1.84906289e-01f, -1.39798716e-01f, -8.26754887e-03f, -2.55984012e-02f,
  -1.28702000e-02f, -7.64150247e-02f, 1.37718581e-03f, -8.75513628e-02f, 6.69700280e-02f, -2.97250040e-02f, -2.31057145e-02f, -6.02404289e-02f, 1.81536395e-02f, 2.60354634e-02f,
  1.08571388e-01f, -2.25419566e-01f, -5.90714924e-02f, -4.84061204e-02f, 4.58088592e-02f, 2.77341325e-02f, -6.45766631e-02f, -3.12980451e-02f, -4.48934808e-02f, -4.31732535e-02f,
  8.09376761e-02f, 6.65635103e-03f, 1.06832478e-02f, 3.63937132e-02f, -7.41369128e-02f, 5.58042638e-02f, -2.49557290e-02f, -5.59912175e-02f, -5.44609055e-02f, -3.88282537e-03f,
  -4.81319521e-03f, -4.20030467e-02f, 2.39102934e-02f, 5.25774574e-03f, -7.93776382e-03f, 9.11341012e-02f, -3.73858660e-02f, -7.04036057e-02f, -3.02133076e-02f, 8.82374030e-03f,
  5.56410588e-02f, 3.78415920e-02f, 9.26152766e-02f, -6.87056631e-02f, 7.08127022e-02f, 5.91364726e-02f, 3.80010763e-03f, 7.56016895e-02f, -4.65122238e-02f, -1.35759423e-02f,
  4.43862826e-02f, -6.41348660e-02f, 1.72976591e-02f, -4.69113849e-02f, -2.34225392e-02f, -1.29677197e-02f, 1.12155704e-02f, 2.98254266e-02f, -5.41195460e-03f, 2.00346727e-02f,
  5.28660603e-02f, 7.56326839e-02f, -1.74319893e-02f, -1.97272301e-02f, -6.30553141e-02f, -8.19312334e-02f, 2.25752871e-02f, -2.49795821e-02f, 5.43139726e-02f, 1.02520902e-02f,
  1.25737160e-01f, 5.23049571e-03f, 1.20138852e-02f, 1.68748070e-02f, 2.71517187e-02f, 7.68055394e-02f, 2.94876006e-03f, 6.26386032e-02f, 8.53782892e-02f, 1.64005477e-02f,
  -4.66814972e-02f, 2.73513477e-02f, -7.18922988e-02f, 2.05859803e-02f, -6.30202815e-02f, -6.48256689e-02f, 3.92279029e-02f, -7.80449510e-02f, 8.68605226e-02f, -2.11008452e-02f,
  1.42032690e-02f, -8.01927783e-03f, -2.09793430e-02f, 1.70322321e-02f, 8.36002752e-02f, 1.41321085e-02f, -1.14863012e-02f, 5.69975702e-03f, -1.91453705e-03f, 2.90720239e-02f,
  1.08456723e-01f, 9.23804566e-02f, 3.33477050e-01f, -4.77306396e-02f, -1.29179945e-02f, 6.65517226e-02f, 1.33551762e-01f, 9.11291465e-02f, -9.60626602e-02f, 8.80620629e-02f,
  -5.37584675e-03f, -8.73810425e-02f, 5.21419235e-02f, 3.21484506e-02f, 7.19886795e-02f, 2.10323393e-01f, 1.57754898e-01f, 8.95464271e-02f, -1.91217382e-02f, -9.62057710e-02f,
  -1.47190809e-01f, -2.37966655e-04f, 4.55491506e-02f, 2.72517782e-02f, -3.22654285e-02f, -6.86572865e-02f, 8.46400410e-02f, -3.17505412e-02f, -7.74801150e-02f, 4.72373180e-02f,
  1.23575628e-01f, 1.40801713e-01f, 4.18676771e-02f, -1.01368576e-01f, -5.29184379e-02f, 7.02389516e-03f, -3.82040702e-02f, -4.26519662e-02f, -4.78007048e-02f, 1.75647084e-02f,
  -4.69936132e-02f, -1.04962466e-02f, 3.68777942e-03f, -6.38428628e-02f, -5.27559817e-02f, -3.61259207e-02f, -3.52150649e-02f, 2.09291745e-02f, 1.33939803e-01f, -7.58817187e-04f,
  -6.53025061e-02f, 1.06229074e-03f, 1.17303692e-01f, 3.10397483e-02f, 1.24396093e-01f, 7.52909258e-02f, 7.27566406e-02f, 3.41643691e-02f, -1.62403658e-02f, -3.83049957e-02f,
  2.12118216e-02f, 2.30060034e-02f, 6.82407320e-02f, 3.94850746e-02f, -5.48994914e-02f, -7.60833696e-02f, 7.55356848e-02f, -3.08491811e-02f, 7.18210042e-02f, -3.73107977e-02f,
  3.94943953e-02f, 4.25979421e-02f, -3.96679901e-02f, 6.94443658e-02f, 4.99753840e-02f, -3.20511013e-02f, 4.01354581e-02f, 6.90034181e-02f, -7.72004575e-02f, -3.39401625e-02f,
  5.98434508e-02f, -3.46985571e-02f, -5.62403202e-02f, 3.75061892e-02f, 8.57686922e-02f, 5.86433485e-02f, -1.48997484e-02f, 5.60081527e-02f, -3.72311845e-02f, 7.04111578e-03f,
  -1.86114773e-01f, 1.89733058e-01f, 3.52563150e-02f, -5.79572225e-04f, -3.70493531e-02f, -2.32170727e-02f, 2.42538955e-02f, 2.16383711e-02f, -2.12035025e-03f, -5.39160781e-02f,
  3.84593243e-03f, -5.60608134e-02f, -3.38225625e-02f, -5.07123210e-02f, 4.97282706e-02f, -3.79160941e-02f, 1.04634147e-02f, -3.93632725e-02f, -3.63079756e-02f, 2.73445081e-02f,
  7.45315757e-03f, 2.48556230e-02f, -8.90201330e-02f, 7.50844255e-02f, -1.07071377e-01f, -9.78427753e-03f, -6.78434670e-02f, -7.83402771e-02f, 4.65844572e-02f, -9.37698931e-02f,
  -1.63312256e-01f, 1.28107388e-02f, -2.92969912e-01f, -1.78427592e-01f, -1.28254190e-01f, -1.32944852e-01f, -5.57428934e-02f, 8.75774492e-03f, 7.97359925e-03f, 4.55698520e-02f,
  1.26304314e-01f, 8.77171084e-02f, 2.26482544e-02f, 6.79761171e-02f, -1.76300585e-01f, -6.34142235e-02f, -1.15206614e-01f, -2.60441095e-01f, -1.06045768e-01f, -7.94061571e-02f,
  2.91239638e-02f, -1.48179069e-01f, -1.82675540e-01f, -9.49461609e-02f, 7.60313077e-03f, 1.18016765e-01f, -7.45200589e-02f, -1.07825451e-01f, -9.37847421e-02f, -5.75177707e-02f,
  5.65603711e-02f, -7.29243457e-02f, 2.85071377e-02f, 4.02803943e-02f, 2.62791365e-02f, 2.68869493e-02f, -6.71098381e-02f, -4.58540656e-02f, 4.28426974e-02f, -7.74576515e-02f,
  6.35065138e-02f, 3.15398350e-02f, -4.28199917e-02f, 1.23472912e-02f, -2.22265907e-02f, -5.39693981e-02f, -5.24445176e-02f, -9.44098681e-02f, -2.33928375e-02f, 4.52683121e-03f,
  2.95229312e-02f, -9.56012160e-02f, -7.83885568e-02f, 9.22923610e-02f, 4.44278233e-02f, -9.01513696e-02f, 6.93488717e-02f, 3.42579484e-02f, -9.92863718e-03f, 1.89371817e-02f,
  -1.06306979e-02f, 3.10508348e-02f, 1.31384395e-02f, 2.56737173e-02f, 3.58055867e-02f, 5.47308065e-02f, 1.83352213e-02f, 3.99212129e-02f, -3.40614021e-02f, 5.37387691e-02f,
  5.52111231e-02f, -4.19878848e-02f, -6.93332497e-03f, -4.13272381e-02f, 1.78333689e-02f, -6.64229542e-02f, -5.71901817e-03f, 3.55496667e-02f, -2.30108527e-03f, -4.65861373e-02f,
  5.77988550e-02f, -1.52499266e-02f, 2.32181344e-02f, 5.55417165e-02f, 5.49496748e-02f, 2.29805950e-02f, -5.91435097e-02f, 3.87014672e-02f, 5.40735573e-02f, -8.93562064e-02f,
  2.12025851e-01f, -1.62146464e-01f, 7.22859055e-02f, 2.52025425e-02f, 7.29046669e-03f, 9.37442780e-02f, 1.00890681e-01f, 1.73303001e-02f, 2.60048658e-02f, 2.80241445e-02f,
  4.71127257e-02f, -1.86233670e-02f, 7.34480396e-02f, 5.36145642e-02f, 6.47272021e-02f, -5.79508953e-02f, -4.71987901e-03f, 4.68843430e-02f, -2.30569784e-02f, 9.72319096e-02f,
  -1.99339390e-02f, 7.33053163e-02f, -4.18972000e-02f, 3.79466638e-02f, -5.15601002e-02f, 5.94660314e-03f, 5.36251962e-02f, 6.72072619e-02f, -1.40663059e-02f, 1.13285050e-01f,
  -9.07363445e-02f, 3.40000354e-02f, 6.61868379e-02f, -2.03978404e-01f, 7.55570014e-04f, 1.10575043e-01f, 1.73383266e-01f, -1.18549438e-02f, -7.53413215e-02f, 5.97845614e-02f,
  1.05561756e-01f, 1.44589525e-02f, -3.41726243e-02f, 1.28013315e-02f, -6.44115284e-02f, 8.96115452e-02f, -7.33511001e-02f, -3.13941129e-02f, -1.68179981e-02f, 9.00659245e-03f,
  -8.82068276e-02f, -9.27811041e-02f, -1.01634048e-01f, -8.81592035e-02f, -3.07993796e-02f, 4.36027125e-02f, -1.02966219e-01f, -1.08154558e-01f, 8.07391778e-02f, -2.03648776e-01f,
  1.09005675e-01f, -3.78203988e-02f, 8.47497880e-02f, 6.62866561e-03f, -7.66049325e-02f, 7.92843848e-02f, -1.96802169e-02f, -1.68127846e-03f, -3.59578393e-02f, -7.75153115e-02f,
  -5.91905564e-02f, 2.51259580e-02f, -1.10486552e-01f, -5.86971268e-03f, 4.76244912e-02f, 1.15729440e-02f, 2.93544540e-03f, -8.37627277e-02f, 2.18501836e-02f, -3.30125950e-02f,
  -7.56395459e-02f, -2.66589392e-02f, 8.88408627e-03f, 1.09505408e-01f, 6.65341467e-02f, 3.73686366e-02f, 7.59617835e-02f, -4.69677262e-02f, 1.09030038e-01f, -3.91674675e-02f,
  -1.50450123e-02f, -7.21732527e-03f, -3.50489430e-02f, 2.99412850e-02f, 2.59406529e-02f, 1.06238993e-02f, -1.01697311e-01f, 5.27854450e-02f, -7.96003118e-02f, -1.04061566e-01f,
  5.97929768e-02f, 5.29692918e-02f, 1.32701732e-02f, -1.85298417e-02f, -7.01396689e-02f, 4.02942486e-02f, 2.53915768e-02f, 9.12187342e-03f, -6.51717372e-03f, -5.47708087e-02f,
  4.41692630e-03f, -5.53446598e-02f, 4.29707915e-02f, -1.10687595e-02f, -5.18286824e-02f, -1.16168715e-01f, 4.70755361e-02f, -5.61164655e-02f, -7.69237429e-02f, -8.98950826e-03f,
  1.51443183e-01f, 4.58235592e-02f, 2.04452649e-02f, -9.12535042e-02f, 1.36858464e-04f, -5.03867902e-02f, -1.86062045e-02f, -4.54854518e-02f, -4.83668037e-02f, 1.28728608e-02f,
  2.00682562e-02f, 6.45321980e-02f, 7.99361318e-02f, -6.46222904e-02f, 9.68597606e-02f, 5.49377054e-02f, 1.94237474e-02f, 4.39234972e-02f, 1.91332754e-02f, -2.92914715e-02f,
  -9.47131440e-02f, 5.36918491e-02f, 1.58016849e-02f, 1.32627800e-01f, 9.70709696e-02f, 6.70017898e-02f, 9.40813944e-02f, 1.25962362e-01f, 1.45824537e-01f, 1.97124809e-01f,
  4.83089447e-01f, 1.52717665e-01f, 9.42388698e-02f, 5.20858075e-03f, -2.09684819e-02f, -4.90131527e-02f, 1.17863260e-01f, -2.74783000e-02f, -4.16704789e-02f, 1.35464504e-01f,
  -9.30768996e-02f, -1.09368928e-01f, -1.40518248e-01f, -1.66402772e-01f, 1.66157726e-02f, 8.47382657e-03f, -4.46467474e-03f, -5.46277352e-02f, -4.12824238e-03f, -1.37882099e-01f,
  -7.89292529e-03f, 1.31239265e-01f, 1.73353851e-01f, 2.23939028e-02f, -2.07869522e-02f, -3.98898002e-04f, 9.02732015e-02f, 8.00548643e-02f, -9.63388849e-03f, -3.23403301e-03f,
  4.47543077e-02f, 8.48983154e-02f, -1.53711915e-01f, -4.20339070e-02f, -2.21525389e-03f, 4.86790612e-02f, 9.02374834e-02f, 1.03753619e-02f, -4.06814180e-03f, 3.53983305e-02f,
  6.15397878e-02f, 6.75988421e-02f, 7.22980592e-03f, -8.29145592e-03f, 4.68399897e-02f, 2.20257118e-02f, 7.41618639e-03f, -5.62390238e-02f, 3.77047085e-03f, 5.10263816e-02f,
  -2.00696737e-02f, -3.07007935e-02f, 5.13899364e-02f, 2.75470316e-03f, -6.45604655e-02f, 4.84286696e-02f, -3.82735841e-02f, 6.68378174e-02f, 1.35527030e-02f, 2.24344313e-01f,
  -2.23607896e-03f, -3.35532799e-02f, 2.42788275e-03f, 8.55516121e-02f, 3.88642140e-02f, -7.33493492e-02f, -4.62788483e-03f, 6.49223626e-02f, -2.35816557e-02f, 9.07907635e-02f,
  -9.42304451e-03f, -5.58421621e-03f, -9.28157121e-02f, 9.87448618e-02f, 4.99278568e-02f, -1.12215420e-02f, 2.42093019e-03f, -2.28181351e-02f, -5.36629045e-03f, 5.77658936e-02f,
  -3.58090848e-02f, -5.14377020e-02f, 1.16564427e-02f, -6.97910264e-02f, -1.08019821e-02f, 1.24626735e-03f, -9.89934243e-03f, 4.54285219e-02f, 9.85849649e-02f, 2.19581965e-02f,
  2.13045720e-02f, -1.44277588e-01f, -9.42490250e-03f, -5.15533760e-02f, -4.73454036e-02f, -9.09852907e-02f, -8.25986564e-02f, 2.36889292e-02f, -2.01046448e-02f, 3.92133482e-02f,
  -9.66721997e-02f, -7.71080703e-03f, 9.60594509e-03f, -6.42178282e-02f, 3.35770398e-02f, 5.14186807e-02f, 1.12070434e-01f, -7.52058625e-02f, -6.10452294e-02f, 7.27276281e-02f,
  -1.46094756e-02f, 7.70416781e-02f, -2.18114890e-02f, 1.41178770e-02f, 5.60526587e-02f, 3.80402207e-02f, -5.00119710e-03f, 6.59499094e-02f, 2.72525325e-02f, 2.87822366e-01f,
  -3.45590651e-01f, 7.81157473e-03f, -4.44812961e-02f, 9.02667362e-03f, -3.30787059e-03f, 8.75958428e-02f, -4.40788642e-02f, -2.13948581e-02f, -6.16131313e-02f, -5.98046221e-02f,
  6.92848908e-03f, 2.05187313e-02f, -1.34019153e-02f, -1.09973794e-03f, -1.61424994e-01f, 7.94790313e-02f, 3.66558693e-02f, -3.23899253e-03f, -1.68849796e-01f, 5.08225560e-02f,
  8.63333344e-02f, -1.10521801e-01f, -7.99294487e-02f, 3.55276726e-02f, 1.29665077e-01f, -4.13185470e-02f, 1.20095097e-01f, 9.20555890e-02f, 1.02287643e-01f, 1.52208030e-01f,
  -5.23049012e-02f, -7.93306455e-02f, 1.04054561e-04f, -3.24699767e-02f, -2.08171899e-03f, -8.08227509e-02f, -9.01831761e-02f, -7.56299645e-02f, 6.35817572e-02f, -6.87266365e-02f,
  -4.54933606e-02f, 7.09625781e-02f, 2.61751246e-02f, -4.75099832e-02f, -9.99136791e-02f, -4.23970073e-02f, -1.76879857e-02f, -5.29719815e-02f, -1.15206450e-01f, 5.47964722e-02f,
  7.94199705e-02f, -1.25529720e-02f, -1.22466013e-01f, -4.72513698e-02f, -7.48045594e-02f, -5.73333018e-02f, -7.78362453e-02f, -9.40768868e-02f, -1.45696238e-01f, -1.80302143e-01f,
  -3.63129005e-03f, 2.11346354e-02f, -2.56332830e-02f, 2.86491346e-02f, -7.28982762e-02f, 1.95478834e-02f, -3.48995402e-02f, 7.50479326e-02f, -2.52431743e-02f, 1.52466481e-03f,
  4.49795537e-02f, -2.99258213e-02f, -1.95794404e-02f, -4.56555933e-02f, -5.36541939e-02f, -7.02081993e-03f, 4.97381724e-02f, 7.08924755e-02f, -9.41713993e-03f, -1.35679729e-02f,
  -7.41417659e-03f, 5.08474037e-02f, 8.73740297e-03f, -3.94174680e-02f, 3.06271482e-02f, -7.77686238e-02f, -4.94483337e-02f, 1.13620991e-02f, -2.52610818e-03f, -1.59056019e-02f,
  -1.13089837e-01f, 5.42259924e-02f, -7.82644302e-02f, -1.12411372e-01f, -3.91284153e-02f, -5.71892969e-02f, 4.34169099e-02f, -3.30947861e-02f, 4.33904614e-04f, -3.59312701e-03f,
  5.65477880e-03f, 1.75186973e-02f, -6.24088421e-02f, -7.79458955e-02f, 1.45220105e-02f, -1.31004259e-01f, -8.55768770e-02f, -8.09233412e-02f, 6.05899282e-02f, -9.94875580e-02f,
  -3.81807350e-02f, -1.71132550e-01f, -2.00542986e-01f, -1.52013719e-01f, -6.56678528e-02f, -7.96718076e-02f, 1.21476986e-02f, -1.22243136e-01f, -1.29842088e-01f, -1.68963090e-01f,
  8.99613574e-02f, 4.11079936e-02f, -1.66160405e-01f, 4.61405665e-02f, -1.24854214e-01f, -8.97928551e-02f, -5.01955934e-02f, 1.08125411e-01f, 1.27513651e-02f, 7.47822151e-02f,
  -5.35651334e-02f, -4.49731909e-02f, 5.78750297e-02f, 2.70034149e-02f, 8.66126716e-02f, -9.86256674e-02f, 2.66224109e-02f, 5.42788841e-02f, -4.96056043e-02f, 1.20840017e-02f,
  -1.88246612e-02f, -6.07047267e-02f, 7.61423707e-02f, 4.30818275e-02f, -2.45103259e-02f, -3.93449366e-02f, -6.99987914e-03f, -1.67903546e-02f, 1.92346498e-02f, -2.26939186e-01f,
  -2.09468037e-01f, -7.23707080e-02f, -5.27891405e-02f, 9.53426883e-02f, -1.91801824e-02f, -3.01658511e-02f, -7.79361874e-02f, 7.75602534e-02f, 8.57145637e-02f, -2.63186172e-02f,
  3.24609019e-02f, 3.36815491e-02f, -7.28329793e-02f, 4.68085557e-02f, -1.52989440e-02f, 5.72109036e-02f, 6.99501410e-02f, 2.75848488e-05f, 1.86662581e-02f, -2.15373803e-02f,
  -2.36217920e-02f, -7.30080754e-02f, -1.91413742e-02f, 8.68134126e-02f, -5.39085362e-03f, 4.24141716e-03f, -1.07293151e-01f, -6.63982108e-02f, 4.40659635e-02f, 3.03330589e-02f,
  -4.35980782e-02f, -6.58822954e-02f, 3.58152762e-02f, 6.49564192e-02f, -7.62448683e-02f, 1.27208726e-02f, -9.84393209e-02f, 6.37267902e-02f, -6.91485777e-02f, 6.34194091e-02f,
  -2.36525275e-02f, -7.42469057e-02f, 3.23682986e-02f, -4.91140150e-02f, 1.40095307e-02f, -1.38331065e-02f, -3.88818942e-02f, 2.20012050e-02f, -2.91056968e-02f, 1.68080609e-02f,
  -3.85776162e-02f, -1.39917620e-03f, -4.33616117e-02f, -2.11720634e-02f, -3.50092873e-02f, -7.90900737e-02f, -3.06268316e-02f, 4.26629186e-02f, -6.46870881e-02f, 1.89759098e-02f,
  8.67119879e-02f, 1.79250732e-01f, -9.97894928e-02f, 2.62151118e-02f, -2.34995745e-02f, 9.96039361e-02f, -4.45962854e-04f, 2.46951915e-02f, -7.63559788e-02f, -5.92002794e-02f,
  8.26872289e-02f, 8.37362707e-02f, 8.18004459e-02f, 1.22133931e-02f, -1.14749912e-02f, 1.01522513e-01f, -1.25351772e-02f, 5.77351544e-03f, -1.72056239e-02f, 1.69719497e-04f,
  8.36564079e-02f, -2.55843811e-02f, 3.98026705e-02f, 5.16170673e-02f, -5.22780372e-03f, 9.14980769e-02f, 2.55631306e-03f, 2.76773199e-02f, 6.42767623e-02f, 7.22962990e-02f,
  5.15610397e-01f, -2.63546431e-03f, -2.44445577e-01f, 1.54046878e-01f, -2.14349896e-01f, -1.92080766e-01f, -2.01746315e-01f, 1.84336416e-02f, 1.58937216e-01f, 3.77763622e-02f,
  -3.03464625e-02f, 7.30836168e-02f, 1.31608233e-01f, -1.32575277e-02f, 1.32087227e-02f, -2.06071958e-02f, -1.67424738e-01f, 4.62555997e-02f, 3.95973548e-02f, 2.55897958e-02f,
  3.26150400e-03f, 1.11463979e-01f, 1.34536013e-01f, -2.07193904e-02f, -7.59135708e-02f, -3.52268703e-02f, -1.65047631e-01f, -2.35189684e-02f, -4.37459014e-02f, 4.83552851e-02f,
  -1.01313721e-02f, -1.81570312e-03f, -8.82919058e-02f, 9.37544107e-02f, -1.11648753e-01f, 8.49695411e-03f, 8.03273078e-03f, 2.61005126e-02f, -2.82152137e-03f, 5.70163354e-02f,
  5.70775904e-02f, -3.58498916e-02f, -3.67134102e-02f, 1.01712802e-02f, -2.43766215e-02f, 2.37910356e-02f, 7.75936618e-02f, 8.82648677e-02f, -3.27740498e-02f, -6.39978573e-02f,
  -6.32873625e-02f, -3.24685499e-02f, 3.43029685e-02f, -1.07240565e-01f, -3.61696221e-02f, 4.82598282e-02f, -5.99904470e-02f, 3.24376300e-02f, -3.10961567e-02f, 3.86816785e-02f,
  5.80289634e-03f, -1.18917413e-02f, 1.60965435e-02f, -4.97075431e-02f, 4.75183968e-03f, 1.17037212e-02f, -5.71704470e-03f, -5.37102148e-02f, 3.80943790e-02f, -4.14817370e-02f,
  4.57274728e-03f, 1.14742573e-02f, -1.28797200e-02f, -3.92731912e-02f, 2.11408008e-02f, -1.44395009e-02f, -7.64511824e-02f, 2.52497662e-02f, 1.71613675e-02f, 1.18401228e-02f,
  6.60158768e-02f, -9.95048136e-03f, 8.01732112e-03f, -6.70433342e-02f, -6.98388293e-02f, 5.13891056e-02f, -4.17111106e-02f, -1.58875901e-02f, 3.29641737e-02f, 6.42995015e-02f,
  -5.93427662e-03f, -8.70299712e-02f, 8.17675516e-02f, 6.56968951e-02f, -1.13763064e-01f, 5.80274649e-02f, 1.58470366e-02f, 6.79746084e-03f, -5.23076132e-02f, 5.97789548e-02f,
  2.16454864e-02f, 8.47901180e-02f, 5.88771887e-03f, -8.81247874e-03f, 9.91328061e-03f, -4.63398639e-03f, 8.48700292e-03f, -4.21276176e-03f, 4.99246418e-02f, 9.14097298e-03f,
  -7.18200579e-02f, 4.11465727e-02f, -3.12815532e-02f, -3.45445313e-02f, 1.87560692e-02f, 4.85805050e-02f, -7.10659027e-02f, -6.87081367e-02f, 1.58217791e-02f, 1.23329446e-01f,
  3.40923935e-01f, 1.78845301e-01f, 5.81722930e-02f, -2.62058200e-03f, -6.21787691e-03f, -1.07136063e-01f, -6.55154139e-02f, -5.17815053e-02f, 3.75575423e-02f, -1.38760945e-02f,
  2.44078394e-02f, -5.46708293e-02f, -5.45008257e-02f, 3.59088294e-02f, 3.69663350e-02f, 3.78897823e-02f, 9.86404438e-03f, -4.01422754e-02f, -7.70348758e-02f, -9.77506191e-02f,
  -1.62679389e-01f, -8.45790505e-02f, -7.86788762e-02f, -1.05723157e-04f, -8.51214956e-03f, 4.43415865e-02f, 6.75678700e-02f, 4.56552841e-02f, 9.94598120e-02f, 8.28601718e-02f,
  2.94047832e-01f, 1.08064756e-01f, 4.85155266e-03f, -8.57482105e-03f, 2.77791508e-02f, 5.36977947e-02f, -2.96899173e-02f, -5.02079502e-02f, 7.61282742e-02f, 1.10207811e-01f,
  9.50629415e-04f, 7.66279474e-02f, -3.26559879e-02f, 3.12306136e-02f, -4.36035432e-02f, 3.67964953e-02f, -3.61811221e-02f, 4.78084125e-02f, -5.21339178e-02f, 8.36387053e-02f,
  -3.66741717e-02f, 3.16689536e-02f, 1.44251511e-01f, -7.93367475e-02f, -1.16666686e-02f, -3.01036406e-02f, 1.35405421e-01f, 1.40335158e-01f, 1.26833737e-01f, 2.44523108e-01f,
  1.51912225e-02f, -7.28822080e-03f, 4.17857170e-02f, -2.99621243e-02f, 4.72433344e-02f, 3.05216033e-02f, -2.91616544e-02f, 2.72491071e-02f, -7.54968524e-02f, 2.00798009e-02f,
  -7.94043615e-02f, -3.71086807e-03f, -1.09692879e-01f, 4.86404411e-02f, -5.84864020e-02f, -6.14177622e-03f, 3.66914719e-02f, -4.12131213e-02f, 5.24631105e-02f, 1.34396506e-02f,
  2.81506404e-02f, 7.69104064e-02f, -7.89564922e-02f, 3.13798040e-02f, -2.39756312e-02f, 3.60010229e-02f, 7.10974261e-03f, -1.92357339e-02f, -5.51720560e-02f, -1.89494845e-02f,
  9.92861688e-02f, -7.68032297e-02f, 1.66802272e-01f, -2.05462649e-02f, 6.63598850e-02f, 1.89408101e-02f, 9.84237567e-02f, -4.32908162e-02f, 2.86460202e-02f, 9.58459750e-02f,
  -5.47331618e-03f, 2.64452193e-02f, 6.93423848e-04f, -5.40834968e-04f, -8.11209381e-02f, -4.95341606e-02f, -5.05535118e-02f, -4.29635774e-03f, -1.03574090e-01f, -4.74412693e-03f,
  -1.31292760e-01f, -3.82003151e-02f, 1.11171573e-01f, 8.52067545e-02f, -2.96681579e-02f, 6.30645780e-03f, 9.67451110e-02f, 1.06981583e-01f, 1.62969723e-01f, 1.38027146e-01f,
  -5.27009666e-02f, 1.93083242e-01f, -5.76984175e-02f, 3.38269025e-02f, -1.07031368e-01f, -1.70524761e-01f, -1.88246250e-01f, 6.29631281e-02f, -2.81045903e-02f, 4.10170294e-02f,
  4.87063900e-02f, 1.39205977e-01f, 1.44087940e-01f, 1.23762839e-01f, 5.16099297e-02f, -8.38815421e-02f, -7.09782690e-02f, -1.08036786e-01f, -1.09818578e-01f, -1.75332408e-02f,
  -4.48651332e-03f, 8.40575024e-02f, 9.50367898e-02f, 6.63619414e-02f, 5.88617772e-02f, -3.31052020e-02f, 6.84372410e-02f, 4.79077958e-02f, 5.46781253e-03f, 1.17790662e-01f,
  1.52975470e-01f, 1.31597698e-01f, -1.26434058e-01f, 4.63628732e-02f, 7.29482770e-02f, 4.73308191e-03f, 4.29984815e-02f, 1.16862841e-01f, 5.03597520e-02f, -3.18520591e-02f,
  -2.39345711e-02f, 2.24278457e-02f, -4.18441258e-02f, -7.89550096e-02f, -5.97733259e-02f, -5.80948666e-02f, 1.14103690e-01f, 3.06287780e-02f, 1.24243572e-01f, 1.16449781e-01f,
  -4.26224433e-03f, 1.13889147e-02f, 6.92215785e-02f, -3.37677039e-02f, 6.04593242e-03f, 5.91134652e-02f, 1.72338765e-02f, -4.59977277e-02f, -2.04401966e-02f, 6.49615303e-02f,
  -6.87176436e-02f, 2.01331023e-02f, -8.17256942e-02f, 8.36680755e-02f, -7.50572383e-02f, -3.99353988e-02f, -2.66402420e-02f, 3.47606465e-02f, -6.26684874e-02f, 3.61753404e-02f,
  5.51864281e-02f, -1.77482143e-02f, -6.02394789e-02f, -1.26856817e-02f, 7.79912844e-02f, -9.04124901e-02f, -4.22669249e-03f, -3.09419334e-02f, -5.58943814e-03f, 8.21414366e-02f,
  4.32458743e-02f, 2.64909882e-02f, 7.91687667e-02f, 3.36331055e-02f, 6.87698573e-02f, 1.55338719e-02f, -3.86994295e-02f, 4.06695902e-02f, -6.03635497e-02f, 2.19984036e-02f,
  5.68208732e-02f, -1.09406561e-01f, -9.42089781e-03f, -7.48287961e-02f, -1.39897224e-02f, 9.94008407e-02f, -4.04166616e-02f, -5.76759269e-03f, 2.05665138e-02f, 3.44058163e-02f,
  -8.94368514e-02f, 2.88872048e-03f, 8.16923380e-02f, -3.99732515e-02f, -4.78280783e-02f, 9.33141541e-03f, -4.68311831e-02f, -7.13954195e-02f, -2.50039659e-02f, 1.91670582e-02f,
  -7.06388876e-02f, -1.40239730e-01f, -1.04100637e-01f, 1.30571034e-02f, 2.43486520e-02f, -1.50951967e-01f, -7.37916958e-03f, -1.65170543e-02f, -7.11131617e-02f, 4.01847670e-03f,
  -2.07953781e-01f, 1.04585879e-01f, 2.73424953e-01f, -2.14998707e-01f, -1.53277278e-01f, -3.86502072e-02f, 6.55767694e-02f, 3.68433073e-02f, -7.86724538e-02f, -5.67319095e-02f,
  -4.88473997e-02f, -1.87674612e-01f, 5.45239337e-02f, 1.28046721e-01f, 1.54298231e-01f, 1.04367867e-01f, 1.12240247e-01f, 1.20932303e-01f, 1.69778280e-02f, -6.60514906e-02f,
  -1.83748811e-01f, -6.99056163e-02f, -6.05835319e-02f, 5.73078021e-02f, -6.28437176e-02f, -7.28384554e-02f, -1.32117243e-02f, -9.10035372e-02f, 6.76575601e-02f, -1.23245448e-01f,
  1.30730152e-01f, -5.11059025e-03f, 4.18858230e-03f, -9.86767709e-02f, -6.74612895e-02f, 2.84813531e-02f, -1.08962670e-01f, -6.98751062e-02f, 4.41729240e-02f, 2.38711014e-02f,
  -9.30754766e-02f, -2.50675287e-02f, 1.18114110e-02f, 5.39804585e-02f, 1.80188473e-02f, -4.23791371e-02f, 1.08549647e-01f, 1.33442581e-01f, 7.78260380e-02f, -3.54393125e-02f,
  -5.80140240e-02f, 1.20173478e-02f, 6.52905256e-02f, 9.56752338e-03f, 1.04334973e-01f, 1.10555487e-03f, 1.53102547e-01f, 1.30797163e-01f, 1.75159946e-01f, -5.29104210e-02f,
  -3.89432795e-02f, 2.70695742e-02f, 6.71061948e-02f, -2.19838545e-02f, -8.98585021e-02f, 2.38397606e-02f, 2.07065931e-03f, -4.54733893e-02f, 5.05467281e-02f, 1.13887824e-02f,
  -4.92195226e-02f, -4.43174280e-02f, -1.36376973e-02f, 2.33280621e-02f, -3.49266753e-02f, 2.89317928e-02f, -3.02736927e-02f, -4.71616816e-03f, -4.71548270e-03f, -6.78632632e-02f,
  6.30788784e-03f, 1.88529193e-02f, -6.91452324e-02f, 1.92185887e-03f, 8.40213299e-02f, 4.77133542e-02f, 2.98211798e-02f, 3.45201232e-02f, -9.62149650e-02f, -2.17834190e-02f,
  -2.02741046e-02f, 1.23593666e-01f, -1.20589912e-01f, 4.03988473e-02f, -7.73173124e-02f, 3.90671007e-02f, 5.16747534e-02f, 6.83944970e-02f, 1.05658490e-02f, 3.13876942e-02f,
  4.75858301e-02f, 3.53909396e-02f, 1.00354254e-02f, -1.80670031e-04f, -4.65175398e-02f, -7.73164630e-02f, -9.35363472e-02f, 6.59873933e-02f, 4.10076650e-03f, -5.13464697e-02f,
  -4.49049510e-02f, -8.26027095e-02f, -9.58409980e-02f, 1.23094305e-01f, 4.42402363e-02f, -7.33228624e-02f, -3.11052203e-02f, 5.68760075e-02f, 2.39908546e-02f, -1.51524208e-02f,
  -1.49859041e-01f, 2.46219665e-01f, 1.13599449e-01f, -3.37109938e-02f, 6.34517297e-02f, 8.48078132e-02f, 2.62338758e-01f, 2.62113810e-02f, -1.36044905e-01f, 4.37804200e-02f,
  1.40202977e-02f, -1.64570227e-01f, -1.47325784e-01f, -7.87469074e-02f, -2.06123479e-02f, 1.40680149e-01f, 3.22924778e-02f, -5.92259839e-02f, -2.11392149e-01f, -8.04126039e-02f,
  4.08509411e-02f, -1.19691923e-01f, -8.46612453e-03f, 3.86920734e-03f, 6.61764890e-02f, -7.92118087e-02f, 5.50131798e-02f, -4.17230502e-02f, -4.77849459e-03f, 3.13318633e-02f,
  1.60663977e-01f, 5.57014644e-02f, -3.55528630e-02f, -6.44772574e-02f, -9.86981392e-03f, 3.69776203e-03f, 1.49904415e-02f, 9.41747576e-02f, -6.70529902e-02f, 7.27317259e-02f,
  1.91882662e-02f, -4.64303419e-02f, 2.30142046e-02f, 3.58044170e-04f, 1.01444736e-01f, -5.79767153e-02f, -3.90678346e-02f, -1.22848183e-01f, -6.87545612e-02f, 3.64345461e-02f,
  -8.90475437e-02f, -1.80046130e-02f, 4.59901057e-02f, 8.09223652e-02f, -5.94190671e-04f, -1.71951130e-01f, 7.54859746e-02f, -2.31422111e-02f, -8.79744515e-02f, 5.55575378e-02f,
  -3.12701799e-02f, 2.34693252e-02f, 2.92233210e-02f, -3.00964732e-02f, -1.91323981e-02f, 5.89465462e-02f, 2.82499567e-02f, 2.43232641e-02f, -1.61075778e-02f, -2.75017321e-02f,
  -7.13325366e-02f, -2.43401024e-02f, -3.60972807e-02f, 1.22061536e-01f, -4.11131158e-02f, 3.66459154e-02f, -3.95343751e-02f, 7.31155574e-02f, -6.83047250e-02f, -1.05091641e-02f,
  -6.19339310e-02f, 2.85261162e-02f, 9.61267948e-02f, -9.08541083e-02f, -3.63334902e-02f, -7.49471635e-02f, 4.62557934e-02f, -7.27959201e-02f, 3.95308249e-03f, 3.87095176e-02f,
  2.32445955e-01f, -1.19276062e-01f, 7.84275234e-02f, -4.03569043e-02f, 7.59313926e-02f, -3.27677280e-03f, 7.18511641e-02f, 3.70183438e-02f, 2.22146418e-02f, -9.02030468e-02f,
  6.20725788e-02f, -4.98565659e-02f, 1.18812241e-01f, 9.24180914e-03f, -7.96964616e-02f, 3.14898230e-02f, 6.11191131e-02f, -7.89411739e-02f, -2.84252502e-02f, -2.79859938e-02f,
  4.94946390e-02f, 1.03819884e-01f, 9.08153653e-02f, 9.70303193e-02f, -5.53590283e-02f, -8.60280693e-02f, 2.22201273e-02f, 5.09581715e-02f, -6.68761320e-03f, 2.57765025e-01f,
  3.37569088e-01f, -1.90141127e-01f, -1.53595805e-01f, -7.94865116e-02f, -9.40207094e-02f, 1.01583019e-01f, -5.16568385e-02f, 1.46963596e-01f, -4.09648381e-02f, -1.15135454e-01f,
  1.18107311e-02f, 1.70848802e-01f, 1.00601338e-01f, -2.00234372e-02f, 4.56649140e-02f, -1.72037020e-01f, -2.89822727e-01f, -8.99900496e-02f, 1.50494754e-01f, 1.80354163e-01f,
  -3.22599895e-03f, 9.80239287e-02f, 4.11258414e-02f, 9.24936607e-02f, -2.10990101e-01f, -1.80646200e-02f, -1.62758499e-01f, -1.54568985e-01f, -1.29714057e-01f, -3.11795950e-01f,
  -2.09143236e-01f, 7.56325349e-02f, -4.69812565e-02f, -2.93375570e-02f, 7.77570484e-03f, 8.07940289e-02f, 1.12795341e-03f, -8.03282708e-02f, 9.96918883e-03f, 3.83535475e-02f,
  2.14385875e-02f, -2.41875602e-03f, 6.47363216e-02f, 3.26648913e-02f, 2.21767928e-02f, -3.06181423e-02f, -8.85222480e-03f, -2.05346048e-02f, 6.45210743e-02f, -2.14940850e-02f,
  -1.77893806e-02f, 4.88091633e-02f, 3.89474519e-02f, 5.68431057e-02f, -9.60700121e-03f, -5.25738858e-02f, -6.10844865e-02f, 2.01945938e-02f, 2.22130157e-02f, 2.09312923e-02f,
  -4.01832946e-02f, 1.71774141e-02f, 1.78166665e-02f, -3.13851684e-02f, 1.17270870e-03f, 4.71938923e-02f, -5.48852198e-02f, -2.07772646e-02f, 8.92398357e-02f, -1.76020805e-03f,
  -3.50775160e-02f, -9.43564437e-03f, 2.93445373e-05f, -2.62138471e-02f, -4.01434787e-02f, -5.04148863e-02f, 9.72014666e-02f, 2.00573597e-02f, 1.37028901e-03f, -4.46767397e-02f,
  -2.78782453e-02f, 3.00447233e-02f, -2.64210105e-02f, 5.27391322e-02f, -1.90689322e-02f, -1.31736845e-02f, 8.11773073e-03f, 1.35452393e-02f, 4.64711525e-02f, 7.69823277e-03f,
  1.33106947e-01f, 1.26490131e-01f, -1.29163206e-01f, 6.41826317e-02f, -7.59206936e-02f, -4.96519431e-02f, 3.19478028e-02f, -3.84612344e-02f, -5.35504110e-02f, -1.34531036e-02f,
  9.45901778e-03f, 5.08049838e-02f, -5.40256687e-02f, -5.07800244e-02f, 9.75340530e-02f, 2.00376082e-02f, -6.17858134e-02f, -2.42981203e-02f, -6.26204237e-02f, -1.14757098e-01f,
  -9.16596279e-02f, 5.24776578e-02f, 1.18385993e-01f, -3.07753086e-02f, 3.13863494e-02f, 7.52695352e-02f, 5.05883023e-02f, 7.11702332e-02f, 1.85061604e-01f, 7.90262520e-02f,
  2.60926306e-01f, 1.28823057e-01f, -9.17379856e-02f, -3.98916192e-02f, 3.02046910e-02f, 3.64149623e-02f, 7.92236105e-02f, 1.17866166e-01f, -3.85812372e-02f, -6.69896305e-02f,
  -1.35496363e-01f, -4.20815833e-02f, 5.35400957e-02f, 4.70507368e-02f, 9.78600979e-02f, 3.15272361e-02f, 1.96063593e-01f, 1.19662285e-01f, 1.26451522e-01f, 9.41318944e-02f,
  9.84918475e-02f, 1.58850566e-01f, 3.01768277e-02f, 1.13581523e-01f, -6.26308471e-02f, -8.64849146e-03f, 1.31470552e-02f, -5.94617538e-02f, 2.02376302e-03f, 4.16748859e-02f,
  -7.98381492e-02f, 6.31347746e-02f, 2.44907499e-03f, 7.73430392e-02f, -1.45856097e-01f, 6.66221827e-02f, -4.16351203e-03f, 4.61563319e-02f, -1.90335419e-02f, -5.27594723e-02f,
  3.23567688e-02f, 4.98837382e-02f, 2.61215977e-02f, -3.13090272e-02f, 3.67102586e-02f, -4.90095392e-02f, 1.29930731e-02f, 8.74779448e-02f, -2.74514724e-02f, -3.57212014e-02f,
  -6.08434081e-02f, 6.55447245e-02f, -2.67053824e-02f, -6.97884113e-02f, -1.26261815e-01f, -3.20446081e-02f, -3.23342942e-02f, -5.41953277e-03f, 1.64202247e-02f, 5.25977202e-02f,
  -2.23079864e-02f, 2.16561090e-02f, -2.79122833e-02f, 8.13945234e-02f, 3.27182822e-02f, -1.19807713e-01f, 8.38697851e-02f, 6.20185658e-02f, 9.72437672e-03f, 2.16555651e-02f,
  -8.99515972e-02f, -1.25532508e-01f, 3.03516518e-02f, -3.12384274e-02f, -8.55556354e-02f, 2.82066353e-02f, 1.11406820e-03f, 7.24060684e-02f, 7.20646093e-03f, 2.51247995e-02f,
  -4.76783365e-02f, 4.58903275e-02f, -4.99466062e-02f, -1.55398306e-02f, -4.91286218e-02f, 5.99933378e-02f, -4.02086712e-02f, -1.65396575e-02f, 1.11556463e-02f, 1.59090869e-02f,
  -2.67673712e-02f, -1.65875331e-01f, 6.49404675e-02f, 4.84759957e-02f, -9.28387865e-02f, -6.06971309e-02f, -1.00312524e-01f, 2.11957768e-02f, -1.10307574e-01f, -2.10357290e-02f,
  -4.57609131e-04f, -4.18302119e-02f, 1.88953653e-02f, -1.39583135e-02f, 5.22913644e-03f, 4.02379110e-02f, 2.27874406e-02f, 9.38935764e-03f, 2.79068649e-02f, -3.46735902e-02f,
  -1.70321632e-02f, -3.19191478e-02f, 4.39238660e-02f, -2.25811154e-02f, 2.78393347e-02f, 5.43521680e-02f, 6.84878752e-02f, -8.74225199e-02f, -2.53582634e-02f, 1.28225043e-01f,
  -9.58816037e-02f, -1.14247343e-02f, -3.01431306e-02f, -1.66481912e-01f, -6.32089004e-02f, 7.31062517e-02f, 2.64108956e-01f, 1.35894835e-01f, -1.22483103e-02f, 4.50607687e-02f,
  -1.41233593e-01f, -5.27797416e-02f, -5.50408252e-02f, -3.86792645e-02f, 1.56112075e-01f, 1.74433187e-01f, 1.12791121e-01f, 1.49983436e-01f, 5.33517338e-02f, 8.05182829e-02f,
  6.62260652e-02f, 1.88768655e-02f, 5.73012158e-02f, -2.74594557e-02f, -1.35853693e-01f, -1.26324296e-01f, -5.76013066e-02f, -1.18437288e-02f, 2.06763614e-02f, -1.51462719e-01f,
  -3.02401543e-01f, 6.64700009e-03f, -1.35062952e-02f, -1.03409871e-01f, -5.04089743e-02f, -4.51279804e-02f, -1.27432505e-02f, 3.67333591e-02f, 1.77042596e-02f, -5.91766741e-03f,
  -2.31178589e-02f, 2.20486727e-02f, -8.31854343e-02f, -9.27834958e-02f, -3.07333027e-03f, -1.98308655e-04f, 1.22400969e-02f, 1.45132542e-01f, 5.49460687e-02f, 3.80246714e-02f,
  -3.28840911e-02f, -7.47874826e-02f, 7.98696652e-03f, 2.65336484e-02f, 1.01363659e-01f, -3.15611373e-06f, 7.14782774e-02f, 3.87658961e-02f, 6.28384426e-02f, -6.24072785e-03f,
  3.77310254e-02f, -6.27701124e-03f, 1.34646520e-03f, 8.15432370e-02f, -4.73180935e-02f, 7.37861693e-02f, -1.95591319e-02f, -5.47189862e-02f, -7.37872906e-03f, -3.03510372e-02f,
  1.98264606e-02f, 5.56305945e-02f, 8.22246745e-02f, -6.32999763e-02f, -2.25341804e-02f, 4.07377854e-02f, 1.20169902e-02f, 1.63058564e-02f, 5.07054552e-02f, 2.13202126e-02f,
  5.60226887e-02f, -1.49774319e-02f, 4.14807610e-02f, 3.24305743e-02f, -1.42093201e-03f, -1.01185674e-02f, 6.80806413e-02f, -6.18078373e-02f, -6.40507191e-02f, -4.26198430e-02f,
  -2.04122320e-01f, 1.70275792e-01f, -1.01625873e-02f, 6.11029342e-02f, -2.79186349e-02f, 3.77994194e-03f, -2.09080130e-02f, 1.33125205e-02f, -1.04264326e-01f, 1.57899987e-02f,
  -2.30256598e-02f, -5.93764409e-02f, 3.56840193e-02f, -3.61980014e-02f, 6.92542642e-02f, 1.81537606e-02f, 2.60027181e-02f, -6.29019514e-02f, 1.14431139e-02f, -3.57135460e-02f,
  6.11350723e-02f, 1.21512219e-01f, -7.06132427e-02f, 6.19169557e-03f, 5.36773494e-03f, 2.71658730e-02f, -1.14644077e-02f, -2.39355545e-02f, 4.06693481e-02f, -5.59161827e-02f,
  7.87486359e-02f, -2.27659598e-01f, -9.15983052e-04f, 1.40593991e-01f, -1.18092939e-01f, -2.40826190e-01f, -3.30579698e-01f, -7.45597705e-02f, 5.11536486e-02f, -1.35948345e-01f,
  6.82440400e-02f, 1.54907048e-01f, 2.15411380e-01f, 1.92464098e-01f, -4.48314734e-02f, -1.90122604e-01f, -4.70233674e-04f, 3.28580402e-02f, 2.16616809e-01f, 7.41569549e-02f,
  9.22914222e-02f, -2.03467701e-02f, 1.12443618e-01f, -2.77590323e-02f, -8.20001811e-02f, 1.20110936e-01f, -6.64898381e-02f, -6.86685294e-02f, -4.40588072e-02f, -1.74166113e-02f,
  7.02257529e-02f, -1.45134687e-01f, 1.03426859e-01f, 2.30103415e-02f, 2.90381908e-02f, -6.86083585e-02f, 6.41202629e-02f, 7.31570199e-02f, 5.04202172e-02f, 3.36359581e-03f,
  8.36392574e-05f, -1.41748702e-02f, 1.62227042e-02f, -6.21639565e-02f, -2.24357359e-02f, -8.36025327e-02f, -9.80980918e-02f, -9.77900159e-03f, -7.27863237e-02f, -8.08121711e-02f,
  -4.27475758e-02f, -9.55774561e-02f, 9.47483629e-03f, 4.31003608e-02f, -7.36141503e-02f, 2.04379261e-02f, -5.67465182e-03f, 2.97878906e-02f, -1.09078065e-01f, -1.18476294e-01f,
  -2.60394458e-02f, 1.09921835e-01f, -9.97284725e-02f, 5.67709431e-02f, -2.34830119e-02f, 2.72701820e-03f, -4.19826386e-03f, -2.56196447e-02f, 6.33541495e-02f, -3.09401806e-02f,
  -1.64422835e-03f, -2.35537719e-02f, 2.50578625e-03f, 6.41464368e-02f, -2.44474579e-02f, -1.69056673e-02f, -1.19793657e-02f, 4.21834877e-03f, -1.53333517e-02f, -4.25379910e-02f,
  1.10795282e-01f, 6.66326210e-02f, 1.69452745e-02f, 7.56489411e-02f, -8.93610492e-02f, -7.19579607e-02f, 9.61707439e-03f, 1.56036280e-02f, -3.86635028e-02f, -7.79018775e-02f,
  9.35524181e-02f, 9.13073495e-02f, -2.58895047e-02f, 4.63174731e-02f, -4.17262949e-02f, 4.56241742e-02f, -1.49892913e-02f, -1.28260814e-02f, 5.46584055e-02f, -8.12052637e-02f,
  2.79430569e-05f, 6.81750402e-02f, -6.61386475e-02f, 4.05271128e-02f, 9.66522917e-02f, 9.48572680e-02f, -6.34745974e-03f, 3.01880036e-02f, 4.60330397e-02f, -1.98082402e-02f,
  -2.90630516e-02f, 6.04607128e-02f, 1.23390913e-01f, -4.77215685e-02f, 2.55525131e-02f, 9.70768631e-02f, -5.01669273e-02f, 4.84607555e-02f, -2.10779198e-02f, -1.31342068e-01f,
  3.23559761e-01f, 2.67258100e-02f, -1.30401906e-02f, 1.31042255e-02f, -1.43664405e-01f, -1.75115556e-01f, -5.65326363e-02f, -1.14438161e-01f, 1.86465811e-02f, 5.55476099e-02f,
  5.88332340e-02f, 1.52881304e-02f, 1.52853474e-01f, 1.20031707e-01f, 1.66461468e-02f, 8.56203586e-02f, 1.08912699e-02f, 7.91986808e-02f, -2.40640882e-02f, 6.15015673e-03f,
  -7.54890814e-02f, -1.19278003e-02f, 6.24078251e-02f, -4.09701057e-02f, -6.06327355e-02f, 6.37069494e-02f, -1.12281684e-02f, -9.95768681e-02f, -3.40420101e-03f, 5.55280186e-02f,
  1.18860498e-01f, 4.22993936e-02f, 8.09962954e-03f, 5.69742434e-02f, 1.43553689e-02f, 9.31226015e-02f, -1.06069678e-02f, 2.09584963e-02f, -7.50364095e-04f, 2.76650451e-02f,
  1.04516745e-02f, -6.67355657e-02f, -1.52853774e-02f, -7.71556348e-02f, 6.22124970e-02f, -5.84689006e-02f, 2.45264955e-02f, 1.26850568e-02f, 2.12455466e-02f, -2.94176154e-02f,
  3.13661173e-02f, 4.41717468e-02f, 3.47689241e-02f, -1.11234210e-01f, -5.48702367e-02f, -6.57804385e-02f, 2.59966198e-02f, 1.88217107e-02f, -9.25868973e-02f, 6.77037984e-02f,
  -6.00934401e-02f, 2.71792579e-02f, -3.67387123e-02f, 3.64585668e-02f, 8.74138474e-02f, -3.11262887e-02f, 7.08982274e-02f, 2.03708429e-02f, 3.36547866e-02f, 1.27496831e-02f,
  -8.50654021e-02f, 4.29182276e-02f, -2.79876664e-02f, 6.78799376e-02f, -2.66314913e-02f, 1.43946810e-02f, 2.94745062e-02f, 7.97765888e-03f, -4.60654721e-02f, 6.32725060e-02f,
  -5.65223135e-02f, -9.51173231e-02f, -3.61052454e-02f, -3.88236344e-02f, 3.98894260e-03f, -8.65617208e-03f, 5.56318164e-02f, 4.02874872e-02f, -6.01364672e-02f, 4.21831235e-02f,
  1.56797066e-01f, -4.23384272e-02f, 1.40895247e-01f, -3.32407616e-02f, 1.81571860e-02f, -9.99140814e-02f, 9.20543820e-02f, -4.48390655e-02f, -1.73054300e-02f, -2.88582277e-02f,
  -6.17736019e-02f, -4.40846272e-02f, -2.68336926e-02f, -3.67592238e-02f, -1.76525232e-03f, -2.71655899e-02f, -6.94543198e-02f, 7.46920183e-02f, -1.01371430e-01f, -7.00824410e-02f,
  4.11036089e-02f, 6.15102798e-02f, 1.36830747e-01f, 4.76378016e-02f, -4.59741466e-02f, 1.31290540e-01f, 4.60450873e-02f, 4.63952981e-02f, -1.24969212e-02f, -9.99657251e-03f,
  -3.42969112e-02f, 1.94124565e-01f, 8.30114782e-02f, -1.30385514e-02f, -1.50937848e-02f, 1.21310048e-01f, 1.20822325e-01f, 1.75105259e-02f, 3.72169018e-02f, 8.94999877e-02f,
  -4.42094430e-02f, -2.06447005e-01f, -1.32303044e-01f, -1.34672806e-01f, 2.21644156e-02f, 1.09344587e-01f, -3.75955068e-02f, -1.68030173e-01f, -2.09476903e-01f, -1.55420145e-02f,
  -1.44986123e-01f, -1.56135574e-01f, -1.54285580e-01f, -1.28887087e-01f, -7.22120479e-02f, -1.73016310e-01f, 8.93643126e-02f, -4.05457020e-02f, -2.61916593e-02f, -3.36875468e-02f,
  -1.11863256e-01f, 1.72777355e-01f, -7.16041327e-02f, -7.96369538e-02f, 1.21471770e-01f, 1.90368891e-02f, 3.44358347e-02f, 3.90584990e-02f, 1.15540467e-01f, 2.43041404e-02f,
  5.33196591e-02f, 5.02416827e-02f, 2.11897139e-02f, -8.08221325e-02f, 8.45594183e-02f, 3.97066250e-02f, 5.48871048e-02f, 4.17619497e-02f, 2.94351932e-02f, 5.90855889e-02f,
  -1.25295934e-04f, 7.34433904e-02f, 9.39761326e-02f, 9.80779529e-03f, 1.48995370e-01f, -1.28748128e-03f, 8.73569101e-02f, 1.05874270e-01f, 1.15615390e-01f, 1.13340989e-01f,
  -2.97194496e-02f, 6.72742799e-02f, -2.98970416e-02f, 7.98487589e-02f, -3.93229508e-04f, 6.08384013e-02f, -5.05538061e-02f, -1.02441855e-01f, -1.80510022e-02f, 1.08234212e-01f,
  5.89808002e-02f, 2.89419969e-03f, 1.96017344e-02f, 9.30618346e-02f, -1.90108027e-02f, 5.71871884e-02f, -1.06354319e-02f, -4.64720652e-02f, -7.04438612e-02f, 5.72747886e-02f,
  6.09181449e-02f, 1.55537069e-04f, -8.47421139e-02f, 2.31870078e-02f, 5.32211401e-02f, 5.66155948e-02f, 5.83409071e-02f, -3.92234065e-02f, -4.60258909e-02f, -2.72444952e-02f,
  -1.69651106e-01f, 1.29253855e-02f, -6.06503263e-02f, -3.54121886e-02f, -3.81701440e-02f, 5.93857504e-02f, 8.01630318e-02f, 1.05176896e-01f, -1.80776976e-02f, -2.02261955e-02f,
  -4.23753336e-02f, 9.85706225e-03f, 2.07496211e-02f, 6.39181584e-02f, -6.93375021e-02f, 3.59426178e-02f, -1.68937612e-02f, -7.95185044e-02f, -8.40408430e-02f, 9.08599645e-02f,
  3.86609510e-02f, -9.91356932e-03f, 4.98707481e-02f, -4.49471027e-02f, -2.90420052e-04f, -3.17835622e-02f, -8.87478590e-02f, 6.23950548e-02f, -7.37498850e-02f, -6.11417107e-02f,
  2.28106886e-01f, -9.47615877e-03f, 8.91573261e-03f, 1.18850879e-01f, -1.12578645e-01f, 6.03293031e-02f, -1.16429375e-02f, 1.13625064e-01f, 2.77194139e-02f, -1.17781401e-01f,
  -7.78625235e-02f, -5.51536977e-02f, 9.81315151e-02f, 1.40285015e-01f, 1.89717755e-01f, 4.29780781e-02f, 1.48621857e-01f, 1.45748243e-01f, 1.11647867e-01f, 1.35125801e-01f,
  7.89006874e-02f, 1.45638749e-01f, 1.58765763e-01f, 1.42989397e-01f, -1.35454889e-02f, -2.31002700e-02f, -8.58645067e-02f, 5.36961220e-02f, -2.27247775e-02f, -9.49958190e-02f,
  -8.36225823e-02f, 4.32831757e-02f, -6.26751631e-02f, -6.75434992e-02f, -1.14723623e-01f, -1.62567524e-03f, -6.00152016e-02f, 7.44660348e-02f, -6.44248873e-02f, -4.08528484e-02f,
  3.56554873e-02f, -1.14904260e-02f, 1.13941021e-01f, -3.28479819e-02f, 9.48564261e-02f, 1.26736417e-01f, 8.86849388e-02f, 1.47375509e-01f, 6.30356893e-02f, 4.36711982e-02f,
  2.95401625e-02f, 1.22619480e-01f, 1.00637414e-01f, 5.06255515e-02f, 5.11917882e-02f, -1.64208170e-02f, -5.27350418e-02f, -1.86479632e-02f, 9.54785198e-02f, -3.32747996e-02f,
  2.46597268e-02f, -4.79116999e-02f, 1.31817535e-03f, -5.80159202e-02f, 4.80890609e-02f, -5.19540310e-02f, -5.28574586e-02f, 1.18447905e-02f, -1.77122690e-02f, 3.83172147e-02f,
  8.66535977e-02f, 2.58567296e-02f, -8.88221860e-02f, 6.56468868e-02f, 4.36438359e-02f, -2.83774007e-02f, -6.29810169e-02f, -5.15277348e-02f, -1.04738567e-02f, -6.29472584e-02f,
  7.50929192e-02f, -1.38143441e-02f, 2.50781281e-03f, -9.62595418e-02f, 2.94011887e-02f, -4.75854538e-02f, -4.31122119e-03f, 2.90008020e-02f, 9.53821242e-02f, -2.90675350e-02f,
  -2.07104161e-02f, 1.28515344e-02f, -7.10408986e-02f, 6.20836765e-02f, 1.79959852e-02f, 2.25009490e-02f, -1.09714873e-01f, -7.56935403e-02f, 3.13126706e-02f, -2.64862794e-02f,
  -1.74306501e-02f, 2.71332990e-02f, -1.54096838e-02f, 3.81584987e-02f, 1.12572350e-01f, 6.00621291e-02f, 7.27841854e-02f, 3.70898806e-02f, -5.48544750e-02f, 3.77590246e-02f,
  -7.76671106e-04f, 1.33040816e-01f, 8.01222697e-02f, 5.11423051e-02f, 4.30316292e-03f, 8.94053727e-02f, -2.76393909e-02f, 5.47659770e-02f, 6.47762045e-02f, 6.37540519e-02f,
  -1.46005422e-01f, 1.00092985e-01f, 9.41132158e-02f, 6.56919274e-03f, -8.88401940e-02f, -9.23830420e-02f, 3.08574084e-02f, -6.09169081e-02f, 3.78407049e-03f, -5.95492125e-02f,
  -3.58899087e-02f, -1.24298751e-01f, -2.56541255e-03f, 8.77429321e-02f, -3.22953761e-02f, 1.88119277e-01f, 1.75757378e-01f, 3.41248102e-02f, -3.89238447e-02f, 6.63483655e-03f,
  -2.16563586e-02f, 4.35712114e-02f, -1.66912116e-02f, -5.51379733e-02f, 5.65627553e-02f, -7.85667747e-02f, 2.14811377e-02f, 2.76046172e-02f, 6.87436983e-02f, 4.64029796e-02f,
  7.66163990e-02f, -6.65789545e-02f, -4.00154367e-02f, 4.78282310e-02f, -7.46599957e-02f, -6.87923953e-02f, 5.92860281e-02f, 8.79480503e-03f, 1.98310558e-02f, 7.04194158e-02f,
  -8.52286071e-02f, 2.29240372e-03f, -7.06304163e-02f, 2.20919885e-02f, -2.20421441e-02f, -6.22739084e-02f, -1.81455109e-02f, 9.29820612e-02f, -4.06309515e-02f, 3.80802378e-02f,
  5.36203608e-02f, -1.01220302e-01f, 4.07286882e-02f, 1.18287444e-01f, 7.10137188e-02f, 7.02114403e-02f, 9.95369554e-02f, 6.42276108e-02f, -4.05200869e-02f, -5.27853109e-02f,
  -4.44696099e-02f, 1.50959222e-02f, -6.61014467e-02f, 3.86687182e-03f, -7.88075626e-02f, -5.59574403e-02f, 8.64246637e-02f, 4.30083461e-02f, -1.97781101e-02f, -2.95737237e-02f,
  2.23451592e-02f, -3.18366960e-02f, -8.00546911e-03f, 7.82065019e-02f, 1.07938917e-02f, 9.68425442e-03f, 7.40301833e-02f, 2.52694748e-02f, 3.77227701e-02f, -1.32071627e-02f,
  6.43162876e-02f, -2.08604969e-02f, 2.33483780e-02f, 7.68563002e-02f, -4.04444709e-02f, -5.65059595e-02f, -8.71938616e-02f, -1.19133200e-02f, -9.53083038e-02f, 4.26229760e-02f,
  -5.22337332e-02f, 4.02521938e-02f, -2.37957761e-02f, 1.84205547e-03f, -2.73095183e-02f, 1.48189431e-02f, 9.09293666e-02f, -3.35883610e-02f, -8.35655257e-02f, -3.34724858e-02f,
  -1.00244008e-01f, 4.10266891e-02f, 9.87731740e-02f, 6.05966635e-02f, 6.12859875e-02f, -1.39090614e-02f, 9.10106450e-02f, -3.59804891e-02f, -3.29877622e-02f, 1.04102055e-02f,
  1.12490974e-01f, -4.10016067e-02f, 9.98831727e-03f, 5.95459640e-02f, 8.07538331e-02f, -7.76414201e-02f, 7.29301050e-02f, 2.31703222e-02f, -2.29700934e-02f, -6.21085800e-03f,
  1.40582398e-01f, -1.84886560e-01f, 2.56908089e-02f, 1.44533530e-01f, -8.84768181e-03f, -2.23957226e-01f, -3.01046163e-01f, -1.51639625e-01f, 6.52304292e-02f, -1.13720469e-01f,
  -1.33361802e-01f, 1.03225395e-01f, 2.68059447e-02f, -2.43344139e-02f, -4.78170663e-02f, -1.58565827e-02f, 3.74834351e-02f, 1.89917222e-01f, 2.08898094e-02f, -1.76744871e-02f,
  1.06064424e-01f, 1.17399022e-01f, 1.32487357e-01f, -3.28693865e-03f, 9.17247310e-02f, 1.51020661e-01f, -1.65715329e-02f, -3.17046344e-02f, -3.06055564e-02f, 1.47280172e-01f,
  -1.20008305e-01f, -6.00212105e-02f, 6.95533529e-02f, 6.15482815e-02f, -3.11200768e-02f, 6.12051114e-02f, 5.81317656e-02f, 2.87374128e-02f, -4.31772359e-02f, -7.29157254e-02f,
  1.89355593e-02f, 5.47410250e-02f, 4.49001305e-02f, 3.30610909e-02f, -2.40077376e-02f, 8.87839124e-02f, 8.09347443e-03f, 1.39498031e-02f, 2.54867356e-02f, -1.25991111e-03f,
  5.41445203e-02f, -9.32455063e-02f, -6.58784956e-02f, -4.87612076e-02f, 2.05899756e-02f, 5.05950563e-02f, 3.72124501e-02f, 2.77721304e-02f, 3.64928842e-02f, 1.38465995e-02f,
  -1.01856617e-02f, -1.07976058e-02f, -7.73328766e-02f, 6.20483123e-02f, -9.49794725e-02f, 5.44914454e-02f, 7.81143084e-02f, -9.29809585e-02f, 4.44132760e-02f, -5.73818982e-02f,
  2.34213248e-02f, -7.46260285e-02f, 8.09993874e-03f, 3.89750041e-02f, -1.69581771e-02f, 7.06495121e-02f, 6.65420517e-02f, -5.17100692e-02f, 1.95450168e-02f, -6.13947995e-02f,
  8.34183916e-02f, -8.41353536e-02f, 6.92763180e-02f, 5.15780486e-02f, 2.72541530e-02f, 3.16870250e-02f, 5.95588870e-02f, -8.09466317e-02f, -3.48063074e-02f, -5.29198088e-02f,
  -1.08001437e-02f, -1.53783172e-01f, 2.28075106e-02f, 6.58282936e-02f, 2.44320147e-02f, -5.80062857e-03f, 2.08751932e-02f, 2.63194758e-02f, 6.51807860e-02f, -6.09137341e-02f,
  -6.84686229e-02f, -1.25682652e-02f, 1.39052598e-02f, -8.59772321e-03f, 1.37079703e-02f, -7.45354891e-02f, -5.68540171e-02f, 4.92321281e-03f, 8.07512999e-02f, 1.50281824e-02f,
  -1.80834103e-02f, -6.57072151e-03f, -7.66308755e-02f, -5.70567064e-02f, 3.59183401e-02f, -4.61506844e-02f, -7.66246989e-02f, -6.84155524e-02f, -1.10876173e-01f, -1.46011010e-01f,
  -2.65631497e-01f, 1.56842336e-01f, 3.54194567e-02f, -1.04867503e-01f, 4.11051605e-03f, -1.26776680e-01f, 5.43941334e-02f, -1.00620247e-01f, -1.43179998e-01f, 7.63950124e-02f,
  -1.19703226e-02f, -1.22380994e-01f, -1.13498624e-02f, -4.72523980e-02f, -1.82159573e-01f, 5.51161356e-02f, 1.51728839e-01f, -6.74654916e-03f, -1.79877087e-01f, -9.98054519e-02f,
  7.66875967e-02f, -6.69546949e-04f, 2.21889932e-02f, -3.81499641e-02f, 1.57346919e-01f, 1.22826099e-01f, 2.08298936e-01f, 1.21682882e-01f, 1.32058471e-01f, 2.72551149e-01f,
  2.29567870e-01f, -2.56674718e-02f, -7.27580562e-02f, 1.30207306e-02f, 6.16739225e-03f, -4.00176123e-02f, -6.17968179e-02f, 6.68153465e-02f, 3.44769023e-02f, 6.59675822e-02f,
  7.07914382e-02f, 1.11588659e-02f, 2.22170409e-02f, 5.57982139e-02f, 4.85355780e-02f, 2.90030520e-02f, 1.20855913e-01f, -1.91105681e-03f, -3.63126807e-02f, -7.65559301e-02f,
  1.01113603e-01f, 8.98105185e-03f, 4.39501442e-02f, -3.26368138e-02f, -1.17917676e-02f, -9.94038433e-02f, 1.13749728e-02f, -2.26863138e-02f, -1.10619180e-01f, 2.13765860e-01f,
  -7.34959692e-02f, 1.14729544e-02f, -8.97673592e-02f, -2.98304111e-02f, 3.11319493e-02f, -7.02751875e-02f, 1.01436064e-01f, -1.42391017e-02f, 6.34929836e-02f, 4.02106643e-02f,
  -4.41488959e-02f, -2.63327304e-02f, 5.74659221e-02f, -4.80489768e-02f, 4.13013482e-03f, 2.38443315e-02f, -2.82646529e-02f, 9.83598307e-02f, -5.71991801e-02f, 2.69418466e-03f,
  -4.20736484e-02f, -6.18761256e-02f, 1.20050132e-01f, -3.39639261e-02f, -5.18886112e-02f, 7.19901472e-02f, 4.05603759e-02f, 6.61298865e-04f, 1.57274902e-02f, -7.97445923e-02f,
  8.37267414e-02f, -1.95297077e-01f, 8.18684697e-02f, -3.38785239e-02f, -5.49812056e-02f, 2.15780195e-02f, 5.07169031e-03f, 5.05110696e-02f, -1.85271315e-02f, 1.57941896e-02f,
  -6.93067759e-02f, -1.44608058e-02f, 1.98255498e-02f, 2.91180462e-02f, -4.36892100e-02f, -4.43262681e-02f, 1.40330161e-03f, 7.51371756e-02f, -2.15115678e-03f, -4.62692901e-02f,
  8.58969614e-02f, 5.76756895e-03f, -1.10869624e-01f, 3.86326537e-02f, -3.30733284e-02f, -9.80272740e-02f, -9.57073923e-03f, 3.19006406e-02f, -5.82291968e-02f, 1.05650434e-02f,
  2.59837657e-01f, 2.07656309e-01f, 1.00970872e-01f, 2.07046986e-01f, 2.10432172e-01f, 1.33115411e-01f, 1.93079859e-01f, 1.29443839e-01f, 1.51471034e-01f, 1.54318720e-01f,
  1.07386731e-01f, 6.16938584e-02f, -4.63984646e-02f, -5.29183112e-02f, -5.30057177e-02f, 7.38473013e-02f, 1.50309652e-01f, 4.37600054e-02f, 5.87936302e-05f, 1.07288495e-01f,
  1.41890407e-01f, 1.44793347e-01f, 7.75460079e-02f, 7.14856163e-02f, 1.25812903e-01f, 3.61208222e-03f, -2.76282965e-03f, 4.25141491e-02f, 2.79130638e-02f, 7.83552676e-02f,
  1.18205473e-01f, 2.00467780e-01f, -5.04886732e-02f, -6.75686896e-02f, 1.09747779e-02f, 1.92126147e-02f, 1.84923597e-02f, -8.35363567e-02f, -6.49500489e-02f, -2.78435722e-02f,
  4.92780246e-02f, 5.04605845e-02f, 9.24926065e-03f, -4.14724760e-02f, -3.31198983e-02f, 1.49763012e-02f, -9.68387723e-02f, 7.30050914e-03f, 1.63490623e-02f, -2.58486215e-02f,
  6.93858266e-02f, 1.85502544e-02f, 1.99522749e-02f, -4.89425175e-02f, -8.91237482e-02f, -9.27627087e-02f, 6.95729349e-03f, 1.77573580e-02f, -6.25313446e-02f, 6.33684620e-02f,
  9.75419953e-02f, -6.85214326e-02f, -4.85648885e-02f, -1.12561425e-02f, -1.74552221e-02f, -1.32262371e-02f, -2.78837681e-02f, 6.41658381e-02f, 5.23061790e-02f, -7.34921321e-02f,
  -6.02623932e-02f, 1.84106939e-02f, -2.52290275e-02f, -6.08129101e-03f, -6.58329651e-02f, 3.92473191e-02f, -2.42805928e-02f, 1.94040462e-02f, -3.40423025e-02f, -6.17437176e-02f,
  7.48650804e-02f, -2.30645319e-03f, 2.34196186e-02f, -1.14508845e-01f, -3.29755992e-02f, 4.95913513e-02f, 1.34912040e-02f, 6.30940124e-02f, -6.49830848e-02f, 3.11095864e-02f,
  -1.59318987e-02f, -1.00112427e-02f, 7.32180998e-02f, -2.40446161e-02f, 4.33736034e-02f, -1.15069769e-01f, 3.78709473e-02f, -3.72818764e-03f, -2.01072022e-02f, 6.07271753e-02f,
  1.60165820e-02f, 9.01963748e-03f, 4.09751162e-02f, 3.24059092e-02f, 4.93662320e-02f, -2.68811453e-02f, 4.57498319e-02f, 4.45792228e-02f, -1.69007014e-02f, 5.46591170e-03f,
  -5.69795296e-02f, 4.17343667e-03f, -4.36215401e-02f, -9.28799957e-02f, -9.26676244e-02f, 2.04708669e-02f, -1.47525789e-04f, -1.07050404e-01f, -5.17348349e-02f, -8.34823549e-02f,
  -3.49281818e-01f, 3.20643783e-02f, -4.91244011e-02f, -9.36348289e-02f, 8.80933776e-02f, 2.92348508e-02f, 8.09333920e-02f, 1.08941659e-01f, -4.47332487e-03f, 5.94725125e-02f,
  -6.00662157e-02f, -5.26765622e-02f, -4.28203270e-02f, 1.00384429e-01f, -5.52675128e-02f, 8.35455135e-02f, 9.09277499e-02f, -1.01916604e-01f, -7.68216103e-02f, 6.97970539e-02f,
  4.98300232e-02f, 3.87933142e-02f, -1.28517836e-01f, 3.08809634e-02f, 1.01193532e-01f, -4.82747369e-02f, 1.22882836e-01f, -8.04940462e-02f, -2.34656986e-02f, 2.86519304e-02f,
  -1.26647264e-01f, -9.66446549e-02f, -5.85997514e-02f, 7.93372840e-02f, 1.69776678e-02f, -3.82384937e-03f, 2.75019705e-02f, -8.52664113e-02f, 5.64861856e-02f, 2.99835950e-02f,
  -1.07939830e-02f, -3.78551558e-02f, -9.80206057e-02f, 9.54725370e-02f, -1.18639516e-02f, -6.99649230e-02f, 8.09837729e-02f, -2.44209021e-02f, -4.97883037e-02f, -2.68305410e-02f,
  7.08464980e-02f, 3.81277576e-02f, -1.74047016e-02f, 1.49428118e-02f, 7.64315650e-02f, -8.60910490e-02f, -5.87547608e-02f, 2.38670763e-02f, 9.21517983e-02f, -7.41419056e-03f,
  1.85149312e-02f, -3.38044241e-02f, 4.70007807e-02f, -1.25826746e-02f, -5.22040501e-02f, -7.96471909e-02f, 4.31430526e-02f, 9.15798843e-02f, 7.70328045e-02f, 4.17613750e-03f,
  3.78727540e-02f, -5.83650805e-02f, -6.86925352e-02f, 6.26725033e-02f, 1.76984500e-02f, 4.29211296e-02f, 4.78875339e-02f, 2.41069179e-02f, 1.69171393e-02f, 6.94416324e-03f,
  4.82255258e-02f, -6.49798810e-02f, -5.90620823e-02f, -3.32877040e-02f, 1.45430164e-03f, 1.08436421e-01f, 4.84035118e-03f, 5.86395748e-02f, -3.88246290e-02f, -3.55558516e-03f,
  -7.99694881e-02f, 6.56837448e-02f, -8.53990093e-02f, -2.01886389e-02f, -3.94260064e-02f, -2.46331524e-02f, -9.82029587e-02f, -3.07760220e-02f, -8.75846669e-02f, 4.51262295e-02f,
  5.96103929e-02f, -4.35053296e-02f, -8.27936232e-02f, -3.22868638e-02f, 4.76478692e-03f, -2.51259543e-02f, 4.53841873e-02f, -1.15558021e-02f, 4.48658168e-02f, 2.81767435e-02f,
  8.21542591e-02f, 1.61259025e-02f, -1.64723918e-01f, 1.36606712e-02f, -6.85373098e-02f, -1.02248564e-01f, -4.58253101e-02f, -2.70797219e-02f, -8.92170593e-02f, -1.34138212e-01f,
  -1.17046818e-01f, 3.76807153e-02f, -2.50753641e-01f, 5.13857715e-02f, 1.25590399e-01f, 1.76068217e-01f, 2.69825429e-01f, 1.63119197e-01f, -3.05852480e-02f, 8.40383396e-02f,
  -6.58661127e-02f, 1.01163881e-02f, -1.09326862e-01f, -1.26818180e-01f, -6.84154453e-03f, 1.40039608e-01f, 1.49611700e-02f, -4.06392403e-02f, -1.47738457e-01f, -3.67345065e-02f,
  1.69525206e-01f, 2.72633210e-02f, -1.02402739e-01f, -9.69124436e-02f, -9.64954942e-02f, 2.65338644e-02f, -6.14785915e-03f, -1.04862832e-01f, 7.54660890e-02f, -1.55772805e-01f,
  -3.22140157e-01f, -1.36438608e-01f, -9.14856493e-02f, -4.40305397e-02f, -1.08243488e-02f, 1.60100628e-02f, -4.19910140e-02f, -1.32371217e-01f, -2.71752942e-02f, -2.36072727e-02f,
  -6.01318553e-02f, 7.56798266e-03f, 9.07328445e-03f, -1.28184380e-02f, -5.51425666e-02f, 7.59500936e-02f, 5.37648685e-02f, -7.89411142e-02f, -2.02909745e-02f, -8.71988162e-02f,
  4.00490314e-02f, -1.67205427e-02f, -4.48990725e-02f, 3.02905124e-02f, 5.04209436e-02f, -4.43425365e-02f, -2.85363048e-02f, 2.15356145e-02f, -8.76673311e-02f, 1.32409502e-02f,
  6.16917945e-02f, 1.02491314e-02f, -3.24522667e-02f, -2.79823970e-02f, -1.73098128e-02f, -3.80169712e-02f, 7.93278776e-03f, 6.95136860e-02f, 6.21973351e-02f, 2.34999247e-02f,
  -2.56171171e-02f, -2.28601824e-02f, -5.37879653e-02f, -1.07660806e-02f, 1.13047482e-02f, 2.94273403e-02f, 1.71987638e-02f, -4.52597775e-02f, 1.78148970e-02f, 4.81086923e-03f,
  -1.49687789e-02f, -8.59892443e-02f, -1.70652047e-02f, -3.56988274e-02f, 6.87613860e-02f, -6.98881224e-02f, -3.54845859e-02f, 6.90375790e-02f, 1.10693239e-02f, -4.24260907e-02f,
  -2.78264750e-02f, -2.56409124e-02f, -5.64259849e-02f, 2.37439070e-02f, -2.73559242e-02f, -9.48801190e-02f, 3.49555314e-02f, -1.89343411e-02f, 1.78587418e-02f, -9.01750661e-03f,
  4.13440837e-04f, -3.56210954e-02f, -3.24425586e-02f, 8.08900371e-02f, 3.14304531e-02f, -7.70723149e-02f, 6.32160380e-02f, -8.71698558e-03f, 8.93005505e-02f, -7.20274150e-02f,
  -8.30805395e-03f, 7.78132826e-02f, -6.88513294e-02f, -4.87914123e-02f, 3.38854305e-02f, 3.85159329e-02f, 6.11908473e-02f, -2.16039494e-02f, -4.35919426e-02f, 1.66714117e-01f,
  -1.12099320e-01f, -1.22979827e-01f, 1.43099139e-02f, 1.27124086e-01f, -1.76626537e-02f, -1.30510032e-01f, -1.56658769e-01f, -3.55165266e-02f, -5.31341359e-02f, 3.56582440e-02f,
  9.63010266e-02f, 9.88632590e-02f, 8.31246898e-02f, 1.71445116e-01f, -2.11736057e-02f, -7.64925033e-02f, 1.23428367e-01f, 1.36179239e-01f, 1.30320162e-01f, 9.21405703e-02f,
  9.78481695e-02f, 5.42083196e-02f, -1.03483289e-01f, -4.13246602e-02f, -3.25457714e-02f, 1.75359219e-01f, 8.14255327e-02f, 5.73257357e-02f, -5.63023202e-02f, 2.22946301e-01f,
  1.78131580e-01f, -2.24562854e-01f, 6.50076121e-02f, 4.99600209e-02f, 2.97019240e-02f, 1.87491681e-02f, 3.57255712e-02f, -8.49458128e-02f, -5.69269806e-02f, 6.35220557e-02f,
  5.36756683e-03f, -4.24869446e-04f, -1.89416998e-04f, 5.08555174e-02f, -4.04967628e-02f, -7.06321001e-02f, -8.73806402e-02f, -2.45093126e-02f, 6.02675378e-02f, 2.89417375e-02f,
  6.81922436e-02f, -7.37788454e-02f, -8.39650705e-02f, 8.86715483e-03f, -1.44159704e-01f, 8.16746652e-02f, -6.84055910e-02f, -6.81902617e-02f, -8.88617933e-02f, -6.77087530e-02f,
  3.27714644e-02f, 4.84603569e-02f, 1.03688948e-02f, 1.23869134e-02f, 1.08993957e-02f, -6.18546493e-02f, 9.76691023e-02f, 1.82951186e-02f, 5.67177422e-02f, 3.42417322e-02f,
  1.59543995e-02f, 1.93917099e-02f, -2.84801759e-02f, 3.06985378e-02f, 1.01621509e-01f, 4.50409763e-02f, 2.73189228e-02f, -6.46223947e-02f, -1.49675990e-02f, -3.62444334e-02f,
  -1.63198821e-02f, -3.62292193e-02f, -7.41923153e-02f, 4.83022965e-02f, -3.57917510e-02f, -1.51573112e-02f, 4.28968184e-02f, 7.06259254e-03f, -9.77962464e-03f, -4.93234582e-02f,
  8.15142319e-02f, -4.70644422e-02f, 6.89547807e-02f, 4.48723473e-02f, -5.86587414e-02f, -7.36192539e-02f, 5.20416386e-02f, -7.00712502e-02f, 2.64589768e-02f, -3.37197655e-03f,
  -2.05554292e-02f, 7.00285435e-02f, 6.03551231e-02f, -3.88657418e-03f, 3.09535097e-02f, -7.75082186e-02f, 4.93251197e-02f, 1.11998744e-01f, -3.86951603e-02f, -4.03372720e-02f,
  -5.33464216e-02f, 2.70224214e-02f, -2.64847130e-02f, -3.60107906e-02f, -4.29580547e-02f, 1.01959318e-01f, 9.86095071e-02f, 2.75341421e-02f, 3.83813120e-02f, 3.54838893e-02f,
  4.89833385e-01f, -8.56473446e-02f, -1.58995911e-01f, 1.91713050e-01f, -1.56806901e-01f, -1.41562745e-01f, -2.15065673e-01f, -2.35778168e-02f, 4.60201986e-02f, -4.19927314e-02f,
  -6.18688799e-02f, -2.23178007e-02f, 9.80959460e-02f, 4.47172076e-02f, 4.98000048e-02f, -1.25904739e-01f, -1.22559935e-01f, 6.73928531e-04f, -1.02529220e-01f, -2.56376714e-02f,
  -9.85354856e-02f, 1.07543528e-01f, 3.50993387e-02f, 6.72886148e-02f, 1.14472248e-02f, 1.73277538e-02f, -2.63542701e-02f, -4.37126011e-02f, -4.81827594e-02f, 1.03316650e-01f,
  -4.00850475e-02f, 8.91365260e-02f, -9.83523503e-02f, 3.46172638e-02f, -1.34353079e-02f, 6.56817034e-02f, -4.28550728e-02f, 1.24676246e-02f, 7.00325519e-02f, -1.49393314e-02f,
  -8.83457214e-02f, 7.57066458e-02f, 6.75895363e-02f, 4.44675758e-02f, 1.00632489e-01f, 1.47367385e-03f, 3.40342037e-02f, 1.28468173e-02f, 4.09294367e-02f, -8.72496367e-02f,
  6.98615797e-03f, 2.43472140e-02f, 1.31652141e-02f, 2.26375200e-02f, 1.60124768e-02f, 4.55258861e-02f, -3.60683203e-02f, -5.09865247e-02f, -2.07658224e-02f, 1.89817831e-01f,
  4.26221155e-02f, -3.89338098e-03f, -3.97795951e-03f, -4.46765348e-02f, 5.35939187e-02f, 1.56127894e-02f, -1.50738945e-02f, -2.06317678e-02f, -1.46131264e-02f, 5.96671589e-02f,
  -1.75943375e-02f, 2.39106547e-02f, 4.76318747e-02f, 3.86968367e-02f, -2.17557009e-02f, 4.34409641e-03f, 1.64620597e-02f, 7.96175227e-02f, 6.94918856e-02f, -5.00513762e-02f,
  7.65776262e-02f, -7.31984973e-02f, -3.19986083e-02f, 3.45489308e-02f, -7.19029531e-02f, 6.65407702e-02f, -5.63869029e-02f, 2.83050612e-02f, -7.14926571e-02f, -3.12334802e-02f,
  1.04871154e-01f, -2.23287314e-01f, 1.32984564e-01f, 8.61365162e-03f, 5.66056296e-02f, 1.93818193e-02f, -4.44292882e-03f, -2.55596098e-02f, -8.72853100e-02f, 1.38155688e-02f,
  2.85428111e-02f, 3.65510583e-02f, -4.21554893e-02f, 3.93777490e-02f, 5.62982075e-03f, -2.89555583e-02f, 1.10375183e-02f, 2.59157736e-02f, -5.02726212e-02f, -2.08083377e-03f,
  3.22950780e-02f, 3.70174572e-02f, -5.86285722e-03f, -2.51177996e-02f, -8.19474682e-02f, -8.28449279e-02f, -5.62377423e-02f, -3.94495130e-02f, -2.26692464e-02f, 1.61950767e-01f,
  -1.75012335e-01f, 1.01507455e-01f, 1.23791851e-01f, 4.71764505e-02f, 1.09697759e-01f, -4.98573587e-04f, 2.08347470e-01f, 2.59564873e-02f, 1.94126014e-02f, 1.79787397e-01f,
  6.05407218e-03f, -1.48708150e-01f, -1.51548877e-01f, -1.29409820e-01f, -1.88025311e-01f, 1.46803737e-01f, 1.69223979e-01f, -1.70808926e-01f, -3.39014381e-01f, -1.64138213e-01f,
  2.79633515e-02f, 5.37452810e-02f, -6.34158850e-02f, -1.17710270e-01f, 1.23174690e-01f, 8.49485770e-03f, 6.46635368e-02f, 1.49654850e-01f, -9.36941709e-03f, 1.71218902e-01f,
  -1.26973446e-02f, 2.10999083e-02f, -1.25734642e-01f, -6.61467835e-02f, -3.64872850e-02f, -7.71288946e-02f, 1.91747360e-02f, 2.62219887e-02f, -7.77398720e-02f, 7.89676979e-02f,
  -6.70684576e-02f, -7.59605095e-02f, -2.05061473e-02f, -6.11200966e-02f, -5.06353751e-02f, -2.64545083e-02f, -3.27227302e-02f, -9.99264270e-02f, 4.16021161e-02f, 1.00816423e-02f,
  -9.89850517e-03f, 6.56761602e-02f, 5.01232855e-02f, 2.81455591e-02f, -5.99734262e-02f, -8.71379748e-02f, 1.23824954e-01f, 1.67260952e-02f, 4.47189733e-02f, 1.47411749e-01f,
  -3.45899463e-02f, 2.81631900e-03f, -3.33558321e-02f, 2.84660757e-02f, 6.26097899e-03f, 5.67279421e-02f, 5.35353385e-02f, -6.10118881e-02f, 2.88150124e-02f, -6.56585693e-02f,
  -5.51090501e-02f, 7.29450509e-02f, -3.70360054e-02f, -6.72388747e-02f, 3.15993950e-02f, -2.00868864e-02f, 6.96298061e-03f, 2.41195858e-02f, 1.16532119e-02f, -6.47508055e-02f,
  3.74194942e-02f, 3.71662192e-02f, 8.17664713e-02f, 3.44064943e-02f, 2.70794109e-02f, -5.40148467e-02f, -4.78417352e-02f, -5.05908206e-02f, -1.45911258e-02f, 7.94540569e-02f,
  -7.25843431e-03f, -8.47398341e-02f, 7.37902224e-02f, -6.97942451e-02f, 2.78527923e-02f, -4.93335761e-02f, -4.89100777e-02f, -9.09532011e-02f, 1.63969621e-02f, 9.00802668e-03f,
  1.15418173e-02f, -9.20641050e-02f, -3.18733230e-02f, -1.46828936e-02f, -7.43605196e-02f, 3.66134010e-02f, 2.98845749e-02f, -5.34798317e-02f, -6.43971339e-02f, 1.41409799e-01f,
  5.30600324e-02f, 3.26610194e-03f, -9.07562301e-02f, -6.55479580e-02f, -1.36244213e-02f, -4.79089171e-02f, -1.19035216e-02f, -5.78860752e-02f, -1.01226538e-01f, 3.04436814e-02f,
  -2.69186020e-01f, -2.56679714e-01f, 6.92183077e-02f, -1.12695985e-01f, -8.84240791e-02f, 3.05643342e-02f, -1.63288355e-01f, -1.28314301e-01f, 3.74576785e-02f, -2.15319663e-01f,
  -3.81096080e-02f, 1.36459708e-01f, 1.67089179e-01f, 1.08507667e-02f, 8.08260292e-02f, -3.49114388e-02f, -1.04301460e-01f, -4.51474227e-02f, 1.89637646e-01f, -1.12416334e-02f,
  2.24123616e-03f, 2.87288651e-02f, -1.03633784e-01f, 3.04129254e-02f, -6.50400817e-02f, -4.94001526e-03f, -1.03404932e-01f, -2.40038689e-02f, -7.63060376e-02f, -1.96334451e-01f,
  -1.42060751e-02f, -3.51119302e-02f, 1.81488559e-01f, -4.55305837e-02f, -6.47620037e-02f, -3.60319540e-02f, -7.48103335e-02f, 7.83898085e-02f, -6.02403581e-02f, -4.35165353e-02f,
  3.24538760e-02f, 7.14697093e-02f, 2.95926165e-02f, 1.73558258e-02f, -5.28405011e-02f, -4.83352281e-02f, -1.02494610e-02f, -5.43931760e-02f, 4.90618311e-02f, 3.27465944e-02f,
  -3.04845744e-03f, -8.09365660e-02f, -7.36328214e-02f, 3.38336341e-02f, 1.30812051e-02f, 2.91012619e-02f, 6.94625601e-02f, -4.43515889e-02f, 5.85177802e-02f, -1.16116345e-01f,
  -1.54311359e-02f, -5.79022951e-02f, -4.41532349e-03f, 1.41108176e-02f, 3.67689356e-02f, 1.78086720e-02f, 2.00475603e-02f, 3.23808081e-02f, 8.06953534e-02f, -3.17257713e-03f,
  1.30451899e-02f, 4.66651516e-03f, -2.57667918e-02f, -5.47480918e-02f, -3.36922444e-02f, -9.95387230e-03f, -2.02117469e-02f, -7.28075728e-02f, -4.76202480e-02f, 6.15694001e-02f,
  8.31936225e-02f, 2.88402606e-02f, -7.30336308e-02f, 2.10590642e-02f, 5.29340841e-02f, 6.09720908e-02f, -6.78580478e-02f, 4.77882773e-02f, -1.47107113e-02f, -6.26647323e-02f,
  6.49238005e-02f, 2.06755713e-01f, 5.89848589e-03f, -2.09284499e-02f, -3.81732024e-02f, -4.16533835e-02f, -7.59917125e-02f, 7.05943555e-02f, -4.97143529e-02f, 8.88292938e-02f,
  -3.93935665e-02f, -7.25927055e-02f, 6.60891235e-02f, 4.66571525e-02f, -3.41841765e-02f, -3.04303840e-02f, -2.60416120e-02f, 5.45998700e-02f, -5.18024564e-02f, 1.07664932e-02f,
  -5.90655804e-02f, -1.15221299e-01f, 4.96060289e-02f, 4.46169786e-02f, -3.29357013e-02f, -3.42444330e-02f, 6.25719354e-02f, 6.70916913e-03f, -2.94612870e-02f, -6.32679164e-02f,
  2.26996049e-01f, 2.82570105e-02f, -1.97263762e-01f, -1.80009585e-02f, -1.04402415e-01f, -4.60776873e-02f, -6.97156414e-02f, 2.69832148e-04f, 5.99869713e-02f, 3.31028588e-02f,
  -5.48391491e-02f, 7.05360547e-02f, 1.03419926e-02f, 9.51685533e-02f, 8.96588340e-03f, -1.13153450e-01f, -5.70509881e-02f, 1.48492176e-02f, -2.16782326e-03f, 9.59278420e-02f,
  -1.24811539e-02f, -9.12492722e-03f, 5.68428114e-02f, 6.17149808e-02f, -1.19348735e-01f, -5.63254543e-02f, -8.35351571e-02f, 1.97455753e-02f, -9.96723771e-02f, -1.52503923e-01f,
  -9.54208300e-02f, 4.80408184e-02f, 3.14583257e-02f, 8.43728185e-02f, 1.27543160e-03f, 1.37649728e-02f, -6.34144023e-02f, 4.15087976e-02f, -1.28839472e-02f, -7.84610864e-03f,
  -4.10661735e-02f, 6.33027265e-03f, -2.56057153e-03f, -1.43930549e-02f, -1.08967852e-02f, 7.14922100e-02f, 2.61756312e-02f, -6.68965131e-02f, -6.84107468e-02f, 2.52079591e-02f,
  2.44007483e-02f, -1.16151068e-02f, -4.24900204e-02f, 2.51034126e-02f, -3.79592888e-02f, 1.36773312e-03f, -5.28560728e-02f, 2.74635083e-03f, -4.81625237e-02f, -1.03380889e-01f,
  4.23019268e-02f, -4.66518290e-02f, 1.93843525e-02f, -6.70819283e-02f, 2.35798042e-02f, -8.70214924e-02f, 2.44024079e-02f, -7.27095008e-02f, 3.37413959e-02f, -7.35419765e-02f,
  -1.26454849e-02f, -6.36635795e-02f, 5.86207993e-02f, -4.51829247e-02f, -4.74079736e-02f, 1.48039265e-03f, 5.70997223e-02f, 8.39937702e-02f, -4.72686067e-02f, 6.07190840e-02f,
  6.15664348e-02f, -4.71044518e-02f, 4.71032336e-02f, -6.09241892e-03f, 1.96496360e-02f, -9.85520557e-02f, 1.36289624e-02f, -4.52169888e-02f, 1.10237049e-02f, -4.07890193e-02f,
  4.55882400e-02f, 1.00351177e-01f, -5.39378077e-02f, -2.67583970e-03f, -3.46821779e-03f, -6.29542693e-02f, -3.57395373e-02f, 7.90249705e-02f, 1.12514727e-01f, 7.20693842e-02f,
  -6.39989087e-03f, 2.54206508e-02f, 6.25778362e-02f, -5.17246462e-02f, 5.89178875e-03f, -8.59583355e-03f, 4.44987081e-02f, 5.58072105e-02f, -4.42452505e-02f, -5.72177842e-02f,
  -4.58574109e-02f, -8.55463650e-03f, 7.37801492e-02f, -5.83456010e-02f, -7.34583586e-02f, 5.22699803e-02f, -1.01173691e-01f, -9.27072987e-02f, -1.66500881e-02f, -3.21039744e-02f,
  1.61960855e-01f, 2.10779816e-01f, 8.87031555e-02f, 1.14977352e-01f, -7.37791583e-02f, -2.54747551e-02f, -4.87161130e-02f, -5.44337928e-02f, -2.21720114e-02f, 6.22160062e-02f,
  8.10960829e-02f, 2.71686204e-02f, -3.57698798e-02f, 2.75611226e-02f, 6.70745894e-02f, -4.96865213e-02f, 9.56260115e-02f, -1.02623314e-01f, -1.09982096e-01f, -3.22442316e-02f,
  -1.58809483e-01f, 2.62198392e-02f, -2.37092879e-02f, 6.66987943e-03f, 1.55824106e-02f, -8.45258906e-02f, 5.18189631e-02f, 1.69029366e-02f, -2.52406634e-02f, 1.27217978e-01f,
  -1.61567941e-01f, 2.54064262e-01f, -6.68196231e-02f, 5.38284406e-02f, 3.82409617e-02f, 4.13367972e-02f, -2.95046289e-02f, 9.69817564e-02f, 1.89383291e-02f, 3.95604409e-02f,
  4.24018465e-02f, 2.74500549e-02f, 1.24342740e-01f, 3.80063318e-02f, 1.04649737e-01f, -4.35296930e-02f, 8.25211927e-02f, 9.55994725e-02f, -5.37716970e-02f, -3.72471735e-02f,
  -5.09310067e-02f, -3.95369454e-04f, 8.54773354e-03f, 3.01906057e-02f, 1.25287017e-02f, -2.87720598e-02f, 8.53076503e-02f, 4.41799164e-02f, 3.58071923e-02f, -5.70491180e-02f,
  -7.70140290e-02f, 4.21883203e-02f, -1.92517450e-03f, -5.07210083e-02f, 2.39789728e-02f, -2.32542097e-03f, 4.37991731e-02f, 2.33133603e-02f, -9.18357354e-03f, 3.58117893e-02f,
  1.49797006e-02f, -6.63322508e-02f, -5.77014722e-02f, -3.34817963e-03f, 8.04794673e-03f, 1.34289665e-02f, 5.32780308e-03f, -1.47938384e-02f, 8.90115350e-02f, -3.59854288e-02f,
  4.51455936e-02f, -3.68109830e-02f, 6.91155121e-02f, -4.27887887e-02f, -4.00454290e-02f, -3.47481284e-04f, -3.09062377e-02f, 8.86402093e-03f, 1.50919510e-02f, -5.10916449e-02f,
  -1.71810538e-01f, -3.54437367e-03f, -9.24085453e-02f, -7.15861144e-03f, -2.23845113e-02f, -1.42130479e-02f, 4.74888906e-02f, -2.94472799e-02f, 1.05190039e-01f, -6.46886379e-02f,
  1.18969247e-01f, 8.57401080e-03f, 9.37796310e-02f, -4.70349491e-02f, -1.08739048e-01f, -4.19570506e-02f, 4.13737893e-02f, -5.63464426e-02f, -1.11786656e-01f, -4.92538475e-02f,
  3.38022076e-02f, -1.77075610e-01f, -2.46445686e-01f, -4.13412564e-02f, 2.94386744e-02f, -2.17533112e-01f, -1.58751175e-01f, -1.58531949e-01f, -1.98812723e-01f, -2.56276608e-01f,
  -3.03543240e-01f, 1.47549212e-01f, -1.68997467e-01f, -1.24044679e-01f, -2.89289355e-02f, -2.68203653e-02f, 1.83738619e-02f, 8.31413493e-02f, 9.68674719e-02f, 2.90120859e-02f,
  1.64843664e-01f, 8.81985128e-02f, 5.66203482e-02f, -3.41307446e-02f, 4.86674234e-02f, -4.50993329e-02f, 2.95751486e-02f, -2.91420948e-02f, -8.04753825e-02f, 6.00955449e-03f,
  -3.64502962e-03f, -9.09662023e-02f, -6.53525144e-02f, -5.56058437e-02f, 1.82640888e-02f, -2.89711896e-02f, -8.40121433e-02f, 4.10798788e-02f, -2.93993056e-02f, 1.57168210e-01f,
  -4.66691852e-02f, -9.48991552e-02f, -9.80793908e-02f, -1.30517986e-02f, -1.02231530e-02f, -8.72398317e-02f, -4.25992534e-02f, -2.38968525e-02f, -4.56230268e-02f, -6.09212443e-02f,
  4.22065295e-02f, -5.86006418e-03f, -4.38885354e-02f, 1.20190252e-02f, -3.10684703e-02f, -6.19188957e-02f, -7.49269053e-02f, -1.22303084e-01f, -1.67205203e-02f, 6.35476410e-02f,
  8.29723179e-02f, 3.18546668e-02f, -1.15665309e-01f, -2.63612568e-02f, -2.47124024e-02f, 2.50787288e-02f, 8.36743042e-03f, -4.95337769e-02f, -9.15884599e-02f, -3.98577824e-02f,
  -2.90337801e-02f, 5.08106798e-02f, -4.57151607e-02f, -4.46782038e-02f, -8.04911647e-03f, 9.19570327e-02f, -1.84949301e-02f, 1.37925742e-03f, 2.73976587e-02f, -4.19176333e-02f,
  -3.42252813e-02f, -1.19760977e-02f, -2.73216832e-02f, 5.58365770e-02f, -5.61708994e-02f, 2.63484828e-02f, 1.70034859e-02f, -2.61669755e-02f, -4.47543189e-02f, -7.90056959e-02f,
  -7.77357146e-02f, -9.55223739e-02f, -1.73350554e-02f, 2.85606179e-02f, 8.93095974e-03f, -4.64777723e-02f, -2.92827259e-03f, 6.76402897e-02f, -8.49074498e-02f, 5.57331517e-02f,
  9.93952993e-03f, -4.34892625e-02f, 1.21840760e-02f, 8.82839318e-03f, -5.12355100e-03f, 3.33306827e-02f, 7.38946125e-02f, 1.04476872e-03f, -4.14010100e-02f, -4.38900031e-02f,
  1.00558186e-02f, -1.77689362e-02f, 3.91383618e-02f, 1.61868874e-02f, 5.64745851e-02f, 4.32052016e-02f, 8.31090435e-02f, -1.11312360e-01f, -1.11271061e-01f, 3.82087827e-02f,
  3.02553121e-02f, -1.21197943e-02f, -1.98587760e-01f, 1.08910154e-03f, -5.85647374e-02f, -1.29497334e-01f, -1.19930096e-01f, 4.14033569e-02f, -1.54401526e-01f, -7.90554956e-02f,
  -3.30525488e-01f, -6.42677024e-02f, -1.24394380e-01f, -6.11893274e-02f, 3.95633765e-02f, 5.23622259e-02f, -4.65951636e-02f, 1.18067060e-02f, -1.03912495e-01f, -6.52593449e-02f,
  6.73185214e-02f, 1.75498109e-02f, 8.10749712e-04f, 7.92354345e-02f, 1.40241114e-02f, 9.64874104e-02f, 1.19286411e-01f, 6.50600493e-02f, 3.68536599e-02f, 6.62399530e-02f,
  -4.26063919e-03f, -8.20592716e-02f, -1.11223660e-01f, -5.22438996e-02f, -6.18798733e-02f, 1.51377484e-01f, -2.71277223e-02f, -6.41282722e-02f, -2.28738077e-02f, -3.13834473e-02f,
  -1.59202479e-02f, -3.02001685e-01f, 1.77354053e-01f, 7.71383941e-02f, 1.98864918e-02f, -1.76004674e-02f, -4.06390689e-02f, -1.05827488e-01f, 2.42018923e-02f, 4.58266586e-02f,
  -9.70737338e-02f, -6.51780069e-02f, -5.66829741e-02f, -1.41629269e-02f, 2.67647356e-02f, -7.00694397e-02f, -7.37399235e-02f, -5.25401197e-02f, -6.83313459e-02f, -1.31838009e-01f,
  3.93073224e-02f, 3.61318067e-02f, -9.78263393e-02f, 7.09922388e-02f, -8.22067335e-02f, 9.40930694e-02f, -5.12535237e-02f, -1.60272747e-01f, -4.45172042e-02f, -5.76718673e-02f,
  6.03999831e-02f, 2.48845518e-02f, -4.01533507e-02f, -2.70053279e-02f, 8.05498436e-02f, 1.92231056e-03f, 6.30287006e-02f, -1.00812670e-02f, 4.60927263e-02f, -1.59843620e-02f,
  1.95469614e-02f, 2.75791343e-02f, -4.83035035e-02f, -5.01456186e-02f, -2.69874930e-02f, -2.91721281e-02f, 9.19389818e-03f, -4.95091975e-02f, 5.04979789e-02f, -4.73800115e-02f,
  1.17892427e-02f, 1.37061048e-02f, -1.08982287e-02f, -3.37475576e-02f, 7.09630363e-03f, 7.79645704e-03f, -7.72366812e-03f, 3.97657268e-02f, -1.36104831e-02f, -4.23395224e-02f,
  3.66882160e-02f, 8.47789124e-02f, -4.57367525e-02f, -6.24409802e-02f, -5.23267128e-02f, -7.85762910e-03f, 7.17230588e-02f, 2.78750360e-02f, 4.53611426e-02f, -5.55695295e-02f,
  3.36851291e-02f, -8.17512199e-02f, -5.63931502e-02f, 4.96302061e-02f, 1.12619363e-02f, 1.25870742e-02f, 1.24605335e-01f, -1.18964221e-02f, -7.81175261e-03f, 3.66707072e-02f,
  2.70242076e-02f, 1.70491275e-03f, 9.41353068e-02f, 6.26140311e-02f, -2.48661004e-02f, 1.35961235e-01f, 1.32772088e-01f, 1.12471700e-01f, 1.49642438e-01f, 1.37445703e-01f,
  1.03814043e-01f, 3.16988118e-02f, -2.60043964e-02f, -1.38746276e-02f, 8.46212283e-02f, 1.16452023e-01f, 2.86178172e-01f, 1.96796641e-01f, -9.85787585e-02f, -3.77420373e-02f,
  -4.32481281e-02f, -9.73951072e-02f, 6.89619929e-02f, -1.55040203e-02f, 8.51063356e-02f, 2.26865690e-02f, 2.88539696e-02f, 6.89067692e-02f, 1.13918930e-01f, 1.20164789e-01f,
  -1.07312560e-01f, 5.13874600e-03f, 9.59268063e-02f, -6.92875609e-02f, -1.25261709e-01f, -1.15919374e-01f, -9.15858448e-02f, -6.69662431e-02f, -1.09962836e-01f, -2.37465009e-01f,
  -1.93444192e-01f, -2.31022574e-02f, 1.11064710e-01f, -3.76024544e-02f, -9.31023434e-02f, -6.78007603e-02f, -1.31613342e-02f, -1.05156235e-01f, 7.90737867e-02f, -1.31996609e-02f,
  -7.73317814e-02f, -4.36309874e-02f, 3.27671058e-02f, -3.41335274e-02f, -5.14210388e-02f, -5.11305733e-03f, 1.75201353e-02f, 4.96354233e-03f, 9.20821279e-02f, 2.73996172e-03f,
  -1.15876101e-01f, -1.04068488e-01f, 1.26493862e-02f, 6.64654672e-02f, 7.63034970e-02f, -5.59952110e-02f, -1.61083546e-02f, -2.88030375e-02f, 1.91058349e-02f, -1.25535354e-01f,
  -1.52612636e-02f, -2.15133578e-02f, -5.72448634e-02f, 5.40173873e-02f, 2.22321879e-02f, -1.12789935e-02f, -2.48746760e-02f, 5.20554893e-02f, -2.56507117e-02f, 3.15027013e-02f,
  2.33870801e-02f, -2.62934994e-02f, -4.07398939e-02f, 1.42731657e-02f, 1.74316596e-02f, -6.84269741e-02f, -2.64188275e-02f, 1.36299087e-02f, -2.20478959e-02f, -1.55978072e-02f,
  2.81106066e-02f, 3.75478417e-02f, -3.51976193e-02f, 2.16812659e-02f, 4.29622596e-03f, 2.81165261e-02f, -7.69705400e-02f, 4.37668785e-02f, -3.25695835e-02f, 3.58365737e-02f,
  8.81080702e-03f, 1.56788036e-01f, -2.41634808e-02f, 6.08792603e-02f, -8.55788738e-02f, 1.37890484e-02f, 5.40920952e-03f, 3.82301360e-02f, -3.33877765e-02f, 1.29991360e-02f,
  8.08517635e-02f, 8.76588840e-03f, -4.65445556e-02f, -1.85485017e-02f, 7.52646178e-02f, -3.71346511e-02f, 3.08353221e-03f, 4.56300415e-02f, 1.25235051e-01f, -5.33573627e-02f,
  3.18660662e-02f, 1.54127672e-01f, 9.41672847e-02f, 1.22196950e-01f, -6.75412938e-02f, 8.83832127e-02f, 9.25069004e-02f, 4.26083580e-02f, 1.74035951e-01f, 1.65157720e-01f,
  -3.10799271e-01f, -2.43440419e-01f, 9.90080237e-02f, -5.84961884e-02f, 1.43308267e-01f, 1.10785402e-01f, 1.48150668e-01f, 7.44111016e-02f, -3.60673144e-02f, -3.75113711e-02f,
  -1.61285847e-01f, 7.77022308e-03f, 7.54774141e-04f, 4.04953510e-02f, 1.63546219e-01f, 1.81877553e-01f, 1.10558257e-01f, 1.73271582e-01f, 1.52983293e-01f, 1.82533652e-01f,
  2.19838899e-02f, -8.22909251e-02f, -1.01709083e-01f, -3.27550173e-02f, -2.38009319e-02f, 2.28201728e-02f, -2.71016806e-02f, -2.47993786e-02f, 1.07073886e-02f, -1.34452567e-01f,
  3.00475843e-02f, -2.04145551e-01f, 1.65387556e-01f, -4.50506434e-02f, 7.74947032e-02f, 6.22438900e-02f, -2.36782022e-02f, 7.62070119e-02f, -1.86080933e-02f, 2.98547801e-02f,
  5.31456321e-02f, 6.18229061e-02f, 3.58108580e-02f, -1.77679975e-02f, 3.38103026e-02f, 3.09152640e-02f, 4.72301543e-02f, 3.74056026e-02f, 5.45044243e-02f, -9.92529690e-02f,
  -4.41199690e-02f, -3.62510094e-03f, 5.25912903e-02f, 4.23764996e-02f, -5.55780046e-02f, 1.00987270e-01f, -9.06212628e-02f, -1.25435948e-01f, 3.68300751e-02f, -2.00562418e-01f,
  7.86698947e-04f, -6.06500208e-02f, 5.48245311e-02f, -1.02471091e-01f, 4.36323062e-02f, 9.46711898e-02f, -1.25860935e-02f, -2.76035387e-02f, -7.94874039e-03f, 2.03197487e-02f,
  -2.60609277e-02f, 5.44357337e-02f, -9.51229557e-02f, 2.94295885e-02f, 6.71479031e-02f, 1.74696166e-02f, 7.73502663e-02f, -6.60964996e-02f, -3.64070535e-02f, 9.47699137e-03f,
  -4.40913849e-02f, -1.23169385e-02f, 6.67533651e-02f, -4.97693792e-02f, -1.23459650e-02f, 6.70550615e-02f, 1.69387981e-02f, 2.96111237e-02f, -3.08684278e-02f, -9.63870063e-03f,
  -1.22388728e-01f, 1.08554937e-01f, 3.41575332e-02f, 1.63492635e-02f, 1.07372485e-01f, 1.82697189e-03f, -2.02951417e-03f, 4.57826629e-02f, -6.37534186e-02f, 5.62874340e-02f,
  7.73720583e-03f, 8.96647852e-03f, -5.49804047e-02f, -9.05990694e-03f, 8.58153217e-03f, 6.11734651e-02f, 1.60157923e-02f, 1.09839842e-01f, 4.61746342e-02f, -2.74235010e-03f,
  -4.25251387e-03f, 8.99186358e-02f, 7.94054344e-02f, 3.56747992e-02f, 1.83272008e-02f, 1.42607763e-01f, 1.11910895e-01f, 1.91194452e-02f, 1.65355191e-01f, -2.29554065e-03f,
  -1.29782885e-01f, 6.96260408e-02f, -4.47217599e-02f, -1.47854239e-01f, 1.21000642e-02f, 2.62590677e-01f, 3.99371296e-01f, 1.61074996e-01f, 4.48340550e-03f, 1.19385689e-01f,
  -4.04790137e-03f, -1.93124905e-01f, -2.01101631e-01f, -3.81867103e-02f, 4.88799028e-02f, 2.02788770e-01f, 1.45823449e-01f, -1.34018347e-01f, -1.17339246e-01f, 1.07137837e-01f,
  -1.86829492e-02f, -9.82175320e-02f, -1.74959183e-01f, -7.50428885e-02f, -5.44756949e-02f, -4.62218821e-02f, 8.55817571e-02f, -9.97246280e-02f, 9.06660855e-02f, -6.89459220e-02f,
  -1.29213452e-01f, 1.25716841e-02f, 3.52809206e-02f, -1.05170822e-02f, -1.02128334e-01f, 5.57686463e-02f, 6.25124872e-02f, -1.04522072e-01f, -9.25496370e-02f, -7.50849396e-03f,
  5.64844115e-03f, -2.23838557e-02f, -1.54588325e-02f, 2.92078834e-02f, -3.63595262e-02f, 5.92125114e-03f, 4.88613099e-02f, -1.51685447e-01f, -1.11418903e-01f, -1.90748461e-02f,
  -1.48096336e-02f, 3.79730836e-02f, -8.88653100e-02f, 3.87107506e-02f, -5.51580153e-02f, -4.29966673e-02f, 1.13202073e-01f, -5.36347069e-02f, -2.56671309e-02f, 6.88069463e-02f,
  5.20393588e-02f, 2.74843182e-02f, 5.48011698e-02f, 2.18641553e-02f, 1.09102027e-02f, 7.83965923e-03f, -4.19116504e-02f, 1.25582078e-02f, 3.09642358e-03f, 3.07316519e-02f,
  -5.09871952e-02f, -4.34773937e-02f, -8.63487646e-02f, 6.56387433e-02f, -6.41942546e-02f, -4.27585989e-02f, -7.23833358e-03f, 4.00950015e-02f, 1.97316315e-02f, 5.77863045e-02f,
  3.59574519e-02f, 4.75431867e-02f, -3.49781178e-02f, 3.77822705e-02f, 4.49549500e-03f, -5.11609623e-03f, -6.31363094e-02f, -1.90693699e-02f, -9.11412761e-02f, -8.08396414e-02f,
  -1.39898583e-01f, -2.14023609e-02f, -5.01146838e-02f, -4.26419862e-02f, 6.67441562e-02f, -3.73065919e-02f, 1.23864589e-02f, -2.47520041e-02f, 1.19589791e-02f, -5.88526502e-02f,
  -3.79205644e-02f, 6.82573840e-02f, 1.37324883e-02f, 8.14188570e-02f, 4.84507382e-02f, 6.03769012e-02f, -2.17644544e-03f, -6.01892658e-02f, -6.10314086e-02f, -2.33822642e-03f,
  4.22027558e-02f, 1.05709612e-01f, -6.07495643e-02f, 2.11136527e-02f, -8.75892937e-02f, -5.55445552e-02f, 6.78945556e-02f, 7.96993971e-02f, -4.92858402e-02f, 1.08762525e-01f,
  7.29625765e-03f, 1.66837126e-02f, -1.49570167e-01f, -5.62444478e-02f, -9.90124419e-02f, -6.00068308e-02f, -1.72574762e-02f, -1.42610706e-02f, 2.18093093e-03f, -6.27589524e-02f,
  1.11142538e-01f, 5.73561378e-02f, -6.29902855e-02f, -2.28469279e-02f, -1.10144764e-01f, -2.01435879e-01f, -1.98770657e-01f, -2.14756057e-01f, -1.52278244e-01f, -4.32794541e-02f,
  -3.49914841e-02f, -5.44880815e-02f, -5.53870481e-03f, -6.67535188e-03f, -4.32201708e-03f, -1.12994768e-01f, 4.21118066e-02f, -1.42365128e-01f, -4.53110076e-02f, -1.73113123e-01f,
  -1.95854813e-01f, -5.20491451e-02f, 5.30175455e-02f, 8.45665336e-02f, -4.18851040e-02f, 3.80913951e-02f, 6.27674237e-02f, 8.87015089e-03f, 5.57177588e-02f, -4.99385186e-02f,
  1.22417770e-02f, 4.54258732e-02f, 1.43736531e-03f, 4.02242430e-02f, 2.68727597e-02f, 4.26797234e-02f, 5.33508509e-02f, -2.72689592e-02f, 8.12323391e-03f, 9.22953784e-02f,
  -3.86121683e-02f, -6.35782108e-02f, -1.27377898e-01f, 2.11785063e-02f, -2.66369618e-02f, 2.59559532e-03f, -6.04278669e-02f, 9.74704400e-02f, -3.23073678e-02f, -9.76791140e-03f,
  5.47012826e-03f, -3.71550992e-02f, 3.58800590e-02f, 5.17576039e-02f, -5.12686111e-02f, 4.42415327e-02f, -4.99651115e-03f, -5.48044108e-02f, 3.07740849e-02f, -1.73279196e-02f,
  5.04554771e-02f, -5.31889573e-02f, -5.36020957e-02f, 7.80682489e-02f, 4.11715060e-02f, 9.37505811e-03f, -3.39064561e-02f, 5.12046665e-02f, -6.06612191e-02f, 1.61851887e-02f,
  -4.84601259e-02f, -4.07520644e-02f, 5.13735078e-02f, -3.59398164e-02f, 4.97040413e-02f, 2.31467392e-02f, -2.58074254e-02f, 1.48963288e-03f, -1.67343076e-02f, -8.92348401e-03f,
  2.89666466e-02f, 8.66419747e-02f, 8.07397813e-02f, -6.69084042e-02f, -2.37236433e-02f, -3.85061465e-02f, 7.77179375e-02f, -5.45302071e-02f, 9.03941542e-02f, -5.77369719e-05f,
  -3.02055478e-03f, 6.18667975e-02f, -6.05800711e-02f, -1.19544119e-02f, 5.76508082e-02f, -4.94440123e-02f, 1.02501817e-01f, 2.96763740e-02f, -5.27624041e-02f, 8.27804729e-02f,
  1.23214811e-01f, -1.13599755e-01f, -3.77616175e-02f, -5.82063459e-02f, -5.01078032e-02f, 1.86732803e-02f, -1.93223692e-02f, -6.46583214e-02f, -7.36133531e-02f, 9.69803855e-02f,
  9.65787098e-02f, 5.54415137e-02f, 2.35264469e-02f, 1.47439778e-01f, 1.35869473e-01f, -2.78177112e-02f, 9.73630995e-02f, 3.09294872e-02f, 4.51154895e-02f, -1.42718758e-02f,
  8.54069293e-02f, 8.78073946e-02f, 5.55186858e-03f, -4.25695740e-02f, 7.48139843e-02f, -1.68048013e-02f, 1.99916810e-02f, -4.58571799e-02f, 3.78081314e-02f, 2.79969219e-02f,
  1.12505592e-01f, 1.26941293e-01f, 5.49349077e-02f, 8.08637515e-02f, 1.22457378e-01f, 3.55299525e-02f, 1.62489563e-02f, 9.21280459e-02f, 9.86194015e-02f, 2.29643568e-01f,
  8.23591873e-02f, -1.72634833e-02f, 6.96859956e-02f, 1.00960515e-01f, -6.92795590e-02f, -3.79702002e-02f, -8.36564675e-02f, -8.34447518e-02f, 3.35595384e-02f, -6.72412291e-02f,
  -3.04446984e-02f, 3.54264490e-02f, 8.03149864e-02f, 4.56756987e-02f, 4.45735529e-02f, -2.43793167e-02f, 3.23497020e-02f, 9.49433132e-04f, 9.15075541e-02f, -3.31559218e-02f,
  1.09663889e-01f, 8.83825570e-02f, 2.33704206e-02f, -2.73541547e-02f, 3.86499912e-02f, -8.88625160e-02f, 4.01788466e-02f, -3.99442166e-02f, -2.51259226e-02f, 9.81102511e-02f,
  1.22704834e-01f, -9.27857012e-02f, 2.78066425e-03f, 8.09409916e-02f, 1.75105892e-02f, 6.70393109e-02f, 7.85038993e-02f, 1.52115999e-02f, -5.71862832e-02f, -3.54872495e-02f,
  1.97293255e-02f, -4.21052761e-02f, 1.03269536e-02f, 3.32376622e-02f, 9.98669118e-03f, -5.97440228e-02f, 4.66618463e-02f, 1.70697551e-02f, 2.86229886e-02f, 1.35089561e-01f,
  8.00568759e-02f, 1.23031149e-02f, -6.34517893e-03f, 7.66083375e-02f, 9.40229371e-02f, -3.41657735e-02f, -9.10115838e-02f, -1.17825560e-01f, -9.67695564e-02f, -1.17223943e-02f,
  -1.18103914e-01f, -6.19470812e-02f, -1.30316168e-02f, -7.23635703e-02f, 6.45641685e-02f, 4.29739878e-02f, 7.31768683e-02f, 4.59979475e-02f, 1.40600353e-02f, 6.41777813e-02f,
  -1.58138592e-02f, 7.71096572e-02f, -2.44266372e-02f, 9.29248519e-03f, -4.33465615e-02f, 8.08947012e-02f, -5.29547222e-02f, 1.16340004e-01f, 9.92691796e-03f, 6.02487028e-02f,
  -4.67905030e-02f, -3.84791270e-02f, -6.68470860e-02f, -7.42692575e-02f, -9.22249258e-03f, 3.49972881e-02f, -8.89356360e-02f, -8.45873207e-02f, -1.04525551e-01f, -1.11716725e-01f,
  -1.99768469e-01f, -7.13330284e-02f, -1.51753211e-02f, 5.65233044e-02f, -5.60438633e-02f, -5.12706339e-02f, -1.71537176e-01f, -3.69790308e-02f, 6.72065765e-02f, 2.95921471e-02f,
  2.66003609e-02f, 2.11329326e-01f, 1.84739497e-03f, 7.85937384e-02f, -1.55391758e-02f, -1.24148123e-01f, -4.17371467e-02f, -1.81334645e-01f, -1.42717868e-01f, 8.16848651e-02f,
  2.09508231e-03f, -3.99133563e-02f, -6.88805953e-02f, 5.69359912e-03f, -4.62800711e-02f, 5.89429773e-02f, -1.02800712e-01f, -2.34766304e-02f, -2.32359730e-02f, -6.05949834e-02f,
  1.68958843e-01f, 8.15202743e-02f, 3.07240523e-04f, 6.79441318e-02f, 2.55234390e-02f, -6.06866693e-03f, -3.72871533e-02f, 2.56965868e-02f, 1.06067419e-01f, 6.81367442e-02f,
  1.23445354e-01f, 1.22439802e-01f, 6.18692450e-02f, 5.61334155e-02f, -2.11914275e-02f, -5.90235777e-02f, 7.40709156e-02f, -1.39484420e-01f, 7.32020149e-03f, -6.17056154e-02f,
  5.47933280e-02f, -1.10066393e-02f, -1.19256623e-01f, -9.32801515e-02f, -2.58119442e-02f, -3.57443690e-02f, -8.47045630e-02f, 7.07048178e-02f, -1.54390186e-01f, -7.60157825e-04f,
  -2.79852632e-03f, 1.02671543e-02f, 4.93712462e-02f, -7.44821355e-02f, 4.51897979e-02f, -1.95433591e-02f, 4.87784296e-02f, -1.06569333e-02f, 2.83609219e-02f, -2.61264816e-02f,
  -2.52956860e-02f, -4.62676361e-02f, -1.74499173e-02f, 5.69114322e-03f, 8.70337114e-02f, -2.58996990e-02f, -2.55553075e-03f, -3.87030952e-02f, 2.38676625e-03f, 9.81845893e-03f,
  7.23723695e-02f, -7.00354427e-02f, 3.12474351e-02f, -1.41062075e-02f, 5.93779311e-02f, -8.53577405e-02f, 3.61404903e-02f, 4.20906506e-02f, -1.60766989e-02f, 6.51437640e-02f,
  1.92704499e-02f, -5.28563820e-02f, 3.34792994e-02f, -1.01596124e-01f, 1.77012496e-02f, -2.07254081e-03f, -3.76612134e-02f, 3.21685933e-02f, 1.93364769e-02f, -9.54325777e-03f,
  9.98637974e-02f, -2.65770834e-02f, 5.87728210e-02f, 8.76607653e-03f, 1.73701681e-02f, -2.17234232e-02f, -4.66427468e-02f, -1.08237974e-01f, -8.85651857e-02f, -4.89059351e-02f,
  -5.60592674e-02f, -1.83398407e-02f, -1.82420954e-01f, -2.42081974e-02f, -5.22295311e-02f, 2.45289486e-02f, 3.72004360e-02f, -1.21535063e-01f, -1.55349627e-01f, -1.97835639e-01f,
  -2.96740811e-02f, 2.47461885e-01f, 2.89468646e-01f, 4.30150889e-02f, 5.56559898e-02f, 6.56863898e-02f, 2.13215902e-01f, -6.86770901e-02f, 6.03783317e-02f, 3.14429924e-02f,
  -9.98397125e-04f, 3.35540138e-02f, 1.26566533e-02f, -5.61725497e-02f, 5.38378255e-04f, 2.56896198e-01f, 2.54821807e-01f, 5.06589152e-02f, -3.67148593e-02f, 5.71307493e-03f,
  4.55715992e-02f, -2.96661947e-02f, -1.23845618e-02f, -9.58832577e-02f, 2.00558733e-02f, 5.55073377e-03f, 5.79761527e-02f, 5.13986126e-02f, 1.17927417e-01f, 2.13462859e-01f,
  3.05599887e-02f, -2.11441610e-02f, -7.28739575e-02f, -6.72997832e-02f, 3.24063525e-02f, 1.17312940e-02f, 3.95014174e-02f, -5.56801520e-02f, 4.10683975e-02f, -4.38034013e-02f,
  -1.77261978e-02f, -4.27904464e-02f, 4.79177460e-02f, -8.08983371e-02f, 5.00113182e-02f, -7.77330697e-02f, 6.96232542e-02f, -2.01846473e-02f, -1.31250490e-02f, -1.36185279e-02f,
  3.84169668e-02f, 8.72960500e-03f, 5.52919656e-02f, 2.82796212e-02f, -6.49195164e-02f, -6.15738295e-02f, -7.20185265e-02f, -4.87684011e-02f, -3.35038602e-02f, 3.13941501e-02f,
  1.54262349e-01f, -3.51410769e-02f, -3.25080976e-02f, -2.92634945e-02f, -1.58653017e-02f, -6.33155778e-02f, 6.84111491e-02f, -2.50712000e-02f, -4.32228670e-02f, 1.94191467e-02f,
  -3.68701853e-02f, 8.07872787e-02f, -2.02163458e-02f, -1.01751937e-02f, 4.80707027e-02f, 7.56326411e-03f, -6.02987893e-02f, 8.40709731e-02f, 1.86024588e-02f, -3.20305191e-02f,
  -5.09152412e-02f, -9.88453850e-02f, -5.28534204e-02f, -1.16167953e-02f, 2.72584558e-02f, 1.49440533e-02f, 4.69859913e-02f, -6.21480234e-02f, -6.45461783e-04f, -3.31569687e-02f,
  2.82070935e-02f, 1.53653193e-02f, -1.93450158e-03f, -2.80146371e-03f, 7.73103908e-02f, 1.85228009e-02f, 2.35735420e-02f, -3.44446884e-03f, -2.80859433e-02f, 4.09427285e-02f,
  -2.11973898e-02f, 2.08624508e-02f, -1.78033207e-02f, 1.30646490e-02f, -4.35548723e-02f, -1.05217025e-01f, 8.42951834e-02f, -4.46371958e-02f, -1.98423080e-02f, -4.30894718e-02f,
  -1.03002731e-02f, 1.99075043e-03f, -1.33339256e-01f, -8.07421729e-02f, -2.43860036e-02f, -4.40913737e-02f, -2.15543318e-03f, 8.52264464e-03f, 2.10696901e-03f, -2.67433329e-03f,
  1.31125068e-02f, -1.83485616e-02f, 1.54416576e-01f, -2.86642555e-02f, 4.02792394e-02f, -6.34710267e-02f, -8.81866738e-02f, -1.33994043e-01f, -1.34556994e-01f, -1.81745775e-02f,
  -2.39517353e-02f, -9.56258252e-02f, -5.75542152e-02f, -1.74931448e-03f, 1.79624539e-02f, -1.03546508e-01f, 2.56674550e-02f, -5.50997928e-02f, -2.24702060e-03f, -1.00885496e-01f,
  -5.60366660e-02f, -1.23982422e-01f, 8.70184749e-02f, -1.11550177e-02f, 1.00404449e-01f, -5.68441823e-02f, 1.06661439e-01f, 7.13300612e-03f, -3.08223511e-03f, 4.43371050e-02f,
  2.16554567e-01f, 5.39617613e-02f, -9.73082241e-03f, 2.05616634e-02f, 7.20165744e-02f, -3.73985320e-02f, 8.47303867e-02f, 2.86413431e-02f, -6.27031401e-02f, 9.91565436e-02f,
  3.03327683e-02f, 4.61835973e-02f, -6.99281916e-02f, 1.06384508e-01f, 7.39488825e-02f, -5.29071130e-02f, 4.84511964e-02f, -2.22692005e-02f, 3.85420695e-02f, 8.61817524e-02f,
  -7.08439052e-02f, 1.09117202e-01f, 2.23612487e-02f, 3.95734981e-03f, 1.36451483e-01f, 6.34711310e-02f, 9.72112790e-02f, 1.30668432e-01f, 1.24741808e-01f, 8.58491585e-02f,
  -4.84879538e-02f, -1.56210014e-03f, 8.45960155e-02f, -6.77039772e-02f, -5.25606461e-02f, 2.64251363e-02f, 5.66190146e-02f, 4.40204479e-02f, -4.27401029e-02f, -5.27763143e-02f,
  -5.16051278e-02f, -4.05552238e-03f, -6.74787313e-02f, 4.40469980e-02f, -5.78729957e-02f, -3.19194905e-02f, 2.04297025e-02f, 7.38708973e-02f, 4.98852767e-02f, -3.27604227e-02f,
  3.07626985e-02f, 6.28010333e-02f, 2.90168542e-02f, 7.41461739e-02f, 5.09189554e-02f, 2.89842323e-03f, -3.83454934e-02f, -6.03222623e-02f, 8.29194396e-05f, 5.42035475e-02f,
  -7.48176649e-02f, 1.17618769e-01f, -2.87435949e-02f, -2.30532419e-02f, -5.61933294e-02f, -3.40568461e-03f, -5.77349998e-02f, 2.50175372e-02f, 2.86050886e-02f, 9.58938152e-03f,
  4.60418835e-02f, -8.28849748e-02f, 1.29600475e-02f, -8.30543041e-02f, -4.10233550e-02f, -7.39030316e-02f, -9.53305364e-02f, 2.24280022e-02f, -4.26535569e-02f, -8.35582912e-02f,
  -1.04709886e-01f, -1.70339704e-01f, -1.42219439e-01f, -5.85592613e-02f, -8.36678594e-02f, -1.01423055e-01f, -6.75508752e-02f, -4.88441363e-02f, -1.26052294e-02f, -2.20822707e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.14509939e-02f, -3.99860583e-04f, -1.88765153e-02f, 2.28036591e-03f, 2.76478343e-02f, -5.68655916e-02f, -1.47865713e-02f, 6.63430840e-02f, -2.85452884e-02f, -5.09682484e-03f,
  4.88990657e-02f, 3.57742719e-02f, 5.51060997e-02f, -3.45081091e-02f, -3.97035889e-02f, -2.69957613e-02f, 3.96341532e-02f, -1.01728767e-01f, -7.39076063e-02f, -5.43163158e-02f,
  -8.17828923e-02f, -7.55545273e-02f, -4.80693541e-02f, -2.19613891e-02f, 2.20466889e-02f, 4.39726701e-03f, -6.93204030e-02f, -4.36117779e-03f, -5.50254174e-02f, -7.24707246e-02f,
  -4.14969586e-02f, 3.90419848e-02f, 2.85962727e-02f, -7.24960417e-02f, 5.63831143e-02f, -1.23225152e-02f, -8.66556366e-04f, 8.61912519e-02f, -8.43548253e-02f, 1.40033220e-03f,
  -4.52524498e-02f, 7.48881251e-02f, 2.34585325e-03f, -8.09789374e-02f, -7.83296227e-02f, -4.67064083e-02f, -3.94083075e-02f, 6.91834912e-02f, 4.42687906e-02f, 5.96422777e-02f,
  2.89197136e-02f, 7.97290802e-02f, 2.04434874e-03f, 6.36048838e-02f, 1.00332797e-01f, -5.30066788e-02f, -9.42015648e-03f, -6.10367469e-02f, 9.76306126e-02f, 7.10003078e-02f,
  2.78510954e-02f, -9.24646780e-02f, -1.10726049e-02f, -6.20831884e-02f, -7.81641677e-02f, -6.59949034e-02f, -4.11755517e-02f, -4.41328681e-04f, -5.66394925e-02f, 7.82446414e-02f,
  -4.10510413e-02f, -1.83332004e-02f, 3.14724408e-02f, -5.76078193e-03f, 6.80097491e-02f, 2.56119594e-02f, -7.03591853e-02f, -2.76727416e-02f, -3.08589581e-02f, -1.50682935e-02f,
  8.01697671e-02f, -3.06037832e-02f, -2.48017572e-02f, 6.68050200e-02f, 6.88516814e-03f, 7.91120902e-02f, -1.65559500e-02f, 7.94519335e-02f, 6.83105662e-02f, -5.62980473e-02f,
  2.46395227e-02f, -8.24315846e-02f, -1.33131742e-02f, -5.00707328e-02f, -1.52302254e-02f, 6.14669581e-04f, -1.50583182e-02f, 8.54699239e-02f, 1.71533541e-03f, 7.01811090e-02f,
  2.69452017e-02f, 6.74398057e-03f, -2.02232436e-03f, 5.31890951e-02f, -4.97120479e-03f, 5.18312119e-02f, -9.47513729e-02f, -6.03351779e-02f, 2.16769474e-03f, 2.06222329e-02f,
  -6.84381872e-02f, -2.24517398e-02f, -3.28409970e-02f, -6.23715371e-02f, -1.54894972e-02f, 2.68020434e-04f, 1.02785066e-01f, -4.98177074e-02f, 2.83846352e-02f, -7.05948845e-02f,
  6.94928765e-02f, -8.89206305e-02f, -7.72713795e-02f, 2.98691262e-03f, 1.92439258e-02f, -3.05068004e-03f, 6.54596314e-02f, 1.63080487e-02f, -5.86304031e-02f, -4.57478948e-02f,
  -4.37723510e-02f, 1.20000526e-01f, -4.74916324e-02f, -2.76654661e-02f, 3.16827558e-02f, -9.88273770e-02f, -1.29412979e-01f, -1.30626142e-01f, 7.41079915e-03f, 2.23392919e-02f,
  6.96856156e-03f, 1.51149770e-02f, -5.24473414e-02f, 4.09147143e-02f, -8.18945616e-02f, -4.26220931e-02f, 8.71582981e-03f, -1.55605590e-02f, 1.36239426e-02f, -7.28270563e-04f,
  6.58833608e-03f, 1.07007056e-01f, -2.75738686e-02f, 8.76595229e-02f, 2.81038601e-02f, -2.41482491e-03f, 9.44353789e-02f, 5.16134016e-02f, 2.52309106e-02f, 5.91331497e-02f,
  1.11650638e-02f, -7.36334920e-02f, 5.57976030e-03f, -7.14565516e-02f, -5.49970753e-02f, 5.63173555e-02f, -1.35332868e-01f, -1.23667911e-01f, -2.16701557e-03f, -1.41607551e-03f,
  4.65199202e-02f, -3.95616181e-02f, 7.55079687e-02f, -9.97218117e-02f, -9.46837887e-02f, -7.66516775e-02f, -7.19831586e-02f, -5.18017896e-02f, -2.16075242e-03f, 7.17290863e-03f,
  4.18510176e-02f, -8.77171978e-02f, 2.88715009e-02f, 5.15907593e-02f, 4.85934466e-02f, 4.09365594e-02f, 8.79788119e-03f, -7.63170421e-04f, -7.13904202e-02f, -6.14193119e-02f,
  -5.60821034e-03f, -4.25770432e-02f, -5.95112145e-02f, 6.44968227e-02f, -1.95569377e-02f, -6.08366728e-02f, 2.80299168e-02f, -5.84044307e-03f, -3.91821451e-02f, 4.15906645e-02f,
  1.59888323e-02f, -3.70342545e-02f, -3.72477882e-02f, -6.91205040e-02f, -3.24385166e-02f, -1.24783039e-01f, 2.56417319e-02f, -6.28086925e-02f, 5.35076149e-02f, 3.71266343e-02f,
  8.62812921e-02f, 4.62169206e-04f, -4.43903245e-02f, -1.76323298e-03f, -4.08965256e-03f, -8.83612707e-02f, -8.50862116e-02f, 5.38453199e-02f, 1.47652561e-02f, 5.39773442e-02f,
  8.53397027e-02f, -5.56647480e-02f, 1.37437731e-02f, -7.67601281e-02f, -6.21892214e-02f, -3.37523706e-02f, -1.15623131e-01f, -9.63324308e-02f, -8.49141739e-03f, -2.40082853e-02f,
  -4.11802977e-02f, -9.59695429e-02f, -5.59840053e-02f, 2.40516253e-02f, -1.91960856e-02f, 7.91125745e-02f, 4.25265469e-02f, 3.14379558e-02f, -9.58725251e-03f, -5.30658774e-02f,
  4.79979254e-02f, -6.91667125e-02f, 6.45720437e-02f, 7.12409103e-03f, 4.25740927e-02f, 1.14348762e-01f, 1.35161132e-01f, 3.91392186e-02f, 1.01138111e-02f, 7.59869292e-02f,
  -7.15915114e-02f, -5.06581143e-02f, -1.38006017e-01f, 3.40998955e-02f, -1.05166309e-01f, 1.01752169e-01f, 5.15438579e-02f, 9.34188887e-02f, -7.53854364e-02f, -3.10618225e-02f,
  3.13425362e-02f, -4.35414724e-02f, 3.56771871e-02f, -8.42076465e-02f, 6.97849840e-02f, -7.52291679e-02f, 1.49076190e-02f, -4.48655449e-02f, -1.27359834e-02f, 2.69918479e-02f,
  -2.25161333e-02f, -1.37316901e-03f, -8.83381739e-02f, -7.75416866e-02f, -3.23639251e-02f, 2.03811582e-02f, -3.04770581e-02f, -1.86198354e-02f, -4.62670177e-02f, -3.54652219e-02f,
  5.55606699e-03f, -9.64130983e-02f, -4.39290777e-02f, -5.38339615e-02f, -4.68776822e-02f, 7.74622411e-02f, -6.69581145e-02f, -9.25136060e-02f, 6.76096929e-03f, -3.60540152e-02f,
  5.26366346e-02f, 7.46758729e-02f, 1.72335394e-02f, -8.80354121e-02f, 3.38336937e-02f, 5.34931757e-02f, -1.62361935e-02f, -6.42065033e-02f, 3.92483510e-02f, 5.28431460e-02f,
  -5.04285321e-02f, 3.28447074e-02f, 7.00747371e-02f, -5.22269756e-02f, 4.57787029e-02f, -4.83328551e-02f, -1.50331366e-03f, 3.97872031e-02f, -2.45824568e-02f, 6.94741234e-02f,
  -8.54883417e-02f, -4.71132733e-02f, 7.03545511e-02f, -5.11929616e-02f, 3.46057117e-02f, 6.89407885e-02f, -1.50201749e-02f, -1.02683231e-01f, -2.77853776e-02f, -7.76305124e-02f,
  6.60051629e-02f, -5.13108782e-02f, 6.88020959e-02f, 7.57734552e-02f, -6.65147007e-02f, 2.34047114e-03f, -7.62082785e-02f, -9.14285854e-02f, -9.62223262e-02f, -5.11555150e-02f,
  1.08185165e-01f, -1.05061300e-01f, 3.50306593e-02f, 1.29647767e-02f, -5.65625168e-02f, -8.66807327e-02f, 7.26937056e-02f, -6.14402676e-03f, 2.61574388e-02f, 1.00807540e-01f,
  7.84214959e-02f, -6.99372962e-02f, -1.43247759e-02f, 8.46123248e-02f, 1.00296862e-01f, 1.10592723e-01f, 4.40571085e-02f, 7.10265711e-02f, -3.43956612e-03f, -4.59120013e-02f,
  -1.97620820e-02f, 9.19835120e-02f, 1.19198501e-01f, -1.76276639e-02f, -2.29589324e-02f, -2.85129668e-03f, 1.16788961e-01f, -1.79002751e-02f, 5.49390316e-02f, 9.23456550e-02f,
  -5.47572449e-02f, -7.09156878e-03f, -5.83995208e-02f, -2.96421386e-02f, -8.61723721e-02f, 4.53980416e-02f, -5.31302020e-02f, 1.01094201e-01f, -5.87957948e-02f, 2.02846397e-02f,
  9.09407064e-03f, 1.78167541e-02f, -2.68101785e-02f, -5.75019978e-02f, -1.03598908e-01f, -1.14681991e-03f, 2.30243653e-02f, -1.02376968e-01f, -1.24534376e-01f, -8.38118196e-02f,
  -4.32485417e-02f, 5.68628907e-02f, -1.04499847e-01f, -1.05159290e-01f, -9.57494136e-03f, -6.23788163e-02f, 4.99118213e-03f, -1.03285521e-01f, -3.33380401e-02f, 6.42219558e-02f,
  1.35182042e-03f, -5.06373346e-02f, 6.86619133e-02f, 4.41900119e-02f, -1.71187166e-02f, 6.27766103e-02f, 5.84674701e-02f, 3.87974940e-02f, 8.90137628e-02f, 9.30805132e-02f,
  -1.98524464e-02f, 1.99224409e-02f, 7.66974129e-03f, -3.18978238e-03f, 8.56584981e-02f, 3.34234275e-02f, -6.04952239e-02f, 6.75375611e-02f, 3.59364487e-02f, 7.77065456e-02f,
  -7.77952448e-02f, 4.88866046e-02f, -1.01062059e-01f, -8.03513676e-02f, -9.56934225e-03f, 6.15085810e-02f, -8.92737359e-02f, -1.32014854e-02f, -7.96057507e-02f, -1.14103016e-02f,
  5.03637567e-02f, -7.17532560e-02f, -2.05032676e-02f, 7.10843652e-02f, -9.91920568e-03f, -2.87065171e-02f, -2.38139927e-02f, -1.60823576e-02f, -5.91923483e-03f, 8.14249441e-02f,
  -6.65691122e-02f, 7.64468312e-02f, 4.69898842e-02f, 8.02141353e-02f, 2.81792339e-02f, -1.37754809e-02f, -8.36044103e-02f, 6.96479455e-02f, 1.67074166e-02f, -1.53645943e-03f,
  -4.50386815e-02f, -6.80508977e-03f, 7.20979497e-02f, 4.58418243e-02f, 1.43588369e-03f, -3.20208212e-03f, -1.77112445e-02f, 5.39263785e-02f, 3.49942222e-02f, 9.52043235e-02f,
  5.51006794e-02f, -3.45662199e-02f, 1.00655593e-01f, -6.93777651e-02f, -4.62707579e-02f, -4.33264039e-02f, -3.36820409e-02f, 9.06044841e-02f, -3.07169612e-02f, -5.74593805e-02f,
  -9.77037847e-03f, 9.67489276e-03f, 5.11434749e-02f, -6.56047929e-03f, -1.79556701e-02f, -8.94770250e-02f, -4.35929559e-02f, -2.94341538e-02f, -1.36587350e-02f, 3.51178311e-02f,
  -4.39437293e-02f, 2.42184829e-02f, -7.95150325e-02f, 2.59159878e-02f, 3.36818248e-02f, -6.99438974e-02f, -6.45137280e-02f, 4.90338318e-02f, -6.15822064e-05f, 1.54176420e-02f,
  -1.32371821e-02f, 4.11231257e-02f, -4.78853993e-02f, 6.89120367e-02f, -1.22991338e-01f, 2.56339312e-02f, -1.40013024e-01f, -3.57245989e-02f, 4.59036529e-02f, 8.72615352e-03f,
  -4.74751517e-02f, 7.20195845e-02f, -4.18808647e-02f, -6.92379549e-02f, -7.76064917e-02f, 2.46399664e-03f, -1.06381387e-01f, 5.71775027e-02f, 8.32301155e-02f, -6.66152760e-02f,
  6.26248792e-02f, 5.42190596e-02f, -1.38858277e-02f, 2.74459049e-02f, -7.34108165e-02f, -4.70861085e-02f, -5.61359152e-02f, -8.74667019e-02f, 4.80128303e-02f, 6.69358000e-02f,
  4.47729006e-02f, 5.46636768e-02f, -1.99004207e-02f, 2.91880053e-02f, -4.82724383e-02f, 3.44080143e-02f, -6.93792850e-02f, 7.98726454e-02f, 3.06275692e-02f, 7.91198686e-02f,
  -2.04279870e-02f, 9.33100581e-02f, -5.25414497e-02f, -5.45592979e-02f, 5.62875345e-02f, -1.12663144e-02f, -4.82753739e-02f, -6.51966333e-02f, -2.57998370e-02f, 5.37604913e-02f,
  -3.60968895e-02f, -6.85369447e-02f, 3.91789079e-02f, 6.05202932e-03f, -7.90978521e-02f, 4.85944897e-02f, 4.01146291e-03f, 6.55781850e-02f, -5.97642362e-02f, -2.72928979e-02f,
  5.43242693e-02f, -2.24978058e-03f, 1.54937925e-02f, -2.17544064e-02f, -4.44784388e-02f, 2.08141208e-02f, 5.29412888e-02f, 5.23898518e-03f, 8.49697068e-02f, -5.03781661e-02f,
  -6.99390098e-02f, -7.14301169e-02f, 6.19526319e-02f, 5.92611693e-02f, -4.09490988e-02f, -3.60011235e-02f, -1.63716567e-03f, -7.91297033e-02f, 3.15643437e-02f, 3.16030830e-02f,
  6.95829839e-02f, -5.37653677e-02f, 4.70905157e-04f, 8.35726596e-03f, -1.68762561e-02f, -3.25870737e-02f, -4.33595327e-04f, 3.03839836e-02f, -4.73547354e-02f, -1.37407174e-02f,
  -4.01856452e-02f, 3.52146588e-02f, -1.42864976e-02f, 9.46232080e-02f, -3.66943218e-02f, 4.29801904e-02f, 7.02894777e-02f, 6.13967925e-02f, 9.23062935e-02f, 6.40997365e-02f,
  -2.05568597e-02f, -1.10054370e-02f, 3.18077183e-03f, -5.68737276e-02f, 1.34088891e-02f, -5.87858371e-02f, 2.91638379e-03f, 8.83682538e-03f, -4.50289883e-02f, 6.84342906e-02f,
  -9.27778799e-03f, -3.13736349e-02f, 7.13811070e-02f, -5.77173419e-02f, -7.46631101e-02f, 3.73466350e-02f, 1.33453654e-02f, -8.23053345e-02f, -8.27383474e-02f, 5.10255285e-02f,
  -1.64893195e-01f, 1.25655010e-02f, 3.78715694e-02f, -9.67110544e-02f, -1.04414336e-01f, 1.13753313e-02f, -4.34979843e-03f, -6.66437894e-02f, -4.21412066e-02f, 5.49538098e-02f,
  1.07685871e-01f, 1.77455496e-03f, 2.23224619e-04f, -7.15876967e-02f, -7.88286552e-02f, -1.28515959e-01f, -7.23536611e-02f, -5.19055724e-02f, -7.53202215e-02f, -2.57911384e-02f,
  3.72173218e-03f, -7.51100332e-02f, -3.68537679e-02f, 3.04064564e-02f, 6.33608326e-02f, 6.06728569e-02f, -6.03722082e-03f, -4.38786037e-02f, 6.66710287e-02f, -5.06604239e-02f,
  1.63659021e-01f, -8.10797513e-02f, -8.81148502e-02f, -6.92783594e-02f, -7.67119825e-02f, -1.92877185e-02f, 6.64768890e-02f, -6.80831745e-02f, -8.45842659e-02f, 4.06994410e-02f,
  -3.90010839e-03f, 7.51343146e-02f, 7.85251334e-02f, 8.60038549e-02f, 3.00300140e-02f, 4.06730510e-02f, 2.28377674e-02f, 1.31971985e-02f, 7.17446879e-02f, -1.92209873e-02f,
  9.58401486e-02f, 6.45898432e-02f, -6.08037524e-02f, -1.76264197e-02f, 6.99749440e-02f, -6.53172955e-02f, -1.48942079e-02f, 4.79608774e-02f, -4.74119335e-02f, 5.90989739e-02f,
  -1.50965722e-02f, 3.65400761e-02f, -4.76979204e-02f, 5.60020320e-02f, 4.95846421e-02f, -2.17836592e-02f, -8.62302631e-02f, -9.79864746e-02f, 6.95182756e-02f, 7.91351274e-02f,
  3.72912991e-03f, -2.85548903e-02f, 3.04547977e-03f, 6.36454225e-02f, -5.63843325e-02f, 1.00447955e-02f, -9.29278210e-02f, -8.43387470e-02f, -3.71239223e-02f, -5.54184476e-03f,
  -7.57924339e-04f, 3.91416624e-03f, 3.50460857e-02f, -5.37006110e-02f, -8.30077305e-02f, 6.54290766e-02f, -7.72271380e-02f, 3.95701043e-02f, 2.98702773e-02f, 4.30383906e-02f,
  1.64558575e-01f, -3.72190289e-02f, 2.14358065e-02f, -9.03461426e-02f, -8.77282321e-02f, 5.36984578e-02f, -1.27092302e-02f, -3.31494585e-02f, -7.95910358e-02f, -5.21932393e-02f,
  -7.87565298e-03f, 3.75479497e-02f, 3.79054509e-02f, 2.73351893e-02f, 1.71166286e-02f, 8.39922354e-02f, 6.38975501e-02f, -1.80529561e-02f, 6.81781247e-02f, 4.90469821e-02f,
  -6.63132146e-02f, -2.05272492e-02f, -4.43324856e-02f, -3.33822295e-02f, -1.35371108e-02f, -3.84046920e-02f, 1.03245832e-01f, 2.63501541e-03f, 3.43896411e-02f, -4.14510118e-03f,
  -1.07035793e-01f, -1.89812891e-02f, -6.78211600e-02f, 6.90449998e-02f, 1.36548921e-01f, 1.31262854e-01f, 1.38174951e-01f, 7.58622885e-02f, 1.13560833e-01f, 7.33021796e-02f,
  1.26612857e-01f, 6.34118468e-02f, 7.90063739e-02f, 9.11054984e-02f, 2.41096672e-02f, 4.04049009e-02f, 1.11789815e-01f, 4.72640730e-02f, -1.36338612e-02f, -5.34071214e-02f,
  4.92899679e-02f, -4.92879152e-02f, -1.00711681e-01f, 2.26387940e-02f, -5.38437590e-02f, 1.21299945e-01f, -5.49023505e-03f, 5.66735379e-02f, -3.93970422e-02f, 2.26331893e-02f,
  1.13948258e-02f, -9.22822505e-02f, 8.12843367e-02f, -1.29546914e-02f, -1.00437663e-01f, 3.40404995e-02f, -1.03243031e-01f, -6.99079484e-02f, -2.68265121e-02f, -9.97022726e-03f,
  -2.44842991e-02f, -1.05197854e-01f, -4.11618426e-02f, -4.46444750e-02f, 3.94261964e-02f, -1.98803213e-03f, -2.28158385e-02f, -1.79351922e-02f, -3.58993970e-02f, 5.93393482e-02f,
  -4.87669408e-02f, -7.90948700e-03f, -1.20709110e-02f, 9.14108008e-02f, 5.55385835e-02f, 3.89814861e-02f, -9.31805223e-02f, 3.50712724e-02f, 4.66292575e-02f, -2.56772954e-02f,
  -5.72856553e-02f, 4.80285985e-03f, 3.68498564e-02f, -4.90613878e-02f, 4.55266275e-02f, 8.38784203e-02f, -1.43617429e-02f, 2.22735032e-02f, 2.76543926e-02f, 4.08247560e-02f,
  8.22125599e-02f, 2.20620129e-02f, 2.65157185e-02f, 3.97896618e-02f, 3.56114693e-02f, 6.77793566e-03f, -7.50941336e-02f, -7.13694915e-02f, -4.30819318e-02f, -5.82599267e-02f,
  9.88705084e-02f, -4.42108186e-03f, 2.16166582e-02f, 5.08635789e-02f, 2.15631668e-02f, -6.38486147e-02f, 5.22428341e-02f, -5.47633208e-02f, 3.52369621e-02f, 5.70822731e-02f,
  -5.29616587e-02f, 1.00938966e-02f, 7.76031688e-02f, 2.55696266e-03f, 1.23507539e-02f, -1.05308391e-01f, 1.70238819e-02f, -5.73013723e-03f, -6.81106597e-02f, -8.09203275e-03f,
  1.88777363e-03f, 3.81978638e-02f, -6.56147078e-02f, 5.02580367e-02f, 5.83210923e-02f, 3.60049605e-02f, -1.44876428e-02f, -2.94677578e-02f, 1.07834771e-01f, 4.41805907e-02f,
  -2.24803411e-03f, 2.59153545e-02f, -1.92883089e-02f, 8.41108784e-02f, 1.94161665e-02f, -1.19893032e-03f, -6.63658082e-02f, -7.84280002e-02f, 7.33765028e-03f, -2.48647481e-02f,
  -3.03354524e-02f, 4.73399237e-02f, -1.06107712e-01f, 5.07372897e-03f, -6.15814477e-02f, -4.79256921e-03f, 3.69564295e-02f, 9.39717703e-03f, -5.93619198e-02f, 2.01825909e-02f,
  -3.83136310e-02f, -8.53756070e-03f, -3.68981175e-02f, 2.67495830e-02f, 8.36049579e-03f, -6.44368902e-02f, -2.02990714e-02f, -6.29448444e-02f, 7.43962452e-02f, 8.05002972e-02f,
  3.55490819e-02f, -6.17246069e-02f, -4.29220386e-02f, -1.36850178e-02f, 2.32298002e-02f, -6.01103231e-02f, 4.79991399e-02f, 5.51096462e-02f, 5.78174107e-02f, -8.73580575e-02f,
  -3.00904810e-02f, -7.99217224e-02f, 2.96205785e-02f, 7.94843212e-03f, -9.20970365e-02f, -8.61527696e-02f, 3.99088785e-02f, -9.43554332e-04f, -5.09075411e-02f, -4.23451327e-02f,
  5.16880974e-02f, -1.03525743e-01f, 2.22159903e-02f, -1.42801423e-02f, 7.66670853e-02f, -3.43016759e-02f, 8.42042342e-02f, 2.41247509e-02f, -4.07981724e-02f, -1.01518944e-01f,
  2.60832030e-02f, -4.72513400e-02f, -9.64123383e-02f, 6.70795962e-02f, 2.84099504e-02f, 6.38995245e-02f, -9.26074088e-02f, -8.74323118e-03f, -7.63480440e-02f, -5.64447679e-02f,
  -3.78711708e-02f, 4.53840010e-02f, 3.17460150e-02f, 5.19728176e-02f, -7.92621300e-02f, 2.59050317e-02f, 3.92495766e-02f, 1.16342138e-02f, -1.93700474e-02f, -3.76231223e-02f,
  1.47151686e-02f, -1.09936371e-02f, -5.30013479e-02f, 4.34834287e-02f, -4.15918082e-02f, 4.17956486e-02f, 2.69716922e-02f, 4.66136225e-02f, 1.26880929e-02f, 4.34232354e-02f,
  1.67375561e-02f, 8.00195113e-02f, 4.00525145e-02f, 4.27732505e-02f, 4.01861258e-02f, 4.44524698e-02f, 8.57075304e-03f, -8.34662989e-02f, 7.50238746e-02f, 3.26424204e-02f,
  2.99825855e-02f, -6.40062839e-02f, -8.56393278e-02f, 2.84398813e-02f, 2.12095995e-02f, -9.47371572e-02f, -5.76733164e-02f, 7.60406405e-02f, -2.64332406e-02f, -8.62958208e-02f,
  -4.41800468e-02f, 1.86851192e-02f, -2.86718383e-02f, 6.90958872e-02f, -3.62062827e-02f, 4.49977629e-02f, -5.77265695e-02f, 6.42166734e-02f, 1.74432304e-02f, 2.77640056e-02f,
  -4.00711894e-02f, 9.31565687e-02f, 8.72362871e-03f, 3.22986860e-03f, -8.60638842e-02f, 9.42395180e-02f, 9.80126560e-02f, 2.44353618e-03f, 1.79613419e-02f, -2.44554840e-02f,
  -3.48502770e-02f, -8.31724033e-02f, -1.71071384e-02f, 6.85422495e-02f, -7.56093264e-02f, -1.30685270e-01f, -1.12430707e-01f, -3.14012356e-02f, -8.04160163e-02f, -1.13519579e-01f,
  -6.94134757e-02f, -5.43506294e-02f, -2.33766995e-02f, 2.41813008e-02f, 8.81935284e-02f, 3.76332365e-02f, 1.26234004e-02f, 6.60566762e-02f, -9.59191564e-03f, -2.76877601e-02f,
  5.28902337e-02f, 6.82623163e-02f, -3.81444879e-02f, -9.03638359e-03f, -2.27917191e-02f, -7.24017082e-05f, -5.95903471e-02f, 6.07632175e-02f, -7.88912773e-02f, 2.15791967e-02f,
  -9.71416980e-02f, -2.26077605e-02f, 5.85719682e-02f, 7.71163311e-03f, -1.01616286e-01f, 3.32701728e-02f, 4.23404463e-02f, 5.21810241e-02f, -2.76259556e-02f, -4.13175859e-02f,
  7.02964216e-02f, 2.71315947e-02f, -4.71673235e-02f, 3.11268885e-02f, -1.02478214e-01f, -8.00931826e-02f, 5.41725010e-03f, 3.47467093e-03f, 1.36707360e-02f, 4.23239172e-02f,
  -2.57238038e-02f, 6.03728741e-02f, 8.49606916e-02f, 7.53175318e-02f, 7.80796558e-02f, 3.74868214e-02f, -2.70623472e-02f, -4.89401035e-02f, 2.66302414e-02f, -8.04553777e-02f,
  -5.23964688e-02f, 6.73583290e-03f, -8.73696953e-02f, 9.30435956e-03f, -2.58605480e-02f, -8.20186436e-02f, -4.56517152e-02f, -4.24371399e-02f, 5.83279505e-02f, 5.37964702e-02f,
  -9.08682942e-02f, -4.86462191e-02f, -1.25369020e-02f, 4.95471321e-02f, 1.45063819e-02f, 4.32471596e-02f, -1.12844920e-02f, 4.17014733e-02f, 9.52603817e-02f, 3.01340017e-02f,
  -3.00206877e-02f, -3.62797156e-02f, -9.64914039e-02f, -6.63787201e-02f, -1.56739447e-02f, 5.42058609e-02f, -2.03398913e-02f, 9.61428508e-02f, 7.96514601e-02f, 1.09132724e-02f,
  -2.41655973e-04f, 3.43756340e-02f, 4.27369438e-02f, 3.05163767e-02f, -3.46550456e-04f, 6.43504113e-02f, -6.74972460e-02f, 1.59576051e-02f, -2.49019340e-02f, -8.44565704e-02f,
  8.13016389e-03f, 3.46604846e-02f, 2.96240989e-02f, -2.69517042e-02f, -3.12838405e-02f, -1.69161651e-02f, 7.13430345e-02f, 5.15017211e-02f, 8.31542909e-02f, 4.58761901e-02f,
  -2.21716557e-02f, -5.43603562e-02f, 7.97380656e-02f, -4.04219404e-02f, -6.22430164e-03f, 8.65946859e-02f, -8.01019445e-02f, -6.02061413e-02f, 3.58596854e-02f, -9.37998220e-02f,
  -6.31962046e-02f, -3.91050689e-02f, -6.20097332e-02f, 2.04816431e-01f, 3.92680988e-02f, 1.67885271e-03f, 1.03217386e-01f, 4.35278490e-02f, 1.76720083e-01f, 6.74583986e-02f,
  1.28964677e-01f, 1.06436998e-01f, 9.61968973e-02f, 1.48957461e-01f, -2.95652878e-02f, 1.50118634e-01f, 1.39491335e-01f, 5.90238012e-02f, 9.07312706e-02f, 8.37436989e-02f,
  1.61520049e-01f, 3.17246728e-02f, -6.85649589e-02f, 1.17143929e-01f, 1.08847305e-01f, 4.66620922e-02f, 1.65334046e-02f, 1.60922483e-02f, -5.20221293e-02f, 5.80510907e-02f,
  -6.27918020e-02f, -1.48175955e-01f, 1.04427874e-01f, -8.44979361e-02f, -1.05160229e-01f, 2.01881602e-02f, 8.35387036e-02f, -8.03094655e-02f, -2.24682409e-02f, -9.28267166e-02f,
  1.21958498e-02f, -7.01990873e-02f, 4.07472700e-02f, -7.71855712e-02f, 3.27668968e-03f, -7.54561275e-02f, 5.64484391e-03f, -6.46317080e-02f, 8.39717686e-02f, -3.23162675e-02f,
  1.19278133e-01f, 5.47228269e-02f, -1.18620001e-01f, 1.13079464e-02f, 3.08792349e-02f, -1.74731463e-02f, -3.23772850e-03f, -1.09173218e-02f, 9.25338641e-03f, 7.61444941e-02f,
  -2.59905756e-02f, -1.47137586e-02f, 1.71935167e-02f, 8.08065608e-02f, -1.18937902e-02f, 1.03167161e-01f, 8.75557140e-02f, 6.32892251e-02f, 1.99963301e-02f, -2.47156769e-02f,
  -6.40665228e-03f, -4.71820049e-02f, -2.42993496e-02f, 9.29577127e-02f, 4.57448699e-03f, -3.61608737e-03f, -7.73904547e-02f, 1.68495513e-02f, 1.46894995e-02f, -3.51637378e-02f,
  6.53776675e-02f, -5.36186434e-03f, -1.26665309e-01f, -2.87734959e-02f, 5.93440188e-03f, -3.28065865e-02f, 4.80101928e-02f, 3.20490114e-02f, -1.07532017e-01f, -5.15459627e-02f,
  -4.28489558e-02f, -8.46640319e-02f, 1.03327461e-01f, 7.30777606e-02f, 4.10542078e-02f, -1.03367597e-01f, 1.09226502e-01f, -3.03739347e-02f, 3.16825807e-02f, 3.98172475e-02f,
  1.67013537e-02f, -7.63546079e-02f, -4.69661988e-02f, -4.08301689e-03f, -3.15577462e-02f, -9.42799225e-02f, -9.77405999e-03f, 6.07059523e-03f, -6.90425634e-02f, 9.33261029e-03f,
  -3.96427251e-02f, 8.50731060e-02f, 1.39262136e-02f, -3.13104168e-02f, 4.02638428e-02f, 1.01469435e-01f, 4.46461812e-02f, 7.84417838e-02f, -1.74281467e-02f, -7.55307227e-02f,
  2.35482424e-01f, 2.15784416e-01f, 1.61654446e-02f, -1.98271088e-02f, -5.30817322e-02f, -2.79883947e-03f, 1.10466219e-01f, 2.29300149e-02f, -6.90811574e-02f, -4.84524295e-03f,
  3.94827276e-02f, -7.41685135e-03f, -1.83144137e-02f, -3.05802934e-02f, 3.81752080e-03f, -7.66053200e-02f, -1.47191929e-02f, 5.53803369e-02f, -7.50751495e-02f, 4.66288067e-02f,
  8.91149268e-02f, 2.33628601e-02f, 5.35402708e-02f, -5.65461330e-02f, 4.37088870e-02f, -3.54799889e-02f, 1.04975671e-01f, 1.10955492e-01f, -2.44668890e-02f, 6.42168522e-02f,
  -7.81504586e-02f, 1.43513605e-01f, -7.37085706e-03f, 2.50118170e-02f, -7.70054162e-02f, 1.39529398e-02f, 6.01858720e-02f, -4.16045301e-02f, -5.80828153e-02f, -2.20472291e-02f,
  -3.61885242e-02f, -6.55762702e-02f, 5.09799644e-02f, 6.83167204e-02f, -5.84630109e-02f, -6.44501597e-02f, 1.30168587e-01f, -2.37766318e-02f, 3.65254506e-02f, 6.62414208e-02f,
  2.53263507e-02f, -4.41806279e-02f, 7.01479092e-02f, 3.50164473e-02f, 4.07672152e-02f, -1.08949199e-01f, 6.85483515e-02f, 6.46796152e-02f, -9.17601138e-02f, 2.94151381e-02f,
  -4.14243340e-02f, -7.34772608e-02f, -8.64441022e-02f, -5.17192408e-02f, -4.60989634e-03f, -3.05378549e-02f, -3.25963646e-02f, 2.34031994e-02f, -5.36652235e-03f, -3.14925872e-02f,
  -1.43799384e-03f, -1.47728669e-02f, -3.58356014e-02f, 1.08371191e-02f, -8.41587037e-02f, -2.04055128e-03f, -6.21631294e-02f, 1.04391538e-02f, 9.77666769e-03f, 2.08293422e-05f,
  5.10955639e-02f, 3.09003126e-02f, -8.68454669e-03f, -5.19111678e-02f, -8.44823346e-02f, 2.27248091e-02f, 1.78380441e-02f, 1.77179445e-02f, 2.40610354e-02f, -5.57618551e-02f,
  1.27219884e-02f, -6.24635294e-02f, -1.11939488e-02f, 3.15936916e-02f, 3.35565954e-02f, -3.25906463e-02f, -5.95110320e-02f, 2.82811970e-02f, -3.07580102e-02f, -5.93279228e-02f,
  2.57121976e-02f, -2.45810170e-02f, -8.09884444e-02f, 5.50692528e-02f, -4.72528413e-02f, -7.35178441e-02f, 9.64624956e-02f, 5.03346734e-02f, 2.18523550e-04f, 3.24422978e-02f,
  -3.32356431e-02f, 2.20544171e-02f, -9.39260945e-02f, -2.69872416e-02f, -3.94938476e-02f, -9.01374742e-02f, -6.52607381e-02f, -2.42264960e-02f, -1.14067055e-01f, 1.00309312e-01f,
  1.20440707e-01f, 7.49321878e-02f, 4.96457554e-02f, -6.61432091e-03f, -8.20673630e-02f, -5.55543751e-02f, -6.39476702e-02f, 2.32219435e-02f, 4.99595478e-02f, -4.94711921e-02f,
  -8.62835869e-02f, 6.60643056e-02f, -7.95195550e-02f, -4.10199240e-02f, 5.06100208e-02f, -4.46354561e-02f, 8.86980668e-02f, -5.33912238e-03f, -3.06314155e-02f, -5.34460880e-02f,
  3.25977169e-02f, 5.02889156e-02f, 8.65701772e-03f, 8.29377621e-02f, 8.05612132e-02f, -3.76097746e-02f, -5.11893071e-02f, 1.25962468e-02f, 1.91012037e-03f, -1.37663232e-02f,
  4.95584011e-02f, 1.98503248e-02f, 4.77924086e-02f, 1.75127368e-02f, 5.65935448e-02f, 2.72009727e-02f, 7.54285092e-03f, 4.67062332e-02f, -3.95356789e-02f, -5.65666966e-02f,
  -4.19152789e-02f, 3.80863994e-02f, 1.38621355e-04f, 6.66120872e-02f, -7.51226395e-03f, -1.86693035e-02f, 5.63580692e-02f, -6.35228306e-02f, 1.82114728e-02f, 6.10916838e-02f,
  2.80636270e-02f, 3.55110988e-02f, 2.56228819e-02f, 3.00346371e-02f, 2.33048573e-02f, -2.70759072e-02f, 3.87425460e-02f, 8.99395868e-02f, -5.96235842e-02f, -7.89320562e-03f,
  6.37827739e-02f, 5.08249775e-02f, -7.25943819e-02f, 3.73355784e-02f, 2.76973080e-02f, -6.48358986e-02f, 8.01967159e-02f, -1.10268846e-01f, -7.99570009e-02f, -6.68569356e-02f,
  -2.34290846e-02f, -8.14613625e-02f, 3.63678182e-03f, -4.79835868e-02f, 5.58154173e-02f, -2.04886887e-02f, -7.94357155e-03f, -5.11153489e-02f, -1.89528719e-03f, -7.37470686e-02f,
  6.21017441e-02f, 8.72167572e-02f, -3.83225568e-02f, -7.63478503e-02f, -2.24560909e-02f, -1.32036787e-02f, -3.49128665e-03f, -8.04010481e-02f, -2.42932327e-02f, 6.19686730e-02f,
  4.75284979e-02f, 4.28674296e-02f, 1.02831848e-01f, 2.93481424e-02f, 5.09520508e-02f, -1.79148074e-02f, 6.02739528e-02f, 7.74856880e-02f, 9.42327380e-02f, 6.21949770e-02f,
  4.49243747e-03f, 4.27243300e-02f, 6.35829121e-02f, 6.88207895e-02f, 6.36623129e-02f, -5.59987174e-03f, -4.30019721e-02f, 9.89048630e-02f, 3.50020714e-02f, -1.12222163e-02f,
  4.58572758e-03f, 7.82079771e-02f, -3.31328921e-02f, -1.48738278e-02f, 1.49286995e-02f, -3.06314752e-02f, -3.13821547e-02f, 7.11358339e-02f, -3.66222858e-03f, -1.33047914e-02f,
  5.51423803e-02f, -1.90289125e-01f, -1.86948568e-01f, -4.17949222e-02f, -5.44103086e-02f, -2.33976729e-02f, -1.35080770e-01f, -4.52121720e-02f, -5.29853106e-02f, -1.58192232e-01f,
  -7.39319250e-02f, -1.28764138e-02f, 8.18105973e-03f, -1.84861924e-02f, -3.00123487e-02f, -1.33585453e-01f, -1.00145042e-01f, -1.24508396e-01f, 2.79024951e-02f, 1.33561939e-01f,
  3.72139364e-02f, -7.57547393e-02f, -3.02732904e-02f, 1.66926086e-02f, -7.75462538e-02f, -1.26192480e-01f, -1.88873485e-01f, 8.48740339e-03f, -4.81360666e-02f, -1.44177437e-01f,
  -1.73359439e-01f, -2.02398151e-02f, 9.30359885e-02f, 1.52520305e-02f, -7.72623792e-02f, 3.68500613e-02f, -2.13222709e-02f, -6.43153489e-02f, -1.03520742e-02f, -6.00667447e-02f,
  1.21631678e-02f, -3.14564444e-02f, -4.87085171e-02f, 1.25053063e-01f, 6.28906041e-02f, 2.49962155e-02f, 2.37901453e-02f, 9.01019871e-02f, -4.61941957e-02f, -3.99563834e-02f,
  6.52782910e-04f, 1.00040548e-01f, 3.29476558e-02f, 1.11439101e-01f, 1.03597388e-01f, 5.78646809e-02f, 4.47926410e-02f, 1.33725733e-01f, -1.45124353e-03f, -6.11949638e-02f,
  -3.90234739e-02f, -9.66616049e-02f, -2.37176865e-02f, -7.59918429e-03f, 2.34492645e-02f, -1.03419229e-01f, -7.35205784e-03f, -1.67024080e-02f, 2.89642997e-02f, -1.25621185e-02f,
  -1.28122307e-02f, -8.74233153e-03f, -8.15295279e-02f, -3.52546088e-02f, -4.07587141e-02f, -1.00545594e-02f, -6.28889054e-02f, -4.85157408e-02f, 6.16437234e-02f, 4.01998162e-02f,
  9.40067470e-02f, -8.82729981e-03f, -3.12163215e-02f, 7.19816387e-02f, -2.12725736e-02f, -6.08771965e-02f, 6.29239008e-02f, 1.27369493e-01f, -3.82115729e-02f, 2.55620107e-02f,
  1.53108621e-02f, 6.12842012e-03f, -3.26789767e-02f, 3.98985744e-02f, -2.06248183e-02f, 3.54579762e-02f, -2.70520262e-02f, 3.33457515e-02f, 8.57215226e-02f, 2.79491972e-02f,
  5.28462604e-02f, 8.62987712e-02f, -3.03845275e-02f, -5.61144240e-02f, -2.85984278e-02f, 5.97793609e-02f, 1.71063580e-02f, -2.61661950e-02f, 1.09211635e-02f, 9.08824503e-02f,
  -8.09981748e-02f, 2.58167200e-02f, 2.47955765e-03f, 7.45319352e-02f, 1.05435975e-01f, 3.80305946e-02f, -6.98326901e-03f, 5.50931925e-03f, 4.50487994e-03f, -1.39106154e-01f,
  1.66770384e-01f, 1.35220706e-01f, 9.23341289e-02f, 8.10255036e-02f, 2.03724089e-03f, 1.02782257e-01f, 9.06186849e-02f, 1.04237989e-01f, 4.74979868e-03f, 4.60552126e-02f,
  1.72466431e-02f, 2.75022686e-02f, -7.67992670e-03f, 1.93084422e-02f, 1.30291758e-02f, 5.91678508e-02f, -9.40791797e-03f, 7.11474800e-04f, -1.09723270e-01f, -4.63736206e-02f,
  -1.18172094e-02f, 1.06610052e-01f, 9.32435133e-03f, -7.00978376e-03f, 3.40297073e-03f, 1.47800716e-02f, 8.76076799e-03f, 1.02563137e-02f, -3.18108089e-02f, -7.19020423e-03f,
  -5.66718541e-02f, 1.08569160e-01f, -1.35054767e-01f, 1.03317550e-03f, -6.63458407e-02f, 8.85113254e-02f, -7.57735893e-02f, -3.77656743e-02f, 3.36903147e-02f, 5.13581000e-02f,
  2.50231847e-02f, 8.01242292e-02f, -1.36458292e-03f, 1.99790355e-02f, -5.60546154e-03f, -6.10696785e-02f, 7.93709829e-02f, -5.98918870e-02f, -1.73523705e-02f, 8.64387900e-02f,
  2.04054900e-02f, 7.45515525e-02f, -5.26069477e-02f, -5.67617342e-02f, -9.28026363e-02f, -3.46218282e-03f, -1.28611699e-02f, 6.77128136e-02f, 1.40348310e-02f, -1.04011651e-02f,
  -2.09964514e-02f, -1.10153086e-01f, 4.27796505e-02f, -4.61939014e-02f, 4.96901311e-02f, -5.00468165e-02f, 6.43808767e-02f, -7.41874874e-02f, 5.07233851e-02f, 7.46684968e-02f,
  -8.13340172e-02f, -2.25933343e-02f, 9.07526463e-02f, -2.15889197e-02f, 3.11228912e-02f, 1.02981016e-01f, 9.96149108e-02f, -6.95682094e-02f, -4.09744643e-02f, -8.64940230e-03f,
  2.53922623e-02f, -2.69570854e-03f, 1.05881736e-01f, 2.66267192e-02f, 5.91205209e-02f, 7.92466775e-02f, 2.41907518e-02f, -3.23636644e-02f, 7.42518008e-02f, 4.59704772e-02f,
  9.65176523e-03f, 6.64706901e-02f, -4.24843878e-02f, 2.72044763e-02f, 1.40473815e-02f, 9.32617933e-02f, -4.06140536e-02f, 8.53784308e-02f, 2.32798737e-02f, 4.26860200e-03f,
  5.79154901e-02f, 4.40961421e-02f, -7.32890964e-02f, 8.09372440e-02f, -1.89324655e-02f, -2.18270551e-02f, 7.09978491e-02f, 4.83816490e-02f, -9.81207564e-02f, 5.63886128e-02f,
  -5.83475269e-02f, -2.87211314e-02f, 7.59432986e-02f, -3.55488360e-02f, 2.51001287e-02f, -9.65215862e-02f, -2.33317874e-02f, 6.68445304e-02f, -4.83417585e-02f, 6.55059516e-02f,
  2.24294662e-01f, -1.33805664e-03f, 3.50967459e-02f, -5.59162684e-02f, -4.20274362e-02f, -1.30865807e-02f, 2.53214538e-02f, -3.74062136e-02f, -3.94462980e-03f, 1.38949957e-02f,
  6.79894909e-02f, 1.54188061e-02f, 8.47081095e-02f, 2.02227104e-02f, -4.69577536e-02f, 1.05933286e-02f, 1.39541309e-02f, 1.16194852e-01f, 1.14327691e-01f, 5.85371852e-02f,
  -8.50876980e-03f, -7.99874403e-03f, 1.49205685e-01f, 8.94220844e-02f, -3.14848125e-02f, -6.81423843e-02f, 7.03976378e-02f, 6.08604252e-02f, 4.31898683e-02f, 4.57436182e-02f,
  7.03408793e-02f, 5.23885339e-02f, 7.51003772e-02f, 2.91083357e-03f, -7.28192553e-02f, 1.10154778e-01f, 4.52799946e-02f, -2.74582673e-03f, -2.71813031e-02f, 9.25759077e-02f,
  -1.01157561e-01f, 5.46869412e-02f, -2.43991520e-02f, -2.01584660e-02f, -5.18932790e-02f, -9.34860762e-03f, 6.78776056e-02f, 1.11109808e-01f, 1.32145854e-02f, -4.53675427e-02f,
  -1.00039572e-01f, 2.05518771e-02f, -3.76297683e-02f, 8.10394809e-02f, -9.23939236e-03f, 6.88032433e-02f, -2.10629702e-02f, 1.29889334e-02f, 9.08360537e-03f, 3.54928114e-02f,
  -6.53306097e-02f, 4.01121676e-02f, 5.49522340e-02f, 7.03153312e-02f, 6.62940089e-04f, 4.19189334e-02f, 1.48289772e-02f, -1.02823749e-01f, 3.27919307e-03f, -3.58846113e-02f,
  -2.05429643e-03f, -2.34424951e-03f, -1.44632300e-02f, 4.13226895e-02f, 2.09684614e-02f, -4.39450257e-02f, -6.51781186e-02f, 4.47242521e-02f, -1.61851700e-02f, 2.76487172e-02f,
  -9.35565382e-02f, 1.14860823e-02f, 1.45636387e-02f, 1.13774613e-02f, -8.51262286e-02f, -6.67532608e-02f, 9.40405428e-02f, -5.00551835e-02f, -8.12674779e-03f, 7.58476108e-02f,
  -3.19037549e-02f, -4.85632904e-02f, 3.07340361e-02f, 7.51012415e-02f, -8.85517225e-02f, -3.64329144e-02f, -1.08821072e-01f, 4.29543629e-02f, 1.19601656e-02f, -6.02519698e-02f,
  1.09568993e-02f, -1.33736304e-03f, -7.67399594e-02f, -3.18789259e-02f, 1.75490994e-02f, 5.71463816e-03f, -7.98754841e-02f, -4.72259941e-03f, 3.90734747e-02f, 2.91184559e-02f,
  -4.42692526e-02f, 8.74738619e-02f, 1.04021050e-01f, 6.81894191e-04f, 5.06731905e-02f, 8.24583415e-03f, -5.04388586e-02f, -5.06684519e-02f, 8.67258534e-02f, -2.02618800e-02f,
  -1.38564974e-01f, -5.91084510e-02f, 1.00226477e-01f, 7.50776008e-02f, 3.43210576e-03f, -2.26159431e-02f, -6.05751686e-02f, 7.82098807e-03f, -6.02751710e-02f, 9.87960771e-03f,
  -7.11493641e-02f, 1.69870618e-04f, -4.08388041e-02f, 7.23572671e-02f, -8.22781399e-02f, 4.81839431e-03f, 3.09324749e-02f, -5.92265464e-03f, 1.23897210e-01f, 1.21810876e-01f,
  5.00678532e-02f, 1.09645493e-01f, 1.34003302e-02f, -2.35842671e-02f, 4.37343940e-02f, 1.09423616e-03f, 7.19151273e-02f, 7.75944516e-02f, 4.95086610e-02f, -2.40302645e-02f,
  1.14663057e-01f, -1.51481941e-01f, 6.43829182e-02f, -1.03922315e-01f, -1.90639850e-02f, 5.78007922e-02f, 4.50041071e-02f, 6.79100677e-02f, -1.51783358e-02f, -9.98470411e-02f,
  -1.99477877e-02f, 3.15881409e-02f, -3.56509760e-02f, -3.37135457e-02f, 5.45874834e-02f, 1.80106498e-02f, 3.83330695e-02f, -7.76283666e-02f, 3.55817489e-02f, -8.77747238e-02f,
  1.06253484e-02f, 5.24355061e-02f, -3.08834836e-02f, -6.26744330e-02f, -1.86718479e-02f, -5.80133498e-02f, 4.50046733e-02f, 3.34769115e-02f, 7.74874762e-02f, -3.66885029e-02f,
  -9.02604405e-03f, 4.75681126e-02f, -8.67171362e-02f, -8.32134672e-03f, -3.65232825e-02f, -3.38038206e-02f, -5.76502830e-02f, 4.99700289e-03f, -4.80959564e-03f, 3.00811790e-02f,
  -1.00838833e-01f, -3.15974131e-02f, 8.02713484e-02f, 2.00406872e-02f, 5.83222769e-02f, -3.63719203e-02f, -6.64997548e-02f, -3.78711373e-02f, 6.01999387e-02f, -4.76549100e-03f,
  3.47499698e-02f, -6.64520497e-03f, 2.03614719e-02f, -7.14388164e-03f, -8.35913941e-02f, 5.63004129e-02f, 6.72519356e-02f, -4.55227867e-02f, -5.68883084e-02f, -7.97282234e-02f,
  -2.84698997e-02f, -4.14505564e-02f, 1.07262328e-01f, -8.68571848e-02f, 5.14446534e-02f, 5.51950149e-02f, -3.57072614e-02f, -2.07290193e-03f, -8.12698603e-02f, -4.44882549e-02f,
  1.20194089e-02f, 1.83331724e-02f, 4.04650792e-02f, 8.05614069e-02f, 1.30337551e-01f, 9.26552936e-02f, -9.77666527e-02f, 5.96474037e-02f, -7.74644688e-02f, -6.36951700e-02f,
  6.33719936e-02f, -3.47449183e-02f, 9.55757592e-03f, 1.20877475e-01f, -2.82485480e-03f, -9.70540196e-03f, 8.41304809e-02f, 1.19673364e-01f, 4.73173372e-02f, 1.25270277e-01f,
  -2.28764340e-01f, -1.19227413e-02f, -1.45803085e-02f, -4.57643941e-02f, 7.45293349e-02f, 4.58234027e-02f, 4.68776301e-02f, -3.87264006e-02f, -2.51391418e-02f, 2.11601481e-02f,
  9.73637775e-02f, 7.05817491e-02f, 4.83864173e-02f, -8.16526338e-02f, -7.49125928e-02f, 6.18959814e-02f, 9.50465386e-04f, 9.50127933e-03f, -9.27855819e-02f, 8.94211084e-02f,
  -1.31512703e-02f, 6.96480870e-02f, -1.04781829e-01f, 7.57168829e-02f, 2.27051117e-02f, -1.05217630e-02f, -7.47326985e-02f, -2.21169405e-02f, -2.37297714e-02f, -3.78783531e-02f,
  -2.16161478e-02f, 2.51857750e-02f, -6.88619614e-02f, -1.37276594e-02f, 8.06461424e-02f, -5.71749806e-02f, 2.43488476e-02f, 4.65946198e-02f, 1.76044125e-02f, -1.06364330e-02f,
  6.55663162e-02f, 6.93247765e-02f, 2.47367024e-02f, -8.39663949e-03f, 1.52634857e-02f, 6.68584332e-02f, -4.87056784e-02f, 4.95585287e-03f, -5.94330840e-02f, 1.09629519e-01f,
  9.54202339e-02f, 4.27611917e-02f, 2.37780660e-02f, -8.08455274e-02f, -5.57699986e-02f, 4.12167683e-02f, -5.88906966e-02f, 6.57256618e-02f, -2.00218614e-03f, -9.56080854e-02f,
  -4.33463566e-02f, 1.55494688e-02f, -3.91752040e-03f, 7.38455802e-02f, -2.90955566e-02f, 1.66824088e-02f, 8.48608613e-02f, 3.12967636e-02f, -3.05358451e-02f, -7.89027736e-02f,
  -6.85633719e-02f, 4.45150807e-02f, -4.76428308e-02f, -7.70614073e-02f, -5.54722324e-02f, -5.78658953e-02f, 3.25074084e-02f, 2.34517902e-02f, 6.61877990e-02f, -9.97104719e-02f,
  5.26942015e-02f, 3.36872824e-02f, -9.55393389e-02f, -2.61368416e-02f, -8.73647034e-02f, 2.38186270e-02f, -6.74468605e-03f, -5.37803508e-02f, -7.17228800e-02f, 7.10756630e-02f,
  7.16736838e-02f, -4.92479242e-02f, -3.93111221e-02f, -5.76489381e-02f, 6.49865344e-02f, -3.70910228e-03f, -4.96299714e-02f, -5.16739450e-02f, -6.11578524e-02f, 4.94618434e-04f,
  1.68301072e-02f, -2.41742712e-02f, 5.57570867e-02f, 1.20881712e-02f, 8.10308084e-02f, 1.48225948e-02f, 4.74851057e-02f, 5.09656854e-02f, -8.75049680e-02f, -6.62138592e-03f,
  -1.48373516e-02f, -3.96835022e-02f, -7.55473077e-02f, -4.99980822e-02f, -4.72575165e-02f, 2.09558867e-02f, 3.83007042e-02f, 4.60837111e-02f, -7.87627250e-02f, -1.04117975e-01f,
  9.60385054e-02f, 4.99223061e-02f, -1.55019656e-01f, 3.30490656e-02f, 4.20758687e-02f, -2.08748598e-02f, 7.65258670e-02f, 8.00026767e-03f, 3.67043838e-02f, 8.12270343e-02f,
  1.07815780e-01f, 8.75837076e-03f, 3.85873802e-02f, -2.69434210e-02f, -3.19636352e-02f, -7.08746091e-02f, -1.02720000e-01f, -5.49528040e-02f, 3.84150185e-02f, -8.09338465e-02f,
  -5.75804189e-02f, -3.19237374e-02f, 3.13762948e-02f, -3.89473215e-02f, -8.59686988e-04f, -6.81800991e-02f, -1.56868319e-03f, 6.17095530e-02f, 3.52423713e-02f, -8.45265538e-02f,
  -9.16394778e-03f, 8.85203928e-02f, 2.04430595e-02f, 5.49348630e-02f, 1.28644216e-03f, -6.30422309e-02f, -5.10655753e-02f, -7.12503418e-02f, 1.12516023e-01f, -5.99150322e-02f,
  4.07231338e-02f, -1.96573567e-02f, 7.83896148e-02f, -2.61196378e-03f, 9.72007290e-02f, -7.29781687e-02f, 9.74455625e-02f, -1.65926553e-02f, 5.51163778e-02f, 2.66864281e-02f,
  9.23563838e-02f, 1.25448080e-02f, 5.19911386e-03f, -2.01979820e-02f, -1.93406809e-02f, 1.16890585e-02f, -2.87740934e-03f, -8.85979906e-02f, 5.26015535e-02f, 6.27874509e-02f,
  -5.88315986e-02f, -1.50499791e-02f, 3.94953191e-02f, -4.67117317e-02f, 1.02651723e-01f, -1.78960785e-02f, 5.18374927e-02f, 2.80478527e-03f, -1.95569750e-02f, 6.82241768e-02f,
  6.32610023e-02f, -7.67625943e-02f, 3.88949700e-02f, -4.22006808e-02f, -2.23061088e-02f, 4.52923268e-04f, -2.53531877e-02f, -9.93759371e-03f, -2.83229258e-02f, 5.69477975e-02f,
  -1.07138595e-02f, -5.56072965e-02f, -4.59837355e-02f, -9.42398235e-02f, -7.16941357e-02f, 4.57750894e-02f, 9.67452116e-03f, 5.85975684e-03f, 1.65342893e-02f, -4.88612950e-02f,
  9.90421548e-02f, 1.66532677e-02f, -4.47471552e-02f, -5.12204021e-02f, -7.68971071e-02f, 5.75860478e-02f, 7.48699531e-02f, -5.42529374e-02f, -5.72221950e-02f, 8.81527737e-02f,
  7.59704188e-02f, -6.81270957e-02f, 7.06799403e-02f, 5.28137833e-02f, 2.69011129e-02f, -4.22579516e-03f, 1.17432140e-01f, -1.08089037e-01f, 2.10870598e-02f, 8.31096545e-02f,
  6.83821514e-02f, -1.37530845e-02f, 2.74600834e-02f, 5.67435939e-03f, -4.77243476e-02f, -3.63280587e-02f, -8.92072618e-02f, 5.07482104e-02f, -5.98691702e-02f, 6.95062578e-02f,
  2.29669452e-01f, -8.69481862e-02f, -2.16459408e-01f, 8.16048235e-02f, -8.30643252e-02f, -1.32514182e-02f, -9.76065025e-02f, 8.15792829e-02f, 3.97701794e-03f, -3.86894128e-04f,
  -8.57382864e-02f, 8.72367024e-02f, 3.05926129e-02f, -2.38573682e-02f, 7.58599024e-03f, -6.09546117e-02f, 1.45608764e-02f, 1.01687005e-02f, -5.59495576e-02f, 6.89997151e-02f,
  6.92959235e-04f, 6.23703934e-02f, -5.28339371e-02f, -4.18904275e-02f, -8.06606710e-02f, -2.26170793e-02f, -1.62243396e-01f, 1.40885813e-02f, -1.15221962e-01f, -1.42187446e-01f,
  -1.41545787e-01f, 2.20948737e-02f, -9.29232985e-02f, 4.14930005e-03f, -5.65046370e-02f, -6.08077236e-02f, 5.90163283e-02f, 3.98819558e-02f, -6.90798834e-02f, -5.73443770e-02f,
  -6.96104914e-02f, 5.93873784e-02f, -6.37900457e-02f, -6.79390728e-02f, 5.04083075e-02f, 6.68620691e-02f, -5.17903157e-02f, 3.95880789e-02f, 2.16576252e-02f, -1.22264072e-01f,
  -2.09824145e-02f, -3.92738450e-03f, -4.88129780e-02f, 3.77043560e-02f, 4.98303585e-02f, -8.75876248e-02f, -7.53968349e-03f, -1.14828855e-01f, -6.76702932e-02f, -5.62550649e-02f,
  -1.74516924e-02f, -8.67087673e-03f, -8.44607800e-02f, 6.62073046e-02f, 8.93729702e-02f, -6.34125248e-02f, -5.78236207e-02f, -5.88437319e-02f, 8.65179226e-02f, 8.37868825e-02f,
  3.12876888e-03f, -6.44488318e-04f, -8.81568715e-02f, 6.01583384e-02f, -7.15759173e-02f, 4.87749428e-02f, -5.39565831e-02f, 8.36917683e-02f, 6.78913966e-02f, -8.49935487e-02f,
  6.45383522e-02f, 1.73576213e-02f, -1.83981762e-03f, 1.21792136e-02f, 5.52431867e-02f, -5.03048450e-02f, 6.58645406e-02f, 7.99393505e-02f, -1.09775020e-02f, -2.11856328e-02f,
  9.89782661e-02f, 1.68614946e-02f, 7.98273087e-02f, 9.92596000e-02f, -3.82382758e-02f, -7.95429125e-02f, -9.22642834e-03f, -2.68043689e-02f, 5.58377989e-03f, 5.56825250e-02f,
  4.01036367e-02f, -5.02268746e-02f, 1.97104216e-02f, -7.62572885e-02f, -2.94991210e-02f, -6.34694332e-03f, 8.56873915e-02f, -5.83089478e-02f, -3.78127098e-02f, -2.05625035e-02f,
  9.22684595e-02f, 1.14251263e-01f, 1.21928327e-01f, -5.17284051e-02f, -7.20028803e-02f, 7.08375722e-02f, -7.65241683e-02f, -8.01077560e-02f, 3.39186005e-02f, 1.18659496e-01f,
  4.08802629e-02f, -1.10742018e-01f, -5.12978733e-02f, 9.38702561e-03f, -4.21347376e-03f, 1.10711150e-01f, 1.31342143e-01f, 4.27846350e-02f, 1.05651535e-01f, 1.05893001e-01f,
  3.65376882e-02f, 5.00085913e-02f, 1.05327226e-01f, 8.35404322e-02f, 4.44273949e-02f, 1.50674768e-02f, 8.37441906e-03f, 6.97210953e-02f, 8.43243003e-02f, 3.58199775e-02f,
  3.59544791e-02f, 3.33406441e-02f, -6.38712794e-02f, -3.45602743e-02f, 7.20560253e-02f, 9.77805331e-02f, 1.56631265e-02f, -4.32150885e-02f, -5.89233115e-02f, -7.81638846e-02f,
  9.07063950e-03f, 1.20167611e-02f, 8.61813352e-02f, 6.04663156e-02f, -5.60312420e-02f, -1.14351876e-01f, -4.85118628e-02f, 3.31488736e-02f, -5.73367327e-02f, 1.81259792e-02f,
  5.38948644e-03f, -6.46132827e-02f, 1.34001300e-02f, 5.59591427e-02f, -3.43201347e-02f, -9.81196165e-02f, -5.60846590e-02f, -7.59581476e-02f, 1.11759365e-01f, 7.04695359e-02f,
  6.54700622e-02f, 4.35299352e-02f, -7.35969618e-02f, 6.07714504e-02f, 2.78195012e-02f, -7.29925931e-03f, 5.48701249e-02f, 2.51133516e-02f, -3.21091935e-02f, 8.02556425e-02f,
  -1.68337859e-02f, 8.73987302e-02f, 9.40816030e-02f, -3.27821635e-02f, 2.24151295e-02f, 2.73298156e-02f, 2.13044900e-02f, 6.03500307e-02f, 6.80380017e-02f, -8.14685673e-02f,
  -5.19552194e-02f, -4.11034115e-02f, 4.16429900e-02f, 4.41839620e-02f, 4.02984880e-02f, -6.90895319e-02f, -6.59252480e-02f, -4.39267000e-03f, -2.87391469e-02f, -6.69708103e-02f,
  5.24023287e-02f, -1.91536304e-02f, -9.57987458e-02f, 3.18268463e-02f, 5.03551848e-02f, 4.43447754e-02f, 5.90098873e-02f, -9.17428359e-02f, 8.33786353e-02f, -3.96894291e-02f,
  -8.73160362e-02f, 8.38664025e-02f, -5.73681854e-02f, 1.87650453e-02f, 3.78129780e-02f, -8.65431130e-02f, 1.86943915e-02f, 3.84653918e-02f, 4.62756231e-02f, 1.70861147e-02f,
  5.46012633e-02f, 4.93935347e-02f, -1.77243259e-02f, 2.63206325e-02f, 4.43754755e-02f, 4.36616130e-02f, 3.82627919e-02f, 8.73576291e-03f, 9.36953500e-02f, 6.48796856e-02f,
  -4.35975939e-02f, 5.11802360e-03f, -1.52811466e-03f, 9.39094462e-03f, -2.88474746e-02f, 1.05304914e-02f, -1.14847282e-02f, -7.14508295e-02f, 9.30601284e-02f, -6.88712150e-02f,
  6.30835220e-02f, -9.19828340e-02f, 4.48583951e-03f, -1.41521813e-02f, -8.89189467e-02f, 3.71919721e-02f, -2.83356756e-03f, -6.63929805e-02f, -1.11324079e-01f, -7.31443753e-04f,
  7.52961030e-03f, -8.98278356e-02f, -4.30025607e-02f, 6.17880858e-02f, 1.04446508e-01f, -4.45907712e-02f, -6.22476526e-02f, 1.28486618e-01f, 1.00931063e-01f, 5.63130639e-02f,
  -3.18540819e-02f, -4.25228700e-02f, 8.43342096e-02f, 9.84702036e-02f, -7.46065453e-02f, 3.77530344e-02f, -6.33630827e-02f, -2.71644127e-02f, -9.50521007e-02f, -1.22443646e-01f,
  -5.45553900e-02f, -4.26082201e-02f, -6.55899793e-02f, -9.82745644e-03f, 5.73809305e-03f, 8.89594015e-03f, -2.98374444e-02f, -2.78684665e-02f, 6.20443374e-02f, 1.98843773e-03f,
  -7.33597064e-03f, -7.69628435e-02f, 1.69223156e-02f, -8.20416138e-02f, -2.95367837e-02f, -4.74269986e-02f, 9.30073261e-02f, 6.87212348e-02f, 2.54593827e-02f, -6.92834035e-02f,
  -7.45732114e-02f, -6.65960228e-03f, 7.90031329e-02f, 5.42495139e-02f, 4.84495610e-02f, -5.34240603e-02f, -3.57218981e-02f, -5.69834448e-02f, 7.44460747e-02f, -2.47573550e-03f,
  -8.86368752e-02f, 5.94323352e-02f, -8.78778398e-02f, 4.38129157e-02f, 5.38403504e-02f, 1.27751790e-02f, 4.93967421e-02f, 5.77835813e-02f, 1.49649540e-02f, -5.57718538e-02f,
  7.14055123e-03f, -8.87588691e-03f, -8.21259841e-02f, -4.17581247e-03f, 8.06058124e-02f, 3.79373357e-02f, 6.54686913e-02f, 8.45565647e-02f, -5.41196689e-02f, -6.33562729e-02f,
  3.48915048e-02f, -5.86315133e-02f, 8.11411515e-02f, -4.74449471e-02f, -3.33147272e-02f, -8.39809887e-03f, -2.10574400e-02f, -3.28772403e-02f, -6.53963462e-02f, 6.55124784e-02f,
  -8.15025344e-02f, 1.31949097e-01f, 4.60627414e-02f, -9.16782692e-02f, 6.70932904e-02f, -7.95813203e-02f, -6.43234253e-02f, -2.92573050e-02f, -1.24715464e-02f, 8.21486712e-02f,
  -3.93820927e-02f, 5.71505353e-02f, 2.12996788e-02f, 6.22773580e-02f, -3.60107571e-02f, -6.09168001e-02f, -7.03829923e-04f, 4.24783565e-02f, 9.89559069e-02f, -9.76091549e-02f,
  -5.67266764e-03f, -6.74350485e-02f, -2.43754145e-02f, -3.14495601e-02f, -1.01637557e-01f, 5.46788462e-02f, -8.76506567e-02f, 5.24122454e-02f, -2.05523130e-02f, -3.93211544e-02f,
  7.66921043e-02f, -2.38269498e-03f, 4.82548075e-03f, 4.42472845e-02f, 1.17848158e-01f, -6.28414080e-02f, 7.76831657e-02f, -3.30976471e-02f, 4.20253258e-03f, 1.41398311e-02f,
  -7.40884990e-02f, -1.05352767e-01f, -9.29898769e-02f, -3.25154178e-02f, 6.31711707e-02f, 8.47774670e-02f, -3.95534225e-02f, -4.16659787e-02f, 7.98600465e-02f, 3.98480073e-02f,
  -7.16277957e-02f, -9.64142149e-04f, -9.31354240e-03f, 7.65101053e-03f, 6.28220513e-02f, 4.52567794e-04f, 7.31476918e-02f, 4.27808538e-02f, 9.83137358e-03f, 1.04224868e-01f,
  -1.85037572e-02f, 6.55233786e-02f, 6.73386827e-02f, 1.24551617e-02f, 9.70989168e-02f, 1.04082823e-01f, -3.64766866e-02f, 1.04965866e-01f, 3.01542133e-02f, 3.68124619e-02f,
  1.06016472e-02f, 4.29827832e-02f, -3.96451689e-02f, 4.88682166e-02f, 9.76126492e-02f, 7.71755725e-02f, -6.18047453e-02f, -7.76862651e-02f, 2.51014289e-02f, 3.38559188e-02f,
  -8.10438395e-02f, 5.19374497e-02f, -8.14832523e-02f, 5.37701659e-02f, 3.41124348e-02f, -2.55588093e-03f, 2.75940169e-02f, -1.23655573e-02f, -4.48110811e-02f, 7.42223635e-02f,
  -1.65781006e-02f, 2.85514463e-02f, -8.31376296e-03f, -9.27553400e-02f, 9.07389149e-02f, -1.49352551e-02f, -1.01827523e-02f, 6.59977868e-02f, -7.92501569e-02f, 5.34458160e-02f,
  -2.69202739e-02f, 7.19250739e-02f, 4.23434004e-02f, -6.57605678e-02f, -8.27563778e-02f, 1.04188453e-03f, -3.12192808e-03f, -2.59742839e-03f, -8.97041634e-02f, 9.49336067e-02f,
  -5.30416109e-02f, 4.67348732e-02f, 8.88902918e-02f, 1.90748144e-02f, -7.83684477e-02f, 8.46390128e-02f, -2.30000950e-02f, -2.84550134e-02f, 1.35876630e-02f, 1.10133797e-01f,
  7.06560761e-02f, -4.99690957e-02f, 3.77925262e-02f, 2.59880014e-02f, 8.64024684e-02f, 4.93300185e-02f, 3.89156416e-02f, -6.52653947e-02f, 2.21605394e-02f, -1.83192939e-02f,
  5.16302846e-02f, -6.26124591e-02f, 4.98790555e-02f, 5.81838936e-02f, 3.48662585e-02f, 4.51675542e-02f, 4.92451852e-03f, 4.02923068e-03f, -6.86714873e-02f, 1.02610745e-01f,
  5.45388237e-02f, 7.06526563e-02f, -7.84364343e-02f, -2.12538522e-02f, -2.36898195e-02f, -3.36862095e-02f, 2.55989116e-02f, -9.19223391e-03f, 5.02701290e-03f, -2.94721629e-02f,
  1.51958093e-01f, -1.53103977e-01f, 1.30965620e-01f, 8.67489725e-03f, -6.99780807e-02f, -8.72745551e-03f, -1.98120624e-02f, 3.49851511e-02f, 7.06805140e-02f, 2.73653809e-02f,
  -3.90342586e-02f, -1.92398056e-02f, -1.58451952e-03f, 7.42143169e-02f, 3.59088741e-02f, 3.25841494e-02f, -1.41776446e-02f, 1.74019039e-02f, 1.77806228e-01f, 5.51529042e-02f,
  -6.11838102e-02f, 7.23569607e-03f, -3.93899456e-02f, 4.58653942e-02f, -4.35052812e-02f, -9.37428921e-02f, -2.84220595e-02f, 2.26085410e-02f, -6.99696466e-02f, -1.12293892e-01f,
  -4.88609448e-02f, 7.52401426e-02f, 9.15292799e-02f, 3.49644050e-02f, 4.93638851e-02f, -6.90616574e-03f, 2.21415255e-02f, 1.77565683e-02f, 6.61871731e-02f, 6.47271192e-03f,
  -8.48880261e-02f, 1.16171828e-02f, 8.86731222e-03f, -2.37188279e-03f, 2.43977942e-02f, 8.43549427e-03f, -1.07238710e-01f, -5.64065985e-02f, 8.93027335e-02f, 1.30298613e-02f,
  3.49294692e-02f, -2.73701493e-02f, 1.11156054e-01f, -4.10642959e-02f, 8.65852758e-02f, 1.34496853e-01f, 5.41032553e-02f, 2.47869194e-02f, 3.88266519e-02f, -5.95482737e-02f,
  -3.43482336e-03f, -1.03912521e-02f, 8.88426527e-02f, -7.11694034e-03f, -7.00268447e-02f, -2.81154606e-02f, 1.07178226e-01f, -2.60076728e-02f, 8.41735527e-02f, -6.63138032e-02f,
  -4.34088632e-02f, -4.10574079e-02f, 6.59506321e-02f, -3.96647230e-02f, -5.88082671e-02f, -3.91314141e-02f, 3.19379158e-02f, -8.26404542e-02f, -7.75333086e-04f, -7.22645670e-02f,
  1.28621487e-02f, 7.16690347e-02f, -1.33730154e-02f, 4.52191830e-02f, -2.26406995e-02f, 5.99706285e-02f, -2.20205411e-02f, -7.81707391e-02f, -4.95083109e-02f, -5.98258972e-02f,
  -6.30534962e-02f, 1.53729573e-01f, -5.51170260e-02f, -9.56057757e-03f, -2.37373691e-02f, 2.57470421e-02f, -1.95064526e-02f, -5.70982918e-02f, -1.46749737e-02f, -6.42313957e-02f,
  4.94742617e-02f, 2.28171814e-02f, -6.50366172e-02f, 4.59472314e-02f, 6.12913556e-02f, 4.38705310e-02f, -9.05945003e-02f, -2.23518461e-02f, -4.57457416e-02f, -1.15507595e-01f,
  5.22443242e-02f, -2.83041112e-02f, 1.14112072e-01f, 6.33214042e-02f, -4.10859566e-03f, 1.54012352e-01f, 1.00980461e-01f, -1.11392783e-02f, 1.50774553e-01f, 5.46855927e-02f,
  7.72097409e-02f, 1.16326869e-01f, 2.54352763e-02f, -8.28736797e-02f, 8.68344381e-02f, -1.43167069e-02f, -3.03204115e-02f, 6.70510530e-02f, 4.26251516e-02f, 1.19939288e-02f,
  -2.50431653e-02f, -6.24373369e-02f, 2.26064604e-02f, 2.02359911e-02f, 1.06193945e-02f, -6.13904819e-02f, 2.93743517e-02f, 2.27181357e-03f, -9.55049545e-02f, -3.65606062e-02f,
  6.77922517e-02f, 5.65071106e-02f, -8.20799470e-02f, -6.04367629e-02f, -6.45887014e-03f, 6.28485903e-02f, 1.18147340e-02f, 7.04988316e-02f, -6.20484492e-03f, 1.08619757e-01f,
  -7.38841519e-02f, -2.93302909e-02f, -4.47029248e-02f, -7.89346769e-02f, -6.80885240e-02f, -2.62015462e-02f, 2.07358338e-02f, 6.61204010e-02f, -8.96446500e-03f, 7.46745691e-02f,
  8.68441164e-02f, 5.64692169e-02f, -8.14629868e-02f, 1.16342641e-02f, 4.97547314e-02f, -9.35099795e-02f, -2.97166929e-02f, 8.94405246e-02f, 4.51325206e-03f, -6.81428686e-02f,
  9.49523523e-02f, -4.46079485e-02f, 4.42962907e-02f, -6.07423224e-02f, 6.81604967e-02f, -4.27150652e-02f, -3.30486596e-02f, 2.91991066e-02f, -6.19169734e-02f, -8.89459103e-02f,
  -8.29785168e-02f, -3.52403484e-02f, 6.11817911e-02f, -3.85727324e-02f, -5.94675820e-03f, 7.19169751e-02f, -1.22808181e-02f, -4.56782021e-02f, -8.05644393e-02f, -5.29296398e-02f,
  3.15602794e-02f, -4.52882089e-02f, 1.09452782e-02f, -3.87095287e-02f, -9.51121897e-02f, 9.29094329e-02f, 3.96522284e-02f, -2.15115175e-02f, -2.82886415e-03f, 3.38561609e-02f,
  -8.41762871e-03f, -2.05384940e-02f, -5.34844324e-02f, 3.99260074e-02f, 5.31310514e-02f, 6.06124103e-02f, 2.22932287e-02f, 1.33451922e-02f, -5.85978702e-02f, -6.33624494e-02f,
  -1.34457154e-02f, 6.35740012e-02f, -6.89342320e-02f, -9.26042199e-02f, 8.49904269e-02f, -7.61253387e-02f, -5.68798408e-02f, 3.42303775e-02f, -5.60105704e-02f, -7.26991668e-02f,
  3.18491980e-02f, 1.83504950e-02f, 1.43217854e-02f, -3.43770124e-02f, 7.00547770e-02f, -1.09871462e-01f, 7.29332268e-02f, 5.23006581e-02f, -1.76731218e-02f, 4.62992676e-02f,
  8.59325901e-02f, -9.41210426e-03f, -8.48539695e-02f, -8.94063860e-02f, 1.83373410e-02f, -1.08123757e-02f, -3.16613987e-02f, -1.75181217e-02f, -1.47646805e-02f, -1.73674077e-02f,
  2.60304753e-02f, -9.80941020e-03f, -7.39224702e-02f, 1.06405161e-01f, 3.93333361e-02f, 9.99271423e-02f, 9.16355997e-02f, 1.00907519e-01f, 1.12170987e-02f, 1.11459628e-01f,
  5.25689013e-02f, 1.56086937e-01f, 6.68116808e-02f, 1.31553888e-01f, 9.18467268e-02f, 3.11546531e-02f, 4.08748053e-02f, -1.93319898e-02f, 9.25237685e-03f, -6.39557391e-02f,
  -1.14100510e-02f, 4.71670628e-02f, 3.97273116e-02f, -1.20201875e-02f, -1.66618749e-02f, -3.77332903e-02f, 3.34956497e-02f, -5.07042967e-02f, 9.21264570e-03f, -9.05068219e-02f,
  2.07674429e-02f, -2.56978925e-02f, 9.24664736e-02f, 6.89516291e-02f, 6.30232021e-02f, -1.31665310e-02f, 3.09982221e-03f, -2.65622195e-02f, -4.46430556e-02f, -5.27818054e-02f,
  -4.89425799e-03f, 8.14876333e-03f, -2.09518652e-02f, -1.07902676e-01f, -1.67107489e-02f, -7.45607540e-02f, 5.02365604e-02f, 9.22710355e-03f, -5.44777466e-03f, -1.30623253e-02f,
  -4.43585701e-02f, 4.98815477e-02f, -4.33713831e-02f, -6.65068775e-02f, 9.32606235e-02f, -6.54738098e-02f, -8.16205516e-02f, 2.59059444e-02f, -2.59542037e-02f, -3.34200449e-02f,
  -4.74355146e-02f, 4.37114947e-02f, 6.22683726e-02f, -9.41010341e-02f, 8.38091299e-02f, -6.59023449e-02f, 1.08752055e-02f, 3.05561088e-02f, -4.24084393e-03f, 5.21321036e-02f,
  -4.56598913e-03f, -1.39360921e-02f, -3.97130400e-02f, -4.25957926e-02f, -1.82722078e-03f, 5.61530963e-02f, 4.88695167e-02f, 8.33615139e-02f, -5.23934960e-02f, -3.50646824e-02f,
  -5.32295853e-02f, -4.91059944e-02f, -1.16076335e-01f, -8.44664276e-02f, -1.45890815e-02f, -4.77809533e-02f, 2.59987134e-02f, -6.23957179e-02f, -4.13675383e-02f, -6.37522526e-03f,
  -1.96930300e-02f, 6.05314486e-02f, 1.03493474e-01f, -9.00759771e-02f, -9.35730189e-02f, 6.15540892e-02f, -8.22987854e-02f, 3.86127383e-02f, 5.98437898e-02f, -4.78960946e-02f,
  3.24928053e-02f, 5.91949336e-02f, -5.30776419e-02f, 4.30933386e-03f, 4.35889959e-02f, 6.14987463e-02f, -8.90368521e-02f, 9.91749167e-02f, -8.20969418e-02f, 2.07567029e-02f,
  5.66690043e-02f, 7.80310929e-02f, 9.08288173e-04f, -2.97221020e-02f, 6.96304590e-02f, 1.21615477e-01f, -1.18884528e-02f, -8.01407099e-02f, 9.05753523e-02f, -8.65565613e-02f,
  -2.59837538e-01f, -1.09092154e-01f, 3.93692441e-02f, 1.58864614e-02f, 3.34330760e-02f, 7.15977401e-02f, -3.83512601e-02f, 5.87758049e-02f, -7.70399347e-02f, -7.83354342e-02f,
  -8.57294574e-02f, -3.75733934e-02f, -2.64907777e-02f, 1.50389280e-02f, 1.34883329e-01f, 2.94285640e-02f, 1.51061147e-01f, 1.31553009e-01f, -2.49878801e-02f, 8.05126783e-03f,
  8.15253928e-02f, -2.19519697e-02f, -1.42825367e-02f, -5.19613177e-02f, 7.11714625e-02f, 1.03930943e-01f, 4.83669862e-02f, 2.97311023e-02f, -3.24736163e-03f, 2.32862048e-02f,
  -1.48166031e-01f, -1.85342535e-01f, -2.51822695e-02f, -3.53584215e-02f, -1.34070441e-02f, -8.51669759e-02f, -4.75489497e-02f, 1.25223622e-02f, -6.78683892e-02f, -5.37767932e-02f,
  -7.00751916e-02f, -5.53069375e-02f, 5.30380830e-02f, 5.26928715e-02f, -1.15178399e-01f, 2.90714949e-02f, -3.89241092e-02f, 9.10819024e-02f, 1.26653239e-01f, -7.69297928e-02f,
  -5.35574462e-03f, -6.80754632e-02f, -8.66943598e-03f, 1.01116374e-01f, 3.66343046e-03f, 8.46074745e-02f, 7.41752833e-02f, 5.10164835e-02f, 5.20260856e-02f, -1.30132243e-01f,
  9.01866425e-03f, -1.22948540e-02f, -7.33434856e-02f, 5.76950051e-02f, 6.62526209e-03f, -1.83345843e-02f, -1.14764925e-02f, 8.17398354e-02f, 3.91968898e-02f, -2.30936538e-02f,
  5.45855016e-02f, -8.54614598e-04f, -4.23644818e-02f, 6.50331303e-02f, -1.03447931e-02f, -3.98239642e-02f, -4.04036604e-02f, 9.31382179e-02f, -5.71251884e-02f, 6.73119444e-03f,
  -3.10988575e-02f, 9.66571569e-02f, -4.34999019e-02f, -1.32043066e-03f, 1.53305829e-02f, -2.80399416e-02f, -6.42490610e-02f, 5.02519086e-02f, 5.38292080e-02f, 7.20756128e-02f,
  -5.20697311e-02f, 4.64702956e-02f, -1.27848819e-01f, 1.79863125e-02f, 3.51115130e-03f, 3.08361184e-02f, -6.43136427e-02f, -6.62432685e-02f, 7.49623254e-02f, -5.18574044e-02f,
  -8.02802444e-02f, -3.48975882e-02f, -9.09768268e-02f, -5.80966212e-02f, -1.11449488e-01f, -7.78703466e-02f, -7.95927867e-02f, -1.11195752e-02f, 4.89727557e-02f, -6.23957030e-02f,
  6.07551709e-02f, -1.21851927e-02f, -5.55298999e-02f, 2.17726827e-02f, 6.57249056e-03f, 3.90213020e-02f, 6.11077137e-02f, -8.73485580e-02f, -3.63178514e-02f, -1.31213546e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -7.38687739e-02f, 1.02335766e-01f, 5.16657196e-02f, 8.46719965e-02f, -2.12260950e-02f, 2.20212471e-02f, -2.40422655e-02f, 2.92640980e-02f, -1.03877047e-02f, 6.42923713e-02f,
  1.18300520e-01f, -7.46468753e-02f, -7.49113364e-03f, -9.19752847e-03f, 6.61219209e-02f, 1.08037859e-01f, 1.04901001e-01f, 6.39475882e-02f, 1.11089639e-01f, -5.37027419e-02f,
  7.60178491e-02f, 7.46470392e-02f, 8.31361488e-02f, 3.27606015e-02f, 5.46132959e-02f, 1.22462370e-01f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  3.36319320e-02f, 5.09065688e-02f, 1.10724889e-01f, 7.63314068e-02f, -2.71078516e-02f, -1.30198365e-02f, -6.26110509e-02f, 3.75917032e-02f, -4.34548333e-02f, -6.85828030e-02f,
  -1.32404305e-02f, 1.04870126e-01f, 5.32628316e-03f, 6.96237832e-02f, 4.45537083e-02f, -8.55418518e-02f, -6.74363822e-02f, -5.06053269e-02f, -3.94067131e-02f, -8.47954750e-02f,
  8.10174569e-02f, 2.59073116e-02f, 1.61767557e-01f, -2.39435509e-02f, -5.41317509e-03f, -8.16558152e-02f, 2.56454926e-02f, -6.41492307e-02f, -4.67670485e-02f, -7.56939799e-02f,
  -4.73049805e-02f, -6.92257881e-02f, -2.72314493e-02f, -2.78422311e-02f, -4.15709987e-02f, -2.95632184e-02f, 1.73326135e-02f, -8.94975662e-02f, 3.28824259e-02f, -9.77220908e-02f,
  1.23700216e-01f, 2.29184218e-02f, -6.28387602e-03f, -1.66316330e-03f, -8.25473368e-02f, -2.58771218e-02f, -4.05959077e-02f, 6.34409040e-02f, 9.24551301e-03f, 8.64381194e-02f,
  -8.86416286e-02f, -4.16480117e-02f, 9.82257798e-02f, -6.69757798e-02f, 1.27351105e-01f, -2.64152773e-02f, -1.05816863e-01f, 1.26465335e-01f, 1.77314624e-01f, 4.13814783e-02f,
  -7.16945529e-02f, 4.78876643e-02f, 1.27459809e-01f, -5.15186861e-02f, 3.51496227e-02f, -1.48124933e-01f, -9.96229146e-03f, -7.90423900e-02f, -1.64747052e-02f, -3.50016505e-02f,
  -1.14966035e-02f, 1.36567518e-01f, 1.27977636e-02f, -9.12549719e-02f, -8.43613818e-02f, 7.11792856e-02f, -1.04347207e-01f, -5.37070520e-02f, 1.65810019e-01f, -1.07729761e-02f,
  -6.88140988e-02f, -9.62225497e-02f, -1.04884192e-01f, -4.73179221e-02f, -7.63783418e-03f, 3.69189493e-02f, -1.68841496e-01f, -5.91988079e-02f, -5.26527017e-02f, 7.81963617e-02f,
  -3.40118222e-02f, 1.11091949e-01f, -1.04416169e-01f, 5.95337246e-03f, 2.17247605e-02f, 4.03070897e-02f, -5.40381595e-02f, 1.30477063e-02f, -7.28088990e-02f, -5.53002134e-02f,
  -7.07875267e-02f, 1.61726668e-01f, -5.09339310e-02f, -6.87215775e-02f, -5.82993925e-02f, -5.29518425e-02f, 7.88914040e-02f, -5.96228838e-02f, 8.23067222e-03f, -6.33125380e-02f,
  1.16587535e-01f, -1.11701816e-01f, -8.57715458e-02f, 9.77853462e-02f, -6.58596084e-02f, 5.25439531e-02f, -7.58801168e-03f, -2.29906607e-02f, -8.78349915e-02f, -5.51316515e-02f,
  1.98645499e-02f, 1.75016727e-02f, 1.24847680e-01f, -1.30822072e-02f, 2.91680600e-02f, 2.54074740e-03f, 3.13102007e-02f, 8.60067680e-02f, -9.59622562e-02f, -3.75319868e-02f,
  -3.11396662e-02f, -4.64655086e-02f, 8.58059376e-02f, -6.89143836e-02f, -9.69864801e-02f, -1.11710848e-02f, -2.73165130e-03f, 2.03642566e-02f, 6.30354360e-02f, 5.76075464e-02f,
  8.03325549e-02f, 1.77849196e-02f, -2.14273892e-02f, -1.24924891e-01f, -3.56414579e-02f, -8.77096057e-02f, -5.74947111e-02f, 9.11255106e-02f, -6.38374090e-02f, 4.12127897e-02f,
  -9.42367241e-02f, -9.53676030e-02f, -4.91475221e-03f, 2.12171804e-02f, -2.88498085e-02f, -5.05541600e-02f, 2.45789737e-02f, 5.08282110e-02f, 2.94829067e-02f, -1.00999720e-01f,
  3.83700319e-02f, -1.24701768e-01f, -8.82909074e-02f, 7.16985390e-02f, -9.01643094e-03f, -1.91712193e-02f, -6.46254420e-02f, -8.23075324e-03f, 1.06919654e-01f, -1.81706659e-02f,
  -1.11928759e-02f, -7.40980506e-02f, -9.35098156e-02f, 6.89595193e-02f, -1.04646116e-01f, -6.91245124e-02f, 6.12704270e-02f, -4.26004007e-02f, -1.50620509e-02f, -5.19069545e-02f,
  1.09114386e-01f, 4.06008437e-02f, -6.29391819e-02f, 1.12141808e-02f, 1.41660674e-02f, 7.22394958e-02f, 1.72475979e-01f, -4.52376977e-02f, 1.72157828e-02f, -9.62762088e-02f,
  4.85949926e-02f, -1.16045974e-01f, -6.74829260e-02f, -1.10693268e-01f, 1.20725349e-01f, -5.93903251e-02f, 3.02252211e-02f, -1.23012096e-01f, 4.85271495e-03f, 1.21322274e-01f,
  -1.39542818e-01f, -1.01360761e-01f, 3.15434225e-02f, 6.72000423e-02f, -4.35357206e-02f, 3.60750072e-02f, 9.72473025e-02f, -6.24406897e-02f, 1.03594907e-01f, 4.93185669e-02f,
  -7.15877563e-02f, 8.99504647e-02f, 6.17897213e-02f, -4.29774709e-02f, -1.55272614e-02f, 4.15650234e-02f, 1.19054981e-01f, 5.84551431e-02f, 5.60454689e-02f, 1.50884226e-01f,
  4.05763946e-02f, -8.26150179e-02f, -4.08656691e-04f, -1.15183843e-02f, 6.79779202e-02f, -7.90613368e-02f, 1.32295936e-01f, 2.08853763e-02f, -2.08292902e-02f, 8.50669146e-02f,
  -1.41395126e-02f, 2.02591568e-02f, -3.79012786e-02f, -2.40263939e-02f, 2.90058702e-02f, -4.03422005e-02f, 4.24308004e-03f, -8.20881128e-02f, 6.76812306e-02f, 1.48465529e-01f,
  -7.58158416e-02f, -1.43042328e-02f, -3.06934374e-03f, 3.46786022e-04f, -7.53676444e-02f, -1.02987058e-01f, -2.30328310e-02f, 3.57234180e-02f, -6.38575554e-02f, 1.15529567e-01f,
  2.29814053e-02f, -6.26268610e-02f, 6.03546798e-02f, -5.19689173e-02f, -4.75855768e-02f, 7.09720105e-02f, -1.21006453e-02f, -1.21485181e-01f, 1.72054190e-02f, -5.91913015e-02f,
  7.04142731e-03f, -5.76047748e-02f, -6.59968406e-02f, -1.10598840e-01f, 3.05034630e-02f, 3.03139705e-02f, -5.05258031e-02f, 8.62623006e-02f, -4.77860384e-02f, 3.90328094e-02f,
  9.46247764e-03f, -4.32497784e-02f, -5.41987345e-02f, 7.89526943e-03f, 8.77550468e-02f, 5.76292463e-02f, -7.22097512e-03f, -5.81811741e-03f, 1.19516380e-01f, -1.80453993e-02f,
  -1.09919623e-01f, -8.39931220e-02f, -3.73589285e-02f, -1.09196715e-01f, 3.19344401e-02f, -3.25621814e-02f, 5.14520034e-02f, 8.81787762e-03f, 5.38723031e-03f, 4.26495858e-02f,
  6.00546449e-02f, 3.41714881e-02f, 4.02040333e-02f, -3.10729407e-02f, -5.88112399e-02f, -3.68481837e-02f, -1.27172858e-01f, 6.27312958e-02f, -4.42792699e-02f, -7.83164054e-02f,
  -3.92579511e-02f, 3.68459299e-02f, 9.14920196e-02f, 3.61174508e-03f, -4.71189767e-02f, 8.01580250e-02f, 5.31979948e-02f, -1.14402715e-02f, -1.23296149e-01f, 4.91782762e-02f,
  -7.59191439e-03f, 2.48743910e-02f, -1.83268189e-02f, -8.71253982e-02f, -1.22351997e-01f, -2.27906015e-02f, 7.51764029e-02f, -2.62738410e-02f, 8.76292139e-02f, 3.38236056e-02f,
  1.37752324e-01f, 2.97460984e-02f, 4.27290127e-02f, -1.18860960e-01f, 2.36290600e-03f, 4.41861786e-02f, 6.00010902e-03f, 7.17612728e-02f, 1.41543895e-01f, -9.36056972e-02f,
  -1.08318955e-01f, -1.18966825e-01f, -1.14623949e-01f, 2.88861357e-02f, 1.19182438e-01f, -1.20388523e-01f, 3.19418311e-02f, -9.88914073e-02f, 1.15012936e-01f, 2.94258967e-02f,
  -3.93382125e-02f, -7.93194920e-02f, 6.37060702e-02f, -1.14561439e-01f, 7.15775192e-02f, -7.72275478e-02f, 1.72314583e-03f, -7.62098804e-02f, 1.71886291e-02f, 2.49446854e-02f,
  -2.95481570e-02f, -2.66370904e-02f, 2.95690019e-02f, -4.41910960e-02f, -9.38040391e-02f, -2.61254422e-02f, -7.63910413e-02f, -1.85510162e-02f, 2.08869167e-02f, 5.10289744e-02f,
  5.08131199e-02f, -1.08536724e-02f, -3.28304358e-02f, 2.50738990e-02f, -1.86253935e-02f, -4.20113951e-02f, -6.86786175e-02f, -4.59963419e-02f, 5.63432761e-02f, 2.50036474e-02f,
  -9.25796404e-02f, 4.75079985e-03f, -2.13677995e-02f, 6.27151132e-02f, 2.50149593e-02f, -2.63982881e-02f, -1.11749232e-01f, -1.24429576e-01f, 4.88705635e-02f, -8.54829252e-02f,
  -7.13271648e-02f, -6.26616627e-02f, 3.34912762e-02f, -9.94113684e-02f, -1.08432524e-01f, -3.43801044e-02f, 4.07340415e-02f, 1.12988517e-01f, 1.80705474e-03f, 7.68894553e-02f,
  -9.49453190e-02f, 3.02608387e-04f, -3.49226780e-02f, -6.37475774e-02f, 7.38785602e-03f, 2.43420573e-03f, -1.92539580e-02f, 8.03818461e-03f, 4.45310622e-02f, -5.07257581e-02f,
  4.85665426e-02f, -5.47913089e-02f, -8.54678750e-02f, 9.23607275e-02f, -7.01655224e-02f, 6.77597076e-02f, -8.91188532e-02f, 4.85730357e-02f, -2.51253322e-02f, -1.02743328e-01f,
  -8.69865790e-02f, 3.52863297e-02f, -6.08323850e-02f, -1.07773237e-01f, -7.36005753e-02f, -1.16069503e-01f, -6.47440851e-02f, -1.81498751e-02f, 6.24365024e-02f, -7.60931596e-02f,
  -2.48855948e-02f, -1.67484507e-02f, -1.34260757e-02f, -1.16993211e-01f, 9.15436745e-02f, 6.95039555e-02f, 1.16716281e-01f, -4.56057712e-02f, 1.13268048e-01f, 1.60097629e-02f,
  -6.82421923e-02f, 4.46726307e-02f, -3.58600616e-02f, 5.11611067e-02f, 3.05136722e-02f, 6.41448572e-02f, -3.42860967e-02f, 8.15223604e-02f, -2.14080494e-02f, 2.02434231e-02f,
  2.14106917e-01f, 7.29283243e-02f, -9.23348367e-02f, 1.65359154e-01f, 8.06897134e-03f, 2.01775968e-01f, -5.65089434e-02f, 1.04025327e-01f, 7.47359172e-02f, -2.24574178e-01f,
  6.71409024e-03f, 4.43673097e-02f, 5.23011349e-02f, -5.16478643e-02f, -4.80883680e-02f, 5.41686751e-02f, -1.85602456e-01f, 1.15880094e-01f, -7.00047910e-02f, -1.17881738e-01f,
  1.92366689e-01f, -3.43982279e-02f, -1.48173109e-01f, -1.00554727e-01f, -3.81061668e-03f, 6.41923770e-02f, -1.01099268e-01f, -1.51204884e-01f, -1.18965171e-01f, -1.26844719e-01f,
  1.65219128e-01f, -1.90947056e-02f, -8.49746466e-02f, 1.87587976e-01f, 3.89686190e-02f, -7.34037235e-02f, 1.92657970e-02f, 3.34137157e-02f, 1.74594999e-04f, 1.02539048e-01f,
  -1.40920073e-01f, -3.42197567e-02f, -5.35212830e-02f, 4.98637892e-02f, -8.16251263e-02f, 5.45705333e-02f, 5.63428104e-02f, -2.89733056e-02f, -1.06510129e-02f, 4.87594232e-02f,
  2.38187760e-02f, 8.84012431e-02f, 1.00572824e-01f, 4.07993756e-02f, -1.05607854e-02f, 5.99459223e-02f, -3.94567102e-03f, -4.75321449e-02f, 2.82359105e-02f, -1.02102451e-01f,
  -2.13806443e-02f, -9.16020572e-03f, -8.58913511e-02f, -4.17843126e-02f, 1.22021390e-02f, 3.50830555e-02f, -7.26809427e-02f, -8.63929912e-02f, 1.29943117e-01f, -1.20595045e-01f,
  6.29872903e-02f, 5.41364215e-02f, 8.56969133e-02f, -1.08544186e-01f, 7.08938949e-03f, -5.60604259e-02f, -3.80453691e-02f, 7.06529394e-02f, 6.65119216e-02f, -7.11532459e-02f,
  -1.99483354e-02f, 3.25941928e-02f, 4.24191244e-02f, 2.87743974e-02f, 1.47091728e-02f, -7.47215748e-02f, 5.97430542e-02f, -8.22935253e-02f, 2.09398363e-02f, 8.11703131e-02f,
  -1.79577973e-02f, 7.28609115e-02f, -1.01093538e-01f, 9.80179384e-02f, 6.89775497e-02f, -7.24482834e-02f, -3.05530466e-02f, 7.77049959e-02f, 2.39575244e-02f, -1.11121617e-01f,
  -1.42508730e-01f, 1.08718025e-02f, 4.20916341e-02f, -2.06596609e-02f, -3.98060121e-02f, 6.79707229e-02f, -6.60449341e-02f, -7.57921264e-02f, -4.21412988e-03f, 1.24816895e-02f,
  1.05215110e-01f, 8.92529916e-03f, -3.11733522e-02f, -1.44640533e-02f, -2.21335329e-02f, -6.17968999e-02f, 3.48279160e-03f, 9.43945441e-03f, 2.16430221e-02f, 3.90993468e-02f,
  -3.89198214e-02f, 7.68772885e-03f, -9.23542008e-02f, 1.44631146e-02f, -7.48752207e-02f, 8.62206742e-02f, -6.88746274e-02f, -1.63409904e-01f, 1.68421939e-02f, -5.98156676e-02f,
  4.45620567e-02f, 4.24840860e-02f, 8.10896605e-02f, 9.75906476e-02f, -1.71738267e-01f, 1.62946448e-01f, 1.16418926e-02f, -4.89606224e-02f, 1.50522202e-01f, -1.06138818e-01f,
  -1.35340199e-01f, -8.78718495e-02f, 1.09025002e-01f, -1.51188195e-01f, 2.06357673e-01f, -5.50601184e-02f, -8.98330137e-02f, -9.85904410e-02f, -1.19725659e-01f, 1.93306655e-02f,
  8.74450430e-02f, -8.90449435e-02f, -3.38400528e-03f, -1.45202488e-01f, 9.29874554e-02f, 8.98685157e-02f, 6.66147694e-02f, 2.20084980e-01f, 3.20094302e-02f, -1.21264488e-01f,
  2.53064483e-01f, -1.50641844e-01f, -3.19288187e-02f, -1.46655897e-02f, 1.94932818e-01f, 1.34709150e-01f, -7.83600956e-02f, -6.89304173e-02f, 7.57954195e-02f, 1.39933145e-02f,
  -4.55446132e-02f, 1.18599251e-01f, 1.21372542e-03f, -8.61161873e-02f, -2.00049989e-02f, -2.82405261e-02f, 1.00071847e-01f, 5.36750443e-02f, -9.50431898e-02f, 4.42469455e-02f,
  -1.97896268e-02f, -3.98813076e-02f, 2.63411701e-02f, 4.75268736e-02f, -2.29506996e-02f, 3.32160294e-02f, -1.44512355e-01f, 8.29060078e-02f, -1.65350661e-01f, -6.23933785e-02f,
  1.56064644e-01f, 7.93273002e-02f, -3.12788635e-02f, 2.39748154e-02f, -1.60498813e-01f, -7.61947315e-03f, -8.49937573e-02f, 1.68000497e-02f, -7.47058764e-02f, 7.34836087e-02f,
  -7.28647709e-02f, 8.80730376e-02f, 3.73702310e-02f, 5.10954820e-02f, 2.48326231e-02f, -5.08709140e-02f, 4.11005691e-02f, -1.72989303e-03f, -8.83321092e-02f, -5.30778477e-03f,
  3.50542776e-02f, 6.49133623e-02f, 2.64056604e-02f, 3.82595286e-02f, -1.15542211e-01f, -9.47899595e-02f, 6.32321415e-03f, -3.93172577e-02f, 8.46436340e-03f, -1.62043050e-02f,
  7.80213112e-03f, 1.04039438e-01f, -1.31112132e-02f, 5.37930615e-02f, -6.08788654e-02f, -1.82152924e-03f, -4.04221714e-02f, 3.68215330e-02f, 6.52017668e-02f, -5.03535122e-02f,
  1.48937348e-02f, 4.66804057e-02f, -5.84578663e-02f, 3.93599924e-03f, 4.10225429e-02f, -2.38063503e-02f, -9.01999604e-03f, -7.61561766e-02f, -1.55841804e-03f, 8.79447907e-02f,
  -1.82737857e-02f, 1.55636566e-02f, -9.66686532e-02f, 8.41807127e-02f, -6.65447041e-02f, 5.21712229e-02f, -8.74943882e-02f, 8.06651711e-02f, 6.18859148e-03f, -2.76627615e-02f,
  -2.15231609e-02f, -7.48380832e-03f, -3.93840075e-02f, 8.16011429e-03f, 1.10227250e-01f, -2.88731921e-02f, -1.64775565e-01f, -1.18612416e-01f, 6.71134442e-02f, 4.43496332e-02f,
  2.25760229e-03f, -1.92922205e-01f, 2.04046741e-01f, -9.14315283e-02f, 6.47518188e-02f, 5.21694757e-02f, 8.91398564e-02f, -3.94421704e-02f, -8.75547528e-02f, 9.96137038e-03f,
  -8.47593397e-02f, 9.28662270e-02f, 5.49231209e-02f, -3.56547125e-02f, 1.36658505e-01f, 8.22322443e-02f, -1.96059063e-01f, -6.61549941e-02f, 9.15108696e-02f, 1.11584075e-01f,
  2.63203997e-02f, -1.15097791e-01f, -1.33540398e-02f, 1.69958532e-01f, 1.08963484e-02f, 8.47485363e-02f, -1.30626202e-01f, -4.41187844e-02f, 6.38750196e-02f, -1.46600276e-01f,
  6.31872192e-03f, 3.42869759e-02f, 4.09782212e-03f, -6.70441836e-02f, 9.80248675e-02f, 4.95696105e-02f, 6.81274161e-02f, -7.68564418e-02f, 8.61996859e-02f, -1.30698547e-01f,
  1.23659246e-01f, -1.17555866e-02f, -5.27511165e-02f, -9.86177754e-03f, 6.92995712e-02f, -3.01184459e-03f, -9.34340805e-02f, -1.23279870e-01f, 6.36863112e-02f, -2.13050172e-02f,
  -7.65114427e-02f, 6.78951815e-02f, 9.14283693e-02f, 2.16997322e-02f, 2.34825872e-02f, 9.35554951e-02f, -1.57535952e-02f, -9.20127928e-02f, 3.63665968e-02f, -3.58824134e-02f,
  -6.41985908e-02f, -3.88978384e-02f, 1.27124051e-02f, 8.75638649e-02f, -3.61948349e-02f, 7.91006684e-02f, -2.74411067e-02f, -7.48857707e-02f, -2.36693351e-03f, 1.08047664e-01f,
  9.17994305e-02f, -6.51840121e-02f, 5.07401936e-02f, -1.06043823e-01f, 2.94852965e-02f, 4.25401144e-02f, 6.05511665e-02f, -5.84671088e-02f, -5.93644269e-02f, 1.86523199e-02f,
  -1.36722356e-01f, 9.54670459e-02f, 3.29465233e-02f, 8.99456590e-02f, 1.27116190e-02f, 6.04317822e-02f, 1.21323250e-01f, -4.77442034e-02f, 1.72930993e-02f, 8.56095403e-02f,
  8.01728591e-02f, 2.86886636e-02f, -5.12398519e-02f, -3.26440521e-02f, 7.46366605e-02f, -2.78467918e-03f, 7.10325241e-02f, 8.30877125e-02f, 7.99971074e-02f, -2.16287952e-02f,
  -1.50770005e-02f, 6.05229326e-02f, -1.16520040e-02f, 4.27755304e-02f, 2.39386018e-02f, -8.90788808e-03f, -2.15887837e-02f, -6.22418858e-02f, -3.70755456e-02f, 9.13416520e-02f,
  -1.10420242e-01f, 4.51440886e-02f, -7.77123589e-03f, 1.02455867e-02f, 4.76214178e-02f, -2.24018078e-02f, -2.22432893e-02f, 2.30809972e-02f, -3.15285251e-02f, 9.37516391e-02f,
  -2.64079925e-02f, -7.85296336e-02f, 7.29288161e-02f, -1.00961722e-01f, -1.54878557e-01f, -1.17821410e-01f, -1.42845273e-01f, 6.36112690e-02f, 2.26893034e-02f, -7.91924819e-02f,
  4.13277708e-02f, 1.04733706e-01f, 1.86289027e-01f, 1.79690987e-01f, -2.25119248e-01f, 7.22741848e-03f, -2.40887702e-03f, 1.55887276e-01f, -7.39473104e-02f, 1.32544776e-02f,
  1.05715685e-01f, 1.89702094e-01f, 1.23669943e-02f, 8.17591250e-02f, -8.17768127e-02f, 1.26939550e-01f, 1.48105219e-01f, 1.00309439e-01f, -3.83657869e-03f, -1.73434690e-01f,
  -1.07093550e-01f, 2.09329501e-02f, -1.46589428e-01f, 1.80964842e-02f, -2.16277778e-01f, 5.67201376e-02f, 3.37078013e-02f, -1.06533328e-02f, -4.27206568e-02f, -7.69821331e-02f,
  -1.31540030e-01f, -4.10260446e-02f, 2.41854027e-01f, -2.05005277e-02f, 1.80198655e-01f, -8.99186283e-02f, -1.60351604e-01f, -4.93432768e-02f, -7.16593564e-02f, -7.96351060e-02f,
  7.16743395e-02f, 4.00086530e-02f, 3.71115506e-02f, 1.47741372e-02f, -5.29681407e-02f, -1.30479541e-02f, -3.34476773e-03f, 2.52749715e-02f, -1.09618180e-01f, 8.06400832e-03f,
  2.44806968e-02f, 4.74430881e-02f, 8.66412371e-02f, 3.41427140e-02f, 4.61799540e-02f, 1.37554109e-03f, -3.28005329e-02f, 6.34209439e-02f, 2.38800962e-02f, 6.57245889e-02f,
  4.33570370e-02f, -8.03624988e-02f, 1.09251581e-01f, -9.75059420e-02f, -1.49752833e-02f, -8.87354091e-02f, -5.32567874e-02f, 2.12452821e-02f, -5.91699295e-02f, 5.50671406e-02f,
  -5.07078245e-02f, -2.44445894e-02f, -7.65802711e-02f, -5.12065515e-02f, -7.71699846e-02f, 1.78477503e-02f, 8.80097523e-02f, 2.89907828e-02f, 1.43674398e-02f, 5.02391383e-02f,
  3.41214165e-02f, -5.06505109e-02f, -5.89917898e-02f, -6.64286390e-02f, -2.90314723e-02f, 1.18169405e-01f, -6.70423657e-02f, -2.99067460e-02f, -6.85422346e-02f, 6.23434037e-02f,
  8.18989426e-03f, -2.84866448e-02f, -4.46591638e-02f, -9.72695276e-02f, 1.20573662e-01f, -1.76762771e-02f, 4.88644987e-02f, 3.88218835e-02f, -5.56308702e-02f, 2.30859369e-02f,
  3.32514308e-02f, 6.72094375e-02f, 6.08137846e-02f, 1.06058391e-02f, 4.30627316e-02f, -3.61969583e-02f, 1.46081552e-01f, 1.03033334e-01f, -5.09183891e-02f, 6.27431199e-02f,
  1.20005593e-01f, -1.00069001e-01f, -7.14533553e-02f, -5.59804849e-02f, -7.33540431e-02f, -2.51886453e-02f, -1.30897912e-03f, -1.05150461e-01f, -2.79499148e-03f, -4.73293886e-02f,
  4.66340641e-03f, -4.88553233e-02f, 9.44195762e-02f, 1.88189715e-01f, 3.70510109e-02f, 1.02768436e-01f, -1.61284178e-01f, 1.10728435e-01f, -4.01688255e-02f, 1.36318542e-02f,
  -6.88003749e-02f, -2.37666622e-01f, 1.59930289e-01f, 9.29326117e-02f, -8.62536505e-02f, -2.26012409e-01f, -6.64344477e-03f, 6.36923835e-02f, -1.72946885e-01f, 3.58596146e-02f,
  -5.14256656e-02f, -1.43628800e-02f, 1.59062222e-01f, -1.33392394e-01f, -9.92413536e-02f, -4.68429998e-02f, -3.98358591e-02f, -1.93247739e-02f, -5.63424788e-02f, -9.32581648e-02f,
  7.36742839e-02f, 2.05649454e-02f, -1.33805424e-02f, -1.52839988e-01f, -1.54066309e-01f, 1.91184938e-01f, -5.20390160e-02f, 1.03875220e-01f, 1.07744277e-01f, -4.46896534e-03f,
  -5.70735037e-02f, 5.34819849e-02f, -1.04302458e-01f, 1.01185888e-01f, -3.10893953e-02f, 1.50664598e-01f, 5.72959781e-02f, -5.40378056e-02f, 8.10899064e-02f, -3.18575129e-02f,
  -2.72796638e-02f, -4.89187725e-02f, 8.51740688e-02f, 9.18183848e-02f, 6.44148365e-02f, 6.44060448e-02f, -4.32046466e-02f, 1.03937965e-02f, -1.07216217e-01f, 7.92758018e-02f,
  6.23447224e-02f, -1.16557628e-01f, 2.74940748e-02f, -7.65931606e-02f, 5.68154044e-02f, 5.71327358e-02f, 3.29828784e-02f, 9.41249505e-02f, 2.88446136e-02f, -1.00104012e-01f,
  4.65823859e-02f, -8.69625527e-03f, -6.05355054e-02f, -2.08012257e-02f, 8.04006830e-02f, 1.09545425e-01f, 6.24206364e-02f, -4.44226526e-02f, 2.68941093e-02f, 4.23022620e-02f,
  6.67051151e-02f, -8.67739543e-02f, -8.51264596e-03f, -6.13608286e-02f, -3.96143906e-02f, 5.58601841e-02f, -6.67153150e-02f, 5.95577657e-02f, -6.29517660e-02f, -5.81165701e-02f,
  7.86020979e-02f, 6.77568000e-03f, 6.84284419e-02f, 3.40005606e-02f, -1.56543981e-02f, 1.56417885e-03f, 1.11920781e-01f, -4.86118942e-02f, 5.46925589e-02f, -1.01833791e-03f,
  1.60246585e-02f, -1.82233620e-02f, -2.13111634e-03f, -1.36321736e-02f, 7.33360089e-03f, -2.28717341e-03f, -4.51730229e-02f, 1.54879340e-03f, 2.59754788e-02f, 3.00205443e-02f,
  -2.56374143e-02f, 8.56205821e-02f, 8.36117864e-02f, -2.74197683e-02f, 3.81153859e-02f, -6.84065148e-02f, 6.33272603e-02f, -6.79142922e-02f, -7.96814682e-04f, 6.39728364e-03f,
  6.10904843e-02f, 8.28018934e-02f, -1.12680206e-02f, 2.05645375e-02f, -4.12298478e-02f, 1.01289712e-01f, -2.80597527e-02f, -1.09870121e-01f, -7.88334310e-02f, -1.01320051e-01f,
  5.13178557e-02f, -4.76775281e-02f, -4.20690812e-02f, -5.52908331e-02f, 4.38475079e-04f, -1.34092560e-02f, 7.70451427e-02f, -1.09226592e-01f, 5.14319204e-02f, 9.33272094e-02f,
  -8.61727223e-02f, 6.23299032e-02f, -1.01333439e-01f, -3.89252007e-02f, -1.53009921e-01f, 2.99356151e-02f, 2.07227543e-02f, 2.90068518e-02f, 4.97925431e-02f, 2.30922345e-02f,
  -4.09115441e-02f, 7.34234368e-03f, -2.20548809e-02f, 9.21188071e-02f, 5.86121641e-02f, -9.46828201e-02f, -7.05110431e-02f, -9.27330777e-02f, 1.82535592e-02f, 1.18500218e-01f,
  -2.26075482e-02f, -1.11688927e-01f, 8.10745880e-02f, 4.62552235e-02f, -7.18701258e-02f, 1.28290765e-02f, -5.25072962e-02f, 1.53715014e-01f, 5.92539050e-02f, 1.56356648e-01f,
  1.20063215e-01f, -1.07335588e-02f, -1.02343649e-01f, -5.43054603e-02f, -4.43469845e-02f, -1.38761222e-01f, 4.21481626e-03f, 4.31994833e-02f, 8.04255344e-03f, -1.99911147e-02f,
  -8.68411660e-02f, -5.52054532e-02f, -8.15393850e-02f, 8.40803683e-02f, 4.88456748e-02f, -1.01935826e-01f, -4.22889702e-02f, -2.81770062e-02f, -4.47061770e-02f, -9.14972946e-02f,
  8.94347727e-02f, 3.75392213e-02f, 6.22744299e-02f, -9.84088182e-02f, 8.15772861e-02f, -7.42840692e-02f, 1.70012191e-02f, 3.45820887e-03f, 3.17247622e-02f, 4.22364026e-02f,
  5.55735268e-02f, 6.35657785e-03f, 8.03879499e-02f, -1.55887492e-02f, -8.96000862e-03f, -7.06655905e-02f, -6.17289264e-03f, 2.63452716e-02f, 5.42863049e-02f, 3.90677676e-02f,
  7.09600896e-02f, -7.75318816e-02f, -1.33863175e-02f, -9.20100231e-03f, -1.06258728e-01f, 4.20057662e-02f, -5.75125106e-02f, 5.55078611e-02f, -4.05130759e-02f, -7.24301040e-02f,
  5.55690192e-02f, -8.30074027e-02f, -1.66131277e-02f, 6.77304193e-02f, 6.54077008e-02f, -4.37435880e-02f, 6.11056983e-02f, 7.62707442e-02f, -4.00353260e-02f, -2.84322239e-02f,
  5.92271686e-02f, -1.66774467e-02f, -4.21716310e-02f, 3.11121121e-02f, 9.28272679e-03f, 1.03404596e-02f, -2.46620104e-02f, 1.73507985e-02f, -6.75219744e-02f, -9.17686522e-03f,
  -8.22063088e-02f, 5.90114146e-02f, -6.62377924e-02f, 2.24164650e-02f, -4.15803827e-02f, 9.50373113e-02f, 2.53988709e-02f, 7.73657160e-03f, 5.85754625e-02f, 7.29516670e-02f,
  2.13058833e-02f, 5.98684028e-02f, -1.87020265e-02f, 1.17616817e-01f, -2.63183210e-02f, -5.60942590e-02f, -8.72976407e-02f, 6.45511597e-02f, -7.77245611e-02f, -2.09288016e-01f,
  -1.83183163e-01f, -1.41051874e-01f, 9.30672064e-02f, -7.41682723e-02f, -2.75505371e-02f, -1.22821210e-02f, 8.21846128e-02f, 1.98311165e-01f, -1.16948187e-02f, -2.74080522e-02f,
  5.36368005e-02f, 1.23513035e-01f, -2.07288936e-02f, 8.82572215e-03f, 1.46385178e-01f, 6.88260645e-02f, 7.69052431e-02f, -6.82150349e-02f, -1.27542391e-01f, 4.27409448e-02f,
  -3.76849920e-02f, 7.68067911e-02f, 8.54756776e-03f, -3.56061533e-02f, -4.94944677e-02f, 1.31581932e-01f, -6.82077035e-02f, -3.60983498e-02f, -1.61622707e-02f, 3.42717879e-02f,
  -2.72680596e-02f, -1.70443863e-01f, -4.18084338e-02f, -2.75148395e-02f, -9.53043848e-02f, -6.48028105e-02f, 1.67271234e-02f, -1.13842160e-01f, 6.09681718e-02f, 3.22374068e-02f,
  -1.10101521e-01f, -1.39794871e-01f, -1.29304873e-03f, -7.23103210e-02f, 1.38037512e-02f, 3.86102125e-02f, 1.22961499e-01f, -6.07866906e-02f, 2.33720173e-03f, -3.19509767e-02f,
  -3.64604741e-02f, -5.83719015e-02f, -8.43071938e-02f, -8.87958333e-02f, 1.08345352e-01f, -7.05298185e-02f, -1.49476543e-01f, 2.77408715e-02f, 6.57648072e-02f, -4.85643260e-02f,
  -7.82050788e-02f, 5.81074320e-02f, -4.10102569e-02f, -4.57965657e-02f, 5.32401763e-02f, 7.95099437e-02f, -5.60183972e-02f, -1.54864304e-02f, 6.15979284e-02f, -1.54220641e-01f,
  3.79243493e-02f, -6.17711730e-02f, 8.34770054e-02f, 7.07650855e-02f, 8.22238252e-02f, -6.80968016e-02f, 7.74729345e-03f, -2.03717593e-02f, -5.29276133e-02f, -6.91648014e-03f,
  6.53411597e-02f, 1.44817248e-01f, 3.76773775e-02f, -7.91034773e-02f, -2.79726204e-03f, -3.56325172e-02f, 6.32223487e-02f, 8.49243328e-02f, 7.11593702e-02f, 1.86573493e-03f,
  -2.48533990e-02f, 6.75116181e-02f, 5.55958971e-02f, -2.24429574e-02f, 1.03328899e-01f, -2.31940718e-03f, 6.21567704e-02f, -1.10916542e-02f, -1.04328059e-01f, -1.70043260e-02f,
  -1.25748934e-02f, 7.38564059e-02f, 8.99401605e-02f, 2.27062330e-02f, 5.61819635e-02f, -1.74634084e-02f, -7.96616375e-02f, -4.12413757e-03f, -2.90950648e-02f, 2.48159133e-02f,
  -5.95479794e-02f, 2.10100431e-02f, 3.06115150e-02f, 2.41145734e-02f, 7.59763643e-02f, -1.31798182e-02f, 3.86178419e-02f, 7.30474591e-02f, -8.21238831e-02f, 8.50416049e-02f,
  -1.84858385e-02f, 8.26819837e-02f, -7.60946125e-02f, 1.65367220e-02f, 1.72539562e-01f, -5.20469211e-02f, -1.50245726e-01f, -5.13474494e-02f, 2.34228745e-01f, -3.13325226e-02f,
  6.42944947e-02f, -2.99148839e-02f, 1.51963919e-01f, -2.00765043e-01f, -1.10598974e-01f, -7.11862221e-02f, 8.12114999e-02f, 2.36582514e-02f, -1.44338161e-01f, -7.12906709e-03f,
  -6.42788410e-02f, 1.79706708e-01f, -4.51336354e-02f, -1.47727862e-01f, -2.01473758e-02f, 7.53718093e-02f, -1.19881727e-01f, -3.20122316e-02f, 3.59006710e-02f, 8.62628669e-02f,
  1.50614992e-01f, -7.72664547e-02f, 1.11037463e-01f, 3.63992294e-03f, 1.22299053e-01f, -1.04070134e-01f, -7.67777488e-02f, -1.59856990e-01f, 1.52821794e-01f, 8.15310888e-03f,
  -8.22899565e-02f, 1.40884474e-01f, 3.54438927e-03f, 5.33882193e-02f, 5.18040620e-02f, 6.74061030e-02f, 1.57448262e-01f, -7.98789859e-02f, 7.44911330e-03f, -2.10194327e-02f,
  1.18190087e-01f, 1.67563438e-01f, 6.96010590e-02f, -8.06183740e-02f, 5.35109676e-02f, -2.29649097e-02f, -8.46278667e-02f, -3.38865444e-02f, -1.78791434e-02f, 2.18984038e-02f,
  3.15739550e-02f, -1.19694494e-01f, -1.36348754e-02f, -2.35991832e-02f, -1.08571604e-01f, 2.77154287e-03f, -9.59725876e-04f, 1.69545822e-02f, 6.90766871e-02f, -7.57618248e-02f,
  -1.10904105e-01f, -5.55142900e-03f, 8.41984376e-02f, 1.12966552e-01f, -5.62187098e-02f, 1.05681352e-01f, -1.10720091e-01f, 1.50747478e-01f, 7.22145811e-02f, 7.44579127e-03f,
  5.61945252e-02f, 8.99723619e-02f, 8.89405385e-02f, 4.26990539e-02f, -4.64513861e-02f, 9.93526056e-02f, -2.14765761e-02f, 4.47160788e-02f, 3.38236913e-02f, -3.75415422e-02f,
  -6.25245273e-02f, -4.79181707e-02f, -5.21354973e-02f, -1.80613901e-02f, 1.19239122e-01f, 3.22806947e-02f, -4.39976167e-04f, 1.63565725e-02f, 5.34882396e-03f, 7.32519059e-03f,
  1.10427774e-01f, 4.96692620e-02f, 3.11718732e-02f, 8.18616804e-03f, -3.43720801e-02f, -4.80494909e-02f, -7.53180459e-02f, -3.36867273e-02f, -4.99896146e-02f, -1.34051135e-02f,
  -6.51989058e-02f, -4.47665993e-03f, 5.69613241e-02f, -2.93736365e-02f, -2.99056228e-02f, -5.32664843e-02f, -5.86094186e-02f, -2.95506660e-02f, 4.25414219e-02f, -3.57785039e-02f,
  6.22709189e-03f, 1.12919189e-01f, 1.50796324e-01f, 2.67965607e-02f, 8.73896778e-02f, -2.96657402e-02f, 5.81327751e-02f, 2.14850046e-02f, 4.38153045e-04f, -3.49147730e-02f,
  -1.14088304e-01f, -6.99781328e-02f, 9.37156752e-02f, -5.55904061e-02f, 8.25736597e-02f, -9.05762464e-02f, 7.40426406e-02f, 1.31070733e-01f, -5.93967065e-02f, 1.42810494e-01f,
  7.16808438e-02f, 6.28423020e-02f, 1.76355690e-01f, -1.36095017e-01f, 2.77006011e-02f, -2.66613383e-02f, -1.59464568e-01f, 5.86354220e-03f, -1.19568426e-02f, 2.31178313e-01f,
  -2.54394487e-02f, -1.37903625e-02f, -1.32924527e-01f, 6.14956841e-02f, -1.00319974e-01f, -1.22663774e-01f, 4.98965010e-02f, -5.86679298e-03f, 2.79769413e-02f, -1.77241728e-01f,
  -1.38052940e-01f, -4.23224382e-02f, 4.90633473e-02f, -1.21455751e-01f, -8.27504247e-02f, -4.09774482e-02f, -7.44258463e-02f, 1.14300303e-01f, 3.08998004e-02f, -8.62105936e-02f,
  -2.35998090e-02f, 7.10845441e-02f, 8.93815905e-02f, 1.37955949e-01f, 6.83249012e-02f, -2.22299863e-02f, -1.05945565e-01f, 4.44728285e-02f, -1.02646306e-01f, 1.07405946e-01f,
  5.31731173e-02f, 9.35639963e-02f, -5.01447879e-02f, -5.11695854e-02f, 6.61953166e-02f, 3.62490267e-02f, -1.40232220e-03f, 9.46453884e-02f, 1.05790310e-02f, -7.87205696e-02f,
  -5.75301498e-02f, -1.44610293e-02f, 4.55411561e-02f, -4.51327823e-02f, 1.01232737e-01f, 1.63997170e-02f, 7.91103113e-03f, 6.93321927e-03f, -9.09057334e-02f, 9.83626768e-02f,
  -4.70886268e-02f, -4.79452796e-02f, 1.21586345e-01f, -2.05532014e-02f, -7.41142631e-02f, -3.76051739e-02f, 5.42715564e-02f, 9.94423106e-02f, 2.52871811e-02f, -1.18272781e-01f,
  -8.83648098e-02f, 8.91825836e-03f, -2.61763819e-02f, -7.57832378e-02f, 8.14861655e-02f, -4.05555181e-02f, 1.59600785e-03f, -3.93719897e-02f, -3.56282480e-02f, 7.44380951e-02f,
  1.60979498e-02f, 5.65367863e-02f, 1.80354714e-02f, 3.01419608e-02f, 2.80146468e-02f, -9.96857211e-02f, -4.25265450e-03f, 3.09076514e-02f, 9.99238417e-02f, -1.05356790e-01f,
  9.76400301e-02f, -6.33181678e-03f, 3.38582844e-02f, -1.77767761e-02f, -9.92476121e-02f, 3.29042710e-02f, -6.30453378e-02f, 9.11186263e-02f, -2.77070198e-02f, -1.29720708e-02f,
  -1.79528594e-02f, 8.60429779e-02f, 3.26120071e-02f, -3.49041000e-02f, 2.10255128e-03f, 4.11448516e-02f, -4.09435946e-04f, 8.34199786e-02f, -8.85601491e-02f, -3.17203552e-02f,
  -5.91557510e-02f, 6.71458095e-02f, -4.86118421e-02f, 1.28482565e-01f, 1.46595191e-03f, 1.45891309e-01f, 5.69267944e-02f, 7.21208081e-02f, -1.26192391e-01f, -8.75015780e-02f,
  3.88645269e-02f, 4.55642566e-02f, -8.34423304e-02f, -2.64732298e-02f, 1.13136426e-01f, -5.79548739e-02f, 4.62272689e-02f, -9.59685910e-03f, 1.23970006e-02f, -2.25979574e-02f,
  8.48183781e-02f, 1.09030798e-01f, 2.44091824e-02f, 4.00688984e-02f, -1.42339006e-01f, -4.37783003e-02f, -1.08341575e-01f, 7.33485371e-02f, 8.99180695e-02f, 5.76620102e-02f,
  -1.32779360e-01f, 2.81904582e-02f, -8.91949758e-02f, -4.75274920e-02f, 1.29910246e-01f, 2.86915223e-03f, 7.19244555e-02f, -3.50292400e-02f, 1.57774277e-02f, -1.05380513e-01f,
  6.56933784e-02f, -1.60552133e-02f, -1.75601512e-01f, -7.82113969e-02f, 1.17761023e-01f, -7.54714152e-03f, 8.70306860e-04f, -6.78882152e-02f, -1.25172734e-01f, -4.56675589e-02f,
  -4.88889329e-02f, -7.22869933e-02f, 1.43169791e-01f, -2.65116971e-02f, -5.82285337e-02f, -5.86293936e-02f, -8.46194103e-03f, 1.08774312e-01f, -1.74376592e-02f, -1.19545572e-01f,
  3.53549346e-02f, 7.98416138e-02f, 3.81465033e-02f, 8.18884522e-02f, -1.05291463e-01f, -9.26855393e-03f, -4.42765132e-02f, -1.56159595e-01f, 3.69922258e-02f, 2.43652333e-02f,
  2.58594602e-02f, -1.12991976e-02f, -3.67081426e-02f, -7.02918395e-02f, -1.78035069e-02f, 4.20206375e-02f, -3.80354119e-04f, -3.23600471e-02f, 6.56533241e-02f, -5.12991771e-02f,
  6.67898264e-03f, 8.26923922e-03f, -8.60787630e-02f, 5.96610270e-02f, 6.46496490e-02f, 1.49977384e-02f, 7.01792017e-02f, -2.37453450e-02f, -6.23776689e-02f, 5.30429408e-02f,
  3.15483212e-02f, -8.34197998e-02f, -4.01834473e-02f, 3.13927010e-02f, 5.50589338e-02f, 9.73949730e-02f, 1.25093356e-01f, 4.56591062e-02f, -5.54799614e-03f, 9.24498308e-03f,
  8.70866627e-02f, -7.55996630e-02f, -1.10119050e-02f, 2.96015907e-02f, -6.20668195e-02f, 2.46506855e-02f, 9.46760550e-02f, -7.54593983e-02f, -6.48885444e-02f, 3.28869186e-02f,
  4.41133454e-02f, 2.95246653e-02f, -6.14399575e-02f, -4.19450775e-02f, 2.90837791e-02f, 8.46436843e-02f, 1.18125737e-01f, -8.56218487e-02f, -6.90738782e-02f, 5.56341074e-02f,
  5.88654727e-02f, -2.71765068e-02f, 3.05064907e-03f, -3.99799459e-02f, 8.05890711e-04f, 5.13531156e-02f, 2.92384233e-02f, -1.01914734e-01f, 4.63109650e-02f, 1.72382798e-02f,
  -3.41763832e-02f, -4.72542010e-02f, -1.74599718e-02f, 5.15133552e-02f, -4.64358367e-02f, 5.35853393e-02f, 1.46699920e-01f, -7.03194067e-02f, 6.86055720e-02f, 8.29697251e-02f,
  -5.59502840e-02f, 7.52051771e-02f, 2.86486186e-02f, -1.12644248e-01f, 3.53490598e-02f, -1.12578131e-01f, 1.20121159e-01f, -1.97629303e-01f, -1.50290698e-01f, -3.57680023e-02f,
  5.28870188e-02f, -1.31054930e-02f, -5.90592027e-02f, 4.55230698e-02f, 1.05080336e-01f, -8.10305849e-02f, 4.87640500e-02f, -9.13346633e-02f, 8.60020891e-02f, -4.55564400e-03f,
  -5.04023209e-02f, -3.95999625e-02f, -9.73364189e-02f, -3.32174562e-02f, 8.94953310e-02f, 2.64589507e-02f, 1.96432114e-01f, 9.62473676e-02f, 7.98288882e-02f, -1.17718540e-01f,
  2.61210315e-02f, 3.03690601e-02f, 1.31924242e-01f, -1.39917508e-01f, -1.23475149e-01f, 8.18482265e-02f, 5.24347574e-02f, -1.42542735e-01f, -1.15998864e-01f, 7.28268456e-03f,
  -7.24135190e-02f, -6.95443526e-02f, 1.92178547e-01f, -1.85212381e-02f, 4.37274948e-02f, 3.74341682e-02f, -6.75037503e-02f, -7.79071301e-02f, -2.88616475e-02f, -8.78884047e-02f,
  -4.98331897e-02f, -4.55487985e-03f, -7.66342655e-02f, -8.67564306e-02f, -9.31062698e-02f, -5.07436655e-02f, 8.39246809e-02f, -3.48818041e-02f, -1.09906130e-01f, 1.24318125e-02f,
  -8.81086439e-02f, 6.16734326e-02f, -4.60729487e-02f, -7.01244771e-02f, 1.04039218e-02f, -6.05920181e-02f, 8.62215608e-02f, -3.54388207e-02f, 3.00578047e-02f, -1.58694331e-02f,
  -7.06193224e-03f, 4.27202918e-02f, -8.18570852e-02f, 4.74769920e-02f, 2.41648387e-02f, 8.94269347e-02f, 3.97167094e-02f, -8.48793387e-02f, -1.00896597e-01f, 4.62051891e-02f,
  -8.38186443e-02f, 5.15527688e-02f, 7.98662454e-02f, 4.95419875e-02f, 1.33012876e-01f, 1.15319721e-01f, -6.49361163e-02f, 4.76930998e-02f, 2.28332002e-02f, -2.01657582e-02f,
  -2.61571184e-02f, 2.69096196e-02f, 1.74221881e-02f, 6.04942888e-02f, -1.03243880e-01f, 1.15948953e-01f, -2.05897354e-02f, 3.82334702e-02f, 5.47215855e-03f, 1.08485058e-01f,
  1.29104093e-01f, 6.91369548e-03f, -3.36256949e-03f, -1.02521792e-01f, -9.08350572e-02f, 9.79677867e-03f, -8.63014385e-02f, 6.95837289e-02f, -9.87055972e-02f, -1.87145602e-02f,
  -3.46610546e-02f, -2.99246255e-02f, 1.69599235e-01f, 5.64548783e-02f, 8.79747793e-02f, -6.52802782e-03f, 1.47094578e-02f, 4.35835309e-02f, -2.83073355e-02f, 6.56260177e-02f,
  6.62294626e-02f, 1.06838858e-02f, -2.86477078e-02f, -7.04901963e-02f, 1.26109123e-01f, 2.31171604e-02f, -1.46852834e-02f, -5.18827103e-02f, 8.99033323e-02f, 3.46186981e-02f,
  -1.53871113e-02f, 3.89156491e-02f, -1.99746415e-02f, -6.10851087e-02f, -2.12424491e-02f, -1.39417410e-01f, -8.81041959e-02f, -1.43875882e-01f, 4.93223108e-02f, 1.40043035e-01f,
  2.08906680e-02f, -8.61818343e-02f, -9.36164409e-02f, -5.70759960e-02f, -6.60670102e-02f, 9.69883148e-03f, 4.82199378e-02f, 1.45555526e-01f, 1.16336815e-01f, 1.70113426e-02f,
  -1.04484946e-01f, 1.18773337e-03f, 2.65857782e-02f, 9.46559832e-02f, -1.07219681e-01f, 2.23269314e-02f, 7.24355225e-03f, 9.40451119e-03f, 2.54764352e-02f, 1.06237642e-01f,
  -1.21095680e-01f, -1.90668588e-03f, 1.46375403e-01f, -9.40321162e-02f, -4.17668447e-02f, 9.91831161e-03f, 1.64990857e-01f, 6.74330071e-02f, 7.49155208e-02f, 4.88960743e-03f,
  -5.15951253e-02f, -8.39775056e-02f, -6.93354681e-02f, -1.42919645e-01f, -3.36576030e-02f, -4.23413105e-02f, -9.02240425e-02f, -3.66635025e-02f, -4.89026681e-02f, -1.12903140e-01f,
  2.43758480e-03f, 6.17407598e-02f, 9.20077264e-02f, 1.52922541e-01f, -8.96515921e-02f, 6.76073739e-03f, 1.56058475e-01f, -9.28485990e-02f, -2.57950127e-02f, 1.08586866e-02f,
  5.54973856e-02f, 4.52925563e-02f, 6.97980151e-02f, 1.03161201e-01f, 1.03867717e-01f, -6.19076118e-02f, 1.81607045e-02f, -2.27172952e-03f, 7.67120197e-02f, 1.06481493e-01f,
  2.61595547e-02f, 1.11635170e-04f, 1.54142324e-02f, 4.93687317e-02f, 6.18586428e-02f, 1.16763838e-01f, 1.08776063e-01f, 2.04479713e-02f, -1.06693082e-01f, 6.07344247e-02f,
  6.36508092e-02f, -6.81857346e-03f, -4.46314700e-02f, -8.79616514e-02f, 5.61389551e-02f, -8.53451639e-02f, -4.57909144e-02f, 5.25018685e-02f, 4.22092155e-02f, 6.05000705e-02f,
  5.62547892e-02f, 2.09025070e-02f, 9.40506384e-02f, -1.06595263e-01f, -3.70127112e-02f, -7.42169246e-02f, 3.58516462e-02f, 5.51552959e-02f, 1.63638089e-02f, 2.20707320e-02f,
  -8.91003236e-02f, 5.27370255e-03f, 5.88969253e-02f, -4.94340137e-02f, -1.47172436e-02f, 4.67755832e-02f, 1.65156964e-02f, -2.26417240e-02f, 3.98169346e-02f, -3.42472419e-02f,
  -8.91428515e-02f, -5.59485592e-02f, 1.48450239e-02f, -1.77093539e-02f, 1.98487211e-02f, 2.82670818e-02f, -2.87091751e-02f, 1.16517218e-02f, 2.99501959e-02f, 1.38190612e-01f,
  1.93434898e-02f, 9.03771296e-02f, -1.33624496e-02f, 2.11876780e-02f, 2.00685044e-03f, 5.05773351e-02f, -1.18633740e-01f, -7.45642334e-02f, 5.83535805e-02f, 1.99470413e-03f,
  -3.98124494e-02f, -1.32400751e-01f, 1.03855906e-02f, -1.39559433e-01f, 1.71332490e-02f, 1.09592058e-01f, 4.54718322e-02f, -9.81324837e-02f, 7.46955872e-02f, 4.80451472e-02f,
  4.66793217e-02f, 6.25119284e-02f, 7.39887133e-02f, -1.98365882e-01f, 1.02434762e-01f, -1.22368261e-02f, -8.05950388e-02f, 1.04497291e-01f, -5.95923588e-02f, 1.98794566e-02f,
  7.72009939e-02f, 1.16084233e-01f, 2.09867775e-01f, 1.30366951e-01f, -4.34354767e-02f, -1.32868409e-01f, 6.38630688e-02f, -5.12226038e-02f, 8.56921598e-02f, 2.38031708e-02f,
  -9.03635323e-02f, 8.13503414e-02f, 8.20737258e-02f, -1.21041201e-01f, -1.18665442e-01f, -2.89772041e-02f, -5.66541310e-03f, 5.22162300e-03f, 1.07303418e-01f, 1.49307903e-02f,
  9.81092006e-02f, 6.88274801e-02f, 7.73864761e-02f, -6.95269555e-02f, -1.45035889e-03f, 7.10352212e-02f, -7.55627677e-02f, 6.59050718e-02f, -1.06436208e-01f, -9.80040506e-02f,
  4.62012598e-03f, -7.90379867e-02f, 5.55642955e-02f, 8.78602490e-02f, 2.07402417e-03f, -1.80021133e-02f, 5.17159775e-02f, 3.71374562e-02f, -5.34809865e-02f, 5.53157665e-02f,
  -4.29936871e-02f, 1.52012967e-02f, 1.66797359e-02f, 1.10126212e-02f, 5.06922081e-02f, 1.82039812e-02f, -3.38446372e-03f, 6.42712787e-02f, 7.66242072e-02f, -9.23866220e-03f,
  6.47863671e-02f, -7.27947578e-02f, 3.69969122e-02f, -1.59278661e-02f, 7.59844854e-02f, -2.31259353e-02f, 1.01401955e-02f, -6.57630116e-02f, -7.55718946e-02f, -9.13289189e-02f,
  -4.94045205e-02f, 1.24028899e-01f, 2.68732887e-02f, 1.19059615e-01f, -3.57759818e-02f, -5.10733426e-02f, -9.03272703e-02f, -3.15335132e-02f, 3.63261178e-02f, 9.87181887e-02f,
  5.75897917e-02f, -9.60087255e-02f, -5.46796769e-02f, 6.95855245e-02f, -7.48054832e-02f, -1.62738748e-02f, -1.03194863e-01f, -7.55293146e-02f, 9.53513309e-02f, -8.01805556e-02f,
  -1.48739517e-01f, 5.67567311e-02f, 8.89436901e-02f, -3.57917100e-02f, 9.52102020e-02f, -7.50389770e-02f, 3.96642238e-02f, -2.07792297e-02f, -2.92042848e-02f, 3.49894054e-02f,
  -7.82384574e-02f, -2.63836477e-02f, 1.03679247e-01f, 1.04530051e-03f, -1.08602978e-01f, -9.80775431e-02f, -4.64507565e-03f, -5.91861233e-02f, 9.18444395e-02f, -4.46954779e-02f,
  -9.52542946e-02f, -1.07279383e-02f, 3.78718302e-02f, -5.78729622e-02f, 1.32685006e-01f, -8.71366337e-02f, -1.31886050e-01f, -6.23847917e-03f, 1.55442674e-02f, 1.16896920e-01f,
  -7.17090070e-02f, 1.49414435e-01f, 1.20470934e-01f, -8.27029645e-02f, -8.14410895e-02f, 1.04384162e-01f, 7.94702321e-02f, 9.43173915e-02f, -5.95655479e-02f, 1.66557971e-02f,
  1.00261807e-01f, 1.11743696e-01f, 1.45474374e-02f, 4.84697446e-02f, -6.39194921e-02f, 3.02014928e-02f, 1.02060691e-01f, -4.54106219e-02f, -9.25884396e-02f, -1.98318586e-01f,
  -1.87383190e-01f, -1.46394551e-01f, 1.14629986e-02f, -2.33863611e-02f, -1.50364116e-01f, -2.46154126e-02f, 3.24987900e-03f, -3.22934310e-03f, 4.57888767e-02f, -2.36662440e-02f,
  5.31929098e-02f, -2.18013581e-03f, 5.22630289e-02f, 2.08770111e-02f, 4.75220382e-02f, 1.17694207e-01f, -1.27041921e-01f, -3.16855055e-03f, -1.28304623e-02f, -1.22810416e-01f,
  3.30565474e-03f, -1.27225900e-02f, -3.45933512e-02f, 6.43192455e-02f, 3.61925587e-02f, 1.01488680e-01f, 3.55581678e-02f, 1.14346724e-02f, 5.14498465e-02f, 1.12743370e-01f,
  -8.35068822e-02f, 6.48048008e-03f, 1.27881125e-01f, -1.58613697e-02f, 7.02214241e-02f, -1.13278814e-01f, 4.46148589e-03f, -4.22476679e-02f, 9.60109904e-02f, 1.00209378e-01f,
  -9.16687474e-02f, -1.39111700e-02f, -6.46075159e-02f, -1.11444369e-01f, 1.28897533e-01f, -1.11860603e-01f, 5.46455421e-02f, 4.45722751e-02f, -7.84555972e-02f, -1.63430031e-02f,
  -1.20559998e-01f, 5.12607135e-02f, 2.09280495e-02f, 5.30957170e-02f, 8.05989876e-02f, 1.38246179e-01f, 1.19671947e-03f, -8.24918598e-02f, 1.05555449e-02f, -1.03782952e-01f,
  5.71321473e-02f, -1.81698508e-03f, -7.14124292e-02f, -3.19171660e-02f, -1.08950287e-02f, 4.75496612e-02f, -9.50459018e-02f, -6.56236187e-02f, -1.06898405e-01f, 4.91450615e-02f,
  1.52402315e-02f, -7.88976476e-02f, 2.71690395e-02f, -7.69172013e-02f, 1.46757618e-01f, 1.78683400e-02f, -8.85246024e-02f, -7.30556902e-04f, -1.94160063e-02f, 1.01469889e-01f,
  -1.85172185e-02f, -1.08494334e-01f, -6.97556138e-02f, 3.66290621e-02f, -7.45036453e-02f, -6.00550994e-02f, 1.74742639e-02f, 2.51808413e-03f, -6.43924922e-02f, 1.35798147e-02f,
  6.78576753e-02f, 1.07842170e-01f, -6.77929819e-02f, 2.41065156e-02f, -3.16419173e-03f, 2.66238805e-02f, 9.87900421e-02f, 5.36231026e-02f, 2.09934395e-02f, 3.94019391e-03f,
  3.82759888e-03f, 2.30406169e-02f, 6.35056868e-02f, -4.39074486e-02f, -1.89626053e-01f, -1.62182167e-01f, -6.09005429e-02f, 5.16325161e-02f, -7.42545500e-02f, -2.38731373e-02f,
  -9.55226570e-02f, 1.17151059e-01f, -6.21539727e-02f, 5.71569130e-02f, 9.50448588e-02f, 1.66744426e-01f, 1.36883587e-01f, -2.43796967e-02f, -9.54606161e-02f, 3.47229168e-02f,
  -1.32499961e-02f, -1.40117705e-01f, 1.51253670e-01f, 1.31910935e-01f, -5.79283051e-02f, -2.57213749e-02f, -5.02433591e-02f, -1.94369594e-03f, 7.30690658e-02f, 8.12472925e-02f,
  -3.17974947e-02f, -1.04736928e-02f, 6.47440031e-02f, 1.26477674e-01f, -1.08335137e-01f, 4.44788262e-02f, 1.19681709e-01f, 5.07842414e-02f, -8.09626747e-03f, -5.62162213e-02f,
  -4.14851122e-02f, -1.73346713e-01f, -1.85360804e-01f, -1.40311047e-02f, 6.10703304e-02f, 9.23133716e-02f, -7.42674321e-02f, 6.27688617e-02f, -5.19268401e-02f, 9.45488811e-02f,
  -8.52020830e-02f, -7.25736693e-02f, 7.30376020e-02f, 2.43665986e-02f, -1.00597762e-01f, -5.83833382e-02f, -1.74622517e-02f, -5.06252199e-02f, -2.58836541e-02f, -1.69476271e-02f,
  -2.80339476e-02f, -6.24586232e-02f, 8.20821971e-02f, 2.24997625e-02f, -4.84790578e-02f, 6.04246333e-02f, 1.10297933e-01f, 4.64750975e-02f, 4.46303599e-02f, -1.45003069e-02f,
  -2.36293748e-02f, 3.57280974e-03f, 8.22908953e-02f, -1.31880149e-01f, 5.24122678e-02f, 1.50154918e-01f, -4.45302986e-02f, -6.92222640e-02f, -2.87643149e-02f, 3.40184034e-03f,
  -3.67745124e-02f, -9.61188152e-02f, 9.24916379e-03f, 5.88055467e-03f, 4.24388200e-02f, 7.65190274e-02f, 7.74834445e-03f, 8.53539184e-02f, 2.03597248e-02f, 4.04306082e-03f,
  2.52797510e-02f, -7.84878284e-02f, 2.56633591e-02f, 2.45248936e-02f, 8.87299236e-03f, 5.26591018e-02f, 3.32687832e-02f, 8.40859562e-02f, 1.11778505e-01f, 8.42215568e-02f,
  1.78192952e-03f, 1.24955162e-01f, -2.45217439e-02f, 2.35822964e-02f, -3.28226984e-02f, 6.33661449e-02f, 9.18008760e-03f, -2.24513393e-02f, -3.43741998e-02f, 1.38974443e-01f,
  -1.03173636e-01f, 2.97890995e-02f, 6.89121410e-02f, 5.02929650e-02f, -3.08238678e-02f, -1.88878400e-03f, -6.27581179e-02f, 1.21007591e-01f, 9.57185403e-02f, -7.11339861e-02f,
  -3.76354754e-02f, 6.72131255e-02f, 4.74868529e-02f, -2.44748350e-02f, -3.25410515e-02f, 4.40757833e-02f, -1.67088628e-01f, -1.13660723e-01f, 9.16650966e-02f, -6.24854267e-02f,
  -1.09332748e-01f, -7.24908859e-02f, -7.86902159e-02f, -4.20177579e-02f, 1.32913455e-01f, -5.75342365e-02f, -2.90038865e-02f, -1.29975066e-01f, 9.48916301e-02f, 6.11643260e-03f,
  -1.14364333e-01f, 1.17990330e-01f, 3.60634439e-02f, 7.38680586e-02f, -1.52018681e-01f, 1.32535055e-01f, 5.24746701e-02f, 1.19088769e-01f, 1.30536407e-01f, 1.49452537e-01f,
  -7.01769441e-02f, -7.08049983e-02f, 6.85466826e-02f, 1.32257313e-01f, 1.07386587e-02f, -1.52478218e-01f, -2.06761748e-01f, -3.21507975e-02f, 2.99277063e-02f, 1.22369826e-01f,
  -1.48568183e-01f, -5.70603311e-02f, -9.82761607e-02f, 8.18353891e-02f, 9.06140171e-03f, -1.72209710e-01f, -4.99865692e-03f, 1.54056162e-01f, 2.38257676e-01f, 2.73469333e-02f,
  9.22363549e-02f, -5.54572754e-02f, -7.83422440e-02f, -1.24992892e-01f, -4.06319015e-02f, -1.03098609e-01f, -2.17726789e-02f, -2.98576038e-02f, 4.10831310e-02f, -8.23390633e-02f,
  -7.69674331e-02f, -3.84676941e-02f, 1.73081886e-02f, 1.08323433e-01f, -3.07763610e-02f, 9.50559601e-03f, 5.81373787e-03f, 5.26254624e-02f, -9.79758650e-02f, 6.13724850e-02f,
  6.17853962e-02f, -8.36892053e-02f, -1.16526365e-01f, -2.53963843e-02f, 2.37032231e-02f, 5.42514175e-02f, 9.46497023e-02f, -9.26992372e-02f, 1.27091944e-01f, 1.78526938e-02f,
  -7.13511705e-02f, -1.78847909e-02f, 1.41764162e-04f, 5.94013371e-02f, 6.12734817e-02f, 3.17152888e-02f, -2.45286040e-02f, -5.17619774e-02f, -1.00412540e-01f, -5.85014559e-02f,
  -7.78519809e-02f, 7.86213279e-02f, 4.07194346e-02f, 4.31329422e-02f, 4.27161418e-02f, -6.67260438e-02f, -1.92411430e-02f, 2.95864139e-03f, -6.83681993e-03f, 1.09806970e-01f,
  -2.58931555e-02f, 5.40403463e-02f, -9.90117416e-02f, 4.49662842e-02f, 1.31149381e-01f, 2.50667278e-02f, -8.19280371e-02f, -3.33611630e-02f, -1.38187585e-02f, -5.33727296e-02f,
  -1.23145794e-02f, -6.64859042e-02f, -5.98512962e-02f, 3.79903056e-02f, 3.90606932e-02f, -3.27439196e-02f, 9.70343724e-02f, 3.40096317e-02f, 7.92970136e-02f, -3.99367996e-02f,
  -7.87264034e-02f, -5.56400955e-05f, -4.09568287e-03f, 3.71838622e-02f, -1.06642373e-01f, -6.24188073e-02f, -8.41328278e-02f, 3.68886143e-02f, 2.97056831e-04f, 7.93987289e-02f,
  2.40456853e-02f, 1.24767177e-01f, 4.51659821e-02f, 4.37805951e-02f, 9.27020162e-02f, 1.78383425e-01f, 4.49145846e-02f, 4.37039547e-02f, -2.93484777e-02f, 8.51290300e-03f,
  6.52569607e-02f, -4.55015488e-02f, -1.14272140e-01f, -4.29048389e-02f, 2.18804944e-02f, -3.29720899e-02f, -3.05742156e-02f, -2.72003026e-03f, 8.87016580e-02f, -1.18630834e-01f,
  4.27953061e-03f, 7.98869655e-02f, 1.25677183e-01f, -7.11881444e-02f, 4.07691710e-02f, -6.88158497e-02f, -1.16878692e-02f, -1.23884343e-01f, -1.25587761e-01f, -3.71295176e-02f,
  1.30769372e-01f, -9.39792991e-02f, -5.11294603e-02f, 7.46889263e-02f, 3.61027159e-02f, 7.63691142e-02f, -4.93923873e-02f, -1.15120135e-01f, -8.35884362e-02f, 2.46822834e-02f,
  2.95554288e-03f, 2.94391196e-02f, 8.64580646e-03f, 9.75100398e-02f, 5.99204712e-02f, -1.84399009e-01f, -2.37585470e-01f, -2.36514717e-01f, 1.85538996e-02f, 4.10799570e-02f,
  5.82858548e-02f, 4.40617884e-03f, -6.87096417e-02f, 8.82647038e-02f, -4.11621146e-02f, 1.53921004e-02f, 3.70358750e-02f, -9.51835141e-03f, 1.41177084e-02f, -2.66256277e-03f,
  -1.19094767e-01f, 5.24193272e-02f, -3.79970968e-02f, -7.01768249e-02f, 1.16608180e-01f, 1.02836147e-01f, -8.34250376e-02f, 6.14309050e-02f, -2.28540786e-02f, -1.01463217e-02f,
  1.19098201e-02f, 7.33092846e-03f, -2.45049410e-02f, -7.94005319e-02f, -3.35891061e-02f, 6.25654384e-02f, -1.24644898e-01f, -1.92932039e-02f, -1.10948257e-01f, -2.54929885e-02f,
  -5.53484932e-02f, 8.50321725e-03f, 7.84628838e-02f, 7.39956181e-03f, 3.25232446e-02f, -4.81364615e-02f, -8.38555843e-02f, -4.73374911e-02f, -2.78127231e-02f, 1.26164794e-01f,
  -2.14212183e-02f, 3.91195063e-03f, 5.10015525e-03f, 5.46023026e-02f, 4.21716608e-02f, -4.95114550e-02f, 6.16099983e-02f, -3.12981941e-02f, -9.81046855e-02f, 9.62452516e-02f,
  6.33255914e-02f, -1.35158915e-02f, -8.34791884e-02f, 2.90353112e-02f, -4.35814867e-03f, -7.61144459e-02f, 4.41574119e-02f, -6.35279641e-02f, 2.19766069e-02f, 1.05599966e-03f,
  2.64541451e-02f, 4.35984023e-02f, -2.95821466e-02f, -4.85790670e-02f, 5.26923351e-02f, -1.52852209e-02f, 3.60090435e-02f, 4.64437529e-02f, -1.13494568e-01f, -6.96908310e-02f,
  4.40939106e-02f, -6.53897449e-02f, -5.24989441e-02f, -2.03587618e-02f, 1.13313042e-01f, -1.11132614e-01f, -7.31972903e-02f, 6.00941405e-02f, -3.77464257e-02f, -2.71014981e-02f,
  3.11570019e-02f, -8.54959115e-02f, 6.17218576e-02f, 5.44971898e-02f, 1.32886872e-01f, 6.04860000e-02f, -6.94404840e-02f, 1.04367755e-01f, 4.36085984e-02f, -9.62420308e-04f,
  1.50822997e-02f, -5.91006223e-03f, 1.05829939e-01f, -8.12716186e-02f, -2.07260512e-02f, -3.93738970e-02f, 1.36030778e-01f, 1.15921892e-01f, 7.71122575e-02f, -1.81813091e-01f,
  3.54689881e-02f, 7.68227279e-02f, -8.35119784e-02f, 9.49635282e-02f, -8.13135952e-02f, 1.85688615e-01f, -4.25819680e-02f, -9.65730622e-02f, 1.19916692e-01f, 2.28634162e-04f,
  5.75000197e-02f, -6.11768402e-02f, -8.58372152e-02f, 5.18921092e-02f, 7.33714849e-02f, -1.28385574e-02f, -7.95554891e-02f, -5.90801947e-02f, -4.66529801e-02f, -1.56595353e-02f,
  1.36552408e-01f, 1.78366065e-01f, 9.18488353e-02f, 3.50283198e-02f, -3.19157094e-02f, -1.49875686e-01f, 5.62088862e-02f, 7.81760085e-03f, -4.29882668e-02f, 8.65198895e-02f,
  -5.41021191e-02f, 4.76238467e-02f, -8.22643787e-02f, 3.15556824e-02f, 6.77756732e-03f, 2.05022865e-03f, -1.93493702e-02f, 3.87343876e-02f, 2.42696460e-02f, 3.88438329e-02f,
  -3.08841728e-02f, -1.02172643e-01f, 4.10954282e-02f, -4.79274150e-03f, 1.05451398e-01f, -6.39557466e-02f, -6.95585534e-02f, -1.96837075e-02f, -7.60202408e-02f, 4.07449491e-02f,
  2.58162171e-02f, 7.27146491e-02f, 1.34891905e-02f, -1.29891392e-02f, 4.44433093e-02f, 1.01808622e-01f, 8.33881572e-02f, 1.04001760e-01f, 9.59811509e-02f, 3.02792285e-02f,
  5.45035340e-02f, 3.44955642e-03f, 6.91173971e-02f, 1.04773762e-02f, 7.44854584e-02f, -2.89461333e-02f, -5.83758131e-02f, -4.08490887e-03f, -6.91636950e-02f, -9.44119915e-02f,
  -1.05401419e-01f, 8.19499865e-02f, -2.68974584e-02f, 1.73189975e-02f, 2.81157084e-02f, 4.80309315e-02f, -6.47958294e-02f, 8.89369994e-02f, 8.74023810e-02f, 8.21560621e-02f,
  8.98318812e-02f, 9.60401352e-03f, -8.54748115e-03f, 8.88312235e-02f, 3.44040729e-02f, 5.21009080e-02f, 2.04901043e-02f, -5.86080812e-02f, -5.00934795e-02f, -3.83457914e-02f,
  -8.48737136e-02f, 1.05255693e-02f, -3.13977003e-02f, 7.59421960e-02f, -3.18359584e-02f, 3.54158320e-02f, 7.15788826e-02f, -3.71318869e-02f, 3.86559367e-02f, 4.11096737e-02f,
  -2.73961853e-02f, 7.13421553e-02f, 1.18982375e-01f, 8.32819790e-02f, 5.65878749e-02f, -8.50264952e-02f, 4.05356921e-02f, -4.04252373e-02f, -3.41053046e-02f, -3.61453034e-02f,
  -5.73776923e-02f, -9.77054238e-02f, 7.16999248e-02f, -1.48855075e-01f, -9.04569775e-02f, -1.18140802e-01f, -4.35932539e-03f, 2.01731129e-03f, 8.60311836e-02f, 1.69248749e-02f,
  2.67689172e-02f, 1.02520108e-01f, 4.92339581e-02f, 1.59326922e-02f, -1.38564676e-01f, 7.32075945e-02f, -8.37324113e-02f, 7.75054619e-02f, 5.83804920e-02f, 6.96496293e-02f,
  1.55166075e-01f, -2.77337898e-02f, -5.84776141e-02f, 4.02297452e-02f, -2.42152568e-02f, -1.91178657e-02f, 1.34732693e-01f, 2.60066185e-02f, 5.90242147e-02f, -1.66129008e-01f,
  5.30139431e-02f, -3.98886874e-02f, 1.13911079e-02f, 9.49980170e-02f, -4.44146655e-02f, -1.92113426e-02f, 7.63867646e-02f, 3.31549980e-02f, -5.37140630e-02f, 2.60026921e-02f,
  -5.82641624e-02f, -4.46626358e-02f, 1.54215366e-01f, 2.99391150e-02f, 1.57927871e-01f, 5.85897304e-02f, -4.34057079e-02f, 3.59631889e-02f, -3.29802558e-02f, -6.67904392e-02f,
  5.18921763e-02f, -5.75321494e-03f, 2.65582111e-02f, 9.41393450e-02f, -2.39360798e-02f, 8.99399295e-02f, 1.95744969e-02f, -5.73134385e-02f, -1.66361947e-02f, 7.66829178e-02f,
  6.29746988e-02f, -1.90365538e-02f, -9.39985458e-03f, 1.04095504e-01f, -8.96214545e-02f, -6.19231500e-02f, -7.33593926e-02f, 1.02427319e-01f, 1.03631653e-01f, 7.93130137e-03f,
  5.37932552e-02f, -4.61595245e-02f, 1.72289405e-02f, -4.02492099e-02f, -3.92244086e-02f, -8.40861127e-02f, -5.78504838e-02f, -9.70757604e-02f, 2.62955315e-02f, -5.00614829e-02f,
  4.75139357e-02f, 8.92095044e-02f, -7.82412216e-02f, 1.83995091e-03f, -1.02718677e-02f, -5.59595414e-02f, -1.22299297e-02f, 1.16415441e-01f, -6.75509125e-02f, -4.00942005e-02f,
  -4.49567437e-02f, 4.54047844e-02f, 3.66039574e-02f, 2.68371813e-02f, -7.16243312e-03f, -5.00141457e-02f, -7.47834817e-02f, 8.55886340e-02f, 1.35392155e-02f, 5.84939308e-02f,
  2.41735745e-02f, 8.99579376e-02f, 7.18539283e-02f, 7.50014111e-02f, -9.97534320e-02f, 8.27442333e-02f, 1.62199382e-02f, 7.45902732e-02f, -1.33746257e-02f, 1.69754568e-02f,
  -8.51364154e-03f, 7.42561296e-02f, 2.71815155e-03f, 2.58133579e-02f, -7.91712701e-02f, -4.18463163e-02f, -4.64990474e-02f, -3.73599082e-02f, 1.64918918e-02f, 1.05731361e-01f,
  -4.25999751e-03f, 2.85533015e-02f, 2.88878623e-02f, 2.70522106e-03f, 2.84130294e-02f, 1.11903936e-01f, -8.17366317e-02f, -9.07940604e-03f, -1.15596883e-01f, 2.55041625e-02f,
  8.57168809e-02f, 1.30900042e-02f, -1.80860236e-02f, 4.89293933e-02f, -4.08887714e-02f, 1.33859202e-01f, -1.03086106e-01f, 6.75263107e-02f, 1.89746246e-02f, 9.63628571e-03f,
  5.74093163e-02f, 4.75720428e-02f, -3.97196272e-03f, -1.11661591e-01f, -1.37157962e-01f, 7.76520073e-02f, -4.79463562e-02f, 1.03165954e-01f, 1.44416615e-01f, -9.18484703e-02f,
  -4.13634330e-02f, 9.04691219e-02f, -1.15633428e-01f, -2.46977955e-02f, 5.31340949e-02f, 1.62797365e-02f, 1.22135319e-01f, -1.37427717e-01f, 1.58586577e-01f, -7.44932294e-02f,
  -2.36275587e-02f, 1.94333016e-03f, -4.52355435e-03f, -1.65517628e-01f, 1.41029388e-01f, 6.86761066e-02f, -1.25123754e-01f, 8.83071199e-02f, 5.82830049e-02f, 1.66791882e-02f,
  -2.92731747e-02f, 1.18270889e-01f, 6.83378875e-02f, -1.08834304e-01f, -5.14353625e-02f, 6.17640056e-02f, -6.87239394e-02f, 8.65781531e-02f, 4.21793722e-02f, -1.88356712e-02f,
  1.29326647e-02f, -2.99552642e-02f, -6.92831958e-03f, 1.86198745e-02f, -6.47361577e-02f, -2.60568094e-02f, -2.81465258e-02f, -5.32744341e-02f, -1.48748429e-02f, 3.31010036e-02f,
  -1.26014322e-01f, -8.23586285e-02f, 4.57527442e-03f, 1.65450294e-03f, -2.87075881e-02f, -2.50066761e-02f, -4.25026529e-02f, 2.09580027e-02f, -7.78075159e-02f, -6.67690635e-02f,
  -5.84737659e-02f, 4.66543920e-02f, 2.77080238e-02f, -1.12032862e-02f, 1.01452537e-01f, -5.16382232e-02f, 4.60885279e-03f, 9.16352309e-03f, -4.59633432e-02f, 1.01005293e-01f,
  4.80878614e-02f, 1.03395976e-01f, -3.60913314e-02f, 9.76041332e-02f, 5.11329509e-02f, 2.45672856e-02f, -7.67322853e-02f, 6.43705130e-02f, 6.14727288e-02f, -1.51259033e-02f,
  -8.80628079e-03f, 1.23603195e-01f, -1.33787869e-02f, 4.18339260e-02f, -1.57530569e-02f, 6.14379570e-02f, -9.13880169e-02f, 1.28078135e-03f, -6.21535294e-02f, 7.07623512e-02f,
  8.08780896e-04f, 4.91969138e-02f, 4.81571928e-02f, 7.42140636e-02f, 1.59527194e-02f, 1.10280758e-03f, 7.39539862e-02f, 1.00551127e-02f, 8.92376974e-02f, 4.83076274e-02f,
  4.46083816e-03f, -5.57740927e-02f, -5.16001247e-02f, 1.62768085e-02f, 5.05167134e-02f, 1.35517910e-01f, 7.66736194e-02f, -1.16640748e-02f, -1.08351149e-01f, 4.69603464e-02f,
  1.64479632e-02f, 1.48276761e-02f, -1.59989987e-02f, 3.70091349e-02f, -3.58711183e-02f, -3.37977037e-02f, 1.50763988e-01f, 5.71582094e-02f, -7.17055276e-02f, -4.33773734e-02f,
  2.67092083e-02f, 9.87282470e-02f, -3.31010148e-02f, -1.43245205e-01f, -1.27851024e-01f, 8.81233662e-02f, -6.02344573e-02f, 9.37449113e-02f, -1.29632741e-01f, -4.06556614e-02f,
  -7.47899562e-02f, -1.95173249e-02f, 1.89847365e-01f, 8.96338075e-02f, 1.30846366e-01f, -1.02092726e-02f, -1.29637852e-01f, 7.13466061e-03f, -7.01275542e-02f, -9.72677916e-02f,
  1.86795130e-01f, 1.58297956e-01f, 3.07303648e-02f, 2.86560832e-03f, -9.75782275e-02f, 1.12639301e-01f, -3.94564979e-02f, -5.28433733e-03f, -8.03256184e-02f, -2.38054231e-01f,
  6.48553297e-02f, 1.90555200e-01f, -8.91543254e-02f, -9.68140364e-03f, 7.22369626e-02f, 5.52416444e-02f, 3.98886651e-02f, -8.88067558e-02f, -1.83254629e-01f, -1.95464015e-01f,
  -2.37826541e-01f, -6.91864779e-03f, 7.11474717e-02f, 1.42027453e-01f, -6.02116995e-02f, -1.18421353e-02f, 8.97318199e-02f, -6.17388636e-02f, -8.74566063e-02f, 6.69581443e-02f,
  4.28314693e-02f, 6.94656149e-02f, -1.06177159e-01f, -1.08412374e-02f, 4.56050746e-02f, 7.46369213e-02f, 6.59638122e-02f, 1.72744282e-02f, -2.22234447e-02f, 7.23497123e-02f,
  1.36635825e-01f, 6.60097227e-02f, -5.90894371e-02f, -4.46702652e-02f, 1.10834520e-02f, 2.28140969e-02f, -1.47265773e-02f, -1.32490452e-02f, -7.27224275e-02f, -6.73313960e-02f,
  -5.03386818e-02f, -1.28949374e-01f, 7.20076263e-02f, -8.46323147e-02f, 2.76190657e-02f, -2.39862856e-02f, 2.90992670e-02f, 1.15947545e-01f, 1.23711854e-01f, -3.72011680e-03f,
  -5.53514957e-02f, -3.67491953e-02f, -2.48520845e-03f, 1.08740255e-01f, 1.73699763e-02f, 4.27633971e-02f, 6.22879006e-02f, -7.30950907e-02f, -8.01228136e-02f, -3.60952020e-02f,
  -1.31481923e-02f, 5.13117434e-03f, 1.36398254e-02f, -1.73010007e-02f, -1.11017466e-01f, -6.83953390e-02f, -4.86941971e-02f, -6.70526400e-02f, 4.78161052e-02f, -5.43428287e-02f,
  2.69058570e-02f, -6.49435744e-02f, 8.27469863e-03f, -8.34574699e-02f, -2.21954994e-02f, 1.47646032e-02f, 3.42775062e-02f, -7.37678558e-02f, -9.47072133e-02f, -1.52733192e-01f,
  1.18509270e-02f, 8.75698216e-03f, 1.09087899e-01f, -8.82179141e-02f, 2.67906021e-02f, -1.41058490e-02f, -8.25007409e-02f, -5.53281642e-02f, 3.73610817e-02f, -1.67370439e-02f,
  2.80874092e-02f, -7.54057541e-02f, -7.32788816e-02f, 7.17390627e-02f, 1.03830680e-01f, 9.37753450e-03f, 4.35926840e-02f, -6.61579485e-04f, 1.17647551e-01f, 7.64955953e-02f,
  -5.64672165e-02f, -5.29053770e-02f, 1.76626425e-02f, -6.90747285e-03f, 1.52140101e-02f, 7.58549944e-02f, -1.82336546e-03f, -5.00795990e-02f, -6.53300658e-02f, -4.68270183e-02f,
  4.40096036e-02f, -3.69831957e-02f, 6.85300380e-02f, 2.33082455e-02f, -1.24589913e-01f, -9.11843777e-02f, 2.73403283e-02f, 3.25938761e-02f, 4.18153144e-02f, 7.50172138e-02f,
  -8.58240128e-02f, -3.91989760e-02f, -3.31350006e-02f, 7.37862661e-02f, -3.07191461e-02f, 5.40199317e-02f, -3.45460922e-02f, -5.15719056e-02f, 4.79110032e-02f, 1.05268145e-02f,
  -8.96946564e-02f, 6.10585213e-02f, -6.09677620e-02f, 9.11282673e-02f, 7.61033595e-02f, 2.02736668e-02f, -7.34721571e-02f, 1.11758998e-02f, -1.12737156e-01f, 4.72467802e-02f,
  -2.16011293e-02f, 4.43691425e-02f, 7.02451915e-02f, -6.53516054e-02f, -4.65301648e-02f, -2.16506515e-02f, 4.72586416e-03f, -5.75854145e-02f, -5.84655218e-02f, -1.07529767e-01f,
  5.97628914e-02f, -4.86233011e-02f, 1.70921497e-02f, 1.40370587e-02f, -1.08352192e-01f, 1.23211496e-01f, -6.23780750e-02f, -1.74243003e-02f, -1.03893075e-02f, -2.15646289e-02f,
  6.58919886e-02f, 3.85243930e-02f, -2.61058956e-02f, 8.08695555e-02f, 1.93420481e-02f, 3.52784544e-02f, 7.58134499e-02f, 8.26769248e-02f, 1.04393631e-01f, -3.83477286e-02f,
  -2.49026064e-02f, -5.92352003e-02f, 6.69025853e-02f, -9.63092130e-03f, 6.86152279e-02f, -4.61039022e-02f, 1.80752575e-02f, -4.77930792e-02f, 5.77166071e-03f, 4.68254015e-02f,
  3.27515788e-02f, -3.08663677e-02f, 2.10520588e-02f, 2.29738280e-02f, 6.74085170e-02f, 5.18583842e-02f, -2.03588381e-02f, 9.04673710e-03f, 2.25024112e-02f, 1.01083033e-01f,
  7.33244270e-02f, 2.20321156e-02f, -3.97542380e-02f, 7.36648217e-02f, 3.76063846e-02f, -7.29073212e-02f, 8.35174844e-02f, -1.94223877e-02f, -4.15698998e-02f, -7.53384233e-02f,
  -3.85504700e-02f, 1.61899757e-02f, -5.99527592e-03f, -1.49818435e-02f, 1.62796210e-02f, -4.21134941e-02f, -6.72861263e-02f, 1.92303229e-02f, 8.97383019e-02f, -1.14224672e-01f,
  1.11981913e-01f, 1.02379188e-01f, 4.70945388e-02f, -4.73038740e-02f, 2.36695390e-02f, 5.02836816e-02f, 8.18364918e-02f, -3.51705775e-02f, -4.87743951e-02f, -6.41232356e-02f,
  -3.46859992e-02f, -1.50341183e-01f, 1.04795195e-01f, 1.58780769e-01f, 1.27985608e-02f, -1.38174385e-01f, 1.95712969e-01f, 7.39189684e-02f, 7.97718316e-02f, 9.89349186e-02f,
  -1.22461813e-02f, 1.89128518e-01f, -1.39488384e-01f, 1.75358713e-01f, 5.09859063e-02f, -2.66289692e-02f, 5.71030611e-03f, 1.00235105e-01f, 7.75697082e-02f, -1.05243325e-01f,
  -4.32499945e-02f, -3.52970771e-02f, -6.74533173e-02f, 4.99523915e-02f, -1.25509083e-01f, -9.44429412e-02f, 1.75783467e-02f, -6.36679828e-02f, 8.64674821e-02f, -8.28057453e-02f,
  -1.59457866e-02f, 9.79404002e-02f, -1.55350387e-01f, -1.39949560e-01f, -2.68274713e-02f, 4.86739650e-02f, -9.94059369e-02f, -6.31605834e-02f, -6.01972453e-03f, 6.86902851e-02f,
  1.19652309e-01f, -6.31394908e-02f, -2.33327989e-02f, 1.10742733e-01f, 2.05381233e-02f, -4.95727174e-02f, -9.21098962e-02f, 1.68794751e-01f, -7.26407394e-02f, 1.49825156e-01f,
  -1.79374933e-01f, -6.73102066e-02f, 2.32156664e-02f, 9.62890610e-02f, -9.40074772e-02f, -1.42053934e-02f, 5.89958504e-02f, 7.32333362e-02f, -8.32283646e-02f, -2.22957171e-02f,
  6.83902204e-02f, -4.27632146e-02f, 2.89248899e-02f, 5.37113883e-02f, 8.08651000e-02f, 2.94852182e-02f, -1.11915030e-01f, 6.09850185e-03f, 6.60597533e-02f, 9.53639522e-02f,
  4.52919304e-02f, -4.06722315e-02f, 1.83082744e-02f, 3.80537212e-02f, 1.84503309e-02f, 4.84382082e-03f, 2.43674684e-02f, -3.01741287e-02f, -7.77363032e-02f, -3.37489247e-02f,
  3.50261927e-02f, 3.65640037e-04f, 1.20922498e-01f, -5.63385710e-02f, 3.82300988e-02f, -1.65135320e-02f, -3.72708179e-02f, -2.84896325e-02f, -2.50518266e-02f, -2.57709268e-02f,
  -6.09199218e-02f, -7.32439533e-02f, 5.46600744e-02f, -6.79450780e-02f, 3.08858813e-03f, -9.26009472e-03f, -1.21529073e-01f, 1.97611451e-02f, -4.42889854e-02f, 5.72786406e-02f,
  -3.35915610e-02f, -3.57575715e-02f, 4.48256955e-02f, -7.54842684e-02f, -3.68609764e-02f, -6.47493750e-02f, -7.18046278e-02f, 3.75315212e-02f, -2.08228528e-02f, 2.24347804e-02f,
  -7.34029487e-02f, -8.90839845e-02f, 4.81973169e-03f, 3.55069153e-02f, -5.39960600e-02f, -6.84652803e-03f, 3.66534404e-02f, -7.48751983e-02f, -6.10972159e-02f, -9.70602855e-02f,
  -2.24852078e-02f, 4.25508134e-02f, 6.30084565e-03f, 2.93106530e-02f, 9.56224129e-02f, -4.17857207e-02f, -6.55173585e-02f, 7.39677101e-02f, -1.27242813e-02f, -4.44377363e-02f,
  -1.79383799e-01f, -1.09298788e-01f, 6.85438290e-02f, -4.24298942e-02f, 9.31098089e-02f, 7.50258565e-02f, 1.05197905e-02f, 1.09862939e-01f, 6.61398843e-02f, 8.87641013e-02f,
  -1.99063383e-02f, 6.54237494e-02f, 9.61390436e-02f, -8.93799886e-02f, 1.11248128e-01f, -3.92926373e-02f, -2.74773836e-01f, 5.23830801e-02f, -8.99484679e-02f, 1.02472551e-01f,
  1.53828532e-01f, -4.06681485e-02f, -1.45453721e-01f, 7.41650686e-02f, -8.33469927e-02f, -9.81568471e-02f, 5.01846112e-02f, -1.45595428e-02f, -3.79132517e-02f, -7.60101080e-02f,
  -4.69488874e-02f, -5.32448925e-02f, 1.15195259e-01f, 1.43298712e-02f, 3.12214326e-02f, -2.53214389e-01f, 1.32052168e-01f, -3.70725170e-02f, 1.72123511e-03f, -7.51738548e-02f,
  -3.03189233e-02f, 1.57811463e-01f, 5.77719770e-02f, 9.08705145e-02f, 1.29273877e-01f, -6.16387427e-02f, -8.29973593e-02f, -3.40497084e-02f, -2.63306797e-02f, 1.19730374e-02f,
  -3.58389542e-02f, -5.63644916e-02f, 3.90441045e-02f, -2.53264559e-03f, -6.73404485e-02f, 1.16498813e-01f, 6.44526780e-02f, -3.43331769e-02f, -3.60045135e-02f, -6.12234976e-03f,
  -1.14372380e-01f, 1.96889285e-02f, -4.54046018e-02f, -6.03546277e-02f, -6.08498938e-02f, 2.99512129e-02f, 9.68943536e-02f, -1.39447562e-02f, 4.34473762e-03f, 7.13597909e-02f,
  -4.82726358e-02f, -9.35525373e-02f, -4.77615781e-02f, -6.41249046e-02f, 5.98437153e-02f, 1.06667951e-01f, 7.05352128e-02f, 9.41137690e-03f, -7.29075596e-02f, 2.72404775e-02f,
  6.83266968e-02f, -7.79637322e-02f, 6.33810982e-02f, 3.02077215e-02f, -1.69604439e-02f, 8.53489488e-02f, -5.08555993e-02f, 1.41807739e-02f, 7.58494660e-02f, -6.20661378e-02f,
  -6.07042313e-02f, -5.16586117e-02f, 1.01558361e-02f, 6.11266904e-02f, 5.19576818e-02f, -6.10447628e-03f, 7.23096430e-02f, 7.68179595e-02f, 4.44772616e-02f, -7.26866489e-03f,
  9.15290117e-02f, -1.06617197e-01f, -7.02563673e-02f, 5.20701148e-02f, 3.54875177e-02f, 5.82688898e-02f, -2.16493718e-02f, 9.35104564e-02f, -2.76520345e-02f, -6.15598783e-02f,
  -1.58864465e-02f, 4.59263809e-02f, -1.86244044e-02f, -8.08124095e-02f, -9.15370807e-02f, 3.75984609e-02f, -3.55613977e-02f, 1.80209486e-03f, 6.87844679e-02f, -4.24444266e-02f,
  2.44161431e-02f, 7.74434283e-02f, -3.90250124e-02f, -2.43225005e-02f, 2.77734306e-02f, 7.98642933e-02f, 2.97384802e-02f, -4.27377485e-02f, 8.13433081e-02f, -4.31411713e-02f,
  1.44432142e-01f, 1.40535906e-01f, -1.15601525e-01f, 4.81354371e-02f, 8.72506946e-02f, -8.55672807e-02f, 7.95293152e-02f, -1.18956063e-02f, 2.35695448e-02f, -1.03491969e-01f,
  -9.28350464e-02f, 2.44726725e-02f, -8.60426649e-02f, 3.35686393e-02f, -9.54893380e-02f, -3.30482535e-02f, -3.58662643e-02f, -3.92056592e-02f, 1.02091189e-02f, -4.43748198e-03f,
  -3.63778472e-02f, 1.26581341e-01f, 2.06339899e-02f, -8.12107995e-02f, 2.56395619e-02f, 3.86774377e-03f, -6.89474344e-02f, 2.17266064e-02f, -1.44549623e-01f, 6.20992146e-02f,
  -9.08410475e-02f, -1.39426552e-02f, -4.65819240e-02f, -5.04785217e-02f, -8.21798220e-02f, 2.21586265e-02f, 6.62779883e-02f, -5.17045287e-03f, -6.46568881e-03f, 8.84847832e-04f,
  1.32018942e-02f, 1.01892166e-01f, -2.75171939e-02f, -1.02589078e-01f, 2.31250040e-02f, 1.65553428e-02f, 4.16230969e-02f, 7.54904598e-02f, 6.40573204e-02f, -1.72005538e-02f,
  4.94677201e-02f, -2.82906052e-02f, -8.35163146e-02f, -2.61186389e-03f, -5.11336587e-02f, -8.55723172e-02f, 1.39728962e-02f, -1.32467210e-01f, -6.61486164e-02f, 1.25347115e-02f,
  3.13956514e-02f, 2.09674072e-02f, 7.73539208e-03f, 3.86194140e-02f, 1.52067346e-02f, -5.49689084e-02f, -2.60602236e-02f, -4.96724732e-02f, 5.25282994e-02f, 8.45020786e-02f,
  4.86128032e-02f, 1.01127774e-01f, 5.92718795e-02f, -6.90849572e-02f, 5.37777208e-02f, -7.11079538e-02f, -4.48801555e-02f, 2.78440826e-02f, 1.32186472e-01f, 1.97802037e-02f,
  3.85513082e-02f, -5.04428186e-02f, 1.74805764e-02f, -9.90918204e-02f, 4.62534986e-02f, 1.06223255e-01f, 8.23213235e-02f, 4.46403027e-02f, 3.42344120e-02f, -1.14827357e-01f,
  3.75569016e-02f, -2.71215178e-02f, -5.85296676e-02f, 5.58640510e-02f, -1.26903616e-02f, -1.95925211e-04f, -5.27793020e-02f, 1.35083066e-03f, 2.03955900e-02f, 9.79008451e-02f,
  9.80508775e-02f, 5.38884327e-02f, -6.66402653e-02f, 2.89031491e-02f, -3.61678600e-02f, 3.18829603e-02f, 2.05051433e-02f, -1.49289332e-02f, -1.05184149e-02f, 2.77361646e-02f,
  -4.89568450e-02f, 5.26080392e-02f, 4.33097333e-02f, -5.74688092e-02f, -1.01254337e-01f, -3.33732516e-02f, 1.14803985e-01f, 6.05031475e-02f, -5.31988293e-02f, 3.46671343e-02f,
  2.98940111e-02f, 8.15401077e-02f, -1.06981046e-01f, -5.64770550e-02f, -4.08127205e-03f, -7.25890622e-02f, 4.51892475e-03f, -6.34195702e-03f, -6.51775599e-02f, -8.67921393e-03f,
  4.32649404e-02f, 4.57960442e-02f, 6.05211928e-02f, 1.22543603e-01f, 1.23882167e-01f, 5.25303232e-03f, -1.10508882e-01f, 4.83210757e-02f, -6.05653673e-02f, -2.33851910e-01f,
  1.46602809e-01f, -1.03370294e-01f, -1.76320374e-01f, -1.91541851e-01f, -7.99023658e-02f, 9.46906880e-02f, -7.13735223e-02f, -7.94366673e-02f, -1.26736760e-02f, 2.75579952e-02f,
  5.18604182e-02f, -1.88306689e-01f, -1.07281461e-01f, -4.42879200e-02f, 4.23078276e-02f, 7.01945797e-02f, -1.70458537e-02f, -1.36827916e-01f, 1.72576532e-01f, 1.21770829e-01f,
  8.75267982e-02f, -2.12114587e-01f, 1.31193493e-02f, 4.93315831e-02f, -1.61820590e-01f, -1.31942816e-02f, 2.10917424e-02f, 1.07706197e-04f, 6.81249797e-02f, 1.58386260e-01f,
  5.74656986e-02f, -4.05645818e-02f, 1.55484406e-02f, 5.97605705e-02f, -1.04912452e-01f, 6.24283291e-02f, 3.46217789e-02f, -4.26720269e-03f, 7.78722540e-02f, 8.97719804e-03f,
  -1.02082439e-01f, -1.14166709e-02f, -1.98799949e-02f, -2.14829184e-02f, -5.36504090e-02f, 6.96026459e-02f, -1.44407712e-02f, 8.43090937e-02f, 6.87336549e-02f, -1.23280093e-01f,
  -9.34034958e-02f, 1.21545032e-01f, 1.00240089e-01f, -5.64992577e-02f, 2.84880283e-03f, 2.77133044e-02f, 8.47302228e-02f, 5.68824969e-02f, 1.04419112e-01f, 4.65910435e-02f,
  -2.98831891e-02f, 1.45343676e-01f, 4.83482741e-02f, 5.17284758e-02f, 4.08041738e-02f, -2.68384274e-02f, -8.79531950e-02f, 5.46820387e-02f, 2.79983301e-02f, -4.77204174e-02f,
  3.81988846e-02f, 7.69693628e-02f, 6.41829222e-02f, 9.18715745e-02f, 8.68461654e-02f, 2.16604080e-02f, -6.37247860e-02f, -5.73400408e-03f, 3.14938426e-02f, 8.14438313e-02f,
  -6.90162182e-02f, -6.24853596e-02f, -2.81949770e-02f, -2.20984370e-02f, 5.80467694e-02f, 3.39530222e-03f, -5.65027222e-02f, 1.08356386e-01f, 7.79858232e-02f, -1.57706454e-01f,
  1.89718567e-02f, -2.65619736e-02f, -9.68725458e-02f, 1.01069972e-01f, 1.29534528e-01f, -2.31809486e-02f, -1.28321946e-01f, 8.73600040e-03f, -7.03838319e-02f, 3.27590555e-02f,
  8.97073150e-02f, 7.23133832e-02f, -2.54149567e-02f, 5.10114431e-02f, 6.45336732e-02f, -4.68413681e-02f, 1.19971074e-01f, 3.10836323e-02f, -1.06880493e-01f, -2.82351542e-02f,
  -1.08162723e-01f, 1.40550166e-01f, -8.69244859e-02f, 5.13252914e-02f, -3.32322018e-03f, -5.23306765e-02f, -1.39794573e-01f, -1.61106765e-01f, 1.86420113e-01f, 9.06309634e-02f,
  -7.57351145e-02f, 1.12222418e-01f, 3.69302183e-02f, 6.33267239e-02f, -1.14095278e-01f, 1.23749293e-01f, -9.21058506e-02f, -1.02058509e-02f, 9.92567390e-02f, 1.26118243e-01f,
  -1.10588282e-01f, -2.39594594e-01f, -1.58354156e-02f, -8.33563432e-02f, 7.64848515e-02f, 2.11408511e-02f, 2.79454365e-02f, -6.18237033e-02f, 4.85677691e-03f, -1.34624809e-01f,
  -1.33796275e-01f, -1.13178663e-01f, 1.13882251e-01f, 3.80845666e-02f, 1.61594123e-01f, -1.40595391e-01f, 2.14585230e-01f, 1.50682017e-01f, 7.28844926e-02f, -3.43316719e-02f,
  1.15719184e-01f, -3.10105830e-03f, 3.79356854e-02f, -1.34261802e-01f, 1.71047658e-01f, 2.01416507e-01f, -5.52214161e-02f, 1.13211423e-02f, 9.26108137e-02f, 1.34679720e-01f,
  -5.66725135e-02f, 1.14429347e-01f, 7.21829617e-03f, -1.58042312e-01f, 1.67375598e-02f, 1.36047704e-02f, 8.32598433e-02f, 1.09792985e-01f, 8.26005451e-03f, 1.31083131e-01f,
  2.56563518e-02f, 3.88072655e-02f, -2.08848957e-02f, 6.78588748e-02f, -3.43128070e-02f, -1.02223516e-01f, -1.23855405e-01f, 6.76332563e-02f, -1.59774229e-01f, 7.81066790e-02f,
  1.37607427e-02f, 6.12713136e-02f, 4.20848690e-02f, -8.45702291e-02f, 9.12767090e-03f, 4.56610583e-02f, -1.76610559e-01f, 5.59778549e-02f, -9.69765037e-02f, -2.48396257e-03f,
  3.20347548e-02f, -1.04395740e-01f, -1.87394731e-02f, -4.89942217e-03f, -1.03176363e-01f, -6.46475926e-02f, 3.49235050e-02f, -3.15916166e-02f, 6.38633668e-02f, -1.28716147e-02f,
  8.19045026e-03f, -5.96883632e-02f, 5.61546162e-02f, 4.99615595e-02f, -3.18355374e-02f, 7.88594186e-02f, -6.03928827e-02f, -7.09967986e-02f, 6.32847548e-02f, 3.81201245e-02f,
  -5.27832508e-02f, 3.40287574e-02f, -1.22056432e-01f, 2.00395696e-02f, -6.74707741e-02f, -6.87535778e-02f, -6.32799044e-02f, -6.01626486e-02f, -3.07050701e-02f, -1.31500838e-02f,
  -1.01408549e-02f, 2.28404924e-02f, -3.95038426e-02f, 1.43453013e-02f, -2.85013337e-02f, 2.37270072e-03f, 2.92918906e-02f, 3.64410169e-02f, -3.78632247e-02f, -4.36028801e-02f,
  1.45930722e-01f, 6.72713667e-02f, 3.43781821e-02f, 3.88802923e-02f, 2.57816911e-02f, 2.36735269e-02f, 7.18368292e-02f, -6.09072298e-02f, 8.75283256e-02f, -3.01392041e-02f,
  -5.40141053e-02f, -1.38477236e-03f, 1.43784165e-01f, 3.02859060e-02f, -1.36412263e-01f, 4.56573330e-02f, 1.17808148e-01f, 1.29273608e-01f, -4.34190594e-02f, -1.37870565e-01f,
  -1.22435845e-01f, 1.22595571e-01f, -2.93638110e-02f, 1.18229412e-01f, -8.05478264e-03f, 1.08575830e-02f, -7.50319585e-02f, 3.73010859e-02f, 1.96365848e-01f, 9.49432666e-04f,
  4.00006212e-02f, -7.40582272e-02f, -1.67771503e-01f, 4.12331559e-02f, -1.93337966e-02f, -1.28612041e-01f, 1.79364637e-01f, 1.17222346e-01f, -1.95968762e-01f, -2.55254004e-02f,
  1.72143169e-02f, 1.66021153e-01f, -3.33857746e-03f, 1.03095854e-02f, -1.26972467e-01f, -2.14470997e-01f, 2.13620529e-01f, 1.82963938e-01f, -2.23947644e-01f, 7.72619545e-02f,
  1.91065744e-02f, -9.80463773e-02f, -4.12772335e-02f, -1.04714297e-01f, -1.02894427e-03f, -1.16949514e-01f, -2.33896524e-01f, 2.54146494e-02f, -8.11327528e-03f, 1.53274179e-01f,
  4.25122562e-04f, 3.43443081e-02f, -8.14063549e-02f, -6.40554726e-02f, -1.21980391e-01f, 1.90387852e-02f, -2.94365883e-02f, 6.81891069e-02f, -8.93424585e-05f, -3.06759179e-02f,
  8.86174738e-02f, 9.88730565e-02f, -1.58823878e-02f, 9.98896081e-03f, 8.08267444e-02f, -1.07900433e-01f, 9.49253887e-02f, 8.24630931e-02f, -3.18568647e-02f, -8.16750824e-02f,
  7.68206418e-02f, 8.82084278e-05f, -4.64393292e-03f, -1.01014130e-01f, -2.57298350e-02f, -7.94334784e-02f, 8.01047459e-02f, -3.03073898e-02f, -6.34231120e-02f, 2.57995576e-02f,
  2.09006760e-02f, 8.93106591e-03f, 1.00366762e-02f, -1.69659518e-02f, 3.72122042e-02f, -3.76418494e-02f, -1.37461564e-02f, 2.98733972e-02f, -9.72937420e-03f, 2.84414012e-02f,
  -9.33758467e-02f, 4.73996922e-02f, -8.43476653e-02f, 1.10315576e-01f, 7.61658549e-02f, 4.28803638e-02f, -6.40868098e-02f, 3.57433595e-02f, -5.05243205e-02f, 8.20577294e-02f,
  1.14724010e-01f, 1.45340357e-02f, 1.04670711e-02f, 6.02072142e-02f, 6.09095842e-02f, -8.57314542e-02f, 5.18976524e-03f, 8.20101202e-02f, -8.00090879e-02f, -5.29062003e-02f,
  1.85006615e-02f, 8.64692330e-02f, -1.16810761e-02f, 7.15301484e-02f, -5.54217808e-02f, 5.73035143e-02f, -8.36409926e-02f, 7.25596473e-02f, -4.69045676e-02f, -5.89487664e-02f,
  -6.93728849e-02f, 6.03582636e-02f, -5.50592802e-02f, 8.13426673e-02f, -4.36335765e-02f, -1.59266386e-02f, -5.91203719e-02f, 4.56699505e-02f, 1.12373158e-02f, -1.00864880e-01f,
  -9.51388329e-02f, 4.84896684e-03f, -4.84209601e-03f, -1.17192820e-01f, 5.54158986e-02f, 2.90133357e-02f, -4.44236435e-02f, 7.86744505e-02f, -3.16700451e-02f, -1.46078076e-02f,
  -7.67139122e-02f, 1.43186703e-01f, -7.47334538e-03f, 1.27836168e-01f, -1.93483604e-03f, -8.06893259e-02f, 6.23563193e-02f, -4.80644852e-02f, 2.15237811e-02f, 1.21705886e-02f,
  1.47144228e-01f, 9.10322741e-02f, 4.50224392e-02f, -1.64472815e-02f, -1.60222962e-01f, -1.34087637e-01f, 1.44996375e-01f, -1.12680495e-01f, -1.17180221e-01f, -1.46982238e-01f,
  7.54282158e-03f, 4.80900854e-02f, 3.80969569e-02f, 1.15068130e-01f, -1.45503491e-01f, -1.17782332e-01f, 7.74560496e-02f, -7.89154246e-02f, 7.18560070e-02f, 7.53883645e-03f,
  5.60049340e-02f, -8.51998776e-02f, 2.63577327e-02f, -1.32021278e-01f, 1.76366791e-01f, -1.29329292e-02f, -2.95447763e-02f, -3.33117619e-02f, 1.70508064e-02f, 6.58836290e-02f,
  1.07164435e-01f, 1.09132349e-01f, 8.39326382e-02f, -8.86158738e-03f, -6.27778992e-02f, -6.43881131e-03f, -1.12856060e-01f, -1.23191939e-03f, -2.01858487e-02f, -9.42617506e-02f,
  1.01218738e-01f, -1.97281726e-02f, 1.04259416e-01f, 7.15666413e-02f, 5.60826361e-02f, -1.07294880e-02f, 9.93732065e-02f, 9.98427421e-02f, -7.28062689e-02f, -7.86490962e-02f,
  -4.08547670e-02f, 8.04333761e-02f, -9.25484896e-02f, 1.33410310e-02f, -7.32874274e-02f, -1.21837601e-01f, -3.27247307e-02f, 1.01656005e-01f, -8.96710604e-02f, -3.05579249e-02f,
  8.37296993e-02f, -5.52365668e-02f, 3.45772356e-02f, -2.61336695e-02f, -1.90040481e-03f, -1.04417332e-01f, 5.76422215e-02f, -6.06732331e-02f, -4.94113527e-02f, 6.79795211e-03f,
  1.53757934e-03f, 6.45617545e-02f, 6.29087836e-02f, 1.02065243e-01f, 2.30459496e-02f, 7.42241070e-02f, 2.82188728e-02f, -1.30891921e-02f, 5.38381934e-02f, 1.37350693e-01f,
  2.43060812e-02f, 5.01643531e-02f, 3.19235623e-02f, 2.77615935e-02f, 1.28305420e-01f, 2.72682402e-02f, 8.05894434e-02f, 6.08194284e-02f, 3.36628244e-03f, 1.73955187e-02f,
  1.08317949e-01f, 3.64015400e-02f, -5.23145609e-02f, 6.65762834e-03f, 7.69171864e-02f, 4.65365686e-02f, -4.72829714e-02f, 5.85205201e-03f, 2.51150504e-02f, 8.91054869e-02f,
  1.23440139e-01f, -5.64715005e-02f, -4.71950918e-02f, 6.51531247e-03f, -7.41036981e-02f, -6.05066270e-02f, 6.65158965e-03f, -7.46262865e-03f, -1.62709951e-01f, -1.35041680e-02f,
  -2.75751445e-02f, -3.15739363e-02f, 1.55108631e-01f, -3.12734470e-02f, -5.99252097e-02f, 1.66489333e-01f, 1.49965286e-01f, 1.26801983e-01f, -1.85858831e-03f, -4.34788177e-04f,
  1.50282368e-01f, -1.49528354e-01f, 4.27958928e-03f, -7.78210536e-02f, -1.44385934e-01f, -7.84027278e-02f, -1.60724789e-01f, -1.11283191e-01f, -4.82892394e-02f, 1.61266148e-01f,
  -1.28701568e-01f, 9.22537670e-02f, 1.53515358e-02f, -2.25612391e-02f, -3.42999585e-02f, -7.19875023e-02f, -1.07024655e-01f, -5.96901700e-02f, -1.05081014e-01f, -5.23213483e-02f,
  -3.54349986e-02f, 1.51656449e-01f, -3.80260572e-02f, -1.79597721e-01f, -7.90114775e-02f, 9.43207517e-02f, -3.41293328e-02f, -1.52850896e-01f, 2.25607585e-02f, 2.16552019e-01f,
  2.15269968e-01f, 1.63517579e-01f, 6.57813102e-02f, -4.24849242e-02f, -1.06639028e-01f, -4.85635456e-03f, -5.21928258e-02f, -4.73262817e-02f, -1.78775880e-02f, 5.74872978e-02f,
  2.18191668e-02f, 1.87574830e-02f, -6.61163852e-02f, -6.86343573e-03f, 1.34801552e-01f, 1.98329557e-02f, 3.38185020e-02f, 4.74512354e-02f, -1.24993354e-01f, -1.02385253e-01f,
  4.29428229e-03f, -6.86239824e-02f, 1.49451860e-03f, 1.02782540e-01f, -3.40798236e-02f, -1.84197128e-02f, 9.27835703e-02f, 8.45190734e-02f, -2.74965968e-02f, 2.25659665e-02f,
  6.13123775e-02f, -5.66735081e-02f, -5.01843542e-02f, -3.30971777e-02f, -7.59768765e-03f, 3.67124416e-02f, 5.99376531e-03f, 7.45742694e-02f, -1.24923386e-01f, -4.78109829e-02f,
  -9.84185264e-02f, -3.67272012e-02f, -4.12821509e-02f, -5.15422039e-02f, 1.94359906e-02f, 2.14539040e-02f, -1.00041188e-01f, -3.59316655e-02f, -7.06327707e-02f, -4.27697413e-03f,
  4.50178310e-02f, -3.23755038e-03f, -7.32234269e-02f, 4.26784670e-03f, -1.18071428e-02f, -7.55303130e-02f, -2.76015364e-02f, 1.34137715e-03f, -7.36249005e-03f, -8.83606374e-02f,
  6.53907135e-02f, -4.98675443e-02f, -1.00379243e-01f, -1.59503184e-02f, -3.82039743e-03f, 5.77090948e-04f, -4.64825407e-02f, 1.17854737e-01f, -1.95668973e-02f, 2.39503421e-02f,
  5.22117354e-02f, 1.14061823e-02f, -4.84131277e-02f, 3.32959881e-03f, 5.69513515e-02f, 7.09710196e-02f, 5.40038347e-02f, -1.00133881e-01f, -8.90049487e-02f, 9.75243822e-02f,
  -1.18103608e-01f, -1.61753278e-02f, -5.01080006e-02f, -7.22183064e-02f, -4.25482839e-02f, -4.37315293e-02f, 1.65820301e-01f, 1.75233960e-01f, -2.47792136e-02f, 2.04270873e-02f,
  8.29115808e-02f, -2.20794436e-02f, -1.18128732e-02f, -8.12246501e-02f, -2.69674882e-02f, -8.22901651e-02f, -8.34916905e-02f, 1.04027689e-01f, -1.27464324e-01f, 7.01947883e-02f,
  9.45143104e-02f, 1.28931729e-02f, 6.37565702e-02f, -1.37866456e-02f, 1.61835581e-01f, -1.49139047e-01f, -1.22858979e-01f, -5.08439764e-02f, -9.83563215e-02f, -1.85367584e-01f,
  1.16540402e-01f, 1.37973367e-03f, 9.57324207e-02f, -5.84293827e-02f, -1.00332499e-01f, 6.47214353e-02f, 4.04966474e-02f, 9.47740301e-02f, -1.83476955e-02f, -1.64692685e-01f,
  -6.77577257e-02f, 1.96480662e-01f, 6.45060912e-02f, -1.26890272e-01f, 6.02127239e-02f, 1.07250527e-01f, -1.59250665e-02f, -2.17227072e-01f, -2.30533540e-01f, -1.15004472e-01f,
  -1.65593550e-01f, 6.70874193e-02f, -5.55916410e-03f, 1.02185972e-01f, -3.25759873e-02f, 6.15062043e-02f, 5.31562492e-02f, 5.58136664e-02f, -8.65653828e-02f, -6.18947670e-03f,
  7.49396235e-02f, 6.38457835e-02f, -1.20049492e-01f, -3.39295603e-02f, -8.01371876e-03f, -5.19167855e-02f, -4.50663175e-03f, 3.38320807e-02f, 1.29870489e-01f, 7.49818608e-02f,
  5.16622104e-02f, 3.50962207e-02f, 6.21147417e-02f, 6.18929714e-02f, 1.01579186e-02f, -9.99537762e-03f, -9.99368131e-02f, -1.06219994e-02f, -3.66873704e-02f, 8.75288770e-02f,
  -9.37094614e-02f, -1.60546184e-01f, 8.82386044e-02f, -7.96930790e-02f, 3.41861174e-02f, -4.26706709e-02f, -9.40160453e-02f, 6.62064180e-02f, 1.10336274e-01f, 6.22314354e-03f,
  1.16181120e-01f, -6.29418483e-03f, 3.37956585e-02f, 4.56127487e-02f, -2.65167910e-03f, 5.34215309e-02f, 1.82587206e-02f, 2.55162958e-02f, 5.58189303e-03f, 3.44046503e-02f,
  1.54445171e-02f, 6.86462736e-03f, -8.40172768e-02f, 6.01684041e-02f, 1.10780820e-01f, -7.74829835e-02f, -1.09206222e-01f, 2.96329800e-02f, 6.60590306e-02f, -9.32519138e-02f,
  -1.42860383e-01f, -5.58815934e-02f, 7.60790259e-02f, -1.36640957e-02f, 5.82348667e-02f, 1.37228966e-01f, -3.88774052e-02f, 3.90208550e-02f, -7.98250921e-03f, -5.39498636e-03f,
  8.29335824e-02f, -8.83495510e-02f, -1.69509649e-02f, 4.92346995e-02f, 2.65798401e-02f, -1.05077284e-03f, -1.30512521e-01f, 1.09791353e-01f, -6.21441379e-03f, 8.20730254e-03f,
  -4.71158102e-02f, 8.58607888e-02f, 3.22096869e-02f, -3.09795104e-02f, 1.89182743e-01f, 9.49650332e-02f, -9.95303765e-02f, -7.67522454e-02f, 2.97539905e-02f, 3.47236879e-02f,
  -3.66480723e-02f, -2.07316265e-01f, 6.84380531e-02f, 5.99532351e-02f, -1.33764073e-01f, 9.55600739e-02f, 3.37740639e-03f, 1.11185819e-01f, 3.45641449e-02f, 7.87055492e-02f,
  1.49435863e-01f, 5.44908457e-02f, 1.65582910e-01f, -1.84543937e-01f, 1.85844004e-02f, 7.30185360e-02f, -8.76210555e-02f, -2.19137877e-01f, 1.09893963e-01f, 1.54811472e-01f,
  5.31684496e-02f, -6.46242052e-02f, -5.05243391e-02f, 1.30664408e-01f, 2.69014146e-02f, -7.62897059e-02f, -9.38148797e-02f, -1.33160278e-01f, 3.10187489e-02f, 2.06444621e-01f,
  1.87081117e-02f, -1.62399814e-01f, 1.43800406e-02f, 1.47617627e-02f, 4.37119789e-02f, -6.25574738e-02f, -5.67318574e-02f, -1.45626545e-01f, -2.02688277e-01f, 1.36542946e-01f,
  5.34162521e-02f, 9.85345840e-02f, -1.30578667e-01f, 4.34773341e-02f, 2.02107038e-02f, 6.44666329e-02f, 2.04825625e-02f, 2.61746943e-02f, 3.25778052e-02f, 5.54946885e-02f,
  5.89952134e-02f, -1.07905604e-02f, 3.81095000e-02f, 1.86760705e-02f, 6.11892268e-02f, -2.14102175e-02f, 2.47448534e-02f, 8.69629309e-02f, 1.72260236e-02f, -2.04866156e-02f,
  -2.17882264e-02f, -1.29399179e-02f, 4.57383282e-02f, -3.87346298e-02f, 1.98305603e-02f, 1.02271438e-01f, -2.74772942e-02f, 6.34522066e-02f, -4.08547074e-02f, -1.07195929e-01f,
  1.75214726e-02f, -6.13023974e-02f, -9.86497253e-02f, -5.14430217e-02f, 8.09604600e-02f, 3.30407433e-02f, -4.84017469e-02f, -1.26780719e-01f, -6.18344285e-02f, 5.73787466e-03f,
  -8.74530524e-03f, -4.37383316e-02f, -7.27460310e-02f, 3.23884655e-03f, -8.20134580e-02f, 5.85606620e-02f, 1.63514279e-02f, 2.90212892e-02f, -1.38287425e-01f, -1.13431383e-02f,
  -7.68874213e-02f, -5.19982837e-02f, 2.68349014e-02f, -3.22309881e-02f, 8.48332122e-02f, -4.87924367e-03f, 6.93146586e-02f, -6.01754487e-02f, -9.74848047e-02f, -9.58316997e-02f,
  1.77654121e-02f, 1.00097202e-01f, 5.26573323e-02f, -8.36896943e-05f, -9.42991599e-02f, -5.80675080e-02f, -2.04949323e-02f, 1.38017699e-01f, -5.56389242e-02f, 6.03211857e-02f,
  -1.18999153e-01f, 5.61471917e-02f, -2.39763986e-02f, -4.25197072e-02f, 1.16164535e-01f, -1.56928897e-02f, 2.49568038e-02f, 6.89430386e-02f, 6.12485223e-02f, 3.38845626e-02f,
  -3.63335037e-03f, 4.33013700e-02f, -3.84997837e-02f, -5.79867698e-03f, 2.42364183e-02f, -2.35362984e-02f, 1.20398831e-02f, -9.57263168e-03f, 5.46309836e-02f, 1.64739400e-01f,
  4.76555452e-02f, 1.05076417e-01f, -1.48208186e-01f, 1.04820251e-01f, 6.75214455e-02f, -9.50212702e-02f, 1.16640627e-01f, 2.20904313e-02f, -1.65642053e-01f, -1.50189996e-01f,
  -6.09488748e-02f, 1.25829548e-01f, 1.03416540e-01f, 9.16113779e-02f, -9.59937498e-02f, 6.69872910e-02f, -1.19204909e-01f, -6.27818629e-02f, 7.24021047e-02f, -1.21022217e-01f,
  -4.34120884e-03f, -1.15625896e-01f, 1.35675386e-01f, -1.03182465e-01f, 1.60962760e-01f, 2.66329069e-02f, -3.86832878e-02f, -4.62870598e-02f, 7.06121624e-02f, -9.82268248e-03f,
  -9.30641219e-02f, -6.90011308e-02f, 1.85434353e-02f, 1.11690741e-02f, 1.80113707e-02f, 7.18047991e-02f, 1.08923115e-01f, 2.09381524e-02f, -9.28770378e-02f, -3.73688415e-02f,
  7.81244189e-02f, 3.16962451e-02f, -9.19005368e-03f, 3.21930647e-02f, -2.11740546e-02f, 7.10090771e-02f, -3.17233726e-02f, 1.24143802e-01f, -5.56824543e-02f, 3.89765240e-02f,
  -6.07867688e-02f, -3.44176404e-02f, 7.43939579e-02f, -1.50376976e-01f, 1.87822077e-02f, 8.38168897e-03f, -5.73219769e-02f, -4.88411784e-02f, 2.86004543e-02f, -9.09543335e-02f,
  -1.18161239e-01f, -9.25856978e-02f, -2.38578604e-03f, -5.64631522e-02f, -9.66261253e-02f, -8.52078758e-03f, -1.60240177e-02f, 8.63142908e-02f, -1.78144500e-02f, -5.76621033e-02f,
  -9.68818665e-02f, 1.03121959e-01f, 6.56249672e-02f, 7.83599075e-03f, -7.75586590e-02f, 9.66821983e-02f, -6.31077513e-02f, -4.90554050e-02f, 8.63852501e-02f, -9.64724123e-02f,
  -2.06431262e-02f, 2.32756995e-02f, -9.11734924e-02f, -1.00227386e-01f, 3.55088823e-02f, 6.09032661e-02f, -1.00051098e-01f, 3.02695241e-02f, 5.51703759e-03f, -7.46233761e-02f,
  -1.68264747e-01f, 6.89645633e-02f, -6.31106868e-02f, -1.05969012e-01f, -5.52022755e-02f, 4.67143059e-02f, 2.57297959e-02f, -5.40581755e-02f, 6.47207117e-03f, -7.31130168e-02f,
  -1.51535138e-01f, -5.77019565e-02f, 1.59162935e-02f, -4.11024094e-02f, 1.96371749e-02f, 4.82777413e-03f, -1.15678608e-01f, 1.73546262e-02f, -2.50928663e-02f, -1.00776859e-01f,
  -2.42804177e-02f, 2.12679524e-02f, 3.99234742e-02f, 5.44537045e-02f, -7.70738274e-02f, -1.05050892e-01f, -6.56740442e-02f, -2.37232938e-01f, -8.07975605e-02f, -6.64942563e-02f,
  9.51505676e-02f, -1.97235569e-02f, 9.91547406e-02f, 2.06984449e-02f, 1.15591839e-01f, 1.08914368e-01f, 1.61124855e-01f, 1.94152892e-01f, -8.78176540e-02f, -4.29405309e-02f,
  5.21440133e-02f, 6.15815260e-02f, 4.85554943e-03f, -1.11247525e-01f, 1.12293810e-01f, -4.76559326e-02f, -1.96399856e-02f, -1.13462150e-01f, 2.08364017e-02f, 8.68791062e-03f,
  -1.74972698e-01f, -1.84805878e-02f, -1.03639193e-01f, 3.31337862e-02f, -5.64644160e-03f, -1.58927336e-01f, -7.61052966e-02f, 7.63478205e-02f, -2.67346203e-02f, 2.31219791e-02f,
  -1.29406899e-01f, -5.78842834e-02f, 7.68493414e-02f, 3.88877690e-02f, -1.22489352e-02f, -6.33192584e-02f, -1.53186634e-01f, 8.81529078e-02f, 3.16340476e-02f, 3.15246284e-02f,
  1.08025670e-01f, -7.75877163e-02f, -2.30180379e-02f, 6.32267371e-02f, -1.60427596e-02f, 5.94798429e-03f, -5.32070082e-03f, 6.43979153e-03f, 1.42626064e-02f, 3.26271057e-02f,
  6.89180344e-02f, 7.80838057e-02f, -7.51725212e-02f, -3.26572917e-02f, -6.69937814e-03f, -6.15599230e-02f, 4.24824767e-02f, -1.49072343e-02f, 1.16855375e-01f, -2.97558866e-02f,
  -9.80730504e-02f, -1.91973876e-02f, 1.90715671e-01f, 4.96609621e-02f, 3.16927396e-02f, -8.93335566e-02f, 5.96884191e-02f, -2.49537975e-02f, -7.66726360e-02f, 3.23356800e-02f,
  9.64353010e-02f, -5.54083362e-02f, 7.94515759e-02f, -1.33776236e-02f, 8.39903876e-02f, 1.22829370e-01f, 2.63989232e-02f, 5.81247769e-02f, 9.67598800e-03f, 1.66707486e-02f,
  -7.12035820e-02f, -7.67027363e-02f, -3.61995324e-02f, -2.19722968e-02f, -4.23668511e-02f, -1.88346710e-02f, -3.44390795e-02f, -7.21362978e-02f, 6.98479414e-02f, 1.44010559e-02f,
  2.32009124e-02f, 5.96630201e-02f, -7.00483248e-02f, 1.95662342e-02f, 9.33260322e-02f, -2.88776890e-03f, 7.36268833e-02f, 6.70159981e-02f, 1.02000954e-02f, -2.12698672e-02f,
  -2.86692753e-02f, 5.40580377e-02f, 2.85918545e-02f, 1.10206850e-01f, 7.31724203e-02f, 6.50128275e-02f, -2.00481042e-02f, 7.90824145e-02f, 4.58744727e-02f, -8.33690539e-02f,
  3.80476527e-02f, 1.16724437e-02f, -1.58807375e-02f, 3.97875197e-02f, -3.05384658e-02f, -4.24361788e-02f, 3.28763388e-02f, 4.82824109e-02f, -9.82840955e-02f, 8.42071846e-02f,
  -6.93652406e-03f, 1.98113695e-02f, -4.82853726e-02f, -3.02302688e-02f, -3.60154896e-03f, 2.03663874e-02f, -4.65601422e-02f, -9.63499304e-03f, 1.39497310e-01f, -2.14369353e-02f,
  6.28812658e-03f, 1.78707093e-01f, -1.51032820e-01f, -1.70517296e-01f, 4.20075729e-02f, -1.79160073e-01f, 1.45210087e-01f, -1.29471451e-01f, 6.87902793e-02f, -2.13975579e-01f,
  -1.38770893e-01f, 1.31310537e-01f, -8.94259289e-03f, -9.09268260e-02f, 1.66865155e-01f, 9.06882882e-02f, 6.16157874e-02f, -3.08213569e-02f, 4.09234427e-02f, -7.39338920e-02f,
  1.20106578e-01f, 2.16733981e-02f, -8.19683596e-02f, 2.21448559e-02f, -2.74307393e-02f, 1.33170217e-01f, 4.73998636e-02f, 1.12373568e-01f, 7.45014921e-02f, 2.89231390e-01f,
  -1.42831001e-02f, 2.26557683e-02f, 1.03980340e-01f, 8.37614909e-02f, 1.26517579e-01f, -9.63242948e-02f, 4.23070267e-02f, 1.40464842e-01f, 6.06216043e-02f, -1.10367127e-01f,
  -3.80277745e-02f, -7.63844699e-02f, -8.23301747e-02f, -1.12403691e-01f, 1.61876217e-01f, -8.38402286e-02f, 1.55181676e-01f, 1.56399813e-02f, -4.29853871e-02f, 2.52273418e-02f,
  5.48039563e-02f, 2.37479508e-02f, 1.23803448e-02f, -5.38378321e-02f, -2.46887468e-02f, 6.95480481e-02f, -6.77296147e-02f, 1.81807250e-01f, 1.19906105e-01f, 6.91550002e-02f,
  -1.40025750e-01f, 9.00032446e-02f, 6.70674816e-03f, -6.09579943e-02f, -1.17921636e-01f, -2.86198016e-02f, 5.23203537e-02f, 5.30938655e-02f, -8.63845795e-02f, -3.08131762e-02f,
  3.55573446e-02f, 4.33872603e-02f, 1.54641457e-02f, -8.52089822e-02f, 4.25965711e-02f, 7.69544840e-02f, -4.25506309e-02f, -6.66740164e-02f, -1.11967906e-01f, -1.08440258e-01f,
  -1.08082458e-01f, -6.07141368e-02f, 4.62328009e-02f, 1.07776947e-01f, -6.96509257e-02f, -1.27657831e-01f, -6.89762384e-02f, 8.17586016e-03f, 1.56011386e-02f, 2.77105551e-02f,
  -2.85432227e-02f, 8.76924023e-02f, -1.06282860e-01f, 1.51778897e-02f, -4.26175036e-02f, -2.39799172e-02f, 1.24237016e-01f, -3.24818236e-03f, -3.63920107e-02f, 3.44591141e-02f,
  4.59157713e-02f, -1.73278470e-02f, -9.58925020e-03f, -6.80079907e-02f, 6.04932494e-02f, 8.57141390e-02f, -6.71706209e-03f, 4.06439707e-04f, 1.30008785e-02f, -2.18868279e-03f,
  5.70517825e-03f, 9.54425111e-02f, -2.97181355e-03f, 5.46596982e-02f, 6.93421960e-02f, 1.28404483e-01f, -1.07277436e-02f, 5.55010140e-02f, 1.70879401e-02f, -5.02289161e-02f,
  4.43263687e-02f, 4.09890860e-02f, -4.21449989e-02f, 6.59618303e-02f, 4.51029744e-03f, -1.13659769e-01f, -1.51492120e-03f, 3.67072001e-02f, 9.52824280e-02f, -6.82748705e-02f,
  1.48053542e-02f, 1.42578080e-01f, 1.77126732e-02f, 7.43645281e-02f, -1.88488230e-01f, 1.28148541e-01f, -1.35851637e-01f, 1.46843538e-01f, -3.59374359e-02f, -9.81362015e-02f,
  -4.50779274e-02f, 1.04261599e-01f, 5.29722869e-03f, -4.59043570e-02f, 1.56624779e-01f, 3.48038115e-02f, -1.44092962e-02f, 6.61580414e-02f, -1.41955223e-02f, -3.89634632e-02f,
  -6.17006198e-02f, -1.31323367e-01f, 7.46034235e-02f, -8.82874131e-02f, -6.46922886e-02f, -1.38241082e-01f, 2.93754432e-02f, -1.80790991e-01f, 1.04037784e-01f, 3.62299196e-02f,
  -7.17848986e-02f, -6.64850175e-02f, -3.89971994e-02f, 8.82407278e-02f, 1.51444942e-01f, 9.62191224e-02f, 6.19906187e-02f, -9.86452624e-02f, 4.12403867e-02f, -1.94233268e-01f,
  9.29132570e-03f, 2.01394349e-01f, -2.52474076e-03f, 1.16519935e-01f, -1.44458726e-01f, 1.28486902e-01f, 3.72375809e-02f, -2.22425703e-02f, -6.06767349e-02f, -3.54341492e-02f,
  4.29873355e-02f, 2.55857240e-02f, -7.89116509e-03f, -6.41959980e-02f, 2.12478382e-03f, -8.23204890e-02f, 2.08458938e-02f, -6.99197426e-02f, 2.44268682e-02f, -7.54661020e-03f,
  -6.50299639e-02f, -2.52063982e-02f, -2.56497283e-02f, 6.12972900e-02f, 8.64836574e-03f, 8.19830298e-02f, 1.36907771e-02f, 9.35764089e-02f, -8.10302645e-02f, -2.09153839e-03f,
  -1.46489544e-02f, -9.00681317e-02f, -7.57398531e-02f, -3.44934165e-02f, -1.58852153e-02f, -2.60240529e-02f, 6.61550221e-05f, 3.99634205e-02f, -7.80347884e-02f, 1.33929420e-02f,
  -1.07225046e-01f, -7.88319334e-02f, 1.29450031e-03f, -4.19265255e-02f, -3.20852660e-02f, -7.63856843e-02f, -8.12683702e-02f, 6.98408531e-03f, -4.12793532e-02f, 5.41342460e-02f,
  -1.54130965e-01f, -4.94706742e-02f, 1.08292028e-01f, 4.93468577e-03f, 3.25388071e-04f, -5.39210141e-02f, -6.93150163e-02f, -6.02019317e-02f, 4.75905426e-02f, -5.47266863e-02f,
  -2.77760602e-03f, 2.27263081e-03f, 1.22618442e-02f, -9.12396684e-02f, 4.53597270e-02f, 5.03647812e-02f, -3.95410620e-02f, 7.83055369e-03f, 6.91484809e-02f, -1.10766413e-02f,
  -9.30217057e-02f, -7.26397410e-02f, -9.45030078e-02f, -1.09720286e-02f, -4.04035076e-02f, 4.09721062e-02f, -7.05621317e-02f, 8.98872316e-02f, -7.43912831e-02f, 8.44593719e-03f,
  -9.28625688e-02f, -1.06554255e-01f, 4.53863367e-02f, 5.39702959e-02f, 7.83779472e-02f, 2.36659497e-02f, -7.28245750e-02f, 6.92432225e-02f, -9.88005102e-03f, -6.67819008e-02f,
  9.92086306e-02f, -1.55998496e-02f, -2.47815121e-02f, -5.47485538e-02f, -4.39559706e-02f, -9.13307369e-02f, -6.64072707e-02f, -7.57501423e-02f, 4.70215976e-02f, 2.22284701e-02f,
  -1.36589274e-01f, 4.26483229e-02f, -4.88125198e-02f, 7.10196942e-02f, -6.99797496e-02f, -1.59404859e-01f, -5.17961718e-02f, -4.95901033e-02f, -5.49035259e-02f, -6.57827407e-02f,
  -6.76548854e-02f, 5.16970940e-02f, 9.95125696e-02f, 1.10084422e-01f, 1.13380760e-01f, -1.55052142e-02f, 3.47216688e-02f, -1.18101850e-01f, 1.12186268e-01f, -8.40722099e-02f,
  3.01887784e-02f, 9.72586721e-02f, -7.23199919e-02f, 4.19444367e-02f, 9.20867920e-02f, -3.14562805e-02f, -1.37859255e-01f, 7.46431127e-02f, -5.71812950e-02f, -1.13186635e-01f,
  2.57922392e-02f, 7.40682557e-02f, 4.43965048e-02f, -8.79363902e-03f, 8.35373923e-02f, -5.29839620e-02f, -5.11055514e-02f, 1.19874962e-02f, -3.82874794e-02f, -5.09148017e-02f,
  1.04255944e-01f, -7.45532289e-02f, -2.31443886e-02f, 1.05591699e-01f, -2.88239270e-02f, 4.26769145e-02f, 9.65555012e-02f, 4.19818461e-02f, 5.36138490e-02f, 4.35150303e-02f,
  7.77438954e-02f, -9.95089859e-02f, -9.88231450e-02f, 2.04071868e-02f, 3.21852937e-02f, 3.31634171e-02f, -4.74859849e-02f, -4.83401492e-03f, 5.21168448e-02f, 7.90584609e-02f,
  -7.93130547e-02f, 8.92092586e-02f, -5.38981147e-02f, -3.76582816e-02f, -2.83229612e-02f, 4.78206091e-02f, -9.40195285e-03f, -6.53376058e-02f, 8.80615562e-02f, 1.10654505e-02f,
  1.04565300e-01f, 3.45760630e-03f, 4.06814516e-02f, 7.23389834e-02f, -6.76960796e-02f, -7.03466758e-02f, 2.97888722e-02f, -5.74912410e-03f, -4.18579951e-03f, -3.52892615e-02f,
  -1.29647646e-02f, -2.84136534e-02f, 8.11247602e-02f, -4.38632108e-02f, -5.11280820e-02f, 1.91806983e-02f, 4.57280017e-02f, -9.77467597e-02f, -8.60334784e-02f, 2.22238638e-02f,
  5.70066385e-02f, 3.72453369e-02f, 2.53489520e-02f, -5.26778307e-03f, -5.13869822e-02f, 6.06534593e-02f, -1.15061831e-02f, 7.08340779e-02f, 1.26039594e-01f, -7.05708638e-02f,
  1.10262692e-01f, -3.25485459e-03f, 6.50316104e-02f, -1.28194364e-02f, -1.02497078e-01f, 5.97578660e-02f, 3.35034169e-02f, 8.34405199e-02f, -4.45158854e-02f, 1.08031686e-02f,
  -9.02376994e-02f, -2.63103247e-02f, 7.60561526e-02f, 6.10454194e-02f, -1.33189857e-01f, -3.51056717e-02f, 4.06223862e-03f, 1.07850678e-01f, -1.09757394e-01f, -5.74879982e-02f,
  6.23000599e-02f, 1.59401521e-02f, -1.08347803e-01f, 1.41106546e-01f, 4.30344418e-02f, 1.15355356e-02f, 1.28024429e-01f, 7.64322206e-02f, 4.21207910e-03f, 2.17904020e-02f,
  -3.84077393e-02f, -1.67524382e-01f, 7.17734694e-02f, 6.12095185e-02f, -1.04527630e-01f, -5.07855639e-02f, -7.19882175e-02f, -7.42340684e-02f, 1.14477821e-01f, -1.41537756e-01f,
  -1.35289924e-03f, -2.62773652e-02f, 8.73476733e-03f, -2.12381743e-02f, 6.09531906e-03f, 5.41874543e-02f, -6.43486828e-02f, 9.45120007e-02f, 6.14720657e-02f, -1.17470376e-01f,
  -2.82886028e-02f, 1.48382261e-02f, 1.28844947e-01f, 6.46901578e-02f, -9.23811048e-02f, 2.10750173e-03f, 1.19766541e-01f, 1.89625993e-02f, 4.84653264e-02f, 3.43835168e-02f,
  -1.17175512e-01f, -1.19224846e-01f, 8.51073861e-03f, -8.11270252e-02f, 6.17951415e-02f, 1.22590642e-02f, 1.01910485e-02f, 8.26627687e-02f, -8.85271505e-02f, 3.79667506e-02f,
  -1.59873441e-02f, -7.46713579e-02f, 5.16005047e-02f, -8.57202522e-03f, -1.33733507e-02f, 4.18279879e-02f, 3.71849909e-02f, -2.19450891e-02f, 1.29959779e-02f, 1.92816015e-02f,
  1.18506784e-02f, -2.65944656e-02f, -1.19204506e-01f, 6.35983124e-02f, -4.70797345e-02f, -1.42181590e-02f, 3.27438340e-02f, -1.80142056e-02f, -2.85579395e-02f, -2.03426369e-02f,
  -5.06672077e-02f, -4.65033650e-02f, 5.69211058e-02f, 9.54399705e-02f, -5.30667417e-02f, 5.74475862e-02f, 7.96154328e-03f, 7.04479590e-02f, 6.79141954e-02f, 5.83163798e-02f,
  6.94232658e-02f, 9.44520521e-04f, 4.50012162e-02f, -1.00755446e-01f, -1.87953319e-02f, 8.97549987e-02f, 7.02576637e-02f, 5.89637496e-02f, -6.63036108e-02f, 5.00635095e-02f,
  9.69062224e-02f, -2.86499616e-02f, 5.16902208e-02f, 1.96077283e-02f, -3.34990583e-02f, 2.46905163e-02f, -3.99221666e-02f, -8.98814294e-03f, -9.82792452e-02f, 6.85906336e-02f,
  4.69601229e-02f, 1.21540666e-01f, 8.49126130e-02f, 8.16832632e-02f, 1.10154442e-01f, -4.89654159e-03f, 7.27353916e-02f, 6.16638213e-02f, 2.83331275e-02f, -6.82264641e-02f,
  3.35479411e-03f, -5.39946631e-02f, -1.40689373e-01f, -3.64186764e-02f, -6.11671582e-02f, 5.03774732e-02f, -5.77783808e-02f, 1.67999834e-01f, -3.28970067e-02f, 1.62236933e-02f,
  1.07032061e-01f, 9.54056755e-02f, -3.81335318e-02f, 1.29664009e-02f, 4.79258522e-02f, 8.32165852e-02f, 7.69116879e-02f, 1.58891901e-02f, -1.24842949e-01f, 1.77255601e-01f,
  -1.78082455e-02f, 1.33509576e-01f, 2.37607025e-02f, -9.51802060e-02f, 8.48121494e-02f, -8.94211531e-02f, -4.91552278e-02f, -7.96524715e-03f, -1.88072014e-03f, -5.14448062e-02f,
  -6.13567121e-02f, -8.64449814e-02f, -1.22628778e-01f, -2.01522842e-01f, -1.63750406e-02f, -2.55482383e-02f, 7.58158881e-03f, -6.13752306e-02f, 2.15331707e-02f, 1.32686228e-01f,
  -1.21605592e-02f, -7.58897811e-02f, 8.74981284e-02f, -1.77134529e-01f, -2.69613732e-02f, -3.65512371e-02f, 7.01437220e-02f, 6.39668107e-02f, -1.34820595e-01f, 5.32607473e-02f,
  4.50271256e-02f, 2.78916508e-02f, -1.68547362e-01f, 2.92796493e-02f, -5.95016293e-02f, 1.11901753e-01f, 5.92520554e-03f, 1.24335311e-01f, -1.16553232e-01f, 1.65734321e-01f,
  1.04080312e-01f, 8.63303244e-02f, 3.39802913e-02f, 2.23566638e-03f, 5.34459502e-02f, 6.42801225e-02f, -3.27330008e-02f, -2.07655691e-02f, 1.87531449e-02f, -1.08161695e-01f,
  3.17419483e-03f, 7.58928806e-02f, -4.70898859e-02f, -9.43783522e-02f, -3.41374651e-02f, 4.63361070e-02f, -6.31295666e-02f, -6.23289831e-02f, -1.37766033e-01f, -7.28241950e-02f,
  7.49752973e-04f, 4.00823168e-02f, 4.13160138e-02f, -4.61485982e-02f, -7.94302970e-02f, -9.13153589e-02f, -5.94737940e-02f, 6.64949194e-02f, 1.55144846e-02f, -1.95283443e-02f,
  2.35479567e-02f, 1.00701459e-01f, 7.08611310e-02f, 3.81659456e-02f, 6.61087856e-02f, 3.62416990e-02f, 6.44164160e-02f, 3.30308601e-02f, 1.14228725e-01f, -6.08297102e-02f,
  -5.35615906e-02f, -3.06389388e-02f, -4.28076051e-02f, 5.21319807e-02f, 1.24407688e-03f, -7.14834407e-02f, 1.06781580e-01f, -7.15710595e-02f, 7.36530498e-02f, 3.16378810e-02f,
  1.12048793e-03f, 4.12990674e-02f, 9.62731168e-02f, 1.03955455e-01f, 9.74715203e-02f, 2.29727887e-02f, 2.71412544e-02f, 5.63369468e-02f, 6.01441339e-02f, -7.26963282e-02f,
  6.08341023e-03f, 1.14458665e-01f, 6.50392324e-02f, 5.52705415e-02f, 7.47151375e-02f, -6.62041977e-02f, -1.36990147e-02f, -8.76827613e-02f, 1.37432784e-01f, -2.67522167e-02f,
  4.99816425e-02f, 5.84431402e-02f, -3.82409315e-04f, 2.29733568e-02f, -3.39958966e-02f, 6.45426437e-02f, -6.73177391e-02f, -8.00433531e-02f, -1.16133429e-01f, -4.56555076e-02f,
  -3.13949399e-02f, -7.17124641e-02f, -9.87833086e-03f, 5.66154979e-02f, -1.61832701e-02f, 1.80950959e-03f, 1.00944899e-01f, 3.69490385e-02f, -1.09501570e-01f, -3.47365136e-03f,
  -1.48809589e-02f, -1.10535800e-01f, -5.89727461e-02f, -2.59477086e-02f, 5.04211150e-03f, -5.21521121e-02f, -1.23587232e-02f, 9.15620103e-03f, 4.66335900e-02f, 2.81017516e-02f,
  -1.76565070e-02f, 7.94860348e-02f, 1.12547548e-02f, -2.48246221e-03f, -1.19999014e-01f, -3.19332853e-02f, -4.84210029e-02f, -3.48834833e-03f, -7.04870895e-02f, -5.90300839e-03f,
  1.04254603e-01f, 1.83880199e-02f, 5.52605242e-02f, -1.40903257e-02f, 5.32016270e-02f, 1.05084352e-01f, -2.23189201e-02f, -1.72380432e-01f, -5.59385307e-03f, 1.73026934e-01f,
  6.01505414e-02f, 2.04238236e-01f, 1.29660934e-01f, 8.65466613e-03f, -9.20235142e-02f, -9.11571085e-03f, -7.38557652e-02f, -4.59456556e-02f, -8.22634101e-02f, -4.47140150e-02f,
  4.55951737e-03f, -1.85183026e-02f, -5.52879833e-03f, -5.50145395e-02f, 9.78875086e-02f, 1.07611634e-01f, 4.51024473e-02f, 7.09388405e-02f, 2.17478890e-02f, -7.83520043e-02f,
  -4.62907068e-02f, -9.00726020e-02f, 5.61887659e-02f, 6.42409921e-02f, -4.81653176e-02f, -1.05206226e-03f, -7.40954578e-02f, 4.31857295e-02f, -2.57022101e-02f, 3.60229798e-02f,
  8.64110980e-03f, -6.70480281e-02f, 7.53755271e-02f, 1.51787363e-02f, 4.62369956e-02f, -6.97976127e-02f, -9.25034517e-04f, 5.28668752e-03f, -5.56567684e-02f, 2.71750381e-03f,
  -5.75187337e-03f, -4.48924080e-02f, -9.06302258e-02f, -2.83182580e-02f, -2.21948531e-02f, -1.09042227e-01f, -4.20381501e-02f, -5.48612326e-02f, 3.11478097e-02f, 3.81201059e-02f,
  2.49689128e-02f, -1.01799928e-01f, -1.61907859e-02f, 5.26169315e-02f, -4.79469858e-02f, 1.03911668e-01f, -1.00396261e-01f, -4.55936603e-02f, 2.36637820e-03f, -2.48320773e-02f,
  7.42261182e-04f, -1.02849960e-01f, 4.31823619e-02f, -7.87222106e-03f, -6.55581132e-02f, -4.03644098e-03f, 9.87242674e-04f, -9.25324112e-03f, -8.88129473e-02f, -9.48389098e-02f,
  -5.13662063e-02f, -3.37236002e-03f, 1.14921005e-02f, 8.06137472e-02f, 6.08113781e-02f, -1.81750208e-02f, -6.40729964e-02f, 2.60026231e-02f, 4.93770391e-02f, 3.06700971e-02f,
  -9.59872305e-02f, 6.04379401e-02f, 3.55780981e-02f, -3.49322557e-02f, 2.35010274e-02f, -8.75400081e-02f, -6.00812137e-02f, 1.19274445e-01f, 7.86713362e-02f, 4.78080735e-02f,
  4.22243141e-02f, 5.54028600e-02f, 1.10038780e-01f, 1.21331140e-02f, -9.42345429e-03f, -3.00737619e-02f, 6.74008280e-02f, 3.74713801e-02f, -2.46142074e-02f, -9.33546945e-02f,
  2.55740657e-02f, 8.13614130e-02f, 2.25217920e-02f, -1.20973602e-01f, 8.67355987e-02f, 2.31819227e-02f, -4.36047837e-02f, 5.86459488e-02f, 6.06465228e-02f, 1.68668106e-01f,
  -1.28563151e-01f, -4.73849028e-02f, 1.52370766e-01f, -6.36359155e-02f, -2.21366435e-02f, -5.88353490e-03f, -5.12142591e-02f, 1.72168203e-02f, 4.66914847e-02f, 1.73019260e-01f,
  -1.43305391e-01f, 1.09118316e-02f, -3.72337885e-02f, -2.06374545e-02f, -1.88353546e-02f, 1.74533367e-01f, 1.56193659e-01f, -6.05884865e-02f, -6.57675341e-02f, -1.75626382e-01f,
  1.20418027e-01f, -1.97651479e-02f, 9.39408839e-02f, 2.91947350e-02f, 1.30273268e-01f, 3.56835946e-02f, -1.12019188e-03f, 4.50199805e-02f, -6.44953400e-02f, 3.57115157e-02f,
  -7.91457146e-02f, -4.62981261e-05f, 5.64549379e-02f, -1.03306565e-02f, 1.50133902e-02f, 2.57863738e-02f, 1.16189741e-01f, -3.60544361e-02f, 7.27227628e-02f, 1.08910501e-02f,
  3.99205908e-02f, -1.26058951e-01f, 1.06327951e-01f, 8.81683975e-02f, -3.29257846e-02f, -5.19539341e-02f, 5.92631921e-02f, 3.04457895e-03f, -1.28621086e-01f, 1.98320039e-02f,
  3.90813164e-02f, 2.97845639e-02f, 6.90379739e-02f, 1.38082266e-01f, 6.98571950e-02f, -6.11100681e-02f, -8.74030404e-03f, 1.43528655e-02f, -4.68008555e-02f, 2.45038942e-02f,
  -2.18232814e-03f, -5.25301173e-02f, 5.53508215e-02f, 7.60127455e-02f, 5.61822467e-02f, 1.20756552e-01f, 1.55143077e-02f, -8.14889849e-04f, 4.49791886e-02f, -8.25773645e-03f,
  -9.51339602e-02f, -7.16976747e-02f, 3.18383090e-02f, 9.94493589e-02f, -3.92643828e-03f, -1.05521411e-01f, -1.34926978e-02f, -8.76722261e-02f, 1.00050047e-01f, -3.54860052e-02f,
  -3.64175974e-03f, 6.32759407e-02f, 3.61561701e-02f, 1.29979357e-01f, 6.98463246e-02f, 5.11837937e-02f, -1.95776988e-02f, 5.10460138e-02f, 7.82992542e-02f, 6.10218830e-02f,
  -9.00697485e-02f, 1.42220333e-02f, 1.04142100e-01f, 7.25321844e-02f, 4.72949669e-02f, 8.68976638e-02f, 1.29880747e-02f, 4.26976569e-02f, 3.96012701e-02f, -1.27340192e-02f,
  -9.23083201e-02f, -2.27412861e-02f, -6.06688857e-02f, 3.97329368e-02f, 4.20754813e-02f, 6.55119270e-02f, -4.44926545e-02f, -3.95959765e-02f, -1.74839988e-01f, 1.88634451e-02f,
  1.15880959e-01f, -1.34724692e-01f, -1.95906945e-02f, -5.39141474e-04f, 6.50118887e-02f, -9.10434797e-02f, -4.44173142e-02f, 8.69419724e-02f, 1.41592305e-02f, 6.27576411e-02f,
  -3.86611968e-02f, -1.60016388e-01f, -7.80780166e-02f, 8.41180086e-02f, -6.32409528e-02f, 1.01819254e-01f, -2.23319437e-02f, 1.41974896e-01f, -6.21383600e-02f, -6.58034086e-02f,
  1.50970995e-01f, 4.79616597e-02f, 7.95425400e-02f, 9.78299999e-04f, -7.34107196e-02f, 4.01456747e-03f, -1.44656710e-02f, -6.13466948e-02f, -2.09110007e-01f, 6.00280650e-02f,
  1.06946819e-01f, 6.48420595e-04f, 3.95924859e-02f, 1.28322184e-01f, -1.33041233e-01f, -1.37909308e-01f, 8.17548297e-03f, -1.09554917e-01f, -7.24270940e-02f, 4.03470844e-02f,
  -7.47950152e-02f, -1.33594021e-01f, -7.92056844e-02f, 4.03482318e-02f, 4.23991010e-02f, -2.24124957e-02f, 4.30316962e-02f, 7.08714500e-03f, -9.40960180e-03f, -1.86918918e-02f,
  -3.66489477e-02f, 5.41049279e-02f, 9.81644392e-02f, -1.03968285e-01f, 8.42289701e-02f, -8.24174508e-02f, 6.31220564e-02f, 7.48465806e-02f, -5.56613058e-02f, -9.97020304e-02f,
  4.07485254e-02f, -3.61751765e-02f, 5.12992181e-02f, -3.32909003e-02f, 2.46880762e-02f, 2.51159221e-02f, 4.21163207e-03f, 2.07514931e-02f, 5.19269854e-02f, 9.11097378e-02f,
  -6.62944019e-02f, -7.54314661e-02f, -2.68290006e-02f, -1.51775070e-02f, -5.80704138e-02f, 4.65951599e-02f, 3.85563006e-03f, -1.63690094e-02f, -8.43808874e-02f, 9.43207666e-02f,
  -1.34540657e-02f, 1.64322816e-02f, -6.52202666e-02f, -1.55023545e-01f, -1.89603772e-02f, 8.02993849e-02f, -1.98309459e-02f, 5.33881597e-02f, -1.17658395e-02f, 4.99428213e-02f,
  -2.27046832e-02f, -1.01686642e-01f, -7.22840577e-02f, 2.56341863e-02f, -1.13572985e-01f, -2.87304539e-02f, 2.22151373e-02f, 1.03218155e-02f, 7.62347579e-02f, -5.06931134e-02f,
  -9.97965690e-03f, -1.08118333e-01f, 5.06536700e-02f, -7.92650506e-02f, -8.35399553e-02f, -7.69776776e-02f, -4.18922082e-02f, -3.93801704e-02f, -3.40587646e-02f, -7.01857954e-02f,
  -3.92296761e-02f, 1.06932960e-01f, -1.18200958e-01f, -4.26420867e-02f, -6.66961819e-02f, 5.16005121e-02f, 6.48982897e-02f, -1.04837850e-01f, -3.76115181e-02f, -1.48126528e-01f,
  -8.19925126e-03f, -3.95218842e-02f, 9.53451321e-02f, 8.00363254e-03f, 1.21351862e-02f, 4.20400985e-02f, 5.27907200e-02f, -2.58527156e-02f, 3.96594452e-03f, -6.21062890e-02f,
  -1.12293281e-01f, -8.10787305e-02f, -6.03915527e-02f, 1.70577206e-02f, -4.70821522e-02f, -2.64920648e-02f, 1.12691037e-02f, -8.53956565e-02f, 9.11157355e-02f, 1.50765046e-01f,
  5.17218634e-02f, 1.95001774e-02f, -5.29532284e-02f, 3.94563191e-02f, 3.30985375e-02f, -1.55387163e-01f, 1.73408180e-01f, 1.40808687e-01f, -9.22091901e-02f, -9.96129960e-03f,
  3.22545469e-02f, 5.40340617e-02f, 5.10512479e-02f, 1.67341590e-01f, -6.55043498e-02f, -1.42393038e-01f, 4.16932441e-02f, 1.37599245e-01f, -7.08970204e-02f, 3.47840860e-02f,
  -9.45253577e-03f, 5.50532192e-02f, 8.97309855e-02f, -1.71931237e-01f, -1.67785853e-01f, -1.00880675e-01f, -1.80812731e-01f, -1.14988774e-01f, 1.74035892e-01f, 1.45756766e-01f,
  1.34692028e-01f, 5.45696467e-02f, 1.65186301e-02f, 5.69427237e-02f, 2.13980079e-02f, -1.00311406e-01f, 2.52319471e-04f, 7.75389140e-03f, -8.05034488e-02f, 2.00638510e-02f,
  -1.72320548e-02f, -5.28903445e-03f, 4.99652624e-02f, 2.93287095e-02f, -6.69239163e-02f, 5.43666855e-02f, -4.92999218e-02f, -7.21281543e-02f, 4.69119027e-02f, -4.98462357e-02f,
  -4.11183871e-02f, -3.54267620e-02f, -3.79431807e-02f, -3.57042104e-02f, -7.61624947e-02f, -8.06078315e-02f, 2.16592699e-02f, -8.68031662e-03f, 3.31604145e-02f, 8.52461755e-02f,
  4.83713150e-02f, -6.04957715e-03f, -2.97005428e-03f, 5.03280945e-02f, -5.33332452e-02f, 1.12169132e-01f, 7.84082413e-02f, -1.47655562e-01f, -3.68470177e-02f, -9.33271125e-02f,
  7.73231089e-02f, 1.26517698e-01f, 4.27410752e-02f, 6.91565871e-02f, -4.08687107e-02f, -6.06463514e-02f, 5.03711067e-02f, -8.42250809e-02f, 9.22740176e-02f, 7.26702511e-02f,
  -8.40953067e-02f, 5.97695485e-02f, 5.27785756e-02f, 1.14485882e-02f, 5.13562597e-02f, -4.25619213e-03f, 4.12297286e-02f, 6.50134981e-02f, 6.73312098e-02f, -8.72637853e-02f,
  4.96758819e-02f, -3.47459093e-02f, -3.73612233e-02f, 1.51662501e-02f, 6.54679015e-02f, -5.81648126e-02f, -6.90645948e-02f, -1.01291507e-01f, 9.48021337e-02f, 2.71520391e-02f,
  3.41237895e-02f, 6.41391277e-02f, -9.25529897e-02f, -8.25391263e-02f, 2.03184108e-03f, 1.64896287e-02f, 9.17541701e-03f, -9.93983895e-02f, 8.68469700e-02f, 1.98420044e-02f,
  8.24681446e-02f, 6.84106275e-02f, -7.10992739e-02f, 3.88810039e-02f, 1.27099864e-02f, 4.57950458e-02f, -1.04386494e-01f, 5.22548519e-02f, 1.76075622e-01f, -9.67017412e-02f,
  4.11618054e-02f, -1.39885649e-01f, 2.20356090e-03f, 2.12772321e-02f, -7.33033270e-02f, 8.06386992e-02f, 1.53204486e-01f, -7.97903538e-02f, -1.86796516e-01f, -1.41399547e-01f,
  -1.55387446e-01f, 1.75767437e-01f, 9.50065553e-02f, 1.02980107e-01f, 1.28797635e-01f, 1.95612130e-03f, -1.27476826e-01f, 4.17575948e-02f, -1.47263095e-01f, 1.26157746e-01f,
  -2.55010098e-01f, 3.45821343e-02f, 1.15880612e-02f, 5.53969443e-02f, -5.20259775e-02f, 1.36066437e-01f, -2.11342067e-01f, 1.19520891e-02f, 7.34046847e-02f, -1.02022760e-01f,
  -1.86585654e-02f, 2.50431951e-02f, 7.05616176e-02f, 1.33640096e-01f, -2.67349370e-02f, 5.44660911e-03f, 3.15063186e-02f, -9.33477059e-02f, -2.71188319e-02f, -1.31857395e-01f,
  -8.37274268e-02f, -5.14963418e-02f, 6.42806962e-02f, 1.14469440e-03f, -4.98968624e-02f, -3.73982824e-02f, -5.46342358e-02f, 8.19551051e-02f, 5.11548109e-02f, 6.56376630e-02f,
  -4.36877199e-02f, 1.27718613e-01f, 4.68735173e-02f, 5.61847985e-02f, 1.40559435e-01f, 9.34473276e-02f, -1.28760666e-01f, -4.30887491e-02f, 1.54273212e-01f, 4.94078919e-02f,
  9.70879570e-02f, 1.77986138e-02f, 9.55164656e-02f, 5.29554859e-02f, 1.29786253e-01f, -9.46464570e-05f, 2.45516305e-03f, -4.71748225e-03f, -6.39149360e-03f, 7.30975494e-02f,
  4.50767316e-02f, -7.93908685e-02f, -8.03964064e-02f, 8.23832750e-02f, 7.51707926e-02f, -1.50804231e-02f, -7.36917257e-02f, -3.74864824e-02f, 3.85094360e-02f, 4.02374975e-02f,
  2.46277754e-03f, 5.46697453e-02f, 7.44590983e-02f, -4.35998403e-02f, 3.82462963e-02f, 8.09434727e-02f, -7.25217983e-02f, -3.84473987e-02f, 2.82930881e-02f, 4.96262759e-02f,
  1.10930530e-02f, -6.50756657e-02f, 6.93144426e-02f, 1.52140772e-02f, -8.50911960e-02f, -9.06482562e-02f, 6.13122433e-02f, -1.31871682e-02f, -8.47499147e-02f, 6.73641339e-02f,
  1.21285178e-01f, 2.26180162e-02f, -1.75291933e-02f, -1.03600845e-01f, -2.91657075e-02f, 5.91031834e-02f, 6.66363165e-02f, 9.48790684e-02f, 4.92004938e-02f, -3.25703919e-02f,
  5.40240742e-02f, 1.31944120e-01f, -3.11512817e-02f, -5.08603305e-02f, 6.85570389e-02f, -8.12355056e-02f, 1.19201746e-02f, 4.22876375e-03f, -1.12632245e-01f, -8.09290782e-02f,
  3.77075858e-02f, -5.75922523e-03f, 1.64201856e-02f, -6.13781624e-02f, -9.84530970e-02f, -1.94598697e-02f, -7.08145574e-02f, 1.63390681e-01f, -9.95869264e-02f, 1.65338233e-01f,
  1.27998918e-01f, -1.59893051e-01f, 5.79829887e-02f, -3.39589156e-02f, -1.21111341e-01f, 1.61921401e-02f, 8.26784149e-02f, 3.44340992e-03f, 7.77164996e-02f, 8.08154866e-02f,
  -1.67340547e-01f, -1.41353101e-01f, 5.84353246e-02f, 7.26230741e-02f, -2.04338208e-02f, -1.67714432e-01f, 1.17759323e-02f, -1.55729234e-01f, -5.23887910e-02f, -1.47252530e-01f,
  -6.82461783e-02f, -1.04742594e-01f, -9.20696482e-02f, -4.05306406e-02f, 6.82639331e-02f, 1.00339569e-01f, -3.50678153e-02f, 5.48074916e-02f, 1.17531136e-01f, 2.69436035e-02f,
  -6.52148947e-02f, -1.07707113e-01f, 4.74187583e-02f, 3.96582484e-02f, -7.12800622e-02f, 1.23258628e-01f, -8.19802210e-02f, 1.83091648e-02f, -4.18384038e-02f, 1.43806532e-01f,
  -6.31628558e-02f, -4.68905941e-02f, -5.54018244e-02f, -6.35147654e-03f, 8.68311301e-02f, -2.02723797e-02f, -9.68769640e-02f, -1.45097785e-02f, 1.25765242e-02f, -1.01790391e-01f,
  7.59982131e-03f, 7.40059167e-02f, -7.63138682e-02f, -3.16927247e-02f, 6.85238540e-02f, -4.25155228e-03f, 5.24936663e-03f, -2.12048385e-02f, -5.05797453e-02f, -8.19715485e-03f,
  -4.20976244e-02f, -4.63508591e-02f, 8.65241066e-02f, 4.73183654e-02f, 5.88843003e-02f, -2.23166775e-02f, -1.81081519e-02f, 1.89009570e-02f, 3.18496153e-02f, -3.54564711e-02f,
  2.85645798e-02f, 3.55931409e-02f, 7.60313217e-03f, 4.26756665e-02f, -1.06032183e-02f, 1.09984942e-01f, -3.01651638e-02f, -7.73055777e-02f, -6.53389394e-02f, -9.85096768e-02f,
  6.40733764e-02f, -4.02618349e-02f, -3.62892114e-02f, -3.33779491e-02f, -6.80170581e-02f, 2.82633062e-02f, 5.38369603e-02f, -7.01666027e-02f, -8.65417123e-02f, -4.16266993e-02f,
  5.07657528e-02f, -1.10889219e-01f, -5.42554185e-02f, -3.41272987e-02f, -8.78049210e-02f, 1.31753571e-02f, 6.42240047e-03f, -2.20614532e-03f, 3.97250503e-02f, -1.99272223e-02f,
  -5.45165353e-02f, -5.95245250e-02f, -3.14460211e-02f, -4.73381998e-03f, -1.12412743e-01f, 8.86078831e-03f, -9.16616176e-04f, 3.96586396e-02f, 6.20401427e-02f, 2.88470946e-02f,
  -1.07922368e-02f, -8.19772184e-02f, -3.94389816e-02f, -4.19219360e-02f, -5.94978146e-02f, -4.75201719e-02f, -5.40939756e-02f, -1.17190629e-01f, -1.15273297e-01f, -3.04122418e-02f,
  2.50169560e-02f, -1.63248256e-02f, -8.34686533e-02f, 1.26649991e-01f, -2.20206734e-02f, -1.08916136e-02f, -3.92589858e-03f, 1.23539448e-01f, 3.34917419e-02f, -8.58996958e-02f,
  8.04416388e-02f, 4.57117222e-02f, -1.16114780e-01f, -8.90881866e-02f, -3.47643644e-02f, 2.09795758e-02f, 1.60569608e-01f, -7.64037967e-02f, -9.22220647e-02f, 1.53067913e-02f,
  -1.82232745e-02f, -8.54947697e-03f, -1.05157718e-02f, -1.21700250e-01f, 1.11906968e-01f, -1.54991984e-01f, 1.36496499e-01f, -3.15253884e-02f, 4.52543572e-02f, 1.29082486e-01f,
  -3.63072497e-03f, -1.16071247e-01f, 1.16789587e-01f, 3.18390355e-02f, -8.62047076e-02f, -8.29823501e-03f, 1.12833239e-01f, 1.46635845e-01f, -2.74392813e-02f, 8.99651796e-02f,
  1.98452756e-01f, 7.67380595e-02f, -3.85234924e-03f, -1.17813470e-02f, -7.04946816e-02f, -4.73830625e-02f, -4.17268835e-02f, -1.02888331e-01f, -5.30345179e-02f, 5.55249006e-02f,
  6.76867664e-02f, 7.80430287e-02f, 1.11838346e-02f, 9.15159062e-02f, 7.26109277e-03f, -6.14000019e-03f, -8.28999653e-02f, 2.87275538e-02f, -6.85685501e-02f, -7.00800195e-02f,
  -1.13411397e-01f, 1.51353087e-02f, 2.51448248e-02f, -4.59383056e-02f, -5.37575409e-02f, -6.16781488e-02f, -8.12210962e-02f, -2.23745462e-02f, -1.21351987e-01f, 4.52638902e-02f,
  8.69211704e-02f, 4.92709838e-02f, 9.06137303e-02f, -6.64957985e-02f, -6.09557964e-02f, -1.03286944e-01f, -2.03195177e-02f, -1.77011453e-02f, -7.97482729e-02f, 2.27598157e-02f,
  4.46606353e-02f, -3.55273150e-02f, -1.52396560e-02f, -4.21411870e-03f, 2.43432485e-02f, 2.53273603e-02f, -3.77152227e-02f, -7.32615516e-02f, 6.04420602e-02f, 6.59044161e-02f,
  7.02723265e-02f, 6.73335567e-02f, 3.52890491e-02f, 4.31933515e-02f, 1.89836770e-01f, -7.22026303e-02f, -8.50556791e-02f, -5.07200025e-02f, -6.78007305e-02f, -3.58922663e-03f,
  -1.45214379e-01f, 8.71829763e-02f, 2.77664270e-02f, 9.97518003e-02f, 5.70453741e-02f, 1.05151363e-01f, -3.77107449e-02f, 6.45884499e-02f, 6.68930262e-03f, 5.92187233e-02f,
  -7.08718970e-02f, 3.68597768e-02f, -3.04076746e-02f, 5.77369817e-02f, -1.06846998e-02f, -5.62546849e-02f, 6.62959218e-02f, 8.19386989e-02f, 5.74307218e-02f, -4.94178794e-02f,
  2.57815123e-02f, 1.38120368e-01f, 3.30837406e-02f, -3.83663625e-02f, -6.69240067e-03f, 1.03767104e-01f, 1.38425231e-01f, -9.54155624e-02f, -2.01881826e-01f, 2.70846561e-02f,
  1.83390096e-01f, -1.38919950e-01f, -1.68279901e-01f, -1.57929920e-02f, 1.33683994e-01f, -3.62501405e-02f, -1.14093050e-01f, 1.30637214e-02f, 3.75754796e-02f, 2.50748591e-03f,
  -4.51712124e-02f, 4.50717844e-03f, 7.09086806e-02f, 4.99935523e-02f, 1.35680899e-01f, -8.67419690e-02f, -2.12265495e-02f, 3.62462550e-02f, -7.75247887e-02f, 1.06410580e-02f,
  2.06536397e-01f, -1.07654426e-02f, 6.79083616e-02f, -2.36597639e-02f, -8.96184426e-03f, 8.35412554e-03f, 1.36887386e-01f, 6.92655072e-02f, -2.51286030e-01f, -5.58247231e-02f,
  2.45318845e-01f, -1.39633998e-01f, 1.50207989e-02f, 1.11233339e-01f, -3.25582630e-04f, -1.15093105e-01f, -5.03757559e-02f, -1.74713850e-01f, 1.08479716e-01f, 7.70843327e-02f,
  -3.35971341e-02f, 8.67789611e-02f, -6.02067960e-03f, 5.49952388e-02f, 2.73655821e-02f, 2.16848832e-02f, 1.04408283e-02f, 7.18715116e-02f, -6.38026521e-02f, 2.53650043e-02f,
  -1.15816593e-01f, -8.89891163e-02f, -9.12775099e-02f, -1.08632304e-01f, 1.13544352e-01f, -6.59707338e-02f, -1.26052320e-01f, 5.86883575e-02f, 5.71660548e-02f, -1.22270741e-01f,
  8.28500744e-03f, 7.33791217e-02f, 2.56547891e-02f, -6.32409900e-02f, -8.43444616e-02f, 3.35984565e-02f, -5.50446883e-02f, 8.84424448e-02f, -7.92465881e-02f, -5.04556186e-02f,
  -2.77944338e-02f, -3.19150276e-02f, 1.12528719e-01f, -9.33979079e-03f, 1.04167052e-01f, 6.75876141e-02f, 4.21440415e-02f, 5.68495579e-02f, -1.10298656e-02f, 3.30659077e-02f,
  -2.59849131e-02f, 9.30527300e-02f, -5.80753386e-03f, 2.72823162e-02f, -1.39293754e-02f, -7.14964718e-02f, -1.33549077e-02f, -1.66267599e-03f, 4.00405265e-02f, -5.21121696e-02f,
  9.28328857e-02f, 4.34639417e-02f, 1.83510929e-01f, -2.35271044e-02f, 1.89600848e-02f, -2.73512825e-02f, 3.28701809e-02f, 1.16194300e-02f, -1.25535458e-01f, 5.45148849e-02f,
  4.82136086e-02f, 1.04337931e-01f, 7.16209486e-02f, 1.78457703e-03f, -6.32798299e-02f, 3.42842378e-02f, -6.49871007e-02f, 6.60736039e-02f, -5.72822522e-03f, 1.03869490e-01f,
  6.28801510e-02f, -4.45552059e-02f, -8.30083489e-02f, 9.09322500e-02f, 7.26973936e-02f, -8.19141567e-02f, 1.57011335e-03f, -2.16054153e-02f, -9.13661644e-02f, 8.62670168e-02f,
  -4.92300056e-02f, 6.92892224e-02f, 5.76523356e-02f, 4.35188562e-02f, 6.97896704e-02f, -1.14305571e-01f, -1.54962555e-01f, 9.94649976e-02f, 1.53472200e-01f, 2.87692696e-02f,
  -3.88920829e-02f, -7.77284876e-02f, 1.11530073e-01f, -5.74697815e-02f, 4.65245694e-02f, 6.50879517e-02f, 7.34856501e-02f, -2.93525332e-03f, -1.44037589e-01f, -2.83252150e-02f,
  4.13439535e-02f, 1.65848672e-01f, 1.49334058e-01f, -8.40627253e-02f, -8.78342986e-02f, 1.14640132e-01f, -2.32742682e-01f, -1.57820910e-01f, 1.78239912e-01f, 1.10747188e-01f,
  -1.01145925e-02f, -1.46769404e-01f, 4.42578383e-02f, -2.03732662e-02f, 5.02363779e-02f, 1.34588405e-01f, -1.33413836e-01f, -1.45473123e-01f, 1.50019288e-01f, 4.04199772e-02f,
  -1.27786011e-01f, 1.30018711e-01f, 5.43475933e-02f, -8.84833094e-03f, 4.19394560e-02f, -9.82679129e-02f, 1.11771129e-01f, -7.10779503e-02f, 2.64556445e-02f, -5.56875095e-02f,
  5.93145452e-02f, 5.31539842e-02f, -3.63862701e-02f, -7.27421120e-02f, -2.77028922e-02f, 8.51392373e-02f, -4.00364175e-02f, 8.49749614e-03f, -5.78852035e-02f, 3.80357751e-03f,
  -7.05246851e-02f, -1.05523422e-01f, 1.08393483e-01f, 3.65121327e-02f, 3.76187032e-03f, 9.89857167e-02f, -3.30526084e-02f, 6.67363703e-02f, 4.81026843e-02f, 2.80581042e-02f,
  -1.19050391e-01f, 1.01902140e-02f, -7.27235153e-02f, 8.90941694e-02f, -7.88757056e-02f, -5.23802079e-03f, 2.86271665e-02f, 7.84822106e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  2.57851705e-02f, 6.77896962e-02f, 5.73112033e-02f, 3.65510695e-02f, 6.37818426e-02f, 4.57417183e-02f, -3.67569625e-02f, 2.02244110e-02f, -8.49223286e-02f, -3.91109847e-02f,
  8.29111636e-02f, -3.92703339e-02f, 9.00117606e-02f, 6.64835051e-02f, 5.94385825e-02f, 1.07782483e-01f, -7.77307898e-02f, 5.23544028e-02f, 4.83351573e-02f, 1.65651031e-02f,
  1.04363821e-01f, -4.19944152e-02f, -6.71347007e-02f, 4.41432446e-02f, 7.61663020e-02f, -1.79236326e-02f, -2.01581083e-02f, 7.37615898e-02f, -1.83468219e-02f, -3.96534428e-02f,
  -8.35356116e-02f, 3.91350240e-02f, -6.22211210e-02f, -5.57434419e-03f, 1.57604851e-02f, 2.26097368e-02f, -4.01190147e-02f, 8.35037977e-02f, -5.84373735e-02f, -1.61050376e-03f,
  3.64374556e-02f, 4.52174209e-02f, 5.78412153e-02f, 3.42252984e-04f, -5.93061652e-03f, -7.53886029e-02f, 9.74506326e-03f, 3.75945680e-02f, 1.02414355e-01f, 8.63309056e-02f,
  -1.07346904e-02f, -1.16105070e-02f, 3.35993245e-02f, 3.72470282e-02f, -1.10107936e-01f, 6.80311769e-02f, 7.20577464e-02f, 4.02973592e-02f, 5.80988489e-02f, -2.95118522e-02f,
  -7.76281059e-02f, -8.83385018e-02f, -3.51847894e-02f, -9.97721627e-02f, 7.02929720e-02f, -3.58048864e-02f, 2.70868465e-02f, -7.01338574e-02f, 6.05793335e-02f, -1.69304796e-02f,
  8.06154385e-02f, 9.73234549e-02f, -7.00520352e-03f, 2.20733173e-02f, 2.60291286e-02f, 1.98606774e-02f, -3.46035650e-03f, -1.15216360e-04f, -3.30414772e-02f, 2.62206756e-02f,
  -1.77560141e-03f, 8.70192870e-02f, -3.08727268e-02f, 6.12171628e-02f, 3.35530378e-02f, 3.33941504e-02f, 8.51801187e-02f, -2.78944429e-02f, -4.88702543e-02f, -6.17946051e-02f,
  -7.05613494e-02f, -9.39292312e-02f, -2.10932810e-02f, 4.38632444e-02f, -5.66420555e-02f, -7.81114548e-02f, -1.48416413e-02f, -2.76831500e-02f, 5.81209622e-02f, -5.14935926e-02f,
  -3.13143134e-02f, 5.15727233e-03f, -6.44547632e-03f, -6.51432797e-02f, -5.39143085e-02f, -4.87108715e-02f, 1.38974665e-02f, -1.09863570e-02f, -1.34998169e-02f, -7.71254972e-02f,
  6.94814846e-02f, -2.13078670e-02f, -3.72473821e-02f, -1.19915390e-02f, 6.62263855e-03f, 1.19873136e-02f, 8.41197148e-02f, 5.75596765e-02f, 5.81665970e-02f, 2.30077449e-02f,
  3.36197577e-02f, -6.91828430e-02f, -4.07627299e-02f, -7.89416358e-02f, -2.16144286e-02f, -6.35168776e-02f, -4.66498509e-02f, 1.56270191e-02f, -2.92378403e-02f, -1.71725806e-02f,
  -3.84733342e-02f, 2.95262691e-02f, -1.98809989e-02f, 1.44429952e-01f, -3.92402485e-02f, 1.16048269e-01f, 5.48326336e-02f, 6.09785132e-02f, 9.31668133e-02f, 8.02307501e-02f,
  3.15277874e-02f, 3.15759704e-02f, -4.23970148e-02f, -6.80098310e-02f, -4.51743696e-03f, 9.26803648e-02f, 5.75234881e-03f, 1.24037094e-01f, 2.25411486e-02f, 1.28765106e-02f,
  1.18364438e-01f, -6.86032549e-02f, 5.74865974e-02f, 7.76074678e-02f, 9.22389105e-02f, -2.98930146e-02f, -7.57695884e-02f, 8.77746008e-03f, 1.04833012e-02f, 1.73497424e-02f,
  -6.38330951e-02f, 4.27332111e-02f, 1.69672333e-02f, -9.82860476e-03f, -3.26016359e-02f, -3.14176604e-02f, 8.39659795e-02f, 5.96039370e-02f, 4.07828093e-02f, 4.04638611e-02f,
  6.80913553e-02f, -6.97210431e-02f, 2.33358443e-02f, 7.92436078e-02f, -3.72078419e-02f, 1.67474337e-02f, -3.70477363e-02f, 1.08846128e-01f, 5.38105099e-03f, 5.80072999e-02f,
  -4.78681624e-02f, -9.35606845e-03f, 9.94681790e-02f, 4.80600772e-03f, 2.81554051e-02f, 1.03520058e-01f, 2.50712167e-02f, 3.78936902e-02f, -1.37077048e-02f, 5.81796914e-02f,
  -5.84079362e-02f, 5.70907518e-02f, 5.50411716e-02f, -6.37666658e-02f, 1.12716809e-01f, -8.32809787e-03f, -2.12915987e-02f, -1.01796776e-01f, -4.33352850e-02f, -4.27073576e-02f,
  -4.34925072e-02f, -1.36375219e-01f, -1.12869732e-01f, -9.14773270e-02f, -1.14012882e-01f, -8.82844105e-02f, 8.37075710e-02f, -8.87821093e-02f, -4.82920147e-02f, -3.72285210e-02f,
  4.59423959e-02f, 3.42137031e-02f, 5.91075942e-02f, 1.84965767e-02f, -2.01127841e-03f, -9.99544188e-02f, 9.55572724e-02f, -7.25946575e-02f, -5.01951762e-02f, 1.17743000e-01f,
  4.25832905e-02f, 8.11880529e-02f, -8.07470754e-02f, -1.11293746e-02f, -2.72570215e-02f, 3.07141896e-03f, -6.96290955e-02f, 2.80436892e-02f, 4.35071439e-02f, 7.54790604e-02f,
  1.16786724e-02f, 3.84059064e-02f, 3.09132170e-02f, -5.30755706e-03f, 4.63888682e-02f, 2.96593718e-02f, -4.91810553e-02f, -5.93236759e-02f, -6.18104786e-02f, -5.66274300e-02f,
  5.13946712e-02f, 2.34221504e-03f, -6.97498694e-02f, -5.57352826e-02f, 1.02210129e-02f, 4.54281867e-02f, -1.25438925e-02f, 7.62108639e-02f, -3.49578485e-02f, -3.08041181e-02f,
  -7.12925643e-02f, -6.64003417e-02f, -8.14366192e-02f, 1.58576928e-02f, 3.16132046e-02f, -4.96044271e-02f, 1.74344350e-02f, -5.06926216e-02f, 8.57014954e-03f, -1.14076845e-02f,
  -2.68802866e-02f, -3.64796631e-02f, 1.23937679e-02f, 8.41462240e-03f, -3.79262976e-02f, 1.11160919e-01f, -2.49274611e-03f, -3.87391634e-02f, -1.12017163e-03f, 8.58969241e-02f,
  -5.40722981e-02f, 1.00248285e-01f, 7.18980730e-02f, -4.44365330e-02f, 1.03175379e-01f, -3.86382677e-02f, 8.76950249e-02f, -2.05655452e-02f, 9.15121958e-02f, -1.97486356e-02f,
  6.21022135e-02f, 4.64090295e-02f, 4.62538861e-02f, 3.50704156e-02f, -1.53633719e-02f, 1.84069201e-02f, -2.80423053e-02f, 1.75749809e-02f, 3.33299488e-02f, 1.23495236e-01f,
  1.14816651e-01f, -3.03060915e-02f, 7.19687119e-02f, -4.56577633e-03f, -5.72356768e-02f, -2.39405222e-02f, -2.86237653e-02f, -1.31256999e-02f, -6.79148361e-02f, 9.12577286e-02f,
  9.45924595e-02f, 1.11488193e-01f, -1.02028875e-02f, -3.54757942e-02f, 3.20500247e-02f, 1.70566479e-03f, -6.31098375e-02f, 1.07723393e-01f, 5.75819165e-02f, -8.83172676e-02f,
  1.03838228e-01f, 9.33873653e-02f, -1.49306342e-01f, -9.31731388e-02f, 9.09018889e-02f, -1.40412375e-01f, -9.36387330e-02f, -8.00917223e-02f, 7.16773495e-02f, 1.43002132e-02f,
  -7.49748275e-02f, 9.72201526e-02f, -6.56163469e-02f, 2.38998048e-02f, 5.00191823e-02f, 4.32151370e-02f, 3.03013138e-02f, 9.72403809e-02f, 2.91377380e-02f, -1.99608095e-02f,
  1.13211244e-01f, -9.99141578e-03f, -9.32122096e-02f, 5.05044945e-02f, -8.05245619e-03f, 1.03204891e-01f, 4.73458283e-02f, -2.69043166e-02f, -7.75515242e-03f, 8.79387408e-02f,
  6.28076345e-02f, -7.40157738e-02f, -8.95505100e-02f, 1.26716509e-01f, 2.01153960e-02f, -1.12476155e-01f, -5.26415417e-03f, 1.07542492e-01f, -4.63027582e-02f, -1.32610247e-01f,
  8.40410739e-02f, -6.57691136e-02f, 3.42561342e-02f, -2.19797064e-02f, 6.08364418e-02f, -1.38582382e-02f, 1.54302372e-02f, 1.25361839e-02f, 2.43960647e-03f, -9.20442417e-02f,
  6.38315603e-02f, 6.37668520e-02f, -5.84884807e-02f, -5.72201796e-03f, -9.12966728e-02f, 7.22252354e-02f, 7.99862668e-02f, -7.21013620e-02f, 1.18072033e-01f, -5.76402992e-02f,
  -3.15610617e-02f, 7.68662840e-02f, 2.60272045e-02f, -3.08935232e-02f, -8.68088007e-02f, 9.05772969e-02f, 5.94987758e-02f, -2.30108034e-02f, 9.64105800e-02f, 6.00864924e-02f,
  -7.19535872e-02f, 5.13244867e-02f, -6.28832951e-02f, 9.79212672e-03f, -6.20096363e-02f, 6.90068603e-02f, 3.77574526e-02f, 6.84236363e-02f, 9.61335450e-02f, -7.73459021e-03f,
  -1.15641087e-01f, 1.36837736e-01f, -7.00483993e-02f, 1.15902297e-01f, -3.61645594e-03f, -3.84882465e-02f, 1.30817994e-01f, -3.23206112e-02f, 5.36187179e-02f, -1.83930025e-02f,
  3.49133275e-02f, 1.37857050e-01f, -1.36443928e-01f, 9.25715044e-02f, 3.13944854e-02f, 4.43556458e-02f, -1.58568263e-01f, 1.82753876e-01f, 3.94000746e-02f, -2.42329091e-02f,
  4.64524701e-02f, -2.50286795e-02f, 1.50404230e-01f, 6.28874870e-03f, 6.10720320e-03f, -1.20250776e-01f, -1.69272460e-02f, 8.59231204e-02f, 2.58582383e-02f, 1.10143527e-01f,
  1.42685786e-01f, -2.84197945e-02f, -9.38221440e-02f, -3.99252176e-02f, 1.29881114e-01f, 5.96955866e-02f, -1.07902952e-03f, 1.98582541e-02f, 9.62834433e-02f, 5.59493937e-02f,
  5.16482070e-02f, -1.91239621e-02f, 6.98669776e-02f, -1.08533576e-01f, 9.29361433e-02f, -3.48004187e-03f, -1.44433752e-02f, 5.95935397e-02f, 1.38286799e-01f, 1.55438051e-01f,
  8.63076374e-02f, 9.81701836e-02f, -1.18591497e-02f, 2.18718946e-01f, -2.72066072e-02f, 1.13660663e-01f, -4.19248492e-02f, -1.21278629e-01f, -1.54892625e-02f, -2.07875967e-01f,
  2.04865616e-02f, -6.54443651e-02f, -2.75203902e-02f, -1.16587147e-01f, -1.09350920e-01f, 5.70586510e-02f, -1.96205765e-01f, 2.30759397e-01f, -1.32635742e-01f, 1.11128546e-01f,
  1.59194246e-01f, -8.81061554e-02f, -3.82356308e-02f, -2.06464622e-02f, -7.72913471e-02f, -4.02056202e-02f, -1.81891099e-01f, -6.11650795e-02f, 3.64135182e-03f, -1.15808256e-01f,
  -1.90033559e-02f, -1.25361800e-01f, -2.83338517e-01f, 1.82923257e-01f, 4.07355949e-02f, -1.15760006e-01f, -1.66156851e-02f, 8.14841017e-02f, 1.63337424e-01f, 2.71914732e-02f,
  -3.69057134e-02f, -1.04979396e-01f, 1.82549153e-02f, 1.09344013e-01f, 4.34084376e-03f, 2.37258263e-02f, -5.74564524e-02f, 8.57674554e-02f, 1.24745993e-02f, -1.08732387e-01f,
  -1.48649784e-02f, 5.09321205e-02f, 3.86867486e-02f, -2.13729180e-02f, 4.82255546e-03f, -2.59365439e-02f, 7.47275213e-03f, -3.84872034e-02f, 2.18257874e-01f, 8.81624967e-03f,
  9.88579094e-02f, 3.20746936e-02f, 5.70072494e-02f, 7.33961537e-02f, 1.62919853e-02f, 1.09738410e-02f, 1.05834998e-01f, -6.39564991e-02f, 1.63779035e-01f, -1.10594720e-01f,
  1.39622518e-03f, 1.00331632e-02f, 3.17519973e-03f, -3.95725761e-03f, 8.54250342e-02f, 4.00618091e-02f, -2.48148013e-02f, 8.41099620e-02f, 2.25357600e-02f, -1.54610239e-02f,
  3.10999881e-02f, -3.03051546e-02f, 1.49664171e-02f, -5.74504398e-02f, 4.32687486e-03f, -4.38080169e-02f, 9.97872651e-02f, -2.18596291e-02f, -3.88658419e-03f, 4.16491665e-02f,
  4.15999927e-02f, -6.07421771e-02f, -1.94146745e-02f, 6.01290204e-02f, -8.36394876e-02f, 3.70753258e-02f, 4.15526740e-02f, -1.68847498e-02f, 5.81636019e-02f, 1.99939758e-02f,
  6.50022477e-02f, -5.11778779e-02f, -5.07017337e-02f, 6.60084635e-02f, 2.25378480e-02f, 8.74475986e-02f, -6.99917786e-03f, 7.15088919e-02f, 1.16676979e-01f, 7.46274889e-02f,
  -5.16712945e-03f, 4.09103557e-02f, -9.91899520e-02f, -9.64372326e-03f, -5.74811436e-02f, -6.19058087e-02f, 6.01960309e-02f, -5.72220273e-02f, 9.33530033e-02f, 8.41060132e-02f,
  3.95435132e-02f, 4.26988080e-02f, 8.27301741e-02f, -5.03524989e-02f, -7.41234720e-02f, -1.13526404e-01f, -4.64144200e-02f, 6.12956993e-02f, 1.72170028e-02f, -9.55612957e-02f,
  -7.65370503e-02f, 1.02401048e-01f, 1.71959680e-02f, -6.26438558e-02f, 1.43525591e-02f, -4.85037453e-02f, 1.06756918e-01f, 5.30483685e-02f, -6.86573237e-02f, -1.01384215e-01f,
  -4.32304516e-02f, 6.69278279e-02f, 1.42626874e-02f, -8.38797633e-03f, 1.53339375e-02f, 5.01083173e-02f, -6.30308390e-02f, -8.31895918e-02f, -4.65412028e-02f, -2.07675528e-02f,
  -7.20735863e-02f, -1.31136263e-02f, -9.70623177e-03f, 1.58657730e-02f, -4.72998284e-02f, -2.86198966e-02f, -8.02161917e-02f, -9.35071260e-02f, -3.50789689e-02f, -9.87127945e-02f,
  1.34902168e-02f, 3.16961110e-02f, 4.91927639e-02f, -1.22973315e-01f, -9.17545408e-02f, -5.49616553e-02f, 2.31481139e-02f, 1.07712731e-01f, 1.12089347e-02f, -1.80030353e-02f,
  3.95322479e-02f, 8.25030059e-02f, -3.35451029e-02f, 3.63353156e-02f, 2.94319075e-03f, 3.41690443e-02f, 5.24374582e-02f, 4.16009910e-02f, 7.42337331e-02f, -1.21980235e-02f,
  -9.01468098e-03f, 7.06698447e-02f, -7.30812699e-02f, 1.02123380e-01f, 4.02120836e-02f, -6.25096262e-02f, 1.06732830e-01f, 6.20341375e-02f, -3.14333327e-02f, -3.83310653e-02f,
  8.68177265e-02f, -5.82554080e-02f, -2.98646241e-02f, 2.92740744e-02f, 1.88970212e-02f, -1.71754416e-02f, 8.48450735e-02f, 3.00636701e-02f, -4.03247289e-02f, -3.71661521e-02f,
  1.08137891e-01f, -3.08744318e-04f, -8.33132863e-02f, -2.32405402e-02f, -4.56237830e-02f, 1.13569554e-02f, 1.07702315e-01f, -3.08999196e-02f, -4.56167869e-02f, 1.19756358e-02f,
  -1.83349021e-03f, -1.28006507e-02f, -1.10536247e-01f, 2.35116482e-02f, 1.21027805e-01f, 9.70486552e-03f, 1.04988188e-01f, 5.06122224e-02f, -2.14775112e-02f, 1.72868520e-01f,
  1.28697738e-01f, -5.87363436e-04f, 7.55615160e-02f, 1.12729922e-01f, 6.49221689e-02f, -2.43073031e-02f, 8.87076333e-02f, -3.55069190e-02f, -8.13572332e-02f, 1.05706006e-02f,
  7.54179759e-03f, -2.58452771e-03f, -8.69146287e-02f, 1.58112854e-01f, 1.09653808e-01f, 9.80022624e-02f, 4.91576456e-03f, 1.74363703e-03f, -3.26785073e-02f, 1.06484361e-01f,
  4.89660837e-02f, 1.60659909e-01f, 1.18138611e-01f, 1.43700674e-01f, 1.30700916e-02f, -1.23887730e-03f, -2.45236196e-02f, 3.40492167e-02f, 1.05383575e-01f, -1.07730471e-01f,
  8.15808848e-02f, -6.46516159e-02f, 1.72266755e-02f, 8.29824433e-02f, -1.10180326e-01f, -1.55562669e-01f, -1.57450270e-02f, 1.65097881e-02f, -1.54686391e-01f, 1.29902707e-02f,
  -4.32553850e-02f, 4.47949488e-03f, -6.23580394e-03f, 1.62625343e-01f, 6.38549253e-02f, -2.78581847e-02f, -6.90616593e-02f, 1.34390285e-02f, 1.31174475e-01f, 8.80200714e-02f,
  4.09937538e-02f, -1.14035457e-01f, 1.03537984e-01f, 1.48947582e-01f, -4.47326750e-02f, -2.99623294e-04f, -3.52393761e-02f, -4.61571552e-02f, 1.29110187e-01f, -1.20415553e-01f,
  -1.20421953e-01f, -1.75074518e-01f, -1.07628204e-01f, -3.99102122e-02f, -2.45684548e-03f, 3.41898017e-02f, -5.01964018e-02f, 9.64647904e-02f, -2.91448310e-02f, -8.58679265e-02f,
  2.10951577e-04f, -1.14622191e-01f, 1.27012223e-01f, -6.25116900e-02f, 2.21354682e-02f, -1.03625081e-01f, 1.37127042e-01f, 1.17225073e-01f, 2.01920047e-03f, 6.45770952e-02f,
  -1.23379506e-01f, -9.33376849e-02f, 6.02695756e-02f, 1.24937288e-01f, 2.85770968e-02f, 6.30699769e-02f, 5.50832786e-02f, 9.66402516e-02f, 4.10520211e-02f, 8.36600829e-03f,
  -7.04001784e-02f, 3.69350202e-02f, 5.16439192e-02f, 3.33945714e-02f, 4.29282431e-03f, -4.08536829e-02f, 2.60982681e-02f, -7.89992735e-02f, 1.20453842e-01f, 1.46889970e-01f,
  1.18506856e-01f, -6.12970181e-02f, 3.32175978e-02f, 9.80729747e-05f, -2.78223827e-02f, 1.96623709e-02f, 5.84925115e-02f, -5.32177277e-02f, -3.16530466e-02f, -3.71683501e-02f,
  2.22467016e-02f, -4.82977293e-02f, -4.49930429e-02f, -3.79287004e-02f, 6.54913411e-02f, 3.68762985e-02f, 5.14482148e-02f, -1.13718966e-02f, 8.03283378e-02f, 4.33665188e-03f,
  4.80703898e-02f, 2.07153577e-02f, -7.01574460e-02f, 3.80761884e-02f, 2.30128411e-02f, 6.56356215e-02f, -7.21284822e-02f, -9.11334082e-02f, -1.94915272e-02f, -5.57564311e-02f,
  -3.37221138e-02f, 4.73348238e-02f, 8.58514532e-02f, -6.99073598e-02f, 3.87101062e-02f, 7.85619542e-02f, 1.96417216e-02f, -2.11598841e-03f, -6.59338385e-02f, -2.31588371e-02f,
  5.88148013e-02f, -5.72219631e-03f, 4.40402403e-02f, -1.34277083e-02f, 2.54653897e-02f, 7.36416131e-02f, -5.26942015e-02f, -2.63281483e-02f, -9.15180668e-02f, 4.66867425e-02f,
  -2.65747625e-02f, -5.76942936e-02f, -6.21304400e-02f, 4.65984605e-02f, -2.61874441e-02f, -2.92198919e-02f, -2.38998197e-02f, 2.25122739e-02f, -6.60736039e-02f, -5.33544682e-02f,
  -6.88628927e-02f, 1.15155056e-02f, -3.51643413e-02f, 9.99773815e-02f, 4.86596711e-02f, -5.58718070e-02f, -6.14806451e-02f, -6.35839701e-02f, 1.13128655e-01f, -8.91121030e-02f,
  7.58706927e-02f, -1.35324812e-02f, 6.98472187e-02f, 2.49751043e-02f, -2.62116585e-02f, -7.36228153e-02f, 7.90999457e-02f, -5.91138192e-02f, -6.32484928e-02f, 7.23992847e-03f,
  -1.38462484e-02f, -6.23048954e-02f, -7.49215186e-02f, -5.27902432e-02f, -6.31123483e-02f, 4.17783894e-02f, -5.68351597e-02f, 2.64442153e-02f, -7.15746805e-02f, -8.24093539e-03f,
  -5.02514057e-02f, 4.92035747e-02f, -2.91617010e-02f, -8.83833766e-02f, -6.57753795e-02f, 6.59563467e-02f, -6.91782087e-02f, 3.47455740e-02f, -7.81157315e-02f, -8.86673629e-02f,
  -8.48945007e-02f, 4.07708921e-02f, 7.07099289e-02f, 3.37216482e-02f, 1.46611268e-03f, -1.45439263e-02f, -3.06713469e-02f, -4.68608774e-02f, 7.43236691e-02f, 8.41325521e-02f,
  2.36441139e-02f, -8.81135911e-02f, -5.97358756e-02f, -7.25731403e-02f, 4.35407795e-02f, -5.97056933e-02f, -1.80757884e-02f, 8.01709443e-02f, -8.30416903e-02f, -3.66930477e-02f,
  -2.28770413e-02f, -3.57920527e-02f, -3.48863713e-02f, -6.48681670e-02f, 2.77853403e-02f, -2.38417592e-02f, 6.43441156e-02f, -1.45084197e-02f, 3.62127312e-02f, -2.23700562e-03f,
  7.49006942e-02f, -6.36571273e-02f, 4.80609946e-02f, 6.69663996e-02f, -6.95418268e-02f, 4.11660559e-02f, 1.46949245e-02f, 2.30950098e-02f, 1.04497887e-01f, 1.54608503e-01f,
  1.18860535e-01f, 1.60134166e-01f, -4.72026691e-02f, -4.60809432e-02f, -1.68149304e-02f, 8.55596662e-02f, 8.56805593e-02f, 1.36670277e-01f, 4.90583032e-02f, -9.12172999e-03f,
  -1.27855707e-02f, -2.86931507e-02f, 9.48344469e-02f, 9.67595950e-02f, 6.82380572e-02f, -5.54252379e-02f, 4.89496812e-02f, 1.85169205e-02f, 6.85160309e-02f, -4.58928086e-02f,
  -3.74689512e-02f, -2.41358252e-03f, 1.07845940e-01f, -3.66284326e-02f, 3.31104659e-02f, 6.27795467e-03f, 2.45547201e-02f, 1.60810366e-01f, 9.20622274e-02f, -5.46857761e-03f,
  8.00571740e-02f, 1.29175708e-01f, 3.02167311e-02f, 8.96407440e-02f, 6.28472939e-02f, 5.65714203e-02f, 4.38175444e-03f, 3.85391191e-02f, 1.04445599e-01f, -1.71624199e-02f,
  4.53870706e-02f, -2.01557036e-02f, 1.56560596e-02f, 8.31851661e-02f, -1.87044649e-03f, 1.36996806e-01f, -2.48114131e-02f, -8.38636309e-02f, -4.39689402e-03f, 4.13931124e-02f,
  4.70846482e-02f, -4.95381169e-02f, 4.80761155e-02f, -2.40004156e-03f, 1.42085806e-01f, 1.07804775e-01f, 8.84437338e-02f, 1.48063019e-01f, 5.80349378e-02f, 4.73524556e-02f,
  7.38646761e-02f, -1.52641058e-01f, 1.33943647e-01f, -1.51054293e-01f, -1.91296354e-01f, -2.14254744e-02f, 3.30197960e-02f, 6.41722605e-03f, 9.36419144e-02f, -1.55882552e-01f,
  9.14801098e-03f, 3.48568223e-02f, 9.58058238e-03f, -4.27328609e-02f, -2.89775671e-05f, 2.17069034e-02f, 9.09774750e-02f, 5.67765608e-02f, 1.83502570e-01f, 1.43573023e-02f,
  5.18801846e-02f, 8.19562674e-02f, 1.63091391e-01f, -7.25808516e-02f, -9.64971352e-03f, -4.28045653e-02f, -1.71298325e-01f, 7.71134975e-04f, 1.21452324e-01f, 8.30736309e-02f,
  -1.23748742e-01f, 6.67977333e-02f, 1.67763736e-02f, -1.16156518e-01f, 7.56307680e-04f, -9.36846528e-03f, -1.94220915e-02f, -3.33432220e-02f, -4.28459086e-02f, -5.16277179e-02f,
  5.53820282e-02f, 3.81137547e-03f, -7.71508878e-03f, 9.90458354e-02f, -2.26074234e-02f, 8.93160999e-02f, 4.75615598e-02f, 8.11571106e-02f, -1.24351256e-01f, -2.80953688e-03f,
  -1.08456284e-01f, -1.16263442e-01f, 8.52523185e-03f, 1.40671417e-01f, 6.15298301e-02f, -5.18558472e-02f, -1.17655165e-01f, 4.35443185e-02f, 1.10345092e-02f, 2.00341791e-02f,
  5.33636324e-02f, 7.80707151e-02f, -9.77783799e-02f, 7.58026019e-02f, -4.28542448e-03f, 4.55366932e-02f, 4.97559495e-02f, 3.37221175e-02f, 3.30217741e-02f, 9.44235474e-02f,
  -1.02816364e-02f, 1.22182211e-02f, 1.13962933e-01f, 1.04782283e-01f, -2.86692400e-02f, -5.92118651e-02f, 2.71391380e-03f, 1.06251962e-01f, 9.84430239e-02f, 1.82532355e-01f,
  7.33869821e-02f, -3.28672305e-02f, 3.07475980e-02f, 3.02016269e-02f, 8.03718492e-02f, 5.69964871e-02f, 5.84679767e-02f, 1.56097025e-01f, 3.20678428e-02f, 3.61505412e-02f,
  1.80040449e-02f, 8.90517607e-02f, 1.55282229e-01f, 1.07639180e-02f, 8.72009918e-02f, 1.38952225e-01f, 7.89421722e-02f, -1.59452371e-02f, 5.76675124e-02f, 3.83876190e-02f,
  -1.70408152e-02f, 1.66984294e-02f, 1.16656661e-01f, 1.25290044e-02f, 4.35852930e-02f, 1.99451894e-02f, 4.58534099e-02f, 1.52322307e-01f, 2.17672512e-01f, 1.08493201e-01f,
  1.42793238e-01f, 3.76589075e-02f, 1.31849021e-01f, 1.78457156e-01f, 3.61522450e-03f, 1.81845576e-02f, -1.70243368e-01f, -1.26541778e-01f, 1.49925118e-02f, 9.56579205e-03f,
  8.66136029e-02f, -1.44778341e-01f, -6.88319877e-02f, -1.46800317e-02f, 1.76222667e-01f, -5.92630357e-02f, 7.37857074e-02f, -1.79330129e-02f, 8.32087994e-02f, 1.61256373e-01f,
  -1.66799471e-01f, 9.80056375e-02f, 8.70083496e-02f, -1.60418563e-02f, -3.57693918e-02f, -2.96804085e-02f, 8.22262466e-02f, 1.38524905e-01f, 5.57610989e-02f, 8.73391423e-03f,
  2.32042558e-02f, 9.38247442e-02f, -7.18795061e-02f, 1.00667655e-01f, -5.32632619e-02f, -1.05971776e-01f, -1.21121265e-01f, -3.03585678e-02f, 3.16587929e-03f, 9.18869972e-02f,
  3.05474885e-02f, -2.24702414e-02f, -1.45844653e-01f, 7.79727399e-02f, 1.25897899e-01f, -2.11642966e-01f, -1.33535773e-01f, 8.35031196e-02f, 1.91195592e-01f, 1.42034680e-01f,
  6.92554330e-03f, 2.95474194e-02f, -1.06812030e-01f, -1.46716863e-01f, -6.84013888e-02f, -9.39156935e-02f, 2.69234013e-02f, 2.18377188e-02f, 3.94197553e-02f, -4.63847108e-02f,
  1.51390145e-02f, -1.06139816e-01f, -8.46507177e-02f, -2.83810385e-02f, 1.41648501e-02f, -7.47978240e-02f, -5.07437289e-02f, -8.78494456e-02f, 4.47628759e-02f, -2.71305870e-02f,
  1.18713796e-01f, 1.04177617e-01f, -1.03229590e-01f, 9.47240461e-03f, 1.51287153e-01f, 4.22219113e-02f, 7.28887767e-02f, -4.18944936e-03f, 1.48086026e-01f, -8.67064446e-02f,
  5.30574434e-02f, 6.22892193e-02f, 1.16803169e-01f, -4.86804321e-02f, 6.69112615e-03f, 1.37425372e-02f, 4.18601325e-04f, 1.21881455e-01f, -5.74697219e-02f, 3.38774547e-02f,
  7.68354088e-02f, 4.87243608e-02f, 6.67632148e-02f, 9.55829099e-02f, 5.18540144e-02f, -4.99529392e-03f, 8.12928677e-02f, -7.26200938e-02f, 1.63154937e-02f, -5.49524184e-03f,
  1.24191239e-01f, 7.56794885e-02f, 4.99796830e-02f, 2.42970567e-02f, 9.37199444e-02f, -2.53740530e-02f, 1.28242392e-02f, 7.75440335e-02f, 1.21005036e-01f, 2.17952840e-02f,
  3.78499106e-02f, 1.08117037e-01f, -4.00828421e-02f, 1.08445257e-01f, 1.00198708e-01f, -2.21449193e-02f, 1.16464853e-01f, 9.22283605e-02f, 7.37692863e-02f, -2.80792336e-03f,
  1.44361600e-03f, 7.34048337e-02f, -9.64192674e-02f, -5.95808104e-02f, -4.19744439e-02f, -6.63509313e-03f, -3.14459018e-02f, -7.52679035e-02f, -3.12127452e-02f, -9.24966931e-02f,
  4.17280458e-02f, 1.47631094e-01f, 8.59982744e-02f, -6.15699142e-02f, 3.19282827e-03f, 5.26644289e-02f, -7.91653395e-02f, 5.44705838e-02f, -4.08816002e-02f, -5.68723120e-02f,
  1.79412086e-02f, -1.79601759e-02f, 6.41487166e-02f, -3.06126568e-02f, -7.79242292e-02f, 1.00736963e-02f, 6.17999211e-03f, -3.90315764e-02f, 1.15249343e-01f, -1.60421029e-01f,
  -1.07588321e-01f, 4.29631248e-02f, -1.01279043e-01f, -9.11721587e-02f, 1.70106329e-02f, -1.32258952e-01f, -9.30410903e-03f, -1.37331292e-01f, -4.41967919e-02f, 6.12164997e-02f,
  3.80766578e-02f, -6.88359141e-02f, -5.81006482e-02f, -1.26566321e-01f, 7.45321140e-02f, 7.89720193e-02f, -1.06531186e-02f, 4.51333225e-02f, -2.81430744e-02f, -9.97338891e-02f,
  8.62739608e-02f, -6.36892617e-02f, -4.54356857e-02f, -1.30449757e-01f, 4.38285880e-02f, 1.30486712e-01f, -1.10420659e-01f, 3.17755379e-02f, 1.20395511e-01f, 1.29932974e-04f,
  -1.68112032e-02f, 6.70166463e-02f, 1.22691048e-02f, 2.02255547e-02f, 3.12771946e-02f, 6.23234697e-02f, 1.26733631e-01f, 2.99727675e-02f, -7.84858763e-02f, 4.46396917e-02f,
  3.44684087e-02f, -3.44774909e-02f, -5.20451441e-02f, 9.77200642e-02f, -8.80159624e-03f, -4.77800034e-02f, -6.18662983e-02f, 8.57016444e-02f, -9.09277275e-02f, 6.84348345e-02f,
  5.26974313e-02f, -1.57554876e-02f, -1.89859122e-02f, -2.71672811e-02f, -9.62101966e-02f, -1.64290126e-02f, -1.79979205e-02f, -1.88230928e-02f, 3.20850201e-02f, -6.13300949e-02f,
  1.05040818e-02f, 3.95603478e-03f, -2.78566014e-02f, 3.02918721e-02f, 2.15427931e-02f, 5.64650260e-03f, 8.76392499e-02f, -2.97033638e-02f, -1.36293732e-02f, 2.29912642e-02f,
  6.40706420e-02f, -2.66336594e-02f, 3.07675195e-03f, -7.70060625e-03f, 1.08137064e-01f, 8.46577138e-02f, 2.44731847e-02f, -4.34469990e-02f, -2.97530480e-02f, 2.80448832e-02f,
  -2.53951177e-02f, 1.02458365e-01f, -7.52972141e-02f, -3.30995433e-02f, 5.34591451e-02f, 1.28404312e-02f, -5.66512868e-02f, -2.65271589e-02f, 1.31548205e-02f, 6.10828958e-02f,
  3.33340652e-02f, 8.18843767e-02f, -5.24772778e-02f, -6.04024753e-02f, 3.05721350e-02f, 2.33701020e-02f, -5.78457564e-02f, -4.11533788e-02f, 7.76712768e-05f, -4.40472104e-02f,
  2.49251686e-02f, 3.24506275e-02f, 8.25233161e-02f, -6.81871898e-05f, -1.37135256e-02f, 4.08626301e-03f, 8.39110091e-02f, -4.18367200e-02f, 6.00807257e-02f, 6.69132769e-02f,
  2.41091754e-02f, 9.46755037e-02f, -4.68840897e-02f, -1.79406777e-02f, -5.48660681e-02f, 7.08473995e-02f, -3.28525156e-02f, -8.04957598e-02f, -7.22166663e-03f, -2.46207453e-02f,
  -2.80109402e-02f, -1.59529094e-02f, -2.70401873e-02f, 1.06969491e-01f, 9.93200205e-03f, 9.93493795e-02f, 1.75683126e-02f, 1.65505335e-02f, 2.01136507e-02f, 4.37683277e-02f,
  9.75438431e-02f, -4.31114398e-02f, 9.54487398e-02f, -2.46762019e-02f, 4.93166409e-02f, 3.17606442e-02f, -1.47855654e-02f, -1.80331059e-02f, -9.11717564e-02f, -6.68780208e-02f,
  7.13948235e-02f, -3.56919169e-02f, 5.85880689e-02f, -2.66901478e-02f, -4.66002002e-02f, 1.00851839e-03f, 1.63411517e-02f, -2.10439004e-02f, 2.41375864e-02f, -7.05083758e-02f,
  -1.36835556e-02f, 4.36816253e-02f, 2.36193482e-02f, -9.12456512e-02f, -1.46112917e-02f, -1.16275912e-02f, -9.58863925e-03f, 3.54164988e-02f, 9.76832733e-02f, 6.98999241e-02f,
  2.14858875e-02f, -6.58587366e-02f, 3.14742401e-02f, 8.52411091e-02f, -3.82982045e-02f, -6.41668364e-02f, 4.17184569e-02f, -5.96564300e-02f, 4.76983599e-02f, 4.75400500e-02f,
  3.85085233e-02f, 9.07384530e-02f, 6.11008108e-02f, 7.88725764e-02f, -4.34511341e-02f, -7.59533569e-02f, 1.35453651e-02f, 2.04060227e-04f, 7.64843896e-02f, 8.80553126e-02f,
  -1.67966988e-02f, 4.95535918e-02f, 1.19435659e-03f, 7.96645880e-03f, 4.05014381e-02f, -4.19160165e-02f, 6.38026223e-02f, -1.89613700e-02f, -1.53874429e-02f, 7.79882818e-02f,
  4.28217649e-02f, 2.47242656e-02f, -1.40252337e-01f, 6.83735386e-02f, 9.16376263e-02f, -1.00531848e-02f, -1.49274636e-02f, 8.84803757e-02f, 1.40317082e-01f, -3.81239094e-02f,
  1.07419215e-01f, 1.12760611e-01f, 8.09912980e-02f, 7.29612410e-02f, 8.42024684e-02f, -1.85596815e-03f, -2.31839307e-02f, 8.50800872e-02f, 4.85169664e-02f, 7.64296949e-02f,
  -6.49341091e-04f, 6.30630180e-02f, 3.26849632e-02f, -1.85275786e-02f, 3.80406454e-02f, -9.07532126e-02f, 5.76678663e-02f, 1.44284852e-02f, 8.21865648e-02f, -7.14042261e-02f,
  -3.84132452e-02f, 9.59108323e-02f, 5.92144765e-02f, 2.96060666e-02f, -2.20813267e-02f, -2.90298536e-02f, -2.18520239e-02f, 7.37323910e-02f, 1.95726722e-01f, 9.37766358e-02f,
  1.00844599e-01f, -5.92887066e-02f, 8.16481560e-02f, 6.59879446e-02f, -5.14645353e-02f, -3.81783098e-02f, 1.04418628e-01f, -6.78069046e-05f, 1.05229750e-01f, -7.54426420e-02f,
  1.26346797e-01f, 8.46836716e-02f, -1.18252777e-01f, 1.07351388e-03f, 1.50253877e-01f, 7.88610578e-02f, -1.38690367e-01f, -8.46916959e-02f, -7.37407478e-03f, -4.50377539e-02f,
  -1.75278634e-01f, 1.33630887e-01f, -1.63110271e-02f, 1.74608771e-02f, 3.20393890e-02f, 8.03935379e-02f, 2.30939820e-01f, -2.20749844e-02f, -5.36204167e-02f, -2.50535905e-01f,
  -1.02314375e-01f, 1.86640769e-01f, -3.19831856e-02f, -6.42481167e-03f, 1.38809815e-01f, 1.17082581e-01f, -7.16841221e-02f, -7.91957155e-02f, -5.02455793e-02f, 1.25693813e-01f,
  -1.09653421e-01f, -7.05791041e-02f, -1.34098111e-02f, 7.76092634e-02f, -8.39424357e-02f, 5.94455600e-02f, -3.06764990e-02f, 1.52336275e-02f, 9.28283483e-02f, -4.58212793e-02f,
  5.48732355e-02f, -2.88833678e-02f, 8.76803324e-02f, -2.26736128e-01f, -9.90029201e-02f, 2.33516961e-01f, 1.62271075e-02f, 1.40704289e-01f, 4.33469787e-02f, -4.44486476e-02f,
  -6.70078620e-02f, -3.99783514e-02f, -1.08915335e-02f, 8.71000886e-02f, -5.20926863e-02f, -5.99759556e-02f, 3.69399339e-02f, 5.36821820e-02f, -6.72331359e-03f, 1.11532077e-01f,
  5.77923208e-02f, -3.22929211e-02f, 1.39202818e-01f, 5.28000593e-02f, 6.13920055e-02f, -1.20438106e-01f, -8.60267282e-02f, 1.15312882e-01f, 1.66758984e-01f, 4.24794778e-02f,
  8.87819845e-03f, -1.20116305e-02f, 5.55631109e-02f, 6.34910446e-03f, 8.97083655e-02f, -7.14830682e-02f, 3.51547003e-02f, 4.47826385e-02f, 4.44974750e-02f, 3.16077545e-02f,
  3.85288373e-02f, 2.26380871e-04f, 1.36865154e-02f, 8.71822536e-02f, 4.03375886e-02f, 5.11006638e-02f, 6.16046079e-02f, 1.21979706e-01f, -4.34096763e-03f, 1.10227987e-01f,
  4.19000536e-02f, -4.68306802e-02f, 4.88218702e-02f, 2.75761429e-02f, -7.26049319e-02f, 1.06487572e-02f, 3.40425372e-02f, 1.23574153e-01f, 3.48357782e-02f, 8.37499723e-02f,
  5.62418960e-02f, 4.62310612e-02f, 6.33231848e-02f, 5.52368946e-02f, 3.76353860e-02f, 1.15623986e-02f, 1.65603124e-02f, -1.13234157e-02f, 9.30095837e-02f, 2.70535983e-02f,
  4.28720824e-02f, -7.32642263e-02f, 2.34250929e-02f, 6.50747027e-03f, -1.37073162e-03f, -8.87699611e-03f, 4.05286402e-02f, -4.19267081e-02f, 1.15590662e-01f, 3.28893366e-04f,
  -6.35846481e-02f, 2.41593774e-02f, 4.55909893e-02f, -5.89697361e-02f, -3.72368507e-02f, 1.71333980e-02f, -1.62033811e-02f, -1.75519940e-02f, 5.40806986e-02f, -1.61329843e-02f,
  5.50470687e-02f, 2.00666245e-02f, 1.03475943e-01f, 1.05159104e-01f, 5.92594594e-02f, 1.45723335e-02f, -5.01084849e-02f, -7.06958305e-03f, -5.82000725e-02f, 5.01992404e-02f,
  -1.59719940e-02f, -7.38995597e-02f, 1.55910909e-01f, -6.96860626e-02f, -3.68636101e-02f, -5.25390320e-02f, 7.10003600e-02f, 1.36770681e-01f, -7.39603117e-02f, 1.73399970e-02f,
  -3.70987840e-02f, 6.75979331e-02f, -8.32128897e-03f, -1.78333074e-01f, 1.23839192e-01f, -3.10244262e-02f, -6.03364222e-02f, 2.46707760e-02f, -9.09763351e-02f, -1.43425196e-01f,
  9.54408050e-02f, 9.20279920e-02f, -1.07043043e-01f, -1.53447732e-01f, 1.07504629e-01f, 7.93434680e-02f, 2.72287019e-02f, -1.04737412e-02f, 1.32746259e-02f, -3.80723737e-02f,
  -6.24686629e-02f, -7.48866200e-02f, -5.27505092e-02f, 1.90055277e-02f, -9.54067260e-02f, 9.24198180e-02f, -2.34979633e-02f, 6.63292333e-02f, 9.43212584e-02f, -1.39797875e-03f,
  -7.48204738e-02f, 2.63359509e-02f, -3.93548459e-02f, 3.62549201e-02f, 5.03454590e-03f, -1.75716877e-02f, 8.23023245e-02f, 3.66341360e-02f, 7.15024322e-02f, -6.13664687e-02f,
  -2.34355517e-02f, 8.30765348e-03f, -4.63136565e-03f, -6.74814433e-02f, 9.18026641e-03f, -1.30050546e-02f, -5.13828099e-02f, -5.26954010e-02f, -1.02766249e-02f, -6.49568588e-02f,
  -7.17042685e-02f, -6.49000779e-02f, -3.34404828e-03f, 9.57380459e-02f, 6.36353791e-02f, 4.78343433e-03f, -7.16360435e-02f, 6.02044985e-02f, 2.33016945e-02f, -2.41469573e-02f,
  8.45403224e-02f, 3.08173150e-02f, 1.22918501e-01f, 4.01048101e-02f, -5.08146286e-02f, 6.67441115e-02f, 6.22747578e-02f, -4.55506779e-02f, 3.13855261e-02f, -8.42254832e-02f,
  4.36049365e-02f, -5.75255267e-02f, 8.84686131e-03f, 6.61774203e-02f, -4.29564938e-02f, -2.30669929e-03f, -1.97619963e-02f, 1.38818234e-01f, -8.45467858e-03f, 3.92377786e-02f,
  6.92516640e-02f, -7.75464922e-02f, 8.49662870e-02f, 2.60456447e-02f, -2.11421773e-02f, 9.54630524e-02f, -5.47704883e-02f, -8.34410116e-02f, 9.51629877e-02f, 1.70724168e-02f,
  5.66325895e-02f, -3.18884142e-02f, 9.67394635e-02f, -5.04732132e-02f, -4.39377129e-02f, 8.09433758e-02f, 9.49075818e-02f, -8.29160511e-02f, 8.58127028e-02f, 3.53338718e-02f,
  7.23923296e-02f, -1.31903356e-03f, 6.69584423e-02f, -9.67661813e-02f, 1.17159247e-01f, 3.32883112e-02f, 1.24153420e-01f, -2.60387789e-02f, 4.88464646e-02f, 4.77451971e-03f,
  -2.40861606e-02f, -4.66947109e-02f, 9.34968367e-02f, 5.63778132e-02f, 8.92120525e-02f, 2.83639319e-02f, -5.51522709e-02f, -1.07220896e-01f, -1.15663975e-01f, 1.60506759e-02f,
  1.05489612e-01f, -1.61057115e-02f, -1.41962012e-02f, -7.09403455e-02f, -1.36424722e-02f, -1.63521841e-01f, 2.43975725e-02f, 4.88365553e-02f, 3.60922851e-02f, -1.01457514e-01f,
  2.46266425e-02f, -1.86479408e-02f, -1.34499311e-01f, 4.18742821e-02f, 3.84587273e-02f, 1.16971195e-01f, -3.86530198e-02f, 1.33864090e-01f, 9.14612710e-02f, 1.19555898e-01f,
  7.56441653e-02f, -8.61889273e-02f, -1.30520826e-02f, -7.18789026e-02f, 5.58294961e-03f, 9.65155140e-02f, 3.99792343e-02f, -1.48033276e-02f, 6.93979813e-03f, 6.56598061e-02f,
  -3.75286653e-03f, 2.75956411e-02f, 2.63273809e-03f, 1.24500394e-01f, -4.25606035e-02f, -4.85440418e-02f, -1.82559323e-02f, 1.00136884e-01f, -2.87133120e-02f, -5.73204197e-02f,
  -8.04921985e-02f, -7.91028664e-02f, -8.03457294e-03f, -1.48179317e-02f, -8.49148408e-02f, 4.32904065e-02f, 4.96104471e-02f, -8.60202089e-02f, 2.34968811e-02f, -7.54150823e-02f,
  -2.19225269e-02f, 6.75695688e-02f, 3.02567650e-02f, 6.77719936e-02f, -2.80403718e-02f, 4.80329506e-02f, -3.45934778e-02f, -2.96127759e-02f, -2.69946922e-02f, 5.24487272e-02f,
  8.97282287e-02f, -8.26572813e-03f, -3.98828685e-02f, -7.25083752e-03f, 6.66200072e-02f, -9.24538262e-03f, 6.66549429e-02f, -1.51856290e-03f, -3.35179679e-02f, 3.15947458e-02f,
  1.20232418e-01f, 5.40648699e-02f, -2.57240552e-02f, -3.54215428e-02f, 5.40861227e-02f, 2.78632063e-02f, 1.01172611e-01f, 9.43842977e-02f, -5.11843450e-02f, 5.30956574e-02f,
  1.19027004e-01f, 6.77973107e-02f, 8.76333788e-02f, -4.60023172e-02f, -1.20882485e-02f, -7.61104573e-04f, -5.76244704e-02f, -6.54594041e-03f, -2.62070708e-02f, 1.13706812e-01f,
  2.03368310e-02f, 1.61761083e-02f, -3.79363000e-02f, 2.72287913e-02f, -3.64195108e-02f, 1.26437126e-02f, 8.45317692e-02f, -5.97473457e-02f, 4.66246344e-02f, 6.63985834e-02f,
  -3.29906940e-02f, -3.63644585e-02f, -3.89324687e-02f, 1.00074433e-01f, 2.10435912e-02f, -4.38433103e-02f, 1.13506839e-02f, 2.28327718e-02f, 1.01202749e-01f, -2.25811582e-02f,
  6.20327750e-03f, 7.56346881e-02f, 6.75777793e-02f, -3.11864857e-02f, -6.93801269e-02f, -6.87504485e-02f, -1.78465303e-02f, -1.47988033e-02f, 4.37056087e-02f, -4.59328443e-02f,
  -7.57813305e-02f, -3.43979374e-02f, -7.89236277e-02f, 9.82709154e-02f, -4.32416750e-03f, 3.88711691e-02f, 1.24633899e-02f, -9.25178230e-02f, -5.04633710e-02f, -1.23514637e-01f,
  -5.06394766e-02f, 5.15135303e-02f, 8.90547633e-02f, -9.68423672e-03f, 1.11721009e-01f, -4.49677445e-02f, -4.94509935e-02f, -1.27445847e-01f, 1.23511970e-01f, -5.68573400e-02f,
  -9.17212293e-02f, -5.92630245e-02f, -2.36476138e-02f, 1.30506232e-02f, 9.94991660e-02f, -1.40992291e-02f, -1.12518281e-01f, -1.32107735e-01f, 1.40262008e-01f, -6.76116422e-02f,
  -8.38941801e-03f, 8.27580839e-02f, 2.41217334e-02f, 2.75669452e-02f, 2.50655506e-03f, -6.52307644e-02f, -9.05069634e-02f, 2.00236291e-02f, -5.83963431e-02f, 3.39977033e-02f,
  -8.40843376e-03f, 8.82815849e-03f, 3.43341045e-02f, 2.80086230e-02f, 4.50514741e-02f, -5.13060391e-02f, 3.74648981e-02f, -1.50499446e-02f, 8.84352177e-02f, 9.45886672e-02f,
  -1.51343802e-02f, 6.81411996e-02f, -5.55049255e-02f, 4.04387638e-02f, -4.71725725e-02f, -4.58599404e-02f, 5.50527722e-02f, 3.11408024e-02f, -2.63628569e-02f, 1.30271822e-01f,
  4.59122285e-02f, 6.24975972e-02f, -2.57864166e-02f, -1.43810902e-02f, -3.00796758e-02f, 8.53404254e-02f, -4.45628073e-03f, -6.25895187e-02f, -9.23312753e-02f, 8.13847929e-02f,
  1.54734692e-02f, 6.86236098e-02f, -1.99637413e-02f, 7.57254586e-02f, 1.11907877e-01f, 1.63279220e-01f, -1.04049303e-01f, 1.36110961e-01f, 2.39780042e-02f, 7.50222802e-02f,
  1.02380544e-01f, 1.33571148e-01f, 5.69547452e-02f, 8.85555446e-02f, 1.58959199e-02f, 5.66066466e-02f, -3.00639737e-02f, 1.07785515e-01f, 1.34136882e-02f, 3.65601517e-02f,
  9.40892920e-02f, -2.76946928e-02f, 1.72185048e-01f, 8.36966336e-02f, 1.59033618e-04f, -3.39867808e-02f, -3.59754148e-03f, -6.96507022e-02f, -1.15566932e-01f, 2.75397263e-02f,
  9.64800268e-02f, 1.23389624e-02f, -4.40063560e-03f, 8.61713365e-02f, 1.86575726e-02f, -1.39084400e-03f, 6.86915070e-02f, 1.27234250e-01f, 5.42351231e-02f, 1.01292804e-01f,
  -9.58993658e-03f, 7.77992606e-02f, 1.08398542e-01f, 4.53584008e-02f, 7.37591684e-02f, 2.50492222e-03f, 3.21522877e-02f, -5.53122237e-02f, -7.24344254e-02f, 8.01860020e-02f,
  2.51844320e-02f, -2.53703035e-02f, -3.76114361e-02f, 4.31244932e-02f, 1.17801512e-02f, -9.98454392e-02f, 1.07954770e-01f, 1.75123826e-01f, 1.25390962e-01f, 1.42715126e-01f,
  -2.15232912e-02f, 1.03718139e-01f, -6.30149469e-02f, 1.49208203e-01f, 3.06241978e-02f, -1.09346755e-01f, 1.27870336e-01f, -6.19127564e-02f, -1.34360880e-01f, -1.58826917e-01f,
  1.21156648e-01f, 1.35519654e-01f, 1.26930540e-02f, -1.03623541e-02f, -1.51146889e-01f, -6.80151433e-02f, -1.28946286e-02f, -9.17803962e-03f, 3.60895023e-02f, -1.02430627e-01f,
  2.83599887e-02f, -6.01323470e-02f, -1.50428503e-03f, -1.41053021e-01f, 1.13017559e-01f, -5.61342807e-03f, 2.95916069e-02f, -1.25705957e-01f, 1.02814652e-01f, 1.03269525e-01f,
  -1.62146110e-02f, -3.57484743e-02f, 7.38171339e-02f, 8.83530900e-02f, -1.50927439e-01f, -9.83533710e-02f, 6.56870231e-02f, 1.22898005e-01f, -7.61138871e-02f, 1.31403163e-01f,
  -5.99645935e-02f, -3.15083750e-02f, 3.57375704e-02f, 3.96771133e-02f, -1.08027868e-01f, 2.46373564e-02f, -7.33631402e-02f, 2.01500021e-02f, -5.14492281e-02f, -2.86568329e-02f,
  -5.67632280e-02f, 4.73946258e-02f, -3.60941514e-02f, 2.02201251e-02f, 9.77967158e-02f, 3.18114609e-02f, -5.31829521e-02f, 6.60348758e-02f, -3.44853923e-02f, 8.34274068e-02f,
  -1.18964195e-01f, 4.14722934e-02f, -6.80290759e-02f, -2.62916721e-02f, 4.76575904e-02f, -9.11434926e-03f, 4.76845391e-02f, 2.10444201e-02f, 5.86489961e-02f, 8.07029456e-02f,
  5.66087291e-02f, 6.65151253e-02f, 1.10342897e-01f, 3.14216465e-02f, 9.99779105e-02f, 9.09429118e-02f, -2.96300836e-02f, 1.21807061e-01f, 5.83497100e-02f, 8.39004964e-02f,
  5.58662117e-02f, 2.95294560e-02f, 4.99890409e-02f, -1.96169764e-02f, -6.88906573e-03f, -6.34682328e-02f, 1.19002737e-01f, -5.52380122e-02f, 4.56723422e-02f, 1.10367171e-01f,
  2.96792351e-02f, -4.40363698e-02f, 6.87689930e-02f, 1.46666855e-01f, 8.55937600e-02f, 1.21156000e-01f, 6.88012019e-02f, 1.30687058e-01f, -1.16212172e-02f, 1.93558149e-02f,
  -8.13345145e-03f, 5.32908365e-02f, 7.61751607e-02f, 1.04393996e-01f, -2.71931477e-02f, 5.29822595e-02f, 6.29067272e-02f, 1.67263765e-02f, -7.21481070e-02f, 5.49349189e-02f,
  6.16478063e-02f, 7.73174912e-02f, 4.40144837e-02f, 7.50830695e-02f, 2.37627421e-03f, 1.18476950e-01f, 9.18458700e-02f, 1.27280131e-02f, 5.87876774e-02f, -5.53070121e-02f,
  6.55313134e-02f, -6.72402084e-02f, -5.73817119e-02f, 1.01428665e-01f, -1.71924740e-01f, 4.63360846e-02f, 7.65244365e-02f, -1.20181791e-01f, -3.23728435e-02f, -1.52991220e-01f,
  1.33245457e-02f, -1.97202012e-01f, -7.25794882e-02f, 1.29827619e-01f, -4.12029866e-03f, -8.91743749e-02f, 4.80764657e-02f, -4.83669341e-03f, -3.96593213e-02f, -1.61728747e-02f,
  5.41029014e-02f, -1.48920625e-01f, 3.07456572e-02f, -2.69614011e-02f, -1.06296092e-01f, -5.42353019e-02f, -5.33678755e-02f, 2.06607170e-02f, -2.37782951e-02f, 9.43313092e-02f,
  5.32977469e-02f, 1.90816909e-01f, -3.00251320e-02f, -6.39294311e-02f, -7.75358975e-02f, 3.96502763e-03f, 1.29988685e-01f, -1.02334090e-01f, -7.73901045e-02f, 1.32421568e-01f,
  -6.88526481e-02f, -1.51339993e-01f, -1.25139594e-01f, -1.05467867e-02f, 1.06559150e-01f, -1.62820667e-01f, 1.56930298e-01f, -8.67601410e-02f, 1.32428512e-01f, 9.80538279e-02f,
  3.96294892e-03f, -7.01339990e-02f, 2.55604815e-02f, -6.57256246e-02f, -1.41261378e-02f, 2.96762882e-04f, -3.76712084e-02f, -8.37887377e-02f, -8.14298764e-02f, 2.03473028e-02f,
  2.18693540e-03f, 3.07203718e-02f, -3.67348120e-02f, 3.95347476e-02f, 5.34396246e-02f, 7.37639293e-02f, 4.68888134e-02f, 1.84034242e-03f, 3.17746744e-04f, -7.76153058e-02f,
  -5.24740852e-02f, 1.06318183e-01f, 8.36474448e-03f, 2.19207667e-02f, -5.63434139e-02f, -6.44681528e-02f, 7.83162788e-02f, -2.51053516e-02f, -2.83722524e-02f, 1.29721969e-01f,
  1.51449725e-01f, 4.51743267e-02f, 6.18942231e-02f, 9.11025777e-02f, 1.37943402e-01f, 4.46428098e-02f, 8.52032378e-02f, 9.04857367e-02f, 1.78266000e-02f, 2.44910046e-02f,
  4.59361970e-02f, 2.28643231e-03f, 4.99729626e-02f, 5.25234789e-02f, -5.50914146e-02f, 4.26525325e-02f, -3.15141454e-02f, -5.94134405e-02f, 8.81919414e-02f, 2.60760523e-02f,
  -5.92586957e-02f, -1.45147098e-02f, -4.87391884e-03f, 8.75655562e-02f, 7.57138133e-02f, -2.35395599e-02f, -4.56562899e-02f, -3.37288454e-02f, 2.29901224e-02f, 1.73528050e-03f,
  -2.59002205e-02f, -2.58638784e-02f, 8.57451260e-02f, 7.12628216e-02f, 3.24646458e-02f, 5.26418462e-02f, -3.36026237e-03f, 7.57605061e-02f, 4.66401316e-02f, 5.35817221e-02f,
  -2.11563427e-02f, -7.82274827e-02f, 1.20821521e-01f, 5.52149229e-02f, 4.97019105e-02f, 9.76028517e-02f, -8.66563153e-03f, 7.72911906e-02f, -6.15097843e-02f, -4.54514436e-02f,
  6.73416778e-02f, -1.57360584e-02f, 1.15442157e-01f, 2.12782789e-02f, 2.50300542e-02f, 6.86615855e-02f, -5.86678088e-02f, 1.49001762e-01f, 3.70761082e-02f, -6.22763187e-02f,
  -5.57962656e-02f, -2.26066299e-02f, -3.99148352e-02f, 1.57784234e-04f, -1.07508808e-01f, 5.62874861e-02f, 2.87817717e-02f, 1.17615849e-01f, 2.30884533e-02f, -1.27543267e-02f,
  -4.46638353e-02f, -1.20334871e-01f, 1.69102952e-01f, 6.83181733e-02f, -2.57318262e-02f, 1.22805970e-04f, 6.58040568e-02f, -2.23560296e-02f, 4.36817184e-02f, 6.41544815e-03f,
  1.84341278e-02f, -8.35860446e-02f, 1.52619690e-01f, -9.36718434e-02f, -1.46392107e-01f, 8.92690718e-02f, -2.76267249e-02f, -1.49491191e-01f, -9.09447670e-02f, 1.09276250e-01f,
  5.20101786e-02f, 1.20019361e-01f, -1.29679561e-01f, -6.37586042e-02f, -1.63036026e-02f, 2.30188034e-02f, -1.00356504e-01f, 1.57642160e-02f, 4.58483472e-02f, 6.48899376e-02f,
  7.94490725e-02f, -1.02360636e-01f, -2.64026374e-02f, 6.08335435e-03f, -2.38801688e-02f, -4.78383079e-02f, 2.79614013e-02f, 4.45732586e-02f, 4.55139065e-03f, -4.07568403e-02f,
  1.65373832e-02f, -5.94567806e-02f, -3.70053314e-02f, 1.06567651e-01f, 8.67463052e-02f, -1.09623969e-01f, -1.27303109e-01f, -3.28176543e-02f, -3.78509052e-02f, 2.73060277e-02f,
  -2.02902220e-03f, 6.09340630e-02f, 6.10589087e-02f, 8.23674202e-02f, -7.37831369e-02f, 1.38808349e-02f, 3.24790590e-02f, -4.29419726e-02f, -2.87599061e-02f, 1.43550644e-02f,
  -7.14137852e-02f, 5.52345254e-02f, -7.42142182e-03f, -2.51774094e-03f, 3.41893844e-02f, 4.01012190e-02f, 1.63747428e-03f, 1.10862680e-01f, -4.15072739e-02f, -2.18625125e-02f,
  8.03011358e-02f, -3.36029194e-02f, 5.70930466e-02f, -2.78366581e-02f, 5.71998842e-02f, -1.09923417e-02f, -2.56699659e-02f, 1.09008901e-01f, 6.00186102e-02f, 2.55186148e-02f,
  1.92327965e-02f, -3.39868516e-02f, 4.10639495e-02f, 7.88452327e-02f, 3.98187675e-02f, -1.23063242e-03f, 6.10515252e-02f, -7.24903494e-02f, 1.02561280e-01f, 6.41052201e-02f,
  1.08952418e-01f, -1.87478773e-02f, 8.01222846e-02f, 1.82593223e-02f, -5.67874014e-02f, 2.65125595e-02f, 2.33519766e-02f, -2.44713686e-02f, -3.27171423e-02f, 9.01327357e-02f,
  -3.83204594e-02f, -1.45587465e-02f, -6.05931468e-02f, 1.12359505e-02f, 6.18380643e-02f, 9.22011063e-02f, -3.24084349e-02f, -7.11271018e-02f, -1.82742812e-02f, 2.51019653e-02f,
  4.89489585e-02f, -1.05210461e-01f, 1.91103481e-02f, 5.49040847e-02f, -1.44614547e-03f, -1.18979454e-01f, 2.39840690e-02f, 3.74027790e-04f, 3.05301975e-02f, 8.58170763e-02f,
  -2.68147737e-02f, 3.87816317e-02f, -1.85255948e-02f, 2.95889899e-02f, -8.55856668e-03f, 5.44954054e-02f, 1.15747014e-02f, -1.02826096e-02f, -2.16395650e-02f, -2.45467983e-02f,
  2.96864156e-02f, -8.09106678e-02f, 5.79164065e-02f, 1.93583518e-02f, 6.45996481e-02f, -3.66835147e-02f, -4.59369756e-02f, 8.40781108e-02f, -2.23140568e-02f, 1.82029661e-02f,
  -8.18574652e-02f, -8.66637602e-02f, -1.46214655e-02f, -3.77336368e-02f, 7.55832270e-02f, -4.97432053e-02f, -1.44962609e-01f, -4.92236279e-02f, 1.34019628e-01f, 1.40838221e-01f,
  1.01061901e-02f, -1.18977226e-01f, 8.60117972e-02f, 1.77566148e-03f, -5.11223674e-02f, -2.91627012e-02f, 6.24538548e-02f, -4.51908670e-02f, 1.74928159e-02f, -8.35352167e-02f,
  -6.52472023e-04f, 2.47890186e-02f, -3.87508199e-02f, 2.60012727e-02f, -4.58297171e-02f, 1.18814923e-01f, -2.35876869e-02f, 6.69902265e-02f, -5.49055636e-02f, 1.02317363e-01f,
  -2.45218594e-02f, -4.77131419e-02f, -3.04326266e-02f, 6.84047341e-02f, 9.84097198e-02f, 7.75616243e-02f, 3.40573154e-02f, 1.00896500e-01f, 1.22188134e-02f, -6.16267212e-02f,
  -2.31007542e-02f, -4.41253744e-02f, -4.35606912e-02f, -7.37001712e-04f, 1.21311136e-01f, 3.86169665e-02f, 1.18772544e-01f, 6.05047634e-03f, 2.68353466e-02f, -1.37476595e-02f,
  5.49094379e-02f, -1.00017320e-02f, 2.04861704e-02f, 1.06358066e-01f, -7.84869678e-03f, -6.66027218e-02f, 8.52604583e-02f, 2.91044619e-02f, 1.06548145e-01f, 3.04486901e-02f,
  5.97956367e-02f, 3.16490681e-04f, -8.18244275e-03f, -3.09580192e-03f, 8.67755860e-02f, 8.22005346e-02f, 6.51433542e-02f, 9.69805196e-02f, -7.38763157e-03f, 3.94963063e-02f,
  1.17732808e-01f, -9.40224808e-03f, 3.90887707e-02f, 1.23130441e-01f, -5.97797381e-03f, 5.75151108e-02f, 9.83641855e-03f, 9.04766768e-02f, 1.31750956e-01f, -3.15402560e-02f,
  -5.30288778e-02f, 2.45955475e-02f, -1.35617733e-01f, 3.09977587e-02f, -4.41640168e-02f, 1.37791798e-01f, 6.09678216e-03f, 1.11669853e-01f, 1.49870887e-01f, 1.02719143e-01f,
  1.08018972e-01f, 1.54583141e-01f, 6.13176264e-02f, 1.21258333e-01f, -8.14370587e-02f, -1.12325184e-01f, -4.28207852e-02f, 7.26491073e-03f, -2.43949867e-03f, -1.62927076e-01f,
  -9.08726454e-02f, 4.14563753e-02f, 3.08657084e-02f, 7.13241845e-02f, 5.88435978e-02f, -9.09614377e-03f, 7.88653344e-02f, 9.83508676e-02f, -6.27219602e-02f, -4.18304019e-02f,
  -2.19636373e-02f, 9.03635398e-02f, -4.23451141e-02f, 4.01797257e-02f, 1.56312749e-01f, 3.04284692e-02f, -7.55265635e-03f, -2.48367642e-03f, 7.82394782e-03f, 7.92190805e-02f,
  -4.81094383e-02f, 2.81773750e-02f, 4.69043218e-02f, -6.20497689e-02f, 8.04139003e-02f, 7.54373893e-02f, 1.86264440e-02f, -8.41563419e-02f, -4.53559980e-02f, 3.10638212e-02f,
  1.69251347e-03f, 3.60284671e-02f, -1.11288019e-01f, -6.24565370e-02f, -7.87526555e-03f, 4.08105962e-02f, 2.21040379e-03f, 7.61449412e-02f, -3.71221453e-02f, -2.32027806e-02f,
  -8.47931057e-02f, 4.47987095e-02f, 5.63621782e-02f, 8.59555006e-02f, -4.95350687e-04f, 7.88692459e-02f, 1.24659024e-01f, 5.69890961e-02f, 1.55636137e-02f, 4.30173464e-02f,
  6.80080475e-03f, 2.37427484e-02f, 2.41326038e-02f, -1.37611717e-01f, 1.06567983e-02f, -6.58359975e-02f, -8.20383281e-02f, 7.59210736e-02f, 3.58347930e-02f, 4.15218584e-02f,
  7.72718489e-02f, -7.38976747e-02f, -7.60462210e-02f, -1.02956983e-04f, 7.02656806e-02f, -7.31414706e-02f, 1.00664690e-01f, -9.38927084e-02f, -5.14862053e-02f, -4.40242328e-02f,
  2.05493197e-02f, -4.22560610e-02f, 8.48543346e-02f, -3.48673319e-03f, -2.54960135e-02f, 1.01612978e-01f, 5.83633557e-02f, -3.96483620e-06f, -3.77160385e-02f, 6.77553639e-02f,
  2.21705530e-02f, 5.51210754e-02f, 5.74939586e-02f, 4.84795272e-02f, -5.44808134e-02f, 7.86807984e-02f, 9.96819232e-03f, 9.77394544e-03f, 7.14402199e-02f, -4.61478867e-02f,
  -3.35360058e-02f, 2.48116795e-02f, 5.13938852e-02f, -7.74251949e-03f, 5.26127703e-02f, 1.13631509e-01f, 9.38392952e-02f, -3.94979864e-02f, 2.20825896e-03f, 1.21087171e-01f,
  1.05321489e-01f, 1.10915497e-01f, 9.57483649e-02f, 1.17480308e-01f, 3.12615708e-02f, 6.30614683e-02f, 1.34811416e-01f, 2.76602507e-02f, 3.98097895e-02f, -1.65669248e-02f,
  -5.04119433e-02f, 7.11034611e-02f, 6.97849169e-02f, -5.79221454e-03f, -7.50956535e-02f, 1.03768498e-01f, -5.46514913e-02f, 7.14791343e-02f, -8.41441602e-02f, 6.88872263e-02f,
  1.18974410e-01f, -4.58108000e-02f, -1.39748733e-02f, 6.99517205e-02f, -1.03875529e-02f, 8.00062343e-02f, -4.26688194e-02f, -9.80271101e-02f, 6.06162883e-02f, -5.86833954e-02f,
  2.74531227e-02f, 4.85953391e-02f, -8.78786594e-02f, 2.73675639e-02f, 5.51419444e-02f, 6.51600733e-02f, -1.60445794e-02f, -6.58409148e-02f, -3.38249207e-02f, 1.20296381e-01f,
  1.07746210e-03f, -1.60771593e-01f, 4.70295325e-02f, -2.14051194e-02f, 1.09302148e-01f, -9.07934085e-02f, -7.82399327e-02f, 1.11143687e-03f, 8.83993506e-02f, 8.48631840e-03f,
  -3.23299356e-02f, -5.03959022e-02f, 8.63597244e-02f, 1.41396701e-01f, -1.88566390e-02f, -6.64091259e-02f, 1.34848822e-02f, 9.98939648e-02f, 1.52704790e-01f, -1.38820633e-01f,
  -9.57529992e-02f, -5.24114408e-02f, 1.14823841e-02f, -1.40109658e-02f, 1.39865456e-02f, -8.79382789e-02f, 1.71682313e-02f, -8.17803368e-02f, 1.17997378e-01f, -1.04551621e-01f,
  -6.55551329e-02f, 7.07781091e-02f, -7.29839653e-02f, 5.06068394e-02f, 1.09247819e-01f, 9.55467001e-02f, 5.66770844e-02f, -5.95411984e-03f, -9.23302248e-02f, -1.22365952e-02f,
  -1.94948073e-02f, -2.51418632e-02f, 1.07475840e-01f, 5.65450601e-02f, 1.94718707e-02f, -2.36859545e-02f, 7.51536340e-02f, 8.64817016e-03f, 1.00309402e-01f, 8.55972841e-02f,
  -6.45802096e-02f, -1.09204136e-01f, -7.13124126e-02f, 8.81477445e-02f, -5.33394367e-02f, -4.68716547e-02f, 7.35070184e-02f, -1.14455014e-01f, 1.04415379e-01f, 9.68527570e-02f,
  -2.05582362e-02f, -5.92226610e-02f, 8.98700133e-02f, -4.95374724e-02f, -5.00232838e-02f, -6.36102185e-02f, 5.96348532e-02f, -3.31518874e-02f, -5.38630188e-02f, -5.76359443e-02f,
  -1.08788768e-02f, 3.71730700e-02f, -2.39068978e-02f, -3.16987969e-02f, 4.09887917e-02f, 2.93036494e-02f, 4.71408553e-02f, -7.53482953e-02f, 5.32432683e-02f, 2.64288136e-03f,
  1.01380326e-01f, 2.85804626e-02f, -3.27775590e-02f, 1.28770443e-02f, -3.03118695e-02f, 1.00153118e-01f, -4.96088974e-02f, -1.61503591e-02f, 9.71627329e-03f, 9.89869684e-02f,
  1.04583114e-01f, 1.09667018e-01f, 9.67619047e-02f, 2.04014275e-02f, -4.04261164e-02f, 8.15893710e-02f, 1.09629966e-01f, 1.83979422e-02f, -5.02255186e-02f, -3.73104252e-02f,
  1.35340337e-02f, -7.19814971e-02f, -6.87255859e-02f, 1.01696104e-01f, 3.18050832e-02f, 6.08726442e-02f, -3.91158946e-02f, 3.36364247e-02f, 4.52908278e-02f, 1.03829745e-02f,
  5.35526462e-02f, 7.50638172e-02f, -1.17564350e-01f, -1.07991405e-01f, -5.94505891e-02f, 8.04388989e-03f, 2.25154702e-02f, -5.82729504e-02f, -4.09592800e-02f, -2.04555281e-02f,
  4.62684333e-02f, -2.59166844e-02f, 4.34873775e-02f, 3.52495462e-02f, 4.60000336e-02f, 1.13066304e-02f, 7.97029436e-02f, 7.99296051e-03f, -3.17299962e-02f, 2.38916706e-02f,
  4.21151258e-02f, -6.79393951e-03f, 6.98229969e-02f, 8.21491405e-02f, -1.31443013e-02f, -2.15792973e-02f, -4.11728509e-02f, 9.03310403e-02f, 5.49059473e-02f, -3.74332294e-02f,
  -4.59049381e-02f, 1.26312589e-02f, -4.12221290e-02f, 1.30749479e-01f, -1.06842935e-01f, -4.68834210e-03f, 1.02130650e-02f, -9.07070413e-02f, 4.77511212e-02f, -4.54413146e-02f,
  6.90526366e-02f, 1.59908161e-02f, -1.77124962e-02f, -6.34715930e-02f, 4.79787774e-02f, 6.00076057e-02f, 2.28084419e-02f, -1.66724417e-02f, -2.58716121e-02f, -1.01507328e-01f,
  7.52039254e-02f, 7.71275163e-02f, 8.61378610e-02f, 4.66153063e-02f, 1.85241885e-02f, 1.66367907e-02f, -8.12892169e-02f, 1.99594907e-02f, -9.03052315e-02f, 5.56244291e-02f,
  2.86082663e-02f, -1.07338903e-02f, -5.56422770e-02f, -2.22415049e-02f, 8.27184618e-02f, 7.03790188e-02f, 1.95836145e-02f, -2.89589856e-02f, 9.37324166e-02f, -1.05359927e-01f,
  -6.27787188e-02f, -4.75115292e-02f, 2.85083260e-02f, -7.28205442e-02f, -2.29191314e-02f, -1.73309930e-02f, -1.30724376e-02f, -4.32777554e-02f, -5.53778000e-02f, 5.17694931e-03f,
  1.15756065e-01f, 2.85923909e-02f, -6.41587749e-02f, 9.18406099e-02f, -7.44275600e-02f, -9.64156091e-02f, -8.64841416e-03f, 6.93660751e-02f, 7.82718882e-02f, -1.60912611e-02f,
  -6.58331215e-02f, -8.57049972e-02f, 9.43361688e-03f, 3.03142332e-02f, -2.72316784e-02f, 1.03693560e-01f, 1.05295695e-01f, 1.39517516e-01f, 5.73992766e-02f, 5.90527803e-02f,
  8.48772228e-02f, 1.00712381e-01f, 3.22609348e-03f, 6.49343804e-02f, 1.82737838e-02f, 8.97875130e-02f, -7.63656525e-03f, 7.06031993e-02f, 6.38431013e-02f, -3.25775705e-02f,
  6.35963008e-02f, -2.01097056e-02f, 7.44065568e-02f, 8.83090571e-02f, 2.94580013e-02f, -5.11327609e-02f, 9.58834961e-02f, -5.72206080e-02f, 1.19290948e-01f, 1.10688180e-01f,
  8.03613067e-02f, -3.61303501e-02f, -3.67339812e-02f, 8.76591951e-02f, -8.43767822e-02f, -3.04605998e-02f, 7.47540295e-02f, -1.49717391e-01f, -1.12947151e-01f, 8.67074877e-02f,
  -1.09071825e-02f, -2.59655658e-02f, -5.24729565e-02f, -7.49836415e-02f, 7.22805336e-02f, 1.01600215e-01f, 9.18382183e-02f, 8.03029835e-02f, -1.46227539e-01f, 6.97355438e-03f,
  7.29242936e-02f, -5.52120097e-02f, 8.09263140e-02f, 7.38385180e-03f, 5.19583188e-02f, -1.46891981e-01f, -1.60678759e-01f, -1.35892972e-01f, -8.38587135e-02f, 1.07288033e-01f,
  1.40209217e-02f, 9.60511789e-02f, -1.12807572e-01f, -4.61471267e-02f, 9.43960901e-03f, -6.93911910e-02f, -4.52516563e-02f, -4.11230028e-02f, -5.87511212e-02f, 1.14024498e-01f,
  1.48748457e-01f, 2.26402000e-01f, -6.56006187e-02f, 9.66078509e-03f, 7.05736130e-02f, -5.59656695e-02f, 6.24610744e-02f, -2.86208410e-02f, 1.23994574e-01f, -3.11922953e-02f,
  1.13516241e-01f, -9.80956946e-03f, 1.38241202e-01f, -5.65226413e-02f, 6.64212853e-02f, 6.29581809e-02f, 6.56515881e-02f, -1.54773742e-01f, 2.48244796e-02f, 1.10025719e-01f,
  7.07148388e-02f, 9.53543372e-03f, 6.92023560e-02f, -2.67363954e-02f, 5.46377040e-02f, -4.93957289e-02f, 3.04087456e-02f, 1.06038690e-01f, -4.18934226e-02f, -8.78503546e-02f,
  1.38015032e-01f, 5.71342073e-02f, 4.98504564e-02f, 5.57628907e-02f, 4.17492650e-02f, 1.27721392e-02f, 7.66905546e-02f, 4.85550128e-02f, -4.98622432e-02f, -8.16872567e-02f,
  -1.88423302e-02f, -5.88356778e-02f, 3.09682149e-03f, -3.67638543e-02f, 8.57967362e-02f, -6.10412247e-02f, 8.59994739e-02f, 5.89798391e-02f, -3.40196490e-02f, -5.86644709e-02f,
  5.47588170e-02f, -9.17115882e-02f, -4.46480103e-02f, 1.83645152e-02f, 2.53927391e-02f, 2.07741689e-02f, -5.27722277e-02f, -5.79357482e-02f, 8.15699697e-02f, -2.08908971e-02f,
  8.16293061e-02f, -6.79754540e-02f, 8.06250870e-02f, 7.89894015e-02f, 2.87374351e-02f, 4.85526547e-02f, 5.95142134e-02f, 3.97976488e-02f, -7.17592537e-02f, -6.37572482e-02f,
  -5.94743863e-02f, -4.58587296e-02f, -5.99022768e-02f, 1.67722646e-02f, 8.36330280e-03f, 3.54648381e-02f, -1.04760204e-03f, -2.16738274e-03f, -7.33352154e-02f, 6.62483647e-02f,
  -6.47540540e-02f, -5.43873236e-02f, -2.06038654e-02f, 1.23956231e-02f, -1.81920175e-02f, 1.33400448e-02f, -3.35436426e-02f, -7.39949495e-02f, -7.36809671e-02f, 4.87830713e-02f,
  5.89556955e-02f, 4.37535197e-02f, -1.93325318e-02f, 2.60702446e-02f, 5.73128536e-02f, 2.29731444e-02f, -7.36804083e-02f, -2.62104385e-02f, 6.30859882e-02f, -4.50035371e-02f,
  -7.89713189e-02f, -4.51898053e-02f, -9.06786770e-02f, -6.91473410e-02f, 8.65270942e-02f, -8.85592494e-03f, 6.78570941e-02f, 1.05140526e-02f, -1.60344075e-02f, -7.01908693e-02f,
  -6.64784387e-02f, -6.83176890e-02f, -7.60162100e-02f, -5.15151396e-02f, 5.72212599e-02f, 3.49559933e-02f, -3.34956087e-02f, -7.45457932e-02f, 2.85787731e-02f, -2.70090774e-02f,
  6.48764148e-02f, -7.80953467e-02f, -1.34191485e-02f, -2.41395421e-02f, 4.71486114e-02f, -4.72868495e-02f, 1.02254972e-02f, 2.52864994e-02f, -8.89353827e-02f, -8.83202329e-02f,
  2.52836943e-02f, 6.57606646e-02f, 4.99504916e-02f, -5.03154434e-02f, -4.87284415e-04f, -5.28829806e-02f, -5.50956912e-02f, 7.00038970e-02f, 2.41025584e-03f, 1.46397939e-02f,
  -3.60123068e-02f, -2.65397616e-02f, -6.05256036e-02f, 1.79133043e-02f, -8.15015584e-02f, -7.51998052e-02f, 3.65946777e-02f, 8.27026516e-02f, -6.91864789e-02f, -2.68715657e-02f,
  -2.20704786e-02f, 7.33950362e-02f, -9.03610811e-02f, -1.00787673e-02f, -5.23875169e-02f, 6.27023429e-02f, 4.39887941e-02f, 1.29504791e-02f, -4.09632288e-02f, -9.51614827e-02f,
  -2.69367211e-02f, 5.75892776e-02f, -7.59858452e-03f, -6.35157749e-02f, -1.99851673e-02f, -8.83079022e-02f, 2.47659478e-02f, -7.05947205e-02f, 3.08975596e-02f, 1.84302786e-04f,
  4.95237298e-02f, -2.27211230e-02f, 6.87778145e-02f, 6.57752007e-02f, 3.30175087e-02f, 7.22647160e-02f, -3.40450145e-02f, 2.84874272e-02f, -2.96578482e-02f, -1.73882768e-02f,
  -4.96035367e-02f, 7.86774680e-02f, 1.14162490e-01f, 9.12917703e-02f, -4.37617749e-02f, 5.28225815e-03f, 2.67548580e-02f, 1.19233735e-01f, -4.90306839e-02f, -5.77001758e-02f,
  1.25843048e-01f, -2.83708088e-02f, 4.19725515e-02f, -5.94711192e-02f, 3.27299349e-02f, 6.34245276e-02f, 1.14073437e-02f, -1.96869280e-02f, 4.18770686e-02f, -1.88929234e-02f,
  9.87169668e-02f, 4.78186756e-02f, -2.73597091e-02f, 3.40842195e-02f, 4.78000492e-02f, 2.74615679e-02f, 7.89071247e-02f, 1.32244959e-01f, -4.23115343e-02f, 1.86882243e-02f,
  -3.95766720e-02f, 3.61432023e-02f, -2.84157060e-02f, -1.88945830e-02f, -6.79397359e-02f, 5.49379885e-02f, -3.09975222e-02f, 5.69955632e-02f, 9.84191969e-02f, 1.13548048e-01f,
  1.33272886e-01f, 1.36681557e-01f, 3.33716646e-02f, -5.75338863e-02f, -6.63251523e-03f, 2.21573245e-02f, -7.93380737e-02f, 4.94129099e-02f, -8.55314359e-02f, 1.26707613e-01f,
  -2.54020840e-02f, -8.59899372e-02f, -1.30615503e-01f, 8.03398341e-02f, 3.42744552e-02f, -1.06496207e-01f, -7.28559718e-02f, -9.93270949e-02f, 1.09251626e-01f, -2.15141829e-02f,
  7.60488585e-02f, 1.43456822e-02f, 1.23915106e-01f, 1.28435314e-01f, -1.01265470e-02f, -1.12023868e-01f, 3.15187387e-02f, 4.83339615e-02f, 1.17611893e-01f, 6.76880032e-02f,
  -5.71551137e-02f, 5.54770343e-02f, 5.45221381e-02f, 1.90244943e-01f, -4.94580949e-03f, -9.45227817e-02f, 1.80416722e-02f, -1.13380454e-01f, 2.07675546e-02f, 6.23662286e-02f,
  -5.13876602e-02f, 1.04519434e-01f, 3.02407704e-02f, 1.12767845e-01f, 7.05617517e-02f, -7.92843662e-03f, -1.36077672e-01f, 4.61040102e-02f, -1.84488609e-01f, -6.49744719e-02f,
  2.81693810e-03f, -5.44106178e-02f, 6.24022968e-02f, -9.03184339e-03f, -5.10012992e-02f, 1.61226522e-02f, 4.42414656e-02f, -2.83550639e-02f, -3.21366056e-03f, 2.57493462e-02f,
  -1.28161997e-01f, 1.67331416e-02f, 9.27971154e-02f, 1.81987453e-02f, -8.16144794e-02f, 1.00529410e-01f, -7.28514418e-02f, -1.01898834e-01f, 5.09990528e-02f, 8.91134217e-02f,
  3.37967724e-02f, 4.59635183e-02f, -1.10479869e-01f, -4.04580571e-02f, 4.65704985e-02f, 4.76165190e-02f, -2.56375726e-02f, 2.21333783e-02f, 1.76515169e-02f, 5.76622374e-02f,
  -4.20026556e-02f, 1.02765583e-01f, -2.18141936e-02f, -5.15823886e-02f, 2.13302094e-02f, 7.00644925e-02f, 9.04344395e-02f, -8.13666210e-02f, 2.99516264e-02f, 3.82954702e-02f,
  3.28403749e-02f, -7.24631995e-02f, 1.03035383e-02f, -1.78056788e-02f, 2.21540742e-02f, 8.47183615e-02f, 3.08199804e-02f, -6.60177022e-02f, 4.09700423e-02f, -3.50756235e-02f,
  -5.36349714e-02f, 5.28452620e-02f, -4.34035622e-02f, 7.94143379e-02f, 4.98142168e-02f, 3.80590335e-02f, 6.21581227e-02f, -1.00113852e-02f, 9.42514911e-02f, -2.56816447e-02f,
  8.76631811e-02f, -4.53688577e-02f, 4.65334989e-02f, 4.55025099e-02f, -6.80365637e-02f, -5.50406426e-03f, -2.91596893e-02f, 3.75853851e-02f, -7.51034468e-02f, -1.33145768e-02f,
  -7.28808194e-02f, 4.14430816e-03f, -6.69279918e-02f, -6.09094761e-02f, 9.05448124e-02f, -5.11273108e-02f, -3.01106106e-02f, -4.96082418e-02f, 1.71920825e-02f, 6.45455495e-02f,
  9.59020928e-02f, 3.02892383e-02f, 4.26411778e-02f, 1.03858439e-02f, 8.35583881e-02f, -8.34653303e-02f, 7.60965124e-02f, 5.29170781e-02f, 3.49262655e-02f, -4.46481928e-02f,
  -9.80797857e-02f, 7.32711703e-02f, 8.39682668e-02f, -8.70841593e-02f, -3.12841833e-02f, 8.53579268e-02f, 9.15852487e-02f, 7.44081065e-02f, -4.55979444e-02f, -6.45738095e-02f,
  -6.16384931e-02f, -6.42033145e-02f, 7.59201273e-02f, -8.27913955e-02f, 8.37639347e-02f, -7.26767182e-02f, -4.34651710e-02f, -5.18697985e-02f, 1.85132306e-02f, 5.55236004e-02f,
  -3.90512459e-02f, 2.39198431e-02f, 5.56547157e-02f, -1.17117073e-02f, -2.85191108e-02f, -5.69515070e-03f, -3.97702940e-02f, 9.62354802e-03f, -3.69132459e-02f, -4.65470962e-02f,
  -7.43002295e-02f, 3.02787218e-02f, -6.82967156e-02f, 1.56051712e-02f, 1.48770073e-02f, 5.77053688e-02f, -4.76219654e-02f, -2.66666822e-02f, -7.85626099e-02f, -1.72475092e-02f,
  7.08458722e-02f, -5.86815514e-02f, -3.18526998e-02f, 1.72754917e-02f, 8.56947601e-02f, -2.27919985e-02f, 5.57123646e-02f, 3.56039107e-02f, -7.83401355e-02f, 4.69833240e-02f,
  2.15749480e-02f, 4.02769111e-02f, 7.70716816e-02f, 4.93829884e-02f, -6.39247447e-02f, 5.19605866e-03f, -3.64392623e-02f, -6.97686046e-04f, -8.27416852e-02f, 5.27785607e-02f,
  5.48282359e-03f, -7.66878948e-02f, 1.38292583e-02f, -8.39379728e-02f, -8.06739181e-02f, 5.06075285e-02f, 5.40509447e-02f, 3.92787419e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.44006209e-02f, 6.70491084e-02f, 4.62534502e-02f, 1.28840491e-01f, -5.55689372e-02f, 6.11209236e-02f, -7.64611438e-02f, 7.38794804e-02f, 4.97463010e-02f, 3.51100154e-02f,
  1.09168895e-01f, 1.05004102e-01f, 1.81491747e-02f, 2.84083243e-02f, -2.60070674e-02f, 4.89111729e-02f, -3.03557310e-02f, 7.57696703e-02f, 1.27750123e-02f, 1.83887873e-02f,
  -2.54536397e-03f, 4.07424867e-02f, 5.72915785e-02f, 2.34090090e-02f, 5.28109483e-02f, 4.55204919e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  5.89544810e-02f, 7.82426596e-02f, -6.03397638e-02f, -9.69372839e-02f, 3.16656306e-02f, -2.70248819e-02f, -2.48952992e-02f, -3.49510729e-01f, 3.73119786e-02f, -9.04737338e-02f,
  -6.37905151e-02f, -8.68499875e-02f, 1.00877918e-01f, -2.07841933e-01f, -1.61729679e-01f, -1.70632616e-01f, -2.09864508e-02f, 2.24725213e-02f, 8.91242325e-02f, 1.19829215e-01f,
  -5.30315675e-02f, 5.06742857e-02f, 4.08252329e-02f, -5.68809249e-02f, -4.32221703e-02f, -3.12445223e-01f, 2.43309159e-02f, 3.92512418e-02f, -4.40743230e-02f, -3.48370485e-02f,
  2.21401230e-02f, -1.65907502e-01f, -1.62151575e-01f, -1.12850644e-01f, 1.19855575e-01f, -3.47791389e-02f, -1.09008037e-01f, -5.00082336e-02f, -2.38712102e-01f, 1.36746809e-01f,
  -9.53692663e-03f, 3.98925245e-02f, 8.72352198e-02f, 9.30326432e-02f, 5.26947435e-03f, 1.27143487e-01f, 4.44916403e-03f, -8.61349255e-02f, 4.81772311e-02f, 1.88484356e-01f,
  7.70888031e-02f, -2.75897048e-02f, -7.51175582e-02f, -1.83277965e-01f, 1.98542431e-01f, -1.06319100e-01f, -1.47100180e-01f, -1.73748117e-02f, 1.96408480e-01f, -1.35083064e-01f,
  -1.38434425e-01f, -4.06257480e-01f, 1.43065602e-01f, -1.40564561e-01f, -1.22427888e-01f, 1.61467835e-01f, -3.43576074e-01f, 1.82398587e-01f, 7.78355524e-02f, -1.22494675e-01f,
  4.19543969e-04f, 1.83089390e-01f, -7.39452541e-02f, -1.67729035e-01f, 6.48731291e-02f, -1.15617536e-01f, 1.00073494e-01f, -5.15020750e-02f, -5.39537556e-02f, 1.19954899e-01f,
  -3.13946232e-03f, 1.82365328e-01f, 1.76015675e-01f, 1.10450543e-01f, 1.91129267e-01f, -9.07407422e-03f, 1.77483112e-01f, 3.98831457e-01f, -2.39019066e-01f, 2.71661252e-01f,
  1.60592925e-02f, 2.40334100e-03f, 1.32934630e-01f, -2.56733652e-02f, 2.11300388e-01f, 6.62365630e-02f, -5.57885356e-02f, 2.58234769e-01f, 1.02656268e-01f, -8.92776623e-02f,
  -9.71416757e-02f, -1.85658813e-01f, 8.78245197e-03f, -1.06137075e-01f, -8.21770802e-02f, 5.51880300e-01f, 2.32714023e-02f, 2.84177601e-01f, -4.59411927e-02f, -2.80095428e-01f,
  -9.84603912e-02f, -2.66029984e-01f, 1.26823662e-02f, 2.71932036e-01f, 1.30789265e-01f, 3.03184818e-02f, -7.41178170e-02f, 1.04615748e-01f, -2.19820216e-01f, -1.09528847e-01f,
  -1.99770276e-02f, -2.68248081e-01f, -9.09257755e-02f, 4.58484516e-03f, 2.92548299e-01f, -3.64358574e-02f, -1.22699521e-01f, -8.28355923e-02f, 1.31626263e-01f, 1.96132865e-02f,
  2.13520671e-03f, 4.26830165e-02f, -2.43090943e-01f, 7.41371214e-02f, -1.01398699e-01f, 2.29957059e-01f, -1.03702471e-02f, 1.73188344e-01f, -5.81854917e-02f, -2.09705383e-02f,
  2.37799976e-02f, -1.74549460e-01f, -1.96320742e-01f, -2.94524934e-02f, 6.69798329e-02f, 1.90276895e-02f, -3.74762826e-02f, -1.09238289e-01f, 1.56499058e-01f, 9.51268524e-02f,
  2.45434158e-02f, -6.94603622e-02f, 1.21587195e-01f, -1.87768146e-01f, 3.41971102e-03f, 1.08973622e-01f, 1.86301127e-01f, 9.44068208e-02f, 2.22896822e-02f, -5.47255203e-02f,
  -4.48588002e-03f, 5.59995621e-02f, 6.61933422e-02f, -2.78190732e-01f, 2.30602145e-01f, -1.85203478e-01f, 1.12271734e-01f, -1.91341564e-01f, 1.33161634e-01f, 1.14373259e-01f,
  3.30397524e-02f, -1.50891319e-02f, 9.66765583e-02f, 7.26438910e-02f, -3.08007777e-01f, 9.40855667e-02f, -1.07620239e-01f, -9.72138792e-02f, 6.43507810e-03f, -5.82158454e-02f,
  5.24503142e-02f, -1.44773036e-01f, 3.65392923e-01f, -4.00610596e-01f, 3.02601680e-02f, 3.61467063e-01f, 2.09210012e-02f, 3.19392011e-02f, 2.21700668e-02f, -2.70560890e-01f,
  1.37900800e-01f, -2.67734796e-01f, -2.52073526e-01f, 2.23389819e-01f, -1.75820664e-01f, 3.44265968e-01f, 2.18148962e-01f, 3.13896358e-01f, -2.21594885e-01f, -2.97584049e-02f,
  9.30615813e-02f, -2.76280522e-01f, 1.04914479e-01f, 2.87362278e-01f, 2.87715662e-02f, -1.35941923e-01f, 3.50620039e-02f, -1.65818632e-01f, -4.62643534e-01f, 4.23037440e-01f,
  -2.65373051e-01f, 1.76957414e-01f, -2.48651117e-01f, 5.77669851e-02f, -3.18262905e-01f, -8.14964399e-02f, -2.55982373e-02f, -1.72696128e-01f, 4.26861225e-03f, -2.48851463e-01f,
  -1.91125989e-01f, 1.12521470e-01f, -1.84191883e-01f, -5.86823039e-02f, -6.57662898e-02f, 2.56606847e-01f, 1.57354698e-01f, -1.85675427e-01f, -3.44860673e-01f, -3.50277334e-01f,
  1.52357831e-03f, -1.69517606e-01f, -1.97536554e-02f, 3.32623988e-01f, 7.53464624e-02f, 7.34888762e-02f, -4.37156819e-02f, -2.63485342e-01f, 3.37372094e-01f, -1.63815856e-01f,
  5.52166589e-02f, 3.23714584e-01f, -1.52247488e-01f, -8.83075036e-03f, -3.28992233e-02f, -2.10536018e-01f, -2.46792004e-01f, 4.75100428e-02f, 9.44146737e-02f, -8.73798653e-02f,
  -2.12893367e-01f, -1.53688103e-01f, -8.81595612e-02f, -3.99742573e-02f, -1.17732756e-01f, -5.99109568e-02f, 9.83793288e-02f, 9.28234532e-02f, -7.38523081e-02f, 2.05353990e-01f,
  -1.78902522e-01f, 1.30396172e-01f, 1.02386512e-02f, -8.83107036e-02f, -5.05441576e-02f, -4.87628356e-02f, -8.94996822e-02f, 9.23278555e-02f, 7.01906579e-03f, 9.90691558e-02f,
  -1.37227178e-01f, 9.67100337e-02f, -8.16273019e-02f, -3.73294093e-02f, 4.86624613e-02f, 1.34007648e-01f, -1.75136477e-02f, 8.23641717e-02f, 9.26097706e-02f, -1.02465779e-01f,
  7.72639737e-02f, 1.80513307e-01f, 2.59655695e-02f, -1.01403065e-01f, 3.12522352e-02f, 1.11689992e-01f, 1.92735679e-02f, 9.94973555e-02f, 2.07246616e-01f, 9.37942713e-02f,
  2.00932354e-01f, 1.39859749e-03f, 5.56231216e-02f, 3.73404533e-01f, 2.69517899e-01f, 1.38106883e-01f, -4.71939752e-03f, -2.88728643e-02f, -1.13665752e-01f, -2.59871241e-02f,
  -1.08551294e-01f, 7.01806396e-02f, -8.25322047e-02f, 6.76547214e-02f, -2.38833204e-02f, 1.22383460e-01f, 6.02804460e-02f, 2.53917038e-01f, -3.44085172e-02f, -7.63181522e-02f,
  1.20959133e-01f, -2.95212120e-01f, -2.31619984e-01f, -3.26940984e-01f, 3.45161468e-01f, 1.75010525e-02f, -2.10928112e-01f, 2.40847751e-01f, 1.50713086e-01f, 8.40047672e-02f,
  1.90681219e-01f, 1.82789057e-01f, 9.60954726e-02f, -3.86267215e-01f, -2.03944948e-02f, -9.35106073e-03f, 6.39296994e-02f, 1.90658137e-01f, -2.15243652e-01f, -3.27138379e-02f,
  1.44509003e-01f, 3.65253799e-02f, 2.03519583e-01f, -1.59805000e-01f, 1.30921826e-01f, 2.35575557e-01f, 1.03010036e-01f, 1.90295279e-01f, -2.87508458e-01f, 9.67076793e-03f,
  -7.11439550e-02f, 1.04125798e-01f, 5.60609065e-02f, -1.29280267e-02f, -1.31613417e-02f, 2.15810373e-01f, -7.87380114e-02f, -9.73290876e-02f, 2.15516970e-01f, 6.49703667e-02f,
  -6.67602867e-02f, 1.90665871e-01f, -1.34226352e-01f, 1.30239213e-02f, -9.03333277e-02f, -1.87857762e-01f, -3.39339226e-02f, 7.92774037e-02f, 1.00739665e-01f, -9.77596175e-03f,
  -6.17207885e-02f, 2.40979627e-01f, -8.46610665e-02f, -3.58356029e-01f, 3.62282954e-02f, 1.47109404e-01f, 1.23527877e-01f, -2.28613973e-01f, -1.77844733e-01f, -1.39438722e-03f,
  1.22911870e-01f, -6.22560382e-02f, 8.60634297e-02f, 1.09064840e-01f, -3.59619432e-03f, 2.20338225e-01f, -4.08624858e-02f, -9.06903949e-03f, -2.65282184e-01f, -1.44751593e-01f,
  -2.59399712e-01f, -1.47102028e-02f, 3.35201263e-01f, 7.49944299e-02f, -7.17038959e-02f, 1.68803763e-02f, 1.16157897e-01f, 1.77374005e-01f, -1.86712705e-02f, 1.66995227e-01f,
  9.03868526e-02f, -9.47822854e-02f, -7.98590779e-02f, -3.13083129e-03f, -6.03085347e-02f, -3.91622156e-01f, -6.30777255e-02f, -1.77922808e-02f, 2.64734104e-02f, 1.21290490e-01f,
  9.55802128e-02f, -2.18178347e-01f, 4.59732488e-02f, -4.76029441e-02f, -4.42896932e-02f, -5.81913888e-02f, -1.39911354e-01f, 2.48835981e-01f, -1.26739964e-01f, -3.05988118e-02f,
  2.61806939e-02f, -4.32852395e-02f, -1.01411633e-01f, -3.13620716e-02f, -1.50700167e-01f, -1.54665321e-01f, -1.27861276e-01f, 1.50168478e-01f, 3.01421523e-01f, -2.89781820e-02f,
  1.86010599e-01f, -1.41006559e-01f, -1.01778489e-02f, -1.01497257e-02f, -7.80995265e-02f, -8.84365216e-02f, -7.52366036e-02f, 9.85926241e-02f, -2.88767386e-02f, -3.08896512e-01f,
  3.50417197e-02f, 4.53299433e-02f, 3.04561295e-02f, -9.21439528e-02f, -2.68616974e-01f, 2.53921658e-01f, 5.16453832e-02f, 1.11148469e-01f, 7.75759891e-02f, 1.93003505e-01f,
  1.54000506e-01f, 8.04199725e-02f, 1.32668331e-01f, 1.46404862e-01f, -1.52999803e-01f, 2.99699694e-01f, 1.82931349e-01f, 2.26186320e-01f, -9.04912055e-02f, 6.12715632e-03f,
  -7.81725496e-02f, 1.58210710e-01f, -2.99361914e-01f, 2.15613589e-01f, 1.91760398e-02f, 1.71900377e-01f, 4.99401018e-02f, 2.22346812e-01f, -3.13259184e-01f, -3.19527625e-03f,
  2.52256989e-01f, 3.53500843e-01f, -6.78555965e-02f, 1.58878222e-01f, 1.81325495e-01f, -3.25543493e-01f, 1.77668139e-01f, 9.71743762e-02f, -3.36909264e-01f, -2.91594952e-01f,
  3.22885752e-01f, 3.16078253e-02f, -2.33922273e-01f, 1.92439169e-01f, -5.79856895e-02f, 8.07672665e-02f, 1.08872883e-01f, 1.01116404e-01f, 1.90295562e-01f, 8.19378719e-03f,
  4.26916666e-02f, -2.01529607e-01f, 1.58274174e-01f, 3.66933584e-01f, 2.26680964e-01f, 2.37700030e-01f, 3.17876637e-02f, 2.01365814e-01f, -1.68190582e-03f, 7.39228204e-02f,
  -3.84105593e-02f, 3.24719548e-02f, 2.90582031e-02f, 2.09010795e-01f, -4.80559953e-02f, 1.29141226e-01f, -9.89658237e-02f, -1.64091021e-01f, 1.54402956e-01f, -1.97890773e-01f,
  -1.69463724e-01f, 3.38269383e-01f, -8.53450745e-02f, -3.48257460e-02f, -6.36607856e-02f, -1.05484590e-01f, -9.29804444e-02f, 6.71438465e-04f, 2.08553165e-01f, -5.37951775e-02f,
  -1.10611938e-01f, 3.05598229e-03f, 1.65595248e-01f, 5.87119944e-02f, 2.00748295e-01f, 4.37563248e-02f, -2.22174986e-03f, 3.99070932e-03f, 9.24060196e-02f, 1.83781367e-02f,
  1.59934368e-02f, 1.16228983e-01f, 1.68515369e-01f, 7.74411559e-02f, 1.81623455e-02f, 1.87466547e-01f, 1.91826239e-01f, 1.62670732e-01f, 1.78916201e-01f, 1.15355209e-01f,
  7.02140778e-02f, -3.98982922e-03f, 1.61662832e-01f, 1.22122489e-01f, 5.53353801e-02f, -1.78326622e-01f, 3.60366888e-02f, -1.16060413e-01f, 2.45278388e-01f, 5.23036569e-02f,
  5.03302775e-02f, 3.68509516e-02f, 1.32645786e-01f, -6.66880161e-02f, 2.80356228e-01f, -8.21134076e-03f, -3.48477364e-01f, 2.15693384e-01f, 8.55467618e-02f, 9.61322039e-02f,
  -8.82137120e-02f, 1.43223017e-01f, -2.05884464e-02f, -3.50935280e-01f, 1.05508223e-01f, 3.57940346e-02f, -1.50447950e-01f, 5.64647317e-02f, 1.31788492e-01f, -1.62267789e-01f,
  1.58353955e-01f, -2.56280571e-01f, 6.08432330e-02f, 2.20929161e-01f, -3.81309763e-02f, 3.62900794e-02f, -1.94612741e-02f, 3.00069451e-01f, -7.51216188e-02f, -1.85129810e-02f,
  -1.99552681e-02f, -5.61693422e-02f, -8.96869525e-02f, -7.63155594e-02f, 1.99814633e-01f, 1.76570207e-01f, -1.30298868e-01f, -2.21938923e-01f, -1.61927808e-02f, 1.81813017e-01f,
  -1.19197100e-01f, -3.56549412e-01f, 2.28404298e-01f, -4.06552330e-02f, 1.02171518e-01f, 1.26311257e-01f, 2.21104041e-01f, 5.42045347e-02f, 2.20367089e-01f, -3.58070321e-02f,
  -1.33902952e-01f, 1.22794278e-01f, 1.59243211e-01f, 6.47157729e-02f, 7.50989839e-02f, -1.55561134e-01f, 3.69050682e-01f, 4.04498607e-01f, 1.44907847e-01f, -2.96363048e-02f,
  -2.74349481e-01f, 2.71876305e-01f, 1.95099264e-02f, 2.65780777e-01f, 8.46905261e-03f, -5.22773527e-03f, -8.21222812e-02f, 2.13265687e-01f, -1.64532512e-01f, -3.99752229e-01f,
  7.97941312e-02f, 6.32269979e-02f, 2.38792822e-01f, 3.36409807e-01f, -9.32395384e-02f, 2.01056167e-01f, 8.57020635e-03f, -3.31822485e-01f, -1.00185692e-01f, 1.30489022e-01f,
  7.83687979e-02f, 4.45624366e-02f, -3.64175588e-01f, -2.84471363e-02f, 8.73094425e-02f, 3.27432901e-02f, 2.40660205e-01f, -1.89948052e-01f, 1.01754747e-01f, 3.19959790e-01f,
  -1.47176161e-01f, -8.83318856e-02f, -2.76235715e-02f, -1.34043723e-01f, 1.26828134e-01f, -1.88750625e-02f, -1.53426766e-01f, -5.07260673e-02f, -6.91017956e-02f, -9.04566273e-02f,
  -7.13156387e-02f, -2.04786703e-01f, 5.00234663e-02f, 1.67804733e-01f, 1.95761338e-01f, 9.26822051e-02f, -5.66030890e-02f, 1.22053914e-01f, -2.34832279e-02f, 1.45615339e-01f,
  2.98071802e-02f, 2.27267042e-01f, 3.59356329e-02f, 8.30145702e-02f, -1.57456473e-02f, 5.77226467e-02f, 1.47938043e-01f, 9.74439958e-04f, -2.83086281e-02f, 1.71779394e-01f,
  1.33738667e-01f, -1.26331627e-01f, 7.86114261e-02f, 1.14778966e-01f, -5.59307709e-02f, 7.32645690e-02f, -2.12624203e-02f, -7.28111714e-03f, 8.55004787e-02f, -1.61463231e-01f,
  9.32643041e-02f, 3.26666646e-02f, 1.29514158e-01f, 6.53209388e-02f, -1.35095462e-01f, 1.57165021e-01f, -2.90180475e-01f, 1.75736308e-01f, 1.06772743e-01f, -3.20099652e-01f,
  -1.14705577e-01f, 1.49749473e-01f, -4.20365594e-02f, 5.63651361e-02f, -8.63811560e-03f, -1.28763676e-01f, 6.01758622e-02f, 1.30371004e-01f, 3.22110057e-02f, 2.31156379e-01f,
  2.09954157e-01f, -2.06523046e-01f, -2.29789227e-01f, -8.04517511e-03f, -1.85608774e-01f, 1.75809309e-01f, -4.31198850e-02f, 2.23088428e-01f, -6.17448576e-02f, 1.74991786e-01f,
  3.04504156e-01f, -2.88357973e-01f, -1.57114699e-01f, 2.73151379e-02f, -1.20909192e-01f, 1.49004385e-01f, -1.33745506e-01f, 1.94224924e-01f, 1.38449594e-01f, 2.92243570e-01f,
  -7.91212097e-02f, -2.30617356e-02f, 4.65259627e-02f, -1.88796639e-01f, 1.28666639e-01f, -9.54586491e-02f, 2.82140851e-01f, -2.45548517e-01f, -1.63497940e-01f, -2.62290984e-01f,
  4.01740342e-01f, 8.68246481e-02f, 2.65046120e-01f, 6.51068613e-02f, -8.53897780e-02f, 2.29305759e-01f, -3.24507654e-02f, -3.01749408e-01f, 1.66861303e-02f, 1.41291693e-01f,
  -1.54755518e-01f, 3.14273179e-01f, -1.37641117e-01f, 7.15263486e-02f, 2.16484647e-02f, 5.03434613e-02f, -4.21463884e-02f, 1.93760127e-01f, 2.50671040e-02f, 4.09780666e-02f,
  1.07900403e-01f, 1.41929546e-02f, 6.95696846e-02f, -3.12395673e-02f, 6.92219734e-02f, -4.34664726e-01f, -1.28767207e-01f, 3.47693622e-01f, -1.14836805e-01f, -1.79445475e-01f,
  3.17790955e-01f, -3.69046628e-02f, 8.14891979e-02f, 4.75958347e-01f, -1.23619132e-01f, -3.62601206e-02f, -1.39401257e-01f, -8.17608461e-02f, -4.39711660e-02f, -2.78972417e-01f,
  -7.46756271e-02f, -7.90540799e-02f, 7.93126076e-02f, 1.51233226e-01f, 1.01604410e-01f, 2.67954580e-02f, -8.01433995e-02f, 5.33010960e-02f, 2.66023353e-02f, 9.01599079e-02f,
  2.61391308e-02f, -1.72999769e-01f, -1.85578778e-01f, 3.88203934e-02f, 1.93446919e-01f, -5.50806709e-02f, 5.55566438e-02f, -4.03073281e-02f, -1.69054836e-01f, -5.45066595e-03f,
  7.96119049e-02f, -9.00716782e-02f, -2.81011276e-02f, -3.42126817e-01f, -1.65095732e-01f, 4.74533532e-03f, 1.43901125e-01f, -2.71037649e-02f, -7.10529611e-02f, 2.75643412e-02f,
  3.00128926e-02f, -2.72065550e-01f, 1.99670680e-02f, -1.23078004e-01f, -3.94488931e-01f, 2.98588239e-02f, 7.79141262e-02f, -1.20561972e-01f, 1.71747684e-01f, 1.39073446e-01f,
  -2.72602588e-01f, 1.29791396e-03f, 7.11847618e-02f, -1.46121383e-01f, -1.53940707e-01f, -2.85671681e-01f, -7.42959380e-02f, 1.14020370e-01f, 7.48057663e-02f, 1.16013415e-01f,
  3.43034714e-02f, 7.86982849e-02f, -8.40017051e-02f, 1.47948980e-01f, 7.46164918e-02f, -1.28776610e-01f, -1.67146295e-01f, -7.69280270e-02f, 3.37457284e-02f, -3.29225659e-02f,
  1.04723528e-01f, -7.27457851e-02f, -2.84058154e-01f, -3.16900194e-01f, 2.48166978e-01f, -5.55245690e-02f, -3.06518435e-01f, -1.57283276e-01f, 2.25984573e-01f, 9.40788761e-02f,
  -1.44119233e-01f, -9.61318016e-02f, 1.48032948e-01f, -3.55082750e-02f, 1.69241652e-01f, -1.38084158e-01f, 1.42444015e-01f, -1.66291624e-01f, 2.66248047e-01f, -3.12522310e-03f,
  -5.99746108e-02f, -2.36133318e-02f, 2.38519266e-01f, -5.88322841e-02f, -3.57583910e-01f, -1.06061168e-01f, -3.26219550e-03f, -2.29043543e-01f, -3.24930549e-01f, 1.62025928e-01f,
  -8.51674005e-02f, -3.90430182e-01f, 1.98090851e-01f, 8.25757235e-02f, -1.14828505e-01f, -1.57141611e-01f, 2.94430871e-02f, -1.60623521e-01f, 1.43336430e-01f, -2.34526083e-01f,
  2.73591075e-02f, -2.00116247e-01f, 9.74079520e-02f, 6.99881464e-02f, 2.87326783e-01f, -2.10375302e-02f, -3.47815275e-01f, -1.99095413e-01f, 1.47467077e-01f, 6.80907965e-02f,
  1.28654256e-01f, -1.02373794e-01f, 3.50418657e-01f, -2.31603026e-01f, -1.09781988e-01f, -1.81322932e-01f, 4.63184938e-02f, -3.31804305e-02f, -2.10804284e-01f, -1.54169589e-01f,
  9.51494873e-02f, -1.79500550e-01f, -1.87865347e-01f, -1.59859866e-01f, 5.34092449e-03f, -3.31757903e-01f, 4.27964032e-01f, -1.63251340e-01f, -3.03647369e-02f, 1.80185474e-02f,
  1.42479464e-01f, -4.18628519e-03f, -1.03170365e-01f, -1.33059174e-02f, 2.58672804e-01f, 1.59948040e-02f, 3.17132361e-02f, 7.59655908e-02f, -3.16715874e-02f, -4.37611677e-02f,
  -3.85721475e-02f, -6.71747625e-02f, -7.73520768e-02f, 2.59650182e-02f, 1.26790106e-02f, 7.36654922e-02f, -1.48600742e-01f, 1.09404624e-01f, -5.45696616e-02f, -2.20047291e-02f,
  -1.32999435e-01f, 4.96634431e-02f, -8.94400626e-02f, -1.29877374e-01f, 8.75347182e-02f, -7.58319814e-03f, 7.58119076e-02f, 9.50272530e-02f, 6.72841072e-02f, 8.31914842e-02f,
  6.67961016e-02f, 9.42226201e-02f, 1.53791219e-01f, 7.40112439e-02f, -3.38606209e-01f, -1.70655083e-02f, -6.89452067e-02f, 3.59705538e-02f, 7.86797926e-02f, -1.31901786e-01f,
  5.54704219e-02f, 1.37254819e-01f, 1.89779550e-01f, -8.16314444e-02f, -1.36162922e-01f, 2.89188325e-02f, 8.78395140e-02f, 7.78621957e-02f, -6.98608235e-02f, 8.65592211e-02f,
  7.68003687e-02f, -3.07506211e-02f, 6.83681294e-02f, -1.30406627e-02f, 1.21040776e-01f, 4.66910563e-02f, -2.22671032e-02f, -1.27055466e-01f, 4.08728629e-01f, -1.40388176e-01f,
  -8.21910426e-02f, 2.64259636e-01f, 1.95896968e-01f, -3.06873560e-01f, 1.11228682e-01f, 2.24706735e-02f, -2.10025951e-01f, 9.53752175e-02f, -1.21228673e-01f, -2.50794828e-01f,
  2.11650357e-01f, 2.42228225e-01f, 1.16656944e-01f, -1.32302120e-01f, -2.86824524e-01f, -2.09156834e-02f, -2.71771342e-01f, 1.35658175e-01f, 1.18370734e-01f, 4.54917215e-02f,
  -2.81875700e-01f, 1.87283397e-01f, -2.73714900e-01f, 1.39459074e-01f, -2.84994338e-02f, 3.11196238e-01f, 2.12239817e-01f, -2.87334383e-01f, -2.15264633e-01f, 3.36690284e-02f,
  -2.62218803e-01f, -3.92509699e-01f, -3.90446186e-02f, 2.16009513e-01f, 1.51834354e-01f, -2.33442426e-01f, 2.39256859e-01f, -1.27162918e-01f, -2.93768764e-01f, 1.46264866e-01f,
  2.35678121e-01f, -3.63907479e-02f, 8.02358799e-03f, 4.17341590e-02f, -1.19020291e-01f, 1.89956158e-01f, -1.76554039e-01f, 1.43851832e-01f, 1.13942670e-02f, 9.14109424e-02f,
  -3.49249281e-02f, -8.23129639e-02f, -3.45695689e-02f, -1.41312450e-01f, 3.11910249e-02f, 3.06788892e-01f, -2.50989079e-01f, 5.31660467e-02f, 9.25167575e-02f, -1.69994861e-01f,
  7.14767426e-02f, 2.02013835e-01f, -4.99428697e-02f, -2.70810947e-02f, 1.80927023e-01f, -8.23348612e-02f, 2.47374047e-02f, -2.11355969e-01f, -6.21170066e-02f, -6.50936365e-02f,
  2.59194106e-01f, -6.75023571e-02f, -6.55757934e-02f, -2.06266250e-02f, 8.18415079e-03f, -1.36531040e-01f, 4.26501818e-02f, -3.14632654e-02f, -5.75336441e-02f, 3.83590758e-02f,
  -1.99611500e-01f, -2.08487764e-01f, -2.04784617e-01f, -4.96842153e-02f, 3.92073795e-04f, 1.33509189e-01f, 5.15377596e-02f, 8.27752501e-02f, 6.03135861e-03f, -2.62895250e-03f,
  1.13121904e-01f, -1.56067342e-01f, -2.54192412e-01f, 3.72694759e-03f, -7.91314021e-02f, 3.27565260e-02f, -2.27290671e-02f, 7.07102045e-02f, -7.16148168e-02f, 1.93984732e-02f,
  2.07627323e-02f, -8.65081027e-02f, 6.66738674e-03f, 1.44420117e-01f, -1.20737240e-01f, 7.03322738e-02f, -1.56489924e-01f, -1.02179438e-01f, 1.96576528e-02f, 1.42594390e-02f,
  -2.24435136e-01f, 7.64443725e-02f, -3.71948808e-01f, 6.41932636e-02f, 1.40553834e-02f, 9.45828110e-02f, -2.09508225e-01f, -2.86033422e-01f, -4.42260988e-02f, -2.72027940e-01f,
  -2.22329363e-01f, 7.88582116e-02f, 2.49298736e-02f, 1.95293482e-02f, 9.71123353e-02f, -2.07163263e-02f, -1.01569586e-01f, 6.30421117e-02f, -1.89745635e-01f, -8.39582160e-02f,
  2.38029599e-01f, 2.30894327e-01f, -3.63464713e-01f, 2.45826766e-01f, 1.98587686e-01f, 1.84589595e-01f, 6.88421819e-03f, 1.33954599e-01f, -2.14866158e-02f, 6.25601560e-02f,
  4.65488469e-04f, -1.11262083e-01f, -2.15510279e-01f, 1.78880960e-01f, -2.23863095e-01f, -2.43897960e-01f, -2.94067673e-02f, 6.21404545e-03f, -2.63411194e-01f, -1.26504123e-01f,
  -2.01500684e-01f, 6.12012334e-02f, 1.06327146e-01f, 1.71756372e-01f, -1.58900768e-01f, -3.13677043e-01f, 1.42380700e-03f, 2.20206276e-01f, -2.17624873e-01f, -1.05196528e-01f,
  -3.37429717e-02f, -1.84003145e-01f, 6.29200563e-02f, -3.68016720e-01f, -1.40154302e-01f, 5.35281859e-02f, -3.58591415e-02f, 9.87497717e-02f, -2.24685565e-01f, 4.18554321e-02f,
  -1.17015250e-01f, 2.54276246e-01f, -2.58346975e-01f, -1.39119521e-01f, -1.63224697e-01f, -1.07244365e-02f, -3.46036977e-03f, -8.29647630e-02f, -4.64968644e-02f, -9.76566821e-02f,
  1.29375070e-01f, -1.72950059e-01f, 1.49710134e-01f, 1.32707879e-01f, 3.00137371e-01f, 1.67044044e-01f, -1.51164457e-02f, -2.72413433e-01f, -1.75176263e-01f, -5.02858916e-03f,
  4.34286855e-02f, -2.89662093e-01f, 1.37554824e-01f, 4.26909067e-02f, 2.14868978e-01f, 1.44821003e-01f, 2.28693992e-01f, 1.32456914e-01f, 1.63448855e-01f, 4.42357175e-02f,
  -1.91263348e-01f, -2.85494737e-02f, -7.39134476e-02f, 2.62311175e-02f, 8.09467062e-02f, 1.71289325e-01f, 8.25887844e-02f, 1.24210916e-01f, -1.80700392e-01f, 1.52963087e-01f,
  -2.45693773e-02f, 8.56447220e-02f, 1.99695617e-01f, 2.38399357e-02f, -3.31868269e-02f, -4.19918187e-02f, -7.53602758e-03f, -5.19029126e-02f, -1.19824052e-01f, -6.11835308e-02f,
  -2.85313547e-01f, -1.27330408e-01f, -4.68184315e-02f, -3.94492084e-03f, -5.77994585e-02f, -2.59655386e-01f, 1.23793297e-01f, 1.51317134e-01f, -1.16470262e-01f, 9.86691937e-03f,
  1.83929831e-01f, 2.31678367e-01f, -3.86008471e-02f, 6.73127249e-02f, 1.52946889e-01f, -6.42853081e-02f, -1.65825367e-01f, -3.76582555e-02f, -2.41919998e-02f, -1.13250799e-02f,
  4.73161004e-02f, -5.64242341e-02f, 6.10999158e-03f, -2.02516198e-01f, 1.32678688e-01f, 1.03524275e-01f, 1.68185189e-01f, 9.76526812e-02f, 9.55855623e-02f, 3.27864476e-02f,
  9.87385027e-03f, 4.92063984e-02f, 1.34732306e-01f, -2.02101901e-01f, 4.73602340e-02f, 9.48887467e-02f, -9.07428712e-02f, 2.40018174e-01f, -1.18550994e-01f, -4.47047651e-01f,
  4.99472544e-02f, -3.18136722e-01f, -1.32420644e-01f, -7.80453235e-02f, -2.61270583e-01f, -2.52120942e-01f, 2.89467871e-01f, -8.20978656e-02f, 2.24243477e-01f, -2.44962633e-01f,
  2.72078127e-01f, -4.72876847e-01f, 1.96781024e-01f, -1.07060177e-02f, -3.33841443e-01f, -9.75364521e-02f, 6.32847622e-02f, 1.34058058e-01f, 3.43311690e-02f, -1.08658776e-01f,
  -5.61303226e-03f, -9.84011684e-03f, 1.35921806e-01f, 1.89988628e-01f, -8.09110701e-02f, -2.45900348e-01f, 4.46960092e-01f, 2.62290418e-01f, -1.73778102e-01f, -7.63743296e-02f,
  3.95838171e-01f, 4.74702306e-02f, -1.74307153e-02f, 1.38853207e-01f, 2.53201574e-01f, -1.41081288e-01f, 5.20724654e-02f, -1.79880932e-01f, 2.99213171e-01f, -9.30272788e-02f,
  1.64493490e-02f, -1.21631399e-01f, -3.96927074e-02f, -2.32830763e-01f, 5.37086977e-03f, 1.79162040e-01f, -1.69405401e-01f, -1.36921436e-01f, -1.35540450e-02f, -7.35732093e-02f,
  1.51065728e-02f, 1.63416237e-01f, -3.49218756e-01f, 2.68180192e-01f, 7.23067671e-02f, 2.42530882e-01f, -9.10953805e-02f, 2.29758859e-01f, 1.52228221e-01f, -1.79528538e-03f,
  1.53555691e-01f, 4.38210182e-03f, -1.38391942e-01f, -1.66140437e-01f, 1.63583130e-01f, -3.23427692e-02f, 3.43190171e-02f, -7.73436055e-02f, 6.32010028e-02f, 9.19246394e-03f,
  -1.13591455e-01f, -4.06882763e-01f, -3.31934430e-02f, 4.04031202e-03f, -6.23660646e-02f, -3.51880006e-02f, 1.36002693e-02f, 1.38972342e-01f, 3.12431511e-02f, 6.79994747e-02f,
  9.37295780e-02f, -1.63601592e-01f, 1.43891026e-03f, 5.97013906e-02f, 8.83673504e-02f, 5.28931618e-02f, 1.05952777e-01f, 5.14505841e-02f, 3.14513892e-02f, 4.87099811e-02f,
  -1.01004981e-01f, -1.17110170e-01f, -7.61620328e-02f, 7.52447620e-02f, -7.13063031e-02f, 3.57320905e-02f, 6.96943849e-02f, -2.25111376e-02f, 8.55028257e-02f, 2.34009977e-02f,
  3.02567966e-02f, -6.20329846e-03f, -1.41747847e-01f, -1.06584460e-01f, 3.68713997e-02f, 7.12214410e-02f, -1.70844406e-01f, 5.52540878e-03f, 1.65578291e-01f, 6.02431186e-02f,
  1.04101025e-01f, 5.97855225e-02f, -7.73657039e-02f, -2.15381175e-01f, 5.56105748e-02f, 1.54517114e-01f, 1.04321972e-01f, -1.64185196e-01f, 1.70400925e-02f, 9.33239236e-02f,
  8.04505199e-02f, -2.42800534e-01f, -1.61482036e-01f, 3.07607532e-01f, 1.73042402e-01f, 1.85377359e-01f, -1.76429436e-01f, 1.86523497e-01f, -2.66764052e-02f, 5.07058352e-02f,
  1.08239196e-01f, -5.76649196e-02f, 2.12078437e-01f, -5.68361655e-02f, -1.59504265e-01f, -3.10162872e-01f, 4.06382941e-02f, 1.45766705e-01f, 1.42732754e-01f, -1.14415754e-02f,
  -8.23125318e-02f, -2.23608062e-01f, 9.83603746e-02f, 2.73471624e-01f, 1.20182727e-02f, 3.35365087e-02f, -2.50780460e-04f, 2.86179394e-01f, -1.70185283e-01f, 9.06859562e-02f,
  1.55817583e-01f, 5.12933359e-02f, 1.41316047e-02f, -7.63038499e-03f, -1.38364255e-01f, -6.80442676e-02f, 2.90418088e-01f, -2.13145792e-01f, -3.04946065e-01f, 1.37223015e-02f,
  -1.40221585e-02f, -1.02089837e-01f, 1.53628349e-01f, 7.54098967e-02f, -1.11105748e-01f, -4.64836419e-01f, 6.11669235e-02f, -3.90512496e-01f, 2.28501827e-01f, 2.66893029e-01f,
  -2.88571447e-01f, -1.35082737e-01f, 1.60446651e-02f, 2.46812357e-03f, -1.13481186e-01f, -2.42588129e-02f, 1.42727852e-01f, 8.25702623e-02f, -8.32944959e-02f, 2.26096883e-01f,
  1.45146608e-01f, 1.40306398e-01f, 9.68569219e-02f, -3.31774771e-01f, -1.13474064e-01f, -8.34005848e-02f, 2.79074758e-01f, 4.91254963e-02f, -1.65911436e-01f, 3.30934644e-01f,
  -9.91629213e-02f, 3.64166588e-01f, 1.09607698e-02f, -1.42916530e-01f, -2.19232500e-01f, 1.41882762e-01f, 9.63082071e-03f, 1.81962643e-02f, 3.03251557e-02f, 1.43632576e-01f,
  9.54068601e-02f, -3.79772544e-01f, -2.29023024e-02f, -2.55559415e-01f, -7.83989727e-02f, -4.95813377e-02f, 1.23883143e-01f, -3.12878005e-02f, -2.26561546e-01f, 9.82996598e-02f,
  -4.66954671e-02f, 9.56958905e-02f, 9.52818841e-02f, 9.01070833e-02f, 8.41474161e-02f, 9.07018036e-02f, 3.97466570e-02f, 9.57446098e-02f, 6.72086403e-02f, -9.35798511e-02f,
  -5.28891431e-03f, 1.48041800e-01f, 3.72853503e-02f, -1.17167793e-02f, 6.23115040e-02f, -1.29324704e-01f, 1.51713312e-01f, -8.75842422e-02f, -2.76439726e-01f, -5.31496480e-03f,
  1.90935329e-01f, 8.27684626e-02f, 1.24555379e-01f, 1.50399327e-01f, -5.92989437e-02f, -1.07889101e-01f, 2.03206226e-01f, -1.44108627e-02f, 5.86865284e-02f, -1.82081442e-02f,
  1.38014078e-01f, 1.49265215e-01f, -1.43366084e-01f, 1.26969054e-01f, 1.64726824e-01f, 1.08439051e-01f, -2.86404230e-03f, -2.71085083e-01f, -2.25968778e-01f, 7.28642792e-02f,
  -1.13592274e-01f, 1.76182240e-01f, -1.97276056e-01f, -2.79519428e-03f, 2.66969293e-01f, 3.63832474e-01f, -1.95470721e-01f, 3.52527015e-03f, 2.56273806e-01f, 1.82815671e-01f,
  9.25782472e-02f, 2.14112282e-01f, 2.06539512e-01f, -2.26549566e-01f, 2.19074622e-01f, 1.52923828e-02f, -2.67296936e-02f, 2.29566872e-01f, 1.65359989e-01f, 2.69612342e-01f,
  2.45754048e-01f, 8.35550502e-02f, -1.15196846e-01f, -2.27345318e-01f, -1.42085537e-01f, -9.36696827e-02f, 1.66459560e-01f, -2.39811271e-01f, -2.69566506e-01f, -3.94012600e-01f,
  2.21508890e-01f, -1.03867732e-01f, -8.74771178e-02f, -1.48307174e-01f, -5.68799935e-02f, -4.49910313e-02f, 2.40054950e-01f, 4.05432731e-02f, -1.33319452e-01f, -1.54231802e-01f,
  -2.03530982e-01f, -2.65641451e-01f, 2.35544965e-01f, 2.62679249e-01f, -1.31808519e-01f, -1.05949230e-01f, 8.19661766e-02f, -1.47176847e-01f, 2.54316926e-01f, 1.07710525e-01f,
  -1.52735800e-01f, 9.60752219e-02f, 2.94354737e-01f, -8.18721130e-02f, 4.92367186e-02f, 1.18321463e-01f, 4.43627089e-02f, -2.12358713e-01f, 8.34348723e-02f, 2.32831528e-03f,
  -1.23840505e-02f, -1.17249496e-01f, -5.73837496e-02f, 6.68222085e-03f, -5.89568634e-03f, -2.03069091e-01f, 2.44823039e-01f, -1.68837041e-01f, 7.59954676e-02f, 1.08835883e-01f,
  1.22711793e-01f, 4.06228425e-03f, -3.94331440e-02f, -3.74598764e-02f, -1.99290842e-01f, 7.04558343e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.12401582e-02f, -7.75044365e-03f, 1.22238509e-02f, 2.77459957e-02f, -1.94611717e-02f, 5.92757426e-02f, -1.72848683e-02f, -4.03024592e-02f, -1.02628872e-01f, -5.27283140e-02f,
  8.36419966e-03f, -5.80568165e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    