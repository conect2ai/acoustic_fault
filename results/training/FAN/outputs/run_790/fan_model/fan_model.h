/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.35431468e-01f, -4.94871698e-02f, -2.08025068e-01f, -4.68882471e-01f, -9.50709451e-03f, 2.07222272e-02f, 4.33727680e-03f, -1.66731611e-01f, -5.84023744e-02f, -1.32265493e-01f,
  1.04582883e-01f, 2.95590758e-01f, 2.17456356e-01f, 2.72495896e-01f, 1.02353334e-01f, -8.33321959e-02f, -1.46113664e-01f, -6.81150332e-02f, 1.53701007e-01f, 2.91634984e-02f,
  5.90838455e-02f, -1.68502808e-01f, -1.89278051e-01f, 2.38083079e-02f, -1.05533868e-01f, 1.22858867e-01f, 2.75881635e-03f, -6.64368793e-02f, 1.97085947e-01f, -1.07475124e-01f,
  1.23597980e-01f, -2.87313700e-01f, 8.61920342e-02f, 4.18782495e-02f, 2.88447216e-02f, -4.08708751e-02f, -5.95459761e-03f, -4.19568010e-02f, 4.36313972e-02f, -6.72804713e-02f,
  -4.34080400e-02f, 4.45471928e-02f, 1.84448306e-02f, 6.66874647e-02f, -1.52580813e-01f, 1.95789244e-02f, -4.82662395e-02f, -1.63045749e-02f, 3.44725838e-03f, -5.78464242e-03f,
  1.14634216e-01f, -4.61329445e-02f, -8.98216963e-02f, 9.00589526e-02f, 3.35093997e-02f, 1.05115905e-01f, 6.03603795e-02f, 1.83866974e-02f, 8.27645361e-02f, -1.82992771e-01f,
  5.16045764e-02f, -1.70119535e-02f, -7.09697779e-04f, -5.00113964e-02f, 2.80954577e-02f, 8.33970029e-03f, -4.51990031e-02f, 1.35203786e-02f, 1.82588436e-02f, -6.61765933e-02f,
  6.02761246e-02f, -1.81669928e-02f, 1.96511112e-03f, -5.70522584e-02f, 4.03537117e-02f, -3.79087776e-02f, -5.28837256e-02f, -5.44100478e-02f, 7.54695386e-02f, -1.14452383e-02f,
  3.15878354e-02f, -7.13384151e-03f, -5.73954433e-02f, 4.14507557e-03f, 8.01430568e-02f, -1.36740291e-02f, -2.77226605e-02f, 2.94866730e-02f, 1.65788317e-03f, -3.90601419e-02f,
  2.65647192e-02f, 1.14647321e-01f, -4.79764752e-02f, -4.05280711e-03f, -4.10256162e-02f, 9.48713273e-02f, 3.33916512e-03f, 8.54390487e-02f, 3.27524692e-02f, 1.01432838e-02f,
  2.55474038e-02f, -2.15181448e-02f, -1.13772294e-02f, 1.18294396e-02f, -3.74999344e-02f, -3.49350795e-02f, 4.34058011e-02f, -1.50960172e-02f, 7.07393140e-02f, -1.14422021e-02f,
  4.65027466e-02f, -8.07090253e-02f, -6.76337183e-02f, -3.90921049e-02f, -2.58050747e-02f, 2.40794960e-02f, -1.92900766e-02f, -5.30143194e-02f, 3.50141004e-02f, -1.90417245e-01f,
  -2.75887877e-01f, 1.11710235e-01f, 3.00929606e-01f, -1.90426335e-01f, -8.99116546e-02f, 1.34287238e-01f, 4.68730517e-02f, 3.57997045e-02f, -1.78664029e-01f, -1.82966236e-02f,
  1.35177048e-02f, -1.42020434e-01f, -3.75027545e-02f, -3.93213797e-03f, 8.93090442e-02f, 6.61537945e-02f, 4.72585894e-02f, 6.77850395e-02f, -7.89198950e-02f, 4.61752936e-02f,
  -1.96379751e-01f, -1.36798307e-01f, 4.12663110e-02f, 2.00879239e-02f, -1.13494672e-01f, -4.66140836e-01f, 3.81046459e-02f, 7.42350593e-02f, 2.00938940e-01f, -6.98352531e-02f,
  -3.99363637e-02f, 2.47664332e-01f, -6.25647530e-02f, -3.99249233e-02f, 6.85232356e-02f, 3.73177677e-02f, -6.34770691e-02f, -1.92181189e-02f, -6.51014298e-02f, 6.51491946e-03f,
  2.08625793e-02f, 7.17331916e-02f, -6.87984824e-02f, 2.90864129e-02f, -2.17572153e-02f, 3.13217752e-02f, 1.04357474e-01f, 1.34627715e-01f, 7.68025368e-02f, 1.10175319e-01f,
  -4.02310602e-02f, 4.12704386e-02f, 1.29030749e-01f, 1.63049206e-01f, 6.33476004e-02f, 7.64651829e-03f, 1.73308462e-01f, 5.26821166e-02f, 8.30352604e-02f, -1.51009232e-01f,
  -2.44013462e-02f, 8.12489819e-03f, 5.32734804e-02f, 3.99356782e-02f, -2.37126835e-02f, 1.05658069e-03f, 8.74225423e-03f, -3.62615958e-02f, 5.73398592e-03f, 3.52318622e-02f,
  1.14638731e-02f, 3.78688448e-04f, -2.52017695e-02f, -1.70287173e-02f, -3.54372896e-02f, 9.95278358e-02f, 1.06903315e-02f, -1.70418881e-02f, 4.05207612e-02f, 5.57458363e-02f,
  4.66428660e-02f, 8.40339065e-02f, -2.84228940e-02f, 6.87117428e-02f, 7.03752339e-02f, 2.07684953e-02f, 2.06305459e-02f, 3.24673466e-02f, 1.22627849e-02f, -7.51968250e-02f,
  -3.43469203e-01f, 1.21154986e-01f, -2.27738559e-01f, -9.95351840e-03f, -1.38969585e-01f, -8.81385431e-03f, -4.50982004e-02f, 2.66964361e-02f, -8.33999068e-02f, -6.55005053e-02f,
  -1.25270085e-02f, -7.76300803e-02f, -3.23214568e-02f, 5.46569787e-02f, -7.90869892e-02f, -6.94938898e-02f, -1.53349685e-02f, -1.96294412e-01f, 5.36966287e-02f, 1.95920337e-02f,
  1.35934722e-04f, -1.01394825e-01f, -3.05671990e-01f, -1.27342150e-01f, -1.50147334e-01f, -2.97720551e-01f, -1.16275683e-01f, -2.07861125e-01f, -2.04214066e-01f, -4.90917444e-01f,
  -1.29746541e-01f, -1.05416410e-01f, 4.00054455e-01f, -3.82589459e-01f, 3.43637466e-01f, 3.54636759e-01f, 5.08678913e-01f, 6.77003562e-02f, -3.09848338e-01f, 3.74266319e-02f,
  4.03458849e-02f, -2.61354804e-01f, -1.31410122e-01f, -2.48978082e-02f, -3.30457911e-02f, 1.13200732e-01f, 1.12953566e-01f, 5.16989231e-02f, 2.40721047e-01f, 1.02236837e-01f,
  -1.11563854e-01f, -1.80346549e-01f, -2.56121129e-01f, 2.62387376e-02f, -1.89714894e-01f, -1.69809703e-02f, 5.04324362e-02f, -1.54328808e-01f, 1.48113981e-01f, -2.13613048e-01f,
  2.18373109e-02f, 1.07236959e-01f, 5.12328669e-02f, -7.62981325e-02f, -2.51420662e-02f, -5.81914708e-02f, -4.49895635e-02f, -1.17785141e-01f, 2.11400762e-02f, -1.07468013e-02f,
  3.25727165e-02f, -1.08628117e-01f, 6.82376698e-02f, -1.77727211e-02f, 7.33768642e-02f, -4.68087420e-02f, -8.98190215e-02f, -5.60291298e-02f, 2.35353746e-02f, 4.78677154e-02f,
  9.66656394e-03f, 1.31765053e-01f, 2.16080189e-01f, 1.52320355e-01f, 6.50065467e-02f, 1.22997798e-01f, 2.52716038e-02f, -7.19342679e-02f, 1.85194075e-01f, -2.05327913e-01f,
  -3.63950469e-02f, -7.54930661e-04f, 3.21171395e-02f, -2.14782972e-02f, 3.89951095e-02f, 1.93847232e-02f, -1.70768891e-02f, 1.86094698e-02f, 2.75733341e-02f, -1.02212289e-02f,
  3.60408872e-02f, 1.90637987e-02f, 3.33955213e-02f, -2.86999140e-02f, -1.23007717e-02f, 3.60333547e-02f, 8.26992765e-02f, -6.27412349e-02f, 9.92931984e-03f, -1.47348056e-02f,
  -2.38774680e-02f, 4.72062826e-02f, -2.69346032e-02f, 2.68513598e-02f, 2.56777350e-02f, 6.94299117e-03f, -6.63881749e-03f, 5.52026089e-03f, -6.55441880e-02f, 1.04967961e-02f,
  -2.17330262e-01f, 2.24382594e-01f, -1.52091429e-01f, 6.73299795e-03f, -1.55689260e-02f, -4.76591401e-02f, 3.52482311e-02f, 3.09260339e-02f, 4.14410867e-02f, -9.46670026e-03f,
  1.80544071e-02f, 6.39001504e-02f, 3.51782329e-02f, 3.53452675e-02f, 6.29942045e-02f, 7.02952668e-02f, -3.12801003e-02f, 5.36346398e-02f, -4.61645946e-02f, -5.48464656e-02f,
  -1.12094201e-01f, 4.74656075e-02f, -6.21777168e-03f, 2.81144939e-02f, -2.52086259e-02f, 8.77848789e-02f, 2.50912588e-02f, -4.19112407e-02f, 1.20376624e-01f, -6.17073812e-02f,
  -2.61299759e-01f, -7.84241420e-04f, 2.02237338e-01f, 4.80396375e-02f, 7.98936635e-02f, -1.15312114e-01f, -2.02318445e-01f, -9.94441882e-02f, -9.69163030e-02f, -4.78236238e-03f,
  3.95826660e-02f, 3.04443650e-02f, 4.50781211e-02f, -5.57031250e-03f, -1.09414943e-01f, 4.20988426e-02f, 1.20995164e-01f, 7.03364089e-02f, -4.31410819e-02f, -1.10429391e-01f,
  1.03405230e-01f, 9.16421413e-02f, -3.55002321e-02f, -6.47703707e-02f, 1.46216780e-01f, -3.61358412e-02f, 1.59211010e-01f, 1.31227404e-01f, 1.06829546e-01f, 4.65156168e-01f,
  1.31181836e-01f, 1.05214611e-01f, -5.26749566e-02f, 2.61135139e-02f, 4.50024344e-02f, -9.44891497e-02f, -5.99109754e-02f, 6.50676116e-02f, -6.60999864e-02f, -1.27151869e-02f,
  3.50447521e-02f, -1.50704966e-03f, 8.06936622e-02f, 5.98463193e-02f, -5.44240735e-02f, -4.16478664e-02f, 1.00927232e-02f, -8.16942751e-03f, -2.40174960e-02f, -1.71931051e-02f,
  8.98543224e-02f, 1.17487468e-01f, 2.99574789e-02f, -6.59478083e-02f, -3.29600610e-02f, 1.10308021e-01f, 3.87705155e-02f, 1.22164994e-01f, -8.03661272e-02f, 5.90640903e-02f,
  -4.39596660e-02f, -2.50002649e-02f, 6.45018816e-02f, 2.63548847e-02f, -8.60686880e-03f, 1.07275639e-02f, 8.43630582e-02f, 2.43426729e-02f, -7.01091718e-03f, -3.64207029e-02f,
  3.19310166e-02f, -8.24389420e-03f, 1.98032223e-02f, -6.31000698e-02f, 1.76733546e-02f, 1.58479214e-02f, 1.60621721e-02f, -8.97912160e-02f, 3.79818678e-02f, -2.00580098e-02f,
  2.87743751e-02f, -3.09356265e-02f, -1.34491082e-02f, 5.09999134e-02f, 6.11967891e-02f, 3.60477227e-03f, 1.92621071e-02f, 1.73650880e-03f, -3.48527692e-02f, -4.99517992e-02f,
  -2.49226928e-01f, -1.13717593e-01f, 1.44358538e-03f, -7.14412928e-02f, 6.35426193e-02f, 3.20622651e-03f, 5.87412529e-02f, -2.45424006e-02f, 3.23177837e-02f, -7.66186789e-02f,
  -1.34423403e-02f, -4.20110784e-02f, -4.12729681e-02f, -3.04049775e-02f, -1.00960143e-01f, -4.14147936e-02f, 2.33812351e-02f, -6.44453801e-04f, 3.20637561e-02f, -8.07938818e-03f,
  -2.71713845e-02f, -7.60251507e-02f, -2.41743118e-01f, -9.62272957e-02f, -2.77033895e-02f, -1.64269105e-01f, -1.57538597e-02f, -1.11909807e-01f, -1.50150329e-01f, -3.63930017e-01f,
  -6.70757651e-01f, 3.01079035e-01f, -3.42282444e-01f, -3.35024655e-01f, -1.24607697e-01f, 1.15479387e-01f, 8.33730102e-02f, 1.26891434e-01f, -2.95996256e-02f, 1.75182391e-02f,
  1.55799121e-01f, -6.19794801e-02f, -7.99054876e-02f, 1.93641882e-03f, -9.67210010e-02f, 1.80346463e-02f, -3.15232635e-01f, -2.31136665e-01f, -1.75319329e-01f, 2.10220367e-01f,
  7.69490302e-02f, -2.15101570e-01f, -1.43429220e-01f, 8.30619484e-02f, 3.22581120e-02f, 1.15614431e-02f, -5.55147268e-02f, -2.55953725e-02f, 1.18127443e-01f, -3.40011209e-01f,
  -1.09548032e-01f, -3.86980282e-05f, -7.16341287e-02f, 2.22803168e-02f, 3.33403759e-02f, 2.00344753e-02f, 1.67311318e-02f, -2.37205382e-02f, 1.12281837e-01f, 7.85326660e-02f,
  -1.86206549e-02f, -6.56818785e-03f, -5.98530211e-02f, -6.32589012e-02f, 4.76108491e-03f, 1.03324261e-02f, 8.28180015e-02f, -3.31925042e-03f, -4.33844849e-02f, 8.40077698e-02f,
  3.07308640e-02f, -2.92389374e-03f, 6.33985968e-03f, 1.17564887e-01f, -2.89948960e-03f, -6.06231354e-02f, 2.20056608e-01f, 1.64953396e-02f, 7.06479177e-02f, 2.33777743e-02f,
  6.22596126e-03f, 5.83616644e-03f, 2.44783540e-03f, -1.96990580e-03f, -4.04988648e-03f, -2.79310960e-02f, 2.41892156e-03f, -8.75646807e-03f, 4.83542010e-02f, -3.03598884e-02f,
  3.72915305e-02f, -5.96244540e-03f, -1.96935539e-03f, -2.46746298e-02f, 7.95441587e-03f, 6.82485057e-03f, -1.23152966e-02f, -1.24773178e-02f, -1.68529805e-02f, -1.85966026e-02f,
  1.39532695e-02f, 1.76931154e-02f, -3.65007408e-02f, 7.21264854e-02f, -3.66605334e-02f, -2.09509139e-03f, -5.92261739e-03f, 3.22930031e-02f, -4.56676893e-02f, -1.77743733e-02f,
  5.34289405e-02f, -4.60140444e-02f, -4.22095843e-02f, 3.22000310e-02f, -7.05931708e-02f, 6.90440685e-02f, -6.48166984e-02f, 7.00818077e-02f, -3.44940238e-02f, -2.94935517e-02f,
  2.45213211e-02f, 9.17623751e-03f, -1.08459555e-01f, 7.68551305e-02f, 4.25851829e-02f, 1.04338778e-02f, 2.34047249e-02f, -5.75165115e-02f, 6.34491295e-02f, 7.97836557e-02f,
  2.96685323e-02f, 5.72091863e-02f, -1.52579816e-02f, -2.62646656e-02f, -6.81155408e-03f, -1.32297680e-01f, 1.00198768e-01f, 5.67721538e-02f, -5.51113188e-02f, 1.87447891e-01f,
  4.80506450e-01f, 4.34887886e-01f, -7.30809420e-02f, 1.18807100e-01f, -2.31597587e-01f, -1.15694411e-01f, 1.98049843e-01f, 1.51614502e-01f, -1.31690174e-01f, 3.43485296e-01f,
  1.58902735e-01f, -5.03611974e-02f, -4.81528044e-02f, 1.23339951e-01f, 1.36547685e-01f, 2.72557855e-01f, 6.12335540e-02f, 3.88790630e-02f, -3.59724015e-01f, -1.94004536e-01f,
  -1.80592775e-01f, 2.83366330e-02f, 6.98255077e-02f, -9.52669233e-02f, 1.37848839e-01f, -3.69337574e-02f, 2.04134062e-01f, 9.83491167e-02f, 6.42160848e-02f, 3.91849041e-01f,
  1.57192916e-01f, 2.62946188e-01f, -2.35212266e-01f, 3.85720469e-02f, -7.07998797e-02f, -4.97230999e-02f, -6.88417032e-02f, -2.04248424e-03f, -8.13821182e-02f, 5.24059869e-02f,
  1.06885042e-02f, -7.55895823e-02f, -1.07237339e-01f, 2.18335986e-02f, 6.78101927e-03f, 8.77808481e-02f, 7.11917207e-02f, 2.64895827e-01f, 1.55507311e-01f, 1.01589665e-01f,
  7.45873451e-02f, 1.81442294e-02f, 8.62708539e-02f, 6.06807768e-02f, 1.41155273e-01f, -1.44869564e-02f, 7.75641873e-02f, 2.26485506e-01f, 1.63604602e-01f, 3.92093182e-01f,
  5.63141294e-02f, -6.29071221e-02f, 2.26742215e-02f, -4.02558185e-02f, 7.24660307e-02f, -1.25141013e-02f, -2.82081626e-02f, -2.76954807e-02f, 1.44138783e-02f, -1.90075561e-02f,
  -1.47213377e-02f, 4.94573116e-02f, -2.98438855e-02f, 5.01753166e-02f, -4.79818992e-02f, 8.66907462e-02f, 2.43488103e-02f, 2.88941041e-02f, -4.62364666e-02f, 8.49515498e-02f,
  1.68288145e-02f, -4.05385792e-02f, -1.97437126e-02f, 3.62365246e-02f, 5.40322997e-02f, -1.71803143e-02f, -3.76720689e-02f, -4.22914252e-02f, 1.08968676e-03f, -8.10250342e-02f,
  5.72944432e-02f, -2.24523097e-01f, 2.31709301e-01f, 4.42051366e-02f, -5.03953062e-02f, 2.31496282e-02f, -4.89659123e-02f, 8.68059993e-02f, -4.29881774e-02f, 2.40500085e-02f,
  -2.21167738e-03f, 2.33944207e-02f, 2.86363866e-02f, -6.50887638e-02f, -5.64981028e-02f, -6.14062101e-02f, 8.30295756e-02f, -7.49413222e-02f, -4.84070405e-02f, 3.46195698e-02f,
  4.19388413e-02f, 2.73892228e-02f, -8.11450556e-02f, -2.99900919e-02f, -9.36733335e-02f, -9.82315615e-02f, -4.92776856e-02f, -6.40727878e-02f, -2.64398772e-02f, 1.19485103e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.88524365e-01f, -4.37221169e-01f, -3.71921539e-01f, -1.59677446e-01f, -1.87389463e-01f, -4.36424203e-02f, -1.67584941e-01f, 4.92252745e-02f, 8.09036717e-02f, -2.11659744e-01f,
  1.59192204e-01f, 4.45974290e-01f, 3.27657938e-01f, 3.27279627e-01f, 3.09493512e-01f, -3.44680786e-01f, -3.38156462e-01f, 4.92052287e-02f, 4.96496797e-01f, 3.43506485e-01f,
  4.90008621e-03f, -1.10111587e-01f, 1.91855449e-02f, 6.05068393e-02f, -3.25586319e-01f, 1.32157840e-03f, -4.84377354e-01f, -2.45461673e-01f, -1.42484128e-01f, -4.16676223e-01f,
  -1.71894252e-01f, 1.25085637e-01f, 1.51130021e-01f, 6.62893727e-02f, -2.01601550e-01f, 6.21195370e-03f, 9.55417845e-03f, -1.08983919e-01f, -4.78066737e-03f, -1.08345516e-01f,
  -7.60899344e-03f, 1.79951545e-03f, -2.31081564e-02f, -2.09546648e-02f, -2.24244576e-02f, 2.08015665e-02f, -6.87807752e-03f, 6.87223896e-02f, 5.59809320e-02f, -4.69532944e-02f,
  -1.31502107e-01f, -9.87710338e-03f, -2.81781740e-02f, 5.16791083e-02f, 2.45646015e-01f, 1.51522979e-01f, 4.11508270e-02f, 1.68064430e-01f, 1.19724609e-01f, -1.15262933e-01f,
  1.71167515e-02f, 2.45096465e-03f, 9.03854296e-02f, 2.82224151e-03f, 4.28531170e-02f, 9.15562268e-03f, -2.02450100e-02f, -6.04183003e-02f, 4.40376252e-02f, -2.52318457e-02f,
  -2.75134780e-02f, 5.97540755e-03f, -1.65788680e-02f, 2.95057669e-02f, -3.69041525e-02f, -5.93278073e-02f, 4.13284004e-02f, -8.61830786e-02f, 4.70372178e-02f, -3.70079093e-02f,
  1.07256889e-01f, 2.41363868e-02f, -7.06174821e-02f, 3.16014774e-02f, -2.32215896e-02f, -2.40309890e-02f, 3.76637131e-02f, 7.24216327e-02f, -4.88162600e-02f, -3.88212129e-02f,
  -1.72848821e-01f, 2.34748855e-01f, -4.13188599e-02f, 1.12776801e-01f, -4.50562537e-02f, -2.56955680e-02f, -7.77976289e-02f, 1.07166804e-02f, -1.40838161e-01f, 1.21855466e-02f,
  6.84305131e-02f, 7.56637380e-02f, -1.04569174e-01f, -2.11367682e-02f, 2.35229637e-02f, 4.70480211e-02f, -2.33694669e-02f, 1.46850171e-02f, 5.81478979e-03f, -9.23640057e-02f,
  -1.24934971e-01f, -5.85306995e-03f, 5.38761131e-02f, 4.34062555e-02f, 8.67207497e-02f, 1.06260896e-01f, -6.14359789e-02f, -5.02885357e-02f, 2.08030239e-01f, -1.66506395e-01f,
  -4.93746996e-01f, 8.16008300e-02f, -4.07756418e-02f, 2.67105311e-01f, 4.66557324e-01f, 3.21805894e-01f, 3.20067257e-01f, 6.36856779e-02f, 2.49250665e-01f, 1.22105904e-01f,
  -8.76118708e-03f, 7.53291473e-02f, 1.29314467e-01f, 1.41378433e-01f, 5.90829514e-02f, 2.61366665e-01f, 3.68184805e-01f, -3.88548970e-02f, -7.56560117e-02f, 9.80192795e-02f,
  2.08288431e-01f, -6.36575818e-02f, -3.27538371e-01f, 4.41213846e-02f, 1.71557188e-01f, 2.67897427e-01f, 3.78594473e-02f, -1.50628015e-01f, -1.25119790e-01f, 2.40270674e-01f,
  -3.52044135e-01f, -1.52479440e-01f, 2.12180659e-01f, 1.66134555e-02f, -7.25149065e-02f, -1.86291218e-01f, -4.02723774e-02f, -1.67456701e-01f, -9.45628732e-02f, 1.60503723e-02f,
  -4.47078608e-02f, -1.03308864e-01f, 9.72987711e-02f, -5.50584914e-03f, -1.63929731e-01f, -8.26322660e-02f, -1.59952387e-01f, -5.46649471e-02f, 1.27140746e-01f, 1.66174173e-02f,
  1.95255995e-01f, 5.13742380e-02f, -1.03597410e-01f, 1.42830297e-01f, 6.89904317e-02f, 8.93674940e-02f, 1.99290141e-02f, 3.89095843e-02f, -3.43884192e-02f, -1.37132302e-01f,
  3.15654054e-02f, -7.48947337e-02f, 1.43027633e-01f, -2.61986479e-02f, 1.63868349e-02f, 2.75715683e-02f, 5.96228763e-02f, 2.02095415e-02f, 9.65626985e-02f, -9.49248523e-02f,
  7.36312270e-02f, 8.05734023e-02f, 1.55792627e-02f, 5.73357269e-02f, 5.62774278e-02f, -2.84037106e-02f, 4.21394041e-04f, -2.19179057e-02f, 2.51627713e-03f, -1.13441665e-02f,
  -9.67262536e-02f, 4.81557362e-02f, -9.41636637e-02f, 3.64746107e-03f, -3.67450453e-02f, 6.75097778e-02f, -8.73255879e-02f, -6.20660521e-02f, -5.92136346e-02f, -1.03601888e-01f,
  -2.23320015e-02f, 9.81630012e-03f, 9.35128108e-02f, -3.05777118e-02f, -4.69965162e-03f, -9.12037864e-02f, 5.67007326e-02f, 3.07198763e-02f, 1.01602431e-02f, -1.37345754e-02f,
  -1.41629800e-01f, -1.07107706e-01f, -1.40489843e-02f, -1.38893604e-01f, -1.51490822e-01f, -2.40526628e-02f, 5.32584684e-03f, 5.56671359e-02f, -1.72914844e-02f, -7.26624113e-03f,
  1.30098965e-02f, 5.49802594e-02f, -1.39208987e-01f, 3.85499187e-02f, 4.36029769e-02f, 6.24419227e-02f, -1.05615005e-01f, -4.66957353e-02f, -1.40017226e-01f, -3.48999351e-02f,
  -1.19220853e-01f, -1.25253856e-01f, -3.13153684e-01f, 1.50772497e-01f, -2.14865990e-02f, -9.55705196e-02f, -5.49338534e-02f, 4.53464836e-02f, 2.16608241e-01f, 9.49775055e-02f,
  5.48353419e-02f, -8.79117996e-02f, -3.59693579e-02f, -1.66822270e-01f, -2.67820001e-01f, -1.62532657e-01f, -3.09662133e-01f, -3.84526491e-01f, -3.92014205e-01f, -1.87039599e-01f,
  -1.41230375e-01f, -1.42661422e-01f, -2.45610788e-01f, -5.51757142e-02f, 2.05612838e-01f, -6.52610585e-02f, 1.01195602e-02f, -3.12140938e-02f, -4.39410470e-02f, 1.01148173e-01f,
  -1.55230805e-01f, 2.01177835e-01f, -8.97056609e-02f, -8.07016566e-02f, -1.26708373e-01f, 7.21840486e-02f, -9.96280834e-03f, -1.06422983e-01f, 4.91506830e-02f, 3.75623703e-02f,
  -3.32234204e-02f, -2.11059917e-02f, -1.21355476e-02f, 2.47233119e-02f, -3.36426757e-02f, -4.28763144e-02f, -5.70210963e-02f, -1.08635277e-01f, -5.39138913e-02f, 9.17894840e-02f,
  1.28190350e-02f, -5.36487363e-02f, -9.85704362e-02f, 3.25249545e-02f, 1.20859174e-02f, -1.16081081e-01f, 7.81861022e-02f, 1.93841740e-01f, -5.27163930e-02f, 1.96180269e-01f,
  7.55658448e-02f, -2.10899506e-02f, 1.59560237e-02f, 1.81278326e-02f, 1.98298506e-02f, 7.17835203e-02f, 7.58912694e-03f, -2.02941615e-02f, 1.94785893e-02f, -3.85318324e-02f,
  -1.48281530e-02f, 4.93383184e-02f, 3.27815078e-02f, -2.23261695e-02f, 5.94784459e-03f, -2.35115690e-03f, -5.68388738e-02f, -1.28532574e-02f, -6.59547001e-02f, -2.89877281e-02f,
  -8.13099071e-02f, 3.85138728e-02f, -3.09414584e-02f, -4.75471728e-02f, -1.38809374e-02f, 1.12599209e-02f, -2.34334059e-02f, 4.96346131e-02f, 1.26301229e-01f, 5.81152446e-04f,
  3.85826528e-02f, -1.22318655e-01f, 4.17929105e-02f, -1.10239517e-02f, 1.09985741e-02f, 1.99129805e-03f, 1.07675508e-01f, -3.51462550e-02f, -5.28025031e-02f, 1.14419637e-02f,
  -7.97937959e-02f, 2.47661620e-02f, 2.67716590e-02f, 2.68766726e-03f, -8.71868208e-02f, 2.30807979e-02f, -1.01374589e-01f, -1.30034655e-01f, -1.47646040e-01f, 8.66625160e-02f,
  -5.53662255e-02f, -2.07814038e-01f, -1.67095602e-01f, -3.01172417e-02f, 1.18566202e-02f, -1.26746073e-01f, -1.37339264e-01f, 4.23624329e-02f, -1.58522367e-01f, -1.71120733e-01f,
  5.71178854e-01f, -1.30175911e-02f, -5.69863379e-01f, 2.95607597e-01f, -1.91773027e-02f, -1.34038553e-01f, -3.40185106e-01f, -1.06351547e-01f, 1.78604856e-01f, -7.53444657e-02f,
  8.71847495e-02f, 3.05626541e-01f, 4.28223535e-02f, -4.65387665e-02f, -1.24167338e-01f, -5.31688511e-01f, -5.24813712e-01f, -3.04290831e-01f, -1.07434586e-01f, 2.29566470e-02f,
  1.95279241e-01f, 1.00696750e-01f, 1.19992942e-01f, -5.09636551e-02f, 3.78907099e-02f, 1.48816705e-01f, -1.70814246e-01f, 3.19115743e-02f, -6.42056242e-02f, 5.67172691e-02f,
  -1.13744423e-01f, -1.63161773e-02f, -5.71977906e-03f, 1.47362247e-01f, -1.00517075e-03f, -1.56310666e-02f, -2.80054659e-02f, -5.18502146e-02f, 5.39266355e-02f, 1.27906157e-02f,
  7.85032511e-02f, 1.66503489e-02f, 7.24634156e-02f, 6.83148876e-02f, 3.33148390e-02f, -1.89894550e-02f, -1.29086688e-01f, -2.12700456e-01f, -1.20460853e-01f, 1.40929800e-02f,
  1.56153023e-01f, 1.04995668e-01f, -6.92833140e-02f, -8.47139210e-02f, -1.85518607e-01f, 2.14638095e-02f, -1.85563833e-01f, -1.26373619e-01f, -6.81036189e-02f, 5.36349230e-02f,
  -3.54226120e-02f, -1.56919733e-02f, -3.22843865e-02f, -8.91211675e-04f, 2.91224979e-02f, 2.70792190e-02f, -3.15526389e-02f, 4.04194929e-02f, -1.82139259e-02f, -7.65741244e-03f,
  -2.73974165e-02f, 7.12552434e-03f, 7.30738975e-03f, -3.42700668e-02f, -4.78823595e-02f, 4.38224450e-02f, 6.64833933e-02f, -5.96305579e-02f, 1.70976352e-02f, 2.91524623e-02f,
  2.19110269e-02f, -3.49247009e-02f, 1.85039807e-02f, 2.79446156e-03f, 1.79811672e-03f, -5.39588220e-02f, 4.93639857e-02f, 6.63246401e-03f, 2.50972137e-02f, 2.08579339e-02f,
  2.66275376e-01f, -1.37996003e-01f, 9.61772501e-02f, -9.28246006e-02f, 7.30896816e-02f, 2.40026545e-02f, 7.54802823e-02f, -4.90091462e-03f, 1.59352779e-01f, -1.77368207e-03f,
  -1.10354449e-03f, 2.78073866e-02f, 8.99422634e-03f, 2.26422939e-02f, 3.23795564e-02f, -6.21957099e-03f, 9.50919688e-02f, 2.93844510e-02f, 1.09224934e-02f, 5.46577983e-02f,
  4.42384668e-02f, 9.20183520e-05f, 1.02727212e-01f, 2.78618038e-02f, 2.25576293e-02f, 7.11094216e-02f, -1.01465896e-01f, -1.83763506e-03f, -5.62279969e-02f, -2.84991208e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.84528112e-01f, 2.02100575e-02f, 2.29024649e-01f, 2.16944203e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.82970804e-01f, 4.43664879e-01f, -5.21412268e-02f, -3.47806722e-01f, 9.27378163e-02f, -1.59222096e-01f, -8.73215348e-02f, 1.34166434e-01f, -8.45360219e-01f, 5.05876184e-01f,
  -5.32443047e-01f, -3.41255143e-02f, 4.39246088e-01f, -2.74479926e-01f, -1.85319737e-01f, 5.54734886e-01f, 4.36415151e-02f, -3.34839523e-02f, -1.70653954e-01f, -2.32050158e-02f,
  2.93105274e-01f, 7.72190001e-03f, -3.14136893e-01f, 5.57290971e-01f, 4.61269200e-01f, 4.59966183e-01f, -5.47575295e-01f, -1.85200386e-02f, -2.64421701e-01f, 3.79482388e-01f,
  -4.13975306e-02f, -5.29168546e-01f, 1.60934538e-01f, -9.04346853e-02f, 8.50493759e-02f, 5.95887601e-01f, 2.09719047e-01f, 4.46630493e-02f, 3.03160667e-01f, 6.78244650e-01f,
  2.11199507e-01f, 1.54173732e-01f, 5.04777133e-01f, -3.92801344e-01f, -3.73802006e-01f, -1.01309970e-01f, 2.39520028e-01f, -3.89818370e-01f, -6.68733716e-02f, 4.55184244e-02f,
  1.74477085e-01f, 5.24363965e-02f, -4.62233752e-01f, -3.82258326e-01f, 8.36023211e-01f, 1.72167078e-01f, -4.39212352e-01f, 3.13226312e-01f, 6.30385995e-01f, -3.22948277e-01f,
  -5.37520237e-02f, -2.84043252e-01f, -1.84996687e-02f, -2.52200097e-01f, -9.16756515e-04f, 1.17482124e-02f, -1.34699777e-01f, 1.34808227e-01f, -2.56940484e-01f, -5.17212987e-01f,
  -7.53607035e-01f, 7.24766672e-01f, -1.94652632e-01f, 1.04312092e-01f, -2.74818361e-01f, 3.58178973e-01f, -3.69113237e-01f, -4.50854361e-01f, 5.61840236e-01f, -5.67187928e-02f,
  1.16572298e-01f, 7.79336318e-02f, 2.01158166e-01f, 3.66362631e-01f, -3.21921468e-01f, -6.20438755e-01f, -9.20758545e-02f, 8.41577709e-01f, -3.54155362e-01f, 1.90157339e-01f,
  8.83678272e-02f, 3.04911643e-01f, 4.23032463e-01f, -3.94097030e-01f, 1.41071975e-01f, 4.81236160e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.05546212e-01f, 1.97307533e-03f, 5.14062047e-01f, 2.89959759e-01f, 6.31576180e-01f, 9.28370893e-01f, 3.22110653e-01f, -3.01307559e-01f, 4.67611939e-01f, -8.60376458e-04f,
  -6.23452604e-01f, -8.59058142e-01f, 4.44961250e-01f, 4.75913674e-01f, -2.62782514e-01f, 3.44488695e-02f, 4.88738865e-01f, 7.56365716e-01f, 4.87557650e-01f, -3.07669640e-01f,
  5.43746412e-01f, 1.53770953e-01f, -1.62135959e-01f, 8.79510641e-01f, -9.02938783e-01f, 1.33533847e+00f, -8.61488044e-01f, 3.52806509e-01f, -5.84285736e-01f, 3.60025913e-01f,
  4.47144866e-01f, 6.65246695e-02f, 1.80939302e-01f, 4.92243730e-02f, 4.78257418e-01f, 2.85497248e-01f, -2.81194687e-01f, -6.26615345e-01f, 8.96858156e-01f, 3.20443243e-01f,
  3.44781309e-01f, -1.42547354e-01f, 3.61275762e-01f, -2.54667968e-01f, 1.21875012e+00f, 8.15634251e-01f, 5.14310956e-01f, 3.35818738e-01f, 6.52609110e-01f, 4.93404508e-01f,
  2.76147932e-01f, -3.86036038e-01f, 1.48673984e-03f, 7.22083449e-01f, 3.54944766e-01f, -4.94567931e-01f, -1.13107872e+00f, -3.76056403e-01f, 6.03189945e-01f, 7.67107904e-02f,
  -7.40252957e-02f, 4.80626106e-01f, 7.36057639e-01f, 1.05631876e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  5.24893820e-01f, 5.57370007e-01f, -6.69929087e-02f, 2.41230443e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.10885970e-01f, -5.04563689e-01f, 3.42471451e-01f, -5.17271936e-01f, 1.81643099e-01f, -4.39775467e-01f, 6.86631978e-01f, -1.51520863e-01f, 1.36032552e-01f, 3.70311379e-01f,
  6.47087907e-03f, -3.33101451e-01f, -6.41107559e-01f, -8.20704222e-01f, 1.03332853e+00f, 2.93733269e-01f, -4.37090248e-01f, 8.21429119e-02f, -4.16950256e-01f, -8.81345421e-02f,
  -5.86894751e-01f, 4.01466787e-01f, 6.31835818e-01f, -5.50949052e-02f, -9.89492238e-01f, -6.58819377e-01f, -4.32808071e-01f, 1.12662293e-01f, 4.72653478e-01f, -7.25272298e-01f,
  8.65147531e-01f, 3.87701653e-02f, -3.65285188e-01f, 4.95204389e-01f, -1.69842467e-01f, 6.43703043e-01f, 5.01548469e-01f, 3.47071141e-01f, 1.09515989e+00f, 2.40652665e-01f,
  7.35213399e-01f, 1.64078906e-01f, -3.09750199e-01f, 5.08539915e-01f, 8.62487316e-01f, 2.89011002e-01f, -2.77838379e-01f, -4.55189049e-01f, -5.14337122e-01f, 6.37663007e-01f,
  -5.92040837e-01f, 1.15679853e-01f, 3.17317277e-01f, 2.27997631e-01f, -1.20998919e+00f, -3.08558136e-01f, 5.87214887e-01f, 7.99587011e-01f, 3.19247037e-01f, 8.73179138e-01f,
  -1.40691891e-01f, -7.40749300e-01f, 8.92553806e-01f, -2.52554566e-01f, 6.10805750e-01f, -2.23362390e-02f, -6.97792113e-01f, -8.51230547e-02f, 6.45949766e-02f, -5.39052308e-01f,
  2.65667498e-01f, -7.57057905e-01f, 7.29027033e-01f, 3.85646224e-01f, 6.39674246e-01f, 6.68410003e-01f, -4.37177330e-01f, 2.63496667e-01f, 4.48854417e-02f, 7.57428765e-01f,
  5.88066518e-01f, -9.24894214e-02f, 2.69009471e-01f, -1.96796462e-01f, 4.90483344e-01f, 6.31283283e-01f, 8.34945858e-01f, -4.57329273e-01f, -4.49117839e-01f, -5.64608932e-01f,
  -5.85981846e-01f, 1.10586025e-01f, -1.70024365e-01f, -5.61655998e-01f, -5.49731731e-01f, 1.15420032e+00f, -3.55105758e-01f, 2.72833952e-03f, 5.07988269e-03f, 4.32989806e-01f,
  -4.47114199e-01f, -1.42187670e-01f, 7.88542986e-01f, 1.14395894e-01f, -8.17714036e-01f, -2.23481804e-01f, 5.84296942e-01f, 4.76471364e-01f, -1.12066150e+00f, 1.37988818e+00f,
  -5.03955007e-01f, -9.82908666e-01f, -5.61864525e-02f, -1.06019092e+00f, -3.18300575e-01f, -2.32087553e-01f, -7.77335465e-01f, -6.07502282e-01f, -3.15753609e-01f, 1.05421863e-01f,
  -2.51947731e-01f, -2.10111141e-01f, -2.06194162e-01f, -6.50704741e-01f, 2.37639487e-01f, 7.65903175e-01f, 2.44511887e-01f, -1.33065343e-01f, 4.08991903e-01f, 4.62249219e-01f,
  2.74382979e-01f, -8.19825411e-01f, 1.94515571e-01f, -2.99029291e-01f, -7.40481079e-01f, 5.26397824e-01f, -7.44941056e-01f, -7.42333233e-01f, -4.07209635e-01f, -7.01030493e-01f,
  1.02882826e+00f, -5.76406777e-01f, -3.94557625e-01f, -7.58912325e-01f, -7.11254656e-01f, 3.77110094e-01f, -7.35484213e-02f, 1.08894788e-01f, 5.56868196e-01f, -4.76571359e-03f,
  2.30760090e-02f, -1.97039276e-01f, -5.38751245e-01f, -3.31134021e-01f, 2.73367375e-01f, 7.93153718e-02f, -2.74196297e-01f, 8.34097326e-01f, -9.21406031e-01f, 7.41329193e-01f,
  2.17807502e-01f, -8.24287813e-03f, 6.03514671e-01f, 6.84132636e-01f, -6.17530048e-01f, 4.87198263e-01f, -9.10200238e-01f, -9.48463500e-01f, 4.51964289e-01f, 9.16090727e-01f,
  -9.56093371e-01f, -9.34098423e-01f, 3.00611705e-01f, -7.21941411e-01f, -1.34709924e-01f, 3.48999888e-01f, 1.13575709e+00f, -3.46650273e-01f, 3.92714500e-01f, -5.19614577e-01f,
  3.94113392e-01f, 6.47567511e-01f, -6.28776431e-01f, 6.57447994e-01f, 2.05782428e-01f, -9.78278637e-01f, 1.10607326e+00f, 5.70181251e-01f, -6.03306368e-02f, 6.15414202e-01f,
  -2.45488092e-01f, -9.48764741e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.78276652e-01f, -3.82194877e-01f, -1.60161003e-01f, 1.75604880e-01f, 1.28030416e-03f, 1.37697101e-01f, 1.05363078e-01f, -2.53479600e-01f, 3.16278547e-01f, -5.06215513e-01f,
  6.71770200e-02f, 4.33202267e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    