/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.62185341e-01f, 8.16465467e-02f, -4.77937281e-01f, 1.57244772e-01f, 6.68603182e-02f, -2.04030499e-02f, 1.49601400e-01f, 1.45284981e-01f, 1.66336283e-01f, -1.47856018e-02f,
  -2.91956253e-02f, 1.63991064e-01f, -3.46028358e-02f, 1.11649908e-01f, 2.12453548e-02f, -1.30621925e-01f, -9.39496160e-02f, -9.33733359e-02f, -2.68252660e-02f, 1.29029468e-01f,
  1.96555212e-01f, 9.92645323e-02f, 8.69215578e-02f, 3.75916362e-02f, 2.60514338e-02f, 7.24773705e-02f, -1.22052372e-01f, -9.33354273e-02f, -1.23691991e-01f, -3.01083267e-01f,
  -3.21235389e-01f, -3.65950465e-01f, 9.99065042e-02f, -2.38821730e-02f, -1.09541938e-01f, -6.18082378e-03f, 2.91741807e-02f, -1.07731774e-01f, 3.97115089e-02f, 5.63671328e-02f,
  -5.96206933e-02f, 2.73369811e-03f, -1.16735129e-02f, -2.24930439e-02f, 4.80433665e-02f, -5.23574352e-02f, -1.79208815e-02f, -8.55050609e-02f, -7.97830820e-02f, -1.15300663e-01f,
  3.40833515e-02f, -1.52723312e-01f, -1.35452002e-01f, -1.32646402e-02f, -1.21966526e-01f, -5.70500307e-02f, -6.91949725e-02f, -1.14951916e-01f, -1.56019509e-01f, -6.23532385e-02f,
  9.96442884e-02f, -4.74305972e-02f, 1.64225679e-02f, -7.13898167e-02f, 6.68702722e-02f, -6.42955676e-02f, -6.26965463e-02f, 8.97222459e-02f, 4.85966122e-03f, 2.39383150e-02f,
  -5.16077457e-03f, 6.61381381e-03f, 2.21010521e-02f, -2.19873954e-02f, 2.20408384e-03f, -6.80456609e-02f, 5.13837636e-02f, 8.71237665e-02f, -7.03484043e-02f, -4.08263877e-02f,
  -3.60375596e-03f, -6.97858781e-02f, -9.42579433e-02f, 2.18439605e-02f, -8.12429041e-02f, -1.32361101e-02f, 5.54196201e-02f, 4.69497778e-02f, 5.71802780e-02f, -2.55620070e-02f,
  2.97127873e-01f, -5.72243184e-02f, -2.29966957e-02f, -4.66386741e-03f, -9.39835757e-02f, -6.40423875e-03f, -9.42272171e-02f, 1.53358961e-02f, 3.61307748e-02f, 1.65615287e-02f,
  1.62629727e-02f, 1.44640962e-02f, -8.73295069e-02f, 4.31797355e-02f, 4.52788547e-02f, 3.38006020e-02f, 4.42691110e-02f, 2.65769102e-02f, 8.93561393e-02f, -7.88092613e-03f,
  1.30119145e-01f, 1.94963291e-01f, 8.79155546e-02f, 1.72265023e-01f, 3.67720090e-02f, 1.37862876e-01f, 6.69645146e-02f, 1.00744694e-01f, 7.50871822e-02f, 3.47374231e-01f,
  -4.58042949e-01f, -1.50829434e-01f, 1.34831257e-02f, -1.78443059e-01f, 4.97218855e-02f, -4.71135750e-02f, -2.99877357e-02f, -1.28965929e-01f, -6.39393479e-02f, 6.56233057e-02f,
  1.29672378e-01f, 2.21951947e-01f, 1.33745641e-01f, 1.66896582e-01f, -5.93318939e-02f, -1.18903950e-01f, -4.12229594e-04f, -1.06637724e-01f, -4.97543253e-02f, 4.46163409e-04f,
  -6.40741363e-02f, -1.08134508e-01f, -1.05579242e-01f, -1.06909662e-01f, 1.10752873e-01f, 1.29605532e-01f, 3.84141169e-02f, -2.76121087e-02f, 8.35416615e-02f, 4.23366427e-02f,
  3.30126062e-02f, -1.48319870e-01f, 9.84799415e-02f, 1.51795037e-02f, 5.92159815e-02f, -5.52669652e-02f, -9.08342227e-02f, 1.52049595e-02f, -4.85526510e-02f, -5.87136298e-02f,
  -5.34963086e-02f, -2.84698866e-02f, -3.45986225e-02f, 7.56103769e-02f, -3.00127808e-02f, -4.43793610e-02f, -1.40707437e-02f, -1.57048956e-01f, -3.59584913e-02f, 6.92850575e-02f,
  6.93602413e-02f, -3.64159271e-02f, -6.33538291e-02f, -2.25313772e-02f, -9.16337296e-02f, 1.57000236e-02f, 3.93428095e-02f, 5.42764626e-02f, 1.17718484e-02f, -1.56490058e-01f,
  -3.22649069e-02f, 4.35139090e-02f, 9.89516638e-03f, 4.20610905e-02f, -9.88703072e-02f, 9.79466140e-02f, 1.93829108e-02f, -1.59898438e-02f, 1.96066741e-02f, -4.96910028e-02f,
  2.79918686e-02f, -1.73284188e-02f, -7.58877257e-03f, -1.31678330e-02f, 4.82228734e-02f, 1.80892162e-02f, 4.42453995e-02f, 1.11475503e-02f, -2.89808325e-02f, -5.91467842e-02f,
  4.36372161e-02f, -4.79127616e-02f, -5.01417778e-02f, -2.82581393e-02f, 9.50626750e-03f, 3.26881534e-03f, -5.38514405e-02f, -1.52712120e-02f, -3.82376984e-02f, 3.76843871e-03f,
  6.24660514e-02f, 5.07911369e-02f, 1.34691913e-02f, -4.37514745e-02f, 4.32389714e-02f, -1.24879694e-02f, 1.08121023e-01f, 1.12114400e-02f, 7.35153109e-02f, -9.53186397e-03f,
  1.27919205e-02f, 4.94591929e-02f, 4.27975953e-02f, -2.99570896e-02f, 3.47759239e-02f, 1.08764200e-02f, -1.31365620e-02f, -1.95473526e-02f, 5.62866852e-02f, 3.14532518e-02f,
  -5.49289212e-02f, -1.13056049e-01f, -7.90284649e-02f, 4.16659452e-02f, -8.64023417e-02f, -3.26802097e-02f, -4.65478078e-02f, -9.94204660e-04f, 5.12767360e-02f, -1.44519672e-01f,
  -3.26969683e-01f, 9.59486812e-02f, 2.02141955e-01f, 1.05186418e-01f, 9.98459533e-02f, -1.41964421e-01f, -2.29742646e-01f, -2.23811582e-01f, -1.13137946e-01f, 5.90852164e-02f,
  -5.83861321e-02f, 4.49895710e-02f, 3.43185142e-02f, 5.72477728e-02f, -1.49823248e-01f, -9.42705665e-03f, 1.73913538e-01f, 5.60553931e-02f, -8.76360387e-02f, -2.01654226e-01f,
  -9.88487620e-04f, 7.58664012e-02f, -1.84432641e-02f, -1.34029388e-02f, 1.71250269e-01f, -6.94273859e-02f, 3.26785147e-02f, 1.42016202e-01f, 7.44285807e-03f, 2.66236633e-01f,
  -7.45931566e-02f, 1.96441486e-02f, -1.73967909e-02f, -5.16677797e-02f, 3.70232053e-02f, -5.94048612e-02f, -4.09752615e-02f, 6.34153709e-02f, 3.77368964e-02f, -9.96034220e-03f,
  1.24929287e-01f, 7.34762400e-02f, 1.17978595e-01f, 5.03296703e-02f, 3.43463896e-03f, -4.84992415e-02f, -1.67259388e-02f, 7.25307614e-02f, 5.73155247e-02f, -3.53457965e-02f,
  1.60989255e-01f, 7.68565238e-02f, -3.94433551e-02f, -3.31435502e-02f, -1.22245498e-01f, 3.79599743e-02f, 5.35017587e-02f, 4.67464477e-02f, -1.68427274e-01f, -1.05940305e-01f,
  -7.42507279e-02f, 9.63007286e-02f, -6.23766333e-02f, -5.47440909e-02f, 2.21512895e-02f, -2.97429636e-02f, 3.31967659e-02f, -4.43775654e-02f, -1.96723249e-02f, 5.73240593e-02f,
  -1.65522434e-02f, 1.49803725e-03f, 5.88561371e-02f, -9.13382396e-02f, 3.20454501e-02f, 2.57345214e-02f, -1.76205486e-02f, 4.72307429e-02f, 4.49796906e-03f, 2.24253349e-02f,
  -7.48629346e-02f, 7.67304143e-03f, 4.02045734e-02f, -1.12792524e-02f, 7.01202005e-02f, 3.30408812e-02f, -1.66317355e-02f, -2.26756446e-02f, 1.48468390e-02f, 1.46483199e-03f,
  -1.81763485e-01f, 7.48481303e-02f, 3.02157970e-03f, -4.15370166e-02f, -3.27392742e-02f, 2.54134033e-02f, 3.52069847e-02f, -4.66502868e-02f, 1.32355765e-01f, 6.10133223e-02f,
  -9.03151482e-02f, -9.23100486e-02f, 1.00502841e-01f, 3.97563912e-02f, -1.65522080e-02f, -3.88673097e-02f, 8.69314671e-02f, -3.71093526e-02f, -4.55130674e-02f, 1.08469306e-02f,
  8.90429094e-02f, -1.62617669e-01f, -1.39355600e-01f, -1.04034238e-01f, -5.99938212e-03f, -1.41213804e-01f, -1.44611761e-01f, -1.11961745e-01f, -1.41827136e-01f, -3.00684422e-01f,
  4.39139605e-01f, 3.01358908e-01f, 2.33367905e-01f, 1.19752847e-01f, -4.39597629e-02f, -6.51623085e-02f, -2.02506669e-02f, -1.96429238e-01f, -1.49603873e-01f, 7.13916346e-02f,
  -1.18747838e-01f, -1.93633348e-01f, -1.06395520e-01f, -2.40054905e-01f, -1.21832885e-01f, 8.74311477e-02f, 1.68981522e-01f, 5.03375717e-02f, -2.51005799e-01f, -2.51239538e-01f,
  -1.20153129e-01f, 1.62460893e-01f, 8.07846114e-02f, 7.58584822e-03f, 5.49076386e-02f, -2.03629807e-01f, 1.23118691e-01f, 9.07816589e-02f, 4.44020033e-02f, 2.09240258e-01f,
  1.61631003e-01f, 2.01141387e-01f, -1.19236447e-01f, -1.28567796e-02f, 8.15161020e-02f, -4.67199972e-03f, -3.93170118e-02f, 7.59463012e-02f, -2.87998803e-02f, 7.23836869e-02f,
  -2.13509630e-02f, -2.77419258e-02f, 2.87241284e-02f, -4.16865796e-02f, 6.56769797e-02f, -6.64730072e-02f, 1.20585814e-01f, 1.75020155e-02f, -1.41784567e-02f, -6.41166233e-03f,
  2.20150687e-02f, 9.63351354e-02f, 1.48344487e-01f, -3.85558270e-02f, -7.36000687e-02f, 5.28446436e-02f, -1.74402017e-02f, 3.41787376e-02f, -9.13024172e-02f, 1.80702820e-01f,
  2.41279206e-03f, 6.59945086e-02f, 1.57353689e-03f, -1.85221601e-02f, -2.97966953e-02f, -3.89626622e-02f, 1.41554680e-02f, 1.02869300e-02f, -4.48793769e-02f, 1.65016446e-02f,
  1.74351165e-03f, -8.02713186e-02f, -1.76183302e-02f, 6.06516674e-02f, -1.33963386e-02f, 7.19030425e-02f, -2.92290151e-02f, 1.44757992e-02f, -3.73858213e-02f, -1.49640832e-02f,
  -1.35853840e-02f, -1.34242317e-02f, 4.64056898e-03f, 1.75003037e-02f, 2.01936229e-03f, 4.56863157e-02f, 6.23901747e-02f, -7.82233551e-02f, -2.40834709e-02f, 1.99937504e-02f,
  -2.37117652e-02f, -4.88065090e-03f, 1.00363120e-01f, 1.56993158e-02f, 1.12136908e-01f, -9.13631078e-03f, -3.01986523e-02f, -1.40638342e-02f, 1.85977146e-02f, 2.04388406e-02f,
  -6.03087693e-02f, 2.51263995e-02f, -4.87417951e-02f, -2.06113309e-02f, -6.51654601e-02f, -1.00727268e-01f, 4.42754775e-02f, 1.56352632e-02f, 1.56784401e-04f, 4.57799099e-02f,
  -1.01953395e-01f, -7.90948421e-02f, -2.21068449e-02f, -7.52562955e-02f, 2.17701737e-02f, -8.44634697e-02f, -2.95631518e-03f, 6.75845239e-03f, -3.36431228e-02f, 1.24568967e-02f,
  2.43788864e-03f, -1.05677051e-02f, -2.98869640e-01f, 1.18329123e-01f, 1.66964587e-02f, -1.90111652e-01f, -3.28075975e-01f, -1.45830557e-01f, 2.11231336e-01f, 1.48120761e-01f,
  1.41305819e-01f, 1.56972542e-01f, 5.65928146e-02f, -9.07031596e-02f, -1.40877053e-01f, -1.39492169e-01f, -1.69731751e-01f, -3.27116728e-01f, -2.62198418e-01f, -1.72852442e-01f,
  7.45095909e-02f, 6.87931478e-02f, -6.31442741e-02f, -1.99374147e-02f, 1.70560986e-01f, 1.94559380e-01f, -2.19301693e-02f, 9.38022360e-02f, -1.16600417e-01f, -4.08059992e-02f,
  7.10991025e-02f, -9.40324515e-02f, -4.51803505e-02f, -1.55767694e-03f, 4.57373895e-02f, -2.45968513e-02f, -7.19727203e-03f, -1.13725634e-02f, 3.75659578e-02f, 1.94116458e-02f,
  4.82968129e-02f, 1.46701317e-02f, 1.16651738e-02f, 7.03302920e-02f, -7.47151449e-02f, 1.34348832e-02f, -3.85777615e-02f, -6.84880093e-02f, -7.28074238e-02f, 1.10626873e-02f,
  3.53277810e-02f, -4.68197428e-02f, -2.24922121e-01f, -4.25500274e-02f, -7.71518275e-02f, -4.29445952e-02f, -3.39505151e-02f, -5.33187799e-02f, -3.12715322e-02f, 6.15870282e-02f,
  -4.80817221e-02f, 5.02106361e-02f, 2.88809054e-02f, 2.46959478e-02f, 3.77164967e-03f, 6.27908707e-02f, -3.76548283e-02f, 6.96842819e-02f, 1.48591641e-02f, 5.66330254e-02f,
  2.29304396e-02f, -2.49325112e-02f, 2.89008976e-03f, -6.72061965e-02f, 6.55493364e-02f, -8.87521426e-04f, -2.56899949e-02f, 1.25216335e-01f, -6.74518272e-02f, 7.46729523e-02f,
  -2.30141953e-02f, 3.91673073e-02f, 4.83866222e-02f, -2.37217676e-02f, 3.48353051e-02f, -3.22581492e-02f, -1.72346141e-02f, 4.68944944e-02f, 2.85453536e-02f, 3.28672328e-03f,
  3.00134808e-01f, -5.11885397e-02f, 3.00451983e-02f, -8.06508437e-02f, 5.67803234e-02f, 1.17497772e-01f, 6.10536747e-02f, -8.80666897e-02f, 1.94761641e-02f, -4.98622730e-02f,
  -6.43516146e-03f, -5.71686961e-03f, -1.50263309e-02f, 2.08364017e-02f, -3.26298401e-02f, -1.83725674e-02f, 6.69705048e-02f, -4.65209968e-03f, -6.42194450e-02f, 1.02523807e-02f,
  9.66840088e-02f, -1.00239977e-01f, 6.01207465e-02f, -5.84025867e-02f, 2.23271325e-02f, -3.76881361e-02f, 2.49071755e-02f, -3.81711014e-02f, -9.08545256e-02f, 6.50757700e-02f,
  -2.70789444e-01f, -2.06737861e-01f, -1.77525021e-02f, -1.52346417e-01f, -8.91157612e-03f, -3.76533531e-02f, -3.22379261e-01f, -1.02089703e-01f, -8.48208740e-02f, -1.09053720e-02f,
  2.53799241e-02f, 8.13501775e-02f, 4.23390120e-02f, 4.75168563e-02f, -5.86331524e-02f, -1.52405426e-01f, -4.14991714e-02f, -3.40374149e-02f, 8.58506784e-02f, 1.74177438e-02f,
  -7.33721554e-02f, -9.46466699e-02f, 2.45542079e-02f, 8.36205408e-02f, 4.88285720e-02f, 8.25920478e-02f, 4.19747978e-02f, 7.21582249e-02f, 1.10664181e-01f, -1.15876801e-01f,
  8.83480981e-02f, -9.95366052e-02f, 3.19726989e-02f, 4.13194373e-02f, 1.43589154e-01f, -1.02010123e-01f, 3.95870879e-02f, 1.16184227e-01f, -2.01309305e-02f, 5.95030524e-02f,
  4.26661745e-02f, 4.75772545e-02f, 8.16467926e-02f, 5.76085374e-02f, -2.36273054e-02f, -9.29527953e-02f, -7.28650987e-02f, -9.77896824e-02f, -1.55892968e-02f, -6.04670905e-02f,
  -1.69384740e-02f, 8.26788321e-02f, -3.87877002e-02f, -3.03623546e-02f, 5.37906699e-02f, 8.06965958e-03f, 1.00926803e-02f, 1.11140184e-01f, -1.16149837e-03f, -2.67171841e-02f,
  -9.31037366e-02f, 1.51695544e-02f, 6.84778811e-03f, -6.63420558e-02f, 2.54283063e-02f, -3.94547842e-02f, -2.97408309e-02f, -3.86297842e-03f, 1.59396846e-02f, 5.68000553e-03f,
  3.32727917e-02f, -2.57485453e-02f, 1.87456806e-03f, 6.90328050e-03f, 9.02175009e-02f, -1.08536229e-01f, -7.15318769e-02f, -4.52125818e-02f, 5.49177751e-02f, -3.05072106e-02f,
  2.06117313e-02f, 3.55827920e-02f, 4.44030464e-02f, -1.31984670e-02f, -1.02174357e-02f, -4.98615094e-02f, 4.80129458e-02f, 8.07839856e-02f, -8.12191144e-02f, -3.59081179e-02f,
  8.36138800e-02f, 1.42088860e-01f, -4.03480344e-02f, -4.24420089e-02f, -2.29760073e-02f, 6.11022636e-02f, 2.89274864e-02f, -9.47336666e-03f, 1.02524944e-01f, -8.37168023e-02f,
  1.14380457e-01f, -5.37536480e-03f, -5.83840609e-02f, 3.05293836e-02f, -7.55198821e-02f, -4.62833680e-02f, -7.44664371e-02f, 1.87893473e-02f, 5.63104376e-02f, 2.81557385e-02f,
  -6.16010502e-02f, -1.19668305e-01f, -1.82971582e-02f, -9.44802538e-02f, 2.49206275e-02f, 6.07359931e-02f, 4.31111194e-02f, -4.63829003e-02f, -2.48383638e-02f, -2.12783441e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.40651108e-02f, -1.88823342e-01f, 1.53104037e-01f, 1.82626203e-01f, 2.26682127e-01f, 2.01245919e-01f, 7.80923516e-02f, 4.18471694e-02f, -1.31681254e-02f, 6.43611103e-02f,
  -6.40984178e-02f, -1.17966257e-01f, -1.65890872e-01f, -1.54913208e-02f, -1.04692116e-01f, 2.60458738e-02f, 2.08827332e-01f, 5.82878217e-02f, 1.15923658e-01f, 8.82259905e-02f,
  6.50143549e-02f, -2.61082239e-02f, -2.17719469e-02f, 4.43142168e-02f, 1.40756266e-02f, 3.77114452e-02f, 7.77688175e-02f, 7.22771958e-02f, -2.05856878e-02f, -2.91689951e-03f,
  -1.78345218e-01f, -5.43681122e-02f, 9.74873155e-02f, -8.17357749e-02f, -9.57593918e-02f, 1.92459337e-02f, 5.45913875e-02f, -1.65125579e-02f, -2.48194002e-02f, -1.61818713e-02f,
  1.28056305e-02f, 8.02554563e-03f, 2.28628982e-02f, -3.16407010e-02f, -1.30464789e-02f, -1.09814876e-03f, -3.85057479e-02f, -9.21520516e-02f, -2.83525325e-02f, -7.72261545e-02f,
  -1.04273193e-01f, 1.12521753e-01f, -4.75216694e-02f, 8.88377279e-02f, -6.46871552e-02f, 5.87930381e-02f, 1.35625526e-03f, 3.57431956e-02f, -1.04139313e-01f, -8.96048620e-02f,
  5.20299934e-03f, 6.72344714e-02f, -1.01376567e-02f, 2.86509637e-02f, 4.29486856e-02f, -6.32849932e-02f, 8.08181707e-03f, 8.48285779e-02f, 1.01834666e-02f, 2.36187340e-03f,
  4.16104868e-02f, -1.34308580e-02f, 4.76124436e-02f, -1.17229689e-02f, -3.90366949e-02f, -6.18052261e-04f, 5.45051023e-02f, -4.71745618e-02f, -7.60226091e-03f, -2.37417016e-02f,
  -6.30270541e-02f, 2.71967240e-02f, -7.07730278e-02f, -3.21648754e-02f, 9.59848519e-03f, 2.57520285e-02f, -1.59235615e-02f, 1.79042481e-02f, 4.01322581e-02f, -4.73250784e-02f,
  -9.80633572e-02f, 1.35453732e-03f, -5.42157590e-02f, 2.83552357e-03f, -2.79266331e-02f, 1.15958005e-02f, -1.38847940e-02f, -9.09860209e-02f, 4.76116762e-02f, -4.45028804e-02f,
  -1.03365079e-01f, -1.07457526e-01f, 1.52710662e-03f, -7.87038654e-02f, 5.43248206e-02f, 7.29674771e-02f, -8.03596675e-02f, 1.29778877e-01f, 2.26583928e-02f, 6.81983307e-02f,
  1.93344597e-02f, 5.49770519e-02f, 1.70849010e-01f, 1.40507028e-01f, -1.82467215e-02f, 1.22998446e-01f, 9.58889723e-02f, 1.03724003e-01f, 9.00212973e-02f, 7.92511702e-02f,
  -2.00804889e-01f, -1.70642868e-01f, 8.56942385e-02f, -2.96980709e-01f, -3.48458290e-02f, 7.41847381e-02f, -8.37216824e-02f, -9.44652129e-03f, -2.11450845e-01f, -1.58456683e-01f,
  -8.83787125e-02f, 1.05372630e-01f, 8.22788551e-02f, 1.36918247e-01f, 4.29337136e-02f, -1.17412575e-01f, -1.79853272e-02f, 1.43497065e-01f, 2.83582270e-01f, 1.16143309e-01f,
  -8.07964206e-02f, -1.07387394e-01f, -3.75634730e-02f, 3.68800871e-02f, -1.85728461e-01f, 4.99306899e-03f, -9.07015949e-02f, -1.47306263e-01f, 8.32126588e-02f, -2.17122644e-01f,
  -6.79636199e-04f, -2.05426797e-01f, 5.40744029e-02f, 4.46366817e-02f, -2.72883587e-02f, -2.02083774e-02f, 2.62600537e-02f, -1.71576366e-02f, -7.07300426e-03f, -1.30086988e-01f,
  -8.43442902e-02f, 6.18675426e-02f, -2.37810612e-02f, -3.35944607e-03f, -1.26110092e-01f, -8.54627788e-02f, -3.05884778e-02f, -2.65791118e-02f, 3.47495601e-02f, -5.25298677e-02f,
  -8.59062076e-02f, 5.66469207e-02f, -3.55278365e-02f, 3.45519632e-02f, -8.58172774e-02f, 1.82792731e-02f, -8.02692696e-02f, -6.42291009e-02f, 9.82178450e-02f, -1.74324229e-01f,
  1.24428794e-02f, -4.48677801e-02f, 1.06511423e-02f, -7.00494042e-03f, 6.76090270e-03f, 1.81675442e-02f, -2.72143423e-03f, -2.37447098e-02f, 6.37499914e-02f, 3.18329632e-02f,
  7.40285441e-02f, -7.18631297e-02f, 8.43400136e-02f, -9.57180804e-04f, -6.03362871e-03f, -3.79946604e-02f, 1.55351314e-04f, 4.16166931e-02f, -1.38490284e-02f, 5.60113043e-02f,
  3.95538956e-02f, 3.18151005e-02f, -1.15218110e-01f, -4.73995134e-02f, 2.00664289e-02f, -1.89351998e-02f, -2.45973486e-02f, 5.89303337e-02f, -7.54114538e-02f, -1.28311813e-02f,
  -1.21330336e-01f, 2.68324226e-01f, -4.38889861e-02f, -4.28444557e-02f, -8.88814032e-02f, -2.04633176e-02f, -9.89298895e-02f, 3.06147859e-02f, -6.27061725e-02f, 5.60945459e-02f,
  1.37833823e-02f, 3.89744597e-03f, -4.13415879e-02f, 2.27864403e-02f, 5.14906906e-02f, -5.68470210e-02f, -9.48302448e-03f, 4.32508439e-02f, 2.17433237e-02f, -3.21090482e-02f,
  5.56136540e-04f, -2.29671486e-02f, 4.66590971e-02f, 2.36003753e-02f, -5.45816077e-03f, 5.59152663e-02f, 1.07013181e-01f, -1.69236548e-02f, 6.46341518e-02f, -4.81064133e-02f,
  -2.52900571e-01f, -1.11121666e-02f, -9.07867551e-02f, 1.05505191e-01f, 2.16679260e-01f, 1.11801349e-01f, 1.63755700e-01f, 2.14111507e-01f, 1.01464085e-01f, 6.39808103e-02f,
  3.40340249e-02f, 1.99636385e-01f, 1.09542459e-01f, 7.46400207e-02f, 2.90396400e-02f, 7.26129413e-02f, 1.43457904e-01f, -5.22022955e-02f, 1.39685366e-02f, 1.11647965e-02f,
  1.86153352e-01f, 6.08023889e-02f, -1.62765663e-02f, 2.30510980e-02f, 1.76443327e-02f, 1.65835902e-01f, 7.57632032e-02f, 3.03832032e-02f, -2.05340199e-02f, 1.11259550e-01f,
  -8.93981978e-02f, 1.22139212e-02f, 6.93143681e-02f, -6.35076836e-02f, -8.12740028e-02f, 1.50828939e-02f, 4.36873771e-02f, 4.46521258e-03f, 7.30008483e-02f, -3.79896313e-02f,
  6.83124661e-02f, 2.98679434e-02f, 6.38072267e-02f, -1.56946126e-02f, -1.20052487e-01f, -2.98772398e-02f, -2.50484189e-03f, 3.42531912e-02f, 7.35335648e-02f, -3.81888710e-02f,
  1.39872864e-01f, 3.15419585e-02f, -1.41782492e-01f, -7.83662051e-02f, 6.94139972e-02f, 6.47641951e-03f, 4.98816743e-02f, -2.68083345e-02f, -6.23491369e-02f, -9.15282816e-02f,
  1.07535616e-01f, -3.59161943e-02f, -5.15164509e-02f, 2.21496169e-02f, 2.74404534e-03f, 2.14234591e-02f, 5.60976937e-02f, -2.83866674e-02f, -1.99459717e-02f, 3.84199619e-02f,
  -1.78979225e-02f, -2.89750677e-02f, 1.09775081e-01f, 5.00863083e-02f, 9.48561262e-03f, -2.25167349e-02f, -5.36713600e-02f, 3.33478153e-02f, -8.70472342e-02f, -3.47074457e-02f,
  -6.00110888e-02f, -5.11521250e-02f, -1.09442063e-01f, 7.18714222e-02f, -2.66117714e-02f, 2.99439691e-02f, 2.35716794e-02f, 2.60073487e-02f, -1.26713635e-02f, -7.56990537e-02f,
  -8.04300755e-02f, -1.45446220e-02f, 3.70842293e-02f, 2.21372824e-02f, -2.45187487e-02f, 1.18141007e-02f, -3.31635028e-02f, -7.92210549e-02f, -1.04186811e-01f, 1.13526117e-02f,
  -6.31663203e-02f, -5.24408445e-02f, -1.02163702e-01f, -4.95284051e-02f, -8.16862956e-02f, -7.10802823e-02f, -7.88601413e-02f, 7.20989844e-03f, -7.93970283e-03f, 1.24672928e-03f,
  -6.81057349e-02f, -1.40865576e-02f, 1.99477859e-02f, -9.02907997e-02f, 9.61064473e-02f, 8.25071633e-02f, -4.95208278e-02f, 8.99168383e-03f, -1.25645697e-01f, -4.08275202e-02f,
  -1.81890786e-01f, 1.88268945e-02f, 3.71081359e-03f, 1.44858122e-01f, 5.21784872e-02f, 9.79794115e-02f, 1.14938915e-01f, 1.23794116e-01f, 1.07871033e-01f, -2.17546634e-02f,
  -4.51438092e-02f, 1.21710852e-01f, 1.65988445e-01f, 4.74269763e-02f, 1.07887067e-01f, 1.56938687e-01f, 9.22610536e-02f, 1.45986080e-01f, 4.73742336e-02f, 8.24278519e-02f,
  3.35293859e-02f, 2.45566703e-02f, -7.54118562e-02f, 1.14902206e-01f, 7.32940808e-02f, 9.93568897e-02f, 8.37212279e-02f, 4.07097451e-02f, -3.89755480e-02f, 4.71542925e-02f,
  -1.42512411e-01f, -8.40180069e-02f, 5.90874515e-02f, -4.69857343e-02f, -9.88292173e-02f, -4.71303314e-02f, -9.46235359e-02f, -3.52234580e-02f, -5.86166605e-02f, 9.98223107e-03f,
  -4.59511019e-02f, -2.72755548e-02f, 7.69195259e-02f, 6.41760677e-02f, 3.64215970e-02f, -9.30467099e-02f, 1.87868960e-02f, 2.65675057e-02f, 7.08070323e-02f, -4.16399091e-02f,
  -6.90497980e-02f, -1.13655813e-01f, -1.10311725e-03f, -6.77337348e-02f, 8.84028003e-02f, 9.77390446e-03f, -9.17068720e-02f, -5.49072772e-02f, 5.03199128e-03f, -8.78152400e-02f,
  5.85164353e-02f, 4.41377535e-02f, 6.68475032e-03f, -5.42716347e-02f, -9.25896969e-03f, -9.98867489e-03f, 4.71245348e-02f, 6.32041991e-02f, 7.94568285e-02f, -2.94282250e-02f,
  5.69554232e-02f, -5.23415245e-02f, -1.55123537e-02f, 7.38032311e-02f, 7.20167980e-02f, -1.10623471e-01f, 5.36650531e-02f, 4.01954576e-02f, -6.72583282e-02f, -1.35996994e-02f,
  -5.21376878e-02f, -6.44124150e-02f, -1.41247407e-01f, 5.57335839e-02f, 1.74950641e-02f, 1.44337723e-02f, -7.10866004e-02f, 1.99714163e-03f, -5.31159621e-03f, -1.05888695e-01f,
  -2.53061741e-03f, -1.76718794e-02f, -2.48181652e-02f, 5.15077785e-02f, -5.41235181e-03f, -1.24667573e-03f, 5.02438881e-02f, 4.15698774e-02f, 1.84344570e-03f, 5.87396435e-02f,
  -6.04916662e-02f, 5.73289618e-02f, 3.28262113e-02f, 7.18257483e-03f, -9.50432494e-02f, -8.67905095e-02f, -3.27414162e-02f, 7.78967561e-03f, 8.06963742e-02f, 1.71667039e-02f,
  -6.98913857e-02f, -1.43387482e-01f, -7.60048954e-03f, 3.08955438e-03f, -5.05817011e-02f, -3.47016193e-02f, 1.88813023e-02f, -6.26444891e-02f, -1.51204700e-02f, -1.42124653e-01f,
  1.11911166e-03f, -9.25291795e-03f, -1.58078782e-02f, 1.13734253e-01f, 6.69888780e-02f, -1.43036515e-01f, -1.28306583e-01f, -2.36246869e-01f, -8.35738555e-02f, -2.60561879e-04f,
  5.38262837e-02f, -3.79988514e-02f, -7.04737892e-03f, -4.08642143e-02f, -1.33802444e-01f, 5.57925142e-02f, 2.29374450e-02f, 6.51399493e-02f, -3.90907563e-03f, -6.43860251e-02f,
  5.78196608e-02f, 1.35740325e-01f, 1.23212405e-01f, 4.50375676e-03f, 9.79268849e-02f, -2.05366760e-02f, 2.88637318e-02f, 1.66080296e-01f, 1.03203125e-01f, 2.14160934e-01f,
  1.28382251e-01f, 9.20239165e-02f, -3.85413133e-02f, 8.14187378e-02f, 1.06126964e-01f, -7.42144734e-02f, -7.56668150e-02f, -8.39726627e-02f, 1.12429690e-02f, 5.29502816e-02f,
  2.69306544e-02f, 4.75829393e-02f, 8.44495445e-02f, -5.68698384e-02f, 4.01639119e-02f, -5.37646636e-02f, 1.59766972e-02f, 3.81548554e-02f, 7.92597886e-03f, -4.22621088e-04f,
  5.62195964e-02f, 5.83067574e-02f, 8.07035062e-03f, -1.47986710e-01f, -1.13588884e-01f, 8.75415429e-02f, -8.25225282e-03f, -2.64541451e-02f, -1.29332691e-02f, -9.50649232e-02f,
  3.98202846e-03f, -2.33325046e-02f, -3.07862889e-02f, 5.37032746e-02f, -1.11735417e-02f, 4.73602116e-02f, 5.62120341e-02f, 4.35915999e-02f, -6.19014166e-02f, 3.77635807e-02f,
  -6.57963306e-02f, -5.78780696e-02f, -4.04783040e-02f, -7.37260282e-02f, 4.27149087e-02f, 5.84639311e-02f, -9.87771302e-02f, -4.24623005e-02f, -1.94581114e-02f, -7.03280270e-02f,
  1.00933574e-01f, 5.59448749e-02f, -7.59647489e-02f, 2.07246896e-02f, -7.73051009e-02f, -6.33584857e-02f, 2.99862828e-02f, 1.87322292e-02f, -5.24364486e-02f, 7.56174773e-02f,
  -9.03634652e-02f, 1.05311789e-01f, -5.87327890e-02f, -4.16234881e-02f, 8.52144733e-02f, -8.16874485e-03f, 3.73971909e-02f, 2.74179373e-02f, 4.58602123e-02f, -2.04496123e-02f,
  7.98428282e-02f, -9.89143327e-02f, 4.27202210e-02f, -9.48062458e-04f, -8.62685740e-02f, -1.06889501e-01f, -5.72969718e-03f, -5.42697310e-02f, -4.41007651e-02f, -1.32730141e-01f,
  -9.31365415e-02f, -1.55738488e-01f, -1.62603080e-01f, -1.84560984e-01f, -1.24189392e-01f, -1.00822091e-01f, -1.51780069e-01f, -1.35191575e-01f, -1.18532144e-01f, -1.75317988e-01f,
  -1.57473028e-01f, -4.64417748e-02f, -7.29172453e-02f, -1.32204458e-01f, -5.22091687e-02f, 2.16402784e-02f, 1.18394010e-02f, -5.55683523e-02f, 6.71236739e-02f, 8.52184091e-03f,
  3.65672037e-02f, 7.17787296e-02f, 3.14332806e-02f, 5.28665036e-02f, -4.51411344e-02f, 1.81138497e-02f, -1.63679477e-02f, -1.31520897e-01f, -9.57033336e-02f, 9.94241238e-02f,
  3.52605917e-02f, 4.62876521e-02f, -1.22742625e-02f, 4.36535105e-02f, 3.81729119e-02f, -2.32135132e-02f, -4.72622477e-02f, -2.90104933e-02f, 9.12477523e-02f, 9.76131707e-02f,
  6.32855520e-02f, 9.37409550e-02f, -1.50110554e-02f, 1.54421087e-02f, -1.82239823e-02f, 6.68056831e-02f, -1.95797198e-02f, -4.60180528e-02f, -8.76814425e-02f, 9.45767686e-02f,
  1.93184968e-02f, 8.59065801e-02f, 9.01015252e-02f, 6.82321861e-02f, -1.70885678e-02f, 2.64021698e-02f, 7.83722475e-03f, -5.27658174e-03f, 6.83380440e-02f, 2.31941994e-02f,
  6.77497461e-02f, -5.59197292e-02f, -2.82261912e-02f, -4.32405584e-02f, 5.51343672e-02f, -4.58337329e-02f, 7.19304755e-02f, 1.18569553e-01f, 1.43587440e-01f, 1.38111487e-01f,
  1.02293054e-02f, -2.93696299e-02f, 7.40995556e-02f, 1.32444547e-02f, -1.27805220e-02f, 5.40273217e-03f, 2.48639304e-02f, 5.64174317e-02f, 7.39087090e-02f, -6.61455840e-02f,
  8.34811777e-02f, 5.70074655e-03f, 5.03732860e-02f, 1.91726778e-02f, -5.29191317e-03f, 6.02869205e-02f, -5.92714697e-02f, -5.06983064e-02f, 9.44872499e-02f, -1.74624324e-02f,
  -7.92970322e-03f, -1.67007968e-02f, 1.02950543e-01f, 7.80622766e-04f, 3.38481031e-02f, 3.84966806e-02f, -3.68774571e-02f, -5.30411862e-02f, 2.23762449e-02f, -6.91153929e-02f,
  8.41616541e-02f, 1.06725320e-02f, -1.99194867e-02f, 8.33593532e-02f, -1.33090625e-02f, 3.22422944e-02f, -3.66039313e-02f, 8.68102759e-02f, -3.80520262e-02f, 8.42303783e-03f,
  -2.50703078e-02f, 3.57080474e-02f, 2.63114553e-03f, -2.56328285e-02f, 5.60028069e-02f, 7.46312514e-02f, 1.65080186e-02f, -3.74891562e-04f, -3.16321403e-02f, 7.63461515e-02f,
  9.90804359e-02f, 3.98056246e-02f, -4.15003523e-02f, -1.50398798e-02f, 9.20774639e-02f, -3.48205641e-02f, -4.01760861e-02f, 1.03031218e-01f, -5.63832857e-02f, 6.87810481e-02f,
  -3.36824477e-01f, 5.72907291e-02f, 4.73634303e-02f, -3.89264405e-01f, -1.88373365e-02f, 2.38643795e-01f, 2.23590776e-01f, 6.13927469e-02f, -1.88483149e-01f, -8.90120864e-02f,
  2.33871955e-02f, -1.19793177e-01f, -8.66615847e-02f, 9.38462839e-03f, 1.01710021e-01f, -2.37264950e-02f, -7.34747946e-02f, -7.38775954e-02f, 4.51804325e-02f, 2.04224372e-03f,
  -7.03163445e-02f, -1.47634670e-01f, -1.50686681e-01f, -1.06122777e-01f, -1.10209279e-01f, -1.78752348e-01f, -8.41951966e-02f, -1.24623045e-01f, 1.04283594e-01f, -9.96758044e-02f,
  -1.08154304e-01f, -2.57601123e-02f, -7.96247739e-03f, -8.95646960e-03f, -7.18655661e-02f, 8.11826065e-03f, -2.11342126e-02f, -9.56094339e-02f, 2.05662604e-02f, -1.79973654e-02f,
  -8.14659745e-02f, -1.74393244e-02f, 2.53295358e-02f, -6.28011227e-02f, 9.14359372e-03f, -1.59805994e-02f, 6.61563426e-02f, 2.57331412e-02f, 1.47716864e-03f, 8.12154189e-02f,
  7.37191737e-02f, 6.30106553e-02f, 4.53033783e-02f, 6.00076914e-02f, 3.21026519e-02f, 2.64323540e-02f, 6.23279698e-02f, 3.03568188e-02f, 3.21183447e-03f, -1.87743381e-01f,
  6.09792722e-03f, 4.03557867e-02f, 2.86163501e-02f, -7.67117366e-02f, -8.39007646e-02f, 5.48333162e-03f, 4.53208946e-02f, 1.00763803e-02f, -5.32214018e-03f, -5.23019955e-02f,
  -1.90238748e-02f, 2.53732931e-02f, -1.54588427e-02f, -1.14622474e-01f, 2.28157779e-03f, -9.53323171e-02f, 2.13820506e-02f, -1.35750361e-02f, 8.55270121e-03f, -4.62452210e-02f,
  -2.25528888e-02f, 1.90702956e-02f, 1.18328845e-02f, -7.09887082e-03f, 5.60748279e-02f, -4.08277474e-02f, 6.74054399e-02f, 4.72085178e-03f, -4.78789583e-02f, 1.05985150e-01f,
  -3.79539490e-01f, 1.93278462e-01f, -9.62786824e-02f, 1.13983620e-02f, 1.52361591e-03f, 7.18886480e-02f, 1.10049043e-02f, -2.09644041e-03f, -6.54229373e-02f, -1.36935078e-02f,
  9.90242660e-02f, -1.17880687e-01f, -1.43038422e-01f, 9.07409266e-02f, -3.55214602e-03f, -3.96791436e-02f, -6.40260875e-02f, -1.24279298e-01f, 9.46725160e-02f, 2.60650530e-03f,
  2.54253168e-02f, 1.99331716e-02f, -8.06247070e-02f, -1.40217673e-02f, -1.34900659e-02f, 8.40132497e-03f, 1.19717559e-02f, -4.35363613e-02f, 1.03614308e-01f, -1.07303165e-01f,
  2.54586071e-01f, -1.26748428e-01f, -1.54352561e-01f, 1.85406029e-01f, -2.98285987e-02f, -9.37849060e-02f, -1.88198894e-01f, -9.18777063e-02f, 8.52387473e-02f, 1.22333113e-02f,
  1.15695328e-01f, 1.78875476e-01f, 7.07522333e-02f, 1.12644620e-01f, -7.38407904e-03f, -4.73394096e-02f, -8.08810741e-02f, -2.83714081e-03f, 1.17505901e-01f, -7.46220574e-02f,
  1.59871541e-02f, -2.07818635e-02f, -1.75945163e-02f, -5.57034910e-02f, -1.21986866e-01f, -7.23040178e-02f, -1.50840253e-01f, -4.04148921e-02f, -1.18938074e-01f, -2.81046480e-02f,
  -5.45615815e-02f, 1.27053320e-01f, 8.39882251e-03f, 6.16652742e-02f, -5.60739748e-02f, 6.73235878e-02f, -6.93400344e-03f, -4.93325256e-02f, -4.20421734e-02f, -1.42124007e-02f,
  2.25738678e-02f, -5.25695970e-03f, -1.30998669e-03f, -3.39131355e-02f, 4.34662551e-02f, -6.48203492e-02f, -8.78096595e-02f, -5.45450039e-02f, -5.47437631e-02f, 4.71220491e-03f,
  2.18428839e-02f, -7.32494071e-02f, -3.59780639e-02f, 1.08740116e-02f, 7.07200021e-02f, -2.37703137e-02f, -4.80658673e-02f, -9.47342515e-02f, 1.08032174e-01f, -2.53703315e-02f,
  -5.77718578e-02f, 5.18545248e-02f, -7.16317678e-03f, -7.09816143e-02f, -4.64722514e-02f, 6.66784181e-04f, -3.22725624e-02f, -8.27047825e-02f, -8.22944865e-02f, 6.31223395e-02f,
  6.96374252e-02f, -5.12433536e-02f, -1.79914124e-02f, 5.10988012e-02f, 4.90345620e-03f, -9.54666808e-02f, 1.23177627e-02f, -6.37727156e-02f, -1.60897672e-02f, -6.86136186e-02f,
  1.36454646e-02f, -6.73716739e-02f, -4.54715267e-03f, -1.34678930e-01f, -8.84226151e-03f, 4.37759310e-02f, 7.08731040e-02f, -1.27962499e-03f, 5.16727604e-02f, -4.06865291e-02f,
  2.02412084e-01f, 1.10819370e-01f, 1.05718151e-01f, 5.01428694e-02f, 2.50554290e-02f, -7.01709613e-02f, 1.37699366e-01f, -5.32993264e-02f, 2.44447533e-02f, 4.70933244e-02f,
  -6.36263862e-02f, 2.71432810e-02f, 3.64888683e-02f, -3.11174290e-03f, -5.41839786e-02f, -8.58200639e-02f, -2.17021499e-02f, 5.72865978e-02f, 1.59517284e-02f, 1.96539192e-03f,
  -1.22322209e-01f, -7.49890506e-03f, 1.55241355e-01f, 3.54766138e-02f, 7.69557357e-02f, 1.68682337e-01f, -4.86066788e-02f, 7.88673162e-02f, 1.22322522e-01f, 6.37517571e-02f,
  -2.76504904e-02f, 1.91964626e-01f, 7.16684833e-02f, -5.51321730e-02f, 1.61207616e-02f, -5.43508097e-04f, 1.70789555e-01f, 7.08874688e-02f, 8.11040252e-02f, 6.64930642e-02f,
  -1.22856200e-01f, -1.04736969e-01f, -6.95738196e-02f, -1.13030963e-01f, -5.16723702e-03f, 1.77497298e-01f, 1.16270281e-01f, 1.70381479e-02f, -1.59040257e-01f, 1.38842221e-02f,
  -8.20886046e-02f, -1.35556519e-01f, 2.47442592e-02f, -7.96166882e-02f, -4.26513441e-02f, -9.53471586e-02f, 8.16819146e-02f, -2.44824309e-03f, 6.61537796e-02f, -3.61659713e-02f,
  -8.25216547e-02f, 1.22969568e-01f, -1.86768323e-01f, -1.29054680e-01f, -9.95455403e-03f, 7.58270100e-02f, -3.01130302e-02f, 2.01681517e-02f, -1.74904820e-02f, 8.13817829e-02f,
  -7.04417303e-02f, -4.43663485e-02f, 6.17874935e-02f, 6.79264311e-04f, -7.03698173e-02f, -4.98324521e-02f, 5.73942773e-02f, -5.54103125e-03f, -2.79888958e-02f, -2.00984068e-02f,
  -1.04250209e-02f, -6.45189732e-02f, 6.69568628e-02f, -8.66813734e-02f, -5.88725694e-02f, -1.92190930e-02f, -7.97370262e-03f, 7.51716495e-02f, 3.71452514e-03f, 5.20139262e-02f,
  3.31171416e-02f, -3.26337479e-02f, -4.33780178e-02f, -8.74323305e-03f, 5.04537672e-02f, 4.17768732e-02f, 4.36970443e-02f, -7.47595206e-02f, 8.01363736e-02f, 1.85475573e-02f,
  7.49492496e-02f, 5.75739369e-02f, -2.48448104e-02f, 9.53201428e-02f, -7.74458647e-02f, -2.00876649e-02f, 5.08008860e-02f, 4.75235432e-02f, -6.40765391e-03f, -1.97095629e-02f,
  -7.68340677e-02f, 2.25201622e-02f, 1.72661413e-02f, 3.44873555e-02f, 4.21045311e-02f, 6.31169304e-02f, 1.32756652e-02f, 4.83335182e-02f, -8.18419531e-02f, -5.05392207e-03f,
  -1.18037209e-01f, -1.56487614e-01f, 3.37220952e-02f, 6.31069988e-02f, -3.55219170e-02f, 8.23980272e-02f, 4.11652029e-02f, -8.40327516e-03f, 3.65139730e-02f, 6.07432332e-03f,
  1.08529557e-03f, 8.87619853e-02f, -4.12972644e-02f, -6.09458704e-03f, -6.24348447e-02f, 2.61010006e-02f, -4.70470339e-02f, -2.76842378e-02f, -4.10831124e-02f, 3.52737159e-02f,
  -9.84200612e-02f, -8.75011235e-02f, -1.80445760e-01f, -1.10998556e-01f, -9.30864662e-02f, -8.34064037e-02f, -1.18075065e-01f, -1.08255513e-01f, -7.55629316e-02f, -4.95900847e-02f,
  2.07005665e-02f, 5.36038578e-02f, -8.10880773e-03f, -6.95825741e-02f, -1.46344110e-01f, -1.92561388e-01f, -1.65285587e-01f, -5.71400523e-02f, -1.00567993e-02f, 2.33577061e-02f,
  3.17823589e-02f, -3.69027629e-02f, -1.17962256e-01f, -4.37310711e-03f, 5.98586071e-03f, -7.15545705e-03f, 7.27220401e-02f, 1.12880925e-02f, -1.43095106e-02f, -8.89374986e-02f,
  6.25897497e-02f, 1.33622009e-02f, 7.88532048e-02f, 1.42242968e-01f, 1.38962567e-01f, 4.37666550e-02f, 1.46136254e-01f, 1.80412501e-01f, 1.41040787e-01f, 2.14544132e-01f,
  7.52846822e-02f, 9.96724069e-02f, -1.29703209e-01f, 2.84650698e-02f, 3.94369997e-02f, 1.08824797e-01f, 5.41141666e-02f, -3.56640071e-02f, -8.74258131e-02f, 5.49778007e-02f,
  -1.86640769e-02f, -5.58519177e-02f, -8.93467292e-02f, 7.94129968e-02f, -1.13582648e-01f, 7.90415891e-03f, -6.67338222e-02f, 6.50703674e-04f, -2.53512636e-02f, -4.01519984e-02f,
  5.93549684e-02f, -4.49244343e-02f, -1.07903987e-01f, -1.00103147e-01f, 3.77531871e-02f, -4.46748175e-02f, -3.58598009e-02f, 1.34093866e-01f, 5.60172684e-02f, 2.24886045e-01f,
  6.89117685e-02f, -4.10325080e-03f, -1.57579351e-02f, 3.76974605e-02f, -2.91992538e-03f, 2.03305446e-02f, -3.78096551e-02f, 4.79059555e-02f, -4.27588541e-03f, -1.05935089e-01f,
  -1.98124945e-02f, -6.75068349e-02f, 3.54301147e-02f, -4.52917479e-02f, 4.70340699e-02f, 6.36931285e-02f, -6.69656396e-02f, 3.49674113e-02f, 4.95942868e-02f, -2.52957921e-02f,
  3.52866948e-03f, 1.37518831e-02f, 1.12518417e-02f, 3.68969552e-02f, 8.54318291e-02f, -6.60979981e-03f, -4.65272814e-02f, 6.57284539e-03f, 6.73483089e-02f, -2.04242487e-02f,
  -7.48691931e-02f, -1.58262357e-01f, 4.38230904e-03f, -1.84541382e-02f, -7.75028095e-02f, -3.07137873e-02f, -4.87619862e-02f, 5.71001731e-02f, -3.97229567e-02f, -8.13885853e-02f,
  1.07598891e-02f, -1.79602671e-02f, -9.71595496e-02f, -6.72704205e-02f, -8.17190707e-02f, -4.57749292e-02f, -1.31798005e-02f, -1.25437930e-01f, -1.21999912e-01f, -3.98307666e-02f,
  -3.42488959e-02f, -8.55100602e-02f, -1.22209392e-01f, -8.01092237e-02f, -7.94798508e-02f, -8.21147561e-02f, -9.63519886e-02f, 5.27828522e-02f, -1.69300497e-01f, -1.06182329e-01f,
  2.86971748e-01f, 1.36484951e-01f, -5.76070324e-03f, -4.21796478e-02f, 1.19274184e-02f, 7.38968551e-02f, 1.33482412e-01f, 6.63521662e-02f, -1.00722546e-02f, 1.08806290e-01f,
  1.30452856e-01f, 8.65520760e-02f, 4.61581945e-02f, 4.09860276e-02f, 1.55715853e-01f, -1.71671528e-02f, -9.47930738e-02f, 9.62001532e-02f, 6.35528117e-02f, 4.83570136e-02f,
  -1.04461148e-01f, -7.17172176e-02f, 9.06344280e-02f, 5.30521423e-02f, -2.40011662e-02f, 3.17181833e-02f, -3.92416306e-02f, 2.15855520e-02f, 3.45553644e-02f, -6.01395518e-02f,
  3.49592753e-02f, 2.58295208e-01f, -4.54410678e-03f, -9.18572769e-02f, -4.42699203e-03f, 8.44325125e-02f, -4.11114246e-02f, 1.27941370e-02f, -3.55524421e-02f, -5.27867228e-02f,
  8.21200386e-03f, 2.68369615e-02f, 5.57475118e-03f, 5.81646189e-02f, 4.74367104e-02f, -5.98941594e-02f, 8.65590870e-02f, 1.15650021e-01f, 4.18213755e-02f, 3.50619294e-02f,
  -3.04032359e-02f, 3.68118249e-02f, -1.50999371e-02f, 7.36322477e-02f, 1.48265347e-01f, -1.89362522e-02f, 3.93349789e-02f, 9.34340656e-02f, -1.43660116e-03f, 8.63221139e-02f,
  4.41984907e-02f, -4.86753024e-02f, 1.74108204e-02f, -5.11149950e-02f, 5.52852899e-02f, 7.51530752e-02f, -9.49503630e-02f, -1.78409810e-03f, 4.15483974e-02f, -5.68183027e-02f,
  -1.59021597e-02f, 7.88100585e-02f, 8.55859816e-02f, -7.44685978e-02f, -9.09021571e-02f, 1.79974474e-02f, -8.07467662e-03f, -9.05372784e-04f, -3.19973826e-02f, 1.34484340e-02f,
  -4.73048873e-02f, 1.01972535e-01f, -8.14415663e-02f, 8.70009512e-02f, 7.77025670e-02f, -6.56260997e-02f, -5.62595688e-02f, 2.36915611e-02f, 7.11800205e-03f, 5.08478321e-02f,
  -1.21224724e-01f, 1.73772410e-01f, -2.64087711e-02f, -2.24446692e-03f, 8.13629255e-02f, -3.31116132e-02f, -3.87080461e-02f, -5.87533005e-02f, -9.34289023e-02f, -5.56979328e-02f,
  4.73191440e-02f, 3.22135887e-03f, 9.21104848e-02f, 3.32931057e-02f, 1.30806118e-02f, -1.13651164e-01f, 4.63972278e-02f, -1.00703454e-02f, -1.99922044e-02f, -5.03207278e-03f,
  1.33491270e-02f, -2.90993918e-02f, -1.63934473e-02f, -6.71048164e-02f, -3.68681587e-02f, -5.33041023e-02f, -4.66100611e-02f, -4.45648143e-03f, 8.29632282e-02f, -2.54570544e-02f,
  1.75396100e-01f, 1.80790916e-01f, -3.84059072e-01f, 2.77192414e-01f, 1.00814216e-02f, -1.39224946e-01f, -1.60973430e-01f, -8.42076764e-02f, 1.07452169e-01f, 1.12219825e-01f,
  -3.99213284e-02f, 5.88664562e-02f, -8.83360729e-02f, -1.68612033e-01f, -3.41791570e-01f, -2.62242705e-01f, -2.20635116e-01f, -3.63119632e-01f, -4.35757518e-01f, -4.93689552e-02f,
  1.13871709e-01f, 9.28800255e-02f, -2.18898710e-02f, -1.55308902e-01f, 1.90059379e-01f, 2.87730563e-02f, -2.34528035e-02f, -4.68147406e-03f, -7.72372261e-02f, 4.93706651e-02f,
  -1.32855982e-01f, -1.55872561e-03f, -1.61552921e-01f, 1.77094787e-02f, -2.46099550e-02f, -4.97813225e-02f, -6.01857901e-03f, 3.16331838e-03f, -1.19608521e-01f, -6.02019615e-02f,
  2.59849466e-02f, 3.23880017e-02f, -1.04595020e-01f, -9.69802886e-02f, -1.50867477e-02f, -5.61692789e-02f, 2.63204351e-02f, -1.12014398e-01f, -1.04874961e-01f, -4.51267362e-02f,
  3.93489972e-02f, 7.53764734e-02f, -8.50575715e-02f, -9.59930010e-03f, -9.09803733e-02f, -1.15723848e-01f, 1.57484133e-02f, -1.17897697e-01f, -2.14491367e-01f, 1.84710324e-01f,
  6.63118809e-02f, -6.58559278e-02f, -5.30593880e-02f, 5.59471659e-02f, 1.31731210e-02f, 1.41090117e-02f, 3.14365909e-03f, -6.33797348e-02f, -2.63251811e-02f, -7.39869773e-02f,
  -3.76088656e-02f, 2.27382462e-02f, 4.14080247e-02f, 8.96242727e-03f, -3.19687314e-02f, -2.67432127e-02f, 4.82725818e-03f, -2.31441408e-02f, 1.26325833e-02f, -2.38898937e-02f,
  6.67173266e-02f, -7.58675039e-02f, -2.95075718e-02f, 7.19929039e-02f, -5.86645566e-02f, -7.17686489e-02f, 4.61635366e-02f, -3.13006639e-02f, -3.41040157e-02f, -2.68832402e-04f,
  1.67940095e-01f, -2.02309445e-01f, 5.69040105e-02f, -8.29818621e-02f, 2.97888815e-02f, -1.77084468e-02f, 1.22422408e-02f, -9.80597585e-02f, -4.47461940e-02f, 3.20801907e-03f,
  -1.11950852e-01f, -4.67568189e-02f, 3.21673006e-02f, -1.11062927e-02f, -3.78454737e-02f, 4.18124441e-03f, 5.24537712e-02f, -4.06605192e-02f, -6.69389218e-02f, 1.29947335e-01f,
  9.73886922e-02f, -7.84408301e-02f, -6.78474307e-02f, -5.78746712e-03f, 2.50125378e-02f, -6.56809285e-02f, -1.23536572e-01f, -1.70607027e-02f, -2.29491159e-01f, 1.56489924e-01f,
  4.37181830e-01f, 2.02090710e-01f, 3.26426834e-01f, 1.48732677e-01f, 3.17122862e-02f, 2.52393693e-01f, 2.40331307e-01f, 1.54668495e-01f, -1.07570663e-02f, 6.01265952e-02f,
  1.45814463e-01f, 7.48133706e-03f, -1.24853617e-03f, 9.92636289e-03f, 4.64273095e-02f, 8.04797933e-02f, 8.12241286e-02f, 1.05846561e-01f, 7.79796690e-02f, 7.30166957e-02f,
  -4.96728420e-02f, 3.46210152e-02f, 2.12003328e-02f, -1.87776256e-02f, -6.09990098e-02f, -1.44965155e-02f, -1.30589195e-02f, 6.67778403e-02f, 5.74558079e-02f, -6.36422336e-02f,
  -2.95932163e-02f, 2.69681901e-01f, -1.40474007e-01f, -1.21783152e-01f, 6.73848689e-02f, -7.85660297e-02f, -1.47619890e-03f, -3.66098508e-02f, -4.75913798e-03f, 5.08355424e-02f,
  -9.36406776e-02f, -1.81886442e-02f, -6.28286824e-02f, -1.87955424e-03f, 9.03535187e-02f, -7.83978254e-02f, 3.30335163e-02f, 8.90643522e-02f, -4.08305489e-02f, 3.64991017e-02f,
  -8.36460292e-02f, 5.63377291e-02f, 1.00149386e-01f, 4.59460281e-02f, 8.09601974e-03f, -7.14686606e-03f, 8.40782225e-02f, 9.30265114e-02f, 8.33685100e-02f, -1.84676424e-02f,
  -1.05792925e-01f, 6.17285110e-02f, 4.71407622e-02f, 3.25635187e-02f, 5.43527491e-02f, 2.42765862e-02f, 3.63156684e-02f, 2.95042302e-02f, 8.21079127e-03f, -3.48845907e-02f,
  7.99383782e-03f, 6.61002621e-02f, -5.40790856e-02f, 5.13056628e-02f, 2.89432029e-03f, 8.16494897e-02f, -2.65760198e-02f, 2.11861674e-02f, -4.75204289e-02f, -6.11141399e-02f,
  3.99253890e-02f, 4.74226512e-02f, 1.19040772e-01f, -3.39942202e-02f, -7.00393394e-02f, 5.80902472e-02f, -7.06129521e-02f, -5.92342764e-02f, -3.97946239e-02f, 7.32143894e-02f,
  -2.09717453e-01f, -5.14088236e-02f, -1.08688697e-01f, -8.89956951e-02f, -5.03559150e-02f, 3.59355994e-02f, 7.46794194e-02f, -1.16999894e-01f, -2.43359921e-03f, -5.63964806e-02f,
  -3.65788154e-02f, -4.57604453e-02f, -5.47015741e-02f, -4.80872439e-03f, -1.41013954e-02f, 4.71187867e-02f, -9.73036662e-02f, -3.56977507e-02f, -2.79555768e-02f, -1.09664522e-01f,
  -1.14328368e-02f, -1.85252912e-02f, -9.87583399e-02f, 6.07729070e-02f, -3.33913527e-02f, -1.05785519e-01f, 1.67746302e-02f, -6.65237531e-02f, 1.48299029e-02f, -5.25535457e-02f,
  -1.00609519e-01f, 1.42009109e-01f, -3.64060886e-02f, 2.31218100e-01f, 1.99454129e-01f, 2.19621301e-01f, 7.94805661e-02f, 4.93461490e-02f, 1.56921729e-01f, 1.33201361e-01f,
  1.02929056e-01f, 1.71019107e-01f, 2.16170222e-01f, 9.69180465e-02f, 7.18113557e-02f, 1.26553386e-01f, 5.64618022e-05f, 9.40183401e-02f, 1.13795429e-01f, 3.20470370e-02f,
  -8.59893765e-03f, -4.76740822e-02f, -5.85169308e-02f, -5.71585149e-02f, -8.21763556e-03f, 2.72461995e-02f, -9.05310083e-03f, 5.64506575e-02f, 8.20016414e-02f, -4.06847037e-02f,
  -5.13597652e-02f, -3.49016413e-02f, -5.30899130e-02f, -8.74138325e-02f, -3.11006941e-02f, -2.67789643e-02f, -8.40888079e-03f, -9.21823457e-03f, -6.80586472e-02f, -1.30173033e-02f,
  -7.88451657e-02f, -2.07535140e-02f, 9.64895040e-02f, -6.89747185e-02f, -5.34591191e-02f, 4.75487411e-02f, -2.24691257e-02f, -4.54941690e-02f, -3.59650962e-02f, 5.30935638e-02f,
  7.83271641e-02f, 7.52978921e-02f, 6.60191327e-02f, -2.49306373e-02f, 2.93971337e-02f, 3.40192555e-03f, 7.33902007e-02f, -3.61940451e-02f, -3.22145484e-02f, -4.80973944e-02f,
  1.47145212e-01f, 4.48562354e-02f, 6.95535019e-02f, 7.80185685e-02f, 8.95369723e-02f, 5.82200326e-02f, -2.97960751e-02f, -4.53121103e-02f, -2.29104254e-02f, 2.58903708e-02f,
  -1.17176247e-03f, 1.67488810e-02f, 9.62323099e-02f, 8.79619420e-02f, -1.67950206e-02f, 9.37821493e-02f, -4.03064713e-02f, 8.61497968e-03f, 9.54603218e-03f, -7.17078894e-02f,
  -4.32989970e-02f, 7.35099986e-02f, 4.55406420e-02f, 2.64054313e-02f, 1.88173465e-02f, 1.30020767e-01f, -3.66642065e-02f, 2.86455994e-04f, 4.95969504e-02f, 1.60233472e-02f,
  -7.79074878e-02f, 1.27865613e-01f, 7.25131184e-02f, 6.48644716e-02f, 5.46044577e-03f, -2.60482468e-02f, 8.71357918e-02f, -9.05271471e-02f, -1.28236949e-01f, -1.41316913e-02f,
  -1.45071838e-02f, -4.63519581e-02f, 8.13922510e-02f, -5.78239895e-02f, -7.45168105e-02f, 4.85777631e-02f, 3.70348687e-04f, 9.12581757e-02f, 5.01443669e-02f, -2.79755481e-02f,
  1.35918185e-02f, -2.27531996e-02f, 6.57787472e-02f, -7.43291080e-02f, 9.99096930e-02f, -1.81988033e-03f, -2.79773213e-02f, -6.16699643e-02f, 7.66305774e-02f, -1.81372166e-02f,
  -1.87471077e-01f, -1.17651112e-01f, -1.20828703e-01f, -8.76106247e-02f, -3.77354808e-02f, -2.49617230e-02f, 2.06347108e-02f, 3.37590091e-02f, -1.39340311e-02f, -9.93657336e-02f,
  -1.06896028e-01f, 2.07868200e-02f, -9.28475186e-02f, -3.97831686e-02f, 7.66820312e-02f, -9.66946259e-02f, -1.27335951e-01f, 1.61653049e-02f, 1.29660770e-01f, 1.10792607e-01f,
  1.34453118e-01f, 7.03972280e-02f, -7.12988228e-02f, 2.60988101e-02f, 6.66979700e-02f, -8.75386000e-02f, -1.09332167e-01f, 3.26568298e-02f, -5.32358065e-02f, -9.11033824e-02f,
  -1.37055442e-01f, -5.32053709e-02f, 5.46277575e-02f, -3.55056045e-03f, 6.80794567e-02f, -2.68335678e-02f, 5.05747721e-02f, -4.10640053e-02f, -5.88623732e-02f, 4.63850684e-02f,
  9.85287055e-02f, 6.97072595e-02f, 6.96055731e-03f, 3.70437950e-02f, -5.22587262e-03f, 9.03216824e-02f, -6.13132641e-02f, 5.78497313e-02f, -5.02192341e-02f, 4.34743846e-03f,
  4.22229394e-02f, -2.19386145e-02f, -4.18511033e-03f, 4.96571809e-02f, 3.41163352e-02f, 1.05410911e-01f, 6.72754645e-02f, 5.77736236e-02f, 4.64393757e-02f, 1.27022583e-02f,
  -1.77695155e-02f, -3.01433317e-02f, -1.57350060e-02f, -4.25608940e-02f, 7.47213885e-02f, -4.88392152e-02f, 8.93426761e-02f, -4.51747589e-02f, 8.06804448e-02f, -3.63106579e-02f,
  4.17079329e-02f, -9.23541263e-02f, -6.98885694e-02f, 2.53380905e-03f, 1.18841594e-02f, -3.33070606e-02f, -6.80616274e-02f, 3.82792801e-02f, 3.37757356e-02f, 1.94873083e-02f,
  2.13678870e-02f, 8.94076657e-03f, -9.90277231e-02f, -4.90822792e-02f, -5.68303615e-02f, -2.09399201e-02f, -2.16449611e-03f, -9.43984929e-03f, 7.02177063e-02f, -6.31167591e-02f,
  -1.26230881e-01f, 3.83459614e-03f, 7.53982514e-02f, -2.61526797e-02f, -1.32446857e-02f, 2.91858017e-02f, 6.21472411e-02f, 1.93596538e-02f, 6.98960871e-02f, -3.62681001e-02f,
  -2.56726351e-02f, 5.08452915e-02f, -2.53762845e-02f, 3.89881097e-02f, -4.09505107e-02f, 4.60965484e-02f, 3.77655029e-03f, -8.44083205e-02f, -7.58769140e-02f, -4.00972366e-02f,
  5.15143685e-02f, 3.85475047e-02f, -3.78093012e-02f, 2.01156717e-02f, 6.50726259e-02f, -6.82101175e-02f, -5.88073060e-02f, -4.66833748e-02f, -8.82230699e-02f, 6.54603867e-03f,
  -1.72099814e-01f, -1.74017698e-01f, -4.28519137e-02f, 6.06043339e-02f, -9.19845048e-03f, -1.32198587e-01f, -1.19461298e-01f, -4.37474735e-02f, -1.58702470e-02f, -2.39275955e-03f,
  -4.00577895e-02f, -4.84833829e-02f, -1.22418940e-01f, -3.04885525e-02f, -1.95733324e-01f, -2.37995505e-01f, -1.65675163e-01f, -2.35366747e-01f, -9.50083602e-03f, -1.35503128e-01f,
  -1.14800960e-01f, -1.01417713e-01f, -5.15540056e-02f, 2.46204529e-02f, 1.27823845e-01f, 4.00909893e-02f, 1.03866711e-01f, -5.08389026e-02f, 3.46631445e-02f, -3.72401401e-02f,
  1.83785651e-02f, 3.59386653e-02f, 1.65620409e-02f, -3.52837443e-02f, -5.66498116e-02f, -8.28516707e-02f, -6.93027675e-02f, 7.53851756e-02f, 1.32354070e-02f, 2.72248387e-02f,
  2.04094183e-02f, -1.69097409e-02f, 5.91823608e-02f, -6.44786358e-02f, 2.46120803e-02f, -3.30994017e-02f, -7.35578164e-02f, 1.10943355e-02f, 4.25462388e-02f, -4.70896112e-03f,
  -2.16634348e-02f, -9.80669707e-02f, -9.69936326e-02f, -4.66202572e-02f, 7.38602057e-02f, -5.04735764e-03f, 2.84402166e-02f, 9.17215869e-02f, 8.07252228e-02f, 1.41278431e-01f,
  6.09522313e-02f, 3.89377065e-02f, 7.86850229e-02f, -8.33377689e-02f, 4.22286093e-02f, -3.51726748e-02f, -2.97080968e-02f, 6.41830936e-02f, 2.12892573e-02f, 2.23048609e-02f,
  1.04828753e-01f, -2.68062893e-02f, 1.06045149e-01f, 5.46766333e-02f, -5.97436316e-02f, -1.31296758e-02f, -2.60358639e-02f, -6.65269271e-02f, 1.60370991e-02f, -4.36114930e-02f,
  3.21446322e-02f, 1.55591769e-02f, -1.60250254e-02f, -1.19864764e-02f, -2.04018708e-02f, 4.87868860e-02f, -1.08167408e-02f, 8.55732858e-02f, 6.92955479e-02f, -1.31971268e-02f,
  5.68707660e-02f, -7.25816330e-03f, -4.99198511e-02f, -2.18412429e-02f, 9.44081414e-03f, -1.92015059e-02f, 2.97482107e-02f, -4.48156288e-03f, 7.27412701e-02f, -5.35614043e-02f,
  -2.85324138e-02f, -7.67905489e-02f, 1.69602558e-02f, -6.03156313e-02f, 5.80988042e-02f, -7.29759857e-02f, -1.42262667e-01f, -1.21508107e-01f, 6.27974197e-02f, -6.19303472e-02f,
  -9.03069675e-02f, -7.80705139e-02f, -6.10643402e-02f, -5.10003604e-02f, -1.44846947e-03f, -1.97035670e-01f, 1.35115907e-03f, 5.16578071e-02f, -7.79130980e-02f, -2.62851268e-02f,
  1.71868265e-01f, -1.38882607e-01f, -1.99830621e-01f, 5.99393398e-02f, 5.68076931e-02f, -9.37090348e-03f, 7.00024515e-02f, 1.41201288e-01f, 1.19444363e-01f, 4.14742380e-02f,
  -1.20699763e-01f, -5.29105254e-02f, -1.07931100e-01f, -8.63767415e-02f, 2.64409240e-02f, -1.40493363e-01f, -9.26843658e-02f, -1.11742519e-01f, -3.76429558e-02f, 7.02196434e-02f,
  8.05061460e-02f, -4.58945632e-02f, 8.00066441e-02f, -7.16749579e-02f, 3.34905162e-02f, -6.81283176e-02f, -1.60809860e-01f, -3.69116329e-02f, -9.94166061e-02f, -1.66215509e-01f,
  -6.87385947e-02f, -1.19338773e-01f, -4.43044230e-02f, -7.93310031e-02f, 2.98326984e-02f, -2.20331755e-02f, -5.54302111e-02f, -1.05903342e-01f, 1.55322580e-02f, -1.09312937e-01f,
  -3.87992151e-02f, 4.31898423e-02f, 5.46518639e-02f, -5.66857029e-03f, -5.75324669e-02f, 3.88604626e-02f, 4.74406668e-04f, -8.69840682e-02f, -4.26074155e-02f, -2.78542768e-02f,
  -1.75531749e-02f, -4.95529398e-02f, -1.16369491e-02f, -7.79696777e-02f, -1.24974705e-01f, -3.09668109e-02f, 5.16685098e-03f, -4.07087766e-02f, -2.81145275e-02f, -5.48424423e-02f,
  8.48473608e-02f, -1.32010579e-02f, 2.28779707e-02f, 3.97695899e-02f, 1.55615034e-02f, -6.25866950e-02f, 5.61796576e-02f, -4.91649136e-02f, 1.36948358e-02f, 9.99187585e-04f,
  -7.27575971e-03f, 3.46321836e-02f, -7.33079836e-02f, -6.05712598e-03f, -5.43567687e-02f, 2.35616937e-02f, 2.38380730e-02f, 7.76484143e-03f, 4.62662503e-02f, -3.83633524e-02f,
  4.03000563e-02f, -8.50652009e-02f, 7.63662718e-03f, 1.02227973e-02f, -6.03045598e-02f, -2.83721723e-02f, 6.70264140e-02f, 6.54469579e-02f, -6.02369420e-02f, 7.46362507e-02f,
  2.63537019e-02f, -1.15198836e-01f, -1.23851402e-02f, 4.45079245e-03f, -6.42975271e-02f, 2.81794253e-03f, 2.47457232e-02f, -5.73220588e-02f, -4.35227789e-02f, 2.99088024e-02f,
  2.11230945e-02f, 6.36747181e-02f, -4.13253494e-02f, -8.56250175e-04f, -6.47995295e-03f, 5.34614958e-02f, 1.89691503e-02f, 6.39334023e-02f, 2.32227845e-03f, -1.38051109e-02f,
  1.14161912e-02f, 5.82022481e-02f, 3.51108722e-02f, 6.77008741e-03f, 1.95809230e-02f, 2.42846515e-02f, 1.87530695e-03f, 6.13392629e-02f, 3.84536386e-02f, 1.35301366e-01f,
  -2.48806581e-01f, -1.44269895e-02f, 9.50337425e-02f, -2.41614491e-01f, -2.25858781e-02f, -1.68460179e-02f, -8.03472102e-03f, -4.20647301e-02f, -1.61497921e-01f, -5.52770197e-02f,
  9.90392268e-02f, 8.53598788e-02f, 5.71627244e-02f, 2.45688837e-02f, 2.00970266e-02f, 5.65235987e-02f, -1.06753044e-01f, 1.70829594e-02f, -3.26889977e-02f, -1.19806498e-01f,
  -2.56173909e-02f, -9.57681462e-02f, -1.69238448e-01f, -5.20663820e-02f, 1.54510466e-02f, -2.34426185e-02f, 5.41816931e-03f, -6.67482689e-02f, -5.23844399e-02f, -7.08479583e-02f,
  2.38259763e-01f, -7.21783340e-02f, -7.48224258e-02f, -1.39239326e-01f, 2.20233314e-02f, -5.80718033e-02f, -7.26339594e-02f, -3.17072421e-02f, -2.93911956e-02f, 4.40822281e-02f,
  1.85845569e-02f, -7.33367279e-02f, -1.91159863e-02f, 7.74015933e-02f, -7.41774887e-02f, 6.84560090e-02f, 1.61905997e-02f, 1.56084858e-02f, 2.78812069e-02f, 1.37742758e-01f,
  8.28906335e-03f, 8.37642758e-04f, 1.29614249e-01f, 7.26667792e-02f, 9.90225468e-03f, 7.06273839e-02f, 7.05216676e-02f, -6.62655756e-03f, -2.92389840e-03f, -6.43244833e-02f,
  -6.24447800e-02f, 7.47661293e-02f, 3.85681093e-02f, 6.49089813e-02f, 1.55939162e-02f, 5.85724600e-02f, -7.73375779e-02f, 9.26557928e-02f, -6.47793636e-02f, -5.87743931e-02f,
  -5.32724485e-02f, 8.74341056e-02f, 5.96413463e-02f, 5.50933294e-02f, -5.96857034e-02f, 4.65102084e-02f, -8.10336620e-02f, 3.22092660e-02f, -4.63884808e-02f, 3.56939156e-03f,
  -5.51008098e-02f, -8.99711922e-02f, -8.60479623e-02f, 9.45171043e-02f, -5.26304170e-02f, 1.74553059e-02f, 2.94892080e-02f, 2.57632155e-02f, -4.78916653e-02f, -3.45688462e-02f,
  1.53134435e-01f, -5.07852808e-02f, 2.01779865e-02f, -1.81583513e-03f, -3.29342671e-02f, 7.36986846e-02f, -5.91177121e-02f, -5.56436926e-02f, -3.72347534e-02f, 1.30432975e-02f,
  -5.37057072e-02f, 7.69518642e-03f, 1.09991953e-01f, -6.63108528e-02f, -7.65672699e-02f, -4.05914783e-02f, -9.29179564e-02f, 3.55950221e-02f, -2.24108924e-03f, 1.11512065e-01f,
  -3.53742465e-02f, -1.65624842e-02f, -4.16333228e-02f, 1.01721615e-01f, -4.74556424e-02f, 7.20581636e-02f, 2.58061178e-02f, 2.56231185e-02f, 5.83740808e-02f, 1.25469282e-01f,
  3.26607302e-02f, 2.35003959e-02f, 1.38721615e-01f, -2.88266136e-04f, 2.17023212e-02f, 2.14914098e-01f, 2.13390946e-01f, 1.38842449e-01f, -5.42970449e-02f, -7.84764737e-02f,
  -5.07085919e-02f, -9.92102176e-02f, -2.04522554e-02f, -1.29622176e-01f, -1.03928410e-01f, 1.05229288e-01f, 1.09691404e-01f, 8.78841430e-02f, -3.39200273e-02f, 1.17952034e-01f,
  -5.85403182e-02f, -7.15834424e-02f, 6.17058501e-02f, -6.94876611e-02f, 3.41091789e-02f, -7.72641897e-02f, 4.76015545e-02f, 2.31734347e-02f, -5.89449294e-02f, -3.92117240e-02f,
  -2.02770680e-02f, 1.07856393e-01f, -2.41800342e-02f, -3.16482969e-02f, 9.30924565e-02f, 1.00951642e-02f, 3.93367931e-02f, -1.42446859e-02f, 8.59116539e-02f, 1.27724290e-03f,
  2.49892827e-02f, -6.08486086e-02f, -5.09005077e-02f, 4.19007577e-02f, 5.28043993e-02f, -2.26316564e-02f, -9.82978866e-02f, -3.22173126e-02f, 5.88291176e-02f, -8.71657059e-02f,
  1.17264548e-02f, -3.20478007e-02f, 9.77806225e-02f, 5.73177822e-02f, 9.92689864e-04f, 5.53690875e-03f, -7.41824731e-02f, 3.19929123e-02f, -2.06780080e-02f, 6.32022023e-02f,
  -4.21450697e-02f, 4.42934632e-02f, -3.74945439e-02f, -4.71634455e-02f, 3.19148302e-02f, 1.17671043e-01f, -1.95265515e-03f, -6.07291497e-02f, -6.57949895e-02f, 1.44262761e-02f,
  3.83599848e-02f, -7.00338185e-02f, -3.70122269e-02f, -2.16370560e-02f, 3.97937708e-02f, 4.86090071e-02f, -1.11889699e-02f, 3.98679748e-02f, 7.27243870e-02f, 8.51274580e-02f,
  7.91069567e-02f, -3.29739377e-02f, -3.38620991e-02f, -6.44632578e-02f, -5.17723784e-02f, -2.30393801e-02f, 7.63862208e-02f, 2.86794454e-02f, 2.10350640e-02f, -6.14582896e-02f,
  5.22374921e-02f, -5.64339794e-02f, -6.43083155e-02f, -6.59006983e-02f, 5.34640849e-02f, -8.07345659e-02f, -1.04694784e-01f, 3.39414105e-02f, 9.88118649e-02f, 1.35306083e-02f,
  -5.66787869e-02f, -5.19966967e-02f, 4.60389517e-02f, -8.52428824e-02f, 7.52945617e-02f, 3.94821726e-02f, -5.48839793e-02f, 6.78759441e-02f, -5.07781841e-02f, 9.19246599e-02f,
  -6.29921816e-03f, 2.02528927e-02f, 9.30396095e-02f, 5.66139333e-02f, -6.00740612e-02f, 8.94533023e-02f, -2.39409730e-02f, -1.23634227e-02f, 2.90407296e-02f, 4.99506779e-02f,
  1.96775392e-01f, 7.96393827e-02f, 2.04645485e-01f, 1.34772867e-01f, 1.97216123e-01f, 2.57960081e-01f, 1.70264170e-01f, 1.10271767e-01f, 7.20770583e-02f, 1.96819007e-02f,
  -8.02554786e-02f, -1.40457571e-01f, -7.84320980e-02f, -6.29015788e-02f, -8.41954947e-02f, -3.41738723e-02f, -4.10648286e-02f, -3.01770605e-02f, 1.31612673e-01f, 1.12300150e-01f,
  3.81882451e-02f, 6.44264743e-02f, 4.13420796e-02f, 9.06006247e-02f, -9.49920062e-03f, -1.10632807e-01f, 2.85204481e-02f, -2.17225663e-02f, -7.53704831e-02f, 3.25912498e-02f,
  -4.14980315e-02f, 7.57416487e-02f, -4.97012436e-02f, -5.23404405e-02f, -4.21452485e-02f, 2.71532778e-03f, 8.02787300e-03f, -5.79638258e-02f, -2.46738084e-02f, 9.57040638e-02f,
  6.46361858e-02f, 6.44192938e-03f, 2.30506100e-02f, 7.20751733e-02f, 1.60050288e-01f, 4.83846255e-02f, -4.75336313e-02f, 5.29954061e-02f, -6.54016882e-02f, -2.70329546e-02f,
  -7.36302584e-02f, 1.35562792e-01f, 3.56756933e-02f, 1.47128031e-02f, -2.48396527e-02f, -2.41575558e-02f, 8.47168937e-02f, -6.06960133e-02f, 5.16709313e-02f, 5.92222065e-02f,
  5.03095873e-02f, 6.55608475e-02f, 2.62118559e-02f, -5.14264684e-03f, -1.11565053e-01f, 5.37834018e-02f, 1.96740590e-02f, 3.33540291e-02f, -4.47128154e-02f, 4.78704087e-03f,
  -2.82714199e-02f, -1.23876631e-02f, 7.64526054e-02f, -4.42099050e-02f, 1.60083584e-02f, 6.53583705e-02f, 6.09524213e-02f, 4.53295931e-02f, -1.09050579e-01f, 3.78089622e-02f,
  -5.51597662e-02f, 7.53121898e-02f, -7.73582980e-02f, 1.35369636e-02f, 3.93817313e-02f, -3.22925150e-02f, -8.38515684e-02f, -2.98113469e-02f, -1.57540049e-02f, -2.47651841e-02f,
  -1.57853700e-02f, 5.25229014e-02f, 1.56572147e-04f, -1.17685877e-01f, 7.42568076e-02f, 1.10065863e-02f, -7.74433166e-02f, 4.80288900e-02f, -7.88477957e-02f, 4.83374782e-02f,
  1.24077424e-01f, -8.27582628e-02f, 7.75102153e-02f, 8.48361626e-02f, 9.77369994e-02f, -2.03751326e-02f, -1.39691401e-02f, 5.14576547e-02f, -1.56084783e-02f, -8.10490549e-02f,
  1.66214928e-02f, 8.55328664e-02f, 5.84720075e-02f, 7.29965940e-02f, -1.39068263e-02f, 5.67334928e-02f, 2.57066675e-02f, 5.17220087e-02f, 7.62102082e-02f, 7.08397850e-02f,
  -1.97469927e-02f, -2.93719489e-02f, 2.44076047e-02f, -5.60105033e-02f, -5.53435609e-02f, -9.61733982e-02f, 4.14766110e-02f, -9.30046216e-02f, -8.31470564e-02f, 9.52443108e-02f,
  -4.22006771e-02f, -4.80855703e-02f, 3.18879224e-02f, -8.20721406e-03f, -1.66845351e-01f, 1.28993327e-02f, -4.16869782e-02f, -1.43488348e-01f, -1.07335001e-01f, -1.22050263e-01f,
  -7.15164095e-02f, 8.57128948e-02f, -5.29749878e-02f, -3.99977937e-02f, 3.63306254e-02f, -8.09649155e-02f, -4.71226200e-02f, -1.24464624e-01f, -1.03417262e-01f, -4.90676798e-02f,
  1.49082676e-01f, -1.23186469e-01f, -5.21825859e-04f, -9.25223604e-02f, 1.60197150e-02f, -4.17880006e-02f, -7.34241083e-02f, 1.33138709e-02f, -5.80388494e-02f, -3.58432680e-02f,
  -1.37573972e-01f, -1.40051097e-01f, -4.95058633e-02f, -6.48353323e-02f, -9.74288359e-02f, -3.34199592e-02f, 4.69634347e-02f, -8.33003037e-03f, -7.94166327e-02f, 9.44057759e-03f,
  -3.71833369e-02f, -1.13370754e-01f, -1.11193068e-01f, 7.08399639e-02f, -9.78274718e-02f, -1.70304433e-01f, 4.35905457e-02f, -1.36074200e-01f, -3.08946185e-02f, 9.41189677e-02f,
  6.08986095e-02f, 2.82032676e-02f, -2.13175882e-02f, 5.06289154e-02f, 4.52725515e-02f, -1.64980274e-02f, 5.26581444e-02f, 5.88049106e-02f, 2.22597588e-02f, -2.62628943e-02f,
  5.02886921e-02f, -1.08422153e-02f, 5.32829128e-02f, -1.22689558e-02f, -3.70333306e-02f, 3.27490568e-02f, -3.45843583e-02f, 1.02677062e-01f, 6.41081557e-02f, -4.22446895e-03f,
  -6.68761432e-02f, 5.36613539e-02f, 4.69956063e-02f, -1.49716763e-02f, -8.66346136e-02f, 6.68958351e-02f, -9.56621990e-02f, -5.92548924e-04f, 5.06434068e-02f, -9.60912704e-02f,
  3.14501196e-01f, -2.27171823e-01f, 2.00965740e-02f, 2.73423898e-03f, -1.18653560e-02f, -2.98465248e-02f, -6.98745390e-03f, 9.46259033e-03f, -2.52978876e-02f, -2.36063935e-02f,
  -5.07226214e-02f, 3.68848443e-02f, 8.44594240e-02f, 6.72994554e-02f, -2.08743364e-02f, -7.46604279e-02f, 8.67698863e-02f, -5.83404154e-02f, 3.98346670e-02f, 5.83696961e-02f,
  4.92455959e-02f, 5.93812540e-02f, 4.04677987e-02f, 9.30131599e-02f, -3.42386067e-02f, -3.76374535e-02f, 1.06655352e-01f, 7.95494691e-02f, 6.54695928e-02f, 3.27247947e-01f,
  -2.82446116e-01f, 1.13355651e-01f, -3.10425997e-01f, 3.59023027e-02f, 1.03147261e-01f, 5.57628982e-02f, 5.13780415e-02f, 5.34204878e-02f, 1.46983936e-01f, 1.87067389e-02f,
  -1.68050788e-02f, -2.34117582e-02f, 4.88068052e-02f, -9.82721299e-02f, -5.66953383e-02f, 1.14591584e-01f, 1.57405213e-01f, -1.20962318e-02f, -3.24430540e-02f, -1.71435159e-03f,
  1.81391090e-01f, -4.59317528e-02f, -9.29137319e-02f, 2.71024257e-02f, 1.39286324e-01f, -5.35012186e-02f, 1.98434442e-02f, -7.41571039e-02f, -2.57889810e-03f, 1.20172866e-01f,
  -3.59953523e-01f, -1.62581518e-01f, -1.31963855e-02f, -1.93006955e-02f, -1.20010160e-01f, -7.34208375e-02f, 6.35861466e-03f, -7.77841453e-03f, -2.60831732e-02f, 2.57129651e-02f,
  -8.85723755e-02f, -6.12649433e-02f, 7.46520087e-02f, 2.21042726e-02f, -1.76825318e-02f, -1.00673489e-01f, 5.37123084e-02f, -6.97357655e-02f, -4.55283225e-02f, -7.17241615e-02f,
  5.23305759e-02f, -3.46526951e-02f, -6.38952777e-02f, 2.01826934e-02f, -1.78438611e-02f, 8.99596512e-03f, -1.27166748e-01f, 4.08945605e-03f, -1.25511512e-01f, 3.21558840e-03f,
  -2.70174295e-02f, -4.81185876e-02f, -4.22168262e-02f, 4.43729199e-02f, 1.16289750e-01f, -6.72658756e-02f, -4.67540175e-02f, -3.21740471e-02f, -4.96670045e-02f, 5.24619259e-02f,
  -5.57317697e-02f, 3.34551521e-02f, 2.56924964e-02f, 2.13122033e-02f, -6.61037210e-03f, -1.41778076e-02f, -4.55081873e-02f, 2.73104552e-02f, -6.52102828e-02f, -1.11939371e-01f,
  -8.23121369e-02f, -5.81380278e-02f, -1.74818300e-02f, -4.19351719e-02f, 6.51619583e-02f, 1.20543102e-02f, 2.77608670e-02f, 6.22958615e-02f, -2.24984698e-02f, -3.17735691e-03f,
  -5.83484322e-02f, -1.83343962e-01f, 7.09198490e-02f, 8.99265520e-03f, -1.90822538e-02f, -1.98235847e-02f, -1.06451511e-02f, -3.25805284e-02f, -8.73431042e-02f, -1.72087345e-02f,
  1.12400260e-02f, 2.09405255e-02f, 3.60580012e-02f, -3.90402302e-02f, -7.37975538e-03f, 4.56346869e-02f, 7.13043362e-02f, -4.58644368e-02f, -3.18577439e-02f, 3.11438255e-02f,
  1.06784003e-02f, 9.70868301e-03f, -6.88552186e-02f, -3.87771428e-02f, 3.05934325e-02f, 1.36333685e-02f, 4.25093025e-02f, -4.63594347e-02f, -1.26140043e-01f, 7.97242224e-02f,
  9.73130912e-02f, 8.04524496e-02f, -1.94585204e-01f, 1.03119090e-02f, -1.29989535e-01f, -1.98279217e-01f, -4.78134863e-02f, -4.99140099e-02f, -3.03846505e-02f, -9.43378173e-03f,
  6.77940855e-03f, 4.96522114e-02f, -6.05298989e-02f, -4.11027297e-02f, -9.46677383e-03f, -1.59353271e-01f, -1.97517633e-01f, -2.27895707e-01f, -1.91511065e-01f, -5.43795675e-02f,
  -3.44425924e-02f, 5.09807020e-02f, -1.48042655e-02f, 2.71623954e-03f, 1.42809171e-02f, 6.17183447e-02f, 2.54281461e-02f, 2.29248647e-02f, -5.31392507e-02f, -2.23968178e-02f,
  -1.74962103e-01f, -3.38115692e-02f, 3.25992741e-02f, 8.74860659e-02f, 5.76061532e-02f, 3.87109369e-02f, 2.67688441e-03f, -2.74473634e-02f, 1.13054775e-01f, 5.99721894e-02f,
  -8.08039971e-04f, 2.82474663e-02f, -4.31987271e-02f, -2.29534898e-02f, -5.67090772e-02f, -3.77693176e-02f, 4.75618057e-03f, -6.67656586e-02f, 5.43024950e-02f, -3.08460332e-02f,
  6.89352900e-02f, -5.93384095e-02f, 5.77617809e-02f, -1.30033903e-02f, 5.96800931e-02f, 5.09172641e-02f, 3.67980339e-02f, -1.62575971e-02f, 6.31870478e-02f, 1.58810183e-01f,
  -4.22568060e-03f, 5.62757328e-02f, -3.17966975e-02f, -6.50226995e-02f, 9.60544571e-02f, 8.13161805e-02f, 3.59158916e-03f, 6.92520216e-02f, -4.81568128e-02f, 5.17731234e-02f,
  2.59424374e-02f, 4.99240905e-02f, -6.28030226e-02f, -4.92106490e-02f, -3.19324285e-02f, 5.04981801e-02f, 2.80733146e-02f, 9.32164118e-02f, -7.42005855e-02f, -1.25065753e-02f,
  6.02358393e-02f, 1.22112766e-01f, -1.55012282e-02f, 6.54724538e-02f, -6.57247305e-02f, 3.43087129e-02f, -9.36559066e-02f, -6.52415082e-02f, -3.85458432e-02f, -7.81053901e-02f,
  1.02165878e-01f, -7.97998980e-02f, -2.61534639e-02f, -4.30130512e-02f, -1.40055539e-02f, -3.49826887e-02f, -2.51201820e-03f, 6.41835183e-02f, -9.14760306e-03f, 5.28029650e-02f,
  -1.59680936e-02f, -4.22952697e-02f, 7.38152862e-02f, 1.08649045e-01f, -8.24260637e-02f, 5.52041121e-02f, 6.98502287e-02f, -4.90077864e-03f, -6.30324930e-02f, 1.05592353e-05f,
  5.37970215e-02f, 4.19510677e-02f, 6.88123405e-02f, 1.32773384e-01f, -1.17316924e-03f, -5.89685552e-02f, 1.18653700e-01f, -2.38248650e-02f, -1.13024665e-02f, 1.95637763e-01f,
  -3.55258346e-01f, -1.94760025e-01f, 4.27051298e-02f, -1.40664995e-01f, -7.28808120e-02f, 4.46052700e-02f, -1.69680834e-01f, -5.73307090e-02f, -6.08327314e-02f, -9.58479792e-02f,
  -1.08301513e-01f, -7.48179061e-03f, -1.22293875e-01f, -1.26765385e-01f, -1.35430530e-01f, -4.76659872e-02f, -1.94837913e-01f, -9.40277055e-02f, -7.05138519e-02f, 9.61163044e-02f,
  -1.02782972e-01f, -1.35471717e-01f, -6.70025423e-02f, -1.35859698e-02f, -1.68232862e-02f, 4.78848927e-02f, -2.71101147e-02f, -4.68643121e-02f, -9.95336920e-02f, -2.09789187e-01f,
  -3.11519913e-02f, -4.85912152e-02f, 4.17419709e-02f, -1.31740049e-01f, 6.87330142e-02f, -4.25851420e-02f, 6.97014108e-02f, 7.87801668e-02f, 2.49565281e-02f, -6.27916399e-03f,
  -8.37377831e-02f, 4.79514375e-02f, -6.16275482e-02f, -5.10895960e-02f, 4.38455269e-02f, 3.09753679e-02f, -4.26063128e-02f, -9.95492265e-02f, 5.49067147e-02f, -7.08392216e-03f,
  -8.14270452e-02f, -5.64310998e-02f, -5.50080910e-02f, 7.04008117e-02f, 4.42695841e-02f, -1.02931403e-01f, 5.22256121e-02f, 7.11903796e-02f, -4.93544638e-02f, -7.65513182e-02f,
  -2.82755457e-02f, 6.76077604e-02f, -6.15589973e-03f, 1.77251305e-02f, -2.32975744e-02f, -2.69646407e-03f, 4.58247736e-02f, -4.97636236e-02f, -2.52424879e-03f, 1.01221511e-02f,
  -1.11275073e-03f, 1.74626871e-03f, 6.98564798e-02f, -1.05745487e-01f, 9.14412439e-02f, -5.34673631e-02f, 2.65896488e-02f, -5.87645955e-02f, 4.95651178e-02f, -5.92580736e-02f,
  -4.61928323e-02f, 6.06439002e-02f, 4.08081412e-02f, 6.89020613e-03f, -9.09635574e-02f, -2.72577051e-02f, -2.01864801e-02f, 5.28311208e-02f, -1.87128205e-02f, -7.13071823e-02f,
  1.87263135e-02f, 2.56216191e-02f, -3.66593041e-02f, 3.06820888e-02f, 5.78965573e-03f, 5.93297221e-02f, -7.53767639e-02f, 1.28169293e-02f, 3.92270461e-02f, 2.20443029e-02f,
  -6.16848804e-02f, 6.38413280e-02f, 1.34125454e-02f, -1.99964494e-02f, -7.19050169e-02f, -9.42436419e-03f, -6.20928816e-02f, -3.63165047e-03f, -9.81245041e-02f, -7.47942850e-02f,
  -1.09963916e-01f, -2.59454012e-01f, -2.63036668e-01f, -8.36983323e-02f, -1.37325348e-02f, -1.27752572e-01f, -1.78543225e-01f, -1.67496651e-01f, -3.77574489e-02f, -2.80315995e-01f,
  -3.64996716e-02f, 1.19777113e-01f, -1.31276265e-01f, 1.38191164e-01f, 4.93760034e-02f, -1.02147665e-02f, -2.78070383e-02f, 4.07563299e-02f, -1.54323662e-02f, 4.53918539e-02f,
  8.68466794e-02f, 4.18977663e-02f, 1.04819365e-01f, 4.53207232e-02f, 6.67813569e-02f, -2.15461869e-02f, 1.91478863e-01f, 9.64617450e-03f, -5.71174510e-02f, -4.01287489e-02f,
  1.63379997e-01f, 1.25797033e-01f, 1.49956699e-02f, 2.50211917e-02f, 1.51263058e-01f, 1.39032140e-01f, 4.15062867e-02f, 8.08427408e-02f, 9.53026414e-02f, 2.70506471e-01f,
  -4.53523435e-02f, -4.89858128e-02f, -1.97410472e-02f, 1.29505888e-01f, -1.00786556e-02f, -5.73453121e-02f, -3.34058069e-02f, -5.07282745e-03f, 2.43169218e-02f, -6.78685904e-02f,
  3.62908170e-02f, -3.51482369e-02f, 4.26865406e-02f, 8.77637491e-02f, -2.36744732e-02f, -8.39042738e-02f, -3.35707851e-02f, 2.29279231e-02f, -5.76661155e-02f, 4.18148376e-02f,
  1.15609244e-01f, -4.27098311e-02f, -9.99612212e-02f, -1.35010168e-01f, 1.58396282e-03f, 8.82089436e-02f, -8.77289176e-02f, 5.91344610e-02f, -1.09584220e-01f, -5.40044047e-02f,
  -6.86944872e-02f, 4.89942916e-02f, -4.87430207e-03f, -2.73736473e-02f, -2.90816221e-02f, 5.73897697e-02f, -5.80249680e-03f, 5.94122894e-02f, -3.30101065e-02f, 2.28716023e-02f,
  -1.00796819e-02f, 6.69808015e-02f, -6.24926090e-02f, 6.55838624e-02f, -2.99004372e-02f, 3.07979845e-02f, 7.49598369e-02f, 9.13054030e-03f, -7.94538669e-03f, 4.01633829e-02f,
  1.26418415e-02f, -1.24946246e-02f, 5.01187518e-02f, 2.32276302e-02f, 8.49317946e-03f, 5.04723042e-02f, 8.21767226e-02f, 1.85619500e-02f, 3.08301486e-02f, -5.19267656e-02f,
  5.30729964e-02f, -1.52639672e-01f, 1.15752518e-01f, 2.73665451e-02f, -1.88346785e-02f, -4.46880274e-02f, -5.53604439e-02f, -2.32619643e-02f, -3.03676096e-03f, 3.65052819e-02f,
  -3.04791145e-02f, -1.05007878e-02f, -6.35346398e-02f, 3.52355838e-02f, 3.72665152e-02f, 2.07787976e-02f, 6.29872605e-02f, 1.73980426e-02f, -3.60843278e-02f, 6.49643168e-02f,
  2.25564018e-02f, -7.76148215e-02f, -2.36343127e-02f, -9.20283142e-03f, 6.31939769e-02f, 3.12802196e-02f, -9.28882882e-02f, -3.16330902e-02f, -6.69798106e-02f, -5.91782294e-02f,
  -1.15144692e-01f, 8.76467451e-02f, 1.52975798e-01f, 2.15909988e-01f, 2.47711137e-01f, 3.57187241e-01f, 2.82002032e-01f, 2.10741445e-01f, 4.27345112e-02f, 2.20191982e-02f,
  -8.61211270e-02f, -1.27691075e-01f, -2.63820589e-02f, -2.32039150e-02f, 7.47989044e-02f, 1.25783652e-01f, 1.77394092e-01f, 2.85269739e-03f, -4.29881103e-02f, -8.02926868e-02f,
  7.64134228e-02f, 4.90928032e-02f, -6.68388903e-02f, -6.60342351e-02f, 9.43022594e-02f, -7.28378519e-02f, 5.48110902e-02f, 1.62633304e-02f, -8.19354206e-02f, 3.10311355e-02f,
  -1.94555014e-01f, 9.65595022e-02f, -1.12514244e-04f, -1.47958353e-01f, -2.30159387e-02f, -1.10255145e-01f, -1.05175376e-01f, -3.94645222e-02f, -6.45752857e-03f, -1.07022054e-01f,
  2.47499477e-02f, -1.07786030e-01f, 1.07247926e-01f, 2.22745705e-02f, 1.44594871e-02f, 1.30869616e-02f, -4.84159477e-02f, 2.98505910e-02f, -8.27551112e-02f, -7.13108405e-02f,
  3.03122252e-02f, 5.35074957e-02f, 1.90543965e-03f, 5.47232628e-02f, 2.28920523e-02f, -5.76582402e-02f, 7.69566596e-02f, 5.26845874e-03f, -4.43198867e-02f, 8.61904677e-03f,
  -1.61890592e-02f, 7.29693323e-02f, -4.75028120e-02f, 6.33135671e-03f, -5.56556433e-02f, 8.90075937e-02f, -9.90697648e-03f, 4.63649482e-02f, 9.22066942e-02f, -5.42939454e-02f,
  -4.45826352e-02f, -7.45025575e-02f, -2.30172854e-02f, -5.69981337e-02f, -4.85106558e-02f, 5.66377491e-02f, -6.95976987e-02f, -2.69221049e-02f, -5.08914813e-02f, -5.43594137e-02f,
  9.19077620e-02f, 2.66730394e-02f, -1.67095754e-02f, -4.74232435e-02f, -1.50850127e-02f, -3.24150287e-02f, -3.93763557e-02f, 1.22291818e-02f, 3.64432633e-02f, 1.58760860e-03f,
  -1.01608284e-01f, 9.75641832e-02f, -7.65714422e-03f, 1.53776053e-02f, -3.07082552e-02f, -1.14445142e-01f, -4.45956402e-02f, -8.91015977e-02f, -8.16266313e-02f, 1.81380566e-02f,
  5.77376261e-02f, 1.57635808e-02f, -7.76674077e-02f, 4.52301018e-02f, -5.40396571e-02f, 3.79056744e-02f, -7.60566220e-02f, -3.62206362e-02f, 6.55998811e-02f, -6.22282512e-02f,
  2.66148131e-02f, 5.79420775e-02f, 7.24254549e-02f, 6.03246838e-02f, 6.12879284e-02f, 3.57576720e-02f, 3.38903330e-02f, -6.72597717e-03f, 1.05223924e-01f, -4.83157411e-02f,
  -1.31187811e-01f, 8.50692391e-02f, -1.10804424e-01f, 1.99583888e-01f, -7.30385184e-02f, -4.97219823e-02f, -1.32358253e-01f, -5.11266179e-02f, 8.13792646e-02f, -9.42292856e-04f,
  -5.29126031e-03f, 1.56751335e-01f, 7.33496249e-02f, -2.51907911e-02f, -3.28521021e-02f, 5.48817404e-02f, 1.11639179e-01f, 6.85078874e-02f, -1.16552114e-01f, -2.25234982e-02f,
  1.26358554e-01f, 2.15213001e-02f, -1.03029482e-01f, -3.42706814e-02f, 9.17708576e-02f, 1.50575951e-01f, -3.61822285e-02f, -1.18041625e-02f, -6.82417825e-02f, 2.59718418e-01f,
  -8.08154047e-02f, -7.66318962e-02f, -7.22656846e-02f, 1.35165751e-01f, -2.15652902e-02f, 3.69251743e-02f, 7.50775933e-02f, -7.12360218e-02f, 4.51233834e-02f, 4.32206690e-02f,
  7.61359408e-02f, -5.24883233e-02f, 4.14275825e-02f, 3.79723050e-02f, -1.00881115e-01f, 3.13212685e-02f, -7.30202273e-02f, -1.03580788e-01f, 1.36593506e-02f, -5.09861000e-02f,
  1.15962870e-01f, 5.75191639e-02f, -7.77205229e-02f, -3.30753177e-02f, -8.81582648e-02f, -8.71758088e-02f, -1.22883186e-01f, 2.70182714e-02f, -1.39646173e-01f, 5.12262508e-02f,
  1.32004946e-01f, 4.83482257e-02f, 5.39404415e-02f, 8.13455954e-02f, 1.03813469e-01f, -3.71452011e-02f, 9.99568626e-02f, -3.72097120e-02f, 4.67388853e-02f, 5.67762181e-02f,
  8.94863065e-03f, 7.14911446e-02f, 7.86211416e-02f, -3.93178165e-02f, 6.45501837e-02f, 7.98674971e-02f, 8.91715214e-02f, -7.26593006e-03f, -7.76409134e-02f, -7.20695034e-02f,
  2.99294833e-02f, 4.99050021e-02f, 6.29281327e-02f, -7.89150596e-03f, -1.36787696e-02f, -4.78121229e-02f, -5.90795688e-02f, -5.89323752e-02f, 4.19870317e-02f, 7.74432421e-02f,
  6.86397851e-02f, -1.29973680e-01f, 7.27005377e-02f, 1.50740147e-02f, 8.64630789e-02f, 2.23331098e-02f, -2.38834624e-03f, 8.25590417e-02f, 3.61674838e-02f, 2.16226719e-04f,
  -4.22034599e-02f, -5.03879152e-02f, 7.55950883e-02f, -6.67544305e-02f, -8.59979093e-02f, 4.62922826e-02f, -5.52460589e-02f, -3.90052274e-02f, 4.12463397e-02f, -8.90097991e-02f,
  6.30377531e-02f, 2.31157020e-02f, -1.68472826e-01f, -1.75238159e-02f, 1.62662324e-02f, -1.27801225e-02f, -1.64993834e-02f, -1.22505806e-01f, -1.84834287e-01f, -1.61649421e-01f,
  3.08555812e-01f, -2.08629102e-01f, -4.65360522e-01f, 8.95647332e-02f, -1.76120847e-01f, -6.45163059e-02f, -1.86814427e-01f, 2.30804645e-02f, 5.67645952e-02f, -1.62313730e-01f,
  -1.13748148e-01f, -4.51526940e-02f, -1.53772131e-01f, -1.37196243e-01f, -1.11252524e-01f, -2.52627701e-01f, -1.64822266e-01f, -1.66654125e-01f, 5.35040721e-02f, 1.39952153e-01f,
  -3.28699946e-02f, 1.06630921e-01f, 7.09758177e-02f, -1.61405758e-03f, 1.99917927e-02f, 4.66335844e-03f, -1.73541769e-01f, -6.88969046e-02f, -1.98593423e-01f, -2.31675714e-01f,
  -1.93435550e-01f, 4.46179658e-02f, 3.16241868e-02f, 7.95823559e-02f, -2.42131148e-02f, -3.87721229e-03f, 3.27851549e-02f, -2.13870797e-02f, 4.74530607e-02f, -7.23121613e-02f,
  -9.68561023e-02f, 3.68028656e-02f, 1.12824207e-02f, -1.52976299e-02f, -2.70353947e-02f, -5.89783816e-03f, -2.27044746e-02f, 4.42628153e-02f, 4.74295989e-02f, -1.02008721e-02f,
  -3.10381092e-02f, -4.49957773e-02f, -4.86359149e-02f, -8.06504935e-02f, -2.58478858e-02f, 1.79316327e-02f, -1.19415961e-01f, 4.67581078e-02f, -8.16602409e-02f, 3.26660089e-02f,
  -8.47736746e-03f, 2.09764321e-03f, 6.73016580e-03f, 4.77830209e-02f, 8.96628350e-02f, 6.02450501e-03f, -1.51414331e-02f, -4.04000245e-02f, 1.16487093e-01f, 8.77910480e-02f,
  -9.72798094e-03f, -2.21043993e-02f, 5.02806455e-02f, -2.28350759e-02f, 2.82282066e-02f, -8.88109878e-02f, -5.34548238e-02f, -5.44072390e-02f, 6.87165186e-02f, 5.84260188e-02f,
  6.08293749e-02f, 4.87472713e-02f, 2.90758070e-02f, 6.42900914e-02f, -1.11692492e-02f, -4.16016616e-02f, 4.93012704e-02f, 8.34429078e-03f, -9.93842706e-02f, -8.50431770e-02f,
  7.09208054e-03f, 2.08471064e-02f, -6.28056973e-02f, 9.73352119e-02f, -1.15894396e-02f, -1.00175627e-01f, -4.44303975e-02f, 1.20584378e-02f, 1.01211537e-02f, 4.96000871e-02f,
  4.42783497e-02f, -1.03185205e-02f, -9.93754566e-02f, 2.09512818e-03f, 1.32700384e-01f, -3.69747058e-02f, 1.84953362e-02f, -5.31561337e-02f, -6.13222346e-02f, 2.77944561e-02f,
  3.76024842e-02f, 5.14088087e-02f, 1.47051990e-01f, 9.73097757e-02f, 6.34988211e-03f, -1.65795237e-02f, -9.73644555e-02f, 3.23362574e-02f, 7.57396594e-02f, 1.29143193e-01f,
  -1.15789644e-01f, -2.94021487e-01f, -2.78128445e-01f, -8.76460746e-02f, -2.68214166e-01f, -2.10262433e-01f, -2.50308365e-01f, -4.65706252e-02f, -7.72950947e-02f, -3.12300175e-01f,
  -2.29965732e-01f, 7.50168338e-02f, -1.16518028e-01f, -1.28098026e-01f, -1.53700367e-01f, -3.73448849e-01f, -3.71591806e-01f, -2.29112059e-01f, -1.61099825e-02f, -1.30121848e-02f,
  -3.37388329e-02f, -1.98733866e-01f, -1.40122145e-01f, -4.09050956e-02f, -8.08318332e-03f, -8.59981179e-02f, -2.23185584e-01f, -4.98527437e-02f, -1.46874040e-01f, -2.76818633e-01f,
  -2.99713969e-01f, 2.04663977e-01f, 7.63639584e-02f, 7.68043920e-02f, -5.41900657e-02f, -4.65715192e-02f, -4.90320995e-02f, 2.13641394e-02f, 8.42425078e-02f, 7.07459915e-03f,
  -1.79797775e-04f, 3.14163826e-02f, -4.67762388e-02f, 5.44413179e-02f, 2.48371530e-02f, -4.46386598e-02f, 2.54639275e-02f, -4.43560965e-02f, 1.35847898e-02f, -9.31370556e-02f,
  -5.85676078e-03f, -3.28648873e-02f, -2.63077971e-02f, 2.70958450e-02f, 3.12486775e-02f, 7.42955878e-02f, 6.33673160e-04f, 8.37286115e-02f, 9.80253052e-03f, -4.30166684e-02f,
  -4.71435301e-02f, 2.64064875e-02f, -7.50604421e-02f, 3.69060822e-02f, -5.35650253e-02f, -1.38122495e-02f, -1.32340575e-02f, -9.86561272e-03f, -3.72218229e-02f, -9.38828513e-02f,
  6.64411187e-02f, -6.35152534e-02f, 1.24745779e-02f, -3.18761393e-02f, -7.41088688e-02f, 6.73313215e-02f, -4.80541326e-02f, -3.08143739e-02f, -9.31273922e-02f, 5.36968186e-02f,
  -5.76416291e-02f, 7.51748160e-02f, -7.29908273e-02f, 6.31633550e-02f, -6.33621439e-02f, -3.52845080e-02f, 4.97236066e-02f, -3.79798859e-02f, 8.71834159e-02f, 1.25891799e-02f,
  5.43257780e-02f, 4.59526628e-02f, -1.27468765e-01f, -5.11018885e-03f, -7.61830956e-02f, 1.37504237e-02f, -6.54167235e-02f, 7.98087865e-02f, -2.63234582e-02f, -3.40663642e-02f,
  6.74199015e-02f, 4.34828782e-03f, -8.64206627e-02f, -1.73800508e-03f, 4.89793792e-02f, -2.05470398e-02f, -7.10559189e-02f, -2.23395303e-02f, 1.76906995e-02f, 2.79207025e-02f,
  -1.83419406e-01f, -4.79360670e-02f, 8.83870795e-02f, -7.34939706e-03f, 1.80751681e-02f, 4.58871834e-02f, 2.39115059e-02f, 8.15983564e-02f, 1.69582069e-02f, -2.07340017e-01f,
  -1.72116101e-01f, -7.60795698e-02f, -3.53981927e-02f, -2.24981830e-01f, -3.93272005e-02f, -4.11452651e-02f, -6.55465275e-02f, -3.52101214e-02f, -1.62368178e-01f, -8.22968781e-02f,
  -7.54775181e-02f, 3.15308943e-02f, -9.00527239e-02f, 3.86178009e-02f, 7.99686462e-02f, 4.62090829e-03f, -1.12921976e-01f, 6.50116280e-02f, 2.68605892e-02f, 6.81602061e-02f,
  -8.64837542e-02f, -9.11689848e-02f, -9.90666598e-02f, -1.05039835e-01f, -2.01006621e-01f, 2.37674359e-03f, -1.38643026e-01f, -7.93011859e-02f, 7.12088570e-02f, -1.50542602e-01f,
  -1.06217980e-01f, -1.14050470e-02f, -7.65302479e-02f, 7.75499940e-02f, 3.99525538e-02f, -3.05381883e-02f, -7.70355090e-02f, 3.27786384e-03f, -6.15867488e-02f, -6.82027265e-02f,
  -6.67522177e-02f, -8.78116637e-02f, -5.73448837e-02f, -4.72357236e-02f, -1.16202131e-01f, -4.54150699e-02f, 4.71501313e-02f, -1.98227670e-02f, 5.03379479e-02f, -7.97850173e-03f,
  -2.82076076e-02f, 8.85873511e-02f, -3.40042077e-02f, 4.52294052e-02f, -4.35027927e-02f, 5.39601259e-02f, 1.26437768e-01f, 1.09857842e-01f, -1.93913840e-02f, -8.75427127e-02f,
  -1.73420403e-02f, 2.93232296e-02f, 4.71976027e-02f, 5.30341156e-02f, -5.02349585e-02f, 6.51129261e-02f, 4.85140160e-02f, -5.38901240e-02f, -1.24032830e-03f, -4.57450598e-02f,
  8.81477222e-02f, 3.25136632e-02f, -7.75300488e-02f, 1.01488195e-02f, -2.81597227e-02f, 9.70246047e-02f, 1.23864800e-01f, -3.55485566e-02f, 1.13120876e-01f, 2.10397802e-02f,
  4.26920503e-03f, 9.40601379e-02f, -3.13217640e-02f, 9.84772369e-02f, 9.00663286e-02f, 3.84021178e-02f, -2.56389715e-02f, 1.58175062e-02f, 4.45330106e-02f, 4.21037450e-02f,
  -1.39236316e-01f, 2.17294067e-01f, -1.14652798e-01f, 5.50144054e-02f, 2.60204845e-03f, -4.75587398e-02f, -8.76354277e-02f, -3.92519943e-02f, -3.73454057e-02f, -8.70332718e-02f,
  5.10369018e-02f, 4.79768775e-02f, -1.17530907e-02f, -2.45646923e-03f, -8.04228336e-02f, 5.49608981e-03f, 9.16922092e-02f, 6.28824951e-03f, 2.02114191e-02f, -6.82405680e-02f,
  8.59087929e-02f, -5.99432997e-02f, 8.19566548e-02f, -1.45407254e-02f, 2.58657187e-02f, -3.78376357e-02f, -3.04737091e-02f, 4.74896282e-02f, 2.19552722e-02f, -6.03837073e-02f,
  1.44686937e-01f, 1.89787373e-01f, -3.57968211e-02f, 2.80924942e-02f, -2.43325174e-01f, -2.07274780e-01f, -2.55331248e-02f, -8.69578868e-03f, 2.44122953e-03f, 1.08409882e-01f,
  -4.32704687e-02f, -5.31201847e-02f, -2.80645043e-02f, 3.13093439e-02f, 1.74491659e-01f, 1.98878318e-01f, 1.02946602e-01f, 1.66700825e-01f, 1.46070570e-02f, 5.54840751e-02f,
  1.44236803e-01f, 1.52681902e-01f, 1.65912747e-01f, 1.87585071e-01f, 1.87915266e-01f, -6.01963215e-02f, 2.20595188e-02f, 7.17941523e-02f, 1.28215358e-01f, 2.93571353e-01f,
  1.52383164e-01f, 3.97616774e-02f, -6.33831173e-02f, -6.23873733e-02f, -1.09612800e-01f, 6.52304292e-02f, -7.71764368e-02f, -1.18815629e-02f, -6.31157383e-02f, 1.11701228e-01f,
  -1.25947416e-01f, 4.60195579e-02f, 5.27099008e-03f, 8.00469369e-02f, 5.77699766e-02f, 3.45653389e-03f, 1.04800045e-01f, 4.90502901e-02f, 5.70554696e-02f, 3.04938909e-02f,
  3.43370959e-02f, -2.29429230e-02f, -7.42174909e-02f, 4.82356036e-03f, 2.97949053e-02f, -2.51163673e-02f, -5.01927771e-02f, -4.71813567e-02f, -6.78652823e-02f, 5.60197681e-02f,
  -4.69163582e-02f, 6.13435209e-02f, -4.67912368e-02f, 1.06016874e-01f, 2.63141114e-02f, -7.03200772e-02f, 6.61634654e-02f, 2.00215206e-02f, -5.23598827e-02f, 2.97952108e-02f,
  -9.90220681e-02f, 2.82055344e-02f, -6.35116454e-03f, -4.46997583e-03f, -1.38931740e-02f, -3.49603295e-02f, 7.69753382e-02f, 4.70976233e-02f, -1.03813913e-02f, 5.76275773e-03f,
  -9.04179737e-03f, -1.24927880e-02f, -5.16977794e-02f, 8.38979781e-02f, -2.96908934e-02f, 1.86118186e-02f, 1.15809962e-01f, -3.84088047e-02f, -7.61512667e-02f, 1.37420371e-02f,
  -1.32252365e-01f, -2.98568428e-01f, 7.87154958e-02f, 1.15110770e-01f, -4.11855755e-03f, -6.05436675e-02f, -4.37117890e-02f, 1.81617215e-02f, -7.71246105e-02f, 5.75240217e-02f,
  -5.46278246e-02f, 8.64328444e-02f, -9.12747756e-02f, 1.61275435e-02f, -9.25959572e-02f, -9.59137231e-02f, 2.27352306e-02f, -2.41491552e-02f, -6.23734668e-02f, -1.06477011e-02f,
  -7.20935315e-02f, -8.41464475e-02f, -7.69835338e-02f, -1.52783453e-01f, -1.08131550e-01f, -1.84611678e-01f, -3.50729302e-02f, -1.04316190e-01f, -1.44758567e-01f, 1.25058126e-02f,
  3.29858810e-02f, 1.44920424e-01f, -4.18356061e-02f, 5.39874285e-02f, -3.84583399e-02f, -2.16304082e-02f, -9.70612094e-02f, 3.48673016e-03f, 1.13699131e-01f, 8.56293887e-02f,
  9.33912620e-02f, 1.37951776e-01f, 1.00906014e-01f, 3.14983330e-03f, -9.82426032e-02f, 6.18971251e-02f, -4.33418602e-02f, -7.09671676e-02f, -9.76146534e-02f, -9.49201733e-02f,
  8.97845104e-02f, 9.07242000e-02f, 3.64798307e-02f, -8.34869295e-02f, 2.32124012e-02f, -2.50330493e-02f, 5.07047437e-02f, -5.68815842e-02f, -3.64271477e-02f, -4.47094347e-03f,
  -9.32302400e-02f, -4.42814752e-02f, 6.15930147e-02f, -7.03591155e-03f, -9.23898593e-02f, 1.14073470e-01f, 4.14238796e-02f, -4.57827002e-02f, 4.06617709e-02f, -3.99386929e-03f,
  6.02084473e-02f, 3.41471061e-02f, -1.26513373e-02f, 1.01792760e-01f, 2.11190600e-02f, 8.17567706e-02f, -3.85295344e-03f, -3.29188965e-02f, -1.95052549e-02f, -7.06725055e-03f,
  3.13523039e-02f, 8.45873356e-02f, -2.44303159e-02f, 5.91683351e-02f, -5.23118787e-02f, 9.65778157e-02f, -1.22466572e-02f, 3.85803394e-02f, 8.80224165e-03f, 1.63589716e-01f,
  7.81837758e-03f, -2.87534986e-02f, -5.46551906e-02f, -4.53774743e-02f, 4.10049334e-02f, 5.75598776e-02f, -9.01647955e-02f, 1.68387275e-02f, 4.19256091e-02f, -2.96247322e-02f,
  -6.51954324e-04f, -4.51864712e-02f, 5.66159077e-02f, -8.12043399e-02f, -4.46402095e-02f, 1.24944060e-03f, -4.79282402e-02f, -1.05283512e-02f, 5.60860075e-02f, 3.15267891e-02f,
  5.79310879e-02f, -2.73866369e-03f, 3.04141417e-02f, -1.12490557e-01f, 8.16976503e-02f, -9.30591226e-02f, 4.81628589e-02f, 4.10660356e-02f, 7.43662417e-02f, 6.69401065e-02f,
  3.79699282e-02f, -5.61901480e-02f, 3.58609632e-02f, -3.70741114e-02f, 7.66736045e-02f, 6.85725361e-02f, 6.84931204e-02f, 5.71557134e-02f, -5.06786518e-02f, 1.33102298e-01f,
  7.45070651e-02f, -1.85333062e-02f, 2.47486308e-02f, 9.84889790e-02f, 1.92746203e-02f, -6.01735786e-02f, 1.15028322e-02f, 7.61412755e-02f, 9.85364467e-02f, 1.04257062e-01f,
  9.43800062e-02f, -1.92635488e-02f, -2.83907959e-03f, -6.47888752e-03f, 2.80537996e-02f, -9.58281755e-02f, -3.72091979e-02f, 4.48650569e-02f, -4.54147048e-02f, 1.26254395e-01f,
  1.55671155e-02f, -1.36740774e-01f, 1.97321922e-01f, -6.59327731e-02f, 3.06143761e-02f, -5.19171022e-02f, -1.48948416e-01f, -3.09623796e-02f, -1.12439200e-01f, -4.74084020e-02f,
  -5.91023117e-02f, -6.77906051e-02f, 3.02288812e-02f, 6.21508025e-02f, -7.02939089e-03f, 7.52317235e-02f, -1.09610637e-03f, 1.34882584e-01f, 1.88036039e-01f, -8.21015462e-02f,
  -1.75620727e-02f, -1.37052964e-03f, 9.27638337e-02f, 5.71581312e-02f, -1.22506209e-01f, 2.02347618e-02f, -1.61584392e-02f, -3.17456387e-03f, 1.08902296e-02f, -1.31591350e-01f,
  -1.61802813e-01f, -7.87534043e-02f, 7.99650401e-02f, -6.87180012e-02f, -1.22434786e-02f, -4.75865640e-02f, -6.69518709e-02f, 3.80666442e-02f, -3.79838236e-02f, 2.34286059e-02f,
  2.02199742e-02f, 5.46861812e-02f, -2.33911127e-02f, -3.10629513e-02f, -1.32778417e-02f, 6.31125048e-02f, 9.12408065e-03f, 6.29608780e-02f, 1.06608100e-01f, -1.00565657e-01f,
  -6.44516647e-02f, -5.34913801e-02f, -2.10194085e-02f, 2.72600818e-02f, 2.53109094e-02f, 1.09107271e-01f, -8.33892599e-02f, -6.52660504e-02f, 1.13750838e-01f, -1.36896789e-01f,
  -1.42861065e-02f, 2.32268572e-02f, 1.04153790e-01f, -1.38899926e-02f, -1.59578659e-02f, -3.14056571e-03f, 5.53607102e-03f, 2.60925256e-02f, 6.90332800e-03f, 1.13365222e-02f,
  3.09939086e-02f, 5.68151996e-02f, 4.58357856e-02f, -3.25124264e-02f, -8.96122959e-03f, -3.47359665e-02f, 3.89854237e-02f, 4.42035124e-02f, -5.82207628e-02f, 2.18795836e-02f,
  3.93064618e-02f, 7.73699954e-02f, 5.59656397e-02f, 1.11141831e-01f, 4.71946271e-03f, -4.63958457e-02f, -5.93933761e-02f, 7.90402144e-02f, -1.58764068e-02f, -5.26385270e-02f,
  -1.62861556e-01f, 2.17578277e-01f, -8.39820877e-02f, -4.58904803e-02f, -7.92399123e-02f, 7.89634287e-02f, -3.97809036e-02f, 3.74225527e-02f, -8.43384340e-02f, -7.02081323e-02f,
  -3.30883339e-02f, -8.37370232e-02f, -2.68452726e-02f, -4.71868366e-02f, -6.71123564e-02f, -1.07725197e-02f, -8.94080177e-02f, -1.85582172e-02f, -5.39272651e-02f, -2.82197334e-02f,
  -7.51238763e-02f, -6.65608570e-02f, -7.89937451e-02f, 3.18309804e-03f, -1.03744725e-03f, 2.91337632e-02f, -1.00703679e-01f, -1.13242500e-01f, -7.07680434e-02f, -8.14304724e-02f,
  -4.12828326e-02f, 1.65536970e-01f, -1.48066040e-02f, 1.40814304e-01f, 1.72519907e-01f, 7.41236135e-02f, 1.96147874e-01f, 1.45672798e-01f, 1.23488389e-01f, 2.30956767e-02f,
  1.41179457e-01f, 9.87846926e-02f, 3.51060033e-02f, 8.52042288e-02f, -9.96391773e-02f, 7.57814646e-02f, 5.90110384e-02f, -7.55287260e-02f, -8.16330165e-02f, 2.16067862e-02f,
  1.00765333e-01f, 1.35214552e-02f, -1.10953212e-01f, -9.72672328e-02f, 7.64234981e-04f, 6.56453073e-02f, -1.40278852e-02f, -1.19208510e-03f, 1.01637878e-02f, -4.19022283e-03f,
  -1.79685637e-01f, 1.08823776e-01f, 6.45132270e-04f, 9.65803564e-02f, 5.47905639e-02f, 1.87790971e-02f, 3.42589617e-02f, -8.02747905e-02f, -9.06802863e-02f, -1.15130693e-02f,
  4.35566204e-03f, -5.84146045e-02f, 2.60634869e-02f, 1.64938439e-02f, -5.47242165e-02f, -7.50354305e-02f, -2.11269353e-02f, -5.45417815e-02f, -7.85976201e-02f, -9.84894037e-02f,
  6.66926205e-02f, -7.76459184e-03f, 9.42109525e-03f, -3.93294450e-03f, -1.83380898e-02f, -7.83660039e-02f, 2.63086073e-02f, -1.13509618e-01f, -1.30674601e-01f, -5.18146493e-02f,
  -3.15955505e-02f, -1.03652030e-01f, 3.15131582e-02f, 3.71495960e-03f, 6.50026836e-03f, 2.03868002e-03f, -3.99389453e-02f, 7.86347501e-03f, 5.13182767e-02f, -8.62364843e-02f,
  5.28510399e-02f, 1.88000314e-02f, 3.30440924e-02f, 4.55372669e-02f, 9.09466222e-02f, 3.42848971e-02f, 1.03025839e-01f, 6.94962544e-03f, 8.73366371e-02f, -5.49151823e-02f,
  -5.29746637e-02f, -3.15997005e-03f, 6.88179433e-02f, -2.58726105e-02f, -2.37078685e-02f, 5.44519052e-02f, 1.32386619e-02f, -2.90751904e-02f, -4.20248061e-02f, -3.39192599e-02f,
  1.27756506e-01f, 1.06105372e-01f, -7.75084496e-02f, -4.75742184e-02f, -6.75058141e-02f, 1.03238691e-02f, 9.35874879e-02f, 2.94143427e-02f, 8.05493668e-02f, 6.59761131e-02f,
  -2.83504948e-02f, -7.79548809e-02f, 4.77250144e-02f, -9.46644694e-03f, -6.69714287e-02f, 3.12779695e-02f, 4.02135216e-02f, -1.14249684e-01f, -1.20011859e-01f, -5.02035692e-02f,
  -2.34474447e-02f, 4.94582020e-02f, 4.90490757e-02f, 5.99984312e-03f, -1.02590285e-01f, 4.97331060e-02f, -8.77649486e-02f, 9.50070377e-03f, -5.28757535e-02f, -5.07283323e-02f,
  -1.25501724e-02f, -4.35711481e-02f, -7.74224550e-02f, 9.99282151e-02f, -1.15012385e-01f, 1.05134454e-02f, -9.84136462e-02f, -8.34879130e-02f, 5.75690717e-02f, -4.63163108e-02f,
  -9.42500606e-02f, -3.48071801e-03f, 6.90150168e-03f, 8.97038579e-02f, 1.29504576e-01f, -4.36597578e-02f, 3.92273366e-02f, 1.11602366e-01f, 1.68309167e-01f, -9.10867471e-03f,
  6.94853961e-02f, 2.49007605e-02f, 1.45496940e-02f, 3.99575792e-02f, 4.25173678e-02f, 8.32455158e-02f, -4.77391928e-02f, 7.52641857e-02f, 1.34099443e-02f, 1.73304155e-02f,
  -1.52580783e-01f, -1.37976771e-02f, 1.42827332e-01f, 8.29281881e-02f, 6.28450364e-02f, 7.37491576e-03f, -1.20398309e-02f, 1.09695112e-02f, -4.12485264e-02f, 5.07950895e-02f,
  -4.66195978e-02f, -5.68318814e-02f, -1.44322878e-02f, -5.79932407e-02f, -2.70896032e-02f, 5.64513989e-02f, -6.67159706e-02f, 1.42120704e-01f, -2.93481741e-02f, 1.91108715e-02f,
  4.59025875e-02f, -8.52481574e-02f, 8.30003768e-02f, 2.19918098e-02f, 4.99143489e-02f, 1.06577404e-01f, 2.88250204e-02f, 3.12998258e-02f, -3.41629125e-02f, -6.97014779e-02f,
  -1.41765876e-02f, 4.50224942e-03f, 1.39011219e-01f, -4.46253754e-02f, 9.25306231e-02f, -7.99935535e-02f, -6.14499263e-02f, 4.82933633e-02f, 4.59230803e-02f, 1.60209257e-02f,
  -8.86977650e-03f, -2.43677143e-02f, 2.82386187e-02f, 9.77610946e-02f, 3.23221013e-02f, 5.22361547e-02f, 6.43539876e-02f, -7.20074624e-02f, 1.91576574e-02f, -2.98806448e-02f,
  1.01862811e-01f, 6.22830093e-02f, 7.74445012e-02f, 9.16704535e-02f, 6.43207459e-03f, -6.03348296e-03f, 6.81834295e-02f, -3.83875445e-02f, 6.69551734e-03f, -2.68115643e-02f,
  -4.47927974e-02f, 9.75447670e-02f, 2.50348682e-03f, -6.65628612e-02f, -2.19589826e-02f, 2.48183403e-02f, 3.77102681e-02f, -8.51849690e-02f, 1.38290022e-02f, -1.30184963e-01f,
  -1.32663932e-03f, 2.62896009e-02f, -9.56946388e-02f, -7.04077631e-02f, -3.68999410e-03f, 1.20073641e-02f, 4.20232937e-02f, 8.41734633e-02f, 9.92216393e-02f, 1.52316308e-02f,
  4.68132906e-02f, -1.33045828e-02f, -4.72603254e-02f, -7.91533291e-02f, -1.89790614e-02f, -2.28589959e-03f, -2.59979609e-02f, 5.13622202e-02f, 9.75897629e-03f, -1.08559988e-01f,
  -1.40009701e-01f, 2.42075980e-01f, 7.09048584e-02f, -2.28174940e-01f, 1.07884720e-01f, 2.47856006e-01f, 2.09507868e-01f, -7.19297379e-02f, -1.13107629e-01f, 9.43032801e-02f,
  2.22810239e-01f, 1.36122741e-02f, -1.46926194e-01f, -2.07659975e-01f, -1.74057618e-01f, 3.08103580e-02f, -1.21315859e-01f, -1.50848746e-01f, -1.61612481e-01f, -1.05410665e-01f,
  -5.00953980e-02f, -1.15501143e-01f, -1.98732644e-01f, -1.71308592e-01f, -1.35764107e-01f, -1.36257410e-01f, -2.09750831e-02f, 1.66609604e-02f, 1.37581527e-01f, -6.85528442e-02f,
  7.96672255e-02f, 1.56221241e-01f, -1.56368032e-01f, -2.72006784e-02f, 4.40513492e-02f, -8.61607194e-02f, 1.05759829e-01f, -9.22413096e-02f, 5.91910556e-02f, 5.72601371e-02f,
  -1.17596062e-02f, 4.11549918e-02f, -7.03130960e-02f, -1.64898168e-02f, 3.58030647e-02f, -6.70313910e-02f, -1.06812701e-01f, -1.11607112e-01f, -6.37069461e-04f, 3.46193910e-02f,
  1.15451068e-01f, 8.18226188e-02f, 8.02256986e-02f, 3.28472350e-03f, -9.36928913e-02f, -6.73507527e-02f, 1.22113928e-01f, -1.02422431e-01f, -7.56852031e-02f, -3.46876606e-02f,
  4.73361015e-02f, 6.91853017e-02f, 2.60183252e-02f, -1.31808110e-02f, -7.11064488e-02f, 6.55233487e-03f, -7.66905323e-02f, -2.66005136e-02f, -1.28035247e-03f, 7.80220777e-02f,
  -9.36156604e-03f, 6.03772886e-02f, 1.64108351e-02f, 3.13589014e-02f, -5.84893227e-02f, -2.08654557e-03f, 4.16013319e-03f, -1.72976013e-02f, -3.00540440e-02f, 6.76958589e-04f,
  -5.28591461e-02f, -2.53509847e-03f, -3.67338769e-02f, -4.32688110e-02f, -5.03568612e-02f, -7.21306447e-03f, -2.50783022e-02f, 6.77605942e-02f, 6.83126375e-02f, 4.25301492e-02f,
  -1.87814683e-01f, 1.15265988e-01f, -9.01448056e-02f, -1.15535967e-01f, -3.57643105e-02f, -5.83780557e-02f, -2.24263351e-02f, -9.31835473e-02f, 1.30230319e-02f, -4.88281948e-03f,
  1.40862778e-01f, -4.45215553e-02f, -7.60112256e-02f, -7.09481090e-02f, -1.04370043e-01f, -3.48524973e-02f, -3.63153741e-02f, -9.87301841e-02f, -5.32219224e-02f, 1.45417091e-03f,
  -4.14921418e-02f, -1.53512076e-01f, -2.09624887e-01f, -1.28575578e-01f, -4.04126830e-02f, -1.98295474e-01f, -9.31164622e-02f, -1.68313354e-01f, -1.12814434e-01f, -2.71210253e-01f,
  -9.77277569e-03f, 1.10995419e-01f, 2.03828603e-01f, -3.02619915e-02f, 2.14977786e-01f, 3.20551574e-01f, 3.03885162e-01f, 2.04978764e-01f, -1.45005565e-02f, -1.75128281e-02f,
  9.84573457e-03f, -1.40977770e-01f, -1.35861143e-01f, -1.56854421e-01f, -9.08132177e-04f, 6.98669255e-02f, 8.16927291e-03f, -1.13957375e-01f, 3.90305072e-02f, 7.04450347e-03f,
  -2.71014660e-03f, -1.20488934e-01f, -1.19302526e-01f, -1.44042313e-01f, -8.73870999e-02f, -1.74540907e-01f, -6.04499690e-02f, 8.75228271e-02f, 9.52498466e-02f, -1.46101087e-01f,
  3.36919501e-02f, 1.48745567e-01f, -1.33435592e-01f, -1.74770281e-01f, -4.25583608e-02f, -4.05937396e-02f, -4.27667499e-02f, -7.73441121e-02f, 2.99118403e-02f, -5.49163260e-02f,
  -1.37137743e-02f, -6.89581707e-02f, -2.78087538e-02f, 8.46790522e-02f, -3.29394899e-02f, -3.51506062e-02f, 5.60243912e-02f, -9.85217243e-02f, -3.66175058e-03f, 1.13493420e-01f,
  2.42582001e-02f, 1.20978346e-02f, 5.14049530e-02f, 7.53554106e-02f, 1.39963096e-02f, -8.09069723e-02f, 3.09180021e-02f, 9.07486677e-02f, 3.38599123e-02f, -5.90597428e-02f,
  3.33951078e-02f, -1.04190521e-02f, -9.99406353e-02f, -4.55766954e-02f, 6.59202114e-02f, -5.41047081e-02f, -8.52952749e-02f, 3.70398201e-02f, 2.77708601e-02f, 2.92404313e-02f,
  7.25773349e-02f, 7.16247037e-02f, 9.37865973e-02f, -6.61142096e-02f, 3.00061260e-03f, 1.26235723e-01f, 1.67204835e-03f, -1.56353023e-02f, 1.28261223e-01f, 7.58683234e-02f,
  7.27537125e-02f, 3.18868682e-02f, -5.70886210e-03f, -2.35689972e-02f, 1.01100139e-01f, 5.83457090e-02f, 4.13137935e-02f, 2.89694816e-02f, -8.08167905e-02f, 7.80214369e-02f,
  -7.50040710e-02f, 1.30030409e-01f, -1.31843522e-01f, -9.88224298e-02f, 1.24401869e-02f, -6.97140172e-02f, -4.90141520e-03f, 1.31159928e-02f, 9.07603651e-02f, 5.48975319e-02f,
  3.44998091e-02f, 1.38857681e-02f, 1.19717166e-01f, 6.57302812e-02f, -1.57698765e-02f, -1.04868663e-02f, 1.64738763e-02f, -7.30458200e-02f, -1.04031540e-01f, 1.61939040e-02f,
  4.79699969e-02f, 5.26223071e-02f, 3.31616290e-02f, -4.76494767e-02f, 8.22021365e-02f, -2.02702545e-02f, -2.77836416e-02f, 7.11939931e-02f, -5.55848777e-02f, -9.58590358e-02f,
  7.92577416e-02f, 1.11887462e-01f, 5.09203449e-02f, -6.69718534e-02f, -1.10159039e-01f, -1.73789710e-02f, 4.07384820e-02f, 3.93389277e-02f, 3.09681427e-02f, -4.14282233e-02f,
  7.21022636e-02f, -1.53366085e-02f, -1.51449107e-02f, -5.13421856e-02f, 5.08269221e-02f, -5.05017191e-02f, 2.05862317e-02f, -1.26187384e-01f, -5.03343977e-02f, -1.04685605e-01f,
  -1.16036157e-03f, -8.08600336e-03f, 1.41332264e-03f, -4.15925309e-02f, -4.64268699e-02f, 3.97515707e-02f, 3.26937102e-02f, -5.95160313e-02f, -5.70750758e-02f, 4.50268202e-02f,
  -7.40045309e-02f, 3.07189468e-02f, -9.75713953e-02f, -1.08614169e-01f, -8.08690637e-02f, 6.38835281e-02f, 4.63519469e-02f, -4.43929024e-02f, -2.87371513e-04f, 6.32538795e-02f,
  2.21935194e-02f, 8.17767531e-02f, 7.26016657e-03f, -4.69730198e-02f, 4.45822515e-02f, 2.63006017e-02f, -2.06109453e-02f, -2.36149747e-02f, -4.36649434e-02f, 7.72234052e-02f,
  7.27383494e-02f, -4.05091420e-02f, 1.05388485e-01f, 9.94881690e-02f, 5.43156601e-02f, -1.03574589e-01f, 4.58914079e-02f, -4.62016128e-02f, 9.36166495e-02f, 1.89463571e-02f,
  2.29375027e-02f, -4.91338782e-02f, -4.55281399e-02f, -2.78736446e-02f, -8.65691900e-02f, 5.15467562e-02f, -8.06438774e-02f, -3.23114246e-02f, -9.30457041e-02f, -6.24312684e-02f,
  -7.57403746e-02f, 7.07080513e-02f, 5.12968414e-02f, 8.80364981e-03f, 5.06714284e-02f, -2.66755633e-02f, -5.95551431e-02f, 6.04557879e-02f, 3.31286378e-02f, 1.06281703e-02f,
  4.24935669e-02f, 6.00227097e-04f, 1.02730384e-02f, 3.43217812e-02f, -3.29043195e-02f, 7.60304481e-02f, -4.42583300e-02f, -4.67698164e-02f, -6.65090885e-03f, 5.58411069e-02f,
  2.27689836e-02f, -1.10169016e-01f, -1.49192773e-02f, -1.59634948e-02f, -7.78700560e-02f, 8.65477696e-02f, 1.75880622e-02f, 5.81126511e-02f, 6.22087494e-02f, 2.82631814e-02f,
  5.41885309e-02f, -8.19999129e-02f, -2.95057353e-02f, -6.59537837e-02f, 3.23085710e-02f, -5.60214259e-02f, -1.99046973e-02f, -6.61596134e-02f, 1.47870015e-02f, 7.65350536e-02f,
  9.96943489e-02f, 9.99089330e-02f, 3.37084979e-02f, 2.98499055e-02f, 9.13528726e-02f, -5.02571613e-02f, -1.03397116e-01f, -3.34222103e-03f, 5.04291058e-02f, -4.32368703e-02f,
  3.88597995e-02f, 1.67188998e-02f, -4.61246446e-02f, 8.45330209e-03f, -3.62235191e-03f, 9.50888172e-02f, 1.29160568e-01f, 9.66229960e-02f, -7.50160962e-02f, 8.94383639e-02f,
  -1.55193172e-02f, -7.91853368e-02f, 3.28315087e-02f, 3.53516452e-02f, -7.62140453e-02f, -2.88188290e-02f, -7.81295821e-02f, -5.48466705e-02f, 1.00616151e-02f, 4.87364903e-02f,
  -2.47178674e-02f, 2.13549137e-02f, -6.56269640e-02f, -1.19325258e-01f, -1.32747620e-01f, -1.09406315e-01f, -7.02258795e-02f, -1.23717144e-01f, -8.66509601e-02f, -1.44042760e-01f,
  2.49995235e-02f, 8.17565247e-02f, -4.07347940e-02f, 1.99805349e-02f, -6.31456524e-02f, -4.93555050e-03f, 4.64812368e-02f, 4.21364531e-02f, 5.89883439e-02f, 9.83307809e-02f,
  4.80263643e-02f, 5.50484359e-02f, 2.36948617e-02f, 4.58190180e-02f, 2.15476174e-02f, 1.33409146e-02f, 1.87566839e-02f, -8.76011178e-02f, -5.38029633e-02f, -2.77653672e-02f,
  8.79963040e-02f, 5.32020032e-02f, -7.41302967e-02f, -8.49484503e-02f, -3.10312752e-02f, -9.14447382e-02f, 8.21425766e-02f, -1.33287609e-02f, 6.63818642e-02f, -9.23545212e-02f,
  7.94399604e-02f, 9.76358447e-03f, 6.81432337e-03f, 9.46390778e-02f, 3.04293297e-02f, -7.06732273e-02f, -2.99496967e-02f, -1.60430335e-02f, 3.14739458e-02f, 3.12228110e-02f,
  7.60797784e-02f, 4.53264639e-02f, 2.25238744e-02f, 2.96338741e-02f, -1.08834378e-01f, -1.14971651e-02f, -6.99226409e-02f, -5.39081357e-03f, -8.15094262e-02f, -2.61006225e-02f,
  -5.57459220e-02f, -7.58583322e-02f, 2.17025895e-02f, -3.77131701e-02f, -3.67978625e-02f, 2.35396028e-02f, 1.20257819e-02f, 4.93899360e-02f, 1.18372272e-05f, 4.01815251e-02f,
  -9.29183885e-02f, -7.06293136e-02f, -2.67814770e-02f, 7.95044899e-02f, -1.02409922e-01f, -1.67969987e-02f, -2.07260400e-02f, 1.70563981e-02f, -3.20055080e-03f, -1.17696449e-02f,
  -3.11309732e-02f, -6.53383806e-02f, -3.90650071e-02f, -5.52090295e-02f, 4.79368605e-02f, 4.79396358e-02f, -3.90339387e-03f, 7.33307796e-03f, 4.32193130e-02f, -4.35687713e-02f,
  -6.76647248e-03f, -1.21756047e-01f, -2.06982959e-02f, -9.26013738e-02f, -5.27844466e-02f, -1.58844560e-01f, -1.33053124e-01f, 2.73232646e-02f, -7.97910169e-02f, -1.37733385e-01f,
  -2.18847975e-01f, -2.66243517e-01f, 2.11714745e-01f, -6.09480739e-02f, 2.75864620e-02f, 1.30665720e-01f, 1.58444628e-01f, -4.58807424e-02f, -9.31833535e-02f, -6.24022298e-02f,
  -2.01889277e-01f, -8.31167102e-02f, 2.09140265e-03f, -4.11239266e-02f, 5.74185029e-02f, 1.23865031e-01f, 2.44730823e-02f, 1.47715777e-01f, 1.95211604e-01f, 2.01373100e-02f,
  1.63760479e-03f, -2.56054830e-02f, -2.79799029e-02f, -3.73560637e-02f, -9.49083418e-02f, 8.27960670e-02f, -6.21412462e-03f, -6.02564849e-02f, -7.02323094e-02f, -4.55127517e-03f,
  3.35517287e-01f, -2.43061453e-01f, 1.49708271e-01f, -1.65276393e-01f, -5.86812757e-02f, 3.12564634e-02f, 4.34791148e-02f, 1.99993551e-02f, -7.18008131e-02f, 5.86315095e-02f,
  -1.00678481e-01f, -8.41235816e-02f, -8.45030881e-03f, 3.39415260e-02f, -3.00559755e-02f, 5.95344976e-02f, -1.37964711e-01f, -6.19990677e-02f, -1.65553406e-01f, -1.36648625e-01f,
  -6.80982620e-02f, -1.09373361e-01f, 1.01537183e-01f, 3.66399344e-03f, -1.27706677e-01f, 2.39121635e-02f, -3.17135863e-02f, -6.94858879e-02f, -3.92844975e-02f, -1.09865768e-02f,
  4.84264158e-02f, 5.93161844e-02f, -7.35826567e-02f, -3.64062898e-02f, 6.80424497e-02f, 1.08589754e-01f, -1.89779084e-02f, 8.77591968e-03f, -4.60016392e-02f, 6.46527410e-02f,
  -7.14489743e-02f, -3.08990087e-02f, 4.79923002e-02f, -5.68158515e-02f, 1.31696472e-02f, -1.58757959e-02f, -1.79976155e-03f, -5.38012758e-02f, 3.15205231e-02f, -3.75498571e-02f,
  -1.93179585e-02f, 7.36728385e-02f, 8.02918375e-02f, 7.86512420e-02f, 2.56787222e-02f, -1.41989822e-02f, 4.39708158e-02f, -8.35937560e-02f, -3.62612009e-02f, -6.76202625e-02f,
  1.63708016e-01f, -7.41835758e-02f, 9.16520953e-02f, -2.29714923e-02f, -2.70758383e-02f, -5.71087608e-03f, -6.52862340e-02f, 1.47323813e-02f, -6.08309396e-02f, 1.32511228e-01f,
  -7.16885850e-02f, -2.63845120e-02f, 5.59633933e-02f, -6.11828715e-02f, 1.77818567e-01f, 4.25401106e-02f, -9.15636048e-02f, 4.09640558e-02f, -6.62657479e-03f, -8.28194693e-02f,
  -1.25910223e-01f, 1.61999121e-01f, 3.22838247e-01f, 1.99379236e-01f, 1.01791680e-01f, 1.29778400e-01f, 1.90633640e-01f, 1.34307891e-01f, 1.78495884e-01f, 2.34346792e-01f,
  2.07226530e-01f, 2.32574176e-02f, -1.73776243e-02f, -4.26856652e-02f, -1.55690745e-01f, -9.47335064e-02f, -8.71423557e-02f, -2.55963895e-02f, -1.81239899e-02f, 2.47089639e-02f,
  -1.08838968e-01f, -8.52268115e-02f, 7.29630515e-02f, 7.70815387e-02f, -1.88432615e-02f, 1.06335983e-01f, 8.95078108e-02f, -4.18582000e-03f, -3.70862447e-02f, 3.10244169e-02f,
  -5.74575439e-02f, 1.55050270e-02f, -6.47841543e-02f, -1.34114409e-02f, -5.04618548e-02f, -2.42779423e-02f, 4.65088040e-02f, -5.28779672e-03f, -3.92462909e-02f, 1.08843565e-01f,
  -3.43063772e-02f, 1.04903817e-01f, 7.01581314e-02f, -6.13496378e-02f, -3.78785394e-02f, 6.92214444e-02f, -3.12909298e-02f, 7.09179342e-02f, -8.36018249e-02f, -1.39343776e-02f,
  -7.62145445e-02f, 1.33759435e-02f, 1.21639101e-02f, -1.05139494e-01f, -3.25332768e-02f, -3.45407203e-02f, -2.20040046e-02f, -3.43939476e-02f, 5.98437265e-02f, 8.03588480e-02f,
  1.70316193e-02f, -7.81945065e-02f, 5.26133515e-02f, 7.56672816e-03f, -3.00239101e-02f, -1.20910592e-02f, 4.98218611e-02f, -3.17049623e-02f, -3.35790142e-02f, -3.68257053e-02f,
  5.22420779e-02f, -3.06734014e-02f, -4.42799032e-02f, 2.92019919e-02f, 1.34405214e-02f, 6.04329221e-02f, -7.21283704e-02f, -4.13113460e-02f, 6.99346978e-03f, -9.20635983e-02f,
  -9.72419679e-02f, -3.04933009e-03f, 6.14945851e-02f, -7.92212412e-02f, -4.94951755e-02f, -1.07085798e-02f, 3.30750048e-02f, 3.70561075e-03f, -3.38016264e-03f, 3.45512405e-02f,
  7.86271691e-02f, 4.92616892e-02f, -8.01991075e-02f, -1.05985887e-01f, 1.95655972e-02f, -8.42650980e-02f, -3.20753865e-02f, -7.89504051e-02f, -1.18637286e-01f, -2.67664790e-02f,
  -1.00338168e-01f, 4.81775366e-02f, -8.26372951e-03f, 1.57734111e-01f, 2.25596735e-03f, -4.55883965e-02f, -3.23197283e-02f, 1.34426961e-02f, -6.84187189e-02f, 8.04356560e-02f,
  -4.74646054e-02f, -1.73622053e-02f, 1.25433914e-02f, 5.62020652e-02f, -1.52452448e-02f, -1.76747597e-03f, 5.44673242e-02f, 1.34223355e-02f, -1.27210245e-02f, -6.47202358e-02f,
  5.47571592e-02f, 3.95593680e-02f, -1.52171785e-02f, 1.10249892e-01f, -5.23051918e-02f, -4.12090085e-02f, 3.42694744e-02f, -7.43567720e-02f, 5.47484271e-02f, 8.30546618e-02f,
  6.80792928e-02f, 1.92111298e-01f, 7.23393932e-02f, 1.19942434e-01f, 1.09661140e-01f, 7.25480169e-02f, 1.76178202e-01f, 1.19167984e-01f, -6.39835149e-02f, -1.39684193e-02f,
  1.17371529e-02f, -2.51924638e-02f, -1.39781162e-01f, -8.98431242e-02f, 3.60327889e-03f, -8.15402437e-03f, -5.77070266e-02f, 1.58219840e-02f, -1.83012098e-01f, -3.48434411e-02f,
  9.84498188e-02f, 1.20545618e-01f, 9.02638137e-02f, -4.96789254e-03f, 9.76495892e-02f, -2.28335951e-02f, 2.26757750e-02f, 2.75808759e-03f, -4.32649106e-02f, 9.16056186e-02f,
  -9.41549689e-02f, 1.70770288e-01f, -1.36783510e-01f, -5.76595925e-02f, -2.82615121e-03f, 2.88621802e-02f, -5.25154285e-02f, -5.19631170e-02f, -3.56549285e-02f, -2.54085176e-02f,
  2.51640137e-02f, 6.83544113e-06f, 1.16281927e-01f, 4.45253216e-02f, 1.11314930e-01f, -7.46815139e-03f, -1.41807199e-02f, -1.35307163e-01f, -9.16808099e-02f, -2.57447995e-02f,
  8.41178522e-02f, 1.51621282e-01f, 1.50306821e-01f, 7.90410861e-03f, -5.85903451e-02f, -4.18657921e-02f, -3.26158083e-03f, -7.85670429e-02f, -3.38363163e-02f, -6.50012270e-02f,
  -1.50778651e-01f, -1.64510347e-02f, 6.58313408e-02f, -7.13130236e-02f, -1.30779594e-02f, 3.55193019e-02f, -8.07453319e-02f, -1.18959742e-02f, -2.32878439e-02f, 6.34246692e-02f,
  -2.93164700e-02f, -2.59939451e-02f, -8.37319437e-03f, -9.10462216e-02f, -4.85636927e-02f, 5.18083423e-02f, 7.19202608e-02f, 1.96693949e-02f, -7.52288029e-02f, -3.71425338e-02f,
  3.97446342e-02f, -8.60657617e-02f, -8.17190185e-02f, -6.92342371e-02f, -3.40893194e-02f, -8.19829777e-02f, -1.13522215e-02f, -9.18423012e-03f, -9.79941860e-02f, -2.89530288e-02f,
  -1.03757605e-01f, 4.38367110e-03f, -1.15492068e-01f, -8.21238905e-02f, 9.49547887e-02f, 2.37990171e-02f, 5.45237102e-02f, -6.12914972e-02f, -2.10546888e-03f, -5.57713071e-03f,
  -8.94846581e-03f, 4.93268184e-02f, 3.17278765e-02f, -4.77110408e-02f, -5.77918394e-03f, -6.53780773e-02f, -4.51729335e-02f, -8.40800181e-02f, -2.19940506e-02f, 1.02547720e-01f,
  2.20600963e-02f, 2.04155389e-02f, -6.05509430e-02f, -8.96974280e-02f, 1.64559972e-03f, -1.22437157e-01f, 7.58906603e-02f, 1.30189406e-02f, -7.63993412e-02f, 5.98453991e-02f,
  -3.62764001e-02f, -9.95659754e-02f, 1.03834763e-01f, -3.95641848e-02f, -9.94021073e-02f, -5.86512685e-02f, 1.05010144e-01f, -3.13212164e-02f, -1.22465506e-01f, -4.92806844e-02f,
  -8.24482962e-02f, -4.06016782e-02f, -2.25611720e-02f, -3.31204161e-02f, -2.88755372e-02f, -4.56129089e-02f, 2.16881167e-02f, -3.87333110e-02f, -6.39412254e-02f, 5.23536094e-02f,
  6.01978265e-02f, -4.25491259e-02f, -3.40100341e-02f, -3.42746340e-02f, 4.95266803e-02f, -6.88621029e-02f, -3.93136367e-02f, 1.38425594e-02f, -7.52813444e-02f, 6.69475552e-03f,
  2.53374815e-01f, -5.96061982e-02f, -1.03701930e-02f, -3.28687616e-02f, -5.53105734e-02f, -4.81110513e-02f, -2.70698313e-02f, -1.14696408e-02f, 2.92396490e-02f, 4.74733189e-02f,
  -8.61555412e-02f, -6.70478567e-02f, -7.11334199e-02f, -2.19830181e-02f, 9.89698991e-02f, 4.89000157e-02f, -1.05267197e-01f, -8.75629112e-02f, -9.20756534e-02f, -3.51955779e-02f,
  -1.04602640e-02f, -3.60262394e-02f, -9.04931128e-02f, -7.26651698e-02f, -6.31141067e-02f, 2.76258197e-02f, 5.19454256e-02f, 8.24572612e-03f, -1.27854496e-01f, 7.94672146e-02f,
  -2.87207831e-02f, 4.47538570e-02f, 1.30698623e-04f, 3.09000933e-03f, 9.08302551e-04f, -6.99185506e-02f, 7.50536248e-02f, 4.05923165e-02f, -6.41228333e-02f, 6.57779202e-02f,
  2.94141676e-02f, 5.36220036e-02f, 1.38721624e-02f, 1.09740190e-01f, -5.22834137e-02f, 5.51146902e-02f, -6.63844794e-02f, -4.70053703e-02f, -8.20439234e-02f, -9.46196262e-03f,
  -1.08329076e-02f, -4.83932346e-02f, -1.34213055e-02f, 6.03219755e-02f, -1.10856935e-01f, -1.01975463e-01f, -7.15859607e-02f, -6.25268072e-02f, -1.33567536e-02f, -3.62201035e-02f,
  1.33075863e-01f, -4.62969653e-02f, 1.71759054e-02f, -1.01707116e-01f, -9.36812721e-03f, -8.21750015e-02f, 7.20147714e-02f, 2.18847413e-02f, -7.57280961e-02f, 3.93484399e-04f,
  -6.29924908e-02f, -8.80315527e-02f, -4.81970012e-02f, -5.04081808e-02f, 5.52379005e-02f, 8.98458883e-02f, 6.78022206e-02f, 1.03392243e-01f, 2.11360678e-02f, 8.68368614e-03f,
  -5.08062802e-02f, 1.56973768e-02f, 1.41089007e-01f, 8.88348222e-02f, -8.00034180e-02f, 3.67393233e-02f, 1.65685758e-01f, 7.46675506e-02f, 1.42257214e-01f, 2.46486500e-01f,
  -1.03258770e-02f, 7.34530091e-02f, 1.10068992e-02f, -8.24196935e-02f, 5.84202856e-02f, -6.86701983e-02f, -7.27455784e-03f, 9.82694030e-02f, 9.95699167e-02f, 8.66656750e-02f,
  -9.84456390e-03f, 2.55673714e-02f, -4.42726836e-02f, -1.04564019e-02f, -1.27254026e-02f, -3.85667123e-02f, 4.25733328e-02f, -1.08451717e-01f, -1.34180278e-01f, -5.81728406e-02f,
  -3.25715654e-02f, -5.28566912e-03f, -8.08215886e-02f, -6.74095526e-02f, -4.00621518e-02f, -1.39725266e-03f, 5.32608256e-02f, -8.27434778e-05f, 2.75817290e-02f, -6.85449392e-02f,
  1.02411635e-01f, 6.79070652e-02f, -8.21870789e-02f, 7.41071850e-02f, 3.07359304e-02f, 8.87751505e-02f, -6.95668394e-03f, 1.19517490e-01f, 8.21223632e-02f, 4.09014784e-02f,
  2.34631859e-02f, 7.26542771e-02f, 8.65627527e-02f, 3.90744209e-02f, -3.98234539e-02f, -3.26921977e-02f, -3.61107104e-02f, -4.41231616e-02f, 8.42956603e-02f, 2.71844910e-03f,
  1.22837335e-01f, 1.28408493e-02f, 5.18225059e-02f, 3.78699005e-02f, -1.79815374e-03f, -2.58493088e-02f, 9.99474227e-02f, 9.94623080e-02f, 8.36473107e-02f, 1.08209820e-02f,
  -7.77127668e-02f, 3.39795202e-02f, 3.30196619e-02f, -6.54886439e-02f, -4.23402898e-02f, -1.56617593e-02f, -3.71372141e-02f, -8.91243517e-02f, -9.03185531e-02f, -4.33249250e-02f,
  -1.97245926e-02f, -3.49409692e-02f, -8.99770483e-02f, -8.73238221e-02f, 2.10920740e-02f, -6.58559427e-02f, -2.38315836e-02f, 4.30613868e-02f, 3.35121527e-02f, 5.25118038e-02f,
  4.40528803e-02f, 8.01060274e-02f, -3.99070121e-02f, -1.94985699e-02f, -7.07961544e-02f, -1.92072783e-02f, 1.24083012e-02f, 2.76360707e-03f, 4.02373187e-02f, 6.06305599e-02f,
  9.13588703e-02f, -8.72040614e-02f, -2.37446129e-02f, -4.96252663e-02f, 7.52029801e-03f, 3.46441269e-02f, 9.85083133e-02f, -1.30814100e-02f, 1.02435723e-01f, 9.17791352e-02f,
  6.56568957e-03f, 3.67228761e-02f, 4.04587053e-02f, 7.26250485e-02f, 3.46236043e-02f, 5.17707467e-02f, 7.26791248e-02f, 9.85106230e-02f, -3.62303890e-02f, 5.38282879e-02f,
  1.34553596e-01f, -4.44947183e-02f, -6.39071986e-02f, 1.09653093e-01f, 1.88400527e-03f, 2.27989033e-02f, 3.50314267e-02f, -2.20134761e-02f, -4.86926883e-02f, 8.78186375e-02f,
  -4.54001933e-01f, 8.71233568e-02f, 1.29315689e-01f, -3.15599769e-01f, -6.83082566e-02f, 1.48707211e-01f, 2.20674872e-01f, -6.48578182e-02f, -2.19575390e-01f, 4.98761423e-02f,
  -1.22687165e-02f, -4.02763337e-02f, 4.03840281e-02f, 2.14958079e-02f, 4.81928661e-02f, 1.30622881e-02f, -9.45111737e-02f, -1.18281413e-02f, 2.99381595e-02f, -7.29086101e-02f,
  -8.75224918e-02f, -2.69062847e-01f, -2.11611837e-01f, -1.50543064e-01f, -1.27300173e-01f, -8.56444314e-02f, -8.12998638e-02f, -4.34998348e-02f, 7.07376748e-02f, -8.42318535e-02f,
  3.06275100e-01f, -2.23028198e-01f, 3.38674616e-03f, -1.22576088e-01f, -6.32327721e-02f, -3.86856459e-02f, -4.59001809e-02f, -9.28677544e-02f, 2.28055026e-02f, 1.60810351e-02f,
  2.95020342e-02f, -8.91517624e-02f, -1.09541463e-02f, -1.40763381e-02f, -6.15291446e-02f, -6.91493154e-02f, -6.33380339e-02f, -1.25856131e-01f, -7.35705942e-02f, 3.79679725e-02f,
  1.05310321e-01f, -2.59227748e-03f, 1.10282898e-01f, 5.94676062e-02f, -4.89577912e-02f, -1.28971506e-02f, 9.93285850e-02f, 3.47804874e-02f, 6.68267757e-02f, -5.79213612e-02f,
  7.91121572e-02f, -6.23279288e-02f, -2.82480177e-02f, -1.29644442e-02f, 4.52904850e-02f, -4.99623679e-02f, -5.94159663e-02f, -3.60426679e-02f, -2.28270572e-02f, 8.03006440e-03f,
  -4.42083813e-02f, 2.85713486e-02f, -5.90303168e-02f, -7.04440400e-02f, 5.13502434e-02f, -4.68982458e-02f, -4.43334840e-02f, 1.15498286e-02f, -1.50137926e-02f, -1.01878189e-01f,
  -1.75563302e-02f, 4.83079217e-02f, -4.55597378e-02f, 5.91504062e-03f, 3.38299125e-02f, -6.02680258e-02f, 2.29589595e-03f, 8.01515728e-02f, 1.07468069e-02f, -4.08942178e-02f,
  8.51271022e-03f, -6.16664514e-02f, -4.97084521e-02f, -8.72847363e-02f, 4.05871719e-02f, -1.15184914e-02f, -8.61736014e-03f, -4.66552563e-02f, -4.72568832e-02f, 1.14745311e-01f,
  7.37872198e-02f, 4.96015027e-02f, -4.83113118e-02f, 9.60198417e-02f, 2.05981848e-03f, 6.95656762e-02f, 8.54701921e-02f, -1.09677827e-02f, -1.66786276e-02f, 4.83742468e-02f,
  4.75289188e-02f, -4.82821837e-02f, 2.73937751e-02f, 4.04385217e-02f, 1.21164098e-02f, -2.64395792e-02f, 8.73966143e-02f, 1.70996323e-01f, 1.41616896e-01f, -1.54080028e-02f,
  6.44404665e-02f, -6.46288544e-02f, -4.77515198e-02f, -1.02690635e-02f, 5.35724014e-02f, 1.45779982e-01f, -8.04116204e-03f, 6.69243466e-03f, 7.45058954e-02f, -5.77947311e-02f,
  5.07790819e-02f, -2.81272568e-02f, 1.12085938e-01f, 3.74167413e-02f, 7.06511065e-02f, 4.82084304e-02f, -3.93784307e-02f, -2.35690754e-02f, 1.26911715e-01f, 2.91361120e-02f,
  -4.20692414e-02f, -1.04539506e-01f, 1.76751930e-02f, -8.56835209e-03f, -1.32670864e-01f, -5.73023148e-02f, -1.81558747e-02f, -4.60837781e-02f, -2.11200230e-02f, -1.18757486e-01f,
  7.11940750e-02f, 2.53271498e-02f, 6.31172433e-02f, 3.66824679e-02f, -6.17402829e-02f, -8.65240991e-02f, 1.26203634e-02f, 1.40293492e-02f, -4.50846255e-02f, -1.82671919e-02f,
  5.51242195e-02f, -1.83813628e-02f, -6.15543984e-02f, -1.07772402e-01f, 4.30049710e-02f, -6.19411319e-02f, -1.17627889e-01f, -1.60925128e-02f, 7.93269798e-02f, 1.82965875e-03f,
  -1.49429170e-02f, 1.00199111e-01f, 1.18071876e-01f, 3.36357057e-02f, 2.18019355e-02f, 2.06325520e-02f, -7.94621836e-03f, -3.62750725e-03f, 8.52337629e-02f, 6.14591949e-02f,
  1.64846554e-02f, -7.55248079e-03f, 5.12843113e-03f, 1.06425829e-01f, 1.05173334e-01f, 2.75158230e-02f, -7.79213337e-03f, 7.97596499e-02f, 9.24034864e-02f, 6.13452718e-02f,
  2.78720595e-02f, -5.51730320e-02f, 7.42567480e-02f, -4.00106795e-02f, -1.54230092e-02f, 4.57513258e-02f, -9.37855244e-02f, -9.57208276e-02f, -8.30778852e-03f, -6.48900270e-02f,
  -2.05896124e-02f, -9.68462322e-03f, 2.48745997e-02f, 5.75231835e-02f, -1.97565239e-02f, -7.34511167e-02f, 9.51411575e-02f, -8.07668939e-02f, 5.48692681e-02f, 1.47133581e-02f,
  -1.33541441e-02f, 8.77852738e-02f, -1.65700056e-02f, 5.94462566e-02f, -9.60715488e-02f, -1.07703596e-01f, 4.85383766e-03f, -1.16061285e-01f, 3.48880352e-03f, 7.01840594e-02f,
  -8.46611857e-02f, -1.33789424e-02f, -1.17832432e-02f, 2.45683379e-02f, -4.30076905e-02f, 1.44801093e-02f, 3.40207741e-02f, -5.35280071e-02f, 9.66904014e-02f, -6.12839824e-04f,
  4.40428965e-02f, 1.02105618e-01f, 2.32732780e-02f, 7.46268108e-02f, -1.29717859e-02f, 1.67300552e-01f, 9.20693129e-02f, -5.96702620e-02f, 1.31567076e-01f, 9.36029851e-02f,
  7.26888552e-02f, -9.32614505e-02f, -1.80322118e-02f, 3.76642682e-02f, 7.00238273e-02f, -2.97873635e-02f, -1.26977473e-01f, -5.44836931e-02f, 4.02281880e-02f, 1.80487428e-02f,
  -4.33673821e-02f, 1.20753348e-01f, -8.19346309e-03f, 1.34541720e-01f, 3.92720550e-02f, 9.15845260e-02f, 4.04286906e-02f, 3.06217112e-02f, 4.83982190e-02f, 7.88596347e-02f,
  -2.85595041e-02f, -3.88858654e-02f, 7.89993033e-02f, -1.36892134e-02f, -4.11836356e-02f, 8.73403475e-02f, -3.95642146e-02f, -6.99041933e-02f, -9.71288309e-02f, -4.33152243e-02f,
  9.04934406e-02f, -7.55074341e-03f, 6.16405196e-02f, 8.06068629e-02f, -9.74087864e-02f, 4.29525115e-02f, -8.23061820e-03f, 6.05389029e-02f, -1.03668168e-01f, 2.91473861e-03f,
  3.47586125e-02f, -9.40839201e-02f, 7.06822500e-02f, -1.16496392e-01f, -1.73124287e-03f, -7.14887679e-02f, -1.59111992e-03f, -2.04970278e-02f, 8.32026526e-02f, 4.45207432e-02f,
  -4.49545495e-02f, -4.47817612e-03f, 5.18547706e-02f, 4.49467264e-02f, 1.99394729e-02f, 1.29195873e-03f, 8.61170068e-02f, 8.30621421e-02f, 4.02311012e-02f, -4.11531180e-02f,
  8.27763230e-02f, 3.31275463e-02f, -3.65407988e-02f, 9.81045607e-03f, -6.83500692e-02f, 5.61118312e-03f, 2.63992157e-02f, -7.06135780e-02f, 5.51198944e-02f, 5.20212715e-03f,
  3.25587876e-02f, -3.80088924e-03f, -9.28901434e-02f, -4.54333201e-02f, -3.10228672e-02f, -1.55226188e-02f, 4.22352972e-03f, -8.20744187e-02f, -1.14780897e-02f, -9.38501731e-02f,
  5.30991405e-02f, -6.15552738e-02f, 5.11875376e-02f, 5.64182587e-02f, -4.33511846e-02f, 5.64243533e-02f, 2.36805379e-02f, -7.40923509e-02f, -4.75744717e-02f, 4.43797670e-02f,
  2.48067938e-02f, 1.60741240e-01f, 6.96167871e-02f, 1.12157047e-01f, 4.31634150e-02f, 4.51373123e-02f, -1.35994405e-02f, -6.37233257e-02f, -6.39270395e-02f, 5.36056794e-02f,
  -7.72250146e-02f, 1.12027727e-01f, 8.58974680e-02f, -6.77669495e-02f, 4.07093428e-02f, -1.52451815e-02f, -2.61783637e-02f, -6.12629717e-03f, 3.71650356e-04f, 3.30069438e-02f,
  -1.05787115e-02f, 9.11620408e-02f, 1.28315061e-01f, 2.02490482e-02f, 2.51820986e-03f, 2.22239092e-01f, 2.29304489e-02f, -2.02498585e-02f, 8.47486779e-02f, 7.10452497e-02f,
  2.74767041e-01f, 3.26866210e-02f, -3.86063308e-02f, 1.03894278e-01f, 8.61473307e-02f, 4.35886458e-02f, 1.04918182e-01f, -3.49130295e-03f, 7.31862038e-02f, -7.13786401e-04f,
  1.08668417e-01f, 2.83190422e-02f, 7.18629882e-02f, 1.40714655e-02f, -2.72204280e-02f, 6.07875064e-02f, -5.05437423e-03f, 7.25024641e-02f, -4.41725664e-02f, 1.36530146e-01f,
  7.19747692e-02f, 9.68105942e-02f, 1.34966046e-01f, 1.13482021e-01f, 6.66179657e-02f, -4.60531749e-02f, 5.81202209e-02f, 4.38021421e-02f, 6.90129250e-02f, 4.79054451e-02f,
  -1.48025081e-02f, 1.22241490e-01f, -9.60720703e-02f, 5.30929230e-02f, 4.49656136e-02f, -8.49265531e-02f, -7.64960423e-02f, 5.79982139e-02f, 5.44700734e-02f, 2.78290305e-02f,
  -8.27210024e-02f, 7.97547996e-02f, -7.33172223e-02f, 3.41707915e-02f, 5.37552200e-02f, 2.71269009e-02f, 7.91075751e-02f, 1.64215025e-02f, -4.11510989e-02f, -4.34821397e-02f,
  -6.46842569e-02f, 1.47701092e-02f, 4.65713441e-02f, -2.81424820e-02f, -3.32869105e-02f, -5.05647324e-02f, -6.30573779e-02f, 5.97962774e-02f, -3.03036422e-02f, 1.12997800e-01f,
  1.08239524e-01f, -4.92357370e-03f, -4.61819023e-02f, 3.02946474e-02f, -3.39660048e-02f, 3.65455970e-02f, 1.19816307e-02f, 3.50195132e-02f, 7.74156004e-02f, 1.88928060e-02f,
  3.17926481e-02f, 8.25754702e-02f, 8.28091130e-02f, 1.19787961e-01f, -2.71668062e-02f, 4.80745286e-02f, 4.96807359e-02f, -5.23896813e-02f, -1.45086087e-02f, 8.16040859e-02f,
  2.91878674e-02f, 1.11235715e-01f, -5.33248624e-03f, 5.72485104e-03f, 5.16484212e-03f, 2.83141248e-02f, 4.27063331e-02f, 1.04069121e-01f, 1.53057918e-01f, 1.55452877e-01f,
  4.41043638e-02f, 8.47764313e-02f, 8.26000720e-02f, -8.64678398e-02f, -7.02143461e-02f, 3.27517204e-02f, 5.00029661e-02f, -4.87342924e-02f, -1.38804644e-01f, -2.65905522e-02f,
  -7.17493594e-02f, -8.86059776e-02f, 2.68019959e-02f, -6.45158812e-02f, 4.50420752e-03f, -1.75177678e-03f, 3.81411687e-02f, -6.61149323e-02f, -6.95797428e-02f, -9.40357670e-02f,
  -7.91298300e-02f, 5.59145957e-02f, 6.13497421e-02f, 5.06058335e-02f, -4.58887815e-02f, 1.60153881e-02f, -6.27399832e-02f, -1.76044889e-02f, -7.26512149e-02f, -2.73413700e-03f,
  5.82006723e-02f, -2.56120235e-01f, -2.65378624e-01f, -3.26048769e-02f, -5.25313057e-02f, 5.16544618e-02f, -2.28441991e-02f, 1.07291214e-01f, 2.84332931e-02f, -4.10484448e-02f,
  1.03267431e-01f, 9.85974818e-02f, 1.71885356e-01f, 6.60376027e-02f, 5.09880185e-02f, -5.64688258e-02f, -1.72640949e-01f, 1.00700654e-01f, 6.28441125e-02f, 1.13052748e-01f,
  3.16977836e-02f, -7.85053223e-02f, 5.96256405e-02f, 2.24860124e-02f, -8.14206451e-02f, 2.73091570e-02f, -8.80017579e-02f, -8.27580169e-02f, -5.48506863e-02f, -2.01183036e-01f,
  -5.09610884e-02f, 4.86005209e-02f, 5.34635708e-02f, 1.71043694e-01f, -1.13998540e-01f, 7.55997002e-02f, -1.28574474e-02f, -7.10534379e-02f, 1.10162333e-01f, -9.60862190e-02f,
  -1.23341102e-03f, -2.74830349e-02f, 5.57459407e-02f, -7.34153092e-02f, -2.43525356e-02f, 2.58751027e-02f, -1.15505405e-01f, 3.29446048e-02f, 3.62622477e-02f, -8.91178325e-02f,
  -6.32014796e-02f, -9.59729552e-02f, 5.21313921e-02f, 7.34918471e-03f, -3.49880867e-02f, 9.08883214e-02f, -5.13978750e-02f, 4.51887995e-02f, 5.57322130e-02f, -6.05178364e-02f,
  -3.96911390e-02f, -8.56442228e-02f, -1.79050025e-02f, 2.97629461e-02f, 1.17959946e-01f, -2.11722162e-02f, 1.34123117e-02f, -2.77571622e-02f, 2.60643084e-02f, -1.24514028e-02f,
  -3.15938592e-02f, -3.69350240e-02f, 1.00709118e-01f, 2.41053011e-03f, -2.12624054e-02f, 5.51535450e-02f, -6.97299689e-02f, 5.77353686e-02f, 6.72924146e-02f, -4.05738428e-02f,
  8.57063010e-02f, 3.19726914e-02f, -4.79051936e-03f, -7.03026205e-02f, 1.53063936e-02f, -4.95762601e-02f, -1.29621755e-02f, -2.54110768e-02f, -3.32557485e-02f, -6.98282868e-02f,
  6.42202646e-02f, 8.54407251e-02f, -2.84834369e-03f, 1.19947724e-01f, 5.91030382e-02f, -3.66713218e-02f, -1.69361867e-02f, 5.21129407e-02f, 9.77495462e-02f, -1.03299124e-02f,
  3.77972028e-03f, -4.02278192e-02f, -6.38281256e-02f, 3.66550088e-02f, 7.30645880e-02f, 1.12221204e-01f, 3.79541069e-02f, -3.80748883e-02f, 1.06175840e-01f, -5.86972311e-02f,
  -5.27186729e-02f, -3.29757631e-02f, 8.64918828e-02f, -3.18530127e-02f, -1.93833783e-02f, 1.32046774e-01f, -2.75859740e-02f, -7.22452700e-02f, -7.04707429e-02f, -1.62347436e-01f,
  -2.70153224e-01f, -8.86580944e-02f, -1.08850919e-01f, 9.29966122e-02f, 1.47449657e-01f, 6.39980808e-02f, 4.28399518e-02f, -7.81125724e-02f, 1.07353523e-01f, 8.86654556e-02f,
  7.22917244e-02f, 1.30134627e-01f, 7.58852065e-02f, -5.48977926e-02f, -8.08683634e-02f, -2.64036022e-02f, 1.79883212e-01f, 3.63640301e-02f, -5.82251139e-02f, -5.98574197e-03f,
  1.80224299e-01f, 8.95439684e-02f, -1.49145260e-01f, -4.82873805e-02f, 1.34331867e-01f, 1.27013892e-01f, 3.41399163e-02f, -3.54120843e-02f, 2.42231414e-02f, 1.97813451e-01f,
  -1.04390597e-02f, -1.51029855e-01f, -1.98985785e-02f, 9.20804963e-02f, 8.68643597e-02f, -1.10689171e-01f, -7.54995272e-02f, -9.08254534e-02f, -6.68893456e-02f, -3.59200984e-02f,
  7.59088621e-02f, -9.74904746e-02f, -3.10693812e-02f, -5.97922038e-03f, -6.35491237e-02f, -6.98273927e-02f, -1.55887485e-01f, -4.39871587e-02f, -1.22950017e-01f, -1.48552656e-01f,
  1.26581624e-01f, 5.18764593e-02f, -6.75268471e-02f, -1.32379740e-01f, -4.03612107e-02f, -1.59494393e-02f, -9.14964974e-02f, -8.86623040e-02f, -1.01448476e-01f, -1.70386076e-01f,
  5.02101257e-02f, -3.55937373e-04f, -1.79320388e-02f, -9.94469225e-02f, 1.12601165e-02f, 1.48852728e-02f, 1.29615724e-01f, 2.48057283e-02f, -3.85594741e-02f, -5.03028603e-03f,
  1.04078911e-01f, -2.52694432e-02f, -5.43274544e-02f, 1.11421738e-02f, -5.35765179e-02f, 5.62456064e-02f, -5.77442944e-02f, -2.46521402e-02f, 3.56098590e-03f, -1.11894328e-02f,
  -1.04032112e-02f, 5.00131808e-02f, 1.42242480e-02f, -7.67841116e-02f, 4.50989977e-02f, 3.35429213e-03f, -1.48897376e-02f, -7.49254972e-02f, -7.37656951e-02f, -2.31958814e-02f,
  -2.50643399e-02f, 3.35191712e-02f, -8.15142915e-02f, -3.92478816e-02f, 4.34308313e-02f, 4.32272777e-02f, -1.80015657e-02f, 6.73253834e-02f, -5.32556092e-03f, -1.49960415e-02f,
  -4.25609015e-02f, -1.09214455e-01f, 5.14798565e-03f, -7.62184411e-02f, 1.44312922e-02f, -9.50786918e-02f, -4.04757187e-02f, 3.82192917e-02f, -7.26338699e-02f, 1.95572134e-02f,
  -4.07085828e-02f, -5.65875471e-02f, -1.65597558e-01f, 5.38598699e-03f, -2.25345511e-03f, 4.24489193e-02f, -3.52728702e-02f, 2.79599950e-02f, -1.90118432e-01f, -1.79270089e-01f,
  -3.48326676e-02f, 6.73591346e-02f, 1.41403615e-01f, -6.67337924e-02f, 9.04492103e-03f, 2.13494487e-02f, 2.00196579e-02f, -5.47057192e-04f, -7.22637922e-02f, 9.89863500e-02f,
  1.78706441e-02f, -7.96099454e-02f, 1.94770601e-02f, 4.18108851e-02f, 1.82898864e-02f, -3.00576631e-03f, 7.05232620e-02f, 1.14730783e-01f, 2.15674229e-02f, 8.57161507e-02f,
  5.24848215e-02f, -1.69222094e-02f, -1.81274212e-04f, 5.10094203e-02f, 1.61081422e-02f, 7.07447380e-02f, -1.71445087e-02f, 9.03829783e-02f, 8.86781961e-02f, 9.54442546e-02f,
  2.31066227e-01f, -1.50687903e-01f, 2.59777959e-02f, -8.50434825e-02f, -1.61272977e-02f, -1.67937558e-02f, -1.00107985e-02f, -3.86610888e-02f, 3.90108116e-02f, 5.19863702e-02f,
  -6.28228858e-02f, -4.18780260e-02f, 7.63220363e-04f, 7.18437210e-02f, 6.39448464e-02f, 3.36616747e-02f, -7.43204728e-02f, 4.81313141e-03f, 2.24516485e-02f, -2.05849633e-02f,
  -3.27304080e-02f, -4.97349054e-02f, 3.23465141e-03f, -8.16440061e-02f, 5.22500463e-03f, -3.95124927e-02f, 2.00662995e-03f, -1.07605092e-01f, -1.03195295e-01f, 1.04956411e-01f,
  6.01845002e-03f, -1.18079640e-01f, 3.19776647e-02f, -5.20443954e-02f, -8.03757980e-02f, -2.83094998e-02f, -2.09939033e-02f, -2.02729832e-02f, 1.49929691e-02f, 5.69924489e-02f,
  5.35420552e-02f, 4.43188101e-03f, 1.06101811e-01f, 9.69787613e-02f, -8.10374245e-02f, 1.33445440e-03f, -1.57456025e-02f, -1.29718864e-02f, -3.80133130e-02f, -7.27021992e-02f,
  -5.80147654e-02f, 4.16674614e-02f, 2.40687653e-02f, -5.13826460e-02f, 6.78400099e-02f, 2.38001086e-02f, 6.17928505e-02f, 2.50878115e-03f, 3.45744900e-02f, 8.24138522e-02f,
  1.90768823e-01f, -4.53736596e-02f, 1.20814359e-02f, 2.82792412e-02f, 8.30415189e-02f, -3.52243185e-02f, -5.21297380e-02f, 2.98720393e-02f, -7.80593157e-02f, -1.01582212e-02f,
  -7.12963492e-02f, 1.23052550e-02f, -2.39086095e-02f, 4.85605113e-02f, 4.80561033e-02f, -4.10185568e-02f, 2.03301912e-04f, -5.14921285e-02f, 3.66788618e-02f, 1.24627659e-02f,
  6.55596852e-02f, 9.33182053e-03f, 3.04111876e-02f, 9.25565585e-02f, 2.67913379e-02f, -8.69345572e-03f, 4.96512130e-02f, 1.10184036e-01f, 8.66927058e-02f, 1.20550267e-01f,
  4.16386761e-02f, 6.39465079e-02f, 1.71243970e-03f, 1.42793238e-01f, 3.59291993e-02f, 1.27662361e-01f, 4.13708948e-02f, -6.17429018e-02f, 2.55803000e-02f, 9.05667543e-02f,
  -7.96076581e-02f, -6.69261217e-02f, -1.12466130e-03f, -3.41481008e-02f, -5.66971712e-02f, -1.61858052e-02f, 1.05117179e-01f, -4.23412472e-02f, 1.70319919e-02f, 1.02865376e-01f,
  2.92324759e-02f, 1.32259056e-02f, -4.23264503e-02f, -5.01273945e-02f, 3.20307501e-02f, 3.79410423e-02f, 3.34529430e-02f, 1.36679318e-02f, -1.83316041e-02f, 8.21182504e-02f,
  -1.32732287e-01f, 1.64923724e-02f, -2.21488774e-02f, 7.22523630e-02f, 5.78965135e-02f, 5.94567843e-02f, -3.55574451e-02f, 4.61748503e-02f, -3.94156128e-02f, -3.97943938e-03f,
  -3.92061360e-02f, -5.37877865e-02f, -7.88740665e-02f, -2.01977454e-02f, -8.15939307e-02f, -1.35404216e-02f, 4.18533795e-02f, -8.44234973e-02f, 2.98994165e-02f, -5.01779728e-02f,
  -4.10515256e-02f, 8.41710642e-02f, 1.09732300e-02f, -3.37354578e-02f, -7.17091039e-02f, 3.53980623e-02f, -9.42540690e-02f, 1.08691724e-03f, -2.56516389e-03f, 7.52077624e-02f,
  -1.40872225e-02f, -6.24587238e-02f, 1.83966365e-02f, 4.89992127e-02f, 5.01286685e-02f, 2.19236761e-02f, -8.49523246e-02f, 1.61076859e-02f, 7.56162852e-02f, 1.97709557e-02f,
  -9.62521359e-02f, -4.82721440e-02f, 4.97643650e-02f, -7.87622780e-02f, -4.00247760e-02f, 5.27333170e-02f, 4.09279726e-02f, -5.31804375e-02f, 5.29836491e-02f, 5.83686344e-02f,
  -1.77423079e-02f, -3.18874307e-02f, -1.06802672e-01f, -6.37203977e-02f, -1.03790775e-01f, 5.58818579e-02f, 1.81552414e-02f, -5.14417514e-02f, -2.22174451e-02f, -6.60526156e-02f,
  1.91543065e-02f, -1.14569291e-01f, 1.09782204e-01f, 4.14201915e-02f, -3.47354077e-02f, -8.27642381e-02f, 7.00622052e-02f, -7.30438754e-02f, 2.43730638e-02f, 7.93918818e-02f,
  7.58918300e-02f, -4.97903153e-02f, -3.47652175e-02f, 1.06565515e-03f, -2.11312026e-02f, -7.05509111e-02f, -7.87893981e-02f, 5.95179275e-02f, -6.76476676e-03f, -6.76551834e-02f,
  -3.27774137e-02f, 1.22733444e-01f, 6.51997551e-02f, 8.33559111e-02f, 9.16665643e-02f, 1.24102412e-02f, -5.20885363e-02f, -5.70364110e-02f, 5.47069386e-02f, -3.53945382e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  6.74207732e-02f, 2.45646566e-01f, 9.41116512e-02f, 1.80653989e-01f, 1.17676377e-01f, -6.42235950e-03f, 1.67257488e-01f, 1.28268868e-01f, 1.70647532e-01f, 2.37839341e-01f,
  1.39508918e-01f, 3.33300889e-01f, 1.86226964e-01f, 8.99443924e-02f, -6.26839548e-02f, 1.25603557e-01f, 1.03474826e-01f, 1.84278145e-01f, -3.03758383e-02f, 1.43357620e-01f,
  1.96926653e-01f, 9.51116383e-02f, 5.25408573e-02f, 1.64702490e-01f, 2.83228401e-02f, 1.41280740e-01f, 1.13659866e-01f, 1.85939029e-01f, 2.13202864e-01f, 1.76820040e-01f,
  4.22283784e-02f, 4.05209847e-02f, 1.96520001e-01f, 1.42187014e-01f, 1.20698951e-01f, 2.10569441e-01f, 1.91029802e-01f, 2.14564223e-02f, 7.26687610e-02f, 2.78628796e-01f,
  -3.57238855e-03f, 2.16192767e-01f, 1.23217881e-01f, -4.60974203e-04f, 2.00958297e-01f, 6.54341578e-02f, 1.01376183e-01f, 7.79800303e-03f, 1.05897464e-01f, 1.08260559e-02f,
  1.63945436e-01f, -1.59920435e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.04928704e-02f, -4.87635732e-02f, 1.46638423e-01f, -2.16728911e-01f, -7.91747794e-02f, -1.27095997e-01f, -2.92378347e-02f, -1.34026006e-01f, -3.45634073e-01f, -1.71561703e-01f,
  1.38044795e-02f, -1.59443527e-01f, -3.72873060e-02f, -1.46254227e-01f, 4.89040986e-02f, -1.08122744e-01f, -1.58127502e-01f, 7.72267282e-02f, -1.53335080e-01f, 2.10427150e-01f,
  -1.35898039e-01f, 6.67172298e-02f, 1.90500051e-01f, 8.31588581e-02f, 1.42617241e-01f, -9.07729045e-02f, 6.84840232e-02f, -1.16000669e-02f, 1.08698219e-01f, -1.57690659e-01f,
  -2.09723022e-02f, 1.22910105e-01f, -1.17555760e-01f, -7.15916753e-02f, 8.59049410e-02f, 6.15872294e-02f, 7.87744522e-02f, -8.45126733e-02f, -5.05682342e-02f, 3.17124635e-01f,
  3.65038365e-01f, -9.75442156e-02f, 3.39007415e-02f, 1.04001239e-01f, -1.47579849e-01f, 5.59885614e-03f, -2.53330134e-02f, -8.76290277e-02f, 1.10187761e-01f, 3.07771284e-02f,
  5.82681485e-02f, -8.50001350e-02f, 2.94931028e-02f, -4.03478034e-02f, 2.82239038e-02f, 4.90195788e-02f, -2.11491510e-01f, 3.95566225e-02f, -4.75603295e-03f, 3.36804204e-02f,
  4.58941311e-02f, -1.69026673e-01f, -5.07428050e-02f, 2.60671582e-02f, -1.49096698e-01f, 7.12071732e-02f, -1.38487250e-01f, -2.11386252e-02f, -2.78645575e-01f, -2.62723714e-02f,
  -5.31224161e-02f, -1.28242135e-01f, 1.16252210e-02f, 3.45471799e-01f, 1.88403904e-01f, -2.63555288e-01f, 7.83261135e-02f, -3.32262903e-01f, 5.53970821e-02f, 2.38149688e-02f,
  9.32566822e-02f, -7.78263733e-02f, -2.36940354e-01f, -2.42875554e-02f, 1.41963571e-01f, 1.94859415e-01f, -1.33496433e-01f, 4.22013819e-01f, -1.09058104e-01f, 2.41287258e-02f,
  -7.48697445e-02f, -4.38298434e-02f, 1.69147924e-02f, -5.89624830e-02f, -3.94111164e-02f, -1.06446959e-01f, 1.47724703e-01f, 1.85111493e-01f, 1.19363546e-01f, -1.30747080e-01f,
  1.21159405e-01f, 4.73681390e-02f, 1.98268786e-01f, 1.60210833e-01f, -1.46401584e-01f, -1.44210353e-01f, 1.62510991e-01f, 1.84965566e-01f, -5.53580411e-02f, 6.57394528e-02f,
  9.72291362e-03f, -1.29245788e-01f, -1.48983508e-01f, 1.74540982e-01f, 4.07106914e-02f, -2.47739300e-01f, 7.11422637e-02f, 1.77785859e-01f, 7.00301901e-02f, 6.35313392e-02f,
  -2.40283370e-01f, -2.11295724e-01f, -5.10678180e-02f, 8.14563408e-02f, -2.28836387e-01f, -9.43939239e-02f, 5.93311042e-02f, 7.70493522e-02f, 4.85054813e-02f, -2.93566398e-02f,
  -4.54062596e-02f, -7.78964832e-02f, -1.46045983e-01f, -2.03811396e-02f, 2.83896327e-01f, 2.24943727e-01f, -7.28784800e-02f, -2.40260422e-01f, 3.59180629e-01f, 1.84640400e-02f,
  -1.40552064e-02f, -8.11664835e-02f, 1.91082194e-01f, 3.14436965e-02f, -4.22194116e-02f, 1.07862931e-02f, -1.84266746e-01f, 2.01179031e-02f, -7.88207427e-02f, 2.50339229e-02f,
  -1.79106802e-01f, 2.45617256e-01f, -2.33437940e-01f, 1.00866035e-01f, 1.44362494e-01f, 9.49062109e-02f, 7.99482092e-02f, 1.22068450e-01f, -1.76921204e-01f, -1.94471851e-01f,
  -3.01217288e-02f, 2.50940621e-01f, 2.51033157e-01f, 6.11518696e-02f, 3.18127871e-02f, 4.23056073e-02f, 1.74714491e-01f, 1.63831130e-01f, 2.03263581e-01f, -7.80521333e-02f,
  -1.86565518e-01f, 2.38492880e-02f, 9.30217619e-04f, 2.10962251e-01f, -1.70373879e-02f, -1.43865407e-01f, 5.53559065e-02f, -3.04018948e-02f, -3.03389132e-02f, -2.77961064e-02f,
  -1.54254586e-01f, 8.91591012e-02f, -2.35530436e-02f, 7.47824088e-02f, -3.19988392e-02f, -1.25790626e-01f, -1.86691768e-02f, -7.88585469e-02f, 1.64518043e-01f, 3.04881454e-01f,
  -1.37050211e-01f, -8.95977393e-02f, 4.23329957e-02f, -1.86955586e-01f, -3.51821706e-02f, -1.18404493e-01f, -1.04063697e-01f, -4.72695976e-02f, -3.62423271e-01f, -1.43405452e-01f,
  1.52433872e-01f, 4.35682774e-01f, -4.79709730e-02f, -1.42228514e-01f, -7.73246512e-02f, -2.22159289e-02f, -3.42011116e-02f, -1.12687096e-01f, 9.85775217e-02f, 5.70417009e-02f,
  -1.07633755e-01f, 1.24957124e-02f, 1.32024631e-01f, 3.52706462e-02f, 1.45640656e-01f, 1.03275016e-01f, 1.60479859e-01f, -3.52364555e-02f, -5.10692336e-02f, -1.82739556e-01f,
  8.87328235e-04f, 1.17233276e-01f, -7.00394157e-03f, 5.13960235e-02f, 6.78427666e-02f, 6.87256381e-02f, 6.64662123e-02f, -2.42053926e-01f, 4.86076139e-02f, 1.26310796e-01f,
  -6.44377097e-02f, -2.11623430e-01f, -3.55645090e-01f, -1.98275726e-02f, -1.11933000e-01f, -1.11169629e-01f, -1.33634821e-01f, 2.36293674e-02f, -6.95475265e-02f, 2.45271802e-01f,
  1.76989242e-01f, 4.34003063e-02f, 6.91611841e-02f, -1.45945484e-02f, 1.05230220e-01f, 1.96428537e-01f, -6.91718310e-02f, -5.26920855e-02f, 1.54384479e-01f, -6.31355643e-02f,
  -7.98665732e-02f, 1.06354319e-02f, -6.90839887e-02f, 8.19399059e-02f, -3.13379318e-02f, 1.00873999e-01f, 1.59712106e-01f, 8.45765546e-02f, 6.12553582e-02f, 9.55512077e-02f,
  5.66969253e-02f, 2.12343037e-02f, 1.67596444e-01f, 1.19276203e-01f, -4.04531389e-01f, -3.07884932e-01f, 6.46017939e-02f, 7.17850998e-02f, 1.62382752e-01f, -8.30170698e-03f,
  -1.22482292e-01f, -2.20467973e-05f, -2.19502196e-01f, 3.23531218e-02f, 2.21830636e-01f, 1.06580913e-01f, -1.28613546e-01f, -1.98458299e-01f, 3.54412906e-02f, -2.45492950e-01f,
  8.09794758e-03f, 1.24467328e-01f, -1.14885956e-01f, -9.17586759e-02f, -4.37364243e-02f, 2.26019114e-01f, 1.19715504e-01f, 2.71856282e-02f, 2.61011347e-02f, -1.30993530e-01f,
  -7.57437013e-03f, -1.54072838e-02f, -2.51628339e-01f, -6.34824336e-02f, -1.21404983e-01f, -1.44530892e-01f, 7.07820728e-02f, 1.10121826e-02f, -1.87728286e-01f, -3.27709205e-02f,
  7.09481761e-02f, 1.45916745e-01f, -1.36733264e-01f, -2.02774648e-02f, 1.15682051e-01f, 4.79159355e-02f, -2.16002036e-02f, 2.93054014e-01f, -1.46841198e-01f, -2.15267926e-01f,
  -3.66948992e-02f, 1.74201772e-01f, 2.02882856e-01f, 1.51092768e-01f, 4.60672602e-02f, 4.70193513e-02f, 2.85386946e-02f, 4.16509621e-02f, 1.27424434e-01f, 7.46034533e-02f,
  -8.21489990e-02f, 3.50506976e-02f, 5.79348318e-02f, -9.30017084e-02f, -2.25347042e-01f, 9.37568471e-02f, -3.12083572e-01f, -2.69054830e-01f, 2.93096572e-01f, 4.32328880e-01f,
  -2.94707239e-01f, -1.32079124e-01f, 1.37693480e-01f, -9.57644209e-02f, -1.12824976e-01f, -1.70247361e-01f, 1.80330992e-01f, -1.72287688e-01f, -1.61046326e-01f, 3.43508925e-03f,
  1.76997334e-01f, -7.53947720e-02f, -3.83779630e-02f, 3.10081728e-02f, 3.47112641e-02f, -1.04305454e-01f, -8.03918839e-02f, -1.16319031e-01f, 3.27907428e-02f, -8.14665928e-02f,
  1.63432464e-01f, 2.91642934e-01f, 5.92656769e-02f, -3.55015360e-02f, -2.04495534e-01f, -1.23564087e-01f, 2.87914984e-02f, 1.54129043e-01f, 3.49790305e-02f, -3.79646681e-02f,
  -2.74352014e-01f, -1.26566231e-01f, 2.97342557e-02f, -4.00258340e-02f, 9.07778963e-02f, -2.21946128e-02f, -6.18255250e-02f, 3.09080780e-02f, 1.44703031e-01f, -3.01265437e-02f,
  -1.51721880e-01f, 2.53331125e-01f, -3.92057933e-02f, 2.26003155e-01f, 1.12912424e-01f, 9.92276706e-03f, -1.70721903e-01f, -8.87654200e-02f, 2.11630594e-02f, -1.92935899e-01f,
  -2.03757495e-01f, 8.51006433e-02f, -5.41368825e-03f, 8.10150355e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.38677612e-01f, 1.22728959e-01f, 2.74010867e-01f, 2.32953489e-01f, 1.52792051e-01f, 4.57677804e-02f, -4.62068096e-02f, 5.24228513e-02f, -8.66098776e-02f, -1.06175020e-02f,
  2.76200939e-03f, -1.04127184e-01f, 1.09541997e-01f, -3.76225486e-02f, 1.88513771e-02f, -4.79843467e-02f, -7.01628625e-02f, 1.04571603e-01f, 2.93679774e-01f, -1.20828122e-01f,
  1.63558304e-01f, 3.58729949e-03f, -7.93353375e-03f, 1.45691648e-01f, 1.19863316e-01f, -1.27512649e-01f, -9.35134366e-02f, 1.31300926e-01f, -1.95866358e-03f, 9.36438888e-03f,
  8.32735598e-02f, 1.57916382e-01f, -1.62926782e-02f, -7.55571425e-02f, 2.51135584e-02f, 2.53249615e-01f, -9.07733738e-02f, 4.72015738e-02f, -9.21397284e-02f, -6.13047667e-02f,
  9.46700051e-02f, 1.81532457e-01f, -2.09099367e-01f, 7.00628236e-02f, -7.92085230e-02f, 1.39049396e-01f, 4.42967564e-02f, 2.60505438e-01f, 1.73364446e-01f, 1.48126900e-01f,
  4.08391505e-02f, 6.87400624e-03f, -9.74602997e-02f, 2.66766250e-02f, -3.81104574e-02f, -4.02929820e-02f, 1.66326985e-01f, 1.66473929e-02f, -1.20592989e-01f, 1.07014783e-01f,
  -1.59498882e-02f, -2.49476489e-02f, -1.46854192e-01f, 9.01748762e-02f, 1.55083211e-02f, 1.09177373e-01f, 1.07576987e-02f, -4.85427566e-02f, 4.86317426e-02f, 1.36492968e-01f,
  -9.49269608e-02f, -1.60547122e-01f, -1.21585615e-01f, 4.15824875e-02f, -1.64462715e-01f, -1.53800875e-01f, 1.75560817e-01f, -4.81968410e-02f, 9.87299308e-02f, 7.02918991e-02f,
  -3.90461236e-02f, 3.89941805e-03f, -1.16024807e-01f, -1.34836525e-01f, 8.69669169e-02f, 4.24873531e-02f, -6.59642816e-02f, 1.32133637e-03f, 5.08082658e-02f, -6.69100955e-02f,
  5.86869419e-02f, -1.02606993e-02f, -3.37373763e-02f, -1.05065368e-01f, 2.57364269e-02f, 1.01318292e-01f, -6.67969361e-02f, 1.85833842e-01f, -1.66023448e-01f, 6.63039610e-02f,
  8.08318779e-02f, 1.31820709e-01f, 1.66199151e-02f, 2.29254793e-02f, -1.04859248e-01f, 4.16958006e-03f, 6.87309504e-02f, -1.36463597e-01f, -2.38385703e-02f, -1.31775752e-01f,
  1.13693416e-01f, -3.70017104e-02f, 1.18243713e-02f, -5.05671352e-02f, -8.69535506e-02f, 2.87058324e-01f, -4.34505334e-03f, -7.28647858e-02f, -3.81590202e-02f, -1.63365886e-01f,
  -1.09974280e-01f, 1.29263207e-01f, 8.01965222e-02f, 8.95944387e-02f, -1.13731876e-01f, 8.75424445e-02f, 1.30361512e-01f, -3.13961096e-02f, 1.11415513e-01f, 1.12420648e-01f,
  -3.81942056e-02f, 1.52819589e-01f, 6.16536178e-02f, 3.67066823e-02f, -9.90566090e-02f, 3.86853963e-02f, 2.24132650e-02f, 1.09870367e-01f, 1.38731882e-01f, -1.59290303e-02f,
  -3.34622264e-02f, -1.93591923e-01f, -1.72111560e-02f, -1.25108570e-01f, 2.48970047e-01f, -6.98037297e-02f, -8.25576931e-02f, 6.99017057e-03f, -1.86237711e-02f, 2.99079180e-01f,
  4.59184013e-02f, 2.25268647e-01f, -1.34699754e-02f, -1.49771750e-01f, -1.00825347e-01f, 5.47910817e-02f, -6.80431724e-03f, -7.52419457e-02f, -2.04390977e-02f, -1.02178715e-01f,
  -4.44497541e-02f, 1.25094771e-01f, -6.88319653e-02f, -3.67760472e-02f, 1.57585636e-01f, -4.96416166e-02f, 1.96716845e-01f, 1.81436762e-01f, -1.52729051e-02f, -9.66014937e-02f,
  2.90211290e-01f, -4.06504422e-02f, -8.40599984e-02f, 5.68443239e-02f, -8.99540484e-02f, -8.10245648e-02f, 4.86757606e-03f, -7.29106516e-02f, -4.21883091e-02f, -1.44164339e-01f,
  -7.73647800e-02f, -1.61794331e-02f, 2.69111004e-02f, -6.72768429e-02f, -5.28725795e-02f, -2.20513903e-02f, -6.24699108e-02f, 3.09247300e-02f, -1.39456332e-01f, 7.81022571e-03f,
  1.00719504e-01f, -2.17098929e-02f, -5.75314760e-02f, 4.27378751e-02f, 1.37425378e-01f, 5.17922826e-02f, 8.76120105e-02f, 1.53997794e-01f, 2.96020836e-01f, -6.43185899e-02f,
  -2.01908648e-01f, -1.04428321e-01f, 1.06280379e-03f, -4.57150973e-02f, 2.23266464e-02f, -1.00679714e-02f, -7.81898573e-02f, -9.95170176e-02f, 3.38349789e-02f, 1.95298269e-02f,
  -9.89566445e-02f, 8.18267018e-02f, -1.94370091e-01f, -6.86715767e-02f, 2.90881639e-04f, 1.87914431e-01f, -2.06195861e-02f, 7.82885104e-02f, -5.79869486e-02f, -8.42611045e-02f,
  1.58677384e-01f, -7.66731948e-02f, 7.59018585e-02f, 1.88442454e-01f, 2.59842545e-01f, 5.62943630e-02f, 1.79461703e-01f, 9.11613852e-02f, -4.56568860e-02f, -8.30144361e-02f,
  5.55679314e-02f, 2.10358799e-01f, 1.53518468e-01f, -4.47279587e-02f, 1.12245828e-01f, 2.10587010e-02f, 6.40639737e-02f, 9.82566625e-02f, 9.20813909e-05f, -2.00600207e-01f,
  -8.87685493e-02f, -7.17103556e-02f, 8.73289257e-02f, 1.13015831e-01f, -1.96321029e-02f, 2.82455646e-02f, -5.36770895e-02f, 6.70736209e-02f, -1.98111519e-01f, 1.66073386e-02f,
  -1.33480757e-01f, 1.38750896e-01f, 1.33418292e-02f, 7.73951337e-02f, 1.69354435e-02f, -7.27236271e-02f, 8.33936706e-02f, -5.67656793e-02f, 1.72347128e-01f, -3.58445495e-02f,
  8.06109328e-03f, -3.09254117e-02f, 5.76085364e-03f, -2.26077680e-02f, 4.22815979e-02f, 4.72744592e-02f, -4.41723205e-02f, -1.09703854e-01f, 1.38528436e-01f, 1.93170667e-01f,
  4.74900566e-02f, -1.41458467e-01f, 6.13790937e-02f, 6.53398708e-02f, 1.99448392e-01f, -1.58451945e-01f, -7.75899291e-02f, 2.44841408e-02f, -1.19739339e-01f, -5.00472263e-02f,
  6.57280311e-02f, 9.45651010e-02f, 1.26624569e-01f, -1.66995257e-01f, 7.80869499e-02f, 1.66964442e-01f, -8.65485370e-02f, -2.19227951e-02f, 6.61723316e-02f, -3.52756754e-02f,
  -1.22181594e-01f, 3.37649323e-02f, 7.42733255e-02f, 1.31517500e-01f, -1.11973420e-01f, 5.13603259e-03f, -4.07273993e-02f, 1.54979497e-01f, 3.41704488e-02f, -1.34226248e-01f,
  1.61582064e-02f, 1.42274141e-01f, -9.13983658e-02f, 2.11116612e-01f, 1.44097507e-01f, 9.69924256e-02f, -9.57551673e-02f, 2.69222349e-01f, 8.75739083e-02f, 8.08035284e-02f,
  1.84882581e-01f, -5.63145429e-02f, 2.85209447e-01f, 8.60516503e-02f, -2.68735941e-02f, 6.75610304e-02f, -1.46978632e-01f, -5.60235269e-02f, 8.99587274e-02f, 4.06153947e-02f,
  2.06224117e-02f, 6.02468848e-02f, 1.74008563e-01f, -1.40575498e-01f, 1.14536621e-01f, 1.12420931e-01f, -1.03346102e-01f, -2.48306960e-01f, -2.95326024e-01f, 8.03583413e-02f,
  -1.93880871e-01f, -2.09102541e-01f, 8.14451799e-02f, 2.58629769e-02f, -6.85900217e-03f, -5.25911450e-02f, 2.35311445e-02f, -9.51395258e-02f, 2.26020396e-01f, -1.15132183e-01f,
  1.06567383e-01f, -1.41651779e-01f, 3.53439748e-02f, 6.27959752e-03f, 2.49965236e-01f, 1.93247125e-01f, -4.50104661e-02f, 4.96027805e-02f, 1.76885292e-01f, 7.94659704e-02f,
  3.20371501e-02f, 7.36366957e-02f, -7.25520924e-02f, -4.82160188e-02f, -3.02669816e-02f, -1.18605075e-02f, -1.23141542e-01f, 2.48873949e-01f, -1.17581695e-01f, 1.42624378e-01f,
  1.90079242e-01f, 4.11002673e-02f, -1.49659142e-01f, -1.03797071e-01f, 5.04229963e-02f, 7.95473456e-02f, -6.43197522e-02f, 2.84976214e-01f, 3.38733017e-01f, -6.38409927e-02f,
  8.03598613e-02f, -8.52070376e-02f, 2.01785360e-02f, 1.24922030e-01f, -4.40227753e-03f, -1.82228833e-01f, 1.10559188e-01f, 1.78131685e-01f, -4.11960781e-02f, 2.09981278e-01f,
  7.84241930e-02f, -6.60595670e-02f, 3.77544612e-02f, 6.34693354e-02f, -6.24215640e-02f, 1.60772294e-01f, 1.05410807e-01f, -6.90824762e-02f, 6.09790124e-02f, 1.63805708e-01f,
  3.92487019e-01f, -1.05205342e-01f, -2.45299280e-01f, -2.14950517e-01f, -2.43304670e-02f, -1.28900498e-01f, 1.03252143e-01f, -1.31829502e-02f, 6.60749674e-02f, 1.86780706e-01f,
  -2.98678817e-04f, 1.20080197e-02f, 9.46553573e-02f, -1.12312669e-02f, -1.06601976e-01f, -1.41050339e-01f, -2.40288340e-02f, 2.07269415e-01f, -7.20276386e-02f, -5.70128709e-02f,
  1.41808006e-03f, 1.24336340e-01f, 4.30543721e-02f, -1.09570228e-01f, -4.98484820e-02f, 4.36531100e-03f, 8.71672034e-02f, 1.35104924e-01f, -2.34975610e-02f, 5.95747232e-02f,
  8.69462341e-02f, 4.30431813e-02f, 1.12456024e-01f, 2.89416462e-01f, 4.47763689e-02f, 4.84414585e-03f, 6.23574108e-02f, 2.93416921e-02f, -1.41422495e-01f, 2.66135391e-02f,
  3.47725675e-02f, -7.81390667e-02f, 7.69247860e-02f, 7.58226886e-02f, 2.08010860e-02f, 1.14394493e-01f, -1.34980664e-01f, 8.37121010e-02f, 6.50899187e-02f, -8.30995068e-02f,
  -8.40987116e-02f, 1.23841658e-01f, -9.67205390e-02f, -1.15908436e-01f, -1.56067703e-02f, 1.06809838e-02f, 9.65333059e-02f, -7.28652179e-02f, 3.47400866e-02f, -1.24175651e-02f,
  1.52696595e-01f, 1.58652782e-01f, 2.16279209e-01f, 1.89520083e-02f, -4.30753194e-02f, 1.58027083e-01f, 2.46812031e-01f, -3.89057472e-02f, 4.69043069e-02f, 1.21450990e-01f,
  3.15039828e-02f, 3.72606777e-02f, 1.16552366e-02f, 7.01104403e-02f, 1.19647734e-01f, 5.42808193e-05f, 1.98727563e-01f, -8.15956146e-02f, 9.60293133e-03f, 1.34605512e-01f,
  1.03155389e-01f, -1.26693621e-01f, -1.05400048e-01f, 1.05465036e-02f, -1.27093241e-01f, -1.48321306e-02f, -1.14357278e-01f, 8.81174058e-02f, -1.07739948e-01f, -1.03370227e-01f,
  -2.26540044e-02f, 4.77275159e-03f, -9.21944603e-02f, 1.31086484e-01f, 1.29445508e-01f, -5.11810705e-02f, 1.04313843e-01f, -4.86360118e-02f, -1.36991423e-02f, 1.78457439e-01f,
  6.02422357e-02f, 1.10317312e-01f, 2.98432237e-03f, -9.47616100e-02f, 2.85339206e-02f, 4.62979125e-03f, -9.84578580e-02f, -1.04709633e-01f, -1.03802212e-01f, 1.34829566e-01f,
  6.30161446e-03f, -6.40520155e-02f, -6.97335377e-02f, 7.71651193e-02f, 6.13422804e-02f, 5.50039113e-02f, 1.73279777e-01f, -9.62183252e-02f, 4.21211571e-02f, 9.13696289e-02f,
  4.08924446e-02f, 6.13462701e-02f, 1.32749677e-01f, 1.43060997e-01f, 2.45615080e-01f, 6.48727268e-02f, 2.30973169e-01f, 1.56229362e-01f, -4.58970040e-01f, -2.09491923e-01f,
  2.76424855e-01f, 3.98222923e-01f, -2.24251807e-01f, 3.74659672e-02f, -1.93472117e-01f, -2.18092799e-02f, -1.60144210e-01f, 6.47061244e-02f, 2.47901529e-01f, -1.55013194e-02f,
  -2.90763634e-03f, -1.26878619e-01f, 1.76117495e-01f, 1.96051955e-01f, 3.10834855e-01f, -4.86292556e-04f, 2.51243502e-01f, -1.33335963e-02f, -2.91429218e-02f, -1.26360402e-01f,
  -1.25779599e-01f, 9.75353494e-02f, -6.51573166e-02f, 4.76621799e-02f, -1.24317460e-01f, -2.41119891e-01f, -6.52472600e-02f, 3.65787111e-02f, -1.27761871e-01f, -5.18903807e-02f,
  -1.66842833e-01f, 2.88623828e-03f, -9.92017835e-02f, 1.23781182e-01f, 2.45249078e-01f, 1.67525169e-02f, 2.18061402e-01f, -7.66642466e-02f, -1.21851079e-02f, 1.55873850e-01f,
  1.96182445e-01f, 1.50031209e-01f, 1.03474066e-01f, -6.99644238e-02f, 3.08211688e-02f, 2.02327877e-01f, -8.49297270e-02f, -5.67657091e-02f, 2.01131403e-02f, -1.23852357e-01f,
  -6.01933450e-02f, 7.43756741e-02f, -9.29804742e-02f, -9.32176188e-02f, 8.72530863e-02f, -7.55354986e-02f, 4.02013250e-02f, 4.48375754e-02f, 1.37498789e-02f, 2.53537130e-02f,
  2.57825907e-02f, 1.47920296e-01f, 1.00548469e-01f, 9.93850008e-02f, 1.18995402e-02f, 2.05046758e-02f, -1.28270194e-01f, 1.65773153e-01f, 2.39623375e-02f, 1.08604565e-01f,
  8.84040967e-02f, 1.21378377e-01f, 1.41233847e-01f, -5.87382391e-02f, 7.12901428e-02f, -1.03300214e-02f, -1.54073745e-01f, 7.06345662e-02f, 5.50130941e-02f, -1.51313305e-01f,
  5.12133315e-02f, -7.69714564e-02f, 1.21836424e-01f, 1.11542210e-01f, 2.21098736e-02f, -9.71059501e-02f, -1.36368930e-01f, -1.04750291e-01f, -1.24635868e-01f, -1.13945797e-01f,
  -7.21798390e-02f, -1.40590211e-02f, -1.32985488e-01f, -5.72081059e-02f, -2.66114380e-02f, 1.76085487e-01f, 1.94201559e-01f, 8.92433450e-02f, -3.90400477e-02f, -9.37820598e-02f,
  1.90474331e-01f, -8.61187503e-02f, -4.17612530e-02f, -1.00833178e-01f, 4.32654917e-02f, -1.38325050e-01f, 4.84910943e-02f, -1.87643263e-02f, 2.25729235e-02f, -1.06212102e-01f,
  -1.26433909e-01f, -1.06434472e-01f, 7.69808888e-02f, 1.06371172e-01f, 4.56741601e-02f, -1.10792540e-01f, 1.67637974e-01f, 3.82293835e-02f, 1.01221882e-01f, -1.70873590e-02f,
  6.80587217e-02f, 1.14139028e-01f, -1.71136335e-02f, 1.50551036e-01f, -1.41622433e-02f, 1.81357767e-02f, 6.29435182e-02f, 2.35292464e-01f, 7.83243328e-02f, -6.25790954e-02f,
  -4.42617908e-02f, 2.20854223e-01f, 9.08421502e-02f, 1.78443283e-01f, -9.37029868e-02f, 2.33145300e-02f, 2.10121535e-02f, 3.57504934e-02f, 1.00153416e-01f, 2.05127001e-02f,
  -1.54932052e-01f, 7.88693130e-02f, -1.46740824e-01f, -1.76138822e-02f, -1.36718437e-01f, -1.43719111e-02f, -1.00952446e-01f, 1.65338725e-01f, -5.37024960e-02f, 1.58220112e-01f,
  -1.30812809e-01f, 1.02010751e-02f, 2.40361542e-02f, -1.93969123e-02f, -6.60873055e-02f, -1.14471214e-02f, -7.75981843e-02f, -8.43082368e-02f, -1.39764100e-01f, -1.10694043e-01f,
  -7.32685998e-02f, -6.64200559e-02f, 8.12616497e-02f, -2.45871656e-02f, 6.79975301e-02f, -2.58500278e-02f, 3.80763076e-02f, 7.07971528e-02f, 1.41695291e-02f, 7.76148438e-02f,
  -9.92665738e-02f, 9.89916697e-02f, -8.60527977e-02f, 2.60904822e-02f, 8.66067037e-02f, -4.64849062e-02f, 1.47604078e-01f, 1.19880857e-02f, 1.03479959e-01f, -1.01507135e-01f,
  -6.70711547e-02f, -1.96203832e-02f, 7.09834546e-02f, 2.85701137e-02f, 9.99723375e-03f, 1.35935977e-01f, -4.03298885e-02f, 3.15218747e-01f, 1.15379959e-01f, 2.56397963e-01f,
  2.53333390e-01f, -1.07588574e-01f, -1.48332894e-01f, 1.26875356e-01f, 8.75108782e-03f, -1.27544954e-01f, 2.57057309e-01f, 7.00097308e-02f, -9.52883274e-04f, 1.33474648e-01f,
  -4.05075587e-02f, -1.64009228e-01f, -2.77336258e-02f, -6.90056151e-03f, -5.93779646e-02f, -1.68436557e-01f, -1.43869579e-01f, 2.55163819e-01f, 3.64274085e-02f, -2.59303860e-02f,
  -3.51433568e-02f, -7.68958852e-02f, 2.18363822e-01f, -1.37139246e-01f, 8.22027922e-02f, 7.46919066e-02f, 1.72194257e-01f, 2.00425506e-01f, 2.06953958e-02f, -1.39242694e-01f,
  1.12005241e-01f, 2.78314024e-01f, -1.38999913e-02f, 2.23856002e-01f, 5.70975505e-02f, -5.39194420e-02f, -1.59143478e-01f, -5.26159187e-04f, -6.32815212e-02f, 2.27572829e-01f,
  -1.18977115e-01f, -1.21824890e-01f, 1.14236906e-01f, -1.02729611e-02f, -6.67462721e-02f, 2.26092935e-01f, -9.78739709e-02f, 1.61363602e-01f, 4.34055142e-02f, 4.30803560e-03f,
  -1.64521605e-01f, 1.36233523e-01f, 4.78854552e-02f, 1.12948753e-01f, 2.68561170e-02f, 7.70119801e-02f, -9.56172571e-02f, 9.70858783e-02f, -5.92248812e-02f, -2.88609117e-02f,
  -1.81268435e-02f, 4.75728884e-03f, 1.32111132e-01f, 1.19856298e-01f, 2.45750949e-01f, 1.27686962e-01f, 6.93689361e-02f, -2.72859812e-01f, 8.52111541e-03f, -5.83291845e-03f,
  -1.71679314e-02f, 1.59090370e-01f, 1.82243325e-02f, 1.94188640e-01f, 3.04519720e-02f, 1.18641891e-01f, 6.77617937e-02f, -9.17234868e-02f, 1.35227069e-01f, 6.13693381e-04f,
  3.38813588e-02f, -2.72882991e-02f, -1.35026455e-01f, 7.01383203e-02f, -3.92432325e-04f, -1.77114177e-02f, -4.31628115e-02f, 3.24971750e-02f, 1.11396387e-01f, -2.27951575e-02f,
  2.07467424e-03f, 2.57229418e-01f, 4.24234234e-02f, 8.58716145e-02f, 1.76543463e-02f, 1.37678891e-01f, 1.77216064e-02f, 2.97630522e-02f, 3.31865586e-02f, 2.58217975e-02f,
  1.70799345e-02f, -1.12551212e-01f, 3.61998975e-02f, -4.63070832e-02f, 1.96190048e-02f, 1.21191502e-01f, 1.37375668e-01f, -4.22866717e-02f, -3.97071466e-02f, 1.68647081e-01f,
  1.18709579e-02f, -2.77870223e-02f, -1.03582796e-02f, -5.60155846e-02f, 2.14267492e-01f, 1.53317466e-01f, 4.39457521e-02f, -1.82585940e-01f, 5.75017557e-02f, 7.27866963e-02f,
  1.30167276e-01f, 8.36232901e-02f, -2.22243555e-02f, 9.66049582e-02f, 1.67873174e-01f, 8.89729708e-03f, -1.07563592e-01f, 4.69527319e-02f, 2.69579560e-01f, 5.30127995e-02f,
  -4.34917994e-02f, -1.10966284e-02f, 2.23915324e-01f, -1.07225128e-01f, 1.52676906e-02f, 1.85636785e-02f, 1.76274225e-01f, -1.49127916e-02f, 1.00145772e-01f, -1.94752086e-02f,
  -1.17139705e-01f, -1.15055621e-01f, 6.13785237e-02f, 1.07483305e-01f, -2.84231324e-02f, 2.92206824e-01f, -3.20204720e-03f, -7.99814239e-02f, 5.64371832e-02f, 1.04883574e-01f,
  1.19097590e-01f, 9.25578550e-02f, 9.06808942e-04f, 1.32629409e-01f, 5.29067405e-02f, 1.36701301e-01f, 8.98512304e-02f, 1.47837296e-01f, 4.12150882e-02f, 1.16366744e-01f,
  -1.07257098e-01f, 2.13169530e-01f, 1.32255740e-02f, -9.94272903e-02f, -1.24750569e-01f, 1.06512062e-01f, -3.36671509e-02f, 1.02449879e-02f, 5.96322604e-02f, 1.68520715e-02f,
  -1.66441277e-02f, -4.33719940e-02f, 1.23019189e-01f, 1.60476521e-01f, -5.86679764e-02f, 7.56277069e-02f, 1.23789713e-01f, 3.61502729e-02f, 9.76167992e-02f, -1.03347845e-01f,
  -1.41882017e-01f, -7.93701187e-02f, 8.03058147e-02f, 1.36667088e-01f, 1.69599235e-01f, -3.93182039e-02f, -2.87618879e-02f, 3.11276942e-01f, 9.95526090e-02f, 2.96754211e-01f,
  7.15529621e-02f, 1.51679680e-01f, 4.29990441e-01f, -3.24482508e-02f, -5.23961075e-02f, -3.93939205e-02f, 3.25898737e-01f, 1.40988512e-03f, -1.37658266e-03f, -5.86710908e-02f,
  1.54740304e-01f, 2.76260376e-01f, -1.18859880e-01f, -1.65090948e-01f, -1.28909588e-01f, 3.34307164e-01f, -1.37865752e-01f, -2.02385515e-01f, 1.41328096e-01f, 9.76043940e-02f,
  1.26716807e-01f, 2.59067714e-01f, 3.66505561e-03f, -1.74160674e-02f, 1.33413240e-01f, -9.54447091e-02f, -6.88339546e-02f, -1.80785879e-02f, -6.75103068e-02f, 1.34043783e-01f,
  1.89629436e-01f, 4.71592471e-02f, 1.42757937e-01f, 1.23058267e-01f, 1.34154812e-01f, 3.29075873e-01f, 3.94822031e-01f, 1.74332127e-01f, -3.47116925e-02f, 4.31776345e-02f,
  4.84089255e-02f, 2.18086466e-01f, 1.12806529e-01f, -2.93183595e-01f, -1.83308899e-01f, -1.07911088e-01f, -1.47045955e-01f, -1.03074880e-02f, -7.25151598e-03f, -1.10794298e-01f,
  6.83569387e-02f, -1.43001247e-02f, -3.64302695e-01f, 1.15646034e-01f, 4.23802324e-02f, 1.51800960e-01f, 1.69646174e-01f, 1.40068457e-01f, -7.49852210e-02f, 1.03973597e-01f,
  1.59856498e-01f, 6.58427998e-02f, 3.59292664e-02f, 7.11074695e-02f, 1.72952656e-02f, -1.65541787e-02f, 3.47921252e-02f, 1.49270594e-01f, 5.59281744e-02f, -1.13089249e-01f,
  -1.22101535e-03f, -2.46703047e-02f, 1.19662121e-01f, 7.40435207e-03f, 1.53532133e-01f, -6.94198236e-02f, 1.27828956e-01f, 3.02065094e-03f, 1.18963338e-01f, -6.23868406e-02f,
  -2.36237068e-02f, 1.12023488e-01f, 3.97454947e-02f, 1.52568266e-01f, -8.10100064e-02f, -4.65309713e-03f, 9.53088179e-02f, 1.00753009e-01f, -3.51195806e-03f, -3.66838686e-02f,
  -8.36001188e-02f, 6.25810027e-02f, 1.51734492e-02f, 7.93672167e-03f, -2.97464877e-02f, 1.44690663e-01f, 1.30530149e-01f, 2.67035551e-02f, -4.40434590e-02f, 4.07613292e-02f,
  1.25696152e-01f, -5.36782891e-02f, 9.25896019e-02f, -1.54311499e-02f, -9.53533724e-02f, -1.05175398e-01f, 8.62876996e-02f, 1.05817340e-01f, -6.52892441e-02f, -1.12222739e-01f,
  -6.24300912e-02f, -1.44464463e-01f, -2.62094326e-02f, -9.86933336e-02f, -1.43775344e-01f, 5.88722676e-02f, -1.33381039e-01f, 2.90529300e-02f, 1.63057849e-01f, 7.60911927e-02f,
  4.88802604e-02f, 9.84012261e-02f, -5.39333150e-02f, 1.28291130e-01f, 2.93167293e-01f, 9.51149464e-02f, 4.78033982e-02f, 1.74326807e-01f, 1.78658232e-01f, 2.26656362e-01f,
  -2.50859469e-01f, 1.32533267e-01f, 3.98563892e-01f, -7.99439251e-02f, -1.05339810e-02f, 2.11347386e-01f, 8.23660791e-02f, 1.59047484e-01f, 4.30454388e-02f, 5.29916100e-02f,
  2.94787616e-01f, -7.40707070e-02f, 9.84566957e-02f, -1.44103095e-01f, -4.43147570e-02f, 9.87079963e-02f, -2.03234792e-01f, 2.25379206e-02f, -1.47858828e-01f, -5.15086693e-04f,
  -1.88018493e-02f, 1.13862924e-01f, -1.54757261e-01f, -1.27999276e-01f, -6.03788756e-02f, -8.70787650e-02f, -9.27173626e-03f, 4.15444858e-02f, -1.49107963e-01f, 1.48502529e-01f,
  -3.06181237e-02f, -1.86242741e-02f, 1.64461613e-01f, 2.32264157e-02f, -2.76494902e-02f, 1.29166514e-01f, 5.97833097e-03f, -7.36442432e-02f, 1.33821681e-01f, 3.25782150e-02f,
  4.07753326e-02f, 2.81965107e-01f, -7.46605471e-02f, -4.24064696e-02f, 9.42316055e-02f, -1.90223634e-01f, -1.09159462e-01f, 1.09636478e-01f, -1.49166226e-01f, 4.78557916e-03f,
  -8.34304094e-02f, 1.28537258e-02f, -8.12099278e-02f, 1.58872306e-02f, -4.81847934e-02f, 2.26025328e-01f, -1.87427729e-01f, 3.09095327e-02f, 1.14138229e-02f, 3.90518457e-02f,
  5.62036131e-03f, 1.36682242e-01f, 3.93900946e-02f, 2.41832256e-01f, -7.67763853e-02f, 7.68888965e-02f, -6.05741329e-03f, -1.30551174e-01f, -1.72713101e-01f, -9.60869044e-02f,
  2.06442162e-01f, 1.37824519e-02f, -5.02983220e-02f, -9.99681503e-02f, -1.08950853e-01f, -7.97780007e-02f, 1.31547913e-01f, -2.01511338e-01f, 1.10101700e-01f, -1.20829511e-02f,
  4.84121181e-02f, -8.56936797e-02f, 5.57949096e-02f, -1.15545183e-01f, 1.18509114e-01f, 1.13820545e-01f, -3.08582978e-03f, -2.75147613e-02f, 1.65292829e-01f, 1.92077830e-01f,
  5.48011102e-02f, 8.99912789e-02f, -1.61496267e-01f, 1.35021970e-01f, 4.94866818e-02f, 8.66915956e-02f, -1.08144693e-01f, -1.24092042e-01f, 1.21943923e-02f, 3.65159400e-02f,
  -1.03219375e-01f, -1.40117379e-02f, 3.32253017e-02f, -8.96991789e-02f, -5.48949204e-02f, 1.46242335e-01f, 1.73401624e-01f, 8.83240253e-02f, -7.97692835e-02f, 1.80290237e-01f,
  -1.10443719e-01f, 1.24130093e-01f, 1.95628986e-01f, 3.46615352e-02f, 2.65944421e-01f, -6.00192286e-02f, -3.50721627e-02f, -6.62475973e-02f, -7.05009997e-02f, -1.73146334e-02f,
  1.07942127e-01f, 1.21503673e-01f, 1.90477312e-01f, 7.69320875e-02f, -4.39218758e-03f, 3.31619829e-01f, -1.73786834e-01f, 1.29277501e-02f, -2.73820907e-01f, -3.37631181e-02f,
  2.60196567e-01f, 5.18041402e-02f, 2.58012623e-01f, 1.13976955e-01f, 6.01647003e-03f, -2.48565078e-01f, -2.37654406e-03f, -2.14267820e-02f, 9.78154838e-02f, 3.82463709e-02f,
  -1.40948951e-01f, -2.88351718e-02f, -3.58019769e-02f, 1.20496385e-01f, -3.73920277e-02f, 3.29931378e-01f, 8.34620185e-03f, 1.69077933e-01f, -1.69674829e-01f, 1.79687142e-01f,
  -1.20520525e-01f, 5.92098720e-02f, -8.21766108e-02f, -4.29656953e-02f, 1.24142520e-01f, -1.48718327e-01f, 1.71557799e-01f, 2.90223844e-02f, -7.00944010e-03f, -7.23760426e-02f,
  6.37342110e-02f, 8.60251393e-03f, 6.33940250e-02f, -8.79259706e-02f, -8.41649026e-02f, 1.14523031e-01f, -8.24687034e-02f, 4.01902981e-02f, -6.94240108e-02f, 1.38831466e-01f,
  -9.07220691e-02f, 4.82491683e-03f, -5.75175807e-02f, 9.67322364e-02f, -4.99344617e-02f, 1.28373923e-02f, 8.56645033e-02f, 1.21363439e-02f, 8.36247727e-02f, 3.92016843e-02f,
  -5.86569533e-02f, 1.83632880e-01f, -1.73092619e-01f, 8.99247900e-02f, 1.60942331e-01f, 6.96825162e-02f, -7.38891289e-02f, -6.87964857e-02f, -5.18143885e-02f, 4.58800904e-02f,
  -1.24481685e-01f, -4.98799011e-02f, 4.66513559e-02f, 8.52652937e-02f, 4.04100195e-02f, 5.79519793e-02f, -3.81162463e-05f, 5.66637404e-02f, 1.10303611e-01f, -3.26610655e-02f,
  2.42493913e-01f, 9.23488140e-02f, -3.93085331e-02f, 8.63088518e-02f, -2.02142503e-02f, 3.70518565e-02f, -1.39300423e-02f, -4.77514006e-02f, 7.72073818e-03f, 1.47146776e-01f,
  1.70246005e-01f, 1.77530557e-01f, -1.21859685e-01f, 2.01139122e-01f, 4.97884713e-02f, -1.51194157e-02f, -2.62816548e-02f, -8.01555440e-02f, 1.22040913e-01f, 1.46388039e-01f,
  -3.25408205e-02f, 1.03283003e-01f, 7.07229152e-02f, 2.54144639e-01f, -3.68090086e-02f, 1.16966039e-01f, 2.43347704e-01f, -1.52687971e-02f, 4.35225591e-02f, 4.86412458e-02f,
  -6.43428788e-02f, 1.93673223e-01f, -5.38974069e-02f, 4.54847142e-02f, -4.19070981e-02f, -9.53574479e-02f, -1.03957439e-02f, -4.43484783e-02f, -6.92446232e-02f, 8.47916976e-02f,
  -6.47340938e-02f, 1.92109793e-02f, -9.25654247e-02f, 4.06312458e-02f, -8.57120752e-02f, -4.05324623e-02f, 1.60328165e-01f, 1.25583172e-01f, -1.18527219e-01f, -8.10906217e-02f,
  1.00904763e-01f, 6.77830949e-02f, 2.02674210e-01f, 5.45559339e-02f, 1.02959558e-01f, -7.00047612e-02f, -5.58826439e-02f, 2.52698123e-01f, 9.33312476e-02f, 4.19607684e-02f,
  5.14748842e-02f, 4.50474657e-02f, -1.41831607e-01f, 5.38729243e-02f, -1.25287518e-01f, 5.33110984e-02f, 2.36077756e-02f, -5.46439067e-02f, 9.15839598e-02f, 2.09441297e-02f,
  -2.99311671e-02f, 9.37110782e-02f, -3.82639542e-02f, -1.40308112e-01f, 1.11072458e-01f, 2.47345958e-02f, -1.46819383e-01f, 1.94285288e-01f, -1.84805542e-01f, 2.72494793e-01f,
  -9.09369532e-03f, -1.19726442e-01f, 2.05375418e-01f, -9.95978639e-02f, 2.73968745e-02f, 2.23782092e-01f, -7.96183795e-02f, -1.34933621e-01f, -2.55705621e-02f, -2.40085855e-01f,
  1.96272731e-02f, 4.70066965e-02f, 4.15021367e-02f, 4.97483788e-03f, 6.41772822e-02f, 1.97373945e-02f, -6.27110228e-02f, 7.06767244e-03f, 9.72654745e-02f, 1.11302763e-01f,
  3.22981807e-03f, 2.67054021e-01f, -4.02544625e-02f, -3.48232239e-02f, 1.59095943e-01f, 7.93582574e-02f, 2.23982960e-01f, -3.04657761e-02f, 4.66553867e-03f, -3.20632383e-02f,
  -1.38059929e-01f, -1.21572148e-02f, 6.79217279e-02f, -2.25337911e-02f, 2.94071622e-02f, 1.62918627e-01f, 9.66067687e-02f, 9.28852707e-03f, 1.59294993e-01f, -3.94099802e-02f,
  2.98800439e-01f, 7.19411522e-02f, -2.44496763e-01f, -9.40773711e-02f, 2.43104368e-01f, 2.71928627e-02f, 1.26770541e-01f, -6.23303391e-02f, 1.14085607e-01f, -8.65153372e-02f,
  -1.15707956e-01f, -9.46964622e-02f, -1.27662838e-01f, 3.88375893e-02f, -5.05823828e-02f, -1.27243042e-01f, -1.10772513e-01f, 1.93176251e-02f, 1.71487212e-01f, 2.00193711e-02f,
  5.98191342e-04f, 3.55370417e-02f, 2.00061217e-01f, 4.72665913e-02f, 1.32430166e-01f, 1.65770277e-01f, 2.00745463e-01f, -1.35670453e-01f, 5.74327931e-02f, 1.39109313e-01f,
  -7.79230222e-02f, -4.19728197e-02f, -5.27814776e-02f, 2.21158147e-01f, 2.24904567e-01f, 4.67174463e-02f, -1.33635610e-01f, -1.09789364e-01f, -1.30985588e-01f, 4.37166579e-02f,
  4.22961749e-02f, -2.25788295e-01f, -1.46057367e-01f, -9.33284909e-02f, -1.26520157e-01f, 2.91654974e-01f, -1.06696214e-03f, 1.07973972e-02f, 1.86908185e-01f, -9.29265320e-02f,
  1.14208102e-01f, 8.87766108e-02f, 4.86656949e-02f, 1.36482835e-01f, 7.81253353e-02f, -1.73848625e-02f, -3.39229032e-02f, 1.44537151e-01f, 2.33598873e-02f, -4.66548130e-02f,
  -1.24264136e-02f, 1.30018279e-01f, 1.84228450e-01f, 9.37731490e-02f, -1.93288196e-02f, -1.18514009e-01f, 1.09738588e-01f, -1.54559463e-01f, -1.35252044e-01f, -2.30850521e-02f,
  8.07030275e-02f, 1.59631655e-01f, 6.87012076e-02f, 8.90731588e-02f, -1.22359015e-01f, -7.43784085e-02f, 1.74108565e-01f, -1.02423139e-01f, 3.43008861e-02f, 1.10807426e-01f,
  -7.80248195e-02f, -8.04992840e-02f, 6.74460605e-02f, 7.34117851e-02f, 1.05371453e-01f, 1.08847484e-01f, 1.90409217e-02f, -3.15369740e-02f, -3.31375152e-02f, 2.69265808e-02f,
  -1.37769073e-01f, 6.78049400e-02f, -6.01821542e-02f, 1.82521865e-01f, -1.29431516e-01f, 1.50287837e-01f, -1.73187051e-02f, 4.22076024e-02f, -7.54193030e-03f, 6.18788414e-02f,
  -1.25136152e-02f, -8.19179416e-03f, 1.02067374e-01f, 2.56532561e-02f, 4.81811464e-02f, 2.89205480e-02f, -7.36085549e-02f, -7.00273439e-02f, -8.88660252e-02f, -5.92420669e-03f,
  -8.00016709e-03f, 1.04208127e-01f, -2.83429865e-02f, -9.05488729e-02f, -1.97283924e-02f, -5.35669103e-02f, 1.08095810e-01f, 2.85787228e-02f, 1.55245036e-01f, -1.25101343e-01f,
  -5.35787956e-04f, 4.69873548e-02f, -6.33833557e-02f, 4.79421988e-02f, 3.81061956e-02f, -3.31667289e-02f, 6.22978285e-02f, 2.35793311e-02f, -1.12737462e-01f, -1.20269887e-01f,
  -4.46729176e-02f, 1.57090686e-02f, -2.87438072e-02f, -6.06454834e-02f, 1.28542930e-01f, 3.70552950e-02f, -8.96558538e-02f, 7.27593526e-02f, -1.01122200e-01f, -7.25828484e-02f,
  -1.25733420e-01f, 4.08148542e-02f, 1.42240778e-01f, 1.54391780e-01f, -1.09957531e-01f, 5.84744923e-02f, 8.83953348e-02f, -1.58932488e-02f, 1.33973733e-01f, 1.05994597e-01f,
  1.27338260e-01f, 3.15231755e-02f, 1.29524879e-02f, 3.82581241e-02f, 1.67515334e-02f, 9.42469165e-02f, -6.65296763e-02f, -6.38498291e-02f, -9.18402970e-02f, 1.16365306e-01f,
  -1.36842467e-02f, -7.94096589e-02f, -8.91724974e-02f, -1.16214968e-01f, 1.78435192e-01f, -9.34897065e-02f, -5.27391396e-02f, -1.16142221e-01f, 2.31179297e-02f, -1.42575026e-01f,
  -6.59578368e-02f, 5.54073825e-02f, -1.27045557e-01f, 9.08676814e-03f, -1.91320274e-02f, -7.51838237e-02f, -3.77842225e-03f, -2.43835561e-02f, 4.23821732e-02f, 9.81206521e-02f,
  9.45465565e-02f, -9.07048807e-02f, -1.21194728e-01f, -1.12971507e-01f, -4.11129780e-02f, 6.60879463e-02f, 3.05769205e-01f, 2.67456055e-01f, -6.87256008e-02f, 1.75077662e-01f,
  2.43450195e-01f, 1.12338066e-01f, -2.00451612e-01f, -5.82301617e-02f, 4.12187725e-01f, 1.33864880e-01f, 7.84078762e-02f, 1.56884283e-01f, 3.96221019e-02f, 8.00789967e-02f,
  8.66028294e-02f, 1.71941832e-01f, 2.27564529e-01f, -2.70251594e-02f, -1.36263102e-01f, -5.01195788e-02f, 3.49673964e-02f, 1.03545085e-01f, -5.91652207e-02f, 4.14769202e-02f,
  -1.10370077e-01f, 1.34325564e-01f, -1.19415205e-03f, -8.95424560e-02f, -4.53057177e-02f, -7.28185400e-02f, -2.71913595e-02f, -1.16333395e-01f, -1.49323583e-01f, -1.23973427e-04f,
  -4.13524136e-02f, -3.28138582e-02f, 2.59385079e-01f, -8.40473641e-03f, 2.15044409e-01f, 5.44044841e-03f, -8.50973427e-02f, -1.29288837e-01f, 1.41981006e-01f, -1.08145066e-01f,
  1.80111319e-01f, -8.07875171e-02f, 2.22626790e-01f, -8.15976113e-02f, -1.39441639e-01f, 1.39281526e-02f, 2.19418481e-02f, -4.53277864e-02f, -5.85326031e-02f, -5.34764975e-02f,
  -6.62164092e-02f, -1.62868544e-01f, 1.57069624e-03f, -7.64803439e-02f, 4.10078000e-03f, -6.92398921e-02f, 9.77417603e-02f, 2.38414675e-01f, -5.30101359e-02f, -9.54123512e-02f,
  -1.04150154e-01f, 9.63582322e-02f, 2.67454326e-01f, -4.49465886e-02f, 1.95218213e-02f, -3.79275903e-02f, -1.01393744e-01f, 4.60584573e-02f, -1.09151304e-01f, 1.40103266e-01f,
  2.54082561e-01f, 3.57363671e-02f, -1.28113315e-01f, -1.63414583e-01f, -4.64931771e-04f, -5.46985157e-02f, 7.14519918e-02f, 1.01747401e-01f, -1.23331167e-01f, -5.26567660e-02f,
  1.41410232e-01f, 1.56645775e-01f, -4.21001837e-02f, 2.47811124e-01f, 1.60141006e-01f, 9.11492556e-02f, -8.19256753e-02f, 2.23242268e-01f, -1.49178682e-02f, 1.31472766e-01f,
  5.05565926e-02f, -6.48562387e-02f, 1.79070354e-01f, 9.90958512e-02f, 1.46518946e-01f, 1.42429015e-02f, -6.33887127e-02f, -2.83752643e-02f, 9.60404053e-02f, 8.35083127e-02f,
  1.68735579e-01f, -7.99793303e-02f, 1.66653588e-01f, 7.07131252e-02f, -1.44454703e-01f, 1.27605245e-01f, -1.42475098e-01f, 1.99399307e-01f, -3.11471168e-02f, -4.40064631e-02f,
  -5.56607507e-02f, -3.63503769e-02f, -4.61288504e-02f, 1.45597890e-01f, 1.62281185e-01f, 1.20284967e-01f, 1.30585447e-01f, 2.97144167e-02f, -1.50209054e-01f, 9.17146355e-03f,
  1.25685334e-02f, -8.97926465e-02f, 1.60745993e-01f, 2.56104674e-03f, -8.53614807e-02f, 5.01214201e-03f, 1.32076874e-01f, 3.77205666e-03f, 6.70058886e-03f, 1.71373650e-01f,
  1.78947136e-01f, -7.93957338e-02f, -6.15160726e-02f, -4.75091599e-02f, 2.07390144e-01f, 4.54444960e-02f, 1.87566895e-02f, 2.40877420e-02f, 1.46747222e-02f, -8.32638815e-02f,
  -9.65030193e-02f, -3.89272682e-02f, -1.08581193e-01f, 9.14304890e-03f, 7.97734261e-02f, -5.34650544e-03f, -5.49902245e-02f, 5.36289774e-02f, 1.47994924e-02f, 1.38070174e-02f,
  -8.08713958e-02f, 5.40259993e-04f, 1.60748899e-01f, 4.42319848e-02f, 1.10448293e-01f, 1.55813470e-01f, 2.29346067e-01f, -2.30326205e-02f, 1.73696548e-01f, -7.03260154e-02f,
  -1.69415884e-02f, -7.73160066e-03f, 6.65624533e-03f, 6.80546165e-02f, 1.76037207e-01f, 9.65589285e-02f, -7.08098188e-02f, 7.17968494e-03f, -2.05687284e-02f, 5.29665090e-02f,
  6.73069730e-02f, -1.42612621e-01f, -1.04037315e-01f, 1.61071628e-01f, -8.37495103e-02f, -9.40455422e-02f, 1.19486406e-01f, -9.27398577e-02f, -1.88486297e-02f, -4.56377352e-03f,
  5.78253344e-02f, -1.06858075e-01f, -4.14715558e-02f, -8.10898468e-02f, -3.84160429e-02f, -1.33709144e-03f, -2.79739741e-02f, 7.85511509e-02f, 3.22740003e-02f, -6.79132789e-02f,
  -2.94775367e-02f, 1.55993074e-01f, 5.33341728e-02f, 1.31453604e-01f, -9.06158909e-02f, 5.39264306e-02f, 1.09063871e-01f, -5.34966439e-02f, -9.95239913e-02f, 1.27617568e-01f,
  -1.24503650e-01f, -4.04026508e-02f, -9.61898193e-02f, 3.35618667e-02f, -7.38624558e-02f, -4.65120599e-02f, 1.29717678e-01f, 1.15315162e-01f, 6.04452267e-02f, -3.77573702e-03f,
  1.03048094e-01f, -1.27661139e-01f, 2.10633688e-02f, -6.39731884e-02f, -4.85946424e-02f, -7.35240802e-02f, -1.36383742e-01f, 2.88797691e-02f, -1.29379436e-01f, -1.02628857e-01f,
  -4.39693071e-02f, -4.25341241e-02f, 9.56723168e-02f, 4.17031385e-02f, -3.29201519e-02f, -6.11405903e-06f, 4.79767062e-02f, 1.47964433e-01f, 2.35813763e-02f, 5.34350350e-02f,
  -1.38416797e-01f, -3.35282497e-02f, 7.91888013e-02f, 2.42664944e-02f, 1.40114743e-02f, -6.97848350e-02f, -1.51735498e-02f, 1.19102046e-01f, 5.40462472e-02f, -6.50298893e-02f,
  3.97666022e-02f, -1.51135624e-04f, -6.41774833e-02f, -1.44524872e-02f, 1.55991586e-02f, 8.82155672e-02f, 1.35085061e-01f, 1.87203404e-03f, -8.73376057e-02f, 3.18530984e-02f,
  -7.39940479e-02f, 9.04036984e-02f, -8.68236870e-02f, -7.99848363e-02f, 2.61605922e-02f, -5.92542067e-02f, 3.68244424e-02f, -8.75290483e-02f, -1.07344642e-01f, -8.94209296e-02f,
  -1.22556441e-01f, 2.46018562e-02f, 1.22074157e-01f, 1.01260252e-01f, 2.78364271e-02f, 1.12575442e-01f, 1.74664766e-01f, 3.25125456e-02f, -1.99508406e-02f, 3.95009853e-02f,
  -1.32934451e-01f, -2.98379315e-03f, -8.86746421e-02f, -6.82296753e-02f, 6.07821383e-02f, -6.92887455e-02f, 2.36168832e-01f, 1.20732889e-01f, 8.86547342e-02f, -3.26896459e-02f,
  -9.30148289e-02f, -2.35076975e-02f, -1.04705431e-01f, 1.57207381e-02f, 3.74179743e-02f, -1.17509298e-01f, -7.26928711e-02f, 9.12996661e-03f, 1.33208081e-01f, 3.84179093e-02f,
  5.86480498e-02f, 4.48535606e-02f, -1.28692314e-01f, -4.12380472e-02f, 3.02701108e-02f, 1.30640894e-01f, -6.47283047e-02f, -6.03634119e-02f, 2.16697287e-02f, -3.99888214e-03f,
  -1.32993497e-02f, -6.34178445e-02f, 3.66881490e-02f, -1.41812176e-01f, 7.94633552e-02f, -6.65805340e-02f, -1.15795389e-01f, 2.57874629e-03f, 1.20852917e-01f, 1.15378071e-02f,
  -2.48306785e-02f, 2.08941773e-01f, -8.64146501e-02f, -7.67301619e-02f, 4.76053841e-02f, -2.30987603e-03f, 3.89257148e-02f, 1.60454102e-02f, 1.44972101e-01f, -1.56286433e-01f,
  -1.49710625e-01f, -1.20806716e-01f, -6.41930252e-02f, 5.34585901e-02f, 1.80332243e-01f, -1.91010088e-01f, 1.36527926e-01f, 5.17149866e-02f, -1.26240607e-02f, 2.29208153e-02f,
  1.30058929e-01f, 1.08575681e-03f, -6.05325401e-02f, 1.56696334e-01f, 2.61733919e-01f, -2.00216576e-01f, 1.79726601e-01f, 1.46784931e-01f, -3.51057053e-02f, 1.99152902e-01f,
  -2.05856413e-02f, -5.97552070e-03f, 1.72659885e-02f, 2.18063846e-01f, 8.97019431e-02f, 3.04324590e-02f, 6.23839125e-02f, -1.16270833e-01f, -1.43976882e-01f, 9.52310637e-02f,
  -1.15638167e-01f, 3.54801387e-01f, -4.13783826e-02f, 5.52858151e-02f, -1.91028435e-02f, 4.33125831e-02f, 1.75941929e-01f, 1.15330257e-01f, -1.02694690e-01f, 1.59182604e-02f,
  -9.35466811e-02f, 1.02847703e-01f, 2.15669628e-02f, 2.01069102e-01f, 1.23835206e-01f, 5.00473641e-02f, 4.06684317e-02f, -8.10294524e-02f, -8.21224526e-02f, 8.41654316e-02f,
  -1.85561493e-01f, 1.55737117e-01f, 4.93643247e-02f, 6.67589307e-02f, -6.24128757e-03f, 1.35851381e-02f, -9.88821238e-02f, 5.97415082e-02f, -3.13758850e-02f, -6.21473640e-02f,
  4.15149927e-02f, 9.85296145e-02f, 1.26579687e-01f, -2.74000857e-02f, -1.23468578e-01f, 3.68907265e-02f, -1.99236706e-01f, 5.03090285e-02f, 3.36081199e-02f, 6.18005618e-02f,
  2.02605557e-02f, -2.54075397e-02f, -7.67560303e-02f, 3.01399752e-02f, -8.67565274e-02f, 8.08006674e-02f, -5.11461869e-02f, 3.97407040e-02f, 3.40214558e-02f, -9.65949744e-02f,
  1.63480714e-02f, 5.00849895e-02f, -4.88823093e-02f, 1.01334743e-01f, 1.53117523e-01f, -3.84264737e-02f, -3.26214023e-02f, 1.66109353e-01f, -8.31973553e-02f, -4.25321572e-02f,
  1.31934032e-01f, 4.16367650e-02f, 5.41076958e-02f, 4.70593795e-02f, -1.08688116e-01f, 1.21861815e-01f, -3.71099226e-02f, 3.57999504e-02f, -7.27409869e-02f, -7.20875040e-02f,
  5.69888167e-02f, -1.45871818e-01f, 2.73827463e-02f, 5.59294820e-02f, 3.39699127e-02f, 1.24527231e-01f, 2.88257543e-02f, 1.06033385e-01f, 1.24104038e-01f, 1.15214474e-02f,
  -3.90590653e-02f, 1.39626861e-01f, -1.17508233e-01f, -7.89928809e-02f, 4.04229388e-02f, 8.81755948e-02f, 3.16513181e-02f, 5.49515560e-02f, -4.49811928e-02f, -1.32118836e-02f,
  -4.30375114e-02f, 2.93550361e-02f, -4.75859568e-02f, -1.04998596e-01f, 2.29706839e-01f, 2.06742227e-01f, 4.87692393e-02f, 8.63600895e-02f, -2.26903018e-02f, 1.12823755e-01f,
  9.11709443e-02f, 1.17333554e-01f, 2.90718496e-01f, -6.91265240e-02f, 1.44403845e-01f, 1.50400087e-01f, 1.58355758e-01f, -9.61788520e-02f, 2.27885351e-01f, 1.85745731e-01f,
  4.40659225e-02f, 1.40756235e-01f, -6.76908270e-02f, 8.24388340e-02f, -9.35500264e-02f, -6.37310669e-02f, -7.17709735e-02f, 1.84621990e-01f, -5.42513020e-02f, 1.61156774e-01f,
  -1.67398285e-02f, 1.02503605e-01f, -7.73391128e-02f, 6.61231428e-02f, -8.66313502e-02f, -5.13304630e-03f, -1.58404142e-01f, 1.00130141e-01f, -1.07978210e-01f, 1.41837955e-01f,
  6.25622422e-02f, 2.00108409e-01f, 2.34954312e-01f, -2.39959098e-02f, 1.98547184e-01f, -9.05594528e-02f, -1.53204516e-01f, 2.29772236e-02f, 5.46193607e-02f, 1.09318439e-02f,
  8.33675638e-02f, -5.10615949e-03f, -6.88215494e-02f, 1.02424093e-01f, -1.28940135e-01f, -1.40568055e-02f, -1.91500336e-02f, 5.85320443e-02f, -2.29959395e-02f, -2.16270424e-02f,
  -1.10720344e-01f, 1.10597946e-01f, 1.46331973e-02f, -1.23324275e-01f, 1.09860823e-01f, 2.31111825e-01f, 1.60942134e-02f, 1.53138814e-02f, 3.40388864e-02f, -8.46003741e-02f,
  9.10968632e-02f, 1.52200088e-01f, 9.42850038e-02f, -1.12681873e-01f, 9.73561481e-02f, 3.74555662e-02f, -1.93901524e-01f, -2.28572562e-01f, -2.59929709e-03f, -1.51178449e-01f,
  -2.82758083e-02f, 7.03573152e-02f, 2.39259258e-01f, 1.74462885e-01f, -7.14737624e-02f, -1.08445078e-01f, -4.81125265e-02f, 1.16938844e-01f, 7.92458951e-02f, 4.96997945e-02f,
  3.19325924e-02f, -1.78290512e-02f, 1.21148162e-01f, 2.30495885e-01f, 2.47672256e-02f, -2.19679940e-02f, -7.19581842e-02f, 1.28223255e-01f, -1.17132910e-01f, -2.76251808e-02f,
  8.21441179e-04f, -3.53132077e-02f, -9.90406647e-02f, -5.91927692e-02f, 3.99811044e-02f, 2.43873432e-01f, 3.85245867e-02f, -1.13958893e-02f, -9.17769782e-03f, 3.36410403e-02f,
  -3.81437056e-02f, 2.38093548e-02f, -1.51768336e-02f, 1.23410150e-01f, 1.01472348e-01f, -7.44298249e-02f, -4.12801765e-02f, 1.07312068e-01f, -7.25392997e-02f, -1.12536930e-01f,
  4.78720404e-02f, -9.06674489e-02f, -9.91345122e-02f, -1.00940332e-01f, -9.24831107e-02f, 1.12187982e-01f, 1.95067689e-01f, 2.64819171e-02f, 6.64336316e-04f, 1.64497986e-01f,
  8.78039151e-02f, 1.12709045e-01f, 9.55541879e-02f, -2.81430036e-02f, 1.08913854e-01f, -1.45443724e-02f, 1.97498724e-02f, -7.24438056e-02f, -5.61238974e-02f, -2.62274668e-02f,
  1.12978600e-01f, -7.33007938e-02f, -2.30907444e-02f, 6.06613122e-02f, -1.82752088e-02f, -3.63471471e-02f, 3.92645225e-02f, -2.55093705e-02f, 6.06946424e-02f, -1.25021767e-02f,
  -1.31718472e-01f, -4.08319943e-02f, 1.35721385e-01f, 3.29090953e-02f, 9.90742669e-02f, -1.75329261e-02f, -1.99646633e-02f, 6.22104257e-02f, -2.10382026e-02f, 6.15576506e-02f,
  6.70359358e-02f, -2.00082250e-02f, 1.71375964e-02f, -5.28242849e-02f, -1.04966521e-01f, 8.49969909e-02f, -1.27416342e-01f, -1.99692585e-02f, -3.98689226e-05f, 2.29356792e-02f,
  8.36614817e-02f, -9.52751040e-02f, -1.00492127e-01f, -8.08713213e-02f, -7.07160607e-02f, 1.08116018e-02f, 7.28138015e-02f, 1.48536459e-01f, -4.66510355e-02f, -1.16346210e-01f,
  -8.51376355e-02f, -9.96551961e-02f, -1.52036045e-02f, -1.45840928e-01f, -4.45241146e-02f, -7.11328909e-02f, -1.36265486e-01f, 1.56669524e-02f, 6.27399161e-02f, -2.05004141e-02f,
  -1.01956360e-01f, 9.00627747e-02f, -3.97947878e-02f, -6.97836503e-02f, -1.13505330e-02f, -7.84857571e-03f, 7.28358701e-02f, 1.13890827e-01f, -2.84957476e-02f, -8.00263733e-02f,
  3.20605538e-03f, 3.03479959e-03f, -5.79592921e-02f, 8.54982287e-02f, 1.47101089e-01f, -2.62917913e-02f, 1.08980745e-01f, -2.39719376e-02f, -1.00009888e-02f, -6.64121360e-02f,
  -4.57716919e-02f, 1.32357210e-01f, 1.76503062e-01f, -1.19093038e-01f, 7.44630955e-03f, -8.72193277e-02f, -7.34599009e-02f, 6.54737577e-02f, -9.78233591e-02f, 1.30184710e-01f,
  -6.62524924e-02f, 1.15124792e-01f, -6.11975566e-02f, -6.55997843e-02f, -8.39292258e-02f, -1.17389582e-01f, -6.85499907e-02f, 3.33933416e-03f, -8.76795948e-02f, 1.32574335e-01f,
  -3.20888683e-02f, 2.01800466e-02f, 7.95572624e-02f, -9.47287530e-02f, 1.20239139e-01f, 4.95579578e-02f, 5.16594015e-02f, -2.41228845e-02f, -8.37812840e-04f, 8.72986689e-02f,
  3.19408067e-02f, -8.00852031e-02f, -1.07840680e-01f, 1.38358325e-01f, 3.11096832e-02f, -8.36316198e-02f, -3.35030258e-02f, -4.89490665e-03f, 6.01504631e-02f, -4.34943736e-02f,
  -1.26294643e-01f, -3.47158723e-02f, 1.16376951e-02f, -1.33205920e-01f, -1.25394836e-01f, 7.36822560e-02f, -9.93556380e-02f, 2.15891991e-02f, 1.01461627e-01f, 7.20046833e-02f,
  -2.88989414e-02f, -9.28870365e-02f, -7.52488300e-02f, 6.37321267e-03f, 1.52289316e-01f, -1.21521018e-01f, 9.62208118e-03f, -9.01237950e-02f, -6.16607741e-02f, 4.17664535e-02f,
  -9.95049812e-03f, -1.13604598e-01f, -1.76919419e-02f, -3.06468233e-02f, 8.16753954e-02f, 7.99998045e-02f, -4.50086705e-02f, -7.52404109e-02f, 1.04417488e-01f, 1.37761489e-01f,
  8.19524974e-02f, -1.06649153e-01f, 6.68319389e-02f, -8.76753628e-02f, 2.24824354e-01f, 1.66279092e-01f, 1.26652077e-01f, -2.15226989e-02f, -9.43980273e-03f, -8.22483795e-04f,
  -7.44765550e-02f, 5.09588495e-02f, -1.12884387e-01f, -1.53499946e-01f, -6.47255257e-02f, -5.87352663e-02f, -3.79362004e-03f, 1.04996644e-01f, 7.88191929e-02f, -1.00008340e-03f,
  -1.08584471e-01f, 7.13592470e-02f, 2.94467174e-02f, 6.34562671e-02f, -4.35529873e-02f, -4.57333913e-03f, -5.54729300e-03f, 1.11870795e-01f, -2.26259269e-02f, 2.85095908e-02f,
  -2.66422369e-02f, -1.48602009e-01f, -6.20515570e-02f, 2.94408910e-02f, 6.18401691e-02f, 1.15258902e-01f, -3.62768099e-02f, 1.70262456e-02f, 5.57553843e-02f, 9.10505429e-02f,
  4.48491648e-02f, -8.25256631e-02f, -1.19180247e-01f, 3.52348350e-02f, -7.20871687e-02f, -7.23725855e-02f, 1.33357555e-01f, 4.45546471e-02f, 8.93871635e-02f, 1.01265997e-01f,
  1.22514181e-01f, 7.74046555e-02f, -5.63671626e-03f, -8.63621533e-02f, 1.32955819e-01f, 1.10654816e-01f, 5.40763102e-02f, 8.23326781e-02f, 7.95390904e-02f, 6.35076687e-02f,
  7.85481408e-02f, 1.26247630e-01f, -2.79053319e-02f, -1.31497651e-01f, 2.08564401e-02f, 1.06094658e-01f, -7.10969046e-02f, -8.78572538e-02f, -3.33228670e-02f, -1.04138680e-01f,
  1.10542595e-01f, 1.28579400e-02f, 7.63994157e-02f, 1.60899907e-01f, -2.54304484e-02f, 1.49040341e-01f, 1.75070673e-01f, -4.62686531e-02f, 4.24247090e-04f, 2.22910374e-01f,
  -7.37007416e-04f, -2.16513406e-02f, 4.91228402e-02f, -2.03269478e-02f, 2.62444876e-02f, -5.88442869e-02f, -1.24639748e-02f, 3.66837084e-02f, -4.72836010e-03f, -7.22829700e-02f,
  -1.12296596e-01f, 1.71239544e-02f, 1.50814861e-01f, -1.16469391e-01f, 4.09836061e-02f, 1.80375874e-01f, -1.17083117e-01f, 1.54592562e-02f, 1.81081489e-01f, 1.96719579e-02f,
  1.16744839e-01f, 1.10776417e-01f, -4.92556766e-02f, -2.39777863e-02f, -9.69899446e-02f, -7.06939846e-02f, 1.75629765e-01f, -9.58000124e-02f, 2.82984167e-01f, 2.59724706e-01f,
  2.61151791e-01f, -2.89795324e-02f, 2.16751993e-01f, 9.48673412e-02f, 6.89214701e-03f, 1.60625905e-01f, -1.60914317e-01f, -3.68519098e-01f, -5.12621962e-02f, 2.90526927e-01f,
  -2.00309500e-01f, 2.58696407e-01f, -8.40285271e-02f, 6.53793942e-03f, -9.71863493e-02f, -2.06500459e-02f, 3.27535361e-01f, 5.55897206e-02f, -6.12023957e-02f, 4.11458053e-02f,
  1.90152422e-01f, -7.20809996e-02f, 3.71618569e-02f, 3.86071764e-02f, 5.83268516e-02f, 6.42617047e-02f, 6.93079680e-02f, 3.51083204e-02f, -4.50330488e-02f, -9.36052352e-02f,
  -1.94322199e-01f, -9.46475193e-02f, 2.01288536e-01f, 2.88295060e-01f, -1.31622031e-01f, -1.77640989e-01f, -4.77905087e-02f, 1.20073564e-01f, 6.21646166e-01f, 3.89654011e-01f,
  6.47214428e-02f, 1.09197572e-01f, 1.08250134e-01f, -1.29153840e-02f, 5.16957827e-02f, 1.54417515e-01f, 5.64461481e-03f, 1.44539788e-01f, 2.00424120e-01f, -9.17950273e-02f,
  1.37692109e-01f, -1.76348656e-01f, -1.89907357e-01f, -1.22249536e-02f, 5.66838719e-02f, 9.73373428e-02f, -5.86215332e-02f, -8.07918906e-02f, 2.19983101e-01f, -6.74504414e-03f,
  -1.70431376e-01f, -1.27195150e-01f, 3.49223055e-02f, -9.30467695e-02f, -2.04592943e-02f, -1.05678163e-01f, -3.33319791e-02f, -2.15703864e-02f, -4.55816975e-03f, 1.20048054e-01f,
  1.86787188e-01f, -8.21686685e-02f, 8.01599324e-02f, 2.71116365e-02f, 1.08378567e-01f, -1.19632944e-01f, 6.24266118e-02f, 6.30305484e-02f, 4.25363816e-02f, -1.07471563e-01f,
  2.47779390e-04f, 9.90395471e-02f, 1.89136136e-02f, -2.08550654e-02f, -5.99365588e-03f, 1.59142949e-02f, 1.08964026e-01f, 3.58494720e-03f, -5.86134009e-02f, 1.01867668e-01f,
  1.20314665e-01f, 3.30032222e-02f, -3.29615246e-03f, -7.84676597e-02f, 2.49361116e-02f, 1.02064777e-02f, 5.41934185e-02f, -2.80847331e-03f, 2.87799072e-02f, 3.61220501e-02f,
  -2.49627791e-02f, 4.04655859e-02f, 2.88353622e-01f, 7.66106397e-02f, 5.81421182e-02f, -7.96624646e-02f, -8.08399320e-02f, 1.30965352e-01f, -1.23890974e-01f, 1.50390595e-01f,
  1.59188341e-02f, 4.08585072e-02f, 1.54743373e-01f, -8.69079828e-02f, -4.55940105e-02f, -2.53665261e-02f, -1.72788262e-01f, -7.58352578e-02f, -8.19103047e-02f, -9.64889023e-03f,
  -1.31901130e-01f, -4.76992805e-04f, 1.70579627e-01f, 1.63474858e-01f, -6.62813010e-03f, 1.25494272e-01f, -3.24169360e-02f, 7.39100054e-02f, 1.37253121e-01f, 9.44768265e-03f,
  2.97839902e-02f, 7.31923208e-02f, 9.02980119e-02f, 1.90226864e-02f, -8.13036337e-02f, 1.40818749e-02f, 1.39021605e-01f, -4.70427908e-02f, -8.70216489e-02f, -1.69366673e-01f,
  7.80019313e-02f, -3.28163281e-02f, 1.23170651e-01f, -1.04526728e-01f, -5.54096475e-02f, 3.32082286e-02f, 4.25650515e-02f, 7.88826570e-02f, -3.86980660e-02f, 1.89707652e-01f,
  7.86703378e-02f, 5.44074811e-02f, -8.38236045e-03f, 1.72489226e-01f, 9.49092358e-02f, -6.35101125e-02f, -1.03253290e-01f, -2.11736304e-03f, 1.94300517e-01f, -6.33592252e-03f,
  -2.61675455e-02f, 1.78107560e-01f, 8.02659541e-02f, 2.90387659e-03f, 5.66003993e-02f, 1.45902127e-01f, 5.74227087e-02f, -7.37114102e-02f, -1.18623555e-01f, 1.35284603e-01f,
  2.24475935e-02f, 1.24420948e-01f, -1.04047239e-01f, 2.11654144e-04f, 3.46962474e-02f, -4.78217229e-02f, -3.92722040e-02f, -9.92101133e-02f, 2.37520728e-02f, 1.33277416e-01f,
  -1.63589492e-02f, -8.19850415e-02f, -1.20849319e-01f, -1.34098485e-01f, -8.33899230e-02f, 4.75206859e-02f, -4.90079783e-02f, 1.23052791e-01f, -4.66180369e-02f, -9.02466625e-02f,
  1.95378233e-02f, 7.62560070e-02f, -8.16327035e-02f, -5.02152294e-02f, 2.21721888e-01f, 1.00650145e-02f, 4.89696898e-02f, 2.16769516e-01f, -2.09735706e-01f, -2.88221329e-01f,
  -1.98069587e-02f, -1.29949693e-02f, 1.44962773e-01f, 1.46524727e-01f, 1.29658729e-01f, 8.13418180e-02f, -3.38650569e-02f, 1.99477691e-02f, 3.06687921e-01f, -9.20037180e-02f,
  1.55839428e-01f, 4.36845468e-03f, -1.65078044e-02f, -1.86410338e-01f, -5.78900352e-02f, 1.65856570e-01f, 1.11478634e-01f, -1.60121828e-01f, -7.07159638e-02f, 1.15419485e-01f,
  -5.31550273e-02f, -6.58518076e-02f, -3.11407410e-02f, -2.52925139e-02f, -1.16790742e-01f, 9.79822129e-02f, 2.31318213e-02f, 3.91468890e-02f, 4.47841547e-03f, -1.53063551e-01f,
  -3.91544122e-03f, 1.94552243e-01f, 7.68420920e-02f, -7.37609938e-02f, 1.96609925e-02f, 2.07688704e-01f, 1.03674911e-01f, 2.60752261e-01f, 2.30742455e-01f, -1.38723403e-01f,
  3.42695564e-02f, 3.49459022e-01f, 6.80202469e-02f, -6.83889464e-02f, -4.68184706e-03f, -4.38552052e-02f, 3.65854710e-01f, 9.02869627e-02f, 8.44990313e-02f, -7.72264972e-02f,
  1.07811667e-01f, 1.60255060e-01f, 7.97908232e-02f, -4.66665253e-02f, -3.68051678e-02f, -4.54546772e-02f, -9.10116918e-03f, -9.26797912e-02f, -3.60071808e-02f, -6.75697299e-03f,
  -1.67230606e-01f, -1.63061619e-01f, -1.81244919e-03f, 8.84962901e-02f, -6.60435259e-02f, -1.00905389e-01f, 8.89793932e-02f, -1.05931729e-01f, 3.55187096e-02f, 1.73411831e-01f,
  1.16803750e-01f, 9.01180729e-02f, -6.32884204e-02f, -2.75515690e-02f, 1.75123677e-01f, 1.76293701e-01f, 3.82376425e-02f, -5.51273152e-02f, 1.14168018e-01f, -9.49793532e-02f,
  -2.51212455e-02f, 5.89589924e-02f, 3.18313041e-03f, -7.05617964e-02f, -1.25255257e-01f, -7.03477114e-02f, -8.14861208e-02f, 1.66650027e-01f, 5.11037149e-02f, -1.30996987e-01f,
  9.82591659e-02f, -8.36911649e-02f, 1.18444875e-01f, -8.28004032e-02f, -1.11342929e-01f, -1.16157979e-01f, 2.26269647e-01f, -7.29688108e-02f, -5.18392362e-02f, -1.10120229e-01f,
  4.18050066e-02f, -1.33549154e-01f, -1.64251149e-01f, 8.74945521e-03f, -4.05473448e-02f, -1.41748431e-04f, -1.93065349e-02f, -3.94847803e-02f, -3.31048556e-02f, -5.40232696e-02f,
  7.78819248e-02f, 8.09571818e-02f, -4.04891046e-03f, 5.82810342e-02f, 3.50924805e-02f, 2.17305925e-02f, 9.42307860e-02f, 7.31161609e-02f, -1.25919253e-01f, 1.95353758e-02f,
  1.15789481e-01f, 7.04227611e-02f, -2.11369116e-02f, 2.13727653e-01f, -1.18476763e-01f, -2.96830684e-01f, -6.09736294e-02f, 6.49668798e-02f, -1.84946448e-01f, -1.48843572e-01f,
  -6.13472387e-02f, -2.02176124e-01f, -6.88313553e-03f, -1.16086183e-02f, 4.12167795e-02f, -9.83018503e-02f, 3.84817086e-02f, -1.19815893e-01f, 1.66245684e-01f, 2.55838603e-01f,
  -3.53830494e-02f, 1.27927616e-01f, 1.72799110e-01f, -1.31786570e-01f, -1.21429667e-01f, -3.71185467e-02f, 1.15387574e-01f, 6.38779998e-02f, -9.65394750e-02f, -5.44107407e-02f,
  4.81742024e-02f, -7.19447806e-02f, -2.42701080e-02f, 5.30031435e-02f, 9.02184397e-02f, -1.18087441e-01f, -2.49229167e-02f, 1.53121248e-01f, 5.94566576e-02f, -6.04275241e-02f,
  3.38589668e-01f, 2.08928362e-02f, 2.71325093e-02f, -1.36367694e-01f, 1.05975591e-01f, -7.85293654e-02f, 8.39591101e-02f, 1.81254037e-02f, 3.36953774e-02f, 4.34247479e-02f,
  1.56564265e-01f, -2.88005695e-02f, 3.19801271e-02f, 1.26177073e-01f, -1.25274248e-02f, -3.50879543e-02f, -5.88207953e-02f, 2.00169235e-01f, -1.23420015e-01f, -1.90250933e-01f,
  1.25536293e-01f, 1.28911316e-01f, 4.71731611e-02f, 1.56942070e-01f, -5.73090129e-02f, -4.17657942e-02f, 1.49883002e-01f, 4.67249518e-03f, 4.13533933e-02f, 8.13689008e-02f,
  4.04261723e-02f, 1.74935795e-02f, -9.65764597e-02f, -6.26337109e-03f, -6.97693378e-02f, -7.98566118e-02f, 8.45980719e-02f, 7.75270239e-02f, -2.78615486e-02f, 7.16392621e-02f,
  2.82645561e-02f, -7.62233958e-02f, -2.55538356e-02f, 2.05314621e-01f, -1.46302477e-01f, 2.21496254e-01f, 6.49472252e-02f, 9.58262086e-02f, 8.19759369e-02f, -1.61104277e-01f,
  -2.72160117e-02f, -4.88163531e-02f, 2.33280491e-02f, -9.67395492e-03f, 2.84467824e-02f, -5.99755719e-03f, -6.09251373e-02f, -3.61082368e-02f, 3.12683061e-02f, -1.19508244e-01f,
  1.89186871e-01f, -1.90399941e-02f, 5.19160181e-02f, -1.35037541e-01f, 2.48685911e-01f, 1.23810641e-01f, -5.03621958e-02f, 1.24919042e-01f, 2.13671289e-02f, 8.15935805e-02f,
  -6.10990897e-02f, 1.13655590e-01f, 1.27992600e-01f, -8.57185498e-02f, 2.21587531e-02f, 1.05454586e-01f, -1.60962995e-02f, 2.06029741e-03f, -7.46307522e-02f, 7.48542231e-03f,
  -1.45447150e-01f, -1.52414339e-02f, 3.86677161e-02f, 1.04588188e-01f, -7.27835894e-02f, 7.38152340e-02f, 1.54337391e-01f, 1.66581675e-01f, -1.13387384e-01f, 9.02824625e-02f,
  8.45495686e-02f, 9.93810147e-02f, -2.74960428e-01f, 1.51020391e-02f, 1.71563566e-01f, 1.87347472e-01f, 1.34729490e-01f, 2.08126023e-01f, 1.74906719e-02f, -1.05778605e-01f,
  -1.65765230e-02f, -1.26937076e-01f, 2.83508241e-01f, 1.02929778e-01f, 3.75582138e-03f, 5.52403107e-02f, -7.90152922e-02f, 5.91937676e-02f, -1.09095030e-01f, 9.38351452e-02f,
  8.02851468e-03f, 1.41015530e-01f, -1.24451943e-01f, 4.04708982e-02f, -2.20779963e-02f, -4.72401530e-02f, 2.75953803e-02f, -1.83720980e-02f, 6.40417635e-02f, -3.07207406e-02f,
  -3.89301218e-02f, 3.02728489e-02f, 4.04137373e-02f, -1.26372695e-01f, 1.24565862e-01f, -1.38954207e-01f, 4.55834828e-02f, -7.74700716e-02f, -9.84578058e-02f, 3.44499610e-02f,
  2.37312857e-02f, -1.87913943e-02f, 1.48562774e-01f, 2.45250970e-01f, 5.38463145e-02f, -1.09991342e-01f, -8.64942372e-02f, 4.36729230e-02f, -1.17248051e-01f, 1.75198987e-01f,
  2.35215370e-02f, 8.81558731e-02f, 9.97947250e-03f, -9.87236425e-02f, -3.08340155e-02f, 1.27303302e-01f, 1.03696153e-01f, 2.44517967e-01f, 1.31197259e-01f, -2.56302301e-03f,
  1.73936456e-01f, 3.07166249e-01f, 2.34610051e-01f, 2.60302335e-01f, 3.80305767e-01f, 1.80249631e-01f, -6.09081201e-02f, 5.52586690e-02f, -2.80314803e-01f, -3.02187707e-02f,
  -1.28733087e-02f, -4.96888766e-03f, -3.71158496e-02f, 3.56008947e-01f, 5.43538714e-03f, 1.07324935e-01f, 3.68447712e-04f, -1.71545550e-01f, -1.53618053e-01f, 1.86259076e-01f,
  2.31016632e-02f, -1.08299941e-01f, -2.03624573e-02f, -3.18071216e-01f, 3.59054878e-02f, 2.74018422e-02f, -1.61792129e-01f, -3.46712098e-02f, -7.54409954e-02f, 1.62867948e-01f,
  -9.40053388e-02f, -1.48110732e-01f, 1.96660042e-01f, -2.44293392e-01f, -1.11734822e-01f, -1.21770822e-01f, -6.88401088e-02f, 2.80769914e-02f, -2.63180807e-02f, 5.90818301e-02f,
  9.52185243e-02f, 8.68515074e-02f, -9.03915688e-02f, -1.65664107e-01f, 2.04114452e-01f, -1.43011585e-01f, 1.25637636e-01f, -2.74664372e-01f, -1.17569976e-01f, -1.71309754e-01f,
  -2.41577208e-01f, 3.44418198e-01f, 1.24702320e-01f, 2.62719393e-02f, 1.85442582e-01f, -1.81298926e-01f, 8.66358876e-02f, 4.08850983e-02f, 1.05754204e-01f, -8.08947012e-02f,
  9.80869010e-02f, -1.00332499e-01f, -2.26585381e-02f, -1.14614978e-01f, 1.94506973e-01f, -9.98379663e-03f, 6.89437091e-02f, 3.30081657e-02f, -6.43346533e-02f, 1.81911483e-01f,
  -2.01505855e-01f, 1.04584947e-01f, 9.40013975e-02f, 1.17662713e-01f, 2.06968814e-01f, 9.14651006e-02f, -1.03065006e-01f, -1.59523666e-01f, -6.06509037e-02f, -8.05239230e-02f,
  1.78335652e-01f, -2.04714015e-02f, -8.43432266e-03f, -3.59763601e-03f, -5.02207205e-02f, 4.89731766e-02f, -4.83728535e-02f, 2.22094461e-01f, -8.75449181e-02f, 1.32855669e-01f,
  -1.50355726e-01f, -4.37987633e-02f, -1.82320122e-02f, 2.02195540e-01f, -9.06104743e-02f, -6.96160248e-04f, 5.28263710e-02f, -1.50818005e-02f, 5.01064956e-02f, 8.71196538e-02f,
  1.86342627e-01f, 7.44333491e-02f, 1.90502301e-01f, -1.17676444e-01f, -3.40078361e-02f, -5.46260551e-02f, 2.27399796e-01f, 1.08649164e-01f, -1.69514567e-01f, -7.30766058e-02f,
  -1.29644439e-01f, 1.65506333e-01f, -6.73032105e-02f, -4.76913676e-02f, 9.86168012e-02f, 1.49560943e-01f, 3.59576233e-02f, 7.89856240e-02f, 5.06418683e-02f, 1.28657445e-01f,
  7.12973550e-02f, -1.28711954e-01f, 5.94048351e-02f, -5.52706793e-02f, -7.03244209e-02f, -3.77437323e-02f, -3.20737101e-02f, -6.62925318e-02f, 4.41713147e-02f, -1.61267370e-02f,
  1.11454159e-01f, -2.42903195e-02f, 9.85042900e-02f, -4.84368019e-02f, 1.13995217e-01f, -1.48619309e-01f, 7.52800032e-02f, 3.98389176e-02f, -7.63673410e-02f, -1.54031813e-01f,
  -5.10697179e-02f, -7.58626685e-02f, 2.46402532e-01f, 1.26629964e-01f, -2.80642007e-02f, 1.34089645e-02f, 2.73410659e-02f, 9.65387598e-02f, 6.52527958e-02f, -1.95901887e-03f,
  -2.54160576e-02f, 1.29246190e-01f, -6.09615333e-02f, 7.50020565e-03f, 2.44686790e-02f, 8.94614086e-02f, 8.83806422e-02f, -7.52333179e-02f, -3.41162607e-02f, 1.85591951e-02f,
  1.16004325e-01f, 2.66226172e-01f, 1.20007351e-01f, -8.66222978e-02f, 2.47825962e-02f, 9.68880430e-02f, 1.73965797e-01f, -5.02050556e-02f, -3.68478559e-02f, -7.88300335e-02f,
  2.69516706e-01f, 1.87207907e-01f, -5.69922552e-02f, -2.50047632e-02f, 3.94481421e-02f, -1.14474185e-01f, -2.63191271e-03f, -5.24984635e-02f, 3.84886600e-02f, -1.31277561e-01f,
  1.56210318e-01f, 7.71046355e-02f, -3.95612977e-02f, 1.05950668e-01f, -1.10022016e-01f, 1.23819366e-01f, 9.99538600e-02f, 1.51440995e-02f, 6.21918403e-02f, 1.59713522e-01f,
  -6.06589876e-02f, 7.98611864e-02f, 1.32734045e-01f, 1.47249982e-01f, 1.68995470e-01f, 2.85793930e-01f, 1.40218988e-01f, 7.12961927e-02f, -3.23130995e-01f, 8.19868818e-02f,
  3.61714184e-01f, 1.37138382e-01f, 1.81353837e-01f, 1.91422209e-01f, -1.16736107e-02f, -2.41888538e-02f, 2.11662799e-02f, 9.82863735e-03f, 1.02914535e-01f, 8.11304990e-03f,
  -8.73081610e-02f, -1.33430973e-01f, 6.52700290e-02f, 1.43804699e-01f, -4.38171923e-02f, 2.74160236e-01f, -1.64033230e-02f, -8.63150582e-02f, 1.03691788e-02f, 2.94970036e-01f,
  -1.67772472e-01f, 1.40278814e-02f, -1.51782870e-01f, -1.42656535e-01f, 1.24372877e-02f, -1.07579395e-01f, 4.62607183e-02f, 2.60170132e-01f, -3.10097523e-02f, -6.11637905e-02f,
  9.01348740e-02f, -1.52751818e-01f, 1.02130756e-01f, 3.63221094e-02f, -6.35673106e-02f, 6.35032877e-02f, 2.57273554e-04f, 5.59037104e-02f, 1.33008584e-01f, 3.99684049e-02f,
  -1.28971323e-01f, -3.06768026e-02f, 2.99732969e-03f, -1.50425926e-01f, 1.76616758e-02f, -8.46822932e-02f, -9.32026133e-02f, -9.33409035e-02f, -1.27817303e-01f, -1.26255289e-01f,
  -1.30465254e-01f, 3.26033332e-03f, -1.25531182e-01f, -1.33384829e-02f, 3.38722467e-02f, -1.11275494e-01f, 2.06193686e-01f, 1.96259513e-01f, 8.72824937e-02f, -1.48571953e-01f,
  2.12057903e-01f, -5.04832305e-02f, -1.13565490e-01f, -9.71005931e-02f, 1.07087389e-01f, 2.35159323e-02f, -6.74548447e-02f, 1.81278318e-01f, 8.18566680e-02f, 1.02176011e-01f,
  3.89433503e-02f, 1.04151547e-01f, -3.50482166e-02f, 1.24991618e-01f, 4.61713821e-02f, 1.22493610e-01f, -6.14294298e-02f, -2.98966169e-02f, 5.49168512e-02f, -9.09188017e-02f,
  5.05944528e-02f, -1.29840538e-01f, 1.95956498e-01f, 7.18242303e-03f, -1.19901091e-01f, -1.15158200e-01f, -7.03820586e-02f, 1.01902492e-01f, -1.05421685e-01f, -9.30599198e-02f,
  -3.83431949e-02f, 1.78407267e-01f, -1.07135758e-01f, -7.93487504e-02f, -1.49231151e-01f, 7.07763955e-02f, 2.77721524e-01f, 5.13343029e-02f, 4.31854390e-02f, 1.16059579e-01f,
  1.95225611e-01f, -4.17793803e-02f, 2.17709884e-01f, -6.41391799e-02f, -1.14374071e-01f, -1.35745615e-01f, -1.07315485e-03f, -5.69808371e-02f, -1.11885935e-01f, -1.16291866e-01f,
  -5.84191084e-02f, 1.48271427e-01f, -1.24668680e-01f, 5.25203794e-02f, 1.04520731e-01f, 5.01884846e-04f, 1.38439327e-01f, -9.63934511e-02f, -4.10527214e-02f, -1.10006273e-01f,
  -9.24748480e-02f, 3.88551205e-02f, 2.00103804e-01f, -1.58185810e-01f, -8.04567784e-02f, 3.16115394e-02f, -5.77186719e-02f, 5.55791929e-02f, 8.28694403e-02f, 7.29808435e-02f,
  -1.24837890e-01f, 7.81310797e-02f, -1.30268738e-01f, 1.43154904e-01f, 7.94530436e-02f, 9.99269187e-02f, 1.43422961e-01f, 8.17347541e-02f, 2.24459171e-01f, -1.46454275e-01f,
  1.30171433e-01f, -5.93474917e-02f, 1.06140345e-01f, 1.34560075e-02f, 2.31336951e-01f, -6.20740429e-02f, 3.33050974e-02f, 8.46655592e-02f, -3.94114380e-04f, 6.64920509e-02f,
  9.98215303e-02f, 6.76973090e-02f, -8.67651403e-02f, 9.11254287e-02f, -4.18345891e-02f, 2.73509249e-02f, -8.30807686e-02f, 1.31813943e-01f, 4.55791168e-02f, 1.38369948e-01f,
  1.55619875e-01f, 6.41961396e-02f, -2.12118030e-01f, -1.05631299e-01f, 1.33864686e-01f, 7.37556070e-02f, 6.56356243e-03f, 2.61428654e-01f, 3.11570168e-01f, -5.73848858e-02f,
  1.10838883e-01f, -1.64631739e-01f, -7.29489401e-02f, 2.30545789e-01f, -7.30931088e-02f, 1.09781504e-01f, 5.39494082e-02f, 1.86003745e-02f, -1.16906695e-01f, 1.09544098e-02f,
  -4.95502800e-02f, -3.90501320e-03f, -8.19596276e-02f, -1.09896444e-01f, 1.38724402e-01f, 1.73882261e-01f, 5.49546294e-02f, 1.19135454e-01f, 1.08703770e-01f, 1.61235526e-01f,
  -2.07378075e-01f, -2.61310816e-01f, -2.42461190e-01f, 1.03977293e-01f, -3.61362189e-01f, -2.94938415e-01f, 2.38903001e-01f, 1.62035868e-01f, -3.65572236e-02f, 7.01531842e-02f,
  -6.18400760e-02f, -9.77099594e-03f, 2.56020948e-02f, 4.52832207e-02f, 2.40123749e-01f, -3.47404246e-04f, 2.03086227e-01f, -2.38853544e-01f, 3.71057898e-01f, 1.94451451e-01f,
  -1.33567140e-01f, 2.17314735e-02f, -5.72978370e-02f, 4.09413464e-02f, 1.38148874e-01f, 2.11208373e-01f, -1.62407830e-01f, 7.30536804e-02f, -1.72790065e-01f, -8.52368176e-02f,
  -1.31309807e-01f, 2.89235115e-01f, -5.96451340e-03f, 1.50392234e-01f, 7.60597140e-02f, -3.23811918e-02f, 1.51356205e-01f, -1.62427664e-01f, 1.28277883e-01f, 2.05573272e-02f,
  8.74948502e-02f, -2.39376887e-03f, 1.90125778e-01f, 4.74705063e-02f, 5.25928251e-02f, 1.48628548e-01f, 1.69698447e-01f, 1.84534505e-01f, -7.00084567e-02f, -1.02903508e-01f,
  -4.00898829e-02f, 2.53594462e-02f, -3.48157212e-02f, 1.17187724e-01f, 4.48843202e-04f, -4.69429009e-02f, -2.61430349e-02f, 1.04675896e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  5.77236377e-02f, 3.75598148e-02f, 1.90269858e-01f, 1.28328696e-01f, 8.63126293e-02f, 1.21318661e-01f, 9.95749608e-03f, 9.19179842e-02f, 1.79292694e-01f, 1.58863768e-01f,
  5.16495742e-02f, 2.31852099e-01f, 5.98215349e-02f, 3.34975161e-02f, 8.47133249e-02f, 3.31707448e-02f, 1.31272078e-01f, 3.80233303e-02f, 1.73351780e-01f, -4.67598438e-02f,
  9.74125415e-02f, 6.72156811e-02f, -1.01141294e-03f, 8.61843228e-02f, 1.86932862e-01f, 1.67663455e-01f, 4.67825495e-02f, 7.16885626e-02f, 5.84263690e-02f, -8.25302396e-03f,
  -6.38199002e-02f, -2.39941478e-02f, 3.64994854e-02f, -3.45628038e-02f, 4.37295102e-02f, -6.60308599e-02f, -2.57675853e-02f, 2.78783321e-01f, -5.78055307e-02f, -4.27610800e-02f,
  6.88014701e-02f, 1.42056465e-01f, 1.56881019e-01f, 8.11542571e-02f, 1.48649171e-01f, 2.56540537e-01f, 1.51440054e-01f, 1.93058163e-01f, 1.67816162e-01f, 2.05068111e-01f,
  1.19835444e-01f, 1.67648047e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -5.51541984e-01f, -1.46281257e-01f, -5.34806132e-01f, -1.99645966e-01f, -8.52851570e-03f, -3.30743283e-01f, 2.92051673e-01f, -1.80040553e-01f, -9.45793986e-02f, 3.81391764e-01f,
  -4.65814173e-02f, 2.24754512e-01f, -9.49313771e-03f, -2.32432410e-02f, -1.83310211e-02f, 1.94019675e-01f, -1.54897407e-01f, 1.34454086e-01f, 2.78715670e-01f, -1.91875681e-01f,
  -2.13016465e-01f, 2.26080164e-01f, 8.35588574e-03f, -2.27175742e-01f, 5.16762026e-02f, 2.48439834e-01f, 1.26186669e-01f, 1.62934452e-01f, -4.88301255e-02f, -1.24055482e-01f,
  -3.18371266e-01f, 1.82727247e-01f, -1.75972968e-01f, 1.97857365e-01f, 1.00729935e-01f, 5.61995916e-02f, -1.19443357e-01f, 6.68502748e-02f, -4.06325012e-02f, -1.58329949e-01f,
  -7.41609633e-02f, 3.60481799e-01f, -6.61240071e-02f, 5.60025498e-02f, -1.47293910e-01f, 2.39656474e-02f, -3.88493724e-02f, -7.83367530e-02f, 1.35787070e-01f, 5.59874117e-01f,
  2.78965086e-01f, 9.92625356e-02f, -6.56065494e-02f, -7.66511485e-02f, -7.34178349e-02f, 9.48103424e-03f, -2.63998210e-01f, -3.36591303e-01f, -2.45891333e-01f, 8.41340423e-02f,
  -5.86365201e-02f, 3.85547251e-01f, 2.63583273e-01f, -2.70895749e-01f, -9.32507813e-02f, 3.46860103e-02f, -1.00836102e-02f, -4.15165484e-01f, -9.86094493e-03f, -9.98577923e-02f,
  3.10412496e-01f, -4.39398557e-01f, 3.13042663e-02f, -1.88701347e-01f, 4.16961223e-01f, -4.50633585e-01f, -9.98150855e-02f, 2.47619729e-02f, -1.80985361e-01f, 1.10000938e-01f,
  -1.93371892e-01f, 1.46357432e-01f, 1.92376450e-02f, -1.04674160e-01f, -2.50809133e-01f, 1.35080665e-01f, -9.10444558e-02f, 9.57591608e-02f, -1.25397801e-01f, -2.79770434e-01f,
  7.89198637e-01f, 1.66260172e-02f, -3.86792779e-01f, -3.32456321e-01f, -1.81938931e-01f, 9.20644179e-02f, -1.35847345e-01f, 2.64660507e-01f, 1.04543649e-01f, -1.56470507e-01f,
  2.99525857e-02f, -2.63397187e-01f, 1.46631032e-01f, 1.38074234e-01f, 2.38726601e-01f, -3.92432988e-01f, -1.91225156e-01f, 5.78740723e-02f, 4.22295123e-01f, 1.28016517e-01f,
  -1.80746436e-01f, 2.81304032e-01f, -2.57795453e-01f, 5.37381530e-01f, -4.42710817e-02f, -1.04184307e-01f, 4.98284400e-02f, 6.88971877e-02f, -1.74188077e-01f, -4.28755879e-02f,
  -1.18560933e-01f, 5.66314459e-01f, -1.91815078e-01f, 1.71790511e-04f, -3.53211105e-01f, 8.33483413e-02f, -7.19138160e-02f, 2.61333793e-01f, -4.44758385e-02f, 3.30431044e-01f,
  2.82129914e-01f, 1.94017008e-01f, 5.34205616e-01f, 5.69355547e-01f, -4.88357246e-01f, -4.20895100e-01f, -9.83086303e-02f, -3.49655420e-01f, -3.30000371e-01f, -1.10820077e-01f,
  4.48858701e-02f, -4.66727838e-02f, -8.19038078e-02f, 6.41712025e-02f, -4.61123288e-02f, -2.72316694e-01f, -2.40946725e-01f, 2.95817196e-01f, 2.39001468e-01f, 3.10617894e-01f,
  1.89280421e-01f, -1.73432946e-01f, -9.39124897e-02f, -7.05836788e-02f, 4.52235900e-02f, -7.21645192e-04f, 5.14561057e-01f, 7.20597580e-02f, -6.23949282e-02f, -2.22474605e-01f,
  4.96488102e-02f, -2.71879017e-01f, 1.88181311e-01f, 3.08978222e-02f, 4.14137214e-01f, -3.49760741e-01f, -3.33937071e-02f, 1.24298930e-01f, -1.25443742e-01f, -1.73959687e-01f,
  -1.10975699e-02f, 1.18904695e-01f, -7.47792795e-02f, 1.07967407e-01f, 2.62837745e-02f, 2.58614589e-02f, 8.49681646e-02f, 2.28977457e-01f, -1.31549463e-01f, -3.20969895e-02f,
  -1.68376982e-01f, -1.03000037e-01f, -9.65583175e-02f, -2.03135118e-01f, 1.47487611e-01f, 3.66098762e-01f, -2.13121593e-01f, -2.34680787e-01f, 4.04188097e-01f, 4.30170447e-01f,
  4.63597924e-02f, -1.79862589e-01f, 7.71288425e-02f, -3.94559085e-01f, 3.03309023e-01f, 2.35393774e-02f, -9.29155052e-02f, -2.30554596e-01f, -1.76283181e-01f, -1.44740507e-01f,
  2.35916018e-01f, -2.29613438e-01f, 2.85948008e-01f, -1.22451372e-01f, 4.82584268e-01f, -9.54859108e-02f, -1.48642734e-01f, -2.78642982e-01f, 3.17026883e-01f, 2.70919174e-01f,
  -9.89751592e-02f, 1.66573510e-01f, -6.94177747e-02f, 6.03572242e-02f, -7.20344530e-03f, -3.02120030e-01f, 2.27419823e-01f, -1.28335416e-01f, -4.41910535e-01f, 7.39673600e-02f,
  2.69585073e-01f, 2.92777181e-01f, -2.67740518e-01f, -2.25014120e-01f, 1.11185044e-01f, -3.38333815e-01f, 1.55678242e-01f, -5.91821447e-02f, -2.72703797e-01f, -1.44823894e-01f,
  -1.76683903e-01f, 1.00738797e-02f, -1.41699329e-01f, 3.11270207e-01f, -7.44923390e-03f, -1.84329242e-01f, -4.16590972e-03f, -1.18579485e-01f, 5.88993393e-02f, -1.41662106e-01f,
  9.16389599e-02f, 5.24731040e-01f, -2.82636564e-02f, -1.87261656e-01f, 6.15127683e-01f, 2.56117346e-04f, -6.45233691e-02f, 8.12415779e-02f, -4.43072170e-02f, -2.76994139e-01f,
  -4.63568605e-02f, -3.43994871e-02f, -2.71144640e-02f, -1.00737497e-01f, 2.61303395e-01f, -6.10135756e-02f, 1.99884892e-01f, 2.32595429e-01f, -2.33842865e-01f, -2.88586188e-02f,
  1.80204231e-02f, -2.99362004e-01f, 3.05454433e-01f, -1.35529758e-02f, 2.91180640e-01f, -3.03703517e-01f, 1.42521868e-02f, -5.72297513e-01f, 2.73985922e-01f, -9.35491323e-02f,
  1.24969482e-01f, -1.72211051e-01f, -1.73504680e-01f, -2.17825025e-01f, -3.30661893e-01f, -2.67125275e-02f, -1.49904087e-01f, -2.25288853e-01f, -2.62454189e-02f, -2.58851409e-01f,
  -2.47095972e-01f, 5.08677885e-02f, -1.24457404e-01f, -2.34471844e-03f, 3.99317257e-02f, -1.26275346e-02f, 5.69220781e-01f, 2.33598888e-01f, 2.63749659e-01f, -2.02096906e-02f,
  -1.08501792e-01f, -6.98607191e-02f, -1.80125788e-01f, 3.73396128e-01f, 1.86026935e-02f, 1.08714141e-01f, 1.60038248e-01f, 3.99229109e-01f, 2.26303503e-01f, 2.81404763e-01f,
  9.37525630e-02f, -6.65306523e-02f, 7.08866492e-02f, -4.75045107e-02f, 9.72482935e-02f, 2.03036055e-01f, 1.34300411e-01f, 1.75905749e-01f, -3.28213632e-01f, -5.23195304e-02f,
  7.33397156e-02f, -7.55747035e-02f, 1.56484887e-01f, -3.19871008e-01f, 2.62162089e-01f, -6.50416613e-02f, 5.31826973e-01f, -4.29075547e-02f, 9.79937091e-02f, -9.74831078e-03f,
  1.56833693e-01f, 3.61058146e-01f, 1.15944445e-01f, 1.82920054e-01f, 5.25052130e-01f, 2.83396453e-01f, 3.15312743e-01f, 6.26657069e-01f, 3.56171995e-01f, -4.33511466e-01f,
  2.85224378e-01f, -4.48077649e-01f, 2.39884868e-01f, -1.19265795e-01f, 9.35660899e-02f, 5.00885546e-01f, -8.75429586e-02f, 6.59344494e-02f, 4.05867815e-01f, -2.31744632e-01f,
  -2.74394125e-01f, -1.11971200e-01f, -2.57589877e-01f, 4.09555376e-01f, -6.82098120e-02f, 4.02045429e-01f, 5.58601081e-01f, -4.82952371e-02f, -2.08121687e-01f, -6.60873726e-02f,
  8.10642540e-02f, 8.60889778e-02f, -1.72985196e-01f, 2.28280708e-01f, -1.26182169e-01f, 1.77411083e-02f, -3.02057922e-01f, 2.19394118e-01f, 3.59674722e-01f, -2.07883939e-01f,
  -3.59397419e-02f, -6.71456233e-02f, -1.59158319e-01f, -9.22187120e-02f, 5.66628613e-02f, 5.60989343e-02f, -5.82005009e-02f, -1.02479793e-01f, 9.65110436e-02f, -1.23087108e-01f,
  -1.46955982e-01f, 2.63054579e-01f, -3.49685609e-01f, -5.69991209e-02f, 1.98618785e-01f, 6.21970482e-02f, -2.38580629e-01f, -1.57295585e-01f, -1.05724409e-01f, 2.48221040e-01f,
  -6.14992641e-02f, -2.83694327e-01f, -7.85194412e-02f, -2.78473467e-01f, 1.12352349e-01f, -1.61602527e-01f, -2.45815426e-01f, 1.82666287e-01f, -2.37344176e-01f, -1.34234428e-02f,
  6.90295473e-02f, 4.99546528e-01f, -5.85092008e-01f, 4.18590605e-01f, -4.41169381e-01f, 5.74394345e-01f, -3.70160222e-01f, 2.12054104e-01f, 3.05206269e-01f, 2.55552921e-02f,
  -1.67507246e-01f, -2.07137376e-01f, -1.44845307e-01f, 3.94475879e-03f, 5.97070754e-01f, -7.30843768e-02f, -1.99750051e-01f, -3.38861287e-01f, -1.90065622e-01f, -2.25263849e-01f,
  -3.27334464e-01f, -6.30825832e-02f, -6.41192272e-02f, -1.24038234e-01f, -1.82125986e-01f, -2.40993798e-01f, -6.90741418e-03f, -1.97411761e-01f, 4.39032800e-02f, 2.32175231e-01f,
  2.83380449e-01f, 1.01697452e-01f, 3.66279036e-02f, -4.68007140e-02f, 5.44488505e-02f, -7.26720989e-02f, 2.56862994e-02f, -2.57012457e-01f, -1.73109666e-01f, 8.61580521e-02f,
  5.32413162e-02f, 6.43583760e-02f, -3.38026695e-02f, -3.26122761e-01f, -2.13179782e-01f, -4.18525860e-02f, -2.75792331e-01f, 4.23178613e-01f, 5.42548895e-01f, 1.97633088e-01f,
  -6.86145052e-02f, -3.32561089e-03f, 1.75958917e-01f, 3.19886923e-01f, -3.31998058e-02f, 1.49954155e-01f, -1.44730613e-01f, 2.75223941e-01f, -2.03286782e-01f, -2.16162235e-01f,
  -9.26596150e-02f, -9.19831321e-02f, -1.67936996e-01f, -1.86946467e-01f, -2.79993802e-01f, 2.58487225e-01f, 3.40095669e-01f, 4.14641723e-02f, -3.58949155e-01f, 1.98479339e-01f,
  -2.73953527e-01f, 1.40534028e-01f, -5.65748513e-02f, -6.51966259e-02f, -1.22208349e-01f, -2.46122748e-01f, 1.96243241e-01f, 1.01367041e-01f, -5.18864334e-01f, -7.68470243e-02f,
  -1.20270550e-01f, 2.30608076e-01f, 3.63497585e-01f, 7.93102458e-02f, 3.01244915e-01f, 3.13240732e-03f, 2.06704348e-01f, -1.03403352e-01f, -1.56183869e-01f, 2.67826438e-01f,
  -1.64289385e-01f, -4.15998511e-02f, 8.75398442e-02f, 1.11136943e-01f, 3.63732219e-01f, -1.49569154e-01f, -9.49835330e-02f, -7.05942744e-03f, -2.15689972e-01f, 2.32448168e-02f,
  1.02414899e-02f, 4.84068632e-01f, 2.66790748e-01f, 1.62407443e-01f, 1.49006635e-01f, -7.66341984e-02f, 1.83474571e-02f, -3.50794643e-01f, 1.04112603e-01f, 1.04291946e-01f,
  2.31096312e-01f, 5.74213415e-02f, -2.89617658e-01f, 1.45391732e-01f, 1.58323254e-02f, -2.42886722e-01f, -5.21397218e-02f, 3.22914869e-01f, -2.03474894e-01f, -1.80425569e-01f,
  9.40440148e-02f, 4.35411632e-02f, 1.04871124e-01f, 2.63541162e-01f, 1.64764807e-01f, 2.82012224e-01f, 6.35469751e-03f, 6.73124790e-02f, 7.35717341e-02f, -2.26223022e-01f,
  -4.91344452e-01f, -6.27223477e-02f, 3.52644712e-01f, 6.27987981e-01f, 7.21321851e-02f, 4.56170768e-01f, -1.03038974e-01f, 1.63853794e-01f, 2.31370777e-01f, 2.81956524e-01f,
  1.57712609e-01f, -1.68411076e-01f, -2.97640175e-01f, -1.15561094e-02f, -1.02302179e-01f, 5.13495922e-01f, -8.28343555e-02f, 5.23436964e-02f, -1.07098930e-01f, -1.11957751e-01f,
  -2.43276283e-01f, 3.35497379e-01f, -4.07914221e-02f, -1.76721290e-01f, -1.51993424e-01f, 2.78221607e-01f, 1.14775248e-01f, 2.19176710e-01f, -6.52732849e-02f, -2.93498933e-01f,
  -2.17571575e-02f, -1.34527788e-01f, -1.15650825e-01f, -1.02826484e-01f, 5.84443249e-02f, -1.46986842e-01f, -5.83099984e-02f, -1.60219669e-01f, 1.30856438e-02f, -1.10120378e-01f,
  1.09526254e-01f, -6.06321931e-01f, -1.64003242e-02f, -1.56397969e-01f, 3.22717652e-02f, -5.35688736e-02f, 8.33611712e-02f, -1.30644754e-01f, -5.70493657e-03f, 3.52069825e-01f,
  -1.53292134e-01f, -1.73431486e-01f, -2.12389141e-01f, -5.76905683e-02f, -9.96739417e-02f, 5.19201636e-01f, -4.47310843e-02f, -4.92829680e-02f, 3.46529096e-01f, 2.66333789e-01f,
  -1.73525661e-01f, 3.84603798e-01f, -1.25805944e-01f, 3.87756795e-01f, 1.99599698e-01f, 2.22111538e-01f, -4.26078022e-01f, 2.49845579e-01f, -8.61275196e-02f, -6.19313344e-02f,
  4.14511859e-01f, -9.20153037e-03f, -1.32737681e-03f, -1.49972811e-01f, -8.89084637e-02f, 1.17473193e-01f, -6.76456373e-03f, -4.70014066e-02f, -5.85921966e-02f, -8.86123069e-03f,
  -1.91537857e-01f, 1.50574278e-02f, 7.89653435e-02f, 2.34014556e-01f, 4.48235720e-01f, -1.87379509e-01f, 4.23782557e-01f, -8.98224339e-02f, -2.43084878e-01f, -1.73161954e-01f,
  -2.31136933e-01f, -2.02341527e-01f, 5.24603724e-01f, 1.58829112e-02f, -1.02128297e-01f, -5.50435223e-02f, 1.23872779e-01f, -6.54041246e-02f, -3.26255569e-03f, 2.01881766e-01f,
  -1.85055107e-01f, -8.90395511e-03f, 2.21494690e-01f, -1.77114829e-01f, -1.30819201e-01f, -3.33678186e-01f, 1.08068854e-01f, 9.87228006e-02f, -1.79967329e-01f, 3.41056287e-02f,
  -7.23524541e-02f, 2.48771429e-01f, 6.07124269e-01f, -3.03058118e-01f, 3.94862831e-01f, -7.70936813e-03f, 3.18378061e-01f, -1.18270189e-01f, -4.94500138e-02f, -4.50610518e-01f,
  1.33810058e-01f, -2.71711677e-01f, 5.10867909e-02f, 7.11961323e-03f, -3.52976471e-01f, 5.26770800e-02f, -2.57524878e-01f, -2.90852368e-01f, 1.29747525e-01f, -5.89389913e-02f,
  2.59011626e-01f, -3.81417483e-01f, -2.52589937e-02f, -3.73707004e-02f, -1.25894085e-01f, 5.22360913e-02f, 2.52221733e-01f, -2.77168959e-01f, 1.12364694e-01f, 6.36608303e-02f,
  -7.89604858e-02f, 1.37559902e-02f, 3.34959626e-01f, -1.98708668e-01f, 1.80495963e-01f, 1.98235258e-01f, -2.35604003e-01f, -2.28806749e-01f, -2.75725037e-01f, 1.77461281e-01f,
  -1.39241740e-02f, -8.93349648e-02f, 5.37499189e-01f, 3.40951145e-01f, -1.64807498e-01f, -8.77036713e-03f, -2.11332083e-01f, 1.90022320e-01f, 2.77339928e-02f, -1.01809256e-01f,
  9.11367983e-02f, -1.42948121e-01f, 4.31917757e-02f, -1.60534605e-01f, -3.92751954e-03f, -1.40576720e-01f, 2.10754178e-03f, 2.16815211e-02f, 4.01875585e-01f, -1.47665635e-01f,
  -1.67018145e-01f, -5.51185533e-02f, 3.76472145e-01f, -1.39489487e-01f, -1.93375066e-01f, -9.71635655e-02f, 3.95364687e-02f, 5.04907548e-01f, 2.02519313e-01f, -1.80385992e-01f,
  -2.34024346e-01f, -1.73335522e-01f, -1.29515216e-01f, -4.00614619e-01f, 1.89041235e-02f, 1.96571931e-01f, 9.81413666e-03f, -2.57149369e-01f, 2.18978226e-01f, -2.59017617e-01f,
  9.03550982e-02f, 9.92360935e-02f, -3.25834543e-01f, 4.06670660e-01f, -3.10435683e-01f, 2.99645245e-01f, 1.85500592e-01f, -1.27640426e-01f, -2.50050068e-01f, -1.05881155e-01f,
  9.11636502e-02f, 5.73256850e-01f, 8.15300562e-04f, -2.23614335e-01f, 6.28497541e-01f, -8.50673243e-02f, -7.55382031e-02f, 6.81660026e-02f, -1.37065336e-01f, -8.76922682e-02f,
  -3.16572756e-01f, -2.42409885e-01f, 2.18944084e-02f, 8.88260901e-02f, -5.48553728e-02f, 1.13938503e-01f, 5.55912927e-02f, -2.96062142e-01f, 3.56378369e-02f, -1.45604357e-01f,
  -1.61842033e-01f, 9.10533294e-02f, -9.15234610e-02f, 1.95580488e-03f, -5.26201688e-02f, 2.27048877e-03f, 1.67527720e-01f, -2.16449782e-01f, -1.58915058e-01f, 9.37064141e-02f,
  -6.74430579e-02f, 1.28428012e-01f, 2.85190511e-02f, -2.38844365e-01f, 1.16127566e-01f, 6.89468533e-02f, 2.81164739e-02f, -1.76793233e-01f, -1.98512282e-02f, -4.50140312e-02f,
  1.63113967e-01f, -1.24515750e-01f, -3.68545838e-02f, -1.26374602e-01f, -1.63046867e-01f, -5.68778161e-03f, 5.89259744e-01f, 4.68901306e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.15484998e-01f, 1.21789731e-01f, 8.53536278e-03f, -1.25535473e-01f, -5.62516740e-03f, 3.05861443e-01f, 1.45525277e-01f, -1.61189392e-01f, -5.73387966e-02f, 9.70068127e-02f,
  -1.29388601e-01f, 8.23587365e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    