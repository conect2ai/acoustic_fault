/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.33339226e-01f, 5.59101664e-02f, -8.28318745e-02f, 3.61805111e-01f, 2.33637214e-01f, -1.23210154e-01f, 1.87143665e-02f, 1.88179657e-01f, 2.10136592e-01f, 1.55495042e-02f,
  4.38432433e-02f, 2.93425679e-01f, -4.78848100e-01f, 3.62308025e-01f, 2.54504412e-01f, -3.21059823e-01f, 3.65469515e-01f, 2.42577687e-01f, -3.39523479e-02f, 2.16169387e-01f,
  1.72325134e-01f, 2.05440924e-01f, 1.14092708e-01f, -5.00517823e-02f, 1.15716293e-01f, -1.49843454e-01f, 4.00874577e-02f, -2.64797419e-01f, 8.41138437e-02f, 1.43407108e-02f,
  1.49530172e-01f, 1.40296683e-01f, -6.68081194e-02f, 4.73584980e-03f, 4.90041748e-02f, -7.77826905e-02f, -3.26675996e-02f, -1.59413710e-01f, 1.35341976e-02f, -1.49405245e-02f,
  -7.91568086e-02f, 8.14183354e-02f, 2.16165055e-02f, -1.19075648e-01f, 9.63706076e-02f, -1.60786957e-02f, 6.26812130e-02f, -2.69803032e-02f, 1.07432520e-02f, 3.32045853e-02f,
  -8.80816877e-02f, -8.46141428e-02f, 2.81946547e-03f, -5.83547503e-02f, -4.03101072e-02f, -1.99340191e-02f, 6.46695271e-02f, -4.99391295e-02f, 6.19698018e-02f, 1.48347482e-01f,
  -7.15782270e-02f, -1.72517709e-02f, -4.75725438e-03f, -7.24623799e-02f, -1.99043807e-02f, 2.46996321e-02f, -3.22019532e-02f, 2.68364940e-02f, 8.41402113e-02f, 5.48119545e-02f,
  3.79963033e-02f, 1.04209267e-01f, -5.40244114e-03f, -1.66766420e-02f, 1.06816262e-01f, 1.09104086e-02f, -4.90787290e-02f, -1.18563678e-02f, 2.39830408e-02f, 4.04760726e-02f,
  -3.74936052e-02f, 7.43947998e-02f, -1.54480236e-02f, 3.90652195e-02f, 2.61299051e-02f, -6.06758632e-02f, -8.54471028e-02f, -4.81504053e-02f, -3.73603627e-02f, 5.00191636e-02f,
  2.06718951e-01f, 1.89555511e-01f, -6.26596361e-02f, 9.17999074e-02f, -2.15937570e-02f, 6.19608872e-02f, 1.00334309e-01f, -4.23327228e-03f, -2.92099938e-02f, -8.88080522e-03f,
  2.82385573e-02f, 5.89523874e-02f, -5.55499224e-03f, 1.93196349e-02f, -1.32805097e-03f, 7.46456981e-02f, -3.83849479e-02f, 2.16685217e-02f, 1.13682002e-01f, 1.05708227e-01f,
  3.16152833e-02f, -1.15082070e-01f, -2.94623226e-02f, 1.10084675e-01f, -2.41349060e-02f, -5.84075227e-03f, 2.48842631e-02f, 2.48337118e-03f, -1.28301919e-01f, 3.45718451e-02f,
  -2.02439278e-01f, -2.15941921e-01f, 1.08871974e-01f, 2.38835692e-01f, 7.92403817e-02f, -5.00625730e-01f, 6.05201088e-02f, 9.13399504e-04f, 3.70380491e-01f, -3.15727741e-01f,
  5.56556955e-02f, -5.14606424e-02f, 9.41733569e-02f, -2.66841084e-01f, -8.72530043e-02f, 1.14734150e-01f, -2.44982511e-01f, -2.12246403e-01f, 2.06333816e-01f, -1.83804885e-01f,
  1.04276404e-01f, -3.02403212e-01f, -5.57002658e-03f, -1.08359933e-01f, -2.61294544e-01f, 8.60494599e-02f, -2.56303459e-01f, 1.10748939e-01f, -3.61916244e-01f, -1.37233781e-02f,
  5.04616648e-02f, 1.78911567e-01f, 1.10190623e-02f, -6.22373307e-03f, -5.18836007e-02f, -6.25780448e-02f, -5.29247485e-02f, 7.55236447e-02f, 2.98043370e-01f, -1.84065904e-02f,
  -1.65646290e-03f, 5.57478108e-02f, 2.68368679e-03f, 4.20410465e-03f, -4.91306884e-03f, 4.42165695e-02f, 1.22967139e-02f, -2.11241264e-02f, 9.37305167e-02f, -2.78021451e-02f,
  4.48435470e-02f, 8.40941817e-03f, -2.88743731e-02f, -6.58297166e-02f, 9.06314030e-02f, 1.31397694e-01f, 1.36441840e-02f, -8.42269510e-02f, -3.62141728e-02f, -5.11216633e-02f,
  -1.52706981e-01f, -3.06441952e-02f, 1.62541261e-03f, -2.38621235e-02f, 2.69066598e-02f, 3.53775285e-02f, -1.08716935e-02f, -8.40729773e-02f, 3.92430909e-02f, -5.52061871e-02f,
  -5.56521825e-02f, 7.08723366e-02f, 2.71065384e-02f, 3.91028523e-02f, -7.30290487e-02f, 3.54780890e-02f, -3.96534130e-02f, 1.22350529e-02f, 7.23784929e-03f, -8.06356408e-03f,
  1.72818732e-02f, 2.11428683e-02f, -1.00937299e-02f, -8.87454022e-03f, 4.99422215e-02f, 2.51689143e-02f, -1.83399338e-02f, 1.25228679e-02f, 1.27964661e-01f, -1.20590396e-01f,
  -1.17218047e-01f, -3.91021639e-01f, 7.51168057e-02f, 1.18088096e-01f, 1.85592973e-03f, -8.59034285e-02f, 5.00901230e-02f, -1.33683562e-01f, -1.38025612e-01f, -3.23395729e-02f,
  -1.06078558e-01f, 3.05609312e-02f, -9.96285081e-02f, 9.27406549e-02f, 9.66022834e-02f, -1.27755431e-02f, -4.27876301e-02f, 5.59610464e-02f, -1.26172081e-01f, -7.49533996e-02f,
  -9.92844403e-02f, -1.11206071e-02f, -1.51800113e-02f, -3.36938817e-03f, 3.51335504e-03f, -1.45885423e-02f, -2.48373151e-02f, 6.52458072e-02f, -1.01177141e-01f, -4.65336181e-02f,
  2.74160821e-02f, 1.63778558e-01f, 3.70553523e-01f, 3.15268815e-01f, -1.16177633e-01f, -2.73490340e-01f, 2.19960764e-01f, -3.99161130e-02f, -2.80881047e-01f, -6.81596473e-02f,
  1.77019477e-01f, 2.13614941e-01f, 2.58836225e-02f, 2.18482986e-01f, -2.54520178e-01f, -1.33211374e-01f, -1.35209545e-01f, -3.02752722e-02f, -1.08750798e-01f, 2.01943126e-02f,
  -1.18683085e-01f, -1.25657439e-01f, 3.94564569e-01f, -1.22454874e-01f, 2.39225224e-01f, 4.93038148e-02f, -1.26085788e-01f, 1.70712262e-01f, -3.66322845e-02f, 1.44573912e-01f,
  1.83342814e-01f, 5.36878109e-02f, 1.28832862e-01f, 2.98943501e-02f, -1.00738183e-01f, 4.36069332e-02f, 7.30627701e-02f, 1.21482186e-01f, 1.37082279e-01f, 7.33370893e-03f,
  -7.72363618e-02f, -6.31633326e-02f, -5.22223078e-02f, 8.57511815e-03f, -5.16255163e-02f, 8.72877538e-02f, -2.50694174e-02f, 5.65330498e-02f, 1.00266896e-02f, -1.16243670e-02f,
  3.06847710e-02f, -1.03086932e-02f, -1.09442897e-01f, 2.90218077e-06f, 7.53635466e-02f, 9.74236727e-02f, 1.71407871e-03f, -4.87468429e-02f, -1.06707275e-01f, -1.38078868e-01f,
  -9.17721540e-02f, -8.88336748e-02f, 7.04733208e-02f, 7.08124489e-02f, -6.98494762e-02f, 4.62183543e-02f, 5.12187481e-02f, -4.23183991e-03f, 1.02715336e-01f, -6.82512894e-02f,
  -5.18467836e-02f, 9.42358188e-03f, 2.93817949e-02f, -3.48626375e-02f, -9.41505805e-02f, 5.92091084e-02f, 5.96975200e-02f, 5.75761236e-02f, -6.66589588e-02f, 4.37810346e-02f,
  4.46134731e-02f, -5.43785654e-02f, 3.74958403e-02f, 5.27151786e-02f, -3.76719683e-02f, 3.95186692e-02f, 1.42520946e-02f, 1.23948880e-01f, 6.70621395e-02f, -4.43575382e-02f,
  -2.00718671e-01f, -3.65707904e-01f, -3.00910696e-03f, 7.74396360e-02f, 3.93574685e-02f, -9.18063968e-02f, -6.00080416e-02f, -1.21504284e-01f, -5.96387759e-02f, -9.39459354e-02f,
  -4.01327983e-02f, 6.47610202e-02f, -6.72705024e-02f, 8.38012323e-02f, 7.50298053e-02f, -1.12584725e-01f, 5.43853045e-02f, 7.21935704e-02f, 2.71431357e-02f, -9.18171331e-02f,
  1.31228250e-02f, -5.94757013e-02f, -1.99381635e-02f, 1.44074066e-02f, -1.91720098e-01f, 1.42540531e-02f, -3.54701355e-02f, -2.04567984e-03f, 2.12699315e-03f, -1.20215619e-03f,
  -6.60094857e-01f, -9.10282731e-02f, -3.20794463e-01f, -1.17794022e-01f, 1.62478179e-01f, 1.47960886e-01f, 4.35747914e-02f, 9.87781882e-02f, -5.34586966e-01f, 2.39696324e-01f,
  3.20402116e-01f, -3.29780817e-01f, 5.86074516e-02f, 3.64676118e-01f, -1.65462703e-01f, -1.12706304e-01f, 9.11031812e-02f, 2.78112292e-02f, -2.03389704e-01f, -2.27275398e-02f,
  -2.34247878e-01f, 4.04278129e-01f, 2.70560477e-02f, 1.58246830e-01f, 3.17765698e-02f, -1.72928602e-01f, 3.40711057e-01f, 3.20456736e-02f, 3.22328985e-01f, 1.46292057e-02f,
  1.08511291e-01f, -8.60751197e-02f, -5.25148325e-02f, -7.67203495e-02f, 4.35019247e-02f, 5.71259744e-02f, 1.10952385e-01f, 1.10607758e-01f, -2.31659319e-02f, -1.30739287e-02f,
  -3.18181678e-03f, -5.06719165e-02f, 2.23419778e-02f, -6.81265816e-02f, -1.95255689e-03f, -1.52026424e-02f, -7.18397796e-02f, 6.22817464e-02f, -2.40611918e-02f, 9.85865574e-03f,
  -7.14458898e-02f, 3.06093898e-02f, -2.03581732e-02f, -1.72910802e-02f, -3.31484377e-02f, -2.52497923e-02f, -5.37228351e-03f, 2.77337395e-02f, -3.10370531e-02f, -9.08132941e-02f,
  1.99197549e-02f, -6.31329492e-02f, -1.61764082e-02f, 4.67487872e-02f, 4.98556904e-02f, 1.03351571e-01f, 3.41147510e-03f, 1.07360162e-01f, -1.13440096e-01f, 1.11201324e-01f,
  -1.31554082e-02f, -5.47811314e-02f, 4.48213927e-02f, -2.85724998e-02f, 8.62542633e-03f, -2.40818337e-02f, -5.30770868e-02f, 3.92625071e-02f, -1.01651803e-01f, 5.00020273e-02f,
  5.54575026e-03f, -4.01733480e-02f, 1.86513253e-02f, 5.87844588e-02f, 1.81385949e-02f, -6.52384758e-02f, 1.96473394e-03f, 2.50272714e-02f, 3.08330334e-03f, 2.95720119e-02f,
  8.92974213e-02f, -3.55768614e-02f, -2.31993943e-02f, 3.86873744e-02f, 5.84777184e-02f, 2.88671795e-02f, -6.24247678e-02f, 8.71603657e-03f, 8.83719127e-04f, -5.79849966e-02f,
  5.62847406e-02f, 5.03296033e-02f, -2.14277003e-02f, 8.73146281e-02f, -1.43865384e-02f, 1.36989336e-02f, 3.00455019e-02f, -5.94008900e-02f, 9.00524780e-02f, 2.80431565e-02f,
  1.29786327e-01f, -4.29574996e-02f, -3.68043706e-02f, 1.72779337e-02f, 2.28157043e-02f, -8.02668277e-04f, 2.03057900e-02f, -7.28482008e-02f, 1.13293305e-01f, 1.15395081e-03f,
  3.21861990e-02f, -3.91432121e-02f, -5.23120642e-01f, 5.28147742e-02f, 1.12304889e-01f, 1.19130239e-01f, 3.24834198e-01f, -2.12002043e-02f, 2.86747903e-01f, 1.51451230e-01f,
  3.50180626e-01f, -2.21411660e-01f, 3.53444874e-01f, -1.20281108e-01f, -4.59570259e-01f, 2.33533069e-01f, -8.18049088e-02f, 1.19336255e-01f, 8.81336629e-02f, 9.00011510e-02f,
  -5.64171188e-02f, 2.49256253e-01f, -1.74092576e-01f, 5.13168275e-02f, -5.61601482e-02f, -2.13815987e-01f, -1.50348663e-01f, 4.11221273e-02f, -4.06050146e-01f, -1.44659281e-01f,
  -1.02924377e-01f, 2.19674513e-01f, -1.16898336e-01f, -5.05351536e-02f, 4.03885642e-04f, 7.37791434e-02f, -1.14616066e-01f, 3.70562226e-02f, 5.22137582e-02f, 7.55349100e-02f,
  9.66126546e-02f, 3.51681747e-03f, 7.69189149e-02f, -1.85014457e-02f, 9.25333947e-02f, -3.38270031e-02f, -8.85644853e-02f, 4.10126615e-03f, -2.22930573e-02f, -1.75530929e-02f,
  -1.56605560e-02f, -7.01694414e-02f, -2.68428656e-03f, -4.20024730e-02f, -1.04207598e-01f, 5.25828116e-02f, 3.33348326e-02f, -7.70863071e-02f, -4.79525626e-02f, -9.41064432e-02f,
  6.98268530e-04f, 1.49114221e-01f, 6.26092106e-02f, 5.52043021e-02f, 7.17662945e-02f, -5.04446663e-02f, 2.46108193e-02f, 1.80434361e-02f, -8.83271545e-02f, 6.75578192e-02f,
  -2.29432574e-03f, -2.89318487e-02f, 3.09012774e-02f, 8.89458135e-02f, 1.25731096e-01f, 4.64350358e-02f, -5.31770922e-02f, -4.74590100e-02f, 4.81321812e-02f, 2.89994180e-02f,
  3.48977232e-03f, -2.14651469e-02f, -4.20709252e-02f, -4.94736880e-02f, 6.45814985e-02f, -1.61565654e-02f, 2.55680587e-02f, -1.52963296e-01f, 6.04154393e-02f, 4.12715003e-02f,
  -1.64975468e-02f, 3.11727505e-02f, 3.65064256e-02f, 3.61908749e-02f, 2.05729753e-02f, -8.82813334e-02f, 5.26272543e-02f, -1.21527933e-01f, -7.23851398e-02f, 9.58245695e-02f,
  -5.12543991e-02f, 4.81919236e-02f, -8.19716007e-02f, -6.88535869e-02f, -4.19844575e-02f, -3.04965973e-02f, 2.94053536e-02f, -5.69830202e-02f, -1.58953182e-02f, -3.35241295e-02f,
  3.71918455e-02f, 1.15912192e-01f, -4.42987075e-04f, 3.15803401e-02f, -2.14645062e-02f, -6.32764352e-03f, -6.01157844e-02f, 4.89779525e-02f, -5.15047945e-02f, 7.19619170e-02f,
  5.25988519e-01f, -3.69484007e-01f, -2.76504904e-01f, 4.04346675e-01f, 4.73998822e-02f, 3.36105108e-01f, 5.18528581e-01f, -8.13021958e-02f, 3.07107568e-01f, 1.28940016e-01f,
  2.30214953e-01f, 1.29707128e-01f, -1.50951177e-01f, 4.25359368e-01f, 2.69477516e-01f, 7.78249651e-02f, 3.88350457e-01f, 2.87147760e-01f, -4.45676781e-02f, -2.41362909e-03f,
  6.55294061e-02f, 2.47251481e-01f, 3.30780027e-03f, -2.16106072e-01f, 5.86119853e-02f, -2.66189545e-01f, -8.50973502e-02f, -2.10861564e-01f, 9.82315093e-02f, 4.60300036e-02f,
  1.00559629e-01f, 5.03605194e-02f, -2.45324504e-02f, 3.16648297e-02f, 5.79877235e-02f, -9.09352675e-02f, -2.16954928e-02f, -4.25827242e-02f, 3.97178009e-02f, 3.55992168e-02f,
  -1.51680494e-02f, -3.61921266e-02f, 7.81841278e-02f, -4.01518457e-02f, 2.76560150e-03f, -6.83726221e-02f, -7.19496608e-02f, -1.57213248e-02f, -2.15348639e-02f, -2.88640149e-02f,
  1.80693455e-02f, 6.80760434e-03f, 5.41650131e-02f, 2.44256184e-02f, -1.41129782e-02f, 7.28613809e-02f, -2.76445015e-03f, -6.22574836e-02f, 2.75580771e-03f, 5.23931049e-02f,
  -6.72015920e-02f, 8.81910848e-04f, -3.50250416e-02f, -5.67312799e-02f, -5.63176274e-02f, -6.54092729e-02f, 2.94811502e-02f, -5.24053387e-02f, 3.25310905e-03f, -1.94031913e-02f,
  5.30701317e-02f, -9.59946029e-03f, 6.73617274e-02f, 6.68624789e-02f, 6.75806701e-02f, 1.84443481e-02f, -2.46657208e-02f, -3.27925421e-02f, 7.21681193e-02f, 1.32162031e-02f,
  2.20810268e-02f, -5.95191726e-03f, -1.04561942e-02f, -2.43074596e-02f, -1.75949540e-02f, 4.47059050e-02f, 3.56698874e-03f, -4.92864363e-02f, -4.40885313e-02f, 5.08568957e-02f,
  -4.75092605e-02f, -1.89259008e-01f, 1.53910173e-02f, 2.27902625e-02f, 2.12008208e-02f, 3.80473323e-02f, 8.33869278e-02f, -2.32748035e-02f, -6.12117276e-02f, -2.07479522e-02f,
  3.03599555e-02f, 2.85317898e-02f, -6.93516433e-02f, 2.80424878e-02f, 8.20352137e-03f, -4.18595076e-02f, 6.80149198e-02f, 5.18865250e-02f, 3.49941514e-02f, -2.19294783e-02f,
  -4.65086810e-02f, 2.25203335e-02f, -1.72273386e-02f, -3.35935093e-02f, 3.60660851e-02f, -1.60303321e-02f, -5.68471365e-02f, 4.19896729e-02f, -1.30849723e-02f, 2.87389886e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.30708051e-01f, 8.72229576e-01f, -5.42723715e-01f, -1.00239404e-01f, 2.82383785e-02f, 6.11152411e-01f, 5.93558908e-01f, 2.22936928e-01f, 1.50158972e-01f, 5.88612616e-01f,
  4.99323934e-01f, -1.80075571e-01f, 5.56796670e-01f, 6.50247812e-01f, -4.50423956e-01f, 4.79587227e-01f, 4.67612594e-01f, 3.60456288e-01f, 1.92157313e-01f, 8.35393816e-02f,
  -1.01711370e-01f, 6.06309116e-01f, 2.52716132e-02f, 2.25489348e-01f, -1.62935659e-01f, -4.23008889e-01f, -3.01610023e-01f, -1.55732155e-01f, -4.64380570e-02f, 8.59394670e-02f,
  -3.74299645e-01f, -5.41335642e-01f, -3.06258768e-01f, -2.66619682e-01f, -2.07199976e-01f, -1.52174965e-01f, -2.22247034e-01f, -6.88120127e-02f, -1.67895064e-01f, 7.01272041e-02f,
  -3.96478213e-02f, 2.89088907e-03f, 4.28570509e-02f, 9.75673422e-02f, 3.86769953e-03f, -5.46046644e-02f, 8.66875052e-02f, -9.44072194e-03f, 1.57596365e-01f, 4.75203730e-02f,
  7.22021163e-02f, -5.94275184e-02f, -9.31023248e-03f, 1.02938458e-01f, -7.70942420e-02f, -9.68286768e-02f, -6.50454611e-02f, -9.20756608e-02f, -4.75443304e-02f, -4.00695205e-02f,
  -8.64905193e-02f, -9.22813639e-02f, 1.05902985e-01f, 8.13923776e-02f, 4.11141589e-02f, -6.75988719e-02f, -1.38862915e-02f, 2.13912744e-02f, -3.93158989e-03f, 1.62807018e-01f,
  2.00257432e-02f, -3.30834724e-02f, -2.15905756e-01f, -8.77293758e-03f, -3.05753071e-02f, -7.65954554e-02f, -8.38242769e-02f, 9.31738019e-02f, 4.40885834e-02f, -6.53385743e-02f,
  -3.41443792e-02f, -4.23723385e-02f, 1.57937154e-01f, 1.18193002e-02f, 6.11220188e-02f, -2.63654161e-02f, -2.88130865e-02f, -9.45491903e-03f, 5.91101870e-02f, -7.35230222e-02f,
  1.78745540e-04f, -3.38409424e-01f, 1.46549314e-01f, 6.01181947e-02f, -6.54131640e-03f, 1.43799394e-01f, 5.25105409e-02f, -4.12521660e-02f, -1.40124336e-02f, 5.74735440e-02f,
  -2.70994492e-02f, -1.01879396e-01f, -8.13721418e-02f, 5.68482205e-02f, 8.53678212e-03f, 1.66496441e-01f, -1.20098852e-02f, -7.44713470e-02f, -9.74265784e-02f, 7.23657012e-02f,
  -4.01458479e-02f, 3.31000499e-02f, -1.01077437e-01f, 6.58974424e-02f, 4.14691977e-02f, 2.76997723e-02f, -9.24776047e-02f, -8.49913657e-02f, -1.09680131e-01f, 9.79824662e-02f,
  9.81556594e-01f, -2.13326693e-01f, 6.11945033e-01f, 7.37811148e-01f, 1.43631641e-02f, 4.79752302e-01f, 8.11857224e-01f, 9.06512141e-02f, 9.10334110e-01f, -4.84361410e-01f,
  -6.18817866e-01f, 4.74918991e-01f, -1.19021140e-01f, -3.05145651e-01f, 2.89292037e-01f, 2.22722739e-02f, 2.39733025e-01f, 2.94525564e-01f, 9.31654051e-02f, 1.04375795e-01f,
  1.33490622e-01f, -5.21693230e-01f, -2.48107105e-01f, -7.76357353e-01f, -2.77326345e-01f, -6.37319908e-02f, -6.94792867e-01f, -1.95662752e-02f, -6.33025289e-01f, -2.35155031e-01f,
  -1.10537782e-01f, -7.11923763e-02f, -2.58165359e-01f, -5.34936115e-02f, -1.70555368e-01f, 2.75522657e-02f, 6.88418048e-03f, -1.10115623e-02f, 6.43882230e-02f, -1.07839718e-01f,
  2.03825504e-01f, -5.87361269e-02f, -1.18474543e-01f, 6.47870526e-02f, 1.78226307e-01f, -4.65200879e-02f, -4.40914333e-02f, -1.24496445e-01f, -2.66720783e-02f, -8.45775306e-02f,
  1.74996909e-02f, -5.13756908e-02f, 1.31910026e-01f, 3.44599597e-02f, 1.94403045e-02f, -7.33259842e-02f, 1.00777112e-01f, 7.84602687e-02f, -1.02826289e-03f, 2.04012301e-02f,
  -3.66496034e-02f, 1.14096299e-01f, -2.23369431e-03f, -2.51116999e-03f, -2.48151217e-02f, -1.18890204e-01f, -1.01260445e-03f, -1.92276612e-01f, 1.98600948e-01f, 1.35646984e-02f,
  6.95278645e-02f, -1.34202152e-01f, 1.29338309e-01f, 3.43957171e-02f, -4.07754863e-03f, 1.90228060e-01f, 1.38689801e-01f, -3.37032974e-02f, 2.47089285e-02f, -4.67708297e-02f,
  -2.11097505e-02f, 6.54872060e-02f, -2.08807066e-01f, 7.62654394e-02f, 3.40309483e-03f, -3.29251848e-02f, -2.04217762e-01f, 1.80489585e-01f, 7.79347271e-02f, -1.16237625e-01f,
  -1.83361754e-01f, -9.97166261e-02f, -1.19173162e-01f, -2.19801158e-01f, 8.96439999e-02f, -2.29804128e-01f, 1.62951514e-01f, -7.29468167e-02f, 1.59064621e-01f, 1.28768578e-01f,
  -1.51277289e-01f, -2.04590000e-02f, 1.51499184e-02f, 7.21681565e-02f, -8.30811188e-02f, -2.65412688e-01f, -1.13547537e-02f, -7.64784664e-02f, -3.66335027e-02f, -1.85751125e-01f,
  -1.43630639e-01f, -1.33496919e-03f, 4.96823117e-02f, 2.23539658e-02f, -1.80497319e-01f, -9.51507390e-02f, 6.62163347e-02f, -7.75576979e-02f, -1.56982899e-01f, -5.51508553e-02f,
  -2.53030270e-01f, -1.99790150e-01f, 5.59775472e-01f, 6.23834670e-01f, -2.84571499e-01f, -2.16734007e-01f, 5.91754079e-01f, -3.07143271e-01f, -2.73611695e-01f, -1.00159757e-01f,
  9.46413353e-02f, 1.01052597e-01f, 4.44090784e-01f, -3.47886294e-01f, 6.22401714e-01f, -2.17560865e-02f, -9.64541733e-02f, 4.90916371e-02f, 1.64754912e-01f, 3.25932652e-01f,
  2.21561983e-01f, -1.52260602e-01f, 4.59369332e-01f, -2.23063394e-01f, -5.51721547e-03f, 2.13679865e-01f, 6.21735036e-01f, 5.40772557e-01f, 1.33993223e-01f, -7.50287697e-02f,
  -2.35208645e-01f, -1.34051859e-01f, -1.40358299e-01f, -8.32963660e-02f, 4.42943275e-02f, 6.26529083e-02f, 2.20778346e-01f, 2.98110433e-02f, 4.98544164e-02f, -7.45591428e-03f,
  3.62877958e-02f, -5.60631463e-03f, -1.92438200e-01f, 4.49495725e-02f, -1.27897009e-01f, -1.01347260e-01f, -2.63219535e-01f, -5.26631959e-02f, 2.67135669e-02f, 3.79791744e-02f,
  1.19451806e-01f, -1.35994390e-01f, 3.96207534e-02f, -8.48117545e-02f, 1.31415874e-01f, -6.34971932e-02f, 1.19198695e-01f, 2.54622370e-01f, -6.32071644e-02f, -7.03241229e-02f,
  -1.60329059e-01f, 1.01375051e-01f, -2.07789242e-02f, -2.05380619e-02f, 6.31589303e-03f, -2.08339859e-02f, 4.06593159e-02f, -1.45321742e-01f, -2.36450993e-02f, 4.84525636e-02f,
  3.29113901e-02f, 3.17666754e-02f, -1.89571857e-01f, 2.72296350e-02f, 1.89810321e-02f, -2.44396254e-01f, 1.15998708e-01f, -1.17487647e-01f, 1.01390898e-01f, -8.63133445e-02f,
  7.31613562e-02f, -5.57186902e-02f, 1.18717149e-01f, -5.10586314e-02f, -1.37215510e-01f, 2.64903177e-02f, -8.61684307e-02f, -2.70547736e-02f, 1.58462394e-02f, 2.01275378e-01f,
  1.49797752e-01f, 5.17924428e-01f, 9.75920185e-02f, -1.63309470e-01f, -1.76194143e-02f, -5.76037802e-02f, -1.51385069e-01f, -1.25539780e-01f, 2.24155784e-01f, -5.41324988e-02f,
  1.57200128e-01f, 3.69038992e-02f, 6.62116781e-02f, -1.54233530e-01f, 2.20683426e-01f, 2.09936604e-01f, 2.03656346e-01f, 1.19939037e-01f, 1.52210236e-01f, 5.67201562e-02f,
  9.83159617e-02f, 1.06881000e-01f, -1.01245143e-01f, -1.28660977e-01f, -1.65839538e-01f, 1.66730046e-01f, -1.37098525e-02f, 4.60004024e-02f, -2.96404064e-02f, 1.14277221e-01f,
  -5.41530788e-01f, 2.50108633e-02f, -5.68381786e-01f, -2.67690927e-01f, 4.71422702e-01f, -7.93235898e-01f, -4.78430986e-01f, 1.23177193e-01f, -1.20941401e-02f, 3.49066794e-01f,
  5.94749115e-02f, -2.66950995e-01f, 2.64239341e-01f, -8.20101142e-01f, -7.92190790e-01f, -6.72932684e-01f, -6.46255016e-01f, -5.52575231e-01f, -4.81125787e-02f, 1.74154818e-01f,
  -2.92982429e-01f, 1.71675291e-02f, -4.90002722e-01f, 6.31998241e-01f, -1.48768231e-01f, 4.46663201e-01f, 6.85620308e-01f, 3.73897612e-01f, -1.97249994e-01f, -1.85170069e-01f,
  -4.06640530e-01f, 2.14889139e-01f, 4.03862540e-03f, -1.04089625e-01f, 2.47060526e-02f, 1.14078142e-01f, -9.64350626e-02f, -2.64419541e-02f, -5.18192835e-02f, -8.75692293e-02f,
  1.17435426e-01f, 5.74780405e-02f, -4.88254577e-02f, 7.97283947e-02f, 1.10059105e-01f, -8.54344014e-03f, -1.66358039e-01f, -1.55123860e-01f, 7.27600530e-02f, -2.74329305e-01f,
  -2.86164820e-01f, -1.60201415e-01f, 1.12590613e-02f, 1.57590315e-01f, -1.15466546e-02f, -4.77846935e-02f, -1.55248255e-01f, -5.06880581e-02f, -7.37584382e-02f, 6.40709624e-02f,
  1.26595542e-01f, 4.08690870e-02f, -1.09729782e-01f, -1.08581200e-01f, 2.68817227e-02f, 2.59957537e-02f, 1.58990696e-02f, -7.91260600e-03f, 1.58968970e-01f, 1.57298136e-03f,
  5.96442446e-02f, -1.90229081e-02f, -4.54964601e-02f, -2.45647151e-02f, 6.28452972e-02f, 1.25343092e-02f, -8.45335424e-02f, -2.78734826e-02f, -1.29440084e-01f, -1.61547497e-01f,
  2.33252719e-01f, -1.70100003e-01f, 2.28799637e-02f, 1.06723361e-01f, -9.36123431e-02f, 1.72461525e-01f, 9.00583863e-02f, -1.73667639e-01f, -4.72826660e-02f, 1.47743955e-01f,
  1.01151370e-01f, 5.87075174e-01f, 1.46241456e-01f, 8.85097682e-02f, 2.17377190e-02f, -7.70630985e-02f, -1.98764861e-01f, -5.92086203e-02f, 1.53114602e-01f, 8.91124010e-02f,
  9.61201116e-02f, 5.22289351e-02f, 7.48968646e-02f, -2.83900872e-02f, -1.11278668e-02f, 2.00039539e-02f, 2.13073924e-01f, 1.73852384e-01f, 1.71772018e-01f, 1.22951604e-01f,
  2.09801376e-01f, 1.86492741e-01f, 1.33531690e-01f, 1.92477047e-01f, 1.10293023e-01f, 1.13773718e-01f, 1.03493109e-01f, -2.27426756e-02f, 5.55778109e-02f, 3.83356288e-02f,
  -2.73568511e-01f, 8.20094109e-01f, 6.63219035e-01f, -2.26265229e-02f, -4.02392626e-01f, 7.69448578e-01f, 1.80941746e-01f, 2.11725071e-01f, 5.32083809e-01f, 5.32573640e-01f,
  -5.16464949e-01f, 7.18116641e-01f, -6.38848320e-02f, 1.47440389e-01f, -2.44635135e-01f, -9.93463323e-02f, 1.80899099e-01f, 1.94763035e-01f, 1.36668488e-01f, -1.10550508e-01f,
  -3.41722310e-01f, -5.99455774e-01f, -4.39825177e-01f, -2.98137873e-01f, -1.13701917e-01f, 2.75371075e-01f, -6.82831168e-01f, -1.63205013e-01f, 1.14442585e-02f, -4.04567868e-02f,
  -1.45993410e-02f, 1.53515682e-01f, 1.67931318e-01f, 4.03682947e-01f, 1.32261202e-01f, 2.02547759e-01f, -3.96166071e-02f, -6.94642887e-02f, -6.19847625e-02f, 9.82796699e-02f,
  3.95040587e-02f, 1.22247748e-01f, 3.17184776e-01f, 2.95943748e-02f, 1.71465993e-01f, 2.21133754e-01f, 2.97403485e-02f, 1.28732502e-01f, 2.14682862e-01f, 6.57697320e-02f,
  -4.27093282e-02f, 1.58226982e-01f, 2.73659583e-02f, 4.80203293e-02f, -9.29871295e-03f, 1.98715419e-01f, 2.27541804e-01f, -2.96207368e-02f, 1.54988989e-01f, 2.34608501e-01f,
  -1.46073207e-01f, 1.49424046e-01f, 9.23796222e-02f, 3.61782499e-02f, -4.15001363e-02f, -6.83079883e-02f, 9.98931658e-03f, -1.74792200e-01f, 4.66591157e-02f, -6.82911053e-02f,
  -6.01931140e-02f, 7.03062192e-02f, -1.13408335e-01f, 7.08734198e-03f, -1.70099139e-01f, 1.35286018e-01f, -1.74739152e-01f, 2.53717750e-02f, 1.79127995e-02f, -5.07888570e-02f,
  -2.20109403e-01f, -1.12372898e-02f, -1.95857342e-02f, -1.80760950e-01f, -2.58024223e-02f, -5.19361794e-02f, -3.99009734e-02f, 3.40189189e-02f, -1.44501418e-01f, -1.38768092e-01f,
  2.54439056e-01f, 3.70191425e-01f, 1.50429294e-01f, 1.86177105e-01f, 8.63533318e-02f, -2.06193514e-03f, -5.35602942e-02f, 1.25331789e-01f, 3.03931683e-01f, 1.28532916e-01f,
  -8.83197188e-02f, 7.75303990e-02f, 1.15215061e-02f, -1.66332349e-01f, -6.58905283e-02f, 1.49239331e-01f, -7.37474114e-02f, 6.28585964e-02f, 7.59934261e-02f, 2.69474145e-02f,
  -2.90719997e-02f, -7.28773624e-02f, -2.96142064e-02f, -3.17785665e-02f, -3.79360951e-02f, -5.21369390e-02f, 1.08620323e-01f, 5.64555153e-02f, -1.20946907e-01f, 1.35849537e-02f,
  7.33924329e-01f, -4.70983356e-01f, -2.61030614e-01f, 6.62106425e-02f, 5.41556656e-01f, 6.68028295e-01f, 5.64209342e-01f, -1.70711532e-01f, -1.85570449e-01f, -4.69906121e-01f,
  1.23084970e-01f, 1.03085034e-01f, -2.23423272e-01f, 3.05827141e-01f, 1.06724000e+00f, -1.37649238e-01f, 4.37369347e-01f, 3.06244224e-01f, -1.73603699e-01f, 1.64979622e-01f,
  1.50993124e-01f, 5.62663674e-01f, -1.46947309e-01f, -3.65823805e-01f, 4.81678277e-01f, -4.23871487e-01f, -1.25738427e-01f, -1.34200022e-01f, 6.45973459e-02f, 4.28122401e-01f,
  1.22512057e-01f, -9.88620967e-02f, 4.12446968e-02f, -1.08807780e-01f, -4.76104431e-02f, -2.65638717e-02f, 1.11281678e-01f, 1.77665427e-01f, 4.34933789e-02f, 2.34072451e-02f,
  9.30268392e-02f, 1.15941606e-01f, 8.44376683e-02f, 9.28776413e-02f, 4.05118465e-02f, 1.39911128e-02f, -8.76683071e-02f, -9.77526605e-02f, -1.63736597e-01f, 9.07342136e-02f,
  -9.10129994e-02f, -1.27479240e-01f, -3.76603194e-02f, -1.35962799e-01f, 5.33266738e-03f, -1.05047353e-01f, -5.63802496e-02f, 6.32361621e-02f, 3.51143144e-02f, 1.04640372e-01f,
  9.10594687e-02f, -5.59898168e-02f, 4.89753438e-03f, 1.18540702e-02f, 1.48365408e-01f, 2.21741851e-03f, 1.15406737e-01f, 7.93864205e-02f, -7.08030388e-02f, 1.48887888e-01f,
  2.53267642e-02f, 4.25374173e-02f, -4.72013950e-02f, 3.48493010e-02f, 8.41440186e-02f, -7.15222433e-02f, 9.80567187e-02f, 2.11550239e-02f, -1.36902958e-01f, -6.53216615e-03f,
  2.62367669e-02f, 8.54754522e-02f, -4.25270647e-02f, -8.90425816e-02f, 3.72493528e-02f, -1.66024286e-02f, -5.03792092e-02f, 6.13262728e-02f, -8.56710970e-02f, 6.56862706e-02f,
  -6.66010529e-02f, -2.48054311e-01f, -1.41431510e-01f, -1.23482592e-01f, -7.17060864e-02f, 2.98064370e-02f, -4.11944278e-02f, 1.57402858e-01f, 8.19260031e-02f, 9.71450731e-02f,
  -1.41943824e-02f, -7.82795623e-02f, -7.48383179e-02f, 6.74065351e-02f, -8.19413662e-02f, -8.04857686e-02f, -2.25148611e-02f, -9.65671018e-02f, 4.00762223e-02f, -1.31896362e-01f,
  -2.20466871e-02f, 7.92378560e-02f, 3.28437239e-02f, -1.34458113e-02f, -3.36037911e-02f, -6.72296202e-03f, 1.19422721e-02f, -1.36241853e-01f, 9.10554174e-03f, -8.05058628e-02f,
  -7.33414173e-01f, 2.82022774e-01f, 5.86088896e-01f, -6.50308803e-02f, 5.87051094e-01f, 7.30323672e-01f, 2.48841971e-01f, 5.92083633e-01f, 6.46295547e-01f, -4.61686313e-01f,
  -5.00707448e-01f, -5.55807471e-01f, -2.59678394e-01f, -1.70503661e-01f, 3.66734952e-01f, 4.54598963e-01f, 3.11519504e-01f, -3.48846227e-01f, 5.91189086e-01f, -1.82504894e-03f,
  4.33476985e-01f, -1.45943001e-01f, 2.92146832e-01f, 1.57872543e-01f, -8.92231911e-02f, -1.20457284e-01f, -4.15906578e-01f, 4.18842196e-01f, -4.01931792e-01f, 2.48864517e-01f,
  -1.63681984e-01f, -1.46156386e-01f, -2.44401291e-01f, -3.26100402e-02f, -8.53738636e-02f, -1.38751760e-01f, 1.38562648e-02f, 4.52327402e-03f, -4.33385633e-02f, 1.41136408e-01f,
  -2.66288400e-01f, -4.66158800e-02f, -8.83057434e-03f, 4.53366190e-02f, 6.38090968e-02f, 1.11337066e-01f, 1.07100248e-01f, 3.66237909e-02f, 4.65093143e-02f, 2.04142347e-01f,
  5.92684420e-03f, 1.74570605e-01f, -2.60852091e-02f, 7.04246089e-02f, 5.93510494e-02f, 9.71957892e-02f, 1.40814349e-01f, -1.93644455e-03f, -2.26405300e-02f, 1.80696666e-01f,
  2.44764611e-01f, 1.63775697e-01f, -1.25730172e-01f, -1.02810428e-01f, -4.79961298e-02f, -2.93326322e-02f, -1.04341343e-01f, -9.06317905e-02f, 4.35682088e-02f, -9.07049701e-02f,
  -3.31935547e-02f, -4.07070555e-02f, 9.99768525e-02f, 8.16520676e-03f, -6.23012967e-02f, -1.37734100e-01f, -9.87055600e-02f, -1.67248517e-01f, 4.78377864e-02f, 6.04917370e-02f,
  -8.40664748e-03f, 5.84498607e-03f, -1.95358276e-01f, 3.18219117e-03f, -2.32530595e-03f, 5.79587445e-02f, -5.17425127e-02f, 1.17815517e-01f, -2.95990873e-02f, 9.96923354e-03f,
  -5.09005263e-02f, 1.77333392e-02f, 1.80695970e-02f, -1.64330453e-01f, -7.25062117e-02f, -1.19758040e-01f, 8.36789310e-02f, 2.70005665e-03f, 1.43067345e-01f, -5.16769327e-02f,
  -4.89983521e-02f, -9.05299261e-02f, -5.88638987e-03f, 3.37792598e-02f, -6.15680963e-02f, 1.12820096e-01f, -4.87206951e-02f, -4.55640107e-02f, 6.26234803e-04f, -1.98336262e-02f,
  -1.88702852e-01f, -1.03773065e-01f, 2.51267701e-02f, -1.05309069e-01f, -4.32935171e-02f, -2.10469767e-01f, -8.54665339e-02f, 9.45884064e-02f, 1.73089840e-02f, 1.50491834e-01f,
  -1.20397910e-01f, 6.92898512e-01f, 6.38119638e-01f, 2.27510616e-01f, -2.62663841e-01f, -5.96258342e-01f, -3.53647232e-01f, 4.05116498e-01f, 2.72741914e-01f, 1.56436726e-01f,
  -2.84144789e-01f, 6.55370533e-01f, 2.87944049e-01f, 7.77958706e-02f, -5.65061986e-01f, -1.31672010e-01f, -3.69408578e-01f, -2.03617156e-01f, 1.91504642e-01f, 2.47493088e-01f,
  5.42275980e-02f, -8.35518017e-02f, -1.03185497e-01f, 1.71827972e-01f, 3.13156575e-01f, 3.93049061e-01f, -4.89134490e-01f, 3.14478487e-01f, -1.09248497e-01f, -6.46483079e-02f,
  -2.50679344e-01f, 4.60403413e-01f, 1.69490159e-01f, 3.29062343e-02f, -2.37969279e-01f, -1.79405242e-01f, -1.60760298e-01f, 6.79545999e-02f, -1.06915697e-01f, 8.96483883e-02f,
  1.83398902e-01f, 2.08677217e-01f, -3.27972770e-02f, 1.09081611e-01f, 1.06456257e-01f, 1.26432136e-01f, 3.07172202e-02f, -1.75946102e-01f, 2.41482005e-01f, 1.27920657e-01f,
  2.98672706e-01f, 3.52813415e-02f, -4.77730250e-03f, -4.43840250e-02f, 8.17387551e-02f, 4.47083116e-02f, -2.23731473e-01f, 2.71456689e-03f, 7.85067491e-03f, 8.62823948e-02f,
  2.58893579e-01f, -2.22092897e-01f, -4.62489873e-02f, -7.51365721e-02f, 1.39504537e-01f, -3.40631530e-02f, -4.10030484e-02f, -6.66473210e-02f, 7.40308836e-02f, -2.10040227e-01f,
  -1.61290646e-01f, -6.15942888e-02f, -1.89853611e-03f, -2.56268680e-01f, -4.38482426e-02f, -8.27480294e-03f, -1.74613237e-01f, 4.11839485e-02f, -8.38636383e-02f, -5.50379641e-02f,
  2.00285539e-01f, -1.34059042e-01f, 3.01645882e-02f, -1.85216799e-01f, -2.21800745e-01f, 2.02848352e-02f, 5.85666150e-02f, 7.50295520e-02f, -5.32901585e-02f, 1.04167378e-02f,
  -1.73952252e-01f, 2.09405214e-01f, 1.04857117e-01f, 3.86154093e-02f, 5.35437465e-02f, -1.65061757e-01f, 1.62278954e-02f, 8.55894610e-02f, 2.83570178e-02f, 8.68310046e-04f,
  -1.46321803e-01f, -1.10167705e-01f, -3.12545985e-01f, -8.14381316e-02f, -1.26174435e-01f, -1.22123070e-01f, -1.90473795e-01f, -8.14204812e-02f, -1.23727724e-01f, 1.05334166e-02f,
  1.62128985e-01f, -1.52295768e-01f, 3.53387631e-02f, 4.14687023e-02f, 4.80336845e-02f, -8.95497575e-02f, -2.20053103e-02f, 8.68142694e-02f, -2.92259007e-04f, -1.49382979e-01f,
  9.49739814e-01f, -7.72299618e-02f, 2.75492251e-01f, 5.17816842e-01f, 1.83771431e-01f, 1.03478681e-03f, -1.23468935e-01f, 8.54317918e-02f, 2.91355848e-01f, -1.18855774e-01f,
  -2.15383962e-01f, -3.16811383e-01f, -5.80172777e-01f, -2.99859226e-01f, -6.51612997e-01f, -4.92066473e-01f, 6.70837089e-02f, -1.35438681e-01f, -7.41135925e-02f, 3.81498337e-01f,
  1.44126475e-01f, -5.74849010e-01f, -3.53064328e-01f, -2.10772499e-01f, 4.50270444e-01f, 3.64644438e-01f, 1.71698689e-01f, -1.16797477e-01f, 1.63979903e-01f, -5.25978208e-01f,
  -3.59303392e-02f, -8.30450878e-02f, -2.89716478e-02f, -1.47084936e-01f, 1.91936016e-01f, 1.34934664e-01f, 1.48727834e-01f, -2.83915162e-01f, -1.03907414e-01f, 1.97016057e-02f,
  7.65113011e-02f, 3.22766113e-03f, -7.36858696e-03f, -1.27327904e-01f, 1.03571311e-01f, 1.05349280e-01f, 7.17112571e-02f, 3.01211208e-01f, -6.33375198e-02f, -4.27448750e-03f,
  1.70317590e-01f, 1.07486688e-01f, 2.91799754e-01f, -4.35972400e-02f, 1.89627439e-01f, 1.99694168e-02f, 7.74394646e-02f, -5.96814156e-02f, 1.66015014e-01f, -3.82302254e-02f,
  1.72507465e-02f, -6.53057247e-02f, -2.02533171e-01f, -7.57232355e-03f, -6.68923697e-03f, 5.10271713e-02f, -4.13407050e-02f, -8.03370923e-02f, 1.09513842e-01f, 1.41872268e-03f,
  1.38561517e-01f, -1.47613948e-02f, -5.06139025e-02f, 1.32177189e-01f, 4.23912741e-02f, 2.75569619e-03f, -1.12982392e-01f, 7.84436911e-02f, 2.39131227e-01f, 7.11631030e-02f,
  -1.82358116e-01f, 5.57138631e-03f, -8.10925812e-02f, 1.13930777e-01f, -1.48088843e-01f, -1.14244647e-01f, 8.20122510e-02f, 1.23086751e-01f, 1.09022237e-01f, 5.77485701e-03f,
  6.52579241e-04f, -4.53257523e-02f, -3.30332965e-02f, -1.25165209e-01f, 2.76845340e-02f, 1.13244876e-01f, 1.64441392e-02f, 5.98260835e-02f, -6.94598556e-02f, -7.01105297e-02f,
  2.32711628e-01f, 1.11733533e-01f, 1.97784811e-01f, -3.90563048e-02f, -1.69686556e-01f, 9.78030488e-02f, 5.87483346e-02f, -6.09729514e-02f, -1.69197042e-02f, 1.92591324e-01f,
  2.54413277e-01f, 1.25825077e-01f, 4.20845747e-02f, 1.68462753e-01f, 2.93051153e-02f, -3.42203863e-02f, 1.57975137e-01f, 1.22280782e-02f, -5.84981171e-03f, -9.37719494e-02f,
  -1.35643566e+00f, 8.61361384e-01f, -5.05130179e-02f, -5.96306264e-01f, -2.65858561e-01f, -4.26944256e-01f, -3.64070565e-01f, -7.60897547e-02f, -2.76774704e-01f, 4.44378436e-01f,
  -4.29085121e-02f, -2.28927121e-01f, 3.85699511e-01f, 4.84464988e-02f, -5.68637788e-01f, 5.24413407e-01f, -3.28769207e-01f, -2.52080798e-01f, -9.37193334e-02f, -4.61728126e-01f,
  -2.24638775e-01f, -2.87286520e-01f, 2.28508525e-02f, 2.12199464e-01f, -3.57101530e-01f, -2.37831488e-01f, -5.40535524e-02f, 8.76136944e-02f, -1.14616096e-01f, 4.42253090e-02f,
  -8.91722560e-01f, -6.00045502e-01f, -3.46337348e-01f, -1.67045981e-01f, -2.90946305e-01f, -2.22232714e-01f, -1.02842458e-01f, -5.59729449e-02f, -2.47862652e-01f, -4.96659502e-02f,
  -1.69527661e-02f, -1.47881331e-02f, -9.42974836e-02f, 4.81408425e-02f, -1.56495437e-01f, -7.35198557e-02f, 6.27979636e-02f, -1.13076717e-01f, -8.09863955e-02f, 1.08489171e-01f,
  1.75301224e-01f, 1.92857590e-02f, -1.99118126e-02f, 1.01896159e-01f, -9.30099115e-02f, -9.29076299e-02f, -1.26741892e-02f, 5.05977608e-02f, -1.35881528e-01f, -7.26520047e-02f,
  -1.92573126e-02f, -8.30941349e-02f, 9.49072167e-02f, -1.63123328e-02f, -9.61522534e-02f, 8.03222209e-02f, 7.52891228e-02f, -3.90927941e-02f, -7.83003401e-04f, -1.01327645e-02f,
  -9.21704397e-02f, -8.64205360e-02f, -2.89388131e-02f, -2.88585089e-02f, -1.08564220e-01f, -1.34846419e-01f, -1.94680039e-02f, -1.86229255e-02f, 3.26556750e-02f, -7.43118897e-02f,
  -1.00469269e-01f, 1.34688720e-01f, -3.26993912e-02f, 9.20076296e-02f, 1.87775455e-02f, -1.58178564e-02f, 5.00394665e-02f, 1.51382670e-01f, -2.55987607e-02f, -4.28459495e-02f,
  -1.26111388e+00f, -1.05464375e+00f, -1.90585539e-01f, -3.93190086e-01f, -7.96288624e-02f, 2.03602249e-03f, 3.88926640e-02f, -5.34773944e-03f, -1.49598196e-01f, -1.46810845e-01f,
  -2.04980560e-02f, 1.72942370e-01f, -2.07616523e-01f, -8.46029520e-02f, -7.49271065e-02f, -2.08746605e-02f, -9.15754810e-02f, -8.90533254e-02f, -3.40192497e-01f, -2.10176468e-01f,
  -5.39070070e-02f, 3.57408002e-02f, 1.38363689e-01f, -5.46610281e-02f, -1.44793391e-01f, -1.88856930e-01f, -1.11149713e-01f, 9.38401744e-02f, -4.15441953e-02f, 1.48318350e-01f,
  3.50332022e-01f, -2.80372441e-01f, -7.57090449e-01f, -4.04917806e-01f, 5.09680092e-01f, 4.64714170e-01f, -6.57426863e-05f, 2.64586598e-01f, -3.28882337e-01f, 4.65324819e-01f,
  4.41257417e-01f, -4.24915701e-01f, -2.35112414e-01f, -1.18334226e-01f, -3.97210866e-01f, -4.58326340e-01f, -1.12031825e-01f, 1.82874184e-02f, -1.89208493e-01f, -1.05483821e-02f,
  -2.16363937e-01f, 6.65710866e-01f, -6.03104115e-01f, 6.02760673e-01f, 4.55219746e-01f, 5.90883642e-02f, 3.68849158e-01f, 3.29041444e-02f, 2.66352594e-01f, 1.83795720e-01f,
  -1.74448499e-03f, -8.52943137e-02f, -1.00193232e-01f, -7.25010484e-02f, -6.03379272e-02f, 1.66833818e-01f, -4.13392261e-02f, -5.41770607e-02f, -1.49303272e-01f, -2.55726486e-01f,
  8.20547994e-03f, -9.74084064e-03f, 2.30990034e-02f, -3.08482964e-02f, 2.73739010e-01f, 3.10674701e-02f, -1.40097052e-01f, -1.09454490e-01f, -8.62134397e-02f, -9.74299610e-02f,
  -1.51443869e-01f, -9.03959125e-02f, 1.22032382e-01f, -1.55671716e-01f, -1.40433788e-01f, 3.91825587e-02f, 4.41061221e-02f, -4.00522612e-02f, 8.39807689e-02f, 4.13208455e-03f,
  2.48996332e-01f, 1.70879275e-01f, 7.11459666e-02f, 1.51280770e-02f, -3.77032384e-02f, 2.82140300e-02f, 9.51999128e-02f, -6.89490512e-02f, -1.98707327e-01f, 6.25844896e-02f,
  -5.87045923e-02f, 5.01132011e-03f, 1.40810579e-01f, 2.85502244e-02f, 1.72980055e-02f, -7.27394298e-02f, -1.96764469e-02f, 2.18910519e-02f, -9.23318714e-02f, -1.23931631e-01f,
  4.81883287e-02f, -3.01892441e-02f, 3.65036651e-02f, 7.18064979e-02f, 7.51207992e-02f, -1.57773659e-01f, 1.40045539e-01f, 3.31087522e-02f, -1.31834447e-01f, 4.92261872e-02f,
  -3.19795869e-02f, 5.83540015e-02f, -1.02900654e-01f, 5.70287555e-02f, -1.70760542e-01f, 1.69978917e-01f, -3.50668728e-02f, -4.78481352e-02f, 1.29281834e-01f, 5.21937348e-02f,
  5.56593016e-02f, 1.15244702e-01f, 1.22100331e-01f, -1.27179340e-01f, -1.65524036e-01f, 1.85205534e-01f, 3.06803044e-02f, -1.24973044e-01f, 1.19537391e-01f, -9.09279939e-03f,
  1.81369513e-01f, 1.19626842e-01f, -1.24581289e-02f, -2.07357947e-02f, -8.85670132e-04f, 2.40641728e-01f, 1.27621442e-01f, -2.35563815e-02f, 8.72798339e-02f, -1.50372937e-01f,
  9.00404155e-01f, -3.01885575e-01f, -2.55946547e-01f, 6.05515122e-01f, 4.52341914e-01f, -9.83478203e-02f, -1.75057456e-01f, 4.59383696e-01f, 4.79913533e-01f, -4.28654820e-01f,
  2.25703776e-01f, -5.04238009e-01f, -5.15265763e-01f, 6.06672049e-01f, 6.30918860e-01f, -3.25768381e-01f, 6.13016605e-01f, -8.77412483e-02f, 2.23598003e-01f, 3.60963404e-01f,
  4.65145826e-01f, 5.79715729e-01f, 4.22748849e-02f, 3.33533496e-01f, 3.80102605e-01f, 5.32860495e-02f, 1.45313457e-01f, -3.05539280e-01f, 9.84109119e-02f, -3.26998234e-02f,
  3.27026770e-02f, 2.63929784e-01f, 9.49691907e-02f, -7.04829544e-02f, 3.34002636e-02f, -1.60928831e-01f, -2.99791247e-01f, -2.33142972e-01f, 3.22920457e-02f, -9.47201345e-03f,
  -1.75208807e-01f, 4.15618904e-02f, 1.20935045e-01f, -3.99671011e-02f, 1.99306637e-01f, 1.22327931e-01f, 5.78719974e-02f, -8.70093107e-02f, -7.14405030e-02f, -8.59324075e-03f,
  4.48943414e-02f, -1.28046479e-02f, 1.87252045e-01f, 4.87475889e-04f, 1.00048520e-01f, 1.13056384e-01f, -1.84430420e-01f, -1.20214798e-01f, 7.22081447e-03f, 1.55554965e-01f,
  1.12911083e-01f, -9.04939622e-02f, -6.09693164e-03f, 1.73618644e-02f, 7.37592876e-02f, 9.74088833e-02f, 2.73115300e-02f, -1.17911525e-01f, 8.17905813e-02f, -8.25425982e-02f,
  5.64941317e-02f, 1.40319303e-01f, 8.03797990e-02f, -2.72916220e-02f, 1.54900447e-01f, 1.29060254e-01f, -1.07904412e-01f, -8.84760171e-02f, 1.15519851e-01f, 2.33056080e-02f,
  -2.07883809e-02f, 9.11365002e-02f, -1.04144633e-01f, -9.86678302e-02f, -2.66184937e-03f, -3.24302763e-02f, 7.22863451e-02f, 1.78551080e-03f, -7.56545737e-02f, -4.23711874e-02f,
  -1.51762292e-01f, 1.67094782e-01f, -7.89523125e-02f, -3.62601951e-02f, -1.48453772e-01f, 1.60769105e-01f, -4.46328782e-02f, 1.82045579e-01f, 7.78967962e-02f, 1.58001259e-01f,
  1.05650045e-01f, -8.87901410e-02f, -1.18903130e-01f, 3.27251963e-02f, -1.14600636e-01f, 1.38005033e-01f, -1.62034839e-01f, -4.78643313e-04f, 2.37121917e-02f, 2.89489347e-02f,
  -7.60123059e-02f, -4.50458601e-02f, -2.01143250e-02f, 1.00604475e-01f, -3.84247792e-03f, -1.19947739e-01f, -1.07711181e-02f, -1.22623928e-01f, -3.63062806e-02f, -2.88250539e-02f,
  5.49638569e-01f, 1.08595993e-02f, 2.06850804e-02f, 6.59794569e-01f, 6.03889003e-02f, -7.61153102e-01f, -4.69357342e-01f, -9.08124819e-03f, 5.04123330e-01f, -3.77589315e-01f,
  -3.08401525e-01f, 4.71681982e-01f, -7.03567863e-01f, -9.84678045e-03f, -6.85906589e-01f, -5.21192789e-01f, -1.05517946e-01f, 7.03469217e-02f, 3.05885166e-01f, -8.53413865e-02f,
  2.48406500e-01f, -2.93832093e-01f, -1.94958057e-02f, -6.98004737e-02f, 1.36592790e-01f, 4.93154317e-01f, -1.77934110e-01f, -1.84974268e-01f, 2.58015484e-01f, -4.96219918e-02f,
  -1.87906906e-01f, 3.31587285e-01f, 2.02382222e-01f, -1.54207364e-01f, -1.28563181e-01f, -1.28633459e-03f, -3.83558720e-02f, -1.23677842e-01f, 8.84951279e-02f, 1.56523079e-01f,
  -8.49952921e-02f, 1.29659204e-02f, 1.96843699e-01f, 6.22671889e-03f, 2.21028432e-01f, 2.62824804e-01f, 8.88523683e-02f, 1.92438737e-01f, 1.42412812e-01f, 1.56615958e-01f,
  2.76065655e-02f, 7.94635117e-02f, 8.73328224e-02f, -9.91120264e-02f, 4.36212048e-02f, 2.99060475e-02f, 1.52928913e-02f, -2.88804434e-02f, -5.54721467e-02f, 2.10828096e-01f,
  8.24968219e-02f, 3.96730565e-02f, -1.40484730e-02f, 1.56606421e-01f, -1.53963521e-01f, 1.26424640e-01f, -6.71859756e-02f, -1.52782977e-01f, -2.56747454e-02f, -1.16780931e-02f,
  -1.24175616e-01f, 2.26102829e-01f, 3.46146151e-02f, -8.47475603e-03f, 6.05954677e-02f, 1.43554062e-01f, -5.08440547e-02f, -1.09451137e-01f, 4.91925739e-02f, -3.00130453e-02f,
  4.30205911e-02f, -2.14421079e-01f, 1.34761147e-02f, 7.83887226e-03f, -1.53784081e-01f, -1.54355198e-01f, 3.24409083e-02f, 1.07964706e-02f, -5.17788231e-02f, -1.63255483e-01f,
  -8.94495547e-01f, -7.94506907e-01f, -4.83996272e-02f, 7.47849867e-02f, -9.99022797e-02f, -8.79059359e-03f, -8.14922154e-02f, 1.55632213e-01f, -1.58829167e-01f, -7.07650483e-02f,
  2.79267561e-02f, -1.68618206e-02f, 2.18684599e-02f, -1.08564617e-02f, -1.45382106e-01f, -5.97211793e-02f, -1.04202010e-01f, -8.20567273e-03f, -3.74857448e-02f, 6.05225423e-03f,
  1.02691622e-02f, -4.40632738e-03f, -3.31032574e-02f, 6.76220357e-02f, 5.75937480e-02f, 9.17893201e-02f, 1.16985597e-01f, 1.36562690e-01f, -1.93787932e-01f, -7.24062789e-04f,
  -1.09467041e+00f, -2.98976064e-01f, -2.17182457e-01f, 6.53786361e-01f, -5.97554803e-01f, -1.50830716e-01f, 2.01749310e-01f, -2.12592959e-01f, -3.24311331e-02f, 2.19571754e-01f,
  1.52973771e-01f, -2.26176575e-01f, -3.00578684e-01f, 7.69878447e-01f, 1.24125570e-01f, 2.89321989e-01f, 6.48813486e-01f, 4.20578152e-01f, -5.02730571e-02f, -2.44740427e-01f,
  8.41619596e-02f, 4.79530096e-01f, 4.11543757e-01f, 1.46944180e-01f, -4.08893414e-02f, 1.75894767e-01f, 4.01665509e-01f, -4.69786450e-02f, 6.24917567e-01f, 1.45760238e-01f,
  -3.79240125e-01f, -1.53257042e-01f, -7.97813816e-04f, -5.04327901e-02f, -2.15329543e-01f, 4.35366482e-03f, -9.81258526e-02f, 3.22765186e-02f, 5.07597532e-03f, -9.89252180e-02f,
  -1.12120718e-01f, -5.64428307e-02f, 6.87654838e-02f, 1.63490325e-02f, -1.56162083e-01f, 6.32076114e-02f, -1.51063874e-01f, -6.68593869e-02f, -1.45298988e-01f, -1.75361231e-01f,
  -1.34884700e-01f, 1.06689492e-02f, 1.62482381e-01f, 2.05515981e-01f, -8.37402940e-02f, -2.71773257e-04f, 2.51968592e-01f, -1.35323450e-01f, 8.41851309e-02f, 2.74295770e-02f,
  1.84476510e-01f, -2.42773611e-02f, -8.58445317e-02f, -2.44836253e-03f, -3.33875082e-02f, 1.82733968e-01f, 1.90606475e-01f, 6.81918934e-02f, 2.49494500e-02f, -7.82998800e-02f,
  3.30819786e-02f, -3.98725420e-02f, 4.64392640e-03f, 9.00814217e-03f, 4.91280714e-03f, 1.89767275e-02f, -3.91542800e-02f, -1.40469804e-01f, -1.08096689e-01f, 5.88922426e-02f,
  1.08215563e-01f, -8.86289552e-02f, -5.29332459e-02f, -1.78485876e-03f, 4.01995331e-02f, -9.59126204e-02f, 9.41871572e-03f, -2.01675086e-03f, -6.10696226e-02f, -6.79143220e-02f,
  -7.15801239e-01f, -4.75975461e-02f, 3.85222584e-02f, -2.71238297e-01f, 1.49740860e-01f, -8.59125406e-02f, 1.19646229e-01f, -9.39445943e-02f, 6.32574558e-02f, -1.36608228e-01f,
  -3.76269333e-02f, 1.21670425e-01f, -6.26373962e-02f, -1.77779701e-02f, 9.85001698e-02f, -7.90475532e-02f, 8.07542205e-02f, -3.53613794e-02f, 4.58847880e-02f, -5.16060181e-03f,
  2.46955268e-02f, -1.07802637e-01f, 3.64521183e-02f, 2.82490533e-02f, 1.89851165e-01f, -7.08709136e-02f, -1.54015943e-01f, 7.67164910e-03f, -1.76463253e-03f, 1.26098886e-01f,
  -4.30394679e-01f, -1.01337981e+00f, 2.39572555e-01f, -3.91982436e-01f, 4.30841506e-01f, 7.39071131e-01f, 1.04424253e-01f, -9.26411748e-02f, -6.69556201e-01f, -4.58073407e-01f,
  -9.19767916e-02f, -2.00951964e-01f, -2.83788145e-01f, -4.30278748e-01f, 4.22542185e-01f, -3.54748487e-01f, -6.88554421e-02f, -9.96050537e-02f, -1.40708193e-01f, -4.52967510e-02f,
  -5.03355451e-03f, 1.55279748e-02f, 4.11229610e-01f, 3.84289175e-01f, 1.45265415e-01f, 6.10034764e-02f, 1.61162138e-01f, 3.04970175e-01f, 3.00860375e-01f, 1.25937939e-01f,
  4.01203036e-02f, -4.22374964e-01f, -1.54942214e-01f, 1.28783807e-01f, 4.61742394e-02f, 1.35022074e-01f, 8.45405385e-02f, 1.98117182e-01f, 1.28103212e-01f, 1.17424548e-01f,
  -2.68990882e-02f, 2.45779261e-01f, 9.20817815e-03f, -1.46168303e-02f, 5.88233322e-02f, 3.01537737e-02f, 1.40749484e-01f, -4.54412140e-02f, -5.48280915e-03f, 1.00123949e-01f,
  1.71733975e-01f, 1.29536670e-02f, 9.75617860e-03f, 7.82542452e-02f, 3.62646393e-02f, -4.42829765e-02f, 9.10553038e-02f, 1.88981429e-01f, -3.54805551e-02f, 4.14948240e-02f,
  4.16998863e-02f, 1.76060408e-01f, 9.11513865e-02f, 1.19334843e-04f, -7.22186565e-02f, -4.66611423e-03f, -4.75452840e-02f, 3.12400446e-03f, 1.12386748e-01f, -8.49695429e-02f,
  -5.19851372e-02f, -1.52846828e-01f, -1.84168369e-01f, 1.18588388e-01f, 1.57130957e-02f, -1.33836329e-01f, -3.79683785e-02f, 4.43274789e-02f, 9.09629986e-02f, 1.79725531e-02f,
  -8.99807662e-02f, 1.07698545e-01f, -8.60552266e-02f, 5.31315580e-02f, -2.02977419e-01f, 2.01147363e-01f, 2.65270402e-03f, -2.17542738e-01f, 2.87463218e-02f, 2.32156649e-01f,
  -1.14917904e-01f, -5.55808604e-01f, -3.17341648e-02f, 5.07054292e-02f, -4.21849154e-02f, -2.27299184e-02f, -1.11616710e-02f, -3.72284278e-02f, -2.60762900e-01f, -6.19476363e-02f,
  1.98164776e-01f, 6.22007996e-02f, -9.69502106e-02f, 6.00617826e-02f, 2.87291277e-02f, -1.08941264e-01f, 3.86936441e-02f, -5.52487597e-02f, -4.95210588e-02f, -1.80515833e-02f,
  -4.97968718e-02f, 9.63190347e-02f, 1.27526283e-01f, 2.80387521e-01f, 1.69332363e-02f, 8.50186944e-02f, -3.40229981e-02f, -3.80686522e-02f, 1.42584532e-01f, -3.62363532e-02f,
  -8.53747055e-02f, -2.66192973e-01f, -1.52398974e-01f, -5.02765812e-02f, -1.23097703e-01f, -1.56806901e-01f, -7.11192548e-01f, 2.16652691e-01f, -5.61968446e-01f, -4.28640902e-01f,
  -1.46072754e-03f, -4.16840136e-01f, -5.15385866e-01f, 3.46991926e-01f, 4.55383420e-01f, -3.82235855e-01f, 4.30996448e-01f, 7.87934884e-02f, 8.42509419e-02f, 3.38825583e-01f,
  2.76004046e-01f, 4.97605234e-01f, 4.21310902e-01f, 7.01332688e-01f, 1.59476101e-01f, 3.68471533e-01f, 5.12590468e-01f, 1.78686723e-01f, 4.89655465e-01f, 1.56080812e-01f,
  7.20914360e-03f, 1.25632565e-02f, -9.34218056e-03f, -1.07247084e-01f, 2.03597024e-01f, 5.63259656e-03f, 3.75089236e-02f, 1.26829846e-02f, 7.20090196e-02f, -5.35596125e-02f,
  -7.03136325e-02f, 7.81571567e-02f, -6.65553333e-03f, 2.90019363e-02f, -9.64605063e-02f, -6.27264902e-02f, -6.45141527e-02f, -3.53330374e-02f, -7.84585401e-02f, -9.88159552e-02f,
  -1.87438533e-01f, -7.72875845e-02f, -1.69910669e-01f, -1.27418488e-01f, -2.80867040e-01f, -9.82600749e-02f, -1.24883458e-01f, -1.94716975e-01f, -9.70457792e-02f, -2.16490012e-02f,
  1.22484162e-01f, -1.08964905e-01f, -1.36824930e-02f, -1.39837891e-01f, 1.56078013e-02f, -1.14958910e-02f, 1.25196446e-02f, -4.30830829e-02f, -8.96523241e-03f, 3.74060720e-02f,
  -2.37038080e-02f, 1.89288817e-02f, -9.27697048e-02f, 3.16600688e-02f, 1.30515799e-01f, 9.02672336e-02f, 1.27893478e-01f, 1.37291357e-01f, -2.10778922e-01f, 4.91865911e-02f,
  -1.40919790e-01f, 1.36392057e-01f, -9.88371745e-02f, 4.60649095e-02f, -7.45612476e-03f, -1.74009755e-01f, 4.22528386e-02f, -2.20933948e-02f, 1.13110550e-01f, 6.75619766e-02f,
  1.11893617e-01f, 2.23308042e-01f, -1.76330302e-02f, 2.16496773e-02f, -3.29625979e-02f, 1.08281694e-01f, 3.59689631e-02f, 9.39895734e-02f, 1.78115896e-03f, 7.19003156e-02f,
  1.97519690e-01f, 9.21369493e-02f, 5.76029532e-02f, 3.55779147e-03f, 1.95308968e-01f, -6.35655746e-02f, 6.80829287e-02f, -1.11363325e-02f, 3.62583362e-02f, 3.44176054e-01f,
  -5.10366671e-02f, -1.83192492e-02f, -1.56552568e-01f, -1.81969225e-01f, -9.87432301e-02f, -1.03530683e-01f, 4.19700295e-02f, 2.27013286e-02f, 2.90166978e-02f, -1.01824321e-01f,
  2.67258525e-01f, -6.46870375e-01f, 3.34936529e-01f, -7.40393549e-02f, 1.97036907e-01f, 1.15527660e-01f, 4.05912876e-01f, -3.04477334e-01f, -8.89284760e-02f, -5.67853212e-01f,
  2.63820559e-01f, -3.35190564e-01f, 5.09113014e-01f, -2.70580411e-01f, 6.54260635e-01f, 5.97359948e-02f, -4.04532194e-01f, -5.16349137e-01f, -2.29952671e-02f, -3.80328357e-01f,
  -1.23989411e-01f, -4.34057236e-01f, 2.59732544e-01f, -5.95988929e-01f, 6.07294403e-03f, -3.30271482e-01f, -1.15841396e-01f, 8.58863220e-02f, -3.01384389e-01f, -5.74228689e-02f,
  1.67406529e-01f, 1.93145692e-01f, 2.62700886e-01f, 8.58293921e-02f, 1.73697919e-01f, 1.39233321e-01f, -3.76811973e-03f, 8.67057666e-02f, 1.13263123e-01f, -5.01900241e-02f,
  -1.37657616e-02f, -7.50932246e-02f, -1.90750614e-01f, -4.40155007e-02f, -1.23129055e-01f, -2.48168991e-03f, 5.65626808e-02f, 2.00585783e-01f, -4.20472585e-02f, 2.71484554e-01f,
  2.71415174e-01f, -7.56165059e-03f, 4.97236177e-02f, -2.44162202e-01f, 1.69884861e-01f, 9.51792821e-02f, 1.33819118e-01f, 7.64858201e-02f, -1.52772203e-01f, -5.17931245e-02f,
  -1.70505077e-01f, -2.62671746e-02f, 2.43170142e-01f, 1.52236491e-01f, 1.62394166e-01f, 1.42248169e-01f, -1.14210166e-01f, -6.06160574e-02f, -2.04194859e-01f, 1.92015812e-01f,
  -9.20790806e-02f, -1.75448865e-01f, 1.91889405e-02f, -1.35481179e-01f, -4.63966765e-02f, 1.96430627e-02f, -6.36734292e-02f, -1.10631093e-01f, 5.88823408e-02f, 6.18349612e-02f,
  -1.02021089e-02f, -2.69178420e-01f, -2.26894580e-02f, -1.93649884e-02f, 5.11799641e-02f, 1.61489680e-01f, -2.51209378e-01f, 8.15988556e-02f, 8.60917643e-02f, -4.84998859e-02f,
  -2.89670080e-02f, -6.04448676e-01f, 1.60643458e-01f, -2.44562909e-01f, -5.87067306e-02f, 3.41729894e-02f, 5.59138283e-02f, -3.26704592e-01f, -6.12397790e-02f, 2.14648936e-02f,
  -2.82579511e-01f, -1.56440631e-01f, -8.88597220e-02f, -1.95807919e-01f, -2.63563484e-01f, -2.31712293e-02f, -2.17986599e-01f, -1.97069705e-01f, -6.49136826e-02f, -2.50152022e-01f,
  -1.67961419e-01f, -2.62710005e-01f, -3.33797783e-02f, -6.46887124e-02f, -3.76342684e-01f, 5.29014207e-02f, -1.33379191e-01f, 5.96718416e-02f, -9.30593833e-02f, -2.18062416e-01f,
  1.08762875e-01f, -4.05923069e-01f, 1.26866385e-01f, -8.20934623e-02f, -1.94773704e-01f, -5.01093626e-01f, -3.14970493e-01f, -3.32172632e-01f, -1.98587462e-01f, -5.81679046e-01f,
  -2.19154164e-01f, 1.82992667e-01f, 4.07888204e-01f, -4.93701637e-01f, 6.75706089e-01f, 3.72630805e-01f, -3.11041862e-01f, -1.04112752e-01f, 9.80198681e-02f, -2.09945172e-01f,
  2.84371346e-01f, -3.88891667e-01f, 4.71972466e-01f, -4.42444205e-01f, -3.02291363e-01f, -6.91491663e-02f, 3.86949301e-01f, 4.17483114e-02f, -3.53539586e-01f, 1.49124227e-02f,
  -1.66703567e-01f, 1.74574014e-02f, -3.37459594e-02f, -1.35185316e-01f, -2.91527193e-02f, -8.86408240e-02f, -6.56261295e-03f, 1.10810883e-01f, -7.43516674e-03f, 5.19918092e-02f,
  5.42970514e-03f, -7.08711147e-03f, -7.13021532e-02f, 2.01025873e-01f, -2.64630467e-01f, 8.60106573e-02f, -3.30965593e-02f, 9.81698185e-03f, -8.30749869e-02f, 9.59259868e-02f,
  -2.93005873e-02f, 7.93741643e-02f, 9.97466817e-02f, 1.32254392e-01f, 2.02467069e-01f, -1.56930283e-01f, 1.78301871e-01f, 1.51540950e-01f, -8.23092759e-02f, 1.67137838e-03f,
  3.55051011e-02f, 3.13457008e-03f, -8.19339007e-02f, -1.17771082e-01f, -8.47668126e-02f, -1.02662325e-01f, 2.35577300e-02f, 1.55769689e-02f, 8.01868141e-02f, -3.90034728e-02f,
  -6.72742724e-02f, 1.22833326e-01f, -1.47506446e-01f, -9.84183475e-02f, -3.95939425e-02f, 8.62536728e-02f, -2.08939370e-02f, -4.86057624e-02f, -1.29598215e-01f, -2.65373047e-02f,
  -4.98891575e-03f, -1.66319773e-01f, -9.49886069e-02f, 1.61354363e-01f, -5.70058599e-02f, 1.55524299e-01f, -5.85818477e-02f, 1.12961447e-02f, -1.25846788e-01f, 8.74650627e-02f,
  4.74709645e-02f, 7.72305131e-02f, -1.32456347e-01f, -8.92427415e-02f, 3.30993645e-02f, -1.35499671e-01f, 4.82418649e-02f, -8.66433010e-02f, 1.00432403e-01f, -7.08363354e-02f,
  -1.94060385e-01f, 8.36391449e-02f, -1.73346624e-02f, -7.48770684e-02f, 1.17593266e-01f, -8.17476362e-02f, 6.15380630e-02f, -8.90229568e-02f, 1.45799533e-01f, 1.43083975e-01f,
  7.81227946e-02f, -9.41521581e-03f, 1.35174036e-01f, -6.82519078e-02f, 6.02310635e-02f, 9.47353989e-02f, 1.20795518e-02f, 1.11147184e-02f, 1.10658593e-01f, 8.98578241e-02f,
  -3.73763889e-02f, 9.58845735e-01f, -2.59056711e-03f, 8.69823456e-01f, -4.60578978e-01f, 1.24793947e-01f, 6.39918506e-01f, 8.35457221e-02f, 2.51671702e-01f, 7.19105124e-01f,
  1.39114186e-01f, 2.01203346e-01f, 3.13189328e-01f, 7.96434045e-01f, -3.05469692e-01f, 4.96432900e-01f, 9.33122754e-01f, 3.98509622e-01f, -1.08656168e-01f, 5.19158483e-01f,
  6.41505793e-02f, 5.65473735e-01f, 1.19805351e-01f, -1.01569347e-01f, 1.54635817e-01f, -1.19003408e-01f, -2.89981235e-02f, -4.94846553e-01f, 1.70188293e-01f, -2.48507306e-01f,
  2.97130197e-02f, 3.37584436e-01f, -5.48940860e-02f, -3.98349836e-02f, 1.15070060e-01f, -1.03180304e-01f, -2.59672124e-02f, -1.65506706e-01f, -2.09794298e-01f, 1.24962710e-01f,
  9.85903144e-02f, -1.34159639e-01f, 1.06041051e-01f, -1.44236371e-01f, -4.47779223e-02f, -1.58043116e-01f, -2.69418117e-02f, -6.39820173e-02f, 2.79654370e-04f, -5.27356565e-03f,
  -1.36007508e-02f, 6.52263314e-02f, 7.13663623e-02f, 2.11291939e-01f, -1.54091656e-01f, 6.83053881e-02f, 5.83055727e-02f, -2.05463469e-02f, 2.20716409e-02f, -2.16760463e-03f,
  3.19191068e-02f, 1.94684803e-01f, 8.01867992e-02f, -1.22925319e-01f, -1.92577522e-02f, -6.97996914e-02f, 6.02749884e-02f, -2.68084742e-02f, -5.91653027e-03f, 7.25857317e-02f,
  -1.95979506e-01f, -7.17643127e-02f, 2.20122794e-03f, 7.59265944e-02f, 1.02694578e-01f, 1.14471763e-01f, -1.11837901e-01f, 2.82625132e-03f, -3.04816570e-03f, -1.38147280e-01f,
  5.17657101e-02f, -2.49655321e-02f, -6.45122156e-02f, -6.56122640e-02f, 6.71886355e-02f, -8.02052096e-02f, 1.16257876e-01f, -5.21399751e-02f, -6.31453469e-02f, -2.69031003e-02f,
  3.86066824e-01f, 6.66089833e-01f, 1.47805512e-01f, -1.04826219e-01f, 1.24095008e-02f, 2.07905062e-02f, 9.30700228e-02f, 1.04507484e-01f, 1.32399395e-01f, 2.08339170e-02f,
  8.38699713e-02f, 8.99771675e-02f, 1.14585109e-01f, -1.48710683e-01f, -6.68676049e-02f, 1.56334266e-01f, 2.80481666e-01f, -9.20237452e-02f, -1.27612110e-02f, 2.17042910e-03f,
  -5.74112358e-03f, 1.12670310e-01f, -4.47236467e-03f, 4.85807322e-02f, -5.16316034e-02f, 6.29165992e-02f, -8.72751549e-02f, -1.23970948e-01f, -4.67547588e-02f, 1.43882826e-01f,
  4.92101073e-01f, -2.36076295e-01f, -4.25973982e-01f, -5.36566198e-01f, -4.50420439e-01f, -2.18862921e-01f, -2.06005901e-01f, -3.69262874e-01f, -3.77320856e-01f, -1.22201204e-01f,
  -5.05542219e-01f, 2.34287426e-01f, 5.09959996e-01f, -5.32980382e-01f, 7.24541247e-01f, 5.59069157e-01f, -3.10882211e-01f, -1.64305151e-01f, -7.35820234e-02f, -1.11058883e-01f,
  2.06561554e-02f, -1.65664375e-01f, -5.88870794e-02f, -1.70378238e-01f, -3.61383945e-01f, -3.40727568e-01f, 9.66890529e-03f, -2.63091177e-01f, -5.46948373e-01f, -2.46769339e-01f,
  -1.35563165e-01f, -8.25709030e-02f, -7.92172998e-02f, 7.46082291e-02f, -3.65080014e-02f, 7.54508525e-02f, 6.88492507e-02f, 1.29071385e-01f, 2.37914585e-02f, 5.84445857e-02f,
  2.62088984e-01f, 2.51941234e-01f, -1.61663592e-01f, 1.57458737e-01f, 3.37340124e-02f, -7.46685416e-02f, -8.92485380e-02f, -2.01427415e-01f, 7.67693715e-03f, 1.72007740e-01f,
  -3.76183391e-02f, -7.98728131e-03f, -2.41596863e-01f, -4.78951037e-02f, -1.43318325e-01f, -1.52129561e-01f, 2.10268974e-01f, 7.43739307e-02f, 4.88801599e-02f, -3.59831266e-02f,
  -1.69804208e-02f, 1.34387523e-01f, 6.54681446e-03f, -7.20073804e-02f, 5.00699021e-02f, -1.27180696e-01f, -1.66411209e-03f, -1.61602162e-02f, -7.93901924e-03f, -5.82494959e-02f,
  -1.46962017e-01f, -1.26368493e-01f, 7.32012391e-02f, -1.84991956e-02f, 4.35561575e-02f, 1.13423400e-01f, 1.34142131e-01f, 3.49689126e-02f, -1.90692782e-01f, -2.16214538e-01f,
  -9.71595123e-02f, 9.00979266e-02f, -1.42329782e-01f, -5.41508906e-02f, 1.11896060e-01f, 5.23294285e-02f, -4.36911210e-02f, 2.39222161e-02f, -2.62840182e-01f, 1.12309031e-01f,
  -1.55428544e-01f, -2.12081149e-02f, -1.22053787e-01f, -1.27797034e-02f, -2.61103995e-02f, 5.73858917e-02f, -9.05059800e-02f, -2.44984061e-01f, -2.67015129e-01f, -8.93485080e-03f,
  -6.74885958e-02f, 1.57465264e-02f, -2.27684423e-01f, -7.36182742e-03f, -4.10306118e-02f, -2.15153262e-01f, 9.27220955e-02f, -4.27836701e-02f, -8.67173523e-02f, -2.25695819e-02f,
  -7.83708021e-02f, 1.73868537e-01f, 2.68034488e-01f, -6.83923736e-02f, 8.50243643e-02f, -1.56689957e-02f, 1.10593170e-01f, 3.30072716e-02f, 2.03439757e-01f, -1.15396522e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  6.56127155e-01f, 8.85635614e-01f, 7.04556286e-01f, 5.45473337e-01f, 6.83767200e-01f, 7.12986350e-01f, 6.11913621e-01f, 9.93853152e-01f, 6.53902113e-01f, 8.21789443e-01f,
  6.92063034e-01f, 6.28955126e-01f, 9.42914248e-01f, 2.76585579e-01f, 9.27658439e-01f, 4.42652613e-01f, 6.51367664e-01f, 3.65859687e-01f, 7.40568519e-01f, 3.98678362e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  3.84007365e-01f, 2.29122445e-01f, 1.00419298e-01f, -5.30539632e-01f, -1.69828042e-01f, 3.77009325e-02f, -4.05093938e-01f, -4.58944887e-01f, 3.14980626e-01f, 6.47484958e-01f,
  6.34286880e-01f, 6.48197353e-01f, 5.73776126e-01f, -5.40553749e-01f, -9.06169601e-03f, -7.15791464e-01f, -1.75636709e-01f, -9.77975428e-01f, -6.38125718e-01f, -8.64113510e-01f,
  -3.37398231e-01f, 3.51502776e-01f, -6.50089383e-01f, -9.94620621e-01f, -1.57285064e-01f, 8.81919265e-01f, -6.13175929e-01f, -1.92059174e-01f, 2.31218606e-01f, -2.60962337e-01f,
  6.79264486e-01f, -4.10024285e-01f, -4.78849560e-01f, -8.68714035e-01f, 3.22284102e-02f, -1.82709530e-01f, 5.82934678e-01f, -1.14070281e-01f, 8.09328377e-01f, -6.10742509e-01f,
  -4.46468055e-01f, 5.63403666e-01f, 4.65018004e-01f, 1.97921731e-02f, 4.44767207e-01f, -9.22449708e-01f, -6.50724709e-01f, -8.14546227e-01f, -2.38764569e-01f, 6.86688066e-01f,
  -3.90678227e-01f, -7.97300816e-01f, -1.76605955e-01f, -9.90381837e-01f, 8.98533940e-01f, 4.73991394e-01f, -9.18818176e-01f, -3.27403814e-01f, -6.29848599e-01f, 5.96035868e-02f,
  -5.92522919e-02f, -3.48413736e-01f, 3.09953243e-01f, 3.61437976e-01f, -7.58100972e-02f, 8.15600082e-02f, 2.13843863e-02f, -3.15408349e-01f, -4.55616236e-01f, -4.97557998e-01f,
  1.39636502e-01f, -9.19204671e-03f, 1.61658525e-01f, 3.98667663e-01f, -6.14947200e-01f, 3.79090697e-01f, -9.72748399e-01f, -6.53640509e-01f, -5.87028027e-01f, -5.85444391e-01f,
  -4.95887220e-01f, 4.55026358e-01f, -3.09852600e-01f, -7.24505246e-01f, -1.89649552e-01f, -5.12525141e-01f, 1.93075359e-01f, 4.96585459e-01f, 3.38757038e-01f, 7.03106701e-01f,
  6.64312720e-01f, 6.06941938e-01f, -8.52862060e-01f, -3.17231297e-01f, -1.09376025e+00f, -3.49697322e-01f, -3.78505766e-01f, -1.16646044e-01f, -7.28142560e-02f, 2.34297529e-01f,
  -2.59953856e-01f, -5.33828735e-01f, -5.83638959e-02f, 9.05128360e-01f, 5.02621889e-01f, 1.74255893e-01f, 6.22460365e-01f, -2.11977601e-01f, 1.71629086e-01f, -9.57033575e-01f,
  -7.28080511e-01f, 7.18895674e-01f, -4.03431170e-02f, -1.62577152e-01f, -5.28711557e-01f, 8.45169067e-01f, -9.70532775e-01f, 4.52292085e-01f, 2.02955931e-01f, -3.16399217e-01f,
  3.37706923e-01f, -7.01992869e-01f, -1.04301858e+00f, -6.64713204e-01f, -2.81846255e-01f, -4.91188198e-01f, -5.08789718e-01f, -3.00487339e-01f, -2.09499240e-01f, 2.31540203e-01f,
  5.08619905e-01f, 4.76842254e-01f, 6.11557007e-01f, 2.99038291e-01f, -8.03512514e-01f, 2.97101513e-02f, -7.47004002e-02f, -4.77155996e-03f, -4.58311379e-01f, -1.25575328e+00f,
  2.26906314e-01f, -3.57239246e-01f, -3.46899658e-01f, -1.15490496e+00f, 4.66528863e-01f, -7.47414649e-01f, 8.17378461e-01f, 2.69341886e-01f, -5.35860598e-01f, 5.00635505e-01f,
  -4.66201484e-01f, -7.07822323e-01f, -8.67664695e-01f, -2.38368839e-01f, 7.14407742e-01f, 5.96469402e-01f, 3.72113585e-01f, -2.89307535e-01f, -1.07839227e+00f, -1.31579831e-01f,
  4.56469625e-01f, 5.61596632e-01f, 2.20080912e-01f, 4.33451802e-01f, -1.58848301e-01f, 2.00757533e-01f, 4.99789387e-01f, -1.28447339e-01f, -7.41129220e-01f, -9.20977056e-01f,
  2.36895625e-02f, 9.61893201e-01f, -4.51712571e-02f, 7.01194048e-01f, 3.57066900e-01f, -3.23889673e-01f, 7.44639575e-01f, -2.24509120e-01f, 5.58018744e-01f, -1.16355643e-01f,
  -3.06291223e-01f, -6.54492915e-01f, -9.31818366e-01f, -2.79561877e-01f, -9.70593512e-01f, -2.72282571e-01f, -7.72551239e-01f, -8.35311055e-01f, -1.00738108e+00f, -6.48824811e-01f,
  4.55673814e-01f, 4.66426641e-01f, -1.56627715e-01f, -3.85473281e-01f, 2.52926290e-01f, -2.68966347e-01f, -1.27529144e-01f, -1.83525071e-01f, 3.90162528e-01f, 7.04194367e-01f,
  -1.83222249e-01f, -5.46108603e-01f, 6.68970942e-01f, 1.76650509e-01f, -8.33416820e-01f, 5.26311636e-01f, -4.06200647e-01f, -1.62113547e-01f, -6.36324346e-01f, 2.06206128e-01f,
  3.04432243e-01f, -3.15805078e-01f, 6.00336730e-01f, -6.95009410e-01f, 5.28137572e-02f, 8.87185216e-01f, 6.70039475e-01f, -1.04308176e+00f, -4.63354550e-02f, -5.71745098e-01f,
  3.01800966e-01f, -5.46809077e-01f, -6.64528728e-01f, -7.77218282e-01f, -2.33283237e-01f, -7.29572326e-02f, -4.58868057e-01f, -5.71940720e-01f, -1.79978862e-01f, -1.46053033e-03f,
  2.67285317e-01f, 1.02626339e-01f, -5.10604978e-01f, -3.04433376e-01f, 2.33817976e-02f, -1.04995430e-01f, -5.75728774e-01f, -1.58826541e-02f, -5.96980870e-01f, -1.76840946e-02f,
  -4.21379387e-01f, -7.55279064e-01f, -4.73722249e-01f, -1.83483139e-01f, -4.65569049e-01f, 2.94846624e-01f, -5.24689138e-01f, -4.13295209e-01f, 5.79989254e-01f, -2.53080159e-01f,
  -5.86695492e-01f, -2.77974576e-01f, 3.34231287e-01f, 7.55973458e-01f, -6.40105367e-01f, 5.90777397e-01f, -1.76002964e-01f, -2.74346828e-01f, -3.61953974e-01f, -8.48097354e-02f,
  -3.37307930e-01f, 1.98954314e-01f, 3.75597656e-01f, 5.80750406e-03f, 3.46111983e-01f, -1.93845699e-04f, -4.29047674e-01f, -4.76242810e-01f, -7.33797967e-01f, -5.32778800e-01f,
  6.49403930e-01f, 9.79757980e-02f, -5.91184258e-01f, -6.64716840e-01f, -4.25551027e-01f, 4.92511660e-01f, 1.24686830e-01f, -6.89279795e-01f, -6.85504854e-01f, 4.68946427e-01f,
  -1.18616678e-01f, 3.61732990e-01f, -4.43271756e-01f, 5.20173192e-01f, -7.06008554e-01f, 4.93269622e-01f, 3.41311604e-01f, -6.50777280e-01f, 6.15554571e-01f, 3.55357379e-01f,
  -1.68190092e-01f, 3.16268414e-01f, 3.47232446e-02f, 2.97539949e-01f, -5.54706752e-01f, 4.85171497e-01f, 6.71430945e-01f, -1.89959660e-01f, -2.32120484e-01f, 5.92373848e-01f,
  -6.69150651e-01f, 4.15975422e-01f, 8.30985785e-01f, -7.24505067e-01f, -1.02199650e+00f, 7.25152969e-01f, -1.50420517e-01f, -6.58208013e-01f, -1.01531756e+00f, -6.19210958e-01f,
  -5.98436177e-01f, -7.96983063e-01f, -8.32739174e-01f, -3.53360951e-01f, 6.73195601e-01f, -5.23086846e-01f, 4.80011553e-01f, 5.81079483e-01f, -9.33568597e-01f, 2.25964069e-01f,
  3.18238139e-01f, 3.19964647e-01f, 1.02427110e-01f, -1.73581377e-01f, 3.58275741e-01f, -2.40863830e-01f, -4.83970433e-01f, -7.24121153e-01f, -6.52253389e-01f, 4.00926977e-01f,
  2.56516546e-01f, -6.02489769e-01f, -8.57941329e-01f, -3.89810026e-01f, 4.70719397e-01f, 7.75646865e-01f, -3.46064508e-01f, -6.90907717e-01f, -7.21111119e-01f, -6.16810143e-01f,
  7.02436507e-01f, -3.88017386e-01f, 8.30763221e-01f, -9.41857815e-01f, -2.55760998e-01f, -5.53726256e-01f, 5.72637498e-01f, 1.33070901e-01f, -5.97658634e-01f, -6.17184460e-01f,
  -4.05346185e-01f, -5.65983295e-01f, 2.46200860e-01f, 1.48788482e-01f, -4.55008596e-01f, -3.67441811e-02f, 2.00906787e-02f, 4.38952386e-01f, 2.78799623e-01f, -1.60887048e-01f,
  7.93104649e-01f, -3.72546166e-01f, -7.64292598e-01f, -4.68928963e-01f, -8.07204902e-01f, 3.52674335e-01f, -4.58999723e-01f, -5.45338154e-01f, 5.16471446e-01f, -6.19594514e-01f,
  -9.07199860e-01f, 7.73551106e-01f, 7.26952136e-01f, -7.11557865e-02f, -6.61437273e-01f, -1.00710154e+00f, 1.00169277e+00f, -2.35055521e-01f, -2.42050573e-01f, -6.12259030e-01f,
  -5.30136526e-01f, -5.63883901e-01f, 3.33875529e-02f, -7.48974144e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.70410842e-01f, 1.89421073e-01f, -1.57768324e-01f, 5.41737536e-04f, 9.40715000e-02f, 1.06968440e-01f, -1.11528993e-01f, -3.25980745e-02f, -8.78854915e-02f, 1.40102981e-02f,
  2.52383053e-01f, -8.85462314e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    