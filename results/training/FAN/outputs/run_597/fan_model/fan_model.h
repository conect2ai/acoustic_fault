/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.32232845e-01f, 8.62042606e-02f, -7.99223036e-03f, 3.13081235e-01f, 2.45569199e-01f, -6.18006214e-02f, 4.08959985e-01f, 2.30844822e-02f, -2.18710676e-02f, 2.24231541e-01f,
  -1.61841795e-01f, -4.80455756e-01f, -3.70413899e-01f, -3.37915719e-01f, -2.98694044e-01f, 2.98294991e-01f, 4.37502950e-01f, -1.02692716e-01f, -4.52733338e-01f, -1.01574972e-01f,
  7.39836395e-02f, 1.30793363e-01f, -1.62109807e-01f, -1.53270945e-01f, 2.96185076e-01f, -2.65210629e-01f, 1.82065845e-01f, 4.50251587e-02f, -7.48411492e-02f, 3.52879643e-01f,
  3.54989362e-03f, 3.42816487e-02f, -1.30745113e-01f, 1.54983848e-02f, 4.20402735e-02f, -4.86841537e-02f, 4.89794649e-02f, -3.69776078e-02f, -6.67911302e-03f, 3.02140154e-02f,
  9.42149013e-02f, 1.38460035e-02f, 3.32735665e-02f, -2.98365019e-03f, 7.90957212e-02f, -5.99858426e-02f, 5.67973498e-03f, -3.55441719e-02f, -8.54109824e-02f, 5.17608300e-02f,
  -2.77655199e-02f, 1.82964280e-01f, 1.51334077e-01f, -6.32239729e-02f, -4.59648706e-02f, -4.74847145e-02f, 2.26886403e-02f, -9.93171781e-02f, -1.28633171e-01f, 2.14197040e-02f,
  3.65450233e-02f, -2.48424336e-03f, 9.60817188e-03f, 5.36528323e-03f, 3.24125253e-02f, -1.58224422e-02f, 5.40070608e-02f, -1.98833644e-02f, -5.06096333e-02f, 1.00475140e-01f,
  -4.02193442e-02f, 1.93582587e-02f, -3.36820148e-02f, -3.98008199e-03f, -3.16405557e-02f, 2.73758415e-02f, -4.17979583e-02f, 3.43118906e-02f, -1.31750688e-01f, 1.69667844e-02f,
  -6.73704892e-02f, 5.44250868e-02f, 5.32402620e-02f, -1.19121097e-01f, -7.64557421e-02f, -3.95199656e-02f, 3.72162275e-02f, -1.10538945e-01f, 5.22118807e-03f, 1.58185456e-02f,
  -1.17504127e-01f, -2.83087760e-01f, 1.20548673e-01f, -1.02294169e-01f, 3.62740196e-02f, -2.01776791e-02f, 3.79156098e-02f, 3.30016874e-02f, 4.09874693e-02f, 3.32678355e-05f,
  -8.61005932e-02f, -7.47022554e-02f, -2.84639420e-03f, -6.30930951e-03f, -2.73927338e-02f, 2.48868223e-02f, -7.28938431e-02f, -6.51983172e-02f, -3.15958168e-03f, -4.47989032e-02f,
  3.71910669e-02f, -3.49903144e-02f, -1.23842843e-02f, -3.93509232e-02f, -4.03723456e-02f, 2.64228322e-02f, -6.17262311e-02f, -2.09819507e-02f, -4.00021300e-02f, 1.39114842e-01f,
  1.71871886e-01f, -4.08660620e-01f, -1.95850119e-01f, 1.20201051e-01f, -4.37577553e-02f, 1.18702479e-01f, -3.05928141e-01f, 1.08859167e-01f, 3.22426021e-01f, -2.01842189e-01f,
  -2.40701512e-01f, 9.70254317e-02f, -6.29707128e-02f, 7.05644935e-02f, 1.48195541e-03f, -2.64882952e-01f, -3.78315777e-01f, -3.82535346e-02f, 3.48098636e-01f, 1.60904109e-01f,
  1.08894750e-01f, 2.04850897e-01f, 1.25036865e-01f, 7.89071247e-02f, -1.93495691e-01f, 5.23310483e-01f, -1.41326338e-01f, -3.60616706e-02f, -1.23547036e-02f, -3.51690620e-01f,
  -1.37309402e-01f, -2.98974484e-01f, 1.62337020e-01f, -3.05528403e-03f, -3.79084679e-03f, -2.70368904e-02f, 5.81281334e-02f, -4.15171310e-02f, -7.41177127e-02f, -2.30488386e-02f,
  -1.46188810e-01f, -7.39284903e-02f, -2.08606333e-01f, 5.81575930e-02f, 1.19589083e-02f, -7.02729961e-03f, 4.76994328e-02f, -5.83955906e-02f, -3.05428402e-04f, -7.72358328e-02f,
  -7.05764145e-02f, -6.77869916e-02f, -5.95466085e-02f, -6.03144728e-02f, 1.16028613e-03f, 3.25653069e-02f, -9.05015226e-03f, 1.34302964e-02f, 2.10706696e-01f, 1.75309125e-02f,
  1.51271969e-01f, -5.81297874e-02f, -2.11815182e-02f, 2.01970413e-02f, 5.02968244e-02f, 1.47595564e-02f, -1.93221346e-02f, 3.53471003e-02f, -6.91871450e-04f, -1.92218553e-02f,
  1.44691011e-02f, -2.13334803e-03f, 5.90472482e-02f, -7.52002150e-02f, -1.81206577e-02f, -7.75442505e-03f, -7.01337606e-02f, 7.33485958e-03f, -6.28698543e-02f, 1.67987887e-02f,
  4.87411991e-02f, 3.19294259e-02f, -7.27052093e-02f, -2.02198420e-02f, -3.93505804e-02f, 1.14921294e-02f, 2.91000586e-02f, -6.53650835e-02f, 3.84005308e-02f, -5.49599864e-02f,
  1.97779462e-01f, 5.85160358e-03f, -1.09867841e-01f, 8.70060455e-03f, 2.45090183e-02f, 4.21832316e-02f, -7.17230439e-02f, 7.22969100e-02f, -4.95063327e-02f, -7.74335861e-03f,
  -3.14657763e-02f, -2.27742791e-02f, -8.70180279e-02f, 7.34448656e-02f, 2.57660840e-02f, 1.07196055e-01f, -5.33348918e-02f, 4.32956927e-02f, 9.07372497e-03f, 4.25677784e-02f,
  -6.70952082e-04f, 1.09863162e-01f, 1.89822033e-01f, 7.06748217e-02f, 1.16598330e-01f, 1.24355309e-01f, -2.35945508e-02f, -1.03557622e-02f, 7.23964795e-02f, 1.31571889e-01f,
  -8.99861380e-03f, -3.96467179e-01f, 9.87098515e-02f, -1.67054966e-01f, 1.36218265e-01f, 1.19307481e-01f, 6.47493675e-02f, -4.49866429e-02f, 1.08144972e-02f, -2.34740585e-01f,
  -1.98307127e-01f, 3.50892544e-02f, -7.81874508e-02f, 1.61934756e-02f, 2.77644306e-01f, -6.41205832e-02f, 5.65641141e-03f, 3.41301560e-01f, 5.82830548e-01f, 1.20464571e-01f,
  -3.66973393e-02f, -3.29185724e-02f, -6.85982257e-02f, 6.62967414e-02f, -2.44511366e-01f, 1.32334664e-01f, -3.47167492e-01f, -1.86787412e-01f, -6.98292479e-02f, -1.61055729e-01f,
  -4.99815308e-02f, -2.16317073e-01f, 1.93832830e-01f, 7.52926096e-02f, -2.91421544e-02f, -7.93262443e-05f, 6.81156386e-03f, -3.78921852e-02f, 1.23554412e-02f, -1.59562193e-02f,
  -5.61672403e-03f, -2.06156876e-02f, 5.72383292e-02f, 4.37017083e-02f, -3.15162875e-02f, -3.33610959e-02f, -9.55202058e-02f, 2.76784170e-02f, -9.98934358e-03f, -7.05136284e-02f,
  3.16350088e-02f, 1.20206803e-01f, -2.74388697e-02f, 4.47372673e-03f, 1.26519874e-01f, 1.60210401e-01f, -6.17958717e-02f, 3.50565277e-02f, -4.23281424e-04f, -1.16726659e-01f,
  1.93374846e-02f, 2.17251033e-02f, 5.11693582e-02f, 1.14290379e-02f, -1.61100421e-02f, -1.12174843e-02f, 1.37784248e-02f, -2.41757259e-02f, 7.25613385e-02f, 7.71763641e-03f,
  2.33670301e-03f, 1.03818541e-02f, 2.71041738e-03f, 3.83778438e-02f, -7.95990527e-02f, 1.70801319e-02f, 1.12419967e-02f, -9.18695796e-03f, 4.57149632e-02f, -2.57146899e-02f,
  3.79272029e-02f, 6.56173676e-02f, 1.83654344e-03f, 2.26475019e-02f, -4.84385379e-02f, 3.42442133e-02f, 5.58445416e-02f, 5.76422699e-02f, 2.48190947e-03f, -2.64878199e-02f,
  -2.15149999e-01f, 2.82770753e-01f, -6.24864958e-02f, -1.30077265e-02f, -8.00110772e-03f, -1.61719900e-02f, -3.32075916e-02f, 2.12300699e-02f, -4.37128358e-03f, 2.60508172e-02f,
  6.72053546e-02f, 8.50016996e-02f, -5.86512201e-02f, -4.47965041e-02f, 5.36222793e-02f, 1.51808644e-02f, -2.70917043e-02f, 4.03665490e-02f, 6.31620660e-02f, -2.12758146e-02f,
  -3.52710555e-03f, -3.20591927e-02f, 1.04466617e-01f, 3.90064083e-02f, 5.13620349e-03f, 9.78146046e-02f, 2.09335554e-02f, 4.46736366e-02f, 1.07975885e-01f, -8.45073014e-02f,
  -7.82696251e-03f, -2.23102421e-01f, 1.69473499e-01f, 1.46104202e-01f, -2.11657688e-01f, -3.06995928e-01f, -3.25030714e-01f, -1.72559753e-01f, -8.08433220e-02f, -2.40971491e-01f,
  -3.00358355e-01f, -2.56760627e-01f, -1.76803067e-01f, -1.20125366e-02f, -2.14095891e-01f, -6.89908490e-02f, 1.94882780e-01f, 2.34658659e-01f, -7.60096451e-03f, -1.57986313e-01f,
  -9.41455960e-02f, 2.02726707e-01f, 2.80815661e-01f, 6.29746616e-02f, 3.21522839e-02f, -1.19089909e-01f, 1.64411619e-01f, 1.88507080e-01f, -5.92278987e-02f, 5.07168949e-01f,
  -1.23237126e-01f, 8.85482952e-02f, -1.03892960e-01f, -5.33854365e-02f, -2.64141373e-02f, -8.96195397e-02f, -1.02554291e-01f, -2.99752709e-02f, -5.93832284e-02f, -5.65800630e-02f,
  -5.91064394e-02f, -2.19290203e-04f, 5.66439927e-02f, 1.74273942e-02f, 1.30323758e-02f, -9.03737545e-02f, 1.12214863e-01f, 1.29136577e-01f, 9.83094722e-02f, -5.39692789e-02f,
  -1.87080540e-02f, 3.72980870e-02f, -3.14766355e-02f, 2.33601276e-02f, 9.67937484e-02f, -1.43261338e-02f, 3.35560320e-03f, 9.40003693e-02f, 5.20794727e-02f, -2.86792573e-02f,
  3.28879468e-02f, -6.99242577e-02f, 1.69335469e-03f, 7.42246816e-03f, 4.67303209e-02f, -2.77512502e-02f, 9.94948372e-02f, 3.13370638e-02f, 5.29256202e-02f, 1.54755069e-02f,
  6.21504821e-02f, 3.60247903e-02f, 9.06479880e-02f, 3.15357521e-02f, -7.23331468e-03f, 8.39803740e-02f, -7.34237134e-02f, 2.15886440e-02f, -3.06074247e-02f, 4.07018624e-02f,
  -2.10980140e-03f, -5.65348426e-03f, -3.55141773e-03f, 8.20810348e-02f, 4.77872752e-02f, 2.55627260e-02f, -5.64359687e-03f, 2.91634891e-02f, -5.42341508e-02f, -1.03286013e-01f,
  -2.02179596e-01f, -9.44845974e-02f, -1.18696995e-01f, -1.58959702e-01f, -8.83937851e-02f, -9.38817486e-02f, -2.33455305e-03f, -6.62069842e-02f, -3.91382501e-02f, -1.13797516e-01f,
  -8.27451050e-02f, -1.00244746e-01f, -8.69672671e-02f, -1.03826284e-01f, -1.22191876e-01f, -1.59503460e-01f, -1.75336093e-01f, -1.45540506e-01f, -1.18324205e-01f, -1.41149640e-01f,
  -2.37883851e-02f, -1.58291087e-01f, -2.12818608e-01f, -1.51326790e-01f, -1.17306285e-01f, -2.22248271e-01f, -1.60691828e-01f, -1.64162949e-01f, -3.27729970e-01f, -2.68442303e-01f,
  -5.50710738e-01f, -2.86166638e-01f, 6.20970070e-01f, 1.21479936e-01f, 1.09995820e-01f, -1.73918724e-01f, -5.58876812e-01f, -4.17357266e-01f, 1.22001674e-02f, -9.17621031e-02f,
  2.10327417e-01f, 2.82770544e-01f, 4.33747739e-01f, 8.53436068e-02f, -3.74725699e-01f, -2.55413562e-01f, -1.86438113e-01f, 1.31188575e-02f, 2.59875935e-02f, 5.35331666e-02f,
  1.01667573e-03f, -2.94880360e-01f, -1.95177391e-01f, -1.14293462e-02f, -3.05975657e-02f, -4.43600193e-02f, 2.80555189e-02f, -2.29263037e-01f, -3.37291174e-02f, -1.00613963e-02f,
  3.93842787e-01f, -2.05840588e-01f, 2.29853466e-01f, 1.42652206e-02f, 1.46822363e-01f, 1.97734702e-02f, 3.14816460e-02f, 7.13617206e-02f, 9.76266488e-02f, 2.59850919e-02f,
  1.04587011e-01f, 7.21780807e-02f, 8.79168063e-02f, 8.60152170e-02f, 6.92825913e-02f, -9.30002239e-03f, -2.54936852e-02f, -3.96892391e-02f, 6.02615662e-02f, 6.86083734e-02f,
  1.55367941e-01f, 7.03604370e-02f, 1.50524184e-01f, -4.15442977e-03f, -2.12121140e-02f, 1.42436802e-01f, 7.91558176e-02f, -4.71566878e-02f, -3.08384728e-02f, -2.08152011e-01f,
  -4.27345373e-02f, -6.60544634e-02f, 1.21638458e-02f, -5.60928658e-02f, -7.83194900e-02f, 9.53240693e-03f, 9.75816026e-02f, 5.36036724e-03f, 2.71104835e-03f, 1.06922153e-03f,
  1.13593889e-02f, 3.73757370e-02f, 3.96055542e-02f, -1.40609341e-02f, 8.06707069e-02f, -9.10396967e-03f, -6.81957304e-02f, -6.28712848e-02f, 1.29104823e-01f, 3.55137587e-02f,
  -2.43787351e-03f, 7.55119026e-02f, -3.25464904e-02f, 2.82005556e-02f, -1.25514135e-01f, -9.79389343e-03f, -2.89283693e-02f, -7.55053088e-02f, -4.74292412e-03f, -3.00379023e-02f,
  -1.94508899e-02f, 1.51709422e-01f, 5.90139553e-02f, 4.41751182e-02f, 3.34309898e-02f, 3.13438848e-02f, 9.03674588e-02f, 8.06701835e-03f, 1.21617042e-01f, -3.47311987e-04f,
  -3.10992654e-02f, -1.94564983e-02f, 6.87406585e-02f, 6.31546378e-02f, 6.14935979e-02f, 8.49696994e-02f, -4.14252505e-02f, 4.55451608e-02f, 7.30696023e-02f, 9.24127921e-02f,
  -5.01853265e-02f, -6.58836216e-02f, -6.27822354e-02f, 8.28193277e-02f, 2.59653968e-03f, -9.59423408e-02f, -1.05085976e-01f, 4.84369062e-02f, -1.22619122e-01f, -2.86910474e-01f,
  -7.48453677e-01f, 2.42905527e-01f, -3.98659497e-01f, -2.52673179e-01f, -6.23031892e-02f, 1.71763059e-02f, 1.30462870e-01f, 1.54679745e-01f, -8.95737037e-02f, 1.29409045e-01f,
  6.65448904e-02f, -7.55365416e-02f, -5.73485233e-02f, 4.80084773e-03f, -5.28833224e-03f, 7.24453628e-02f, -7.93723166e-02f, -3.25152248e-01f, -3.15973669e-01f, 1.46257266e-01f,
  1.56404912e-01f, -3.49682927e-01f, -3.73559564e-01f, -6.78888783e-02f, -2.88299471e-02f, 3.82504500e-02f, 7.92734548e-02f, -1.93720490e-01f, 8.15263465e-02f, -1.71224058e-01f,
  -2.21573934e-02f, -3.69189978e-02f, -3.18289138e-02f, 3.82425301e-02f, 2.09292825e-02f, 4.39338721e-02f, 4.85806093e-02f, 3.47180180e-02f, 3.25919278e-02f, -7.91298673e-02f,
  1.68928970e-02f, 4.58012410e-02f, -6.77849576e-02f, 7.59766530e-03f, -1.05030634e-01f, 5.44630736e-02f, 2.37571225e-02f, -4.71066236e-02f, -3.65625508e-02f, 1.22856170e-01f,
  6.82683662e-02f, -2.37642806e-02f, -1.55731544e-01f, 2.00493932e-02f, 9.14352313e-02f, -9.45763886e-02f, -2.64070071e-02f, 9.71639454e-02f, 9.43026394e-02f, 3.93442176e-02f,
  4.68873195e-02f, 2.08501257e-02f, 1.24212233e-02f, 2.42456179e-02f, -5.18440679e-02f, -1.28809176e-02f, -1.07505377e-02f, -3.64489038e-03f, 1.71985403e-02f, 6.71875924e-02f,
  -3.97537015e-02f, -4.08962369e-02f, -2.50309668e-02f, 3.31988074e-02f, -3.78540345e-02f, -1.56575162e-02f, -3.06748692e-02f, 1.11823948e-02f, -2.51819734e-02f, -5.94249144e-02f,
  -2.73632370e-02f, 3.12078409e-02f, -3.24041508e-02f, 5.59768602e-02f, -5.51965646e-03f, 3.60094868e-02f, -3.58817563e-03f, 6.63478822e-02f, 8.01357441e-03f, -3.11835855e-02f,
  -4.83376384e-02f, -1.38458684e-01f, -9.40367132e-02f, 3.88632528e-02f, -3.01119331e-02f, 3.21293697e-02f, 6.10004459e-03f, 5.34983538e-02f, -5.25204418e-03f, 6.31395429e-02f,
  1.96309499e-02f, -2.23254599e-02f, -4.77316193e-02f, 1.22812726e-02f, -7.77047535e-04f, -6.70416746e-04f, 4.90869991e-02f, -5.41889295e-02f, 5.49048558e-02f, -2.26311442e-02f,
  3.79825495e-02f, 2.73384303e-02f, 2.82901265e-02f, 5.47791570e-02f, -5.63129187e-02f, -1.08729221e-01f, -6.01294152e-02f, -1.23220086e-02f, -3.01547516e-02f, 4.51546423e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.17788041e+00f, -1.05176799e-01f, -1.56790480e-01f, -8.20271671e-02f, 7.78908134e-01f, 1.58299673e-02f, -4.34574753e-01f, -2.40071416e-01f, 1.33125737e-01f, -2.07728177e-01f,
  2.31861264e-01f, 2.26823479e-01f, -5.45696877e-02f, 2.61268288e-01f, -4.49253470e-01f, -1.80986941e-01f, 2.04927206e-01f, -4.17759031e-01f, -2.56102473e-01f, 1.01182960e-01f,
  6.02100313e-01f, 9.18573886e-03f, -5.11383176e-01f, -6.33210987e-02f, 9.62835085e-03f, 5.44807911e-02f, -3.61071266e-02f, 1.50189906e-01f, 3.03088054e-02f, 2.78596938e-01f,
  -2.95235336e-01f, -2.03450680e-01f, 3.01512033e-01f, 1.06829897e-01f, 1.16405763e-01f, -2.04007655e-01f, -2.18537062e-01f, -1.49279550e-01f, -2.82947663e-02f, 6.95405379e-02f,
  1.36209056e-01f, 8.27495828e-02f, 2.41612583e-01f, 5.58461919e-02f, -4.52953875e-02f, -1.72812507e-01f, -1.40072331e-02f, -1.58416137e-01f, -2.01507747e-01f, -1.33729339e-01f,
  3.18456173e-01f, 1.96093962e-01f, -3.00503731e-01f, 7.13057742e-02f, -3.12860683e-02f, 1.46251813e-01f, 2.20389739e-01f, 1.03212431e-01f, -5.33338226e-02f, -2.44383991e-01f,
  7.41706491e-02f, -2.49076802e-02f, 5.96278161e-02f, 4.90667447e-02f, 9.34970751e-03f, -3.54302339e-02f, -3.26640792e-02f, -4.12614904e-02f, -1.21592160e-03f, -9.42800492e-02f,
  9.62679535e-02f, -5.13020642e-02f, 3.58677059e-02f, -1.05070442e-01f, -5.52742779e-02f, 6.24374002e-02f, 3.74726392e-02f, -1.15722947e-01f, -2.53660269e-02f, -1.27672032e-02f,
  -6.72163218e-02f, -6.47312030e-03f, -8.54654144e-03f, 4.55255210e-02f, 1.84756204e-01f, 9.84376855e-03f, -1.97534133e-02f, 3.02979071e-02f, 3.54544073e-02f, 6.42360523e-02f,
  -3.35556895e-01f, 3.52890551e-01f, -3.61511350e-01f, 6.28092501e-04f, -1.50061935e-01f, 1.44237816e-01f, 4.89251651e-02f, 8.74659121e-02f, 4.74161562e-03f, -1.79064676e-01f,
  1.85140725e-02f, -6.28869683e-02f, -1.33696809e-01f, 2.03839168e-02f, -4.24557552e-02f, 1.45586096e-02f, 3.60263214e-02f, -6.72491863e-02f, -8.65631402e-02f, 1.42246202e-01f,
  1.59980226e-02f, -2.02462539e-01f, -2.44723573e-01f, -2.11963981e-01f, 1.08611755e-01f, -2.64702082e-01f, -3.16489041e-01f, -4.90761921e-02f, -3.85013193e-01f, -8.06832254e-01f,
  6.20274186e-01f, -2.65793979e-01f, -2.18520582e-01f, 7.30366230e-01f, -1.55471623e-01f, -4.51749563e-01f, -5.94919682e-01f, -2.34604046e-01f, 2.01359734e-01f, 1.93703279e-01f,
  2.14764271e-02f, 5.21232843e-01f, 3.14314783e-01f, 3.68003547e-01f, 3.45542952e-02f, 7.33266324e-02f, 2.83424854e-01f, 3.92408222e-01f, 8.81680846e-02f, 2.01898992e-01f,
  5.91264367e-01f, 1.37641400e-01f, -4.00040671e-02f, 1.17435917e-01f, 4.86612737e-01f, 3.99871618e-01f, -2.42715299e-01f, -8.63118395e-02f, -6.00421848e-03f, 1.03406405e+00f,
  5.50645709e-01f, 4.96151671e-03f, 1.49975330e-01f, 1.28766060e-01f, -7.33106360e-02f, -5.72395474e-02f, -1.52327493e-01f, -9.12814513e-02f, -2.18866870e-01f, -7.34815607e-03f,
  6.44631833e-02f, -2.01362534e-03f, 7.08877444e-02f, -8.30462261e-04f, -9.20997560e-02f, -1.54075891e-01f, -1.43654365e-02f, 1.24311686e-01f, 2.56379545e-02f, -1.47070922e-02f,
  3.30804646e-01f, 7.89095834e-03f, -3.33182096e-01f, -2.54692882e-01f, 1.22174732e-02f, 1.97364256e-01f, -1.71401009e-01f, 6.65051490e-02f, -2.02732593e-01f, 3.46278042e-01f,
  -4.82605683e-04f, 7.00651333e-02f, -1.37345921e-02f, 4.18586880e-02f, 1.61955252e-01f, -1.69519767e-01f, 1.56857550e-01f, -1.36463389e-01f, 1.25642985e-01f, 2.92177629e-02f,
  -4.39640880e-02f, 4.66737449e-02f, -1.46907344e-01f, -1.65354200e-02f, 7.86915720e-02f, -1.59950048e-01f, -1.59648061e-02f, 6.21326007e-02f, -1.96977139e-01f, -1.40958101e-01f,
  1.25111789e-01f, -3.37351300e-02f, -5.36304452e-02f, -4.31351917e-04f, 3.54321562e-02f, 1.85176030e-01f, 1.61934569e-01f, -7.99771398e-02f, -1.64487623e-02f, -1.04336940e-01f,
  -6.92695856e-01f, -4.96753484e-01f, 5.81813991e-01f, 2.22067818e-01f, 1.13542229e-01f, 3.41129489e-04f, 2.45831385e-01f, -1.20364474e-02f, -6.36059418e-02f, -3.23686339e-02f,
  -1.08457096e-01f, -3.79565991e-02f, -1.36495777e-03f, -6.23718947e-02f, -1.63815379e-01f, -4.51149866e-02f, -1.55205838e-02f, -7.19120307e-03f, -7.43831024e-02f, -2.42379874e-01f,
  -1.02874562e-01f, -2.47795686e-01f, -3.21433425e-01f, -2.74864137e-01f, -2.62000244e-02f, -3.77409384e-02f, -3.16004157e-01f, -2.21613735e-01f, -3.87715340e-01f, -3.13478738e-01f,
  1.05911732e+00f, 5.81144579e-02f, -1.18223989e+00f, 8.21621358e-01f, -6.61370873e-01f, -2.72019237e-01f, -8.74115407e-01f, 8.64989311e-02f, 6.95000827e-01f, -2.62122214e-01f,
  1.18448749e-01f, 3.78269911e-01f, 2.48217240e-01f, -2.34029982e-02f, -1.91094458e-01f, -8.74921918e-01f, -7.13199854e-01f, -4.32936788e-01f, -2.77369112e-01f, -2.18917564e-01f,
  -2.35601962e-01f, -1.74712658e-01f, 3.82494591e-02f, 1.81068912e-01f, 1.17748775e-01f, -7.33238310e-02f, -5.79034507e-01f, -3.09473783e-01f, -4.13060695e-01f, -7.36858964e-01f,
  -7.41173446e-01f, 1.01655997e-01f, -1.76810667e-01f, 1.70716420e-01f, -1.77765861e-01f, 2.89209843e-01f, 1.03218079e-01f, 2.55269930e-03f, 1.46288246e-01f, 1.10913880e-01f,
  1.63083225e-01f, 1.44583285e-01f, 2.96577871e-01f, -5.69398478e-02f, 1.72233149e-01f, -7.13237226e-02f, -4.71471027e-02f, -1.24396376e-01f, -3.32829803e-02f, -8.68270844e-02f,
  -5.08679375e-02f, -3.71336490e-01f, -2.70612895e-01f, -2.74154283e-02f, -1.39996260e-02f, 2.12723166e-02f, -4.13561277e-02f, -3.70488055e-02f, -2.31027424e-01f, -2.06868365e-01f,
  -1.57352030e-01f, 4.33840491e-02f, -1.07505219e-02f, 1.81140248e-02f, 6.87219426e-02f, 1.69014201e-01f, -3.25797163e-02f, -7.34818876e-02f, 4.68900567e-03f, 5.47705740e-02f,
  -2.93942671e-02f, -5.03957830e-02f, -2.58576479e-02f, 7.92602226e-02f, -2.73212213e-02f, -1.21646682e-02f, 1.30968774e-02f, -1.01729343e-02f, 7.69486874e-02f, 3.73662412e-02f,
  -2.34833118e-02f, 4.51574065e-02f, 4.54191752e-02f, 1.12424940e-02f, -1.38186589e-01f, 1.65931880e-02f, -8.54746103e-02f, 4.53350581e-02f, 5.57269305e-02f, 7.68160298e-02f,
  5.53733706e-01f, -1.73745781e-01f, 2.93357015e-01f, 1.80659518e-01f, -5.10896295e-02f, 2.17833463e-02f, -6.75968751e-02f, -6.73004687e-02f, 2.12443754e-01f, -3.34773846e-02f,
  -4.77255769e-02f, 5.18692769e-02f, 4.44642939e-02f, -1.55739620e-01f, -9.90401506e-02f, -7.94830844e-02f, -8.80238712e-02f, 2.64210775e-02f, 1.27394393e-01f, -4.46564965e-02f,
  5.14473096e-02f, 5.00989109e-02f, 2.79474854e-01f, 2.64725555e-02f, 1.27823025e-01f, 1.49636090e-01f, 6.50841370e-02f, 3.40161473e-02f, -1.79358900e-01f, 1.54419586e-01f,
  -4.21265662e-01f, 1.53775513e-01f, -2.85943419e-01f, 5.89471340e-01f, 4.06059116e-01f, 2.28374824e-01f, 3.82626563e-01f, 2.18150184e-01f, 1.41999334e-01f, 6.45107552e-02f,
  1.57302916e-01f, 2.42947787e-01f, 2.77102798e-01f, 1.33974999e-01f, 1.23227179e-01f, 2.59397060e-01f, 2.80258268e-01f, -1.82200208e-01f, -7.41327778e-02f, 5.63080283e-03f,
  3.72578412e-01f, 1.77752338e-02f, -3.32237363e-01f, -4.77997996e-02f, 4.23096791e-02f, 3.53082925e-01f, 1.47678182e-01f, -4.81488518e-02f, -1.17813729e-01f, -8.68529920e-03f,
  -6.44672096e-01f, -1.25960723e-01f, 2.10236907e-01f, 5.89093268e-02f, -2.25913823e-01f, -1.32840902e-01f, -1.35183796e-01f, -1.74948260e-01f, -1.49970474e-02f, 6.17588349e-02f,
  -2.05651857e-02f, -1.74495667e-01f, -6.66986629e-02f, -5.38171045e-02f, 2.97453627e-02f, -4.23746482e-02f, -3.80873494e-02f, 8.50194097e-02f, 2.81343907e-01f, 7.54975379e-02f,
  2.23056301e-01f, -6.35793060e-02f, -1.06699988e-02f, 1.31672576e-01f, 5.57672046e-02f, 1.08404346e-01f, -1.00636762e-02f, -1.19896457e-01f, 4.75068130e-02f, -6.19691871e-02f,
  1.18898563e-01f, -1.36095658e-01f, -1.10041738e-01f, 1.66436397e-02f, -1.74413752e-02f, 7.18606710e-02f, 7.40082636e-02f, -5.05751707e-02f, 1.80094130e-02f, -1.11291662e-01f,
  7.35773519e-02f, 9.82584432e-02f, 1.09873645e-01f, 6.32013306e-02f, 2.81414278e-02f, -1.29018687e-02f, -1.30780950e-01f, 3.34068537e-02f, -5.28726131e-02f, -7.83703104e-03f,
  6.35110959e-02f, -1.45155210e-02f, -1.18958525e-01f, -8.42722505e-03f, 1.73004329e-01f, 1.36607215e-01f, -5.89293763e-02f, -2.85899863e-02f, -6.36449158e-02f, -5.68559533e-03f,
  3.59969676e-01f, 2.58554280e-01f, -1.11683058e-02f, 1.44032523e-01f, -3.38928811e-02f, -1.24743521e-01f, 1.09894179e-01f, -5.96943423e-02f, -6.65915906e-02f, 9.28096659e-03f,
  -1.88226160e-02f, -1.08504914e-01f, -3.81852239e-02f, -1.02348685e-01f, -4.84128594e-02f, 3.83354761e-02f, 1.05423048e-01f, 1.47573516e-01f, 2.13709190e-01f, -5.45115061e-02f,
  3.33859585e-02f, 1.13776825e-01f, -1.46062806e-01f, 8.01684633e-02f, 1.37174785e-01f, 1.30118385e-01f, -1.44820437e-01f, -1.29983351e-01f, 1.06731197e-02f, -1.39406370e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  8.63189161e-01f, 6.32981360e-01f, 6.59847856e-01f, 1.72594473e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.13714433e-03f, -2.47646004e-01f, 2.00132906e-01f, 7.89705962e-02f, 1.57207027e-01f, 1.43158719e-01f, -4.00011539e-01f, 5.99762440e-01f, 5.92589617e-01f, -2.33701319e-01f,
  3.18651021e-01f, -4.94398296e-01f, 9.68718827e-02f, 3.53289172e-02f, 1.55941650e-01f, -2.43042484e-01f, -3.25915724e-01f, 2.46769071e-01f, -2.23906562e-01f, -1.95218354e-01f,
  1.66923583e-01f, -1.26193896e-01f, -4.93479311e-01f, 5.04577577e-01f, 7.83083737e-01f, 6.79296032e-02f, -3.80001277e-01f, -1.50032461e-01f, -2.81336457e-01f, 2.47545000e-02f,
  1.97177261e-01f, 2.31674850e-01f, 7.58493543e-02f, 1.80181488e-01f, 1.07986376e-01f, 1.18665174e-01f, -2.56287187e-01f, 1.06253766e-01f, -4.20151167e-02f, -5.85152328e-01f,
  -7.21993327e-01f, 1.40567318e-01f, 1.15665691e-02f, 3.23911190e-01f, 5.09185791e-01f, -1.84384901e-02f, 1.09303445e-01f, 1.77927658e-01f, -2.80373245e-01f, -2.52592921e-01f,
  3.13259453e-01f, -6.50505498e-02f, 2.16578871e-01f, -1.33175567e-01f, -1.11836299e-01f, -5.22751927e-01f, 2.61670835e-02f, -2.72914097e-02f, 2.79505521e-01f, -1.03603148e+00f,
  1.73485398e-01f, 9.26492289e-02f, -5.36892593e-01f, 9.39742550e-02f, -3.50407273e-01f, -1.27039021e-02f, -1.60503000e-01f, 2.59398222e-01f, 2.84377392e-02f, 8.46217424e-02f,
  -3.02154541e-01f, 6.23396635e-01f, 2.67097592e-01f, 3.18238838e-03f, -5.85456006e-02f, 3.02108794e-01f, 1.80987015e-01f, -3.22347105e-01f, 2.28152946e-01f, 4.83181387e-01f,
  -8.99574831e-02f, -2.70962030e-01f, 4.23117310e-01f, 2.22249717e-01f, 2.66802073e-01f, 4.40574102e-02f, 4.45142090e-01f, -1.31841958e-01f, 4.60860223e-01f, -1.71782836e-01f,
  -2.69897968e-01f, -5.24924576e-01f, 7.24280775e-02f, -2.15312347e-01f, -7.03154504e-02f, 3.53419870e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.77622986e-01f, 2.53021657e-01f, 1.03386030e-01f, 7.42355824e-01f, -2.29006596e-02f, 6.83249682e-02f, 4.56570126e-02f, 4.00318146e-01f, -1.94692105e-01f, -4.56749946e-01f,
  9.77503583e-02f, 1.13505340e+00f, 1.62646890e+00f, 2.89937735e-01f, 1.59244847e+00f, 3.55918229e-01f, -1.40065365e-02f, 8.24197829e-01f, 9.65954840e-01f, -2.72351131e-02f,
  1.30012274e-01f, 9.91408706e-01f, -1.02851081e+00f, 4.29463893e-01f, -3.52779031e-01f, -5.57200193e-01f, 1.16310731e-01f, 5.74347615e-01f, -2.06165886e+00f, 6.09677434e-01f,
  3.98087174e-01f, -1.85286984e-01f, -4.68928427e-01f, 5.54361761e-01f, 4.35142159e-01f, -3.48717906e-02f, 6.78277910e-01f, 4.89674091e-01f, -1.05695593e+00f, 7.88399100e-01f,
  1.18163764e+00f, 2.60238022e-01f, 1.57138824e+00f, -2.43813381e-01f, 9.71301854e-01f, 7.28077292e-01f, 8.22293479e-03f, -2.55362630e-01f, 3.39044958e-01f, 4.02252436e-01f,
  1.17412835e-01f, 3.44306618e-01f, 4.26836520e-01f, 9.68744516e-01f, 8.21622014e-01f, 1.23789318e-01f, 1.77695438e-01f, 2.33842447e-01f, -7.49920607e-01f, -9.88583267e-01f,
  -2.04093337e-01f, 1.21787453e+00f, 6.19537771e-01f, 3.94391835e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  9.45099443e-02f, 4.35872018e-01f, 1.02507323e-01f, 4.81658638e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.34670687e+00f, -3.87624651e-01f, -2.56711096e-01f, -3.38319153e-01f, -1.20352018e+00f, -7.61587083e-01f, 4.77081031e-01f, 1.41590405e+00f, 7.49874413e-01f, -2.83738464e-01f,
  -4.63472188e-01f, -7.47080743e-01f, 3.52918506e-01f, -5.74749708e-01f, 3.17063332e-01f, -7.57861912e-01f, -1.30055451e+00f, -1.79806006e+00f, 4.05017287e-01f, -3.88673954e-02f,
  -9.71510351e-01f, -3.62242162e-01f, -2.18916416e-01f, 6.65622473e-01f, -6.45982862e-01f, 1.46834135e-01f, -5.42385764e-02f, 6.36684537e-01f, -1.86392888e-01f, 7.16689110e-01f,
  1.39768213e-01f, 1.60437599e-01f, -8.92683446e-01f, 1.81876659e-01f, 8.48312199e-01f, 2.31860712e-01f, 1.31504819e-01f, 1.89893264e-02f, 5.11078298e-01f, 9.40457582e-01f,
  9.42960382e-01f, 8.90528798e-01f, -2.04283223e-01f, -4.64956284e-01f, -7.76723862e-01f, -1.11637080e+00f, 1.34024465e+00f, -4.39738810e-01f, 1.01266778e+00f, -3.66523974e-02f,
  -5.45935571e-01f, 2.10047030e+00f, 1.15386808e+00f, 9.63548541e-01f, 1.06393445e+00f, -3.29578161e-01f, 7.72908628e-01f, -3.15894067e-01f, 4.53444533e-02f, 1.06995535e+00f,
  3.69718462e-01f, -1.57350719e+00f, 1.19805418e-01f, -1.76587737e+00f, 9.42745745e-01f, 5.94757438e-01f, -4.62635010e-01f, -1.83263361e+00f, 6.52914166e-01f, -1.84814692e-01f,
  -6.32859826e-01f, -4.60057557e-01f, -6.09490156e-01f, -1.08509541e+00f, 1.01481187e+00f, -1.72970343e+00f, 4.85112906e-01f, -9.34412837e-01f, -7.37722337e-01f, -3.67060751e-01f,
  7.28611410e-01f, 2.61724234e-01f, 2.80753255e-01f, -9.28753853e-01f, 2.64585376e-01f, 1.10235222e-01f, 6.84958577e-01f, 1.08333468e+00f, 9.80479538e-01f, 9.94774252e-02f,
  9.91537273e-01f, 3.88129443e-01f, 2.14022979e-01f, 4.49773252e-01f, -1.39495397e+00f, -4.95154746e-02f, -3.46170276e-01f, 7.50327945e-01f, 7.99540937e-01f, -6.44379616e-01f,
  -1.47164738e+00f, 1.16661370e+00f, -8.88975084e-01f, -2.31700361e-01f, 8.86504501e-02f, 2.54176468e-01f, 4.15252537e-01f, -1.48750210e+00f, -1.33433068e+00f, 4.03765082e-01f,
  -4.23518658e-01f, 4.95223403e-01f, -7.82750547e-01f, -2.78473705e-01f, -9.26138461e-01f, -5.54226100e-01f, 6.51353970e-02f, -1.29345810e+00f, -1.23638511e+00f, -6.90755844e-02f,
  -1.40377009e+00f, 2.69698109e-02f, 3.39985371e-01f, 6.54959440e-01f, 1.84514150e-01f, -8.84573936e-01f, 2.07850054e-01f, 1.17728814e-01f, -1.97043017e-01f, 9.22960341e-01f,
  5.01958989e-02f, 8.59843850e-01f, 1.08992410e+00f, -1.09435320e+00f, 1.21782947e+00f, 1.28649676e+00f, -1.96077418e+00f, -1.87432334e-01f, -1.13756828e-01f, 1.11664319e+00f,
  -7.94905484e-01f, -1.00570381e+00f, -3.52178663e-01f, 4.41880912e-01f, 9.67848837e-01f, -5.91911554e-01f, -8.10705662e-01f, 1.81649789e-01f, -1.46505368e+00f, 4.37004685e-01f,
  5.00764370e-01f, -8.78228307e-01f, 6.80928946e-01f, -6.61509991e-01f, -1.50992250e+00f, -1.36293077e+00f, -4.03095156e-01f, -6.84365392e-01f, 7.56371439e-01f, 9.33788046e-02f,
  3.72934818e-01f, 6.47685766e-01f, 4.48988289e-01f, 5.06744921e-01f, 6.82396233e-01f, -1.54700547e-01f, 1.63081020e-01f, -9.63162661e-01f, -1.95168570e-01f, -1.35803068e+00f,
  4.94641334e-01f, -8.78896773e-01f, -4.00052875e-01f, 1.51661134e+00f, 3.71265501e-01f, -1.73866689e+00f, 1.06940043e+00f, 2.99486518e-01f, 3.02487731e-01f, -2.35198781e-01f,
  1.03449595e+00f, -7.31067434e-02f, -1.08051538e+00f, -1.50873518e+00f, 1.25915098e+00f, 1.09597409e+00f, -1.04298639e+00f, 1.96592975e+00f, -9.33858573e-01f, -3.07619572e-01f,
  -1.26515377e+00f, 9.70405191e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.10862327e-02f, -2.78609961e-01f, 5.79279244e-01f, 2.84586191e-01f, 3.93126547e-01f, -6.15965068e-01f, -1.23046869e-02f, -8.93344581e-01f, 5.11071920e-01f, -2.85308540e-01f,
  -9.72330868e-02f, 4.61727411e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    