/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.92427272e-01f, -7.15233013e-02f, 1.74613178e-01f, 1.24342367e-01f, 1.45859450e-01f, -2.16610217e-03f, -1.91718534e-01f, -1.75230756e-01f, -1.14296570e-01f, -1.51282087e-01f,
  -1.59324154e-01f, -1.24124162e-01f, -2.30541509e-02f, 1.03003569e-01f, 2.03470528e-01f, -8.95373430e-03f, 1.32373646e-01f, 4.14377749e-01f, 9.18100104e-02f, 7.97646642e-02f,
  -3.62193845e-02f, 3.70049104e-02f, 1.96462527e-01f, 2.09936485e-01f, 1.56671166e-01f, -6.69464841e-03f, 1.04350351e-01f, 1.95254788e-01f, 2.92790115e-01f, 4.39824164e-01f,
  8.16077143e-02f, 1.73425630e-01f, -8.36102068e-02f, 5.70267290e-02f, -4.88110594e-02f, 1.81401875e-02f, -1.21729020e-02f, -5.22505259e-03f, -2.94219609e-02f, -9.89385843e-02f,
  -3.18169445e-02f, -1.87219698e-02f, 3.14844921e-02f, 4.46917303e-02f, 2.58720038e-03f, 4.80974540e-02f, 1.05850391e-01f, 2.27918789e-01f, -1.19549213e-02f, -5.60967885e-02f,
  2.75325216e-02f, 3.58044431e-02f, 1.19707622e-01f, -1.58891710e-03f, 5.29745296e-02f, 9.16464441e-03f, 2.08499376e-02f, 6.70152679e-02f, 1.22083656e-01f, 8.12054574e-02f,
  -3.46538681e-03f, 1.11236498e-01f, -4.45055738e-02f, 1.29300449e-03f, -4.36721034e-02f, -9.46811438e-02f, 1.22417994e-01f, -1.67777762e-02f, 2.82082371e-02f, 1.06794596e-01f,
  8.00856799e-02f, -1.93627268e-01f, -8.27519447e-02f, 1.43639455e-02f, -1.03254549e-01f, -2.97485087e-02f, -5.91114350e-02f, -1.52176917e-01f, -1.21994689e-01f, -1.73871845e-01f,
  -7.83521533e-02f, 1.11423284e-02f, -5.75110801e-02f, 1.13011058e-02f, 8.26280862e-02f, -1.27511667e-02f, -4.93162014e-02f, -4.35207859e-02f, -2.66152453e-02f, 5.79467379e-02f,
  -3.54500949e-01f, 1.48233965e-01f, -3.76688279e-02f, -7.92130902e-02f, -1.45096378e-02f, 7.23265037e-02f, 3.33891809e-02f, 4.22130115e-02f, -1.25040812e-02f, 3.06077823e-02f,
  -1.03254542e-02f, 8.84792283e-02f, 8.08177702e-03f, 4.07750048e-02f, -8.49698037e-02f, -2.17551515e-02f, 2.63641290e-02f, 1.02323882e-01f, -1.18629858e-01f, -2.29518563e-02f,
  -4.98394668e-02f, -8.42614919e-02f, -4.30138446e-02f, -1.01799332e-01f, -8.02337825e-02f, -1.10766485e-01f, -6.57708868e-02f, 5.52387163e-02f, -6.92047477e-02f, -2.38098562e-01f,
  -7.96888709e-01f, -1.12385593e-01f, -1.53533846e-01f, -1.23074748e-01f, 2.09434420e-01f, 2.53288239e-01f, 1.30385250e-01f, 1.44244030e-01f, -8.61483589e-02f, -4.01595235e-02f,
  1.67751566e-01f, 5.75799532e-02f, -3.54919471e-02f, 1.00671150e-01f, 4.17926870e-02f, -4.16580252e-02f, 2.42372323e-02f, -7.56045133e-02f, 1.40769452e-01f, 1.39216691e-01f,
  2.07150817e-01f, -1.35167599e-01f, -1.25668600e-01f, 6.36958480e-02f, -1.71275642e-02f, 1.17955126e-01f, -4.45213318e-02f, -3.75014618e-02f, 1.62265971e-01f, -7.74423480e-02f,
  -3.13623756e-01f, -1.12576142e-01f, 1.43919721e-01f, 2.40833461e-02f, -1.82974413e-02f, -1.21807374e-01f, 2.58657932e-02f, -6.96923360e-02f, 2.48383451e-02f, -4.22519781e-02f,
  -3.55337723e-03f, 5.06310016e-02f, -5.71478531e-02f, 1.33401886e-01f, -4.94325832e-02f, 2.10893583e-02f, -2.66287336e-03f, -1.51177377e-01f, -4.48644198e-02f, 6.72534928e-02f,
  9.19527262e-02f, 1.44534779e-03f, -5.88777736e-02f, 1.12888440e-01f, -3.97984311e-03f, 2.81507317e-02f, -1.49113138e-03f, 2.77962293e-02f, -1.78308468e-02f, -1.35044888e-01f,
  7.20921382e-02f, -1.10607510e-02f, 2.87772398e-02f, 5.80015257e-02f, -1.62475612e-02f, 3.92232835e-02f, -2.73422268e-03f, 8.63028318e-02f, 7.02403113e-02f, -7.30367824e-02f,
  2.66443286e-02f, -7.40892533e-03f, 1.13232195e-01f, 4.34043854e-02f, 1.06219076e-01f, 7.11081922e-02f, 5.83470054e-02f, 3.04953214e-02f, 7.01695532e-02f, 6.33149669e-02f,
  -4.40708436e-02f, 5.50732128e-02f, -2.22725663e-02f, 2.85349134e-02f, 1.95704866e-02f, 3.51305939e-02f, 1.25475163e-02f, 1.23919174e-01f, -1.09111905e-01f, -6.50804639e-02f,
  -2.44525388e-01f, 1.36104375e-01f, -1.38829216e-01f, 1.07400097e-01f, 5.76247685e-02f, -6.44193515e-02f, -2.04975586e-02f, -4.76866998e-02f, 1.57674251e-03f, -4.56980051e-04f,
  3.49668227e-02f, -9.94286761e-02f, -5.42042358e-03f, -1.82043537e-02f, 6.84622116e-03f, 2.23159678e-02f, 1.32812411e-01f, 4.46195342e-03f, 8.76023099e-02f, -5.27109690e-02f,
  1.80904511e-02f, 1.23681193e-02f, -6.01710752e-02f, -3.43000330e-03f, 6.47639036e-02f, -1.50487527e-01f, -8.45678747e-02f, -7.10384995e-02f, 2.86775958e-02f, -2.10072771e-01f,
  2.14183833e-02f, -3.92816275e-01f, -3.98910701e-01f, 4.01155241e-02f, -4.53270078e-02f, 1.30214803e-02f, -9.51534733e-02f, 1.26494274e-01f, 2.20351264e-01f, -1.98378012e-01f,
  -9.65699255e-02f, 1.49193317e-01f, 9.48675945e-02f, 2.34513320e-02f, 9.71657932e-02f, -1.72548652e-01f, -1.92541510e-01f, -4.73603085e-02f, 3.77891988e-01f, 1.87218904e-01f,
  1.17761962e-01f, 8.68146569e-02f, 1.64299719e-02f, 1.71988711e-01f, -7.18164891e-02f, 8.07002410e-02f, -2.61647135e-01f, -1.90611675e-01f, -1.46959245e-01f, -3.24200034e-01f,
  -1.83894292e-01f, -1.81481361e-01f, 1.98018327e-01f, 1.54081091e-01f, 4.21362743e-02f, 1.77034974e-01f, 1.00505769e-01f, -1.97750069e-02f, 1.06422760e-01f, 5.85253946e-02f,
  9.25085098e-02f, 8.19382370e-02f, 7.34527931e-02f, 6.11603968e-02f, 8.32160190e-02f, 1.62112340e-02f, 1.20648462e-02f, -8.13906416e-02f, 6.58807456e-02f, 8.98045599e-02f,
  5.49995899e-02f, -8.88620391e-02f, -1.21637657e-02f, 4.68240827e-02f, -5.88683831e-03f, 1.52453631e-01f, -9.82988924e-02f, -5.51752299e-02f, -6.80858046e-02f, -1.39851376e-01f,
  -4.09541577e-02f, -2.06167940e-02f, -9.79560539e-02f, -7.33696818e-02f, 3.97071097e-04f, 9.78405733e-05f, -9.64046717e-02f, -2.27461685e-03f, -7.24438205e-02f, 1.56695377e-02f,
  -7.54608810e-02f, -1.13142841e-01f, -2.65515503e-02f, -6.36049956e-02f, -7.34993294e-02f, -1.61447853e-01f, -2.49548387e-02f, -3.49974632e-02f, 7.77773885e-03f, -1.73872355e-02f,
  9.56960171e-02f, -3.70002612e-02f, 6.16506953e-03f, 6.48205876e-02f, -4.49097306e-02f, -1.06640220e-01f, -4.34463508e-02f, 5.73429875e-02f, 8.89473334e-02f, -3.46350297e-03f,
  2.21030354e-01f, -5.21337390e-02f, -3.30316499e-02f, 3.10843755e-02f, 1.47168962e-02f, 8.60493630e-02f, 4.15531099e-02f, 5.70167787e-02f, -2.43947599e-02f, 7.91896433e-02f,
  5.03104851e-02f, 9.50181410e-02f, -1.57571677e-02f, 1.23889251e-02f, 9.14543346e-02f, 1.30545795e-01f, -5.45628704e-02f, 4.82626483e-02f, 5.60472272e-02f, -2.95022838e-02f,
  1.29752517e-01f, 1.18442737e-01f, 1.33035287e-01f, -3.10827512e-02f, 9.55152437e-02f, 1.48099437e-01f, 7.59520829e-02f, 1.31938651e-01f, 7.04712495e-02f, 7.11753294e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.54747465e-02f, 3.24337892e-02f, -4.31653231e-01f, -3.23024346e-03f, -3.94792736e-01f, -1.39753446e-01f, -2.00469662e-02f, 1.83506951e-01f, -6.87589049e-02f, -2.96146005e-01f,
  1.57538557e-03f, 9.97753963e-02f, 2.20963769e-02f, 6.62435666e-02f, 1.55742848e-02f, -1.76048771e-01f, -3.64206463e-01f, -1.41817167e-01f, 1.75698042e-01f, 1.36758626e-01f,
  3.34923305e-02f, 3.12055182e-02f, 1.08008254e-02f, 1.67400673e-01f, -7.36389011e-02f, -1.08373584e-02f, -1.86143026e-01f, -2.22991288e-01f, -1.83459356e-01f, -4.63904023e-01f,
  -2.31426880e-01f, -2.30615422e-01f, -5.59322499e-02f, -6.17986284e-02f, -8.93792659e-02f, 1.01024002e-01f, -2.17180289e-02f, -5.57322986e-02f, -5.66857792e-02f, -1.72253400e-01f,
  -1.11272514e-01f, 8.22788011e-03f, 5.77411540e-02f, 1.66182462e-02f, -1.29868299e-01f, -9.11729559e-02f, 6.19304273e-03f, -7.76404366e-02f, 1.92295648e-02f, 3.83122526e-02f,
  1.33987181e-02f, -1.04940698e-01f, 3.49721909e-02f, -4.19222843e-03f, 2.99700778e-02f, -1.44615183e-02f, 6.17928728e-02f, -1.31139159e-01f, -1.14990927e-01f, -7.47363791e-02f,
  -1.91859845e-02f, 2.41622720e-02f, -6.72062347e-03f, 7.31914788e-02f, 1.43367171e-01f, 4.44716327e-02f, 8.98391288e-03f, 1.30566403e-01f, 2.13817358e-02f, 4.43422273e-02f,
  7.02316500e-03f, 1.12411110e-02f, 6.30869269e-02f, 7.02289939e-02f, -7.03196749e-02f, -6.88893674e-03f, 4.38742377e-02f, 1.12158597e-01f, -5.48172109e-02f, -8.63393303e-03f,
  6.39237184e-03f, -1.32860452e-01f, -7.47413188e-02f, -1.68216194e-03f, -1.25480279e-01f, -1.77587941e-01f, -2.83253845e-02f, -2.00530216e-02f, 9.70317796e-02f, -1.18683122e-01f,
  3.64504933e-01f, -2.19985068e-01f, -3.66347805e-02f, 7.12008923e-02f, -8.20443705e-02f, -1.33602872e-01f, 1.19735776e-02f, -1.13130234e-01f, -1.55407205e-01f, -1.10897377e-01f,
  -1.71170443e-01f, 1.47754443e-04f, 9.80116278e-02f, -1.86598748e-02f, -4.00878973e-02f, -4.42111567e-02f, 7.38038644e-02f, -2.25527231e-02f, -4.53931913e-02f, -6.63197115e-02f,
  -7.04460442e-02f, 4.71547432e-03f, 1.65346250e-01f, 1.09965898e-01f, 5.50473854e-02f, 3.93707603e-02f, 3.15964520e-02f, 2.29916703e-02f, 3.86832729e-02f, 1.49316281e-01f,
  -1.49345383e-01f, -1.83501244e-01f, 1.61917135e-01f, 1.41911745e-01f, -1.55977041e-01f, -3.60418737e-01f, -4.74827647e-01f, -2.35437855e-01f, -1.13555722e-01f, -1.60785452e-01f,
  -1.87537029e-01f, 7.96044916e-02f, -2.20384263e-03f, 1.19639099e-01f, 1.17811784e-01f, 6.28353581e-02f, 4.17171180e-01f, 3.77187908e-01f, 2.15374991e-01f, -2.23660506e-02f,
  1.94474876e-01f, 3.08195889e-01f, 2.02786982e-01f, 1.59458429e-01f, 1.81385934e-01f, 7.52058476e-02f, 5.79821020e-02f, 1.84672862e-01f, 8.72536078e-02f, 3.92278552e-01f,
  -2.28045970e-01f, -3.40028182e-02f, 7.22106397e-02f, 4.10570391e-02f, 3.58434282e-02f, -1.33607104e-01f, -4.82232198e-02f, 8.56506079e-02f, -5.17124571e-02f, -8.50165710e-02f,
  -2.00348739e-02f, -7.82248005e-02f, -9.79403928e-02f, 1.22113645e-01f, -5.12572192e-02f, -4.44765724e-02f, 1.68878883e-01f, 2.91362554e-01f, -3.80108453e-04f, -7.62395933e-02f,
  9.64338332e-02f, 1.36530057e-01f, -1.40304029e-01f, 1.86243968e-03f, -4.16509993e-02f, 1.10122912e-01f, -1.59583930e-02f, 1.17138401e-01f, -1.04977801e-01f, 9.61278528e-02f,
  7.65721276e-02f, 9.91494283e-02f, 2.77599357e-02f, -4.81285304e-02f, 2.53172293e-02f, -7.27654025e-02f, 1.22381717e-01f, 1.83465600e-01f, 4.52765673e-02f, 1.06144138e-01f,
  -6.98711202e-02f, 5.66940382e-02f, -8.89197737e-02f, -6.97911978e-02f, -3.92032303e-02f, 7.28583038e-02f, 6.09239563e-02f, 4.34588231e-02f, -1.63031258e-02f, -8.32625404e-02f,
  4.80002910e-02f, 8.55959114e-03f, -5.98558523e-02f, -2.81478977e-03f, 1.50540590e-01f, 1.28294155e-01f, 6.44575730e-02f, -7.61885047e-02f, 3.67836468e-02f, 1.01898104e-01f,
  -6.37207150e-01f, 1.98241085e-01f, 1.80316865e-01f, 2.58538336e-01f, -2.26852577e-02f, 5.64224683e-02f, 1.22274578e-01f, -5.26162907e-02f, -1.21031620e-01f, -7.97519311e-02f,
  -1.31374866e-01f, -1.58674300e-01f, 4.10601078e-03f, 3.62192728e-02f, -1.19146192e-02f, -5.72669739e-03f, 1.35427237e-01f, 3.92666906e-02f, -1.10054307e-01f, -2.26907998e-01f,
  -4.15666141e-02f, -1.77965000e-01f, -3.01233172e-01f, -6.60601184e-02f, -1.42683377e-04f, -2.10834220e-02f, -1.34695411e-01f, -1.18202195e-01f, -2.14384660e-01f, -3.88768822e-01f,
  -1.95897520e-01f, 2.15268716e-01f, -1.01853393e-01f, 2.93722212e-01f, -2.56214738e-02f, -2.69068360e-01f, -3.22395802e-01f, -9.82830897e-02f, 7.73552880e-02f, 8.80151838e-02f,
  -9.93409008e-02f, 1.56003982e-01f, 2.03480080e-01f, 8.68596658e-02f, -2.02118888e-01f, 1.21801216e-02f, 3.66284281e-01f, 2.35040747e-02f, -3.17466468e-01f, -2.65893638e-01f,
  1.05785362e-01f, 2.27115199e-01f, -9.20667499e-02f, -2.77293064e-02f, 1.38651937e-01f, 4.71691340e-02f, 1.89188600e-01f, 1.32909849e-01f, -6.08144142e-02f, 3.26653183e-01f,
  -2.82171220e-01f, -3.55229139e-01f, 7.96322525e-02f, 1.08534008e-01f, -1.39274949e-03f, 4.58579473e-02f, -5.99978666e-04f, 3.43490764e-02f, 5.97153977e-02f, 3.22232470e-02f,
  -4.37514186e-02f, -9.69547778e-02f, 1.59795508e-01f, -5.20149507e-02f, -2.58395392e-02f, -1.43434316e-01f, 6.25966936e-02f, 6.00981861e-02f, 9.73532870e-02f, -9.22492296e-02f,
  1.62133977e-01f, -3.75967547e-02f, -2.21267164e-01f, -6.21503918e-03f, -8.06247368e-02f, 5.13824914e-03f, -1.44101098e-01f, -2.12238193e-01f, -2.51844108e-01f, -8.11423063e-02f,
  -1.58648625e-01f, -4.13643382e-02f, 3.20607051e-02f, -4.73015867e-02f, 1.34399250e-01f, 2.80601308e-02f, -8.82664397e-02f, -1.32985376e-02f, 7.47157037e-02f, -5.38121052e-02f,
  -7.64017552e-02f, 8.98749530e-02f, -3.73235345e-02f, -1.48769200e-01f, -4.84512001e-02f, -1.92563795e-02f, -1.34039465e-02f, 1.50071383e-01f, 3.46898884e-02f, -3.24029215e-02f,
  9.11811888e-02f, -1.17039211e-01f, -8.83078575e-03f, 2.92745400e-02f, 4.18173261e-02f, -5.21762902e-03f, 4.18565562e-03f, 1.13917878e-02f, 7.61962011e-02f, -1.77925736e-01f,
  1.12417422e-01f, 7.99168795e-02f, 8.48795325e-02f, 8.62293616e-02f, 9.35774855e-03f, 2.89136283e-02f, 7.79727623e-02f, -4.74153385e-02f, -2.26747263e-02f, -5.33438995e-02f,
  -1.91930786e-01f, -8.80639479e-02f, 1.51041195e-01f, -6.34909868e-02f, -3.83640118e-02f, -4.26621959e-02f, 7.48135522e-02f, 9.47781727e-02f, -6.02890030e-02f, -2.70288121e-02f,
  1.12117328e-01f, 7.48433312e-03f, -1.68147042e-01f, -4.52551022e-02f, 1.20595038e-01f, -1.05982870e-02f, -5.92343397e-02f, -7.86249265e-02f, -3.40130210e-01f, 1.02924332e-02f,
  7.13254571e-01f, -4.62992221e-01f, -3.67827922e-01f, 1.48132712e-01f, 1.71067417e-02f, 1.28540188e-01f, -2.41796210e-01f, -8.01355019e-02f, 9.13573056e-02f, -2.05943733e-01f,
  5.77405393e-02f, 2.59383798e-01f, 1.58588901e-01f, 8.99213478e-02f, 1.73057646e-01f, -3.17360222e-01f, -2.48627812e-01f, 1.11029543e-01f, 3.50113571e-01f, 2.75229961e-01f,
  7.42264763e-02f, -1.90251488e-02f, 1.10895090e-01f, 1.34835064e-01f, -3.09361696e-01f, 8.49963501e-02f, -3.89218092e-01f, -2.81887501e-01f, -1.65025800e-01f, -4.39254016e-01f,
  2.30173897e-02f, -6.93522319e-02f, 1.39531225e-01f, 1.08602211e-01f, -5.47803640e-02f, 5.18585071e-02f, 2.98782345e-02f, -6.48421422e-02f, -3.46540473e-02f, -1.74694166e-01f,
  -7.20446035e-02f, -2.55902447e-02f, 7.85410851e-02f, -3.99330966e-02f, -3.43514010e-02f, -2.64098030e-02f, -1.07507400e-01f, -1.25732897e-02f, -3.81209212e-03f, 5.72548108e-03f,
  1.54067026e-02f, -3.10794916e-02f, -1.19885646e-01f, 5.35351364e-03f, 1.37667909e-01f, 7.68688321e-02f, -1.72875404e-01f, 1.81316249e-02f, 9.17308852e-02f, -2.57963032e-01f,
  -8.70398362e-04f, 3.90331373e-02f, 6.59573684e-03f, 1.92950889e-02f, 5.69272935e-02f, -9.68608446e-03f, 6.02634959e-02f, -1.55051164e-02f, 7.77894557e-02f, -7.70102516e-02f,
  1.09660625e-02f, -5.43394722e-02f, 2.90868133e-02f, -4.81354222e-02f, 1.81612000e-02f, 2.07113978e-02f, 6.57744780e-02f, -3.28745209e-02f, -2.71007344e-02f, -4.05800305e-02f,
  8.06722045e-02f, 2.45959405e-02f, 1.85952988e-02f, 8.10615532e-03f, 7.05707865e-03f, 2.98271757e-02f, 8.26996099e-03f, 4.91627119e-02f, 9.71614644e-02f, -1.79165229e-02f,
  5.00034429e-02f, 1.76664010e-01f, -4.97172922e-02f, 3.54849361e-02f, -1.09813131e-01f, -4.02549841e-03f, 2.18151100e-02f, 1.29623953e-02f, -4.43698233e-03f, -7.37865865e-02f,
  -2.24161576e-02f, 1.18136667e-01f, -1.29725918e-01f, -9.77008864e-02f, 8.21518078e-02f, 1.42743468e-01f, -3.77367549e-02f, 6.94343448e-02f, 3.20261680e-02f, -6.13107756e-02f,
  -8.91301036e-02f, -4.93614227e-02f, 2.05494642e-01f, 6.60245270e-02f, -7.36010671e-02f, 2.30664313e-01f, 6.18415549e-02f, -3.81919444e-02f, 5.79611957e-02f, -1.58379048e-01f,
  3.29801708e-01f, 3.08555156e-01f, 2.37190068e-01f, 7.12092742e-02f, 7.25077316e-02f, 1.76310956e-01f, 2.51818031e-01f, 2.13513941e-01f, -1.77402332e-01f, 1.06976397e-01f,
  5.32006137e-02f, -3.16504873e-02f, -2.16803215e-02f, -1.30412862e-01f, 7.93848746e-03f, 1.00505479e-01f, 1.89505070e-02f, 1.28568886e-02f, -6.96371496e-02f, 6.51640305e-03f,
  -1.42168343e-01f, 4.55350243e-02f, 8.54907781e-02f, -7.14623332e-02f, -2.23305561e-02f, -1.88670158e-01f, 7.02272356e-02f, 1.57215476e-01f, 1.71919122e-01f, -1.91312656e-01f,
  6.94310144e-02f, 5.06042361e-01f, -1.76593617e-01f, -1.49253100e-01f, -2.24065259e-02f, -1.28736153e-01f, -5.75203747e-02f, -8.60612243e-02f, 6.03426881e-02f, -1.26346961e-01f,
  -9.60221887e-02f, -6.54873326e-02f, 1.98363513e-02f, 6.64147490e-04f, 4.85404991e-02f, 1.03662565e-01f, 1.96102813e-01f, 5.81083819e-02f, 9.80022997e-02f, 8.08896720e-02f,
  7.24956542e-02f, 1.80440262e-01f, 1.73455834e-01f, 5.17099947e-02f, 1.21308364e-01f, -2.09924094e-02f, 6.95619211e-02f, 6.28651306e-02f, 1.27693983e-02f, 7.93572441e-02f,
  2.52124108e-02f, -8.69335458e-02f, -1.59222439e-01f, 3.25077847e-02f, 2.88512483e-02f, 1.48234656e-02f, 2.16483641e-02f, 1.40348701e-02f, 5.02505898e-02f, 6.51642531e-02f,
  1.44816026e-01f, 1.29839391e-01f, 2.03236174e-02f, 6.68382794e-02f, 8.98585934e-03f, -2.15674061e-02f, 3.48888040e-02f, 1.04091406e-01f, 9.82071832e-02f, 3.92276375e-03f,
  8.66720676e-02f, 6.34623840e-02f, -7.81090511e-03f, 1.47096276e-01f, -2.08013167e-04f, 6.22652844e-02f, 4.78879549e-02f, 2.66445633e-02f, 8.57628509e-02f, 3.95627692e-03f,
  -4.00812596e-01f, 1.96641862e-01f, -1.86289534e-01f, -7.61017278e-02f, -1.34578012e-02f, 5.65196499e-02f, -7.39471987e-02f, -1.07307374e-01f, -1.42281532e-01f, -9.71351787e-02f,
  -1.28832147e-01f, -1.22584976e-01f, 1.16647795e-01f, 1.52725562e-01f, -1.08173579e-01f, -4.15277816e-02f, -4.08688327e-03f, -2.26937719e-02f, 4.96429615e-02f, -1.55574447e-02f,
  2.02557426e-02f, -1.68413632e-02f, -5.75755388e-02f, -1.02926776e-01f, -1.96012594e-02f, -1.56654701e-01f, -1.75773278e-01f, -5.53264245e-02f, -1.42477909e-02f, -1.53064027e-01f,
  -1.83642760e-01f, -6.88296109e-02f, 2.95622200e-02f, 2.22869664e-01f, 5.87173514e-02f, -3.45994145e-01f, -5.42383134e-01f, -4.09467459e-01f, -1.07006788e-01f, -7.77147263e-02f,
  -1.89295739e-01f, 6.87846616e-02f, 1.37569532e-01f, 5.99982403e-02f, -2.97432505e-02f, -1.05837258e-02f, 3.00782770e-01f, 1.19568288e-01f, -7.39870295e-02f, -1.31316632e-01f,
  1.77577868e-01f, 1.50000274e-01f, -5.07059619e-02f, -5.13194464e-02f, 2.55382746e-01f, -9.22185834e-03f, -2.71003339e-02f, 5.89598678e-02f, 3.10030393e-02f, 5.36248267e-01f,
  2.13540167e-01f, -1.24192849e-01f, -1.24542572e-01f, 6.20249398e-02f, 1.26339063e-01f, -5.39517701e-02f, -5.90992102e-04f, 8.51886421e-02f, 5.88193052e-02f, 1.39547482e-01f,
  1.95181161e-01f, 4.10596207e-02f, 8.35639536e-02f, 6.57862723e-02f, -2.93656299e-03f, -1.87323336e-02f, -3.88876982e-02f, 1.15606487e-01f, 6.11330289e-03f, -1.18030086e-01f,
  1.94228500e-01f, -6.13341527e-03f, -3.08014303e-01f, -2.30151489e-01f, -1.03145711e-01f, 2.01264307e-01f, -1.65942103e-01f, 7.37685785e-02f, -1.37207612e-01f, -7.09720924e-02f,
  -7.94389546e-02f, -2.31504906e-02f, 6.43464774e-02f, 4.86047566e-02f, 8.44972283e-02f, 9.10129771e-02f, 6.65295050e-02f, -2.40814760e-02f, -3.33121009e-02f, 8.81966874e-02f,
  8.19583833e-02f, 1.19079992e-01f, 9.48346686e-03f, 3.34848575e-02f, 3.50363180e-02f, -7.78327659e-02f, 1.07266940e-01f, -3.60229798e-02f, 1.27976425e-02f, -1.13781594e-01f,
  -7.64506403e-03f, 5.51359728e-02f, 1.92719027e-02f, -2.58172508e-02f, 3.11117936e-02f, -2.15369207e-03f, 1.18019275e-01f, -4.62752469e-02f, -4.30391058e-02f, -4.15137708e-02f,
  4.47661206e-02f, 8.22377205e-02f, 1.05231605e-01f, 7.30292406e-03f, 7.82641023e-03f, -1.02496900e-01f, 5.48418500e-02f, 8.48960504e-02f, 7.01648891e-02f, 2.49040443e-02f,
  -8.27799086e-03f, -1.39980782e-02f, -2.96680573e-02f, 1.57323796e-02f, -3.78960595e-02f, 1.22435447e-02f, 1.09495752e-01f, 1.01452388e-01f, -1.30205443e-02f, -8.77848417e-02f,
  7.62690827e-02f, -3.02945465e-01f, -4.29453492e-01f, -2.38009334e-01f, 4.59115021e-03f, -1.53327003e-01f, -1.79272965e-01f, -2.35505432e-01f, -3.90468180e-01f, -3.13306630e-01f,
  -2.17440099e-01f, 2.67252147e-01f, 4.72562574e-02f, 3.14231277e-01f, 3.00149292e-01f, 2.96465546e-01f, 4.68596220e-01f, 2.50620157e-01f, -3.85430567e-02f, -6.71323538e-02f,
  9.22441036e-02f, -2.73045916e-02f, 3.99544314e-02f, -1.02118023e-01f, 1.01291858e-01f, 2.08837137e-01f, 1.39947385e-01f, -9.69678909e-02f, -1.20555706e-01f, -1.49995774e-01f,
  -5.78313693e-02f, -1.56565189e-01f, -3.77306551e-01f, -1.02172114e-01f, -5.85894585e-02f, -3.96548808e-02f, 5.24152666e-02f, -5.96743897e-02f, 7.09210336e-02f, -2.49250054e-01f,
  -2.86183387e-01f, -5.42591400e-02f, -5.37966862e-02f, 7.50540048e-02f, -1.05483741e-01f, -3.14175189e-01f, -6.28665164e-02f, -2.25145742e-01f, -8.38295519e-02f, -1.98219031e-01f,
  -1.35574779e-02f, -2.16191754e-01f, 2.02369273e-01f, -7.96098709e-02f, -3.04770581e-02f, 2.99118669e-03f, -7.83482343e-02f, -7.17624649e-02f, -1.32650003e-01f, -1.86102867e-01f,
  -4.71337885e-02f, -1.98854223e-01f, -1.29888758e-01f, 1.06860951e-01f, 7.31507167e-02f, -2.29636952e-03f, 6.86664432e-02f, -1.50866926e-01f, -9.08969715e-02f, -4.61883634e-01f,
  3.95048633e-02f, 4.61480916e-02f, -5.75380884e-02f, 8.32310021e-02f, -9.04243141e-02f, -9.65712592e-02f, 6.65305480e-02f, 7.43017942e-02f, 1.45783173e-02f, -3.69489044e-02f,
  2.17510581e-01f, -5.19771781e-03f, 5.64010954e-03f, 7.49981925e-02f, 8.13190490e-02f, -5.63493781e-02f, 5.40957600e-02f, -4.82787825e-02f, 2.79164538e-02f, -1.94317341e-01f,
  -2.28485707e-02f, -3.79191376e-02f, -1.28771037e-01f, 1.26884691e-02f, 1.63387671e-01f, 1.69511050e-01f, -1.62769675e-01f, 1.58585921e-01f, 1.86051559e-02f, -9.72784963e-03f,
  -7.54206069e-03f, 4.45538498e-02f, -1.74051046e-01f, -1.06269680e-01f, -1.32469594e-01f, 7.81665668e-02f, 2.29153752e-01f, 1.54667139e-01f, 1.66743307e-03f, -1.39140002e-02f,
  6.36542141e-02f, 4.69513461e-02f, 1.84925854e-01f, -1.11205779e-01f, -2.02427944e-03f, 8.93333033e-02f, 1.70393869e-01f, 9.04740170e-02f, -1.23565190e-01f, -8.05578604e-02f,
  5.90415299e-02f, 1.85275842e-02f, -9.70143676e-02f, 1.33122802e-01f, 6.99292049e-02f, 1.02927618e-01f, -2.84773540e-02f, -2.24764705e-01f, -7.11984560e-02f, -1.95133314e-02f,
  -9.53872055e-02f, 2.92212546e-01f, 4.20566797e-02f, 2.23878846e-01f, -1.71975195e-01f, -2.72182852e-01f, -1.25556260e-01f, -1.84628405e-02f, 5.26174158e-02f, 4.17037398e-01f,
  1.02572612e-01f, -2.61552781e-02f, 4.12677415e-02f, -1.36417702e-01f, -3.67159754e-01f, -5.05300723e-02f, -9.73988175e-02f, -2.71571130e-01f, -4.05704230e-01f, -4.30157930e-01f,
  -4.77472432e-02f, 1.24310330e-02f, -2.07394101e-02f, -1.98455080e-02f, 1.14559047e-01f, 5.15508801e-02f, 3.69861782e-01f, 5.75854257e-02f, -2.33442679e-01f, 3.61795048e-03f,
  9.20016766e-02f, -1.52181283e-01f, -2.28184000e-01f, -1.64334834e-01f, 9.08933431e-02f, 9.00993124e-03f, -1.10594459e-01f, -2.85246279e-02f, -3.51151824e-02f, 7.02489167e-03f,
  -3.53899878e-03f, 1.71417575e-02f, -2.52044380e-01f, 1.47711933e-02f, -7.13934377e-02f, -6.18604943e-02f, 1.05195969e-01f, -2.23181501e-01f, -1.82786360e-01f, -1.80114716e-01f,
  -1.71028942e-01f, -1.87956944e-01f, -1.39098093e-01f, -5.28462231e-02f, -1.34817585e-01f, -6.74483553e-02f, -2.94463541e-02f, -1.82232291e-01f, -3.43926102e-01f, 2.79072523e-01f,
  6.36060536e-02f, 1.17331613e-02f, -3.45343500e-02f, 1.57473106e-02f, 1.67347565e-01f, 2.10589468e-02f, 4.91103306e-02f, 1.50538966e-01f, 8.19124058e-02f, -1.53184645e-02f,
  -6.39568642e-02f, 1.05363041e-01f, 4.26154630e-03f, 4.87395488e-02f, 2.82677431e-02f, 7.63281807e-02f, -8.78387503e-03f, 1.10992245e-01f, -1.28593802e-01f, 4.38688183e-03f,
  6.25525787e-02f, 9.65902060e-02f, 8.06854367e-02f, 8.91011357e-02f, -4.06986624e-02f, 3.51631492e-02f, -2.58002267e-03f, 1.57642178e-02f, 2.99872085e-02f, -6.42070267e-03f,
  3.81985098e-01f, -4.13156450e-01f, 2.50365704e-01f, -4.83923741e-02f, -8.56317207e-02f, 3.75280343e-02f, 1.10725343e-01f, 1.32045299e-01f, 1.13616340e-01f, 1.62830144e-01f,
  -8.74626786e-02f, 2.07247764e-01f, 3.76651660e-02f, -2.79678125e-03f, -1.38969198e-01f, -8.06172043e-02f, 1.22935966e-01f, 9.36693922e-02f, -1.47529453e-01f, 1.66551098e-01f,
  8.18835944e-02f, 1.02161475e-01f, 2.13602230e-01f, 1.88504413e-01f, 8.79501775e-02f, -9.41222087e-02f, 1.53399229e-01f, 1.53040946e-01f, -1.60842568e-01f, 6.40405476e-01f,
  -3.29051852e-01f, 4.68681544e-01f, 1.00762555e-02f, 8.80808011e-02f, 3.04539204e-01f, 1.65489227e-01f, 3.32523763e-01f, 7.55034313e-02f, -2.06810832e-01f, 3.78885530e-02f,
  1.63865834e-01f, -5.03933057e-02f, -6.05893619e-02f, -6.25251979e-02f, -1.73584580e-01f, 1.48549363e-01f, 2.71261036e-01f, -1.11055754e-01f, -4.14578319e-01f, 1.59591790e-02f,
  1.91589475e-01f, -1.73280239e-02f, -2.63147473e-01f, -1.63262084e-01f, 1.74579024e-01f, -1.04211666e-01f, -6.46745265e-02f, 9.39954296e-02f, 1.65929317e-01f, 2.82584041e-01f,
  5.79757476e-03f, -3.88014615e-02f, -1.60124272e-01f, -2.92988811e-02f, 1.58599034e-01f, -2.63348192e-01f, -1.82918862e-01f, -5.52976131e-02f, 7.04769567e-02f, -4.59777676e-02f,
  1.80841193e-01f, 5.44036068e-02f, 2.76539892e-01f, -3.75788026e-02f, -1.51931420e-01f, -7.72484988e-02f, -1.64496303e-01f, -1.31321982e-01f, -3.72764617e-01f, -1.76951170e-01f,
  4.99465585e-01f, 2.86999583e-01f, 5.70418574e-02f, -8.56989026e-02f, -8.03852901e-02f, 6.54856190e-02f, -1.85947139e-02f, -8.92906860e-02f, -7.21804351e-02f, -8.44696909e-02f,
  1.42178014e-01f, 3.87650728e-02f, -4.37214673e-02f, 3.93579677e-02f, -2.38719992e-02f, 1.80360042e-02f, 1.56687170e-01f, 1.54813886e-01f, -1.49746656e-01f, 2.02508364e-02f,
  -1.86213199e-02f, -1.46752223e-01f, -1.03288420e-01f, -4.88061309e-02f, -7.58896992e-02f, 8.81872401e-02f, 1.99995637e-02f, -5.04618846e-02f, -6.35460764e-02f, -2.00625658e-01f,
  -4.15469036e-02f, 4.79085371e-02f, -2.04810761e-02f, 7.50041530e-02f, -3.50936316e-02f, 2.11352378e-01f, -1.07094660e-01f, -1.07019439e-01f, -1.66652039e-01f, 7.47194365e-02f,
  -8.46183375e-02f, -2.50036716e-01f, -5.34603260e-02f, -7.68917352e-02f, 7.81774893e-02f, -3.86204347e-02f, 1.26587778e-01f, -1.19190320e-01f, 1.32345065e-01f, -7.53148422e-02f,
  1.46536946e-01f, 2.81486940e-02f, 3.21106873e-02f, -1.96095139e-01f, -1.14143334e-01f, -6.34901077e-02f, 2.31573246e-02f, -6.69910163e-02f, -1.53700203e-01f, -5.37108034e-02f,
  1.35391518e-01f, 6.87745661e-02f, -2.11629093e-01f, 5.68041876e-02f, -1.47800773e-01f, -4.27160747e-02f, 2.77003143e-02f, -1.26065746e-01f, -2.19652802e-01f, -2.99833864e-01f,
  4.20210421e-01f, 2.27032118e-02f, 2.64461190e-01f, 6.93182424e-02f, -1.58876762e-01f, -2.86894649e-01f, -4.44499373e-01f, -2.77095258e-01f, -1.77988738e-01f, 1.01644896e-01f,
  -1.42238721e-01f, -1.51722729e-01f, -3.48526426e-02f, 5.42539125e-03f, -7.78524950e-02f, 1.38271779e-01f, 1.96735024e-01f, 2.78202087e-01f, -2.07871586e-01f, -2.11546779e-01f,
  -3.83534804e-02f, 1.68492213e-01f, 1.22770898e-01f, -8.24393556e-02f, 1.06771648e-01f, -1.15466803e-01f, 5.06170131e-02f, 2.13548914e-01f, -6.18001148e-02f, 5.51618338e-01f,
  2.99239635e-01f, 2.15329453e-01f, -1.29194975e-01f, -1.09524377e-01f, 1.31489828e-01f, 1.01482660e-01f, -7.59479553e-02f, 2.23155856e-01f, 1.17877461e-02f, 1.29866898e-01f,
  1.90850422e-02f, 5.05702104e-03f, -7.76115283e-02f, -1.02431156e-01f, -1.73751041e-01f, -2.52811998e-01f, -1.69768676e-01f, 2.05343574e-01f, 1.63685471e-01f, -1.83873266e-01f,
  3.11800987e-02f, 4.62106280e-02f, -7.78249651e-02f, -1.58950120e-01f, 4.46380079e-02f, 1.04467228e-01f, -9.50870067e-02f, 5.34711219e-02f, -1.38673812e-01f, 1.35571748e-01f,
  -3.72542180e-02f, -3.50698233e-02f, 1.00705795e-01f, 1.07012980e-01f, -7.03493133e-02f, -5.53905703e-02f, 7.76847824e-02f, -1.57774031e-01f, -7.53651783e-02f, -5.83533645e-02f,
  -1.52097166e-01f, 4.17853473e-03f, 3.90850790e-02f, 1.04606980e-02f, 7.79812410e-02f, 1.74535606e-02f, -1.33616760e-01f, 6.62293937e-03f, 1.17814958e-01f, 1.36842951e-01f,
  2.82936096e-02f, 3.93454637e-03f, 8.90683830e-02f, -3.97703610e-02f, 6.20635338e-02f, 2.72773914e-02f, -7.84062892e-02f, -7.18013644e-02f, 6.05495684e-02f, -5.94250904e-03f,
  -3.45674515e-01f, -4.66708802e-02f, 5.36697507e-02f, -1.14688508e-01f, -7.73115549e-03f, 3.54933925e-02f, 5.77454232e-02f, 4.87450138e-02f, -3.65432985e-02f, -1.09405309e-01f,
  -1.08855858e-01f, -1.33881971e-01f, -7.08387941e-02f, -8.42206404e-02f, -6.26273733e-03f, -1.81813732e-01f, 2.74306852e-02f, -1.65457234e-01f, -9.19729173e-02f, -1.62099376e-01f,
  -1.76162273e-01f, -2.74636686e-01f, -9.87521559e-02f, -8.59113410e-02f, -1.85462404e-02f, -1.80492744e-01f, -2.68311083e-01f, -1.76539019e-01f, -3.03862005e-01f, -3.20795298e-01f,
  2.09281623e-01f, -2.61431932e-01f, -1.34557962e-01f, 2.41669565e-01f, 4.27380890e-01f, 4.16042417e-01f, 3.16452950e-01f, 3.14782709e-01f, 3.12057495e-01f, 1.02253616e-01f,
  -3.69682103e-01f, -3.17113727e-01f, -1.52532682e-01f, -2.71590531e-01f, -2.62180358e-01f, 8.19694623e-02f, 2.15885743e-01f, 5.91577031e-02f, 1.59532264e-01f, 8.43267441e-02f,
  9.44153741e-02f, 2.42517591e-01f, -1.09273225e-01f, 6.32949080e-03f, -2.42611617e-02f, 6.78672120e-02f, -3.99006084e-02f, -2.22453877e-01f, -3.24597239e-01f, -4.23433818e-02f,
  -4.09985065e-01f, -3.24068427e-01f, 2.08706841e-01f, -1.45196635e-02f, -1.02428347e-01f, 6.48446903e-02f, -4.14304994e-02f, -7.52775744e-02f, 3.97284888e-02f, 1.25796780e-01f,
  2.85295695e-02f, -6.39415607e-02f, 7.03130588e-02f, -3.62742017e-03f, 2.64898725e-02f, 3.79087441e-02f, -1.29641935e-01f, -2.08557695e-01f, -4.07055989e-02f, -3.03267568e-01f,
  -1.14116438e-01f, -1.47371963e-01f, -7.77925402e-02f, 4.86929417e-02f, -1.16728179e-01f, -5.99069782e-02f, -1.66650459e-01f, -1.39288470e-01f, -3.36570963e-02f, -1.14428885e-02f,
  8.19036067e-02f, 1.39600918e-01f, -9.48768258e-02f, 8.43968615e-03f, -1.79608427e-02f, 1.14084266e-01f, 8.38919505e-02f, 4.71141189e-02f, -4.93011735e-02f, 4.07269821e-02f,
  -4.10888903e-03f, -1.08351216e-01f, -1.47596881e-01f, 6.67633489e-02f, -4.97167930e-02f, -1.01003431e-01f, 9.52618290e-03f, -6.90177307e-02f, -2.02694461e-01f, 4.34784172e-03f,
  -1.89493239e-01f, -4.19054180e-02f, -7.95574412e-02f, -1.40972167e-01f, -9.72757041e-02f, -1.96322352e-01f, -3.82978544e-02f, -1.81013465e-01f, 7.23163970e-03f, 2.48112828e-02f,
  -8.76508877e-02f, -2.89495885e-01f, -2.13328470e-02f, -1.60851538e-01f, -4.79166433e-02f, -8.34263712e-02f, -2.57164478e-01f, -9.52484682e-02f, 1.07002547e-02f, 9.76854116e-02f,
  -7.51627311e-02f, -1.16411999e-01f, -1.57324791e-01f, 3.04451417e-02f, 2.02019826e-01f, 1.14154316e-01f, -1.55980274e-01f, -8.76214064e-04f, -1.01125941e-01f, -7.23493919e-02f,
  2.01929379e-02f, 1.76849648e-01f, 1.07166506e-01f, 1.23960219e-01f, 7.85956066e-03f, 2.70466268e-01f, 1.59925431e-01f, 1.90123424e-01f, 2.40046725e-01f, 3.28428537e-01f,
  -3.50980550e-01f, 4.03966866e-02f, -1.21801384e-01f, -2.04836041e-01f, -1.43141419e-01f, -9.84846801e-02f, -2.05935203e-02f, -1.11701051e-02f, 3.45714390e-02f, 8.16705674e-02f,
  3.21682155e-01f, 3.01480114e-01f, 3.37853193e-01f, 2.58089960e-01f, 1.94796413e-01f, -7.24174455e-02f, -2.78415024e-01f, -1.00535743e-01f, -1.16653949e-01f, -3.90001610e-02f,
  -2.97677033e-02f, -3.17884713e-01f, -2.32877150e-01f, -4.11710329e-02f, 1.13723047e-01f, 2.70326436e-01f, 2.43476942e-01f, 3.38433981e-02f, 2.68802553e-01f, 4.36553583e-02f,
  5.10271966e-01f, -8.18607882e-02f, 1.35848060e-01f, 5.67832738e-02f, -4.75277863e-02f, -4.90239151e-02f, 1.66811759e-03f, -7.27231652e-02f, -9.25352573e-02f, 7.84446150e-02f,
  -3.64486799e-02f, -1.20719895e-01f, -6.83848485e-02f, 3.46401371e-02f, -6.08112477e-02f, 4.15354148e-02f, 2.14519911e-02f, 3.39552537e-02f, 1.67704653e-02f, 9.36881080e-02f,
  -8.49732682e-02f, 8.55958685e-02f, 1.87047616e-01f, 1.74013868e-01f, 9.60547030e-02f, 8.98885205e-02f, 2.07573637e-01f, 1.34120688e-01f, 2.61715293e-01f, 3.18783909e-01f,
  1.89285100e-04f, 2.36908197e-02f, -5.03984950e-02f, 6.51454031e-02f, 8.34993944e-02f, 6.77607059e-02f, 4.93476875e-02f, 1.20559342e-01f, 7.15250820e-02f, -6.50288686e-02f,
  5.79772852e-02f, -3.52700688e-02f, 1.31609794e-02f, -4.71044518e-02f, -1.71543360e-02f, -7.36957267e-02f, -7.56603256e-02f, -3.49017866e-02f, 2.00554095e-02f, 7.21834749e-02f,
  4.43630703e-02f, -4.91650701e-02f, -1.90518975e-01f, -1.46007881e-01f, -8.68895501e-02f, 2.03292910e-02f, 6.39681146e-03f, -3.10838092e-02f, -1.06243618e-01f, -1.91159710e-01f,
  4.58797425e-01f, -5.76365143e-02f, 2.20332909e-02f, -2.08954196e-02f, 3.61418873e-02f, -7.19665587e-02f, -3.66855301e-02f, 8.74364981e-04f, -5.24964146e-02f, 1.18204936e-01f,
  3.97684313e-02f, -1.46911800e-01f, -6.47452995e-02f, -3.67431343e-02f, 1.15231704e-02f, 3.44913616e-03f, 7.95079302e-03f, -3.00805620e-03f, -2.24063434e-02f, -8.64070132e-02f,
  -5.94800785e-02f, 1.25857532e-01f, 2.77005315e-01f, 1.98022172e-01f, -2.96901651e-02f, 4.24800776e-02f, 5.40286265e-02f, 2.10921541e-02f, 1.74148947e-01f, 2.00242937e-01f,
  3.28308970e-01f, 3.50263506e-01f, 2.08402738e-01f, 2.66165227e-01f, 3.92762601e-01f, 4.07402664e-01f, 4.75364000e-01f, 3.24772090e-01f, 1.82545543e-01f, 1.71520904e-01f,
  3.95939916e-01f, 2.75006384e-01f, 1.90862149e-01f, 1.12678379e-01f, 2.61474371e-01f, 1.77493095e-01f, -2.11069565e-02f, 2.50558928e-02f, 1.14615642e-01f, 1.50753319e-01f,
  7.73525285e-03f, 4.70721945e-02f, 9.65432972e-02f, 4.53522950e-02f, -7.66301304e-02f, -2.28495076e-02f, 1.61579028e-01f, 2.15271533e-01f, 1.84761047e-01f, -2.14411855e-01f,
  6.49716407e-02f, 1.94923609e-01f, -6.67544976e-02f, -9.90359262e-02f, -6.14519976e-02f, -1.53002590e-01f, -2.82858238e-02f, -2.12097228e-01f, -1.85074553e-01f, -1.48042738e-01f,
  -7.53373057e-02f, -1.11388676e-01f, 2.46813204e-02f, -1.44829720e-01f, -1.32859722e-01f, -7.50478283e-02f, -1.11191422e-01f, -1.89466495e-02f, 1.39249101e-01f, 5.54682240e-02f,
  -2.38029044e-02f, 6.73773214e-02f, 1.11823581e-01f, 7.87488744e-02f, 1.08932838e-01f, 5.32847233e-02f, 5.07024936e-02f, 1.15152700e-02f, 7.91506842e-02f, -1.04243644e-01f,
  8.45079422e-02f, 1.14246115e-01f, 1.19311512e-01f, 1.58161130e-02f, 1.93023719e-02f, -3.15515068e-03f, -6.35157153e-02f, -3.88465226e-02f, -3.92703991e-03f, -5.03888056e-02f,
  2.76890956e-02f, 9.26613510e-02f, 5.96791655e-02f, 9.48795453e-02f, -5.73177524e-02f, 4.92937770e-03f, -1.42782584e-01f, -1.93299688e-02f, -4.86511774e-02f, -1.76834483e-02f,
  -2.24440861e-02f, -4.78071161e-02f, -1.79086745e-01f, -1.31931826e-01f, -7.16083869e-02f, -4.34483849e-02f, -8.13584626e-02f, 2.58736759e-02f, -5.42023145e-02f, 1.43684598e-03f,
  -1.40967712e-01f, 3.85597259e-01f, -8.79750680e-03f, -7.46604130e-02f, -6.92506880e-02f, -1.75162911e-01f, 6.05654391e-03f, 1.90714840e-02f, -2.03667983e-01f, -8.92473683e-02f,
  -1.00949526e-01f, -1.60273090e-01f, 3.64483078e-03f, -1.78738534e-02f, -9.37933773e-02f, -1.44898742e-01f, 7.26955570e-03f, 2.65268348e-02f, 4.46937308e-02f, -1.57816321e-01f,
  -1.09815203e-01f, -7.56673664e-02f, 8.28525871e-02f, -2.17044223e-02f, 1.11247683e-02f, -3.39879729e-02f, -1.23580508e-01f, -7.56168664e-02f, 6.97054267e-02f, -7.43818879e-02f,
  -2.21183121e-01f, -5.02340635e-03f, -3.94180678e-02f, 8.00115839e-02f, 2.71502525e-01f, 3.59535307e-01f, 4.51801211e-01f, 2.49286041e-01f, 4.17134427e-02f, 7.77958706e-02f,
  -4.60547432e-02f, -6.94070607e-02f, -3.35658342e-02f, 7.03903148e-03f, 2.06570569e-02f, 2.20572606e-01f, 1.53305605e-01f, -6.49133325e-02f, -1.10108003e-01f, 7.16249496e-02f,
  8.96819681e-02f, -1.55785203e-01f, -3.51801842e-01f, -5.85910752e-02f, 9.65445787e-02f, -1.33382514e-01f, -6.27629273e-03f, 6.44801417e-03f, 2.30274722e-03f, -5.82533218e-02f,
  -2.73564309e-01f, 4.61098514e-02f, 8.55054632e-02f, -6.32185861e-02f, -5.37870452e-02f, -1.43610582e-01f, -1.22395061e-01f, -1.66707933e-01f, -5.68117015e-02f, -4.94666910e-03f,
  -3.68533880e-02f, -6.59776405e-02f, 7.33526051e-02f, -3.82492095e-02f, -6.12598211e-02f, 1.69515628e-02f, 5.90925552e-02f, 7.69697130e-02f, -1.00629799e-01f, -1.21990461e-02f,
  1.28255442e-01f, 5.71011705e-03f, 7.19387978e-02f, 1.37458593e-01f, 2.23856047e-01f, 2.44821254e-02f, 7.15698600e-02f, 3.84230651e-02f, -5.00819385e-02f, 1.97595134e-02f,
  8.01702030e-03f, 8.00140202e-02f, 4.09128964e-02f, 6.11860715e-02f, -2.48326901e-02f, -7.45113716e-02f, 5.20536341e-02f, 1.37286097e-01f, 4.26101051e-02f, 9.90313143e-02f,
  -3.22051123e-02f, -2.66200956e-02f, -3.51777710e-02f, 4.36223447e-02f, -1.52691016e-02f, 4.30270322e-02f, 2.71226522e-02f, 3.55691090e-02f, -3.91558409e-02f, -4.03188094e-02f,
  -1.09767534e-01f, -8.77958164e-02f, -7.40297437e-02f, 5.78065552e-02f, 8.55000988e-02f, 9.96437743e-02f, 8.79012886e-03f, 4.99478430e-02f, 1.62709299e-02f, -1.08713377e-02f,
  -3.95463407e-01f, -9.86507814e-03f, 2.30922978e-02f, -6.89518377e-02f, -1.12472244e-01f, -1.74116030e-01f, -1.65093333e-01f, -1.11937560e-01f, 1.85573883e-02f, -5.53749613e-02f,
  -1.45516843e-01f, -1.33890845e-02f, -4.64230478e-02f, 6.42957911e-02f, -7.30846170e-03f, -6.20379858e-02f, 4.37394308e-04f, 2.13476755e-02f, -4.70062755e-02f, -7.36592785e-02f,
  -3.98360789e-02f, -6.42900616e-02f, -9.83995721e-02f, 9.60204378e-02f, 3.24775279e-03f, -3.19989100e-02f, -1.00693777e-01f, -1.02140181e-01f, 3.97273712e-02f, -1.28337741e-01f,
  6.28204882e-01f, -3.29590827e-01f, -4.89600152e-01f, 1.48933038e-01f, -2.46107325e-01f, -2.79068828e-01f, -5.32557845e-01f, -4.75533828e-02f, 1.96631223e-01f, -4.62810427e-01f,
  -3.03895563e-01f, 7.72597268e-02f, -7.77747622e-03f, -1.84527963e-01f, 2.95541361e-02f, -4.80091333e-01f, -3.40719104e-01f, -9.08168331e-02f, 1.39224291e-01f, 8.89286585e-03f,
  8.04580450e-02f, 3.07051074e-02f, 2.58324742e-01f, 1.29068092e-01f, -7.81189129e-02f, 4.96086068e-02f, -4.11313206e-01f, -1.83676913e-01f, -1.73873872e-01f, -3.92757773e-01f,
  -3.97578984e-01f, 9.08536986e-02f, -7.05035478e-02f, 7.06022158e-02f, -6.89129531e-02f, 3.38211879e-02f, -8.36331844e-02f, 3.01518571e-02f, 4.42570634e-02f, -1.08706936e-01f,
  -1.59990303e-02f, 1.64880566e-02f, 2.15530440e-01f, -1.64215975e-02f, 1.19205099e-02f, 3.84260081e-02f, -2.17550434e-02f, -1.06267286e-02f, 3.34247239e-02f, -2.79193069e-03f,
  -7.05822110e-02f, -8.31314102e-02f, -9.66116562e-02f, -1.30622447e-01f, 2.54452750e-02f, -5.81049314e-03f, -1.10089421e-01f, -1.22248814e-01f, -1.85558081e-01f, -1.75507054e-01f,
  -8.64690691e-02f, -1.02057323e-01f, -5.51284999e-02f, 5.53766787e-02f, 5.74096441e-02f, -4.34052460e-02f, 2.42072367e-03f, -2.00262349e-02f, -6.40665367e-02f, 2.93926205e-02f,
  -4.08701189e-02f, -7.07918033e-02f, 3.36230062e-02f, -1.43467644e-02f, -1.20850995e-01f, 1.34581449e-02f, 7.86449164e-02f, 2.55597793e-02f, 1.04156686e-02f, 1.07462108e-02f,
  -6.65306300e-02f, -1.57699175e-02f, -1.29481144e-02f, 1.47407874e-01f, -7.15835690e-02f, -1.04903534e-01f, 3.99376564e-02f, -6.64320439e-02f, 1.02882884e-01f, -3.49152349e-02f,
  2.14915738e-01f, -1.76960036e-01f, -1.24470465e-01f, 1.49107561e-01f, 6.25692233e-02f, -1.13030765e-02f, -4.61099967e-02f, 5.69114685e-02f, 1.46004617e-01f, 1.43233277e-02f,
  1.37760499e-02f, -1.30944829e-02f, -4.62727388e-03f, -1.32396191e-01f, -1.00266054e-01f, -1.49841299e-02f, -1.10926025e-01f, -2.95329448e-02f, 4.12263349e-03f, 6.48223087e-02f,
  2.32238211e-02f, -2.03549527e-02f, 6.09115288e-02f, -5.92877083e-02f, 9.94571596e-02f, 7.03807548e-02f, -7.04672635e-02f, 1.72681231e-02f, 1.45459756e-01f, 4.20446433e-02f,
  -8.79594147e-01f, -2.94798344e-01f, 9.11097974e-02f, -7.04091668e-01f, -9.07266438e-02f, 1.30503848e-01f, 7.18725100e-02f, -2.60986965e-02f, -2.08322540e-01f, -3.06578666e-01f,
  -1.22188896e-01f, -1.86166212e-01f, -2.73992985e-01f, 1.64198756e-01f, 2.99779465e-03f, -1.61313966e-01f, -9.69486758e-02f, 1.17056042e-01f, 2.54126877e-01f, 4.33628649e-01f,
  1.51115164e-01f, -2.11824253e-01f, -6.77065849e-02f, 1.10100359e-01f, -2.92999834e-01f, -7.67928064e-02f, -1.37565836e-01f, -8.76581147e-02f, 1.62141114e-01f, -3.95896316e-01f,
  -1.49881065e-01f, -5.21074831e-02f, 9.64375883e-02f, -1.25447251e-02f, -1.13233440e-01f, 3.36392112e-02f, -9.57208425e-02f, -3.23771313e-02f, 9.86128524e-02f, -9.02339537e-03f,
  -1.75373405e-01f, 1.70876145e-01f, -1.62571654e-01f, -7.49439225e-02f, -6.52424693e-02f, 4.57007438e-02f, -1.99495330e-02f, 9.01691541e-02f, -5.33094816e-02f, 6.11987412e-02f,
  5.11237569e-02f, 9.01569575e-02f, 2.61523277e-02f, 1.81996241e-01f, 1.95626631e-01f, 2.46263370e-02f, 5.62798046e-02f, 2.68516302e-01f, 2.60527223e-01f, -1.88137621e-01f,
  -1.49391200e-02f, -2.71500275e-02f, -5.31891994e-02f, 1.07737869e-01f, 9.66014341e-03f, -3.09167914e-02f, -1.38393804e-01f, -1.51245013e-01f, 2.25944016e-02f, -1.23559460e-01f,
  1.46312872e-02f, -1.47575065e-02f, 3.07216421e-02f, -1.17248975e-01f, -6.65666983e-02f, 2.01779343e-02f, 1.32650528e-02f, 1.44918944e-04f, -5.72241209e-02f, 1.01669291e-02f,
  1.94625910e-02f, 7.22015202e-02f, -2.91941185e-02f, 1.32636011e-01f, 9.70353261e-02f, -3.47551964e-02f, 1.11479975e-01f, 2.90336646e-02f, 1.35859316e-02f, 1.61675349e-01f,
  -4.03363228e-01f, 1.12729020e-01f, -2.73939818e-01f, 1.24085024e-01f, -2.19281480e-01f, 7.54263327e-02f, -1.84210822e-01f, 2.09403820e-02f, -6.58534616e-02f, 6.84716552e-02f,
  2.44374961e-01f, -5.68386428e-02f, -1.66437432e-01f, 1.22520991e-01f, -9.21599418e-02f, -5.58718815e-02f, 1.94637931e-03f, -1.36375263e-01f, 9.81520936e-02f, 1.52164679e-02f,
  8.28405097e-02f, 3.34148221e-02f, -1.38211906e-01f, 1.82305072e-02f, 5.48048019e-02f, -2.43617651e-05f, 1.17638074e-02f, 3.49733829e-02f, 9.95611623e-02f, -2.15089738e-01f,
  -2.94523835e-01f, -7.84857720e-02f, -7.10512772e-02f, 1.12087712e-01f, 1.65518165e-01f, -9.60545242e-02f, -4.26785827e-01f, -2.62419254e-01f, 1.96946226e-02f, 8.84205941e-03f,
  -7.18623400e-03f, 1.76575050e-01f, 2.19093144e-01f, 3.74385044e-02f, -2.99598157e-01f, -9.08744559e-02f, 3.13483924e-01f, -4.83318456e-02f, -1.42646983e-01f, -2.85409153e-01f,
  1.84711054e-01f, 1.11487754e-01f, 6.64467663e-02f, -9.93458927e-02f, 1.69630900e-01f, 1.11654773e-01f, 2.75102764e-01f, 1.18109308e-01f, -1.77648775e-02f, 3.64562571e-01f,
  1.03117071e-01f, -1.11396201e-01f, -7.61338770e-02f, 1.78536549e-01f, -2.26420574e-02f, -3.09632979e-02f, -8.90769437e-02f, 8.74737464e-03f, 1.37312964e-01f, 3.73044163e-02f,
  9.73393768e-02f, 1.90684646e-02f, 1.77937612e-01f, 8.98377299e-02f, -4.55342568e-02f, -1.13025658e-01f, -1.13479316e-01f, -1.43599689e-01f, -8.59286115e-02f, -1.77812845e-01f,
  2.90445775e-01f, 9.23723653e-02f, -2.46052489e-01f, -2.26198599e-01f, -1.21761754e-01f, -1.55687276e-02f, -1.97460979e-01f, -2.72136390e-01f, -2.52369851e-01f, -1.56915888e-01f,
  -7.31790587e-02f, -1.59119532e-01f, -4.23428640e-02f, -1.89328983e-01f, -5.90565614e-02f, 5.36381118e-02f, 5.41070327e-02f, -1.13464095e-01f, -9.25586447e-02f, -4.31324057e-02f,
  9.88537520e-02f, 6.58841953e-02f, 7.07220435e-02f, 2.50890404e-02f, 8.68910328e-02f, 1.38298929e-01f, -1.87182128e-02f, -1.10182576e-02f, 2.72872415e-03f, 4.10866849e-02f,
  6.90690055e-02f, 1.19252086e-01f, 8.86713862e-02f, -4.67036739e-02f, -2.04418469e-02f, -1.44265100e-01f, -2.15774979e-02f, -1.03610985e-01f, -6.49348944e-02f, 5.78424931e-02f,
  2.11126432e-01f, 2.46155441e-01f, -1.98959094e-02f, -1.41874224e-01f, 2.10603923e-02f, 9.00580883e-02f, -6.29559625e-03f, -4.33762856e-02f, 4.94184494e-02f, -2.75526550e-02f,
  -1.67942882e-01f, -1.44091276e-02f, 1.15819156e-01f, -1.57097261e-02f, -5.22874445e-02f, 8.17738771e-02f, -8.82513970e-02f, -2.70083137e-02f, -1.41180560e-01f, 7.46551156e-02f,
  4.67408523e-02f, -1.38596639e-01f, -2.12039798e-01f, -4.14835252e-02f, 1.68926958e-02f, -1.19726405e-01f, -9.20491964e-02f, -2.19313070e-01f, -2.58922845e-01f, -3.08704495e-01f,
  -8.11058402e-01f, -2.94097841e-01f, 1.88726634e-01f, -7.56346509e-02f, 2.63097703e-01f, 7.73246214e-02f, -2.28641570e-01f, -2.31711939e-01f, 1.00910239e-01f, -1.41556626e-02f,
  -1.73415184e-01f, 2.85921767e-02f, 2.70371675e-01f, 2.10498020e-01f, 3.48149389e-02f, 2.52643049e-01f, 5.00259161e-01f, 2.38627300e-01f, -2.37873513e-02f, -3.00664097e-01f,
  1.50618985e-01f, 1.51103571e-01f, -6.16670288e-02f, 4.58953492e-02f, -5.07541075e-02f, 6.26637414e-02f, 2.26686969e-01f, 1.05619460e-01f, 1.84524059e-02f, 3.59549671e-02f,
  -2.10335627e-01f, -3.98061037e-01f, 1.61567464e-01f, -1.16793469e-01f, -5.32578416e-02f, -4.85284962e-02f, -1.02310933e-01f, -1.38473716e-02f, -6.64660782e-02f, -7.41178542e-02f,
  -9.67349783e-02f, -1.97094887e-01f, 6.91518635e-02f, -3.90621764e-03f, -2.11469576e-01f, -2.22672835e-01f, 1.20552117e-02f, -2.26302683e-01f, -2.75175404e-02f, -2.32575402e-01f,
  1.74134627e-01f, 5.79607300e-02f, -9.03415680e-02f, 1.48787163e-03f, -1.01134010e-01f, 6.47657141e-02f, -1.80360526e-01f, -3.44045043e-01f, -1.62874088e-01f, -3.19300622e-01f,
  5.87363653e-02f, -5.78236878e-02f, 4.51935455e-02f, 4.83822189e-02f, -4.04230990e-02f, 2.95956824e-02f, 2.15580799e-02f, 2.82564363e-03f, 6.96839765e-02f, -2.35451870e-02f,
  4.39749286e-02f, -6.35797232e-02f, 3.62159275e-02f, 3.19377966e-02f, 2.42169239e-02f, -6.98409304e-02f, 3.47006172e-02f, 2.23753631e-01f, 8.32401142e-02f, -7.87100941e-02f,
  -8.91077518e-03f, 4.59564961e-02f, 1.48402303e-01f, -6.81386963e-02f, 7.05156773e-02f, -7.21422490e-03f, -3.24524357e-03f, -2.71316543e-02f, 5.83672188e-02f, -5.10599744e-03f,
  2.17866059e-02f, 5.32858610e-01f, -1.61499470e-01f, -1.12094814e-02f, -2.12213770e-03f, 2.72332504e-02f, -2.17915904e-02f, 1.66136920e-02f, -1.50404006e-01f, -2.61131704e-01f,
  -7.81281143e-02f, -1.52118713e-01f, 5.49026318e-02f, -1.13807365e-01f, -1.44879133e-01f, -1.04882471e-01f, -8.16529989e-02f, 4.55593467e-02f, 1.95079848e-01f, -7.80516267e-02f,
  4.90025394e-02f, -2.75847595e-02f, -1.47962719e-01f, -6.67529181e-02f, 1.28771430e-02f, -1.15809023e-01f, -3.47744599e-02f, -8.86900648e-02f, 7.33328462e-02f, -1.76272884e-01f,
  1.58862323e-01f, 3.83981884e-01f, 8.82086530e-02f, -1.44604251e-01f, 2.39191964e-01f, 4.30122279e-02f, 3.32805067e-01f, -4.22902580e-04f, -1.95870131e-01f, 1.64917320e-01f,
  1.32463723e-01f, -1.93895310e-01f, -8.11357349e-02f, -1.16262317e-01f, -1.37869388e-01f, 4.68269456e-03f, 4.52629849e-02f, -1.19560584e-01f, -3.95314544e-01f, -3.14907700e-01f,
  -3.57240401e-02f, -1.36587232e-01f, -2.47233942e-01f, -2.99129307e-01f, 1.23208878e-03f, -1.15247510e-01f, -9.55283456e-03f, 1.32735014e-01f, 2.32932732e-01f, 2.57126898e-01f,
  5.62745593e-02f, 2.12838277e-01f, -2.82531440e-01f, 3.07088774e-02f, -3.10232770e-02f, -1.40601108e-02f, -1.19795971e-01f, -8.54467526e-02f, -6.00573607e-02f, -1.28963161e-02f,
  1.87991142e-01f, 1.85080454e-01f, 2.86359955e-02f, -1.39837682e-01f, 3.89531888e-02f, -1.06304906e-01f, 3.34313363e-02f, -9.68628526e-02f, -1.67134196e-01f, 3.98118123e-02f,
  1.33723184e-01f, 2.60229677e-01f, 6.67385384e-02f, -2.08306573e-02f, -5.88276330e-03f, 1.76227223e-02f, 1.18112370e-01f, 6.42927587e-02f, -9.57773242e-04f, 1.32690713e-01f,
  -1.81794435e-01f, 4.48287725e-02f, 6.18656874e-02f, -3.02652195e-02f, 2.41706353e-02f, 4.02558371e-02f, -4.20126691e-02f, 1.31427469e-02f, -1.42825231e-01f, -6.71886951e-02f,
  -4.64735366e-02f, -7.60857388e-02f, -3.33014242e-02f, -1.58447832e-01f, -2.52177417e-01f, 7.49371573e-02f, 1.32966973e-02f, -5.26536666e-02f, -3.27692777e-02f, 4.25364934e-02f,
  -4.41368818e-02f, 4.87190336e-02f, 1.03483507e-02f, 4.63236943e-02f, -7.80370086e-02f, -1.46245822e-01f, 2.11994555e-02f, 1.21696413e-01f, -5.10780513e-02f, 8.00636932e-02f,
  -3.41075659e-01f, -5.46748824e-02f, -1.10163897e-01f, -1.95121318e-02f, 1.04815006e-01f, 1.09466217e-01f, 1.33703947e-01f, -1.78188346e-02f, 4.12926972e-02f, 4.80894670e-02f,
  6.97642788e-02f, -1.84666812e-02f, -1.70416813e-02f, -1.54154077e-01f, -1.67104051e-01f, -1.53034395e-02f, 4.20996025e-02f, -5.53766415e-02f, -3.69098149e-02f, 1.18504213e-02f,
  4.06969562e-02f, -9.31143202e-03f, -2.09685773e-01f, -1.30273879e-01f, -8.77611637e-02f, -2.30366290e-01f, -5.26710562e-02f, -1.82435676e-01f, -7.84087405e-02f, -2.69744456e-01f,
  -6.22020483e-01f, -1.29839644e-01f, 1.30823851e-02f, 9.21355784e-02f, 2.66476572e-01f, 5.68335243e-02f, -8.43975469e-02f, -1.22647651e-01f, 1.02560692e-01f, -1.01130232e-01f,
  2.99550802e-01f, 2.31618732e-01f, 5.53534627e-02f, -4.73298766e-02f, -2.73658097e-01f, -2.85314411e-01f, -1.10302001e-01f, -1.26510873e-01f, 1.35118216e-01f, 1.31181598e-01f,
  3.25139642e-01f, -3.56260017e-02f, -1.96546093e-01f, 8.26751441e-02f, -1.13646418e-01f, 1.83207959e-01f, -1.12396635e-01f, -1.63353011e-01f, 7.68651813e-02f, -2.25506738e-01f,
  -3.20038013e-02f, -2.86534965e-01f, 1.11509161e-02f, 1.87110171e-01f, 1.16102494e-01f, -2.10555598e-01f, -1.97575539e-01f, -1.35057434e-01f, 2.23950073e-02f, -7.54817724e-02f,
  1.18461721e-01f, -1.38138803e-02f, 4.65782955e-02f, 1.75424963e-01f, -8.57331976e-02f, -2.30903402e-02f, -4.77738045e-02f, -1.18843086e-01f, -2.16757834e-01f, 3.92285176e-02f,
  1.93131551e-01f, 2.59480804e-01f, -1.54911309e-01f, -2.63703346e-01f, -1.11277938e-01f, 8.44180807e-02f, -4.49084751e-02f, -1.64272472e-01f, -3.24653983e-01f, -4.61714566e-01f,
  2.80501936e-02f, -7.33704958e-03f, -1.25906661e-01f, -8.58527794e-02f, 1.38559237e-01f, -8.79615769e-02f, 2.72321682e-02f, 1.44033998e-01f, 6.08885996e-02f, -1.09500624e-01f,
  4.47371602e-02f, 6.70583099e-02f, 5.00074252e-02f, -2.40738586e-01f, -9.44353342e-02f, -5.37385605e-02f, -4.51776832e-02f, -1.93673238e-01f, -1.28721237e-01f, 7.26702586e-02f,
  7.02172378e-03f, 2.85582375e-02f, 8.65412503e-03f, 8.56374353e-02f, -1.62607417e-01f, 4.82537039e-02f, -5.42457812e-02f, -1.19142249e-01f, -2.55297814e-02f, -5.89236543e-02f,
  -5.25368303e-02f, -6.89611584e-02f, -1.35672241e-01f, 7.84238949e-02f, 8.85059014e-02f, -1.29422108e-02f, 1.34864867e-01f, 1.13869414e-01f, 1.81469083e-01f, -1.26980981e-02f,
  -1.62461717e-02f, -1.22322343e-01f, -1.87094674e-01f, 1.40379015e-02f, 1.11644901e-01f, -8.05801302e-02f, -2.24226385e-01f, 1.32376393e-02f, 6.91648498e-02f, -4.57378384e-03f,
  -1.07315384e-01f, -1.33984223e-01f, -9.37637314e-02f, -1.81841686e-01f, -2.40903050e-01f, -1.39629662e-01f, -3.26384097e-01f, -2.29642823e-01f, -4.18349266e-01f, -5.92310548e-01f,
  9.56308767e-02f, -2.78751813e-02f, -2.99441338e-01f, -4.57464810e-03f, -2.62373269e-01f, -2.10679755e-01f, -2.08955631e-01f, 2.03247085e-01f, 1.63057938e-01f, -2.42902011e-01f,
  -1.24104537e-01f, 3.07172127e-02f, 2.44569685e-02f, 1.64257223e-03f, 1.63571071e-02f, -2.81383604e-01f, -3.64643753e-01f, -9.15719792e-02f, 1.04182541e-01f, 1.97827090e-02f,
  -5.37148938e-02f, -4.14738990e-02f, 8.34730119e-02f, 5.23326211e-02f, -1.60437763e-01f, -1.42806008e-01f, -2.05121458e-01f, -1.70133486e-01f, -2.26438522e-01f, -4.53175545e-01f,
  -3.68314922e-01f, 3.90881374e-02f, -5.81363663e-02f, -2.14611888e-02f, -2.37706155e-01f, -3.21420096e-02f, 2.69493293e-02f, -2.80029643e-02f, -2.67797783e-02f, 9.15004313e-02f,
  7.17218593e-02f, 8.39620978e-02f, 2.99513228e-02f, -1.84441227e-02f, -9.27255899e-02f, 2.65367492e-03f, 7.33102933e-02f, -5.36471717e-02f, 7.15476200e-02f, 5.93545511e-02f,
  -2.15537380e-02f, -6.68704929e-03f, -8.20158944e-02f, -4.85274568e-02f, 3.38391140e-02f, -6.92333728e-02f, -6.41423687e-02f, 4.04911004e-02f, -8.08829665e-02f, -1.26224622e-01f,
  8.39136466e-02f, 3.39033548e-03f, -1.20893982e-03f, 4.96104127e-03f, -4.78806794e-02f, 1.11496840e-02f, -7.29912072e-02f, -3.38570774e-02f, 1.92896649e-02f, -8.28926936e-02f,
  -2.63850321e-04f, -8.14777017e-02f, 1.54013736e-02f, 3.86198163e-02f, 6.91634417e-02f, 7.56656006e-02f, -2.42776144e-03f, -1.14502534e-01f, 4.24959995e-02f, 2.78597176e-02f,
  -1.07285455e-01f, 8.21134001e-02f, 2.06831452e-02f, 3.18262577e-02f, -3.75632197e-02f, 5.43060340e-02f, 7.53935948e-02f, 4.44491319e-02f, 4.52402234e-03f, 8.33924115e-02f,
  1.68526664e-01f, -1.27877429e-01f, -8.09145942e-02f, 1.22263515e-02f, 7.01374561e-02f, -2.42265407e-02f, 8.24422985e-02f, -2.32302248e-02f, 1.71207190e-02f, 5.62849548e-03f,
  -3.46557312e-02f, 5.57377636e-02f, -2.18364540e-02f, -7.70580024e-02f, -7.72694126e-02f, 1.64866373e-01f, 1.21479258e-01f, 7.12152421e-02f, -1.71734374e-02f, 9.78194643e-04f,
  9.08913910e-02f, 5.41160963e-02f, 5.22630215e-02f, 3.52128930e-02f, -4.43913080e-02f, -6.01016684e-03f, 3.00922524e-02f, 3.90638746e-02f, -3.21987830e-02f, 4.51689139e-02f,
  1.60356298e-01f, -2.91374564e-01f, 4.99934614e-01f, 2.61300325e-01f, 7.38811716e-02f, 2.41859660e-01f, 2.26198256e-01f, 3.04139405e-01f, 6.46126494e-02f, -1.94614455e-02f,
  -4.69170988e-01f, -3.71729851e-01f, -3.40299338e-01f, -2.37486988e-01f, -6.44438490e-02f, 2.49047086e-01f, 3.22681814e-01f, 3.45356733e-01f, 2.74933040e-01f, 1.29505500e-01f,
  6.07336760e-02f, 1.56221285e-01f, 8.24070498e-02f, -1.31517695e-02f, 7.21263587e-02f, -9.62458104e-02f, 1.09290294e-01f, -9.69901010e-02f, -2.18678549e-01f, 2.29483366e-01f,
  -2.11973786e-01f, -3.20539735e-02f, 1.54334921e-02f, -3.09677422e-01f, -2.12802395e-01f, -2.50322390e-02f, -1.96897816e-02f, -7.38263130e-02f, -2.19832972e-01f, 5.72819598e-02f,
  -2.64592081e-01f, -1.74000308e-01f, 1.06910728e-02f, -1.32173821e-01f, 9.79919136e-02f, 4.53670025e-02f, 5.46693318e-02f, -8.07489753e-02f, -2.33266037e-02f, -7.36896768e-02f,
  -1.43654659e-01f, 2.63107475e-02f, -4.33369391e-02f, 1.09930418e-01f, -8.83091614e-02f, 3.73403765e-02f, -8.22960287e-02f, 1.76070929e-02f, -8.66566449e-02f, 7.06383809e-02f,
  -8.75871405e-02f, -2.25865036e-01f, -2.55315416e-02f, 1.02050342e-01f, 3.61279286e-02f, -6.41062930e-02f, 1.41340643e-01f, 2.12168209e-02f, 1.21240042e-01f, 4.73736562e-02f,
  5.43313473e-02f, 4.29316834e-02f, 7.55014643e-02f, 1.92935504e-02f, 9.35291424e-02f, 5.16039543e-02f, 9.52434465e-02f, 2.11366378e-02f, 1.10299140e-02f, 1.31295338e-01f,
  1.47612453e-01f, 3.10292412e-02f, 1.24567814e-01f, 7.46811554e-02f, -4.65962216e-02f, 1.17268443e-01f, 1.91288367e-01f, -2.49929503e-02f, 1.38601456e-02f, 6.05816804e-02f,
  5.07626534e-02f, -1.44971624e-01f, -5.13980761e-02f, 5.40980808e-02f, 4.83166985e-02f, -1.38709486e-01f, -7.55660310e-02f, -9.56942886e-02f, -8.68285447e-02f, 5.92822582e-02f,
  6.31964281e-02f, -2.76939813e-02f, -3.14478502e-02f, 1.96606159e-01f, 1.41704425e-01f, 8.12018812e-02f, -2.11380854e-01f, 8.02615937e-03f, -7.20504969e-02f, 2.03447491e-02f,
  6.40673237e-03f, 1.14423312e-01f, 6.94853961e-02f, 1.31979644e-01f, 4.46167216e-02f, 1.04509935e-01f, 6.78974986e-02f, -3.54681648e-02f, -1.92677435e-02f, 8.17086175e-02f,
  -9.41202104e-01f, 3.94501202e-02f, 3.09281439e-01f, -6.97757959e-01f, -1.60545841e-01f, -5.55722462e-03f, -6.93849027e-02f, -2.17277091e-02f, -3.72398376e-01f, 6.90743420e-03f,
  1.72448218e-01f, -4.77998033e-02f, 6.78869113e-02f, 5.62657118e-02f, 1.08966623e-02f, 6.34932294e-02f, -1.51926130e-01f, -6.94169253e-02f, 2.40024835e-01f, 2.22504318e-01f,
  4.31279186e-03f, -2.88365752e-01f, -1.29378766e-01f, 3.80041003e-02f, -2.32121855e-01f, 8.55269842e-03f, -1.98165402e-02f, -1.42043859e-01f, 9.81371254e-02f, -4.59881663e-01f,
  2.78643012e-01f, -3.55251014e-01f, -1.58157889e-02f, -2.03064054e-01f, 5.98966703e-02f, -8.07677358e-02f, 3.59966904e-02f, -1.86220203e-02f, -3.03144008e-02f, -6.58916077e-03f,
  -1.38466612e-01f, 3.11990851e-03f, -1.58168837e-01f, 2.71175690e-02f, -1.11984080e-02f, -6.68775365e-02f, -2.81228088e-02f, 6.24211654e-02f, 1.43647601e-04f, 2.36010149e-01f,
  -6.87083676e-02f, -2.04082191e-01f, -6.52876422e-02f, 4.38822024e-02f, 1.58531070e-01f, -5.46969026e-02f, 1.14698090e-01f, -2.74304748e-02f, 6.25845790e-02f, -3.57756130e-02f,
  3.81433144e-02f, -4.88674380e-02f, 4.87089194e-02f, -3.53841744e-02f, 1.59781501e-01f, -4.15777452e-02f, 3.26211862e-02f, -5.51958568e-02f, 7.76847526e-02f, 5.09555861e-02f,
  1.67577624e-01f, 8.70402381e-02f, 1.14082076e-01f, -7.99513385e-02f, -4.93331533e-03f, -2.75105964e-02f, -1.03484720e-01f, 1.38945967e-01f, -5.47526851e-02f, -1.48535416e-01f,
  -6.89050704e-02f, -1.57538548e-01f, -1.46779075e-01f, 7.63663054e-02f, -1.04200400e-01f, -3.15126479e-02f, -1.17984749e-01f, 6.61770776e-02f, -1.38435522e-02f, -1.58142656e-01f,
  1.81956172e-01f, 1.83548667e-02f, -4.55783345e-02f, 4.22604606e-02f, -1.55826271e-01f, 5.73344668e-03f, -1.33016542e-01f, 7.96971992e-02f, -7.87452757e-02f, -1.34329960e-01f,
  -6.37441427e-02f, -1.77957509e-02f, -4.43542004e-02f, 2.03518629e-01f, 2.14109182e-01f, 6.58986997e-03f, -5.39719500e-03f, -2.76620351e-02f, -8.01460743e-02f, -1.60804112e-02f,
  -1.84911378e-02f, -2.19930798e-01f, -1.61168396e-01f, 1.09693423e-01f, 8.24620500e-02f, -1.60693794e-01f, 1.98524877e-01f, -3.04054804e-02f, -8.47515836e-02f, 1.21103115e-01f,
  -3.63370836e-01f, 7.82800540e-02f, 4.24109221e-01f, -2.84423959e-02f, 3.35064173e-01f, 1.65427104e-01f, -1.08966157e-01f, -1.55110493e-01f, 8.81235451e-02f, 3.95544693e-02f,
  1.65311560e-01f, -1.62453502e-01f, -7.66026676e-02f, -1.86408266e-01f, -4.83522385e-01f, -1.72070235e-01f, -2.33955130e-01f, -2.80304253e-01f, -4.22893524e-01f, -3.59904230e-01f,
  -1.08047441e-01f, -2.91938782e-01f, -3.56011778e-01f, -3.07839781e-01f, -1.02491848e-01f, -4.77103814e-02f, 5.27702346e-02f, -4.86406498e-02f, -7.00056553e-02f, -1.38376340e-01f,
  5.18883765e-02f, 3.76697868e-01f, 1.87687755e-01f, -1.40768707e-01f, 1.78027958e-01f, 9.81109738e-02f, 7.42239580e-02f, 1.67879805e-01f, 1.96268246e-01f, 1.21221906e-02f,
  1.91518888e-01f, 1.94859076e-02f, 8.89732689e-02f, 2.96597276e-02f, 1.92132941e-03f, -4.71519344e-02f, 1.57384694e-01f, -7.16684088e-02f, -1.76008537e-01f, 5.16444966e-02f,
  -1.97394654e-01f, 9.60669219e-02f, -1.48636743e-01f, -1.96917579e-02f, 2.17984691e-02f, 1.33732378e-01f, 7.23635778e-02f, -1.03592321e-01f, 5.68729267e-03f, -2.50074923e-01f,
  5.26749110e-03f, 1.49948627e-01f, 1.54638246e-01f, -7.85864145e-02f, -1.87296867e-01f, 1.25775561e-02f, -1.32749602e-02f, -2.39927787e-02f, -3.26593742e-02f, -4.95134331e-02f,
  5.81426695e-02f, 3.31741348e-02f, -3.41586955e-02f, -5.55049852e-02f, 6.46233326e-03f, 9.22611356e-02f, -9.53065455e-02f, -6.85211718e-02f, 8.61297771e-02f, -7.84736723e-02f,
  -2.90986504e-02f, -7.38678649e-02f, -6.04012050e-02f, -1.11479975e-01f, -1.49178162e-01f, 1.95256174e-02f, 7.38209486e-02f, -4.09512408e-02f, 4.01751176e-02f, 1.04648367e-01f,
  -2.07769707e-01f, 1.85281217e-01f, 1.90751255e-02f, -1.67513698e-01f, 7.09357709e-02f, -5.06028645e-02f, 3.45888659e-02f, 1.30008116e-01f, 1.75388321e-01f, -1.16685726e-01f,
  -8.07207376e-02f, 5.54985516e-02f, -4.86031361e-02f, -9.69809368e-02f, -1.21825919e-01f, -1.66285396e-01f, -7.40485936e-02f, -1.15287475e-01f, -3.04216985e-02f, 4.35223617e-02f,
  -3.04017901e-01f, -3.03849757e-01f, -3.84965450e-01f, -2.34673411e-01f, -7.18647093e-02f, -2.66952783e-01f, -3.36562663e-01f, -2.93161690e-01f, -2.89228171e-01f, -4.55533862e-01f,
  8.39866042e-01f, -5.11960864e-01f, 7.49335289e-02f, 1.77674130e-01f, 1.17816329e-01f, 3.10166180e-01f, -9.84739959e-02f, -1.19257897e-01f, 1.45091176e-01f, -1.10219434e-01f,
  1.24189779e-02f, 1.65892780e-01f, 1.73936531e-01f, 1.29850283e-01f, 8.03375989e-02f, -5.67397624e-02f, -6.03890792e-02f, 1.99858680e-01f, 3.24157476e-01f, 2.20517352e-01f,
  -1.84138522e-01f, -9.78022143e-02f, -6.06380589e-02f, -9.17282179e-02f, -3.03690135e-01f, 9.45367813e-02f, -2.33591929e-01f, -1.01765640e-01f, -9.61397588e-02f, -3.85516912e-01f,
  4.57613245e-02f, -1.16551258e-01f, 1.18073141e-02f, -1.29371032e-01f, -8.30786973e-02f, -2.25953497e-02f, -2.43345536e-02f, -8.35413858e-02f, -8.30282867e-02f, -3.02341897e-02f,
  7.49745360e-03f, -1.08852997e-01f, -3.88665907e-02f, -7.79289529e-02f, -8.29677656e-02f, -7.56030306e-02f, -1.50385395e-01f, 6.12275451e-02f, 2.25514844e-02f, -1.21958964e-01f,
  -1.97659224e-01f, 3.39844376e-02f, 1.45006999e-01f, 1.31513476e-01f, 1.16443612e-01f, 1.66056916e-01f, -7.19492137e-02f, 3.47931087e-02f, 1.49508715e-01f, 2.34950688e-02f,
  7.55197108e-02f, 9.29468051e-02f, 9.75996852e-02f, 6.39182180e-02f, -7.48904124e-02f, 1.38059616e-01f, 1.23083554e-01f, 1.36036187e-01f, 8.27491507e-02f, -1.93241071e-02f,
  3.42823304e-02f, -1.59379914e-02f, -1.68513320e-02f, 3.15425405e-03f, -2.89456337e-03f, -2.76765693e-02f, -3.64883356e-02f, -1.05961733e-01f, -8.61568302e-02f, -8.85981023e-02f,
  -1.15479631e-02f, 1.34103810e-02f, -1.27186105e-01f, -1.16798781e-01f, -1.62530690e-01f, -3.99568642e-04f, 5.47170974e-02f, -1.47400543e-01f, -3.69656384e-02f, 6.89854324e-02f,
  -2.47717768e-01f, 1.40826747e-01f, 9.83381644e-02f, -1.01689003e-01f, 1.64842326e-02f, -6.20789267e-02f, 3.78609747e-02f, -7.20947832e-02f, -6.34447187e-02f, 5.91489337e-02f,
  -3.64850909e-02f, 8.03921893e-02f, -1.17220385e-02f, -6.74931630e-02f, 8.96802396e-02f, -1.40105849e-02f, -1.40215307e-01f, 1.55697733e-01f, -4.37909700e-02f, -1.22237094e-01f,
  -9.65452045e-02f, 1.31824180e-01f, 1.58541769e-01f, 2.24405169e-01f, 1.46644607e-01f, 2.67183691e-01f, -1.37632526e-02f, 2.93425079e-02f, 1.14696272e-01f, -1.00144677e-01f,
  4.98236686e-01f, 1.20571807e-01f, 6.64507091e-01f, 3.29489708e-01f, 1.51346084e-02f, 3.76513064e-01f, 4.78352219e-01f, 2.98292547e-01f, 1.06530786e-01f, 2.64565796e-02f,
  -1.78724125e-01f, -2.84815460e-01f, -2.33815312e-01f, -1.50836006e-01f, 2.08701029e-01f, 4.60157543e-01f, 4.23783958e-01f, 4.04083550e-01f, 2.85584837e-01f, 1.65199786e-01f,
  -1.86237134e-02f, 9.09549817e-02f, 1.23114541e-01f, 7.11359903e-02f, 1.38180956e-01f, -1.83582693e-01f, 2.34923914e-01f, 2.38389537e-01f, 1.66048929e-01f, 2.86354154e-01f,
  1.05443552e-01f, 2.40576819e-01f, -7.57562742e-02f, -2.07446888e-01f, -1.17988810e-01f, -8.50174867e-04f, 1.25938859e-02f, -1.41732870e-02f, -1.37704164e-01f, -1.33299261e-01f,
  -9.92056797e-04f, -8.49685967e-02f, -8.23146105e-02f, -1.51861414e-01f, 2.39498401e-03f, -1.22876681e-01f, -1.05995650e-03f, 4.26801182e-02f, 9.51262191e-02f, -4.93322685e-02f,
  -1.69820651e-01f, -1.31356463e-01f, -5.46377301e-02f, -2.23312490e-02f, 5.50641865e-02f, -1.10799819e-01f, 2.72286274e-02f, -2.16345172e-02f, -4.88114841e-02f, 1.99859235e-02f,
  8.11059549e-02f, 2.88105700e-02f, -9.23782364e-02f, -6.87024593e-02f, -8.28490406e-02f, -8.66796598e-02f, 6.78000376e-02f, -1.59167522e-03f, 1.32237211e-01f, 6.28448427e-02f,
  -7.33599067e-02f, 1.28557188e-02f, 3.17323133e-02f, -3.02619254e-03f, -7.25601539e-02f, 2.85966992e-02f, 4.11175825e-02f, -1.10094868e-01f, 1.02042099e-02f, -1.00184284e-01f,
  -1.01863176e-01f, 7.42138624e-02f, 6.08318821e-02f, -3.85391265e-02f, -4.41866294e-02f, -8.97178277e-02f, 2.43774820e-02f, -1.07867680e-01f, 1.11251101e-02f, -5.17835282e-02f,
  -2.70445675e-01f, -8.45818594e-02f, 3.03107351e-02f, 1.14713602e-01f, 1.65702999e-01f, 4.47412804e-02f, -8.72927345e-03f, 4.77363393e-02f, 3.65277342e-02f, -3.54763027e-03f,
  2.90015750e-02f, 1.51515484e-01f, 4.22891155e-02f, -1.35331407e-01f, -1.39849447e-02f, 3.27745173e-03f, -1.20290123e-01f, 6.95162565e-02f, 6.52258471e-02f, -5.71949966e-02f,
  3.88960391e-02f, 3.49016786e-02f, 1.97394770e-02f, -2.94441376e-02f, 3.82333770e-02f, -6.78380877e-02f, 3.01689655e-03f, 1.01178177e-01f, 1.25253752e-01f, 1.13457292e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.16565756e-01f, 2.08321631e-01f, 2.88466692e-01f, 6.27876744e-02f, 1.37846425e-01f, 2.22841412e-01f, 6.09248802e-02f, 3.19713265e-01f, 4.64579761e-02f, 1.84428588e-01f,
  1.74741879e-01f, -1.59822800e-03f, 4.59908098e-02f, 1.86899968e-03f, -2.64943596e-02f, 2.45076001e-01f, 1.86367720e-01f, 2.74098068e-01f, 2.84494102e-01f, 2.41809618e-02f,
  -7.33316224e-03f, 5.82766496e-02f, 3.02042633e-01f, 1.47145420e-01f, 1.02227889e-02f, 1.81327820e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  7.53848627e-02f, 2.30874270e-01f, -7.20371976e-02f, 1.71157811e-02f, 8.58107209e-02f, 5.63226007e-02f, 1.18495956e-01f, 4.94089499e-02f, -2.68369257e-01f, 3.01912636e-01f,
  1.87218890e-01f, -2.23105237e-01f, -5.71044125e-02f, -2.31869388e-02f, -1.26388460e-01f, -1.67917442e-02f, -2.96297401e-01f, 1.56941578e-01f, 3.18342417e-01f, -1.64067850e-01f,
  1.73776373e-01f, 2.42850512e-01f, 3.87489982e-02f, -2.01202407e-01f, 1.37655765e-01f, 2.64408320e-01f, 4.87991013e-02f, -2.24572822e-01f, 9.43982881e-03f, 2.74293244e-01f,
  -4.16300446e-02f, 1.56625286e-02f, -5.01536299e-03f, -6.56146109e-02f, 5.19494154e-03f, 3.00488230e-02f, 3.39950919e-02f, -1.46953881e-01f, 5.11793233e-02f, 1.71870321e-01f,
  -8.26556385e-02f, -2.25345343e-01f, 8.23001936e-02f, -7.15520754e-02f, 1.80780575e-01f, -2.20990088e-02f, 2.92500973e-01f, -1.95640191e-01f, -8.48575756e-02f, -1.00704148e-01f,
  1.16524413e-01f, 1.12390347e-01f, -5.33985436e-01f, 2.30370745e-01f, 4.55436893e-02f, 3.27686846e-01f, 2.40472294e-02f, 4.49950919e-02f, -7.22214133e-02f, -1.74536049e-01f,
  2.28662401e-01f, -1.38323188e-01f, -1.54555604e-01f, -3.04174542e-01f, -1.38499424e-01f, -1.24795623e-01f, 1.35792131e-02f, -7.45809078e-02f, -1.09206147e-01f, -1.53186336e-01f,
  -5.91099933e-02f, 7.17129782e-02f, 1.30709764e-02f, -3.92025441e-01f, 1.59293249e-01f, -9.34103131e-03f, 1.32076442e-01f, -3.20594646e-02f, 2.70960957e-01f, 1.64746657e-01f,
  -1.31430492e-01f, 1.25992328e-01f, -1.36005059e-01f, -3.29235233e-02f, -3.74770612e-01f, 3.70245241e-02f, 3.11954366e-03f, 5.00487499e-02f, 2.57257998e-01f, -1.03424080e-02f,
  -9.35611203e-02f, -1.80443805e-02f, 1.08687334e-01f, 9.27435383e-02f, -1.40021265e-01f, -1.42410491e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.88643977e-01f, -2.16672465e-01f, -6.69918209e-02f, -3.13941509e-01f, 8.82921070e-02f, 4.23303068e-01f, 2.38415152e-01f, 1.70865834e-01f, 6.11070497e-03f, 2.19303682e-01f,
  -3.45532261e-02f, 4.99631884e-03f, 4.70446348e-02f, 1.32750750e-01f, 8.96515045e-03f, -3.88613135e-01f, 7.75835291e-02f, -1.85856894e-01f, 1.69271335e-01f, 2.40175948e-01f,
  3.01664978e-01f, 1.23976149e-01f, 1.70787096e-01f, -2.87411828e-02f, -2.25909725e-01f, 1.39947295e-01f, 9.68453586e-02f, 2.48778999e-01f, 2.93136656e-01f, 9.16217789e-02f,
  8.76921564e-02f, 7.24718198e-02f, 2.81327426e-01f, 1.42613515e-01f, -8.44642222e-02f, -3.15580741e-02f, -1.10125169e-01f, 9.03869718e-02f, 2.67237097e-01f, -1.62255913e-02f,
  -1.29842341e-01f, 5.15898168e-01f, 1.40787423e-01f, -1.06089711e-01f, 1.60325497e-01f, -1.81151301e-01f, 1.90603912e-01f, -1.97957337e-01f, 4.27642852e-01f, 1.17610931e-01f,
  2.18580917e-01f, 5.17740101e-02f, 4.17185724e-01f, -6.45133182e-02f, -1.04501843e-01f, 8.36243257e-02f, -1.29342720e-01f, 6.24237098e-02f, 7.13449121e-02f, 3.63516390e-01f,
  -6.76025301e-02f, -2.31663421e-01f, 5.00882030e-01f, 1.52186170e-01f, 2.89417893e-01f, 7.34095424e-02f, 1.49007857e-01f, -1.74501583e-01f, -1.98399667e-02f, 3.73222023e-01f,
  1.24256626e-01f, -2.09955111e-01f, 3.56536239e-01f, 1.54761225e-01f, -2.39124075e-01f, 9.20811668e-02f, 3.62091333e-01f, -3.72062530e-03f, 2.18791798e-01f, -1.86646938e-01f,
  2.23522767e-01f, -1.40253827e-01f, 5.00729755e-02f, -1.30016916e-02f, 4.27195221e-01f, 8.02440196e-02f, 3.00091088e-01f, 9.89715531e-02f, 5.24685644e-02f, 3.68727177e-01f,
  3.38641047e-01f, -3.06145884e-02f, 2.65972406e-01f, 2.87897289e-01f, 9.66231525e-02f, -1.59181058e-01f, -2.72817668e-02f, 2.02335015e-01f, 7.90429562e-02f, 3.22860032e-01f,
  3.50564629e-01f, -7.13954791e-02f, -1.17228858e-01f, 1.22435950e-01f, -2.19991818e-01f, -3.93231779e-01f, -1.44163489e-01f, 9.18612853e-02f, -2.32014164e-01f, 1.50593907e-01f,
  -2.46020824e-01f, 2.57888228e-01f, -2.48844683e-01f, 9.42090824e-02f, 1.93376075e-02f, -1.76545069e-01f, -1.98259413e-01f, 4.33712691e-01f, 5.30512631e-02f, 3.67229968e-01f,
  7.94818923e-02f, 3.38732362e-01f, 2.04285253e-02f, -3.00649166e-01f, 3.98567408e-01f, 4.27276522e-01f, -2.08132509e-02f, -5.38820803e-01f, -3.10861450e-02f, 4.96652246e-01f,
  1.37418300e-01f, -1.94719225e-01f, -2.38522574e-01f, -1.20669734e-02f, -7.93003961e-02f, -6.32492527e-02f, 3.51513833e-01f, -3.69698107e-01f, -5.63582703e-02f, 1.60263646e-02f,
  1.72752067e-02f, 5.16885400e-01f, 1.13827094e-01f, 1.17266655e-01f, 5.98968506e-01f, -3.13593835e-01f, 6.80744499e-02f, 1.88133761e-01f, 2.90281605e-02f, -3.26963723e-01f,
  4.03236479e-01f, 2.73772955e-01f, -5.70280710e-03f, -1.02405427e-02f, -5.64612374e-02f, 1.40537933e-01f, -1.15524177e-02f, 1.41295686e-01f, -4.32268918e-01f, 1.32619159e-03f,
  7.20284656e-02f, 1.27392128e-01f, 8.34499076e-02f, 1.98186055e-01f, -2.78380752e-01f, 5.60416505e-02f, -1.96661741e-01f, 1.54354095e-01f, 2.00990170e-01f, -9.99882445e-02f,
  1.21740371e-01f, 4.75974202e-01f, -2.39770412e-01f, 5.13965152e-02f, 2.92323977e-01f, 4.93209153e-01f, -4.06017959e-01f, -3.71517241e-01f, 6.33070171e-02f, -3.86542417e-02f,
  1.91413850e-01f, -3.41933966e-01f, 2.00973764e-01f, -3.41547757e-01f, 1.14778280e-01f, 7.16036409e-02f, -9.53329578e-02f, -6.86069578e-02f, -4.31535125e-01f, -2.82994509e-01f,
  -2.13819370e-01f, 1.08990647e-01f, -4.61351834e-02f, 4.51356500e-01f, 4.48695093e-01f, -2.96870265e-02f, -3.16425771e-01f, -7.49255568e-02f, 9.65719745e-02f, 3.50588650e-01f,
  2.53507316e-01f, -3.50689411e-01f, -1.43661454e-01f, 3.45149696e-01f, -3.03302884e-01f, 3.73067647e-01f, -1.32239640e-01f, 5.46648204e-01f, 1.59668386e-01f, -2.50608623e-01f,
  -3.29464912e-01f, -2.64755368e-01f, -5.80687262e-02f, -3.29646438e-01f, 2.94096142e-01f, -4.46958803e-02f, -1.26684383e-01f, -1.33698329e-01f, -1.23993903e-01f, 2.02692673e-01f,
  -2.56314576e-02f, 2.22585127e-01f, -3.67862821e-01f, -1.15042247e-01f, 2.05951348e-01f, 5.52453101e-01f, 2.08276168e-01f, -5.97189255e-02f, -3.12047690e-01f, 2.61276402e-03f,
  3.66904408e-01f, 7.09969327e-02f, 2.40888879e-01f, -5.19574396e-02f, -7.15428516e-02f, -4.93345819e-02f, 7.63895363e-02f, 6.86216831e-01f, -2.59580582e-01f, 1.55550420e-01f,
  1.62419498e-01f, 3.43304902e-01f, -2.80835629e-01f, -2.57473946e-01f, 1.27097115e-01f, -2.61732548e-01f, 1.69752881e-01f, 4.04290378e-01f, -5.59090935e-02f, -1.74408145e-02f,
  9.49369222e-02f, -1.65356725e-01f, 5.03239870e-01f, 1.78767424e-02f, -1.52163312e-01f, -3.59527171e-01f, 3.66157204e-01f, 2.57307775e-02f, 1.81046471e-01f, 6.32750764e-02f,
  -7.01522753e-02f, -4.88042444e-01f, -1.15638949e-01f, -1.17657259e-01f, -2.10499987e-02f, -1.37244478e-01f, 2.91891575e-01f, 1.67049780e-01f, 3.08177192e-02f, 4.30411607e-01f,
  1.88783690e-01f, 2.43090555e-01f, -8.27625021e-02f, -2.72622257e-02f, 3.36473957e-02f, -3.56566310e-02f, 1.87391073e-01f, -3.49692941e-01f, 9.67151895e-02f, -3.35369319e-01f,
  5.54760635e-01f, 1.16265900e-02f, -1.77647620e-01f, -1.55942425e-01f, -2.42419943e-01f, 1.11157648e-01f, -2.10708037e-01f, -7.61928707e-02f, 3.72503459e-01f, 3.29540938e-01f,
  9.35377553e-02f, -2.51339585e-01f, -2.83516973e-01f, 1.47280529e-01f, 1.85474351e-01f, -4.78601843e-01f, 1.16354153e-01f, 4.18420613e-01f, -2.02169940e-01f, 9.84647647e-02f,
  6.74327686e-02f, 3.45338851e-01f, -2.11273745e-01f, -6.91678300e-02f, -1.08478330e-01f, -7.30057899e-03f, 1.17293797e-01f, 1.89275797e-02f, 5.52536845e-01f, -1.80626214e-01f,
  -2.35309452e-02f, -3.13444197e-01f, -2.18806043e-01f, 1.34220645e-01f, 2.39929870e-01f, -1.14529639e-01f, -9.68258008e-02f, 2.06582248e-02f, 2.49110460e-01f, -2.09956244e-01f,
  9.11982805e-02f, 8.47940817e-02f, 4.54724669e-01f, 1.20135263e-01f, -3.95572782e-02f, -4.95858699e-01f, -1.44422755e-01f, -1.42141417e-01f, 1.69341579e-01f, -4.09252793e-01f,
  2.52740085e-01f, -2.63702385e-02f, 2.00982779e-01f, 1.15594797e-01f, 2.42564753e-01f, 3.55347246e-01f, 1.50634095e-01f, -3.85924667e-01f, -2.84280568e-01f, -1.26412705e-01f,
  -8.27037245e-02f, -1.85726061e-01f, 1.09010942e-01f, 4.49624136e-02f, 1.61903873e-01f, -1.07162725e-02f, 1.67932436e-01f, 2.34076515e-01f, -5.10765426e-02f, 2.78852910e-01f,
  5.43251121e-03f, 1.38856441e-01f, 2.41985649e-01f, -6.25103340e-02f, -1.81924835e-01f, -5.80499768e-02f, 3.28958154e-01f, -1.38998078e-02f, 2.69883245e-01f, -1.34916425e-01f,
  -3.41458142e-01f, 4.28159386e-01f, 3.18708628e-01f, -3.61011446e-01f, 1.88336328e-01f, -3.71827513e-01f, 3.39059144e-01f, -2.73312151e-01f, -1.39998242e-01f, -2.62801498e-01f,
  2.58170605e-01f, 2.75907397e-01f, 4.40470800e-02f, 3.27761531e-01f, -2.13538140e-01f, -3.68979484e-01f, 2.73500770e-01f, 3.52162719e-01f, 1.55238360e-01f, 5.49696274e-02f,
  3.53830829e-02f, 3.99836600e-01f, 3.82359356e-01f, 9.05466154e-02f, -1.75086409e-01f, -3.83565463e-02f, 6.99874684e-02f, 2.59299837e-02f, -5.03517166e-02f, -1.65343702e-01f,
  -1.77207187e-01f, 7.60566369e-02f, -1.19778179e-01f, 1.02673665e-01f, 1.71007171e-01f, -4.04864326e-02f, -1.15981139e-01f, -1.67237714e-01f, -2.93596953e-01f, 4.03196931e-01f,
  4.82719541e-01f, -5.01957498e-02f, -5.14110148e-01f, -6.17653057e-02f, -3.92329186e-01f, 4.39284556e-02f, -1.29450187e-01f, -1.45692378e-01f, -3.12334509e-03f, -3.47677857e-01f,
  -4.25048143e-01f, 4.34677631e-01f, -2.43407935e-01f, -4.50396031e-01f, 1.96332633e-01f, 2.57636517e-01f, 2.71034658e-01f, 1.16578341e-01f, 2.73964465e-01f, 7.70777240e-02f,
  3.01713198e-02f, -1.99795410e-01f, -1.40100092e-01f, 2.60798275e-01f, 1.63765937e-01f, -3.03497344e-01f, 2.43158728e-01f, 2.27011472e-01f, 2.08026692e-01f, -2.88917013e-02f,
  3.04265499e-01f, 3.36997271e-01f, -4.09984112e-01f, -2.74316847e-01f, 4.03021835e-02f, 2.72459127e-02f, -1.59831047e-01f, -8.66944194e-02f, 1.56031713e-01f, 1.84858561e-01f,
  3.12674075e-01f, 8.81593078e-02f, -2.54693888e-02f, -3.69340666e-02f, -1.59933075e-01f, 1.61431953e-01f, -5.07981665e-02f, -4.71875668e-02f, 2.25682095e-01f, -1.77340925e-01f,
  -9.60958153e-02f, -3.08389097e-01f, -2.16727793e-01f, 3.93434465e-02f, -2.64853239e-01f, 1.62622616e-01f, 2.57167727e-01f, 2.33587712e-01f, 2.79649645e-01f, 2.48050570e-01f,
  4.76873964e-02f, -5.46498261e-02f, 3.94961417e-01f, 2.18009856e-02f, -1.09276827e-02f, -1.28440157e-01f, 2.16705173e-01f, 1.33158520e-01f, -4.16624993e-02f, -4.12874997e-01f,
  -1.22035280e-01f, -1.12004943e-01f, 3.40752274e-01f, 2.52567977e-01f, -2.82289833e-01f, -9.23293605e-02f, -2.13029116e-01f, -4.20592427e-02f, -4.80108708e-03f, 2.52725594e-02f,
  1.72246695e-01f, 1.04944713e-01f, -1.94915570e-02f, 1.22001261e-01f, -1.86907619e-01f, -1.42115086e-01f, -1.13944836e-01f, -1.54400533e-02f, -1.15210265e-01f, 1.11952700e-01f,
  -5.29625267e-02f, 7.10519552e-02f, 1.67175308e-01f, 1.55180141e-01f, 1.13935217e-01f, 2.49862015e-01f, -5.19006908e-01f, 2.55048066e-01f, 2.61460006e-01f, 5.40797226e-02f,
  -1.62016954e-02f, -4.74362493e-01f, 1.32201940e-01f, -4.42547739e-01f, 1.99479982e-01f, 8.24915171e-02f, 6.66755345e-03f, -2.26860598e-01f, -5.41419148e-01f, 1.44682229e-01f,
  -4.23149988e-02f, 1.52876884e-01f, 1.55588672e-01f, -5.50270230e-02f, 5.04247136e-02f, 1.12608716e-01f, 3.28349508e-02f, -1.64541870e-01f, -3.22574452e-02f, 3.03380311e-01f,
  1.36390969e-01f, -1.43473476e-01f, 2.70721018e-01f, 2.56530285e-01f, 1.02872767e-01f, -7.90307745e-02f, 4.41955060e-01f, 2.51981884e-01f, -2.44676203e-01f, -3.20672184e-01f,
  2.67178323e-02f, 1.25031233e-01f, -1.31984457e-01f, 1.02611189e-03f, 1.49967209e-01f, -1.20134071e-01f, 3.48639935e-01f, 1.61350071e-01f, -1.87617704e-01f, 1.10182770e-01f,
  -1.30494997e-01f, -1.04628079e-01f, -8.33342411e-03f, 1.40939236e-01f, 7.34803751e-02f, -7.48116150e-02f, 8.82108659e-02f, 8.24525952e-02f, 2.96108663e-01f, -1.88472643e-01f,
  -7.20939413e-02f, 1.96375608e-01f, 7.94913098e-02f, -8.80574808e-02f, -5.30640930e-02f, 1.66777059e-01f, 2.78416611e-02f, -1.00730233e-01f, 6.54640645e-02f, -1.53121844e-01f,
  -6.47206828e-02f, -3.04235309e-01f, -1.96692973e-01f, 5.34026287e-02f, -1.74477890e-01f, 5.57909012e-01f, -1.14776976e-01f, 4.72554743e-01f, 1.21039718e-01f, 1.33119881e-01f,
  -2.33700988e-03f, 1.87975213e-01f, 2.89694726e-01f, 1.88718408e-01f, 4.19262564e-03f, -2.72097647e-01f, 2.26132333e-01f, 4.44113612e-01f, 1.03212781e-01f, -1.86650023e-01f,
  -1.15580253e-01f, 1.34142756e-01f, 2.80826360e-01f, -8.78071412e-02f, 5.28317571e-01f, -1.21792592e-01f, -1.92442074e-01f, 4.82688278e-01f, 2.67129540e-01f, 3.21023732e-01f,
  1.66059852e-01f, 1.01233102e-01f, 4.07036364e-01f, -1.44590046e-02f, 7.09859729e-02f, 8.19076300e-02f, 2.42582709e-01f, -3.22889596e-01f, 3.45825940e-01f, 2.04823852e-01f,
  -1.88566506e-01f, 2.67919991e-02f, 3.29988390e-01f, 1.70752078e-01f, 2.89498176e-02f, 4.68174331e-02f, -1.90842405e-01f, -3.90000224e-01f, 9.79541391e-02f, -8.70833397e-02f,
  2.85086542e-01f, 4.17339891e-01f, 2.42125452e-01f, -1.55266374e-01f, -1.77231863e-01f, 4.13406432e-01f, 2.51269579e-01f, -7.91494176e-02f, -2.70023018e-01f, 2.94892251e-01f,
  -1.24182865e-01f, 1.61271505e-02f, 2.39721373e-01f, 2.42817014e-01f, 1.92479759e-01f, -3.47948194e-01f, -3.21989924e-01f, 1.36631250e-01f, -2.43256047e-01f, 2.43314192e-01f,
  2.39513457e-01f, 4.53937620e-01f, 4.33483860e-03f, 2.64130890e-01f, 1.03156418e-01f, 1.98116619e-03f, 1.34628117e-01f, 5.61283976e-02f, -1.44254997e-01f, -9.38993767e-02f,
  8.59899521e-02f, 3.01095657e-04f, 1.16939219e-02f, 2.34352231e-01f, 1.94277227e-01f, 1.18642375e-01f, 2.10264057e-01f, 4.39526029e-02f, -6.46329075e-02f, 5.69441654e-02f,
  -6.94915280e-02f, 1.81071818e-01f, 1.73993140e-01f, 1.28575474e-01f, 1.47359774e-01f, -1.06790094e-02f, -1.92806974e-01f, 2.54401833e-01f, -3.75840929e-03f, -1.10026309e-02f,
  1.74035892e-01f, 4.92793113e-01f, 2.71221608e-01f, 3.79231483e-01f, -7.54681155e-02f, 2.61906087e-01f, 1.93129629e-01f, -2.42277801e-01f, 4.55304235e-01f, 2.64320523e-01f,
  1.90310255e-01f, -3.22359055e-01f, 2.23375022e-01f, 1.29547626e-01f, 9.32252873e-03f, 2.21552387e-01f, -2.66512185e-02f, 3.90118286e-02f, 3.54244746e-02f, 3.51276472e-02f,
  2.95961887e-01f, -2.34147638e-01f, 1.35730550e-01f, -7.20302686e-02f, 2.09145755e-01f, 1.78056255e-01f, 3.66114467e-01f, -1.97397679e-01f, 1.58038870e-01f, 9.30616632e-02f,
  9.24116522e-02f, 3.67267504e-02f, -5.27445786e-03f, 3.81410867e-01f, 3.29337776e-01f, 2.77338326e-01f, 4.30141211e-01f, 4.43825781e-01f, 2.08508208e-01f, -5.38644306e-02f,
  1.41540498e-01f, 4.17250454e-01f, -2.34541163e-01f, -4.27642137e-01f, -5.20155095e-02f, -1.88239127e-01f, -9.82796587e-03f, -3.51629376e-01f, 8.99810642e-02f, 3.79662737e-02f,
  1.93617910e-01f, -6.84527576e-01f, -2.39305422e-01f, -2.52568424e-01f, -2.76973665e-01f, -6.04949772e-01f, 2.82601953e-01f, 3.62104625e-01f, 1.02134764e-01f, -4.73677754e-01f,
  2.22902730e-01f, 3.58237684e-01f, -6.94092140e-02f, 2.42762044e-01f, -2.31272876e-01f, 3.28367770e-01f, -2.26413414e-01f, 1.46319121e-01f, 7.61005059e-02f, -1.27897069e-01f,
  -1.52916521e-01f, -3.83391172e-01f, 4.86782044e-01f, 2.37521734e-02f, -1.45999074e-01f, -8.56783018e-02f, -4.22760332e-03f, 4.10629436e-02f, 1.50762111e-01f, -1.25547290e-01f,
  9.62040648e-02f, -1.48675337e-01f, 2.26837963e-01f, -2.14450210e-01f, -1.46537527e-01f, -4.11577910e-01f, 1.62137866e-01f, -4.25557792e-01f, 3.35153162e-01f, 2.95427769e-01f,
  -1.31690279e-01f, -1.47700295e-01f, 5.11100888e-01f, -2.10288972e-01f, 1.46601111e-01f, 2.70497262e-01f, -5.69468662e-02f, 5.43284491e-02f, -1.32197544e-01f, -6.28883243e-02f,
  3.12755883e-01f, -1.97849840e-01f, 2.40881622e-01f, 1.28905177e-01f, -8.26196894e-02f, 2.27849424e-01f, -1.86782330e-01f, 1.01725064e-01f, -8.84741619e-02f, -2.45931923e-01f,
  5.54547831e-02f, -9.17544737e-02f, 1.75940007e-01f, 9.14489925e-02f, -7.67628327e-02f, 2.62974083e-01f, 2.20455080e-01f, 3.81386518e-01f, 6.93317950e-02f, -2.57173087e-02f,
  3.68627518e-01f, -4.38214332e-01f, 9.47275907e-02f, -3.96769047e-01f, -7.11084157e-02f, 1.06675759e-01f, 2.25675002e-01f, 2.00609609e-01f, 3.88281703e-01f, 3.24782848e-01f,
  3.45198065e-02f, 1.73129976e-01f, 9.70623940e-02f, 1.21594436e-01f, 7.73791149e-02f, -1.43467247e-01f, -3.02959047e-02f, 1.71467379e-01f, 1.89512029e-01f, -1.38271093e-01f,
  1.08465441e-01f, 1.70490816e-01f, 3.86341959e-01f, 1.40396759e-01f, -1.41248673e-01f, 6.75670207e-02f, -3.56632620e-02f, 1.75387114e-01f, 2.96427637e-01f, 1.79545376e-02f,
  -2.86194712e-01f, 3.80900651e-01f, -1.14711024e-01f, 9.00963992e-02f, 1.26445051e-02f, 3.49217296e-01f, 4.74687368e-01f, -1.51367456e-01f, -3.02894890e-01f, -6.34042993e-02f,
  1.16313294e-01f, -1.73495561e-01f, 3.58832657e-01f, 4.29488271e-01f, 4.02078368e-02f, 7.16082975e-02f, -6.83869049e-02f, 2.64348071e-02f, -2.17003748e-01f, 8.83519929e-03f,
  -1.85288824e-02f, -2.43192539e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -7.80585706e-02f, -1.21974051e-01f, 2.61415869e-01f, 1.16773605e-01f, 2.98530400e-01f, 6.06370717e-02f, 2.60050952e-01f, 2.51999170e-01f, 1.96079493e-01f, 3.33571851e-01f,
  2.64915228e-01f, 1.93252623e-01f, 1.74511254e-01f, 2.34159738e-01f, -1.55782104e-01f, 3.12103540e-01f, 2.53480852e-01f, 1.56325638e-01f, 3.91319007e-01f, -6.43794611e-02f,
  1.55612424e-01f, 1.72866285e-01f, -1.95759669e-01f, 1.40264314e-02f, -3.19290087e-02f, 1.59635171e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  4.89298344e-01f, 3.60808492e-01f, -1.06059432e-01f, -2.98869401e-01f, -1.24941736e-01f, -1.34206116e-01f, 1.60576832e-02f, 1.97663590e-01f, 2.38214001e-01f, 9.97447073e-02f,
  -9.27260667e-02f, -2.70184934e-01f, -1.37255015e-02f, -2.10194334e-01f, -1.29519969e-01f, 2.67895550e-01f, 1.27716944e-01f, -2.10511265e-03f, -7.23514929e-02f, -1.69872373e-01f,
  -6.08728006e-02f, -2.61612207e-01f, -9.71518904e-02f, 1.69221833e-01f, 1.84934378e-01f, 4.95626889e-02f, -5.87103143e-02f, 2.58446783e-01f, -2.40369111e-01f, 7.86460787e-02f,
  1.43556505e-01f, 1.95723981e-01f, -1.21283226e-01f, -4.56766486e-02f, -3.84467065e-01f, 4.73172396e-01f, -1.76542833e-01f, 2.31032997e-01f, -2.79656976e-01f, 1.85651273e-01f,
  -2.19438225e-02f, -2.07895815e-01f, -2.67753810e-01f, 8.60675797e-02f, -1.40706927e-01f, -1.82037409e-02f, -5.21414690e-02f, 1.14377305e-01f, 8.66368413e-03f, 1.21878877e-01f,
  -7.08507281e-03f, -5.68620488e-02f, -4.03403640e-02f, 4.04715538e-01f, 2.35398673e-02f, -7.58414418e-02f, -1.32739395e-02f, -1.74401999e-01f, 3.95868793e-02f, -2.21124098e-01f,
  5.20830750e-02f, -4.03292418e-01f, 3.05940416e-02f, 9.84091312e-02f, 2.22583205e-01f, -7.49827027e-02f, -2.01003343e-01f, -2.89137125e-01f, 1.60617232e-01f, -4.49780899e-04f,
  -5.36386296e-02f, 1.88347667e-01f, -1.46258503e-01f, -3.00730258e-01f, -9.83714312e-02f, 6.75713792e-02f, -1.81923836e-01f, -9.01521146e-02f, -1.48936868e-01f, 1.48348734e-01f,
  2.13122874e-01f, -1.45030141e-01f, 2.58726984e-01f, 1.31259903e-01f, -1.00619182e-01f, 6.15674257e-02f, 1.37791872e-01f, 1.92859650e-01f, 1.63583294e-01f, 1.81191951e-01f,
  -8.44764560e-02f, -1.69328049e-01f, 1.65828511e-01f, -1.70566678e-01f, 2.47358888e-01f, -9.94358063e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.10523620e-01f, 2.95628518e-01f, 4.76387501e-01f, 5.60226798e-01f, -2.78280169e-01f, 4.65259820e-01f, -6.19904064e-02f, -1.84107304e-01f, 4.36035693e-02f, 5.15604056e-02f,
  2.25520805e-01f, 4.62199867e-01f, 5.25080979e-01f, -5.63129373e-02f, 2.26836249e-01f, 4.15169783e-02f, -5.91705702e-02f, -4.12093103e-01f, 1.95506230e-01f, 1.38464123e-01f,
  1.47385910e-01f, 1.44327119e-01f, 5.31051457e-02f, 1.11492902e-01f, 3.01490873e-02f, 2.97690600e-01f, 8.15829914e-03f, 8.32468213e-04f, 3.84414941e-01f, 1.57620400e-01f,
  -5.48460297e-02f, 2.21964732e-01f, -2.68438868e-02f, -5.07629884e-04f, 5.57683893e-02f, -9.63509642e-03f, -2.07311492e-02f, 3.84054184e-02f, 4.65129614e-02f, -7.36902608e-03f,
  9.42303091e-02f, -1.13000266e-01f, 1.37724251e-01f, 6.54209778e-02f, -6.57342095e-03f, 3.92113142e-02f, 1.22811735e-01f, 1.68131903e-01f, 7.01375380e-02f, 1.14897043e-01f,
  8.57188134e-04f, 6.22929856e-02f, 1.55382436e-02f, -1.02955671e-02f, 4.90027517e-02f, -7.82676414e-02f, 8.53807256e-02f, -1.16340123e-01f, 2.28419956e-02f, 2.14670636e-02f,
  5.59243467e-03f, 7.34361112e-02f, 4.10916377e-03f, -4.24416587e-02f, 5.09747684e-01f, 5.79005003e-01f, 1.94546372e-01f, 2.32095540e-01f, -4.31322515e-01f, -1.30726933e-01f,
  8.60699117e-02f, 3.71284992e-01f, 3.91573757e-02f, 2.66558714e-02f, 8.50405321e-02f, 1.54531643e-01f, 2.47362405e-01f, 3.33761901e-01f, -5.97020462e-02f, 2.88724720e-01f,
  -3.41055423e-01f, -2.99548775e-01f, 2.71885525e-02f, -1.96619645e-01f, 2.09116451e-02f, -4.48149703e-02f, 1.08902514e-01f, -4.12306249e-01f, 3.78905624e-01f, -1.90734640e-01f,
  1.44421197e-02f, -7.88990557e-02f, 2.70427346e-01f, -2.46606871e-01f, -6.74217865e-02f, 2.12104425e-01f, 2.15829492e-01f, -1.72346339e-01f, 1.82203297e-02f, -5.44638276e-01f,
  -2.39888161e-01f, -3.65520090e-01f, 1.42105833e-01f, 2.57483929e-01f, 1.29272506e-01f, 1.28879389e-02f, -3.28332186e-02f, -3.75785768e-01f, 1.38542250e-01f, 4.70764562e-02f,
  -3.44864637e-01f, 2.95834124e-01f, 2.23365098e-01f, 1.37099862e-01f, 2.56391674e-01f, -8.93177986e-02f, -3.34936112e-01f, -9.12051648e-02f, -2.55302817e-01f, 1.39705300e-01f,
  3.22740600e-02f, -3.62616568e-03f, -6.63575018e-03f, -8.46136883e-02f, -5.89610159e-01f, -2.80234188e-01f, 1.12337828e-01f, 3.87790203e-01f, 1.01576321e-01f, 3.84179950e-01f,
  1.34449780e-01f, 3.44248921e-01f, 2.06929669e-01f, -2.87502795e-01f, 1.76768720e-01f, -2.27558970e-01f, 1.00828961e-01f, 1.55035734e-01f, 1.48631126e-01f, -5.26434742e-02f,
  7.47191906e-02f, 6.10828519e-01f, -1.62497193e-01f, 8.45353454e-02f, -1.53396055e-01f, -4.35594112e-01f, -4.58776861e-01f, 3.75500396e-02f, -1.26203015e-01f, -1.49664342e-01f,
  -4.07624133e-02f, -2.26086807e-02f, 3.74598205e-01f, 1.09681062e-01f, 4.42871451e-01f, 1.55788675e-01f, 4.42426503e-01f, -8.77754614e-02f, -1.57513231e-01f, 4.71650772e-02f,
  1.92433923e-01f, -2.58217126e-01f, -8.11642259e-02f, -7.02325046e-01f, -2.25059241e-01f, -3.75234038e-01f, 2.63530076e-01f, 2.35380277e-01f, 1.87793881e-01f, -9.76909846e-02f,
  2.25606874e-01f, -3.10051680e-01f, 1.15942821e-01f, 4.14502829e-01f, -2.28374586e-01f, 1.81679368e-01f, 1.50917515e-01f, -1.59451336e-01f, 4.81832922e-01f, -1.01883605e-01f,
  -1.32779792e-01f, -2.19743714e-01f, -2.06675589e-01f, -5.47967441e-02f, 2.92388618e-01f, 9.41354260e-02f, 6.60553062e-03f, 7.76799172e-02f, 1.17549710e-01f, 1.04710296e-01f,
  4.89868820e-02f, 1.83984131e-01f, 2.17418477e-01f, -3.27312313e-02f, 4.68028069e-01f, 7.64302909e-01f, -5.44053912e-01f, 4.22349960e-01f, -7.11039677e-02f, -4.96750414e-01f,
  -9.00521502e-02f, 1.06109381e-01f, 1.10680468e-01f, 2.73821890e-01f, 4.41027164e-01f, 1.71452835e-01f, 4.47701603e-01f, 8.42892155e-02f, 3.13094258e-01f, 4.92880499e-05f,
  1.63110793e-01f, 1.85286909e-01f, 2.01620147e-01f, 1.96996167e-01f, 1.50720194e-01f, -2.07815707e-01f, 1.96865827e-01f, -7.93920755e-02f, -1.36111647e-01f, 1.17158256e-01f,
  1.13760099e-01f, 2.11169407e-01f, -2.40980193e-01f, 5.01229018e-02f, -5.33292294e-01f, -4.27644491e-01f, -8.87713283e-02f, -2.78382987e-01f, 2.00158715e-01f, 8.06445777e-02f,
  2.64277101e-01f, -9.99239907e-02f, 2.98951000e-01f, 8.64405781e-02f, -2.11077631e-01f, 1.10152766e-01f, -3.49290878e-01f, 1.42250791e-01f, -1.56430267e-02f, 5.04779965e-02f,
  -1.94539130e-02f, -1.55213673e-03f, -6.95429146e-01f, 5.06515354e-02f, 3.44432533e-01f, 1.54563695e-01f, 2.08382711e-01f, 3.89475435e-01f, 1.26971751e-01f, 3.63477290e-01f,
  4.87795323e-01f, 2.25773990e-01f, 1.44453943e-01f, -3.10263932e-01f, 3.33931237e-01f, 1.13950193e-01f, -3.01661521e-01f, -1.71417311e-01f, 1.81755736e-01f, 4.21261221e-01f,
  1.05677970e-01f, 2.89991260e-01f, -2.10630372e-02f, 6.11844137e-02f, 2.51188844e-01f, -1.08636990e-01f, -1.14707060e-01f, 5.19252010e-02f, -4.02734816e-01f, -1.99866205e-01f,
  3.27414632e-01f, 1.59608960e-01f, 4.62159887e-02f, 3.85429502e-01f, -2.69892186e-01f, 1.33741245e-01f, 4.01435435e-01f, 2.67643511e-01f, 2.38156289e-01f, 1.39353812e-01f,
  -1.72859728e-01f, -2.13167593e-01f, 1.62516207e-01f, 2.27559507e-01f, 9.78182629e-03f, -2.80078053e-01f, 1.71141773e-01f, -2.19569758e-01f, -1.87850356e-01f, 1.31504774e-01f,
  3.47052008e-01f, 7.92084098e-01f, -3.17224503e-01f, 2.90038615e-01f, -3.58342081e-01f, -1.08191319e-01f, -1.21340007e-01f, 2.44698718e-01f, 3.15930039e-01f, 2.14145392e-01f,
  2.79540896e-01f, 2.64956653e-01f, 3.67839187e-01f, -4.67176661e-02f, 2.40708053e-01f, -2.08966583e-01f, -5.31337023e-01f, 3.04250330e-01f, -1.08599989e-02f, 1.93653941e-01f,
  -5.17506376e-02f, -3.34278829e-02f, 1.10300973e-01f, -4.20817956e-02f, -1.42093554e-01f, 2.10036233e-01f, 1.11602984e-01f, 2.00389758e-01f, -1.34961784e-01f, 2.20475167e-01f,
  2.28145629e-01f, -1.27215415e-01f, 2.86686987e-01f, -2.42087990e-01f, -1.46714300e-01f, 2.81719834e-01f, -2.01278538e-01f, -1.31679222e-01f, 4.65060137e-02f, -4.56016868e-01f,
  2.90689558e-01f, 3.79097313e-01f, 1.91542491e-01f, -4.30164337e-01f, 3.46288800e-01f, -4.27769721e-02f, 5.57325920e-03f, -1.12965688e-01f, 3.03692251e-01f, 1.68019831e-01f,
  4.64773886e-02f, 7.40214288e-02f, 3.02527219e-01f, -6.40689163e-03f, 3.12497467e-01f, 1.49501607e-01f, -3.13805968e-01f, -3.73049006e-02f, 7.54646137e-02f, -4.60358411e-02f,
  -1.31573370e-02f, 1.83822379e-01f, 2.93070197e-01f, 1.93715692e-01f, -4.04835433e-01f, -2.05789208e-02f, 5.36080062e-01f, -3.48379642e-01f, 2.27484673e-01f, -1.67305082e-01f,
  2.42843509e-01f, -1.53206848e-03f, -3.91218573e-01f, -1.46203890e-01f, -5.01923025e-01f, 1.35870531e-01f, -2.88040265e-02f, 2.01171249e-01f, -1.21619605e-01f, 3.72457355e-01f,
  -6.77228034e-01f, -3.43214780e-01f, -1.51718274e-01f, -1.05698109e-01f, -4.30314660e-01f, 3.98226008e-02f, 8.27358663e-03f, -6.78982213e-02f, 3.85762811e-01f, 1.82390437e-01f,
  2.08052874e-01f, -2.63430357e-01f, 1.88336730e-01f, -2.51809388e-01f, 1.79499254e-01f, -3.69860865e-02f, 2.24604234e-01f, -2.86912829e-01f, -7.24651754e-01f, -3.78011286e-01f,
  -4.79535423e-02f, 1.36089206e-01f, 1.46425366e-01f, -3.85593325e-01f, 4.28005338e-01f, 1.22060798e-01f, 5.54451823e-01f, 1.77972034e-01f, 2.51643687e-01f, 2.98970461e-01f,
  3.63101244e-01f, -1.94006711e-01f, 7.18343437e-01f, 2.43406445e-01f, 9.96799320e-02f, 1.02539450e-01f, 1.88591093e-01f, -3.03512961e-01f, 3.55072916e-01f, 6.60883412e-02f,
  -2.95011133e-01f, 3.93511616e-02f, -3.08993936e-01f, -5.05600870e-02f, -7.79675841e-02f, 3.96211535e-01f, 1.69749379e-01f, -3.35505337e-01f, -3.26861233e-01f, -5.28129637e-01f,
  -4.66192812e-01f, -6.50418341e-01f, 3.00615102e-01f, 4.25806940e-01f, 2.16137990e-01f, -1.17008947e-01f, 1.89216614e-01f, -3.15006614e-01f, -3.22071999e-01f, -4.16342318e-02f,
  -4.36407188e-03f, 3.61102909e-01f, -2.21550316e-01f, 2.77121484e-01f, 5.49300984e-02f, -1.71078295e-01f, 2.34248832e-01f, -1.60940457e-02f, 1.42088428e-01f, -2.24062428e-01f,
  1.77583620e-01f, -3.16566378e-01f, 8.94125625e-02f, 4.09913156e-03f, -1.40183181e-01f, -3.13955873e-01f, 3.19532216e-01f, 2.39108857e-02f, -1.01119705e-01f, 5.31890571e-01f,
  4.49235767e-01f, 5.61185837e-01f, -1.64694667e-01f, 5.11750638e-01f, 1.32490098e-01f, -1.42567143e-01f, -6.40476197e-02f, 3.30982327e-01f, 2.37001032e-01f, 4.49400209e-02f,
  5.31902872e-02f, -5.67809641e-02f, 6.01191521e-01f, -1.14549823e-01f, 1.14618860e-01f, 4.71392244e-01f, 6.79269210e-02f, 6.67656437e-02f, 1.64448574e-01f, 1.66742399e-01f,
  1.46604940e-01f, -9.15764570e-02f, -1.76110044e-02f, -3.35337162e-01f, -6.73607960e-02f, 1.15539566e-01f, 4.64521274e-02f, 5.29425085e-01f, -9.47759077e-02f, -3.41322213e-01f,
  -4.44420427e-01f, -6.60865426e-01f, 7.13264421e-02f, -9.16071832e-01f, 3.05047750e-01f, 5.66814840e-01f, -2.69291028e-02f, 3.55030224e-02f, 6.77073523e-02f, -4.78677720e-01f,
  2.13210940e-01f, -9.94971395e-02f, -1.88912675e-01f, -2.52205163e-01f, 2.33130082e-01f, -2.77060680e-02f, 3.15058231e-02f, -1.59692317e-01f, -3.42409968e-01f, 1.22541063e-01f,
  3.47146243e-01f, 8.19151551e-02f, 2.22405121e-01f, 4.65788692e-02f, 6.06034212e-02f, 2.50607133e-01f, -2.09499039e-02f, 1.32850066e-01f, -1.26976997e-01f, -3.11033428e-01f,
  1.14875786e-01f, 2.36394018e-01f, 5.71455210e-02f, -2.97139138e-02f, -2.23575398e-01f, -4.04498547e-01f, 1.49218976e-01f, -2.36780003e-01f, 3.38750780e-01f, -6.75650612e-02f,
  3.01525950e-01f, 4.82660085e-01f, 1.85145304e-01f, -2.77855664e-01f, -9.90998372e-02f, -2.90032089e-01f, -3.69962007e-01f, -9.21879783e-02f, 1.52697489e-01f, 8.71862695e-02f,
  -2.01734435e-02f, -1.20121479e-01f, -1.13085121e-01f, -3.24968576e-01f, -2.27029800e-01f, 6.30887866e-01f, 3.04599553e-01f, 5.15048921e-01f, 3.17598492e-01f, 4.11739349e-01f,
  -4.76886660e-01f, 6.10584438e-01f, 3.11039716e-01f, 3.15340400e-01f, 1.17704548e-01f, -1.20123185e-01f, -2.31272206e-01f, 3.38389546e-01f, 1.52781039e-01f, 1.30873412e-01f,
  9.32508036e-02f, 1.50512591e-01f, -2.41628755e-02f, 9.69777629e-03f, -3.20329875e-01f, 4.19059366e-01f, -3.19863319e-01f, 1.35383129e-01f, -3.44927400e-01f, 7.42181316e-02f,
  -4.39333230e-01f, 1.24204345e-01f, -2.87206024e-01f, 1.05110586e-01f, 1.41134709e-01f, 5.43229997e-01f, 6.22265711e-02f, 2.22826585e-01f, 9.29324329e-02f, 6.64280578e-02f,
  1.92826599e-01f, -9.07605886e-02f, 2.95912564e-01f, -5.73547781e-01f, 2.12386698e-01f, 1.65504974e-03f, -1.45018771e-01f, -3.61318886e-02f, 4.08651769e-01f, 1.52891472e-01f,
  -2.10918099e-01f, 5.68269789e-01f, 7.29619488e-02f, 7.60985166e-02f, -1.86641142e-01f, -1.28403857e-01f, -1.07007533e-01f, 3.65207344e-01f, -1.24840856e-01f, -8.68005902e-02f,
  3.90886515e-01f, 2.17819035e-01f, 8.34927559e-02f, 2.55424529e-01f, 1.05471555e-02f, 1.79275960e-01f, 2.68932730e-01f, 2.19666228e-01f, 1.31563008e-01f, -4.38727915e-01f,
  2.46429071e-01f, -1.23649575e-01f, -1.65998429e-01f, 9.13213864e-02f, -1.64645195e-01f, -4.60854262e-01f, 3.00161839e-01f, -1.54476508e-01f, -5.77779077e-02f, 2.64050573e-01f,
  3.93000871e-01f, 3.77094507e-01f, 3.57551098e-01f, 1.76525131e-01f, -1.34064600e-01f, -3.86011779e-01f, 2.21191466e-01f, 3.62569153e-01f, 1.79948330e-01f, -2.46170983e-01f,
  2.77114719e-01f, 1.51621282e-01f, 9.11552235e-02f, -2.67889619e-01f, 2.39032179e-01f, 1.87057555e-01f, -3.23959410e-01f, 2.34373465e-01f, -1.71582237e-01f, -2.72346437e-01f,
  1.72659159e-01f, 4.69647527e-01f, 9.78831127e-02f, 2.52207220e-02f, 2.75726855e-01f, 1.50832325e-01f, 2.12557781e-02f, 4.14890498e-01f, 8.15980881e-02f, 5.58430031e-02f,
  -1.34609401e-01f, -6.12228885e-02f, -4.90156226e-02f, -9.18469951e-02f, -3.66148353e-01f, -3.65585119e-01f, 2.51171678e-01f, 1.89747259e-01f, 2.43125662e-01f, -1.99804679e-01f,
  1.31129742e-01f, -3.15406650e-01f, -1.02783926e-01f, 1.09892495e-01f, 3.34503293e-01f, 3.21214020e-01f, 7.01014474e-02f, 2.85616994e-01f, -5.92441373e-02f, 2.08838925e-01f,
  9.29783732e-02f, 3.95965762e-02f, 1.46461949e-01f, -3.28564554e-01f, 2.97660530e-02f, -1.43649772e-01f, -5.93271032e-02f, -1.00034941e-03f, -6.12639010e-01f, -1.24646723e-01f,
  1.41764298e-01f, -4.74314466e-02f, 2.96916306e-01f, 1.82852194e-01f, 2.43505344e-01f, 1.46382330e-02f, 1.17436014e-01f, 1.81777433e-01f, -1.96386859e-01f, -3.68984908e-01f,
  -2.05560744e-01f, 1.91439658e-01f, 2.10921373e-02f, 3.76558304e-01f, 5.09888411e-01f, -1.29643604e-01f, 5.04002394e-03f, -1.73867688e-01f, 3.15309554e-01f, -8.60670134e-02f,
  -3.73211317e-02f, 3.00336808e-01f, -1.31061420e-01f, -2.02415273e-01f, 3.19557011e-01f, 3.97500813e-01f, -5.63487932e-02f, 3.75191927e-01f, 1.47280604e-01f, 1.49986073e-01f,
  -2.08307937e-01f, 2.60921687e-01f, 7.94014335e-02f, 2.54070789e-01f, -3.95394057e-01f, -8.40394869e-02f, 1.65355623e-01f, -2.11194921e-02f, -3.26939851e-01f, 2.53483921e-01f,
  -1.25744864e-01f, 1.56507373e-01f, 2.51606345e-01f, -2.20468849e-01f, 6.37259632e-02f, -2.25602284e-01f, 1.44286856e-01f, 1.44659072e-01f, 2.23433867e-01f, 4.27218944e-01f,
  2.89513975e-01f, 2.72239566e-01f, -5.05070448e-01f, 2.48025730e-01f, 2.58596856e-02f, 2.20027298e-01f, -5.52912392e-02f, -5.47321700e-02f, 2.37565234e-01f, -6.78154528e-02f,
  6.75798580e-02f, 1.64769650e-01f, -6.02711916e-01f, -7.68070593e-02f, 2.74592400e-01f, 1.22839620e-03f, 2.26641089e-01f, 4.54727948e-01f, 3.59592944e-01f, 4.05838132e-01f,
  -1.73743889e-01f, -7.09987506e-02f, 1.52243510e-01f, -2.14461699e-01f, 3.30172926e-01f, 3.69678438e-01f, 4.03493494e-01f, -2.03706980e-01f, 3.53180230e-01f, 5.00372410e-01f,
  -1.40630528e-01f, 4.43466604e-01f, 5.73625043e-02f, -1.14872091e-01f, -3.57121736e-01f, -1.30289763e-01f, -3.00137281e-01f, -4.06254470e-01f, -2.65106142e-01f, -4.90367189e-02f,
  4.71138149e-01f, -1.90256819e-01f, 3.34241301e-01f, 1.95726052e-01f, -1.07018121e-01f, -5.74741326e-02f, -1.61000714e-01f, -6.13093637e-02f, -1.78877950e-01f, 6.33560941e-02f,
  1.83957532e-01f, 2.42980897e-01f, 5.28746247e-01f, 6.03666902e-01f, 1.14055827e-01f, -1.43616274e-01f, -4.30919565e-02f, 2.60001123e-01f, 2.45495755e-02f, -2.09339172e-01f,
  -2.18574628e-01f, -1.41692892e-01f, 2.26981446e-01f, -2.92709678e-01f, 3.47819358e-01f, 3.72805357e-01f, -1.52770340e-01f, 1.77651241e-01f, 4.03311336e-03f, -2.70889699e-01f,
  2.40494721e-02f, 2.68637419e-01f, -1.17583768e-02f, 2.57487804e-01f, 1.49619341e-01f, 2.84594327e-01f, 6.72035962e-02f, 1.50279701e-01f, 2.17043519e-01f, -2.74294559e-02f,
  -1.01678267e-01f, 1.58861920e-01f, 5.68664968e-02f, -2.59174276e-02f, 4.86781031e-01f, -1.55725554e-01f, 1.73354909e-01f, -2.52204537e-01f, 2.03362897e-01f, 6.00970626e-01f,
  1.19743988e-01f, 7.20974579e-02f, 6.54224679e-02f, 3.73171926e-01f, 2.18846481e-02f, -3.59194726e-02f, -7.17294589e-02f, 2.13401794e-01f, -5.42338908e-01f, -8.51631239e-02f,
  -4.77821007e-02f, 3.39600779e-02f, -3.78200449e-02f, 4.31627423e-01f, 1.06731869e-01f, 1.74371645e-01f, 4.17099655e-01f, 4.05003726e-01f, 2.15271398e-01f, 9.66081768e-03f,
  2.46169657e-01f, -5.32547757e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.64109021e-01f, 1.55683337e-02f, 6.12855554e-02f, 1.84140056e-01f, 2.34458745e-01f, 2.50219792e-01f, 3.76350611e-01f, -2.87601408e-02f, 3.24780494e-02f, 3.19257468e-01f,
  5.36646470e-02f, -7.03662559e-02f, 1.47564143e-01f, 5.21502867e-02f, 1.64709479e-01f, -4.52481546e-02f, -1.04804881e-01f, 7.27670267e-02f, 3.80481720e-01f, -7.37826228e-02f,
  -7.48240249e-03f, 1.59087270e-01f, 1.27660945e-01f, 2.77997464e-01f, -4.40672524e-02f, -1.12013280e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  9.06225410e-04f, -6.15198195e-01f, 1.09381728e-01f, -2.28531912e-01f, -1.55758739e-01f, 1.28061324e-01f, 2.37166956e-01f, -3.43510471e-02f, -2.14646503e-01f, -1.88993260e-01f,
  -8.47726036e-03f, 5.29042110e-02f, 1.44058153e-01f, 1.30998850e-01f, 4.72787693e-02f, 1.05219685e-01f, 8.70848447e-02f, -2.41178110e-01f, -4.94367667e-02f, -3.27984601e-01f,
  -2.25875780e-01f, 2.97663957e-01f, -3.15008722e-02f, -2.79758051e-02f, 1.35209635e-01f, -2.05025245e-02f, -2.29135379e-01f, -7.99282193e-02f, -1.55913129e-01f, -2.00399205e-01f,
  -1.70930520e-01f, -8.78982421e-04f, -6.13259478e-03f, -4.35955338e-02f, -6.14136346e-02f, 1.78882688e-01f, -6.41568542e-01f, 2.69984379e-02f, 1.67264745e-01f, -8.32501426e-03f,
  2.56897748e-01f, -5.78919239e-02f, 6.81274980e-02f, 6.64522871e-02f, -2.38681450e-01f, 2.05249682e-01f, -5.55285290e-02f, 1.36151463e-01f, -7.29781296e-03f, -1.08394608e-01f,
  3.88721339e-02f, -1.16825872e-03f, -2.48320043e-01f, -1.68448269e-01f, -1.83207437e-01f, 1.41988531e-01f, -2.77373761e-01f, 2.09186655e-02f, -1.98309362e-01f, 7.15468600e-02f,
  -2.65078634e-01f, -4.03687149e-01f, -6.34025931e-02f, 1.63683034e-02f, -2.78933406e-01f, -5.34344494e-01f, 1.43865466e-01f, -1.95245191e-01f, -2.75799334e-01f, 2.79774368e-01f,
  9.44657028e-02f, -1.22635793e-02f, 1.03568360e-01f, -1.84214279e-01f, 1.22724593e-01f, 1.40109420e-01f, 1.27738014e-01f, 1.19230207e-02f, -2.71064695e-04f, -1.61576092e-01f,
  6.50973618e-02f, -2.45912746e-01f, 1.81073040e-01f, -2.20106736e-01f, 4.66773333e-03f, 6.39353171e-02f, 2.36944444e-02f, -1.96097463e-01f, -1.00062333e-01f, -3.97464298e-02f,
  2.91560944e-02f, -1.42646134e-02f, 1.03371419e-01f, -1.09515198e-01f, 1.41641786e-02f, -2.42441297e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.92929202e-01f, 4.61227804e-01f, 2.12245032e-01f, 1.77181721e-01f, -6.84485286e-02f, 7.05430582e-02f, -3.16568345e-01f, 6.75633922e-03f, 2.36211233e-02f, 9.55771729e-02f,
  2.97119141e-01f, 1.68402299e-01f, 8.55901614e-02f, 2.77624130e-01f, 1.04389921e-01f, -2.63063699e-01f, -1.17189728e-01f, 5.05554914e-01f, -1.80481434e-01f, 1.64179489e-01f,
  2.45470405e-01f, 2.90126763e-02f, -1.85242500e-02f, -7.38604739e-02f, -8.18204228e-03f, -2.55239522e-03f, 1.82318956e-01f, -3.90168935e-01f, 5.14695048e-02f, 2.50601262e-01f,
  -7.23147541e-02f, 2.36341059e-01f, -1.43740922e-01f, -6.15344718e-02f, -1.14847362e-01f, 3.34298074e-01f, -2.57409364e-01f, 1.48135856e-01f, 6.34451509e-02f, -3.53729874e-02f,
  4.03668620e-02f, 1.06896106e-02f, 1.18388303e-01f, 1.27277598e-01f, -2.37033322e-01f, 6.49057254e-02f, 6.56991601e-02f, -9.06196609e-02f, 2.04847917e-01f, 1.76324636e-01f,
  -6.23378754e-02f, -7.23461434e-02f, 7.38708377e-02f, -2.83747524e-01f, 8.46785679e-03f, 4.78959307e-02f, -1.35885388e-01f, 5.31462729e-02f, -1.17070735e-01f, 6.20919839e-03f,
  -2.41662756e-01f, -1.42281875e-01f, 1.39789835e-01f, 1.23226851e-01f, 5.05675495e-01f, 1.30744770e-01f, 3.70410621e-01f, 5.25094986e-01f, -3.08400691e-01f, -1.41392052e-01f,
  -1.32445633e-01f, 6.20354451e-02f, 1.56241521e-01f, 1.16376989e-01f, 5.17871417e-02f, 1.41988859e-01f, -1.09050386e-01f, -2.15071887e-01f, 4.74708378e-02f, -1.91439748e-01f,
  2.61211637e-02f, 1.15921825e-01f, 1.35181487e-01f, 1.89804375e-01f, 1.40264839e-01f, 3.35268527e-01f, -9.24960002e-02f, -3.53608578e-02f, 1.38770685e-01f, -2.24067032e-01f,
  1.92106575e-01f, -3.16969723e-01f, 4.40644436e-02f, 3.17651093e-01f, -1.25413001e-01f, -1.32858783e-01f, -1.21635735e-01f, 3.08928907e-01f, 3.12525541e-01f, -1.23734571e-01f,
  3.98716092e-01f, 2.74707139e-01f, 1.70077905e-01f, -2.67818682e-02f, -3.13535333e-01f, -3.15608948e-01f, -6.08671606e-01f, -5.21446057e-02f, 2.88479805e-01f, -2.87088811e-01f,
  1.43579915e-01f, 9.46353897e-02f, 2.15547115e-01f, 5.65802678e-02f, 7.17044100e-02f, -1.55666083e-01f, 3.99462968e-01f, -1.44538907e-02f, -1.93132624e-01f, -2.02420905e-01f,
  2.20751226e-01f, 5.34633473e-02f, 7.61926994e-02f, -8.87452886e-02f, 9.91318375e-02f, -5.24780631e-01f, 5.79187833e-03f, -2.49158621e-01f, 8.11592713e-02f, 5.02496183e-01f,
  -1.28284574e-01f, -7.23789275e-01f, 4.16779488e-01f, 4.12630022e-01f, 1.53067127e-01f, 4.91214804e-02f, -1.52010739e-01f, -1.62264660e-01f, -1.26325771e-01f, 2.18543392e-02f,
  3.51136297e-01f, -7.55487084e-02f, 3.79078805e-01f, 8.12599063e-02f, 1.91566214e-01f, 7.18344152e-02f, 2.18534824e-02f, 1.82067081e-01f, 5.98051846e-01f, 1.42033055e-01f,
  -1.98603481e-01f, -2.05104500e-01f, 3.54473948e-01f, 9.10566673e-02f, 2.12385163e-01f, 8.49826783e-02f, 2.82235771e-01f, -9.40268487e-03f, 2.72578865e-01f, -1.24939293e-01f,
  8.94119143e-02f, 7.73007870e-02f, 1.52973071e-01f, -1.75388053e-01f, -4.88664716e-01f, -4.29997712e-01f, 4.01159912e-01f, 5.61752021e-02f, 1.79351404e-01f, -2.17156738e-01f,
  2.72035152e-01f, 1.00899294e-01f, 4.13530022e-01f, -1.97211787e-01f, -2.43505016e-01f, 4.65606242e-01f, -6.04232252e-02f, -2.22915784e-01f, 1.12533420e-01f, -1.60682231e-01f,
  3.48595589e-01f, -3.34062785e-01f, -1.92180321e-01f, -4.14237618e-01f, 1.62681956e-02f, 3.00977498e-01f, -1.04804926e-01f, 1.42921358e-01f, 7.12500140e-02f, 3.19740355e-01f,
  -9.81665701e-02f, 1.79061502e-01f, 3.95457476e-01f, 7.40832150e-01f, 2.82542288e-01f, -9.12740827e-01f, 2.49928176e-01f, -4.43801641e-01f, 4.12684023e-01f, 6.91374242e-02f,
  3.72468919e-01f, -1.34891495e-01f, -3.73053640e-01f, -4.75383937e-01f, 4.89629716e-01f, -1.76826581e-01f, 2.95686990e-01f, 2.55295873e-01f, 3.29522252e-01f, 3.95272858e-03f,
  1.50744796e-01f, -1.32386386e-01f, 4.79146004e-01f, 1.95670664e-01f, -4.00213331e-01f, 3.33240211e-01f, 4.89304870e-01f, -1.41703606e-01f, -1.96034029e-01f, 1.30971730e-01f,
  1.01367317e-01f, -3.28035265e-01f, -7.36848786e-02f, -1.53711706e-01f, -1.17813885e-01f, -3.93603230e-03f, 1.79365709e-01f, 5.98883510e-01f, -5.73278844e-01f, 2.81978417e-02f,
  3.63566548e-01f, -3.93663906e-03f, -2.09299654e-01f, 3.80300105e-01f, -4.49249987e-03f, 2.29945943e-01f, -7.52336383e-02f, 2.13430561e-02f, -1.59718201e-01f, 7.73953199e-02f,
  2.37328038e-01f, -2.46074528e-01f, 6.80026636e-02f, 1.00469775e-01f, -1.42684519e-01f, 1.42285451e-01f, 3.40853512e-01f, -4.81283218e-01f, -1.77166045e-01f, 1.64950743e-01f,
  -2.34449461e-01f, 4.48585361e-01f, 5.38228936e-02f, -5.43578044e-02f, 2.77035236e-01f, 4.12640832e-02f, -2.19557106e-01f, -1.07858822e-01f, -5.88701904e-01f, -1.99272215e-01f,
  2.42570609e-01f, 6.78222120e-01f, 1.54183879e-01f, -1.37644053e-01f, -3.17198157e-01f, 3.18151653e-01f, -3.24491203e-01f, 1.71923697e-01f, 1.57397449e-01f, 1.68082505e-01f,
  -1.28130347e-01f, -8.82399082e-02f, 2.32055143e-01f, 1.81444019e-01f, 2.76468486e-01f, -1.08539194e-01f, -1.40794486e-01f, 2.85914660e-01f, 3.27690840e-01f, -5.68504155e-01f,
  -1.46223083e-01f, 2.30052948e-01f, -2.50285953e-01f, 2.82883257e-01f, 4.25559655e-02f, 6.89381436e-02f, 2.64795423e-01f, 1.40788421e-01f, -2.23003104e-02f, 3.72100800e-01f,
  1.23730168e-01f, -2.88225077e-02f, -5.06946862e-01f, -6.52815327e-02f, -1.19132720e-01f, 7.34959245e-02f, 1.08623207e-01f, 9.23569575e-02f, 8.39299411e-02f, 2.07322836e-01f,
  2.04492837e-01f, -1.79216802e-01f, 4.82622944e-02f, -1.11820370e-01f, 2.22069129e-01f, 1.20904289e-01f, 4.24620092e-01f, 4.01883245e-01f, 3.40639472e-01f, 2.52699971e-01f,
  -1.91273910e-04f, -4.35694277e-01f, 3.46803308e-01f, -1.73994079e-01f, 4.25210148e-01f, -7.87334070e-02f, 1.43127084e-01f, -1.04274731e-02f, -1.24596499e-01f, -1.24935925e-01f,
  1.24448270e-01f, 7.55796582e-02f, -3.30622315e-01f, 2.75706112e-01f, -8.03025886e-02f, 5.56807995e-01f, 8.71688798e-02f, 5.37637621e-02f, 1.75017819e-01f, 2.92774498e-01f,
  -5.05221747e-02f, 2.47385442e-01f, 6.29163533e-02f, -5.37065446e-01f, -3.09145689e-01f, 7.10141286e-02f, -3.82311866e-02f, -3.54290575e-01f, 2.32030988e-01f, 4.50254604e-02f,
  1.86123978e-03f, -1.53603032e-01f, 1.14332475e-01f, 4.24587689e-02f, -8.71468037e-02f, -6.69190139e-02f, 1.23387992e-01f, 1.06433980e-01f, 3.72504517e-02f, 3.26153226e-02f,
  6.01188429e-02f, -4.34803247e-01f, -2.15469718e-01f, 4.93541807e-01f, -3.54303539e-01f, -1.40426606e-01f, 4.87960339e-01f, 4.07561064e-02f, -1.59575522e-01f, -4.10072915e-02f,
  -1.02707632e-01f, 2.55039651e-02f, -9.05881673e-02f, -1.83591750e-02f, 2.35308651e-02f, -1.26357302e-02f, 2.29027107e-01f, 1.85362130e-01f, -2.11064532e-01f, -1.03656523e-01f,
  -8.02427456e-02f, 1.38152644e-01f, 5.62623978e-01f, 1.86547488e-02f, -8.06012303e-02f, -2.46128395e-01f, 2.95042127e-01f, 2.28487015e-01f, 4.10248727e-01f, -9.88084525e-02f,
  2.96550393e-01f, 9.12941527e-03f, 2.33486965e-01f, 4.17508259e-02f, 2.23906323e-01f, 2.29786932e-01f, -5.21436259e-02f, 2.46986076e-01f, 4.95295972e-03f, -4.09290828e-02f,
  -1.08905561e-01f, 5.94888814e-04f, 4.13698733e-01f, 4.01257426e-01f, 2.82116145e-01f, 1.85915291e-01f, 4.18720059e-02f, 1.18404828e-01f, -1.99974224e-01f, 2.02508360e-01f,
  -2.07760245e-01f, -3.09697628e-01f, 3.28445464e-01f, 2.76267260e-01f, -1.25892341e-01f, 1.20623767e-01f, -5.91896027e-02f, 1.11932851e-01f, 1.42745361e-01f, -2.13067725e-01f,
  3.51360202e-01f, -1.58384144e-01f, 2.61460900e-01f, 2.53354102e-01f, -2.22438544e-01f, 1.68940760e-02f, 1.52595444e-02f, 1.11128101e-02f, -7.13455155e-02f, 2.87328690e-01f,
  8.87690425e-01f, 5.69577396e-01f, -3.34327072e-01f, 6.77440390e-02f, 3.02531663e-02f, 2.37899393e-01f, -2.96805233e-01f, 2.26790574e-03f, -3.40755805e-02f, -4.27895188e-02f,
  3.00288290e-01f, -1.54089227e-01f, 1.36801317e-01f, 1.83967110e-02f, 1.36761472e-01f, 1.41152009e-01f, 2.56026536e-01f, 2.56646663e-01f, -2.13056639e-01f, -6.22748099e-02f,
  3.08940709e-01f, -2.77990729e-01f, 2.84401417e-01f, -8.38751644e-02f, 1.65319890e-01f, -3.32570449e-02f, 2.39295475e-02f, -3.08609515e-01f, -2.69355327e-01f, -5.33147752e-01f,
  -1.98079601e-01f, 1.18527003e-01f, 6.43908978e-02f, 6.30292892e-01f, -2.26632521e-01f, -8.08610395e-02f, 2.64335632e-01f, 8.90456736e-01f, 5.79263419e-02f, 3.44607860e-01f,
  -2.33491689e-01f, 1.49413506e-02f, 9.59273279e-02f, -1.81119710e-01f, -3.01209409e-02f, -9.43744034e-02f, 2.75193930e-01f, 4.12721694e-01f, -5.26038051e-01f, -1.37934819e-01f,
  1.96768492e-01f, 3.04133266e-01f, 1.01456106e-01f, -3.88217457e-02f, 4.37991202e-01f, 5.59268147e-03f, 6.88125715e-02f, -4.44860905e-02f, -9.99861285e-02f, -9.03717130e-02f,
  8.97886902e-02f, -1.57635152e-01f, 5.56542158e-01f, -1.90755472e-01f, -2.65062094e-01f, -7.29166493e-02f, 4.04381841e-01f, 9.57294628e-02f, 7.04862177e-01f, -7.27341771e-02f,
  2.17618555e-01f, 1.52094990e-01f, 3.24156195e-01f, 6.77399114e-02f, -2.26260394e-01f, 1.62840158e-01f, 2.64602870e-01f, -1.19655132e-01f, 4.60999399e-01f, -7.33217299e-02f,
  -3.50327849e-01f, 2.30731055e-01f, -1.10211760e-01f, 2.19600787e-03f, 2.14517280e-01f, -1.68180808e-01f, -2.61460468e-02f, 1.97255880e-01f, 6.99457452e-02f, 8.90584439e-02f,
  -1.18171096e-01f, -1.27322152e-01f, 3.36013585e-01f, 1.13441929e-01f, 1.96170911e-01f, 4.51426417e-01f, -7.16102004e-01f, -6.13688886e-01f, 3.54972808e-03f, 6.19595638e-03f,
  2.84020633e-01f, -1.50621561e-02f, 4.67830747e-01f, 1.33248270e-01f, -6.57777563e-02f, 4.35630009e-02f, 4.94937450e-02f, 2.77325697e-02f, -2.17670739e-01f, 4.25787158e-02f,
  2.14718841e-02f, -2.37764861e-03f, 2.64555335e-01f, -4.62552719e-02f, 2.93571860e-01f, -2.12656111e-01f, -1.72893211e-01f, 3.04419041e-01f, 2.32583005e-02f, 6.13468252e-02f,
  -3.64145301e-02f, 3.36799026e-01f, 3.40878189e-01f, 3.94050241e-01f, -4.64507639e-01f, -3.38626206e-01f, -8.92474409e-03f, 2.37618819e-01f, -4.73371536e-01f, 2.22899020e-01f,
  -1.32623956e-01f, -3.67221795e-02f, 4.79430705e-02f, 1.43932849e-01f, -1.18610688e-01f, 2.44049132e-01f, -8.54150131e-02f, -1.38101965e-01f, -3.09166819e-01f, 1.70066282e-01f,
  6.21904172e-02f, -3.15475225e-01f, 3.16605598e-01f, 1.90565318e-01f, -2.06321687e-01f, 1.56597868e-01f, 3.58321518e-01f, -3.43565434e-01f, -2.48124138e-01f, 9.64751095e-02f,
  2.01296315e-01f, -1.20389625e-01f, 2.41220772e-01f, 8.09144527e-02f, -1.15801796e-01f, -3.32076708e-03f, -2.29967222e-01f, -3.39871407e-01f, 3.39069247e-01f, 2.00427398e-01f,
  2.43332624e-01f, 2.54675359e-01f, -2.18239166e-02f, 2.63958853e-02f, 2.77822137e-01f, 1.41032979e-01f, -3.25086452e-02f, 2.21620709e-01f, 7.21386299e-02f, 3.85197997e-02f,
  4.35163751e-02f, -1.11203395e-01f, 1.18641794e-01f, -1.82597086e-01f, 3.19761097e-01f, 3.06137502e-01f, -2.57461122e-03f, 3.86829674e-01f, -1.22719839e-01f, -3.77862714e-02f,
  1.63394988e-01f, -3.09463412e-01f, 2.82679826e-01f, -1.78866219e-02f, 1.12393023e-02f, -3.17493230e-02f, -1.50112182e-01f, -2.62484133e-01f, 2.70958513e-01f, 1.08596988e-01f,
  -3.13136399e-01f, -2.72064954e-01f, 4.53168601e-01f, -2.32801083e-02f, -7.47646615e-02f, 4.88691255e-02f, 1.03315070e-01f, -9.06441659e-02f, 7.86610246e-02f, 1.51788026e-01f,
  -3.77628356e-01f, 2.47549310e-01f, 1.47495836e-01f, 8.25643092e-02f, -5.34698591e-02f, 2.21690208e-01f, -1.10892333e-01f, 3.03009599e-01f, 5.11353882e-03f, 7.06991106e-02f,
  5.03717363e-02f, 3.57379764e-01f, 1.66106239e-01f, 3.04000080e-03f, -8.33024979e-02f, -3.10275376e-01f, 8.49197283e-02f, 2.37455249e-01f, 1.77709252e-01f, 2.19987527e-01f,
  -1.82376951e-01f, -5.72600782e-01f, 4.63770539e-01f, -5.21761142e-02f, 4.22071725e-01f, 3.27470332e-01f, 1.07316980e-02f, 1.56577807e-02f, 7.11618289e-02f, 3.88373770e-02f,
  1.06546119e-01f, 3.28362510e-02f, -2.23253638e-01f, 2.31156930e-01f, 1.87893212e-01f, 9.11158398e-02f, 1.58551842e-01f, 4.17984128e-02f, -7.55602270e-02f, 2.44651884e-01f,
  -2.21033916e-01f, 4.30774748e-01f, 1.09799601e-01f, 7.22626373e-02f, 1.52441934e-01f, -2.09319323e-01f, 1.60610572e-01f, 1.82375386e-02f, 1.33843347e-01f, -2.58076757e-01f,
  -1.26879290e-01f, 3.74874519e-03f, -3.34527157e-02f, 2.53546655e-01f, -2.11209595e-01f, 3.52913886e-02f, 1.91152990e-01f, -4.01581138e-01f, -1.50853604e-01f, -8.65299255e-02f,
  -7.59161413e-02f, -8.40013921e-02f, 3.86915952e-01f, -3.32060121e-02f, 9.77215692e-02f, 1.96390107e-01f, 1.90190509e-01f, 1.12048730e-01f, -1.23837769e-01f, 1.26871288e-01f,
  -5.70805632e-02f, -1.50906727e-01f, 3.10811162e-01f, -1.65943816e-01f, 2.81474233e-01f, -4.08290565e-01f, 1.24872454e-01f, 1.10957541e-01f, 1.94515914e-01f, -6.59726709e-02f,
  1.87067226e-01f, 3.77291173e-01f, 1.15839124e-01f, 2.13070899e-01f, -2.40621626e-01f, -2.78719276e-01f, 4.01161492e-01f, 1.30812421e-01f, 3.64744142e-02f, -1.64576143e-03f,
  -4.08686139e-02f, 9.54127219e-03f, -3.83581489e-01f, -2.13621825e-01f, -1.11883782e-01f, -2.04360962e-01f, -5.09497151e-02f, 1.97330922e-01f, 3.34622115e-01f, 2.09485143e-01f,
  3.59663755e-01f, -1.63830012e-01f, 2.67055002e-03f, -2.57566750e-01f, 3.05858970e-01f, 4.55192387e-01f, -6.21125102e-02f, 5.48227765e-02f, 1.45373657e-01f, 2.14951932e-01f,
  -1.33672491e-01f, 1.36941016e-01f, 7.15162531e-02f, -3.23761821e-01f, 3.16338807e-01f, 1.23080187e-01f, -2.29778767e-01f, -2.64712721e-01f, -1.21556759e-01f, -3.36005777e-01f,
  9.84714508e-01f, 2.54429311e-01f, -2.88102657e-01f, 6.52676076e-02f, -1.83210135e-01f, 1.26347408e-01f, -1.24378175e-01f, -8.73240009e-02f, -2.52008438e-01f, 1.56243518e-01f,
  3.88594419e-01f, -2.25752115e-01f, 6.73915073e-02f, 1.96216390e-01f, 7.35618845e-02f, 1.32336289e-01f, 1.04646631e-01f, 3.27167124e-01f, 4.21906970e-02f, -5.76243475e-02f,
  2.60932237e-01f, -1.27931491e-01f, 2.19456822e-01f, -7.72140771e-02f, 3.20394129e-01f, -2.53373869e-02f, 1.13401115e-01f, 1.63098574e-01f, -2.75870506e-02f, -1.81980297e-01f,
  3.94582272e-01f, 5.15857875e-01f, -1.56167701e-01f, -4.23009604e-01f, 8.50248113e-02f, 2.18959674e-02f, 1.21560290e-01f, -2.34221816e-01f, 4.85124111e-01f, 1.87271029e-01f,
  -1.19642586e-01f, 4.61652070e-01f, 3.49294811e-01f, 8.74312744e-02f, -2.54969075e-02f, 3.65350068e-01f, -2.50755101e-01f, 8.92277211e-02f, -2.28004366e-01f, 1.17012873e-01f,
  1.89906925e-01f, 3.60784739e-01f, -2.18431875e-01f, 4.46120888e-01f, -1.96046293e-01f, 1.33434683e-01f, 2.29773447e-01f, 4.62943166e-02f, 2.49998286e-01f, 4.63795424e-01f,
  -3.07676077e-01f, 5.76175842e-03f, 3.68307561e-01f, -3.95947725e-01f, 3.02363187e-02f, 1.29433513e-01f, 2.06251264e-01f, -9.71319713e-03f, -3.17431957e-01f, -9.64883044e-02f,
  4.70707491e-02f, -1.63471669e-01f, 5.78183234e-01f, 1.40383899e-01f, 1.39598235e-01f, 4.65417445e-01f, 1.65532738e-01f, -4.12021369e-01f, 3.05252612e-01f, -4.16963816e-01f,
  2.12217242e-01f, 5.84542565e-02f, -5.06622009e-02f, 1.55514583e-01f, 1.31255001e-01f, 2.50020146e-01f, -1.96911842e-01f, 4.78095651e-01f, 8.39590579e-02f, -4.49769162e-02f,
  1.57156393e-01f, 1.20290844e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  -1.05445750e-01f, 1.32132858e-01f, 9.65116918e-02f, 1.05630290e-02f, 4.92234901e-02f, 3.47243696e-01f, 2.56181002e-01f, 1.78495631e-01f, -5.13343997e-02f, 2.49027610e-01f,
  2.50992179e-01f, -2.90461909e-02f, 1.64973870e-01f, 2.30645150e-01f, 3.55517745e-01f, 1.50099382e-01f, 1.66616172e-01f, 1.36374801e-01f, 2.05560341e-01f, -1.91980153e-01f,
  -1.58807546e-01f, -1.48581445e-01f, 2.08459258e-01f, -1.67279124e-01f, -4.77029309e-02f, 1.11233637e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.61100447e-01f, 1.65584758e-01f, -1.74896881e-01f, 4.68073301e-02f, 1.26841655e-02f, -1.41246945e-01f, 2.23882318e-01f, 4.91395146e-02f, -5.11586033e-02f, -7.28597690e-04f,
  -5.02843373e-02f, -3.78620058e-01f, -5.52775383e-01f, -3.08521837e-01f, -4.93439920e-02f, 2.28751032e-03f, -2.66866893e-01f, -1.49012124e-02f, -1.47915050e-01f, -5.34599066e-01f,
  1.53082952e-01f, -3.90557915e-01f, 1.96490988e-01f, -1.86084926e-01f, -4.08525467e-01f, 1.64473027e-01f, 1.23746783e-01f, -8.19591526e-03f, -4.15766388e-01f, 1.37054324e-01f,
  1.30757108e-01f, -7.36829877e-01f, 1.50274768e-01f, -4.00361091e-01f, -8.79296288e-03f, -8.02790672e-02f, -6.00511372e-01f, -4.20230329e-01f, 1.32878944e-01f, 2.26757359e-02f,
  1.87794611e-01f, -3.09637278e-01f, 7.25031495e-02f, -5.94619155e-01f, -3.48867625e-01f, -6.16510928e-01f, -5.01883984e-01f, 7.25331232e-02f, -4.83444273e-01f, 5.05983233e-02f,
  1.18670784e-01f, 3.34463954e-01f, 1.92625597e-01f, 6.73355833e-02f, -1.35742515e-01f, -1.92779407e-01f, 1.80375591e-01f, -3.00135370e-02f, 2.53572375e-01f, -6.83537796e-02f,
  5.37570380e-02f, 2.53104329e-01f, -6.90062791e-02f, -2.81978428e-01f, 3.05417329e-01f, -4.63029504e-01f, 2.77435303e-01f, 3.20075721e-01f, 5.21124423e-01f, 4.53816324e-01f,
  -6.79721534e-01f, 6.96327537e-02f, -3.65391344e-01f, -1.64806306e-01f, -9.41067398e-01f, 2.55418092e-01f, -3.80182505e-01f, 3.62072468e-01f, -1.21320359e-01f, -6.14571869e-01f,
  -3.43645848e-02f, -5.20136476e-01f, -6.38261512e-02f, -2.32583627e-01f, 2.64051467e-01f, -2.43558139e-02f, 1.67389601e-01f, 1.67500824e-02f, -6.94764256e-02f, -2.74481028e-01f,
  4.10876125e-02f, -2.13293836e-01f, 6.83960170e-02f, -2.52405494e-01f, 1.93901449e-01f, 2.51488566e-01f, 1.96815860e-02f, 1.34963095e-01f, -2.20202118e-01f, -2.17729345e-01f,
  -1.71459138e-01f, -2.53998004e-02f, 1.25435799e-01f, 2.07928166e-01f, -1.27373517e-01f, -1.03070643e-02f, -5.68711907e-02f, -3.14400308e-02f, -4.62518901e-01f, 3.50171104e-02f,
  1.17761612e-01f, -7.32258320e-01f, 6.22386532e-03f, 4.93241809e-02f, -7.30563641e-01f, -3.99683937e-02f, -4.72765148e-01f, -7.33175039e-01f, 1.96026102e-01f, -5.79031587e-01f,
  -9.11291838e-02f, -6.30005002e-02f, -1.84724167e-01f, 8.00216496e-02f, 1.72451571e-01f, 1.47418603e-02f, 1.80749387e-01f, -1.48846403e-01f, -1.66029572e-01f, 2.08185211e-01f,
  -3.11991304e-01f, -4.10968393e-01f, -3.34771514e-01f, -2.62558639e-01f, -2.72931512e-02f, -2.30960503e-01f, -4.14266944e-01f, -7.21549749e-01f, 1.59977019e-01f, 2.94835865e-01f,
  3.88473958e-01f, -1.97159141e-01f, 1.52593121e-01f, -2.78847963e-01f, -5.08643806e-01f, 2.08509371e-01f, 1.22736968e-01f, 5.61563596e-02f, 1.12030797e-01f, -2.17152178e-01f,
  3.44917625e-02f, 1.04085453e-01f, -5.45559108e-01f, 3.28446962e-02f, -1.81230769e-01f, 2.48649895e-01f, -4.09901232e-01f, 5.42586520e-02f, -8.66497532e-02f, -4.12509665e-02f,
  -2.85554118e-02f, 1.05182484e-01f, 2.43784383e-01f, -2.22655579e-01f, -1.44304112e-01f, 1.54539362e-01f, 3.30322161e-02f, -8.94520953e-02f, 8.48833621e-02f, -1.92139015e-01f,
  5.05863577e-02f, 2.21729457e-01f, -6.47059605e-02f, -1.12972021e-01f, -4.55240190e-01f, 2.80133963e-01f, -1.60080418e-01f, -9.38334092e-02f, 1.32640749e-01f, -3.49838346e-01f,
  9.88697708e-02f, 1.70043066e-01f, 1.41560733e-01f, 2.92328864e-01f, 5.29048033e-02f, -1.85622320e-01f, -1.49222389e-01f, 4.58751135e-02f, -3.27791840e-01f, -4.13786441e-01f,
  -2.27377534e-01f, -4.44235444e-01f, 1.28488034e-01f, -1.85884058e-01f, 1.47972286e-01f, 3.03586036e-01f, -6.67568371e-02f, 3.27699542e-01f, -3.13644886e-01f, 2.02830415e-03f,
  -1.86889201e-01f, 2.78236121e-01f, 1.42335206e-01f, 1.07836783e-01f, 3.11355323e-01f, -3.76393534e-02f, 1.69896886e-01f, 1.51623815e-01f, 2.55134404e-02f, -4.00340825e-01f,
  -3.66807669e-01f, -2.38230750e-02f, -7.85513297e-02f, 3.24311733e-01f, -8.64613593e-01f, -4.10856754e-02f, 1.00114189e-01f, -1.74529478e-02f, -1.58878237e-01f, -8.30307841e-01f,
  -7.15696588e-02f, -2.38770247e-01f, -8.45465183e-01f, 1.72506049e-01f, -2.52278715e-01f, 4.72371727e-01f, -3.03725421e-01f, 2.46083423e-01f, 5.17576784e-02f, 1.85313579e-02f,
  -3.96539897e-01f, -4.10189033e-01f, -4.97612655e-01f, -1.78831607e-01f, 3.35847363e-02f, -4.12704468e-01f, -2.51073632e-02f, 1.96122065e-01f, 3.10923159e-01f, -2.49469638e-01f,
  -2.30167955e-01f, -1.84947848e-02f, -1.64054081e-01f, 1.89255044e-01f, 1.07325912e-01f, 2.97971889e-02f, -2.14491755e-01f, 2.96798617e-01f, 2.39470154e-01f, 6.69869557e-02f,
  2.75198460e-01f, -3.09893116e-02f, 2.01119885e-01f, 3.44224811e-01f, 7.78010767e-03f, -2.08124891e-02f, 1.91920828e-02f, 2.00832844e-01f, -1.11502789e-01f, 1.23607911e-01f,
  2.13208020e-01f, 6.38064323e-03f, -1.23434134e-01f, 6.81068301e-02f, 1.63660362e-01f, -8.79955590e-02f, -2.22224653e-01f, -3.97664696e-01f, -3.19443882e-01f, 3.55906069e-01f,
  1.92774788e-01f, 2.61060238e-01f, 5.41178405e-01f, -1.46843910e-01f, 2.29699209e-01f, 3.32037300e-01f, 2.62015879e-01f, -4.69309241e-02f, -1.03666574e-01f, 3.19621146e-01f,
  1.74124286e-01f, -7.09190965e-01f, -2.97439516e-01f, -6.04308128e-01f, -2.22307265e-01f, -2.09759906e-01f, -8.23818266e-01f, -1.96754746e-02f, -3.80357713e-01f, 1.73442334e-01f,
  3.22128050e-02f, 2.39870369e-01f, 1.66125968e-01f, 4.23161089e-01f, -5.20930231e-01f, -2.57426918e-01f, -5.41252255e-01f, -4.70980287e-01f, -1.16287455e-01f, 1.23829275e-01f,
  2.67071307e-01f, 7.43193328e-02f, -1.41331193e-03f, -1.11175790e-01f, -5.14199972e-01f, -2.64158726e-01f, 3.74920256e-02f, -2.48103678e-01f, -2.60712534e-01f, 3.00459951e-01f,
  -1.80226162e-01f, -3.02397072e-01f, -1.78569362e-01f, -7.45448470e-01f, 1.96939200e-01f, -1.38957515e-01f, 2.00109586e-01f, -2.35392690e-01f, -2.63534244e-02f, 3.11867923e-01f,
  -1.80944890e-01f, 1.77821293e-01f, -2.52742716e-03f, -2.50291973e-01f, 1.20783471e-01f, -3.22413631e-02f, 1.23573259e-01f, 1.61391124e-01f, 1.17727280e-01f, -8.92416040e-07f,
  -8.87605548e-01f, 4.12964523e-01f, -8.54230821e-01f, -4.57527220e-01f, -4.75355119e-01f, -2.11938620e-01f, -6.52734518e-01f, -7.84758985e-01f, 6.74386919e-02f, -1.36486560e-01f,
  -8.56496036e-01f, 2.41386771e-01f, 2.85861880e-01f, -5.73630571e-01f, -4.51138496e-01f, 5.47259413e-02f, -8.78043652e-01f, 5.20990752e-02f, -7.05357373e-01f, -3.67012441e-01f,
  1.41511068e-01f, -2.04033226e-01f, -1.27954513e-01f, -2.17875585e-01f, 5.98345473e-02f, -2.34044194e-01f, 1.35099173e-01f, -6.05108999e-02f, -2.38583282e-01f, -1.20273508e-01f,
  -2.95993239e-01f, 3.61094207e-01f, 3.30184370e-01f, -5.22802174e-02f, -7.98456778e-04f, -1.71052843e-01f, -1.84936628e-01f, 1.43516004e-01f, -1.15598194e-01f, 3.96288723e-01f,
  -3.13498735e-01f, 3.01346272e-01f, -2.65361279e-01f, -2.94847757e-01f, -2.55243480e-01f, -1.28600836e-01f, -1.94114540e-02f, -5.82996845e-01f, -1.73981667e-01f, -5.95351309e-02f,
  2.50645638e-01f, 1.68152019e-01f, -3.91004533e-01f, 2.05695257e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.22357771e-01f, 2.04359498e-02f, 3.24902058e-01f, 1.18661039e-02f, -5.56982346e-02f, 2.31813058e-01f, 1.06065325e-01f, -2.43149698e-01f, -6.66109845e-02f, -1.86729461e-01f,
  -7.96065703e-02f, -7.09650898e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    