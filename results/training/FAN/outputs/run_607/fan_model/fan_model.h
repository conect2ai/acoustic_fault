/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.24558564e-02f, -8.13296288e-02f, 1.73407763e-01f, 1.20229311e-01f, 1.85005933e-01f, -9.07190237e-03f, 3.01963668e-02f, -6.97247013e-02f, -1.03426568e-01f, -6.35219589e-02f,
  1.22673228e-01f, 1.42653078e-01f, 7.08521083e-02f, 9.08897743e-02f, 1.81505695e-01f, -8.10149759e-02f, -1.62923578e-02f, 2.20721841e-01f, 1.73976853e-01f, 2.31164187e-01f,
  1.37027174e-01f, 4.44488913e-01f, 4.02918577e-01f, 2.38174379e-01f, 8.32576212e-03f, 7.86064565e-02f, 1.04365565e-01f, 2.19498929e-02f, 1.53996840e-01f, 1.88246761e-02f,
  -1.47097662e-01f, -5.23085780e-02f, 6.66613877e-02f, -2.53197458e-02f, 3.35508734e-02f, -1.51339829e-01f, 5.03068194e-02f, 1.10274360e-01f, -5.39477207e-02f, 4.92770113e-02f,
  1.80266559e-01f, 7.20001087e-02f, 1.29702225e-01f, 1.46405712e-01f, 8.63643736e-02f, 1.86631121e-02f, -5.30766100e-02f, 6.96590766e-02f, 6.50831386e-02f, -4.44774032e-02f,
  1.52328864e-01f, 2.17733100e-01f, -4.19406928e-02f, 1.26281735e-02f, -7.77520761e-02f, 7.52405822e-02f, -6.23756647e-02f, -9.44811665e-03f, 8.92470106e-02f, -1.48159266e-01f,
  -1.53172553e-01f, 1.44723221e-03f, -1.38743863e-01f, 2.64896508e-02f, -5.11344615e-03f, -4.99714576e-02f, -4.14487422e-02f, 4.80553098e-02f, -9.38776881e-02f, 6.62489757e-02f,
  2.69222278e-02f, 1.21323960e-02f, 2.14812579e-03f, 4.02010716e-02f, 1.30076230e-01f, 3.99498418e-02f, 6.97087646e-02f, 4.12220955e-02f, 9.21766087e-02f, 5.29433154e-02f,
  -9.42494944e-02f, 6.05151691e-02f, 5.77365197e-02f, 1.00577250e-01f, 2.36341101e-03f, 2.79234815e-02f, 2.49410719e-02f, -9.28805918e-02f, -5.20026460e-02f, -2.29785405e-02f,
  -1.98105052e-01f, 1.63223580e-01f, -1.59797464e-02f, -4.70774136e-02f, -8.92775133e-02f, -1.66563839e-01f, 1.42236985e-02f, -1.12743884e-01f, -4.30024229e-02f, 1.51670165e-02f,
  -8.50477889e-02f, 7.58426217e-03f, 4.41481024e-02f, -1.33382961e-01f, -2.18263175e-02f, -3.18623036e-02f, -3.39004174e-02f, 1.01016112e-01f, 3.21610793e-02f, -1.50900772e-02f,
  -1.16546601e-01f, -1.47209749e-01f, -2.37435848e-01f, -1.38360664e-01f, -1.74138173e-01f, 1.49842957e-02f, -1.69698805e-01f, -1.77495018e-01f, -2.22703785e-01f, -4.06827182e-01f,
  -4.51978892e-02f, -4.18560892e-01f, -1.00356065e-01f, 1.16779804e-01f, -7.92504475e-02f, -6.19118139e-02f, -3.86339813e-01f, -8.24580565e-02f, 1.59573525e-01f, -3.56767952e-01f,
  -3.24380584e-02f, 1.95795283e-01f, 1.13030806e-01f, 1.13741525e-01f, 6.66730031e-02f, -3.96319062e-01f, -1.27488628e-01f, 1.88529298e-01f, 2.52983421e-01f, 1.04624130e-01f,
  7.51695260e-02f, 5.65883778e-02f, 3.22793752e-01f, 1.13629758e-01f, -3.02106082e-01f, 6.31888732e-02f, -1.87127337e-01f, -8.45238715e-02f, -6.17060997e-02f, -4.05778557e-01f,
  -1.74266174e-01f, -1.83382764e-01f, 5.11693470e-02f, 3.55144106e-02f, -6.91793486e-02f, -1.03195995e-01f, -3.95707823e-02f, -7.69257098e-02f, -5.51073141e-02f, 1.01327179e-02f,
  -3.16264257e-02f, -1.03228698e-02f, 8.03903714e-02f, 6.13294058e-02f, -6.76779971e-02f, -2.37746555e-02f, 5.27956011e-03f, -1.97351743e-02f, -3.03630792e-02f, -1.13542423e-01f,
  2.79632490e-02f, 2.42945720e-02f, 1.30561553e-02f, -9.19881165e-02f, -9.01499912e-02f, 4.37801257e-02f, -9.13328230e-02f, -7.57025853e-02f, -1.36204973e-01f, -3.75224978e-01f,
  3.29390615e-02f, 8.29952210e-02f, 3.26359533e-02f, 1.29375132e-02f, 4.04323973e-02f, -2.19336096e-02f, 3.53163853e-02f, -1.74762513e-02f, 4.14747819e-02f, -4.47145626e-02f,
  9.14486572e-02f, -1.01493061e-01f, 8.75308365e-02f, -1.36081027e-02f, -3.05583794e-02f, -3.87934297e-02f, 8.83449614e-03f, -7.17025772e-02f, 7.12910667e-02f, 4.91623441e-03f,
  -2.23010741e-02f, 2.93217022e-02f, 3.85679640e-02f, 4.57649268e-02f, 2.34908834e-02f, 8.03111494e-03f, -5.84082343e-02f, -8.56702309e-03f, -4.11419384e-02f, -3.09106428e-02f,
  -3.82077601e-03f, 1.48663327e-01f, -1.97442457e-01f, -9.30472091e-02f, -3.34365387e-03f, 9.19357699e-04f, -8.15268680e-02f, 4.46805265e-03f, -5.28685413e-02f, -9.25425813e-02f,
  -3.10546737e-02f, -1.43477302e-02f, -3.94146219e-02f, -1.43657550e-02f, -4.90335710e-02f, -5.17005287e-02f, -9.65888947e-02f, -5.70478775e-02f, -1.44833056e-02f, -7.41279945e-02f,
  -8.65388811e-02f, -1.05054021e-01f, -2.40638945e-02f, -9.41751301e-02f, -4.29469235e-02f, -4.78738882e-02f, -1.68494076e-01f, -1.37676090e-01f, -8.23096372e-03f, -3.08208317e-01f,
  2.00995222e-01f, 3.86462480e-01f, 1.22342423e-01f, 1.81514561e-01f, 2.67000049e-02f, -5.42256832e-02f, 2.24314630e-01f, -1.55007601e-01f, -1.79808035e-01f, 2.89591193e-01f,
  8.67563784e-02f, -1.21768422e-01f, -1.20716393e-01f, 6.88747328e-04f, 8.42147991e-02f, 3.02491426e-01f, 2.51468569e-01f, 1.40367791e-01f, -3.15809220e-01f, -4.02564257e-01f,
  -1.52588278e-01f, 3.73045281e-02f, -4.12259530e-03f, -1.48445353e-01f, 8.17817003e-02f, -7.18654841e-02f, 2.64497727e-01f, 1.67111039e-01f, 1.33538112e-01f, 6.29991591e-01f,
  2.03970239e-01f, 1.25242874e-01f, -1.10988863e-01f, -4.16062959e-02f, 9.16079059e-02f, -1.30327374e-01f, 2.19918657e-02f, -1.81082413e-02f, -4.18895744e-02f, -4.95307185e-02f,
  1.97740160e-02f, -5.55797815e-02f, -5.59458807e-02f, -2.29182616e-02f, 4.07342650e-02f, 3.42578324e-03f, -6.78919489e-03f, 1.37211420e-02f, 6.69739693e-02f, 7.69392252e-02f,
  8.68243575e-02f, 9.19666737e-02f, 1.23793483e-01f, -9.18065757e-03f, -5.95195517e-02f, -2.88716685e-02f, 4.30940986e-02f, 1.89372730e-02f, 4.30193692e-02f, 1.65209278e-01f,
  -3.70196104e-02f, 4.97933850e-02f, 1.82994939e-02f, -3.05886380e-02f, -6.49306504e-03f, -3.84810828e-02f, 7.71940202e-02f, 2.30026478e-03f, -5.64848185e-02f, 2.76960265e-02f,
  -6.34951070e-02f, -5.88656217e-03f, -1.63239855e-02f, 1.79318991e-02f, 2.83100139e-02f, 7.76690021e-02f, -2.18255352e-02f, 4.59335335e-02f, 2.88120285e-02f, -1.08242538e-02f,
  -3.40459496e-02f, 2.40865611e-02f, 8.18393305e-02f, 4.41822107e-04f, 4.95909266e-02f, 1.41045460e-02f, 6.75344700e-03f, -8.49163309e-02f, -7.01422989e-02f, -6.76252693e-02f,
  -1.67160615e-01f, 7.42595121e-02f, 8.05905685e-02f, -5.91190346e-02f, 1.75742190e-02f, -4.65685949e-02f, 1.07764117e-01f, -3.54572386e-02f, 4.83995155e-02f, 1.80545561e-02f,
  -1.08900834e-02f, 1.11419214e-02f, 1.30270302e-01f, -1.84569345e-03f, -2.49502435e-02f, -4.83418293e-02f, 4.14429866e-02f, 2.11079400e-02f, -2.14300938e-02f, -1.35309966e-02f,
  2.10847259e-02f, -8.96110758e-02f, -8.16708431e-02f, -1.25181809e-01f, -5.68428524e-02f, -7.95406550e-02f, -1.98401988e-01f, -1.20725520e-01f, -8.40382203e-02f, -9.72838551e-02f,
  1.07697055e-01f, -2.94518679e-01f, -4.15148586e-02f, 1.42671734e-01f, -2.19394583e-02f, 4.57652174e-02f, -4.31568056e-01f, -2.75596529e-01f, 1.27344102e-01f, -2.31402919e-01f,
  2.44023249e-01f, 4.45876330e-01f, 2.04416081e-01f, 1.14058122e-01f, -1.49123937e-01f, -4.96065468e-01f, -3.18359613e-01f, -2.33951267e-02f, 4.04043868e-02f, 7.69703612e-02f,
  8.45010653e-02f, -8.44428316e-02f, 7.47559965e-02f, 8.29757452e-02f, -6.69568852e-02f, 2.69576252e-01f, -1.59761161e-01f, -2.71768775e-02f, -1.02744631e-01f, -2.18284637e-01f,
  1.76219478e-01f, -1.36383399e-01f, 1.42681181e-01f, 1.15386657e-01f, 4.35154438e-02f, -3.95440944e-02f, 1.18590333e-02f, 1.22271031e-02f, 1.88305974e-02f, -1.20776929e-02f,
  1.53700069e-01f, 1.37097714e-02f, 5.12225516e-02f, -3.71643826e-02f, 4.02113982e-02f, 1.10432699e-01f, -1.12160333e-01f, -3.25667784e-02f, 9.05523747e-02f, -5.66232763e-02f,
  7.19577447e-02f, 2.26972271e-02f, -1.04509801e-01f, 1.53514156e-02f, -5.88511899e-02f, 2.02111945e-01f, -4.28944342e-02f, 4.28984240e-02f, 7.84857571e-02f, -7.43035041e-03f,
  -5.19883931e-02f, 4.87485826e-02f, -6.09440450e-03f, -1.22721605e-01f, 8.53603613e-03f, -5.14408108e-03f, 3.71501930e-02f, -1.58872977e-02f, -3.25639546e-02f, -7.85716102e-02f,
  1.68600027e-02f, -7.09837675e-02f, 1.33074529e-03f, -4.49092500e-02f, 6.93927333e-02f, -8.25880282e-03f, 6.06522448e-02f, -6.08120766e-03f, 6.94501922e-02f, -1.00587696e-01f,
  -1.38141448e-03f, 5.19129522e-02f, 2.91832667e-02f, -3.44843902e-02f, 3.56766246e-02f, -1.01224110e-02f, 2.95373844e-03f, -1.03961252e-01f, -5.32217091e-03f, 4.97177318e-02f,
  1.10676363e-01f, 2.19522864e-01f, 1.91461667e-02f, -5.51830791e-03f, 2.55465265e-02f, 2.54697036e-02f, 1.59175098e-01f, 3.44179757e-02f, 1.83378398e-01f, 7.16848159e-03f,
  6.22679107e-02f, 3.26649286e-02f, 3.34974681e-03f, 4.55175340e-02f, 1.07772708e-01f, 6.68758303e-02f, 9.12494678e-03f, 1.29122198e-01f, 5.68490895e-03f, 9.40655544e-02f,
  -5.34845926e-02f, -9.30394083e-02f, -6.85845092e-02f, 2.02390505e-03f, 1.09534934e-01f, 1.17398106e-01f, -3.30054536e-02f, 1.43443450e-01f, 5.82435168e-02f, -6.60828575e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.64092267e+00f, 1.68487892e-01f, 2.50819355e-01f, -6.32329106e-01f, -1.43473610e-01f, 1.79175198e-01f, 3.12782884e-01f, 1.39471944e-02f, -2.46951491e-01f, 1.43856809e-01f,
  1.11372910e-01f, -6.99664578e-02f, 6.59684017e-02f, 1.13375306e-01f, 5.96762672e-02f, 2.43058726e-01f, 7.51137286e-02f, -1.64471656e-01f, -6.90404028e-02f, 6.30104095e-02f,
  4.74775545e-02f, -4.19894725e-01f, -6.23487473e-01f, -1.59845084e-01f, 6.21806383e-02f, 7.71999881e-02f, 1.16003297e-01f, -9.30359662e-02f, 3.23692411e-01f, 1.30296946e-01f,
  6.43084168e-01f, -1.87178895e-01f, 6.04935996e-02f, 5.45852992e-04f, 1.00997202e-01f, -9.17923078e-02f, 3.95395793e-02f, 1.76075809e-02f, -2.89244000e-02f, 5.56718856e-02f,
  -2.84289178e-02f, 3.74910934e-03f, -5.47038279e-02f, -1.46653503e-03f, -9.00754258e-02f, -3.92708294e-02f, -7.10356310e-02f, -9.29070171e-03f, 5.59427068e-02f, 2.87055910e-01f,
  7.42763430e-02f, -8.22344422e-03f, 9.74449217e-02f, 1.00410849e-01f, -6.19632863e-02f, -4.32494618e-02f, 1.89513236e-01f, 8.34281594e-02f, 9.60811451e-02f, -3.48194055e-02f,
  -8.08147807e-03f, 5.53694926e-02f, 6.57444894e-02f, -1.56530023e-01f, 2.24092882e-03f, 8.61783605e-03f, -1.81323441e-03f, 9.55089703e-02f, -3.61583643e-02f, -8.99345130e-02f,
  1.92087051e-02f, 1.36401746e-02f, 3.95493675e-03f, -1.60706148e-01f, 5.91980852e-02f, 7.73641234e-03f, 8.31583589e-02f, 6.46853149e-02f, -1.93663109e-02f, -2.52086222e-02f,
  -4.29339297e-02f, -8.40163305e-02f, -1.78327914e-02f, 9.06971768e-02f, 5.54130040e-02f, 2.84867845e-02f, -1.06519580e-01f, 4.04867493e-02f, -2.98318570e-03f, -7.12220967e-02f,
  2.20551670e-01f, -7.47280419e-02f, 9.57466941e-03f, 6.54437914e-02f, -1.41193438e-03f, 4.52734269e-02f, -1.27375230e-01f, -1.77126508e-02f, 2.00356469e-01f, 1.42431380e-02f,
  4.57357019e-02f, -6.87949583e-02f, 2.95275599e-02f, 2.79372260e-02f, -7.13467598e-02f, 2.55423319e-02f, -2.58297194e-02f, 2.06569862e-02f, 1.97422922e-01f, 6.89557195e-02f,
  4.69103381e-02f, -1.79082025e-02f, 4.88890074e-02f, 1.09340198e-01f, 2.48656683e-02f, 9.04829800e-02f, 1.30188614e-01f, 1.54956102e-01f, 1.75860330e-01f, 1.47814438e-01f,
  -2.11147845e-01f, 2.67510593e-01f, -3.55228707e-02f, -2.83648163e-01f, 4.78421777e-01f, 4.87696648e-01f, 5.47065914e-01f, 2.77187228e-01f, -9.97407138e-02f, -7.50040039e-02f,
  1.53971359e-01f, -1.04340024e-01f, -3.13518435e-01f, -2.79172026e-02f, 2.23797053e-01f, -3.46667506e-02f, -3.71809602e-01f, -2.79025584e-01f, 1.47202983e-01f, 4.51350987e-01f,
  7.82672539e-02f, -9.77676436e-02f, -1.60955954e-02f, -1.22977972e-01f, -1.38085023e-01f, -5.18095016e-01f, -3.91044587e-01f, 2.38431282e-02f, 2.11269960e-01f, -6.12641037e-01f,
  -1.64092794e-01f, 2.37334639e-01f, -1.29503086e-01f, 6.69811293e-03f, 1.30807394e-02f, -4.91052344e-02f, 3.75084532e-03f, -1.06985748e-01f, 3.11583206e-02f, -7.29391351e-02f,
  3.82264294e-02f, 1.51176676e-01f, 6.82622492e-02f, 8.56419131e-02f, 1.38590112e-01f, 9.70373303e-02f, -3.07028443e-02f, -6.58173189e-02f, -4.18775789e-02f, 1.39932349e-01f,
  -9.30831134e-02f, 1.85385615e-01f, 1.84784308e-01f, 1.22805864e-01f, 2.72915453e-01f, -8.74290243e-02f, 1.66323259e-01f, 1.82365298e-01f, 9.90040675e-02f, -2.37335637e-01f,
  -5.15041500e-02f, -1.22095551e-02f, 3.60887051e-02f, 4.98220511e-03f, 3.41526307e-02f, -1.91109460e-02f, -1.90658495e-02f, 5.58750480e-02f, 1.93331148e-02f, 1.86270960e-02f,
  -4.89033870e-02f, 3.18400823e-02f, -2.96561476e-02f, -1.41339330e-02f, -1.17208116e-01f, -2.63988357e-02f, 6.11708090e-02f, -4.95936126e-02f, 1.42015396e-02f, 2.91420985e-02f,
  2.15195194e-02f, 6.59323633e-02f, 8.90701637e-03f, 1.97090115e-02f, 4.60328199e-02f, -3.71638499e-02f, -7.83067383e-03f, 1.84849933e-01f, 2.98844837e-02f, 4.44073370e-03f,
  -1.17784724e-01f, 6.41905442e-02f, -2.54256785e-01f, 5.78427240e-02f, -7.97822922e-02f, 4.82521616e-02f, -1.07365958e-01f, -4.90479842e-02f, -5.98356090e-02f, -3.06368228e-02f,
  5.74531257e-02f, -4.80001718e-02f, -7.52285793e-02f, -2.08606776e-02f, -2.61023790e-02f, 1.14471801e-02f, 6.94533512e-02f, -1.06632523e-01f, 1.10527076e-01f, 8.05262923e-02f,
  -1.35501269e-02f, -1.18833832e-01f, -5.11558764e-02f, -1.67715460e-01f, -1.20190121e-01f, -1.82111740e-01f, -1.99092776e-01f, -9.66478065e-02f, -4.68634330e-02f, -4.72038239e-01f,
  1.21713555e+00f, -5.08902296e-02f, 3.86575490e-01f, 1.37865230e-01f, -2.79821068e-01f, -1.55926362e-01f, -6.58991113e-02f, -7.21696541e-02f, -1.14108250e-01f, -6.61412030e-02f,
  -1.73723549e-01f, 1.22184912e-02f, 4.05462086e-02f, 1.29107907e-01f, 3.54587168e-01f, -4.98520844e-02f, -5.42368852e-02f, 4.63894725e-01f, 3.63050401e-01f, 3.72354835e-02f,
  -1.71239436e-01f, 8.72126818e-02f, 4.04838622e-01f, 1.33360922e-01f, -4.21227328e-02f, -1.91924825e-01f, -2.18740836e-01f, -4.10312973e-02f, -5.18227406e-02f, 4.37668353e-01f,
  4.79136974e-01f, 3.37912917e-01f, -1.90671191e-01f, -1.16119020e-01f, 4.96986359e-02f, 7.88117722e-02f, 6.46519959e-02f, 1.92797147e-02f, -9.85809788e-02f, 1.25683695e-02f,
  -3.56798694e-02f, 5.70824295e-02f, 3.32420580e-02f, -2.94268113e-02f, 1.50851216e-02f, 6.32805228e-02f, 3.77441430e-03f, 1.55583858e-01f, -8.92982855e-02f, 4.70787995e-02f,
  -2.14797050e-01f, -6.93803504e-02f, -5.34261204e-02f, -1.89319268e-01f, 1.47238389e-01f, 3.57876369e-03f, -6.25994653e-02f, 1.52805686e-01f, 5.64232608e-03f, 7.11140409e-02f,
  -3.25056873e-02f, 1.09853409e-01f, 3.51566412e-02f, -9.06679779e-02f, 1.97579693e-02f, -7.85464868e-02f, 4.52239439e-02f, -2.88933655e-03f, -3.33532132e-03f, 6.33002594e-02f,
  -8.77595171e-02f, 3.19797383e-03f, -6.88855276e-02f, -2.64679864e-02f, 4.16028779e-03f, -2.47583687e-02f, -1.07439666e-03f, 3.62292007e-02f, -1.29220694e-01f, 1.56295002e-02f,
  1.45408763e-02f, 1.07469015e-01f, -3.94042954e-02f, 5.58383726e-02f, 4.93866019e-03f, 4.72150296e-02f, 2.96523445e-03f, -3.58428545e-02f, -5.22553921e-02f, -3.16390246e-02f,
  -2.23884359e-01f, -3.59475464e-01f, 1.09709732e-01f, 1.87910438e-01f, 1.33993447e-01f, -4.23061736e-02f, -3.82735245e-02f, -4.21089083e-02f, 2.24173837e-03f, 5.92910089e-02f,
  -5.68127222e-02f, 5.55110388e-02f, -3.71086709e-02f, -1.99388321e-02f, -2.18759570e-02f, -1.13028467e-01f, -4.20276448e-02f, 9.60673019e-02f, 8.30618590e-02f, -1.75091755e-02f,
  -6.68079481e-02f, -4.39867042e-02f, -1.67338595e-01f, -1.66601554e-01f, -1.85780391e-01f, -2.11733773e-01f, -1.78343475e-01f, -3.34923975e-02f, -1.46847576e-01f, -3.80371034e-01f,
  -6.70216441e-01f, 2.42081046e-01f, -5.80848217e-01f, 4.67883706e-01f, 4.39225018e-01f, 1.40072557e-03f, -1.27505198e-01f, -1.75479636e-01f, 1.19670115e-01f, 2.71337479e-01f,
  1.80334434e-01f, 3.39402407e-01f, 1.41311958e-01f, 6.03770651e-02f, -2.04883516e-01f, 1.30527183e-01f, 3.70986700e-01f, -2.63822168e-01f, -5.14334440e-01f, 9.81525108e-02f,
  5.68678975e-01f, 1.48245916e-01f, -3.41983825e-01f, -7.42871463e-02f, 5.04651904e-01f, 2.84299463e-01f, -7.42881075e-02f, 1.05258701e-02f, 1.45513058e-01f, 8.60447586e-01f,
  -9.86267030e-02f, -2.88121492e-01f, -1.91472277e-01f, 2.85200536e-01f, -2.93110870e-03f, -1.85260043e-01f, 3.02703939e-02f, -1.42378181e-01f, 9.11963880e-02f, 5.99824749e-02f,
  1.64960340e-01f, 8.65513608e-02f, 2.65158296e-01f, 1.50023717e-02f, 5.74273840e-02f, 4.36161570e-02f, -2.42874295e-01f, -2.23923877e-01f, -1.43402517e-01f, 6.14462122e-02f,
  7.70772457e-01f, 3.87284935e-01f, -1.40464231e-01f, -9.52111706e-02f, -1.48429185e-01f, 1.34045869e-01f, -1.44237310e-01f, 2.85498407e-02f, -3.43849897e-01f, 3.28349359e-02f,
  5.12967408e-02f, 5.74142374e-02f, -9.72384214e-02f, 4.26036753e-02f, 2.17301641e-02f, -9.09732878e-02f, -3.17888707e-02f, 4.95912321e-02f, 1.42876029e-01f, -6.49221614e-02f,
  -1.51609406e-01f, -8.78537819e-02f, -6.03429154e-02f, -1.19511284e-01f, 6.47662655e-02f, 1.73059758e-02f, -3.77181247e-02f, -8.41321126e-02f, -1.02892347e-01f, 1.12001337e-01f,
  7.17504025e-02f, -4.89652939e-02f, 6.64701164e-02f, 3.04149128e-02f, 6.69838339e-02f, 1.37604438e-02f, 1.95087284e-01f, 5.88831343e-02f, 1.35616407e-01f, 1.97655082e-01f,
  -1.13528788e-01f, -2.12014019e-01f, 1.97611019e-01f, 5.36567681e-02f, 3.55693465e-03f, -2.31753550e-02f, 1.06127441e-01f, -9.51537043e-02f, 1.03547975e-01f, 2.23416160e-03f,
  -7.21445456e-02f, -2.28853047e-01f, -7.82477334e-02f, -9.92862210e-02f, -1.39011472e-01f, -6.31422848e-02f, 4.52304408e-02f, -6.09345101e-02f, -1.59239456e-01f, -1.28997266e-01f,
  1.66377630e-02f, -9.16414931e-02f, -2.12100655e-01f, -1.42138064e-01f, -1.91454515e-02f, -1.73403807e-02f, -3.07000905e-01f, -2.47519329e-01f, -5.44444144e-01f, -5.09216070e-01f,
  -1.01033136e-01f, -4.67216790e-01f, 1.73867896e-01f, 1.42266735e-01f, 5.45119107e-01f, 5.17899334e-01f, 4.50232565e-01f, 2.20962018e-01f, 1.27488419e-01f, 8.83562788e-02f,
  -2.91710526e-01f, -2.88915873e-01f, -2.86416948e-01f, -2.42454350e-01f, -2.25018367e-01f, 3.24361086e-01f, 2.67835528e-01f, 1.33867517e-01f, 4.50343847e-01f, 3.32368255e-01f,
  2.45069891e-01f, 1.64968178e-01f, -1.42395720e-01f, -9.37737823e-02f, 5.84722869e-03f, 3.33320439e-01f, 1.34593919e-01f, -1.47291496e-01f, -2.76348349e-02f, -3.87763195e-02f,
  7.13032763e-03f, -3.60900253e-01f, 4.47320230e-02f, -1.49720147e-01f, -1.05157280e-02f, -5.25694229e-02f, 1.84472837e-02f, -7.37363920e-02f, -2.56836526e-02f, -2.36378703e-03f,
  -5.81560582e-02f, -7.98366442e-02f, -4.24319245e-02f, -1.38019592e-01f, 5.78308702e-02f, 7.51080066e-02f, -2.33624786e-01f, -1.49880260e-01f, -1.59714401e-01f, -3.11090685e-02f,
  -1.05444334e-01f, -3.90601754e-02f, 1.43959736e-02f, 1.02063358e-01f, -4.13050083e-03f, 8.34297314e-02f, -1.64372623e-01f, -2.33338121e-02f, -1.13959327e-01f, -7.89955445e-03f,
  7.55082294e-02f, 5.14565334e-02f, 7.55051449e-02f, -2.66357176e-02f, 9.38908681e-02f, 1.36498001e-03f, 7.12947026e-02f, -1.09155700e-01f, 8.29386786e-02f, 1.11598752e-01f,
  2.62801838e-03f, 2.64749979e-03f, -4.47208583e-02f, -3.97838093e-02f, -7.97879696e-03f, 7.04287319e-03f, 1.41240045e-01f, -1.56146631e-01f, -1.43549830e-01f, -1.84651725e-02f,
  -1.13289859e-02f, 9.22598541e-02f, 1.99333834e-03f, -7.42614046e-02f, -2.84902211e-02f, -1.04472280e-01f, 4.17905711e-02f, -9.98704880e-02f, -2.86330841e-02f, 2.69292723e-02f,
  1.92860171e-01f, -1.76539600e-01f, 6.89936206e-02f, 9.92687885e-03f, -1.61097816e-03f, -1.47059649e-01f, 4.72703483e-03f, -1.09433368e-01f, 2.91448692e-03f, 3.88335846e-02f,
  -3.16135101e-02f, 7.56368320e-03f, -5.92951775e-02f, -7.01502338e-02f, 1.41755387e-01f, 8.69312584e-02f, -4.13401984e-02f, 1.08072005e-01f, -1.66046202e-01f, -4.18302454e-02f,
  -1.58949457e-02f, 2.54976928e-01f, 2.65572757e-01f, 8.74775499e-02f, 3.12361605e-02f, 2.45291591e-01f, 1.20641507e-01f, 2.30350181e-01f, 8.21477696e-02f, 2.51837969e-01f,
  9.85688746e-01f, -5.05584896e-01f, -3.02102836e-03f, 1.64305702e-01f, -8.89946222e-02f, 1.51615307e-01f, -1.32524863e-01f, 8.92818943e-02f, 2.37153247e-01f, 3.79090197e-02f,
  -7.63924047e-03f, 3.07570517e-01f, 2.68957019e-01f, 4.81958613e-02f, 2.62676865e-01f, -1.41289562e-01f, -6.74608722e-02f, 1.83297589e-01f, 3.75078589e-01f, 1.96022898e-01f,
  -3.85274626e-02f, -2.05446839e-01f, 1.24418959e-01f, -6.64313063e-02f, -1.89236194e-01f, 1.32356897e-01f, -4.64577377e-02f, -7.94856697e-02f, -1.67961940e-01f, -2.33941898e-01f,
  1.50763229e-01f, 1.32678822e-01f, 2.84392565e-01f, 1.47510141e-01f, -1.71147082e-02f, 8.66289586e-02f, 8.74631032e-02f, -5.49417734e-02f, 7.69290030e-02f, 7.38056749e-02f,
  2.89444420e-02f, 8.53519514e-02f, 1.99936591e-02f, -6.36262149e-02f, -5.41555509e-03f, 5.74298855e-03f, -3.58121954e-02f, -1.19903972e-02f, 3.77513990e-02f, 3.56640220e-02f,
  -7.48556703e-02f, 2.48456765e-02f, -2.26195641e-02f, 7.70399943e-02f, 1.14339277e-01f, 1.24599472e-01f, -4.71603721e-02f, 3.18410620e-02f, 1.36464894e-01f, 6.45791292e-02f,
  4.58359383e-02f, 4.68949713e-02f, -9.07892510e-02f, -4.68279645e-02f, 4.22319211e-02f, 5.81992744e-03f, 8.69427696e-02f, -1.68784484e-02f, 8.18484724e-02f, 6.09548064e-03f,
  -1.03019685e-01f, -2.25845668e-02f, -1.12089992e-01f, 1.05440646e-01f, -4.58438732e-02f, -2.71690935e-02f, -2.27238331e-03f, 7.02330726e-04f, -9.55723748e-02f, 1.70196928e-02f,
  1.46995336e-02f, 1.18567601e-01f, 2.25035995e-02f, -2.29829907e-01f, -7.91452453e-02f, 3.71147096e-02f, 1.65047213e-01f, -3.22135426e-02f, 1.02544567e-02f, 1.25183806e-01f,
  -1.91459194e-01f, 2.66904086e-01f, 2.44105697e-01f, 3.33264284e-02f, 7.80458152e-02f, 7.15997368e-02f, 1.23078376e-01f, -4.22695018e-02f, -6.51137605e-02f, 3.30969342e-03f,
  5.04367687e-02f, 9.65775698e-02f, -1.52636006e-01f, 2.29601040e-02f, -1.13404328e-02f, 1.00182764e-01f, -1.09431148e-01f, 1.53147161e-01f, 3.19704078e-02f, -1.56718984e-01f,
  -1.03824086e-01f, 1.73069030e-01f, 3.05273443e-01f, 1.94386840e-01f, 2.69229323e-01f, 2.81876504e-01f, 5.64003736e-02f, 7.06439540e-02f, 1.80514634e-01f, 2.38392968e-02f,
  1.04760957e+00f, -1.29020408e-01f, -4.73514736e-01f, 1.00832567e-01f, -7.77248293e-02f, -8.40577111e-03f, -1.10908844e-01f, -1.00091528e-02f, 2.41919830e-01f, 2.43108105e-02f,
  6.57732412e-02f, 2.84265608e-01f, 3.69195789e-01f, 1.99907988e-01f, 2.75605381e-01f, -4.05471511e-02f, -7.11376369e-02f, 3.62242050e-02f, 5.62963448e-02f, -1.62731260e-01f,
  -9.50509384e-02f, -2.29873210e-01f, -1.62308197e-02f, -8.73654038e-02f, -4.20176476e-01f, 4.19214070e-02f, -3.35228115e-01f, -3.60448986e-01f, -2.92730123e-01f, -2.16192335e-01f,
  2.92462055e-02f, -1.53039277e-01f, 5.55755571e-02f, 1.64397936e-02f, -1.77851900e-01f, 5.08000702e-02f, 3.82630825e-02f, -6.46846518e-02f, -2.26701368e-02f, -3.51976836e-03f,
  -1.86323702e-01f, -1.71352886e-02f, 1.32867619e-01f, -4.90148067e-02f, -2.20868856e-01f, -4.87671234e-02f, -1.57614186e-01f, -1.78990252e-02f, 3.79578061e-02f, 8.89761560e-03f,
  -4.07114960e-02f, -1.35719746e-01f, -2.27043293e-02f, -5.45836687e-02f, 1.27791706e-02f, 8.08776841e-02f, -2.67037511e-01f, -1.23279445e-01f, -8.95565972e-02f, -1.01294488e-01f,
  3.24821323e-02f, 6.97483793e-02f, 9.52312630e-03f, 1.96618540e-03f, 9.13793221e-02f, -5.58870519e-03f, 8.88319593e-03f, -4.42562103e-02f, 9.57813039e-02f, -5.12832105e-02f,
  -8.98257270e-02f, 4.06861380e-02f, 7.20698899e-03f, 5.43149374e-02f, -4.19576885e-03f, 7.68789575e-02f, -6.67479187e-02f, -6.53387085e-02f, 5.21535352e-02f, 3.17885727e-02f,
  -5.46670798e-03f, 8.32030028e-02f, -9.78163481e-02f, -1.13701247e-01f, -6.05538301e-03f, -3.05067636e-02f, 2.66542230e-02f, 2.26431061e-02f, 2.19215024e-02f, 9.49661955e-02f,
  2.79345155e-01f, 2.21952841e-01f, 7.16934204e-02f, 5.12248240e-02f, -6.16875216e-02f, -1.47866905e-01f, 2.09191162e-03f, -6.76061884e-02f, -1.48468241e-01f, -2.84339711e-02f,
  -1.11437969e-01f, -6.02102242e-02f, 8.11190978e-02f, -1.10966668e-01f, -1.49069941e-02f, -6.88987672e-02f, -3.17254364e-02f, 1.92497969e-01f, -3.01609188e-02f, -8.91383886e-02f,
  -7.01508373e-02f, 2.83843398e-01f, 3.83889973e-01f, 2.47165307e-01f, 5.85478954e-02f, 2.64522403e-01f, 1.26828223e-01f, -4.03216854e-02f, 2.93055832e-01f, 2.09492356e-01f,
  -9.68019962e-01f, 4.40758377e-01f, 5.54321148e-02f, -3.00481319e-01f, 3.04923326e-01f, -1.99889336e-02f, 1.45428836e-01f, 6.58283883e-04f, -9.98640507e-02f, 1.88353911e-01f,
  1.89078912e-01f, -2.91252583e-02f, -5.86413108e-02f, 1.10689573e-01f, -1.57227740e-02f, 2.83830762e-01f, -9.70466658e-02f, -2.61492997e-01f, 3.43268551e-03f, 2.84466863e-01f,
  2.40801051e-02f, -4.37514544e-01f, -6.33409381e-01f, -1.37661219e-01f, 1.70613304e-01f, -1.11931548e-01f, -8.39841366e-02f, -3.87703627e-01f, 1.47161171e-01f, -2.96460569e-01f,
  4.54325788e-02f, 1.89019740e-01f, 7.91598782e-02f, -2.11523473e-01f, -7.57928267e-02f, -1.70243695e-01f, 1.14936419e-01f, -2.26684049e-01f, -4.29647192e-02f, -7.34166801e-02f,
  -1.56314194e-01f, 1.39207333e-01f, -1.92612886e-01f, -5.10136709e-02f, -4.37797979e-02f, -1.99329611e-02f, -2.52844006e-01f, 2.98414193e-02f, -7.60510266e-02f, 1.90019920e-01f,
  -3.62376906e-02f, 1.89750731e-01f, 1.20944485e-01f, 5.64622618e-02f, 2.98934360e-03f, 2.80386601e-02f, 1.25733048e-01f, 1.36176636e-02f, 1.91586703e-01f, -4.65527810e-02f,
  4.13385890e-02f, -3.10091954e-02f, 7.33290091e-02f, -4.44090692e-03f, -2.53721029e-02f, -2.55942661e-02f, 4.00801152e-02f, -1.03430182e-01f, 8.53693113e-02f, -1.45049125e-01f,
  5.92290871e-02f, -4.71245907e-02f, 7.09411949e-02f, -5.68867475e-02f, 8.84569064e-02f, 3.27721843e-03f, -1.00747980e-01f, -1.02543809e-01f, 9.07502994e-02f, -4.75726500e-02f,
  -7.97308758e-02f, 9.32045951e-02f, -6.91746082e-03f, -9.57534909e-02f, -7.11536501e-03f, 9.18230116e-02f, 6.04632534e-02f, 3.05529609e-02f, -7.66270468e-03f, 1.03122935e-01f,
  -3.42489868e-01f, 8.52388367e-02f, 2.13377718e-02f, 4.08417918e-03f, 9.60425958e-02f, -6.88449144e-02f, -1.51414182e-02f, 5.40238395e-02f, -5.25595844e-02f, -1.12284862e-01f,
  1.56568307e-02f, -1.49505854e-01f, 5.59889339e-02f, 3.11117060e-02f, -3.50905657e-02f, -8.51070732e-02f, 5.52443676e-02f, -1.34948820e-01f, 5.57548292e-02f, -6.50558174e-02f,
  -1.83322206e-02f, -7.12885857e-02f, -2.51441747e-01f, 7.38419443e-02f, 1.18840225e-01f, 1.43622458e-01f, -9.78554264e-02f, -1.19727790e-01f, 4.17591929e-02f, -2.34821051e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -5.70340976e-02f, 1.54627085e-01f, 6.30128860e-01f, 4.04733747e-01f, 2.35116646e-01f, -1.99572712e-01f, 2.74295449e-01f, 3.23804021e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -6.83298558e-02f, -1.81111604e-01f, -1.58191606e-01f, -1.66434590e-02f, 2.35022932e-01f, -1.88171849e-01f, 1.10295810e-01f, -6.88635791e-03f, -8.49038959e-02f, 4.52758938e-01f,
  3.70512903e-02f, 3.49957585e-01f, -7.78612420e-02f, -4.74818379e-01f, 7.43287504e-02f, 2.65466154e-01f, -2.61719804e-03f, -1.25379473e-01f, -2.52530158e-01f, -3.10248315e-01f,
  1.93596110e-01f, 4.91530336e-02f, 2.58294135e-01f, 8.52770582e-02f, -3.40570867e-01f, 2.96699814e-03f, 3.48213643e-01f, 6.80060461e-02f, -4.92914677e-01f, -2.47003496e-01f,
  2.15099633e-01f, -2.99568027e-01f, -5.29188700e-02f, -8.89840126e-02f, -4.49688226e-01f, -1.56045958e-01f, -3.37793417e-02f, 5.34814477e-01f, 1.04592703e-01f, 2.63105869e-01f,
  -1.30524173e-01f, 3.91198337e-01f, 2.43927598e-01f, 1.39258727e-01f, -5.89501858e-01f, 2.46260479e-01f, 4.20875043e-01f, -1.46086425e-01f, 1.08841071e-02f, -8.65273476e-02f,
  1.20517509e-02f, 7.17482120e-02f, 9.67759117e-02f, 6.47140592e-02f, 9.09234956e-02f, 7.71269901e-03f, -1.59874201e-01f, 5.83627641e-01f, -8.17191079e-02f, 2.16756627e-01f,
  -2.01357275e-01f, -5.46408109e-02f, -2.95478255e-01f, 2.33480588e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.46909490e-01f, 1.01171732e+00f, 1.18733430e+00f, 2.88318694e-01f, -1.93036780e-01f, -5.41469455e-01f, -1.54181004e-01f, -5.73182344e-01f, 6.62623703e-01f, 4.83568013e-02f,
  -5.74613571e-01f, 8.52074265e-01f, 6.61560237e-01f, -4.44903910e-01f, 2.22119480e-01f, 7.86360800e-01f, 9.50592533e-02f, 6.99580088e-02f, 8.90419930e-02f, 3.37691605e-01f,
  5.09827673e-01f, -2.14957312e-01f, 1.02962315e+00f, -4.66826797e-01f, -3.29926103e-01f, 6.75095260e-01f, 8.90715480e-01f, -3.94612461e-01f, 1.47194684e-01f, 2.93434076e-02f,
  -4.91862804e-01f, -3.20022583e-01f, 1.32841125e-01f, 2.74382144e-01f, 1.02442883e-01f, -1.61925465e-01f, 3.32179129e-01f, -6.52697012e-02f, 8.96830380e-01f, 5.20630740e-02f,
  1.18595235e-01f, 1.60351068e-01f, 5.89763045e-01f, 6.10809624e-01f, 3.25751245e-01f, -3.43198888e-02f, 1.16944320e-01f, -7.29920268e-01f, -1.24061443e-01f, 3.89555484e-01f,
  6.03685558e-01f, 1.57130331e-01f, -1.93925589e-01f, 4.64670628e-01f, -1.28581658e-01f, 2.82528520e-01f, -5.11190355e-01f, -4.24645811e-01f, -8.08371902e-02f, 5.43607652e-01f,
  2.96304733e-01f, 3.62563342e-01f, 5.94534099e-01f, -8.22586492e-02f, -4.55966771e-01f, 5.71059883e-01f, 1.10865426e+00f, 3.73930484e-01f, -3.48278850e-01f, -1.73414111e-01f,
  -4.87680972e-01f, -1.84602410e-01f, -8.52915168e-01f, -2.31171668e-01f, 5.44150889e-01f, 2.17496574e-01f, 5.76486945e-01f, 1.54607281e-01f, 4.19554114e-01f, -2.55722076e-01f,
  -1.75492585e-01f, 6.03155911e-01f, 1.16262746e+00f, 8.74678075e-01f, 6.95970893e-01f, 7.52665222e-01f, -1.76749185e-01f, 4.00696963e-01f, -7.90708601e-01f, -5.70189655e-01f,
  -2.09948465e-01f, 4.48631942e-01f, -1.08926944e-01f, 1.89646453e-01f, 5.43707132e-01f, -1.38264143e+00f, 5.88771760e-01f, 6.32600307e-01f, 4.72811097e-03f, -3.41242373e-01f,
  2.63299018e-01f, -3.19901794e-01f, 6.68747783e-01f, -1.25852346e-01f, -3.55137438e-02f, -6.16938293e-01f, 5.63877374e-02f, 7.00693905e-01f, -1.01664975e-01f, -8.08039308e-01f,
  -4.35028523e-01f, -2.97693342e-01f, -5.94996661e-03f, 1.90742657e-01f, 5.52656472e-01f, 1.16680942e-01f, 6.59296811e-01f, -1.07123055e-01f, 2.65944868e-01f, -9.07082483e-02f,
  -4.13823463e-02f, -9.15076077e-01f, 5.84508061e-01f, 1.33990109e-01f, -5.76170981e-01f, -5.08788303e-02f, -4.38375652e-01f, -3.89857411e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  6.64199591e-01f, 7.66373396e-01f, 2.84483939e-01f, 4.88125473e-01f, 9.36913788e-01f, 4.40154284e-01f, 4.73418506e-03f, 2.73235917e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.56255054e-01f, -4.07983273e-01f, 5.15948057e-01f, 2.01160476e-01f, -1.63342617e-02f, -1.35934249e-01f, -5.66814363e-01f, 5.83680049e-02f, 3.81934255e-01f, 7.31994808e-02f,
  -3.96449417e-01f, -3.14690381e-01f, 3.15932721e-01f, 8.40815380e-02f, -2.19819486e-01f, -6.07708693e-01f, 3.17456931e-01f, 5.48362970e-01f, -8.99587125e-02f, 2.11039230e-01f,
  8.86289477e-02f, -1.83830380e-01f, 5.80920100e-01f, -6.40922636e-02f, -1.98599145e-01f, -6.74951598e-02f, -3.14213224e-02f, 3.20348769e-01f, 3.55117097e-02f, -1.68912828e-01f,
  -2.31394738e-01f, -5.43324351e-01f, 2.71102246e-02f, -4.50023770e-01f, -2.09589392e-01f, -2.95876384e-01f, -8.37641656e-02f, -2.20692128e-01f, -4.45667326e-01f, -9.32108819e-01f,
  -6.04108647e-02f, 2.93618321e-01f, -3.43738258e-01f, 9.73701477e-02f, 4.88563925e-01f, 1.99065894e-01f, -9.90291759e-02f, -9.86514762e-02f, 1.43849313e-01f, 7.99422204e-01f,
  4.42297459e-01f, 2.31539831e-01f, 7.08748758e-01f, 1.37822479e-01f, 1.51411071e-01f, 1.13984346e+00f, 3.91974449e-02f, -6.05593994e-02f, 1.33697502e-02f, 4.56809811e-02f,
  -3.33571494e-01f, 2.30503440e-01f, -2.97404557e-01f, -1.81036398e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.67375756e-03f, -7.04746414e-03f, 4.02135760e-01f, 1.96151257e-01f, 5.02402365e-01f, 6.83308363e-01f, 2.99108867e-02f, 5.10481417e-01f, 1.27396905e+00f, 1.66663572e-01f,
  6.74707592e-01f, -4.34354603e-01f, -3.17150772e-01f, -5.71312189e-01f, 1.51589203e+00f, 2.00261518e-01f, 5.73689491e-02f, 7.43325293e-01f, 5.38191378e-01f, 2.17295140e-01f,
  8.20532590e-02f, 2.47562990e-01f, 5.70517838e-01f, -2.92681575e-01f, 5.62196150e-02f, 1.29277945e-01f, 7.78200924e-01f, 8.23707521e-01f, 1.09180450e+00f, 1.83138597e+00f,
  3.25190753e-01f, 8.19826722e-01f, 2.48053879e-01f, -3.82941961e-01f, 4.99476761e-01f, 3.20566118e-01f, -5.31782269e-01f, -8.58831882e-01f, -3.84210408e-01f, -5.07248044e-01f,
  1.29650497e+00f, -4.58596557e-01f, -1.13737091e-01f, 4.44875956e-01f, 8.74498248e-01f, -6.45826995e-01f, -1.66492149e-01f, -1.05748916e+00f, -8.02975297e-01f, -1.90523013e-01f,
  9.30841267e-02f, -3.37475896e-01f, 1.01242101e+00f, -2.22956210e-01f, 3.62032384e-01f, 9.56029654e-01f, 2.78575718e-01f, -2.36726001e-01f, -6.14770710e-01f, -9.25757468e-01f,
  -7.45257020e-01f, 1.00889087e-01f, -7.10239410e-01f, -5.16357534e-02f, -2.59229720e-01f, 8.71899426e-01f, -3.46563339e-01f, 2.73806036e-01f, -2.85888404e-01f, 1.39669061e-01f,
  1.97180390e-01f, 7.62094438e-01f, 2.74362773e-01f, 5.21685839e-01f, 2.15425879e-01f, -3.60773116e-01f, -2.39623383e-01f, 5.87703168e-01f, -2.62005359e-01f, -8.65788519e-01f,
  8.03019464e-01f, 4.01488304e-01f, 5.19466519e-01f, 1.00917614e+00f, 6.64596915e-01f, -2.08048731e-01f, 8.33783686e-01f, 8.12301159e-01f, -5.55614717e-02f, 1.37629962e+00f,
  6.83375299e-02f, -7.59105980e-01f, 3.53387475e-01f, -1.09773612e+00f, -4.69107956e-01f, 1.73805684e-01f, -5.09194732e-01f, 4.69996512e-01f, -8.50260496e-01f, 2.37878680e-01f,
  1.09002221e+00f, -2.03339055e-01f, 6.07186973e-01f, 1.01719761e+00f, 1.61264062e-01f, -3.97704184e-01f, -3.28261435e-01f, -7.76589811e-01f, -4.33576286e-01f, 8.30494165e-02f,
  -2.29048908e-01f, 2.53260225e-01f, 1.07412398e+00f, 3.40487331e-01f, 1.24361992e+00f, 1.05903935e+00f, 1.05906522e+00f, -5.52003264e-01f, 6.32451713e-01f, 9.01952684e-01f,
  5.47545373e-01f, -7.39293635e-01f, -2.77157336e-01f, -6.53267205e-02f, -3.77633013e-02f, 1.92201272e-01f, -5.21587133e-01f, 2.69989878e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -1.59138978e-01f, -1.38106821e-02f, 3.27199429e-01f, 2.63977915e-01f, 4.89227384e-01f, 7.65974879e-01f, 4.47721541e-01f, 4.27105367e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  7.72107899e-01f, -7.64783174e-02f, 1.43896908e-01f, -1.99036613e-01f, -1.01915753e+00f, 7.78622329e-01f, -1.04567266e+00f, 8.45382869e-01f, -1.18886113e+00f, -2.97964275e-01f,
  -4.09652710e-01f, 5.70769608e-01f, 2.92514324e-01f, 3.50628406e-01f, 1.38722622e+00f, 4.58680660e-01f, 8.37568462e-01f, -1.12749374e+00f, -1.09278774e+00f, -9.09874588e-03f,
  -1.00064623e+00f, 6.06032848e-01f, 7.25851059e-01f, -7.60848820e-01f, -5.43109119e-01f, 4.74860221e-01f, -1.17699057e-01f, -3.12017173e-01f, -2.14218318e-01f, -6.76270247e-01f,
  -2.62472421e-01f, -1.62701499e+00f, 4.71896410e-01f, 1.02434766e+00f, 5.27192950e-01f, -5.71110137e-02f, -1.06143725e+00f, -6.93991721e-01f, 1.22069848e+00f, 1.41470468e+00f,
  -1.33910322e+00f, 3.08058679e-01f, -1.01406109e+00f, -2.38731861e-01f, -2.11933300e-01f, 8.99680555e-02f, -5.80738187e-01f, 9.89375412e-02f, -8.16254437e-01f, -3.04377168e-01f,
  -2.01720953e-01f, 2.08223641e-01f, -1.56459957e-01f, -6.94908202e-01f, -5.34196317e-01f, 5.47581792e-01f, 2.19297707e-01f, -1.67582083e+00f, 7.01796487e-02f, 9.07132626e-01f,
  1.85851663e-01f, -5.60570598e-01f, 1.61084190e-01f, 1.11964077e-01f, 5.06600318e-03f, 4.67540603e-03f, 9.48266864e-01f, 1.46680862e-01f, 1.00950170e+00f, 9.29294229e-01f,
  -4.07948226e-01f, 8.92430902e-01f, -3.76118541e-01f, -4.95317936e-01f, 3.80946815e-01f, -9.23141122e-01f, -6.13706470e-01f, 4.78054494e-01f, -1.17851508e+00f, 5.77105701e-01f,
  4.09132279e-02f, 7.15690315e-01f, -6.29032552e-01f, 8.56650054e-01f, 1.31382036e+00f, 9.70691860e-01f, 6.59384608e-01f, 8.44460446e-03f, -8.54669452e-01f, 5.52894436e-02f,
  1.52047589e-01f, -5.47777057e-01f, -1.69987410e-01f, -1.25911701e+00f, -3.91320556e-01f, 5.28005362e-01f, -9.16810274e-01f, -7.59112537e-01f, 6.65746272e-01f, -5.54406464e-01f,
  -2.73824900e-01f, 3.46820742e-01f, 3.46754454e-02f, -1.22054815e+00f, 6.46282807e-02f, -5.54693006e-02f, -4.87459272e-01f, -6.15851939e-01f, -1.41951835e+00f, 9.53221083e-01f,
  -6.27905726e-01f, -4.71617520e-01f, 2.94634104e-01f, -3.30219030e-01f, -2.14092404e-01f, 8.11013281e-02f, -3.95240992e-01f, 3.96982402e-01f, -6.99442208e-01f, -4.76358533e-01f,
  4.72112894e-01f, -7.36678392e-02f, 9.84978974e-02f, -8.24440956e-01f, -8.68680775e-02f, -1.21775770e+00f, -5.63970566e-01f, -6.40484571e-01f, -6.15120351e-01f, 5.18938482e-01f,
  -3.88864100e-01f, -8.33943963e-01f, 6.78627670e-01f, -1.07380092e+00f, -5.29687762e-01f, -2.48401344e-01f, -4.90359992e-01f, -5.84579483e-02f, 6.05280280e-01f, -7.52414525e-01f,
  9.01160017e-02f, -9.75021869e-02f, -3.51218432e-01f, -2.04054308e+00f, -4.56537187e-01f, -2.73137718e-01f, 7.99201190e-01f, 5.20034730e-01f, -3.39461088e-01f, -1.21961284e+00f,
  -1.77462623e-01f, 4.05822657e-02f, 4.02333736e-01f, 3.25113833e-01f, -1.07888162e+00f, -3.83792132e-01f, 7.72600472e-01f, -9.37347114e-01f, -2.84942597e-01f, -1.26313865e+00f,
  -1.12528217e+00f, 4.74774977e-03f, -3.54932189e-01f, -9.15834308e-01f, 4.54288960e-01f, -4.76655573e-01f, 1.04111993e+00f, -1.11388409e+00f, -1.27258403e-02f, -1.65145624e+00f,
  8.85329068e-01f, -1.32825148e+00f, -1.01139724e+00f, -1.36552191e+00f, -1.45046091e+00f, 3.82930562e-02f, 4.97625411e-01f, 1.95273831e-01f, -1.06224529e-01f, 4.60509444e-03f,
  -2.98415065e-01f, -3.68797719e-01f, -3.07301968e-01f, 1.17459643e+00f, 8.68697315e-02f, -6.17493153e-01f, -3.87911379e-01f, -1.44250512e+00f, 1.06977582e+00f, 1.02313912e+00f,
  -1.19818139e+00f, -9.30976748e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  3.39799821e-01f, -1.16751559e-01f, 1.09965265e-01f, -5.90342104e-01f, -3.01746726e-02f, -2.87644386e-01f, 3.49724293e-01f, -1.84196323e-01f, 2.69528061e-01f, -6.37478605e-02f,
  6.99952617e-02f, -1.78692356e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    