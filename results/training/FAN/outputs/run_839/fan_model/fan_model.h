/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.22560900e-01f, -3.86067629e-01f, 3.02307755e-01f, -1.63245276e-01f, -2.50368081e-02f, 1.11537732e-01f, -2.24631969e-02f, -5.91665991e-02f, -4.53604646e-02f, -2.00370178e-01f,
  -9.68023539e-02f, 2.67775357e-03f, 1.81573015e-02f, 1.13083078e-02f, 1.04308560e-01f, -1.45047575e-01f, -2.65156001e-01f, 2.28622749e-01f, 5.39847314e-01f, 1.99625134e-01f,
  -1.08719528e-01f, -7.06980377e-02f, 1.90994576e-01f, 1.21345252e-01f, -2.82701194e-01f, 9.85841081e-03f, -9.72409844e-02f, -7.15521649e-02f, -4.60152440e-02f, -6.31970823e-01f,
  1.10008698e-02f, 2.65444014e-02f, 7.70497844e-02f, -5.20842634e-02f, -3.42235118e-02f, 6.17858693e-02f, 8.66692141e-02f, -3.53268208e-03f, 1.73893292e-02f, -8.23782906e-02f,
  -2.81937290e-02f, -1.60440765e-02f, -9.30989310e-02f, -7.76371062e-02f, -5.50093455e-03f, -5.73710129e-02f, -4.39006388e-02f, 5.28484732e-02f, 2.19589546e-02f, -2.81908996e-02f,
  -2.01674998e-01f, -6.51793256e-02f, 9.54430029e-02f, 3.14370915e-02f, 2.20446270e-02f, 7.91857466e-02f, -2.11389083e-02f, -4.78780568e-02f, 5.75854927e-02f, -2.57065862e-01f,
  2.33942047e-02f, -1.25690242e-02f, 8.09749439e-02f, -2.88471356e-02f, -1.68229062e-02f, 1.42560806e-02f, -1.90712214e-02f, -3.51343639e-02f, -4.23280010e-03f, -2.06642970e-02f,
  5.76675753e-04f, 3.48649770e-02f, -3.53834592e-02f, 1.66766535e-04f, -2.06053983e-02f, -1.33807398e-02f, 5.51377796e-03f, -7.98791274e-02f, 1.05909640e-02f, -3.37738590e-03f,
  -1.68481246e-02f, 1.15277357e-02f, -4.13039178e-02f, -1.28687341e-02f, -2.95753982e-02f, 4.50753532e-02f, 1.77896265e-02f, 6.24862919e-03f, 9.85468179e-03f, 3.70990075e-02f,
  -6.77978992e-02f, 2.38799393e-01f, -7.42309913e-02f, -2.31586248e-02f, 5.61815649e-02f, -7.06673935e-02f, -5.70951365e-02f, -2.50705663e-04f, -1.57072265e-02f, 1.25948461e-02f,
  8.48512575e-02f, 1.04790241e-01f, 3.87708633e-03f, -3.30439135e-02f, 4.11037840e-02f, 1.46160042e-02f, -1.34635167e-02f, -2.97720153e-02f, 1.18793221e-02f, 1.02171227e-01f,
  -1.02777623e-01f, 9.78174359e-02f, 1.53055161e-01f, -5.55332452e-02f, -2.96001472e-02f, 1.52708113e-01f, 1.15070343e-01f, 4.05024439e-02f, 2.51067132e-01f, -1.37711689e-01f,
  -2.29900360e-01f, -1.23121224e-01f, -2.14876980e-01f, -4.09817509e-02f, -1.29077256e-01f, -7.86998793e-02f, -2.89894491e-01f, 8.30255635e-03f, 6.89561293e-02f, -1.84061661e-01f,
  -1.35614246e-01f, 8.82344767e-02f, 6.19935468e-02f, -2.18453128e-02f, -3.11956983e-02f, -3.52011263e-01f, -2.50032097e-01f, -7.46940896e-02f, 1.83892976e-02f, -1.50436997e-01f,
  6.98971853e-05f, -1.46441713e-01f, -2.29506474e-02f, -2.33050082e-02f, 4.05910015e-02f, 6.45330250e-02f, 3.04321554e-02f, 1.97525509e-02f, -6.11357689e-02f, -7.81476945e-02f,
  -2.66727358e-01f, -5.94149455e-02f, 6.60514459e-02f, 1.19687449e-02f, -7.61057362e-02f, 1.00683197e-01f, -7.39625935e-03f, 2.66625434e-02f, 4.00279574e-02f, -9.68778208e-02f,
  4.50055264e-02f, -2.86699757e-02f, 7.51771033e-02f, 4.36669402e-02f, 6.74224570e-02f, -1.25760272e-01f, 2.57711019e-02f, -6.93237782e-02f, 2.33149175e-02f, -1.45443439e-01f,
  4.57409322e-02f, -7.03242719e-02f, -1.90330893e-01f, 3.41410674e-02f, 6.88990504e-02f, 4.88066152e-02f, -2.01861691e-02f, 1.20254099e-01f, 7.24036917e-02f, 4.15730588e-02f,
  -1.27088958e-02f, 7.73050264e-02f, 4.86755148e-02f, -7.41797360e-03f, -2.79110204e-02f, 1.17296660e-02f, 6.09360859e-02f, 1.33212442e-02f, 2.04384662e-02f, -6.56182691e-03f,
  -1.93559807e-02f, -6.87326416e-02f, 9.33293905e-03f, -5.11140078e-02f, -2.86401599e-03f, -5.20688817e-02f, 6.96840361e-02f, -4.02393006e-02f, -9.16197374e-02f, 2.11180821e-02f,
  -6.74233139e-02f, 3.04628965e-02f, 2.18590181e-02f, 1.12573855e-01f, -1.06990729e-02f, -2.62668040e-02f, 7.33966827e-02f, 6.74964190e-02f, -5.43758608e-02f, 2.07186490e-02f,
  -3.85695212e-02f, -2.40278561e-02f, -4.30431478e-02f, -8.72922242e-02f, 4.29345109e-02f, -3.49848531e-02f, 5.47155105e-02f, 1.30465450e-02f, 5.79149127e-02f, 1.58260930e-02f,
  -4.11139876e-02f, 3.21543552e-02f, -2.67000985e-03f, -4.31084773e-03f, -1.56534370e-02f, -2.25061197e-02f, -1.40243977e-01f, -3.56185213e-02f, 1.88150760e-02f, 4.17127907e-02f,
  -4.00962234e-02f, -6.38576001e-02f, -1.58173665e-01f, 6.21247143e-02f, 1.35223912e-02f, -5.31163178e-02f, 6.45288615e-04f, -6.53599063e-03f, 1.66166071e-02f, -1.38185143e-01f,
  3.67480487e-01f, 3.71697456e-01f, 4.17601243e-02f, 4.92533147e-02f, 1.64888650e-01f, 2.03252345e-01f, 3.98530245e-01f, 6.33922368e-02f, -1.27636611e-01f, 1.52476668e-01f,
  -7.62501806e-02f, -1.90620139e-01f, -1.38293713e-01f, -1.13493934e-01f, 5.32265417e-02f, 1.94169313e-01f, 2.45372981e-01f, 3.72088887e-02f, 2.74645947e-02f, -5.20020463e-02f,
  1.91783011e-02f, 1.06943808e-01f, -1.75303537e-02f, -5.55560663e-02f, -5.37491031e-03f, -2.05440998e-01f, 7.14050755e-02f, -6.98670894e-02f, -1.67498276e-01f, -2.55967397e-02f,
  -2.32500702e-01f, 2.28110045e-01f, -1.45666748e-01f, -3.01844850e-02f, -4.30412740e-02f, -3.06138154e-02f, -5.52412681e-02f, -1.95663907e-02f, -3.62312160e-02f, -2.03193594e-02f,
  2.71237083e-02f, -1.60353798e-02f, -1.43969394e-02f, 4.73982003e-03f, 1.07248396e-01f, 4.96999696e-02f, -6.30695280e-03f, 5.85932545e-02f, 3.10453996e-02f, 4.03319076e-02f,
  -3.50536928e-02f, 8.07789862e-02f, 1.76845804e-01f, 1.24257628e-03f, -2.30691843e-02f, 2.86319833e-02f, -6.40716553e-02f, 1.69647094e-02f, -2.33018678e-02f, 8.84688497e-02f,
  9.81737487e-03f, -5.71752340e-02f, -3.80779281e-02f, 2.35496964e-02f, 3.98230292e-02f, -3.18932557e-03f, 4.37686108e-02f, 9.58521850e-04f, -5.82239181e-02f, 5.89624234e-02f,
  -5.53542450e-02f, 6.43725856e-04f, -1.30654117e-02f, 6.33053854e-02f, -1.00911587e-01f, 5.94798997e-02f, -1.67101808e-02f, 3.29058059e-02f, -4.87294644e-02f, 7.19322786e-02f,
  -1.55270239e-02f, -8.37311670e-02f, 5.13647981e-02f, -2.73382626e-02f, 1.78541970e-02f, 2.40496323e-02f, -4.66033118e-03f, 9.23023559e-04f, 4.77914810e-02f, 3.36756818e-02f,
  -5.62318936e-02f, 3.60928103e-02f, -2.22596689e-03f, -1.94216950e-03f, 2.90274322e-02f, -2.71381084e-02f, 1.47621974e-03f, 2.43869089e-02f, 6.39848737e-03f, 5.77453598e-02f,
  3.70278619e-02f, 3.06788851e-02f, 3.86859551e-02f, -7.14123845e-02f, -4.11714949e-02f, 1.67558249e-03f, 3.76728885e-02f, 6.19918145e-02f, -1.83257870e-02f, 1.97779071e-02f,
  -1.53130051e-02f, 1.30304426e-01f, 6.48470595e-02f, 9.78462622e-02f, 2.60421596e-02f, 1.13571443e-01f, -9.00685228e-03f, 4.15370651e-02f, 1.33650616e-01f, 1.33556172e-01f,
  -4.36263293e-01f, 1.87513724e-01f, 4.52500612e-01f, -3.87583256e-01f, -1.98303405e-02f, 1.71355650e-01f, 2.34532759e-01f, -1.76032111e-01f, -2.16774613e-01f, -1.35388356e-02f,
  -4.47962135e-02f, -2.15905026e-01f, -1.60219178e-01f, 2.56825536e-02f, 3.34133394e-02f, 3.22543591e-01f, 2.31379613e-01f, 7.46682733e-02f, -2.38672970e-03f, -1.59291744e-01f,
  -8.82669985e-02f, -1.01033419e-01f, -2.06467748e-01f, -1.43430129e-01f, 2.10374016e-02f, 8.40298310e-02f, 1.89802840e-01f, 1.63806796e-01f, 1.86781719e-01f, 3.80800545e-01f,
  2.63645321e-01f, -1.63725629e-01f, -3.49687226e-02f, -5.23465089e-02f, 6.33145794e-02f, 4.39660326e-02f, 2.69062147e-02f, 7.87119493e-02f, -1.05729908e-01f, -4.05771919e-02f,
  -6.12235442e-03f, -5.03724478e-02f, -7.72913024e-02f, 4.68086191e-02f, -1.10774897e-01f, -8.72683227e-02f, 2.72594560e-02f, -7.65716583e-02f, 6.88016936e-02f, -4.53813039e-02f,
  6.77824318e-02f, 3.96536998e-02f, 6.87890500e-02f, 6.04302436e-02f, -3.58878146e-03f, 3.65113728e-02f, 1.04132846e-01f, 1.73178017e-01f, 1.82308733e-01f, 1.40332088e-01f,
  -1.76174175e-02f, 6.65908456e-02f, 3.40241455e-02f, 1.14584016e-02f, 7.99709372e-03f, -6.91066077e-03f, -3.44985947e-02f, 1.21869976e-02f, -4.41675410e-02f, 6.86838254e-02f,
  -1.72720905e-02f, 3.58975749e-03f, -9.91760660e-03f, -5.08419424e-02f, 7.58208893e-03f, 3.89413908e-02f, 2.85134688e-02f, -4.25642096e-02f, -3.79298031e-02f, 7.01600593e-03f,
  1.68453462e-05f, 5.45447059e-02f, -5.51971830e-02f, 5.21326475e-02f, -8.34845565e-03f, 1.70869064e-02f, 4.46025096e-02f, -2.09333096e-02f, -2.89265625e-02f, -3.35870013e-02f,
  -2.64897227e-01f, 1.12978823e-01f, -5.02067208e-02f, -7.93725923e-02f, -2.45427862e-02f, -2.91465372e-02f, 1.06491996e-02f, -8.61890987e-03f, 1.63001548e-02f, -1.10075939e-02f,
  -1.99639909e-02f, -1.18985400e-02f, 1.05440719e-02f, 4.91413139e-02f, 6.77016154e-02f, 4.62665455e-03f, -3.84300910e-02f, -2.00743525e-04f, 3.63041423e-02f, -4.92385728e-03f,
  -3.38634364e-02f, 3.61714400e-02f, -1.36166975e-01f, 6.09511212e-02f, -3.29039358e-02f, -4.48105186e-02f, 7.25350752e-02f, 3.09953038e-02f, 6.18869588e-02f, 6.96088523e-02f,
  -5.23945726e-02f, 3.84139568e-02f, 1.61994845e-02f, -1.80795893e-01f, 3.45067196e-02f, 1.54743418e-01f, 2.98047185e-01f, 1.23776026e-01f, -5.36157526e-02f, 1.31207585e-01f,
  4.92478237e-02f, -2.18576223e-01f, -1.74915865e-01f, -1.72340631e-01f, -4.95955423e-02f, -5.10108611e-03f, -2.71302283e-01f, -3.02569121e-01f, -7.51236156e-02f, 1.00629635e-01f,
  2.77462006e-02f, 9.36116651e-03f, 1.83753408e-02f, 4.56238165e-02f, -3.25453244e-02f, -1.13290280e-01f, 1.05874881e-01f, -6.25763312e-02f, 4.40098308e-02f, -3.35655928e-01f,
  6.15513884e-02f, 1.48148134e-01f, -8.17080960e-02f, -1.61007434e-01f, -4.68681939e-03f, 4.25869413e-03f, 1.10603571e-01f, 7.37183401e-03f, -6.49348348e-02f, 3.91986035e-02f,
  -4.95454185e-02f, 2.64943317e-02f, -1.16632059e-01f, 8.63616839e-02f, -4.10315916e-02f, 2.31605154e-02f, 1.60373952e-02f, 5.42888083e-02f, 3.41864228e-02f, 1.36467084e-01f,
  -9.13928375e-02f, -3.69340591e-02f, 3.01481504e-02f, 1.05432831e-01f, 3.09296977e-02f, -9.37115923e-02f, 9.33395475e-02f, 5.61748371e-02f, 9.01819766e-02f, 4.76821065e-02f,
  3.07900067e-02f, -3.41127031e-02f, -6.86926628e-03f, -3.20782624e-02f, 1.17383264e-02f, -2.62621846e-02f, -8.58131945e-02f, -2.29687430e-02f, -1.62214264e-02f, 1.17402300e-02f,
  7.89003000e-02f, 5.65876588e-02f, 6.22029277e-03f, 5.04402854e-02f, -8.48009512e-02f, -2.21467558e-02f, -7.00853765e-02f, -1.94813665e-02f, 1.12425638e-02f, 2.68578213e-02f,
  -3.95237580e-02f, 4.87683481e-03f, 2.98509840e-02f, 6.57553831e-03f, 1.63661614e-02f, 4.72846674e-03f, -4.95099984e-02f, -2.15945039e-02f, 4.32411432e-02f, 5.14263399e-02f,
  8.57919920e-03f, -6.79238662e-02f, 1.87273379e-02f, 3.81306820e-02f, -1.49916094e-02f, -9.29850806e-03f, -8.81610364e-02f, 2.16179136e-02f, -9.89720598e-02f, 6.36093169e-02f,
  4.34482209e-02f, -4.39035743e-02f, 1.44579662e-02f, -1.24527598e-02f, 2.74078287e-02f, 1.77503168e-03f, -8.53415355e-02f, -9.08260569e-02f, -1.10922521e-02f, 1.12461828e-01f,
  2.55579688e-02f, 3.25761959e-02f, -1.13003869e-02f, -6.74524307e-02f, -2.34843194e-02f, -1.38607532e-01f, -4.88491822e-03f, 4.59824204e-02f, 1.88803598e-02f, 1.51787177e-01f,
  4.30622369e-01f, -2.79994220e-01f, 2.69318193e-01f, 3.57181132e-01f, 1.77664503e-01f, -1.21454492e-01f, -1.62029177e-01f, 5.65017834e-02f, 1.65771231e-01f, -4.63900566e-02f,
  -2.15365812e-01f, -1.00110650e-01f, -8.36548135e-02f, -1.14193305e-01f, -3.70940641e-02f, 6.79548085e-02f, 2.87608832e-01f, 2.13615179e-01f, 2.03376830e-01f, -4.30795178e-03f,
  -1.78102106e-01f, 1.12258174e-01f, 2.20011577e-01f, 1.42397195e-01f, 1.57082938e-02f, -1.54051296e-02f, 1.06795378e-01f, 1.78048596e-01f, -1.69753969e-01f, 3.06318730e-01f,
  -8.56767520e-02f, 1.62336558e-01f, 2.17876229e-02f, -3.72555628e-02f, -2.64950544e-02f, -5.67856058e-02f, -5.03545962e-02f, 3.17496224e-03f, -5.35902232e-02f, 5.79472408e-02f,
  5.72926626e-02f, -4.80495915e-02f, 8.57864022e-02f, -3.79996672e-02f, 4.74804081e-02f, 3.69795673e-02f, 2.26576701e-02f, 4.95477691e-02f, 1.00166254e-01f, -5.58335558e-02f,
  -1.12535723e-01f, 4.60959971e-02f, 9.06548798e-02f, 1.08004955e-03f, 1.13710912e-03f, 7.13549033e-02f, -3.97776589e-02f, 8.13191698e-04f, 2.07110750e-03f, -6.07562922e-02f,
  -5.77314086e-02f, 2.70508323e-03f, -1.59374848e-02f, -2.25988049e-02f, -6.98048109e-03f, -1.51032498e-02f, 2.50810180e-02f, 2.69352626e-02f, -2.69925985e-02f, -5.20457327e-02f,
  6.05265843e-03f, -3.26661058e-02f, 7.03755990e-02f, -7.69234670e-04f, -3.44701037e-02f, 6.76040202e-02f, 7.01842085e-02f, -7.76303262e-02f, -1.54664833e-02f, 5.81214391e-02f,
  -9.76197701e-03f, 9.02537182e-02f, 5.73089235e-02f, -1.15041956e-02f, -4.85012978e-02f, 4.33670916e-02f, 4.12484491e-03f, 4.27431520e-03f, -5.12354895e-02f, 9.73940566e-02f,
  -1.96431488e-01f, -8.02213252e-02f, -1.54685108e-02f, 9.24685155e-04f, 4.63139303e-02f, -4.69612144e-02f, 4.71055880e-02f, -8.88960343e-03f, -4.34369904e-05f, -3.52483541e-02f,
  1.04188565e-02f, 2.01735622e-03f, 1.14203105e-02f, -7.99824484e-03f, -4.99924719e-02f, 1.19772870e-02f, -9.65038538e-02f, 5.65184206e-02f, -7.65311420e-02f, 1.65325012e-02f,
  -2.54239701e-02f, -1.42488331e-02f, 1.89617127e-02f, -4.87015992e-02f, -7.50068873e-02f, 5.47764748e-02f, -1.35054812e-01f, 6.97476557e-03f, -2.12072860e-02f, -2.62232840e-01f,
  -2.70677190e-02f, -3.01958144e-01f, -7.63182491e-02f, -9.04996395e-02f, -1.37608573e-01f, 7.11604516e-05f, -2.04342380e-01f, -3.42562795e-02f, 1.58625916e-01f, -7.56312385e-02f,
  8.15154538e-02f, 2.88585812e-01f, 2.37612024e-01f, 2.26189122e-01f, 1.17015280e-01f, -1.85205340e-01f, -1.67414173e-01f, 2.61316425e-03f, 2.03294262e-01f, 4.77189161e-02f,
  -7.55326496e-03f, -1.13293357e-01f, 8.35405141e-02f, 5.96148297e-02f, -2.02825099e-01f, 6.10815696e-02f, -1.22989073e-01f, -1.87679425e-01f, -1.37732640e-01f, -2.60140002e-01f,
  2.37351377e-02f, -1.57201007e-01f, 9.46263224e-02f, 4.00041789e-03f, -2.90944800e-02f, 2.31550373e-02f, -4.07741889e-02f, -2.52455883e-02f, 5.38142994e-02f, 3.84322219e-02f,
  1.33501766e-02f, 6.36864528e-02f, 1.92889199e-02f, 3.31250057e-02f, -6.58154711e-02f, 6.84528751e-03f, -1.89415496e-02f, 1.25781789e-01f, 1.21494286e-01f, 1.02316022e-01f,
  -3.95589694e-02f, -1.77388862e-01f, 3.64434496e-02f, 3.56803089e-02f, 1.07261248e-01f, 3.64230797e-02f, 6.77572144e-03f, 8.69357437e-02f, 1.43493995e-01f, -1.04345225e-01f,
  6.63812011e-02f, 5.74109778e-02f, -1.52564384e-02f, -4.04495075e-02f, 6.84260055e-02f, -6.16758242e-02f, -3.29979695e-02f, -4.02422398e-02f, 6.58536777e-02f, -1.90464929e-02f,
  3.10773347e-02f, 3.77296992e-02f, 2.10795980e-02f, -1.84924584e-02f, 3.93347368e-02f, -7.61708692e-02f, 5.40026017e-02f, -2.49094982e-02f, 8.93311575e-02f, 3.23109180e-02f,
  1.10583920e-02f, 1.30120842e-02f, -5.65733686e-02f, -5.26929758e-02f, -4.23607081e-02f, 2.90862266e-02f, 5.52412495e-03f, 1.17864208e-02f, 1.14641994e-01f, -7.37752346e-03f,
  9.56488997e-02f, 8.57829303e-02f, -4.42304388e-02f, 1.24446098e-02f, -8.16957802e-02f, 4.68034251e-03f, 2.66787745e-02f, -7.45671168e-02f, -7.70670269e-03f, 5.21862470e-02f,
  1.52766984e-02f, 2.14917548e-02f, 1.31100966e-02f, 2.74660103e-02f, 8.49375203e-02f, 3.26309279e-02f, -6.05152585e-02f, -1.75468484e-03f, 8.58028792e-03f, -5.09685799e-02f,
  2.46050227e-02f, 2.83945892e-02f, 6.93007931e-02f, 1.01217054e-01f, 9.62621570e-02f, 6.90497607e-02f, -4.32956358e-03f, -8.04979280e-02f, -2.72548310e-02f, -2.95963287e-02f,
  5.24945498e-01f, -2.95138005e-02f, 2.85714775e-01f, 2.02205390e-01f, -1.16790600e-01f, -2.45065168e-01f, -2.74486601e-01f, -8.37696120e-02f, 3.17344628e-02f, -7.02615548e-03f,
  -6.87156469e-02f, -1.19715594e-01f, 7.51150101e-02f, -4.17912975e-02f, 7.78119266e-02f, -2.11167615e-02f, 1.77141786e-01f, 1.65624127e-01f, -1.47894993e-01f, -3.67227942e-01f,
  -2.17314258e-01f, -2.32508425e-02f, 2.78558969e-01f, 5.72967604e-02f, -1.91961527e-02f, -8.89757872e-02f, 9.80052277e-02f, 1.66394308e-01f, -1.54506877e-01f, 1.67868584e-01f,
  3.68339233e-02f, 2.15673074e-01f, -1.13583535e-01f, -6.90443739e-02f, -2.52765194e-02f, 1.00535646e-01f, -3.25316973e-02f, 9.61897671e-02f, -1.25259254e-02f, 7.63944238e-02f,
  9.50786099e-02f, -4.35881466e-02f, -3.32927667e-02f, -7.91167542e-02f, 2.35908087e-02f, -4.32895608e-02f, 1.53315872e-01f, 1.58475563e-01f, 2.18146130e-01f, 5.84879704e-03f,
  -1.21588655e-01f, -6.01364002e-02f, 1.53232589e-01f, -4.72708531e-02f, 7.54136071e-02f, 6.03391193e-02f, 3.94840948e-02f, 5.79093322e-02f, 4.68801595e-02f, 1.09903440e-01f,
  9.75827046e-04f, -3.03010568e-02f, -2.24062502e-02f, -1.41116912e-02f, 2.62659090e-03f, -1.77290849e-02f, 2.23718188e-03f, -6.31653890e-02f, -8.39011744e-03f, 7.56657403e-03f,
  1.06610404e-02f, 6.60731457e-03f, 1.12856152e-02f, 4.64371033e-02f, 6.07455801e-03f, -2.43114494e-02f, -1.07341064e-02f, -4.97093657e-03f, 8.40574577e-02f, -1.94253121e-03f,
  -2.69269682e-02f, 3.05128023e-02f, 4.91142273e-03f, -5.57281040e-02f, 6.59440309e-02f, 2.98188664e-02f, -8.33561569e-02f, -3.68441232e-02f, 2.38863993e-02f, 3.03827901e-03f,
  -1.14366852e-01f, 9.67296734e-02f, -2.29496863e-02f, 8.63284804e-03f, 3.50427721e-03f, 5.86464778e-02f, -1.03233764e-02f, -4.61050123e-02f, -1.96508528e-03f, -4.27934155e-02f,
  -7.19093606e-02f, 5.25035672e-02f, 8.04467965e-03f, 9.79927462e-03f, -6.81702271e-02f, -2.43591685e-02f, -5.80756329e-02f, 1.88990608e-02f, -6.07688762e-02f, -4.90317978e-02f,
  6.58644438e-02f, -4.32381295e-02f, -6.28656447e-02f, -1.11336373e-02f, 2.73273867e-02f, -1.58023238e-01f, -1.15383223e-01f, -3.86108719e-02f, -3.37865800e-02f, -2.02248842e-01f,
  3.40730071e-01f, -6.19847178e-02f, -1.56554028e-01f, 1.86634585e-01f, -1.07287847e-01f, 2.93707680e-02f, -8.34452212e-02f, 3.71605605e-02f, 6.34080693e-02f, 7.42235109e-02f,
  -5.05130887e-02f, -2.73169186e-02f, 6.26556650e-02f, -2.44578514e-02f, 7.28189200e-02f, -9.82162356e-03f, 5.47195785e-03f, 2.95766201e-02f, 2.46366441e-01f, 5.19944876e-02f,
  2.43108231e-03f, 7.88986832e-02f, 1.42017156e-01f, 9.45310742e-02f, -9.34989825e-02f, 6.28514364e-02f, -1.80634081e-01f, -1.62778959e-01f, -2.72780329e-01f, -2.53821731e-01f,
  -8.43515545e-02f, -3.51947695e-01f, 7.11557874e-03f, 3.88692208e-02f, -3.37228291e-02f, 1.66411586e-02f, -1.49278413e-03f, 4.36825417e-02f, -4.82329540e-02f, -4.06003632e-02f,
  2.85024662e-02f, -5.31485444e-03f, -1.10635221e-01f, -2.78517064e-02f, 4.63006832e-02f, -3.24210897e-02f, 1.03890754e-01f, 8.28944072e-02f, 8.57524052e-02f, 6.79983944e-02f,
  -9.98267252e-03f, -5.39518818e-02f, 5.45841902e-02f, 5.18457144e-02f, -7.66629130e-02f, 5.13183773e-02f, -2.13767169e-03f, -1.43690556e-01f, -6.21434823e-02f, 1.58765942e-01f,
  3.39700468e-02f, 1.59477722e-02f, -7.65834600e-02f, 4.23763432e-02f, 8.61499459e-02f, 6.62675127e-02f, -3.01434044e-02f, 5.96961863e-02f, -1.10628389e-01f, 1.37765437e-01f,
  -2.60732938e-02f, -5.15074320e-02f, -3.34233083e-02f, -2.66879722e-02f, 6.02062158e-02f, -5.92954364e-03f, -5.12048742e-03f, 5.60567304e-02f, -6.18126802e-02f, 5.03860191e-02f,
  1.92303490e-02f, -6.26071841e-02f, -2.43922323e-03f, 5.75450510e-02f, -8.09535682e-02f, -6.36569485e-02f, -2.68783532e-02f, -8.72850120e-02f, 8.49861130e-02f, -1.03405915e-01f,
  3.86837006e-01f, -1.75901070e-01f, 8.32386017e-02f, 1.12877659e-01f, -5.18787513e-03f, -8.92103277e-03f, -9.91131738e-02f, -4.48019430e-02f, -1.23387322e-01f, 5.83852232e-02f,
  -1.44987985e-01f, 2.17678808e-02f, -4.09346782e-02f, 4.26427759e-02f, 9.15224999e-02f, 6.40795678e-02f, 1.15867488e-01f, 5.89079410e-02f, -5.86412363e-02f, 4.09263372e-02f,
  3.56656127e-02f, 2.20263436e-01f, 2.61332095e-01f, 1.38570994e-01f, -8.24575312e-03f, 2.22310960e-01f, 8.73210877e-02f, 6.26842231e-02f, 9.69716683e-02f, 5.03625512e-01f,
  -2.83339292e-01f, -4.14851345e-02f, -1.13250077e-01f, 1.67394429e-02f, 2.98949510e-01f, 3.37332562e-02f, 1.65656924e-01f, -4.46381420e-02f, 1.31145343e-01f, 2.61135697e-02f,
  3.07248563e-01f, -4.17689309e-02f, -2.01971993e-01f, -1.08745411e-01f, -3.20926070e-01f, -1.18692808e-01f, -1.21086732e-01f, -3.90798748e-01f, -3.77394557e-01f, -3.08249705e-02f,
  1.29871935e-01f, -1.42944828e-01f, -2.17406780e-01f, -2.40625665e-02f, 1.24590069e-01f, -1.92270085e-01f, 6.05388470e-02f, 1.10000655e-01f, 1.18041620e-01f, 1.00966185e-01f,
  -2.19556302e-01f, 1.91491023e-01f, -3.20073329e-02f, 1.95049327e-02f, 2.07792167e-02f, -1.19563460e-01f, -8.54685754e-02f, 3.28412056e-02f, -1.99139453e-02f, -8.13664421e-02f,
  1.71414897e-01f, 5.93281463e-02f, -5.01262918e-02f, 6.75018504e-02f, -3.24808173e-02f, -7.39846146e-04f, 3.04467287e-02f, -4.47550118e-02f, -7.70386457e-02f, 5.79344444e-02f,
  7.57287145e-02f, 1.96621299e-01f, 1.48099780e-01f, 9.01667178e-02f, 1.31888874e-02f, 7.84392804e-02f, 8.63943100e-02f, 8.05537999e-02f, 1.36866439e-02f, -1.29027084e-01f,
  -2.60696430e-02f, -4.20534238e-02f, 5.97402155e-02f, -1.43391388e-02f, -3.60376798e-02f, -1.20334411e-02f, 8.12787469e-03f, -3.97540443e-02f, -3.10094804e-02f, -2.21051406e-02f,
  -5.09812422e-02f, 5.81025193e-03f, -5.06245755e-02f, -1.07022434e-01f, -2.80913827e-03f, 6.57560006e-02f, -1.19559448e-02f, -1.76949948e-02f, 5.77972047e-02f, 2.16689203e-02f,
  -5.69650084e-02f, 3.97050530e-02f, -3.54259051e-02f, -1.81321520e-02f, 6.06190674e-02f, -7.94160366e-03f, 2.69431882e-02f, 2.53954194e-02f, 9.46592726e-03f, -5.96219860e-03f,
  -2.60871172e-01f, 6.54290542e-02f, -3.34988870e-02f, -2.44855583e-02f, 5.55823976e-03f, 7.19095320e-02f, 2.84368135e-02f, -2.30183359e-02f, 7.11652935e-02f, 6.92757452e-03f,
  4.63027842e-02f, -6.16041385e-02f, -4.85671721e-02f, 1.14692170e-02f, -4.31965441e-02f, 2.99433209e-02f, 8.01556483e-02f, -6.01739101e-02f, 6.29541576e-02f, 9.08763036e-02f,
  2.44005751e-02f, -1.48324236e-01f, -2.01837614e-01f, -7.15600997e-02f, -1.57440025e-02f, -1.42334253e-01f, -1.03765585e-01f, -1.05316058e-01f, -1.41860247e-01f, -3.35800022e-01f,
  -3.57684106e-01f, 1.06510885e-01f, 6.22793697e-02f, -1.00943632e-01f, 3.17450613e-01f, 4.15079385e-01f, 4.25417632e-01f, 1.87601879e-01f, -1.81503445e-02f, 1.79263636e-01f,
  1.04345679e-01f, -1.85379684e-01f, -2.95337588e-01f, -2.46160552e-01f, -8.22245479e-02f, 1.17751092e-01f, 2.73514050e-03f, -3.49504143e-01f, -2.27725178e-01f, 1.53883740e-01f,
  5.66168688e-02f, -7.98774660e-02f, -2.81680405e-01f, -9.81359258e-02f, 1.05912991e-01f, -1.60883576e-01f, 6.68653995e-02f, 3.26147974e-02f, 7.84116145e-03f, -2.40846768e-01f,
  -7.57321566e-02f, 6.12796545e-02f, -7.23715574e-02f, -7.56815262e-03f, 1.43265501e-02f, -2.95204241e-02f, 3.37870568e-02f, -9.09125507e-02f, 1.08557507e-01f, 9.01591592e-03f,
  6.59756437e-02f, 4.63040136e-02f, -1.36303371e-02f, 2.70169545e-02f, 8.30905437e-02f, 3.34700719e-02f, -1.11759052e-01f, -1.79245770e-01f, -1.38776883e-01f, 6.05493858e-02f,
  -6.50833994e-02f, 6.18380588e-03f, 1.63184047e-01f, 1.07771605e-01f, 6.13447689e-02f, -4.52577956e-02f, 1.52655110e-01f, -3.30136418e-02f, 8.01841915e-02f, -1.46180958e-01f,
  3.02675273e-02f, 3.89281064e-02f, 4.39540260e-02f, 1.66931618e-02f, -4.02134843e-02f, 5.69285974e-02f, -6.02339860e-03f, 4.18902412e-02f, -4.69366722e-02f, -1.06738333e-03f,
  -3.02721616e-02f, -4.08938974e-02f, 7.73177594e-02f, 1.91482697e-02f, -6.12250995e-03f, 5.48996404e-03f, 6.45417422e-02f, -6.57657683e-02f, 4.50624786e-02f, -1.14565725e-02f,
  -4.66313958e-02f, 2.01645736e-02f, 1.52058071e-02f, -8.17209631e-02f, 6.99866517e-03f, -4.96256836e-02f, 3.27459129e-04f, 1.97760612e-02f, -8.79190862e-02f, 4.39692885e-02f,
  -6.41656741e-02f, 6.80850446e-02f, -4.57755998e-02f, -1.28705174e-01f, 4.68851998e-02f, 4.16078093e-03f, 4.04009558e-02f, -1.88395213e-02f, 8.63183755e-03f, -9.73142833e-02f,
  5.75190336e-02f, 2.95804683e-02f, -2.73385774e-02f, 8.42009019e-03f, -1.10565815e-02f, 1.72066130e-02f, 2.73359213e-02f, -5.20644188e-02f, 5.98635860e-02f, 1.13945447e-01f,
  1.38316639e-02f, 4.83472049e-02f, 3.86644043e-02f, 4.03215699e-02f, -1.81238279e-02f, 1.94791276e-02f, 9.21749026e-02f, -1.57197732e-02f, 4.25391905e-02f, 7.47624636e-02f,
  2.09900975e-01f, -7.23530259e-03f, -5.29197335e-01f, 6.90772384e-02f, -3.25891934e-02f, -2.07438305e-01f, -3.86273444e-01f, -8.99427310e-02f, 1.15836479e-01f, -1.71428844e-01f,
  1.59206405e-01f, 2.10448503e-01f, 2.10359350e-01f, -4.16017659e-02f, -1.31320864e-01f, -4.00785506e-01f, -4.59860325e-01f, -3.49899471e-01f, -1.09870911e-01f, -2.67409422e-02f,
  1.04589025e-02f, -2.44125612e-02f, 1.25359237e-01f, 6.51899800e-02f, 5.54743931e-02f, -2.26949062e-02f, -1.67244822e-02f, 1.43421263e-01f, 5.95985129e-02f, -2.00056657e-01f,
  -1.86462924e-01f, -1.19316624e-02f, -6.12866282e-02f, 1.47023335e-01f, 3.41440067e-02f, 6.01732321e-02f, 1.31143713e-02f, -2.54687686e-02f, 2.34376118e-02f, 3.00614275e-02f,
  7.64790773e-02f, 8.42474550e-02f, -1.40231512e-02f, -5.13196166e-04f, -1.33883255e-02f, 5.31135872e-03f, -4.31988090e-02f, -1.44481644e-01f, -1.11513212e-01f, 4.41666767e-02f,
  7.98325315e-02f, 4.96929511e-02f, 8.73638084e-04f, -6.93158135e-02f, -1.07687272e-01f, 7.47415796e-02f, 6.38147220e-02f, 1.10788912e-01f, -6.98672757e-02f, -9.39028859e-02f,
  -1.54758655e-02f, -4.81488109e-02f, -2.14280933e-02f, 2.98148878e-02f, -5.09654321e-02f, 6.68611377e-02f, -7.33961686e-02f, -6.61065504e-02f, -2.25718636e-02f, 2.33313460e-02f,
  -1.30396234e-02f, -1.62872951e-02f, -2.48666275e-02f, 2.30918899e-02f, -2.16014981e-02f, 4.95553426e-02f, 1.23588443e-02f, -4.26260531e-02f, 5.35866581e-02f, 2.67820340e-02f,
  -1.47973802e-02f, 1.55374352e-02f, 6.83714077e-03f, -3.68496254e-02f, 2.26210766e-02f, -5.69822267e-02f, -1.79710891e-02f, 3.60094421e-02f, 8.63921270e-02f, 3.63876880e-03f,
  1.92913681e-01f, -5.42808995e-02f, -6.66768700e-02f, -2.04526149e-02f, -6.54456839e-02f, 6.21927716e-02f, 1.80468876e-02f, -5.46203135e-03f, 1.03241801e-01f, -5.92220090e-02f,
  5.39492518e-02f, -2.85112299e-02f, -3.20073850e-02f, 2.11957898e-02f, -2.96854880e-02f, 3.54203917e-02f, 1.52572310e-02f, 5.51669113e-02f, 8.52561817e-02f, 2.75088008e-02f,
  3.92549597e-02f, -2.27634665e-02f, 4.81728874e-02f, -3.35280113e-02f, 2.37118360e-02f, -2.99957693e-02f, -6.87935948e-02f, 3.89546044e-02f, 1.47990249e-02f, -8.61961469e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.22140323e-02f, 4.67791557e-02f, -1.72680020e-01f, 1.24458231e-01f, 1.91393703e-01f, 1.50278151e-01f, 1.34438321e-01f, 3.51565778e-02f, 1.31554902e-01f, 3.05083338e-02f,
  6.31893724e-02f, 7.48436376e-02f, 2.78388783e-02f, -2.61885300e-02f, -1.22597165e-01f, 1.47712277e-02f, -5.23720011e-02f, -1.06126450e-01f, -1.66527808e-01f, 9.39647257e-02f,
  9.82044861e-02f, 6.99817240e-02f, -7.89722353e-02f, 5.05939275e-02f, 1.01060309e-02f, -6.06938303e-02f, -5.01692481e-02f, 4.05535810e-02f, -9.37461704e-02f, 5.82774170e-02f,
  -2.15206429e-01f, -6.22840859e-02f, 1.09595414e-02f, 2.90701501e-02f, -8.97386000e-02f, -4.91783433e-02f, -6.77929819e-02f, -1.15232728e-01f, 1.97057296e-02f, -1.12873100e-01f,
  -9.83653516e-02f, 3.11792791e-02f, 4.96275537e-02f, -1.23473257e-01f, -4.67013977e-02f, 3.78895253e-02f, -1.12290114e-01f, -1.61301687e-01f, -1.10968962e-01f, -4.57017757e-02f,
  4.99956161e-02f, 4.93493825e-02f, -1.17985606e-01f, -7.15183765e-02f, 2.35990100e-02f, -7.98868611e-02f, -6.38119727e-02f, -9.48690549e-02f, -4.18702886e-02f, -1.49143234e-01f,
  -1.15847647e-01f, 2.08170945e-03f, -3.29511203e-02f, 9.12825689e-02f, 4.31625405e-03f, 9.07154456e-02f, -8.33493248e-02f, -8.68034735e-02f, 5.53149022e-02f, -3.48432995e-02f,
  -3.66185196e-02f, -2.96533220e-02f, 1.44131985e-02f, 1.28339883e-03f, 3.72219235e-02f, -5.95322549e-02f, -4.20439988e-03f, -3.02452669e-02f, -6.04625382e-02f, -1.49839651e-02f,
  6.74733669e-02f, 5.85740097e-02f, -8.99902359e-03f, -5.82090355e-02f, -7.60753974e-02f, 6.69889972e-02f, -4.20204513e-02f, -7.13741258e-02f, -3.02950330e-02f, 1.67078059e-02f,
  -1.79215893e-02f, -1.69957742e-01f, -7.56329894e-02f, -3.18232961e-02f, 3.87048572e-02f, -8.27010423e-02f, 1.23814242e-02f, -1.01321176e-01f, -6.73822314e-02f, 5.35713322e-02f,
  5.40059293e-03f, -6.73308596e-02f, 2.34083887e-02f, -2.33457517e-02f, -4.05789316e-02f, -3.46986465e-02f, 4.71224599e-02f, -4.75087725e-02f, -4.38843593e-02f, -4.01839092e-02f,
  9.12510231e-03f, -6.86170906e-02f, -1.39039000e-02f, -8.35026726e-02f, -5.90097122e-02f, 6.80311024e-02f, -1.13208234e-01f, 1.59176905e-02f, -1.26373246e-01f, 3.09853777e-02f,
  9.31486338e-02f, 5.60506471e-02f, -1.15431193e-02f, -2.59808749e-02f, -8.79859328e-02f, -7.69687369e-02f, -3.13262157e-02f, 1.97037756e-02f, 9.80424806e-02f, 6.59885630e-02f,
  2.78711226e-02f, -2.37702522e-02f, 6.04902357e-02f, 5.14615735e-04f, 7.74393044e-03f, -2.20065340e-02f, -7.12018460e-02f, -2.41014846e-02f, -5.27400263e-02f, -5.31011708e-02f,
  -2.04055347e-02f, -1.05540290e-01f, -8.17550272e-02f, -7.28365853e-02f, -1.14021011e-01f, -1.31216254e-02f, 1.21382754e-02f, 7.68732419e-03f, 2.58018263e-02f, -9.35811102e-02f,
  -1.76605389e-01f, -2.95789819e-02f, 3.10260635e-02f, 1.10775597e-01f, 8.45435262e-02f, 5.22152893e-02f, 6.84799701e-02f, 9.51732919e-02f, 1.26180813e-01f, -8.51242617e-03f,
  -5.31346276e-02f, 1.25598698e-03f, -1.01496257e-01f, -7.12282360e-02f, 3.56350467e-02f, 1.68699888e-03f, 1.17389746e-01f, 6.94593042e-02f, 9.63692293e-02f, 1.18051171e-02f,
  6.50276989e-02f, 9.01151821e-02f, 6.70758635e-02f, 8.47463403e-03f, -2.27620974e-02f, -5.08801527e-02f, 9.95756872e-03f, -3.82756605e-03f, -1.08335027e-02f, -3.59612964e-02f,
  -4.11915258e-02f, 8.53512529e-03f, 8.17764327e-02f, 3.74558233e-02f, -3.45836394e-02f, 9.70122684e-03f, -6.18978068e-02f, -4.81862873e-02f, -6.80098161e-02f, 4.44743820e-02f,
  6.67680427e-02f, 7.92311355e-02f, -4.81106015e-03f, -2.03801207e-02f, -4.00482081e-02f, -4.37149145e-02f, -3.46403345e-02f, -6.26996085e-02f, -8.25030431e-02f, -4.23327424e-02f,
  2.74585932e-02f, -6.92708641e-02f, 5.72793074e-02f, -6.57225028e-02f, 7.25633353e-02f, -3.70234549e-02f, -2.78657433e-02f, 8.09944123e-02f, 6.84481394e-03f, 1.11191593e-01f,
  -6.41161650e-02f, 3.75005119e-02f, 4.12468836e-02f, -1.17783502e-01f, 7.14883506e-02f, 8.94025564e-02f, 7.30929822e-02f, 1.44039199e-01f, 1.25473976e-01f, 8.29552710e-02f,
  1.03146240e-01f, 7.11332336e-02f, 4.45863977e-02f, -9.13273692e-02f, -1.20869018e-01f, -2.59097107e-02f, -1.31408926e-02f, 2.85464283e-02f, -4.12022620e-02f, -2.28879098e-02f,
  6.83914684e-03f, -2.77972594e-02f, 2.64057145e-02f, -4.38893773e-02f, -2.23497897e-02f, -6.50402829e-02f, 1.98211111e-02f, -2.09314190e-03f, -2.34121177e-02f, 1.45939812e-01f,
  1.52614251e-01f, 1.02954149e-01f, 7.13329837e-02f, 2.19531178e-01f, 3.29354145e-02f, -1.53412610e-01f, -2.90149510e-01f, -2.70526588e-01f, -2.15918776e-02f, 1.12000249e-01f,
  2.21145988e-01f, 1.68879032e-01f, 5.88510334e-02f, -7.24001229e-02f, -2.73595095e-01f, -1.63759410e-01f, 2.49047838e-02f, -1.62682623e-01f, -1.74336299e-01f, -6.17221072e-02f,
  1.23178057e-01f, 2.97289956e-02f, 3.02139856e-02f, -2.70437393e-02f, 1.40865862e-01f, 5.09331189e-02f, 1.42940000e-01f, -7.56277191e-03f, 6.22650869e-02f, 1.65425077e-01f,
  2.85981566e-01f, -3.42894159e-02f, -1.01472333e-01f, 3.19342427e-02f, 1.31145641e-01f, -5.54924719e-02f, -6.56920969e-02f, -6.13518693e-02f, 3.71116363e-02f, 6.73548952e-02f,
  6.56226650e-02f, 1.88213158e-02f, -3.01215379e-03f, -1.07646063e-02f, 2.90724039e-02f, -8.60190094e-02f, -7.94107318e-02f, -1.62030533e-01f, -1.59796536e-01f, 2.78348569e-04f,
  -1.98707692e-02f, 1.13710910e-02f, -3.62223759e-02f, -9.09965485e-02f, -1.67436957e-01f, -9.93965492e-02f, -3.51220965e-02f, -1.51464030e-01f, -1.88684329e-01f, -1.00236543e-01f,
  7.12547377e-02f, 5.18345870e-02f, -6.36094958e-02f, -2.76998505e-02f, 5.31057939e-02f, 5.86306900e-02f, 1.19115442e-01f, 4.80326638e-03f, -2.04288382e-02f, -1.38351116e-02f,
  -9.82555822e-02f, 4.48861085e-02f, 3.56485546e-02f, 1.96771752e-02f, -2.10416280e-02f, 5.39478697e-02f, -2.04329863e-02f, -9.00054276e-02f, -8.38556048e-03f, 1.21958144e-02f,
  -3.21763717e-02f, 7.81644695e-03f, 6.45915046e-03f, -6.73827231e-02f, -3.30780260e-02f, -6.63272738e-02f, -3.37913781e-02f, -1.46489576e-01f, 5.71544887e-03f, -1.04011772e-02f,
  1.82056636e-01f, -6.61471635e-02f, 2.62001716e-02f, -8.01619142e-03f, 4.78003994e-02f, 3.40613388e-02f, 5.40406816e-02f, -4.34332453e-02f, -5.53750386e-03f, -3.84263806e-02f,
  -1.22715672e-02f, -4.84008901e-02f, 2.93624327e-02f, -2.33045127e-03f, -5.96256070e-02f, -3.14307399e-02f, 9.01123788e-03f, -7.36450404e-02f, -1.35092989e-01f, 2.48080734e-02f,
  -1.07362084e-01f, -1.43320665e-01f, -7.40592256e-02f, -2.02152312e-01f, 3.10977902e-02f, -1.21756494e-02f, -9.03040469e-02f, -1.47148415e-01f, -2.31307492e-01f, -2.38598600e-01f,
  1.62007004e-01f, -9.40783098e-02f, 1.01756744e-01f, -1.02258883e-02f, -8.20863545e-02f, -1.70703143e-01f, -1.90235987e-01f, 8.83900840e-03f, -5.28130727e-03f, -4.34719920e-02f,
  1.55285999e-01f, 2.24584013e-01f, 2.81916171e-01f, 1.50195837e-01f, 1.44534707e-01f, -4.37255986e-02f, -1.91205852e-02f, 2.44351134e-01f, 7.27847517e-02f, -6.95205554e-02f,
  4.06570137e-02f, 3.21152359e-02f, 3.43495086e-02f, -1.92169510e-02f, -1.31363094e-01f, 1.61146730e-01f, -5.05506806e-02f, 4.32166047e-02f, 6.88793659e-02f, 6.18090183e-02f,
  1.11204479e-02f, -9.02178977e-03f, 7.95946196e-02f, 4.87411432e-02f, 1.78477690e-02f, -2.95174718e-02f, 6.55676052e-02f, -8.22930038e-02f, 4.51231003e-02f, -9.59939510e-02f,
  -5.17932838e-03f, 3.25352773e-02f, -7.17451796e-02f, -5.10775447e-02f, 1.49143459e-02f, 1.90823805e-02f, 2.05803234e-02f, -1.26039144e-02f, 1.23704389e-01f, 6.41050860e-02f,
  1.10855754e-02f, -7.01188892e-02f, 6.98341131e-02f, -1.07458435e-01f, 3.78763154e-02f, 7.37799332e-02f, 3.26177999e-02f, -7.36557022e-02f, 8.60905871e-02f, 1.92007422e-02f,
  4.03749980e-02f, -8.74463748e-03f, 8.09260607e-02f, -8.46043751e-02f, 7.90562760e-03f, -6.14603646e-02f, -5.62523343e-02f, -7.30652036e-03f, -4.73076105e-02f, -7.42440298e-02f,
  4.67610322e-02f, 1.99424718e-02f, 6.31621629e-02f, 1.38997510e-02f, 4.97988127e-02f, -1.09801739e-02f, 6.58941120e-02f, -3.84322405e-02f, 9.23330337e-02f, -5.90770468e-02f,
  2.46507544e-02f, -5.65117076e-02f, 2.00665835e-02f, 2.89559998e-02f, -1.01899514e-02f, -3.29133905e-02f, -4.07244777e-03f, -5.72999828e-02f, 2.60972362e-02f, -5.74812479e-02f,
  -1.31495014e-01f, 4.14337754e-01f, 5.81652522e-02f, 6.31891713e-02f, -5.97402342e-02f, -1.85450874e-02f, -1.04209818e-01f, 7.63999224e-02f, -8.16440657e-02f, -1.20891929e-01f,
  7.62044340e-02f, 9.22490656e-02f, -8.54164809e-02f, -6.30125105e-02f, -3.80828092e-03f, 2.76571698e-02f, 5.31844003e-03f, 5.38353026e-02f, 7.80196954e-03f, 3.20204198e-02f,
  -5.67871593e-02f, 3.96876223e-02f, -9.02528409e-03f, 5.31888418e-02f, 1.23155667e-02f, 6.32050037e-02f, -3.92342396e-02f, 4.19330131e-03f, 1.61101401e-01f, 1.46339834e-02f,
  -1.52677387e-01f, -1.73258409e-01f, 2.36573562e-01f, 5.87566160e-02f, 2.89489150e-01f, 2.43942142e-01f, 2.92822748e-01f, 8.38917717e-02f, 1.22955881e-01f, 4.96355183e-02f,
  -1.39550179e-01f, -1.22093996e-02f, -2.17567347e-02f, 9.70327482e-02f, 5.51922247e-02f, 5.74376099e-02f, 9.65490863e-02f, 5.94752431e-02f, 1.60048589e-01f, 7.35268742e-02f,
  6.36417940e-02f, -4.09604982e-02f, -9.03513432e-02f, 7.42743686e-02f, 1.06612518e-01f, 1.07731737e-01f, 1.18103564e-01f, 9.71541256e-02f, -3.05663329e-02f, 9.28321034e-02f,
  3.82278189e-02f, -1.78471386e-01f, 4.83413078e-02f, -1.20446764e-01f, -9.61894542e-02f, -1.31049275e-01f, 1.49337910e-02f, -4.62028459e-02f, -2.52922196e-02f, 2.81517264e-02f,
  -2.72228243e-03f, -1.58597171e-01f, -1.07864430e-02f, -1.22232296e-01f, 3.53230238e-02f, -5.09473868e-02f, -1.38966173e-01f, -1.42343100e-02f, -9.66969803e-02f, -3.79693173e-02f,
  5.02896204e-04f, 2.45105755e-02f, 1.78759061e-02f, 7.47335032e-02f, 6.18954003e-02f, 4.91409265e-02f, 2.81778928e-02f, -7.64360502e-02f, -6.17897026e-02f, -1.07068293e-01f,
  -5.98741807e-02f, 3.70759070e-02f, 7.69552812e-02f, -6.78052828e-02f, -6.68779910e-02f, 1.91439502e-02f, -9.01267806e-04f, 2.81831194e-02f, 1.13245891e-02f, 8.69203806e-02f,
  2.66363304e-02f, 8.22387859e-02f, 8.10327008e-02f, 3.23271863e-02f, -2.17849910e-02f, 8.97890702e-02f, 9.34764091e-03f, 6.14869315e-03f, -2.69477163e-02f, 1.27875721e-02f,
  1.97970332e-03f, -2.94121373e-02f, -7.12078810e-02f, 5.07314457e-03f, 3.95253021e-03f, 6.38254406e-03f, -9.56532359e-03f, -6.65180236e-02f, -2.67306883e-02f, 1.99913122e-02f,
  1.38895005e-01f, -9.49537456e-02f, 1.05298102e-01f, -5.93755096e-02f, 2.69702990e-02f, -9.21744481e-02f, 1.08333697e-04f, -7.58422464e-02f, 1.53757203e-02f, 5.12033105e-02f,
  6.83427043e-03f, 9.89702158e-03f, 3.30605395e-02f, -9.05768201e-02f, 5.60448505e-02f, -6.96616173e-02f, 1.01582427e-02f, 4.96111484e-03f, 2.86193117e-02f, -4.13995832e-02f,
  -9.79350060e-02f, 7.17973337e-02f, 9.18005481e-02f, 5.09540029e-02f, 7.04008192e-02f, -6.69647520e-03f, -2.46951114e-02f, -1.46751469e-02f, 6.31705001e-02f, 1.11448364e-02f,
  1.33258358e-01f, -2.80531585e-01f, -1.74364179e-01f, 8.71984512e-02f, 5.00291176e-02f, 1.67567864e-01f, 7.17987642e-02f, 4.35448103e-02f, 1.18712923e-02f, -1.25136167e-01f,
  -1.12185262e-01f, 1.92246392e-01f, 3.42638530e-02f, 7.78061524e-02f, 1.07433662e-01f, -1.49926364e-01f, -3.00512556e-02f, 4.75172810e-02f, 1.91662297e-01f, 1.47725359e-01f,
  5.23043685e-02f, -8.85000601e-02f, -1.56196095e-02f, -6.28770217e-02f, -1.80486590e-01f, 6.00105338e-03f, -2.05981851e-01f, -1.73605204e-01f, -1.92262098e-01f, -1.43942043e-01f,
  -1.58012323e-02f, 1.03712276e-01f, 1.13093905e-01f, 5.53798378e-02f, -7.04167783e-02f, -6.22844673e-04f, 1.20373465e-01f, -9.77239944e-03f, -6.86948001e-02f, -8.57136175e-02f,
  6.53878078e-02f, 9.47276130e-02f, 8.89463723e-02f, 6.33161291e-02f, 5.83157055e-02f, 3.73111106e-02f, -8.64512473e-02f, -1.96551271e-02f, -1.21792359e-02f, -7.30002718e-03f,
  -1.78345099e-01f, -3.07771694e-02f, 1.66377909e-02f, 8.89137164e-02f, 3.03015346e-03f, 2.05741581e-02f, -1.37565032e-01f, 1.17654894e-02f, 4.65267710e-03f, 9.22036823e-03f,
  -1.32810092e-02f, 3.67696807e-02f, -2.89821271e-02f, 7.51578808e-02f, 6.49778619e-02f, 6.53325208e-03f, 3.40221040e-02f, -1.23075340e-02f, 6.40708655e-02f, -1.26280174e-01f,
  -2.79351324e-02f, 4.22375364e-04f, 6.43219873e-02f, -4.44390476e-02f, -2.29518116e-02f, -3.11999358e-02f, 6.32958636e-02f, -4.40179892e-02f, -2.22312622e-02f, -5.61731234e-02f,
  -1.48090078e-02f, 1.05708474e-02f, 2.38551947e-05f, 2.72994265e-02f, -5.33120707e-02f, -7.82900676e-02f, 2.56995540e-02f, 2.74442323e-02f, -9.63923857e-02f, -9.63603258e-02f,
  1.70244217e-01f, 1.62730932e-01f, 8.11820403e-02f, 1.18558586e-01f, 2.28634700e-02f, -3.48939151e-02f, -1.70663800e-02f, 6.77561611e-02f, 3.10737584e-02f, -2.00768765e-02f,
  3.19530517e-02f, -1.08669549e-02f, -7.81959221e-02f, -5.20690084e-02f, 4.47972976e-02f, 1.09397799e-01f, -1.03250600e-01f, 8.63346681e-02f, 1.12460963e-02f, -9.66653675e-02f,
  -1.18921243e-01f, 1.37048736e-01f, 2.51964003e-01f, 1.69461206e-01f, 4.48254459e-02f, 1.59853131e-01f, -5.02626747e-02f, 7.32765198e-02f, 8.28985348e-02f, 1.31509855e-01f,
  4.10445273e-01f, 3.11521441e-01f, 1.42706856e-01f, 7.88095072e-02f, -9.60520953e-02f, -8.39398131e-02f, -2.11578086e-02f, -9.12241042e-02f, 7.50642344e-02f, 1.01301663e-01f,
  7.97304437e-02f, -1.21311404e-01f, -3.39753255e-02f, -7.48581663e-02f, -7.45858476e-02f, 6.62281504e-03f, 4.16370928e-02f, -2.29119114e-03f, -1.42259479e-01f, -1.71119764e-01f,
  2.63442323e-02f, 4.62597683e-02f, 1.71759292e-01f, -4.20007408e-02f, 1.08256578e-01f, -8.44361782e-02f, 9.88465548e-02f, 1.25124604e-01f, 1.04622588e-01f, 1.65411770e-01f,
  2.69027740e-01f, 2.55147666e-01f, -1.76803544e-01f, 4.89514731e-02f, 2.52124388e-02f, 9.40412655e-02f, 8.18653181e-02f, 6.91718683e-02f, 8.31302255e-03f, 2.06243861e-02f,
  2.39134976e-03f, 1.26750246e-01f, 1.18220411e-01f, 3.43117639e-02f, 6.59465939e-02f, -1.39949732e-02f, 1.12193316e-01f, 1.44646227e-01f, -3.09081040e-02f, -2.75005251e-02f,
  -1.15915991e-01f, -9.53681692e-02f, 2.32019443e-02f, -1.29817978e-01f, 6.39590845e-02f, -1.57057226e-01f, 8.67333263e-02f, 2.71859877e-02f, -4.65253331e-02f, 1.21123306e-01f,
  -2.90948786e-02f, 1.13737941e-01f, 6.69476390e-02f, 7.88047314e-02f, -1.30805653e-02f, -5.13881408e-02f, -4.79124039e-02f, -1.26677612e-02f, -2.29123402e-02f, 3.70718096e-03f,
  3.55597809e-02f, -2.14149039e-02f, 5.05092146e-04f, -2.35141665e-02f, 7.14216381e-03f, -4.30697948e-03f, 8.30404311e-02f, -4.02296260e-02f, -6.60345629e-02f, 4.40646298e-02f,
  -2.83246045e-03f, -2.82754283e-02f, 4.69056703e-02f, -4.03413922e-02f, -6.27301335e-02f, 5.54528609e-02f, -1.09175062e-02f, -3.31932157e-02f, -2.12734789e-02f, 5.78136928e-02f,
  1.01455860e-01f, -2.26934105e-01f, 5.84437065e-02f, 5.50766513e-02f, -3.06118149e-02f, -2.38115210e-02f, -2.45915335e-02f, -7.16774613e-02f, 5.71774133e-02f, -1.67760681e-02f,
  -3.39125330e-03f, -1.42088467e-02f, 7.95417726e-02f, -2.91363318e-02f, -2.98099592e-02f, -4.48095277e-02f, -2.70085931e-02f, -1.27119765e-01f, 1.21082468e-02f, 5.43320328e-02f,
  -5.79439141e-02f, -1.25214592e-01f, -2.40458027e-01f, -7.83630908e-02f, -1.39650762e-01f, -2.37605155e-01f, -1.29027575e-01f, -1.74761843e-02f, -1.43228501e-01f, 7.97810033e-03f,
  -3.77511621e-01f, -1.79224730e-01f, -2.23695021e-02f, 1.89230993e-01f, 2.17972159e-01f, -1.15156732e-01f, -5.63297747e-03f, -2.93260217e-02f, 1.34186357e-01f, 6.46385029e-02f,
  5.11631966e-02f, 1.92855880e-01f, 1.30323902e-01f, 1.30572736e-01f, -3.92952673e-02f, 1.03112184e-01f, 1.65824145e-01f, 1.12099476e-01f, -9.05838683e-02f, 9.39579867e-03f,
  2.31199890e-01f, 1.10415258e-01f, -6.44337432e-03f, -3.54368240e-02f, 1.33896932e-01f, 1.33504510e-01f, -4.46366705e-02f, -3.28060728e-03f, 1.00781463e-01f, 3.90762091e-01f,
  1.02449981e-02f, -2.30488911e-01f, 4.43343408e-02f, 1.36673838e-01f, -3.02702677e-03f, -1.97450355e-01f, 1.24428393e-02f, -3.80415730e-02f, -5.49346544e-02f, -3.36400382e-02f,
  7.88085386e-02f, -4.21056449e-02f, 7.74464756e-03f, 4.45781685e-02f, -7.11968616e-02f, -9.31905285e-02f, -1.36585623e-01f, -2.07220647e-03f, -3.08256503e-02f, 8.53684824e-03f,
  1.50650784e-01f, 4.36681844e-02f, -7.94343725e-02f, -1.25288367e-01f, 1.08698728e-02f, -1.90111659e-02f, -7.11472183e-02f, -2.50634961e-02f, -1.80499479e-01f, -6.71719685e-02f,
  6.42136037e-02f, 4.92710844e-02f, 2.37799678e-02f, -1.20117608e-02f, 9.68675539e-02f, 1.59183443e-02f, 1.96028110e-02f, 6.63781166e-02f, -7.09687592e-03f, 3.86441015e-02f,
  8.84974003e-02f, -1.85023770e-02f, -3.01597044e-02f, -5.50437607e-02f, 2.75849402e-02f, -3.89614999e-02f, 3.50664221e-02f, -4.13639173e-02f, -7.01908246e-02f, -6.62637427e-02f,
  7.01152310e-02f, -2.42845039e-03f, -3.10164038e-02f, 3.45018469e-02f, 2.62459721e-02f, 9.60211381e-02f, -2.70226710e-02f, -4.61698957e-02f, -5.19223139e-02f, 2.36044973e-02f,
  -1.72763653e-02f, -1.01225965e-01f, 6.96642045e-03f, -3.25124748e-02f, 3.22498120e-02f, -3.24281603e-02f, 5.27563691e-02f, -1.10277012e-02f, -5.67768924e-02f, -8.31474215e-02f,
  -2.72608865e-02f, 2.10721027e-02f, -6.07370399e-02f, 1.57153606e-02f, -6.34639114e-02f, 6.33612182e-03f, -4.69445288e-02f, 2.82015223e-02f, -4.81394418e-02f, -4.57235575e-02f,
  -3.88916098e-02f, -9.16660279e-02f, -8.39231759e-02f, -1.46899030e-01f, -9.08936337e-02f, 1.66547322e-03f, -1.80932894e-01f, -1.06919885e-01f, -1.62545651e-01f, -2.55658865e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  8.86473730e-02f, 1.13651410e-01f, 8.22602808e-02f, 1.72823250e-01f, 1.51969180e-01f, 2.74791002e-01f, 2.49019295e-01f, 1.09749600e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.37099528e-01f, 8.26054364e-02f, -1.85235575e-01f, 1.51245713e-01f, -1.81169733e-01f, -1.68713361e-01f, 1.20640315e-01f, -8.21921974e-02f, -3.05898696e-01f, 8.63457620e-02f,
  -2.05208540e-01f, 1.10815160e-01f, -2.41794601e-01f, -1.71357080e-01f, 1.46125376e-01f, 5.08563817e-01f, -5.19864075e-02f, 1.86454490e-01f, -4.65885043e-01f, 2.38338605e-01f,
  -4.94531244e-01f, 4.14599717e-01f, 4.08240288e-01f, -7.68679529e-02f, -1.01096325e-01f, -9.10071749e-03f, -1.18812928e-02f, -2.61513054e-01f, -9.41988379e-02f, -4.41614419e-01f,
  2.89909661e-01f, -1.36282984e-02f, -1.45284772e-01f, 1.90368712e-01f, 8.74514952e-02f, 3.10686678e-01f, 5.56634665e-02f, -2.55184412e-01f, 1.33104950e-01f, -4.15469885e-01f,
  4.22991291e-02f, -3.08993962e-02f, -1.25816613e-01f, -8.49240720e-02f, -1.10954054e-01f, -4.50662911e-01f, 2.97879457e-01f, 6.09081350e-02f, -7.44266361e-02f, 3.67679119e-01f,
  -3.57291639e-01f, 2.10631147e-01f, 2.47387007e-01f, -4.09003675e-01f, -2.14800909e-01f, -4.27280545e-01f, -1.10005453e-01f, -1.14014164e-01f, -2.80449480e-01f, -2.54072249e-01f,
  -7.00720325e-02f, 7.50983804e-02f, 2.04514682e-01f, -1.24424770e-01f, -2.58327007e-01f, 2.79033612e-02f, -6.31776974e-02f, 1.87294245e-01f, -3.37831415e-02f, 3.90615642e-01f,
  -1.78575218e-02f, 6.13492765e-02f, -1.07021645e-01f, 8.07725415e-02f, 4.10718983e-03f, -3.33546966e-01f, 3.64185512e-01f, 1.82196811e-01f, 4.78363574e-01f, -1.27236038e-01f,
  -4.12328273e-01f, 4.14544731e-01f, 3.01145911e-02f, 4.44135368e-01f, 3.30457598e-01f, -2.63288617e-01f, -2.39795193e-01f, -2.49639630e-01f, 3.03908531e-02f, 1.12136155e-01f,
  -1.95380285e-01f, 1.69647008e-01f, 1.05913207e-01f, 1.86673686e-01f, -1.97709069e-01f, 5.85552305e-02f, -2.22546592e-01f, 1.99722201e-01f, 1.73462525e-01f, 3.50026116e-02f,
  -3.57827060e-02f, -2.33342081e-01f, -1.35154366e-01f, -4.78013344e-02f, -1.40775770e-01f, -1.08248167e-01f, 2.13728890e-01f, 6.90030083e-02f, -1.31923556e-01f, -1.54607639e-01f,
  -3.04564923e-01f, 6.48199320e-02f, 2.43341178e-02f, -3.86880338e-01f, 1.79483831e-01f, -6.40993834e-01f, 2.14929134e-01f, -2.17505738e-01f, 1.72367245e-01f, 3.29311937e-02f,
  1.19361199e-01f, -2.00864539e-01f, -4.93845269e-02f, -1.42010748e-01f, 2.13465735e-01f, 1.77317768e-01f, -5.05845249e-01f, 2.38675460e-01f, 3.75236124e-02f, 4.51890796e-01f,
  5.57916939e-01f, 2.78989881e-01f, 7.90050477e-02f, -2.64122427e-01f, 1.89103007e-01f, -2.82595515e-01f, -1.39531093e-02f, 8.16122144e-02f, -2.21327469e-01f, 2.49803260e-01f,
  1.15703546e-01f, 1.10328577e-01f, -2.49318779e-01f, 1.82773128e-01f, -3.99950027e-01f, 1.61864132e-01f, 1.84319556e-01f, -8.54490027e-02f, 3.60903502e-01f, -5.32603741e-01f,
  -6.32238388e-01f, -2.38320008e-01f, -8.91622752e-02f, 4.07404155e-02f, -1.83086485e-01f, 2.52808243e-01f, -6.24108911e-02f, 5.04681766e-02f, -1.60878703e-01f, -7.04709589e-02f,
  -2.69830137e-01f, 3.17721516e-01f, 1.94153205e-01f, 3.93211007e-01f, -2.04783991e-01f, 3.00553560e-01f, -1.00240707e-01f, 8.96405652e-02f, -2.14430258e-01f, 1.45090148e-01f,
  -3.82453166e-02f, -2.49869794e-01f, -6.35202825e-01f, -2.37045929e-01f, 5.46929538e-01f, -8.25852305e-02f, -1.64528698e-01f, 3.44807923e-01f, -4.40785378e-01f, 2.92701513e-01f,
  1.70576721e-01f, 1.32104725e-01f, 5.70980459e-02f, -2.03063730e-02f, 1.46942884e-01f, -1.75686404e-02f, 2.66734451e-01f, -1.82408780e-01f, -1.31573543e-01f, 1.78727824e-02f,
  3.21285754e-01f, 1.82248116e-01f, -7.07714617e-01f, 4.75853644e-02f, 1.91944897e-01f, -1.64034277e-01f, -2.78877735e-01f, 3.18414479e-01f, -3.27109039e-01f, 3.18596482e-01f,
  5.27116768e-02f, -1.37310982e-01f, 1.14435606e-01f, -5.05987287e-01f, 9.32657346e-03f, 6.33180588e-02f, -8.34420621e-02f, -1.35724172e-01f, -4.96075094e-01f, 1.57179892e-01f,
  9.41186771e-02f, 1.32209465e-01f, -2.77097411e-02f, 1.56987980e-02f, -2.80979156e-01f, 1.10230327e-01f, 1.59649625e-01f, 2.82154628e-03f, 5.04370779e-02f, 1.61173418e-01f,
  -2.61305552e-02f, 2.29281455e-01f, -2.28203952e-01f, 3.18059087e-01f, -4.34001476e-01f, 2.53735751e-01f, 1.86180726e-01f, 1.55496642e-01f, -2.95019507e-01f, -4.13739622e-01f,
  -2.79615998e-01f, -2.04825163e-01f, -4.68620434e-02f, -2.08893061e-01f, -1.44188240e-01f, 1.89347729e-01f, -3.56835544e-01f, -2.74802506e-01f, -9.82690006e-02f, 5.68891764e-01f,
  -1.23553440e-01f, 3.19425076e-01f, -1.59340471e-01f, -2.08450735e-01f, -5.02547342e-03f, -2.34108537e-01f, 8.41352120e-02f, -4.17534232e-01f, -1.49993151e-01f, -1.26009598e-01f,
  -2.15511516e-01f, 2.40106776e-01f, 2.02865645e-01f, 3.02576870e-01f, -2.41484419e-01f, 2.37553388e-01f, -4.13497210e-01f, -8.76455661e-03f, 4.44055758e-02f, 1.58834174e-01f,
  -1.52235314e-01f, 3.28198671e-01f, -8.86730403e-02f, 2.64868259e-01f, 1.87854484e-01f, -4.00909707e-02f, 1.12385981e-01f, -3.38295400e-01f, -1.68850586e-01f, 3.99892360e-01f,
  -2.05822378e-01f, -1.85148254e-01f, -3.95379812e-01f, 2.61733830e-01f, 3.59300017e-01f, 2.96795189e-01f, -3.90745848e-01f, 2.30665892e-01f, -4.99371022e-01f, 2.13371873e-01f,
  -2.61449337e-01f, -1.31903931e-01f, 2.48313308e-01f, 6.22867197e-02f, -2.18497619e-01f, -1.51808277e-01f, 2.65510986e-03f, 4.32834446e-01f, 1.84520379e-01f, -3.73594105e-01f,
  -3.50880682e-01f, -2.19071329e-01f, 4.29816172e-02f, 6.54078498e-02f, 5.49534522e-02f, 1.31868809e-01f, -2.10906975e-02f, -7.00474158e-02f, -5.16991690e-03f, -1.66298389e-01f,
  -3.92433971e-01f, -6.39586523e-02f, 6.14796519e-01f, -3.00768286e-01f, 2.32291520e-01f, -1.32548492e-02f, -3.49978477e-01f, 1.72737256e-01f, -1.77684262e-01f, 4.68279719e-01f,
  4.25665557e-01f, 2.74889827e-01f, 1.89519271e-01f, 1.38999093e-02f, 1.84461802e-01f, 1.34767368e-01f, -1.59586579e-01f, -3.21162976e-02f, 3.99746895e-01f, -2.46253416e-01f,
  -6.88139126e-02f, 2.37845212e-01f, -1.74054597e-02f, 1.91186890e-01f, -3.05998713e-01f, 1.45073652e-01f, -1.30357429e-01f, 1.25093520e-01f, -1.43228278e-01f, 8.46178681e-02f,
  -9.92453694e-02f, 1.06961884e-01f, -3.85114133e-01f, -6.82270229e-02f, 2.19880357e-01f, 3.13511968e-01f, -3.29565406e-01f, 2.42291927e-01f, -3.86192203e-01f, 2.96811998e-01f,
  -3.06067377e-01f, 3.49352866e-01f, 3.49364340e-01f, 1.74670387e-02f, 3.87386605e-02f, 4.53656949e-02f, 1.41469792e-01f, -2.88378119e-01f, 7.78024495e-02f, -4.03083563e-01f,
  8.77183303e-02f, 2.24976182e-01f, 5.02998531e-01f, 4.15925115e-01f, 3.40587646e-01f, 3.30213249e-01f, -3.68222445e-02f, -1.64389282e-01f, 1.17524669e-01f, 2.61663664e-02f,
  -2.09413946e-01f, -9.80152637e-02f, -2.75886327e-01f, 6.72985196e-01f, -2.92163849e-01f, 1.57545477e-01f, -2.73933828e-01f, 3.44579428e-01f, -2.12469831e-01f, -2.48585623e-02f,
  -2.51988601e-02f, 2.24218220e-01f, 1.58137754e-01f, -3.32172334e-01f, -3.40867966e-01f, 2.01208070e-01f, -3.28336149e-01f, 6.26997277e-02f, 1.58270717e-01f, 1.56234846e-01f,
  -1.15318090e-01f, -2.67796636e-01f, 2.24092782e-01f, 4.98466454e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -8.60763863e-02f, -2.15428844e-02f, 1.97071984e-01f, 2.47147962e-01f, 1.43200353e-01f, 2.20555887e-01f, -1.77523550e-02f, 1.82264313e-01f, 1.02555953e-01f, 2.62974381e-01f,
  1.68763578e-01f, 1.01130836e-01f, -1.54779539e-01f, -8.16949084e-03f, -1.07066743e-01f, -5.85026518e-02f, -5.50202668e-01f, 4.68650252e-01f, 1.78100839e-01f, 5.51643670e-01f,
  -2.37682983e-02f, 1.51218846e-01f, -4.20489043e-01f, 4.99497615e-02f, -1.46055073e-01f, -1.40988529e-02f, 2.28780910e-01f, 3.32434535e-01f, 1.96366996e-01f, 8.46095681e-02f,
  1.29434884e-01f, 4.12501603e-01f, 3.69505554e-01f, -8.71902555e-02f, 6.08487576e-02f, 2.06608370e-01f, 6.70828000e-02f, 2.95838088e-01f, 1.37682423e-01f, 5.63893497e-01f,
  1.43851295e-01f, 4.02484648e-02f, -2.54008770e-02f, 2.33887389e-01f, -2.96430856e-01f, 2.29268491e-01f, -2.11842477e-01f, -3.46731693e-01f, 1.45973593e-01f, -2.55576879e-01f,
  6.87033013e-02f, -1.78122148e-01f, -4.17205423e-01f, 6.21868134e-01f, 3.55954647e-01f, 5.00488997e-01f, 2.31738865e-01f, 2.82087862e-01f, 5.55662692e-01f, 2.67880764e-02f,
  -1.93546101e-01f, -1.49310067e-01f, 4.05601747e-02f, 2.85590321e-01f, -3.55658799e-01f, -2.83826049e-02f, -3.17064933e-02f, 6.24000803e-02f, 1.40479982e-01f, 2.73827940e-01f,
  2.00974181e-01f, 8.83090124e-02f, 3.44207734e-02f, 1.55527800e-01f, 3.15657526e-01f, -1.55059189e-01f, 1.75561875e-01f, -3.68838400e-01f, 3.59836787e-01f, 1.88630030e-01f,
  1.91534497e-02f, 2.53581941e-01f, 1.15141440e-02f, -2.48403206e-01f, -6.92052469e-02f, 1.30480062e-02f, 4.08753008e-01f, -4.14860576e-01f, 2.82564461e-01f, -1.84864730e-01f,
  -2.64277041e-01f, -2.03003585e-01f, 4.97969151e-01f, 3.90465915e-01f, -1.91809699e-01f, 2.45273605e-01f, -9.91220102e-02f, -2.26340517e-01f, 1.21533573e-01f, -2.82397807e-01f,
  1.15667447e-01f, -6.08345047e-02f, 2.07904026e-01f, 1.77968547e-01f, -8.46058354e-02f, -8.14810768e-02f, 3.62475365e-01f, -2.57498831e-01f, 3.74293402e-02f, 8.75386149e-02f,
  2.04071388e-01f, -4.37196344e-01f, 5.96027933e-02f, -5.74815199e-02f, 3.32234830e-01f, -5.18711563e-03f, 9.87316221e-02f, -1.58600718e-01f, -3.08205605e-01f, 1.48716941e-01f,
  -6.65964857e-02f, 8.49486515e-02f, 1.03218690e-01f, 1.35975674e-01f, 1.97605297e-01f, 6.19162843e-02f, 1.59011036e-01f, 1.66811854e-01f, 9.34699848e-02f, 8.50587264e-02f,
  4.67752427e-01f, -5.26141981e-03f, 1.28304809e-01f, 1.50469795e-01f, 1.54458731e-01f, 1.65161133e-01f, -1.95322961e-01f, 2.91254133e-01f, 3.58622760e-01f, -3.97046879e-02f,
  -2.15333611e-01f, 1.79566443e-01f, 2.94411451e-01f, -6.38775706e-01f, -1.01252317e-01f, -4.33787763e-01f, 1.28129780e-01f, -9.20619518e-02f, 3.67434561e-01f, -3.43190193e-01f,
  -1.16199985e-01f, 5.04824817e-01f, 1.66296870e-01f, 2.03069791e-01f, -6.29471466e-02f, 4.54562381e-02f, -1.06610246e-01f, 4.73553389e-02f, 3.34394462e-02f, -3.08736842e-02f,
  7.63938501e-02f, 1.45253003e-01f, -2.52263318e-03f, 1.46401823e-01f, 1.58516392e-01f, -1.27253443e-01f, -3.37162497e-03f, -1.46256939e-01f, -9.31111127e-02f, -1.28581181e-01f,
  8.26619640e-02f, 1.46241069e-01f, 2.53389746e-01f, -7.29280710e-02f, -2.27051452e-01f, 3.32042009e-01f, 9.41589624e-02f, -1.11081265e-01f, 1.27040550e-01f, -1.78288698e-01f,
  2.68333584e-01f, -2.50893161e-02f, -3.83275561e-02f, -7.74431005e-02f, -1.44831538e-01f, 1.28091007e-01f, -2.64979936e-02f, 6.33336231e-02f, 7.93079808e-02f, 2.88193254e-03f,
  -1.90524701e-02f, -1.94501862e-01f, 8.38179290e-02f, 1.21501116e-02f, 1.07213184e-01f, -2.08495244e-01f, 1.44512653e-01f, -5.61721772e-02f, -5.40178157e-02f, 9.02461410e-02f,
  3.30259092e-02f, -4.87678833e-02f, 2.44257718e-01f, -1.57268465e-01f, 1.41150475e-01f, 6.36809766e-02f, -5.09748422e-02f, -1.04883298e-01f, -3.98216420e-04f, -1.85910061e-01f,
  1.32988125e-01f, 1.51676312e-01f, 2.41482407e-01f, 2.00833976e-02f, -1.53890744e-01f, 1.50109813e-01f, 6.21411242e-02f, -1.64124630e-02f, 1.55957490e-01f, 1.47850616e-02f,
  5.59662730e-02f, 7.35577568e-02f, 1.80814907e-01f, 3.35345417e-02f, 1.06074616e-01f, -1.19241022e-01f, 6.63177818e-02f, -1.53825834e-01f, 1.01750575e-01f, 3.49728204e-02f,
  1.18041232e-01f, -1.81968674e-01f, 1.04513101e-01f, 1.42476812e-01f, 1.36229098e-01f, -1.68769360e-01f, -7.35320970e-02f, -2.49111205e-01f, 1.58719286e-01f, -1.80442095e-01f,
  -1.23278186e-01f, -2.06276383e-02f, -7.79621452e-02f, -1.37681738e-01f, -7.22378418e-02f, 8.73355642e-02f, -1.51267275e-01f, -1.27890989e-01f, 2.43793517e-01f, 2.35130176e-01f,
  1.33116275e-01f, -1.86359093e-01f, -7.46287331e-02f, 8.08775723e-02f, 1.77374482e-01f, 1.45634353e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.13118601e-01f, 2.00725421e-01f, 2.74691224e-01f, 3.93573716e-02f, 1.38261065e-01f, 2.09291026e-01f, -3.60147245e-02f, 1.86507389e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -3.48219872e-01f, -2.90835202e-01f, 2.18435097e-02f, 1.31631956e-01f, -2.20952839e-01f, -5.72324812e-01f, 3.00874621e-01f, -7.05405295e-01f, 1.14221513e-01f, 2.24613026e-01f,
  -4.18160260e-01f, -6.03516340e-01f, -5.26721835e-01f, -1.73184484e-01f, -5.77760875e-01f, 6.65269941e-02f, -5.38183808e-01f, -5.10824621e-01f, 6.66229054e-02f, -2.11086199e-01f,
  1.67646930e-01f, 3.51013660e-01f, -6.41284943e-01f, -1.10629559e+00f, -3.75805110e-01f, 2.72747487e-01f, -3.11668105e-02f, 3.75882596e-01f, 1.23483889e-01f, -8.13624710e-02f,
  2.02311903e-01f, 3.49744320e-01f, -8.34652603e-01f, -2.27837920e-01f, -3.42478037e-01f, 2.12699741e-01f, -1.47928253e-01f, 2.45073229e-01f, -6.74685389e-02f, -6.23807162e-02f,
  3.67922217e-01f, -1.13856308e-01f, -3.87443870e-01f, 2.26016968e-01f, -6.53894544e-02f, -1.05868541e-01f, 6.86355352e-01f, 1.96386263e-01f, 5.62132299e-01f, -3.33046198e-01f,
  8.36387813e-01f, -2.35841230e-01f, 3.91212612e-01f, -2.99182653e-01f, -4.11638737e-01f, -3.78523469e-02f, 3.64358574e-01f, -6.16015315e-01f, 8.40663835e-02f, 6.10047698e-01f,
  5.78638613e-01f, -7.42166787e-02f, 2.56756961e-01f, -2.36126572e-01f, 3.82443458e-01f, 5.60220063e-01f, 4.85688113e-02f, 1.19372487e-01f, -5.15542090e-01f, 7.12580085e-01f,
  3.09010632e-02f, 1.51811481e-01f, -5.13035059e-01f, -3.66024494e-01f, 6.18183553e-01f, -7.91429877e-01f, -4.36825544e-01f, -2.23717183e-01f, 5.42688966e-01f, -5.86766541e-01f,
  3.10566515e-01f, -2.66667396e-01f, 1.38311923e-01f, -5.77902436e-01f, 7.48358011e-01f, -4.65175211e-01f, 4.03363891e-02f, 3.03170025e-01f, 4.71827984e-01f, -7.31519088e-02f,
  -3.32893431e-01f, -1.74188554e-01f, -1.47452325e-01f, 1.25463396e-01f, -1.24620751e-01f, -3.49899471e-01f, 5.94257951e-01f, -1.33592829e-01f, -4.33794886e-01f, 1.27408072e-01f,
  4.96865064e-01f, 2.01324478e-01f, -2.57086158e-01f, 3.81106049e-01f, 1.33030638e-01f, 2.97918916e-01f, 3.71419221e-01f, 2.96266168e-01f, 4.04382735e-01f, -6.94887221e-01f,
  -2.77290046e-01f, 3.30214977e-01f, -2.42187440e-01f, -3.30145508e-01f, -4.24642533e-01f, -4.23565537e-01f, -4.83267903e-01f, 1.15643047e-01f, 9.54990685e-02f, 3.07478845e-01f,
  -6.21631324e-01f, 5.11090815e-01f, -1.19072817e-01f, -3.18540633e-01f, -1.86840519e-01f, 9.78542790e-02f, -3.40827167e-01f, -1.04476310e-01f, 4.66290802e-01f, -4.38190132e-01f,
  -7.03821555e-02f, 1.19300380e-01f, -3.35450590e-01f, 6.67844176e-01f, 5.36648519e-02f, -5.64081967e-01f, -2.28884831e-01f, -3.79884154e-01f, 4.37615037e-01f, 6.53977334e-01f,
  -1.32549927e-01f, -3.66794109e-01f, -3.89563560e-01f, -5.19434094e-01f, -6.09122276e-01f, -9.69908684e-02f, -2.42970258e-01f, 1.07580796e-01f, 7.79071033e-01f, 5.03625691e-01f,
  -1.22585259e-01f, -2.11300462e-01f, -1.02860063e-01f, 6.72998369e-01f, -2.91038692e-01f, -6.39467537e-02f, 1.51361153e-01f, -2.49587253e-01f, 6.71214536e-02f, -2.71348983e-01f,
  -5.39067328e-01f, 1.40624046e-01f, 4.64244545e-01f, 1.49744049e-01f, 3.35394889e-01f, 4.81007367e-01f, 2.67871976e-01f, -5.10065138e-01f, 3.33497465e-01f, 4.96517479e-01f,
  1.88374817e-01f, -9.61200148e-02f, -6.38738573e-01f, -4.13866788e-02f, 1.35500565e-01f, 1.60515696e-01f, 4.37973201e-01f, 2.04979822e-01f, -4.53962654e-01f, -5.05279243e-01f,
  -6.20972216e-01f, 2.02236757e-01f, -3.66340727e-01f, 4.09758627e-01f, -1.81036204e-01f, 2.33209357e-02f, -2.32432246e-01f, 2.49281585e-01f, 9.68572497e-01f, -1.39240578e-01f,
  8.46954733e-02f, 1.63597956e-01f, 1.80158183e-01f, -6.83375239e-01f, 2.73080111e-01f, -3.73213977e-01f, -1.72860280e-01f, -4.44933593e-01f, 2.72410244e-01f, 4.28430021e-01f,
  3.29308897e-01f, 4.77238595e-01f, 9.24022123e-02f, -5.95571041e-01f, 8.01582575e-01f, 7.69690216e-01f, -1.30562158e-02f, -4.59212214e-01f, 5.96522748e-01f, 5.03819704e-01f,
  -3.38320971e-01f, 3.25219899e-01f, 5.96604884e-01f, 2.27679595e-01f, 3.45023066e-01f, 4.04244840e-01f, 3.80488992e-01f, -5.55276692e-01f, -2.84945756e-01f, 5.42807803e-02f,
  -1.24989375e-01f, -1.84955522e-02f, 1.05879962e-01f, 3.09160113e-01f, -1.18351979e-02f, 9.15501937e-02f, -2.30042189e-01f, -2.92150266e-02f, 7.78091550e-02f, -8.16381991e-01f,
  -2.47349262e-01f, -4.79314148e-01f, -2.29514807e-01f, 1.05786011e-01f, -6.64062262e-01f, 3.08072448e-01f, 4.77615416e-01f, 3.41145426e-01f, 3.36561322e-01f, 4.64123935e-01f,
  -7.78897479e-02f, 2.57044196e-01f, 7.79032171e-01f, 4.96436864e-01f, 3.85087043e-01f, -1.03515163e-02f, 3.27073842e-01f, -5.93406677e-01f, 2.65764087e-01f, -2.07109854e-01f,
  6.73854589e-01f, -1.22737467e-01f, -6.04478195e-02f, -1.13026835e-01f, -1.71736032e-01f, 1.44926399e-01f, 4.22535658e-01f, -2.61283386e-02f, -3.43756080e-01f, 1.48925617e-01f,
  -4.25440818e-03f, 2.03129351e-01f, 7.64200464e-02f, 2.08277449e-01f, -4.42390829e-01f, 2.33335391e-01f, 3.87034237e-01f, 3.42717856e-01f, -4.25729185e-01f, 7.47816443e-01f,
  7.06283867e-01f, 2.87969500e-01f, 2.01338857e-01f, 1.76972106e-01f, -7.52249211e-02f, 4.13212717e-01f, -8.81705463e-01f, -2.57215381e-01f, -4.05218452e-01f, -3.90594155e-01f,
  -2.14331046e-01f, -4.19288099e-01f, 8.01532090e-01f, -7.31869638e-02f, -3.42879891e-01f, 1.90656260e-01f, 3.20410132e-02f, -1.48642629e-01f, 3.64524066e-01f, 4.42924142e-01f,
  -1.50499055e-02f, 2.60933816e-01f, 3.78114790e-01f, -4.78873640e-01f, 2.63473213e-01f, -3.05414088e-02f, -7.97853053e-01f, 1.31687805e-01f, -1.94672570e-01f, -5.37601233e-01f,
  2.51647055e-01f, -1.49527118e-01f, -2.30322048e-01f, -7.50089586e-02f, 1.22303061e-01f, 7.19185948e-01f, 6.62989974e-01f, 7.61468932e-02f, 4.24208552e-01f, 1.69416517e-01f,
  5.30831933e-01f, 2.83067763e-01f, 4.92811114e-01f, 5.63858092e-01f, -5.08800685e-01f, -1.54617056e-02f, -1.87307134e-01f, -1.65009186e-01f, 5.01393713e-02f, 6.57460419e-03f,
  -1.92463189e-01f, 5.22901475e-01f, 2.25163668e-01f, -5.19924700e-01f, -1.31298944e-01f, -2.61732310e-01f, -4.67454083e-02f, 2.69604176e-01f, -9.78588015e-02f, -4.60010916e-01f,
  -5.55943176e-02f, -5.85230589e-02f, -5.26850939e-01f, -8.08491558e-03f, -6.70199335e-01f, 7.27231145e-01f, 4.41528916e-01f, -6.97031856e-01f, -4.81533736e-01f, 2.86169231e-01f,
  -7.09066629e-01f, -6.64264441e-01f, -5.95749140e-01f, 4.83265519e-01f, -3.95638108e-01f, -4.73965585e-01f, -2.31031291e-02f, -6.12394661e-02f, 4.92328517e-02f, 4.90819037e-01f,
  7.12588355e-02f, -9.55969766e-02f, -2.62615234e-01f, 6.47347271e-01f, 4.54110742e-01f, -2.97274113e-01f, -2.21543456e-03f, -2.00271551e-02f, 6.04246743e-02f, 2.41255909e-01f,
  3.33276510e-01f, -2.99219668e-01f, -2.61077851e-01f, 3.25933158e-01f, 6.96667492e-01f, 4.59635317e-01f, 1.03999384e-01f, -5.01937091e-01f, -9.10763264e-01f, 5.11149049e-01f,
  -4.93490398e-01f, -1.28013343e-01f, -7.19235241e-01f, 8.48804116e-01f, 5.47597229e-01f, 2.59481892e-02f, -2.52991561e-02f, -3.11900768e-02f, 1.73170984e-01f, -6.46457896e-02f,
  -3.29129249e-01f, 3.84365730e-02f, -2.42581274e-02f, 2.13550031e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.64030373e-01f, 1.29361033e-01f, -6.00917786e-02f, -3.02809500e-03f, -8.31892714e-02f, -2.01325804e-01f, 3.61931734e-02f, 6.47405535e-02f, -9.92165953e-02f, -2.37767786e-01f,
  1.20044477e-01f, 2.17128649e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    