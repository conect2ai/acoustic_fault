/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.93553382e-01f, 3.83457780e-01f, -7.87512909e-05f, 2.15116888e-01f, -6.82995915e-02f, -2.21403092e-01f, -3.62308621e-02f, 1.03637002e-01f, 1.57050103e-01f, 2.28375033e-01f,
  2.29599867e-02f, 1.17229342e-01f, 4.60499898e-03f, 1.66911364e-01f, -3.52585286e-01f, -6.24173880e-02f, -8.21851417e-02f, 6.46092221e-02f, 2.19614506e-02f, 8.61312076e-02f,
  2.69857962e-02f, 1.12046011e-01f, -1.15258493e-01f, 5.91568127e-02f, -1.55126313e-02f, 4.92968597e-02f, 2.85449391e-03f, -6.08899407e-02f, 1.67830288e-02f, -2.75684195e-03f,
  -8.34855810e-02f, 1.24223217e-01f, 3.43288183e-02f, -8.76987074e-03f, -1.28714994e-01f, -1.88019685e-02f, 6.17028400e-02f, -2.54633516e-04f, 1.90576576e-02f, 2.42887326e-02f,
  -2.29339395e-02f, 1.96435256e-03f, 3.92576084e-02f, -3.82812060e-02f, -3.05228457e-02f, 2.55087391e-02f, 4.20734845e-02f, 1.74154229e-02f, 6.87117800e-02f, 1.00028301e-02f,
  1.76614169e-02f, 1.10116424e-02f, -2.47784574e-02f, 1.11734504e-02f, 2.91119539e-03f, 8.14994518e-03f, 6.55232295e-02f, -6.24954849e-02f, 2.32114084e-02f, 3.66866589e-02f,
  -1.02547720e-01f, 1.22556672e-03f, 1.97681747e-02f, -1.71855055e-02f, 6.59033805e-02f, 3.26925814e-02f, -3.75902094e-03f, 4.70778495e-02f, -5.77778071e-02f, -7.97708705e-03f,
  -4.53919964e-03f, 8.81394222e-02f, 5.90366423e-02f, 1.17319589e-02f, 3.28041054e-02f, 6.07503839e-02f, -1.40337255e-02f, 5.39626516e-02f, -2.14864761e-02f, 2.20164992e-02f,
  1.03210770e-01f, 3.36021185e-02f, -2.15068590e-02f, -7.15242401e-02f, -1.18801221e-02f, 3.60089019e-02f, 1.02936383e-02f, 3.29722725e-02f, -7.92793836e-03f, -2.94592953e-03f,
  1.06945746e-01f, 2.50529796e-01f, -9.15639277e-04f, 2.52647083e-02f, -1.49896024e-02f, -3.69591489e-02f, -9.05302316e-02f, 4.99414131e-02f, 9.66882799e-03f, -1.25025241e-02f,
  -4.53855954e-02f, -1.38188386e-02f, -7.21830353e-02f, -2.84847673e-02f, -8.50490294e-03f, 4.56474200e-02f, 4.64192033e-03f, 4.55865115e-02f, -3.91953401e-02f, 1.02715380e-01f,
  6.08614367e-03f, 2.95317490e-02f, 2.19744397e-03f, 7.20083574e-03f, -1.65147930e-02f, -4.69398759e-02f, -8.15046877e-02f, 2.57954262e-02f, 3.12759317e-02f, -7.43453354e-02f,
  -4.44249297e-03f, -3.56977582e-01f, -1.44116119e-01f, -7.68353567e-02f, 6.86264262e-02f, 2.19551235e-01f, 2.13858649e-01f, -1.08965531e-01f, 1.37086570e-01f, -1.46956205e-01f,
  5.70708998e-02f, -6.41506165e-02f, 1.31565118e-02f, -2.46574990e-02f, 2.28837758e-01f, 2.01882035e-01f, 1.21061541e-01f, 1.57825872e-01f, 5.44399209e-02f, -9.54491049e-02f,
  -7.41980458e-03f, 7.88285434e-02f, -6.87454715e-02f, -1.65464357e-01f, -1.34455860e-01f, -2.82689452e-01f, -9.02691111e-02f, -5.15824445e-02f, -2.07584023e-01f, 6.44932762e-02f,
  1.28221989e-01f, -1.94007847e-02f, -8.89120772e-02f, 2.52713487e-02f, -1.07305132e-01f, 2.49411929e-02f, 3.27930376e-02f, 3.82151231e-02f, 5.74495159e-02f, -7.00346455e-02f,
  5.79303354e-02f, 8.22195113e-02f, -1.37897372e-01f, 1.26564242e-02f, 3.14702801e-02f, 8.54230078e-04f, 4.24970314e-02f, 2.03365628e-02f, -2.49344762e-02f, 6.72829384e-03f,
  8.90481323e-02f, 3.03584766e-02f, 1.01677358e-01f, -3.40446010e-02f, -4.73288633e-02f, 6.34840280e-02f, 7.73733258e-02f, -4.83226217e-02f, -1.05289193e-02f, -2.99331415e-02f,
  -5.26686525e-03f, 6.18787669e-02f, 3.93215865e-02f, -4.80025038e-02f, 6.54378682e-02f, 4.80574258e-02f, 3.48958448e-02f, -1.69608928e-02f, 4.52683754e-02f, 4.92707081e-02f,
  -1.98223609e-02f, -5.87668549e-03f, 6.64899722e-02f, -1.01348646e-02f, -1.33570498e-02f, 1.14720101e-02f, 5.23855202e-02f, 3.11530419e-02f, -1.46460235e-02f, -1.51835103e-02f,
  6.03140891e-03f, 4.53798249e-02f, -6.11865669e-02f, -6.70118108e-02f, 5.44255562e-02f, -2.24461965e-03f, -1.25206141e-02f, 2.41335668e-02f, -2.38847006e-02f, -1.78004541e-02f,
  1.11992948e-03f, -1.31711841e-01f, -5.70285246e-02f, 5.76260611e-02f, 2.92494018e-02f, -5.77825531e-02f, 3.55899595e-02f, -6.43415079e-02f, -1.42944586e-02f, 2.55266987e-02f,
  -5.61346672e-02f, -2.61614155e-02f, 5.50726391e-02f, 6.45656958e-02f, -1.60480849e-03f, -1.34098576e-02f, -2.61851028e-02f, 5.18941060e-02f, -1.05765248e-02f, -5.06009646e-02f,
  -1.62423344e-03f, 5.94119988e-02f, 1.24831200e-02f, -6.76486716e-02f, -3.82025167e-02f, -9.14693177e-02f, 3.60398018e-03f, 3.55108939e-02f, -2.91527156e-03f, -4.12516668e-03f,
  3.73316288e-01f, 1.16884559e-01f, 2.28545353e-01f, 2.53451318e-01f, 7.01819360e-02f, 7.87697211e-02f, 2.14331582e-01f, 8.87106284e-02f, 2.87233442e-02f, -6.36849403e-02f,
  7.55183995e-02f, 1.39240876e-01f, -1.23102069e-01f, 1.91353470e-01f, 1.81774601e-01f, -1.26290604e-01f, 1.46059558e-01f, 9.62560847e-02f, 3.39676738e-02f, 1.19418301e-01f,
  2.84934770e-02f, 1.43833412e-02f, 1.34957731e-01f, 3.32041793e-02f, 2.51610756e-01f, 1.68631878e-02f, -1.05207056e-01f, -2.57220585e-03f, 1.57938614e-01f, 6.28688186e-02f,
  1.15240263e-02f, -5.27561568e-02f, 7.56659955e-02f, -2.49698590e-02f, -6.49843216e-02f, -3.88959073e-03f, 4.50676978e-02f, -5.02021518e-03f, 1.04842335e-02f, -2.54320074e-02f,
  -9.45537072e-03f, 2.63731387e-02f, -2.57401895e-02f, -2.13927981e-02f, 6.69359267e-02f, 5.02926894e-02f, 8.50033760e-02f, 3.95418219e-02f, 5.24574332e-02f, 2.26286054e-03f,
  -1.61334053e-02f, 1.59545094e-02f, 1.43771190e-02f, -1.58575438e-02f, 5.11722546e-03f, 2.24469770e-02f, 2.04754900e-02f, 1.55015178e-02f, 2.03295629e-02f, 1.21688726e-03f,
  -5.72036617e-02f, 2.42714211e-02f, 1.29018985e-02f, 4.99836430e-02f, -2.50189239e-03f, -1.41714709e-02f, -5.32774739e-02f, 8.50704964e-03f, -4.54872698e-02f, 4.61601280e-02f,
  1.28988251e-02f, 4.66928184e-02f, -8.05490837e-02f, -6.24889322e-03f, 4.99857450e-03f, -4.61331382e-02f, -2.94928160e-02f, -2.79883551e-03f, 1.86924133e-02f, -3.99787258e-03f,
  -6.06797775e-03f, 1.71382941e-04f, -1.09244855e-02f, -2.83398610e-02f, -5.22921700e-03f, 2.23932993e-02f, -4.11497876e-02f, 6.48043230e-02f, 1.32210059e-02f, -2.06555016e-02f,
  -9.00940746e-02f, -7.80350948e-03f, -2.78757699e-02f, 5.51522709e-02f, -5.52522205e-02f, -5.19234221e-04f, -5.64247444e-02f, -7.87112582e-03f, 6.92013744e-03f, -2.59695482e-02f,
  -3.88512686e-02f, 7.50082196e-04f, 5.23956027e-03f, -4.77163540e-03f, -2.54770014e-02f, -3.12991887e-02f, -5.86182736e-02f, 4.26885788e-04f, -5.42247072e-02f, 2.19031125e-02f,
  1.18191051e-03f, -3.97824980e-02f, -6.63147941e-02f, 5.64609393e-02f, -7.19981128e-03f, 1.67181753e-02f, -2.63932068e-02f, 1.29269930e-02f, -3.74294296e-02f, -2.22907979e-02f,
  -1.55651197e-01f, -2.52503287e-02f, -6.19529076e-02f, -7.70182535e-02f, -1.09879278e-01f, -4.87955799e-03f, 7.83098564e-02f, -1.02695182e-01f, 1.28580555e-01f, -4.44039218e-02f,
  5.57700023e-02f, -6.53107166e-02f, 2.00967222e-01f, -2.75230229e-01f, 2.60260403e-02f, 2.86207199e-01f, -1.99069187e-01f, -3.63257527e-02f, 1.16408490e-01f, -8.22770149e-02f,
  -2.22642571e-02f, -2.97053456e-01f, -4.72865999e-02f, -2.18719885e-01f, -1.38374925e-01f, -1.93447620e-02f, -1.63566709e-01f, 1.35507494e-01f, -1.90604433e-01f, -3.53226513e-02f,
  -1.82418898e-02f, 2.89199390e-02f, -7.25408569e-02f, -7.02552646e-02f, -3.93542787e-03f, -3.17330360e-02f, 4.50205756e-03f, -1.28247617e-02f, 8.77179652e-02f, 1.84850469e-02f,
  6.11595716e-03f, 1.55125500e-03f, -8.96440521e-02f, -5.37615642e-03f, -7.11321905e-02f, -2.18479820e-02f, 1.63220614e-02f, -2.32109316e-02f, -3.17751691e-02f, -1.01753045e-02f,
  1.48839112e-02f, -1.89979170e-02f, -4.36785854e-02f, 5.15516326e-02f, 5.91217764e-02f, 3.64569575e-02f, -6.92336634e-03f, 1.07383197e-02f, 2.39706337e-02f, -1.11671269e-03f,
  -5.46870567e-02f, 4.50809002e-02f, 1.44013269e-02f, -1.58788823e-02f, -3.82023118e-02f, 2.39131097e-02f, -7.08512366e-02f, 9.76628973e-04f, -2.23513786e-02f, -1.85728408e-02f,
  -5.17455861e-02f, 1.97962075e-02f, -5.79443015e-02f, 5.60000092e-02f, -3.97691445e-04f, -4.70446311e-02f, -4.61981818e-03f, 2.84259636e-02f, -1.12509346e-02f, 3.81490663e-02f,
  -2.70068143e-02f, 3.09968367e-02f, 3.31866369e-02f, 8.28517321e-03f, 3.15360166e-02f, -1.77254435e-02f, -1.61260478e-02f, 4.03971272e-03f, 9.92314219e-02f, -9.44415294e-03f,
  -6.42595766e-03f, -7.69232661e-02f, 7.63086751e-02f, 3.38531435e-02f, 3.55626382e-02f, 6.13636244e-03f, -3.34015320e-04f, -1.44874537e-02f, -3.06714773e-02f, 1.17299426e-02f,
  -9.63208918e-03f, 1.58423334e-02f, -4.31717597e-02f, -2.43506255e-03f, -1.95445269e-02f, -3.38560157e-02f, -4.40493925e-03f, -2.27290057e-02f, -1.15645044e-01f, 1.60679091e-02f,
  2.96280757e-02f, 5.27353175e-02f, -2.60817893e-02f, -8.53894204e-02f, -5.18386737e-02f, 3.11999936e-02f, 7.38873705e-03f, 6.59972802e-02f, -3.66894435e-03f, -2.74842530e-02f,
  4.02514398e-01f, 2.49356806e-01f, 7.42372200e-02f, 2.15686411e-01f, 1.19956266e-02f, -1.27829313e-01f, -1.68197557e-01f, 2.60566652e-01f, 4.92720127e-01f, 1.54567938e-02f,
  -8.21903870e-02f, -2.67488174e-02f, -3.61306220e-02f, -2.56468840e-02f, -1.25310227e-01f, -3.12925391e-02f, -4.20035003e-03f, 3.36499475e-02f, 8.40979144e-02f, 7.33305812e-02f,
  3.65805924e-02f, -5.56200147e-02f, -1.04501337e-01f, 4.87825600e-03f, 2.22976841e-02f, 8.15641358e-02f, -1.09115385e-01f, -4.51036282e-02f, -1.11049362e-01f, -1.53324455e-01f,
  -1.00857213e-01f, 6.57373890e-02f, -1.01583265e-01f, 9.97624919e-03f, 1.17500365e-01f, 8.56717001e-04f, -7.26529434e-02f, -1.68177873e-01f, 3.02383956e-02f, -2.18154844e-02f,
  -3.00129075e-02f, 3.30020599e-02f, 4.01669890e-02f, -1.50476769e-02f, 8.99169967e-02f, 4.18999419e-02f, 1.76075343e-02f, 5.26444055e-02f, 7.34533146e-02f, -7.88705330e-03f,
  6.29722839e-03f, -2.27325074e-02f, -4.93177911e-03f, -4.06829603e-02f, -4.62086387e-02f, 5.21243643e-03f, -1.10377491e-01f, -3.85665894e-02f, 1.23639880e-02f, 6.47513345e-02f,
  -1.10210134e-02f, -1.45014818e-03f, 3.19056772e-02f, -2.05547065e-02f, -1.38148014e-02f, 2.58146133e-02f, -1.05445078e-02f, -5.62713183e-02f, -3.35697122e-02f, 2.19628005e-03f,
  3.45540158e-02f, 1.77694466e-02f, 2.63872128e-02f, -4.81115170e-02f, -1.94161218e-02f, 4.79907021e-02f, 2.60515921e-02f, -4.09071632e-02f, 6.16244562e-02f, -2.16171965e-02f,
  4.66312747e-03f, -4.89930958e-02f, -8.30816396e-04f, 1.43628316e-02f, -4.47228365e-03f, -1.22385304e-02f, -3.74999270e-02f, -2.41800807e-02f, -2.43380163e-02f, 2.94194510e-03f,
  1.20364673e-01f, 1.65876657e-01f, 1.60334948e-02f, 3.82153168e-02f, -5.16829826e-02f, 2.90462803e-02f, 5.13028167e-02f, 8.47769082e-02f, -4.75442410e-03f, -9.27306525e-03f,
  8.27072188e-03f, -2.10685078e-02f, 1.38925351e-02f, -3.49581428e-02f, -4.47517857e-02f, 3.20861326e-03f, -1.55546702e-02f, -8.10738280e-02f, -6.31804764e-02f, 1.30674504e-02f,
  1.20964032e-02f, -3.83627228e-02f, -8.53358507e-02f, -1.19760791e-02f, -4.52398807e-02f, 2.70959642e-02f, 5.79397520e-03f, 1.05729827e-03f, -8.41098428e-02f, -2.33086571e-02f,
  -1.86683461e-01f, 2.01750949e-01f, 2.99394011e-01f, -2.46821821e-01f, -2.72043217e-02f, 2.12217327e-02f, 5.18119335e-03f, -3.89958434e-02f, -1.80173144e-01f, -6.54943362e-02f,
  -5.43323942e-02f, 3.38530123e-01f, 3.58887948e-02f, 2.55005769e-02f, -1.39087617e-01f, -4.64863665e-02f, -1.46775946e-01f, -8.04939792e-02f, -1.75440107e-02f, 5.32165579e-02f,
  -5.56481741e-02f, -9.51154381e-02f, 7.11538494e-02f, 7.30936453e-02f, 1.12209685e-01f, -3.36509869e-02f, -4.17748056e-02f, 9.95916575e-02f, 3.83429751e-02f, -5.25729097e-02f,
  -2.51846202e-02f, -7.20503554e-02f, 1.74989045e-01f, 5.52694686e-02f, 5.35659026e-03f, 1.87279303e-02f, 6.98834732e-02f, 8.62518921e-02f, -2.57678479e-02f, 2.80146208e-02f,
  8.97985995e-02f, 1.00118160e-01f, -2.71942783e-02f, -1.93230920e-02f, -7.58343786e-02f, 5.63082695e-02f, 4.94869277e-02f, 1.28420005e-02f, 4.23680805e-02f, 8.72944891e-02f,
  8.82062316e-02f, 2.48215515e-02f, -3.90197039e-02f, -1.01773344e-01f, -1.88986631e-03f, -4.45509814e-02f, 5.87078230e-03f, 2.24316269e-02f, -1.76124219e-02f, -8.33489522e-02f,
  6.11657947e-02f, -7.54478574e-02f, 3.33032198e-02f, -2.62434632e-02f, -2.85167177e-03f, -2.68525947e-02f, 3.16196084e-02f, -3.06815244e-02f, -1.17679099e-02f, 4.31415141e-02f,
  -1.51092727e-02f, -2.14722916e-03f, -4.07523615e-03f, -1.78044066e-02f, 1.51163843e-02f, 4.50918004e-02f, 1.27812731e-03f, -2.14677863e-02f, 2.68386193e-02f, -4.58588526e-02f,
  3.35091874e-02f, -3.49198505e-02f, 4.47946787e-02f, -4.26732376e-02f, -5.47463493e-03f, 1.67948268e-02f, 3.72939967e-02f, 2.13453192e-02f, 2.99110245e-02f, -4.84249517e-02f,
  -2.18299732e-01f, -2.70855814e-01f, -5.17044365e-02f, 5.08389249e-03f, -4.75609154e-02f, 2.97114309e-02f, -2.27809977e-02f, 1.29331555e-02f, 1.83069054e-02f, -3.33193690e-02f,
  4.13043723e-02f, -9.58987251e-02f, -2.47959122e-02f, 2.05008648e-02f, -1.14571908e-02f, -1.72569547e-02f, 2.17811428e-02f, 6.25862256e-02f, -4.18764725e-02f, -8.36014822e-02f,
  -3.82847600e-02f, 2.06491519e-02f, 2.04279236e-02f, -3.17638740e-02f, -6.53070770e-03f, -5.87555696e-04f, -3.99860628e-02f, -8.98429304e-02f, 2.77309865e-02f, -1.15768323e-02f,
  -1.27836183e-01f, 3.14633101e-01f, -1.00056536e-01f, -2.58591712e-01f, -2.67012686e-01f, 2.18536794e-01f, -2.52135783e-01f, 5.58221303e-02f, 3.58529165e-02f, 3.54316741e-01f,
  -5.86643964e-02f, 5.65287694e-02f, 5.51117733e-02f, -1.71588373e-03f, -2.27509364e-01f, 1.25827298e-01f, 2.49586813e-02f, 1.06593166e-02f, -1.73935648e-02f, -7.24475682e-02f,
  -1.81297630e-01f, -1.21529289e-01f, -2.43120030e-01f, -6.84107766e-02f, -2.22743481e-01f, -1.99898537e-02f, -2.11512834e-01f, -1.09285079e-01f, 9.00918320e-02f, 9.64263007e-02f,
  7.33247250e-02f, 8.20251927e-03f, -2.97092721e-02f, 1.16751879e-01f, -4.47428785e-02f, -1.77421309e-02f, -2.64258962e-02f, -4.83395010e-02f, -6.73003346e-02f, 4.65530157e-02f,
  1.58089884e-02f, -4.22392860e-02f, -3.86313796e-02f, -3.28500569e-02f, 5.02472706e-02f, 2.19546296e-02f, 1.99065497e-03f, -4.84012924e-02f, -2.58986000e-02f, -4.43823077e-02f,
  -2.36158259e-02f, -3.73166008e-03f, -1.62412375e-02f, 7.70614222e-02f, -4.80458289e-02f, 6.58538640e-02f, -3.58063616e-02f, 3.13775763e-02f, 2.10962258e-02f, 3.56243970e-03f,
  8.91603380e-02f, 3.99424545e-02f, -2.68966909e-02f, 4.23020013e-02f, 6.25433177e-02f, -1.23096341e-02f, 4.32477519e-02f, -3.85932066e-02f, 3.60879512e-03f, -8.09046731e-04f,
  5.19865640e-02f, -1.41585460e-02f, 2.58118045e-02f, 2.92441837e-04f, -3.15895155e-02f, -8.67946167e-03f, -4.45764251e-02f, 8.69402196e-03f, -8.98809079e-03f, -7.72882700e-02f,
  -5.96779101e-02f, -1.05892057e-02f, 1.49539821e-02f, -1.43384248e-01f, 3.51950862e-02f, -1.29001653e-02f, 5.49120083e-03f, 6.82309419e-02f, -4.82972339e-02f, -7.91481137e-02f,
  5.85051626e-02f, 1.29220665e-01f, 3.84416478e-03f, 3.45025621e-02f, 9.10450742e-02f, 1.98415127e-02f, 1.31389899e-02f, 4.95651402e-02f, 9.58258808e-02f, -4.16860776e-03f,
  -2.74758991e-02f, 7.67767150e-03f, 1.41174803e-02f, 1.52187254e-02f, 3.06448173e-02f, -3.43477018e-02f, -5.79525717e-02f, 7.81096220e-02f, -2.99652270e-03f, -5.86419541e-04f,
  1.22323483e-02f, 4.27690148e-02f, -3.77931353e-03f, -9.83016640e-02f, -4.29984480e-02f, -3.11863907e-02f, 1.19133769e-02f, 3.65991285e-03f, 1.70844682e-02f, -7.12418370e-03f,
  2.37089276e-01f, 7.29606077e-02f, 2.33842805e-01f, 2.13461056e-01f, -1.08525611e-01f, -8.72646347e-02f, 1.43984646e-01f, 6.54500052e-02f, 1.67526722e-01f, -6.05451427e-02f,
  -3.63327973e-02f, 2.68722802e-01f, 6.22900249e-03f, -1.53785199e-01f, 1.46159101e-02f, -7.40116984e-02f, 1.96410082e-02f, 1.47737730e-02f, -2.01704856e-02f, 7.46985059e-03f,
  8.32075328e-02f, -8.09205174e-02f, 6.04024269e-02f, -1.33564979e-01f, -4.52657454e-02f, 5.31952158e-02f, -1.63235962e-01f, -1.02915615e-02f, -2.14978397e-01f, -7.28630498e-02f,
  -8.65540206e-02f, 1.49006411e-01f, 1.02526791e-01f, -3.06332875e-02f, -2.84204409e-02f, 8.07696581e-03f, 3.00935972e-02f, 1.21964142e-02f, -3.93292606e-02f, 1.53997196e-02f,
  1.09588793e-02f, -8.25204700e-02f, -9.46299732e-03f, 3.53504270e-02f, -7.07814172e-02f, 2.85872389e-02f, -9.57706664e-03f, -5.87975746e-03f, 3.06945667e-02f, 2.40759761e-03f,
  2.26778141e-03f, 3.38753685e-02f, 3.97928432e-02f, -5.19064851e-02f, 8.06608424e-02f, 4.06382643e-02f, 4.86692712e-02f, 1.60578936e-02f, 3.26197874e-03f, -1.67930257e-02f,
  9.59889218e-02f, 2.52627172e-02f, -3.15765366e-02f, -5.03716357e-02f, 2.34329328e-02f, -6.69797584e-02f, 2.59276889e-02f, -5.40899206e-03f, 4.61778268e-02f, -1.54179856e-02f,
  -6.17044866e-02f, 4.00204808e-02f, 2.72001438e-02f, 1.10058021e-03f, -6.25593662e-02f, 1.18819848e-02f, 2.54747123e-02f, -3.67885530e-02f, -3.10873296e-02f, -2.81415097e-02f,
  1.09478622e-03f, 3.25274952e-02f, -2.22560279e-02f, -5.40374480e-02f, 7.00371666e-03f, 4.45700660e-02f, 2.44711209e-02f, 2.42352136e-03f, 3.24168205e-02f, 2.77546812e-02f,
  -3.29633176e-01f, 4.59808297e-03f, -7.05575570e-02f, -9.86267552e-02f, -7.95330480e-02f, -7.18429089e-02f, 6.32278174e-02f, -4.93702218e-02f, -2.36855913e-02f, 3.97595577e-02f,
  -4.53949310e-02f, -3.83787602e-02f, -3.59869488e-02f, -2.33010040e-03f, 9.10414532e-02f, 1.51528390e-02f, 1.48254624e-02f, -2.37262584e-02f, 9.60058533e-04f, 5.86536266e-02f,
  -9.25102606e-02f, 1.00648394e-02f, 6.05535097e-02f, 5.04010916e-02f, -1.69827621e-02f, 2.26018839e-02f, -4.47921716e-02f, 7.81298876e-02f, -3.25756259e-02f, -4.30685952e-02f,
  3.58313657e-02f, 2.57220954e-01f, 2.13768572e-01f, -1.63491815e-01f, -4.39289995e-02f, 2.41191342e-01f, 2.31398493e-01f, 1.27551332e-02f, -1.11118950e-01f, 9.11827385e-02f,
  -2.29090646e-01f, 3.22776705e-01f, 3.50036239e-03f, -1.02363065e-01f, -9.62283015e-02f, -2.79082321e-02f, -1.72965415e-02f, 1.65646225e-01f, 1.05194174e-01f, -1.00484295e-02f,
  -4.82012657e-03f, -2.22142249e-01f, 6.36762455e-02f, -9.86316577e-02f, 6.94085732e-02f, 1.11722246e-01f, -1.37401178e-01f, 5.39798103e-02f, -2.28978507e-02f, 4.77120392e-02f,
  3.88039462e-02f, 4.78702271e-03f, 7.90873617e-02f, 4.57267910e-02f, 4.17673886e-02f, -4.07629795e-02f, 2.67792176e-02f, -5.26667014e-02f, -3.32448110e-02f, -1.03193164e-01f,
  3.58405374e-02f, 1.08051477e-02f, -2.78340168e-02f, -4.19246741e-02f, 6.79294541e-02f, -9.70355235e-03f, 2.57081259e-02f, 2.28902535e-03f, 3.72911356e-02f, 4.45844494e-02f,
  5.41992113e-02f, -1.12901405e-02f, -2.61865882e-03f, 1.42902113e-03f, 3.96556556e-02f, -5.08299991e-02f, 3.22846472e-02f, 3.84021252e-02f, 1.01702129e-02f, 1.75232738e-02f,
  -1.39671247e-02f, -2.83755250e-02f, 4.20533717e-02f, -3.78005989e-02f, -4.57333364e-02f, -5.63625433e-03f, -2.63089295e-02f, -2.34060679e-02f, 2.32973304e-02f, -3.29900943e-02f,
  -2.01883670e-02f, -3.49471495e-02f, -3.07542961e-02f, -5.14211170e-02f, 5.80855832e-03f, 6.05985112e-02f, -5.14586866e-02f, 1.13774911e-02f, 3.23819406e-02f, -4.18533608e-02f,
  -1.83150377e-02f, -2.96184048e-02f, 9.35340673e-03f, 3.99768800e-02f, 2.61250567e-02f, -3.33152304e-04f, -5.54622896e-02f, 4.16398682e-02f, -2.79002078e-03f, -1.32104731e-03f,
  6.26935959e-02f, 6.15259781e-02f, -4.07522731e-02f, 3.83751616e-02f, 1.62018575e-02f, -1.62326396e-02f, -5.41108567e-03f, 1.67242102e-02f, 3.56318504e-02f, -3.19383061e-03f,
  -2.29723789e-02f, -2.05601845e-02f, 1.09658157e-02f, -4.05817032e-02f, -1.12906024e-02f, -2.48849345e-03f, -2.72685662e-03f, 5.59415435e-03f, -2.77652331e-02f, -1.39168901e-02f,
  -1.11537024e-01f, -4.93554063e-02f, 1.80371329e-02f, -4.47221510e-02f, -4.65326458e-02f, -8.36951134e-04f, 8.71158913e-02f, 8.15099329e-02f, -7.17344582e-02f, 7.88931735e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.70400539e-02f, 2.37141132e-01f, -1.69749424e-01f, -2.04282686e-01f, 1.19867250e-01f, -1.67783558e-01f, -2.27109119e-01f, 1.33038983e-01f, -5.40061444e-02f, 2.66359478e-01f,
  6.44967780e-02f, -1.18148580e-01f, -4.96074893e-02f, -3.35103065e-01f, -5.91715455e-01f, -2.22295150e-01f, -4.15996104e-01f, -1.19102679e-01f, -1.05767123e-01f, 4.91797775e-02f,
  -1.69925004e-01f, -9.60728973e-02f, -3.27982932e-01f, 2.14201882e-01f, 1.11424230e-01f, 1.90830499e-01f, 1.27415717e-01f, 2.13092700e-01f, -2.91950312e-02f, 1.48359006e-02f,
  4.78839055e-02f, -2.58777551e-02f, 2.68806312e-02f, -3.33527438e-02f, 6.10030955e-03f, -2.71660485e-03f, 6.25823140e-02f, -4.52023111e-02f, -2.22786013e-02f, -6.99208304e-02f,
  4.46568914e-02f, -3.75251696e-02f, -9.08040348e-03f, 5.72167337e-03f, -1.57513320e-02f, 9.51227918e-03f, -6.52848333e-02f, -1.90944057e-02f, -6.96788430e-02f, -8.41277838e-02f,
  -8.88619348e-02f, -6.34888038e-02f, -4.52761352e-03f, -9.00064111e-02f, -2.20225714e-02f, 8.80060159e-03f, -3.72484364e-02f, -6.08287677e-02f, 2.46764161e-02f, -6.21536933e-02f,
  -5.52155636e-03f, 7.04475269e-02f, -5.74898301e-03f, 1.18178697e-02f, 1.83273992e-03f, 9.11953952e-03f, -3.66225131e-02f, 3.88287902e-02f, 2.57303342e-02f, -2.52009346e-03f,
  1.93896685e-02f, -1.31848725e-02f, 5.11100441e-02f, -1.01477820e-02f, -2.05868538e-02f, 2.82414723e-02f, -5.02711814e-03f, 8.46788287e-03f, -6.78730831e-02f, -4.55391258e-02f,
  2.33306382e-02f, 1.09191798e-02f, -2.61007864e-02f, -1.96300261e-02f, 6.77182823e-02f, -2.96439864e-02f, 4.37213518e-02f, 5.96883660e-03f, -1.11983633e-02f, -4.13411530e-03f,
  -1.90238766e-02f, 9.04710442e-02f, -2.64323801e-02f, 6.77274689e-02f, -5.50763495e-03f, -2.31521782e-02f, -9.16360468e-02f, 1.27965845e-02f, -4.25741524e-02f, 4.51041721e-02f,
  4.90411632e-02f, 3.52520570e-02f, 5.04086651e-02f, 6.38721064e-02f, -2.45498791e-02f, 7.64886942e-03f, 1.23955376e-01f, 4.46811654e-02f, 3.32952328e-02f, 8.03190991e-02f,
  9.88677070e-02f, 6.71879761e-03f, -9.40858051e-02f, 2.27665436e-02f, 2.41729245e-02f, 4.19738293e-02f, -1.23467604e-02f, 1.93977822e-02f, -5.33288941e-02f, 7.65320137e-02f,
  1.30464122e-01f, -1.53219387e-01f, -2.45178416e-01f, 2.15481059e-03f, -1.14577755e-01f, -2.79737473e-01f, -3.91748339e-01f, 6.05277857e-03f, -2.88927794e-01f, 8.99244398e-02f,
  7.67752007e-02f, -1.03730932e-02f, -2.38241285e-01f, -7.37498328e-02f, 1.19853325e-01f, -1.40813455e-01f, 1.17995724e-01f, -1.51610968e-03f, -2.04013102e-02f, 1.49196878e-01f,
  1.52950659e-01f, 1.35248274e-01f, 9.17235911e-02f, 2.23546579e-01f, -7.09995925e-02f, 1.87780872e-01f, 3.67272079e-01f, 9.07615796e-02f, 3.13331097e-01f, 3.18038538e-02f,
  -1.29713967e-01f, -7.62586147e-02f, -1.05896845e-01f, -9.21974778e-02f, 7.79765174e-02f, -1.05165102e-01f, 1.51809060e-03f, -6.61180168e-02f, 3.89743075e-02f, -4.77124117e-02f,
  -6.03505671e-02f, 5.56910113e-02f, -3.49868387e-02f, -6.14066720e-02f, 2.66498048e-03f, 1.06347026e-02f, -4.93382663e-03f, 3.88020016e-02f, -9.70169678e-02f, -2.83330902e-02f,
  -4.65489849e-02f, -3.81787084e-02f, 3.39517929e-02f, 4.42595147e-02f, -2.21827198e-02f, 2.79651452e-02f, 1.72061026e-02f, 4.18355204e-02f, -8.37430940e-04f, 8.34899675e-03f,
  8.76565836e-03f, 4.77745160e-02f, 3.38346809e-02f, -7.74187818e-02f, -4.41227593e-02f, 3.43170464e-02f, -1.49297332e-02f, 4.54279743e-02f, 3.66054662e-02f, -5.21974266e-02f,
  -2.18296330e-02f, 9.55449119e-02f, -3.47818597e-03f, -3.06247966e-04f, 3.62103023e-02f, -4.18393798e-02f, 3.90624851e-02f, 8.24417770e-02f, 2.90786531e-02f, -6.29763380e-02f,
  -3.10878977e-02f, 5.53027494e-03f, -6.03553373e-03f, -5.84900156e-02f, 3.04031360e-04f, 9.69682857e-02f, 7.68671855e-02f, -8.09469819e-03f, -8.35125335e-03f, -5.41122667e-02f,
  1.21104464e-01f, 9.95024219e-02f, -7.69192725e-02f, 2.15604878e-03f, -1.67186912e-02f, 3.70034799e-02f, 2.01688474e-03f, 1.32511243e-01f, 8.25158060e-02f, -1.70286056e-02f,
  8.15779045e-02f, -2.57772952e-02f, 5.94891421e-03f, 9.51085687e-02f, 6.58584312e-02f, -2.51174923e-02f, 3.88988219e-02f, 1.37770236e-01f, 9.01891366e-02f, 8.30926523e-02f,
  1.26130218e-02f, -1.98578890e-02f, 8.94669369e-02f, -1.12009585e-01f, 5.66846579e-02f, 1.11701125e-02f, -2.20460095e-03f, 7.67781362e-02f, -2.99050752e-02f, 3.69803831e-02f,
  4.39804420e-02f, 1.90283671e-01f, -2.88337618e-01f, 6.42337874e-02f, -1.41533092e-01f, 1.50794715e-01f, 2.14522421e-01f, -8.77341479e-02f, -1.51234306e-02f, 3.44147652e-01f,
  1.84791416e-01f, -7.95588456e-03f, 8.64937976e-02f, 4.06481266e-01f, 2.26315055e-02f, 2.70244122e-01f, 3.16024363e-01f, 2.46147677e-01f, -1.91171113e-02f, 1.88515037e-01f,
  -4.09057327e-02f, 1.92017585e-01f, -6.46106824e-02f, -3.25478166e-02f, 6.57258928e-02f, -2.42772281e-01f, -7.83172026e-02f, -2.40731135e-01f, 4.59979735e-02f, -6.49321079e-02f,
  -5.74311940e-03f, -4.65913340e-02f, -4.04386260e-02f, 6.57625720e-02f, -6.80226982e-02f, -2.54617948e-02f, -3.26684415e-02f, -3.14789191e-02f, -1.40546203e-01f, 6.65889829e-02f,
  -2.28165253e-03f, 7.26265088e-02f, 1.02959789e-01f, 4.23581281e-04f, -1.20661044e-02f, -1.55152872e-01f, -1.10819126e-02f, -2.86491774e-02f, -7.45154768e-02f, -4.27903235e-02f,
  -5.41841947e-02f, -4.71647456e-02f, 4.18622047e-02f, 3.14932726e-02f, -1.24258183e-01f, -2.25610901e-02f, 4.01464775e-02f, -1.13003932e-01f, 3.14975455e-02f, 5.46428598e-02f,
  3.82113606e-02f, -3.77184674e-02f, -8.61665793e-03f, 4.20748256e-02f, 3.11388541e-02f, -3.02733649e-02f, -2.51799766e-02f, 3.46977189e-02f, -5.31380437e-02f, 2.31849104e-02f,
  -3.16283968e-03f, -2.60126777e-02f, -3.49758081e-02f, 2.97405254e-02f, 9.24238116e-02f, -7.76476692e-03f, -7.33073279e-02f, -2.01014634e-02f, -1.42695513e-02f, -3.23089445e-03f,
  3.60587332e-03f, -6.67307451e-02f, -3.18709277e-02f, -8.12053904e-02f, 1.63954422e-02f, -1.48804449e-02f, 3.28497142e-02f, 2.44681034e-02f, -4.86430861e-02f, -1.56228105e-02f,
  8.30345303e-02f, 1.96165487e-01f, 4.69441339e-02f, 1.42116519e-02f, -3.08096446e-02f, 2.99898759e-02f, 9.91072226e-03f, 5.75464107e-02f, 3.00344247e-02f, -5.89221306e-02f,
  3.80047821e-02f, 6.23932667e-02f, -2.27367878e-02f, -4.25354615e-02f, 3.23452093e-02f, 4.44052927e-02f, 3.59267108e-02f, -4.36961316e-02f, 2.48385482e-02f, -8.84678774e-03f,
  -5.80259413e-02f, 5.46411648e-02f, 1.12723764e-02f, 9.00945365e-02f, 8.99172761e-03f, 1.11263938e-01f, 3.16040270e-04f, -5.56656048e-02f, -3.00772078e-02f, 3.23072709e-02f,
  5.62767200e-02f, -1.46218568e-01f, -4.03199583e-01f, -2.09595323e-01f, 1.99607000e-01f, 2.69363284e-01f, -4.27986309e-02f, 4.24922071e-02f, -2.67684340e-01f, 3.63940597e-02f,
  1.21594265e-01f, -9.26375613e-02f, -1.67794347e-01f, 6.51900247e-02f, -5.16917855e-02f, -2.60111392e-01f, 1.22635528e-01f, 1.87548921e-02f, -1.62065640e-01f, 8.04146826e-02f,
  -7.74335712e-02f, 3.45631540e-01f, -1.76851436e-01f, 1.53314933e-01f, 2.28550419e-01f, -6.20458797e-02f, 1.57418668e-01f, -3.43816890e-03f, 2.60116577e-01f, 7.72411674e-02f,
  8.36892575e-02f, -5.23193963e-02f, -4.30801846e-02f, -6.95471168e-02f, 5.36075383e-02f, 1.35000139e-01f, 6.32251576e-02f, -2.14187615e-02f, -1.12426914e-01f, -3.17365266e-02f,
  2.65912805e-02f, -2.90735508e-03f, 6.01864457e-02f, -2.32840162e-02f, -2.05090214e-02f, 1.95878167e-02f, -8.32061395e-02f, -8.62466544e-02f, -7.21656457e-02f, 4.71816882e-02f,
  -1.12431332e-01f, 8.14586282e-02f, -8.20360631e-02f, 7.15738395e-03f, 1.02558658e-02f, 1.06464662e-02f, -1.10921048e-01f, 5.32737486e-02f, 1.65783241e-02f, 3.74373719e-02f,
  1.49256498e-01f, 7.51077151e-03f, -8.54392946e-02f, 2.79546343e-03f, 3.32363322e-02f, 4.48558200e-03f, 3.72420214e-02f, -3.92198302e-02f, 1.13652907e-02f, 3.59765030e-02f,
  3.21451426e-02f, 1.77397598e-02f, 2.68669985e-02f, 1.60316899e-02f, 6.59372732e-02f, 2.58888714e-02f, -2.57775355e-02f, 2.79269479e-02f, -1.03151593e-02f, 4.16980404e-03f,
  -4.92603667e-02f, 4.58334163e-02f, 3.13003138e-02f, 5.62892063e-03f, -2.72070784e-02f, -3.27325091e-02f, 8.39526802e-02f, -5.71647324e-02f, -4.48648781e-02f, 1.75383743e-02f,
  1.75362572e-01f, 4.25991677e-02f, -2.69867498e-02f, -3.88322137e-02f, -2.25198139e-02f, 1.43137291e-01f, -5.42679690e-02f, 3.79400961e-02f, -4.85842824e-02f, 3.30591165e-02f,
  7.16745928e-02f, -7.80882984e-02f, 3.81306522e-02f, -3.18027996e-02f, -2.98547861e-03f, 6.92716464e-02f, 7.99950659e-02f, -1.00850547e-02f, 1.04932174e-01f, 6.51908666e-02f,
  1.08471634e-02f, 3.46356668e-02f, 5.34762628e-02f, -1.14019755e-02f, 1.93185583e-02f, 2.43390780e-02f, 6.36039898e-02f, -4.26740348e-02f, 9.64824706e-02f, -1.21844485e-01f,
  1.16742216e-01f, 4.98241037e-02f, -1.19153671e-01f, -2.40278691e-01f, -3.12347353e-01f, -4.19374228e-01f, -3.93191695e-01f, -2.49334127e-01f, -4.22431529e-02f, 1.61844250e-02f,
  -1.09834783e-01f, 1.35271519e-01f, 1.40581980e-01f, -3.30793858e-01f, 1.51480213e-01f, 2.78738856e-01f, -2.45827243e-01f, -1.22094445e-01f, 1.22360215e-01f, -1.53839290e-01f,
  1.30193114e-01f, -2.23019451e-01f, -2.48154942e-02f, -5.54278009e-02f, -2.38005906e-01f, 2.55092587e-02f, 2.31157854e-01f, -2.27057293e-01f, -1.83719575e-01f, -1.63579032e-01f,
  -4.83881198e-02f, 3.59116606e-02f, -1.29577637e-01f, 6.65821731e-02f, -4.07691933e-02f, -6.43992350e-02f, -1.57961100e-01f, 7.03865010e-03f, -1.30044632e-02f, -5.04322201e-02f,
  8.85301754e-02f, 1.31312594e-01f, 2.72282511e-02f, 2.44673225e-03f, -1.10472657e-01f, -1.06551386e-01f, 8.16600621e-02f, -8.93094167e-02f, -1.57464355e-01f, 7.11056739e-02f,
  -4.53338362e-02f, 6.25789864e-03f, -5.54713532e-02f, 1.12229288e-01f, -5.68111567e-03f, -6.72134534e-02f, -6.00332916e-02f, 1.56273227e-02f, 7.06152022e-02f, 1.69564411e-02f,
  6.87018186e-02f, 4.72037569e-02f, -9.66800451e-02f, 4.68949229e-02f, 3.34698632e-02f, -9.24910232e-02f, -1.57772359e-02f, 1.60386879e-02f, 1.13193251e-01f, -6.88979551e-02f,
  -1.46493584e-01f, -5.45126759e-02f, -5.10693751e-02f, 2.74649734e-04f, 4.37198915e-02f, 4.59090509e-02f, -1.44130904e-02f, 7.30755366e-03f, 4.68598008e-02f, -9.40713007e-03f,
  -2.68930905e-02f, 4.81176972e-02f, -7.16362968e-02f, 1.23869004e-02f, -4.17473726e-03f, 7.61549473e-02f, 4.57335114e-02f, -3.30278613e-02f, -2.51590461e-02f, -2.71742009e-02f,
  2.82881111e-02f, 1.51001438e-01f, 1.42238364e-02f, 2.91113686e-02f, -3.72438803e-02f, -5.52175790e-02f, 5.39094992e-02f, 9.02732089e-02f, 1.99358426e-02f, -1.27611123e-02f,
  6.91393614e-02f, -7.50974417e-02f, -1.24744782e-02f, -1.49849104e-02f, -6.37351424e-02f, 1.71018951e-03f, 4.71297838e-02f, 4.96714301e-02f, -1.51921913e-01f, 6.98358044e-02f,
  -3.38854641e-02f, -1.16341233e-01f, 4.83944640e-03f, 2.13708933e-02f, 5.90174459e-02f, 8.01466033e-03f, -4.85561267e-02f, -4.27519791e-02f, 3.84361520e-02f, 5.32976203e-02f,
  1.75458625e-01f, 2.53090411e-01f, -1.62417181e-02f, 6.45828024e-02f, -1.35342613e-01f, -2.95287937e-01f, -1.52742401e-01f, 2.20468789e-02f, -2.73469508e-01f, 2.12041333e-01f,
  -1.21415697e-01f, 4.62098233e-02f, -8.16293899e-03f, -2.03514487e-01f, -3.19462806e-01f, -1.22398548e-01f, -8.18755925e-02f, -2.87209172e-02f, -6.02999702e-02f, 2.56378680e-01f,
  5.31492680e-02f, -2.05233887e-01f, 1.01727605e-01f, -1.32365078e-01f, 1.68183669e-01f, 2.39277899e-01f, 1.86589986e-01f, -5.78894420e-03f, 2.21122816e-01f, -1.90427080e-01f,
  -1.09490350e-01f, -2.56603751e-02f, 3.31079848e-02f, -4.46580388e-02f, 4.28892970e-02f, 1.24850087e-01f, 7.24434182e-02f, -1.16942041e-01f, -8.23781714e-02f, -4.63387482e-02f,
  3.71612161e-02f, -1.17840851e-02f, -1.13906093e-01f, -5.42812385e-02f, -6.49143234e-02f, -9.35471430e-03f, 6.70023356e-03f, 4.26292233e-02f, 4.11502756e-02f, 4.96320985e-03f,
  1.67287737e-01f, 9.15267691e-02f, -1.43186990e-02f, 5.53500094e-02f, 2.28452291e-02f, 3.71109508e-02f, 5.02039194e-02f, 6.77571073e-02f, 9.80078951e-02f, -8.25363174e-02f,
  1.02471285e-01f, -3.12978476e-02f, -2.43915580e-02f, 2.99477596e-02f, 4.26544324e-02f, 3.83778997e-02f, 1.61521919e-02f, -1.11618880e-02f, 1.00331157e-01f, 6.52532354e-02f,
  -3.27073410e-02f, 2.35199183e-02f, -1.04450308e-01f, 6.63257316e-02f, -2.78911553e-02f, 5.05837426e-02f, 3.39967869e-02f, 7.30820792e-03f, -1.71026383e-02f, -7.06731305e-02f,
  7.77190225e-03f, 3.52851376e-02f, 5.00722975e-02f, -2.39754077e-02f, -1.21260457e-01f, -3.71715017e-02f, -6.60990700e-02f, -4.36248966e-02f, 1.66731942e-02f, -3.49979028e-02f,
  1.18752897e-01f, 1.92867428e-01f, 1.52636785e-03f, -1.86838403e-01f, 5.52226678e-02f, -7.24953562e-02f, -3.83668928e-03f, -5.26569746e-02f, 4.59218817e-03f, -5.56159988e-02f,
  1.25095218e-01f, 1.31020055e-03f, 1.27265260e-01f, 7.67105222e-02f, 2.73045246e-03f, 3.72264944e-02f, 2.04421650e-03f, 2.62128878e-02f, 5.22920899e-02f, 3.70370038e-02f,
  9.87329409e-02f, 2.51667909e-02f, 1.65048987e-02f, -1.08599057e-02f, -7.39475191e-02f, 8.99307802e-03f, 4.82361093e-02f, 5.39480150e-02f, 1.01556405e-02f, 7.73207378e-03f,
  -3.81114185e-01f, 3.08999896e-01f, -2.21323043e-01f, 6.42625913e-02f, -7.32719824e-02f, 1.26339749e-01f, 8.40967819e-02f, 7.61573985e-02f, 3.23195726e-01f, 1.85138509e-01f,
  -9.61887371e-03f, -2.40100026e-02f, 1.50020435e-01f, 5.65437302e-02f, 4.79534902e-02f, 2.71553069e-01f, 8.12837631e-02f, 1.31923854e-01f, 2.03007057e-01f, -7.02854097e-02f,
  -2.59541385e-02f, -4.60879654e-02f, -1.92458868e-01f, -3.59346941e-02f, -2.45061979e-01f, -1.68709263e-01f, -1.24771081e-01f, 5.62386699e-02f, -1.66812167e-01f, -6.23918197e-04f,
  -1.79940701e-01f, -1.55226618e-01f, -1.05777659e-01f, 1.27687193e-02f, -1.04410246e-01f, -2.20882490e-01f, 4.57165986e-02f, 3.22632864e-02f, 1.22061034e-03f, 1.98587347e-02f,
  -6.62584975e-02f, 9.20065958e-03f, 8.19092840e-02f, 6.47551268e-02f, -9.19594169e-02f, -1.40937772e-02f, -2.10859571e-02f, -1.67360734e-02f, 2.21940894e-02f, -8.55546594e-02f,
  -5.87055795e-02f, -3.25498101e-03f, -2.30355654e-02f, 5.80730960e-02f, -1.93841159e-02f, 6.02977537e-03f, 7.54031613e-02f, -7.83398375e-02f, 1.25372969e-02f, -1.08040089e-03f,
  -1.59421973e-02f, 4.08459939e-02f, -2.02449877e-02f, -6.78903908e-02f, -8.76060277e-02f, -5.24562299e-02f, -4.03529312e-03f, 3.33487391e-02f, 7.94221237e-02f, -7.12018237e-02f,
  -1.13483192e-02f, 2.18047574e-02f, 2.10924111e-02f, -6.38397485e-02f, -2.22734809e-02f, -3.28329019e-02f, -6.88486919e-02f, 4.99314070e-02f, 6.72040554e-03f, -3.12383994e-02f,
  6.10650778e-02f, 1.14233553e-01f, 5.53362817e-02f, 8.47867429e-02f, -3.28870192e-02f, -5.34898452e-02f, 1.71045176e-04f, 5.27792908e-02f, 3.19232717e-02f, -6.85885698e-02f,
  5.88028319e-02f, 1.30221695e-01f, -5.86668663e-02f, -6.12375289e-02f, 3.90452370e-02f, 1.00791566e-02f, 6.99540153e-02f, -5.09947054e-02f, 1.09704800e-01f, 5.00567909e-03f,
  4.40622903e-02f, -2.92496048e-02f, -5.52439578e-02f, 1.76811963e-02f, 1.16034620e-03f, 1.15926765e-01f, -2.47622132e-02f, 7.86230564e-02f, 2.05188338e-02f, -3.62662114e-02f,
  5.35077192e-02f, 9.18943658e-02f, 6.27735332e-02f, -6.48221448e-02f, 8.63663405e-02f, -6.71829563e-03f, 3.41576301e-02f, -4.29864340e-02f, -7.59938657e-02f, 3.77265699e-02f,
  -3.75450969e-01f, 1.51301414e-01f, -2.37649828e-01f, 2.26363972e-01f, -2.54416198e-01f, -6.57498762e-02f, 1.33006379e-01f, 5.95663907e-03f, -1.00778200e-01f, 3.18314284e-01f,
  1.58018917e-01f, -2.90973131e-02f, 4.69632186e-02f, 1.11803114e-01f, -4.00759727e-01f, -8.97992328e-02f, 1.28802419e-01f, 1.74583539e-01f, -6.32435903e-02f, 5.42912185e-02f,
  8.47965572e-03f, -3.13831680e-02f, 5.09579517e-02f, 1.04297241e-02f, -7.20151439e-02f, 8.73617828e-02f, 2.95491338e-01f, -6.44659325e-02f, 1.23546079e-01f, -1.55805901e-01f,
  -6.61381185e-02f, 3.67868170e-02f, 2.86118928e-02f, -1.74802057e-02f, 1.39987934e-02f, -3.65389884e-02f, 5.89417107e-02f, -1.15511402e-01f, 2.71318797e-02f, -4.60394509e-02f,
  -3.43413604e-03f, -9.91244093e-02f, -4.63342965e-02f, 5.29107312e-03f, -7.77831748e-02f, 5.72077185e-02f, 1.40255000e-02f, 1.32463481e-02f, -1.95950735e-02f, -7.92088136e-02f,
  -1.53982909e-02f, -3.57351974e-02f, 1.84096336e-01f, 4.61542569e-02f, 9.52384260e-04f, -1.59174670e-03f, 6.48437664e-02f, 3.91082205e-02f, -1.38648190e-02f, -3.21928412e-02f,
  -7.05716684e-02f, 1.99073367e-02f, 5.39126731e-02f, -1.01269158e-02f, -7.75042996e-02f, -4.75625088e-03f, -3.10244095e-02f, -2.97570582e-02f, -1.26971468e-01f, -1.45294648e-02f,
  -2.53758710e-02f, 1.96987181e-03f, -6.69048866e-03f, 3.93167734e-02f, -9.44876000e-02f, 9.48822871e-03f, -2.81091779e-02f, -5.56948036e-02f, -5.26767150e-02f, -1.95030216e-02f,
  -1.90415177e-02f, -8.70355219e-02f, 1.10005653e-02f, 1.17060587e-01f, 4.06565005e-03f, -4.23403196e-02f, -6.72654947e-03f, 1.20373465e-01f, 9.66117382e-02f, -1.63833871e-02f,
  1.51117891e-01f, 1.40975446e-01f, 2.40546875e-02f, -9.49501805e-03f, -5.51820435e-02f, 1.06418948e-03f, -7.59436225e-04f, -2.36788765e-02f, 5.54294186e-03f, -2.63018683e-02f,
  3.39060090e-02f, 7.65035823e-02f, -7.91728497e-02f, 2.69839857e-02f, -8.90853778e-02f, 2.26246957e-02f, 1.26449585e-01f, 5.45804165e-02f, 2.40174998e-02f, -9.24129859e-02f,
  7.33645484e-02f, -1.60441045e-02f, -6.30539730e-02f, 1.05513155e-01f, 5.18348478e-02f, 2.27955971e-02f, -3.97378281e-02f, -4.31041829e-02f, -5.80995949e-03f, -9.80446190e-02f,
  3.44089389e-01f, 2.74747550e-01f, 1.98275089e-01f, 2.40044355e-01f, -1.74608514e-01f, -2.73897886e-01f, -1.02520101e-01f, 4.66005914e-02f, 1.44699812e-01f, 2.42858585e-02f,
  2.25656964e-02f, 1.45741925e-01f, 8.46192166e-02f, 1.65595874e-01f, -5.23644276e-02f, -3.92566025e-02f, 1.36884481e-01f, -2.00549774e-02f, 6.95080310e-02f, 1.55318484e-01f,
  1.92262948e-01f, 4.60315570e-02f, 6.76310733e-02f, 4.41457443e-02f, 1.29239723e-01f, 7.69153237e-02f, 2.15034746e-02f, 8.82383361e-02f, 6.57777935e-02f, -1.44313768e-01f,
  2.77078580e-02f, 6.39903694e-02f, 1.19942814e-01f, -4.24163751e-02f, 6.96286336e-02f, -6.29308745e-02f, -7.33380318e-02f, -1.27511710e-01f, 8.35798085e-02f, 2.70444807e-02f,
  -5.08435257e-02f, -6.00190237e-02f, -6.65120631e-02f, -9.23312455e-02f, -5.03820889e-02f, 3.73203382e-02f, -6.05280548e-02f, 2.79229105e-04f, 3.07816118e-02f, 4.72117551e-02f,
  1.38654083e-01f, 9.55855299e-04f, 9.67361331e-02f, -8.09859931e-02f, 1.48288861e-01f, -8.32081661e-02f, -3.75858955e-02f, -1.34579111e-02f, -1.47052137e-02f, 2.56810840e-02f,
  4.99098822e-02f, 8.60039517e-02f, 1.86974984e-02f, 3.92187089e-02f, 1.31169826e-01f, 7.60030150e-02f, 6.64476454e-02f, -3.90287139e-03f, 2.92518530e-02f, 1.14164852e-01f,
  -2.91491728e-02f, -3.55224647e-02f, 3.25341709e-02f, 2.56311409e-02f, 5.03151305e-02f, -5.15859909e-02f, 2.77387034e-02f, -1.19008899e-01f, 6.02559075e-02f, 9.41362083e-02f,
  -1.87572390e-02f, -1.00674592e-01f, 7.86186978e-02f, -1.00566298e-01f, 2.67161857e-02f, 1.92538537e-02f, 7.56522790e-02f, 4.38262671e-02f, 8.46598148e-02f, -5.80872968e-02f,
  6.20915554e-02f, 1.20555878e-01f, 7.40574375e-02f, -1.41066138e-03f, 7.33099272e-03f, 2.31923107e-02f, -1.02188148e-01f, 4.32099067e-02f, 4.04932201e-02f, -5.52445883e-03f,
  5.90480603e-02f, 1.17122531e-02f, -9.42103863e-02f, 9.15694144e-03f, -6.95265383e-02f, -7.20488355e-02f, 6.77471012e-02f, 9.41683054e-02f, -3.70906070e-02f, 1.04892969e-01f,
  5.71473464e-02f, -2.56695151e-02f, 1.82713829e-02f, -7.62491226e-02f, 4.23818007e-02f, -7.52274841e-02f, 5.60383536e-02f, 4.16661985e-02f, 4.09218408e-02f, 3.65903713e-02f,
  -8.23810548e-02f, -1.30895928e-01f, -1.07811660e-01f, -2.83728421e-01f, -4.84257601e-02f, 4.59519355e-03f, 2.24071871e-02f, 1.69683993e-02f, -2.36548379e-01f, 1.34217694e-01f,
  1.95166543e-02f, -8.97421017e-02f, 6.49549365e-02f, -1.40714869e-01f, -2.68078864e-01f, 4.09745537e-02f, -1.19725972e-01f, -8.65873918e-02f, -1.46229386e-01f, 1.22238964e-01f,
  3.57750207e-02f, -4.19307016e-02f, -1.19068675e-01f, 1.84510931e-01f, 9.95000973e-02f, -1.21265026e-02f, 3.91716547e-02f, 7.58923069e-02f, 2.82016695e-02f, -1.62522152e-01f,
  1.20251395e-01f, 9.47785005e-02f, -3.83550487e-02f, 2.54793777e-05f, 2.24074926e-02f, -3.38072553e-02f, 5.38363829e-02f, -1.01300478e-01f, 3.18351761e-02f, -1.45290038e-02f,
  5.80475442e-02f, 3.06710433e-02f, 3.03804595e-03f, -1.17162779e-01f, 4.30582948e-02f, -7.75760561e-02f, 3.34313288e-02f, -6.41685575e-02f, 3.36222127e-02f, 2.41657495e-02f,
  -5.24485437e-03f, -2.11579166e-02f, -6.84513301e-02f, -1.61572024e-01f, -1.00883678e-01f, -3.34034394e-03f, -7.36521780e-02f, 8.49555992e-03f, 1.41799673e-02f, -4.78906408e-02f,
  3.27574909e-02f, 2.74287648e-02f, 8.07066187e-02f, 6.33246824e-02f, -2.95595266e-02f, 2.81981807e-02f, -2.18333025e-02f, -1.89140737e-02f, -1.23959132e-01f, -4.06439789e-02f,
  -2.51274128e-02f, 2.40195449e-03f, 3.19950283e-02f, -7.13095069e-02f, -4.99646515e-02f, -1.78092178e-02f, 1.17509738e-01f, 4.32983413e-02f, 3.59156840e-02f, -1.22651257e-01f,
  7.57901696e-03f, -6.70436118e-03f, 3.02853342e-02f, 9.84336808e-02f, 1.29291639e-01f, -1.01831324e-01f, -1.03804298e-01f, -1.24570012e-01f, -5.18715428e-03f, 1.23518810e-01f,
  7.05954805e-02f, 1.55295387e-01f, 2.37714406e-02f, -1.48118827e-02f, -6.21804036e-02f, -4.61193807e-02f, 1.96777657e-02f, -3.87496129e-02f, -5.59122041e-02f, -5.80388382e-02f,
  2.25358643e-02f, -4.12138142e-02f, 9.48883072e-02f, -8.71476084e-02f, -1.01938277e-01f, -3.75684313e-02f, -4.46703285e-03f, -2.68102158e-02f, -7.42216557e-02f, -2.58511640e-02f,
  1.71985209e-03f, 1.47532187e-02f, 7.20222713e-03f, 7.00818822e-02f, 3.95644233e-02f, 5.80359511e-02f, 1.00237578e-01f, -4.01376449e-02f, -2.00040732e-02f, -7.15466142e-02f,
  -7.42213249e-01f, 2.11572275e-01f, 8.10395181e-02f, -4.12945598e-02f, -1.76014110e-01f, -5.47991917e-02f, 4.06968966e-03f, -1.02967873e-01f, 1.33695416e-02f, 2.73274839e-01f,
  1.62138313e-01f, -5.97987287e-02f, 1.67033210e-01f, 1.66738987e-01f, -2.32698098e-01f, 2.02080220e-01f, -3.91113907e-02f, -7.59761930e-02f, -2.71482877e-02f, -1.16547912e-01f,
  -6.44590929e-02f, 7.96164200e-02f, 1.24782808e-01f, 1.51903793e-01f, -8.32768995e-03f, -3.57819311e-02f, -1.12966381e-01f, 1.13338530e-01f, -6.18519844e-04f, -7.97559097e-02f,
  -2.12151557e-01f, 4.20139991e-02f, -1.09888136e-01f, -1.65317878e-02f, -5.25422432e-02f, 9.01491381e-03f, -1.15342364e-01f, 7.82936662e-02f, -8.18003416e-02f, -4.42133769e-02f,
  1.98297482e-03f, 3.06205470e-02f, 1.77018680e-02f, -1.86219048e-02f, -4.55836654e-02f, 2.74937972e-03f, -1.21611329e-02f, -4.10823114e-02f, 1.36387348e-01f, 3.25877033e-02f,
  8.15345496e-02f, -1.51659427e-02f, -3.78772579e-02f, 6.47041872e-02f, 1.21734869e-02f, 5.07321469e-02f, -2.42100731e-02f, 2.14362070e-02f, 1.43409707e-02f, -1.63362548e-02f,
  -9.16542038e-02f, -3.29247937e-02f, -4.21720855e-02f, 2.18267441e-02f, 6.64592758e-02f, 1.67165063e-02f, 2.98094451e-02f, -3.46621452e-03f, 4.30744898e-04f, 1.95916109e-02f,
  -8.13976675e-02f, -4.98403853e-04f, -3.00284065e-02f, -7.63442665e-02f, -1.04607707e-02f, -5.80392778e-02f, 4.01038416e-02f, 4.51777428e-02f, 1.73073821e-02f, -2.95528136e-02f,
  7.31204823e-02f, 2.13672090e-02f, 4.03467901e-02f, -2.94721071e-02f, -5.18035330e-02f, 2.54950318e-02f, 1.20809730e-02f, 3.72281694e-03f, -9.12145805e-03f, -1.34916991e-01f,
  -4.90437448e-01f, -2.39418581e-01f, 4.98544984e-02f, 4.37910184e-02f, -3.27957347e-02f, -7.45892823e-02f, -7.21529359e-03f, -2.99731102e-02f, -7.58224204e-02f, -2.40524784e-02f,
  -7.99529999e-02f, -5.12270257e-02f, -7.17232376e-03f, 4.15006578e-02f, 2.32086442e-02f, -1.50534473e-02f, -1.54646277e-01f, -3.55121270e-02f, -1.00828469e-01f, 2.26963665e-02f,
  3.29906233e-02f, -2.00142190e-02f, 9.38593671e-02f, 2.10069623e-02f, -4.47225533e-02f, -3.66589315e-02f, -6.80403709e-02f, 8.28014687e-02f, -6.51996136e-02f, 9.87305641e-02f,
  2.46776074e-01f, 3.19360912e-01f, 8.45198631e-02f, 2.93328285e-01f, -9.33853984e-02f, 6.81904182e-02f, -2.30892133e-02f, 1.21290244e-01f, 1.59743786e-01f, 1.02705143e-01f,
  -3.67361754e-02f, 2.85173774e-01f, -1.60357803e-01f, 2.31876209e-01f, -1.96900398e-01f, 1.44484583e-02f, 1.18390862e-02f, 2.01680258e-01f, -1.74771428e-01f, 2.96114311e-02f,
  2.52829548e-02f, -2.00076997e-01f, -1.31656202e-02f, -2.67687231e-01f, 1.86802432e-01f, 3.02434135e-02f, -2.51153231e-01f, -8.96552354e-02f, 6.61473051e-02f, -1.87724024e-01f,
  -1.17256669e-02f, 8.58698115e-02f, 3.78753088e-04f, 1.13448374e-01f, 4.78277653e-02f, 3.45285609e-02f, 4.87736836e-02f, -1.40426368e-01f, -6.18658289e-02f, 8.26651901e-02f,
  1.49403602e-01f, 1.82842370e-02f, 4.21965942e-02f, -2.81072278e-02f, 1.03649490e-01f, 1.05069630e-01f, 5.23106083e-02f, 8.41982141e-02f, 1.51326433e-01f, 6.22391887e-02f,
  1.06332205e-01f, 1.01412751e-01f, 9.29875672e-02f, 2.11033985e-01f, 2.59699989e-02f, -4.53071203e-03f, 3.58209456e-03f, 4.70932052e-02f, 5.58515191e-02f, 6.38496429e-02f,
  -2.97788605e-02f, -1.32230848e-01f, -5.00148237e-02f, -7.80264437e-02f, 3.99373658e-02f, -4.88083921e-02f, -2.12149583e-02f, 3.24985683e-02f, 8.68667811e-02f, 8.45761299e-02f,
  -4.62443493e-02f, 4.27124910e-02f, 2.74450108e-02f, 3.03348843e-02f, -2.39259619e-02f, 3.68248858e-02f, -4.59019355e-02f, -1.28274104e-02f, 1.54591620e-01f, -1.21530928e-01f,
  -2.68763062e-02f, -1.70072373e-02f, -1.39812129e-02f, -1.02434140e-02f, -6.51856437e-02f, 2.46305373e-02f, -4.73154262e-02f, 4.30840626e-03f, -1.26380309e-01f, -4.38989736e-02f,
  -8.07394972e-04f, 1.28842980e-01f, -3.45961414e-02f, 7.75220171e-02f, -5.09809889e-02f, 5.00386320e-02f, -2.52075549e-02f, 1.24707751e-01f, -7.47224316e-02f, -7.86800534e-02f,
  -3.50624174e-02f, -8.08863565e-02f, 1.36967570e-01f, -3.67403589e-02f, 5.07211946e-02f, -9.22158640e-03f, 7.30359182e-02f, -4.22357768e-02f, -3.76461595e-02f, -3.15989964e-02f,
  6.83408454e-02f, -2.39715185e-02f, 9.97461602e-02f, 6.20943159e-02f, -1.10432580e-01f, 1.08778805e-01f, 8.34545419e-02f, 2.65645590e-02f, -2.59981044e-02f, -2.18104366e-02f,
  -7.15741456e-01f, 2.85442382e-01f, -8.47139731e-02f, -1.97313234e-01f, -6.02881908e-02f, -3.69659849e-02f, -2.22040638e-02f, 2.74702199e-02f, -6.22275583e-02f, 2.20878422e-02f,
  -1.30885869e-01f, -1.63930342e-01f, 1.42855614e-01f, 1.73893824e-01f, -2.52590001e-01f, 2.36674652e-01f, 8.73553008e-03f, 2.53537335e-02f, 1.46531180e-01f, 7.24670663e-03f,
  -3.16840671e-02f, 1.30501017e-01f, 1.31018206e-01f, 2.79211432e-01f, -4.35074307e-02f, -1.19909860e-01f, -1.79241031e-01f, 1.04515821e-01f, -1.10206954e-01f, -4.21201847e-02f,
  -2.59640783e-01f, -2.43302494e-01f, -1.32141739e-01f, -1.14889078e-01f, -1.27210170e-01f, -4.78939973e-02f, -9.26412269e-03f, -3.32783051e-02f, -3.96201164e-02f, 1.33590996e-02f,
  -5.27450852e-02f, 1.89850349e-02f, -1.77875347e-02f, 3.59910317e-02f, 2.82353908e-02f, -6.50208909e-03f, 1.00932933e-01f, 8.70256498e-02f, -5.87207545e-03f, 6.43231422e-02f,
  1.98901035e-02f, 2.80678291e-02f, 4.68174219e-02f, -4.10760380e-02f, -1.90062691e-02f, 1.54216634e-02f, 3.36761512e-02f, -2.12354809e-02f, -2.39297859e-02f, -4.01676893e-02f,
  1.23637624e-01f, 1.86738521e-02f, -7.78290397e-03f, -6.59280717e-02f, 3.44688818e-02f, -8.76413733e-02f, -7.77478963e-02f, -1.35026430e-03f, 8.18453822e-03f, 7.52086639e-02f,
  -8.38708580e-02f, -7.26509243e-02f, -3.74444351e-02f, 4.72869240e-02f, 1.60216708e-02f, -4.51104306e-02f, -1.02064647e-02f, -8.87161568e-02f, 8.22543949e-02f, -7.63450116e-02f,
  -1.27334418e-02f, -2.94323191e-02f, 4.48167920e-02f, 5.29800281e-02f, 1.10283419e-02f, 5.25417030e-02f, -9.21087619e-03f, 1.51449392e-04f, 2.06989218e-02f, -4.69078161e-02f,
  -3.35790128e-01f, -1.43692642e-01f, 3.67018320e-02f, -1.35141879e-01f, 1.87493842e-02f, 4.54026163e-02f, -5.44184074e-03f, -2.83157881e-02f, -3.45673598e-02f, -6.56633973e-02f,
  -2.87116282e-02f, -7.73653528e-03f, -9.80400145e-02f, -8.51701386e-03f, 4.77611460e-02f, -2.08266098e-02f, 1.66843515e-02f, -4.00052369e-02f, -3.77146974e-02f, -5.27072996e-02f,
  -3.64059918e-02f, -7.78669268e-02f, -8.16485882e-02f, -2.09109695e-03f, 5.42070419e-02f, -7.55075589e-02f, -1.17627859e-01f, -7.02965306e-03f, -4.85239439e-02f, 6.47057220e-02f,
  -1.66300297e-01f, 2.53417552e-01f, -2.43082628e-01f, 1.27334625e-01f, -1.02912650e-01f, 3.16143095e-01f, 2.91778117e-01f, -7.13459998e-02f, 3.17550898e-02f, 1.99459821e-01f,
  2.25871295e-01f, -1.52191333e-02f, 7.06210881e-02f, 2.52695590e-01f, -2.94925421e-02f, 1.65281042e-01f, 2.60005563e-01f, 1.04389623e-01f, -1.03945769e-01f, 8.20128694e-02f,
  -6.54262155e-02f, 2.33261585e-01f, -4.72040251e-02f, -9.67854708e-02f, 4.72361818e-02f, -1.29648373e-01f, 3.10307695e-03f, -9.94583592e-02f, 1.44464329e-01f, -5.12462072e-02f,
  6.35297224e-02f, 3.00244875e-02f, -1.42216340e-01f, -1.54900208e-01f, 5.25572337e-02f, 2.16278546e-02f, 6.13825805e-02f, -7.16769621e-02f, -2.43531913e-02f, 1.38713300e-01f,
  -5.15051819e-02f, -1.52534485e-01f, -1.12891607e-01f, -2.94486731e-02f, 4.61069942e-02f, 1.54434750e-02f, -1.01012528e-01f, 5.95104024e-02f, 2.41156258e-02f, 1.40565243e-02f,
  1.12520188e-01f, 1.76878162e-02f, -2.20290814e-02f, -4.46421467e-02f, -1.16843786e-02f, 1.71252247e-02f, 8.48816894e-03f, 2.90900208e-02f, -2.09790338e-02f, -6.07146062e-02f,
  9.31489468e-03f, -2.48978753e-02f, 7.68218786e-02f, 9.50690475e-04f, -5.35202436e-02f, -9.03606135e-03f, 9.84816626e-03f, -3.42028663e-02f, -8.07869360e-02f, 1.89399809e-01f,
  -6.72004297e-02f, 2.23307908e-02f, -2.32882071e-02f, 7.41586136e-03f, 1.62249375e-02f, 6.71390519e-02f, 4.71178852e-02f, -4.30283844e-02f, 2.71273702e-02f, 8.11587498e-02f,
  -3.63062061e-02f, -2.03674240e-03f, 8.57656822e-03f, 2.08579581e-02f, 1.07769938e-02f, -1.10095277e-01f, 9.93075520e-02f, -3.03798001e-02f, 5.38566820e-02f, -2.70360503e-02f,
  1.84031665e-01f, 8.71845335e-02f, -2.14776564e-02f, -4.11958247e-02f, 3.02429236e-02f, -8.50625262e-02f, 3.46504785e-02f, -7.28650317e-02f, 3.48258354e-02f, 4.16222773e-03f,
  -1.95442475e-02f, -3.87078337e-03f, 3.54078263e-02f, 3.15800421e-02f, -2.49633808e-02f, 3.31865996e-02f, 1.42181376e-02f, -1.34122577e-02f, 7.16185430e-03f, 2.48462223e-02f,
  5.21710776e-02f, 3.18224402e-03f, -5.67072853e-02f, 1.37311118e-02f, 2.80846041e-02f, 4.19748612e-02f, -6.32290319e-02f, 9.25685987e-02f, -4.17200141e-02f, -6.34700432e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -1.07676126e-02f, 1.80651382e-01f, 1.07549898e-01f, 1.53308645e-01f, -7.06384629e-02f, 1.60999671e-01f, 2.98092216e-01f, 2.30562657e-01f, 1.16977036e-01f, 7.10886046e-02f,
  5.97116724e-02f, 1.34330571e-01f, 6.68075681e-02f, -3.38773220e-03f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.25772372e-01f, -2.18366116e-01f, 2.22362280e-02f, 6.01654127e-03f, 9.72718373e-02f, 2.09691361e-01f, -3.30002606e-01f, -4.45440449e-02f, 1.79775238e-01f, -1.85525164e-01f,
  1.95098042e-01f, 1.78538725e-01f, 2.10404783e-01f, -2.02295572e-01f, -1.97539538e-01f, -4.71535116e-01f, 1.07383043e-01f, -2.37409994e-01f, -2.32890099e-01f, 6.34040032e-03f,
  -8.13467894e-03f, -9.25641954e-02f, -3.78882280e-04f, -2.29226351e-01f, 7.96937793e-02f, 2.12380856e-01f, 1.15258858e-01f, -1.80771366e-01f, 2.82469869e-01f, -1.10040627e-01f,
  1.44282682e-02f, -9.95062813e-02f, 1.20371342e-01f, 1.70769632e-01f, 1.82754919e-01f, 3.69653851e-02f, -8.38592798e-02f, 9.89359096e-02f, 1.42990589e-01f, 1.51127860e-01f,
  2.96354353e-01f, -3.41893703e-01f, 3.03508729e-01f, -4.23902631e-01f, 1.89040974e-01f, -4.41596299e-01f, -5.60306273e-02f, -2.86340356e-01f, -2.36244306e-01f, -1.91441700e-01f,
  4.40888911e-01f, 1.32829949e-01f, -1.73598364e-01f, 2.89536834e-01f, -8.25641900e-02f, -2.43812859e-01f, 6.85008019e-02f, 2.74869669e-02f, -2.83033103e-01f, 2.23732352e-01f,
  9.15264860e-02f, -5.90254404e-02f, 6.95042238e-02f, -1.21825757e-02f, -3.29466828e-04f, -5.50528280e-02f, -1.70257658e-01f, -1.63346380e-01f, 6.14521727e-02f, -3.05422861e-02f,
  -1.82016492e-01f, -7.23410025e-02f, -3.57410610e-01f, 2.44666278e-01f, -2.52213866e-01f, 1.12100162e-01f, -2.27144808e-02f, 2.09438786e-01f, 1.11274965e-01f, 3.17835152e-01f,
  1.15608662e-01f, 1.93585232e-01f, -1.24142151e-02f, 8.47549289e-02f, -1.16466984e-01f, -3.95751476e-01f, 1.35146588e-01f, -2.15043221e-02f, 1.44468516e-01f, -1.60827428e-01f,
  4.63485382e-02f, -3.02305119e-03f, -9.62306932e-02f, 1.45215139e-01f, 1.48924828e-01f, -3.53954226e-01f, -1.09662339e-01f, -1.33192256e-01f, -2.62336254e-01f, -1.51632816e-01f,
  -3.34283672e-02f, 8.57231990e-02f, -5.53099103e-02f, 1.02656037e-01f, -1.25896275e-01f, -2.63807140e-02f, -2.05689147e-01f, 3.23627293e-02f, -1.08728178e-01f, 2.35826209e-01f,
  -1.90541357e-01f, -5.06487563e-02f, 1.74394533e-01f, -1.23534814e-01f, 1.99792519e-01f, 7.73346946e-02f, -2.94429123e-01f, -1.52113333e-01f, -5.59521690e-02f, 2.00252205e-01f,
  8.73368606e-02f, -3.00115108e-01f, -1.57739986e-02f, -2.48961933e-02f, -2.21570775e-01f, -1.65140375e-01f, 5.26992083e-02f, -2.33322784e-01f, -1.44454315e-01f, 2.81734820e-02f,
  5.15878722e-02f, 2.06993684e-01f, 7.33978255e-03f, 4.81330510e-03f, 2.92556345e-01f, -1.63987085e-01f, -1.71808004e-01f, 1.32860959e-01f, -7.06447801e-03f, -2.57915277e-02f,
  -9.45038125e-02f, -3.16677362e-01f, -4.83289771e-02f, -7.83433765e-02f, -4.16993201e-01f, 2.30931118e-03f, 1.13112234e-01f, -6.34962972e-03f, 4.54108901e-02f, 2.51569927e-01f,
  -2.52105862e-01f, 6.36427701e-02f, -5.97459003e-02f, 1.81531474e-01f, -2.32830063e-01f, 1.62803814e-01f, 1.80932894e-01f, -1.57834843e-01f, 2.55598426e-01f, 8.54824632e-02f,
  -7.33401552e-02f, 8.36251825e-02f, 9.86334905e-02f, -3.30508165e-02f, 1.25968203e-01f, 2.54523735e-02f, -1.78225636e-01f, 8.83736238e-02f, 5.10641858e-02f, -3.64367872e-01f,
  2.95094430e-01f, -9.59541276e-02f, 2.54725844e-01f, -3.23849171e-01f, 9.59024057e-02f, -6.37183636e-02f, 1.05705380e-01f, 3.20516936e-02f, -3.28124136e-01f, -1.48026541e-01f,
  -1.78108945e-01f, -1.21715359e-01f, 2.11414874e-01f, -3.14956605e-01f, 3.15921418e-02f, -1.92665756e-01f, -1.91998765e-01f, 1.99025199e-02f, 1.09010465e-01f, -2.43805632e-01f,
  2.46149469e-02f, 9.07431636e-03f, 7.34216645e-02f, -1.16524346e-01f, -8.42344612e-02f, -3.31173807e-01f, -1.25654697e-01f, 2.85752356e-01f, 1.11491881e-01f, -1.37996495e-01f,
  2.18898758e-01f, 2.76460287e-05f, 3.98680791e-02f, 2.71894448e-02f, -3.04340035e-01f, -3.96657959e-02f, -8.45571905e-02f, -1.60088569e-01f, -2.01931208e-01f, -2.80450732e-01f,
  -2.26876855e-01f, 3.33626866e-01f, 3.80955249e-01f, 1.49382561e-01f, 3.33054602e-01f, 5.01525737e-02f, 9.66127887e-02f, 2.59249151e-01f, -4.96696532e-02f, -1.01125300e-01f,
  -6.94206953e-02f, -7.41959214e-02f, -1.62800774e-01f, 2.37833872e-01f, 8.75465870e-02f, -2.38009512e-01f, 8.42968002e-02f, 4.02883850e-02f, -2.01274216e-01f, -1.73101798e-01f,
  5.88809652e-03f, 8.74942467e-02f, -2.10013300e-01f, -1.60171896e-01f, -1.16762377e-01f, 1.89375386e-01f, 2.51115430e-02f, 1.07437344e-02f, -4.12058942e-02f, -1.91150919e-01f,
  3.05061936e-01f, -1.83690220e-01f, 4.73936163e-02f, -1.18493503e-02f, -6.41674399e-02f, -2.56936938e-01f, -3.00134987e-01f, 1.85190126e-01f, -2.42500618e-01f, 2.88323462e-01f,
  2.83801794e-01f, -1.72849327e-01f, 3.59392613e-02f, 1.78109944e-01f, -3.58113289e-01f, -2.12083921e-01f, 1.18870154e-01f, 1.40683413e-01f, 1.67708322e-01f, -8.71282667e-02f,
  -4.07650210e-02f, 1.11335628e-01f, 4.62138187e-03f, 1.58931851e-01f, 1.19614266e-01f, -3.00588906e-01f, 5.85226864e-02f, 1.55625999e-01f, 4.98270839e-02f, 3.50101978e-01f,
  -1.77407011e-01f, -1.74289495e-01f, 2.09182516e-01f, 2.17142835e-01f, -2.72931963e-01f, -5.32574542e-02f, -1.01500563e-01f, -2.26008475e-01f, 2.96192437e-01f, 4.78571169e-02f,
  1.56652004e-01f, -2.28053048e-01f, 1.44660264e-01f, -1.76833235e-02f, -4.08780249e-03f, 5.55726439e-02f, -8.17030892e-02f, -1.11462511e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  7.53637180e-02f, 4.74582314e-01f, 1.83680266e-01f, 4.73539025e-01f, 3.87033999e-01f, -9.91910174e-02f, 3.19419086e-01f, 3.68323594e-01f, 1.00215457e-01f, 5.12510300e-01f,
  -2.55015165e-01f, -3.94297183e-01f, -4.22149412e-02f, -5.79022244e-02f, 2.76735544e-01f, 4.25016671e-01f, -2.05562010e-01f, 2.47686774e-01f, 1.87889978e-01f, -8.98517370e-02f,
  9.84893590e-02f, 8.19883496e-02f, -6.40261844e-02f, 2.61163473e-01f, 2.09188551e-01f, 3.99245948e-01f, 4.90836427e-02f, 3.02726567e-01f, 4.08054233e-01f, 4.70189482e-01f,
  5.05350649e-01f, 1.50494516e-01f, -7.22640455e-02f, 2.62419432e-01f, 2.45619625e-01f, 2.02582225e-01f, 1.96119055e-01f, -6.38909824e-03f, 1.66314706e-01f, 1.14625618e-01f,
  2.05017716e-01f, 6.45586476e-02f, 2.77682245e-01f, -3.87680739e-01f, 4.67036098e-01f, -2.17531562e-01f, 1.55428439e-01f, 8.73509198e-02f, 6.62734881e-02f, 8.35936144e-02f,
  4.15509939e-02f, -7.58132562e-02f, 9.46750343e-02f, -3.32995087e-01f, 2.25988060e-01f, -2.17895612e-01f, 2.34620184e-01f, 2.27660462e-01f, -8.68593901e-02f, -5.61334267e-02f,
  6.01430833e-01f, -5.48946634e-02f, 4.91689384e-01f, 7.91605413e-02f, 2.83749700e-01f, 8.42496604e-02f, 8.50676596e-02f, -8.68549719e-02f, 1.04141384e-01f, 4.21853870e-01f,
  4.54107858e-02f, 8.24679956e-02f, 4.96873334e-02f, -1.78178161e-01f, -1.20067507e-01f, 1.21431798e-01f, -4.12765115e-01f, -6.76222816e-02f, -3.47713470e-01f, -2.61135161e-01f,
  -3.62007767e-01f, -4.32666481e-01f, 4.41007838e-02f, 4.73931640e-01f, 9.74664316e-02f, 3.06973130e-01f, 2.24952355e-01f, 1.01036668e-01f, 1.70148507e-01f, 1.43741965e-01f,
  6.10830523e-02f, -1.81824043e-01f, -3.92262936e-01f, -1.20938644e-01f, -3.48982900e-01f, 2.45945286e-02f, -1.13367952e-01f, 7.79536888e-02f, -1.57065943e-01f, 3.10045004e-01f,
  -4.48274463e-02f, -9.48218349e-03f, -5.59525974e-02f, 1.23320512e-01f, -6.82053640e-02f, 4.03355569e-01f, -3.00744742e-01f, -6.19605303e-01f, 1.32341787e-01f, -2.16378853e-01f,
  -6.82117790e-02f, 7.51396269e-02f, -3.22927125e-02f, -2.32375622e-01f, 5.02608478e-01f, 3.93232405e-02f, 1.29932895e-01f, -3.30592506e-02f, -3.48392390e-02f, 1.71374574e-01f,
  5.83983073e-03f, 4.33142930e-01f, -9.33828428e-02f, 7.78558701e-02f, 3.32272559e-01f, -1.75051421e-01f, 8.53615776e-02f, -8.60137027e-03f, 2.58292407e-01f, -2.72074670e-01f,
  2.48263463e-01f, 6.83100224e-02f, 1.05271421e-01f, -1.07172672e-02f, 2.90327370e-01f, -1.20906964e-01f, 1.16081133e-01f, -2.00261816e-01f, -3.43908295e-02f, 2.18486354e-01f,
  -1.16361387e-01f, -2.01389164e-01f, 1.01833627e-01f, -1.64587330e-02f, -4.11025807e-02f, 3.56444448e-01f, 2.77336419e-01f, 2.09741101e-01f, 2.00409871e-02f, 1.96662560e-01f,
  -5.45064919e-02f, 3.71019512e-01f, -2.47951269e-01f, 1.13303259e-01f, 2.75549650e-01f, 2.71015167e-01f, -3.55595201e-01f, 3.80379677e-01f, -3.85435790e-01f, 1.33137465e-01f,
  2.28381693e-01f, 3.61697584e-01f, 7.40921348e-02f, 2.49835789e-01f, 3.31332117e-01f, -2.98923603e-03f, 4.27381814e-01f, 3.40760686e-02f, 9.18825567e-02f, 2.62135834e-01f,
  -4.54137400e-02f, -3.16359431e-01f, -3.04414146e-02f, -1.36284515e-01f, -3.01248372e-01f, 2.82299310e-01f, -3.61107498e-01f, -1.51256219e-01f, 1.61800861e-01f, 1.26588255e-01f,
  2.31205195e-01f, -3.99710238e-02f, 2.54315019e-01f, 1.27496034e-01f, 2.23173931e-01f, 3.14330429e-01f, -1.11335285e-01f, 1.78947091e-01f, 1.53363213e-01f, -1.64161250e-01f,
  -6.65717933e-04f, 3.35486650e-01f, 3.50458592e-01f, 5.38854338e-02f, 1.04226351e-01f, -2.23478163e-03f, 3.80293399e-01f, 3.83625239e-01f, 2.92483717e-01f, 4.67203790e-03f,
  1.01491332e-01f, -2.77062990e-02f, -7.09508508e-02f, 3.63703549e-01f, -2.98767984e-01f, 3.80717933e-01f, -3.40831816e-01f, 3.27855647e-02f, -1.61776379e-01f, -6.25568554e-02f,
  -3.08615575e-03f, 2.10823834e-01f, 3.51848722e-01f, 2.77162164e-01f, 2.00407207e-03f, 2.77984142e-01f, 2.00159669e-01f, 1.95878178e-01f, 3.02142680e-01f, -1.32793516e-01f,
  -4.16226000e-01f, 1.13837995e-01f, -3.31838548e-01f, 2.05447212e-01f, 2.50941545e-01f, 1.19777024e-01f, 4.97038633e-01f, 4.18767929e-01f, 6.15437180e-02f, 3.52945119e-01f,
  -1.18852220e-02f, 1.48618266e-01f, 3.04754347e-01f, -2.84826756e-01f, 2.06538543e-01f, 2.07788989e-01f, 2.81518936e-01f, -6.94271235e-04f, 6.31649867e-02f, -2.00286880e-01f,
  4.16975617e-01f, 4.76291299e-01f, -3.28397363e-01f, -5.12546062e-01f, 1.38524026e-01f, -3.46390814e-01f, -2.26589009e-01f, -3.28550786e-01f, 8.49910975e-02f, 1.02783449e-01f,
  1.02574043e-01f, 2.03564037e-02f, 1.48335591e-01f, 9.76079404e-02f, 1.81117579e-01f, 8.60103872e-03f, -2.71083210e-02f, -2.44478136e-01f, 1.45578131e-01f, -8.70939642e-02f,
  1.23105310e-01f, 1.50973737e-01f, -1.99180603e-01f, -2.40921043e-02f, -2.27523670e-02f, 2.21473649e-01f, -3.07086706e-01f, 4.92993653e-01f, -7.31196105e-02f, 3.71305913e-01f,
  6.38601035e-02f, -2.09359348e-01f, 2.45751441e-01f, -2.11485028e-02f, -1.02610119e-01f, 1.89536065e-01f, 9.22908410e-02f, -1.22123912e-01f, 1.14004396e-01f, 3.21406245e-01f,
  -2.03880891e-01f, 2.99626529e-01f, 3.37266564e-01f, -3.28449339e-01f, -1.20085374e-01f, 3.01450312e-01f, -1.03521280e-01f, -7.54450262e-02f, 2.07300663e-01f, 2.21217483e-01f,
  3.17689508e-01f, 1.88779831e-01f, 1.86522186e-01f, 2.65587062e-01f, 1.76248983e-01f, 1.50678128e-01f, 2.97858953e-01f, -4.63349789e-01f, -6.41295984e-02f, 2.61686057e-01f,
  1.85018077e-01f, -2.56620675e-01f, 3.56580585e-01f, -1.85312793e-01f, 3.74450237e-02f, 1.65494546e-01f, 2.30095908e-01f, -1.57845885e-01f, -3.48265260e-01f, -6.29969388e-02f,
  -2.82415807e-01f, -2.64193267e-01f, -1.25052899e-01f, -2.33004779e-01f, -1.26953483e-01f, 3.15698683e-01f, 1.74919218e-01f, -4.37653107e-05f, 4.70125228e-02f, -3.81025702e-01f,
  3.71749818e-01f, 2.27835953e-01f, 3.31011474e-01f, 3.19888353e-01f, 3.58155876e-01f, 6.54188544e-02f, 1.54750258e-01f, 1.66118190e-01f, 1.80476606e-01f, 2.19983682e-01f,
  3.03886801e-01f, 3.19476843e-01f, -1.37284726e-01f, 6.88395679e-01f, -3.61094356e-01f, 1.93653882e-01f, -3.46404500e-02f, 3.19398046e-01f, -4.92030084e-01f, -9.90989506e-02f,
  5.20844638e-01f, -2.36061795e-04f, 2.58035697e-02f, 5.47257364e-02f, 3.73680621e-01f, 5.56591041e-02f, 2.61783779e-01f, 2.02246338e-01f, 1.09816171e-01f, 3.65520537e-01f,
  1.47331029e-01f, 3.60911518e-01f, 2.29738623e-01f, 5.03145810e-03f, -8.15189704e-02f, -1.30131021e-01f, 1.48889557e-01f, 1.67616725e-01f, -1.46078542e-01f, 3.29664871e-02f,
  2.43424952e-01f, -1.94372922e-01f, 2.64401555e-01f, 1.73091441e-01f, -2.09001809e-01f, 5.49802303e-01f, -2.92189121e-01f, -1.47079185e-01f, 3.02925289e-01f, -1.91618055e-01f,
  -7.11097419e-02f, 3.42465043e-01f, 9.29695964e-02f, -2.99375523e-02f, 4.78784353e-01f, 2.17053473e-01f, 2.42260262e-01f, -5.01293987e-02f, 2.77931154e-01f, -4.40473594e-02f,
  -3.43382627e-01f, 2.14172080e-02f, -1.82221070e-01f, -6.59128353e-02f, 2.93240577e-01f, 2.29792103e-01f, 7.90130347e-02f, -5.07798418e-02f, 6.41025603e-02f, 1.57754853e-01f,
  4.78570014e-01f, 1.22481994e-02f, 3.29554290e-01f, 1.07198238e-01f, 3.28591436e-01f, -1.51687324e-01f, -3.00440371e-01f, -2.24914588e-02f, -3.73555630e-01f, 3.44866961e-01f,
  -3.81699860e-01f, 1.55047968e-01f, 4.21530791e-02f, 2.27411091e-03f, 4.33412999e-01f, 2.93126971e-01f, 6.33339733e-02f, -8.41483697e-02f, 1.22966945e-01f, 4.10016393e-03f,
  -2.02050023e-02f, 2.02651545e-01f, -8.92553404e-02f, -3.30427811e-02f, 3.22672091e-02f, 3.30938846e-01f, 2.87010044e-01f, 3.10287416e-01f, -1.88253760e-01f, -4.40487899e-02f,
  7.41372481e-02f, 2.38512650e-01f, 1.05951123e-01f, 1.24618381e-01f, 2.78683037e-01f, -2.40329161e-01f, 2.84727633e-01f, -2.42517322e-01f, -2.45284244e-01f, 2.73228884e-01f,
  -1.45505607e-01f, 3.77146184e-01f, -1.73989847e-01f, 1.55405521e-01f, -5.00752144e-02f, 4.28693555e-02f, 7.39396736e-02f, 1.15695745e-01f, 4.97004598e-01f, 2.35698774e-01f,
  2.05319613e-01f, -7.61655122e-02f, 7.65365958e-02f, 1.70265347e-01f, -3.30478162e-01f, -1.00347534e-01f, 3.87191139e-02f, 2.81621635e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.00676551e-01f, 4.81183268e-02f, 2.89045334e-01f, 1.39404893e-01f, 1.46645308e-01f, 7.79794063e-03f, 3.69876146e-01f, 3.46580327e-01f, -2.42505986e-02f, 3.47237676e-01f,
  1.82554990e-01f, 1.84507281e-01f, 1.58601210e-01f, -1.11832134e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.67236590e-01f, -1.29169285e-01f, -2.12072834e-01f, -2.01373503e-01f, 1.21471353e-01f, -1.78746849e-01f, 1.78564817e-01f, 1.08168289e-01f, 5.44272214e-02f, -2.87804246e-01f,
  -2.15490088e-01f, -6.48605525e-02f, -1.73967779e-01f, 2.89805174e-01f, -2.62245834e-01f, -2.14716241e-01f, -1.55026063e-01f, -1.82376038e-02f, 1.90270498e-01f, 1.20636545e-01f,
  -3.34882677e-01f, -1.49792045e-01f, 1.74861506e-01f, 2.40305722e-01f, 4.44471464e-02f, 2.25783944e-01f, -2.28454426e-01f, -1.97995789e-02f, 6.58027008e-02f, -2.57641822e-01f,
  2.26783589e-01f, -2.22628132e-01f, -1.39619291e-01f, 7.25676343e-02f, -1.55774698e-01f, -1.17108732e-01f, 1.23551320e-02f, -5.64280897e-03f, 1.10272512e-01f, -2.88515277e-02f,
  -1.44079715e-01f, -2.68636197e-01f, 2.60736972e-01f, -1.96713865e-01f, 1.84520818e-02f, 3.57954890e-01f, 1.06687739e-01f, 3.40482593e-02f, -2.29738057e-01f, -2.19202518e-01f,
  3.16296821e-04f, 9.49367732e-02f, -1.49579257e-01f, 1.41390309e-01f, -5.72898891e-03f, 2.43041545e-01f, 5.92184216e-02f, -9.09119546e-02f, -3.70737702e-01f, 8.88649300e-02f,
  5.16620688e-02f, -2.05792651e-01f, 2.84493506e-01f, 1.11131944e-01f, -1.57229990e-01f, 6.08720966e-02f, 5.35826236e-02f, 1.12141922e-01f, 1.43605292e-01f, -1.46812215e-01f,
  3.03951085e-01f, 2.19163876e-02f, 3.98943014e-02f, -2.22867817e-01f, -2.00833201e-01f, 1.72861040e-01f, -2.55858805e-02f, -1.65072188e-01f, -1.84156552e-01f, -2.15819925e-01f,
  1.84668556e-01f, 9.29195136e-02f, 1.04480788e-01f, -4.80433971e-01f, -1.87671155e-01f, -3.11781876e-02f, 3.87304574e-01f, -3.03500369e-02f, 1.82788953e-01f, -1.55247122e-01f,
  3.69392037e-02f, -2.88311362e-01f, 1.91699579e-01f, 1.45965412e-01f, 3.23871583e-01f, 1.73921838e-01f, -3.37623090e-01f, 1.90844610e-02f, 4.08370281e-03f, -6.67809919e-02f,
  -1.96649656e-01f, 3.97034138e-02f, -2.09352568e-01f, -1.05328932e-01f, -2.08298266e-02f, 7.10914889e-03f, -2.67161399e-01f, 1.98646367e-01f, 1.49191126e-01f, -5.66335730e-02f,
  -3.63720506e-01f, 3.21068883e-01f, 2.28227060e-02f, -1.73166782e-01f, -2.82102153e-02f, -6.74692541e-02f, -4.41789739e-02f, -2.10201722e-02f, 2.71542162e-01f, -1.59206707e-02f,
  2.65156925e-01f, -8.59725699e-02f, -2.37140983e-01f, -2.97224581e-01f, 2.05242977e-01f, 2.53028244e-01f, 6.33469149e-02f, 3.78114760e-01f, -2.10387915e-01f, 5.35175838e-02f,
  9.50812325e-02f, -1.57171503e-01f, 1.34795099e-01f, 1.17242534e-03f, 1.87030286e-02f, 8.67838115e-02f, -4.84083593e-02f, 6.73518404e-02f, -2.97210127e-01f, 1.70424819e-01f,
  -6.61037862e-02f, -1.61185384e-01f, 1.04640596e-01f, -2.45817870e-01f, 3.43580469e-02f, -1.00130839e-02f, 1.99176103e-01f, 1.83438241e-01f, -3.60605121e-01f, 6.66643083e-02f,
  -1.28017575e-01f, 4.85202782e-02f, -2.04641491e-01f, 1.28629357e-01f, 1.22479916e-01f, -2.31354296e-01f, 2.17993006e-01f, -2.60500126e-02f, -4.42149825e-02f, -3.05409860e-02f,
  -1.33768013e-02f, -2.26263404e-01f, -7.52378777e-02f, -9.62023735e-02f, 1.16662167e-01f, -1.94128841e-01f, -4.55564372e-02f, 1.62335187e-01f, 5.03808707e-02f, -9.39835832e-02f,
  4.73318458e-01f, -2.76136041e-01f, -1.91219822e-01f, 2.60505617e-01f, -6.21259622e-02f, -1.48932949e-01f, -3.70026797e-01f, -1.00497499e-01f, 1.60253629e-01f, 5.13380766e-02f,
  1.72822639e-01f, -2.12299768e-02f, 3.71743925e-02f, 7.88904503e-02f, -1.42100215e-01f, -1.58868030e-01f, -2.92424560e-01f, 2.92911410e-01f, -2.98112810e-01f, -1.58436418e-01f,
  6.03733659e-02f, 9.64904279e-02f, -2.03785244e-02f, -1.31889284e-01f, -2.24054545e-01f, -4.90694046e-02f, 1.88857198e-01f, 2.42473613e-02f, 1.51163489e-01f, 9.94992033e-02f,
  1.05926007e-01f, -8.85048043e-03f, 7.20075332e-03f, 7.25608170e-02f, 1.67356014e-01f, 1.99513897e-01f, -1.11614935e-01f, 5.05817682e-02f, 2.73663580e-01f, -1.28372073e-01f,
  1.47174269e-01f, -5.56689464e-02f, -8.83868486e-02f, 2.99416006e-01f, 1.12186082e-01f, 1.90585658e-01f, -2.80484017e-02f, -1.54516455e-02f, -1.28945217e-01f, 6.27873689e-02f,
  -2.26299092e-01f, -3.34318995e-01f, 2.46725958e-02f, -9.34282094e-02f, -1.78404570e-01f, -4.64919284e-02f, -2.26397932e-01f, -2.20551655e-01f, -1.77701980e-01f, -1.11694559e-01f,
  -2.00027972e-02f, 1.03793874e-01f, -1.75831854e-01f, 1.49311036e-01f, 1.70788348e-01f, -1.26027972e-01f, 1.81725189e-01f, 2.57637799e-01f, -1.44624591e-01f, 1.85838386e-01f,
  -8.50604326e-02f, -2.08598509e-01f, 1.14963248e-01f, 5.89449704e-02f, -1.58648670e-01f, 3.10101151e-01f, -1.99171737e-01f, 1.74979076e-01f, 7.88801536e-03f, -2.76659876e-01f,
  -2.47219771e-01f, -2.93485105e-01f, -5.08578457e-02f, -1.50608391e-01f, -5.10988384e-02f, -5.14410948e-03f, -4.36660238e-02f, 4.72351648e-02f, 1.61944143e-02f, 8.66240487e-02f,
  -3.52351069e-02f, 6.99277669e-02f, -1.02012917e-01f, -1.88437048e-02f, -9.18241963e-02f, -4.66604345e-02f, -9.85156279e-03f, -1.09309226e-01f, 2.01790005e-01f, -5.14654396e-03f,
  -3.14446896e-01f, -1.62563071e-01f, 2.05360755e-01f, -1.99730843e-01f, -1.86131611e-01f, -2.09349915e-01f, 9.37387124e-02f, 2.63099104e-01f, -8.79184082e-02f, -9.74361897e-02f,
  1.50047004e-01f, -1.50817528e-01f, 2.23164186e-01f, 1.98421761e-01f, 1.14506604e-02f, -1.38257325e-01f, -1.41495556e-01f, -2.97811508e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.51421982e-01f, 3.30514759e-01f, 3.19399446e-01f, 2.93641299e-01f, 1.51781008e-01f, 4.19772893e-01f, -5.21715023e-02f, 5.73484600e-02f, -2.26638839e-01f, 4.79335152e-02f,
  -1.93875402e-01f, 8.41111131e-03f, 1.69899240e-01f, -4.58002687e-01f, -2.38697212e-02f, 4.22963440e-01f, -1.74929291e-01f, 2.12006629e-01f, -2.58962423e-01f, -4.34639771e-03f,
  3.25358480e-01f, -2.49139979e-01f, -2.24784091e-01f, 4.88284901e-02f, 3.35678011e-01f, -1.29201800e-01f, 2.71564633e-01f, -9.14037600e-02f, 2.09621236e-01f, 3.47963840e-01f,
  1.86754674e-01f, 1.38835862e-01f, 1.68202266e-01f, 5.26839256e-01f, 2.41197526e-01f, 1.10257633e-01f, 4.68929112e-01f, 2.22579077e-01f, 1.94498152e-01f, 1.85643107e-01f,
  3.39744329e-01f, -2.27781814e-02f, -1.00002974e-01f, 1.04411334e-01f, -2.92636544e-01f, -1.28520876e-01f, 2.25611731e-01f, -5.32092631e-01f, -1.16598308e-01f, 3.17837805e-01f,
  4.89526570e-01f, 3.60170811e-01f, -3.85276020e-01f, -1.27482831e-01f, -4.31656577e-02f, -1.27482474e-01f, -9.29027870e-02f, 7.59923577e-01f, -6.77027106e-02f, 1.31780133e-01f,
  3.77365023e-01f, -9.95432213e-02f, -2.30715591e-02f, -1.94610208e-01f, 1.58859059e-01f, 4.16971713e-01f, 1.13687821e-01f, 4.04417336e-01f, 2.74500877e-01f, 1.58607975e-01f,
  9.15600806e-02f, 4.25363451e-01f, -1.02959536e-01f, 5.01089156e-01f, 1.81501254e-01f, -3.84460270e-01f, 2.91080177e-01f, -3.40109646e-01f, -1.37033284e-01f, 3.30417365e-01f,
  5.35949051e-01f, 3.34363788e-01f, -3.86546046e-01f, -2.09928796e-01f, 3.27698380e-01f, 3.11039872e-02f, 1.26515269e-01f, -3.43669981e-01f, 3.13323349e-01f, 2.11268604e-01f,
  4.73870903e-01f, 2.99277782e-01f, 5.02071083e-02f, 3.59798282e-01f, -2.24564672e-01f, -1.92577899e-01f, 2.77620912e-01f, 4.36817884e-01f, 8.47620666e-02f, -1.27980039e-01f,
  6.19239956e-02f, 3.93578738e-01f, -1.70391396e-01f, -1.33128300e-01f, -1.48476094e-01f, -1.34038553e-01f, 8.31554681e-02f, -1.87753767e-01f, -1.73188359e-01f, -3.38066071e-01f,
  -7.75391189e-03f, 3.14115435e-01f, -3.70269150e-01f, 3.19985002e-01f, -2.27542639e-01f, 5.94711788e-02f, 1.42666191e-01f, -1.81984887e-01f, -1.62311524e-01f, 2.49581188e-01f,
  1.88808292e-01f, -1.80251971e-02f, -4.69658561e-02f, -9.66710821e-02f, 4.38828677e-01f, 4.87325728e-01f, 3.34526122e-01f, 4.26319629e-01f, 3.61530840e-01f, -1.68014541e-01f,
  5.37109077e-01f, 6.25382781e-01f, 2.15067983e-01f, 3.68850604e-02f, 4.77447629e-01f, 1.29286870e-01f, 2.42575631e-01f, -5.09007275e-01f, -1.72458246e-01f, 3.66480410e-01f,
  -3.40800375e-01f, -3.37663621e-01f, -3.04716170e-01f, -5.75539112e-01f, 2.85614222e-01f, 3.28797787e-01f, 4.92599010e-01f, 1.22675672e-01f, -2.64924049e-01f, 1.45023078e-01f,
  3.05474699e-01f, -1.22247614e-01f, 2.27777362e-01f, 3.63761000e-02f, 4.74154860e-01f, 4.95507985e-01f, 1.55692235e-01f, 8.18649121e-03f, -1.97688475e-01f, -7.42600933e-02f,
  2.09181368e-01f, 3.38617176e-01f, 2.10932419e-01f, 2.20001578e-01f, 1.59413621e-01f, 3.58394720e-02f, 5.97702980e-01f, 2.46724531e-01f, 5.34534901e-02f, 3.95974398e-01f,
  2.49863312e-01f, -3.30927521e-01f, -4.15816337e-01f, -4.40526277e-01f, 3.14955294e-01f, -1.88803941e-01f, 6.69816732e-02f, 5.10471582e-01f, -7.19825998e-02f, 1.59634531e-01f,
  -2.25500971e-01f, -2.21456110e-01f, -1.39033841e-02f, -9.51609090e-02f, -1.34275705e-01f, 6.72972977e-01f, -1.82561547e-01f, 4.99417424e-01f, -7.68884867e-02f, 2.56856501e-01f,
  5.67219481e-02f, 1.78215653e-01f, 2.25905970e-01f, 3.62029701e-01f, 4.05539945e-02f, 1.85640275e-01f, -2.12760806e-01f, 2.78096795e-01f, -6.01851940e-03f, -1.66115120e-01f,
  -2.56268024e-01f, 6.39775023e-03f, 2.09535912e-01f, 3.29099804e-01f, 1.37691706e-01f, -7.09796846e-01f, 5.14025450e-01f, 6.35788560e-01f, -6.18367851e-01f, 4.78763163e-01f,
  -3.94935757e-01f, 3.03305715e-01f, 3.14021111e-01f, -1.53142199e-01f, -1.93438694e-01f, 6.07110038e-02f, -1.87781632e-01f, -3.28967631e-01f, -1.23872131e-01f, -1.34113878e-01f,
  -2.07212463e-01f, 3.99631947e-01f, 2.04889271e-02f, 2.86809206e-01f, 2.02521205e-01f, -2.91153729e-01f, 1.05917156e-01f, 2.87475199e-01f, 4.10442114e-01f, 3.92985731e-01f,
  5.44121340e-02f, 4.93608177e-01f, 3.97359937e-01f, 4.31216121e-01f, 5.59139013e-01f, -4.84133899e-01f, -3.27385604e-01f, -3.50859612e-02f, 1.63510779e-03f, 5.25640607e-01f,
  3.34095396e-02f, 2.45386600e-01f, -6.43082678e-01f, -5.95543347e-02f, 4.30902243e-01f, -5.99599361e-01f, 2.81286865e-01f, -2.76945233e-01f, 1.08136602e-01f, -5.38653955e-02f,
  -1.41893581e-01f, 1.77358836e-01f, -3.56137842e-01f, 2.60303263e-02f, 1.43792704e-01f, -4.52342212e-01f, 2.75517076e-01f, 1.14898764e-01f, 4.94138151e-02f, 2.09363863e-01f,
  1.51134059e-01f, 2.86266387e-01f, 4.59512740e-01f, 3.83506238e-01f, 1.76402941e-01f, 5.14029920e-01f, 2.12830231e-01f, -2.42716461e-01f, -2.31780007e-01f, -2.86037594e-01f,
  4.93925959e-01f, -1.42127022e-01f, 7.73861259e-02f, 4.85385299e-01f, -3.53243649e-02f, 2.49193221e-01f, -2.85881251e-01f, -1.76889729e-02f, 5.47077274e-03f, -1.36628687e-01f,
  6.39853301e-03f, 6.08940303e-01f, -3.28601748e-01f, 1.46961406e-01f, 4.07614440e-01f, -2.72261016e-02f, -1.53400555e-01f, -2.94615805e-01f, 1.29158953e-02f, 2.35805824e-01f,
  -2.31464311e-01f, -2.41848886e-01f, 1.13270544e-01f, 4.08196211e-01f, -1.85461059e-01f, -1.17979266e-01f, 2.98555076e-01f, 1.23027571e-01f, 4.17687088e-01f, -6.43831432e-01f,
  -1.13929011e-01f, 2.12107450e-01f, -1.93405166e-01f, 3.54301125e-01f, -5.16303062e-01f, 2.88474381e-01f, 5.51947393e-02f, 1.30010530e-01f, 2.48877063e-01f, -5.17969191e-01f,
  -5.71437692e-03f, 5.00908829e-02f, 9.91780832e-02f, 2.00125501e-01f, -5.55154145e-01f, -2.87190620e-02f, 5.22107363e-01f, 2.64930837e-02f, 4.56446648e-01f, 1.18767872e-01f,
  -9.75024700e-03f, 3.46345961e-01f, 3.71694565e-01f, 1.51088806e-02f, 3.24566513e-02f, -6.39098883e-02f, 2.25091308e-01f, 2.84421891e-01f, 6.37055859e-02f, -7.59689659e-02f,
  6.95235059e-02f, -2.39131033e-01f, -4.72600311e-02f, 9.80512872e-02f, 1.89458668e-01f, 2.99670786e-01f, -2.57872641e-01f, 1.50482535e-01f, 1.84740528e-01f, 4.74195480e-01f,
  1.70861036e-01f, 2.48826295e-01f, 8.50408822e-02f, 4.49931413e-01f, 9.62856263e-02f, 2.18260288e-01f, 1.29124060e-01f, -1.58565074e-01f, 3.46051753e-01f, 2.67780542e-01f,
  3.03279787e-01f, 3.41635406e-01f, 2.56869227e-01f, 3.18096250e-01f, 3.09409112e-01f, 2.76658144e-02f, 2.22166136e-01f, 8.24408382e-02f, -4.94676176e-03f, 2.83185601e-01f,
  3.31258148e-01f, -1.29190907e-01f, 4.09322172e-01f, 9.89693180e-02f, -9.27686170e-02f, 7.60684088e-02f, -2.80200355e-02f, -2.16070205e-01f, -5.71125686e-01f, -3.19278724e-02f,
  4.36612248e-01f, 5.60672522e-01f, -2.45075986e-01f, 4.55334395e-01f, -1.51885942e-01f, 3.57398421e-01f, -1.93904176e-01f, -4.96016331e-02f, -3.29392105e-01f, -1.87517535e-02f,
  9.05473009e-02f, -9.21964198e-02f, 3.34561288e-01f, 1.33904666e-01f, 1.33189410e-01f, 1.80161938e-01f, -8.78741369e-02f, -8.79041012e-03f, 1.33521646e-01f, 1.89020395e-01f,
  7.88279902e-03f, 9.34830457e-02f, 1.90873623e-01f, -4.01895106e-01f, 2.28001967e-01f, -2.38393560e-01f, -7.50349313e-02f, 6.24929428e-01f, -3.13578784e-01f, 3.65994304e-01f,
  -3.47135425e-01f, -4.52861100e-01f, 4.54419017e-01f, 1.66324303e-01f, 1.80062518e-01f, 5.04994094e-01f, -5.31713739e-02f, 4.53729451e-01f, 1.58006370e-01f, 3.13157141e-02f,
  -4.84877467e-01f, -1.44430771e-01f, 1.58867121e-01f, -2.96659976e-01f, 4.05050397e-01f, 4.32769619e-02f, 1.36596888e-01f, -1.49665009e-02f, 2.24723592e-01f, 3.24759483e-01f,
  1.84535518e-01f, 4.41731997e-02f, 4.60238121e-02f, 1.25925258e-01f, 1.91908330e-01f, -2.75145620e-01f, -3.36032897e-01f, -2.09554002e-01f, -1.81630850e-01f, -5.94803430e-02f,
  -3.28145474e-01f, 3.49552602e-01f, 6.86236769e-02f, 3.07831496e-01f, 4.93153483e-02f, -2.22199515e-01f, 5.79572916e-01f, -2.53659934e-01f, 1.68256223e-01f, 2.60405064e-01f,
  6.10272527e-01f, -8.52445066e-02f, 2.97567874e-01f, 6.91397414e-02f, 4.32881713e-01f, 3.08106005e-01f, 3.54469419e-01f, 1.77384600e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  4.75087874e-02f, 3.93026352e-01f, 2.81079561e-01f, 1.34172603e-01f, 2.44274691e-01f, 1.61571071e-01f, -2.67331973e-02f, 2.34351292e-01f, 9.56870541e-02f, 2.44891107e-01f,
  3.28898221e-01f, 2.92456001e-02f, 2.32988000e-01f, 2.51029521e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  9.06967558e-03f, -3.09735760e-02f, 1.71638310e-01f, -3.28999877e-01f, -3.81073579e-02f, 1.05396479e-01f, 2.96873033e-01f, 2.56050676e-02f, 7.62381554e-02f, -9.69674140e-02f,
  1.14425965e-01f, -3.71629089e-01f, -4.56063598e-01f, -1.60618126e-01f, 2.00513527e-01f, -1.35912240e-01f, 1.43012807e-01f, -3.96433473e-02f, -2.77548105e-01f, 1.11919627e-01f,
  2.45596528e-01f, 1.53829575e-01f, -1.32866934e-01f, -1.66794240e-01f, -1.30549937e-01f, 3.72682720e-01f, -1.15486570e-01f, 8.67079049e-02f, -6.42412379e-02f, 1.48596555e-01f,
  5.84142692e-02f, -1.69783458e-01f, 1.85568154e-01f, -1.62910581e-01f, -1.33570001e-01f, -1.11024469e-01f, 1.69288069e-01f, 2.11637035e-01f, 3.45729232e-01f, 1.22892775e-01f,
  1.21558584e-01f, 2.11394697e-01f, 3.88603248e-02f, -1.96950614e-01f, -4.01850820e-01f, -1.01736121e-01f, 3.45318615e-01f, 9.10563990e-02f, -1.20451383e-01f, -2.74211839e-02f,
  -1.53526083e-01f, 6.17370494e-02f, -1.40383691e-01f, 3.46658789e-02f, -1.19486693e-02f, 9.50418562e-02f, -1.45457461e-01f, 3.33865762e-01f, -5.72376288e-02f, 2.00042501e-01f,
  -1.09168895e-01f, 2.45806742e-02f, -1.21879362e-01f, 4.58274148e-02f, -7.09650889e-02f, -8.11694860e-02f, -1.84562027e-01f, 1.64499074e-01f, 7.06638098e-02f, -1.30054906e-01f,
  -1.74201459e-01f, -2.94782847e-01f, -1.80061534e-02f, 2.30208278e-01f, -1.22033656e-01f, 1.72035769e-01f, 3.53926986e-01f, -4.24352987e-03f, -3.39041919e-01f, -3.54983769e-02f,
  3.36589366e-01f, 2.02276837e-02f, -1.30700707e-01f, -2.83823181e-02f, 8.51331651e-02f, -2.23922849e-01f, -1.14946678e-01f, -1.99135840e-01f, -1.08469628e-01f, -4.47454959e-01f,
  1.67600155e-01f, 1.59017041e-01f, 5.55123091e-02f, -1.81360036e-01f, 1.99933842e-01f, 2.40373835e-01f, -8.70801359e-02f, -1.80917650e-01f, -2.97190130e-01f, -7.74497259e-03f,
  5.03949523e-02f, 1.80323973e-01f, 2.32094929e-01f, 4.98955026e-02f, 9.53613892e-02f, 8.07590261e-02f, -1.62458658e-01f, -1.04491860e-02f, 2.45193854e-01f, -2.77322054e-01f,
  -1.76521003e-01f, 4.23675478e-02f, -1.91915944e-01f, 5.97418547e-02f, -1.62789389e-01f, -2.59457659e-02f, -1.64590642e-01f, 8.84311125e-02f, 3.04736160e-02f, -1.28445685e-01f,
  -1.67466462e-01f, 3.53168100e-01f, -1.08193748e-01f, 3.32489088e-02f, -1.31729171e-01f, -2.48804465e-01f, -7.82172680e-02f, 2.26561844e-01f, -1.76131010e-01f, -1.63072288e-01f,
  -1.82156891e-01f, -8.57638270e-02f, 3.09362393e-02f, -1.28890663e-01f, 1.01387322e-01f, -8.96901265e-03f, -3.45263481e-02f, 3.53588955e-04f, -1.94306169e-02f, 2.44417265e-01f,
  1.99442476e-01f, -1.57783180e-01f, -3.50599503e-03f, -1.37885079e-01f, 2.07324281e-01f, 1.37939364e-01f, 2.56426275e-01f, -2.40383744e-02f, -3.49564850e-02f, 1.94317251e-01f,
  -3.11665088e-01f, -1.40800476e-01f, 5.20029366e-02f, -9.22507569e-02f, -1.32045031e-01f, -1.16981842e-01f, 1.26688987e-01f, 7.56470188e-02f, 1.83552459e-01f, 9.59093962e-03f,
  -1.64772630e-01f, -1.60786077e-01f, -1.27172634e-01f, -1.47417992e-01f, -1.17351264e-01f, 3.70087139e-02f, 1.00327522e-01f, -7.83933103e-02f, 1.03049852e-01f, 1.62870482e-01f,
  2.96635088e-02f, -9.90306661e-02f, 9.73196775e-02f, 5.60302734e-02f, 8.78877491e-02f, 2.84143031e-01f, 1.67746499e-01f, -5.23283780e-02f, -3.38192254e-01f, 8.67730938e-03f,
  -1.32436365e-01f, -1.58529952e-01f, 1.34001061e-01f, -1.32410124e-01f, 7.69919008e-02f, 1.57092795e-01f, -1.20573871e-01f, 3.40912156e-02f, -1.94412187e-01f, 1.11035459e-01f,
  2.40037084e-01f, 1.56971753e-01f, 1.65482402e-01f, -1.50644466e-01f, -9.14301276e-02f, -2.22337872e-01f, -8.57047364e-02f, -1.19507210e-02f, 1.11472663e-02f, -3.68605368e-02f,
  -9.90215540e-02f, 3.55206430e-01f, -1.40317548e-02f, -2.55761594e-01f, -1.55802667e-01f, 8.77369046e-02f, 2.84352362e-01f, 2.21574351e-01f, -1.55472243e-02f, -2.02691928e-01f,
  -1.30178764e-01f, 2.05003068e-01f, 1.61309168e-02f, -1.63035244e-01f, 1.19322285e-01f, -1.79073244e-01f, 4.71314415e-03f, 2.51330078e-01f, -1.79098159e-01f, -8.24705884e-03f,
  -2.08760515e-01f, 1.29986376e-01f, 1.67485535e-01f, -7.06059113e-02f, 3.07929993e-01f, 2.25052118e-01f, 6.26015887e-02f, 3.24463397e-02f, 1.26656875e-01f, -5.93902096e-02f,
  -1.78249732e-01f, 3.77511047e-02f, 1.94757596e-01f, 2.08271712e-01f, 1.16917744e-01f, -6.61780536e-02f, -2.33694062e-01f, -2.68573407e-02f, 2.45422333e-01f, 1.92139238e-01f,
  3.22407931e-02f, -6.60205260e-02f, -2.55386382e-02f, -1.04129039e-01f, 1.69768050e-01f, -2.02367142e-01f, 1.23062678e-01f, 8.56462643e-02f, -3.87212597e-02f, 3.85701239e-01f,
  6.08215109e-02f, -3.70514840e-02f, -5.79879321e-02f, 2.87845671e-01f, 6.75594807e-02f, -2.06023455e-01f, 1.23056456e-01f, 5.88486344e-02f, -9.25199166e-02f, -5.53402752e-02f,
  9.75716040e-02f, 2.08083987e-01f, 6.59847483e-02f, 1.53876185e-01f, 1.26103058e-01f, -3.02728027e-01f, -1.51923150e-01f, -5.70294335e-02f, -1.69050708e-01f, -1.90965593e-01f,
  -2.35212520e-01f, 9.43729430e-02f, -1.94129393e-01f, 1.75499365e-01f, 2.11157545e-01f, 1.48304179e-01f, 2.55888879e-01f, -2.78691575e-02f, 1.59425884e-01f, -8.19665194e-02f,
  -6.83409274e-02f, 5.27378060e-02f, -4.63983454e-02f, 3.85836735e-02f, -2.57855862e-01f, -2.79405773e-01f, -1.57155432e-02f, 8.16103369e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.84362277e-01f, -3.81391421e-02f, 2.33152464e-01f, -2.45630965e-01f, 1.66143179e-01f, 2.98290551e-01f, 2.79848665e-01f, 5.41407987e-02f, -1.61484465e-01f, 2.59285092e-01f,
  -1.50788752e-02f, -6.31729066e-01f, -2.05736488e-01f, 1.67415947e-01f, 5.98017752e-01f, 5.74424922e-01f, 3.40556175e-01f, -3.27757329e-01f, -5.14346540e-01f, 6.48297593e-02f,
  -1.23166710e-01f, -4.44616526e-01f, -2.36487668e-02f, 3.67989361e-01f, -2.19848141e-01f, 5.52470684e-01f, 3.35375547e-01f, 8.98837112e-03f, 3.40368778e-01f, 3.62326384e-01f,
  3.20373446e-01f, -1.82911247e-01f, 2.84998536e-01f, 3.80738050e-01f, 3.15176308e-01f, 1.93004888e-02f, 3.96507094e-03f, 2.52382725e-01f, 1.28595382e-01f, 2.54231133e-02f,
  -3.17011327e-02f, 2.03375772e-01f, -1.50097476e-03f, -3.03290159e-01f, -5.31856835e-01f, 5.35019994e-01f, 7.86287412e-02f, -2.43797585e-01f, -4.22400922e-01f, -2.18301728e-01f,
  -1.05667569e-01f, 7.31266439e-01f, 1.86888948e-01f, 1.06533661e-01f, 2.45843187e-01f, 6.49982274e-01f, -7.33882904e-01f, 2.55905330e-01f, 7.40797997e-01f, 2.70401597e-01f,
  1.52426418e-02f, 9.62391645e-02f, 2.75816228e-02f, 3.36915590e-02f, -1.16260797e-01f, 2.61020362e-01f, 2.27708057e-01f, 3.13833654e-01f, -6.59720525e-02f, 1.92684069e-01f,
  1.32963173e-02f, -3.19558561e-01f, 2.30772793e-01f, -2.64804453e-01f, -4.32046682e-01f, 1.78134367e-01f, 5.65896153e-01f, 3.22047174e-01f, -7.32312202e-01f, -5.16178787e-01f,
  -3.18027914e-01f, 1.21038683e-01f, 4.59654927e-01f, 7.68073499e-02f, 7.77600229e-01f, 3.47705245e-01f, 3.80939126e-01f, 3.35033953e-01f, 6.88174009e-01f, 3.26965928e-01f,
  2.91037887e-01f, -2.95738161e-01f, 1.06442161e-01f, -2.62206912e-01f, -4.01229352e-01f, 3.21293175e-01f, -2.76275009e-01f, 1.85954422e-01f, 4.59423929e-01f, 4.26016122e-01f,
  -1.84135541e-01f, 3.05092514e-01f, -4.47067171e-02f, -2.04293564e-01f, -3.92220646e-01f, -5.81654310e-01f, -3.00346583e-01f, -2.29612008e-01f, 2.02696756e-01f, 2.03797728e-01f,
  -1.90114200e-01f, -1.57282874e-01f, 5.64299077e-02f, 7.82144517e-02f, 4.65758026e-01f, -1.91488229e-02f, 5.28068691e-02f, 5.50766826e-01f, -3.70984077e-01f, -2.70558950e-02f,
  8.89048517e-01f, -3.10954340e-02f, -7.68147781e-02f, 4.68719095e-01f, 3.23053241e-01f, 1.27531961e-01f, 9.01362970e-02f, 1.78671688e-01f, -3.00467163e-01f, -3.48896056e-01f,
  -8.02569866e-01f, -6.31161809e-01f, -2.14249238e-01f, -2.51971662e-01f, -1.98291540e-01f, -4.61083859e-01f, 9.34496988e-03f, -1.93874136e-01f, -4.01894420e-01f, -2.17722937e-01f,
  3.74271065e-01f, -3.41211975e-01f, -3.32015425e-01f, -6.63999394e-02f, 2.66261309e-01f, 1.39455363e-01f, 1.75792962e-01f, -1.15350381e-01f, 1.16143383e-01f, 1.52450457e-01f,
  4.49288607e-01f, -6.28089130e-01f, -4.03004915e-01f, -2.35941857e-01f, -3.54472518e-01f, -4.22346145e-01f, 2.46681586e-01f, -2.71196783e-01f, -7.67999291e-02f, 2.68937409e-01f,
  4.61958647e-01f, 6.14505336e-02f, 4.74552251e-02f, -2.20776834e-02f, 2.38610491e-01f, 1.62054896e-01f, 5.48799224e-02f, -1.52569264e-01f, 5.62239349e-01f, -4.02971119e-01f,
  -1.65286362e-01f, 3.67805697e-02f, -6.00094162e-02f, -6.14659786e-01f, -1.39271989e-01f, -5.36328793e-01f, -1.36760399e-01f, 2.46346310e-01f, 5.19174159e-01f, -7.58475140e-02f,
  6.91216111e-01f, 1.09994166e-01f, -1.37312531e-01f, 1.38144583e-01f, -9.63955879e-01f, 8.75424325e-01f, 4.44111705e-01f, 3.38488013e-01f, 1.33433476e-01f, -3.64220858e-01f,
  -2.43547246e-01f, 3.95108968e-01f, -1.37891144e-01f, -3.58696550e-01f, -1.50586450e-02f, 3.60295177e-02f, -2.10231155e-01f, -2.07364019e-02f, -2.22935438e-01f, -2.27401778e-01f,
  4.74176593e-02f, 2.78919023e-02f, -2.40023464e-01f, 7.05170035e-02f, 3.91933560e-01f, -4.58489582e-02f, 1.39551461e-01f, 3.11947405e-01f, 5.83524168e-01f, -7.16958717e-02f,
  -3.14455092e-01f, -7.54683986e-02f, -8.96926671e-02f, -2.41539076e-01f, -1.64874971e-01f, -4.59731311e-01f, -1.66930139e-01f, -3.71491238e-02f, -1.32772759e-01f, -1.56940718e-03f,
  3.58059853e-01f, 2.07581207e-01f, 4.74011004e-01f, 1.16816372e-01f, -3.55308950e-02f, -1.61166683e-01f, -8.80639702e-02f, 4.26833510e-01f, 2.32589602e-01f, -5.24619780e-02f,
  -5.25163651e-01f, 1.98145974e-02f, 6.69183016e-01f, 3.56332242e-01f, -1.21813789e-02f, 2.67144501e-01f, 2.70364463e-01f, 3.59843671e-01f, 4.99772429e-02f, 5.20170987e-01f,
  3.62277538e-01f, -2.69244999e-01f, -3.15790951e-01f, 6.28692508e-02f, -9.79394168e-02f, -5.55376172e-01f, 6.39194608e-01f, -2.95683056e-01f, 9.48837101e-02f, -3.46810162e-01f,
  -4.17555809e-01f, -6.76819146e-01f, 9.40002054e-02f, 1.94332868e-01f, 3.38297635e-01f, 2.73284495e-01f, -2.21202940e-01f, 9.82529391e-03f, 3.79613847e-01f, 3.46972287e-01f,
  -3.23512733e-01f, 1.23094290e-01f, -1.71281159e-01f, 1.07974857e-01f, -1.20182760e-01f, 1.29746407e-01f, 1.92305371e-01f, -7.06021786e-02f, 2.29893804e-01f, 3.69464844e-01f,
  -4.70039994e-02f, 2.55329460e-01f, 3.81280929e-01f, -9.36264470e-02f, 3.81534398e-01f, 8.27077925e-02f, -1.45989537e-01f, 3.13327521e-01f, -2.63518363e-01f, -3.42745870e-01f,
  -7.80628901e-03f, 1.19859815e-01f, -2.06330448e-01f, 3.68705571e-01f, 2.15674132e-01f, 4.75047290e-01f, 4.10882860e-01f, 1.58858359e-01f, 6.62345365e-02f, -5.16916737e-02f,
  -2.69558012e-01f, 7.32147321e-02f, 4.95951176e-02f, -4.59126681e-02f, 3.16969939e-02f, 4.53763783e-01f, 4.53787237e-01f, -1.71459600e-01f, 2.11994633e-01f, 2.27197409e-01f,
  5.63722193e-01f, -8.53213906e-01f, 3.31416428e-01f, 2.04056595e-02f, -1.60387099e-01f, -2.62430340e-01f, 1.57827869e-01f, -7.62979507e-01f, 2.94084735e-02f, 2.60487646e-01f,
  -9.02940035e-02f, -4.17142063e-01f, 1.56753749e-01f, 4.35127169e-01f, -6.76599324e-01f, 3.72281700e-01f, 1.74902290e-01f, -3.40580754e-02f, 3.12904865e-01f, 4.93658006e-01f,
  3.35621126e-02f, -1.45575553e-01f, -5.31525493e-01f, 1.01006769e-01f, 2.22777992e-01f, -2.52609879e-01f, 8.95522386e-02f, 2.86482096e-01f, 1.47890419e-01f, 4.56075370e-01f,
  8.64285752e-02f, 6.46314621e-01f, 3.73478800e-01f, -4.47824985e-01f, -4.40520436e-01f, -2.88154334e-01f, -3.38539928e-01f, -1.26658097e-01f, 5.19931853e-01f, 8.42707828e-02f,
  -5.40419202e-03f, 4.58337456e-01f, 4.11276430e-01f, 1.15843326e-01f, -5.10226727e-01f, -7.81719744e-01f, -1.20063871e-01f, 3.23252112e-01f, 3.23899388e-02f, -2.51939774e-01f,
  8.22311267e-02f, 5.07405996e-01f, 1.49821848e-01f, 3.70730162e-01f, 6.53741462e-03f, -1.08389169e-01f, 1.80923223e-01f, -6.53890148e-02f, 5.74265085e-02f, 1.41562015e-01f,
  8.95465836e-02f, 5.70449531e-01f, 4.68903571e-01f, -1.41540021e-01f, -3.46014231e-01f, 5.78383327e-01f, 1.95088342e-01f, 1.59924954e-01f, -7.07942918e-02f, -1.62756324e-01f,
  -2.70882279e-01f, 5.22562861e-01f, -5.18639565e-01f, -3.38651836e-01f, 7.20519483e-01f, 7.99643621e-02f, -1.98026851e-01f, -5.06305933e-01f, 3.62934917e-02f, -7.70006999e-02f,
  2.18509823e-01f, 4.88416761e-01f, 4.04236168e-02f, 1.46345228e-01f, 1.23352922e-01f, -1.91893995e-01f, -1.07229799e-01f, -2.07318380e-01f, 2.20615923e-01f, 2.89768398e-01f,
  2.64408201e-01f, 2.66715050e-01f, -3.53808999e-01f, 3.05754691e-01f, 4.36135173e-01f, 9.13213287e-03f, -3.83144200e-01f, 1.32414073e-01f, 2.49769405e-01f, 8.86680465e-03f,
  -2.66664803e-01f, -1.82955369e-01f, -8.03676322e-02f, 4.32183355e-01f, -4.35079545e-01f, 3.76599163e-01f, -1.34056970e-01f, 4.07107979e-01f, 5.56698814e-03f, -5.47251940e-01f,
  4.29332733e-01f, 5.14811754e-01f, 2.40222201e-01f, 3.41782182e-01f, 1.97646186e-01f, 1.75397411e-01f, 2.30751365e-01f, 3.63629878e-01f, -4.69201840e-02f, -2.43346959e-01f,
  3.87958974e-01f, 1.19553819e-01f, 3.45788777e-01f, -1.32871777e-01f, 2.42699504e-01f, 3.02097470e-01f, -3.76431160e-02f, 7.54062757e-02f, -2.38511607e-01f, 3.11324596e-01f,
  -3.66068840e-01f, -3.03459108e-01f, -3.83429796e-01f, -5.19696099e-04f, -6.38610218e-04f, 3.09899181e-01f, 4.24149752e-01f, -8.85391980e-02f, 4.06736135e-01f, 6.07108176e-01f,
  -2.16082171e-01f, -4.85339463e-01f, 5.05352795e-01f, -2.38066554e-01f, 1.73948750e-01f, -9.38148126e-02f, -2.84179479e-01f, 1.58978865e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  3.02365303e-01f, 2.91624278e-01f, 2.34218523e-01f, -1.26612619e-01f, 4.36596125e-02f, 3.01147074e-01f, -4.71299253e-02f, 8.79196748e-02f, -3.54441479e-02f, 1.13138631e-01f,
  9.48801339e-02f, 2.71205127e-01f, 3.29492949e-02f, 3.28866690e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.12134963e-01f, -2.02343287e-03f, -1.67906776e-01f, -2.41090998e-01f, -2.75583025e-02f, -1.05471447e-01f, 2.36727491e-01f, 1.33256406e-01f, -1.79459587e-01f, 3.63153547e-01f,
  3.96783138e-03f, 3.58017057e-01f, -6.43362850e-02f, 2.20162824e-01f, 2.14780256e-01f, 3.03530276e-01f, -8.45412910e-02f, 1.16231032e-01f, 3.58382821e-01f, 2.80296020e-02f,
  -3.34881186e-01f, 4.70320880e-01f, -1.17256537e-01f, -4.17780966e-01f, 3.72279018e-01f, -5.25134742e-01f, 3.87832612e-01f, -3.91166478e-01f, -4.05482382e-01f, -1.03212513e-01f,
  1.35421038e-01f, -4.75299716e-01f, 1.72672048e-01f, -1.34145319e-01f, -1.76228374e-01f, 3.09196353e-01f, -1.87149376e-01f, 2.91061878e-01f, 1.47801340e-01f, -1.92568958e-01f,
  1.11296944e-01f, 3.15786183e-01f, 3.03237706e-01f, 3.68181199e-01f, 4.86027487e-02f, -3.26111794e-01f, 4.91808534e-01f, -1.27502829e-01f, -8.59985054e-02f, -4.25252348e-01f,
  -2.72561908e-01f, -1.01443253e-01f, -5.53947926e-01f, 7.05898106e-02f, -8.42752904e-02f, -6.78138286e-02f, -5.22171855e-02f, -6.27205074e-01f, 2.15190336e-01f, 3.33677262e-01f,
  2.83504158e-01f, -2.48213023e-01f, 2.56866515e-01f, -5.69706202e-01f, 1.49748638e-01f, 2.10837647e-01f, 1.04979917e-01f, 3.39694768e-02f, 1.92495883e-01f, 2.50483185e-01f,
  8.41930285e-02f, 2.82503694e-01f, -1.16324596e-01f, 5.22323549e-01f, 3.15162629e-01f, -4.94052857e-01f, 4.83817279e-01f, 3.22216541e-01f, -2.46798679e-01f, -2.09899440e-01f,
  2.91202873e-01f, 3.92510325e-01f, -2.22163245e-01f, -5.96359260e-02f, 1.71960264e-01f, 1.85497284e-01f, -5.67806661e-01f, 3.58080208e-01f, -2.07451701e-01f, -2.84413844e-01f,
  2.36814007e-01f, 3.46523106e-01f, -2.33504683e-01f, -4.20651615e-01f, -4.93249059e-01f, -4.59439367e-01f, 9.25675631e-02f, 5.33384364e-03f, 3.18415105e-01f, -3.25181693e-01f,
  2.47503415e-01f, -1.52838737e-01f, -1.46859139e-01f, -3.71240765e-01f, -2.33712539e-01f, 3.09162825e-01f, -1.64924383e-01f, 1.10376626e-01f, 2.44740397e-01f, 1.91331282e-01f,
  6.92275688e-02f, 6.68489709e-02f, 4.86106984e-02f, -3.85451540e-02f, 1.69490114e-01f, 3.37729696e-03f, -1.89725667e-01f, -3.53928387e-01f, -1.54717654e-01f, -2.20075741e-01f,
  1.46617815e-01f, 5.03253818e-01f, 2.99681455e-01f, -5.91605067e-01f, -4.75921512e-01f, 3.80896240e-01f, -8.59705806e-02f, -3.54653060e-01f, 1.99504986e-01f, -2.49425218e-01f,
  3.55757959e-02f, -2.47266278e-01f, 1.92025512e-01f, 2.33176187e-01f, 8.01425651e-02f, -1.84117794e-01f, 1.87864841e-03f, 3.11901391e-01f, 3.48250300e-01f, -5.39750934e-01f,
  1.52606182e-02f, -4.85001713e-01f, 7.75227249e-02f, 4.34927851e-01f, 4.91944075e-01f, -2.96210796e-01f, 1.28906086e-01f, 1.85422137e-01f, -5.64484060e-01f, -3.30638617e-01f,
  -1.08694047e-01f, -6.42614007e-01f, -3.26337874e-01f, -4.48780566e-01f, -2.05768183e-01f, 5.57703956e-04f, -1.14026435e-01f, 4.93553519e-01f, 3.79737735e-01f, 3.41359526e-01f,
  -1.91680938e-01f, 1.12121075e-01f, 2.88635492e-02f, -8.14680606e-02f, 1.04820132e-01f, 5.93295842e-02f, -1.02433182e-01f, 1.07132211e-01f, -5.49834361e-03f, -3.93557280e-01f,
  -1.39346659e-01f, 2.12111577e-01f, -3.53945434e-01f, 5.87498724e-01f, -3.65110397e-01f, -2.46066481e-01f, -4.31820810e-01f, -2.25827262e-01f, -3.69229764e-01f, 1.74185589e-01f,
  2.37101428e-02f, -1.55137163e-02f, -7.24047124e-02f, -1.74301773e-01f, -2.93567657e-01f, -5.90836942e-01f, 1.73816875e-01f, -3.12012315e-01f, 1.67813674e-01f, 2.08141953e-01f,
  2.35204786e-01f, 9.72610563e-02f, 1.66893438e-01f, 2.63652056e-01f, 3.33353311e-01f, -1.33116841e-02f, 6.69059828e-02f, -4.43107277e-01f, -5.01915157e-01f, 3.58063191e-01f,
  -2.44633049e-01f, 1.15090162e-02f, 9.22520906e-02f, -9.40452963e-02f, -1.97759047e-01f, -3.79411697e-01f, -1.04234209e-02f, -1.68777764e-01f, 1.04627572e-01f, 8.10920298e-02f,
  -6.26726091e-01f, 2.03994498e-01f, 2.76252478e-01f, 2.59760823e-02f, -4.36617047e-01f, 3.49604368e-01f, 1.35717869e-01f, -1.47757724e-01f, -5.22402644e-01f, -4.62398320e-01f,
  7.79645294e-02f, -5.71267188e-01f, -1.46784395e-01f, 2.58190960e-01f, -7.99107105e-02f, -1.28353819e-01f, -6.52519837e-02f, 3.33167464e-02f, -1.55530795e-01f, -2.95802772e-01f,
  -1.68892682e-01f, -1.70549095e-01f, 1.88014835e-01f, -4.18159306e-01f, -3.71869475e-01f, -3.97672206e-01f, -1.91497013e-01f, 9.10346359e-02f, -2.18956947e-01f, 7.73402303e-02f,
  -2.69680828e-01f, -3.46950740e-01f, -2.83886522e-01f, -5.40420294e-01f, 2.98067361e-01f, 5.15678525e-01f, -2.93563724e-01f, -4.14584130e-01f, -4.86846238e-01f, -1.85332298e-01f,
  2.06400916e-01f, 1.24841973e-01f, -5.26573062e-02f, -4.89266813e-01f, 8.10140371e-02f, -2.40759224e-01f, 2.92364210e-02f, -7.32273385e-02f, -1.52311280e-01f, 3.25184837e-02f,
  -2.93437958e-01f, 1.34750009e-01f, -1.10083342e-01f, -3.05677205e-01f, 4.46271524e-02f, -3.29133987e-01f, -4.12813902e-01f, 3.97608131e-01f, 3.17906380e-01f, 3.31130385e-01f,
  -2.02993214e-01f, -1.78106979e-01f, -3.02133471e-01f, 1.97769046e-01f, -2.76427865e-01f, -5.69350421e-01f, 1.72849551e-01f, -2.53404081e-01f, 6.49421871e-01f, 2.48156592e-01f,
  8.57386440e-02f, -3.17224234e-01f, -1.68375298e-01f, 1.58111960e-01f, 2.50883520e-01f, -3.55042398e-01f, -3.63522917e-01f, 1.71780303e-01f, -2.57162541e-01f, -3.95193785e-01f,
  -1.16676874e-01f, 9.50521156e-02f, -2.18322784e-01f, -7.52327293e-02f, 3.13119918e-01f, -1.75268322e-01f, 1.63721547e-01f, 3.36581290e-01f, 2.31198028e-01f, -2.98442334e-01f,
  -8.04457963e-02f, -2.18904495e-01f, -5.12420177e-01f, -1.18098028e-01f, 1.04500875e-01f, 3.12186390e-01f, 3.82001609e-01f, 3.28796774e-01f, -8.15653987e-03f, -5.58857441e-01f,
  -3.76536734e-02f, 3.31923008e-01f, -1.92242339e-01f, -1.75838172e-01f, -4.06021297e-01f, -2.23776355e-01f, -7.49533176e-01f, -1.61932230e-01f, 1.32599026e-01f, 2.13649109e-01f,
  -1.93500128e-02f, -4.55450006e-02f, -3.25668693e-01f, 1.63346991e-01f, -1.46299332e-01f, -2.37198830e-01f, 1.62020952e-01f, 6.85088485e-02f, -2.12564662e-01f, -4.09157276e-01f,
  -2.84081101e-01f, 2.17653885e-01f, -4.11063641e-01f, 2.46328920e-01f, 1.78679243e-01f, 2.34172478e-01f, 5.16187549e-01f, -1.36411741e-01f, 1.11390650e-01f, -6.77514315e-01f,
  -5.26839375e-01f, -2.90486395e-01f, 2.40458772e-01f, -5.21072745e-01f, 3.22314143e-01f, 4.25338209e-01f, 9.13263410e-02f, 4.07355785e-01f, 2.20830426e-01f, -2.88919173e-02f,
  6.27475744e-03f, -4.33675677e-01f, -1.23098314e-01f, -4.26197611e-02f, -4.47607599e-02f, -5.19442314e-04f, -1.59036800e-01f, -2.15360634e-02f, 2.55251527e-01f, 8.79477486e-02f,
  -1.49229854e-01f, -3.91435266e-01f, 5.10237888e-02f, 3.41844499e-01f, 3.39259028e-01f, -3.51352721e-01f, 4.33261007e-01f, 2.09261447e-01f, -3.38297814e-01f, 4.26391661e-01f,
  -3.49608183e-01f, -1.00727323e-02f, 2.25842267e-01f, -4.42838967e-01f, 3.51125091e-01f, -3.83194774e-01f, -3.18320215e-01f, 5.07967472e-01f, -3.19324642e-01f, -2.63695806e-01f,
  1.16952695e-01f, 3.35490108e-01f, -1.77681699e-01f, 3.91949862e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.32417664e-01f, -1.61149234e-01f, -6.69857338e-02f, 1.08127996e-01f, -1.08648367e-01f, -4.63284319e-03f, -9.59186777e-02f, 9.39702913e-02f, 4.93451953e-02f, -9.54904780e-02f,
  7.27451593e-02f, 1.29417360e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    