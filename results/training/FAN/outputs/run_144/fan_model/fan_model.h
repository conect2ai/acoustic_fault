/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.73969746e-01f, 1.77442223e-01f, -1.95462406e-01f, -2.80527640e-02f, 7.93052316e-02f, -1.22357413e-01f, -1.32383719e-01f, 1.76527843e-01f, -8.50040615e-02f, 2.71667004e-01f,
  2.53493726e-01f, -2.14974955e-01f, 1.37171835e-01f, -7.39340410e-02f, -3.43023419e-01f, 8.80387425e-02f, -2.23681793e-01f, -1.93167925e-01f, 1.67017564e-01f, 2.04394870e-02f,
  -8.40354785e-02f, 2.62431383e-01f, 3.33201662e-02f, 1.67037353e-01f, 2.63081752e-02f, -1.06729788e-03f, 1.71326473e-01f, 6.15950897e-02f, -6.02705684e-03f, -6.20093197e-02f,
  -6.74265251e-02f, 1.78415954e-01f, -1.11750821e-02f, -6.38204813e-02f, 1.30287185e-01f, 3.05210818e-02f, -1.24265566e-01f, 2.80412030e-03f, -2.31522117e-02f, 1.47114381e-01f,
  -9.13821608e-02f, -1.48967393e-02f, 3.81152071e-02f, -6.35046745e-03f, -7.04313591e-02f, 3.35956179e-02f, 1.29026710e-03f, -1.88613776e-02f, 2.08644923e-02f, -1.29516795e-01f,
  -8.35532229e-03f, 4.39001173e-02f, -9.37635526e-02f, -1.39849144e-03f, -1.65951885e-02f, -1.13623738e-01f, -1.11312024e-01f, -8.90492350e-02f, 2.51863208e-02f, 4.04936858e-02f,
  8.27059820e-02f, -2.17408035e-02f, 3.75838615e-02f, -1.32147707e-02f, 2.38561910e-02f, 8.18648040e-02f, -5.12165613e-02f, 7.32795373e-02f, -4.91441153e-02f, 7.58230016e-02f,
  2.19240561e-02f, 3.13965790e-02f, 2.99811848e-02f, -8.07072297e-02f, 9.43697318e-02f, -3.80918905e-02f, -1.00182645e-01f, -4.63944897e-02f, -2.85959784e-02f, -6.74450770e-02f,
  3.95029932e-02f, -1.63536623e-01f, 1.12565719e-01f, 1.05734803e-02f, 3.98592800e-02f, 8.59654173e-02f, -1.03037469e-02f, 5.58147999e-03f, -2.33992729e-02f, 5.99757060e-02f,
  3.89572196e-02f, 1.65150568e-01f, 4.50414792e-02f, 4.51350883e-02f, 5.89320436e-02f, 1.58684388e-01f, -2.51812395e-02f, -3.60112637e-02f, 6.01198971e-02f, 9.29409862e-02f,
  -1.10132106e-01f, 1.58341846e-03f, 1.17940426e-01f, -8.74001607e-02f, 2.36105220e-03f, 7.31803477e-02f, -1.24772657e-02f, 1.61616057e-02f, 5.80196120e-02f, -7.72516727e-02f,
  2.48746090e-02f, 1.15132727e-01f, 4.22042683e-02f, 1.08144537e-01f, -1.76421497e-02f, 4.66592722e-02f, -6.59931824e-02f, 1.00269690e-02f, 3.29008996e-02f, 1.34224324e-02f,
  1.37147233e-01f, -1.86203439e-02f, 4.84062098e-02f, 1.46360338e-01f, 1.28429636e-01f, -1.12998411e-01f, -3.06317568e-01f, 2.37333551e-01f, 5.10344245e-02f, -5.33563085e-02f,
  -1.04057919e-02f, -4.21984717e-02f, -3.29333097e-01f, 2.00484350e-01f, 9.45442263e-03f, -2.06665531e-01f, 8.40580240e-02f, -6.67975396e-02f, 3.53793278e-02f, -1.25858597e-02f,
  1.01089090e-01f, 1.26321778e-01f, 1.38044849e-01f, 1.40938386e-01f, 1.71952054e-01f, 9.60052088e-02f, 1.39891803e-01f, -1.49478048e-01f, 1.74795687e-01f, -4.07659076e-02f,
  3.40449326e-02f, 8.77077729e-02f, 1.33059487e-01f, -8.15980323e-03f, 6.66075423e-02f, 5.84857054e-02f, 1.29053406e-02f, -1.16576426e-01f, 2.22077151e-03f, 2.75744759e-02f,
  9.13250446e-03f, 4.92787883e-02f, -5.75226620e-02f, 4.36211079e-02f, 1.33137435e-01f, 4.94270734e-02f, 1.31046355e-01f, 8.30183253e-02f, 2.73009893e-02f, 1.02840744e-01f,
  -5.03610820e-02f, -8.28977600e-02f, 4.73716594e-02f, -1.09998994e-01f, -2.97991652e-02f, 5.47013246e-04f, -1.17620654e-01f, -4.72791679e-02f, -3.96355912e-02f, 3.48055661e-02f,
  3.47188897e-02f, -8.55609775e-02f, -5.99164143e-02f, -4.96680625e-02f, -6.87449351e-02f, 5.45676351e-02f, -4.31689285e-02f, 1.19521268e-01f, -3.33916619e-02f, 1.16713392e-02f,
  -1.70305334e-02f, 5.43829612e-02f, 5.14742620e-02f, -3.44152302e-02f, 4.47652228e-02f, -4.87961024e-02f, -1.29340604e-01f, -2.44193859e-02f, 3.57365236e-02f, 6.06501363e-02f,
  -6.62555546e-02f, -6.68323040e-02f, -6.82139769e-02f, 9.55628231e-02f, -3.45839895e-02f, -3.42248566e-02f, 1.88762873e-01f, 3.33383679e-02f, 3.73120829e-02f, 1.32606179e-02f,
  -9.28232223e-02f, -1.65066391e-01f, -7.98009261e-02f, -3.19226794e-02f, -1.11942910e-01f, 4.17789556e-02f, 2.22324375e-02f, 9.45775658e-02f, -6.26939610e-02f, -2.29236186e-02f,
  9.30179060e-02f, 1.27805965e-02f, -9.47657228e-02f, -5.77042811e-03f, 6.96136802e-02f, 7.40264207e-02f, -7.44460225e-02f, -2.61955578e-02f, -1.65026318e-02f, 2.37211715e-02f,
  9.84149706e-03f, -1.04834490e-01f, 1.56529602e-02f, -8.03937316e-02f, 8.52602348e-02f, -1.00964718e-01f, -7.41591081e-02f, -2.98334956e-02f, -4.05809060e-02f, 3.69067374e-03f,
  2.12117434e-01f, -1.52541950e-01f, 1.41679123e-01f, 2.81166345e-01f, -7.81132728e-02f, 2.29895055e-01f, 1.85152292e-01f, 5.30144386e-03f, 1.35411143e-01f, -4.94115613e-02f,
  -5.01257777e-02f, -1.34071824e-03f, 5.01746796e-02f, -6.29147456e-04f, 2.88229674e-01f, -5.09014241e-02f, 2.15955034e-01f, -2.56677680e-02f, 1.21775262e-01f, 1.35153815e-01f,
  8.28087106e-02f, 1.35526061e-01f, -5.30097866e-03f, -3.68565284e-02f, 5.45480885e-02f, 2.52655633e-02f, 7.08929524e-02f, 2.24034768e-02f, -3.51883918e-02f, -1.12034738e-01f,
  -1.01745389e-02f, 2.17702147e-02f, 5.20679206e-02f, 2.81339902e-02f, -9.64264944e-03f, -3.22242491e-02f, 1.01486109e-01f, -7.68678486e-02f, 3.81975435e-02f, -5.81075363e-02f,
  -4.29332145e-02f, -6.11951109e-03f, -3.35824639e-02f, 1.07395604e-01f, -2.91488711e-02f, -2.45563798e-02f, -1.32887959e-02f, -5.39888255e-02f, 4.01712302e-03f, -1.81958191e-02f,
  2.24709678e-02f, -8.37696642e-02f, 2.46680919e-02f, -6.52152523e-02f, 5.63117526e-02f, 2.43003163e-02f, 3.85307074e-02f, -8.70291516e-03f, 1.28422107e-03f, 6.42535537e-02f,
  -8.36783126e-02f, 3.81646268e-02f, 5.86728528e-02f, -9.66918655e-04f, 4.35481705e-02f, -5.86594120e-02f, 1.22165583e-01f, -4.57799546e-02f, 1.64833307e-01f, 2.59402189e-02f,
  -4.37099040e-02f, 1.42442361e-02f, -4.11013849e-02f, 2.62571070e-02f, 6.72822222e-02f, -2.95555163e-02f, -2.91977208e-02f, 8.99076685e-02f, 5.59501909e-02f, 2.47200094e-02f,
  -2.54574977e-02f, -2.53511891e-02f, 2.46048719e-03f, -4.62527312e-02f, 3.37123461e-02f, 2.66799051e-02f, 1.81274246e-02f, -6.39662938e-03f, -1.14743803e-02f, 7.54853487e-02f,
  2.59910226e-01f, 2.44911388e-01f, 4.06306013e-02f, 6.86897561e-02f, 8.05617645e-02f, 4.89561036e-02f, 1.54294252e-01f, -2.20493507e-02f, 6.44868612e-02f, 1.84735116e-02f,
  -6.96781417e-03f, -2.32192874e-02f, 4.71933559e-03f, 6.26574978e-02f, 3.48823331e-02f, 8.20852295e-02f, 5.18619567e-02f, 4.35370468e-02f, -4.68630120e-02f, 8.09190571e-02f,
  2.42629610e-02f, -6.65842891e-02f, 5.11299483e-02f, 4.27450351e-02f, -9.79279354e-02f, -1.49170104e-02f, -2.29777433e-02f, -4.17160541e-02f, 2.34635659e-02f, -5.82986325e-02f,
  -5.30293211e-02f, -2.38194272e-01f, 3.13308477e-01f, 1.48982346e-01f, 2.43756458e-01f, 1.86700433e-01f, 1.90423816e-01f, 1.32513821e-01f, 1.58070445e-01f, -2.81573147e-01f,
  -6.66806176e-02f, -6.38127625e-02f, -1.51348859e-01f, 1.78139303e-02f, 5.23908846e-02f, -4.03904133e-02f, 1.78282354e-02f, 8.08985997e-03f, 8.10053572e-02f, -9.92683843e-02f,
  1.60885751e-01f, -1.28490468e-02f, 1.14487581e-01f, 1.80540919e-01f, 3.39581557e-02f, 3.58694233e-02f, -1.53621003e-01f, 1.96843594e-01f, 1.77333970e-02f, 1.37134597e-01f,
  -1.30688176e-01f, -2.79242676e-02f, -1.80856809e-01f, -4.11150008e-02f, -2.94366684e-02f, -7.16737136e-02f, 1.25216857e-01f, 3.17978263e-02f, -4.67179120e-02f, -5.80257550e-02f,
  -2.12656148e-02f, 4.36241329e-02f, 5.39497733e-02f, -1.03280309e-03f, 7.20917881e-02f, 2.24198983e-03f, 1.22664407e-01f, 4.15114276e-02f, 7.42364079e-02f, 1.30539447e-01f,
  8.28973278e-02f, 1.03431024e-01f, -1.38739934e-02f, 1.15932979e-01f, 1.57715991e-01f, 1.62567317e-01f, 1.57405213e-01f, 7.79748857e-02f, -1.97169892e-02f, 9.43429321e-02f,
  9.46698189e-02f, 9.63973850e-02f, 4.86867651e-02f, 2.72521190e-02f, -3.76277342e-02f, -7.05120787e-02f, 4.33120243e-02f, -6.06309697e-02f, -4.43693586e-02f, -7.32076094e-02f,
  -5.08436039e-02f, -2.62346324e-02f, -2.58518364e-02f, 1.79536361e-02f, -3.32169831e-02f, 4.36816961e-02f, -2.54270583e-02f, -6.11979738e-02f, -9.17174667e-02f, -1.58413909e-02f,
  -8.94806907e-02f, 3.29616889e-02f, -2.12378815e-01f, 1.00105211e-01f, 6.37693405e-02f, -5.62727228e-02f, 3.56581137e-02f, -9.09178182e-02f, 6.28302223e-04f, -4.46975604e-02f,
  -2.66078860e-01f, -1.29513696e-01f, -6.92508966e-02f, -1.31767124e-01f, -8.25035945e-02f, -1.69953316e-01f, 1.67595491e-01f, -4.17889915e-02f, -1.20874420e-01f, -3.54305580e-02f,
  1.00795239e-01f, -5.95973656e-02f, -9.54434052e-02f, 9.24407840e-02f, -2.18755174e-02f, 1.02785669e-01f, -2.84046624e-02f, -2.75364574e-02f, -7.38195777e-02f, 1.15771450e-01f,
  -2.57504284e-02f, 2.80666351e-02f, 4.68655415e-02f, 5.41911200e-02f, 5.31434789e-02f, 9.01840404e-02f, -8.82466063e-02f, 1.41184777e-01f, 4.33321781e-02f, -6.70813546e-02f,
  -2.73635760e-02f, 1.73896581e-01f, -2.03350484e-01f, 1.86347812e-01f, 8.91683996e-03f, -1.19669802e-01f, -8.95072706e-03f, 1.59623817e-01f, 2.68444955e-01f, 3.33187252e-01f,
  3.38369831e-02f, 7.90927410e-02f, -1.38953149e-01f, 4.18305457e-01f, -2.24952608e-01f, -5.11462204e-02f, 2.31741786e-01f, 1.90436006e-01f, -6.00060634e-02f, -3.53157595e-02f,
  1.20014427e-02f, 2.44317174e-01f, -3.30968313e-02f, 1.61466166e-01f, 1.64877754e-02f, 6.43414771e-03f, 6.56784251e-02f, -1.96061715e-01f, 2.20225900e-01f, -1.81092434e-02f,
  -4.33892906e-02f, 1.48423299e-01f, -4.15340951e-03f, 7.58826593e-03f, -8.35974067e-02f, -4.83695371e-03f, -1.60575230e-02f, -1.01512581e-01f, -6.69091493e-02f, -5.53898960e-02f,
  1.14013953e-02f, 1.46064647e-02f, 7.10406378e-02f, 1.22159505e-02f, -3.49128395e-02f, -4.27795686e-02f, -4.11738493e-02f, -3.09763942e-02f, 1.03056878e-01f, 8.67207255e-03f,
  2.22353712e-02f, -8.02977085e-02f, -3.90543453e-02f, 5.58898821e-02f, -2.80863587e-02f, 8.49026889e-02f, 4.12521213e-02f, -1.70006342e-02f, 4.95600365e-02f, 1.15471058e-01f,
  1.03633299e-01f, 1.47536641e-03f, -6.71907663e-02f, -1.39069604e-02f, -7.66617209e-02f, -6.85390458e-02f, -2.03642398e-02f, -1.34985209e-01f, -1.24695785e-01f, -7.73229748e-02f,
  -2.80909967e-02f, -7.68395811e-02f, 5.41899987e-02f, 5.14949374e-02f, -3.33730094e-02f, 9.23393741e-02f, -1.65099084e-01f, 1.59386918e-02f, -4.39522229e-02f, -5.95753677e-02f,
  -3.76005881e-02f, 6.88688606e-02f, -2.02853139e-02f, -6.12746775e-02f, -9.57504846e-03f, -1.15980394e-01f, 9.45346951e-02f, -3.17541286e-02f, 8.33841190e-02f, -5.16864806e-02f,
  -5.74819520e-02f, 3.00525152e-03f, -2.24820757e-03f, 6.84703095e-03f, 7.10773841e-03f, -3.57577913e-02f, 5.51499315e-02f, 3.59962881e-03f, -4.31987979e-02f, 1.03996489e-02f,
  3.09648793e-02f, -1.01160601e-01f, -3.80504504e-02f, 5.45172542e-02f, -1.69164911e-02f, -1.22761475e-02f, 3.25042047e-02f, 1.26972115e-02f, -9.54424404e-03f, 1.06583111e-01f,
  6.83858898e-03f, -5.04935980e-02f, -1.30063370e-01f, 3.02527398e-02f, 3.01233307e-02f, 2.10412145e-02f, -1.92944314e-02f, 1.32306501e-01f, -1.31133199e-02f, 3.86428498e-02f,
  2.95953929e-01f, -9.72995982e-02f, 2.59562850e-01f, 2.88676381e-01f, 2.04823822e-01f, 3.36946510e-02f, 1.31777599e-01f, -6.68503437e-03f, 9.53256339e-02f, -2.03892931e-01f,
  -2.32671902e-01f, 2.35106319e-01f, -2.10881576e-01f, -2.60807071e-02f, 3.53762686e-01f, -1.10509448e-01f, 8.47182721e-02f, 8.31214935e-02f, 1.01937197e-01f, 5.16061001e-02f,
  1.53006297e-02f, -5.23868762e-02f, 1.05257265e-01f, -1.36583284e-01f, 9.52148288e-02f, 7.39890561e-02f, -7.11444467e-02f, 1.28446728e-01f, 4.89559583e-02f, 1.03926636e-01f,
  1.03415519e-01f, -5.40975295e-03f, -1.20603755e-01f, 6.28407300e-02f, 5.50083630e-02f, -2.21832227e-02f, -3.36833298e-02f, -7.82319251e-03f, 8.72071274e-03f, 8.39366242e-02f,
  -5.89888878e-02f, 1.31290600e-01f, 3.53404880e-02f, -1.97970450e-01f, 1.40443280e-01f, 1.58636093e-01f, 7.64207095e-02f, -5.74463680e-02f, -2.95517426e-02f, 6.24071136e-02f,
  -3.46844904e-02f, 1.34521171e-01f, 6.88227117e-02f, 5.50658479e-02f, 1.15814865e-01f, 7.72638619e-02f, 3.14121284e-02f, 1.54680029e-01f, 1.74456462e-01f, 1.06080279e-01f,
  -7.12246224e-02f, -5.26130460e-02f, -1.08060027e-02f, 4.58530821e-02f, -2.48251949e-02f, -2.03444492e-02f, -1.29443184e-01f, -5.55007271e-02f, -3.80881652e-02f, 5.27511314e-02f,
  8.39969516e-02f, -4.84060422e-02f, -1.94335785e-02f, -4.47628573e-02f, -9.07520279e-02f, -1.07433803e-01f, 7.17347935e-02f, -2.12162808e-02f, 1.85185708e-02f, -1.37819871e-01f,
  -3.59383896e-02f, 7.05258399e-02f, 5.73977223e-03f, 2.02555060e-02f, 7.48127252e-02f, 1.35469720e-01f, -1.08632490e-01f, 2.97338571e-02f, -6.39906945e-03f, -1.27876122e-02f,
  1.18909195e-01f, 5.55257425e-02f, -5.97670861e-02f, 5.36493957e-02f, 4.05552648e-02f, -7.40093291e-02f, -5.98869566e-03f, -5.00594527e-02f, 5.53578064e-02f, -1.20995283e-01f,
  -8.38976279e-02f, -4.00997810e-02f, 1.44673362e-01f, -4.82124239e-02f, 2.44580545e-02f, -9.51360166e-02f, -2.24712510e-02f, -4.79506701e-02f, 9.09693688e-02f, -5.56220412e-02f,
  -5.61011359e-02f, 9.72991660e-02f, 2.30754483e-02f, 9.30416062e-02f, -7.32389092e-02f, 6.59155920e-02f, 5.07735536e-02f, -1.96056888e-02f, 9.95461345e-02f, 7.85575286e-02f,
  4.26898360e-01f, 7.36053661e-03f, 1.75163746e-01f, 2.36377999e-01f, -3.49470116e-02f, -2.48598218e-01f, 2.25488264e-02f, -1.02991365e-01f, 9.05016810e-02f, -2.39420563e-01f,
  -2.01109692e-01f, 2.58418173e-01f, -2.38837495e-01f, 2.10861877e-01f, 3.00719529e-01f, -2.00622916e-01f, 2.39238992e-01f, 1.02525301e-01f, -3.77639234e-02f, 5.90330772e-02f,
  1.73156589e-01f, 6.45312369e-02f, 9.39209908e-02f, -1.80940300e-01f, 4.92209718e-02f, 6.49617836e-02f, 1.19762018e-01f, -1.25391409e-01f, 8.19206461e-02f, 6.75458983e-02f,
  2.97159664e-02f, 7.75444284e-02f, 1.10492229e-01f, 4.49829400e-02f, 6.89063966e-02f, 7.36378133e-02f, 5.04184365e-02f, 9.73743498e-02f, 2.77773384e-03f, -9.32514966e-02f,
  2.31320523e-02f, -2.12599095e-02f, -5.12749739e-02f, -8.72831196e-02f, -1.37053858e-02f, -3.28151695e-02f, -4.38104793e-02f, -5.91644272e-02f, -2.11110152e-02f, 4.77966061e-03f,
  -5.28987572e-02f, 1.10471295e-02f, 2.32279971e-02f, -2.62771244e-03f, 7.37542734e-02f, 1.17873717e-02f, 8.03690627e-02f, 4.07572016e-02f, -7.93163478e-03f, 4.92087379e-03f,
  -1.79971352e-01f, 1.44886002e-01f, 1.13895439e-01f, 1.86757013e-01f, 1.20411366e-01f, 7.87918270e-02f, 1.65440887e-02f, 3.61293033e-02f, 1.01033852e-01f, 1.19098082e-01f,
  3.08894925e-02f, 6.99209869e-02f, -5.76471910e-03f, 1.01211727e-01f, 4.44207229e-02f, 2.10041746e-01f, 1.04652964e-01f, -3.30139361e-02f, 1.48613425e-02f, 7.67674006e-04f,
  -6.62262831e-03f, 1.21262893e-01f, 3.09012067e-02f, -1.04919776e-01f, -6.24582656e-02f, 5.26721217e-02f, -9.72436517e-02f, -4.73035537e-02f, -1.59510951e-02f, -1.25724345e-01f,
  -8.58230516e-02f, 1.06405258e-01f, -1.16951177e-02f, 7.34745860e-02f, -2.84938831e-02f, -1.03245778e-02f, 9.74060595e-02f, 5.22835180e-02f, -4.79667485e-02f, -1.17574967e-01f,
  4.05158615e-03f, 2.01252159e-02f, 1.52273215e-02f, -1.03801237e-02f, -3.79256904e-02f, -8.97978172e-02f, 7.24982098e-02f, 1.43104428e-02f, -2.04646084e-02f, -2.62384079e-02f,
  -6.88425601e-02f, -5.63178100e-02f, -2.80933063e-02f, -3.26346941e-02f, -6.03651954e-03f, 7.01212883e-02f, 9.56003740e-02f, 1.59586594e-02f, -5.80388270e-02f, -6.18147291e-02f,
  -5.55239841e-02f, 1.33827522e-01f, -2.93832839e-01f, -1.97170705e-01f, -7.42079131e-03f, -1.77462585e-03f, -1.37978211e-01f, 9.06929001e-02f, -2.77347088e-01f, 2.02550352e-01f,
  1.69447467e-01f, 8.01844930e-04f, -1.71237618e-01f, 1.62351564e-01f, -2.90009141e-01f, -1.93890065e-01f, -4.37043328e-03f, 6.50362372e-02f, -9.13173780e-02f, 1.40929995e-02f,
  -9.92255956e-02f, 4.47603650e-02f, -1.91549454e-02f, 1.27858251e-01f, 1.02631822e-01f, 5.08995820e-03f, 1.21931642e-01f, -1.69203743e-01f, 2.26746723e-01f, -3.17743805e-04f,
  1.15748450e-01f, -4.57419828e-02f, 1.00551315e-01f, 7.53539503e-02f, 1.47835746e-01f, -3.03293057e-02f, -4.94745076e-02f, -1.46886632e-01f, -2.16953531e-02f, 5.59835183e-03f,
  4.38187718e-02f, -5.46297804e-02f, 9.37731862e-02f, -7.98080713e-02f, -1.95656970e-01f, -5.46072386e-02f, 2.20114421e-02f, 8.56706351e-02f, 1.12367682e-01f, -1.10862792e-01f,
  -7.54984245e-02f, 1.32524133e-01f, -1.09970599e-01f, 1.65839717e-02f, -5.28282188e-02f, 2.09151357e-02f, -8.14344138e-02f, -5.57714067e-02f, 1.01676725e-01f, -6.58604950e-02f,
  -4.98724617e-02f, -7.47603402e-02f, -4.59562875e-02f, -1.57856308e-02f, -1.95631734e-03f, -8.22973810e-03f, 2.99549904e-02f, 2.30168458e-02f, -2.86021847e-02f, 1.28675446e-01f,
  1.05993137e-01f, 8.12317152e-03f, 7.02559575e-02f, -3.00314389e-02f, 2.68951617e-02f, 4.80576738e-04f, 4.42446135e-02f, 1.96463615e-02f, -3.40779759e-02f, 2.40377113e-02f,
  8.77639744e-03f, -1.67987987e-01f, 1.76667452e-01f, 2.73710657e-02f, -1.05288193e-01f, 3.75711471e-02f, -1.21336296e-01f, -7.81393200e-02f, 3.00613767e-03f, 1.02369441e-02f,
  1.29984871e-01f, -1.84608120e-02f, 8.15899447e-02f, 8.12644213e-02f, 5.16555235e-02f, -3.02153043e-02f, -2.00459570e-01f, 4.80254777e-02f, -1.77060291e-02f, -1.08926920e-02f,
  -2.62849145e-02f, 7.74154663e-02f, -6.22683205e-03f, -8.87590721e-02f, -9.97453704e-02f, -4.72985283e-02f, -2.81207822e-02f, 6.05379529e-02f, 1.20685920e-01f, 1.11364111e-01f,
  1.19799547e-01f, 1.57211144e-02f, -8.64450485e-02f, -1.55978547e-02f, 6.91458136e-02f, 1.53680056e-01f, -7.29764402e-02f, 9.51053482e-03f, -1.66437346e-02f, -2.33196132e-02f,
  -3.43260348e-01f, 3.27546299e-01f, -2.20814743e-03f, -1.83148943e-02f, 6.75159469e-02f, 2.43776441e-01f, 2.34395474e-01f, 9.61871371e-02f, 1.71235740e-01f, 3.00070584e-01f,
  1.09857418e-01f, 2.05352247e-01f, 1.63827688e-01f, -4.04581912e-02f, 7.12641403e-02f, 2.72043496e-02f, -1.28450468e-01f, -3.00119277e-02f, -2.75500715e-01f, -1.49121702e-01f,
  -1.26226068e-01f, -2.06693336e-01f, -1.37707993e-01f, -1.05060063e-01f, -1.32601023e-01f, -1.24246866e-01f, 6.83607459e-02f, 4.02383171e-02f, 3.60421650e-02f, 9.61015746e-02f,
  -1.61712334e-01f, -1.76558837e-01f, -2.54521936e-01f, -2.25378484e-01f, -1.16165191e-01f, -3.30753922e-02f, -5.37228771e-03f, -4.39052470e-02f, -9.65790376e-02f, -8.51541460e-02f,
  3.32660563e-02f, -1.13725215e-01f, 4.61888574e-02f, 1.14166677e-01f, 8.35916549e-02f, -4.61787470e-02f, -6.79476261e-02f, -2.76450180e-02f, -4.44768816e-02f, 8.02187026e-02f,
  3.38742472e-02f, 5.86260036e-02f, 4.93498705e-02f, 7.91947097e-02f, -6.07115515e-02f, 1.11483425e-01f, -3.65029275e-02f, 1.62113875e-01f, 8.80341902e-02f, 3.65425535e-02f,
  1.81787074e-01f, -1.45121619e-01f, -1.42181128e-01f, -7.37794936e-02f, -6.97988346e-02f, -5.36346175e-02f, -6.55497685e-02f, -1.60458684e-01f, -1.55269414e-01f, -1.25261813e-01f,
  -3.34542952e-02f, -1.36308581e-01f, -9.82063860e-02f, 7.94144198e-02f, -8.17746744e-02f, 1.72631908e-02f, -5.20233512e-02f, -9.59941000e-03f, 1.17086628e-02f, 7.80285224e-02f,
  8.35366249e-02f, 2.90778074e-02f, -1.09129526e-01f, -7.10750148e-02f, 3.47424112e-02f, -2.60023270e-02f, -4.57536653e-02f, 3.79656665e-02f, 2.12562233e-02f, 2.02308453e-04f,
  5.89876920e-02f, 5.47146536e-02f, -1.91024914e-01f, -1.14024736e-01f, -4.92273308e-02f, -8.75939503e-02f, -1.68134212e-01f, -9.76790562e-02f, -3.00873034e-02f, -4.28750776e-02f,
  -5.27848005e-02f, -7.84941688e-02f, 9.27706510e-02f, 6.69031441e-02f, -5.63037544e-02f, 5.81952296e-02f, 3.72626958e-03f, -6.40527233e-02f, 8.38002935e-02f, 1.31761253e-01f,
  7.44436681e-02f, -4.95099425e-02f, -7.46153668e-02f, -8.13231096e-02f, -8.29124302e-02f, 1.37375340e-01f, 5.19860685e-02f, 3.22328508e-02f, -2.70008463e-02f, 8.22162442e-03f,
  -2.45259300e-01f, 2.87241310e-01f, 1.08199403e-01f, -2.18839869e-01f, -1.17074110e-01f, -2.36307994e-01f, -2.62665689e-01f, 1.16971463e-01f, -3.90696861e-02f, 2.35082339e-02f,
  -3.15795839e-01f, 2.03676403e-01f, 9.00733620e-02f, -1.46197379e-01f, -2.86182106e-01f, 2.68986672e-02f, -1.28269851e-01f, -1.20385282e-01f, 4.42450419e-02f, -4.71162945e-02f,
  3.53299156e-02f, -1.65224701e-01f, 6.82289675e-02f, 1.34139493e-01f, -2.01229844e-02f, 2.13938743e-01f, -4.55774665e-02f, 1.02804601e-01f, 1.28872171e-01f, -3.22267674e-02f,
  -5.49068190e-02f, 3.67561541e-02f, 2.42854301e-02f, 3.44933309e-02f, -8.18290859e-02f, -1.00993775e-01f, -4.14927006e-02f, -5.28541617e-02f, 2.41698772e-02f, 7.84038380e-02f,
  1.17793810e-02f, 1.40549362e-01f, -1.26672804e-03f, -1.53206680e-02f, -2.81691942e-02f, 8.83167461e-02f, -5.22499811e-03f, 4.44997363e-02f, 9.54046175e-02f, 6.13014661e-02f,
  -2.98408195e-02f, 7.11667761e-02f, -4.28468473e-02f, 1.45846143e-01f, 8.24913532e-02f, 1.88017376e-02f, 1.61337808e-01f, -1.31937573e-02f, 1.01773553e-01f, 6.45060018e-02f,
  1.02924909e-02f, -3.02081648e-02f, 7.57009955e-03f, 5.17981499e-02f, -1.77416168e-02f, 1.58334300e-02f, -8.79518688e-02f, -1.14787640e-02f, -2.00440940e-02f, -3.26114856e-02f,
  -6.79667518e-02f, -5.50448559e-02f, -3.11208498e-02f, 2.06852648e-02f, -1.45002892e-02f, -1.50962295e-02f, 1.67460814e-02f, 1.23362042e-01f, -1.76569950e-02f, -3.68168801e-02f,
  -3.96759324e-02f, -1.26813492e-02f, -3.72003429e-02f, -4.68307175e-02f, -1.83150545e-01f, 1.96998343e-02f, 3.37572880e-02f, 9.46206003e-02f, -7.04096444e-03f, -8.94397423e-02f,
  -2.03202534e-02f, 1.22582123e-01f, -1.25901168e-02f, 1.28982449e-02f, -8.29890221e-02f, -9.63725671e-02f, -2.45947670e-02f, 1.72957256e-02f, 7.85565376e-02f, 6.48957724e-03f,
  4.90272343e-02f, 2.62534637e-02f, -2.24139709e-02f, -6.41294196e-02f, 2.48250272e-02f, -2.30164081e-02f, -5.31041361e-02f, -1.44338533e-02f, 1.10956747e-02f, 1.09468410e-02f,
  5.10835610e-02f, 5.04509434e-02f, -3.60521451e-02f, 3.16574872e-02f, 8.05422291e-03f, -5.05333804e-02f, 2.75969934e-02f, 5.47865927e-02f, 7.44043067e-02f, 1.21866912e-01f,
  -7.46305510e-02f, -9.67298746e-02f, -3.38073224e-02f, 2.92747080e-01f, -1.91678554e-02f, 1.96372494e-01f, 2.42401555e-01f, -5.80232814e-02f, 8.68009701e-02f, 1.24813877e-01f,
  9.18454155e-02f, 1.09760817e-02f, -1.85051933e-02f, 2.31146693e-01f, 2.30318859e-01f, -3.23552489e-02f, 4.30384547e-01f, 3.01278204e-01f, -5.43818250e-02f, 1.03640519e-01f,
  -2.01408612e-03f, 2.89847404e-01f, -7.90926144e-02f, -1.23870380e-01f, -3.38618383e-02f, -2.52503902e-01f, 4.64249812e-02f, -2.16838598e-01f, 1.25085235e-01f, -7.50664845e-02f,
  3.63989547e-02f, -1.39627159e-01f, -8.02314561e-03f, 6.29033744e-02f, 9.98307019e-02f, -2.45758574e-02f, 6.08484484e-02f, 7.12681934e-02f, -2.37689633e-02f, 1.01016305e-01f,
  7.82073885e-02f, -7.01285601e-02f, -1.88889727e-02f, -1.15174577e-02f, -6.71117082e-02f, -9.95382294e-03f, -2.96521746e-02f, 5.06796762e-02f, -4.61756624e-02f, -1.13694116e-01f,
  -1.28380498e-02f, -4.42906097e-02f, 5.32926023e-02f, 1.37064476e-02f, 7.40530267e-02f, -3.72025073e-02f, -2.20336989e-02f, -4.37868834e-02f, -5.17599471e-03f, -1.34337470e-02f,
  -6.37622923e-02f, -5.15265763e-02f, -3.30831446e-02f, -2.04470623e-02f, 8.89555458e-03f, -7.40080997e-02f, 7.63502941e-02f, -9.46537033e-03f, -1.19157566e-03f, 5.72978929e-02f,
  3.22622471e-02f, -2.09551565e-02f, 8.43838081e-02f, 1.30277518e-02f, 4.98622991e-02f, -1.28370896e-01f, -6.28074855e-02f, 6.47888929e-02f, 1.18318826e-01f, -2.89828721e-02f,
  -8.78383964e-02f, -6.04562536e-02f, 5.45902438e-02f, 1.00611309e-02f, 6.54945895e-02f, -6.65721763e-03f, 5.11246622e-02f, -1.51371686e-02f, -8.18122774e-02f, 1.42322138e-01f,
  1.94446012e-01f, 1.49530709e-01f, 4.97797243e-02f, 3.76669504e-02f, 1.62608940e-02f, 4.42690030e-02f, 1.84206069e-02f, 1.77174490e-02f, 8.39396864e-02f, 6.12180494e-03f,
  9.95582864e-02f, 3.88162360e-02f, -3.32749002e-02f, 5.39257238e-03f, 2.03122839e-01f, 6.10212795e-02f, -1.06048426e-02f, 1.30625680e-01f, 1.37276486e-01f, -7.85371214e-02f,
  5.96366860e-02f, 2.66965963e-02f, 1.86350062e-01f, 4.23551872e-02f, 1.27156362e-01f, -1.39314486e-02f, -1.06092654e-02f, -1.84184648e-02f, 1.60353497e-01f, 9.90867764e-02f,
  -3.16561103e-01f, 2.32954755e-01f, 1.52798891e-01f, -1.30709276e-01f, -1.90458760e-01f, -2.49418288e-01f, -2.09004611e-01f, 3.56684178e-02f, 2.24638339e-02f, 8.29898417e-02f,
  -1.15556903e-01f, 1.15361989e-01f, 2.72308350e-01f, -3.04295570e-01f, -2.36955538e-01f, 1.92049921e-01f, -1.35357320e-01f, -2.53830273e-02f, 1.98545575e-01f, -3.19680665e-03f,
  -9.77777466e-02f, -2.81985104e-01f, -2.87995841e-02f, 4.64519523e-02f, -1.98018730e-01f, 1.00872241e-01f, -3.09826955e-02f, 1.60995409e-01f, -1.02252021e-01f, -6.25342056e-02f,
  8.81336513e-04f, -9.82121527e-02f, -1.33099556e-02f, 5.15628345e-02f, -1.02294818e-01f, -9.73154306e-02f, 6.31186664e-02f, -6.04470558e-02f, 2.55116653e-02f, 4.36448567e-02f,
  1.06362462e-01f, 1.17820920e-02f, 4.87047769e-02f, 5.51773719e-02f, -2.08020136e-02f, 5.02567440e-02f, 4.83779684e-02f, -4.38710954e-03f, 2.15198961e-03f, -7.09884763e-02f,
  1.16884094e-02f, -8.74352604e-02f, -5.54669015e-02f, -1.19802579e-02f, 1.40428962e-02f, -7.50877932e-02f, -5.62006719e-02f, 8.85205995e-03f, -1.65399835e-02f, -3.40586267e-02f,
  -4.58898135e-02f, -7.91621804e-02f, -2.48421356e-02f, 2.06712298e-02f, -9.30504277e-02f, -1.81058738e-02f, 3.46880071e-02f, -5.26027344e-02f, 5.38099632e-02f, -3.88402380e-02f,
  9.99310613e-02f, 3.90072279e-02f, 8.27298909e-02f, -5.43555729e-02f, -5.52808493e-02f, -1.50693133e-01f, 2.12444309e-02f, 1.92538753e-01f, 1.14012845e-01f, 6.37192950e-02f,
  -5.21404110e-02f, -1.08255856e-01f, 1.15302511e-01f, 2.54265051e-02f, 3.95648926e-02f, -3.83612420e-03f, 1.06437104e-02f, 5.03793396e-02f, 6.48870971e-03f, 8.74721482e-02f,
  1.50483632e-02f, 1.45211872e-02f, 8.06850791e-02f, 4.40683551e-02f, 9.42085162e-02f, 3.70894931e-02f, -3.88225205e-02f, 3.30038667e-02f, 9.64008495e-02f, -3.58706899e-02f,
  -3.08407620e-02f, 8.32379051e-03f, 4.07446474e-02f, -9.62003693e-03f, 7.72069469e-02f, 1.23116719e-02f, 2.94498093e-02f, 1.47241518e-01f, -4.33021002e-02f, 3.20456140e-02f,
  -5.21772821e-03f, 4.92037348e-02f, 8.82785842e-02f, -1.88964512e-02f, 1.09058544e-02f, 4.82984744e-02f, -1.08854905e-01f, 1.10027995e-02f, 2.71686725e-02f, 4.52213064e-02f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.28003585e-02f, -3.99571545e-02f, -1.61617436e-02f, -1.66571379e-01f, 1.24481544e-01f, 2.74542361e-01f, 2.51507044e-01f, 6.35078996e-02f, 5.16384132e-02f, -3.53169143e-02f,
  2.96099763e-02f, -1.27860352e-01f, 1.37311801e-01f, -2.38551572e-02f, 2.53855497e-01f, 7.71905333e-02f, 7.01784901e-03f, -9.71592665e-02f, -2.81495824e-02f, -6.61459491e-02f,
  -4.41028103e-02f, -1.25587508e-01f, -2.99094487e-02f, -2.92882286e-02f, 8.98670256e-02f, 2.58638635e-02f, -4.89897989e-02f, 7.66336992e-02f, -1.90841809e-01f, 8.85484591e-02f,
  2.13783495e-02f, 5.19793555e-02f, 4.27693538e-02f, -9.22947973e-02f, 9.91749540e-02f, 3.30850184e-02f, 4.76395991e-03f, 2.29324419e-02f, 5.29636480e-02f, -6.46640882e-02f,
  -1.12937786e-01f, -7.89480060e-02f, 5.19269332e-02f, 1.30993858e-01f, -4.65999320e-02f, -5.31418771e-02f, -9.26581398e-02f, -1.66948847e-02f, -9.54883695e-02f, 2.70976387e-02f,
  7.38525242e-02f, -1.80391930e-02f, -5.61883599e-02f, -1.62046060e-01f, -7.84427747e-02f, 1.98731106e-03f, 2.18767468e-02f, 1.02318220e-01f, -1.03317508e-02f, 4.23369408e-02f,
  -4.51612025e-02f, 3.48256379e-02f, 6.94265440e-02f, -6.83964267e-02f, 9.00755525e-02f, -2.24531381e-04f, -4.08432968e-02f, -8.10738504e-02f, -2.31322069e-02f, -8.55398849e-02f,
  -8.21946375e-03f, -2.82734577e-02f, -6.79481355e-03f, 4.33123298e-02f, -8.38026404e-02f, -8.92704874e-02f, -7.22679347e-02f, -3.86662409e-02f, 7.39396065e-02f, 1.54010326e-01f,
  -5.99986464e-02f, -3.63489501e-02f, 4.14337069e-02f, -2.66343374e-02f, -6.92657602e-04f, -2.49732807e-02f, -8.90907347e-02f, -8.15857574e-03f, 6.52185977e-02f, -9.95423459e-03f,
  2.10257638e-02f, 1.55782308e-02f, 1.14755603e-02f, -2.08523020e-01f, 5.48689044e-04f, 1.22438639e-01f, 6.23667017e-02f, 5.20694884e-04f, -2.73423316e-03f, -2.86246296e-02f,
  -1.24782272e-01f, 3.43095586e-02f, 4.63438220e-02f, 5.84913120e-02f, -1.66835770e-01f, 1.40377864e-01f, -7.88254365e-02f, -3.44838277e-02f, -7.55755007e-02f, -7.39172101e-02f,
  -5.63000329e-02f, 4.05248161e-03f, -4.51464579e-02f, -7.91623630e-03f, -1.99124128e-01f, -4.71674837e-02f, 1.14143074e-01f, -1.80499293e-02f, -8.56056288e-02f, -4.21942957e-02f,
  1.13137871e-01f, 4.76980694e-02f, -1.83836907e-01f, 2.49035954e-01f, 1.71488479e-01f, 4.21771318e-01f, 2.52456784e-01f, 1.48583159e-01f, 3.35405946e-01f, 9.22216177e-02f,
  1.27626508e-01f, 9.12037343e-02f, -1.59661084e-01f, 3.35731655e-01f, 1.99532107e-01f, -4.34951298e-03f, 4.32987452e-01f, 2.88290471e-01f, 2.12046146e-01f, 8.29895735e-02f,
  1.34397626e-01f, 2.41095126e-01f, -2.19132513e-01f, -1.43956896e-02f, -2.88021397e-02f, -2.87373036e-01f, -2.16556892e-01f, -2.34149620e-01f, 7.50600770e-02f, 1.92608550e-01f,
  5.59939407e-02f, 1.07996158e-01f, -9.28968042e-02f, -8.46833810e-02f, -6.54029772e-02f, -1.09255254e-01f, -4.85266671e-02f, -1.21256724e-01f, -3.99448425e-02f, -1.23397760e-01f,
  1.85659379e-02f, -5.93437739e-02f, -2.39727180e-03f, 3.04886792e-02f, 6.51771203e-02f, -9.35583636e-02f, 7.56645249e-03f, 3.87871563e-02f, -2.85437275e-02f, -2.24194415e-02f,
  -1.57643610e-03f, -1.21054582e-01f, 5.00792377e-02f, -2.58724000e-02f, 1.01766847e-02f, 7.59301260e-02f, 3.53570059e-02f, -1.59480702e-02f, -5.99925928e-02f, 1.02740034e-01f,
  -2.78083980e-02f, 7.83105418e-02f, -7.99113140e-02f, -5.86783886e-02f, 8.19790585e-04f, -8.99459049e-02f, 1.11178279e-01f, -6.39828807e-03f, 1.52467014e-02f, 5.27695343e-02f,
  -2.65433230e-02f, 1.77052394e-02f, 4.97846194e-02f, 9.60671678e-02f, 1.21844098e-01f, 2.56844480e-02f, -1.71783850e-01f, -3.42933498e-02f, 6.69535771e-02f, -1.86960436e-02f,
  -1.09446630e-01f, 1.21318720e-01f, -1.53437972e-01f, -9.07789320e-02f, 7.21333623e-02f, -4.59005572e-02f, 4.57807742e-02f, 3.95634677e-03f, 6.94551319e-03f, 1.27985077e-02f,
  1.66531876e-01f, 2.09456861e-01f, -1.28009589e-02f, -9.70588624e-03f, -1.55605953e-02f, 8.02176893e-02f, 1.12795971e-01f, -2.98649762e-02f, 5.96822537e-02f, -1.12358900e-02f,
  -3.57082044e-03f, -6.00006543e-02f, -9.20693800e-02f, 3.58696841e-02f, 3.82132046e-02f, 3.82978749e-03f, 8.68491009e-02f, 4.10046205e-02f, -4.63993251e-02f, -3.05635668e-02f,
  -6.19763806e-02f, -2.52286699e-02f, -8.56988225e-03f, -6.27552122e-02f, 1.08005159e-01f, -3.07570351e-03f, 1.03779398e-01f, 8.46066549e-02f, -3.94894965e-02f, -4.22831662e-02f,
  5.09363487e-02f, -2.02982575e-01f, 6.56250641e-02f, 1.12411194e-03f, -1.63906217e-02f, 1.78956855e-02f, -1.36013359e-01f, -1.43677339e-01f, -1.47205159e-01f, 4.00277525e-02f,
  -1.84543356e-01f, 9.48192179e-03f, -2.41218001e-01f, -3.19819182e-01f, -2.14539081e-01f, -3.82659703e-01f, -4.65824008e-02f, 1.55520979e-02f, -1.06169932e-01f, -2.51664873e-02f,
  -9.17725712e-02f, -2.50905424e-01f, -1.90922976e-01f, -9.84557122e-02f, 4.81278896e-02f, 2.24430546e-01f, 8.63267481e-02f, 1.05363289e-02f, 1.36930391e-01f, -5.74122258e-02f,
  -4.90669124e-02f, -2.49693930e-01f, 6.52282834e-02f, -3.22499722e-02f, -4.80385385e-02f, 7.00031742e-02f, 3.52896862e-02f, -7.45391920e-02f, -8.43411088e-02f, -1.08337522e-01f,
  6.15364239e-02f, 1.04787629e-02f, -7.82480463e-03f, -1.35099543e-02f, -4.73900279e-03f, -4.72242646e-02f, 4.09870222e-02f, 1.73069715e-01f, -1.23116211e-03f, -4.70008282e-03f,
  1.29885271e-01f, 4.52504717e-02f, 1.39344826e-01f, 5.92143573e-02f, 7.22890645e-02f, 2.98391357e-02f, 9.54505950e-02f, 8.58888328e-02f, 1.01711832e-01f, 5.45130111e-02f,
  -3.37115377e-02f, -3.60774510e-02f, -8.90247822e-02f, 4.70459126e-02f, -1.53200194e-01f, -3.74333672e-02f, -2.08720751e-02f, -2.90149283e-02f, -1.73729733e-02f, -2.04172488e-02f,
  -2.06120498e-02f, -1.55412674e-01f, -2.65826415e-02f, 9.08151120e-02f, -9.98662561e-02f, 6.68934211e-02f, 1.91795267e-02f, 1.08238056e-01f, 8.83564278e-02f, 4.77329418e-02f,
  -3.54439616e-02f, 8.27740878e-02f, -1.52236214e-02f, 3.33032236e-02f, -3.02503202e-02f, -3.31026092e-02f, 1.36331499e-01f, 1.68782063e-02f, -1.90709531e-02f, 8.51338357e-02f,
  6.99541792e-02f, -1.24567337e-02f, -9.67551023e-02f, -4.55592833e-02f, 1.66818930e-03f, 7.02617690e-02f, -4.08152230e-02f, 3.03990319e-02f, -4.98603918e-02f, -1.37255758e-01f,
  1.60115194e-02f, 4.54085432e-02f, 1.40279785e-01f, 6.17678128e-02f, -3.05880662e-02f, -4.45233025e-02f, 2.75076292e-02f, 8.91254842e-02f, 3.60047333e-02f, 1.07473008e-01f,
  1.49126053e-01f, 4.44776230e-02f, 9.14855450e-02f, 1.10725559e-01f, 6.08831942e-02f, 7.14351684e-02f, 2.48277150e-02f, -4.99874949e-02f, 4.36881222e-02f, 2.69087441e-02f,
  1.66225851e-01f, 1.77513316e-01f, 8.78957137e-02f, 8.19020942e-02f, -3.49589363e-02f, 1.61977977e-01f, -9.23622176e-02f, -1.14718981e-01f, 2.69247979e-01f, 2.21834317e-01f,
  -2.83266634e-01f, 3.41619909e-01f, -1.67085633e-01f, -1.45682931e-01f, -2.08757836e-02f, -3.93587202e-02f, 1.46663889e-01f, 1.20161530e-02f, 2.73210872e-02f, -5.14622517e-02f,
  3.12895998e-02f, -1.12023801e-01f, -2.51914471e-01f, -7.49002174e-02f, -1.07211009e-01f, -1.08666465e-01f, -2.21832067e-01f, -1.79299012e-01f, -9.48710069e-02f, -6.57459646e-02f,
  1.80067997e-02f, 3.50693502e-02f, -1.54029904e-02f, -7.72992224e-02f, 7.75861889e-02f, 2.89963372e-02f, 8.52928013e-02f, -6.32989500e-03f, -4.48852591e-02f, -1.23348683e-01f,
  1.45355374e-01f, 4.93178293e-02f, -2.20455378e-02f, -1.32454813e-01f, -8.30202699e-02f, -4.84934039e-02f, 5.26905758e-03f, -7.49059021e-02f, -4.38525826e-02f, -3.78578864e-02f,
  3.48221660e-02f, 3.72324437e-02f, 5.85527830e-02f, 1.13235814e-02f, 4.23243502e-03f, -6.37599304e-02f, 2.81568039e-02f, -3.09354998e-02f, -6.90436065e-02f, 1.33353248e-01f,
  1.38975047e-02f, 1.38160899e-01f, -2.15727501e-02f, -5.36733977e-02f, 1.26024541e-02f, -1.84962749e-02f, 1.10827319e-01f, 6.71480522e-02f, 3.68368737e-02f, 3.41977738e-02f,
  6.71524042e-03f, -5.39304763e-02f, -8.97637084e-02f, 7.31003582e-02f, 1.06421933e-01f, 7.96919689e-02f, -1.22040845e-01f, -1.25275208e-02f, 1.57588292e-02f, 1.84048146e-01f,
  -6.40514866e-02f, -2.60436479e-02f, -7.12793395e-02f, 2.79936418e-02f, -9.22989324e-02f, -9.36776176e-02f, -5.62525494e-03f, -2.27434244e-02f, -4.45633940e-02f, 2.45296117e-02f,
  8.58776346e-02f, 2.40448952e-01f, -9.71241668e-03f, -8.03826824e-02f, -2.36536674e-02f, 1.09358862e-01f, 1.54495940e-01f, 1.46150216e-01f, 4.40163463e-02f, -1.96831711e-02f,
  7.59404600e-02f, -2.24185805e-03f, 7.10357055e-02f, -2.11846009e-02f, -1.08068042e-01f, -2.12572142e-02f, 1.83356851e-02f, 2.95257047e-02f, 3.97008806e-02f, -3.29536339e-03f,
  -5.56132803e-03f, 6.49710521e-02f, 1.46645859e-01f, 1.28578633e-01f, 1.49948373e-01f, 4.18848507e-02f, 9.14974138e-02f, -3.86806726e-02f, -2.85594668e-02f, 1.05240040e-01f,
  -3.50794755e-02f, 1.39869690e-01f, -2.37615749e-01f, 2.89613247e-01f, -4.44610715e-02f, 3.86002928e-01f, 3.63079369e-01f, 5.58193214e-02f, 2.55981386e-01f, 2.56489992e-01f,
  2.75462329e-01f, -3.34441289e-02f, 9.06708688e-02f, 4.56823885e-01f, 2.85528321e-02f, 2.92863876e-01f, 3.71135652e-01f, 2.13126838e-01f, 1.45361423e-01f, 1.69209093e-01f,
  2.80359723e-02f, 2.59623915e-01f, -1.47590905e-01f, -9.47628915e-02f, 3.57771479e-02f, -3.14851791e-01f, -1.98401988e-01f, -2.27903709e-01f, 4.97271977e-02f, -9.53564886e-03f,
  1.32089734e-01f, 1.09855890e-01f, -7.07374662e-02f, -4.34289780e-03f, -1.36736166e-02f, -9.19044577e-03f, -2.03391369e-02f, -1.66117951e-01f, -4.63527814e-02f, 4.36845496e-02f,
  -2.31634695e-02f, -5.77349365e-02f, 1.10641211e-01f, -1.76844075e-02f, 6.59439415e-02f, -1.63164902e-02f, 2.19485145e-02f, -3.40975262e-02f, -2.44775023e-02f, -2.66390219e-02f,
  -1.03865743e-01f, 9.06831771e-02f, 8.43946561e-02f, 7.60292914e-03f, -4.62624654e-02f, 4.59437110e-02f, 3.88362892e-02f, -6.71140999e-02f, -2.26037614e-02f, 8.58609006e-02f,
  -9.81589779e-02f, 2.47127533e-01f, 7.00286329e-02f, -1.25002256e-02f, -2.62516607e-02f, -1.06895147e-02f, 1.09685868e-01f, -6.84238551e-03f, -3.12261321e-02f, 1.58033773e-01f,
  5.65209007e-03f, -2.29937173e-02f, 1.05592988e-01f, -6.66263746e-03f, 2.26547331e-01f, 3.92610990e-02f, -9.69925970e-02f, 1.71429105e-02f, 4.51679789e-02f, -1.53768644e-01f,
  -8.93401261e-03f, -1.68338344e-02f, -2.28486415e-02f, -3.19044329e-02f, 4.44977470e-02f, 7.14910636e-03f, 5.57168871e-02f, 6.24894053e-02f, -1.76031366e-02f, 4.92739268e-02f,
  1.87179521e-01f, 7.74453878e-02f, 2.28760652e-02f, -4.18009609e-03f, -1.25812097e-02f, 7.12115169e-02f, 7.05032125e-02f, -8.63311812e-02f, 5.03135882e-02f, 2.78283730e-02f,
  -2.15324797e-02f, 6.20281324e-02f, 6.06859662e-02f, -4.64041755e-02f, 7.05762357e-02f, 4.80565764e-02f, 7.72307292e-02f, -1.32807689e-02f, -5.70776165e-02f, -5.65431677e-02f,
  -1.42089695e-01f, 1.37823194e-01f, -4.93924394e-02f, 4.59813140e-02f, 4.92369086e-02f, -9.92743066e-04f, 1.09496331e-02f, -1.67836845e-02f, -3.27139981e-02f, 1.05309576e-01f,
  9.18288305e-02f, -3.59528571e-01f, 7.91827813e-02f, 1.40898377e-01f, 3.13401252e-01f, 4.19688560e-02f, -3.13639417e-02f, 1.25527874e-01f, 1.11792557e-01f, -1.88024908e-01f,
  -2.46099234e-02f, -5.02773374e-02f, -2.63631433e-01f, 5.41427284e-02f, 1.13054082e-01f, -1.21526927e-01f, 7.79851377e-02f, -3.28964666e-02f, 7.04024807e-02f, 4.54864874e-02f,
  1.75822511e-01f, 1.04194388e-01f, 5.44640645e-02f, 5.97201055e-03f, 1.85590774e-01f, 7.89882094e-02f, -5.87677956e-02f, -1.28019780e-01f, 3.55830342e-02f, 5.82549199e-02f,
  -2.93781492e-03f, 2.45786384e-02f, -6.42367685e-03f, -2.82751042e-02f, 2.25374382e-02f, 1.45112034e-02f, 2.96934806e-02f, -3.08447797e-02f, 1.02971122e-01f, 7.79126063e-02f,
  -1.68350935e-02f, 1.05826755e-03f, 3.82086970e-02f, 3.33830230e-02f, -7.94081390e-03f, 1.83875710e-02f, 9.35457051e-02f, 4.52522784e-02f, 3.65080731e-03f, 6.11157864e-02f,
  6.33698851e-02f, -2.73569468e-02f, 3.68905142e-02f, 1.41211394e-02f, 3.34355719e-02f, 1.18630782e-01f, 9.15905088e-03f, -5.40412366e-02f, -4.51523736e-02f, 7.64826089e-02f,
  -4.12924327e-02f, -7.78074749e-03f, 2.70509440e-02f, 1.58511437e-02f, -9.64507833e-02f, 9.86119583e-02f, 5.12516964e-03f, 2.48257793e-03f, -1.33632906e-02f, -3.93628627e-02f,
  -2.27426905e-02f, 1.00538477e-01f, 2.38927398e-02f, -6.37459755e-02f, 3.47113460e-02f, 9.63870957e-02f, -4.65911254e-02f, -1.06549963e-01f, 3.30354087e-02f, 4.35066335e-02f,
  -2.80757546e-02f, -3.15243676e-02f, -4.89092506e-02f, 7.04232752e-02f, -4.00487818e-02f, -1.85532980e-02f, 5.23620322e-02f, -2.11403910e-02f, 1.34320632e-01f, -6.97847530e-02f,
  -4.05655146e-01f, -3.73840749e-01f, -3.51864547e-02f, 1.85872577e-02f, -8.02686661e-02f, 6.12026379e-02f, 5.80937900e-02f, 1.10298246e-01f, -1.28206417e-01f, 2.90054902e-02f,
  3.66177671e-02f, -1.04967011e-02f, 3.08773480e-02f, 7.10614324e-02f, -1.77524015e-02f, 3.61833069e-03f, -5.65175153e-02f, -1.27395973e-01f, -5.99320605e-02f, -5.06067425e-02f,
  -2.06386968e-02f, -7.47353807e-02f, 3.54539566e-02f, 8.22696760e-02f, 7.19417036e-02f, -1.88355651e-02f, -8.26967694e-03f, 1.77957863e-02f, 3.37233022e-02f, 4.95831966e-02f,
  -2.19726235e-01f, -2.59038687e-01f, -3.41607124e-01f, 9.74386856e-02f, 1.13608383e-01f, 2.73782074e-01f, 2.42070943e-01f, -7.96332583e-03f, -1.84308723e-01f, 2.27456197e-01f,
  4.08090264e-01f, -7.21091256e-02f, -5.35912067e-02f, 3.79928797e-01f, 1.10875197e-01f, 4.45526838e-02f, 2.62648046e-01f, 2.76712805e-01f, -6.45432845e-02f, -2.10653365e-01f,
  -1.16916802e-02f, 3.27528328e-01f, 2.73611099e-02f, -1.11060841e-02f, 2.40605250e-01f, -1.70969784e-01f, 2.82506227e-01f, -2.82541275e-01f, 2.76708007e-01f, 1.95156425e-01f,
  -5.52164530e-03f, -2.37605512e-01f, -1.12789206e-01f, -1.06977925e-01f, 1.89714264e-02f, 8.81164800e-03f, -8.71441513e-02f, 8.50995854e-02f, -6.65275678e-02f, -9.48915854e-02f,
  -3.76883261e-02f, -1.21382393e-01f, 8.84089693e-02f, -4.36628386e-02f, -2.18479987e-02f, -1.12996586e-01f, -9.34031680e-02f, 5.69415353e-02f, -1.43824592e-02f, -7.10566491e-02f,
  -1.91690791e-02f, 1.04339018e-01f, 1.54320315e-01f, 5.55650294e-02f, -3.86627503e-02f, 7.08990917e-02f, -1.99527051e-02f, -8.20438415e-02f, 1.26903012e-01f, -6.96369680e-04f,
  6.12290576e-02f, -3.45416591e-02f, 1.81490853e-02f, 5.73329292e-02f, -4.30658273e-02f, 8.67778212e-02f, 1.00078396e-01f, 8.96229520e-02f, 3.01920110e-03f, -9.62957144e-02f,
  -1.93579160e-02f, -5.06181009e-02f, -3.21313553e-02f, -1.83844677e-04f, 1.33139715e-02f, -2.05862895e-03f, -8.31269994e-02f, -8.54428262e-02f, -1.26305878e-01f, 6.43340051e-02f,
  -8.91805291e-02f, -9.72930118e-02f, -1.05938893e-02f, 5.55095673e-02f, -2.47634631e-02f, -5.61689064e-02f, -2.73699709e-03f, -1.51623309e-01f, 1.34877972e-02f, 7.20259845e-02f,
  -1.02188796e-01f, -3.21536422e-01f, -1.13444306e-01f, 7.24394545e-02f, -6.77157268e-02f, 1.61401965e-02f, -5.82014360e-02f, 1.05897695e-01f, -1.19403154e-01f, -1.75981876e-02f,
  -6.92691356e-02f, 1.27448052e-01f, -1.59497093e-02f, 6.32437645e-03f, 1.14794105e-01f, -2.52772626e-02f, -1.40169803e-02f, 2.50729341e-02f, 4.96216118e-02f, -3.88718955e-02f,
  1.01498999e-01f, -8.14477950e-02f, 1.29239395e-01f, 3.43120249e-04f, 1.26253918e-01f, 1.16593659e-01f, -3.08170374e-02f, 3.28988843e-02f, 2.14470878e-01f, 7.90891275e-02f,
  1.51027754e-01f, -7.76179880e-02f, -2.25794762e-01f, 1.15163727e-02f, 2.13700049e-02f, -1.46886930e-01f, -4.41372216e-01f, 2.70310044e-02f, -3.07454467e-01f, -8.95178616e-02f,
  1.15425117e-01f, -5.25283031e-02f, -2.70957857e-01f, 3.50818187e-01f, 2.66048372e-01f, 6.91645518e-02f, 3.30857515e-01f, 1.21445462e-01f, 1.24889515e-01f, 1.60339817e-01f,
  2.61836499e-01f, 4.83110189e-01f, 2.61443943e-01f, 3.00504476e-01f, 9.00694206e-02f, -3.36843506e-02f, 2.62646854e-01f, -1.27452567e-01f, 2.32905179e-01f, 7.97448605e-02f,
  1.21113010e-01f, 9.33693871e-02f, -4.21835519e-02f, -4.70896959e-02f, 1.13957353e-01f, -5.33202244e-03f, 6.96310261e-03f, 2.79036742e-02f, -6.30492494e-02f, -3.24282497e-02f,
  -2.04241537e-02f, 3.75278927e-02f, 1.07103884e-01f, -5.12835383e-03f, -9.16215256e-02f, -2.94161383e-02f, -3.72276232e-02f, -1.09766304e-01f, -6.29984885e-02f, -1.23269819e-02f,
  -1.00260407e-01f, 8.76038522e-02f, -1.13545284e-01f, -1.97100434e-02f, -6.53698221e-02f, -1.24339014e-01f, -6.68283999e-02f, -1.58553302e-01f, 6.11904785e-02f, -2.16624979e-03f,
  2.97138412e-02f, 8.12495127e-02f, 6.95596309e-03f, -1.99044924e-02f, -1.58518851e-02f, 1.95328109e-02f, -3.30203846e-02f, 9.65787098e-02f, -8.66907910e-02f, 3.80638950e-02f,
  1.65091548e-02f, -4.65189256e-02f, -5.23117781e-02f, -7.72738755e-02f, 1.73745900e-01f, 5.16083091e-02f, 4.53043170e-02f, -4.97693047e-02f, -1.10109925e-01f, -9.58888829e-02f,
  -6.30944921e-03f, -4.15271036e-02f, -1.09376125e-01f, 5.51744141e-02f, -1.76920366e-05f, -4.95272726e-02f, 6.89580590e-02f, -6.34584650e-02f, -2.53771152e-02f, 4.84389849e-02f,
  7.50880614e-02f, 2.11981192e-01f, -9.10385326e-02f, -2.87622586e-03f, -1.73029117e-02f, 7.03793019e-02f, 2.46118307e-02f, 6.41922578e-02f, 4.31385897e-02f, 4.29162681e-02f,
  1.06567390e-01f, -7.87954703e-02f, 9.11666751e-02f, -6.38696626e-02f, 6.06635287e-02f, -6.97887912e-02f, -2.03505252e-02f, -1.01609543e-01f, 3.30257528e-02f, 8.41607004e-02f,
  2.81952396e-02f, -4.13147621e-02f, -7.58560598e-02f, -4.41950709e-02f, 6.33324906e-02f, -8.67956653e-02f, 5.83571903e-02f, 2.81608347e-02f, 3.36538143e-02f, -2.95738131e-02f,
  -3.10783923e-01f, 1.02871940e-01f, 3.88287216e-01f, -3.24027926e-01f, 1.80253461e-01f, 1.60687849e-01f, 4.86873724e-02f, -9.91221890e-02f, -2.41693974e-01f, -1.99568197e-01f,
  -1.36010349e-01f, 1.54647470e-01f, 2.37394542e-01f, -3.53834420e-01f, 4.18223105e-02f, 2.65432484e-02f, -2.51143247e-01f, -1.39708847e-01f, 1.05608270e-01f, 4.15327139e-02f,
  1.01330495e-02f, -6.55973330e-02f, 7.18942732e-02f, 1.34388879e-01f, -6.38528615e-02f, -1.66088074e-01f, -1.98710635e-01f, 2.48845831e-01f, -1.93475723e-01f, 2.58032833e-05f,
  -1.92060456e-01f, -2.10003242e-01f, -2.00036783e-02f, 3.58480290e-02f, -1.08351469e-01f, -1.35452151e-02f, 8.60565528e-02f, 3.29011828e-02f, -6.50272742e-02f, -2.45323870e-02f,
  2.30260435e-02f, -1.00792490e-01f, -1.06656559e-01f, 9.54518747e-03f, 9.17060883e-04f, -3.26438323e-02f, 8.11094269e-02f, 9.03129429e-02f, 5.10858037e-02f, 1.18329411e-03f,
  1.23552836e-01f, 1.59039572e-01f, -1.73806641e-02f, -8.86422470e-02f, 9.66086760e-02f, -2.11448278e-02f, 4.92728874e-03f, 1.38805747e-01f, -5.08604851e-03f, -1.00602113e-01f,
  -3.44906151e-02f, -3.61841023e-02f, 5.98813482e-02f, 3.82516459e-02f, 6.34062737e-02f, -6.27355352e-02f, 8.35513114e-04f, 4.54215407e-02f, 3.27672847e-02f, 8.68879166e-03f,
  -7.10152537e-02f, 3.59567255e-02f, -5.84064089e-02f, 2.99188629e-04f, -9.00760144e-02f, -1.10057876e-01f, -1.23946294e-02f, -9.82304290e-02f, 1.00932438e-02f, 1.84736848e-02f,
  -5.63951768e-02f, -1.64500326e-02f, -1.97727345e-02f, 4.16917130e-02f, -1.08986872e-03f, 5.22428676e-02f, -9.58269984e-02f, -3.36375572e-02f, -1.48717299e-01f, 1.97946653e-01f,
  -2.86946386e-01f, -2.10692078e-01f, -2.44479086e-02f, -7.84035847e-02f, -6.97547197e-02f, -1.36060975e-02f, 1.31950453e-02f, -8.09070319e-02f, -4.40081023e-02f, 1.35842599e-02f,
  -3.99777777e-02f, -1.23666830e-01f, -7.63948932e-02f, -4.69973683e-02f, 1.32860258e-01f, -9.86278802e-03f, 2.65581477e-02f, 1.11030051e-02f, -8.46028794e-03f, -1.28515229e-01f,
  -3.31970900e-02f, -7.80467689e-02f, -2.95427963e-02f, -2.02368684e-02f, 2.77763065e-02f, -4.66177166e-02f, -1.16202682e-01f, 2.89697815e-02f, 1.07085213e-01f, -7.10999966e-02f,
  -1.31075338e-01f, 3.85693461e-01f, 2.79271424e-01f, 3.12299788e-01f, -4.63486373e-01f, -3.84048931e-02f, 2.71665126e-01f, -7.98600633e-03f, 2.75271326e-01f, 2.38456041e-01f,
  -1.69123590e-01f, 1.05954267e-01f, 7.37875048e-03f, 1.56343177e-01f, 5.01427576e-02f, 2.46848047e-01f, 2.48893827e-01f, 7.98301101e-02f, 5.29942773e-02f, 1.73558742e-01f,
  6.59687594e-02f, -1.53567195e-01f, 3.70785892e-02f, -8.37016106e-02f, -1.08153708e-01f, 1.19065724e-01f, -1.42818108e-01f, 1.84020819e-03f, 2.00555436e-02f, -1.43395737e-01f,
  -1.25105143e-01f, 3.67923155e-02f, -7.22561479e-02f, -1.01036066e-03f, -5.30876815e-02f, -2.84613203e-02f, 5.59623986e-02f, -8.27079341e-02f, -3.07584386e-02f, 4.58245538e-02f,
  2.57957913e-02f, 4.69482280e-02f, 8.06007236e-02f, 1.29285585e-02f, -1.72621291e-02f, 2.72732824e-02f, -8.38417932e-02f, -1.84691809e-02f, -8.80148336e-02f, -4.18671779e-02f,
  -2.13671885e-02f, 9.25253844e-04f, -3.45275439e-02f, 7.23533928e-02f, -3.52661684e-02f, -1.02111101e-01f, 1.46363840e-01f, 4.65150625e-02f, 2.21454874e-02f, 8.87520891e-03f,
  5.65626333e-03f, 2.70109065e-02f, 6.01596422e-02f, -3.51367779e-02f, 4.69143912e-02f, -1.70573201e-02f, 1.53709017e-02f, -8.25540498e-02f, -6.62341900e-03f, -5.96182309e-02f,
  -1.70303434e-02f, -6.14008904e-02f, -5.47150709e-02f, -4.68554460e-02f, 6.39730617e-02f, 1.05809622e-01f, 3.43646184e-02f, -6.06109239e-02f, 8.46405253e-02f, -8.06667283e-02f,
  1.05971619e-01f, 3.77789699e-02f, -1.18169956e-01f, -9.37691703e-03f, 5.22900783e-02f, 2.87791379e-02f, 1.63039602e-02f, 4.82294671e-02f, 1.84145719e-02f, -1.35701150e-01f,
  2.14854591e-02f, 2.81033874e-01f, -4.20334525e-02f, -2.01117426e-01f, 3.27778533e-02f, -6.52447864e-02f, 7.63717294e-02f, 8.15237872e-03f, 4.05674651e-02f, 6.80547208e-02f,
  2.60561891e-02f, -6.50497973e-02f, 5.93283400e-02f, -2.29134224e-02f, -3.19988467e-02f, 9.34885349e-03f, 2.14389376e-02f, 4.25276272e-02f, -4.03531976e-02f, -1.12381214e-02f,
  -1.28118828e-01f, 3.36136259e-02f, -5.51676862e-02f, -8.03237408e-02f, -8.43542963e-02f, -7.99929053e-02f, 3.91657390e-02f, -8.05174857e-02f, -1.25398710e-01f, 7.68221691e-02f,
  -1.15214691e-01f, 9.55704674e-02f, 2.13955119e-01f, -3.35019052e-01f, -2.00287655e-01f, 1.82341576e-01f, -1.60450906e-01f, 1.31154120e-01f, -2.85735317e-02f, 4.68545295e-02f,
  -1.29812807e-01f, 8.04717317e-02f, 1.86702199e-02f, -2.24885240e-01f, 3.48437913e-02f, 5.96519932e-02f, -1.46090746e-01f, -1.46293953e-01f, -1.46494135e-01f, -1.46286294e-01f,
  -1.38845742e-01f, -3.09117019e-01f, -4.71036322e-02f, -9.87202972e-02f, -1.77388012e-01f, 8.14219341e-02f, -2.23572627e-01f, -2.34407619e-01f, -1.12268873e-01f, -1.45189673e-01f,
  3.18722539e-02f, -1.54971138e-01f, 1.41958416e-01f, 2.03943387e-01f, -6.63827080e-03f, 3.43845296e-03f, 5.64470068e-02f, 9.69505236e-02f, -1.18564077e-01f, 2.34381538e-02f,
  9.19142291e-02f, 8.70308056e-02f, 7.50348251e-03f, -1.22582287e-01f, -1.05688624e-01f, -6.37211502e-02f, 4.66265604e-02f, 1.87987953e-01f, 2.95980841e-01f, -4.37691845e-02f,
  -3.01307831e-02f, 1.26091331e-01f, -4.17653657e-02f, 2.68869027e-02f, 6.85859248e-02f, 5.11007085e-02f, 5.40041514e-02f, -1.77350547e-03f, 5.90874366e-02f, 1.09476941e-02f,
  -4.85000685e-02f, -1.27868271e-02f, 9.58548784e-02f, -1.91063229e-02f, -1.22100994e-01f, -2.92913951e-02f, -9.15592909e-02f, -1.26113012e-01f, 3.34705077e-02f, 3.57548073e-02f,
  7.42738023e-02f, 9.09841955e-02f, -1.12542644e-01f, -7.53829330e-02f, -5.14605977e-02f, 3.39414775e-02f, 1.40886188e-01f, 4.47797813e-02f, -8.67451727e-02f, 1.74943984e-01f,
  -5.48443012e-02f, 1.42506622e-02f, -8.68538618e-02f, -1.25388622e-01f, 9.85548273e-02f, -4.57937689e-03f, 8.51549432e-02f, 9.36447158e-02f, 3.27829495e-02f, -4.19327132e-02f,
  2.58721467e-02f, 4.37724181e-02f, 1.32816896e-01f, 8.02532732e-02f, 5.03927246e-02f, -6.90132333e-03f, 2.49761399e-02f, 1.30840495e-01f, 1.51027348e-02f, 4.54989076e-02f,
  1.66738331e-02f, 9.56380740e-02f, 2.87560876e-02f, -1.38361901e-01f, -2.78134272e-02f, 1.28081053e-01f, -5.39101139e-02f, 1.67688742e-01f, 1.36041462e-01f, 3.01304292e-02f,
  3.80771264e-04f, 2.01268196e-02f, -5.20683685e-03f, 6.71413541e-02f, 5.98852299e-02f, 5.89862652e-02f, -5.54161258e-02f, 4.69717942e-03f, -6.95634559e-02f, -5.93235600e-05f,
  3.84891421e-01f, 1.45898536e-01f, 6.47623325e-03f, 8.92553106e-02f, -4.28095870e-02f, 9.60437655e-02f, -1.89625278e-01f, 1.84152778e-02f, -2.25099459e-01f, -3.56930345e-02f,
  -1.35073006e-01f, 1.26084864e-01f, -2.75796533e-01f, 3.73657584e-01f, 1.93851694e-01f, -2.78251231e-01f, 3.22861850e-01f, 6.02012500e-02f, -4.78904285e-02f, 1.70416012e-01f,
  7.92329833e-02f, 3.15493941e-01f, 5.90220354e-02f, 2.33060971e-01f, 2.42916092e-01f, -6.92963740e-03f, 6.25372902e-02f, -2.47473553e-01f, 2.06413820e-01f, 8.40089321e-02f,
  7.80004337e-02f, 7.91454762e-02f, 1.13981314e-01f, -2.07008626e-02f, -3.62042859e-02f, 7.36759678e-02f, 1.19314238e-01f, 7.84408767e-03f, -1.08132124e-01f, -5.33339046e-02f,
  1.59881711e-01f, 2.97535546e-02f, 7.24155083e-02f, 9.05892774e-02f, 4.64388058e-02f, 1.04157478e-02f, 1.64968073e-02f, -4.23440300e-02f, 4.71610464e-02f, 1.33421376e-01f,
  1.62094422e-02f, 3.53175215e-02f, 5.42241856e-02f, -4.19391915e-02f, -1.00461751e-01f, -8.21777359e-02f, -1.18232742e-02f, -1.93570629e-02f, 1.31553458e-02f, 4.47683185e-02f,
  1.24407396e-01f, 5.75076640e-02f, -7.56268352e-02f, -2.00231560e-02f, -4.63788360e-02f, -1.63381681e-01f, 1.38144463e-01f, 6.21112436e-02f, -1.89118013e-02f, 9.23427287e-04f,
  -8.04696977e-02f, 7.84586743e-02f, -3.68107967e-02f, 2.10376475e-02f, 7.75129274e-02f, 6.31021559e-02f, -3.77902091e-02f, -3.39525193e-02f, -3.58905941e-02f, -7.55111650e-02f,
  6.57132966e-03f, -4.20898497e-02f, -1.05387330e-01f, 6.03836030e-02f, -5.11516780e-02f, -7.70275593e-02f, 3.13250460e-02f, 2.81274933e-02f, -1.20636255e-01f, 1.39183208e-01f,
  -4.43366244e-02f, -2.43401546e-02f, -1.06426381e-01f, -3.84637862e-02f, -7.00010583e-02f, 1.83179490e-02f, 1.00036122e-01f, 9.64916497e-02f, -2.01155003e-02f, -1.12787997e-02f,
  1.49979010e-01f, -8.03006962e-02f, -1.28148675e-01f, 5.24149761e-02f, 8.54858570e-03f, 3.43535841e-02f, 1.69130974e-02f, -1.95603862e-01f, -2.22986583e-02f, 4.21359167e-02f,
  5.50116703e-04f, -2.19407659e-02f, -1.61390584e-02f, -1.23409018e-01f, -5.96291013e-03f, -5.62339015e-02f, 5.76626323e-02f, 4.39009853e-02f, 2.03460902e-02f, -1.03439078e-01f,
  -3.69235247e-01f, -2.23980285e-02f, 1.73766613e-01f, 3.86769801e-01f, -1.15096390e-01f, -4.37634110e-01f, -2.33901560e-01f, -2.19738707e-01f, 6.38885796e-02f, -1.17042199e-01f,
  -6.72474429e-02f, 1.22506231e-01f, -2.16485083e-01f, 3.60119402e-01f, 2.00368732e-01f, 1.19231209e-01f, -1.98045466e-02f, -8.68202969e-02f, -4.57635745e-02f, -8.53783190e-02f,
  2.09811643e-01f, 2.15084210e-01f, 1.42337382e-01f, 1.06897123e-01f, 2.83138733e-02f, 2.03482524e-01f, 3.43195736e-01f, 3.01897109e-01f, 3.89280260e-01f, 1.45232111e-01f,
  -2.27932394e-01f, 1.03662960e-01f, 1.20443199e-02f, -1.68983191e-01f, -9.33887884e-02f, -2.21579030e-01f, -1.26482975e-02f, 4.55040745e-02f, 1.57462180e-01f, 3.38744409e-02f,
  -9.98786613e-02f, -1.96872819e-02f, 1.19020119e-01f, 9.03728306e-02f, -7.50061497e-02f, 1.12186521e-01f, 2.13738084e-02f, -2.69214272e-01f, -1.37005337e-02f, -8.19203854e-02f,
  -6.95621967e-02f, 2.18653642e-02f, -6.92388788e-02f, 8.85710195e-02f, 3.25550474e-02f, -1.04178578e-01f, 1.43229794e-02f, -1.74055006e-02f, 2.28347853e-02f, 1.21539466e-01f,
  5.36513589e-02f, 1.44588560e-01f, 4.28529866e-02f, 1.20697938e-01f, -3.60224210e-03f, 5.01931133e-03f, 5.70680909e-02f, -3.53449024e-02f, 5.44457026e-02f, -3.79016064e-02f,
  3.33769037e-03f, -1.26265317e-01f, 3.83230187e-02f, -6.07281178e-02f, 4.10053693e-02f, 2.61601079e-02f, 9.25879031e-02f, 5.23958392e-02f, -1.39282063e-01f, -5.66173717e-02f,
  1.32755622e-01f, -2.64159217e-03f, -7.77313113e-02f, -1.13934591e-01f, -1.97954789e-01f, 4.85211350e-02f, -8.50254223e-02f, 4.62766849e-02f, 2.11493531e-03f, -3.75866480e-02f,
  -2.03567848e-01f, 2.50546277e-01f, 7.39697739e-02f, -2.05208927e-01f, 1.00558296e-01f, -1.46147355e-01f, 9.89519432e-02f, -3.22164111e-02f, 1.23775385e-01f, -2.89160516e-02f,
  -7.05134273e-02f, -1.32135004e-01f, -9.91172418e-02f, 1.80758201e-02f, -2.00153291e-02f, -2.60572620e-02f, 5.24424650e-02f, -9.06652138e-02f, 1.05443202e-01f, -2.83143879e-03f,
  -4.05285917e-02f, -1.88664589e-02f, 4.84975986e-02f, -1.42544910e-01f, -1.54457642e-02f, -4.85126339e-02f, -5.08867987e-02f, 2.57772841e-02f, 8.36935416e-02f, -7.18218684e-02f,
  2.55430251e-01f, -3.46025497e-01f, 4.81005833e-02f, 2.34328926e-01f, 2.11854562e-01f, -1.87722653e-01f, -1.26999570e-02f, -7.56658092e-02f, 2.96708852e-01f, -2.77494699e-01f,
  8.98689330e-02f, 5.42703569e-02f, 7.56738260e-02f, -1.86820462e-01f, 2.65863091e-01f, 4.12394889e-02f, -1.79271981e-01f, -1.00725815e-01f, 8.97256956e-02f, -6.68460578e-02f,
  1.58331826e-01f, -1.05741821e-01f, 2.22108793e-02f, -2.56432235e-01f, -1.23596508e-02f, -3.15464176e-02f, 1.04379341e-01f, -7.12283552e-02f, -2.16679499e-01f, 5.56359999e-02f,
  -1.28303364e-01f, -2.40883119e-02f, -1.02066062e-01f, -9.84217972e-02f, -4.58926558e-02f, 3.36765163e-02f, 1.45898297e-01f, 8.57353732e-02f, -1.66840237e-02f, -4.86066379e-02f,
  4.00535902e-03f, -4.22194563e-02f, -1.17280848e-01f, 6.90916851e-02f, -1.93708204e-02f, -9.03956294e-02f, 1.23167979e-02f, 1.98207144e-02f, 3.27351764e-02f, 3.45707051e-02f,
  2.99618207e-02f, 2.19206214e-02f, 4.70188819e-02f, 3.08501534e-03f, 1.35390833e-01f, 7.19183758e-02f, 3.36773880e-02f, 3.31400447e-02f, -9.64006484e-02f, 4.27153297e-02f,
  4.99658212e-02f, 1.11291064e-02f, 6.26573488e-02f, -3.60781848e-02f, -8.24727565e-02f, 5.29755317e-02f, -4.74415012e-02f, -3.99555005e-02f, 2.81117521e-02f, 4.31851298e-03f,
  -1.10730588e-01f, 3.40345092e-02f, -5.67786358e-02f, -4.87372242e-02f, -7.98610412e-03f, 8.41175541e-02f, -5.48961982e-02f, -5.64372875e-02f, 6.03805631e-02f, 1.13092670e-02f,
  -1.54026961e-02f, -4.51497212e-02f, -5.93159609e-02f, 3.75533998e-02f, -1.36887459e-02f, 3.47847268e-02f, -1.77252721e-02f, -3.72281522e-02f, 9.78732631e-02f, -2.92586572e-02f,
  -3.65021646e-01f, -4.38439280e-01f, -6.13203906e-02f, -4.25217636e-02f, -9.42519456e-02f, 1.20303985e-02f, 1.26119748e-01f, 8.36631879e-02f, -1.46779597e-01f, 9.77341365e-03f,
  -7.65433982e-02f, -3.74355959e-03f, -3.16294432e-02f, 9.82742831e-02f, -5.76101094e-02f, 5.49146459e-02f, 1.86989158e-02f, -3.91237698e-02f, -2.95383297e-02f, -8.83858874e-02f,
  9.11526848e-03f, -4.10846323e-02f, 4.31903936e-02f, 4.18140404e-02f, 7.75453001e-02f, 6.49233311e-02f, 1.06148399e-01f, -7.85574969e-03f, 3.18874530e-02f, -4.69684042e-03f,
  2.11420581e-01f, 1.70646250e-01f, 1.04215123e-01f, 3.21473807e-01f, 1.41311325e-02f, -2.90944666e-01f, -2.19896972e-01f, 8.06852207e-02f, 2.17468426e-01f, -2.01621115e-01f,
  -1.44211203e-01f, 1.63871884e-01f, -2.72190630e-01f, 1.49316177e-01f, 1.77864328e-01f, -1.56142175e-01f, 2.37688199e-01f, 5.49276210e-02f, 1.45375133e-01f, 1.74036324e-01f,
  2.58776069e-01f, -7.96385184e-02f, 1.62455514e-01f, 9.52330753e-02f, 1.32679299e-01f, 2.88844407e-01f, 1.86382458e-01f, 5.88641390e-02f, -5.33375936e-03f, -3.84496190e-02f,
  -4.56594676e-02f, 8.59140232e-02f, -5.00096232e-02f, -9.82303265e-03f, 2.07043700e-02f, -1.32477984e-01f, -2.35247970e-01f, -1.90922245e-01f, -3.43470983e-02f, -1.23626739e-01f,
  -1.85415447e-02f, -1.95541922e-02f, 1.31306564e-02f, -1.03461500e-02f, 1.35348246e-01f, 1.13654658e-01f, 9.22415406e-02f, -2.29235739e-02f, -1.23900059e-03f, 3.05838063e-02f,
  1.33185387e-01f, 6.63277805e-02f, 1.04419611e-01f, 2.20176335e-02f, 3.84032913e-03f, 1.97114751e-01f, -3.71867768e-03f, -5.27327135e-03f, 7.52666965e-02f, 9.90737155e-02f,
  -7.11304396e-02f, -3.53106447e-02f, 7.45201809e-03f, 4.30718660e-02f, 1.72111422e-01f, 6.05510436e-02f, 3.11711263e-02f, -8.65026861e-02f, 5.60453348e-02f, -4.63694474e-03f,
  8.75768736e-02f, 5.63201122e-02f, 8.31129700e-02f, 7.06254095e-02f, -1.59957036e-02f, 9.53116491e-02f, -1.05581656e-01f, -1.43130556e-01f, 9.59791243e-02f, 8.02656487e-02f,
  -1.68484569e-01f, -7.00339377e-02f, 1.36354640e-01f, 6.08763322e-02f, -6.20429814e-02f, 5.99071160e-02f, -1.27057031e-01f, -4.37299982e-02f, 5.55571467e-02f, 6.39602318e-02f,
  -1.95102766e-02f, 2.48171315e-02f, -8.99369642e-02f, -1.35466978e-01f, -2.17749309e-02f, 4.74945977e-02f, -1.41060650e-01f, 1.67836528e-02f, -4.12596297e-03f, -6.09343722e-02f,
  6.55994341e-02f, -1.21112503e-01f, 8.09208080e-02f, 3.52838151e-02f, 1.96885727e-02f, 1.86664850e-01f, -1.03098355e-01f, 5.72250076e-02f, -9.90150217e-03f, 2.23305542e-03f,
  -2.91339383e-02f, 4.67577018e-03f, 4.22057025e-02f, 2.52550006e-01f, -4.94798310e-02f, -9.24958512e-02f, 5.92186637e-02f, 7.02915937e-02f, -1.97910853e-02f, 4.70667928e-02f,
  -3.79618816e-02f, -4.76585865e-01f, -5.04508466e-02f, 4.11413431e-01f, 6.62429407e-02f, -2.02372253e-01f, -2.17983201e-01f, 1.33229792e-02f, 1.73423558e-01f, -2.40080103e-01f,
  1.50603414e-01f, -2.76948422e-01f, -2.94141263e-01f, 2.23925337e-01f, -3.33555751e-02f, 4.76157898e-03f, 5.97291254e-02f, -3.71743962e-02f, 1.45164225e-03f, -1.94148347e-02f,
  1.60122499e-01f, 1.79614350e-01f, -1.29641984e-02f, 8.87655616e-02f, 2.78940219e-02f, 1.09792016e-01f, -2.19948925e-02f, -1.19650923e-01f, 2.36106262e-01f, 6.08222894e-02f,
  -1.03471786e-01f, 8.07161033e-02f, -7.16756731e-02f, -5.43260649e-02f, -1.27462111e-02f, -9.41363424e-02f, -4.12996449e-02f, -1.42113522e-01f, 9.52418968e-02f, 6.02353178e-02f,
  -9.63068232e-02f, 5.18309139e-02f, 1.40978932e-01f, 3.56022045e-02f, -4.46527824e-02f, 3.15260626e-02f, 2.35822722e-02f, 3.48369009e-03f, -7.70290429e-03f, -5.30606359e-02f,
  -1.70048736e-02f, -3.19595560e-02f, 1.30990893e-02f, -2.19337642e-02f, 1.48239331e-02f, 6.41965270e-02f, 6.76311776e-02f, -9.84078720e-02f, -1.48654291e-02f, 5.44728003e-02f,
  7.01937079e-02f, -3.16716880e-02f, 2.24307980e-02f, -3.96777429e-02f, 4.39069271e-02f, 3.29332575e-02f, 3.04612480e-02f, 2.17173062e-03f, -9.13386866e-02f, -1.30378604e-01f,
  -6.08412996e-02f, 7.87981302e-02f, 2.68344153e-02f, -5.25730662e-02f, 1.17772937e-01f, 4.37969528e-02f, -2.59622596e-02f, 2.63319965e-02f, 9.74448696e-02f, 4.38998081e-03f,
  -7.52689242e-02f, -3.81943025e-02f, -1.05671473e-01f, -2.45104395e-02f, -6.17395863e-02f, -4.97691669e-02f, 2.10139547e-02f, 1.36898197e-02f, -2.27838382e-02f, 4.81610559e-02f,
  -4.37984407e-01f, -3.58205497e-01f, -6.00366406e-02f, 5.02710827e-02f, -3.03121004e-02f, -4.61219847e-02f, -8.53453577e-03f, -4.79365140e-02f, -4.88065593e-02f, 9.52307507e-02f,
  1.08815059e-02f, 8.62879306e-02f, 3.76755632e-02f, 1.28293812e-01f, 5.30623309e-02f, -1.30035318e-02f, 5.99311711e-03f, -5.88028766e-02f, -5.90904690e-02f, 3.07678767e-02f,
  -1.58748068e-02f, -6.32556155e-03f, -1.35740526e-02f, 5.03448769e-02f, 7.89283663e-02f, -8.09689835e-02f, 2.17503738e-02f, -9.60670528e-04f, 1.71538386e-02f, -6.37928918e-02f,
  1.44924447e-01f, 1.36662006e-01f, -5.37212044e-02f, 9.15671587e-02f, 1.39647424e-01f, -1.73616484e-01f, 2.45524243e-01f, 3.68942060e-02f, 1.17523327e-01f, 1.89545333e-01f,
  -2.01913700e-01f, 3.24202469e-03f, 4.05624276e-03f, -2.58818120e-01f, -4.78081942e-01f, -3.97319406e-01f, -2.55329072e-01f, -1.54195338e-01f, -5.93023598e-02f, 7.94265345e-02f,
  -3.15394066e-02f, -1.08168684e-01f, 3.56948981e-03f, 5.55650070e-02f, 2.31529891e-01f, 2.87814945e-01f, 6.93183299e-03f, 2.13347465e-01f, -3.47361974e-02f, -1.20635204e-01f,
  3.13615873e-02f, 1.15630262e-01f, 1.84578270e-01f, 1.34473536e-02f, 2.37863194e-02f, 2.02930987e-01f, 1.29847497e-01f, 3.05529349e-02f, 3.85474823e-02f, -5.00904657e-02f,
  -2.02665590e-02f, 5.42187691e-02f, -2.04909533e-01f, -5.22067770e-02f, 1.48707688e-01f, 7.89040178e-02f, -7.81948026e-03f, 3.89885493e-02f, 8.13398585e-02f, -1.09073929e-02f,
  1.35314196e-01f, -4.10027914e-02f, 6.84574395e-02f, -4.17668894e-02f, -8.10881630e-02f, 3.81119438e-02f, -6.83869272e-02f, -1.28258783e-02f, -5.71778219e-04f, 5.60035296e-02f,
  3.94804813e-02f, -1.22956764e-02f, 2.74087600e-02f, -8.26558005e-03f, -4.56064455e-02f, 8.12098235e-02f, -5.89424334e-02f, -9.45584401e-02f, 1.21007592e-03f, -6.59012422e-02f,
  -4.94222566e-02f, 3.59854288e-02f, -8.26534182e-02f, 1.49294846e-02f, 3.71546224e-02f, 1.42284036e-01f, 5.16841561e-02f, -1.01301871e-01f, -5.58159836e-02f, 1.82284657e-02f,
  7.42133930e-02f, 2.33422890e-02f, 1.00998972e-02f, 7.35810399e-02f, -1.96868982e-02f, -2.98958868e-02f, -6.68479204e-02f, -6.13623112e-02f, -1.99874211e-02f, -1.05341636e-01f,
  -1.42433941e-01f, -9.08021852e-02f, 5.92386387e-02f, 1.85883529e-02f, 2.56558377e-02f, -8.06959160e-03f, 3.17816511e-02f, -8.12407732e-02f, -8.95759314e-02f, 2.23283679e-03f,
  3.24569345e-02f, 1.78212091e-01f, -8.07506889e-02f, -2.25944668e-02f, -9.57489833e-02f, -5.05357273e-02f, 1.54185183e-02f, -1.55755794e-02f, 1.01803668e-01f, -3.55859399e-02f,
  6.52332604e-02f, -4.82172519e-02f, 1.13995234e-02f, 8.32029879e-02f, 6.16159551e-02f, -8.64883140e-03f, 9.34915021e-02f, -2.40773801e-03f, 5.09426780e-02f, -1.88676585e-02f,
  -5.61085880e-01f, 2.20457390e-01f, 1.35124847e-01f, -1.78503171e-01f, -1.78283349e-01f, 1.88303337e-01f, 2.87399083e-01f, -4.24524695e-02f, -1.09639525e-01f, 1.97865903e-01f,
  -9.84048620e-02f, -9.68493894e-02f, 2.00787589e-01f, 6.56064451e-02f, -5.06118126e-03f, 2.74137765e-01f, 5.52478321e-02f, 2.47173347e-02f, -4.66525853e-02f, 3.73988482e-03f,
  1.18697956e-02f, 5.76136783e-02f, 1.54532447e-01f, 4.19863984e-02f, -1.93647429e-01f, -1.41044408e-01f, -7.59291649e-02f, 1.21647261e-01f, -5.43680415e-02f, -6.75515905e-02f,
  -1.90488249e-01f, -3.84859443e-01f, -4.95941378e-02f, 5.93519993e-02f, -1.56930506e-01f, -1.14095576e-01f, -4.33901101e-02f, 5.61220348e-02f, -4.85261679e-02f, 6.05216213e-02f,
  6.36187196e-02f, -5.62882237e-02f, -5.59228435e-02f, -3.46160717e-02f, 1.16237933e-02f, -4.00856286e-02f, 8.50275233e-02f, 9.99942049e-03f, 5.99376485e-02f, 6.68240385e-03f,
  1.38882756e-01f, 3.09009403e-02f, -7.19634220e-02f, 1.39090428e-02f, -3.97103140e-03f, -9.17999595e-02f, 3.27184796e-02f, 4.33271788e-02f, -6.80445731e-02f, -1.09517060e-01f,
  -2.07576528e-02f, -2.81082094e-03f, 1.36178374e-01f, 1.19470395e-01f, 1.48656011e-01f, -1.01201944e-01f, 1.12461828e-01f, 4.52620164e-02f, 2.96057165e-02f, 1.08550981e-01f,
  -8.87501538e-02f, -1.73588395e-01f, -2.03711346e-01f, 4.97118644e-02f, 7.35628605e-02f, 2.74159070e-02f, 3.53357755e-02f, -7.66322985e-02f, -2.18476858e-02f, -4.36416455e-02f,
  1.16202094e-01f, -1.47708552e-02f, -1.40744030e-01f, 8.19076726e-04f, -1.75597717e-03f, 9.17933211e-02f, -6.71851784e-02f, -1.09887555e-01f, -7.62293786e-02f, -5.85401766e-02f,
  -2.32765406e-01f, -2.05503553e-01f, 5.56587009e-03f, -1.16558805e-01f, -9.56242904e-02f, -6.25692308e-02f, 5.73703507e-03f, -6.99496083e-03f, -5.18911742e-02f, 2.11779848e-02f,
  2.53313817e-02f, -1.22984283e-01f, 3.12882997e-02f, 1.62544399e-02f, 5.24341986e-02f, 1.17840422e-02f, 1.23821966e-01f, -5.41457646e-02f, 6.64244816e-02f, -4.31669317e-02f,
  3.28844376e-02f, -2.70255283e-02f, -8.54965225e-02f, -8.83104354e-02f, -1.52863055e-01f, -9.59659927e-03f, -1.10818505e-01f, 1.90420239e-03f, -1.40651941e-01f, -7.12846890e-02f,
  2.31424436e-01f, 2.95328617e-01f, 2.90899724e-01f, 4.28467184e-01f, -5.90608343e-02f, -2.98898101e-01f, -1.18768148e-01f, 1.24970056e-01f, 3.20697159e-01f, -2.45915130e-02f,
  -1.87810540e-01f, 2.95978844e-01f, -7.70209879e-02f, 8.31905603e-02f, -1.81903288e-01f, -2.41861492e-01f, 6.97266981e-02f, 5.02438769e-02f, 5.02441004e-02f, 1.77514151e-01f,
  2.24297464e-01f, -1.26908883e-01f, 1.55093879e-01f, -1.70266002e-01f, 2.38154918e-01f, 2.58814871e-01f, 9.16478597e-03f, -8.04890990e-02f, 1.88663289e-01f, -2.11123019e-01f,
  -3.02252211e-02f, 8.73492509e-02f, 5.73989563e-02f, 8.25317204e-03f, 8.41670036e-02f, -1.08092111e-02f, -2.50086486e-02f, -1.35568798e-01f, -5.78940175e-02f, -1.67889353e-02f,
  1.41786292e-01f, 2.44288333e-02f, 4.08184789e-02f, -8.95335376e-02f, -3.29761282e-02f, 7.88991973e-02f, 1.27121300e-01f, 9.63087901e-02f, 5.15376180e-02f, 1.24977678e-01f,
  1.05714954e-01f, 7.87266046e-02f, 9.83302891e-02f, -2.63543352e-02f, 1.08405963e-01f, 4.01136465e-02f, 1.97859518e-02f, 9.39761251e-02f, 8.30668584e-02f, 3.81357148e-02f,
  7.80248195e-02f, 3.24095376e-02f, -4.91515994e-02f, -1.60663184e-02f, -4.45586927e-02f, -5.78520000e-02f, -1.87588707e-02f, -1.17989153e-01f, -1.67728178e-02f, -1.14990938e-02f,
  -8.91016573e-02f, 8.91488045e-02f, -7.63581395e-02f, 3.49543281e-02f, 8.73897672e-02f, 7.31461793e-02f, -6.61176071e-02f, -2.21196841e-03f, 1.25981927e-01f, 2.25254651e-02f,
  -5.69576584e-02f, -1.01682104e-01f, 4.49069105e-02f, -2.12490316e-02f, -1.74195483e-01f, 5.62952645e-02f, 8.52908716e-02f, 7.99893681e-03f, 2.15573534e-02f, 3.53772044e-02f,
  -3.23053561e-02f, 7.26748705e-02f, 9.32091996e-02f, -3.69355306e-02f, -1.23153571e-02f, 3.02591901e-02f, -8.07990506e-02f, 5.45381680e-02f, 1.97890792e-02f, -7.99220428e-02f,
  1.24944329e-01f, -1.06198620e-02f, -4.92602959e-02f, -8.38487875e-03f, -3.13430913e-02f, 9.10958424e-02f, 3.06247864e-02f, -5.17120734e-02f, -2.56854463e-02f, 1.76775560e-01f,
  3.83230448e-02f, 3.98703068e-02f, 3.40948068e-02f, 7.00740665e-02f, 3.09398361e-02f, 4.42748293e-02f, -8.74341354e-02f, 6.50664344e-02f, -1.01829628e-02f, -4.99799252e-02f,
  -2.37963900e-01f, 3.99696380e-02f, -1.64745197e-01f, -1.40268207e-01f, 1.58958659e-01f, 4.23406452e-01f, -1.86960083e-02f, -1.28629252e-01f, -2.64956862e-01f, -1.32320032e-01f,
  -7.47174919e-02f, -5.70212379e-02f, -1.90666586e-01f, 8.77889395e-02f, 2.58467317e-01f, 6.90160394e-02f, 8.41819569e-02f, 7.07061365e-02f, 2.14034170e-01f, -1.47922635e-02f,
  1.21590123e-01f, 2.55118817e-01f, 6.65439367e-02f, 2.34805301e-01f, 1.05468534e-01f, -1.03788003e-01f, -6.83596432e-02f, 7.03575462e-03f, 1.80908382e-01f, 1.44180089e-01f,
  1.12075452e-03f, -3.13020557e-01f, -1.05210140e-01f, -3.84347956e-03f, -2.02322542e-03f, -1.77151546e-01f, -4.83840611e-03f, 3.45169455e-02f, -8.71970803e-02f, 7.66250491e-02f,
  -1.03374138e-01f, 2.08908301e-02f, -3.12136598e-02f, -1.20734856e-01f, 7.54703349e-03f, 5.53119630e-02f, 1.32649511e-01f, -5.68041131e-02f, 4.63147983e-02f, -4.83438708e-02f,
  -1.20791225e-02f, 3.35712880e-02f, 1.90883595e-02f, 9.71137211e-02f, 1.40394509e-01f, 1.03696197e-01f, 2.04205085e-02f, -3.35938372e-02f, 1.13880292e-01f, 1.49090335e-01f,
  3.74335051e-02f, -4.63105068e-02f, 9.63228696e-04f, 1.41148046e-02f, -7.50554493e-03f, 7.06792925e-04f, 5.99764474e-02f, 1.27789564e-03f, 1.02529213e-01f, 1.40138358e-01f,
  -3.96889187e-02f, -7.04032257e-02f, -9.42980573e-02f, -1.60389449e-02f, 1.31995613e-02f, -1.50307551e-01f, -1.37245893e-01f, -3.56011256e-03f, -3.36997695e-02f, 7.87362233e-02f,
  -1.12857975e-01f, 9.63618141e-03f, 4.28035073e-02f, 6.95317164e-02f, -3.46962847e-02f, 6.64041415e-02f, 3.25301997e-02f, 5.39329872e-02f, -3.84066179e-02f, 7.29225948e-02f,
  8.17640498e-02f, -7.71714374e-02f, 7.87333474e-02f, 1.24045990e-01f, -2.46478040e-02f, 8.49117152e-03f, 8.52662921e-02f, 9.99204516e-02f, 8.26378446e-03f, 7.96744749e-02f,
  -1.31469756e-01f, -3.93728204e-02f, -8.13231468e-02f, -7.00248480e-02f, 7.61039183e-02f, 6.14336655e-02f, 5.46404645e-02f, 3.14649008e-02f, 7.15119243e-02f, -3.53024341e-02f,
  7.58315623e-03f, -1.19515015e-02f, 6.43381625e-02f, 1.74435511e-01f, 3.71652059e-02f, 1.05464095e-02f, -5.96588962e-02f, -1.36785395e-03f, 1.45583972e-01f, 4.39334176e-02f,
  2.92846411e-01f, -1.00053355e-01f, 2.92719185e-01f, 1.50016472e-01f, 2.00219050e-01f, 1.76785365e-02f, 1.42637819e-01f, 9.40452218e-02f, 7.54249245e-02f, -2.19655350e-01f,
  -7.35176131e-02f, 1.76947653e-01f, 1.51687274e-02f, -1.12580150e-01f, 1.22338600e-01f, 4.68884930e-02f, -1.16886735e-01f, -1.67705849e-01f, 5.44006415e-02f, -8.32250640e-02f,
  -1.69280712e-02f, -2.63746887e-01f, 1.76864535e-01f, -2.29125738e-01f, 1.39506394e-03f, -7.14721233e-02f, -1.23073965e-01f, 8.72011483e-03f, -1.24859288e-01f, 1.59443449e-02f,
  -8.00674632e-02f, 1.69849824e-02f, 8.21035057e-02f, 6.86682314e-02f, 4.40527759e-02f, -3.43043171e-02f, 8.02017748e-02f, 3.38293351e-02f, 6.88807480e-03f, 8.64594418e-04f,
  9.33353379e-02f, 1.96135766e-03f, -1.87486142e-01f, -1.67717025e-01f, 6.46622945e-03f, 1.71658546e-02f, 1.28150836e-01f, 8.60144794e-02f, 1.82968348e-01f, 7.32361674e-02f,
  -6.81473780e-03f, 4.54902910e-02f, -9.75147728e-03f, -4.43657003e-02f, 8.24368000e-02f, -3.89704965e-02f, -9.43057705e-03f, 9.25499573e-02f, -3.74240465e-02f, -4.77676317e-02f,
  1.90038551e-02f, 1.97941735e-02f, 6.50749430e-02f, -3.58149409e-03f, 4.54055518e-02f, -1.04229897e-01f, -5.58146387e-02f, 1.85589597e-03f, 7.24243522e-02f, 6.63405284e-02f,
  2.16428749e-02f, 6.25272393e-02f, 8.18880275e-02f, -5.66063039e-02f, -9.42770112e-03f, 1.90654192e-02f, 3.03535778e-02f, -4.69212867e-02f, 4.88722743e-03f, -4.86332877e-03f,
  -4.39570323e-02f, -8.26340690e-02f, -2.25742068e-02f, 6.39837384e-02f, -6.37995005e-02f, 2.98050754e-02f, -5.54733090e-02f, 8.84714425e-02f, 4.40475605e-02f, -9.78165679e-03f,
  -3.04980963e-01f, -3.16618413e-01f, 7.98173621e-02f, -3.06995958e-02f, -7.68579990e-02f, -2.86477506e-02f, -2.37036720e-02f, -2.74179634e-02f, -1.21897645e-02f, 3.31400521e-02f,
  -2.29767337e-02f, 4.47872467e-02f, -9.05199051e-02f, -1.05695486e-01f, -8.06743205e-02f, -1.34600773e-01f, 4.68787625e-02f, -1.85213760e-02f, 7.80375153e-02f, -9.85942930e-02f,
  -4.65090685e-02f, -5.95759340e-02f, -6.82185963e-02f, -3.86845693e-02f, 2.93089282e-02f, 3.46686319e-02f, -5.53080551e-02f, 4.12879921e-02f, -9.31101888e-02f, -1.15594730e-01f,
  -1.63097993e-01f, -1.13214618e-02f, 1.76730052e-01f, -1.09931126e-01f, 1.73357893e-02f, -1.01490110e-01f, -2.49408886e-01f, 9.71269608e-02f, -8.33155140e-02f, -1.69740647e-01f,
  -1.61737666e-01f, 1.92355867e-02f, 2.37709478e-01f, -4.46420982e-02f, 3.62032801e-01f, 1.95183158e-01f, 2.03213803e-02f, -2.63459943e-02f, 1.82878867e-01f, 1.34921595e-01f,
  1.38405338e-01f, -9.38425064e-02f, 4.35440242e-01f, 1.04492262e-01f, 1.46015212e-01f, 2.01281875e-01f, 2.38264531e-01f, 2.24964127e-01f, 1.33956224e-01f, 1.18472479e-01f,
  -1.76876336e-02f, -4.15734798e-02f, -2.88985185e-02f, -1.00129336e-01f, 1.08520947e-01f, 7.25837424e-02f, 5.89900352e-02f, 5.86727224e-02f, -2.80007385e-02f, 2.37952918e-02f,
  5.14503159e-02f, 9.71795991e-02f, -8.47971588e-02f, 4.20612097e-03f, -1.27598196e-01f, -1.36715725e-01f, 6.87329620e-02f, 1.22206084e-01f, 1.22872770e-01f, 1.68612935e-02f,
  1.27160788e-01f, -4.36719395e-02f, -9.70666930e-02f, 6.28177598e-02f, -2.15507429e-02f, -1.18666090e-01f, 9.59430449e-03f, 6.28897771e-02f, -6.40480593e-02f, -9.60708057e-05f,
  8.69287997e-02f, -6.23007156e-02f, -1.00928634e-01f, -1.19023593e-02f, -6.05368912e-02f, -1.40974075e-01f, -1.50759563e-01f, -3.73820588e-02f, -2.26277076e-02f, -1.39517888e-01f,
  -7.79693648e-02f, 4.99980338e-02f, -1.45040587e-01f, -1.95853859e-01f, 4.63709459e-02f, -1.43886968e-01f, -2.10246183e-02f, 1.59558192e-01f, 1.31110940e-02f, -9.64507461e-02f,
  -1.37571394e-01f, 1.16989668e-02f, -8.48569721e-02f, -4.52680700e-02f, -1.14596151e-01f, -9.47779883e-03f, -1.60392642e-01f, -6.48646578e-02f, 9.17843953e-02f, 1.20760597e-01f,
  8.38617906e-02f, 1.48675933e-01f, 6.40613586e-02f, -1.13951154e-01f, 6.62482949e-03f, 7.31148720e-02f, 1.13110710e-02f, -2.20976537e-03f, 4.90257926e-02f, 1.53898582e-01f,
  1.07318824e-02f, 1.96142178e-02f, -8.88039321e-02f, 1.83724575e-02f, 1.33881811e-02f, 5.26887178e-03f, 3.03250961e-02f, -4.64318879e-03f, 5.22428788e-02f, -1.50836213e-02f,
  -1.64174698e-02f, -1.28107131e-01f, -2.34923549e-02f, 7.13504627e-02f, -2.98818331e-02f, -7.44661763e-02f, -4.95653301e-02f, -1.69091485e-02f, 1.38062716e-01f, 6.30402789e-02f,
  -5.98429814e-02f, 3.37134361e-01f, 3.82865489e-01f, 1.32466167e-01f, 2.10064594e-02f, 3.35077286e-01f, 6.18258603e-02f, 2.64000982e-01f, 4.54009473e-01f, -7.80899003e-02f,
  -1.03089742e-01f, 2.25621480e-02f, -3.56653184e-02f, -4.41871118e-03f, -1.61751155e-02f, 1.58054814e-01f, 8.99713710e-02f, -1.09929867e-01f, 1.77952632e-01f, -3.24731581e-02f,
  4.01984639e-02f, -2.48266682e-01f, -1.43417448e-01f, -2.20365673e-01f, -1.02370672e-01f, 8.89766589e-02f, -3.67066413e-01f, 4.21296209e-02f, -9.23364311e-02f, 7.96220079e-02f,
  4.49305438e-02f, 1.78270712e-02f, -2.22073104e-02f, 1.47184908e-01f, 7.85060972e-02f, 6.36021653e-03f, 3.50151286e-02f, -5.59110418e-02f, 4.61008139e-02f, 2.34730784e-02f,
  -1.26695479e-04f, 3.66643555e-02f, 1.01310546e-02f, -7.01858103e-02f, 2.07849637e-01f, 1.05033197e-01f, 1.23743907e-01f, 5.83174452e-02f, 6.35271221e-02f, 1.25462055e-01f,
  1.20946264e-03f, 1.41380012e-01f, 9.11774039e-02f, 5.84147237e-02f, -2.04652380e-02f, 3.48242931e-02f, 9.16244164e-02f, 2.30772980e-02f, 1.68841705e-02f, 2.60418877e-02f,
  -4.26433235e-02f, 1.33298635e-01f, -6.96766302e-02f, 3.21481861e-02f, 3.98450866e-02f, -7.67866196e-03f, 7.46428147e-02f, -6.63748458e-02f, 1.35188783e-02f, -2.71210298e-02f,
  -3.25105265e-02f, 1.98410768e-02f, 1.93364412e-01f, 6.11594804e-02f, 2.09751204e-02f, 2.90945936e-02f, 2.70015672e-02f, 1.07451282e-01f, 7.49515742e-02f, -7.89746493e-02f,
  -1.12604387e-01f, -5.47882058e-02f, -1.62563428e-01f, 6.72916025e-02f, 2.84186434e-02f, 6.98939040e-02f, -1.00683486e-02f, 5.98585196e-02f, 2.34845448e-02f, -1.29698142e-01f,
  3.66173238e-02f, 4.38830554e-02f, -9.47222114e-02f, -4.68057916e-02f, -1.85168739e-02f, -8.55316818e-02f, 3.79429311e-02f, 2.16196757e-02f, 4.89452370e-02f, 5.27348323e-03f,
  8.57885480e-02f, -1.57073691e-01f, 7.13031217e-02f, -1.39865521e-02f, 1.85020436e-02f, -3.98228876e-02f, -3.50652114e-02f, -9.31760296e-03f, -8.42599496e-02f, 3.14596742e-02f,
  -1.14019021e-01f, -5.08921146e-02f, -1.02430306e-01f, -7.51815438e-02f, 1.42611645e-03f, -5.17470241e-02f, -2.55485848e-02f, -1.05620045e-02f, -6.50326163e-02f, -2.94245835e-02f,
  -4.77577686e-01f, 3.09018075e-01f, 2.71654636e-01f, 1.55419540e-02f, -1.86787501e-01f, 3.51673394e-01f, 2.65159488e-01f, 2.77594780e-03f, 2.40626544e-01f, 1.89156696e-01f,
  -1.47319704e-01f, -1.27738684e-01f, 5.30216098e-02f, 8.32898095e-02f, 1.36905566e-01f, 2.98768669e-01f, 2.26178870e-01f, 1.30662516e-01f, 3.61003354e-02f, -5.25931604e-02f,
  -9.21659023e-02f, -1.37256309e-01f, -1.52549138e-02f, -6.51782453e-02f, -2.23381311e-01f, -1.05779126e-01f, -2.35144272e-01f, 7.48707950e-02f, -4.11239639e-02f, 3.22428606e-02f,
  -9.34349746e-02f, -1.63347229e-01f, -1.95795849e-01f, 8.81330892e-02f, -8.05523654e-04f, -6.64498061e-02f, 2.09922753e-02f, -6.49282411e-02f, -5.21604642e-02f, 2.31500883e-02f,
  -1.14548139e-01f, 2.32910085e-02f, 1.11025814e-02f, 3.70214996e-03f, 5.13412505e-02f, 5.28432950e-02f, -1.31608415e-02f, 3.81796956e-02f, -1.25669956e-01f, -3.80390808e-02f,
  -1.51133100e-02f, 8.51114765e-02f, -1.63561255e-02f, 9.14161578e-02f, -9.14157853e-02f, -2.86548194e-02f, 1.31317869e-01f, 2.94763669e-02f, 6.24623187e-02f, -2.00355742e-02f,
  -2.34338883e-02f, 6.81593269e-02f, 3.94035913e-02f, 7.05637634e-02f, 3.89219597e-02f, -1.19918741e-01f, 1.79210715e-02f, -6.28461391e-02f, -2.68093385e-02f, -5.66194952e-02f,
  -2.08126418e-02f, -1.10056058e-01f, -4.15924378e-02f, 6.59473985e-02f, -9.17242747e-03f, 5.02660535e-02f, -3.80390510e-03f, -1.27047658e-01f, 4.95747030e-02f, -5.81288151e-02f,
  -4.92689526e-03f, 9.16074365e-02f, -2.56828405e-03f, -1.02437679e-02f, 5.09207323e-02f, 2.37073726e-03f, -1.17422886e-01f, -4.06625448e-03f, 7.99477622e-02f, -1.26310542e-01f,
  1.65390104e-01f, 2.60983616e-01f, -7.22282007e-02f, -1.41865134e-01f, 1.52896196e-02f, -7.12882436e-04f, -1.60348248e-02f, -9.02314261e-02f, 1.19720317e-01f, 8.22388101e-03f,
  -1.74042862e-02f, -1.62375551e-02f, 4.60508913e-02f, 5.54762855e-02f, 3.53561714e-02f, 1.07476629e-01f, -7.36686438e-02f, -3.90083827e-02f, -4.00333367e-02f, -7.92368501e-02f,
  -1.34858876e-01f, 1.88894030e-02f, -8.25432315e-02f, -6.50617778e-02f, -7.44738057e-02f, -7.58655220e-02f, -5.04102260e-02f, 2.30647940e-02f, -1.76610798e-02f, -2.85966089e-03f,
  1.81639031e-01f, -1.31439239e-01f, -3.26194108e-01f, -1.29671738e-01f, 1.58786476e-01f, 3.39833975e-01f, 2.88625568e-01f, -1.35614574e-01f, -2.22679645e-01f, 1.73501983e-01f,
  2.05653414e-01f, -1.95281133e-02f, 2.55861849e-01f, 8.51559937e-02f, 2.47239843e-01f, 4.10315208e-02f, 9.88101363e-02f, 9.75409523e-02f, -1.70835614e-01f, 1.39725998e-01f,
  3.19232829e-02f, 2.89332598e-01f, -2.19804551e-02f, -5.86344413e-02f, 2.38453045e-01f, -3.08117747e-01f, 2.70385474e-01f, 6.40427321e-02f, -4.80449460e-02f, 8.36024657e-02f,
  1.80272441e-02f, -4.86270525e-03f, -6.81843236e-02f, -8.54610577e-02f, 5.57315052e-02f, 1.35508493e-01f, 1.02297284e-01f, 7.49667287e-02f, -1.59902610e-02f, -1.82920136e-02f,
  2.09816918e-01f, -1.01038717e-01f, -1.51952272e-02f, 7.13663846e-02f, -4.20791022e-02f, -1.94201693e-02f, -8.59825537e-02f, -7.78326318e-02f, -2.31546275e-02f, 2.03288525e-01f,
  -2.74694711e-02f, -8.20182785e-02f, -6.47362843e-02f, -1.44281730e-01f, -1.06191799e-01f, -4.90409806e-02f, -2.57568117e-02f, 7.22114071e-02f, -1.32294605e-02f, 4.71617691e-02f,
  7.43294656e-02f, 1.33932918e-01f, 1.03886753e-01f, -6.45284429e-02f, -2.55835205e-02f, -6.54868856e-02f, 1.49581313e-01f, 5.69109246e-02f, -4.22846228e-02f, 8.24487135e-02f,
  -5.25995642e-02f, 2.97412314e-02f, 1.19204260e-01f, 3.37581262e-02f, 1.46718934e-01f, -3.47500993e-03f, 6.74174167e-03f, 4.30306494e-02f, -1.73656065e-02f, -1.12699792e-01f,
  -3.56481560e-02f, 1.78359379e-03f, 1.40807908e-02f, 6.08070381e-03f, -5.14868386e-02f, -6.24485724e-02f, 1.24950886e-01f, 1.20505497e-01f, -1.22811355e-01f, 6.13377318e-02f,
  5.37289605e-02f, 1.45438714e-02f, -5.33593856e-02f, -7.33828098e-02f, -3.38512883e-02f, 8.66066292e-02f, -2.01850794e-02f, -5.54349422e-02f, 2.14190818e-02f, 2.92226728e-02f,
  1.44210070e-01f, -3.58761176e-02f, -6.60048053e-02f, -2.20251549e-02f, -1.48513123e-01f, 1.36966467e-01f, 1.52969882e-01f, -1.19578905e-01f, 3.15878280e-02f, 5.97754009e-02f,
  -3.15975547e-02f, 2.65610684e-02f, -1.09615162e-01f, 8.78315512e-03f, -8.47370028e-02f, 6.35887012e-02f, 4.34672423e-02f, 5.72080687e-02f, 3.45163643e-02f, -2.56522298e-02f,
  -7.01116323e-02f, -1.70290526e-02f, 6.39918372e-02f, -2.21322328e-01f, 1.95411090e-02f, -4.34624851e-02f, -2.59530991e-01f, 1.27750531e-01f, -1.31226391e-01f, 1.08726233e-01f,
  -5.01330011e-02f, -2.31516719e-01f, 1.84667425e-03f, -2.03575134e-01f, -3.74756604e-02f, -7.35384375e-02f, -1.89060569e-01f, -2.71021754e-01f, -2.12050691e-01f, -1.15795746e-01f,
  -8.15851688e-02f, -2.10711539e-01f, -9.34057906e-02f, -2.39387974e-02f, -1.69772580e-01f, 7.03490973e-02f, 1.12256333e-01f, -1.26133189e-01f, 3.22469585e-02f, -9.04539078e-02f,
  -5.51025234e-02f, 3.46668027e-02f, 5.01090735e-02f, -5.89538105e-02f, 9.24530551e-02f, 7.90249705e-02f, 9.99382883e-03f, 2.72593386e-02f, 2.07346585e-02f, -2.41412297e-02f,
  -6.15985915e-02f, -4.68655769e-03f, -3.31407301e-02f, -7.82911777e-02f, -1.11197516e-01f, -7.82394037e-03f, -7.94123411e-02f, 3.92681956e-02f, -8.89617056e-02f, -2.38126740e-02f,
  -4.52054329e-02f, 3.16611342e-02f, 4.11420725e-02f, 3.45274694e-02f, -4.09569703e-02f, 3.72740586e-04f, 4.19137105e-02f, -2.39157006e-02f, 4.01530713e-02f, 1.42312393e-01f,
  8.13617557e-02f, -2.52673663e-02f, -3.72707248e-02f, -5.86339794e-02f, -2.60987896e-02f, 4.18809466e-02f, -5.06853499e-02f, 6.66387677e-02f, 2.84253266e-02f, -2.67707370e-02f,
  1.06513184e-02f, -2.66549569e-02f, -1.09964117e-01f, 5.08799367e-02f, 6.38857260e-02f, 5.15903383e-02f, -6.11294713e-03f, 4.06542197e-02f, -7.82083422e-02f, 4.11968753e-02f,
  -8.27462003e-02f, 4.39000223e-03f, -4.05351669e-02f, -5.94526865e-02f, -1.36104852e-01f, 1.25125712e-02f, -4.26966585e-02f, -2.49587297e-02f, 8.46192613e-02f, -1.11150175e-01f,
  8.93734694e-02f, 2.51057506e-01f, 7.24498183e-02f, -8.14348608e-02f, -6.02524355e-03f, 5.07703237e-02f, 9.21497419e-02f, 5.69008775e-02f, 4.15267311e-02f, 8.92909691e-02f,
  3.10447738e-02f, -5.61761893e-02f, 1.50338382e-01f, -4.44684401e-02f, -4.70818393e-02f, 5.47734462e-02f, -3.80153283e-02f, -2.52509937e-02f, 1.21480875e-01f, 6.93374798e-02f,
  -8.11290592e-02f, -5.24890330e-03f, 8.99081957e-03f, -4.32083756e-02f, 3.33003327e-02f, 3.34462598e-02f, 8.34413171e-02f, -4.03886400e-02f, -4.38690223e-02f, 9.05530751e-02f,
  -6.11831769e-02f, -2.11661801e-01f, 6.94708452e-02f, -2.71750242e-01f, 5.41024879e-02f, 6.21666685e-02f, -1.00698106e-01f, -4.13663499e-02f, -7.63249919e-02f, -2.82152206e-01f,
  -1.08311988e-01f, -8.16611275e-02f, 1.23646870e-01f, -3.43335479e-01f, 3.68173540e-01f, 1.46320060e-01f, -2.17929423e-01f, -1.79736882e-01f, -7.46108592e-02f, -2.17081398e-01f,
  -1.04964547e-01f, -4.04031724e-01f, 5.49332313e-02f, -3.40949744e-01f, -2.42907092e-01f, -4.91992682e-02f, -7.95676932e-02f, -6.00513443e-02f, -1.96868852e-01f, 6.50919080e-02f,
  1.07547283e-01f, -6.91530630e-02f, 4.09756079e-02f, 5.53885512e-02f, -6.88606054e-02f, 3.41769196e-02f, -1.17448963e-01f, 4.11023293e-03f, 1.11195646e-01f, 1.96270924e-02f,
  -1.94706142e-01f, 2.24749856e-02f, -5.45165241e-02f, 3.78727131e-02f, -1.56183884e-01f, -2.68172678e-02f, -4.99391370e-02f, 1.25094861e-01f, -3.84809040e-02f, 7.43237883e-02f,
  2.75586098e-02f, 3.96406576e-02f, 3.29768769e-02f, -7.26265833e-02f, -1.84829459e-02f, -1.93414255e-03f, 1.04122527e-01f, 4.41062748e-02f, 6.77786320e-02f, 7.53730237e-02f,
  -7.68241510e-02f, -3.33970189e-02f, -6.38287440e-02f, -5.09611368e-02f, 4.65241261e-02f, 5.48623726e-02f, -9.04522315e-02f, -6.25407472e-02f, -1.62497815e-02f, -4.83342856e-02f,
  -1.71737187e-02f, -6.21377900e-02f, -6.95274919e-02f, -1.83505099e-02f, -7.89878666e-02f, 5.05879819e-02f, 3.73567455e-02f, -5.68465739e-02f, -1.05716385e-01f, 8.50220919e-02f,
  -2.46954616e-02f, 2.83799078e-02f, -3.01720202e-02f, -1.38925239e-01f, -4.26945798e-02f, 5.67007400e-02f, -1.66245222e-01f, 2.66922526e-02f, 8.99453163e-02f, -8.89823064e-02f,
  3.34086195e-02f, -9.66523141e-02f, -2.78298501e-02f, 1.39010698e-03f, -1.73368882e-02f, -2.86375564e-02f, -8.13634247e-02f, -1.16198674e-01f, 6.96333945e-02f, -1.07849725e-02f,
  -1.56556502e-01f, -8.04570615e-02f, -2.01207809e-02f, 7.55838603e-02f, -2.04420071e-02f, -1.81855224e-02f, -1.48388550e-01f, 2.52853222e-02f, 3.98864783e-02f, 7.93216843e-03f,
  -5.54726971e-03f, -5.93806393e-02f, 5.66654373e-03f, -9.08601582e-02f, -1.42997086e-01f, -2.76240129e-02f, 8.39961395e-02f, -1.22262925e-01f, -1.01287745e-01f, 1.69231538e-02f,
  -1.19563751e-01f, 2.10060015e-01f, 2.32629888e-02f, 2.46866971e-01f, -2.58610904e-01f, 1.47299469e-01f, 2.97999978e-01f, -3.98084298e-02f, 8.46134201e-02f, 2.48427287e-01f,
  1.21193066e-01f, 1.08040117e-01f, 1.75609395e-01f, 2.72348940e-01f, -2.32059151e-01f, 2.87403643e-01f, 3.20121765e-01f, 2.13183641e-01f, 7.80710354e-02f, 3.70981917e-02f,
  -7.59692788e-02f, 8.98898989e-02f, 5.28780743e-02f, -1.30492762e-01f, -7.57120550e-02f, -1.20815858e-01f, -2.01404318e-01f, -1.51597872e-01f, 8.43186378e-02f, -1.66930825e-01f,
  1.54437423e-01f, -1.16283791e-02f, 1.31701166e-02f, 1.11934446e-01f, -2.21816212e-04f, -7.75777083e-03f, 1.15722284e-01f, -1.04380742e-01f, -5.06414175e-02f, 1.23705074e-01f,
  1.09142207e-01f, -1.56356301e-02f, -2.88662128e-02f, -1.87382087e-01f, 3.83044593e-02f, 2.53436016e-03f, 9.05089304e-02f, 1.36647433e-01f, 1.10800378e-01f, 7.41410628e-03f,
  1.21526554e-01f, -3.80793051e-03f, 9.67127681e-02f, 7.66781569e-02f, 4.40980075e-03f, 7.26431236e-02f, 6.75301114e-03f, 1.40928943e-02f, 1.75500624e-02f, -7.20770657e-02f,
  -1.20429590e-01f, 5.91174178e-02f, 6.03303798e-02f, 6.26056939e-02f, -1.13202065e-01f, -4.44349349e-02f, 4.11890857e-02f, 3.33363488e-02f, 3.34804831e-03f, 1.03489580e-02f,
  2.52592210e-02f, 2.00189762e-02f, 4.38751988e-02f, -7.33741373e-02f, -1.52855525e-02f, -2.64583230e-02f, 2.18680426e-02f, 4.23797369e-02f, 6.18007481e-02f, -2.53869630e-02f,
  -6.70691133e-02f, 1.90843344e-02f, 2.26380508e-02f, 7.54327476e-02f, 1.65161222e-01f, -6.34254962e-02f, 2.70952694e-02f, 3.05332858e-02f, -1.26428045e-02f, -1.64433643e-02f,
  6.29043207e-02f, -1.11444503e-01f, 4.45337929e-02f, 1.46383941e-01f, 8.90867189e-02f, -8.60101804e-02f, 6.30765110e-02f, 7.10411444e-02f, 1.23183252e-02f, -9.43804607e-02f,
  1.06366485e-01f, 1.26508415e-01f, -1.39995813e-02f, -1.33681625e-01f, 5.55511639e-02f, 9.23899338e-02f, 1.53996974e-01f, 3.85822766e-02f, -6.40229434e-02f, -5.40344529e-02f,
  2.96534784e-02f, 5.51384836e-02f, 1.22840911e-01f, 2.47310884e-02f, 1.51143253e-01f, 1.00943245e-01f, -1.36663288e-01f, 2.71461923e-02f, -4.91059534e-02f, -1.10265315e-02f,
  -4.74451818e-02f, -2.13337719e-01f, 8.62776190e-02f, 2.15397105e-02f, 2.67743856e-01f, 1.34202048e-01f, -9.27951187e-02f, 8.82977247e-02f, -1.68460188e-03f, -3.55005175e-01f,
  -1.63813055e-01f, -1.17373750e-01f, -2.06651732e-01f, 5.17760329e-02f, 2.24522665e-01f, -4.15461250e-02f, 9.73062068e-02f, -9.70561355e-02f, 1.24654680e-01f, 1.34700477e-01f,
  1.98819265e-01f, 1.38307750e-01f, 1.82532281e-01f, 2.28784308e-01f, 1.36685684e-01f, 3.25672142e-02f, -9.96315852e-02f, 1.31748030e-02f, 1.68721136e-02f, 3.88217829e-02f,
  -5.15719205e-02f, 5.17521426e-02f, 4.97139394e-02f, 1.99047383e-02f, 8.41655955e-03f, 3.54095250e-02f, 1.36967944e-02f, -3.24584059e-02f, 7.11923093e-02f, -2.99646147e-02f,
  -8.73336494e-02f, 5.04453890e-02f, -2.04243511e-03f, -6.35432228e-02f, 2.61891168e-02f, 1.35662965e-02f, 7.27942064e-02f, -5.24550490e-03f, -2.82356283e-03f, 5.86894751e-02f,
  2.69694533e-02f, -7.87294134e-02f, 4.97537665e-02f, 3.63937132e-02f, 4.36329506e-02f, -2.96522696e-02f, -2.95053720e-02f, -6.63749315e-03f, -5.84646389e-02f, -2.68591233e-02f,
  4.08378057e-02f, 1.30132958e-01f, -3.34339738e-02f, -3.91880283e-03f, -3.31246741e-02f, 1.23652440e-04f, 2.99726408e-02f, 4.22388352e-02f, -3.95781100e-02f, -7.69814774e-02f,
  -5.22239916e-02f, 8.98590013e-02f, 2.25619469e-02f, -8.28548148e-02f, -3.47196870e-02f, -1.78094152e-02f, -2.97049601e-02f, -6.48510084e-02f, -3.94411050e-02f, 2.55020168e-02f,
  1.33785913e-02f, 7.75148273e-02f, -4.80756490e-03f, 6.95071071e-02f, 5.75243160e-02f, 9.53038875e-03f, -5.12699820e-02f, -8.26590229e-03f, 1.15949977e-02f, -1.70320794e-02f,
  -3.01128656e-01f, -1.96842268e-01f, 2.17431970e-02f, -4.47290801e-02f, -2.91218869e-02f, 1.18366648e-02f, 1.82751883e-02f, 2.15561409e-02f, -7.24163651e-02f, 5.11447974e-02f,
  1.05081024e-02f, -7.87879899e-02f, -8.63689333e-02f, -6.14297157e-03f, 5.88941649e-02f, -6.83490112e-02f, -7.07349479e-02f, -1.01404086e-01f, -8.63597095e-02f, 3.15314019e-03f,
  -2.77482010e-02f, -3.66016403e-02f, 8.16804916e-02f, 1.29130602e-01f, 5.81082404e-02f, -8.12627524e-02f, 1.07228113e-02f, 2.54685413e-02f, 1.97806694e-02f, -5.39398901e-02f,
  -3.15636694e-01f, 5.84969446e-02f, -2.90375322e-01f, -6.55298755e-02f, 7.67856464e-02f, -1.68491870e-01f, 1.15453929e-01f, 7.75539801e-02f, 1.81209017e-02f, 2.35173464e-01f,
  2.34343514e-01f, -7.10006803e-02f, 2.37961888e-01f, -5.24231233e-02f, -5.59534311e-01f, -1.37542695e-01f, -1.12307563e-01f, 3.38075049e-02f, -3.91846523e-02f, 2.12345451e-01f,
  -1.52925730e-01f, 2.02245072e-01f, -1.27469674e-01f, 2.76369244e-01f, -6.23483807e-02f, -7.48903826e-02f, 9.24786776e-02f, 6.89922497e-02f, -5.94842657e-02f, -1.07257411e-01f,
  -7.63803646e-02f, 6.34927899e-02f, -1.13729157e-01f, -1.84680130e-02f, -8.94771367e-02f, 2.62681954e-02f, 4.03189734e-02f, -1.48986205e-01f, -8.82566124e-02f, -4.23069149e-02f,
  7.21237510e-02f, 1.53738484e-02f, -1.32799493e-02f, -4.00871038e-02f, 1.00290149e-01f, -7.28085935e-02f, -2.38644686e-02f, -1.09173646e-02f, 6.44358546e-02f, -4.97353263e-02f,
  -5.31080775e-02f, -1.30664527e-01f, 3.05314490e-04f, 8.80239881e-04f, -9.84237492e-02f, -3.65135111e-02f, -3.63826863e-02f, -7.85290524e-02f, -1.45879939e-01f, -1.49549261e-01f,
  9.03902482e-03f, 2.27402225e-02f, 1.16483625e-02f, 1.15075633e-02f, -9.43988115e-02f, -7.36072510e-02f, 1.11368716e-01f, 9.08542797e-02f, -7.01038614e-02f, 1.05404168e-01f,
  5.47885783e-02f, 2.42628437e-02f, 1.20963454e-01f, -1.72002278e-02f, -2.11136993e-02f, -7.24868774e-02f, -8.64822939e-02f, 6.33285791e-02f, 3.14902142e-02f, -6.78256005e-02f,
  -1.29551776e-02f, -1.18984133e-01f, 3.74470800e-02f, 1.39214009e-01f, 1.30554028e-02f, -5.24269417e-02f, 1.30698472e-01f, -4.38264534e-02f, 5.39913680e-03f, 1.97783653e-02f,
  1.13596767e-01f, 9.15738195e-02f, 3.91048938e-02f, 7.19932243e-02f, 5.95483184e-02f, -5.59168644e-02f, -3.17699350e-02f, -7.40071833e-02f, -5.08301482e-02f, 3.69978063e-02f,
  9.23261642e-02f, -7.27893487e-02f, 1.00094378e-01f, -5.23311682e-02f, -3.31536047e-02f, -7.54086599e-02f, 1.54986978e-01f, 2.31209565e-02f, 5.46140075e-02f, 4.97570746e-02f,
  1.67158842e-01f, 8.58726799e-02f, 5.81826791e-02f, 1.08222235e-02f, 8.84804279e-02f, 1.69694155e-01f, -9.98066925e-03f, -1.33167917e-03f, -9.27232876e-02f, -2.58257203e-02f,
  -7.06754386e-01f, 2.62427837e-01f, 2.35583171e-01f, -2.82617867e-01f, 2.20014006e-01f, 2.16807902e-01f, -1.17310889e-01f, 4.26273830e-02f, -2.30790809e-01f, 7.02792704e-02f,
  3.40671651e-02f, -1.57390833e-01f, 1.07525773e-01f, -6.06360771e-02f, -2.97445774e-01f, 1.89361885e-01f, -1.53127789e-01f, -1.78771749e-01f, 2.99473349e-02f, -1.18731909e-01f,
  -1.80698037e-01f, 1.03605598e-01f, 1.26235232e-01f, 2.56322443e-01f, 6.56088889e-02f, -3.38896737e-02f, -9.30987895e-02f, 1.16360895e-01f, -1.72669739e-01f, 9.67133567e-02f,
  -1.75648741e-02f, -9.43110809e-02f, 7.85101056e-02f, 7.29492754e-02f, 6.12360165e-02f, -2.77047348e-03f, -7.81532973e-02f, -4.66056215e-03f, -6.89503103e-02f, -1.28156707e-01f,
  1.84788406e-02f, 6.55121654e-02f, -1.46585315e-01f, 9.29148793e-02f, -8.51344317e-02f, 8.46508518e-02f, 1.57267511e-01f, 9.38544143e-03f, 4.73682620e-02f, 4.60760705e-02f,
  5.86452112e-02f, 6.94112480e-02f, -6.19775355e-02f, -3.52329947e-02f, 1.08011283e-01f, 6.90326840e-02f, 1.10448478e-02f, -4.18620519e-02f, -3.36063765e-02f, -9.57298875e-02f,
  3.32397735e-03f, -3.90465651e-03f, 9.50480029e-02f, 2.15390120e-02f, -1.47788962e-02f, -1.36665395e-02f, 1.92375761e-02f, 7.55472342e-03f, 3.06770997e-03f, 1.13013409e-01f,
  3.16303708e-02f, -9.05258730e-02f, -9.12665203e-03f, 3.18379737e-02f, -7.58740306e-02f, 1.89367570e-02f, 3.70011516e-02f, -9.31046903e-02f, -1.22789383e-01f, 6.94420189e-02f,
  2.30221953e-02f, -3.49486768e-02f, -3.60163562e-02f, 4.93863150e-02f, 1.11574449e-01f, -3.48500744e-03f, 3.88408303e-02f, 8.65223706e-02f, -7.44466484e-02f, 1.12413345e-02f,
  -1.88498259e-01f, -2.06121847e-01f, 4.98270914e-02f, 9.26090591e-03f, 2.20378749e-02f, 6.95007518e-02f, 2.76729669e-02f, 4.55840044e-02f, -2.07288493e-03f, -1.05097905e-01f,
  -9.16801468e-02f, 1.24427266e-02f, -1.46632746e-01f, -3.69048566e-02f, -1.48321111e-02f, 4.38465327e-02f, -1.12605408e-01f, -8.96983147e-02f, -6.40920326e-02f, 1.57066043e-02f,
  -7.69886980e-03f, -4.27316502e-02f, 9.93991457e-03f, 7.63079617e-04f, -8.36425368e-03f, -5.65726310e-02f, -2.96711456e-02f, 1.07179228e-02f, 7.32920766e-02f, -3.11709084e-02f,
  2.16677785e-01f, -1.36588171e-01f, -3.34261328e-01f, -2.15526760e-01f, 2.11010247e-01f, 3.01751584e-01f, -1.80475399e-01f, 1.50692081e-02f, -3.32856297e-01f, 2.07775667e-01f,
  5.27277067e-02f, -1.05299830e-01f, -3.75437021e-01f, 3.42522599e-02f, -8.43873024e-02f, -2.86071420e-01f, 1.85884893e-01f, 4.12607044e-02f, -1.30206808e-01f, 9.41062197e-02f,
  6.28133938e-02f, 2.84451783e-01f, -1.58456713e-01f, 2.69219369e-01f, 2.74812073e-01f, 2.00064816e-02f, 3.28784645e-01f, -1.23589277e-01f, 2.39484400e-01f, 7.21745938e-02f,
  -8.74213427e-02f, -3.35180573e-02f, -5.97121343e-02f, 3.28346388e-03f, 4.66540679e-02f, 1.37656346e-01f, 9.66234803e-02f, -8.23071133e-03f, -1.77320465e-01f, -1.04360670e-01f,
  7.27434084e-02f, -7.61912912e-02f, 1.14717716e-02f, -2.71420897e-04f, 1.49031132e-02f, 5.58960773e-02f, -1.59768298e-01f, -6.70027286e-02f, -1.43495515e-01f, -6.70790300e-03f,
  -1.65913686e-01f, 7.85170346e-02f, 6.71920255e-02f, 1.07957292e-02f, -1.60929382e-01f, -3.52004692e-02f, 1.03862613e-01f, 2.92867050e-03f, 4.79542054e-02f, 5.75137846e-02f,
  1.64653957e-01f, 1.69069037e-01f, -5.11760786e-02f, -1.49339080e-01f, 1.54860197e-02f, -7.71330446e-02f, 2.43024975e-02f, 3.62837613e-02f, -8.24881122e-02f, 4.56990078e-02f,
  -5.83891496e-02f, -9.09206644e-02f, -6.24074303e-02f, 1.03978746e-01f, 1.24025814e-01f, 1.52031809e-01f, 2.92029721e-03f, -5.80766127e-02f, -1.13100767e-01f, -1.05065756e-01f,
  2.17387713e-02f, -1.54623073e-02f, -6.58878610e-02f, 1.14788920e-01f, -3.15799601e-02f, -7.23180473e-02f, 6.23389035e-02f, 3.25954780e-02f, -3.01494002e-02f, 7.09633455e-02f,
  9.52156186e-02f, 1.21603616e-01f, -8.83104950e-02f, -7.66345337e-02f, -1.52384341e-01f, 1.55262770e-02f, 4.62465361e-02f, -4.18060832e-02f, -7.76389008e-03f, 1.60810873e-02f,
  1.61995724e-01f, 1.54643469e-02f, 1.73163444e-01f, -9.55671892e-02f, -6.23032218e-03f, -2.86232624e-02f, 1.04417674e-01f, -1.86143711e-01f, 8.87704194e-02f, -1.95884164e-02f,
  4.38788198e-02f, 2.36043781e-02f, -4.91255410e-02f, 3.67801939e-03f, -2.54905615e-02f, 7.86998030e-03f, 1.77623957e-01f, 6.60381000e-03f, 4.72560264e-02f, -3.08137313e-02f,
  6.76710755e-02f, -4.95508127e-02f, 1.54538780e-01f, 2.04472229e-01f, 1.56260997e-01f, -7.92521238e-03f, 2.11238950e-01f, -2.43338011e-03f, 4.09860820e-01f, -3.51919293e-01f,
  -9.83438343e-02f, -1.42062321e-01f, -1.29878595e-02f, -2.06774592e-01f, -9.26706381e-03f, -6.58524632e-02f, 8.46735984e-02f, 1.11087978e-01f, 2.95718968e-01f, 3.66663672e-02f,
  4.58816625e-03f, -3.77684265e-01f, -2.42295533e-01f, -1.73479676e-01f, -7.67962337e-02f, 1.18228041e-01f, -2.87465423e-01f, 6.04218468e-02f, -3.31517398e-01f, 4.90462221e-03f,
  8.97864625e-02f, 3.02931089e-02f, 5.09103462e-02f, 1.56586044e-04f, 4.78295088e-02f, -1.45560727e-01f, -1.22886918e-01f, -1.34606913e-01f, 2.16071635e-01f, -1.88466888e-02f,
  2.53867172e-03f, -9.32299495e-02f, 2.14312342e-03f, -1.45813599e-01f, 7.37349689e-02f, -5.58002479e-02f, 5.20787053e-02f, 1.85640067e-01f, 1.37181208e-01f, -1.86774619e-02f,
  9.24009532e-02f, 4.56167869e-02f, 1.38321936e-01f, 1.17119729e-04f, 1.22605897e-01f, 1.63083494e-01f, -8.73371959e-03f, -3.07482984e-02f, 4.09638956e-02f, 1.85650270e-02f,
  -5.59503511e-02f, -2.23800577e-02f, -1.71176642e-01f, -5.19879311e-02f, 3.20082456e-02f, -9.50536039e-03f, -5.93187213e-02f, -1.24087676e-01f, 1.02623634e-01f, 8.67143460e-03f,
  9.24259871e-02f, -2.21981630e-02f, 6.85286224e-02f, 8.60815570e-02f, -1.10652968e-01f, -1.89759076e-01f, -7.41394237e-02f, 6.80414587e-02f, 6.32068962e-02f, 5.79227172e-02f,
  -6.79081529e-02f, 6.49113581e-02f, 3.38289924e-02f, -7.78254718e-02f, -2.72890013e-02f, -5.63713685e-02f, -1.48059368e-01f, -1.53154477e-01f, 2.44843904e-02f, 1.03603967e-01f,
  8.60380456e-02f, -6.25079945e-02f, 1.37765095e-01f, 4.24441546e-02f, 1.41458169e-01f, -1.54233560e-01f, -1.81085885e-01f, 6.00363081e-03f, 1.99125528e-01f, -7.96460435e-02f,
  -3.37346569e-02f, 7.69213736e-02f, 4.61251661e-02f, -8.97505954e-02f, -2.30748653e-02f, -1.10244654e-01f, -5.98905608e-03f, 2.02748880e-01f, 1.02317303e-01f, -4.73848283e-02f,
  1.01982191e-01f, 1.25820979e-01f, 8.73072725e-03f, 1.13880411e-01f, 3.44324037e-02f, 7.68819312e-03f, -8.68892968e-02f, 9.11942124e-02f, 6.89514503e-02f, 6.24779090e-02f,
  -3.93000931e-01f, 5.70711493e-02f, -8.46308842e-02f, -2.99015045e-01f, 9.38221142e-02f, -2.74563283e-02f, -7.44273067e-02f, 2.04460442e-01f, -9.86400321e-02f, 1.26651928e-01f,
  1.35566741e-01f, -2.58358568e-01f, 1.12919651e-01f, -2.84590811e-01f, -2.41746560e-01f, -1.42795295e-01f, -3.11275154e-01f, -1.34504408e-01f, -1.74246952e-01f, 5.20707332e-02f,
  -1.97379947e-01f, -2.23530695e-01f, -2.56158914e-02f, 1.20063908e-01f, -6.70500994e-02f, 2.00593844e-01f, 1.74425229e-01f, 1.50951833e-01f, -1.79482773e-02f, -9.04361010e-02f,
  2.18993202e-02f, 8.50119721e-03f, 7.04210922e-02f, 4.07585055e-02f, 1.23406425e-01f, 6.38840944e-02f, -1.80990547e-02f, -6.39926195e-02f, 1.89327206e-02f, 3.37611437e-02f,
  -7.43260160e-02f, -9.92235541e-02f, -3.80316935e-02f, -1.06073201e-01f, -9.73920450e-02f, -1.65395327e-02f, -7.71908835e-02f, 6.69489205e-02f, -3.90033983e-02f, -1.12893112e-01f,
  -9.60090663e-03f, 3.16986516e-02f, -6.17613457e-02f, -4.26675342e-02f, -8.96071941e-02f, 1.01520885e-02f, -5.33532314e-02f, 2.02255249e-02f, 4.91431989e-02f, -2.97713336e-02f,
  4.92815152e-02f, -1.95926037e-02f, 1.90883856e-02f, 6.33612871e-02f, -8.39286204e-03f, 4.47212011e-02f, -8.81742463e-02f, -3.08689531e-02f, -4.34716158e-02f, -2.71001849e-02f,
  3.16512287e-02f, 1.79144926e-02f, -7.74616674e-02f, -4.57316637e-02f, -1.02691568e-01f, -6.35840520e-02f, 1.07146455e-02f, -2.95639713e-03f, -1.12716950e-01f, 1.00387163e-01f,
  9.05247182e-02f, -9.31404456e-02f, -8.53882357e-03f, -6.28768504e-02f, -3.01343063e-03f, 3.06939855e-02f, -1.08462133e-01f, -6.18093684e-02f, 1.09732538e-01f, 2.26681661e-02f,
  1.57515332e-01f, 1.83936879e-01f, 1.17607251e-01f, -1.74332112e-02f, 6.55377582e-02f, -2.26164721e-02f, -7.00576454e-02f, -6.87322915e-02f, 2.39661708e-02f, 3.66712622e-02f,
  -7.71364048e-02f, -3.90493497e-03f, 6.76603690e-02f, -6.87476769e-02f, -2.47742794e-03f, 8.85806680e-02f, -1.60203185e-02f, 9.67199877e-02f, 1.32945612e-01f, 2.22068820e-02f,
  6.47883415e-02f, 6.21408261e-02f, -8.24760944e-02f, -2.56574340e-02f, -5.55517003e-02f, 8.58401433e-02f, 1.04222864e-01f, -1.58149358e-02f, 2.66265906e-02f, 8.22585672e-02f,
  -2.00734958e-01f, -3.94366682e-01f, 9.96132568e-02f, 1.27860919e-01f, -2.04925492e-01f, -8.00956423e-06f, 1.56736672e-01f, -3.27448308e-01f, -2.97868401e-01f, -2.13719591e-01f,
  1.22890890e-01f, 1.26811400e-01f, 3.01559083e-02f, 1.55326054e-01f, 2.70539910e-01f, -2.26933490e-02f, 4.88015600e-02f, 1.11514591e-01f, -5.72524332e-02f, -1.05880186e-01f,
  -7.27229491e-02f, -8.98277014e-03f, 1.96483150e-01f, 2.08526161e-02f, 4.55993749e-02f, 1.77334756e-01f, 1.77439183e-01f, 1.86734244e-01f, 2.57583737e-01f, 2.68413812e-01f,
  -1.57430321e-01f, -2.36987606e-01f, -4.88447063e-02f, -1.65517449e-01f, -7.55871311e-02f, 1.67447105e-02f, 1.11841567e-01f, 1.61728427e-01f, 2.18288258e-01f, -1.05574839e-01f,
  2.54539791e-02f, -6.60900958e-03f, 8.85857791e-02f, 1.23841345e-01f, -8.16224590e-02f, -4.20603305e-02f, -1.72401816e-01f, -7.06003839e-03f, -8.78085196e-02f, 3.62375304e-02f,
  -1.05228737e-01f, -4.58056666e-02f, 3.14462185e-02f, 1.58246178e-02f, 2.64952239e-02f, -9.42284316e-02f, 2.66305692e-02f, 3.45377848e-02f, -1.79307461e-02f, -6.76667318e-02f,
  -2.74351370e-02f, -1.68734565e-02f, -1.04199551e-01f, 8.57570115e-03f, 5.94356582e-02f, 5.34286946e-02f, 3.08581926e-02f, 3.31393257e-02f, 6.20512851e-02f, -1.15748212e-01f,
  -5.72664402e-02f, -5.10196723e-02f, 1.98530424e-02f, -9.90267750e-03f, -7.97873959e-02f, -1.00206323e-01f, 6.26949891e-02f, -2.39461157e-02f, -2.31054742e-02f, 1.30307972e-01f,
  5.77456206e-02f, 3.45693119e-02f, 2.71563269e-02f, 1.43185807e-02f, -2.26868037e-02f, -5.93609884e-02f, 9.50703248e-02f, -7.68708885e-02f, 3.56313884e-02f, 1.45529717e-01f,
  -2.23428622e-01f, -1.77126318e-01f, 6.59829099e-03f, -1.16013259e-01f, 1.11236818e-01f, -4.24677953e-02f, 2.32116859e-02f, -9.64831561e-02f, 1.38752712e-02f, -1.28968760e-01f,
  -3.15713026e-02f, 1.17454551e-01f, -7.69976899e-02f, 1.32273391e-01f, 1.83971897e-02f, -3.49809192e-02f, -1.99420806e-02f, 5.75151145e-02f, -4.01177928e-02f, 3.60952206e-02f,
  3.24566737e-02f, 6.29798695e-02f, 1.34318963e-01f, 1.63839646e-02f, -6.32018372e-02f, 4.41559963e-02f, 3.03758606e-02f, -4.22272757e-02f, -2.79422179e-02f, 4.90170978e-02f,
  1.27114281e-02f, 3.10772415e-02f, -7.19852448e-02f, -2.06790641e-02f, -1.67338818e-01f, -1.80911765e-01f, -6.29901588e-02f, -2.72789765e-02f, 1.43327385e-01f, 8.33528489e-03f,
  -2.81483084e-01f, 2.35028416e-01f, -4.10642028e-02f, -2.48563111e-01f, 9.80575904e-02f, 1.06986374e-01f, -1.13456368e-01f, -3.30122747e-02f, 4.68576476e-02f, -1.47512406e-01f,
  -1.57482959e-02f, -2.74834543e-01f, -1.71140194e-01f, -2.35206440e-01f, -3.03317249e-01f, 2.55745593e-02f, -2.11485490e-01f, -1.65536165e-01f, -1.81851357e-01f, 2.30720975e-02f,
  -1.53695354e-02f, -5.05006919e-03f, 5.28870970e-02f, 1.41155571e-01f, -9.95825529e-02f, -2.56398227e-02f, -8.87662638e-03f, 1.50988698e-01f, 6.57419115e-02f, 2.41537541e-02f,
  5.85836917e-03f, 9.09494087e-02f, -7.69436434e-02f, -1.78394362e-01f, -8.05055443e-03f, -9.39184278e-02f, -1.90506354e-02f, -1.22077856e-02f, 1.09732434e-01f, -8.86620954e-02f,
  -3.06049921e-02f, 2.76769288e-02f, -8.42218101e-02f, 2.30380699e-01f, 1.60245121e-01f, 1.29465416e-01f, 1.10018514e-01f, 8.54230449e-02f, 9.21236798e-02f, 6.18419982e-02f,
  -5.46928085e-02f, -3.53518361e-03f, 4.46256548e-02f, -5.58350198e-02f, -2.07181964e-02f, -5.29810302e-02f, -6.55373465e-03f, -6.68128133e-02f, 8.50336254e-02f, -4.78298217e-02f,
  3.83220688e-02f, 7.27858916e-02f, -1.67268395e-01f, -8.19921196e-02f, -2.38834694e-02f, 2.02875331e-01f, 7.09176436e-02f, -4.90981564e-02f, -3.64437420e-03f, -1.67500600e-03f,
  -1.80953089e-02f, 7.82753825e-02f, 4.85640438e-03f, -1.32305816e-01f, -7.10034370e-02f, 1.79458987e-02f, -7.83860981e-02f, -2.96749063e-02f, -2.73856111e-02f, -1.77140728e-01f,
  -5.33778295e-02f, 9.94113609e-02f, 1.02300264e-01f, 1.77277982e-01f, -9.51811764e-03f, -1.46296248e-02f, 2.16540936e-02f, 1.30762056e-01f, 3.14112343e-02f, 1.03135414e-01f,
  -1.30762486e-02f, -2.23495923e-02f, -6.73551718e-03f, 2.46517621e-02f, 4.12027501e-02f, -4.10353914e-02f, -3.26473527e-02f, 1.87649667e-01f, 2.71469038e-02f, -1.84381418e-02f,
  -9.43259597e-02f, 5.41425906e-02f, 9.00296420e-02f, 1.60864443e-01f, 1.13924496e-01f, 3.07400748e-02f, 9.31967236e-03f, 3.62373628e-02f, -7.35879168e-02f, 3.43869776e-02f,
  -3.58593792e-01f, 1.85848773e-01f, 4.44303751e-01f, -2.23275319e-01f, -4.83409539e-02f, 3.92325163e-01f, 1.51447564e-01f, 3.08314860e-02f, 4.65061851e-02f, 1.81694813e-02f,
  -1.29779354e-01f, 3.73615921e-02f, 9.41068456e-02f, -2.17095360e-01f, 9.18512195e-02f, 1.83339268e-02f, -1.25044994e-02f, 6.83383793e-02f, 1.75888930e-02f, 5.32314274e-03f,
  4.68103699e-02f, -9.63413641e-02f, -1.56163126e-01f, -9.79452208e-02f, -4.35810396e-03f, 1.06349383e-02f, -2.28713870e-01f, 2.36741856e-01f, -1.36017323e-01f, 1.20582215e-01f,
  -4.61632274e-02f, -1.68466523e-01f, -1.42793894e-01f, 6.61700442e-02f, 7.72725744e-03f, 3.77848744e-03f, 1.51284352e-01f, 1.14219613e-01f, 7.09778687e-04f, -5.77568263e-02f,
  -6.73435405e-02f, 2.57223891e-03f, -1.19718788e-02f, -9.39585548e-03f, -3.38483751e-02f, -8.81641805e-02f, -9.29491594e-03f, 2.07765568e-02f, -9.19411704e-03f, 8.85226727e-02f,
  8.19510296e-02f, 1.43955901e-01f, -1.72185060e-02f, 1.72252774e-01f, -5.27699217e-02f, 3.13759930e-02f, -4.69828174e-02f, 2.81501040e-02f, 7.03960434e-02f, 1.07842170e-01f,
  5.69461174e-02f, 3.99894416e-02f, -3.16436193e-03f, 7.19631463e-02f, -1.39964581e-01f, 2.19050841e-03f, 3.27113383e-02f, -1.95314512e-01f, 4.44361503e-04f, -1.71521619e-01f,
  -3.90453376e-02f, -1.09476335e-01f, 7.08778054e-02f, 9.76341665e-02f, -1.14276327e-01f, -1.02388293e-01f, 3.31589244e-02f, 6.72762692e-02f, 1.35573521e-01f, 4.07530591e-02f,
  -6.30519316e-02f, 1.52892858e-01f, -6.48466721e-02f, -7.87398368e-02f, 6.64142296e-02f, -3.59013416e-02f, 8.22819173e-02f, 8.20087211e-04f, -2.86187232e-02f, 8.17847699e-02f,
  1.78934768e-01f, 2.30244085e-01f, -1.69766873e-01f, -5.18935099e-02f, 3.88480909e-02f, 5.53190634e-02f, 1.91912968e-02f, -5.14927916e-02f, -1.70394406e-02f, 2.93478020e-03f,
  3.00311930e-02f, -3.34867984e-02f, 1.14927098e-01f, -8.13046023e-02f, -1.67699456e-02f, -6.31076321e-02f, -7.33874738e-02f, 5.19292504e-02f, 6.53788596e-02f, 9.09022763e-02f,
  -2.92232800e-02f, 5.77563085e-02f, 8.17216337e-02f, 3.87149900e-02f, -8.80901739e-02f, 5.49803339e-02f, -8.65681022e-02f, -7.51010180e-02f, 2.30412930e-02f, 4.94521409e-02f,
  1.63255572e-01f, 1.48714200e-01f, 1.59202311e-02f, 5.65637909e-02f, -1.55515388e-01f, -1.86508074e-01f, -1.56395584e-01f, -5.58733046e-02f, -6.37532845e-02f, 5.02969101e-02f,
  -7.18793347e-02f, 1.29371479e-01f, 3.45364287e-02f, -7.02644140e-02f, 5.75110801e-02f, -1.67874172e-01f, 1.14325576e-01f, -5.55744022e-02f, -5.73996603e-02f, 2.95809120e-01f,
  2.09928855e-01f, 3.11243311e-02f, 6.55889586e-02f, 1.53201371e-01f, 1.62063450e-01f, 2.34384388e-01f, 2.84186184e-01f, 6.73520043e-02f, 9.96853337e-02f, -1.17780693e-01f,
  -1.02850519e-01f, -1.07083343e-01f, -5.81951253e-02f, -1.58483535e-01f, 7.55830929e-02f, 3.11653886e-04f, -4.71445657e-02f, -1.06054783e-01f, -1.09981209e-01f, -4.99859974e-02f,
  3.51570733e-02f, -2.99152598e-04f, 3.26962546e-02f, -3.92329320e-03f, 3.62204351e-02f, -9.64204781e-04f, -5.32212630e-02f, -8.88407454e-02f, -1.25321746e-01f, 1.05394192e-01f,
  6.55316487e-02f, 7.25094453e-02f, 5.82684316e-02f, -2.15370022e-03f, 8.28694999e-02f, 9.27573908e-03f, 3.74897681e-02f, 8.69593844e-02f, -2.24551354e-02f, 3.60890627e-02f,
  1.19577974e-01f, 6.95043430e-02f, 1.97603013e-02f, -1.41507193e-01f, -1.91734247e-02f, -1.27944769e-03f, -5.96256666e-02f, -6.90370947e-02f, 4.01197746e-02f, -3.99463922e-02f,
  -3.91979329e-02f, 3.69298309e-02f, -1.21624462e-01f, 2.86430474e-02f, 8.08686092e-02f, -2.25172043e-02f, -8.38433430e-02f, -4.36740406e-02f, 6.55583590e-02f, 8.69866740e-03f,
  -6.54138848e-02f, 1.05703965e-01f, -9.07827541e-02f, 6.82137720e-03f, -1.96464375e-01f, 1.33853465e-01f, 1.21913597e-01f, -8.16560909e-02f, 4.41617193e-03f, 1.42689189e-02f,
  1.15360782e-01f, 2.25977659e-01f, 7.49480277e-02f, -5.67722805e-02f, -9.65883061e-02f, 8.79612267e-02f, -2.94689722e-02f, -4.78987489e-03f, 1.62972361e-02f, 2.99685448e-02f,
  1.39487386e-01f, 1.54382139e-01f, -1.21908877e-02f, 6.75483719e-02f, -6.45880103e-02f, 1.88835829e-01f, 7.77290389e-03f, -3.88520323e-02f, -3.72072123e-02f, 1.23146348e-01f,
  5.22387698e-02f, 2.39211805e-02f, 8.87867138e-02f, -4.15022299e-02f, 8.54471847e-02f, 3.56180891e-02f, 1.80994403e-02f, 3.70094962e-02f, 3.12146638e-02f, -1.14266627e-01f,
  1.60525039e-01f, -2.66137104e-02f, -2.44336739e-01f, -8.84295851e-02f, -1.69983432e-01f, 2.22660434e-02f, -3.74480300e-02f, -4.94023077e-02f, 7.59621263e-02f, 8.97061527e-02f,
  -2.27534547e-01f, 2.42509663e-01f, 1.91948980e-01f, -1.75010517e-01f, 1.00512505e-01f, 1.90661907e-01f, -3.90966199e-02f, -1.15224509e-03f, -2.14373749e-02f, -6.67972118e-02f,
  4.44413386e-02f, 3.47517431e-02f, -1.09945029e-01f, -2.86403242e-02f, -1.79958895e-01f, -1.24820225e-01f, -3.95086110e-02f, -1.87058166e-01f, -2.23622352e-01f, -6.70221448e-02f,
  -1.04507573e-01f, 1.58524960e-02f, -2.63432041e-02f, 6.36484697e-02f, -5.87559193e-02f, 2.80272905e-02f, -4.61288914e-02f, -2.12170407e-02f, 2.71205674e-04f, -2.28341762e-02f,
  1.17629223e-01f, 1.71458185e-01f, -8.29994492e-03f, -5.89933284e-02f, -7.97062740e-02f, -1.08626157e-01f, 1.18484668e-01f, -3.83109674e-02f, 1.11668594e-01f, -2.31547877e-02f,
  -3.33965756e-02f, -1.29367933e-01f, 2.77632624e-02f, 1.44923285e-01f, 6.50709718e-02f, 1.12870313e-01f, 2.67864466e-02f, 3.72936577e-02f, -1.43064093e-02f, -1.06004868e-02f,
  -1.42846042e-02f, 7.59312361e-02f, 3.00178844e-02f, -4.73823063e-02f, -1.26855141e-02f, -9.27742124e-02f, 5.93782328e-02f, -4.31638435e-02f, 1.12184070e-01f, 2.28602532e-02f,
  2.66563222e-02f, -3.26587423e-03f, -7.51590952e-02f, 4.42447774e-02f, 7.21934363e-02f, 5.93006983e-02f, -6.41027912e-02f, 1.91882788e-03f, -3.31857707e-04f, 1.27453171e-02f,
  -5.78772016e-02f, 8.38949308e-02f, 2.17420440e-02f, -7.47474609e-03f, -1.17846318e-01f, -8.90818313e-02f, 3.20120379e-02f, 1.01812873e-02f, -9.75380242e-02f, 9.82932225e-02f,
  -2.59052087e-02f, 2.54326850e-01f, 1.77610200e-02f, 8.43021199e-02f, -6.22214675e-02f, 1.31115317e-02f, 8.73081535e-02f, 1.20443344e-01f, 3.11448146e-02f, 9.59976912e-02f,
  4.26702350e-02f, 9.77502316e-02f, -2.10647676e-02f, -1.99049786e-02f, -8.45629871e-02f, 1.71975028e-02f, 1.21178083e-01f, -1.81499850e-02f, 5.21065481e-02f, -4.85110655e-02f,
  8.11773539e-02f, 2.50878222e-02f, 2.16544792e-01f, 7.10665956e-02f, 1.72301531e-01f, 5.92573807e-02f, -7.69561082e-02f, 7.08321258e-02f, 4.30391021e-02f, 5.31137511e-02f,
  2.90863365e-01f, 1.06735677e-01f, 1.13523938e-01f, 4.50005084e-01f, 1.49080902e-01f, 1.11740723e-01f, 2.93730795e-01f, 2.36017361e-01f, 4.83498782e-01f, -1.87775567e-02f,
  4.71470356e-02f, -9.37421024e-02f, 5.38610630e-02f, 4.35675420e-02f, 1.34153858e-01f, 1.28542915e-01f, 2.73537934e-01f, -1.58123951e-02f, 2.03230664e-01f, 3.49997394e-02f,
  2.21121937e-01f, 7.89400488e-02f, -5.01040020e-04f, -7.88754001e-02f, 3.61044891e-02f, 9.30847414e-03f, -7.53200725e-02f, 6.66063577e-02f, -1.43222094e-01f, -7.62232579e-04f,
  1.57168824e-02f, 2.43691206e-01f, -7.91494399e-02f, -8.54617283e-02f, 2.60937437e-02f, -1.08789338e-03f, -6.87952340e-02f, -1.04759395e-01f, -2.17314661e-02f, -7.33993277e-02f,
  -8.00847933e-02f, -5.02697714e-02f, -8.66522454e-03f, 7.12257773e-02f, 1.50576919e-01f, -5.89515790e-02f, 5.80437928e-02f, -1.21286931e-02f, -3.61091830e-02f, 3.62968780e-02f,
  2.71797851e-02f, -1.45781515e-02f, 1.27861068e-01f, 3.57911699e-02f, 4.84835058e-02f, 5.02824448e-02f, -4.76868600e-02f, -5.15374402e-03f, -1.79195795e-02f, 4.82333712e-02f,
  -4.77568479e-03f, 4.74076159e-02f, 2.74929516e-02f, -5.52051775e-02f, 6.91882148e-02f, -5.70542254e-02f, 1.10623360e-01f, -6.68394715e-02f, 9.14676562e-02f, 1.72329247e-02f,
  1.52331190e-02f, 4.51957108e-03f, 8.18238482e-02f, 6.75555766e-02f, 8.23951587e-02f, 3.57064456e-02f, -1.45832181e-01f, -4.98892218e-02f, 1.15121886e-01f, 9.57780145e-03f,
  -9.00832340e-02f, -4.31723446e-02f, -1.57530177e-02f, -2.13614572e-02f, -3.96975651e-02f, 3.40944417e-02f, 3.31998169e-02f, 1.69315487e-02f, -3.13981026e-02f, -8.45426507e-03f,
  5.23342378e-02f, 3.22710663e-01f, 4.50909659e-02f, 1.99932847e-02f, -1.06459983e-01f, 2.85201371e-02f, 6.93794638e-02f, 1.67660862e-02f, 9.19197500e-02f, 9.94644761e-02f,
  8.40401743e-03f, 2.58991634e-03f, -2.95425523e-02f, 7.74356946e-02f, -8.39889720e-02f, 1.04699455e-01f, 1.96398105e-02f, -2.40570158e-02f, -4.55606207e-02f, -6.36115372e-02f,
  -1.27853334e-01f, 4.22952846e-02f, 2.61391383e-02f, 3.42753977e-02f, -3.48936059e-02f, 4.28230204e-02f, -7.95104355e-02f, -1.55027851e-03f, 2.61403024e-02f, -6.97548687e-02f,
  7.40999281e-02f, 4.35176631e-03f, 1.57886088e-01f, -1.42207518e-01f, -5.27185574e-03f, 4.07640412e-02f, -1.16468377e-01f, -1.19556184e-03f, 1.65317267e-01f, -1.46570057e-01f,
  -1.62318900e-01f, 3.79784405e-02f, 1.27578169e-01f, -2.52324045e-01f, 2.43911892e-01f, 1.67324841e-01f, -9.98505503e-02f, -6.83403537e-02f, 5.64481206e-02f, -3.63992415e-02f,
  4.80331331e-02f, -1.89457282e-01f, -9.28380787e-02f, -2.20704198e-01f, -1.53638214e-01f, -6.42359704e-02f, -2.11403370e-01f, 9.36724991e-03f, -2.41395622e-01f, -2.58295760e-02f,
  -5.37066050e-02f, -1.14146650e-01f, -8.12446401e-02f, -4.93378155e-02f, 1.14249233e-02f, -7.21533895e-02f, -5.84698170e-02f, -2.77744490e-03f, 9.69985649e-02f, 5.33842817e-02f,
  1.07281581e-01f, 4.84468490e-02f, 6.06211312e-02f, 1.01256162e-01f, 4.89839651e-02f, -9.43597406e-03f, -2.43170578e-02f, -1.00152671e-01f, -1.85452364e-02f, 5.76000772e-02f,
  7.09790885e-02f, 3.39547405e-03f, 3.77120227e-02f, -2.58063953e-02f, -8.64771307e-02f, -1.40071943e-01f, -1.51159205e-02f, -1.15272328e-02f, -2.07454804e-02f, 1.39082456e-02f,
  -4.67135869e-02f, -7.27082118e-02f, -1.25547186e-01f, -1.42349144e-02f, -6.49689212e-02f, 3.71194817e-02f, 8.63980129e-02f, -6.16273731e-02f, 4.92841750e-03f, -5.33211343e-02f,
  3.43756191e-02f, -5.04767261e-02f, 1.32638827e-01f, 6.50627678e-03f, -6.39487281e-02f, -1.17886558e-01f, -3.20138410e-02f, 1.13227129e-01f, 8.14123526e-02f, 5.13156392e-02f,
  -3.35110053e-02f, -7.06241727e-02f, -1.26379274e-03f, -2.80834101e-02f, 5.42043373e-02f, -3.50767821e-02f, -4.73423749e-02f, 9.26886126e-02f, 5.57205118e-02f, 7.93340728e-02f,
  -3.22862295e-03f, -2.14853078e-01f, -8.67467895e-02f, -1.00702584e-01f, 1.23003580e-01f, -2.28880085e-02f, 1.28516536e-02f, -5.29384725e-02f, 4.61025201e-02f, 4.22474230e-03f,
  -1.80024821e-02f, 2.68793069e-02f, 3.52381095e-02f, 5.10942042e-02f, -1.36382626e-02f, 7.51194879e-02f, -9.52417627e-02f, 3.64054553e-02f, -1.12885922e-01f, -1.32885650e-02f,
  -3.75412181e-02f, 3.70259732e-02f, 5.03940135e-02f, -4.72804680e-02f, -1.66390389e-01f, -5.59338070e-02f, 5.14628217e-02f, -5.96242473e-02f, -3.96761186e-02f, 3.46194841e-02f,
  4.91731822e-01f, -2.08500966e-01f, 5.71221150e-02f, 2.59414792e-01f, 1.82677194e-01f, 1.39410943e-01f, 3.16897750e-01f, -1.14578970e-01f, 1.49670139e-01f, -2.84798652e-01f,
  2.64521707e-02f, -9.85273272e-02f, 1.22560777e-01f, -5.37691303e-02f, 3.39548498e-01f, 9.29886359e-04f, 7.37973750e-02f, 5.52318618e-02f, -6.32836204e-03f, 7.27521777e-02f,
  6.84199631e-02f, 3.11590196e-03f, 5.38913384e-02f, -2.55427271e-01f, 9.63737667e-02f, -1.16889007e-01f, -1.29571259e-01f, 5.71134873e-02f, -2.24550650e-01f, 3.46575826e-02f,
  4.88821194e-02f, 7.48592254e-04f, 4.75075580e-02f, -1.13126189e-01f, 3.81322801e-02f, 2.91597079e-02f, -3.07746716e-02f, 6.76205903e-02f, 5.70531599e-02f, -5.57138398e-02f,
  1.39663704e-02f, -9.27551538e-02f, -3.01279798e-02f, 1.45268396e-01f, 1.68701470e-01f, 3.70991267e-02f, -4.82929200e-02f, -5.96660450e-02f, -9.94898975e-02f, -5.15510282e-03f,
  8.70307609e-02f, -2.64127217e-02f, 1.00002527e-01f, -1.43729210e-01f, -5.92900403e-02f, -2.19525937e-02f, -1.06545694e-01f, -3.69529203e-02f, -3.42107601e-02f, -6.16666712e-02f,
  -2.52951924e-02f, 3.91591369e-04f, 4.57132719e-02f, 6.90847635e-03f, 1.07720636e-01f, 7.41720200e-02f, 9.14299488e-02f, -7.37984153e-03f, 1.71289593e-02f, 3.31058949e-02f,
  2.74109859e-02f, 4.10216637e-02f, -1.78659149e-03f, 1.05097458e-01f, -6.85760602e-02f, -1.89032611e-02f, 6.05201945e-02f, -8.05216581e-02f, 1.34969071e-01f, 2.81737037e-02f,
  2.08092183e-02f, 2.75199916e-02f, 1.82114448e-02f, -5.74088581e-02f, 1.46624655e-03f, 7.86524937e-02f, -4.74106893e-02f, 9.98033118e-03f, -5.20041399e-02f, 1.20263457e-01f,
  -9.22025740e-02f, -2.72319704e-01f, -9.07184258e-02f, -1.78355306e-01f, -3.20335589e-02f, 1.41337877e-02f, 2.61598453e-02f, -6.66992888e-02f, -5.09087257e-02f, -1.73149835e-02f,
  -1.28067717e-01f, 5.04186153e-02f, 3.10714953e-02f, 9.41468775e-02f, -7.70391896e-02f, -1.11308793e-04f, -7.73272058e-03f, 1.04314573e-02f, -2.58302856e-02f, -1.22508816e-01f,
  -5.30959554e-02f, 3.76918800e-02f, 5.97759373e-02f, -4.77560516e-03f, -1.68727830e-01f, -8.93491879e-03f, -6.20236918e-02f, -1.37875350e-02f, -2.16488838e-02f, -1.02021180e-01f,
  1.71544880e-01f, -1.57516729e-02f, 3.01686943e-01f, 1.03399262e-01f, 1.10805975e-02f, 1.03847019e-01f, 3.29696923e-01f, -1.59158871e-01f, -8.04110542e-02f, -1.79615140e-01f,
  -1.65426925e-01f, 2.61019856e-01f, 9.55790579e-02f, -5.12962751e-02f, 1.12852260e-01f, -4.75707613e-02f, -8.36843476e-02f, 4.44217399e-03f, -1.06865317e-01f, 5.54361418e-02f,
  -7.36631975e-02f, -2.23855108e-01f, 2.43883178e-01f, -2.31402799e-01f, 1.38737941e-02f, -5.57793155e-02f, -1.04161464e-01f, 1.74920842e-01f, -4.84909303e-02f, 2.17751730e-02f,
  -1.16117172e-01f, -3.13389264e-02f, 9.36976522e-02f, 1.49467988e-02f, -1.51869282e-01f, -4.32234397e-03f, 4.96118926e-02f, 1.68651238e-01f, -1.51312109e-02f, -4.19216324e-03f,
  -4.52875309e-02f, -4.16735560e-02f, -1.11511238e-01f, -4.92412187e-02f, -9.26169567e-03f, 9.48340021e-05f, -1.57767534e-02f, 6.03263304e-02f, 3.20407525e-02f, 5.42230383e-02f,
  1.76265463e-02f, -2.09779106e-03f, 2.84986608e-02f, 9.92306769e-02f, 1.80035815e-01f, -3.62420194e-02f, 3.58907841e-02f, 2.37552419e-01f, -2.91818753e-02f, -8.36123005e-02f,
  1.39106065e-01f, 5.76222390e-02f, 5.55223450e-02f, -4.70274501e-02f, -4.33235280e-02f, -2.03601465e-01f, -6.46628141e-02f, -7.51597341e-03f, -1.44529529e-02f, -2.41417233e-02f,
  -4.36288603e-02f, 4.33354825e-02f, -1.01202697e-01f, 6.86934292e-02f, -5.92154600e-02f, 1.29873520e-02f, 1.07478775e-01f, -4.63757850e-02f, -1.16987757e-01f, 4.60771298e-05f,
  6.71357103e-03f, 6.76655173e-02f, -4.60108891e-02f, 2.81900261e-02f, -6.62135556e-02f, 3.87513191e-02f, -1.24734923e-01f, -1.05024176e-02f, 6.92486316e-02f, 4.66950163e-02f,
  -1.18830569e-01f, -5.49158454e-02f, 8.75970796e-02f, -7.16709048e-02f, -6.84979931e-02f, -6.78526163e-02f, 4.29081768e-02f, 1.09868897e-02f, -1.16091250e-02f, -1.73476189e-02f,
  -7.19495937e-02f, -3.44137698e-02f, 3.58641334e-02f, 5.87090962e-02f, -5.77047542e-02f, -3.54017802e-02f, 5.52293882e-02f, -5.41789047e-02f, 9.84695833e-03f, -6.16599061e-02f,
  -2.25053765e-02f, 9.17072222e-02f, -1.21246446e-02f, 5.64097948e-02f, 5.15250787e-02f, 7.73549220e-03f, 5.12781851e-02f, 3.33933309e-02f, 4.51230630e-02f, -3.25387865e-02f,
  1.67367563e-01f, -4.97538090e-01f, 6.91818744e-02f, 2.27667376e-01f, 1.22146562e-01f, -1.39760301e-01f, -5.18944953e-03f, 2.31765304e-02f, 1.81347921e-01f, -3.28044593e-01f,
  6.38935864e-02f, -3.35541926e-02f, -1.38526797e-01f, -2.49348879e-02f, 2.91040033e-01f, -4.04754430e-02f, 1.62894428e-02f, -5.13724685e-02f, 8.96334350e-02f, -1.26783386e-01f,
  2.14827344e-01f, -4.59836759e-02f, 7.71767721e-02f, -1.92986935e-01f, -4.40380760e-02f, 4.01320076e-03f, 1.23645231e-01f, -3.62672471e-02f, -3.86048630e-02f, 1.04804426e-01f,
  -1.77388221e-01f, -2.33807955e-02f, -1.41356597e-02f, -1.02723412e-01f, -3.90538536e-02f, 1.54994363e-02f, 6.73286170e-02f, 5.52905649e-02f, 5.82772791e-02f, 1.43361855e-02f,
  -3.11585292e-02f, 4.71278615e-02f, 2.85712373e-03f, -2.87936572e-02f, -5.43246493e-02f, 8.25240742e-03f, -4.92039919e-02f, 1.27468994e-02f, 1.65601820e-02f, 6.42819051e-03f,
  2.37176940e-02f, 1.18621923e-02f, 2.65369900e-02f, 2.58500930e-02f, 8.94710124e-02f, 9.35058594e-02f, 3.00229024e-02f, -5.47213294e-02f, -5.88042401e-02f, 4.29880060e-03f,
  1.00040641e-02f, 3.11860647e-02f, 1.35838159e-03f, 3.15117352e-02f, -2.78702043e-02f, 8.63402933e-02f, 4.75103362e-03f, 1.76806201e-03f, -3.71526880e-03f, -1.49253337e-03f,
  -5.49450517e-02f, 4.99280281e-02f, -5.29944040e-02f, -1.41016755e-03f, 4.19602990e-02f, 1.08778439e-01f, 5.51047968e-03f, -1.07711427e-01f, 6.34099692e-02f, -1.23481825e-03f,
  -7.00474679e-02f, 9.36761266e-04f, -8.24473649e-02f, 4.08713892e-03f, -5.05532585e-02f, 4.33055498e-02f, -5.31904921e-02f, -4.33477238e-02f, 9.78434905e-02f, -5.96663356e-02f,
  -4.90009427e-01f, -4.55491692e-01f, -9.70051289e-02f, 2.06858423e-02f, -1.08991250e-01f, -2.48420462e-02f, 6.66136667e-02f, -5.68388076e-03f, -1.00957625e-01f, 9.97025287e-04f,
  -5.37686087e-02f, -5.21583529e-03f, -4.69913520e-02f, 1.06815286e-01f, -2.99749058e-02f, 2.21199598e-02f, -5.26364781e-02f, -1.15261162e-02f, -4.01862338e-02f, 2.04134104e-03f,
  -3.93228456e-02f, -4.68335487e-02f, 7.97443837e-02f, 6.25576973e-02f, 4.02655974e-02f, 1.68866720e-02f, -5.10881357e-02f, 6.88051581e-02f, 1.13914097e-02f, -2.86774952e-02f,
  -3.36330384e-01f, 2.73059100e-01f, -9.72648934e-02f, 4.60309051e-02f, 1.88337728e-01f, 1.03273474e-01f, 1.60036758e-01f, 1.18873812e-01f, 3.63940328e-01f, 1.06365986e-01f,
  8.61971751e-02f, 1.30439222e-01f, 2.02090293e-02f, -4.47851000e-03f, -2.47715890e-01f, -7.33624632e-03f, 5.65884076e-02f, 1.65959567e-01f, 2.39905089e-01f, -7.86560923e-02f,
  -1.41075939e-01f, 1.96499489e-02f, -2.82040417e-01f, 3.26350927e-02f, -3.36594917e-02f, 5.96188717e-02f, -7.90582001e-02f, 2.75104076e-01f, 3.88071984e-02f, 2.60787696e-01f,
  -1.18417621e-01f, 1.24152042e-01f, -1.18873812e-01f, -9.33671519e-02f, -1.53059259e-01f, -1.15540296e-01f, 8.12238082e-02f, -5.14934538e-04f, 2.60608252e-02f, -9.88951027e-02f,
  2.15922073e-02f, -2.07531434e-02f, -8.62054341e-03f, 1.21976338e-01f, 6.76742792e-02f, -3.00384834e-02f, 5.42447940e-02f, 4.77884933e-02f, 1.84686873e-02f, -8.91914442e-02f,
  -8.83037001e-02f, -1.90846995e-01f, -8.71642679e-02f, 1.19047835e-01f, -7.34224496e-03f, 1.09294921e-01f, -2.55508963e-02f, 1.48417773e-02f, 3.44525315e-02f, 1.21592823e-02f,
  9.01736021e-02f, 1.21078379e-01f, 1.13062141e-02f, -2.63420749e-03f, 1.21241584e-02f, -5.30540608e-02f, -2.74326820e-02f, -1.03979439e-01f, -5.28319366e-02f, -4.79568820e-03f,
  -2.27740891e-02f, 3.24055180e-02f, -1.17261689e-02f, 4.44764793e-02f, -2.37619076e-02f, 6.63873646e-03f, -5.95091246e-02f, 7.69860968e-02f, -1.63273867e-02f, 3.48439366e-02f,
  6.81179315e-02f, 4.26110178e-02f, -6.54714406e-02f, -5.22201620e-02f, 3.98058668e-02f, -1.20227989e-02f, 8.37824494e-02f, -1.41223967e-01f, 5.21531515e-02f, 2.94895638e-02f,
  2.40160659e-01f, 4.47471976e-01f, -2.12430768e-02f, -1.30992115e-01f, -8.13650414e-02f, -8.18843022e-02f, 3.87631692e-02f, -5.18749021e-02f, 6.19441196e-02f, -5.31055070e-02f,
  -3.97491008e-02f, -3.59178223e-02f, -1.76556669e-02f, 5.90256006e-02f, -6.56688362e-02f, 3.43113020e-02f, 1.14186913e-01f, 1.60527423e-01f, -1.19108288e-02f, 8.13840032e-02f,
  -7.89266676e-02f, 2.21587289e-02f, -8.02095383e-02f, -6.54828548e-02f, -7.71067441e-02f, -2.28423886e-02f, 1.05820797e-01f, 2.26917248e-02f, -3.48382071e-02f, -1.63046345e-02f,
  -3.97401780e-01f, 4.67734873e-01f, -1.39135206e-02f, -2.51651406e-01f, 3.03651154e-01f, 1.97347507e-01f, -1.07680105e-01f, 2.03871548e-01f, 7.07501024e-02f, -7.64285102e-02f,
  -1.65806770e-01f, -1.01952411e-01f, 5.10873273e-02f, -1.53209046e-01f, 2.36798525e-02f, 1.56541780e-01f, -1.18244551e-01f, -2.39241496e-01f, 2.89696306e-01f, -1.25419527e-01f,
  1.01949506e-01f, -1.16269179e-01f, -1.68708414e-02f, 1.34632900e-01f, -4.66392376e-02f, -3.20172422e-02f, -1.72881439e-01f, 2.82929569e-01f, -2.25389764e-01f, 8.46487805e-02f,
  3.51883471e-02f, -1.38963833e-01f, -1.03247188e-01f, -2.24362090e-02f, -9.06767417e-03f, 1.05708530e-02f, -6.48011491e-02f, 8.59947875e-02f, 6.57269582e-02f, 1.75899994e-02f,
  6.49522170e-02f, 9.51944664e-02f, -2.07741745e-02f, 1.15868933e-02f, 3.96732688e-02f, 4.62202728e-02f, -7.50972703e-02f, -9.21231210e-02f, 5.99983074e-02f, 1.97189286e-01f,
  -4.03046981e-02f, 2.28694007e-02f, 5.34969792e-02f, -7.13365665e-03f, 8.99921730e-03f, 5.92052452e-02f, -4.49498855e-02f, -1.81136336e-02f, -5.60308844e-02f, 2.25300305e-02f,
  -8.36105719e-02f, 9.22377780e-02f, 1.21243574e-01f, -2.33638398e-02f, -9.41566774e-04f, 1.71994660e-02f, 8.26353356e-02f, 8.11326259e-04f, 2.11685784e-02f, 9.83050466e-02f,
  4.34499867e-02f, 8.16364363e-02f, 1.60764009e-01f, 1.23183131e-02f, 3.69069129e-02f, -7.27344081e-02f, -4.28984649e-02f, -5.34635186e-02f, 1.07440792e-01f, 1.13874422e-02f,
  -3.68042663e-02f, -4.68578562e-02f, -3.16798724e-02f, 5.81766069e-02f, -5.98720573e-02f, 3.34540419e-02f, 8.52382928e-02f, -5.79955503e-02f, 9.79997441e-02f, -3.85033176e-03f,
  1.21862628e-01f, -1.34383738e-01f, 1.46949347e-02f, 6.02080263e-02f, 1.04706071e-01f, 1.95530243e-02f, 3.38444598e-02f, 1.40257704e-03f, 1.92461368e-02f, 1.57187823e-02f,
  9.13659111e-02f, -7.25036561e-02f, 2.29519363e-02f, 4.36426438e-02f, -1.89914797e-02f, 2.41962094e-02f, -2.05439344e-01f, 3.97627102e-03f, -2.89098229e-02f, 1.02811880e-01f,
  -2.79607549e-02f, -5.30088805e-02f, 4.05269451e-02f, 1.16448984e-01f, -5.61367199e-02f, -3.73047777e-02f, -3.16988006e-02f, -2.13775150e-02f, -8.17399323e-02f, 1.31781936e-01f,
  -1.59367517e-01f, 2.60211945e-01f, 1.48849696e-01f, 2.39432991e-01f, -5.01274168e-01f, -1.08732451e-02f, 8.03613588e-02f, -2.22450137e-04f, 1.06326409e-01f, 1.46430492e-01f,
  -1.35999799e-01f, 1.42804563e-01f, 1.28091738e-01f, 7.98280835e-02f, 5.22971749e-02f, 1.62986279e-01f, 1.77845523e-01f, 1.51930168e-01f, 3.59948687e-02f, 1.71075240e-01f,
  4.49589528e-02f, -6.52040318e-02f, 4.81564589e-02f, 3.58748785e-03f, -1.60027117e-01f, -3.91269587e-02f, -1.47133246e-01f, -2.16002554e-01f, -1.28709853e-01f, -2.06171632e-01f,
  -1.33653998e-01f, -1.89753845e-02f, 2.49575153e-02f, -4.52332348e-02f, 5.03403656e-02f, -7.94343427e-02f, -5.44433072e-02f, -8.49364698e-02f, 2.61221360e-03f, 3.48884203e-02f,
  -1.99403390e-02f, -6.89550415e-02f, 5.91600016e-02f, 1.01556443e-01f, -2.09510513e-03f, -8.65139533e-03f, -5.35970069e-02f, -5.02597727e-02f, -6.98227957e-02f, -1.10732280e-01f,
  7.65469149e-02f, 9.74711627e-02f, -2.98363343e-02f, -6.28026053e-02f, -1.15634732e-01f, -6.29760548e-02f, 3.30193751e-02f, -4.99607511e-02f, -3.48555036e-02f, 2.61132140e-02f,
  2.11032648e-02f, -5.25989048e-02f, -2.74608340e-02f, 2.26975214e-02f, 5.28636947e-02f, -7.10305152e-03f, 4.60740738e-02f, -6.34348020e-02f, 7.25253224e-02f, 4.38285545e-02f,
  -4.23357598e-02f, -6.36660084e-02f, -1.58484150e-02f, 1.68683261e-01f, 1.33803740e-01f, 1.25966892e-01f, -2.52210442e-02f, -1.03128418e-01f, -2.38588126e-03f, 3.26394029e-02f,
  7.16981217e-02f, -3.27460058e-02f, 4.62876894e-02f, -8.56407806e-02f, 7.19573721e-02f, -2.66861133e-02f, -5.88002242e-02f, 9.71224457e-02f, 6.06127083e-02f, -2.53747813e-02f,
  -4.30631302e-02f, 1.26284197e-01f, 5.70222037e-03f, -7.92275965e-02f, 1.12487897e-01f, -3.92632671e-02f, -6.52859956e-02f, -1.15834147e-01f, 1.10807918e-01f, 1.54629312e-02f,
  -4.02167700e-02f, 4.94160727e-02f, 6.47028759e-02f, -6.21371195e-02f, 2.87548061e-02f, 5.74728101e-02f, -7.22182449e-03f, 4.06452045e-02f, -5.10811768e-02f, -6.13881983e-02f,
  -1.30834579e-02f, -6.46609953e-03f, -4.25357074e-02f, -4.99893911e-02f, 2.06622258e-02f, 9.49117821e-03f, 6.78729713e-02f, 4.19606542e-04f, -1.14195779e-01f, 8.51058885e-02f,
  2.10173145e-01f, 1.69693008e-01f, -9.68604982e-02f, -2.21931860e-01f, -7.32064294e-03f, 3.53464246e-01f, 3.41908727e-03f, -1.19262841e-02f, -2.65748143e-01f, 1.68132737e-01f,
  -2.47236690e-03f, -3.69069315e-02f, 1.93280857e-02f, -1.40506700e-02f, 1.17012262e-01f, 4.23538685e-02f, 1.44747585e-01f, -1.07607627e-02f, -9.10924841e-03f, 1.11960873e-01f,
  1.10362528e-03f, 2.66842008e-01f, -7.38854930e-02f, 1.80011302e-01f, 7.97486007e-02f, -1.99567318e-01f, 7.72843435e-02f, -1.69883519e-01f, -7.39780674e-03f, 1.20359994e-02f,
  3.90374591e-03f, 2.00071149e-02f, 3.46126221e-02f, -5.06336093e-02f, 1.17948048e-01f, 1.62795000e-03f, 4.04947028e-02f, 9.96951852e-03f, -1.83804870e-01f, -3.78426313e-02f,
  9.21191424e-02f, -3.54988128e-02f, 4.21480052e-02f, 2.49072257e-02f, 1.04548343e-01f, -8.86153132e-02f, 8.70387303e-04f, -2.06578791e-01f, -3.90557311e-02f, 1.59272596e-01f,
  -7.89445937e-02f, -8.47573727e-02f, 7.09426543e-03f, -1.21829867e-01f, 3.32200490e-02f, -5.08848801e-02f, -4.35011163e-02f, -4.39926051e-02f, 2.34786253e-02f, 5.17441472e-03f,
  7.91942552e-02f, 8.11381564e-02f, 1.20780833e-01f, -8.99217054e-02f, 2.02577915e-02f, 2.28074603e-02f, 1.14168949e-01f, 8.84889737e-02f, -1.72658432e-02f, 3.62103842e-02f,
  -8.70399997e-02f, 2.23194920e-02f, -1.85827594e-02f, 9.51533318e-02f, 1.87832147e-01f, 5.48738800e-03f, 3.59057449e-02f, -2.05327645e-02f, -9.60652307e-02f, 1.69909205e-02f,
  3.21759051e-03f, 4.04236354e-02f, 2.81483633e-03f, -1.87963061e-02f, 2.95082126e-02f, -8.48511979e-02f, 1.25003904e-01f, -5.96087538e-02f, -3.10633294e-02f, 1.35675684e-01f,
  -1.65450014e-02f, 2.15174630e-01f, -5.38270995e-02f, -2.40575522e-02f, -3.65858786e-02f, 9.91899613e-03f, 1.00956954e-01f, 1.97716489e-01f, 1.44662606e-02f, 3.47762443e-02f,
  2.08031967e-01f, -5.22447564e-02f, 8.46054479e-02f, -1.23893268e-01f, -2.82904785e-02f, 1.70757413e-01f, 1.66504040e-01f, -2.17632428e-01f, -5.21712080e-02f, 5.60455546e-02f,
  -2.57869661e-02f, -5.56807034e-02f, -6.73366562e-02f, -4.13707756e-02f, 1.10604964e-01f, -9.66911763e-02f, 4.20013256e-02f, -1.09359056e-01f, 5.13752960e-02f, -7.18255416e-02f,
  -2.41945311e-01f, -2.83076197e-01f, -1.44417211e-01f, -1.10168792e-01f, 2.01445371e-01f, 7.07914904e-02f, 2.95822062e-02f, -8.89641643e-02f, -2.74512321e-01f, -4.83419523e-02f,
  5.97282387e-02f, -2.03841954e-01f, -1.34173140e-01f, -1.80274516e-01f, -2.14403048e-01f, -2.76714265e-01f, -1.34545833e-01f, 1.99962035e-02f, -2.08599508e-01f, 5.57451136e-02f,
  -9.59248394e-02f, -1.11915752e-01f, -1.52636200e-01f, 8.24704394e-02f, 1.11181289e-01f, 1.91793889e-01f, 1.89015850e-01f, 2.35953301e-01f, 1.67811692e-01f, -2.84346994e-02f,
  2.50916760e-02f, -1.89893380e-01f, -9.85801071e-02f, -1.27916252e-02f, 9.21988953e-03f, 4.39269617e-02f, 1.06077649e-01f, 4.93615121e-02f, 2.85322517e-02f, -1.76752619e-02f,
  1.18938647e-01f, 1.19614802e-01f, -8.06899965e-02f, -7.39866719e-02f, 2.89243441e-02f, -2.20933333e-02f, 3.05083767e-02f, -7.12903589e-03f, 1.23535842e-02f, 9.70508624e-03f,
  -2.85318699e-02f, 3.38070616e-02f, 2.53908522e-02f, -4.57691215e-03f, 3.54311094e-02f, 1.93179604e-02f, -2.56746728e-02f, 1.53682321e-01f, -3.15347128e-02f, -1.16697676e-01f,
  -1.79334148e-03f, -2.70263329e-02f, -1.08922176e-01f, -2.29237229e-02f, -6.81252480e-02f, -1.59267746e-02f, -4.09788117e-02f, -6.20336793e-02f, -6.27442747e-02f, -3.90321426e-02f,
  8.12864080e-02f, -3.72918136e-02f, 2.23764195e-03f, 9.55985785e-02f, -5.63554280e-02f, -8.61553252e-02f, 3.07716727e-02f, 1.07416905e-01f, 1.46705940e-01f, -2.64054090e-02f,
  -8.00251737e-02f, 1.08904384e-01f, 9.46732014e-02f, 2.49824394e-02f, -4.08833176e-02f, 5.25329933e-02f, 1.06721945e-01f, -2.65898462e-02f, 1.46597391e-02f, -7.28767249e-04f,
  1.98214293e-01f, -2.38758121e-02f, -5.92810325e-02f, 1.03410244e-01f, -3.50939557e-02f, -4.34893519e-02f, -1.79346368e-01f, -1.21927410e-02f, 6.13459945e-02f, -1.61894545e-01f,
  1.57994673e-01f, 8.07091817e-02f, 6.27425686e-02f, -6.50473461e-02f, 6.43792301e-02f, 3.14416066e-02f, 1.20433480e-01f, 1.87362432e-01f, 6.30714968e-02f, 1.30718797e-01f,
  1.14166655e-01f, 7.67944977e-02f, -1.16518043e-01f, -4.02836874e-02f, 8.20444748e-02f, 1.14297234e-01f, -3.12721245e-02f, 5.52669354e-02f, 3.90025377e-02f, 3.74900028e-02f,
  4.99658912e-01f, -2.66825467e-01f, -2.66386569e-01f, 1.87757537e-01f, 3.10162753e-01f, 1.96032643e-01f, 9.49859992e-02f, 2.29130968e-01f, 2.52394736e-01f, -7.46297911e-02f,
  2.38750353e-01f, -1.94733635e-01f, -2.62466967e-01f, 2.73898184e-01f, 2.31272623e-01f, -1.66965514e-01f, 2.27910131e-01f, 2.06044596e-02f, 3.99584696e-02f, 1.69230610e-01f,
  1.77161589e-01f, 3.24094683e-01f, -1.42632648e-01f, 4.39434573e-02f, 2.38153458e-01f, -5.99356964e-02f, 8.18593875e-02f, -1.41387388e-01f, -1.65442787e-02f, -4.27738503e-02f,
  6.71508629e-03f, 4.14456911e-02f, -1.97169371e-02f, -9.31447372e-02f, 4.79243286e-02f, 3.60479355e-02f, -1.17831722e-01f, -2.26598412e-01f, -2.39814389e-02f, 1.42536256e-02f,
  -2.11642757e-01f, -1.24615341e-01f, 7.00454861e-02f, 9.97128189e-02f, 1.77555040e-01f, 1.33519009e-01f, 9.95346438e-03f, -9.31537747e-02f, -1.19030304e-01f, 1.05172312e-02f,
  -3.51799577e-02f, 1.41328014e-02f, 3.49529088e-02f, -1.22003704e-01f, -6.76337853e-02f, 4.52536978e-02f, -1.12589784e-01f, -9.42800492e-02f, 2.86389980e-02f, 1.62174758e-02f,
  9.95844156e-02f, -1.41038269e-01f, 2.89517920e-02f, 1.50233973e-03f, 7.90686905e-02f, -6.29275218e-02f, 9.91409644e-02f, -2.06067506e-02f, 7.68755972e-02f, -8.82519502e-03f,
  4.88863289e-02f, 2.66207661e-03f, 5.49189635e-02f, 4.12433185e-02f, 7.94030651e-02f, 4.95957844e-02f, -4.02004011e-02f, -6.97791353e-02f, 5.60449585e-02f, -5.86382821e-02f,
  -3.20973136e-02f, 7.46541610e-03f, -2.88047642e-02f, -2.47390084e-02f, 9.42585152e-03f, 7.77732953e-02f, -2.52358485e-02f, 7.00868666e-02f, 1.21494476e-02f, -3.15024778e-02f,
  -3.47260609e-02f, -9.68837440e-02f, -4.93816100e-02f, -1.06450573e-01f, -1.50945678e-01f, 1.23648457e-01f, -4.09790827e-03f, -7.15321526e-02f, -3.31482366e-02f, 7.06993341e-02f,
  -7.44961649e-02f, 8.59578699e-03f, 1.31021902e-01f, 9.72419754e-02f, -5.94276264e-02f, 1.54213160e-01f, -1.18385583e-01f, -9.45260003e-02f, -4.72496301e-02f, -1.13168105e-01f,
  -6.21481910e-02f, 1.32472545e-01f, -6.10578135e-02f, -3.94675843e-02f, -1.05953276e-01f, -5.82098365e-02f, 1.00677952e-01f, 1.50557784e-02f, -1.63970981e-02f, -1.06317349e-01f,
  -2.82980576e-02f, 6.68890309e-03f, -1.05111338e-01f, -7.72349164e-02f, 9.61989611e-02f, 2.25857809e-01f, 6.08100370e-02f, 1.80167437e-01f, 6.20711502e-03f, -4.23190035e-02f,
  4.57822569e-02f, -2.03260660e-01f, -2.05324978e-01f, -4.01842967e-02f, 2.03201529e-02f, -1.33294538e-01f, 3.89940105e-02f, -7.22682923e-02f, 7.37879872e-02f, -1.15673179e-02f,
  -2.22323295e-02f, 5.48116490e-02f, -7.87909925e-02f, 2.98569590e-01f, -6.81198202e-03f, 8.78939256e-02f, -2.85496395e-02f, 1.49121046e-01f, 1.56427678e-02f, 5.48779108e-02f,
  4.92728539e-02f, -9.85393021e-03f, 4.55014817e-02f, 1.19387694e-01f, -1.64512154e-02f, -4.78184633e-02f, 6.41599894e-02f, 1.11655025e-02f, 9.82148275e-02f, 3.43997627e-02f,
  -1.39146047e-02f, -2.78761960e-03f, -9.96583025e-04f, 3.78542580e-02f, 1.23674922e-01f, 9.79047641e-03f, -4.13528793e-02f, 1.96603574e-02f, 4.70910817e-02f, -1.20852590e-01f,
  -6.54882193e-02f, -1.45802990e-01f, -7.77242780e-02f, -1.83582127e-01f, -1.44350631e-02f, -1.23693291e-02f, -8.09722915e-02f, -1.16739333e-01f, -8.74873027e-02f, -9.22762305e-02f,
  -4.54724394e-02f, -7.76275024e-02f, -4.83302865e-04f, 3.66143323e-02f, -4.93623838e-02f, -3.89810055e-02f, 7.15238824e-02f, -5.49611002e-02f, 6.65052012e-02f, -3.70278284e-02f,
  -1.86565407e-02f, 6.26995564e-02f, 3.18877809e-02f, -6.06864765e-02f, -7.84659311e-02f, -3.41874198e-03f, 3.76946554e-02f, -9.59982276e-02f, 3.99145894e-02f, 5.25624640e-02f,
  3.38164493e-02f, 3.08675994e-03f, -2.90397368e-02f, 5.30282408e-02f, 1.41540915e-01f, -6.91277981e-02f, -6.60843477e-02f, 1.87090654e-02f, 1.01489700e-01f, -7.85395578e-02f,
  -8.18739012e-02f, -1.35110259e-01f, 1.30798385e-01f, 8.85451809e-02f, 4.91315685e-02f, 9.34739783e-02f, 1.29097849e-01f, 7.30461031e-02f, 3.66373286e-02f, 1.16574680e-02f,
  9.79552977e-03f, 8.37010518e-02f, -1.98191106e-02f, -3.32159065e-02f, -8.11555702e-03f, 6.70671389e-02f, -8.63327011e-02f, 7.97403157e-02f, -8.67465138e-02f, -3.65399681e-02f,
  -6.13192969e-04f, -4.11770716e-02f, -6.02938607e-02f, -6.28477633e-02f, 1.19466959e-02f, -1.36330724e-01f, -1.33758341e-03f, 3.08620464e-02f, -1.20601594e-01f, -1.51646109e-02f,
  1.39957396e-02f, -3.60415205e-02f, -2.10009038e-01f, 1.23328701e-01f, -3.93299520e-01f, 4.83809561e-02f, 2.09129393e-01f, -1.00599393e-01f, 1.10774517e-01f, 2.57359266e-01f,
  1.64330304e-01f, -2.32289657e-02f, 1.96872771e-01f, 1.88523501e-01f, -1.72398046e-01f, 3.74174148e-01f, 2.18238950e-01f, 2.13415369e-01f, 4.90133800e-02f, 3.55224998e-04f,
  -8.64903331e-02f, 1.22055121e-01f, 8.49091262e-02f, -1.75635025e-01f, -1.81689814e-01f, -2.54408211e-01f, -9.28628668e-02f, -2.32487917e-01f, -5.39873503e-02f, -1.40917882e-01f,
  7.14632273e-02f, 2.18051709e-02f, -3.07038333e-02f, 8.92287791e-02f, -4.80354987e-02f, -9.85736586e-03f, 5.98590411e-02f, -1.42562032e-01f, -7.96333775e-02f, 8.46511871e-02f,
  1.12411804e-01f, 9.73012485e-03f, 5.11767976e-02f, -2.12566182e-01f, -7.59659559e-02f, -6.98618144e-02f, 1.45798758e-01f, 1.52163506e-01f, 9.59909707e-02f, 4.74498793e-02f,
  2.78851464e-02f, 1.99053576e-03f, 3.35655287e-02f, 5.76573759e-02f, -7.15191243e-03f, 1.87802203e-02f, 5.21515310e-03f, -4.39229384e-02f, -5.84146343e-02f, -6.99016973e-02f,
  -9.16089267e-02f, 2.98003424e-02f, 1.09762177e-01f, 3.01109441e-02f, -1.70389920e-01f, -6.60395622e-02f, 4.14911062e-02f, 3.25311907e-02f, -4.02744934e-02f, 4.42119129e-02f,
  6.19887151e-02f, -6.75040260e-02f, 8.53938460e-02f, -7.10710362e-02f, -1.84753928e-02f, 4.95163770e-03f, -9.57764611e-02f, 2.74207350e-02f, 5.53667471e-02f, -6.41161203e-02f,
  -2.82065421e-02f, -4.57110740e-02f, 2.20263544e-02f, 7.53877759e-02f, 6.11287951e-02f, -1.05984911e-01f, 1.40262321e-01f, 2.50359140e-02f, 5.95397130e-02f, 1.27672404e-03f,
  1.82580203e-02f, -5.22145182e-02f, 3.04700751e-02f, 4.85026650e-02f, -2.28966139e-02f, -2.68517975e-02f, 1.68253612e-02f, -4.24466003e-03f, -4.32979763e-02f, -2.19001770e-02f,
  1.70197040e-02f, 4.56630113e-03f, 1.16856143e-01f, -1.67127550e-01f, -2.90644937e-03f, 7.59823574e-03f, 2.26927847e-01f, -7.49532413e-03f, -3.29646058e-02f, -1.16611002e-02f,
  5.99960377e-03f, 5.29616624e-02f, 5.76916896e-02f, -4.56819165e-04f, 8.21240842e-02f, 1.30261347e-01f, -1.73114911e-01f, 1.39235584e-02f, -1.90711394e-02f, 2.37363763e-02f,
  -5.77671409e-01f, 2.61237979e-01f, -1.36168733e-01f, -2.36175954e-01f, -1.27259091e-01f, -1.19504957e-02f, 3.03151552e-02f, 3.27708386e-02f, 1.62417635e-01f, 2.58447528e-01f,
  9.52084810e-02f, -8.22576694e-03f, 4.31159109e-01f, 6.03718385e-02f, -2.07730755e-01f, 2.93254256e-01f, -1.23406112e-01f, -8.08991790e-02f, 1.16082348e-01f, 8.80435482e-03f,
  -1.07135057e-01f, -5.87748960e-02f, -1.79803222e-01f, 1.67482823e-01f, -2.66579598e-01f, -1.29261509e-01f, -1.31619871e-01f, 2.65481044e-02f, -3.04037780e-01f, -7.14067668e-02f,
  -2.41404444e-01f, -1.03572793e-01f, -2.48724353e-02f, -1.38674706e-01f, -1.50405973e-01f, -5.63647300e-02f, -6.25060126e-02f, 2.46382877e-02f, -1.87637154e-02f, 4.96417470e-02f,
  5.12136333e-02f, -9.38830301e-02f, -2.51463223e-02f, 1.67656615e-01f, -1.51028866e-02f, -7.88370967e-02f, -9.15904865e-02f, -1.96694151e-01f, 2.11109202e-02f, -8.47641379e-02f,
  2.08296180e-02f, -3.46604101e-02f, -9.62375104e-02f, -2.11470146e-02f, -1.74068660e-01f, -9.10823420e-02f, -1.15326554e-01f, -7.76635036e-02f, -6.25632554e-02f, -7.59998560e-02f,
  -1.67298329e-03f, 1.05990854e-04f, 5.74831590e-02f, -2.57582776e-02f, 1.86484814e-01f, -2.60517485e-02f, 1.97573435e-02f, -4.85877059e-02f, 3.98553908e-03f, -4.49415296e-02f,
  -3.40069756e-02f, -2.62647681e-02f, -4.94233258e-02f, -7.83843100e-02f, 7.17005953e-02f, 5.57557680e-02f, -3.24572958e-02f, -8.62051919e-02f, 6.66927770e-02f, -1.45827383e-01f,
  -3.15702446e-02f, -2.19240226e-03f, -1.02112908e-02f, -2.70646811e-02f, -3.75827849e-02f, 1.46642169e-02f, 1.08002983e-01f, 3.18547152e-02f, -7.70659149e-02f, -1.32979602e-02f,
  -2.42622986e-01f, -1.54863074e-01f, 2.53060577e-03f, -1.05525017e-01f, -3.69101912e-02f, -2.01808847e-03f, 4.55630980e-02f, -1.48100015e-02f, -1.11945204e-01f, 1.19134545e-01f,
  3.34708877e-02f, -8.21736604e-02f, 3.18172202e-02f, 1.16551116e-01f, 1.33613020e-01f, -9.05177295e-02f, 5.04935272e-02f, -9.65458713e-03f, 5.79005806e-03f, -1.57375131e-02f,
  3.14848572e-02f, 9.29062143e-02f, 7.06306398e-02f, -8.87419581e-02f, -1.09207280e-01f, -6.74016599e-04f, -2.69077718e-02f, 4.88076545e-03f, -1.03161737e-01f, 3.73718180e-02f,
  -2.44710639e-01f, 1.47168534e-02f, -2.94140816e-01f, -1.92942068e-01f, 1.34829670e-01f, -3.83389235e-01f, -1.71081826e-01f, -5.87669648e-02f, 2.20303312e-02f, 9.17611346e-02f,
  5.23197725e-02f, -5.03198244e-02f, 1.04184203e-01f, -3.17277163e-01f, -5.31945765e-01f, -1.76344126e-01f, -3.67757916e-01f, -2.51913816e-01f, -6.26049936e-02f, -2.00384483e-02f,
  -6.97626248e-02f, 2.45479569e-02f, -2.69966364e-01f, 2.50764847e-01f, -9.16393357e-04f, 1.82957545e-01f, 2.47746706e-01f, 1.35460466e-01f, -9.67447162e-02f, 1.74286738e-02f,
  -2.14964062e-01f, 1.62779361e-01f, -3.35378796e-02f, -2.17385478e-02f, -5.28295785e-02f, 5.46039119e-02f, -1.35448769e-01f, 5.03999032e-02f, 4.26886715e-02f, -5.41935069e-03f,
  -2.70938361e-03f, 6.80371076e-02f, -1.56209068e-02f, -5.33109196e-02f, -2.94077434e-02f, -2.49234438e-02f, -1.01024091e-01f, -4.25396487e-02f, 5.59631474e-02f, -1.47642344e-01f,
  -4.85047400e-02f, 1.63758118e-02f, -3.69369425e-02f, 7.70655051e-02f, 5.74447960e-02f, 1.58707984e-02f, -1.44348769e-02f, 1.79027468e-02f, 3.21127512e-02f, 3.03529967e-02f,
  1.11726820e-02f, 4.11580168e-02f, 7.54812779e-03f, -2.49657743e-02f, 6.63062111e-02f, 2.06931718e-02f, -2.85186898e-02f, 5.34999855e-02f, 4.03666645e-02f, 3.74158733e-02f,
  -1.95455309e-02f, 4.83721308e-03f, -6.49337694e-02f, 2.93551777e-02f, 4.00826335e-02f, 7.69496858e-02f, -5.20166568e-02f, -5.10682985e-02f, -5.21562509e-02f, -6.79638013e-02f,
  4.72167432e-02f, -1.98565125e-02f, 1.55988745e-02f, -1.12015726e-02f, -1.52630597e-01f, 1.35560647e-01f, 3.10368463e-02f, -1.37567163e-01f, -1.11108974e-01f, -4.76831421e-02f,
  -3.11166905e-02f, 1.90497190e-01f, 9.63802412e-02f, 4.63353135e-02f, 1.64526366e-02f, -3.72988731e-02f, -1.15948707e-01f, -1.29705388e-02f, 4.80814762e-02f, 6.01867624e-02f,
  -3.59544940e-02f, 4.86071408e-02f, 2.44295355e-02f, 2.40347274e-02f, -3.43034789e-02f, -8.24124366e-02f, 4.44476912e-03f, 1.98060106e-02f, 9.53102335e-02f, -1.56922378e-02f,
  9.88654569e-02f, 1.07536912e-01f, 9.12248194e-02f, 1.63177714e-01f, 6.86510429e-02f, 5.90656362e-02f, 3.50506492e-02f, 1.68778952e-02f, 9.81287882e-02f, 3.96603197e-02f,
  -2.32190236e-01f, -4.00616139e-01f, -1.18767001e-01f, -5.24825938e-02f, 5.70614152e-02f, -6.81299046e-02f, -1.47172108e-01f, -1.69553578e-01f, -2.44239435e-01f, -2.31626302e-01f,
  -1.38111860e-01f, 9.31402445e-02f, -2.47338220e-01f, -1.08067602e-01f, 6.33498132e-02f, -2.41217777e-01f, 1.90616399e-02f, 6.17217571e-02f, -1.73222438e-01f, -1.01904683e-01f,
  6.53912127e-02f, -1.29864171e-01f, 4.54021692e-02f, 4.88027632e-02f, 6.19761413e-04f, 3.41498137e-01f, 2.82960653e-01f, 1.80664748e-01f, 4.32492286e-01f, 2.10318491e-01f,
  -1.03100769e-01f, -1.46614343e-01f, -5.80871068e-02f, 2.92216595e-02f, 5.94935231e-02f, 1.14499539e-01f, 4.89519201e-02f, 8.94839466e-02f, 1.25274017e-01f, 4.49399687e-02f,
  6.57226983e-03f, 1.65047258e-01f, 2.69787330e-02f, 5.72670111e-03f, -8.40880908e-03f, -2.46156473e-02f, -3.74468975e-04f, -1.00279905e-01f, -9.18403417e-02f, 1.75656509e-02f,
  -1.11333683e-01f, -5.29486239e-02f, 3.49257365e-02f, 9.29999873e-02f, 7.98838809e-02f, 9.00849525e-04f, 1.24016859e-01f, 1.69791281e-01f, 9.63008180e-02f, 1.00664996e-01f,
  -1.39327034e-01f, 7.31225237e-02f, 7.78460279e-02f, 3.36110741e-02f, 7.19457213e-03f, 8.22331682e-02f, -4.43399809e-02f, -8.18661472e-04f, 6.34171441e-02f, -2.38322392e-02f,
  9.38192662e-03f, 1.09123446e-01f, -4.58542779e-02f, 1.30638648e-02f, 3.48611102e-02f, -9.42017883e-03f, 9.69762430e-02f, 6.71879202e-02f, -7.07171857e-02f, -6.28634244e-02f,
  -1.53879570e-02f, 8.15086588e-02f, -4.31935042e-02f, -6.73210397e-02f, -2.29518205e-01f, 5.20608872e-02f, -5.87564185e-02f, -4.42773364e-02f, 3.16173844e-02f, 1.82515010e-02f,
  -2.43421141e-02f, 1.97325740e-03f, 2.88775712e-02f, 7.27475137e-02f, -4.90926653e-02f, -8.11925810e-03f, -5.65190278e-02f, -3.24027911e-02f, -6.85250685e-02f, -7.36992061e-02f,
  -1.02022542e-02f, 1.68969825e-01f, -8.79921094e-02f, -1.99586004e-02f, 5.48707275e-03f, -3.59729603e-02f, -9.85424500e-03f, 3.82510088e-02f, -3.53680737e-02f, 3.46374884e-02f,
  -9.95165557e-02f, 4.53381352e-02f, 3.46560478e-02f, -3.06457058e-02f, -1.51162064e-02f, 1.02657266e-02f, 9.40398052e-02f, 4.91945893e-02f, 7.95742422e-02f, 1.24808680e-02f,
  2.44118139e-01f, 1.61001042e-01f, 2.68324733e-01f, 2.73467243e-01f, 1.72317967e-01f, -1.53349310e-01f, 6.79611936e-02f, 1.18955672e-01f, 3.09670061e-01f, -1.34432232e-02f,
  3.34896473e-03f, 1.21344656e-01f, -1.00372799e-01f, 2.08057705e-02f, -3.45066249e-01f, -1.96506709e-01f, -1.25899673e-01f, -9.94752869e-02f, -5.01677245e-02f, -1.29927811e-03f,
  -2.60107666e-02f, -1.97455496e-01f, -3.07005700e-02f, -1.02891415e-01f, 2.37801522e-01f, 1.76625982e-01f, -2.30461001e-01f, -4.48120385e-02f, 2.20665354e-02f, -8.32216293e-02f,
  -2.79278662e-02f, 2.05306813e-01f, 7.07708672e-02f, 2.77967211e-02f, 2.36247201e-02f, -1.27807511e-02f, -6.01492859e-02f, 5.73691400e-03f, 3.26329134e-02f, 3.16323079e-02f,
  6.52308539e-02f, 2.54555345e-02f, -2.80284174e-02f, 1.84611138e-02f, 3.30389515e-02f, 7.93753639e-02f, 1.15887865e-01f, 8.57139379e-02f, 7.87259936e-02f, 1.54594660e-01f,
  4.72261757e-02f, -6.29806891e-02f, -2.11290992e-03f, -4.24829349e-02f, 1.49383089e-02f, 1.17066689e-01f, -4.86870781e-02f, -2.18681600e-02f, -4.93052080e-02f, 7.93223679e-02f,
  6.50955960e-02f, -6.79374933e-02f, 1.93259325e-02f, -7.19789118e-02f, 1.38601661e-02f, 6.88133165e-02f, -2.92474050e-02f, -7.32054561e-02f, -3.90328802e-02f, -1.29217699e-01f,
  -5.53433746e-02f, 9.84336734e-02f, 6.15839250e-02f, -7.92530254e-02f, 4.29987274e-02f, 4.97571416e-02f, 6.39788283e-04f, -6.99056545e-03f, -4.65936493e-03f, 1.24871405e-02f,
  5.65163605e-02f, -1.10319071e-02f, -7.87320808e-02f, -5.55199198e-02f, -5.58964573e-02f, -7.58327311e-03f, 1.09073399e-02f, 6.53896108e-02f, -5.30101098e-02f, -1.16110258e-01f,
  -4.08723950e-01f, -3.70156437e-01f, -9.93566364e-02f, 3.71571481e-02f, 1.13214580e-02f, -6.29590824e-02f, -4.52987710e-03f, -3.43540646e-02f, -1.74019411e-01f, 3.63398753e-02f,
  5.54875471e-02f, 4.77691032e-02f, -3.83484624e-02f, -3.94826159e-02f, -1.09424159e-01f, -4.81762365e-02f, -4.96107563e-02f, -1.22331992e-01f, -1.83652595e-01f, -3.46838757e-02f,
  -1.38692493e-02f, -3.04885507e-02f, -7.32312649e-02f, -2.57537421e-02f, -2.76091248e-02f, -8.07750747e-02f, 4.30753231e-02f, 2.14885026e-02f, -1.37099579e-01f, 1.24349212e-02f,
  2.44608447e-01f, -2.96820551e-01f, -9.90548506e-02f, -1.88299268e-01f, 3.75041068e-02f, -7.88382888e-02f, -3.43239978e-02f, -2.53122568e-01f, -2.33178616e-01f, -2.57129818e-01f,
  -9.40377787e-02f, 8.64853188e-02f, 1.64189667e-01f, -2.35237807e-01f, 2.70615965e-01f, 1.26659125e-01f, -1.82108626e-01f, -1.05881415e-01f, 1.19071985e-02f, -7.13162348e-02f,
  5.40447570e-02f, -7.22120404e-02f, 8.47128555e-02f, -2.59002477e-01f, -5.55931963e-02f, -1.53143466e-01f, 2.23510582e-02f, 2.09277421e-02f, -2.38439813e-01f, 7.02740476e-02f,
  -4.32757623e-02f, 3.67396735e-02f, 9.45996214e-03f, -7.43416697e-02f, 5.49422912e-02f, 1.21596798e-01f, 3.49479541e-03f, 1.27684101e-01f, 1.29783023e-02f, -1.97737608e-02f,
  -1.51090268e-02f, 4.56536263e-02f, -1.20021664e-01f, 2.27941975e-01f, -6.11973330e-02f, -1.03302948e-01f, -1.33303106e-01f, -6.21047914e-02f, -1.11215018e-01f, 1.03314526e-01f,
  3.85455266e-02f, 3.21487933e-02f, -3.91706675e-02f, -7.71535560e-02f, -7.21378997e-02f, -2.81440951e-02f, 9.75407884e-02f, 7.30477348e-02f, -3.67164277e-02f, 2.77765989e-02f,
  -5.37808761e-02f, 1.23417780e-01f, 2.64395513e-02f, -4.16605882e-02f, 4.24214668e-04f, 1.04657002e-02f, -2.06087604e-02f, -5.00003211e-02f, 1.88113954e-02f, -2.95710843e-03f,
  -7.21190199e-02f, -1.03445463e-01f, -7.61322677e-02f, 3.60488556e-02f, 4.14004214e-02f, 5.29432185e-02f, 1.00602947e-01f, -6.80802613e-02f, -7.58574978e-02f, -1.12491220e-01f,
  8.86955187e-02f, 2.60366220e-02f, -5.19559756e-02f, -6.99459836e-02f, -8.40768963e-02f, 5.50105609e-02f, 3.07191466e-03f, 1.59775577e-02f, -5.67964055e-02f, 5.23228990e-03f,
  9.75800026e-03f, -1.08136408e-01f, -1.35871425e-01f, -1.02120876e-01f, -3.33987214e-02f, -3.60385403e-02f, 5.71531542e-02f, -2.19692796e-01f, -4.74133603e-02f, -7.99674615e-02f,
  -7.15940148e-02f, -4.55837250e-02f, -5.53662255e-02f, 8.90519284e-03f, -7.99476728e-02f, -1.16523355e-01f, 5.88987954e-02f, -4.38579777e-03f, 1.16900373e-02f, -8.31676573e-02f,
  1.09378835e-02f, -7.22639188e-02f, 7.73156201e-03f, -3.68554294e-02f, -1.64993331e-01f, 3.61232576e-03f, 9.01295021e-02f, -4.99772020e-02f, -3.82998288e-02f, -1.37093971e-02f,
  -4.92046140e-02f, -3.14434797e-01f, 2.34357730e-01f, -6.04996085e-02f, 4.76496667e-02f, 1.80494010e-01f, 3.40007395e-01f, -1.82623550e-01f, -2.13589668e-01f, -2.78165758e-01f,
  -1.34735733e-01f, 9.59800482e-02f, 2.17456922e-01f, -1.20400555e-01f, 3.85517538e-01f, 4.95164096e-02f, -2.45564748e-02f, 5.55234179e-02f, -1.15435138e-01f, 7.96522126e-02f,
  1.37638010e-03f, -9.93275791e-02f, 2.47610331e-01f, -2.69122899e-01f, 4.67239693e-02f, -1.20870642e-01f, -4.47642095e-02f, 1.62408978e-01f, -5.89596890e-02f, 5.78978024e-02f,
  -3.86014804e-02f, -1.45111501e-01f, -3.18733091e-03f, -1.33345336e-01f, -1.53978467e-01f, 7.26760477e-02f, 6.25258759e-02f, 1.41635701e-01f, 2.47526430e-02f, -3.33162509e-02f,
  1.85173843e-02f, 5.41498587e-02f, -6.98714256e-02f, 7.33157396e-02f, -4.79257636e-04f, -2.99483053e-02f, -5.95516302e-02f, -1.51224425e-02f, -6.50488958e-02f, 2.75591742e-02f,
  9.48513001e-02f, -1.01505704e-01f, 2.94027627e-02f, -1.05496578e-01f, -2.72888858e-02f, -5.90778217e-02f, 5.41876629e-02f, 7.13003501e-02f, -1.00997217e-01f, -5.73071837e-02f,
  -7.68381581e-02f, -5.72905736e-03f, 7.44195702e-03f, 5.36289178e-02f, -3.64284962e-02f, 6.38093129e-02f, 1.39181772e-02f, -9.61717591e-03f, -4.56283661e-03f, -4.57219444e-02f,
  7.49616418e-03f, -1.54607072e-02f, 1.04367100e-02f, 9.64121446e-02f, -8.93065557e-02f, -3.14943008e-02f, 1.03642568e-01f, -3.49331908e-02f, -4.32677679e-02f, -3.27055566e-02f,
  5.44818826e-02f, 9.57966670e-02f, -1.22449007e-02f, 1.22426664e-02f, -1.44433513e-01f, 1.07620172e-02f, -5.51118655e-03f, 8.89574736e-03f, 6.48718188e-03f, 9.63821858e-02f,
  -8.24419856e-02f, -1.64092720e-01f, -1.18412636e-01f, -7.74078146e-02f, -3.67346853e-02f, -9.01348144e-02f, -2.93567088e-02f, -2.06374303e-02f, -1.27611225e-02f, -7.84195773e-03f,
  -9.08055231e-02f, 5.73112555e-02f, 7.83753023e-02f, 1.27981707e-01f, -4.52069640e-02f, -1.63033772e-02f, 2.71508191e-02f, -7.14075118e-02f, -8.85458738e-02f, -6.98818192e-02f,
  -3.14574130e-02f, 2.08788626e-02f, 7.73894787e-02f, -8.62244219e-02f, -2.98630744e-02f, -7.89811648e-03f, -2.14065076e-03f, -1.24788262e-01f, 3.12303398e-02f, 5.62287755e-02f,
  3.87153089e-01f, -1.67012326e-02f, 2.05574751e-01f, 2.22862482e-01f, 1.07291728e-01f, 9.99553055e-02f, 3.26654494e-01f, -1.78365991e-01f, 1.12214655e-01f, -1.05035327e-01f,
  -6.31729960e-02f, 1.36245281e-01f, 1.08870845e-02f, -1.50762707e-01f, 8.71289801e-03f, -1.29313439e-01f, -1.52318608e-02f, 1.11345351e-01f, 9.19860303e-02f, 1.95347100e-01f,
  6.34271726e-02f, -2.26354778e-01f, -6.05461560e-02f, -2.94994026e-01f, 1.64827868e-01f, 3.43428515e-02f, -2.36710906e-01f, 8.50180313e-02f, -1.37885094e-01f, -6.32625595e-02f,
  2.47407705e-02f, 6.00612909e-02f, 5.84744364e-02f, 2.24193539e-02f, 1.02438599e-01f, 5.52195273e-02f, -3.66811454e-02f, -3.41427773e-02f, 3.76218818e-02f, -3.27055901e-02f,
  -3.68684605e-02f, -6.99624568e-02f, 7.03601018e-02f, 1.56027436e-01f, 1.44325659e-01f, 1.05848595e-01f, -9.85636003e-03f, 7.00177103e-02f, -6.12539724e-02f, 3.26037258e-02f,
  1.04183830e-01f, 1.30309984e-01f, 6.02272972e-02f, -4.37601805e-02f, -1.00669013e-02f, -3.86388078e-02f, -3.00356988e-02f, 2.79133860e-02f, 6.61600158e-02f, 2.29707081e-02f,
  -7.70625249e-02f, -5.11356480e-02f, -5.71856694e-03f, 3.20475996e-02f, 3.17961313e-02f, -1.37698678e-02f, 3.46557833e-02f, -7.82612190e-02f, -9.49320756e-03f, -7.18006715e-02f,
  9.71872360e-03f, 7.49024972e-02f, -5.23760319e-02f, 3.84183191e-02f, -4.37237322e-02f, -4.92100697e-03f, -5.73482066e-02f, -2.69276239e-02f, 1.31041467e-01f, 8.22787210e-02f,
  2.87408717e-02f, -2.15901397e-02f, 9.68127996e-02f, 6.11277064e-03f, 3.54373120e-02f, 1.53943785e-02f, -7.88234100e-02f, 1.80210418e-03f, -6.43331334e-02f, 7.53542408e-02f,
  -7.69241527e-02f, -1.92200750e-01f, -2.08287742e-02f, -5.08230068e-02f, 3.03985979e-02f, 8.08301419e-02f, -3.72355320e-02f, -3.98793928e-02f, 1.74517538e-02f, -1.05407007e-01f,
  1.29592977e-02f, 8.37257132e-02f, 1.21598318e-01f, 8.23726431e-02f, -2.82022394e-02f, -2.12095659e-02f, -1.01793639e-01f, 1.28810247e-02f, -1.58592984e-02f, -6.13561682e-02f,
  1.37751140e-02f, 1.67072251e-01f, 1.44389123e-02f, 3.96101549e-02f, -7.01826215e-02f, -2.91766804e-02f, 5.41420169e-02f, -2.60796994e-02f, 7.89214969e-02f, -7.79425651e-02f,
  -6.69031441e-01f, 3.12153488e-01f, -1.43366551e-03f, -1.59476832e-01f, -1.13591217e-01f, -1.90930869e-02f, 2.68153585e-02f, -4.45074365e-02f, -1.11897774e-01f, 2.18905091e-01f,
  9.03587788e-02f, -1.79931074e-01f, 2.03568161e-01f, 2.44724184e-01f, -3.47684234e-01f, 2.06065908e-01f, 1.40307341e-02f, -2.42319778e-02f, 5.91663681e-02f, -1.34487227e-01f,
  -9.99768749e-02f, 5.32950424e-02f, 1.00417040e-01f, 1.58099294e-01f, -1.41906692e-02f, -9.52690393e-02f, 3.63482721e-02f, 5.77916205e-02f, 7.24074468e-02f, 2.62055937e-02f,
  -1.66327953e-01f, -1.97670072e-01f, -5.30765541e-02f, -1.18206725e-01f, -1.17908686e-01f, -5.46076782e-02f, -4.50523384e-02f, -4.77880128e-02f, -1.33587152e-01f, -9.15471539e-02f,
  -1.90228261e-02f, -1.92605462e-02f, -6.65681511e-02f, 7.42586851e-02f, -8.70159641e-02f, -9.07830521e-03f, 7.70957246e-02f, 4.08767872e-02f, -4.62650098e-02f, 3.10513042e-02f,
  1.32644638e-01f, 1.41394762e-02f, 4.01260667e-02f, 2.63490882e-02f, 1.78534426e-02f, 7.88385794e-02f, 3.69568653e-02f, 5.63781597e-02f, -1.90608297e-02f, -4.62373570e-02f,
  -1.83865819e-02f, -4.36851522e-03f, -2.42471765e-03f, -7.59449601e-03f, -2.09031198e-02f, 6.77903965e-02f, 3.27562615e-02f, -1.80434305e-02f, -2.10660789e-02f, 9.78201628e-02f,
  -1.08656706e-02f, -6.92339838e-02f, -1.27233230e-02f, 3.43293487e-03f, 4.31714095e-02f, 1.25799829e-03f, -2.99090985e-02f, -7.17060044e-02f, 1.03480238e-02f, -3.31721865e-02f,
  -2.56043524e-02f, 4.21725176e-02f, 4.68843840e-02f, 2.20500529e-02f, -5.70487678e-02f, 3.47897559e-02f, 3.97923850e-02f, 4.75766547e-02f, -3.85822654e-02f, -1.60631500e-02f,
  -4.08946306e-01f, -3.73337537e-01f, -1.06825590e-01f, -1.17378414e-01f, -1.22097269e-01f, 1.41592044e-02f, -9.70503967e-03f, 3.06578688e-02f, -8.60175341e-02f, -9.91536453e-02f,
  -5.86102046e-02f, 1.17256731e-01f, -4.08859402e-02f, 1.48129612e-02f, -3.97201218e-02f, -3.61408293e-02f, -9.05230083e-03f, -1.00684881e-01f, -1.22891039e-01f, -1.03202283e-01f,
  -5.69050126e-02f, -3.47216576e-02f, 2.36177561e-03f, -9.37463657e-04f, 1.78986192e-02f, 6.75850967e-03f, -9.17841420e-02f, 3.43872346e-02f, -2.80002970e-02f, 6.95231110e-02f,
  -8.00069869e-02f, -1.42152563e-01f, 2.73914278e-01f, 7.58960843e-02f, -5.73844425e-02f, -1.90461397e-01f, 1.06425487e-01f, -1.06255509e-01f, -2.09236398e-01f, -2.95845568e-01f,
  -2.23732251e-03f, 1.93414092e-02f, 2.34311953e-01f, -1.04942016e-01f, 3.17171991e-01f, 5.08858189e-02f, -7.19572678e-02f, 5.57934381e-02f, 7.73073807e-02f, 1.78026333e-01f,
  1.02833606e-01f, -1.06391296e-01f, 2.87640065e-01f, -5.92844002e-02f, 6.80382326e-02f, 1.51493371e-01f, 1.41031533e-01f, 1.25423431e-01f, -5.10549508e-02f, -4.96156560e-03f,
  -7.69291520e-02f, 5.53609990e-02f, 8.10917541e-02f, -7.28641897e-02f, 4.98259738e-02f, 5.16405376e-03f, -4.57762703e-02f, 1.14148341e-01f, 7.95168728e-02f, 1.15084918e-02f,
  -2.03078538e-02f, 1.08426563e-01f, -5.95584624e-02f, 1.53748486e-02f, -1.55783594e-01f, -8.46472383e-02f, -1.29009485e-01f, -6.37959391e-02f, -4.44551371e-02f, 4.27432731e-02f,
  9.58553180e-02f, -5.61749935e-02f, -1.54974069e-02f, -5.66402159e-04f, 3.67171578e-02f, -9.40094367e-02f, 2.96919551e-02f, 5.17889857e-02f, -3.19617577e-02f, 5.38826920e-03f,
  -1.73773482e-01f, 1.41470088e-02f, 2.27758586e-02f, 1.01886488e-01f, -5.95456846e-02f, 5.58647625e-02f, -8.19024816e-02f, -7.18788579e-02f, 9.16741136e-03f, -4.13569137e-02f,
  -2.34560799e-02f, 5.01042716e-02f, -1.07391752e-01f, -1.11595048e-02f, -8.84731710e-02f, -8.82748291e-02f, 1.20836683e-01f, 5.24804108e-02f, -2.75756903e-02f, 3.24518979e-02f,
  9.62152258e-02f, -2.28170510e-02f, 5.39668500e-02f, -5.17866910e-02f, -1.23988576e-01f, 3.51295620e-02f, -6.80379197e-02f, -2.69871913e-02f, 7.85088912e-03f, 8.99551138e-02f,
  4.02356870e-02f, 7.40678608e-02f, 9.00615305e-02f, -3.14434879e-02f, 8.25371072e-02f, -3.97060998e-02f, -5.35949245e-02f, -5.82098924e-02f, -1.35845058e-02f, -1.93562917e-02f,
  -1.25312880e-01f, 8.61740038e-02f, -4.98557761e-02f, 1.49376187e-02f, 2.05089450e-02f, -1.84929147e-02f, -3.05631366e-02f, 8.53096545e-02f, 5.99261038e-02f, 1.12151727e-01f,
  4.99745011e-02f, -4.06708345e-02f, 3.98688279e-02f, 1.67073309e-02f, -4.18593325e-02f, 7.68740401e-02f, -1.08729163e-02f, -8.12742189e-02f, 7.03492835e-02f, 7.71763921e-02f,
  -8.08480680e-02f, 4.89250779e-01f, 2.34550804e-01f, 2.73283184e-01f, -1.09909326e-01f, -5.15092790e-01f, -1.65472969e-01f, 2.50719726e-01f, 4.05981317e-02f, 7.16989487e-02f,
  1.45368323e-01f, 6.39479980e-02f, 1.17162988e-01f, 2.74522245e-01f, -2.69833684e-01f, 6.22050725e-02f, -3.67499515e-03f, -2.25156243e-03f, -2.82099433e-02f, 2.81928033e-01f,
  -8.06013346e-02f, -4.29449752e-02f, 3.37905824e-01f, 3.89880203e-02f, 9.94299874e-02f, 1.41405880e-01f, 1.03159912e-01f, 1.62761346e-01f, 1.28264606e-01f, -1.24098726e-01f,
  7.72330984e-02f, 2.19683900e-01f, 1.68377280e-01f, -2.90900934e-02f, -3.85756753e-02f, -6.73297569e-02f, 3.23766954e-02f, -1.90372486e-02f, -1.70737337e-02f, 5.53702116e-02f,
  -3.68982524e-04f, -1.73361063e-01f, -7.36686075e-03f, -1.29931360e-01f, -4.10337634e-02f, 4.22648340e-02f, 7.83437714e-02f, -3.55322622e-02f, 9.48111415e-02f, 2.01183408e-02f,
  5.18105030e-02f, 3.79755534e-02f, 5.31044677e-02f, -1.20032942e-02f, -6.80715144e-02f, -1.69164807e-01f, -1.08157679e-01f, -9.51904152e-03f, 3.75175923e-02f, -2.39121784e-02f,
  -9.99918580e-02f, -2.50448138e-02f, 1.11031651e-01f, 1.30761921e-01f, 4.43541296e-02f, 5.72641157e-02f, 3.05073559e-02f, 2.97276359e-02f, -5.41975647e-02f, -6.44625127e-02f,
  -2.56252605e-02f, 1.82396360e-02f, 5.44362031e-02f, -1.29286543e-01f, -4.24497165e-02f, -1.16782524e-01f, 3.98120172e-02f, 8.39167647e-03f, -5.82077801e-02f, -1.85034573e-02f,
  5.66025563e-02f, -4.99460921e-02f, 1.01054780e-01f, -2.21349448e-02f, 5.87073490e-02f, -8.04028586e-02f, 9.93517339e-02f, 4.30755727e-02f, 1.91527203e-01f, 3.91145758e-02f,
  -1.44794276e-02f, 3.62059586e-02f, -1.49437729e-02f, -1.30323628e-02f, 7.09428042e-02f, -2.74480358e-02f, -1.08634055e-01f, -1.59153175e-02f, -3.37254517e-02f, -8.32000300e-02f,
  -2.81853229e-02f, -3.88728790e-02f, -8.58792439e-02f, -5.43819815e-02f, 7.37700686e-02f, -3.63215664e-03f, 3.30972262e-02f, -2.14510970e-02f, 5.02727814e-02f, 1.08411580e-01f,
  1.59028202e-01f, -3.05294413e-02f, 1.57049317e-02f, -7.61131793e-02f, -8.27763677e-02f, -5.63281663e-02f, -9.45376977e-03f, 6.15188405e-02f, 6.63982844e-03f, -4.66680191e-02f,
  -1.19177982e-01f, 3.93152177e-01f, 8.30938295e-02f, -1.47668168e-01f, -7.78302848e-02f, -1.75757349e-01f, -3.19221407e-01f, 4.36264975e-03f, 7.24232346e-02f, 1.58910975e-02f,
  -1.84375048e-01f, 3.22350025e-01f, 6.01297617e-02f, -1.67049557e-01f, -8.25412422e-02f, 5.53580709e-02f, -2.16913432e-01f, -2.16030777e-02f, 1.96688488e-01f, -6.87377229e-02f,
  2.62017865e-02f, -3.07630450e-01f, -1.43355494e-02f, -2.93374807e-02f, -1.66557357e-01f, -5.50111830e-02f, -1.81254447e-01f, 3.55049111e-02f, -1.31002113e-01f, -2.72640847e-02f,
  -1.17270596e-01f, -2.38988519e-01f, -1.71973079e-01f, -9.14428830e-02f, -1.50633931e-01f, -2.68131401e-02f, -1.20027140e-01f, -9.97679681e-02f, -8.82961228e-02f, 1.39666582e-02f,
  8.94442108e-03f, -3.95163000e-02f, 5.35444617e-02f, 7.29807317e-02f, -9.39418934e-03f, -2.12190058e-02f, -1.21411774e-02f, -3.70990075e-02f, -2.30862815e-02f, 9.00990218e-02f,
  1.37218401e-01f, 3.46008427e-02f, -3.30753811e-02f, -5.38382865e-02f, -4.98605072e-02f, -1.09024242e-01f, -2.94379462e-02f, -2.67348513e-02f, 5.02319448e-02f, 1.49785448e-03f,
  2.03966107e-02f, -3.61108175e-03f, -7.70308822e-03f, 1.81167312e-02f, 8.43400427e-04f, -1.41115757e-02f, 8.27380568e-02f, -4.22009826e-02f, -9.96644422e-02f, -5.19943796e-02f,
  -6.83815777e-02f, 7.37759797e-03f, -3.56476870e-03f, 9.51702297e-02f, 4.31132615e-02f, -2.39759195e-03f, -1.33960113e-01f, -4.10965830e-02f, 7.20078051e-02f, 1.63488798e-02f,
  -1.16085187e-02f, -6.74016103e-02f, 5.28754368e-02f, 4.39053178e-02f, -4.91624959e-02f, 5.20677194e-02f, 2.56673750e-02f, 4.89475802e-02f, -2.00507175e-02f, 4.84547205e-02f,
  -1.71194002e-01f, -2.99556315e-01f, -9.30318758e-02f, -1.07842766e-01f, -5.00958003e-02f, -2.43388638e-02f, -4.79632467e-02f, -4.40009758e-02f, -6.72709122e-02f, -4.15278822e-02f,
  -8.57833847e-02f, -4.91558239e-02f, -3.36619169e-02f, 3.22489105e-02f, 9.45843309e-02f, 5.29060466e-03f, -2.37850025e-02f, 4.55837743e-03f, -5.31356782e-02f, 1.44928306e-01f,
  7.92813450e-02f, -2.38240436e-02f, 1.57091394e-02f, -9.07795206e-02f, -7.67297298e-02f, -4.23831008e-02f, -2.31669266e-02f, 4.08674553e-02f, -8.97223596e-03f, 5.88183925e-02f,
  5.46225786e-01f, 3.08331009e-02f, -2.50961240e-02f, 1.00652173e-01f, 1.60325505e-02f, 2.15477064e-01f, 1.60085008e-01f, 1.18595585e-01f, 2.02819094e-01f, -2.84087751e-02f,
  -2.60143951e-02f, 1.26161158e-01f, -9.61641818e-02f, 1.36162266e-01f, 2.36659825e-01f, -1.70925274e-01f, 2.35634506e-01f, 4.58346382e-02f, 5.87634789e-03f, 2.11074710e-01f,
  1.37227729e-01f, 2.08417073e-01f, -1.37420952e-01f, -1.57403282e-03f, 2.35389963e-01f, -1.19600207e-01f, -1.79928690e-01f, -2.02544764e-01f, -1.25418797e-01f, -2.89430544e-02f,
  -9.27938800e-03f, -8.10261071e-03f, 2.93732472e-02f, -1.90433450e-02f, -1.42705208e-02f, 1.67288873e-02f, -9.31078643e-02f, -1.33067161e-01f, -2.49732123e-03f, 7.45927077e-03f,
  1.26855215e-02f, -7.84419999e-02f, -1.76017117e-02f, 8.95839706e-02f, 1.82161674e-01f, 7.13487118e-02f, 3.59482728e-02f, -6.92086890e-02f, -6.88390359e-02f, 1.75837371e-02f,
  6.91240206e-02f, -8.68337750e-02f, 8.02418888e-02f, -1.05310731e-01f, -3.56626771e-02f, -1.39049748e-02f, -1.61421243e-02f, -6.54519722e-02f, -3.25930342e-02f, -2.06283107e-03f,
  -3.54959816e-02f, -3.10177449e-02f, 1.65651944e-02f, 1.67837124e-02f, 3.65948901e-02f, -1.79711774e-01f, 9.13723037e-02f, -2.80447397e-02f, 1.15373842e-01f, -7.33009800e-02f,
  -6.61310414e-03f, 8.02758485e-02f, 1.94723792e-02f, 8.83282200e-02f, 8.48795697e-02f, 9.76650715e-02f, -7.46898428e-02f, -9.63027924e-02f, 7.25901425e-02f, -3.95185687e-02f,
  -1.87702253e-02f, 2.43638246e-03f, -9.69349116e-04f, 2.16043908e-02f, 2.88831796e-02f, 1.01260878e-01f, 1.19656892e-02f, -1.28774540e-02f, -5.09440638e-02f, 3.50400545e-02f,
  -3.81868258e-02f, -2.72848662e-02f, -1.46855135e-02f, -1.00877889e-01f, -1.35948882e-01f, 7.73307905e-02f, 7.96926990e-02f, -4.66715693e-02f, 3.43232602e-02f, -8.95826332e-03f,
  3.76293692e-03f, -3.86515930e-02f, -5.49441837e-02f, 1.10827796e-01f, -5.26027977e-02f, 1.30566522e-01f, -8.48939344e-02f, -1.13397762e-01f, -1.16130792e-01f, -9.07430276e-02f,
  -5.22630066e-02f, 3.95050868e-02f, 9.79916379e-03f, -9.19622108e-02f, -5.99357784e-02f, -1.19854338e-01f, 6.50673956e-02f, 5.55109642e-02f, -6.94897771e-03f, -1.27765879e-01f,
  3.53138477e-01f, -2.31869191e-01f, 5.99025674e-02f, 3.33678693e-01f, 1.84994698e-01f, 1.03041127e-01f, 3.14092219e-01f, 1.43648041e-02f, 4.32960004e-01f, -2.52583504e-01f,
  -1.10793091e-01f, -4.71055768e-02f, -5.54420389e-02f, -7.14874119e-02f, 3.39569569e-01f, -7.24243373e-02f, 1.75375104e-01f, 1.68383256e-01f, 3.26769389e-02f, -3.88360731e-02f,
  1.85261533e-01f, -9.93251503e-02f, -1.44106299e-01f, -1.92439094e-01f, 1.15016401e-02f, -8.73549655e-02f, -2.66769409e-01f, -8.10979772e-03f, -3.19817722e-01f, 1.91325154e-02f,
  -2.00131796e-02f, 7.24288896e-02f, -9.03588310e-02f, -2.71141771e-02f, 3.27037983e-02f, -7.92946145e-02f, -8.96718800e-02f, -1.03061043e-01f, 1.28563911e-01f, -1.48156479e-01f,
  -1.63628650e-03f, -5.06288633e-02f, -3.63080166e-02f, 7.26512372e-02f, 9.14768726e-02f, -8.10939446e-02f, -2.51268856e-02f, -2.45746803e-02f, -8.34112540e-02f, -5.65343015e-02f,
  7.25924671e-02f, -4.03366685e-02f, 7.87186399e-02f, -1.08165666e-01f, -2.01366339e-02f, 4.13082726e-02f, -4.07805070e-02f, 2.70639057e-03f, -5.79893291e-02f, -1.48526405e-03f,
  -5.15392497e-02f, 5.08151855e-03f, -6.45260587e-02f, -5.02074622e-02f, 9.85778868e-02f, -6.76648319e-02f, 4.21742983e-02f, -4.05835360e-02f, 1.25139430e-01f, -4.86322492e-03f,
  4.56653014e-02f, -4.04050462e-02f, 6.44214079e-03f, 1.78286701e-01f, 4.36982466e-03f, -4.63379808e-02f, -1.67748570e-01f, -5.49326725e-02f, 1.21633209e-01f, 3.83120589e-02f,
  -3.56465019e-02f, 3.55342366e-02f, 9.45654698e-03f, -1.86037570e-02f, -1.31865945e-02f, 4.38187793e-02f, -7.51072392e-02f, -2.21191756e-02f, -7.85569027e-02f, 3.11677493e-02f,
  6.61497638e-02f, -7.05832019e-02f, -1.27622858e-02f, -1.28908396e-01f, -4.34937961e-02f, -6.79121614e-02f, -4.29417640e-02f, -4.69988473e-02f, -1.76452268e-02f, -7.56884888e-02f,
  -6.62280768e-02f, -5.60900057e-03f, 1.82649834e-04f, 3.63117680e-02f, 8.41244869e-03f, -1.63437754e-01f, -3.51646617e-02f, -1.07184621e-02f, -3.33111584e-02f, -8.88242573e-02f,
  -9.26465914e-02f, 4.06829752e-02f, 6.68139979e-02f, 4.71353605e-02f, -5.50028309e-02f, -2.82775573e-02f, 3.00340056e-02f, -1.40201626e-02f, 3.09672970e-02f, -3.11409961e-02f,
  -3.51834334e-02f, -1.86801732e-01f, -4.01435755e-02f, 7.93639198e-02f, 2.25937217e-01f, -1.58674151e-01f, -2.51582950e-01f, 5.10562770e-02f, 5.41219227e-02f, -2.44870454e-01f,
  -4.40532751e-02f, -1.00898258e-01f, -2.37909257e-01f, -4.32106219e-02f, 1.55825540e-01f, -1.01923558e-03f, -7.26199523e-02f, -1.45372227e-01f, 7.74722472e-02f, -1.83536813e-01f,
  1.44275412e-01f, 1.42675027e-01f, 1.00511052e-02f, 1.48550510e-01f, 7.26575702e-02f, -2.10433397e-02f, 1.06797880e-02f, 1.19960923e-02f, 3.15361619e-02f, 8.20602998e-02f,
  -1.65561438e-01f, -8.50384980e-02f, -1.61384568e-01f, -4.93384041e-02f, -5.26645556e-02f, -2.34005861e-02f, -7.67337605e-02f, 4.09097672e-02f, 4.87896353e-02f, 5.67259034e-04f,
  -1.26880214e-01f, 7.24123139e-03f, -1.76429637e-02f, 4.28292640e-02f, -2.37854663e-02f, 7.82911852e-02f, 9.47891697e-02f, -1.24920020e-02f, -6.23884983e-02f, 2.11558063e-02f,
  -2.11791191e-02f, -7.11576864e-02f, -2.86339242e-02f, -1.02867279e-02f, 1.07196043e-03f, 4.78322841e-02f, 3.00336163e-02f, -7.71828145e-02f, -3.38965394e-02f, 1.54636065e-02f,
  5.74752130e-02f, -8.86961520e-02f, 3.31633128e-02f, -2.93155182e-02f, -7.54291266e-02f, -3.99686024e-03f, 1.44416047e-02f, -2.38145292e-02f, -6.82894439e-02f, -8.80761654e-04f,
  6.35407642e-02f, 3.37882638e-02f, 4.93125431e-02f, -4.05380055e-02f, -3.50168757e-02f, 5.03480667e-03f, 8.84076208e-02f, 1.84388068e-02f, 1.93906706e-02f, -2.26828586e-02f,
  5.87625504e-02f, -2.99931448e-02f, 2.50211675e-02f, 8.22563097e-02f, -1.79950288e-03f, -4.64737676e-02f, -1.29443593e-02f, 5.26999980e-02f, -1.45165483e-02f, 2.27976013e-02f,
  -3.85498703e-01f, -3.34898680e-01f, -5.48693165e-02f, 1.86240245e-02f, -2.44691502e-02f, 5.19689359e-02f, 7.22186714e-02f, 1.10721841e-01f, -1.55135781e-01f, -3.74542437e-02f,
  -3.99309248e-02f, -4.56733722e-03f, 7.94126540e-02f, 5.14498390e-02f, 5.16437441e-02f, 1.16072886e-01f, -4.78998981e-02f, -6.03560619e-02f, -6.32582977e-03f, -5.08008972e-02f,
  -5.59324026e-02f, 7.82038122e-02f, -3.64343859e-02f, 8.65283608e-02f, 2.94822012e-03f, -1.65178720e-02f, 1.17837295e-01f, -1.41132984e-03f, 8.63472819e-02f, 3.09703480e-02f,
  -1.94545805e-01f, 4.37650174e-01f, 2.82677889e-01f, -1.50312215e-01f, -3.90603533e-03f, 1.53991833e-01f, -7.32360259e-02f, 7.94899911e-02f, -1.54200852e-01f, 7.16278479e-02f,
  -1.38429746e-01f, 2.05959305e-01f, 5.19537367e-03f, -4.55413349e-02f, -3.39416146e-01f, -1.17873907e-01f, -9.16965976e-02f, -3.61800604e-02f, 4.25030738e-02f, 1.65591519e-02f,
  -1.08391084e-01f, -2.37750322e-01f, -2.24201698e-02f, 1.19283713e-01f, 9.08489898e-02f, 1.18631124e-01f, -2.75734037e-01f, 1.22980915e-01f, -3.78668308e-02f, 3.22972387e-02f,
  5.21887727e-02f, -6.65275827e-02f, -6.78694295e-03f, 2.50462373e-03f, -1.50096893e-01f, -5.97536303e-02f, -9.53092426e-03f, -4.26870324e-02f, -2.27064323e-02f, 5.66819534e-02f,
  -2.47521978e-02f, 1.19562097e-01f, -2.58835796e-02f, 5.52942185e-03f, 3.93431745e-02f, 1.49878964e-01f, 1.83706239e-01f, 3.26872356e-02f, 1.17751576e-01f, 1.33422583e-01f,
  1.05828524e-01f, 1.58376008e-01f, 5.52360304e-02f, 2.32280046e-02f, -8.56623519e-03f, 6.57810420e-02f, 1.27046574e-02f, 3.02677173e-02f, 1.09274700e-01f, 7.54017476e-03f,
  -6.03163941e-03f, -9.84450579e-02f, 3.60982306e-02f, 6.72575533e-02f, -7.61974975e-02f, -7.79706892e-03f, 4.09456389e-03f, -3.68157513e-02f, 1.66574325e-02f, 5.91668636e-02f,
  -4.57926653e-03f, -2.38506068e-02f, -2.16865856e-02f, 4.26589558e-03f, -1.51991576e-01f, -1.69301685e-02f, 4.57769185e-02f, 3.69009189e-02f, -8.37675184e-02f, -3.99810635e-02f,
  3.12809162e-02f, -1.36889080e-02f, -1.27640709e-01f, -2.63989158e-02f, 7.57378191e-02f, -3.29021402e-02f, -3.97444703e-02f, 1.01327978e-01f, -3.27613018e-02f, -6.20690957e-02f,
  -1.50780484e-01f, -3.11932296e-01f, -4.52989042e-02f, 3.19977775e-02f, -2.23837048e-02f, 1.27588268e-02f, -1.58681571e-02f, 3.18264291e-02f, -1.50219342e-02f, -7.43843429e-03f,
  -8.27054903e-02f, -4.32875305e-02f, -1.08245295e-02f, 2.36912426e-02f, -1.27636120e-01f, -6.82579130e-02f, -3.01201046e-02f, -5.58552369e-02f, -4.81765345e-02f, 5.26403412e-02f,
  2.53659934e-02f, 1.20197115e-02f, -1.42960912e-02f, -6.90781772e-02f, -8.50795656e-02f, 3.11467517e-02f, -9.29650068e-02f, 7.07185715e-02f, 2.07867678e-02f, -6.40200302e-02f,
  -6.55130506e-01f, 1.85238585e-01f, 1.31544828e-01f, -1.09528536e-02f, -3.22947294e-01f, 9.21375751e-02f, 1.62292153e-01f, 1.47952642e-02f, 3.31696197e-02f, 2.47009680e-01f,
  -5.26371002e-02f, -1.88784942e-01f, 1.65600583e-01f, 2.56930083e-01f, -1.24960385e-01f, 3.44735295e-01f, 2.08300784e-01f, -2.73987278e-02f, 4.83746007e-02f, -7.19649866e-02f,
  -7.09683597e-02f, -1.83120862e-01f, 2.47876316e-01f, 3.58070694e-02f, -8.83423761e-02f, 6.33063319e-04f, -3.14742774e-02f, -3.25901620e-02f, 4.95066829e-02f, -8.98813382e-02f,
  -7.89930597e-02f, -2.87466329e-02f, 6.48841411e-02f, -7.07773790e-02f, -1.46457508e-01f, -1.43446028e-02f, 5.91954477e-02f, -7.74520785e-02f, -5.74306846e-02f, -2.52350401e-02f,
  -6.61398694e-02f, -2.31581293e-02f, -4.91139367e-02f, -4.87126000e-02f, -9.62312073e-02f, -6.10914640e-02f, 9.38472822e-02f, 2.22596675e-02f, -1.45381644e-01f, 8.40606317e-02f,
  7.19627813e-02f, 7.75845870e-02f, 5.21047488e-02f, 6.01704866e-02f, -3.29041444e-02f, -1.26553830e-02f, 9.18346867e-02f, 7.73840398e-02f, 4.73742820e-02f, -9.78490263e-02f,
  5.78066967e-02f, 7.79019967e-02f, 9.40930024e-02f, -5.62492348e-02f, 3.81392092e-02f, -1.01308793e-01f, 4.59659062e-02f, -1.61428321e-02f, 4.22435775e-02f, 8.98251403e-03f,
  -7.43487403e-02f, -4.02737036e-03f, -4.83307205e-02f, 2.94272229e-02f, -1.27422977e-02f, 7.45197684e-02f, 4.48475704e-02f, -4.57723960e-02f, 1.86552834e-02f, -3.83397527e-02f,
  -1.44314300e-03f, 2.29733549e-02f, -5.65721169e-02f, 2.30504991e-03f, 2.11285204e-02f, 9.48663577e-02f, 1.04497790e-01f, 7.11513162e-02f, -1.13642596e-01f, -1.84373543e-01f,
  -2.61502504e-01f, -1.74857602e-01f, -3.07771619e-02f, -1.66981652e-01f, -4.70162146e-02f, -5.00787806e-04f, 2.05279868e-02f, -4.54153605e-02f, -9.81392115e-02f, -1.69831589e-02f,
  5.80476713e-04f, 1.16181605e-01f, -1.98937152e-02f, 4.92783450e-02f, 1.66452006e-02f, -6.35105893e-02f, -5.38415574e-02f, -7.19089434e-02f, -1.67190403e-01f, -2.33679209e-02f,
  -9.31221396e-02f, -2.43382305e-02f, -4.42428328e-02f, -3.28556336e-02f, 1.65873803e-02f, -4.30558920e-02f, -1.04568236e-01f, 9.79123339e-02f, -8.20028111e-02f, 5.45895807e-02f,
  1.32616565e-01f, -1.30454466e-01f, -2.16150641e-01f, -6.02518395e-02f, -2.17648953e-01f, 3.50500233e-02f, 1.09996684e-01f, -1.83931708e-01f, -9.67178345e-02f, 7.79851228e-02f,
  -2.14015752e-01f, 6.32825494e-02f, 1.67118251e-01f, -1.56052083e-01f, 1.77212000e-01f, 1.67345271e-01f, 9.06355307e-03f, 9.09702480e-02f, -8.92428234e-02f, -4.25896160e-02f,
  8.12607072e-03f, 1.13399722e-01f, -4.42839116e-02f, -2.02270582e-01f, -2.36607224e-01f, -3.67207617e-01f, -7.33936206e-02f, -3.29206109e-01f, -2.44642138e-01f, -9.82951596e-02f,
  -5.57227023e-02f, -5.84233105e-02f, -6.97780326e-02f, 8.75845924e-02f, 8.32455233e-03f, 1.03832446e-01f, 8.55232850e-02f, 4.85559180e-02f, -7.38670677e-02f, -9.49395224e-02f,
  1.50125459e-01f, -5.46278991e-03f, -1.09135658e-01f, -1.58768758e-01f, -7.85150230e-02f, -1.01792954e-01f, 2.99108196e-02f, -1.80264562e-02f, 4.61581536e-02f, 2.91432999e-02f,
  -6.40560165e-02f, -8.52706134e-02f, -1.30111709e-01f, 1.52281448e-01f, 6.41164482e-02f, -5.16879819e-02f, 1.62817135e-01f, 8.67872983e-02f, 9.84097123e-02f, 3.64027731e-02f,
  -1.35443304e-02f, 1.42341971e-01f, 2.34370790e-02f, -2.66626924e-02f, -5.05894870e-02f, -1.05511442e-01f, 2.03069057e-02f, -4.31415103e-02f, -3.47741856e-03f, 4.19817027e-03f,
  -4.42543216e-02f, 1.22896293e-02f, -1.27139345e-01f, 3.46563980e-02f, 6.06968217e-02f, 1.11804567e-01f, -3.17647383e-02f, 3.42344819e-03f, -1.29805416e-01f, -1.01856314e-01f,
  -1.36811569e-01f, 5.23356386e-02f, -3.48603688e-02f, 7.20505789e-02f, -7.73131251e-02f, 4.56647612e-02f, 3.88206169e-02f, -6.08637743e-02f, -1.96247965e-01f, 1.30153224e-01f,
  -4.43537980e-02f, 2.96800155e-02f, -2.30962336e-02f, 1.09480388e-01f, 3.84688713e-02f, -2.82313284e-02f, 6.96436912e-02f, 3.96895297e-02f, -4.80319597e-02f, 9.75923464e-02f,
  6.56844466e-04f, -2.04626098e-02f, -6.04734123e-02f, -1.34220302e-01f, -3.27750593e-02f, -1.70730706e-02f, 2.19097093e-01f, -5.98398522e-02f, 5.80223650e-02f, -7.72990808e-02f,
  5.95453903e-02f, -2.57496648e-02f, 7.96785727e-02f, 1.02410831e-01f, 1.29682496e-01f, 8.58687162e-02f, -7.98002407e-02f, 5.89844361e-02f, 1.80515125e-01f, -5.30036874e-02f,
  -3.81698042e-01f, 2.96951681e-01f, 2.51869887e-01f, 8.47571194e-02f, -2.95017213e-01f, 1.84217587e-01f, 3.00089419e-01f, -5.20196483e-02f, 2.17655614e-01f, 2.05493093e-01f,
  -1.33081749e-01f, -5.13009019e-02f, 6.16742894e-02f, 1.79278001e-01f, -3.94551037e-03f, 3.03483307e-01f, 2.18644693e-01f, 1.51678964e-01f, 6.59933267e-03f, -7.93484375e-02f,
  -9.19289663e-02f, -9.24072936e-02f, 7.18997717e-02f, -6.60747588e-02f, -1.57899410e-01f, -5.77086816e-03f, -1.61085665e-01f, -1.16372518e-02f, -3.57964151e-02f, 7.99101815e-02f,
  -9.93613005e-02f, -1.08287312e-01f, -1.18896656e-01f, 3.57259600e-03f, -6.10689893e-02f, 8.08896497e-03f, 5.58569608e-03f, -3.02108806e-02f, -1.19161494e-02f, 1.37398085e-02f,
  -1.03989415e-01f, 1.71990413e-02f, -1.10401906e-01f, 2.23924797e-02f, -2.35043913e-02f, -1.92708138e-03f, 2.71836650e-02f, 2.33599246e-02f, -5.59032857e-02f, 5.03153987e-02f,
  2.34072609e-03f, 1.13698561e-02f, -5.27802110e-02f, 7.84306750e-02f, -8.66907611e-02f, 4.74548480e-03f, 1.62038907e-01f, 6.76076040e-02f, 1.90086458e-02f, -6.93246629e-03f,
  -3.28415260e-02f, 6.61225691e-02f, 5.12911715e-02f, 1.03503875e-02f, 2.14974359e-02f, -5.59702627e-02f, 3.10743954e-02f, -2.75101643e-02f, -4.71654674e-03f, -4.05622721e-02f,
  9.77929682e-03f, -6.29500970e-02f, -6.86030537e-02f, 7.83864856e-02f, 5.59655353e-02f, 5.72735369e-02f, 1.23053752e-02f, -1.39656961e-02f, -1.09520061e-02f, -3.86419706e-02f,
  7.48658460e-03f, 2.45232712e-02f, -1.41922329e-02f, -1.40153319e-02f, 8.23325440e-02f, -3.23074237e-02f, -1.34159857e-03f, 1.01167731e-01f, -2.66266242e-02f, -1.43870950e-01f,
  -3.66931339e-03f, 5.38865179e-02f, -8.04953203e-02f, -8.47801566e-02f, 1.12824596e-03f, -4.72260043e-02f, 5.91469277e-03f, -6.28050342e-02f, -1.08563888e-03f, -2.65099350e-02f,
  -1.41528174e-02f, 5.45894839e-02f, -2.96513662e-02f, 3.74575495e-03f, -3.18511613e-02f, -5.65129332e-03f, -3.57441083e-02f, -7.69790635e-02f, -4.94505130e-02f, -5.69234006e-02f,
  -1.69025764e-01f, -4.89614112e-03f, -3.06236930e-02f, -7.50034004e-02f, -6.00314774e-02f, -4.90491278e-02f, -6.39033541e-02f, -3.35826725e-02f, -7.91550800e-02f, 5.16663864e-02f,
  -7.82943368e-02f, 2.88079947e-01f, -1.69823468e-01f, 1.13374628e-01f, -1.52758420e-01f, 1.48264483e-01f, 1.79262891e-01f, -7.39500225e-02f, -1.28982618e-01f, 2.90188968e-01f,
  2.62475848e-01f, -1.60448477e-01f, 2.13035300e-01f, 3.06049824e-01f, -1.36829913e-01f, 2.30877340e-01f, 2.86999017e-01f, 6.42689094e-02f, 6.18549362e-02f, 9.89781097e-02f,
  -8.66463259e-02f, 3.50405753e-01f, 1.42551944e-01f, 9.48345140e-02f, 4.25857119e-02f, -2.02893719e-01f, 1.27839133e-01f, -1.35064140e-01f, 1.15411334e-01f, -9.82258618e-02f,
  1.73069179e-01f, -9.22611356e-03f, 5.13647757e-02f, 3.27028558e-02f, 1.48137584e-01f, 3.08533292e-02f, 8.74144584e-02f, -5.56879453e-02f, -1.48896337e-01f, 8.00205097e-02f,
  -1.36185531e-02f, -9.59881917e-02f, 2.45301649e-02f, -1.18024409e-01f, -4.46986891e-02f, -2.53860876e-02f, -2.02458333e-02f, 5.01482794e-03f, -2.16845367e-02f, 4.07682685e-03f,
  -6.56078532e-02f, 3.10129281e-02f, 3.75617072e-02f, 1.17815407e-02f, -4.16814648e-02f, -5.94240390e-02f, -2.80275401e-02f, -6.06108196e-02f, -1.65682770e-02f, -5.30747809e-02f,
  -7.46741891e-02f, 9.06915218e-02f, 1.63549349e-01f, 3.09795123e-02f, -1.93162970e-02f, 1.09605126e-01f, 6.83753043e-02f, 7.43141100e-02f, -7.39718899e-02f, 1.99616522e-01f,
  -2.47142911e-02f, -1.80920679e-02f, 1.36258423e-01f, -3.39979827e-02f, 7.99252167e-02f, -7.34462515e-02f, -4.39023674e-02f, -3.04776523e-02f, 4.93064374e-02f, -1.81243420e-02f,
  4.94377455e-03f, -8.57316703e-02f, 1.15682527e-01f, 7.79390857e-02f, 8.14945474e-02f, -5.93722090e-02f, 3.41120586e-02f, 8.75162184e-02f, 5.49451336e-02f, 1.14847451e-01f,
  6.30709976e-02f, 1.16119005e-01f, 3.93160619e-02f, 3.73506956e-02f, 1.14819080e-01f, 4.56697866e-02f, 4.23545279e-02f, 1.68272331e-02f, 4.03892770e-02f, -6.65294304e-02f,
  6.38741581e-03f, 1.32067399e-02f, 1.23989470e-01f, -9.61974189e-02f, -1.59016605e-02f, 1.93740681e-01f, 9.33629051e-02f, -1.22479208e-01f, -4.78766002e-02f, -9.82388761e-03f,
  7.47562852e-03f, -1.77713542e-03f, 5.33594675e-02f, -1.55302798e-02f, 6.41021132e-02f, 4.56559882e-02f, -9.19699762e-03f, -2.27504633e-02f, 4.80381995e-02f, -6.33143187e-02f,
  -2.44071662e-01f, 4.41700965e-01f, 2.20390841e-01f, -1.25441179e-01f, -4.91413400e-02f, -6.48949519e-02f, -8.65821466e-02f, 1.14534706e-01f, -7.95577932e-03f, 2.00019345e-01f,
  -1.01646669e-01f, 2.88505375e-01f, 1.80747434e-02f, 1.38758551e-02f, -4.72071201e-01f, -2.14324117e-01f, -1.92152768e-01f, -4.85545024e-02f, -7.05720782e-02f, -5.10861687e-02f,
  -1.12695508e-01f, -2.22784981e-01f, -9.33903307e-02f, 9.91581753e-02f, 1.24910504e-01f, 1.50455534e-01f, -1.64188758e-01f, 9.58591029e-02f, 4.30183709e-02f, 3.29531170e-02f,
  3.73579678e-03f, -4.30922173e-02f, 1.19564220e-01f, 1.86022948e-02f, -1.12885386e-01f, -6.79950193e-02f, 4.52808067e-02f, -6.28626719e-02f, -7.55045414e-02f, -4.85163592e-02f,
  -2.61568017e-02f, 1.91112235e-02f, 4.92817052e-02f, 4.73558977e-02f, 8.54464620e-03f, 4.50746194e-02f, 8.76191035e-02f, 6.58656880e-02f, 7.08354041e-02f, 9.59376469e-02f,
  7.53234103e-02f, 1.17231019e-01f, 4.49535586e-02f, -7.93057382e-02f, 2.62804963e-02f, 3.85110229e-02f, 1.23119522e-02f, 5.22371903e-02f, 2.21201424e-02f, 3.63477618e-02f,
  8.77924263e-03f, -1.11865632e-01f, -3.14508975e-02f, 3.85330021e-02f, -4.73099127e-02f, -2.47365097e-04f, -5.32718897e-02f, -2.28868891e-02f, 1.90800596e-02f, -1.18569704e-02f,
  -3.58939767e-02f, -1.61345005e-02f, -1.68933682e-02f, 3.69849987e-02f, -6.03452213e-02f, 3.76669578e-02f, -8.64636451e-02f, 2.87280362e-02f, -9.93319154e-02f, 4.58575413e-02f,
  4.15307395e-02f, -5.24745211e-02f, 1.11344801e-02f, -6.73710078e-04f, -2.00510491e-02f, -2.20601670e-02f, -1.29863769e-02f, 1.76029615e-02f, -4.08494025e-02f, -3.38891968e-02f,
  -2.61513889e-01f, -2.56374955e-01f, 6.24023704e-03f, 1.65900942e-02f, 5.00631577e-04f, 8.43973272e-03f, 5.75686339e-03f, 6.68573976e-02f, -1.32821640e-03f, -6.68328255e-02f,
  -1.39383022e-02f, 5.45828119e-02f, -7.58701041e-02f, 6.76922575e-02f, -1.25147268e-01f, -2.90266592e-02f, -6.44990653e-02f, -2.14594360e-02f, -4.39838544e-02f, 5.25330752e-02f,
  6.03413917e-02f, 2.07259232e-04f, -1.75484736e-02f, -8.78053904e-02f, -5.46854269e-03f, 1.69034526e-02f, -5.87185752e-03f, 8.89293849e-02f, -5.01887761e-02f, -2.27393806e-02f,
  2.47576192e-01f, -2.97364235e-01f, -3.18095207e-01f, -1.77583441e-01f, 1.16058238e-01f, 9.02183205e-02f, -1.48127094e-01f, -1.56856999e-01f, -2.85695016e-01f, -4.89482246e-02f,
  -1.34988353e-01f, 6.79142848e-02f, -2.29912609e-01f, 7.18627423e-02f, 3.72539818e-01f, -5.23720495e-02f, 8.54552723e-03f, 9.14636813e-03f, -1.24825321e-01f, -1.54394269e-01f,
  -1.05270771e-02f, 3.46892983e-01f, -1.55296549e-01f, 5.76812997e-02f, 8.49228650e-02f, -7.02246651e-02f, 1.93949804e-01f, -7.55913332e-02f, 9.27736089e-02f, 2.10709751e-01f,
  -3.57728563e-02f, 4.23506796e-02f, -4.86133434e-02f, 3.48256230e-02f, -5.22669256e-02f, 9.82418135e-02f, 7.92306736e-02f, 1.38274059e-01f, -1.37602631e-03f, -4.02703434e-02f,
  7.14343786e-02f, 1.80396110e-01f, 3.87636200e-02f, 1.42700180e-01f, 3.74857560e-02f, 3.58543172e-02f, -1.71043705e-02f, -1.50810644e-01f, -9.44629833e-02f, 6.42616004e-02f,
  -7.65544698e-02f, -5.78463413e-02f, -1.51863054e-03f, -8.31141975e-03f, -8.34335908e-02f, -1.11338720e-02f, 9.43564177e-02f, -2.72297300e-02f, 1.22000769e-01f, 1.65049378e-02f,
  6.40874654e-02f, 2.36067772e-01f, -5.36597241e-03f, -1.09779246e-01f, 5.98559231e-02f, -2.58586239e-02f, -1.12695461e-02f, 3.15245949e-02f, -5.43459207e-02f, 3.97798866e-02f,
  -8.48276392e-02f, 1.82498619e-03f, -2.64424123e-02f, -2.82195061e-02f, 1.67640999e-01f, 8.35064352e-02f, 1.57116037e-02f, 1.45860680e-03f, -2.01549783e-01f, -1.75823286e-01f,
  3.52274440e-02f, 1.42475232e-01f, -1.34374559e-01f, 3.39443833e-02f, -3.58552895e-02f, 9.15171765e-03f, 3.42763364e-02f, 2.12332048e-03f, -1.47519618e-01f, -7.53795654e-02f,
  4.74154428e-02f, -4.15902920e-02f, -9.96944979e-02f, 6.27460852e-02f, -3.96120101e-02f, 4.56104763e-02f, 4.30226102e-02f, -4.14315239e-02f, 1.80845372e-02f, -1.85393617e-02f,
  2.13776343e-02f, 5.62361861e-03f, 1.71552803e-02f, 9.33467131e-03f, 1.85582340e-02f, -1.70170560e-01f, 1.27025664e-01f, -6.95991442e-02f, -1.71588250e-02f, -2.29644645e-02f,
  -5.24617359e-02f, -4.68326546e-02f, 3.53566036e-02f, -6.69542179e-02f, -2.13930756e-03f, 2.30560941e-03f, 8.45292509e-02f, -1.73520111e-02f, -1.28728570e-03f, 2.30488796e-02f,
  -3.25062901e-01f, 1.48122564e-01f, 8.00539404e-02f, -2.82508016e-01f, 1.10372774e-01f, 6.81939870e-02f, -1.13439262e-01f, 1.34150118e-01f, -4.83405478e-02f, 2.13523611e-01f,
  -9.81953442e-02f, 8.93807039e-03f, 1.89134888e-02f, -2.18812108e-01f, -3.98700237e-01f, -2.43597075e-01f, -1.66715771e-01f, -1.41978666e-01f, -1.01144895e-01f, 1.51972705e-02f,
  -2.30032764e-02f, -1.37556598e-01f, -1.27241369e-02f, 1.16134137e-01f, 1.40534833e-01f, 1.61347508e-01f, 1.01578601e-01f, 1.50021523e-01f, 1.04198143e-01f, -8.35755020e-02f,
  -1.13572158e-01f, -1.33755445e-01f, 1.10239066e-01f, -8.16711225e-03f, 8.41827318e-03f, 4.15303893e-02f, 1.30724251e-01f, -9.14004669e-02f, -2.87056975e-02f, -3.48334550e-03f,
  9.86595452e-02f, -3.61061655e-02f, -6.68884814e-02f, -2.63821259e-02f, 9.10322815e-02f, 2.19884533e-02f, 7.52468407e-02f, 8.32240880e-02f, 4.75918725e-02f, -3.76243563e-03f,
  8.30151588e-02f, 3.61034297e-03f, 1.26818076e-01f, -8.16441402e-02f, -5.36068529e-03f, 7.29266331e-02f, 1.79438703e-02f, 3.40120979e-02f, 4.65098731e-02f, 4.48741913e-02f,
  -2.00856049e-02f, -2.93741003e-02f, -1.34648513e-02f, -9.68261808e-02f, -6.72542602e-02f, -1.78320222e-02f, 5.57567477e-02f, 2.78674588e-02f, 6.82879910e-02f, -1.12366052e-02f,
  -1.04043759e-01f, 6.06897362e-02f, -5.27998693e-02f, 3.92500758e-02f, 5.04656620e-02f, -1.21154360e-01f, -1.50676081e-02f, 2.62071341e-02f, -5.38739339e-02f, 7.81390816e-03f,
  1.04130562e-02f, -5.63794635e-02f, -6.53191730e-02f, 1.49420291e-01f, -5.75679205e-02f, 2.96160877e-02f, 1.31714329e-01f, -2.42380705e-02f, -4.55444045e-02f, 2.69616079e-02f,
  -6.97894394e-02f, -1.05983377e-01f, -9.51778493e-04f, -8.41288418e-02f, -8.12379271e-02f, 2.60529894e-04f, 4.71778549e-02f, 4.96666245e-02f, 5.46150468e-03f, -2.47150790e-02f,
  9.55405757e-02f, 8.45259652e-02f, -1.06883524e-02f, -3.92114595e-02f, -6.94686994e-02f, 1.13762736e-01f, 3.49869132e-02f, -1.16230436e-02f, 3.17753875e-03f, 3.04209292e-02f,
  1.02942191e-01f, -1.12672374e-02f, 2.62786001e-02f, -4.00149170e-03f, 3.68538052e-02f, -3.06065660e-03f, -2.11793073e-02f, 6.04545698e-03f, 4.18203808e-02f, 5.10227354e-03f,
  2.77228691e-02f, -1.68785974e-01f, 2.61741310e-01f, 1.85059592e-01f, -3.26658390e-03f, -7.07359612e-02f, 1.78861052e-01f, -1.65523902e-01f, 4.78567481e-02f, -4.30077910e-01f,
  -2.68393964e-01f, -5.68955392e-02f, -1.27774119e-01f, -7.09420023e-03f, 3.04577798e-01f, -3.35284844e-02f, 1.09151870e-01f, 1.65329576e-02f, 8.08361098e-02f, -9.22727063e-02f,
  -7.49251693e-02f, -1.79104537e-01f, 5.91133833e-02f, -1.99625835e-01f, -8.83197412e-02f, 1.25503644e-01f, -3.26366955e-03f, 1.07306741e-01f, 8.53682756e-02f, 2.10680634e-01f,
  1.20738400e-02f, 6.97249779e-03f, 1.03761945e-02f, -7.00300336e-02f, -5.43018170e-02f, 6.31538108e-02f, 6.69979826e-02f, 1.14895985e-01f, 2.16528639e-01f, -1.20738216e-01f,
  -1.03385054e-01f, 7.74904862e-02f, -6.58598095e-02f, 4.58270498e-02f, 1.98876625e-03f, -4.47922014e-02f, 4.65276353e-02f, -8.58970508e-02f, 6.81473389e-02f, 3.50393541e-02f,
  4.24400829e-02f, -9.25568566e-02f, 6.82953373e-02f, 4.46959995e-02f, 1.31575927e-01f, 8.20200443e-02f, 1.63747109e-02f, 1.44638615e-02f, -3.14832712e-03f, 1.68276012e-01f,
  1.20131008e-01f, -7.75072053e-02f, -1.96979225e-01f, -7.67873079e-02f, -7.84137696e-02f, -3.07682343e-02f, -5.56381419e-02f, -1.73375040e-01f, -2.18915045e-02f, -9.01244804e-02f,
  4.50280122e-02f, -2.11214554e-02f, -4.04406898e-02f, 9.98490304e-03f, -5.86750545e-02f, -1.24423571e-01f, 7.86991641e-02f, 3.24337892e-02f, -9.09157321e-02f, -8.83838255e-03f,
  1.94504764e-02f, 1.82114035e-01f, -1.67909302e-02f, -1.03999056e-01f, -2.83519160e-02f, 2.74451042e-04f, -1.44822411e-02f, -5.50549338e-03f, -4.93146814e-02f, 5.37450127e-02f,
  5.07030897e-02f, 7.65343234e-02f, 3.00715640e-02f, -1.73497405e-02f, 7.11711794e-02f, -1.01131670e-01f, -6.82758167e-03f, -1.79459248e-02f, 1.12548940e-01f, -7.30494112e-02f,
  -2.08649188e-01f, 6.30881712e-02f, 2.42113378e-02f, 4.61621918e-02f, 1.16102308e-01f, -5.24572246e-02f, 2.53828652e-02f, -5.87851331e-02f, 9.98822600e-02f, 1.21329501e-01f,
  -2.97558531e-02f, -1.84173122e-01f, 1.12698879e-02f, -9.16387066e-02f, 1.65293030e-02f, 5.58113195e-02f, -1.01022460e-01f, -4.42533605e-02f, 6.07746243e-02f, 1.40421167e-01f,
  -1.42480299e-01f, -1.54383983e-02f, 1.08797036e-01f, 1.94835454e-01f, 1.04528099e-01f, -3.50295603e-01f, -1.51175216e-01f, 1.80142611e-01f, -2.39877645e-02f, -6.87088072e-02f,
  -2.68241018e-02f, -1.45247400e-01f, -7.47262985e-02f, -2.25169972e-01f, -3.17682885e-02f, -3.53670180e-01f, -8.39711502e-02f, -1.63335070e-01f, -1.38290241e-01f, 7.88023546e-02f,
  1.75852582e-01f, 9.74182971e-03f, 1.79047763e-01f, 1.48616821e-01f, 2.79760994e-02f, 2.22531796e-01f, 3.81463319e-01f, 7.67739788e-02f, 2.11027607e-01f, -4.58978787e-02f,
  -1.19484738e-01f, 7.41974711e-02f, 6.57560900e-02f, -5.66664971e-02f, 6.15021028e-02f, -1.14579331e-02f, -2.14599948e-02f, 1.36727626e-02f, -2.95301080e-02f, 4.45888303e-02f,
  3.60215791e-02f, -2.32504401e-02f, -6.59561232e-02f, -1.47014156e-01f, -3.86393555e-02f, -5.23541607e-02f, -3.50330956e-02f, 1.04176864e-01f, 1.07164413e-01f, -8.19641203e-02f,
  7.90887102e-02f, 1.18170336e-01f, 1.42089427e-02f, 1.11637957e-01f, 1.57701254e-01f, 4.06613797e-02f, -2.94856131e-02f, 8.36174861e-02f, 1.75886531e-03f, -7.33755901e-03f,
  5.60929105e-02f, -9.27133393e-03f, -8.34912658e-02f, -1.12005755e-01f, -9.08965543e-02f, -1.02829011e-02f, -4.60390262e-02f, -6.30720854e-02f, 3.14756035e-05f, -2.51614265e-02f,
  -5.34967240e-03f, -2.13582888e-02f, -1.33569911e-01f, 2.81020962e-02f, -2.08816770e-02f, -3.73653583e-02f, 1.60087147e-05f, -8.62873420e-02f, -4.32779267e-03f, -2.93871178e-03f,
  -3.91711965e-02f, -6.00112304e-02f, 2.68665329e-02f, 3.49788219e-02f, -1.21772915e-01f, 6.42491579e-02f, -7.46067893e-03f, -1.36734486e-01f, 2.81400196e-02f, 5.06255440e-02f,
  9.81225520e-02f, 1.59458593e-01f, 8.23232159e-02f, 5.22158146e-02f, 1.99646540e-02f, -9.38528702e-02f, -1.71925858e-01f, -1.79119464e-02f, -3.37498554e-04f, -4.11779396e-02f,
  6.38236925e-02f, -9.21170134e-03f, 2.98067229e-03f, -3.80189605e-02f, 5.15338778e-02f, 5.35408556e-02f, 1.53687559e-02f, 7.42826834e-02f, 1.48953393e-01f, 1.50651574e-01f,
  1.32220358e-01f, 3.71065270e-03f, 3.03684697e-02f, 1.32095322e-01f, 9.50346589e-02f, 1.06404878e-01f, -5.87931275e-02f, 3.00664250e-02f, 6.58710748e-02f, 3.05801108e-02f,
  -1.45299330e-01f, -1.71824783e-01f, -1.17560893e-01f, 1.04166001e-01f, 3.18698227e-01f, -1.94402665e-01f, -6.50964901e-02f, 1.45719394e-01f, -3.18937786e-02f, -3.25349458e-02f,
  -1.45458341e-01f, -3.66425842e-01f, -2.25260496e-01f, -2.47020140e-01f, -2.00360373e-01f, -4.17968482e-01f, -1.14678465e-01f, -2.17593849e-01f, -1.78245127e-01f, 2.01784703e-03f,
  7.76877105e-02f, 1.44012555e-01f, 1.25527354e-02f, 2.75844425e-01f, 1.92882732e-01f, 1.28413454e-01f, 3.24305445e-01f, 1.01964504e-01f, 1.99238747e-01f, 4.65430971e-03f,
  -5.61078750e-02f, -1.43078402e-01f, 3.63515392e-02f, 7.15544596e-02f, 1.19472697e-01f, 1.19234547e-01f, 6.95566610e-02f, 8.72902945e-02f, 1.78508612e-03f, -1.19543457e-02f,
  3.96420322e-02f, 4.72244397e-02f, -1.28534630e-01f, -7.29228333e-02f, 6.54615983e-02f, 5.91627099e-02f, -3.13896276e-02f, 2.75398009e-02f, 9.69881937e-02f, -2.01482072e-01f,
  -1.68456752e-02f, -3.60059813e-02f, 5.46926148e-02f, -5.91800995e-02f, -5.94040565e-02f, 2.82561406e-02f, -3.24276574e-02f, -1.42994784e-02f, -3.91793763e-03f, -4.84014153e-02f,
  -4.02552038e-02f, 2.67959218e-02f, 2.22520791e-02f, -1.10453963e-02f, -2.63813436e-02f, 6.16659373e-02f, -3.56842345e-03f, -6.69487640e-02f, -6.22039810e-02f, -1.89238526e-02f,
  8.28720033e-02f, 1.59680434e-02f, -4.00712341e-02f, 8.21171179e-02f, 1.30858971e-02f, -4.77866270e-03f, 8.82376805e-02f, -4.13795225e-02f, -3.53560559e-02f, 7.21708080e-03f,
  -4.05337475e-03f, 1.21923491e-01f, 3.46442475e-03f, 8.85594562e-02f, -5.29959798e-02f, 2.16404139e-03f, 6.58157766e-02f, -7.37295672e-02f, 1.00964375e-01f, 2.21324973e-02f,
  -3.09117343e-02f, 1.30856708e-02f, 3.01174410e-02f, 6.35938048e-02f, 3.06469481e-02f, -1.29566537e-02f, -7.91077763e-02f, -1.41358972e-02f, -2.44806241e-02f, 4.87592220e-02f,
  9.15185884e-02f, 1.77691638e-01f, -8.38602707e-03f, -4.47725914e-02f, 1.16773993e-01f, 1.22212828e-03f, 8.33669081e-02f, 7.54960105e-02f, 2.75391877e-01f, 2.67122481e-02f,
  1.35868400e-01f, -5.94870225e-02f, 7.24161714e-02f, 1.28539309e-01f, 1.06053405e-01f, 8.09224788e-03f, -1.36556327e-02f, -5.48080578e-02f, 4.27408405e-02f, -7.76886344e-02f,
  1.65325478e-01f, -5.15506081e-02f, -1.69954479e-01f, 4.38984744e-02f, -1.38967782e-01f, -1.57415643e-01f, 2.14618891e-02f, -2.50336289e-01f, -6.59986958e-02f, 7.17513543e-03f,
  2.16438249e-01f, -1.67014435e-01f, 1.90693483e-01f, 1.82821184e-01f, -3.14702801e-02f, 3.28956842e-01f, -7.56470412e-02f, 3.62001695e-02f, -1.56075522e-01f, 1.47079496e-04f,
  -8.53591692e-03f, 2.55568475e-01f, 6.31289929e-02f, -1.65801555e-01f, 4.87590060e-02f, -2.29666620e-01f, -4.53067105e-03f, -2.65367012e-02f, -1.36353076e-01f, -9.13486257e-02f,
  9.40958038e-02f, 2.15274274e-01f, 4.07960964e-03f, -6.47625476e-02f, -1.58186350e-02f, 5.66873774e-02f, -5.41870520e-02f, -8.99016708e-02f, -2.73711439e-02f, -3.49844918e-02f,
  9.07694281e-04f, 5.26813120e-02f, -5.33095524e-02f, 2.75276229e-02f, 7.67476559e-02f, -5.01440205e-02f, -4.01689559e-02f, -3.73476744e-02f, -8.89725462e-02f, 1.16326571e-01f,
  9.77575928e-02f, 1.82640493e-01f, -3.95046268e-03f, 1.04633182e-01f, -3.10401842e-02f, -3.79346088e-02f, -4.94208783e-02f, 4.95407209e-02f, -6.96717873e-02f, 3.00250854e-02f,
  -1.40102990e-02f, 7.27141500e-02f, 3.94963063e-02f, 5.51205501e-02f, 4.04400900e-02f, 5.98905012e-02f, 1.52121987e-02f, 2.77696885e-02f, -1.86483875e-01f, -1.88556500e-03f,
  -9.36193615e-02f, -5.54007217e-02f, 6.22820221e-02f, -2.03686208e-03f, -6.79005906e-02f, -1.59539860e-02f, -1.82713475e-02f, -1.13428049e-01f, -8.43562931e-02f, -2.14858040e-01f,
  1.24660827e-01f, -6.81811273e-02f, 2.32647662e-03f, 1.49737939e-01f, 1.12018950e-01f, -4.83087413e-02f, 3.32801417e-02f, 3.27512622e-02f, -4.52896617e-02f, -6.16513565e-02f,
  -3.35406810e-02f, -3.96539569e-02f, 8.12502112e-03f, -5.21343760e-03f, -7.85533190e-02f, -3.55207063e-02f, -2.94439252e-02f, -2.40769014e-01f, -1.30356655e-01f, -6.09512776e-02f,
  -1.10456467e-01f, -5.94364479e-02f, 9.99847986e-03f, -1.36348113e-01f, 2.15657279e-02f, -8.40032026e-02f, -3.75900082e-02f, -1.25075370e-01f, -8.52101818e-02f, -4.44592945e-02f,
  3.73146404e-03f, 8.24195594e-02f, -3.52694541e-02f, -1.57969026e-03f, -5.40320314e-02f, 1.25213666e-02f, -6.23302609e-02f, 7.65250474e-02f, 9.08432435e-03f, -1.65040474e-02f,
  -2.77176425e-02f, 2.22284235e-02f, -3.95862833e-02f, 1.85177311e-01f, 1.02878571e-01f, -4.65804003e-02f, 1.11581020e-01f, 2.15981156e-01f, 4.01513249e-01f, 8.39088559e-02f,
  7.31934281e-03f, 1.74820140e-01f, 1.54723957e-01f, -4.01233658e-02f, -1.48154333e-01f, -3.90601940e-02f, -2.61247247e-01f, 1.30673954e-02f, 8.78017992e-02f, 4.76802513e-02f,
  3.84041630e-02f, 1.51404679e-01f, -2.64559120e-01f, 4.81048599e-02f, -6.31847158e-02f, -1.62049325e-03f, -2.94572026e-01f, 1.00398757e-01f, -2.14643121e-01f, -9.48516428e-02f,
  -1.12503745e-01f, 1.73399091e-01f, -1.14728421e-01f, -3.03313415e-02f, -1.46777868e-01f, -6.31786212e-02f, -1.75256953e-01f, 4.95907851e-02f, 5.24828769e-02f, 1.38026237e-01f,
  1.77553706e-02f, -1.56128872e-02f, 9.63375717e-02f, 5.46240062e-02f, 4.72554788e-02f, 3.47905643e-02f, -1.47351131e-01f, -1.80318460e-01f, 6.24224022e-02f, -6.97523504e-02f,
  1.44041628e-02f, -6.47389889e-02f, -8.28783587e-02f, -5.23571260e-02f, -9.03948769e-02f, 3.39849405e-02f, -5.01267165e-02f, -1.14892185e-01f, -1.03806905e-01f, -8.03892389e-02f,
  8.20804387e-02f, 5.22729158e-02f, 5.75757492e-03f, 7.51981661e-02f, 7.95855224e-02f, -6.03266060e-03f, -9.25284401e-02f, -6.18568137e-02f, 4.25913446e-02f, -1.80565238e-01f,
  -1.10635288e-01f, -5.46323955e-02f, 3.70538644e-02f, -8.34620297e-02f, 1.31251141e-01f, 1.36701256e-01f, -2.75946222e-02f, -8.19285512e-02f, -6.39855713e-02f, -1.35684207e-01f,
  1.76382631e-01f, -2.32904516e-02f, -3.09794750e-02f, -1.04229622e-01f, -6.36159182e-02f, 6.88416883e-02f, 3.94713543e-02f, 3.11035067e-02f, 5.21675386e-02f, -6.26007542e-02f,
  -1.50413796e-01f, 1.01851828e-01f, 9.93413851e-03f, -2.83978693e-02f, 4.20920663e-02f, -7.14577138e-02f, 5.34581803e-02f, -4.24536057e-02f, -2.56473664e-04f, 1.25984907e-01f,
  -1.09564131e-02f, -5.51371053e-02f, -7.13310838e-02f, -1.88205633e-02f, 4.11349870e-02f, -3.80029343e-02f, -1.51177133e-02f, -4.46263663e-02f, -6.67685792e-02f, -1.80915873e-02f,
  3.14154569e-03f, 1.37217611e-01f, -2.04566903e-02f, 3.18664275e-02f, -1.36667475e-01f, -6.72141612e-02f, 1.28445834e-01f, -2.35886928e-02f, -2.84634177e-02f, 6.43089712e-02f,
  2.46164933e-01f, 2.92154431e-01f, 1.46815270e-01f, 1.72769457e-01f, -1.66550994e-01f, -9.41691920e-03f, 9.80186015e-02f, -1.87030569e-01f, -4.05230522e-02f, 1.88418835e-01f,
  -1.81855530e-01f, 3.60523909e-01f, -1.84104934e-01f, 8.05500820e-02f, -3.48814547e-01f, -8.04674029e-02f, 1.32627338e-01f, 1.67712167e-01f, 3.44783813e-02f, 4.10821177e-02f,
  -8.02622214e-02f, -1.88209116e-02f, -3.22995111e-02f, -1.03576012e-01f, 1.52422473e-01f, 6.45918176e-02f, -1.19778864e-01f, -1.26626045e-01f, 2.21779540e-01f, -4.00397815e-02f,
  2.74141300e-02f, 2.43999418e-02f, 4.17849422e-02f, 5.60098439e-02f, 4.19095308e-02f, 6.83766082e-02f, 2.40292370e-01f, -4.88278158e-02f, -1.00583225e-01f, 1.82359237e-02f,
  1.17858149e-01f, 6.61787912e-02f, 3.93884024e-03f, -1.09666534e-01f, 5.87190017e-02f, 8.57095234e-03f, 6.46374747e-02f, 1.14424855e-01f, 1.40354082e-01f, 1.23577274e-01f,
  1.20293714e-01f, -1.03555266e-02f, 5.36072184e-04f, 1.49908960e-01f, 6.31122440e-02f, 3.00986581e-02f, 1.38531670e-01f, 9.83997211e-02f, 9.48571041e-02f, 7.31064752e-02f,
  -4.36547287e-02f, 1.34246141e-01f, 3.13724540e-02f, -1.67285874e-02f, -1.27189338e-01f, -5.39505407e-02f, 4.14254107e-02f, -5.58475181e-02f, 7.64163909e-03f, 7.57318288e-02f,
  -1.67535227e-02f, 4.46633436e-02f, 1.83080751e-02f, 1.97072327e-02f, -4.18180041e-02f, 4.45874520e-02f, -1.36316782e-02f, 1.73494667e-01f, -3.23129185e-02f, -3.47422250e-02f,
  -1.02687255e-01f, 2.72576939e-02f, 1.11348461e-03f, 4.43091504e-02f, 6.00157399e-03f, -4.47051525e-02f, 8.26069862e-02f, 2.61990968e-02f, -2.03131825e-01f, -7.49563426e-02f,
  -1.99623909e-02f, -3.23011726e-02f, -3.46009433e-02f, 1.36713982e-01f, 2.82413941e-02f, 6.74348995e-02f, 4.66332361e-02f, 1.43282279e-01f, -2.97697373e-02f, -3.36767770e-02f,
  1.06089510e-01f, 8.97026211e-02f, -5.33349905e-03f, -5.55350184e-02f, -1.83089599e-02f, -7.46968528e-03f, 5.41736409e-02f, -2.65670735e-02f, 1.60025265e-02f, 3.37928832e-02f,
  -4.95058065e-03f, 2.13779975e-03f, 7.90449977e-02f, 8.33629295e-02f, 1.15155555e-01f, 6.84816316e-02f, -5.04015237e-02f, 9.26111117e-02f, 1.35549288e-02f, -2.41532885e-02f,
  2.07026869e-01f, -7.16228485e-02f, -2.46964931e-01f, -1.24510899e-01f, -2.16837332e-01f, -2.43395567e-02f, -1.59057379e-01f, -3.14987451e-02f, 1.04772307e-01f, 2.27209702e-01f,
  5.83829954e-02f, 2.21768692e-01f, 6.65393695e-02f, -5.43756746e-02f, 8.63800272e-02f, 2.01991603e-01f, -1.55692235e-01f, 3.66575271e-02f, -3.49980891e-02f, 5.53749539e-02f,
  6.03009388e-02f, 1.26167163e-01f, -1.32513836e-01f, 4.48570326e-02f, -7.25014806e-02f, -1.08260609e-01f, -9.21685919e-02f, -1.53065190e-01f, -1.11978039e-01f, -1.13722518e-01f,
  -3.40623781e-02f, -5.47199510e-02f, -2.11291328e-01f, -2.00374685e-02f, -9.85772759e-02f, -1.14296656e-02f, 8.96158740e-02f, -5.93351573e-02f, -1.07665442e-01f, -1.18490219e-01f,
  1.36237234e-01f, 1.84247509e-01f, 6.96464330e-02f, -4.72510280e-03f, 2.26695240e-02f, -1.58101290e-01f, -5.74032601e-04f, -3.56159136e-02f, -3.58459055e-02f, -2.50808820e-02f,
  -5.75699396e-02f, -1.52645379e-01f, -1.35292470e-01f, -5.55073731e-02f, -1.40655518e-01f, -2.70715784e-02f, -5.95609322e-02f, -1.17642470e-01f, -5.25084138e-02f, -2.69085541e-02f,
  1.95115991e-02f, 1.40441116e-02f, 2.48582140e-02f, 1.04894256e-02f, -1.66282430e-02f, -1.45712972e-01f, 3.17720249e-02f, -1.76710002e-02f, 7.17804208e-02f, -1.92003120e-02f,
  3.05715464e-02f, -8.45512822e-02f, 7.29900524e-02f, 1.89595611e-03f, 6.84702247e-02f, 9.05141830e-02f, -2.42815800e-02f, 1.90326378e-01f, 7.22020641e-02f, 4.25962210e-02f,
  -6.79222168e-03f, -2.69145309e-03f, -4.00982909e-02f, 1.70273650e-02f, -1.53525874e-01f, -1.39558688e-03f, 7.55562410e-02f, 7.92150572e-02f, -1.04900263e-01f, -1.64176941e-01f,
  -7.52896369e-02f, 1.09920181e-01f, -1.08209878e-01f, 5.85912652e-02f, -1.42078161e-01f, -2.25722492e-02f, -5.27203269e-02f, 1.76402442e-02f, -8.19368809e-02f, -4.03138995e-02f,
  6.73808977e-02f, -6.34782314e-02f, 7.49913454e-02f, -5.67710958e-04f, -7.16877133e-02f, 9.99519974e-03f, 1.80086419e-01f, -3.98255028e-02f, -9.61174294e-02f, -7.96134248e-02f,
  -1.37737459e-02f, 7.63859749e-02f, -2.20349468e-02f, -1.96203217e-02f, 7.18549639e-02f, 1.01106346e-01f, 3.77080925e-02f, -5.82332127e-02f, -1.19202159e-01f, -1.33925959e-01f,
  -8.76196474e-02f, -1.03748307e-01f, -3.11514795e-01f, -2.37490684e-01f, 1.33368075e-01f, -3.15387160e-01f, -2.37592176e-01f, -6.05263859e-02f, 1.08426623e-03f, 1.45943016e-01f,
  -6.79395571e-02f, -1.06229521e-02f, 1.29388466e-01f, -3.23932946e-01f, -3.86162937e-01f, -9.72714424e-02f, -4.07601595e-01f, -2.35483691e-01f, -6.88560680e-02f, -9.89136472e-02f,
  -4.42798436e-02f, -8.58406126e-02f, -1.59814849e-01f, 1.94324851e-01f, -1.52886063e-01f, 1.28060952e-01f, 2.29075655e-01f, 1.14704244e-01f, -1.02040969e-01f, -1.03135221e-02f,
  -2.06279218e-01f, 7.47673288e-02f, -1.13711685e-01f, -1.41959474e-03f, -3.56093831e-02f, 1.48418948e-01f, -7.67518356e-02f, -8.03125128e-02f, -1.23774996e-02f, -2.86817327e-02f,
  -3.63046378e-02f, 5.84239140e-02f, -2.20713001e-02f, 5.80885857e-02f, 3.84139717e-02f, -2.24760603e-02f, -6.22707792e-02f, -2.04209648e-02f, -2.33902652e-02f, -2.79822517e-02f,
  -1.13192067e-01f, -8.81905959e-04f, -3.69922183e-02f, 3.67649123e-02f, -1.64919849e-02f, 2.70427410e-02f, -5.77400252e-02f, -2.33047344e-02f, 6.84946626e-02f, 5.41364923e-02f,
  5.79744205e-02f, 1.18694440e-01f, -5.28042065e-03f, 7.86518306e-03f, 2.12186202e-02f, 1.54429907e-02f, -4.26012911e-02f, -2.42634118e-02f, -3.25995609e-02f, 1.14252781e-02f,
  7.97457527e-03f, -1.07872538e-01f, -1.96504910e-02f, -1.67525269e-03f, -2.29937565e-02f, 8.32583681e-02f, 2.44230013e-02f, -4.09346521e-02f, -6.61750436e-02f, -1.60264507e-01f,
  1.00499064e-01f, 4.72109579e-02f, -2.49739382e-02f, 7.63991848e-03f, -5.59959710e-02f, 6.36641905e-02f, 3.26143987e-02f, -2.42892858e-02f, -1.23551348e-02f, -2.47244816e-02f,
  1.99347804e-03f, 2.62169875e-02f, -7.09127933e-02f, 2.03568395e-02f, -4.33548428e-02f, -5.67290895e-02f, -2.34530270e-02f, -1.06494121e-01f, -2.32451502e-02f, 5.08261882e-02f,
  3.78290638e-02f, 1.95904505e-02f, 1.43254280e-01f, -1.38109839e-02f, -3.61905806e-02f, -5.49629405e-02f, 7.92834908e-02f, 4.14473489e-02f, 9.02587920e-02f, 3.47346142e-02f,
  8.36423263e-02f, 8.92300680e-02f, -3.05892993e-02f, 8.27841386e-02f, 6.30789027e-02f, 7.64153004e-02f, 7.19228536e-02f, 3.55570577e-02f, 5.74153699e-02f, 3.81019451e-02f,
  2.22155333e-01f, -1.12793721e-01f, 2.67948896e-01f, 5.31266093e-01f, 1.18215710e-01f, -3.22346687e-01f, -2.08706148e-02f, 2.01370731e-01f, 2.66166210e-01f, -2.16998577e-01f,
  2.09591314e-01f, -4.59339172e-02f, -1.40495524e-01f, 7.59322271e-02f, -1.09275155e-01f, 5.72426571e-03f, -3.69411781e-02f, -1.92344666e-01f, 3.01361792e-02f, 5.79215102e-02f,
  8.86258334e-02f, 9.91807505e-02f, 1.95222408e-01f, 4.07914212e-03f, 2.12086841e-01f, 2.35017911e-01f, 9.87903625e-02f, 1.76464077e-02f, 5.81335686e-02f, -1.35167554e-01f,
  -1.45092666e-01f, 2.82466084e-01f, -4.16398011e-02f, -8.94477889e-02f, -1.37230828e-02f, -5.96541651e-02f, -1.45746656e-02f, -8.91937390e-02f, 4.23345454e-02f, -6.49485178e-03f,
  -5.44921234e-02f, 1.18243314e-01f, 6.43796399e-02f, 6.29728436e-02f, -6.47044405e-02f, 6.63032085e-02f, 4.50666482e-03f, -1.71457361e-02f, 7.59524405e-02f, 1.33947104e-01f,
  1.05436318e-01f, -8.11005160e-02f, -7.87746254e-03f, -1.19838789e-01f, 9.37778354e-02f, -2.75781122e-03f, -1.22650683e-01f, -8.47306326e-02f, -3.92436907e-02f, 3.39161530e-02f,
  6.52200058e-02f, -8.62258151e-02f, 4.95964065e-02f, 3.90391052e-02f, 4.64556087e-03f, 1.35223940e-01f, 3.44789438e-02f, -2.23255083e-02f, -3.07495054e-02f, -4.28859480e-02f,
  -7.74203539e-02f, 9.56852436e-02f, 2.47723758e-02f, -3.38910590e-03f, 1.48452640e-01f, 1.26965061e-01f, -7.03152269e-02f, -1.16476618e-01f, -8.83413106e-02f, 1.72887351e-02f,
  1.07668832e-01f, -1.05366811e-01f, -6.85061738e-02f, -5.55725954e-02f, -1.10736638e-02f, 9.29549858e-02f, 1.20274000e-01f, -1.40861403e-02f, 3.94126624e-02f, 2.28420049e-02f,
  -3.12645823e-01f, 3.73689122e-02f, -1.51197627e-01f, -9.11523625e-02f, 4.42008674e-02f, -1.66059081e-02f, 4.89370599e-02f, -1.14924490e-01f, 5.71926273e-02f, 6.37409389e-02f,
  -5.42541407e-02f, 5.85329207e-03f, -1.15090445e-01f, -1.48954531e-02f, -7.14984983e-02f, 1.09988481e-01f, 4.29245532e-02f, -8.06962699e-02f, -9.00658667e-02f, 2.06682850e-02f,
  4.24905717e-02f, -8.11969489e-03f, -6.18527196e-02f, 2.52494998e-02f, -3.22391130e-02f, -3.51466238e-02f, 4.13588844e-02f, -5.72658740e-02f, -7.07812607e-02f, -3.83807383e-02f,
  1.33195683e-01f, 3.40199545e-02f, 1.08191527e-01f, -8.50420073e-02f, 8.87784958e-02f, 1.25755265e-01f, -5.67673892e-02f, 2.23700643e-01f, 3.75270337e-01f, -1.52726784e-01f,
  -1.31123170e-01f, -1.12208784e-01f, -1.20709777e-01f, -1.80396006e-01f, 1.15140729e-01f, 8.68726373e-02f, -6.64075315e-02f, -1.06550984e-01f, 1.21442154e-01f, -2.25806639e-01f,
  1.94052234e-02f, -3.48544002e-01f, -2.30753914e-01f, -2.39418536e-01f, -1.43411949e-01f, 6.56472594e-02f, -2.50480801e-01f, -5.70054092e-02f, -2.00658947e-01f, 1.25154704e-02f,
  5.81878498e-02f, 1.08946316e-01f, 3.62505317e-02f, -2.60832291e-02f, 5.47464639e-02f, -7.66510665e-02f, -9.61265042e-02f, -1.34910688e-01f, 3.61308567e-02f, -6.06002621e-02f,
  -1.63114771e-01f, -9.71921980e-02f, 3.35167125e-02f, -6.15605190e-02f, -4.82186936e-02f, -1.23988725e-01f, -7.03544095e-02f, 9.88130867e-02f, -1.46151796e-01f, -5.54823354e-02f,
  3.66051346e-02f, 8.63527060e-02f, 1.99882430e-03f, 2.81891203e-03f, 3.58483195e-02f, 4.61804448e-03f, 6.93275407e-02f, -8.38391855e-03f, 2.25610472e-02f, -2.57157646e-02f,
  -5.94318053e-03f, 1.01583220e-01f, -3.17077190e-02f, -4.65838574e-02f, 5.83312772e-02f, 5.66771105e-02f, -5.56391664e-02f, -2.74676853e-03f, 2.02594757e-01f, -1.46501437e-02f,
  -3.16606723e-02f, -2.67727226e-02f, -9.69898514e-03f, 2.29196995e-02f, -1.15909792e-01f, 6.90085217e-02f, -1.25336304e-01f, -6.72798604e-02f, -1.57636069e-02f, 6.75659180e-02f,
  -1.93981472e-02f, 1.67488232e-02f, -1.76536907e-02f, -1.36707723e-01f, -6.39514253e-02f, 5.64767309e-02f, -1.61990657e-01f, -9.38012376e-02f, 2.75540464e-02f, -1.62141293e-01f,
  -1.36958743e-02f, 2.33858097e-02f, 7.54142227e-03f, -2.82954471e-03f, -1.23051358e-02f, 1.80744454e-02f, -3.34391482e-02f, 3.39339115e-02f, 2.64435243e-02f, -2.39666067e-02f,
  -1.44771799e-01f, -1.20112672e-02f, -1.92924179e-02f, 7.67676681e-02f, -1.07948616e-01f, -4.68099192e-02f, -2.12149069e-01f, 7.02586845e-02f, -1.37144119e-01f, -1.13458104e-01f,
  -1.06145605e-01f, 1.98063198e-02f, -3.74118984e-02f, -3.44185866e-02f, -2.03434989e-04f, -7.02872202e-02f, 7.36529157e-02f, 1.22889187e-02f, -8.56065936e-03f, -1.58784576e-02f,
  -4.44142371e-02f, -2.38573328e-01f, 6.95502236e-02f, -7.35590160e-02f, -1.41711846e-01f, 3.92182022e-02f, 3.49162310e-01f, -2.20628276e-01f, -3.10599506e-01f, -1.41741127e-01f,
  1.50113516e-02f, 1.95805877e-01f, 2.04899192e-01f, -7.31376186e-02f, 3.09404165e-01f, 1.15373522e-01f, -7.37827346e-02f, 5.61751463e-02f, -2.18459472e-01f, -1.21167757e-01f,
  -1.02481864e-01f, -6.62927628e-02f, 2.71175027e-01f, -1.36104062e-01f, -1.20415904e-01f, -1.87523693e-01f, 9.82712135e-02f, 1.37754619e-01f, -1.18554886e-02f, 1.24642015e-01f,
  -1.61392942e-01f, -2.27189571e-01f, 4.42244820e-02f, 4.27758098e-02f, -2.12398604e-01f, -6.86687902e-02f, 1.90913752e-01f, 2.11089686e-01f, 3.57550010e-02f, 8.87626689e-03f,
  7.63566494e-02f, -1.18289754e-01f, -1.79046825e-01f, 2.90818568e-02f, -6.37432709e-02f, -5.11304848e-02f, -7.71221146e-02f, 4.42028540e-04f, -1.09404826e-03f, -7.37384930e-02f,
  -1.12641426e-02f, -8.36391076e-02f, -1.27019405e-01f, -7.60594849e-03f, 9.09088999e-02f, -1.26493558e-01f, 9.25665274e-02f, 1.76007360e-01f, -4.76167463e-02f, -1.78798869e-01f,
  7.40713403e-02f, -4.81033400e-02f, 8.86465982e-02f, 1.14203840e-02f, 3.45152169e-02f, -1.41657844e-01f, 8.77856161e-04f, 6.41754940e-02f, 5.49087338e-02f, 1.92686394e-02f,
  -3.40827517e-02f, 2.91502313e-03f, -8.79077017e-02f, 1.64293051e-02f, -1.28692165e-02f, -1.74432062e-02f, 1.51185498e-01f, -6.48019165e-02f, -1.35477349e-01f, -1.00711852e-01f,
  6.37648031e-02f, -9.25537422e-02f, -1.00712441e-01f, 1.61624640e-01f, 1.70577057e-02f, 8.86782780e-02f, -1.55076370e-01f, -5.09594455e-02f, -2.06422694e-02f, 1.30216748e-01f,
  -1.62837297e-01f, -6.95941597e-02f, 6.79375380e-02f, -5.41581884e-02f, -3.91761027e-02f, -8.94799083e-02f, 5.17944656e-02f, -7.97005743e-02f, -1.04002180e-02f, 3.46923433e-02f,
  -4.66551371e-02f, -4.44101728e-02f, -1.34269804e-01f, -1.59205794e-02f, 1.04223033e-02f, -5.45544596e-03f, 1.20563425e-01f, -3.77732404e-02f, 8.20920691e-02f, -1.54978335e-01f,
  -7.37659708e-02f, 6.11179844e-02f, -1.26491040e-02f, -8.85707065e-02f, -3.95631120e-02f, -4.43732850e-02f, -8.51496011e-02f, -1.38387522e-02f, 1.82353575e-02f, -1.61759079e-01f,
  -5.79419017e-01f, 1.57047570e-01f, 9.89338476e-03f, -6.86827451e-02f, -1.47895571e-02f, 1.84489697e-01f, 2.82622993e-01f, -5.79039939e-02f, -1.70848116e-01f, 1.33755594e-01f,
  1.56011820e-01f, 2.78310981e-02f, 2.53414661e-01f, 2.49337256e-01f, 8.83560628e-02f, 1.74467906e-01f, 1.29584474e-02f, 7.06223920e-02f, -1.83861963e-02f, -2.48889178e-01f,
  -9.71263573e-02f, -1.36724580e-02f, 9.23757553e-02f, -3.00169513e-02f, 7.98237547e-02f, -8.56009945e-02f, 8.86817053e-02f, 3.76349241e-02f, 4.47473191e-02f, 2.20120758e-01f,
  -1.47351325e-01f, -2.87722111e-01f, -4.74407896e-02f, -4.09899838e-02f, -8.27808306e-02f, -2.68275421e-02f, 6.06569462e-02f, 4.34584431e-02f, -1.23452090e-01f, -8.02865773e-02f,
  6.80318922e-02f, -4.76946868e-02f, -7.84770995e-02f, 3.58555913e-02f, -1.41490966e-01f, 4.15572111e-04f, 6.67637065e-02f, -1.08190216e-02f, 2.81105004e-02f, 2.40449943e-02f,
  1.04492329e-01f, -2.60946713e-02f, 6.63922951e-02f, 2.47846879e-02f, 1.41360968e-01f, -4.15751822e-02f, -1.61130000e-02f, 3.91168557e-02f, -2.80218646e-02f, -1.17939316e-01f,
  4.84854467e-02f, 6.02670610e-02f, 2.16407888e-02f, 2.82899104e-02f, -4.29463014e-02f, 6.83609620e-02f, 7.41483942e-02f, 4.76608686e-02f, 3.18135172e-02f, 9.04140696e-02f,
  -7.73673207e-02f, -2.18960084e-02f, -1.25668481e-01f, -4.63507278e-03f, 8.23334791e-04f, -1.44131109e-02f, -1.05750903e-01f, -8.39400962e-02f, 6.03182912e-02f, 5.12966812e-02f,
  -8.84143934e-02f, -1.09707609e-01f, 1.65733561e-01f, 9.06353444e-02f, -5.37051708e-02f, 4.24977988e-02f, 2.87780948e-02f, -1.47379218e-02f, -1.88146308e-02f, 3.91000956e-02f,
  -3.02514315e-01f, -2.97366649e-01f, -1.84021797e-02f, -6.40131161e-02f, -2.37350836e-02f, 2.84922011e-02f, 1.07622109e-02f, -8.79744813e-02f, -1.23959482e-01f, -1.33461475e-01f,
  -1.62102968e-01f, 1.00669555e-01f, -1.72475725e-01f, 3.63802947e-02f, 6.93271905e-02f, -1.75189262e-03f, -8.61228630e-03f, -1.01850256e-01f, -8.71794894e-02f, -4.55610789e-02f,
  -4.25955169e-02f, -1.22285441e-01f, 1.48731500e-01f, 1.24805100e-01f, 4.37132679e-02f, 7.22360909e-02f, -3.35962325e-02f, 3.26902010e-02f, -3.88599932e-02f, -2.22103633e-02f,
  -4.16694134e-01f, 1.04475923e-01f, -1.41985729e-01f, 8.07865560e-02f, -4.28646281e-02f, -1.43880740e-01f, 1.66396722e-01f, -6.43670186e-02f, -7.56561011e-02f, 2.49416977e-01f,
  3.73515904e-01f, -2.01918215e-01f, 2.49938339e-01f, 1.37199968e-01f, -4.48826760e-01f, 1.72786862e-01f, 2.16262080e-02f, 1.56965658e-01f, -9.78772640e-02f, 3.79095338e-02f,
  -1.58887282e-01f, 1.37504339e-01f, 1.09118909e-01f, -2.65163509e-03f, -3.30926105e-02f, -7.43911192e-02f, 1.19813763e-01f, 6.72808811e-02f, 3.37771699e-02f, -7.16769099e-02f,
  7.95850009e-02f, -8.24610144e-03f, -5.73676601e-02f, -2.55564563e-02f, -2.21228339e-02f, 4.99309599e-02f, -1.92662459e-02f, -1.26246616e-01f, 1.25503009e-02f, -4.18693312e-02f,
  -1.11784339e-02f, -7.53097087e-02f, -6.26330525e-02f, -8.15758854e-02f, 1.84432101e-02f, -6.27364218e-02f, -2.15549208e-02f, 4.30393331e-02f, -4.05898690e-02f, -6.49999455e-02f,
  4.76977788e-02f, -1.86499860e-02f, 9.71169968e-04f, 3.08145694e-02f, -7.35094994e-02f, 1.28552727e-02f, -8.14556330e-02f, -1.88577715e-02f, 4.53640008e-03f, -1.15980349e-01f,
  -8.56315047e-02f, -1.92343127e-02f, -3.56164165e-02f, 4.67288941e-02f, -2.90744826e-02f, 8.74743685e-02f, -3.98241309e-03f, 4.17191312e-02f, -1.37425140e-01f, 2.02925578e-02f,
  -2.44860295e-02f, -4.69590165e-02f, 1.21629886e-01f, -5.73154399e-03f, -1.39176995e-01f, -1.13972746e-01f, 4.18932699e-02f, 8.67588595e-02f, 5.46397828e-02f, -1.39070582e-02f,
  7.18820915e-02f, -3.75521332e-02f, 4.85063978e-02f, 7.52417073e-02f, 1.23355247e-01f, -5.80926761e-02f, 1.48053855e-01f, 2.15890463e-02f, 1.34448826e-01f, -1.14889070e-02f,
  5.30271865e-02f, -1.49998069e-01f, 2.06553806e-02f, 5.98858595e-02f, 5.12983687e-02f, -9.88971815e-02f, -1.42118990e-01f, -2.20338643e-01f, 3.28131318e-02f, -1.54608279e-01f,
  -5.04650474e-02f, 2.49072332e-02f, 6.92459717e-02f, -5.09219058e-02f, 2.28506215e-02f, 6.38989313e-03f, 3.43313329e-02f, 1.77760385e-02f, -1.03450762e-02f, 2.02700105e-02f,
  1.36656255e-01f, 3.32596898e-02f, 2.59713233e-02f, -2.08469443e-02f, -3.45197581e-02f, 1.64849058e-01f, 7.69309700e-04f, -2.79286951e-02f, 4.42434922e-02f, 3.47358584e-02f,
  -2.37233147e-01f, 2.41188779e-01f, -3.20969671e-01f, -8.33424553e-03f, 1.14863209e-01f, 2.19987139e-01f, 2.05312863e-01f, -1.60179324e-02f, 6.63162395e-02f, 3.14529747e-01f,
  2.96964675e-01f, -1.31928478e-03f, 1.74818918e-01f, 3.49752605e-01f, -2.21404299e-01f, 1.45975158e-01f, 1.86653748e-01f, 2.96403080e-01f, -5.53869419e-02f, -1.00667188e-02f,
  -8.11015368e-02f, 3.04870695e-01f, -9.28485841e-02f, -2.63173301e-02f, 1.62738085e-01f, -2.28046715e-01f, 2.91359145e-02f, -2.85638034e-01f, 1.00934677e-01f, 1.11332757e-03f,
  1.77762248e-02f, -1.06494047e-01f, -8.83910209e-02f, -2.01486826e-01f, -1.07804790e-01f, -5.71129508e-02f, -1.73186675e-01f, -5.72162643e-02f, -1.24901216e-02f, -2.86800228e-02f,
  -2.05791934e-04f, -8.14722627e-02f, 3.89700904e-02f, 2.36954391e-02f, -4.03506830e-02f, -6.06198721e-02f, -2.80113472e-03f, 5.48048615e-02f, 2.14165095e-02f, -5.65317459e-02f,
  9.03814584e-02f, -4.42220457e-02f, 1.36491144e-02f, -2.64243167e-02f, 1.27312150e-02f, 1.03356257e-01f, -6.83252886e-02f, -8.01261216e-02f, 4.64984998e-02f, 3.08091380e-02f,
  -8.88071023e-04f, -8.33363086e-02f, -8.17445591e-02f, 6.66340590e-02f, -3.24141569e-02f, 9.33516547e-02f, -4.04211879e-03f, -3.33779007e-02f, -7.71390796e-02f, 5.79966158e-02f,
  -4.51845862e-02f, -3.46306190e-02f, -9.87008289e-02f, 3.52392793e-02f, -4.05991636e-02f, -5.01859300e-02f, -4.56096493e-02f, 7.97451416e-04f, 2.41796765e-02f, -1.17556658e-03f,
  2.14903313e-03f, -1.16604241e-02f, 1.48937210e-01f, -1.00089889e-02f, -1.99781498e-03f, 3.55921313e-02f, 7.09130466e-02f, -5.29865781e-03f, -2.42402088e-02f, -5.09824865e-02f,
  1.02146491e-01f, -1.54408410e-01f, -5.51725104e-02f, -6.68407604e-02f, -6.58368170e-02f, 2.03771908e-02f, -1.35398000e-01f, -1.39692435e-02f, -7.71832420e-04f, -1.09797381e-01f,
  -2.49841753e-02f, 7.47628957e-02f, -3.88063416e-02f, 3.32542770e-02f, -1.44369816e-02f, 4.39361483e-02f, 4.11380036e-03f, 2.96909250e-02f, -2.89828004e-03f, -1.50188254e-02f,
  4.50810902e-02f, 3.89628224e-02f, -3.03295851e-02f, 3.02128680e-02f, 3.48891951e-02f, 1.13807857e-01f, 3.81088406e-02f, -9.90868285e-02f, 4.56544617e-03f, 1.13889307e-01f,
  -4.49334264e-01f, -1.95145920e-01f, 2.39619359e-01f, -2.82827169e-01f, -4.72989470e-01f, 1.88491791e-01f, 2.79169917e-01f, -1.56452119e-01f, -1.35545969e-01f, 8.29689056e-02f,
  -1.50825188e-01f, -1.56515568e-01f, 3.58291179e-01f, -5.83221242e-02f, 4.06186312e-01f, 3.86613816e-01f, 1.76032484e-01f, 1.90477967e-01f, -2.14569062e-01f, -1.85305536e-01f,
  -2.43452623e-01f, -2.53600299e-01f, 2.21487314e-01f, -2.81114608e-01f, -3.02333266e-01f, -1.99736938e-01f, -9.96773764e-02f, -9.35970619e-02f, -1.46828696e-01f, -1.11350603e-01f,
  -1.79846600e-01f, -3.07759285e-01f, 5.93129639e-03f, -2.12089028e-02f, -1.00107029e-01f, 4.52632941e-02f, 1.28220230e-01f, 1.13524266e-01f, -1.30135715e-01f, -8.66362359e-03f,
  1.31438281e-02f, 5.06535135e-02f, -1.19723804e-01f, 4.31683660e-02f, -9.80142727e-02f, -7.55111799e-02f, -1.32843629e-02f, -1.08640864e-01f, -1.53669566e-01f, 6.79828301e-02f,
  1.45197496e-01f, -1.18146345e-01f, 2.64033116e-02f, 1.67473685e-02f, -1.10253379e-01f, 2.52799364e-03f, 5.69461137e-02f, 1.77681483e-02f, -7.35557824e-02f, -9.84513834e-02f,
  7.03446791e-02f, 2.76881922e-02f, 6.19255565e-02f, 4.58305776e-02f, 1.14278439e-02f, 5.78227593e-03f, 1.38190743e-02f, -3.04580685e-02f, -6.57149255e-02f, -1.50091633e-01f,
  7.74112437e-03f, 5.84406331e-02f, 5.84332384e-02f, 1.20385736e-01f, -7.10798353e-02f, 3.76517773e-02f, 7.98703656e-02f, -3.93043682e-02f, 8.94188508e-02f, 3.09870522e-02f,
  -1.80236567e-02f, 1.09015509e-01f, -3.80897485e-02f, 9.35922861e-02f, 1.33247241e-01f, -1.48026999e-02f, -3.58355790e-02f, 1.44492552e-01f, -7.24365264e-02f, -4.28758897e-02f,
  -2.39148766e-01f, -2.98822194e-01f, -1.38816833e-01f, -1.01101480e-01f, 2.36532949e-02f, -7.94765651e-02f, -3.30068767e-02f, -6.39533326e-02f, -1.48271248e-01f, -4.04188298e-02f,
  -4.45158668e-02f, 1.18929446e-01f, -3.71426567e-02f, 1.21284932e-01f, 5.14920875e-02f, -2.09900551e-02f, 1.29130119e-02f, -1.05073787e-01f, -6.08529784e-02f, -6.46522120e-02f,
  -6.08220659e-02f, -2.37119645e-02f, 9.09377560e-02f, -5.05349934e-02f, 8.40707589e-03f, -2.75782263e-03f, -1.10603176e-01f, -5.88861108e-03f, -4.97113690e-02f, -4.66887979e-03f,
  -2.63979495e-01f, 3.75063181e-01f, 5.59183862e-03f, -3.67215020e-03f, 8.47464427e-02f, 1.79480344e-01f, 1.00505672e-01f, 7.92166814e-02f, 2.23343059e-01f, -2.05460992e-02f,
  -1.94271095e-02f, 2.64183640e-01f, 6.92447647e-02f, 3.72170694e-02f, -9.80691463e-02f, -1.14281140e-01f, -5.59812672e-02f, 1.31130382e-01f, 1.99414998e-01f, -4.84750755e-02f,
  -9.03397426e-02f, -1.21748090e-01f, -3.22803497e-01f, 1.11425050e-01f, -1.04284570e-01f, -5.01658302e-03f, -2.32506469e-01f, 2.98624694e-01f, -1.86334010e-02f, 2.37520933e-01f,
  -7.00333938e-02f, 9.96977463e-02f, 1.25884209e-02f, 4.48172539e-02f, -6.32937327e-02f, -1.32687137e-01f, 5.77535927e-02f, -2.62426976e-02f, 1.51531640e-02f, 1.14904992e-01f,
  -2.60454305e-02f, 3.97076868e-02f, 1.04488395e-01f, -3.97447906e-02f, 1.54828936e-01f, 5.54635562e-02f, -3.34129445e-02f, -3.31931710e-02f, 1.67565458e-02f, -2.03834809e-02f,
  -6.09090775e-02f, 3.94383185e-02f, 1.25392703e-02f, 7.08361790e-02f, 6.62081689e-02f, 9.01295319e-02f, 2.93294829e-03f, 2.20712423e-02f, 4.30133343e-02f, -1.00926623e-01f,
  6.27402514e-02f, -3.65809910e-02f, -3.45829576e-02f, -1.36043760e-03f, 6.32591993e-02f, 6.98117912e-02f, 1.01672523e-01f, -9.40563157e-02f, 1.06587254e-01f, -2.83771437e-02f,
  -6.81889132e-02f, 3.37310918e-02f, 1.86394174e-02f, 1.81919783e-02f, -8.57675299e-02f, -5.57531826e-02f, -2.16579121e-02f, 2.15573628e-02f, 5.05382866e-02f, -1.05004519e-01f,
  -2.29693055e-02f, -4.90282737e-02f, -5.43752424e-02f, -1.06050298e-02f, 7.67606124e-02f, -3.80006656e-02f, -3.45442630e-02f, -9.73551199e-02f, 7.78485835e-02f, -7.50304013e-02f,
  4.14242446e-02f, 1.29510775e-01f, 6.14218712e-02f, 1.56489700e-01f, 3.53352316e-02f, -2.81365514e-02f, -1.10226581e-02f, -3.40319462e-02f, 6.60395473e-02f, -4.57447581e-03f,
  -9.68647897e-02f, -2.63337400e-02f, -4.52462025e-02f, -7.37045929e-02f, 4.44305465e-02f, 4.93575912e-03f, -1.12267829e-01f, 7.19445050e-02f, -1.04795918e-01f, 9.17975977e-02f,
  5.72341084e-02f, 5.98950945e-02f, 7.43476972e-02f, -2.58713979e-02f, 6.71398342e-02f, 1.56481173e-02f, 3.82751040e-02f, 5.54243103e-02f, -5.36270365e-02f, -7.24656805e-02f,
  5.03968060e-01f, -3.92518759e-01f, -1.54022962e-01f, 2.07523435e-01f, 2.97427803e-01f, 2.55750060e-01f, 2.28481680e-01f, -1.20167278e-01f, -2.60591134e-02f, -3.32191199e-01f,
  1.46125928e-01f, -2.45211851e-02f, -2.05945417e-01f, 1.75693929e-01f, 5.10179877e-01f, -1.18758567e-01f, 1.62686646e-01f, 1.59535646e-01f, -5.35149761e-02f, 2.50949673e-02f,
  1.27173215e-01f, 2.54246444e-01f, -8.40058774e-02f, -1.68462127e-01f, 1.65266976e-01f, -2.11014494e-01f, -4.85561900e-02f, -6.95079118e-02f, -3.14997621e-02f, 1.66219220e-01f,
  9.31911767e-02f, 1.81928761e-02f, 8.11982006e-02f, -3.67512107e-02f, 5.34778126e-02f, 1.20714074e-03f, -1.35349467e-01f, 7.65042603e-02f, 1.23651490e-01f, -1.80377718e-02f,
  2.35848762e-02f, 9.12161171e-02f, 8.60348195e-02f, 7.95821026e-02f, 8.17246288e-02f, 7.12122917e-02f, -2.15516333e-02f, -2.92327572e-02f, -1.32429361e-01f, -6.56531528e-02f,
  3.86030935e-02f, 5.36079518e-02f, 5.61178140e-02f, -7.33264685e-02f, -1.13435328e-01f, -4.30370048e-02f, -5.72477505e-02f, -5.96737787e-02f, 5.78244887e-02f, -2.41562631e-02f,
  -1.05514517e-02f, -8.63829702e-02f, -3.58378477e-02f, 2.91144084e-02f, 7.24980831e-02f, 3.93042974e-02f, 5.34318350e-02f, 1.02686696e-02f, -3.93261090e-02f, 1.44552952e-02f,
  7.38467425e-02f, 7.04550594e-02f, -2.78008217e-03f, 1.65259585e-01f, 5.98469079e-02f, 1.82061866e-02f, 5.15467450e-02f, -8.71358812e-02f, 2.10790951e-02f, 3.12895589e-02f,
  6.77160099e-02f, -4.71285656e-02f, -1.56612303e-02f, -2.50483938e-02f, -1.09590124e-02f, 9.89464521e-02f, -1.20566793e-01f, 5.95273590e-03f, -9.69434455e-02f, 5.55250980e-02f,
  -1.11909643e-01f, -3.37288886e-01f, -8.71027410e-02f, 2.45370879e-03f, -6.71097338e-02f, 9.52137858e-02f, -2.64020730e-02f, -1.54836811e-02f, 3.52667831e-02f, 8.78033042e-02f,
  -2.96645667e-02f, 1.79396644e-02f, 5.99513128e-02f, 1.39717683e-01f, 1.41882629e-04f, -7.63660073e-02f, -1.46428987e-01f, 2.96366983e-03f, 4.60399911e-02f, -5.14335893e-02f,
  -6.65901601e-02f, 9.93569270e-02f, 1.55808413e-02f, 4.01440859e-02f, -1.07993394e-01f, -2.31013391e-02f, -5.55175990e-02f, -6.50874078e-02f, -5.74356057e-02f, -2.04093289e-02f,
  1.18451402e-01f, -2.32819747e-02f, 1.95919070e-02f, -1.53347462e-01f, 1.64906293e-01f, 1.98783159e-01f, 1.03700913e-01f, -3.61273885e-02f, -1.71994165e-01f, -3.01376134e-01f,
  -6.10415153e-02f, -2.19031960e-01f, 9.21292752e-02f, 9.54070408e-03f, 2.03868523e-01f, 1.52774736e-01f, -1.14978865e-01f, -1.54674888e-01f, 1.20315216e-01f, 7.96086714e-02f,
  -1.05981469e-01f, -3.63888452e-03f, 1.34422690e-01f, -1.96095239e-02f, 2.77560242e-02f, -8.32805783e-02f, -1.26809627e-01f, 1.54288471e-01f, -1.27933398e-01f, -5.78835420e-02f,
  1.98264837e-01f, 8.92816931e-02f, 1.97167024e-01f, 3.42818350e-03f, 4.92014699e-02f, 3.62753756e-02f, -1.39470011e-01f, -1.33772148e-02f, 8.25577751e-02f, 2.94199996e-02f,
  -1.61502421e-01f, -1.27976730e-01f, 3.64110209e-02f, 1.31345242e-01f, -2.84092184e-02f, -1.71795022e-02f, -5.56059554e-02f, 3.69296335e-02f, -2.45942563e-01f, -2.76304930e-02f,
  2.89602093e-02f, -7.46363848e-02f, -6.14117272e-02f, -1.81769624e-01f, -1.53448418e-01f, -2.23375842e-01f, -3.10028214e-02f, -8.10980871e-02f, -2.08821986e-02f, -1.06034897e-01f,
  -7.77809368e-03f, 2.05134857e-03f, 3.99478711e-02f, 8.70004296e-02f, 1.44634694e-01f, -2.07729335e-03f, -3.77258584e-02f, -6.85383333e-03f, -9.60065275e-02f, -1.14350267e-01f,
  -7.38222450e-02f, -3.91831920e-02f, 8.17724168e-02f, 1.83404572e-02f, 3.06734978e-03f, 2.91002300e-02f, 8.14916342e-02f, -8.45405981e-02f, -1.27244983e-02f, 4.11460586e-02f,
  8.19913074e-02f, -6.32007197e-02f, 5.22182975e-03f, -1.64291978e-01f, -1.55995181e-02f, 6.65965453e-02f, -7.58798122e-02f, 7.87263140e-02f, 1.64301351e-01f, -3.80168892e-02f,
  1.78643949e-02f, -1.63133159e-01f, 9.31741744e-02f, -2.80635394e-02f, 3.38495448e-02f, 9.33960602e-02f, 1.11441435e-02f, -1.53940678e-01f, 1.78106111e-02f, 5.57797104e-02f,
  -2.00558603e-01f, -5.08022718e-02f, 4.54093739e-02f, 7.26521462e-02f, -1.45776391e-01f, 1.94884520e-02f, -1.77717566e-01f, -1.84261904e-03f, -2.02147350e-01f, -1.64554939e-01f,
  -1.13566324e-01f, -5.33696599e-02f, -6.95293248e-02f, -1.73270348e-02f, -2.30783060e-01f, -2.54569352e-01f, 1.56567127e-01f, -5.37659340e-02f, -1.32090494e-01f, -4.83665615e-02f,
  -1.47413611e-01f, 2.11525157e-01f, 9.92670730e-02f, -1.60693303e-01f, -1.25060514e-01f, -1.66588143e-01f, -1.10729419e-01f, 1.20732233e-01f, 2.10515216e-01f, 1.46490991e-01f,
  7.70181045e-02f, 2.02950090e-01f, 1.79586425e-01f, -2.16767825e-02f, -2.09374785e-01f, 5.06241620e-02f, -3.73185873e-01f, -1.01505518e-01f, -3.75003703e-02f, -2.40938962e-01f,
  -2.10797906e-01f, -2.89095968e-01f, -1.12204663e-01f, -8.50748941e-02f, -1.39639482e-01f, 7.60193318e-02f, -2.34973505e-01f, 1.06557552e-02f, -1.05693139e-01f, 6.46162555e-02f,
  2.35605240e-01f, 2.08176762e-01f, 1.48360223e-01f, 2.02215120e-01f, -2.24659573e-02f, -5.47045246e-02f, -2.28023212e-02f, 1.45101622e-01f, 1.37543052e-01f, 6.06261827e-02f,
  -4.65996601e-02f, 1.78584531e-01f, -4.56570461e-02f, -9.69296321e-02f, -7.40039498e-02f, 5.45358360e-02f, -4.90904739e-03f, 7.22379535e-02f, 1.89740047e-01f, -6.82621449e-02f,
  -6.84255138e-02f, 4.67427596e-02f, -1.28348917e-01f, 4.37008590e-02f, 3.26915272e-02f, 9.92632136e-02f, 9.21438821e-03f, -8.93151090e-02f, -4.96429428e-02f, -6.84741512e-03f,
  -1.62177712e-01f, -1.18879057e-01f, 1.75052024e-02f, 3.28466296e-02f, -4.46133390e-02f, 1.09192275e-01f, -7.87823573e-02f, 2.06893813e-02f, -4.20167334e-02f, 2.15214491e-02f,
  2.08794586e-02f, 2.21030582e-02f, -4.41874601e-02f, -1.33639470e-01f, -9.91503820e-02f, 2.27130260e-02f, 3.39556374e-02f, 1.32585779e-01f, -1.40341073e-01f, 1.23808887e-02f,
  4.99592051e-02f, 1.01598063e-02f, 6.56043440e-02f, -1.36295095e-01f, -1.55916892e-03f, 3.36107798e-02f, -6.15750663e-02f, 5.95861599e-02f, 6.87397197e-02f, -2.03327820e-01f,
  9.32120606e-02f, -1.06792310e-02f, 1.63941160e-01f, 2.46696964e-01f, 5.06684147e-02f, -3.51654775e-02f, -7.88292214e-02f, 7.29015842e-03f, 5.57388142e-02f, -4.43469584e-02f,
  -3.56903337e-02f, 3.48493718e-02f, -1.64927661e-01f, -9.75422114e-02f, -2.46945638e-02f, -3.33230756e-02f, -4.14031371e-02f, 1.05387792e-01f, -7.96448439e-03f, -3.83210033e-02f,
  1.27199730e-02f, -3.54487337e-02f, -4.30098223e-03f, 2.65474860e-02f, -5.22751221e-03f, 4.51720096e-02f, -1.94535553e-02f, -7.35692959e-03f, -5.61978742e-02f, 5.85993901e-02f,
  -2.29058135e-02f, 1.29133344e-01f, -1.01527691e-01f, -1.99014675e-02f, -1.52915701e-01f, -3.89657110e-01f, -1.07650198e-01f, -1.17487185e-01f, 8.42371508e-02f, 2.03963965e-01f,
  5.56847593e-03f, 2.39911526e-01f, 1.05735756e-01f, -6.69352114e-02f, -3.07460129e-01f, 1.43649787e-01f, -1.87780946e-01f, 1.37773892e-02f, 6.62420467e-02f, -1.74158588e-01f,
  -1.05208255e-01f, -2.22896889e-01f, -3.07998657e-02f, -1.28127024e-01f, -1.10781923e-01f, 7.22252280e-02f, 7.97166750e-02f, -3.10949255e-02f, -1.55406401e-01f, 4.77693938e-02f,
  -1.51860192e-01f, 8.67236853e-02f, 4.37847339e-02f, -7.09616989e-02f, -1.28779843e-01f, -6.76491037e-02f, 9.79801118e-02f, -5.09928726e-02f, -1.82314347e-02f, -7.65207559e-02f,
  1.33118778e-02f, -1.19747147e-02f, -8.58841911e-02f, 1.21835187e-01f, 1.07542306e-01f, -3.44635732e-02f, -3.02043539e-02f, 2.88193151e-02f, 1.65440757e-02f, 6.66617751e-02f,
  3.67551856e-02f, -5.40677644e-02f, -1.62175763e-02f, 8.29060227e-02f, -8.82684533e-03f, -7.07727894e-02f, -7.63744935e-02f, 5.57942875e-02f, -9.92223248e-02f, -2.68852971e-02f,
  4.14934531e-02f, -3.45510840e-02f, -6.79904036e-03f, -4.99475971e-02f, -8.24706182e-02f, -7.47596100e-02f, 2.28324141e-02f, 5.31047620e-02f, 8.71205851e-02f, 1.13884499e-03f,
  -1.44852340e-01f, -1.91982090e-02f, -4.25693765e-02f, -1.47229033e-02f, -4.27920073e-02f, 3.70467715e-02f, -6.77067861e-02f, -2.62170285e-03f, -2.16492806e-02f, 1.12530161e-02f,
  3.67021039e-02f, -1.11320406e-01f, -3.09471460e-03f, 8.31081718e-02f, 3.52507569e-02f, 4.04953063e-02f, 4.16233502e-02f, -2.05130484e-02f, 4.94256169e-02f, -9.19378251e-02f,
  -1.48147166e-01f, -1.51655227e-01f, -2.21933108e-02f, -4.01656628e-02f, -3.11920866e-02f, -6.06995076e-02f, 6.50588498e-02f, -3.16209085e-02f, -1.01734519e-01f, -1.57882109e-01f,
  -8.08722079e-02f, 9.65675805e-03f, -1.62447929e-01f, 9.81055275e-02f, 5.62210055e-03f, -4.55122534e-03f, -6.00260275e-04f, 9.99280624e-03f, -9.87454876e-02f, 3.36704031e-02f,
  -5.87738715e-02f, -6.01785295e-02f, 1.75258890e-02f, 1.71567742e-02f, 5.49621433e-02f, -2.72262865e-03f, 3.94375026e-02f, 7.68312439e-02f, -1.38208997e-02f, -1.19605632e-02f,
  9.16673020e-02f, 5.20356419e-03f, 7.64787495e-02f, 8.36255029e-02f, 2.08995089e-01f, 1.97325453e-01f, 3.80711332e-02f, 2.71223307e-01f, 4.22950000e-01f, -1.35599971e-01f,
  -1.43292457e-01f, -1.86711490e-01f, -2.40120471e-01f, -1.00621708e-01f, 7.32578784e-02f, 1.41022086e-01f, 1.13512471e-01f, -1.39381830e-02f, 2.25289837e-01f, -5.91373518e-02f,
  -7.46004879e-02f, -1.85912311e-01f, -2.23490894e-01f, -1.41941696e-01f, -9.68456566e-02f, 7.61293098e-02f, -2.80199468e-01f, 5.33556864e-02f, -1.51703551e-01f, 1.03598036e-01f,
  2.15648580e-02f, 5.80855012e-02f, -9.77668762e-02f, -5.91585562e-02f, 2.72437800e-02f, 5.48048578e-02f, -4.21812721e-02f, -2.98420023e-02f, 1.77397933e-02f, 8.47447291e-03f,
  -2.21712902e-01f, -4.72993851e-02f, 3.95661071e-02f, -3.46808285e-02f, 6.33189902e-02f, 1.07134551e-01f, 1.60195846e-02f, 2.98458827e-03f, -5.56904227e-02f, -1.25933876e-02f,
  -9.48177055e-02f, -6.94894716e-02f, -4.38382924e-02f, 8.00279230e-02f, -4.45668958e-03f, -3.21720750e-03f, 1.48833273e-02f, 3.53797749e-02f, 7.49982372e-02f, -7.76373781e-03f,
  3.42850722e-02f, 7.90961087e-02f, -4.23141941e-02f, 3.26986574e-02f, -1.53491823e-02f, -4.95996475e-02f, -1.04991153e-01f, -2.94751418e-03f, 1.50892615e-01f, -1.15879878e-01f,
  -4.29800013e-03f, 7.51446187e-02f, 5.67572080e-02f, -3.28557529e-02f, 9.89091862e-03f, 4.51407433e-02f, 3.03127151e-03f, 8.31198096e-02f, 1.82987079e-02f, -5.73680475e-02f,
  7.68545792e-02f, 5.65484650e-02f, -1.11187257e-01f, -1.20613232e-01f, -2.92247757e-02f, 1.67471115e-02f, -9.70890149e-02f, 5.84269650e-02f, 2.79641226e-02f, -5.23244850e-02f,
  1.40216395e-01f, 1.63418069e-01f, -4.54450361e-02f, -1.12772547e-01f, 3.42153981e-02f, 6.12727590e-02f, 1.84629694e-01f, 1.63308028e-02f, 8.26291293e-02f, 1.03721909e-01f,
  -8.98910463e-02f, -2.77643837e-03f, 7.78907398e-03f, 6.19406253e-02f, 7.21882284e-03f, 1.32444371e-02f, -1.00407831e-01f, 4.38378118e-02f, -5.89789785e-02f, -2.94507463e-02f,
  -2.59072989e-01f, 4.97770011e-02f, -7.93656856e-02f, 1.61835738e-02f, -1.14080839e-01f, -1.82118416e-01f, -2.55413316e-02f, 5.19348532e-02f, 4.03578319e-02f, 8.16882253e-02f,
  -4.44588512e-01f, 3.73019844e-01f, -2.27921382e-01f, -1.25562400e-01f, 3.65102649e-01f, 4.15602654e-01f, 3.01814359e-02f, 2.57603467e-01f, -1.47512853e-01f, 2.18554676e-01f,
  3.76643836e-01f, -1.22190356e-01f, 1.31144345e-01f, 2.81008333e-01f, 6.59506209e-03f, 1.90012246e-01f, 2.09366858e-01f, 1.00311294e-01f, -9.72883701e-02f, -9.86865908e-02f,
  -4.60461201e-03f, 2.37077639e-01f, 1.48254424e-01f, 8.36049840e-02f, 1.35357708e-01f, -3.28124195e-01f, 2.25472692e-02f, -2.57822990e-01f, 1.34360507e-01f, 3.06984950e-02f,
  -2.27141064e-02f, -2.44604677e-01f, -1.97387278e-01f, -1.23155169e-01f, 5.73123153e-03f, -1.44653231e-01f, -3.11478954e-02f, -4.93674725e-02f, -1.52818456e-01f, -2.48031486e-02f,
  1.76888388e-02f, -9.72410515e-02f, -1.27274528e-01f, -8.59485641e-02f, -5.04241548e-02f, 2.41739023e-02f, 1.73514470e-01f, 1.88583851e-01f, 1.59827024e-01f, 3.93080479e-03f,
  9.08568129e-02f, 1.04600795e-01f, 8.01761001e-02f, 7.80873746e-02f, 1.08722925e-01f, 4.71725650e-02f, -3.19901742e-02f, -1.16743371e-02f, 6.76760003e-02f, 1.78863332e-02f,
  -4.96511906e-02f, -9.60688218e-02f, 5.78121282e-02f, -6.88970834e-02f, -2.05756575e-02f, 5.53339906e-02f, -9.44590662e-04f, 8.29448774e-02f, -1.04144394e-01f, 1.68816417e-01f,
  1.91723537e-02f, 1.90969296e-02f, -8.42913389e-02f, -3.52885872e-02f, 1.37909446e-02f, -7.82763660e-02f, -7.35103935e-02f, -9.67932120e-02f, -6.08875789e-02f, 4.57431283e-03f,
  -6.49341121e-02f, -4.95877713e-02f, 9.28551555e-02f, 2.98296940e-02f, 3.27268392e-02f, 7.79246017e-02f, 1.50953310e-05f, 3.34207974e-02f, 1.93062276e-02f, 5.66148795e-02f,
  1.73023939e-01f, -1.11923985e-01f, 4.69790725e-03f, 4.68374416e-02f, -8.32865611e-02f, -1.79038756e-02f, -7.56827816e-02f, -9.10758693e-03f, 8.36670399e-02f, -8.43657274e-03f,
  -3.16265933e-02f, -1.96007080e-02f, -1.10853828e-01f, -6.47872090e-02f, -2.24904902e-02f, 1.31847724e-01f, 3.32233086e-02f, -3.28584947e-02f, 9.40962434e-02f, -4.20587100e-02f,
  9.46459919e-02f, 6.69450359e-03f, -1.59271434e-03f, 1.14905983e-01f, 1.22355215e-01f, 1.10860981e-01f, -7.75528327e-02f, -2.54314765e-02f, 7.60866702e-02f, 1.65165067e-02f,
  2.22725332e-01f, -1.11647546e-01f, -2.94208050e-01f, -3.04199364e-02f, 1.09302802e-02f, -7.07832277e-02f, -2.31041610e-01f, 9.71690640e-02f, -1.70899749e-01f, 4.55464609e-02f,
  2.00917840e-01f, 4.19476703e-02f, -1.43650338e-01f, 3.02338988e-01f, 3.09216529e-01f, 1.69315301e-02f, 2.58659154e-01f, 6.78541064e-02f, -1.37816193e-02f, 1.82716787e-01f,
  2.19011888e-01f, 4.73158151e-01f, 2.34259248e-01f, 3.15893859e-01f, 1.71161920e-01f, -2.11783797e-02f, 2.20945835e-01f, -4.45918515e-02f, 2.26030633e-01f, 1.95699170e-01f,
  4.72924262e-02f, 6.29231408e-02f, 8.99447501e-02f, -3.86730395e-02f, 3.99737731e-02f, 6.23596236e-02f, 1.95250120e-02f, -4.74209227e-02f, -4.57647294e-02f, 2.96149869e-02f,
  -2.82601006e-02f, 6.80700615e-02f, 9.45643261e-02f, 1.20702740e-02f, -1.09131142e-01f, -1.83871910e-02f, -4.44070064e-02f, -8.70815292e-02f, -5.05509973e-02f, 4.39296886e-02f,
  -7.89316520e-02f, 3.12772878e-02f, -1.11723259e-01f, -6.78042844e-02f, -1.38145879e-01f, -5.81556447e-02f, -2.73753721e-02f, -1.12889530e-02f, -3.71536352e-02f, 1.15022004e-01f,
  1.14898279e-01f, 9.74053964e-02f, -6.39430135e-02f, -8.95247385e-02f, 2.17989106e-02f, -3.30797099e-02f, -4.41043973e-02f, -6.05448941e-03f, -6.90147355e-02f, 7.26783648e-02f,
  -4.72341999e-02f, -3.23080942e-02f, 3.44763845e-02f, 1.19180679e-02f, 1.84241027e-01f, 9.96170714e-02f, -1.81857683e-02f, 6.81577772e-02f, -9.03347507e-02f, -1.31604597e-01f,
  1.05871800e-02f, -6.28232211e-02f, -3.71296927e-02f, -1.62191298e-02f, -1.70172825e-02f, 1.03991572e-02f, 8.35863426e-02f, 7.51290470e-02f, 1.14020146e-02f, 1.47582348e-02f,
  7.27841705e-02f, 2.41129905e-01f, 2.17697341e-02f, -3.82970348e-02f, -4.03844118e-02f, 4.77916896e-02f, 1.36089027e-01f, 3.31899151e-02f, 5.01500331e-02f, 7.12438971e-02f,
  1.07168041e-01f, -6.81589842e-02f, 3.62182409e-03f, -2.09357440e-02f, -4.88384925e-02f, 4.06440236e-02f, 5.38754836e-02f, -6.91680685e-02f, 6.77643269e-02f, 1.26816789e-02f,
  5.17593557e-03f, -6.55708015e-02f, -7.55115300e-02f, -1.32135317e-01f, 1.47520110e-03f, -7.06898719e-02f, 2.86413059e-02f, -3.11345533e-02f, 3.89819499e-03f, -4.53606769e-02f,
  -6.67962581e-02f, -1.57534890e-02f, -2.75407165e-01f, -2.03127488e-01f, -1.11711040e-01f, -2.68621296e-01f, -1.78356484e-01f, -2.41426006e-02f, 1.41925037e-01f, 2.34265730e-01f,
  3.16446573e-02f, 7.22512975e-02f, 2.70998508e-01f, -1.16353787e-01f, -2.17484847e-01f, 1.89841494e-01f, -3.46951038e-01f, -1.16998650e-01f, 1.59362808e-01f, -2.06182823e-01f,
  -7.66604245e-02f, -2.17884425e-02f, -1.76929235e-01f, 3.28741036e-02f, -2.12920964e-01f, -7.97314048e-02f, -4.95590791e-02f, -2.23111808e-02f, -2.56182581e-01f, -7.17835426e-02f,
  -8.19351375e-02f, 2.04852059e-01f, -6.41113445e-02f, 8.11365023e-02f, -1.43833265e-01f, -1.04228575e-02f, -8.36824253e-02f, 6.75997064e-02f, 8.29775259e-02f, 5.06605431e-02f,
  1.36874365e-02f, 1.96910277e-01f, 2.39372440e-02f, -3.47661749e-02f, -9.99001116e-02f, -1.03712834e-01f, 1.28534818e-02f, -1.01957895e-01f, 7.67476857e-02f, -5.06508611e-02f,
  -5.34232333e-02f, -1.65835302e-02f, -1.40300617e-01f, 6.36533201e-02f, 8.79222713e-03f, -4.37775441e-02f, -5.49641214e-02f, -6.88406527e-02f, -8.24222192e-02f, -1.70975656e-03f,
  -3.89637463e-02f, 5.41796610e-02f, -2.55122781e-03f, 3.32159325e-02f, 7.56231323e-03f, 1.18286684e-02f, -4.32399698e-02f, 7.21125398e-03f, 2.20582411e-02f, -3.61552909e-02f,
  -5.27614914e-02f, -4.44843061e-02f, 2.45071109e-02f, -6.80882037e-02f, 4.86410521e-02f, 2.24155840e-02f, -2.98768114e-02f, 3.26549984e-04f, -4.12556902e-02f, -1.52754053e-01f,
  6.82283267e-02f, 2.15296224e-02f, 5.04912324e-02f, 5.27288474e-04f, -1.00599609e-01f, 9.85695273e-02f, -7.22348981e-04f, 4.28266823e-03f, -1.23090193e-01f, -8.45348388e-02f,
  -7.44509697e-02f, 6.01965450e-02f, 1.45965323e-01f, 1.18612029e-01f, -2.64215972e-02f, -2.55970359e-02f, -2.94973552e-02f, 3.13365087e-02f, -5.16769551e-02f, 3.82549800e-02f,
  -7.24733919e-02f, 1.41645980e-03f, -1.09273784e-01f, -3.44607532e-02f, -5.22242561e-02f, -1.60893410e-01f, -1.56321563e-02f, 1.84529554e-02f, -5.62691353e-02f, -2.93286927e-02f,
  -4.32199463e-02f, -9.35465656e-03f, 1.15995323e-02f, 9.10431668e-02f, -2.76959110e-02f, 2.66565848e-02f, -3.72904688e-02f, -2.17424496e-03f, -5.43360971e-02f, 3.83118540e-02f,
  -3.48033905e-02f, 1.08533174e-01f, -8.29775482e-02f, -4.25366350e-02f, -1.24806426e-01f, -1.74025193e-01f, -4.45568439e-04f, -1.21835381e-01f, 5.53102838e-03f, 1.58401594e-01f,
  -1.24048635e-01f, 2.91172355e-01f, 3.35363150e-02f, 5.97634492e-03f, -9.49259922e-02f, 1.04269080e-01f, -1.51411772e-01f, 5.39157260e-03f, -1.08243123e-01f, -6.27852231e-02f,
  -1.09394521e-01f, -2.15117902e-01f, -6.75946772e-02f, -5.14376014e-02f, -1.01622477e-01f, 1.70558672e-02f, 4.71032076e-02f, 5.73981889e-02f, -5.02131432e-02f, -1.25625487e-02f,
  -7.42590204e-02f, 1.69662409e-03f, 6.94328407e-03f, -3.12969759e-02f, -1.17026024e-01f, -8.19924921e-02f, 1.49144262e-01f, -2.17977650e-02f, -9.80010629e-02f, 2.82694818e-03f,
  8.02330598e-02f, -7.87842199e-02f, -3.67034152e-02f, 5.15229963e-02f, 3.23347114e-02f, 5.84621988e-02f, 3.73611115e-02f, -1.10519297e-01f, -6.85887784e-02f, -3.85146178e-02f,
  2.08069049e-02f, -1.04758270e-01f, -3.81491818e-02f, 1.15557730e-01f, -4.53407951e-02f, -1.43317133e-01f, 9.54862684e-02f, 5.87786548e-02f, 7.95016140e-02f, -1.80331320e-01f,
  3.77681758e-03f, 5.69035597e-02f, 9.34033394e-02f, -3.89556959e-02f, 2.03905720e-02f, -1.18201070e-01f, 2.31406074e-02f, 3.64925340e-02f, 7.51463044e-03f, -3.50113399e-02f,
  -1.39985615e-02f, 1.45456210e-01f, 6.10134862e-02f, -6.41394332e-02f, -2.93204729e-02f, 1.21022120e-01f, -3.07183228e-02f, 2.91107595e-02f, -4.00678925e-02f, -1.51605085e-01f,
  -4.25592205e-03f, -6.75207302e-02f, -6.08524606e-02f, 2.85018478e-02f, -8.41807388e-03f, 5.16697429e-02f, 2.12293528e-02f, -4.62492602e-03f, -7.72626251e-02f, -6.69835582e-02f,
  -1.20612614e-01f, -4.92793731e-02f, -6.56639263e-02f, -7.06308931e-02f, -1.22857206e-02f, 8.17348249e-03f, 6.59318268e-02f, 4.65453602e-02f, -1.10761844e-01f, 5.22815548e-02f,
  4.41322289e-02f, -2.31086351e-02f, -3.83417122e-02f, 3.30582783e-02f, -2.28801053e-02f, -6.52959198e-02f, 8.26767534e-02f, -3.49777844e-03f, -1.24746887e-02f, -3.48894559e-02f,
  -9.72624421e-02f, 2.99752429e-02f, -3.00704185e-02f, -3.85134369e-02f, -5.35117579e-04f, -9.68292654e-02f, 3.91802229e-02f, 1.05859898e-02f, -3.81801054e-02f, -1.22449338e-01f,
  -5.50025813e-02f, 2.54347801e-01f, 7.53457323e-02f, -8.69516507e-02f, 9.82238352e-03f, -3.02210897e-01f, -2.02274382e-01f, 2.76296604e-02f, 4.55978252e-02f, 1.42789707e-01f,
  -1.14340849e-01f, 2.58692622e-01f, 6.50272071e-02f, -1.17913969e-01f, -4.86526132e-01f, -2.37274289e-01f, -2.13059098e-01f, -9.09817368e-02f, -9.14785415e-02f, -1.05822291e-02f,
  -9.13662612e-02f, -1.90424800e-01f, -1.69787362e-01f, 7.20609874e-02f, 8.72274488e-02f, 2.20408350e-01f, -7.17629194e-02f, 1.84808716e-01f, -4.09962572e-02f, -7.37730786e-02f,
  -6.31965846e-02f, 4.85786721e-02f, 5.93010895e-02f, -4.65790294e-02f, -8.39597136e-02f, 6.52605146e-02f, 4.23460305e-02f, -6.19074330e-03f, -5.04772877e-03f, -6.98948801e-02f,
  3.48888226e-02f, -5.16621135e-02f, 2.66153924e-02f, 6.79775281e-03f, 5.91291152e-02f, 8.39392468e-03f, -4.05334458e-02f, -1.00685610e-02f, -2.61442978e-02f, 9.75123234e-03f,
  2.56483350e-02f, 7.70806670e-02f, -1.73807014e-02f, -4.62361537e-02f, -8.26530438e-03f, 4.78492817e-04f, -3.65258823e-03f, 7.52412826e-02f, 3.30548920e-02f, 3.83080840e-02f,
  1.93641596e-02f, 7.72413891e-03f, -4.27440886e-04f, 4.60635386e-02f, 2.08017435e-02f, 6.52824640e-02f, -3.09744086e-02f, 6.56569377e-02f, 3.96565162e-02f, 7.50525063e-03f,
  -7.01709166e-02f, -2.53830827e-03f, -5.14978133e-02f, -8.01804767e-04f, 2.47316738e-03f, 2.84449160e-02f, -4.72568758e-02f, 5.42232729e-02f, -3.23680080e-02f, 1.66105218e-02f,
  4.03237231e-02f, -4.40127812e-02f, 4.05618884e-02f, -6.36124909e-02f, -1.10826015e-01f, 2.12334618e-02f, -1.56439859e-02f, -6.04485013e-02f, 2.74456758e-02f, -2.28062328e-02f,
  -2.04664961e-01f, -8.00105482e-02f, 2.98822243e-02f, 1.52887581e-02f, 7.38685485e-03f, -2.54211724e-02f, 9.22781155e-02f, 2.91351564e-02f, 1.07827308e-02f, -5.54521158e-02f,
  -2.83432901e-02f, -1.89802404e-02f, 7.27253128e-03f, 1.74349938e-02f, 3.56848631e-03f, -8.11898187e-02f, -6.30877391e-02f, 3.38517390e-02f, -8.74794424e-02f, 1.47108845e-02f,
  5.16275242e-02f, 3.12417280e-02f, 3.54436822e-02f, 2.91962409e-03f, 4.08877768e-02f, -2.57896278e-02f, 4.90869619e-02f, 9.28925946e-02f, 2.20007449e-02f, 6.93332702e-02f,
  1.94895510e-02f, 3.09726477e-01f, 3.01102370e-01f, 1.99498624e-01f, -1.82706773e-01f, -9.58460718e-02f, -8.89598504e-02f, 7.75239766e-02f, -4.26336527e-02f, 7.81829730e-02f,
  -6.53390884e-02f, 2.77537495e-01f, -3.98165286e-02f, 2.19013140e-01f, -1.45560056e-01f, -7.43111446e-02f, 1.39965892e-01f, 1.64179858e-02f, 9.02529210e-02f, 7.82896131e-02f,
  -5.62177077e-02f, -3.30114588e-02f, 1.30048379e-01f, 4.85892855e-02f, 2.00352564e-01f, 1.64346531e-01f, -6.03991514e-03f, -6.48778826e-02f, 2.84821600e-01f, -3.56824994e-02f,
  -3.02097034e-02f, 1.55944511e-01f, 9.04191509e-02f, 1.06017247e-01f, -3.85270491e-02f, -2.62147412e-02f, 1.60624295e-01f, -3.43057439e-02f, -4.52436507e-02f, 2.25607846e-02f,
  9.69785899e-02f, 3.67861576e-02f, 4.38050814e-02f, -9.98238698e-02f, 1.04469182e-02f, 5.64652048e-02f, 8.26930180e-02f, -4.59908992e-02f, 1.38740674e-01f, 1.85870994e-02f,
  9.11300704e-02f, -4.51530479e-02f, 7.93045312e-02f, 9.54358727e-02f, 4.93883118e-02f, 3.57678533e-02f, 5.76806217e-02f, 1.59344729e-02f, 1.51950885e-02f, 8.96467119e-02f,
  -1.28893619e-02f, -4.72053029e-02f, -1.44722620e-02f, 1.58409607e-02f, -3.03486381e-02f, -3.94224077e-02f, 7.25597814e-02f, 9.35952365e-03f, 7.73446932e-02f, 9.31141526e-02f,
  -5.30082434e-02f, 1.54442757e-01f, 2.15265006e-02f, -1.92276016e-02f, 7.24529698e-02f, -5.06721251e-02f, -2.14874353e-02f, 1.15105852e-01f, 5.01889251e-02f, 1.03773162e-01f,
  -5.62610812e-02f, -5.17236702e-02f, 2.19920166e-02f, 6.08495399e-02f, -4.56222557e-02f, -1.32686436e-01f, 1.23646945e-01f, 4.43818420e-03f, -3.40884998e-02f, 2.96937451e-02f,
  1.09406412e-01f, 2.38840654e-01f, 9.76197720e-02f, 5.05904183e-02f, 5.65210618e-02f, 4.06716689e-02f, 2.86633242e-02f, 1.42309070e-01f, 1.06507562e-01f, 2.33704075e-02f,
  6.89038038e-02f, 9.30035207e-03f, -5.83363399e-02f, -2.01334357e-02f, 1.61046200e-02f, 6.58150092e-02f, 4.57897149e-02f, -4.35865863e-04f, -1.75848957e-02f, 8.05287734e-02f,
  3.10958866e-02f, -1.08068950e-01f, 6.63635209e-02f, -2.88923718e-02f, 1.38357401e-01f, 1.95946973e-02f, -8.23738053e-02f, 3.92233618e-02f, 5.12968004e-02f, 2.80890130e-02f,
  8.03709254e-02f, -3.08270365e-01f, -3.85913253e-01f, -2.28441834e-01f, 2.93933123e-01f, 3.65322858e-01f, -1.80600598e-01f, 3.61432247e-02f, -3.92355412e-01f, 8.24248195e-02f,
  1.68928474e-01f, -1.83717221e-01f, -3.50459009e-01f, 6.38723746e-02f, 2.20976565e-02f, -3.15327615e-01f, 1.20446853e-01f, 7.38378614e-02f, -1.03558712e-01f, 1.99596763e-01f,
  3.27641144e-02f, 3.49914730e-01f, -6.80704415e-02f, 2.55945355e-01f, 1.03762776e-01f, -3.42699401e-02f, 2.50510424e-01f, -2.56588086e-02f, 2.72499174e-01f, 6.81276545e-02f,
  7.84592554e-02f, -5.76144606e-02f, -5.87444082e-02f, 5.96442167e-03f, 1.79573610e-01f, 1.60681054e-01f, 1.24054492e-01f, -9.95903611e-02f, 1.57643575e-02f, -1.27758030e-02f,
  2.19760854e-02f, -6.34859055e-02f, -4.19136323e-02f, -3.47433821e-03f, 1.81633867e-02f, 7.12284679e-03f, -4.75414060e-02f, -1.20504282e-01f, -7.61613175e-02f, -5.72405532e-02f,
  -1.98209405e-01f, 6.53226897e-02f, -1.25118226e-01f, -1.10972643e-01f, -1.00566521e-01f, -1.29008308e-01f, 9.02154297e-03f, 7.36410171e-02f, -4.71538715e-02f, 4.06921767e-02f,
  8.29330459e-02f, 5.83795942e-02f, -4.74021584e-02f, -1.25915602e-01f, 6.94186091e-02f, -3.77370343e-02f, -9.14939214e-03f, 1.09974071e-01f, -1.02414362e-01f, 6.00022227e-02f,
  1.25262663e-02f, -6.99000880e-02f, -6.39256686e-02f, 9.70029980e-02f, 1.38454661e-01f, 9.36338976e-02f, 2.08294280e-02f, -2.68652681e-02f, -4.61656228e-02f, -3.48600410e-02f,
  -4.69453372e-02f, 2.70908792e-02f, 4.69796434e-02f, 5.39462194e-02f, 5.76989353e-03f, 8.85179639e-03f, 6.21338608e-03f, 2.78773662e-02f, -1.24441115e-02f, -5.01095280e-02f,
  1.30928243e-02f, 7.38030002e-02f, -2.39095166e-02f, -1.86443217e-02f, -6.74211979e-02f, 2.86690202e-02f, -6.37686402e-02f, -1.04837634e-01f, 3.53744179e-02f, 8.60331953e-02f,
  1.85264081e-01f, -4.53593247e-02f, 2.69924849e-02f, -6.92155883e-02f, -3.11637986e-02f, 4.26185690e-02f, 5.59536032e-02f, -6.44765645e-02f, 3.00646015e-02f, 8.10862631e-02f,
  6.32587895e-02f, 8.22679177e-02f, -1.89993918e-01f, -3.11519187e-02f, -1.42062269e-02f, 1.48292501e-02f, 1.45572349e-01f, -1.06533244e-03f, -9.82050300e-02f, -8.49767849e-02f,
  5.15890658e-01f, 2.77578831e-01f, 1.95601016e-01f, 3.23513597e-01f, 6.37209937e-02f, 7.79067306e-03f, 2.37711549e-01f, -2.14051809e-02f, 3.67405146e-01f, -3.79338041e-02f,
  -9.00719240e-02f, 2.42835835e-01f, -2.85233885e-01f, 1.65705979e-01f, -1.85076997e-01f, -2.54408479e-01f, 1.23075090e-01f, 1.39196843e-01f, -7.79977664e-02f, 1.23067386e-01f,
  6.08670041e-02f, -2.92979956e-01f, -8.79304260e-02f, -2.55647570e-01f, 1.33608803e-01f, 1.73763931e-01f, -2.75185078e-01f, -9.02158618e-02f, 3.79969738e-02f, -1.06047675e-01f,
  1.10324167e-01f, 1.43206611e-01f, 1.23523315e-02f, 1.53449727e-02f, 4.42907773e-02f, -7.06811920e-02f, -1.96080580e-02f, -1.11339845e-01f, 2.99526043e-02f, 5.79366386e-02f,
  8.66518915e-03f, -7.96529502e-02f, 2.44479254e-02f, -5.54413088e-02f, 2.11832941e-01f, 8.35390091e-02f, 4.74585108e-02f, 1.58527821e-01f, -7.52905558e-04f, 4.79223318e-02f,
  1.50362089e-01f, 8.05981830e-02f, 1.69485211e-01f, 7.36361891e-02f, 5.99650107e-02f, 6.71987534e-02f, -1.44234411e-02f, 4.47496213e-02f, 4.49562743e-02f, 1.22832926e-02f,
  -7.41239637e-02f, -8.10238048e-02f, -6.47434441e-04f, 2.44210251e-02f, -3.60479988e-02f, -1.54830767e-02f, 4.19860259e-02f, -7.91127905e-02f, 8.31328481e-02f, -8.64749029e-03f,
  -1.61585975e-02f, 7.99125135e-02f, -1.07872710e-02f, 3.32952142e-02f, -3.30899954e-02f, 1.07823737e-01f, -8.58411938e-02f, -1.27852827e-01f, 1.68281376e-01f, 7.56348833e-04f,
  -1.36758015e-01f, 3.74905244e-02f, -3.29449065e-02f, 6.37224759e-04f, -8.87223240e-03f, -2.09673680e-02f, -8.85176733e-02f, -1.69856902e-02f, 6.44196570e-02f, -1.44407243e-01f,
  -1.34925544e-01f, -2.52869576e-01f, 3.35876644e-02f, -3.58722708e-03f, -5.85364364e-02f, -8.70883558e-03f, -8.05209670e-03f, 4.94978577e-02f, -2.79056188e-02f, -6.77838922e-02f,
  1.00482376e-02f, 1.29617471e-02f, 4.23239805e-02f, 6.50967509e-02f, 2.05963291e-02f, -5.40659875e-02f, -2.37674210e-02f, -1.21005364e-02f, -1.57387987e-01f, -8.72606486e-02f,
  1.21473474e-02f, 3.68155204e-02f, 7.63707533e-02f, 9.85335484e-02f, -1.52540430e-02f, 6.82773488e-03f, 6.29191101e-02f, 1.00745745e-01f, -1.04213715e-01f, -4.14580852e-02f,
  2.96166033e-01f, 9.97547507e-02f, -9.62293744e-02f, 1.09957650e-01f, -1.12799304e-02f, 1.11449525e-01f, -1.13284037e-01f, 9.04752314e-02f, -9.70865190e-02f, 4.34744032e-03f,
  -1.12847641e-01f, 3.07196528e-02f, -2.78443873e-01f, 2.23070979e-01f, 4.57895100e-01f, -1.55686736e-01f, 3.57485831e-01f, 1.11046948e-01f, -7.12548941e-02f, 2.69110382e-01f,
  5.07900864e-02f, 3.24013352e-01f, -1.14253782e-01f, 1.91139698e-01f, 8.16073045e-02f, -1.29005119e-01f, 9.46773514e-02f, -1.81628168e-01f, 9.09188986e-02f, 7.11468235e-02f,
  3.89088504e-02f, 3.08306254e-02f, -1.77087896e-02f, -3.79572958e-02f, 8.21081996e-02f, -1.24333957e-02f, -1.14294372e-01f, 1.24031454e-01f, -9.39881057e-02f, -1.54423028e-01f,
  7.41503164e-02f, 2.56524123e-02f, 6.55090138e-02f, 1.02685541e-01f, 6.26675338e-02f, 5.00403643e-02f, -5.10251150e-02f, 1.56697351e-02f, 6.30949959e-02f, 4.46231402e-02f,
  6.54909611e-02f, -3.54414061e-02f, 3.33992988e-02f, 8.71457681e-02f, -2.44372319e-02f, 7.26503059e-02f, 4.31269631e-02f, 5.38781285e-02f, 6.62947446e-02f, 1.38760179e-01f,
  7.34723210e-02f, 2.12689526e-02f, 8.70672800e-03f, -6.38134331e-02f, 1.04370728e-01f, 6.04136288e-02f, 2.06306409e-02f, -7.89793208e-02f, -5.20289168e-02f, 4.08563837e-02f,
  1.77209955e-02f, -5.88723412e-03f, -5.37875146e-02f, 7.36685097e-02f, -6.82539865e-02f, 1.98944714e-02f, -4.57838885e-02f, -4.76525761e-02f, -5.32137677e-02f, 1.54728189e-01f,
  1.24602839e-02f, 1.51555315e-01f, -5.43752387e-02f, -1.52871802e-01f, 5.25800474e-02f, -1.24129049e-01f, 5.78893814e-03f, -7.67557919e-02f, -7.61226192e-02f, 8.88543874e-02f,
  1.23918451e-01f, 2.56981671e-01f, 3.90994139e-02f, -2.68769450e-03f, 6.62808493e-02f, 1.31944597e-01f, -4.75191046e-03f, 1.11735016e-01f, 1.22351445e-01f, 6.70048892e-02f,
  1.15953699e-01f, -1.20865725e-01f, -6.08691610e-02f, -1.81784120e-03f, 7.79339001e-02f, 1.30320489e-01f, -5.35652973e-02f, 1.10068908e-02f, 1.81897685e-01f, 1.21409111e-01f,
  1.00301445e-01f, -1.14475697e-01f, 2.07714453e-01f, -1.75899677e-02f, 1.25081748e-01f, -1.10195894e-02f, 8.61251354e-02f, 2.71685962e-02f, 4.76755016e-02f, 2.43930481e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  3.03306699e-01f, 1.81407541e-01f, 2.45939493e-01f, 2.44778946e-01f, 1.90830424e-01f, 2.28775576e-01f, 1.02792509e-01f, 1.83801532e-01f, 3.21669728e-01f, 3.30157548e-01f,
  2.38977000e-01f, 2.43309125e-01f, 2.49340013e-01f, 1.56795159e-01f, 3.37642789e-01f, 1.12622306e-01f, 3.80745113e-01f, 2.44086117e-01f, 2.56796449e-01f, 2.48352349e-01f,
  3.52757722e-01f, 2.07541764e-01f, 2.78657943e-01f, 2.98406363e-01f, 2.75668949e-01f, 2.01795831e-01f, 1.88644096e-01f, 1.54001117e-01f, 2.68888801e-01f, 1.30357534e-01f,
  2.36140236e-01f, 2.88917661e-01f, 1.91556215e-01f, 2.13777930e-01f, 1.58101007e-01f, 2.23525271e-01f, 3.19682181e-01f, 2.66849905e-01f, 1.51971385e-01f, 2.40170494e-01f,
  3.44454080e-01f, 2.58834988e-01f, 2.59071529e-01f, 2.37117171e-01f, 2.34689295e-01f, 2.53397644e-01f, 1.47822082e-01f, 2.00155050e-01f, 1.04266874e-01f, 2.01413751e-01f,
  2.29968652e-01f, 6.83389679e-02f, 2.63077348e-01f, 1.21548086e-01f, 2.86614776e-01f, 3.29243451e-01f, 1.81891322e-01f, 1.95135444e-01f, 3.54122102e-01f, 1.85070142e-01f,
  2.04079881e-01f, 2.20337540e-01f, 2.76852697e-01f, 3.41158003e-01f, 1.85834542e-01f, 2.09999040e-01f, 2.88246989e-01f, 1.30567327e-01f, 1.74031422e-01f, 2.21717492e-01f,
  2.35211119e-01f, 1.98562056e-01f, 2.71791160e-01f, 2.74642617e-01f, 1.70907691e-01f, 1.30350575e-01f, 3.45352173e-01f, 1.68034390e-01f, 2.26521343e-01f, 1.50649130e-01f,
  1.00960881e-01f, 1.58578157e-01f, 2.21885294e-01f, 2.21576050e-01f, 1.90126181e-01f, 2.39098549e-01f, 1.39580950e-01f, 1.38312906e-01f, 2.97607303e-01f, 1.99566588e-01f,
  3.01751912e-01f, 1.76484928e-01f, 4.60612662e-02f, 1.74571931e-01f, 2.61866093e-01f, 1.79583684e-01f, 1.21385314e-01f, 8.89028087e-02f, 3.20020348e-01f, 1.93036243e-01f,
  2.30833232e-01f, 2.86349863e-01f, 2.13599294e-01f, 3.38010937e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -7.81584755e-02f, -8.18537399e-02f, -1.03225462e-01f, -1.30304784e-01f, -1.12174302e-01f, -2.54632175e-01f, -5.81071265e-02f, 1.90742880e-01f, -7.72625357e-02f, -5.04442565e-02f,
  -1.54990852e-01f, 1.37040615e-01f, 3.01518012e-02f, -1.21959127e-01f, -1.86683640e-01f, -7.41634592e-02f, 2.48482034e-01f, -3.42419177e-01f, -2.66515672e-01f, 5.35674766e-02f,
  4.70070168e-02f, -1.68321446e-01f, 1.83687985e-01f, -4.61486243e-02f, -1.16240215e-02f, -4.08241153e-02f, -3.90172228e-02f, -4.22452748e-01f, 2.97542512e-01f, -1.13905393e-01f,
  3.34559321e-01f, -1.66957565e-02f, -3.80542785e-01f, 2.66509771e-01f, -2.62049645e-01f, -3.87393206e-01f, 1.25759423e-01f, -1.93317130e-01f, -3.38985950e-01f, 1.65430352e-01f,
  -6.08357638e-02f, 3.11773717e-01f, -1.99119031e-01f, -1.92805782e-01f, -2.76315749e-01f, -2.20768854e-01f, -3.36213052e-01f, 2.96882391e-01f, 2.44391672e-02f, -2.61499524e-01f,
  -2.12933987e-01f, 4.14479822e-01f, -3.15515369e-01f, 1.56978950e-01f, 4.45080213e-02f, -1.81890845e-01f, -8.38078782e-02f, 2.05230173e-02f, 1.70335740e-01f, -3.16817850e-01f,
  -3.02558094e-01f, -2.55976707e-01f, -3.15398604e-01f, -6.70845807e-02f, -3.74022514e-01f, -1.24122873e-01f, -1.41264871e-01f, 5.75427292e-03f, -2.11522162e-01f, -3.59448701e-01f,
  2.95837104e-01f, -1.76457196e-01f, -9.08845291e-02f, -2.13024125e-01f, -1.87242161e-02f, 3.74818295e-01f, 1.18616290e-01f, -1.37793735e-01f, -2.78884053e-01f, -7.29998350e-02f,
  -1.72957629e-01f, -8.10895115e-02f, -1.12402566e-01f, 4.03209925e-01f, -1.17637999e-01f, 1.83359787e-01f, -2.65935898e-01f, -5.10176480e-01f, -3.41437280e-01f, -2.63050616e-01f,
  -1.94301307e-01f, 5.43440163e-01f, -2.97996625e-02f, 3.85844886e-01f, 3.69901180e-01f, -8.19856003e-02f, -3.98841649e-01f, -1.45674795e-01f, -1.44268185e-01f, -2.90847607e-02f,
  -2.63872296e-01f, 3.00944388e-01f, -3.05426985e-01f, -8.84071812e-02f, -1.60619646e-01f, -2.29072601e-01f, -1.25677764e-01f, -3.18454951e-01f, 5.36954440e-02f, 3.74262154e-01f,
  4.70101148e-01f, 3.43792796e-01f, 4.01296943e-01f, -3.84410560e-01f, -2.96867341e-01f, 6.21883757e-02f, -4.73449007e-03f, 1.28119960e-01f, -3.82605165e-01f, 2.24138439e-01f,
  -1.02263138e-01f, 8.74225330e-03f, 1.23935021e-01f, -2.43337736e-01f, -1.07437350e-01f, -7.95439109e-02f, -7.97122493e-02f, -2.65144289e-01f, 1.65335104e-01f, 2.48955727e-01f,
  1.60366461e-01f, 1.29948705e-01f, -5.85457124e-02f, 2.69838423e-01f, 2.87496299e-01f, -5.24677709e-02f, 2.20824666e-02f, -1.61703855e-01f, -7.00339898e-02f, -2.19427571e-01f,
  2.20258519e-01f, -9.47066303e-03f, 1.44289330e-01f, -4.79988873e-01f, 1.11328373e-02f, 6.33458644e-02f, 6.40094280e-02f, 5.77894509e-01f, 2.33845174e-01f, -1.99234888e-01f,
  -3.34747299e-03f, -3.18116248e-01f, 8.42017755e-02f, 3.11790079e-01f, -2.63858318e-01f, 9.21443030e-02f, 2.71934927e-01f, -1.71629429e-01f, 2.90020734e-01f, 2.79919177e-01f,
  -2.08853021e-01f, -2.77577102e-01f, -3.09699774e-01f, 3.26272786e-01f, -6.50447547e-01f, -2.07082912e-01f, -8.33017379e-02f, -4.03233528e-01f, -9.22101960e-02f, -1.54117554e-01f,
  -2.57651597e-01f, 2.00590551e-01f, -2.65666455e-01f, -8.10330138e-02f, -2.52532452e-01f, -6.36908561e-02f, 4.02333826e-01f, -8.72917473e-02f, -1.82304993e-01f, -1.08354967e-02f,
  -1.82355687e-01f, -6.71353564e-03f, -3.35295171e-01f, 3.67043346e-01f, -6.05487823e-01f, -2.90349871e-01f, -2.73418158e-01f, -3.57730329e-01f, -5.18080443e-02f, 5.55423610e-02f,
  -2.15547308e-02f, 8.79312009e-02f, -3.20478708e-01f, 1.45122662e-01f, -2.80925930e-01f, -3.91924649e-01f, 1.45135298e-01f, -1.25240669e-01f, -1.41613603e-01f, 3.46480936e-01f,
  -2.41785839e-01f, 3.83675933e-01f, 2.73193093e-03f, 3.92571129e-02f, -5.76653659e-01f, -2.24828213e-01f, -3.91745001e-01f, -2.13132173e-01f, 1.33945197e-01f, -4.10607129e-01f,
  -1.62166394e-02f, -3.35263401e-01f, -2.56256163e-01f, -1.01949535e-01f, -2.86540419e-01f, 2.58368373e-01f, -1.16900057e-01f, -2.56573021e-01f, 7.51603162e-03f, -4.70494628e-01f,
  1.16453528e-01f, -1.18520327e-01f, 2.03264117e-01f, -3.06862950e-01f, 2.34379560e-01f, -2.60975420e-01f, -4.98591870e-01f, -4.06296194e-01f, -2.36631066e-01f, 1.39319271e-01f,
  -1.68105960e-01f, 1.78726867e-03f, 1.99450761e-01f, -9.11450014e-02f, -4.47295666e-01f, -1.58061117e-01f, -1.53019309e-01f, -1.29688438e-02f, -1.31865233e-01f, 4.25644815e-01f,
  -6.89985871e-01f, 9.07575265e-02f, 2.43360177e-01f, 1.06574066e-01f, -3.19331765e-01f, -1.80700034e-01f, -1.53197676e-01f, 5.24865150e-01f, 3.27427626e-01f, -9.97781679e-02f,
  -3.16773355e-01f, -1.92585438e-01f, -1.67469643e-02f, 2.63453513e-01f, -1.18219271e-01f, 3.26922894e-01f, -9.85491127e-02f, -2.52253354e-01f, -9.79447067e-02f, -5.06442599e-02f,
  -4.95202616e-02f, -1.32445097e-01f, -1.25314161e-01f, -3.25657874e-02f, -1.63843036e-01f, -3.94923389e-02f, -1.79584503e-01f, -1.36899516e-01f, -2.53118753e-01f, 2.39832595e-01f,
  -4.05680351e-02f, 2.33764857e-01f, 1.53504521e-01f, 5.68079501e-02f, 9.54025239e-02f, 3.83259580e-02f, -2.82966226e-01f, -1.31228313e-01f, 9.11058411e-02f, -1.09651603e-01f,
  -3.72089237e-01f, 1.27536848e-01f, 1.91258326e-01f, -1.88083753e-01f, -8.26814473e-02f, 3.01461607e-01f, 3.43798608e-01f, 3.15996379e-01f, -2.07606137e-01f, -2.63956845e-01f,
  5.14846900e-03f, 2.41104424e-01f, 2.01988235e-01f, -1.50625333e-01f, 6.72646835e-02f, 4.28280920e-01f, -1.96900353e-01f, -2.16117978e-01f, -3.00917327e-01f, 3.54259372e-01f,
  -3.29995424e-01f, -1.38700321e-01f, -2.76784122e-01f, -2.52966523e-01f, -3.28395635e-01f, -2.44335055e-01f, -6.71338588e-02f, -5.02272770e-02f, 3.27527583e-01f, -1.44979686e-01f,
  -2.00932361e-02f, 1.79626390e-01f, -9.05608088e-02f, -2.09115922e-01f, 3.80302787e-01f, -1.49583258e-02f, -1.89405635e-01f, -3.13735783e-01f, -2.46923611e-01f, -4.25465137e-01f,
  -1.83274791e-01f, -1.35948494e-01f, -2.45117173e-01f, 2.82540113e-01f, -3.50894362e-01f, -1.84050694e-01f, -1.03865482e-01f, -2.44830862e-01f, 2.38741085e-01f, 1.31148323e-01f,
  2.38317966e-01f, -1.83535382e-01f, -7.59673268e-02f, -1.58367634e-01f, 4.21116233e-01f, -1.15934707e-01f, -2.45039254e-01f, -3.43514495e-02f, -3.56949270e-01f, -2.05692858e-01f,
  -9.94190052e-02f, -3.71851802e-01f, -1.07184269e-01f, -5.32091185e-02f, -6.10021390e-02f, 2.56494552e-01f, -6.21033423e-02f, -1.49658620e-01f, -1.81569576e-01f, -1.91506565e-01f,
  -2.73321033e-01f, 3.26221436e-02f, 3.04592609e-01f, -4.16466519e-02f, 1.16117753e-01f, -2.94218753e-02f, 2.09527090e-01f, -3.51343781e-01f, -1.62634820e-01f, -1.30203113e-01f,
  -3.38976495e-02f, -1.43753216e-01f, -3.98399010e-02f, -2.34177247e-01f, -2.43383478e-02f, -1.23142704e-01f, -1.37421548e-01f, -3.50023776e-01f, -8.11365768e-02f, -1.03615075e-02f,
  3.20645750e-01f, -9.90057364e-02f, 1.23296916e-01f, -1.87226161e-01f, -1.01050556e-01f, -3.22259367e-01f, 1.91408649e-01f, -1.41415969e-01f, -1.47915423e-01f, -1.27650155e-02f,
  -1.05242886e-01f, 3.26583743e-01f, -1.75792709e-01f, 2.33242095e-01f, -2.10187256e-01f, -3.87001187e-02f, -3.39613110e-01f, 2.35330146e-02f, -6.67277575e-02f, -2.76086718e-01f,
  -1.35667861e-01f, 1.93523895e-02f, -1.31406412e-02f, -2.09662095e-01f, -2.61184990e-01f, -2.59207100e-01f, 1.26644433e-01f, -1.29385322e-01f, -1.08066864e-01f, -9.47274268e-02f,
  2.12108538e-01f, -1.69431850e-01f, -1.39370590e-01f, -6.11507939e-03f, 2.22966537e-01f, 5.17511033e-02f, -2.06885725e-01f, 6.56135380e-02f, -9.31535512e-02f, -9.44479257e-02f,
  -3.99140686e-01f, -3.10955971e-01f, -1.79080680e-01f, -7.44003952e-02f, -2.58623004e-01f, -1.62524864e-01f, 2.46802002e-01f, -2.59964556e-01f, -1.80590868e-01f, -1.41416296e-01f,
  2.31697530e-01f, -1.29146531e-01f, -1.88747227e-01f, 1.05713204e-01f, 2.77013600e-01f, 9.00494084e-02f, -1.65313944e-01f, -2.30952784e-01f, -2.13018000e-01f, -3.45980972e-01f,
  -3.34939867e-01f, -2.67084241e-01f, -1.85246602e-01f, -4.52838354e-02f, -3.59776527e-01f, -2.65500277e-01f, -4.76217121e-02f, 4.17174339e-01f, 3.90049219e-01f, -4.24727589e-01f,
  -1.28835857e-01f, 1.76093116e-01f, -1.47664085e-01f, 9.54281632e-03f, -1.87197492e-01f, -3.75468820e-01f, -3.46000642e-02f, 3.07218451e-02f, -6.44356757e-02f, -8.69111568e-02f,
  -1.33834839e-01f, -2.60429442e-01f, 3.50710362e-01f, 2.75088847e-01f, -2.05799550e-01f, -1.69816107e-01f, -1.84404761e-01f, -1.54561952e-01f, 1.04444563e-01f, -2.45323181e-01f,
  4.24385279e-01f, 4.44000483e-01f, -3.91632140e-01f, 2.29571223e-01f, -1.55899391e-01f, -1.23361193e-01f, -2.47854277e-01f, 3.68560940e-01f, -2.08125234e-01f, 2.03265995e-01f,
  2.10581392e-01f, -1.65250808e-01f, -1.44856378e-01f, 1.93334356e-01f, 2.42950901e-01f, -1.01103932e-01f, -3.27651858e-01f, -2.69925505e-01f, -1.69470295e-01f, 2.94863492e-01f,
  -1.25604853e-01f, 1.91791981e-01f, -1.12803720e-01f, -9.74858180e-02f, -6.82253018e-02f, 2.02242225e-01f, 4.26532865e-01f, -1.76100925e-01f, 7.95136243e-02f, 2.97057778e-01f,
  1.85424745e-01f, -2.38066718e-01f, -1.66227281e-01f, 4.84945700e-02f, 2.89076239e-01f, 6.34505078e-02f, -4.24344361e-01f, 3.73188585e-01f, -1.07586473e-01f, 2.57740784e-02f,
  3.35919857e-01f, 3.04929733e-01f, -1.52081057e-01f, -2.06413671e-01f, -1.51527733e-01f, 4.15483743e-01f, 2.14885697e-01f, 3.95996779e-01f, 2.31310371e-02f, -4.75928247e-01f,
  -3.24709058e-01f, -1.73974752e-01f, 2.21601576e-01f, 1.42414361e-01f, -4.43779752e-02f, 2.32111067e-02f, -7.50249699e-02f, 2.75181651e-01f, -3.76437977e-02f, 7.59870708e-02f,
  -1.61364973e-01f, 1.00457922e-01f, 2.72730023e-01f, 1.52869299e-01f, -9.43582803e-02f, -4.45274897e-02f, -1.50142327e-01f, 3.79928797e-01f, -3.43450397e-01f, -1.60060748e-01f,
  -3.22268963e-01f, -2.08658934e-01f, -1.37481764e-01f, 3.28680962e-01f, -4.11810905e-01f, 2.97376096e-01f, 2.05583379e-01f, -4.90833014e-01f, -2.07488686e-01f, -1.38291255e-01f,
  -4.10492718e-01f, 1.77507848e-01f, -2.70928502e-01f, 1.53761864e-01f, 4.43944186e-01f, -1.14489712e-01f, 3.16403538e-01f, -3.30648124e-02f, -2.37468302e-01f, -2.72894025e-01f,
  -7.23008886e-02f, -1.51326358e-01f, -2.77302444e-01f, 3.20244730e-01f, -1.75464824e-01f, 4.27118421e-01f, 1.75884530e-01f, 4.97262090e-01f, 3.27328652e-01f, 2.84939647e-01f,
  -1.68224946e-01f, 1.49043873e-01f, 2.85207808e-01f, -2.20483303e-01f, 4.03847337e-01f, -4.42599684e-01f, 5.83397329e-01f, -1.61062013e-02f, -1.15877181e-01f, 1.06356658e-01f,
  -1.75829738e-01f, -1.09071314e-01f, 3.18758607e-01f, -8.49000812e-02f, -2.24456415e-01f, -2.76500046e-01f, 1.22505665e-01f, -2.28933424e-01f, 1.05732670e-02f, -1.13597862e-01f,
  -1.66258276e-01f, 4.21947777e-01f, -1.52974129e-01f, 1.61054149e-01f, -2.09167764e-01f, -2.13493839e-01f, 2.01711506e-01f, -3.90739560e-01f, 8.71394277e-02f, -5.19909203e-01f,
  -7.25150406e-02f, 9.55714285e-02f, -5.40429056e-02f, 1.57435209e-01f, -1.68112636e-01f, 3.63334686e-01f, 9.44936723e-02f, -4.06232849e-02f, 1.92049816e-01f, -9.78095606e-02f,
  -4.50944811e-01f, 1.85756698e-01f, 3.30604374e-01f, 3.20072412e-01f, -4.24608201e-01f, 1.57066017e-01f, -8.67594220e-03f, 1.11682117e-01f, -2.00118348e-01f, 1.74203619e-01f,
  -1.07096829e-01f, -1.29409477e-01f, -3.40554208e-01f, -1.78271800e-01f, -1.50559098e-01f, -3.60759616e-01f, -3.04764509e-01f, -4.23583567e-01f, -3.23702872e-01f, 1.49036810e-01f,
  -1.05502881e-01f, 3.83692443e-01f, -1.81458503e-01f, -1.68813005e-01f, 2.33345389e-01f, 7.62760490e-02f, -3.63863736e-01f, 3.13130468e-01f, 1.97010726e-01f, -3.44739407e-01f,
  8.91762748e-02f, 3.69321942e-01f, 5.74437305e-02f, -1.58704594e-01f, -8.46321285e-02f, -2.03892916e-01f, -3.12056877e-02f, 8.05870891e-02f, -2.50733525e-01f, -2.91613549e-01f,
  5.76907806e-02f, -2.51012808e-03f, 1.12975657e-01f, 2.23663241e-01f, 2.13617593e-01f, 1.98921611e-04f, 5.45843728e-02f, 2.21906468e-01f, 2.47405749e-03f, 1.87490970e-01f,
  -7.54143065e-03f, 2.32112408e-01f, -2.47040719e-01f, -2.92312503e-01f, 2.13404715e-01f, 1.94821328e-01f, 2.34711245e-01f, 8.95023271e-02f, 1.10099487e-01f, -4.09568638e-01f,
  2.46252194e-01f, -1.32783026e-01f, 4.09605473e-01f, 2.69679874e-02f, 6.64394125e-02f, 1.66297406e-01f, -1.08134218e-01f, 3.40226322e-01f, 2.35604346e-01f, -2.78510630e-01f,
  -4.98220772e-01f, -3.30427170e-01f, -2.39116922e-01f, 4.21485394e-01f, 1.75205454e-01f, -1.37063503e-01f, 1.60850286e-01f, -4.45187002e-01f, 1.26079068e-01f, -4.04489070e-01f,
  -3.13259482e-01f, 1.05239399e-01f, -1.53921135e-02f, -1.55262100e-02f, -2.36494124e-01f, -8.42627957e-02f, 2.73428440e-01f, 4.22313511e-01f, -1.27889633e-01f, -1.03601180e-01f,
  -2.23793790e-01f, 2.25673392e-01f, -1.55066237e-01f, 2.99495086e-02f, -4.14340764e-01f, -2.30991825e-01f, 3.14800620e-01f, -2.49621734e-01f, -1.02333590e-01f, 3.06026876e-01f,
  3.17871571e-01f, 1.61790419e-02f, 3.18388969e-01f, 2.48786807e-01f, 7.88207948e-02f, -1.63168013e-01f, 3.41032408e-02f, -4.43338871e-01f, 3.98725629e-01f, 1.12929948e-01f,
  3.78084987e-01f, 5.35648838e-02f, -1.78914040e-01f, -2.12041929e-01f, 5.84533922e-02f, 1.50643334e-01f, 1.96826562e-01f, -2.25569569e-02f, -1.29881248e-01f, -2.54826069e-01f,
  -2.83301651e-01f, -7.49431923e-02f, 1.13473171e-02f, -3.91519576e-01f, -1.59938708e-01f, -3.78529459e-01f, 2.44118161e-02f, 1.09410331e-01f, 1.52330205e-01f, -3.27278674e-01f,
  -3.35462898e-01f, -8.16726089e-02f, 2.16186121e-01f, 2.49011844e-01f, -3.87351364e-02f, -4.65434670e-01f, -9.48997736e-02f, -2.96047032e-01f, 2.44362742e-01f, -7.36704320e-02f,
  -2.63697296e-01f, -1.21810526e-01f, 3.69022369e-01f, 1.83903188e-01f, 3.21014911e-01f, -2.15513393e-01f, -1.35385022e-01f, 1.75070241e-01f, -8.35712347e-03f, -2.94785589e-01f,
  -2.55339026e-01f, -1.54860422e-01f, 9.82983783e-02f, 2.85134554e-01f, -3.03179443e-01f, -2.22883090e-01f, -6.43860772e-02f, -2.92516053e-01f, 3.80980581e-01f, -2.72883803e-01f,
  -3.15481752e-01f, 8.53203088e-02f, 1.08607948e-01f, -3.67063463e-01f, 5.33794463e-02f, -3.42231512e-01f, 6.78154677e-02f, 1.52887896e-01f, -4.47083078e-02f, -1.65585172e-03f,
  -3.53812389e-02f, -1.63955450e-01f, 1.45074025e-01f, -1.19822711e-01f, -5.54993227e-02f, -1.56238288e-01f, -6.41768128e-02f, -1.02293745e-01f, 7.40599493e-03f, -2.08437249e-01f,
  4.74080071e-02f, 3.84418696e-01f, 8.86446387e-02f, 2.20509529e-01f, 2.32948735e-02f, -5.38656712e-02f, 1.25760764e-01f, -2.03910530e-01f, -1.47571996e-01f, -1.89612895e-01f,
  -1.46441042e-01f, -1.31921351e-01f, 1.13144912e-01f, 1.36108056e-01f, -8.80270824e-02f, 6.19687997e-02f, 1.30280867e-01f, 3.40580821e-01f, -2.44776562e-01f, -3.06804180e-01f,
  -2.76641279e-01f, -1.23593420e-01f, -3.91594797e-01f, -1.19841546e-01f, -4.34713453e-01f, 3.68838936e-01f, 2.85009027e-01f, 3.08763355e-01f, 3.75101447e-01f, -5.24963200e-01f,
  1.33081824e-01f, -3.64951581e-01f, 2.84924597e-01f, -1.90400198e-01f, 1.97979584e-01f, -3.69413465e-01f, -2.09863842e-01f, -1.42795414e-01f, -1.81697663e-02f, -5.60989901e-02f,
  1.74805462e-01f, -9.69873816e-02f, -1.74504355e-01f, -1.93729565e-01f, 3.72495800e-01f, -7.35561252e-02f, -4.80894208e-01f, 1.54400701e-02f, -3.50086838e-01f, -4.70316187e-02f,
  -1.43353581e-01f, 3.24205726e-01f, 1.35332033e-01f, 4.30142641e-01f, 2.07886249e-02f, 3.90520334e-01f, -4.86644298e-01f, 2.16705650e-02f, -2.64819443e-01f, -3.51045907e-01f,
  -2.25814909e-01f, 4.14929360e-01f, 1.23614199e-01f, 7.20307305e-02f, -3.00237149e-01f, -5.72449667e-03f, -3.28213990e-01f, 3.52632046e-01f, -1.40221730e-01f, -9.67715010e-02f,
  2.39809319e-01f, -2.46937886e-01f, -1.69630468e-01f, -1.84295088e-01f, -3.83601636e-01f, 3.79634589e-01f, 4.08110380e-01f, 2.23129839e-01f, -3.51253629e-01f, -1.08511344e-01f,
  -2.18975142e-01f, -2.11931273e-01f, -2.04955876e-01f, -2.81236023e-01f, -3.17582041e-01f, -4.39024754e-02f, 1.16747051e-01f, 8.89387131e-02f, 3.34872901e-01f, 9.05968919e-02f,
  2.40104675e-01f, -3.17607731e-01f, -2.92381179e-02f, 3.60539481e-02f, 4.27294493e-01f, 2.69731879e-01f, -3.79873157e-01f, -4.26666826e-01f, -1.22583769e-01f, -2.68237919e-01f,
  -3.34772408e-01f, -3.94879133e-01f, 2.61202216e-01f, 1.20995998e-01f, -2.26056501e-01f, -1.31648034e-01f, 2.90647268e-01f, -1.32811144e-01f, -3.60329062e-01f, -3.39108407e-02f,
  -2.42432550e-01f, -2.12906078e-01f, -4.66539115e-01f, -2.37904385e-01f, 3.50145936e-01f, -9.07017440e-02f, -4.55633402e-02f, -1.61180913e-01f, -1.18369997e-01f, -5.13452478e-02f,
  -6.26537204e-02f, -2.11886674e-01f, -1.82996273e-01f, -2.03871310e-01f, -3.09135243e-02f, -9.82825235e-02f, -1.61431476e-01f, -2.10824221e-01f, -4.18420956e-02f, -6.34566396e-02f,
  -2.07159489e-01f, -1.09464474e-01f, -5.26007339e-02f, -2.21185721e-02f, 5.08147255e-02f, -1.86269939e-01f, 1.93207972e-02f, 1.14947572e-01f, -5.16279265e-02f, 1.57091454e-01f,
  4.41453345e-02f, -1.63630709e-01f, 9.61014256e-02f, 1.93932772e-01f, -3.01332235e-01f, -5.76776974e-02f, -6.91002682e-02f, 8.16016123e-02f, 5.83287403e-02f, -1.84343740e-01f,
  1.55511215e-01f, -2.58265585e-01f, 4.71296944e-02f, 3.05222690e-01f, 1.44943208e-01f, 2.21535377e-02f, -3.18673998e-01f, -2.24952415e-01f, 2.46958751e-02f, -1.34463578e-01f,
  8.58519971e-03f, 1.22411124e-01f, -6.26029149e-02f, -3.42457630e-02f, -1.52113736e-01f, 2.31715009e-01f, 3.22551876e-01f, -2.67062873e-01f, -1.43550977e-01f, -2.19768420e-01f,
  -1.54849946e-01f, -4.03683111e-02f, 7.78460652e-02f, -6.06021620e-02f, -2.69897841e-02f, 3.69850457e-01f, -1.89751923e-01f, 3.37033793e-02f, 2.65404046e-01f, -5.31332195e-02f,
  4.17907566e-01f, -1.78555831e-01f, -1.82221085e-01f, 2.24446177e-01f, -2.21428841e-01f, 9.56755131e-02f, -1.04489408e-01f, -6.04353435e-02f, -1.42910287e-01f, -1.46487340e-01f,
  -2.03492761e-01f, 6.65104017e-02f, 1.71532750e-01f, 1.28219277e-01f, 1.44082457e-01f, -1.99231774e-01f, 2.77887940e-01f, -1.33646369e-01f, -1.83703214e-01f, -1.50195315e-01f,
  -6.30102903e-02f, -1.95421055e-01f, 4.85414773e-01f, -2.37249076e-01f, -3.71737815e-02f, 2.54994333e-01f, -2.05995366e-01f, -1.62493810e-01f, 2.38668680e-01f, -1.88898742e-01f,
  -3.82359713e-01f, -2.74686575e-01f, 1.74842909e-01f, -1.02829434e-01f, -9.85128284e-02f, -1.85418117e-03f, -2.88711250e-01f, 1.25720903e-01f, -5.43088503e-02f, 2.20167730e-02f,
  2.26580605e-01f, 2.68083304e-01f, -1.50915638e-01f, 2.36674666e-01f, -4.30239625e-02f, -1.38378546e-01f, -1.77213177e-01f, -1.68918058e-01f, 2.30336696e-01f, -1.64861441e-01f,
  -2.38071129e-01f, -5.66845462e-02f, 1.32168218e-01f, 3.67864132e-01f, -5.78186028e-02f, -2.33047798e-01f, -5.88263609e-02f, 2.63570964e-01f, 2.49371022e-01f, 4.21476550e-02f,
  -1.30433068e-01f, -1.47028223e-01f, -1.36645928e-01f, -1.87996894e-01f, -1.67662308e-01f, -7.91866109e-02f, -1.52289301e-01f, -8.86200219e-02f, -7.95470625e-02f, -7.19474703e-02f,
  -2.23748401e-01f, -5.00906631e-02f, -7.30162635e-02f, -2.76188310e-02f, -3.99556458e-02f, 7.68227279e-02f, 2.88702160e-01f, 2.42127568e-01f, 1.96026713e-01f, -1.14920452e-01f,
  4.60513309e-03f, 8.08833763e-02f, 2.03138024e-01f, -1.99102834e-01f, -1.45900503e-01f, 2.13511199e-01f, 1.13527946e-01f, 1.12247340e-01f, -3.55517566e-01f, -2.22852871e-01f,
  -1.93882719e-01f, -3.38665769e-02f, -1.40196055e-01f, -2.79767066e-01f, -3.22866112e-01f, 3.61260533e-01f, -1.11303620e-01f, 2.40934536e-01f, -1.53105170e-01f, 1.70375392e-01f,
  4.32521492e-01f, -1.17816769e-01f, 3.69692177e-01f, -6.88539818e-02f, -1.92600757e-01f, -1.71524629e-01f, 3.61260265e-01f, -2.22675055e-01f, -1.65190417e-02f, 4.00168896e-01f,
  -5.29379174e-02f, -1.57351688e-01f, -1.52034849e-01f, 2.01159269e-01f, -9.84307006e-02f, -1.58302873e-01f, -3.16640548e-02f, 1.00280903e-02f, -7.06202686e-02f, -2.53786277e-02f,
  -1.81868762e-01f, 3.07623930e-02f, 9.85358357e-02f, -1.39089555e-01f, -1.67944640e-01f, 3.39615941e-01f, 2.95300642e-03f, 1.64504036e-01f, -1.49528384e-01f, -1.59029886e-01f,
  -6.77756146e-02f, -7.09663332e-02f, -1.29602402e-01f, -1.42385632e-01f, 2.31803462e-01f, 1.66166294e-02f, -1.44484073e-01f, -6.31762445e-02f, -3.33232641e-01f, -1.15609348e-01f,
  -1.69760153e-01f, 4.62851897e-02f, 3.64638567e-02f, -1.17650002e-01f, -1.92992344e-01f, -6.37988746e-02f, -2.55707204e-01f, -5.66453449e-02f, 3.62797767e-01f, 4.77062225e-01f,
  -4.77458872e-02f, -6.23628683e-02f, -2.27369174e-01f, -1.63172036e-01f, -1.50191709e-01f, 5.02746627e-02f, -9.72988009e-02f, -1.59537584e-01f, 1.09962828e-01f, -1.81200922e-01f,
  -1.63670048e-01f, -1.80311307e-01f, 1.56646565e-01f, 4.52040464e-01f, 1.10559613e-01f, -1.26191705e-01f, -1.11797869e-01f, -8.88478681e-02f, -2.38577500e-01f, -2.40955785e-01f,
  3.49942088e-01f, -8.93531516e-02f, -9.00324956e-02f, -1.65275201e-01f, -7.82352686e-02f, -1.57258600e-01f, -1.13127112e-01f, -1.12087071e-01f, -3.32681507e-01f, -3.08476359e-01f,
  -2.01717764e-01f, -1.29670203e-01f, -2.31439367e-01f, -1.24076143e-01f, 3.32999825e-01f, -1.50825962e-01f, -1.50539488e-01f, -1.18929535e-01f, 3.41957510e-01f, -2.06821859e-01f,
  -2.68052876e-01f, 2.64041066e-01f, -1.44310847e-01f, -1.26050767e-02f, 1.49173096e-01f, -5.79232723e-02f, -2.13607445e-01f, -4.76731136e-02f, 9.11909491e-02f, -1.13497533e-01f,
  1.36257038e-01f, -2.25483943e-02f, 1.09661803e-01f, 1.41119361e-01f, -2.85112053e-01f, -3.80758554e-01f, 1.86130181e-01f, 1.58356294e-01f, -3.38364810e-01f, 2.90212452e-01f,
  2.01702252e-01f, -1.48344338e-01f, -5.39208092e-02f, -2.91297346e-01f, -1.99265294e-02f, -1.95017651e-01f, 1.56841233e-01f, -4.03874964e-01f, -9.65473519e-05f, -2.14771509e-01f,
  -2.67044812e-01f, 2.03384422e-02f, 3.80396619e-02f, -3.73042196e-01f, 3.71803641e-01f, -1.71199784e-01f, -1.52879059e-01f, -1.80459574e-01f, -1.01359263e-02f, 2.73294270e-01f,
  -5.93639791e-01f, -2.31385186e-01f, -2.15873584e-01f, 1.67276964e-01f, -4.16787207e-01f, 2.11797524e-02f, 3.04869682e-01f, 7.83507451e-02f, -2.05732033e-01f, -1.99623123e-01f,
  3.28568578e-01f, -3.32822770e-01f, 3.08137447e-01f, -9.37320665e-02f, 4.11059558e-02f, -2.08507940e-01f, -1.84452683e-01f, -1.75053895e-01f, 1.06646441e-01f, -3.30727279e-01f,
  3.94350588e-01f, 4.29841364e-03f, 2.20687762e-01f, -2.56063730e-01f, -6.70929030e-02f, -2.79010326e-01f, 1.28914043e-01f, 3.83852631e-01f, 4.21816468e-01f, 2.54034549e-01f,
  -2.34994665e-01f, -4.58380908e-01f, -1.54638514e-01f, -1.02744557e-01f, 8.71601477e-02f, -2.76839644e-01f, -3.94721776e-01f, -6.70960248e-02f, -3.21946919e-01f, -4.16804478e-02f,
  1.23835132e-01f, -1.43133014e-01f, 4.29117739e-01f, 5.57966888e-01f, 2.56019205e-01f, -2.37386107e-01f, 3.85399640e-01f, -2.22503066e-01f, -3.46341193e-01f, 1.35795921e-02f,
  1.68609515e-01f, 8.63724574e-03f, -2.11391911e-01f, -1.48251951e-01f, 2.45231658e-01f, -1.25234991e-01f, -1.87895000e-01f, -1.87809154e-01f, 1.29631862e-01f, -2.60978132e-01f,
  2.85400569e-01f, -1.85991079e-01f, -3.22169095e-01f, 1.10012561e-01f, -5.30530401e-02f, -8.00579861e-02f, -3.29515904e-01f, -2.33396441e-01f, -1.32388800e-01f, -2.67035663e-01f,
  5.12032866e-01f, 2.27886453e-01f, 2.58658137e-02f, -3.05202663e-01f, 3.46070766e-01f, -2.31315285e-01f, 2.65306473e-01f, 1.58115655e-01f, -1.90655857e-01f, 8.24315380e-03f,
  -2.19205424e-01f, -2.60375232e-01f, -2.71389842e-01f, -3.92484367e-01f, 2.27853339e-02f, -1.00139007e-01f, -2.56550342e-01f, -2.03147069e-01f, -3.36537808e-01f, -4.14637148e-01f,
  3.09844501e-03f, 1.20521836e-01f, 2.59699404e-01f, 1.16042480e-01f, 1.11025937e-01f, 1.56158969e-01f, 3.01232934e-03f, -1.81505661e-02f, 8.45198855e-02f, 8.26611593e-02f,
  1.47755265e-01f, 1.41164109e-01f, 2.41982892e-01f, -5.17556779e-02f, -1.57483891e-02f, -1.81886896e-01f, -1.62277564e-01f, -3.44046921e-01f, -2.96580166e-01f, 2.95806319e-01f,
  1.46762833e-01f, 6.76490515e-02f, -1.66650284e-02f, 1.34754166e-01f, 4.97355200e-02f, -1.88983694e-01f, 4.83651876e-01f, 1.56691194e-01f, -9.29933786e-02f, -1.95084900e-01f,
  -3.05647030e-02f, -3.02517623e-01f, -1.42197490e-01f, -1.01849668e-01f, 7.97394216e-02f, -3.41046333e-01f, -4.42590684e-01f, -1.25414297e-01f, -1.06067516e-01f, -1.71379238e-01f,
  2.72635490e-01f, -2.27248609e-01f, 1.98304281e-02f, -7.84363076e-02f, -2.45357633e-01f, 1.13249840e-02f, -1.07483007e-01f, -1.22462381e-02f, 2.26012662e-01f, 3.19648534e-01f,
  -1.41554326e-01f, -1.58379391e-01f, -2.73112804e-01f, 3.69483322e-01f, -5.95809184e-02f, 4.74737614e-01f, 2.93800589e-02f, 4.59997475e-01f, -6.10904805e-02f, -1.87161088e-01f,
  2.01361164e-01f, 2.79471904e-01f, -6.94211274e-02f, -2.12722600e-01f, -1.33454144e-01f, -2.09985569e-01f, -6.60456270e-02f, -1.36708900e-01f, 5.62303215e-02f, -6.58759922e-02f,
  -1.66673392e-01f, 1.97876915e-01f, 4.81077820e-01f, -8.97056088e-02f, 1.17796712e-01f, -4.68937941e-02f, -2.06931949e-01f, 3.72446775e-01f, 3.61832350e-01f, -4.07265693e-01f,
  -7.43422285e-02f, -6.95010424e-02f, -2.02721991e-02f, -2.01471925e-01f, -1.03986133e-02f, -2.02467993e-01f, -3.23585272e-01f, -2.01539710e-01f, -8.80464315e-02f, -2.60049194e-01f,
  -1.11377254e-01f, -1.77216813e-01f, -4.61626686e-02f, -1.59556344e-01f, 5.98497167e-02f, -8.09598789e-02f, 7.43388906e-02f, 4.05832499e-01f, -1.39241889e-01f, 3.10091078e-01f,
  4.69511986e-01f, -4.11584496e-01f, -3.24470431e-01f, -9.42407772e-02f, -6.98743910e-02f, 3.94734055e-01f, -3.62375498e-01f, -8.27181190e-02f, -8.13748762e-02f, -3.27271044e-01f,
  1.81556135e-01f, -1.90231457e-01f, -2.15390295e-01f, -9.84308645e-02f, -2.94001609e-01f, -3.23078126e-01f, -3.99933070e-01f, -1.94184124e-01f, 1.22403288e-02f, -1.02420576e-01f,
  -1.53414890e-01f, -2.77861148e-01f, 2.23387927e-02f, 1.09655261e-01f, -1.60181776e-01f, 4.84636754e-01f, -2.53411889e-01f, -1.47316262e-01f, 3.21938237e-03f, 6.05021492e-02f,
  1.27299488e-01f, 2.30350774e-02f, -5.68603352e-02f, 8.96276385e-02f, 9.13562626e-02f, 1.05818167e-01f, 5.81176057e-02f, -1.30691424e-01f, 7.43271131e-03f, 3.95072885e-02f,
  -1.99726820e-01f, 1.57324448e-01f, -1.53676033e-01f, -1.40085295e-01f, 9.44395065e-02f, 1.31388873e-01f, 2.15772450e-01f, 2.19195426e-01f, -1.84592034e-03f, 3.13267201e-01f,
  -1.57104984e-01f, 1.38408393e-01f, -2.06284687e-01f, -3.10452282e-01f, 3.00086886e-01f, 2.05327988e-01f, -2.60307074e-01f, 8.93749017e-03f, -9.71659422e-02f, -2.54666328e-01f,
  5.66775128e-02f, 1.71190023e-01f, 8.81325379e-02f, 2.67761230e-01f, -1.48048490e-01f, -1.83747187e-01f, 1.81760699e-01f, -1.93790451e-01f, 3.66208673e-01f, -2.08912045e-01f,
  4.25062478e-01f, -2.36307368e-01f, 2.32384458e-01f, -3.65447730e-01f, 1.94367930e-01f, -1.43859521e-01f, -1.58177420e-01f, -7.20831677e-02f, -2.26759359e-01f, 9.44377407e-02f,
  -1.63477078e-01f, -2.80382723e-01f, -2.62322336e-01f, 2.08458211e-02f, -1.45679675e-02f, -2.15721071e-01f, -7.82022998e-02f, 1.22041181e-01f, -2.46736463e-02f, 7.40889907e-02f,
  -2.03684315e-01f, -2.70786822e-01f, -1.61376204e-02f, -5.28425388e-02f, 1.96516812e-01f, -1.91402107e-01f, -1.88181803e-01f, -1.71256244e-01f, 1.46237060e-01f, -2.19338357e-01f,
  -1.92445517e-01f, -2.05280349e-01f, -1.94281533e-01f, -1.33907080e-01f, -3.16177696e-01f, -1.92411736e-01f, 7.64237344e-03f, 4.57573652e-01f, -1.45977706e-01f, -6.87017068e-02f,
  3.52259755e-01f, -9.39032137e-02f, -1.49557263e-01f, 3.80677044e-01f, 2.76797950e-01f, 1.89092740e-01f, -1.46329314e-01f, -1.77353397e-01f, 4.19355273e-01f, 4.24116105e-02f,
  -2.33430535e-01f, 1.07774893e-02f, -1.53884783e-01f, 3.68166566e-01f, -1.87942564e-01f, 1.65593103e-01f, -1.23459630e-01f, -1.40997797e-01f, -3.28420341e-01f, -1.75260484e-01f,
  1.79826224e-03f, 4.43305641e-01f, -1.76712885e-01f, -1.79056525e-01f, 8.39668140e-02f, -6.41726376e-03f, -1.21954225e-01f, -1.46753043e-01f, -1.57210335e-01f, -1.03014089e-01f,
  -2.66507775e-01f, 1.26292571e-01f, -1.55526936e-01f, -1.53992549e-01f, 1.39626592e-01f, 2.30706051e-01f, -1.15113653e-01f, -2.84808546e-01f, -2.23416135e-01f, -2.02670574e-01f,
  2.46954381e-01f, 3.61760527e-01f, 3.35184783e-01f, -1.59475535e-01f, 5.65666854e-01f, -2.07201257e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -8.97264108e-02f, 2.06400156e-02f, -2.90598497e-02f, -5.06220236e-02f, 9.66094434e-02f, 5.50376847e-02f, -5.01574911e-02f, -3.62402387e-02f, 2.87807602e-02f, -3.83658451e-03f,
  4.96286415e-02f, 6.67700451e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    