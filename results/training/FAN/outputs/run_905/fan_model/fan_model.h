/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.04283415e-01f, 9.67093408e-02f, 1.42236993e-01f, 7.21583003e-03f, 5.00833355e-02f, 1.31314039e-01f, 2.16507897e-01f, -3.71506996e-02f, -5.30435778e-02f, 4.16662283e-02f,
  3.02061010e-02f, -1.41601369e-01f, -1.29461549e-02f, -3.52732576e-02f, -6.14858344e-02f, 6.03036545e-02f, 1.56523921e-02f, -3.34026068e-02f, 4.41061854e-02f, 9.68873873e-02f,
  -7.00963363e-02f, -2.22864635e-02f, -8.97991210e-02f, -1.62003398e-01f, -9.52503458e-02f, -4.82041873e-02f, -3.19812959e-03f, -1.93955544e-02f, 3.32185067e-02f, 1.28323719e-01f,
  1.06758259e-01f, -3.76524925e-02f, -6.89023659e-02f, 2.20831744e-02f, 3.44636254e-02f, -8.78959298e-02f, 4.99768090e-03f, 7.78134093e-02f, -2.85283476e-02f, 2.06630044e-02f,
  -8.56543630e-02f, 1.86824463e-02f, 1.35248983e-02f, 1.51937129e-02f, 5.93426041e-02f, 7.46157542e-02f, -3.14944834e-02f, -8.99417996e-02f, -4.30072239e-03f, -8.35976657e-03f,
  5.35876825e-02f, -1.18075134e-02f, 1.22138262e-02f, -1.99243855e-02f, -5.05871475e-02f, -3.40885594e-02f, 5.01984023e-02f, 7.64463320e-02f, 9.83543471e-02f, -4.65500541e-02f,
  -1.80671997e-02f, 9.80189890e-02f, 9.72707495e-02f, -6.35337085e-02f, 5.21905124e-02f, 1.27379656e-01f, -6.92649037e-02f, -1.37705375e-02f, 3.41563970e-02f, 3.86881344e-02f,
  -1.99315175e-02f, -7.00446358e-03f, 1.81442723e-02f, -2.24933513e-02f, 7.10904449e-02f, -2.11149976e-02f, -4.02248427e-02f, -1.36573203e-02f, -3.39739732e-02f, 5.63209876e-02f,
  9.52254087e-02f, 4.40788493e-02f, -3.13561857e-02f, -2.10818034e-02f, 4.86927666e-03f, -5.51376417e-02f, 5.07811457e-02f, 5.76878041e-02f, -9.64380726e-02f, 1.72541067e-02f,
  2.11937651e-02f, -4.95572761e-02f, -4.60549034e-02f, 4.32819352e-02f, 3.12368531e-04f, 2.00156830e-02f, -1.27175311e-02f, 6.63485825e-02f, -5.66123836e-02f, -4.34351191e-02f,
  1.88834537e-02f, -3.85778137e-02f, -5.31426491e-03f, 3.64921871e-03f, -2.19713598e-02f, 7.48847723e-02f, -8.66970271e-02f, -5.25315143e-02f, 6.16663545e-02f, -6.05886756e-03f,
  -9.69599932e-04f, -3.21171395e-02f, 7.41620734e-02f, 3.45624499e-02f, -6.69119135e-02f, 4.87618223e-02f, -8.81522521e-03f, 3.30894254e-02f, 4.82714083e-03f, -1.71546247e-02f,
  -1.30788296e-01f, 2.81403303e-01f, 8.18766281e-02f, 1.07807070e-01f, 5.24833873e-02f, -1.82898194e-01f, 7.82943740e-02f, -2.58507915e-02f, -2.91304234e-02f, 1.37392208e-01f,
  1.90253198e-01f, -1.36713848e-01f, -7.19389766e-02f, -1.70560367e-02f, 1.80104654e-02f, 2.71442924e-02f, 6.57941252e-02f, -6.58028126e-02f, -2.98399270e-01f, -7.70784169e-02f,
  -4.18733917e-02f, -4.55304049e-03f, 1.74709588e-01f, -2.74375789e-02f, 5.62051274e-02f, -2.13864192e-01f, -2.67584138e-02f, 1.39308825e-01f, 1.44310966e-01f, 1.22792847e-01f,
  -7.81870559e-02f, 2.12571785e-01f, -6.11779168e-02f, 2.05360707e-02f, -1.35874702e-02f, 3.10148802e-02f, -4.71261553e-02f, -2.06884108e-02f, -2.26432458e-02f, 1.14477791e-01f,
  7.99841583e-02f, 3.71948071e-02f, 4.27302271e-02f, 8.16983208e-02f, 7.79411793e-02f, 7.46212751e-02f, 7.57707655e-02f, 1.69616342e-01f, 2.63014268e-02f, -3.62737291e-02f,
  2.93028448e-02f, 8.11060891e-02f, -2.14280328e-03f, 8.76613930e-02f, 4.99323271e-02f, 9.54099000e-04f, 9.79324728e-02f, 4.08659279e-02f, 4.86017689e-02f, -1.12490483e-01f,
  -4.59719114e-02f, 6.46116585e-02f, -4.65024225e-02f, 9.83363204e-03f, -1.43272176e-01f, 1.32719036e-02f, 5.43889068e-02f, 2.26785373e-02f, 3.51395793e-02f, -6.99411631e-02f,
  1.41693382e-02f, -2.92974245e-02f, -6.21769531e-03f, 9.26496536e-02f, -5.02785146e-02f, 5.65423556e-02f, -1.46908285e-02f, 7.17821196e-02f, 1.82491653e-02f, -3.02533023e-02f,
  -4.16130992e-03f, 7.88873434e-02f, 3.02705541e-02f, -1.76471174e-02f, 3.84260453e-02f, 4.88736704e-02f, -6.35251850e-02f, 2.73887310e-02f, -4.76976894e-02f, 9.45015345e-03f,
  -3.71465534e-01f, 1.72011599e-01f, -3.34695913e-02f, -8.73522162e-02f, 1.30912347e-03f, -3.47395875e-02f, 3.43541764e-02f, 6.23856671e-02f, 2.08501425e-02f, -3.36315623e-03f,
  2.98870783e-02f, -3.99498045e-02f, 2.23988704e-02f, -2.22626776e-02f, -7.92117789e-02f, -2.57487874e-02f, -4.39181216e-02f, -1.38844028e-01f, 6.42738044e-02f, -9.93503034e-02f,
  -7.33073568e-03f, -1.64920598e-01f, -2.16410622e-01f, -4.16196585e-02f, -6.95994049e-02f, -2.68647194e-01f, -1.03518911e-01f, -8.38988125e-02f, -1.89333305e-01f, -3.59202147e-01f,
  -3.85417342e-01f, -2.08003134e-01f, 2.13811234e-01f, -4.32542376e-02f, -2.16607060e-02f, -4.00744155e-02f, -3.82440716e-01f, -2.39271209e-01f, 1.67289469e-02f, -1.18343934e-01f,
  -1.11237019e-01f, -8.43694620e-03f, 4.43832725e-02f, 2.55506001e-02f, -1.97306246e-01f, -4.37242836e-02f, 1.92555726e-01f, 1.95445344e-01f, 7.55795836e-02f, -9.29726288e-02f,
  -7.95586556e-02f, 5.02583794e-02f, 1.91670153e-02f, 2.80562136e-02f, 5.80209829e-02f, 6.88069388e-02f, 3.18125822e-02f, 8.34553093e-02f, -5.97741678e-02f, 2.29562208e-01f,
  1.02359414e-01f, -2.33902573e-03f, -4.54339199e-02f, -4.18115184e-02f, 4.91492748e-02f, -6.65580034e-02f, -5.68280891e-02f, 7.57089555e-02f, -2.87636416e-04f, 3.09425239e-02f,
  1.17159665e-01f, 7.73589835e-02f, 1.05164222e-01f, 4.83903699e-02f, 1.36993185e-01f, 1.37295976e-01f, 5.57024367e-02f, 1.25096917e-01f, 4.17732410e-02f, 8.51014182e-02f,
  4.84950058e-02f, 4.10669968e-02f, -2.89517883e-02f, 9.94112249e-03f, -3.78769003e-02f, 1.69976130e-02f, -1.67969968e-02f, 1.12677012e-02f, -2.85829958e-02f, -6.13855533e-02f,
  -8.26478004e-02f, 1.88365821e-02f, 2.76632532e-02f, -7.47971088e-02f, -5.16889058e-02f, -2.75389031e-02f, 9.95422006e-02f, -3.28366384e-02f, -4.71182726e-03f, -3.95740904e-02f,
  3.93840037e-02f, 3.37445661e-02f, -1.56016927e-02f, 3.81581187e-02f, 2.07511000e-02f, 5.87531440e-02f, -7.98349977e-02f, -7.86439627e-02f, 7.94847831e-02f, 1.66429002e-02f,
  -1.70290738e-03f, 5.73972277e-02f, 6.86083781e-03f, 5.25716804e-02f, 8.30111504e-02f, 1.35399446e-01f, 3.76613103e-02f, -2.30999757e-02f, -4.09048572e-02f, -4.06571738e-02f,
  -2.56278664e-01f, 1.10116348e-01f, -1.17368490e-01f, -5.85560165e-02f, 9.84309427e-03f, 8.21266174e-02f, 4.48896782e-03f, 2.57426091e-02f, 1.13971286e-01f, -1.30866161e-02f,
  -4.37608808e-02f, 2.17027161e-02f, -2.42808070e-02f, 2.48331926e-03f, -6.86390623e-02f, -5.39727733e-02f, -6.88501308e-03f, -8.93426538e-02f, -9.55857150e-03f, 1.07645802e-01f,
  -1.56088665e-01f, -2.11848810e-01f, -2.77784705e-01f, -2.05571502e-01f, 2.45563593e-02f, -2.05487505e-01f, -1.52904555e-01f, -1.47236496e-01f, -2.35012501e-01f, -5.70093513e-01f,
  2.55409986e-01f, 9.51671898e-02f, -2.65789449e-01f, 2.28156343e-01f, -1.62498161e-01f, -2.85537690e-01f, -5.86175084e-01f, 7.74447471e-02f, 2.19709173e-01f, -1.47706822e-01f,
  -1.46616083e-02f, 1.78613424e-01f, 2.14885682e-01f, 1.36848763e-01f, -5.14429435e-02f, -2.13791505e-01f, -1.20670274e-01f, -1.29781011e-02f, 3.51354070e-02f, -4.87222932e-02f,
  8.42442885e-02f, 7.60281458e-02f, 1.73324272e-01f, 9.80498195e-02f, -5.39421216e-02f, 4.54007424e-02f, -2.92162821e-02f, 3.34288962e-02f, -1.21662445e-01f, -1.30489273e-02f,
  -2.77557999e-01f, -4.49657924e-02f, 6.60117567e-02f, 1.14841975e-01f, 8.97577256e-02f, -3.60896997e-02f, -1.83376353e-02f, 9.42350253e-02f, 5.48422709e-02f, 2.36860197e-02f,
  -6.78082416e-03f, 7.44025409e-02f, 2.52232030e-02f, 4.81902957e-02f, -4.31455439e-03f, -8.30780491e-02f, 1.00805074e-01f, 6.00308850e-02f, 2.90077552e-02f, -7.65774176e-02f,
  -7.22792745e-02f, -4.34035771e-02f, -3.73531617e-02f, -1.52375728e-01f, -2.23868154e-02f, 5.56787625e-02f, 2.73234136e-02f, -5.80241531e-02f, 7.57889748e-02f, 5.99515922e-02f,
  -5.69645576e-02f, -3.70146446e-02f, -1.03910290e-01f, 3.12137846e-02f, 5.67694679e-02f, 4.05283831e-02f, 6.07559085e-02f, 2.49706320e-02f, -1.65275726e-02f, -5.31352684e-03f,
  5.56288585e-02f, 3.37115079e-02f, 7.78933987e-02f, -1.35231316e-02f, 1.24106265e-03f, -4.63647390e-04f, -5.48265912e-02f, 6.39301091e-02f, 4.72302288e-02f, -2.80524381e-02f,
  7.73220435e-02f, -4.56245942e-03f, -3.28772217e-02f, -3.58023047e-02f, 1.55783650e-02f, 2.61457171e-02f, -3.86520699e-02f, 3.25726951e-03f, 7.59399533e-02f, 3.53567414e-02f,
  8.09690505e-02f, -7.93399885e-02f, -3.44403349e-02f, 6.19102223e-03f, -3.78810205e-02f, 2.47056279e-02f, -9.76562649e-02f, 1.79783907e-02f, -2.00887099e-02f, 2.98569296e-02f,
  -7.75958374e-02f, -5.14601357e-02f, -4.14201617e-02f, -3.38766002e-03f, -1.61453895e-02f, -1.34209506e-02f, 9.36938543e-03f, 5.73148355e-02f, 4.31152955e-02f, -9.99281108e-02f,
  1.29389107e-01f, 4.63866368e-02f, -3.07748429e-02f, 1.01140685e-01f, 7.79901221e-02f, -6.10404760e-02f, -5.94257563e-02f, 1.08719030e-02f, -4.44245562e-02f, -2.83054374e-02f,
  1.62438869e-01f, -4.60626408e-02f, 6.89650252e-02f, -1.26087546e-01f, -1.20532453e-01f, 2.09522158e-01f, 3.16291749e-01f, 7.57603394e-03f, -2.41524220e-01f, -7.53190741e-02f,
  1.02547659e-02f, -3.70031074e-02f, 8.02783221e-02f, 6.07691146e-02f, 1.85125783e-01f, 1.13362111e-01f, 8.10217708e-02f, 1.83353260e-01f, 8.10235962e-02f, 3.61544476e-03f,
  1.76628903e-02f, 1.19107537e-01f, 7.19722956e-02f, 5.82852215e-02f, -9.60939974e-02f, 2.72776792e-03f, -2.51658615e-02f, 1.04102984e-01f, 1.44663662e-01f, 1.48877141e-03f,
  8.00670311e-02f, 7.27654770e-02f, 8.60005394e-02f, -4.32750136e-02f, 1.52477799e-02f, 1.24989346e-01f, 1.05021395e-01f, -1.44648284e-03f, -7.07060322e-02f, 5.41318543e-02f,
  4.78642918e-02f, -3.82423364e-02f, -4.08509858e-02f, 6.53085113e-02f, -8.29858035e-02f, -5.84747121e-02f, -6.31541684e-02f, 5.47552528e-03f, 2.07068119e-02f, 2.22944445e-03f,
  -6.90452429e-03f, -5.73399439e-02f, 1.34525644e-02f, -2.70814225e-02f, -7.12986141e-02f, 1.36195002e-02f, -1.82997603e-02f, 6.40542656e-02f, 2.21072640e-02f, 2.30727587e-02f,
  -1.97473262e-02f, 9.88184586e-02f, -3.17600695e-03f, -1.22875348e-02f, -2.41597556e-02f, -8.05191994e-02f, 4.99343239e-02f, -4.41517159e-02f, 4.29024510e-02f, -1.08277716e-01f,
  -1.01239912e-01f, -9.07182470e-02f, -9.84345376e-03f, -1.10373028e-01f, 1.29419621e-02f, -3.47844441e-04f, 9.44573805e-02f, -4.92936838e-03f, 5.13005778e-02f, -6.37649447e-02f,
  4.87209111e-03f, -3.58724445e-02f, -9.03398842e-02f, 1.29999686e-02f, -2.40430851e-02f, 2.03210451e-02f, -4.69447710e-02f, -1.68797924e-04f, 3.48984003e-02f, 6.60062432e-02f,
  -2.01392427e-01f, 4.93941717e-02f, 3.57658379e-02f, 8.20195302e-02f, -3.56873460e-02f, -3.57704633e-03f, 4.59216125e-02f, 7.47858286e-02f, 4.69115272e-04f, 1.93906408e-02f,
  -3.27307619e-02f, 1.94688123e-02f, 4.24254388e-02f, 9.69889536e-02f, -2.41125170e-02f, -8.84091109e-02f, -1.40885648e-04f, 2.96858680e-02f, 9.00095925e-02f, -3.19893993e-02f,
  -9.20882002e-02f, 2.27235816e-02f, -1.42869383e-01f, -3.38994451e-02f, 2.68216040e-02f, 3.29787955e-02f, 6.67200163e-02f, 7.32136741e-02f, 1.78009093e-01f, -3.35462019e-02f,
  4.87652570e-02f, 3.50435264e-02f, 7.09962398e-02f, -7.84449838e-03f, -3.36939096e-02f, -5.40460274e-02f, 1.12416081e-01f, 4.62320028e-03f, -9.48549882e-02f, 7.23510683e-02f,
  -7.67278746e-02f, -1.32627845e-01f, -1.02872185e-01f, -2.46700663e-02f, -5.80641218e-02f, 5.62040769e-02f, 1.11839019e-01f, 7.34645948e-02f, 1.34565616e-02f, -1.06080465e-01f,
  5.65538518e-02f, 3.51199396e-02f, -5.75394742e-02f, 1.33392494e-02f, 4.67347987e-02f, -9.66796130e-02f, -1.61812995e-02f, 1.75752938e-02f, -3.47871892e-02f, 2.79040039e-01f,
  -4.96441834e-02f, 1.38491556e-01f, -1.26085626e-02f, 5.31263044e-03f, 1.04797129e-02f, 7.67266303e-02f, 2.58106459e-02f, -3.67938983e-03f, -9.71636698e-02f, -6.63246661e-02f,
  -8.23440999e-02f, -1.21109718e-02f, -5.80977239e-02f, 4.38050516e-02f, -1.96936615e-02f, 5.37749613e-03f, 2.72220634e-02f, -4.06707004e-02f, -7.93545321e-03f, -4.05800529e-02f,
  -3.63507494e-02f, -6.54585883e-02f, 5.63963912e-02f, 1.70954093e-02f, -6.19921125e-02f, -3.52423117e-02f, -3.13385092e-02f, 3.10191885e-02f, 1.80207491e-02f, -3.48765105e-02f,
  5.59388399e-02f, -5.43550448e-03f, 4.14043106e-02f, 1.22826003e-01f, 8.03355798e-02f, 3.39567810e-02f, 5.42352116e-03f, 2.46764421e-02f, 6.50053695e-02f, 3.82486396e-02f,
  -2.59647379e-03f, 8.75402689e-02f, -3.32423188e-02f, -2.73828115e-03f, 4.26335782e-02f, 8.51730555e-02f, 3.74114178e-02f, 1.52467322e-02f, 1.44885397e-02f, 1.35632725e-02f,
  -2.11504959e-02f, -4.38665785e-02f, -8.98149908e-02f, 4.22607139e-02f, 4.16955575e-02f, 1.06277481e-01f, -3.75349559e-02f, 6.93427101e-02f, 1.34215932e-02f, 1.13933295e-01f,
  -1.04731560e-01f, -3.95070352e-02f, 3.69017124e-02f, -1.05715385e-02f, -1.45145088e-01f, 9.90907010e-03f, 1.83528941e-02f, 7.25075323e-03f, -3.11643947e-02f, 6.09169565e-02f,
  -9.77505185e-03f, 1.44047095e-02f, 5.46558239e-02f, 9.86300875e-04f, -2.40215063e-02f, -1.16395772e-01f, 1.95055902e-02f, 7.82499183e-03f, 4.40997966e-02f, 2.59390883e-02f,
  1.01828482e-02f, 3.68635058e-02f, 7.67076463e-02f, -4.30276394e-02f, -7.69080669e-02f, -6.94441497e-02f, -6.40242919e-02f, -1.07562793e-02f, -6.22131787e-02f, -2.93502701e-03f,
  -2.34211399e-03f, 2.01770633e-01f, 4.12984230e-02f, -1.55966043e-01f, 6.38113022e-02f, 6.52177557e-02f, 1.39026508e-01f, -2.49954388e-02f, -2.44585779e-02f, 1.04147559e-02f,
  3.33515089e-03f, -4.04484756e-02f, -1.14239983e-01f, -4.22799513e-02f, -1.25301480e-01f, 3.82192880e-02f, -3.38769145e-02f, -1.70291930e-01f, -1.74262553e-01f, -9.33830515e-02f,
  -8.77513811e-02f, 3.05535011e-02f, -1.75199494e-01f, -2.10812483e-02f, 1.50619581e-01f, -1.45154625e-01f, -5.07773086e-02f, 4.38409746e-02f, -7.39623308e-02f, 8.86285082e-02f,
  1.86251234e-02f, 1.08326234e-01f, -2.14123651e-01f, -8.12817439e-02f, 2.13640872e-02f, 2.45240629e-02f, 2.59691980e-02f, 7.71421343e-02f, -2.57449858e-02f, -5.37304953e-02f,
  -3.35780494e-02f, -1.66628528e-02f, 4.87839468e-02f, -1.04357190e-01f, -5.68574108e-02f, -2.45620944e-02f, 5.23406528e-02f, -9.52584576e-03f, 1.43126363e-03f, 6.80987313e-02f,
  1.25812171e-02f, -7.01858290e-03f, -6.63410202e-02f, -1.02155125e-02f, -3.17323096e-02f, 9.79817379e-03f, -3.08152959e-02f, -3.94170284e-02f, -1.19057205e-02f, 2.42355987e-02f,
  -1.31294221e-01f, 9.62976273e-03f, 2.85534449e-02f, -3.62727195e-02f, 7.87083618e-03f, 3.63984928e-02f, 4.56817932e-02f, -2.87599657e-02f, -3.46508920e-02f, 2.99564842e-03f,
  -7.01350272e-02f, -2.73123886e-02f, 2.33439598e-02f, -6.94812089e-02f, 3.65545414e-02f, -4.99343909e-02f, 6.60004909e-04f, 7.63260806e-03f, -5.35810255e-02f, 2.11890750e-02f,
  3.81587707e-02f, 2.52292324e-02f, -2.33312808e-02f, -3.43057588e-02f, -1.78431801e-03f, 1.10542431e-01f, 1.10033443e-02f, 3.49471271e-02f, 5.41982464e-02f, 2.18118057e-02f,
  -8.74253735e-03f, -1.34777501e-01f, -1.13200083e-01f, 7.47071058e-02f, 7.38103967e-03f, 1.16036581e-02f, 3.80708389e-02f, -8.12179316e-03f, 6.31167963e-02f, 1.15939351e-02f,
  9.17499606e-03f, -2.59751198e-03f, 4.33803163e-02f, -1.03226908e-01f, 1.69767588e-02f, -1.01911604e-01f, 1.05694057e-02f, 6.20902181e-02f, -1.04677938e-01f, 5.07650664e-03f,
  9.16135237e-02f, 2.31747478e-02f, -9.91718546e-02f, 4.30847034e-02f, -2.55549010e-02f, -1.73064783e-01f, 4.67983540e-03f, -2.70115416e-02f, -1.77721262e-01f, -3.81124625e-03f,
  -1.63705140e-01f, 7.34191537e-02f, -1.19641237e-02f, 1.11644790e-02f, 1.27892241e-01f, -2.59480253e-02f, 2.53186468e-02f, -4.75421064e-02f, 5.69641702e-02f, 1.59509052e-02f,
  6.32685944e-02f, -4.63476181e-02f, 3.49067301e-02f, -2.24402584e-02f, -7.50314817e-02f, 2.37944606e-03f, 1.79287672e-01f, -5.46846949e-02f, -1.32553279e-01f, 2.76283957e-02f,
  1.16398171e-01f, -3.98563687e-03f, -1.38980793e-02f, -7.44152665e-02f, 4.33365032e-02f, -4.89977524e-02f, -1.10493144e-02f, 1.23694919e-01f, 3.31162773e-02f, 3.15960556e-01f,
  -1.74582042e-02f, 7.75223076e-02f, 2.49793958e-02f, 6.80920780e-02f, 2.41357125e-02f, -5.31731807e-02f, -2.27098074e-02f, 8.04682670e-04f, 2.66987942e-02f, 6.43519461e-02f,
  7.96141326e-02f, -4.36100997e-02f, -7.08866045e-02f, -9.27127246e-03f, 2.83730756e-02f, 2.65597142e-02f, -3.33523341e-02f, -1.55814849e-02f, -2.46331957e-03f, -3.60877700e-02f,
  4.57721055e-02f, 1.93778872e-01f, 1.01392850e-01f, -8.90003145e-02f, -6.58682957e-02f, 1.26627967e-01f, -5.93366101e-02f, 3.84576246e-02f, 2.27096584e-02f, 1.13577299e-01f,
  3.05501092e-03f, -2.44434383e-02f, 4.43905890e-02f, -3.08449287e-02f, -6.80249259e-02f, -6.74392562e-03f, 4.34740335e-02f, 7.06922039e-02f, -3.57734635e-02f, -2.27094274e-02f,
  4.51221243e-02f, -5.16065992e-02f, -1.03502981e-02f, -9.77443829e-02f, -3.08052395e-02f, 2.23153159e-02f, 2.26777028e-02f, 8.54633190e-03f, -7.08873123e-02f, 3.00076585e-02f,
  7.82133937e-02f, -3.56084891e-02f, -1.72857866e-02f, 7.88962767e-02f, 3.42409033e-03f, -1.92361493e-02f, 4.36484963e-02f, -4.51915152e-02f, -1.91061925e-02f, 1.44741461e-01f,
  -8.73214900e-02f, -1.37982061e-04f, 8.32698569e-02f, 1.46547519e-02f, 2.51744874e-03f, -1.02368183e-01f, -1.57595742e-02f, 1.57419145e-02f, 5.00343889e-02f, 4.58569601e-02f,
  4.07534838e-02f, -4.65835743e-02f, -4.99703847e-02f, 3.84267457e-02f, 6.93350956e-02f, -4.77919988e-02f, 4.53991070e-02f, -5.49212843e-02f, 3.31802629e-02f, -7.71698728e-02f,
  -1.40809603e-02f, 1.81255639e-02f, -6.92874938e-02f, 2.18227506e-02f, 8.62968527e-03f, 4.76353392e-02f, -1.57958381e-02f, 5.22748977e-02f, -2.72537880e-02f, -9.12943855e-02f,
  -1.25346575e-02f, -2.95432061e-01f, -1.21447697e-01f, 2.70224720e-01f, 1.81620374e-01f, 5.28963320e-02f, -3.32460701e-01f, -1.59773320e-01f, 1.53300151e-01f, -1.29498258e-01f,
  7.96459988e-02f, 8.17445740e-02f, 1.81745850e-02f, -8.67591128e-02f, -1.69383124e-01f, -3.77054006e-01f, -5.92318885e-02f, -1.37867689e-01f, -1.07546143e-01f, -1.09538384e-01f,
  6.67506754e-02f, 1.03271879e-01f, 2.02840231e-02f, -4.45941016e-02f, 1.15813419e-01f, 1.69432625e-01f, 6.99322224e-02f, 1.01243764e-01f, -3.02269980e-02f, 9.33912322e-02f,
  7.03417882e-02f, -5.64423651e-02f, 4.05432656e-02f, 4.31777276e-02f, 7.45391622e-02f, -5.28599881e-02f, -9.38495994e-02f, 2.57978179e-02f, -2.88236775e-02f, -3.90928313e-02f,
  4.73573208e-02f, 3.58962044e-02f, 8.90695117e-03f, 1.38897493e-01f, -1.07621036e-01f, -6.38081506e-02f, -3.65796238e-02f, -4.34658900e-02f, -1.69819951e-01f, -9.47815999e-02f,
  7.54346047e-03f, -6.51109517e-02f, -1.29161760e-01f, -9.12845135e-02f, -6.81717843e-02f, -5.16961627e-02f, 8.29767063e-03f, 7.17433617e-02f, -1.88835170e-02f, -1.85896400e-02f,
  -9.09393653e-03f, 8.11106265e-02f, -2.07833927e-02f, 5.13294674e-02f, -7.55629987e-02f, -9.88589227e-03f, 1.75996907e-02f, 7.79437423e-02f, 2.70852949e-02f, -8.27534944e-02f,
  -2.32652631e-02f, -2.66413558e-02f, 1.16089126e-02f, -2.11557318e-02f, 9.12203267e-02f, 3.41100730e-02f, 9.05035734e-02f, -6.84300810e-02f, -7.96020478e-02f, -5.74992374e-02f,
  -4.41580452e-02f, -6.23508580e-02f, -1.84752848e-02f, -2.87277345e-02f, -9.03408825e-02f, -1.58126038e-02f, -1.82205322e-03f, 3.19449380e-02f, 6.57734424e-02f, 6.87939972e-02f,
  1.04420289e-01f, 8.15960988e-02f, 8.20591953e-03f, -1.02028914e-01f, 8.14574212e-02f, -9.11273211e-02f, 7.85478204e-02f, -1.57985371e-02f, 6.75266087e-02f, -5.53673655e-02f,
  5.06607955e-03f, -4.88493964e-02f, 1.10545181e-01f, 7.53442720e-02f, 5.65268211e-02f, -2.53825765e-02f, -1.23801306e-01f, 5.01593351e-02f, 1.70553643e-02f, -6.54712133e-03f,
  -6.23371219e-03f, -1.61374539e-01f, -2.53369240e-03f, -1.71450213e-01f, -6.31434247e-02f, 3.65603603e-02f, 1.08237267e-02f, 9.50930566e-02f, -9.82957259e-02f, -1.28463373e-01f,
  7.70076960e-02f, -6.63391314e-03f, -1.32116914e-01f, 4.91014495e-02f, 3.25403772e-02f, 9.65332761e-02f, -1.04936976e-02f, 1.25284255e-01f, 1.57249838e-01f, -8.04685354e-02f,
  1.76067185e-02f, 1.32185966e-01f, -2.35475018e-03f, -7.74149643e-03f, -4.33294177e-02f, -8.79651383e-02f, -1.69055954e-01f, -3.40638719e-02f, 1.49299065e-02f, 1.23057142e-01f,
  5.57914451e-02f, -1.40689397e-02f, 4.28611077e-02f, -4.40311916e-02f, -9.69988778e-02f, -4.34076637e-02f, -1.47653997e-01f, -1.60223588e-01f, -4.66795489e-02f, -2.42619067e-01f,
  -1.41558528e-01f, -5.58302086e-03f, 3.33287641e-02f, -7.12883472e-02f, -1.21166967e-01f, 1.03990056e-01f, 1.10973246e-01f, -3.93334217e-02f, 4.16979752e-02f, 6.40305206e-02f,
  -2.32455339e-02f, 8.22045654e-03f, 1.46710854e-02f, -1.85793769e-02f, -4.65617552e-02f, -6.78097308e-02f, 5.16205095e-02f, -7.03263879e-02f, 2.08543912e-02f, 5.34467474e-02f,
  1.00984357e-01f, 4.03138399e-02f, 1.95356458e-02f, -8.19608346e-02f, 1.00017436e-01f, 1.17511181e-02f, 1.07823079e-02f, -7.74438865e-03f, -1.03367358e-01f, 1.11766607e-02f,
  -1.30323898e-02f, 6.51310980e-02f, 4.28143255e-02f, -9.56113357e-03f, 2.77435109e-02f, 7.56492540e-02f, 5.72378710e-02f, 4.37722802e-02f, -3.26889418e-02f, 6.19052947e-02f,
  -6.57765865e-02f, -3.89844514e-02f, -8.34572315e-02f, -1.04810953e-01f, -1.01564869e-01f, -3.21195349e-02f, 2.79173870e-02f, 3.29115835e-04f, -8.84995759e-02f, 5.10329530e-02f,
  5.28887622e-02f, -1.31131068e-01f, 2.91063543e-02f, -1.71462353e-02f, -3.45467180e-02f, -2.83465311e-02f, 1.04100749e-01f, 4.13826965e-02f, 1.29558280e-01f, 1.10141285e-01f,
  1.27756357e-01f, -1.20853847e-02f, -3.51037048e-02f, 4.33850139e-02f, -4.47713546e-02f, -6.44390732e-02f, -4.74968962e-02f, 4.88569252e-02f, -1.82151254e-02f, 5.91757298e-02f,
  5.10453014e-03f, -3.75545248e-02f, 3.44587564e-02f, 5.00439815e-02f, 8.78645033e-02f, 1.09175965e-02f, -6.61262199e-02f, 6.63402602e-02f, -2.26137061e-02f, 2.50772778e-02f,
  -4.76573147e-02f, -3.62286140e-04f, 1.07772984e-01f, 5.99685423e-02f, 5.70307933e-02f, 8.63196154e-04f, -7.70913064e-02f, -5.14593832e-02f, -6.89561516e-02f, 5.36302924e-02f,
  6.48570433e-02f, 9.12022963e-02f, 1.08891092e-01f, 4.12951633e-02f, 1.36244074e-01f, 8.03020447e-02f, 1.47252202e-01f, -8.17377642e-02f, -7.93627948e-02f, 1.46307036e-01f,
  -1.37395129e-01f, -2.26613790e-01f, -1.96295932e-01f, -2.30606586e-01f, -1.11051172e-01f, 5.05067520e-02f, 1.51072875e-01f, -3.97230778e-03f, 5.24491351e-03f, 5.75956106e-02f,
  -9.18243527e-02f, 1.12191617e-01f, 6.76566362e-02f, -1.36733636e-01f, 3.95078212e-02f, -4.74733897e-02f, 5.32205738e-02f, 6.59349114e-02f, -2.37611495e-02f, 1.42556608e-01f,
  -7.54988045e-02f, 7.62241483e-02f, 6.81056753e-02f, -1.64550617e-02f, 7.16567636e-02f, 4.61731181e-02f, -6.02962524e-02f, 3.26900557e-02f, 2.60719713e-02f, 4.87538464e-02f,
  -2.29470879e-02f, 6.99907765e-02f, -3.73044387e-02f, 1.89011358e-02f, 1.69820473e-01f, 2.12409515e-02f, 5.94947934e-02f, 6.18052632e-02f, 7.99683705e-02f, 7.51202330e-02f,
  -2.77288891e-02f, 4.15571332e-02f, -2.27461904e-02f, -3.67141031e-02f, 7.80414417e-02f, -5.21725938e-02f, -3.04056369e-02f, 2.11900137e-02f, -5.58621809e-03f, 3.59037444e-02f,
  6.69468194e-03f, -7.18408376e-02f, -8.87456685e-02f, 4.47348803e-02f, 5.96414208e-02f, -4.24045846e-02f, 5.82257360e-02f, -6.30770437e-03f, -1.02020510e-01f, -3.63444798e-02f,
  5.73713472e-03f, 7.09096640e-02f, 4.75913286e-02f, -1.73280586e-03f, -9.70899686e-03f, 6.71389338e-04f, -1.42492345e-02f, -5.45419939e-02f, -5.00595607e-02f, -3.78653705e-02f,
  -1.12285614e-01f, -1.22709602e-01f, 2.36792192e-02f, -2.47507207e-02f, 6.24932200e-02f, 1.79836862e-02f, -2.51298361e-02f, 3.42426216e-03f, 4.37385738e-02f, 1.17973639e-02f,
  -1.63422395e-02f, -9.96845029e-03f, -1.16373830e-01f, -9.98897776e-02f, 2.44713910e-02f, -5.38415276e-03f, -4.74109426e-02f, 3.11029260e-03f, 9.75024626e-02f, -5.69530055e-02f,
  -9.95991528e-02f, -5.74378632e-02f, 3.41786217e-04f, 2.64493674e-02f, 4.66611534e-02f, -5.93384774e-03f, -5.39328493e-02f, 5.36992773e-02f, 5.11084311e-02f, 5.49441129e-02f,
  -8.13122615e-02f, 1.93126108e-02f, -3.10869347e-02f, -1.21475540e-01f, 3.85130830e-02f, -4.27101590e-02f, 3.85423154e-02f, -6.85333982e-02f, -2.14238558e-02f, -6.27522394e-02f,
  2.09296778e-01f, -1.44921988e-01f, -7.82551020e-02f, -1.57452170e-02f, -1.32610556e-02f, 7.22188503e-02f, -2.46941298e-02f, 4.29597907e-02f, 1.69049967e-02f, 1.88963171e-02f,
  -1.40676619e-02f, -2.46188268e-02f, 3.69122922e-02f, -4.67031002e-02f, 1.22765899e-01f, -8.12162757e-02f, -2.80687418e-02f, 5.95450141e-02f, 1.85033083e-01f, 6.89120293e-02f,
  -7.05120564e-02f, -2.82411318e-04f, 8.05136468e-03f, -1.88914631e-02f, -1.49453908e-01f, -4.97618504e-02f, -1.15872681e-01f, -1.36971660e-02f, -6.54491037e-03f, -1.45280197e-01f,
  2.74430122e-02f, -2.03151777e-02f, 9.90504250e-02f, 3.54290046e-02f, 2.01799516e-02f, 6.19837828e-02f, 2.79194042e-02f, 2.06376873e-02f, -7.03672096e-02f, 6.34199753e-02f,
  3.08982171e-02f, 3.74756753e-02f, -2.41610333e-02f, -5.81920706e-02f, 2.37943954e-03f, -1.39117343e-02f, 6.00481927e-02f, 1.31428649e-03f, 5.36133833e-02f, -6.50482252e-02f,
  1.35409450e-02f, -4.29218933e-02f, -1.00128561e-01f, -1.02982938e-01f, -3.50327455e-02f, 2.70907171e-02f, -4.78971377e-02f, -1.06751189e-01f, -3.12695093e-02f, -1.64038122e-01f,
  4.74646688e-02f, -5.50505333e-03f, 3.53578888e-02f, -4.92427871e-02f, 6.92123082e-03f, -7.18801795e-03f, -2.62619890e-02f, 1.49964262e-02f, 3.92905623e-02f, -4.39827070e-02f,
  4.00671810e-02f, 7.05075562e-02f, -3.48241702e-02f, -3.68378870e-02f, 3.16871405e-02f, 3.92994136e-02f, -8.83506425e-03f, -7.71248937e-02f, 3.48988213e-02f, -6.15935661e-02f,
  5.86083233e-02f, 8.63129497e-02f, 4.18619886e-02f, 5.43007404e-02f, 2.95281056e-02f, 3.39207649e-02f, 4.53132726e-02f, -1.17722992e-02f, -3.66405174e-02f, -5.86917289e-02f,
  -4.10426557e-02f, -4.86286767e-02f, 1.56414285e-02f, 7.08947331e-02f, -4.78156023e-02f, 1.91174932e-02f, -5.79855405e-02f, -5.40532060e-02f, 9.83590540e-03f, 2.41672248e-02f,
  2.20084973e-02f, 1.46840625e-02f, 5.77815101e-02f, 5.74853867e-02f, -1.85496062e-02f, -1.47149945e-03f, -5.39425276e-02f, -7.81099722e-02f, 2.61022449e-02f, -2.64960658e-02f,
  -1.05321687e-02f, 6.04069307e-02f, 2.80400924e-02f, 2.57587880e-02f, 1.18324868e-02f, 2.43927054e-02f, 6.99205026e-02f, -1.22685926e-02f, 1.29504893e-02f, 4.07586321e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.52961710e-02f, -2.08712950e-01f, -1.70842364e-01f, -1.40878269e-02f, -2.05050744e-02f, 2.85807196e-02f, -9.79617983e-02f, -2.07766909e-02f, 4.09012660e-02f, -6.76851571e-02f,
  2.19456609e-02f, 1.20789677e-01f, 5.35144657e-02f, 2.36376096e-02f, -3.48340767e-03f, -1.84459776e-01f, -1.30639240e-01f, -8.20312575e-02f, 1.30986348e-01f, 5.11788353e-02f,
  4.47417283e-03f, -9.45798755e-02f, 2.22271886e-02f, 1.13111950e-01f, -6.59203678e-02f, -6.52287304e-02f, -2.01650083e-01f, -1.93170682e-02f, -1.21785507e-01f, -1.19938888e-01f,
  1.40405595e-02f, -3.71777453e-02f, -2.81775463e-03f, 9.47078317e-02f, -9.35199857e-02f, 6.89716265e-02f, -1.54388668e-02f, -1.35520538e-02f, 6.85587823e-02f, -2.94826995e-03f,
  8.48098099e-02f, -3.44713926e-02f, -1.88502036e-02f, 1.06834183e-02f, 5.96623421e-02f, 1.12058204e-02f, -1.68499257e-03f, -6.22511432e-02f, -1.95329990e-02f, -5.43144308e-02f,
  -3.85981449e-03f, -6.15514256e-02f, 7.68868774e-02f, 8.90652463e-02f, 9.52458754e-02f, 1.15082197e-01f, -4.15604226e-02f, 1.18425926e-02f, -8.68961439e-02f, -1.18624352e-01f,
  -1.38762221e-01f, -5.65115549e-02f, 6.19002618e-03f, -3.52178216e-02f, -3.79024679e-03f, -1.25749866e-02f, 2.67571677e-02f, -7.05106035e-02f, 1.10373065e-01f, -1.80744343e-02f,
  -3.42893526e-02f, 5.21259159e-02f, -2.52840575e-02f, -9.42472667e-02f, 1.16356277e-04f, -7.57094705e-03f, 5.94801530e-02f, 3.00387833e-02f, 8.24956819e-02f, 1.97100211e-02f,
  -3.46369930e-02f, -4.85531874e-02f, 5.56023978e-02f, -7.31054619e-02f, -9.16709155e-02f, -2.54346523e-02f, 3.37869599e-02f, 5.56945279e-02f, -4.03519720e-02f, 1.23417720e-01f,
  -1.71039887e-02f, -1.40746776e-02f, 6.33319560e-03f, 1.99486092e-02f, 9.09209251e-03f, -2.78501008e-02f, 5.36499806e-02f, 7.13222176e-02f, -2.20017452e-02f, 3.75438631e-02f,
  5.07389940e-02f, 6.35317862e-02f, 9.62910522e-03f, 4.09953035e-02f, 4.56831381e-02f, -2.51709968e-02f, -1.85383074e-02f, 9.87856984e-02f, -2.84079239e-02f, 3.42835784e-02f,
  1.62481163e-02f, 3.58580761e-02f, 1.02102831e-01f, -2.04172991e-02f, -6.98009133e-02f, 7.35681280e-02f, -4.16552909e-02f, 3.78068686e-02f, -2.32316181e-02f, -1.17052063e-01f,
  -9.34237912e-02f, -1.57547027e-01f, -1.52703285e-01f, 3.66287157e-02f, -6.60075918e-02f, 4.75558825e-02f, -7.81749655e-03f, 6.28821775e-02f, 1.01126432e-02f, -4.46614549e-02f,
  -6.01187572e-02f, -1.39978603e-02f, -1.14289813e-01f, -5.17306961e-02f, -6.16733991e-02f, -1.22969419e-01f, -6.62176907e-02f, -9.39679593e-02f, -2.77783964e-02f, 3.70033421e-02f,
  -3.53619196e-02f, -1.46380037e-01f, 1.42812543e-02f, -1.99408662e-02f, 8.96711461e-03f, -8.94232094e-02f, -2.33696088e-01f, -1.06654920e-01f, -1.27582684e-01f, -2.18194023e-01f,
  -1.07729457e-01f, 7.63329342e-02f, 4.63122018e-02f, -4.11697812e-02f, -6.15675710e-02f, 2.70236935e-02f, 4.04796898e-02f, -9.38964263e-02f, 4.89495322e-02f, -7.01126382e-02f,
  -1.25249073e-01f, 5.84684759e-02f, 1.68332912e-03f, -4.78558168e-02f, 2.65168585e-02f, 5.53202219e-02f, -6.37676790e-02f, -6.59936741e-02f, 1.26879895e-02f, -2.61116102e-02f,
  2.40197070e-02f, -5.41397892e-02f, -3.61917503e-02f, -5.10844924e-02f, 3.33214439e-02f, -5.14458790e-02f, -1.16877921e-01f, 4.62166145e-02f, -6.99190004e-03f, -1.13518760e-01f,
  -7.95153230e-02f, -9.61991772e-02f, -6.25882903e-03f, 7.99134299e-02f, 8.14877898e-02f, 9.41087902e-02f, 9.56814960e-02f, -9.83456671e-02f, 7.39686117e-02f, -2.99713742e-02f,
  2.73286551e-02f, -7.21260682e-02f, 2.40726359e-02f, -9.15857032e-02f, -1.06612310e-01f, -1.45156886e-02f, -3.08089722e-02f, 3.37148942e-02f, -1.15444981e-01f, -4.63352166e-03f,
  3.40857543e-02f, -8.95292014e-02f, -1.37488963e-02f, 2.21755411e-02f, -5.88786379e-02f, -7.27052540e-02f, -6.01700433e-02f, 4.73739058e-02f, 5.43675981e-02f, -3.36332917e-02f,
  3.78287397e-03f, -5.53713217e-02f, -5.26357852e-02f, 8.78763124e-02f, -8.88248160e-02f, -5.22881672e-02f, -5.47348298e-02f, -4.57952842e-02f, 1.37816831e-01f, 1.85991824e-02f,
  6.86599463e-02f, -2.78964378e-02f, -1.04417250e-01f, -6.04635067e-02f, 3.78767252e-02f, 3.46752629e-02f, 4.36076410e-02f, -7.10095838e-02f, 9.96739119e-02f, 5.69265001e-02f,
  -8.50898623e-02f, 6.45584706e-03f, -2.45514307e-02f, -8.23325571e-03f, -7.55944774e-02f, -1.09503213e-02f, 9.09415167e-03f, 8.99918657e-03f, -3.51375677e-02f, 4.38623875e-03f,
  -7.92320743e-02f, 1.24589145e-01f, -6.70581758e-02f, -1.04711570e-01f, 1.03453413e-01f, -1.74298696e-02f, 4.28469144e-02f, 6.02070475e-03f, -9.58469063e-02f, 6.44376203e-02f,
  2.53265928e-02f, 9.39839892e-03f, 7.11601526e-02f, 1.40952980e-02f, -1.06604420e-01f, 6.71960926e-03f, -5.30119389e-02f, -1.41430143e-02f, -1.83291718e-01f, -2.77536884e-02f,
  1.06634855e-01f, 8.97761900e-03f, -2.12458730e-01f, -1.28629908e-01f, 8.96752775e-02f, 2.34145038e-02f, -1.53428987e-02f, -7.50334421e-03f, -9.83033106e-02f, 2.51048982e-01f,
  5.10591120e-02f, -1.16469134e-02f, -5.94930239e-02f, 4.38535120e-03f, -4.54652645e-02f, -4.87864353e-02f, 8.40337425e-02f, 5.17989881e-02f, 5.19421175e-02f, 4.69147898e-02f,
  4.91971448e-02f, -6.83219060e-02f, 5.17722629e-02f, 7.72043969e-03f, 2.22275183e-02f, -1.20008305e-01f, -1.04119487e-01f, -1.12804949e-01f, -3.88618745e-02f, 6.32746071e-02f,
  1.32785365e-01f, -2.06630211e-02f, -1.15030691e-01f, 2.97732633e-02f, -4.97440472e-02f, -8.98379274e-03f, -3.29119079e-02f, -9.06936005e-02f, -1.57896966e-01f, -5.52889146e-02f,
  -1.73623580e-02f, -4.80239056e-02f, -5.03966324e-02f, 4.28679958e-02f, -5.97279929e-02f, -2.98684686e-02f, 4.79130074e-02f, -6.21428229e-02f, -1.02583446e-01f, -9.78875235e-02f,
  3.21652070e-02f, -1.43986177e-02f, -3.10903061e-02f, -3.04599535e-02f, -2.20286846e-02f, -4.99848984e-02f, -2.10319962e-02f, -1.25508383e-02f, -5.91116846e-02f, -6.06928989e-02f,
  6.48827553e-02f, -2.39847181e-03f, 5.43800853e-02f, -5.38925305e-02f, -2.87593920e-02f, -4.04182039e-02f, -9.52368528e-02f, -7.15325326e-02f, 1.48598226e-02f, 1.56431291e-02f,
  -1.10383525e-01f, -7.66645670e-02f, -5.18918745e-02f, -8.11312869e-02f, -1.12830568e-02f, 1.63207650e-02f, 3.28989811e-02f, -6.98720738e-02f, 6.44168854e-02f, 4.06151358e-03f,
  -2.93700732e-02f, 4.46387101e-03f, -5.89504503e-02f, 4.06185687e-02f, -3.73500288e-02f, 4.54906151e-02f, -5.12991734e-02f, 2.06299312e-02f, 4.72340994e-02f, 7.56682679e-02f,
  2.50418764e-02f, -1.12265103e-01f, -3.55412252e-02f, 4.97617014e-02f, -3.99149284e-02f, -8.61658156e-02f, -1.47158336e-02f, -4.18492183e-02f, -3.08460128e-02f, -7.93608576e-02f,
  9.02753603e-03f, 1.35627404e-01f, -1.07446343e-01f, 6.97919577e-02f, -3.45892422e-02f, -1.91897884e-01f, -1.54745206e-01f, -2.04240188e-01f, 4.34029512e-02f, 8.39066207e-02f,
  -8.67732912e-02f, 1.12579055e-02f, 9.03877392e-02f, 7.51368999e-02f, -3.05203889e-02f, 2.14589071e-02f, 6.85174316e-02f, 9.13598668e-03f, -2.08805263e-01f, -5.39711677e-02f,
  7.66828610e-03f, -2.77284021e-03f, -2.18288116e-02f, -5.53920791e-02f, 1.35251567e-01f, 2.83691175e-02f, 1.67981014e-02f, -1.90035589e-02f, 1.13573000e-02f, 3.69374275e-01f,
  5.72761334e-02f, -4.29404266e-02f, -1.31665254e-02f, 7.87142012e-03f, 4.24551107e-02f, -3.59742343e-02f, -3.63924354e-02f, 1.08427899e-02f, 1.11246817e-02f, -4.72449400e-02f,
  1.14818327e-01f, 6.46473020e-02f, -2.69248635e-02f, -9.48958844e-02f, -4.68013957e-02f, -3.59228849e-02f, -1.15960382e-01f, 4.83114347e-02f, -1.08276486e-01f, -1.11289293e-01f,
  1.39936462e-01f, 2.48902552e-02f, -2.12341100e-02f, -1.14762411e-01f, -2.26602238e-02f, -6.82099815e-03f, -6.15973845e-02f, 3.59920878e-03f, -1.34879574e-01f, 2.39632837e-02f,
  4.65511084e-02f, 2.20117741e-03f, -8.51602703e-02f, -2.24784445e-02f, 8.68413523e-02f, 5.06174155e-02f, -1.20422980e-02f, -4.73048165e-02f, 2.33649053e-02f, -4.81487922e-02f,
  -7.00756609e-02f, -7.33936056e-02f, -5.89752989e-03f, 4.12038714e-02f, -2.53854878e-02f, 3.90989184e-02f, -7.61075318e-02f, -6.88251108e-02f, 1.92438196e-02f, 9.18556154e-02f,
  -1.21924570e-02f, -5.60055906e-03f, -2.03126902e-03f, -3.97263169e-02f, 7.88155943e-02f, -7.54965916e-02f, 7.54749328e-02f, 4.56092022e-02f, -1.13518246e-01f, -6.24568649e-02f,
  -6.56230822e-02f, -1.10110104e-01f, 3.59943951e-03f, 9.39393342e-02f, -3.22818607e-02f, 9.76207107e-02f, -3.00206374e-02f, 2.66434606e-02f, -3.59452516e-02f, 3.54144275e-02f,
  1.05193436e-01f, 5.06086312e-02f, -3.92926335e-02f, -4.90635298e-02f, -5.59072383e-02f, 6.59515336e-02f, 6.23965599e-02f, -7.71731362e-02f, -9.18902904e-02f, 2.32239179e-02f,
  -1.02482093e-02f, -2.92874109e-02f, -4.23235185e-02f, -1.55144902e-02f, 2.04239860e-02f, 2.16113273e-02f, -3.27052251e-02f, -7.35264346e-02f, -7.84887895e-02f, -7.88708851e-02f,
  -8.39979276e-02f, 6.65884279e-03f, 5.36255315e-02f, -1.18111372e-01f, -2.24213973e-02f, 1.53203038e-02f, 2.83802934e-02f, 1.96945816e-02f, -8.60634893e-02f, 5.33470735e-02f,
  1.70662394e-03f, -6.42738417e-02f, -1.47750461e-02f, -6.29228204e-02f, 4.29627411e-02f, -4.29438287e-03f, -1.15398299e-02f, -9.76893976e-02f, -4.97831739e-02f, 1.95932277e-02f,
  5.04319519e-02f, -1.32453302e-02f, -1.19953305e-01f, -5.48259802e-02f, -1.71154598e-03f, 6.04052730e-02f, -9.76256728e-02f, 2.59142779e-02f, -6.15693666e-02f, -7.00109378e-02f,
  9.99991223e-02f, -1.18574597e-01f, -7.09957629e-02f, 3.04842927e-02f, -2.06776299e-02f, -5.00022545e-02f, -1.19462758e-02f, -3.37485708e-02f, 7.62238503e-02f, 1.11135945e-01f,
  4.88483952e-03f, -6.67294413e-02f, -1.98609885e-02f, 9.37762409e-02f, 4.28980701e-02f, 8.87870491e-02f, -1.09718861e-02f, 7.78026879e-02f, 5.01133781e-03f, 6.61038458e-02f,
  9.97984260e-02f, -7.33437017e-02f, -4.59658951e-02f, -4.53276262e-02f, 8.31046030e-02f, 9.28339064e-02f, -7.44478684e-03f, 9.56917554e-02f, -3.85490619e-02f, -6.97203502e-02f,
  -8.18580016e-02f, 4.75245155e-02f, -2.83731949e-02f, 8.60935003e-02f, -2.20758896e-02f, -4.77146655e-02f, -2.61567216e-02f, 1.20627694e-01f, 7.41544366e-02f, -4.09442757e-04f,
  -3.05521861e-03f, -4.38451506e-02f, 9.04879943e-02f, 1.82532519e-02f, 9.89736468e-02f, -2.79512219e-02f, -3.84045020e-02f, -5.18642776e-02f, 1.89823844e-02f, 1.41155804e-02f,
  -6.66628629e-02f, 8.26873109e-02f, 7.79138878e-02f, 8.00824016e-02f, -5.40163629e-02f, 4.44347300e-02f, -4.28989753e-02f, -6.69508288e-03f, 9.08607692e-02f, -3.66090126e-02f,
  9.50250998e-02f, 1.43644372e-02f, -3.06378794e-03f, 6.68672398e-02f, 2.65909499e-03f, -6.10105619e-02f, -3.05413865e-02f, -7.98994899e-02f, 6.24787882e-02f, 6.34132326e-02f,
  5.63223511e-02f, 6.10253699e-02f, 2.24357080e-02f, -5.71216121e-02f, 9.79301929e-02f, 1.04322126e-02f, 7.23014921e-02f, -1.04699386e-02f, 4.06549983e-02f, 2.98179017e-04f,
  2.85949018e-02f, 8.03677812e-02f, 1.26292212e-02f, -1.35450123e-03f, 4.69332263e-02f, 6.50108382e-02f, 7.94439688e-02f, -2.86345445e-02f, 8.58526453e-02f, 1.01261154e-01f,
  -1.57277961e-03f, -2.71775108e-02f, -6.99346736e-02f, 2.06798967e-02f, 9.60730687e-02f, 1.26917437e-01f, -6.03307858e-02f, 9.01270658e-02f, 1.45149589e-01f, 7.17100576e-02f,
  1.36819735e-01f, 4.37337086e-02f, 1.46062775e-02f, 4.35438715e-02f, 2.71318685e-02f, 6.36903122e-02f, 4.74883281e-02f, -1.42762288e-02f, 1.12478517e-01f, -3.10708731e-02f,
  1.61180317e-01f, 1.13889530e-01f, 7.56767243e-02f, -3.72923464e-02f, 8.00142586e-02f, 1.08394951e-01f, 6.43001348e-02f, 5.18492386e-02f, 6.26266235e-03f, 6.17966056e-02f,
  3.11943553e-02f, -1.10487923e-01f, -1.47388345e-02f, -1.55096184e-02f, -2.96607167e-02f, -3.84684205e-02f, 6.30437508e-02f, -1.13024332e-01f, -8.78926143e-02f, -7.95580149e-02f,
  1.61322914e-02f, -6.62725270e-02f, -1.06495395e-02f, 1.65548939e-02f, 2.83987690e-02f, -4.49851900e-02f, 1.33293858e-02f, 3.35321240e-02f, -9.33171362e-02f, 2.39179675e-02f,
  9.00220126e-02f, 9.63320658e-02f, -4.26019728e-02f, 5.05559631e-02f, 2.67302501e-03f, 9.43582058e-02f, -7.51549602e-02f, -8.04220960e-02f, 5.15644578e-03f, 7.03439042e-02f,
  1.17077336e-01f, 5.25804423e-02f, -6.16013771e-03f, -5.12751658e-03f, -1.36671180e-03f, 2.43215598e-02f, 6.15839027e-02f, 2.13915370e-02f, 5.65491021e-02f, 4.56657857e-02f,
  -4.95746210e-02f, -1.91957075e-02f, -4.43419740e-02f, 2.16703247e-02f, 1.24145877e-02f, 7.13033369e-03f, 6.81534708e-02f, -3.14645506e-02f, 8.80755261e-02f, 4.67996709e-02f,
  -7.71943778e-02f, 6.05918095e-02f, 8.19828957e-02f, -7.60733709e-02f, -6.85286000e-02f, 4.23726672e-03f, -3.88503857e-02f, 9.92109030e-02f, -3.19745652e-02f, 8.08059499e-02f,
  2.47852821e-02f, 4.06646393e-02f, 1.29249305e-01f, 6.05711900e-02f, -2.13615708e-02f, 6.92074001e-02f, -1.66332144e-02f, 1.23881865e-02f, -6.63245842e-02f, 6.16902187e-02f,
  -7.60591701e-02f, -5.15185148e-02f, -7.63135105e-02f, -7.65627772e-02f, -7.98254982e-02f, -4.63598445e-02f, 7.75340647e-02f, -4.19424549e-02f, 8.28280300e-02f, 1.62835233e-02f,
  -2.22146306e-02f, 1.12392731e-01f, 7.74773359e-02f, -8.32128078e-02f, 6.39229119e-02f, 2.69822218e-02f, -6.43967986e-02f, -3.54826264e-02f, -5.24840914e-02f, -7.42018893e-02f,
  -9.21406671e-02f, -5.55192716e-02f, -2.04953961e-02f, 9.95312035e-02f, 7.76490718e-02f, -2.19882820e-02f, -3.36662903e-02f, 8.36541280e-02f, 5.35866991e-02f, 3.95619357e-03f,
  -2.46585021e-03f, 5.27794994e-02f, 1.76581480e-02f, -3.26925628e-02f, -7.53746629e-02f, 8.39682370e-02f, 1.28683090e-01f, -6.58955600e-04f, 4.30355733e-03f, -1.11537717e-01f,
  3.52235213e-02f, 5.25445342e-02f, -9.52975526e-02f, -5.24961725e-02f, 9.09096301e-02f, -9.41482559e-02f, 6.78357109e-02f, 7.65979886e-02f, -7.92815834e-02f, 3.91939580e-02f,
  -4.70613949e-02f, -6.13659024e-02f, 4.68298011e-02f, 6.47615641e-02f, -4.72928435e-02f, -5.52827008e-02f, 3.65521759e-02f, 2.46088090e-03f, -7.36928210e-02f, 3.94817777e-02f,
  -1.73757952e-02f, -9.15937424e-02f, -2.62510357e-03f, -3.67548466e-02f, 3.55363302e-02f, -9.43803489e-02f, -8.76788944e-02f, -4.99676855e-04f, -1.92232020e-02f, -1.21029476e-02f,
  -3.45354676e-02f, 6.73971698e-02f, -3.85109037e-02f, 5.16513037e-03f, -5.89777343e-02f, 3.20345871e-02f, -8.92927796e-02f, -2.63594687e-02f, -2.52149943e-02f, 1.22164702e-02f,
  -6.48651496e-02f, 4.63898927e-02f, -2.35898569e-02f, -3.21316645e-02f, -3.79909389e-02f, 1.16071567e-01f, 4.46391143e-02f, 6.57780021e-02f, 1.01178482e-01f, -7.30558336e-02f,
  4.39104922e-02f, 2.00592186e-02f, 3.35518755e-02f, -2.39255801e-02f, 3.99629772e-03f, 6.40229434e-02f, 7.37837479e-02f, -7.74741396e-02f, -5.21433018e-02f, -8.59667659e-02f,
  -8.92485864e-03f, -1.43001229e-02f, -9.37978551e-02f, -8.34072977e-02f, 8.74434412e-02f, 3.56933996e-02f, -4.17901948e-02f, -3.17567401e-02f, -8.17303285e-02f, 2.74312235e-02f,
  6.84032515e-02f, 2.06187144e-02f, 9.64571014e-02f, 1.43353092e-02f, -9.95264016e-03f, -5.10217324e-02f, -3.53926979e-02f, 1.99508853e-02f, -7.52102584e-02f, -1.18084624e-02f,
  -6.55201748e-02f, -7.65140206e-02f, -2.37766653e-02f, -5.91945499e-02f, 3.07852160e-02f, 5.42247370e-02f, 6.68466389e-02f, 6.09411933e-02f, -2.85794642e-02f, 7.78035298e-02f,
  3.07328533e-02f, -9.21388995e-03f, -4.19627056e-02f, 8.72460939e-03f, 2.13069767e-02f, 6.22755587e-02f, -8.09256956e-02f, -1.68282203e-02f, -1.98804084e-02f, -2.34966502e-02f,
  -1.97883815e-01f, 4.11146916e-02f, -3.61089408e-02f, -1.31892757e-02f, -6.97428957e-02f, -8.59116483e-03f, -1.04427069e-01f, -2.21141726e-02f, 1.05723090e-01f, 7.15376064e-02f,
  1.39674591e-02f, 1.47425383e-02f, -4.74249050e-02f, -5.90690449e-02f, -1.22955129e-01f, -3.29422317e-02f, 4.26620804e-03f, -1.39660597e-01f, -1.57141075e-01f, -7.37493634e-02f,
  9.32274945e-03f, -5.27135134e-02f, -1.34704471e-01f, -2.66980901e-02f, 6.49170056e-02f, 1.88304968e-02f, -4.34478968e-02f, -5.88830151e-02f, 5.77374399e-02f, 9.79561359e-02f,
  5.87939937e-03f, -2.17712689e-02f, 2.41425373e-02f, 3.93524161e-03f, 5.11389226e-02f, -4.88507599e-02f, -4.50894497e-02f, 4.91212979e-02f, 2.02932190e-02f, 4.59911264e-02f,
  2.18098778e-02f, 1.77075863e-02f, -7.58870095e-02f, -5.88419512e-02f, -2.28800550e-02f, -8.07717219e-02f, -4.44999263e-02f, -9.64538082e-02f, -5.73994368e-02f, -4.14475501e-02f,
  1.12523578e-01f, -4.80214832e-03f, -5.11864237e-02f, -1.21631408e-02f, 1.84895080e-02f, 2.72380933e-02f, 7.96030983e-02f, 2.72016358e-02f, 8.05071965e-02f, -3.06283701e-02f,
  3.34304385e-02f, 6.09470643e-02f, 2.82450505e-02f, 1.52157368e-02f, -8.05006847e-02f, 7.48662576e-02f, -8.37111995e-02f, -8.04136042e-03f, -3.88632691e-03f, -2.87247095e-02f,
  2.86331102e-02f, 4.28781696e-02f, -4.90930416e-02f, 5.90411089e-02f, -7.02511296e-02f, -6.69181207e-03f, 1.20042868e-01f, 6.26002252e-02f, -3.72770941e-03f, -6.15691990e-02f,
  7.42576122e-02f, 3.69175896e-02f, -6.07864261e-02f, 5.52076884e-02f, 1.16614126e-01f, 6.06127307e-02f, -2.85131615e-02f, 1.14167243e-01f, -2.98662670e-02f, 1.18533008e-01f,
  -5.86542450e-02f, -6.55228943e-02f, 8.13656002e-02f, 1.66880507e-02f, -5.54674789e-02f, -3.24434377e-02f, 7.98935667e-02f, -1.63621940e-02f, 6.36847084e-03f, 2.25453377e-02f,
  6.09928034e-02f, 3.58694792e-02f, 2.55879499e-02f, -5.51090091e-02f, 5.23001887e-02f, 1.05730437e-01f, -9.95705575e-02f, -2.12608390e-02f, -6.63441699e-03f, 2.21132189e-02f,
  -5.41223027e-02f, -3.36384028e-02f, -7.98083749e-03f, -2.61340514e-02f, -3.36761177e-02f, -2.50518546e-02f, 6.43688962e-02f, 8.56754482e-02f, 5.31460233e-02f, -7.11156726e-02f,
  1.11596650e-02f, -4.43873368e-02f, -1.05044395e-02f, 1.32096022e-01f, 1.37487531e-01f, 3.42033505e-02f, -9.32347924e-02f, -6.25159545e-03f, 4.12260257e-02f, 9.55795571e-02f,
  -3.74300517e-02f, 6.32976592e-02f, 6.16182238e-02f, -7.03539103e-02f, 3.42879370e-02f, -7.75823817e-02f, 6.00770600e-02f, 1.04503818e-02f, -5.83815575e-03f, 4.61627506e-02f,
  1.86034162e-02f, -3.04291714e-02f, -7.04234689e-02f, -3.73739786e-02f, 4.43309061e-02f, -5.49009144e-02f, 5.67529956e-03f, 8.44602361e-02f, 4.47640195e-02f, 1.08729951e-01f,
  -3.41913924e-02f, -2.45606750e-02f, -4.62701842e-02f, -4.74549010e-02f, -6.36044443e-02f, -9.79377180e-02f, -1.27157317e-02f, -5.50474599e-02f, -6.55376464e-02f, -4.56484705e-02f,
  4.40140404e-02f, -3.51450704e-02f, -1.60693172e-02f, -2.73141218e-03f, -2.72248778e-02f, 2.05840040e-02f, 2.52017863e-02f, 5.88450171e-02f, -7.19840825e-02f, 4.17711996e-02f,
  -9.03858629e-04f, 8.52776915e-02f, 3.98275489e-03f, -4.55393158e-02f, 8.08876976e-02f, -4.34362367e-02f, 1.97396502e-02f, 4.16631326e-02f, -6.00660183e-02f, -8.26845095e-02f,
  -8.05952027e-02f, 3.90491411e-02f, 3.07874698e-02f, 8.00357461e-02f, -1.49054304e-02f, -1.18690990e-02f, -4.09262590e-02f, -2.52905264e-02f, 5.79920597e-02f, -3.70753855e-02f,
  -2.54803384e-03f, 4.68186848e-02f, 7.94597045e-02f, -7.27921277e-02f, 8.61281827e-02f, -8.84957761e-02f, -4.26232032e-02f, 2.60637957e-03f, 5.59077673e-02f, 1.21564548e-02f,
  3.09147835e-02f, -2.96728201e-02f, -7.51747862e-02f, -9.41374823e-02f, -6.30793199e-02f, 1.20243430e-02f, 8.96156877e-02f, 2.57981587e-02f, -3.26602571e-02f, 3.44763398e-02f,
  -6.63423985e-02f, 2.60577500e-02f, 4.97715846e-02f, -1.84706599e-02f, 9.64941382e-02f, 7.40112364e-02f, -6.69340268e-02f, -3.64024900e-02f, 4.38025147e-02f, -7.96543658e-02f,
  -2.67913491e-02f, -1.55640515e-02f, 3.85480598e-02f, -3.55354659e-02f, -4.91446331e-02f, 2.41939556e-02f, 2.50321869e-02f, 3.38752382e-03f, 9.69399288e-02f, 1.65129621e-02f,
  -9.05867666e-02f, 1.06614836e-01f, -1.17446762e-02f, 9.81526896e-02f, 5.55170886e-02f, 3.88608426e-02f, 9.60972235e-02f, 4.43876795e-02f, 4.19391692e-02f, 1.34881940e-02f,
  -2.17700616e-01f, 1.00609936e-01f, -1.41128138e-01f, 5.37766330e-02f, 9.74438265e-02f, 2.82726232e-02f, -3.21497023e-03f, -2.47927420e-02f, 8.70002210e-02f, -1.18247658e-01f,
  -5.81326298e-02f, -9.99117792e-02f, -1.61255524e-01f, -1.50664046e-01f, -1.97957307e-01f, -2.17277050e-01f, -2.10027322e-01f, -1.63448647e-01f, -1.87684998e-01f, -8.93643424e-02f,
  -8.20948854e-02f, -9.67506319e-02f, -1.83630183e-01f, -5.75201996e-02f, 8.95625129e-02f, 1.32357404e-01f, -6.64601028e-02f, 3.62165570e-02f, 3.87507230e-02f, 1.00107573e-01f,
  -1.34630352e-01f, -8.81444383e-03f, -9.21718925e-02f, -3.40195112e-02f, -3.35096940e-02f, 8.66058767e-02f, -4.23932113e-02f, 2.65249424e-02f, -1.18955625e-02f, -1.00957721e-01f,
  -9.53413546e-02f, -7.52772614e-02f, -7.14056641e-02f, -4.17273566e-02f, 2.71061771e-02f, -6.00299276e-02f, -4.65590134e-02f, -2.42079832e-02f, -5.14593394e-03f, 6.68423399e-02f,
  4.84300815e-02f, 1.06679209e-01f, 1.15127908e-02f, 3.86582166e-02f, 5.94027974e-02f, -8.29852745e-02f, -2.55311988e-02f, 1.79470211e-01f, 7.90177360e-02f, 1.79659694e-01f,
  8.02042633e-02f, -1.34373590e-01f, 2.76442170e-02f, -1.82445496e-02f, 4.10965011e-02f, -1.79137308e-02f, 5.16723329e-03f, -5.91589324e-02f, 4.86583523e-02f, -4.44763452e-02f,
  6.61140531e-02f, 2.67217644e-02f, 2.90661417e-02f, -4.12624069e-02f, -1.04593150e-02f, 1.02176771e-01f, 6.94892108e-02f, -7.84449503e-02f, 2.29222979e-03f, -2.78632175e-02f,
  -5.05701788e-02f, 1.15838610e-02f, -1.42105110e-02f, 3.88380699e-02f, 2.72175521e-02f, 2.38278192e-02f, -2.71385610e-02f, -5.60038984e-02f, -7.06675574e-02f, 2.99375877e-02f,
  5.34381308e-02f, -1.14858523e-01f, -5.17077073e-02f, -7.74852559e-02f, -6.08398095e-02f, 1.08950675e-01f, 6.27410263e-02f, 6.27571270e-02f, 7.63061456e-03f, -4.82003316e-02f,
  -3.45460363e-02f, 2.30434965e-02f, 2.35336889e-02f, -2.39185560e-02f, -3.12241670e-02f, 5.17913047e-03f, 5.45158423e-03f, 7.25173876e-02f, 2.52878387e-02f, 7.79873356e-02f,
  5.27848676e-02f, -9.27871186e-03f, -2.78608836e-02f, 9.16441809e-03f, 6.85596764e-02f, 3.93965282e-02f, 3.54748294e-02f, 8.55572373e-02f, 1.00232653e-01f, 8.12716857e-02f,
  -1.39710873e-01f, -5.19084372e-02f, -1.09199941e-01f, -1.20596647e-01f, -5.22973612e-02f, -5.21061830e-02f, 7.55034536e-02f, 2.38786340e-02f, -1.02559309e-02f, -7.93619156e-02f,
  6.14759699e-02f, 1.56385824e-02f, -4.20692377e-02f, 8.32345188e-02f, 6.48299232e-02f, -3.69153991e-02f, -6.34588376e-02f, -9.38195288e-02f, -8.38919580e-02f, 2.80106701e-02f,
  4.98979446e-03f, -1.19966403e-01f, 5.27940877e-02f, 1.06564105e-01f, -4.91742678e-02f, -5.33705726e-02f, 1.72742307e-02f, -5.84635548e-02f, -5.75929182e-03f, -4.90501598e-02f,
  -7.63690472e-02f, -6.25796570e-03f, -4.03065532e-02f, -7.96297044e-02f, 2.31991019e-02f, 6.57855272e-02f, -4.78652604e-02f, 8.14898312e-02f, -5.88592924e-02f, -8.26420709e-02f,
  -1.09284714e-01f, 6.94063306e-02f, -2.05812603e-02f, 4.64335866e-02f, 4.77780215e-02f, -5.08269854e-03f, 2.00502947e-02f, 3.99657190e-02f, 6.83084354e-02f, 6.45929351e-02f,
  -3.68643291e-02f, -7.06300661e-02f, -3.02365683e-02f, 2.57600173e-02f, 3.23202205e-03f, 1.82205625e-02f, -6.51654378e-02f, 5.81297278e-02f, -3.68084200e-02f, 4.87932377e-02f,
  2.50859326e-03f, -6.45606890e-02f, -1.73973385e-02f, -4.34182920e-02f, -7.39067867e-02f, 6.28303885e-02f, -5.22503853e-02f, 6.54513612e-02f, 7.20411167e-02f, 3.24645340e-02f,
  4.75464985e-02f, 2.15606559e-02f, -6.54496998e-02f, -5.44532537e-02f, -3.74948457e-02f, -7.28347152e-02f, -2.45910697e-02f, -1.00839823e-01f, 5.54932058e-02f, 5.34731299e-02f,
  -4.99239750e-02f, -1.27421715e-03f, -6.34135604e-02f, -5.72201870e-02f, 8.90529342e-03f, -3.57840583e-02f, -7.43981823e-02f, -4.32973877e-02f, -1.03104836e-03f, 2.48146802e-02f,
  -5.83715923e-03f, 6.34274706e-02f, -1.00166179e-01f, -5.84224425e-02f, -4.77930158e-02f, 6.33607283e-02f, -3.81327718e-02f, -5.67607991e-02f, -1.15302764e-03f, -2.73902901e-02f,
  -4.49472945e-03f, 1.83236636e-02f, 5.44115417e-02f, 7.79212499e-03f, 2.98829880e-02f, -2.44560502e-02f, 1.02819372e-02f, -9.00145099e-02f, 5.11462465e-02f, -1.24328956e-02f,
  9.70628932e-02f, 5.34791918e-03f, -5.96764917e-03f, 7.47498497e-02f, 1.42682549e-02f, 2.31348928e-02f, 6.34769648e-02f, -6.32218495e-02f, -2.28172056e-02f, -1.28199145e-01f,
  -3.33098173e-01f, 3.56301591e-02f, -1.10650428e-01f, 1.33030444e-01f, 2.24027425e-01f, 1.26446739e-01f, 2.62982786e-01f, 2.21778393e-01f, 1.31983548e-01f, 6.83255540e-03f,
  -8.10394734e-02f, 2.20060106e-02f, -5.85694937e-03f, 3.95466276e-02f, 4.52309884e-02f, 2.11656108e-01f, 1.85662985e-01f, 3.51705737e-02f, 2.25985367e-02f, -8.36488977e-02f,
  5.61926924e-02f, 3.98650691e-02f, -2.17666835e-01f, 2.01442894e-02f, 2.14889888e-02f, -7.21417218e-02f, -8.69524628e-02f, -1.12131245e-01f, -6.76406622e-02f, 1.66942999e-01f,
  -1.80949956e-01f, -7.79607892e-02f, -1.77878309e-02f, -2.84368619e-02f, -1.05915278e-01f, -5.58538921e-02f, 5.58128953e-03f, -9.50538889e-02f, -9.65427533e-02f, 3.80803160e-02f,
  -3.21228406e-03f, 6.91698194e-02f, -6.92274934e-03f, 7.69622922e-02f, -7.07489848e-02f, -4.56592813e-02f, -7.13387728e-02f, -1.63213466e-03f, -9.09941178e-03f, 5.01546971e-02f,
  4.23054434e-02f, -9.08205509e-02f, 5.84815778e-02f, 8.99935961e-02f, 6.42459169e-02f, 6.21523708e-02f, -7.56415576e-02f, 3.43369204e-03f, -5.66782244e-02f, -3.04125678e-02f,
  -2.10936219e-02f, -8.78984015e-03f, -2.21013334e-02f, -2.50498690e-02f, -2.70972378e-03f, -3.45448926e-02f, -4.46837544e-02f, 4.19433899e-02f, 4.09195423e-02f, 2.87783183e-02f,
  -5.45962490e-02f, 1.18096387e-02f, 1.25833973e-02f, -4.63706069e-02f, -2.40600258e-02f, -2.22729556e-02f, 6.05831444e-02f, -5.22804484e-02f, -3.60310003e-02f, -1.11536197e-01f,
  3.50781344e-02f, -6.66190218e-03f, -6.10339781e-03f, 6.70051202e-02f, 3.87252420e-02f, -6.45135045e-02f, 4.88315038e-02f, -7.83337876e-02f, 1.49103021e-02f, -6.21492341e-02f,
  -7.63120428e-02f, 2.99527892e-03f, -4.95575881e-03f, 3.16722617e-02f, 1.34214967e-01f, -2.90916786e-02f, -8.87895226e-02f, -8.57147947e-02f, -6.63212407e-03f, 4.61813528e-03f,
  -4.81308438e-02f, -5.00698239e-02f, 6.06688261e-02f, 6.12917505e-02f, -5.93688525e-02f, -6.08598776e-02f, 5.70457764e-02f, 1.18732527e-01f, 4.97817509e-02f, 2.95123942e-02f,
  -2.95024794e-02f, 1.39973005e-02f, 5.49394116e-02f, -2.20949594e-02f, 1.36913985e-01f, -9.04000271e-03f, -1.21931933e-01f, 4.53704968e-03f, 9.09991264e-02f, 4.43757474e-02f,
  -1.18577972e-01f, -1.26777217e-01f, -1.05968462e-02f, -9.74072367e-02f, -7.70983323e-02f, 2.52487250e-02f, 3.05591268e-03f, 6.09646067e-02f, -3.32365893e-02f, -1.30555376e-01f,
  7.08268806e-02f, -8.46069604e-02f, -6.17210232e-02f, 7.85827488e-02f, -5.41617274e-02f, -6.50459453e-02f, -1.40258834e-01f, -1.10112894e-02f, -7.27484822e-02f, 4.32525091e-02f,
  -3.51649970e-02f, 2.88633872e-02f, -7.90129602e-03f, -3.35398763e-02f, 6.02637827e-02f, 3.98306474e-02f, -1.79736428e-02f, -5.77491447e-02f, -2.90080309e-02f, -6.78912252e-02f,
  -1.26378253e-01f, 2.00777352e-02f, 5.46774082e-03f, 9.21455547e-02f, -5.88222966e-02f, -7.22519085e-02f, 8.48313421e-02f, -2.22142097e-02f, 4.07340117e-02f, -1.46576250e-02f,
  1.65759940e-02f, -8.34192708e-03f, -5.56683540e-02f, 5.13073467e-02f, 2.51914635e-02f, 3.67585272e-02f, -1.51635678e-02f, -4.72490210e-03f, 1.47669092e-02f, -3.44366841e-02f,
  -2.29370315e-02f, -5.89727052e-02f, -4.45005763e-03f, 1.19324096e-01f, 3.40969861e-02f, 1.31559931e-02f, 1.20545188e-02f, 3.34192067e-02f, 2.84240264e-02f, 8.90628025e-02f,
  3.30150798e-02f, -2.12831050e-03f, 3.00320387e-02f, -5.53874746e-02f, -4.75291349e-02f, 8.02221969e-02f, 9.44997221e-02f, -3.01465504e-02f, -7.76530523e-03f, 6.81497669e-03f,
  4.94698212e-02f, -5.85904121e-02f, -4.47424762e-02f, -5.22812344e-02f, 8.21856111e-02f, -2.25002505e-02f, 8.75593498e-02f, -1.51070189e-02f, 9.19605866e-02f, 1.36972889e-02f,
  -5.80960251e-02f, 5.32501750e-02f, 1.64095070e-02f, 1.03274003e-01f, -3.33975293e-02f, -2.66779494e-02f, 5.54189272e-02f, -6.64695203e-02f, 2.22452432e-02f, -3.91328819e-02f,
  -1.09894827e-01f, 8.41441005e-02f, -1.18508361e-01f, 1.64432544e-02f, 6.36696666e-02f, 3.75316478e-02f, -8.65597576e-02f, -3.22413109e-02f, -4.27995436e-02f, 4.90415022e-02f,
  -3.12727429e-02f, -9.60228816e-02f, -7.29505718e-02f, -2.03763135e-02f, -8.81796330e-02f, 8.14234931e-03f, 3.38627547e-02f, 4.08957452e-02f, -1.28608253e-02f, 1.12070575e-01f,
  -3.92140225e-02f, 1.53364707e-02f, 1.97633579e-02f, -5.54680116e-02f, 1.83889978e-02f, 1.86510347e-02f, 2.15969123e-02f, 2.14438327e-02f, -1.51355639e-02f, -2.37201136e-02f,
  1.69673637e-01f, -5.99509515e-02f, 1.14243783e-01f, 1.68401957e-01f, 1.17291376e-01f, 7.22410902e-02f, 6.30575642e-02f, -1.81413684e-02f, 1.12396553e-01f, 3.92785715e-03f,
  1.06985696e-01f, 8.66450071e-02f, -2.36687716e-02f, 1.10029794e-01f, 1.16203455e-02f, -5.22579774e-02f, 7.07858801e-03f, 1.05849005e-01f, 1.21398354e-02f, 3.22532579e-02f,
  4.44567762e-02f, -1.62873939e-02f, -4.56731059e-02f, 2.03028601e-02f, 4.61295284e-02f, 4.01698239e-02f, 5.94003834e-02f, 2.31910823e-03f, -3.01431250e-02f, -6.16566651e-02f,
  2.31543817e-02f, 1.50386304e-01f, 2.84454208e-02f, 2.22685933e-02f, 2.60179094e-03f, -4.33146544e-02f, 1.04132675e-01f, -6.18768930e-02f, 2.58343425e-02f, -4.97557074e-02f,
  5.04565425e-03f, -5.24269566e-02f, -4.18836251e-02f, 6.53015450e-02f, -7.71607533e-02f, 4.82829362e-02f, 4.56846729e-02f, 9.52609330e-02f, 4.34326157e-02f, -4.37702471e-03f,
  1.43821668e-02f, -3.79191921e-03f, 3.80929071e-03f, -4.27957028e-02f, -2.44878847e-02f, -5.45017906e-02f, 6.41530231e-02f, -2.18038969e-02f, -1.32492110e-02f, -6.89338446e-02f,
  -7.88044631e-02f, 1.34282866e-02f, -4.47318796e-03f, -7.62973577e-02f, 4.11944948e-02f, 6.76677525e-02f, -2.65284535e-03f, 3.84244174e-02f, 1.05789546e-02f, -5.65797985e-02f,
  3.74227762e-02f, -5.19407205e-02f, -5.99474944e-02f, 3.78403403e-02f, -5.48413917e-02f, 2.42511015e-02f, 4.33939174e-02f, -6.05524741e-02f, -8.54883045e-02f, -6.17856160e-02f,
  -2.41923835e-02f, 6.25352859e-02f, 5.48576154e-02f, -9.65539739e-02f, 6.38950914e-02f, 8.35499093e-02f, 1.56631581e-02f, 1.32479900e-02f, -3.61747593e-02f, 2.91599929e-02f,
  -3.24038453e-02f, 5.05788997e-02f, -5.35138398e-02f, -1.08696930e-02f, -6.60629645e-02f, -1.59778651e-02f, 8.59096274e-02f, 1.76277217e-02f, -8.34634006e-02f, 5.87188378e-02f,
  -7.46744871e-03f, -4.73243706e-02f, -8.36989433e-02f, 1.83305535e-02f, 1.00486755e-01f, -6.47066534e-02f, -8.77537057e-02f, 8.36971626e-02f, 7.19704702e-02f, -1.86670776e-02f,
  1.56211965e-02f, -8.71002972e-02f, 2.15199888e-02f, -7.40404129e-02f, -5.34306280e-02f, 8.56604353e-02f, 5.73374219e-02f, 4.24129963e-02f, -8.53344053e-02f, -4.14688326e-02f,
  -1.26893654e-01f, 6.90136626e-02f, 6.22512437e-02f, 1.41009372e-02f, -1.42086316e-02f, 1.60470717e-02f, -8.25234130e-02f, -5.79660609e-02f, -4.97548608e-03f, 6.80350745e-03f,
  -3.31794173e-02f, 1.05176605e-01f, -3.39697227e-02f, 3.91960181e-02f, 1.10050648e-01f, 3.16661038e-02f, 1.35113478e-01f, 6.68662041e-02f, 1.37593895e-02f, 2.58017480e-02f,
  1.05270840e-01f, -4.27080430e-02f, -8.45996290e-02f, -2.50727404e-02f, 6.09840490e-02f, -2.96659246e-02f, -1.89394560e-02f, 5.86114526e-02f, -5.23854792e-03f, 5.82586974e-02f,
  -1.46510517e-02f, -1.14318192e-01f, 5.78361563e-02f, -6.45326376e-02f, -7.99203143e-02f, -1.43769700e-02f, 1.93731003e-02f, -4.63412851e-02f, -4.79644686e-02f, 6.17951602e-02f,
  6.48546666e-02f, -7.43944049e-02f, -2.06113644e-02f, 4.95889522e-02f, -9.59719867e-02f, 1.22698070e-02f, 3.56068648e-02f, 4.63620853e-03f, 7.35294223e-02f, 3.84217910e-02f,
  6.83403909e-02f, -1.70742963e-02f, -3.15352306e-02f, 5.12263142e-02f, 2.71106008e-02f, 2.13936437e-02f, 1.08785480e-02f, -1.08258292e-01f, -8.75716582e-02f, -9.17182118e-02f,
  -1.40020764e-03f, 2.11811122e-02f, -5.08517660e-02f, 5.50804101e-02f, -2.45794421e-03f, 5.80251925e-02f, -4.04717438e-02f, 9.42209512e-02f, -1.78782903e-02f, -4.67149951e-02f,
  -1.44215208e-02f, 1.60644967e-02f, 5.61358482e-02f, -4.73473333e-02f, -3.09789591e-02f, -3.58742028e-02f, 6.18240349e-02f, 9.47567075e-03f, 9.06242877e-02f, -3.83260883e-02f,
  -1.72693692e-02f, 5.84042110e-02f, 1.65487621e-02f, -6.72288937e-03f, 1.25868537e-03f, 5.07884920e-02f, -2.05328856e-02f, 5.64428270e-02f, 8.46165717e-02f, -3.24012944e-03f,
  -6.53643683e-02f, 9.10014883e-02f, 9.01964903e-02f, -9.38087255e-02f, 6.90192506e-02f, 6.28020018e-02f, -2.79320665e-02f, -4.82297912e-02f, 9.66948457e-03f, 2.88482122e-02f,
  -9.33705717e-02f, -3.60412039e-02f, -5.41864485e-02f, -1.80259869e-02f, -9.82719436e-02f, -1.03440516e-01f, -8.08559954e-02f, 6.25608042e-02f, -4.81389649e-02f, 1.32846572e-02f,
  4.11651209e-02f, 1.81480162e-02f, 5.28853983e-02f, -9.23457146e-02f, 4.04216386e-02f, -9.55588073e-02f, -3.91980670e-02f, -6.18337914e-02f, -1.08744308e-01f, -1.17442086e-01f,
  -1.60778031e-01f, 3.91291007e-02f, -7.83562288e-02f, 6.53729029e-03f, 7.32473359e-02f, 8.09193477e-02f, 1.34527877e-01f, 6.33959994e-02f, -3.61070111e-02f, 4.95605078e-03f,
  7.20106214e-02f, -7.89471492e-02f, -4.27597538e-02f, -1.77143160e-02f, -8.07083994e-02f, 3.92244868e-02f, -5.08789085e-02f, -5.58293536e-02f, -2.45429408e-02f, -4.61819768e-02f,
  -6.89509884e-02f, 3.37355919e-02f, 1.21835461e-02f, 2.68487330e-03f, -1.00628100e-01f, -5.43624982e-02f, -4.59220260e-02f, -3.51001658e-02f, 3.42585077e-03f, 7.03800544e-02f,
  1.87668093e-02f, -7.09175840e-02f, 4.37980182e-02f, -9.25572515e-02f, -5.55060320e-02f, -4.32004072e-02f, -3.26709412e-02f, 4.65965308e-02f, 3.93585116e-02f, 2.59672049e-02f,
  -1.36426268e-02f, -5.81059465e-03f, -4.38588038e-02f, -7.78357089e-02f, 3.46415825e-02f, -2.98806990e-05f, 3.97773832e-02f, -7.52192289e-02f, 4.47796136e-02f, 7.51201063e-03f,
  4.97956295e-03f, -1.57590006e-02f, 7.60765523e-02f, -5.41196950e-02f, 2.56144293e-02f, -3.01370583e-02f, 2.33823750e-02f, 6.96583139e-03f, -8.75291824e-02f, 3.69135402e-02f,
  -2.97450069e-02f, -2.87342863e-03f, 5.09005226e-02f, 1.76160655e-03f, -8.63917768e-02f, -7.67642707e-02f, -2.36741882e-02f, -4.96081971e-02f, -9.12236124e-02f, 2.18643136e-02f,
  -5.65227643e-02f, 3.90336197e-03f, -7.61421910e-03f, -8.18910003e-02f, -2.94738822e-02f, 3.91051285e-02f, 2.32852437e-02f, 4.63867337e-02f, -3.54760475e-02f, 7.45375976e-02f,
  -5.04906289e-02f, 8.12866390e-02f, 5.16560413e-02f, -5.26390597e-02f, -3.51452306e-02f, 5.79390004e-02f, -6.51708469e-02f, 7.84882456e-02f, 3.52535886e-03f, -4.74310517e-02f,
  -1.34844184e-01f, 5.45369387e-02f, -5.91850579e-02f, -3.93760093e-02f, -3.96682881e-02f, 7.41947442e-02f, 5.77578880e-02f, 3.78582962e-02f, -7.38904402e-02f, -7.63173252e-02f,
  -3.99179794e-02f, 9.28064622e-03f, -1.08058867e-03f, -7.68873468e-02f, -7.97896367e-03f, -4.17837948e-02f, 1.69403129e-03f, 1.83849409e-02f, 9.09790769e-02f, -8.07482749e-02f,
  5.09941466e-02f, 3.99238132e-02f, -6.82136118e-02f, 7.69251287e-02f, -7.15751350e-02f, -5.01082391e-02f, 1.32499365e-02f, 7.34653370e-03f, -5.96445836e-02f, 3.33353616e-02f,
  6.77445754e-02f, -5.73406853e-02f, -8.65681022e-02f, -3.57170380e-03f, 3.74036059e-02f, -6.81306049e-02f, 1.27271274e-02f, 3.47937755e-02f, 1.08675556e-02f, -9.82356891e-02f,
  -6.85622245e-02f, -6.81288019e-02f, -5.99134825e-02f, 3.57463732e-02f, -2.66458802e-02f, -4.24326211e-03f, 6.28973097e-02f, 7.39522055e-02f, 3.63889411e-02f, -2.51015723e-02f,
  2.94618588e-02f, 3.40654440e-02f, -2.32391283e-02f, -7.24518374e-02f, -1.36987939e-02f, -3.78196314e-02f, -4.96359989e-02f, -8.86937305e-02f, 6.09299801e-02f, 1.51505636e-03f,
  -8.05599149e-03f, -4.93208207e-02f, 6.43768758e-02f, 7.04225339e-03f, -1.31562110e-02f, -6.77255169e-02f, 2.73176245e-02f, -1.01505101e-01f, 6.85051680e-02f, -4.18973304e-02f,
  -6.51874319e-02f, 5.16142137e-02f, 7.76484832e-02f, 2.41642855e-02f, 1.34627968e-02f, 5.29414676e-02f, -2.45332215e-02f, -3.88242467e-03f, -2.05010399e-02f, -8.73737410e-02f,
  -8.39039981e-02f, -3.75298830e-03f, -1.77453011e-02f, -6.84217215e-02f, -7.55070671e-02f, -3.82379070e-03f, -3.21307257e-02f, 8.68232101e-02f, 5.69476709e-02f, -5.23741310e-03f,
  7.76334554e-02f, -2.81022098e-02f, -9.46520790e-02f, -1.56545453e-02f, -8.58523231e-03f, -1.71906166e-02f, -1.44738480e-02f, -1.11602647e-02f, -4.21144627e-03f, 9.85396132e-02f,
  -2.90140342e-02f, 5.94713446e-03f, -3.71691287e-02f, 1.55378468e-02f, -6.86713159e-02f, -9.85939335e-03f, -7.50923008e-02f, 4.00884338e-02f, -8.13390240e-02f, -6.23613931e-02f,
  4.40331288e-02f, -3.09552420e-02f, -7.35836178e-02f, 5.10468334e-02f, -3.06107569e-02f, -2.08722055e-02f, -8.80369265e-03f, 3.42411995e-02f, -7.90436566e-02f, 1.92396827e-02f,
  1.04313949e-02f, -1.91353913e-02f, 2.63598822e-02f, 4.52401750e-02f, -2.65287980e-02f, 4.73869443e-02f, -1.81182008e-02f, -7.57262995e-03f, 2.86005065e-02f, -7.18695298e-02f,
  6.30868226e-02f, -9.36689973e-02f, 1.02378819e-02f, 3.84159312e-02f, 5.57734370e-02f, 9.79285762e-02f, 3.71714011e-02f, 1.07914388e-01f, -2.71289386e-02f, 1.37526169e-03f,
  -2.44981553e-02f, 1.08966358e-01f, 9.50415805e-02f, -1.71735864e-02f, -8.26280564e-03f, 5.81414104e-02f, 2.27890592e-02f, 7.19930232e-02f, 3.84688675e-02f, -1.55908577e-02f,
  2.48762697e-01f, -1.14638567e-01f, 8.68413746e-02f, 8.56271200e-03f, 6.54862225e-02f, 9.05902982e-02f, -3.23757455e-02f, -6.63873777e-02f, 3.28024477e-02f, -5.56190982e-02f,
  8.70637968e-03f, 5.46111465e-02f, -1.64604057e-02f, 6.67027710e-03f, -6.53285310e-02f, -1.20344926e-02f, -5.80190010e-02f, 1.46559011e-02f, 4.21948880e-02f, -5.04390672e-02f,
  4.73139584e-02f, -3.23992819e-02f, 1.22225925e-01f, 1.48478327e-02f, 3.54580879e-02f, -7.81685188e-02f, -5.95906414e-02f, 3.08558606e-02f, -8.97626355e-02f, 3.42711657e-02f,
  -2.41787732e-02f, -3.11716236e-02f, 1.07075535e-01f, 7.27933049e-02f, 1.24453008e-02f, 4.86812592e-02f, 5.84606379e-02f, 7.56670013e-02f, 7.46915713e-02f, 4.53277566e-02f,
  4.37556058e-02f, -8.28393325e-02f, -7.39566758e-02f, -5.85096851e-02f, 3.08310892e-02f, 7.37296790e-02f, -4.75820675e-02f, 9.92521942e-02f, -6.10903241e-02f, -3.14164907e-02f,
  5.79851121e-02f, 2.62356887e-04f, 8.44007209e-02f, 2.00385563e-02f, 7.99748302e-02f, -6.31081732e-03f, 5.05542532e-02f, 2.57519800e-02f, 4.97728959e-02f, -2.09481064e-02f,
  -1.18478872e-02f, 1.78584899e-03f, 1.16119732e-03f, 4.36274409e-02f, -6.03398681e-03f, 7.48964846e-02f, -7.96831846e-02f, 2.11013388e-02f, 2.84385439e-02f, 1.02680363e-02f,
  6.00536652e-02f, 3.99379283e-02f, -1.19577441e-02f, -5.96208610e-02f, -4.95121889e-02f, 6.00021146e-02f, -3.14357728e-02f, 2.72877757e-02f, 3.85036059e-02f, 5.18692806e-02f,
  3.41957398e-02f, -8.12438056e-02f, -1.89376082e-02f, -4.74997982e-02f, 1.31069701e-02f, -3.82228196e-02f, -2.91800741e-02f, 3.24655622e-02f, -5.78220896e-02f, -3.67192514e-02f,
  -8.80707502e-02f, 5.72833698e-03f, -1.09890448e-02f, -5.32917790e-02f, 3.70700434e-02f, -1.96870826e-02f, -4.03634422e-02f, -5.21128206e-03f, -8.64891037e-02f, -2.39656735e-02f,
  -4.49687466e-02f, 2.53777709e-02f, -3.58923972e-02f, -9.37133059e-02f, 9.67903361e-02f, 8.75708833e-02f, -8.04445073e-02f, -1.89884640e-02f, -5.74328452e-02f, 2.43716259e-02f,
  2.85237599e-02f, 8.84868428e-02f, 8.08798820e-02f, 2.95452140e-02f, -1.00513622e-01f, -4.16035093e-02f, -5.11554144e-02f, 6.18958799e-03f, -4.82598506e-02f, 1.31585598e-02f,
  8.38580802e-02f, -5.67348637e-02f, -1.19652137e-01f, -7.40674660e-02f, 1.49107585e-02f, 2.43491703e-03f, -2.68213805e-02f, 4.63985391e-02f, -1.31804734e-01f, -9.52974483e-02f,
  -1.07496031e-01f, 7.59230405e-02f, 3.86550389e-02f, 5.76949306e-03f, 8.00182298e-02f, -1.16695235e-04f, 1.16182482e-02f, -7.06438720e-02f, 1.17790401e-01f, 5.46455644e-02f,
  -9.85725746e-02f, -8.58184397e-02f, -4.58049867e-03f, -5.77768311e-02f, -1.20172456e-01f, 3.54984924e-02f, -9.82055515e-02f, -1.29860103e-01f, -7.59653300e-02f, -4.64226343e-02f,
  -1.01613235e-02f, -7.71024004e-02f, 7.66695067e-02f, -4.89846356e-02f, 1.77566744e-02f, 7.53361136e-02f, -8.52346886e-03f, 2.18812265e-02f, -3.88413742e-02f, -4.53932919e-02f,
  -1.61178522e-02f, -1.61728058e-02f, 1.93863846e-02f, -2.03672033e-02f, -1.09141514e-01f, 8.51786509e-03f, -4.38079151e-04f, -8.81312340e-02f, 4.85126115e-02f, -1.15432050e-02f,
  -1.15390904e-01f, -5.11796400e-02f, -5.35433516e-02f, -7.83350412e-03f, -6.30160421e-02f, -5.11903055e-02f, -1.50562478e-02f, 4.89611551e-02f, 3.47646624e-02f, -1.26308158e-01f,
  4.18733954e-02f, 7.53918886e-02f, 3.67673952e-03f, 2.96236891e-02f, -5.56076281e-02f, -7.97219723e-02f, -6.65476471e-02f, -4.24713343e-02f, -5.57593703e-02f, 6.35708123e-02f,
  4.22852673e-02f, -6.42000139e-02f, 1.77336596e-02f, -5.12127504e-02f, 8.74880925e-02f, -6.37627319e-02f, -7.04727694e-03f, 7.66995251e-02f, -5.07680997e-02f, 5.76557033e-02f,
  -4.89083007e-02f, 9.23305452e-02f, -6.30829763e-03f, 7.20728114e-02f, 2.17565112e-02f, 1.68818664e-02f, -7.54655376e-02f, 9.79447290e-02f, -7.13882297e-02f, 1.15905777e-02f,
  6.30026907e-02f, 1.77164394e-02f, 2.87594981e-02f, -3.26974615e-02f, 4.93815877e-02f, -7.04971999e-02f, -7.79658481e-02f, 4.22055647e-02f, -6.52743578e-02f, -9.10478681e-02f,
  8.37094635e-02f, 3.46611813e-02f, -1.14543037e-02f, 2.10049897e-02f, 6.03630617e-02f, -7.42703527e-02f, -9.32566002e-02f, 3.66516151e-02f, -6.13833927e-02f, -9.36939865e-02f,
  -1.80326477e-02f, 1.02912504e-02f, 1.26664704e-02f, 6.21084906e-02f, 3.94957922e-02f, 9.47738588e-02f, 6.89058155e-02f, -6.96273595e-02f, -4.91735041e-02f, 2.34173816e-02f,
  -1.34282574e-01f, -7.34995008e-02f, -1.11734137e-01f, -2.56455503e-02f, 1.24073564e-03f, 1.36400416e-01f, 7.61946514e-02f, -1.25798965e-02f, 2.46400293e-02f, 7.55786598e-02f,
  -6.39491975e-02f, 3.11067570e-02f, -3.04238219e-02f, 3.93795744e-02f, -1.23159453e-01f, -5.99198916e-04f, -1.04703970e-01f, -5.55494465e-02f, -7.79308826e-02f, -2.69195233e-02f,
  -6.00304306e-02f, -5.75805493e-02f, -1.19359843e-01f, -7.25569110e-03f, -3.67973782e-02f, -7.72962272e-02f, -1.44703373e-01f, 9.34434962e-03f, -6.53053373e-02f, -9.27281454e-02f,
  4.66781622e-03f, 6.45965189e-02f, 3.14479619e-02f, -1.04746111e-01f, 8.57374743e-02f, 3.22022252e-02f, 8.73502344e-02f, -9.08357874e-02f, -1.51620954e-02f, 8.94043297e-02f,
  2.31158454e-02f, 1.25395924e-01f, 4.57400503e-03f, -2.94406712e-02f, -2.25651357e-02f, 2.20003501e-02f, -2.71685645e-02f, 1.74692664e-02f, 7.72201270e-02f, 1.20926589e-01f,
  9.33145061e-02f, -6.48095980e-02f, -9.05366242e-02f, -3.53771038e-02f, -8.50680098e-02f, -1.25250623e-01f, -8.67760926e-02f, -7.32844993e-02f, 7.32699502e-03f, -1.27704486e-01f,
  4.88624386e-02f, 7.64603913e-02f, -7.83310831e-02f, 3.81216332e-02f, -3.14724557e-02f, -4.17645760e-02f, 2.22933833e-02f, -4.56657410e-02f, 2.06850544e-02f, 8.74859281e-03f,
  -2.45721675e-02f, 9.64911431e-02f, 1.03109442e-01f, -8.00454170e-02f, -2.98281061e-03f, -9.12330747e-02f, -2.85455901e-02f, -1.18296862e-01f, -1.81108192e-02f, 4.32027504e-02f,
  -1.73432063e-02f, 2.59088445e-03f, -5.57919033e-02f, 3.07808863e-03f, -1.28995031e-01f, -1.08081833e-01f, -2.70228777e-02f, 2.43277475e-02f, -2.40144953e-02f, -3.00997775e-02f,
  -2.55819727e-02f, -3.53620760e-02f, -7.34638125e-02f, -2.98875496e-02f, 7.54138753e-02f, 8.65349993e-02f, 5.54611981e-02f, -8.51146579e-02f, -2.23881584e-02f, -5.97777180e-02f,
  1.41651761e-02f, -3.56551297e-02f, -1.37217315e-02f, 1.12690747e-01f, 1.82472244e-02f, 3.84793095e-02f, 5.99873392e-03f, -1.34027839e-01f, 3.62415388e-02f, 7.29896277e-02f,
  -2.61466745e-02f, -5.41329049e-02f, -1.00857085e-02f, 1.55402096e-02f, -6.93706423e-02f, -5.50057460e-03f, -6.95656762e-02f, -1.15638651e-01f, -1.48811772e-01f, -1.97912902e-01f,
  -3.39574814e-01f, -6.57885196e-03f, -9.77832898e-02f, -1.21429585e-01f, -1.11553341e-01f, 7.34311417e-02f, 4.19233628e-02f, 1.77026778e-01f, 2.73121614e-02f, -9.08594057e-02f,
  -4.25264761e-02f, -6.40333444e-02f, -1.09837791e-02f, -4.69982401e-02f, -1.27254143e-01f, -1.20926373e-01f, -6.05188757e-02f, -2.27711186e-01f, -1.53267473e-01f, 3.27386968e-02f,
  -4.92452160e-02f, -1.53139994e-01f, -1.38649523e-01f, 7.55949169e-02f, -2.33214125e-02f, -7.04969689e-02f, -6.73584789e-02f, -7.68128112e-02f, -8.65794420e-02f, -7.34458566e-02f,
  -1.51719168e-01f, 1.28514757e-02f, 2.51393057e-02f, -9.54029858e-02f, -5.95193096e-02f, 4.25633788e-02f, 3.18813208e-03f, -1.04212850e-01f, -9.82492045e-03f, 3.89638618e-02f,
  -1.82174426e-02f, -9.19281226e-03f, 2.64292601e-02f, 4.13416512e-02f, -5.77601083e-02f, -3.68000455e-02f, -1.02163097e-02f, -6.04954548e-02f, -8.45269784e-02f, 6.47606701e-02f,
  3.72929312e-02f, 1.70179252e-02f, 5.21422066e-02f, 1.51641220e-01f, 1.06942542e-01f, 4.20368128e-02f, 5.95417581e-02f, 4.56578396e-02f, 5.34461550e-02f, -3.61389257e-02f,
  7.29892496e-03f, 1.79169662e-02f, 5.98302484e-02f, -8.43637623e-03f, 2.37208325e-02f, 6.08244678e-03f, -5.40308394e-02f, -6.72540292e-02f, -9.14004594e-02f, 1.19142486e-02f,
  8.96706432e-02f, 2.90476792e-02f, -4.98531125e-02f, -6.40674904e-02f, 1.97495543e-03f, -2.62624957e-02f, -8.71042460e-02f, -7.42170364e-02f, 3.97332795e-02f, 7.23570734e-02f,
  -2.61043794e-02f, 5.86841814e-02f, -1.83216296e-02f, 7.68669918e-02f, 2.33738925e-02f, -4.89878282e-02f, -7.51126930e-02f, -8.74147043e-02f, -8.72253999e-02f, -1.42149076e-01f,
  -5.77277355e-02f, -8.98303092e-02f, -8.70770663e-02f, 1.60688255e-02f, -7.76188122e-03f, 1.19990446e-01f, -3.14898416e-02f, -5.40033095e-02f, 2.45992709e-02f, 7.71534592e-02f,
  4.39271778e-02f, 4.19379771e-02f, 5.32629900e-02f, 1.24085762e-01f, 8.46429765e-02f, 3.16289924e-02f, -3.06529645e-02f, -2.00429559e-03f, 6.21017776e-02f, 9.01421085e-02f,
  4.68580164e-02f, 3.10204215e-02f, -7.73873851e-02f, 6.70122355e-02f, 8.51599574e-02f, -7.22002760e-02f, -9.45000648e-02f, 1.76761113e-02f, -1.26187131e-01f, -1.87952623e-01f,
  -4.85611893e-02f, -4.06859785e-01f, 7.93028176e-02f, 4.34180200e-01f, 4.40461040e-01f, 4.15568620e-01f, 3.18466097e-01f, 1.76917940e-01f, 3.06025475e-01f, 5.14113754e-02f,
  -8.84370655e-02f, 1.92485396e-02f, 9.77098942e-03f, -9.29778162e-03f, -1.17729500e-01f, 1.50755078e-01f, 1.59943283e-01f, 2.74555385e-02f, 2.43077368e-01f, 1.27490625e-01f,
  9.38181952e-02f, 3.22991051e-02f, -1.19947724e-01f, -5.28199039e-02f, 3.92425768e-02f, 1.43495932e-01f, 5.12477905e-02f, -9.72301960e-02f, -1.02165133e-01f, -6.00362085e-02f,
  -3.16022933e-01f, -5.96719757e-02f, 1.31042302e-01f, -1.04117535e-01f, -9.91480500e-02f, -4.33512963e-02f, -9.80963260e-02f, -6.62657917e-02f, -1.55905755e-02f, 1.31597184e-02f,
  3.93079920e-03f, -1.31843314e-01f, 1.06595263e-01f, -4.94533256e-02f, -4.42919694e-02f, 3.24421003e-02f, -1.16644509e-01f, -1.72475688e-02f, -5.80184422e-02f, -1.32487446e-01f,
  -4.76629026e-02f, -5.99211082e-03f, 1.01943493e-01f, 1.00648478e-01f, 1.45420253e-01f, -6.81748381e-03f, -2.57344656e-02f, -3.34231295e-02f, 6.19991496e-02f, -1.34783179e-01f,
  3.55025455e-02f, 1.98179521e-02f, 2.39541791e-02f, -3.46352346e-02f, 4.50573862e-03f, 4.68159840e-02f, 3.77150252e-02f, -7.48489350e-02f, -1.03638330e-02f, -5.22099920e-02f,
  2.87677459e-02f, 3.34333517e-02f, 5.86627498e-02f, 2.49766000e-03f, -8.38392302e-02f, 3.42390127e-03f, 8.83427486e-02f, -1.54632470e-02f, -6.71275929e-02f, 7.98836723e-03f,
  -3.71172912e-02f, 7.86087885e-02f, 4.30677906e-02f, -1.33361469e-03f, -1.60949156e-02f, 1.16702244e-01f, -6.00083657e-02f, -6.92187995e-02f, 1.17665129e-02f, 2.55559627e-02f,
  -1.80637121e-01f, 2.84817107e-02f, 7.01784864e-02f, -1.07216746e-01f, 1.19037658e-01f, -9.29700509e-02f, 8.80672410e-03f, -5.35033420e-02f, -9.31967422e-03f, -4.04935628e-02f,
  -1.71629488e-02f, -1.12923933e-02f, -1.13760456e-01f, -6.08417951e-02f, 8.43831450e-02f, 8.98147076e-02f, 2.25923676e-02f, 1.47019386e-01f, 3.87023948e-02f, -6.65149242e-02f,
  -5.79845859e-03f, 1.32688597e-01f, 1.48660839e-01f, 1.59462571e-01f, 5.85194379e-02f, 1.62201658e-01f, 2.82830056e-02f, 1.65969297e-01f, 6.62009045e-02f, 9.93171334e-02f,
  -3.61529797e-01f, 8.07967316e-03f, -2.19282880e-02f, -1.29236197e-02f, 6.96295574e-02f, 7.97825232e-02f, 5.70025668e-02f, -5.91364428e-02f, -9.97386500e-03f, 2.37994157e-02f,
  3.91818509e-02f, -9.20266882e-02f, 2.84521841e-02f, 2.85958219e-02f, -1.12430297e-01f, -9.86938700e-02f, -4.61837351e-02f, -2.10415751e-01f, -6.34756014e-02f, -1.69146005e-02f,
  -5.55257984e-02f, -2.29212373e-01f, -2.06150174e-01f, -1.30089521e-01f, -2.34797839e-02f, 7.06046298e-02f, -2.01911293e-02f, -9.99943838e-02f, 4.21003588e-02f, 9.73807648e-02f,
  1.03795998e-01f, 5.77835329e-02f, 7.51859322e-02f, -1.33741796e-02f, -3.55793722e-02f, 9.94843524e-03f, -3.05197127e-02f, -1.05301440e-01f, 1.77488402e-02f, 4.83817123e-02f,
  -1.76030006e-02f, 2.44701058e-02f, -1.68689843e-02f, -7.38060176e-02f, 1.91985834e-02f, 2.47221850e-02f, -1.02824271e-01f, -1.78539485e-01f, 3.36631238e-02f, 6.60268143e-02f,
  2.18803138e-02f, -4.70496714e-02f, -1.14007369e-01f, 9.38992668e-03f, -4.78172256e-03f, 1.36653585e-02f, 7.21353740e-02f, 2.25475039e-02f, 5.03710359e-02f, 1.76505372e-02f,
  2.50838660e-02f, 5.90991080e-02f, 2.30089808e-03f, 9.94369760e-03f, 7.61259943e-02f, -5.88728972e-02f, -7.67493844e-02f, -7.30706900e-02f, 3.61162797e-02f, -9.30316448e-02f,
  -3.43631580e-02f, 4.14498179e-04f, 6.21326603e-02f, 3.98574397e-02f, -5.77376224e-02f, -3.55116911e-02f, 8.36827382e-02f, 6.91473037e-02f, 4.27381061e-02f, 3.97555679e-02f,
  2.06905231e-03f, -4.29546759e-02f, 6.40167519e-02f, 1.92993730e-02f, 8.04835111e-02f, 1.25304684e-01f, 3.37261967e-02f, -7.78789893e-02f, 4.48896140e-02f, 1.22640980e-02f,
  -9.50077102e-02f, -2.51121558e-02f, 5.08326441e-02f, -3.94517183e-02f, 2.45515574e-02f, 8.40123668e-02f, -5.99086797e-03f, 5.10446951e-02f, -2.38337796e-02f, -1.22731276e-01f,
  2.49280483e-02f, -1.46766692e-01f, -3.67186181e-02f, -2.82265600e-02f, -1.20520964e-01f, -9.52431634e-02f, -1.31588474e-01f, -2.63574496e-02f, 3.28935008e-03f, 5.41172475e-02f,
  -6.45090416e-02f, -1.33599453e-02f, -5.35847172e-02f, -1.95762478e-02f, 4.35699150e-02f, -1.52791888e-01f, -1.16453551e-01f, -4.10525426e-02f, -8.15439522e-02f, -2.11896569e-01f,
  -4.00814340e-02f, -1.70990676e-01f, -2.70447414e-02f, -7.19623491e-02f, 7.08206594e-02f, 1.31227821e-01f, 1.06072456e-01f, -7.66087174e-02f, 9.12731700e-03f, -2.28719171e-02f,
  -7.95828775e-02f, -7.75137246e-02f, 4.24982943e-02f, 4.88712220e-04f, 5.95063008e-02f, -3.48588303e-02f, 4.30503525e-02f, -3.35309766e-02f, 7.15005621e-02f, 1.04866371e-01f,
  -6.33724630e-02f, -7.83161148e-02f, -8.70488435e-02f, -1.12887904e-01f, 1.51689677e-02f, -5.82721755e-02f, 3.19868736e-02f, -1.16928622e-01f, 3.81974503e-02f, -8.85585845e-02f,
  1.58485278e-01f, -9.88875329e-02f, 2.94050835e-02f, 1.43603124e-02f, -7.35171810e-02f, -2.93281693e-02f, 1.10423202e-02f, -6.48507625e-02f, -8.53174776e-02f, -1.13710118e-02f,
  1.27256624e-02f, -8.46686214e-03f, -8.00766349e-02f, 4.48090509e-02f, -5.32624982e-02f, 3.38068162e-03f, -1.20368287e-01f, -5.85106798e-02f, -9.63492915e-02f, 2.05902755e-03f,
  -6.48263171e-02f, 3.00685987e-02f, -7.65781701e-02f, 6.56655133e-02f, 7.02681094e-02f, -1.00419395e-01f, 3.90682481e-02f, -6.86898604e-02f, -2.84370277e-02f, 1.04351016e-03f,
  1.32126063e-02f, -8.01384971e-02f, -2.19980683e-02f, 2.13984288e-02f, 6.91907015e-03f, -3.76541875e-02f, 2.66383253e-02f, 6.74732178e-02f, 6.11121356e-02f, 2.92175673e-02f,
  -9.05441307e-03f, 3.42126749e-02f, 1.22942552e-02f, 4.09872457e-02f, -3.03267669e-02f, -8.94136727e-02f, -1.41663023e-03f, 5.83540164e-02f, -6.73939055e-03f, 4.76215854e-02f,
  2.85493974e-02f, -3.76671776e-02f, -6.40850365e-02f, 1.16525861e-02f, -9.75619182e-02f, -2.33640745e-02f, -3.32340635e-02f, -5.39432913e-02f, -3.58549654e-02f, 6.19816929e-02f,
  -3.78545225e-02f, -9.09183994e-02f, 5.38438000e-02f, 2.06278861e-02f, -7.21647292e-02f, -1.86772570e-02f, -7.21550584e-02f, 4.02593873e-02f, -1.16022481e-02f, 1.38980106e-01f,
  4.64504026e-02f, -4.49177101e-02f, -2.44060475e-02f, 2.98680626e-02f, 1.07474113e-02f, 8.15981850e-02f, -9.47773233e-02f, -4.04241774e-03f, 5.16963191e-05f, -1.23231928e-03f,
  -6.69703782e-02f, 1.25976458e-01f, 1.19506143e-01f, 2.99867280e-02f, -1.88756995e-02f, 1.36038080e-01f, 3.89588028e-02f, 3.84998769e-02f, 6.19581230e-02f, 8.80762413e-02f,
  -1.37627736e-01f, 1.43248618e-01f, -2.42151752e-01f, 1.30736530e-01f, 9.89622027e-02f, -6.03555255e-02f, -1.09676920e-01f, -1.95375025e-01f, 2.38159653e-02f, 3.99870239e-02f,
  -7.68510532e-03f, 1.87774226e-01f, -2.11759787e-02f, -1.47493277e-02f, -1.32114381e-01f, 9.95508954e-02f, 8.72939378e-02f, 1.19412886e-02f, -1.02748878e-01f, -2.51829457e-02f,
  6.30857348e-02f, -3.46674137e-02f, -1.65697083e-01f, -9.89941955e-02f, 1.07658848e-01f, 4.95370887e-02f, 2.69919857e-02f, -4.16032672e-02f, 7.67508075e-02f, 2.54510164e-01f,
  6.82974607e-02f, -5.98544627e-02f, 4.48482409e-02f, 9.01562870e-02f, -2.68339738e-02f, -4.59695905e-02f, 1.67831816e-02f, -4.10197228e-02f, 2.94807758e-02f, -5.52144870e-02f,
  9.61790159e-02f, 4.87030135e-04f, 3.92645076e-02f, 8.51368252e-03f, -6.91610500e-02f, -1.50485225e-02f, -3.36142965e-02f, -9.55282077e-02f, -1.05153456e-01f, -7.48531371e-02f,
  1.12245321e-01f, 1.84106901e-02f, -6.42870888e-02f, -9.07698944e-02f, -1.29513592e-01f, 6.56237528e-02f, 2.64706812e-03f, 5.56912832e-03f, -2.12239549e-01f, -7.72663811e-03f,
  -3.95121761e-02f, 1.51998000e-02f, 6.01344258e-02f, 6.64908513e-02f, 2.98099294e-02f, 1.77295017e-03f, -1.03842840e-03f, -3.94091234e-02f, 2.76757847e-03f, 4.50785272e-02f,
  2.89790668e-02f, 1.97559386e-03f, -6.81999847e-02f, -4.81832065e-02f, -3.39900516e-02f, -1.06321976e-01f, 5.41896699e-03f, 9.35486481e-02f, -7.52998814e-02f, 2.19629444e-02f,
  -8.00105706e-02f, 2.37351935e-02f, 1.29864635e-02f, -1.97635219e-02f, 3.64876762e-02f, -8.22662115e-02f, 4.93111238e-02f, 3.88338952e-03f, -8.34816769e-02f, -7.39026666e-02f,
  3.21946032e-02f, -1.83376670e-02f, 5.94670735e-02f, 8.07574242e-02f, -7.50916600e-02f, 6.10909872e-02f, 3.16255018e-02f, -4.13271263e-02f, 1.41662527e-02f, -2.06117183e-02f,
  -2.74824277e-02f, 2.51228698e-02f, 7.56167173e-02f, -4.42632996e-02f, -8.19066912e-02f, -6.46073148e-02f, -2.95575429e-02f, 4.29352559e-02f, 2.27121022e-02f, -1.15053073e-01f,
  3.43916379e-02f, -5.96441701e-02f, -1.13108024e-01f, 6.30934397e-03f, -3.38112749e-02f, 4.09253500e-03f, -1.25228018e-01f, -3.96317691e-02f, -2.06257358e-01f, -1.16617516e-01f,
  -2.75277317e-01f, -1.15820348e-01f, -1.71428666e-01f, -2.88776532e-02f, -8.41116812e-03f, 7.65765607e-02f, 6.86056167e-03f, 1.23894110e-01f, 6.71881363e-02f, -3.07767037e-02f,
  -1.04781896e-01f, -1.75965466e-02f, -6.83665723e-02f, 3.43276374e-02f, -3.63359717e-03f, -1.14387363e-01f, -2.25108918e-02f, -1.13293231e-01f, 8.87676403e-02f, 4.91658859e-02f,
  6.29638284e-02f, -5.13788275e-02f, -1.58682801e-02f, 4.29759920e-02f, 5.79501912e-02f, 3.17700095e-02f, -7.20187724e-02f, -8.22059065e-02f, -1.57562830e-02f, -1.07716389e-01f,
  -1.76653918e-03f, -4.81261946e-02f, 8.81804228e-02f, -7.04695880e-02f, -6.79888297e-03f, -4.15234752e-02f, 2.03854754e-03f, -1.09739184e-01f, 4.84037213e-02f, 2.38022320e-02f,
  5.67634292e-02f, 3.06902789e-02f, -5.84873222e-02f, 2.00470239e-02f, 6.29216135e-02f, 6.36531264e-02f, 4.56185341e-02f, 5.41885057e-03f, 4.43112329e-02f, -2.65695564e-02f,
  -1.46158170e-02f, 3.44111547e-02f, 2.15649381e-02f, 1.04711764e-01f, 9.53270048e-02f, -2.16529369e-02f, 5.24112210e-02f, 6.77542388e-02f, -5.34254387e-02f, -5.93231581e-02f,
  1.27166584e-01f, 5.62177040e-02f, 5.18902279e-02f, 1.05657078e-01f, -1.69703197e-02f, -5.14682233e-02f, 2.82116532e-02f, -7.17796162e-02f, 1.39652519e-02f, -5.79550900e-02f,
  -6.69817030e-02f, -2.67502330e-02f, 5.30346744e-02f, 5.84045202e-02f, -5.15288413e-02f, -1.26236398e-02f, -7.16935694e-02f, -3.17874737e-02f, -3.75422724e-02f, -4.96105924e-02f,
  6.48307055e-02f, 9.33712050e-02f, -5.89270107e-02f, 1.39604494e-01f, -6.57614619e-02f, 1.39591489e-02f, 6.09076247e-02f, 5.93582913e-03f, -5.14942296e-02f, 8.37540850e-02f,
  -5.09460568e-02f, -5.18138669e-02f, 5.32825328e-02f, 1.49379335e-02f, -9.31513682e-02f, 1.42500165e-03f, -3.73591483e-02f, 1.04470225e-02f, 8.56500715e-02f, 3.68307158e-02f,
  2.47963648e-02f, 1.04359556e-02f, 6.15017153e-02f, 3.06198169e-02f, 5.00427857e-02f, 1.78159715e-03f, -8.69540721e-02f, 8.30902904e-03f, 7.94671252e-02f, 6.06266335e-02f,
  3.46321464e-02f, -2.83200424e-02f, 2.70716939e-02f, -6.22469001e-03f, 5.95344007e-02f, -7.48603269e-02f, 9.41238739e-03f, -4.89950106e-02f, -4.24998999e-02f, -1.26466885e-01f,
  -3.62689972e-01f, -4.53528538e-02f, 5.54012023e-02f, -2.14165911e-01f, -1.30041530e-02f, -5.89018129e-02f, 8.91851038e-02f, -1.13998108e-01f, -1.55356929e-01f, -9.21842530e-02f,
  -1.52150709e-02f, 6.90046400e-02f, 5.26522994e-02f, -2.15996560e-02f, 1.16129793e-01f, 1.15563884e-01f, -3.77647788e-03f, -6.25917315e-02f, -5.25226407e-02f, -4.52454723e-02f,
  -1.40469884e-02f, -1.55775711e-01f, -1.91270992e-01f, -1.20618217e-01f, -1.60520196e-01f, -3.39233950e-02f, -5.65469451e-02f, -7.02343658e-02f, 4.66749333e-02f, -3.61703970e-02f,
  2.44136229e-01f, -1.07912362e-01f, -3.53884622e-02f, -9.59772468e-02f, 2.49864943e-02f, -5.22368290e-02f, -7.44817704e-02f, -9.15789381e-02f, 2.39957832e-02f, 1.12651680e-02f,
  -5.80818057e-02f, 4.29399163e-02f, -6.14601523e-02f, 2.03780252e-02f, -7.24646151e-02f, -5.87275922e-02f, -2.75060181e-02f, -1.25842705e-01f, 1.88102853e-02f, -1.33207552e-02f,
  8.02606493e-02f, -2.80684587e-02f, -4.41591628e-02f, -6.57697171e-02f, 4.32256721e-02f, 5.50736766e-03f, 6.21114708e-02f, 4.41516889e-03f, -3.14731002e-02f, 3.13803256e-02f,
  -3.65922153e-02f, -1.91190783e-02f, 2.99678929e-02f, 2.04615202e-02f, -8.33570808e-02f, 7.99570084e-02f, 1.03551991e-01f, 7.90531859e-02f, -6.11130893e-03f, -1.52563937e-02f,
  4.94196005e-02f, 4.07393016e-02f, 9.72632915e-02f, -6.55571595e-02f, 8.35860819e-02f, -4.01246212e-02f, -3.82965095e-02f, 3.13705355e-02f, -5.38582653e-02f, -8.98087472e-02f,
  1.67187471e-02f, 3.77451722e-03f, 3.35117914e-02f, 9.01900455e-02f, -2.31535863e-02f, -6.97236136e-02f, 1.24773895e-02f, -9.09442315e-04f, -3.12912799e-02f, 1.06757497e-02f,
  4.79624048e-02f, 9.41443145e-02f, 8.49975199e-02f, -8.12223479e-02f, 6.38873875e-02f, 2.51729600e-02f, 2.90016402e-02f, 1.96404220e-03f, -4.80543599e-02f, 2.50045955e-03f,
  4.26915195e-03f, 6.04739003e-02f, 6.42117336e-02f, 4.12323773e-02f, 1.51190383e-03f, 2.48455051e-02f, -8.93696621e-02f, 5.19730002e-02f, 2.01866589e-02f, 5.78238405e-02f,
  5.66163100e-02f, 5.29254600e-02f, 3.30947265e-02f, -1.80335492e-02f, -3.08985990e-02f, 9.12689492e-02f, 1.64490342e-01f, 5.15697859e-02f, 1.22523564e-03f, 5.04772551e-02f,
  -5.99833801e-02f, -3.37867066e-02f, -6.97520599e-02f, -1.04082726e-01f, 6.25653267e-02f, 4.47301939e-02f, -6.29307106e-02f, 5.48668653e-02f, 6.23318776e-02f, -5.77524677e-02f,
  -3.73588293e-03f, 7.58732343e-03f, -2.90379934e-02f, 2.68084630e-02f, -5.62581196e-02f, 7.61946198e-03f, 1.11464616e-02f, 3.50031815e-02f, -3.07932869e-02f, 5.02238199e-02f,
  1.02541678e-01f, -7.73273855e-02f, -2.23777536e-02f, 5.01846187e-02f, -5.31056412e-02f, -6.62944391e-02f, -8.68264884e-02f, -4.44301255e-02f, 5.92215657e-02f, -5.13528772e-02f,
  -1.55856684e-02f, -2.04760041e-02f, -4.10613185e-03f, -8.16759001e-03f, -5.25684953e-02f, -3.32626025e-03f, 8.36626291e-02f, 4.84045371e-02f, 2.14414503e-02f, -3.59293036e-02f,
  -6.58480078e-02f, -5.69705814e-02f, 6.04265486e-04f, 4.79090996e-02f, 6.72865510e-02f, -1.50323436e-02f, 5.38664721e-02f, 6.18086159e-02f, 1.92679316e-02f, -1.46028409e-02f,
  -3.08026373e-03f, 7.10297748e-02f, 7.45608658e-02f, -2.88919061e-02f, -1.37676625e-02f, 1.09425504e-02f, 2.13751122e-02f, -4.64595854e-02f, 5.86906858e-02f, 4.13240790e-02f,
  1.15729801e-01f, 1.68003887e-02f, -6.34167120e-02f, -7.00703487e-02f, 7.82465339e-02f, -6.58804104e-02f, 1.10565670e-01f, 3.95828895e-02f, 4.84886281e-02f, -4.24766988e-02f,
  1.31811425e-02f, 5.60107082e-02f, 2.64581107e-02f, 8.21779370e-02f, 7.63476193e-02f, -7.06862286e-02f, 7.86872208e-02f, 3.99283171e-02f, -7.75757506e-02f, 7.80868083e-02f,
  -4.57768328e-02f, 1.99828018e-02f, 9.01838094e-02f, -4.31507155e-02f, 5.42286374e-02f, -5.45862913e-02f, 8.33073556e-02f, 1.01303935e-01f, 1.13362685e-01f, -2.57267058e-02f,
  -1.05679043e-01f, 5.75417839e-02f, -1.75846629e-02f, 7.55365342e-02f, -3.38971429e-02f, 8.56221169e-02f, 6.23774938e-02f, 1.95116512e-02f, 4.67427634e-02f, -5.36059588e-02f,
  2.35187598e-02f, 6.59164786e-02f, 3.01994216e-02f, -6.46135956e-02f, -9.30825099e-02f, 7.68267736e-02f, -2.31420286e-02f, -1.10056521e-02f, -2.54962910e-02f, -7.09781945e-02f,
  -6.34739250e-02f, -8.31652731e-02f, 7.34159499e-02f, -2.13494506e-02f, 3.47597562e-02f, 3.40089910e-02f, 4.09289189e-02f, -1.07006403e-03f, -3.32790688e-02f, -1.77291334e-02f,
  -2.17747897e-01f, -1.15878619e-01f, -1.62933975e-01f, -1.85298115e-01f, -1.16531469e-01f, 1.99258104e-02f, 7.91772678e-02f, 6.41412511e-02f, -3.01341321e-02f, -1.10904053e-01f,
  -2.45491434e-02f, -8.78317133e-02f, 3.11615039e-02f, 5.30656949e-02f, -3.61776687e-02f, -3.47545035e-02f, -1.16227251e-02f, -1.55824125e-01f, -5.08503756e-03f, 7.56818727e-02f,
  -8.46472457e-02f, -1.48532644e-01f, -1.24410257e-01f, -3.79480645e-02f, 1.11119645e-02f, 7.20849112e-02f, 1.77105963e-02f, -9.71733630e-02f, 1.10839128e-01f, -1.43892184e-01f,
  -7.20891729e-02f, -5.48560247e-02f, -1.10647552e-01f, -5.52642308e-02f, -6.70197457e-02f, -9.05828625e-02f, -3.15654390e-02f, 8.51698424e-05f, 2.79998370e-02f, -9.50893462e-02f,
  -6.55396953e-02f, 8.48364532e-02f, -1.22605907e-02f, -2.05063540e-02f, 1.69151258e-02f, 5.50329387e-02f, 7.10724294e-02f, -1.20082706e-01f, -7.76679069e-02f, 6.58431873e-02f,
  3.68020423e-02f, -7.02965483e-02f, 3.22619900e-02f, 4.26183753e-02f, 8.47620219e-02f, -8.21066871e-02f, -2.94110123e-02f, 1.20761216e-01f, 3.52891535e-02f, 1.17419008e-02f,
  4.09810878e-02f, -7.66556384e-03f, 4.66810130e-02f, -2.13461369e-02f, -6.25181496e-02f, 1.21140696e-01f, 6.57939017e-02f, 4.45497446e-02f, 6.04499653e-02f, 2.52866212e-05f,
  8.74120221e-02f, -8.46060291e-02f, -1.28135150e-02f, 7.97871202e-02f, -8.51134136e-02f, 3.78908888e-02f, 5.28246462e-02f, 3.01539563e-02f, -6.16366006e-02f, -7.88419396e-02f,
  7.40647987e-02f, -7.63836363e-03f, -5.16754873e-02f, -4.15972099e-02f, 7.85190985e-02f, -5.42073697e-02f, 9.32505280e-02f, 1.01988420e-01f, -4.46352996e-02f, 9.66759622e-02f,
  -1.08235605e-01f, -7.06205610e-03f, -4.26798090e-02f, -4.59563881e-02f, 4.21585254e-02f, -1.46830175e-02f, 6.01917803e-02f, 8.07831362e-02f, -5.22961169e-02f, -1.10795714e-01f,
  -2.28476189e-02f, -2.14392114e-02f, -9.44724306e-02f, -6.14978448e-02f, 6.17773868e-02f, -3.12609524e-02f, -8.99025276e-02f, -1.23077758e-01f, -1.03018349e-02f, -4.81568277e-02f,
  6.14307262e-02f, -3.91831510e-02f, 1.14935655e-02f, -3.57265696e-02f, 6.45759106e-02f, -6.42649829e-02f, -3.16464552e-03f, -4.55782376e-02f, -8.66312906e-03f, -3.05590592e-02f,
  -8.25183187e-03f, 1.45746991e-01f, -1.10300565e-02f, -7.88482279e-02f, -1.88606810e-02f, -6.78237304e-02f, -1.24418817e-01f, -3.10629252e-02f, -2.58713886e-02f, 1.14869513e-01f,
  6.50784373e-02f, 8.24603345e-03f, -3.36994901e-02f, 4.82039154e-02f, 5.12323789e-02f, 5.16615063e-02f, -4.40778732e-02f, -5.86684272e-02f, -4.60121408e-02f, -1.62003506e-02f,
  1.17980652e-02f, -1.79121606e-02f, -5.23980856e-02f, -5.88021465e-02f, 1.04122885e-01f, -6.00513443e-02f, -4.26990492e-03f, 4.01290730e-02f, -2.06661923e-03f, 1.06519207e-01f,
  -3.06708496e-02f, 3.92702073e-02f, -1.81609504e-02f, 2.02331729e-02f, 5.05616702e-02f, 7.70592839e-02f, -5.23605831e-02f, -6.03218004e-02f, -8.28982443e-02f, 8.07040408e-02f,
  -1.57115683e-02f, -5.26614748e-02f, -4.55344804e-02f, -8.13134462e-02f, 1.06157705e-01f, 1.01045169e-01f, 5.36702983e-02f, -5.20837344e-02f, 5.54112606e-02f, 6.96547329e-02f,
  4.60178703e-02f, 8.14492851e-02f, -2.61804406e-02f, 4.88113351e-02f, -1.94999892e-02f, 1.79559570e-02f, 5.19519206e-03f, -1.79861486e-02f, -8.42066333e-02f, -7.74803944e-03f,
  2.51835622e-02f, -4.34821472e-02f, -7.90550262e-02f, -5.62259071e-02f, 2.57897805e-02f, 2.42901538e-02f, 1.53015461e-02f, -6.00605495e-02f, 3.68363187e-02f, 1.37926629e-02f,
  -1.97852161e-02f, 6.61866441e-02f, -7.32599720e-02f, -7.70896534e-03f, 8.81908983e-02f, 1.55936545e-02f, -5.22132926e-02f, -7.96678811e-02f, -3.79137509e-02f, 3.76587212e-02f,
  -4.84509207e-02f, -4.92275022e-02f, 2.25654384e-03f, 4.42781970e-02f, 7.81326592e-02f, 1.83679741e-02f, 5.01780249e-02f, 9.34421495e-02f, -6.89565688e-02f, -9.02921893e-03f,
  -3.06381006e-02f, -2.17196811e-02f, 7.05159605e-02f, 3.85226086e-02f, 1.03655010e-02f, 5.67950271e-02f, 9.37845930e-02f, 9.00370851e-02f, -1.31207872e-02f, 2.83191204e-02f,
  1.20283440e-01f, 1.03028052e-01f, 6.46680593e-03f, 7.97728598e-02f, 1.02984011e-01f, 9.71214175e-02f, 8.00494775e-02f, -2.45033912e-02f, 2.18931003e-03f, 9.73099321e-02f,
  8.96456838e-02f, 1.38479099e-01f, 8.74193460e-02f, -5.85418269e-02f, 1.06443472e-01f, 1.65370703e-02f, -1.97085440e-02f, -2.64924560e-02f, 9.32426527e-02f, 8.72786790e-02f,
  -2.35654879e-02f, -1.51830167e-01f, -1.88553091e-02f, -6.67853579e-02f, -4.14985456e-02f, -6.43570349e-02f, -1.87028293e-02f, 3.56306918e-02f, 4.84110303e-02f, -1.50993884e-01f,
  -4.11013700e-02f, 3.78005113e-03f, 1.67188663e-02f, -6.94100261e-02f, 7.31924176e-02f, -5.29318899e-02f, -9.60047822e-03f, -6.41717687e-02f, 1.16470665e-01f, 9.96728893e-03f,
  -6.57943487e-02f, -1.36775702e-01f, -1.86868329e-02f, 4.59739901e-02f, -5.86110614e-02f, -1.15922943e-01f, -4.48881499e-02f, -1.30954742e-01f, 6.66034874e-03f, -1.59959316e-01f,
  -1.25478730e-01f, -3.03343832e-02f, 1.59862265e-02f, 4.21359576e-02f, -7.65112340e-02f, -2.59476528e-03f, 3.46943364e-02f, -3.77208032e-02f, -6.26931936e-02f, -7.01778978e-02f,
  -1.94683652e-02f, -8.47586803e-03f, 5.99283539e-02f, 1.57671161e-02f, -3.98607999e-02f, 3.71628106e-02f, -5.37730120e-02f, 4.08326425e-02f, -1.03079952e-01f, -8.71169865e-02f,
  -8.66516605e-02f, -4.39110622e-02f, -4.21648994e-02f, 3.86220664e-02f, -1.44613488e-02f, 4.68322150e-02f, 6.90198615e-02f, 5.53008281e-02f, 5.43152168e-02f, -1.17750950e-01f,
  -3.45486328e-02f, 5.11969030e-02f, -2.28506196e-02f, -1.50531679e-02f, -5.05924933e-02f, -8.04079622e-02f, -3.57028246e-02f, -7.90352300e-02f, 4.97463606e-02f, -3.85778770e-02f,
  -3.26146781e-02f, -8.25827122e-02f, 9.00782943e-02f, 6.12309128e-02f, 2.60786917e-02f, -8.50692391e-02f, 2.04552114e-02f, -6.63703308e-02f, -6.55472353e-02f, -3.14428471e-02f,
  1.89244077e-02f, -1.06184028e-01f, 4.75188754e-02f, 1.21880226e-01f, 3.31668556e-02f, 6.46187067e-02f, 5.88634750e-03f, 8.79886746e-02f, 1.26379639e-01f, 1.84688140e-02f,
  -4.44445014e-02f, 4.14378829e-02f, 3.86807835e-03f, 8.41785818e-02f, -5.14078327e-02f, -9.05525759e-02f, -9.04940814e-03f, -4.73669916e-02f, 9.07384530e-02f, -3.46988924e-02f,
  5.06182462e-02f, 1.10657094e-03f, 3.03472150e-02f, -5.66492081e-02f, 6.62511885e-02f, 7.06082508e-02f, -9.78673249e-02f, 6.62102252e-02f, -6.04424067e-02f, 6.18039183e-02f,
  -1.85066380e-03f, -5.17284162e-02f, 4.68177125e-02f, -8.41828063e-02f, -3.20895724e-02f, -3.07595693e-02f, -6.16512559e-02f, 2.61529498e-02f, -6.00184351e-02f, -9.98566002e-02f,
  2.12854475e-01f, -2.08022296e-01f, 8.37133173e-03f, 1.59930512e-01f, 1.26171149e-02f, -3.48500386e-02f, -1.86349109e-01f, -5.73970936e-02f, 1.35667786e-01f, -4.81553972e-02f,
  1.83808893e-01f, 2.42398337e-01f, 1.16880141e-01f, 2.86867060e-02f, 6.34814501e-02f, -4.06249017e-02f, -1.00482605e-01f, 1.40722960e-01f, 2.16219321e-01f, 1.06018484e-01f,
  -9.59961209e-03f, -3.83539684e-02f, 1.21125996e-01f, 1.96128841e-02f, -1.81961849e-01f, -2.59488765e-02f, -9.46742073e-02f, -1.00913391e-01f, 9.98686720e-03f, -1.42931819e-01f,
  7.46843815e-02f, -9.36516281e-03f, 2.09041223e-01f, -2.61785910e-02f, -1.03630297e-01f, 4.81969826e-02f, -6.92082942e-03f, 8.68282659e-05f, -1.08075356e-02f, -2.67433655e-02f,
  6.66245744e-02f, -6.23934856e-03f, -8.86943191e-02f, -5.67421764e-02f, -8.97114724e-03f, -8.05571899e-02f, -3.54919098e-02f, 6.31317347e-02f, 1.46466261e-02f, -6.35215119e-02f,
  8.19829851e-03f, -4.35674638e-02f, -6.99480549e-02f, -9.24804434e-03f, -7.84416497e-02f, 3.96902411e-04f, -1.00849152e-01f, -1.32862613e-01f, -9.48389545e-02f, -1.16307974e-01f,
  -5.71117029e-02f, 7.49536678e-02f, 3.92518379e-02f, 4.58347797e-02f, -4.82091634e-03f, -2.52404623e-02f, -1.66881271e-02f, 3.72675136e-02f, -5.29352278e-02f, -7.47484490e-02f,
  -5.14560714e-02f, 5.34060411e-02f, -6.59107119e-02f, 3.24705094e-02f, -3.48361097e-02f, -1.05153523e-01f, -6.21539541e-02f, -7.60959610e-02f, -2.71004848e-02f, 1.00932568e-02f,
  -5.94081879e-02f, 7.43802302e-05f, 5.00238873e-03f, -9.65320691e-03f, 6.19295686e-02f, 6.13720901e-02f, 2.26254724e-02f, -1.88383926e-02f, -4.98895124e-02f, 3.71580422e-02f,
  -9.88493562e-02f, 2.01157689e-01f, 1.66378781e-01f, 1.20713199e-02f, 4.09446619e-02f, -2.21176371e-02f, 5.22498488e-02f, 6.86425194e-02f, -4.33434695e-02f, 8.87717679e-03f,
  6.61489218e-02f, 3.65833230e-02f, -3.78591418e-02f, -6.84930459e-02f, -1.43267782e-02f, 9.13308468e-03f, -3.19097638e-02f, 1.25653893e-01f, 6.02106825e-02f, 4.42350209e-02f,
  3.84041481e-02f, 7.70978108e-02f, 1.33801281e-01f, 3.51086557e-02f, 7.57489800e-02f, 1.51346862e-01f, -6.44216910e-02f, -6.65408224e-02f, 1.47336259e-01f, 1.41498307e-02f,
  -1.14589863e-01f, -1.03080561e-02f, -7.43374079e-02f, 1.38223946e-01f, 7.73291513e-02f, 1.19545244e-01f, 1.27440572e-01f, 1.21599615e-01f, 7.33498037e-02f, 2.84647313e-03f,
  -3.15707624e-02f, -3.01133469e-02f, 7.92003796e-02f, 4.50034812e-02f, -2.18436979e-02f, 8.30918923e-02f, 7.02410489e-02f, 8.11954662e-02f, 6.24679513e-02f, 8.39616582e-02f,
  4.32002731e-02f, 5.00659691e-04f, -1.00110382e-01f, 4.51298319e-02f, -2.63127089e-02f, 9.21891257e-02f, -6.66322885e-03f, -5.10675199e-02f, 2.76081581e-02f, 1.15453169e-01f,
  -9.78837013e-02f, -3.02597228e-02f, 9.47871655e-02f, -2.85861921e-02f, 6.95478823e-03f, -1.29564002e-03f, -4.27790321e-02f, 4.08025086e-02f, -6.97379857e-02f, 3.59607823e-02f,
  -3.17620374e-02f, 7.34098107e-02f, 5.71958162e-02f, 5.21522388e-02f, -9.25442874e-02f, -4.97370213e-02f, -3.81195284e-02f, 1.60864294e-02f, 2.07224470e-02f, 5.12382388e-02f,
  -2.03763563e-02f, 4.87974882e-02f, 7.34265968e-02f, 5.81563897e-02f, -8.68927315e-02f, -1.34300869e-02f, 3.66382226e-02f, -5.70612401e-02f, 1.36559494e-02f, 2.05963687e-03f,
  1.92429721e-02f, -5.15771657e-02f, -8.25125352e-03f, 6.35241419e-02f, 1.92404650e-02f, 1.92260239e-02f, -9.29570384e-03f, 4.90496308e-03f, -8.96371454e-02f, 5.62443510e-02f,
  2.87542660e-02f, -5.82173094e-02f, -8.61591399e-02f, 6.98592141e-02f, 7.46449362e-03f, 6.00618683e-02f, -6.38895184e-02f, -3.45465317e-02f, 4.52909172e-02f, -3.14180814e-02f,
  -1.34163955e-02f, 6.84192032e-02f, 6.20146953e-02f, 7.48733431e-02f, 2.25958340e-02f, 7.89125785e-02f, 7.78928399e-02f, -2.41827834e-02f, 1.26100359e-02f, 5.18981367e-03f,
  -1.85310207e-02f, -5.19335009e-02f, 9.33595225e-02f, 8.63217190e-02f, 3.60861863e-03f, 6.05533682e-02f, 3.10822576e-02f, 3.96139584e-02f, 6.86591193e-02f, 9.79982615e-02f,
  -1.70035586e-02f, -4.98179533e-02f, 3.17344777e-02f, -7.09861442e-02f, 2.81601008e-02f, 1.49045419e-02f, 6.86774254e-02f, 7.29071796e-02f, -4.62168120e-02f, 6.14352487e-02f,
  3.10553703e-02f, 8.80375355e-02f, 2.79186834e-02f, 2.98409611e-02f, -9.06506460e-03f, 4.12647910e-02f, 4.07865420e-02f, -4.50331829e-02f, -8.07352811e-02f, 4.51781927e-03f,
  -2.56905705e-02f, -2.64678635e-02f, -2.70231124e-02f, -1.24965705e-01f, 2.04249704e-03f, -3.13602686e-02f, -3.37540135e-02f, -4.79931757e-02f, 4.26992029e-02f, -6.97101131e-02f,
  3.16995308e-02f, -1.30488118e-02f, 1.01656141e-03f, -1.98486168e-02f, 8.30548108e-02f, 3.59854847e-02f, 1.77366156e-02f, -3.56934443e-02f, -4.28950079e-02f, -5.75173423e-02f,
  4.42397752e-04f, -3.99024412e-02f, 8.79129320e-02f, -4.74680178e-02f, -5.77476956e-02f, -3.08441352e-02f, -6.63253143e-02f, -4.81408834e-02f, 3.05308606e-02f, -7.58454110e-03f,
  2.62261909e-02f, -3.22097577e-02f, 3.54908901e-04f, -1.28421644e-02f, 3.88771556e-02f, 1.11556072e-02f, -1.59372538e-02f, 2.74756476e-02f, -3.79666910e-02f, -3.41803208e-02f,
  2.02602800e-02f, -4.34497781e-02f, 5.14324568e-02f, -2.30742376e-02f, -3.54261920e-02f, -6.21508509e-02f, -4.23000604e-02f, 3.26340124e-02f, -1.33432718e-02f, 2.68878397e-02f,
  -5.64794242e-02f, 4.59060967e-02f, 3.72519577e-03f, 1.05197154e-01f, 8.29422195e-03f, 4.67111059e-02f, 3.97801064e-02f, -3.66873965e-02f, 8.17772821e-02f, 3.61083187e-02f,
  7.80322254e-02f, 9.77198035e-03f, -4.79515456e-02f, -3.44911292e-02f, -4.63831127e-02f, 7.11718872e-02f, 9.27606225e-02f, -2.39006039e-02f, -7.69463181e-02f, 6.84530959e-02f,
  8.80630538e-02f, -6.60874024e-02f, -5.16220033e-02f, 6.47159591e-02f, 7.66655281e-02f, -6.65318966e-02f, 7.10633174e-02f, 9.27894339e-02f, 7.29381293e-02f, -8.47800598e-02f,
  -6.60942495e-02f, 7.70576075e-02f, -8.05315003e-02f, 7.81463981e-02f, 7.80656636e-02f, 6.49170503e-02f, -4.93389368e-02f, 7.20315352e-02f, -4.11297046e-02f, 1.03714401e-02f,
  -3.24611142e-02f, 4.72503155e-02f, -4.15321775e-02f, -4.27823961e-02f, -3.59617770e-02f, -1.06004126e-01f, -5.44418693e-02f, 7.90611655e-02f, -1.18453838e-01f, -7.72222802e-02f,
  -8.50244239e-02f, -5.60156479e-02f, -3.80313359e-02f, 1.13765225e-02f, -6.72683716e-02f, 6.89348131e-02f, -3.70059423e-02f, 6.84516951e-02f, 8.15776512e-02f, 1.42729226e-02f,
  5.35750650e-02f, 9.31640118e-02f, 2.36374959e-02f, -2.61483155e-02f, 8.00747648e-02f, 1.91968475e-02f, 8.29127878e-02f, 8.13885480e-02f, 9.12112445e-02f, 1.04210712e-01f,
  2.05936423e-03f, -7.19674081e-02f, -1.10817961e-02f, 5.91002479e-02f, 8.07268173e-03f, -4.23754677e-02f, 1.14216749e-02f, -1.06610246e-01f, 4.23940048e-02f, 1.42476335e-03f,
  1.08437076e-01f, 1.03985339e-01f, -8.97948220e-02f, -7.77651668e-02f, -1.36275381e-01f, -5.18931309e-03f, 6.38825148e-02f, -2.24205740e-02f, -6.10190863e-03f, -9.56532285e-02f,
  1.02474190e-01f, 3.36177647e-02f, -1.22161377e-02f, -1.24035530e-01f, 4.52264883e-02f, 9.76766050e-02f, -5.04920855e-02f, 7.68894926e-02f, 1.05369076e-01f, 1.47816166e-01f,
  1.11817174e-01f, -8.47695917e-02f, 4.96653629e-05f, 8.60118568e-02f, -2.83246934e-02f, 6.61628246e-02f, 6.67040646e-02f, 1.60351035e-03f, -6.69112578e-02f, 8.84500369e-02f,
  3.73246297e-02f, 1.42972702e-02f, 7.02872686e-03f, 7.89794475e-02f, -9.65484902e-02f, -7.64019638e-02f, -1.01763554e-01f, -4.43168469e-02f, -9.80313942e-02f, -1.01683624e-01f,
  2.57222331e-03f, 3.30719468e-03f, -1.00528978e-01f, -5.01505621e-02f, 8.54164734e-03f, 8.59386772e-02f, -2.81065498e-02f, 3.82735655e-02f, -6.23048805e-02f, -5.04864939e-02f,
  2.81381179e-02f, 7.42113218e-02f, 6.63991421e-02f, 1.08483462e-02f, 5.79955876e-02f, 9.92016718e-02f, -6.43381700e-02f, 6.50868863e-02f, 2.31263912e-04f, 2.25123800e-02f,
  1.12052104e-02f, -1.11388266e-02f, -8.88170376e-02f, 5.04906848e-02f, 2.60259751e-02f, 6.06962480e-03f, -1.61893982e-02f, 6.15828745e-02f, -4.02017869e-02f, 2.13662572e-02f,
  2.28054393e-02f, 4.48224731e-02f, -6.58739284e-02f, 8.32756087e-02f, 8.33033472e-02f, -8.98680687e-02f, -6.16675131e-02f, -1.11590877e-01f, -8.28185678e-02f, -1.08538410e-02f,
  3.71592529e-02f, -7.98862949e-02f, 2.97544207e-02f, -3.76192071e-02f, 7.14664236e-02f, 2.71450803e-02f, -3.04754078e-02f, -9.62204635e-02f, 7.68865719e-02f, -7.72499070e-02f,
  -7.04217851e-02f, 7.91139901e-02f, 9.57091246e-03f, -6.26469776e-02f, 7.74023831e-02f, -3.98230627e-02f, -2.29702089e-02f, 2.43590921e-02f, -2.44521294e-02f, -4.40779440e-02f,
  8.48582480e-04f, -4.93416935e-02f, -8.59731361e-02f, -5.64039610e-02f, -7.98636768e-03f, -1.44964457e-02f, 3.52480263e-02f, -2.15922538e-02f, 2.55455710e-02f, -8.54455605e-02f,
  -1.23592066e-02f, 1.75205730e-02f, -3.10214385e-02f, 1.40571855e-02f, 6.67105168e-02f, -3.31721902e-02f, 5.56382686e-02f, 9.82063338e-02f, 4.49439464e-03f, -7.29848295e-02f,
  -4.62245606e-02f, -1.86855104e-02f, 8.52988884e-02f, 2.83573028e-02f, -5.40321097e-02f, -2.04867823e-03f, -2.28951350e-02f, 6.01984598e-02f, 4.97384407e-02f, 3.45943607e-02f,
  -6.22120574e-02f, -6.88171899e-03f, -1.11305155e-01f, 3.65588665e-02f, -3.03157587e-02f, 3.63285653e-02f, 1.97695717e-02f, -7.26759210e-02f, -2.66034268e-02f, 2.36110166e-02f,
  1.83452830e-01f, -8.48298967e-02f, -2.78387335e-03f, -8.26708153e-02f, 4.68822829e-02f, -6.30287901e-02f, 3.35277282e-02f, -5.43624200e-02f, 8.20559189e-02f, -8.30183830e-03f,
  -4.75752950e-02f, -3.23658623e-02f, -5.53895272e-02f, 6.31201193e-02f, 4.26863171e-02f, 5.98565862e-02f, -9.94695649e-02f, 5.10950759e-02f, -1.70904547e-02f, 1.09462380e-01f,
  -1.19938133e-02f, -4.84521454e-03f, 1.00893587e-01f, 1.90794617e-02f, 1.14154108e-01f, 4.34108675e-02f, -2.32670959e-02f, -3.16237658e-02f, -3.28361802e-03f, -8.80187601e-02f,
  -3.77832819e-03f, -6.47942424e-02f, 6.87046163e-03f, 3.31929252e-02f, -1.75544005e-02f, -6.61768168e-02f, 3.95443626e-02f, 2.97441315e-02f, 5.74395573e-03f, -7.27875084e-02f,
  1.16590923e-02f, 6.13820814e-02f, 5.03897145e-02f, -3.55239622e-02f, 5.68831526e-02f, -7.78231993e-02f, 8.36864784e-02f, -2.44141854e-02f, -3.26718725e-02f, -1.32706463e-02f,
  8.12834725e-02f, -3.78307067e-02f, -6.86269030e-02f, 7.14089870e-02f, -4.49688882e-02f, 4.57199365e-02f, -4.21110541e-02f, -8.42819735e-02f, 6.17676489e-02f, 5.23384027e-02f,
  3.71778719e-02f, 9.60388482e-02f, 1.44951837e-05f, 6.10541403e-02f, -4.53847982e-02f, 4.66506146e-02f, 3.10752206e-02f, -6.76561072e-02f, -4.10212725e-02f, -3.56839001e-02f,
  7.27282315e-02f, 3.51926796e-02f, 1.41650839e-02f, -6.15967959e-02f, 1.67945605e-02f, 1.54574458e-02f, 2.07128767e-02f, 1.05020944e-02f, 9.25305635e-02f, 6.05334109e-03f,
  7.70561397e-02f, -4.60465886e-02f, -2.35346984e-02f, 4.38477732e-02f, 4.12494987e-02f, 1.19275823e-01f, 5.54544069e-02f, 7.46304542e-02f, 3.81341241e-02f, -2.22509596e-02f,
  -5.10062731e-04f, -2.31785148e-01f, -1.04578994e-01f, -3.64408232e-02f, -1.11801840e-01f, 3.31021808e-02f, -8.20790678e-02f, -6.47545531e-02f, 5.53809702e-02f, -1.55199870e-01f,
  -6.08431920e-02f, -3.02697122e-02f, -1.15871258e-01f, 6.99351057e-02f, 2.55184658e-02f, 1.21711427e-02f, -1.76757038e-01f, 3.71472910e-03f, 9.74106416e-02f, 1.42510578e-01f,
  -4.09913473e-02f, 2.00711819e-03f, -4.39079665e-02f, 1.49716049e-01f, 4.98948731e-02f, 4.94625680e-02f, -9.35489014e-02f, -1.29823402e-01f, -1.02967270e-01f, -1.48261458e-01f,
  -1.64898753e-01f, -1.36232479e-02f, -6.94759637e-02f, -1.96160283e-02f, -9.09502879e-02f, -7.43400604e-02f, -8.40523764e-02f, -5.50516956e-02f, 4.50011976e-02f, -1.22640952e-02f,
  -2.56936811e-03f, -1.46611957e-02f, 6.72285333e-02f, -4.35850322e-02f, 1.53141292e-02f, 6.27718046e-02f, -6.67425916e-02f, -4.77481335e-02f, -2.24960614e-02f, -6.61692629e-03f,
  -7.48142079e-02f, 1.16888899e-02f, -7.82126412e-02f, 2.22362857e-02f, -4.22378220e-02f, 7.12283403e-02f, -6.12786785e-02f, -5.14455326e-02f, -7.22016841e-02f, -1.38902113e-01f,
  2.50528865e-02f, 5.51794935e-03f, -1.95108801e-02f, 4.95252665e-03f, 9.91814360e-02f, 3.11451405e-02f, -3.25757898e-02f, -7.61349797e-02f, 6.28516078e-02f, -2.19591595e-02f,
  -4.95524295e-02f, -1.14468681e-02f, 7.56909177e-02f, 7.76588544e-02f, -5.61420433e-02f, -2.79308520e-02f, -1.11964894e-02f, 5.42399362e-02f, -5.43625653e-02f, 5.19747287e-02f,
  -8.03964809e-02f, -4.68041264e-02f, -3.73014919e-02f, 1.59560144e-02f, 3.47882733e-02f, -6.35216460e-02f, -4.18745652e-02f, -2.95797270e-02f, 6.16681837e-02f, 2.17551533e-02f,
  -2.57482529e-02f, 6.72651008e-02f, -6.40984550e-02f, 4.09909301e-02f, 5.55376485e-02f, 5.36955297e-02f, 2.70306747e-02f, 1.82433631e-02f, 5.19050136e-02f, 1.16259931e-02f,
  -3.14024501e-02f, 5.23827597e-02f, -3.69111523e-02f, -2.68195812e-02f, -7.67477043e-03f, 9.86491740e-02f, -7.85045177e-02f, 8.79204050e-02f, 8.76315460e-02f, 1.02062775e-02f,
  8.73278733e-03f, 4.60010394e-02f, -6.04219809e-02f, -3.12028658e-02f, -4.41831462e-02f, -9.31492597e-02f, -8.23055282e-02f, -3.67725529e-02f, -2.98271030e-02f, -2.03387290e-02f,
  4.01665755e-02f, -8.73864889e-02f, -1.39614418e-01f, -7.37311468e-02f, -7.64527023e-02f, -6.03561215e-02f, -1.43463304e-02f, 5.07861562e-02f, 1.45658897e-02f, 3.15537155e-02f,
  1.49226486e-04f, 8.81874785e-02f, 5.63453101e-02f, -5.28038666e-02f, -3.66067477e-02f, -3.02585792e-02f, -8.43585953e-02f, 8.45800415e-02f, -8.11004788e-02f, -2.40421388e-02f,
  -5.62265106e-02f, -6.73960755e-03f, 7.56133720e-02f, -8.76964629e-02f, -8.76067877e-02f, -3.03313602e-02f, -9.13794711e-02f, -2.92552467e-02f, -1.22726455e-01f, -6.68084249e-02f,
  3.41804735e-02f, 3.99197750e-02f, 1.65157411e-02f, 7.62487873e-02f, -5.05943149e-02f, 3.97259295e-02f, -4.85042185e-02f, 4.62209769e-02f, -1.62958410e-02f, 7.25796148e-02f,
  7.43997246e-02f, 8.14461038e-02f, -6.96967468e-02f, -5.76970838e-02f, 6.91502318e-02f, -7.56343231e-02f, 1.38778808e-02f, -8.56964756e-03f, 6.29440472e-02f, -5.31271063e-02f,
  2.82651763e-02f, -1.47666158e-02f, -7.28891045e-02f, -6.18194528e-02f, -9.48371273e-03f, -1.79894604e-02f, 3.63737717e-02f, 4.59066182e-02f, 5.02316952e-02f, 8.08855444e-02f,
  -2.98833698e-02f, -5.54117523e-02f, 6.00675009e-02f, -1.68485977e-02f, 9.88574177e-02f, 5.37469648e-02f, -3.47771421e-02f, 6.13621920e-02f, 1.37784373e-04f, -5.13633415e-02f,
  6.45699650e-02f, -3.14533785e-02f, 6.37486801e-02f, 1.93602685e-02f, -5.17646596e-02f, 8.08966830e-02f, -6.85575530e-02f, 2.77150832e-02f, -4.25667427e-02f, -4.55395840e-02f,
  -6.65436089e-02f, 4.40963767e-02f, -5.72510809e-03f, -1.73785035e-02f, 2.79399846e-02f, -4.87867706e-02f, 5.84353842e-02f, 2.83751190e-02f, -6.90852478e-02f, 4.36608680e-02f,
  4.86508086e-02f, -8.52186382e-02f, 4.03855331e-02f, -3.64991324e-03f, 1.86707377e-02f, 4.36785594e-02f, 1.99169870e-02f, -5.88331260e-02f, 7.93259311e-03f, -2.34343689e-02f,
  -6.30701557e-02f, 6.91025183e-02f, -3.59159075e-02f, -3.32685709e-02f, 2.86029428e-02f, -4.39534150e-02f, -1.44089595e-03f, -2.47097090e-02f, 6.34123012e-02f, 2.82854922e-02f,
  5.25438227e-03f, 8.55596587e-02f, 1.19683087e-01f, 1.33850381e-01f, -2.26775892e-02f, -4.75793518e-02f, 3.07406187e-02f, 4.59378026e-02f, -3.00034173e-02f, 1.09074466e-01f,
  -2.27764189e-01f, 1.01535004e-02f, -3.89669240e-02f, -1.39621034e-01f, -1.27607316e-01f, 2.45127957e-02f, 9.61005762e-02f, -6.54707253e-02f, 5.87987043e-02f, 7.05775619e-02f,
  2.01167203e-02f, 5.42852320e-02f, 8.01453218e-02f, -6.17765486e-02f, 8.26783665e-03f, 1.68311130e-02f, 2.32261382e-02f, -8.13900754e-02f, -8.56547058e-02f, -1.77958608e-02f,
  -6.73371479e-02f, -9.84284878e-02f, -1.53895825e-01f, -1.28288731e-01f, -1.81282833e-02f, -1.21610649e-01f, -1.07443184e-01f, -1.35839909e-01f, 1.88830141e-02f, -8.01705848e-03f,
  4.03059572e-02f, -8.90999064e-02f, -4.27538715e-02f, 4.03508581e-02f, 4.83204518e-03f, -7.68919068e-04f, -6.71410933e-02f, -6.57101199e-02f, -8.55362937e-02f, -1.63203739e-02f,
  -4.67544124e-02f, 1.62370689e-02f, -2.99042780e-02f, -7.78472275e-02f, -1.16738901e-01f, -4.94096391e-02f, -7.04078153e-02f, 3.71399634e-02f, -9.40808058e-02f, 4.11842167e-02f,
  -3.19053158e-02f, -1.11106411e-01f, -1.03003792e-01f, -3.82238105e-02f, 7.40958676e-02f, 9.35385283e-03f, 6.80207238e-02f, -2.69817114e-02f, -8.69794786e-02f, -9.37236287e-03f,
  -4.74113002e-02f, -8.11405331e-02f, 3.09297983e-02f, -6.71542212e-02f, -4.35938053e-02f, 6.60233498e-02f, 8.89335722e-02f, -4.90801260e-02f, 9.24869627e-03f, -2.21837740e-02f,
  8.46588165e-02f, 1.69157833e-02f, -1.84975136e-02f, -3.23069654e-02f, 6.68853000e-02f, -4.38131019e-02f, 8.34922642e-02f, -6.89631477e-02f, 5.49939275e-02f, 3.33601050e-02f,
  -5.92869744e-02f, 4.23325449e-02f, -7.90037662e-02f, 6.86081732e-03f, -5.46512082e-02f, -2.91978065e-02f, -7.51119433e-03f, -2.15340722e-02f, 9.83021036e-02f, 6.95754066e-02f,
  -9.18017179e-02f, -6.63006585e-03f, -2.81934738e-02f, -9.85814258e-02f, 4.72317934e-02f, -5.20811006e-02f, -2.46581864e-02f, -8.57914016e-02f, 9.76487771e-02f, 3.35101672e-02f,
  -8.60324502e-03f, -6.04078732e-02f, 5.49410321e-02f, 9.18545276e-02f, 7.33572766e-02f, -7.91454390e-02f, 2.09065452e-02f, -5.63020003e-05f, 3.74946073e-02f, -4.91294824e-02f,
  5.96045218e-02f, -1.72697399e-02f, -1.06966989e-02f, -1.52901411e-02f, -8.86243954e-02f, 8.92884508e-02f, 9.56960320e-02f, -3.18121053e-02f, 4.99542505e-02f, -6.87356666e-02f,
  9.39267650e-02f, -3.16203982e-02f, -8.53630528e-02f, -2.42490880e-02f, -6.68996647e-02f, -4.17902991e-02f, 4.01710719e-02f, -2.52028462e-02f, 1.16088940e-02f, 8.46745744e-02f,
  -4.47041029e-03f, -1.39320455e-02f, -3.73403020e-02f, 8.26113597e-02f, 8.81375968e-02f, 2.60785464e-02f, -6.97929040e-02f, -1.51401749e-02f, 1.19543523e-01f, 5.57849999e-04f,
  1.03275673e-02f, -5.44207953e-02f, -2.43746508e-02f, -2.64941566e-02f, -1.95827428e-02f, 9.11422670e-02f, -5.93055449e-02f, -3.90751995e-02f, -7.23192394e-02f, -8.23926106e-02f,
  -3.20817605e-02f, 3.54554616e-02f, -5.02984822e-02f, 7.12758303e-02f, -1.24768894e-02f, 2.45628320e-02f, -1.03414198e-02f, -4.42355499e-03f, 6.34341687e-02f, 6.90446496e-02f,
  8.46180245e-02f, 2.17351690e-02f, 8.97014439e-02f, -9.06503499e-02f, -3.42119223e-04f, 8.95442367e-02f, -5.18081076e-02f, -2.56663300e-02f, 5.17956875e-02f, 4.13324460e-02f,
  3.63656841e-02f, 6.89809695e-02f, 4.78223562e-02f, 9.31993052e-02f, -2.64250790e-03f, 9.52186659e-02f, 9.93749350e-02f, 9.34234411e-02f, 3.99120897e-02f, 5.37893549e-02f,
  4.38443683e-02f, -1.09433979e-02f, 2.48592086e-02f, 2.18610442e-03f, 1.63171347e-02f, 6.66767135e-02f, -5.72539084e-02f, -7.02719167e-02f, -9.64086130e-02f, -1.05219427e-02f,
  -7.66520798e-02f, -2.47262605e-02f, -8.03409051e-03f, 2.96215303e-02f, 4.45295647e-02f, 5.56802638e-02f, 4.53032218e-02f, -7.97504634e-02f, -3.77462097e-02f, -2.55793575e-02f,
  9.16860402e-02f, -3.15896161e-02f, 4.51754592e-02f, 4.95048091e-02f, -1.68528203e-02f, -5.86373061e-02f, 8.30078200e-02f, -1.60403494e-02f, -1.11704804e-01f, 1.79726444e-02f,
  3.13697197e-02f, 1.51542246e-01f, -1.32369781e-02f, 2.80961562e-02f, 3.26412916e-02f, -5.16863950e-02f, 9.43955854e-02f, 5.05228876e-04f, -3.25169368e-03f, 3.01634073e-02f,
  -2.55700909e-02f, 2.99416780e-02f, 2.42648646e-02f, -4.56212685e-02f, -1.79379769e-02f, -6.04585037e-02f, -9.22973379e-02f, 4.44095172e-02f, 6.99328184e-02f, -1.59672014e-02f,
  6.69056326e-02f, 1.00930795e-01f, 3.92416902e-02f, 1.82702951e-02f, -5.01732416e-02f, 7.69777596e-02f, 8.98842961e-02f, -3.81788388e-02f, 1.05846740e-01f, -3.84462662e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  -3.22488807e-02f, 1.08869307e-01f, 1.22373901e-01f, 1.44201919e-01f, -7.92217255e-02f, 6.47309199e-02f, 6.52504638e-02f, 4.62305173e-02f, -8.87196139e-03f, 1.86286062e-01f,
  6.75694346e-02f, 8.08797684e-03f, -6.09935075e-02f, 3.95374075e-02f, 4.45356406e-02f, 7.82933831e-02f, -5.78271523e-02f, -7.82668218e-03f, 1.12348467e-01f, -1.81207657e-02f,
  1.75642982e-01f, -2.07532980e-02f, 8.09067935e-02f, -1.53238978e-03f, 1.38507381e-01f, 1.18515275e-01f, -1.01257777e-02f, 1.09141739e-02f, 8.22381377e-02f, 9.95015055e-02f,
  9.91212502e-02f, 1.71090722e-01f, -2.59088650e-02f, 9.00211185e-02f, 6.19306676e-02f, 1.41795576e-02f, -5.15519641e-02f, -5.87597936e-02f, 7.61056915e-02f, 9.14762020e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  4.61736461e-04f, -2.89872080e-01f, 2.37624213e-01f, -1.70044541e-01f, 2.03565687e-01f, -5.83851859e-02f, -6.20842613e-02f, -3.92839238e-02f, 1.85406327e-01f, 1.47833645e-01f,
  -6.31086081e-02f, -1.17313690e-01f, 1.19165413e-01f, -5.00002354e-02f, -1.60524979e-01f, -2.73769617e-01f, 1.31274238e-02f, -8.96316841e-02f, -3.22647467e-02f, -7.46356547e-02f,
  2.03904901e-02f, -9.19161588e-02f, -6.06592298e-02f, 1.04509786e-01f, -7.26646781e-02f, -1.07622139e-01f, 1.14178702e-01f, 2.93405242e-02f, 1.69259131e-01f, -9.60398540e-02f,
  -1.09207220e-01f, -2.68658181e-03f, -1.11695267e-01f, -1.66410848e-01f, -5.35803102e-02f, 6.31188303e-02f, -8.17583725e-02f, 1.20834231e-01f, 4.62881736e-02f, 2.10394152e-03f,
  -3.29868309e-02f, 1.62308320e-01f, -4.49935235e-02f, 1.75869539e-02f, -1.32115409e-01f, 1.76212460e-01f, -1.44439926e-02f, 1.34767860e-01f, -6.96964413e-02f, -1.42367244e-01f,
  2.16317609e-01f, 5.12548834e-02f, -4.23856378e-02f, 4.80483808e-02f, -5.19459252e-04f, -1.06901705e-01f, 1.52363544e-02f, -4.14461046e-02f, -3.21616419e-02f, 1.31124288e-01f,
  2.57186797e-02f, 1.19643226e-01f, 1.48812328e-02f, -3.56581770e-02f, 3.09012029e-02f, -2.42408626e-02f, -5.85386232e-02f, -1.81712974e-02f, -5.19396253e-02f, -1.51386783e-02f,
  1.38959453e-01f, 3.47523317e-02f, 7.34677762e-02f, 1.52599901e-01f, 1.70671239e-01f, 1.59333408e-01f, 1.23812839e-01f, 1.58088729e-01f, 1.73009917e-01f, -2.78573573e-01f,
  -7.20339864e-02f, 1.78766131e-01f, 1.21380575e-01f, 1.83457330e-01f, 5.19301035e-02f, 1.06956726e-02f, 2.30313629e-01f, -9.83484238e-02f, -1.72850668e-01f, -1.31341681e-01f,
  1.23320922e-01f, 1.58456668e-01f, -3.69082787e-03f, -1.05987154e-01f, 8.38524327e-02f, 3.47548984e-02f, 8.21919590e-02f, 6.63292259e-02f, 7.46369176e-03f, -2.50994079e-02f,
  -1.42727554e-01f, -1.09003484e-01f, -3.17333043e-02f, -2.01963708e-02f, -2.37862580e-03f, -5.59806861e-02f, -1.15961075e-01f, -6.03171214e-02f, -3.90833169e-02f, 6.61366107e-03f,
  8.74284282e-02f, -8.67027789e-02f, 1.39265895e-01f, -1.06979571e-01f, 2.31860932e-02f, 1.82560012e-02f, -3.52041121e-03f, 1.06243819e-01f, -5.47722168e-02f, -1.26971737e-01f,
  4.68460731e-02f, 1.42238074e-04f, 2.31735762e-02f, -1.54763879e-02f, -4.04612161e-02f, -2.21386515e-02f, 3.20017412e-02f, -3.25059034e-02f, -1.17136933e-01f, -1.75551847e-01f,
  -8.77592787e-02f, 1.76028218e-02f, -1.35294780e-01f, -6.35535419e-02f, 1.00000449e-01f, 1.92806982e-02f, -6.36779219e-02f, 2.50599384e-02f, -8.78873244e-02f, -7.84645155e-02f,
  4.30629700e-02f, 5.44470437e-02f, -8.39530528e-02f, -1.32469177e-01f, -1.13069855e-01f, 5.60721681e-02f, 3.64024416e-02f, -1.33415358e-02f, -3.65217179e-02f, -8.29187706e-02f,
  7.59598566e-03f, 4.02574204e-02f, -1.42155528e-01f, -4.21804339e-02f, -7.65098557e-02f, 6.42746463e-02f, 6.67186379e-02f, -1.50993578e-02f, -1.55659467e-01f, 8.56782049e-02f,
  -1.06551219e-02f, -8.98155943e-02f, -8.37034136e-02f, -1.40170947e-01f, -1.07696250e-01f, -1.43727168e-01f, 5.08077033e-02f, -4.30445708e-02f, -1.00610526e-02f, -3.71945351e-02f,
  -2.65844539e-02f, -4.69502658e-02f, -4.33366367e-04f, -1.39179811e-01f, -1.05575591e-01f, 5.04237078e-02f, -1.15742370e-01f, -5.94562739e-02f, 3.95637490e-02f, -8.49319175e-02f,
  1.69036537e-01f, 2.41377037e-02f, -1.37333781e-01f, -2.71765351e-01f, -1.78441871e-02f, -1.07770897e-02f, -6.18462674e-02f, -1.03074901e-01f, 3.49935032e-02f, 8.76872614e-02f,
  3.01881116e-02f, -1.41183868e-01f, -8.90781954e-02f, -1.41041666e-01f, 2.35638753e-01f, -1.36154205e-01f, 3.65845859e-03f, -4.98174652e-02f, -1.21384531e-01f, 1.60228372e-01f,
  2.33205020e-01f, 2.72876583e-02f, -1.71554059e-01f, 4.44573015e-02f, 1.07875519e-01f, -9.58235264e-02f, -2.41361558e-01f, -2.02992633e-01f, 1.31980866e-01f, -1.30235944e-02f,
  1.55510187e-01f, -1.55436605e-01f, -1.47227094e-01f, -6.13915771e-02f, 6.81728125e-02f, 9.00089461e-03f, 5.78297526e-02f, 7.25950226e-02f, -9.31725800e-02f, -1.27163500e-01f,
  7.95163810e-02f, -8.37735310e-02f, -6.80500120e-02f, -1.26575390e-02f, -7.31857195e-02f, -1.18678905e-01f, 9.45481583e-02f, 6.25216663e-02f, -5.99509478e-03f, 2.69625783e-02f,
  -4.21967506e-02f, 1.05377585e-01f, -4.65021357e-02f, 4.96608578e-02f, 1.59225002e-01f, -5.04037775e-02f, -1.05171598e-01f, 1.91780582e-01f, -2.20646877e-02f, 1.27446115e-01f,
  -1.23011023e-01f, -6.41305670e-02f, 3.44529487e-02f, -3.66656780e-02f, 2.65873922e-03f, -7.85760432e-02f, -2.06399653e-02f, 8.98245629e-03f, 1.04872450e-01f, -9.65150297e-02f,
  -2.81081721e-02f, 1.60035640e-01f, 1.67270079e-01f, -6.65046796e-02f, 5.92372678e-02f, 8.84214491e-02f, -1.63799569e-01f, 3.76900309e-03f, 1.10942952e-01f, -1.93308629e-02f,
  1.34611234e-01f, 4.55887318e-02f, -1.32949511e-02f, -8.15674588e-02f, 2.00584561e-01f, 3.58322822e-03f, 4.00550477e-02f, 7.90950581e-02f, -1.03262125e-03f, -1.02278069e-01f,
  -1.12340897e-01f, -9.27900076e-02f, 2.52145585e-02f, -3.45781073e-02f, -6.80111721e-02f, -2.93954253e-01f, 3.27711701e-02f, -6.95935860e-02f, -2.32993841e-01f, 6.98921606e-02f,
  8.84739980e-02f, 6.04366399e-02f, -6.65379018e-02f, -2.22500369e-01f, -3.84099633e-02f, -4.09640372e-02f, 3.56064402e-02f, -1.66009851e-02f, -3.15974094e-02f, -9.84691307e-02f,
  9.59190801e-02f, -1.14900149e-01f, 1.37796983e-01f, -8.31234753e-02f, 1.65884018e-01f, -7.05233142e-02f, -1.37020960e-01f, -1.24945067e-01f, 3.25702652e-02f, 2.82756444e-02f,
  1.26820475e-01f, -2.15152353e-01f, 3.48526239e-02f, 1.85491182e-02f, -1.95703998e-01f, 1.68454479e-02f, 2.30085343e-01f, 3.96394804e-02f, 1.06120251e-01f, -3.45708542e-02f,
  7.65201449e-02f, 1.92565128e-01f, -1.05303243e-01f, 6.13295473e-02f, -1.26582131e-01f, 3.54933627e-02f, 1.30418152e-01f, 1.27582073e-01f, 1.82336271e-01f, -9.25923288e-02f,
  1.33362308e-01f, 3.71537864e-01f, -1.03066809e-01f, 2.53139198e-01f, -2.09883481e-01f, 3.04208547e-02f, -5.76246455e-02f, -1.45843431e-01f, -1.36868119e-01f, -5.16679557e-03f,
  7.59679452e-02f, -6.07065372e-02f, -1.60496458e-01f, 4.93058711e-02f, 2.24480890e-02f, 3.76075387e-01f, -1.81236729e-01f, -1.86604083e-01f, 1.25565520e-02f, -3.49088274e-02f,
  2.49000743e-01f, 1.05605379e-01f, -1.95775628e-01f, -7.01474175e-02f, 9.65621695e-02f, 6.05003312e-02f, -6.01713583e-02f, 9.89859272e-03f, 1.87867824e-02f, 1.22984901e-01f,
  2.90377885e-02f, 1.19583100e-01f, 1.21110380e-01f, 1.32883593e-01f, -4.75112833e-02f, -1.32587120e-01f, -9.07650664e-02f, 3.49115096e-02f, 9.58683118e-02f, -1.30043998e-01f,
  4.47810590e-02f, 4.45717908e-02f, 4.30261716e-02f, -7.10198134e-02f, 5.04687950e-02f, 1.17304035e-01f, -4.67511304e-02f, -1.06317319e-01f, 7.52923787e-02f, -6.25933409e-02f,
  -2.78564811e-01f, 1.02875262e-01f, -7.17415735e-02f, 1.61304548e-02f, 4.39857468e-02f, 2.46427432e-01f, -4.98235524e-02f, 6.44996539e-02f, 1.36750370e-01f, -1.10764019e-01f,
  -6.82817772e-02f, 1.42588437e-01f, -3.64970788e-02f, -8.65785331e-02f, 1.23435132e-01f, 1.55266123e-02f, 3.86182554e-02f, -5.00268042e-02f, 1.21790729e-01f, 9.67580173e-03f,
  -2.89600864e-02f, 1.60515592e-01f, 5.23944534e-02f, 1.86885491e-01f, -3.17437425e-02f, -4.00638357e-02f, -7.32577872e-03f, -1.78874493e-01f, -3.19417613e-03f, -1.68918725e-02f,
  -7.56429136e-03f, -2.82572750e-02f, 2.29503363e-02f, -1.27249271e-01f, -1.03801340e-02f, -4.63969028e-03f, -8.84788707e-02f, 2.39934158e-02f, 7.55482316e-02f, -3.86291258e-02f,
  9.43109468e-02f, -1.01644546e-01f, -2.61112899e-02f, 5.10447100e-02f, -5.40846400e-02f, -9.11467448e-02f, 8.21964890e-02f, -2.76911329e-03f, -1.36088476e-01f, 5.32787107e-02f,
  -1.09448329e-01f, -4.99061048e-02f, -5.23057431e-02f, 9.07319561e-02f, 1.22284450e-01f, 1.11061111e-01f, -4.55451645e-02f, 3.40353958e-02f, -1.58468679e-01f, 2.71114349e-01f,
  -4.20951582e-02f, 8.55391473e-02f, 5.51514048e-03f, -1.14035919e-01f, -1.21051237e-01f, -1.07946701e-01f, 4.04769890e-02f, -5.30852005e-02f, -8.79332572e-02f, 2.38511395e-02f,
  1.05185591e-01f, -1.20660335e-01f, 2.38665156e-02f, -7.85467625e-02f, -9.32913572e-02f, 8.44427943e-02f, -5.63763687e-03f, 6.32847175e-02f, 1.10893048e-01f, -3.02129179e-01f,
  1.44259989e-01f, -9.56900120e-02f, 2.64290422e-01f, 9.58919451e-02f, 1.03575751e-01f, 2.10842475e-01f, 4.11981225e-01f, 2.61447608e-01f, 6.59255907e-02f, 1.72944795e-02f,
  -1.74598657e-02f, -1.38569266e-01f, -1.37448460e-01f, -2.45266393e-01f, 8.70795846e-02f, 1.94284946e-01f, 9.99683812e-02f, -1.26318648e-01f, -6.03192672e-02f, 2.73322295e-02f,
  5.27689941e-02f, 1.26163676e-01f, 3.52022983e-02f, -5.06423935e-02f, 4.85398760e-03f, -6.12139292e-02f, 7.58974627e-02f, -9.32147503e-02f, 9.01945904e-02f, -7.13226274e-02f,
  -1.02625139e-01f, -1.47077605e-01f, 1.39753640e-01f, 9.64899808e-02f, -6.54177815e-02f, 1.46299660e-01f, 6.43204600e-02f, 2.57227290e-02f, -4.75239269e-02f, 1.52361557e-01f,
  1.77753076e-01f, -1.21519871e-01f, 2.27485579e-02f, 1.86484918e-01f, -1.11771822e-01f, 7.81528577e-02f, -6.79073855e-02f, -8.46929997e-02f, 5.88496774e-02f, 1.70407239e-02f,
  4.05359529e-02f, -9.61649716e-02f, 1.72574610e-01f, 7.53464177e-02f, -3.88219059e-02f, 8.89863744e-02f, 3.42767239e-02f, 5.44223264e-02f, 2.43376624e-02f, -6.35841954e-03f,
  -4.21462171e-02f, 1.01261765e-01f, 7.87142664e-02f, 1.70799926e-01f, -6.51430339e-02f, 4.16803733e-02f, -6.70945421e-02f, -7.34695718e-02f, -1.18899293e-01f, -2.95254346e-02f,
  -2.83935428e-01f, -1.01396255e-01f, 1.30852431e-01f, 7.25327507e-02f, 1.31833702e-01f, 1.01001263e-01f, 2.04308212e-01f, -9.53097418e-02f, -2.03044005e-02f, -1.48839504e-01f,
  7.45256543e-02f, 8.98559615e-02f, 1.62077993e-01f, 2.15774961e-02f, -4.07106206e-02f, -2.03066140e-01f, -1.63556729e-02f, -9.39652249e-02f, 1.10441349e-01f, -3.08514908e-02f,
  5.33814803e-02f, -1.03777079e-02f, 8.39399770e-02f, 1.57684982e-01f, 8.14357493e-03f, 7.53541365e-02f, 8.34814310e-02f, -4.21560295e-02f, 1.18795522e-01f, 7.51928911e-02f,
  5.35995234e-03f, 5.07043451e-02f, -3.78181338e-02f, -1.19705431e-01f, -1.77587390e-01f, 1.36928499e-01f, -2.02000570e-02f, -1.26078442e-01f, 1.98111713e-01f, -4.81393300e-02f,
  2.33994219e-02f, 3.92764919e-02f, 1.36241183e-01f, 7.99202546e-02f, -3.27684171e-02f, 5.60932010e-02f, 8.40004832e-02f, -9.20460746e-02f, 1.03889823e-01f, -6.95860758e-02f,
  9.23018828e-02f, 1.03616118e-01f, -7.35188648e-02f, -1.36273056e-01f, 2.89282836e-02f, 2.11732443e-02f, 1.29472136e-01f, 1.78459510e-01f, 8.20161626e-02f, 1.68263525e-01f,
  9.85762030e-02f, 1.27801895e-01f, 4.19164300e-02f, 2.52239220e-02f, 3.94092314e-02f, 4.50991467e-03f, -2.38683983e-03f, 8.11826959e-02f, 6.73822388e-02f, -3.68527249e-02f,
  2.66340934e-02f, -1.02862380e-02f, 1.55916691e-01f, -1.04346149e-01f, 5.66072799e-02f, 1.69846211e-02f, 1.53591456e-02f, 6.34313673e-02f, -5.65793440e-02f, 2.24475525e-02f,
  -7.52765238e-02f, 1.48133874e-01f, -1.76823903e-02f, -2.95983977e-03f, -5.85029796e-02f, 1.10258169e-01f, -2.50318758e-02f, 1.16653807e-01f, -8.19886476e-02f, -2.05323063e-02f,
  -6.60044625e-02f, -5.95813105e-03f, 1.07748926e-01f, 7.97316432e-02f, -2.92386711e-02f, -4.89838384e-02f, -1.14302896e-01f, -5.34509085e-02f, 1.24468476e-01f, 1.28492028e-01f,
  -2.93149203e-02f, -1.47780523e-01f, 7.85469636e-02f, -4.10826728e-02f, -1.54319152e-01f, -5.73068671e-02f, -8.35890099e-02f, -8.49510506e-02f, -2.75114551e-02f, -2.26160530e-02f,
  9.35866535e-02f, -7.00171292e-02f, -9.97751802e-02f, 1.01473048e-01f, -8.31441209e-02f, -7.31069893e-02f, -4.96510603e-02f, -7.08803535e-02f, 1.66191552e-02f, 3.72979976e-02f,
  4.04368192e-02f, -2.33804747e-01f, 4.11965698e-02f, -2.49383301e-01f, 4.26956639e-02f, 6.86417818e-02f, 1.13257267e-01f, 6.31979406e-02f, 9.26041454e-02f, 1.74847960e-01f,
  -2.02625424e-01f, 8.20523407e-03f, 8.87852684e-02f, 8.60444903e-02f, -1.51318714e-01f, -2.51772910e-01f, 5.25520891e-02f, 4.67017889e-02f, 1.42931297e-01f, 1.48291681e-02f,
  -1.83715641e-01f, 5.52725084e-02f, 1.99603602e-01f, 7.82404561e-03f, 9.62011218e-02f, 2.11219732e-02f, -1.26580498e-03f, -5.13162911e-02f, -9.21374653e-03f, -4.90960963e-02f,
  -7.83925802e-02f, 5.18748984e-02f, -1.16328597e-01f, -3.46958749e-02f, 1.12390611e-02f, 2.19328664e-02f, -6.11120500e-02f, 3.30605656e-02f, -6.26893539e-04f, 1.00282684e-01f,
  5.52693494e-02f, 5.60034774e-02f, 9.88738686e-02f, -2.86823139e-02f, 1.92772485e-02f, 9.58688036e-02f, 6.61071911e-02f, -4.05360624e-05f, -8.65659341e-02f, -7.15615302e-02f,
  2.31714964e-01f, -4.75081056e-02f, 1.30554423e-01f, -1.16539419e-01f, -1.16981365e-01f, -1.71734095e-01f, -5.26232868e-02f, -3.65536921e-02f, -1.40292505e-02f, 3.58523354e-02f,
  -9.27941352e-02f, -7.88664538e-03f, -3.28692272e-02f, -1.21310595e-02f, -1.78561695e-02f, 2.95678198e-01f, -3.49339321e-02f, 1.84832424e-01f, -8.16059113e-02f, -1.40653141e-02f,
  -5.38819246e-02f, 2.92707663e-02f, -1.23384655e-01f, -2.28112116e-02f, 2.00323895e-01f, -2.25013848e-02f, -8.07820410e-02f, 2.98451543e-01f, 3.37227970e-01f, 1.49119481e-01f,
  -2.00499054e-02f, -4.64701019e-02f, -1.06383383e-01f, 8.07733685e-02f, 4.98623364e-02f, -1.43021494e-02f, 9.66020152e-02f, -2.01644868e-01f, 2.81870700e-02f, 1.98573135e-02f,
  1.59367576e-01f, 9.81700048e-02f, -1.45498127e-01f, 1.13002591e-01f, -7.17912912e-02f, 1.97204828e-01f, 5.09611592e-02f, -1.72755998e-02f, 8.21111500e-02f, 1.93838879e-01f,
  -5.09285033e-02f, -8.83010626e-02f, -6.43641688e-03f, 4.07434553e-02f, -2.97915488e-02f, 3.76670733e-02f, -1.07600711e-01f, 1.64786845e-01f, 2.74442166e-01f, -5.79984225e-02f,
  1.26223266e-01f, -5.22182584e-02f, 1.89784039e-02f, 2.08464324e-01f, -9.18385834e-02f, 1.54521495e-01f, 2.76373811e-02f, -1.05380483e-01f, 1.17413126e-01f, -1.95153773e-01f,
  9.16683003e-02f, 3.82789411e-02f, 7.30414465e-02f, -4.56800982e-02f, 1.92287806e-02f, -9.75561440e-02f, -2.51079947e-02f, -1.72059759e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  6.70152903e-02f, 1.24375291e-01f, 1.63610458e-01f, -3.88829038e-02f, 1.64413646e-01f, -2.46520173e-02f, 2.46520471e-02f, 1.71270534e-01f, 4.99384999e-02f, -8.14678371e-02f,
  -6.96136802e-02f, -3.32196914e-02f, -1.77946035e-02f, 6.70898287e-03f, 9.05592367e-02f, 3.70777212e-02f, 1.11918323e-01f, -2.39622705e-02f, -1.81775615e-01f, 2.21323539e-02f,
  -1.21780120e-01f, -1.77900176e-02f, -1.44889936e-01f, 6.28645942e-02f, 9.43208858e-02f, -8.11611712e-02f, -8.97850990e-02f, 9.09052119e-02f, 8.30716118e-02f, 8.45035389e-02f,
  8.84461179e-02f, -1.43575799e-02f, 3.18069793e-02f, 6.34390414e-02f, -8.57942402e-02f, 6.91324025e-02f, 9.79163423e-02f, 8.21838975e-02f, 1.26641169e-01f, -1.21441908e-01f,
  9.36765596e-02f, -6.64427504e-02f, -2.03058627e-02f, -8.72519538e-02f, -1.51390597e-01f, 1.77629411e-01f, -1.55345239e-02f, -1.22187734e-02f, 3.44445780e-02f, 8.99489522e-02f,
  1.77868214e-02f, -1.25154898e-01f, 8.34807474e-03f, 1.31497994e-01f, 1.14935279e-01f, 2.90273368e-01f, 6.26645237e-02f, 1.05927043e-01f, 2.28838976e-02f, 1.07660308e-01f,
  -2.98445076e-02f, -1.69869233e-02f, 5.39622921e-03f, 1.08415775e-01f, -7.44223520e-02f, -2.24070530e-02f, 1.07780091e-01f, 4.14690226e-02f, -6.83335662e-02f, 1.21623933e-01f,
  -8.35947320e-02f, 3.82810086e-02f, -5.20613939e-02f, -6.30187988e-02f, -1.06470093e-01f, 8.17376748e-02f, -5.65017238e-02f, 6.24154434e-02f, -1.13840379e-01f, -6.09744601e-02f,
  -1.24339245e-01f, -2.41964776e-02f, -1.11417279e-01f, 8.99007171e-02f, 1.45655824e-02f, 1.56503886e-01f, -5.72537668e-02f, -1.39286518e-02f, 9.26969014e-03f, 1.27813937e-02f,
  5.74432220e-03f, 5.71633317e-02f, -6.57437593e-02f, -3.22236754e-02f, -3.08388751e-03f, -3.67284082e-02f, -1.21054970e-01f, 5.45985363e-02f, 1.28114536e-01f, -5.28486893e-02f,
  5.16962595e-02f, 3.45997177e-02f, -4.83774431e-02f, -6.59375032e-03f, 4.06027678e-03f, -2.28335094e-02f, 4.26298790e-02f, 1.66991562e-01f, 3.80798467e-02f, -3.24245021e-02f,
  1.45340875e-01f, -5.72957769e-02f, 7.62202442e-02f, 6.72713146e-02f, 7.14925900e-02f, 6.08805828e-02f, 6.57143220e-02f, -1.05787873e-01f, -2.55778097e-02f, 1.01454437e-01f,
  -3.41056548e-02f, 7.14233369e-02f, -1.03978626e-01f, 6.58171996e-02f, 8.48290473e-02f, -1.20650887e-01f, -2.22825073e-02f, -1.01379648e-01f, 7.94032216e-02f, 1.29613243e-02f,
  -1.90365538e-02f, -5.76835312e-02f, -6.75707459e-02f, 2.05754172e-02f, -8.91373158e-02f, -1.11532457e-01f, -7.34909251e-02f, -1.03643732e-02f, -9.78765041e-02f, -7.33565614e-02f,
  -3.97596136e-02f, -1.92451477e-02f, 3.41102555e-02f, 1.25836834e-01f, -1.20758280e-01f, -6.25036582e-02f, 5.00600450e-02f, -8.43228772e-02f, 2.72592079e-05f, 6.29629269e-02f,
  -1.28550217e-01f, -2.63052993e-02f, 5.73066697e-02f, 1.54827982e-01f, -6.65184557e-02f, -7.02877641e-02f, 1.27420500e-01f, 2.29352266e-02f, -3.57492603e-02f, 5.37998267e-02f,
  -1.21009713e-02f, 1.22786082e-01f, -1.51492341e-03f, -3.34718749e-02f, -7.08069876e-02f, 2.68917587e-02f, -5.89811057e-02f, 3.18919644e-02f, 3.81919332e-02f, 9.66584310e-02f,
  -4.91370447e-02f, 1.02711290e-01f, 9.20568556e-02f, -5.98488860e-02f, 2.77990345e-02f, -1.05660729e-01f, -5.19213043e-02f, 4.39372174e-02f, -5.27191162e-02f, 5.21187708e-02f,
  8.82768482e-02f, -4.59697805e-02f, -1.32298376e-02f, 9.50448029e-03f, 6.13959283e-02f, -2.70982645e-03f, 1.07812010e-01f, -1.20945707e-01f, 5.89317493e-02f, 3.01249884e-02f,
  8.64481255e-02f, -1.20879740e-01f, 1.31924391e-01f, -1.38837453e-02f, -5.11345677e-02f, 1.53243035e-01f, -1.96825769e-02f, 1.01612523e-01f, -5.95188066e-02f, 1.29746526e-01f,
  -9.50162672e-03f, 6.06537275e-02f, 1.54179111e-02f, 1.13979198e-01f, 8.24883045e-06f, 1.28432259e-01f, -2.37932149e-02f, 1.21568002e-01f, 5.79037778e-02f, 9.94657166e-03f,
  1.00411430e-01f, 7.13767931e-02f, 4.03186195e-02f, -2.43312456e-02f, -1.48319289e-01f, 4.69765626e-02f, 1.24306872e-01f, 8.99937600e-02f, 9.13754776e-02f, 1.17397852e-01f,
  5.25484756e-02f, 4.74558100e-02f, -8.11854005e-02f, -4.52690711e-03f, -8.70954245e-04f, 2.11591408e-01f, 3.66607569e-02f, -7.97782615e-02f, 8.18006471e-02f, -3.31716128e-02f,
  -1.06487229e-01f, -1.59129081e-03f, 5.85225821e-02f, -4.22062725e-02f, 3.57051305e-02f, 1.75334617e-01f, 1.03856862e-01f, -1.10980766e-02f, 7.01195449e-02f, -1.42662646e-02f,
  -3.08178142e-02f, -7.50487819e-02f, -7.57128522e-02f, 8.82247835e-02f, 1.87585860e-01f, 1.54072627e-01f, -2.81744897e-02f, 3.82039584e-02f, 3.03289089e-02f, -4.25413400e-02f,
  4.42071371e-02f, -4.89009358e-02f, 2.23417562e-02f, -3.98868620e-02f, 5.38656488e-02f, 6.88859820e-02f, 1.10849686e-01f, 2.09114134e-01f, 6.37551099e-02f, 1.95204820e-02f,
  1.47429973e-01f, 1.11739971e-01f, 1.38533488e-01f, 8.44764151e-03f, -6.38236851e-02f, 1.35669172e-01f, -6.08691536e-02f, -4.34165634e-02f, 3.01207323e-02f, 1.22899031e-02f,
  -1.23072132e-01f, 7.61115551e-02f, 6.30509555e-02f, -1.17045514e-01f, -1.03854626e-01f, 3.72441806e-04f, 1.20658509e-01f, 8.77971004e-04f, -3.51325721e-02f, 1.45945713e-01f,
  1.20671719e-01f, 8.94228444e-02f, -1.13660790e-01f, -1.10789798e-01f, -1.37046188e-01f, 8.57391730e-02f, 2.57089101e-02f, 2.20499188e-02f, 2.74864025e-02f, -2.92772092e-02f,
  -7.67068639e-02f, -4.87582684e-02f, -9.06094834e-02f, -3.81308980e-02f, 4.77753654e-02f, -1.23591170e-01f, -5.18050902e-02f, -3.20778079e-02f, 7.10359588e-02f, 2.85478425e-03f,
  -4.61853445e-02f, 3.25401038e-01f, 4.53406423e-02f, -5.37540540e-02f, -1.00697510e-01f, -1.15750119e-01f, -6.19657859e-02f, 1.16953567e-01f, -1.89414546e-02f, -6.05609342e-02f,
  1.40594229e-01f, 9.21021029e-02f, 1.03263967e-01f, 1.42969236e-01f, -3.18837017e-02f, 5.57920784e-02f, 1.43229872e-01f, 2.19582133e-02f, -3.27860601e-02f, -2.40478776e-02f,
  1.47968397e-01f, 1.02491446e-01f, -3.99393990e-04f, 1.62981778e-01f, 8.69448408e-02f, 6.31324649e-02f, 9.79882404e-02f, 1.24428794e-01f, 5.82163222e-03f, 1.06473446e-01f,
  1.82023332e-01f, 1.94359869e-02f, -5.75507581e-02f, -3.22603099e-02f, 7.61925429e-02f, -9.73073319e-02f, 1.51915752e-04f, -1.49144456e-01f, 2.86011975e-02f, -3.06802876e-02f,
  9.94829312e-02f, 1.23500258e-01f, -2.05440715e-01f, 4.89190631e-02f, -4.51272689e-02f, 1.09831050e-01f, 3.32004181e-03f, 2.66679917e-02f, 8.44328403e-02f, -5.98645695e-02f,
  1.00652181e-01f, 1.71948671e-01f, -6.79578409e-02f, 2.76552498e-01f, 7.00267702e-02f, -1.06441982e-01f, 1.70052871e-01f, -1.72681287e-01f, 1.24225849e-02f, -5.43092452e-02f,
  1.49599770e-02f, -6.89655691e-02f, 5.46019152e-02f, 1.13446787e-01f, 2.74698645e-01f, -1.51066408e-01f, 1.61839709e-01f, 1.50842816e-01f, 4.19848822e-02f, 1.98130801e-01f,
  1.24768309e-01f, 5.46894893e-02f, 1.38301954e-01f, 7.00058648e-03f, 6.61577135e-02f, 4.93690744e-02f, -5.77962324e-02f, 1.52465068e-02f, 7.94297010e-02f, 8.58757421e-02f,
  6.22791983e-02f, -8.63206536e-02f, 1.38760149e-01f, -4.29326342e-03f, 8.29418600e-02f, 5.56276888e-02f, 1.48401171e-01f, 2.03299206e-02f, 7.53465667e-02f, -1.10205626e-02f,
  8.22156221e-02f, 6.69679344e-02f, -4.04307246e-02f, 9.89157185e-02f, 1.45244002e-01f, 8.20393562e-02f, -1.18977003e-01f, -2.51519307e-02f, 1.30400732e-01f, -7.71376863e-02f,
  -3.90897729e-02f, 8.17397758e-02f, 6.05242625e-02f, 1.38419703e-01f, 9.18031707e-02f, -1.13793679e-01f, -8.81001577e-02f, -9.15017352e-02f, -1.40328914e-01f, -3.51325832e-02f,
  7.67358113e-03f, 1.78953126e-01f, -5.44596910e-02f, -9.87198278e-02f, 1.39889494e-01f, -6.99188635e-02f, -1.05122499e-01f, 1.19443320e-01f, 1.05658390e-01f, 1.15627490e-01f,
  -3.59471291e-02f, 1.12435900e-01f, 1.10021859e-01f, -3.75643671e-02f, -1.67572666e-02f, -1.09577306e-01f, 2.51128767e-02f, 1.09901316e-01f, 1.40027657e-01f, 1.27193153e-01f,
  9.19054672e-02f, 6.08959235e-02f, 9.48349983e-02f, -9.53966677e-02f, 4.96222712e-02f, 4.97339070e-02f, -5.57204597e-02f, 1.29451677e-01f, -3.51909250e-02f, -2.58348770e-02f,
  9.84524749e-03f, -9.16053802e-02f, -8.94600600e-02f, -1.93281174e-02f, -1.47030190e-01f, -4.54172753e-02f, 3.80088165e-02f, 1.14201121e-01f, 2.05175444e-01f, 3.13958317e-01f,
  -1.26170322e-01f, 1.84714779e-01f, -9.35644284e-02f, -2.42276788e-02f, 1.41508013e-01f, 1.10655934e-01f, -1.86259285e-01f, 1.06716648e-01f, 1.10755257e-01f, 1.36616111e-01f,
  1.17752571e-02f, -9.22085997e-03f, 1.69898555e-01f, 1.15288123e-01f, -1.53238386e-01f, 6.35503381e-02f, -6.79818615e-02f, 8.66486412e-03f, 1.85392022e-01f, 9.18177050e-03f,
  -9.14341584e-02f, -1.30420879e-01f, 9.67576206e-02f, 4.80359346e-02f, -9.01713315e-03f, 4.44147848e-02f, -6.07224554e-02f, 1.24842651e-01f, -6.98837042e-02f, -3.49702053e-02f,
  -3.83832939e-02f, 2.34511107e-01f, 2.30154535e-03f, -1.24349520e-01f, 7.50049427e-02f, 2.04872284e-02f, 7.84823224e-02f, 6.06858879e-02f, -5.67396358e-02f, -9.68199596e-02f,
  -9.52348709e-02f, 1.21485732e-01f, 1.56226352e-01f, -1.46117076e-01f, 1.24604449e-01f, -8.57174993e-02f, -1.87676139e-02f, 2.36589927e-02f, -8.44800919e-02f, 1.13958269e-01f,
  1.00285500e-01f, 4.24050819e-03f, -1.14783412e-02f, -6.54196218e-02f, 1.36872172e-01f, 1.34737521e-01f, 1.58050060e-01f, -2.39238907e-02f, -4.59564440e-02f, 7.72952884e-02f,
  -3.45534757e-02f, 2.81372629e-02f, 1.25313967e-01f, 1.65577203e-01f, 1.03224777e-02f, 7.14995489e-02f, 1.38162836e-01f, -2.94212457e-02f, 8.97130892e-02f, -1.57687161e-02f,
  1.31149337e-01f, 1.87502548e-01f, 1.83526836e-02f, 1.49900109e-01f, 2.80769616e-02f, 2.15675876e-01f, 1.01947099e-01f, -8.87078568e-02f, -6.62275851e-02f, -4.25624847e-03f,
  2.06922144e-01f, 2.36681029e-01f, 2.39641387e-02f, -2.75294259e-02f, -4.62983884e-02f, -8.26938450e-02f, -1.30599052e-01f, -1.06755771e-01f, 9.91710722e-02f, 2.25540876e-01f,
  -9.48782638e-02f, 5.80708794e-02f, 5.21836895e-03f, 9.96878818e-02f, 7.14079887e-02f, 9.65996832e-02f, 1.96034741e-02f, 1.96150512e-01f, -7.10234344e-02f, -2.33760215e-02f,
  1.21459924e-01f, 1.03743859e-01f, -7.18259439e-02f, -3.26210819e-02f, 1.53441885e-02f, 3.95854004e-02f, -2.22004205e-02f, -1.90919284e-02f, 1.71603352e-01f, -9.65259075e-02f,
  2.35416740e-01f, 2.84426063e-02f, -2.10138187e-02f, 3.98523994e-02f, 1.24525927e-01f, -1.89273395e-02f, 1.10735513e-01f, 4.90246853e-03f, 7.01815486e-02f, -5.66979535e-02f,
  8.81382450e-02f, 3.57272290e-02f, -1.24373250e-01f, -6.23533390e-02f, 1.21687129e-01f, 6.39323518e-02f, 8.28584433e-02f, 1.69022642e-02f, 6.23432174e-02f, 1.40002966e-01f,
  1.84924945e-01f, 1.48802355e-01f, 1.46607950e-01f, 3.07835583e-02f, -3.19933407e-02f, 1.70642108e-01f, 7.26446211e-02f, 7.58794174e-02f, -1.13238010e-03f, -4.58290093e-02f,
  -1.42936334e-02f, -1.00505032e-01f, -1.75481178e-02f, -6.62175119e-02f, 1.06233455e-01f, 3.23692001e-02f, -6.47138432e-02f, 5.25261089e-02f, -9.52065811e-02f, -4.41205055e-02f,
  9.98364910e-02f, 1.11841589e-01f, -5.97294942e-02f, -1.15131497e-01f, 1.40266255e-01f, -6.63204119e-02f, -1.28720284e-01f, -9.81375054e-02f, -9.32702348e-02f, 1.50857329e-01f,
  -2.55305544e-02f, 2.90000997e-02f, 7.21822353e-03f, -1.25336289e-01f, -1.07840180e-01f, 1.21358424e-01f, 8.85024890e-02f, -1.24090090e-01f, 1.59815833e-01f, 7.63375089e-02f,
  5.44066317e-02f, -3.38514000e-02f, 1.82853043e-01f, 1.65102527e-01f, 4.46301140e-02f, 1.52384818e-01f, 1.83257803e-01f, 5.57659976e-02f, 2.13934645e-01f, -1.09398693e-01f,
  9.61468369e-02f, -5.07842451e-02f, -1.02456272e-01f, 1.27744436e-01f, -7.12119266e-02f, 1.05366655e-01f, 1.34918749e-01f, -3.25167738e-02f, 2.09660351e-01f, 1.04805894e-01f,
  1.17977068e-01f, 9.49161313e-03f, -5.59456535e-02f, 7.18952045e-02f, -2.11988874e-02f, -4.10308465e-02f, -1.77986443e-03f, 1.16455935e-01f, 5.06342854e-03f, 1.59041379e-02f,
  -4.96584214e-02f, -8.19978714e-02f, -9.91337895e-02f, -7.68918097e-02f, -4.56095207e-03f, -1.16913944e-01f, 6.19608723e-02f, 4.48127184e-03f, -6.78617554e-03f, 2.08425056e-02f,
  -3.92515883e-02f, -2.14560200e-02f, 6.23067953e-02f, -1.01332273e-02f, 1.25672564e-01f, 5.83827011e-02f, -9.09324959e-02f, 9.34555233e-02f, -1.23652322e-02f, 1.78275816e-02f,
  -2.11418960e-02f, 2.55938806e-02f, -4.15510833e-02f, 8.59489813e-02f, -1.03438154e-01f, -3.85245457e-02f, -9.15216282e-02f, -5.64661846e-02f, -3.14888880e-02f, 7.28096217e-02f,
  -3.92572843e-02f, -1.12272263e-01f, 1.36585340e-01f, 7.79473335e-02f, -4.54580672e-02f, 1.30509347e-01f, 2.10262276e-02f, 9.51035917e-02f, -1.09649427e-01f, -7.87671581e-02f,
  -3.59020606e-02f, 1.44033562e-02f, 2.58679874e-02f, -8.88973549e-02f, 9.20470431e-02f, -1.13832109e-01f, 7.64896050e-02f, 1.23461448e-01f, 2.40472089e-02f, -7.48287067e-02f,
  -9.74298418e-02f, 4.14656252e-02f, 2.83759832e-02f, -2.26594899e-02f, -2.73500737e-02f, 1.03555791e-01f, -1.15289412e-01f, -7.98910260e-02f, -4.73844111e-02f, 7.53384084e-02f,
  -8.98330137e-02f, -9.14265215e-02f, 1.09903686e-01f, 3.33112963e-02f, -1.05217114e-01f, 9.51904282e-02f, 6.67591766e-02f, -3.77849415e-02f, -1.02397338e-01f, 3.76111232e-02f,
  -9.18218493e-02f, -8.19942430e-02f, -5.70146069e-02f, -1.16591685e-01f, -1.09218813e-01f, -9.58738942e-03f, -1.23452647e-02f, -2.59368271e-02f, -4.15737256e-02f, 2.89252270e-02f,
  -7.25167170e-02f, -1.10509254e-01f, 8.89447853e-02f, -4.26179133e-02f, 5.37537038e-04f, -1.40209377e-01f, -3.99986356e-02f, 5.17659858e-02f, -1.13576882e-01f, 7.57995695e-02f,
  8.82557705e-02f, -5.81497513e-02f, -1.02870867e-01f, 1.12860411e-01f, 1.20591022e-01f, -1.04693957e-01f, -1.10664383e-01f, -3.36834453e-02f, 5.93874604e-03f, 8.60534608e-02f,
  4.72905580e-03f, -1.08923718e-01f, 1.06759250e-01f, 1.23348022e-02f, 6.25916794e-02f, -7.26431757e-02f, 6.75235456e-03f, 2.36321911e-02f, -4.86629829e-02f, 9.80219319e-02f,
  9.60497558e-02f, 3.69503722e-02f, 2.91704275e-02f, -1.09226450e-01f, -1.18601583e-02f, -7.72021487e-02f, 3.96652706e-02f, -5.60220443e-02f, 8.99689421e-02f, -1.23897009e-01f,
  6.06444627e-02f, -1.41649498e-02f, 1.37195298e-02f, -7.66852498e-02f, 1.44069225e-01f, -7.29055032e-02f, -6.45386055e-02f, -9.33582783e-02f, -7.11894706e-02f, 1.07140504e-01f,
  8.76030922e-02f, 8.30893070e-02f, -7.06833676e-02f, -8.88907462e-02f, -2.59430893e-03f, 5.24773146e-04f, 1.16473638e-01f, -1.19087135e-03f, -1.02124877e-01f, 1.18289821e-01f,
  -4.98519950e-02f, 9.92600545e-02f, -1.04088886e-02f, 3.90100405e-02f, 9.23906341e-02f, -9.09886882e-02f, -6.83103513e-04f, -4.47545312e-02f, -1.24547437e-01f, -4.43730503e-02f,
  -1.03187397e-01f, -9.13598835e-02f, 2.04323940e-02f, 4.42477763e-02f, 6.87532350e-02f, -1.09553881e-01f, -6.69425726e-02f, -1.14761904e-01f, 1.19033277e-01f, -5.04429974e-02f,
  1.27863875e-02f, 8.76530930e-02f, -7.35670924e-02f, 1.42515346e-03f, -7.79542699e-02f, 6.20996505e-02f, -8.13713390e-03f, -8.45077783e-02f, 1.53683364e-01f, 7.14361593e-02f,
  -6.71719834e-02f, -4.85011488e-02f, -5.59840985e-02f, -6.90709916e-04f, -4.78731170e-02f, 2.77242195e-02f, -1.52559187e-02f, 8.05302113e-02f, -8.66452232e-02f, 7.09703490e-02f,
  -3.58231775e-02f, 6.52560443e-02f, 8.10206160e-02f, 3.71593721e-02f, -3.68082114e-02f, 9.16683823e-02f, -9.87628326e-02f, 1.37398973e-01f, -4.33504321e-02f, -2.89191883e-02f,
  -1.72131866e-01f, 1.19568676e-01f, 2.52733994e-02f, -3.09949294e-02f, 2.46746913e-02f, 9.58142653e-02f, -2.23691463e-02f, 4.50402722e-02f, 1.94079839e-02f, 9.56601426e-02f,
  1.26038373e-01f, -4.82471548e-02f, 2.12024599e-01f, -3.03803012e-02f, -1.11668907e-01f, 3.82886715e-02f, -5.46281459e-03f, 2.58324631e-02f, 1.74511701e-01f, 1.70024931e-01f,
  2.41380818e-02f, -6.49734363e-02f, 6.97368234e-02f, 1.23540998e-01f, 8.42894912e-02f, 1.19441211e-01f, -7.25676864e-02f, 1.07193552e-01f, -8.91549699e-03f, 5.70030231e-03f,
  3.90626825e-02f, 8.52067024e-03f, -2.38368195e-02f, -1.49776870e-02f, -5.04542701e-02f, 5.51973134e-02f, -1.15794450e-01f, -3.26163098e-02f, 1.37046918e-01f, 4.29745838e-02f,
  4.81213480e-02f, -1.34041771e-01f, 5.08607030e-02f, -1.03679299e-01f, -1.26848787e-01f, 1.01175115e-01f, -1.40673265e-01f, 8.27284381e-02f, 2.85877474e-02f, -9.44611207e-02f,
  1.67643294e-01f, -1.24188431e-01f, -1.16549082e-01f, -5.04110493e-02f, -8.17208737e-03f, 4.92971204e-02f, -4.47256677e-02f, -4.03905436e-02f, 2.44753305e-02f, 1.19907871e-01f,
  1.29969105e-01f, 7.95522779e-02f, -3.93000580e-02f, 3.48084942e-02f, -2.77849175e-02f, 2.58386254e-01f, 1.17771886e-01f, 1.26712590e-01f, 1.21254876e-01f, 4.26268280e-02f,
  -9.25038010e-02f, -2.05908939e-01f, -6.40773997e-02f, 1.80513620e-01f, 1.46418482e-01f, 1.04200631e-01f, -2.72812042e-02f, 7.58931935e-02f, 2.56128222e-01f, -6.09259084e-02f,
  -1.03937425e-01f, 2.68595498e-02f, -2.97290813e-02f, 8.78381506e-02f, -3.04022189e-02f, 3.03245429e-02f, 1.00908451e-01f, 6.11651987e-02f, 1.39371768e-01f, -1.05436265e-01f,
  -1.33038312e-01f, 2.48011619e-01f, 5.11915563e-03f, -1.34281982e-02f, -1.34710327e-01f, -2.78529339e-02f, -6.77368417e-02f, -7.62767484e-03f, 5.41439503e-02f, -1.37742385e-01f,
  6.51889667e-02f, 3.53707850e-01f, -3.08584552e-02f, 1.45702705e-01f, 4.84262779e-02f, 3.86019759e-02f, -1.06289927e-02f, 6.71706796e-02f, -1.45124391e-01f, -1.77079633e-01f,
  -8.70687142e-02f, -8.30317289e-02f, 8.27516764e-02f, -1.10916048e-02f, -6.99280500e-02f, 8.54542553e-02f, 8.61350447e-02f, -9.98440310e-02f, -7.40432441e-02f, 3.47245485e-02f,
  -1.16309393e-02f, 1.96198925e-01f, 6.31757379e-02f, 5.19582536e-03f, 3.55014019e-02f, 1.75158605e-01f, 7.23078027e-02f, 1.47564858e-01f, -6.15332387e-02f, 9.47701409e-02f,
  1.71877518e-02f, -2.44045933e-03f, -6.30306005e-02f, -5.48165590e-02f, -6.42075390e-02f, 7.15631843e-02f, -8.50875974e-02f, 7.02589899e-02f, -1.60498425e-01f, 2.28255019e-02f,
  1.97439194e-01f, 1.47794783e-01f, -1.29121512e-01f, 1.37144715e-01f, 1.82013750e-01f, 4.18023467e-02f, -6.14308938e-02f, -1.23930015e-01f, -9.39692631e-02f, 1.38432026e-01f,
  1.15057305e-01f, -2.01972090e-02f, 2.82284077e-02f, -7.62881339e-02f, -3.71945500e-02f, -8.35370570e-02f, -7.05863023e-03f, 3.53518277e-02f, 2.43123621e-02f, -5.91358505e-02f,
  5.17658517e-02f, 1.81390028e-02f, 8.26455373e-03f, 6.95339218e-02f, 1.59084395e-01f, -1.84293482e-02f, -3.28367464e-02f, 4.75697499e-03f, 4.12638187e-02f, 4.39190641e-02f,
  -1.55491248e-01f, 6.76580071e-02f, 1.44666269e-01f, -2.21159551e-02f, 1.15702182e-01f, 1.94572359e-01f, -2.43688319e-02f, -1.13436848e-01f, -4.93148267e-02f, 5.60636371e-02f,
  1.74622074e-01f, 8.75330269e-02f, -6.96612075e-02f, 5.95414080e-02f, 1.81973577e-02f, 1.38366334e-02f, 1.37237787e-01f, 1.11061990e-01f, 5.99968061e-02f, -4.41875495e-02f,
  -7.98245370e-02f, -7.92658925e-02f, 1.12631731e-01f, -7.73431957e-02f, 1.47462547e-01f, 1.17055215e-01f, 6.11301884e-02f, 1.08132127e-03f, -3.47108692e-02f, 7.78265670e-02f,
  1.19570546e-01f, -7.82344304e-03f, 1.11647826e-02f, 1.15530819e-01f, 9.24481004e-02f, 5.25237285e-02f, -1.50162503e-01f, 1.17776930e-01f, 4.53649722e-02f, 9.39807370e-02f,
  1.66390851e-01f, 4.70312200e-02f, -7.50090331e-02f, 1.84222057e-01f, 6.63262159e-02f, 1.39592707e-01f, 7.91163892e-02f, 7.03301877e-02f, -5.32782860e-02f, 3.20052952e-02f,
  6.18715212e-03f, 1.11405827e-01f, 1.46651268e-01f, 7.76830018e-02f, -9.60882679e-02f, -4.41023819e-02f, 3.57309915e-02f, -1.33166239e-02f, 8.43571573e-02f, 1.63066074e-01f,
  8.21178705e-02f, -1.11607783e-01f, 1.36538118e-01f, 1.48737490e-01f, 2.77128965e-02f, 2.42447890e-02f, 7.33843446e-02f, -1.07346915e-01f, -6.65141419e-02f, -2.18579508e-02f,
  1.32013559e-02f, -3.15668918e-02f, 1.51765257e-01f, 3.84715013e-02f, 8.54790583e-02f, -1.07332118e-01f, 9.36861113e-02f, 5.95005974e-02f, 5.62329181e-02f, 9.60452557e-02f,
  1.27933351e-02f, 8.86854455e-02f, 1.07456587e-01f, 8.41162652e-02f, 1.54586896e-01f, 1.30002886e-01f, 1.23884283e-01f, -2.80451905e-02f, 1.80751592e-01f, 1.78646088e-01f,
  5.56617416e-02f, 1.60924867e-01f, -1.09773660e-02f, -1.66254118e-01f, -5.01525104e-02f, 5.96719049e-02f, 1.74101502e-01f, -4.22032028e-02f, -1.86071828e-01f, -1.05953095e-02f,
  1.08107589e-01f, -7.63883740e-02f, -1.01606853e-01f, -6.00712039e-02f, -4.48490167e-03f, 1.41077349e-02f, 2.43777074e-02f, 1.42046195e-02f, 9.50284451e-02f, 1.33729011e-01f,
  -9.72936377e-02f, 1.52148321e-01f, 2.24565398e-02f, 2.34254841e-02f, -5.49895763e-02f, 1.05355002e-01f, 1.22362308e-01f, 9.69852880e-02f, -2.03206576e-02f, -9.28701740e-03f,
  1.32289110e-02f, 1.46154955e-01f, 2.16806039e-01f, -8.82048812e-03f, 1.60766527e-01f, 1.30513132e-01f, -6.38181642e-02f, -3.93063091e-02f, -1.22189950e-02f, -8.76692832e-02f,
  -9.73997544e-03f, 9.31755602e-02f, -2.65170983e-03f, -1.21008098e-01f, 4.79079895e-02f, 8.79640728e-02f, -4.23133224e-02f, -4.82713580e-02f, -4.21900190e-02f, 7.63601512e-02f,
  1.86404184e-01f, -8.22510496e-02f, -7.49622434e-02f, -1.79806049e-03f, 4.29223441e-02f, 3.74890976e-02f, 6.81206509e-02f, 9.33335274e-02f, 9.50269625e-02f, -1.31105464e-02f,
  9.67913643e-02f, 1.46463700e-02f, -6.01214729e-02f, 5.16726375e-02f, -5.56038916e-02f, 2.03251168e-01f, 1.53101035e-04f, -7.30648860e-02f, -8.53151903e-02f, 1.05635943e-02f,
  1.42273590e-01f, 1.29522800e-01f, -9.34901088e-02f, -1.38031170e-01f, -5.75410239e-02f, -3.96195389e-02f, 9.25048590e-02f, 5.93299009e-02f, 1.14785418e-01f, -2.91078836e-02f,
  -1.23631045e-01f, -2.71683035e-04f, 9.95290950e-02f, 1.28429353e-01f, -5.42569757e-02f, 9.61224176e-03f, 1.49555970e-04f, 1.02409586e-01f, 2.03364971e-03f, -8.90961885e-02f,
  -1.02435857e-01f, -7.76077732e-02f, -8.71819779e-02f, -4.20753099e-02f, 1.49337659e-02f, -1.75457355e-02f, 1.22121759e-02f, 4.30327617e-02f, 1.41293973e-01f, -1.01175994e-01f,
  1.50336578e-01f, -4.72981296e-02f, 1.09836631e-01f, 6.04942963e-02f, 5.34898527e-02f, -1.02172270e-01f, -4.36772890e-02f, -1.01041712e-01f, -2.57779993e-02f, -1.30448863e-01f,
  -9.27868858e-02f, 1.26596456e-02f, -8.34961310e-02f, 4.47905362e-02f, -8.56418982e-02f, -5.70008866e-02f, -6.50494099e-02f, -8.15798193e-02f, 1.39921486e-01f, -9.97703075e-02f,
  -2.11692061e-02f, 2.65815593e-02f, 7.88025633e-02f, -5.73279001e-02f, 1.97871234e-02f, 6.10762462e-02f, 1.29852951e-01f, 2.39854198e-04f, -7.28465617e-02f, -6.42766058e-02f,
  9.75709967e-03f, 3.98430564e-02f, -2.08929665e-02f, 3.57149206e-02f, -7.15073645e-02f, -1.71501622e-01f, 5.80011159e-02f, 1.20214194e-01f, -5.37519529e-03f, -6.16651075e-03f,
  1.38747230e-01f, 1.92724466e-01f, -2.38690758e-03f, -1.15571413e-02f, 1.81678329e-02f, -3.75681259e-02f, 8.43345895e-02f, -1.25429451e-01f, 2.83848476e-02f, 3.27252522e-02f,
  4.74711508e-02f, -3.08877602e-02f, 2.89933681e-02f, -2.28289384e-02f, -3.91498096e-02f, -6.88243583e-02f, -8.01576376e-02f, -4.24791966e-03f, 1.05096839e-01f, 6.06284067e-02f,
  1.28367379e-01f, 3.34097892e-02f, -8.39113146e-02f, 8.27016123e-03f, 9.34131145e-02f, 6.94718510e-02f, 9.25122108e-03f, 2.64226478e-02f, 3.56169194e-02f, 9.04295594e-02f,
  1.16308250e-01f, 2.25971118e-01f, 8.14972911e-03f, -2.99758520e-02f, -7.42758214e-02f, -4.80477065e-02f, 3.73185409e-04f, 1.14087477e-01f, -1.12989448e-01f, 1.42651901e-01f,
  -3.22873704e-02f, 1.12920076e-01f, 6.50315508e-02f, -4.66483459e-02f, 4.11261618e-02f, -7.28545487e-02f, 1.08248936e-02f, 5.47019839e-02f, -6.38269410e-02f, 9.94612649e-03f,
  3.08332988e-03f, 7.65816644e-02f, 1.07614584e-02f, 9.02712718e-03f, -4.76969890e-02f, 1.35447696e-01f, 1.03434645e-01f, -6.40361086e-02f, 5.22575388e-03f, -1.60430856e-02f,
  1.56708673e-01f, 1.86308071e-01f, -1.11932486e-01f, 1.56145379e-01f, -1.73797607e-02f, 1.68098032e-01f, 7.21037462e-02f, -1.15975849e-01f, -2.40500662e-02f, -6.69942796e-02f,
  -2.99332850e-02f, 6.46297559e-02f, -1.82519783e-03f, 2.42299177e-02f, 1.22773521e-01f, -1.26604080e-01f, -8.09367225e-02f, -9.99585167e-03f, -3.31222564e-02f, 6.60301149e-02f,
  5.55051826e-02f, 9.03355256e-02f, 1.07613765e-01f, 1.25526443e-01f, 1.70505434e-01f, 2.03077160e-02f, 2.78544351e-02f, -6.02932870e-02f, -1.56295486e-02f, 8.65816921e-02f,
  -8.27271119e-02f, -8.21293294e-02f, 1.41266346e-01f, 9.15609449e-02f, 1.34942651e-01f, -3.05794664e-02f, 8.66255686e-02f, -1.02539107e-01f, -1.28003761e-01f, -2.90224757e-02f,
  1.61059827e-01f, 1.08208239e-01f, -2.99976114e-02f, 1.11574963e-01f, -2.29519662e-02f, -1.17090978e-01f, -2.54117232e-03f, -4.69856616e-03f, 1.48530379e-01f, 2.14294605e-02f,
  5.20998165e-02f, 1.16978519e-01f, 1.95813283e-01f, 2.46424451e-02f, 4.72785272e-02f, 1.65537238e-01f, 1.09699845e-01f, 5.39712980e-02f, -1.64616153e-01f, -2.22213771e-02f,
  1.49290049e-02f, -1.03938326e-01f, 8.30651000e-02f, 6.48393631e-02f, -1.83059424e-01f, -8.07996318e-02f, -7.76133686e-03f, 7.06793834e-03f, -1.57677196e-02f, 4.06619608e-02f,
  3.64558622e-02f, 6.71122000e-02f, 2.45382022e-02f, 4.95241247e-02f, -3.91656049e-02f, -5.65641597e-02f, -7.31246099e-02f, -9.91212651e-02f, -4.24382649e-02f, -9.04025361e-02f,
  1.20948918e-01f, -7.33488426e-02f, -3.12734172e-02f, -7.75321648e-02f, 6.44819066e-02f, -1.20201789e-01f, -4.49066944e-02f, 7.12804794e-02f, 5.03615364e-02f, 1.15853198e-01f,
  -1.58531982e-02f, 1.10575914e-01f, 3.06709930e-02f, 4.59086858e-02f, 1.86406597e-01f, -4.14877338e-03f, 4.40771319e-02f, -4.52200808e-02f, -2.26731165e-04f, 3.52545641e-02f,
  -3.98118570e-02f, 1.08351484e-01f, 1.15768351e-01f, 1.03527598e-01f, 1.45714059e-01f, 3.53106596e-02f, 1.59935147e-01f, 1.63613096e-01f, 6.79994151e-02f, 8.81082416e-02f,
  1.08745635e-01f, -1.93844996e-02f, 7.42338896e-02f, 8.39763060e-02f, 1.11383371e-01f, 7.98904747e-02f, -1.43222406e-03f, 1.30342208e-02f, -5.32448664e-02f, -6.15124591e-03f,
  -4.12372779e-03f, -9.35845170e-03f, -1.32818639e-01f, 1.53634697e-01f, -1.05643637e-01f, -4.74525690e-02f, -7.19263852e-02f, -1.45833105e-01f, -8.73943195e-02f, 1.17363691e-01f,
  -2.01237071e-02f, -3.29877548e-02f, 1.35748580e-01f, 8.22416320e-02f, 6.92662373e-02f, -3.04591283e-02f, -5.27432300e-02f, 5.22506759e-02f, 3.39882635e-02f, 8.69890377e-02f,
  -2.19267830e-02f, 1.42450184e-01f, 1.09111026e-01f, -3.38785723e-02f, -4.01609614e-02f, -5.42830043e-02f, -7.21068308e-02f, 1.50788547e-02f, -1.16656765e-01f, 2.17844695e-02f,
  -6.75637415e-03f, 3.13511714e-02f, -4.09977362e-02f, -1.00214370e-01f, -2.10802071e-02f, -9.48964879e-02f, -1.11293634e-02f, 1.41318083e-01f, -4.00012732e-02f, 7.47929290e-02f,
  -8.60726461e-02f, 6.34367811e-03f, 1.13261484e-01f, 2.66583520e-03f, 2.42643384e-03f, 2.65390873e-02f, 1.00438237e-01f, 1.75363924e-02f, 1.06705248e-01f, 1.08845718e-01f,
  -3.91060039e-02f, -9.29769129e-02f, 4.40424681e-02f, 9.15996060e-02f, 7.91999698e-03f, -4.99125198e-02f, 1.34646863e-01f, 2.73665935e-02f, 4.52722795e-02f, 2.46233158e-02f,
  4.23567742e-02f, 2.49891520e-01f, 1.43923447e-01f, 2.63474844e-02f, 4.91716638e-02f, 6.70246184e-02f, 1.83372900e-01f, -2.63566580e-02f, -3.56911346e-02f, 1.48967817e-01f,
  -9.82850939e-02f, 5.07302061e-02f, 1.05192669e-01f, -7.56486086e-03f, -8.82739872e-02f, -1.05926335e-01f, 4.02775332e-02f, 3.35233286e-03f, 1.53656512e-01f, 1.34762540e-01f,
  -1.27521018e-02f, 9.18389186e-02f, 1.53958589e-01f, -7.32891634e-02f, 2.32140645e-02f, -1.31457672e-01f, 1.02769822e-01f, 3.07482213e-01f, 1.88944046e-03f, -1.70739880e-03f,
  8.38690177e-02f, -1.36601739e-02f, 1.06905848e-02f, -9.55176726e-02f, 5.86766982e-03f, -4.55627255e-02f, -2.67010126e-02f, 2.82457948e-01f, 1.40694141e-01f, -6.53601736e-02f,
  2.16098338e-01f, 1.25549838e-01f, 6.20769663e-03f, 1.12400614e-01f, 1.11414026e-02f, 5.34935407e-02f, -8.61696228e-02f, -1.90196503e-02f, 3.78886648e-02f, -4.82547395e-02f,
  9.72056836e-02f, 8.27456638e-02f, -1.03327848e-01f, 3.30991112e-02f, 3.66775356e-02f, 1.16580807e-01f, -2.74952650e-02f, -7.01105073e-02f, 3.27020884e-03f, 9.19480547e-02f,
  -6.54928386e-02f, -3.24028987e-03f, 8.66815001e-02f, 5.80422543e-02f, 4.31941114e-02f, -7.45170237e-03f, 1.19162142e-01f, -7.47452825e-02f, -7.91859552e-02f, 1.64538324e-02f,
  6.91845417e-02f, 1.32236019e-01f, -4.43861336e-02f, 1.15047663e-01f, -9.39745978e-02f, 7.57132843e-02f, 5.84242307e-02f, -9.74922534e-03f, -5.56580760e-02f, -7.28597939e-02f,
  1.05872065e-01f, -9.48027372e-02f, 3.22842575e-03f, 4.48344983e-02f, -2.81211622e-02f, 6.77361116e-02f, -9.58131328e-02f, 1.07897751e-01f, -8.67540911e-02f, 8.18694755e-02f,
  -4.64836434e-02f, -3.53923216e-02f, 8.52928087e-02f, -2.37316489e-02f, -3.79651822e-02f, 1.00809895e-01f, 5.56499660e-02f, 6.99301809e-02f, -7.22246468e-02f, 5.19969799e-02f,
  -2.35172380e-02f, -5.47932182e-03f, 5.32657728e-02f, 3.82415392e-02f, 9.02097821e-02f, -3.13008167e-02f, 7.95735195e-02f, 5.57544194e-02f, -4.66847643e-02f, 7.97172189e-02f,
  -1.66192781e-02f, 1.33095318e-02f, -3.22009958e-02f, -1.08972766e-01f, -3.03322840e-02f, -1.05948374e-01f, 1.52768008e-02f, -4.92587350e-02f, 1.24124907e-01f, -4.38146926e-02f,
  6.35885894e-02f, -1.13009557e-01f, -4.67962362e-02f, -3.52112688e-02f, -1.51944505e-02f, 1.03401683e-01f, -1.09769553e-01f, 5.74464956e-03f, -5.20806611e-02f, 1.09332584e-01f,
  -6.63078576e-02f, -3.70241925e-02f, 9.29115862e-02f, 7.68522397e-02f, -1.34677008e-01f, -2.15152698e-03f, -2.77562998e-02f, -1.36221247e-02f, -8.36832151e-02f, 5.34740947e-02f,
  -1.19974457e-01f, -2.80048121e-02f, -8.02236944e-02f, 1.37704760e-01f, 7.46668428e-02f, 1.16688246e-03f, -7.93629661e-02f, 4.84126769e-02f, -7.93241709e-03f, -7.35658333e-02f,
  -1.01975903e-01f, -6.23267218e-02f, -7.76983202e-02f, -1.08932823e-01f, -4.47018445e-03f, -8.83237496e-02f, -1.19753420e-01f, 1.04275055e-01f, 7.31480345e-02f, -7.60219842e-02f,
  -6.87018484e-02f, 9.76214409e-02f, -7.11502433e-02f, -1.14752464e-01f, 7.67841339e-02f, -1.28610075e-01f, -7.94056356e-02f, -1.64714903e-02f, 6.02409951e-02f, -1.01589903e-01f,
  1.64385475e-02f, -7.97292888e-02f, -6.13486134e-02f, -5.31294709e-03f, 4.78184484e-02f, -2.66618580e-02f, -1.08121438e-02f, -6.87646121e-02f, 1.02293089e-01f, 5.72169051e-02f,
  3.97320837e-02f, 3.34684402e-02f, 7.80138969e-02f, -9.63905752e-02f, 1.09934108e-02f, -1.00591686e-02f, 1.04325391e-01f, 1.45952720e-02f, 3.12302057e-02f, 4.17274013e-02f,
  -7.41183311e-02f, -1.17517740e-01f, -1.13665901e-01f, -1.03579737e-01f, -1.02437161e-01f, -1.16193809e-01f, -1.08869538e-01f, 6.82541355e-02f, 1.06608383e-01f, -1.29309028e-01f,
  -7.82519504e-02f, -8.67195129e-02f, -8.57385062e-03f, 5.55841401e-02f, 8.72126371e-02f, -3.49461772e-02f, -4.28530276e-02f, -2.68293247e-02f, -5.03066145e-02f, -8.41252282e-02f,
  1.03200413e-01f, 7.96226859e-02f, -1.89853199e-02f, -6.91777617e-02f, -3.37522179e-02f, -8.82215053e-03f, 7.61704743e-02f, -1.09031148e-01f, -2.97506060e-02f, -1.27198413e-01f,
  1.10989705e-01f, 1.06311262e-01f, 2.43005324e-02f, 3.25467139e-02f, 9.38839745e-03f, -3.77371982e-02f, 8.31015408e-03f, 2.68269476e-04f, -6.26148060e-02f, 2.75810603e-02f,
  2.81909201e-02f, 3.05807926e-02f, -1.01500213e-01f, 6.07841015e-02f, 1.22615537e-02f, 1.02139264e-01f, -1.00838579e-01f, -4.54705767e-02f, -3.97199504e-02f, -4.71928827e-02f,
  -9.32356194e-02f, 1.23499312e-01f, -1.52291032e-02f, 5.28710373e-02f, -5.74190505e-02f, -9.74395499e-02f, -2.84269266e-02f, 6.23718575e-02f, 9.66954455e-02f, 2.15760753e-01f,
  -3.12411990e-02f, 2.55610924e-02f, -8.92630666e-02f, 1.33482516e-01f, -7.85271898e-02f, 3.78198773e-02f, -1.61296412e-01f, 5.84263057e-02f, 5.49788997e-02f, 1.68556482e-01f,
  -1.00987904e-01f, 1.33965373e-01f, 1.70618609e-01f, 1.14855908e-01f, -1.25101134e-01f, -9.68510509e-02f, -4.83160391e-02f, 1.16166264e-01f, 1.18408874e-01f, -2.09407974e-02f,
  -2.28541028e-02f, -3.70803475e-02f, 1.09055467e-01f, -1.72997937e-02f, 3.06354836e-02f, -4.32771295e-02f, -8.99628699e-02f, 7.85814747e-02f, -3.17001343e-02f, -5.78593276e-02f,
  1.25958517e-01f, 7.58038014e-02f, -2.54124086e-02f, -2.27026679e-02f, 1.36827961e-01f, -3.13618705e-02f, 6.10529184e-02f, -3.78112271e-02f, -1.24919862e-01f, 5.99430967e-03f,
  -2.43833940e-02f, 7.08103180e-02f, 4.85562868e-02f, 8.83871242e-02f, 1.91557512e-01f, -9.68314931e-02f, 1.44371033e-01f, 1.26959816e-01f, -2.83095753e-03f, 1.72394942e-02f,
  -1.83542985e-02f, -7.13535175e-02f, 8.27763155e-02f, 1.54617772e-01f, 7.24721625e-02f, -9.18433815e-02f, 8.83335918e-02f, -7.41579980e-02f, 4.50408347e-02f, -1.28704593e-01f,
  1.65407173e-02f, -1.80781819e-02f, -7.08695222e-03f, 1.63299412e-01f, 1.25863984e-01f, -2.77448408e-02f, -1.63228381e-02f, -4.88762446e-02f, -1.06291682e-01f, 1.05163492e-02f,
  2.83960570e-02f, -1.95912924e-02f, 8.28439891e-02f, 2.96572223e-03f, -1.35966957e-01f, 2.82021780e-02f, 6.89641610e-02f, -2.57146321e-02f, -8.07464197e-02f, -1.33709475e-01f,
  -4.70031127e-02f, 5.95205389e-02f, 8.63797311e-03f, 3.55706625e-02f, -1.38425365e-01f, 1.33347465e-02f, 9.26245302e-02f, -3.83811407e-02f, 1.11983083e-01f, 6.62576035e-02f,
  -9.22487229e-02f, 1.25314128e-02f, -9.59798470e-02f, 3.56526822e-02f, 1.08966619e-01f, -6.79615438e-02f, -1.28065437e-01f, -1.30228400e-01f, 6.50522998e-04f, 2.67037582e-02f,
  -4.00972590e-02f, -3.83480638e-02f, 1.25681749e-02f, -7.70356879e-02f, -1.28186494e-01f, -1.83539316e-02f, -1.28093764e-01f, -6.96294159e-02f, -1.07770085e-01f, 3.11671700e-02f,
  7.74215162e-02f, -5.13298288e-02f, -4.70505096e-03f, 2.73027718e-02f, 6.10303022e-02f, -2.47408953e-02f, 1.05251543e-01f, 1.10703245e-01f, -1.55315381e-02f, 2.23338790e-02f,
  -9.64418650e-02f, -1.18701637e-01f, 1.13516606e-01f, 1.07469395e-01f, -4.81087975e-02f, 1.02437548e-02f, 7.34230205e-02f, 5.83447069e-02f, -2.18139496e-02f, 1.27267256e-01f,
  -3.76992486e-02f, -9.16968435e-02f, -1.42500885e-02f, 7.44467154e-02f, 3.38404514e-02f, -1.46336451e-01f, 9.61647108e-02f, -1.08336091e-01f, -6.04453050e-02f, -1.19918182e-01f,
  -1.09822936e-01f, 5.44793671e-04f, 8.94305259e-02f, -4.49013673e-02f, -9.87195000e-02f, 3.83091308e-02f, 1.37914464e-01f, 8.53656232e-02f, 4.46112230e-02f, 8.45522732e-02f,
  8.32180902e-02f, 8.04431140e-02f, -6.66328222e-02f, -7.03686923e-02f, 5.91732562e-02f, 6.60959482e-02f, -6.90216124e-02f, -2.22964678e-02f, 1.24431647e-01f, -1.08516157e-01f,
  6.17672987e-02f, 6.27932255e-04f, -4.04277071e-02f, -4.55401838e-03f, -1.09460533e-01f, 1.07894212e-01f, -9.63502824e-02f, -7.38293305e-02f, 1.05559818e-01f, 2.14788038e-02f,
  1.02523409e-01f, -5.50305797e-03f, -1.65018067e-02f, -8.21953416e-02f, -1.13603748e-01f, 8.46779495e-02f, -1.21360667e-01f, 1.13555036e-01f, 9.77513120e-02f, -1.20300896e-01f,
  5.41508831e-02f, 1.86716206e-02f, -2.89360676e-02f, -7.43490532e-02f, 1.94743350e-02f, -1.03364319e-01f, 3.22629735e-02f, 1.01938590e-01f, -2.89407354e-02f, -4.40508239e-02f,
  2.51850802e-02f, 1.42076403e-01f, -1.03740640e-01f, -3.75900902e-02f, -1.16810910e-01f, 5.63343912e-02f, 5.67433722e-02f, 1.19361833e-01f, -1.17569320e-01f, -8.49801973e-02f,
  -1.40872877e-02f, -5.95826246e-02f, 7.49603519e-03f, 1.81625187e-02f, 1.82956215e-02f, 7.87891373e-02f, -9.21844020e-02f, -1.66255176e-01f, -5.73145924e-03f, 2.11376194e-02f,
  6.94377050e-02f, 2.91374866e-02f, -6.89088553e-02f, -9.49070752e-02f, 1.54442713e-01f, 1.31712154e-01f, -2.06086878e-02f, -1.39131919e-01f, 6.00338243e-02f, -1.47883017e-02f,
  -1.02126293e-01f, 4.92556281e-02f, 4.39227857e-02f, 1.75920621e-01f, 1.33254766e-01f, -6.65861443e-02f, 1.20368764e-01f, -3.98209877e-02f, 5.04115336e-02f, -2.42595114e-02f,
  1.24460245e-02f, 7.87080079e-03f, -7.94070512e-02f, 1.98752508e-02f, 2.89824493e-02f, -5.69189452e-02f, 1.73779707e-02f, 1.05095103e-01f, -1.02266274e-01f, 1.54160991e-01f,
  -1.31678497e-02f, -6.12185337e-02f, 1.23759225e-01f, -2.35912353e-02f, 1.43724650e-01f, 8.11528787e-02f, -3.42306122e-02f, -6.10679723e-02f, -7.06785917e-02f, 3.31762470e-02f,
  7.69026056e-02f, 8.31451546e-03f, 5.83923198e-02f, 2.67269127e-02f, 6.50528669e-02f, -3.31647433e-02f, -1.01431809e-01f, 3.92675027e-02f, -4.56012301e-02f, 2.38651671e-02f,
  -5.10229506e-02f, -3.45385298e-02f, -6.51835948e-02f, 7.95993954e-02f, -1.24199856e-02f, -4.12156731e-02f, -1.06472686e-01f, -1.41718969e-01f, 1.01861157e-01f, 2.22979821e-02f,
  6.33652955e-02f, 4.18368019e-02f, 7.51624769e-03f, -1.50051937e-01f, 4.23616543e-02f, -1.13402374e-01f, -5.77895194e-02f, -6.49049282e-02f, -6.95230290e-02f, 9.31595862e-02f,
  -9.68290418e-02f, -1.29343132e-02f, 9.31619033e-02f, -8.29539523e-02f, -1.30509455e-02f, -9.02022123e-02f, 8.83039758e-02f, 1.01864405e-01f, -1.62145253e-02f, 1.67788882e-02f,
  -6.85410202e-02f, -8.38089511e-02f, 1.48703502e-02f, -2.34216433e-02f, 6.45339340e-02f, 7.98416734e-02f, 6.25564680e-02f, -4.59151193e-02f, -6.43583611e-02f, -3.42800282e-02f,
  -6.14058785e-02f, 1.00552760e-01f, 1.58766489e-02f, 4.24554572e-02f, 3.16625498e-02f, 8.94310176e-02f, -5.27791530e-02f, -1.14905842e-01f, -1.56488344e-02f, -3.03746108e-02f,
  -3.99591494e-03f, 1.05715856e-01f, 4.16697189e-02f, -3.24792787e-02f, 9.57341343e-02f, 1.13506466e-01f, 5.75243197e-02f, 4.55434695e-02f, 1.84580788e-01f, -1.27213001e-01f,
  9.28268507e-02f, 1.16549566e-01f, 1.74247116e-01f, 2.55405426e-01f, 9.92560014e-02f, 1.64595261e-01f, 6.60810471e-02f, 2.59570956e-01f, 1.65746912e-01f, 3.11640531e-01f,
  9.68012661e-02f, 2.09304482e-01f, 3.47344279e-02f, -3.34758103e-01f, -6.20391108e-02f, 2.74092704e-01f, 3.03225994e-01f, 1.91598982e-01f, -1.62416205e-01f, -1.52495108e-04f,
  8.37956071e-02f, -1.83167860e-01f, -1.99571475e-01f, -4.05024365e-02f, 2.60025829e-01f, 1.24783427e-01f, 1.38973296e-01f, -6.02667220e-02f, 1.16894767e-01f, 1.52091816e-01f,
  3.29533480e-02f, 8.23480710e-02f, 7.24997148e-02f, 2.03709707e-01f, 1.30529255e-02f, -1.89173937e-01f, 8.45355466e-02f, 2.09501222e-01f, 9.63301435e-02f, -1.00780331e-01f,
  -7.65138343e-02f, 6.47553280e-02f, 1.86876237e-01f, 5.96014485e-02f, 1.83944196e-01f, -2.60125473e-02f, 2.98826575e-01f, 1.00256577e-01f, 1.91649437e-01f, 1.12065747e-01f,
  4.49871868e-02f, 2.48386145e-01f, -4.48193513e-02f, -2.65308082e-01f, -2.48210989e-02f, -9.69505072e-06f, 1.28985852e-01f, -8.08982253e-02f, -1.64660469e-01f, 1.03376910e-01f,
  1.80567667e-01f, 1.87578537e-02f, 7.15790763e-02f, 6.44560829e-02f, 9.56861377e-02f, 1.74879760e-01f, 2.06221253e-01f, -3.32494639e-02f, 1.91103756e-01f, 1.66840240e-01f,
  1.21919654e-01f, 1.92552701e-01f, 1.65717021e-01f, 1.22138597e-01f, 6.36879504e-02f, 1.76070973e-01f, 1.66728705e-01f, -2.99899783e-02f, 2.89272089e-02f, 2.02973515e-01f,
  -2.15050336e-02f, 1.33498862e-01f, 5.48098274e-02f, -1.59769654e-01f, 1.80594772e-02f, 6.27125939e-03f, 1.25117209e-02f, 8.58504027e-02f, 9.49461460e-02f, 2.10695520e-01f,
  -8.13577548e-02f, 9.50867161e-02f, 8.96754563e-02f, -6.63347766e-02f, 5.85371964e-02f, -1.09072022e-01f, 5.42431977e-03f, 2.75220037e-01f, -9.70224943e-03f, -2.85571944e-02f,
  1.52053490e-01f, -8.76695588e-02f, 1.00819334e-01f, 2.52400618e-02f, 1.42440479e-02f, 4.82722595e-02f, -1.27076074e-01f, 2.30981201e-01f, 2.43486650e-02f, 1.96591159e-03f,
  2.54914999e-01f, -5.54949269e-02f, 5.23114949e-02f, 1.05914593e-01f, 5.55677190e-02f, 7.15318918e-02f, -8.33508372e-02f, 3.79774645e-02f, 1.32067963e-01f, -4.23602760e-03f,
  -2.21044687e-03f, 8.95928890e-02f, -1.00645944e-01f, -6.85170963e-02f, 5.06765172e-02f, -1.03058688e-01f, -1.19407363e-01f, -8.05101618e-02f, 1.07928249e-03f, 9.08516198e-02f,
  -1.87210161e-02f, -2.15474255e-02f, 1.26495790e-02f, -6.43261196e-03f, -1.14597611e-01f, -6.96863607e-02f, 7.48583153e-02f, 9.54246894e-02f, -4.20215493e-03f, 1.31540820e-01f,
  1.23564608e-01f, 9.63381212e-03f, 1.21873185e-01f, -7.90203139e-02f, 7.62257203e-02f, 8.50148797e-02f, -5.22758998e-03f, -2.63229497e-02f, 1.38854533e-01f, 7.39524364e-02f,
  -4.87085506e-02f, -1.08132601e-01f, -3.87636051e-02f, -7.91415423e-02f, 4.39166278e-02f, 8.21710452e-02f, 3.51245664e-02f, -5.43632284e-02f, 4.81567904e-02f, 6.86497465e-02f,
  -1.10930882e-01f, 8.26515781e-04f, 2.73272265e-02f, -4.74484841e-04f, -2.36200262e-02f, -5.02403826e-02f, 4.75146296e-03f, 8.66492689e-02f, 8.25059135e-03f, -1.01696752e-01f,
  -8.38149562e-02f, -1.74257010e-02f, -1.24763763e-02f, -8.44161138e-02f, -1.19985782e-01f, -7.81867355e-02f, -4.19154093e-02f, 3.63870221e-03f, -1.05545260e-01f, -1.08031809e-01f,
  -6.75651506e-02f, 9.04929191e-02f, -1.29448846e-01f, -1.04254350e-01f, -3.42513248e-02f, -3.84689979e-02f, -1.47016682e-02f, 1.08379446e-01f, 5.79633527e-02f, -7.34994141e-03f,
  -5.78650162e-02f, 2.27193758e-02f, -3.82531323e-02f, 3.27062383e-02f, 1.52803347e-01f, 6.90441653e-02f, 6.63921684e-02f, 5.60743213e-02f, -2.42503509e-02f, 4.30634655e-02f,
  2.71433480e-02f, 1.19306363e-01f, 4.04733699e-03f, -3.34362611e-02f, 7.49254227e-03f, 3.81318368e-02f, 1.04398780e-01f, -1.21173626e-02f, -4.56377119e-02f, -1.53760254e-01f,
  -1.00829341e-01f, 1.19364433e-01f, -1.22299962e-01f, 1.24199942e-01f, 6.75944909e-02f, 3.21914852e-02f, -1.34661108e-01f, -1.84989162e-02f, -1.11928701e-01f, -1.07189275e-01f,
  -1.26243323e-01f, 6.94109872e-02f, -2.64333244e-02f, 6.33891970e-02f, 7.27985650e-02f, -1.12914303e-02f, 1.47437960e-01f, -3.21367867e-02f, 4.59467899e-03f, 5.41127920e-02f,
  1.01153903e-01f, 7.50187710e-02f, 6.94719255e-02f, -3.56869102e-02f, 1.73861887e-02f, 4.04429212e-02f, -3.39376293e-02f, -1.00028649e-01f, -1.79229230e-02f, -1.20123476e-02f,
  1.03289589e-01f, -6.03163019e-02f, 3.00100427e-02f, -5.15801348e-02f, -4.76743504e-02f, -1.03983488e-02f, -1.29494378e-02f, 1.06684506e-01f, -7.72782266e-02f, -1.96462329e-02f,
  4.54033762e-02f, -5.47704063e-02f, 4.72723856e-04f, 9.31102112e-02f, 4.17847149e-02f, 3.27449245e-03f, 2.96111871e-02f, 1.14981025e-01f, 1.34462938e-01f, 2.19171289e-02f,
  9.55952778e-02f, 5.36515601e-02f, 1.08430989e-01f, -2.76841340e-03f, 5.27400859e-02f, -2.60385927e-02f, 3.07978466e-02f, 3.17218266e-02f, 3.75853442e-02f, 4.72533032e-02f,
  2.60168165e-02f, -1.63672690e-03f, 4.19717506e-02f, -1.00921132e-01f, -1.37863338e-01f, 1.39083356e-01f, -1.04966477e-01f, 1.26772285e-01f, -6.59034252e-02f, 1.82048187e-01f,
  -6.91268891e-02f, -1.03615098e-01f, -9.09568667e-02f, -1.10571019e-01f, -9.26268548e-02f, -9.60369334e-02f, -1.82251707e-02f, 9.95180160e-02f, 1.07456051e-01f, -8.43653232e-02f,
  5.94051592e-02f, -9.72186401e-02f, 8.41636658e-02f, 9.80273560e-02f, 2.76903864e-02f, 1.00052483e-01f, 9.06180963e-02f, -2.04998571e-02f, -6.01249654e-03f, -7.36178905e-02f,
  1.19094044e-01f, -8.61594155e-02f, -1.19589753e-01f, 1.55482396e-01f, -3.00715882e-02f, 7.28452504e-02f, 1.82984956e-02f, -4.19370905e-02f, 1.27126174e-02f, 1.05269440e-01f,
  2.43034959e-02f, -1.08779017e-02f, -3.46827209e-02f, -5.42719569e-03f, 6.74198419e-02f, 4.19835933e-03f, 1.37543857e-01f, 7.53532350e-02f, -1.08469807e-01f, 4.87790480e-02f,
  3.16687115e-02f, -8.87528509e-02f, -4.24447283e-02f, -9.37486663e-02f, 8.64284486e-02f, 3.02333571e-02f, 9.70877260e-02f, -4.74268291e-03f, -6.15996383e-02f, -7.48841674e-04f,
  8.67302865e-02f, -6.21756762e-02f, -4.22809944e-02f, 2.99185440e-02f, -8.18972588e-02f, -1.69943292e-02f, 1.22781261e-03f, 3.86336818e-02f, -2.00825334e-02f, -4.67492603e-02f,
  7.54340887e-02f, -1.93218198e-02f, 7.08915070e-02f, 2.28749570e-02f, 7.72199258e-02f, -1.31527007e-01f, -7.35383481e-02f, -7.94521272e-02f, -8.68768543e-02f, -9.94400382e-02f,
  9.65517014e-02f, -9.33782309e-02f, -2.78436281e-02f, -6.67554662e-02f, 5.43902703e-02f, 5.98960370e-02f, -6.26295879e-02f, -4.79265340e-02f, 3.01429946e-02f, -1.19265929e-01f,
  7.27662221e-02f, -8.88837948e-02f, -9.15784612e-02f, 4.04025428e-03f, 2.76147407e-02f, 1.26517728e-01f, -1.17585443e-01f, 8.99179652e-02f, 1.10873759e-01f, -1.65056959e-02f,
  5.96990362e-02f, -9.46335681e-03f, -2.61818711e-02f, 1.19550116e-01f, -5.85058182e-02f, 9.62274522e-02f, -1.20168805e-01f, 3.22562754e-02f, 3.68794203e-02f, 1.87188089e-02f,
  -1.02091998e-01f, 6.72517344e-02f, 2.49443427e-01f, 8.53763446e-02f, -1.53636739e-01f, 1.37411520e-01f, 6.34853146e-04f, 1.81731269e-01f, -2.39478629e-02f, 1.28676757e-01f,
  2.25126594e-02f, -4.93238121e-03f, 1.28182083e-01f, 9.81028304e-02f, 1.51899159e-01f, 1.44508123e-01f, 4.12930399e-02f, 6.25839084e-02f, -1.23561569e-01f, -4.25678641e-02f,
  1.10066280e-01f, -1.38398364e-01f, 7.44924322e-02f, -5.58877625e-02f, -1.13900930e-01f, 9.71714556e-02f, 1.30824804e-01f, 2.38499939e-01f, -4.59223427e-03f, -1.09453931e-01f,
  1.44204423e-01f, -1.24418605e-02f, -1.25219092e-01f, 1.94076300e-01f, -4.94687119e-03f, 3.61006916e-01f, 1.59146413e-01f, -2.22299248e-02f, 5.62461913e-02f, -1.24715559e-01f,
  1.61013827e-01f, -4.09176461e-02f, -3.74159217e-02f, -1.29343674e-01f, -6.95271492e-02f, 1.42078146e-01f, 3.08571100e-01f, -2.48962194e-01f, 2.00311586e-01f, 8.59697685e-02f,
  2.10298318e-02f, 1.13299169e-01f, -5.64748701e-03f, 6.67563304e-02f, 2.75786430e-01f, 1.48534045e-01f, 8.62341821e-02f, -1.21438086e-01f, 1.30950948e-02f, 1.40141115e-01f,
  5.70933893e-02f, 1.09851941e-01f, -6.51948452e-02f, 5.60244396e-02f, 1.88995190e-02f, 2.61570811e-02f, 4.82432684e-03f, -1.32639334e-01f, 1.00192271e-01f, -2.07236167e-02f,
  3.29842985e-01f, 2.00047106e-01f, 1.64152443e-01f, 1.60949156e-01f, 2.59422451e-01f, 1.75032690e-01f, 1.62730843e-01f, 1.86177731e-01f, -3.76776867e-02f, -1.23220809e-01f,
  -3.35347652e-01f, -1.35109127e-01f, 1.55349061e-01f, -2.37853676e-02f, -1.29301056e-01f, -1.26400486e-01f, 1.41413677e-02f, 1.12170815e-01f, -3.07783838e-02f, 2.23149270e-01f,
  1.66463107e-01f, 1.21672273e-01f, -1.09005429e-01f, -9.34592262e-02f, 3.98073085e-02f, 3.41202468e-02f, -1.86586361e-02f, -3.01882718e-02f, 7.65295923e-02f, 1.35998711e-01f,
  -3.08586378e-03f, -6.14331178e-02f, 9.84979868e-02f, 4.27887104e-02f, -1.20440431e-01f, -1.01604752e-01f, 1.64045811e-01f, 6.51309714e-02f, 1.34293996e-02f, -4.53529656e-02f,
  2.23601032e-02f, 3.64894181e-01f, -1.08223364e-01f, 2.40297571e-01f, -6.73374310e-02f, 1.49632860e-02f, 8.91365185e-02f, 8.17938000e-02f, 8.23919773e-02f, -3.05128284e-02f,
  2.03430489e-01f, 1.71343565e-01f, -1.32244989e-01f, -6.03932030e-02f, 8.03369433e-02f, -5.13577983e-02f, 5.01027033e-02f, -1.45321712e-03f, 1.21316962e-01f, -1.65386759e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.23433985e-01f, 7.65538514e-02f, -3.66192609e-02f, 1.61574364e-01f, -1.98543202e-02f, 2.15306535e-01f, 7.02998117e-02f, 1.82677567e-01f, 1.72658656e-02f, 4.49639224e-02f,
  -6.00428134e-02f, 2.12870613e-02f, -1.03647880e-01f, -3.29244100e-02f, 2.46040579e-02f, 1.29807115e-01f, -4.29560244e-02f, -4.53153439e-02f, 9.95152071e-02f, -6.75326511e-02f,
  -1.01929503e-02f, -5.86186461e-02f, -7.83392135e-03f, 7.44035840e-02f, 1.01159476e-01f, -1.07093520e-01f, 1.05013959e-01f, 1.20473810e-01f, 5.56630455e-02f, -3.85030657e-02f,
  3.04265935e-02f, -8.55777785e-02f, 2.04677075e-01f, 6.83492124e-02f, -2.87803560e-02f, 6.32343143e-02f, 1.09159745e-01f, -3.53119597e-02f, 8.35356340e-02f, 1.90652266e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.19873606e-01f, -4.46037091e-02f, 1.96154397e-02f, -5.57873771e-02f, 6.79188818e-02f, -3.38089988e-02f, -1.09638125e-01f, -2.53358006e-01f, -7.76839033e-02f, -7.80921802e-02f,
  6.14762045e-02f, 1.09790921e-01f, 8.65764990e-02f, -1.06894046e-01f, 7.66544491e-02f, 2.59927958e-01f, 1.69303596e-01f, -1.21113978e-01f, 1.23706192e-01f, 1.50763065e-01f,
  -1.26881376e-01f, -5.16661070e-02f, 1.64767459e-01f, -3.26727271e-01f, -1.16662554e-01f, 8.42526257e-02f, 1.15403250e-01f, 4.88009155e-02f, 1.31196514e-01f, 8.69781896e-02f,
  1.06623573e-02f, -7.83688650e-02f, -1.92727759e-01f, -1.62813440e-02f, 4.94681001e-02f, -7.06664026e-02f, 7.94592127e-02f, 1.31983301e-02f, 1.50181698e-02f, 1.07577913e-01f,
  -8.78456533e-02f, 1.37624238e-02f, -1.42550588e-01f, -8.04081634e-02f, -9.13917944e-02f, -3.36881913e-02f, 1.56038590e-02f, -1.07062355e-01f, 4.90292199e-02f, -5.57946861e-02f,
  -5.49936853e-02f, 1.09612010e-02f, -6.72497377e-02f, 1.32050455e-01f, -5.25594829e-03f, 4.41126227e-02f, -4.52845283e-02f, -7.14069009e-02f, -1.16859913e-01f, 7.40469471e-02f,
  1.32531181e-01f, 1.25637457e-01f, 3.89680974e-02f, 2.79919863e-01f, 1.02984615e-01f, -7.32524693e-02f, 1.73319373e-02f, -8.97565857e-02f, 3.50650437e-02f, -9.09300372e-02f,
  1.67617425e-01f, 2.30124190e-01f, -8.40800032e-02f, 3.75652798e-02f, -1.26931548e-01f, 7.61821195e-02f, -7.53439665e-02f, 2.58560866e-01f, -1.10875085e-01f, -1.40784994e-01f,
  -2.10794181e-01f, -7.13033825e-02f, 8.67337175e-03f, -3.32557131e-03f, 2.47601449e-01f, -7.46501163e-02f, 1.47094458e-01f, -3.24089400e-04f, -1.64002508e-01f, 6.48436174e-02f,
  -5.36016077e-02f, 9.77220833e-02f, -2.21357226e-01f, -4.56740297e-02f, 7.85378516e-02f, 4.79803383e-02f, 1.60886630e-01f, -7.20266998e-02f, 2.46896613e-02f, -2.08653347e-03f,
  -4.78512719e-02f, 1.29717052e-01f, -1.28149688e-01f, -8.11470002e-02f, 2.82213911e-02f, 1.35684669e-01f, 2.82462221e-02f, -1.30696446e-01f, -9.81817469e-02f, -1.04282565e-01f,
  -1.17262952e-01f, 5.49821742e-02f, 5.82711957e-02f, -6.25159070e-02f, -7.33696073e-02f, 7.18197674e-02f, -9.80792120e-02f, -1.13860913e-01f, -1.43296018e-01f, 5.59893139e-02f,
  3.61943603e-01f, 4.76116613e-02f, 7.64927343e-02f, -9.46123451e-02f, -1.62417740e-01f, -9.79249328e-02f, -5.72859962e-03f, -2.88630098e-01f, -1.00685671e-01f, 1.29345298e-01f,
  -1.49754873e-02f, -3.64354774e-02f, 6.81546777e-02f, -7.49763995e-02f, 7.94232339e-02f, 2.52734154e-01f, 8.91150460e-02f, 4.26934697e-02f, 1.05955757e-01f, 1.12192899e-01f,
  -2.02908218e-01f, -2.14673758e-01f, 4.52618906e-03f, -1.32101730e-01f, 2.82475829e-01f, 3.44647706e-01f, -4.89711389e-03f, -5.53269982e-02f, 5.95573522e-02f, 1.38506398e-01f,
  -2.79772341e-01f, 1.96396083e-01f, 1.86660200e-01f, 8.16014316e-03f, 1.12337582e-01f, 1.37835622e-01f, 9.32287574e-02f, 1.02278545e-01f, 2.16072872e-02f, 1.93442434e-01f,
  5.70282005e-02f, -1.03350416e-01f, 1.62033793e-02f, 6.26938269e-02f, -3.61933969e-02f, 7.44476095e-02f, -2.55020618e-01f, 1.01690084e-01f, 5.91104850e-02f, -8.32987800e-02f,
  4.73439023e-02f, 1.26726508e-01f, -5.63853569e-02f, -6.81783184e-02f, 1.23817936e-01f, -1.47266239e-02f, 1.40959427e-01f, 7.71642402e-02f, -7.60160983e-02f, 3.37449200e-02f,
  1.72468841e-01f, -3.07183489e-02f, -5.73692024e-02f, 5.80958724e-02f, -3.32626700e-01f, -7.11348802e-02f, -1.06952518e-01f, -6.98809186e-03f, 3.56336534e-02f, -1.15137026e-01f,
  1.35213941e-01f, -7.63342753e-02f, -1.45507911e-02f, 3.39731798e-02f, -2.85920668e-02f, -9.12463143e-02f, -2.08516210e-01f, -1.12507790e-01f, 6.60610050e-02f, 7.08795488e-02f,
  3.91476875e-04f, -1.24582745e-01f, -7.82375708e-02f, -5.80961369e-02f, -8.19235891e-02f, -1.96454301e-01f, -4.53387015e-02f, 4.74361237e-03f, 3.00566941e-01f, -1.60873875e-01f,
  -8.85517523e-02f, 1.27241001e-01f, 1.15263604e-01f, 9.55902040e-02f, -4.07911725e-02f, -4.00539823e-02f, 2.90481560e-02f, 1.03939287e-01f, -7.94498771e-02f, 1.01223916e-01f,
  -1.20051011e-01f, 2.94506922e-02f, -2.21644845e-02f, 3.54357902e-03f, -1.11445338e-01f, 1.52200818e-01f, -4.46207039e-02f, 9.92884859e-02f, 3.85173187e-02f, -3.89229367e-03f,
  -1.80887610e-01f, 5.62802069e-02f, -5.12264743e-02f, -4.18937728e-02f, 5.88413738e-02f, 1.46009743e-01f, 1.52577072e-01f, -9.77962278e-03f, -3.49964499e-02f, -1.98166281e-01f,
  -7.83551931e-02f, 9.58477147e-03f, -2.95562241e-02f, -9.68545005e-02f, 1.76901417e-03f, 3.75408120e-02f, -1.47661315e-02f, 1.48199331e-02f, -1.11792676e-01f, -2.43649408e-02f,
  1.11635424e-01f, 1.42994553e-01f, 9.80623811e-03f, 4.88736620e-03f, 3.80709507e-02f, 9.37894657e-02f, 1.83258966e-01f, -1.36215510e-02f, -1.32915407e-01f, -1.11323200e-01f,
  -1.30130798e-01f, -8.05569217e-02f, -1.42455876e-01f, -1.72662541e-01f, 8.26981440e-02f, 8.12051147e-02f, -3.46622691e-02f, 2.33521871e-02f, 1.66076913e-01f, 1.69854108e-02f,
  3.42374258e-02f, 7.00738579e-02f, -1.03721851e-02f, -2.89440248e-02f, 1.70265600e-01f, 1.40581280e-01f, -1.70935228e-01f, -2.07739025e-02f, -7.22744167e-02f, -1.34239793e-01f,
  1.77038744e-01f, -8.70892927e-02f, -3.87242879e-03f, 5.37178107e-02f, 5.79394177e-02f, -1.69557750e-01f, 1.14420556e-01f, -1.51174933e-01f, 3.23003493e-02f, -5.95060224e-03f,
  -3.14800218e-02f, 3.54441591e-02f, -9.78448465e-02f, -8.32557306e-02f, -7.39396038e-03f, -5.81068993e-02f, -4.12791828e-03f, -5.02195098e-02f, 5.41616157e-02f, 1.47647083e-01f,
  -6.40803277e-02f, 7.07454607e-02f, 1.82885285e-02f, 1.02948174e-01f, -1.29951864e-01f, 6.64386377e-02f, 9.15538147e-02f, -1.73531771e-01f, 6.12768866e-02f, 9.07553732e-03f,
  -9.75455344e-02f, -8.55388213e-03f, 1.25294462e-01f, 1.92239240e-01f, 7.54884705e-02f, -8.25432241e-02f, -7.14717805e-02f, 1.37379780e-01f, -2.40974337e-01f, 1.33434981e-01f,
  -8.69257450e-02f, 5.58269396e-02f, -1.83192968e-01f, 5.72157614e-02f, -1.00302570e-01f, 7.61281028e-02f, -1.38264731e-01f, 7.52243176e-02f, 1.69835538e-02f, -3.67680890e-03f,
  -1.92575827e-02f, -2.24490426e-02f, -2.39028633e-01f, -1.63344517e-01f, -2.06418574e-01f, -2.19996780e-01f, 1.53491255e-02f, 3.49086285e-01f, 1.57930460e-02f, -1.82409510e-01f,
  7.57885724e-02f, 8.51221159e-02f, -1.78353027e-01f, 2.38903210e-01f, 9.40334871e-02f, 4.89824302e-02f, -3.23759876e-02f, 1.52646720e-01f, 7.25678876e-02f, -8.86756834e-03f,
  1.48876682e-01f, 2.19744034e-02f, 2.86661386e-02f, -1.34104192e-01f, -9.44256261e-02f, 7.53831118e-02f, -4.57117483e-02f, 6.31709546e-02f, -1.10207967e-01f, 1.64239570e-01f,
  1.53815180e-01f, -1.34233609e-01f, -1.25994205e-01f, 1.52575612e-01f, -3.30133028e-02f, -1.45606115e-01f, -6.56122044e-02f, 5.15108444e-02f, 1.10447757e-01f, -8.37200806e-02f,
  -2.55552828e-02f, 1.56634927e-01f, 7.07813278e-02f, 8.46996382e-02f, 1.23755999e-01f, -3.59676071e-02f, -2.36988366e-01f, 5.58313243e-02f, -1.33743331e-01f, 1.09089360e-01f,
  7.29366094e-02f, 8.43339786e-02f, -5.05418591e-02f, -3.17888781e-02f, 1.16552059e-02f, -5.85880987e-02f, -7.98590481e-02f, -3.78574431e-02f, -1.05000794e-01f, 1.07355183e-02f,
  -1.83024779e-01f, -1.35481387e-01f, -5.62385134e-02f, -5.04388362e-02f, -5.43394350e-02f, -9.76701602e-02f, 5.96359521e-02f, -2.26450071e-01f, -2.04249099e-01f, 5.02238050e-02f,
  -6.31573647e-02f, 2.66093552e-01f, 1.09362207e-01f, -1.36427566e-01f, 1.52344732e-02f, 1.06562905e-01f, -1.26055479e-01f, 1.04764096e-01f, 2.15977207e-01f, 3.21368240e-02f,
  3.85468304e-02f, -6.56570122e-02f, 1.24155335e-01f, 1.19219780e-01f, 8.89355615e-02f, 1.44370541e-01f, -3.99841703e-02f, -1.58461124e-01f, 7.85342231e-03f, -3.99478972e-02f,
  -7.06852078e-02f, 1.50146604e-01f, -1.45509362e-01f, 1.41270325e-01f, 1.01230711e-01f, -5.69096953e-02f, 6.40655905e-02f, 4.91231196e-02f, 2.03879148e-01f, 5.40641770e-02f,
  -1.55518958e-02f, 4.91666161e-02f, -1.03624202e-01f, 7.48077482e-02f, 3.24072652e-02f, 3.91503312e-02f, 4.19710353e-02f, -3.38566527e-02f, -3.38032842e-02f, 1.73877906e-02f,
  -1.55448049e-01f, 1.08794957e-01f, -1.32313417e-02f, 3.32731456e-02f, 3.63950618e-02f, 4.17671874e-02f, -6.18834374e-03f, 1.07026003e-01f, -2.23220795e-01f, -1.12747483e-01f,
  -2.97252741e-03f, 6.54835179e-02f, -9.13486183e-02f, 4.91185039e-02f, -1.72122851e-01f, -1.47908866e-01f, 1.83479779e-03f, 2.89739650e-02f, 5.52559197e-02f, -9.12552141e-03f,
  3.85736078e-02f, -2.80082852e-01f, -1.85586046e-02f, 1.17436036e-01f, 2.98878014e-01f, 1.50270432e-01f, -2.23830082e-02f, -8.34957510e-02f, -2.49404699e-01f, -4.40326408e-02f,
  -8.05650726e-02f, -1.78467661e-01f, 1.43062934e-01f, 1.18812136e-01f, 1.45131394e-01f, 1.22270152e-01f, 1.32793888e-01f, -9.51537490e-02f, -1.22754619e-01f, 5.85722029e-02f,
  -2.05564395e-01f, 7.11188838e-02f, -7.98963606e-02f, 1.25581343e-02f, -1.18984729e-01f, -5.34938760e-02f, 5.60834743e-02f, 7.90896341e-02f, 4.98002693e-02f, -1.57790944e-01f,
  -7.20755309e-02f, 1.36280715e-01f, 3.83195281e-02f, 6.62364364e-02f, 3.94677296e-02f, -8.81510749e-02f, -1.00777961e-01f, -4.11922000e-02f, -1.09749520e-02f, 9.05079916e-02f,
  -1.58389509e-02f, 1.25919044e-01f, 8.57402161e-02f, 1.43733844e-01f, -3.75709534e-01f, -1.78343400e-01f, -1.03544332e-01f, 1.11103274e-01f, -2.45061945e-02f, -7.51414225e-02f,
  -9.86471921e-02f, 2.47983634e-01f, 9.55531150e-02f, 4.79162447e-02f, 2.37744916e-02f, 1.22584619e-01f, 8.07971209e-02f, 1.61019161e-01f, 1.36033133e-01f, -6.73187301e-02f,
  1.26015529e-01f, 1.18574798e-01f, 8.65375530e-03f, -6.10226877e-02f, 3.58481184e-02f, -2.70901900e-02f, -4.36387770e-02f, 1.43341243e-01f, 2.58177251e-01f, -6.63252622e-02f,
  3.92117091e-02f, 1.04202054e-01f, 5.14934994e-02f, 3.23088765e-02f, 7.62474015e-02f, -1.73456505e-01f, -1.41170308e-01f, 7.56237730e-02f, 1.53645307e-01f, -1.01502053e-01f,
  6.14399798e-02f, 4.91545573e-02f, -1.20093122e-01f, -2.64337752e-03f, -1.56492114e-01f, 9.48418379e-02f, 8.69458467e-02f, 6.61869794e-02f, 4.88409959e-02f, -2.91171297e-02f,
  6.99791731e-03f, -5.09913377e-02f, -7.32425153e-02f, -7.36695603e-02f, -2.89538899e-03f, 1.23242646e-01f, 1.34650171e-01f, 1.55191705e-01f, -3.84802632e-02f, -2.37640738e-01f,
  2.90055815e-02f, 6.11142255e-02f, 9.47047770e-02f, 4.66997772e-02f, -7.88854212e-02f, 2.61236653e-02f, 1.24316849e-01f, 9.40309465e-02f, -2.36379251e-01f, -1.77815706e-01f,
  2.89236428e-03f, 2.73751225e-02f, 8.12182669e-03f, 1.28161699e-01f, 1.34364769e-01f, 1.74441651e-01f, 1.01927012e-01f, -6.21485598e-02f, 1.08107902e-01f, 7.68106356e-02f,
  -3.19845341e-02f, -8.98505375e-02f, 6.93972856e-02f, 8.85116607e-02f, 5.61275370e-02f, -1.22358680e-01f, -2.71325279e-02f, -9.47883055e-02f, -7.23603070e-02f, 1.33729950e-01f,
  8.17479715e-02f, -1.04791924e-01f, -2.14539066e-01f, 1.20579220e-01f, 1.03427596e-01f, -4.21592295e-02f, 3.05859335e-02f, -1.24247320e-01f, -1.37863783e-02f, 2.04551488e-01f,
  -1.55716047e-01f, -8.17738101e-02f, 1.07512757e-01f, 1.32409632e-01f, -1.31886795e-01f, -7.03230351e-02f, 1.58824846e-01f, 7.42402375e-02f, 1.45518899e-01f, -9.84898731e-02f,
  -8.13658088e-02f, 6.45516068e-02f, 3.25831324e-02f, 1.93959117e-01f, 7.64628053e-02f, -2.24680588e-01f, -1.20719830e-02f, -3.93988639e-02f, 1.32135883e-01f, -1.34322912e-01f,
  -9.47691053e-02f, -2.46802773e-02f, -7.14996159e-02f, 8.27849470e-03f, 4.69212979e-02f, 8.67693797e-02f, 5.65184914e-02f, 1.17319273e-02f, -3.93675268e-02f, -5.16739264e-02f,
  -6.98826090e-02f, -1.08683042e-01f, 3.28594565e-01f, -9.30381659e-03f, -1.17200062e-01f, -1.92679539e-02f, -1.37053058e-01f, -1.35968849e-01f, 1.25532135e-01f, -1.62460774e-01f,
  -1.21756457e-01f, -1.09164445e-02f, -1.90449022e-02f, -6.46053627e-02f, -5.03589213e-02f, 5.92958089e-03f, 7.56026208e-02f, -1.24173068e-01f, -5.98506890e-02f, 1.33260787e-01f,
  7.32003003e-02f, 5.24175204e-02f, -1.65180378e-02f, -2.10518882e-01f, 4.06217761e-02f, -1.30237900e-02f, 1.87936828e-01f, -1.84893250e-01f, 4.55955267e-02f, 1.34177476e-01f,
  -1.41095251e-01f, 7.07974434e-02f, 1.05896741e-01f, -2.42689550e-01f, -3.07918862e-02f, 1.38105348e-01f, 1.33297727e-01f, 6.35050759e-02f, -9.44047123e-02f, 1.57865152e-01f,
  -1.80546626e-01f, 3.59656289e-03f, -1.06959641e-01f, 6.68985248e-02f, 9.98951942e-02f, -8.68754685e-02f, -6.71086414e-03f, -1.50655791e-01f, -1.47315726e-01f, -1.82576906e-02f,
  -7.24795461e-02f, -9.90549698e-02f, -4.53257225e-02f, -2.14117840e-02f, 1.35051191e-01f, 1.01497009e-01f, 9.79734659e-02f, 3.02472599e-02f, -8.01360905e-02f, 1.05749987e-01f,
  1.12008518e-02f, -1.07984886e-01f, 4.21307236e-02f, 9.78190750e-02f, 1.10239670e-01f, -6.66135177e-02f, -2.06079692e-01f, -8.45305473e-02f, -8.00383538e-02f, -1.14519177e-02f,
  1.08091325e-01f, 1.49149671e-02f, -1.56732749e-05f, 1.35540143e-01f, 6.41910881e-02f, 2.23191947e-01f, -7.76694193e-02f, -4.66121063e-02f, 1.85764015e-01f, 3.30606066e-02f,
  6.18582964e-03f, -1.50087520e-01f, -4.19760421e-02f, -7.92281404e-02f, 9.04243737e-02f, 1.84880331e-01f, 8.83611850e-03f, 3.77236307e-02f, -1.65274873e-01f, 4.22015339e-02f,
  -2.20863670e-01f, -4.15991172e-02f, 1.78947330e-01f, 5.20341210e-02f, -1.85100824e-01f, -9.50386152e-02f, -2.22600084e-02f, -5.08194277e-03f, -1.28114894e-01f, -1.06666513e-01f,
  -6.84424639e-02f, -1.30321696e-01f, 2.27799043e-02f, -1.30278304e-01f, 1.79082707e-01f, -1.66373283e-01f, 1.11957170e-01f, -9.34551656e-02f, 1.31120995e-01f, 1.20082028e-01f,
  -3.30341756e-02f, 8.79746899e-02f, 1.88751578e-01f, -1.00355163e-01f, 4.87046130e-02f, -7.10990280e-02f, -8.98867771e-02f, -1.44148454e-01f, 3.02097257e-02f, -5.47764786e-02f,
  -7.72435218e-02f, 1.48916438e-01f, 4.96135987e-02f, 4.42192405e-02f, -6.06354699e-02f, -1.11900203e-01f, 5.56447357e-03f, -5.13836592e-02f, -1.11183852e-01f, 7.58624775e-03f,
  -5.99873513e-02f, 2.58221388e-01f, -5.27623408e-02f, -1.35171741e-01f, -7.42011070e-02f, 4.44767997e-02f, -1.88430235e-01f, 9.19914618e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -9.33274850e-02f, -5.71045540e-02f, 1.14642262e-01f, -5.51285185e-02f, 4.74517383e-02f, -8.08930248e-02f, -6.65193349e-02f, 8.89042020e-02f, -8.42485353e-02f, 7.97194541e-02f,
  2.48764269e-02f, -1.21952944e-01f, -1.62904635e-02f, -5.87244257e-02f, 4.72932681e-02f, -2.13079005e-02f, -1.36755332e-01f, -1.24358632e-01f, 2.42250748e-02f, 1.12966165e-01f,
  -3.29667106e-02f, 7.63394535e-02f, -2.19875425e-02f, -7.08347559e-02f, 2.27381587e-02f, -4.38691042e-02f, -9.85376015e-02f, -5.20630646e-03f, 6.78255111e-02f, -1.07707925e-01f,
  3.88284773e-02f, 1.12840734e-01f, 1.15251258e-01f, -8.89806524e-02f, 2.07248349e-02f, 5.59951295e-04f, 1.42722875e-02f, 1.86167490e-02f, 1.15560785e-01f, -1.13187291e-01f,
  3.81539539e-02f, -9.39821154e-02f, 6.84955791e-02f, 8.98664817e-02f, 8.50565210e-02f, 6.89140409e-02f, -1.21606521e-01f, 2.64788792e-02f, 5.77087887e-02f, -7.22348690e-02f,
  4.55080830e-02f, -9.43486020e-02f, -7.02726692e-02f, 1.10617422e-01f, 4.07768972e-02f, -3.55520472e-02f, -4.62622046e-02f, 1.46556601e-01f, -1.25931362e-02f, 2.27878075e-02f,
  -1.25526026e-01f, -2.85727810e-02f, -9.39922407e-02f, -3.63652557e-02f, -1.19739184e-02f, 7.60929435e-02f, 1.27474768e-02f, 1.95387200e-01f, 6.74656266e-03f, 1.48549527e-01f,
  1.35016412e-01f, 7.74102584e-02f, 2.74685938e-02f, 2.30267178e-02f, 1.63893282e-01f, 1.39948800e-01f, -2.71064043e-02f, -1.02071956e-01f, 1.03287339e-01f, 9.24082771e-02f,
  3.37583572e-01f, -2.39696071e-01f, -5.75991534e-02f, 1.48172677e-02f, -1.24400593e-01f, 1.80501908e-01f, -4.38004658e-02f, -3.39377783e-02f, -1.62883326e-02f, -3.21561918e-02f,
  -1.08163655e-02f, 1.66908115e-01f, -1.43480003e-01f, 3.03233743e-01f, 7.03748763e-02f, 1.58580188e-02f, 4.99068797e-02f, 2.78589517e-01f, 1.07561670e-01f, -9.03620273e-02f,
  1.19213507e-01f, -8.94360766e-02f, -2.25171104e-01f, 1.10227101e-01f, 8.76752213e-02f, 1.78039581e-01f, -9.68376920e-02f, -2.19950303e-02f, 6.02652803e-02f, 1.72892585e-01f,
  8.34999606e-02f, -1.69717178e-01f, 7.22912773e-02f, 7.99927637e-02f, -1.08006470e-01f, -4.16406840e-02f, -1.27904922e-01f, 9.12131295e-02f, 1.26180708e-01f, 1.08161934e-01f,
  1.41776875e-01f, -1.39308095e-01f, -1.17295921e-01f, -3.68614905e-02f, 1.09948382e-01f, 8.22040141e-02f, 3.27142179e-01f, 6.13377281e-02f, -2.08038408e-02f, -7.72009045e-02f,
  -4.33500744e-02f, 1.37111053e-01f, -9.10152197e-02f, 1.04717940e-01f, -8.05243701e-02f, 7.81011581e-02f, 9.00069475e-02f, 1.31108552e-01f, 2.33370475e-02f, 3.92988250e-02f,
  1.85233504e-02f, -1.35754377e-01f, -1.83925942e-01f, 2.59226225e-02f, 1.57923266e-01f, 1.64318874e-01f, 3.90439271e-03f, 1.09697901e-01f, -2.04858668e-02f, -8.45421255e-02f,
  -1.34041339e-01f, 4.74583134e-02f, 6.49169758e-02f, 9.76443067e-02f, -4.52621765e-02f, 8.52984488e-02f, 5.38129546e-02f, 1.35912612e-01f, -8.16320593e-04f, 4.31846492e-02f,
  6.91026524e-02f, 1.68542147e-01f, 1.17500879e-01f, -7.63946399e-02f, -1.23859212e-01f, -8.38257447e-02f, 3.09940446e-02f, 1.35554790e-01f, 1.56287044e-01f, -1.34202624e-02f,
  4.63733040e-02f, 1.23503126e-01f, 1.06273495e-01f, -1.46257849e-02f, 8.86337236e-02f, 1.72274873e-01f, 4.54474986e-02f, -1.90310739e-02f, -2.74493992e-02f, 1.79886624e-01f,
  -6.09074421e-02f, -4.10735793e-02f, 1.40191847e-03f, 1.11387283e-01f, -6.46983758e-02f, 2.06367429e-02f, 1.24191437e-02f, 3.47855687e-03f, 3.76530960e-02f, -1.11481193e-02f,
  1.60214096e-01f, 1.71938211e-01f, -8.09569061e-02f, 1.41490449e-03f, 1.07927226e-01f, 1.27838776e-01f, -3.30129303e-02f, -5.79421744e-02f, -6.39022142e-03f, 5.32774329e-02f,
  1.14666574e-01f, 1.27813116e-01f, 3.39102373e-02f, 4.77405861e-02f, -8.64058267e-03f, -3.96719314e-02f, -2.68678945e-02f, 7.39445910e-02f, 2.17666000e-01f, -7.07556009e-02f,
  5.46519011e-02f, 1.87176481e-01f, -1.11908138e-01f, 1.19778574e-01f, -9.10075977e-02f, -4.97502908e-02f, 3.93669866e-02f, -9.56214741e-02f, 9.84790921e-02f, 4.79398705e-02f,
  9.99898612e-02f, 3.13856974e-02f, -2.72302106e-02f, 6.12825155e-02f, 6.25918731e-02f, 8.85139555e-02f, -7.98227340e-02f, 5.95520996e-02f, 7.24241957e-02f, -6.00971468e-02f,
  -9.88563988e-03f, 1.55897111e-01f, 1.27209246e-01f, 1.09519958e-01f, -1.03256740e-01f, -2.41814088e-02f, -4.97448631e-02f, 2.11808197e-02f, 8.85896832e-02f, 4.34478559e-02f,
  6.70473874e-02f, 4.13355269e-02f, 4.16000336e-02f, -2.33065151e-02f, -5.71065582e-02f, -2.78331153e-02f, 1.54082596e-01f, -4.56413180e-02f, -5.59751540e-02f, -1.31238356e-01f,
  -1.12337179e-01f, 1.49149626e-01f, 9.53497440e-02f, 1.26183301e-01f, 4.97826040e-02f, 3.97074297e-02f, -9.27394480e-02f, 2.99936142e-02f, 1.20226221e-04f, 7.22341612e-02f,
  -4.48812321e-02f, -1.02518812e-01f, -6.30183937e-03f, 1.01962723e-01f, 3.61462198e-02f, -1.12895511e-01f, 2.27966309e-02f, 3.86349969e-02f, 6.25061151e-03f, 6.39806539e-02f,
  -1.47822008e-01f, 7.20743909e-02f, -1.12516172e-01f, 8.17750469e-02f, -7.81767815e-02f, 6.82277158e-02f, 7.96505436e-02f, -1.08181700e-01f, -1.51209757e-01f, 5.75873926e-02f,
  4.19770554e-03f, -9.49976072e-02f, 3.32211368e-02f, 9.55280587e-02f, -9.18092206e-03f, 6.43174201e-02f, 9.81737450e-02f, 1.07647041e-02f, 4.63775247e-02f, -3.57599445e-02f,
  8.88629928e-02f, 6.32120238e-04f, 5.83310015e-02f, 3.55294570e-02f, 1.27210870e-01f, -6.45143986e-02f, -3.83378752e-02f, -6.17130613e-03f, -9.72150415e-02f, 5.04051335e-02f,
  -8.66219923e-02f, 1.07814856e-01f, -7.55427405e-02f, 7.99425542e-02f, 7.39732310e-02f, 6.51388019e-02f, 7.92074874e-02f, 8.59082639e-02f, -3.76496539e-02f, -7.52308965e-02f,
  -4.90404386e-03f, 9.68519673e-02f, -2.57718526e-02f, 1.95893377e-01f, -1.07411958e-01f, 4.78032529e-02f, 9.76918489e-02f, 1.18435033e-01f, -8.75216573e-02f, -5.92573434e-02f,
  6.74375817e-02f, -7.08119757e-03f, 1.25626162e-01f, -2.73096986e-04f, 5.80350915e-03f, 2.29458705e-01f, 2.19089925e-01f, 2.14991853e-01f, 1.17448471e-01f, 1.45713374e-01f,
  1.10549591e-01f, -3.90209779e-02f, -1.37365669e-01f, 2.41564706e-01f, -9.73065346e-02f, -2.25913748e-01f, -2.46272400e-01f, 2.45296851e-01f, 7.30204433e-02f, -3.72446217e-02f,
  1.48385078e-01f, 7.36179203e-02f, -1.62412181e-01f, 3.18055183e-01f, 1.25239521e-01f, 6.10880442e-02f, -4.84348349e-02f, 1.38444811e-01f, -1.17962413e-01f, 2.03410909e-02f,
  2.15126246e-01f, 1.26877785e-01f, 2.99735159e-01f, 2.43861023e-02f, -2.98255123e-02f, -1.51363745e-01f, -8.04698616e-02f, 1.43749967e-01f, 1.05554931e-01f, 1.07029490e-01f,
  1.51792929e-01f, 5.00383880e-03f, -2.16375887e-02f, -9.96669978e-02f, -1.11999430e-01f, -1.68457236e-02f, -1.16242103e-01f, 2.04435438e-01f, 9.68303606e-02f, -1.14714205e-01f,
  -1.07232966e-02f, 1.22439981e-01f, 4.26038355e-02f, 3.46823819e-02f, -1.01050064e-01f, -1.23114027e-01f, 1.63540706e-01f, 2.88548589e-01f, -9.35090184e-02f, 1.11746406e-02f,
  6.60520932e-03f, -1.01191230e-01f, -7.69809484e-02f, -1.15932636e-01f, 5.98014556e-02f, 1.54409856e-02f, 2.20670700e-02f, -1.27877787e-01f, 1.71174720e-01f, -3.77426334e-02f,
  1.36528239e-01f, 1.65832669e-01f, 1.21055678e-01f, 5.26665617e-03f, 6.48184419e-02f, -6.94157556e-02f, -1.31668225e-01f, -1.60110012e-01f, -7.72414804e-02f, -1.78347807e-02f,
  2.98116691e-02f, 1.96196601e-01f, -1.79532506e-02f, 3.63193862e-02f, -8.63860622e-02f, 1.31361797e-01f, -1.97901726e-01f, -8.58803540e-02f, -1.28119811e-02f, 1.64495800e-02f,
  -1.12245671e-01f, -3.21461223e-02f, -2.61922088e-02f, 9.20713022e-02f, -1.02784738e-01f, 1.81600824e-01f, -2.89991274e-02f, -5.57561293e-02f, -1.38597209e-02f, -7.64104575e-02f,
  -1.81558747e-02f, 3.93824242e-02f, 1.12074107e-01f, 1.95056662e-01f, 4.17457409e-02f, -8.42462108e-02f, -1.00241080e-01f, 4.29676436e-02f, 1.22249000e-01f, -1.19048990e-01f,
  1.17512699e-02f, 1.16056025e-01f, 1.15101293e-01f, -7.35470653e-02f, 6.63555935e-02f, 1.76940218e-01f, 2.69266311e-02f, 1.51374214e-03f, -7.40867928e-02f, -9.82923508e-02f,
  -3.24522033e-02f, 5.76643869e-02f, 6.73789829e-02f, 1.05730258e-01f, 1.24085620e-01f, 1.42847253e-02f, -6.16928264e-02f, 1.35868350e-02f, 4.39869463e-02f, -1.32558951e-02f,
  -1.28486007e-01f, 1.14420794e-01f, -8.06864351e-02f, -9.12947580e-02f, -7.09322989e-02f, -7.57437646e-02f, -8.69292468e-02f, -9.75517407e-02f, -7.27508441e-02f, -1.27634127e-02f,
  9.25624743e-02f, 1.14978470e-01f, 4.97682467e-02f, 8.61506984e-02f, -8.15873966e-02f, 5.51021546e-02f, 7.89594799e-02f, 5.25800474e-02f, -4.94318530e-02f, 1.04850411e-01f,
  -1.25068620e-01f, 3.88994277e-03f, 7.70575041e-03f, 6.39257133e-02f, -6.24317639e-02f, -1.25885472e-01f, 1.15975507e-01f, 7.92828649e-02f, -1.10687107e-01f, 6.78260028e-02f,
  6.60647154e-02f, -2.54438315e-02f, -3.91349904e-02f, -1.25151455e-01f, 3.08522419e-03f, -5.64545952e-02f, 1.04910903e-01f, 2.06785183e-02f, -4.43932898e-02f, 3.60816577e-03f,
  7.02111498e-02f, -1.10413104e-01f, -5.70754334e-02f, -7.28485957e-02f, 5.49174845e-02f, -8.51625651e-02f, -1.09268062e-01f, 3.00985482e-03f, -1.59628969e-02f, 3.32316360e-03f,
  5.75055182e-02f, 9.12567303e-02f, -7.11824596e-02f, -6.60811141e-02f, 6.84464276e-02f, 1.06005788e-01f, 4.86267507e-02f, -1.03584923e-01f, 1.11445021e-02f, 9.23356488e-02f,
  -8.78088549e-02f, 1.93391065e-03f, -1.04905404e-01f, -4.55317460e-03f, 7.92487711e-02f, -6.21293075e-02f, 1.16535366e-01f, -1.14479505e-01f, 7.10937157e-02f, -6.07650019e-02f,
  -1.16918841e-02f, 1.07491545e-01f, 1.11370154e-01f, -8.59054998e-02f, -3.82633619e-02f, 3.39265317e-02f, -9.22540054e-02f, 5.44662513e-02f, -1.54840961e-01f, 1.40144318e-01f,
  1.50322229e-01f, 5.01116328e-02f, -3.43177989e-02f, -1.42747894e-01f, 7.46346042e-02f, 2.01537926e-02f, 7.96629786e-02f, 1.32939694e-02f, 7.95060918e-02f, 3.47757526e-02f,
  -4.87301387e-02f, 5.40888384e-02f, 4.67645228e-02f, 1.12050071e-01f, -4.74204943e-02f, 6.12518042e-02f, -8.67154077e-02f, -1.50989403e-03f, -3.68130766e-02f, 1.32237598e-01f,
  5.49399890e-02f, 2.76746880e-02f, 1.75449662e-02f, 5.79553582e-02f, -8.70801657e-02f, -4.95772921e-02f, -1.72499213e-02f, 3.87264527e-02f, -4.87272963e-02f, 7.50834793e-02f,
  6.26670662e-04f, -1.35552064e-02f, -1.12974279e-01f, 1.36976168e-02f, -7.26687461e-02f, -4.93157394e-02f, -1.33047670e-01f, -1.17385335e-01f, -4.10364605e-02f, 1.27572238e-01f,
  -1.13804482e-01f, -1.44417929e-02f, -1.00462466e-01f, 1.18787669e-01f, -4.96887788e-02f, -1.12850964e-01f, 2.19859113e-03f, -9.24572423e-02f, 7.51627311e-02f, -7.53796520e-03f,
  7.17541799e-02f, -6.13886081e-02f, 1.36379134e-02f, 2.80890502e-02f, 1.48624510e-01f, 6.09444976e-02f, 8.69209990e-02f, 1.25398606e-01f, -7.15955645e-02f, -3.69808115e-02f,
  1.06881268e-01f, -1.74096420e-01f, -1.34978490e-02f, -1.37628570e-01f, 7.85937905e-02f, 1.08827949e-01f, 4.53451090e-03f, -6.29611313e-03f, 1.38685122e-01f, 8.33652392e-02f,
  1.58004873e-02f, 5.42885736e-02f, -1.16200320e-01f, 5.97834624e-02f, -1.70059830e-01f, -5.05403802e-02f, 1.21040232e-02f, 1.30231038e-01f, 1.51495770e-01f, -8.33706465e-03f,
  -1.30114794e-01f, -5.60822934e-02f, 1.13817826e-02f, -1.07997116e-02f, 5.39618768e-02f, -6.00801259e-02f, 5.64849563e-02f, 8.93984437e-02f, 5.09300530e-02f, -4.39730994e-02f,
  4.05840427e-02f, 8.76570586e-03f, 9.32943672e-02f, 1.03496686e-01f, 1.32222772e-01f, -5.28213345e-02f, -2.05290224e-02f, -4.66720946e-02f, -2.27188449e-02f, -9.36377719e-02f,
  -1.12429939e-01f, 9.48018804e-02f, 1.37048870e-01f, 1.22858576e-01f, -1.23699903e-01f, 5.51603474e-02f, 1.09908596e-01f, 3.62824462e-02f, -2.01196708e-02f, -6.11948315e-03f,
  -4.46815006e-02f, -4.35866751e-02f, -1.42526310e-02f, -1.60891786e-02f, -2.18553469e-02f, -4.55269553e-02f, 6.88885227e-02f, 1.11344300e-01f, 3.00079565e-02f, 1.88848395e-02f,
  -8.36613104e-02f, 3.73170748e-02f, 1.04762278e-01f, 6.45032600e-02f, -2.89870892e-02f, 7.46560395e-02f, 6.81026205e-02f, -6.36855960e-02f, -6.03480674e-02f, 4.26557027e-02f,
  9.61970687e-02f, 2.46876739e-02f, 1.57912485e-02f, 7.23953545e-02f, 8.70652050e-02f, 7.63556734e-02f, 1.40651483e-02f, 2.18716431e-02f, -9.54857562e-03f, 8.01772103e-02f,
  -6.91226646e-02f, -9.54771712e-02f, -7.75902569e-02f, 1.47951856e-01f, 6.57654181e-02f, 4.82913479e-02f, 1.38601323e-03f, -6.60204962e-02f, 1.77016370e-02f, -1.13317683e-01f,
  4.82570753e-03f, 5.28418273e-02f, -2.89332885e-02f, 9.68670398e-02f, -7.75921866e-02f, 3.65332626e-02f, -9.33208540e-02f, -3.59871089e-02f, 1.10577054e-01f, 9.35987756e-02f,
  -6.92314208e-02f, 1.23267464e-01f, -7.15873912e-02f, 1.53886015e-02f, 6.45062402e-02f, 1.01025715e-01f, 9.66358259e-02f, 1.11945845e-01f, 9.03973877e-02f, 8.44161958e-02f,
  -1.17268965e-01f, -8.53741840e-02f, 5.13478257e-02f, 5.18678352e-02f, 5.61279664e-03f, 2.25728899e-01f, 1.54823959e-01f, 1.80224240e-01f, 1.22438379e-01f, 3.65545414e-02f,
  1.26920328e-01f, -1.19660519e-01f, 2.25485004e-02f, 1.60391495e-01f, 1.80195183e-01f, 2.64420122e-01f, 1.87146738e-01f, -4.48358729e-02f, -6.76390007e-02f, 2.21870780e-01f,
  2.10721016e-01f, 7.68669555e-03f, 5.82580157e-02f, 3.22435290e-01f, -9.43685248e-02f, 1.64175421e-01f, 1.70010388e-01f, -2.49437988e-01f, 4.27988395e-02f, 1.06228709e-01f,
  -7.27743208e-02f, 7.67369643e-02f, 1.87190935e-01f, 1.96761355e-01f, 8.68106112e-02f, 8.77383910e-03f, -1.24562353e-01f, 1.67876691e-01f, 7.43670985e-02f, 1.43013652e-02f,
  -3.43643501e-02f, -1.58825126e-02f, 9.53010321e-02f, 9.69371870e-02f, 8.02492574e-02f, 5.18502295e-03f, -2.08999403e-02f, -1.14275161e-02f, 1.19476356e-01f, 6.42924532e-02f,
  1.63441807e-01f, 4.02671136e-02f, 9.52402949e-02f, 1.07903466e-01f, -1.13236137e-01f, -1.30842939e-01f, 1.08917169e-02f, -7.45892003e-02f, 9.38988989e-04f, -7.68077224e-02f,
  -1.18665539e-01f, -6.82881847e-02f, -9.06919912e-02f, 1.37785837e-01f, 1.72191665e-01f, -2.53924429e-02f, -2.59290785e-02f, 3.43817979e-01f, 1.02801830e-01f, -5.29633090e-02f,
  1.00806735e-01f, -1.52812777e-02f, 1.05517201e-01f, 4.61250590e-03f, 5.37730614e-03f, -1.83125108e-01f, 1.40758872e-01f, 9.95276421e-02f, 1.52695011e-02f, 1.39154375e-01f,
  2.96054453e-01f, 6.84267059e-02f, -1.91982444e-02f, 2.76942044e-01f, 5.13357623e-03f, -1.55205116e-01f, 8.39401558e-02f, 2.76171178e-01f, 4.63979356e-02f, 1.29379462e-02f,
  3.08507830e-01f, -6.54490069e-02f, -9.16677043e-02f, -1.25748618e-02f, -5.77289313e-02f, 5.68008013e-02f, -7.97689855e-02f, -5.52447811e-02f, -1.15882969e-02f, -1.44913554e-01f,
  1.12945937e-01f, 1.17861815e-01f, 5.62875904e-02f, -1.28624633e-01f, -6.46510124e-02f, 1.91807579e-02f, 1.65097654e-01f, 8.10488500e-03f, 8.83443505e-02f, 1.98685750e-01f,
  1.61373705e-01f, -1.03250891e-01f, -7.33898804e-02f, 1.54707521e-01f, -7.49402270e-02f, 1.08845659e-01f, 7.77028129e-02f, -4.37442139e-02f, 4.86353636e-02f, -1.64139662e-02f,
  -1.05453208e-01f, 7.63874426e-02f, -1.47635698e-01f, -7.20655993e-02f, 2.23926812e-01f, 8.74586552e-02f, -1.14074484e-01f, 7.00915754e-02f, 4.47207466e-02f, 2.57367250e-02f,
  4.23289463e-02f, 2.03292355e-01f, 6.85632452e-02f, 2.63966061e-03f, -1.07872844e-01f, -7.99765214e-02f, 6.25620186e-02f, -2.41037365e-02f, 2.13407297e-02f, 1.92704797e-01f,
  -1.20492160e-01f, 1.00836337e-01f, -8.21729451e-02f, -9.21857134e-02f, -5.31547479e-02f, 1.10946581e-01f, -4.02574502e-02f, -1.18129114e-02f, -8.81254673e-02f, -6.78265318e-02f,
  -6.57989308e-02f, -5.96522652e-02f, 1.17061213e-01f, 1.16860524e-01f, 1.12946346e-01f, 1.27707750e-01f, -9.42748636e-02f, 6.13326356e-02f, 1.14034437e-01f, 1.65332958e-01f,
  -5.32531701e-02f, 2.21277967e-01f, 4.02543917e-02f, 4.21891408e-03f, -5.05548995e-03f, 8.15548971e-02f, 2.64968332e-02f, -9.53560248e-02f, 1.05742775e-01f, 1.71577990e-01f,
  -3.79969217e-02f, 5.90660311e-02f, 1.01376891e-01f, 8.21927041e-02f, 4.44690362e-02f, 5.36766020e-04f, -5.31859174e-02f, 5.42182662e-02f, -5.67398183e-02f, 9.33197811e-02f,
  7.32232258e-02f, 2.64804736e-02f, -5.89886233e-02f, 1.96104273e-02f, 1.05966114e-01f, -4.23991643e-02f, 9.63875558e-03f, -1.02110259e-01f, 2.06214353e-01f, 1.55320406e-01f,
  1.55519592e-02f, -1.16774850e-01f, -2.25304626e-02f, -1.33470327e-01f, 1.86261386e-01f, -2.71944352e-03f, 1.22587025e-01f, 1.08533971e-01f, -2.14931369e-03f, 1.40698761e-01f,
  -2.48890184e-02f, -2.45790854e-02f, -4.29520607e-02f, -1.22150913e-01f, 7.01382756e-02f, 3.48194987e-02f, -6.96597993e-02f, 1.37641326e-01f, 1.37075009e-02f, 7.87477791e-02f,
  -7.53922239e-02f, 8.99319425e-02f, 8.90188366e-02f, -1.24532484e-01f, -3.03137805e-02f, 1.37234166e-01f, -7.17370957e-02f, -2.88094450e-02f, -2.27589719e-03f, 2.62889620e-02f,
  9.25740451e-02f, -1.07185677e-01f, -7.78733566e-03f, -1.17058873e-01f, -3.19686979e-02f, -4.57591340e-02f, -3.46161127e-02f, -1.10542208e-01f, -1.00613818e-01f, 1.18934512e-01f,
  -5.81235066e-02f, -5.22539467e-02f, 4.92008030e-03f, -9.13256258e-02f, 1.40663743e-01f, -4.71071526e-02f, 5.95686920e-02f, -9.47108418e-02f, 4.24578078e-02f, -7.38331228e-02f,
  3.18510868e-02f, 1.19361065e-01f, -7.32450560e-02f, 7.40454271e-02f, -7.95674026e-02f, -3.58102545e-02f, -1.05057344e-01f, 5.83012961e-02f, -1.05220176e-01f, 7.44765485e-03f,
  2.90877949e-02f, -4.57589254e-02f, 1.06102139e-01f, 2.71041151e-02f, 1.33634778e-02f, 1.13806076e-01f, 5.78292704e-04f, -6.80232495e-02f, -5.57527365e-03f, 1.43285260e-01f,
  7.20820427e-02f, 1.23848543e-01f, 1.06525257e-01f, -1.03450857e-01f, 1.19088337e-01f, 5.40202074e-02f, 4.55080122e-02f, 7.37234578e-02f, -2.00520679e-02f, 1.33830994e-01f,
  1.26134381e-01f, -1.26836404e-01f, -1.24850348e-01f, 6.39692768e-02f, 2.84665395e-02f, -1.11882091e-01f, 2.65342910e-02f, 1.45540193e-01f, -1.85377032e-01f, -8.05185512e-02f,
  1.66190833e-01f, 1.42902508e-01f, -5.73595092e-02f, 1.41632140e-01f, 2.41323784e-02f, 1.15381449e-01f, 1.23895168e-01f, 5.17074466e-02f, 4.97060828e-02f, 2.53342003e-01f,
  6.35151491e-02f, 2.09116265e-01f, 1.98045000e-01f, 8.73310640e-02f, 1.84718762e-02f, -4.72566187e-02f, -1.41738817e-01f, -8.42205733e-02f, 5.96907269e-03f, -4.57887873e-02f,
  1.25242755e-01f, 6.55896962e-02f, 1.49857685e-01f, -7.48018324e-02f, 1.51451901e-01f, 2.11257283e-02f, -1.24644376e-02f, 5.58047965e-02f, -1.50040761e-02f, -1.38813406e-01f,
  -7.21030608e-02f, 2.18005210e-01f, 1.13830857e-01f, 7.22120851e-02f, 1.01273753e-01f, -6.15579151e-02f, 1.71589583e-01f, -4.13808376e-02f, -2.79060714e-02f, -8.64960700e-02f,
  -4.40077223e-02f, -2.29132944e-03f, 2.84757525e-01f, -4.42358479e-02f, 6.47790954e-02f, 8.95039830e-03f, 1.38718724e-01f, 6.50366545e-02f, -1.21327221e-01f, 1.21220415e-02f,
  4.25892659e-02f, -2.54216474e-02f, -1.73486210e-02f, -7.51586705e-02f, -7.92672262e-02f, 1.00198537e-01f, 1.47980988e-01f, 7.55839273e-02f, 9.11674555e-03f, 9.18403938e-02f,
  4.46786061e-02f, -1.91213012e-01f, -4.29278798e-02f, 1.71469420e-01f, 1.46559492e-01f, -7.32853264e-03f, 1.48095965e-01f, 8.79314020e-02f, 1.85961537e-02f, -3.08015514e-02f,
  -9.55795869e-02f, 8.75014290e-02f, -1.27810508e-01f, 2.27049738e-01f, 5.25832511e-02f, 1.18101947e-02f, 3.52911986e-02f, 1.37339592e-01f, -9.21778288e-03f, 6.85573975e-03f,
  1.84456147e-02f, -2.10894551e-02f, 5.86083941e-02f, -1.24661632e-01f, 1.25322357e-01f, 1.10473130e-02f, -3.92819084e-02f, 3.52565199e-02f, 1.22994678e-02f, 7.01740459e-02f,
  3.46917547e-02f, 7.19975084e-02f, 4.68800291e-02f, -9.26591679e-02f, 6.78416267e-02f, 8.03818088e-03f, 1.10386848e-03f, -1.30770311e-01f, -4.87988330e-02f, 1.17722176e-01f,
  5.14047034e-02f, 8.02703798e-02f, -1.12102672e-01f, -2.25678980e-02f, 1.43336594e-01f, 2.34483127e-02f, 6.85187131e-02f, 6.30016923e-02f, 3.00683454e-02f, 1.78608373e-02f,
  6.99913055e-02f, -6.89356849e-02f, 3.71582657e-02f, 8.77178758e-02f, 5.71143292e-02f, 1.04411535e-01f, 5.52431718e-02f, -2.19771303e-02f, 9.31637809e-02f, -4.56007868e-02f,
  6.39442801e-02f, -8.99594799e-02f, -1.39281049e-01f, 2.62506716e-02f, 5.91357052e-03f, 1.80374607e-01f, 5.80314845e-02f, -1.00166351e-01f, 6.62267283e-02f, -5.67773217e-03f,
  -1.31887749e-01f, 6.90298453e-02f, 1.54726310e-02f, -3.53196403e-03f, 1.13414444e-01f, 1.79372653e-02f, 3.20922490e-03f, 3.82054830e-03f, 1.02836341e-01f, 1.34062365e-01f,
  1.41068116e-01f, -9.00446177e-02f, -1.06021971e-01f, -1.10186068e-02f, -1.10729458e-02f, -1.71156097e-02f, -4.38879691e-02f, 1.68134570e-01f, 7.29949996e-02f, -6.51668906e-02f,
  -3.56549807e-02f, -6.80627972e-02f, -4.72513027e-02f, -1.05531245e-01f, 1.36552036e-01f, 6.88681304e-02f, -1.75349734e-04f, -2.37948857e-02f, -2.35625729e-02f, -3.43293734e-02f,
  -6.98108375e-02f, -4.62700203e-02f, -6.70381337e-02f, -3.47430515e-03f, -8.86032358e-03f, 1.12910949e-01f, -6.23992682e-02f, -6.73382953e-02f, 4.84896526e-02f, -3.88743840e-02f,
  7.07793981e-02f, -5.34733534e-02f, -3.67653407e-02f, 6.03019558e-02f, -7.33745545e-02f, 8.20410997e-02f, 1.09800078e-01f, 1.14877030e-01f, -1.24041758e-01f, -2.17154622e-02f,
  -6.46493584e-02f, 7.12604374e-02f, 4.11017425e-02f, -2.21876372e-02f, 1.69198126e-01f, 7.51414970e-02f, -6.04793169e-02f, 1.39474869e-01f, -4.34260592e-02f, -5.29252887e-02f,
  1.44366398e-01f, 9.53363106e-02f, -1.22196436e-01f, 3.92768085e-02f, 2.69763358e-02f, 1.22844037e-02f, -3.26243043e-02f, 2.77233608e-02f, 3.20496187e-02f, 1.04004061e-02f,
  1.51637211e-01f, -4.63976860e-02f, -8.96617696e-02f, -1.32546768e-01f, 1.19548060e-01f, -9.61010382e-02f, 2.63170972e-02f, 5.32991625e-02f, 1.31484210e-01f, -6.26545921e-02f,
  1.57274231e-01f, -7.17611238e-02f, 9.98365432e-02f, 1.04866073e-01f, -3.41568626e-02f, 1.23647682e-01f, -5.99192316e-03f, -1.03410468e-01f, -1.05357774e-01f, 1.11900315e-01f,
  1.59298573e-02f, 7.35333338e-02f, -1.08974166e-01f, 6.55462667e-02f, -2.61388440e-02f, 8.10218006e-02f, 7.45531693e-02f, -4.19628620e-03f, 1.32949799e-01f, 4.46784161e-02f,
  -6.14364222e-02f, -7.87009001e-02f, 1.73883419e-02f, -1.45002017e-02f, 5.47958054e-02f, -3.56531143e-02f, 1.11607924e-01f, 1.75306514e-01f, 9.36237797e-02f, 1.42577052e-01f,
  9.50265583e-03f, 5.45325875e-02f, -5.04072309e-02f, 3.91795486e-02f, -7.83845037e-02f, -2.90020686e-02f, -1.43555505e-02f, -1.64754363e-03f, -4.79540974e-02f, 5.96872605e-02f,
  -1.07778497e-01f, 2.05301210e-01f, -2.25287639e-02f, 4.45555411e-02f, 1.29363194e-01f, -6.31146356e-02f, -1.57566085e-01f, -8.25552568e-02f, 1.62616521e-01f, -1.40008569e-01f,
  8.07961076e-02f, -6.11087643e-02f, 6.06168658e-02f, 3.48957106e-02f, -6.61651865e-02f, 1.08207241e-01f, 1.02137573e-01f, -1.31988436e-01f, 4.55348715e-02f, 1.18725300e-01f,
  2.37127929e-03f, 8.14751089e-02f, 1.01977222e-01f, -1.89857297e-02f, 1.87221259e-01f, -3.99952494e-02f, -1.02085233e-01f, 7.70648867e-02f, -1.04540877e-01f, -9.73215327e-03f,
  -1.13963401e-02f, -1.71613656e-02f, -6.74113706e-02f, 3.13260108e-02f, -5.76122813e-02f, -1.75301284e-02f, -5.93728200e-02f, -1.20219573e-01f, -5.21817841e-02f, -5.01603186e-02f,
  -9.33441147e-02f, -6.69869930e-02f, -6.56918734e-02f, -1.16003759e-01f, 4.39886861e-02f, 1.64784715e-02f, -7.97694623e-02f, -1.02545857e-01f, -1.07300237e-01f, 2.08097696e-01f,
  -7.87590668e-02f, 8.84704739e-02f, -9.30334479e-02f, 3.34331254e-03f, -1.00840427e-01f, -2.66297720e-02f, -8.05381909e-02f, -8.24811757e-02f, 5.46368323e-02f, 1.68809034e-02f,
  -1.88020039e-02f, -9.59396660e-02f, -9.92421135e-02f, -1.75306834e-02f, 6.90084398e-02f, -5.06913988e-03f, -4.97698374e-02f, 1.17737338e-01f, 1.06845148e-01f, -6.18005022e-02f,
  -7.79387578e-02f, -9.77593362e-02f, -1.15187675e-01f, 1.06010236e-01f, -9.50383097e-02f, 9.82530713e-02f, 8.24166089e-02f, -5.55319823e-02f, 4.59497422e-02f, 3.49094607e-02f,
  -5.30172847e-02f, -7.56990835e-02f, 1.40019253e-01f, 2.92066839e-02f, 3.27975452e-02f, 1.24086037e-01f, -9.50470418e-02f, -1.01498865e-01f, 7.45795295e-02f, 6.72387034e-02f,
  1.23774827e-01f, 5.00335842e-02f, 1.13992564e-01f, 4.21304964e-02f, -2.86014080e-02f, -4.10606116e-02f, -7.59521946e-02f, -5.60030714e-02f, -1.20145589e-01f, -1.29450455e-01f,
  7.33979940e-02f, 5.64014949e-02f, -4.20169607e-02f, 8.22208226e-02f, 1.76881962e-02f, -1.35126915e-02f, 5.83189018e-02f, -4.37754057e-02f, -4.19243202e-02f, -1.20316364e-01f,
  4.98645566e-02f, 1.68760177e-02f, 4.46754918e-02f, -1.17782123e-01f, 1.50905639e-01f, -7.52780065e-02f, 1.27804473e-01f, 8.10459852e-02f, -4.61908095e-02f, 3.04540899e-02f,
  -4.30985205e-02f, 2.76789232e-03f, 1.24436215e-01f, -3.02825179e-02f, 1.36746630e-01f, 5.21761626e-02f, 8.73598009e-02f, -1.36396885e-01f, 7.40319351e-03f, 1.10648293e-02f,
  1.94897428e-01f, -1.97672382e-01f, -3.08671761e-02f, 2.26672485e-01f, -1.19177930e-01f, 1.10048801e-01f, 9.55617130e-02f, -7.45874494e-02f, -1.10969022e-01f, -1.02922529e-01f,
  -1.24544628e-01f, 2.16151960e-02f, -1.27540573e-01f, 8.87472928e-02f, 1.07205316e-01f, 3.29401158e-02f, 4.04282250e-02f, 1.56301633e-01f, 7.23314062e-02f, -1.17542334e-01f,
  1.27115086e-01f, 1.04789641e-02f, -6.35052919e-02f, -3.05373259e-02f, -8.95199701e-02f, -1.17086228e-02f, -1.11280769e-01f, 1.21511333e-01f, 1.26509786e-01f, 7.73577467e-02f,
  5.39431721e-02f, 1.98089480e-02f, 8.47998932e-02f, 2.25941045e-03f, 2.74830852e-02f, -1.18800044e-01f, -8.14941749e-02f, -4.96707894e-02f, 1.25069022e-01f, -1.72158796e-02f,
  6.15251586e-02f, 8.03343654e-02f, 2.09238436e-02f, 1.22268066e-01f, 2.89706569e-02f, 2.55800225e-02f, 9.65799093e-02f, 1.64767385e-01f, 9.86188203e-02f, -3.10119521e-02f,
  -1.08346559e-01f, 2.07535513e-02f, 6.83415756e-02f, 8.12269840e-03f, -1.08897492e-01f, -1.20578684e-01f, -7.58379400e-02f, -5.98423183e-02f, 1.13554850e-01f, 1.96457103e-01f,
  1.69740722e-01f, -2.50700247e-02f, 4.18867506e-02f, 2.04390213e-01f, 8.11787844e-02f, 1.38942495e-01f, 1.83649644e-01f, 4.79752794e-02f, -1.11489519e-01f, -1.07160574e-02f,
  1.00930251e-01f, -2.03745350e-01f, 2.48330265e-01f, 2.70003779e-03f, -3.28962989e-02f, -8.10487941e-02f, 1.84970602e-01f, -4.95280698e-02f, 1.70750935e-02f, -9.53975394e-02f,
  -8.60626344e-03f, 9.27471966e-02f, 1.08064329e-02f, 5.17888665e-02f, -9.62468162e-02f, 7.79446438e-02f, 1.85761005e-01f, -4.00244929e-02f, 1.03701688e-01f, 1.31583542e-01f,
  -5.13522960e-02f, -2.11692043e-02f, -2.89630168e-03f, 1.16208911e-01f, -6.52878657e-02f, 1.75654680e-01f, 2.54909438e-03f, -9.41380411e-02f, -5.92942499e-02f, -2.23423075e-03f,
  9.25651938e-02f, -6.27270341e-02f, -7.00230673e-02f, -8.18737447e-02f, 6.58222474e-03f, 2.53566384e-01f, 9.57509968e-03f, 8.82990733e-02f, -9.06855389e-02f, -8.32887087e-03f,
  -8.18538219e-02f, 3.38841230e-01f, 8.92701745e-02f, -3.01321615e-02f, 1.62054047e-01f, -3.43185104e-02f, -5.70364185e-02f, 1.71810836e-01f, -6.78479820e-02f, -3.86207402e-02f,
  6.02114052e-02f, 2.18579303e-02f, 1.21853903e-01f, 4.76473086e-02f, 1.08441655e-02f, 1.14341639e-01f, -1.28477424e-01f, -1.01306506e-01f, -4.04220587e-03f, 5.45252897e-02f,
  -3.36240605e-02f, 1.77638888e-01f, 6.19769432e-02f, 5.48915714e-02f, -3.53641286e-02f, 6.25098646e-02f, -5.61672188e-02f, -1.25765100e-01f, -1.11737892e-01f, 4.40681018e-02f,
  -1.18452922e-01f, -1.14827521e-01f, 1.28167391e-01f, 8.94559622e-02f, -7.94624686e-02f, -1.01858161e-01f, 3.90509926e-02f, -1.32716149e-01f, 5.67691363e-02f, -8.91189799e-02f,
  4.44874018e-02f, 9.39188525e-02f, -5.48304394e-02f, 6.46578595e-02f, 6.55048341e-02f, -6.63430765e-02f, -8.49290714e-02f, 9.92967114e-02f, 3.07983682e-02f, 1.47261590e-01f,
  1.19899504e-01f, -7.14336932e-02f, 5.60523905e-02f, 1.08707324e-01f, 5.45300134e-02f, -4.69093695e-02f, -5.57057634e-02f, -6.52923360e-02f, -8.98815021e-02f, 9.17328000e-02f,
  6.41563535e-02f, -2.79646479e-02f, -3.35035324e-02f, -1.11618809e-01f, -7.60829225e-02f, -7.90971071e-02f, 1.41631693e-01f, 1.63664877e-01f, 2.31426030e-01f, 5.62630519e-02f,
  8.98015276e-02f, -4.78612306e-03f, 1.56106219e-01f, -6.83732405e-02f, 1.50837541e-01f, 2.15682432e-01f, -1.27911922e-02f, 7.90608898e-02f, -4.02587168e-02f, -1.15026698e-01f,
  -1.62772241e-03f, 4.73755598e-02f, 1.71636820e-01f, -1.70352861e-01f, -7.92144090e-02f, 6.21930808e-02f, -1.86781123e-01f, 1.09487921e-01f, 4.04535867e-02f, -1.53808534e-01f,
  6.67818785e-02f, -8.29099789e-02f, 4.21035513e-02f, 1.04301281e-01f, 6.19315915e-02f, -8.08487739e-03f, -8.22089240e-03f, -1.07729279e-01f, -1.40984863e-01f, 3.33451736e-03f,
  6.19039275e-02f, 5.08389883e-02f, 1.10216722e-01f, -1.10856593e-01f, -8.73057023e-02f, 1.32032394e-01f, -4.25435090e-03f, -8.33937377e-02f, 3.31397131e-02f, 1.03409335e-01f,
  3.58371213e-02f, 7.22004250e-02f, 4.57754061e-02f, -1.21384330e-01f, -1.04044145e-03f, -1.49570750e-02f, -1.53048456e-01f, -1.01925723e-01f, 1.05743393e-01f, -9.74694490e-02f,
  8.29158165e-03f, 1.71884838e-02f, 1.46064922e-01f, 7.57401064e-02f, -2.87547521e-03f, 5.98619552e-03f, 1.29390851e-01f, 9.45954118e-03f, 1.33867353e-01f, 1.63883552e-01f,
  5.81640601e-02f, -1.67387035e-02f, 1.07978888e-01f, 1.29532158e-01f, -3.36991176e-02f, -8.12670663e-02f, -2.91807633e-02f, -8.75531603e-03f, 9.17133037e-03f, -6.07843250e-02f,
  -5.41196689e-02f, 9.65713486e-02f, 9.54521969e-02f, 6.78157285e-02f, -1.08851045e-01f, 5.45046255e-02f, -7.91685879e-02f, -4.74636778e-02f, -5.45567572e-02f, -6.32415563e-02f,
  -1.07162260e-01f, -7.79073834e-02f, -2.44388469e-02f, -4.83111925e-02f, -9.75218862e-02f, -4.78269830e-02f, 3.97989154e-02f, -6.24330575e-03f, -1.09340385e-01f, -6.40721768e-02f,
  1.01192109e-01f, -8.33955705e-02f, 7.77500793e-02f, -1.06475376e-01f, -1.09457918e-01f, 5.09199649e-02f, -9.66208987e-03f, -3.05397678e-02f, 1.12619013e-01f, -6.67931214e-02f,
  -1.03476629e-01f, -1.02951765e-01f, 9.17813331e-02f, -6.26963675e-02f, 3.27147706e-03f, -1.19967386e-01f, 1.03818201e-01f, -9.55810472e-02f, 1.19312994e-01f, 2.69910917e-02f,
  6.20050170e-02f, -1.25144832e-02f, 4.84799519e-02f, 1.50107462e-02f, 3.50927450e-02f, 1.64423604e-02f, 1.53514817e-02f, -3.46547961e-02f, -1.03556946e-01f, -4.92024496e-02f,
  -1.12552002e-01f, -7.70493317e-03f, 6.26947433e-02f, -9.60317776e-02f, 3.57417925e-03f, 2.65689582e-01f, 2.78492689e-01f, 1.73068717e-01f, 1.46203429e-01f, 2.98521489e-01f,
  6.43882528e-02f, 3.29950035e-01f, 1.92979828e-01f, 9.83048156e-02f, 3.03298771e-01f, 4.87882318e-03f, -3.14786345e-01f, 1.02601692e-01f, 3.83072756e-02f, -2.91037560e-01f,
  1.12200610e-01f, 2.21082672e-01f, -1.64897859e-01f, 1.17068337e-02f, 1.69032380e-01f, 2.33571663e-01f, -1.20415710e-01f, 3.49229097e-01f, 9.05811638e-02f, -6.62730485e-02f,
  -3.47034931e-02f, 2.07728878e-01f, 1.09346151e-01f, 2.20284700e-01f, 8.51619542e-02f, 2.85867691e-01f, -4.60645137e-03f, 1.58568118e-02f, 2.50730254e-02f, -1.03676766e-01f,
  -1.26000956e-01f, 6.83795437e-02f, -8.76239911e-02f, 1.35108992e-01f, -8.02876353e-02f, 1.67342350e-01f, -7.68725127e-02f, 9.33754966e-02f, 8.48830491e-02f, -6.18759468e-02f,
  3.64630390e-03f, 1.64305583e-01f, -7.96152558e-03f, 4.12494056e-02f, -3.36365737e-02f, 2.21220821e-01f, -4.78408560e-02f, -3.28540280e-02f, -5.21705039e-02f, -7.98003599e-02f,
  2.61158139e-01f, 1.19241469e-01f, 2.87398882e-02f, -7.12294877e-02f, 7.21674114e-02f, -1.08056821e-01f, 3.48584414e-01f, -1.28574878e-01f, 3.79576571e-02f, 1.41478658e-01f,
  -9.11312327e-02f, 1.48709044e-01f, 1.07036069e-01f, -5.65119460e-02f, -6.15128735e-03f, -8.88838470e-02f, 9.39755049e-03f, -4.82394807e-02f, -4.38498966e-02f, 1.32449819e-02f,
  1.41245462e-02f, 1.32470345e-02f, -1.11473858e-01f, -1.07519194e-01f, 3.32082361e-02f, 1.63780108e-01f, 4.49740030e-02f, -6.56179264e-02f, -6.11167625e-02f, 8.20592865e-02f,
  -2.11206190e-02f, -8.52500498e-02f, 8.10086504e-02f, -1.00288168e-01f, 6.93116989e-03f, 7.07648695e-02f, 5.14099654e-03f, 1.56229749e-01f, -6.30592182e-02f, -1.80337802e-02f,
  5.38395494e-02f, 8.56413171e-02f, -8.10197443e-02f, -6.04954455e-03f, 3.95592824e-02f, -1.05547860e-01f, -1.11353777e-01f, 1.49851292e-01f, 4.29565981e-02f, 1.21474471e-02f,
  -8.98356289e-02f, 4.72233444e-02f, -3.89150642e-02f, 6.72209822e-03f, 1.27246782e-01f, -5.65909036e-02f, 1.11858768e-03f, 6.70928732e-02f, 5.22003509e-02f, -4.07266803e-02f,
  1.25023440e-01f, 9.59883854e-02f, -5.03554493e-02f, 2.78463811e-02f, 6.95490986e-02f, 5.40197343e-02f, 4.85347472e-02f, 1.43086836e-01f, 2.52869297e-02f, -7.05887675e-02f,
  1.39148653e-01f, 6.64409623e-02f, 6.50130361e-02f, -9.33862329e-02f, 9.46301743e-02f, -1.29904658e-01f, 7.98901767e-02f, -3.29773538e-02f, 6.69024810e-02f, 1.01584904e-01f,
  -1.10193238e-01f, -1.30988717e-01f, -1.62701868e-02f, -1.19650051e-01f, 7.70703256e-02f, 4.78360541e-02f, -8.52062739e-03f, 1.12092584e-01f, 3.69048305e-02f, -3.73961926e-02f,
  7.41313994e-02f, -9.67737809e-02f, -7.05761015e-02f, -1.08517120e-02f, 7.07541034e-02f, -4.37259227e-02f, -3.25289443e-02f, 9.88264531e-02f, -6.21318035e-02f, -6.11820705e-02f,
  8.48518088e-02f, 5.61718382e-02f, 1.78637134e-03f, 1.02846161e-01f, -6.41660467e-02f, 7.11553022e-02f, -8.24589580e-02f, -4.22868505e-02f, 2.70512979e-02f, 8.25424790e-02f,
  1.13784172e-01f, 7.32442141e-02f, -1.09118536e-01f, -8.84059444e-02f, 4.01956923e-02f, -4.29271758e-02f, -2.20680069e-02f, 4.80312631e-02f, -4.02636044e-02f, -6.67973906e-02f,
  1.18536100e-01f, 9.59689543e-02f, -7.22135827e-02f, -2.09991331e-03f, -9.11132917e-02f, 9.02549252e-02f, -9.82172713e-02f, -7.59096071e-02f, -1.41453268e-02f, -3.50827686e-02f,
  -6.55640736e-02f, 3.22834067e-02f, -7.52510428e-02f, 1.28829002e-01f, -9.57449824e-02f, 1.28105521e-01f, 1.40122473e-01f, 1.54999048e-01f, 1.51617855e-01f, -4.21697833e-02f,
  2.50441372e-01f, 4.80195619e-02f, 1.89305380e-01f, 3.26353043e-01f, 2.26208553e-01f, 4.31596674e-02f, 1.55897692e-01f, 9.31138992e-02f, -2.21514270e-01f, -1.19567126e-01f,
  -1.95326313e-01f, -3.09295416e-01f, 1.79466023e-03f, 2.54020631e-01f, 8.85578468e-02f, -2.15120882e-01f, 9.10805613e-02f, 1.80938244e-01f, -1.99844882e-01f, 2.60775566e-01f,
  -1.23303287e-01f, -1.13859586e-02f, -1.45258615e-02f, 1.68208048e-01f, -1.56092958e-03f, 1.67318061e-01f, 1.27522066e-01f, 2.90168226e-01f, 8.99214074e-02f, 1.46053895e-01f,
  -3.35480757e-02f, -1.64138731e-02f, -6.90778121e-02f, 1.77768052e-01f, -9.74112675e-02f, 1.32264107e-01f, -1.04060704e-02f, 1.49976462e-01f, 1.18735030e-01f, 7.87109062e-02f,
  1.76421285e-01f, 3.18781957e-02f, 1.32366598e-01f, -5.77836297e-02f, 6.33779541e-02f, -9.12139378e-03f, 2.74737161e-02f, 3.62100862e-02f, -3.97130288e-02f, 6.37405291e-02f,
  1.66883677e-01f, 6.80775195e-02f, -3.90646644e-02f, 4.68840338e-02f, -2.08147094e-02f, 8.26565921e-02f, -3.83609608e-02f, -8.11867137e-03f, 3.08516383e-01f, 8.25237762e-03f,
  7.50941783e-02f, 9.77005139e-02f, -1.70279748e-03f, -1.22122001e-02f, 3.88245769e-02f, -9.83688384e-02f, -3.81415449e-02f, -1.17207371e-01f, 1.28775667e-02f, -7.64274374e-02f,
  4.31225486e-02f, 8.32793936e-02f, -5.68567142e-02f, 4.93036695e-02f, -4.80975471e-02f, -5.87214231e-02f, -1.07580721e-01f, 7.72384852e-02f, 5.31739667e-02f, -8.49339291e-02f,
  -4.08355752e-03f, -9.28707793e-02f, 1.20639227e-01f, 5.08675091e-02f, 8.04536976e-03f, -7.92968497e-02f, 2.41599344e-02f, 4.55776462e-03f, 2.34914999e-02f, -1.10769607e-01f,
  -2.57541202e-02f, -1.28185406e-01f, 1.64666977e-02f, 1.07080109e-01f, 7.51988739e-02f, -1.13777239e-02f, 7.86222145e-02f, 1.12599850e-01f, 1.23433478e-04f, -1.01374678e-01f,
  2.32934617e-02f, -1.16736330e-02f, -7.90933892e-02f, 5.51149696e-02f, -5.72124775e-03f, -9.10501182e-02f, 3.19916345e-02f, -1.35565296e-01f, -1.17706068e-01f, 8.67063254e-02f,
  7.15003386e-02f, -1.13147624e-01f, -7.35588297e-02f, 1.10575095e-01f, -1.17452875e-01f, 9.21323597e-02f, -1.00878648e-01f, 4.50901017e-02f, 1.12167843e-01f, -2.00739559e-02f,
  -6.63842708e-02f, 9.59811062e-02f, 5.25824241e-02f, -3.90320942e-02f, 1.08296785e-03f, 3.41968462e-02f, -8.33410621e-02f, -4.03759070e-02f, 1.02442734e-01f, -1.01402432e-01f,
  4.54002805e-02f, 2.97840755e-03f, -4.92404476e-02f, -9.87143293e-02f, 4.38277088e-02f, -8.13402981e-02f, 2.80939210e-02f, -4.65492718e-04f, -2.74920128e-02f, 3.41956504e-02f,
  1.43394798e-01f, 1.02998577e-02f, -6.32257611e-02f, 2.32764408e-02f, 1.39793620e-01f, -2.58545112e-02f, -6.45261109e-02f, 6.86901137e-02f, -4.01476026e-02f, 5.90932630e-02f,
  -2.13099066e-02f, 1.21520311e-01f, -9.78611410e-02f, -7.45906169e-03f, -1.10560022e-01f, -4.28939648e-02f, 9.20865685e-02f, 1.65363669e-01f, 9.34337229e-02f, 2.91874856e-02f,
  -2.80960035e-02f, 1.12639433e-02f, -3.93314213e-02f, 3.64363752e-02f, 6.47882298e-02f, 7.83465877e-02f, -2.26131622e-02f, 2.14805678e-02f, 6.20507784e-02f, 9.33721960e-02f,
  5.23241460e-02f, -8.83032754e-02f, -1.32331988e-02f, -6.95860460e-02f, -6.15058094e-02f, -6.61467202e-03f, -7.39442632e-02f, -8.99755806e-02f, 1.44986764e-01f, -1.24146022e-01f,
  -6.04925528e-02f, 1.82848759e-02f, 4.31980416e-02f, 9.79659855e-02f, -9.02974084e-02f, 3.46522443e-02f, 1.08629264e-01f, 1.55843254e-02f, 5.86655410e-03f, 1.06434032e-01f,
  1.32337064e-01f, 1.12580813e-01f, 3.75437178e-02f, -4.72306758e-02f, 2.00396311e-02f, -6.79011941e-02f, 1.03393219e-01f, 1.87156335e-01f, 7.13496283e-02f, 8.13625753e-02f,
  -9.20849070e-02f, 9.47394818e-02f, 1.03133479e-02f, -2.77749468e-02f, 1.80101275e-01f, -1.04635008e-01f, 6.64099008e-02f, 2.04784662e-01f, -1.98821917e-01f, 1.47746652e-01f,
  1.05477154e-01f, 4.07631025e-02f, -1.01149911e-02f, -3.54313888e-02f, 7.09840283e-03f, -1.02451108e-01f, 3.35148387e-02f, 1.23659797e-01f, 4.61932085e-02f, 1.11304335e-02f,
  7.84873962e-02f, 8.12664703e-02f, -1.27558649e-01f, 5.96967936e-02f, 6.19472452e-02f, -1.22660913e-01f, 6.27505705e-02f, -2.81522190e-03f, -1.27779394e-01f, -8.77724681e-03f,
  2.45458577e-02f, -3.95797640e-02f, -1.31190658e-01f, -3.01877521e-02f, 1.71256512e-02f, -1.56215221e-01f, 6.06057644e-02f, -8.01840574e-02f, -6.43487349e-02f, -1.14309244e-01f,
  1.45257646e-02f, -6.53674453e-02f, -1.27950385e-01f, -1.20656647e-01f, 1.10351875e-01f, -2.05227397e-02f, 4.54455465e-02f, 7.74457380e-02f, -8.33504945e-02f, -3.87900323e-02f,
  -1.15795389e-01f, 7.63113648e-02f, 6.52594492e-02f, -8.48876610e-02f, 4.46553789e-02f, 8.16460773e-02f, 1.59311280e-01f, 4.76991609e-02f, 1.29748806e-01f, -8.42303410e-02f,
  -4.93429601e-03f, 4.13140357e-02f, -5.74828759e-02f, 5.19382134e-02f, 9.35043383e-04f, 3.23555917e-02f, 1.59862377e-02f, 2.37308927e-02f, -2.23282129e-01f, -1.44598737e-01f,
  8.23361650e-02f, 8.05780068e-02f, -1.34820059e-01f, -7.87645951e-02f, 2.53628809e-02f, -3.84161174e-02f, -1.01088904e-01f, -3.81172374e-02f, -7.74737373e-02f, 5.44774719e-02f,
  -7.41095766e-02f, -7.26501420e-02f, 1.03186421e-01f, 4.15929705e-02f, 9.65966731e-02f, -1.22078255e-01f, 5.87742366e-02f, 1.91327836e-02f, -3.91006470e-02f, -3.17846686e-02f,
  1.60094872e-01f, -3.91828641e-02f, -8.91279355e-02f, 6.64235279e-02f, 1.32437393e-01f, 2.50758920e-02f, 3.10020316e-02f, 6.50410056e-02f, 6.28473610e-02f, -3.62960063e-02f,
  1.19576983e-01f, -1.07874975e-01f, -1.06150553e-01f, -1.22980572e-01f, 7.05253631e-02f, 1.50017077e-02f, -1.71877965e-02f, 1.94005556e-02f, 2.02392682e-01f, 7.45928288e-02f,
  1.19198322e-01f, -7.93092847e-02f, -1.07487738e-01f, 4.15951088e-02f, -1.27161562e-01f, 5.33813313e-02f, 1.50439903e-01f, 1.57436609e-01f, 2.82332916e-02f, 1.67769238e-01f,
  1.55599520e-01f, 8.07515159e-02f, 1.92645006e-02f, -5.41219637e-02f, 1.91090181e-01f, 1.88405797e-01f, 9.51273963e-02f, 4.16438691e-02f, 1.88483030e-01f, 1.19287491e-01f,
  -1.69205725e-01f, 3.22312713e-02f, -2.21309870e-01f, -1.85347721e-01f, 6.06032498e-02f, 2.76817232e-01f, 4.05524783e-02f, -1.99557170e-02f, 1.79472253e-01f, 5.93595169e-02f,
  3.09534054e-02f, -9.23094898e-02f, -2.92969085e-02f, -1.03951514e-01f, 1.22177321e-02f, 1.48955109e-02f, 3.88321951e-02f, -1.24241240e-01f, 2.63735265e-01f, 1.61365643e-01f,
  -7.74259642e-02f, 8.41019675e-02f, 1.27724409e-01f, 2.69245580e-02f, 2.57471681e-01f, -9.46166925e-03f, -2.60871183e-02f, 2.38997233e-03f, 1.31377667e-01f, 5.21187782e-02f,
  -4.84615564e-02f, 1.03882551e-01f, -2.56239139e-02f, 2.52070963e-01f, 8.72331038e-02f, 4.13085334e-02f, 2.01926101e-02f, 8.67010802e-02f, -1.58180073e-01f, -1.57615229e-01f,
  -1.33596390e-01f, -9.16198939e-02f, 4.36314255e-01f, 1.89201966e-01f, 2.22262777e-02f, -2.38634963e-02f, -2.58558225e-02f, 3.60069610e-02f, -1.24022342e-01f, 6.34130612e-02f,
  -1.04853339e-01f, -4.22029793e-02f, 2.06992570e-02f, 4.83234897e-02f, 7.52214864e-02f, 1.12029813e-01f, -9.01041925e-02f, -7.76339620e-02f, -5.81050329e-02f, 9.96994134e-03f,
  -3.82423378e-03f, -5.95142096e-02f, 9.24254954e-02f, -1.49247661e-01f, 3.13292257e-03f, 3.84329185e-02f, 1.30597860e-01f, -1.92387074e-01f, -3.60798910e-02f, 8.53093527e-03f,
  1.04309611e-01f, 1.09709688e-01f, 1.17026508e-01f, 1.80811360e-02f, -1.18909158e-01f, 1.34615023e-02f, 8.29416737e-02f, 1.54185459e-01f, 1.06602021e-01f, 1.75181165e-01f,
  3.68409157e-02f, 3.82075310e-02f, -8.84160036e-05f, 1.43600732e-01f, 2.92391572e-02f, -3.08570638e-02f, 8.21259525e-03f, -1.29457295e-01f, 3.87527384e-02f, -2.77975146e-02f,
  1.22733369e-01f, 1.42848894e-01f, 2.09519789e-02f, 8.67193639e-02f, 1.19451694e-01f, -5.12959361e-02f, 2.96132243e-03f, 8.13666265e-03f, -7.65699968e-02f, -7.57994503e-02f,
  1.01420283e-01f, 1.82309095e-02f, -7.46970922e-02f, 7.05509111e-02f, 5.84731996e-02f, -1.08902805e-01f, 2.06280574e-01f, -4.21534292e-02f, 5.64086176e-02f, 4.81129298e-03f,
  1.29709989e-01f, -9.38981101e-02f, 2.41072297e-01f, 1.54891610e-01f, -8.39892849e-02f, 2.92731840e-02f, 6.30570725e-02f, 7.53865838e-02f, 4.44689021e-02f, 1.10159494e-01f,
  -1.05697252e-01f, -1.58646807e-01f, 1.16663910e-01f, -5.58246002e-02f, -7.08167255e-02f, 8.43394026e-02f, 2.07432769e-02f, -4.47470322e-02f, 7.51111656e-02f, 1.73349500e-01f,
  -6.14159368e-02f, 2.91893464e-02f, -6.27713930e-03f, -5.59789836e-02f, -1.49608716e-01f, -1.17625766e-01f, 1.03009298e-01f, -1.33999856e-02f, 1.67310133e-03f, 1.03595918e-02f,
  -7.79775605e-02f, 9.23237279e-02f, 1.25427470e-01f, -7.79954866e-02f, 1.45796556e-02f, -1.11328647e-01f, -5.08924462e-02f, 3.66054140e-02f, -1.29962321e-02f, 1.04027100e-01f,
  6.17668554e-02f, -1.28435627e-01f, -7.52804428e-02f, -4.05952372e-02f, 1.05128847e-02f, 2.48131491e-02f, 5.21669649e-02f, -5.24621904e-02f, 7.94341713e-02f, 1.02346830e-01f,
  1.12530671e-01f, -7.82144144e-02f, -9.76849869e-02f, -4.39641662e-02f, 1.63019411e-02f, 1.07869402e-01f, 6.80541107e-03f, 5.57806995e-03f, -6.53347075e-02f, -2.17989553e-02f,
  4.18277830e-02f, -1.78545000e-04f, 4.44747657e-02f, 3.92746702e-02f, -8.15321207e-02f, -8.36128816e-02f, -1.18350796e-01f, 1.76798284e-01f, 1.47646248e-01f, 2.07244039e-01f,
  2.54951924e-01f, 2.60386646e-01f, 2.56740488e-02f, 1.77634731e-01f, 2.55707353e-01f, -3.62077840e-02f, 2.38369614e-01f, 2.14560032e-01f, 2.06217661e-01f, 2.40077674e-01f,
  1.72660217e-01f, 2.80442655e-01f, -1.09553980e-02f, 1.10472083e-01f, -5.66605739e-02f, -2.97402918e-01f, 1.22579157e-01f, 2.57643193e-01f, -1.89072981e-01f, 1.39523700e-01f,
  2.03091040e-01f, 3.43143903e-02f, -4.28706519e-02f, 9.65205133e-02f, -1.36182168e-02f, 5.06521687e-02f, -1.48971885e-01f, -3.75426374e-02f, 1.55053064e-01f, -1.40939757e-01f,
  1.85236260e-01f, -1.24569749e-02f, 6.35819659e-02f, 9.09212157e-02f, -9.79121551e-02f, -1.02505445e-01f, 4.50608581e-02f, -1.50354818e-01f, -1.70500472e-01f, 2.71443248e-01f,
  7.26695433e-02f, 1.26356408e-01f, -9.90417376e-02f, 1.21047877e-01f, -7.78914690e-02f, 8.32531452e-02f, -1.28164142e-01f, -2.92164329e-02f, 9.99865383e-02f, -1.93794578e-01f,
  -2.49961615e-02f, -1.58767685e-01f, -1.28544107e-01f, -1.10285945e-01f, 4.01052594e-01f, 2.18612522e-01f, 2.91746929e-02f, 1.24100685e-01f, 4.59862314e-03f, -1.00832820e-01f,
  -9.66041535e-03f, 1.53577387e-01f, 1.13154821e-01f, 4.34805118e-02f, -1.71956271e-02f, -5.19398451e-02f, -2.44380813e-02f, 4.71448936e-02f, 1.47609487e-01f, -2.52080197e-03f,
  1.66698862e-02f, 7.62501583e-02f, 1.20682314e-01f, 1.60265446e-01f, -1.39334127e-01f, 8.56707245e-02f, -5.24743907e-02f, -5.13378084e-02f, -4.09607887e-02f, 3.02944658e-03f,
  -1.27558798e-01f, -9.25716758e-03f, -7.43379295e-02f, 1.22094326e-01f, 1.25766322e-01f, 1.51703089e-01f, -1.53927654e-02f, -1.20613717e-01f, 5.07238731e-02f, -2.96641234e-02f,
  2.11564898e-02f, 1.23972140e-01f, 1.14261001e-01f, 1.10827141e-01f, -4.62561324e-02f, -8.61649439e-02f, 1.75635461e-02f, -6.50627390e-02f, 5.74299656e-02f, -1.10041872e-01f,
  5.44535331e-02f, -1.21618852e-01f, -2.81279702e-02f, 1.74954250e-01f, 7.95364678e-02f, -1.47728130e-01f, -1.39758676e-01f, -3.17211598e-02f, -2.05749739e-02f, -4.83811162e-02f,
  -5.55925071e-04f, -2.65092496e-02f, 1.46475062e-02f, 4.87509221e-02f, -2.22802628e-02f, 6.68616369e-02f, -1.18578069e-01f, -2.09287889e-02f, 1.41494974e-01f, -4.61929440e-02f,
  9.54229087e-02f, -6.14110194e-03f, -6.54308423e-02f, -8.57448354e-02f, 1.78119838e-01f, -1.56758159e-01f, -4.62713353e-02f, 1.30027071e-01f, 1.87210292e-02f, -9.09602642e-02f,
  6.67536929e-02f, 9.98241603e-02f, 9.73351449e-02f, -3.07161594e-03f, -1.10902593e-01f, -8.46237019e-02f, -7.95086399e-02f, -5.36455177e-02f, 8.60887170e-02f, 4.01853099e-02f,
  -5.26066422e-02f, -9.00436379e-03f, 1.47692800e-01f, -1.40092343e-01f, 1.04449522e-02f, 3.86991575e-02f, 1.74692012e-02f, -7.82635659e-02f, 1.59680739e-01f, -7.45707080e-02f,
  -9.66915116e-02f, -2.39247214e-02f, -1.11056447e-01f, -3.12302988e-02f, 4.91810068e-02f, 2.03501746e-01f, 4.69393432e-02f, 1.47948503e-01f, 1.31173134e-01f, 3.73871699e-02f,
  3.78768258e-02f, 1.07421890e-01f, 1.06336012e-01f, -4.46033515e-02f, -2.49838606e-02f, 5.43861613e-02f, 8.23082551e-02f, 9.12235007e-02f, 1.00934774e-01f, -9.22965929e-02f,
  -1.40236877e-03f, 5.56598976e-02f, 6.75434023e-02f, -5.09502441e-02f, 1.15196228e-01f, 4.45568301e-02f, -1.52372951e-02f, 4.53560166e-02f, 7.23870024e-02f, -5.24885580e-02f,
  1.36155233e-01f, -1.12479582e-01f, 1.17714055e-01f, -7.55740032e-02f, -8.01712740e-03f, 7.00460896e-02f, 1.61237240e-01f, 2.37397142e-02f, 2.19363675e-01f, -1.09546430e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -6.94898069e-02f, 1.85622111e-01f, -6.80484027e-02f, 8.60130563e-02f, 6.06805161e-02f, -7.78887002e-03f, 1.48162365e-01f, -3.16835493e-02f, 3.37077044e-02f, 5.53586334e-02f,
  5.08148447e-02f, 1.08112238e-01f, 1.11071274e-01f, -9.26148240e-03f, -7.37409294e-02f, 3.80193256e-02f, 4.21570092e-02f, -1.58493058e-04f, -3.68923470e-02f, 6.37337863e-02f,
  -3.19633260e-02f, 6.36153445e-02f, 2.09105369e-02f, 7.49951303e-02f, 1.14699323e-02f, -8.68886523e-03f, 2.32512996e-01f, -3.49712595e-02f, 4.25338037e-02f, 8.39090943e-02f,
  -3.61772217e-02f, 8.28200653e-02f, 9.55160931e-02f, -2.87256334e-02f, 1.97911665e-01f, 9.61189345e-02f, -9.26039070e-02f, 1.56648368e-01f, -4.52552103e-02f, -1.27094588e-03f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  6.03397377e-02f, 1.14290819e-01f, 3.65081020e-02f, -1.84912479e-03f, 7.04071298e-02f, -6.24562129e-02f, 6.03704788e-02f, -5.88549674e-03f, 1.60621330e-01f, -1.25897573e-02f,
  1.24181889e-01f, -1.00872375e-01f, 1.04131654e-01f, 1.31550416e-01f, -2.83655226e-01f, -2.14614108e-01f, 3.48717511e-01f, -1.91642977e-02f, -3.44244130e-02f, -8.50146916e-03f,
  -9.48647931e-02f, 1.47338182e-01f, -2.52986759e-01f, 2.11955503e-01f, 1.59037203e-01f, -3.07738572e-01f, -9.27695259e-02f, -1.00839026e-01f, 1.67655602e-01f, 8.65083709e-02f,
  5.45388646e-02f, -4.15997766e-03f, 3.30856144e-02f, -6.94848821e-02f, -5.74464463e-02f, -4.11897935e-02f, 1.58985183e-01f, -1.22173004e-01f, 3.64167914e-02f, -1.72676131e-01f,
  1.33031728e-02f, 1.04984142e-01f, 1.50252283e-01f, 6.55234754e-02f, 6.54480830e-02f, -7.58521333e-02f, 1.69330314e-01f, -5.98158501e-03f, 6.34563863e-02f, 8.15729201e-02f,
  -2.26362929e-01f, -1.51107565e-01f, 6.22432865e-02f, -1.68763518e-01f, -5.05120270e-02f, 4.84498292e-02f, 6.62391707e-02f, 2.16417268e-01f, 1.31126478e-01f, -1.00453429e-01f,
  1.22497633e-01f, 6.73176795e-02f, 7.37359654e-03f, -1.71838135e-01f, -5.64866811e-02f, -1.28714472e-01f, -2.24710777e-01f, -5.65126650e-02f, -2.12932885e-01f, -1.05673987e-02f,
  -2.19600163e-02f, -1.16609447e-02f, -1.61501125e-01f, -1.42172128e-01f, -1.12386733e-01f, -6.88253194e-02f, -6.18714727e-02f, 4.30904664e-02f, -1.42496973e-01f, 1.62045822e-01f,
  5.35706840e-02f, -8.30006003e-02f, 1.41708523e-01f, 7.86126405e-03f, 4.48371004e-03f, -2.91692223e-02f, 5.24665900e-02f, -1.60131797e-01f, -4.01968807e-02f, 2.62346882e-02f,
  1.20426044e-01f, -3.50470878e-02f, -6.09140145e-03f, -7.07672760e-02f, -1.05968699e-01f, -5.78111000e-02f, 1.12792179e-01f, 5.87500446e-02f, 3.16458964e-03f, -4.98792157e-02f,
  8.74370858e-02f, 1.42712414e-01f, -3.39225167e-03f, 1.54405475e-01f, 2.42609382e-02f, -1.70972882e-04f, -1.82347111e-02f, 2.59974115e-02f, 8.29822347e-02f, -1.15259513e-01f,
  7.37874508e-02f, -8.80796313e-02f, -5.03898486e-02f, -3.40618961e-03f, 6.57605007e-02f, -6.69486821e-02f, 4.26432900e-02f, -2.12563463e-02f, -1.13510601e-01f, -4.79918607e-02f,
  5.11386544e-02f, 7.92065635e-02f, 3.86048034e-02f, 9.60879587e-03f, 1.08560193e-02f, -1.08341888e-01f, -9.68450904e-02f, -2.09717974e-02f, -8.44477862e-02f, -3.26918885e-02f,
  9.82625410e-02f, 1.63362145e-01f, 6.83200955e-02f, -8.26063901e-02f, -5.45703694e-02f, -7.27361487e-03f, 7.92003423e-02f, -8.54342580e-02f, 6.79427460e-02f, 1.03283256e-01f,
  1.53564066e-01f, -1.88027084e-01f, 4.35754769e-02f, 8.04399773e-02f, 7.71055669e-02f, 1.03609391e-01f, 9.13050622e-02f, -3.40070277e-02f, 1.03844181e-01f, 3.66561767e-03f,
  5.84624670e-02f, 9.43792164e-02f, 1.01950549e-01f, 2.16853283e-02f, 1.00841917e-01f, -5.92865385e-02f, 2.12568995e-02f, -1.38158992e-01f, 1.37529314e-01f, -8.66900086e-02f,
  5.75016774e-02f, -1.04724124e-01f, -6.48629889e-02f, 4.96702790e-02f, -9.05731320e-02f, -1.56169742e-01f, 6.06192350e-02f, -1.60190344e-01f, 4.57258569e-03f, 6.85572699e-02f,
  1.18817814e-01f, 7.02694282e-02f, -4.55534086e-02f, -3.48219462e-02f, -6.18089363e-02f, 7.61047378e-02f, 8.72534513e-02f, 9.85553116e-02f, -1.84574619e-01f, 8.63687918e-02f,
  1.10139079e-01f, -1.86246559e-02f, -1.24784783e-01f, 9.18240324e-02f, 7.97872841e-02f, -1.50355999e-03f, 5.39262593e-02f, -8.18491634e-03f, 5.05336896e-02f, 7.60860816e-02f,
  -1.96797699e-02f, -5.59873134e-02f, -1.74229503e-01f, -2.91603561e-02f, 1.09468058e-01f, -1.90339983e-01f, 1.42941564e-01f, -8.62197056e-02f, -3.74894850e-02f, -2.90438384e-01f,
  -3.51434648e-02f, -8.70427191e-02f, -1.41987428e-01f, 1.86484277e-01f, -5.53686284e-02f, 1.72545508e-01f, -1.35228440e-01f, -1.48999929e-01f, -9.03139636e-02f, 1.84658207e-02f,
  -1.82661876e-01f, -3.28793973e-01f, -1.38611451e-01f, 1.18678093e-01f, -1.35297298e-01f, 5.31339040e-03f, 8.99553746e-02f, -5.44943847e-02f, -8.23003880e-04f, -5.87419122e-02f,
  1.41079083e-01f, 2.07861722e-01f, -1.11320749e-01f, 8.79590660e-02f, 1.01287827e-01f, 7.53588453e-02f, -3.00349146e-02f, -2.47908562e-01f, -8.55877176e-02f, -6.50799945e-02f,
  3.45105566e-02f, -1.13598399e-01f, 4.82379049e-02f, -1.94936898e-02f, 9.16582067e-03f, 2.62194891e-02f, -1.92765165e-02f, 8.71495977e-02f, -1.32562906e-01f, 8.64194054e-03f,
  -6.30134940e-02f, 3.35147977e-02f, 1.05327241e-01f, -1.32634982e-01f, -1.15523890e-01f, -5.84667735e-02f, -6.80944547e-02f, -9.12714005e-02f, 3.14829126e-02f, 1.31422117e-01f,
  1.16603777e-01f, -1.02568135e-01f, 8.29501599e-02f, 7.33576939e-02f, -5.48341870e-02f, -1.18265457e-01f, 6.62768558e-02f, 2.08923090e-02f, -4.68897037e-02f, -3.69966775e-03f,
  -4.48840149e-02f, 1.17210887e-01f, -5.77272214e-02f, 3.77014726e-02f, -2.47394871e-02f, 3.76566313e-02f, -3.05296648e-02f, -1.18436657e-01f, -8.74394178e-02f, 4.57570367e-02f,
  3.26025605e-01f, 3.84867676e-02f, -1.02122284e-01f, 3.03807616e-01f, 1.12185463e-01f, -5.69411367e-02f, 9.73218493e-03f, -1.06764674e-01f, 3.74077447e-02f, 2.11100038e-02f,
  9.85020772e-02f, -8.63190442e-02f, -4.46887948e-02f, -8.65526381e-04f, -1.39669543e-02f, 1.59918174e-01f, 2.07729280e-01f, -7.06550330e-02f, 7.58995675e-03f, -1.16100371e-01f,
  -5.48702525e-03f, 3.04309912e-02f, -2.09674180e-01f, -1.40994951e-01f, -8.90639275e-02f, 1.48390932e-02f, -8.53237286e-02f, 1.48884922e-01f, -3.08499001e-02f, -5.83173707e-02f,
  -5.73433079e-02f, -6.20491914e-02f, 3.75336991e-03f, 3.24473679e-02f, -6.45020306e-02f, 5.50059900e-02f, 2.51077265e-01f, -3.62287052e-02f, -1.32126193e-02f, 1.77635506e-01f,
  3.83850895e-02f, 5.82489707e-02f, -9.66285821e-03f, -4.36718538e-02f, -2.11409912e-01f, -1.17477499e-01f, -1.24553546e-01f, -1.41990736e-01f, 4.13573533e-02f, -1.59800112e-01f,
  -1.12341806e-01f, -8.01783279e-02f, -1.38365000e-01f, -8.57435912e-02f, -1.06344245e-01f, -2.05362171e-01f, -1.45515621e-01f, -1.80617943e-02f, -1.66917786e-01f, 7.69413412e-02f,
  -1.31638110e-01f, -2.22799048e-01f, 2.35313490e-01f, -1.49932936e-01f, -3.85021150e-01f, -5.75474976e-03f, 1.25690162e-01f, -6.59239069e-02f, -7.77389780e-02f, 8.24455321e-02f,
  1.32413417e-01f, 1.95582565e-02f, 2.19849080e-01f, 1.75367475e-01f, 3.05976700e-02f, -3.58802043e-02f, 2.54746210e-02f, 5.00437282e-02f, 4.53087054e-02f, -1.29588172e-01f,
  -4.22094613e-02f, 6.93841204e-02f, 8.69731009e-02f, 5.07658795e-02f, 3.09047829e-02f, -3.33892889e-02f, 1.53609559e-01f, -1.40670761e-01f, 6.20153919e-02f, -1.12960778e-01f,
  8.84856060e-02f, 4.13269736e-02f, 7.00545833e-02f, 4.13818508e-02f, 2.78456286e-02f, 7.28312507e-02f, -6.85008839e-02f, -2.07819883e-02f, 1.11422196e-01f, 4.31179628e-02f,
  -1.53828830e-01f, 8.67638886e-02f, -5.28676659e-02f, -1.12094313e-01f, 1.37348220e-01f, -1.37270391e-02f, 1.29451498e-01f, 1.41840026e-01f, 1.51737764e-01f, -1.29767274e-03f,
  -4.92925569e-02f, 6.29574507e-02f, -1.26142934e-01f, 6.96151704e-03f, -1.17199354e-01f, -2.11432710e-01f, 5.02732769e-02f, -1.37382433e-01f, -2.32179984e-01f, 9.44483355e-02f,
  -1.17300168e-01f, -3.25834244e-01f, -2.07704544e-01f, -2.49408960e-01f, -8.88305902e-02f, -1.24673493e-01f, -1.82101488e-01f, -1.13080703e-02f, -6.92335218e-02f, 1.01412371e-01f,
  3.01562529e-02f, 2.12458953e-01f, 1.43938407e-01f, 2.47183610e-02f, -2.67367773e-02f, -3.81704047e-02f, -1.25983641e-01f, -1.43234715e-01f, 3.41821015e-02f, 9.70013887e-02f,
  1.22994229e-01f, 1.50747299e-02f, 1.13859437e-01f, 2.28683323e-01f, 9.46893245e-02f, -3.27181444e-02f, 3.63025325e-03f, -2.48801373e-02f, 1.03110455e-01f, -1.47575647e-01f,
  6.50736643e-03f, 1.79606512e-01f, -7.10970610e-02f, 1.02769196e-01f, -1.76936053e-02f, 3.42990085e-02f, 1.33020788e-01f, -7.96395093e-02f, 1.85454469e-02f, -1.21109530e-01f,
  1.21522948e-01f, -7.69264698e-02f, -6.40888512e-02f, 2.08106898e-02f, -6.70957416e-02f, -5.18426895e-02f, -1.11419819e-01f, 5.68786785e-02f, -6.69285953e-02f, 8.22694674e-02f,
  -1.30382046e-01f, -4.57582362e-02f, -9.83443484e-03f, 4.93635125e-02f, -1.35156944e-01f, -4.58461568e-02f, -7.35645145e-02f, 1.62378520e-01f, 1.16351359e-01f, 1.43769890e-01f,
  9.10037756e-02f, 1.02198973e-01f, 7.92747736e-02f, 1.53109103e-01f, 3.56153063e-02f, -1.07913531e-01f, 2.25150034e-01f, 1.52745947e-01f, 1.58622861e-01f, 1.31683320e-01f,
  -2.53299445e-01f, 2.99010307e-01f, 2.09001184e-01f, 1.50930174e-02f, -1.22191034e-01f, -1.65021986e-01f, -3.98501717e-02f, -3.20243478e-01f, 3.53286564e-02f, 6.42392933e-02f,
  -2.08386436e-01f, 8.24150667e-02f, -1.20479360e-01f, -9.53947753e-02f, 3.00208805e-03f, -5.83843812e-02f, -7.05081876e-03f, 5.18104993e-02f, 1.64652616e-02f, 7.43036624e-03f,
  -5.88314943e-02f, 3.05308606e-02f, 1.10845439e-01f, -1.73593673e-03f, 1.41953770e-02f, -1.35918586e-02f, -1.21214896e-01f, -8.82766694e-02f, 4.33451263e-03f, 3.92499268e-02f,
  3.94158345e-03f, -9.76154432e-02f, 8.03132430e-02f, 1.75790079e-02f, -9.06501114e-02f, 1.01406455e-01f, -7.46705802e-03f, 9.50925499e-02f, 9.03521478e-03f, 1.70394536e-02f,
  1.10487409e-01f, 1.21026643e-01f, -2.21804231e-02f, -1.36254445e-01f, 3.05263251e-02f, -4.92802402e-03f, -9.54482481e-02f, -3.49001959e-02f, -3.79367508e-02f, 5.08945109e-03f,
  1.34501681e-01f, 8.70205313e-02f, -1.01056166e-01f, -7.87376314e-02f, -1.18187025e-01f, -1.07660830e-01f, -1.99764743e-01f, -4.32148054e-02f, -1.79452766e-02f, -1.22546308e-01f,
  4.29315716e-02f, 3.06923557e-02f, -7.90215880e-02f, -1.50181562e-01f, -1.49997354e-01f, -4.69271913e-02f, 2.68181056e-01f, 1.85732096e-01f, -6.74902797e-02f, 3.16259146e-01f,
  1.37884691e-01f, 1.86565861e-01f, -4.39320616e-02f, -1.36917278e-01f, 1.28593415e-01f, -1.78271815e-01f, 9.05427337e-03f, 9.29615423e-02f, 1.91730350e-01f, -4.49355599e-03f,
  4.58599515e-02f, -4.47420441e-02f, 1.09021030e-01f, 2.60826368e-02f, 1.57237742e-02f, -9.51021537e-02f, -5.71021736e-02f, -8.86192098e-02f, -1.70578852e-01f, -9.07636434e-02f,
  3.14346179e-02f, 1.30180016e-01f, -6.63073808e-02f, 9.89575908e-02f, -6.49532825e-02f, 4.79839602e-03f, 1.97355598e-02f, 1.95832830e-02f, 1.80613343e-02f, 1.20776586e-01f,
  -2.36810185e-02f, 4.75798035e-03f, 1.11404054e-01f, 1.83930155e-02f, 7.43772602e-04f, 1.78189250e-03f, -6.81816190e-02f, -8.02684459e-04f, 3.26984860e-02f, -1.65691867e-01f,
  -1.63920537e-01f, 3.95615138e-02f, -2.58040545e-03f, -2.63594687e-01f, -1.33856758e-01f, 1.05683059e-01f, -1.87394306e-01f, 3.39675359e-02f, -9.15967599e-02f, -1.60917059e-01f,
  -6.02538846e-02f, -8.24008882e-02f, 8.85039009e-03f, -4.24386486e-02f, -9.98591632e-02f, -1.56958893e-01f, -1.10990018e-01f, 1.16285915e-02f, -4.41512279e-02f, 2.28381515e-01f,
  -5.87057658e-02f, -6.95869252e-02f, 1.50176078e-01f, 7.79362321e-02f, 5.46230935e-02f, -1.76776513e-01f, -1.38833597e-01f, -5.69038838e-02f, -2.42451474e-01f, 5.13156541e-02f,
  1.60283670e-01f, -2.67522365e-01f, -1.08950593e-01f, -1.38984129e-01f, 4.32229862e-02f, 2.00052634e-01f, 2.62287110e-02f, -1.83949731e-02f, -1.20073799e-02f, 5.70119247e-02f,
  -3.48485820e-02f, -1.85122844e-02f, 9.67283919e-02f, 9.31561440e-02f, 8.60946104e-02f, 2.09896378e-02f, 7.09642023e-02f, -1.09939966e-02f, -8.34562406e-02f, -8.04415643e-02f,
  -8.77407193e-03f, -1.48862615e-01f, 4.70974855e-02f, 1.33162573e-01f, -1.53602347e-01f, -2.31037959e-02f, -1.10138662e-01f, 8.90419409e-02f, -8.39686468e-02f, -1.09908633e-01f,
  -5.08581288e-02f, -1.22259453e-01f, -6.22630976e-02f, 1.00358039e-01f, 1.81694567e-01f, -1.11326054e-01f, 5.50662912e-02f, 3.98990400e-02f, -8.08128912e-04f, 5.52883446e-02f,
  7.50426343e-03f, 7.28179067e-02f, -1.11616217e-01f, -1.06980070e-01f, 1.17245771e-01f, -8.25526565e-02f, -1.10634482e-02f, -5.69504015e-02f, 1.36601493e-01f, -7.77157489e-03f,
  8.34675655e-02f, -1.00507468e-01f, -1.99797265e-02f, 1.99831307e-01f, -2.75556207e-01f, -2.01160073e-01f, 2.00787514e-01f, -1.56339165e-02f, 2.65302621e-02f, -6.49439171e-02f,
  -1.20907106e-01f, -9.59266326e-04f, -2.95420945e-01f, 3.49758148e-01f, 4.36424203e-02f, -3.34488153e-01f, -1.23479806e-01f, -1.75314639e-02f, 1.47623166e-01f, 1.66919634e-01f,
  1.35396361e-01f, 1.47734238e-02f, 1.55186474e-01f, -1.02149069e-01f, 1.04454473e-01f, 2.89299861e-02f, 2.36497279e-02f, 7.61594921e-02f, 1.09797582e-01f, -4.01229486e-02f,
  5.29377423e-02f, -3.59886102e-02f, 1.88095048e-01f, 4.79585864e-02f, -4.79378290e-02f, -1.31490976e-01f, 1.56431317e-01f, 2.50042174e-02f, -1.59495443e-01f, -3.58077325e-02f,
  -1.79417089e-01f, -8.01181644e-02f, 1.28080487e-01f, -1.60069525e-01f, 1.39096767e-01f, 1.09326551e-02f, -5.29057570e-02f, -1.92042179e-02f, 2.02040732e-01f, -1.17743067e-01f,
  3.00109806e-03f, 1.08777046e-01f, -1.24392323e-02f, -5.20343781e-02f, 8.42728019e-02f, 8.14224556e-02f, -5.36600612e-02f, -3.16838548e-02f, 1.58044353e-01f, -1.59323797e-01f,
  1.47863492e-01f, -1.12799667e-01f, 1.63640782e-01f, 1.48853913e-01f, 4.31650765e-02f, 2.22040303e-02f, -2.62399018e-03f, 1.22484386e-01f, -2.65553594e-01f, -1.30125761e-01f,
  1.28581211e-01f, -2.81529307e-01f, -6.28025681e-02f, -3.05939466e-01f, -5.96049652e-02f, 9.53777879e-02f, -1.38424963e-01f, 2.61383593e-01f, 6.48003891e-02f, -7.82781560e-03f,
  -1.36513680e-01f, 1.38549944e-02f, 2.95197014e-02f, 4.06178795e-02f, 7.99563248e-03f, -5.48955128e-02f, 7.18958974e-02f, -9.02499538e-03f, -5.66645488e-02f, -5.22551648e-02f,
  2.00945079e-01f, 1.12762652e-01f, -6.14924403e-03f, -1.58344463e-01f, 4.65898141e-02f, -7.86538720e-02f, 8.65466893e-02f, 1.26199409e-01f, 8.20818618e-02f, 7.02574626e-02f,
  -1.94488734e-01f, 1.15018651e-01f, -9.16981418e-03f, 7.15999231e-02f, -1.64229065e-01f, 8.80724378e-03f, -2.29526199e-02f, -6.21704869e-02f, -4.38249744e-02f, -9.74738896e-02f,
  -6.60956651e-02f, 1.44693196e-01f, 2.15859786e-01f, 3.14516425e-02f, -8.60802382e-02f, 2.48590112e-01f, 9.11692083e-02f, -7.87464753e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  9.88869071e-02f, -2.41014082e-03f, -3.01385447e-02f, 5.46413399e-02f, 1.51214749e-01f, -3.32136266e-02f, 1.81756184e-01f, 1.33700132e-01f, 8.51463154e-02f, -9.08567831e-02f,
  9.12621692e-02f, -2.57387832e-02f, 2.12739259e-01f, -1.12895757e-01f, -1.58503816e-01f, -1.36133447e-01f, 1.41565531e-01f, 1.68245577e-04f, 9.94356200e-02f, 3.35640945e-02f,
  1.71011433e-01f, -1.05617791e-01f, 1.53614953e-01f, 8.31288993e-02f, 2.73208618e-02f, 3.94591540e-02f, 4.26255390e-02f, 1.44444287e-01f, 6.25342727e-02f, -2.28857086e-03f,
  1.08975269e-01f, 8.22117701e-02f, 2.06578057e-03f, -1.24158368e-01f, -9.39716995e-02f, 2.23513111e-01f, 2.42845848e-01f, 2.09965538e-02f, 1.50564000e-01f, -8.18279833e-02f,
  -2.10184306e-02f, -1.44794196e-01f, 7.10887685e-02f, 1.85704038e-01f, -1.16611533e-01f, 1.31632611e-01f, 2.18989149e-01f, -4.22997735e-02f, 1.75014302e-01f, 3.82328816e-02f,
  -1.70812592e-01f, -4.33946168e-03f, -4.21043970e-02f, -1.64354265e-01f, 1.01900242e-01f, -4.21596579e-02f, -3.45643610e-02f, 4.01248038e-02f, 1.07314646e-01f, 2.09232699e-02f,
  -2.44922396e-02f, 5.55695631e-02f, -1.05892316e-01f, -1.21899903e-01f, -2.06503458e-02f, -1.19535318e-02f, 9.70275700e-02f, 1.34707717e-02f, 7.79116750e-02f, -9.83548164e-02f,
  -7.70966858e-02f, 1.16930038e-01f, 5.83419167e-02f, -6.70927316e-02f, 1.36532281e-02f, 7.69647211e-02f, 1.00825325e-01f, 7.48685095e-03f, 1.05316974e-02f, -8.12029541e-02f,
  -7.47273564e-02f, -8.72367620e-03f, -8.80951360e-02f, 4.15887833e-02f, 1.09358698e-01f, 3.39208692e-02f, 8.38244483e-02f, -8.28452036e-02f, 5.65080438e-03f, 1.83727983e-02f,
  -5.00521474e-02f, -1.02912068e-01f, -1.08380042e-01f, -3.07443663e-02f, -4.20714729e-02f, 5.81156909e-02f, -5.67726307e-02f, 1.47746596e-02f, 5.23231141e-02f, 8.66440535e-02f,
  1.37636080e-01f, 1.49625884e-02f, 3.24872620e-02f, 7.36485645e-02f, -6.05861619e-02f, -6.35635257e-02f, -6.59752637e-02f, 1.01308167e-01f, -3.25749777e-02f, 9.72872004e-02f,
  3.25312689e-02f, 1.16593279e-02f, 1.26632988e-01f, 3.19409147e-02f, -5.66270575e-02f, -4.62995581e-02f, -2.53478512e-02f, 1.84214616e-04f, -6.19316176e-02f, 1.14517145e-01f,
  -7.72713646e-02f, -9.82112512e-02f, 8.66756514e-02f, 1.34926036e-01f, 1.17270164e-02f, 8.81841115e-04f, 1.19996771e-01f, -4.84151877e-02f, 4.42302264e-02f, -5.25413081e-02f,
  1.33295417e-01f, 1.62580349e-02f, 3.40210972e-05f, 2.04819739e-01f, -1.99446324e-02f, 2.56278832e-02f, -9.23216119e-02f, -6.68860227e-02f, 3.73833925e-02f, -1.21966504e-01f,
  9.68939289e-02f, -1.08642928e-01f, 1.23752892e-01f, -8.88450071e-02f, 1.45048901e-01f, -5.67365400e-02f, 1.12375766e-01f, 1.07587837e-01f, -8.85379128e-03f, -1.01265199e-01f,
  3.52447256e-02f, -3.91895883e-03f, -4.58830148e-02f, -1.13148570e-01f, 6.29322007e-02f, 4.96931039e-02f, 1.30934700e-01f, 1.20495096e-01f, -7.42728412e-02f, -5.23595959e-02f,
  5.06210849e-02f, 8.33407268e-02f, -1.02645934e-01f, 1.59059405e-01f, 2.09015876e-01f, -5.73036671e-02f, 1.37780309e-01f, -1.53854519e-01f, -7.92975947e-02f, 1.16053402e-01f,
  1.48552507e-01f, 9.05942172e-03f, 8.14731605e-03f, -8.54703858e-02f, 2.66188353e-01f, 2.23243441e-02f, 1.48265705e-01f, -1.29871190e-01f, -8.65002722e-02f, 1.08902380e-01f,
  5.36852740e-02f, -1.46051526e-01f, -1.02173008e-01f, -7.23262355e-02f, -6.12757094e-02f, -2.61466969e-02f, 2.60378003e-01f, 1.76971145e-02f, 3.80408764e-02f, 2.05622569e-01f,
  -6.62776008e-02f, -2.27366891e-02f, -4.83590849e-02f, 7.46739134e-02f, -5.52298613e-02f, -1.87682966e-03f, 4.29240651e-02f, -4.39407416e-02f, 9.09112319e-02f, 1.10580266e-01f,
  7.90402107e-03f, -5.44876568e-02f, -1.02037676e-01f, -7.98566565e-02f, -2.61049699e-02f, -1.15827106e-01f, -2.13654369e-01f, -5.88988997e-02f, 1.42278686e-01f, -9.32739303e-02f,
  7.98012242e-02f, 1.09441176e-01f, 1.11831546e-01f, 6.53356016e-02f, 8.66355971e-02f, -5.36243506e-02f, 8.02668557e-02f, 1.70577914e-01f, 3.04568373e-02f, 1.32474720e-01f,
  -7.76665434e-02f, -4.11523096e-02f, 1.56825371e-02f, -5.77180870e-02f, 5.57927638e-02f, 1.38442725e-01f, 1.16975317e-02f, 8.81538168e-02f, 1.49406437e-02f, -4.10603248e-02f,
  -3.59142683e-02f, 2.13285293e-02f, 7.38391504e-02f, 6.55786321e-02f, 1.06532596e-01f, 1.50260061e-01f, -6.58112690e-02f, 3.81552763e-02f, 5.35636507e-02f, -6.53084442e-02f,
  6.75024912e-02f, -5.70690744e-02f, 8.57752264e-02f, 1.12468414e-01f, -1.03722118e-01f, -1.09079573e-03f, 1.24732954e-02f, 1.08789288e-01f, 1.23217881e-01f, 1.13624550e-01f,
  -1.13171386e-02f, 1.91806972e-01f, -8.43820721e-02f, 1.93083182e-01f, -7.58711994e-02f, 1.08987227e-01f, 1.89850837e-01f, 1.03312865e-01f, 1.21055588e-01f, -4.80772853e-02f,
  1.66304559e-01f, 1.58961788e-02f, 1.02440774e-01f, 3.13599706e-02f, 2.90434062e-02f, 1.56422839e-01f, -2.99654872e-04f, 4.86060902e-02f, -1.31860077e-01f, -2.19318435e-01f,
  1.39322281e-01f, -3.46006714e-02f, -1.69079289e-01f, 1.18265778e-01f, 1.50558978e-01f, 1.50639951e-01f, 7.31544867e-02f, -1.25272632e-01f, -9.08772647e-03f, 4.12898622e-02f,
  -9.44643170e-02f, 4.72349189e-02f, 1.99459121e-01f, 1.78733557e-01f, 9.26969945e-02f, 6.36573955e-02f, 1.84029415e-01f, -2.49501262e-02f, 1.34093706e-02f, 1.19488351e-02f,
  2.68407501e-02f, -3.37392674e-03f, -2.33732760e-02f, -9.83170122e-02f, -3.32351848e-02f, 8.50088820e-02f, -1.34007141e-01f, 6.51699528e-02f, 5.74317090e-02f, -1.13687389e-01f,
  -8.20702761e-02f, -5.65198716e-03f, 9.51361805e-02f, 1.38161063e-01f, 6.33051172e-02f, -1.29995178e-02f, 1.40290737e-01f, 1.43458322e-01f, -3.45526822e-02f, 1.33433565e-01f,
  -3.62216085e-02f, -7.61595666e-02f, 1.24555945e-01f, -1.05315641e-01f, 6.31593689e-02f, -1.53688028e-01f, -1.29900659e-02f, -7.78443068e-02f, 4.39335480e-02f, -9.40621123e-02f,
  1.69729516e-01f, 2.73680985e-01f, 2.79111564e-02f, 1.77984893e-01f, 3.94417979e-02f, 1.84579089e-01f, -6.24414720e-02f, -1.14024065e-01f, 1.70211390e-01f, 1.79247051e-01f,
  1.40466720e-01f, 3.26208286e-02f, -1.45156920e-01f, 1.94303468e-01f, -4.18987870e-02f, -1.13570608e-01f, -2.17928693e-01f, -3.26649621e-02f, -2.15962380e-01f, -3.49169910e-01f,
  -1.77890584e-02f, 1.85834765e-01f, -2.27527156e-01f, -6.08007573e-02f, 8.29875991e-02f, 1.55433878e-01f, 1.30356802e-03f, -8.28403756e-02f, 1.25230283e-01f, 2.16889501e-01f,
  -1.39150366e-01f, -8.10862780e-02f, 5.32584228e-02f, 1.30281284e-01f, -8.12516287e-02f, -1.73882559e-01f, -2.19712034e-02f, -2.71933861e-02f, 9.48130786e-02f, 2.30630875e-01f,
  1.64046437e-01f, 4.55552060e-03f, 4.39237021e-02f, 1.03215709e-01f, 4.62412983e-02f, -1.96881965e-02f, -1.57938942e-01f, -6.92098290e-02f, -9.00497362e-02f, 5.46156839e-02f,
  3.51117760e-01f, 8.26551393e-02f, -6.96264803e-02f, 1.29567832e-01f, 1.03761129e-01f, 6.12841472e-02f, -9.37545393e-03f, 1.04956292e-02f, 1.17224604e-01f, 1.13122009e-01f,
  -5.20343445e-02f, 3.03826451e-01f, 2.25610361e-01f, 1.71790048e-01f, 1.89916089e-01f, 2.56303586e-02f, 1.66837201e-01f, 5.62609127e-03f, 2.81653613e-01f, 7.85764977e-02f,
  1.67627290e-01f, -1.84081551e-02f, 4.74578477e-02f, 1.15586482e-01f, 3.03473771e-02f, 6.47938177e-02f, 1.10205099e-01f, -9.26063955e-02f, -2.76197255e-01f, 6.55537844e-02f,
  1.73226699e-01f, -3.74016076e-01f, -1.93896368e-01f, -4.96329069e-02f, 4.03036810e-02f, -1.65745407e-01f, 1.84525415e-01f, 1.57980938e-02f, -6.88844081e-03f, 2.48336300e-01f,
  -1.05661988e-01f, 1.39849886e-01f, 1.37006044e-02f, -1.67008221e-01f, -6.90655410e-02f, -7.34246820e-02f, 6.19854452e-03f, 1.42569661e-01f, 1.32828427e-03f, 3.13553125e-01f,
  2.58708715e-01f, -7.03836419e-03f, 9.55494866e-02f, -8.89535621e-02f, -4.01539616e-02f, -3.26453708e-02f, -3.01788319e-02f, 7.10462332e-02f, -1.42077710e-02f, 2.69710273e-01f,
  3.38618308e-02f, -1.73203535e-02f, 1.69620529e-01f, 8.44083205e-02f, -1.55534791e-02f, 6.06643632e-02f, -3.57929431e-02f, -1.53706580e-01f, 4.19985019e-02f, 6.59634098e-02f,
  1.53023258e-01f, 1.81087516e-02f, 2.82442480e-01f, 1.64930701e-01f, 2.44876510e-03f, 3.52030665e-01f, 1.16324062e-02f, -5.83171360e-02f, 2.68624067e-01f, 2.31761187e-01f,
  3.38261500e-02f, 2.94899762e-01f, 1.41462967e-01f, 2.12637395e-01f, 2.79014036e-02f, 1.68545619e-01f, 1.04223900e-01f, 2.56698132e-01f, 2.07783654e-01f, 3.36041264e-02f,
  -7.11384267e-02f, -2.19803244e-01f, 1.88649178e-01f, 2.62343884e-02f, -2.83301473e-01f, -1.04427515e-02f, -1.50716797e-01f, -3.40450695e-03f, 9.20534879e-02f, -5.75302914e-02f,
  1.23402812e-01f, -1.60946637e-01f, -1.30136564e-01f, 2.48951495e-01f, 2.01146379e-02f, 1.40781030e-01f, 2.41794959e-02f, -1.50178019e-02f, 1.03116348e-01f, 9.75763053e-03f,
  -1.38369486e-01f, 1.07511833e-01f, -3.89545001e-02f, 1.65740088e-01f, -1.30980074e-01f, 4.41125594e-02f, -3.79563123e-02f, 1.45694911e-01f, 4.00447510e-02f, -5.07685319e-02f,
  -3.60982418e-02f, -1.23342119e-01f, -6.46728128e-02f, 1.17730565e-01f, -1.21746860e-01f, -3.07882391e-02f, 1.60943896e-01f, 2.77111195e-02f, 4.25964117e-01f, -1.09253209e-02f,
  -1.34974971e-01f, 3.46860796e-01f, -5.96240535e-02f, -1.00418255e-02f, 1.23360470e-01f, -1.45491213e-01f, -1.45918906e-01f, -7.30460882e-02f, -1.43713534e-01f, 1.37828678e-01f,
  -4.04353179e-02f, 1.67056471e-01f, 3.73954587e-02f, 9.05205589e-03f, -8.12762976e-02f, 7.02934945e-03f, -4.08912338e-02f, 1.14225820e-02f, -4.71394584e-02f, -1.06338851e-01f,
  1.06415004e-01f, 6.24348316e-03f, -4.23593260e-02f, -1.50065705e-01f, -1.25999795e-02f, -8.50471184e-02f, 1.30278602e-01f, -1.32951038e-02f, 6.44783378e-02f, 1.32273719e-01f,
  -2.78602336e-02f, 4.21094242e-03f, -3.90714891e-02f, -1.27696037e-01f, 1.00552909e-01f, 8.72535855e-02f, 4.49313819e-02f, -1.04158245e-01f, 8.75908956e-02f, 1.11608878e-02f,
  -8.57322589e-02f, 5.14374375e-02f, 2.50103362e-02f, 1.18159577e-01f, 3.92793231e-02f, -5.03842719e-02f, 1.81439072e-02f, -5.69963120e-02f, 1.48684263e-01f, -5.37605099e-02f,
  1.40139297e-01f, 1.25700429e-01f, 9.76355374e-02f, 1.08145669e-01f, 3.58593166e-02f, 7.77060315e-02f, 2.73175128e-02f, 1.17421709e-01f, 5.97780347e-02f, 3.89371514e-02f,
  -9.66463163e-02f, -1.08564226e-02f, 1.83629215e-01f, -9.00899768e-02f, -1.01023518e-01f, 1.70849711e-01f, -1.04997903e-01f, -9.59379449e-02f, -4.72513661e-02f, 9.43640694e-02f,
  1.32604241e-01f, -3.92286852e-02f, 9.47011560e-02f, 6.40594736e-02f, -1.21153228e-01f, 7.44240172e-03f, -5.83987497e-02f, -2.10513007e-02f, -9.47493687e-03f, -5.51969418e-03f,
  6.12206832e-02f, 1.26904488e-01f, -1.92689747e-02f, 1.85711697e-01f, -8.06440786e-03f, 7.36671314e-02f, 1.44787757e-02f, -1.32878609e-02f, 5.37603581e-03f, -1.90203741e-01f,
  1.56435832e-01f, 6.96625784e-02f, 3.81375514e-02f, 2.71059096e-01f, 2.09391117e-01f, 2.51057804e-01f, 1.44608527e-01f, -1.28261194e-01f, 4.06630039e-02f, 1.51671199e-02f,
  3.25308293e-02f, 1.38765752e-01f, 4.13416214e-02f, 5.11818640e-02f, 1.15314931e-01f, 1.18489183e-01f, 2.24791765e-01f, -4.37234761e-03f, 8.93515348e-03f, -4.88667469e-03f,
  9.30473488e-03f, 1.49181783e-01f, -1.34438127e-01f, -6.53137416e-02f, -7.12609142e-02f, 1.61354780e-01f, -2.10523177e-02f, 1.52320892e-01f, 1.15710400e-01f, 2.53728591e-02f,
  1.17958322e-01f, 3.55037451e-02f, 1.05933793e-01f, -8.07126537e-02f, -3.12082581e-02f, -3.30479406e-02f, 2.21317053e-01f, 6.82538971e-02f, 2.35602856e-02f, 1.32684439e-01f,
  -4.85630985e-03f, 4.17240784e-02f, -4.86984886e-02f, 1.71438288e-02f, -7.95534030e-02f, 1.20373264e-01f, 6.60909712e-02f, -7.02582672e-02f, -1.01764351e-01f, -1.34387180e-01f,
  -4.94166464e-02f, 1.80938747e-02f, 6.60003722e-02f, -8.64424482e-02f, 9.30294469e-02f, 3.03283092e-02f, -7.30079040e-03f, -1.16568334e-01f, -1.37075067e-01f, -7.67595917e-02f,
  -8.33394565e-03f, 8.79480466e-02f, -9.35926735e-02f, 9.61716771e-02f, 3.35119478e-02f, -2.71496419e-02f, 1.38481289e-01f, 3.59358452e-02f, 1.93507478e-01f, 7.58111924e-02f,
  -2.19936952e-01f, -3.57150286e-02f, -1.03044949e-01f, 9.78458002e-02f, 1.02590963e-01f, -1.28315940e-01f, -1.94438584e-02f, -2.38551963e-02f, -6.36517778e-02f, 1.11016698e-01f,
  9.80001241e-02f, -4.80440110e-02f, 1.00335270e-01f, 2.31423266e-02f, 3.00062895e-02f, -2.07416490e-01f, 6.18353933e-02f, 9.78523716e-02f, -1.35485873e-01f, 1.47686437e-01f,
  5.94418235e-02f, -2.29704939e-02f, 6.83771968e-02f, -3.81550975e-02f, 7.94717148e-02f, -1.43804222e-01f, -8.69300961e-02f, -1.67474542e-02f, 4.94306497e-02f, -7.17999786e-02f,
  1.68396294e-01f, -4.92842756e-02f, -4.08276580e-02f, 1.54684037e-01f, -3.48883029e-03f, -1.22033380e-01f, -1.01047769e-01f, 8.08436498e-02f, 8.64459500e-02f, -1.03163138e-01f,
  -2.49447003e-02f, -3.76747176e-02f, 1.37355421e-02f, -9.91264954e-02f, -1.19316652e-02f, -1.08048953e-01f, 9.27218646e-02f, -2.41983123e-03f, 8.79198015e-02f, -6.13769591e-02f,
  1.12027481e-01f, -1.91370919e-01f, -8.70942771e-02f, -4.99933474e-02f, 5.45237213e-04f, -1.09455539e-02f, -1.18618436e-01f, 1.52847290e-01f, -4.15426493e-02f, 1.05989084e-01f,
  1.04767680e-01f, -1.27404127e-02f, 1.93770692e-01f, 3.13457623e-02f, -2.22917005e-01f, 1.57771744e-02f, 1.26408823e-02f, -7.09549114e-02f, -5.71414866e-02f, -4.71435534e-03f,
  1.57924265e-01f, -9.08910111e-02f, -2.93561220e-02f, 1.48933008e-01f, -1.36457920e-01f, 8.59119371e-02f, -4.20279242e-02f, 1.41877338e-01f, 7.75516778e-02f, -7.51456916e-02f,
  2.03485057e-01f, 7.81910717e-02f, 3.74447480e-02f, 1.05694808e-01f, 1.89547434e-01f, 1.18636534e-01f, -4.64509986e-02f, -1.28976136e-01f, 8.29232931e-02f, 7.72954673e-02f,
  4.71643768e-02f, 6.48682266e-02f, -1.50869831e-01f, 7.04698218e-03f, -4.45285020e-03f, -5.63313924e-02f, 1.25665190e-02f, -5.99050522e-02f, -1.85667984e-02f, -1.13108665e-01f,
  -4.01443616e-02f, -4.24744785e-02f, 2.80945659e-01f, 1.41032580e-02f, -1.09623060e-01f, 1.62203476e-01f, -1.19434586e-02f, 7.55144134e-02f, 1.21571280e-01f, 7.64245465e-02f,
  2.95511521e-02f, 6.88887909e-02f, 1.16891317e-01f, -4.12343740e-02f, 3.26665714e-02f, 6.73013180e-02f, 9.92890671e-02f, -5.97518906e-02f, -5.14479652e-02f, -5.24004884e-02f,
  -4.46675234e-02f, -9.39582810e-02f, -1.55381605e-01f, -7.48644769e-02f, 1.12529509e-01f, -1.15065314e-01f, 8.89529958e-02f, -1.28191471e-01f, -6.10847771e-02f, 4.53689098e-02f,
  -1.08888932e-01f, -1.33724418e-02f, 3.00048254e-02f, 7.66646490e-02f, -4.33936082e-02f, -6.80413619e-02f, -1.00930847e-01f, -1.24123044e-01f, 4.64115925e-02f, -5.76113760e-02f,
  -8.90205503e-02f, -3.21030803e-02f, -1.16538601e-02f, -8.07084814e-02f, -4.87910844e-02f, -8.28877091e-03f, -2.16521807e-02f, -2.84800120e-02f, 9.98333022e-02f, -8.45608115e-02f,
  6.60523921e-02f, -2.82857101e-02f, -6.21890500e-02f, 5.21134958e-03f, 8.07011127e-02f, 1.58716217e-02f, 1.07767686e-01f, 5.24874032e-03f, 5.52330315e-02f, -6.83478788e-02f,
  -5.40219322e-02f, -8.33989903e-02f, -3.88268009e-02f, 9.96851400e-02f, 7.10372031e-02f, 5.07750399e-02f, -2.83569470e-02f, 1.61329359e-02f, 1.19488113e-01f, 8.60255770e-03f,
  -4.20931093e-02f, 6.50660023e-02f, 8.86463448e-02f, 3.86713624e-01f, 3.54673937e-02f, 2.10773170e-01f, 2.57904708e-01f, -1.50188044e-01f, 1.45584568e-01f, 4.01038051e-01f,
  2.50870883e-01f, 2.32438758e-01f, 2.83474624e-01f, 2.81155616e-01f, 1.22592375e-01f, 2.88843662e-02f, -3.66220385e-01f, -1.04476660e-01f, 6.59938306e-02f, -3.61662030e-01f,
  -3.09226096e-01f, -1.13447309e-01f, 2.72347212e-01f, -5.81455044e-02f, 1.60641104e-01f, 2.56230652e-01f, 3.65906022e-03f, 9.41037089e-02f, -1.66447714e-01f, -3.92390862e-02f,
  -1.11984350e-01f, -1.87814519e-01f, -1.14838809e-01f, -1.10841177e-01f, -8.92773867e-02f, 7.35776573e-02f, 4.58091460e-02f, 2.86936730e-01f, 3.61367494e-01f, -9.48667154e-02f,
  8.29182938e-02f, -7.83081912e-03f, 1.39931470e-01f, -1.02837704e-01f, 9.98515710e-02f, 1.65397584e-01f, -1.30756781e-01f, 6.52779415e-02f, 1.68799777e-02f, 6.36737272e-02f,
  2.10879937e-01f, -6.16514757e-02f, -4.12156582e-02f, -7.33741745e-02f, -7.00131282e-02f, -1.00575551e-01f, 7.82515202e-03f, -1.71303228e-02f, 1.94808617e-01f, 1.22009113e-01f,
  2.36156553e-01f, -7.75088370e-02f, 3.47863659e-02f, 5.58084428e-01f, -5.56000881e-02f, -1.45317810e-02f, 4.89568785e-02f, 2.02723265e-01f, -5.14536425e-02f, 7.99695216e-03f,
  -4.83267605e-02f, 1.20442040e-01f, 5.67358956e-02f, 9.23769325e-02f, -3.21587431e-03f, -5.35887778e-02f, 1.04168765e-01f, 7.60209039e-02f, 3.02261747e-02f, -1.31730020e-01f,
  1.58361703e-01f, -1.54552171e-02f, -8.79675373e-02f, -2.49696467e-02f, -2.21075248e-02f, -8.99719521e-02f, -8.65388438e-02f, 1.73914865e-01f, -4.52889502e-02f, -1.55672207e-01f,
  -1.09783933e-01f, 1.11175835e-01f, -8.68741423e-02f, -4.18134853e-02f, 9.23677608e-02f, 1.34570003e-02f, 1.43202409e-01f, -1.38938516e-01f, 5.57854436e-02f, -4.08304110e-02f,
  -7.46514574e-02f, -6.61243573e-02f, -1.59567729e-01f, 1.05843090e-01f, -1.29110605e-01f, 1.96073472e-01f, -3.34326550e-02f, 9.01817158e-02f, 2.87229009e-02f, 1.04943775e-01f,
  -2.54695932e-03f, -6.13607541e-02f, -9.41199809e-02f, -8.04482587e-03f, 6.88411817e-02f, 2.05452349e-02f, 2.64142066e-01f, 2.16213334e-02f, 4.78717573e-02f, 1.96980163e-01f,
  4.16359641e-02f, 6.03091009e-02f, -7.06190765e-02f, 9.24724638e-02f, -1.34538040e-01f, 2.37384550e-02f, -1.54975569e-02f, 3.82142514e-02f, 3.19185592e-02f, -8.71076286e-02f,
  6.06374331e-02f, 1.32844597e-01f, -1.82710793e-02f, 4.19559516e-02f, -7.12277517e-02f, -1.15172816e-02f, -7.42929131e-02f, 2.07410268e-02f, -3.96207906e-02f, 4.63872552e-02f,
  -6.86198026e-02f, -1.31394610e-01f, 5.37965214e-04f, -6.46770447e-02f, -1.34842798e-01f, 1.63228698e-02f, -6.87692910e-02f, -4.63418588e-02f, -9.41530988e-02f, 8.15344900e-02f,
  -7.65420198e-02f, -9.10924524e-02f, 7.04489350e-02f, 2.90160887e-02f, -6.42822906e-02f, -9.08129662e-02f, -2.67219841e-02f, -8.79836604e-02f, 4.31090891e-02f, -1.69471521e-02f,
  -5.28831333e-02f, 4.24991772e-02f, 8.33861530e-02f, 1.09313661e-02f, -3.52278836e-02f, 6.96735736e-03f, -4.09011021e-02f, -4.91126738e-02f, 7.27608502e-02f, -7.87258223e-02f,
  9.03024599e-02f, -6.02630712e-02f, -8.65334086e-03f, 1.20877631e-01f, -6.89365119e-02f, -1.25919031e-02f, 1.35735989e-01f, -6.44394308e-02f, -4.69857119e-02f, -1.08140267e-01f,
  7.06839338e-02f, 1.06102750e-01f, 1.38429506e-02f, -3.38908173e-02f, 7.48245567e-02f, 3.09487786e-02f, -2.03049462e-02f, 8.36621970e-02f, 8.19056630e-02f, -4.49737273e-02f,
  1.06616370e-01f, -6.64274469e-02f, -1.00720813e-02f, -6.55014589e-02f, -3.91977765e-02f, 1.24721862e-01f, -2.26320494e-02f, 7.01210722e-02f, 1.27068177e-01f, 1.53938502e-01f,
  1.16664343e-01f, -1.77110612e-01f, 7.51312599e-02f, -5.61134294e-02f, 1.29585311e-01f, -2.15347297e-02f, -2.58431256e-01f, 1.89807966e-01f, 1.48449078e-01f, 2.05365866e-02f,
  6.55997917e-02f, -8.89510736e-02f, -4.53756899e-02f, -1.59710377e-01f, -1.11158684e-01f, 2.15161428e-01f, -2.40963355e-01f, -1.96689032e-02f, 3.84639413e-03f, 4.38012816e-02f,
  -1.31735891e-01f, -3.18382569e-02f, 2.10078359e-02f, 2.21808732e-01f, -6.93129823e-02f, 1.28218597e-02f, -2.17896644e-02f, 7.09413737e-02f, 1.17959619e-01f, -9.11973789e-02f,
  2.51946338e-02f, 1.75091401e-02f, -7.29767457e-02f, 9.74451751e-03f, -1.61372647e-02f, -8.61990675e-02f, 5.56179024e-02f, -4.70859408e-02f, 2.97805313e-02f, 1.10861912e-01f,
  -7.60947391e-02f, 8.79996866e-02f, -1.65658444e-01f, -1.39644686e-02f, 2.01050818e-01f, -1.40867382e-01f, -4.47394280e-03f, -7.08149821e-02f, 7.36663267e-02f, 1.09655604e-01f,
  1.15449905e-01f, -2.33238023e-02f, 8.96788016e-03f, 9.28122252e-02f, -1.29103228e-01f, 2.06936479e-01f, -3.03335581e-02f, -5.90693094e-02f, 1.50827929e-01f, 1.14544019e-01f,
  2.38631651e-01f, 1.22603904e-02f, 2.16426343e-01f, -3.58114690e-02f, -1.10485747e-01f, -1.13913260e-01f, 1.57145202e-01f, 7.29487911e-02f, 6.43610954e-02f, 1.64241701e-01f,
  -3.26890685e-02f, 4.35669534e-02f, 6.02133274e-02f, -4.78657335e-02f, -1.70275480e-01f, -1.68964028e-01f, -7.59529397e-02f, 7.20581086e-03f, 8.14308450e-02f, -4.41285223e-02f,
  1.82221785e-01f, -1.44195169e-01f, -1.16306648e-01f, 3.10472369e-01f, 1.06793553e-01f, -3.04246992e-02f, 4.17698622e-02f, -5.31717055e-02f, 2.10649017e-02f, -1.55690759e-01f,
  -9.67834368e-02f, -3.33584729e-03f, 1.10366717e-01f, 1.50965020e-01f, 1.13351233e-01f, -5.08648455e-02f, 9.85403508e-02f, 8.94379392e-02f, 1.70880601e-01f, 5.89563772e-02f,
  -9.63088032e-03f, -1.50026888e-01f, 3.44663449e-02f, -7.18053663e-03f, -1.49244577e-01f, -1.04451761e-01f, 1.77865639e-01f, -6.34664297e-02f, -1.38316182e-02f, -5.88663705e-02f,
  9.63523425e-03f, -1.02858514e-01f, -9.26397219e-02f, 1.07305966e-01f, 1.36311725e-01f, -7.04517141e-02f, 1.03255585e-01f, 1.91989109e-01f, -1.21245183e-01f, 9.87046957e-02f,
  1.38892895e-02f, 8.51333886e-02f, -9.27523300e-02f, 6.86869100e-02f, 1.55625105e-01f, -1.30977724e-02f, -7.09482506e-02f, 2.21742652e-02f, 3.57304625e-02f, 5.16458862e-02f,
  1.13352962e-01f, 9.34009328e-02f, 9.72474366e-03f, 4.60198410e-02f, 1.38571173e-01f, -3.27443816e-02f, -6.91019595e-02f, -5.82701974e-02f, -1.07028209e-01f, -1.21082120e-01f,
  7.28559867e-02f, -1.82314869e-03f, -4.23691534e-02f, 9.14470032e-02f, 1.90952476e-02f, -1.98593847e-02f, -1.66324358e-02f, 2.56019793e-02f, -5.47403470e-02f, -5.62476963e-02f,
  -8.29678625e-02f, -5.07873483e-02f, -5.56193180e-02f, -3.57567817e-02f, -7.80741647e-02f, -7.01037571e-02f, 1.08752027e-01f, -7.08819181e-02f, 1.03120290e-01f, 1.20794140e-01f,
  -9.56867561e-02f, -3.31859030e-02f, 7.83886015e-02f, -1.72866620e-02f, 6.97157830e-02f, 3.44072022e-02f, 1.10419132e-01f, -7.93331191e-02f, 1.15271330e-01f, -1.09916165e-01f,
  -3.63707207e-02f, 1.19139403e-02f, 5.21569140e-02f, -9.51205492e-02f, 8.25525634e-03f, 1.29509345e-01f, -7.26455972e-02f, 9.57348943e-02f, 4.64970805e-03f, 2.31153537e-02f,
  1.11350566e-01f, 3.53225470e-02f, 5.57063669e-02f, 2.50767707e-03f, 3.22486125e-02f, 9.50744301e-02f, -1.54780790e-01f, -9.81049240e-02f, 5.60591556e-02f, -1.00355461e-01f,
  -1.28326938e-01f, 1.34396404e-01f, 1.13026708e-01f, -7.83869773e-02f, 4.04196382e-02f, -1.36301875e-01f, -4.93811294e-02f, -1.65797770e-01f, 8.42595175e-02f, 2.42930162e-03f,
  -1.89376801e-01f, -1.22125991e-01f, 3.48152108e-02f, -9.04589891e-02f, -3.06525640e-02f, -2.69819535e-02f, -2.46626344e-02f, 3.79027091e-02f, -1.47708207e-01f, 7.20942020e-02f,
  2.13039685e-02f, -9.09786075e-02f, 5.44105917e-02f, -1.32400870e-01f, 3.24753020e-03f, 2.42469758e-01f, -1.11126579e-01f, -8.10759440e-02f, -2.07758248e-02f, 1.98291033e-03f,
  1.18797578e-01f, -4.29629646e-02f, 4.82776500e-02f, 1.12189136e-01f, -4.05148864e-02f, -5.19921295e-02f, -2.41774134e-02f, 1.29416555e-01f, 2.58569270e-02f, -8.65448490e-02f,
  5.37843034e-02f, -6.69206157e-02f, 1.34807363e-01f, 7.60809928e-02f, 1.60221551e-02f, -3.59061658e-02f, 1.09466098e-01f, 1.20888509e-01f, 1.14989527e-01f, -7.98743591e-02f,
  1.45270713e-02f, 4.97998446e-02f, -6.07132688e-02f, 7.82955345e-03f, 2.74857879e-01f, 1.26062885e-01f, -1.77408699e-02f, 2.42758185e-01f, -4.71271537e-02f, -1.07873358e-01f,
  4.37810980e-02f, -1.04559176e-02f, 1.06735192e-02f, 7.83997588e-03f, 8.81097838e-02f, 2.13154510e-01f, 1.54220611e-01f, 2.48767495e-01f, 1.59378037e-01f, 1.51234105e-01f,
  7.03178272e-02f, -3.95972244e-02f, 1.62203223e-01f, -2.55607992e-01f, 9.66686234e-02f, 3.92274149e-02f, 4.08201851e-02f, 1.54915467e-01f, 1.22272186e-01f, 5.54523431e-02f,
  2.20656723e-01f, -1.33870095e-01f, 1.28863797e-01f, -1.63200006e-01f, 7.52453953e-02f, 2.59967782e-02f, 1.28079146e-01f, 1.54836196e-02f, 8.84828568e-02f, 5.87619133e-02f,
  -3.21152247e-02f, 8.81152898e-02f, -4.68620434e-02f, -1.83356330e-02f, -3.58824991e-02f, 2.16631562e-01f, -1.08624019e-01f, 5.17673455e-02f, 4.09916639e-02f, 1.56401284e-02f,
  -1.47934660e-01f, 9.00661647e-02f, -4.09291387e-02f, 1.05414420e-01f, -8.22035894e-02f, 2.17350665e-02f, 1.85630023e-01f, 2.07808446e-02f, 1.77426755e-01f, 9.34221596e-02f,
  7.66216815e-02f, 3.49644460e-02f, -8.76484811e-02f, 2.81578392e-01f, -3.78430560e-02f, 1.09783830e-02f, 1.11822285e-01f, 7.54383057e-02f, -1.25138938e-01f, 1.69427600e-02f,
  -1.23954937e-01f, -7.24045560e-02f, -1.40646219e-01f, 6.76525906e-02f, 1.22862577e-03f, 4.32629548e-02f, -2.13070959e-02f, 7.64946565e-02f, -3.74393016e-02f, -9.07187685e-02f,
  -1.32293962e-02f, -6.39944971e-02f, 1.23089664e-01f, -2.08054874e-02f, 1.20226994e-01f, 1.56757012e-01f, -1.85547963e-01f, 2.04258189e-01f, -1.50874317e-01f, -6.28343672e-02f,
  1.32842109e-01f, -3.39278653e-02f, -1.79628953e-01f, -4.59108539e-02f, 3.18698138e-02f, 1.73508033e-01f, -1.34987801e-01f, 2.01516330e-01f, 2.27410831e-02f, -1.78541556e-01f,
  -1.69747278e-01f, -2.71965601e-02f, -1.01439334e-01f, 1.87913135e-01f, 6.22229427e-02f, 2.38098553e-03f, 6.54874295e-02f, 6.28602207e-02f, -8.30296800e-02f, -1.33804262e-01f,
  1.25716357e-02f, 5.89063158e-03f, -5.05035045e-03f, 2.61360519e-02f, -1.72899235e-02f, -8.08438286e-02f, 1.02103867e-01f, -1.20690212e-01f, 8.82232562e-02f, -1.30010784e-01f,
  -8.02889392e-02f, 4.11355644e-02f, 5.51342033e-02f, 1.12263754e-01f, -2.21864283e-02f, -1.32572740e-01f, 4.97069843e-02f, 1.13965861e-01f, 6.56690672e-02f, 3.08411475e-02f,
  1.03979386e-01f, 1.91901997e-01f, 1.76137164e-01f, 2.93779261e-02f, 1.49887556e-03f, 2.67532587e-01f, -2.48767762e-03f, -8.69929865e-02f, -1.62434615e-02f, 7.06363022e-02f,
  -1.18241109e-01f, -7.31131285e-02f, 3.93190533e-02f, -1.18113525e-01f, 1.12557830e-02f, -1.54596806e-01f, -8.24925005e-02f, -4.58602980e-02f, 9.71098319e-02f, -1.27274558e-01f,
  -4.54534367e-02f, 6.18445016e-02f, 5.44110872e-02f, 1.45070972e-02f, 4.46030125e-02f, 6.72692084e-04f, 5.49107715e-02f, 1.25840018e-02f, -5.00225835e-02f, -6.51414320e-02f,
  1.25926286e-02f, -8.78303126e-02f, -1.11106619e-01f, 5.57811232e-03f, 1.43123148e-02f, -5.30989319e-02f, -9.90385488e-02f, -3.08715012e-02f, -1.92447137e-02f, -9.94575247e-02f,
  8.32028091e-02f, -1.41824074e-02f, -9.79952589e-02f, -7.76779875e-02f, -2.70194933e-02f, -9.38058794e-02f, -1.02639891e-01f, 6.21137768e-02f, 5.17040342e-02f, -1.03036642e-01f,
  1.33474782e-01f, 3.11981142e-02f, -3.30445133e-02f, 3.63247916e-02f, -1.03717133e-01f, 1.18056275e-01f, 1.80197321e-02f, 1.73378959e-02f, 6.82951733e-02f, -1.70933325e-02f,
  -4.85299267e-02f, 3.77338491e-02f, -1.08154729e-01f, -6.12420123e-03f, 7.99496844e-03f, -1.19572952e-01f, 1.21960141e-01f, 2.41049230e-02f, -1.14455223e-01f, 1.08965673e-01f,
  1.34089068e-01f, 5.06727248e-02f, 5.99486865e-02f, 6.12687282e-02f, 7.17799887e-02f, 8.52300376e-02f, -4.77079116e-02f, -2.88333427e-02f, -3.77523638e-02f, -7.42253885e-02f,
  -1.34195909e-01f, 1.25302240e-01f, -1.32483676e-01f, -4.04143631e-02f, 1.74526852e-02f, -1.05255842e-01f, -6.92798048e-02f, 8.23052526e-02f, 8.73896778e-02f, -8.61321166e-02f,
  1.25919078e-02f, 1.37479499e-01f, -7.64302537e-02f, -1.66022666e-02f, 1.15935102e-01f, -8.91216621e-02f, -7.35943019e-02f, 1.46585166e-01f, 6.71516696e-04f, -2.33825948e-03f,
  4.40641008e-02f, -3.74210402e-02f, -1.69213321e-02f, 7.85007328e-02f, -8.48797932e-02f, -7.71539658e-02f, -4.02291566e-02f, 1.86302543e-01f, 9.85637531e-02f, 4.81319092e-02f,
  -2.84637026e-02f, -5.57189435e-02f, 7.40545169e-02f, 2.32601655e-03f, -2.25424627e-03f, -7.93356001e-02f, 1.09430410e-01f, 9.83876362e-02f, 5.79122221e-03f, -1.88362543e-02f,
  9.81449783e-02f, -1.34870306e-01f, 1.41236916e-01f, -1.06029920e-02f, -9.94466022e-02f, -4.20683324e-02f, -3.36323120e-02f, -3.75099555e-02f, -1.59649458e-02f, -5.87303787e-02f,
  -1.06797747e-01f, 3.19945663e-02f, 1.16177328e-01f, -5.94534464e-02f, 3.07758851e-03f, -8.99049416e-02f, -8.82624686e-02f, -4.04713415e-02f, -1.71119417e-03f, -1.33243650e-01f,
  1.14471748e-01f, 7.60530755e-02f, 3.36299390e-02f, -1.15045011e-01f, 1.17916368e-01f, 8.17245916e-02f, 4.08020569e-03f, 4.84565124e-02f, -1.45351544e-01f, 2.13934973e-01f,
  -8.70554000e-02f, -1.73800960e-01f, 1.74629297e-02f, -1.24671459e-01f, -1.18585713e-01f, -1.71341114e-02f, -1.97587863e-01f, 1.70233667e-01f, -2.29378328e-01f, -4.79399599e-03f,
  -8.00398812e-02f, -6.57719970e-02f, 5.63815199e-02f, -1.24175586e-01f, -3.24665494e-02f, 5.54118156e-02f, 7.81549364e-02f, 4.24970465e-04f, -5.93366325e-02f, 8.32039863e-02f,
  9.42965224e-03f, -5.15700802e-02f, 1.15148760e-02f, 1.72451660e-01f, 1.10922763e-02f, 1.45811677e-01f, 2.14746775e-04f, -3.27435285e-02f, -5.61787784e-02f, -1.30380049e-01f,
  -7.75826862e-03f, -1.53982462e-02f, -1.21152103e-01f, 3.63603309e-02f, -2.24258471e-02f, 1.10984616e-01f, 1.02879405e-01f, 9.43093821e-02f, -5.93119301e-02f, -6.59510046e-02f,
  -3.35955173e-02f, 4.84210327e-02f, 4.58047464e-02f, 8.28455612e-02f, 2.30539545e-01f, 2.35535279e-02f, 5.70359416e-02f, 1.02042958e-01f, -4.78557386e-02f, 5.30436169e-03f,
  4.66903150e-02f, -5.91511726e-02f, 5.03145494e-02f, 7.71417767e-02f, 5.10303816e-03f, 9.98120829e-02f, 6.16491362e-02f, -1.00262381e-01f, -7.46050850e-02f, -7.09916092e-03f,
  3.83564271e-02f, -1.22595951e-02f, -1.13482118e-01f, 6.33755652e-03f, 6.84854761e-02f, -8.94744545e-02f, 3.95029485e-02f, 5.09191230e-02f, 1.37547627e-01f, -1.35566548e-01f,
  -1.81052938e-01f, 2.31358558e-02f, -1.63709313e-01f, 3.27125825e-02f, 1.00035258e-01f, -6.40583783e-02f, 8.64739567e-02f, -1.27067298e-01f, 1.47138610e-01f, 3.16374689e-01f,
  1.36217579e-01f, 6.30865712e-03f, 1.29337050e-02f, 7.18315914e-02f, 2.57932097e-02f, -1.66242316e-01f, 5.02415374e-02f, -3.50599177e-02f, -4.11050655e-02f, 1.51639789e-01f,
  -5.28776795e-02f, 6.93399981e-02f, 5.63550368e-03f, -6.24180324e-02f, -4.64452291e-03f, 6.75364509e-02f, -1.22892030e-01f, 1.53203979e-01f, -1.73945799e-01f, -9.63790342e-03f,
  1.70609117e-01f, 1.00902490e-01f, -8.13389942e-02f, 2.38880083e-01f, 6.07486861e-03f, 4.38528098e-02f, -5.40305786e-02f, 7.53125921e-02f, 9.73006710e-03f, -9.80374366e-02f,
  -9.10793915e-02f, -1.24301299e-01f, 9.79557261e-02f, 1.32113937e-02f, 3.81404087e-02f, 9.96935070e-02f, 1.10312611e-01f, 3.36239003e-02f, 2.28426438e-02f, -1.17377453e-01f,
  -3.01890858e-02f, -9.08965915e-02f, -6.73987940e-02f, -7.60901421e-02f, -7.29087442e-02f, 1.09766401e-01f, 1.02401219e-01f, -2.39573848e-02f, 1.51783107e-02f, -8.48595649e-02f,
  -8.15812033e-03f, -5.41445129e-02f, -7.73017183e-02f, 4.86406982e-02f, 9.18743461e-02f, -1.01184979e-01f, -8.85570124e-02f, -3.93435061e-02f, -5.67575395e-02f, -8.18824098e-02f,
  1.01772331e-01f, -4.09348607e-02f, 1.85224563e-02f, 8.01354125e-02f, 8.29070434e-02f, 2.08747387e-03f, 1.02444641e-01f, 3.79118770e-02f, -9.85078439e-02f, -1.05555587e-01f,
  -1.19581603e-01f, -3.57770994e-02f, -6.92180246e-02f, -8.86926129e-02f, 5.32048307e-02f, -5.18096909e-02f, 1.10772520e-01f, 1.06888138e-01f, 1.12714611e-01f, -8.01804662e-03f,
  -9.07994285e-02f, -3.43989469e-02f, -1.81043940e-03f, 7.79826865e-02f, -2.07903665e-02f, 6.61985129e-02f, 1.73925757e-02f, -2.29848512e-02f, 6.08733967e-02f, -1.03688002e-01f,
  -1.20887831e-01f, -4.63748015e-02f, -1.64939091e-02f, -6.89192414e-02f, -8.74951929e-02f, -2.94677205e-02f, -2.14497503e-02f, 6.41733930e-02f, 1.46956174e-02f, 2.63782054e-01f,
  2.12489128e-01f, 2.28017867e-01f, 2.43995056e-01f, 3.05527806e-01f, 2.32488692e-01f, -2.47515008e-01f, 2.02178136e-01f, 1.43234119e-01f, 1.48905635e-01f, 3.30863386e-01f,
  -4.20938939e-01f, 3.80665839e-01f, 2.33459249e-01f, -2.03882575e-01f, -5.20708896e-02f, -1.00485593e-01f, -2.51193345e-01f, -2.93351680e-01f, -8.61257911e-02f, 3.52635622e-01f,
  -3.21698546e-01f, -5.27882278e-02f, 2.84054577e-02f, -7.87410587e-02f, -9.95476991e-02f, -3.45513076e-02f, 1.31986022e-01f, 4.27397698e-01f, -9.07863975e-02f, 5.93024828e-02f,
  1.38006762e-01f, 1.49681747e-01f, -1.06105283e-01f, -1.87000871e-01f, -8.11474472e-02f, 9.18662176e-02f, -1.33743644e-01f, 1.54765204e-01f, -3.79527025e-02f, 4.43211012e-02f,
  -1.19336650e-01f, -9.61178914e-02f, -2.37195976e-02f, -4.21543084e-02f, -1.30350128e-01f, 1.45085469e-01f, 2.95400713e-02f, 7.15242773e-02f, 4.74204242e-01f, 8.77603218e-02f,
  -1.50202736e-01f, 1.59067228e-01f, -9.32864025e-02f, -1.40824631e-01f, 1.37496799e-01f, 7.26118833e-02f, 2.29956836e-01f, -2.24521384e-01f, -1.47165269e-01f, 2.50833213e-01f,
  2.30980292e-01f, -8.63577574e-02f, -2.50422470e-02f, 5.03615886e-02f, 5.13234958e-02f, -6.29742965e-02f, 2.83645876e-02f, 9.03378204e-02f, -1.00844979e-01f, -1.18780494e-01f,
  9.01601762e-02f, -5.96249849e-02f, 6.77895173e-02f, 1.20851472e-01f, 9.52972397e-02f, 9.00699273e-02f, -9.80471969e-02f, 1.22706592e-01f, 4.34159972e-02f, 5.74763259e-03f,
  -9.54965204e-02f, 1.47764443e-03f, 4.36062217e-02f, 6.77071512e-02f, 9.57925990e-02f, 4.07749265e-02f, 8.33934769e-02f, 9.69689190e-02f, -9.90579575e-02f, 1.35844588e-01f,
  -5.98915480e-02f, -3.79528850e-02f, -4.07292582e-02f, -8.04457143e-02f, -7.85834491e-02f, -2.80404203e-02f, -8.45755058e-05f, 5.57619072e-02f, 1.36875868e-01f, 1.01598948e-01f,
  -4.78089452e-02f, 1.86672822e-01f, 1.27188265e-01f, 7.97050353e-03f, 8.39047413e-03f, 6.65396824e-02f, -1.08781710e-01f, 2.82530542e-02f, 3.94504284e-03f, -4.98962179e-02f,
  -5.10695279e-02f, 4.43279743e-02f, 4.39943150e-02f, -2.03527380e-02f, -9.81908068e-02f, 4.10580263e-02f, 6.68742359e-02f, 8.23733807e-02f, -4.13478538e-02f, -9.00874510e-02f,
  9.68939513e-02f, 1.29793286e-01f, -2.31322204e-03f, -7.68910050e-02f, 5.06017841e-02f, 1.01788931e-01f, -8.09469372e-02f, -9.73017067e-02f, 2.87217498e-02f, 1.52828535e-02f,
  1.00488104e-01f, 1.80794939e-01f, 1.99777745e-02f, -1.85291335e-01f, 9.08424929e-02f, 7.20667541e-02f, 1.17521763e-01f, 1.71091393e-01f, -1.69215024e-01f, 1.10724688e-01f,
  1.44564867e-01f, -1.38673961e-01f, 1.80148091e-02f, -4.46373262e-02f, 4.99223173e-02f, -1.45066217e-01f, -2.05326766e-01f, 1.69997930e-03f, -1.89405680e-01f, 4.36354354e-02f,
  -9.51743424e-02f, -1.62827045e-01f, -6.14702404e-02f, -5.51568605e-02f, -8.60810354e-02f, 2.54330456e-01f, 1.09443225e-01f, 1.39756128e-02f, -5.15688621e-02f, 1.34188205e-01f,
  3.96327227e-02f, -1.02907263e-01f, 6.76283846e-03f, 1.63131833e-01f, -6.84403582e-03f, -5.34233041e-02f, -1.02327421e-01f, 1.56045111e-03f, -2.10443381e-02f, 3.29146795e-02f,
  -1.12186603e-01f, -1.44716576e-01f, -8.52502584e-02f, 5.43143153e-02f, -7.51303509e-02f, 1.17605202e-01f, 1.40998736e-01f, -1.21459872e-01f, 2.73743309e-02f, 1.95826769e-01f,
  8.16442966e-02f, 6.47588223e-02f, -1.10933082e-02f, 8.28970131e-03f, 1.71749666e-01f, -6.92086620e-03f, -4.69891541e-02f, 1.28025278e-01f, -3.18678804e-02f, -7.70143047e-02f,
  1.89346656e-01f, -3.65975313e-02f, -9.71966609e-02f, 1.60330310e-01f, -8.10758099e-02f, 1.93488210e-01f, 1.87028021e-01f, 2.23004296e-01f, 1.16305605e-01f, 1.01097189e-01f,
  7.12037534e-02f, 1.37227392e-02f, 2.12022159e-02f, -1.13798276e-01f, 4.13507223e-02f, -6.36297911e-02f, -6.86053187e-02f, 2.24452928e-01f, 7.86612928e-02f, 2.41939157e-01f,
  9.90962684e-02f, -6.52513877e-02f, 8.72106776e-02f, -1.96837515e-01f, -2.30303686e-02f, 6.50766492e-03f, 2.42158324e-01f, -6.05486706e-02f, 6.73396289e-02f, 9.65513811e-02f,
  1.60793319e-01f, -1.44913852e-01f, -1.55784413e-02f, 1.80014446e-02f, -6.31551445e-02f, 1.17732070e-01f, -1.09496832e-01f, 8.86250436e-02f, -1.16011307e-01f, 5.74876107e-02f,
  -1.26112863e-01f, 8.23151991e-02f, 3.30206100e-03f, 1.22850813e-01f, 1.42689899e-01f, -1.79855898e-02f, 8.72641951e-02f, -1.07331879e-01f, -2.98787206e-02f, -2.94565372e-02f,
  2.73641497e-01f, 1.47626787e-01f, 3.35794613e-02f, 3.90894651e-01f, -1.56495869e-02f, 1.22724608e-01f, -1.29939109e-01f, -9.47802067e-02f, -6.47407398e-02f, 1.34016916e-01f,
  -5.80022633e-02f, -2.06196919e-01f, 9.86165181e-02f, -7.40908086e-02f, 1.28179463e-02f, -2.65527628e-02f, 3.62023129e-03f, 4.55669127e-03f, -1.60369352e-01f, -9.01261717e-02f,
  3.66780050e-02f, 1.13873430e-01f, 6.34922879e-03f, 1.47421211e-01f, -5.11825942e-02f, -7.73057491e-02f, -1.66653022e-01f, -5.25027588e-02f, 2.18324617e-01f, -4.19834740e-02f,
  -1.84787855e-01f, 1.37001857e-01f, -6.46568686e-02f, -2.03754604e-01f, 9.03502256e-02f, 9.59738493e-02f, 4.73070629e-02f, -1.81206897e-01f, 3.94306257e-02f, 6.94324672e-02f,
  -4.25329879e-02f, 6.02194592e-02f, 5.05109839e-02f, 2.11759984e-01f, -1.68840103e-02f, -1.03967004e-01f, 7.44912922e-02f, 2.37242468e-02f, 5.26121370e-02f, -1.21287189e-01f,
  -1.65345699e-01f, 2.45327950e-01f, -7.78135359e-02f, 3.65225643e-01f, 1.01295039e-01f, 8.71426836e-02f, -8.46282914e-02f, 7.10979849e-02f, 2.92240363e-02f, -9.67794880e-02f,
  -1.65450662e-01f, -8.79252627e-02f, -9.59348083e-02f, -1.28318325e-01f, 3.30849111e-01f, 1.05668105e-01f, -4.62458543e-02f, 4.32146251e-01f, -4.14938554e-02f, 1.27974942e-01f,
  -1.65731564e-01f, -1.48621082e-01f, -5.11618555e-02f, 1.73418239e-01f, -6.65637776e-02f, -2.32689023e-01f, 1.34854168e-01f, 1.06328756e-01f, 9.16769579e-02f, 6.91652531e-03f,
  7.32111260e-02f, 1.32799819e-01f, -7.14523569e-02f, -1.11963507e-02f, 8.24483410e-02f, 3.16946283e-02f, -4.29739766e-02f, 7.55233411e-03f, 1.26248509e-01f, 7.52086565e-02f,
  8.84004086e-02f, 4.51693498e-02f, -1.83361284e-02f, 1.97884709e-01f, -8.85132104e-02f, 2.63930298e-02f, 9.95236710e-02f, 1.03411764e-01f, 3.85752060e-02f, 1.54092128e-03f,
  -2.61120517e-02f, -1.58086225e-01f, -3.47249322e-02f, 8.55353028e-02f, 3.53826657e-02f, 1.34627014e-01f, 5.14275506e-02f, -1.17797719e-03f, -9.21172053e-02f, -6.24809228e-02f,
  -9.61904749e-02f, 1.00550942e-01f, 1.43275470e-01f, 1.90544426e-02f, 1.63401023e-01f, 1.23639017e-01f, 1.96680352e-02f, 3.58194299e-02f, 1.68170735e-01f, -4.70310040e-02f,
  2.17173658e-02f, -6.64790720e-02f, 4.44177166e-02f, 2.24994287e-01f, 6.43019155e-02f, -3.42815556e-02f, 8.45917165e-02f, -1.34730935e-01f, -3.34977657e-02f, -9.74305626e-03f,
  5.53092435e-02f, -5.22093140e-02f, -9.16390195e-02f, 1.27005711e-01f, -4.32924069e-02f, -5.58450632e-02f, 1.62087195e-02f, 2.12115064e-01f, 6.37498721e-02f, 8.14586654e-02f,
  -1.18096601e-02f, -2.77393814e-02f, -5.07838354e-02f, 1.25698652e-02f, 5.80541082e-02f, 7.28769898e-02f, -2.95731630e-02f, 7.42406324e-02f, -1.60382222e-03f, -5.33264950e-02f,
  1.43052712e-01f, 7.27679878e-02f, -1.55409146e-02f, -1.09578617e-01f, 8.88339430e-02f, -1.27436846e-01f, -8.94032419e-02f, -1.67469084e-01f, -6.01204634e-02f, -1.74211025e-01f,
  -2.21436266e-02f, -1.62151661e-02f, 6.93451986e-02f, -7.77750239e-02f, -6.59596622e-02f, 1.80246577e-01f, -8.04403275e-02f, -1.18002936e-01f, -8.45936686e-02f, -1.22823426e-02f,
  -2.45389342e-02f, -9.48192924e-02f, 7.42929876e-02f, -6.41391501e-02f, 8.54868889e-02f, -5.99754155e-02f, -9.68286842e-02f, 1.12047695e-01f, 1.81249529e-02f, -1.25851423e-01f,
  1.09690897e-01f, -1.31481187e-03f, -3.85921299e-02f, 9.17083770e-02f, 5.69373593e-02f, 1.57939807e-01f, 1.95631087e-02f, -1.53270196e-02f, -4.40553762e-02f, -6.41305521e-02f,
  -7.51006454e-02f, -5.06129563e-02f, -1.06809504e-01f, -4.28441502e-02f, 8.47236142e-02f, -8.54148641e-02f, -2.65905168e-02f, -6.72139823e-02f, 2.61148699e-02f, 1.54487073e-01f,
  1.14616856e-01f, 1.19584687e-01f, 2.57210564e-02f, 8.78994819e-03f, 6.58435374e-03f, 2.31360663e-02f, -2.82803122e-02f, -1.08759381e-01f, 4.57503498e-02f, 2.24729311e-02f,
  1.43887382e-02f, -3.79802845e-02f, -8.74580666e-02f, 1.21008575e-01f, -1.05021037e-01f, -1.65840052e-02f, 1.00967087e-01f, -7.33615234e-02f, 6.60020113e-02f, -1.27804503e-01f,
  -7.58575201e-02f, 6.44765720e-02f, -1.51825305e-02f, -5.42953461e-02f, 8.80100206e-02f, -5.34452386e-02f, 8.94937366e-02f, -9.06480197e-03f, -9.12514850e-02f, -1.44320056e-01f,
  5.46870045e-02f, -8.33102986e-02f, -8.72092620e-02f, -3.95311490e-02f, 1.10375375e-01f, 9.88745615e-02f, 3.48831676e-02f, -4.98718163e-03f, -2.63381675e-02f, 5.35953715e-02f,
  -1.00856185e-01f, -1.07693575e-01f, -1.25658542e-01f, 2.04875320e-02f, -2.48015039e-02f, 3.90862562e-02f, -3.81322615e-02f, -7.88437277e-02f, -1.83402877e-02f, -8.48393589e-02f,
  5.32499179e-02f, -3.06494981e-02f, 4.77228984e-02f, 1.06864832e-01f, -4.18948345e-02f, 1.03044912e-01f, 1.06574044e-01f, 9.19996798e-02f, 4.43805121e-02f, -5.98351359e-02f,
  -2.98718419e-02f, -1.10491030e-01f, 9.39219594e-02f, -6.44996837e-02f, -2.71244161e-02f, 7.98827782e-02f, 1.16709873e-01f, -1.32401258e-01f, -1.18420541e-01f, -2.78630219e-02f,
  1.30118281e-01f, 2.49033961e-02f, -1.01022549e-01f, 7.20674023e-02f, -1.10317104e-01f, 1.59111153e-02f, -5.44218197e-02f, -2.43549999e-02f, 4.92861085e-02f, 4.23386432e-02f,
  9.73108932e-02f, -1.57476246e-01f, 8.21076557e-02f, -1.44840285e-01f, 7.23716021e-02f, -9.82833430e-02f, 1.62341654e-01f, 1.13323510e-01f, 1.75936207e-01f, 4.22150642e-02f,
  -1.08274288e-01f, -1.15459830e-01f, -7.26875886e-02f, 6.41087443e-02f, 3.72421369e-02f, -5.61071001e-02f, 1.17404059e-01f, 2.98957173e-02f, 1.34408876e-01f, 7.11632594e-02f,
  -1.35669415e-03f, 6.04574569e-02f, -3.25604156e-02f, 3.28040086e-02f, -4.38605547e-02f, 1.12576045e-01f, -3.29499207e-02f, 5.04920110e-02f, 7.41745830e-02f, 3.59872170e-02f,
  1.20555900e-01f, 6.74711987e-02f, 1.42448604e-01f, 8.58479440e-02f, 1.17995717e-01f, -4.78967279e-02f, 5.06502055e-02f, 1.04333379e-03f, -2.48507857e-02f, -8.27778354e-02f,
  -1.27501786e-02f, 6.11296371e-02f, -8.87502879e-02f, 1.16501689e-01f, -1.10630602e-01f, 2.42512790e-04f, -1.07473489e-02f, -8.17491487e-02f, 1.17804304e-01f, -2.47463603e-02f,
  1.62575543e-02f, -3.49584967e-02f, -7.54293799e-02f, -1.54161407e-02f, -1.03642762e-01f, -4.68059219e-02f, -2.80644279e-03f, 4.18449715e-02f, 8.66312832e-02f, 2.83087138e-02f,
  5.44151850e-02f, 3.52932066e-02f, -3.81770208e-02f, -8.10129717e-02f, -4.17123828e-03f, -5.83242662e-02f, -1.24564089e-01f, 1.25988554e-02f, 3.09403101e-03f, -6.19230121e-02f,
  1.28035903e-01f, -4.70088460e-02f, -2.32579596e-02f, -2.81592389e-03f, -3.08369379e-03f, -3.00574806e-02f, 2.98377890e-02f, 5.56755662e-02f, -3.55415903e-02f, 3.11505534e-02f,
  -1.93909965e-02f, -8.80818218e-02f, 1.25236958e-02f, 7.23345056e-02f, 8.12960044e-02f, -3.63055356e-02f, -1.22649364e-01f, -1.89813059e-02f, 6.72526807e-02f, -8.73992145e-02f,
  -4.21635015e-03f, -6.42401427e-02f, 3.03779040e-02f, -6.73250714e-03f, -9.46631059e-02f, 2.65163295e-02f, -7.45822862e-02f, 1.82472281e-02f, 7.81779885e-02f, 3.02818827e-02f,
  -2.41888762e-02f, 6.69912323e-02f, 1.22330226e-01f, 2.06217989e-02f, 1.35220006e-01f, -7.72088319e-02f, -9.30723101e-02f, -5.13874069e-02f, -8.78304839e-02f, -1.63493957e-02f,
  1.05599865e-01f, -4.13737334e-02f, -1.26073182e-01f, -6.20195605e-02f, -1.62427966e-02f, 7.13950321e-02f, -2.17905138e-02f, -1.13719903e-01f, -4.89185862e-02f, 6.41135201e-02f,
  1.70636013e-01f, 5.90154901e-02f, 3.82157378e-02f, 3.23475786e-02f, 1.53821900e-01f, -1.00057954e-02f, 2.80658770e-02f, -4.59713414e-02f, -4.86747772e-02f, -1.33587390e-01f,
  3.03784497e-02f, -1.51615083e-01f, -8.36234614e-02f, -5.25930291e-03f, 9.58464965e-02f, -7.54104089e-03f, 1.19018592e-01f, 2.15597734e-01f, 6.12490252e-02f, -1.38035566e-01f,
  -1.91558972e-02f, -5.24900779e-02f, -9.45118144e-02f, 7.70768747e-02f, 9.78770778e-02f, 1.08138360e-01f, 2.52717473e-02f, -2.59086043e-02f, -9.13638100e-02f, 4.59875874e-02f,
  1.46838976e-02f, 6.83131889e-02f, 1.07387342e-01f, 2.18518227e-02f, 1.25316903e-01f, 4.45469543e-02f, -2.16402188e-02f, -6.36658743e-02f, 6.33692816e-02f, 1.08673736e-01f,
  9.06025991e-02f, 9.24223512e-02f, 5.71782887e-02f, 1.88058674e-01f, 1.07357994e-01f, -2.62017641e-02f, 1.62227564e-02f, -1.51111297e-02f, 5.04895970e-02f, 1.04198545e-01f,
  -7.33521953e-02f, -3.73520814e-02f, -5.24537312e-03f, 1.62290651e-02f, -1.90245621e-02f, 6.91581890e-02f, 4.75159362e-02f, 9.36124548e-02f, 1.16679169e-01f, 1.47373388e-02f,
  5.14127538e-02f, 3.11302580e-02f, -1.07307546e-01f, 1.27383754e-01f, -1.58760130e-01f, 5.25246225e-02f, -1.27155006e-01f, -4.33499590e-02f, 9.10645425e-02f, 3.13225091e-02f,
  -6.37551621e-02f, -2.84723490e-02f, 8.26556906e-02f, 5.05777970e-02f, -1.74564943e-01f, 4.82106283e-02f, 1.57063827e-01f, -4.14772257e-02f, 4.46399581e-03f, 1.07954431e-03f,
  2.78630294e-03f, -4.83161974e-04f, 1.91397071e-02f, 7.83997178e-02f, -2.15744767e-02f, 7.91640428e-04f, 1.09442383e-01f, 4.71113250e-02f, 7.16131032e-02f, 1.89572144e-02f,
  1.24452055e-01f, 1.74734086e-01f, 1.65224746e-01f, 9.84965116e-02f, 7.09535107e-02f, 1.73033848e-02f, 8.87143053e-03f, 3.94228287e-02f, -1.43985838e-01f, -1.14696048e-01f,
  -2.70652231e-02f, -5.81888780e-02f, -3.24702486e-02f, 1.46906301e-01f, -8.57917741e-02f, -9.69219580e-02f, -4.78009135e-02f, -8.24642107e-02f, 3.53547209e-03f, 1.40932739e-01f,
  8.83702412e-02f, 7.50049502e-02f, 2.32951716e-01f, 3.46772261e-02f, 3.48389409e-02f, 1.09422646e-01f, -6.06162958e-02f, -1.00224666e-01f, -3.31872702e-02f, 1.09226452e-02f,
  7.50673488e-02f, -8.55122805e-02f, -9.22684595e-02f, -4.37077209e-02f, -4.12565805e-02f, -1.07469544e-01f, 3.11106086e-01f, 1.09876297e-01f, 2.66440660e-01f, 2.23113775e-01f,
  2.52579868e-01f, 7.82970339e-02f, 1.33714288e-01f, 2.58820117e-01f, 2.48468723e-02f, 1.25005230e-01f, 2.57229328e-01f, 2.46491402e-01f, 7.41737634e-02f, -1.76361129e-01f,
  9.02957190e-03f, 1.15182482e-01f, 1.17911279e-01f, -1.88039854e-01f, -1.33537099e-01f, 7.17979223e-02f, 2.07619265e-01f, -2.61947185e-01f, 1.80012569e-01f, 7.45207891e-02f,
  -2.36720560e-04f, 2.02875048e-01f, -8.53742007e-03f, 1.96140170e-01f, -1.17566571e-01f, -1.33587167e-01f, 1.05411343e-01f, 7.75408596e-02f, -1.08514860e-01f, 3.10219824e-04f,
  8.98137689e-02f, 3.18645388e-01f, 1.29809171e-01f, -1.37655511e-01f, 4.73048128e-02f, -8.63440856e-02f, 1.75265893e-01f, -1.27667829e-01f, -2.94251982e-02f, 2.84627844e-02f,
  -4.22481224e-02f, 1.07341513e-01f, 1.97505161e-01f, 5.71876131e-02f, 1.53487459e-01f, 5.04613593e-02f, 2.96387207e-02f, 4.91963848e-02f, 6.48268536e-02f, 9.11137182e-03f,
  -1.15272850e-01f, -9.66657773e-02f, 2.02637076e-01f, -1.09522939e-01f, 1.67759582e-01f, -4.86081205e-02f, 1.13479465e-01f, 3.37399065e-01f, 4.02367413e-02f, 7.27269202e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  7.33218566e-02f, 2.55704336e-02f, 3.43972594e-02f, -4.88372929e-02f, -4.57522133e-03f, -8.15911666e-02f, 4.53647487e-02f, 9.57323089e-02f, -4.75494601e-02f, 5.79026751e-02f,
  5.64208347e-03f, 1.92767868e-04f, -6.61747754e-02f, 1.69833601e-01f, 1.16851762e-01f, -6.77625313e-02f, 2.83453800e-02f, -2.04265267e-02f, 7.45460019e-02f, -1.09786389e-03f,
  1.65822208e-01f, -7.54254544e-03f, 7.56265372e-02f, 5.69420233e-02f, 1.13707781e-01f, 1.03963546e-01f, 2.17453577e-02f, 2.00291336e-01f, 1.07850999e-01f, 1.02950940e-02f,
  1.44531026e-01f, 8.40701833e-02f, 4.53568175e-02f, -2.54420247e-02f, 4.81111519e-02f, -4.09950204e-02f, 2.32988019e-02f, -2.37980634e-02f, 8.73652697e-02f, 1.23452544e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.47149876e-01f, -3.93167920e-02f, 5.78125492e-02f, -2.76031226e-01f, -1.99589983e-01f, 1.06511950e-01f, -1.97863013e-01f, 7.87534267e-02f, -3.88662159e-01f, -2.04898760e-01f,
  -5.14509995e-03f, -2.08825395e-01f, -1.36676237e-01f, 2.77968287e-01f, -1.88288674e-01f, 3.80647257e-02f, 2.28869200e-01f, -1.51179701e-01f, 2.19441399e-01f, -2.65936077e-01f,
  2.09444910e-01f, -9.40311030e-02f, -2.39691183e-01f, -4.19990718e-01f, -2.11522847e-01f, 4.73237261e-02f, -2.46300444e-01f, 1.81443453e-01f, 1.15985468e-01f, -7.49888346e-02f,
  -2.06242755e-01f, 2.98308760e-01f, 8.79719257e-02f, 3.66875321e-01f, 9.99555960e-02f, -1.20842032e-01f, 6.09556995e-02f, -3.14012259e-01f, 1.90531582e-01f, 1.74704276e-03f,
  -2.94802904e-01f, -7.48521611e-02f, -1.38903037e-01f, -1.58867061e-01f, 1.83645651e-01f, -9.17371083e-03f, 5.33930734e-02f, 1.46589950e-01f, -2.11856633e-01f, 1.01852491e-01f,
  -3.79270129e-02f, -5.95534980e-01f, 3.21994014e-02f, -9.44806784e-02f, 4.35441405e-01f, 4.95368034e-01f, -2.56406404e-02f, -7.10029155e-02f, 1.10403053e-01f, 1.36979371e-01f,
  8.26805551e-03f, 5.58264330e-02f, 1.61754444e-01f, -2.23300934e-01f, -1.37556091e-01f, 1.81975663e-01f, 2.15082899e-01f, -1.06868744e-01f, 5.12418628e-01f, 4.59491044e-01f,
  4.11258429e-01f, 2.81972945e-01f, 2.88949668e-01f, -6.98785335e-02f, -2.09707007e-01f, 9.56591889e-02f, 1.90060064e-01f, -2.94092726e-02f, 2.93004662e-01f, -1.51930124e-01f,
  1.06997386e-01f, -1.53080136e-01f, -6.87629357e-02f, -2.54280865e-01f, 2.69792844e-02f, -4.50102128e-02f, 1.88743532e-01f, -1.89713359e-01f, 3.04906309e-01f, 3.08632897e-03f,
  2.93927640e-01f, 3.14837769e-02f, 2.31174797e-01f, -6.70210242e-01f, 2.15198502e-01f, 1.03796229e-01f, -1.82520561e-02f, 3.52644116e-01f, -6.16224855e-03f, 1.30482092e-01f,
  -4.27627191e-02f, -1.88806981e-01f, -1.83725432e-01f, -9.61555317e-02f, -1.13532096e-01f, 2.96289735e-02f, -3.38041745e-02f, -9.25931241e-03f, 3.32332850e-01f, -2.01982543e-01f,
  5.29867923e-03f, 1.16022736e-01f, -2.12432250e-01f, -2.07919255e-03f, -8.00222605e-02f, -6.75696015e-01f, 1.45009323e-03f, -1.14897043e-01f, 2.08186239e-01f, -3.17635715e-01f,
  1.71745911e-01f, 1.87041573e-02f, -4.69942093e-02f, 2.36525714e-01f, -8.39106739e-02f, 2.48856157e-01f, -1.59646899e-01f, 4.19705480e-01f, -8.36658180e-02f, -7.33030885e-02f,
  1.24985561e-01f, 4.81283158e-01f, -4.99619395e-02f, -2.88532287e-01f, 3.68514359e-01f, -1.89223170e-01f, 5.24572790e-01f, 4.38553661e-01f, 4.11227852e-01f, 4.96960431e-01f,
  -6.25746906e-01f, -2.29087695e-01f, -1.36486758e-02f, 6.64206073e-02f, 2.82973051e-01f, -1.71007618e-01f, -2.02475965e-01f, 3.46970148e-02f, -1.20926080e-02f, -3.63627762e-01f,
  -6.84720159e-01f, 1.07636198e-01f, -2.45192081e-01f, 1.75197516e-02f, -1.94062755e-01f, -2.69547701e-01f, 2.52365768e-01f, 1.76969349e-01f, -2.56957501e-01f, 3.19686562e-01f,
  2.33883802e-02f, 1.20935671e-01f, -4.13086899e-02f, -2.34751984e-01f, -2.26110276e-02f, -1.16380621e-02f, 4.72439341e-02f, -6.25067726e-02f, 4.53709662e-02f, 6.89729974e-02f,
  -9.08878595e-02f, -2.92669684e-01f, 4.18597274e-02f, 1.08669419e-02f, 3.05221546e-02f, -3.41512412e-02f, -7.80205568e-03f, 8.43367428e-02f, 6.26426712e-02f, 4.05472487e-01f,
  -1.13961749e-01f, 2.48729512e-02f, 1.71813704e-02f, 1.25180155e-01f, -1.31776944e-01f, -1.43448591e-01f, 5.24778180e-02f, 1.87933687e-02f, 2.15258449e-02f, -1.45315677e-01f,
  2.07170695e-01f, 1.32222354e-01f, -1.08520679e-01f, 5.61509430e-02f, -1.04959540e-01f, 1.74659550e-01f, -6.00130251e-03f, -1.55320227e-01f, -1.37516633e-01f, -8.44673887e-02f,
  6.72096536e-02f, 2.83134021e-02f, -1.31454006e-01f, 3.30405176e-01f, -9.17829201e-02f, 4.67585325e-02f, 1.15756383e-02f, -2.22736806e-01f, -2.61688650e-01f, -1.76065236e-01f,
  2.42604658e-01f, -4.93241251e-02f, 2.65775800e-01f, -2.25874156e-01f, -1.33633763e-01f, -6.73227385e-02f, -8.11078325e-02f, 8.86121318e-02f, -1.41371042e-01f, 1.37917653e-01f,
  -1.17738314e-01f, 3.98125052e-01f, 1.83242172e-01f, 1.86819583e-01f, 9.57472548e-02f, -2.23373950e-01f, -1.26243398e-01f, 1.61462978e-01f, -3.65032591e-02f, -1.25647813e-01f,
  -7.51046091e-02f, 4.17503938e-02f, 1.92047060e-01f, 4.01662230e-01f, 1.65619254e-01f, 8.22392404e-02f, -2.17991114e-01f, -6.12740554e-02f, 9.20146406e-02f, 2.71713194e-02f,
  8.70452598e-02f, -2.53497194e-02f, -1.11563936e-01f, 4.30227816e-02f, 2.07930654e-01f, -4.91402261e-02f, -2.29175434e-01f, 1.46995425e-01f, 2.61295080e-01f, 6.19433373e-02f,
  -7.94028491e-02f, -1.36277363e-01f, -1.18173987e-01f, 8.72727484e-02f, -2.13234156e-01f, 1.21697433e-01f, 8.34234878e-02f, -1.14158273e-01f, -1.43995211e-01f, -1.09065056e-01f,
  -2.03385181e-03f, -1.70852423e-01f, -7.33332634e-02f, -4.69745174e-02f, 1.12158597e-01f, -2.01075882e-01f, -3.41016978e-01f, 2.15481758e-01f, 9.79883522e-02f, 2.11767718e-01f,
  -4.43658903e-02f, -3.85320634e-01f, 2.62683451e-01f, 9.51664597e-02f, 2.21053749e-01f, 1.11726403e-01f, 4.92720634e-01f, -2.45576501e-01f, 8.37234780e-03f, -5.53921044e-01f,
  -2.36266982e-02f, 5.80548570e-02f, -8.75756070e-02f, -1.42300963e-01f, -1.69338390e-01f, 3.66411120e-01f, -3.89698803e-01f, 1.23828880e-01f, -1.12223644e-02f, -2.80499049e-02f,
  -1.10677406e-01f, -1.22266345e-01f, -1.00628957e-01f, -3.24904501e-01f, 3.16910297e-01f, 3.02649010e-02f, 1.75146297e-01f, -1.41438723e-01f, 9.06348750e-02f, -8.73875096e-02f,
  6.49382547e-02f, -1.32509798e-01f, 1.56940624e-01f, -1.61060005e-01f, -1.36761606e-01f, 2.12304860e-01f, 3.05404477e-02f, 2.64348716e-01f, 2.36941054e-02f, 3.79837700e-03f,
  2.17022777e-01f, 4.75120097e-01f, -3.84994000e-02f, -1.97906271e-02f, 7.49739558e-02f, 1.24875173e-01f, 4.57642712e-02f, -5.53263612e-02f, 1.11100078e-01f, -2.43325904e-01f,
  1.45920724e-01f, -2.92217769e-02f, 2.46368840e-01f, -4.24150303e-02f, 3.19927037e-01f, 1.55405924e-01f, -7.36961588e-02f, 2.64129996e-01f, 2.95796096e-01f, -1.71977788e-01f,
  -1.20160319e-01f, 4.64210689e-01f, -1.42836183e-01f, -1.85800821e-01f, 2.85683088e-02f, -3.28288406e-01f, -4.39503975e-02f, -1.26024097e-01f, -3.13377827e-01f, 1.70791447e-01f,
  -4.07566309e-01f, -1.01676047e-01f, -1.25332803e-01f, 9.71853957e-02f, -5.63957989e-02f, -1.48943011e-02f, -5.30216321e-02f, 9.68064666e-02f, 1.73965603e-01f, 7.51905888e-03f,
  1.21866032e-01f, 4.35155243e-01f, -2.32427698e-02f, 1.48316044e-02f, -1.44708276e-01f, -2.63423890e-01f, 9.44978148e-02f, 4.10392106e-01f, 1.65240809e-01f, 5.84025010e-02f,
  -1.87235251e-01f, -4.63830084e-02f, 2.16687564e-03f, -7.63254911e-02f, 2.70983726e-01f, -9.22477245e-02f, -9.13484544e-02f, -8.29737633e-02f, -2.15271682e-01f, -1.68156624e-01f,
  -9.97955054e-02f, -5.96036389e-03f, -1.15937211e-01f, -1.11166842e-01f, 3.00829709e-01f, 1.33350585e-02f, -1.20819315e-01f, 7.26114064e-02f, -3.01511912e-03f, -1.00830376e-01f,
  -1.12618797e-01f, 1.11810549e-03f, 5.77591136e-02f, 1.86566368e-01f, 3.85952592e-01f, -1.32533818e-01f, 7.56227523e-02f, -1.18792795e-01f, 3.50201994e-01f, -4.28122170e-02f,
  2.24952966e-01f, -1.47109181e-01f, -2.02790335e-01f, 2.86907226e-01f, 3.32623452e-01f, -4.23634529e-01f, 3.34319800e-01f, -8.91419053e-02f, -4.49061878e-02f, 1.99493036e-01f,
  5.64598627e-02f, -3.99070561e-01f, -9.99335200e-02f, 1.95589855e-01f, -2.51968920e-01f, 3.11405540e-01f, 5.17341793e-01f, 3.59965026e-01f, -1.01461843e-01f, -2.32282300e-02f,
  -1.41836464e-01f, 9.71265230e-03f, -7.04220608e-02f, 2.16676742e-01f, 1.67664178e-02f, -4.23645321e-03f, -1.33728281e-01f, -1.85398504e-01f, -1.56645104e-02f, -7.88116157e-02f,
  8.69580880e-02f, -1.34230524e-01f, -5.27703390e-02f, -1.00637510e-01f, 3.09736133e-01f, -5.87349758e-02f, -6.57606730e-03f, -5.73771866e-03f, -2.23565251e-01f, 2.01586738e-01f,
  -3.28039527e-02f, -6.40533492e-02f, 7.40053877e-02f, 1.97878048e-01f, -4.46968526e-02f, 6.72504961e-01f, -1.23180375e-01f, 2.36313045e-01f, -2.85048693e-01f, -3.86512071e-01f,
  -1.22917801e-01f, -1.57684401e-01f, 3.40174437e-02f, -1.32029265e-01f, 8.55192691e-02f, -1.73432119e-02f, 1.41087577e-01f, -1.24661796e-01f, -1.73449621e-01f, -7.91796017e-03f,
  -1.42163575e-01f, -4.22895104e-01f, -1.15024716e-01f, 9.81245711e-02f, -1.95071384e-01f, 8.23893547e-02f, -3.22471142e-01f, -4.59819585e-01f, -4.27471578e-01f, -3.53131980e-01f,
  2.49164134e-01f, 2.08111390e-01f, -1.13181069e-01f, 1.54452384e-01f, -1.85520411e-01f, 2.73703188e-01f, 2.65986919e-01f, -1.02794901e-01f, 5.33376113e-02f, 1.06265068e-01f,
  7.70413280e-02f, -8.87930170e-02f, -1.36284217e-01f, -1.24951698e-01f, 2.22487777e-01f, 3.53386626e-02f, -6.45832047e-02f, 3.63094546e-02f, 1.98418703e-02f, -5.20565808e-01f,
  1.11984745e-01f, -1.27090260e-01f, 2.27533787e-01f, 4.06074226e-01f, -1.12864017e-01f, -2.22577780e-01f, -2.61731833e-01f, -5.45687564e-02f, 1.03963546e-01f, -3.09885174e-01f,
  -1.02902584e-01f, 3.57257873e-01f, -1.93456665e-01f, 2.35258713e-01f, 1.23462893e-01f, 4.84848581e-03f, 2.38045990e-01f, 1.17088936e-01f, -6.14169836e-02f, 2.19357297e-01f,
  -8.48036557e-02f, 7.74871781e-02f, -1.21918626e-01f, -9.69272777e-02f, -1.30988985e-01f, 2.14460567e-02f, -4.02579904e-02f, 8.81999582e-02f, -1.94490794e-02f, 1.01718642e-01f,
  1.20790459e-01f, -3.11242849e-01f, -3.42380255e-01f, 7.17138052e-02f, -3.34355272e-02f, 3.17153335e-02f, -8.79815146e-02f, -1.04711510e-01f, -1.70451805e-01f, -1.06448896e-01f,
  -4.09605622e-01f, 2.58951962e-01f, 3.91452722e-02f, -5.04265189e-01f, 4.46105599e-01f, -2.32946891e-02f, 8.30428004e-02f, -3.39523703e-02f, -1.45954087e-01f, 5.03936887e-01f,
  -1.38370171e-01f, -2.55667686e-01f, -3.02059557e-02f, 1.32583752e-01f, 6.14433646e-01f, 2.34114736e-01f, 5.03674448e-01f, 1.18515715e-01f, 1.59346223e-01f, 1.96148545e-01f,
  -2.07496658e-01f, -3.08492512e-01f, 2.58290142e-01f, -5.07792950e-01f, 2.10285746e-02f, -5.26170060e-02f, -1.28527820e-01f, -1.20863304e-01f, 1.34056985e-01f, 6.59401238e-01f,
  -1.48822278e-01f, 8.80686343e-02f, -2.59564817e-01f, -2.14540347e-01f, 1.19472682e-01f, 1.93174675e-01f, 9.73109796e-04f, -1.35166161e-02f, 5.19089215e-03f, -4.83054891e-02f,
  -6.08204976e-02f, -2.52923787e-01f, -2.00766604e-02f, -5.29802501e-01f, -1.17235705e-01f, -2.78447568e-01f, -1.82769924e-01f, -1.09537400e-01f, -1.14837214e-01f, 2.88276672e-01f,
  -6.18206970e-02f, 1.18413806e-01f, -1.25507470e-02f, 1.64224431e-01f, -1.01771764e-02f, 2.57350922e-01f, 5.35118058e-02f, 4.84601874e-03f, -9.38364491e-03f, -6.89704940e-02f,
  1.34835094e-01f, -3.41117471e-01f, -2.25931242e-01f, -5.73892295e-02f, 4.16169435e-01f, 1.31064221e-01f, 3.78059149e-01f, 1.88245878e-01f, -2.59495884e-01f, 1.30634597e-02f,
  -1.43291056e-01f, 2.45808467e-01f, 1.95979431e-01f, -1.49367228e-01f, 2.33203307e-01f, 2.30388731e-01f, -2.62768298e-01f, 2.95093715e-01f, -3.43507081e-02f, 3.00802380e-01f,
  -6.47539496e-02f, 1.62141174e-02f, -2.74141848e-01f, -2.02323884e-01f, -3.26750334e-03f, 3.96384001e-02f, -5.06388128e-01f, -2.42214292e-01f, -1.54171707e-02f, 6.46898011e-03f,
  3.48508447e-01f, 1.67036831e-01f, -1.53567363e-02f, -6.47869408e-01f, 5.75801246e-02f, -1.31044716e-01f, 1.32692382e-01f, -1.44811392e-01f, 4.51577343e-02f, 1.36163339e-01f,
  -1.80798173e-01f, 1.83962032e-01f, 2.22491995e-02f, -1.43050075e-01f, 2.90527880e-01f, 3.72095108e-01f, 4.15669866e-02f, 4.36344624e-01f, 5.40417507e-02f, 3.95640105e-01f,
  1.63230151e-02f, 3.04730564e-01f, -1.87649354e-01f, 7.17314407e-02f, -4.71898466e-02f, -8.37000087e-03f, -9.18452367e-02f, -8.54718238e-02f, 1.13691716e-02f, -5.86126029e-01f,
  2.72546351e-01f, -7.67454207e-02f, -1.16356961e-01f, 1.70779020e-01f, -1.90253645e-01f, 9.36501473e-02f, -8.34335610e-02f, -1.07080629e-02f, -2.45705098e-01f, -1.23467602e-04f,
  3.92569333e-01f, -1.58621185e-02f, -1.56738505e-01f, 6.92748502e-02f, -3.85777168e-02f, 2.10570879e-02f, -1.58382654e-01f, 2.19575077e-01f, -1.47303805e-01f, -9.79993567e-02f,
  -3.22576433e-01f, -3.72693777e-01f, -4.46999013e-01f, 4.54083681e-01f, 6.91514686e-02f, 2.45659202e-01f, -1.98230952e-01f, 1.28518641e-01f, -2.42141172e-01f, -1.56489357e-01f,
  4.33189869e-01f, 1.44878238e-01f, -2.22034097e-01f, -1.81891561e-01f, -6.98728189e-02f, 9.11542550e-02f, 5.91136515e-02f, 5.26242077e-01f, -1.39953762e-01f, -3.63548682e-03f,
  -2.00639352e-01f, 4.22630280e-01f, -9.48990881e-03f, -1.47997931e-01f, -1.33282453e-01f, -2.62026310e-01f, 5.18435352e-02f, 1.56105354e-01f, -3.42637599e-02f, -1.31815627e-01f,
  4.61077504e-02f, -2.89864868e-01f, 1.58036113e-01f, -3.17787647e-01f, -3.08622628e-01f, -8.93409699e-02f, 1.52801976e-01f, -1.30950838e-01f, -3.36497352e-02f, -9.81949046e-02f,
  -4.52951118e-02f, 1.04211703e-01f, -1.17871448e-01f, 3.76120806e-01f, -8.44318792e-02f, 3.86348031e-02f, 6.06295653e-02f, 8.15945119e-02f, -1.86344489e-01f, 1.23276085e-01f,
  1.40896253e-02f, -7.90658221e-02f, -2.33818725e-01f, 2.36345887e-01f, -4.12708633e-02f, -1.86088249e-01f, 1.89901114e-01f, -7.73069113e-02f, -1.36064673e-02f, 4.65618312e-01f,
  -1.12524368e-01f, 8.52110907e-02f, -2.83013046e-01f, 2.65242338e-01f, 2.00269759e-01f, 3.12970906e-01f, 2.17572048e-01f, -1.17563218e-01f, 9.01897326e-02f, 7.30163455e-02f,
  -1.09261632e-01f, -5.33326156e-02f, -2.21303716e-01f, 1.25568628e-01f, 3.66034031e-01f, -3.06507558e-01f, -1.81835383e-01f, -2.41823405e-01f, -1.92194939e-01f, -6.97219744e-02f,
  1.81386590e-01f, 6.39842570e-01f, -8.86163414e-02f, -7.76715055e-02f, 1.03192054e-01f, -5.15882671e-02f, -2.75598336e-02f, -8.08276422e-03f, -3.03636134e-01f, 3.56280476e-01f,
  1.15286507e-01f, -1.53389826e-01f, 1.30155355e-01f, -2.15787590e-01f, -5.54894954e-02f, 2.98542809e-02f, 9.58656222e-02f, 7.53306970e-02f, -2.72913426e-01f, -2.90768266e-01f,
  3.13573778e-02f, 1.41136751e-01f, -1.65623836e-02f, -1.61463186e-01f, -9.58378389e-02f, -1.66890234e-01f, -1.76416770e-01f, 1.68141440e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -8.56379271e-02f, 3.32469910e-01f, 2.51637120e-02f, -1.35446489e-01f, -8.13351125e-02f, 9.33336094e-02f, -5.85720390e-02f, -3.30642685e-02f, -1.50532052e-01f, 1.34653086e-02f,
  -7.11159855e-02f, -8.80357325e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    