/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.76288438e-01f, -2.65655190e-01f, -1.21106878e-01f, -1.72992870e-01f, -1.91601217e-01f, 1.62931494e-02f, 6.95240647e-02f, -2.19718665e-01f, 4.15432341e-02f, -2.74218246e-02f,
  -7.43990019e-02f, 1.06129475e-01f, 1.06043436e-01f, 6.72803912e-03f, 2.40823805e-01f, 2.54182816e-01f, -2.13638470e-01f, -7.95724019e-02f, 4.17534038e-02f, -1.94175854e-01f,
  -1.28212616e-01f, -3.96559127e-02f, 2.76286863e-02f, -9.88501310e-02f, -1.72823966e-01f, -1.07159398e-01f, -1.08631477e-02f, 9.41347331e-02f, -1.16137201e-02f, 1.19509175e-01f,
  -2.62341853e-02f, -8.79582092e-02f, 4.36753482e-02f, 2.84747519e-02f, -1.46116167e-01f, -4.08459827e-02f, -2.20646411e-02f, 7.61314332e-02f, 4.99998741e-02f, -7.37932045e-04f,
  2.42377557e-02f, -4.71640676e-02f, 3.04576810e-02f, 7.80846998e-02f, 1.30878324e-02f, -4.65062298e-02f, -3.88308316e-02f, -1.76630318e-02f, -2.73093320e-02f, 4.08242196e-02f,
  -1.87617075e-02f, 1.21240327e-02f, -9.77923423e-02f, 3.55754308e-02f, -3.59748416e-02f, -6.10406091e-03f, 2.62346584e-02f, -2.37974375e-02f, 1.77816227e-02f, -2.74215452e-02f,
  -1.81505457e-02f, -9.46723484e-03f, 1.29398545e-02f, 9.25501622e-03f, -4.31413613e-02f, -3.42287198e-02f, 1.58502571e-02f, -1.21278679e-02f, 3.31943557e-02f, -4.50249389e-02f,
  -1.04289548e-02f, -3.96592729e-02f, 1.00290058e-02f, 4.46255654e-02f, -1.55104958e-02f, 1.65983066e-02f, -3.51500628e-03f, -2.37610061e-02f, -6.46165386e-02f, -6.59342331e-04f,
  5.99007159e-02f, -3.91841382e-02f, -2.59307027e-02f, -3.13503891e-02f, 2.17639096e-02f, 2.14098468e-02f, -3.79287861e-02f, -5.13152368e-02f, 2.85110194e-02f, -1.87442955e-02f,
  -6.35840222e-02f, -1.37399673e-01f, 2.84616891e-02f, -1.84909031e-02f, 9.40287635e-02f, 4.31025289e-02f, 1.01741320e-02f, -5.24754710e-02f, 1.84573662e-02f, -3.59293669e-02f,
  -6.19419515e-02f, 1.57562550e-02f, -5.08515425e-02f, -1.35823824e-02f, -1.04030734e-02f, -6.12039566e-02f, 2.03883387e-02f, 8.89569893e-03f, -1.75287426e-02f, -9.01984610e-03f,
  1.89494025e-02f, 4.04575989e-02f, 4.63752933e-02f, -7.10063279e-02f, -3.49442624e-02f, 1.15920103e-03f, -2.62886789e-02f, 2.12551150e-02f, -7.81509839e-03f, -2.33405903e-02f,
  -4.05949444e-01f, -1.61314100e-01f, 2.48836540e-02f, -2.67695814e-01f, 2.80684233e-02f, -3.18774551e-01f, -2.47528121e-01f, -4.32908833e-02f, -3.87107618e-02f, -1.19865045e-01f,
  -1.11736402e-01f, -2.49149762e-02f, 8.68025329e-03f, -1.76904872e-01f, -7.46988412e-03f, 4.71452326e-02f, -1.62054375e-01f, -1.04773350e-01f, 5.23058660e-02f, -1.58683240e-01f,
  1.70788486e-02f, -1.80069312e-01f, 2.49893740e-02f, 3.78791839e-02f, -6.01244606e-02f, 9.30901337e-03f, 9.94405057e-03f, 4.54500318e-02f, -1.34224787e-01f, -5.34368120e-02f,
  -7.00452477e-02f, 1.35713473e-01f, 5.37168570e-02f, 3.95924449e-02f, -5.17687947e-02f, -3.82425934e-02f, -2.30897795e-02f, 2.77139582e-02f, 2.44859681e-02f, -2.36580763e-02f,
  -7.17788562e-03f, 2.07195655e-02f, -5.34278294e-03f, 1.60389170e-02f, -6.28686743e-03f, 3.25588435e-02f, 5.22736460e-02f, -3.35783586e-02f, -6.07890775e-03f, 3.05595286e-02f,
  5.35688587e-02f, 6.01924583e-03f, -4.77190217e-04f, -3.79496999e-02f, 6.78698123e-02f, -3.00984401e-02f, 6.89845532e-03f, 2.51050349e-02f, -4.72167246e-02f, -4.54822183e-02f,
  6.02884926e-02f, -8.86153616e-03f, -2.62537245e-02f, 1.54216802e-02f, -2.40330752e-02f, -1.74240873e-03f, -3.16881202e-02f, -2.40132902e-02f, -2.60563596e-04f, -2.29981821e-02f,
  -1.75109804e-02f, -1.44304382e-02f, -2.91232276e-03f, 8.47418047e-03f, -6.38761818e-02f, -1.45796151e-03f, 1.74625516e-02f, -6.12108372e-02f, -1.95646975e-02f, 2.21868465e-03f,
  8.00486654e-03f, -4.63941433e-02f, 4.40811273e-03f, -1.03128850e-02f, -3.46087627e-02f, 1.58704706e-02f, -3.58285792e-02f, -4.08050306e-02f, 8.19018204e-03f, -4.22973149e-02f,
  -5.01057267e-01f, -2.29195312e-01f, -6.23707706e-03f, 2.17000209e-02f, -1.84504762e-02f, 1.76474694e-02f, -1.09004145e-02f, 1.78572889e-02f, -2.29419097e-02f, -1.45785073e-02f,
  -2.13415045e-02f, -1.43995183e-02f, 1.33740045e-02f, -1.25833005e-02f, -1.34090837e-02f, -5.83357774e-02f, -4.77658138e-02f, -2.69955248e-02f, -6.79435134e-02f, -5.10684475e-02f,
  -4.47201058e-02f, 2.50250623e-02f, 1.12486072e-02f, 3.20971459e-02f, -2.07356680e-02f, -2.27538603e-05f, -1.77584998e-02f, 9.92693473e-03f, 2.75131203e-02f, 8.31919815e-03f,
  1.29606292e-01f, -7.31328577e-02f, 3.77737761e-01f, 3.08104515e-01f, 2.44818851e-02f, -2.48676866e-01f, -9.54924673e-02f, 7.70637840e-02f, 1.97762679e-02f, -2.52256870e-01f,
  -1.72793362e-02f, 1.25948302e-02f, -2.06742838e-01f, 2.01688241e-02f, 2.51747489e-01f, -2.08405226e-01f, 3.99751728e-03f, -6.96829855e-02f, 1.55154327e-02f, 3.97663936e-02f,
  9.58153009e-02f, -7.66790882e-02f, 1.71779975e-01f, -1.29186762e-02f, 1.43749580e-01f, 1.38797298e-01f, 8.80502313e-02f, 7.77328759e-02f, 1.89936578e-01f, 4.83931787e-02f,
  7.73845613e-02f, 8.77785787e-04f, 1.40983343e-01f, -4.46270220e-02f, 1.52129098e-03f, -2.40651313e-02f, 1.33478194e-02f, 2.83387508e-02f, 7.25516230e-02f, 1.51562700e-02f,
  -9.35135409e-03f, 2.26396620e-02f, 1.50147136e-02f, 5.89150004e-02f, -1.71417498e-03f, 3.94478329e-02f, 2.76879687e-02f, 2.42927074e-02f, -1.92495435e-02f, -5.27559258e-02f,
  3.62620056e-02f, 2.62264684e-02f, 4.71798405e-02f, -2.69421730e-02f, 6.05132170e-02f, 8.32596142e-03f, -2.66600735e-02f, 4.00412828e-02f, -2.72357501e-02f, 2.12368486e-03f,
  -8.17028731e-02f, -1.79498289e-02f, -1.95677020e-02f, 3.97967501e-03f, -2.22787354e-02f, 1.28047913e-02f, 1.17439181e-02f, -2.95964833e-02f, 2.94140279e-02f, -3.78224999e-02f,
  2.33909898e-02f, 1.38382362e-02f, -1.83472093e-02f, 6.39918679e-03f, -1.00418152e-02f, -1.02671748e-02f, 2.85101775e-02f, -1.80954803e-02f, 8.91278032e-03f, 3.86951938e-02f,
  1.24251917e-02f, 2.59334296e-02f, -6.10277522e-04f, -8.30348115e-03f, -6.63179858e-03f, 3.71040925e-02f, 9.18806624e-03f, -4.99457214e-03f, 1.82854459e-02f, -1.46007501e-02f,
  -1.51923195e-01f, -1.33108214e-01f, -3.06345057e-02f, 1.20202703e-02f, -2.78563444e-02f, -9.56253894e-03f, 1.20850105e-03f, -2.81329714e-02f, 5.91186527e-03f, -5.40386923e-02f,
  -6.49735937e-03f, 1.50158415e-02f, -5.31263575e-02f, 5.21861669e-03f, 4.46935073e-02f, -2.68856511e-02f, -1.60441417e-02f, 1.66574661e-02f, 4.32344228e-02f, 1.46711851e-02f,
  1.06854374e-02f, -7.82090425e-02f, 8.06073844e-03f, -8.81514803e-04f, -1.43827135e-02f, -1.10807531e-02f, 4.18344792e-03f, -4.44468632e-02f, 2.91266032e-02f, -7.17824325e-03f,
  4.43223938e-02f, 2.27787271e-02f, -2.57941276e-01f, 1.33371294e-01f, -1.03875384e-01f, -8.46130103e-02f, -7.51091167e-02f, 5.74444160e-02f, -2.94666439e-01f, 2.10254058e-01f,
  2.66650189e-02f, 1.34100735e-01f, -2.28740752e-01f, 4.34011251e-01f, -1.54453829e-01f, -1.35369152e-01f, 1.86513036e-01f, 1.98557362e-01f, -9.07887891e-02f, 9.29582492e-02f,
  9.21518877e-02f, 2.77722478e-01f, 7.06655979e-02f, 6.37258962e-02f, 1.57649234e-01f, -1.86217725e-02f, 2.88770050e-01f, -1.51289985e-01f, 2.37137392e-01f, 4.04918604e-02f,
  -9.20387451e-03f, 1.83858238e-02f, 9.87634528e-03f, 2.28742454e-02f, -3.97361219e-02f, 1.96341844e-03f, -3.89125459e-02f, -3.23189311e-02f, -1.57722253e-02f, -2.22138204e-02f,
  -1.49626667e-02f, -4.38348530e-03f, 3.49237048e-03f, 7.99630489e-03f, -5.99839278e-02f, -1.26860738e-02f, -1.81123875e-02f, -2.86364667e-02f, 5.08832978e-03f, -5.73393106e-02f,
  -6.59428462e-02f, 9.24982410e-03f, -2.63207667e-02f, 2.69034393e-02f, -2.78976858e-02f, -3.87592614e-03f, 1.95095763e-02f, -2.57931240e-02f, 3.07831634e-03f, -7.73597434e-02f,
  6.56880112e-03f, -6.30730018e-02f, -2.39539202e-02f, 4.70763221e-02f, -1.43531663e-02f, 1.14001250e-02f, -3.89504386e-03f, -1.24745118e-02f, -2.39022635e-02f, 1.43440934e-02f,
  1.31436270e-02f, 1.77021902e-02f, 1.54025387e-02f, 6.09269505e-03f, 3.10762040e-03f, 1.52151864e-02f, 5.25344815e-03f, -2.75968071e-02f, 3.12393811e-03f, -2.43058149e-02f,
  -3.55387782e-03f, -4.99993078e-02f, 1.36020444e-02f, -3.00733745e-03f, -4.82589267e-02f, -2.69307736e-02f, 3.62260081e-02f, -4.02902672e-03f, -4.67074215e-02f, -2.96300333e-02f,
  4.95217182e-02f, -7.11856708e-02f, 4.40605506e-02f, 6.34894520e-02f, -1.01605766e-02f, -5.10531943e-04f, 2.52884277e-03f, 6.65619150e-02f, -5.03557064e-02f, 3.85278352e-02f,
  5.66962510e-02f, 6.03432432e-02f, 1.02026872e-02f, 1.47661921e-02f, -5.97562734e-03f, -1.68509372e-02f, -1.74744632e-02f, 6.61798716e-02f, 1.14579992e-02f, 2.68655363e-02f,
  4.51577380e-02f, -1.26992455e-02f, 4.16622050e-02f, 4.30637859e-02f, 9.26444009e-02f, 2.83450838e-02f, -1.73856039e-02f, -9.74458642e-03f, -7.13359751e-03f, 3.10635362e-02f,
  -3.53879809e-01f, 6.89778745e-01f, -1.10512614e-01f, 2.34496057e-01f, -2.68072635e-01f, -7.87937716e-02f, -2.55378455e-01f, 1.16458543e-01f, 3.44476327e-02f, 1.41098946e-01f,
  -9.40038785e-02f, 8.40701610e-02f, 4.36073579e-02f, 1.15145467e-01f, 1.19503541e-02f, 2.38763005e-01f, 4.00408581e-02f, -4.57145236e-02f, 8.02420229e-02f, 1.67203846e-03f,
  -3.05491989e-03f, 4.63006198e-02f, -4.58983593e-02f, 1.01115562e-01f, -1.12416111e-01f, -8.85739997e-02f, -1.19808249e-01f, -4.49045375e-02f, -4.73834798e-02f, 1.05442844e-01f,
  -1.17804676e-01f, -5.04836105e-02f, -8.11595097e-02f, -2.92636473e-02f, -9.14483070e-02f, -9.01593566e-02f, -2.23166049e-02f, -6.67079836e-02f, -8.81038010e-02f, 7.47138343e-04f,
  -2.28163917e-02f, -3.83664332e-02f, 7.53881559e-02f, 8.20918102e-03f, -5.51647134e-02f, 1.33631444e-02f, 1.47307767e-02f, -7.34645547e-03f, 2.21536756e-02f, -2.49965489e-02f,
  2.75111813e-02f, 2.17002500e-02f, -5.15994094e-02f, 9.15329717e-03f, -2.64881295e-03f, 1.55304000e-02f, 1.17519805e-02f, -2.37203501e-02f, 5.02101295e-02f, 2.75109131e-02f,
  -8.87849256e-02f, -2.42910665e-02f, 2.73623914e-02f, -4.58195135e-02f, 2.93807741e-02f, -6.73601311e-03f, 2.43781824e-02f, -1.54643999e-02f, 1.38295647e-02f, -9.82285826e-04f,
  -3.00450958e-02f, -4.24610730e-03f, -2.07496118e-02f, -3.85789089e-02f, -1.91304386e-02f, 1.22214621e-02f, -4.62373607e-02f, 4.89566289e-02f, -1.76609308e-02f, 2.28191819e-02f,
  1.80863887e-02f, 3.83800711e-03f, 2.23745536e-02f, -1.46179963e-02f, 5.53366775e-03f, 1.81343090e-02f, 6.59287255e-03f, 8.25188607e-02f, -6.39779717e-02f, -4.51597758e-03f,
  9.96669158e-02f, 2.17757896e-01f, -5.26207173e-03f, -4.83557917e-02f, 7.03012124e-02f, 6.65889587e-03f, -9.34534054e-03f, 5.30908592e-02f, 9.45272595e-02f, -1.50196031e-02f,
  -5.82247563e-02f, 2.40747835e-02f, -1.03420652e-01f, -4.12524268e-02f, 4.91626821e-02f, 4.51065451e-02f, 7.21219042e-03f, -2.93718139e-03f, 8.28738231e-03f, -6.40405063e-03f,
  -2.44499091e-02f, -9.47514549e-02f, 9.28238966e-03f, -9.02763940e-03f, -2.81163082e-02f, -5.66661172e-02f, -3.99032980e-02f, -4.12365742e-04f, -1.22417258e-02f, 6.99618133e-03f,
  2.43648261e-01f, 1.66123286e-01f, 1.60143569e-01f, 1.51476175e-01f, -1.61216468e-01f, -5.51516175e-01f, -1.52910799e-01f, 8.87295976e-03f, 2.31321931e-01f, 7.51965344e-02f,
  -1.01053864e-01f, 2.12662399e-01f, 3.38647440e-02f, -1.68672666e-01f, -3.27677399e-01f, -8.48468766e-02f, -2.80276418e-01f, -7.19070388e-03f, 8.67204089e-03f, -2.95977332e-02f,
  -6.94659278e-02f, -2.95291185e-01f, -1.12567089e-01f, -2.34823361e-01f, -1.52115941e-01f, 3.26822959e-02f, 6.98410440e-03f, -2.40870882e-02f, -4.37463261e-02f, -8.63298308e-03f,
  -1.23040788e-01f, 2.51249313e-01f, 6.74036145e-02f, 5.06599210e-02f, -4.09572646e-02f, -1.18630212e-02f, 2.80190259e-03f, -2.19103135e-03f, -5.63129550e-03f, -1.52644664e-02f,
  4.01570350e-02f, -5.30129783e-02f, -1.31476568e-02f, 5.17741963e-02f, -5.03214672e-02f, 4.61652242e-02f, -1.23308906e-02f, 3.76925543e-02f, 6.46736696e-02f, -3.95293348e-02f,
  -2.10215766e-02f, 2.47379988e-02f, -1.24142254e-02f, 2.92282980e-02f, -1.80661101e-02f, 7.61976019e-02f, 5.55879204e-03f, 2.01078760e-03f, 2.81209894e-03f, 3.17175686e-02f,
  -3.27189341e-02f, -2.56223865e-02f, -1.19214449e-02f, -1.07702920e-02f, 8.56755022e-03f, -9.97864362e-03f, -6.34536371e-02f, -2.09120885e-02f, 4.25921306e-02f, -1.24988053e-02f,
  6.60451269e-03f, 2.52643283e-02f, -2.00862139e-02f, -4.49288152e-02f, 2.88542040e-04f, -3.05662351e-03f, -6.84061088e-03f, 3.27774021e-03f, -1.35021443e-02f, -6.38289824e-02f,
  2.21003145e-02f, -4.61442843e-02f, -1.98591519e-02f, -4.26370166e-02f, -4.00109552e-02f, 1.88584123e-02f, 3.63668939e-03f, 1.21452734e-02f, 3.52613665e-02f, -8.07213336e-02f,
  -3.78868766e-02f, -3.71503308e-02f, -2.99886279e-02f, -2.24313568e-02f, 3.81172821e-02f, -3.23722772e-02f, -2.28700880e-02f, -7.33932294e-03f, -3.33797373e-02f, -3.46005596e-02f,
  -2.90758852e-02f, 4.13324982e-02f, -4.64004464e-02f, -5.06917685e-02f, 3.74948196e-02f, -5.75083820e-03f, 3.85290422e-02f, -1.95518583e-02f, -5.81814647e-02f, 1.18634058e-02f,
  9.49465390e-03f, -3.35129723e-02f, 2.63647195e-02f, -3.11723780e-02f, -3.30764167e-02f, -5.05560972e-02f, 3.41449752e-02f, 6.13943003e-02f, -7.66274929e-02f, 3.02956265e-04f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.84020412e-02f, 3.28739047e-01f, 3.05880696e-01f, -1.26584440e-01f, 5.12297601e-02f, 1.06301069e-01f, -1.05512254e-01f, 5.12299649e-02f, -2.01011132e-02f, -6.33752951e-03f,
  -1.49717480e-01f, 2.16700599e-01f, -2.17020422e-01f, 1.23733804e-01f, -3.14353615e-01f, -1.65565029e-01f, -1.07472390e-01f, -1.28917471e-01f, 4.00877092e-03f, 5.58909774e-03f,
  -6.16157539e-02f, -1.72554180e-01f, 5.09847775e-02f, 9.98231247e-02f, 1.22634880e-01f, 2.13409141e-01f, -2.40920141e-01f, -2.53851749e-02f, 8.34624171e-02f, 1.00448221e-01f,
  1.59933805e-01f, -9.60107595e-02f, 9.79449227e-02f, 2.79476717e-02f, -4.58072647e-02f, -4.54538167e-02f, -1.41366022e-02f, 1.11749675e-02f, 5.76473586e-02f, 2.32097283e-02f,
  6.13021711e-03f, -1.53318292e-03f, 5.95022999e-02f, 6.14762045e-02f, -1.31152906e-02f, 8.84616598e-02f, 1.34003192e-01f, 1.11249521e-01f, 6.94564357e-02f, 8.95265639e-02f,
  6.52643219e-02f, 6.84684142e-02f, -2.28882320e-02f, 1.03054019e-02f, -2.54678112e-02f, -1.57948211e-02f, 6.74821902e-03f, 1.55823138e-02f, 8.41750652e-02f, -2.01655496e-02f,
  -3.22287120e-02f, -5.32104522e-02f, 6.01524971e-02f, 6.10472038e-02f, 9.78263095e-04f, 2.84613110e-02f, -8.06971733e-03f, -1.08882627e-02f, 2.33295988e-02f, -3.26520056e-02f,
  2.31291186e-02f, -5.11055905e-03f, -7.49416742e-03f, -3.29156816e-02f, -4.33402061e-02f, 1.56263467e-02f, -4.48394231e-02f, 2.68784966e-02f, -5.04199602e-02f, 4.41058213e-03f,
  -9.17116273e-03f, -6.32011145e-02f, 1.46205407e-02f, -4.27390896e-02f, -2.73736590e-03f, 5.34881698e-03f, 1.12493271e-02f, 1.01909176e-01f, -4.93774116e-02f, -9.46080871e-03f,
  -2.13587865e-01f, -4.81271565e-01f, 1.22912964e-02f, 1.28127979e-02f, 5.13007529e-02f, 1.61437970e-02f, -4.39522602e-02f, 6.52084872e-02f, -8.65708292e-02f, -3.40514407e-02f,
  -4.19795886e-03f, -2.96778921e-02f, -8.35918561e-02f, -6.83902949e-02f, -3.20722163e-02f, -1.69624370e-02f, -1.30065054e-01f, -6.60169423e-02f, 1.54732540e-03f, -3.17012370e-02f,
  1.78706143e-02f, -9.48070362e-02f, -3.71849686e-02f, 1.65895931e-02f, -4.47194763e-02f, -4.76691313e-02f, -5.50571941e-02f, 3.69806699e-02f, 2.34234929e-02f, -3.30930762e-02f,
  1.67518780e-01f, 1.87392920e-01f, 1.10569507e-01f, 6.06560893e-02f, -1.45135567e-01f, -3.18556219e-01f, -2.22344697e-01f, -8.06289315e-02f, -1.40070245e-01f, 3.81672084e-02f,
  -9.93906036e-02f, 1.47623748e-01f, 2.16548033e-02f, -3.17558825e-01f, -2.48145521e-01f, -7.00236037e-02f, -1.10527821e-01f, -6.24118634e-02f, -4.47544493e-02f, 9.68312938e-03f,
  2.69774832e-02f, -2.50652671e-01f, 3.26604098e-02f, -7.21811652e-02f, -9.60960239e-03f, 2.46068716e-01f, 2.13407427e-01f, 5.33449203e-02f, 1.28383219e-01f, -4.46448326e-02f,
  -7.52045140e-02f, 3.69379157e-03f, 9.64528024e-02f, -4.72128876e-02f, -8.07643235e-02f, 1.13955297e-01f, 1.08034208e-01f, -6.16702922e-02f, -7.97519367e-03f, -1.99335930e-03f,
  2.55169217e-02f, 4.36012782e-02f, -2.14921534e-02f, -8.30655990e-05f, 5.65986708e-02f, -2.99000908e-02f, 1.10330313e-01f, 7.88967386e-02f, -3.88219841e-02f, 9.04136375e-02f,
  6.08841740e-02f, 1.39992358e-02f, 4.58527431e-02f, 2.78422944e-02f, 1.64220519e-02f, -4.66583669e-02f, -3.14709619e-02f, -3.80254313e-02f, 3.64322886e-02f, 6.10430501e-02f,
  7.92796910e-02f, 1.01541229e-01f, -2.57492810e-02f, 3.00691016e-02f, -3.85217741e-02f, -1.16513167e-02f, 6.58148378e-02f, 3.87751311e-02f, 4.08105515e-02f, -2.72001568e-02f,
  -5.82408346e-02f, 2.25078780e-03f, -2.92482190e-02f, 3.55170257e-02f, 3.71140726e-02f, -2.18114778e-02f, 3.18576507e-02f, -7.48237222e-03f, -2.16629207e-02f, -4.25429717e-02f,
  1.06520029e-02f, 3.33389901e-02f, -1.94737595e-02f, -1.70457959e-02f, -1.15416972e-02f, 1.00525736e-03f, 2.24784538e-02f, -3.77278565e-03f, 2.84979828e-02f, -2.81231776e-02f,
  2.75582895e-02f, 1.15646340e-01f, -5.77021986e-02f, -1.04136407e-01f, 7.09199309e-02f, 2.07194034e-02f, -1.43408673e-02f, -6.85516968e-02f, 1.09646782e-01f, -8.83156806e-02f,
  6.07989654e-02f, -3.76491435e-02f, 2.60318462e-02f, 8.71225819e-02f, -6.83115572e-02f, -7.09394142e-02f, 2.57901158e-02f, 2.54040025e-02f, 2.90795509e-03f, 5.60465977e-02f,
  1.12680860e-01f, 6.18523322e-02f, -2.11867038e-02f, -1.55671509e-02f, 3.67553942e-02f, 4.10726182e-02f, -1.40034668e-02f, 2.90534999e-02f, 4.18899246e-02f, -5.06718718e-02f,
  -3.72651726e-01f, -2.31626667e-02f, 2.57358283e-01f, -2.58710176e-01f, -2.82683223e-01f, -7.50342337e-03f, 2.39486694e-01f, -2.13051602e-01f, -4.04240429e-01f, 7.14516267e-02f,
  1.05368122e-01f, -2.00797573e-01f, 3.27275187e-01f, -2.46612653e-02f, 3.65407988e-02f, 1.77499756e-01f, 1.10910602e-01f, 5.89957833e-02f, -1.76912919e-01f, -2.44542107e-01f,
  -5.16783446e-02f, -1.75115749e-01f, 3.24681014e-01f, -3.01938325e-01f, -1.90267712e-02f, -1.81356683e-01f, 1.47414386e-01f, -1.26331393e-02f, -4.10207920e-02f, 8.25847536e-02f,
  -1.45442739e-01f, -1.67841971e-01f, -1.94559693e-02f, 4.60556149e-02f, 5.72423600e-02f, 1.21620312e-01f, 1.35994792e-01f, 9.25335288e-02f, -8.10736194e-02f, -4.29480188e-02f,
  1.49939973e-02f, -8.08099210e-02f, -1.90557644e-01f, -6.07544892e-02f, -7.45375752e-02f, -1.69924796e-02f, -2.26947255e-02f, 6.23056144e-02f, -4.65131290e-02f, 2.93887109e-02f,
  7.13208467e-02f, -1.61840077e-02f, 4.69393097e-02f, 2.58059110e-02f, 7.20010474e-02f, -1.87383257e-02f, 1.83755569e-02f, 4.89008017e-02f, -4.05840911e-02f, -5.52889891e-02f,
  7.76290223e-02f, -6.11860305e-02f, 2.65755765e-02f, -9.72061530e-02f, 8.67108405e-02f, 7.31191561e-02f, -1.41756106e-02f, 6.82370737e-02f, -4.54932265e-02f, 4.32593049e-03f,
  -4.39471118e-02f, 3.67829129e-02f, -2.53441501e-02f, 3.27062700e-03f, 2.88235340e-02f, -2.86792256e-02f, 6.36173189e-02f, -2.50654314e-02f, 5.84621653e-02f, -6.13141945e-03f,
  -1.73415430e-03f, 5.41115552e-02f, 5.76288328e-02f, 5.24328351e-02f, -6.68513700e-02f, 4.01938632e-02f, -3.82135399e-02f, -1.47069595e-03f, -1.17276870e-02f, 7.72918016e-02f,
  -4.68985975e-01f, -3.62950802e-01f, -1.05194137e-01f, -1.02436833e-01f, -4.87958491e-02f, -1.03774918e-02f, -6.48562238e-02f, -9.09593552e-02f, -6.77405149e-02f, -1.08887143e-02f,
  8.77560582e-04f, 7.12701604e-02f, -3.65706533e-02f, -9.02670994e-03f, 4.40079831e-02f, -9.75023862e-03f, -1.44184812e-03f, -3.61751169e-02f, -5.07791154e-02f, -5.79193309e-02f,
  -1.61585286e-02f, -4.64871526e-02f, 7.76788294e-02f, -1.79096181e-02f, 5.10832444e-02f, 1.43257929e-02f, -1.49765834e-01f, 6.46088319e-03f, -1.41234025e-02f, 3.53983901e-02f,
  -3.06718111e-01f, -5.11793643e-02f, -2.93841034e-01f, -3.63210201e-01f, 1.28350198e-01f, -1.71668202e-01f, -6.43891394e-02f, -3.49649526e-02f, -9.58427638e-02f, 2.31762916e-01f,
  1.26957834e-01f, -9.45843235e-02f, 1.82577223e-01f, -3.17233205e-01f, -4.00098085e-01f, -1.70713887e-01f, -3.41220677e-01f, -1.22704588e-01f, -5.80890179e-02f, -5.41653186e-02f,
  -9.37210619e-02f, -9.67299938e-02f, -2.26365894e-01f, 1.83531225e-01f, -1.00263268e-01f, 7.35878870e-02f, 1.73507839e-01f, 2.35793203e-01f, -5.80006652e-03f, -8.39297473e-03f,
  -1.85597837e-01f, -1.42456457e-01f, -3.01092863e-02f, -3.44262756e-02f, -1.26636988e-02f, 6.29812926e-02f, 6.91154450e-02f, 3.32728587e-02f, 6.90737786e-03f, -2.12942548e-02f,
  4.06811126e-02f, 2.37163100e-02f, -9.94352326e-02f, 3.44201848e-02f, 4.84753698e-02f, -4.01485153e-03f, -9.80993733e-02f, 2.45015752e-02f, -4.79523279e-02f, -9.57235843e-02f,
  -1.50555283e-01f, -9.78556424e-02f, -3.64587195e-02f, 2.74096299e-02f, -8.11158121e-02f, -5.35610411e-03f, -4.52058762e-02f, 2.62664650e-02f, -9.40421782e-03f, -8.57418478e-02f,
  4.87341871e-03f, 4.66552451e-02f, -1.35583458e-02f, -1.65456850e-02f, 3.11419088e-02f, 3.79998721e-02f, 1.38489287e-02f, 1.52816270e-02f, 3.01957559e-02f, 4.74892259e-02f,
  6.21545166e-02f, -1.82259139e-02f, 3.35135981e-02f, 1.74612366e-02f, 1.42144347e-02f, 2.07209773e-03f, 2.41314135e-02f, 3.43104564e-02f, -6.35363162e-02f, -5.42422608e-02f,
  6.32590950e-02f, -3.68735716e-02f, -2.72159297e-02f, 1.51992859e-02f, -1.29208174e-02f, 3.18743885e-02f, 3.38789374e-02f, -3.08941677e-02f, -2.13843882e-02f, 8.77576321e-02f,
  5.23013354e-04f, 2.04038084e-01f, 7.18246102e-02f, 2.55571250e-02f, 6.46491442e-03f, -1.36161232e-02f, -6.64145872e-02f, -6.14438727e-02f, -3.16957347e-02f, 3.43624712e-03f,
  8.84855986e-02f, 2.37789024e-02f, -3.73928398e-02f, -4.02525328e-02f, 1.29280156e-02f, -3.54202837e-02f, 3.08399014e-02f, 2.56621931e-02f, 3.73162813e-02f, 4.87426296e-02f,
  1.07318982e-01f, 6.26829639e-02f, 6.97956532e-02f, 1.93323102e-02f, 3.62219289e-02f, 4.63374704e-02f, -3.52323428e-02f, -4.24361303e-02f, 3.40818651e-02f, -3.09011457e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  3.56411844e-01f, 3.27276707e-01f, 2.58166105e-01f, 2.71067116e-02f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.53201351e-02f, -3.03019762e-01f, 3.30082662e-02f, -2.33997464e-01f, -2.08653733e-01f, 1.20046936e-01f, 1.54218137e-01f, -6.20909154e-01f, -6.77436590e-01f, 8.13300073e-01f,
  4.34477739e-02f, -3.89154702e-01f, -4.75973040e-01f, 1.54142976e-01f, 3.99770141e-02f, -8.47910270e-02f, 2.79351801e-01f, -4.57139462e-01f, 5.04800320e-01f, 2.94957727e-01f,
  2.07140714e-01f, -2.10196182e-01f, -3.07734072e-01f, 2.56202757e-01f, -6.36444390e-01f, -3.49864542e-01f, -3.30188483e-01f, 2.69221723e-01f, 3.60829115e-01f, 1.02027901e-01f,
  -1.67095378e-01f, 4.58356112e-01f, -1.32654477e-02f, -6.91577613e-01f, -1.36173725e-01f, -2.27765199e-02f, 2.78844714e-01f, 1.02645703e-01f, -3.77604097e-01f, -9.78296548e-02f,
  -3.90649050e-01f, 3.07235271e-01f, 8.00593257e-01f, 2.87678987e-01f, -5.37205100e-01f, 2.90094018e-01f, -3.86213303e-01f, 5.38961351e-01f, 1.33544713e-01f, 6.69269860e-01f,
  -2.00343028e-01f, 3.82426055e-03f, -2.64262795e-01f, 8.21129739e-01f, -6.49842560e-01f, -4.92990255e-01f, 4.84103709e-01f, 1.53331710e-02f, -2.92924851e-01f, -6.73286393e-02f,
  -4.98852670e-01f, -3.69701232e-03f, -2.22852111e-01f, 2.81591415e-01f, 6.47124695e-03f, -4.69972521e-01f, -9.09512267e-02f, -6.52735904e-02f, 3.69214118e-01f, -3.66578072e-01f,
  4.34784263e-01f, -4.91119064e-02f, -5.16438842e-01f, 6.96404278e-01f, 1.03068829e+00f, 5.13362279e-03f, 6.99029714e-02f, 2.94473290e-01f, 5.31810969e-02f, -2.32264008e-02f,
  -3.80340010e-01f, -4.22108591e-01f, -3.16513032e-01f, -3.37666810e-01f, 1.26969486e-01f, -8.35083008e-01f, -1.15135528e-01f, 2.39887685e-01f, 3.79137456e-01f, 8.49590719e-01f,
  2.84280777e-01f, 2.44194925e-01f, 2.18342878e-02f, 4.26765889e-01f, 1.81012571e-01f, -2.91320086e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.59623224e-01f, 3.91947061e-01f, -3.80570114e-01f, -4.96546507e-01f, 3.96029711e-01f, -6.42433107e-01f, -6.07490599e-01f, -3.56428444e-01f, 1.00336647e+00f, 8.28998983e-01f,
  -2.53701150e-01f, -4.97074693e-01f, 4.60136950e-01f, -1.68031827e-01f, -4.48157579e-01f, -4.29439425e-01f, 4.13225204e-01f, 2.36807942e-01f, -2.88665801e-01f, 4.86714654e-02f,
  3.36876750e-01f, 2.85899431e-01f, 1.64003894e-01f, -1.00342977e+00f, 8.15066248e-02f, 1.91637948e-01f, 8.64296615e-01f, -6.15417548e-02f, -2.33236909e-01f, -3.22569609e-02f,
  -2.42718861e-01f, -5.57908893e-01f, -3.56525451e-01f, 5.84380865e-01f, 2.91321993e-01f, 2.67921120e-01f, -1.26922697e-01f, 8.24924111e-01f, -1.56837094e+00f, -2.25672632e-01f,
  6.15008473e-01f, 1.83662906e-01f, 4.29955833e-02f, 4.41070557e-01f, -2.16238517e-02f, 6.86308622e-01f, -4.47219193e-01f, 1.97352663e-01f, -3.71523052e-01f, 4.39643800e-01f,
  5.27773127e-02f, 7.73083866e-02f, -8.11868757e-02f, 5.14345132e-02f, 6.27781391e-01f, -1.81494176e-01f, -3.27501208e-01f, 2.77929932e-01f, 2.44634703e-01f, -1.76379189e-01f,
  1.78248793e-01f, -3.28481674e-01f, 1.11224043e+00f, -2.10206613e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  7.25893319e-01f, 6.16478264e-01f, 4.87522006e-01f, 5.32194134e-03f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -4.00261372e-01f, 1.15759216e-01f, 2.57665306e-01f, 4.28185523e-01f, -2.28250220e-01f, 2.07675830e-01f, 1.12636960e+00f, -1.12452424e+00f, -5.45418203e-01f, -5.01337171e-01f,
  5.52075505e-01f, 6.73219934e-02f, -3.95547420e-01f, 3.06288123e-01f, -4.68779087e-01f, 1.09203267e+00f, -6.70681298e-01f, 8.61546755e-01f, 4.17827964e-01f, 9.03806388e-01f,
  -3.11055571e-01f, 9.37428176e-01f, 1.59163463e+00f, 3.65802318e-01f, 8.68595958e-01f, -2.87471682e-01f, 7.67084539e-01f, 3.25678676e-01f, 5.98939955e-01f, 4.52939451e-01f,
  -2.33704686e-01f, -2.61639267e-01f, 1.66915879e-01f, 1.02267928e-01f, -5.14505208e-01f, -1.67955518e-01f, 5.91477156e-02f, 2.25065365e-01f, 8.44177082e-02f, -9.47586060e-01f,
  -7.54516721e-01f, 4.38167006e-01f, -3.34051907e-01f, 4.99780804e-01f, 1.52713704e+00f, 1.49058595e-01f, -6.60954952e-01f, -2.56766289e-01f, -5.05684853e-01f, -1.39966834e+00f,
  3.74270886e-01f, 5.00690222e-01f, 3.49272847e-01f, 2.22124830e-01f, -1.28403437e+00f, 2.52610505e-01f, 1.12511027e+00f, -6.42805278e-01f, 9.20497358e-01f, -9.03255045e-01f,
  -4.36019272e-01f, -4.61063385e-01f, -1.13321550e-01f, -6.25261739e-02f, 1.06130220e-01f, 5.34088016e-01f, -3.44837941e-02f, -2.86060143e-02f, 8.53156805e-01f, 2.32345015e-01f,
  -1.17543709e+00f, 5.46134651e-01f, -1.49217880e+00f, -1.16293681e+00f, 2.66801715e-01f, -5.43356776e-01f, -1.19326174e-01f, -3.31485629e-01f, -7.91393757e-01f, 5.26771486e-01f,
  8.63533735e-01f, 6.34533226e-01f, 5.08437514e-01f, 4.03847188e-01f, 6.43790364e-01f, -8.96660566e-01f, 3.45989794e-01f, 5.23548350e-02f, 3.05542856e-01f, 5.93278944e-01f,
  2.44766623e-01f, -7.59690583e-01f, -6.23209178e-01f, 1.14204276e+00f, -3.23733717e-01f, -1.65148377e-01f, -5.95571399e-01f, 7.50126839e-01f, -1.27774999e-01f, -4.53369051e-01f,
  -1.02909744e+00f, -7.14328885e-01f, -6.67462409e-01f, 3.42810780e-01f, -7.43871808e-01f, 6.44449532e-01f, -8.11965406e-01f, -6.61011398e-01f, 2.62660354e-01f, -3.15807551e-01f,
  7.51345754e-01f, -2.46877819e-01f, 9.53885853e-01f, -1.44823954e-01f, 2.83932053e-02f, -6.18978620e-01f, -6.83686674e-01f, -3.20860356e-01f, 4.49815542e-01f, 9.64497030e-01f,
  1.13667893e+00f, -1.13188434e+00f, 5.97879052e-01f, 1.36436272e+00f, -3.90506446e-01f, -2.33048856e-01f, -3.28359962e-01f, 2.74158388e-01f, 4.92552528e-03f, -8.19771811e-02f,
  9.56635028e-02f, -6.77096188e-01f, 1.78016022e-01f, 6.91914782e-02f, 2.51661450e-01f, -1.17241895e+00f, 8.64058793e-01f, 3.87218744e-01f, 2.66300946e-01f, 8.21060538e-01f,
  4.33017969e-01f, 4.13591504e-01f, 8.43701005e-01f, -1.17087282e-01f, 2.91130185e-01f, 8.77822280e-01f, -1.42705584e+00f, 9.66327548e-01f, -3.26467991e-01f, -3.12790990e-01f,
  -5.32352805e-01f, -3.05257946e-01f, -2.30276927e-01f, 3.35518479e-01f, -1.44252276e+00f, -6.35211885e-01f, -2.39236832e-01f, -3.06756437e-01f, -6.88485205e-01f, 5.61957538e-01f,
  4.79228050e-01f, -7.88283706e-01f, 3.94254088e-01f, -5.64390123e-01f, 3.04224610e-01f, -5.04335880e-01f, 4.34778810e-01f, 5.57982802e-01f, 6.13336802e-01f, 8.86568427e-01f,
  -7.41551042e-01f, -6.57495022e-01f, -6.76920414e-01f, -7.37393141e-01f, 1.10003364e+00f, -3.01886052e-02f, -1.23394239e+00f, -6.16718948e-01f, 2.29267314e-01f, 4.91536260e-01f,
  2.87959874e-01f, 3.83713722e-01f, -4.66273218e-01f, 8.28069746e-01f, -6.80101752e-01f, -4.24524873e-01f, 2.94239055e-02f, 1.08739412e+00f, 4.95161980e-01f, -1.09101735e-01f,
  8.48485172e-01f, -2.91983306e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.71416628e-01f, -1.01302519e-01f, -1.86275646e-01f, 4.90524888e-01f, 3.48689049e-01f, 2.02222660e-01f, -2.46111691e-01f, 3.35794330e-01f, -6.03913605e-01f, 4.99271303e-01f,
  -2.01400995e-01f, -2.26202086e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    