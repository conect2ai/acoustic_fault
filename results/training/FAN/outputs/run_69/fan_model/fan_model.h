/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.43274710e-02f, 4.93972093e-01f, -8.52579325e-02f, 4.51847762e-02f, -2.07260743e-01f, -6.57272562e-02f, 2.04365402e-02f, -2.47557666e-02f, 1.67949513e-01f, 4.06602621e-01f,
  -3.31558026e-02f, 3.60785350e-02f, 1.04674190e-01f, 1.41630948e-01f, -2.33650684e-01f, 1.16497576e-01f, 4.59421724e-02f, 1.14546709e-01f, -2.15646182e-03f, -9.64552835e-02f,
  -6.04664311e-02f, -4.67262454e-02f, -2.18466729e-01f, -9.94343683e-02f, 2.87420005e-02f, -6.89016357e-02f, -2.66671292e-02f, -1.24622799e-01f, -1.44888526e-02f, 3.95725444e-02f,
  2.80508511e-02f, 1.49395987e-01f, 5.10411337e-02f, -1.91403907e-02f, -3.74976657e-02f, -7.51742497e-02f, 3.64583172e-02f, -6.84619993e-02f, -1.01861380e-01f, -9.85258352e-03f,
  -6.09029131e-03f, -1.06039889e-01f, 2.45370045e-02f, -2.12831534e-02f, -4.65217717e-02f, 5.28582409e-02f, -1.18103968e-02f, 5.69854379e-02f, -9.50352475e-03f, -1.43757300e-03f,
  -1.12316851e-02f, 3.09891012e-02f, -5.38483448e-03f, 4.64931130e-02f, -1.06344536e-01f, -3.43204699e-02f, -4.36748154e-02f, -9.15526152e-02f, 7.80111402e-02f, -3.27033401e-02f,
  5.77079281e-02f, 8.44520330e-03f, 4.48934594e-03f, 1.01234540e-01f, 1.22061931e-03f, 1.93791166e-02f, 7.52392933e-02f, -4.62762490e-02f, 2.04453729e-02f, 4.50732708e-02f,
  -5.00927642e-02f, -2.73067206e-02f, 1.78404804e-02f, -6.71481714e-02f, -2.30467580e-02f, 2.08717790e-02f, -8.87511969e-02f, -4.08325605e-02f, 1.68411322e-02f, -3.86764035e-02f,
  4.13930863e-02f, -8.98240358e-02f, 2.90840250e-02f, -2.25166921e-02f, 2.08990946e-02f, -1.21542722e-01f, -5.56583004e-03f, -1.38886496e-02f, -7.28845075e-02f, 1.75624527e-03f,
  1.36057332e-01f, 1.42765835e-01f, -3.20203342e-02f, -8.20272565e-02f, 8.46810937e-02f, 1.38750095e-02f, 3.22113745e-02f, 6.04083762e-02f, 3.24019417e-02f, 3.78049142e-03f,
  -8.19368809e-02f, -4.40391228e-02f, 1.01716198e-01f, -6.07256107e-02f, -1.97844324e-03f, -2.41484959e-03f, -1.68963391e-02f, -3.24013606e-02f, -1.82634138e-03f, 4.10496965e-02f,
  1.68087427e-02f, -7.43998215e-02f, 3.95347998e-02f, -1.07536398e-01f, 2.91218478e-02f, 7.25989714e-02f, 1.85511019e-02f, 5.85896373e-02f, 6.49851933e-03f, 1.10747248e-01f,
  2.07957588e-02f, -2.26388022e-01f, -3.65419537e-01f, -1.49781361e-01f, 3.28663707e-01f, 1.97037786e-01f, -2.15362146e-01f, 1.92013636e-01f, -1.92765266e-01f, -3.03080846e-02f,
  -1.09849195e-03f, -1.69454932e-01f, -1.30719334e-01f, -3.76669280e-02f, 1.55730352e-01f, -3.22515994e-01f, 8.14997628e-02f, -1.42324075e-01f, -6.33901218e-03f, 4.53795381e-02f,
  -2.56180950e-02f, 1.79757372e-01f, -1.29609704e-01f, 2.46353313e-01f, 7.08286092e-02f, 7.83914626e-02f, 2.01904267e-01f, -5.96385896e-02f, 2.95774013e-01f, 4.97788051e-03f,
  6.16562366e-02f, -1.94898933e-01f, -1.82893053e-02f, -4.86671515e-02f, 1.72537029e-01f, 5.95875569e-02f, 2.57026535e-02f, -1.31172240e-01f, -6.30312115e-02f, -3.91315110e-02f,
  -4.54654731e-02f, -1.28526269e-02f, -7.20951066e-04f, -6.71234578e-02f, -1.03451451e-02f, -5.37642138e-03f, -7.85584189e-03f, 1.87388007e-02f, -8.01117644e-02f, 9.42554995e-02f,
  -5.47056124e-02f, -2.50578653e-02f, -4.13121423e-03f, 2.87803039e-02f, -5.27059883e-02f, -6.21545650e-02f, 1.17132682e-02f, -4.70519625e-02f, 7.89667219e-02f, 9.50890407e-02f,
  -4.99005429e-02f, -1.85843632e-02f, 1.61946323e-02f, 3.95022333e-02f, -5.32530099e-02f, 2.91023757e-02f, 1.87808211e-04f, 4.77852747e-02f, -5.05233295e-02f, 5.45264641e-03f,
  1.51756987e-01f, -5.17013855e-02f, -1.80621701e-03f, -7.27089727e-03f, 1.65019166e-02f, -2.97800428e-03f, 2.23406907e-02f, 5.73676080e-02f, 2.88519636e-03f, 5.00020608e-02f,
  -5.55490255e-02f, 8.17137435e-02f, 1.49383955e-02f, 6.83405623e-03f, 1.27432412e-02f, -6.38671815e-02f, 5.95790334e-03f, -9.84508358e-03f, -1.78228430e-02f, 5.51120825e-02f,
  3.58065575e-01f, 1.54235289e-01f, 1.21687064e-02f, 3.11035085e-02f, 1.26628289e-02f, 4.53980751e-02f, -4.28452939e-02f, 2.27588583e-02f, -1.91693660e-02f, -1.98184606e-03f,
  7.69133344e-02f, 8.18430781e-02f, 8.76543224e-02f, 6.26702458e-02f, -9.16997865e-02f, -5.61872777e-03f, -4.35814783e-02f, 3.63856321e-03f, 6.74969926e-02f, 3.99809256e-02f,
  4.31996845e-02f, -2.49918457e-02f, 1.02133431e-01f, 6.14258796e-02f, -4.23009461e-03f, 6.59347400e-02f, 7.91043863e-02f, 3.11766881e-02f, 2.77659558e-02f, 3.17824595e-02f,
  -3.75428796e-01f, -2.07292140e-01f, -3.82313281e-01f, -1.60190910e-01f, 6.91329539e-02f, -1.23004794e-01f, -1.42519161e-01f, 5.11222892e-02f, -4.90473598e-01f, 3.93574804e-01f,
  2.04757571e-01f, -2.08612964e-01f, -5.17717399e-06f, 2.30585232e-01f, -1.06861554e-01f, -1.60122260e-01f, 1.12787992e-01f, -5.40808365e-02f, -3.14984500e-01f, 1.15836971e-01f,
  -5.47005720e-02f, 5.26062131e-01f, 9.64814946e-02f, 2.21490785e-01f, 1.18650205e-01f, -1.65026501e-01f, 2.64930248e-01f, -3.98607701e-02f, 2.66689062e-01f, 1.53489813e-01f,
  -1.52687475e-01f, -1.98989874e-03f, -7.86594450e-02f, -7.00173229e-02f, 7.57866725e-02f, 5.78352064e-03f, 2.28456762e-02f, -5.06830029e-02f, -8.99685025e-02f, -4.31218483e-02f,
  -8.02079495e-03f, 8.87343138e-02f, 1.49833830e-02f, -7.62258051e-03f, -6.11293390e-02f, -3.45189758e-02f, 7.87244439e-02f, -4.33037989e-02f, 1.55696943e-02f, -5.86268865e-02f,
  -6.95205554e-02f, 2.67830640e-02f, -6.06351579e-03f, -2.55418639e-03f, -6.28183335e-02f, 1.03304973e-02f, 5.94849102e-02f, -1.36001743e-02f, -4.84770723e-02f, -4.29906622e-02f,
  4.27186899e-02f, -7.00989440e-02f, -1.58029497e-02f, -5.32668922e-03f, 6.32480485e-03f, 2.62530223e-02f, -3.21081257e-03f, 9.75648239e-02f, -5.96534945e-02f, 1.13673462e-02f,
  8.79097953e-02f, -3.01379766e-02f, -1.98908392e-02f, -8.22929665e-02f, 3.47773470e-02f, -3.77637567e-03f, -3.57695185e-02f, -2.58669686e-02f, -7.50510916e-02f, -1.09420542e-03f,
  6.36769012e-02f, -4.90518846e-02f, 1.33912696e-03f, 8.47688038e-03f, -3.98288369e-02f, -1.18579164e-01f, 6.99511766e-02f, -1.04047552e-01f, -1.72839947e-02f, 2.36680713e-02f,
  2.40120038e-01f, 1.95967704e-01f, -1.20551400e-02f, -7.30991783e-03f, -7.85999149e-02f, 8.20130408e-02f, -1.89381242e-02f, 5.41681685e-02f, -5.71423844e-02f, 3.18269543e-02f,
  2.11219937e-02f, 5.36435321e-02f, -4.62916913e-03f, -1.66342099e-04f, -2.72897398e-03f, -5.40068513e-03f, 1.22058596e-02f, 5.34228086e-02f, 1.03324957e-01f, -2.53552949e-04f,
  7.78639540e-02f, -1.00821611e-02f, 2.63032503e-02f, 9.35885906e-02f, 1.11606233e-01f, 5.60552999e-02f, -8.41896012e-02f, -1.15575179e-01f, 1.01547964e-01f, 4.32302989e-02f,
  7.35124767e-01f, -2.96564341e-01f, -2.12298706e-02f, 5.03317058e-01f, 1.08857110e-01f, -2.24193767e-01f, 2.28340328e-01f, -3.86869931e-03f, 4.22154844e-01f, -3.19472104e-01f,
  9.79411751e-02f, -4.57130447e-02f, -3.51430848e-03f, 6.10163212e-02f, 2.95041144e-01f, -5.60806207e-02f, 1.98350221e-01f, 5.44251576e-02f, 7.29942396e-02f, 1.75513308e-02f,
  1.74075663e-01f, 9.94934514e-02f, 4.62869592e-02f, -1.45829350e-01f, 4.77141663e-02f, -1.94103085e-02f, -1.38767973e-01f, -1.35146007e-01f, -2.66694445e-02f, -4.00849693e-02f,
  1.34933352e-01f, 1.32197350e-01f, 4.83961292e-02f, -6.13597706e-02f, -5.36611602e-02f, -4.64293063e-02f, -3.87104712e-02f, 3.85929123e-02f, 4.81524020e-02f, -6.90454990e-03f,
  -2.69961841e-02f, 4.45317067e-02f, 9.05617401e-02f, -2.56065149e-02f, 6.28098845e-02f, 5.34163080e-02f, -1.06362766e-02f, -1.45462691e-03f, -7.45076127e-03f, 2.74197236e-02f,
  5.01803532e-02f, 4.55982983e-02f, 2.09029317e-02f, 1.02277901e-02f, -3.87271009e-02f, 5.92384152e-02f, -5.86303920e-02f, -9.41409022e-02f, 3.96660119e-02f, -6.48154179e-03f,
  -7.05906004e-03f, -3.74367498e-02f, -1.11078704e-02f, 3.70076858e-02f, 1.98375117e-02f, 4.59254012e-02f, 1.45692648e-02f, -1.18935537e-02f, 8.57972577e-02f, 1.08075878e-02f,
  5.35741961e-03f, 5.15713282e-02f, 2.94922758e-02f, 4.50250879e-02f, 7.00894073e-02f, -9.96638834e-03f, 1.81881692e-02f, -3.53794619e-02f, 6.68586418e-02f, 2.15044823e-02f,
  -2.66866349e-02f, -1.84005965e-02f, -3.54308002e-02f, -4.90294248e-02f, -3.25646959e-02f, -2.27447022e-02f, -3.43153370e-04f, -4.87523377e-02f, 1.47066256e-02f, -6.33998169e-03f,
  -2.09021494e-01f, -3.67127359e-01f, 2.58808509e-02f, 3.35733369e-02f, 1.67931635e-02f, -4.38691564e-02f, 4.18239161e-02f, -7.21107842e-03f, -6.12624623e-02f, 5.78115648e-03f,
  2.02418491e-02f, -4.18684743e-02f, -8.53411928e-02f, 4.99206632e-02f, 4.16557956e-03f, -7.28079155e-02f, -3.02119385e-02f, -6.12794384e-02f, -4.17621918e-02f, 4.08037081e-02f,
  -7.75863826e-02f, -1.95586476e-02f, 5.48761860e-02f, -3.21464203e-02f, 1.43141448e-02f, -6.71922863e-02f, -1.67958438e-03f, 8.32369700e-02f, -6.18374795e-02f, 2.89580021e-02f,
  -1.23623379e-01f, 2.58398831e-01f, 6.12150170e-02f, 4.36688475e-02f, -6.68721348e-02f, -5.37144065e-01f, -4.35442716e-01f, -5.88696897e-02f, -2.21668761e-02f, -2.70070359e-02f,
  -1.02253355e-01f, 1.13953374e-01f, -1.03479426e-03f, -1.67463526e-01f, -4.97516960e-01f, -8.67239013e-02f, -2.13086709e-01f, -1.54410554e-02f, 1.43108547e-01f, 5.21987677e-02f,
  -3.29740345e-02f, -1.79640085e-01f, -7.32382461e-02f, 8.66743643e-03f, -2.79457476e-02f, 2.08016649e-01f, -1.21009890e-02f, -4.03940305e-02f, 4.05364372e-02f, -5.57236597e-02f,
  -1.90093927e-02f, 2.40844205e-01f, 2.01489497e-02f, -5.66012524e-02f, -7.71915913e-02f, 2.30827183e-02f, 1.69099085e-02f, -2.12270170e-02f, -9.49542411e-03f, -1.02833649e-02f,
  -1.27996765e-02f, -2.14678291e-02f, -3.75094898e-02f, -5.62313199e-02f, 3.98669839e-02f, 6.11728244e-02f, 5.10369651e-02f, 3.00066471e-02f, 9.56387669e-02f, 2.76491661e-02f,
  5.84475286e-02f, 3.90461758e-02f, -2.65547336e-04f, 2.36069299e-02f, -1.06345359e-02f, -7.80458376e-03f, -2.14101821e-02f, -3.77690041e-04f, 4.20168303e-02f, -2.07551718e-02f,
  -3.46172638e-02f, 1.20904529e-02f, 4.40042913e-02f, 2.49824096e-02f, 4.89530265e-02f, 1.04521690e-02f, -5.47186052e-03f, -5.34932502e-03f, 3.21362503e-02f, 1.06596714e-02f,
  7.00327707e-03f, 3.44909839e-02f, -1.26214018e-02f, -4.81815636e-02f, 1.52997626e-02f, -6.20918302e-03f, -3.40914950e-02f, 8.37622508e-02f, 1.05665056e-02f, -3.15919928e-02f,
  -1.42482156e-02f, -1.16557563e-02f, 2.18750769e-03f, 1.52452930e-03f, -1.00690827e-01f, -6.30545663e-03f, -1.47822164e-02f, 2.97283027e-02f, 6.39128685e-02f, -5.82117476e-02f,
  -1.29394218e-01f, -1.06882408e-01f, 3.05435210e-02f, 3.39538902e-02f, 4.91013676e-02f, 6.90901466e-03f, -4.25235741e-02f, -2.60191411e-02f, 2.95922495e-02f, -6.11873195e-02f,
  2.99353525e-02f, -3.17874961e-02f, 7.47474749e-03f, 4.37078178e-02f, -1.02938311e-02f, -6.32884726e-02f, -2.63272710e-02f, -2.37388164e-02f, -7.48220086e-02f, 8.84852931e-02f,
  5.93683496e-02f, -4.74935398e-02f, 2.26597507e-02f, -1.78780369e-02f, -1.63388234e-02f, -4.33142073e-02f, -3.57972793e-02f, 4.28867042e-02f, 7.18301395e-04f, -4.76653427e-02f,
  4.95045245e-01f, -9.99815539e-02f, 3.16943288e-01f, 1.53683081e-01f, 2.96300292e-01f, 1.04797266e-01f, 1.73109785e-01f, 1.22667409e-01f, 2.42245182e-01f, -1.29814431e-01f,
  7.78421536e-02f, 1.59114264e-02f, -1.36163801e-01f, -1.01425007e-01f, 1.08040474e-01f, -2.04821095e-01f, 3.49568389e-02f, 1.35282859e-01f, -6.55367002e-02f, 4.07750458e-02f,
  5.43806441e-02f, -5.71686849e-02f, 6.81461161e-03f, -5.44142798e-02f, 1.66080341e-01f, 5.22089750e-02f, 3.61077711e-02f, 7.86680877e-02f, -8.63302592e-03f, 1.26342818e-01f,
  1.01413488e-01f, 2.33804703e-01f, 8.29879194e-02f, 8.87788832e-03f, 1.33086085e-01f, 8.77126828e-02f, 2.83909868e-02f, -4.50045392e-02f, -8.20369497e-02f, 3.44496593e-03f,
  -2.45493595e-02f, -2.69974358e-02f, 2.12457497e-02f, 4.10227512e-04f, 3.55973430e-02f, 1.03582986e-01f, -8.16389918e-02f, 4.15451899e-02f, -6.98719621e-02f, -3.18184607e-02f,
  -4.37973030e-02f, 6.72187377e-03f, 3.73302437e-02f, -3.36594209e-02f, 1.56673845e-02f, 3.51212025e-02f, 6.18977472e-03f, 2.46117320e-02f, 5.34868985e-02f, 8.78927335e-02f,
  1.02676578e-01f, -4.40935977e-03f, 1.50793940e-02f, -2.99462471e-02f, 3.80604411e-03f, 5.97150847e-02f, -1.18623646e-02f, 6.09883778e-02f, -4.21163850e-02f, 2.37987936e-02f,
  2.89478321e-02f, 2.89542079e-02f, 3.05984896e-02f, -3.92480493e-02f, -4.46950197e-02f, 4.05737273e-02f, -8.61416906e-02f, 2.22876798e-02f, 5.07992133e-02f, -1.16834948e-02f,
  1.59346424e-02f, 4.07224670e-02f, 5.71804568e-02f, 1.07982312e-03f, 3.64363939e-02f, -3.73249389e-02f, 1.66022740e-02f, -4.73953336e-02f, 2.82231551e-02f, 2.86033545e-02f,
  6.52497634e-02f, 3.20082784e-01f, -1.02570821e-02f, 5.07510714e-02f, -3.49328551e-03f, -3.94890942e-02f, -2.21558586e-02f, 3.12949233e-02f, 1.04672641e-01f, 6.29456788e-02f,
  -2.43530981e-03f, 4.23812754e-02f, 7.24210218e-02f, -2.75453255e-02f, -5.82491979e-02f, -5.12930155e-02f, 8.28217529e-03f, -2.89354511e-02f, 1.28356680e-01f, -3.47469794e-03f,
  2.80167591e-02f, 6.08210787e-02f, -2.72167828e-02f, 4.38347794e-02f, 2.71140714e-03f, 1.81879234e-02f, 1.10312752e-01f, -1.66054126e-02f, 5.09363711e-02f, 1.80690233e-02f,
  5.05974352e-01f, -3.04288447e-01f, 2.03552783e-01f, 7.63962790e-02f, -1.98680889e-02f, -2.44565219e-01f, -3.47579084e-03f, -2.15383723e-01f, -9.86177996e-02f, -2.68506855e-01f,
  -1.37476429e-01f, 1.84724167e-01f, -2.00732619e-01f, -1.51341349e-01f, 1.56606182e-01f, -2.79154748e-01f, 2.62277778e-02f, -9.63334925e-04f, -1.18341520e-01f, -5.01105050e-03f,
  3.07390429e-02f, -2.01203093e-01f, 1.37537971e-01f, -2.01646581e-01f, 1.01083249e-01f, 1.40540615e-01f, 1.55186117e-01f, -8.21650669e-04f, 1.42567039e-01f, -5.52081056e-02f,
  -1.11742593e-01f, -1.27789214e-01f, 1.34353623e-01f, 4.45360951e-02f, 1.06595159e-01f, 4.13804948e-02f, 2.93818209e-02f, 4.55589145e-02f, 4.53117229e-02f, -1.47917271e-02f,
  -4.22584526e-02f, -2.59375386e-02f, -1.94364469e-02f, 1.26762157e-02f, -1.09269820e-01f, 8.13506320e-02f, 1.93703994e-02f, -1.76180657e-02f, -3.02213535e-04f, -1.06604239e-02f,
  5.54555580e-02f, 5.50786853e-02f, 1.02642654e-02f, -5.46197332e-02f, 8.99377167e-02f, -1.40431281e-02f, 6.56044390e-03f, 8.58478397e-02f, -2.22564582e-02f, -2.45217010e-02f,
  -6.85129091e-02f, -5.85530698e-02f, -2.01460700e-02f, -3.29993777e-02f, -1.89504120e-02f, -1.43906809e-02f, -1.31925913e-02f, 2.82823816e-02f, 5.73595613e-02f, -6.18137270e-02f,
  1.44650685e-02f, 1.33523010e-02f, -7.54155517e-02f, 6.09677956e-02f, 1.91747025e-02f, -4.06433269e-02f, 5.56457937e-02f, 1.49309821e-02f, -2.41932389e-03f, 4.42859046e-02f,
  -3.85007933e-02f, -6.61690086e-02f, 8.91135931e-02f, -6.90035801e-03f, -4.08805087e-02f, 5.75047098e-02f, -3.47091891e-02f, 4.52837460e-02f, 1.91353802e-02f, 5.25685847e-02f,
  -5.03708497e-02f, -1.33209080e-01f, -7.82577097e-02f, -4.14552167e-02f, -6.70660585e-02f, -4.68132012e-02f, -7.02151954e-02f, 1.97534766e-02f, 7.03294855e-03f, -3.96365412e-02f,
  1.59649625e-02f, 2.53383033e-02f, -2.72858143e-02f, -9.01216920e-03f, 2.09512562e-02f, -1.01173744e-02f, 4.90599964e-03f, 4.76177521e-02f, 4.20400873e-02f, 2.65599973e-02f,
  6.73371106e-02f, -5.11842556e-02f, 1.66529380e-02f, 6.97783232e-02f, 2.32390836e-02f, 8.13094527e-02f, 1.07347535e-03f, 1.02486081e-01f, 1.13983927e-02f, -1.00769533e-03f,
  -7.95201510e-02f, -2.69987524e-01f, 2.63279855e-01f, -1.35013327e-01f, 2.08059743e-01f, 1.79560676e-01f, 2.12073714e-01f, -4.60487045e-02f, 2.08206568e-02f, -4.02084172e-01f,
  -1.32554248e-01f, -1.93693131e-01f, -1.61182806e-01f, 5.67182489e-02f, 1.76635444e-01f, 2.17390686e-01f, 1.59301311e-01f, -7.50161409e-02f, 2.20199168e-01f, -1.93832070e-01f,
  5.81045635e-02f, 3.13794389e-02f, 1.35152861e-01f, -1.56898335e-01f, 1.00769829e-02f, -8.02205503e-03f, -4.10253778e-02f, 1.13625847e-01f, -1.22198373e-01f, 1.47540793e-01f,
  7.79688805e-02f, -4.23008054e-02f, 5.21079563e-02f, -7.20087439e-02f, -1.05551782e-03f, 3.14230397e-02f, -5.26081882e-02f, 1.43477783e-01f, 5.55786192e-02f, -8.22623223e-02f,
  -4.67275381e-02f, 4.07984853e-03f, -3.69366035e-02f, 9.12646353e-02f, 2.49879658e-02f, -2.91739982e-02f, 5.05184010e-02f, -3.07929702e-03f, -4.18697372e-02f, 6.47819489e-02f,
  1.41843436e-02f, 1.28856748e-02f, -4.06865664e-02f, -6.96162507e-02f, 1.27667010e-01f, 3.09435627e-03f, 1.42139927e-01f, 3.53891440e-02f, 8.17603767e-02f, 9.65740811e-03f,
  6.05625100e-02f, 6.75916895e-02f, -3.75676006e-02f, -1.92144867e-02f, -5.78990318e-02f, 3.26141007e-02f, 2.07532123e-02f, -3.22440565e-02f, -1.00534894e-02f, 7.45007917e-02f,
  -6.09125942e-02f, -6.58990517e-02f, 2.17988491e-02f, 1.26454294e-01f, -9.62305963e-02f, -3.11536547e-02f, 3.96900661e-02f, 4.06125933e-03f, -8.84159133e-02f, -3.33316252e-02f,
  -8.04246515e-02f, 7.23866001e-03f, -1.07447229e-01f, 2.27465797e-02f, -5.90504659e-03f, 2.76805405e-02f, -1.79483164e-02f, 1.21603599e-02f, 1.81881990e-02f, 6.57723239e-03f,
  -1.83138847e-01f, -2.51509458e-01f, 2.50046141e-03f, -4.19988260e-02f, -4.14177701e-02f, -4.54973951e-02f, 5.64505532e-02f, 1.11770239e-02f, 3.13041210e-02f, -8.72203242e-03f,
  4.45002615e-02f, -4.91816364e-02f, -3.72177362e-02f, 6.33058548e-02f, -1.91554353e-02f, 7.30008706e-02f, 3.46655138e-02f, 4.65168878e-02f, -5.45065999e-02f, -4.06798497e-02f,
  -1.14759644e-02f, -4.52315137e-02f, 2.17274632e-02f, -1.21919207e-01f, -1.79488417e-02f, -9.94478762e-02f, -1.51669696e-01f, 1.12571806e-01f, -2.29025539e-02f, 2.15000492e-02f,
  -2.07922488e-01f, 1.49039596e-01f, 2.01358497e-02f, -1.21593408e-01f, 1.38399363e-01f, 6.12631552e-02f, -1.82702765e-01f, 1.84535965e-01f, 3.79530061e-03f, 1.39751151e-01f,
  -4.65257689e-02f, -2.24723518e-01f, -2.24431783e-01f, 6.41659722e-02f, -5.23143768e-01f, -2.17347473e-01f, -2.40628943e-01f, -1.19362243e-01f, 1.71276722e-02f, -7.15637356e-02f,
  -5.28446399e-02f, 1.17723949e-01f, -9.52936634e-02f, 2.66970009e-01f, 3.11740935e-01f, 1.23362876e-01f, -6.62763566e-02f, 1.00741275e-01f, 1.03358224e-01f, 8.93306732e-03f,
  1.28587767e-01f, 1.00924745e-01f, 7.03071952e-02f, 4.72878180e-02f, -4.20608409e-02f, -2.40568854e-02f, -1.05233081e-01f, -5.99560477e-02f, -7.10687973e-03f, -2.22400054e-02f,
  -9.25829783e-02f, -6.37375563e-02f, 1.26123093e-02f, 3.52254249e-02f, 5.68194687e-02f, 3.25514562e-02f, 1.80098098e-02f, 1.55094080e-02f, 2.71364860e-02f, -2.42740214e-02f,
  3.63162197e-02f, -2.68121511e-02f, -7.45026544e-02f, -8.06472003e-02f, -2.27470454e-02f, -2.13949592e-03f, -2.85848714e-02f, -3.14557105e-02f, 3.10843177e-02f, -9.52891912e-03f,
  -2.75756326e-02f, -3.25568281e-02f, -2.58382736e-03f, 2.61714924e-02f, -9.16810427e-03f, 7.57723972e-02f, -5.03786542e-02f, 1.96236596e-02f, 4.15913761e-02f, -2.83731483e-02f,
  1.01221856e-02f, -1.17897354e-02f, 2.87932120e-02f, 6.08549416e-02f, -1.26614887e-02f, 5.28490543e-02f, -6.83876723e-02f, 1.07767005e-02f, 7.91655108e-03f, -8.24863184e-03f,
  -2.68483497e-02f, -2.51978077e-02f, 1.23169376e-02f, -2.40598228e-02f, 5.84741868e-02f, 1.41025416e-03f, 2.18521617e-02f, 4.29552570e-02f, 1.55312205e-02f, -8.92057791e-02f,
  -1.82843506e-01f, -2.11860985e-01f, 4.14816029e-02f, 2.57501006e-02f, 3.04861702e-02f, 1.84065476e-02f, -4.15160041e-03f, 7.92585313e-02f, -2.42780447e-02f, -2.04278901e-02f,
  4.01909314e-02f, 3.53297219e-02f, -5.55202411e-03f, -1.42038823e-03f, 3.33649199e-03f, -1.41733261e-02f, -9.35052559e-02f, -3.62164564e-02f, -5.69619648e-02f, 5.87381888e-03f,
  -5.56452014e-02f, -1.94074295e-03f, -9.29124374e-03f, 5.66401035e-02f, 5.53915324e-03f, -6.25670105e-02f, 1.33501180e-02f, 6.99370801e-02f, -5.77894226e-02f, 1.35380477e-02f,
  8.75677839e-02f, 6.27060086e-02f, 3.51125956e-01f, 8.91893543e-03f, -1.19084667e-03f, -4.58523892e-02f, -1.00233994e-01f, 1.22776948e-01f, 1.28231138e-01f, -1.55211806e-01f,
  -6.21517785e-02f, 1.93542044e-03f, -7.71351308e-02f, 6.21923506e-02f, -3.35994899e-01f, -6.70723468e-02f, 2.94476207e-02f, -9.30567905e-02f, 7.98708349e-02f, 3.99026796e-02f,
  7.44953826e-02f, -1.36769280e-01f, 1.57906979e-01f, 1.46841675e-01f, 1.90122381e-01f, 3.01835872e-02f, -1.68717831e-01f, 4.57606185e-03f, -6.20693192e-02f, -9.02210474e-02f,
  -4.69790362e-02f, 2.01588005e-01f, 1.22120015e-01f, 4.57641408e-02f, 5.81187159e-02f, -1.12214992e-02f, -8.53893720e-03f, -7.09293708e-02f, -2.65607261e-03f, -1.48915565e-02f,
  -5.02348803e-02f, -7.70323947e-02f, -2.82135364e-02f, 1.79038290e-02f, 1.02919471e-02f, 1.05272099e-01f, 8.28748718e-02f, 8.77860561e-02f, 1.23439170e-02f, 8.12921673e-02f,
  5.66811226e-02f, 5.72385266e-02f, 1.00272804e-01f, -6.66591227e-02f, -7.12947873e-03f, 3.08773126e-02f, -2.09286041e-03f, -1.77751072e-02f, -3.89608219e-02f, 4.29594889e-02f,
  4.40107472e-02f, 3.55466716e-02f, 4.38274554e-04f, 9.56697203e-03f, -3.60187180e-02f, -4.19369452e-02f, -1.38974702e-02f, -6.11213595e-02f, -4.82898653e-02f, -1.91586036e-02f,
  2.46503241e-02f, -2.02708300e-02f, 5.20264767e-02f, -1.71841457e-02f, 3.34299169e-02f, -6.49915636e-02f, -2.61794385e-02f, -1.19544573e-01f, 5.93454204e-02f, 1.98806878e-02f,
  -5.75106367e-02f, -2.16965750e-02f, 1.60060097e-02f, -1.31392460e-02f, 7.95981288e-03f, -7.79690817e-02f, 2.96696238e-02f, 5.49034565e-04f, -3.88963930e-02f, -2.10780613e-02f,
  -3.51837516e-01f, -2.21569881e-01f, -7.09775537e-02f, -4.60658371e-02f, -1.26844704e-01f, -3.32158841e-02f, 1.56655032e-02f, -1.89892780e-02f, -6.09485582e-02f, 8.03833529e-02f,
  4.97191846e-02f, -3.95929255e-02f, 4.38806191e-02f, -6.00506477e-02f, -2.76149344e-02f, 4.27870546e-03f, -7.31226355e-02f, -1.15344405e-01f, -4.55707647e-02f, -1.38385510e-02f,
  -2.60671470e-02f, 2.68005729e-02f, 1.89441107e-02f, 4.17286940e-02f, -5.08212931e-02f, 2.46637445e-02f, 2.13280972e-02f, 2.01242752e-02f, -2.17903499e-02f, -1.66360866e-02f,
  -2.08498657e-01f, 2.38023490e-01f, 2.99097807e-03f, -9.52258185e-02f, -4.29748073e-02f, 8.91467836e-03f, 1.09959655e-01f, -2.39268187e-02f, 2.17584178e-01f, 8.67538825e-02f,
  4.44468664e-04f, 1.36932567e-01f, 2.63909012e-01f, -6.14433624e-02f, 7.72448257e-02f, 1.89933375e-01f, -2.96530910e-02f, 5.35310106e-03f, 1.46197900e-01f, 9.89940576e-03f,
  -1.97614636e-02f, 1.40414457e-03f, 2.84534022e-02f, -1.74943786e-02f, -8.15481395e-02f, -5.09833843e-02f, -9.76356585e-03f, 3.90993915e-02f, -1.64445400e-01f, -1.12729304e-01f,
  -1.02778457e-01f, 1.16268694e-02f, -1.59617160e-02f, 6.45897612e-02f, 7.32324570e-02f, -2.62493994e-02f, -7.70183802e-02f, -7.58612379e-02f, -5.57714254e-02f, 4.86220866e-02f,
  -3.46035846e-02f, -2.52414756e-02f, -6.00109901e-03f, 7.57353753e-02f, -3.36205103e-02f, -3.34725715e-02f, -2.05084905e-02f, -4.86875772e-02f, 2.37058941e-02f, 1.49624133e-02f,
  1.55267548e-02f, -5.98006509e-03f, -4.75910231e-02f, 1.53446347e-02f, -9.18235444e-03f, 6.49698004e-02f, 4.93096150e-02f, 5.86504899e-02f, -6.81427270e-02f, 2.61034239e-02f,
  1.99619830e-02f, 4.50136662e-02f, 2.05951091e-03f, -5.32228500e-02f, 2.82607935e-02f, -6.69135451e-02f, 1.16738025e-02f, -1.57885998e-02f, 6.16782391e-03f, 1.99097395e-02f,
  5.55826165e-03f, -1.91390440e-02f, -3.15377340e-02f, 2.60004085e-02f, 2.80485358e-02f, -2.80669481e-02f, 4.35350044e-03f, 4.13296334e-02f, 6.95897415e-02f, -4.34737243e-02f,
  -2.76985532e-03f, 4.48529087e-02f, 3.26578878e-02f, 1.11578070e-02f, 1.86050925e-02f, 3.45912925e-03f, 4.77721170e-02f, -2.97620352e-02f, -7.00375810e-02f, -3.30211595e-02f,
  1.95430666e-01f, 3.84571880e-01f, 2.46051215e-02f, -8.16096291e-02f, 4.10523675e-02f, -2.89594359e-03f, 2.71052793e-02f, -3.65928449e-02f, 3.57520543e-02f, 4.98703010e-02f,
  1.10026672e-02f, -5.60896806e-02f, -8.62463564e-03f, -9.85291079e-02f, -5.05049936e-02f, 6.97415993e-02f, 3.44770066e-02f, -1.77254286e-02f, 1.74347237e-02f, -6.76529948e-03f,
  -4.37941775e-02f, 3.33191864e-02f, -6.77190199e-02f, -9.84798744e-03f, -3.92025150e-03f, 5.19653177e-03f, 4.93152104e-02f, -1.03836283e-01f, 1.73419677e-02f, 4.79502603e-02f,
  3.56588870e-01f, -3.17755967e-01f, -6.66696355e-02f, 9.66078544e-04f, 3.82210940e-01f, -1.77842706e-01f, -1.85624093e-01f, 1.00488834e-01f, 2.08618641e-01f, -2.02339083e-01f,
  -9.40757059e-03f, -1.00381158e-01f, -3.51940840e-01f, -1.31086677e-01f, 2.08405647e-02f, -3.37003797e-01f, -3.08195651e-02f, -1.15410268e-01f, 6.23852238e-02f, 4.06871848e-02f,
  1.66542709e-01f, -8.58028084e-02f, -1.60509780e-01f, 9.35947448e-02f, 8.37997869e-02f, 9.88525227e-02f, 2.84309406e-02f, -2.89349444e-02f, 1.20855328e-02f, -1.00671211e-02f,
  -2.50352174e-02f, -3.82035272e-03f, 6.63170591e-02f, -3.32347304e-02f, -9.40018892e-03f, 2.00595967e-02f, -2.70855520e-02f, -6.56351373e-02f, 4.03830633e-02f, 3.35697224e-03f,
  -6.51718155e-02f, 4.63638939e-02f, -5.57616465e-02f, 3.21658514e-02f, 1.17982700e-01f, 7.52755404e-02f, 9.10847709e-02f, 3.59318815e-02f, -6.62424937e-02f, -4.18085344e-02f,
  3.58504336e-03f, 1.20257316e-02f, 6.86122328e-02f, -5.08499406e-02f, 2.46903449e-02f, 3.54963914e-02f, -1.25016961e-02f, -1.84023399e-02f, 3.84985581e-02f, 1.20805646e-03f,
  -1.35957934e-02f, -4.05801926e-03f, -4.71960148e-03f, 1.08445063e-02f, -6.81591500e-03f, 5.82751520e-02f, 1.06058549e-03f, -4.22039442e-02f, 1.66076273e-02f, 2.56359894e-02f,
  5.45162931e-02f, 4.44309860e-02f, -2.82812044e-02f, 4.95645329e-02f, 3.63982767e-02f, -5.20201959e-02f, -1.50106726e-02f, -8.37148651e-02f, 3.83777432e-02f, 1.89875346e-02f,
  2.63923053e-02f, 3.46982107e-02f, -3.55859697e-02f, -2.14141011e-02f, -9.15597286e-03f, -2.07779482e-02f, -3.55961658e-02f, 1.00619532e-03f, -6.97576478e-02f, -5.42148426e-02f,
  -1.29225865e-01f, -1.83953345e-01f, -4.74385507e-02f, -5.88849932e-02f, -2.19517481e-02f, 6.52022138e-02f, -1.48661612e-02f, 3.01942155e-02f, -3.64350155e-02f, 1.38523187e-02f,
  6.61695749e-02f, 1.52958063e-02f, 6.50682077e-02f, 3.11610871e-03f, 1.29478257e-02f, -2.67591290e-02f, -9.49190557e-02f, 1.14037441e-02f, 4.70579900e-02f, -2.71055894e-03f,
  -6.13468047e-03f, -4.12123613e-02f, -6.88903779e-03f, 4.34427112e-02f, 5.21872938e-02f, -2.55681723e-02f, 4.44748662e-02f, -8.29102821e-04f, 2.70601213e-02f, 1.87848206e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.51247934e-01f, 2.34030068e-01f, 2.36161098e-01f, 5.05382240e-01f, -1.35842934e-01f, -2.51879722e-01f, -3.70586157e-01f, 1.45413563e-01f, 2.25982796e-02f, -1.57086536e-01f,
  5.47680296e-02f, 3.42696011e-02f, -2.43633330e-01f, 4.59746897e-01f, 4.35422212e-01f, -2.06699312e-01f, 4.04581428e-01f, 9.71480757e-02f, 5.05318865e-03f, 1.92857116e-01f,
  2.66739190e-01f, 3.17941487e-01f, 2.68198788e-01f, 3.13282222e-01f, 1.96405560e-01f, 2.56786078e-01f, 3.68689716e-01f, 3.35463285e-02f, 5.00976026e-01f, 1.76175952e-01f,
  -1.70446172e-01f, 1.45776160e-02f, -2.45407913e-02f, -1.23563455e-02f, -4.64350879e-02f, -9.26811844e-02f, -1.02634653e-01f, 3.59771624e-02f, -5.30018844e-02f, -1.40979178e-02f,
  -5.63915744e-02f, 5.35214739e-03f, 1.43948525e-01f, 5.11957742e-02f, -2.52823643e-02f, 7.47068003e-02f, 1.95981506e-02f, -6.70327991e-02f, 3.72965634e-02f, -6.51246831e-02f,
  -1.98982861e-02f, -1.13926521e-02f, 9.02179070e-03f, 3.56595218e-03f, 1.35904640e-01f, 2.64833085e-02f, -9.04084370e-02f, 6.93729520e-02f, -2.23911852e-02f, 2.43645292e-02f,
  5.14473841e-02f, -1.76637694e-02f, -5.42166419e-02f, -7.69998506e-02f, 6.21355623e-02f, -2.64532976e-02f, 5.83163053e-02f, -2.46396884e-02f, 4.03213464e-02f, 6.23252206e-02f,
  -4.24762107e-02f, 3.76249515e-02f, -2.68707518e-02f, -5.64899184e-02f, 1.80068985e-02f, -7.36282691e-02f, -5.33752777e-02f, 2.49568932e-02f, 1.79939084e-02f, 3.50605957e-02f,
  5.68389427e-03f, 7.66455978e-02f, -2.41119172e-02f, 3.32978438e-03f, -6.25219792e-02f, 6.98745809e-03f, 1.45837620e-01f, 7.86098614e-02f, 1.04304822e-03f, -3.47113609e-02f,
  2.04849720e-01f, 5.45155287e-01f, 2.85879709e-03f, -2.15073861e-02f, 3.31025273e-02f, 5.33696264e-04f, 5.16255759e-02f, 8.94243643e-02f, 1.47507519e-01f, 6.94454229e-03f,
  -3.45008597e-02f, -7.58572146e-02f, -4.57278192e-02f, 3.20812035e-03f, 8.62693191e-02f, 3.12097631e-02f, 1.72740303e-03f, 4.79657762e-02f, 1.05081260e-01f, 1.09475821e-01f,
  -1.61521118e-02f, -8.11100677e-02f, 4.55819592e-02f, -5.57486638e-02f, 2.10353937e-02f, -6.94805086e-02f, 3.13249044e-02f, -7.36148879e-02f, 5.22846729e-02f, 5.47832511e-02f,
  3.68421935e-02f, -2.43582919e-01f, -4.20935929e-01f, -4.16109473e-01f, -8.98965970e-02f, -6.02774680e-01f, -5.28534412e-01f, -2.08611786e-01f, 1.28519356e-01f, -3.50057818e-02f,
  -1.33948222e-01f, 1.30444512e-01f, 2.76807219e-01f, -3.99882376e-01f, -2.71073412e-02f, 1.77288353e-01f, -5.29950500e-01f, -1.54156610e-01f, 1.73415959e-01f, -3.08057547e-01f,
  -1.29754484e-01f, -2.26964593e-01f, -1.69992536e-01f, -8.63145217e-02f, -4.35167313e-01f, -1.51091963e-01f, -1.75119992e-02f, 2.91349646e-02f, -2.78111905e-01f, 2.13711755e-03f,
  -1.03602841e-01f, 1.19032264e-01f, -1.05940513e-01f, -3.87434661e-02f, -2.13164464e-01f, -4.54203300e-02f, -1.41975626e-01f, 1.24919429e-01f, 5.64472973e-02f, 2.78463662e-02f,
  3.91916223e-02f, 4.86888289e-02f, -6.50473535e-02f, 1.18848182e-01f, 1.35748880e-03f, 3.19500379e-02f, 2.24996312e-03f, -1.51476204e-01f, -1.01528782e-02f, 6.47639856e-02f,
  -2.20321584e-02f, -8.32577348e-02f, -1.47011369e-01f, 3.83007862e-02f, -6.89904392e-02f, -6.69154897e-02f, -4.80637029e-02f, -5.76320989e-03f, -1.34003460e-01f, -4.96436879e-02f,
  -1.94794703e-02f, 4.64444980e-02f, -9.87398252e-02f, -6.95481598e-02f, -3.64475548e-02f, -1.22701814e-02f, 7.07880333e-02f, 1.05752394e-01f, -2.77221948e-02f, 2.99906991e-02f,
  -2.16408260e-02f, 4.54592891e-02f, 1.88303441e-02f, -7.50002116e-02f, 3.63941044e-02f, 1.00854911e-01f, 4.43821624e-02f, 2.17499100e-02f, -1.26343608e-01f, 3.81498672e-02f,
  4.80403341e-02f, -2.55769379e-02f, 4.32384573e-02f, -3.10244858e-02f, -6.84877560e-02f, 1.28968144e-02f, -2.67821327e-02f, 6.44196989e-03f, -4.78407517e-02f, -2.43252050e-02f,
  -1.38724357e-01f, -1.86673045e-01f, 2.27851868e-02f, 4.86377701e-02f, 4.79678027e-02f, -9.88568589e-02f, -5.04567437e-02f, -6.46926463e-02f, -1.30896300e-01f, -4.81878966e-02f,
  -7.56401792e-02f, 5.19134663e-02f, -1.22810058e-01f, 4.39915759e-03f, 3.32266614e-02f, -1.10908844e-01f, 8.19802936e-03f, 5.04120439e-02f, -8.66831094e-02f, -1.28793657e-01f,
  -1.49044050e-02f, 1.05577111e-01f, 1.55153319e-01f, 1.95283405e-02f, 1.05069846e-01f, 4.58694585e-02f, 5.16361445e-02f, 4.55798395e-02f, 4.74831350e-02f, 1.37411486e-02f,
  -4.30780947e-01f, 4.65258777e-01f, 1.19022854e-01f, -2.04795375e-01f, -6.44555723e-04f, -5.64889789e-01f, -1.95784286e-01f, 3.03424418e-01f, -1.73057631e-01f, 2.64942765e-01f,
  -2.59228069e-02f, -7.94462636e-02f, 1.67381570e-01f, -2.73192674e-01f, -6.69787109e-01f, -2.78583288e-01f, -3.75571311e-01f, -1.37121573e-01f, -1.49766922e-01f, 5.29349297e-02f,
  -1.54603183e-01f, -1.28351331e-01f, -3.02414060e-01f, 2.06202760e-01f, 2.09819917e-02f, 3.42145681e-01f, 2.71534711e-01f, 3.44245017e-01f, 8.31055790e-02f, -9.28056762e-02f,
  -9.81478095e-02f, 1.42753139e-01f, 1.29002184e-01f, -1.09463088e-01f, -1.86256301e-02f, 1.16168112e-02f, 1.40439183e-01f, 4.23045643e-02f, -5.66294640e-02f, -3.52056734e-02f,
  6.65285066e-02f, 4.26951535e-02f, -5.74114965e-03f, 7.34020472e-02f, -4.41595167e-02f, 5.04884087e-02f, 8.58873948e-02f, -1.85890263e-03f, -4.44559567e-02f, -4.68195975e-02f,
  3.02098431e-02f, -5.47391213e-02f, -5.91053069e-02f, -6.95176050e-02f, 4.21833321e-02f, -4.93088290e-02f, -8.49201754e-02f, 1.89425237e-02f, 2.86660921e-02f, -2.85398010e-02f,
  3.13709974e-02f, -9.72748101e-02f, -1.08237185e-01f, -6.92366511e-02f, -4.13130671e-02f, 5.38683124e-02f, -2.39433534e-02f, -8.28131568e-03f, 5.33878244e-02f, -1.17377834e-02f,
  -1.17328046e-02f, -1.16377231e-02f, -9.77608785e-02f, -1.05463434e-03f, 2.74899825e-02f, -5.70978671e-02f, 6.81458414e-02f, 5.10862581e-02f, -6.45675659e-02f, -1.16055952e-02f,
  5.84882572e-02f, -7.17946962e-02f, 1.48853529e-02f, 2.53333393e-02f, -1.45120367e-01f, 5.94944023e-02f, 2.78052967e-02f, -3.96493264e-02f, -3.77823412e-02f, 3.63594815e-02f,
  -1.87887773e-02f, 3.55956882e-01f, -4.25406639e-03f, -3.59044895e-02f, 5.23903929e-02f, -8.33358541e-02f, -7.13428706e-02f, 1.63027644e-02f, 5.27058616e-02f, -1.52299739e-02f,
  9.25949216e-02f, -5.07377498e-02f, -2.77653486e-02f, -8.84456336e-02f, -7.80536421e-03f, 3.80124077e-02f, 9.75437239e-02f, 1.12908869e-03f, 6.96910620e-02f, 2.53654774e-02f,
  1.89652860e-01f, 2.78270952e-02f, -4.80131656e-02f, -4.51658182e-02f, 3.91101763e-02f, 2.52333749e-02f, -2.34039184e-02f, 1.02091156e-01f, 5.14642932e-02f, 3.70774791e-02f,
  5.39898276e-01f, 8.82866010e-02f, -7.49730617e-02f, -4.30199429e-02f, -2.47017950e-01f, -3.96735042e-01f, -3.77323925e-01f, 6.41631112e-02f, -1.71107948e-01f, -1.22046083e-01f,
  -6.20315224e-02f, -1.37775868e-01f, 1.30435362e-01f, -1.91721559e-01f, 8.86616334e-02f, 8.28833580e-02f, -1.81475058e-02f, -1.68150887e-01f, 2.15600029e-01f, 2.90009737e-01f,
  2.14877501e-01f, -4.61847484e-02f, 1.22664310e-01f, 1.04991570e-01f, 9.22881532e-04f, 2.42070302e-01f, 3.70165050e-01f, -4.18615080e-02f, -6.90132845e-03f, -1.08712830e-01f,
  -9.18460041e-02f, 7.46838609e-03f, -5.08803353e-02f, -8.21035132e-02f, 1.01283953e-01f, -2.01002844e-02f, -3.10733616e-02f, -1.02400884e-01f, -2.46389844e-02f, -1.01126164e-01f,
  -3.90979722e-02f, 4.50404324e-02f, -1.16368547e-01f, -7.16230422e-02f, -6.63654879e-02f, -1.02177836e-01f, -3.97471525e-02f, -1.24235958e-01f, -1.25683323e-01f, 1.59296155e-01f,
  2.98191011e-02f, -1.66539513e-02f, -8.22575111e-03f, -9.76427048e-02f, -3.24885324e-02f, -8.79368186e-02f, -1.07193068e-02f, 6.47670496e-03f, -5.57635864e-03f, 1.46861523e-01f,
  1.20749898e-01f, 3.15016955e-02f, 4.97352555e-02f, -9.47006419e-03f, 2.73388866e-02f, 2.64946632e-02f, -5.22947051e-02f, -1.10686168e-01f, 8.45669881e-02f, -7.42601529e-02f,
  2.70496076e-03f, 4.00057025e-02f, 9.18333158e-02f, 1.98490992e-02f, 1.04198031e-01f, 7.12658837e-02f, -5.35719916e-02f, -4.53575402e-02f, -1.83568094e-02f, -1.23325653e-01f,
  -2.67045554e-02f, -1.55458050e-02f, -1.07604712e-01f, -1.89849641e-02f, -3.57923284e-02f, 4.73430473e-03f, 4.91073132e-02f, 2.97100451e-02f, 8.77996534e-02f, 7.09398165e-02f,
  6.08566590e-02f, 2.93965667e-01f, -4.47454639e-02f, -1.49770886e-01f, 1.15079591e-02f, 1.00468725e-01f, -5.85863646e-03f, 1.43071618e-02f, 9.30691436e-02f, 8.05780068e-02f,
  4.76535317e-03f, -1.36929482e-01f, 3.76463346e-02f, 2.43155900e-02f, -1.35297045e-01f, 6.04154132e-02f, 6.58171698e-02f, 2.19119787e-02f, -6.80849031e-02f, 1.42135084e-01f,
  7.67810717e-02f, -6.13268726e-02f, -1.27188209e-02f, -1.34161681e-01f, -7.45741576e-02f, -1.10453151e-01f, -1.84812155e-02f, 7.33945072e-02f, 2.79643908e-02f, -5.56582548e-02f,
  -7.14159250e-01f, 2.74030734e-02f, 5.49297869e-01f, -7.05764592e-01f, 1.37296319e-01f, 3.60798597e-01f, 2.82317251e-01f, -1.32255033e-01f, -3.98702562e-01f, -1.48710728e-01f,
  -6.68406412e-02f, -5.45459464e-02f, 4.20120597e-01f, -2.58073866e-01f, 4.46527630e-01f, 1.54218659e-01f, -2.88478076e-01f, -8.67064148e-02f, -2.22489075e-03f, -3.04960042e-01f,
  -8.40902254e-02f, -2.05625981e-01f, 2.04127491e-01f, -1.26154378e-01f, -1.05269134e-01f, -2.61007339e-01f, -2.71630615e-01f, 2.31826618e-01f, -1.62457556e-01f, 5.25581054e-02f,
  -2.41840303e-01f, -3.12334716e-01f, -9.84703079e-02f, -4.26380080e-04f, -4.51397076e-02f, 9.90069658e-02f, 1.26960520e-02f, 2.66043514e-01f, -1.23385698e-01f, -7.77621800e-03f,
  4.61093113e-02f, 9.23503339e-02f, -1.45499542e-01f, 9.44157597e-03f, -9.37171653e-02f, -1.14113605e-02f, 1.24040525e-02f, 4.81650271e-02f, -6.65385202e-02f, 1.59443006e-01f,
  1.48100048e-01f, 4.83103134e-02f, 1.22692958e-02f, -1.03996761e-01f, 6.35043308e-02f, -2.19711680e-02f, -5.02987877e-02f, 1.09799616e-01f, 2.50548183e-04f, -5.78739122e-02f,
  -4.25857306e-02f, 7.67085627e-02f, -5.01871705e-02f, -9.49761458e-03f, 1.16757475e-01f, -4.03219387e-02f, -7.13486820e-02f, 3.74116339e-02f, -2.94487737e-02f, 1.38510688e-04f,
  -6.71372414e-02f, -5.68917729e-02f, -2.51469240e-02f, -6.75291941e-02f, -1.45981275e-02f, -8.17900077e-02f, 4.34607826e-02f, 1.61631708e-03f, 3.51532102e-02f, 4.89141000e-03f,
  5.35617992e-02f, 1.13442585e-01f, 1.08597048e-01f, -7.95930699e-02f, 4.94250394e-02f, 6.95872903e-02f, -5.73190711e-02f, 1.05695374e-01f, -3.47112715e-02f, 8.43848214e-02f,
  -2.64301389e-01f, -3.51329595e-01f, -9.26412120e-02f, -1.50427014e-01f, -4.22980972e-02f, 1.37842186e-02f, -3.04107442e-02f, -6.39593378e-02f, -7.30281025e-02f, -5.64734265e-02f,
  -1.47889778e-01f, -1.22896127e-01f, 1.22526393e-03f, -8.79042409e-03f, 9.78687257e-02f, -2.61083022e-02f, -1.09671533e-01f, -1.30299538e-01f, -8.08172151e-02f, 4.36840253e-03f,
  -4.92999181e-02f, -8.00996646e-02f, 1.08155333e-01f, -7.95004442e-02f, -4.81172465e-02f, -8.26803967e-04f, -8.66271481e-02f, -4.39431630e-02f, 1.12264395e-01f, 9.93726701e-02f,
  6.67557865e-02f, -1.53233102e-02f, -5.44137836e-01f, 3.38290557e-02f, 2.99965113e-01f, 5.37123203e-01f, 1.31323993e-01f, -3.19955423e-02f, -2.74727255e-01f, 2.63938397e-01f,
  2.79050082e-01f, -3.15040290e-01f, -3.61629814e-01f, 2.63028979e-01f, -6.65254295e-02f, -2.43951187e-01f, 3.26818228e-01f, 2.18143195e-01f, -1.89838335e-01f, 1.09026670e-01f,
  -5.05042002e-02f, 4.94968891e-01f, -2.84575820e-01f, 1.96854964e-01f, 3.19620430e-01f, -1.35966137e-01f, 1.41396105e-01f, -2.99072266e-01f, 2.84155637e-01f, 9.24143717e-02f,
  1.54765695e-01f, -5.15944846e-02f, -8.46512169e-02f, -5.78534938e-02f, 6.03705011e-02f, 1.27323285e-01f, 9.14023593e-02f, -8.48582089e-02f, -6.38080537e-02f, -5.57815097e-02f,
  1.22676706e-02f, -6.28817752e-02f, -4.47613895e-02f, -3.70081700e-02f, 5.68215288e-02f, 2.93043796e-02f, -4.36164252e-02f, -7.51670524e-02f, -1.07362948e-01f, -2.87342854e-02f,
  -9.35954377e-02f, -2.13577189e-02f, 5.25698587e-02f, -8.99539217e-02f, -7.03943297e-02f, 9.04366467e-03f, -3.71787883e-03f, -4.26760949e-02f, 5.54716848e-02f, 3.65858302e-02f,
  8.03815424e-02f, 3.83262038e-02f, -3.26375142e-02f, -8.03245157e-02f, 4.41783220e-02f, -1.48143908e-02f, -5.77372266e-03f, 3.26854140e-02f, -1.07456483e-01f, 1.01741381e-01f,
  1.05227418e-02f, -1.73944905e-02f, 4.35496904e-02f, 1.16433062e-01f, 1.97539940e-01f, -3.35951224e-02f, 4.53287512e-02f, -5.46554569e-03f, 2.45505106e-02f, 5.97074395e-03f,
  -6.67187124e-02f, 8.45290646e-02f, 4.12921757e-02f, 1.75758302e-02f, 1.64080858e-02f, -6.32436797e-02f, 1.50607437e-01f, 3.48781496e-02f, -1.01064779e-01f, 3.68839912e-02f,
  1.14120945e-01f, 8.17442909e-02f, -8.13412294e-02f, -3.95864658e-02f, -7.24788904e-02f, 1.08774647e-01f, -9.51291770e-02f, 6.37838244e-02f, -3.28229344e-03f, 3.23059992e-03f,
  1.21890612e-01f, -5.69062307e-02f, 1.50163159e-01f, 3.29257012e-03f, 2.49912925e-02f, 1.33401006e-01f, 4.72297333e-02f, -2.73350403e-02f, 6.97869807e-02f, 1.66060235e-02f,
  1.31097794e-01f, 1.28679603e-01f, -2.28297338e-02f, 9.65109915e-02f, 1.56853259e-01f, 4.87777069e-02f, 4.01023217e-02f, 8.96638725e-03f, 9.55211148e-02f, -1.36839524e-01f,
  5.58259428e-01f, 5.16187489e-01f, 3.67301643e-01f, 3.76426339e-01f, -2.12813079e-01f, 4.41888779e-01f, 1.75323322e-01f, 1.38080105e-01f, 5.01516879e-01f, 1.29398361e-01f,
  -3.84323090e-01f, 5.14861166e-01f, -3.09409618e-01f, 2.52750784e-01f, -1.13925196e-01f, -1.14890985e-01f, 2.93822855e-01f, 2.55278081e-01f, 3.78192286e-03f, 2.64653742e-01f,
  2.80243363e-02f, -3.58715385e-01f, -2.25961283e-01f, -2.06309497e-01f, -4.44793887e-02f, 1.00266762e-01f, -5.19478142e-01f, -2.58174598e-01f, -7.97216669e-02f, -1.94170907e-01f,
  -7.49962330e-02f, 1.91309936e-02f, -3.25006992e-02f, 4.18381914e-02f, -2.87699644e-02f, 6.87103942e-02f, 3.24256271e-02f, -7.52525851e-02f, -9.14338604e-02f, 6.19796775e-02f,
  8.61268193e-02f, 3.75269875e-02f, 1.00084834e-01f, -5.24369366e-02f, 3.12201418e-02f, 4.17598784e-02f, 2.57900022e-02f, 4.79377899e-03f, 1.60621423e-02f, -5.44415936e-02f,
  1.83549877e-02f, 4.92998064e-02f, 6.36855662e-02f, 3.05236764e-02f, 5.07370643e-02f, 3.50296684e-02f, 8.90232399e-02f, -3.12588997e-02f, 8.74164179e-02f, 1.34905323e-01f,
  3.11458693e-03f, 7.03325346e-02f, -7.56632611e-02f, -8.59414041e-02f, 5.32490872e-02f, -6.58330843e-02f, -3.28214578e-02f, -8.85165632e-02f, 1.13472126e-01f, -3.05371657e-02f,
  6.63502514e-02f, -9.71405767e-03f, -2.10506544e-02f, 6.37638867e-02f, 5.29236160e-02f, 1.40049532e-02f, 4.57735099e-02f, 3.31767015e-02f, 6.06666617e-02f, -4.31310944e-02f,
  -6.70410842e-02f, 7.23171309e-02f, -9.48239043e-02f, -4.88496423e-02f, -5.53152673e-02f, -4.78615947e-02f, -2.24505980e-02f, 1.35319039e-01f, -1.18231043e-01f, 1.07311904e-02f,
  1.31531924e-01f, 3.77122194e-01f, 1.04374113e-02f, -2.78399028e-02f, 1.50080360e-02f, -1.84351392e-02f, 5.71293607e-02f, 1.26030177e-01f, 8.50725453e-03f, 4.52881726e-03f,
  8.27420950e-02f, 5.66505566e-02f, 4.44989614e-02f, -2.51569482e-03f, 3.23774852e-02f, 4.99948338e-02f, 2.04500128e-02f, 9.66478214e-02f, 4.96331863e-02f, 5.73706292e-02f,
  7.86017999e-02f, 5.04435860e-02f, 5.07839806e-02f, -2.94144917e-02f, 1.16525829e-01f, -4.58771698e-02f, 9.09919068e-02f, 6.35694340e-02f, -2.10718419e-02f, 3.26318257e-02f,
  -8.53564024e-01f, -7.33282119e-02f, -6.47702143e-02f, 3.61306012e-01f, -3.39958906e-01f, 2.35902369e-01f, 3.40157211e-01f, 2.31292285e-03f, 2.96159297e-01f, 2.87824899e-01f,
  8.90599638e-02f, -2.05383480e-01f, -2.06486117e-02f, 5.04129469e-01f, -1.27871670e-02f, 3.88433844e-01f, 4.74703014e-01f, 2.45382413e-01f, -3.76895443e-03f, -1.51577309e-01f,
  2.53374632e-02f, 6.81837499e-02f, 1.13101482e-01f, -1.55756548e-01f, -1.64675653e-01f, -2.59941697e-01f, -5.86446933e-02f, -2.81787276e-01f, 2.18730047e-02f, -5.48197292e-02f,
  -4.31587435e-02f, -1.10756218e-01f, -3.21474522e-02f, -2.54595019e-02f, -2.26354487e-02f, -1.03362128e-01f, 1.59242749e-02f, -9.29713845e-02f, -8.21736157e-02f, -5.88412099e-02f,
  -9.98522788e-02f, -9.07928273e-02f, 1.50040776e-01f, -5.35494834e-02f, -6.60474300e-02f, 2.57391785e-03f, 1.45598990e-03f, 9.43247974e-02f, -8.61610007e-03f, -1.60824955e-02f,
  1.54569149e-02f, 7.80159384e-02f, 1.32456332e-01f, 1.03373200e-01f, 8.65316764e-03f, 6.69048578e-02f, 1.13722302e-01f, -9.91499498e-02f, 5.18506160e-03f, 1.38486158e-02f,
  1.19717736e-02f, -7.71317035e-02f, -4.51563857e-02f, -3.89676169e-02f, -5.03956573e-03f, 8.08436051e-02f, 2.20979489e-02f, 4.48011719e-02f, -2.22652145e-02f, 4.00112122e-02f,
  5.10325618e-02f, -3.72589082e-02f, -4.15053889e-02f, 7.24048615e-02f, 6.42231703e-02f, 4.74488586e-02f, -4.03735749e-02f, 6.06080964e-02f, 8.31197277e-02f, 6.24511838e-02f,
  -1.04529457e-02f, 2.32634284e-02f, 4.70799906e-03f, 3.84157500e-03f, -3.54104973e-02f, -8.27660337e-02f, -2.13487558e-02f, 7.94800371e-02f, 5.37883639e-02f, -8.32248926e-02f,
  -3.11080903e-01f, -2.31643692e-01f, 2.84635220e-02f, 1.46141704e-02f, 1.81825981e-02f, -6.65056631e-02f, -1.63892582e-02f, 2.57872418e-02f, -1.99604705e-02f, 7.21651595e-03f,
  1.67207583e-03f, 7.63006359e-02f, -1.65970072e-01f, 8.95380136e-03f, 4.86461781e-02f, 7.19916597e-02f, -2.60948227e-03f, 1.34142321e-02f, 8.65991637e-02f, -6.71880022e-02f,
  1.94564462e-02f, -8.48937929e-02f, 2.49637887e-02f, -3.92416157e-02f, 1.18468411e-01f, -7.89229758e-03f, -5.93280122e-02f, 1.55097721e-02f, 1.04067696e-03f, 1.23262972e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.61031112e-01f, -1.49758961e-02f, 5.59473455e-01f, 7.98015296e-02f, 2.58330017e-01f, 3.67066085e-01f, 5.47754765e-01f, 3.58105212e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.85675561e-01f, 1.00830883e-01f, 4.52464074e-02f, 5.33278883e-01f, -4.17228162e-01f, 1.91338047e-01f, -2.51352251e-01f, 4.96522412e-02f, -2.65505791e-01f, 3.20384814e-03f,
  -3.84836614e-01f, 1.98980987e-01f, 2.59397447e-01f, -2.56420761e-01f, -2.81113416e-01f, 3.92564446e-01f, 1.56859666e-01f, 8.30002055e-02f, 3.48527789e-01f, 2.14426382e-03f,
  -2.99977124e-01f, -2.13999003e-01f, 6.94061220e-02f, -1.51186902e-02f, 6.70181662e-02f, 3.13109428e-01f, -2.74321586e-01f, -1.48860216e-01f, 4.17647287e-02f, -3.10804129e-01f,
  1.72076330e-01f, -2.49899015e-01f, 2.04287574e-01f, 2.31405213e-01f, 1.78683013e-01f, -1.01405727e-02f, 5.18210381e-02f, 7.97839239e-02f, -9.40824002e-02f, -1.52912764e-02f,
  3.23550440e-02f, 6.91208392e-02f, -1.68878749e-01f, 1.95144415e-01f, 8.78478924e-04f, -1.43524840e-01f, -3.46900433e-01f, -1.75542817e-01f, -1.12285905e-01f, -1.96959153e-01f,
  -4.49433364e-02f, 3.88367593e-01f, 4.23040807e-01f, 2.42121518e-01f, 1.25340149e-01f, 6.02194443e-02f, -7.76494294e-02f, -6.76210597e-02f, 8.36462155e-02f, -3.52721304e-01f,
  -9.76364035e-03f, -1.93033099e-01f, 3.66234541e-01f, -2.39471540e-01f, 3.59402150e-02f, 2.83512343e-02f, -1.90001503e-01f, -3.35067242e-01f, 7.35004023e-02f, -2.17626303e-01f,
  -3.66860777e-02f, 9.82372537e-02f, -9.79109257e-02f, -2.97605917e-02f, -8.91349539e-02f, -4.20047283e-01f, 2.76387244e-01f, -2.35305399e-01f, -1.58727944e-01f, 1.10715218e-01f,
  1.89686790e-01f, 1.72208995e-01f, 1.96295604e-01f, -9.43940803e-02f, 1.13630176e-01f, 1.87808931e-01f, -2.49400720e-01f, 4.40818191e-01f, -2.44380981e-01f, 3.28923076e-01f,
  -6.61659520e-03f, -4.45297398e-02f, -2.63955712e-01f, -1.09221853e-01f, 1.08019195e-01f, 1.79309294e-01f, 1.73289120e-01f, 1.20852865e-01f, -4.86734658e-02f, -3.25443745e-01f,
  -1.38987303e-01f, 2.71944940e-01f, -5.17810695e-02f, -1.65404290e-01f, -1.79602072e-01f, 4.41277176e-02f, 2.53542960e-01f, 4.63385507e-02f, 1.85296722e-02f, -2.19918847e-01f,
  -3.64803553e-01f, 1.75243512e-01f, 2.09140062e-01f, 2.89465010e-01f, 4.52450484e-01f, 4.85483935e-04f, 6.11900277e-02f, 1.55594602e-01f, -2.43938297e-01f, 1.22170396e-01f,
  -2.13501722e-01f, -2.38505661e-01f, 2.68558234e-01f, -7.07951710e-02f, -9.33376849e-02f, -2.64973223e-01f, 1.52540371e-01f, -3.36078972e-01f, -2.18807459e-02f, 1.89228311e-01f,
  9.68731269e-02f, 2.90016264e-01f, 1.10580131e-01f, -4.21301186e-01f, -1.24765441e-01f, 7.33315721e-02f, 1.49935007e-01f, -4.16811183e-02f, 1.85209036e-01f, -1.85220227e-01f,
  3.97214293e-01f, -2.78177440e-01f, -2.12035611e-01f, -1.48839638e-01f, 9.62603763e-02f, -3.02766532e-01f, -2.88822711e-01f, 2.26816997e-01f, 2.83862233e-01f, 7.18335733e-02f,
  1.91609338e-01f, -1.72969624e-01f, -1.99701220e-01f, 2.77454019e-01f, -2.02943057e-01f, -1.30645499e-01f, 5.13770655e-02f, -1.43867224e-01f, 1.97625324e-01f, 1.13441668e-01f,
  -4.21657488e-02f, 2.40351602e-01f, 2.09860317e-02f, -1.19462945e-01f, -9.11111943e-03f, -1.85430929e-01f, -1.25860805e-02f, -1.40339574e-02f, -2.72167474e-02f, -9.71074328e-02f,
  3.27358395e-01f, 3.57261710e-02f, 2.08366796e-01f, -2.04774618e-01f, 8.24488401e-02f, -3.63656521e-01f, 3.92674059e-01f, -3.22032392e-01f, -1.62885502e-01f, 1.21015562e-02f,
  4.66489732e-01f, 2.52729803e-01f, 1.42879188e-02f, 1.23474546e-01f, -2.37406358e-01f, 2.39375889e-01f, 2.94365019e-01f, -1.73791885e-01f, -5.89216612e-02f, 3.77017222e-02f,
  -6.16706572e-02f, -3.35861295e-02f, -1.72630802e-01f, 4.50319089e-02f, 1.41582382e-03f, -2.35867679e-01f, 2.57379651e-01f, -8.88040587e-02f, -4.10411432e-02f, -7.46990144e-02f,
  -2.45326012e-01f, 2.43208200e-01f, 1.21212520e-01f, -2.06947312e-01f, -3.06339025e-01f, -2.43208617e-01f, 2.52094030e-01f, 7.71214813e-02f, -2.42803976e-01f, 1.54945359e-01f,
  3.68827343e-01f, 7.90014025e-03f, -2.03068286e-01f, 2.41055682e-01f, -1.72049612e-01f, 5.53646535e-02f, 1.01657584e-01f, -2.10013032e-01f, 1.74221084e-01f, 6.60691336e-02f,
  2.22596765e-01f, -1.12394035e-01f, -4.03548509e-01f, 2.79550880e-01f, 3.50470990e-02f, -1.14710651e-01f, -3.85489017e-02f, -1.91692084e-01f, 2.35767141e-01f, 2.17821926e-01f,
  9.61555317e-02f, -1.38456017e-01f, 9.34877753e-05f, 1.61069676e-01f, -1.75816551e-01f, -3.06884944e-02f, -2.76706219e-01f, 3.81796882e-02f, -2.43744597e-01f, 2.56530970e-01f,
  -3.58587563e-01f, 3.17941427e-01f, 3.26604813e-01f, 1.46574408e-01f, -2.25557223e-01f, 1.27982125e-01f, 4.44803014e-02f, 6.17388897e-02f, 3.19560945e-01f, -3.68854165e-01f,
  -1.78979605e-01f, 9.01743248e-02f, -1.13537356e-01f, -1.64086178e-01f, 4.32820357e-02f, -4.71524373e-02f, -1.18496478e-01f, 8.71150717e-02f, -1.00308605e-01f, 8.96962136e-02f,
  -1.50385156e-01f, -2.41810068e-01f, -1.90169718e-02f, 1.78352132e-01f, -8.62596333e-02f, -1.64156348e-01f, -1.79929622e-02f, -3.31024267e-02f, 1.14557959e-01f, 9.04863179e-02f,
  4.02341485e-01f, -3.62534560e-02f, 2.45121077e-01f, -2.09216163e-01f, -5.15061140e-01f, -3.70463371e-01f, -7.36724287e-02f, -1.90891281e-01f, 1.92439258e-01f, -5.11524454e-02f,
  1.88372225e-01f, 2.65531361e-01f, 9.32167992e-02f, 2.58881122e-01f, -1.37771025e-01f, 1.96827173e-01f, -2.44267121e-01f, 2.08726749e-01f, 9.35908332e-02f, 9.04749781e-02f,
  -1.43547952e-02f, 4.32054520e-01f, -2.76147395e-01f, -2.62304228e-02f, -1.10046364e-01f, 2.01086581e-01f, -2.64117178e-02f, -2.47020684e-02f, -2.94506550e-01f, 1.63598612e-01f,
  2.94944614e-01f, 3.29739507e-03f, 3.74598354e-02f, 1.25024632e-01f, 1.38710961e-01f, -7.91922212e-02f, -2.70030081e-01f, -1.76909983e-01f, -2.34576821e-01f, -2.46374205e-01f,
  2.15083659e-01f, -1.34766936e-01f, 3.81971776e-01f, 3.08869213e-01f, -5.69907464e-02f, 9.16151628e-02f, -1.22240372e-01f, 3.30149829e-02f, 1.95916176e-01f, -7.95064569e-02f,
  6.79862574e-02f, -2.00944677e-01f, 1.04003452e-01f, -2.85128444e-01f, 3.01312506e-01f, 1.56656634e-02f, 1.72027186e-01f, -7.46356100e-02f, 2.61613071e-01f, 1.91228271e-01f,
  7.70495012e-02f, -2.31368542e-01f, -2.35430613e-01f, 2.28536114e-01f, -9.85475257e-02f, -1.62482947e-01f, -1.87340423e-01f, 2.44536642e-02f, 2.91720986e-01f, 2.33620197e-01f,
  2.18676642e-01f, 9.75470021e-02f, -1.78143427e-01f, 8.62639397e-02f, -3.51482183e-01f, -2.81169683e-01f, -4.73203175e-02f, -6.10850342e-02f, 2.74569038e-02f, 1.54898196e-01f,
  1.62225246e-01f, 2.67545938e-01f, 1.25077844e-01f, 2.38893777e-01f, 7.13824406e-02f, 4.20095295e-01f, 4.55540232e-02f, -1.77181929e-01f, -6.04004078e-02f, -2.68785153e-02f,
  2.01767385e-01f, -1.41405210e-01f, 8.99686739e-02f, 1.39982387e-01f, 3.89438897e-01f, -1.63455427e-01f, -3.54779780e-01f, -3.16468775e-01f, 1.90553829e-01f, -3.14741135e-01f,
  -2.83828527e-01f, 2.09723130e-01f, 3.58823210e-01f, 7.05672875e-02f, 1.78174660e-01f, -9.25336555e-02f, -1.93247929e-01f, 1.67226404e-01f, -1.17446721e-01f, -6.82428032e-02f,
  2.82335039e-02f, -2.45313987e-01f, 2.80528277e-01f, -1.08163759e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.86337692e-01f, -1.59425419e-02f, -2.76169151e-01f, -2.57846415e-01f, 5.30052006e-01f, 1.20720036e-01f, 4.90097702e-01f, 2.86096454e-01f, 8.05001378e-01f, -6.07665852e-02f,
  4.08970773e-01f, 1.88994110e-01f, 8.40483606e-02f, 2.45313928e-01f, -1.20405227e-01f, -2.46463194e-01f, 4.46100160e-02f, 4.96568769e-01f, 3.33227396e-01f, -2.75254041e-01f,
  4.60538238e-01f, 5.67065179e-01f, -2.83854991e-01f, 3.37117493e-01f, 1.84008136e-01f, -3.93740892e-01f, 2.04663500e-01f, 4.98826385e-01f, -4.86000985e-01f, 4.75768119e-01f,
  1.11468554e+00f, 1.86907545e-01f, 3.66057158e-01f, 3.14722568e-01f, 2.18615949e-01f, 6.69052899e-02f, -1.31437525e-01f, 1.70807779e-01f, 3.24564308e-01f, 2.41041228e-01f,
  2.27971807e-01f, 2.80240536e-01f, 7.18025029e-01f, 7.52705812e-01f, 9.82377306e-02f, 3.73126030e-01f, 3.92206520e-01f, -4.76092339e-01f, 5.38483739e-01f, -3.81172687e-01f,
  -6.13681793e-01f, -3.12697411e-01f, 3.57608408e-01f, -1.76220641e-01f, 2.05017582e-01f, -1.01734005e-01f, -1.74772784e-01f, 8.40765238e-01f, 1.07585990e+00f, 4.56639528e-01f,
  7.67738938e-01f, 4.15136188e-01f, -3.71370196e-01f, -3.23032379e-01f, 2.70842016e-01f, 2.55053770e-02f, -1.38176858e-01f, 6.28215075e-01f, 3.27058047e-01f, -4.93041486e-01f,
  2.31489018e-01f, 4.04775828e-01f, 5.09311914e-01f, 1.70084298e-01f, 1.44552276e-01f, -1.55540138e-01f, 6.27079725e-01f, -2.14852560e-02f, 9.58273038e-02f, -1.45976737e-01f,
  -1.80669948e-01f, -2.90606350e-01f, -7.27813005e-01f, -1.41915321e-01f, -4.37575489e-01f, -4.37005550e-01f, 5.85233092e-01f, -5.14581859e-01f, -1.32024303e-01f, 4.78559285e-01f,
  -7.98453152e-01f, 5.75409234e-01f, 2.59584218e-01f, 4.68501419e-01f, 5.63131422e-02f, 5.56119323e-01f, 2.40011290e-01f, -1.66178286e-01f, 9.99937579e-02f, -1.18435428e-01f,
  2.80584991e-01f, 7.04618871e-01f, 3.90392393e-01f, 2.79988766e-01f, 3.79119337e-01f, 3.13462853e-01f, -1.69190750e-01f, 2.53360242e-01f, -4.33958769e-01f, 6.86065674e-01f,
  3.42679828e-01f, 2.03620456e-02f, -1.06570005e-01f, 5.38662732e-01f, 5.03473938e-01f, -2.74326295e-01f, -2.83294916e-01f, -2.68622905e-01f, -1.53015479e-01f, 3.89341086e-01f,
  9.84283388e-01f, -1.86192825e-01f, 1.92270979e-01f, 2.41530448e-01f, -5.54105043e-01f, 7.00095594e-01f, 2.44808853e-01f, -8.29715952e-02f, -4.02382761e-02f, 1.84618786e-01f,
  1.08799033e-01f, 4.58391547e-01f, 3.53278100e-01f, -3.94372344e-01f, -8.73360559e-02f, 1.68756783e-01f, 2.54748136e-01f, 4.31444407e-01f, -4.07589018e-01f, -4.77649093e-01f,
  6.19339228e-01f, -2.48317376e-01f, 1.48710415e-01f, 5.03190458e-02f, -5.61920226e-01f, -8.15829784e-02f, -5.19533396e-01f, -1.55247217e-02f, -3.62046301e-01f, -5.72429895e-01f,
  5.24080336e-01f, -4.28927183e-01f, 2.06221908e-01f, -4.15771327e-04f, -5.27861416e-01f, -1.98290244e-01f, -3.90260518e-01f, 5.58974445e-01f, 4.88081783e-01f, 8.12989354e-01f,
  1.60783067e-01f, 5.63282847e-01f, 2.39518315e-01f, 9.27892029e-01f, -2.58265864e-02f, 3.45967352e-01f, 1.31440312e-01f, 2.63911597e-02f, -1.76007394e-02f, 2.00141892e-01f,
  4.08239752e-01f, 6.02527440e-01f, 3.88042778e-01f, -6.75695479e-01f, -8.53955925e-01f, 2.19918951e-01f, 4.79018033e-01f, -4.85978089e-03f, 3.30553204e-01f, 1.33194730e-01f,
  -2.94641227e-01f, 2.68160403e-01f, 2.98933625e-01f, -5.44621885e-01f, 8.64483774e-01f, 2.48134091e-01f, 3.49340290e-01f, 2.40780070e-01f, 9.33609009e-01f, -7.60744333e-01f,
  6.54368639e-01f, -5.30723035e-01f, 4.61725980e-01f, 1.02656931e-01f, -5.56028113e-02f, 5.58753550e-01f, -5.50294757e-01f, 5.38646281e-01f, 1.26972189e-02f, 2.77237922e-01f,
  -1.41007397e-02f, 3.09443951e-01f, 1.37110308e-01f, 5.70658207e-01f, 1.27028584e-01f, -1.19464196e-01f, -2.38738552e-01f, 9.63221729e-01f, -3.45641196e-01f, 4.41662341e-01f,
  5.74234784e-01f, -2.69314796e-01f, -8.99299145e-01f, -6.05572581e-01f, -6.31706743e-03f, -3.12154949e-01f, 1.44435540e-01f, 6.89751506e-01f, -4.09219265e-01f, 1.21172577e-01f,
  2.76208729e-01f, 2.15190798e-01f, 5.25069833e-01f, -3.31304103e-01f, 8.36824998e-02f, 5.17386079e-01f, 3.93857181e-01f, -2.33177319e-02f, 8.96157444e-01f, -3.05750787e-01f,
  3.51946115e-01f, -1.04779519e-01f, 3.75346959e-01f, 3.75045687e-01f, 5.96650302e-01f, -1.60147935e-01f, -3.79010201e-01f, -5.61693490e-01f, -6.97942078e-01f, -6.77776486e-02f,
  -7.40562201e-01f, -2.15514395e-02f, 2.47938052e-01f, 8.99366498e-01f, -1.48715362e-01f, 4.95682091e-01f, 3.61108273e-01f, -8.02403688e-02f, -1.85957834e-01f, -3.55389491e-02f,
  -5.18185377e-01f, 3.46834324e-02f, 8.46273065e-01f, -2.43484035e-01f, 1.01351477e-01f, 5.71376264e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.87965918e-01f, 4.58131790e-01f, 2.97533929e-01f, 3.50312054e-01f, 3.13376933e-01f, 3.28279465e-01f, 3.61562014e-01f, 5.38063765e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -2.71087676e-01f, -1.18848674e-01f, 2.14015797e-01f, -3.54459912e-01f, -3.02391380e-01f, 1.76192418e-01f, -5.38246557e-02f, -1.80254757e-01f, -2.61723161e-01f, 2.42380261e-01f,
  -2.37854123e-02f, 4.04508501e-01f, -4.35394406e-01f, -7.51669407e-01f, 1.49961993e-01f, 2.06810515e-02f, 4.56466258e-01f, 2.71364033e-01f, 3.62432718e-01f, -4.32845622e-01f,
  3.52783829e-01f, 6.39253482e-02f, 1.69291615e-01f, 3.07947267e-02f, -2.49785110e-01f, -2.20946312e-01f, 6.46132231e-01f, -7.20197082e-01f, 7.33981371e-01f, -8.22464347e-01f,
  -7.00816929e-01f, 2.93994248e-01f, -8.98578614e-02f, -4.05906975e-01f, -4.84254628e-01f, -4.96949166e-01f, 4.68213588e-01f, 5.23058362e-02f, -4.52129915e-02f, 4.37826306e-01f,
  -3.92824143e-01f, -4.01012033e-01f, 1.23088453e-02f, 1.83623865e-01f, -3.80813330e-01f, -1.97445527e-01f, 1.34853981e-02f, -2.75146723e-01f, -5.83379507e-01f, -4.66138899e-01f,
  -5.71523011e-01f, -3.33845556e-01f, 2.65004009e-01f, 3.55059475e-01f, -1.54619664e-01f, -6.66070819e-01f, 2.07693294e-01f, 1.33333787e-01f, 6.17811561e-01f, 1.50927320e-01f,
  2.13857517e-01f, -1.02746356e+00f, 4.27847922e-01f, -1.06592059e+00f, 3.38600278e-01f, 2.14703918e-01f, 1.72241211e-01f, -1.46394640e-01f, -5.91852665e-01f, -2.20964476e-01f,
  1.27029344e-01f, -3.31499040e-01f, 3.45196486e-01f, 4.39550489e-01f, 4.18531984e-01f, -4.57862109e-01f, -3.77737045e-01f, -4.54367459e-01f, -4.08495098e-01f, -7.33458281e-01f,
  -3.85797143e-01f, -5.51135719e-01f, 6.96256459e-01f, 6.43008113e-01f, 2.11293057e-01f, 3.07173580e-01f, 4.81673270e-01f, -8.30945522e-02f, 1.74996093e-01f, -9.99277890e-01f,
  -6.81963980e-01f, 8.35979879e-01f, 2.10445896e-02f, -7.82251120e-01f, -5.28883226e-02f, -5.70261657e-01f, 1.40954494e-01f, 8.55088681e-02f, 2.10482955e-01f, 2.86322951e-01f,
  1.34151876e-01f, -5.44237971e-01f, 2.68024951e-01f, -5.76326549e-01f, -2.61797100e-01f, 2.46800944e-01f, -2.28424311e-01f, 1.01470321e-01f, -5.45014679e-01f, 4.76038218e-01f,
  8.12313557e-02f, 1.03684440e-01f, 4.52915400e-01f, -2.11416200e-01f, -2.28850901e-01f, 1.08714560e-02f, 5.40037215e-01f, 5.31022489e-01f, -8.09491992e-01f, 4.65240657e-01f,
  -6.36530638e-01f, 7.87625015e-01f, -6.09064937e-01f, -7.96301603e-01f, -2.06188947e-01f, 3.07634175e-01f, -7.29307890e-01f, -5.91218472e-01f, -2.04403654e-01f, -2.18818977e-01f,
  -5.10673463e-01f, 9.02315453e-02f, -1.53054044e-01f, 3.29925567e-01f, 1.97931349e-01f, 4.18447256e-01f, 5.17574251e-01f, 2.24326804e-01f, 1.44504011e-01f, -3.30174595e-01f,
  -3.77202213e-01f, 4.66499627e-01f, -4.30439502e-01f, -4.69887465e-01f, 3.27855140e-01f, 7.90890217e-01f, 9.24537778e-02f, -6.54926062e-01f, -4.01259273e-01f, -3.79992843e-01f,
  4.25440878e-01f, 3.04939002e-01f, -1.88666940e-01f, 2.88230538e-01f, 9.41342935e-02f, -7.35851109e-01f, -4.96174276e-01f, 4.82172996e-01f, -1.07020128e+00f, 7.38592684e-01f,
  2.41161659e-01f, 1.49019333e-02f, 2.30768353e-01f, 2.65600652e-01f, -5.94109073e-02f, 3.25247608e-02f, -1.27766162e-01f, 6.63049966e-02f, 4.17477667e-01f, -4.25612211e-01f,
  1.86552554e-01f, -8.83576721e-02f, 7.17518330e-01f, 8.08921039e-01f, -9.56493840e-02f, -5.61757743e-01f, 4.26891088e-01f, -2.95705914e-01f, -7.87939966e-01f, 4.20175157e-02f,
  -3.13531101e-01f, 2.43115649e-01f, 7.70949498e-02f, 5.54571688e-01f, -1.88639045e-01f, -7.74907231e-01f, 1.70685887e-01f, -1.12551674e-01f, 6.28370106e-01f, 3.05828989e-01f,
  3.26421320e-01f, 6.69216663e-02f, -3.80431302e-02f, 1.97537705e-01f, 2.65458733e-01f, 1.23194121e-01f, 3.88355345e-01f, 3.60083669e-01f, 3.37184310e-01f, -6.89589456e-02f,
  -3.89188007e-02f, 1.69758424e-01f, -2.64593691e-01f, 4.23904568e-01f, -6.82384491e-01f, 5.32768130e-01f, 9.16892052e-01f, 7.27483332e-01f, -2.07690716e-01f, -7.17833042e-02f,
  5.08199275e-01f, 5.91810405e-01f, -5.06358147e-01f, -6.99393034e-01f, 4.41056013e-01f, -3.59617144e-01f, 7.65999615e-01f, -6.83105767e-01f, -4.12188590e-01f, 4.44484651e-02f,
  -3.32008064e-01f, -3.21940690e-01f, -4.52932388e-01f, 5.19195020e-01f, -4.33216006e-01f, 1.74283478e-02f, -2.26113662e-01f, -2.13296548e-01f, -1.21059649e-01f, -2.96667032e-02f,
  6.51397416e-03f, -2.72897601e-01f, -2.71916240e-01f, -5.22225559e-01f, -5.07300973e-01f, -2.23418958e-02f, 5.02463818e-01f, -5.09186566e-01f, 5.57945251e-01f, -9.12096575e-02f,
  1.01696476e-01f, 5.58318436e-01f, -3.62944692e-01f, 8.24044496e-02f, 1.58154711e-01f, 7.42835253e-02f, -3.03756505e-01f, 1.53953537e-01f, -6.84442163e-01f, 2.70939022e-01f,
  2.87774175e-01f, -3.44567090e-01f, -4.59849030e-01f, 3.00219387e-01f, 6.21256530e-01f, -1.61893725e-01f, -2.89743934e-02f, -2.67570555e-01f, -5.52495182e-01f, 2.89061159e-01f,
  -4.34808493e-01f, -1.23885460e-02f, -5.81668653e-02f, -3.06726724e-01f, -3.71070296e-01f, -3.77717316e-01f, -6.43504679e-01f, -2.68508077e-01f, -2.24730484e-02f, -4.15243447e-01f,
  -2.48528555e-01f, -2.14785039e-02f, -1.33793294e-01f, -2.52841175e-01f, 1.94524661e-01f, 2.77810633e-01f, 5.42484522e-01f, 5.13180085e-02f, -6.38592482e-01f, -4.19428974e-01f,
  1.95107698e-01f, -1.58555761e-01f, -4.02588487e-01f, 3.84696484e-01f, -5.43820024e-01f, 7.72484839e-01f, -1.12177581e-01f, -5.99811018e-01f, 2.30901957e-01f, 2.77707279e-01f,
  -1.03095453e-03f, 3.36975217e-01f, 1.85375839e-01f, -2.56170928e-02f, -5.16784012e-01f, 2.89823979e-01f, -9.62564498e-02f, 8.90058205e-02f, 1.00825444e-01f, 2.00878531e-01f,
  5.68525851e-01f, -1.01910591e-01f, -6.22444570e-01f, 4.19586241e-01f, -3.85030895e-01f, -6.50689960e-01f, 3.74795645e-01f, 4.58351165e-01f, -4.17474270e-01f, -4.44449127e-01f,
  2.25801811e-01f, -8.05723488e-01f, -1.19057894e+00f, -2.53767759e-01f, -3.98668766e-01f, -3.49898428e-01f, -5.32876134e-01f, 4.74036098e-01f, 7.75828779e-01f, 4.88632351e-01f,
  -3.58155817e-01f, 2.26044253e-01f, -5.25783934e-02f, 2.28680283e-01f, -2.10434824e-01f, -1.56922907e-01f, 1.89923421e-02f, 2.21476182e-01f, 2.21438020e-01f, 1.85131818e-01f,
  1.91973597e-01f, 2.61795431e-01f, 2.45292172e-01f, -6.82235882e-02f, -1.79863870e-01f, 2.30079919e-01f, -4.32770908e-01f, 7.56144524e-01f, -2.46379837e-01f, -7.37803876e-01f,
  4.10678923e-01f, -2.29132518e-01f, 4.44641471e-01f, -3.05791706e-01f, 4.10019428e-01f, 5.96299410e-01f, -6.51783943e-01f, 4.58497077e-01f, -4.95051980e-01f, -8.13034594e-01f,
  -7.38187909e-01f, -5.69588244e-01f, 1.26169086e-01f, -2.26942360e-01f, 8.59971121e-02f, -4.93717194e-01f, 2.21232742e-01f, 6.65174201e-02f, -7.89543316e-02f, 4.80003744e-01f,
  4.53891233e-02f, 2.82756954e-01f, 2.23534897e-01f, -2.66912699e-01f, 6.15072370e-01f, 4.08136547e-01f, 5.09290814e-01f, 5.60096502e-01f, 3.50670367e-01f, 4.55912352e-01f,
  -6.26267016e-01f, -4.96511132e-01f, -6.01635218e-01f, 2.88168281e-01f, -2.79081557e-02f, 6.83793426e-01f, 6.39681697e-01f, -3.10916305e-01f, -8.70766819e-01f, -2.29573950e-01f,
  -6.40570402e-01f, 7.30308652e-01f, 2.42869437e-01f, -7.78389096e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -6.79591745e-02f, -2.20037121e-02f, 3.76932651e-01f, 1.70065746e-01f, -6.67791739e-02f, -1.18477084e-01f, 2.09768921e-01f, -1.46563694e-01f, -1.04877248e-01f, -6.12076484e-02f,
  5.37680052e-02f, 2.44201086e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    