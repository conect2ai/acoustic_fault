/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.06782818e-01f, -1.79388419e-01f, 2.48427004e-01f, 3.88183855e-02f, -3.37074161e-01f, 4.68059443e-04f, 2.70564973e-01f, 9.01496932e-02f, -9.01239738e-02f, -4.28840518e-02f,
  -1.09211102e-01f, -3.22881415e-02f, 1.37179911e-01f, -4.93025891e-02f, 2.01110482e-01f, 8.60740691e-02f, -1.08838342e-02f, 1.45847484e-01f, 2.20916659e-01f, -5.33332191e-02f,
  -2.07333148e-01f, 6.09632321e-02f, 6.47928640e-02f, 2.36849170e-02f, -2.15002984e-01f, 3.86587866e-02f, -7.21889585e-02f, -2.18086302e-01f, -2.07168892e-01f, -2.34733120e-01f,
  -4.13843803e-02f, -3.94316576e-02f, 8.61030445e-02f, 8.78044590e-03f, -9.53611657e-02f, 4.21059318e-02f, 7.95428753e-02f, 2.32804865e-02f, 1.10781798e-02f, -3.38796116e-02f,
  -4.33886722e-02f, -2.13146862e-02f, 1.40149903e-03f, -9.63654593e-02f, -6.27224445e-02f, -7.62345940e-02f, 1.04106115e-02f, 1.63678363e-01f, 1.31981865e-01f, -2.60942499e-03f,
  -4.81403358e-02f, -1.73782110e-01f, -8.17297772e-02f, -2.99347863e-02f, 4.69638892e-02f, 1.61711909e-02f, -9.40942988e-02f, -2.06239615e-02f, 5.52632995e-02f, -9.60116312e-02f,
  1.08174784e-02f, 3.89094464e-02f, 4.51816712e-03f, -7.94789344e-02f, 5.99375404e-02f, 1.21183209e-01f, -1.34424837e-02f, 1.82647035e-02f, 2.58568656e-02f, 4.15581726e-02f,
  -8.97808187e-03f, 5.95529377e-02f, 1.09773785e-01f, 1.18092364e-02f, -3.07332594e-02f, -5.54304719e-02f, 2.11543646e-02f, 2.94977636e-03f, -4.99358699e-02f, 2.07329374e-02f,
  5.98504534e-03f, -2.01794058e-02f, 3.77387702e-02f, -1.73826944e-02f, -8.40281174e-02f, -3.84923816e-02f, -4.81531061e-02f, -4.49123830e-02f, -1.05821742e-02f, -8.98023881e-03f,
  1.31269962e-01f, 1.20353056e-02f, 5.75692393e-02f, 2.26546805e-02f, -3.40402499e-02f, 2.63862982e-02f, -8.43466222e-02f, -7.83245713e-02f, -4.74869497e-02f, -7.19363615e-02f,
  -3.58408950e-02f, 1.19905308e-01f, -6.88343495e-03f, -9.14377347e-02f, -1.63260456e-02f, -1.50017276e-01f, -9.58485901e-02f, -1.09254131e-02f, -5.92575921e-03f, -1.59722939e-01f,
  4.52638939e-02f, 9.62909311e-02f, 1.67088196e-01f, 8.64768494e-03f, 3.15781645e-02f, 4.80616689e-02f, 9.20811761e-03f, 2.20761984e-03f, 1.66651338e-01f, 2.05035329e-01f,
  8.44356179e-01f, 1.07068224e-02f, 1.66850477e-01f, 6.40533328e-01f, 9.53722596e-02f, -2.07535371e-01f, -2.54073590e-01f, -9.95755196e-02f, 3.98350731e-02f, 3.49208862e-02f,
  -1.46737009e-01f, -8.73240381e-02f, 1.74038776e-03f, -2.18919963e-01f, -1.56781241e-01f, 7.33372476e-03f, 1.89998493e-01f, 1.17406860e-01f, -1.15382209e-01f, -7.25420937e-02f,
  -5.97285405e-02f, 4.45196003e-01f, 3.28627020e-01f, 7.58547708e-02f, 2.21250698e-01f, -1.91082302e-02f, 7.89871365e-02f, 8.21495205e-02f, -1.62723884e-01f, 4.34880644e-01f,
  1.11097135e-01f, 7.66685456e-02f, -7.19748810e-02f, 2.95924582e-02f, -2.62025353e-02f, -2.37424038e-02f, 1.47811451e-03f, 5.54820225e-02f, 1.60449129e-02f, 6.37252331e-02f,
  -2.40159202e-02f, -1.18259035e-01f, 1.14871144e-01f, -6.44643381e-02f, 4.23850454e-02f, -6.02005273e-02f, 2.27457713e-02f, 5.60426116e-02f, -4.61109448e-04f, -8.68309960e-02f,
  2.75657541e-04f, 2.26372126e-02f, -1.70590859e-02f, -3.85575034e-02f, -1.01711661e-01f, 8.18533674e-02f, -9.85547528e-02f, 1.23438016e-02f, -8.80597457e-02f, 2.50755638e-01f,
  -9.26008169e-03f, 6.90333620e-02f, 8.48927349e-03f, 4.35737260e-02f, -4.13712934e-02f, 4.74923216e-02f, 2.39356793e-02f, 2.97107622e-02f, -3.36065255e-02f, 7.71455020e-02f,
  -2.78396402e-02f, -6.91420063e-02f, -3.87617643e-03f, -9.60382808e-04f, -6.75737811e-03f, 4.22213599e-02f, -2.21716911e-02f, 7.64107332e-02f, -7.98396245e-02f, 1.96893513e-02f,
  1.88414138e-02f, -8.47653747e-02f, 6.27175644e-02f, -1.92007255e-02f, -8.15765001e-04f, 2.74109747e-02f, -2.08177231e-02f, -8.86168703e-02f, 8.59922543e-02f, 2.06709336e-02f,
  -8.83480441e-03f, -3.07916343e-01f, 1.34036481e-01f, -7.93975294e-02f, 1.20008253e-01f, -6.72568567e-03f, 9.59282592e-02f, -6.21545734e-03f, 1.41786300e-02f, 2.38214154e-02f,
  -2.45820247e-02f, 5.71867451e-02f, 8.03675968e-03f, 3.44314538e-02f, -2.88357157e-02f, -8.66115838e-02f, -2.20250469e-02f, -4.57732119e-02f, -1.03102498e-01f, 7.40739033e-02f,
  -6.28640037e-03f, -5.40987961e-02f, 4.93927822e-02f, -6.22062124e-02f, -3.36252106e-03f, 2.42866296e-02f, -5.98884700e-03f, -1.80028006e-02f, -1.04396507e-01f, 7.05506746e-03f,
  -7.50623271e-02f, 1.32853374e-01f, 2.03244612e-01f, 1.79584756e-01f, 6.82741180e-02f, 5.01305051e-02f, -1.15549356e-01f, -1.47408411e-01f, -1.89784300e-02f, 1.48922414e-01f,
  1.49451926e-01f, 1.27592489e-01f, 2.74410874e-01f, 5.91401272e-02f, -2.08770171e-01f, -1.24836050e-03f, -7.26310760e-02f, 5.20301098e-03f, 3.01967077e-02f, -2.43975386e-01f,
  -8.10845941e-02f, 3.50217856e-02f, -4.72607091e-02f, 6.52524605e-02f, -8.28409195e-02f, 4.29534703e-01f, 2.35830784e-01f, 8.24358910e-02f, -4.27743793e-02f, -1.20376274e-01f,
  2.37554967e-01f, -1.62581891e-01f, -8.05281848e-02f, 4.29233909e-02f, 5.75426295e-02f, -1.31949455e-01f, -3.80639806e-02f, -1.03388883e-01f, 1.12723717e-02f, -7.56692067e-02f,
  -1.28910560e-02f, -9.93049443e-02f, -4.17587161e-03f, 2.54406687e-02f, 2.03288738e-02f, -3.01011950e-02f, -5.20917736e-02f, -1.32457286e-01f, -2.61523132e-03f, 1.17605301e-02f,
  5.00007831e-02f, -6.97463974e-02f, -8.60402510e-02f, -2.41363905e-02f, -9.81117487e-02f, 2.03979202e-02f, 2.10241191e-02f, -1.18860886e-01f, -9.80908889e-03f, -2.45300923e-02f,
  -3.18717062e-02f, -1.43305296e-02f, -2.40713800e-03f, -1.29066082e-02f, 1.77430846e-02f, 1.94670670e-02f, -4.77852114e-02f, 4.58949469e-02f, -1.40412521e-04f, 3.31952013e-02f,
  5.56093268e-02f, 4.88785729e-02f, 6.63590897e-03f, 6.51641469e-03f, 7.62183145e-02f, 5.87503007e-03f, 6.77815033e-03f, -1.09040085e-02f, 2.35744175e-02f, -1.02287747e-01f,
  -3.38429436e-02f, -4.38970625e-02f, 7.19604269e-02f, -8.05674028e-03f, -1.70059223e-02f, -3.75217758e-02f, -8.99521261e-03f, -3.56677882e-02f, 5.06251045e-02f, -9.55234990e-02f,
  1.81003466e-01f, -8.78802389e-02f, 1.37183711e-01f, -6.29483759e-02f, -1.80469349e-03f, 3.93572822e-02f, 1.71121091e-01f, -2.66361572e-02f, 1.86749641e-02f, -4.27015163e-02f,
  -9.53500345e-02f, 3.88360247e-02f, 9.82902125e-02f, 1.00502977e-02f, 4.29214947e-02f, 2.43121199e-02f, 6.27447516e-02f, 6.26523122e-02f, -2.37826779e-02f, -2.32279431e-02f,
  4.94964793e-03f, -4.36952412e-02f, 1.81150977e-02f, 4.92212698e-02f, 8.23275186e-03f, 5.56385815e-02f, 9.49510857e-02f, 2.52462979e-02f, -6.26440123e-02f, 2.89543688e-01f,
  4.28327881e-02f, 3.35375488e-01f, 2.33776629e-01f, -1.40321150e-01f, 2.37557478e-02f, -6.10080697e-02f, 1.60945505e-01f, -6.68452159e-02f, -1.68467984e-01f, 1.43373564e-01f,
  1.21365879e-02f, -2.68884420e-01f, -2.05532879e-01f, -9.81657431e-02f, -1.85853653e-02f, 1.17472574e-01f, 1.43486068e-01f, -1.36122191e-02f, -2.77918994e-01f, -2.45527118e-01f,
  -1.87476337e-01f, 6.39703944e-02f, -5.53835183e-02f, -8.81830007e-02f, 1.12955973e-01f, -1.82342023e-01f, 1.48293123e-01f, 1.52747571e-01f, 7.39988908e-02f, 4.82134610e-01f,
  1.70796469e-01f, 1.19987272e-01f, -1.25055864e-01f, -2.84912121e-02f, -4.32102475e-03f, -7.12367073e-02f, -6.09091036e-02f, -3.31020984e-03f, -1.20106332e-01f, -2.11552754e-02f,
  -3.98550816e-02f, -8.89516771e-02f, -1.23482063e-01f, 1.18536584e-01f, 1.26955107e-01f, 2.26919074e-02f, 5.40618263e-02f, 1.18669085e-01f, -4.50002290e-02f, 5.28983772e-02f,
  1.55111728e-02f, 1.28608197e-01f, 6.68238550e-02f, 8.56571272e-02f, 3.59529629e-02f, -1.77053884e-01f, 1.55509993e-01f, 1.87807083e-01f, 2.00045258e-01f, 2.76845723e-01f,
  5.59239946e-02f, 1.97743140e-02f, -4.72908914e-02f, -3.08743361e-02f, -4.18891497e-02f, -3.57176699e-02f, -1.33760669e-03f, 3.43155526e-02f, 9.29435343e-03f, -7.16201514e-02f,
  8.43230188e-02f, 7.61193708e-02f, 3.02069150e-02f, 3.45649943e-02f, -4.97771055e-02f, -3.33888233e-02f, -7.76060438e-03f, -2.44019870e-02f, 2.01890357e-02f, 1.97121054e-02f,
  -6.50234744e-02f, 1.22882901e-02f, 9.17867757e-03f, 8.86083581e-03f, 4.70907846e-03f, -5.17575964e-02f, -3.44088413e-02f, 6.03446690e-03f, -5.66450544e-02f, -3.06641050e-02f,
  -4.45480458e-02f, -4.88070659e-02f, 8.50705337e-03f, -1.75227281e-02f, -2.66949553e-02f, 1.24222403e-02f, 5.25946207e-02f, -2.53146105e-02f, 3.38154510e-02f, 5.22267818e-03f,
  -8.10459629e-03f, 7.15073124e-02f, 2.12542713e-02f, 5.55662438e-02f, -5.34313545e-02f, 7.18793832e-03f, -8.73886943e-02f, -1.27941012e-01f, 5.72840758e-02f, -2.64431853e-02f,
  2.29333732e-02f, -3.36805321e-02f, -7.15911761e-02f, 2.31085550e-02f, -1.31708477e-03f, -9.06848162e-02f, 3.51715721e-02f, -3.55948508e-02f, -1.38853833e-01f, 4.41936590e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.80608849e-02f, -5.75571895e-01f, 2.74728462e-02f, 3.22670043e-01f, 3.79937649e-01f, 3.77516896e-01f, 1.37582719e-01f, 1.28694430e-01f, 2.71541119e-01f, 2.66153403e-02f,
  -6.56724051e-02f, 1.16676306e-02f, -1.02518834e-01f, -9.74407196e-02f, 2.65178904e-02f, 1.10594302e-01f, 8.05206224e-02f, 5.46511300e-02f, 3.12407881e-01f, 4.00041312e-01f,
  2.13669762e-01f, -6.60879090e-02f, -1.19042069e-01f, -1.80216283e-02f, 5.07997423e-02f, 1.62382886e-01f, 8.32161903e-02f, -3.76821458e-02f, 7.72807524e-02f, -4.21105251e-02f,
  4.62511927e-01f, -2.46553957e-01f, 4.59539026e-01f, -3.33539657e-02f, -5.85122555e-02f, -5.69959953e-02f, 7.86670251e-04f, -7.65145570e-02f, 8.13325588e-03f, 2.21618190e-02f,
  7.78895197e-03f, -9.25977156e-02f, 1.58835091e-02f, -6.97636828e-02f, -1.79627780e-02f, 8.91740471e-02f, -1.59187526e-01f, -8.57458487e-02f, 4.65935878e-02f, 1.77646726e-01f,
  -1.38218507e-01f, -6.90623149e-02f, 7.67435506e-02f, 2.74136811e-01f, 8.56186543e-03f, -4.44638310e-03f, -9.95323732e-02f, -7.72388130e-02f, 9.69286822e-03f, -8.65786746e-02f,
  1.42631948e-01f, 3.81065831e-02f, 1.82293765e-02f, 7.82664195e-02f, -1.18451230e-02f, 5.55355139e-02f, 1.18113555e-01f, 7.17907175e-02f, -5.05657196e-02f, -1.61178216e-01f,
  3.67130595e-03f, 7.55024031e-02f, -1.74438190e-02f, 1.38415489e-02f, -1.11961842e-01f, -8.81727040e-02f, -1.15740247e-01f, -5.03638834e-02f, 4.92242798e-02f, -6.61352649e-02f,
  8.74405131e-02f, 1.54175058e-01f, 2.63501238e-02f, -1.90299988e-01f, -2.98301950e-02f, 2.95765954e-03f, 5.30398265e-03f, -3.08202598e-02f, -1.04923740e-01f, -1.18196970e-02f,
  2.74826378e-01f, -8.72641951e-02f, 2.30762720e-01f, -2.08526582e-01f, -1.41769573e-01f, -7.44506940e-02f, 2.61376277e-02f, 1.15872815e-01f, 3.01715937e-02f, 2.34559268e-01f,
  3.17114517e-02f, -3.85131910e-02f, -5.07453196e-02f, -1.32993385e-01f, 2.22610459e-01f, 4.85730320e-02f, -2.46575512e-02f, 1.54323494e-02f, 8.35020170e-02f, 6.40068669e-03f,
  -1.48242474e-01f, 2.64353484e-01f, 3.71509641e-01f, 1.82026848e-01f, 1.92227364e-01f, 2.51529574e-01f, 1.48150370e-01f, 1.52790159e-01f, 3.44552286e-02f, 1.53861865e-01f,
  -6.53480351e-01f, 9.73652229e-02f, -8.17438960e-01f, 2.41628483e-01f, 2.06320852e-01f, 2.94975966e-01f, 6.25598609e-01f, 2.57290810e-01f, 1.95258960e-01f, 2.77135462e-01f,
  -1.05932117e-01f, -1.86630413e-01f, -1.82189509e-01f, -2.00149149e-01f, -9.79614705e-02f, 5.04103959e-01f, 3.87886375e-01f, -4.53932881e-01f, -5.38032830e-01f, -2.10490078e-02f,
  3.21478665e-01f, -1.90975085e-01f, -3.72668207e-01f, -8.81734397e-03f, 9.27299559e-02f, -1.07767522e-01f, 2.45335698e-02f, -2.63680011e-01f, -2.64664907e-02f, 5.89901730e-02f,
  -7.95601189e-01f, -4.01710570e-01f, 5.12265153e-02f, -1.02718554e-01f, -2.11232096e-01f, -5.07773682e-02f, -6.81050643e-02f, -2.89966613e-01f, -5.24934120e-02f, 9.81612280e-02f,
  -6.56358972e-02f, 2.40560155e-02f, -1.78529900e-02f, -1.62299871e-01f, -2.68411189e-02f, -4.14536111e-02f, 9.99432281e-02f, -3.70122582e-01f, -2.01013595e-01f, -2.13671565e-01f,
  3.65181655e-01f, -2.77356118e-01f, -5.19282103e-01f, 2.04900339e-01f, -9.40163732e-02f, -1.30391821e-01f, -2.22225845e-01f, -2.45164454e-01f, -2.04258606e-01f, -6.58398643e-02f,
  3.55853625e-02f, -4.77039590e-02f, -4.28104140e-02f, 1.75159238e-02f, 1.30667731e-01f, 2.13839486e-02f, -1.39196571e-02f, -2.51262747e-02f, 3.73338237e-02f, 1.54289491e-02f,
  -1.56822111e-02f, 1.56682864e-01f, 1.26630319e-02f, -3.08769085e-02f, 1.18146501e-01f, -1.11738639e-02f, 5.14576724e-03f, 1.89907968e-01f, -3.01040523e-02f, -7.34587060e-03f,
  -1.35020941e-01f, -7.46930689e-02f, 4.18026838e-03f, 5.04918359e-02f, -1.87034123e-02f, 1.46153774e-02f, 9.92209557e-03f, 1.33502856e-02f, -8.01301152e-02f, 1.00491777e-01f,
  3.51303041e-01f, 6.62995130e-02f, -1.38690740e-01f, -4.42497544e-02f, -3.28885503e-02f, -2.12876070e-02f, 4.92242239e-02f, 1.25110745e-01f, -5.38191609e-02f, -5.65659665e-02f,
  -4.24916334e-02f, 1.15438029e-01f, 1.91292409e-02f, -1.35298455e-02f, -2.71599945e-02f, -3.25297415e-02f, 2.60529220e-01f, -1.07501216e-01f, 1.67234391e-01f, 1.20025888e-01f,
  2.50576258e-01f, 2.94053823e-01f, -8.23629871e-02f, 3.82539369e-02f, 2.74640769e-02f, 7.70906825e-03f, -1.82456642e-01f, -1.26079604e-01f, -1.23645559e-01f, 3.64078104e-01f,
  3.78865927e-01f, 2.44453624e-01f, -1.92136496e-01f, 3.36912662e-01f, -3.08243275e-01f, -3.27805370e-01f, -2.07030073e-01f, 7.94853419e-02f, 1.88918456e-01f, 1.92060307e-01f,
  -1.62306011e-01f, 3.04160714e-01f, 2.16421902e-01f, 3.20296079e-01f, 1.51770696e-01f, 2.22527102e-01f, 4.19289768e-01f, 2.90567279e-01f, -4.14055735e-02f, 1.45520970e-01f,
  2.59735465e-01f, 9.09023732e-02f, -2.59061921e-02f, 1.47064880e-01f, 3.34404230e-01f, 7.71708265e-02f, -7.61373714e-02f, -8.98846518e-03f, 7.17273802e-02f, 8.67145956e-01f,
  9.27367657e-02f, 2.36033976e-01f, 6.86253682e-02f, -3.82807627e-02f, -2.38960803e-01f, -6.88502342e-02f, -6.76314021e-03f, 7.56303519e-02f, -1.46330908e-01f, -1.37396967e-02f,
  -4.76282230e-03f, -5.41203879e-02f, 1.05247945e-01f, -6.42059594e-02f, -5.71294725e-02f, -3.41312289e-02f, 3.36661227e-02f, 1.56324953e-01f, 1.04109176e-01f, -2.78091133e-02f,
  1.70831755e-01f, 5.87459691e-02f, -5.54618984e-02f, 2.34183315e-02f, 3.24208662e-02f, -8.89773890e-02f, -8.98722485e-02f, 1.16223916e-01f, -7.91874826e-02f, 2.80472249e-01f,
  -2.89670348e-01f, -9.01514515e-02f, -3.10650654e-02f, 4.38738205e-02f, -3.62510495e-02f, 1.86461601e-02f, 1.57528564e-01f, -5.01083545e-02f, 2.93609910e-02f, -8.59717280e-02f,
  -8.80926028e-02f, -8.96013435e-03f, -1.01226889e-01f, 1.56801090e-01f, 9.50317085e-02f, 4.20717373e-02f, 1.38448775e-01f, 7.61431903e-02f, -6.10150248e-02f, 1.18394429e-03f,
  9.64820012e-02f, 9.27105024e-02f, -3.82014690e-03f, 1.26417577e-01f, 4.31939065e-02f, 6.20211363e-02f, 9.65738967e-02f, -1.03299610e-01f, -1.31097674e-01f, -5.96394576e-02f,
  -1.87802747e-01f, -2.43172050e-01f, 3.78535718e-01f, 2.15933442e-01f, 6.21941546e-03f, -5.83207607e-02f, 2.36870553e-02f, 9.25097242e-03f, -2.31846064e-01f, 5.88843524e-02f,
  -1.38436943e-01f, 2.41250601e-02f, 5.69877848e-02f, -5.57123944e-02f, -1.47567336e-02f, -1.19357677e-02f, -9.18080881e-02f, 9.56603885e-03f, 1.34534994e-02f, -1.38789164e-02f,
  6.55721053e-02f, 5.48580065e-02f, -6.35963082e-02f, -2.68441811e-02f, -2.44933218e-02f, -8.54687095e-02f, -1.39352754e-01f, -1.67059968e-03f, -2.84624398e-01f, -1.54651210e-01f,
  -2.48815700e-01f, -2.60119766e-01f, -4.63028222e-01f, -4.78797257e-02f, 9.94725972e-02f, 1.96030200e-01f, -1.70451984e-01f, 1.73521899e-02f, 3.25055867e-01f, -7.81917050e-02f,
  8.34770128e-02f, 2.60713845e-01f, -3.54429632e-01f, -2.66627699e-01f, -5.43369651e-01f, -4.43268985e-01f, -4.61639196e-01f, -3.41002584e-01f, 6.66122586e-02f, 2.92877525e-01f,
  1.64351627e-01f, -1.25195310e-01f, -1.34110630e-01f, 7.82294199e-03f, 7.71023259e-02f, 1.96453497e-01f, -3.27773988e-01f, -1.38860494e-01f, 1.10538572e-01f, -3.13020080e-01f,
  -2.24714756e-01f, 1.67100653e-01f, 5.40848374e-02f, -6.46494981e-03f, -1.27631679e-01f, -3.55624296e-02f, -9.93712526e-03f, -2.01615497e-01f, 1.88647565e-02f, -5.47510758e-02f,
  6.07204884e-02f, 7.47543275e-02f, -3.34092975e-02f, -1.01083023e-02f, 9.12332162e-03f, 7.06622601e-02f, -9.80969444e-02f, -4.50142846e-02f, -1.83359399e-01f, -1.67923704e-01f,
  2.44832560e-02f, 8.67842063e-02f, -2.21844196e-01f, -9.67657045e-02f, -1.26628280e-01f, 4.43028584e-02f, -8.87728557e-02f, 5.04404269e-02f, -2.01896429e-01f, -2.77825952e-01f,
  1.08654108e-02f, 2.20315345e-02f, -5.43607585e-02f, -5.48439287e-02f, -5.80017595e-03f, 3.12055293e-02f, 8.42410699e-02f, -6.47508353e-02f, -9.57125332e-03f, -5.56160994e-02f,
  6.20200783e-02f, 1.39451623e-01f, 8.17599818e-02f, -6.62003607e-02f, 8.92955158e-03f, -4.23413627e-02f, 1.11493263e-02f, -8.30513984e-02f, -1.11392051e-01f, 7.20833009e-03f,
  -3.67355682e-02f, -1.29259363e-01f, 1.10162236e-01f, 1.90015465e-01f, -7.25545362e-02f, -1.03571871e-02f, 5.12093753e-02f, -4.96326461e-02f, -9.63551775e-02f, 1.14954054e-01f,
  -3.00814509e-01f, 3.50630097e-02f, -7.19801430e-03f, -3.81572507e-02f, 5.83779961e-02f, -4.81537767e-02f, -6.19937740e-02f, -6.94957003e-02f, 4.13176529e-02f, -1.49450824e-01f,
  -5.05803293e-03f, -1.81528538e-01f, -9.67183858e-02f, -5.65705448e-02f, -1.04476903e-02f, -1.51313230e-01f, -1.73165232e-01f, -2.24968895e-01f, -8.39073956e-02f, 2.25957349e-01f,
  -1.56390727e-01f, -1.15609765e-01f, -2.75155365e-01f, -3.21679026e-01f, 1.50984898e-01f, -4.68741432e-02f, -2.28693679e-01f, -8.31879303e-02f, -3.19999844e-01f, -3.83388191e-01f,
  8.70581508e-01f, -4.74954695e-01f, -1.46773517e-01f, 3.93924236e-01f, 6.63959458e-02f, 1.11947089e-01f, 4.44288217e-02f, 2.39704866e-02f, 3.81109297e-01f, 7.06136525e-02f,
  -4.18697864e-01f, -5.65281749e-01f, -3.02920103e-01f, -3.72246623e-01f, -1.92539260e-01f, 2.19412684e-01f, 3.80806774e-01f, 2.20312119e-01f, 9.96561572e-02f, -1.57773718e-01f,
  -2.16774419e-01f, 2.71840990e-01f, 2.15563148e-01f, 5.73606379e-02f, -1.52511969e-01f, 2.51741800e-02f, 2.01494992e-01f, -8.39191303e-02f, -3.43086332e-01f, -4.66593891e-01f,
  -2.75053889e-01f, 3.23333554e-02f, 1.26079649e-01f, 1.14140600e-01f, -1.09073639e-01f, 3.14899720e-02f, -3.54455784e-02f, -2.23979931e-02f, -7.69507373e-03f, 3.82520333e-02f,
  -6.65346310e-02f, -7.39051029e-02f, -3.15988325e-02f, -9.42397565e-02f, 8.06847215e-02f, -2.61962693e-03f, 6.68190494e-02f, -1.32829443e-01f, -2.61024535e-02f, -5.09868115e-02f,
  -2.45281354e-01f, -1.77339971e-01f, -1.21783778e-01f, -1.16372146e-01f, -6.81589469e-02f, -7.02179000e-02f, -3.00728649e-01f, -1.39228940e-01f, -1.65992051e-01f, -7.63354525e-02f,
  -5.49058467e-02f, -3.11586889e-03f, -1.08400770e-01f, -2.86051985e-02f, 5.09095788e-02f, 5.48361689e-02f, 7.84013513e-03f, -1.87636074e-02f, 2.73693074e-02f, -7.67815858e-02f,
  3.12102418e-02f, 6.40229955e-02f, -4.29828726e-02f, 9.62728187e-02f, 6.63328031e-03f, -2.10836139e-02f, 7.53707364e-02f, -4.71172407e-02f, -4.87755239e-02f, 1.05850652e-01f,
  -9.44069996e-02f, 6.44782633e-02f, 1.05811372e-01f, 2.06139944e-02f, -4.88178544e-02f, 7.00093282e-04f, -2.62857843e-02f, -1.00216955e-01f, 1.75701771e-02f, -1.24035394e-02f,
  1.05608970e-01f, -5.62034212e-02f, 1.02244712e-01f, -5.18174246e-02f, 6.63831457e-02f, 3.98834869e-02f, -3.68805155e-02f, -1.18845969e-03f, 3.09828222e-02f, 7.25549757e-02f,
  -7.77326897e-02f, -5.64036053e-03f, -8.09118748e-02f, -1.07133649e-01f, 1.41821848e-02f, 4.68543619e-02f, -6.10915124e-02f, 4.26988602e-02f, 1.87924244e-02f, 7.51451999e-02f,
  3.53143476e-02f, 1.32177517e-01f, 9.34931561e-02f, 1.66535363e-01f, 2.72164121e-02f, 2.65980273e-01f, 6.58926070e-02f, 6.27725199e-02f, 1.79966584e-01f, 3.85350049e-01f,
  -4.53256279e-01f, 3.30629855e-01f, -4.88262981e-01f, 2.12884005e-02f, -5.05335629e-01f, -4.71828878e-01f, -5.37415683e-01f, 1.26455486e-01f, 2.17719316e-01f, -8.30782205e-02f,
  -6.53184801e-02f, 1.82288848e-02f, 1.21645115e-01f, 2.77299210e-02f, -8.81787091e-02f, -2.28972822e-01f, -4.93306011e-01f, -4.10013199e-01f, -5.26465297e-01f, -4.23665196e-01f,
  -3.61352891e-01f, -2.55520642e-01f, -9.52064171e-02f, 1.74364865e-01f, 9.04843211e-02f, 2.25609869e-01f, -1.08691733e-02f, -9.58093554e-02f, -6.54811263e-02f, -1.69749141e-01f,
  -2.40827620e-01f, -1.72997668e-01f, -2.34993219e-01f, -1.05822399e-01f, -1.23517856e-01f, -6.70766979e-02f, -1.94434315e-01f, -1.09706670e-01f, -3.29941884e-03f, 6.27158731e-02f,
  -4.79496829e-02f, -6.36737943e-02f, 8.54534209e-02f, 2.63037253e-02f, -3.38549204e-02f, -1.16239324e-01f, 8.65205303e-02f, -1.21330090e-01f, -6.02171756e-03f, 1.19906813e-01f,
  -1.26503304e-01f, -2.01421335e-01f, 1.06687270e-01f, 1.25074372e-01f, 1.52312249e-01f, -2.24368513e-01f, 2.28433058e-01f, 7.17786625e-02f, 1.02647170e-02f, 2.43394852e-01f,
  4.96353814e-03f, 5.99108562e-02f, 9.37011186e-03f, -1.23861879e-02f, 4.75362465e-02f, -1.63289420e-02f, -5.81379049e-02f, 4.29775231e-02f, -5.25120161e-02f, 4.85569052e-02f,
  1.69786755e-02f, -1.57296717e-01f, 8.31430480e-02f, -6.59185648e-03f, -6.88178241e-02f, 2.69297678e-02f, -9.41969678e-02f, 9.50418711e-02f, 1.06638990e-01f, 4.81936745e-02f,
  -3.13884090e-03f, 3.54574583e-02f, -1.11446112e-01f, 4.59290333e-02f, -1.31949276e-01f, 1.23443052e-01f, -3.80696468e-02f, -6.99712429e-03f, 1.16262380e-02f, -1.24444969e-01f,
  3.59432071e-01f, -1.93508193e-01f, 9.76799279e-02f, 1.85029671e-01f, -1.33288745e-02f, 7.37159103e-02f, -1.29596088e-02f, 6.29597232e-02f, -1.94963627e-02f, -1.47010088e-02f,
  4.60823588e-02f, 1.07697435e-01f, 1.31231518e-02f, 1.21140122e-01f, -2.44239438e-02f, -8.49990547e-02f, -2.12778207e-02f, -6.92737708e-03f, 1.20594040e-01f, 8.98303911e-02f,
  2.11748466e-01f, -1.32172285e-02f, 1.25212640e-01f, 1.47999942e-01f, 8.25363025e-03f, -1.42237470e-01f, 1.11820504e-01f, -3.62452120e-02f, 2.42048800e-02f, 4.19329315e-01f,
  -2.10948214e-01f, 1.86360776e-01f, 3.35740954e-01f, -1.09954802e-02f, 4.27291453e-01f, 4.20231849e-01f, 7.35091031e-01f, 1.86468199e-01f, -7.03299046e-02f, 8.43951628e-02f,
  -5.95534556e-02f, -2.92528808e-01f, -2.77232856e-01f, -2.85325915e-01f, 8.44697505e-02f, 2.82249779e-01f, 2.53423601e-01f, -1.02705164e-02f, -4.26347665e-02f, 2.07213243e-03f,
  2.75251316e-03f, 4.61322665e-02f, -6.34735674e-02f, -2.30103694e-02f, 3.30623060e-01f, -2.18433589e-01f, 3.36763337e-02f, 2.86525786e-01f, 3.53959128e-02f, 1.31886780e-01f,
  -2.40427315e-01f, 2.84079045e-01f, -2.45390888e-02f, -2.06033006e-01f, 1.25013351e-01f, -1.14558443e-01f, -8.89523104e-02f, -2.51886062e-02f, -2.09778503e-01f, -4.18656468e-02f,
  9.51332226e-02f, -1.01772130e-01f, 1.36526242e-01f, 8.85497183e-02f, 1.71386868e-01f, -2.15130653e-02f, 1.51869804e-01f, -1.32636040e-01f, -2.10295781e-01f, -2.70812735e-02f,
  5.56332506e-02f, 9.44172293e-02f, 2.71691084e-01f, 5.33034746e-03f, 1.47023186e-01f, -1.36506632e-01f, 8.25329721e-02f, 3.84466872e-02f, -4.44113910e-02f, -2.03428447e-01f,
  -3.04316998e-01f, 1.23361009e-04f, 6.46394491e-02f, 1.47943078e-02f, -1.38851786e-02f, 8.30638781e-03f, -8.61249585e-03f, 4.75227982e-02f, 3.77953909e-02f, 5.60791902e-02f,
  5.51148597e-03f, -4.70686927e-02f, -9.85405892e-02f, -2.64572911e-02f, 4.56005009e-03f, 1.51478797e-01f, 1.82108387e-01f, -8.13331679e-02f, -2.36036535e-02f, -1.18087949e-02f,
  -6.47875369e-02f, 6.44770488e-02f, 1.14978127e-01f, -4.90865856e-02f, 1.47501323e-02f, -5.47752082e-02f, 7.22301677e-02f, -1.16239458e-01f, -2.03346014e-01f, -7.62678012e-02f,
  -1.91149935e-01f, -4.82972898e-02f, -6.07572682e-02f, 2.30868440e-02f, 1.27281677e-02f, -2.37752840e-01f, -3.16593535e-02f, -7.50351623e-02f, 3.55403796e-02f, -2.49373436e-01f,
  2.58213542e-02f, -1.69748571e-02f, 1.39725924e-01f, -4.08392176e-02f, 1.03316763e-02f, 2.71724854e-02f, 1.24776922e-03f, 7.35015124e-02f, -1.24601580e-01f, -3.72926667e-02f,
  6.17730357e-02f, -6.29647598e-02f, -7.84321055e-02f, -1.50838709e-02f, -1.72279045e-01f, -2.72119015e-01f, -6.38689995e-02f, -2.63836258e-03f, 2.39700563e-02f, -2.77146697e-01f,
  -2.18185782e-01f, 8.00081268e-02f, 2.41136663e-02f, 5.83843291e-02f, 3.60312492e-01f, -3.15343738e-01f, -3.16067964e-01f, -3.74372929e-01f, -1.15762472e-01f, 1.56726748e-01f,
  1.78240120e-01f, 1.99025869e-03f, 1.41489789e-01f, -2.64455192e-02f, -3.09063464e-01f, 8.63670111e-02f, 2.46017590e-01f, -1.30093396e-02f, -4.17137444e-01f, -4.46445853e-01f,
  2.17321459e-02f, -1.67942252e-02f, -1.46127447e-01f, -3.65990847e-01f, 1.08047925e-01f, 6.89142421e-02f, 2.46610567e-01f, 1.33521497e-01f, 8.73454660e-02f, 6.50635719e-01f,
  1.41852081e-01f, 4.37761135e-02f, -4.37169485e-02f, 2.22404495e-01f, 2.47210875e-01f, 5.51291741e-03f, -1.64906219e-01f, 8.15221071e-02f, 4.87793870e-02f, 7.54712522e-02f,
  3.95082623e-01f, 4.23122570e-02f, 1.69914290e-01f, -7.53817856e-02f, 3.59432809e-02f, -1.30545467e-01f, -6.95508644e-02f, -1.34288073e-01f, 1.75870140e-03f, -6.30472228e-02f,
  1.49230003e-01f, 1.28667235e-01f, -1.27374172e-01f, -1.30661651e-01f, -1.99038714e-01f, 3.45562287e-02f, -1.02120787e-01f, -1.54176895e-02f, -2.65155554e-01f, -1.27390906e-01f,
  -1.54406969e-02f, 1.06674314e-01f, 1.18025653e-01f, -9.85607505e-02f, 1.77953728e-02f, 9.95231643e-02f, 7.59334862e-02f, 1.87051538e-02f, -2.18428466e-02f, 2.76752352e-03f,
  -4.81943339e-02f, 3.67447734e-03f, -4.72419299e-02f, 6.25508949e-02f, -4.60541919e-02f, 8.40090364e-02f, -8.79108384e-02f, -3.25373858e-02f, -8.91345441e-02f, 5.17938286e-02f,
  -6.07080460e-02f, -3.40088606e-02f, 1.23598225e-01f, -2.20204905e-01f, 1.21122435e-01f, 2.93119326e-02f, -3.33534833e-03f, 1.33985765e-02f, -2.08134893e-02f, 6.94770515e-02f,
  -2.52826005e-01f, 4.42263000e-02f, -3.07958163e-02f, -6.06146380e-02f, 7.97143653e-02f, 1.16999429e-02f, 3.13131437e-02f, 1.06724635e-01f, 8.85652676e-02f, -1.68989956e-01f,
  -6.85511902e-02f, -4.31900583e-02f, 1.07959911e-01f, -1.64910451e-01f, -1.80020824e-01f, -5.42758405e-02f, 1.45343453e-01f, -1.48935556e-01f, -1.19225793e-01f, -2.33179349e-02f,
  -1.53590485e-01f, -2.51221597e-01f, -2.28392333e-01f, -2.00798586e-01f, -8.32640231e-02f, -2.06846491e-01f, -1.43511906e-01f, -1.85536683e-01f, -4.10859942e-01f, -5.73004127e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -3.66568625e-01f, 5.65669060e-01f, 1.66776761e-01f, 1.49041072e-01f, 4.46431488e-01f, 4.73612487e-01f, -1.92689568e-01f, 5.08190274e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -5.03034651e-01f, -2.63110548e-01f, -2.58303378e-02f, 4.04584371e-02f, -2.68186361e-01f, -1.89943671e-01f, 6.36772633e-01f, 1.25684991e-01f, 1.60664376e-02f, -2.24415377e-01f,
  1.47002161e-01f, -9.29455236e-02f, -2.91599870e-01f, 1.01611048e-01f, -6.00596488e-01f, 5.85147403e-02f, -3.44288409e-01f, 9.87612903e-02f, -1.41882464e-01f, -2.58092165e-01f,
  -2.45056793e-01f, -1.97266787e-01f, -2.75162667e-01f, -3.93924028e-01f, 1.70007169e-01f, -3.67619276e-01f, -2.45839834e-01f, 3.84984791e-01f, -2.70705462e-01f, 1.30521938e-01f,
  -4.30849791e-02f, -3.73150975e-01f, 5.50363697e-02f, 6.71602070e-01f, -6.36683544e-03f, 3.02005917e-01f, 3.26980539e-02f, -8.17822758e-03f, 3.79209042e-01f, -2.76822805e-01f,
  7.22938403e-03f, -9.91484821e-02f, -3.83774668e-01f, -1.39455676e-01f, 7.74797797e-01f, 2.37341121e-01f, 5.07412516e-02f, 1.14985324e-01f, 2.30517387e-01f, -5.03717214e-02f,
  1.71895534e-01f, 5.28943539e-02f, 4.63679321e-02f, -3.64503294e-01f, -5.52241385e-01f, -3.90339166e-01f, -2.34990537e-01f, -7.61544481e-02f, -3.95107657e-01f, 2.25314260e-01f,
  -9.08682644e-02f, 3.97706628e-01f, -9.62029472e-02f, -5.24626195e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -8.33694786e-02f, -1.79053470e-01f, 5.75787611e-02f, -1.26653031e-01f, 4.10519987e-02f, 1.02246664e-01f, -2.70230740e-01f, 3.42013657e-01f, 3.98635268e-01f, 2.42414057e-01f,
  1.75847754e-01f, 3.50780755e-01f, 2.82334387e-01f, -1.09142743e-01f, -1.45949945e-01f, -1.30611673e-01f, 8.27436447e-01f, -4.31692481e-01f, 6.74061418e-01f, 3.65128726e-01f,
  1.31619945e-01f, 5.91043174e-01f, -7.51028717e-01f, 9.44021404e-01f, -4.27777201e-01f, -6.28491342e-02f, 2.69964039e-01f, -3.07182550e-01f, 2.45559245e-01f, -4.14686538e-02f,
  -2.95333445e-01f, 3.62023234e-01f, 6.17585123e-01f, 2.08462641e-01f, 7.44575381e-01f, 5.86494684e-01f, -4.24439549e-01f, 6.82859302e-01f, -2.50990063e-01f, 5.52662075e-01f,
  -6.68312728e-01f, -1.21904314e-01f, 2.50428110e-01f, 4.61433381e-02f, -4.59618270e-01f, -4.99604911e-01f, 1.77939221e-01f, 4.68162209e-01f, 6.43892646e-01f, 4.38843995e-01f,
  3.92970741e-01f, 8.50679994e-01f, -7.81849682e-01f, 5.28857887e-01f, 2.76966952e-02f, 6.29016995e-01f, -1.83792561e-01f, 7.87767291e-01f, -3.89285646e-02f, 4.01341856e-01f,
  -4.08959627e-01f, 5.71073711e-01f, 1.39614880e-01f, 7.40706086e-01f, 8.29726756e-01f, 3.27648938e-01f, 3.84983718e-01f, 3.47344697e-01f, 2.90087014e-01f, 4.47959840e-01f,
  -5.92370071e-02f, 3.96412313e-01f, -4.75439131e-02f, 5.85606098e-01f, -1.95916891e-01f, -3.71457249e-01f, 6.05370581e-01f, 8.07824731e-02f, 3.12104821e-01f, -2.04432666e-01f,
  -8.38430077e-02f, -4.57469851e-01f, 2.09115282e-01f, -2.44294293e-02f, -6.71836376e-01f, 3.42231184e-01f, -3.90156448e-01f, -2.62785405e-01f, -2.19891280e-01f, 8.98994982e-01f,
  1.19295090e-01f, 5.48647106e-01f, -2.44070709e-01f, 1.16535433e-01f, -1.34930998e-01f, 1.10239223e-01f, 1.14639945e-01f, 3.34137470e-01f, 4.09632735e-02f, -1.66435823e-01f,
  -2.59848595e-01f, -9.41704139e-02f, -5.65912962e-01f, -2.09240228e-01f, -1.37801483e-01f, 5.47519565e-01f, 4.20136452e-01f, -1.35219976e-01f, -6.35051668e-01f, 7.11845830e-02f,
  3.73137951e-01f, -2.25731269e-01f, 4.09786642e-01f, 1.73325554e-01f, 5.62613547e-01f, 4.55447137e-01f, 2.62905329e-01f, -4.39971119e-01f, 3.41721296e-01f, -5.82161725e-01f,
  -2.98886299e-01f, 3.14707845e-01f, 4.18529689e-01f, 4.90738183e-01f, 1.59985557e-01f, 7.55546510e-01f, -6.08004689e-01f, -8.80226791e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -1.82180315e-01f, 4.31367666e-01f, 7.60494292e-01f, 5.67337394e-01f, 5.11990964e-01f, 3.17098945e-01f, 1.19171679e-01f, 5.51328838e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  5.82835712e-02f, -2.38496855e-01f, -6.44298047e-02f, -1.54408498e-03f, 3.68571848e-01f, -2.07661897e-01f, -9.24650609e-01f, -8.09727460e-02f, 2.31166184e-01f, 3.91447067e-01f,
  -2.50213519e-02f, 1.96843252e-01f, -1.33684888e-01f, 2.99895674e-01f, 3.34546745e-01f, -4.01834160e-01f, 1.57129839e-02f, 3.23041201e-01f, -4.39876318e-01f, 1.73202664e-01f,
  1.29050955e-01f, -7.48861611e-01f, 1.30399421e-01f, 5.89839928e-03f, -2.48589739e-01f, 2.88662523e-01f, 1.29769385e-01f, -2.09637240e-01f, 3.71931881e-01f, -4.27664936e-01f,
  -7.27440836e-03f, 1.40341580e-01f, -7.79429153e-02f, 5.28499722e-01f, 9.23367888e-02f, 1.07901745e-01f, -4.59772587e-01f, -7.62733538e-03f, 5.77935949e-03f, -9.49790254e-02f,
  9.06338841e-02f, -1.18187577e-01f, -5.66184521e-02f, 8.50331262e-02f, 5.75873375e-01f, -1.29800186e-01f, 3.75977993e-01f, -5.73774338e-01f, -1.54872462e-01f, 2.24185899e-01f,
  -2.94558257e-01f, -9.17162225e-02f, 1.41933607e-03f, 5.96915632e-02f, -1.90389514e-01f, 2.04305220e-02f, 1.90946788e-01f, 5.14920317e-02f, 1.15906015e-01f, -9.90240797e-02f,
  3.39391619e-01f, -2.16334164e-01f, -2.72851408e-01f, -2.22737715e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  8.61661673e-01f, 4.84855548e-02f, 6.54853582e-01f, 4.55159754e-01f, -1.57400355e-01f, -4.91801292e-01f, -5.96216917e-01f, 3.82576674e-01f, -2.46419966e-01f, 7.34790623e-01f,
  8.38068843e-01f, 9.14846301e-01f, 3.30273151e-01f, 6.21826351e-01f, 1.21114463e-01f, 2.87083779e-02f, 5.78465700e-01f, 1.05297935e+00f, 7.36870756e-03f, 9.19466317e-01f,
  2.55772978e-01f, -9.15480018e-01f, 4.38488364e-01f, 8.21385741e-01f, -5.64483225e-01f, 7.25601614e-01f, 6.41113222e-01f, 5.65487325e-01f, -1.00465253e-01f, -3.32649410e-01f,
  -8.30361843e-01f, 1.43715352e-01f, 6.55461311e-01f, 1.94755733e-01f, -6.09381080e-01f, -6.80612922e-01f, -3.07468235e-01f, -4.29557264e-01f, -2.03979924e-01f, -5.54670155e-01f,
  2.20419317e-01f, 6.22979581e-01f, 1.24960825e-01f, -4.05722409e-01f, 3.05134803e-01f, -3.82173359e-01f, 1.74378827e-01f, 3.79656464e-01f, -4.31705639e-02f, -2.80866206e-01f,
  -4.40208793e-01f, -1.77150875e-01f, -1.41334558e+00f, 4.66934405e-02f, -1.39679670e-01f, -3.21410984e-01f, -3.46835464e-01f, 4.83410150e-01f, -1.52022243e-01f, 1.42651379e-01f,
  1.03728664e+00f, -1.13995038e-01f, 2.43613794e-01f, -3.15091498e-02f, -3.58204126e-01f, 5.83188534e-01f, 4.32776660e-02f, 2.40693480e-01f, -3.62185448e-01f, -5.50384998e-01f,
  6.51846051e-01f, -1.90036371e-01f, -3.08737308e-01f, 1.60123810e-01f, 8.72306466e-01f, 5.18959999e-01f, 4.39352572e-01f, -7.31604248e-02f, 6.05454296e-02f, -3.81937772e-01f,
  2.35048681e-01f, 6.98873475e-02f, 4.91777509e-01f, -2.63240308e-01f, 3.47952902e-01f, -9.71100554e-02f, -1.24815655e+00f, -3.91838402e-01f, -1.73513994e-01f, 7.52937078e-01f,
  7.30821967e-01f, 1.48962632e-01f, 1.52971447e-01f, 2.20590755e-01f, 3.69502157e-01f, -4.53823447e-01f, 3.48695457e-01f, -5.77481091e-01f, 2.57667065e-01f, -3.71404022e-01f,
  -1.47348627e-01f, 3.23370993e-01f, -8.30117106e-01f, 1.90081075e-02f, 2.91069657e-01f, 1.38329878e-01f, 2.05673665e-01f, 3.15425038e-01f, -3.69374193e-02f, 8.20952713e-01f,
  1.72603041e-01f, 1.29744500e-01f, 5.82122803e-01f, -1.69443693e-02f, 3.69349778e-01f, 6.34627521e-01f, 5.04521370e-01f, -1.72844410e-01f, 3.24692994e-01f, 6.42379880e-01f,
  -4.09541160e-01f, -5.05189478e-01f, -6.95304513e-01f, 6.23522103e-01f, 3.67104769e-01f, 1.74696162e-01f, -5.17145395e-01f, 8.01963568e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  2.63483196e-01f, 3.82011324e-01f, 2.98707157e-01f, 4.44283336e-01f, 3.86878192e-01f, 2.51000911e-01f, -2.38823697e-01f, 3.98827255e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  8.66126642e-02f, -3.12502503e-01f, 4.67854232e-01f, -9.52016488e-02f, 3.56833160e-01f, -8.10255408e-01f, -1.15729414e-01f, -3.36630009e-02f, 1.10579580e-01f, 2.46943280e-01f,
  -4.58804429e-01f, -1.33022338e-01f, 6.06691688e-02f, -1.30693719e-01f, 7.23069608e-02f, -4.58157398e-02f, -9.14169014e-01f, -1.47035658e-01f, 7.59722069e-02f, -2.38767609e-01f,
  2.97115326e-01f, 9.27328393e-02f, -5.24998784e-01f, 7.02073336e-01f, 1.18402559e-02f, 2.93806970e-01f, 2.17033494e-02f, 3.85072194e-02f, 1.53382793e-01f, -1.19489096e-01f,
  2.13661790e-01f, -5.91363013e-01f, 2.61139393e-01f, 5.43347180e-01f, -3.33426118e-01f, 3.75100583e-01f, -4.09249440e-02f, 2.85461783e-01f, 2.33844548e-01f, 3.75097096e-01f,
  -4.85990830e-02f, 1.11691356e-01f, -1.97664753e-01f, 2.09632427e-01f, 4.36584324e-01f, -2.28866786e-01f, -4.76731986e-01f, 2.17105359e-01f, -4.96134788e-01f, 5.88807799e-02f,
  2.74497569e-01f, 7.94329122e-02f, -6.38603941e-02f, 2.74406523e-01f, -1.68179646e-01f, 3.24234992e-01f, 3.65918614e-02f, -1.48405448e-01f, 4.19718236e-01f, 1.06365390e-01f,
  -1.49892986e-01f, 1.54866025e-01f, 4.40840423e-02f, -2.66917884e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -6.17256641e-01f, 6.94903672e-01f, 1.14547515e+00f, 1.11225688e+00f, 6.32737398e-01f, 7.13151634e-01f, -6.97847605e-01f, -3.82105350e-01f, 4.15820837e-01f, 1.10020363e+00f,
  6.58775806e-01f, -4.60300624e-01f, 1.47366464e-01f, 3.09374064e-01f, -4.77910072e-01f, 1.84312493e-01f, 9.16778564e-01f, 1.64697349e-01f, 1.93816245e-01f, 5.75177193e-01f,
  -7.78571427e-01f, 8.69400859e-01f, -1.07985854e-01f, 5.85058868e-01f, -4.38266248e-02f, 3.52899432e-01f, 1.08603239e+00f, 1.06328368e+00f, 5.80614626e-01f, 8.79838597e-03f,
  -6.44720316e-01f, 1.08267277e-01f, -7.77773380e-01f, 8.10872495e-01f, -2.92542279e-01f, 1.32918982e-02f, 7.61980712e-01f, -2.22949490e-01f, 2.61428773e-01f, -2.60037720e-01f,
  7.71783650e-01f, -1.23328887e-01f, -2.38911480e-01f, -1.48800030e-01f, 3.70926529e-01f, 1.26731956e+00f, 7.04360783e-01f, -4.07607079e-01f, -1.39626563e-01f, 1.29213184e-01f,
  -9.77575928e-02f, -8.03271905e-02f, 4.87590522e-01f, -7.60194540e-01f, -6.05447531e-01f, -6.14049971e-01f, 1.81313246e-01f, 8.92037272e-01f, -7.08667815e-01f, -6.93414152e-01f,
  6.99744463e-01f, -6.47133961e-02f, -2.11909235e-01f, 3.94965820e-02f, 9.93455887e-01f, -7.78345838e-02f, -6.67567551e-01f, -5.94673395e-01f, -6.23633265e-01f, -4.50917691e-01f,
  2.33002141e-01f, -1.08759239e-01f, 4.94856685e-01f, 2.78332412e-01f, -6.80886388e-01f, -4.34726477e-01f, -1.17424458e-01f, -1.16245961e+00f, 1.27141967e-01f, 8.16136122e-01f,
  -1.16810277e-01f, -4.35750604e-01f, 9.05058026e-01f, 3.28899920e-01f, -8.45302224e-01f, -5.73762476e-01f, -5.28591394e-01f, -1.00127399e+00f, 3.92528057e-01f, 3.47636253e-01f,
  4.48221296e-01f, 4.48562384e-01f, -5.46940863e-01f, -4.69043136e-01f, 6.80312514e-01f, 7.97742426e-01f, 1.01651084e+00f, 2.84860939e-01f, 1.44116580e-01f, 3.30682933e-01f,
  2.48013780e-01f, -4.24959779e-01f, 8.94172370e-01f, -1.00657322e-01f, 6.10945880e-01f, -1.97970271e-01f, -6.03068411e-01f, 9.24582064e-01f, 3.40784729e-01f, 1.24743894e-01f,
  -7.78952911e-02f, -2.28328463e-02f, 5.28213501e-01f, -5.40164053e-01f, -1.08252990e+00f, -6.09143555e-01f, 6.28882125e-02f, 4.54545587e-01f, 7.08868742e-01f, 1.08118558e+00f,
  2.40133017e-01f, 4.52761352e-01f, 3.67192149e-01f, 6.02383375e-01f, 6.53298259e-01f, -2.37184852e-01f, -6.92421943e-02f, -5.37805021e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  2.76609570e-01f, 6.44721910e-02f, -2.08225995e-02f, 1.20698594e-01f, 4.58852321e-01f, 5.31375647e-01f, -1.14655286e-01f, 3.16641062e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -2.33319141e-02f, -6.77252889e-01f, -1.36072576e-01f, -2.49512717e-01f, 6.44312441e-01f, -1.85544893e-01f, -1.01809466e+00f, -3.65941942e-01f, -1.25497782e+00f, -9.24274981e-01f,
  -1.06000543e-01f, -1.03353941e+00f, 5.82477391e-01f, 2.68987983e-01f, -1.18436217e-01f, -9.96015370e-01f, 8.91079381e-02f, 1.21216667e+00f, 4.33119476e-01f, 4.49366242e-01f,
  -1.11078453e+00f, -7.42972970e-01f, 7.92064011e-01f, 9.26906765e-01f, 4.36831653e-01f, 4.10036862e-01f, -6.62643164e-02f, -1.30523121e+00f, -1.09665310e+00f, 3.63080680e-01f,
  -1.12012815e+00f, -5.41330993e-01f, 3.60774100e-02f, 4.35631782e-01f, -7.15570748e-01f, 2.87102968e-01f, 1.04623222e+00f, 1.09637523e+00f, 2.04278365e-01f, -1.99551567e-01f,
  4.99429971e-01f, 1.37800917e-01f, -3.29596609e-01f, 3.49200755e-01f, -7.21086204e-01f, -3.07319134e-01f, -5.00322171e-02f, 2.09143892e-01f, -1.21042287e+00f, 2.27338746e-01f,
  2.77596474e-01f, -2.02277929e-01f, 2.22941503e-01f, -6.99865043e-01f, -3.71371627e-01f, -1.18581367e+00f, 1.95284545e-01f, -9.62430298e-01f, 1.74377218e-01f, -8.31729174e-02f,
  -2.77356684e-01f, 1.69709235e-01f, 1.66222915e-01f, -2.73779780e-01f, -9.02766883e-02f, -4.32352692e-01f, 7.32458711e-01f, -1.82379901e-01f, 9.04941708e-02f, 7.68647715e-02f,
  2.64352769e-01f, 6.98930502e-01f, -3.34296435e-01f, -6.40598476e-01f, -5.84072292e-01f, 4.49725091e-01f, 5.81945837e-01f, 9.84503925e-02f, -3.10208589e-01f, 4.87002283e-01f,
  7.63399065e-01f, -4.20281529e-01f, -3.28034818e-01f, 4.32430059e-01f, -3.30641806e-01f, -3.48662436e-01f, 4.50499296e-01f, -6.14282012e-01f, -2.03116521e-01f, 2.11051732e-01f,
  -5.60546458e-01f, -9.38028097e-01f, -1.26072869e-01f, 3.12711924e-01f, 6.88057899e-01f, -9.46758315e-02f, -1.03539340e-01f, -5.43414414e-01f, 7.30993822e-02f, -7.75385499e-01f,
  -9.77383077e-01f, -1.30445793e-01f, -1.21195495e+00f, -6.92962825e-01f, 3.79278600e-01f, 2.28907377e-01f, 2.83485860e-01f, -6.14891171e-01f, -7.39670157e-01f, -3.54176462e-01f,
  -1.95468247e-01f, 4.89868894e-02f, -8.21773931e-02f, 3.44705909e-01f, 2.63016075e-02f, -1.18194951e-03f, -1.41866386e-01f, 5.22426903e-01f, -5.51911235e-01f, 5.58624446e-01f,
  -1.16404366e+00f, -5.47583878e-01f, 5.58563411e-01f, -5.00173509e-01f, -5.25079608e-01f, -5.42139590e-01f, 5.58640182e-01f, 5.60416877e-01f, -4.93653834e-01f, 1.58775076e-01f,
  -2.98734158e-01f, -1.65204585e-01f, -7.38734424e-01f, 3.92313808e-01f, 5.79936683e-01f, 3.43250364e-01f, -1.54808378e+00f, 7.73071468e-01f, -5.20992160e-01f, -5.44537485e-01f,
  -9.74705666e-02f, -6.35643423e-01f, 3.43402207e-01f, 6.80031121e-01f, -3.21463585e-01f, -3.09682637e-01f, 5.56412101e-01f, 2.36797556e-01f, 8.13241661e-01f, -1.20886892e-01f,
  -1.68835074e-01f, 5.84496379e-01f, 3.93573523e-01f, -5.62352002e-01f, 4.33585912e-01f, 8.80189836e-01f, -1.09049952e+00f, -5.82309484e-01f, -5.13291895e-01f, -2.65354216e-01f,
  3.31319571e-01f, -2.06702739e-01f, -1.21832514e+00f, -7.80757129e-01f, -6.24074817e-01f, -5.80204904e-01f, 2.95979589e-01f, -7.57947683e-01f, 6.91541731e-01f, -2.28479773e-01f,
  -1.19798970e+00f, 2.45764315e-01f, 3.08920056e-01f, -2.33531475e-01f, -7.54966795e-01f, -1.09116626e+00f, 2.67748624e-01f, -2.82483101e-01f, 9.31629352e-03f, -2.57670283e-01f,
  -2.55145311e-01f, -1.92480370e-01f, 7.61343658e-01f, 1.39459014e-01f, -8.60894024e-02f, 2.69589335e-01f, 2.75966555e-01f, 1.35780007e-01f, -1.18550524e-01f, -1.69858384e+00f,
  2.23008394e-01f, 6.10809088e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.34376237e-01f, 7.83623397e-01f, 2.21712645e-02f, -5.65677524e-01f, 6.48210868e-02f, 5.02635166e-02f, -1.15194879e-01f, 6.42126203e-02f, -7.51672462e-02f, -1.96956322e-01f,
  -3.16163898e-01f, -8.30479339e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    