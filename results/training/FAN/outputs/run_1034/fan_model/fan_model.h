/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.53376818e-01f, -5.39062142e-01f, -6.32378757e-02f, 5.72928190e-02f, 6.10524192e-02f, -3.98348942e-02f, -2.09297791e-01f, -4.26955633e-02f, 1.24184012e-01f, -2.20823452e-01f,
  -7.32963607e-02f, 2.83613086e-01f, 1.07807092e-01f, 5.17245680e-02f, 8.07024166e-03f, -1.92677528e-01f, -1.04704253e-01f, 1.19771995e-01f, 1.68814480e-01f, -7.89670087e-03f,
  2.71335971e-02f, 3.48381922e-02f, 1.03256941e-01f, 9.30406973e-02f, -8.45966935e-02f, 6.30603805e-02f, -1.97953388e-01f, -1.24259256e-01f, -3.24875355e-01f, -4.43235725e-01f,
  -1.39329180e-01f, -3.62613320e-01f, 9.14186537e-02f, -1.04044437e-01f, -3.03296801e-02f, -2.01138947e-02f, -2.96878982e-02f, -1.13434054e-01f, -2.10432317e-02f, -4.59180512e-02f,
  -7.38742277e-02f, -1.06697328e-01f, -5.19835809e-03f, -5.62982745e-02f, -3.43666263e-02f, -9.40830410e-02f, -1.02383852e-01f, -5.38589098e-02f, 1.18604358e-02f, -6.74412325e-02f,
  -1.29285678e-01f, -7.75274038e-02f, -1.69308186e-01f, -1.08501218e-01f, -6.91844942e-03f, -6.45258874e-02f, -9.43611339e-02f, -8.90217498e-02f, -8.98153558e-02f, -2.76847541e-01f,
  -1.96488015e-02f, 4.64892276e-02f, 6.18966445e-02f, 2.60857940e-02f, 9.52777043e-02f, 5.67517988e-02f, -1.91999059e-02f, 5.60458079e-02f, 7.97727779e-02f, 2.78015155e-02f,
  -3.02600395e-03f, 7.42223784e-02f, -3.57415117e-02f, 4.17394489e-02f, -6.38226792e-02f, -2.34301807e-03f, 2.04027258e-02f, 8.03232938e-02f, 9.09474562e-04f, 2.27635484e-02f,
  1.83271524e-02f, -2.75284331e-02f, 1.65310293e-03f, 1.93157736e-02f, -8.08332339e-02f, 1.29066389e-02f, 4.47143577e-02f, 8.49954784e-03f, -4.31831321e-03f, 7.93496054e-03f,
  3.14067125e-01f, -2.98122060e-03f, -1.70852989e-02f, -4.27250415e-02f, 3.52118947e-02f, -5.47001809e-02f, -2.10163072e-02f, 1.31262243e-02f, -9.80128068e-03f, -1.73562076e-02f,
  -4.79173511e-02f, -9.86737851e-03f, -8.90921522e-03f, -2.29184073e-03f, -3.32932593e-03f, 7.79917017e-02f, 5.77516900e-03f, 4.23187800e-02f, -4.55808006e-02f, 6.57891333e-02f,
  2.70799976e-02f, 1.24944396e-01f, 2.00185910e-01f, 2.75151227e-02f, -1.62608530e-02f, 1.52469233e-01f, 1.02281965e-01f, 7.16672987e-02f, 1.46089897e-01f, 7.79143572e-02f,
  6.06383264e-01f, 1.06359012e-01f, -2.75884181e-01f, 8.69449973e-02f, -1.85781747e-01f, -1.97774008e-01f, -2.70005465e-01f, -4.79207560e-02f, 3.61511344e-03f, -3.11813094e-02f,
  6.54309690e-02f, -1.79314110e-02f, -2.80582961e-02f, 6.47898903e-03f, 2.48774029e-02f, -3.41647536e-01f, -1.64230660e-01f, -8.41419920e-02f, -2.03563154e-01f, -1.13201633e-01f,
  -2.27618262e-01f, -2.67425682e-02f, 1.54820532e-01f, -4.78354134e-02f, -1.29056484e-01f, -2.09620580e-01f, -2.72333361e-02f, -8.96174759e-02f, -8.82021263e-02f, -2.04737335e-02f,
  -2.11050808e-01f, 1.92138314e-01f, -1.58069909e-01f, -2.35597626e-03f, -2.31392905e-02f, 2.69947089e-02f, -4.51350622e-02f, 1.19492680e-01f, 1.10002980e-01f, -5.68467639e-02f,
  -1.59502737e-02f, -6.15414372e-03f, 3.00945323e-02f, -1.41982749e-01f, -5.59794828e-02f, -1.14239156e-01f, -5.01357466e-02f, -6.31917035e-03f, 4.71983887e-02f, -1.20561607e-01f,
  -4.37233560e-02f, -1.35691073e-02f, 1.53443739e-02f, -4.85082194e-02f, -5.86837865e-02f, 7.53084943e-02f, -9.68580097e-02f, 6.78064004e-02f, -4.09188606e-02f, 2.87246215e-03f,
  -1.09289968e-02f, 7.30713606e-02f, 1.68717653e-02f, 6.75371885e-02f, 8.30387101e-02f, 3.33986878e-02f, 1.32135227e-01f, -1.52418448e-03f, 2.02862006e-02f, -1.48979593e-02f,
  5.81830367e-02f, 9.74560156e-02f, 3.47691588e-02f, 5.61767668e-02f, 4.86598499e-02f, 1.06716454e-01f, 1.04166076e-01f, 4.69662175e-02f, 7.36110061e-02f, 1.61636844e-01f,
  1.13311470e-01f, 1.48759797e-01f, 2.16311608e-02f, 1.46361277e-01f, 7.46333227e-02f, 1.01686455e-01f, 1.09423295e-01f, 1.86351165e-02f, 1.09313436e-01f, 4.20138687e-02f,
  -7.71915391e-02f, 2.59458087e-02f, -1.47235572e-01f, 4.01946437e-03f, 1.39026633e-02f, -4.50570099e-02f, -4.96891811e-02f, -3.94003140e-03f, -1.57463420e-02f, -8.04075971e-02f,
  -2.81844325e-02f, 2.50984766e-02f, -7.69568086e-02f, -1.22651368e-01f, -4.71748337e-02f, -1.27301469e-01f, 1.20518152e-02f, -7.96110407e-02f, 4.21907343e-02f, -1.18845114e-02f,
  -9.20298770e-02f, -1.82215318e-01f, -5.29106632e-02f, -1.13958389e-01f, -1.04111783e-01f, -1.34878829e-01f, -2.18666568e-01f, -1.35715157e-01f, -8.38750452e-02f, -2.90845782e-01f,
  5.89102320e-02f, -2.83359677e-01f, -9.29758847e-02f, 9.57558230e-02f, 2.55811308e-02f, -2.14583986e-02f, -3.17901939e-01f, 4.43305150e-02f, 2.41304711e-01f, -9.88152325e-02f,
  2.47998927e-02f, 3.14614773e-01f, 3.24919403e-01f, 7.86360577e-02f, 3.27721760e-02f, -3.65936756e-01f, -1.30984247e-01f, -3.33405957e-02f, 1.28545448e-01f, -6.75786212e-02f,
  -1.51344445e-02f, 3.42396386e-02f, 1.74870074e-01f, 1.54441655e-01f, -7.13257268e-02f, 9.42302942e-02f, 9.59568918e-02f, 4.67507988e-02f, 4.49262746e-02f, -2.70684481e-01f,
  -3.22355509e-01f, -5.94817363e-02f, 1.42676488e-01f, 9.70600322e-02f, 8.29521343e-02f, -3.43670622e-02f, -4.96265404e-02f, 9.89138633e-02f, 5.01343869e-02f, 8.34225416e-02f,
  1.32228732e-01f, 1.24903835e-01f, 1.52434304e-01f, 1.24970868e-01f, -1.35809872e-02f, -6.11223560e-03f, 1.02691531e-01f, 1.85464099e-02f, 7.98613504e-02f, -1.38668260e-02f,
  4.91437428e-02f, 7.37835541e-02f, 8.78433436e-02f, 7.39074200e-02f, 3.07915942e-03f, 2.04838574e-01f, 1.06826708e-01f, 7.76733756e-02f, 2.16524914e-01f, 1.42951601e-03f,
  6.56840578e-02f, -4.46655834e-03f, -1.53336981e-02f, -5.60372844e-02f, -7.05392361e-02f, -2.75620855e-02f, -7.43901506e-02f, -7.66302273e-02f, -2.27450263e-02f, -2.09105071e-02f,
  -2.91485130e-03f, -9.67829376e-02f, 5.68876648e-03f, -9.39538479e-02f, -1.14495326e-02f, -9.02978629e-02f, -9.97390077e-02f, -8.04122239e-02f, 8.91849305e-03f, -3.25375237e-02f,
  -2.41816118e-02f, -5.50744298e-04f, -4.98714000e-02f, -4.01446223e-02f, -3.05053424e-02f, -3.18217576e-02f, -7.21148700e-02f, 4.59113009e-02f, 2.15368047e-02f, -4.28066887e-02f,
  1.25483483e-01f, 3.20429802e-01f, -5.17789368e-03f, 5.36529981e-02f, 1.09726395e-02f, 1.53616890e-01f, 9.33345333e-02f, 6.74726516e-02f, 1.39423504e-01f, 5.24952859e-02f,
  7.30678961e-02f, 7.91488588e-02f, 6.34931624e-02f, 1.05020955e-01f, 8.15831721e-02f, 1.38008639e-01f, -1.36824045e-02f, 1.12729870e-01f, 5.99784851e-02f, 4.08212729e-02f,
  7.99602047e-02f, 1.22688703e-01f, 5.55181764e-02f, 7.73200840e-02f, 1.41154662e-01f, 1.56129271e-01f, -2.93951947e-02f, 2.75114700e-02f, 2.33352855e-02f, -9.71093401e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.43916261e-01f, -1.30140156e-01f, 2.48458937e-01f, 3.41876447e-02f, 2.14858085e-01f, 2.71109730e-01f, 4.97574568e-01f, 1.63446799e-01f, -4.92906235e-02f, 4.36519459e-02f,
  -2.51129091e-01f, -6.55046761e-01f, -5.33561945e-01f, -5.19576967e-01f, -1.41239285e-01f, 3.53285551e-01f, 2.64586538e-01f, 1.48934752e-01f, 7.81413075e-03f, 1.35390356e-01f,
  -6.80739433e-02f, 1.60725936e-01f, 1.62119687e-01f, 1.18792050e-01f, -7.68025033e-03f, -4.75085266e-02f, 1.25010997e-01f, 1.90348640e-01f, -8.85231271e-02f, -1.18383132e-01f,
  -1.24813631e-01f, 1.69275150e-01f, -1.41311198e-01f, -2.17007607e-01f, -9.88248810e-02f, -1.47885323e-01f, -7.15900362e-02f, -6.18476281e-03f, 2.63659563e-02f, 1.76150184e-02f,
  -1.94835544e-01f, -5.40184826e-02f, -1.92558035e-01f, -2.91556716e-02f, 3.60134132e-02f, 2.29419470e-02f, 8.37441757e-02f, -8.30354542e-02f, -1.83164507e-01f, -1.71351805e-01f,
  -2.00402960e-01f, 5.65095283e-02f, 9.41908956e-02f, -1.14709269e-02f, -1.09575085e-01f, -1.23553589e-01f, 5.00665978e-02f, -5.94415776e-02f, -1.40681759e-01f, 3.63927931e-02f,
  -1.82436965e-02f, -9.19093285e-03f, -7.16140568e-02f, 3.26364003e-02f, 3.56730297e-02f, 7.14309439e-02f, 1.12475287e-02f, -5.35675660e-02f, -7.40199164e-02f, 3.77395339e-02f,
  -1.09047689e-01f, -2.79153269e-02f, -6.33640438e-02f, -5.26133068e-02f, -2.14070648e-01f, -4.09455374e-02f, 2.64012963e-02f, -5.48579730e-02f, -1.97151098e-02f, -2.46275794e-02f,
  2.27250531e-02f, -1.86133329e-02f, -1.52912724e-03f, -1.00540549e-01f, 3.07434443e-02f, -1.16956651e-01f, -1.22792028e-01f, -1.48668990e-01f, -1.84342498e-03f, -2.58102883e-02f,
  -2.60893077e-01f, -1.04733706e-01f, -1.18183075e-02f, -1.41795814e-01f, 1.74556360e-01f, -6.66798353e-02f, -2.12118372e-01f, -8.01450983e-02f, -4.24319915e-02f, -7.20378831e-02f,
  -6.95311502e-02f, -3.80416475e-02f, -1.28662482e-01f, 8.19342304e-03f, 1.47333816e-01f, 4.56982059e-03f, -1.77900970e-01f, -9.77578014e-02f, -5.91262765e-02f, -6.28486052e-02f,
  -3.49626802e-02f, 2.63410830e-03f, 6.46807551e-02f, -2.91039087e-02f, -1.46433622e-01f, -2.14767065e-02f, 7.77064115e-02f, 2.52591595e-02f, 1.68022871e-01f, 3.73423815e-01f,
  -3.29004347e-01f, 3.40758145e-01f, -1.71143293e-01f, 7.97099695e-02f, 2.46457100e-01f, 1.75863057e-01f, 2.71581233e-01f, 1.99039817e-01f, 2.02566609e-01f, 1.40272632e-01f,
  4.89261262e-02f, 1.03760473e-01f, 8.88446420e-02f, 2.12283120e-01f, 6.94142729e-02f, 2.10675865e-01f, 3.12375188e-01f, 4.50390764e-02f, -1.56582981e-01f, 7.67506137e-02f,
  2.76520610e-01f, 6.23800093e-03f, -2.28901923e-01f, 8.13087374e-02f, 1.84078142e-01f, -2.85929680e-04f, 6.20686673e-02f, 7.70541728e-02f, 1.24132380e-01f, 3.09757173e-01f,
  -2.59931087e-01f, -1.66819498e-01f, -1.64671689e-01f, -8.84395614e-02f, -1.12323865e-01f, -5.59383556e-02f, -9.58410949e-02f, -7.26681426e-02f, -8.01488459e-02f, -1.47657264e-02f,
  5.27936183e-02f, 3.46786566e-02f, 9.19031650e-02f, 3.80711257e-03f, -7.11494908e-02f, -1.06415905e-01f, 8.73411149e-02f, -3.41771841e-02f, -5.72493998e-03f, 1.12801101e-02f,
  1.76202044e-01f, 6.66584000e-02f, 7.84707256e-03f, -6.95392862e-02f, -8.60928744e-02f, -1.22803964e-01f, -5.53164855e-02f, -4.18439396e-02f, -2.55015969e-01f, -1.50331214e-01f,
  -2.23774672e-01f, 1.62303209e-01f, 1.25324905e-01f, -5.03689088e-02f, 9.61410031e-02f, -1.48905814e-01f, -1.25745013e-02f, 1.21535975e-02f, 1.05710372e-01f, 3.98748480e-02f,
  1.00284837e-01f, 4.04487783e-03f, -6.03752621e-02f, -1.19757764e-01f, -1.78996492e-02f, -7.30777159e-02f, -4.98500541e-02f, -2.64556557e-02f, 3.80005427e-02f, -3.75830345e-02f,
  -9.65054706e-03f, -1.00237325e-01f, -6.21676221e-02f, 8.41916725e-02f, 1.67996846e-02f, -1.79810356e-02f, 1.12650823e-02f, 2.96993516e-02f, 5.54656982e-02f, -6.40006512e-02f,
  -1.49902880e-01f, -1.24006547e-01f, -1.23147555e-01f, 1.17342204e-01f, 6.47457615e-02f, -1.53256074e-01f, -6.00004643e-02f, 3.45101804e-02f, -3.98045927e-02f, -1.94659263e-01f,
  -1.74143404e-01f, -7.14758784e-02f, -9.05939117e-02f, 1.35524422e-02f, -1.10975675e-01f, -7.71859847e-03f, 1.77032631e-02f, 8.93054008e-02f, -6.57662936e-03f, -8.11351165e-02f,
  -2.27763336e-02f, -1.03699811e-01f, -1.63328737e-01f, -8.78155157e-02f, -9.03485939e-02f, -3.29853557e-02f, -1.65745199e-01f, -1.35508373e-01f, -2.29505792e-01f, -2.48218730e-01f,
  5.67648947e-01f, 6.58313707e-02f, 2.02382445e-01f, 1.38500482e-01f, 9.87353101e-02f, 1.61288902e-01f, 2.46280462e-01f, 2.48092696e-01f, 2.44908720e-01f, 1.39092943e-02f,
  -6.08338788e-02f, 1.89924892e-02f, 3.87278758e-02f, 8.10378790e-03f, 7.18034059e-02f, 1.89831689e-01f, 1.80807367e-01f, 9.32322070e-02f, 8.52353722e-02f, 1.66665688e-01f,
  -1.74373258e-02f, 1.77807659e-01f, 1.46499082e-01f, 6.92663416e-02f, -5.14877103e-02f, 9.50551704e-02f, -2.07326971e-02f, -3.52248140e-02f, -1.76243261e-01f, 5.50807687e-03f,
  -4.77013797e-01f, -1.42237455e-01f, 1.12740122e-01f, -7.67634735e-02f, -8.39428976e-02f, 3.02453861e-02f, 1.13163844e-01f, -2.42976341e-02f, -8.88223574e-02f, -4.85572964e-02f,
  -4.31973860e-02f, -1.36451930e-01f, -1.91403970e-01f, -8.78744051e-02f, -1.14745319e-01f, -5.04892170e-02f, -8.62405673e-02f, 1.42308353e-02f, 7.29744658e-02f, -1.51187137e-01f,
  -5.00743873e-02f, -1.92873031e-01f, -1.39313966e-01f, -7.68608153e-02f, -8.02044291e-03f, -1.04256727e-01f, -7.76585639e-02f, -1.62971038e-02f, 1.13940155e-02f, 2.81807799e-02f,
  1.78420588e-01f, 3.56208496e-02f, -2.21291989e-01f, -6.61878139e-02f, -2.01640993e-01f, -1.05910264e-01f, -7.49774352e-02f, 9.83117595e-02f, 8.82539153e-02f, 9.15005580e-02f,
  -5.98310716e-02f, -2.02834755e-02f, 1.61517714e-03f, -1.23047484e-02f, -6.09333254e-02f, -4.33184728e-02f, 7.60304406e-02f, -2.65271962e-01f, -2.34608710e-01f, -1.90049663e-01f,
  -1.62122101e-01f, -9.32299495e-02f, -1.51623473e-01f, -1.58345222e-01f, -4.26787324e-02f, 2.23914795e-02f, -1.32080719e-01f, -4.09840308e-02f, 1.66501582e-01f, 5.26463874e-02f,
  -1.41929775e-01f, -1.74000338e-01f, -9.17264447e-02f, 1.67922199e-01f, -1.29633695e-01f, -4.60825376e-02f, -1.00871831e-01f, -1.82994202e-01f, -1.02605484e-01f, -1.10889174e-01f,
  -5.93452752e-02f, 3.74094844e-02f, -6.92679957e-02f, -2.77261790e-02f, 3.66846547e-02f, 1.64645817e-02f, -1.39102340e-02f, 2.37683341e-01f, 5.10844439e-02f, -9.61248428e-02f,
  5.75615140e-03f, 2.70577490e-01f, 1.92680284e-01f, 9.80973691e-02f, 2.03052238e-01f, 2.03995347e-01f, -6.73773233e-03f, -2.83113867e-02f, 1.45589784e-01f, 2.38453060e-01f,
  6.77253962e-01f, 2.11214989e-01f, 2.88932174e-01f, 3.02947104e-01f, 3.24634075e-01f, 3.61063778e-01f, 3.29385370e-01f, 1.57970563e-01f, 1.50587365e-01f, 2.64299065e-01f,
  1.43452600e-01f, 7.04933554e-02f, -1.67683661e-02f, 1.36673311e-02f, 8.81590843e-02f, -8.01988039e-03f, -1.96472406e-01f, -4.13438194e-02f, -2.99091116e-02f, -5.45526817e-02f,
  -1.16549388e-01f, -8.68402272e-02f, 7.26544484e-02f, -8.15705732e-02f, -1.23946451e-01f, 3.22658778e-03f, -8.98309331e-03f, -3.10253054e-02f, -1.03746414e-01f, -3.01775604e-01f,
  -2.04249948e-01f, 1.93677232e-01f, -3.02848548e-01f, 1.38191984e-03f, 4.85756733e-02f, -6.75352067e-02f, -6.13997094e-02f, -1.32847846e-01f, -9.08988491e-02f, -5.30739725e-02f,
  -2.76495982e-02f, -4.70316112e-02f, -6.72670007e-02f, -1.16188705e-01f, -2.81179287e-02f, 2.47243401e-02f, -1.36040047e-01f, -1.38560802e-01f, -6.07552417e-02f, -9.11819041e-02f,
  -1.41442657e-01f, 4.74842526e-02f, 3.67124286e-03f, 1.69982016e-01f, 1.56344891e-01f, -7.67732486e-02f, 8.42083469e-02f, 4.28437106e-02f, 5.94495516e-03f, 5.82657158e-02f,
  -1.79173604e-01f, 1.19352162e-01f, 1.84493676e-01f, 8.95902142e-02f, 2.07505986e-01f, 9.56674963e-02f, -2.83327177e-02f, 3.55511159e-02f, 3.87608930e-02f, 1.68772303e-02f,
  2.70667067e-03f, -3.61467078e-02f, -8.71630162e-02f, -1.12347908e-01f, 1.48358336e-02f, -3.46202143e-02f, -1.08965322e-01f, -6.68758410e-04f, 5.03260046e-02f, -5.01650311e-02f,
  1.22369252e-01f, -1.17289484e-01f, -6.55961186e-02f, -1.38606727e-01f, -1.12621740e-01f, 1.94559246e-02f, -1.39596701e-01f, 2.39232536e-02f, -9.97503400e-02f, -6.85574189e-02f,
  -2.60608971e-01f, 1.00368783e-01f, -7.25795701e-02f, -5.02284281e-02f, 5.98264039e-02f, -1.40813841e-02f, 4.14280519e-02f, -1.08504407e-02f, -9.75088403e-02f, -5.62899671e-02f,
  -1.42967300e-02f, 3.49485800e-02f, -1.05141904e-02f, 6.95500076e-02f, -9.21844244e-02f, 4.17757481e-02f, -4.58798651e-03f, 6.24298817e-03f, -2.21716851e-01f, -1.01081520e-01f,
  -1.59821108e-01f, -6.16853032e-03f, 9.49616358e-02f, 1.72774091e-01f, 8.24198052e-02f, -1.15911894e-01f, -6.68417721e-04f, -2.67330874e-02f, 8.05707425e-02f, 1.21889994e-01f,
  -7.44449973e-01f, -5.24604380e-01f, 3.02805781e-01f, -1.41985312e-01f, 3.89250159e-01f, 4.15886015e-01f, 4.29491997e-01f, 1.28474683e-01f, -1.17230535e-01f, 1.02170967e-02f,
  -1.09292321e-01f, -7.23055303e-02f, -9.70955417e-02f, 5.16003706e-02f, -2.93321963e-02f, 3.41314435e-01f, 3.03441435e-01f, 1.21894721e-02f, 1.79670990e-01f, 2.21717879e-01f,
  7.12184310e-02f, -1.73290253e-01f, -3.56950879e-01f, -7.06561357e-02f, -1.18851036e-01f, 1.18259840e-01f, -9.18343365e-02f, -2.05598608e-01f, -4.23181169e-02f, -2.91520432e-02f,
  2.12054431e-01f, -3.19987714e-01f, 1.92143530e-01f, -1.70837656e-01f, -1.33073762e-01f, -1.52019545e-01f, -2.62631215e-02f, -5.78361638e-02f, -1.47468969e-01f, 4.16258126e-02f,
  -2.31421627e-02f, -1.39950424e-01f, -4.68434319e-02f, -7.86971599e-02f, -1.20222986e-01f, -1.85508698e-01f, -1.93818673e-01f, -1.43811971e-01f, -7.73949400e-02f, -1.12491466e-01f,
  -1.69673786e-01f, -1.79126412e-01f, 9.67795923e-02f, 5.89069575e-02f, 1.60167608e-02f, 5.82401901e-02f, -6.31427839e-02f, -3.58296260e-02f, -9.54178795e-02f, -9.42856595e-02f,
  7.51324072e-02f, -1.15053050e-01f, -7.01286420e-02f, -2.03276961e-03f, 4.72206362e-02f, 9.40098986e-02f, 5.50807044e-02f, 3.76099609e-02f, 1.55069642e-02f, -8.55028927e-02f,
  -5.92262037e-02f, -6.21897057e-02f, 1.12965465e-01f, 7.86728133e-03f, -2.11213361e-02f, -3.23545970e-02f, -1.50317505e-01f, -1.15632504e-01f, -1.19974084e-01f, -8.64996612e-02f,
  4.21266444e-02f, 5.36850244e-02f, -1.04065903e-01f, 4.85472269e-02f, 2.92664468e-02f, -4.85618375e-02f, -1.51073132e-02f, -1.74741879e-01f, 1.33393062e-02f, -5.76766580e-03f,
  1.58425912e-01f, 1.48681074e-01f, 8.47868770e-02f, 2.62375828e-02f, 8.38797763e-02f, -2.34591961e-01f, -4.87417821e-03f, -2.96583269e-02f, -3.14746089e-02f, 1.85466558e-01f,
  -9.80314612e-02f, -1.17161393e-03f, 2.49544512e-02f, -5.67154177e-02f, 2.67502312e-02f, -2.07054298e-02f, -3.11233699e-01f, -4.63146605e-02f, 1.10845394e-01f, 2.39857864e-02f,
  -1.92796830e-02f, 3.10145076e-02f, 1.41176358e-01f, 1.64967403e-01f, 1.13216177e-01f, 2.47777253e-01f, 8.41493905e-02f, 9.85301379e-03f, 9.49758068e-02f, 1.52483881e-01f,
  -3.13241541e-01f, -6.50593400e-01f, 5.30440770e-02f, -1.70490935e-01f, -2.00788528e-01f, -2.42556155e-01f, -5.23557961e-01f, -1.81008190e-01f, -1.02766110e-02f, -6.14006221e-01f,
  -2.44020328e-01f, 6.86507951e-03f, 2.15296999e-01f, 7.25488290e-02f, -2.80187521e-02f, -4.21793789e-01f, -1.06236435e-01f, 2.92309016e-01f, 3.15805525e-01f, -3.20870906e-01f,
  -2.12872893e-01f, 9.67017189e-02f, 2.63177216e-01f, 1.68854505e-01f, -4.82184887e-01f, -1.61948234e-01f, -2.83143669e-02f, -1.70928240e-01f, -3.74692857e-01f, -5.74312210e-01f,
  -5.59938431e-01f, -3.84547472e-01f, 3.35438550e-01f, 1.89025640e-01f, -5.03125153e-02f, -1.19514085e-01f, -2.90385336e-01f, -1.27242431e-01f, 1.65076688e-01f, -1.41653478e-01f,
  -1.85070381e-01f, -1.62084743e-01f, 4.37393561e-02f, -1.01614542e-01f, -1.48106620e-01f, -1.12483628e-01f, 6.10038973e-02f, -4.82944511e-02f, 1.87994123e-01f, -2.50270039e-01f,
  -3.45828801e-01f, -2.24235669e-01f, -7.85225704e-02f, 1.25044271e-01f, -8.03652108e-02f, 1.90081894e-01f, -2.46373817e-01f, -3.85062575e-01f, 3.02208811e-02f, -7.22607613e-01f,
  1.71253040e-01f, 9.25660282e-02f, 1.10653147e-01f, -2.58647129e-02f, -1.23522528e-01f, 5.67606241e-02f, -3.07444105e-04f, -3.86490673e-02f, -3.82148698e-02f, -1.71614923e-02f,
  5.94584309e-02f, 8.45442936e-02f, 8.35213289e-02f, 1.17933407e-01f, -8.24980251e-03f, 1.10560626e-01f, -1.41597306e-03f, -5.93279228e-02f, 4.70513105e-02f, 2.22921520e-02f,
  -3.81215177e-02f, -2.02906248e-03f, 3.21313143e-02f, -1.45634711e-01f, 6.51197582e-02f, 4.10331152e-02f, 1.31073192e-01f, 8.15690309e-03f, 1.82105839e-01f, 1.20704502e-01f,
  -2.26501465e-01f, 6.96236074e-01f, -3.20408493e-01f, -1.57204360e-01f, -1.31751215e-02f, 8.80506933e-02f, -2.56702509e-02f, 1.12601712e-01f, -1.32266972e-02f, -2.13926837e-01f,
  -1.49605513e-01f, -1.29646197e-01f, -2.65926458e-02f, 2.10624531e-01f, -2.28189901e-02f, -7.07519650e-02f, -1.72602028e-01f, 1.78429876e-02f, 2.42765293e-01f, 2.73656882e-02f,
  1.00112827e-02f, -6.10797182e-02f, -1.55353010e-01f, -2.23136116e-02f, -2.27693588e-01f, -2.26468444e-02f, -9.90101770e-02f, -2.73601115e-01f, 7.37826601e-02f, -4.31334198e-01f,
  1.84224024e-02f, -3.40086251e-01f, -4.61526006e-01f, -1.81793779e-01f, -2.02447161e-01f, -2.30566040e-02f, -1.12035975e-01f, 1.75735891e-01f, 1.14463262e-01f, -1.36383638e-01f,
  3.88299003e-02f, 3.48490506e-01f, 1.16263412e-01f, 1.52276203e-01f, 2.20670447e-01f, -3.08076143e-01f, -3.35793078e-01f, -6.45638779e-02f, 5.16477704e-01f, 2.83318996e-01f,
  1.17214464e-01f, 1.69052392e-01f, 1.06718987e-01f, 9.53568295e-02f, -2.99841732e-01f, 1.27582243e-02f, -3.76734853e-01f, -1.16149344e-01f, -2.67595887e-01f, -6.06790185e-01f,
  -1.86623689e-02f, -2.77980059e-01f, 6.89876229e-02f, -1.53256506e-02f, -1.63590714e-01f, 2.21528877e-02f, -1.30659528e-02f, -2.06418589e-01f, -1.03879973e-01f, -1.21488534e-01f,
  -6.65625185e-02f, 1.44065484e-01f, 1.60660446e-01f, 1.40876144e-01f, 5.57172634e-02f, 1.54965803e-01f, -9.51306373e-02f, -1.14455335e-02f, -6.06168471e-02f, -8.27037618e-02f,
  -4.19031605e-02f, -1.15023285e-01f, -1.69568941e-01f, -1.29716381e-01f, -1.30314469e-01f, -1.74777191e-02f, -1.25350952e-01f, -1.26620844e-01f, -7.26522654e-02f, -2.90640414e-01f,
  1.28045440e-01f, -1.33405253e-01f, -1.32691085e-01f, -7.37298951e-02f, -9.74678695e-02f, -3.71384546e-02f, 5.85856773e-02f, 1.37434043e-02f, 7.30323568e-02f, 1.31414816e-01f,
  5.47634764e-03f, -7.52098039e-02f, -1.90028008e-02f, -1.01744436e-01f, 4.00655679e-02f, 1.96594447e-02f, -9.86571773e-04f, 4.28154208e-02f, -8.17257538e-02f, -1.03682399e-01f,
  3.18901576e-02f, -1.62667349e-01f, -8.03617835e-02f, -5.90785556e-02f, -1.09263957e-01f, -9.95151028e-02f, 2.60979533e-02f, 4.65266146e-02f, 1.47625521e-01f, 6.94002537e-03f,
  3.99369270e-01f, -7.92550743e-02f, 7.35110268e-02f, 4.75888401e-02f, -1.31992891e-01f, -1.65092796e-01f, -1.06699899e-01f, 4.09707166e-02f, 5.09342477e-02f, 2.25063600e-02f,
  -1.03997160e-02f, 1.32041559e-01f, -1.00269951e-01f, -9.99630690e-02f, 1.12157837e-01f, 4.72777188e-02f, -7.16232322e-03f, 7.62824416e-02f, -2.59227753e-02f, -3.49514857e-02f,
  -3.88246845e-03f, 1.04105033e-01f, 1.51540264e-01f, -3.23966518e-02f, -6.47323877e-02f, 8.67563635e-02f, -5.59919104e-02f, 1.29420832e-01f, 2.02711329e-01f, 9.45874080e-02f,
  6.58568203e-01f, -1.27943158e-01f, -4.87445086e-01f, 2.65497360e-02f, -2.15365738e-01f, -1.80474669e-01f, 1.51667476e-01f, 1.63415998e-01f, 4.11688201e-02f, -2.06312463e-02f,
  8.87618065e-02f, 5.30466735e-02f, 1.76279396e-01f, -1.74572412e-02f, 2.27078512e-01f, -4.02409993e-02f, -6.52297586e-02f, 3.59594934e-02f, -4.33165655e-02f, -2.13391051e-01f,
  -1.02092855e-01f, 3.54092494e-02f, 6.62729563e-03f, -7.82167539e-02f, -3.05854112e-01f, -7.57825421e-03f, -1.28890052e-01f, -2.50063986e-01f, -1.42648637e-01f, -3.66583705e-01f,
  -3.83322895e-01f, -3.47695291e-01f, 7.35301375e-02f, 3.70340943e-02f, 1.33007662e-02f, 1.07769802e-01f, 2.95484159e-03f, 5.21174967e-02f, 1.47508502e-01f, 1.60665158e-02f,
  -7.96436965e-02f, 4.75136302e-02f, -4.43921983e-02f, -1.70738157e-03f, -1.53107941e-01f, -1.65844947e-01f, -1.67248204e-01f, -2.39128135e-02f, 1.74604394e-02f, -1.28802031e-01f,
  -1.68873351e-02f, -1.82213217e-01f, -1.19524024e-01f, -1.82359233e-01f, -1.45507023e-01f, -3.37778293e-02f, -2.30270773e-01f, -4.04252112e-01f, -3.12775522e-01f, -1.17203213e-01f,
  4.61954810e-02f, -1.23849893e-02f, -4.86866161e-02f, 3.27098439e-03f, 2.34799907e-01f, 1.56938195e-01f, 7.94360116e-02f, 6.16891161e-02f, 1.47742853e-01f, -7.87265599e-03f,
  -2.14098189e-02f, -1.08543284e-01f, -2.15819683e-02f, 7.39033967e-02f, 6.80171251e-02f, -5.34551851e-02f, -1.07879803e-01f, 9.58813578e-02f, -8.08629543e-02f, 1.49436653e-01f,
  2.05840454e-01f, -1.50340185e-01f, -3.19468528e-02f, 1.03669025e-01f, -2.59909742e-02f, 4.30499809e-03f, -9.86140519e-02f, 9.54571664e-02f, 1.07777558e-01f, 8.03315565e-02f,
  2.12458506e-01f, 2.48661288e-03f, 2.43911341e-01f, -3.16308774e-02f, -5.22213504e-02f, 1.04382947e-01f, -1.42694280e-01f, 2.86433306e-02f, -2.16608997e-02f, -2.89272480e-02f,
  -1.24416664e-01f, -7.92299514e-04f, -5.71920611e-02f, -8.01576227e-02f, 3.08256447e-02f, -1.82952881e-02f, 1.44495159e-01f, 2.01154619e-01f, 7.37954630e-03f, -1.00727156e-01f,
  6.95639476e-02f, 2.67770797e-01f, 2.83667475e-01f, 1.02523744e-01f, -8.62461179e-02f, 1.46747813e-01f, 8.66955444e-02f, 1.14411470e-02f, -1.76209658e-02f, 4.66050893e-01f,
  6.94983676e-02f, 3.89129192e-01f, -3.27799231e-01f, 1.14381775e-01f, 3.45473513e-02f, -3.66888419e-02f, 5.10313988e-01f, 9.63972136e-02f, 1.65324315e-01f, 4.12123740e-01f,
  1.89923495e-01f, -3.26147318e-01f, -2.31440529e-01f, -1.87575191e-01f, -1.95359677e-01f, 4.47414726e-01f, 2.53904611e-01f, -3.83336872e-01f, -5.27530015e-01f, -2.25019589e-01f,
  -4.08779550e-03f, 1.10956535e-01f, -1.87693298e-01f, -6.13248609e-02f, 1.69083789e-01f, -1.72685850e-02f, 1.55011207e-01f, -1.79237589e-01f, -1.18737193e-02f, -8.24798718e-02f,
  -3.69722784e-01f, -2.56393284e-01f, -2.03144506e-01f, -6.49580136e-02f, -1.41659737e-01f, -1.22761153e-01f, -6.84724674e-02f, -2.23087490e-01f, 7.65236914e-02f, 1.38161421e-01f,
  -5.43084927e-02f, -7.44683370e-02f, -2.25263491e-01f, 3.17389891e-02f, -1.00704804e-01f, -1.59259945e-01f, -1.33573338e-01f, -3.74374330e-01f, -1.72311574e-01f, -1.13765106e-01f,
  -1.69447601e-01f, -3.24710160e-01f, -4.52707499e-01f, 3.39696705e-02f, -2.41592988e-01f, -1.56865016e-01f, -1.67754650e-01f, -3.52878541e-01f, -2.95115471e-01f, 1.68309614e-01f,
  -2.55170725e-02f, 6.80976287e-02f, 7.69399293e-03f, 1.50585636e-01f, 2.91035473e-02f, 7.73537382e-02f, -8.60108435e-02f, -1.43446410e-02f, 1.00062452e-01f, 7.12630078e-02f,
  -8.09983816e-03f, 1.28810659e-01f, -3.49549092e-02f, 2.33341068e-01f, 9.65441540e-02f, -1.41584978e-01f, -1.54482061e-02f, 9.31410789e-02f, -3.83342169e-02f, -3.36254528e-03f,
  -1.38650000e-01f, -8.66248906e-02f, -3.04907262e-02f, -1.90354720e-01f, 7.65632279e-03f, -5.69255017e-02f, 1.13060072e-01f, 7.81541914e-02f, 5.84175736e-02f, 1.52042136e-01f,
  3.71729702e-01f, -1.94796786e-01f, 2.41902664e-01f, -2.84147430e-02f, -8.75042975e-02f, 7.17069507e-02f, 1.30016759e-01f, 1.94505490e-02f, 2.70425994e-02f, -1.05208829e-01f,
  -1.81303173e-01f, -7.18723089e-02f, 9.46550071e-02f, 8.06946531e-02f, -8.78489763e-02f, 1.05603881e-01f, 2.20081210e-01f, -4.69724275e-02f, -1.50530040e-03f, 1.50990799e-01f,
  1.66031331e-01f, 1.83598563e-01f, 1.07239142e-01f, 8.61428231e-02f, 1.37652736e-02f, 4.38411608e-02f, 6.51023239e-02f, 1.61958188e-01f, -3.38053703e-02f, 6.54706478e-01f,
  -2.52108455e-01f, 2.86468327e-01f, 7.35048130e-02f, -6.15899339e-02f, 1.71598211e-01f, -8.14923197e-02f, 2.83861384e-02f, -3.28562647e-01f, -1.53687656e-01f, 1.39671460e-01f,
  1.17621452e-01f, 1.18656673e-01f, 7.32128844e-02f, 8.48908350e-02f, -1.32365197e-01f, 3.99854809e-01f, 4.31081682e-01f, -2.13500671e-02f, -4.12764311e-01f, -2.46607959e-01f,
  2.23061472e-01f, 7.83787295e-02f, -3.77928346e-01f, -1.01191700e-01f, 1.34462595e-01f, 3.68920043e-02f, 9.27881747e-02f, 8.32212567e-02f, 1.59063429e-01f, 4.13603336e-01f,
  1.84974939e-01f, -1.23391338e-01f, -1.59745216e-01f, 2.49381997e-02f, -2.86991298e-02f, -1.51392549e-01f, -5.32740727e-02f, -1.22574188e-01f, 1.18732331e-02f, -3.68824564e-02f,
  3.08205128e-01f, -2.60688346e-02f, 1.34810194e-01f, 2.73175873e-02f, -2.76567817e-01f, -2.38821387e-01f, -9.72987637e-02f, -1.99176334e-02f, -1.32438004e-01f, -3.58125865e-01f,
  3.98057431e-01f, 1.05338521e-01f, -2.59971738e-01f, -1.40425697e-01f, -1.04958482e-01f, 3.78955752e-02f, -1.49590760e-01f, -1.22963041e-01f, -3.52044314e-01f, -2.41093248e-01f,
  -6.70647100e-02f, 9.12508443e-02f, 1.31657980e-02f, 2.23706543e-01f, 1.68099880e-01f, 1.44947514e-01f, 1.92126051e-01f, 1.04542188e-01f, 1.94576368e-01f, -7.26253018e-02f,
  -9.31385756e-02f, -1.84671760e-01f, -7.09385797e-02f, -7.25581720e-02f, 6.54173419e-02f, -2.31131054e-02f, 1.15884177e-01f, 8.18518251e-02f, -1.16087258e-01f, -1.26663461e-01f,
  -2.54264232e-02f, -1.13708386e-02f, 2.56414916e-02f, -2.21813753e-01f, 9.86458510e-02f, 1.90143089e-03f, 4.03483734e-02f, 1.29181087e-01f, 7.90090412e-02f, 7.24945776e-03f,
  -2.17956200e-01f, 1.58963561e-01f, 2.58070290e-01f, 2.10700594e-02f, 2.58661583e-02f, -2.27939576e-01f, 2.08445340e-02f, -1.75733209e-01f, -1.61799848e-01f, -2.79003739e-01f,
  -1.04901098e-01f, -2.26678457e-02f, -1.24663105e-02f, -3.39386947e-02f, -3.55658233e-01f, -3.64676304e-02f, 2.13492379e-01f, 7.37489909e-02f, -1.05053477e-01f, -3.32843781e-01f,
  -1.09139364e-02f, -1.19580857e-01f, -2.70951867e-01f, -1.44277900e-01f, -1.27557395e-02f, -1.03895031e-01f, -8.20411369e-02f, -1.41211376e-01f, -2.32204601e-01f, -1.37524128e-01f,
  -5.66054657e-02f, -1.47897452e-01f, -3.20639312e-01f, -2.42572129e-01f, -2.66398668e-01f, -4.83217090e-02f, 6.22323193e-02f, -2.24526096e-02f, -2.22575143e-01f, -1.63714699e-02f,
  -2.35464536e-02f, -5.16957119e-02f, 3.68768466e-03f, -1.67213380e-01f, 6.22093752e-02f, -1.11410484e-01f, -2.24353611e-01f, -1.46964729e-01f, 9.82270911e-02f, -1.48905933e-01f,
  -1.37453839e-01f, -1.24813013e-01f, -1.85591087e-01f, -7.03105628e-02f, -8.90778154e-02f, 9.74119976e-02f, -9.05933380e-02f, -1.92617700e-01f, -2.75252670e-01f, -2.79271722e-01f,
  6.59655854e-02f, -3.36519361e-01f, -4.32351530e-02f, -9.74661335e-02f, 2.07907632e-02f, -4.85758707e-02f, 1.18416391e-01f, 5.78605719e-02f, 7.19355419e-02f, -6.17295131e-02f,
  -1.46874830e-01f, -7.41906092e-02f, 4.03492758e-03f, 1.97563499e-01f, -1.37359714e-02f, -2.47940365e-02f, 1.46579985e-02f, -3.76365259e-02f, -5.79088889e-02f, 7.69799128e-02f,
  -8.26234892e-02f, -4.85692546e-02f, 1.73988953e-01f, 1.53093323e-01f, 1.01959333e-01f, -1.75703794e-01f, 1.02019543e-02f, -6.40828386e-02f, 3.85618210e-02f, -1.42051345e-02f,
  8.23179726e-03f, 3.73074919e-01f, 8.08675364e-02f, 1.78210005e-01f, 2.04029709e-01f, 2.10183725e-01f, 9.38339084e-02f, 2.65452087e-01f, 5.29390685e-02f, 4.45984975e-02f,
  8.10495540e-02f, 2.42889719e-03f, 5.71293570e-02f, -7.39334896e-02f, -1.21639565e-01f, 3.22255827e-02f, -6.36715889e-02f, -4.30207141e-02f, -4.75989059e-02f, -4.87103350e-02f,
  2.63313558e-02f, -1.83910709e-02f, -1.35148987e-01f, -5.19789755e-02f, -2.09205911e-01f, -6.89958408e-02f, -1.92992881e-01f, -3.07290107e-02f, -9.35602561e-03f, -2.17558131e-01f,
  2.02953056e-01f, -2.73916632e-01f, -1.27688749e-02f, 2.83553600e-02f, -1.09593580e-02f, -6.18063547e-02f, -7.57186413e-02f, -7.34369606e-02f, 6.71162910e-04f, -1.56939477e-01f,
  -2.03899533e-01f, -9.87608582e-02f, 3.04236691e-02f, -2.02928726e-02f, 1.14901386e-01f, 1.84092019e-02f, -1.52627185e-01f, 1.84651554e-01f, -7.80346841e-02f, -5.61493300e-02f,
  -3.50229256e-02f, 1.29091442e-01f, 1.83924302e-01f, 1.59871221e-01f, 1.06239870e-01f, 8.57892409e-02f, 1.75109833e-01f, -1.73927173e-02f, 3.48314047e-02f, 2.41814509e-01f,
  1.74916908e-02f, -7.93181136e-02f, 1.49565767e-02f, 2.92468756e-01f, 1.76033765e-01f, -4.34365720e-01f, -8.76446486e-01f, -3.33878875e-01f, 8.41132998e-02f, -1.68255568e-01f,
  6.09570444e-02f, 2.98019052e-01f, 1.90445855e-01f, -1.32273868e-01f, -6.63681209e-01f, -5.56237638e-01f, -2.37354636e-01f, -2.51281708e-01f, -2.33702630e-01f, -1.99242622e-01f,
  -1.90320164e-02f, 1.00477107e-01f, 6.79002702e-02f, -6.33887723e-02f, 2.54706740e-01f, 2.84934312e-01f, 1.81893662e-01f, 2.69058347e-01f, 2.36882437e-02f, 4.76968318e-01f,
  3.26523930e-01f, 1.08513042e-01f, -1.46458358e-01f, 6.84117451e-02f, 1.68070421e-01f, 2.20219232e-02f, -6.43347353e-02f, 6.95838630e-02f, 2.07600594e-01f, 1.22443043e-01f,
  6.41427562e-02f, 5.57683036e-02f, 1.60123948e-02f, 1.96921423e-01f, 2.71338336e-02f, 1.20149506e-02f, -1.51264235e-01f, -2.79723942e-01f, -2.34782189e-01f, -3.11353561e-02f,
  -2.94233393e-02f, 2.56403685e-02f, -1.25506729e-01f, -2.61536777e-01f, -1.42828017e-01f, 1.42224923e-01f, 1.24499984e-01f, 7.43281096e-02f, -6.33947225e-03f, 9.51957256e-02f,
  -1.96369905e-02f, 1.45727873e-01f, 7.23649114e-02f, 6.23523630e-02f, 1.22663811e-01f, -2.40796916e-02f, 7.94005245e-02f, 1.52140885e-04f, 4.73858751e-02f, -1.06660336e-01f,
  -2.91450452e-02f, -2.90833898e-02f, 1.62025876e-02f, -9.88026150e-03f, 2.18108952e-01f, 8.59287530e-02f, 9.01069492e-02f, -1.25567121e-02f, -3.30250524e-02f, 1.05970576e-01f,
  5.16827479e-02f, 4.98188846e-02f, 1.94038764e-01f, -6.40553162e-02f, -9.61849466e-03f, 3.11882538e-03f, 5.25313057e-02f, -1.11498674e-02f, 1.16412684e-01f, 1.21515229e-01f,
  2.78159469e-01f, -2.94791520e-01f, 3.61270420e-02f, -9.66277868e-02f, -1.60196442e-02f, -1.01646641e-02f, 9.32777524e-02f, -3.62917110e-02f, 1.38882205e-01f, -9.87307206e-02f,
  -2.42037550e-01f, 5.52646955e-03f, -1.61168333e-02f, -1.38174281e-01f, -3.19392979e-02f, 5.47073148e-02f, -8.31288546e-02f, 3.37995142e-02f, -2.75984943e-01f, -7.39201112e-03f,
  -1.31928056e-01f, -3.15118402e-01f, -2.71855831e-01f, -1.40655980e-01f, 5.95612451e-02f, -6.39212951e-02f, -8.11772794e-02f, -3.54554765e-02f, -3.50904405e-01f, -3.14717621e-01f,
  1.65272057e-01f, 1.14882849e-01f, 2.30184589e-02f, 1.49127292e-02f, 3.99535507e-01f, 5.70931025e-02f, -9.86832473e-03f, -1.06155440e-01f, 6.23768717e-02f, 1.26434445e-01f,
  2.09784105e-01f, 8.45337659e-02f, -8.05697814e-02f, -3.37194800e-01f, -7.63749957e-01f, -2.26035789e-01f, -2.91795284e-01f, -3.83333951e-01f, -5.25014699e-01f, -2.82444149e-01f,
  2.22906955e-02f, -2.46710852e-01f, -3.95287871e-01f, -3.68767500e-01f, 3.52416672e-02f, -1.02288581e-01f, -6.39788359e-02f, -5.17217107e-02f, -8.07811469e-02f, 1.83175832e-01f,
  2.77807683e-01f, 1.69885501e-01f, -2.20007285e-01f, -2.96375267e-02f, 4.39504348e-02f, -1.00394763e-01f, -3.33375633e-02f, -1.87616255e-02f, 1.53938094e-02f, 8.33151639e-02f,
  -7.92175811e-03f, -9.66208950e-02f, 1.84128225e-01f, -1.44993633e-01f, -1.27655081e-02f, -9.17816535e-02f, -1.42217904e-01f, -3.13618392e-01f, -2.23054543e-01f, 2.01528698e-01f,
  2.00038791e-01f, 1.64208502e-01f, 1.33508798e-02f, -1.50235221e-01f, -2.58986056e-01f, -6.79245666e-02f, -1.90445647e-01f, -2.03423455e-01f, -3.19633693e-01f, -3.14736366e-01f,
  -7.44388551e-02f, 1.65331773e-02f, -3.06991469e-02f, 1.03408806e-01f, -6.42600134e-02f, 1.14968322e-01f, -8.55690893e-03f, -8.33061561e-02f, -7.90158063e-02f, -1.83498450e-02f,
  1.98225062e-02f, 7.46374801e-02f, 3.21569331e-02f, -4.90281805e-02f, -1.82247728e-01f, 2.58627646e-02f, -6.77538589e-02f, -2.34287113e-01f, -2.20312968e-01f, -1.20760482e-02f,
  2.41070781e-02f, 8.99848640e-02f, 4.28668000e-02f, -1.52107775e-01f, -1.10970691e-01f, -9.93057042e-02f, -9.72049460e-02f, -2.11443931e-01f, -2.15372853e-02f, 3.11392676e-02f,
  -1.06044583e-01f, -8.77644569e-02f, -1.77696589e-02f, -1.94001213e-01f, -2.59864554e-02f, 1.53948460e-02f, 1.57347232e-01f, -1.26553178e-01f, 4.69630025e-02f, -1.66156575e-01f,
  -8.65654089e-03f, -6.87885582e-02f, 1.36916146e-01f, -2.41883304e-02f, -6.10832460e-02f, -7.48101473e-02f, -2.31348261e-01f, -4.81352815e-03f, -1.57123268e-01f, 1.06362335e-01f,
  -1.48821801e-01f, -3.25397551e-01f, -7.39125311e-02f, -1.34041339e-01f, -1.26761958e-01f, -3.84186357e-01f, -3.48657936e-01f, -2.52083004e-01f, -3.35436493e-01f, -3.93357992e-01f,
  7.11433113e-01f, 3.44118237e-01f, 1.73413917e-01f, 3.08235437e-01f, 3.30418833e-02f, 2.43973866e-01f, 3.32793415e-01f, 4.11906004e-01f, 6.62024245e-02f, 2.20427990e-01f,
  1.63088992e-01f, 5.19418344e-02f, 1.17052346e-01f, 5.16969413e-02f, 1.21381633e-01f, -1.20895267e-01f, -1.71898678e-01f, -4.39598598e-02f, 1.84452921e-01f, 2.11352780e-01f,
  -4.99787517e-02f, -2.98118312e-02f, 2.11369619e-01f, 7.44615570e-02f, -1.09652162e-01f, 1.70388620e-03f, -1.26762673e-01f, -1.44041613e-01f, -6.01460114e-02f, -3.46125603e-01f,
  -5.19399457e-02f, 3.17416161e-01f, -1.38243005e-01f, 4.65642735e-02f, -1.63440093e-01f, 9.17932019e-02f, 9.61389989e-02f, 5.57462219e-03f, -3.36922556e-02f, -3.77996303e-02f,
  -8.75848234e-02f, -2.98623368e-02f, -8.34698081e-02f, -2.34557837e-02f, -1.17023349e-01f, -1.62803493e-02f, -7.07342550e-02f, -6.06973171e-02f, -8.85677561e-02f, 2.92608831e-02f,
  -2.33840451e-01f, -2.05269247e-01f, 5.16533218e-02f, 1.32484743e-02f, 9.81716719e-03f, -1.47883758e-01f, -1.83267117e-01f, -2.00186595e-02f, 1.52380019e-02f, -9.49114114e-02f,
  -1.23946466e-01f, -3.16224508e-02f, -1.59655228e-01f, 9.17794406e-02f, -7.31479330e-03f, -1.13658592e-01f, -1.90314442e-01f, -2.47460812e-01f, -6.64955527e-02f, 3.65246348e-02f,
  -5.87840118e-02f, -7.86417499e-02f, -5.04308268e-02f, -3.46653238e-02f, -9.02986750e-02f, -6.56711385e-02f, -2.65741907e-02f, 1.75966276e-03f, -3.77151258e-02f, -5.33135645e-02f,
  3.10612805e-02f, -2.20585287e-01f, 7.48940781e-02f, -9.81822833e-02f, 3.00411768e-02f, 1.17526963e-01f, 2.11431794e-02f, -1.63073316e-02f, 3.60974297e-02f, 5.65514304e-02f,
  2.09772319e-01f, -9.23443958e-03f, -1.15669660e-01f, -2.43941292e-01f, -1.15087815e-01f, 3.83180240e-03f, 7.12880492e-02f, -1.37666717e-01f, -6.28864020e-02f, 1.11467004e-01f,
  6.11521341e-02f, 3.50424983e-02f, -4.00664173e-02f, 4.83432636e-02f, -1.15351021e-01f, -7.23265633e-02f, -4.70933095e-02f, -1.42375559e-01f, -3.30606028e-02f, -1.50846124e-01f,
  -1.95249662e-01f, -4.28841487e-02f, 5.08636981e-02f, -6.21612044e-03f, -5.46482056e-02f, 4.39517274e-02f, -1.88193336e-01f, -1.53286904e-01f, 1.60156399e-01f, 7.89397433e-02f,
  4.34498727e-01f, -6.15023822e-02f, 2.52734780e-01f, 1.94481373e-01f, 1.89217806e-01f, 3.35746706e-01f, 3.83630246e-01f, 3.13028157e-01f, -4.14756387e-02f, 6.23583701e-03f,
  -4.28672694e-02f, -3.00481711e-02f, 1.38450218e-02f, -1.02684565e-01f, -9.10063460e-02f, -7.67634213e-02f, -8.16605985e-02f, 1.08801313e-02f, 1.58562526e-01f, 2.46335536e-01f,
  2.03177077e-03f, 2.47558169e-02f, 7.25713670e-02f, -9.27898064e-02f, -1.05016679e-01f, -8.05732980e-02f, 8.15769285e-03f, -1.16722561e-01f, -1.28509760e-01f, -3.32869649e-01f,
  -2.41766170e-01f, 1.59661740e-01f, -6.84845820e-02f, -5.26989289e-02f, -4.29441184e-02f, -1.24251880e-01f, -7.56634492e-03f, -8.19367096e-02f, -1.81202576e-01f, -1.12476774e-01f,
  -3.20903934e-03f, 6.03479743e-02f, 1.22179471e-01f, -2.49851532e-02f, 2.95590721e-02f, 6.85192272e-02f, -4.93212156e-02f, 1.86023161e-01f, 9.14914832e-02f, -3.85665596e-02f,
  1.11677060e-02f, 4.91633862e-02f, 1.86042219e-01f, 1.01024523e-01f, 1.98734496e-02f, -1.72218401e-02f, -5.84031455e-02f, 5.19471988e-02f, 5.25255762e-02f, 4.40985337e-02f,
  2.32294232e-01f, 2.41114289e-01f, 1.30518094e-01f, 9.50461105e-02f, 1.47273093e-02f, -2.23291558e-04f, -9.55430940e-02f, 8.70858356e-02f, 3.36094685e-02f, 1.55758664e-01f,
  8.98885578e-02f, 6.46402836e-02f, 1.67744249e-01f, 2.18124837e-01f, 7.77446479e-02f, 1.40498996e-01f, 4.27947678e-02f, -2.00704932e-02f, -1.35316188e-03f, -6.16283715e-03f,
  7.65301660e-02f, 1.53304115e-01f, 8.74875672e-03f, 1.20630473e-01f, 3.86438146e-02f, 1.07963823e-01f, 1.04123428e-01f, 4.89816293e-02f, 5.03753722e-02f, 1.14486404e-01f,
  -1.42598435e-01f, 1.94370717e-01f, -5.65487966e-02f, -1.17794253e-01f, -2.70265900e-02f, -1.27323046e-01f, -3.50524392e-03f, -1.93741485e-01f, -3.05489033e-01f, -2.29685903e-01f,
  -3.10809780e-02f, 5.35593778e-02f, 1.35989085e-01f, 1.13307647e-01f, 2.22457852e-02f, 2.73588509e-03f, -1.80619910e-01f, 9.35453102e-02f, -1.41003817e-01f, -1.10059515e-01f,
  -8.21250752e-02f, 1.24962404e-01f, 7.90634304e-02f, 4.26774807e-02f, 4.15283069e-02f, 1.20088875e-01f, 4.69232723e-02f, 4.84336801e-02f, 6.04847334e-02f, 1.89407691e-01f,
  1.05698013e+00f, 4.23730075e-01f, 1.98300302e-01f, 2.96278149e-01f, -1.53291404e-01f, -7.10396096e-02f, -5.34503758e-02f, -6.95168134e-03f, -5.44027612e-02f, 1.86946750e-01f,
  8.32010731e-02f, 1.39726490e-01f, 1.62346065e-01f, 1.29260719e-01f, 8.17293972e-02f, 1.85297623e-01f, 8.11320394e-02f, 2.46950120e-01f, 6.31623194e-02f, 1.03131801e-01f,
  1.47114083e-01f, 1.60519421e-01f, 1.86418101e-01f, 6.05427548e-02f, 1.92137763e-01f, -1.00743778e-01f, -4.92884219e-02f, 1.36725202e-01f, 9.30113420e-02f, 3.34603965e-01f,
  6.26876205e-02f, 5.07459223e-01f, -2.48187929e-01f, -6.55454546e-02f, -6.67210370e-02f, 6.96857795e-02f, 7.95040578e-02f, -5.09989075e-02f, -2.24362165e-02f, 6.04295870e-03f,
  -1.51666954e-01f, 4.58589494e-02f, 4.16024216e-02f, -3.84101607e-02f, -7.29888901e-02f, -1.00917190e-01f, -1.18467805e-03f, 1.18594564e-01f, 1.56280249e-02f, -2.27999650e-02f,
  -8.13906590e-05f, 9.49754938e-03f, -2.59613916e-02f, -6.35517389e-02f, 7.25466833e-02f, -2.60367207e-02f, 9.86427590e-02f, 6.47675619e-02f, -1.00959808e-01f, 1.55950248e-01f,
  -1.06914513e-01f, 1.13028094e-01f, 1.03341818e-01f, 2.28538990e-01f, 2.03995019e-01f, 1.27253518e-01f, 8.40468481e-02f, 1.76746547e-02f, 1.11203417e-01f, -2.47247200e-02f,
  -3.05053182e-02f, 8.02767724e-02f, 6.54009432e-02f, -7.33998604e-03f, -1.31422043e-01f, -1.35211963e-02f, -3.53716575e-02f, 6.13092817e-02f, 2.14235578e-02f, -1.33156434e-01f,
  -2.26624031e-02f, -2.00381242e-02f, -2.30818652e-02f, 1.33501381e-01f, -1.10198312e-01f, 2.13477630e-02f, -4.77670170e-02f, -6.94401339e-02f, 3.05817779e-02f, 9.69526023e-02f,
  -6.46049380e-01f, -2.78762430e-01f, 2.17912644e-01f, 8.05280432e-02f, 1.22579439e-02f, 9.14462283e-02f, 6.98182220e-03f, 6.58138376e-03f, -1.36912078e-01f, -1.85189433e-02f,
  -5.19733317e-02f, 6.63557649e-02f, -1.75248887e-02f, -1.04699880e-01f, -2.68433932e-02f, -1.71829998e-01f, 1.74178388e-02f, -9.95061919e-03f, -1.11810587e-01f, -1.79578379e-01f,
  -2.10636184e-01f, -2.23779842e-01f, -1.14071026e-01f, -1.07516527e-01f, -3.94274518e-02f, -1.76028848e-01f, -2.28046700e-01f, -2.70476311e-01f, -2.39124790e-01f, -1.79844245e-01f,
  -1.51144698e-01f, -2.26735547e-01f, -4.46186543e-01f, -6.10855594e-02f, -5.01367271e-01f, -2.69084454e-01f, -3.35269749e-01f, -7.94639520e-04f, -8.15539286e-02f, -4.49854136e-01f,
  -3.11245829e-01f, 1.49146304e-01f, 1.16202168e-01f, -1.43238222e-02f, 1.45153984e-01f, -3.48099381e-01f, -3.67240846e-01f, -6.39283881e-02f, 2.82927275e-01f, -5.47473468e-02f,
  -1.40727758e-01f, 1.12336509e-01f, 2.26559311e-01f, 1.13502353e-01f, -1.29881397e-01f, -1.94878299e-02f, -3.93938720e-01f, -1.69167280e-01f, -1.09767854e-01f, -5.29751599e-01f,
  -7.55159184e-02f, -1.14734545e-01f, -4.37947996e-02f, 3.15542184e-02f, -1.12429343e-01f, 2.59638820e-02f, -1.69156156e-02f, -4.43664603e-02f, -1.07907504e-02f, -8.39395970e-02f,
  -7.78645501e-02f, 7.19376951e-02f, 8.50203913e-03f, -2.98532508e-02f, -1.22829899e-01f, -1.50221363e-02f, -1.10762157e-01f, -9.04697329e-02f, -1.47271365e-01f, -7.72193596e-02f,
  -2.57929862e-01f, -2.32283860e-01f, -7.12006178e-04f, -9.73902550e-03f, -7.02213421e-02f, 2.11754888e-02f, 1.22490590e-02f, -4.05339375e-02f, -2.03751877e-01f, -1.14562966e-01f,
  -2.12267622e-01f, -4.16715220e-02f, -9.60069150e-02f, 7.16235787e-02f, 4.33588475e-02f, 1.05566094e-02f, -3.52826267e-02f, 6.72072619e-02f, 2.76037231e-02f, 1.94506273e-02f,
  -3.00452039e-02f, -1.10405460e-02f, 7.55655812e-03f, 5.83822764e-02f, 3.89889032e-02f, 1.37894183e-01f, -4.04878259e-02f, 2.45064795e-02f, -1.53119750e-02f, -5.77628277e-02f,
  -2.94175558e-02f, -1.04204327e-01f, 1.28843591e-01f, 3.47334072e-02f, -2.03318715e-01f, -1.77459851e-01f, -8.64633024e-02f, -1.05558755e-03f, -9.07270703e-03f, -1.57192752e-01f,
  3.37770015e-01f, 7.96516016e-02f, 3.79860625e-02f, 2.24953577e-01f, -7.12236688e-02f, -7.99858272e-02f, -2.36163959e-02f, 1.19687356e-02f, 5.45086376e-02f, 4.17691320e-02f,
  -8.51287469e-02f, 8.20555538e-02f, 4.85868193e-02f, -7.41170272e-02f, 8.61011632e-03f, 1.17643602e-01f, -4.76950072e-02f, 2.00608335e-02f, 5.61341718e-02f, -1.21747088e-02f,
  -9.30992663e-02f, 1.16947621e-01f, 2.24429935e-01f, 2.63734031e-02f, -9.95449349e-03f, 2.58073926e-01f, 1.52930707e-01f, 9.02666301e-02f, 6.90357909e-02f, 1.24279700e-01f,
  -4.60355282e-01f, 3.85087766e-02f, 3.25974315e-01f, 1.08599611e-01f, 1.49267063e-01f, -1.47195041e-01f, -3.42167705e-01f, -1.87980875e-01f, -2.58017629e-02f, -1.84272099e-02f,
  2.08652783e-02f, 1.17961004e-01f, 3.30342203e-01f, 2.63799906e-01f, 1.16207944e-02f, 3.00587028e-01f, 4.15611506e-01f, 3.60034227e-01f, 1.23697962e-03f, -2.08962858e-01f,
  1.34548724e-01f, 5.28881773e-02f, 1.14148147e-01f, -1.69915427e-02f, 2.91446894e-02f, 1.51427433e-01f, 1.55783296e-01f, 1.38738632e-01f, 9.09899548e-02f, 2.76502192e-01f,
  -9.53465758e-04f, -2.36824125e-01f, -2.21586227e-02f, -1.32042170e-01f, 8.89232755e-02f, 3.71226594e-02f, -1.67555381e-02f, 2.28803918e-01f, 3.47748324e-02f, -4.86046448e-02f,
  1.54925808e-01f, -3.62315997e-02f, -8.03982690e-02f, -2.07563899e-02f, -7.27571994e-02f, -2.71230251e-01f, 9.37067792e-02f, 1.23107925e-01f, -1.34264931e-01f, -3.05169404e-01f,
  2.70589143e-01f, -3.58921513e-02f, -1.15738228e-01f, -8.11635777e-02f, -2.37440825e-01f, -6.51367824e-04f, -3.09620619e-01f, -4.01746035e-01f, -3.18040431e-01f, -3.76331478e-01f,
  5.82270399e-02f, -1.26520410e-01f, -6.07787669e-02f, -4.21169773e-02f, -4.31080163e-02f, -4.93270457e-02f, -1.87223908e-02f, -6.73659444e-02f, -1.31728826e-03f, -3.22859176e-02f,
  -1.36275394e-02f, -1.50581360e-01f, -1.16368830e-01f, -2.31814403e-02f, -4.29482050e-02f, -6.45353198e-02f, -1.23032510e-01f, -4.74376455e-02f, -4.40892801e-02f, 2.18029786e-02f,
  1.54677695e-02f, -6.19356036e-02f, -1.72128584e-02f, -1.00941576e-01f, 4.78110798e-02f, 1.71875320e-02f, -1.26186684e-01f, -6.97024688e-02f, -5.65657318e-02f, 5.96958725e-03f,
  -1.79459557e-01f, 4.75117445e-01f, -1.64733976e-01f, -2.01188311e-01f, -8.90107825e-02f, 6.32696822e-02f, 1.59923080e-02f, -2.01993100e-02f, -2.44542703e-01f, -2.17230633e-01f,
  -2.92476982e-01f, -9.96384844e-02f, -4.97555956e-02f, 1.82839297e-02f, 5.50770713e-03f, -1.80827707e-01f, -6.13908321e-02f, -4.61834222e-02f, -1.03350259e-01f, -3.84982884e-01f,
  -1.05671868e-01f, -2.94187814e-01f, -2.94682860e-01f, -1.73841879e-01f, -1.56197160e-01f, -6.39292821e-02f, -2.06626698e-01f, -2.39219397e-01f, -3.45442414e-01f, -2.84185290e-01f,
  -9.17863026e-02f, -1.76816806e-01f, -5.63101649e-01f, -1.27048895e-01f, -1.93734616e-01f, 5.97063750e-02f, -7.65699744e-02f, 2.25299880e-01f, 4.12502229e-01f, -2.75566667e-01f,
  -2.59457588e-01f, -1.26801670e-01f, -2.37869024e-01f, -1.55292526e-01f, -1.92711219e-01f, -4.91575062e-01f, -4.94146347e-01f, -3.76749635e-01f, -4.24147993e-02f, 7.50855878e-02f,
  -2.78707854e-02f, -1.71020687e-01f, -5.86325675e-03f, 1.33561060e-01f, 7.90632293e-02f, 3.02651208e-02f, -9.04414505e-02f, 3.13505828e-02f, 1.66106820e-02f, -4.02884454e-01f,
  -5.00252426e-01f, 1.05493050e-02f, -3.82045917e-02f, -1.57973766e-01f, -3.86505246e-01f, 3.66065800e-02f, 5.17119579e-02f, -1.60415232e-01f, 1.18714180e-02f, 2.75809206e-02f,
  -1.02058180e-01f, 6.48142956e-03f, -5.70874698e-02f, -6.69093207e-02f, 1.10117689e-01f, 3.67505103e-02f, -3.98379117e-02f, -9.08758938e-02f, -1.85912088e-01f, -1.33568749e-01f,
  -2.86485642e-01f, -8.94029066e-02f, -1.71582028e-01f, 1.15289740e-01f, 6.60891784e-03f, -2.42642276e-02f, 1.05359279e-01f, 2.71778971e-01f, 2.71489501e-01f, 1.13493770e-01f,
  1.32298609e-02f, 3.62977237e-02f, -1.42207086e-01f, 2.04357326e-01f, 3.00214197e-02f, 2.23022439e-02f, -6.30302206e-02f, -8.41783509e-02f, 7.78906718e-02f, 8.54933560e-02f,
  -1.37753680e-01f, -7.15583563e-02f, 5.70044108e-03f, -1.10610742e-02f, -1.09241508e-01f, -1.64100781e-01f, -2.71684770e-02f, -2.28283718e-01f, -1.71526968e-01f, 9.03513283e-02f,
  -1.47224516e-01f, 9.13838856e-03f, 7.74875805e-02f, 1.16401352e-02f, -4.17973921e-02f, -2.69184913e-02f, -1.51834261e-04f, -2.85579953e-02f, -1.22405708e-01f, -7.65543990e-03f,
  1.01775095e-01f, -1.13856539e-01f, -1.52909979e-02f, 6.60806000e-02f, -5.03245220e-02f, 6.81779981e-02f, -9.55100171e-03f, -1.19496152e-01f, 6.13174103e-02f, -3.44531350e-02f,
  -1.14944950e-01f, -1.63319111e-01f, -1.28339529e-01f, -2.13737749e-02f, -8.75214189e-02f, -2.24748462e-01f, -1.62550583e-01f, -1.08560421e-01f, 1.10459561e-02f, 3.27708200e-02f,
  -1.27232268e-01f, -1.58807546e-01f, -2.09324256e-01f, -2.02850655e-01f, 1.22664578e-01f, -1.35679349e-01f, -9.41035897e-02f, 1.41527474e-01f, 1.41919509e-01f, -1.01766065e-01f,
  3.83939296e-01f, -3.62514913e-01f, -6.11732602e-01f, 1.90307188e-03f, -9.97836143e-02f, -5.26374876e-02f, -2.00334474e-01f, 2.31012031e-01f, 2.74790674e-01f, -2.53942132e-01f,
  8.84779729e-03f, 1.44571260e-01f, -3.19109410e-02f, -4.59566452e-02f, -1.30870357e-01f, -4.23654050e-01f, -4.37560767e-01f, -1.80777133e-01f, 4.04923819e-02f, 1.87210083e-01f,
  1.16626837e-03f, -1.30660921e-01f, 8.21941197e-02f, -7.36582000e-03f, -3.69068459e-02f, -1.37151152e-01f, -3.59452248e-01f, -1.43911764e-01f, -1.76503971e-01f, -4.28276122e-01f,
  -5.62137604e-01f, 1.37417421e-01f, 2.07496822e-01f, 1.33996382e-01f, -9.99362990e-02f, 1.06468230e-01f, -7.90389851e-02f, 2.06318032e-02f, 1.14129484e-01f, 4.55568172e-02f,
  3.64644155e-02f, -8.35938230e-02f, -1.45057902e-01f, -7.17284216e-04f, 1.13825165e-02f, 6.82527050e-02f, 1.02312662e-01f, 1.27325475e-01f, -6.57268167e-02f, 2.94871759e-02f,
  3.07383314e-02f, -8.90447572e-03f, 1.13029994e-01f, 1.39979914e-01f, 1.44828886e-01f, 4.16060276e-02f, 9.82831493e-02f, 2.42807150e-01f, 1.27654180e-01f, 2.20415354e-01f,
  -4.42094766e-02f, -1.07924074e-01f, 7.70787150e-02f, 5.48473448e-02f, 7.53596574e-02f, 1.48514375e-01f, 7.03609511e-02f, -4.39102650e-02f, 1.23872317e-01f, 6.82666376e-02f,
  -7.93244988e-02f, -1.38927817e-01f, -1.57470684e-02f, -1.09922148e-01f, -1.36556149e-01f, -7.83301294e-02f, 9.24223810e-02f, 1.33426755e-03f, -1.02538746e-02f, 6.33877590e-02f,
  3.67682353e-02f, -1.17909943e-03f, -1.39941171e-01f, -1.01297218e-02f, -3.33026424e-02f, 7.46974275e-02f, 5.63040338e-02f, -3.07328515e-02f, -3.06861941e-02f, 6.75133243e-02f,
  -4.94475067e-02f, -1.42380819e-01f, -1.23491861e-01f, 1.28136709e-01f, 1.23637458e-02f, -8.58453736e-02f, -1.56915620e-01f, -1.25342473e-01f, -1.42296180e-02f, 1.04607465e-02f,
  8.16077292e-02f, 5.29499771e-03f, -1.13697708e-01f, 7.45786652e-02f, 3.49685922e-02f, 5.95443994e-02f, 1.49441734e-01f, 3.10524162e-02f, 4.74393647e-03f, -3.84950358e-03f,
  6.96771368e-02f, 2.08322167e-01f, 1.29290000e-01f, 6.30142987e-02f, 1.15617894e-01f, -5.88594042e-02f, 5.24576046e-02f, 9.99668017e-02f, -5.72689958e-02f, -3.70002352e-02f,
  -9.54566658e-01f, 6.04753755e-02f, -2.87510663e-01f, -9.74096060e-01f, -3.27524930e-01f, 1.96009159e-01f, 5.72983086e-01f, 2.35614687e-01f, -2.27713466e-01f, 1.87555879e-01f,
  1.88658476e-01f, -2.54896551e-01f, -3.13745081e-01f, 1.71036631e-01f, 2.82629758e-01f, 2.77496517e-01f, -2.04813391e-01f, -3.09104919e-01f, -1.22098334e-01f, 3.03251177e-01f,
  5.27490079e-02f, -3.90663236e-01f, -5.38815022e-01f, -2.80816257e-01f, -4.05234545e-01f, -3.49321812e-01f, -2.95275241e-01f, -4.46246982e-01f, 1.46792894e-02f, -4.97854829e-01f,
  1.84408620e-01f, -4.62376446e-01f, 1.53361544e-01f, -1.41840115e-01f, -1.67892322e-01f, -7.53319357e-03f, 3.01898420e-02f, -1.87312856e-01f, 1.84097851e-03f, -7.94179738e-02f,
  -2.20739290e-01f, 1.06832340e-01f, -2.72874445e-01f, 2.94387471e-02f, -1.74881190e-01f, 7.62853622e-02f, -2.43005473e-02f, -1.18457466e-01f, -4.81299311e-02f, 2.66852230e-01f,
  2.98370063e-01f, -7.41842836e-02f, -1.34298444e-01f, 2.53494620e-01f, 1.37711346e-01f, -6.76098615e-02f, 2.13020697e-01f, 3.01422477e-02f, 8.85012448e-02f, -1.24699481e-01f,
  2.34471604e-01f, 6.47716746e-02f, 5.00207841e-02f, -5.17928693e-03f, -1.20296352e-01f, -3.55571732e-02f, -8.25210512e-02f, -8.26064870e-03f, 9.25765261e-02f, -1.22983068e-01f,
  3.89329195e-02f, 1.09683238e-01f, -7.76834786e-02f, -2.37380356e-01f, -4.69453633e-02f, -1.16497584e-01f, 1.17216736e-01f, 1.33402437e-01f, 8.19811970e-02f, 8.73808190e-03f,
  -5.06089590e-02f, -8.20401981e-02f, -1.14974439e-01f, 1.60708949e-02f, 8.01098049e-02f, 1.32293403e-02f, -2.53660046e-02f, 1.68218285e-01f, 9.54888016e-02f, -5.40047623e-02f,
  -4.64565575e-01f, 4.21251766e-02f, -6.89497739e-02f, -1.70522511e-01f, -1.69710591e-02f, 9.27852020e-02f, -1.51096866e-01f, 8.53789374e-02f, -1.49167225e-01f, 9.08566117e-02f,
  1.55213937e-01f, 1.78601984e-02f, -5.87523356e-02f, 3.78756709e-02f, 3.16305943e-02f, 5.55102676e-02f, 1.93776622e-01f, -2.15500653e-01f, 1.56266928e-01f, 1.48978621e-01f,
  1.29421487e-01f, 6.69016466e-02f, -9.04170647e-02f, 5.69573492e-02f, -6.41421229e-02f, -1.42994672e-01f, 1.01775594e-01f, 7.39505291e-02f, 8.39946344e-02f, 5.39910905e-02f,
  -4.19189520e-02f, -1.79261163e-01f, 1.64404616e-01f, -9.71868634e-02f, 3.83465290e-01f, 5.81006587e-01f, 7.89548457e-01f, 2.15907305e-01f, -2.79131979e-01f, 2.00734422e-01f,
  -1.31606823e-02f, -5.28638244e-01f, -5.40959895e-01f, -3.81276667e-01f, -2.38457825e-02f, 1.36136740e-01f, 1.41969889e-01f, -8.21784735e-02f, 1.77371800e-01f, 1.55897632e-01f,
  -9.49883163e-02f, -2.32650563e-02f, -8.56096894e-02f, -2.23869890e-01f, -3.21605057e-01f, -3.31576794e-01f, -1.05758128e-03f, 7.24072456e-02f, -1.33370534e-02f, -3.01834196e-01f,
  1.86867137e-02f, 1.92953810e-01f, -2.15902757e-02f, -9.32570174e-02f, -7.13605881e-02f, -2.58420229e-01f, -7.61114433e-02f, -1.05366416e-01f, -6.00623749e-02f, -2.29819074e-01f,
  -6.28390023e-03f, -1.88004561e-02f, -7.36062825e-02f, 1.17555588e-01f, 1.61829770e-01f, 1.75864268e-02f, -2.50997897e-02f, -1.06577396e-01f, -5.69502860e-02f, -1.54317776e-02f,
  -2.18715191e-01f, 9.44133177e-02f, 2.92422831e-01f, 8.41469914e-02f, -4.91057802e-03f, -1.13730490e-01f, 1.21297121e-01f, 4.35232297e-02f, 1.61018446e-02f, -2.61975914e-01f,
  -7.91442320e-02f, -7.02188388e-02f, 1.06497422e-01f, 4.04427871e-02f, 2.04251092e-02f, 9.70729813e-02f, -1.95319559e-02f, -2.41759140e-02f, -6.81167394e-02f, -5.13454564e-02f,
  -4.25484627e-02f, 1.11981668e-01f, 5.42399809e-02f, -5.09289019e-02f, -3.78298834e-02f, 6.05085343e-02f, 4.36648130e-02f, -9.17115808e-02f, 7.87742138e-02f, -3.47051658e-02f,
  -8.51024836e-02f, 5.36424406e-02f, -1.05569705e-01f, -1.09565347e-01f, -2.54584141e-02f, -1.42510042e-01f, -3.52527760e-02f, -7.95536265e-02f, -4.29840349e-02f, 6.85199425e-02f,
  -4.51344907e-01f, 3.52772474e-01f, -1.92071483e-01f, -1.40328616e-01f, 3.30134332e-02f, 2.03359500e-02f, -3.90535891e-02f, -7.27876946e-02f, 1.16765082e-01f, -4.49966814e-04f,
  8.68417472e-02f, -5.46279140e-02f, -1.45242820e-02f, -1.42727457e-02f, 3.78609123e-03f, 1.02195941e-01f, -4.40734380e-04f, -1.28739715e-01f, -3.81278433e-02f, -1.22977365e-02f,
  -1.23144440e-01f, 1.45571634e-01f, -3.51589243e-03f, -4.27416004e-02f, -8.26783627e-02f, 8.58815983e-02f, 3.53073105e-02f, 3.98475155e-02f, 2.11244181e-01f, -6.30999077e-03f,
  4.37919468e-01f, -3.48131627e-01f, 6.00182898e-02f, -3.11993778e-01f, -4.01388496e-01f, -1.38511341e-02f, -1.49467811e-01f, -1.62541881e-01f, -1.63414136e-01f, -1.48579061e-01f,
  -2.90147844e-03f, 3.85000110e-01f, 3.32935780e-01f, 2.97103345e-01f, 3.54524583e-01f, -1.00304402e-01f, -9.80296284e-02f, 4.32021439e-01f, 5.26778758e-01f, 1.13966562e-01f,
  -1.33249715e-01f, -1.27265453e-01f, 1.58221647e-01f, 6.39383867e-02f, -3.44084203e-01f, -7.25930557e-03f, -1.84483603e-01f, -2.49886349e-01f, -1.37061387e-01f, -2.53339827e-01f,
  2.08574012e-01f, 9.72224027e-02f, 1.27851978e-01f, -3.62236202e-02f, -6.01690523e-02f, 5.98472776e-03f, 9.05971676e-02f, -7.17611313e-02f, -1.63375571e-01f, -1.24913141e-01f,
  -1.52931316e-02f, -1.09300978e-01f, -5.14399782e-02f, -1.82009246e-02f, -6.97263479e-02f, 3.87646295e-02f, 4.35679685e-03f, 7.11125433e-02f, -2.89058108e-02f, 1.03253331e-02f,
  3.24908993e-03f, 4.99075428e-02f, 8.98184329e-02f, 1.07938580e-01f, 6.63808659e-02f, 1.66318461e-01f, -2.70311013e-02f, 8.14596266e-02f, 1.41431406e-01f, 1.60360504e-02f,
  2.74909046e-02f, 1.47881955e-01f, 1.95037901e-01f, 1.01286039e-01f, 1.58999786e-01f, 1.19060287e-02f, 2.54753269e-02f, 5.98971024e-02f, 2.06509337e-01f, 6.43750886e-03f,
  -1.16712667e-01f, 3.74469571e-02f, 1.14046603e-01f, 2.90048718e-02f, 9.12525430e-02f, -1.12140272e-02f, 3.16959433e-02f, 9.78214890e-02f, 1.68692588e-03f, -1.96712743e-02f,
  3.04243993e-02f, -3.30303758e-02f, -1.45048499e-01f, -3.73977832e-02f, -1.20172754e-01f, 2.12362409e-02f, 3.96452881e-02f, 1.17984088e-02f, 1.92837864e-02f, -1.09350815e-01f,
  -1.47841517e-02f, 3.60707760e-01f, 1.00152560e-01f, -4.33487669e-02f, -1.51806414e-01f, -1.76638454e-01f, 7.58612677e-02f, -1.75411999e-01f, -1.91208348e-01f, -4.54125069e-02f,
  -1.68675303e-01f, -1.60076156e-01f, -7.66820759e-02f, -1.87587608e-02f, -1.07352115e-01f, -8.84298831e-02f, -6.10440560e-02f, 6.28775954e-02f, -1.16117597e-01f, -2.51510710e-01f,
  -2.14065507e-01f, -5.61242923e-02f, 1.60980254e-01f, 5.90717643e-02f, 2.34744921e-02f, 1.58380926e-01f, 3.66659537e-02f, -2.18276754e-02f, -5.56616765e-03f, -9.20298547e-02f,
  -4.06599760e-01f, -3.39824021e-01f, 1.57048739e-02f, 3.97388488e-01f, 5.92446208e-01f, 4.21481729e-01f, 3.25910151e-01f, 4.13488060e-01f, 2.97721505e-01f, 1.78638101e-01f,
  -4.42456119e-02f, 1.61210205e-02f, 5.28870635e-02f, 6.35751635e-02f, 7.83434510e-02f, 2.72076219e-01f, 4.02604431e-01f, 1.62974045e-01f, 2.18803748e-01f, 2.61697203e-01f,
  2.62641937e-01f, 1.01582639e-01f, -6.17435724e-02f, 1.26615822e-01f, 5.61971217e-02f, 2.56114125e-01f, 1.21626981e-01f, 8.61257762e-02f, 2.29611490e-02f, 1.05002359e-01f,
  -4.02123779e-01f, -2.08307415e-01f, 1.58409141e-02f, -1.26284644e-01f, -1.39706329e-01f, -1.63934380e-01f, 4.65760827e-02f, -9.75657403e-02f, -1.59414951e-02f, 4.24352363e-02f,
  -8.00247714e-02f, -8.83868858e-02f, -1.04929164e-01f, -1.75940096e-02f, -3.19249444e-02f, -3.94591689e-02f, -1.77033290e-01f, 1.05573125e-01f, 7.75988474e-02f, -9.41197872e-02f,
  -1.00705646e-01f, 3.60824689e-02f, 4.87633720e-02f, 8.78911167e-02f, 8.29408690e-02f, 9.98829827e-02f, -2.13747062e-02f, -2.26666909e-02f, -3.90489288e-02f, 3.21991928e-02f,
  3.29382807e-01f, -1.26978848e-02f, -5.67605197e-02f, 8.14668834e-02f, -2.39282921e-02f, 1.17535733e-01f, 2.53067225e-01f, 8.68569016e-02f, 8.16017166e-02f, 5.06042391e-02f,
  1.86761878e-02f, 5.24638444e-02f, 1.03741474e-01f, 6.71919957e-02f, -2.37202402e-02f, 8.64093900e-02f, -1.23628434e-02f, -1.86072782e-01f, -1.19573444e-01f, -1.49043918e-01f,
  -1.15235019e-02f, 4.14120257e-02f, 1.20869977e-02f, -1.89624242e-02f, 6.55873492e-02f, 1.96881026e-01f, 9.44115072e-02f, 4.79218177e-02f, -2.19932217e-02f, 6.30917773e-02f,
  3.55622232e-01f, 1.30720377e-01f, 4.87775216e-03f, -9.84982997e-02f, -1.18124343e-01f, -2.24244133e-01f, -1.00276187e-01f, -8.95242542e-02f, -1.20737091e-01f, -2.94808298e-02f,
  1.31256683e-02f, -1.46588892e-01f, -9.97585356e-02f, -7.50241354e-02f, 1.44639567e-01f, 9.85736586e-03f, -2.40985110e-01f, 9.64356512e-02f, 9.36860964e-02f, -5.10113239e-02f,
  -2.84832083e-02f, 1.64824843e-01f, 1.49710596e-01f, 2.08660007e-01f, 1.50560156e-01f, 1.40883416e-01f, 9.66956988e-02f, 1.58739407e-02f, 1.60229370e-01f, 9.75990817e-02f,
  8.34799588e-01f, -2.10575745e-01f, 1.65568098e-01f, 1.92081660e-01f, -5.03812671e-01f, -3.82644087e-01f, -3.43766302e-01f, -4.26096693e-02f, 1.49238959e-01f, -1.07952051e-01f,
  -4.15093899e-01f, -2.80192614e-01f, -5.56435846e-02f, -8.80660191e-02f, 1.01585723e-01f, 5.38605750e-02f, 6.53449222e-02f, 2.38104209e-01f, 2.88946897e-01f, -1.27524897e-01f,
  -2.91535348e-01f, 9.95791852e-02f, 2.64125347e-01f, 3.39345634e-02f, -9.39475447e-02f, -1.10094259e-02f, -2.26294715e-02f, -1.02437384e-01f, -2.80091137e-01f, -1.32779658e-01f,
  2.35908568e-01f, -1.01935342e-01f, -2.51902997e-01f, -3.34527403e-01f, -1.27438128e-01f, 1.19578473e-01f, -5.35144769e-02f, 2.03328654e-01f, 3.31150517e-02f, -2.06878558e-02f,
  -2.22872466e-01f, -5.99485375e-02f, -2.10387763e-02f, -5.32795340e-02f, -2.70194112e-04f, 2.84432285e-02f, 6.61581829e-02f, 1.06825620e-01f, 7.73842335e-02f, 6.79379180e-02f,
  -1.28103226e-01f, -1.13557324e-01f, 1.69225503e-03f, -6.58996180e-02f, -1.50426030e-01f, -4.26635146e-02f, -2.56911635e-01f, -2.35526264e-01f, -1.57356873e-01f, 1.77809715e-01f,
  -1.05002366e-01f, -4.16035093e-02f, -2.23526061e-02f, 5.86739322e-03f, -8.20005126e-03f, -4.92909290e-02f, 6.96153492e-02f, -8.35112855e-02f, -1.09452538e-01f, 4.04853337e-02f,
  -2.46942881e-02f, -1.49555668e-01f, -9.71200690e-02f, -5.48341498e-02f, -1.25526814e-02f, -8.52858927e-03f, 3.12129166e-02f, 3.14275064e-02f, -7.78897852e-02f, -4.00721692e-02f,
  -3.54520343e-02f, 2.44698767e-02f, -1.94036472e-03f, 1.44730732e-01f, 1.02109630e-02f, 1.64762586e-01f, -1.40611306e-02f, -6.44532964e-02f, 1.02602504e-01f, 5.03297709e-02f,
  3.41486603e-01f, -2.84157455e-01f, 1.96517438e-01f, -1.31320968e-01f, 1.62861183e-01f, -1.08613349e-01f, -5.90210455e-03f, -1.02957286e-01f, 4.84163233e-04f, -2.45308354e-02f,
  -1.89848334e-01f, -2.66622356e-03f, 1.15031332e-01f, -5.58911636e-03f, -6.01647086e-02f, -4.23410861e-03f, -1.18395440e-01f, 1.20797224e-01f, -7.95067251e-02f, 8.50339010e-02f,
  7.94904307e-02f, -9.73491073e-02f, 5.44720106e-02f, 1.26679897e-01f, 4.82603125e-02f, 9.02353078e-02f, 6.82765916e-02f, 3.92126180e-02f, 1.39979720e-01f, 2.65134573e-01f,
  5.36607981e-01f, -3.09747774e-02f, 1.87604040e-01f, -5.11287116e-02f, -7.75329173e-02f, 5.64488061e-02f, 9.37401224e-03f, 1.94625892e-02f, 2.59935558e-02f, 3.93508002e-02f,
  2.61085749e-01f, 3.96013170e-01f, 2.46039629e-01f, 2.16132164e-01f, 3.11364412e-01f, 1.95228457e-02f, -1.64396673e-01f, 2.42092654e-01f, 2.46833563e-01f, 8.30502138e-02f,
  -2.68332679e-02f, -1.10973783e-01f, 1.11950122e-01f, 2.32152920e-02f, -8.50412771e-02f, 6.05137721e-02f, -2.11036161e-01f, -1.45866424e-01f, 3.55434380e-02f, -2.42283002e-01f,
  1.69239283e-01f, 2.40104888e-02f, 1.37748033e-01f, -1.12207577e-01f, -7.97370970e-02f, -1.27834514e-01f, -1.33928567e-01f, -1.11109294e-01f, -1.32048249e-01f, -5.22526912e-02f,
  -2.04174578e-01f, -1.03048928e-01f, -1.66243806e-01f, -5.11468016e-02f, -1.13953218e-01f, -1.88449457e-01f, -6.00004531e-02f, -9.81756970e-02f, 3.91368456e-02f, -1.03221975e-01f,
  -8.18463787e-03f, -8.02198425e-02f, 5.53832040e-04f, -6.85886899e-03f, 5.74419573e-02f, -4.07139622e-02f, 1.40460804e-02f, -1.31561421e-02f, 7.84768835e-02f, -8.35227594e-02f,
  2.02904880e-01f, 8.16915091e-03f, -4.74654101e-02f, 9.26740915e-02f, 2.54311651e-01f, 7.77320862e-02f, 5.24386838e-02f, -7.40101114e-02f, -2.13820431e-02f, -3.41717787e-02f,
  4.12005074e-02f, 1.19049445e-01f, -1.08099908e-01f, 3.02521493e-02f, 1.28856912e-01f, -1.84604734e-01f, -2.10421920e-01f, -2.24034991e-02f, 8.42889696e-02f, -2.27625817e-02f,
  1.44408017e-01f, -1.24105543e-01f, -1.70785617e-02f, -5.59263974e-02f, -2.87332758e-02f, 1.42194360e-01f, 7.46565610e-02f, 6.59251809e-02f, -4.34337892e-02f, -4.25719135e-02f,
  -3.61092895e-01f, 3.29856545e-01f, 1.82042554e-01f, 1.49067631e-02f, -2.26526916e-01f, -9.84499007e-02f, -9.79601666e-02f, -5.47431363e-03f, -1.75338089e-02f, -5.04752714e-03f,
  1.91039294e-02f, 2.88887396e-02f, -9.82641280e-02f, 1.77999437e-02f, -4.29073349e-02f, -2.77879052e-02f, 1.26846328e-01f, 1.01956271e-01f, -1.75626036e-02f, -1.65462673e-01f,
  -1.33228809e-01f, 2.04567052e-02f, 2.45844554e-02f, 1.03181399e-01f, 1.34260356e-02f, 1.27993867e-01f, 9.53405425e-02f, 4.65887934e-02f, 7.84249231e-02f, -6.73671113e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.89361703e-01f, 2.22377628e-01f, 2.17540309e-01f, 4.15247262e-01f, 5.79813898e-01f, 6.21995568e-01f, 3.17988724e-01f, 2.89861262e-01f, 5.48461556e-01f, 2.79767960e-01f,
  2.82375932e-01f, 3.33713382e-01f, 1.06495604e-01f, 2.30564594e-01f, 2.03227967e-01f, 3.60295773e-01f, 3.35522383e-01f, 5.06542027e-01f, 1.52822107e-01f, -1.90594509e-01f,
  3.06314409e-01f, 4.24556643e-01f, 4.02867317e-01f, 1.40273184e-01f, 7.03266025e-01f, 2.69444317e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -6.09069541e-02f, 1.55829728e-01f, -1.82609066e-01f, 5.19623272e-02f, 1.53733656e-01f, 5.17854057e-02f, 1.06695993e-02f, 1.06452450e-01f, 1.40164182e-01f, 1.73901826e-01f,
  -3.93986166e-01f, 1.70903504e-01f, 5.85631356e-02f, -2.06016317e-01f, -3.75051111e-01f, -2.78399020e-01f, -6.21921755e-02f, 1.97831303e-01f, 1.04855932e-01f, 1.15743674e-01f,
  1.34731472e-01f, 9.67287272e-02f, -1.83178615e-02f, -1.58637553e-01f, 1.78127930e-01f, 4.22275901e-01f, -2.84440130e-01f, 6.34158105e-02f, 1.18251957e-01f, -1.32159933e-01f,
  1.64511576e-01f, -9.13621038e-02f, 1.65510565e-01f, 1.49510100e-01f, 1.09208278e-01f, -4.02764119e-02f, -3.47074866e-02f, -2.75751427e-02f, -1.35486975e-01f, -1.24937780e-02f,
  2.80375540e-01f, -6.83323219e-02f, 2.27173865e-02f, -2.27045581e-01f, -2.18733832e-01f, 1.33114338e-01f, 2.80061573e-01f, 2.76483029e-01f, 2.27369145e-02f, -1.04075357e-01f,
  2.21244156e-01f, 3.03096712e-01f, 1.07244238e-01f, 1.89219862e-01f, -2.66157001e-01f, 2.41830617e-01f, -6.77314177e-02f, -1.92905605e-01f, 1.18135057e-01f, -4.01445525e-03f,
  1.44388542e-01f, 2.17526853e-01f, -1.38533607e-01f, 1.42604839e-02f, 3.96714471e-02f, 1.09111741e-01f, -2.96751615e-02f, -3.61619405e-02f, -7.97144249e-02f, 5.20976372e-02f,
  -2.99717069e-01f, 2.78186709e-01f, 2.58232653e-02f, -1.12076171e-01f, -1.67375952e-01f, 1.58323012e-02f, 9.08292755e-02f, -3.54678631e-01f, -1.21345915e-01f, -7.16816485e-02f,
  -1.91834956e-01f, 2.24950284e-01f, 2.20795736e-01f, 1.68050509e-02f, -9.54676513e-03f, 9.56351757e-02f, 8.28954950e-03f, -1.76430773e-02f, 2.68056720e-01f, 1.87441975e-01f,
  1.70913845e-01f, 1.00004626e-02f, 5.02961800e-02f, -2.12974682e-01f, -4.17300642e-01f, -6.37913495e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  7.65737519e-02f, -3.29431263e-03f, 4.45006490e-02f, -4.93877120e-02f, 2.27888733e-01f, 2.48492688e-01f, -6.31706953e-01f, 2.49720868e-02f, 1.77980140e-01f, 1.88564464e-01f,
  1.99381664e-01f, 1.92112491e-01f, 3.06360126e-01f, 1.58046648e-01f, -5.74118316e-01f, -5.40043294e-01f, -1.39623925e-01f, -3.05045485e-01f, -1.30704120e-01f, 1.02986924e-01f,
  1.85052082e-01f, 3.06521475e-01f, 4.34368700e-01f, -2.08881021e-01f, 1.31973609e-01f, 7.21871406e-02f, 1.72019035e-01f, 9.54160318e-02f, 4.91014391e-01f, 2.00772896e-01f,
  -1.91375330e-01f, 3.23293924e-01f, -2.41442937e-02f, 2.24893354e-02f, 5.08295149e-02f, -8.88524354e-02f, -1.42026290e-01f, -2.91564554e-01f, -5.34551665e-02f, 3.54154617e-01f,
  9.50210616e-02f, 9.35615972e-02f, 5.33252478e-01f, -1.82427000e-02f, 4.34975140e-02f, -1.49862722e-01f, 3.21793228e-01f, 3.26600462e-01f, 1.67550966e-01f, -2.42360264e-01f,
  4.72478271e-02f, -2.24460900e-01f, 3.14444825e-02f, 6.94346474e-03f, -7.54734054e-02f, 1.55834839e-01f, -2.13869557e-01f, -4.61286813e-01f, 3.24757427e-01f, 3.79999369e-01f,
  1.12903990e-01f, 3.37083787e-01f, -5.96694410e-01f, 2.13513952e-02f, 1.20316774e-01f, -2.35579267e-01f, 3.93790573e-01f, 2.11687163e-01f, -2.81637698e-01f, -4.85035896e-01f,
  1.24800235e-01f, -6.16415888e-02f, -3.09429020e-01f, -2.35419780e-01f, 4.41469103e-01f, -5.39624751e-01f, 2.13953465e-01f, -1.92786977e-02f, -3.13247621e-01f, -9.80124157e-03f,
  3.43371361e-01f, 6.16823211e-02f, -2.76549667e-01f, 9.55705941e-02f, -1.22497790e-01f, 3.94172579e-01f, 1.72275707e-01f, 1.49246618e-01f, -2.66177028e-01f, -6.31757796e-01f,
  2.30172306e-01f, -6.29428983e-01f, 2.43774995e-01f, -3.21330458e-01f, 4.05352771e-01f, 1.59198716e-01f, 3.52226734e-01f, -7.33083710e-02f, 1.03824362e-01f, -4.36220944e-01f,
  1.37314469e-01f, -2.53678802e-02f, -3.05211931e-01f, 2.39173740e-01f, -5.46298288e-02f, -2.64878213e-01f, 2.82425433e-01f, 1.17223412e-01f, -4.26881850e-01f, -2.95577705e-01f,
  2.48520926e-01f, 6.03812397e-01f, -3.29095602e-01f, 4.26780224e-01f, 4.47455436e-01f, -3.65335166e-01f, -1.23397611e-01f, 6.59969971e-02f, -8.64852145e-02f, 2.65266061e-01f,
  3.31422538e-02f, -2.67237276e-01f, 1.33516550e-01f, -9.79204848e-02f, -2.20468521e-01f, 1.10964425e-01f, -2.27542460e-01f, -2.83572733e-01f, 2.15852499e-01f, 1.66218832e-01f,
  2.64183760e-01f, -1.76231116e-01f, -8.93446803e-02f, -1.69776171e-01f, 5.04335463e-01f, 3.05169135e-01f, 2.62908489e-01f, -2.53176838e-02f, 3.84704769e-01f, 5.20485602e-02f,
  -2.51201391e-01f, 3.40007156e-01f, 8.09010208e-01f, 4.38167244e-01f, 2.07091257e-01f, -2.86091536e-01f, -1.05817944e-01f, -7.50549277e-03f, 1.79220125e-01f, -1.86113551e-01f,
  -2.69710403e-02f, 2.32026786e-01f, -2.04495918e-02f, -9.52125117e-02f, 2.23838344e-01f, 4.81979221e-01f, -2.31614485e-01f, 3.19929928e-01f, 1.71185896e-01f, -5.26223600e-01f,
  3.20912115e-02f, -6.46685658e-04f, -7.05400389e-03f, -5.43415137e-02f, -1.10121451e-01f, 9.54832956e-02f, -8.16519186e-02f, 2.37670496e-01f, -3.37591320e-01f, 1.24242857e-01f,
  -1.83787212e-01f, -1.40193375e-02f, 1.42879924e-02f, -6.06888592e-01f, -1.85501531e-01f, 1.98858932e-01f, -1.40522465e-01f, 2.87228853e-01f, 4.50771749e-01f, 3.50713760e-01f,
  1.23389773e-01f, -5.67966811e-02f, 1.63249359e-01f, 1.13132522e-01f, 4.32997584e-01f, 1.17470831e-01f, 6.46947145e-01f, 5.31264246e-01f, -2.97299087e-01f, -7.46721774e-02f,
  -5.84606469e-01f, 9.13380533e-02f, 2.06444180e-03f, 1.03502691e-01f, -4.28314172e-02f, -1.37264773e-01f, 3.36931109e-01f, -7.32154176e-02f, -2.61739343e-01f, 2.80894786e-01f,
  2.27459639e-01f, -1.81348056e-01f, 4.65042032e-02f, 1.14366561e-02f, -2.29574651e-01f, -1.63292214e-01f, -2.15953458e-02f, 1.60437703e-01f, -1.65062621e-01f, 1.05027808e-02f,
  -1.91099241e-01f, -2.89878994e-01f, -1.53968409e-01f, 2.04215512e-01f, -3.58236641e-01f, 4.77383941e-01f, -2.24470109e-01f, -1.37599647e-01f, -1.78466395e-01f, -2.18570292e-01f,
  -2.14068424e-02f, 1.46737918e-01f, 2.50372022e-01f, 6.23946823e-02f, 2.17632473e-01f, 6.87065646e-02f, 2.85735548e-01f, 1.48027718e-01f, 9.09349248e-02f, 1.04746699e-01f,
  -1.31001532e-01f, 9.36998501e-02f, -2.47276485e-01f, -9.49338898e-02f, -1.96404383e-01f, 1.01680912e-01f, 4.03710455e-01f, 6.05315745e-01f, 5.70537150e-01f, -2.82322437e-01f,
  4.06526864e-01f, 2.22409055e-01f, -2.06169650e-01f, 3.91980201e-01f, -2.21663207e-01f, -3.62821847e-01f, 5.06222010e-01f, 2.89361089e-01f, 4.91979837e-01f, 3.12875032e-01f,
  3.55470628e-01f, -4.93818253e-01f, 1.95826992e-01f, -2.25908771e-01f, 1.82119101e-01f, 1.36137083e-01f, 8.97245333e-02f, 2.70585954e-01f, 3.53060335e-01f, 1.49557322e-01f,
  1.23273939e-01f, -1.08479997e-02f, -4.68558997e-01f, -5.88502958e-02f, 6.47183731e-02f, 1.21697076e-01f, -1.86051220e-01f, 2.37659529e-01f, 1.97880343e-01f, 6.90985620e-02f,
  7.97596574e-02f, -2.85076797e-01f, -2.26132557e-01f, 1.32446676e-01f, 1.20945454e-01f, 2.74551660e-01f, 4.21790965e-02f, 3.47577244e-01f, 2.24321499e-01f, 2.78335303e-01f,
  4.26950514e-01f, 4.08471584e-01f, 2.30286047e-02f, -4.84990597e-01f, 9.73382071e-02f, 1.72115028e-01f, 2.88219184e-01f, 2.48166636e-01f, 9.47265401e-02f, 9.56164449e-02f,
  1.72647238e-01f, -2.72524148e-01f, -3.10320351e-02f, -5.46974987e-02f, -5.23169972e-02f, -5.88941611e-02f, -5.03015578e-01f, -1.32456765e-01f, 1.28164083e-01f, 1.74722522e-01f,
  -1.26657799e-01f, -1.10180445e-01f, -2.59354800e-01f, 1.88923299e-01f, -2.98530847e-01f, 4.54849005e-02f, 9.17814970e-02f, -3.64856601e-01f, -1.00399740e-01f, 1.02566779e-01f,
  -2.06591591e-01f, 1.27812788e-01f, 1.23933099e-01f, 7.41734803e-02f, 4.91051912e-01f, 4.14689332e-02f, 2.51989812e-01f, -4.62323315e-02f, -6.71472788e-01f, 1.28776297e-01f,
  1.46019533e-01f, 1.04863778e-01f, 1.89392820e-01f, 2.01972544e-01f, -1.11334600e-01f, 5.74486032e-02f, -3.67064327e-01f, 1.90464873e-02f, -9.03844833e-02f, -5.36298119e-02f,
  3.18774670e-01f, 6.31688952e-01f, -2.24032681e-02f, 5.35596069e-03f, -3.58155280e-01f, 9.09985155e-02f, 1.49143547e-01f, 1.86150603e-04f, -9.93424803e-02f, -4.93096858e-01f,
  -2.61848778e-01f, -1.94582731e-01f, 1.27157405e-01f, 5.48941672e-01f, -6.78728521e-02f, -3.92989576e-01f, 8.87462571e-02f, -7.81781897e-02f, 5.11061251e-01f, 1.49608985e-01f,
  -2.13647876e-02f, 2.47750595e-01f, 1.32747173e-01f, 3.80987674e-01f, 4.58310843e-01f, -2.91966677e-01f, 4.43857998e-01f, 2.22835302e-01f, 3.06308359e-01f, 1.80650786e-01f,
  1.49676025e-01f, 2.91774154e-01f, -1.53555632e-01f, 2.54987448e-01f, -3.34101677e-01f, 1.90919131e-01f, 8.43205824e-02f, -9.63194147e-02f, 5.86004481e-02f, 3.48807871e-01f,
  2.70651244e-02f, 8.32138658e-02f, 2.37037107e-01f, 4.37135279e-01f, 1.66942760e-01f, 2.42379636e-01f, -1.32998958e-01f, -7.08572790e-02f, -2.95682460e-01f, -7.31410235e-02f,
  -1.60760179e-01f, -1.78851485e-01f, 4.35814977e-01f, 2.99610853e-01f, 3.70257020e-01f, 2.60719121e-01f, 3.96041006e-01f, 4.15377378e-01f, -7.22986162e-02f, 1.63916677e-01f,
  4.23631608e-01f, 8.41035843e-02f, 5.23266196e-02f, 9.64517593e-02f, 5.46012104e-01f, -1.55313611e-01f, 3.64630431e-01f, 4.34783787e-01f, 3.77631128e-01f, -6.98428601e-02f,
  2.25473613e-01f, -2.83570886e-01f, -3.68673176e-01f, 1.21701859e-01f, 2.85542548e-01f, -1.36037484e-01f, 2.61774659e-01f, -2.44511038e-01f, -2.18119279e-01f, -1.16170958e-01f,
  -1.84638396e-01f, 3.21957618e-01f, -1.16486177e-01f, 1.94046676e-01f, 3.90044808e-01f, 1.74471349e-01f, 1.23628207e-01f, 1.09431818e-01f, -6.32650331e-02f, -1.75638460e-02f,
  -5.53719997e-02f, 5.57768019e-03f, -1.60884008e-01f, -2.95255315e-02f, 1.96736619e-01f, 3.20667252e-02f, -9.78760608e-03f, 3.90654474e-01f, 2.63744771e-01f, 4.16124970e-01f,
  6.05676353e-01f, -1.64711475e-01f, 1.97556153e-01f, -1.56997778e-02f, -1.58854440e-01f, 1.49507985e-01f, -1.32079005e-01f, -1.62187517e-01f, 3.77117306e-01f, 1.82032108e-01f,
  4.53882217e-01f, 4.44749683e-01f, 2.85896331e-01f, -1.19582824e-01f, -2.74514973e-01f, -2.00967807e-02f, -1.76025569e-01f, 1.22515723e-01f, 3.00417185e-01f, 2.97947109e-01f,
  2.44060516e-01f, 4.09662724e-01f, 4.04541910e-01f, 3.62081289e-01f, -4.45499159e-02f, -7.65536427e-02f, -1.88104108e-01f, 1.38955802e-01f, -1.65625125e-01f, 2.53850371e-01f,
  5.10852218e-01f, 4.92063940e-01f, -6.89676106e-02f, -1.00073785e-01f, -2.53878273e-02f, 1.17368855e-01f, -1.18163235e-01f, 3.36660892e-01f, -3.45752351e-02f, -1.44460887e-01f,
  3.78744513e-01f, 2.02433571e-01f, 3.37481230e-01f, 1.06036365e-01f, -1.30484715e-01f, -1.72602594e-01f, -1.48578390e-01f, -6.19974323e-02f, 3.05635482e-01f, 2.80532867e-01f,
  1.44554302e-01f, 3.71073246e-01f, 2.33315170e-01f, 2.43585035e-01f, 1.03761867e-01f, 1.73562765e-01f, 4.83699113e-01f, 2.59523932e-02f, -2.34458104e-01f, 3.02259233e-02f,
  4.89904672e-01f, 2.09433734e-01f, 2.08810642e-01f, 1.82639688e-01f, 2.50541538e-01f, 6.25038743e-02f, 1.33087859e-01f, -4.98790920e-01f, -1.06882475e-01f, -1.61735639e-02f,
  3.86671126e-01f, 1.17594227e-02f, 1.38511583e-01f, 5.46243507e-03f, -4.25567515e-02f, -1.68398321e-01f, 2.21497416e-01f, 7.58127451e-01f, 7.76396841e-02f, 3.54124717e-02f,
  1.72752157e-01f, -1.34055629e-01f, -6.52029216e-02f, 1.07865922e-01f, 2.70193189e-01f, 3.14157099e-01f, -3.36748026e-02f, -1.76526178e-02f, -4.87236410e-01f, 2.21833751e-01f,
  -1.48312598e-01f, 3.71009618e-01f, 1.76548615e-01f, 2.50933379e-01f, 3.66619825e-01f, 2.57866174e-01f, -2.55153716e-01f, -4.31694031e-01f, 5.75188873e-03f, 1.36422530e-01f,
  2.83679903e-01f, 3.15414101e-01f, 2.33676255e-01f, 2.88543880e-01f, 3.25341344e-01f, -2.18991026e-01f, 2.96932369e-01f, 2.23223090e-01f, -1.13888867e-01f, -4.29149538e-01f,
  1.64361462e-01f, 4.55925893e-03f, 7.32823685e-02f, 3.03907305e-01f, -2.22736642e-01f, 6.64146692e-02f, 1.95249215e-01f, -4.76604640e-01f, 5.97038209e-01f, -3.06776464e-01f,
  2.75948614e-01f, 2.21588075e-01f, -1.54672623e-01f, 4.44968283e-01f, -3.98175448e-01f, -4.93666530e-01f, -4.00170743e-01f, -4.04343456e-01f, -7.03501478e-02f, 3.93694580e-01f,
  -5.77140987e-01f, 2.11946949e-01f, 7.71935165e-01f, 3.47657561e-01f, 3.34495842e-01f, 4.43838418e-01f, -3.40250045e-01f, 1.32136503e-02f, -2.80369729e-01f, -3.05420697e-01f,
  -2.73210704e-01f, 5.11098742e-01f, -2.16362372e-01f, -1.06542170e-01f, -1.11217283e-01f, -2.11087182e-01f, 3.70882079e-02f, 1.47611976e-01f, 5.44506423e-02f, 1.67277440e-01f,
  -2.21320405e-03f, 1.68049589e-01f, -1.19184531e-01f, -2.32458171e-02f, -6.08157814e-02f, -1.56976342e-01f, 2.55124986e-01f, 2.66369760e-01f, 5.54467380e-01f, 1.21379718e-01f,
  -3.73996198e-01f, -3.35402042e-01f, -9.95203406e-02f, -2.91265935e-01f, -2.07129076e-01f, 1.03166707e-01f, 1.35164037e-02f, 1.48541659e-01f, 2.64970601e-01f, -1.05406649e-01f,
  1.11147925e-01f, 2.63284445e-01f, 2.53897846e-01f, 3.53959441e-01f, 3.60704601e-01f, -8.43285099e-02f, -1.20870627e-01f, 2.71371752e-01f, 4.32013780e-01f, 5.35936058e-01f,
  1.30454034e-01f, 1.57562941e-01f, 1.07037537e-01f, 1.39273629e-01f, -2.41534729e-02f, -2.23026887e-01f, -2.66854376e-01f, -3.59793492e-02f, -2.23892048e-01f, 1.24162942e-01f,
  6.81776181e-02f, -7.34028816e-02f, 3.53321493e-01f, -6.97641969e-02f, -1.38562724e-01f, 4.76348311e-01f, 3.97178173e-01f, -1.25797689e-01f, -9.64583606e-02f, -2.66756825e-02f,
  1.06246918e-01f, -1.27699211e-01f, 2.52885729e-01f, 6.77220449e-02f, 1.38428845e-02f, -4.11212772e-01f, -8.87261212e-01f, -9.70699564e-02f, 3.13549265e-02f, -4.16883260e-01f,
  4.63718563e-01f, 3.26509267e-01f, 1.43548071e-01f, -6.44608513e-02f, -1.92801598e-02f, 1.53851658e-01f, -8.96032751e-02f, 1.12854145e-01f, 1.17421292e-01f, -3.76700491e-01f,
  -4.27037120e-01f, 1.79099329e-02f, -5.19800544e-01f, -5.89204013e-01f, -7.53224492e-01f, 2.83689946e-01f, -6.62540138e-01f, 4.13366884e-01f, -2.03826025e-01f, -3.78729105e-01f,
  -2.73274601e-01f, 3.35748971e-01f, -3.00237060e-01f, 4.75065619e-01f, -4.46714580e-01f, 1.00278825e-01f, -2.74078101e-01f, -6.74494505e-01f, 2.01543346e-01f, -1.36068761e-01f,
  5.55187404e-01f, -1.49024233e-01f, 2.08235756e-01f, 1.38086304e-01f, -3.76973078e-02f, -7.33260661e-02f, 2.44656112e-02f, 2.12673515e-01f, -3.99057001e-01f, 1.83682770e-01f,
  -1.20748781e-01f, -2.26725161e-01f, 2.70674825e-01f, 4.36376750e-01f, -3.05756748e-01f, -5.86071908e-02f, -1.95197552e-01f, 5.26145160e-01f, -4.96165335e-01f, 3.01186919e-01f,
  1.00602821e-01f, -3.07380974e-01f, -2.82065898e-01f, -1.17677137e-01f, 4.10053469e-02f, 4.39273536e-01f, -1.62894756e-01f, -3.70958418e-01f, -2.12793171e-01f, -4.96412337e-01f,
  6.96795434e-02f, 3.20822150e-01f, -7.54732937e-02f, -3.36266421e-02f, 3.32828879e-01f, 2.92103976e-01f, 2.95568526e-01f, 2.36213118e-01f, 2.51482688e-02f, 2.97047377e-01f,
  -3.30614597e-01f, 1.64015636e-01f, -9.06356275e-02f, 9.43874121e-02f, -4.71259095e-02f, 8.13386068e-02f, -2.49633864e-01f, -1.89444125e-01f, 4.05286461e-01f, 3.34627032e-01f,
  9.99344513e-02f, 5.17366886e-01f, 4.69970584e-01f, -3.78007859e-01f, -2.67117739e-01f, -2.72406876e-01f, -1.09481089e-01f, 2.68588543e-01f, 2.24918276e-01f, -7.13990256e-02f,
  5.17457664e-01f, -1.12173669e-01f, -3.80221426e-01f, 7.19146058e-02f, -3.02017599e-01f, -7.90128633e-02f, 3.96844506e-01f, 1.48363322e-01f, 4.50872369e-02f, -2.10541319e-02f,
  1.92508604e-02f, -1.42140418e-01f, -2.60036528e-01f, 9.03135091e-02f, -2.47656360e-01f, -2.69158836e-02f, 9.44439024e-02f, 2.96527863e-01f, 1.24254011e-01f, -3.70087139e-02f,
  -3.80206108e-01f, 2.26919040e-01f, -1.90658346e-01f, 5.13653643e-02f, 3.73784937e-02f, -1.43006116e-01f, -9.81395245e-02f, 5.97089492e-02f, -5.97179495e-02f, 1.06721492e-02f,
  3.85016739e-01f, 2.45626613e-01f, 5.44498503e-01f, 3.10198545e-01f, 1.41272709e-01f, -2.00902894e-01f, -7.08320141e-01f, 3.82900476e-01f, -4.78219353e-02f, -1.72551140e-01f,
  2.14377105e-01f, 3.52681726e-01f, -3.73305589e-01f, -2.29358554e-01f, -1.25769392e-01f, -2.93308377e-01f, -5.00941277e-02f, 9.54634510e-03f, 3.72010589e-01f, -2.56574452e-01f,
  2.89536685e-01f, -1.77926958e-01f, 1.37892356e-02f, 7.46182352e-02f, 3.53364021e-01f, 1.99879542e-01f, -2.26520017e-01f, -5.62291920e-01f, -3.15150857e-01f, -2.42640957e-01f,
  4.05337065e-01f, -1.04300708e-01f, -2.35889971e-01f, -5.61179817e-01f, 3.73827904e-01f, -5.34445465e-01f, 1.62089750e-01f, 7.88953304e-02f, 1.59610271e-01f, 2.01833714e-02f,
  5.09503186e-01f, 3.96476835e-01f, 4.04595762e-01f, 1.54297084e-01f, -3.51794735e-02f, 1.47371426e-01f, 1.83008239e-01f, -8.17348361e-02f, -2.34612301e-01f, 9.30898413e-02f,
  -1.07958972e-01f, 2.99969763e-01f, -6.00876957e-02f, 2.79922545e-01f, 7.68371880e-01f, 1.01285495e-01f, 2.26695567e-01f, 2.93295741e-01f, 2.72971094e-01f, -1.32249206e-01f,
  4.10479046e-02f, -2.76212662e-01f, -1.69485193e-02f, 4.61713165e-01f, -3.10350992e-02f, -1.91990033e-01f, 4.63166207e-01f, 2.56495579e-04f, -6.01994574e-01f, 5.73722869e-02f,
  -3.34370524e-01f, 5.95626310e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -1.40667766e-01f, -2.21515253e-01f, 4.39410567e-01f, 4.23714727e-01f, 2.23882914e-01f, 3.31091255e-01f, 3.21993470e-01f, 2.03636482e-01f, 8.06208774e-02f, 2.82224387e-01f,
  3.04368168e-01f, 4.43510681e-01f, 1.30577475e-01f, -1.56648785e-01f, 3.62048969e-02f, 3.97241451e-02f, 1.50206536e-01f, 5.43455243e-01f, -1.98656246e-01f, 3.21052223e-01f,
  7.19655097e-01f, 4.07915473e-01f, 4.98491526e-01f, 6.27583533e-04f, 1.11412846e-01f, 4.99786288e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -8.15010592e-02f, -4.64714170e-01f, -3.57779592e-01f, -4.36353356e-01f, 2.31046513e-01f, -1.97878182e-01f, 2.86479115e-01f, 1.65267795e-01f, 2.08336428e-01f, -3.70177925e-02f,
  -1.85091823e-01f, 8.02411586e-02f, -2.59500027e-01f, -3.36480327e-02f, -1.14645790e-02f, 1.54459327e-01f, 2.94455200e-01f, -1.05266921e-01f, -4.54673655e-02f, -1.26950899e-02f,
  -1.57470584e-01f, 8.48185271e-02f, 2.64731399e-03f, 2.07065307e-02f, 2.60354131e-02f, 8.25492367e-02f, -2.46339753e-01f, 1.35910781e-02f, -1.10461332e-01f, 5.58984615e-02f,
  2.18139708e-01f, -9.64502692e-02f, 2.09616080e-01f, 8.16229079e-03f, -9.83438566e-02f, 1.49051547e-01f, 1.33908484e-02f, 3.03191900e-01f, -2.72114277e-01f, -2.03455448e-01f,
  -2.24911034e-01f, 2.29622394e-01f, 5.87368272e-02f, 1.47458732e-01f, -5.71248420e-02f, 2.17564162e-02f, -2.33838465e-02f, 4.55677032e-01f, -4.35015678e-01f, -5.08006662e-02f,
  -1.53122500e-01f, 5.44188134e-02f, -1.17694274e-01f, -5.82657419e-02f, -7.68018067e-02f, 1.34153083e-01f, -1.05625838e-01f, 1.05920635e-01f, 1.11502334e-02f, -8.85587409e-02f,
  5.24302237e-02f, 8.26980993e-02f, -2.26732403e-01f, 5.23090251e-02f, -1.04108728e-01f, 2.03264579e-01f, 3.97532582e-01f, 1.63172498e-01f, 2.53699988e-01f, -2.66561359e-02f,
  -2.30596378e-01f, -9.75953322e-03f, -3.01293582e-01f, 8.32910910e-02f, 4.81675528e-02f, -1.28201127e-01f, -1.52198579e-02f, -2.61316836e-01f, -1.72230616e-01f, -1.04164220e-01f,
  1.92002848e-01f, 2.01824665e-01f, 1.17880581e-02f, 1.19361460e-01f, -1.21450767e-01f, 2.62101889e-01f, -1.16265707e-01f, 1.34883329e-01f, 5.14510609e-02f, 7.44872075e-03f,
  1.55082032e-01f, 1.58303246e-01f, 4.99665327e-02f, -2.40908146e-01f, -3.47624809e-01f, 9.64671746e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -4.46730316e-01f, -3.69621068e-01f, 6.31633222e-01f, 2.69637316e-01f, 3.77092779e-01f, -2.61310607e-01f, 3.44951749e-01f, -7.05501363e-02f, 3.88680130e-01f, -1.76447079e-01f,
  -1.79282814e-01f, 5.64479455e-02f, -6.89037666e-02f, 3.75608802e-02f, -1.83620647e-01f, -1.99157581e-01f, 5.48814058e-01f, 7.83190504e-02f, 1.66122481e-01f, -2.46027246e-01f,
  1.16631754e-01f, 1.27268717e-01f, 3.72315168e-01f, 4.45125163e-01f, 2.56716400e-01f, -6.89824820e-01f, -6.45695269e-01f, -1.40025765e-01f, -3.10148716e-01f, -2.30694786e-02f,
  4.53509718e-01f, -2.18212306e-01f, 2.03271315e-01f, 2.56180674e-01f, -7.78708905e-02f, -4.13285702e-01f, -3.34452450e-01f, -2.18340918e-01f, -1.49871528e-01f, 2.34449387e-01f,
  3.13535184e-01f, 2.64641970e-01f, 3.63717616e-01f, -4.74258542e-01f, 2.65708923e-01f, 2.19558656e-01f, 5.04207835e-02f, -5.69638669e-01f, 3.73259157e-01f, -5.25875017e-02f,
  4.24298018e-01f, 1.98902503e-01f, 1.70992553e-01f, 1.04567166e-02f, -1.17148899e-01f, -1.69098467e-01f, -3.28946084e-01f, -5.19831739e-02f, 3.60965014e-01f, 5.22980928e-01f,
  -1.40793830e-01f, -4.09455299e-01f, 6.40273929e-01f, 1.57220751e-01f, 1.78722635e-01f, -4.72434342e-01f, 3.18091542e-01f, 3.99012953e-01f, 4.45061922e-01f, -3.06886375e-01f,
  2.86750227e-01f, 1.70447096e-01f, -1.64785922e-01f, 1.74683079e-01f, 3.64220411e-01f, -2.35454664e-01f, 2.58473992e-01f, -5.35420418e-01f, 9.22336802e-03f, -7.78872669e-02f,
  -1.01998650e-01f, 1.46743834e-01f, 3.26599360e-01f, -5.88967025e-01f, -3.62797379e-01f, 4.44146097e-01f, 8.35821554e-02f, 3.77669156e-01f, 2.35647023e-01f, -5.42754054e-01f,
  1.97969973e-02f, -6.08812906e-02f, -3.56706530e-01f, -5.32399476e-01f, -2.34429464e-01f, -4.66599762e-01f, 2.06361469e-02f, 3.70909333e-01f, 2.56485552e-01f, 2.64006127e-02f,
  -7.80068785e-02f, 9.17583052e-03f, 1.45567313e-01f, 6.35165796e-02f, -8.55703890e-01f, 1.81119218e-01f, 2.55319178e-01f, 9.92743820e-02f, 6.25761747e-02f, 7.54345655e-02f,
  5.65817505e-02f, 3.66035730e-01f, 6.79900587e-01f, 1.17859602e-01f, -7.76403695e-02f, -8.17534551e-02f, -1.56620190e-01f, 1.80605292e-01f, -1.26952901e-01f, -7.06476942e-02f,
  1.58327281e-01f, 4.51959930e-02f, -1.55991867e-01f, 3.15106004e-01f, 3.03764492e-01f, 3.14890891e-01f, -3.78078997e-01f, 3.43693733e-01f, -2.49447063e-01f, -1.04737751e-01f,
  6.06547773e-01f, 1.89673215e-01f, -3.63398641e-01f, 1.05249085e-01f, 2.23142803e-01f, -2.27251962e-01f, 3.77866834e-01f, -2.28275776e-01f, -5.80962524e-02f, -7.77666718e-02f,
  1.20227277e-01f, 3.74518931e-01f, 4.14544225e-01f, -3.12083244e-01f, -1.03342114e-02f, 4.24260050e-01f, -1.08032476e-03f, 3.26685488e-01f, 3.92321676e-01f, -1.91795319e-01f,
  3.45539600e-01f, 3.79323602e-01f, -1.36160344e-01f, 1.25902832e-01f, 1.60715252e-01f, -2.99801141e-01f, -1.35253757e-01f, -8.66728052e-02f, -1.70461953e-01f, -2.84182746e-02f,
  -1.28744990e-01f, 1.10975407e-01f, -2.62115091e-01f, 4.87319380e-01f, -5.11798084e-01f, 1.27472296e-01f, -8.33154097e-02f, -7.29802370e-01f, -3.03017527e-01f, -2.79805094e-01f,
  -1.81903720e-01f, 2.96330541e-01f, -2.36616489e-02f, 2.23323420e-01f, 1.39398158e-01f, 1.50953943e-04f, -5.75768910e-02f, 3.78760919e-02f, -9.44665521e-02f, 2.45258063e-01f,
  3.37756872e-01f, 5.88860400e-02f, 1.84630111e-01f, -2.47318864e-01f, 7.20036328e-02f, 3.09149683e-01f, -1.20612912e-01f, -1.98206857e-01f, 1.93203181e-01f, -6.11380786e-02f,
  -3.46333981e-01f, 1.49449632e-01f, -2.82420162e-02f, 2.47638747e-01f, 1.54708996e-01f, -6.13546789e-01f, 2.60371864e-01f, 1.19854718e-01f, -4.02003974e-01f, 3.15408230e-01f,
  3.10228735e-01f, 5.16376853e-01f, 4.08399314e-01f, 9.69798386e-01f, -1.55224934e-01f, 2.23363891e-01f, -2.37604424e-01f, 1.06834225e-01f, -1.58265680e-01f, -1.92749519e-02f,
  -1.12354711e-01f, 1.45598084e-01f, -1.49686322e-01f, 3.19108695e-01f, 3.51789780e-02f, 2.59165257e-01f, 5.09613194e-02f, 1.94979683e-01f, -7.23752558e-01f, -1.29333660e-01f,
  6.53763413e-01f, 2.70500332e-01f, 6.74606919e-01f, 5.71941614e-01f, 5.98559268e-02f, -3.65699261e-01f, 6.69556022e-01f, 2.10483432e-01f, 7.79973447e-01f, 1.77710965e-01f,
  -3.89448941e-01f, 1.21745177e-01f, 2.07349688e-01f, 2.33920857e-01f, 2.67040491e-01f, -7.66494945e-02f, 2.30720520e-01f, -2.99783647e-01f, -1.17264390e-01f, -6.40924647e-02f,
  -3.04653555e-01f, 4.18658942e-01f, -2.89151281e-01f, -2.49937952e-01f, -7.84550235e-02f, -2.54749775e-01f, -3.25301915e-01f, 5.93741417e-01f, -5.60041606e-01f, -1.80478767e-01f,
  5.60019851e-01f, 4.04133528e-01f, 1.78930849e-01f, 7.73934498e-02f, -9.85977575e-02f, -1.28727674e-01f, 3.35039347e-01f, 8.81211758e-02f, -2.27913186e-02f, -2.89855987e-01f,
  -1.72123119e-01f, 3.13948393e-02f, 3.20165634e-01f, 3.33007544e-01f, -7.82498956e-01f, 2.35349432e-01f, 2.25592569e-01f, 5.26556313e-01f, 1.64065242e-01f, 1.59263715e-01f,
  2.74374157e-01f, 1.16131924e-01f, 5.20515293e-02f, -1.92532718e-01f, -4.37691920e-02f, 5.98213859e-02f, 1.79274783e-01f, 2.59444932e-03f, 1.36228517e-01f, 2.55382925e-01f,
  3.85728739e-02f, 1.64077785e-02f, -2.03366235e-01f, 3.84419441e-01f, 3.98715049e-01f, 2.05311924e-01f, -4.80956525e-01f, 2.46451467e-01f, 1.22503512e-01f, 2.47278720e-01f,
  2.40517586e-01f, -4.92633495e-04f, 2.11635996e-02f, -2.56730288e-01f, -9.58264247e-02f, 7.07714781e-02f, -4.78455454e-01f, -5.26993454e-01f, 2.20499724e-01f, -3.73121560e-01f,
  3.14204469e-02f, 2.61275738e-01f, -4.89571951e-02f, -5.08122623e-01f, -2.59144276e-01f, 2.20238239e-01f, 3.93946975e-01f, 1.07947670e-01f, 3.13515544e-01f, 2.55335152e-01f,
  -1.23030215e-03f, 3.29344332e-01f, 4.67785411e-02f, -7.79789090e-02f, -3.77079576e-01f, -5.73803663e-01f, -4.02699471e-01f, -2.05264553e-01f, -1.91080824e-01f, 2.33256996e-01f,
  9.71700698e-02f, -3.21013808e-01f, 2.06497073e-01f, 5.30001342e-01f, 5.89428186e-01f, -9.72985625e-02f, -1.07842915e-01f, 3.17512229e-02f, 1.36534154e-01f, -9.02124196e-02f,
  1.04879774e-01f, -9.96318385e-02f, -7.52014741e-02f, -4.81945813e-01f, 2.84185521e-02f, 1.22549340e-01f, -2.46289834e-01f, 2.72333652e-01f, 2.87123412e-01f, -4.85558838e-01f,
  -4.28846218e-02f, 5.15290916e-01f, 3.05218488e-01f, 4.27574426e-01f, 2.53935963e-01f, -6.34918213e-01f, -4.01630886e-02f, -3.86110902e-01f, -3.68463576e-01f, -2.45643511e-01f,
  -2.63810128e-01f, -5.04493535e-01f, 2.81592548e-01f, 4.05741125e-01f, -1.68701373e-02f, -5.06350219e-01f, 7.63750225e-02f, -4.97179888e-02f, -2.58198321e-01f, -1.70398608e-01f,
  3.50882947e-01f, -3.45270544e-01f, 2.05760241e-01f, -3.74670893e-01f, -2.23932326e-01f, 7.39708245e-02f, -1.29655391e-01f, -5.58013916e-01f, -2.03789398e-01f, 1.26859263e-01f,
  3.33141237e-01f, -1.21465497e-01f, -1.01423867e-01f, 3.77795905e-01f, 6.76272437e-02f, -1.12612277e-01f, -7.67746642e-02f, 2.24984646e-01f, -5.53133152e-02f, -2.68533111e-01f,
  9.87898484e-02f, -2.21718535e-01f, 3.99732739e-01f, 3.54370862e-01f, 3.38613123e-01f, 3.35215718e-01f, -1.64707854e-01f, -1.64271697e-01f, -8.39722008e-02f, -1.27856076e-01f,
  -3.39602903e-02f, 1.96844339e-02f, -2.66788244e-01f, 3.40687260e-02f, 4.98100340e-01f, -7.03065172e-02f, -5.43976650e-02f, 4.58234847e-02f, 2.04771813e-02f, 1.46224171e-01f,
  -5.02245903e-01f, 8.40019807e-02f, 1.56662494e-01f, 2.31271580e-01f, 1.96311399e-01f, 3.21236253e-01f, -1.73380315e-01f, -3.67268413e-01f, -2.69734263e-01f, 7.29958341e-02f,
  -1.19307354e-01f, -1.43327981e-01f, 1.89025834e-01f, 8.74609500e-02f, -4.22622532e-01f, 3.19480836e-01f, -3.20286423e-01f, -8.88046026e-01f, -5.21666050e-01f, 1.85303792e-01f,
  -1.52276531e-01f, -1.24567740e-01f, 3.29449803e-01f, -2.54997045e-01f, 5.01127958e-01f, -2.28035823e-01f, -6.14139795e-01f, 1.03083961e-01f, -2.26789623e-01f, 9.15344134e-02f,
  2.15817094e-01f, -1.36255950e-01f, 1.16608240e-01f, -2.97575891e-01f, -2.66432948e-02f, -1.38450842e-02f, 2.63065130e-01f, 1.17607683e-01f, 3.90763044e-01f, 2.77104795e-01f,
  4.52320158e-01f, -2.79739946e-02f, 1.73460203e-03f, -1.15276366e-01f, -2.35017553e-01f, 3.00345331e-01f, -2.61887163e-02f, -2.01312572e-01f, -3.92846726e-02f, -2.49829248e-01f,
  4.72404882e-02f, -7.10343540e-01f, 1.30296558e-01f, -4.15389538e-01f, -1.22777492e-01f, 1.10568322e-01f, 4.37047631e-01f, -3.73050511e-01f, 1.21345803e-01f, 2.84890067e-02f,
  7.92897418e-02f, 3.15139681e-01f, -2.17596125e-02f, 1.10902458e-01f, -1.56288311e-01f, -1.16403259e-01f, 1.11031495e-01f, 2.56630629e-01f, 2.47274980e-01f, 4.44968283e-01f,
  1.04077235e-01f, -8.76325518e-02f, 4.29718524e-01f, -2.13344097e-01f, -2.05622062e-01f, -2.44921818e-01f, -3.06792378e-01f, 1.21418029e-01f, 3.34352225e-01f, 2.75648862e-01f,
  3.09236467e-01f, 9.60120916e-01f, 4.09821630e-01f, 6.54518604e-01f, 1.24107398e-01f, 7.50649333e-01f, -4.30141866e-01f, -3.49320084e-01f, -2.16491632e-02f, 4.91777718e-01f,
  -3.71999741e-02f, 5.04950106e-01f, -2.23181024e-01f, -1.17434174e-01f, 1.27301186e-01f, 5.17029822e-01f, 3.85397881e-01f, 1.25080988e-01f, -3.96415591e-01f, -2.96526462e-01f,
  8.47095102e-02f, -1.85633618e-02f, 8.35639313e-02f, -6.11042939e-02f, -3.92165750e-01f, 4.45115536e-01f, 2.74869144e-01f, 2.87155271e-01f, 4.88530040e-01f, 2.87753314e-01f,
  -2.27735966e-01f, 3.58189374e-01f, 2.34185457e-02f, -4.39738706e-02f, -2.79260248e-01f, -9.37081426e-02f, 4.89057332e-01f, -5.62898591e-02f, -6.62804693e-02f, 1.74359143e-01f,
  -2.82360554e-01f, 3.88951480e-01f, 2.51420856e-01f, 2.81937569e-01f, -1.58719480e-01f, -4.96487588e-01f, -4.49922085e-01f, -3.35607350e-01f, 1.61602899e-01f, -2.41420604e-02f,
  3.00920784e-01f, -2.23483086e-01f, -7.91674480e-02f, 5.62562108e-01f, -2.98598588e-01f, 3.99571985e-01f, 1.18623890e-01f, -2.12048098e-01f, -5.07831752e-01f, -1.24217540e-01f,
  4.37898368e-01f, 6.49663135e-02f, 3.73984985e-02f, 7.89772794e-02f, 2.38464043e-01f, 2.30698481e-01f, 5.11697412e-01f, 1.52234703e-01f, 5.97595394e-01f, 3.97014320e-01f,
  7.65086990e-03f, -6.65309504e-02f, 4.84009236e-01f, 6.83065206e-02f, -2.99218357e-01f, -4.21009511e-01f, 1.57549009e-01f, 2.88639194e-03f, 6.50200769e-02f, 1.18264146e-01f,
  2.69960761e-01f, 3.83792669e-01f, -1.48498386e-01f, -2.47126907e-01f, 1.77573904e-01f, 2.64735743e-02f, -4.74623702e-02f, 1.26792610e-01f, -1.43923480e-02f, 1.66200966e-01f,
  6.26987517e-01f, 4.55413312e-01f, 1.96030855e-01f, 9.15970132e-02f, -2.63499677e-01f, -1.17569119e-01f, 4.35777545e-01f, -3.12575519e-01f, -2.28647694e-01f, 5.07646352e-02f,
  -9.38232020e-02f, -3.19091558e-01f, 2.79427081e-01f, 1.53253675e-01f, -3.47080417e-02f, 1.42719343e-01f, -3.46910506e-02f, -8.99697423e-01f, 7.07160160e-02f, -8.38797316e-02f,
  8.80951956e-02f, -3.25893790e-01f, -2.16004290e-02f, 1.84351191e-01f, 8.73682350e-02f, 6.01951927e-02f, 1.59331441e-01f, 3.18393469e-01f, 2.54690051e-01f, -1.08147301e-01f,
  2.35400990e-01f, -3.53143126e-01f, -1.36867300e-01f, 1.38622373e-02f, -6.55766845e-01f, -9.09835249e-02f, -3.15156609e-01f, -2.38163576e-01f, 1.84667811e-01f, -2.66861618e-01f,
  -1.19767033e-01f, -7.26724043e-02f, 3.46187294e-01f, 3.41180861e-01f, 3.90731990e-02f, 3.61240089e-01f, -8.20672438e-02f, 4.35876280e-01f, 9.93036106e-02f, -1.46920696e-01f,
  2.31746837e-01f, -3.47001731e-01f, 9.93601009e-02f, -2.43462890e-01f, 4.53948714e-02f, -3.57459113e-02f, -4.06255834e-02f, -4.32992786e-01f, -5.86636811e-02f, -2.22243816e-01f,
  4.82678041e-02f, 5.82260219e-03f, -2.45630518e-01f, 2.21694887e-01f, 9.24374387e-02f, 5.24609089e-01f, 3.14684987e-01f, -2.11106569e-01f, 1.58193633e-01f, -2.61660457e-01f,
  3.39697093e-01f, -2.83047289e-01f, 3.75050575e-01f, 5.49789250e-01f, 1.67095333e-01f, 2.20968783e-01f, 3.67565826e-02f, 1.36018218e-02f, 5.16957223e-01f, 1.07997634e-01f,
  -9.24207270e-02f, 2.17921153e-01f, 2.94524848e-01f, -3.60913351e-02f, 7.94653222e-02f, -5.75742051e-02f, -6.58534765e-01f, 4.21381563e-01f, 5.19814566e-02f, 4.91143130e-02f,
  1.21718511e-01f, -7.31423274e-02f, 4.38337624e-01f, 6.82303548e-01f, -2.17086166e-01f, 1.28210053e-01f, 3.67638201e-01f, -1.33815959e-01f, -1.84342954e-02f, 3.41575965e-02f,
  -2.57429689e-01f, -8.66334438e-02f, 7.09375218e-02f, 6.32015884e-01f, 5.79090476e-01f, 2.41537333e-01f, -7.31881917e-01f, 7.65071511e-02f, -1.16798446e-01f, -2.10679337e-01f,
  6.72127828e-02f, -1.53462812e-01f, -4.88707647e-02f, -1.94469526e-01f, -1.22989090e-02f, 7.99241066e-02f, 2.05746308e-01f, -5.25805205e-02f, 4.46077585e-01f, 2.73990661e-01f,
  1.96876168e-01f, -5.29554933e-02f, 1.74543247e-01f, -7.75202364e-02f, 1.77465841e-01f, -7.71781683e-01f, -1.70729727e-01f, 7.30205253e-02f, 1.10864662e-01f, 3.82269651e-01f,
  8.81236345e-02f, -7.98595548e-02f, 8.98161307e-02f, 3.05649992e-02f, 4.65874493e-01f, -6.77172169e-02f, 5.70823215e-02f, 4.69535664e-02f, -2.24440843e-01f, -1.14731630e-02f,
  -3.84107798e-01f, -3.11204255e-01f, -3.77893567e-01f, -1.61649957e-01f, -7.87934884e-02f, 2.40770131e-01f, -3.01431298e-01f, 2.00300142e-01f, 2.25031257e-01f, -1.58078715e-01f,
  -5.59542298e-01f, 1.90004319e-01f, 3.72008979e-03f, 1.20761245e-01f, 3.48310590e-01f, -9.61454213e-02f, 3.95671099e-01f, 3.29800278e-01f, -3.86356041e-02f, 5.03709793e-01f,
  -5.07725060e-01f, -2.46998161e-01f, 2.33673692e-01f, 2.61510015e-01f, 9.72428471e-02f, 1.25067174e-01f, -2.89293468e-01f, -1.28266573e-01f, 2.19691060e-02f, 5.68187647e-02f,
  3.46992433e-01f, 1.32452682e-01f, 3.69425640e-02f, -1.45019993e-01f, -1.87110037e-01f, 4.19219099e-02f, -1.30998239e-01f, 1.72540724e-01f, 5.75927272e-02f, 9.31986272e-02f,
  4.54744026e-02f, 3.12647402e-01f, 6.14429712e-01f, -1.60499692e-01f, -1.49589941e-01f, 2.96363205e-01f, 3.44432235e-01f, 2.57669330e-01f, 5.68991750e-02f, -8.38577151e-01f,
  5.70930362e-01f, -6.45121858e-02f, 7.14341402e-02f, 2.58489341e-01f, -1.51820675e-01f, 2.49276042e-01f, -2.94453174e-01f, 1.93577290e-01f, 2.69937426e-01f, 2.43921965e-01f,
  1.50849536e-01f, 7.33369768e-01f, -2.04802722e-01f, 6.76482022e-01f, -2.61518478e-01f, -3.52136761e-01f, 5.43914698e-02f, 1.71635568e-01f, -3.42342049e-01f, 3.79049450e-01f,
  4.47746925e-02f, 2.32909620e-01f, 2.29498763e-02f, 2.29277223e-01f, -1.20151445e-01f, 2.79497504e-01f, -2.94923097e-01f, 2.33996324e-02f, -6.16651494e-03f, -5.80837011e-01f,
  2.75115907e-01f, 1.61554292e-01f, -2.12941170e-01f, 4.81722474e-01f, 1.25009909e-01f, 2.58710921e-01f, 6.00457907e-01f, 1.18328638e-01f, -3.28659862e-02f, 1.83211997e-01f,
  -1.67555377e-01f, -4.54447269e-02f, 1.24007894e-03f, -3.74294132e-01f, -4.41326499e-01f, -4.02405828e-01f, 1.08915068e-01f, 2.69145429e-01f, 4.90432590e-01f, -4.79540795e-01f,
  -3.79381999e-02f, -1.70710370e-01f, 2.20262334e-02f, 4.54420000e-01f, 2.25341275e-01f, -1.28152981e-01f, -1.14968553e-01f, 6.69700429e-02f, 2.55214363e-01f, 2.83577174e-01f,
  6.96740448e-02f, -1.77865937e-01f, 3.44717979e-01f, -4.00113836e-02f, 3.22605371e-01f, 5.20725921e-02f, 1.32729575e-01f, -2.57079333e-01f, -2.77135909e-01f, 1.90676883e-01f,
  4.29627299e-02f, -7.95543417e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.33071601e-01f, 3.64506871e-01f, 3.14317286e-01f, 6.29989430e-02f, 4.29564565e-01f, 6.01499267e-02f, 2.04730630e-01f, 4.06771749e-01f, 3.50700170e-02f, 1.11324213e-01f,
  7.23690465e-02f, 9.66716707e-02f, 5.76470122e-02f, -2.10360289e-01f, -2.59118736e-01f, 4.21958685e-01f, 1.50152862e-01f, 1.86272055e-01f, 3.24061438e-02f, 1.79554999e-01f,
  2.85780281e-01f, 2.57679641e-01f, 7.01801255e-02f, -2.73742750e-02f, 2.93809742e-01f, 8.00625533e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -5.28948270e-02f, -3.12399864e-02f, 3.23813520e-02f, 3.52749795e-01f, -1.20359389e-02f, 6.02889776e-01f, -3.03873181e-01f, -4.03917849e-01f, -3.02328080e-01f, -1.09454438e-01f,
  7.49680549e-02f, 2.71252453e-01f, 1.78383589e-02f, -1.16157472e-01f, 7.03558102e-02f, -3.68277073e-01f, 4.32064272e-02f, -1.44329354e-01f, -1.85366094e-01f, 5.79871178e-01f,
  1.96554095e-01f, -2.19331950e-01f, -2.41633058e-02f, -8.91529024e-02f, -8.54329094e-02f, 2.72305459e-02f, 2.08078343e-02f, -2.41403416e-01f, 2.19113171e-01f, 1.49126217e-01f,
  2.03018952e-02f, 2.65376389e-01f, 1.49922892e-01f, -2.70756662e-01f, -1.24421589e-01f, -9.81295202e-03f, -1.40330374e-01f, -3.67616266e-01f, 3.46672237e-01f, 2.11591888e-02f,
  6.34959638e-02f, -1.93793327e-02f, 2.58568585e-01f, 1.12172619e-01f, -5.96990466e-01f, -3.35900605e-01f, 7.16500357e-02f, 1.11880928e-01f, 9.49671194e-02f, -3.66623521e-01f,
  -1.55842409e-01f, 3.63922298e-01f, 1.33486792e-01f, -5.73156655e-01f, -1.86202407e-01f, 1.02198228e-01f, 3.83746922e-01f, 6.67328537e-02f, 1.60610154e-01f, -5.97343408e-03f,
  1.04446284e-01f, 2.18888633e-02f, -4.71000969e-01f, 2.36343145e-01f, 7.26905987e-02f, 2.59100229e-01f, 1.70835018e-01f, -2.89922476e-01f, 4.73356470e-02f, 6.18658923e-02f,
  -1.81861222e-01f, 1.52484491e-01f, -6.59038246e-01f, 3.56413960e-01f, 1.79613054e-01f, 2.59629190e-01f, -8.11674178e-01f, -7.63388053e-02f, -1.03879839e-01f, -2.63928860e-01f,
  -2.86229640e-01f, -2.58533686e-01f, -5.99080808e-02f, -1.45471558e-01f, -1.36228487e-01f, 3.24729860e-01f, -3.77931207e-01f, 2.54981399e-01f, -4.19141352e-01f, -3.52148384e-01f,
  -3.19516897e-01f, 6.58121943e-01f, -4.52558488e-01f, 4.27283436e-01f, 9.75083783e-02f, -1.65855270e-02f, -5.78895248e-02f, -4.00125496e-02f, -1.95829272e-01f, 8.87817979e-01f,
  -4.22225371e-02f, -1.05712399e-01f, 4.12765332e-02f, -3.33391845e-01f, -3.20942163e-01f, 3.43962669e-01f, -7.33708203e-01f, -1.49527609e-01f, 2.01506943e-01f, -2.27622911e-01f,
  1.96085691e-01f, -1.31317616e-01f, 1.08429544e-01f, -1.64303780e-01f, 2.36555934e-01f, -1.84007123e-01f, 2.70731747e-01f, 3.24725807e-02f, 8.59914795e-02f, -5.00394881e-01f,
  -4.14937772e-02f, -5.57582021e-01f, -7.26265609e-01f, -5.20839989e-01f, -1.11298330e-01f, 1.86622426e-01f, -3.56765762e-02f, -5.79458065e-02f, 1.16721638e-01f, -5.65707684e-01f,
  -2.84167200e-01f, -1.56620711e-01f, 9.16273296e-02f, -6.67641699e-01f, -9.67586786e-02f, 2.11725965e-01f, 1.96908027e-01f, 1.40269220e-01f, -1.12881333e-01f, 3.03146750e-01f,
  1.06963463e-01f, -6.22577310e-01f, 1.21453725e-01f, -4.10096496e-01f, -6.64369836e-02f, -2.13287950e-01f, 2.31986074e-03f, -2.61228472e-01f, -4.80514914e-01f, 2.70143926e-01f,
  -4.58282232e-01f, -3.87712300e-01f, 1.95194900e-01f, 3.33672501e-02f, -6.16957732e-02f, 1.97686478e-01f, 2.16099694e-01f, -1.42905489e-01f, 2.39731610e-01f, -8.48454610e-02f,
  -2.93795913e-01f, 3.13072056e-01f, 1.66560471e-01f, -1.53810814e-01f, 8.97079781e-02f, -4.45788562e-01f, -6.78768575e-01f, 2.76668638e-01f, -1.65522620e-01f, -3.07465661e-02f,
  2.38304004e-01f, -7.11099729e-02f, 2.26436350e-02f, -6.93701655e-02f, 1.59581974e-02f, 4.06203449e-01f, -2.70596385e-01f, 2.96290010e-01f, 3.12874615e-01f, -5.14007390e-01f,
  3.03178489e-01f, -6.02360666e-01f, -5.24001241e-01f, -1.36831358e-01f, -1.00941151e-01f, -5.66932708e-02f, 1.39933825e-01f, 6.54338161e-03f, 2.73938447e-01f, -1.41046435e-01f,
  -1.48196146e-01f, 2.30860770e-01f, -2.35602766e-01f, 3.38019699e-01f, 3.72696429e-01f, -3.07863891e-01f, 1.66014329e-01f, 1.33599237e-01f, -2.84554660e-01f, 8.29060189e-03f,
  2.57637382e-01f, -4.00139481e-01f, 2.90395647e-01f, -2.10634366e-01f, -7.19987690e-01f, 4.92052764e-01f, -6.32222235e-01f, -3.97395849e-01f, 3.30482483e-01f, -2.32349738e-01f,
  -4.09850031e-01f, -1.93876654e-01f, -3.71393919e-01f, -1.52781621e-01f, -8.01733792e-01f, 1.94495440e-01f, -4.52441759e-02f, -1.40524777e-02f, 4.44110245e-01f, -3.79288524e-01f,
  -5.81626296e-01f, -3.17401022e-01f, -6.04234673e-02f, -2.50780672e-01f, -2.07518592e-01f, 7.04114735e-02f, -2.05411196e-01f, 2.68246979e-01f, 1.30937383e-01f, -9.53264013e-02f,
  1.16060890e-01f, 3.26649636e-01f, 1.40594959e-01f, 1.16259687e-01f, -4.82484967e-01f, -1.29683524e-01f, 2.98669159e-01f, 2.61009127e-01f, 1.12871327e-01f, -3.61801654e-01f,
  -1.07454948e-01f, -2.03062698e-01f, -2.18413517e-01f, 6.68055424e-03f, -1.84262753e-01f, -2.92434394e-01f, 2.24953517e-01f, 3.69515410e-03f, -7.36230286e-03f, 2.68031359e-01f,
  -1.06451623e-01f, -1.75581932e-01f, -1.87148675e-01f, 7.04932085e-04f, -4.72239494e-01f, -2.86098331e-01f, 8.46647173e-02f, 1.36850163e-01f, -6.66832402e-02f, -2.98929453e-01f,
  -1.24342591e-01f, 3.82788390e-01f, -1.17450774e-01f, 2.03811586e-01f, 1.94163308e-01f, -3.10777277e-01f, -4.65277165e-01f, -5.63972555e-02f, -4.54025529e-02f, -1.96938932e-01f,
  -3.48487049e-01f, 3.69167924e-01f, 3.82731706e-01f, 4.77173090e-01f, 2.98747241e-01f, 1.23707131e-01f, 2.62293488e-01f, -3.60147595e-01f, 4.81139809e-01f, -2.40204886e-01f,
  1.99135929e-01f, -2.18393207e-01f, -1.45368129e-01f, -3.76134403e-02f, -7.39264011e-01f, -2.00681299e-01f, 5.21702170e-02f, -1.88310862e-01f, 2.16623172e-02f, -1.04648903e-01f,
  6.21873885e-02f, -3.71051848e-01f, 4.34523225e-02f, 4.95832413e-01f, -2.31581077e-01f, 6.72196178e-03f, -3.96530956e-01f, -8.04469528e-05f, -1.80173934e-01f, -2.78380156e-01f,
  -3.10663432e-01f, 2.01990634e-01f, 9.94367525e-02f, -1.96654409e-01f, -4.41811204e-01f, 3.15969348e-01f, -4.14222986e-01f, -1.72153220e-01f, -3.56319636e-01f, 4.95956630e-01f,
  -5.33273935e-01f, 3.53073031e-01f, -3.48315030e-01f, 3.27452928e-01f, 2.46599391e-01f, -2.37055451e-01f, -1.65964756e-02f, -7.90398717e-01f, 2.52689362e-01f, -2.43441001e-01f,
  -1.67140394e-01f, -4.08918351e-01f, -3.95643059e-03f, 6.58036113e-01f, -2.85532743e-01f, -1.77049667e-01f, 5.14724731e-01f, 3.83254170e-01f, -6.67062402e-01f, -3.61957788e-01f,
  -7.05243424e-02f, -6.65486276e-01f, 5.76304197e-01f, -2.83040613e-01f, -6.37698889e-01f, -8.42211768e-02f, -6.60057783e-01f, 3.63582969e-01f, -3.47690344e-01f, -2.85190972e-03f,
  3.53781164e-01f, -1.29061565e-01f, -2.97210310e-02f, -5.37774563e-02f, -4.88055408e-01f, -4.29520130e-01f, -4.87630844e-01f, 1.42593652e-01f, -2.32799500e-01f, -1.15896679e-01f,
  -1.05184674e-01f, 1.85173422e-01f, 2.36007646e-01f, 9.42314714e-02f, 5.55758700e-02f, -2.41143465e-01f, -1.17582209e-01f, 2.97692955e-01f, 6.70422494e-01f, -6.71431839e-01f,
  2.05719650e-01f, -2.03843992e-02f, 1.12995483e-01f, 1.19676832e-02f, 3.35485578e-01f, 1.34754404e-01f, -4.96533141e-02f, 2.20268488e-01f, 3.95089269e-01f, -1.28343463e-01f,
  -4.98483956e-01f, -5.35871796e-02f, -1.10832050e-01f, -2.12585554e-01f, 3.09394062e-01f, -5.04797220e-01f, -3.63852859e-01f, -3.36017042e-01f, 1.60874456e-01f, -4.91677672e-01f,
  1.05014868e-01f, -4.25797313e-01f, -4.54036623e-01f, -5.34463942e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.96676749e-01f, -2.23344281e-01f, 1.23398468e-01f, -5.93820848e-02f, 1.38295591e-01f, -2.07564697e-01f, 1.40713170e-01f, -2.26362750e-01f, -2.09250711e-02f, 1.09652661e-01f,
  9.65557918e-02f, -9.04693678e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    