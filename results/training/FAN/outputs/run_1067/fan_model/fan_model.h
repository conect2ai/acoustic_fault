/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.80553854e-01f, 2.48446867e-01f, 3.23704123e-01f, -2.05625534e-01f, 3.28948796e-01f, 3.08463365e-01f, 4.54823583e-01f, 5.82494736e-02f, -7.53216892e-02f, 1.25524938e-01f,
  1.71392620e-01f, 4.62486036e-02f, 3.90728489e-02f, 4.24690284e-02f, -8.81435573e-02f, 3.72013122e-01f, 3.67685318e-01f, -4.00908105e-03f, -7.87590165e-03f, 1.88540727e-01f,
  1.94918230e-01f, 2.48404723e-02f, -2.71460623e-01f, -1.08604148e-01f, 2.63693631e-01f, 9.13636535e-02f, 1.37917727e-01f, 1.82988882e-01f, 3.09354931e-01f, 3.35176736e-01f,
  3.20888042e-01f, -2.54987534e-02f, 3.15611176e-02f, -2.16839425e-02f, 1.81708321e-01f, 3.39074805e-02f, 5.53302057e-02f, 5.63346781e-02f, 7.54071325e-02f, 9.05433297e-02f,
  7.99935013e-02f, 4.23239991e-02f, 1.39948472e-01f, 2.30001837e-01f, 5.23464344e-02f, 9.83814299e-02f, 3.95049825e-02f, 8.14114660e-02f, 1.37410671e-01f, 1.40973136e-01f,
  1.85528710e-01f, 1.67409927e-01f, 4.48496314e-03f, 1.21131472e-01f, 7.67369047e-02f, 2.60280352e-02f, 2.25153685e-01f, 1.47271186e-01f, 7.61710182e-02f, 1.03524692e-01f,
  -1.09658517e-01f, -1.76466256e-01f, -1.23167612e-01f, -1.14272349e-01f, -1.67351380e-01f, 1.38300126e-02f, -8.27114433e-02f, -5.55116683e-02f, -1.23326741e-01f, -1.31598994e-01f,
  -4.14253771e-02f, -5.67003526e-02f, -8.16481113e-02f, -1.10196948e-01f, -1.20432980e-01f, -9.81193408e-02f, -4.58342098e-02f, -1.15585253e-01f, -1.03778198e-01f, -4.57990319e-02f,
  -1.59612343e-01f, -1.78113822e-02f, -7.68179595e-02f, 6.88616512e-03f, -3.70142832e-02f, -8.68283808e-02f, -7.45518580e-02f, -1.33676082e-01f, -1.15981981e-01f, -8.37867931e-02f,
  1.25484854e-01f, -1.62081476e-02f, 1.70335114e-01f, 4.31910418e-02f, 1.52126253e-01f, 7.57406354e-02f, 8.13635960e-02f, 1.84427053e-01f, 1.42342791e-01f, 1.43384278e-01f,
  1.59984246e-01f, -2.48628501e-02f, 1.12345695e-01f, 1.39917776e-01f, 9.57065374e-02f, 8.58300924e-02f, 7.87212476e-02f, 1.22050628e-01f, 7.54934922e-02f, 1.59744397e-01f,
  5.99393174e-02f, 7.80803338e-02f, 1.14467211e-01f, 1.23726994e-01f, 1.19084604e-01f, 9.46304873e-02f, 1.67594761e-01f, 2.41843969e-01f, 5.47221825e-02f, 1.18424088e-01f,
  -3.91021878e-01f, 4.02323037e-01f, 3.80890101e-01f, 1.46364957e-01f, 2.70994425e-01f, 1.33066654e-01f, 1.22106537e-01f, -7.96323121e-02f, -1.38416633e-01f, 2.31417045e-01f,
  2.28619784e-01f, 2.86815409e-02f, 7.22431438e-03f, 4.06910060e-03f, -1.96363226e-01f, 1.85942724e-01f, 2.42135212e-01f, -9.14894566e-02f, -4.01169360e-01f, -1.65960118e-01f,
  5.39870672e-02f, -1.92852259e-01f, -3.80858809e-01f, -1.63576543e-01f, 2.71111310e-01f, 2.82588694e-02f, 2.05884799e-01f, 1.66811183e-01f, 2.01963037e-01f, 5.07977009e-01f,
  4.23277229e-01f, 2.18397051e-01f, -1.07905515e-01f, -5.87629564e-02f, 1.76246613e-01f, -1.36501595e-01f, 1.14656590e-01f, 2.39730533e-02f, -1.34374127e-02f, 3.00140399e-02f,
  1.22665413e-01f, -3.59708741e-02f, 8.88163745e-02f, 9.01511237e-02f, -3.79729606e-02f, 4.93181758e-02f, 8.69057104e-02f, 5.03347591e-02f, 6.18480006e-03f, 1.28540888e-01f,
  2.75045663e-01f, 2.32800707e-01f, 1.62935525e-01f, 3.92312482e-02f, 4.19387482e-02f, 1.76667962e-02f, 1.09051295e-01f, 3.41666080e-02f, -1.85407158e-02f, 1.04695544e-01f,
  4.99722101e-02f, 1.30123366e-02f, -1.33410329e-02f, -1.05052844e-01f, -6.38428554e-02f, -1.17763095e-01f, 1.48731703e-02f, -6.90155551e-02f, -1.39380265e-02f, -8.97579715e-02f,
  -5.85552193e-02f, 5.08923875e-03f, 7.05011841e-03f, -9.55610573e-02f, -6.60554087e-03f, 2.56726556e-02f, -2.82600373e-02f, -3.70225795e-02f, -2.39859316e-02f, -1.00336649e-01f,
  -8.18156730e-03f, -4.50400002e-02f, -6.02939427e-02f, -2.71131527e-02f, 1.15704192e-02f, -3.25416923e-02f, -5.82582457e-03f, -1.22614332e-01f, -4.77964766e-02f, -2.25912575e-02f,
  -1.22048035e-01f, -5.96520081e-02f, 1.85683191e-01f, 4.96752039e-02f, 9.81589928e-02f, 8.49337578e-02f, 1.26103088e-01f, 4.37421650e-02f, 5.43727241e-02f, 2.21060589e-02f,
  7.57325515e-02f, -1.39125828e-02f, 3.56605798e-02f, 4.84859981e-02f, 3.36892195e-02f, -1.99899133e-02f, -2.29342841e-02f, 4.46934812e-02f, 8.94882679e-02f, 7.54684955e-02f,
  1.08029671e-01f, -1.45608202e-01f, -1.64705545e-01f, 6.82173520e-02f, 1.65303238e-02f, -4.29795682e-02f, 1.27736675e-02f, -4.03304473e-02f, -1.41426504e-01f, -1.17640495e-01f,
  -2.03685582e-01f, -1.87070161e-01f, -2.15954017e-02f, -1.10563166e-01f, -2.85957512e-02f, -1.70233846e-01f, -3.14148515e-01f, 3.12683545e-02f, 1.03425227e-01f, -1.56441331e-01f,
  -4.40413654e-02f, -1.43816005e-02f, 1.15759447e-01f, 4.24407087e-02f, 3.70603055e-02f, -1.97673932e-01f, -8.66950005e-02f, 7.48822019e-02f, 1.12183936e-01f, -1.58969805e-01f,
  -2.02843830e-01f, -5.18838838e-02f, 1.09102145e-01f, 1.18629850e-01f, 3.41796502e-02f, 4.93434519e-02f, 9.77620482e-02f, -2.92276610e-02f, 5.23374304e-02f, -1.78261548e-01f,
  3.41699421e-02f, -5.25872298e-02f, -6.50910987e-03f, -7.15952516e-02f, -6.13958426e-02f, -3.27089732e-03f, -1.06492929e-01f, -4.32887897e-02f, -8.38899165e-02f, -8.38800445e-02f,
  -3.71714868e-02f, -1.64636314e-01f, -8.50537047e-02f, -7.93044493e-02f, -1.49269372e-01f, -5.29756024e-02f, -2.66359616e-02f, -6.45518452e-02f, 6.35526842e-03f, -1.50530800e-01f,
  -2.61458576e-01f, -2.28776842e-01f, -1.02120653e-01f, 5.88914286e-03f, -7.71227255e-02f, -3.29634473e-02f, 5.13529815e-02f, 3.06400135e-02f, -8.14559404e-03f, 2.79251523e-02f,
  5.51220253e-02f, 8.45842212e-02f, -5.74681684e-02f, -1.16299197e-01f, -1.16974197e-01f, -4.51608263e-02f, -2.04259120e-02f, -6.44704401e-02f, -5.80841191e-02f, -4.51622391e-03f,
  -2.03641858e-02f, -9.03440416e-02f, 9.45516489e-03f, 5.98417548e-03f, 3.46841803e-03f, -7.71227404e-02f, 7.82738850e-02f, -3.81180309e-02f, -2.30889004e-02f, -2.91296896e-02f,
  -4.12019566e-02f, -2.81508975e-02f, 2.22818237e-02f, 8.73659272e-03f, -7.84026459e-02f, 3.83693092e-02f, -2.51400433e-02f, -3.34868836e-03f, 1.42782321e-03f, -6.93454500e-03f,
  2.81271964e-01f, 1.31762013e-01f, -4.13557328e-02f, 5.48910175e-04f, -9.65247899e-02f, -2.21830048e-02f, -8.80178486e-05f, -1.32405767e-02f, 1.01571567e-01f, -5.95357642e-03f,
  -5.66772968e-02f, -2.85377055e-02f, -6.89650537e-04f, 3.76781859e-02f, -5.79829677e-04f, 2.03286856e-02f, -6.06836900e-02f, -6.82032928e-02f, 3.17620346e-03f, 1.10981213e-02f,
  -2.78433505e-02f, -5.04849702e-02f, -6.80161174e-03f, 2.06684902e-01f, 6.87742904e-02f, 3.50376517e-02f, 6.07342124e-02f, 1.64778352e-01f, 1.15052216e-01f, 4.44482788e-02f,
  1.80569649e-01f, 3.13978270e-02f, 2.42737338e-01f, 2.06934646e-01f, 3.51042390e-01f, 1.27835527e-01f, -3.16728167e-02f, -2.86284685e-01f, 1.76324714e-02f, 2.37708569e-01f,
  -3.20279747e-02f, -4.47384864e-02f, -8.60584304e-02f, -2.56493807e-01f, -2.77429551e-01f, 1.57082945e-01f, 2.74829447e-01f, -2.98287198e-02f, -1.62374124e-01f, -2.27010861e-01f,
  -2.53476724e-02f, 1.62768662e-02f, -1.98719114e-01f, -1.55902058e-01f, -3.16422246e-03f, 1.48472011e-01f, 2.09953219e-01f, 1.17095642e-01f, 1.01086661e-01f, 2.86409169e-01f,
  1.91964582e-01f, -1.59806579e-01f, -1.01209767e-01f, -7.73771033e-02f, -6.94126403e-03f, -1.26475140e-01f, -1.92365721e-02f, -1.53927341e-01f, -5.90937845e-02f, -1.00773491e-01f,
  3.65407169e-02f, -7.34686926e-02f, 2.97937766e-02f, -6.38285279e-02f, -1.21625938e-01f, 7.30365841e-03f, -8.99793431e-02f, -2.41610378e-01f, -1.25017837e-01f, -1.63598806e-01f,
  -8.23456943e-02f, 1.26091525e-01f, 7.44905621e-02f, -5.71474545e-02f, -1.51923120e-01f, 9.24989302e-03f, -1.55895680e-01f, -1.13570929e-01f, -1.51729882e-01f, 7.79349804e-02f,
  -9.54419523e-02f, 1.06343180e-01f, -1.90951535e-03f, 4.51959111e-03f, 5.00100963e-02f, 5.99220656e-02f, 8.19508806e-02f, 2.33171172e-02f, -1.33156274e-02f, 4.79469523e-02f,
  -2.92176194e-02f, 7.36225545e-02f, -6.30895719e-02f, 1.17878895e-02f, 1.48187369e-01f, 1.04929328e-01f, 2.44944170e-02f, -1.40011106e-02f, -1.28237819e-02f, 2.81287245e-02f,
  -2.47497316e-02f, 4.55746353e-02f, 7.80949295e-02f, -9.96987373e-02f, -2.55474485e-02f, -2.30265800e-02f, 9.63902399e-02f, 3.07714529e-02f, 1.46648623e-02f, 8.95149261e-02f,
  1.24982879e-01f, -1.34189084e-01f, 1.11415260e-01f, -1.80554211e-01f, 5.66096716e-02f, -6.94798259e-03f, 7.73389041e-02f, -3.28178406e-02f, 1.14751402e-02f, -1.02673601e-02f,
  -9.49162468e-02f, -5.97784780e-02f, -2.16441341e-02f, -5.00792190e-02f, 7.98528865e-02f, 2.03737076e-02f, 7.18187988e-02f, 3.02727763e-02f, -4.02989611e-02f, -1.50820734e-02f,
  -1.98891424e-02f, 7.52786323e-02f, 1.76259577e-01f, 1.74478702e-02f, 7.56494328e-02f, 1.68566301e-01f, 8.26159418e-02f, 7.99942985e-02f, 9.17968377e-02f, 3.16632807e-01f,
  -1.53619230e-01f, 2.43063658e-01f, 2.12711334e-01f, 9.48639140e-02f, 6.54074922e-03f, 6.91645667e-02f, 2.54509628e-01f, 9.07448307e-02f, 9.12304148e-02f, 2.30698198e-01f,
  -8.55413377e-02f, -2.20979780e-01f, -6.29355311e-02f, -1.78716481e-01f, -9.43891425e-03f, 3.59330624e-01f, 2.91328132e-01f, -9.87899750e-02f, -2.29469538e-01f, -1.78545639e-01f,
  -7.42295980e-02f, -7.94022977e-02f, -3.08518074e-02f, 1.78472977e-02f, 2.64193386e-01f, -5.78600504e-02f, 2.82048643e-01f, 1.41137496e-01f, 5.48832119e-03f, 2.91228920e-01f,
  -4.38753553e-02f, 1.81658015e-01f, -1.11679435e-01f, -4.89848182e-02f, -1.71757338e-03f, 1.07971625e-02f, -6.19123615e-02f, -1.39882425e-02f, 3.25852307e-03f, 5.03802896e-02f,
  2.72258855e-02f, -1.01071084e-02f, -1.29347146e-02f, 1.25680640e-01f, 2.64871009e-02f, 1.42746776e-01f, 6.02682792e-02f, 9.79629830e-02f, 8.91777277e-02f, 1.59246191e-01f,
  -4.65709083e-02f, -6.20021969e-02f, -3.38612311e-02f, 7.41199311e-03f, 6.06699251e-02f, -1.04061642e-03f, 1.14878282e-01f, -1.43444305e-02f, -1.35216145e-02f, 2.47197151e-01f,
  -1.63878039e-01f, -7.52247572e-02f, 1.66349597e-02f, 3.18480916e-02f, 3.88300978e-03f, -1.93123017e-02f, 6.10347986e-02f, 1.65269971e-02f, 5.39761130e-03f, 2.16339752e-02f,
  5.26206801e-03f, 2.48455331e-02f, 6.97858585e-03f, 2.98010558e-02f, -4.69231866e-02f, 6.62084445e-02f, -1.07149675e-01f, 8.76805782e-02f, -7.28028789e-02f, 5.09552248e-02f,
  -4.49124575e-02f, -6.15987508e-03f, -3.80070880e-02f, -7.78372362e-02f, 1.10226998e-03f, -5.73179536e-02f, -1.67759061e-02f, 2.44696680e-02f, -3.02924272e-02f, -2.46783663e-02f,
  -2.13176668e-01f, -1.63518742e-01f, -3.65371667e-02f, -7.79298171e-02f, -7.32512027e-02f, 4.10724729e-02f, -7.84957707e-02f, -3.36040854e-02f, -2.00961158e-02f, -4.56763953e-02f,
  -1.86431799e-02f, -5.81685007e-02f, -2.75614904e-03f, 1.20432116e-01f, -9.16420817e-02f, -4.08482701e-02f, 6.74649328e-02f, -7.43422508e-02f, 2.40146741e-02f, 3.77300940e-03f,
  6.18147887e-02f, -7.52887726e-02f, -6.44694790e-02f, -6.71292022e-02f, -5.16282879e-02f, -2.45314568e-01f, -7.91492127e-03f, -8.72586519e-02f, -9.27599967e-02f, 8.81049782e-03f,
  5.35762012e-01f, -3.18815053e-01f, -1.15229569e-01f, 6.54931664e-02f, 2.44220365e-02f, -2.71906853e-02f, -2.67708022e-02f, -6.65135235e-02f, 9.35017541e-02f, -4.43302058e-02f,
  -8.73426273e-02f, -1.03524573e-01f, 3.76041420e-02f, 3.16983573e-02f, 1.68670833e-01f, -9.25497189e-02f, -9.15510952e-02f, 1.06611148e-01f, 2.38993675e-01f, 6.82143420e-02f,
  -9.37760323e-02f, 5.14449328e-02f, 1.86105475e-01f, 7.36422092e-02f, -2.70692140e-01f, -1.07227499e-02f, -1.14952788e-01f, -8.82776231e-02f, -9.82282609e-02f, -2.18680248e-01f,
  -2.72620559e-01f, -2.67079890e-01f, 1.92297250e-02f, -3.44480425e-02f, -1.49940878e-01f, -5.17415330e-02f, -2.73536593e-02f, -7.89420456e-02f, -6.31938130e-02f, -1.60100579e-01f,
  -2.05422521e-01f, -1.14744112e-01f, -3.08565963e-02f, -1.19888820e-01f, -1.66591004e-01f, -1.16989091e-01f, -1.90596461e-01f, -1.35148072e-03f, -1.35625154e-02f, -2.23435134e-01f,
  -8.79969373e-02f, -1.11586832e-01f, -5.75967655e-02f, -7.57354572e-02f, -1.08081028e-01f, -9.31398794e-02f, -1.80865169e-01f, -2.30040967e-01f, -1.18089460e-01f, -6.28783926e-02f,
  5.04971482e-02f, 1.37537926e-01f, 9.30247903e-02f, 8.12436193e-02f, 1.26110017e-01f, 9.05689523e-02f, 9.09345374e-02f, 6.60386384e-02f, 1.64319783e-01f, 5.21529168e-02f,
  1.60160050e-01f, 1.42674237e-01f, 4.69518788e-02f, 1.80536285e-01f, 1.02428995e-01f, 6.85597733e-02f, 1.15456641e-01f, 6.30346462e-02f, 8.32265243e-02f, 6.62721768e-02f,
  1.02080993e-01f, 1.02894247e-01f, 1.49704572e-02f, 6.21829815e-02f, 1.67302340e-01f, 9.85420495e-02f, 1.48909763e-01f, 7.98867941e-02f, 2.37727296e-02f, 9.27641466e-02f,
  7.15266615e-02f, 7.07129315e-02f, -4.24937122e-02f, -1.09141432e-01f, -1.37375817e-01f, -9.02746245e-02f, -1.28899515e-01f, -4.68658656e-02f, -1.37709647e-01f, -8.37035626e-02f,
  -6.23536035e-02f, -7.92672634e-02f, -1.69881225e-01f, -1.35484800e-01f, -3.96773182e-02f, -1.57346442e-01f, -1.06883451e-01f, -8.27561170e-02f, -5.45553677e-02f, -1.07709169e-01f,
  -1.33602023e-01f, 7.60717466e-02f, 5.08755520e-02f, -4.03088368e-02f, -5.99175058e-02f, 1.55793428e-01f, -8.04588720e-02f, -8.20909068e-02f, 1.75472479e-02f, 2.86996607e-02f,
  -5.58688998e-01f, 3.85562219e-02f, -1.13310874e-01f, -1.37955220e-02f, -1.33098319e-01f, -2.91232765e-01f, -2.40041509e-01f, -2.18752295e-01f, 8.29643197e-03f, -5.81276976e-02f,
  2.05270126e-02f, -2.14757975e-02f, 3.70158926e-02f, 1.01321511e-01f, -9.30935740e-02f, -9.29525644e-02f, 6.46648556e-02f, -1.19000666e-01f, -2.25618020e-01f, -1.68058157e-01f,
  1.21751495e-01f, -4.99127321e-02f, -1.66094959e-01f, -1.19165499e-02f, 2.08798230e-01f, 8.60900953e-02f, 1.82462454e-01f, 1.26503229e-01f, 1.47466278e-02f, 2.53263503e-01f,
  -2.37405285e-01f, -1.65550753e-01f, -1.06273897e-01f, -5.98909855e-02f, -3.54016665e-03f, -1.22953437e-01f, -1.30102232e-01f, -4.34492744e-04f, 1.23664895e-02f, -3.80677432e-02f,
  9.31165367e-03f, -2.03799177e-02f, -1.57383867e-02f, -3.71608883e-02f, -3.29056233e-02f, -7.76986629e-02f, -6.69744462e-02f, -8.75186324e-02f, -1.08143881e-01f, -7.08213598e-02f,
  3.88403460e-02f, -1.74402118e-01f, -1.70022547e-01f, -1.81775779e-01f, -6.41110018e-02f, -1.20480374e-01f, -2.10346028e-01f, -1.45169869e-01f, -1.11083753e-01f, -3.08629945e-02f,
  -1.24400683e-01f, 1.59502216e-02f, 2.01464500e-02f, 2.95374859e-02f, 3.22788395e-02f, 6.75620586e-02f, 6.53165281e-02f, 7.08580092e-02f, 1.32461581e-02f, 3.18901427e-02f,
  4.53333519e-02f, 5.16230799e-02f, 5.08529395e-02f, 1.26827851e-01f, 9.04847458e-02f, 4.29487266e-02f, 9.21510160e-02f, 1.03471011e-01f, 1.43883646e-01f, 1.33643255e-01f,
  9.48368311e-02f, 1.36579955e-02f, 1.02696508e-01f, 1.96025759e-01f, 1.76445588e-01f, 8.15841854e-02f, 6.58985972e-02f, 1.28987744e-01f, -1.44235194e-02f, 1.32853791e-01f,
  -1.11330345e-01f, -9.35016498e-02f, -1.68604255e-01f, -1.63262472e-01f, -4.74654734e-02f, -5.04298601e-03f, -6.21008985e-02f, 4.71733920e-02f, -3.51111442e-02f, -2.16379799e-02f,
  -1.88239112e-01f, -1.81573883e-01f, -1.08155236e-01f, -1.35910049e-01f, -2.39283651e-01f, -1.50727585e-01f, -1.01200789e-01f, -5.59226796e-02f, -8.86315927e-02f, -1.45937175e-01f,
  -4.46102172e-02f, -2.02650055e-01f, -3.87906820e-01f, -2.10420594e-01f, -2.64406323e-01f, -2.04030797e-01f, -2.52020568e-01f, -1.96240917e-01f, -2.64846921e-01f, -3.30318987e-01f,
  -5.00132143e-01f, 4.03436869e-01f, 3.13497633e-02f, -1.35659412e-01f, -2.44234636e-01f, -2.06189305e-01f, -4.01101448e-02f, -1.34224826e-02f, -3.32287326e-02f, 1.16508640e-01f,
  -7.72191510e-02f, -8.32111749e-04f, 1.27606019e-01f, 3.79495360e-02f, -4.20024507e-02f, 2.61753201e-01f, 3.33038241e-01f, -1.41651526e-01f, -3.45317096e-01f, -2.72225529e-01f,
  -4.06821929e-02f, -1.85659364e-01f, -2.51122504e-01f, -8.19074642e-03f, 1.33587524e-01f, 8.51931721e-02f, 9.65822935e-02f, 3.93614359e-03f, 1.76074877e-01f, 3.43699664e-01f,
  1.94823846e-01f, -4.28853519e-02f, -1.01724789e-01f, 1.64472740e-02f, -3.44096124e-02f, 3.17147151e-02f, -5.04382253e-02f, -8.51232186e-02f, -6.76143318e-02f, -4.24956298e-03f,
  -6.35516867e-02f, -2.37156693e-02f, -1.53324483e-02f, -3.43628600e-02f, -8.53652284e-02f, -2.00960130e-04f, -5.42934313e-02f, 4.58884463e-02f, 1.20978035e-01f, 4.76451404e-02f,
  7.72718936e-02f, -3.00031737e-03f, -1.46240056e-01f, -6.47354797e-02f, -4.34666611e-02f, -8.90005529e-02f, -5.24885803e-02f, 4.34624031e-02f, 2.08338127e-02f, 2.64842585e-02f,
  -7.43010342e-02f, -1.13208545e-02f, -4.78907265e-02f, -6.23987522e-03f, -5.54439053e-02f, 3.30651887e-02f, 7.89185092e-02f, -1.80274788e-02f, -6.45193905e-02f, 1.54872099e-02f,
  2.11720932e-02f, 4.87849824e-02f, 4.10136767e-03f, -3.01697347e-02f, 7.32318088e-02f, 7.10241124e-02f, 6.75063282e-02f, 4.91353199e-02f, -3.78166474e-02f, 3.46160447e-03f,
  -2.97166370e-02f, -2.60553882e-02f, 4.39059213e-02f, 3.31995301e-02f, 1.05407551e-01f, 6.18534628e-03f, 1.11375012e-01f, -1.09413150e-03f, 3.57632823e-02f, 1.55955944e-02f,
  1.51923532e-02f, -2.57113814e-01f, 1.27532795e-01f, 1.24231741e-01f, -1.07991882e-02f, 5.20173497e-02f, -8.75242706e-03f, -8.27780925e-03f, 9.03728902e-02f, -6.56255782e-02f,
  1.62114613e-02f, -1.97332092e-02f, 8.82248729e-02f, 1.37699600e-02f, -1.59246132e-01f, -2.47633904e-02f, 5.60527444e-02f, 3.24476995e-02f, 5.05819619e-02f, 6.03982136e-02f,
  3.76123041e-02f, -1.02817677e-01f, -1.83901682e-01f, 2.06270791e-03f, 7.42537826e-02f, -9.48310867e-02f, -1.45519361e-01f, 1.37918890e-02f, -1.96341500e-01f, -7.45118409e-02f,
  5.47796309e-01f, 2.26682443e-02f, -3.09311543e-02f, 7.89426044e-02f, -3.37102383e-01f, -4.22367156e-01f, -4.67154533e-01f, -1.75138265e-01f, -9.59885046e-02f, -8.72365907e-02f,
  1.07872784e-01f, 2.81074852e-01f, 1.70680106e-01f, 2.49979906e-02f, -6.01174347e-02f, -2.48171046e-01f, -4.10234272e-01f, -3.31997871e-02f, 4.31461334e-02f, -1.93930119e-01f,
  -2.35663235e-01f, 4.69738692e-02f, 1.32250950e-01f, -5.24030114e-03f, -7.87184164e-02f, -5.85161857e-02f, -1.70440555e-01f, -4.71408255e-02f, -1.11040466e-01f, -5.00680730e-02f,
  2.86872834e-01f, 1.22625947e-01f, -1.78461924e-01f, -1.47338077e-01f, -1.02649622e-01f, -1.19983211e-01f, -2.14906558e-01f, -5.55971526e-02f, -1.39269784e-01f, -1.88723013e-01f,
  -1.08089834e-01f, -7.08744153e-02f, 1.96488407e-02f, -1.62830040e-01f, -1.05342358e-01f, -9.41838548e-02f, -1.37840882e-01f, -3.14717391e-03f, -1.05230719e-01f, -3.94247919e-02f,
  -9.31177884e-02f, -8.68749395e-02f, -8.76202062e-02f, -1.80413231e-01f, -8.74907523e-02f, -6.49448335e-02f, -1.67375803e-01f, -1.25162199e-01f, -1.29714891e-01f, -1.22203633e-01f,
  -7.52625614e-02f, 9.48563069e-02f, 6.08534068e-02f, 9.33808759e-02f, 1.60690695e-01f, 8.00307617e-02f, 1.45996749e-01f, 9.41156149e-02f, 1.14951104e-01f, 1.54788077e-01f,
  1.13192722e-01f, 1.11333154e-01f, 1.33853942e-01f, 1.84849650e-01f, 2.14921340e-01f, 1.21665321e-01f, 1.27640516e-01f, 1.37895435e-01f, 2.00127319e-01f, 9.53035578e-02f,
  2.20096037e-01f, 1.51639968e-01f, 1.41561493e-01f, 1.24108739e-01f, 1.45623326e-01f, 1.29703268e-01f, 2.16343284e-01f, 1.24158181e-01f, 1.82658777e-01f, 1.43253386e-01f,
  1.46484390e-01f, -2.94942260e-01f, 2.42455434e-02f, -3.39711681e-02f, -1.69082806e-01f, -1.49887562e-01f, -4.42111865e-02f, -8.47161710e-02f, -1.11783534e-01f, -7.80280679e-02f,
  -1.59522310e-01f, 2.30332408e-02f, -1.15410425e-01f, -1.23819537e-01f, -1.28539622e-01f, -1.90665513e-01f, -1.25319943e-01f, -7.20661879e-02f, -1.38549492e-01f, -8.74633342e-02f,
  -1.72140121e-01f, -1.61238328e-01f, 1.74459126e-02f, -8.07826594e-02f, -1.60993725e-01f, 2.37332433e-02f, -4.28331196e-02f, -1.75342605e-01f, -4.99818586e-02f, -2.17931867e-01f,
  -7.06346691e-01f, -3.73923093e-01f, -1.68117315e-01f, -3.12261164e-01f, -8.48489404e-02f, 3.18057358e-01f, 1.41014248e-01f, 1.78834647e-01f, -4.56094146e-02f, -1.72353998e-01f,
  -3.76829989e-02f, 3.55871655e-02f, -1.72659054e-01f, -8.93980148e-04f, 9.86916423e-02f, -4.76668216e-02f, -1.00562707e-01f, -1.63473248e-01f, 2.31088459e-01f, 2.16725454e-01f,
  8.10904652e-02f, -1.63791180e-01f, -2.14169055e-01f, -6.26354814e-02f, -1.18828073e-01f, 1.53115438e-02f, -1.12933829e-01f, -1.93576381e-01f, 2.69944742e-02f, -3.55683148e-01f,
  -2.47377783e-01f, -2.22505420e-01f, 1.13521852e-01f, -1.16997436e-01f, -7.59757981e-02f, 2.66542956e-02f, 2.95203924e-02f, -1.70828809e-03f, -8.95765498e-02f, -2.61606090e-02f,
  1.55060170e-02f, -8.53883624e-02f, -4.47878689e-02f, -5.10601401e-02f, 6.01221137e-02f, 1.08684786e-01f, -6.49530962e-02f, 2.26176698e-02f, 4.30453569e-02f, -6.82210252e-02f,
  -1.54920056e-01f, -4.29832041e-02f, -5.61068952e-02f, 1.47340581e-01f, 9.41896252e-03f, -4.94299009e-02f, -7.87066296e-04f, 4.46011238e-02f, 7.94954672e-02f, -1.14960864e-01f,
  7.87383616e-02f, -2.56814603e-02f, 6.25018477e-02f, -1.02854781e-01f, -3.05501577e-02f, -6.77249283e-02f, -1.31916642e-01f, -5.74516878e-02f, 2.47816704e-02f, -1.78962499e-02f,
  -7.91465417e-02f, -7.40390792e-02f, -2.05025226e-02f, -4.68655601e-02f, 5.65929823e-02f, -7.93513507e-02f, -3.42291268e-03f, -2.70477571e-02f, -6.92212656e-02f, -1.70502905e-02f,
  -2.40266379e-02f, 1.35469669e-03f, -2.75965687e-02f, 4.26379256e-02f, -4.57563773e-02f, -1.43081406e-02f, 6.95862249e-03f, -1.63402949e-02f, 2.60923579e-02f, -1.17326841e-01f,
  -6.95018172e-02f, 1.47164330e-01f, -2.08417118e-01f, 3.91044095e-02f, -2.53357273e-02f, 2.86538657e-02f, -1.01867169e-01f, -2.27030274e-02f, -1.24552976e-02f, -1.69565156e-02f,
  -1.62710564e-03f, -2.67599318e-02f, -9.54143405e-02f, -2.15843730e-02f, 2.89765019e-02f, 1.38992220e-01f, -7.54216164e-02f, -1.17997773e-01f, 8.21963698e-02f, 6.52096570e-02f,
  -2.04084218e-02f, 5.60970418e-02f, -3.95786315e-02f, -1.01114707e-02f, 1.18193679e-01f, 8.30451399e-02f, -8.08941945e-03f, 6.38104752e-02f, 1.65439367e-01f, -5.69253005e-02f,
  2.25465894e-01f, 5.97253382e-01f, -8.11205581e-02f, -2.19991833e-01f, -1.01494074e-01f, 3.05631638e-01f, 4.54354137e-01f, 3.82841766e-01f, -1.02665490e-02f, 9.81603190e-02f,
  1.02668628e-01f, -2.52289195e-02f, -1.24103660e-02f, 9.19433460e-02f, 4.14701223e-01f, 3.47491056e-01f, 6.58970475e-02f, 1.14435349e-02f, 7.28748227e-03f, 1.73853517e-01f,
  6.48987815e-02f, -7.44621605e-02f, -4.83514890e-02f, 1.11300595e-01f, 2.25708187e-02f, -1.46238998e-01f, -1.26793280e-01f, -6.00913242e-02f, 2.45865673e-01f, -1.87992696e-02f,
  -6.86065182e-02f, 3.03891152e-01f, -6.48885891e-02f, -7.06790239e-02f, -9.68026370e-02f, 1.70550451e-01f, 3.10401544e-02f, -1.65886537e-04f, 5.22287153e-02f, 5.23883011e-03f,
  -4.93910862e-03f, 1.45507902e-01f, 6.03919476e-02f, 7.11648837e-02f, 2.93101799e-02f, 1.42466635e-01f, 1.31588012e-01f, 1.28542289e-01f, 1.37130350e-01f, 2.16717198e-01f,
  1.58564001e-01f, -9.13039781e-03f, 3.45922858e-02f, 2.14312181e-01f, 2.23452121e-01f, 1.36553841e-02f, 1.37959525e-01f, 1.61738023e-01f, 2.41956756e-01f, 5.22115827e-03f,
  -1.80025369e-01f, -8.19487497e-02f, -9.12409648e-02f, -6.52023479e-02f, -1.17362536e-01f, -1.18915729e-01f, -1.06790870e-01f, -1.28001824e-01f, -1.33225873e-01f, -1.31496117e-01f,
  -5.31389825e-02f, -6.01213379e-03f, -1.26926392e-01f, -8.61577839e-02f, -1.53736204e-01f, -3.44413742e-02f, 3.23543809e-02f, -7.07993135e-02f, -8.20800141e-02f, -2.47608721e-02f,
  -5.82155734e-02f, -5.63637307e-03f, -1.28847823e-01f, -2.10311078e-02f, 5.03929285e-03f, -3.69158909e-02f, -4.31427732e-02f, 2.99227014e-02f, -2.37620343e-02f, -4.60790955e-02f,
  -2.48444110e-01f, 8.84009749e-02f, 8.51249620e-02f, 2.47078881e-01f, 3.57858688e-02f, 1.12393066e-01f, 9.84435454e-02f, 1.11636072e-01f, 1.17770314e-01f, 2.26062402e-01f,
  2.33978689e-01f, 1.22388698e-01f, 7.62627050e-02f, 9.28788334e-02f, -2.51995903e-02f, 8.52256119e-02f, 1.19094260e-01f, 1.13267370e-01f, 2.59635359e-01f, 1.92639738e-01f,
  6.70285895e-02f, 9.00400877e-02f, -7.86364302e-02f, -1.55061185e-02f, 2.00518876e-01f, 1.23641416e-02f, -2.66854521e-02f, 3.67142484e-02f, 1.18588395e-01f, 2.57289261e-02f,
  -1.36086762e-01f, 2.42385548e-02f, 4.01231080e-01f, -1.23144768e-01f, 2.97779031e-03f, 1.01438999e-01f, 3.69857922e-02f, 3.26721147e-02f, -3.46962065e-02f, -2.79085524e-02f,
  1.36865601e-01f, 1.21615902e-01f, 1.57942325e-01f, 1.58843711e-01f, 1.92115977e-01f, -1.07466355e-01f, -4.86850701e-02f, 1.96181566e-01f, 1.36279568e-01f, -5.96167929e-02f,
  -9.97760668e-02f, -5.43924496e-02f, 1.60197869e-01f, 4.91546877e-02f, -3.29359025e-01f, -3.02907884e-01f, -2.53328513e-02f, 2.82869115e-02f, 4.69411239e-02f, -3.55668694e-01f,
  1.30193278e-01f, 2.91909486e-01f, 7.33920792e-03f, 7.64941797e-02f, 1.26600906e-01f, 3.87223880e-03f, -1.06981881e-02f, -1.59509610e-02f, -1.16677871e-02f, -3.19556668e-02f,
  9.41679850e-02f, 1.04138955e-01f, 2.47756429e-02f, 7.27432221e-02f, 2.40940750e-02f, 8.11934769e-02f, 1.60405532e-01f, 2.27612853e-01f, 1.78962439e-01f, 1.36445612e-01f,
  8.36362317e-02f, 7.83750191e-02f, 1.23397827e-01f, 1.35778561e-01f, 1.61060557e-01f, 1.42973915e-01f, 1.60623208e-01f, 3.89115214e-02f, 1.28772482e-01f, -1.97763741e-01f,
  -1.20011508e-01f, 2.96528954e-02f, 2.37466823e-02f, 1.92661975e-02f, -1.13617785e-01f, -2.64835618e-02f, -2.77549047e-02f, -8.99663270e-02f, 1.61186047e-02f, -3.76143493e-02f,
  7.69175077e-03f, 4.68656905e-02f, 2.34638751e-02f, -7.41639137e-02f, -6.45225942e-02f, 4.32451963e-02f, 1.17680943e-02f, -7.01937079e-02f, 2.67229397e-02f, -3.60050946e-02f,
  -1.36710191e-02f, 1.07418550e-02f, -6.53212517e-02f, 1.22331372e-02f, 1.28093292e-03f, 3.32311429e-02f, -2.29126289e-02f, -1.61474515e-02f, 4.55974165e-04f, 6.19483329e-02f,
  -1.66200012e-01f, 3.83532435e-01f, -4.85005565e-02f, 4.39136699e-02f, -6.69179559e-02f, 7.84351602e-02f, 6.27753884e-02f, 2.81766132e-02f, 1.12075657e-01f, -2.47712620e-02f,
  1.54337257e-01f, 8.17337707e-02f, 7.86065310e-02f, 9.69238877e-02f, 4.24887985e-02f, -2.98973713e-02f, 4.60136421e-02f, 1.29341837e-02f, 1.44240484e-01f, 3.41861360e-02f,
  -2.93620657e-02f, -7.30697289e-02f, -1.01741821e-01f, 5.10700187e-03f, -2.88522709e-02f, -7.41520450e-02f, -5.04566990e-02f, -5.45051806e-02f, -7.15626031e-02f, -3.56309563e-01f,
  2.24376604e-01f, 3.68349850e-01f, -5.16527593e-02f, 3.38597633e-02f, 4.91752066e-02f, -7.72802234e-02f, -6.22925684e-02f, -2.42825523e-02f, 3.19466256e-02f, 1.02254391e-01f,
  3.37640703e-01f, 1.64147019e-01f, -3.39609049e-02f, -1.17318496e-01f, -2.93964177e-01f, -3.50309759e-01f, -3.85314256e-01f, -3.62283170e-01f, -4.62219924e-01f, -2.05721706e-01f,
  2.27190871e-02f, -1.68002710e-01f, -2.20764965e-01f, -1.93371058e-01f, 7.36264363e-02f, -5.75258918e-02f, 4.92812432e-02f, 4.81825918e-02f, 1.03145912e-01f, 5.80018722e-02f,
  -2.15621412e-01f, 1.28758416e-01f, -1.32946879e-01f, -5.11894710e-02f, -3.42848562e-02f, -4.43503484e-02f, 1.20963212e-02f, -9.97949466e-02f, -2.78766342e-02f, -1.49579912e-01f,
  8.43021274e-03f, -6.73218668e-02f, 2.52954173e-03f, -7.08004162e-02f, -1.42424434e-01f, -1.51348487e-01f, -7.85924867e-02f, -1.15949512e-01f, -1.10473312e-01f, -9.93891433e-02f,
  1.12629890e-01f, 6.70344606e-02f, -2.39865370e-02f, -1.10889919e-01f, -6.69871643e-02f, 1.02804326e-01f, -2.04492267e-02f, -2.61204839e-02f, -1.42247602e-02f, 2.02810648e-03f,
  6.14308007e-02f, 1.63823366e-02f, 6.02503903e-02f, 9.79074650e-03f, -6.26162738e-02f, -2.96102185e-03f, -8.78896657e-03f, -1.27210058e-02f, -2.06000935e-02f, -3.46357375e-02f,
  -8.82657021e-02f, 2.88808532e-02f, 2.63959449e-02f, -4.62119319e-02f, 3.27447988e-03f, 7.91147165e-03f, -1.42605612e-02f, 4.00468260e-02f, -4.94508855e-02f, -6.75929561e-02f,
  -2.52876338e-02f, -1.97037496e-02f, 5.91707714e-02f, -2.34948099e-02f, 5.83446622e-02f, -7.57314190e-02f, -8.57491344e-02f, -2.41414532e-02f, 1.96415819e-02f, -1.96992010e-02f,
  -8.68764445e-02f, -5.74952886e-02f, -5.61386421e-02f, -1.44766599e-01f, -1.50852650e-01f, -8.19314644e-02f, 1.51975099e-02f, -1.29474774e-01f, -1.90410316e-02f, -1.28601938e-01f,
  8.67537782e-03f, -5.39876074e-02f, -2.20777616e-02f, -1.01932295e-01f, -1.03843898e-01f, -9.78424326e-02f, -1.67277962e-01f, -1.17705688e-01f, -7.81411007e-02f, 9.90591291e-03f,
  -7.29904845e-02f, -1.36436075e-01f, -6.79773912e-02f, -1.03305526e-01f, -6.79594353e-02f, -1.07973158e-01f, -1.65665627e-01f, -8.06709975e-02f, -2.13276133e-01f, -1.70039549e-01f,
  9.73807126e-02f, 5.91650367e-01f, 3.34449932e-02f, -1.35403633e-01f, -6.90381527e-02f, -5.42051345e-02f, 3.23481113e-01f, 1.31573573e-01f, -6.42239973e-02f, 3.15382659e-01f,
  2.33264416e-01f, -1.07990399e-01f, -1.72148235e-02f, -1.44688964e-01f, -2.81846356e-02f, 2.86387533e-01f, 1.56120649e-02f, -3.30822825e-01f, -4.40511316e-01f, -1.85424596e-01f,
  -2.20765918e-02f, 4.41501848e-02f, -6.96152449e-02f, -3.97894382e-02f, 8.47998485e-02f, -2.92995907e-02f, 1.75151289e-01f, 2.05513602e-03f, 9.19405520e-02f, 1.27220392e-01f,
  3.17470163e-01f, 2.72185624e-01f, -7.77864754e-02f, 5.93460351e-03f, 6.87093735e-02f, 7.58164898e-02f, 1.25346079e-01f, 1.18096054e-01f, 8.96019954e-03f, 2.06767142e-01f,
  1.11428080e-02f, 2.16811392e-02f, 1.27346992e-01f, 5.36258854e-02f, 8.92023444e-02f, 7.39711970e-02f, 3.33228447e-02f, 3.49851809e-02f, 4.35886458e-02f, 1.06899977e-01f,
  1.85234286e-02f, 7.07948431e-02f, 1.19663559e-01f, 1.02705911e-01f, -3.11015714e-02f, -1.30156815e-01f, 2.16187164e-01f, 1.33000547e-02f, 6.01861812e-02f, 1.78292111e-01f,
  -2.86081899e-02f, -7.00302562e-03f, -3.86964269e-02f, -2.34408583e-02f, 1.88366100e-02f, 2.77426410e-02f, -2.05843933e-02f, 1.60858873e-02f, -1.96567103e-02f, -1.54647836e-02f,
  3.66975041e-03f, 5.55344112e-02f, 5.56532703e-02f, -1.75733920e-02f, -4.40376475e-02f, 6.15528896e-02f, -1.22545972e-01f, 3.78880426e-02f, 1.51730599e-02f, 3.13333655e-03f,
  2.47040540e-02f, -1.54604346e-01f, -1.36042815e-02f, -3.70058492e-02f, -5.59195876e-02f, -3.58190648e-02f, -7.53915459e-02f, -6.87007308e-02f, 4.90765497e-02f, -1.78585835e-02f,
  3.76582474e-01f, -1.11690514e-01f, 9.43001285e-02f, 6.03034608e-02f, 3.71589586e-02f, -3.71068120e-02f, 1.46740600e-01f, -1.70100611e-02f, -2.89020147e-02f, 7.19764978e-02f,
  2.35159174e-02f, 1.80360042e-02f, 1.27288029e-01f, 6.20513000e-02f, -9.01310444e-02f, 5.24414480e-02f, 1.15321286e-01f, -9.07456949e-02f, -4.52742167e-02f, 7.33644441e-02f,
  1.45409763e-01f, 6.25831336e-02f, 7.39781335e-02f, 1.49615958e-01f, -3.39921638e-02f, -7.82967210e-02f, 2.03290179e-01f, 9.69890505e-02f, 7.97284022e-02f, 3.12568635e-01f,
  -7.88797200e-01f, -1.82760924e-01f, 8.89067575e-02f, -1.16788901e-01f, 1.40984997e-01f, 1.37868002e-02f, -1.44413292e-01f, -2.09644064e-01f, 5.09617524e-03f, -6.21431731e-02f,
  1.46406263e-01f, 8.94517526e-02f, -1.77205913e-02f, 7.15061203e-02f, -2.02228516e-01f, -1.68406636e-01f, -2.48219464e-02f, -4.71915454e-02f, 7.71173909e-02f, 1.21004649e-01f,
  2.08652347e-01f, 1.34703279e-01f, -1.50834173e-01f, -9.17679891e-02f, 9.60386246e-02f, 5.58397621e-02f, 9.01648868e-03f, 1.87876932e-02f, 3.05954181e-02f, 3.63989361e-02f,
  2.15495691e-01f, -1.67669162e-01f, 1.03800893e-01f, -6.01477697e-02f, 5.02939783e-02f, -1.58371016e-01f, 3.62160951e-02f, 4.32818457e-02f, 2.40711588e-02f, 4.63796780e-02f,
  2.96836365e-02f, -3.11363232e-03f, 7.36708343e-02f, -8.49746354e-03f, -2.47246511e-02f, -1.28273055e-01f, -7.70218447e-02f, -1.90489948e-01f, 4.78133652e-03f, -1.58517864e-02f,
  1.24011733e-01f, 4.42262329e-02f, -1.19531333e-01f, 4.56365086e-02f, -4.56802063e-02f, 4.54277098e-02f, 7.06525072e-02f, -8.06809366e-02f, -1.05445683e-01f, -1.33359894e-01f,
  -5.27740046e-02f, -6.42951066e-03f, -7.74391694e-04f, -4.15685624e-02f, -7.37510398e-02f, -6.47083204e-03f, -6.97137639e-02f, -5.12545258e-02f, 1.99783444e-02f, -3.31403725e-02f,
  -9.38067660e-02f, -4.09205779e-02f, -2.43759621e-02f, -1.75863922e-01f, -1.18985856e-02f, -8.32812786e-02f, -2.62808185e-02f, -3.11257653e-02f, -7.38310888e-02f, -1.37026057e-01f,
  7.18330666e-02f, 7.76738918e-04f, 8.05423632e-02f, -5.71221150e-02f, 4.57558893e-02f, -8.53870660e-02f, 7.04168109e-03f, -6.00251444e-02f, -1.13308601e-01f, 1.26678338e-02f,
  1.78956892e-02f, 2.65267156e-02f, 8.86621606e-03f, -1.02092884e-01f, -3.85040194e-02f, 3.23300548e-02f, 1.71650425e-02f, -5.11429757e-02f, 6.40019625e-02f, -2.41294093e-02f,
  3.37278880e-02f, -7.29742497e-02f, 6.18925951e-02f, 4.50282134e-02f, 1.19265214e-01f, 1.90711133e-02f, -3.81535143e-02f, -5.66588938e-02f, 7.01314956e-02f, 4.69067805e-02f,
  -4.32619452e-02f, -1.53811909e-02f, -1.90575644e-01f, -2.76987022e-03f, 1.01075873e-01f, -1.00374378e-01f, 5.48038110e-02f, -5.45636266e-02f, -3.94184403e-02f, -2.79373437e-01f,
  3.67323816e-01f, 1.16796315e-01f, 1.89263284e-01f, 1.30216315e-01f, 7.38704801e-02f, 1.24395408e-01f, 3.26036960e-01f, 1.40044376e-01f, -2.81857746e-03f, 1.15754984e-01f,
  -3.19457859e-01f, -3.92375648e-01f, -2.46058971e-01f, -1.57221928e-01f, 1.66396230e-01f, 2.80480325e-01f, 2.73881167e-01f, 1.23920843e-01f, 7.17846081e-02f, -1.95655569e-01f,
  -1.06272042e-01f, 6.75369501e-02f, -3.18445265e-02f, 6.94013201e-03f, -1.00639239e-01f, -2.07273513e-01f, -1.72591470e-02f, 3.39425616e-02f, 1.48447938e-02f, 1.83870848e-02f,
  -9.66287628e-02f, 9.95264426e-02f, -2.29814425e-02f, -1.89125627e-01f, -2.28457645e-01f, -1.41232144e-02f, -1.14094108e-01f, -6.75405785e-02f, -9.62053910e-02f, 2.91795656e-02f,
  -1.94050729e-01f, -9.96571705e-02f, -5.91280796e-02f, -6.06330149e-02f, 4.83259745e-02f, -9.12915543e-02f, -6.05659671e-02f, 1.06324002e-01f, 3.90147492e-02f, -4.67341878e-02f,
  -1.94922253e-01f, -3.10746897e-02f, -1.42383082e-02f, 3.80688137e-03f, -6.48846924e-02f, -1.20763011e-01f, -1.20175272e-01f, -1.64396942e-01f, -6.46676645e-02f, 2.00640112e-02f,
  -1.78754389e-01f, -6.21717460e-02f, 5.66763803e-02f, 7.85055459e-02f, 3.01882941e-02f, 1.72043983e-02f, 1.04106985e-01f, -2.06202567e-02f, 6.45346791e-02f, 5.98863587e-02f,
  4.50920798e-02f, 7.42707327e-02f, 1.02441050e-01f, 1.02329992e-01f, 2.69865282e-02f, 4.90315259e-02f, 7.92144313e-02f, 1.70906372e-02f, 6.16130382e-02f, 5.02633713e-02f,
  5.53189218e-02f, -2.08769855e-03f, 4.95158136e-02f, 7.19584990e-03f, 9.92842242e-02f, 7.91425258e-02f, -9.28054564e-03f, -5.26544685e-03f, -8.81709307e-02f, 1.61695611e-02f,
  2.16302313e-02f, 6.04534755e-03f, 4.55756783e-02f, 3.15272175e-02f, -4.18003537e-02f, -8.43208060e-02f, -8.24368894e-02f, 5.82492612e-02f, -5.10373414e-02f, -7.58199170e-02f,
  -1.40681669e-01f, -1.82498358e-02f, -5.87545671e-02f, -9.34717134e-02f, -2.33573020e-02f, -5.57410643e-02f, 4.66270745e-02f, -5.21902964e-02f, 4.99849534e-03f, -6.22843131e-02f,
  -4.72747013e-02f, 1.02673054e-01f, 5.25136888e-02f, 3.24446633e-02f, -3.14035155e-02f, 2.86234990e-02f, 6.48793429e-02f, 5.34530394e-02f, 1.02147758e-01f, 2.60576010e-01f,
  4.53703284e-01f, 3.15015316e-01f, 4.93662685e-01f, -1.10587344e-01f, -1.96707249e-01f, -8.56465325e-02f, -1.60594545e-02f, -1.31529808e-01f, -2.12863490e-01f, 4.85230349e-02f,
  1.25445753e-01f, 1.03251021e-02f, 1.81551307e-01f, -1.53782815e-02f, 4.42104749e-02f, 9.59672108e-02f, -1.13420017e-01f, 1.75946459e-01f, -3.90366577e-02f, -3.01174968e-01f,
  -3.17559630e-01f, -1.57493457e-01f, -8.96181464e-02f, -1.73801094e-01f, -1.32757887e-01f, -2.38439478e-02f, -1.98291317e-02f, 3.68927531e-02f, -1.57987569e-02f, 1.34013504e-01f,
  4.59919989e-01f, 3.27785760e-01f, -3.84813920e-02f, -4.22821343e-02f, 9.65725109e-02f, 9.25077349e-02f, 5.62084727e-02f, 8.24583545e-02f, 1.60328858e-02f, 3.94749977e-02f,
  3.45456079e-02f, 4.19295771e-04f, 5.99786006e-02f, -1.20794415e-01f, 5.85322864e-02f, -7.21433684e-02f, -2.86905877e-02f, 1.08251739e-02f, -2.12091226e-02f, 5.46964370e-02f,
  -8.05984288e-02f, -3.45803834e-02f, 1.76943943e-01f, 5.42895570e-02f, 1.07026203e-02f, 4.42033187e-02f, 3.02345157e-02f, 1.28245234e-01f, 1.57460466e-01f, -3.09605356e-02f,
  -4.44944836e-02f, -5.03727701e-03f, -4.69380729e-02f, 1.54753178e-01f, -8.73310771e-03f, 3.07450145e-02f, -3.82122844e-02f, -2.47450899e-02f, -3.69241275e-02f, 2.70616431e-02f,
  -7.38827558e-03f, 1.09353531e-02f, 7.05627054e-02f, -3.83131136e-03f, -2.76304651e-02f, 1.06268652e-01f, -1.32020889e-02f, -4.57875729e-02f, 4.25374359e-02f, 5.14184684e-02f,
  8.36839899e-02f, 1.80500876e-02f, -1.59070436e-02f, 4.88188490e-02f, 8.31459910e-02f, 9.40846130e-02f, 3.72179300e-02f, -3.70988995e-02f, 2.35115755e-02f, 1.24388203e-01f,
  -1.90569192e-01f, -5.03733940e-02f, 1.39411658e-01f, -5.66641167e-02f, -3.18662561e-02f, -9.08098668e-02f, -3.30457687e-02f, -3.25991213e-02f, 9.81709510e-02f, -3.81549783e-02f,
  -5.33581637e-02f, -4.86128591e-02f, -2.83831041e-02f, -7.83476830e-02f, -1.33101732e-01f, -6.69342056e-02f, -9.47980434e-02f, -3.44055295e-02f, 5.04424889e-03f, -1.19684767e-02f,
  -2.24450544e-01f, -8.20056349e-02f, 1.20488949e-01f, -4.66749305e-03f, -6.68858364e-02f, -1.94122121e-02f, 1.11275151e-01f, 6.27148617e-03f, 8.59620199e-02f, -1.72701672e-01f,
  -5.65236621e-03f, 1.65275544e-01f, -7.27903470e-02f, -7.94915855e-02f, -1.04140319e-01f, 1.95212245e-01f, 3.95034879e-01f, 3.06546122e-01f, 3.25859748e-02f, 1.92817226e-01f,
  2.20112488e-01f, 3.47032458e-01f, 3.82127374e-01f, 3.18672061e-01f, 4.39484388e-01f, 2.04737306e-01f, 7.44591877e-02f, 1.38115004e-01f, 1.47554979e-01f, 2.12423429e-01f,
  9.69342291e-02f, -5.12588769e-02f, -1.08927161e-01f, -9.84445289e-02f, -1.56684518e-01f, 1.63360359e-03f, -9.72602740e-02f, -2.38442626e-02f, 1.09811276e-01f, -1.25376835e-01f,
  2.80416578e-01f, -7.87108988e-02f, 2.70212442e-01f, 2.86388844e-01f, 7.69642740e-02f, 1.83833957e-01f, 2.56694764e-01f, 9.07060578e-02f, 1.47733808e-01f, 1.71213090e-01f,
  2.07284629e-01f, 1.79976478e-01f, 2.19998106e-01f, 2.39908084e-01f, 2.66090304e-01f, 1.93522960e-01f, 1.82938233e-01f, 1.91944942e-01f, 2.16286436e-01f, 2.39344269e-01f,
  1.66119531e-01f, 1.85883231e-02f, 1.69261485e-01f, 2.52410710e-01f, 2.47053459e-01f, 2.38998801e-01f, 3.02800387e-01f, 1.95063040e-01f, 1.88028738e-01f, 2.81820893e-01f,
  -7.49419779e-02f, -2.09058270e-01f, -2.05341414e-01f, -2.75070339e-01f, -6.42510355e-02f, -2.03764737e-01f, -2.77027607e-01f, -2.04236642e-01f, -1.98959157e-01f, -2.14261606e-01f,
  -1.21719457e-01f, -2.55079389e-01f, -1.64018571e-01f, -2.40667120e-01f, -1.39952883e-01f, -3.03286612e-01f, -2.74438381e-01f, -1.21182144e-01f, -2.53722787e-01f, -2.59490728e-01f,
  -1.18765652e-01f, -2.60783046e-01f, -2.42666647e-01f, -1.20116293e-01f, -2.62996852e-01f, -2.64188945e-01f, -1.36537969e-01f, -2.39342928e-01f, -1.63089916e-01f, -1.25215039e-01f,
  3.46837908e-01f, 2.43348315e-01f, 2.75077313e-01f, 3.40235293e-01f, 1.26834542e-01f, 2.74702936e-01f, 2.33638808e-01f, 2.07865998e-01f, 2.48116747e-01f, 2.26743922e-01f,
  2.39106804e-01f, 3.27605397e-01f, 2.75586843e-01f, 2.67473310e-01f, 2.27636352e-01f, 2.34341636e-01f, 2.20091522e-01f, 1.76546484e-01f, 2.43389845e-01f, 2.03235582e-01f,
  2.07037643e-01f, 2.81215012e-01f, 4.43827271e-01f, 3.32685351e-01f, 2.38934189e-01f, 3.49692166e-01f, 3.56940001e-01f, 4.25791532e-01f, 3.65682483e-01f, 4.05822903e-01f,
  -1.03405617e-01f, -1.72383636e-01f, -4.53532249e-01f, 1.69079944e-01f, 2.15902284e-01f, 2.22620502e-01f, 2.14846119e-01f, 3.04749966e-01f, 1.55162945e-01f, -8.70355889e-02f,
  -1.36235803e-01f, -4.45305593e-02f, -1.48753047e-01f, -2.33364508e-01f, -1.21333607e-01f, -1.17158748e-01f, -3.04236054e-01f, -4.48220253e-01f, 1.47729991e-02f, 3.02723169e-01f,
  1.40942112e-01f, 7.40792155e-02f, -7.25657195e-02f, -7.70398080e-02f, 5.77075817e-02f, -8.73458460e-02f, -1.13136910e-01f, -1.30569741e-01f, -1.91929683e-01f, -3.65866005e-01f,
  -4.76074398e-01f, -2.05858529e-01f, -1.16271801e-01f, -2.51248386e-02f, -2.26385966e-01f, -1.68093801e-01f, -6.51704669e-02f, -2.36422926e-01f, -7.43252411e-02f, -8.35786462e-02f,
  -1.59534693e-01f, -2.83685904e-02f, -5.62914908e-02f, 1.55946449e-03f, 2.65340880e-02f, 1.92780029e-02f, -1.33451656e-01f, -1.57794550e-01f, -1.07455358e-01f, -8.75479132e-02f,
  -1.70095880e-02f, -2.23114640e-01f, -2.20584288e-01f, 1.71933342e-02f, -1.00069083e-01f, -9.64358822e-02f, -3.23442509e-03f, -5.17041497e-02f, -1.36067882e-01f, -4.03456651e-02f,
  -4.63194847e-02f, 4.56613377e-02f, 8.42771456e-02f, 1.26858518e-01f, 2.02840224e-01f, 7.08916560e-02f, 6.18646629e-02f, 1.45417064e-01f, 1.80024087e-01f, 1.36707187e-01f,
  1.20360374e-01f, 7.97623396e-02f, 1.26936451e-01f, 1.09999977e-01f, 2.93412898e-02f, -4.09899093e-02f, -3.87051180e-02f, 1.32263005e-01f, 2.91853361e-02f, 1.09349109e-01f,
  -2.76629739e-02f, 8.83012041e-02f, 1.24958518e-03f, 1.01133198e-01f, -1.61970016e-02f, -3.11862119e-02f, 8.04575384e-02f, 1.67571738e-01f, 7.88624138e-02f, 8.36097524e-02f,
  1.86899111e-01f, -2.19097033e-01f, -1.44013792e-01f, -1.44473270e-01f, -1.18526258e-01f, -1.72426403e-01f, -1.00371987e-01f, -6.50169849e-02f, -1.46934912e-01f, -8.56770296e-03f,
  2.87848115e-02f, -2.65953578e-02f, -1.26011312e-01f, -1.14241138e-01f, 1.78924259e-02f, -1.62354931e-02f, -3.87081318e-02f, -1.19175650e-01f, -5.25564179e-02f, -7.94685155e-04f,
  -6.23260811e-02f, -9.17932950e-03f, 2.76805926e-02f, 2.42155120e-02f, -3.85659151e-02f, -5.79850264e-02f, -8.32433626e-02f, 1.15381938e-03f, 1.13390600e-02f, 1.11810043e-01f,
  -3.60891640e-01f, -2.80423313e-01f, -1.16119608e-02f, -2.03404620e-01f, -7.91495368e-02f, -1.97208717e-01f, -2.02608302e-01f, -1.82572097e-01f, -5.01802713e-02f, -2.20937312e-01f,
  -3.99972908e-02f, 2.73514867e-01f, 2.45355040e-01f, 9.66298282e-02f, 1.06805116e-01f, -2.32479513e-01f, -3.41344476e-01f, -4.22347449e-02f, 3.82886380e-02f, -8.41802880e-02f,
  -5.70150167e-02f, -4.59142290e-02f, -3.74085978e-02f, -1.01633348e-01f, -2.45534241e-01f, -3.35148387e-02f, -2.13487536e-01f, -1.87802419e-01f, -1.38949722e-01f, -4.73385364e-01f,
  -1.46249339e-01f, -1.54428467e-01f, 8.19005594e-02f, 6.92465752e-02f, 6.13884628e-03f, -7.04826191e-02f, -7.88770616e-02f, -2.64076870e-02f, -4.51360131e-03f, -4.89915647e-02f,
  -9.47145075e-02f, 2.88796499e-02f, -1.20701447e-01f, -4.69196811e-02f, -4.28338870e-02f, -2.17326377e-02f, -1.05625233e-02f, -1.20568000e-01f, -1.46244943e-01f, -9.43782553e-02f,
  -1.36912942e-01f, -7.39513040e-02f, -7.69836903e-02f, -1.55896991e-01f, -2.53041964e-02f, -4.89433780e-02f, -1.33395821e-01f, -1.95078611e-01f, -1.69856831e-01f, -4.05275881e-01f,
  -1.88210562e-01f, 6.18544035e-03f, 7.88501725e-02f, 3.81351635e-02f, 1.84069704e-02f, 9.19354558e-02f, -2.78804209e-02f, 2.37215068e-02f, 2.31897067e-02f, 6.60553202e-02f,
  3.93359512e-02f, 4.96955030e-02f, 5.03920875e-02f, -1.29189432e-01f, 1.67251425e-03f, 4.55652270e-03f, 5.07543460e-02f, 1.67832207e-02f, 1.14814630e-02f, 8.87146890e-02f,
  3.69828269e-02f, -2.08875742e-02f, 6.13591410e-02f, 2.13305000e-02f, 4.01993692e-02f, -6.15488812e-02f, -2.58584749e-02f, 1.49371564e-01f, -1.51748280e-03f, 6.84408331e-03f,
  3.16054851e-01f, 3.16626221e-01f, -4.16866802e-02f, -8.31821710e-02f, -1.17562443e-01f, 2.23055854e-02f, -2.03441363e-02f, -4.23378572e-02f, 1.19943647e-02f, -9.33895782e-02f,
  -3.38321887e-02f, -6.04708306e-02f, 2.62602288e-02f, -2.56723445e-02f, -9.41948686e-03f, -8.60686302e-02f, -1.07747585e-01f, -7.93189034e-02f, 5.50518744e-02f, -1.56468034e-01f,
  -1.53972786e-02f, -1.26647934e-01f, 4.84293886e-02f, 3.57294828e-02f, -2.01776344e-02f, 7.70706385e-02f, 6.77713007e-02f, -5.05819395e-02f, -6.86847270e-02f, -1.52683958e-01f,
  2.18680143e-01f, 4.70262378e-01f, -1.85104266e-01f, 1.91244021e-01f, 9.24784392e-02f, -1.73294470e-01f, -3.29921693e-02f, -1.12447260e-05f, -3.63708176e-02f, 1.10612795e-01f,
  2.16214240e-01f, 7.25550530e-03f, -1.14528947e-01f, -2.16223478e-01f, -2.02701107e-01f, -1.52523428e-01f, -3.30466568e-01f, -3.32272977e-01f, -2.86167949e-01f, -4.31024209e-02f,
  -7.62215853e-02f, 7.45711289e-03f, 1.71708800e-02f, -8.88632610e-02f, -7.63581274e-03f, -2.75727391e-01f, -6.63173348e-02f, 2.39696242e-02f, -8.33271518e-02f, -1.76802099e-01f,
  -1.74504761e-02f, 3.12779278e-01f, -2.05656126e-01f, -3.45795266e-02f, 8.12879279e-02f, -4.37920261e-03f, -4.48626690e-02f, -3.68836075e-02f, 7.47311637e-02f, -6.76010847e-02f,
  5.62188551e-02f, 2.20524389e-02f, 3.14240623e-03f, -3.71251665e-02f, 4.95691895e-02f, 9.94209014e-03f, 9.13313497e-03f, -1.54664025e-01f, -4.60466407e-02f, 5.24271391e-02f,
  7.93061405e-02f, 1.30365372e-01f, -6.05121814e-02f, 4.95822653e-02f, -5.83897904e-02f, -1.64719343e-01f, -1.03789911e-01f, -1.03864633e-01f, -2.18700275e-01f, -1.42633483e-01f,
  9.06679481e-02f, 2.37378869e-02f, 5.46526425e-02f, 2.54429951e-02f, -1.49048828e-02f, 2.10623778e-02f, -4.03133221e-02f, 5.31937666e-02f, 3.30476998e-03f, -4.77267131e-02f,
  -5.28442003e-02f, 1.96654517e-02f, -1.26266037e-03f, -2.76648328e-02f, -1.12610362e-01f, 1.96984261e-02f, -1.63310152e-02f, -1.69207193e-02f, 6.22633807e-02f, 2.98480093e-02f,
  1.82975270e-02f, -4.44292203e-02f, 1.08216941e-01f, -1.54404491e-01f, -3.63650620e-02f, -6.16614930e-02f, 1.15050606e-01f, 1.79255512e-02f, 1.23123288e-01f, 4.02859263e-02f,
  -3.72450873e-02f, -1.90441608e-01f, -7.69533664e-02f, -1.43190697e-01f, -7.70073384e-02f, -4.38225418e-02f, -5.66818193e-02f, -6.36136010e-02f, 2.42287144e-02f, -6.91369027e-02f,
  1.49688618e-02f, -6.58623576e-02f, -2.05061380e-02f, -4.39476930e-02f, -1.70195237e-01f, 2.87043210e-02f, -2.92052347e-02f, -7.14654624e-02f, -6.96857795e-02f, 1.62372515e-02f,
  -9.86440033e-02f, -8.76467228e-02f, -1.22884624e-01f, -1.33098274e-01f, -7.05311298e-02f, -2.24608839e-01f, -1.03554420e-01f, -2.06790388e-01f, -1.89011708e-01f, -1.74662635e-01f,
  -4.82141525e-01f, 2.75003940e-01f, 3.16977829e-01f, 1.80130795e-01f, 7.27645829e-02f, -9.74745229e-02f, -5.56293204e-02f, -1.22182719e-01f, -8.58752877e-02f, 6.15389906e-02f,
  1.26653284e-01f, -4.04958762e-02f, -1.73927978e-01f, -2.70559698e-01f, -2.93299049e-01f, 3.12725827e-02f, -1.18195996e-01f, -3.74485672e-01f, -4.09045249e-01f, -2.38826379e-01f,
  -1.20369479e-01f, -2.30632257e-02f, -3.05887878e-01f, -5.17614260e-02f, 3.25047761e-01f, -4.07178439e-02f, 1.55096337e-01f, 1.67154104e-01f, -6.51038811e-02f, 6.71450421e-02f,
  2.08790779e-01f, 2.79797554e-01f, -1.48655653e-01f, -1.28608987e-01f, 8.00542086e-02f, 4.32127342e-02f, -1.59181152e-02f, 8.93961936e-02f, -3.31814438e-02f, -2.41343761e-04f,
  1.27991904e-02f, -1.01920133e-02f, 5.57315946e-02f, -4.02598754e-02f, 6.77779168e-02f, 6.40887767e-02f, -6.17234595e-02f, -7.96144307e-02f, -6.50318190e-02f, 7.80293811e-03f,
  1.72697932e-01f, -6.73453906e-04f, -1.65840853e-02f, 3.04284170e-02f, 5.78988343e-02f, -1.90789565e-01f, 1.40797362e-01f, 1.86765622e-02f, -1.69380635e-01f, -8.61165151e-02f,
  -1.05512336e-01f, 5.04689440e-02f, 6.78182691e-02f, -1.64703988e-02f, 5.48604354e-02f, 9.37432349e-02f, 9.41950232e-02f, -2.38943361e-02f, -2.23443806e-02f, 1.73595309e-01f,
  9.05019045e-02f, -1.82176586e-02f, -2.14965735e-02f, 7.90628791e-02f, 1.15667515e-01f, 3.41042541e-02f, 6.95413426e-02f, 1.48616314e-01f, 3.24098803e-02f, 3.89902107e-02f,
  3.00439671e-02f, 9.23801064e-02f, 1.52673498e-01f, 6.39337450e-02f, -2.82313470e-02f, 1.16346972e-02f, 4.57794406e-02f, 1.24038152e-01f, 1.91463586e-02f, 2.82584620e-03f,
  1.34886339e-01f, -1.96631148e-01f, -1.49480207e-02f, -5.09141348e-02f, 7.40494877e-02f, -9.76333544e-02f, 2.67183315e-02f, -5.72577293e-04f, -3.64537053e-02f, -2.93885637e-02f,
  -3.90546359e-02f, -1.53274834e-01f, 3.80209871e-02f, -3.88333835e-02f, -1.27635464e-01f, -1.22531392e-01f, -1.32590979e-01f, -1.79138675e-01f, -1.05339147e-01f, 9.24012810e-02f,
  -1.12185441e-01f, -1.53438538e-01f, -3.24152887e-01f, -2.17228159e-01f, -9.70680714e-02f, -2.30396941e-01f, -3.94903347e-02f, -4.96900789e-02f, -2.10602328e-01f, -1.80191666e-01f,
  -1.78751145e-02f, -1.90740213e-01f, 4.27244931e-01f, 1.41361177e-01f, -1.58786505e-01f, 7.11311074e-03f, -6.37299120e-02f, -5.91935366e-02f, -3.12321298e-02f, 4.16983403e-02f,
  1.03353046e-01f, 1.54561043e-01f, 4.03381348e-01f, 4.44152951e-01f, 3.80110085e-01f, 3.58401895e-01f, 2.93760866e-01f, 4.70443606e-01f, 3.14052045e-01f, -4.21365686e-02f,
  -8.63660574e-02f, -1.12734467e-01f, 1.91948950e-01f, 1.84461087e-01f, -2.14271396e-02f, 1.82966381e-01f, 2.37990722e-01f, 3.61976326e-02f, 1.78646937e-01f, 3.51317018e-01f,
  3.63121271e-01f, 9.99396387e-03f, 2.26385236e-01f, 2.71520227e-01f, 2.94003695e-01f, 2.15772972e-01f, 2.86927849e-01f, 2.01196522e-01f, 2.08094388e-01f, 2.49884069e-01f,
  1.93018705e-01f, 1.87385365e-01f, 2.44876042e-01f, 1.76958650e-01f, 2.06701204e-01f, 2.54139960e-01f, 1.81213468e-01f, 3.90166193e-01f, 3.24231148e-01f, 1.43664122e-01f,
  1.14338256e-01f, 1.32489502e-01f, 2.64161557e-01f, 2.66280681e-01f, 2.56083250e-01f, 3.56979907e-01f, 2.35397145e-01f, 1.89391941e-01f, 3.62097949e-01f, 1.69499785e-01f,
  -5.75353950e-02f, -2.01196089e-01f, -2.32937485e-01f, -2.44790196e-01f, -1.70403957e-01f, -8.69665816e-02f, -2.13482887e-01f, -1.43593028e-01f, -2.12268338e-01f, -1.93501666e-01f,
  -1.99690595e-01f, -1.14183806e-01f, -2.31471181e-01f, -1.14864707e-01f, -8.94998163e-02f, -1.37332708e-01f, -1.14568420e-01f, -1.96160898e-01f, -8.67019966e-02f, -1.66601181e-01f,
  -8.42900276e-02f, -8.13526735e-02f, -1.80086106e-01f, -1.08180135e-01f, -1.52574018e-01f, -9.19222906e-02f, -2.06764102e-01f, -2.21977621e-01f, -2.46871650e-01f, -2.80419528e-01f,
  -3.63843888e-02f, 3.22586626e-01f, 2.59870738e-01f, 1.87983274e-01f, 1.77476570e-01f, 2.38157034e-01f, 2.56139755e-01f, 2.60861754e-01f, 2.06065133e-01f, 2.81794518e-01f,
  2.66271621e-01f, 2.38334626e-01f, 2.51932204e-01f, 2.09499821e-01f, 2.19124779e-01f, 2.43605316e-01f, 1.94898456e-01f, 3.12172472e-01f, 2.44559601e-01f, 2.03515038e-01f,
  1.88192666e-01f, 2.78995246e-01f, 4.08250391e-01f, 2.84956396e-01f, 2.56422341e-01f, 3.99929702e-01f, 3.27895820e-01f, 2.46479914e-01f, 3.20950925e-01f, 1.39550790e-01f,
  6.22589648e-01f, -8.76358226e-02f, 3.48565370e-01f, 3.91258508e-01f, 1.32506073e-01f, -1.43753648e-01f, -2.39336863e-01f, -1.95344985e-01f, 5.42061776e-02f, 7.75699839e-02f,
  -2.59722881e-02f, 2.37865243e-02f, -1.65016428e-02f, -7.98324943e-02f, -1.78159758e-01f, 6.19882233e-02f, 1.39052466e-01f, 2.37125427e-01f, -7.25772157e-02f, -2.41416574e-01f,
  -2.03056201e-01f, -7.75970295e-02f, 9.42375660e-02f, -1.55375227e-01f, 8.89964327e-02f, -1.22292051e-02f, 1.66882843e-01f, 2.17288166e-01f, -3.87063483e-03f, 2.66128719e-01f,
  2.98800319e-01f, 1.38289526e-01f, -7.55078569e-02f, -2.01860331e-02f, 1.57197341e-01f, -6.01271447e-03f, -5.23444824e-02f, 1.13826066e-01f, 2.61571147e-02f, 2.75333412e-03f,
  2.00685170e-02f, -3.24578322e-02f, 2.43611783e-02f, -1.54556073e-02f, 6.67355284e-02f, -6.41020462e-02f, 3.62765379e-02f, 1.44952029e-01f, 4.52848636e-02f, 6.14156723e-02f,
  -2.91363671e-02f, 1.99647903e-01f, 3.21944594e-01f, 2.20279116e-02f, 7.03325914e-03f, 3.45775345e-03f, 8.00389275e-02f, 3.14027187e-03f, -1.11281453e-03f, 1.86214112e-02f,
  -5.72609715e-02f, 2.71884780e-02f, -9.57218781e-02f, -1.16275482e-01f, -1.44060791e-01f, -1.12022404e-02f, -6.36317059e-02f, -1.10299930e-01f, -1.15129903e-01f, -8.64604488e-02f,
  -3.63006666e-02f, -1.84314288e-02f, -3.66033055e-02f, 3.22467810e-03f, -1.91342440e-02f, 7.92593285e-02f, 8.56083818e-03f, -9.58474353e-02f, -4.41233180e-02f, -5.95066138e-02f,
  -3.62699963e-02f, 3.23411115e-02f, 6.89402074e-02f, -8.54155421e-02f, -7.91913420e-02f, 6.89027458e-02f, -9.98129174e-02f, -1.41830146e-01f, -1.07154131e-01f, -1.08739976e-02f,
  -5.47736585e-02f, -1.03873320e-01f, 5.50257042e-02f, -8.79440829e-02f, 8.43919143e-02f, 6.32082000e-02f, 1.03483260e-01f, -3.68074216e-02f, 1.03460208e-01f, 7.19339699e-02f,
  -2.07965113e-02f, -1.36736324e-02f, 6.84789196e-02f, -5.01260608e-02f, -7.35661015e-02f, 1.28758876e-02f, -7.69528672e-02f, 1.27624750e-01f, 2.71921847e-02f, 4.53598350e-02f,
  -3.84737812e-02f, 1.52045056e-01f, 1.31992891e-01f, 5.85981980e-02f, 3.60516571e-02f, 1.12357959e-01f, 2.35758256e-02f, 2.20183935e-02f, 9.67869908e-02f, -3.54461372e-02f,
  4.47462589e-01f, -1.97799444e-01f, -6.49292469e-02f, 1.52358994e-01f, -2.27147996e-01f, -3.33784878e-01f, -4.79930133e-01f, -1.70945689e-01f, 7.84070119e-02f, -5.47656268e-02f,
  1.12216055e-01f, 2.34983265e-01f, 1.39495552e-01f, 9.49306637e-02f, -5.37734218e-02f, -2.04301268e-01f, -1.89776808e-01f, 1.01157092e-01f, 8.94592255e-02f, -5.06014638e-02f,
  -1.84389114e-01f, -1.14650644e-01f, 8.18869621e-02f, -5.44686392e-02f, 5.58952466e-02f, 1.07559606e-01f, 3.54035720e-02f, 1.51427193e-02f, -4.41486761e-02f, 5.95147349e-02f,
  2.40075052e-01f, 5.63370176e-02f, -4.41756733e-02f, 6.08400740e-02f, -1.35543328e-02f, -3.82926762e-02f, -1.97974313e-02f, -3.51040363e-02f, -9.09087658e-02f, -1.12007760e-01f,
  -2.22233608e-02f, -7.92116672e-02f, 2.45390013e-02f, -1.43948749e-01f, -8.79153386e-02f, 6.41368469e-03f, -3.02953855e-03f, -1.64416581e-02f, -8.62081423e-02f, -5.70360981e-02f,
  2.44108215e-03f, -6.43197373e-02f, -1.25542656e-01f, -1.62217766e-01f, -8.76009762e-02f, 8.48459378e-02f, -1.49771661e-01f, -1.72494799e-02f, -5.90878390e-02f, -4.70184498e-02f,
  -1.04626437e-04f, 1.19086348e-01f, 7.69617930e-02f, 4.88184765e-02f, 2.31045447e-02f, 6.96314499e-02f, 9.05026048e-02f, 1.66249946e-02f, -2.29694764e-03f, -8.95881187e-03f,
  1.17056474e-01f, 1.12313844e-01f, 5.83674153e-03f, 9.50755402e-02f, 2.11182926e-02f, 5.75315766e-02f, 3.59798484e-02f, 3.79040577e-02f, 7.41900504e-02f, 1.10560248e-03f,
  6.23550788e-02f, 5.66440895e-02f, 6.37162402e-02f, -1.36779705e-02f, 1.70342661e-02f, 1.42009318e-01f, 4.12668996e-02f, 3.54533382e-02f, 8.13931152e-02f, 5.94764128e-02f,
  -8.92986134e-02f, -4.51237559e-02f, 1.25526516e-02f, -2.33716201e-02f, -8.60446170e-02f, -2.07024589e-02f, -4.35931832e-02f, -3.47299017e-02f, 1.54635431e-02f, 1.67084765e-02f,
  3.58531475e-02f, -1.72066167e-02f, -9.85412747e-02f, -6.23224536e-03f, -1.10485472e-01f, -1.61245197e-01f, -8.13195705e-02f, 2.39916183e-02f, -3.41950580e-02f, -1.41400397e-01f,
  -1.82930917e-01f, -8.70377943e-02f, -2.91263293e-02f, -1.21396385e-01f, -1.16000898e-01f, -3.35135753e-03f, -7.58807361e-02f, -1.11364007e-01f, -5.99847697e-02f, -3.33480090e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.07135010e+00f, -5.72896481e-01f, -5.18071413e-01f, 2.73671776e-01f, 1.56850472e-01f, -1.59086779e-01f, -5.26219547e-01f, -2.11670503e-01f, 5.08968495e-02f, 6.31274879e-02f,
  3.59861135e-01f, 5.32057226e-01f, 4.45029646e-01f, 2.94231683e-01f, 1.45952720e-02f, -3.09238374e-01f, -2.97403812e-01f, -6.34054095e-03f, 1.27117619e-01f, 3.78819674e-01f,
  3.18057954e-01f, -2.10203230e-02f, 1.69660076e-01f, 1.22684754e-01f, 2.07951128e-01f, 3.59026045e-01f, -2.25096866e-01f, 9.31508467e-02f, 6.05433248e-02f, 1.95406049e-01f,
  1.63136914e-01f, 3.53781544e-02f, 2.14396432e-01f, 3.28964651e-01f, 4.83321883e-02f, -1.62455574e-01f, 4.49576322e-03f, -2.17808351e-01f, -6.61722124e-02f, -2.56203800e-01f,
  5.11968955e-02f, 6.07658140e-02f, 6.39409050e-02f, 1.63156539e-02f, -1.68164328e-01f, -4.19719554e-02f, -1.86195254e-01f, -7.33871982e-02f, 4.45764065e-02f, -4.91570346e-02f,
  2.00030357e-01f, 9.25503373e-02f, -1.06990583e-01f, -1.39093310e-01f, 3.48587036e-02f, 2.09801763e-01f, -7.55048245e-02f, 1.66215330e-01f, -1.85892656e-02f, -1.17909856e-01f,
  3.75239164e-01f, 1.34473696e-01f, 2.43113399e-01f, 6.05891421e-02f, 1.94893971e-01f, 1.36262730e-01f, 1.35720866e-02f, -5.23292236e-02f, 1.03068195e-01f, -1.10097565e-01f,
  -6.12219088e-02f, -1.44694485e-02f, -1.23066314e-01f, -5.67238517e-02f, 1.45594552e-01f, 9.89282206e-02f, -7.09692761e-02f, -1.25027791e-01f, 1.18024528e-01f, -3.08004511e-03f,
  6.30984828e-02f, 6.93226010e-02f, -2.66554058e-02f, -7.55199492e-02f, -3.54064330e-02f, 1.10431686e-01f, 9.85315889e-02f, 2.46323422e-02f, 3.62885185e-02f, -3.94531600e-02f,
  -8.73217285e-01f, 1.63233593e-01f, 2.99056798e-01f, 1.36695147e-01f, -2.81963404e-02f, -6.04557768e-02f, 2.75540560e-01f, -1.45348273e-02f, -3.41675580e-02f, -2.00320467e-01f,
  -1.10412963e-01f, -1.85948294e-02f, -9.87028629e-02f, -1.07098922e-01f, -1.05250917e-01f, -7.65268877e-02f, 3.64369228e-02f, 3.95766720e-02f, 6.28478229e-02f, -3.72457244e-02f,
  -1.84007391e-01f, -2.30625257e-01f, -2.77989328e-01f, -1.97408319e-01f, 5.82226962e-02f, 4.45815958e-02f, -1.25578910e-01f, -7.16638267e-02f, -2.37184633e-02f, -2.40484253e-01f,
  -7.65055299e-01f, -5.99365294e-01f, 6.08905219e-02f, -8.44833076e-01f, -5.04395127e-01f, -3.92952234e-01f, -8.55426490e-01f, -2.87898719e-01f, -4.75009412e-01f, -8.16310167e-01f,
  2.94967312e-02f, 9.94353235e-01f, 6.09828651e-01f, 7.71276593e-01f, 7.19111145e-01f, -9.03834760e-01f, -9.25867379e-01f, 2.35989347e-01f, 9.50268686e-01f, 7.51243755e-02f,
  -3.86472642e-01f, -6.01751089e-01f, -2.94356253e-02f, 3.78669687e-02f, -9.92063105e-01f, -9.55606923e-02f, -7.59941459e-01f, -7.71944523e-01f, -3.49674404e-01f, -1.21387839e+00f,
  2.70885348e-01f, -1.85356230e-01f, 3.37149352e-01f, 2.35002458e-01f, -2.97549605e-01f, 2.86195904e-01f, 5.62977493e-02f, -7.23437071e-02f, -2.05868878e-03f, -1.44816503e-01f,
  -6.80608824e-02f, 2.89528459e-01f, -2.40352489e-02f, 1.44399807e-01f, -4.32112604e-01f, 4.82539013e-02f, -1.30441085e-01f, 7.19878450e-02f, 1.54144270e-02f, -1.48303639e-02f,
  -1.91150814e-01f, -2.03663543e-01f, 2.34435335e-01f, 1.67882994e-01f, 1.59320444e-01f, 3.12267721e-01f, -3.97672616e-02f, 7.38002062e-02f, 1.04103059e-01f, -9.44324493e-01f,
  -2.88539708e-01f, 1.34692073e-01f, 5.93361147e-02f, -7.39808977e-02f, -1.55527160e-01f, -4.14348431e-02f, -7.75656849e-02f, -6.51692897e-02f, 8.60860199e-02f, -8.62235948e-02f,
  1.30618170e-01f, -1.49779022e-01f, -4.04101498e-02f, -4.78242524e-02f, -2.85803713e-02f, -1.13012977e-01f, -9.52904522e-02f, -4.02823165e-02f, -1.26373336e-01f, -2.48223886e-01f,
  5.67738079e-02f, 5.52048497e-02f, -2.16200083e-01f, -2.33819000e-02f, 1.18299805e-01f, -2.63608880e-02f, 1.47859499e-01f, 2.82518029e-01f, -1.32317916e-01f, -7.04606017e-03f,
  1.46583065e-01f, 4.50735003e-01f, -3.43198657e-01f, 1.34433806e-01f, -1.53277457e-01f, -3.23088095e-02f, -3.28270830e-02f, -2.24574562e-02f, -4.38078865e-03f, 1.03433415e-01f,
  2.07729131e-01f, 1.23223318e-02f, -1.36120901e-01f, 6.50778264e-02f, 8.49293917e-02f, 1.02005623e-01f, -2.20824242e-01f, -3.18447761e-02f, 6.98073879e-02f, -1.56488195e-01f,
  -3.28651786e-01f, -2.54561424e-01f, 1.02755778e-01f, 7.02681765e-02f, -1.42757669e-01f, 2.55309045e-01f, 1.07376620e-01f, -3.39212865e-02f, 2.68095523e-01f, -6.51541770e-01f,
  -1.50726235e+00f, 4.43030179e-01f, 1.05394192e-01f, -5.96441269e-01f, -5.07264614e-01f, -4.40830231e-01f, 3.58986735e-01f, -2.74539962e-02f, -2.12979242e-01f, 6.57430947e-01f,
  5.68220019e-01f, -2.21419901e-01f, 7.29666576e-02f, -1.03404738e-01f, -2.08701953e-01f, 3.78641516e-01f, -4.63210456e-02f, -8.51137877e-01f, -9.51236248e-01f, -6.15364671e-01f,
  -4.61092055e-01f, -7.61600494e-01f, -9.55179572e-01f, -3.66117328e-01f, 1.78202495e-01f, -3.27103138e-01f, 2.86503524e-01f, -3.80554199e-01f, -2.03658372e-01f, 4.96838763e-02f,
  5.82746029e-01f, -5.08750916e-01f, -2.11530641e-01f, -2.72177219e-01f, 2.29068369e-01f, 5.57999872e-02f, 8.56480971e-02f, -3.07578910e-02f, 6.89261630e-02f, 1.29992187e-01f,
  -3.70047428e-03f, 7.84319192e-02f, -7.28566498e-02f, 4.68082465e-02f, -2.10261688e-01f, -1.25999883e-01f, 8.85028671e-03f, -1.93612888e-01f, 6.98749870e-02f, 4.74786222e-01f,
  2.94508040e-01f, -9.50054452e-02f, 7.78071117e-03f, 2.40245610e-01f, 9.88985226e-02f, -3.37034643e-01f, 2.65823811e-01f, 3.79906632e-02f, 2.14893855e-02f, 2.30562970e-01f,
  1.02526538e-01f, 2.47442469e-01f, -5.45605738e-03f, -9.49307680e-02f, 5.82211874e-02f, 8.50119591e-02f, -1.00989327e-01f, 1.50772259e-01f, -9.15946662e-02f, 9.81732681e-02f,
  2.02605203e-01f, 6.63473383e-02f, 1.99076086e-02f, -1.60239302e-02f, 4.05292362e-02f, -4.98611927e-02f, -3.35411169e-04f, 1.62319750e-01f, 1.65125236e-01f, -1.01957828e-01f,
  -1.29656851e-01f, 2.89510284e-02f, 1.50522739e-02f, 5.09720966e-02f, 8.20375159e-02f, -2.96169054e-03f, -7.63425650e-03f, 1.23094358e-01f, -3.67175601e-02f, -1.11338906e-01f,
  8.92894045e-02f, -3.42940211e-01f, 2.56305367e-01f, -1.66670814e-01f, -4.39087525e-02f, 2.43091390e-01f, 4.52798931e-03f, -4.11146097e-02f, -1.44091204e-01f, -5.61238602e-02f,
  -1.93813458e-01f, 9.95572284e-03f, 1.06144235e-01f, 1.71209931e-01f, -1.14760771e-01f, -6.22614734e-02f, 1.07350044e-01f, -4.82162796e-02f, -7.16592520e-02f, 1.57969087e-01f,
  2.94189215e-01f, 5.31093637e-03f, 2.58742832e-02f, 1.67426765e-01f, 6.70143962e-02f, -2.91991204e-01f, 1.92921877e-01f, 7.22430199e-02f, -2.74294596e-02f, 5.17950416e-01f,
  9.42682624e-01f, 2.87574202e-01f, 4.06540841e-01f, 8.93284529e-02f, -7.14436993e-02f, 8.27299580e-02f, 1.35069534e-01f, 2.47497529e-01f, 1.66368913e-02f, 8.29181001e-02f,
  1.74949080e-01f, 1.08707890e-01f, 7.81853274e-02f, 7.03901052e-03f, 2.04598159e-01f, -1.43342629e-01f, -2.04940379e-01f, 2.26844072e-01f, 2.22373903e-01f, 1.16449423e-01f,
  -1.19880959e-01f, 1.96656108e-01f, 3.74880821e-01f, 1.95226967e-01f, -2.12162122e-01f, -1.91485748e-01f, 1.83973521e-01f, -8.54922459e-04f, -2.61782091e-02f, -4.01612908e-01f,
  -2.98001021e-01f, 3.65683138e-01f, -1.35878578e-01f, 8.12052190e-02f, 2.86400855e-01f, 2.82236129e-01f, 8.23085234e-02f, 8.44579786e-02f, -8.65227208e-02f, -1.13167174e-01f,
  -8.30964074e-02f, 1.46122694e-01f, 2.50532597e-01f, 1.42150149e-01f, 9.23281983e-02f, 6.60483837e-02f, 1.55533582e-01f, -1.06696617e-02f, -3.47990766e-02f, 1.36259004e-01f,
  -4.56546433e-02f, 7.59501979e-02f, -3.96340759e-03f, -7.84111246e-02f, -3.99402939e-02f, 4.20831628e-02f, -2.80537480e-03f, 5.53741306e-02f, 7.91914985e-02f, -5.97297959e-02f,
  -1.71284258e-01f, -3.67254466e-02f, 1.03001669e-01f, -1.15899719e-01f, 5.67967631e-02f, 8.87091458e-02f, -1.54453397e-01f, -1.37590349e-01f, 1.95749730e-01f, 2.68649429e-01f,
  -6.20253608e-02f, 4.42364514e-02f, 6.87002093e-02f, 1.64828915e-02f, 1.99325621e-01f, 1.19602621e-01f, -5.39757460e-02f, 2.20277645e-02f, 1.49347529e-01f, 6.30816817e-02f,
  1.12577207e-01f, -5.61250411e-02f, 4.07505423e-01f, 3.20612162e-01f, -3.98283526e-02f, -2.72923466e-02f, -5.91352060e-02f, 1.00480355e-01f, 6.86115623e-02f, -1.58452824e-01f,
  -2.50698477e-01f, 4.83822525e-01f, -2.34279916e-01f, -2.11132705e-01f, 8.95585418e-02f, 1.05180219e-01f, -1.06484674e-01f, -1.69434682e-01f, -2.50992745e-01f, -3.53574157e-01f,
  -1.10684842e-01f, -2.72004008e-02f, 1.23484060e-01f, 1.64332941e-01f, 2.06621978e-02f, -6.29020929e-02f, -7.70111606e-02f, -6.75209165e-02f, -1.44857526e-01f, -2.02124745e-01f,
  -1.08767658e-01f, -1.29747227e-01f, -1.50304273e-01f, -1.44274116e-01f, -1.61149681e-01f, -1.63167447e-01f, -8.57908502e-02f, -7.81197101e-02f, 9.85782221e-03f, 2.23354828e-02f,
  2.21324667e-01f, 6.77050769e-01f, 7.01406002e-02f, 3.31728578e-01f, 2.14819804e-01f, 2.78515697e-01f, 4.13388789e-01f, 1.53628215e-01f, 2.17646748e-01f, 1.44644573e-01f,
  3.18293989e-01f, 3.63239735e-01f, 2.80478030e-01f, 2.34585792e-01f, 2.63854355e-01f, 2.14748546e-01f, 2.37694636e-01f, 4.16496471e-02f, 8.11325386e-02f, 2.32351124e-01f,
  3.45905215e-01f, 1.22775115e-01f, -1.60865318e-02f, 2.73887385e-02f, 3.03043067e-01f, 2.24376708e-01f, 2.28462040e-01f, 2.68998116e-01f, 2.61792660e-01f, 2.73301870e-01f,
  1.38199061e-01f, 1.28941104e-01f, -1.38043076e-01f, 4.29558903e-02f, -1.20192720e-02f, -2.26259321e-01f, -5.32266237e-02f, -2.01732785e-01f, -1.80148661e-01f, -4.06649038e-02f,
  -3.99863832e-02f, -3.02173141e-02f, 4.11359929e-02f, -1.27946958e-01f, -6.66308105e-02f, -2.30089232e-01f, -1.85899198e-01f, 2.97705121e-02f, 2.38242354e-02f, -1.09317638e-01f,
  1.57654192e-02f, 1.01002241e-02f, -9.07248780e-02f, -3.64221819e-02f, 6.87002614e-02f, -1.41974334e-02f, -6.28675073e-02f, 4.04694676e-03f, 2.74995565e-02f, -5.67482337e-02f,
  -1.67353943e-01f, -1.99351907e-02f, 4.66077216e-02f, -6.83178678e-02f, 8.96256343e-02f, -1.18411541e-01f, 7.52246240e-03f, 1.03906868e-02f, 1.30464748e-01f, -8.81608799e-02f,
  -1.08560473e-01f, -4.00248282e-02f, -2.61062081e-03f, 6.24171086e-02f, -6.53377324e-02f, -1.27746062e-02f, -2.54160743e-02f, -1.46569654e-01f, -5.23611046e-02f, -5.62114455e-02f,
  9.62387621e-02f, -1.63145438e-01f, -1.71167478e-01f, -8.28336999e-02f, -1.22328863e-01f, 2.36591473e-02f, -1.02101400e-01f, -1.08063206e-01f, -1.66706502e-01f, -7.35230744e-02f,
  2.65504152e-01f, 1.49851730e-02f, -8.19700584e-03f, -2.75431424e-02f, 2.20575184e-02f, -2.08490431e-01f, 4.89988662e-02f, -1.59454301e-01f, -2.80921021e-03f, 7.21483305e-03f,
  -4.41250652e-02f, -1.33390293e-01f, 6.84721619e-02f, -1.39999762e-01f, -1.53624862e-01f, -5.51801808e-02f, 3.39689553e-02f, 8.52238908e-02f, 4.45337454e-03f, -1.44316390e-01f,
  -9.73652005e-02f, -1.71613604e-01f, -1.96877390e-01f, -4.20321599e-02f, -1.38230026e-02f, -1.93674788e-01f, -1.78824589e-01f, -1.01621829e-01f, -8.13351870e-02f, -1.40228793e-01f,
  -1.53275180e+00f, 2.05934986e-01f, -2.60654449e-01f, -6.86791003e-01f, 5.09012103e-01f, 2.37714648e-01f, 1.18611790e-01f, -6.19056225e-01f, -5.83409429e-01f, -2.22390234e-01f,
  5.92313588e-01f, 1.88389018e-01f, -4.95200492e-02f, 1.35381460e-01f, -1.12971574e-01f, 2.58855879e-01f, 3.12882394e-01f, -1.87007919e-01f, -1.74868926e-02f, 3.61956835e-01f,
  6.11285567e-01f, -1.58623040e-01f, -4.21489984e-01f, -1.02337830e-01f, -2.97249436e-01f, -7.75839016e-02f, -8.39037150e-02f, 5.92896640e-02f, 3.50460798e-01f, 9.16572195e-03f,
  -4.31412101e-01f, -1.02508378e+00f, 2.76680291e-01f, 1.89009652e-01f, 2.26554319e-01f, -3.94429922e-01f, -2.68809468e-01f, -3.06629986e-01f, -1.11091480e-01f, -3.40375379e-02f,
  2.48072118e-01f, -2.29907110e-01f, 2.53428537e-02f, 1.30030409e-01f, -7.41699040e-02f, -3.19607258e-01f, 2.34946702e-02f, -2.76420653e-01f, -5.88890910e-01f, -2.82520682e-01f,
  8.81169081e-01f, 5.24349630e-01f, -2.26827189e-01f, 9.95078012e-02f, -2.01099321e-01f, 8.67324919e-02f, -8.09764937e-02f, -4.65642154e-01f, -4.83284444e-01f, -1.17859101e+00f,
  -1.79348260e-01f, 1.48429334e-01f, 1.28831249e-02f, -7.69768879e-02f, -5.47739081e-02f, 1.07717052e-01f, 1.10645242e-01f, 2.38031313e-01f, 4.12124544e-02f, -2.34149754e-01f,
  9.19140503e-02f, -7.86933377e-02f, -6.35186210e-02f, -4.03248221e-01f, 3.43901142e-02f, 1.62972018e-01f, -1.98333096e-02f, 9.78929698e-02f, 3.37904431e-02f, -1.55412033e-01f,
  1.33605371e-03f, -1.82307176e-02f, 1.08842455e-01f, -1.65790766e-01f, 3.13648656e-02f, -1.27610296e-01f, -1.83766380e-01f, 8.33455399e-02f, 6.22362085e-03f, 1.56037398e-02f,
  -5.03000855e-01f, 6.40481591e-01f, -6.77565098e-01f, 1.05406463e-01f, -6.86706454e-02f, 4.02892619e-01f, 4.45224997e-03f, 3.49127620e-01f, 8.29123631e-02f, -1.89383477e-01f,
  -1.29570588e-02f, -1.02681302e-01f, 4.05329727e-02f, 2.38088623e-01f, 1.12008059e-03f, -2.44654831e-03f, 2.83322573e-01f, 2.22224779e-02f, 1.44012384e-02f, 1.59937814e-01f,
  -1.87505245e-01f, -4.58832175e-01f, -8.31190467e-01f, -6.45539999e-01f, -3.08348686e-01f, -4.27759379e-01f, -3.79101217e-01f, -5.87321222e-01f, -4.90698516e-01f, -1.25957417e+00f,
  -1.41527176e-01f, 1.07918644e+00f, 6.94676161e-01f, -4.34538960e-01f, 2.87027240e-01f, 4.48542774e-01f, 9.15009916e-01f, 2.82450348e-01f, -4.37204748e-01f, 2.75775999e-01f,
  -4.99402136e-02f, -9.73029613e-01f, -2.91984379e-01f, -4.71840799e-01f, -2.32272997e-01f, 5.88134289e-01f, 5.38294733e-01f, -1.90263152e-01f, -6.56465352e-01f, -6.49324596e-01f,
  -4.33062136e-01f, -3.60150516e-01f, -4.45793360e-01f, -7.91598931e-02f, 4.09221590e-01f, -3.25106442e-01f, 7.44571745e-01f, 1.89143226e-01f, 3.61889333e-01f, -8.23837593e-02f,
  -1.87042415e-01f, 8.63899827e-01f, -4.98562366e-01f, -4.11805451e-01f, -1.61881864e-01f, -2.94652820e-01f, 2.36184504e-02f, -2.99226493e-03f, 2.07816716e-02f, 5.44339642e-02f,
  -9.97673199e-02f, -1.07249811e-01f, -1.35818303e-01f, 6.30176514e-02f, -1.74726978e-01f, -2.29075700e-01f, -1.07494486e-03f, -2.04776555e-01f, 1.50894104e-02f, 1.76422596e-01f,
  -3.56090039e-01f, 2.30292678e-02f, 6.45474970e-01f, 3.22964281e-01f, 2.45794833e-01f, -8.85518849e-01f, 1.91528231e-01f, -1.18109152e-01f, 1.88903660e-01f, -2.50816047e-01f,
  7.29303136e-02f, 1.84177801e-01f, 1.04477875e-01f, 2.56205082e-01f, -3.14150639e-02f, -7.10418299e-02f, -2.82782670e-02f, -4.18742672e-02f, -4.10732180e-02f, 1.21659681e-01f,
  -1.66953914e-02f, -1.25914738e-01f, -1.99260712e-02f, 9.26961601e-02f, 2.20177863e-02f, -1.48335114e-01f, -1.67703517e-02f, -1.79792717e-01f, 4.24656346e-02f, 1.80816837e-02f,
  -1.04985870e-01f, -2.69424114e-02f, 3.15481015e-02f, -1.86669290e-01f, 1.59039885e-01f, 1.59987345e-01f, -1.10181093e-01f, -1.03222236e-01f, 7.29102790e-02f, 2.44187534e-01f,
  -7.15168834e-01f, 1.91853032e-01f, -2.90732324e-01f, 1.74105389e-03f, 1.82909101e-01f, -1.02027006e-01f, 2.57692546e-01f, 1.39428928e-01f, 2.39262328e-01f, -1.74057007e-01f,
  1.16185673e-01f, 1.67523753e-02f, 1.76785693e-01f, -8.18892121e-02f, -4.41132903e-01f, 1.72820985e-01f, -1.52628332e-01f, -1.10202484e-01f, 5.09217083e-02f, -1.21483728e-01f,
  -1.15488023e-01f, -5.55533059e-02f, -5.72196066e-01f, 6.62079751e-02f, -7.48051628e-02f, -8.00129950e-01f, -2.88592190e-01f, -5.03882505e-02f, -3.09352875e-01f, -2.55459100e-01f,
  -4.22390521e-01f, -5.41017175e-01f, 4.11380082e-01f, 4.50307101e-01f, 6.07985616e-01f, 4.82542098e-01f, 2.57956892e-01f, 3.44345063e-01f, 5.19797862e-01f, 2.98795432e-01f,
  9.04825702e-02f, 4.66629297e-01f, 4.44826603e-01f, 2.28345796e-01f, 1.99932665e-01f, 3.64533067e-01f, 4.35917318e-01f, 2.54330605e-01f, 2.43678689e-01f, 2.54393280e-01f,
  1.60981238e-01f, -7.50473887e-02f, -3.90273184e-01f, 1.45257726e-01f, 9.10906047e-02f, 2.66567290e-01f, 8.53309035e-02f, -6.28140718e-02f, -1.33403152e-01f, 7.37653002e-02f,
  -1.12339422e-01f, -3.58347297e-01f, 3.39761198e-01f, -1.82264566e-01f, -3.13640386e-01f, -2.73363531e-01f, 5.03891893e-02f, -1.89658076e-01f, -2.86321044e-01f, 5.12687750e-02f,
  -1.59942642e-01f, -2.51961201e-01f, -3.81818376e-02f, -1.32596627e-01f, -1.19862840e-01f, -2.45792329e-01f, -1.46963611e-01f, 1.17287382e-01f, 1.46622345e-01f, -2.35068239e-02f,
  -5.67685626e-02f, 1.15759000e-01f, 1.77798718e-01f, 2.12484062e-01f, -4.49707955e-02f, -1.99313853e-02f, -1.50634408e-01f, 1.59452129e-02f, 1.92204881e-02f, 1.14379495e-01f,
  2.69844770e-01f, 3.22595060e-01f, 1.07741386e-01f, 1.38250634e-01f, 1.30031005e-01f, 1.40751138e-01f, 1.12600759e-01f, 2.13020612e-02f, 1.12350374e-01f, 3.03144585e-02f,
  9.89461392e-02f, 2.12681830e-01f, 1.32274285e-01f, -8.63231719e-02f, 1.69858530e-01f, 6.10886626e-02f, -1.28599718e-01f, -2.41779853e-02f, -2.71052439e-02f, -1.09971344e-01f,
  -1.37080420e-02f, 1.13260923e-02f, -2.95779288e-01f, 6.21517263e-02f, 1.79372933e-02f, 1.42089456e-01f, 7.16841668e-02f, -2.25675888e-02f, -9.92841497e-02f, 5.53592108e-03f,
  2.74595499e-01f, 1.52402610e-01f, 2.14769527e-01f, 1.87143851e-02f, -2.10491136e-01f, -2.69142777e-01f, 1.65670797e-01f, -3.38233747e-02f, -2.55573601e-01f, -3.91432904e-02f,
  -1.05202965e-01f, -1.62632257e-01f, -1.59432739e-01f, -8.82133320e-02f, 9.24111977e-02f, 7.25412443e-02f, -2.19723627e-01f, 1.75902337e-01f, 6.17177114e-02f, -6.22679442e-02f,
  -8.24870989e-02f, 3.88232589e-01f, 4.05354053e-01f, 3.35450619e-01f, 1.19951919e-01f, 1.80127501e-01f, -6.09183544e-03f, 2.16892082e-02f, 7.84429759e-02f, 3.03784236e-02f,
  4.15716887e-01f, -3.90700817e-01f, 7.28134632e-01f, 4.03607845e-01f, 4.55308110e-02f, -6.53120875e-01f, -1.63762462e+00f, -6.22764051e-01f, 2.12729499e-01f, -2.65224755e-01f,
  -1.55447423e-01f, 2.40924805e-01f, 4.59916502e-01f, -3.44349295e-02f, -5.31474352e-01f, -6.58509851e-01f, 6.62218779e-02f, 2.18640119e-01f, -1.83244050e-01f, -6.52961016e-01f,
  -6.27102494e-01f, -2.56087855e-02f, 2.95662165e-01f, 7.43628442e-02f, 5.53142071e-01f, 3.09289813e-01f, 5.95682979e-01f, 4.34203893e-01f, -5.30263744e-02f, 7.59315789e-01f,
  3.00478518e-01f, 4.34803218e-01f, -3.50616336e-01f, 1.92530245e-01f, 3.78438741e-01f, 7.11685419e-02f, -6.61140755e-02f, 5.06214142e-01f, 9.52000096e-02f, 2.17467129e-01f,
  2.67701954e-01f, 4.80674170e-02f, 1.28000066e-01f, -1.41600482e-02f, -1.28412604e-01f, -1.11090690e-01f, 1.79126710e-01f, 4.02553678e-02f, 2.34359980e-01f, -2.32691858e-02f,
  -3.44121993e-01f, -2.20123827e-01f, 1.86452210e-01f, -4.00499165e-01f, 1.02156773e-02f, 2.06522435e-01f, 7.73199871e-02f, 1.48978680e-01f, -2.21286155e-02f, 2.39045113e-01f,
  -1.98239639e-01f, 1.60320759e-01f, 1.95617452e-01f, 1.00834481e-01f, -1.29133299e-01f, 5.32325879e-02f, 7.68273771e-02f, -2.14351252e-01f, 1.75185591e-01f, -5.07855341e-02f,
  6.38566390e-02f, 4.91193719e-02f, 1.70784041e-01f, 1.36203496e-02f, -5.59682085e-04f, 1.26144737e-01f, 5.13586402e-02f, -2.10045993e-01f, 2.53906436e-02f, -8.25600922e-02f,
  3.03714275e-02f, 5.96837178e-02f, 2.52546638e-01f, -7.64320791e-02f, -2.43981611e-02f, 1.63771182e-01f, 6.52170554e-02f, 3.84350494e-02f, 1.19267471e-01f, 2.46209018e-02f,
  -3.15489590e-01f, -2.91690856e-01f, -2.38348469e-02f, -1.19391128e-01f, 1.58544645e-01f, 1.58805117e-01f, 4.12946974e-04f, -1.39933050e-01f, 1.48763090e-01f, -3.37597460e-01f,
  -3.43409018e-03f, -1.00990497e-01f, 1.16599403e-01f, -5.58775738e-02f, -1.93450987e-01f, 1.86773054e-02f, -2.79864907e-01f, -9.75925624e-02f, -1.08933650e-01f, -1.29155517e-01f,
  -1.15439072e-01f, -8.63089085e-01f, -7.71662176e-01f, -5.24094820e-01f, -1.99377120e-01f, -4.55613077e-01f, -2.97848165e-01f, -1.00674815e-01f, -5.88822186e-01f, -9.42778647e-01f,
  1.58289242e+00f, 3.35394181e-02f, -1.83559072e+00f, 7.00920701e-01f, -6.95443988e-01f, -7.74451017e-01f, -4.44943309e-01f, 4.65944916e-01f, 9.03795719e-01f, 7.45344982e-02f,
  -2.49706656e-01f, -1.70610964e-01f, -4.56755072e-01f, -6.74359739e-01f, -7.83842444e-01f, -1.00898921e+00f, -1.10041046e+00f, -1.40311146e+00f, -9.47427988e-01f, 1.05552621e-01f,
  4.91314799e-01f, 3.87286931e-01f, 1.08825520e-01f, -1.63319603e-01f, 2.59371340e-01f, -1.21870063e-01f, -6.04779661e-01f, -3.60563189e-01f, -7.29516923e-01f, -7.88570225e-01f,
  -1.19470477e+00f, -2.05518335e-01f, -4.96235341e-01f, 2.48646922e-02f, -2.41357937e-01f, 2.51734465e-01f, -1.60661772e-01f, -2.72440165e-02f, 1.81514114e-01f, -1.46636218e-01f,
  -2.05440462e-01f, 1.02209799e-01f, 5.40737361e-02f, -3.90502483e-01f, -5.83389588e-02f, -1.46086486e-02f, 2.90506799e-02f, -4.92834926e-01f, -3.39388371e-01f, -4.18637991e-01f,
  -1.25377372e-01f, -7.53385901e-01f, -6.57144606e-01f, -2.87497729e-01f, -3.05264175e-01f, -4.79663372e-01f, -2.51924276e-01f, -6.09313883e-02f, -5.78506589e-01f, 4.23606128e-01f,
  1.61010146e-01f, 3.55401263e-02f, 1.53735951e-01f, 3.09706867e-01f, 3.92648280e-01f, -7.17350692e-02f, -2.23888591e-01f, -1.79768428e-01f, 2.52228091e-03f, 6.79384768e-02f,
  -1.55721217e-01f, -1.19393535e-01f, 5.78169078e-02f, -9.56237987e-02f, -2.44482562e-01f, -9.62091014e-02f, -1.08865194e-01f, 1.16524823e-01f, -1.62500694e-01f, -9.97019187e-02f,
  -4.86002676e-02f, -3.85020413e-02f, 3.05318199e-02f, -2.19660867e-02f, -1.90901950e-01f, -1.18881047e-01f, 1.07331499e-02f, -7.22896680e-02f, 1.26002982e-01f, 2.73167998e-01f,
  6.14431262e-01f, -5.64720988e-01f, 1.16035230e-01f, 1.43649394e-03f, -4.25070018e-01f, -1.26202285e-01f, 1.67341977e-01f, 2.63155818e-01f, 2.29290202e-02f, -4.25738841e-02f,
  -2.76943773e-01f, -8.92069712e-02f, -1.78953171e-01f, 1.61916420e-01f, -9.79676247e-02f, 9.32035372e-02f, 1.76249117e-01f, -2.00311199e-01f, -1.41971529e-01f, 1.23367332e-01f,
  3.50697011e-01f, 4.00965177e-02f, 3.15707207e-01f, 5.81032000e-02f, 2.09250376e-01f, -2.06841086e-03f, -3.54543328e-01f, 1.83324777e-02f, -5.61349809e-01f, 7.30665684e-01f,
  1.54770422e+00f, 6.06723011e-01f, -2.62926966e-02f, 1.30720794e-01f, -3.35577756e-01f, -8.63767713e-02f, 2.05738083e-01f, 2.46853396e-01f, 4.02777418e-02f, 2.51252145e-01f,
  7.05023706e-02f, 1.82587922e-01f, 1.17217965e-01f, 3.67403366e-02f, 3.42719972e-01f, 1.35487676e-01f, -9.38055813e-02f, 1.12783484e-01f, 2.76019145e-02f, 2.50019059e-02f,
  -2.94183847e-03f, 2.01856077e-01f, 4.29311633e-01f, 1.39993340e-01f, -2.41673276e-01f, -1.03295319e-01f, -1.06325068e-01f, -1.45615309e-01f, -2.84244597e-01f, -2.43753359e-01f,
  -1.25632823e-01f, 1.39653817e-01f, -5.56364208e-02f, 1.23844044e-02f, -4.64494340e-03f, 1.39428258e-01f, 1.28621429e-01f, -8.39771181e-02f, -4.71819155e-02f, -1.17655680e-01f,
  -5.26824594e-02f, -1.28107548e-01f, -1.87247455e-01f, -1.40828416e-01f, -9.43952426e-02f, -8.16845968e-02f, 1.56958494e-02f, 2.23565400e-02f, -2.31274933e-01f, -1.02030262e-01f,
  -2.13238224e-01f, -1.73456609e-01f, -1.75596163e-01f, -3.31378952e-02f, 9.35902745e-02f, -6.94937930e-02f, -8.54498148e-02f, -5.48855476e-02f, -1.83694735e-02f, 4.49600294e-02f,
  -1.58486068e-01f, 2.11276874e-01f, -1.42081648e-01f, -2.32087206e-02f, 2.70071514e-02f, -9.62175950e-02f, 9.93676600e-04f, 1.63266197e-01f, 8.43813419e-02f, 1.45027518e-01f,
  -1.32095432e-02f, -2.82829434e-01f, -1.77307948e-01f, 1.81814954e-01f, -2.99839266e-02f, -1.38939515e-01f, 8.15423578e-02f, -2.72828490e-02f, -2.32614785e-01f, -1.43024817e-01f,
  3.27679142e-02f, -6.83786944e-02f, -9.80900377e-02f, -2.07333446e-01f, -1.66045144e-01f, -1.32288978e-01f, -8.27046782e-02f, -4.06376086e-02f, 1.17383100e-01f, 1.52470589e-01f,
  -1.84474185e-01f, -2.97172666e-01f, 1.46549195e-01f, 2.78467864e-01f, -6.45658076e-02f, 1.50807887e-01f, 1.40279964e-01f, -2.25033075e-01f, -2.16366604e-01f, -1.69241264e-01f,
  -5.76562732e-02f, 1.10015273e-01f, 1.30126625e-01f, 6.78221509e-02f, 9.42822918e-03f, -1.30342260e-01f, 6.27740398e-02f, 1.19493395e-01f, -1.08288139e-01f, -5.99706322e-02f,
  -1.51774120e-02f, 1.18044488e-01f, 4.50012721e-02f, 1.92699581e-01f, 1.75759733e-01f, 1.10351987e-01f, 9.76896212e-02f, 2.56781299e-02f, 3.94038707e-02f, 2.99097240e-01f,
  1.75983638e-01f, -8.33766982e-02f, 6.15099132e-01f, -3.53599370e-01f, 3.59342605e-01f, 7.67831683e-01f, 6.62590027e-01f, 1.53486952e-01f, -1.76331446e-01f, 6.33379212e-04f,
  1.70271680e-01f, -2.22613350e-01f, -3.43474001e-01f, -1.44979373e-01f, 1.25612661e-01f, 2.03847021e-01f, -2.58923545e-02f, 2.66223192e-01f, 3.21108192e-01f, 1.40523091e-01f,
  -1.80251151e-01f, -3.54203343e-01f, -2.53806919e-01f, -3.10129642e-01f, -5.67537963e-01f, -3.81884247e-01f, -1.65664181e-01f, -2.03805238e-01f, 1.77514434e-01f, -4.42194164e-01f,
  -3.30413692e-02f, 3.99421901e-02f, -5.98908216e-02f, -3.02477479e-01f, -3.57464403e-02f, -1.59055129e-01f, 3.32351290e-02f, -2.19293624e-01f, -5.92305698e-02f, -1.47883862e-01f,
  -5.87628260e-02f, -8.57896209e-02f, -1.26613965e-02f, -7.78373107e-02f, 7.78826028e-02f, 5.02291359e-02f, -1.99333340e-01f, -1.18540168e-01f, -7.51999766e-02f, -1.20760836e-02f,
  -1.33516774e-01f, 2.81313956e-01f, 3.85845184e-01f, 2.34931588e-01f, 1.58335000e-01f, 7.37464279e-02f, 5.73341362e-02f, 7.29989707e-02f, 1.41161218e-01f, -2.52646625e-01f,
  -1.64220817e-02f, 1.40459999e-01f, 1.83787540e-01f, 6.86302781e-02f, 1.28676340e-01f, 5.52544631e-02f, -1.35611594e-01f, -8.03180411e-02f, 1.18371882e-01f, 1.66349381e-01f,
  1.44920219e-02f, 4.38411504e-01f, 2.05565363e-01f, 5.63697629e-02f, -4.95274365e-02f, 1.75901517e-01f, 1.79006249e-01f, -4.94770147e-02f, 6.30262420e-02f, -1.43767715e-01f,
  9.06528682e-02f, -8.00375566e-02f, -5.91886193e-02f, -1.27741722e-02f, 1.42626494e-01f, -1.14303671e-01f, -2.21209060e-02f, 4.62639928e-02f, -2.45847460e-02f, 2.44920198e-02f,
  -5.30903220e-01f, 3.86882693e-01f, -2.95095652e-01f, -2.46874467e-01f, -1.96421400e-01f, -6.89616427e-02f, -1.31662339e-01f, -2.71233559e-01f, -2.63629317e-01f, -5.60912229e-02f,
  1.74135864e-02f, -2.29111854e-02f, 7.15681389e-02f, 1.71730518e-02f, 7.05823898e-02f, 5.30775785e-02f, -2.94069070e-02f, -8.96200945e-04f, -1.12527989e-01f, -1.04769580e-01f,
  -3.44715081e-02f, 1.48987055e-01f, 2.82481432e-01f, 1.17926151e-01f, -3.23696737e-03f, 2.52740175e-01f, 9.58323851e-02f, 8.72711763e-02f, 3.96484554e-01f, 4.53124708e-03f,
  4.78655666e-01f, 5.09281456e-01f, -1.11042254e-01f, 2.61302739e-01f, -1.26534656e-01f, -1.20060235e-01f, -2.34705374e-01f, -1.35921329e-01f, -1.42022138e-02f, 7.60340877e-03f,
  -3.42268616e-01f, -9.36544314e-02f, -2.38501616e-02f, 6.20524138e-02f, 1.29064783e-01f, 1.87792048e-01f, 2.88653582e-01f, 3.38402152e-01f, 2.27482125e-01f, 2.70435631e-01f,
  3.12954485e-01f, 4.64079231e-01f, 4.61363286e-01f, 2.83801943e-01f, 4.28348660e-01f, 2.38178313e-01f, 7.22685158e-02f, 3.09912890e-01f, 2.67630845e-01f, 7.10137546e-01f,
  -7.82993883e-02f, -2.68873274e-01f, -5.32753110e-01f, 7.23228604e-02f, -2.20811576e-01f, 2.33068928e-01f, 6.99089989e-02f, 9.86336619e-02f, -1.49730861e-01f, 2.32486069e-01f,
  5.46256080e-02f, 7.88880140e-02f, 6.20518103e-02f, 3.54075104e-01f, 1.29984856e-01f, -2.39889920e-01f, 1.70021057e-01f, -1.99099034e-02f, -6.77739084e-02f, -1.16258159e-01f,
  5.13676643e-01f, -8.44479166e-03f, -3.02834809e-01f, -4.76320773e-01f, -3.41956168e-01f, -2.92062372e-01f, -3.48165035e-01f, 3.99976708e-02f, -3.72421235e-01f, 1.58873439e-01f,
  -1.35105625e-01f, 6.03786632e-02f, 1.82022735e-01f, 1.82700992e-01f, 1.52296886e-01f, -1.04494803e-01f, 1.92386761e-01f, 2.00433925e-01f, 3.04967672e-01f, 9.49898660e-02f,
  -7.72968829e-02f, -8.90209079e-02f, -1.63584560e-01f, -1.71093971e-01f, -7.73828104e-02f, -2.80593038e-01f, 3.79137516e-01f, 1.36709079e-01f, -5.03075495e-02f, -1.91371441e-01f,
  1.31584629e-01f, 1.88356824e-02f, 1.37134567e-01f, 2.80695528e-01f, -1.39305089e-02f, -2.19351679e-01f, 3.30201447e-01f, 2.85762221e-01f, 9.31221992e-02f, 1.64592057e-01f,
  -1.84201732e-01f, -8.64842653e-01f, -1.96845323e-01f, 2.67993301e-01f, 2.84637883e-02f, -2.01652572e-01f, -9.12134573e-02f, -2.77355134e-01f, -2.06779137e-01f, 2.14487255e-01f,
  -8.34385902e-02f, 8.91450420e-02f, 1.47960838e-02f, 3.13785285e-01f, -2.43129998e-01f, -4.04417247e-01f, 7.42263943e-02f, -3.54321264e-02f, 4.67973761e-03f, -1.88867062e-01f,
  2.78353870e-01f, -2.46830553e-01f, -2.61264503e-01f, -5.02033830e-01f, -3.68464857e-01f, -4.81247127e-01f, -4.97215122e-01f, -2.25679591e-01f, -6.89491749e-01f, -3.01447928e-01f,
  -2.41947442e-01f, -6.24796808e-01f, 9.25067604e-01f, -3.38455230e-01f, -4.89959687e-01f, -3.19473475e-01f, -3.35404605e-01f, -2.16273889e-01f, -4.40598965e-01f, -2.36157805e-01f,
  -7.10602343e-01f, -6.05484188e-01f, -6.31136522e-02f, 2.38036942e-02f, 1.48252368e-01f, 3.45092684e-01f, 6.04962349e-01f, 8.05314362e-01f, 6.58034563e-01f, 1.17697127e-01f,
  -3.78339916e-01f, 2.23475963e-01f, 2.81750262e-01f, 2.11520955e-01f, -9.79601145e-02f, -1.02545723e-01f, 2.05048308e-01f, -5.28913774e-02f, -2.81942934e-01f, 1.42732605e-01f,
  6.16366923e-01f, -3.44426990e-01f, 2.43390594e-02f, -3.21081161e-01f, -1.03242517e-01f, 7.14289472e-02f, 5.90474941e-02f, 1.37124300e-01f, -2.36567110e-01f, -4.89977859e-02f,
  -2.69166559e-01f, -1.71361387e-01f, -5.02575003e-02f, -1.36937564e-02f, -2.39950977e-02f, 7.10265040e-02f, 1.14943042e-01f, 1.78441375e-01f, 1.68152060e-02f, -4.16141152e-02f,
  -3.20550114e-01f, -1.78726479e-01f, -3.12879984e-03f, -6.35100901e-02f, -1.29783362e-01f, -2.38427907e-01f, -8.61921608e-02f, -8.29564780e-02f, -2.79156659e-02f, 2.18447357e-01f,
  1.24636054e-01f, 1.04765140e-01f, 6.26473054e-02f, 7.87823051e-02f, -2.84081008e-02f, -8.66313428e-02f, -3.03663816e-02f, -2.00053994e-02f, 1.06116440e-02f, -1.18671590e-02f,
  -1.36453271e-01f, -3.78667638e-02f, 1.12655394e-01f, -1.01655819e-01f, 1.66820437e-02f, -9.33084637e-02f, 7.96838552e-02f, 2.00686548e-02f, -7.27240518e-02f, -9.05863941e-02f,
  -7.74526447e-02f, -5.08280471e-02f, -8.21105242e-02f, 1.62964478e-01f, -2.21470356e-01f, 3.32917236e-02f, -8.06863606e-02f, -1.95053324e-01f, 8.28080550e-02f, -8.62731114e-02f,
  6.39659986e-02f, -3.16378593e-01f, 8.05042163e-02f, -7.27786357e-03f, -7.34749213e-02f, -1.75626099e-01f, -9.26055610e-02f, -1.25352949e-01f, -1.64675042e-01f, 1.08701140e-01f,
  -1.07469738e-01f, 1.71728104e-01f, 9.03142914e-02f, 3.40396836e-02f, 1.13550164e-01f, 6.78188226e-04f, -2.66273499e-01f, -4.46299724e-02f, -4.48847264e-02f, -1.04632340e-02f,
  -2.36181151e-02f, 5.35551719e-02f, 9.89487097e-02f, -1.31790061e-02f, 7.12092640e-03f, 3.19673829e-02f, 2.83757627e-01f, 1.47279844e-01f, 1.90160066e-01f, 1.51587591e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.71431828e-01f, 9.19130981e-01f, 9.02702749e-01f, 8.12182367e-01f, 1.30743369e-01f, 9.55631971e-01f, 1.36513233e+00f, 6.40913308e-01f, 9.70289230e-01f, 8.77874136e-01f,
  1.05478632e+00f, 1.41185319e+00f, 6.00141466e-01f, 1.41638792e+00f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  5.55534028e-02f, -5.09135008e-01f, -4.42025252e-03f, -8.88286710e-01f, 1.39772119e-02f, 2.00232595e-01f, 1.50611430e-01f, 1.41036242e-01f, 1.90604955e-03f, -7.25316167e-01f,
  -1.21525554e-02f, -3.49150598e-01f, 7.54845049e-03f, -5.66125810e-01f, 3.10143270e-02f, -3.99224460e-01f, -6.47962153e-01f, 1.15951002e-01f, -6.44017518e-01f, 1.58459872e-01f,
  -2.94409841e-01f, 4.14822936e-01f, -2.88955510e-01f, -7.49875069e-01f, 3.51750478e-02f, -5.81285417e-01f, -1.87457979e-01f, 1.63178265e-01f, -5.16323507e-01f, -7.24097669e-01f,
  1.16439126e-01f, -6.62489310e-02f, -7.28280962e-01f, -3.24349664e-02f, 1.01167865e-01f, 2.88477689e-01f, 1.02783538e-01f, -4.11864929e-02f, -2.76165873e-01f, 3.85988444e-01f,
  4.96678427e-02f, -1.10155009e-01f, -3.95879559e-02f, 2.38314793e-01f, -1.54324964e-01f, 1.85068503e-01f, -8.63424987e-02f, -6.51649609e-02f, -2.72046089e-01f, 2.07084998e-01f,
  2.68565148e-01f, 4.33235317e-01f, -4.73597974e-01f, 1.74240157e-01f, -4.04969364e-01f, 1.87283680e-01f, -1.00986052e+00f, -6.67499900e-01f, -4.39340562e-01f, 4.13641542e-01f,
  -9.38448370e-01f, -4.18963075e-01f, -6.00796267e-02f, -1.38101196e+00f, -4.38016891e-01f, -2.34029695e-01f, 1.39593733e-02f, 3.37675214e-02f, -5.13886750e-01f, -3.21361810e-01f,
  -4.14660983e-02f, 6.53563365e-02f, -1.09527357e-01f, 1.12381235e-01f, 2.07546398e-01f, 1.80389166e-01f, 1.04040921e-01f, 1.43423021e-01f, 1.64903998e-01f, 2.43237302e-01f,
  1.03487566e-01f, 4.05395143e-02f, 3.02199394e-01f, -5.97096793e-02f, 1.41540945e-01f, -4.56161976e-01f, 5.20441383e-02f, 5.04854731e-02f, 8.29063803e-02f, -4.78792936e-01f,
  2.41369642e-02f, 6.20840304e-02f, -2.78814048e-01f, -1.10154122e-01f, 2.15977341e-01f, -2.29897887e-01f, -4.00778741e-01f, 3.65239412e-01f, -1.06212527e-01f, -1.05485976e-01f,
  -6.35593235e-02f, 1.18813053e-01f, -3.51364732e-01f, -3.46353084e-01f, -1.01284735e-01f, 2.96231836e-01f, 1.15796484e-01f, -1.76128834e-01f, 6.77293763e-02f, -1.28731102e-01f,
  -4.02926236e-01f, 1.76090479e-01f, 2.44840365e-02f, 3.18698585e-01f, 1.00792837e+00f, 1.03348827e+00f, -1.04370713e+00f, 4.58538905e-02f, -2.92127654e-02f, -1.43210578e+00f,
  -1.90571487e+00f, 1.22393318e-01f, -6.50493801e-01f, -7.14860111e-02f, 3.55890691e-01f, 1.44491971e-01f, -3.59559149e-01f, -9.99010742e-01f, 1.71572820e-03f, 5.70359640e-02f,
  8.26148465e-02f, 4.07778546e-02f, 2.99088627e-01f, 1.06440715e-01f, -6.42778352e-02f, 1.05039112e-01f, 1.25451431e-01f, 2.21086755e-01f, -1.38406837e-02f, 1.99324489e-02f,
  2.33524412e-01f, -3.36958796e-01f, 1.66105211e-01f, 2.38145828e-01f, -6.50960729e-02f, -2.02262960e-03f, -1.15551449e-01f, 4.02031168e-02f, 8.69760811e-02f, 2.32651964e-01f,
  1.83881298e-01f, 2.16087818e-01f, -9.82484408e-03f, -4.31942761e-01f, -4.57056046e-01f, 2.87128776e-01f, -4.51504022e-01f, 5.89141771e-02f, 1.14319004e-01f, 1.28295675e-01f,
  -1.62740424e-01f, 1.46692723e-01f, 2.68425681e-02f, -3.83817047e-01f, 2.47169241e-01f, -1.95207730e-01f, -4.35243458e-01f, 1.55973285e-01f, -8.38976875e-02f, -1.23831585e-01f,
  -2.56767780e-01f, -2.72720218e-01f, 5.28094292e-01f, -3.35262358e-01f, -3.11491549e-01f, 4.49871093e-01f, -7.53734708e-02f, 1.28329173e-01f, -2.92588025e-01f, 3.29639167e-01f,
  -1.37000251e+00f, 6.90706253e-01f, -1.01941419e+00f, 7.63922989e-01f, -1.07910621e+00f, -2.45074660e-01f, 7.07012236e-01f, -1.41848660e+00f, -8.66051763e-02f, -8.41985285e-01f,
  -4.48141068e-01f, 6.25899255e-01f, -1.35166690e-01f, 4.37471449e-01f, 1.06607862e-01f, -1.55119553e-01f, 1.68255016e-01f, -1.57841861e-01f, -1.19477764e-01f, -2.16850251e-01f,
  -1.57969847e-01f, -8.12250614e-01f, -4.88706350e-01f, -2.81565249e-01f, 1.54290348e-01f, 2.18017921e-01f, -4.32407856e-01f, -1.84336230e-01f, 3.96039665e-01f, 1.84350401e-01f,
  1.95741385e-01f, -1.63664907e-01f, 5.40374629e-02f, 1.18784595e-03f, -5.43194711e-02f, -4.91372973e-01f, -2.15216279e-01f, 5.47957242e-01f, 3.75542268e-02f, 3.69900651e-02f,
  -4.47452098e-01f, 1.33593947e-01f, -2.11982220e-01f, 1.22720990e-02f, 4.17209625e-01f, -4.15002555e-01f, 4.84583415e-02f, 2.54242182e-01f, 3.32408547e-01f, 2.29288414e-01f,
  -6.92636818e-02f, 2.74398357e-01f, -7.95044377e-02f, -3.36788446e-01f, -1.12553537e-02f, -1.56622857e-01f, 7.05673695e-02f, 1.59076512e-01f, -1.07364595e-01f, -1.36160910e-01f,
  -9.50066671e-02f, -2.31899843e-01f, -7.16062129e-01f, 1.06534839e-01f, 3.66688043e-01f, -7.41074264e-01f, -6.84737921e-01f, 8.87113631e-01f, 8.46997023e-01f, -5.55148840e-01f,
  -1.46200609e+00f, -8.12897861e-01f, -1.17890048e+00f, 8.14813137e-01f, -6.91902995e-01f, -7.47197807e-01f, 2.66767442e-01f, 3.18136066e-01f, -4.07312393e-01f, 3.41490686e-01f,
  -1.01663908e-02f, -6.36879122e-03f, 1.61906797e-02f, -1.47416905e-01f, 9.94016975e-02f, 2.66637355e-01f, -1.02381095e-01f, -1.00852340e-01f, -1.52092859e-01f, 5.82195399e-03f,
  -1.99064180e-01f, -1.76640183e-01f, 1.29479557e-01f, -8.38771313e-02f, 5.70373833e-02f, -9.46195871e-02f, -2.65370399e-01f, -3.51836056e-01f, -6.59871623e-02f, 3.02777559e-01f,
  -6.66103978e-03f, 9.32314321e-02f, 8.18455294e-02f, 7.15799779e-02f, -1.46076813e-01f, 2.72558868e-01f, -2.50430286e-01f, 1.76849335e-01f, 3.57375771e-01f, 1.59344018e-01f,
  2.77293622e-01f, -8.09539557e-02f, -7.71913901e-02f, -2.44524181e-02f, 3.96167859e-02f, -9.49389637e-02f, -1.68917045e-01f, -7.79261738e-02f, -2.99506206e-02f, 8.71100128e-02f,
  1.05665885e-01f, 1.02844797e-01f, 2.68872380e-01f, -1.34013474e-01f, 2.71365372e-03f, 1.68536574e-01f, -7.35039294e-01f, -1.95699617e-01f, 6.59099519e-01f, 3.06034759e-02f,
  1.61155537e-01f, -2.27412060e-01f, 3.43077779e-01f, 2.52750397e-01f, 1.07642567e+00f, -1.83412922e-03f, -1.99718162e-01f, -1.01140237e+00f, -1.26321042e+00f, -7.50055373e-01f,
  1.67438224e-01f, -2.01224741e-02f, 7.84935728e-02f, 1.47251636e-01f, 3.32077682e-01f, -2.36805454e-02f, 2.78404057e-01f, 1.89211652e-01f, 1.71037912e-01f, 1.04827031e-01f,
  4.75784987e-02f, 6.27145618e-02f, -2.43304460e-03f, 1.41200438e-01f, 7.62630403e-02f, 1.37774572e-01f, 2.06412092e-01f, 1.46287218e-01f, -8.44725072e-02f, 2.56191909e-01f,
  2.33561918e-01f, 2.10305780e-01f, 3.91395539e-02f, 1.38696536e-01f, 2.15170115e-01f, -4.55480963e-01f, -4.79962856e-01f, 1.15286700e-01f, 2.19820365e-01f, -1.97772026e-01f,
  9.48387757e-02f, -1.51151836e-01f, -1.77094266e-01f, 1.07455090e-01f, -2.58114129e-01f, -5.74630545e-03f, -3.48339617e-01f, 3.16823363e-01f, 3.03940743e-01f, -2.65086174e-01f,
  1.32695585e-01f, -4.16732430e-01f, -5.91261778e-04f, 3.38978440e-01f, 6.49895705e-03f, 1.89628020e-01f, -3.04937422e-01f, -2.80024260e-01f, -2.79980183e-01f, -4.37687337e-02f,
  -3.54856700e-01f, -1.18411994e+00f, 3.74190599e-01f, 1.76662058e-01f, 6.25827909e-02f, -6.72246635e-01f, -1.05276847e+00f, -1.69066608e-01f, -1.45649469e+00f, 1.09804821e+00f,
  4.68641698e-01f, -9.68331397e-01f, 2.14667484e-01f, -5.57978988e-01f, -6.76052496e-02f, 1.08975701e-01f, -3.29534970e-02f, 2.56828815e-01f, -4.86323297e-01f, 6.04622886e-02f,
  2.21216120e-02f, -9.87581462e-02f, -7.07664043e-02f, -2.54760355e-01f, 2.72676200e-01f, 1.49503201e-01f, 1.30540252e-01f, 1.37381062e-01f, -6.78992691e-03f, -5.26965261e-02f,
  -1.12340190e-01f, -1.57363787e-02f, -1.90893769e-01f, -2.12959602e-01f, 2.68820971e-01f, 1.63020656e-01f, 7.75349215e-02f, -1.20028377e-01f, -1.66993763e-03f, -4.69283968e-01f,
  2.84921415e-02f, -1.09857777e-02f, -1.88609809e-01f, 3.01205426e-01f, -8.36513266e-02f, 1.94366515e-01f, 4.03887838e-01f, 2.97774911e-01f, -2.36790646e-02f, 4.22807842e-01f,
  -8.58068541e-02f, -2.77731657e-01f, 2.14299455e-01f, -4.72089648e-01f, 4.21135753e-01f, 2.54118025e-01f, 3.51788513e-02f, -2.86522895e-01f, -8.41270164e-02f, -8.47145915e-03f,
  2.82300748e-02f, 6.38313890e-02f, 2.99767822e-01f, 1.91804484e-01f, -2.69094795e-01f, -6.47352576e-01f, -8.85096729e-01f, -7.84970969e-02f, -2.69824918e-03f, -1.69854367e+00f,
  6.94534034e-02f, -9.37997043e-01f, 5.52798390e-01f, -1.13684559e+00f, 5.34775376e-01f, -1.20643318e+00f, 6.90128088e-01f, 5.56427062e-01f, -2.19443023e-01f, -1.61796391e-01f,
  -1.13724396e-01f, 1.27394155e-01f, -4.48833913e-01f, -7.72275776e-02f, -1.35097310e-01f, -2.63681680e-01f, -2.09790751e-01f, 1.21084834e-02f, -2.45170705e-02f, -2.50445932e-01f,
  -2.46925335e-02f, -8.36739615e-02f, -1.45394951e-01f, -5.19468402e-03f, -1.53847426e-01f, -4.27963659e-02f, 1.31352376e-02f, -4.79730703e-02f, -1.08586259e-01f, -4.99630272e-02f,
  -3.93152758e-02f, 1.14145596e-03f, -1.40878364e-01f, 3.45282674e-01f, 1.51968837e-01f, -2.80222110e-02f, -9.53030586e-02f, 2.35222310e-01f, -1.33255452e-01f, 2.42862664e-02f,
  3.42580199e-01f, -1.13031328e-01f, 1.10166773e-01f, 1.76904485e-01f, -1.68431774e-02f, -3.54505144e-02f, -4.57892232e-02f, -3.05124000e-03f, 2.76758671e-02f, -1.57330647e-01f,
  2.82119419e-02f, 1.27640992e-01f, -1.27007470e-01f, -1.17073074e-01f, 1.51072726e-01f, 6.45133257e-02f, -2.69138902e-01f, -2.23185450e-01f, -5.64334631e-01f, -9.19059217e-01f,
  -5.04917204e-01f, -6.22533560e-01f, 2.16370881e-01f, 9.09419537e-01f, 6.33848488e-01f, 5.08200645e-01f, -1.03864026e+00f, -4.89559203e-01f, -7.04761624e-01f, -9.77116346e-01f,
  8.90916809e-02f, -5.42416036e-01f, 3.66165131e-01f, 3.21552575e-01f, 1.43976852e-01f, 5.93444966e-02f, 6.08237684e-02f, -5.72891571e-02f, -5.46083860e-02f, -3.67741883e-01f,
  -8.19269195e-02f, 4.21004623e-01f, -1.75541621e-02f, 1.34528220e-01f, -5.41867495e-01f, 4.31092352e-01f, 4.26758081e-02f, -1.88502729e-01f, 2.48243093e-01f, 1.69186652e-01f,
  3.95194322e-01f, -3.73411655e-01f, -1.28027037e-01f, -1.34873465e-01f, 4.55318205e-02f, 1.90821916e-01f, -4.38296907e-02f, 1.47281289e-01f, -1.73074603e-01f, 5.56880496e-02f,
  4.96770203e-01f, -2.19591156e-01f, 1.33000404e-01f, -1.82987705e-01f, -3.18042666e-01f, -4.22820598e-01f, 3.52502614e-01f, -2.97830284e-01f, -2.57603854e-01f, -2.47274622e-01f,
  -8.69278386e-02f, -3.30535293e-01f, 2.50179261e-01f, 1.57194622e-02f, 4.47868509e-03f, 7.90428668e-02f, -4.67628270e-01f, -3.05900544e-01f, -4.36533749e-01f, 7.28353187e-02f,
  4.89114136e-01f, -3.03062737e-01f, -4.21775162e-01f, -6.30285501e-01f, -1.65301430e+00f, -1.27638027e-01f, -6.08097374e-01f, -6.25348806e-01f, 3.01670164e-01f, 1.93089500e-01f,
  -8.95713270e-01f, -8.76381934e-01f, -1.91133767e-01f, 6.28213584e-01f, -5.10443114e-02f, 9.91985977e-01f, 2.80025989e-01f, -2.84062654e-01f, 1.57382131e-01f, 7.38279670e-02f,
  4.02497202e-01f, -1.20249115e-01f, -6.74504936e-02f, 7.13496208e-02f, -1.21959627e-01f, -5.09964168e-01f, -4.01317000e-01f, 1.09778658e-01f, -4.67110544e-01f, 1.98035955e-01f,
  1.54972285e-01f, 1.23949023e-02f, 1.42089009e-01f, -1.42207846e-01f, -1.33816540e-01f, 2.10907087e-01f, -6.34508952e-02f, -1.27637029e-01f, 1.23688458e-02f, 1.45691827e-01f,
  -2.54115552e-01f, 5.99723995e-01f, 5.79112947e-01f, -5.72234467e-02f, 6.84450448e-01f, 1.43141717e-01f, -3.12682182e-01f, 3.30067635e-01f, 3.63879442e-01f, 3.89179736e-01f,
  -3.95025432e-01f, -6.13342285e-01f, -3.66664320e-01f, 5.28118670e-01f, -1.06244035e-01f, 7.57100701e-01f, -5.78882813e-01f, -1.63403869e-01f, -1.48090392e-01f, -2.89383739e-01f,
  -1.72833890e-01f, 5.83777800e-02f, 5.22946715e-01f, 2.68849125e-03f, 3.79619598e-01f, 3.24448407e-01f, 8.09653103e-01f, -1.37349677e+00f, -6.88674390e-01f, -4.70280141e-01f,
  2.23794524e-02f, 4.19402331e-01f, -1.28285623e+00f, -5.84505022e-01f, 7.16014743e-01f, 5.58665767e-02f, -6.03020906e-01f, -3.24550807e-01f, 1.87962204e-01f, -4.58983243e-01f,
  -3.72070581e-01f, 2.71427065e-01f, -7.56288245e-02f, 3.99515033e-02f, -8.63631517e-02f, 1.99286506e-01f, -1.14621386e-01f, 4.69534621e-02f, 5.87004051e-02f, 3.01271021e-01f,
  -8.22067112e-02f, 2.99426764e-01f, 2.54457980e-01f, -3.82894933e-01f, 3.69262904e-01f, 2.53892660e-01f, 1.22488983e-01f, -1.65986240e-01f, 1.85856476e-01f, 6.80371150e-02f,
  3.70342587e-03f, 3.09924483e-01f, 1.40772074e-01f, 2.79769778e-01f, 1.62957236e-01f, 5.96662462e-01f, 1.21640012e-01f, 3.31616759e-01f, 5.90941310e-01f, -1.50247276e-01f,
  -1.42358631e-01f, -1.38027385e-01f, 3.89984965e-01f, 1.18134983e-01f, 1.72915578e-01f, -3.41097742e-01f, -2.84870982e-01f, -3.67138952e-01f, 5.04608810e-01f, 5.37304163e-01f,
  -1.57604203e-01f, 3.67552340e-01f, 1.33069769e-01f, 1.56654164e-01f, 3.01314414e-01f, -3.15109253e-01f, 2.70424217e-01f, -1.25411302e-02f, -3.39729369e-01f, -2.96857566e-01f,
  -7.75963962e-01f, 5.12525320e-01f, 3.02274734e-01f, -6.51591778e-01f, -1.36025041e-01f, -6.78965032e-01f, -9.68606412e-01f, -2.59477161e-02f, -9.41349685e-01f, -1.20798337e+00f,
  -8.03850293e-01f, -3.95639271e-01f, 3.64399366e-02f, 8.33826721e-01f, 9.91283655e-02f, -9.90705416e-02f, -2.44463217e-02f, -1.11295782e-01f, 8.78602266e-02f, 1.89536102e-02f,
  2.28420675e-01f, 1.12639412e-01f, 2.60429204e-01f, -7.29856938e-02f, 8.31736401e-02f, -4.02750336e-02f, 1.31310999e-01f, -2.12531969e-01f, -2.24000812e-01f, -2.63462011e-02f,
  -2.88019568e-01f, 6.59018904e-02f, -7.06055388e-02f, -4.68689092e-02f, -2.05337673e-01f, 5.79985306e-02f, 1.43775046e-02f, 6.91430047e-02f, 7.98361823e-02f, 1.44771365e-02f,
  1.74824670e-01f, -1.05298884e-01f, -3.41562182e-02f, 1.51549384e-01f, -8.50018784e-02f, -1.93120256e-01f, -4.29796726e-01f, 2.78798472e-02f, -8.55573639e-02f, 3.23013753e-01f,
  3.71523589e-01f, 1.83388934e-01f, 2.74974018e-01f, -2.17717409e-01f, 2.16124579e-01f, 2.73845911e-01f, -7.88910016e-02f, -1.45447433e-01f, 1.26048937e-01f, 4.13606167e-01f,
  2.48179018e-01f, -3.86235625e-01f, 2.33376712e-01f, -1.08143024e-01f, -5.84514320e-01f, -3.99214029e-01f, -3.70122522e-01f, 4.15827990e-01f, 4.21013176e-01f, -2.90022381e-02f,
  1.18966269e+00f, -1.12926114e+00f, -4.14187044e-01f, -7.32218623e-01f, 5.17358929e-02f, 8.27422023e-01f, -3.20771933e-01f, -8.02540481e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  9.35975015e-01f, 3.59640092e-01f, 3.86612803e-01f, -6.61292970e-01f, -1.35909274e-01f, 3.98285463e-02f, -3.31633151e-01f, -2.76664924e-02f, -1.71258062e-01f, 2.09652066e-01f,
  -6.93357110e-01f, -5.13808131e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    