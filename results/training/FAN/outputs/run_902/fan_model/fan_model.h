/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.45716536e-01f, -1.63969874e-01f, 1.52254719e-02f, 5.31998230e-03f, -2.76811212e-01f, -7.06346631e-02f, -5.84857762e-02f, -5.28719984e-02f, -7.15209693e-02f, -2.71907821e-02f,
  -1.61058173e-01f, -1.26686782e-01f, -2.92280829e-03f, -2.08474919e-01f, 4.79480401e-02f, 2.45526452e-02f, -9.70555022e-02f, 1.04150355e-01f, 4.94164452e-02f, -3.06171197e-02f,
  -9.46300328e-02f, 1.26131505e-01f, 1.78214729e-01f, 7.70626292e-02f, 6.29536584e-02f, -1.75057665e-01f, -2.13400852e-02f, 1.87302697e-02f, -9.93275270e-02f, -2.32493710e-02f,
  -5.17029874e-02f, 8.73013809e-02f, -4.45920229e-02f, 1.17197884e-02f, -1.48203656e-01f, 1.22072451e-01f, 5.47454059e-02f, 4.99542244e-02f, 1.04134041e-03f, 5.58836497e-02f,
  -9.46025997e-02f, -2.01838072e-02f, 2.32069450e-03f, -3.80754694e-02f, 3.70715559e-02f, -3.32257035e-03f, 7.74519891e-02f, 9.45487395e-02f, 1.01687193e-01f, 3.98622453e-02f,
  -9.70996469e-02f, -9.57076102e-02f, -5.28084114e-02f, -4.50502746e-02f, 1.39915735e-01f, -9.72964540e-02f, -5.53867370e-02f, 1.15171764e-02f, -4.11466807e-02f, 7.12642595e-02f,
  -4.13402133e-02f, -3.51181924e-02f, 3.02874800e-02f, 1.25788515e-02f, 8.80233664e-03f, 7.39021525e-02f, -4.66128178e-02f, -3.87625769e-02f, -1.37096308e-02f, 2.87687462e-02f,
  -5.03315702e-02f, -2.76602898e-02f, -6.59868270e-02f, -2.21661609e-02f, 1.41748879e-02f, -4.95190285e-02f, -1.47250788e-02f, -5.33077158e-02f, 3.71943861e-02f, 2.23838091e-02f,
  4.98258732e-02f, 3.10058910e-02f, -5.67285456e-02f, 3.39603014e-02f, 2.55652633e-03f, -4.95806076e-02f, -1.41986934e-02f, 6.56088674e-03f, -4.88081835e-02f, -1.55642731e-02f,
  -9.81050357e-03f, -1.08508691e-01f, 1.92260873e-02f, -5.32218907e-03f, 1.42484894e-02f, -5.78648597e-03f, 9.53415502e-03f, 1.02870981e-03f, 1.95155805e-03f, 2.77155358e-02f,
  9.98724531e-03f, 6.00207932e-02f, -2.41758325e-03f, 2.01921002e-03f, -7.24807708e-03f, 1.55430045e-02f, -4.30553593e-02f, 1.56042632e-02f, 1.53320754e-04f, -4.00932096e-02f,
  6.20980039e-02f, 1.96708161e-02f, 1.66916139e-02f, -1.02922097e-02f, 2.27925144e-02f, -2.78468430e-02f, -3.67002226e-02f, -2.10011285e-03f, 2.51213200e-02f, 9.12676528e-02f,
  -4.77522939e-01f, 5.62583655e-03f, 6.11830652e-02f, -1.68940678e-01f, -6.99516758e-02f, 1.57782927e-01f, -8.96641165e-02f, 6.25044033e-02f, -4.67576683e-02f, -1.16215676e-01f,
  1.02383897e-01f, 2.75343210e-02f, 1.15298122e-01f, 7.63855800e-02f, 1.21562533e-01f, -1.56418681e-01f, -2.43561596e-01f, -7.66869560e-02f, 8.25495794e-02f, 1.08451262e-01f,
  -9.66095850e-02f, -1.83713913e-01f, -2.27346301e-01f, 5.02912588e-02f, -9.97195370e-04f, 5.96525930e-02f, -2.47192048e-02f, -1.92203134e-01f, 8.65123719e-02f, -2.42807716e-01f,
  1.30071566e-01f, -3.65590467e-03f, 6.18812144e-02f, -8.00881311e-02f, 6.82715280e-03f, 1.17199784e-02f, 1.58799731e-03f, 5.47858141e-02f, -1.05977161e-02f, 4.16801348e-02f,
  -1.20697901e-01f, -1.07405186e-01f, -4.50337380e-02f, -6.07169047e-03f, -5.18620275e-02f, -7.55671784e-02f, -9.80375186e-02f, 5.60399704e-03f, -3.54504609e-03f, 8.35034326e-02f,
  -5.19088097e-02f, -1.41089812e-01f, 7.48362532e-03f, 5.49209043e-02f, 1.59098431e-01f, -3.07078417e-02f, 8.43027681e-02f, 1.10721523e-02f, 1.26045689e-01f, -8.76068443e-05f,
  -3.44838575e-02f, 4.02581766e-02f, 8.61236826e-03f, -6.43347949e-02f, -7.60679841e-02f, 5.49323186e-02f, -1.73483584e-02f, -2.04436784e-03f, 5.33590540e-02f, -7.76949376e-02f,
  -1.82855614e-02f, -4.63500358e-02f, 3.40906568e-02f, -3.40649951e-03f, 8.13771561e-02f, -1.04273863e-01f, -3.87551486e-02f, 4.41863388e-03f, 2.37285737e-02f, -4.63629626e-02f,
  1.13000656e-02f, 5.99247329e-02f, -1.34149253e-01f, 1.31081864e-01f, -1.33377612e-02f, 9.79959406e-03f, -4.51416634e-02f, -1.51606584e-02f, 1.19277760e-02f, -3.79796810e-02f,
  -1.18861198e-01f, 1.86548233e-01f, -1.14306785e-01f, -2.91282907e-02f, -5.09345308e-02f, -1.34810572e-02f, 1.46059366e-02f, 1.15388278e-02f, -3.89762446e-02f, 2.24097688e-02f,
  -2.57587247e-02f, -1.56373177e-02f, -3.38860005e-02f, 4.71120737e-02f, 5.31350560e-02f, -3.52501422e-02f, -1.24481983e-01f, -3.97272520e-02f, 8.03994536e-02f, -1.85621828e-02f,
  -2.49426197e-02f, -8.56845230e-02f, -1.13227569e-01f, 3.00281905e-02f, -1.52113531e-02f, 6.87893853e-03f, 3.63056287e-02f, 4.28946353e-02f, -7.56668905e-03f, -1.08450525e-01f,
  -9.17677507e-02f, 3.82987522e-02f, 4.36877646e-02f, -8.61481428e-02f, -5.87673672e-02f, -1.17832780e-01f, -3.36810470e-01f, -7.91010410e-02f, 2.26629581e-02f, -1.97639577e-02f,
  -1.04954824e-01f, 6.60480186e-03f, 8.83439407e-02f, 1.85921580e-01f, -2.01447550e-02f, -7.75490180e-02f, 2.73740944e-03f, 2.16760337e-01f, 9.83247906e-02f, 7.71997347e-02f,
  7.60546774e-02f, 1.42256111e-01f, 2.65141577e-01f, 1.23038203e-01f, 3.82572152e-02f, 5.00587262e-02f, 6.40721172e-02f, 8.18074942e-02f, 2.51442373e-01f, 1.58451393e-01f,
  -3.27097960e-02f, 5.15523106e-02f, 2.95796562e-02f, 8.14813003e-02f, 8.01110566e-02f, -2.68967766e-02f, 4.24903706e-02f, 1.02476433e-01f, -1.30653838e-02f, 3.23522016e-02f,
  3.83633897e-02f, 1.07047021e-01f, -7.38362372e-02f, 8.17894042e-02f, -6.28590807e-02f, 9.67776626e-02f, 6.62894696e-02f, 1.62930548e-01f, 1.36150774e-02f, 1.21426526e-02f,
  8.29948559e-02f, 4.97217067e-02f, -5.13203405e-02f, 4.97387908e-02f, 2.22763941e-02f, 1.17082231e-01f, -6.46553710e-02f, 1.40605122e-01f, 6.56408593e-02f, -3.25748995e-02f,
  5.38650379e-02f, 1.94707587e-02f, -2.35502403e-02f, -6.10003024e-02f, 4.81239818e-02f, -6.35614693e-02f, 8.55953395e-02f, -3.39218602e-02f, 2.49097031e-02f, -5.07229976e-02f,
  1.69614889e-02f, -1.23608775e-01f, -8.28705356e-03f, -9.51221809e-02f, 6.28948119e-03f, 1.96378697e-02f, 4.30517532e-02f, -2.63545793e-02f, 2.34144845e-05f, 2.86437515e-02f,
  5.41070625e-02f, 1.94748957e-02f, 3.74401025e-02f, -1.78534202e-02f, 1.20027520e-01f, 2.85510495e-02f, -5.81146777e-02f, 4.21112031e-02f, 3.04666292e-02f, 9.39239264e-02f,
  -2.14191467e-01f, 8.41116011e-02f, -8.97562429e-02f, 4.07831594e-02f, -3.16952914e-02f, 1.17243446e-01f, -5.37981167e-02f, 3.80154289e-02f, -8.15462787e-03f, -1.06023690e-02f,
  -9.63552669e-02f, -3.39173377e-02f, 1.25515079e-02f, 6.28320724e-02f, -6.51668757e-02f, -8.63791928e-02f, -1.27295777e-01f, -7.34015601e-03f, -4.31463346e-02f, -1.32469647e-02f,
  -5.73235936e-02f, -1.21589601e-01f, -1.30307019e-01f, -1.68373570e-01f, 2.84052510e-02f, -1.17237851e-01f, -3.69614549e-02f, 9.85663850e-03f, -1.36039779e-01f, -2.91710019e-01f,
  -3.02383192e-02f, 2.12969501e-02f, 2.45283917e-02f, -1.01907305e-01f, 1.27700076e-01f, 8.81226808e-02f, 9.12398398e-02f, -4.36109938e-02f, -1.36979192e-01f, 2.69870572e-02f,
  -7.39080925e-03f, -1.57854590e-03f, 1.56540296e-03f, 4.06112708e-02f, 6.05752915e-02f, -2.62936275e-03f, -3.66090052e-03f, 7.08338171e-02f, 8.00038055e-02f, -5.30656315e-02f,
  -2.57696328e-03f, -2.52205580e-02f, 4.67549637e-03f, -1.42476827e-01f, 3.40116955e-02f, -3.17916051e-02f, 8.49585831e-02f, -9.10438318e-03f, 6.29894733e-02f, 1.33576304e-01f,
  1.46888137e-01f, 5.10407202e-02f, 1.59223191e-02f, 1.54858641e-02f, 7.36800060e-02f, 3.64091657e-02f, 8.56375471e-02f, 6.19226620e-02f, -6.82435092e-03f, 3.09974533e-02f,
  5.54560535e-02f, 2.13868916e-02f, 4.90447916e-02f, -7.03128725e-02f, 1.56302117e-02f, -2.52642948e-02f, -1.97510552e-02f, 4.37064543e-02f, 2.06600055e-02f, -4.31860201e-02f,
  7.74198249e-02f, 5.61897526e-04f, -2.05793381e-02f, 5.68051077e-02f, -1.08875912e-02f, 9.85875726e-03f, -3.22454013e-02f, -5.50448336e-02f, 1.15913846e-01f, -1.73573375e-01f,
  -5.27185760e-02f, 8.30951929e-02f, 5.04555646e-03f, -4.21583094e-02f, 1.08172670e-02f, 2.01854445e-02f, -8.12572688e-02f, -4.58395183e-02f, -4.89314720e-02f, -4.73411717e-02f,
  -7.21892193e-02f, 3.50930057e-02f, -6.21324871e-03f, -6.90595433e-02f, 3.82403797e-03f, -3.39619583e-03f, 2.24509221e-02f, -2.38093771e-02f, 4.07605618e-02f, -1.72419436e-02f,
  2.54531857e-02f, -1.24109043e-02f, -1.30767543e-02f, 6.95429295e-02f, -1.85623635e-02f, 7.99588338e-02f, -3.86450067e-02f, 4.80296575e-02f, -2.92969588e-02f, 9.81686637e-02f,
  -2.38100111e-01f, 1.80973887e-01f, 9.52723697e-02f, 2.22957041e-02f, 6.68867305e-02f, 7.88725156e-04f, -5.09345345e-02f, -2.34306306e-02f, 6.09234087e-02f, -2.76469551e-02f,
  -3.04804537e-02f, 5.32268658e-02f, -5.02936989e-02f, 4.31064144e-02f, 4.64655319e-03f, -5.19286133e-02f, -5.17142825e-02f, 3.88819389e-02f, 6.49701878e-02f, -3.90390679e-02f,
  -6.31797165e-02f, -1.06693797e-01f, -1.21634156e-01f, -4.72953729e-02f, -1.16946902e-02f, 9.63910073e-02f, -6.13539554e-02f, -1.75877672e-03f, -4.72158156e-02f, -3.11466873e-01f,
  -2.73686610e-02f, 2.66990364e-01f, -1.00772791e-01f, 1.41277105e-01f, -9.47567225e-02f, -1.50620893e-01f, -5.18904068e-02f, -3.95977497e-02f, 2.71601807e-02f, 1.39869124e-01f,
  -4.62653004e-02f, 4.53540683e-02f, 1.86088979e-02f, -9.34681445e-02f, -1.28174335e-01f, 2.77887750e-02f, -3.33978273e-02f, -1.22172274e-01f, -2.48030081e-01f, -1.78181961e-01f,
  1.58506501e-02f, 2.31532417e-02f, 1.24767618e-02f, -4.25958075e-02f, 9.44631472e-02f, -1.30902737e-01f, -1.36915430e-01f, -7.92234689e-02f, -7.83814937e-02f, 1.63994934e-02f,
  -2.52812654e-01f, 1.07280403e-01f, -1.49833560e-01f, 4.00599875e-02f, -5.16216494e-02f, -6.47217855e-02f, -6.05517160e-03f, -6.75735548e-02f, 3.07456609e-02f, 4.28461209e-02f,
  3.48306932e-02f, -2.14270549e-03f, -5.43558598e-02f, -6.60610795e-02f, -4.42756414e-02f, 9.01009049e-03f, 5.83984191e-03f, -5.47497384e-02f, 3.29312235e-02f, 9.47929546e-02f,
  8.12769160e-02f, 4.79619093e-02f, -4.50058356e-02f, 3.11180558e-02f, 1.00027241e-01f, -9.88777429e-02f, -4.69665825e-02f, 2.01439522e-02f, -1.04271792e-01f, -2.87061539e-02f,
  5.53203076e-02f, -3.21762240e-03f, -2.72695068e-02f, 6.20223917e-02f, -4.56379242e-02f, 4.99235913e-02f, -1.23617556e-02f, -2.95350291e-02f, -1.77118089e-02f, 4.98303166e-03f,
  -1.77120678e-02f, 8.06675330e-02f, -7.22958967e-02f, -8.65503307e-03f, 5.81158176e-02f, -1.26233762e-02f, -3.37504013e-03f, 7.07902163e-02f, 6.23332597e-02f, 2.35960050e-03f,
  -4.18775305e-02f, 4.81611025e-03f, -7.30044767e-02f, 2.01257523e-02f, 1.59798078e-02f, 6.52415305e-02f, 1.20226638e-02f, -1.87709294e-02f, -2.29464062e-02f, 4.02632030e-03f,
  -1.21830583e-01f, -1.01328403e-01f, -7.78063908e-02f, -1.29823148e-01f, -6.30383268e-02f, 4.02479209e-02f, -6.05372824e-02f, 2.32256129e-02f, 1.61534119e-02f, -4.11227010e-02f,
  -4.59497012e-02f, 1.24806250e-02f, -4.80370671e-02f, 4.07686047e-02f, 3.28508578e-02f, -3.77753042e-02f, 7.84298033e-02f, -9.47951674e-02f, -3.96518596e-02f, 1.63546726e-02f,
  7.50307739e-02f, -8.56848508e-02f, -9.51236486e-02f, -6.37467429e-02f, 8.89832247e-03f, -3.65435630e-02f, -2.36617148e-01f, -3.58235314e-02f, -2.82015711e-01f, -1.91281527e-01f,
  -2.17791438e-01f, 2.17820972e-01f, 5.89013658e-02f, -2.09593251e-02f, -4.76831244e-03f, 2.37760022e-02f, 1.28148615e-01f, -9.98595878e-02f, -7.80340135e-02f, 3.15870829e-02f,
  1.06590234e-01f, -7.57790655e-02f, -5.59343398e-03f, -1.00817576e-01f, -4.89051528e-02f, 1.21696807e-01f, 1.39260128e-01f, 4.46352139e-02f, -1.81065008e-01f, 2.51383130e-02f,
  8.72557759e-02f, -4.25862893e-02f, -2.46561244e-02f, -5.93481250e-02f, 7.88178965e-02f, -9.94889662e-02f, 1.15094408e-01f, 6.95838109e-02f, 1.50234386e-01f, 2.57769883e-01f,
  1.46799520e-01f, 1.46947592e-01f, -2.75409017e-02f, 9.42577198e-02f, -4.91112517e-03f, -8.58269483e-02f, -2.24531405e-02f, -3.97788770e-02f, -7.43419603e-02f, 4.08226997e-02f,
  -2.81846710e-02f, 3.49969603e-02f, -3.88817191e-02f, 1.60705373e-02f, -5.46984524e-02f, 5.03117777e-03f, -2.78743785e-02f, 1.17394388e-01f, -1.79072767e-02f, -3.66471261e-02f,
  1.22406550e-01f, 7.90378526e-02f, 2.70492453e-02f, 9.07275751e-02f, -5.60394619e-06f, 6.53167292e-02f, 1.24380052e-01f, 1.55141219e-01f, 5.35456240e-02f, 1.45601109e-01f,
  5.32480143e-03f, 1.62156411e-02f, -2.63412334e-02f, -1.29905893e-02f, -7.58663239e-03f, -5.67124411e-02f, 5.43998331e-02f, 8.59308522e-03f, -3.37446183e-02f, 6.89139636e-03f,
  4.90071587e-02f, 4.24516276e-02f, 1.81199331e-02f, 2.04320438e-02f, -3.18886265e-02f, -1.26338881e-02f, -1.73562020e-02f, 4.95418794e-02f, -5.87553382e-02f, -3.41473445e-02f,
  -2.68624201e-02f, 2.75843758e-02f, 3.65518257e-02f, -3.78181450e-02f, 4.14427556e-02f, -4.38470170e-02f, 1.43589042e-02f, 5.06547652e-02f, -6.40974119e-02f, -4.33387272e-02f,
  -5.19366786e-02f, -3.60080786e-02f, 5.47959618e-02f, 2.25760043e-02f, -2.65705120e-02f, -7.02888146e-02f, 4.97958548e-02f, -2.34592203e-02f, 5.19598555e-03f, 6.65079653e-02f,
  8.99102248e-04f, -1.59127593e-01f, 5.28861117e-03f, 5.52574918e-02f, 8.10178928e-03f, 2.02515889e-02f, -6.61857426e-02f, 1.38161210e-02f, 3.25665586e-02f, -2.28587799e-02f,
  -2.98383385e-02f, -1.16350405e-01f, -9.09352973e-02f, 1.46093043e-02f, 5.18038822e-03f, -7.83439800e-02f, -1.64625198e-02f, -1.01791874e-01f, -7.61532336e-02f, -1.12524733e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.09923740e-02f, 8.01478419e-03f, -5.24146147e-02f, 1.68526382e-03f, 1.33386925e-01f, -6.41451254e-02f, -4.88425493e-02f, -7.14422166e-02f, 2.19475199e-02f, 4.44563068e-02f,
  1.25280038e-01f, 1.76574379e-01f, 3.02981082e-02f, 1.29498884e-01f, 5.72541207e-02f, -2.12178342e-02f, -3.17365453e-02f, 8.24400410e-02f, -2.42109620e-03f, 8.81849602e-02f,
  1.25029266e-01f, 2.99568884e-02f, 1.16484590e-01f, 5.66341765e-02f, 4.29509468e-02f, 1.38735324e-01f, 1.09265551e-01f, 1.10083528e-01f, 9.71985385e-02f, 6.05162010e-02f,
  3.79399420e-03f, -7.13111553e-03f, 8.77324864e-02f, -2.27231886e-02f, 2.44022869e-02f, -8.26339945e-02f, 6.19409196e-02f, -7.87513256e-02f, 4.33886833e-02f, 5.54906279e-02f,
  1.09539479e-01f, 2.33064238e-02f, -6.54154420e-02f, 9.43063721e-02f, -7.10805282e-02f, 2.14735605e-02f, 7.48230964e-02f, -8.27972889e-02f, -3.06435488e-02f, -7.04396591e-02f,
  -1.72827952e-02f, -3.02047376e-02f, 2.61727534e-02f, 2.99698189e-02f, -5.89425564e-02f, 6.24249130e-02f, -5.61027154e-02f, -1.03332000e-02f, 2.71815006e-02f, 2.32986212e-02f,
  9.01795477e-02f, 6.94997758e-02f, 6.72771409e-02f, 9.24079344e-02f, 8.96705315e-02f, -7.40551502e-02f, 1.31634958e-02f, 7.21263094e-03f, 4.24309373e-02f, 3.45078148e-02f,
  -8.14094916e-02f, -1.91532094e-02f, -1.12999300e-03f, -5.11499448e-03f, 1.12409657e-02f, -6.57224879e-02f, 6.92900419e-02f, 9.68066230e-03f, -2.86163874e-02f, 2.43995804e-02f,
  -1.23916762e-02f, 3.04093435e-02f, 3.43976431e-02f, -9.78902634e-03f, 1.16940411e-02f, -5.38452305e-02f, 1.12203090e-02f, -7.88869709e-02f, -1.11592468e-02f, -1.96460374e-02f,
  -4.46376950e-02f, 6.98596537e-02f, 2.93415096e-02f, -2.60697324e-02f, -2.28062384e-02f, -7.06708953e-02f, 7.83098266e-02f, 1.54698370e-02f, 7.04631060e-02f, -2.58140769e-02f,
  4.00035493e-02f, -8.24572518e-02f, 7.25425780e-03f, -2.72398852e-02f, -7.07532242e-02f, -4.11214232e-02f, -5.16633317e-02f, 6.79677501e-02f, -1.80250444e-02f, -1.09732319e-02f,
  -1.01380758e-01f, -6.04903661e-02f, -5.37043735e-02f, -8.65930393e-02f, -4.61314544e-02f, 1.75202023e-02f, -1.45357233e-02f, -6.69643730e-02f, -5.88648655e-02f, -5.81465624e-02f,
  -7.09943622e-02f, 1.20635785e-01f, 2.86810305e-02f, 1.42374607e-02f, 1.05048634e-01f, -4.69964035e-02f, -2.31861472e-02f, -1.00613609e-02f, -4.98540774e-02f, 8.71615019e-03f,
  5.42980917e-02f, 4.79582213e-02f, -2.47805249e-02f, 7.89250340e-03f, 3.14792544e-02f, -4.03980911e-02f, 1.99659797e-03f, -5.24085015e-02f, -1.13873154e-01f, 4.87644486e-02f,
  3.58025767e-02f, -6.89843595e-02f, -8.11766088e-02f, 1.33980857e-02f, 2.36277655e-02f, -7.92147592e-02f, 6.17714003e-02f, 8.80701989e-02f, 8.78154188e-02f, 1.19060405e-01f,
  1.34381913e-02f, 1.23989195e-01f, -3.82586159e-02f, -7.30057433e-02f, -2.43368521e-02f, -2.73843035e-02f, -8.70845318e-02f, -4.17209305e-02f, 6.62596375e-02f, 8.04477781e-02f,
  -9.32652876e-03f, -2.97480803e-02f, 6.03953414e-02f, -2.36314349e-02f, 7.38658637e-05f, -7.30753765e-02f, 8.73625278e-03f, 2.99234502e-02f, 6.85166121e-02f, -9.65448562e-03f,
  -4.72383760e-03f, 1.72382053e-02f, 6.30211830e-02f, -1.18202642e-01f, -8.99775475e-02f, 4.39230800e-02f, -1.04306139e-01f, 8.57693702e-03f, -3.23481113e-02f, -5.67809120e-02f,
  -4.59726490e-02f, -8.00293609e-02f, -4.05621491e-02f, 2.04820763e-02f, -4.12453301e-02f, -6.62123561e-02f, -3.92826609e-02f, -6.05949052e-02f, -4.93998900e-02f, -1.80938933e-02f,
  -3.40185165e-02f, -3.65764201e-02f, -1.17274905e-02f, -1.06075751e-02f, 1.50632383e-02f, 1.35624912e-02f, -1.20300740e-01f, -3.32159502e-03f, 6.67950734e-02f, -2.85357311e-02f,
  -5.09112254e-02f, 3.19239460e-02f, -2.33840533e-02f, -9.17206779e-02f, -9.37465206e-02f, -3.91632803e-02f, -2.50331629e-02f, 9.97692812e-03f, 2.61371508e-02f, 8.95260647e-03f,
  -3.07152532e-02f, 1.43230617e-01f, -4.83485013e-02f, -7.33711645e-02f, -2.93191317e-02f, 4.80427481e-02f, 8.96977782e-02f, 1.21912907e-03f, 9.28410217e-02f, -2.58395560e-02f,
  -8.06095451e-02f, 5.37329763e-02f, -1.61666365e-03f, -8.93142521e-02f, 4.20646183e-02f, -2.08879746e-02f, -9.54974741e-02f, -1.05681941e-01f, -5.92906512e-02f, 6.10735640e-02f,
  4.55427617e-02f, -1.85539965e-02f, 1.04027642e-02f, -6.81827366e-02f, -2.84493733e-02f, -6.53441995e-02f, -6.09636605e-02f, -9.70799848e-02f, -4.55058143e-02f, -1.74132392e-01f,
  1.53474547e-02f, 3.11520100e-02f, -5.38244992e-02f, -2.42552459e-02f, 2.02967107e-01f, 9.67572257e-02f, -2.02399716e-02f, -5.96478470e-02f, 5.38392067e-02f, 5.62424101e-02f,
  5.87200113e-02f, -5.25108352e-02f, 7.75072053e-02f, 2.06184406e-02f, -2.64048646e-03f, -6.24415018e-02f, 1.15469145e-03f, 4.22053225e-02f, -1.86738789e-01f, -4.10094261e-02f,
  6.30335063e-02f, -6.10315986e-02f, -4.14971597e-02f, -7.04903007e-02f, 7.55040869e-02f, -6.97557032e-02f, -5.33065461e-02f, 9.36873779e-02f, 1.08306579e-01f, 1.12647206e-01f,
  1.20041696e-02f, 1.84397604e-02f, -1.47659212e-01f, 9.31754559e-02f, 1.37765199e-01f, 4.80935462e-02f, -2.06815377e-02f, -9.03929844e-02f, 9.16262120e-02f, 6.66377693e-02f,
  6.90988870e-03f, -4.25308943e-02f, 4.00677621e-02f, -2.80949995e-02f, -2.35519186e-02f, -3.58606018e-02f, -9.52583924e-02f, -1.35985181e-01f, -7.63619598e-03f, -7.65174553e-02f,
  2.50114035e-02f, 9.04145092e-02f, -4.49617952e-02f, -1.24493517e-01f, -8.48681778e-02f, 7.47166127e-02f, 4.90260720e-02f, 1.59537047e-02f, -6.86695054e-02f, -2.45318934e-03f,
  -1.01091363e-01f, -2.78565921e-02f, -5.35148084e-02f, 6.42829016e-02f, 9.49229971e-02f, 1.13027036e-01f, -5.84350005e-02f, 1.10271182e-02f, 5.20725474e-02f, -3.66122015e-02f,
  1.95983015e-02f, -1.55312307e-02f, -7.98881352e-02f, -9.14706066e-02f, 3.42748016e-02f, -1.03343032e-01f, -6.35605380e-02f, -1.24900311e-01f, -9.75126997e-02f, -1.58976410e-02f,
  7.62553141e-02f, -6.68386966e-02f, -9.10489932e-02f, 6.65031606e-03f, -2.51570381e-02f, -8.10472220e-02f, -7.74239004e-02f, -1.04865663e-01f, -1.43163502e-02f, 1.50928488e-02f,
  -1.03144214e-01f, 9.98530462e-02f, -7.40800276e-02f, -5.79339452e-02f, 1.09351166e-01f, 8.05093497e-02f, 1.00969851e-01f, -9.44338925e-03f, 2.39805412e-02f, -2.26705056e-02f,
  5.92309237e-02f, -4.42608907e-05f, 5.29214814e-02f, 2.95900851e-02f, -4.78509739e-02f, -3.60061452e-02f, 7.01567763e-03f, -1.28988951e-01f, -9.30767953e-02f, -1.49976285e-02f,
  -9.38977376e-02f, -1.14228301e-01f, 2.60687135e-02f, -3.48049179e-02f, -6.65488914e-02f, -2.71795690e-02f, -9.62999314e-02f, -8.20553899e-02f, -1.24127097e-01f, -1.00579776e-01f,
  1.96629897e-01f, -9.15452614e-02f, -3.17148641e-02f, -5.11597805e-02f, -1.24213845e-01f, -1.23051837e-01f, -9.49369147e-02f, 6.78182319e-02f, 9.72617269e-02f, -5.25424927e-02f,
  4.26008590e-02f, 4.70612906e-02f, 6.07750341e-02f, 2.89123482e-03f, 1.50592431e-01f, -2.36005485e-02f, -3.72921452e-02f, 3.62135842e-02f, 1.38855785e-01f, 8.18983242e-02f,
  2.76899170e-02f, -1.96842700e-02f, 1.59472153e-01f, 1.17091417e-01f, -5.38856834e-02f, 5.34181073e-02f, 4.47515883e-02f, 2.43082885e-02f, 1.40402850e-03f, -1.81023385e-02f,
  1.69876162e-02f, -2.83870031e-03f, 8.61948654e-02f, 7.40733519e-02f, -7.99182430e-02f, 1.08420044e-01f, -5.17093688e-02f, 5.27537875e-02f, 6.01228029e-02f, -7.08811404e-03f,
  7.10295737e-02f, 2.67753545e-02f, -6.35526404e-02f, -1.55505557e-02f, -4.63960990e-02f, 1.07484651e-04f, 7.37081096e-02f, 1.05763078e-01f, 1.02637924e-01f, 5.03694676e-02f,
  -5.99011332e-02f, -1.00402139e-01f, -8.47273543e-02f, -4.75827046e-03f, -2.68662944e-02f, 7.55581930e-02f, 6.43134408e-04f, 3.13376337e-02f, 9.80067551e-02f, 8.09954014e-03f,
  3.61660272e-02f, 3.53214778e-02f, 7.03386962e-02f, 4.30457368e-02f, -9.73438770e-02f, -6.10656701e-02f, 6.32031914e-03f, 2.52731480e-02f, 5.88294603e-02f, -6.97244937e-03f,
  -6.73167109e-02f, -8.36717058e-03f, 8.81983861e-02f, -5.30675314e-02f, -3.12028304e-02f, -1.03095062e-01f, -6.85380585e-03f, 3.57514024e-02f, -3.06225475e-02f, 8.31057280e-02f,
  -3.13535780e-02f, -8.04179534e-02f, -5.31938709e-02f, 1.90564487e-02f, -3.94008197e-02f, 1.98887032e-03f, -6.26287758e-02f, 7.42981862e-03f, -9.72693935e-02f, 7.88975134e-02f,
  -1.49000794e-01f, 1.75123736e-01f, -2.89863218e-02f, 4.48865369e-02f, -2.23202389e-02f, 5.61691634e-02f, 1.46528976e-02f, 5.90834708e-04f, 8.06501955e-02f, -2.07179766e-02f,
  -3.50509472e-02f, 4.07607369e-02f, 6.95613250e-02f, -1.89655852e-02f, 3.06408145e-02f, -4.35810797e-02f, -7.37338439e-02f, 6.71804771e-02f, 1.25412829e-02f, -1.04660191e-01f,
  -5.84486611e-02f, -6.36328533e-02f, 2.61290260e-02f, 2.88722310e-02f, 8.38577896e-02f, 6.44219154e-03f, -5.42813614e-02f, 5.39688319e-02f, -7.04280362e-02f, -1.18009247e-01f,
  -1.25130832e-01f, -8.90710298e-03f, -7.12231100e-02f, 2.32187305e-02f, 5.80811203e-02f, 4.84812520e-02f, 3.79183441e-02f, 7.81174451e-02f, -6.89680576e-02f, 4.27680463e-02f,
  6.34775078e-03f, 5.03542274e-02f, -5.66520058e-02f, 7.92552829e-02f, 9.17142779e-02f, 1.31804943e-01f, 2.44813897e-02f, -2.31393445e-02f, 1.07636221e-01f, -4.56075035e-02f,
  1.43275067e-01f, 7.93749690e-02f, 4.64137979e-02f, 7.92385265e-03f, 2.07824446e-02f, 9.48704481e-02f, -4.66116099e-03f, -5.28674237e-02f, -8.72895494e-03f, 8.42535198e-02f,
  2.05156710e-02f, -2.34763939e-02f, -1.32538676e-02f, 1.38735399e-03f, -5.53256012e-02f, -2.48731226e-02f, 6.05590753e-02f, -7.61047974e-02f, -9.02242288e-02f, 7.40723638e-03f,
  -3.32592241e-02f, 1.14008402e-02f, 4.68127020e-02f, -2.48973034e-02f, 7.55664632e-02f, 7.05058724e-02f, 3.08919139e-02f, -6.45771101e-02f, -4.52095903e-02f, 3.07163615e-02f,
  1.15721421e-02f, -4.71418798e-02f, -9.11643580e-02f, -5.56850582e-02f, -2.15064231e-02f, -5.96664175e-02f, 4.16380726e-02f, -4.94894646e-02f, 3.44185419e-02f, 4.63994555e-02f,
  3.63768302e-02f, 2.16151997e-02f, 2.26832610e-02f, -2.13901643e-02f, -1.82623288e-03f, 2.26641353e-02f, 1.24378107e-03f, -7.79038668e-02f, 8.17690883e-03f, 3.69189028e-03f,
  3.60455438e-02f, -4.98216003e-02f, 7.38425329e-02f, -7.88684860e-02f, -2.87816115e-02f, 6.55988744e-03f, 2.37803422e-02f, -5.19842915e-02f, -1.22782413e-03f, -1.09396972e-01f,
  7.13462681e-02f, 6.53820252e-03f, -7.35352561e-03f, 5.60940839e-02f, 4.91699129e-02f, 4.38858271e-02f, 5.87413870e-02f, 2.60793814e-03f, -1.93275381e-02f, -2.18215119e-03f,
  1.10718325e-01f, -7.04669431e-02f, -7.01425150e-02f, -5.79144545e-02f, -5.30606769e-02f, 2.89213508e-02f, 4.41812463e-02f, -7.42914528e-02f, -9.24178585e-02f, 3.66050117e-02f,
  -4.26468365e-02f, -8.20151567e-02f, 3.33256908e-02f, 4.74484041e-02f, 7.15437308e-02f, 9.61885750e-02f, -7.27172941e-02f, 2.36529950e-02f, 4.28074086e-03f, 6.37506172e-02f,
  -4.15953994e-02f, 4.58025262e-02f, 7.99992755e-02f, -3.56714353e-02f, -8.07139054e-02f, -2.19221413e-03f, -2.50610132e-02f, 6.20810539e-02f, -8.91270414e-02f, 1.53266601e-02f,
  -4.94233817e-02f, -1.51551485e-01f, -1.24777511e-01f, -7.71850348e-02f, 7.61819184e-02f, -2.35500261e-02f, -6.41566440e-02f, 1.12096921e-01f, 1.03783183e-01f, -1.55675458e-02f,
  1.21953720e-02f, -4.90269475e-02f, -7.25004598e-02f, -1.24642320e-01f, -2.25914028e-02f, -1.25202194e-01f, -1.39867961e-01f, -1.66195869e-01f, -3.81244197e-02f, 3.19723524e-02f,
  -4.86609191e-02f, -3.19376662e-02f, -1.09257109e-01f, -1.76215861e-02f, -4.81518880e-02f, -4.93037002e-03f, -1.61494732e-01f, -7.25443959e-02f, 5.73498197e-02f, -1.49699494e-01f,
  -3.89933549e-02f, 1.12811871e-01f, -5.01308404e-03f, 6.61335066e-02f, -5.17260749e-03f, -1.07986689e-01f, 5.44760264e-02f, 5.60274534e-02f, -7.90779814e-02f, 2.13198680e-02f,
  -1.05373785e-02f, 5.38810864e-02f, 5.54222316e-02f, 4.32537757e-02f, -2.08222046e-02f, 7.24580064e-02f, -1.03817917e-01f, -1.36823758e-01f, -1.17845513e-01f, 1.49744190e-02f,
  5.06045483e-02f, 2.33548954e-02f, -5.58590926e-02f, -5.35298549e-02f, 1.09924674e-02f, -7.35217929e-02f, -5.67885265e-02f, 4.43850793e-02f, 6.85770139e-02f, -6.30103722e-02f,
  2.28667762e-02f, -3.23031098e-02f, 3.96844745e-02f, 6.08481392e-02f, 4.67080884e-02f, 7.23538105e-04f, 5.77043556e-03f, 7.32903779e-02f, 4.41662632e-02f, 1.71191599e-02f,
  -4.93111499e-02f, -1.07925786e-02f, -8.92077107e-03f, -2.10272707e-02f, -6.97324201e-02f, -5.50376736e-02f, 2.93977931e-02f, 8.68518779e-04f, -9.29960012e-02f, 2.47026235e-02f,
  -3.76388840e-02f, 8.42737779e-03f, -9.17060375e-02f, 4.42209803e-02f, 2.58667916e-02f, 1.37219727e-02f, 4.67314869e-02f, 5.65518662e-02f, -7.13406652e-02f, -8.82619098e-02f,
  -4.02656309e-02f, -9.45196599e-02f, -9.84963179e-02f, -7.23078242e-03f, 4.46373522e-02f, -1.03992827e-01f, 5.92777915e-02f, 5.53077683e-02f, 2.91480925e-02f, -5.52162565e-02f,
  1.58019885e-02f, 6.92067891e-02f, -5.60658462e-02f, -2.15205792e-02f, 5.65054156e-02f, -2.58784462e-02f, -1.39361724e-01f, -1.27062708e-01f, -8.70954171e-02f, -9.37961973e-03f,
  -1.31350800e-01f, -6.53331913e-03f, -1.18407033e-01f, -1.56291336e-01f, -3.65338698e-02f, -4.14013788e-02f, 1.34595791e-02f, -3.14953513e-02f, -1.45947531e-01f, -1.13328218e-01f,
  -3.02133590e-01f, 2.97404826e-02f, -2.54248492e-02f, -4.38600816e-02f, 6.22326089e-03f, 1.29967779e-01f, 5.23922555e-02f, 1.27987906e-01f, -1.17843447e-03f, -1.66383728e-01f,
  -7.07876533e-02f, 2.77856831e-02f, -4.14143540e-02f, -3.76817025e-02f, -7.16134384e-02f, -1.01257272e-01f, -7.79681355e-02f, -1.27605781e-01f, 5.12996167e-02f, 1.16778478e-01f,
  -7.41401315e-02f, -1.83908924e-01f, -1.34678647e-01f, 1.02291822e-01f, -1.26260117e-01f, -1.90091789e-01f, -2.41951749e-01f, -2.38304719e-01f, -5.74992038e-02f, -2.66117722e-01f,
  -1.91082135e-01f, 1.37449428e-01f, 2.98068975e-04f, -1.23364516e-02f, -1.31672993e-01f, -2.23476142e-02f, -8.30836594e-03f, 7.63941035e-02f, 5.70032485e-02f, 9.33030322e-02f,
  -7.67059475e-02f, 8.20133556e-03f, -8.08894336e-02f, 6.17841557e-02f, 5.84809184e-02f, 9.18129683e-02f, -2.49037817e-02f, 8.96780491e-02f, -1.79780391e-03f, -9.48497001e-03f,
  -3.86864841e-02f, 4.75705266e-02f, 3.06324698e-02f, -4.28267270e-02f, -1.68090127e-02f, -1.11739440e-02f, -1.28015265e-01f, -1.33822739e-01f, -1.55316694e-02f, -2.68805027e-01f,
  1.42542431e-02f, 6.86160922e-02f, 5.28249405e-02f, 8.19889158e-02f, 3.54995430e-02f, -2.28498690e-02f, -4.14157547e-02f, -6.99560111e-03f, -3.97337088e-03f, -5.46010658e-02f,
  1.53305931e-02f, 1.04457021e-01f, 6.16189986e-02f, -3.04216072e-02f, 7.70036802e-02f, -3.02041080e-02f, 6.04705438e-02f, -1.08303837e-01f, 1.19382832e-02f, -1.03836171e-01f,
  6.05700202e-02f, -5.33691645e-02f, 5.68891279e-02f, -1.86889693e-02f, 1.29901450e-02f, -1.56880971e-02f, -8.27422831e-03f, 7.96677470e-02f, -1.21455686e-02f, 1.12633623e-01f,
  -8.60831290e-02f, 3.75158675e-02f, -9.23475251e-02f, 5.19235656e-02f, -5.62659539e-02f, -1.01566277e-01f, -2.28431467e-02f, -8.87300223e-02f, -1.90952560e-03f, -4.13969681e-02f,
  1.40396561e-02f, -4.47335988e-02f, -3.65394801e-02f, -3.16269659e-02f, 1.14817414e-02f, 7.15122595e-02f, 3.73684466e-02f, 2.14310531e-02f, 5.73344268e-02f, 9.54716578e-02f,
  -1.59509517e-02f, 1.49981119e-04f, -5.47732934e-02f, -1.55126140e-01f, 3.30816321e-02f, -9.98876616e-03f, -1.65123478e-01f, -8.50903913e-02f, -8.76328126e-02f, -2.45982349e-01f,
  1.60579562e-01f, -3.00405025e-01f, 1.44706306e-03f, 1.01253554e-01f, 1.37539422e-02f, 2.13574022e-01f, 1.25309214e-01f, -7.86525011e-03f, 5.87299019e-02f, -7.90200830e-02f,
  3.91754434e-02f, 5.58833219e-02f, 6.89418763e-02f, -4.59314287e-02f, 8.51164535e-02f, -4.08660285e-02f, 4.38835248e-02f, 1.66330934e-01f, 1.49651185e-01f, 5.21044321e-02f,
  6.66809380e-02f, 2.02489924e-03f, -1.12326421e-01f, 1.47147346e-02f, -7.82498196e-02f, -6.81640133e-02f, -6.49937838e-02f, -5.31045347e-02f, 7.17152515e-03f, -1.15425251e-01f,
  5.00965305e-02f, 7.10535496e-02f, 1.63336530e-01f, -3.41076106e-02f, -1.35647312e-01f, 6.50599971e-02f, 4.33646627e-02f, 1.35830399e-02f, -7.84195121e-03f, -1.09112775e-02f,
  -3.78889777e-02f, -1.05943941e-02f, -7.34338090e-02f, -1.03875205e-01f, 2.69470783e-03f, 2.95382701e-02f, -8.55508298e-02f, 4.51603392e-03f, -6.34254015e-04f, -3.03576123e-02f,
  -2.35583037e-02f, -9.39155370e-02f, 1.79049454e-03f, -3.61247212e-02f, -2.41939817e-02f, 8.87272581e-02f, -8.48432332e-02f, -5.03079183e-02f, 1.55767733e-02f, -4.04886715e-02f,
  -2.50022747e-02f, -2.91128755e-02f, 9.69128907e-02f, 4.73801941e-02f, -8.03934783e-02f, 3.72640863e-02f, 8.24004412e-02f, 4.53204885e-02f, -1.57536156e-02f, -1.92687043e-03f,
  1.52407412e-03f, 1.10271372e-01f, -5.48970215e-02f, -4.53880765e-02f, 2.96261050e-02f, 1.98034178e-02f, -5.30362083e-03f, -2.70303022e-02f, -6.88922852e-02f, 2.46801693e-02f,
  -6.61964864e-02f, 1.23637259e-01f, 4.94448701e-03f, -6.18576035e-02f, -4.49625365e-02f, -3.43555883e-02f, 1.24083906e-02f, -7.63264075e-02f, -8.91155303e-02f, -3.43391784e-02f,
  1.26417801e-02f, 1.67286664e-01f, 1.59567565e-01f, -5.36092333e-02f, 3.04936990e-02f, 1.55089656e-02f, -5.12971543e-02f, -2.46657673e-02f, -2.45621353e-02f, -2.27576774e-02f,
  6.57246187e-02f, 4.92378026e-02f, -1.03033818e-01f, -1.12138458e-01f, 1.02204300e-01f, 5.79045080e-02f, -4.37530763e-02f, 4.67739068e-03f, 9.05918889e-03f, 2.69563626e-02f,
  -6.82469383e-02f, 1.46936893e-01f, 1.81812316e-01f, 1.41579404e-01f, -3.59307416e-02f, 2.13445008e-01f, 9.81897935e-02f, -7.77719496e-03f, 1.66466177e-01f, -1.29068596e-03f,
  4.01768029e-01f, 1.63207218e-01f, 1.92845717e-01f, 7.95130730e-02f, 1.07657604e-01f, 2.85676979e-02f, 2.41388619e-01f, 8.72637704e-02f, 2.60882638e-02f, 8.70673507e-02f,
  8.69398378e-03f, -7.99707323e-02f, -7.28290528e-03f, 2.78575458e-02f, 9.77322832e-03f, 1.60745420e-02f, -8.01828951e-02f, 1.90340774e-03f, 1.31771296e-01f, 1.24391049e-01f,
  -6.69380501e-02f, 1.07492711e-02f, 1.46386057e-01f, 1.24018658e-02f, 6.49395883e-02f, -6.34465739e-02f, 3.25374566e-02f, 1.60102576e-01f, 9.51078832e-02f, -7.11269453e-02f,
  1.05796419e-01f, 2.86188424e-01f, -1.47695377e-01f, -1.12210633e-03f, -3.76027115e-02f, 7.39992112e-02f, 4.87218983e-02f, 6.12562485e-02f, -1.10552437e-03f, 7.29681412e-03f,
  2.04715524e-02f, 1.28196774e-03f, 9.76460353e-02f, 5.16698174e-02f, 7.30368719e-02f, 7.23120719e-02f, 6.42124787e-02f, 2.58144699e-02f, -1.91148482e-02f, 1.26705125e-01f,
  -3.77802700e-02f, 1.20901830e-01f, 1.08199343e-01f, 8.26709419e-02f, 8.47417489e-02f, -8.36191401e-02f, 3.02536022e-02f, 7.03619644e-02f, -3.73069383e-03f, 1.00465618e-01f,
  8.47483613e-03f, -5.12431301e-02f, -5.77253290e-02f, 2.19342615e-02f, -7.57410303e-02f, -1.08485334e-01f, 1.02878846e-02f, -2.42710859e-02f, -1.71288159e-02f, 1.87678654e-02f,
  3.45399119e-02f, 1.41830500e-02f, -5.01148179e-02f, 3.11908089e-02f, 1.30165443e-02f, 5.00703640e-02f, 5.89728728e-02f, -5.41431122e-02f, -1.10052880e-02f, -6.28994778e-02f,
  3.66844833e-02f, -2.41536386e-02f, 9.75396857e-02f, -3.51447500e-02f, 5.81667125e-02f, 6.09277375e-02f, -6.22329973e-02f, -9.00290087e-02f, 4.31758864e-03f, -5.34915552e-03f,
  -1.31290093e-01f, 1.12188898e-01f, -6.05101399e-02f, -1.30236864e-01f, 4.85021174e-02f, -5.82270548e-02f, 2.40901131e-02f, -1.25935540e-01f, -1.77090208e-03f, 4.94840369e-02f,
  5.12377061e-02f, 1.17019318e-01f, 3.75605281e-03f, 5.08205183e-02f, 5.57240397e-02f, -3.23290229e-02f, -3.94788124e-02f, 5.55471443e-02f, -1.00360990e-01f, 4.31107432e-02f,
  -1.52975529e-01f, -9.18592215e-02f, 1.28704039e-02f, -4.79510278e-02f, -2.01115645e-02f, -8.48637819e-02f, -1.15355469e-01f, 5.25564738e-02f, -4.28108387e-02f, -1.47121504e-01f,
  -4.95608225e-02f, 1.15304396e-01f, 9.24829245e-02f, 2.10189596e-02f, -5.54002002e-02f, 6.96256608e-02f, 1.10230587e-01f, -1.08134013e-03f, 2.99436580e-02f, -2.41282489e-02f,
  1.24752589e-01f, -5.05146347e-02f, -8.44067186e-02f, -1.41835352e-02f, -5.90376183e-02f, -9.18327793e-02f, -9.28122550e-02f, -1.22203536e-01f, -1.46356210e-01f, -4.82442304e-02f,
  2.39558909e-02f, -7.83048384e-03f, -7.01058283e-02f, -9.77239460e-02f, -1.36796841e-02f, -8.00136551e-02f, 9.41806734e-02f, 8.19341913e-02f, 1.17414057e-01f, -3.04373726e-02f,
  9.24529415e-03f, 9.57029760e-02f, -1.30402759e-01f, -7.86854848e-02f, -1.28405225e-02f, -1.00476630e-01f, -3.34024578e-02f, 5.46530969e-02f, -7.55589083e-02f, 9.70517471e-02f,
  1.71583835e-02f, -1.15803862e-02f, 7.83380568e-02f, 6.01597913e-02f, -3.13758515e-02f, 4.30570282e-02f, -7.22920895e-02f, -1.22000672e-01f, -2.28530932e-02f, 4.83039021e-02f,
  -5.63908368e-02f, 5.28985518e-04f, -4.07234766e-02f, -6.54249638e-02f, 9.71478298e-02f, 3.05486396e-02f, 7.36457482e-02f, -2.89671049e-02f, 4.42958735e-02f, 4.14986797e-02f,
  2.27866508e-02f, 4.99999300e-02f, -7.11359009e-02f, -5.65183014e-02f, 8.21787938e-02f, -6.62745163e-02f, 1.23541411e-02f, -6.85094893e-02f, -7.79767632e-02f, 2.84069404e-02f,
  -6.07584231e-02f, -9.21916496e-03f, -8.35929364e-02f, -3.45443264e-02f, 3.34650241e-02f, 4.61898558e-03f, 2.36006062e-02f, -6.28176853e-02f, -2.87480652e-02f, 1.64166968e-02f,
  4.74892594e-02f, 3.03329695e-02f, -8.00527707e-02f, -7.90511593e-02f, 6.23301975e-02f, -1.42518645e-02f, 5.41643165e-02f, 3.37032415e-02f, -2.87165795e-03f, -4.15894575e-02f,
  -6.15032539e-02f, 7.84564093e-02f, 5.06589711e-02f, -3.54084373e-02f, -5.55050708e-02f, -7.45981336e-02f, 3.17907557e-02f, -3.15835550e-02f, -6.32515401e-02f, 5.54300435e-02f,
  -3.44909020e-02f, 7.70849064e-02f, 3.98798063e-02f, 8.67733583e-02f, -1.73159745e-02f, 8.82614478e-02f, -7.56990239e-02f, -5.47657050e-02f, 6.07640259e-02f, -5.03792837e-02f,
  7.20281005e-02f, -2.68734898e-03f, 3.40617411e-02f, 2.90302024e-03f, 1.31181227e-02f, -5.44061624e-02f, 9.79207009e-02f, -5.08671477e-02f, -7.98164904e-02f, -7.16790780e-02f,
  -5.93477450e-02f, 6.45855144e-02f, -7.47672021e-02f, 2.63001025e-02f, -3.43814828e-02f, -1.25424145e-03f, -1.41620651e-01f, -1.13162123e-01f, 7.72408321e-02f, 6.15889058e-02f,
  -2.40738299e-02f, 6.11896776e-02f, 5.44940643e-02f, -9.94051471e-02f, -5.28609678e-02f, -8.29550475e-02f, -6.82917684e-02f, -1.52914941e-01f, -6.75329641e-02f, 1.95596945e-02f,
  2.52812169e-02f, 3.50961797e-02f, -3.00428737e-02f, -9.95025486e-02f, 3.04138977e-02f, 5.86678684e-02f, 2.15888843e-02f, -6.87195733e-02f, 1.25482276e-01f, 4.13557589e-02f,
  4.30322550e-02f, -4.44486849e-02f, -2.15710537e-03f, 1.01099722e-01f, -5.23710586e-02f, -7.05226734e-02f, 7.73706064e-02f, 2.96619199e-02f, 2.19151452e-02f, -6.39315769e-02f,
  1.08102970e-02f, -2.52464246e-02f, -9.03837830e-02f, 2.02382319e-02f, 4.31740135e-02f, -5.08485436e-02f, -8.32986087e-02f, -3.89215499e-02f, -4.11068387e-02f, -7.76559338e-02f,
  -2.51195170e-02f, 7.72548094e-02f, -1.09367728e-01f, -8.69229436e-02f, -2.33622249e-02f, -6.50687814e-02f, 1.15581471e-02f, 4.54291888e-02f, -1.06637858e-01f, 8.33067894e-02f,
  6.04810193e-02f, -1.70679782e-02f, 6.17969707e-02f, -5.16656833e-03f, -2.36387365e-02f, -6.95062336e-03f, -1.70144849e-02f, 3.77979912e-02f, 2.27202065e-02f, -1.06739486e-02f,
  2.85172649e-02f, 2.34558973e-02f, -3.47804353e-02f, 6.58485219e-02f, -5.15469313e-02f, -4.22394164e-02f, -9.05992836e-02f, -9.86607745e-02f, -5.00311442e-02f, 3.76758501e-02f,
  -4.76933941e-02f, 3.23833525e-02f, 2.22556889e-02f, 4.80683446e-02f, 1.20896092e-02f, 2.86791958e-02f, 8.18920732e-02f, 7.00936243e-02f, 1.48920622e-03f, -6.88786209e-02f,
  2.21556183e-02f, -4.94374447e-02f, -5.56920804e-02f, 7.27397874e-02f, 6.06825575e-02f, -3.93919200e-02f, 8.62111524e-02f, -5.70541434e-02f, -3.75960767e-02f, 3.10301147e-02f,
  6.06688000e-02f, 2.13574208e-02f, 1.70833115e-02f, 7.25964755e-02f, 6.30070269e-02f, 1.02070071e-01f, 3.08361836e-02f, 2.60484535e-02f, 4.56281342e-02f, -7.41078556e-02f,
  -6.26756251e-02f, -1.13662742e-01f, -1.34616479e-01f, 3.01053654e-02f, -1.50333233e-02f, -1.03893228e-01f, -7.25748688e-02f, -9.34782401e-02f, -8.21341947e-02f, -5.85474959e-03f,
  -9.76872668e-02f, -1.28367022e-01f, -3.80100422e-02f, -1.09020717e-01f, 3.89216724e-03f, -5.58347628e-02f, 8.70187953e-03f, -2.30547283e-02f, 4.21198308e-02f, -1.31979346e-01f,
  4.60250713e-02f, -8.61831754e-02f, 9.70760733e-03f, -5.94422035e-02f, -6.12285361e-02f, -1.07241750e-01f, -1.64480910e-01f, -3.43844742e-02f, -1.36249764e-02f, 3.87748927e-02f,
  1.21692463e-03f, -9.53244194e-02f, -2.56953780e-02f, -4.12567630e-02f, 4.89145182e-02f, -9.57528576e-02f, -7.64689744e-02f, -5.73826768e-02f, 2.76593193e-02f, -1.04186475e-01f,
  -2.16616541e-01f, 3.97656299e-02f, 3.44212353e-02f, 1.51697444e-02f, -6.60563912e-03f, -2.04071216e-02f, 3.13032605e-02f, 2.43610777e-02f, 2.94202510e-02f, -4.48343158e-02f,
  -7.16320276e-02f, 4.19652909e-02f, -1.59228053e-02f, 5.51188029e-02f, 5.35830557e-02f, 8.82846117e-02f, 9.78877693e-02f, 6.79126158e-02f, -3.95124145e-02f, -1.57057261e-03f,
  8.66883714e-03f, -3.62130702e-02f, -4.49456647e-02f, -2.02800427e-03f, 6.28241375e-02f, 1.57651473e-02f, -1.83311850e-03f, 5.49336411e-02f, -8.45913514e-02f, -3.56925651e-02f,
  -3.97569649e-02f, -4.01440896e-02f, 2.76872274e-02f, 7.62978056e-03f, 5.34727313e-02f, -5.55879921e-02f, -9.50623362e-04f, 6.74039200e-02f, 2.19616015e-02f, -1.10145435e-02f,
  -8.91790390e-02f, -3.64251919e-02f, 2.13920046e-02f, -3.79161630e-03f, 2.60249302e-02f, 6.76663443e-02f, -9.74157900e-02f, -3.17656659e-02f, 8.15905035e-02f, 5.54079190e-02f,
  -4.21929359e-02f, 5.33701200e-03f, 4.26064432e-02f, 1.32989455e-02f, -1.34836435e-02f, -6.74489886e-02f, 2.23255549e-02f, -1.91113614e-02f, -9.96746793e-02f, -4.42159101e-02f,
  -1.18868038e-01f, -2.25308668e-02f, -8.97044316e-02f, 6.45795837e-02f, -3.08615398e-02f, 7.88486227e-02f, -3.63424905e-02f, 7.93530270e-02f, 1.80989108e-03f, 6.42030165e-02f,
  -3.24387439e-02f, 9.90315229e-02f, -5.98623417e-02f, 4.63616699e-02f, -7.73686320e-02f, 7.36393854e-02f, -2.90708430e-02f, 5.65682575e-02f, 2.97310355e-04f, 1.22328863e-01f,
  9.59256440e-02f, -1.93529781e-02f, 1.52979661e-02f, -1.18949153e-01f, -5.30775674e-02f, -1.14489116e-01f, 4.30316059e-03f, -1.26767248e-01f, -1.21849060e-01f, -1.21161357e-01f,
  1.57435238e-02f, -5.38282935e-03f, -9.41296667e-03f, 5.52182719e-02f, -6.19503893e-02f, -6.06465638e-02f, 9.80769992e-02f, 2.02695578e-02f, 5.08830063e-02f, -5.94349317e-02f,
  -1.91079061e-02f, 1.16582867e-02f, -5.40365912e-02f, -4.07801345e-02f, 6.22748956e-02f, -2.05940232e-02f, 9.02380198e-02f, -2.46158266e-03f, -8.08273405e-02f, -8.94225314e-02f,
  9.86994207e-02f, 2.38789488e-02f, -9.40306708e-02f, -4.88450304e-02f, 3.54671367e-02f, 8.00195932e-02f, -4.40129936e-02f, -2.15892065e-02f, -7.74757266e-02f, 1.20934419e-01f,
  -3.37087885e-02f, -6.49680793e-02f, 7.24539459e-02f, -4.56798226e-02f, 7.52288476e-02f, -8.13335776e-02f, -1.57294162e-02f, 1.05247861e-02f, 7.88697526e-02f, -6.89444840e-02f,
  5.20851351e-02f, 3.97695228e-02f, -2.90407185e-02f, 5.87554136e-03f, 1.08337095e-02f, 1.60490815e-02f, 1.80759802e-02f, 9.28460807e-03f, 1.30008431e-02f, -3.43727954e-02f,
  3.70654725e-02f, -7.54498616e-02f, 3.67990546e-02f, -9.27239656e-02f, -4.89297658e-02f, 7.61374384e-02f, -4.17179875e-02f, -4.26588543e-02f, 1.21190231e-02f, 7.46040046e-02f,
  4.81944606e-02f, 8.64975601e-02f, 1.02275543e-01f, 3.35345380e-02f, -1.18051693e-02f, 1.62863694e-02f, 6.73608389e-03f, -1.73886977e-02f, -1.61960237e-02f, -6.53450713e-02f,
  -1.01225019e-01f, -8.21298510e-02f, 3.28514762e-02f, 7.62517452e-02f, -2.23109685e-02f, 7.08573759e-02f, 5.56706311e-03f, 3.69495042e-02f, 4.48252223e-02f, -2.25355420e-02f,
  2.54271235e-02f, 1.61810927e-02f, 6.98205605e-02f, -2.29205657e-02f, -6.36044517e-02f, -5.73975639e-03f, -3.73842865e-02f, 7.93025419e-02f, 4.73512076e-02f, 2.07961854e-02f,
  -8.40978026e-02f, -7.31899461e-04f, 4.42008078e-02f, 4.74250764e-02f, -6.68636486e-02f, -6.71707243e-02f, -7.26106483e-03f, -7.50303268e-02f, -3.73049080e-02f, -5.82756400e-02f,
  4.71104719e-02f, 2.41967551e-02f, 3.82185280e-02f, 8.10435489e-02f, -7.82335922e-02f, -9.54100024e-03f, 8.85452628e-02f, -7.64610171e-02f, -6.72381558e-03f, 6.11592233e-02f,
  7.67063349e-03f, 2.79492568e-02f, 3.03390082e-02f, -8.70667621e-02f, -6.26243651e-02f, 4.96108942e-02f, -9.09936652e-02f, 6.67478144e-02f, -8.74648839e-02f, 5.68567887e-02f,
  5.99159412e-02f, -1.16530359e-01f, -6.38579428e-02f, 1.88359216e-01f, 1.89033136e-01f, 4.43032458e-02f, 1.45906940e-01f, 7.21320361e-02f, 1.84160382e-01f, 1.53893918e-01f,
  -6.63304329e-02f, 9.20940489e-02f, 3.18695232e-03f, -1.14779966e-02f, 2.90623177e-02f, 1.02255866e-01f, 1.65259615e-01f, -5.20943999e-02f, -1.84102077e-03f, 4.82199453e-02f,
  -4.97861952e-02f, 1.20319799e-03f, -1.62035655e-02f, -7.96507299e-02f, -6.35232683e-03f, -2.22605430e-02f, 5.80132455e-02f, -1.10609934e-01f, -6.45619491e-03f, 6.07277937e-02f,
  -1.07390881e-01f, -4.22720574e-02f, 1.73690379e-01f, 7.01909959e-02f, -1.25313312e-01f, -7.18264356e-02f, -5.92928194e-02f, -4.58054477e-03f, -4.59760875e-02f, -6.59800693e-02f,
  -2.99704671e-02f, -1.13715660e-02f, -3.80049832e-02f, 2.82811318e-02f, -1.11634448e-01f, 7.23285154e-02f, -6.97819749e-03f, 9.72261745e-03f, -1.88358780e-02f, -3.36533301e-02f,
  4.53568883e-02f, 3.38151157e-02f, -8.33241642e-02f, 3.59219350e-02f, -7.23393634e-02f, 3.08777653e-02f, -3.72822247e-02f, -7.54418448e-02f, -9.48598888e-03f, -1.58488080e-02f,
  8.40640143e-02f, 7.83521042e-04f, -2.31709052e-02f, 6.71702549e-02f, -4.54451069e-02f, 6.20831102e-02f, -3.74051146e-02f, -1.65564530e-02f, 4.34737187e-03f, -2.02057958e-02f,
  3.09941098e-02f, 2.28832178e-02f, 1.88022642e-03f, -8.73956922e-03f, -4.39618118e-02f, 8.48537683e-02f, 6.29573641e-03f, 1.00987135e-02f, -2.38465406e-02f, -2.81174649e-02f,
  -2.19701231e-02f, 1.77684333e-02f, -7.02018961e-02f, -2.77211685e-02f, 4.34527807e-02f, -9.00718793e-02f, 4.19718251e-02f, -5.23420377e-03f, 9.15448815e-02f, -8.47283676e-02f,
  -1.59142762e-01f, 8.82347152e-02f, 3.06864977e-02f, -2.19753273e-02f, -2.60282774e-02f, 5.39932698e-02f, -7.35029951e-02f, -5.26408141e-04f, -6.59939349e-02f, -7.79015496e-02f,
  4.39538667e-03f, 5.82816154e-02f, -3.81758437e-02f, -8.32488462e-02f, -2.01190431e-02f, -4.95125651e-02f, -1.85372178e-02f, 5.86682484e-02f, -4.88779694e-03f, -7.99979344e-02f,
  4.69307229e-02f, -5.43465763e-02f, 5.11160828e-02f, 8.98653865e-02f, 8.52832198e-02f, -2.82429694e-03f, 2.59823371e-02f, 8.93112645e-03f, -3.13810296e-02f, 2.59514637e-02f,
  -1.57685038e-02f, -1.06198996e-01f, -1.29077425e-02f, -4.28309962e-02f, -6.45773783e-02f, 6.25620931e-02f, -1.60945673e-02f, -3.40241902e-02f, 5.90804182e-02f, -8.90311003e-02f,
  3.80465090e-02f, 9.37095564e-03f, -4.83831316e-02f, 8.14820901e-02f, 3.93492915e-02f, -2.33682687e-04f, -1.25753060e-01f, 6.57763854e-02f, -2.40030885e-02f, -1.42046129e-02f,
  -2.90440228e-02f, -7.42666200e-02f, 1.53792202e-02f, -3.66862491e-02f, -8.45521390e-02f, -8.66104439e-02f, -5.07276393e-02f, -4.43964265e-02f, 2.44428199e-02f, 1.70798879e-02f,
  2.84545636e-03f, -2.31293719e-02f, -6.96047619e-02f, -3.21386494e-02f, -6.51995987e-02f, 8.45736563e-02f, 2.83418577e-02f, 1.29441302e-02f, 2.66547929e-02f, -8.09328333e-02f,
  -2.36449465e-02f, -6.16157763e-02f, -2.95139924e-02f, -8.17566961e-02f, -4.05183583e-02f, 2.42555104e-02f, -6.49374202e-02f, -7.30051100e-02f, 6.26216531e-02f, 8.21864828e-02f,
  3.37563157e-02f, 1.36544472e-02f, -6.43152073e-02f, -2.80901007e-02f, 6.78167492e-02f, 6.11175708e-02f, 3.18080448e-02f, -1.14330761e-02f, -1.90662239e-02f, -2.50292812e-02f,
  -6.93888217e-02f, 1.35151460e-03f, -1.65371224e-02f, -7.46063143e-02f, 4.24090549e-02f, -5.54478243e-02f, 6.16356507e-02f, 2.89717223e-02f, -5.17888628e-02f, -7.53740594e-02f,
  -7.62668774e-02f, -3.20422091e-02f, 6.97433352e-02f, 2.17562634e-02f, 2.81695873e-02f, 2.07281988e-02f, -7.66469315e-02f, -1.84181351e-02f, -7.60404542e-02f, 4.46335925e-03f,
  -8.39699283e-02f, -8.88477042e-02f, -1.56013025e-02f, -8.03092793e-02f, 1.43987676e-02f, -5.12820482e-02f, 3.89095284e-02f, -2.23984923e-02f, -5.86943813e-02f, 8.00351426e-02f,
  -4.25398611e-02f, 5.72735071e-02f, 8.77354741e-02f, -6.88346243e-03f, 5.30115776e-02f, 3.57156135e-02f, 7.13825822e-02f, -9.74375904e-02f, -4.54991944e-02f, 8.93377736e-02f,
  5.22628352e-02f, -7.64634227e-03f, -8.03192630e-02f, -3.37330289e-02f, -8.42295662e-02f, -3.10556702e-02f, 6.45961612e-02f, -7.15280250e-02f, -3.72381918e-02f, -3.52565348e-02f,
  2.44022887e-02f, -3.87696102e-02f, 8.81472230e-02f, -5.31068146e-02f, 2.57692691e-02f, -4.92746830e-02f, -5.48424468e-05f, -7.13519305e-02f, -2.65867710e-02f, -1.01011850e-01f,
  2.34258305e-02f, 1.15568768e-02f, 9.60214287e-02f, 3.37280072e-02f, 1.12718731e-01f, 1.09581597e-01f, 7.70604890e-03f, 3.99637641e-03f, -1.15057282e-01f, 5.85922264e-02f,
  5.90259358e-02f, -3.21520865e-02f, -1.13087028e-01f, 2.50154361e-02f, 1.55992806e-02f, 2.47539934e-02f, 1.27140256e-02f, -2.09588874e-02f, -4.68470901e-02f, -5.95243238e-02f,
  -4.18016948e-02f, -3.07768844e-02f, -1.53207462e-02f, -1.15454338e-01f, -1.34416642e-02f, 4.07891683e-02f, 1.88789493e-03f, -9.33618937e-03f, 8.74190256e-02f, -9.32157934e-02f,
  1.08695425e-01f, -8.88646021e-03f, -2.00289693e-02f, -6.42829388e-02f, 4.66058701e-02f, -5.69133833e-02f, 7.01049566e-02f, -9.34505276e-03f, -9.12184492e-02f, -9.45676938e-02f,
  -9.72260721e-03f, -9.10690799e-02f, -5.14290594e-02f, -3.86341736e-02f, -4.12032306e-02f, -1.14204912e-02f, -5.96207306e-02f, 1.09772924e-02f, 3.81603241e-02f, 8.80665854e-02f,
  3.07118464e-02f, 1.59063295e-03f, 1.05810195e-01f, -4.96994033e-02f, -1.26111368e-03f, -1.79477400e-04f, -1.06582241e-02f, 8.22562426e-02f, 1.13334343e-01f, -4.81687039e-02f,
  -1.09756842e-01f, -7.34280571e-02f, -1.43578090e-02f, -2.86068656e-02f, 8.00315291e-02f, -6.98257983e-03f, -6.11630380e-02f, 7.69299315e-03f, -3.31296921e-02f, -5.23910969e-02f,
  8.06556791e-02f, 8.53149593e-02f, 5.91300093e-02f, 1.07300483e-01f, 1.04837686e-01f, 3.74779887e-02f, 3.30573469e-02f, 2.07683705e-02f, -4.24795561e-02f, 1.59104839e-02f,
  -5.48638515e-02f, -7.99320731e-03f, 8.48086178e-02f, 6.07730914e-03f, -1.18649015e-02f, 7.71286562e-02f, 9.16624740e-02f, -3.16835232e-02f, -1.34462193e-02f, 6.26556724e-02f,
  -1.39281899e-01f, 8.85216966e-02f, 3.04238573e-02f, 5.86310513e-02f, 7.33978599e-02f, -6.15566894e-02f, -7.76846241e-03f, 4.33513522e-02f, -2.21351385e-02f, -2.13328544e-02f,
  -2.56634154e-03f, 2.98601352e-02f, 1.11706942e-01f, -2.81874146e-02f, -6.94240257e-02f, -9.50006992e-02f, -5.19956835e-02f, 6.95156455e-02f, -2.14814357e-02f, 5.55417836e-02f,
  6.67071044e-02f, 6.62747398e-02f, 2.14516241e-02f, -8.38498101e-02f, 3.28681171e-02f, -8.71810243e-02f, -3.64269204e-02f, 8.76629818e-03f, 7.38636628e-02f, 1.40405204e-02f,
  8.91263708e-02f, -7.72697181e-02f, -1.03303269e-01f, -5.64178489e-02f, -5.14781401e-02f, -1.24441341e-01f, -1.42691165e-01f, 7.09893834e-03f, 6.27829209e-02f, -1.53273605e-02f,
  5.53898886e-02f, 1.23908453e-01f, 9.99956951e-02f, 1.37489960e-01f, 6.38766810e-02f, -8.19972083e-02f, -1.72036976e-01f, -6.52784333e-02f, 5.62885851e-02f, -5.35683893e-03f,
  -6.15439704e-03f, 4.29559089e-02f, -2.23655086e-02f, 1.11156870e-02f, -1.19278356e-01f, 3.11328433e-02f, -1.09238394e-01f, -5.08560054e-02f, -3.26087512e-02f, -1.70012906e-01f,
  -1.97846621e-01f, -2.20281491e-03f, 4.84212127e-04f, 6.23164028e-02f, -1.20095782e-01f, 2.95691136e-02f, 5.62846661e-02f, -4.56194058e-02f, -5.43970279e-02f, -3.51812989e-02f,
  -3.27183641e-02f, -1.90866087e-02f, 1.79301109e-02f, -2.20970139e-02f, 5.44066951e-02f, -3.35905366e-02f, -8.96737054e-02f, 4.48478535e-02f, -6.60318360e-02f, 1.64833516e-02f,
  -7.40434751e-02f, 3.66460020e-03f, -1.55658489e-02f, -6.15844987e-02f, 3.57389823e-02f, -1.10765798e-02f, -7.04743043e-02f, -1.06756620e-01f, -3.68197113e-02f, -1.45088494e-01f,
  -6.76865280e-02f, -4.32817377e-02f, 7.29850382e-02f, 3.86734903e-02f, 2.76984442e-02f, -1.29314568e-02f, -7.54642263e-02f, -5.85070029e-02f, -4.46228795e-02f, -3.89682241e-02f,
  8.35896730e-02f, 4.29022685e-02f, 7.54089057e-02f, 2.47991253e-02f, 1.44515466e-02f, -1.03920302e-03f, 8.84336382e-02f, -8.82226452e-02f, -3.23043987e-02f, -6.86559528e-02f,
  5.88157475e-02f, -5.11124581e-02f, 3.49831693e-02f, -3.18180807e-02f, 4.05245200e-02f, 6.33459613e-02f, 4.46167625e-02f, 2.05721054e-02f, 5.63403033e-02f, 7.22060204e-02f,
  1.10105209e-01f, 1.77502725e-02f, 6.42121211e-02f, -4.08532321e-02f, 3.93874794e-02f, 4.58859373e-03f, -3.00619211e-02f, 3.32974233e-02f, -7.48226000e-03f, 3.97008508e-02f,
  9.84180123e-02f, -4.21040766e-02f, -7.71877021e-02f, -5.84949460e-03f, -5.22638485e-02f, -3.14614624e-02f, 5.11587597e-02f, 8.17877352e-02f, 2.21202970e-02f, 3.84816453e-02f,
  -6.78175986e-02f, 2.94438321e-02f, 8.91074836e-02f, -1.51920877e-02f, -2.40942482e-02f, 3.53115015e-02f, 7.03913495e-02f, 2.41635721e-02f, -6.69335872e-02f, -3.74992080e-02f,
  1.13861538e-01f, 1.00650556e-01f, -3.94629985e-02f, -6.44268990e-02f, -3.41313966e-02f, 3.09881102e-03f, -4.83993255e-02f, 1.52552957e-02f, -2.45939251e-02f, -4.85479496e-02f,
  -1.04833907e-02f, -2.19885353e-02f, -8.61476064e-02f, -6.78399652e-02f, -9.67937484e-02f, 3.87439691e-02f, -1.50649920e-02f, -6.24572597e-02f, -2.31575202e-02f, -7.17000887e-02f,
  -7.82638714e-02f, 1.12958495e-02f, -1.45007849e-01f, -3.76690738e-02f, -1.26918986e-01f, -7.72448815e-03f, -3.95645462e-02f, 2.95041353e-02f, 3.54814418e-02f, -3.92190926e-02f,
  1.06013201e-01f, 1.38181806e-01f, -6.97288886e-02f, -2.45195311e-02f, 7.92420134e-02f, 5.82280830e-02f, 8.48615542e-03f, 4.52372096e-02f, -6.69318512e-02f, -4.61518392e-02f,
  7.39947632e-02f, 5.68914339e-02f, -7.00380504e-02f, -1.04546838e-01f, -1.10085785e-01f, 1.42055918e-02f, -8.41762349e-02f, -1.63058937e-02f, -1.12988003e-01f, 3.79660889e-03f,
  -3.31444852e-02f, -2.40014326e-02f, -3.48257460e-02f, -5.00456877e-02f, 2.50229631e-02f, 6.53001890e-02f, 3.03191841e-02f, 6.61081299e-02f, -8.43148306e-02f, -1.12676002e-01f,
  -6.65505081e-02f, -7.17698410e-02f, -5.20520583e-02f, -9.66271833e-02f, -2.49724723e-02f, -6.62752055e-03f, -1.75605938e-02f, 1.08850477e-02f, 2.71931477e-02f, 3.87179777e-02f,
  -5.19292615e-02f, 1.92821510e-02f, -1.02618942e-02f, -5.49135096e-02f, -3.15471622e-03f, -2.17236299e-02f, -7.45315105e-02f, -9.48987901e-02f, -7.87146464e-02f, -3.77522479e-03f,
  -2.44050194e-02f, 2.24224366e-02f, -4.96198796e-02f, -5.46687394e-02f, -6.07462451e-02f, -3.26096825e-02f, 1.16300331e-02f, 4.47766781e-02f, -8.20084810e-02f, -7.84610659e-02f,
  -7.66723529e-02f, 8.44378117e-03f, -3.87122110e-02f, 2.19766758e-02f, -5.82397953e-02f, 3.53700817e-02f, 4.87899259e-02f, -1.51323117e-02f, 1.65087506e-02f, 9.87640321e-02f,
  9.64796990e-02f, -9.36512277e-02f, -1.38377529e-02f, -3.56863402e-02f, -7.36861378e-02f, 2.27651894e-02f, -5.27127571e-02f, -5.81395924e-02f, -2.38089506e-02f, -4.06269729e-02f,
  7.38379657e-02f, -7.84473717e-02f, -9.14185196e-02f, 5.06555382e-03f, 2.35675909e-02f, 2.15783017e-03f, -1.17050514e-01f, 5.37558608e-02f, 5.51174302e-03f, -1.61687568e-01f,
  -2.39846990e-01f, -3.77270505e-02f, 6.85443878e-02f, -6.20274954e-02f, -2.88052596e-02f, -4.05241624e-02f, -3.58921327e-02f, 8.29585195e-02f, -8.52345452e-02f, 1.02065176e-01f,
  -2.16239952e-02f, 1.10280931e-01f, 8.75718296e-02f, 1.69833019e-01f, 9.49191004e-02f, 7.07087964e-02f, 6.78430274e-02f, -5.81184123e-03f, 7.03861937e-02f, 1.51895247e-02f,
  3.40729244e-02f, -9.04595926e-02f, 1.78279784e-02f, -9.77920890e-02f, 9.52783078e-02f, -2.42273081e-02f, -7.46190622e-02f, 7.87747093e-03f, 7.51807988e-02f, 3.50995027e-02f,
  2.84638345e-01f, -1.71464786e-01f, -1.20351678e-02f, 2.35893279e-02f, -1.04273865e-02f, -5.11016473e-02f, -2.28123181e-02f, -4.71378751e-02f, 4.92166057e-02f, 1.19997427e-01f,
  3.39893787e-03f, -3.15597318e-02f, -8.09857011e-05f, 7.34474510e-02f, 4.79408167e-02f, 6.83851391e-02f, -3.75847481e-02f, -4.78616022e-02f, 1.69069984e-03f, 6.62426129e-02f,
  -2.58321259e-02f, 3.27916932e-03f, 3.65856029e-02f, 6.18760586e-02f, 3.12980413e-02f, -9.22497641e-03f, 7.86983892e-02f, -1.91251189e-02f, 6.50723651e-02f, -7.28433281e-02f,
  3.07880919e-02f, 2.91648638e-02f, 5.39583415e-02f, -1.50382891e-02f, 6.45182729e-02f, -5.12861572e-02f, -2.80741192e-02f, -3.62604745e-02f, -2.32530590e-02f, 2.14482900e-02f,
  2.76849642e-02f, -5.35500795e-02f, -6.47929013e-02f, -9.11554229e-03f, -6.94098324e-03f, 3.75596918e-02f, -2.78536957e-02f, -3.95609550e-02f, -1.97235793e-02f, -3.69577445e-02f,
  3.54067944e-02f, 7.10780323e-02f, 5.62060103e-02f, -1.82759278e-02f, -5.01483344e-02f, -4.57221828e-02f, 2.39013955e-02f, 4.85904291e-02f, 6.28871992e-02f, -9.59434360e-02f,
  2.21100256e-01f, 3.37458923e-02f, -4.96663107e-03f, -3.10378652e-02f, 6.89021870e-02f, 1.14192320e-02f, -2.29445528e-02f, 6.75444081e-02f, -5.08592762e-02f, 7.88540915e-02f,
  6.17888309e-02f, -9.10901465e-03f, 3.99137810e-02f, 5.59650399e-02f, 3.67361419e-02f, -3.07526765e-03f, -3.26484516e-02f, -2.48230528e-02f, 7.48487264e-02f, 6.20456412e-02f,
  8.73530880e-02f, 1.30555779e-01f, 1.34666264e-01f, 9.29292440e-02f, -5.10522816e-03f, 1.44955695e-01f, 1.56671688e-01f, 8.38100463e-02f, 1.76120415e-01f, 1.04998596e-01f,
  -2.20998880e-02f, 7.54162436e-03f, 1.73915289e-02f, 1.81130990e-02f, -2.70736925e-02f, 7.19861919e-03f, 3.80186848e-02f, -1.01845987e-01f, -9.59169418e-02f, -1.76896583e-02f,
  3.93708497e-02f, 9.93799791e-02f, 2.00977339e-03f, 6.50007054e-02f, 4.75398004e-02f, 5.40514998e-02f, 1.26804728e-02f, -5.98736899e-03f, -1.81807857e-02f, 1.25859128e-02f,
  3.39397937e-02f, 1.58667546e-02f, 7.59714246e-02f, 2.08115745e-02f, -1.86683312e-02f, 6.78190291e-02f, -1.86668579e-02f, -2.84111369e-02f, 3.55626829e-02f, 1.29438728e-01f,
  2.03933436e-02f, 5.09734526e-02f, -3.38670351e-02f, -5.58384135e-02f, 3.61626484e-02f, -4.65884842e-02f, 8.74390267e-03f, 5.04891314e-02f, -4.99137416e-02f, -5.35599776e-02f,
  3.20832804e-03f, 8.35189503e-03f, -9.00194868e-02f, -6.99354857e-02f, -9.89510491e-02f, 1.46911582e-02f, -4.89948951e-02f, -9.26709268e-03f, -7.57714882e-02f, -5.09447930e-03f,
  -1.59538835e-02f, 1.18352637e-01f, 4.76045869e-02f, -1.37419999e-02f, 2.84966584e-02f, -1.91355310e-02f, 1.44845825e-02f, -1.90492533e-02f, 1.52500244e-02f, -8.68310183e-02f,
  -7.74336532e-02f, 3.49354036e-02f, 2.13502124e-02f, 6.97614998e-02f, 2.81408969e-02f, -5.74864447e-02f, -6.54769242e-02f, 4.01437609e-03f, -7.07160309e-02f, -7.37764016e-02f,
  5.47646061e-02f, -7.20439628e-02f, -7.59806708e-02f, -3.07387896e-02f, 1.93980671e-02f, 7.88634643e-02f, -2.81952098e-02f, -2.04086471e-02f, 4.46117260e-02f, 2.64626294e-02f,
  7.14763254e-02f, 1.42863104e-02f, -6.17550835e-02f, -3.94220240e-02f, -5.32459654e-02f, 7.40845203e-02f, -6.16945252e-02f, -4.15372755e-03f, 3.17379348e-02f, 4.68297442e-03f,
  -3.54749374e-02f, 7.86324888e-02f, 1.29751666e-02f, -2.83052549e-02f, -2.76158638e-02f, 6.08553663e-02f, -3.54999048e-03f, -3.43821347e-02f, -5.52840643e-02f, -2.00717915e-02f,
  -1.05755292e-01f, 5.66785317e-03f, -5.79425804e-02f, 6.03020657e-03f, 2.85562687e-03f, -9.65314806e-02f, 9.06202570e-03f, -7.59973824e-02f, -1.23599414e-02f, 1.72678567e-02f,
  7.14024827e-02f, -1.16281986e-01f, -1.19894810e-01f, -6.61941841e-02f, 1.11081218e-02f, 4.91857231e-02f, -6.67440891e-02f, -3.66327241e-02f, 2.52957419e-02f, -4.54696938e-02f,
  6.15224838e-02f, -2.13621184e-02f, -9.70791094e-03f, 7.14821592e-02f, 1.77947935e-02f, 1.92092322e-02f, -9.39173717e-03f, -2.83598229e-02f, 5.00005819e-02f, -2.84058750e-02f,
  -5.66805862e-02f, -5.11385538e-02f, -1.00483686e-01f, -5.47762066e-02f, -1.51411723e-02f, 6.68158056e-03f, 2.09985490e-04f, 1.48893958e-02f, -9.93101764e-03f, -7.22908154e-02f,
  9.38792303e-02f, 4.87357080e-02f, 2.17959029e-03f, 3.80918570e-02f, 2.75406037e-02f, -5.52558154e-02f, 8.02650750e-02f, 1.42943934e-01f, 1.34897083e-01f, 1.36344507e-01f,
  -5.44972792e-02f, 8.07835460e-02f, 1.31365201e-02f, 3.80244702e-02f, -1.33889876e-02f, 5.68625145e-03f, 1.01330362e-01f, 1.03597991e-01f, 3.24876024e-03f, 1.12013988e-01f,
  7.96705335e-02f, 3.43899503e-02f, 1.03717729e-01f, 2.12775636e-02f, 1.00494027e-01f, -3.70088741e-02f, 1.10678144e-01f, 1.27920792e-01f, 9.22897980e-02f, 2.44367570e-02f,
  -7.07162246e-02f, -3.33719850e-02f, -4.39749137e-02f, 6.83416873e-02f, -8.86261314e-02f, 1.37054631e-02f, 1.15388788e-01f, -2.80072335e-02f, 7.41189718e-02f, 7.30825663e-02f,
  -8.83367062e-02f, -5.99895269e-02f, -2.08604671e-02f, -4.64613885e-02f, -8.10082778e-02f, -2.26036273e-02f, 4.71947826e-02f, -7.84444511e-02f, 6.89809620e-02f, -9.42642018e-02f,
  7.80251995e-02f, -9.84923020e-02f, -7.29028806e-02f, -4.34015803e-02f, 8.50346908e-02f, 6.83976710e-02f, -6.89689443e-02f, -7.00946227e-02f, -3.53507958e-02f, -4.89564054e-02f,
  -2.85361381e-03f, -1.30249634e-02f, -6.89781681e-02f, -5.27370255e-03f, 2.68185772e-02f, -7.09768981e-02f, -6.32766709e-02f, -3.67331877e-02f, 6.81986194e-03f, 6.81827366e-02f,
  2.47104485e-02f, -1.93876587e-02f, -3.74974087e-02f, -6.26064613e-02f, 9.77010746e-03f, 8.85676742e-02f, -8.76495093e-02f, 4.33425829e-02f, 1.03679821e-01f, -2.55554840e-02f,
  1.02348715e-01f, 5.88668250e-02f, 7.14924634e-02f, 1.17934480e-01f, -4.12763059e-02f, 5.49066486e-03f, 4.67365980e-02f, -1.20486906e-02f, -3.32181416e-02f, 6.58625662e-02f,
  5.64770699e-02f, 5.28416820e-02f, 3.57544050e-02f, -4.87615131e-02f, 8.52387324e-02f, 5.80891706e-02f, 1.63526610e-02f, 1.11414917e-01f, -3.75334248e-02f, -5.10524102e-02f,
  -3.04873466e-01f, 5.72023466e-02f, -7.86777437e-02f, -1.07790351e-01f, 1.08215421e-01f, 3.44944671e-02f, 1.27751961e-01f, 7.51666054e-02f, 3.76039632e-02f, 1.24917224e-01f,
  8.55704844e-02f, -1.10177770e-02f, -3.22244614e-02f, 4.84484434e-03f, 5.20798564e-02f, 3.69424075e-02f, 9.22394618e-02f, -1.49273843e-01f, -1.06052950e-01f, -1.38031378e-01f,
  1.12034306e-01f, -8.94682191e-04f, -2.30475798e-01f, -1.15560979e-01f, -1.35153905e-02f, -5.51494807e-02f, -1.81989297e-02f, -3.90568972e-02f, 7.68204555e-02f, 6.77986518e-02f,
  -1.19032189e-01f, -4.70042937e-02f, -4.22338136e-02f, -9.44614783e-03f, 6.04420044e-02f, 2.30301041e-02f, -6.21244404e-03f, -1.00921012e-01f, -8.91887248e-02f, 1.23110497e-02f,
  -1.48781752e-02f, -6.37391582e-02f, 3.17479670e-02f, -4.13438268e-02f, -1.52593814e-02f, -3.03353742e-03f, 8.23875982e-03f, -3.73256207e-02f, -3.53394970e-02f, 1.66152678e-02f,
  2.50727721e-02f, 1.01965524e-01f, -1.01076998e-01f, -1.78322401e-02f, -3.12683322e-02f, 3.65821384e-02f, -1.82138123e-02f, -1.25596330e-01f, -3.52661423e-02f, -1.58880189e-01f,
  4.41651966e-04f, 4.04508077e-02f, 8.90202746e-02f, -6.09450787e-02f, -1.34979794e-02f, 1.19571276e-01f, 8.11054930e-02f, 1.31375358e-01f, 4.42616194e-02f, 6.86080754e-02f,
  3.41903828e-02f, -5.02224267e-02f, 4.53966595e-02f, -1.13406077e-01f, -4.13066968e-02f, -1.53789101e-02f, -4.46245000e-02f, 5.92608526e-02f, -1.52774304e-02f, 3.93821895e-02f,
  3.46388780e-02f, -5.90224564e-02f, -9.07787979e-02f, -4.42461409e-02f, 1.23806208e-01f, -2.18450488e-03f, -5.10235392e-02f, -6.76551089e-02f, -2.19985023e-02f, 2.65112109e-02f,
  -2.06441164e-01f, -2.27369787e-03f, -3.41156013e-02f, -4.95851524e-02f, 7.11250901e-02f, -2.74695493e-02f, 7.68771395e-02f, -3.45980152e-02f, -4.55350690e-02f, -2.93670334e-02f,
  6.08740607e-03f, -9.56096873e-02f, 2.12931167e-02f, -5.43597564e-02f, -9.56432745e-02f, -9.15283188e-02f, -4.06455249e-02f, -3.79448347e-02f, 6.61695898e-02f, -4.50008214e-02f,
  5.80155924e-02f, -8.54335576e-02f, 8.39714985e-03f, -5.94158322e-02f, 4.29537036e-02f, -3.49773169e-02f, -8.65627080e-02f, -1.14694439e-01f, -1.00651473e-01f, -1.30896822e-01f,
  4.19198442e-03f, -1.14018582e-01f, -8.04519355e-02f, -5.44272661e-02f, 5.16219251e-02f, -6.59443587e-02f, 2.77093686e-02f, 5.54306507e-02f, -1.46466633e-02f, -8.42652023e-02f,
  -6.40132278e-02f, 7.52176270e-02f, 1.72260199e-02f, 1.13330238e-01f, 1.04126096e-01f, -5.08637838e-02f, -1.05770245e-01f, -5.60308136e-02f, 5.91907054e-02f, 7.81509373e-03f,
  -1.56208770e-02f, -8.70657340e-02f, 6.39099777e-02f, 4.73545603e-02f, -4.36841808e-02f, -5.38803041e-02f, -5.74490018e-02f, 5.73819615e-02f, 3.31734233e-02f, 2.47708126e-03f,
  1.29755521e-02f, -1.57864317e-02f, 1.06323278e-02f, -6.69543748e-04f, -5.85534275e-02f, 7.15165883e-02f, 6.96609765e-02f, 4.72454019e-02f, -4.77155522e-02f, -4.76254150e-02f,
  3.73730324e-02f, 4.72085178e-02f, -3.91424149e-02f, 3.94915007e-02f, 3.89015488e-02f, -3.41077521e-02f, 6.72569722e-02f, 2.72786170e-02f, -1.36859007e-02f, 1.40883243e-02f,
  -1.85096525e-02f, 2.83747409e-02f, 8.79097655e-02f, 8.84126425e-02f, 6.55287132e-02f, 5.21773696e-02f, 1.06419407e-01f, 7.33237341e-03f, 6.41102567e-02f, -7.46818818e-03f,
  4.76561189e-02f, -5.94384968e-02f, 6.87705353e-02f, -5.45579158e-02f, -4.76864818e-03f, -5.00631295e-02f, -5.01622222e-02f, -4.24790606e-02f, 5.24684787e-02f, 8.40846896e-02f,
  -6.46393821e-02f, 5.60851283e-02f, -3.03007420e-02f, -8.31433162e-02f, -1.67039055e-02f, 4.34433483e-02f, 6.71438947e-02f, -3.46411765e-02f, 3.25924680e-02f, 2.51629706e-02f,
  -1.45063614e-02f, 2.75065117e-02f, -3.79295126e-02f, -8.40163603e-02f, -6.25793338e-02f, 1.86301023e-02f, 6.35148957e-02f, 2.90526431e-02f, -2.93101799e-02f, -4.78476658e-02f,
  6.10515894e-03f, 2.65759863e-02f, -2.12599691e-02f, 5.38910404e-02f, -7.06486702e-02f, 7.09857419e-03f, -2.11066436e-02f, -2.03541964e-02f, 1.17877517e-02f, 1.66045483e-02f,
  -1.16990311e-02f, 4.68732156e-02f, 8.91272947e-02f, 3.74737382e-02f, 3.42247225e-02f, -3.49917635e-02f, -2.15824461e-03f, -3.97799425e-02f, -3.22412811e-02f, -5.36994115e-02f,
  -8.74953941e-02f, 1.72083657e-02f, 2.55677141e-02f, -1.39391441e-02f, 6.71682134e-02f, 1.23270899e-02f, 3.62982438e-03f, 3.97885442e-02f, 5.63686937e-02f, -1.80622749e-02f,
  2.34044269e-01f, 1.07425870e-02f, 1.64900452e-01f, 1.09258674e-01f, 5.18025197e-02f, 1.33187979e-01f, 3.92187051e-02f, 8.19410384e-02f, 7.44587556e-02f, 9.98003110e-02f,
  9.16465372e-02f, 1.17710501e-01f, 4.73830625e-02f, 5.72353490e-02f, 1.27323821e-01f, -3.05333976e-02f, -7.35920668e-02f, 5.49506694e-02f, 5.91378883e-02f, 3.03515419e-02f,
  1.05909770e-04f, -9.17808153e-03f, 3.93412113e-02f, 1.94228087e-02f, 3.66460579e-03f, -2.39231493e-02f, -9.44142137e-03f, 1.22695945e-01f, 9.18473229e-02f, -7.37296268e-02f,
  1.05793409e-01f, 2.01223686e-01f, -7.43057728e-02f, 5.72428890e-02f, -3.30479406e-02f, -4.04339433e-02f, 2.09540501e-02f, -5.39446063e-02f, 6.94614311e-04f, -9.23712850e-02f,
  3.74282226e-02f, 7.90677033e-03f, 7.13381246e-02f, 3.43337879e-02f, -7.66684934e-02f, -1.38711352e-02f, 1.60565693e-02f, 9.25524309e-02f, 5.18754162e-02f, -3.87651548e-02f,
  -3.76156829e-02f, 2.72404067e-02f, 1.55611942e-02f, 3.70107079e-03f, 4.48379554e-02f, -4.39101942e-02f, 6.65914714e-02f, -3.11984476e-02f, 9.04433243e-03f, 4.58697155e-02f,
  4.81217913e-02f, 5.22493497e-02f, 6.73767924e-02f, -2.64334008e-02f, -6.16975389e-02f, -8.38480715e-04f, -5.15282191e-02f, 2.48557031e-02f, 3.05244867e-02f, -3.77700739e-02f,
  2.64778677e-02f, 7.93829262e-02f, 8.70577693e-02f, -2.77348030e-02f, -6.60637245e-02f, 5.03302254e-02f, -5.20232394e-02f, -3.28859277e-02f, 1.08485349e-01f, 7.52040446e-02f,
  -4.09425907e-02f, -5.80641255e-02f, 7.44614452e-02f, -3.60947438e-02f, 1.27522042e-02f, -1.05086789e-02f, -5.95615990e-02f, 8.87214094e-02f, -7.27531463e-02f, 3.14004235e-02f,
  -6.15464821e-02f, 5.98393902e-02f, -1.39750717e-02f, 1.67762320e-02f, -7.09273294e-02f, 3.93373445e-02f, 2.48290077e-02f, -1.11305555e-02f, -4.98809889e-02f, 1.73329674e-02f,
  -5.62286489e-02f, -2.61075124e-02f, 2.01647449e-02f, -8.32519084e-02f, -1.05277076e-01f, 4.18789871e-02f, -5.68531714e-02f, -2.20928658e-02f, 2.42402013e-02f, -7.82215036e-03f,
  -5.85564822e-02f, -1.44201383e-01f, 3.47525179e-02f, -8.79090950e-02f, -2.57097408e-02f, 2.26624683e-03f, -4.69900034e-02f, 1.62217170e-02f, -3.60752158e-02f, -5.32332622e-02f,
  -2.07201257e-01f, -5.01466170e-02f, -2.18425561e-02f, -6.63572326e-02f, 3.30280066e-02f, 6.66102916e-02f, 5.26532978e-02f, -8.81216601e-02f, -9.40345824e-02f, -8.07632878e-02f,
  3.06178574e-02f, -4.93614711e-02f, -2.46927626e-02f, -8.80028903e-02f, -1.23439275e-01f, 1.32857496e-02f, -4.80825230e-02f, -9.43603069e-02f, -9.03473347e-02f, -5.18909991e-02f,
  6.65132105e-02f, 2.01120973e-02f, -5.41483723e-02f, -4.92154323e-02f, 6.13279603e-02f, 4.14568745e-02f, -8.81962925e-02f, -9.29212198e-02f, 5.45501187e-02f, -3.12014148e-02f,
  1.49167441e-02f, 5.52049167e-02f, 1.79215670e-02f, -1.03925471e-03f, -6.09163158e-02f, -4.69030291e-02f, -1.79597493e-02f, 6.73653856e-02f, 1.66794844e-02f, -2.10063402e-02f,
  -1.67079791e-02f, -9.44343768e-03f, -2.79766601e-02f, 6.36196211e-02f, 3.91245726e-03f, -4.16473746e-02f, 3.81121784e-02f, 5.75764887e-02f, 5.26352338e-02f, 9.93212219e-03f,
  1.62256940e-03f, 6.79209977e-02f, -1.20251635e-02f, -4.37440388e-02f, 6.68102205e-02f, -4.22210246e-02f, 3.58277522e-02f, 3.91338132e-02f, 6.62383363e-02f, -2.60340199e-02f,
  -7.67583773e-02f, -4.22406569e-02f, -1.32503845e-02f, 5.71285337e-02f, -1.85314547e-02f, 3.56957726e-02f, 6.75735325e-02f, -7.25269224e-03f, -6.15763105e-02f, 8.34012479e-02f,
  8.32862630e-02f, 4.11746167e-02f, 6.68784603e-02f, -4.04041037e-02f, 1.28058895e-01f, -5.13482727e-02f, -4.49686944e-02f, 6.59367219e-02f, 8.88601691e-02f, -2.96152439e-02f,
  2.55590826e-02f, -5.31366700e-03f, 7.72595108e-02f, 1.72124840e-02f, -3.32695320e-02f, 8.56872648e-03f, 1.28477076e-02f, 2.38427166e-02f, -3.99540178e-02f, 5.51704057e-02f,
  -1.28716752e-01f, 5.19765578e-02f, -5.14930040e-02f, -6.40104339e-02f, -4.06223796e-02f, 9.46059451e-02f, -2.07634196e-02f, -5.31008877e-02f, -6.47065043e-02f, -4.91784848e-02f,
  3.77873145e-02f, -4.73905914e-02f, -5.58856651e-02f, -8.49704891e-02f, -1.12238236e-01f, -8.32683966e-02f, 5.33937663e-03f, -2.43077818e-02f, -7.13791093e-03f, 7.35673606e-02f,
  6.68000728e-02f, -6.10731021e-02f, -1.26209334e-02f, 3.36132534e-02f, -5.96898282e-03f, -6.19156547e-02f, 5.46715083e-03f, -6.29302338e-02f, -1.56741105e-02f, -4.34109941e-02f,
  -8.21258314e-03f, -1.50567770e-01f, -4.38189059e-02f, 2.62617636e-02f, -9.07473415e-02f, 3.48784495e-03f, -7.15993643e-02f, 6.13568991e-04f, 1.31662726e-01f, -3.00796945e-02f,
  7.79344141e-02f, 1.28621951e-01f, 1.02312528e-01f, 4.89515699e-02f, 2.49410830e-02f, -1.34640947e-01f, -1.23330660e-01f, 8.94525126e-02f, 1.58571735e-01f, -3.91590111e-02f,
  -5.15184700e-02f, -2.19742861e-02f, 5.38337864e-02f, 1.00045890e-01f, -9.82202962e-02f, 7.88040161e-02f, 9.34565067e-03f, -1.15607925e-01f, -1.00702057e-02f, -1.10845678e-01f,
  -1.41852438e-01f, 8.18061754e-02f, 7.07374187e-03f, 2.62998301e-03f, -1.12182721e-01f, -4.13922779e-02f, 1.73121821e-02f, -6.71098605e-02f, -4.50524576e-02f, 6.09616190e-02f,
  9.07475501e-02f, -4.41587977e-02f, -9.14112944e-03f, -5.92106469e-02f, -3.90344206e-03f, 3.74036878e-02f, 4.92086858e-02f, -5.41966595e-02f, -7.53028691e-02f, -7.29701072e-02f,
  -3.37157324e-02f, -1.45945214e-02f, -8.87019485e-02f, -7.46044144e-02f, -5.31290583e-02f, -7.19826221e-02f, -1.00520946e-01f, 1.25881638e-02f, -4.30359505e-02f, -1.27590060e-01f,
  7.94906076e-03f, -4.96317074e-02f, -1.71345584e-02f, -2.39155479e-02f, -2.26733517e-02f, 2.38023140e-02f, -2.27956218e-03f, -4.55240645e-02f, -7.02080801e-02f, 6.51141405e-02f,
  2.82856897e-02f, 8.44608620e-02f, -6.52061030e-02f, -5.66751212e-02f, -2.76045687e-02f, -5.21903411e-02f, -2.49271821e-02f, 7.95997009e-02f, -7.57762836e-03f, 6.37202486e-02f,
  1.36449710e-02f, 7.16570318e-02f, -3.53045426e-02f, 7.30241612e-02f, -8.31696093e-02f, 9.38359573e-02f, 5.41678667e-02f, 1.78433694e-02f, 8.56733248e-02f, 6.75971583e-02f,
  -3.93874757e-02f, -7.69723160e-03f, 4.39501069e-02f, -4.92849462e-02f, 3.28088924e-02f, 5.78425825e-02f, 5.54527789e-02f, 2.26957388e-02f, -2.58574132e-02f, -5.77435782e-03f,
  -8.21015798e-03f, 1.07118636e-01f, 2.36193798e-02f, -5.05955843e-03f, -6.60236552e-02f, 2.18447335e-02f, -7.50505030e-02f, 9.23623145e-02f, -4.67769355e-02f, -7.59130623e-03f,
  -4.05752845e-02f, 7.11232871e-02f, 4.44465019e-02f, -2.15057898e-02f, -8.55025649e-02f, 5.80763258e-02f, 3.32925431e-02f, -3.83026078e-02f, 5.14977276e-02f, -2.72640958e-02f,
  5.57005964e-02f, 1.27668893e-02f, 1.02859609e-01f, -7.74467073e-04f, 7.35669285e-02f, 2.76241563e-02f, 1.06843464e-01f, 6.89642355e-02f, 6.24768175e-02f, -1.66505519e-02f,
  2.23732833e-02f, -6.98782057e-02f, 1.92387644e-02f, -4.48664613e-02f, 2.09394414e-02f, 8.47982839e-02f, 9.02619436e-02f, -2.71953158e-02f, 2.41126344e-02f, -6.91399351e-02f,
  -5.83130261e-03f, -6.42845780e-02f, 4.43876866e-04f, 4.77738902e-02f, 8.44174325e-02f, -5.15768975e-02f, 6.11402690e-02f, -4.68219928e-02f, -4.41950113e-02f, 1.49435215e-02f,
  6.19531386e-02f, 9.17347707e-03f, 4.99475300e-02f, -5.14039062e-02f, -1.45327551e-02f, -5.05654290e-02f, -2.54225247e-02f, -1.71077773e-02f, 4.95945029e-02f, 8.53800960e-03f,
  -3.77597250e-02f, 6.78549409e-02f, -4.66030166e-02f, 2.51216218e-02f, 8.34894627e-02f, 6.07590750e-02f, 8.50257203e-02f, 6.72438890e-02f, -8.50695148e-02f, 5.35860620e-02f,
  -2.73667146e-02f, -3.63866426e-03f, -1.51956733e-02f, -5.19346669e-02f, 2.96741910e-02f, 5.20799793e-02f, -5.40149696e-02f, -2.86023393e-02f, 2.36433651e-02f, 4.47361358e-03f,
  1.21628866e-02f, -3.30127068e-02f, 7.59535506e-02f, -3.89639139e-02f, 9.05579850e-02f, 2.89872736e-02f, 6.72161430e-02f, 1.32599170e-03f, -3.79736722e-02f, -5.08931391e-02f,
  2.67393328e-02f, -4.71909647e-04f, 8.05921257e-02f, 8.50222483e-02f, -7.04642013e-02f, 1.02815337e-01f, 3.97312827e-02f, 9.45207030e-02f, -6.48376495e-02f, -7.99511820e-02f,
  4.73129153e-02f, -5.46772219e-02f, 3.96511890e-02f, 1.18757505e-02f, 8.07395279e-02f, 4.72517870e-02f, 3.72479670e-02f, 3.28051187e-02f, 3.71713005e-02f, 7.40038184e-03f,
  -6.27166629e-02f, 2.62613595e-03f, 3.07013411e-02f, -1.14654759e-02f, -7.56132007e-02f, 6.88928440e-02f, 7.09337834e-03f, 1.65542681e-02f, -4.16631438e-02f, -8.07124283e-03f,
  3.31484750e-02f, 5.56191094e-02f, 5.22606932e-02f, -7.10957199e-02f, -2.54412498e-02f, -7.53761008e-02f, 5.78854345e-02f, 7.12331310e-02f, -8.60818774e-02f, -3.18039842e-02f,
  4.15786169e-02f, 6.45149872e-02f, -7.20234886e-02f, -3.45956981e-02f, -5.87780774e-02f, -7.17115030e-02f, 4.94897962e-02f, 8.44161585e-02f, -1.68728866e-02f, -1.01820961e-01f,
  4.15551066e-02f, -5.50632775e-02f, -2.53908001e-02f, 4.91584577e-02f, -3.11669186e-02f, -2.54653804e-02f, -9.86913070e-02f, 2.89156586e-02f, -1.13083579e-01f, -1.00965552e-01f,
  6.42693695e-03f, -7.41253421e-02f, -7.42183179e-02f, -4.99386480e-03f, -7.04757646e-02f, -5.00414595e-02f, 3.05463839e-02f, -6.42590895e-02f, -5.57892025e-02f, -3.17104682e-02f,
  -1.45517528e-01f, -2.54646875e-02f, -2.53694709e-02f, -2.31738649e-02f, 1.25410687e-02f, -7.43199959e-02f, -1.05139375e-01f, -1.41557418e-02f, 1.06118685e-02f, -4.69193198e-02f,
  -8.64957049e-02f, 9.86562371e-02f, 5.83560579e-02f, -2.21661720e-02f, -7.77992420e-03f, -8.11706036e-02f, -5.78165725e-02f, 3.83113809e-02f, 5.16006388e-02f, 1.14184516e-02f,
  -1.60212293e-02f, 3.26015055e-02f, 3.36119793e-02f, 4.60748412e-02f, 6.29912987e-02f, -7.60656074e-02f, -1.06703706e-01f, -1.33797422e-03f, 1.25389565e-02f, -1.15637951e-01f,
  -1.23195425e-01f, 5.99899404e-02f, 7.09165931e-02f, -4.10996098e-03f, 4.70404662e-02f, 6.11404739e-02f, 1.19295856e-02f, 6.29935414e-02f, 1.12257581e-02f, -9.28192288e-02f,
  7.17037693e-02f, -1.42310802e-02f, -5.81678636e-02f, 6.56312630e-02f, 8.87484029e-02f, 1.09236516e-01f, 1.01007655e-01f, -4.89262538e-03f, -5.11769531e-03f, -4.32672128e-02f,
  -1.05795391e-01f, 3.05290390e-02f, 9.84734148e-02f, 4.92050080e-03f, -2.58249473e-02f, -7.75372982e-02f, -7.51531571e-02f, -9.45746750e-02f, 3.02785300e-02f, 4.13277512e-03f,
  8.19760785e-02f, 5.37944660e-02f, 1.81924552e-02f, -6.01203591e-02f, 5.27437357e-03f, -1.30257439e-02f, -5.69250844e-02f, -9.32143256e-02f, 7.84938484e-02f, 2.18303576e-02f,
  -4.21578474e-02f, -3.56892720e-02f, -6.22720346e-02f, 1.21113695e-02f, 1.02039948e-01f, -4.26443852e-02f, 1.94413979e-02f, 5.58543280e-02f, 1.07041813e-01f, 9.98094529e-02f,
  3.77404061e-03f, -9.60574374e-02f, 7.07711279e-02f, -8.81579667e-02f, -3.17871831e-02f, -3.52648124e-02f, 1.13785081e-02f, -5.78884780e-02f, 5.66760339e-02f, -6.16334891e-03f,
  -9.57443789e-02f, 7.54910633e-02f, 5.52293807e-02f, -3.76360714e-02f, 1.04885818e-02f, 1.49130195e-01f, 1.77663229e-02f, -3.77668589e-02f, -4.35560048e-02f, 5.33200316e-02f,
  2.68922057e-02f, -1.06472611e-01f, 1.54136524e-01f, 6.34125844e-02f, 1.11390062e-01f, 1.53372169e-01f, 1.40590236e-01f, -1.38704805e-02f, -1.28952011e-01f, -2.36214846e-02f,
  -2.41178414e-03f, -1.53245568e-01f, -6.14881441e-02f, -1.64105952e-01f, -1.01674393e-01f, -1.84503905e-02f, -1.78660136e-02f, -4.62666452e-02f, 8.75855982e-03f, -8.30607191e-02f,
  -4.05041091e-02f, 7.68391937e-02f, -1.50876781e-02f, -7.94490892e-03f, 5.57591729e-02f, -1.28138006e-01f, 6.64742216e-02f, 1.06869740e-02f, 2.97215004e-02f, 6.27924874e-02f,
  1.43084556e-01f, 1.32801637e-01f, -1.08667528e-02f, -1.10575587e-01f, 6.42271042e-02f, -8.75150599e-03f, 1.49463816e-02f, -1.00865196e-02f, 3.07643246e-02f, 5.87456673e-03f,
  -5.00274301e-02f, -9.46699083e-02f, -7.04859123e-02f, 4.66158390e-02f, -8.99086222e-02f, -1.77983996e-02f, -4.19724640e-03f, 6.81152642e-02f, -3.33827431e-03f, -1.70682278e-03f,
  -6.82740137e-02f, 1.35103418e-02f, 8.35990459e-02f, 8.03647935e-02f, 6.58699721e-02f, 2.82704663e-02f, -5.72616570e-02f, -3.22118327e-02f, 8.28935858e-03f, -7.33937994e-02f,
  4.55500931e-02f, -1.28217600e-02f, -2.57012583e-02f, 6.31511882e-02f, -8.21791664e-02f, 3.66366915e-02f, -4.74986713e-03f, -3.89195606e-02f, -2.62659751e-02f, -7.45741203e-02f,
  4.39833775e-02f, 3.92914489e-02f, -2.93201115e-02f, -6.99891597e-02f, 3.81702408e-02f, 7.71574676e-02f, 6.37087151e-02f, -6.90731108e-02f, -6.34560511e-02f, 6.06372058e-02f,
  -3.48477587e-02f, -1.66829042e-02f, 4.31054793e-02f, 3.64625677e-02f, 1.81970708e-02f, 3.29873525e-02f, -2.58746929e-02f, -4.08332497e-02f, 6.11791238e-02f, 8.63647982e-02f,
  9.89827979e-03f, -3.13470289e-02f, 4.59180139e-02f, -5.22319786e-02f, 1.73617862e-02f, -1.02739386e-01f, -9.54075437e-03f, 4.52584550e-02f, -6.89096227e-02f, 2.23677531e-02f,
  5.33413962e-02f, 3.22792754e-02f, -9.62855741e-02f, -3.48427296e-02f, -2.32033916e-02f, 5.48306666e-03f, 4.16487902e-02f, -2.52782442e-02f, 5.47399484e-02f, 2.96268687e-02f,
  6.66106567e-02f, 2.93469857e-02f, 1.09092155e-02f, -2.42431951e-03f, 4.98032458e-02f, -2.53852215e-02f, 1.22796528e-01f, -2.30762810e-02f, -1.49120193e-03f, -4.22789417e-02f,
  1.69345543e-01f, -9.85151678e-02f, 4.17789705e-02f, -6.95783645e-02f, -5.94497733e-02f, 6.14924133e-02f, -1.21140443e-01f, -3.08531020e-02f, -5.16660139e-02f, -3.77454273e-02f,
  -7.90126473e-02f, 9.48478933e-03f, 4.34758700e-02f, -7.73998797e-02f, -8.03086236e-02f, -5.35337739e-02f, 3.09716109e-02f, 5.52857816e-02f, 9.39537957e-02f, 1.66196618e-02f,
  -6.43715113e-02f, -4.37892377e-02f, 7.97105301e-03f, -1.91039555e-02f, -6.21687900e-03f, 1.95815992e-02f, -6.58329725e-02f, -4.86790203e-02f, 1.72340423e-02f, -5.02770767e-02f,
  -7.02134445e-02f, 3.01312525e-02f, 9.97280702e-02f, -9.38009247e-02f, 1.82523970e-02f, -4.66815792e-02f, -5.07359207e-02f, 1.01609677e-01f, -6.66762814e-02f, 4.22395580e-02f,
  -2.63841227e-02f, 9.85643417e-02f, 5.95411658e-02f, 8.49911943e-02f, 2.32562032e-02f, 6.99950606e-02f, 2.03773305e-02f, -3.20853293e-02f, 1.00375727e-01f, -2.24763062e-02f,
  -5.84721044e-02f, -2.85320263e-02f, 2.62172874e-02f, -2.34555341e-02f, 1.03813462e-01f, 2.46514045e-02f, -4.23323438e-02f, -8.40732362e-03f, -2.29789559e-02f, 7.18742609e-02f,
  9.77318734e-03f, 9.41048190e-02f, -4.50508520e-02f, -5.74074946e-02f, 3.46368030e-02f, -7.25656226e-02f, -5.90326674e-02f, 7.47938305e-02f, 2.30701342e-02f, -1.69544257e-02f,
  -2.05168575e-02f, -7.85145685e-02f, -2.11487804e-02f, -5.25160320e-02f, -4.55558707e-04f, -1.53662246e-02f, -7.26239383e-02f, 6.89704344e-02f, -7.33721629e-02f, -3.96462455e-02f,
  -9.18025747e-02f, -7.75099024e-02f, -1.01925870e-02f, 2.14794301e-03f, 4.99225594e-02f, -2.92578321e-02f, 7.98491687e-02f, 5.33182360e-02f, -6.57430813e-02f, 1.63074806e-02f,
  4.63009514e-02f, -7.80794844e-02f, -8.23889021e-03f, 8.35038871e-02f, -9.05977096e-03f, -6.01554029e-02f, -7.20730871e-02f, -6.46151602e-02f, 2.09948625e-02f, 5.71330916e-03f,
  -6.82492554e-02f, -6.89057037e-02f, 1.67639852e-02f, 1.27209704e-02f, -8.22281092e-02f, -1.87876914e-02f, 3.48362774e-02f, 3.46634760e-02f, 5.56241125e-02f, 5.17023169e-02f,
  -4.08425927e-03f, -6.33822680e-02f, -7.25446865e-02f, -3.19930427e-02f, 6.11710399e-02f, 4.73880097e-02f, -6.80704564e-02f, 5.81951849e-02f, 3.28406617e-02f, 9.10026580e-02f,
  -7.04736933e-02f, 2.01188959e-02f, -3.61092127e-04f, 8.32283050e-02f, 6.90514396e-04f, 2.39224732e-02f, 5.85377067e-02f, -2.63303313e-02f, 3.84369632e-04f, -6.53045252e-02f,
  -3.35156173e-02f, -7.42057711e-02f, 4.18450311e-02f, -9.28800628e-02f, -2.62217559e-02f, 1.69790233e-04f, -7.35699385e-02f, 6.02166876e-02f, -5.42731695e-02f, -6.55933172e-02f,
  -1.11020980e-02f, 6.29734546e-02f, 1.93017013e-02f, 6.05615824e-02f, 4.86506559e-02f, -8.90592560e-02f, -4.11949791e-02f, -3.84660885e-02f, -1.16872080e-01f, 1.95924193e-02f,
  5.33837751e-02f, -3.10426578e-02f, -7.90167674e-02f, -1.17038608e-01f, 4.52947319e-02f, 7.67197832e-02f, 2.57098712e-02f, -7.52708763e-02f, -1.01998053e-01f, -3.42385769e-02f,
  -8.48619491e-02f, 6.42572120e-02f, -1.63763426e-02f, 5.30137904e-02f, 2.63142344e-02f, 5.74561208e-02f, 5.08824214e-02f, 5.72839566e-02f, 2.70169023e-02f, -7.22785145e-02f,
  -1.70093551e-02f, 3.55726779e-02f, 9.50134471e-02f, 4.56721783e-02f, 1.66763160e-02f, 4.10653725e-02f, 4.33466248e-02f, -3.99805941e-02f, -3.65941525e-02f, -5.97205386e-02f,
  -2.73244288e-02f, 7.59774670e-02f, 2.43683942e-02f, -5.10285944e-02f, -5.19782603e-02f, -2.12287866e-02f, 2.17387546e-02f, -8.08411092e-02f, -1.75569858e-02f, 8.50453675e-02f,
  7.96176717e-02f, -3.45382094e-02f, -4.53632325e-02f, 3.85292061e-02f, -9.26517919e-02f, -5.75200953e-02f, 9.24595073e-02f, -7.11362138e-02f, -4.41347212e-02f, 1.37045775e-02f,
  3.21909599e-02f, 8.05599838e-02f, 6.52941912e-02f, 3.34222354e-02f, -6.12718463e-02f, 6.03932068e-02f, -5.55397235e-02f, 6.92224279e-02f, 6.56934306e-02f, -3.45257260e-02f,
  1.38804931e-02f, 9.74209141e-03f, 2.75721624e-02f, -5.12710400e-02f, 9.45875719e-02f, -2.01457776e-02f, 7.86580220e-02f, 5.54031953e-02f, -4.67374511e-02f, -8.75230953e-02f,
  8.48287344e-03f, -3.89158875e-02f, -9.69764888e-02f, 3.32429931e-02f, -7.44833201e-02f, 8.73486251e-02f, -5.83769754e-02f, -2.56285388e-02f, -1.80553440e-02f, 3.91425602e-02f,
  2.73398384e-02f, 1.16516754e-01f, -2.59932522e-02f, 8.74250084e-02f, 1.06732301e-01f, 1.20009325e-01f, -4.91552018e-02f, 2.06400733e-02f, 7.73926899e-02f, 2.83134729e-02f,
  3.09002250e-01f, -1.35999948e-01f, 6.98540658e-02f, 5.72415479e-02f, -6.97403103e-02f, -2.84001455e-02f, 6.31494522e-02f, -9.11434926e-03f, 3.90306972e-02f, 4.80975062e-02f,
  1.59833692e-02f, 8.35696906e-02f, -1.22065172e-02f, -3.88545431e-02f, -1.29545247e-02f, -5.87105341e-02f, 3.57879475e-02f, 9.76226404e-02f, 1.78968191e-01f, 1.08127810e-01f,
  -5.90300038e-02f, 5.81610575e-02f, 4.28434946e-02f, 1.02695003e-01f, -4.79595736e-02f, 4.29340340e-02f, 9.06788930e-03f, -9.91670117e-02f, -4.30699773e-02f, 1.74247473e-02f,
  -7.40972441e-03f, 1.19042002e-01f, 6.63288385e-02f, 4.96563092e-02f, -7.61644766e-02f, 7.30618183e-03f, -8.75120983e-02f, -1.58132538e-02f, -2.38197073e-02f, -1.79860517e-02f,
  -3.35164219e-02f, 5.26592955e-02f, 3.81276757e-02f, 1.24766687e-02f, -2.97631025e-02f, 3.11372951e-02f, 4.81799804e-02f, 7.45177120e-02f, 9.41137075e-02f, -9.80530605e-02f,
  -1.09415859e-01f, -3.26228291e-02f, 8.23414177e-02f, -1.12999557e-02f, -4.70544286e-02f, 3.21346298e-02f, -7.37282187e-02f, 8.26385915e-02f, 8.85967445e-03f, -3.28472927e-02f,
  1.14690159e-02f, -9.90083069e-03f, -4.45279814e-02f, 2.66592558e-02f, 9.31241661e-02f, -5.86816818e-02f, 2.89888550e-02f, -1.17387623e-03f, -3.98516357e-02f, -8.93876329e-03f,
  3.90009210e-02f, 7.76496381e-02f, 1.38100004e-02f, 9.07937214e-02f, -4.18772474e-02f, 4.63265479e-02f, -1.72265302e-02f, 3.39483395e-02f, -3.86574864e-02f, 5.64267188e-02f,
  -4.01954092e-02f, 1.75421499e-02f, 1.17438957e-01f, -5.43176793e-02f, 3.36148627e-02f, 4.95226830e-02f, 4.09137048e-02f, 7.88811967e-02f, 9.51038301e-02f, 8.13549459e-02f,
  -9.12107006e-02f, 9.75440219e-02f, 4.15192507e-02f, -1.03761600e-02f, -1.91983376e-02f, -2.01612487e-02f, 2.29842607e-02f, 2.64744665e-02f, -1.00902840e-01f, -3.09818387e-02f,
  -8.95674229e-02f, -6.48303404e-02f, -6.25004470e-02f, -1.19049521e-02f, 1.02990516e-03f, 2.95905937e-02f, -5.93318650e-03f, 1.18928645e-02f, 4.78820726e-02f, -5.33520058e-02f,
  7.33365305e-03f, -7.13048503e-02f, 1.95028484e-02f, 4.10211496e-02f, -9.49673075e-03f, 2.34083682e-02f, -1.02496669e-02f, -6.52479157e-02f, 8.49337652e-02f, -1.40024036e-01f,
  -4.53355223e-01f, -1.25866771e-01f, -2.20343679e-01f, -2.71373540e-01f, -4.21560518e-02f, 1.14910342e-01f, 7.62988031e-02f, 1.65787011e-01f, -1.07151652e-02f, -9.54653621e-02f,
  -4.60494570e-02f, 6.75783306e-02f, -1.59794554e-01f, -6.87519163e-02f, -3.69189531e-02f, -9.28764865e-02f, -1.51173532e-01f, -8.01972672e-02f, 6.37701973e-02f, 7.16425478e-02f,
  3.18766246e-03f, -1.61175519e-01f, -6.52032569e-02f, 2.79837437e-02f, -7.25845322e-02f, 6.41399771e-02f, -6.61707222e-02f, -3.11020892e-02f, 1.67521499e-02f, -1.69125065e-01f,
  -1.99860066e-01f, 1.00249834e-02f, -4.48977463e-02f, -6.78367987e-02f, -7.54672438e-02f, -1.96924191e-02f, 6.52047321e-02f, -8.40380192e-02f, 1.76039636e-02f, -2.24690866e-02f,
  4.54662405e-02f, 8.45693331e-03f, -7.92610571e-02f, 1.05777204e-01f, 4.51914780e-03f, -2.18116250e-02f, 9.73024815e-02f, -1.30110537e-03f, -2.73322780e-02f, 1.04814634e-01f,
  -2.25151498e-02f, 1.18590847e-01f, 3.22292261e-02f, 2.99020931e-02f, 1.11345738e-01f, 9.07846093e-02f, 7.41553232e-02f, 9.17461142e-02f, 9.53235328e-02f, -1.22132100e-01f,
  1.88141186e-02f, -1.41455689e-02f, -7.14907348e-02f, 7.70456791e-02f, -4.68983501e-02f, 3.83532271e-02f, 3.22414115e-02f, -1.68080535e-02f, 7.39645809e-02f, -9.31439325e-02f,
  1.41511941e-02f, -3.01017370e-02f, -2.98838168e-02f, -1.03285410e-01f, -9.18054506e-02f, 6.96494579e-02f, -2.10685916e-02f, -2.79288422e-02f, 6.83440194e-02f, 1.49756055e-02f,
  -1.31595768e-02f, 9.28096026e-02f, -1.24440175e-02f, 3.08344308e-02f, -1.65370610e-02f, -7.45549500e-02f, -3.67110968e-02f, 1.27922535e-01f, 2.54194867e-02f, -4.72870506e-02f,
  -2.67758727e-01f, 1.16263898e-02f, -8.62439722e-02f, 8.15788433e-02f, 4.19051014e-03f, 4.93296832e-02f, -5.60989417e-02f, 6.60884306e-02f, -2.70762090e-02f, 6.24835640e-02f,
  1.03176527e-01f, 9.76432522e-04f, 3.48448455e-02f, -7.30248913e-03f, 6.50270209e-02f, 5.70888668e-02f, 4.01920006e-02f, -2.04281732e-02f, 7.46503919e-02f, 9.72302854e-02f,
  4.85269278e-02f, -5.04534468e-02f, -3.78528014e-02f, -4.66421917e-02f, 2.74746902e-02f, -1.09782265e-02f, -4.53894958e-02f, 6.29817620e-02f, -1.23981461e-02f, -2.09238321e-01f,
  -1.85604379e-01f, -9.66713130e-02f, -1.52854398e-01f, 8.60905722e-02f, 8.17509145e-02f, 1.06781594e-01f, 1.73244402e-01f, 1.45600170e-01f, 6.24956004e-02f, 2.75452789e-02f,
  3.75837013e-02f, 5.58965094e-02f, 1.19144067e-01f, -3.75169627e-02f, -1.16093401e-02f, 4.72555645e-02f, 1.50092438e-01f, -6.32202327e-02f, 6.30072281e-02f, -3.16592380e-02f,
  1.16731010e-01f, -7.50873536e-02f, -3.86494286e-02f, -4.08910550e-02f, 2.68486124e-02f, 8.14812407e-02f, 2.23242007e-02f, 4.06509712e-02f, 6.12719059e-02f, 8.08746554e-03f,
  -8.63383338e-02f, -7.61772096e-02f, -1.32447667e-02f, 1.35885654e-02f, -7.02016577e-02f, -5.98148368e-02f, 1.77806504e-02f, -1.34169638e-01f, -4.61694524e-02f, 6.57086968e-02f,
  -7.64899030e-02f, -6.04211306e-03f, 8.64488110e-02f, 3.24277729e-02f, -2.55058110e-02f, 2.85318820e-03f, 1.55290784e-02f, -1.23118475e-01f, -4.80474308e-02f, -7.51543194e-02f,
  9.22384262e-02f, -3.05602029e-02f, -1.81267872e-01f, -7.31588230e-02f, -7.78826103e-02f, -3.31365801e-02f, -4.08613309e-02f, -7.03269690e-02f, -1.82949286e-02f, -4.97490503e-02f,
  -8.57482329e-02f, 5.00385128e-02f, -8.79888833e-02f, -4.82613314e-03f, -2.38329228e-02f, -1.23928301e-02f, 5.57474978e-02f, 5.39037548e-02f, 8.42772946e-02f, -8.25649872e-02f,
  -5.98484837e-02f, -3.95390801e-02f, -3.44773903e-02f, 4.15419266e-02f, 6.03425279e-02f, 3.49338502e-02f, 6.25619590e-02f, 1.28804930e-02f, 1.14133349e-02f, 4.38500568e-03f,
  -7.10477978e-02f, -6.62077963e-02f, -8.33301172e-02f, -4.30825613e-02f, 9.65449885e-02f, -2.11809995e-03f, 7.34321177e-02f, 6.97379261e-02f, -2.58085020e-02f, -7.89461657e-02f,
  3.96427289e-02f, -7.55344629e-02f, 3.05051934e-02f, -5.61954379e-02f, -5.12660518e-02f, -7.13790208e-02f, -4.24419977e-02f, 9.36513394e-03f, -2.76489221e-02f, -8.23224857e-02f,
  -7.07733557e-02f, 3.10781207e-02f, 2.76092626e-02f, -1.02646962e-01f, 2.18359418e-02f, 4.24621180e-02f, 3.06563396e-02f, 3.05807535e-02f, -1.06509840e-02f, 4.23485041e-02f,
  7.94470161e-02f, -5.67718484e-02f, 4.10364792e-02f, -2.97963489e-02f, -9.53577533e-02f, -3.17225754e-02f, -1.15152493e-01f, -3.47440355e-02f, 8.45239311e-03f, 1.09789276e-03f,
  2.64842808e-01f, -1.40907332e-01f, -1.49719968e-01f, 3.48483287e-02f, -1.25838980e-01f, -1.81124106e-01f, -1.96700439e-01f, -9.05786734e-03f, -5.90318777e-02f, -2.02094018e-01f,
  1.20405611e-02f, 9.72138252e-03f, 1.27741143e-01f, -3.91114987e-02f, -2.28883675e-03f, -1.78345725e-01f, -1.03406526e-01f, -1.08576924e-01f, 8.64856318e-02f, -8.15682635e-02f,
  -3.93136591e-02f, -6.54570907e-02f, 3.37688401e-02f, -4.75527532e-03f, -8.36918652e-02f, -8.97051021e-02f, -6.52831122e-02f, -7.48877078e-02f, -1.14378281e-01f, -2.33162671e-01f,
  -1.46257252e-01f, 2.61461679e-02f, 5.33806719e-02f, 2.13394631e-02f, 4.02585119e-02f, 2.05419641e-02f, -4.65088412e-02f, -7.47047514e-02f, 9.62967426e-02f, 5.51627874e-02f,
  -1.50355687e-02f, -2.90179495e-02f, 8.65926370e-02f, -7.04499185e-02f, -9.08588544e-02f, -8.49393234e-02f, 3.48070636e-02f, 3.28837931e-02f, -2.65643392e-02f, 1.09217716e-02f,
  -3.02600283e-02f, -9.91817340e-02f, -9.45607573e-02f, -1.30509302e-01f, 5.82078248e-02f, 1.14993535e-01f, -6.88788816e-02f, -3.89777012e-02f, -1.06063277e-01f, -1.59120142e-01f,
  -1.09622255e-01f, -3.57002355e-02f, -3.94230522e-02f, -3.98332253e-02f, 9.64106992e-03f, -3.74505557e-02f, -3.63993570e-02f, 3.83436270e-02f, 4.20166627e-02f, 2.37054285e-02f,
  8.71754512e-02f, -3.40658277e-02f, 1.32949762e-02f, -3.74918468e-02f, -4.62022657e-03f, -1.60533823e-02f, 2.07905490e-02f, 1.55249760e-02f, -4.21917997e-02f, 5.18259294e-02f,
  3.38704418e-03f, 2.58298535e-02f, -6.44053146e-02f, 9.07639414e-02f, 8.49848613e-03f, -5.21467440e-02f, -5.29346541e-02f, 1.20917428e-02f, 2.24986896e-02f, -2.04751473e-02f,
  4.92400192e-02f, 1.11906968e-01f, -1.69727691e-02f, 1.16760015e-01f, 2.22624075e-02f, -6.15093000e-02f, 4.16030623e-02f, -5.64726330e-02f, 1.01867892e-01f, -5.27022257e-02f,
  2.65182909e-02f, 3.95288281e-02f, -5.82858697e-02f, 8.35644256e-04f, -9.21432525e-02f, 9.73732118e-03f, -1.22567125e-01f, 8.21290389e-02f, 1.71344858e-02f, -6.80999598e-03f,
  1.59556530e-02f, 5.60462587e-02f, 3.35725956e-02f, -2.98056472e-03f, -4.52694446e-02f, 6.65769652e-02f, 1.64091382e-02f, -1.11284561e-01f, 7.64059052e-02f, -4.61492799e-02f,
  -4.00212593e-02f, -2.59611141e-02f, 3.34217012e-01f, 3.20674986e-01f, 3.88635814e-01f, 5.06473541e-01f, 6.27031624e-01f, 2.82165945e-01f, 1.62449051e-02f, 8.85687768e-02f,
  -8.30324665e-02f, -1.29793227e-01f, -2.76579618e-01f, -2.22274616e-01f, -1.41411331e-02f, 1.82313457e-01f, 1.57860741e-01f, -2.38903593e-02f, 1.36945713e-02f, 1.12333156e-01f,
  1.45851204e-03f, 4.30789851e-02f, -1.07041091e-01f, -1.52660161e-01f, 1.31133586e-01f, -1.84728559e-02f, 4.97600883e-02f, 6.00610226e-02f, -5.28849885e-02f, -1.77937418e-01f,
  -2.07079425e-01f, 1.70821682e-01f, 2.52141748e-02f, -2.32686892e-01f, 6.06284924e-02f, -1.63684055e-01f, -4.07454297e-02f, -6.74123392e-02f, -1.63212810e-02f, -1.14620320e-01f,
  3.60151380e-03f, -8.23610052e-02f, 3.12169082e-02f, -1.44583732e-02f, 7.55358338e-02f, 4.76310067e-02f, -8.96101072e-02f, -6.37112409e-02f, -8.90735909e-02f, -4.16978449e-02f,
  5.84891252e-02f, 3.18547040e-02f, 2.24201962e-01f, 1.12030171e-01f, 8.55394155e-02f, 1.52940601e-02f, 9.95347798e-02f, 8.99502635e-03f, 1.29185528e-01f, -8.09276551e-02f,
  7.62347830e-04f, 8.93711150e-02f, 7.22349510e-02f, -1.00904159e-01f, 1.51903089e-02f, -1.40365341e-03f, 7.77791291e-02f, -1.19729385e-01f, 1.69218972e-01f, -6.39429688e-02f,
  -9.84976813e-02f, -5.65568032e-03f, -5.03228651e-03f, -6.62778551e-03f, -5.75647131e-02f, 8.02652612e-02f, 5.98407909e-02f, -1.99113917e-02f, -6.26914054e-02f, -2.68798284e-02f,
  1.19287316e-02f, 1.40702920e-02f, 1.01054259e-01f, -6.88353628e-02f, 2.08681487e-02f, 5.77239599e-03f, 2.72489581e-02f, -2.71723419e-02f, -6.65661786e-03f, 1.09332475e-04f,
  -2.75001109e-01f, 5.53698186e-03f, -1.76743865e-01f, -1.06263734e-01f, 4.74774241e-02f, -1.16032109e-01f, 2.12574303e-02f, 4.68712021e-03f, -2.29196940e-02f, 5.75541258e-02f,
  1.05823856e-02f, -5.29229939e-02f, -3.67292054e-02f, 3.84105891e-02f, 4.95765693e-02f, 1.21705914e-02f, -5.42500149e-03f, 5.56853190e-02f, -2.10487694e-02f, 2.92684920e-02f,
  -3.74743529e-02f, 1.32213503e-01f, 2.33042948e-02f, 1.46898344e-01f, 2.54749656e-02f, 2.08493974e-03f, 2.40674037e-02f, 1.02072552e-01f, 8.94916058e-02f, -1.14686631e-01f,
  -2.17071578e-01f, -4.02890667e-02f, 1.94947477e-02f, 2.26273730e-01f, 2.16402456e-01f, 2.13835433e-01f, 1.60048962e-01f, 2.21585318e-01f, 1.85953155e-01f, 7.32783377e-02f,
  2.14236286e-02f, 4.42891521e-03f, 1.74998194e-01f, 1.32754132e-01f, 3.69457267e-02f, 1.81018591e-01f, 1.14940852e-01f, 4.92825955e-02f, 6.80806935e-02f, 1.05064727e-01f,
  1.45579293e-01f, -1.00523662e-02f, -9.43467915e-02f, -3.80276442e-02f, 7.14235082e-02f, 9.40954387e-02f, 6.74755797e-02f, -1.24953166e-01f, -7.95270056e-02f, 6.07334264e-02f,
  -4.54450324e-02f, -1.41154006e-01f, 9.50977206e-02f, -3.31017226e-02f, -4.57765125e-02f, -1.10211089e-01f, 8.28317404e-02f, -2.29211804e-02f, 5.31795388e-03f, 2.37423368e-02f,
  -9.79014337e-02f, -8.51236284e-02f, -7.37420991e-02f, -2.76406296e-02f, -1.38001576e-01f, 7.63144752e-04f, -1.63598880e-01f, 6.93652220e-03f, -2.40893811e-02f, 3.53312939e-02f,
  6.76003695e-02f, -4.79300357e-02f, -1.49177862e-02f, 3.84392589e-02f, 4.19401079e-02f, 8.97201970e-02f, -8.79252609e-03f, -3.66026796e-02f, -7.28858188e-02f, 8.83659907e-03f,
  -1.21377716e-02f, -1.74672678e-02f, -8.16722214e-02f, -2.50277743e-02f, 8.46166089e-02f, -3.61603498e-02f, 5.23673631e-02f, -4.25138287e-02f, -7.09370226e-02f, -7.35750571e-02f,
  1.05860143e-03f, -2.85647940e-02f, 7.67396949e-03f, -1.74975600e-02f, 5.56482412e-02f, 3.01617887e-02f, -8.28715712e-02f, -8.22848082e-02f, -3.63592580e-02f, -4.17128503e-02f,
  8.23707134e-02f, 4.16837111e-02f, -1.12673663e-01f, 3.81290317e-02f, 1.02856271e-01f, 5.73959388e-02f, -2.29269955e-02f, -3.20692523e-03f, -6.39718324e-02f, 2.26486251e-02f,
  3.38738039e-02f, 2.48150006e-02f, 8.82774219e-02f, 1.32309049e-02f, -1.06760792e-01f, 4.22318354e-02f, 2.70029176e-02f, -9.29680318e-02f, -5.76276286e-03f, -6.73121437e-02f,
  -3.33553888e-02f, -3.89144965e-03f, 2.76517756e-02f, 3.80310901e-02f, -6.40815198e-02f, -7.37100793e-03f, -7.49400165e-03f, 1.89437941e-02f, -4.75125900e-03f, 1.35939391e-02f,
  -9.42844972e-02f, -5.83633184e-02f, -1.16538420e-01f, -1.99221577e-02f, 4.93547767e-02f, -1.57967526e-02f, -2.75359172e-02f, -3.86164114e-02f, -1.28085837e-02f, 2.48980224e-02f,
  -5.87090570e-03f, -1.15595140e-01f, 2.29522195e-02f, -7.27670267e-02f, -1.22683041e-01f, -8.88979062e-04f, 6.88429549e-02f, -2.88597643e-02f, -3.04048117e-02f, -1.26166448e-01f,
  4.56791557e-02f, 1.46699443e-01f, 1.75539568e-01f, 6.08763359e-02f, 1.08572125e-01f, -9.54813212e-02f, -1.82170302e-01f, 2.41199322e-02f, 3.36223155e-01f, 1.04757026e-01f,
  7.83289373e-02f, 1.37670171e-02f, -1.24487821e-02f, -4.61065285e-02f, -1.56276345e-01f, 1.39207482e-01f, -4.85402867e-02f, -1.82465017e-01f, -1.21480279e-01f, -1.91096917e-01f,
  1.64185360e-01f, -1.61266819e-01f, 3.94572467e-02f, 4.44187857e-02f, 4.83158417e-02f, -4.11283784e-02f, 1.20545708e-01f, -1.05357021e-02f, -8.90775491e-03f, -4.26857360e-02f,
  -1.23221222e-02f, -4.93509695e-02f, 1.14401661e-01f, -4.10172716e-02f, -1.06169418e-01f, -1.64870713e-02f, -1.18965343e-01f, 5.89429252e-02f, -3.82934362e-02f, -7.93886408e-02f,
  -5.06744422e-02f, -9.03892219e-02f, 2.63655707e-02f, 5.29832963e-04f, 5.14292195e-02f, -6.25072941e-02f, -1.12170607e-01f, -1.24200419e-01f, -3.37062925e-02f, -1.01773486e-01f,
  4.16111238e-02f, 4.08003628e-02f, 4.76510124e-03f, -4.65803966e-03f, 9.60519016e-02f, 4.95393537e-02f, 6.22370876e-02f, 5.43235950e-02f, -7.59458914e-03f, -3.50292400e-02f,
  -5.73308654e-02f, 5.92582226e-02f, 2.32481081e-02f, -5.11052879e-03f, 1.71955992e-02f, -4.85167243e-02f, -9.00151860e-03f, 3.72116379e-02f, -2.49411957e-03f, 1.67503320e-02f,
  1.69727430e-02f, -1.25604654e-02f, -1.02759590e-02f, 6.70538619e-02f, -7.78430700e-02f, -3.61412987e-02f, -9.80194472e-03f, -3.77186900e-03f, 5.05971424e-02f, -1.14297234e-02f,
  1.80854023e-01f, -2.97253914e-02f, 3.21730897e-02f, 6.47161901e-02f, 4.05599549e-02f, -6.90561011e-02f, 2.37322040e-02f, 6.24776781e-02f, -4.64389771e-02f, -7.73267169e-03f,
  8.21457058e-02f, 5.38682193e-02f, 4.59187739e-02f, -6.93173409e-02f, 1.04664937e-01f, 9.48107243e-02f, -1.96291190e-02f, 2.28737202e-02f, 3.69120426e-02f, -9.17199776e-02f,
  1.67854829e-03f, 1.08546682e-01f, 1.90938860e-01f, -2.32126024e-02f, 9.95121971e-02f, 3.36691700e-02f, 1.51256755e-01f, 9.51165631e-02f, 3.46359909e-02f, 8.26593861e-02f,
  8.94809514e-02f, -4.34890650e-02f, 7.27587864e-02f, 6.87444061e-02f, 1.10925183e-01f, 1.20698981e-01f, -3.74203064e-02f, -5.74044324e-02f, 3.03856097e-02f, 3.11463289e-02f,
  9.07513220e-03f, -1.31252348e-01f, -4.43905219e-02f, 5.04440852e-02f, -1.62003301e-02f, 9.37184021e-02f, 1.03650399e-01f, -2.53907666e-02f, 4.65598591e-02f, -3.54956165e-02f,
  6.84455633e-02f, 1.96584966e-02f, 1.89717393e-02f, 7.48507902e-02f, 4.43901941e-02f, -3.52826454e-02f, 1.08384497e-01f, 1.06778085e-01f, -7.42725581e-02f, -3.10825557e-02f,
  9.08678472e-02f, 1.77155584e-01f, -8.77638906e-02f, 3.50228325e-02f, 7.79161155e-02f, 1.04019322e-01f, -8.00477639e-02f, -7.98056368e-03f, -4.44854423e-02f, -3.96301225e-02f,
  3.51257436e-02f, 5.31278476e-02f, 4.75719385e-02f, -5.09358058e-03f, -6.56740144e-02f, -2.35944651e-02f, -5.77530377e-02f, 1.44702613e-01f, 2.31579933e-02f, 7.74321798e-03f,
  -8.20794627e-02f, 1.14457160e-01f, 4.36474606e-02f, -6.91552162e-02f, 8.48517567e-02f, 6.78552315e-02f, 1.71083715e-02f, 1.12377137e-01f, 1.09410092e-01f, -4.01389636e-02f,
  6.12753965e-02f, 1.70788933e-02f, 9.93606150e-02f, 8.14643502e-02f, -6.30776063e-02f, -5.41603230e-02f, 5.33912480e-02f, -7.39408955e-02f, -7.55838677e-02f, -9.22503248e-02f,
  -5.22335619e-02f, 7.30638355e-02f, 6.53903047e-03f, -2.96985880e-02f, -1.00345835e-01f, -1.43453199e-02f, -8.01185220e-02f, -7.36575127e-02f, -7.66170174e-02f, 1.11750633e-01f,
  2.15593842e-03f, 8.66304860e-02f, -1.52029935e-02f, -4.35432158e-02f, 6.38634786e-02f, -4.47857603e-02f, -8.02616496e-03f, 7.62423873e-02f, 8.93696472e-02f, 8.31359997e-03f,
  -2.71903947e-02f, 3.99936587e-02f, -4.91373725e-02f, 8.06528628e-02f, 1.03139572e-01f, 4.81999032e-02f, 5.69701977e-02f, 1.01282276e-01f, -2.61884332e-02f, 7.64182657e-02f,
  7.17657059e-02f, -6.97324350e-02f, -2.03557238e-02f, 4.87230569e-02f, -7.61840418e-02f, 1.36415167e-02f, -3.13511565e-02f, -1.97742116e-02f, 1.67305395e-02f, -3.34354788e-02f,
  2.84894276e-02f, 5.96004277e-02f, 3.68128046e-02f, -7.54905716e-02f, 7.84436837e-02f, 4.80546765e-02f, 7.37908557e-02f, 1.25482529e-01f, 3.07551008e-02f, -5.98380789e-02f,
  2.03549072e-01f, 2.64907070e-02f, 1.22531271e-02f, 1.12333028e-02f, -9.74060372e-02f, 8.84940289e-03f, -8.74261707e-02f, -1.29099369e-01f, 3.47453766e-02f, -4.71086986e-02f,
  -8.07050914e-02f, -9.18553025e-02f, 3.78042720e-02f, -1.30466402e-01f, -1.15785770e-01f, 2.92262305e-02f, 1.70129351e-02f, -1.22928597e-01f, -2.30293870e-02f, -5.87489866e-02f,
  -1.04073472e-01f, -3.96360159e-02f, -9.52008590e-02f, -2.47783493e-02f, -3.80588397e-02f, -7.09474683e-02f, -7.18303099e-02f, -7.76048601e-02f, 4.76131728e-03f, 1.43231649e-03f,
  5.93380891e-02f, 7.93051254e-03f, -9.42666233e-02f, 3.80038470e-02f, -2.38171611e-02f, 7.74895698e-02f, -3.68434228e-02f, 4.26178053e-02f, -1.00397192e-01f, 5.54690883e-02f,
  1.66972745e-02f, -8.47775489e-02f, -7.71577507e-02f, -9.86196101e-02f, 5.61244637e-02f, -3.25279497e-02f, 7.20826630e-03f, -6.04676344e-02f, 4.04191948e-02f, -2.60864198e-02f,
  -4.17683534e-02f, -2.73834006e-03f, 3.81519124e-02f, -2.53259465e-02f, 6.65261820e-02f, -9.12470520e-02f, 1.91212893e-02f, 6.81090802e-02f, -1.76140945e-02f, 6.81826249e-02f,
  4.56851274e-02f, -5.33008836e-02f, -1.85043234e-02f, -7.23101012e-03f, 5.81496358e-02f, -3.92381996e-02f, -1.14607692e-01f, 6.39814287e-02f, 2.06235424e-02f, 6.75866101e-03f,
  -4.02859077e-02f, -4.23479006e-02f, -1.04631051e-01f, 5.33447936e-02f, 6.67527840e-02f, -5.82815893e-03f, -1.38857607e-02f, 8.66129696e-02f, -1.48569513e-02f, -3.01719941e-02f,
  4.31699939e-02f, -3.39584723e-02f, -1.12386979e-02f, 1.51180020e-02f, 2.79111899e-02f, 2.40284693e-03f, 4.35170420e-02f, -2.59691803e-03f, -9.84221883e-03f, -7.36850649e-02f,
  -1.22205660e-01f, -3.84609476e-02f, -4.68099043e-02f, 3.84993739e-02f, 9.93153080e-03f, 1.05918355e-01f, 3.78399007e-02f, 1.32970437e-02f, -7.36795291e-02f, -3.48608047e-02f,
  -9.41119045e-02f, 7.11636469e-02f, 7.04612210e-02f, 3.68167443e-04f, -1.15592673e-01f, 4.19105962e-02f, -2.41668355e-02f, -9.87265110e-02f, -2.17429437e-02f, 1.08744830e-01f,
  -4.77708653e-02f, -1.89305674e-02f, -7.24341869e-02f, -3.91549505e-02f, -3.44339758e-02f, -3.37671526e-02f, -1.13431014e-01f, -8.98984671e-02f, -2.32171360e-02f, -4.86105531e-02f,
  7.35922456e-02f, 6.64012954e-02f, 1.28962070e-01f, -2.32700855e-02f, 2.63986085e-02f, 2.16915812e-02f, 1.59672692e-01f, -1.34003118e-01f, -5.67163043e-02f, 6.36785924e-02f,
  9.97283030e-03f, -1.11071654e-01f, -2.17107441e-02f, -5.96285127e-02f, -2.77393106e-02f, 8.68124887e-02f, 9.16775223e-03f, -4.50359285e-02f, -6.61954060e-02f, -5.60523942e-02f,
  -6.85081678e-03f, -1.37206931e-02f, -2.86739208e-02f, -1.41250640e-01f, -7.09018111e-02f, -8.32501501e-02f, -1.82723124e-02f, 1.57249391e-01f, 5.78703582e-02f, 5.10220639e-02f,
  1.02494411e-01f, 2.48017907e-01f, -6.06909059e-02f, -8.46275166e-02f, 1.14143595e-01f, -3.12781706e-02f, 6.06455505e-02f, 7.03555197e-02f, 5.03222682e-02f, 2.11175978e-02f,
  -2.51045749e-02f, -3.74867171e-02f, -2.27898415e-02f, 6.65106848e-02f, -2.72904839e-02f, 5.40606230e-02f, -2.39679739e-02f, 2.36805975e-02f, -2.70844344e-02f, 4.24298979e-02f,
  1.03727579e-01f, 1.01324201e-01f, 4.24634553e-02f, 5.03006727e-02f, 7.77510330e-02f, -8.70478377e-02f, 1.43834293e-01f, -8.20871629e-03f, -4.60074320e-02f, -8.72893184e-02f,
  -1.23392083e-01f, 9.47336778e-02f, -2.65235920e-02f, 7.78782293e-02f, -7.75496941e-03f, -5.31314462e-02f, 1.14011420e-02f, 9.22169089e-02f, 2.77655162e-02f, -1.94108933e-02f,
  -4.76663187e-02f, 1.96599271e-02f, 6.72894716e-02f, -5.98741090e-03f, -7.72643462e-02f, 6.96101114e-02f, 4.11356911e-02f, 8.39797594e-03f, -1.55726518e-03f, -3.84308621e-02f,
  6.63753366e-04f, 8.36928412e-02f, 4.57157977e-02f, 1.78696606e-02f, 3.49582620e-02f, -8.34589731e-03f, 1.42612588e-02f, 9.45870727e-02f, 8.05635080e-02f, 2.98099592e-02f,
  -1.27713084e-01f, 1.78392246e-01f, -8.87087267e-03f, -8.69346634e-02f, -4.87308428e-02f, 1.39727928e-02f, 7.21589997e-02f, -2.66168471e-02f, 1.63366310e-02f, 3.62769254e-02f,
  4.53851884e-04f, 6.90106302e-02f, 5.15071526e-02f, -8.89622048e-02f, 1.40983490e-02f, 3.31815071e-02f, -1.15895392e-02f, -1.12132981e-01f, -6.70194626e-02f, -4.21800017e-02f,
  -8.48312154e-02f, -1.25825629e-01f, -4.28098477e-02f, -1.31044313e-01f, -7.93768987e-02f, -8.97922888e-02f, 3.79013047e-02f, -1.25228941e-01f, -1.41967162e-01f, -1.37389123e-01f,
  -3.47886309e-02f, -1.30458206e-01f, -7.03909546e-02f, 7.16922525e-03f, 8.62725228e-02f, -7.18559027e-02f, -1.07523218e-01f, -1.48610681e-01f, -1.78219844e-02f, -1.29881039e-01f,
  -2.59815361e-02f, -5.20081297e-02f, -1.00080937e-01f, -1.38589308e-01f, -1.93330646e-01f, -1.71505243e-01f, -2.00751364e-01f, -1.62282676e-01f, -1.26980558e-01f, 2.53681168e-02f,
  -1.05681814e-01f, -2.64832359e-02f, 3.56969945e-02f, -5.90398908e-02f, -1.18684687e-01f, 6.26276582e-02f, -1.48098052e-01f, -1.92093686e-03f, 1.00593390e-02f, -1.30215347e-01f,
  -6.69077784e-02f, 3.17586698e-02f, -7.96717554e-02f, 1.07183382e-01f, 5.31872846e-02f, 4.91705388e-02f, 2.11388133e-02f, 6.06885403e-02f, 1.08444117e-01f, 3.27847935e-02f,
  -8.29142556e-02f, 6.04397543e-02f, 6.34974018e-02f, 9.40373018e-02f, -9.50442106e-02f, 3.59276682e-02f, -1.08334243e-01f, -1.00630373e-02f, -6.00262433e-02f, -5.47373965e-02f,
  5.43501005e-02f, -1.24691650e-02f, -1.13809332e-02f, -4.99554127e-02f, 3.43720466e-02f, -5.75785078e-02f, -7.08300471e-02f, 8.71250406e-03f, -2.17625760e-02f, -7.53351450e-02f,
  -5.17503731e-02f, 1.33123230e-02f, 1.78702977e-02f, -4.65318710e-02f, -8.93907323e-02f, 6.39427528e-02f, -2.30719559e-02f, -1.27934609e-02f, 4.01574783e-02f, -5.46412319e-02f,
  9.65525210e-02f, 1.90306921e-02f, -3.54171242e-03f, -3.33337635e-02f, 1.70710608e-02f, 7.38265067e-02f, 7.13867024e-02f, 1.55911073e-02f, -3.04385312e-02f, 2.92426962e-02f,
  8.68942589e-04f, -2.95242458e-03f, -8.95352755e-03f, 5.63783385e-02f, 1.13205742e-02f, 4.92253453e-02f, -8.76624975e-03f, -2.81474553e-02f, -2.34542228e-02f, -2.77076685e-03f,
  -9.06592011e-02f, 7.75518194e-02f, -7.12992623e-02f, 2.38292478e-02f, 7.52597228e-02f, -6.67241961e-02f, 2.81967781e-02f, 3.37929241e-02f, -1.16324723e-02f, -9.51633081e-02f,
  -8.38441774e-02f, -8.49313140e-02f, -4.96997079e-03f, 6.63728714e-02f, -1.35791019e-01f, -1.05304591e-01f, 4.23781835e-02f, -1.04126014e-01f, -3.73504795e-02f, 1.17921289e-02f,
  -1.32070720e-01f, -4.11137044e-02f, -2.33172357e-01f, -1.21812351e-01f, 3.06000262e-02f, 1.29615637e-02f, -1.66027457e-01f, -1.08026035e-01f, -5.45722023e-02f, -2.91483939e-01f,
  -1.25820220e-01f, -4.64404412e-02f, -2.83541549e-02f, 1.47759974e-01f, 1.88427627e-01f, 9.64855179e-02f, 1.44785076e-01f, 1.72276184e-01f, 1.76858276e-01f, 1.61203384e-01f,
  1.49329111e-01f, 5.14432974e-02f, 1.61963955e-01f, 1.20096132e-01f, 4.94099744e-02f, 1.04316503e-01f, 1.80391967e-01f, -8.40434358e-02f, 9.60022956e-02f, 1.08436763e-01f,
  1.08235359e-01f, 7.33198971e-02f, -1.67269520e-02f, 5.01719750e-02f, 1.46094058e-02f, 1.46419689e-01f, -5.24086580e-02f, -1.25938088e-01f, -4.28085588e-02f, 1.09058157e-01f,
  -1.58900350e-01f, -1.09025635e-01f, 5.03921025e-02f, 1.09016009e-01f, 1.65453367e-02f, -9.52667370e-02f, -7.19201099e-03f, -1.23470731e-03f, 3.12679820e-02f, 1.65117159e-02f,
  4.32721712e-03f, -1.47775859e-02f, -3.72194797e-02f, -5.61811551e-02f, 1.43220369e-03f, 4.37529497e-02f, -1.26159471e-02f, -1.00287832e-01f, -1.24904541e-02f, -5.76023385e-03f,
  -2.68560788e-03f, -3.39811086e-03f, -1.30121615e-02f, 9.08984467e-02f, -1.70643236e-02f, 6.55315295e-02f, -9.27218869e-02f, 5.30289337e-02f, 3.41574736e-02f, -4.41554300e-02f,
  7.79996663e-02f, 9.82393883e-03f, -2.08555646e-02f, 8.26334506e-02f, -1.96710676e-02f, 4.92528416e-02f, 8.55919998e-03f, 4.96071801e-02f, 7.93368891e-02f, 5.34135289e-02f,
  -6.18653484e-02f, -3.37245874e-02f, 1.58998091e-02f, -1.14667676e-02f, -1.69640817e-02f, -3.94325778e-02f, -3.88452448e-02f, 3.12307049e-02f, -3.60159576e-02f, -1.17567196e-01f,
  -3.37746255e-02f, -1.11220963e-01f, -1.32991880e-01f, 8.48445594e-02f, -7.60069042e-02f, -6.98845685e-02f, 2.79201921e-02f, 9.57409143e-02f, 5.32874418e-03f, -1.29571915e-01f,
  -4.97910567e-02f, -8.72324929e-02f, -2.94367177e-03f, 9.35940370e-02f, -1.51310876e-01f, -3.52014676e-02f, 4.63627316e-02f, -2.04847436e-02f, -1.19692795e-01f, 1.34885954e-02f,
  2.12794263e-02f, -1.15200974e-01f, 2.91715097e-02f, -5.19888550e-02f, 4.64077331e-02f, -4.97228280e-02f, -1.13301851e-01f, -5.80416620e-02f, 5.50343245e-02f, -5.91324158e-02f,
  1.51620787e-02f, -3.64312269e-02f, 1.41834817e-03f, -3.97931971e-02f, -8.13426524e-02f, -4.60942797e-02f, -1.45334333e-01f, -7.10223056e-03f, 4.51940075e-02f, -1.29427373e-01f,
  -3.51176739e-01f, 1.07575849e-01f, -1.32530823e-01f, 2.10104082e-02f, 1.90955147e-01f, 1.75453454e-01f, 2.53792733e-01f, 1.96219818e-03f, 1.03509827e-02f, 1.05440989e-01f,
  9.24653709e-02f, 4.05332446e-02f, -9.50385854e-02f, -5.23794480e-02f, -3.36007476e-02f, 4.12344038e-02f, 1.71013042e-01f, -1.46814466e-01f, -3.54496807e-01f, -7.43437111e-02f,
  -4.68299724e-02f, -1.93772361e-01f, -2.06195101e-01f, -1.45461932e-01f, 7.47071579e-02f, -1.54673576e-01f, -3.16088088e-02f, -1.53880641e-01f, 8.09133332e-03f, 1.83440059e-01f,
  -4.63979393e-02f, -4.68640309e-03f, 6.61014318e-02f, 6.65155426e-03f, -4.62735929e-02f, 1.31499097e-02f, -3.93714420e-02f, 2.71294471e-02f, 1.48094753e-02f, 1.15803815e-02f,
  9.54221375e-03f, 9.61628277e-03f, 3.72540317e-02f, 1.92512962e-04f, -4.25068736e-02f, -6.13804460e-02f, -8.66555870e-02f, -6.34740591e-02f, -1.49237132e-02f, -3.70197035e-02f,
  1.60149693e-01f, 1.03959916e-02f, -5.04906029e-02f, -8.99885669e-02f, -6.16662167e-02f, -5.49689569e-02f, -1.39202520e-01f, -5.75496405e-02f, -5.29931039e-02f, -1.62711725e-01f,
  7.09147155e-02f, 6.93485700e-03f, 5.63186295e-02f, 6.05417415e-02f, 6.73854863e-03f, 7.06058694e-03f, -2.18799654e-02f, 2.25899741e-02f, -7.78899109e-03f, -3.57399322e-02f,
  -9.31673422e-02f, -5.25301136e-02f, -5.02773561e-02f, 5.68538941e-02f, -2.70533841e-02f, 6.78355172e-02f, -1.55538581e-02f, 5.81414215e-02f, -1.25156805e-01f, 2.42558084e-02f,
  -2.67813057e-02f, -3.32453921e-02f, 1.26573211e-02f, 5.15263453e-02f, 1.28581837e-01f, -1.68977957e-02f, 4.29924130e-02f, 5.33255897e-02f, -8.53234977e-02f, 4.70454842e-02f,
  -5.56879081e-02f, -3.66711468e-02f, -2.82056127e-02f, 2.17015948e-02f, -3.17939967e-02f, -6.17071837e-02f, 7.94091001e-02f, -7.47315437e-02f, 4.76526953e-02f, -9.31517258e-02f,
  -7.01744622e-03f, 9.40028857e-03f, -2.11792625e-02f, 4.71811835e-03f, -2.27730684e-02f, -8.59585106e-02f, 3.79714221e-02f, 3.72574106e-02f, -8.03120285e-02f, -1.20171845e-01f,
  -6.02361895e-02f, -8.60122889e-02f, -1.34769469e-01f, -1.28692821e-01f, -4.60098265e-03f, -3.80261913e-02f, -7.38895461e-02f, -1.68333054e-01f, -7.68029317e-02f, -1.02127001e-01f,
  -4.18278068e-01f, -4.29293886e-02f, -1.96039781e-01f, -2.99623132e-01f, 8.73418897e-02f, 1.20497309e-01f, -2.83593014e-02f, 1.84273943e-01f, 5.02014719e-02f, -2.48285592e-01f,
  -3.82661521e-02f, 2.63341554e-02f, 1.19693521e-02f, 5.81135936e-02f, 2.60606571e-03f, -1.13324553e-01f, -2.60872543e-01f, -8.90016854e-02f, 3.84920165e-02f, 9.63814631e-02f,
  6.10064715e-02f, -2.34427929e-01f, -1.74207658e-01f, -3.07800863e-02f, -6.12594299e-02f, 5.84436841e-02f, -1.00760713e-01f, -9.90969315e-02f, 1.40304402e-01f, -1.12831831e-01f,
  -1.21609896e-01f, 1.20296925e-01f, 2.81835105e-02f, 1.90065173e-03f, -5.16365804e-02f, 6.99152350e-02f, -7.04528838e-02f, -5.24458587e-02f, 8.89138132e-02f, -3.05979196e-02f,
  -4.47356552e-02f, 7.95611739e-02f, -8.05697441e-02f, 3.23610120e-02f, -8.75093937e-02f, -3.11124120e-02f, 3.32119968e-03f, -8.40774402e-02f, 3.30681875e-02f, 2.16124579e-02f,
  6.62288889e-02f, 1.28689021e-01f, 7.61088133e-02f, 2.18893096e-01f, 1.68686345e-01f, -1.17093306e-02f, 1.71181932e-01f, 1.60789430e-01f, 2.08018124e-01f, 7.52953887e-02f,
  -4.77510765e-02f, 3.12386593e-03f, 2.49969177e-02f, -5.80189377e-03f, -2.04827879e-02f, -2.71633547e-02f, 4.45713922e-02f, -1.01584561e-01f, 2.75033116e-02f, 4.36206497e-02f,
  4.05127853e-02f, -4.12428081e-02f, -8.48222971e-02f, 3.47725637e-02f, -5.68748936e-02f, -4.52182721e-03f, 5.49484566e-02f, 6.10905513e-02f, -2.46563200e-02f, 1.14069795e-02f,
  1.75619647e-02f, -2.62273531e-02f, -9.05362815e-02f, 7.61758909e-02f, 9.72143263e-02f, -6.44667372e-02f, 4.11350802e-02f, 4.67426740e-02f, -3.41686700e-03f, -4.74571250e-02f,
  -7.55809471e-02f, -3.29903364e-02f, -1.01316422e-01f, 1.23090046e-02f, -2.80700289e-02f, -7.93592334e-02f, -1.95596367e-02f, -1.31017774e-01f, -2.17154101e-02f, 1.05400607e-02f,
  1.32782236e-01f, -3.08223795e-02f, 1.70611273e-02f, -4.89932150e-02f, -1.00935631e-01f, 1.34729575e-02f, -7.62559772e-02f, -2.95335166e-02f, 3.74220312e-02f, -1.81828905e-02f,
  -5.46010733e-02f, -9.64732096e-02f, 1.72984283e-02f, 8.86972472e-02f, 4.67061475e-02f, -1.41793396e-02f, -1.39559424e-02f, 8.32798779e-02f, 5.76418377e-02f, 4.34826538e-02f,
  7.44194835e-02f, -2.11295336e-02f, -5.38363755e-02f, 1.67102680e-01f, 6.41660318e-02f, 1.73890423e-02f, -1.15298755e-01f, -1.33522838e-01f, 6.66172877e-02f, 1.33795291e-02f,
  1.11448281e-01f, 1.04627639e-01f, 6.75242990e-02f, 9.08234268e-02f, -7.62673095e-02f, 1.73734259e-02f, 3.60343382e-02f, -1.01232547e-02f, 6.73830956e-02f, 1.05644450e-01f,
  1.42959580e-01f, 1.83403820e-01f, 7.02470690e-02f, 1.15225807e-01f, 4.67471741e-02f, 9.78025049e-02f, 8.48321840e-02f, 1.17107518e-01f, 1.13037176e-01f, 7.04549626e-02f,
  8.10910538e-02f, -6.54358342e-02f, -4.06806506e-02f, -1.67583525e-02f, -4.71542291e-02f, 1.85805149e-02f, -1.19012678e-02f, -3.11259348e-02f, 8.67089480e-02f, 6.33968711e-02f,
  5.24836071e-02f, 5.44821806e-02f, 8.02625120e-02f, -4.40901332e-03f, -6.22429214e-02f, 4.71252836e-02f, 4.93227690e-02f, 8.18109419e-03f, -4.07418562e-03f, -4.25199792e-02f,
  8.89882445e-02f, 8.63449723e-02f, 6.18955456e-02f, -3.52493674e-02f, -9.70674381e-02f, -7.61424704e-03f, -2.59401985e-02f, 4.71653193e-02f, -1.24957286e-01f, 1.47072207e-02f,
  -5.65343425e-02f, -6.77921474e-02f, 7.82621186e-03f, -4.53114398e-02f, -5.06839715e-02f, -2.83387993e-02f, 4.45095748e-02f, -5.72154261e-02f, 6.37303367e-02f, 6.57948330e-02f,
  -2.56931093e-02f, -5.45146223e-03f, -2.42919754e-02f, -3.92950661e-02f, 4.14891392e-02f, -1.43723618e-02f, -7.52012655e-02f, -3.57869938e-02f, 4.63272296e-02f, 9.26209912e-02f,
  -3.98564376e-02f, -6.86386898e-02f, 3.76062989e-02f, 6.45008695e-04f, 4.71764691e-02f, -9.85949114e-02f, 4.93637510e-02f, -9.13293064e-02f, 1.40507268e-02f, 8.30388889e-02f,
  -8.14548228e-03f, -5.57141900e-02f, -6.38660118e-02f, 6.22314475e-02f, -1.23628108e-02f, -5.08262105e-02f, 3.97389792e-02f, -1.57579221e-03f, 8.70654806e-02f, -4.85116020e-02f,
  -9.36701894e-02f, -2.93407980e-02f, -5.46185346e-03f, -1.15845585e-02f, 5.43385074e-02f, -1.09468549e-01f, -2.27351282e-02f, 6.16818555e-02f, 3.10746208e-02f, -1.13619916e-01f,
  -3.17765288e-02f, -6.84217662e-02f, -7.80418143e-02f, 1.79485288e-02f, -1.04768664e-01f, 6.20770603e-02f, -1.10046268e-01f, -9.22756493e-02f, -7.55611509e-02f, -1.52987335e-02f,
  4.22055572e-02f, 1.12816364e-01f, -5.03024235e-02f, -1.63803864e-02f, 8.43805224e-02f, -6.11875169e-02f, 5.52275255e-02f, -9.67724025e-02f, -7.89884701e-02f, -4.11331728e-02f,
  -8.18895921e-03f, -4.42621298e-02f, -3.10612619e-02f, -2.55971048e-02f, -1.15758285e-01f, -5.36474921e-02f, 1.06110923e-01f, 3.01855970e-02f, -4.53679599e-02f, 5.89571940e-03f,
  9.29675177e-02f, 3.97774428e-02f, -8.09848830e-02f, -5.05591221e-02f, 2.01443397e-02f, 2.36190725e-02f, 5.99960983e-02f, -1.62860304e-02f, 3.21309417e-02f, 4.81636785e-02f,
  -1.15882650e-01f, -4.27121529e-03f, 4.71569374e-02f, 1.42605305e-01f, 7.28731677e-02f, -7.97742903e-02f, -1.86717510e-02f, 3.38473096e-02f, -1.99874043e-02f, -1.45450225e-02f,
  -3.75371836e-02f, 2.99953576e-02f, 6.61935881e-02f, -8.21872875e-02f, -7.80513138e-02f, -8.50703940e-02f, -7.01592341e-02f, -7.16824979e-02f, -8.34359601e-02f, 5.38587347e-02f,
  1.26483992e-01f, -5.02150208e-02f, -1.44821210e-02f, -1.02189951e-01f, 6.08156510e-02f, 5.95199056e-02f, 4.06849161e-02f, -1.00433081e-01f, -8.75645876e-02f, 3.25751901e-02f,
  1.15533903e-01f, 1.60187129e-02f, -1.10250050e-02f, -2.31468715e-02f, 1.25940802e-04f, -6.37683049e-02f, 3.84687968e-02f, 6.64112791e-02f, -9.47101321e-03f, -2.85385475e-02f,
  -2.36785822e-02f, -3.68427187e-02f, 1.78965945e-02f, -8.77741501e-02f, 4.57827635e-02f, -3.93131608e-03f, 1.17967963e-01f, 9.40747410e-02f, -5.19248992e-02f, -4.18443605e-02f,
  2.18699742e-02f, 2.57378016e-02f, 4.33308817e-02f, 2.63912510e-02f, 1.04628220e-01f, 3.55873927e-02f, 1.01909868e-01f, -6.47144467e-02f, 6.48372099e-02f, -1.22826472e-02f,
  -4.87938225e-02f, -8.88764411e-02f, -1.03077553e-02f, 9.64732319e-02f, -8.34956691e-02f, -6.39457405e-02f, 7.06062792e-03f, 4.44403570e-03f, -4.18517441e-02f, -2.29908270e-03f,
  4.54215407e-02f, -7.85772577e-02f, -7.26481751e-02f, -2.22313739e-02f, -5.57095967e-02f, -2.50473972e-02f, 1.25935093e-01f, -4.55459021e-02f, -3.78811397e-02f, -5.47391400e-02f,
  1.77720357e-02f, 9.00995284e-02f, -1.01867229e-01f, -4.62505296e-02f, 1.60022657e-02f, -9.51278135e-02f, 4.92089614e-02f, -2.20573209e-02f, 2.98907906e-02f, 6.50206804e-02f,
  8.24988261e-02f, -8.95630196e-02f, 2.66272072e-02f, 1.73968539e-01f, 1.68821067e-01f, 1.54238150e-01f, 8.61975551e-02f, -9.27996449e-03f, 4.69953343e-02f, -7.28375837e-02f,
  2.25264952e-02f, -7.35748112e-02f, -3.17963213e-02f, -2.11287010e-02f, -3.30274440e-02f, 1.52705740e-02f, 8.97595808e-02f, -5.89989349e-02f, 4.66176122e-02f, -1.62142236e-02f,
  4.16185074e-02f, 5.20345662e-03f, 5.38347773e-02f, -3.15316662e-04f, -7.61044100e-02f, -7.11992150e-03f, -4.92991619e-02f, -5.24179824e-03f, 3.11002657e-02f, 2.94599961e-02f,
  3.74167524e-02f, -3.01258103e-03f, -1.18755614e-02f, 4.82672453e-02f, -5.81193455e-02f, 4.89986129e-02f, -4.62858602e-02f, -6.48543015e-02f, 2.63797268e-02f, 1.84972566e-02f,
  7.08052889e-02f, -7.62493238e-02f, -6.89867735e-02f, -4.80029080e-03f, -3.92114557e-02f, -1.00236675e-02f, -1.02408007e-01f, 5.49866259e-02f, -6.28974885e-02f, -2.87092384e-02f,
  -1.80390924e-02f, -5.45628555e-03f, 8.72645974e-02f, -7.59772807e-02f, 1.14257380e-01f, -2.96478607e-02f, 9.92951393e-02f, -6.05750792e-02f, 7.27534220e-02f, -1.38533385e-02f,
  -4.44711521e-02f, 3.47075425e-02f, 6.49684519e-02f, 1.82699263e-02f, -2.84909736e-02f, 9.01306346e-02f, -5.04136905e-02f, 7.63639882e-02f, 1.64449122e-02f, -1.48876170e-02f,
  -4.57867123e-02f, 6.25285730e-02f, -7.20976815e-02f, 6.68111369e-02f, 1.21505931e-03f, -7.21448809e-02f, -1.35163918e-01f, -6.10721298e-03f, 3.21468674e-02f, -3.20242047e-02f,
  7.86540359e-02f, 2.52170507e-02f, -2.09151972e-02f, -6.41194358e-02f, 6.37518987e-02f, -7.64053538e-02f, 2.76092067e-02f, 6.18483648e-02f, -3.77448052e-02f, 3.46137173e-02f,
  -5.20951673e-02f, -7.37569854e-02f, -7.20751435e-02f, -1.02546141e-02f, 4.32406142e-02f, -4.06405330e-02f, 3.95340212e-02f, -1.65812932e-02f, 1.01018474e-02f, 3.33047360e-02f,
  -8.36616829e-02f, -2.24659760e-02f, -8.71549770e-02f, 7.81530142e-02f, 4.38974611e-02f, -1.33398436e-02f, 9.78427008e-03f, 2.09436985e-04f, -5.00574447e-02f, 9.64080468e-02f,
  -7.90573061e-02f, 9.42719951e-02f, -3.14573646e-02f, 1.77681651e-02f, 1.59289762e-02f, 1.45571798e-01f, 4.80174646e-02f, 1.02685079e-01f, 6.56415820e-02f, -1.03936069e-01f,
  -1.13094084e-01f, -1.54462140e-02f, -1.46876276e-01f, -4.62400587e-03f, -7.39341006e-02f, -4.47163172e-02f, 3.30763264e-03f, 1.63711030e-02f, 9.36651975e-02f, -2.99139936e-02f,
  -6.81438670e-02f, 5.11944182e-02f, 6.49995357e-02f, 1.14872046e-01f, -4.56618182e-02f, -1.84265196e-01f, -2.13758592e-02f, -7.19604418e-02f, 8.23074207e-02f, 1.39426246e-01f,
  -3.35761420e-02f, -3.44363451e-02f, -5.66939041e-02f, 4.72029038e-02f, -5.98268509e-02f, 2.79830527e-02f, -1.37022108e-01f, -3.67762856e-02f, -7.50917643e-02f, -2.23129213e-01f,
  -1.23067640e-01f, 2.33099367e-02f, -7.08326101e-02f, 1.99705781e-03f, -1.15597874e-01f, 3.28280777e-02f, -5.94704524e-02f, -7.30948895e-02f, -2.40895916e-02f, 2.53197365e-02f,
  4.51195762e-02f, 8.86779651e-02f, -3.94013971e-02f, 2.09351759e-02f, -3.19764065e-03f, -2.80825477e-02f, 1.23973293e-02f, 1.00039253e-02f, -6.79254457e-02f, 6.97283819e-02f,
  9.58494693e-02f, -8.89436975e-02f, 8.24923143e-02f, -1.08547546e-01f, -7.59075955e-02f, -1.74985714e-02f, -1.41186506e-01f, -6.80581033e-02f, -6.03186265e-02f, -1.52175725e-01f,
  -8.57453346e-02f, 3.61692533e-03f, -9.81335044e-02f, 9.29537639e-02f, -2.90314872e-02f, -3.68064381e-02f, -7.40702972e-02f, -1.22603513e-02f, -5.71844094e-02f, -1.59694459e-02f,
  -8.18731487e-02f, -5.84767498e-02f, 2.25457586e-02f, -1.20555023e-02f, -1.46007130e-03f, -1.70322042e-03f, -1.00734137e-01f, -9.08806268e-03f, -4.64839153e-02f, 4.64134961e-02f,
  -3.46642919e-02f, 4.49383771e-03f, 1.23728095e-02f, -6.69389293e-02f, -9.01790932e-02f, -1.44400047e-02f, -2.98728514e-02f, -6.07773066e-02f, -7.90318772e-02f, -2.28374023e-02f,
  -1.03738960e-02f, 6.78095967e-02f, -2.22290903e-02f, 2.64343321e-02f, 6.64872080e-02f, 1.11286454e-02f, -5.83205968e-02f, -5.49604893e-02f, 3.52034383e-02f, 5.43053448e-02f,
  -5.11138402e-02f, -1.75248738e-02f, -3.32403071e-02f, 1.18483501e-02f, -5.29344529e-02f, 1.81333628e-02f, 7.63429850e-02f, -6.07195944e-02f, -2.95314491e-02f, -6.85471594e-02f,
  5.75322285e-02f, 7.39361048e-02f, 4.83325534e-02f, 1.87621620e-02f, 7.84071628e-03f, -1.19377095e-02f, -2.23905826e-03f, -5.14223389e-02f, 2.63989661e-02f, -8.85576978e-02f,
  -2.09475592e-01f, -7.47718140e-02f, 1.65559780e-02f, -1.59191623e-01f, -1.55426981e-02f, 9.44744200e-02f, -3.62889096e-02f, -5.11560515e-02f, -7.24216402e-02f, 2.03387830e-02f,
  -6.51235953e-02f, -8.14248323e-02f, 2.34751031e-02f, 5.17790616e-02f, -1.80443563e-02f, -1.25638008e-01f, 2.42376886e-02f, 5.68322698e-03f, 5.27578183e-02f, -4.98273894e-02f,
  6.80586472e-02f, -8.54721591e-02f, -6.82523847e-02f, 6.13083206e-02f, -1.27155585e-02f, 7.06808493e-02f, 8.34504962e-02f, 8.76597464e-02f, 6.24952354e-02f, -8.78733620e-02f,
  -1.69377811e-02f, -9.13907439e-02f, -6.14943507e-04f, -1.43038128e-02f, -4.95182071e-03f, 2.08995957e-02f, 7.96058476e-02f, 4.45201099e-02f, -6.57465383e-02f, -1.71677675e-02f,
  -3.66359614e-02f, -1.58682726e-02f, -4.43411991e-02f, 9.82548073e-02f, -8.81348550e-02f, 3.11262012e-02f, 6.53057769e-02f, -2.71453951e-02f, 7.18051717e-02f, 3.20684677e-03f,
  8.46560672e-02f, 8.28975737e-02f, -1.34989042e-02f, 1.16918907e-01f, -2.71245791e-03f, -4.98998389e-02f, -3.68225537e-02f, 1.14064671e-01f, -6.51112385e-03f, 2.40599047e-02f,
  9.27178282e-03f, -1.59529839e-02f, 1.83333214e-02f, 1.63603723e-02f, -5.98945357e-02f, 7.46630654e-02f, -4.32752147e-02f, 4.79283333e-02f, -2.24918295e-02f, -7.56326467e-02f,
  -6.40656352e-02f, -5.24923205e-02f, -4.47766632e-02f, 2.19729114e-02f, 4.14812863e-02f, -4.65591587e-02f, 4.08325419e-02f, 7.75141120e-02f, 2.43400354e-02f, -1.11876301e-01f,
  -1.89477752e-03f, 5.20777740e-02f, -5.20080775e-02f, 3.45396847e-02f, -5.31720966e-02f, 9.80679169e-02f, 5.72565012e-02f, 3.87112387e-02f, 7.72221684e-02f, -8.63715541e-03f,
  -4.31721564e-03f, -8.71705189e-02f, -1.32303372e-01f, -7.31641203e-02f, 6.15420453e-02f, -2.90183090e-02f, 2.11965982e-02f, 6.80828765e-02f, -2.73225596e-03f, -1.35571079e-03f,
  -2.94077210e-02f, 2.13608053e-02f, 4.86933365e-02f, -2.32852995e-02f, -4.73395102e-02f, -6.74254075e-02f, -9.19059440e-02f, -7.31193721e-02f, -3.06774285e-02f, -2.78590322e-02f,
  8.81650113e-03f, -1.55920014e-02f, -3.04900855e-03f, -2.52662245e-02f, 6.41111135e-02f, -5.29675074e-02f, -5.93875395e-03f, 3.15941982e-02f, -3.36502045e-02f, 1.26395121e-01f,
  1.23018235e-01f, 1.31922904e-02f, 7.18249455e-02f, 3.25084887e-02f, -1.79645997e-02f, -3.61494571e-02f, -6.78386763e-02f, 5.75008094e-02f, 1.00243948e-01f, 7.50000477e-02f,
  8.65415782e-02f, 7.26138502e-02f, 2.88414452e-02f, 2.89307199e-02f, -5.71711510e-02f, -7.30035752e-02f, -8.47424206e-04f, 8.58609155e-02f, 4.05250713e-02f, 4.49407324e-02f,
  -3.23744565e-02f, 7.79669732e-02f, 4.24885303e-02f, -4.10791524e-02f, 8.85171145e-02f, 5.99560961e-02f, 8.13106447e-02f, 3.85434218e-02f, -3.73726152e-02f, -6.95775868e-03f,
  -3.51135060e-02f, 1.41419172e-01f, -4.45680395e-02f, -4.37919311e-02f, -5.89554012e-02f, 6.64611207e-03f, 4.37637307e-02f, 8.07386115e-02f, -6.86347559e-02f, 5.13001531e-02f,
  -9.14044008e-02f, -5.46701178e-02f, 6.11885302e-02f, 6.61711693e-02f, 3.51124741e-02f, -7.16513097e-02f, 8.22620094e-03f, 6.17107525e-02f, 6.01692796e-02f, 2.66433638e-02f,
  -4.43982659e-03f, 3.34087946e-02f, -2.85879653e-02f, 5.06242290e-02f, -6.92937821e-02f, 2.26256680e-02f, -5.73518910e-02f, -2.55031083e-02f, 7.97755271e-02f, 2.86624208e-02f,
  5.46029732e-02f, 4.38496843e-02f, 2.96347830e-02f, 5.58270551e-02f, 7.33506754e-02f, 8.29909816e-02f, -8.46352801e-02f, -5.89019340e-03f, -2.75452365e-03f, 2.54005920e-02f,
  1.52326319e-02f, -4.64123674e-02f, 2.23779995e-02f, 1.12211406e-01f, -7.60258548e-03f, -6.27418235e-02f, -7.35975569e-03f, 4.25228588e-02f, 6.82154447e-02f, 1.63136981e-02f,
  -4.36376082e-03f, -2.91892444e-03f, 1.16582654e-01f, 9.30133685e-02f, 8.42793584e-02f, 6.00523613e-02f, 1.02159671e-01f, 3.47547308e-02f, -1.10193724e-02f, 3.61721069e-02f,
  8.11449066e-03f, 4.32746997e-03f, 3.87171507e-02f, 7.33653307e-02f, -1.03834860e-01f, -1.00354766e-02f, 8.29392821e-02f, -2.92710215e-02f, -5.30755147e-02f, -4.11364511e-02f,
  3.32498476e-02f, -1.04850136e-01f, 4.82425373e-03f, -8.82762205e-03f, 5.65088987e-02f, -4.78841104e-02f, 5.10342009e-02f, -9.03555900e-02f, -6.00485541e-02f, -6.34385645e-02f,
  -5.48489764e-02f, 4.59464788e-02f, -9.81542766e-02f, -1.06378319e-03f, -2.00312566e-02f, -3.30106206e-02f, -8.44847560e-02f, 3.12071443e-02f, 5.77403642e-02f, -2.57455395e-03f,
  1.96337342e-01f, -1.31796543e-02f, -8.25570822e-02f, 7.26257935e-02f, -5.72267314e-03f, 1.48216024e-01f, 2.69405842e-02f, 3.07973698e-02f, 4.32254635e-02f, 5.19036688e-02f,
  -1.25758454e-01f, -9.73839462e-02f, -3.35745625e-02f, -6.15724474e-02f, 3.20169590e-02f, 7.87197202e-02f, 1.14910841e-01f, -4.24965657e-02f, 1.07297592e-01f, 6.94967955e-02f,
  -2.98024788e-02f, 5.37460111e-02f, 1.61114689e-02f, -1.24734357e-01f, 9.63277277e-03f, 5.11543341e-02f, -8.17409679e-02f, -3.48754078e-02f, -1.94993839e-02f, 1.96357705e-02f,
  -9.96951461e-02f, -3.72048095e-03f, -1.32804103e-02f, 7.28091672e-02f, -6.57642037e-02f, -4.18848023e-02f, 3.43515240e-02f, 5.84370978e-02f, -7.03381449e-02f, 4.39446457e-02f,
  1.62335578e-02f, 3.53254974e-02f, 3.79579179e-02f, 6.14259765e-02f, -3.96209322e-02f, 4.39827181e-02f, -5.66905700e-02f, -7.64437392e-02f, -3.82428467e-02f, 5.11970706e-02f,
  -1.04312897e-01f, -3.36791165e-02f, 5.04820347e-02f, -9.45812557e-03f, 6.41841143e-02f, 5.64462505e-02f, -1.41078040e-01f, 2.94668358e-02f, -2.43756827e-02f, -9.06963721e-02f,
  -4.62166406e-02f, -3.35054882e-02f, -4.93336432e-02f, 7.05630109e-02f, -1.82289034e-02f, 2.88070869e-02f, 1.13596186e-01f, 4.64483649e-02f, 5.74285649e-02f, 5.54747656e-02f,
  1.02432241e-04f, -5.24648055e-02f, -4.40499671e-02f, 5.68365641e-02f, -1.02603801e-01f, 1.66239347e-02f, -4.36703339e-02f, -5.38742207e-02f, 6.55611232e-02f, 1.24490730e-01f,
  -3.18862237e-02f, -5.83144762e-02f, -1.33451847e-02f, -1.65421944e-02f, -6.13335632e-02f, -7.69677386e-02f, 1.85754709e-02f, -8.03082883e-02f, 5.55132069e-02f, -1.56556536e-02f,
  -1.12130567e-01f, 2.75205523e-02f, 1.56331025e-02f, 6.26557916e-02f, 9.33719147e-03f, -6.34436980e-02f, 1.92615259e-02f, -3.20232697e-02f, -1.18032977e-01f, 1.30595649e-02f,
  1.16319326e-03f, -6.53315336e-02f, 4.94813453e-03f, -5.91460839e-02f, -6.14513941e-02f, -2.95752846e-02f, -2.47752015e-02f, 1.39038682e-01f, 8.84919241e-03f, -1.11783966e-01f,
  2.01915596e-02f, 4.40436639e-02f, 9.54240635e-02f, -1.79375708e-02f, 1.74862221e-02f, 1.27316743e-01f, 3.04399116e-04f, 6.74076080e-02f, 7.37642287e-04f, 7.02864975e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  5.83796129e-02f, 1.22853816e-02f, 1.69221967e-01f, 4.99251634e-02f, -2.13876050e-02f, 4.06372994e-02f, 9.46540833e-02f, 8.31042379e-02f, 1.44902080e-01f, -1.71481781e-02f,
  7.03575909e-02f, 1.42647579e-01f, 2.85317656e-03f, 1.92311943e-01f, 4.55280803e-02f, 9.57089886e-02f, 6.34367466e-02f, 1.33473530e-01f, 4.82158028e-02f, 2.93976478e-02f,
  -4.88788560e-02f, 1.91715732e-01f, -6.81843087e-02f, 4.72779050e-02f, 2.14659274e-02f, 1.45517170e-01f, -1.69596579e-02f, 1.25409886e-01f, 9.27354619e-02f, 1.32028591e-02f,
  1.11848526e-01f, 1.63597688e-01f, 1.87273741e-01f, 1.14932366e-01f, 1.50087595e-01f, 5.59808873e-02f, -2.39754990e-02f, 1.99047431e-01f, -1.64773245e-03f, 1.36382893e-01f,
  1.33324862e-01f, 2.19536066e-01f, 2.73029823e-02f, 2.27549285e-01f, 1.99743435e-01f, 8.65665004e-02f, 8.78487453e-02f, -3.43667343e-02f, 1.07086651e-01f, -1.91575121e-02f,
  3.21030430e-02f, 4.61429777e-03f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.40446931e-01f, 1.96957126e-01f, 1.41808867e-01f, 3.34239304e-02f, 8.43184069e-02f, -1.83154672e-01f, 4.46994126e-01f, -2.39821315e-01f, -5.59668951e-02f, 4.26524691e-02f,
  1.87720716e-01f, -5.56196161e-02f, 6.62665721e-03f, 2.05506571e-02f, -9.99273211e-02f, 8.39657411e-02f, -6.05768301e-02f, -1.19986467e-01f, -1.57840461e-01f, 5.51618971e-02f,
  4.45358232e-02f, -7.08314627e-02f, 1.46004587e-01f, 5.60152009e-02f, -2.19802139e-03f, 2.46827044e-02f, 7.13803619e-02f, -5.93399182e-02f, 1.23244517e-01f, -3.96770462e-02f,
  -7.53665110e-04f, -5.29907085e-02f, 1.79115891e-01f, -6.40800223e-02f, -1.02025092e-01f, -4.33917232e-02f, -7.87958503e-02f, 1.04777873e-01f, -9.91192162e-02f, 4.81558740e-02f,
  -9.67158899e-02f, 1.27724528e-01f, -6.39810115e-02f, 1.15005277e-01f, -2.76804924e-01f, -8.87509584e-02f, 2.37710446e-01f, -2.10628025e-02f, -4.03812304e-02f, -7.70597011e-02f,
  1.28887266e-01f, 1.69134155e-01f, 5.29132411e-02f, 1.76878467e-01f, -1.47902109e-02f, 3.10895536e-02f, -3.12455058e-01f, 1.25652418e-01f, 1.43585607e-01f, 5.54055981e-02f,
  -6.67774528e-02f, -1.55526595e-02f, 6.22508638e-02f, 8.91359523e-02f, -5.82061820e-02f, -1.14246704e-01f, 1.65789455e-01f, 1.66014694e-02f, 8.64635035e-02f, 5.05939536e-02f,
  -2.04729527e-01f, 1.06642909e-01f, -2.58737449e-02f, -4.32830714e-02f, -2.69677371e-01f, -6.71083704e-02f, -1.01628862e-02f, -3.49450223e-02f, -1.32464315e-03f, 1.15806006e-01f,
  4.91888896e-02f, 2.71218475e-02f, 2.04243869e-01f, 7.96193331e-02f, -2.05767855e-01f, 4.22348455e-02f, -4.10125628e-02f, -5.62759750e-02f, -1.02197796e-01f, 3.14411931e-02f,
  -5.51322773e-02f, -4.96002100e-02f, 9.68728587e-02f, -1.66551769e-01f, 1.19913975e-02f, 1.80653371e-02f, -1.29680619e-01f, -6.31580800e-02f, 3.77060212e-02f, 1.64039284e-02f,
  -4.81277667e-02f, 1.23523287e-01f, -4.45539161e-04f, -2.51855459e-02f, -1.74833924e-01f, 2.32866332e-02f, 3.27187106e-02f, -1.63217708e-02f, 1.45969927e-01f, 3.81079428e-02f,
  6.93650618e-02f, -1.14336826e-01f, 7.65004382e-02f, 2.06456155e-01f, -1.56641692e-01f, -1.46869317e-01f, -1.29767522e-01f, -1.10020995e-01f, 6.82514086e-02f, 2.66937204e-02f,
  2.06804261e-01f, -4.07327637e-02f, -1.70073807e-02f, -5.58367074e-02f, 1.45276755e-01f, 1.47004321e-01f, 3.01220752e-02f, 9.86888111e-02f, 6.57326952e-02f, -1.95824113e-02f,
  4.87700142e-02f, 1.18816167e-01f, -1.63706750e-01f, -7.62732401e-02f, 1.28070503e-01f, 1.25490338e-01f, -1.61127687e-01f, -7.30364537e-03f, -5.17859496e-02f, 8.28209892e-03f,
  -2.33492963e-02f, -1.44495174e-01f, -1.50949985e-01f, 9.72479698e-04f, -1.12919221e-02f, 1.43344477e-01f, -9.01553556e-02f, 2.56412268e-01f, 2.71809697e-02f, -1.18029296e-01f,
  -1.88358233e-03f, -1.46903843e-01f, -8.58895294e-03f, 4.36150916e-02f, 9.74439681e-02f, -1.15085125e-01f, -9.13402140e-02f, 5.59164546e-02f, 2.07985193e-01f, 3.70168425e-02f,
  -5.55714928e-02f, -1.48056850e-01f, 1.16611719e-01f, -4.60569002e-02f, 8.02031010e-02f, -5.77315502e-02f, 9.28598514e-04f, -7.31608272e-02f, 6.56258091e-02f, 6.61269128e-02f,
  -1.04006037e-01f, -8.05086493e-02f, -1.39194280e-01f, 3.30125913e-02f, -5.59640303e-02f, 7.91129768e-02f, 1.29829645e-01f, 2.60967642e-01f, -4.53639925e-02f, 5.11502847e-02f,
  -7.40186125e-02f, 6.96416292e-03f, 4.09719460e-02f, -7.40095004e-02f, -1.40776470e-01f, -1.64320081e-01f, -1.06334269e-01f, 4.43694443e-02f, -6.76409975e-02f, -1.96344610e-02f,
  5.16564921e-02f, -8.28592628e-02f, -1.17894702e-01f, 1.94993578e-02f, 9.28965509e-02f, -1.22688852e-01f, -8.77693146e-02f, -2.43990630e-01f, 4.59362119e-01f, -3.01930159e-01f,
  -7.92105198e-02f, 1.12631001e-01f, 1.36644274e-01f, -1.74392566e-01f, -5.17340265e-02f, 4.20990847e-02f, 5.23339100e-02f, 1.61692247e-01f, -1.05065346e-01f, -1.04692630e-01f,
  9.51864794e-02f, 1.28176704e-01f, 2.22601041e-01f, 4.24949341e-02f, -5.82978800e-02f, -7.65218958e-02f, 6.62549436e-02f, 1.18198059e-01f, -1.76875833e-02f, -9.07090679e-02f,
  -1.98771409e-03f, 1.25259295e-01f, -1.43068045e-01f, 1.24941036e-01f, -3.46606597e-02f, -1.51764542e-01f, -5.32945897e-03f, 5.60498312e-02f, 4.94348034e-02f, -1.06265880e-01f,
  4.90873978e-02f, 1.56294420e-01f, 1.05333157e-01f, -2.54000854e-02f, 3.30730341e-02f, 1.24495968e-01f, -8.30304846e-02f, 6.74151257e-02f, 8.15218613e-02f, 3.54461491e-01f,
  -1.28333867e-01f, -6.20949678e-02f, 1.67038858e-01f, 2.08172321e-01f, 1.68753564e-01f, -6.35571256e-02f, -1.11242108e-01f, 7.66675547e-02f, -2.49460056e-01f, -1.19118635e-02f,
  1.27115786e-01f, 1.29376099e-01f, -9.44766998e-02f, -1.44587621e-01f, 7.02947676e-02f, 1.22350164e-01f, 5.44802248e-02f, -6.70066327e-02f, 1.12998433e-01f, 1.97329186e-02f,
  -2.09558308e-01f, 1.14895320e-02f, -2.48544171e-01f, 1.51100770e-01f, -2.87784159e-01f, -1.48369789e-01f, -8.33067000e-02f, 3.35977115e-02f, -6.91676885e-02f, -1.37979627e-01f,
  -4.27647196e-02f, -2.01803058e-01f, 2.49223728e-02f, 6.91751987e-02f, 7.29797110e-02f, 1.86437100e-01f, 3.36629450e-02f, 6.20121621e-02f, 1.10944569e-01f, -1.39972955e-01f,
  4.26988900e-02f, -1.09265596e-01f, -7.75508434e-02f, 6.67675883e-02f, -1.15076138e-03f, 3.08955424e-02f, 1.83564916e-01f, 5.12836576e-02f, 4.67705401e-03f, -6.17269389e-02f,
  -8.31990093e-02f, -1.43492460e-01f, 1.40882898e-02f, 6.65593073e-02f, -1.33259982e-01f, 2.33709440e-02f, 7.80983865e-02f, -1.05927408e-01f, 1.54791117e-01f, -1.39134288e-01f,
  1.22652128e-01f, 6.46555871e-02f, -1.11327909e-01f, 2.16200113e-01f, -4.75892350e-02f, 2.26045012e-01f, -4.48344275e-02f, -3.38315107e-02f, -1.15509659e-01f, -4.29777205e-02f,
  -8.79718214e-02f, -2.25297157e-02f, 1.19186699e-01f, -1.41649410e-01f, 9.34725031e-02f, 1.01571344e-01f, 6.42923564e-02f, 9.73924622e-02f, 3.93427797e-02f, -3.62490378e-02f,
  -2.17992794e-02f, -1.66085243e-01f, 2.90430412e-02f, 7.27920756e-02f, 1.41226903e-01f, 8.50168765e-02f, -1.36661842e-01f, -5.20926416e-02f, 2.50335991e-01f, 2.82829732e-01f,
  -6.70480505e-02f, 1.87754393e-01f, 1.86272070e-01f, 1.51527539e-01f, 8.89653862e-02f, 1.28434122e-01f, -1.55311421e-01f, 7.85884485e-02f, 1.81819603e-01f, -3.10962945e-02f,
  -3.44674215e-02f, 1.63345888e-01f, 8.48195255e-02f, -2.33154576e-02f, 1.95308272e-02f, -2.04664513e-01f, 1.34605125e-01f, 9.76422569e-04f, -1.12487927e-01f, 3.99905033e-02f,
  -2.78363526e-01f, -1.54153118e-02f, 6.93408176e-02f, -8.32895786e-02f, -3.03328093e-02f, 1.99416041e-01f, 1.41334444e-01f, 4.77719605e-02f, -1.58902723e-02f, 5.44975512e-02f,
  7.73096411e-03f, -6.95062149e-03f, -1.33328825e-01f, 4.41189446e-02f, 1.71027035e-01f, -6.71176612e-02f, 1.05892308e-02f, -1.36528373e-01f, 2.90066749e-02f, -2.21034557e-01f,
  -7.04831704e-02f, -8.92273989e-03f, 1.27070263e-01f, 1.08028539e-01f, -5.41411340e-02f, 3.19009870e-02f, 1.04168236e-01f, 3.45515981e-02f, -1.30531460e-01f, 6.46719411e-02f,
  -8.49346817e-02f, -7.03472719e-02f, 1.36891305e-01f, -1.27678841e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.13239177e-01f, 4.36060466e-02f, -2.34288685e-02f, 6.27725432e-03f, -5.43689691e-02f, 1.68747699e-03f, -1.19465172e-01f, 2.85476074e-02f, -8.47327635e-02f, 2.36351453e-02f,
  1.29928719e-03f, -2.12151427e-02f, -3.90535779e-02f, -3.07711363e-02f, -3.82496268e-02f, 2.91780997e-02f, 1.38777748e-01f, 5.14590144e-02f, 1.47076817e-02f, 3.61381583e-02f,
  -2.38521360e-02f, -2.76634581e-02f, 1.11413918e-01f, 7.65703395e-02f, 1.59763172e-02f, 1.38688371e-01f, 1.29944101e-01f, -6.24662228e-02f, -4.44326550e-04f, -5.91490418e-02f,
  -4.80866209e-02f, -1.17978603e-01f, -7.73009509e-02f, 4.87589985e-02f, -6.62610009e-02f, -9.85853225e-02f, -7.38430619e-02f, 4.17756587e-02f, 4.31231745e-02f, -1.16501033e-01f,
  -5.28680347e-02f, -3.55506986e-02f, 1.13622136e-01f, 7.76270702e-02f, -8.67544413e-02f, 1.14324242e-01f, -1.37198836e-01f, -7.22045824e-02f, 1.41592234e-01f, 8.04849491e-02f,
  4.82219271e-02f, 6.64006174e-02f, -4.84494083e-02f, -7.22217038e-02f, -6.09305575e-02f, 9.18977857e-02f, -6.73492998e-02f, -3.23606469e-02f, 1.00744762e-01f, -6.39992021e-03f,
  -1.44483838e-02f, 3.99603993e-02f, -4.59658429e-02f, 6.89252838e-02f, 1.70051724e-01f, 8.83159190e-02f, -3.82133499e-02f, 1.25542516e-02f, 7.37936273e-02f, 1.37730107e-01f,
  -1.16691813e-01f, -6.36244863e-02f, 7.21710697e-02f, 8.88411999e-02f, 1.90050989e-01f, 4.46832068e-02f, -5.44474721e-02f, 1.85292900e-01f, 1.34333998e-01f, -7.05465451e-02f,
  7.77524039e-02f, 8.06358680e-02f, -6.21105246e-02f, -1.11578025e-01f, 1.17970042e-01f, 1.25802100e-01f, -6.45403191e-02f, -1.02576740e-01f, 2.29433808e-03f, -1.24903955e-01f,
  1.47618309e-01f, 1.01514049e-01f, -1.63484551e-02f, 1.59514084e-01f, -7.42964819e-02f, 1.54029638e-01f, -8.19711983e-02f, 1.25498563e-01f, -1.33730546e-01f, 8.44068304e-02f,
  6.21848591e-02f, -1.33343130e-01f, -2.63475515e-02f, -1.92996524e-02f, -2.55423505e-02f, -8.87631476e-02f, -5.05988635e-02f, 6.88464567e-02f, 1.11651570e-01f, -1.93502996e-02f,
  -3.17371711e-02f, -9.27418694e-02f, 3.89830605e-03f, -6.11067861e-02f, -8.54679644e-02f, 4.60640490e-02f, 9.40849558e-02f, 1.53900206e-01f, -4.54413220e-02f, 1.87491655e-01f,
  1.17921405e-01f, 1.21030860e-01f, 8.70693177e-02f, -9.82474089e-02f, -1.03579722e-02f, -7.47371763e-02f, 6.28648177e-02f, -9.67405662e-02f, -2.48638019e-02f, 1.21105951e-03f,
  5.42471297e-02f, 7.45742097e-02f, -3.00604738e-02f, 8.42887163e-02f, 6.55283481e-02f, 2.59933658e-02f, -5.47135808e-02f, -1.46353826e-01f, -7.96805099e-02f, 5.49751800e-03f,
  -5.66195399e-02f, -6.26044050e-02f, -1.17529556e-01f, -6.37853742e-02f, 1.05190150e-01f, 6.49353415e-02f, 6.54342622e-02f, -2.71797106e-02f, -1.08069241e-01f, 9.44356397e-02f,
  8.96438062e-02f, -3.32650319e-02f, 1.25625357e-01f, 2.75996104e-02f, 1.21951662e-02f, 4.42539044e-02f, 6.09867945e-02f, 4.05387171e-02f, -1.21814147e-01f, 2.86813565e-02f,
  9.85932201e-02f, -1.36332194e-04f, -6.34629419e-03f, -7.64148636e-03f, 2.15158928e-02f, -3.82164307e-02f, 5.27873775e-03f, 1.02948345e-01f, -1.25972494e-01f, 1.04012661e-01f,
  -7.41645694e-02f, 9.82518718e-02f, -7.90002719e-02f, 1.10986523e-01f, 1.33288234e-01f, 1.80378500e-02f, -8.46010000e-02f, -7.89422616e-02f, -5.23178838e-02f, -8.59748498e-02f,
  -1.06098540e-01f, -7.36885443e-02f, 5.51536717e-02f, 7.74341682e-03f, 3.25879082e-02f, 8.20365474e-02f, -2.10370813e-02f, 4.82094027e-02f, -3.53677347e-02f, 2.18063686e-02f,
  -1.89905819e-02f, -1.51827978e-02f, -5.54185919e-02f, -1.17698945e-01f, -8.49545375e-02f, 5.02906069e-02f, 4.93225157e-02f, -1.16923109e-01f, 8.41995627e-02f, 1.52296107e-02f,
  1.67093515e-01f, 6.00330271e-02f, 2.21709162e-02f, 6.81911036e-02f, 1.13997959e-01f, -8.22432339e-03f, 1.05480768e-01f, 1.17786542e-01f, 1.19992726e-01f, 3.69303934e-02f,
  7.58972913e-02f, 1.19805627e-03f, -1.05112776e-01f, -1.00213327e-01f, 2.26611104e-02f, 6.58053309e-02f, -3.31207179e-02f, -4.03488874e-02f, -1.21803060e-01f, 1.87110510e-02f,
  -3.87023129e-02f, -1.06163301e-01f, -2.48137917e-02f, 3.44699770e-02f, 2.44962461e-02f, -4.95158732e-02f, 6.97261095e-02f, -1.12180486e-01f, -1.71581488e-02f, -1.06876329e-01f,
  1.02496453e-01f, 5.69298863e-02f, 2.48402394e-02f, -6.88228086e-02f, 2.57410668e-02f, -4.55215573e-02f, -9.98162404e-02f, -2.07587611e-02f, 3.36680338e-02f, -1.25055060e-01f,
  -5.98457530e-02f, 4.52726660e-03f, -1.15954213e-01f, 6.72417274e-03f, -1.14884056e-01f, 2.68987380e-02f, 1.03167541e-01f, -7.61512220e-02f, 6.05195686e-02f, -5.76699339e-02f,
  -1.11775048e-01f, 9.15739834e-02f, 4.33003455e-02f, 1.33952320e-01f, 8.07883888e-02f, -1.23433799e-01f, 9.80316382e-03f, 2.81878948e-01f, 1.72783375e-01f, 2.52093732e-01f,
  6.01024330e-02f, -3.66029255e-02f, 1.31859362e-01f, -1.55232564e-01f, -2.09690347e-01f, 1.71233162e-01f, 7.48511869e-03f, 9.56243202e-02f, -1.07581221e-01f, -6.07322028e-04f,
  1.30485356e-01f, -1.33157238e-01f, 1.26853669e-02f, 1.28176972e-01f, -4.59527597e-02f, 1.10688888e-01f, -5.16087487e-02f, -2.90107839e-02f, -4.26413193e-02f, -6.49029687e-02f,
  -5.45770042e-02f, 1.34244617e-02f, 1.26104191e-01f, -1.80940926e-02f, -5.35527654e-02f, 4.76132929e-02f, -1.35305122e-01f, -7.56668150e-02f, 1.43571850e-02f, 1.97074503e-01f,
  -3.80754587e-03f, 5.42936102e-03f, -8.70165080e-02f, -4.84796651e-02f, -9.80137438e-02f, 1.38202846e-01f, 1.46686301e-01f, 4.78265211e-02f, 8.93380642e-02f, -1.92946363e-02f,
  2.61962004e-02f, 1.48058131e-01f, 1.23770326e-01f, 3.68680358e-01f, 9.81080458e-02f, -1.32702310e-02f, -3.53120118e-02f, 9.04709548e-02f, 8.53717402e-02f, -1.37684504e-02f,
  1.55755088e-01f, 3.00856858e-01f, -1.42239720e-01f, -8.91628787e-02f, -7.39798993e-02f, 9.05801952e-02f, -4.02844734e-02f, -6.88549653e-02f, -5.25701754e-02f, -1.56354960e-02f,
  -1.19524196e-01f, 1.73446372e-01f, 8.95459950e-02f, -1.38808899e-02f, -4.60725762e-02f, 9.07738730e-02f, -1.90313295e-01f, -9.04911757e-02f, 4.61673439e-02f, 6.52550161e-02f,
  1.09225094e-01f, 1.01022929e-01f, -2.79081389e-02f, 1.17654391e-01f, 7.56991655e-02f, -9.71409772e-03f, 6.20956309e-02f, 5.59373088e-02f, 1.06933512e-01f, 6.01889454e-02f,
  -7.14218318e-02f, -8.20523873e-02f, 6.86350977e-03f, -4.25943434e-02f, 1.87645033e-02f, 1.65946871e-01f, -6.16136231e-02f, -1.49106532e-02f, -5.81889898e-02f, -7.49013647e-02f,
  2.63556968e-02f, 1.11220507e-02f, -3.79738808e-02f, 1.38338074e-01f, -6.52586222e-02f, -8.03217012e-03f, 1.30626321e-01f, -2.98237484e-02f, 2.17081551e-02f, -4.78263460e-02f,
  3.13972048e-02f, -5.95550910e-02f, -1.23825185e-01f, -1.25468835e-01f, 1.10929504e-01f, 1.91823632e-01f, 1.06875174e-01f, 1.73395276e-01f, 1.90509871e-01f, -1.14339069e-01f,
  8.82879552e-03f, -1.20175071e-01f, -6.66250139e-02f, -9.94583219e-02f, 2.17607886e-01f, 2.92239726e-01f, 6.12204038e-02f, 1.09403264e-02f, 1.33773059e-01f, 1.39946649e-02f,
  6.17134906e-02f, -1.02485374e-01f, -1.43433027e-02f, -5.03968783e-02f, 2.36198828e-02f, 1.46541491e-01f, 5.35640642e-02f, 1.13708876e-01f, 1.64321035e-01f, -2.21192744e-02f,
  2.96442211e-02f, -3.61428820e-02f, -3.93229127e-02f, -7.02212602e-02f, -6.17894195e-02f, -2.72448897e-01f, -1.31195322e-01f, -3.14703584e-02f, 8.35264027e-02f, -2.17404049e-02f,
  -9.93217677e-02f, 2.14714497e-01f, 1.95778012e-01f, 1.09051347e-01f, 1.80190802e-02f, -1.14542738e-01f, 1.31171137e-01f, 7.13109821e-02f, 8.67431313e-02f, 3.57608199e-02f,
  -8.20369925e-03f, -1.61086485e-01f, 1.79294974e-01f, 7.49017149e-02f, -6.23825984e-03f, -9.50237289e-02f, 7.74366260e-02f, -9.86300558e-02f, 5.43815196e-02f, -4.37314622e-02f,
  -4.86334451e-02f, 6.88226596e-02f, -5.78653067e-02f, 1.45242428e-02f, -1.86971173e-01f, 1.17737882e-01f, -5.95597699e-02f, 3.78376655e-02f, 9.40709636e-02f, -4.60957661e-02f,
  1.14033543e-01f, -2.52905488e-03f, -3.21554653e-02f, 1.35553449e-01f, -3.61817032e-02f, 5.75106731e-03f, -1.68883875e-01f, 1.89590231e-01f, 2.72907242e-02f, -1.22199535e-01f,
  4.08045463e-02f, -1.63458213e-01f, 7.13504627e-02f, -5.09707779e-02f, 1.95018381e-01f, -4.24313769e-02f, 6.35138527e-02f, -4.57735918e-02f, -6.89785331e-02f, -4.16233577e-02f,
  -4.91856877e-03f, -1.46327186e-02f, -2.93436944e-02f, 2.55305152e-02f, -1.53683081e-01f, 9.23157483e-03f, -7.47564211e-02f, -1.31836487e-02f, 8.73470977e-02f, 1.08521603e-01f,
  -1.10625871e-01f, -1.40155494e-01f, -1.15660854e-01f, -7.49100819e-02f, 2.58015972e-02f, -6.21371269e-02f, 2.50103790e-02f, 1.59879997e-01f, 5.49499206e-02f, -8.62641409e-02f,
  6.70775846e-02f, -1.44962342e-02f, 7.84716383e-02f, 5.31381741e-02f, 4.59290221e-02f, -4.79283370e-02f, -5.53476848e-02f, -6.22802079e-02f, -6.97112409e-03f, -1.33567572e-01f,
  9.99163091e-02f, 9.12194178e-02f, -1.16267547e-01f, 5.47548197e-02f, -7.80892819e-02f, 3.96442339e-02f, -4.30836603e-02f, -2.30889414e-02f, 4.03710119e-02f, 1.04926147e-01f,
  4.85893562e-02f, -1.09212331e-01f, 6.64292052e-02f, 9.90060791e-02f, -6.76392168e-02f, -1.27005596e-02f, -2.86203735e-02f, -7.33067840e-03f, 1.18600346e-01f, -3.89414169e-02f,
  5.06847091e-02f, -1.91803351e-02f, 9.31224450e-02f, 1.21536151e-01f, 1.16701402e-01f, -1.70618121e-03f, 1.59174278e-02f, 5.34741320e-02f, 3.95634510e-02f, 8.36500376e-02f,
  -4.04243022e-02f, 2.16632485e-02f, 5.13531175e-03f, -6.54426590e-02f, 3.16400379e-02f, 7.80972710e-04f, -4.67491113e-02f, -7.16991201e-02f, -1.01203412e-01f, -3.76224183e-02f,
  -1.58667415e-02f, 7.43992031e-02f, -3.40947099e-02f, -6.21928647e-02f, -8.30512121e-02f, 1.25791281e-01f, 1.26956543e-02f, 6.42528757e-03f, -6.40530735e-02f, 1.20908663e-01f,
  1.03543118e-01f, -4.50840667e-02f, 1.25211552e-01f, 8.09906349e-02f, 8.84977169e-03f, -2.97817197e-02f, 8.43945295e-02f, 3.32759023e-02f, -4.95285057e-02f, 2.64621284e-02f,
  2.95654275e-02f, 7.09486306e-02f, 9.83645767e-02f, -1.17133744e-01f, 1.26151577e-01f, 9.97562427e-03f, 8.41312259e-02f, 1.12121910e-01f, 1.02309458e-01f, 1.08067825e-01f,
  -1.99626088e-02f, 8.72489437e-02f, -8.01333934e-02f, 5.50221233e-03f, 2.47105099e-02f, 8.70333165e-02f, 1.07956849e-01f, 8.61956179e-03f, -6.16721213e-02f, -3.37613560e-02f,
  -4.63640280e-02f, -1.00735597e-01f, 6.13189675e-03f, 9.69339162e-02f, -7.85580203e-02f, 1.43361509e-01f, -6.59990776e-03f, 1.41743738e-02f, -6.81047589e-02f, 8.36975425e-02f,
  -7.20863640e-02f, 1.94195472e-02f, 5.99135868e-02f, 1.17062189e-01f, -1.02030531e-01f, -4.86689657e-02f, 3.03457737e-01f, 5.05424887e-02f, 1.90760732e-01f, 2.58156091e-01f,
  2.44364932e-01f, 3.65040660e-01f, -4.07119483e-01f, 2.05212787e-01f, 1.23855300e-01f, 8.26839060e-02f, 1.12222925e-01f, -1.13811731e-01f, 1.65688813e-01f, 5.51950149e-02f,
  1.70320556e-01f, -6.40509203e-02f, -1.09467030e-01f, 1.69530347e-01f, 3.24931264e-01f, -2.09580809e-02f, -4.57187817e-02f, 3.93052809e-02f, 1.05407186e-01f, 1.08828411e-01f,
  -4.49971147e-02f, 1.38943031e-01f, -3.31444740e-02f, -3.73866297e-02f, -7.28850514e-02f, 1.57352731e-01f, 1.51052877e-01f, 1.05852835e-01f, -9.56362188e-02f, 6.80765659e-02f,
  -3.19598652e-02f, 1.08964354e-01f, 1.29613936e-01f, -9.70459450e-03f, 9.51836482e-02f, 7.22785294e-02f, -8.50893259e-02f, -3.74712348e-02f, 1.21677689e-01f, 1.32556334e-01f,
  2.61606246e-01f, 1.54001480e-02f, -6.28398657e-02f, -2.54723400e-01f, -1.22858830e-01f, 3.14635746e-02f, -8.22781101e-02f, 7.33966753e-03f, 4.98918118e-03f, 2.39533633e-01f,
  2.17442438e-02f, 7.44088786e-03f, 2.58684486e-01f, 1.84415504e-01f, -4.00993191e-02f, 5.62998429e-02f, 1.89769551e-01f, 1.09025121e-01f, 6.64603636e-02f, -1.71916589e-01f,
  3.84331308e-02f, 2.41530299e-01f, 2.12929368e-01f, 2.13860601e-01f, -4.29335237e-02f, 8.76116902e-02f, 1.23047329e-01f, -8.45768303e-02f, -1.94540471e-01f, 1.72126666e-01f,
  1.86155930e-01f, 2.02019691e-01f, 4.93262149e-02f, 1.05878867e-01f, -3.31216748e-03f, -1.32743582e-01f, -6.09184280e-02f, 1.42481297e-01f, -4.89732437e-02f, -3.84055339e-02f,
  3.57317030e-01f, 1.44956589e-01f, -1.25012815e-01f, 1.23296240e-02f, 1.52820610e-02f, 1.34772539e-01f, -2.55184416e-02f, 1.92161441e-01f, -1.64609984e-01f, 1.13980897e-01f,
  -1.23876065e-01f, -6.02642000e-02f, 7.72488788e-02f, 2.01234315e-02f, 1.31665925e-02f, 1.78715229e-01f, 5.83919976e-03f, -1.66904524e-01f, 1.25891298e-01f, 1.25160992e-01f,
  -2.10784655e-03f, 1.05546169e-01f, 9.42577943e-02f, 7.20197782e-02f, -8.51335004e-02f, -1.46112651e-01f, -2.53902227e-02f, 4.82364297e-01f, -1.16501912e-01f, -7.14966506e-02f,
  2.05792367e-01f, 5.01056947e-02f, 2.65070111e-01f, -4.54930700e-02f, -1.78347174e-02f, 2.12286100e-01f, -7.59339556e-02f, -2.42206044e-02f, -1.14634864e-01f, 1.18763685e-01f,
  -7.74073601e-02f, -1.43557563e-01f, 1.40712768e-01f, 1.34586930e-01f, -1.72631796e-02f, 1.32679939e-01f, 1.02431113e-02f, -8.26913118e-03f, 1.94526210e-01f, 7.92521760e-02f,
  -1.35199890e-01f, -1.39370143e-01f, 1.65015504e-01f, -1.25761405e-01f, 4.58653904e-02f, 1.21023379e-01f, 1.72958270e-01f, 7.64586106e-02f, 1.18239798e-01f, 1.08287178e-01f,
  1.14312284e-01f, 1.50207609e-01f, 1.05472468e-01f, -1.44248813e-01f, -9.82814580e-02f, -7.42398053e-02f, 1.68632776e-01f, 1.03904776e-01f, 1.27686992e-01f, 9.97046009e-02f,
  -2.83319186e-02f, -1.35380700e-01f, 3.23812850e-02f, -1.14137262e-01f, -1.22830406e-01f, 1.36576638e-01f, -7.75918141e-02f, 1.79742396e-01f, 6.77569434e-02f, 4.45468910e-02f,
  4.94786650e-02f, 4.12458228e-03f, -2.58854255e-02f, 1.29585236e-01f, -4.13429551e-02f, -4.94643860e-02f, -2.30423957e-02f, -6.02436848e-02f, 9.04382765e-02f, 2.34451815e-02f,
  6.06358759e-02f, -2.44768728e-02f, 1.24572508e-01f, 9.21636063e-04f, -1.13673069e-01f, -8.76568481e-02f, -2.39507519e-02f, 8.91358107e-02f, 1.43785387e-01f, 1.04317926e-01f,
  3.27985324e-02f, 8.75478685e-02f, 1.32321969e-01f, 1.09074749e-01f, -2.76694214e-03f, -3.62953059e-02f, 1.37751907e-01f, -8.45326856e-02f, 2.84822751e-02f, 5.59823913e-03f,
  4.63647209e-02f, 2.88000721e-02f, -7.48954862e-02f, -3.08286604e-02f, 1.23055123e-01f, -9.41104293e-02f, -1.51579484e-01f, -4.25956920e-02f, 3.66912670e-02f, -1.18914567e-01f,
  -7.76312202e-02f, 2.08431147e-02f, 1.95669737e-02f, -1.05302721e-01f, -1.14527673e-01f, 6.08784929e-02f, -1.33970097e-01f, 5.30926585e-02f, 7.54191307e-03f, 7.99709707e-02f,
  -7.80178905e-02f, 6.17796108e-02f, -8.51919875e-02f, -1.11405076e-02f, 1.03315368e-01f, 1.02234133e-01f, -1.02753565e-01f, -4.35447916e-02f, -6.61448017e-02f, 6.50833994e-02f,
  4.30056974e-02f, -1.63336052e-03f, 5.85848726e-02f, -8.60537961e-02f, -1.87707040e-02f, -8.86075273e-02f, -8.66320282e-02f, -1.00423910e-01f, 1.11947671e-01f, 9.21472237e-02f,
  9.67256874e-02f, -8.37159753e-02f, -1.37211397e-01f, -9.91620421e-02f, -3.46743390e-02f, 5.10210693e-02f, -1.14888765e-01f, 4.31698263e-02f, -6.92344755e-02f, 3.13233361e-02f,
  5.45442514e-02f, 9.22883153e-02f, 1.00970529e-01f, -2.75334753e-02f, 9.25283786e-03f, -4.16393355e-02f, 1.23345204e-01f, -5.25249355e-02f, -3.87264118e-02f, 1.49290469e-02f,
  1.10344574e-01f, 5.78719378e-02f, 1.94437027e-01f, 3.97131890e-02f, 1.62575945e-01f, 1.63959444e-01f, 3.55318598e-02f, 1.70526579e-01f, 2.78171867e-01f, -8.40397924e-02f,
  6.63674101e-02f, -6.80295080e-02f, 1.23162605e-02f, 1.33276656e-01f, -1.07265763e-01f, -5.91135100e-02f, 8.77867267e-02f, 8.60653818e-02f, 2.85337791e-02f, -2.32156273e-02f,
  -8.48427340e-02f, 6.15596138e-02f, 1.31183848e-01f, -2.34396886e-02f, 5.27904220e-02f, 7.07632601e-02f, 7.00382367e-02f, 4.14989293e-02f, -5.20029105e-03f, 8.93006772e-02f,
  -1.29967541e-01f, -4.62094694e-02f, -6.88749105e-02f, -2.43688356e-02f, 1.37368981e-02f, 1.05134532e-01f, -2.29520313e-02f, 3.41415107e-02f, -4.74628285e-02f, 2.89556310e-02f,
  1.02765411e-01f, 3.74010913e-02f, 8.32324177e-02f, -7.48427352e-03f, 1.19213387e-01f, 1.35746777e-01f, -6.75305277e-02f, -5.82221188e-02f, 9.58234146e-02f, 4.66600955e-02f,
  -2.00958282e-01f, -5.61358668e-02f, 6.51885271e-02f, 1.77714109e-01f, 8.88826326e-02f, 1.04804903e-01f, -1.03213862e-01f, -5.18215410e-02f, -1.17393136e-01f, -8.57235268e-02f,
  1.32063299e-01f, 7.92902783e-02f, 8.80538151e-02f, -9.53890681e-02f, 1.62774622e-02f, -1.35195088e-02f, 1.52990207e-01f, 4.52731363e-02f, 1.12377867e-01f, 3.25273746e-03f,
  1.90348327e-02f, -6.55389503e-02f, 5.89506254e-02f, -3.86793762e-02f, -8.43847096e-02f, -9.17163566e-02f, 1.38595432e-01f, 2.03523785e-01f, 4.46497723e-02f, -3.67413275e-02f,
  -3.51394750e-02f, -1.09417895e-02f, -5.81031851e-02f, 9.52142552e-02f, -4.44920808e-02f, -1.91056773e-01f, 4.22158167e-02f, -1.84773654e-02f, 1.65394582e-02f, 1.61124226e-02f,
  1.07972115e-01f, 5.52326255e-02f, -6.85534403e-02f, 8.29866752e-02f, 7.74737597e-02f, -6.14374429e-02f, -8.19642618e-02f, 7.01596728e-03f, -2.72457278e-03f, 1.25144213e-01f,
  -1.21388957e-01f, -8.20853487e-02f, -1.15688734e-01f, -4.11715619e-02f, 1.02099538e-01f, 4.96399365e-02f, -1.87102780e-02f, 1.14843965e-01f, 1.28155306e-01f, -7.18358383e-02f,
  2.36944016e-02f, 9.52695012e-02f, -9.18707550e-02f, 4.11168970e-02f, -7.54571334e-02f, -8.94174501e-02f, -3.00495736e-02f, 1.19855098e-01f, 5.51540256e-02f, 9.94474534e-03f,
  4.38716151e-02f, -6.59536943e-03f, -1.86690494e-01f, -6.20576665e-02f, 1.29231587e-01f, 5.79044856e-02f, 4.31756116e-02f, -6.47078976e-02f, -1.28431767e-02f, 8.61702636e-02f,
  -8.18049237e-02f, -4.65031415e-02f, 8.90725944e-03f, 1.59939840e-01f, -1.05786957e-02f, 1.44563327e-02f, -1.06407359e-01f, 1.38725504e-01f, -3.23940367e-02f, 9.14896652e-02f,
  -1.75144136e-01f, -1.35959670e-01f, 1.22204274e-01f, 9.68821347e-02f, 1.27547055e-01f, -9.37923342e-02f, -9.21906531e-03f, 2.50430405e-02f, -4.61374335e-02f, 1.20120101e-01f,
  1.49170235e-01f, -5.77209853e-02f, -3.38645503e-02f, -6.04124479e-02f, -1.02373287e-01f, -4.23946977e-02f, 2.32189968e-02f, 1.24495896e-02f, -5.99680617e-02f, 1.15924276e-01f,
  2.91971508e-02f, 6.21199198e-02f, -1.15751252e-01f, -5.56507781e-02f, 7.77792707e-02f, 1.72569692e-01f, -5.54994419e-02f, 1.09245762e-01f, -2.92157400e-02f, 5.89610972e-02f,
  -2.20600218e-02f, -7.76209384e-02f, -5.93069829e-02f, 7.85155222e-02f, -6.90846145e-02f, 1.06232710e-01f, 8.58302042e-02f, -3.77699472e-02f, 8.00883770e-02f, 1.43282622e-01f,
  6.49018660e-02f, -3.77326161e-02f, 1.07816674e-01f, -6.24252744e-02f, 1.27175137e-01f, 7.27072284e-02f, 4.44440506e-02f, -2.94771157e-02f, -8.77053142e-02f, 1.04806341e-01f,
  1.26458570e-01f, -1.13529094e-01f, -8.14424269e-03f, -9.10236686e-02f, 4.64431308e-02f, 3.35489176e-02f, 4.67205159e-02f, -5.24801575e-02f, -3.81394066e-02f, -9.68890414e-02f,
  -9.10462365e-02f, -8.67470205e-02f, -6.98929206e-02f, -1.03237949e-01f, 1.42491102e-01f, 8.76914710e-02f, 2.11056266e-02f, -9.18081626e-02f, 1.28614798e-01f, -1.28036529e-01f,
  2.93742027e-02f, -1.50645925e-02f, 1.71576932e-01f, -9.28954333e-02f, -1.01955004e-01f, -1.09743342e-01f, 6.57570809e-02f, -5.20411655e-02f, 7.27104098e-02f, 3.99724767e-02f,
  1.05802596e-01f, -4.62258384e-02f, 3.86074968e-02f, -9.68878940e-02f, -7.52430111e-02f, -7.90119693e-02f, 1.43500157e-02f, 1.78400502e-01f, 9.50011984e-02f, -1.98121443e-01f,
  1.15879793e-02f, -2.03529764e-02f, -7.33441561e-02f, 2.79497411e-02f, -2.98955124e-02f, 6.47247359e-02f, 5.18476926e-02f, -4.41363081e-02f, 2.07274914e-01f, 2.01029822e-01f,
  -1.02972567e-01f, 9.40366164e-02f, 1.26774058e-01f, -5.01893722e-02f, -4.51765731e-02f, -5.48350625e-02f, -7.91122466e-02f, 8.62412974e-02f, 1.10255554e-01f, 2.34776884e-01f,
  1.37944281e-01f, -4.45856191e-02f, 9.00025293e-02f, -1.02469614e-02f, -3.94125134e-02f, 1.00927703e-01f, 7.66612068e-02f, -7.96167403e-02f, 1.77065805e-01f, 1.81594893e-01f,
  1.59861520e-01f, 2.23778963e-01f, 1.31803676e-01f, 1.87809929e-01f, -9.26467329e-02f, 1.04091004e-01f, 1.91606298e-01f, -6.90684840e-02f, 2.19002798e-01f, -1.38734207e-01f,
  -3.64294387e-02f, -5.04594389e-03f, 5.87145835e-02f, -7.78072551e-02f, -8.18082839e-02f, 9.97349247e-03f, 2.98472941e-01f, -1.14257976e-01f, -1.14003912e-01f, 1.34048656e-01f,
  1.77404925e-01f, 2.06200466e-01f, 1.03671633e-01f, 5.93378507e-02f, 1.54209346e-01f, 1.40552774e-01f, -7.46129155e-02f, 1.33342445e-01f, -3.44204269e-02f, 1.00557849e-01f,
  1.26622409e-01f, 1.59051985e-01f, -6.60901964e-02f, -2.38494202e-02f, 9.61979702e-02f, 8.47956166e-02f, -4.47013155e-02f, 1.39705054e-02f, 4.62971963e-02f, -9.92970914e-02f,
  -2.23135315e-02f, 6.95623532e-02f, 9.87775475e-02f, -1.20620809e-01f, -1.04269795e-01f, -1.95904955e-01f, -5.62048890e-02f, -2.53013819e-02f, 3.17511335e-02f, 1.41508147e-01f,
  6.99573383e-02f, 2.28357166e-01f, -9.40765068e-02f, 1.36785835e-01f, 3.06116164e-01f, -5.87643608e-02f, 1.41550392e-01f, -6.49857298e-02f, 3.30880359e-02f, 1.15251176e-01f,
  5.60721681e-02f, -8.24051946e-02f, 3.99472751e-03f, 1.11522162e-02f, 9.44342762e-02f, 3.37755568e-02f, 8.78233276e-03f, -1.19552039e-01f, 8.80069509e-02f, 8.24819803e-02f,
  -9.86485034e-02f, -6.72649071e-02f, -9.06277969e-02f, -1.20478772e-01f, 7.63411000e-02f, -1.07085288e-01f, -1.42097518e-01f, 3.64027694e-02f, -1.00012928e-01f, -9.86922383e-02f,
  4.53648791e-02f, -5.36328666e-02f, 9.28559452e-02f, 8.81317407e-02f, -1.14720479e-01f, 1.18280262e-01f, -2.37932112e-02f, 2.25924142e-02f, -9.28529799e-02f, -9.05759782e-02f,
  4.41312231e-02f, 4.54415120e-02f, 5.25761098e-02f, -1.88082047e-02f, -1.18499927e-01f, -7.10727349e-02f, 1.12004876e-01f, 1.35975435e-01f, -5.37137501e-02f, 1.79858729e-02f,
  -9.67330113e-02f, -5.73957227e-02f, 9.53979865e-02f, 2.55890302e-02f, -6.59077168e-02f, -9.25328359e-02f, -1.20184921e-01f, -2.19769608e-02f, -2.13206112e-02f, -1.39174625e-01f,
  -3.80072556e-02f, 1.36459827e-01f, -3.23944576e-02f, 1.27803637e-02f, 2.76970379e-02f, -6.27512559e-02f, 7.35205933e-02f, -1.39043137e-01f, -2.44839024e-02f, 3.80792357e-02f,
  -1.05239870e-02f, -3.84160168e-02f, 9.24791470e-02f, -7.97592998e-02f, -1.10868970e-02f, -4.63946648e-02f, 5.83412573e-02f, 9.14928317e-02f, 1.43675692e-02f, 6.90241456e-02f,
  -3.35404761e-02f, 1.70012817e-01f, -1.80116281e-01f, -9.59835574e-02f, -1.45125523e-01f, -4.53965999e-02f, 1.06390126e-01f, 1.09354392e-01f, 1.23368390e-01f, 1.19885407e-01f,
  1.92444354e-01f, 7.09592998e-02f, -1.34143963e-01f, -6.24970943e-02f, 1.03389375e-01f, 2.71222158e-03f, 1.02021210e-01f, 6.86867982e-02f, 1.07837208e-01f, 3.70448530e-02f,
  -3.23994225e-03f, -8.43075886e-02f, 9.33871642e-02f, 7.21640065e-02f, -9.50407702e-03f, 6.30915090e-02f, 5.76004796e-02f, -7.89397284e-02f, 8.54736492e-02f, 1.34506091e-01f,
  4.92131822e-02f, 8.38350505e-02f, 1.51714399e-01f, 6.59861714e-02f, -1.10786334e-01f, -6.58806115e-02f, 7.87657499e-02f, -1.19480975e-01f, -5.53843677e-02f, 3.75572070e-02f,
  1.62030801e-01f, 1.23417445e-01f, -6.85590431e-02f, 1.25890553e-01f, 9.27583128e-02f, -1.09914981e-01f, 9.45289508e-02f, 1.16120316e-01f, -6.57189563e-02f, 8.89593810e-02f,
  1.10302277e-01f, 1.36893645e-01f, 1.26021490e-01f, 1.77206155e-02f, 9.28592235e-02f, 7.20379874e-02f, -4.24728692e-02f, -4.11995798e-02f, 1.16187304e-01f, -6.87718391e-02f,
  1.88918069e-01f, 2.03401223e-01f, 1.57104984e-01f, 1.77662387e-01f, 6.76061437e-02f, -5.41406311e-02f, -1.87080409e-02f, -1.42218813e-01f, -9.02018473e-02f, -1.23533318e-02f,
  2.07163721e-01f, -2.63266824e-02f, 3.71253826e-02f, -5.32537838e-03f, 1.75306767e-01f, -1.04204938e-01f, 1.23470075e-01f, 1.40009403e-01f, -1.41871452e-01f, -1.70219764e-01f,
  -2.31103539e-01f, 3.64560634e-02f, 1.80504307e-01f, 4.80093434e-02f, -6.19245991e-02f, 7.22585097e-02f, -7.36856982e-02f, 5.00816561e-04f, 1.41751915e-01f, -7.07784072e-02f,
  -4.61017378e-02f, 1.03842467e-01f, -1.23280317e-01f, 2.29211241e-01f, -1.15267038e-01f, -7.54102767e-02f, -4.40135151e-02f, 1.03399500e-01f, -1.09198615e-01f, 3.60768549e-02f,
  -9.96044055e-02f, 6.26039952e-02f, -1.11793339e-01f, -4.82961424e-02f, -4.68609296e-02f, 1.69878438e-01f, 1.18982978e-01f, -2.71817460e-03f, 1.33487418e-01f, 3.03336382e-02f,
  -4.68526296e-02f, 7.16669019e-03f, 5.17709404e-02f, 7.68168569e-02f, 1.00618713e-01f, 6.71562031e-02f, -1.45471901e-01f, 1.17509604e-01f, 1.25206932e-01f, 4.46492210e-02f,
  1.17427863e-01f, -3.62644717e-02f, 2.33069323e-02f, -3.02539654e-02f, -1.12342931e-01f, -1.13896981e-01f, -5.40651605e-02f, -1.02847256e-01f, 4.92892116e-02f, -7.91666731e-02f,
  -5.19726463e-02f, 1.19285956e-01f, -1.39869139e-01f, 9.64323133e-02f, -2.23644692e-02f, 1.16159022e-01f, -1.22519538e-01f, 3.05878744e-02f, -1.28636351e-02f, -1.02933086e-02f,
  9.04963315e-02f, -7.08052069e-02f, -1.21593058e-01f, 2.48000212e-02f, -8.49723145e-02f, -1.08545125e-01f, 3.01581975e-02f, 9.60945711e-02f, -9.77157131e-02f, -2.14438625e-02f,
  -5.02712131e-02f, 7.38999471e-02f, -2.30847485e-02f, -9.19035822e-02f, -1.00513071e-01f, 1.20239191e-01f, -1.17754981e-01f, 4.66730678e-03f, -7.92034343e-02f, -6.80111423e-02f,
  9.79186222e-02f, -1.05036199e-01f, 8.27117910e-05f, -7.39905536e-02f, 7.68419430e-02f, -1.88897420e-02f, 4.29237522e-02f, 6.14776351e-02f, -3.24413441e-02f, -7.40493312e-02f,
  -2.10102778e-02f, 5.66504560e-02f, -6.68396056e-02f, -5.35645485e-02f, -7.53242671e-02f, 3.23037840e-02f, 5.06952405e-02f, -1.03274569e-01f, 8.93882737e-02f, 3.95426787e-02f,
  8.84898826e-02f, -9.07437280e-02f, 4.42230850e-02f, -9.38055366e-02f, -5.95072173e-02f, -3.49261537e-02f, -1.00270495e-01f, -1.50964353e-02f, 9.00003389e-02f, 2.75714640e-02f,
  1.46888167e-01f, 4.73973937e-02f, 1.29140809e-01f, -1.75842211e-01f, -3.43931373e-03f, 1.22307725e-01f, 6.14642166e-02f, -1.59530267e-01f, -2.02204753e-02f, -1.38893742e-02f,
  5.13099246e-02f, 4.57060896e-02f, -7.93892667e-02f, 1.42944574e-01f, -2.24683136e-02f, 1.78532913e-01f, 5.08206058e-03f, -8.01480114e-02f, 9.21868756e-02f, -1.06843300e-02f,
  4.16934006e-02f, 2.01393649e-01f, 1.14039117e-02f, 5.57867587e-02f, -8.41144472e-02f, 1.46136491e-03f, 1.95318088e-01f, -7.34109282e-02f, -7.15552419e-02f, -6.05247132e-02f,
  1.26622811e-01f, -9.30704549e-02f, 4.94452827e-02f, -2.70897280e-02f, 7.94216320e-02f, 7.81343281e-02f, -1.09963417e-01f, 7.39022121e-02f, -6.37179837e-02f, 7.21132904e-02f,
  -1.29320081e-02f, 6.92755729e-02f, 1.88155964e-01f, -1.33571193e-01f, 1.94223389e-01f, -1.10533170e-01f, -1.25906095e-01f, 4.71661612e-02f, 3.91382203e-02f, -1.11573696e-01f,
  -3.92054804e-02f, 2.37740248e-01f, -1.20163120e-01f, -1.75491139e-01f, 3.75301875e-02f, -1.18523993e-01f, 6.27064109e-02f, -6.80597546e-03f, 1.19834065e-01f, -9.15855467e-02f,
  -3.72552387e-02f, -2.46523600e-02f, -5.34833446e-02f, 1.83585808e-01f, 5.46791181e-02f, 1.20087840e-01f, 2.41328627e-02f, -4.98644263e-02f, 1.81578323e-02f, -2.34572217e-02f,
  -1.45082012e-01f, 7.88045898e-02f, 1.14921145e-01f, 6.12530299e-02f, -3.20005715e-02f, 5.04320525e-02f, -3.65936011e-02f, 9.15132761e-02f, -2.48485152e-02f, -3.93485464e-02f,
  -3.41275125e-03f, 2.11803779e-01f, -1.98786497e-01f, 6.32110685e-02f, -1.00181080e-01f, -3.07270885e-02f, 1.39857382e-01f, 1.92985058e-01f, 7.54204243e-02f, 4.87975366e-02f,
  -5.90335429e-02f, -4.46489267e-02f, 1.10498384e-01f, 4.80919592e-02f, -7.99491704e-02f, 7.55248293e-02f, 1.11710588e-02f, -1.18877977e-01f, -5.28487451e-02f, 9.24896300e-02f,
  1.11551571e-03f, -6.74507469e-02f, 4.29102406e-03f, 1.28413960e-01f, 4.20322306e-02f, 3.66010889e-03f, 7.77971819e-02f, 1.39968842e-01f, 3.29817310e-02f, 2.98114389e-01f,
  3.14201355e-01f, 1.50114849e-01f, 6.46461695e-02f, -3.95667329e-02f, -1.72619522e-01f, -6.63712174e-02f, 2.75913298e-01f, 2.69390047e-01f, 1.39391229e-01f, 1.11449815e-01f,
  -4.51077633e-02f, 1.04966305e-01f, 1.50933161e-01f, -1.04562476e-01f, -7.56532401e-02f, 1.31333843e-01f, 1.69650421e-01f, 2.92399704e-01f, 2.92280942e-01f, 3.07547063e-01f,
  -6.12884313e-02f, -3.50227579e-02f, 2.39408717e-01f, 1.73885286e-01f, -3.52275372e-02f, -1.67814456e-02f, -6.57541752e-02f, -2.55828708e-01f, -3.24870721e-02f, -1.42709106e-01f,
  -1.55220836e-01f, 7.77158141e-03f, -3.04155461e-02f, 3.11302319e-02f, 7.36940503e-02f, 2.57193208e-01f, -3.18516642e-02f, -1.73977882e-01f, -7.07423016e-02f, -7.23332018e-02f,
  -1.03420839e-01f, 1.76902503e-01f, -6.45278990e-02f, -5.77345528e-02f, 2.38607660e-01f, 6.83095157e-02f, -7.45538529e-03f, -1.15733169e-01f, -1.51734605e-01f, 8.22747424e-02f,
  4.39964011e-02f, 4.42928635e-02f, -3.75217944e-02f, 1.35918632e-01f, 7.18132630e-02f, 1.51711270e-01f, -1.58032849e-01f, -6.11452051e-02f, 2.75176186e-02f, 1.66427478e-01f,
  6.96117803e-02f, 1.96901634e-01f, 3.15820873e-01f, 1.60573646e-01f, 2.99833089e-01f, 2.23922059e-01f, -4.93143909e-02f, -4.37579900e-02f, -1.30601227e-01f, 5.01940697e-02f,
  1.68041065e-01f, 1.22189686e-01f, 7.71557093e-02f, 4.64043804e-02f, -1.31464168e-01f, 7.07095563e-02f, 1.78575739e-01f, 3.06711011e-02f, 7.85614252e-02f, 1.02281190e-01f,
  1.03062145e-01f, -1.04696825e-01f, 4.76841070e-02f, 1.18609555e-01f, 3.88871357e-02f, -1.41171962e-01f, 1.20347496e-02f, -5.26301265e-02f, -7.59481639e-03f, 8.34587067e-02f,
  -1.82003260e-01f, -1.92668527e-01f, -1.23216949e-01f, -9.65317264e-02f, -1.25974268e-01f, 1.10778876e-01f, -1.08909244e-02f, -9.85981300e-02f, 7.04152137e-02f, 1.97597090e-02f,
  2.03557014e-02f, 7.78612122e-02f, -1.30668551e-01f, 3.39280665e-02f, 1.08194992e-01f, 9.35126096e-02f, 9.63922739e-02f, 2.08600815e-02f, 1.59497466e-02f, 3.15275113e-03f,
  4.87104431e-02f, -4.85424995e-02f, -3.70819159e-02f, -8.46445411e-02f, 1.13736063e-01f, -6.50979653e-02f, 1.14911459e-01f, -3.77953313e-02f, -1.02502026e-03f, -6.84638619e-02f,
  -1.14432603e-01f, -2.17396277e-03f, -1.34017780e-01f, -7.96994269e-02f, 9.21037793e-02f, -1.05849512e-01f, 5.60887046e-02f, -2.26871632e-02f, -2.19278019e-02f, 1.51682347e-01f,
  -1.11536711e-01f, -7.93739855e-02f, -9.79365781e-02f, 6.58317655e-02f, 1.62632130e-02f, -1.17307313e-01f, 1.03551149e-01f, -2.47927353e-04f, -7.72449076e-02f, -1.16407163e-01f,
  1.06801413e-01f, 2.00009681e-02f, 4.47212867e-02f, -4.82340995e-03f, -2.15500034e-02f, -3.46889310e-02f, 2.53858596e-01f, 1.68729663e-01f, 3.23379152e-02f, 1.41644478e-01f,
  -2.24614069e-01f, 3.03170919e-01f, 3.77147272e-02f, 1.51316822e-01f, -7.00490102e-02f, -1.80654019e-01f, -2.48400848e-02f, -2.60625733e-03f, -5.35740741e-02f, 1.25757128e-01f,
  6.10038154e-02f, 1.86161637e-01f, 2.10726619e-01f, 1.39152348e-01f, -8.80693346e-02f, 3.68610211e-02f, -7.33292894e-03f, 1.74966812e-01f, 7.22372252e-03f, 2.44466290e-02f,
  7.31852502e-02f, 9.40748975e-02f, 1.12460963e-01f, 7.62470663e-02f, 3.92548107e-02f, -1.11883759e-01f, -6.79732338e-02f, 9.47748944e-02f, 1.77216619e-01f, -1.14121735e-01f,
  -5.23905344e-02f, 8.45462754e-02f, -1.11998916e-01f, -9.10000224e-03f, -1.36231720e-01f, 4.97424342e-02f, 7.70390406e-02f, 1.10103458e-01f, 1.89471662e-01f, -5.93224168e-02f,
  3.53877246e-02f, -1.07112937e-01f, -2.58404240e-02f, 1.30264968e-01f, -1.28083915e-01f, -7.67959133e-02f, -7.69352913e-02f, 1.87984839e-01f, -5.60212247e-02f, -8.11151639e-02f,
  2.56431878e-01f, -5.12917936e-02f, -8.94264504e-02f, -1.47175282e-01f, 1.01134896e-01f, 4.42961380e-02f, -5.34527190e-02f, -9.40524787e-02f, 6.37063235e-02f, 1.83146641e-01f,
  1.42495055e-02f, 6.62288889e-02f, 1.65038090e-02f, -5.08283265e-02f, 7.75443614e-02f, 1.05917178e-01f, 4.74570915e-02f, 1.42046705e-01f, -5.08682132e-02f, -1.06492758e-01f,
  2.48681623e-02f, -9.96720791e-02f, -1.24395452e-01f, 6.42985478e-02f, 4.15820926e-02f, -1.00113548e-01f, -6.02027401e-02f, 1.28549755e-01f, 1.06006131e-01f, -6.63729981e-02f,
  6.00125035e-03f, -4.72777113e-02f, -4.98886369e-02f, 1.56442955e-01f, -1.32568125e-02f, 1.33766681e-01f, -3.23663140e-03f, -3.09964381e-02f, -4.37180400e-02f, -2.36690473e-02f,
  -1.63444176e-01f, -1.33098945e-01f, 6.23946898e-02f, 1.67523324e-01f, -1.33929342e-01f, 1.91266000e-01f, -6.31634817e-02f, 6.62923381e-02f, -3.08770183e-02f, 7.94779360e-02f,
  1.10445641e-01f, 1.97027877e-01f, 7.57255852e-02f, 5.71847074e-02f, 8.13545883e-02f, 1.51094496e-01f, 1.31847680e-01f, 5.27055040e-02f, -7.51818717e-02f, 2.68071704e-02f,
  -9.85199735e-02f, 1.08187415e-01f, 8.36869180e-02f, -7.62541816e-02f, -1.87376738e-02f, -8.40780511e-03f, 3.62929655e-03f, 5.12602963e-02f, -1.41123254e-02f, 8.42734128e-02f,
  -2.35673469e-02f, 1.19592980e-01f, -9.92380530e-02f, -2.96277236e-02f, -1.82617068e-01f, 7.24200085e-02f, 3.98843624e-02f, 1.08209893e-01f, 6.89728111e-02f, -1.50077499e-03f,
  -5.88805526e-02f, 3.92077044e-02f, 8.23707804e-02f, -2.98921880e-03f, -1.06150858e-01f, -4.14231821e-04f, -6.55507967e-02f, -5.65071814e-02f, 6.05107099e-03f, -2.78490372e-02f,
  -1.33454710e-01f, -1.89058355e-03f, 7.90737793e-02f, -1.34476656e-02f, 5.76235317e-02f, -1.32847771e-01f, -1.16068237e-01f, -5.36935069e-02f, -1.30963370e-01f, 6.03035502e-02f,
  -1.82350986e-02f, 8.57622325e-02f, 2.28451490e-01f, 3.45072970e-02f, 1.12384163e-01f, 6.84190542e-02f, 2.33163089e-02f, -9.35979560e-02f, -5.47219031e-02f, 6.44478435e-03f,
  -1.24960266e-01f, 1.05690755e-01f, -7.29086101e-02f, 8.26552138e-02f, 3.98417190e-02f, -9.84772965e-02f, -8.31961781e-02f, -5.40443771e-02f, -1.47955830e-03f, 4.90671769e-02f,
  1.14514828e-01f, 1.14017129e-01f, -1.11309458e-02f, -9.72376913e-02f, 6.70256093e-02f, 8.86379480e-02f, 1.79679859e-02f, -5.13963867e-03f, -3.00991163e-02f, 8.53615701e-02f,
  3.64950672e-02f, 8.49225447e-02f, -4.74703573e-02f, -8.44594464e-02f, -5.86613454e-02f, 3.48355845e-02f, 3.05859391e-02f, -6.05059527e-02f, 1.95486113e-01f, 8.06025863e-02f,
  -1.04598686e-01f, -3.72150689e-02f, -2.94414209e-03f, 2.00913697e-01f, 5.11104278e-02f, -1.96646377e-02f, -2.48827606e-01f, -2.35122606e-01f, 1.14158042e-01f, 8.83925892e-03f,
  -9.99276116e-02f, 1.14546128e-01f, -3.97438146e-02f, 1.62920550e-01f, 1.49766162e-01f, 2.64195842e-03f, -1.07321590e-01f, -3.57566550e-02f, -7.65377097e-03f, 1.33396804e-01f,
  -4.10569049e-02f, -9.40828249e-02f, 1.17328160e-01f, -1.29311517e-01f, 4.22482453e-02f, 4.36314149e-03f, 5.51944822e-02f, 1.81657355e-03f, -1.06335357e-02f, 3.07562053e-02f,
  -9.47228458e-04f, -2.70551816e-02f, -2.94622104e-03f, 1.51825294e-01f, 6.43034233e-03f, -3.35723981e-02f, -1.40036702e-01f, 7.94378743e-02f, 5.03842672e-03f, 4.11418527e-02f,
  1.66678920e-01f, 1.25079438e-01f, 1.85798168e-01f, -1.24814034e-01f, 4.11459431e-03f, 2.42210180e-01f, -2.78281886e-02f, 2.96548121e-02f, 3.70017476e-02f, 1.74430817e-01f,
  7.30810538e-02f, -1.46057203e-01f, 2.39271253e-01f, 1.21808909e-02f, -5.07213585e-02f, -1.24929607e-01f, 1.15570650e-01f, 3.83385569e-02f, 2.53451709e-02f, 1.86567586e-02f,
  -9.83495265e-02f, 1.25755116e-01f, 5.01974300e-03f, -2.19731685e-02f, -9.53792185e-02f, 1.70476753e-02f, -1.88224837e-02f, 4.05224506e-03f, 4.74495776e-02f, 5.14668301e-02f,
  1.51368156e-02f, -6.77859634e-02f, 7.22705200e-02f, -4.95859012e-02f, 8.52050707e-02f, -7.38611370e-02f, 7.75362551e-02f, -1.37163755e-02f, 7.26911575e-02f, 1.70437228e-02f,
  -4.72407900e-02f, -8.50418806e-02f, -4.76715490e-02f, 4.12162058e-02f, 1.20769024e-01f, 1.35069907e-01f, -7.51113705e-03f, -5.90802617e-02f, -5.19714728e-02f, 9.10884514e-02f,
  -5.30842431e-02f, -4.96906936e-02f, 5.80567680e-02f, 1.29842862e-01f, 7.23679513e-02f, 1.06694937e-01f, -8.50036889e-02f, -9.80623886e-02f, -5.56000210e-02f, -1.37579530e-01f,
  8.38826075e-02f, -1.13021404e-01f, 8.12976509e-02f, 7.49432072e-02f, -4.27413732e-02f, -1.23683615e-02f, -1.15239769e-01f, -1.73738655e-02f, 1.35670573e-01f, -7.29953945e-02f,
  -3.73088047e-02f, -9.50275436e-02f, -1.60929337e-02f, -1.11433096e-01f, 1.66274443e-01f, 1.22623727e-01f, 2.29404401e-02f, -7.49979243e-02f, 1.26142055e-01f, 1.62680801e-02f,
  1.05599267e-02f, -1.16751611e-01f, 7.20069110e-02f, 7.13872612e-02f, 8.75382125e-02f, -4.42648083e-02f, 2.00301722e-01f, 2.74266787e-02f, -3.36430594e-02f, 2.10637853e-01f,
  -2.77004719e-01f, 7.22534433e-02f, -3.51017428e-04f, 1.43195063e-01f, 7.34863281e-02f, 1.12409552e-03f, 1.24108061e-01f, 9.72694606e-02f, 1.15974851e-01f, -1.38792127e-01f,
  -6.60203323e-02f, 1.21409692e-01f, 2.20475256e-01f, -9.45154205e-02f, -1.37386352e-01f, -2.23170947e-02f, 1.44297123e-01f, 7.58272260e-02f, -3.06775514e-02f, -1.53487315e-03f,
  6.04277402e-02f, 1.13951981e-01f, 5.87796047e-02f, 1.31792381e-01f, -8.11064523e-03f, 2.04256084e-02f, -4.58041467e-02f, 5.10468322e-04f, 2.32709143e-02f, 5.27476296e-02f,
  9.59410369e-02f, 3.15384157e-02f, -2.31267065e-02f, 5.15027903e-02f, -1.02128848e-01f, 8.57970789e-02f, 5.66777959e-02f, -7.41240680e-02f, 2.74528593e-01f, -7.33315721e-02f,
  5.67257665e-02f, -1.53724164e-01f, -1.08315095e-01f, -1.95906088e-01f, 1.27150059e-01f, 1.35397092e-01f, 9.93722081e-02f, 2.57345051e-01f, -6.18869253e-02f, 7.08274841e-02f,
  1.20120816e-01f, 7.28811696e-02f, -5.56399263e-02f, -9.61908028e-02f, 1.36313632e-01f, 1.09066270e-01f, -2.94590276e-02f, -1.40121952e-01f, 1.64124802e-01f, 6.37787879e-02f,
  3.58649522e-01f, 2.95254916e-01f, 3.08228824e-02f, 1.41501129e-01f, 1.83675051e-01f, 9.47812647e-02f, -3.22044313e-01f, 5.12528419e-02f, -1.75703332e-01f, -5.30885682e-02f,
  -6.85700923e-02f, -5.29911630e-02f, 4.39301506e-02f, 2.51903348e-02f, -1.02647401e-01f, 1.19541720e-01f, -4.98442538e-02f, 1.17637254e-01f, 6.51551038e-02f, -6.48579448e-02f,
  2.82732211e-02f, -6.55246004e-02f, -8.80975574e-02f, -3.47139910e-02f, 1.34712502e-01f, 7.21125975e-02f, 1.44688897e-02f, 1.02956802e-01f, -1.14948675e-02f, -6.27253056e-02f,
  -1.55636966e-01f, 7.72514939e-02f, -5.30971698e-02f, 9.43086669e-02f, -8.48935246e-02f, 2.13520098e-02f, 9.37245861e-02f, 1.79492801e-01f, 1.49466619e-01f, -5.57038486e-02f,
  2.97620967e-02f, 3.94025631e-02f, -1.16903730e-01f, -1.54169719e-03f, 1.12834543e-01f, 4.12379473e-01f, 1.07702821e-01f, 2.54533291e-01f, -7.82587007e-02f, 8.49360526e-02f,
  1.42138034e-01f, 7.94655383e-02f, 1.28417924e-01f, 7.61346593e-02f, -5.19801341e-02f, -1.56360283e-01f, 1.98942758e-02f, 1.07904851e-01f, -8.56543258e-02f, 1.28199542e-02f,
  -1.62418615e-02f, -2.35877396e-03f, -1.59663297e-02f, -1.78514887e-02f, 7.40901604e-02f, 1.54776424e-01f, 1.84225906e-02f, -5.41664623e-02f, 3.30420993e-02f, 1.18824743e-01f,
  1.00087263e-01f, -6.02178387e-02f, -1.29418015e-01f, 3.75137702e-02f, 1.41917914e-01f, -1.22128148e-02f, -1.80346407e-02f, 3.71271148e-02f, -4.07730117e-02f, -8.89535919e-02f,
  7.31356367e-02f, 5.31116128e-02f, -3.31335030e-02f, 3.37084308e-02f, 6.15954436e-02f, 4.13502706e-03f, 1.08608335e-01f, 2.30101980e-02f, 8.73304084e-02f, 6.68470189e-02f,
  1.51199669e-01f, -9.37794670e-02f, 1.61288485e-01f, 1.04963891e-01f, -2.59100161e-02f, -1.19892307e-01f, 1.15026183e-01f, -4.39237477e-03f, -6.91669434e-02f, -3.12556922e-02f,
  -3.81346196e-02f, 4.14052494e-02f, -1.00520499e-01f, 9.38761234e-03f, -9.03425068e-02f, 6.70503005e-02f, 1.42505452e-01f, 2.85410392e-03f, 4.46593873e-02f, -7.30906054e-02f,
  4.38079946e-02f, -1.78137794e-02f, 9.35004428e-02f, -1.20598219e-01f, -5.60161769e-02f, 6.92847520e-02f, -9.46098790e-02f, -1.30354941e-01f, 5.59494346e-02f, -9.50483456e-02f,
  9.27755143e-03f, -3.27694826e-02f, -2.78096534e-02f, -6.87332526e-02f, -5.06334146e-03f, -5.79961613e-02f, 9.70023274e-02f, -1.32383853e-02f, 9.86581147e-02f, -3.24330144e-02f,
  3.13723348e-02f, -7.83837512e-02f, 1.60207212e-01f, -1.29732236e-01f, 1.24755464e-01f, 1.42299518e-01f, -1.33123264e-01f, 1.25416279e-01f, 1.49797603e-01f, 1.20546483e-01f,
  1.23510830e-01f, 1.17971025e-01f, -7.11738020e-02f, -1.22568645e-01f, -4.45407145e-02f, 5.89094758e-02f, -1.34989396e-02f, -5.64750098e-02f, 3.57251205e-02f, -4.64556962e-02f,
  -3.85760926e-02f, -3.45580950e-02f, 5.50386235e-02f, -1.00251384e-01f, 2.03949548e-02f, 1.23833008e-01f, 4.82104421e-02f, 3.85798793e-03f, -1.47585094e-01f, 8.85112491e-03f,
  -9.94281024e-02f, 7.13722333e-02f, 7.67763108e-02f, 1.10775329e-01f, -5.21682808e-03f, 1.12512052e-01f, 7.90793225e-02f, -3.17987278e-02f, -9.15872827e-02f, 7.18310848e-02f,
  9.69192982e-02f, 1.00127747e-02f, -6.56255186e-02f, 3.94035429e-02f, 4.10580635e-02f, 5.46285138e-02f, 2.73267794e-02f, -4.21973243e-02f, 6.00930899e-02f, 7.27044186e-04f,
  1.57266632e-01f, -4.27355394e-02f, 6.68653771e-02f, 3.09191793e-02f, -7.62856528e-02f, -9.64474156e-02f, 5.34630194e-02f, 4.21076939e-02f, 3.27465087e-02f, 1.00833856e-01f,
  1.28893843e-02f, 8.40337873e-02f, 8.68149325e-02f, 2.08089322e-01f, -2.28885226e-02f, 1.32338526e-02f, 2.46405587e-01f, -6.58709034e-02f, -2.67355796e-03f, -8.17804597e-03f,
  3.64769995e-02f, -6.13569561e-03f, 9.30482894e-02f, -1.21273756e-01f, -1.38584018e-01f, 1.66153774e-01f, 7.09102675e-02f, -2.38458626e-02f, -9.29834843e-02f, -8.13933536e-02f,
  1.69493854e-01f, -1.12147763e-01f, -1.32946879e-01f, -4.34060358e-02f, 4.88402061e-02f, 1.05471916e-01f, 1.09827213e-01f, -4.71298061e-02f, 8.90815631e-02f, -1.30246775e-02f,
  -1.08535655e-01f, -3.17189172e-02f, 1.34889424e-01f, -6.56650588e-02f, -1.64017528e-02f, -3.63535190e-04f, 6.78950325e-02f, 9.97334570e-02f, -1.14593402e-01f, -3.13862748e-02f,
  -1.52155995e-01f, 7.16752857e-02f, 2.96085570e-02f, 1.21347465e-01f, 9.78205130e-02f, 9.85701978e-02f, 9.85108167e-02f, 1.03613131e-01f, 5.73699102e-02f, 1.10179998e-01f,
  -4.19994779e-02f, -3.17550041e-02f, 1.56429491e-03f, 9.96584073e-02f, 1.85971916e-01f, -2.91332416e-02f, 4.64180894e-02f, 4.80406657e-02f, 3.35176326e-02f, -1.16512470e-01f,
  -1.95849407e-02f, -6.32126629e-02f, 1.31469116e-01f, 5.68199344e-02f, 1.77772660e-02f, 1.56243771e-01f, -1.44459074e-02f, 2.25132883e-01f, 1.12430319e-01f, 1.50910452e-01f,
  1.26422882e-01f, -4.86369319e-02f, -2.38077700e-01f, -2.15519905e-01f, -3.52362953e-02f, -2.08565727e-01f, 5.68969399e-02f, 3.03942692e-02f, 4.50321436e-02f, -1.09094277e-01f,
  -9.84488428e-02f, 1.07252650e-01f, -6.67577386e-02f, 9.14335847e-02f, -1.33044273e-01f, -1.49778739e-01f, -6.48867413e-02f, 4.55120914e-02f, 6.46629259e-02f, 1.56190218e-02f,
  1.07544661e-01f, 7.34157264e-02f, -2.62293629e-02f, -2.53940597e-02f, -1.41586274e-01f, -1.50073230e-01f, 3.02964859e-02f, -1.27174973e-01f, 2.84818280e-03f, -1.62706479e-01f,
  -1.16722740e-01f, 1.54786840e-01f, -6.46738037e-02f, 1.56406954e-01f, 9.18620452e-02f, 4.12834920e-02f, 1.22988865e-01f, 7.87248719e-04f, -6.68054745e-02f, -4.58097272e-02f,
  2.00045317e-01f, 1.78277135e-01f, 9.96179134e-02f, 2.96418760e-02f, -1.49011269e-01f, 7.10166991e-02f, -9.42593887e-02f, -3.47264879e-03f, -3.71512957e-02f, -1.50523819e-02f,
  -2.14092638e-02f, -7.00495811e-03f, -1.34540377e-02f, 1.13229752e-01f, 1.24210693e-01f, -1.21171676e-01f, 5.78183634e-03f, 1.57821015e-01f, 1.04348861e-01f, 5.90198161e-03f,
  1.20654322e-01f, -8.32409933e-02f, 6.33885339e-02f, -4.44906950e-02f, 1.10438503e-02f, -4.52838801e-02f, 1.52049661e-01f, 5.57962246e-02f, -4.74321917e-02f, -4.30920199e-02f,
  1.39761001e-01f, 1.05798684e-01f, -8.53240341e-02f, 1.35671854e-01f, 1.10756189e-01f, 1.18871387e-02f, -6.19181506e-02f, -1.73194055e-02f, 7.96737000e-02f, 2.76501067e-02f,
  2.62785070e-02f, 4.17198939e-03f, 1.25383705e-01f, 7.97057226e-02f, -9.24926922e-02f, 4.23584133e-02f, -1.20777600e-01f, 2.64183879e-02f, -9.66987833e-02f, 9.83751044e-02f,
  1.27743751e-01f, -1.14401132e-01f, 4.40401863e-03f, 6.91094398e-02f, -3.56016718e-02f, -2.98551004e-02f, 6.48677424e-02f, -1.26791999e-01f, -1.13285124e-01f, 8.80979076e-02f,
  1.03486918e-01f, -9.55072716e-02f, -1.18608467e-01f, 2.69352570e-02f, -1.16329052e-01f, -9.24338214e-03f, -9.50546004e-03f, 1.48900962e-02f, 1.01282068e-01f, 1.51118282e-02f,
  1.36665646e-02f, -3.50938030e-02f, 1.06443934e-01f, -1.04205079e-01f, -1.31406471e-01f, 2.85461005e-02f, 1.18304761e-02f, -7.62180910e-02f, 3.53108495e-02f, -5.63556664e-02f,
  1.33401854e-02f, -1.10635445e-01f, -8.34764466e-02f, 1.81129035e-02f, 1.14533104e-01f, 9.08181146e-02f, -1.00336976e-01f, 1.31514192e-01f, -1.19708225e-01f, 7.78931975e-02f,
  -1.19364545e-01f, 3.16675082e-02f, -3.03546735e-03f, -1.27652157e-02f, -5.59466295e-02f, 9.93250906e-02f, 1.12100288e-01f, -1.16562754e-01f, -8.95146802e-02f, 6.61212429e-02f,
  1.53406886e-02f, 3.07104718e-02f, 4.32887785e-02f, 7.69597888e-02f, 4.18460742e-02f, -5.11418134e-02f, -9.60480571e-02f, -1.33651242e-01f, -7.81900212e-02f, 1.43211961e-01f,
  -1.30501524e-01f, 6.90886006e-02f, -1.05335109e-01f, 1.31003454e-01f, 5.42230383e-02f, -8.48690048e-02f, 3.92581895e-02f, 9.49224681e-02f, -1.94774270e-02f, 5.61558232e-02f,
  1.09394133e-01f, -1.10921986e-01f, 1.07504524e-01f, -4.22254624e-03f, 7.45049790e-02f, -1.13548800e-01f, -8.75443369e-02f, -9.32994932e-02f, -3.29110934e-03f, 1.76186770e-01f,
  6.96448609e-02f, -1.34680152e-01f, 2.14958587e-03f, -9.25647691e-02f, 1.84157521e-01f, 1.32807180e-01f, 1.06065311e-02f, -1.53194033e-02f, 9.12053697e-03f, 1.07705303e-01f,
  3.07502262e-02f, -2.11975109e-02f, 8.65494609e-02f, 1.15073457e-01f, -7.96573460e-02f, 3.63168120e-02f, 2.87317317e-02f, -1.99865513e-02f, 1.65803894e-01f, 1.17044702e-01f,
  -9.74564105e-02f, 1.08841792e-01f, 9.31253210e-02f, 1.38699412e-01f, -2.78104786e-02f, -6.09040679e-03f, -1.46001652e-01f, -1.82647988e-01f, -1.23123698e-01f, 1.47492774e-02f,
  -4.95591350e-02f, -1.08100347e-01f, 1.19608335e-01f, 1.04695253e-01f, -6.84477538e-02f, 4.81744073e-02f, -8.32478330e-02f, 8.80617183e-03f, 1.29331341e-02f, 1.14063874e-01f,
  -1.18563220e-01f, 7.76908249e-02f, 8.36776569e-02f, 1.63605567e-02f, 3.52908932e-02f, -5.69625087e-02f, 7.95223117e-02f, 3.48867173e-03f, -2.40143575e-02f, -1.37020990e-01f,
  -1.27361745e-01f, -1.34830028e-01f, -9.37471241e-02f, -5.95189333e-02f, 1.17351711e-02f, 1.18118688e-01f, 3.12273223e-02f, -9.27320197e-02f, 1.52180926e-03f, 6.28429279e-02f,
  4.45361733e-02f, -1.12950295e-01f, 5.08587323e-02f, 3.00889052e-02f, 4.23341803e-02f, -4.66979900e-03f, -1.40403956e-01f, -2.67268289e-02f, -1.33989722e-01f, -4.69852872e-02f,
  4.01803851e-02f, -1.32678434e-01f, 3.68307605e-02f, -8.41124430e-02f, -1.40351340e-01f, -1.01726532e-01f, -8.06960762e-02f, 7.24862516e-02f, -4.78289798e-02f, 5.20497262e-02f,
  1.45769328e-01f, 4.01881002e-02f, 9.09843855e-03f, 1.11420803e-01f, 2.53848046e-01f, 6.84818327e-02f, -2.09536478e-01f, -1.31730422e-01f, 4.46030684e-02f, 1.81844279e-01f,
  3.01963657e-01f, 2.70468682e-01f, 1.45211920e-01f, 2.40189154e-02f, 1.53481886e-01f, -6.30189180e-02f, -1.14430832e-02f, 1.21138170e-01f, -5.95548674e-02f, -1.55299716e-02f,
  -8.75276253e-02f, 2.78826077e-02f, 1.58893153e-01f, 1.24516428e-01f, 8.18972141e-02f, 1.36325315e-01f, -6.42189011e-02f, -1.92428511e-02f, -9.38062295e-02f, 1.72815204e-01f,
  1.07278891e-01f, 2.44444627e-02f, 1.64840445e-02f, 2.49976769e-01f, -8.42235312e-02f, -8.63038599e-02f, 1.46966875e-01f, -1.11354165e-01f, 7.27065355e-02f, 6.64659403e-03f,
  1.69026684e-02f, -1.44455224e-01f, 9.66929123e-02f, -1.63683817e-01f, 1.78205758e-01f, 9.75220278e-03f, 2.82807350e-02f, 1.83265030e-01f, 1.57182068e-01f, -2.55486388e-02f,
  4.94747423e-03f, -4.46497276e-02f, 1.50466621e-01f, 1.78274453e-01f, 1.01164386e-01f, 4.22912180e-01f, 4.15573940e-02f, 1.81428254e-01f, 1.05105527e-01f, 6.04955666e-02f,
  1.04165316e-01f, -4.62623648e-02f, -1.60748407e-01f, 8.57174620e-02f, 1.23468295e-01f, 8.49832669e-02f, 8.69601890e-02f, 1.08333893e-01f, 1.06285252e-01f, -8.64561945e-02f,
  3.06736790e-02f, 2.33340207e-02f, -1.17415339e-02f, -1.55503169e-01f, -1.70406569e-02f, -1.26263052e-01f, 9.39354450e-02f, -1.18441723e-01f, -5.24962470e-02f, -1.38571728e-02f,
  1.01548858e-01f, -8.07634294e-02f, 2.09156629e-02f, 1.17045110e-02f, -1.12520866e-01f, -5.81679977e-02f, -8.81144255e-02f, -2.59545147e-02f, 1.04663484e-01f, 9.89857875e-03f,
  3.51388268e-02f, -8.04809630e-02f, 1.37719899e-01f, -9.70630813e-03f, 5.77406324e-02f, -2.47959439e-02f, -1.25281930e-01f, 2.78117321e-02f, -1.22784832e-02f, -1.09650329e-01f,
  -3.89527604e-02f, -3.46083939e-02f, -8.30737203e-02f, 1.19962178e-01f, 4.27869409e-02f, 6.83398321e-02f, -9.17725042e-02f, -5.27439825e-02f, 6.77155703e-02f, 3.66141610e-02f,
  9.74361971e-02f, -1.00483559e-01f, -7.90613964e-02f, 1.02898508e-01f, -1.41022369e-01f, 1.20979838e-01f, -1.32462144e-01f, 5.95136918e-02f, 1.72222219e-02f, -6.69391453e-02f,
  6.44210428e-02f, 7.60538876e-02f, -1.02450013e-01f, -1.16678022e-01f, 6.99150413e-02f, -2.94685699e-02f, -1.19772486e-01f, 3.40760574e-02f, 3.98742929e-02f, 6.56657293e-02f,
  -1.70122460e-02f, 1.32765532e-01f, -8.61285701e-02f, 7.54616484e-02f, 6.24376312e-02f, -1.28116533e-01f, 6.39450848e-02f, -1.25572562e-01f, 1.87240150e-02f, 8.59472752e-02f,
  -3.80177796e-02f, 1.20205641e-01f, -1.38882166e-02f, -4.91017736e-02f, 6.12229947e-03f, -1.91936456e-02f, 7.63183832e-02f, 1.40109649e-02f, -5.58080338e-02f, 1.09363727e-01f,
  8.82631168e-02f, -8.59656855e-02f, 8.72174203e-02f, -8.54062662e-02f, -5.53860962e-02f, -4.63783517e-02f, -2.59166174e-02f, 7.66133070e-02f, -4.33108695e-02f, -2.92622857e-03f,
  -1.86130926e-02f, 3.80457677e-02f, -1.25892594e-01f, 9.79355201e-02f, 8.16746131e-02f, 5.44972047e-02f, -2.16896981e-02f, -5.86378723e-02f, -9.52768475e-02f, -5.80686145e-02f,
  8.00488517e-02f, -8.76987074e-03f, -3.92318256e-02f, -5.90318069e-02f, -2.26842873e-02f, -7.88158849e-02f, 7.06564188e-02f, -1.08713567e-01f, 1.94408800e-02f, 9.42359045e-02f,
  1.18013456e-01f, -1.13617390e-01f, 8.04160908e-02f, 1.43357158e-01f, 1.19988536e-02f, -2.15053968e-02f, 1.48136571e-01f, 1.16500430e-01f, 3.61740105e-02f, -4.38043587e-02f,
  1.06515199e-01f, 7.85913914e-02f, 7.66497254e-02f, 3.04630753e-02f, 1.31404430e-01f, -9.29330289e-03f, 1.00892670e-01f, -1.28093436e-02f, 6.22943416e-02f, -2.78847292e-02f,
  -1.11730032e-01f, 6.04947731e-02f, 1.44277355e-02f, 3.39914933e-02f, -8.53113905e-02f, -6.05105646e-02f, 1.13643825e-01f, 8.03095847e-02f, 5.48593067e-02f, -7.19155893e-02f,
  -6.70514330e-02f, 9.22349617e-02f, 1.76127240e-01f, -1.31604578e-02f, -2.06115507e-02f, -5.87334149e-02f, 1.11817621e-01f, 1.08393945e-01f, -6.07577562e-02f, 1.35220006e-01f,
  2.22299024e-02f, 1.14522167e-01f, -2.07401127e-01f, -4.20139246e-02f, -1.22549884e-01f, 1.97047014e-02f, -1.01519436e-01f, 1.07067198e-01f, -3.80690917e-02f, -6.78870454e-02f,
  1.46840103e-02f, -3.79679352e-02f, 8.63782167e-02f, 9.15392563e-02f, 2.06337813e-02f, 2.23700404e-01f, -8.12586397e-02f, -1.34810239e-01f, -6.14720918e-02f, 2.00160801e-01f,
  8.05325061e-02f, 3.19498852e-02f, 4.33834977e-02f, 6.05632961e-02f, 8.18769112e-02f, 7.55502433e-02f, -5.31100631e-02f, -1.15610644e-01f, -5.91307953e-02f, -2.87851244e-02f,
  -1.21859968e-01f, 1.63560539e-01f, -1.16065770e-01f, -4.22705561e-02f, 1.63061082e-01f, 7.99239948e-02f, -1.01647884e-01f, -8.38252008e-02f, -6.89164037e-03f, -3.46175954e-02f,
  -5.76235466e-02f, -6.57891929e-02f, -6.91592619e-02f, 2.05315165e-02f, 2.61989590e-02f, -5.62745705e-02f, -1.71587113e-02f, 1.66025102e-01f, 7.63070434e-02f, 4.03731205e-02f,
  3.11696213e-02f, 4.51200362e-03f, 6.85935989e-02f, -2.48292903e-03f, -1.17422260e-01f, -1.01255495e-02f, -8.04878995e-02f, 1.07298829e-01f, 7.81682432e-02f, 9.00417566e-02f,
  5.53293191e-02f, -1.13322079e-01f, -4.34893556e-02f, 2.06516427e-03f, 1.64219271e-02f, -5.42528592e-02f, 4.69603278e-02f, -1.09295063e-02f, -4.87909168e-02f, 3.02309752e-03f,
  -5.81681877e-02f, -1.22624665e-01f, -8.92574564e-02f, -7.22678453e-02f, 8.48531537e-03f, 2.67937668e-02f, 7.25532845e-02f, 9.84939188e-02f, 8.50406438e-02f, 6.03457093e-02f,
  5.35212681e-02f, 4.44517396e-02f, -7.56029412e-02f, -3.53441499e-02f, -8.57921243e-02f, -3.01766824e-02f, -5.22680841e-02f, -4.71918285e-02f, -1.07480146e-01f, 6.17964379e-02f,
  -3.97687452e-03f, 2.90419906e-02f, -3.76441851e-02f, -1.45625779e-02f, 4.31936681e-02f, -1.14121698e-01f, -1.22064285e-01f, 7.95599669e-02f, 1.03523143e-01f, -4.15812396e-02f,
  1.19686693e-01f, 1.05529316e-01f, 2.08831251e-01f, 1.48360794e-02f, 1.90756559e-01f, -5.33804223e-02f, -1.49482399e-01f, 1.53160706e-01f, 2.84508429e-02f, -1.03692129e-01f,
  -7.59342760e-02f, 3.15280780e-02f, 1.04859024e-02f, 5.84473833e-02f, 2.37503201e-02f, 1.34681076e-01f, 3.47316340e-02f, 7.56937414e-02f, 2.16830432e-01f, 1.45875096e-01f,
  -7.06755519e-02f, 3.53608392e-02f, -1.49279414e-02f, 1.56964213e-01f, -1.13921560e-01f, 2.63761170e-02f, -1.18543711e-02f, 2.47950535e-02f, 8.98699686e-02f, -4.62626778e-02f,
  6.45365044e-02f, -9.44202021e-02f, -1.04819104e-01f, -8.73577371e-02f, -5.91009893e-02f, -5.22493012e-02f, 8.25777054e-02f, 8.05508792e-02f, -4.05882522e-02f, -5.28827012e-02f,
  4.50451486e-03f, 1.03294194e-01f, 9.03874785e-02f, 1.47664594e-02f, 2.04508007e-01f, 1.27179340e-01f, -1.43833105e-02f, -1.10655703e-01f, 7.45433569e-02f, 4.46486697e-02f,
  4.40089740e-02f, 5.87270334e-02f, -1.08114757e-01f, 1.65577635e-01f, 1.08409718e-01f, 4.92804237e-02f, 1.39029473e-01f, -3.91802229e-02f, 5.54599613e-02f, 9.05941427e-02f,
  1.76864922e-01f, 1.84823871e-02f, 5.84928542e-02f, -1.11772992e-01f, 1.25438377e-01f, 6.38567135e-02f, 1.48643618e-02f, 1.48881292e-02f, 1.67504176e-02f, 7.72562623e-02f,
  1.10571362e-01f, 7.41672367e-02f, 9.63334590e-02f, -5.16508222e-02f, 1.16738610e-01f, -6.56532720e-02f, -9.82387140e-02f, -9.31208059e-02f, 5.00098765e-02f, -1.63946617e-02f,
  -1.18961096e-01f, -1.45790037e-02f, 4.82869372e-02f, 3.76875326e-02f, -7.28863552e-02f, 5.61557803e-03f, -7.76193067e-02f, 1.37091264e-01f, -3.79059650e-02f, 1.89557020e-02f,
  -5.13788611e-02f, -9.76722538e-02f, -3.08368281e-02f, 6.49339333e-02f, -5.02270684e-02f, -3.00651025e-02f, 9.82101411e-02f, -2.44684760e-02f, 5.30001428e-03f, -9.31582078e-02f,
  1.29478663e-01f, 2.75679231e-02f, -6.16620146e-02f, 1.08379364e-01f, -7.22845495e-02f, 3.25472932e-03f, 1.25940636e-01f, -7.29494542e-02f, -7.08384365e-02f, 1.01309232e-01f,
  1.73720226e-01f, -2.69875280e-03f, -1.60534218e-01f, -1.30364820e-02f, 6.34348392e-02f, 1.68669671e-01f, 1.10700861e-01f, 1.85345143e-01f, -1.31062537e-01f, 4.11896035e-02f,
  -6.13188893e-02f, 8.43016751e-05f, 1.30948111e-01f, 1.14514545e-01f, 9.80308503e-02f, -8.71683955e-02f, 8.92288983e-02f, -3.53115313e-02f, 1.59604903e-02f, -1.17708728e-01f,
  -6.58762008e-02f, -5.81003912e-03f, -1.82706378e-02f, -1.19083323e-01f, -2.60929726e-02f, 9.17917937e-02f, 1.77002326e-01f, 2.29735747e-02f, 1.19607762e-01f, -1.10393748e-01f,
  1.48274839e-01f, -4.45724232e-03f, -6.78914040e-02f, -2.69038044e-02f, 8.18130597e-02f, 1.55275241e-01f, 1.44418806e-01f, 1.90978218e-02f, 4.24373783e-02f, -9.94285643e-02f,
  8.27903748e-02f, 6.24072887e-02f, -6.52890876e-02f, -8.05966333e-02f, 1.29713818e-01f, -7.71220848e-02f, -4.51241769e-02f, -3.51444036e-02f, 1.00238442e-01f, 9.44343582e-02f,
  8.61943811e-02f, 9.63216573e-02f, 1.00983955e-01f, 5.94371371e-02f, -6.26257285e-02f, 1.29602402e-01f, 1.76751018e-02f, 2.29160339e-02f, 1.56561546e-02f, -3.77071686e-02f,
  -9.61352926e-05f, 1.00563258e-01f, 1.24010310e-01f, 1.24594033e-01f, -1.19216755e-01f, -1.10076696e-01f, 9.39994752e-02f, -1.02819964e-01f, -1.23241059e-01f, 5.55824265e-02f,
  -6.88004717e-02f, -5.49419560e-02f, -7.71506801e-02f, 6.93650544e-02f, 2.13917464e-01f, 6.64973632e-02f, 1.05849497e-01f, -8.99976492e-02f, -2.03495566e-02f, 8.73972476e-02f,
  -5.82779869e-02f, -1.06129684e-01f, 1.43694028e-01f, 4.59132344e-02f, 8.26991070e-03f, 2.87246890e-02f, -9.89032239e-02f, 6.96498528e-02f, 2.17709795e-01f, 7.25600645e-02f,
  -4.47322093e-02f, -1.22748680e-01f, -9.19879600e-02f, -8.22138414e-02f, -1.84591301e-02f, 1.03705354e-01f, -3.37909833e-02f, -5.17519824e-02f, -2.65231207e-02f, 2.07408369e-01f,
  2.17847168e-01f, 1.20541163e-01f, 1.37501672e-01f, -2.64528729e-02f, 1.28413901e-01f, 7.23886192e-02f, 9.00488570e-02f, 8.29108804e-02f, -8.07338953e-02f, 9.56384116e-04f,
  1.04262330e-01f, 4.00845148e-02f, 7.40499496e-02f, -6.42333701e-02f, -1.39904276e-01f, -7.63705447e-02f, -5.87419271e-02f, 7.26055801e-02f, -7.20786378e-02f, 9.12832916e-02f,
  -6.40329951e-03f, 1.64103564e-02f, -2.25803759e-02f, 1.19229302e-01f, -5.60403289e-03f, 9.65448655e-03f, -3.42451483e-02f, -7.05397725e-02f, 2.52555460e-01f, -9.45751891e-02f,
  4.76567782e-02f, 1.93211604e-02f, -1.52853891e-01f, -6.52332827e-02f, -1.46680862e-01f, 2.10298657e-01f, 3.37198898e-02f, -5.21403551e-02f, 1.24508344e-01f, -1.12051733e-01f,
  -1.36082113e-01f, 3.16647836e-03f, 8.00452530e-02f, -7.73393065e-02f, -8.18898752e-02f, 1.19854555e-01f, -1.23239920e-01f, 6.99700415e-02f, 8.54153559e-02f, 8.76721963e-02f,
  -4.92314473e-02f, -8.91939700e-02f, 8.16694424e-02f, -9.74885225e-02f, -1.18041672e-01f, 7.29984641e-02f, -1.11871236e-03f, -1.61357537e-01f, -4.70833033e-02f, -1.15535066e-01f,
  -1.14841849e-01f, -1.01429202e-01f, 2.76452601e-02f, -2.98612956e-02f, 1.06186233e-02f, -8.75072256e-02f, -9.39837843e-02f, -9.21131447e-02f, 3.32183130e-02f, -4.68990058e-02f,
  -2.13197675e-02f, -4.44804132e-02f, 3.66400070e-02f, 1.14200497e-02f, 8.54229927e-02f, 5.06065600e-02f, -3.34608853e-02f, 7.73865357e-02f, 6.32619858e-03f, 8.01624358e-02f,
  -7.07576498e-02f, 4.50729094e-02f, 6.43728226e-02f, 8.29076320e-02f, 2.89454423e-02f, -4.34614345e-02f, -1.12452075e-01f, 8.11232179e-02f, -5.63602187e-02f, 1.32778110e-02f,
  1.65736210e-02f, 3.41049843e-02f, 3.65676545e-02f, -1.40419841e-01f, -8.11608322e-03f, 2.68005654e-02f, -7.37246275e-02f, 1.04322247e-01f, 7.73238577e-03f, -1.16596200e-01f,
  -5.99936284e-02f, -1.24042451e-01f, -5.10961376e-02f, -1.31273568e-01f, -1.10128276e-01f, 9.05006975e-02f, 5.72949760e-02f, 8.40813592e-02f, -1.21009365e-01f, 1.13514751e-01f,
  1.06754959e-01f, -8.27689692e-02f, 2.38056052e-02f, 1.38283551e-01f, 3.84665914e-02f, -5.39661311e-02f, -1.44367933e-01f, -7.47036785e-02f, -1.62457332e-01f, 5.96665591e-02f,
  1.41883492e-01f, 1.31402194e-01f, -1.28132910e-01f, 7.03605711e-02f, 1.05501115e-01f, -3.98746766e-02f, 5.48589639e-02f, -9.63369161e-02f, 1.24972910e-01f, 1.17974326e-01f,
  -9.92280915e-02f, -1.93682294e-02f, -8.27368796e-02f, 3.95075493e-02f, 7.90111199e-02f, 3.03680878e-02f, -2.78735776e-02f, -4.08064686e-02f, -3.34446528e-03f, 2.65503619e-02f,
  1.36073738e-01f, 5.33157997e-02f, -1.03949137e-01f, 1.96079567e-01f, -3.63359302e-02f, -4.03041802e-02f, 1.36761903e-03f, -4.26090974e-03f, -1.72827970e-02f, 9.97352153e-02f,
  -3.64318043e-02f, -6.62810579e-02f, 6.44064918e-02f, 9.71759018e-03f, 1.63348079e-01f, 4.08509038e-02f, -1.32659106e-02f, 6.43881708e-02f, 1.18326783e-01f, -1.73908770e-02f,
  4.07871716e-02f, -1.88091211e-02f, 1.18058167e-01f, -6.78301379e-02f, 1.51562998e-02f, 9.42738950e-02f, 1.28043517e-01f, -8.90741199e-02f, 1.01532482e-01f, -1.09327594e-02f,
  -1.68585498e-02f, -3.52481194e-02f, -4.86320332e-02f, -8.69892016e-02f, -1.24539901e-02f, 1.78377986e-01f, 5.37661351e-02f, 7.40217417e-02f, -5.50234318e-02f, -5.81861548e-02f,
  2.18363360e-01f, 1.02484189e-02f, 1.17912397e-01f, -7.91445822e-02f, 1.82900671e-02f, -2.20725879e-01f, -7.87587017e-02f, -3.14613944e-03f, -1.45114332e-01f, 1.74228087e-01f,
  -4.60666530e-02f, 1.11621236e-02f, 9.41955596e-02f, 1.63477566e-02f, 8.13837498e-02f, -6.17740117e-02f, 5.30586345e-03f, 9.33309197e-02f, -5.03383912e-02f, -1.58630889e-02f,
  1.10257208e-01f, -7.73999393e-02f, 1.97859504e-03f, 4.66615446e-02f, -1.94390118e-01f, 1.30291685e-01f, -7.50705674e-02f, -1.94207728e-02f, 2.24392880e-02f, 1.28893420e-01f,
  8.58305544e-02f, 1.94948450e-01f, -7.12158019e-03f, -7.13456646e-02f, -6.00037649e-02f, -1.54590188e-02f, 8.41665491e-02f, 1.93804935e-01f, 1.34645611e-01f, 3.46304476e-02f,
  1.66282579e-01f, 4.86320397e-03f, 9.71433073e-02f, 9.18529108e-02f, 1.12014756e-01f, 5.43021001e-02f, -3.18443105e-02f, 1.02463938e-01f, 1.54722273e-01f, -4.17729095e-02f,
  1.29447132e-01f, 3.04748062e-02f, -2.69945655e-02f, 8.80842283e-02f, 1.06441587e-01f, 4.70762812e-02f, 1.39698073e-01f, 1.39145121e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -3.33899632e-02f, 1.88150570e-01f, 3.44715603e-02f, -9.17624012e-02f, 2.58912802e-01f, 9.99906845e-03f, 1.83939338e-01f, -2.07603388e-02f, 8.83444399e-02f, 3.20339590e-01f,
  1.33067310e-01f, 2.06640422e-01f, 7.74605870e-02f, 1.34340376e-01f, 4.66831326e-02f, -2.57005822e-02f, 1.79241635e-02f, 6.84228987e-02f, -4.41446677e-02f, 2.33462378e-02f,
  1.03055499e-01f, -7.49163032e-02f, 3.72586325e-02f, 3.31576634e-03f, 2.18719468e-01f, -6.26969635e-02f, 2.20253870e-01f, 2.64824070e-02f, -9.16862562e-02f, 1.51372761e-01f,
  -9.39471796e-02f, 1.50488406e-01f, 1.99541152e-01f, -3.58953327e-02f, -1.74086168e-02f, 9.14715007e-02f, 2.48613134e-01f, -1.35979634e-02f, -5.23703732e-02f, -1.50685590e-02f,
  1.24915347e-01f, -2.18136162e-02f, 5.11871651e-03f, 1.38750136e-01f, 6.95858076e-02f, 1.44840196e-01f, 1.98086604e-01f, 3.03714480e-02f, 8.29975158e-02f, -6.29512519e-02f,
  -7.01137185e-02f, 9.43617076e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.38659492e-01f, -3.85031588e-02f, 3.76553684e-02f, 1.61737233e-01f, 8.59072357e-02f, 8.53403956e-02f, 2.31989667e-01f, -2.50038594e-01f, 1.56920657e-01f, 5.34829497e-02f,
  -1.93854973e-01f, -1.61107387e-02f, -2.68984586e-02f, 3.97673286e-02f, -9.53089297e-02f, 3.89894694e-02f, 2.59878695e-01f, 9.08387601e-02f, -5.95622212e-02f, 7.78878294e-03f,
  -1.37203589e-01f, -2.16721892e-01f, 2.32218459e-01f, -3.94512787e-02f, -2.76639797e-02f, 8.59359186e-03f, -3.65474671e-02f, 3.54621699e-03f, -2.16488056e-02f, -1.12210214e-01f,
  -4.75200899e-02f, 2.32761241e-02f, 8.55212957e-02f, 1.08364694e-01f, 5.12882508e-02f, 1.46720439e-01f, 1.68233663e-01f, 5.07393926e-02f, -1.03691392e-01f, 1.01131871e-01f,
  -3.60196345e-02f, -9.23940390e-02f, 1.17914766e-01f, -1.75146028e-01f, 1.52156681e-01f, 8.88575837e-02f, 2.46395357e-02f, 1.09524205e-01f, 1.04500391e-01f, -7.15504959e-03f,
  -5.12699448e-02f, 2.45528892e-02f, 8.71585533e-02f, -1.30806282e-01f, -5.37223890e-02f, 6.95907250e-02f, 1.20572299e-02f, -5.62846288e-02f, 1.26113445e-01f, -1.32407501e-01f,
  -1.07295424e-01f, -7.19834268e-02f, 8.59762505e-02f, -3.37059014e-02f, 1.33273061e-02f, -7.49190003e-02f, 9.72745642e-02f, -4.72191945e-02f, -9.17648822e-02f, 1.08075999e-01f,
  1.69232920e-01f, -1.94521807e-02f, -1.47859558e-01f, -1.26817688e-01f, -2.19583750e-01f, 8.23084489e-02f, 1.22741926e-02f, -3.33692096e-02f, 6.55786097e-02f, 1.26902670e-01f,
  -2.00177938e-01f, -1.27558410e-01f, -5.44682890e-02f, -9.92527828e-02f, 1.29759550e-01f, -1.08826710e-02f, -2.27583945e-01f, 1.25227109e-01f, -1.29973114e-01f, 7.69724101e-02f,
  -1.20946810e-01f, -2.21021920e-02f, -9.74607170e-02f, 6.20994121e-02f, 1.09273180e-01f, -1.38056904e-01f, 6.66915700e-02f, -1.03303604e-01f, 7.43596256e-02f, -2.28777066e-01f,
  -1.66420653e-01f, 7.49273896e-02f, -1.29293054e-01f, -9.03754830e-02f, 1.18133649e-01f, -5.57904616e-02f, 8.89144465e-02f, -1.68141518e-02f, -2.30838120e-01f, 3.56051885e-02f,
  1.11159705e-01f, 1.48073912e-01f, -2.15470861e-03f, 6.34261668e-02f, -1.25866011e-01f, 5.84586710e-02f, -2.07054004e-01f, -3.44863124e-02f, -6.77543506e-02f, 3.37004140e-02f,
  1.23709463e-01f, -6.85815793e-03f, 4.40741628e-02f, 1.72815964e-01f, -1.77850313e-02f, 1.63041186e-02f, -7.86109343e-02f, 1.72892660e-02f, 6.24376610e-02f, 5.60688693e-03f,
  5.45321926e-02f, 1.85187832e-01f, 3.17842737e-02f, 6.97798282e-02f, 2.45433450e-01f, -3.78750116e-02f, 7.10362345e-02f, 1.53067455e-01f, 1.11608677e-01f, -9.32361409e-02f,
  -5.69929555e-02f, -5.94676360e-02f, 8.43972713e-02f, -1.46164089e-01f, -7.18426481e-02f, -8.25089738e-02f, -1.61731038e-02f, 1.01109082e-02f, -1.64293107e-02f, -6.37938753e-02f,
  3.11000645e-02f, -1.06229104e-01f, 6.48150146e-02f, 1.24925502e-01f, -7.56799877e-02f, -4.90197130e-02f, -1.87124521e-01f, 1.02381436e-02f, 6.39808103e-02f, -7.32194781e-02f,
  1.28380954e-02f, 4.77332585e-02f, -1.28175914e-01f, 5.26386360e-03f, 1.55289352e-01f, -6.46168292e-02f, -7.78499153e-03f, 7.33280974e-03f, -2.67483834e-02f, 1.89401079e-02f,
  -1.42979831e-01f, -1.42792836e-01f, 5.45613617e-02f, 1.07668489e-01f, 2.04535257e-02f, 3.87380570e-02f, 1.78159893e-01f, 1.13125324e-01f, 8.51655304e-02f, 4.41780426e-02f,
  -1.88017741e-01f, 8.58849138e-02f, -6.15504272e-02f, 9.98234004e-02f, 4.36684769e-03f, -1.42541707e-01f, -7.30049983e-02f, -1.96762547e-01f, 8.61105546e-02f, -6.80872649e-02f,
  -2.99728326e-02f, -8.72163102e-02f, -7.84984324e-03f, 1.48677707e-01f, 2.83362772e-02f, 2.89918721e-01f, 5.64115122e-03f, 4.48110588e-02f, 3.10605973e-01f, -4.93316017e-02f,
  -7.21553043e-02f, 8.02236646e-02f, -1.32430524e-01f, -2.89186370e-02f, 8.12444612e-02f, -2.44335681e-02f, 1.10862479e-01f, -5.68508394e-02f, 9.70900357e-02f, 4.46436033e-02f,
  -4.76124324e-02f, 8.86988118e-02f, -3.84309925e-02f, -2.04012185e-01f, -6.35048300e-02f, 1.65749818e-01f, 3.88319865e-02f, 3.64613393e-03f, 1.67860910e-01f, -1.71742216e-01f,
  4.38035578e-02f, -7.27563426e-02f, -1.72113776e-02f, -2.56931148e-02f, 1.44690245e-01f, -3.34784240e-02f, -1.28951639e-01f, 1.13710398e-02f, 3.47155482e-02f, -2.02872068e-01f,
  -2.48729885e-01f, -7.36294836e-02f, 1.69685446e-02f, -1.96479604e-01f, 7.97572955e-02f, -1.10074654e-01f, -2.63082087e-01f, 6.35781735e-02f, -4.70216684e-02f, -1.11846561e-02f,
  6.14035949e-02f, 1.14366189e-01f, -1.20357521e-01f, -5.76855950e-02f, 2.18674213e-01f, 8.37043971e-02f, 8.14388096e-02f, -1.95490077e-01f, -8.04669559e-02f, -9.35184583e-03f,
  1.03825286e-01f, -5.39403260e-02f, -1.03288442e-01f, 3.30812261e-02f, 1.77743137e-02f, 6.79720640e-02f, 6.54348359e-02f, -1.50374249e-02f, -1.37528002e-01f, -9.90314931e-02f,
  -4.84050028e-02f, 1.03192836e-01f, 1.59659281e-01f, -1.57217711e-01f, -1.79010518e-02f, 1.76585019e-01f, 1.12510569e-01f, -1.00479662e-01f, -3.16923112e-02f, -1.21432878e-01f,
  -1.50880832e-02f, 2.83077778e-03f, 2.39456087e-01f, -3.55989486e-02f, -4.97365594e-02f, 1.34798773e-02f, 6.42002299e-02f, -2.79022098e-01f, 2.30891362e-01f, -1.71885774e-01f,
  -8.33335370e-02f, 3.31564806e-03f, 1.13438040e-01f, -2.74827555e-02f, 7.13708624e-02f, -7.19904900e-02f, 9.25209522e-02f, -1.18391931e-01f, -6.54584020e-02f, -4.14953269e-02f,
  -1.39243618e-01f, -1.16932811e-02f, 1.37723476e-01f, 6.56910688e-02f, -9.80538130e-02f, 1.70818388e-01f, 5.27614467e-02f, 9.32733491e-02f, 9.43013132e-02f, -2.10694835e-01f,
  2.86079496e-01f, 8.66024420e-02f, 2.30449084e-02f, -1.15780085e-02f, -9.18290988e-02f, -1.17816880e-01f, -1.60050113e-02f, 1.91187591e-03f, -1.30065216e-03f, -9.26688835e-02f,
  -1.02224126e-01f, 8.45538825e-02f, -7.59611353e-02f, 6.63468316e-02f, -1.35614618e-03f, 1.66500881e-02f, 1.38846129e-01f, -4.04471830e-02f, -5.55660925e-04f, 6.13935012e-03f,
  1.73995525e-01f, 1.40487283e-01f, 2.57504880e-01f, 2.93394744e-01f, 1.28963456e-01f, 1.91776320e-01f, 1.64776430e-01f, -3.51082414e-01f, -7.37982839e-02f, 1.13859758e-01f,
  -8.96450952e-02f, 7.21883625e-02f, -5.49688041e-02f, 2.66813099e-01f, -5.85654452e-02f, -4.25143801e-02f, 5.19221053e-02f, 1.24780778e-02f, -3.26517760e-03f, -2.88299732e-02f,
  1.14103340e-01f, 6.20650090e-02f, 1.06179111e-01f, 1.14561468e-01f, -3.38310405e-04f, 7.40701109e-02f, 1.69624284e-01f, -1.30188152e-01f, -7.26776272e-02f, 4.29468118e-02f,
  4.65123430e-02f, 1.92892849e-01f, 1.69364512e-01f, -6.95887730e-02f, 6.59623044e-03f, -7.52439797e-02f, -2.71516383e-01f, -5.07542267e-02f, -1.80891752e-01f, -1.81131124e-01f,
  -3.13030258e-02f, -2.65057594e-01f, 2.00003572e-02f, -3.66674457e-03f, -1.30171537e-01f, -1.94491640e-01f, -8.00806507e-02f, 3.39828879e-02f, -1.89135484e-02f, -9.67319310e-02f,
  -8.51594135e-02f, -2.05212040e-03f, 6.19539507e-02f, 9.25881136e-03f, 1.46672487e-01f, -7.73256496e-02f, 1.10347725e-01f, -2.88695619e-02f, -4.63276505e-02f, -1.75651193e-01f,
  -1.06673755e-01f, -7.07507208e-02f, -7.95763358e-02f, -9.51084644e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -3.73848155e-02f, -4.31660526e-02f, -1.10146895e-01f, 8.14046040e-02f, -4.83220220e-02f, -9.65625048e-03f, 5.47232851e-02f, -8.83448124e-02f, 5.37762139e-03f, 1.03901275e-01f,
  1.90496352e-02f, -7.45283589e-02f, 5.80135128e-03f, -1.57123234e-03f, -7.75121525e-02f, 1.11358583e-01f, -4.03430425e-02f, 1.77232120e-02f, 1.26005203e-01f, 4.63249274e-02f,
  -1.27746880e-01f, -1.20664015e-01f, 1.14261270e-01f, -5.87947406e-02f, 1.80021152e-02f, 4.83295508e-02f, 4.00828719e-02f, -8.15754607e-02f, 1.12974465e-01f, 7.69883469e-02f,
  -9.67494622e-02f, -1.55208278e-02f, 4.36996631e-02f, -1.19744770e-01f, 7.38949254e-02f, 2.96143000e-03f, -3.47398873e-03f, 4.00875658e-02f, -6.07348569e-02f, -7.68614188e-02f,
  -9.64180392e-04f, 4.91688885e-02f, 7.68054798e-02f, 6.03491850e-02f, 1.22087814e-01f, -2.77850609e-02f, -5.82286902e-02f, -8.41007680e-02f, 9.80551615e-02f, 3.43942293e-03f,
  -8.75885561e-02f, -5.19015640e-02f, 2.99684741e-02f, 1.07936598e-01f, -1.20827287e-01f, 1.19498722e-01f, -3.52470353e-02f, -8.90347660e-02f, 8.85834247e-02f, 6.34388551e-02f,
  3.67992111e-02f, 6.07017539e-02f, 6.12182468e-02f, 8.21059868e-02f, 1.36724889e-01f, 8.84533897e-02f, 1.26665786e-01f, 1.21912345e-01f, 1.57623649e-01f, 1.88459054e-01f,
  7.74782598e-02f, 6.67125806e-02f, 6.85763359e-02f, 3.56580014e-03f, 1.72786221e-01f, -8.25230181e-02f, -2.63231508e-02f, -6.70412406e-02f, -4.79624979e-02f, 1.10721089e-01f,
  5.18678315e-03f, -1.64629728e-01f, 5.49252369e-02f, -5.62418550e-02f, -1.10219434e-01f, 7.77740031e-02f, 6.40259311e-02f, -1.24500938e-01f, 3.93469520e-02f, -2.73618172e-03f,
  -9.93342549e-02f, -4.50694710e-02f, -9.94451717e-03f, -6.47214577e-02f, 6.34997804e-03f, -9.58919618e-03f, -6.40660003e-02f, -7.86932185e-02f, 3.43477279e-02f, 1.43979993e-02f,
  1.44812211e-01f, -5.68011217e-02f, 1.94314048e-01f, 1.37237996e-01f, -1.19187325e-01f, 2.05615714e-01f, -6.21797219e-02f, -5.12399152e-02f, 5.18205725e-02f, 8.81155655e-02f,
  6.64795265e-02f, 1.61229428e-02f, 2.10717618e-01f, -5.29113524e-02f, -7.84803405e-02f, 1.32237971e-01f, -1.85407892e-01f, 1.93856686e-01f, 3.40460762e-02f, -1.95963532e-02f,
  -1.83163304e-02f, -1.50783351e-02f, 1.06472507e-01f, 3.20530646e-02f, -6.25130208e-03f, 6.90642744e-02f, -8.83874446e-02f, 1.37355417e-01f, 6.95888698e-02f, -6.86102137e-02f,
  9.40184668e-02f, -8.31053257e-02f, -5.85423633e-02f, 5.33310249e-02f, 1.10284761e-01f, -2.05402113e-02f, -1.42421061e-02f, -1.05629861e-01f, 7.90398046e-02f, 9.32087526e-02f,
  -4.15269025e-02f, 4.75246236e-02f, 7.61689693e-02f, -8.60200152e-02f, -6.92388192e-02f, 4.14305441e-02f, -3.12280376e-02f, 9.03165564e-02f, 7.50719905e-02f, 2.05723364e-02f,
  -1.19169310e-01f, -1.26939580e-01f, 6.13648482e-02f, 1.05158605e-01f, 9.44397449e-02f, -2.06375699e-02f, -1.25813931e-01f, 1.21288270e-01f, -8.45330358e-02f, -9.08540115e-02f,
  -7.45543316e-02f, -8.07254165e-02f, -1.01392426e-01f, -9.08698887e-02f, -2.56184116e-02f, 6.72206730e-02f, -4.10763249e-02f, 4.52775359e-02f, -1.07253522e-01f, 1.27520934e-01f,
  -1.68083068e-02f, 1.02520421e-01f, 8.82290825e-02f, -1.05726063e-01f, -8.85157064e-02f, -6.96833134e-02f, 1.18662575e-02f, 1.13762608e-02f, 3.81438024e-02f, -6.05150424e-02f,
  -1.20548487e-01f, 5.86749576e-02f, 6.77945092e-02f, 8.84375572e-02f, -5.00092953e-02f, -3.76838408e-02f, 9.36054215e-02f, -9.95311663e-02f, -1.16683496e-02f, 3.73567902e-02f,
  -3.59111726e-02f, 1.25362605e-01f, 3.75907347e-02f, 1.40211046e-01f, 4.07294706e-02f, 1.00614466e-01f, -4.18552868e-02f, 9.04858559e-02f, 7.48135149e-02f, -2.02381704e-02f,
  -9.21231508e-02f, -3.24164033e-02f, -1.88835204e-01f, -2.05018651e-03f, -1.07643448e-01f, -2.51788497e-02f, -7.03084618e-02f, 9.51116011e-02f, -1.31994514e-02f, 3.48294154e-02f,
  -8.75584409e-02f, 7.91755468e-02f, -4.28240970e-02f, -8.25648606e-02f, 1.25638749e-02f, -4.21153344e-02f, 7.46864313e-03f, 4.13446054e-02f, -4.16305251e-02f, 9.86767486e-02f,
  -7.51695037e-02f, -5.80070764e-02f, 8.58296305e-02f, -1.03073709e-01f, 2.29281299e-02f, -4.31703106e-02f, -3.38324159e-02f, 4.02390286e-02f, 9.93710235e-02f, -7.46384263e-02f,
  1.65382319e-03f, -7.86302090e-02f, -5.39588369e-03f, -7.80006126e-02f, -1.02652414e-02f, 6.43549338e-02f, -8.37662667e-02f, 1.71647388e-02f, 1.23616256e-01f, 1.21132463e-01f,
  -6.09648861e-02f, 1.28296003e-01f, 3.87979411e-02f, -6.63058758e-02f, -3.15157883e-02f, 3.15101109e-02f, 6.14070185e-02f, 3.00436169e-02f, 5.28813787e-02f, -2.82870699e-02f,
  -6.23273291e-02f, 4.68431488e-02f, -8.74238089e-02f, 6.90547228e-02f, -6.14257343e-02f, 1.03382595e-01f, 2.36530259e-01f, 2.45813489e-01f, 1.43085778e-01f, 1.65493414e-01f,
  1.65319219e-01f, 4.06800173e-02f, 1.15056492e-01f, -8.39130878e-02f, -1.80465281e-01f, -1.06107846e-01f, -3.82650234e-02f, 3.31587076e-01f, -6.89444095e-02f, 1.29727170e-01f,
  3.33578438e-02f, 6.01886734e-02f, -3.38647538e-03f, 2.17006654e-02f, -7.01075420e-02f, -1.03785701e-01f, 1.76130399e-01f, 3.47038329e-01f, 1.45242751e-01f, 1.92227900e-01f,
  -1.10128827e-01f, 7.71481246e-02f, -3.22097801e-02f, 6.27668723e-02f, -1.38992727e-01f, 1.11110702e-01f, -4.48587835e-02f, 2.30823487e-01f, 2.09170487e-02f, -6.02077916e-02f,
  -9.51080173e-02f, -8.16614181e-02f, -1.56747922e-01f, -1.05565459e-01f, -4.89404760e-02f, 1.00762129e-01f, 1.09260559e-01f, 4.91587743e-02f, -8.43019634e-02f, 1.05021365e-01f,
  -1.07406080e-01f, 6.03523059e-03f, 1.40020609e-01f, 5.88494055e-02f, 6.42175134e-03f, 1.56153083e-01f, 1.03615515e-01f, -1.50533468e-01f, 1.16562903e-01f, -7.32784495e-02f,
  -4.52242978e-02f, 1.43855426e-03f, 2.95678899e-02f, -8.52680802e-02f, 4.97923493e-02f, -6.61095381e-02f, -8.15116242e-02f, -1.19269907e-01f, -1.09108858e-01f, -1.07538350e-01f,
  -3.55546921e-02f, -2.90999655e-02f, 1.97114516e-02f, 1.77458692e-02f, -4.85052392e-02f, 4.11677212e-02f, -4.61840630e-02f, -1.67678028e-01f, -6.54545650e-02f, 8.46422166e-02f,
  7.84841254e-02f, 5.50822206e-02f, -1.03001639e-01f, 1.40634226e-02f, -5.00296615e-02f, -6.63938820e-02f, -1.89215057e-02f, -1.21466793e-01f, -1.13793835e-01f, -1.01802938e-01f,
  -1.76451523e-02f, -1.95562746e-02f, 2.71367848e-01f, -1.17193706e-01f, 9.42062661e-02f, 1.40929982e-01f, 1.20779373e-01f, 1.17930584e-01f, -1.35444432e-01f, -1.06598116e-01f,
  6.77228570e-02f, 1.34223938e-01f, -1.24658212e-01f, -2.06944123e-02f, 2.06797421e-02f, 6.40199035e-02f, 1.35859787e-01f, -5.68384416e-02f, 9.71101969e-02f, -8.41422379e-02f,
  1.43302344e-02f, -1.37865171e-01f, -1.29333109e-01f, -1.09946772e-01f, 1.65981621e-01f, -7.56470934e-02f, -5.60542308e-02f, -3.69315743e-02f, -1.18269123e-01f, -6.67535886e-03f,
  1.04526341e-01f, -7.05475286e-02f, -3.43929529e-02f, 1.14253424e-02f, 1.41634233e-02f, 1.85793743e-01f, -4.29617725e-02f, -1.09321289e-01f, -7.19585940e-02f, -6.45056814e-02f,
  7.23048300e-02f, -4.18309309e-02f, -7.94589072e-02f, 4.74730060e-02f, 2.65895963e-01f, 4.30509262e-02f, 7.66600147e-02f, -7.54316803e-04f, 8.21013749e-02f, 2.56332725e-01f,
  1.55780300e-01f, -3.28313373e-02f, -1.41109927e-02f, 1.23711623e-01f, -4.78661060e-02f, 2.08500940e-02f, -1.06185205e-01f, -8.18537697e-02f, 8.68593305e-02f, -7.53078833e-02f,
  3.20325419e-02f, 1.05051966e-02f, 6.59167692e-02f, -1.18450671e-01f, 3.99763621e-02f, 1.18725874e-01f, 1.32264167e-01f, -3.47541012e-02f, 7.74159236e-03f, 1.89121485e-01f,
  5.97398393e-02f, -2.05328502e-02f, -1.93971813e-01f, 2.97668818e-02f, -1.07469805e-01f, 6.29654229e-02f, -1.10902630e-01f, -1.36710733e-01f, 2.21833680e-02f, -1.14092924e-01f,
  1.04562402e-01f, -6.66356459e-02f, 1.13412773e-03f, 1.04230426e-01f, -1.29119396e-01f, 3.48993018e-02f, 8.76297578e-02f, 1.41166031e-01f, 1.96932301e-01f, -2.32349313e-03f,
  3.84932421e-02f, 2.21487377e-02f, 1.65665254e-01f, 5.91834784e-02f, 7.14000091e-02f, -3.93578410e-02f, 5.48355244e-02f, -7.10705295e-02f, -4.35666479e-02f, 1.33075818e-01f,
  -1.46994144e-01f, 1.26887634e-01f, 1.24272190e-01f, -1.34412661e-01f, 9.21724737e-02f, -1.11086018e-01f, -8.67143646e-02f, 1.34529829e-01f, 1.63482413e-01f, -8.92577171e-02f,
  1.97812453e-01f, 1.19858803e-02f, 1.78083196e-01f, 6.13110811e-02f, 1.85986534e-01f, -1.81611568e-01f, -1.17262051e-01f, 2.20406100e-01f, -1.45782858e-01f, 1.17615446e-01f,
  -1.56359851e-01f, -2.86888182e-02f, -7.19318679e-03f, -7.09453225e-02f, 1.74378261e-01f, -1.78550668e-02f, -8.73752534e-02f, -7.05311224e-02f, -3.27661410e-02f, -1.52755678e-02f,
  1.09152369e-01f, -3.91030423e-02f, -4.05299506e-04f, 8.21024925e-02f, 9.02267396e-02f, 5.61874695e-02f, -1.52791619e-01f, 5.98087497e-02f, -4.35502157e-02f, -6.85923472e-02f,
  -6.57427609e-02f, -6.80857077e-02f, 4.28521000e-02f, -1.13481604e-01f, -1.13662116e-01f, 6.12762347e-02f, -1.21377848e-01f, 8.47753510e-03f, 4.11084853e-02f, -1.16934411e-01f,
  -3.94543773e-03f, -1.42951056e-01f, 2.05122843e-01f, -1.41340077e-01f, 1.17681935e-01f, 8.45651254e-02f, 1.59762159e-01f, -4.23987135e-02f, 4.80049700e-02f, 1.21256724e-01f,
  1.27449572e-01f, 6.68527186e-02f, -2.87461821e-02f, 1.79336354e-01f, -9.52291191e-02f, 1.77916493e-02f, 2.80012488e-02f, 4.74531129e-02f, -1.18369281e-01f, -7.37812594e-02f,
  8.72637555e-02f, 2.16773176e-03f, 7.71691427e-02f, 5.11390008e-02f, 1.63552418e-01f, -7.07677472e-03f, 1.46799430e-01f, -8.99423435e-02f, 1.34804904e-01f, -5.23747504e-02f,
  -7.43975937e-02f, 6.36612400e-02f, 1.96088143e-02f, 8.25300142e-02f, -2.97229434e-03f, 1.21562235e-01f, 1.09370753e-01f, 1.18571296e-01f, -5.44745103e-02f, 1.91050898e-02f,
  1.65817320e-01f, -4.50451449e-02f, 1.73338801e-02f, -7.79440776e-02f, -1.19172610e-01f, 8.78169835e-02f, 1.61622092e-02f, 2.31919587e-02f, -9.76008549e-02f, -1.07113026e-01f,
  -6.47325665e-02f, -2.12654900e-02f, 2.32648989e-03f, 2.81944592e-02f, -4.37106984e-03f, 6.31039888e-02f, 1.35996610e-01f, -2.99896151e-02f, 1.32744431e-01f, 1.62565745e-02f,
  4.48545255e-02f, -1.77196544e-02f, -8.70441720e-02f, 7.87618235e-02f, 4.18720581e-02f, 4.03595529e-03f, -1.20410919e-02f, -5.89220524e-02f, -1.00585539e-03f, 6.06960431e-02f,
  4.38955091e-02f, 7.16814697e-02f, -3.01255882e-02f, 1.22429013e-01f, -1.31883651e-01f, 1.38411775e-01f, 6.30854368e-02f, -7.30252191e-02f, -2.90097184e-02f, -6.00112341e-02f,
  1.20253600e-01f, 4.06348743e-02f, 2.30553523e-02f, 8.92937407e-02f, 4.39625867e-02f, -8.57963227e-03f, 1.30242622e-02f, -2.51472741e-02f, -3.25364934e-04f, -6.85899407e-02f,
  -5.43977506e-02f, 2.29491144e-02f, -1.07789867e-01f, 4.64558564e-02f, 6.53146803e-02f, 2.38629933e-02f, 5.21253832e-02f, 1.16032317e-01f, 3.72196436e-02f, 3.55101153e-02f,
  -1.06242202e-01f, -2.10392801e-03f, 3.85207012e-02f, 7.14834780e-03f, 1.05861925e-01f, 1.71800412e-03f, 9.96363163e-02f, 2.41972566e-01f, -2.64005847e-02f, -1.54974665e-02f,
  3.67456004e-02f, -6.22216314e-02f, -9.55053046e-02f, 1.33205697e-01f, -9.83606931e-03f, 1.65214136e-01f, 8.37323144e-02f, 1.12584226e-01f, 5.28301671e-02f, -6.85516000e-02f,
  1.05467990e-01f, 8.16168487e-02f, -1.04531370e-01f, -2.09079832e-02f, 2.61877310e-02f, 1.15514304e-02f, -4.41994332e-02f, -1.35046849e-02f, -3.79189849e-02f, 6.39541745e-02f,
  4.41920795e-02f, 3.96966003e-02f, 3.07843369e-02f, -1.33666500e-01f, -6.58684671e-02f, 1.01378709e-01f, 6.54440895e-02f, -1.01254106e-01f, 9.26475152e-02f, -6.43970296e-02f,
  3.85385193e-02f, 2.28001494e-02f, 3.50699350e-02f, 8.38436484e-02f, -1.00493260e-01f, 6.18381426e-02f, 2.90631242e-02f, -1.29816800e-01f, -6.45606667e-02f, 3.29850093e-02f,
  1.13530401e-02f, 8.59713927e-02f, -5.51730432e-02f, 2.00505495e-01f, 1.79377735e-01f, 1.31758302e-01f, 3.97426076e-02f, 1.47575557e-01f, -1.63557440e-01f, -8.38818550e-02f,
  -2.04257518e-01f, 3.38390991e-02f, 7.73414224e-02f, 7.61355683e-02f, 5.51483668e-02f, -2.78909020e-02f, -6.54949471e-02f, 2.21407562e-01f, 1.65064007e-01f, 8.04787204e-02f,
  8.78523663e-02f, 1.35503605e-01f, 8.16392750e-02f, 2.09841847e-01f, -1.60065964e-01f, -2.84238514e-02f, -6.60543442e-02f, 4.78351079e-02f, 1.45603910e-01f, 1.92938000e-01f,
  1.34963328e-02f, 3.35903391e-02f, 1.23834752e-01f, -7.99788907e-02f, 1.58732072e-01f, 2.25739986e-01f, 2.04771444e-01f, 1.57311499e-01f, 1.05666809e-01f, 9.54874307e-02f,
  -1.24874569e-01f, 1.05088383e-01f, 1.11542284e-01f, 8.63960460e-02f, -1.35578662e-01f, 1.69525817e-01f, 6.24026731e-02f, 1.23231076e-01f, -7.23147020e-02f, 1.32493436e-01f,
  2.58514043e-02f, -3.57454680e-02f, 2.37460092e-01f, 8.92453827e-03f, 9.13297012e-02f, -3.12463269e-02f, -6.19247369e-02f, 2.07373470e-01f, -5.24869598e-02f, 1.05400175e-01f,
  -2.02034861e-02f, -2.75939740e-02f, -8.96004066e-02f, 4.47892733e-02f, -8.37774426e-02f, 8.21880847e-02f, 6.46837950e-02f, -1.23501949e-01f, -1.01556495e-01f, 1.24186046e-01f,
  3.31012793e-02f, 6.31211028e-02f, 8.86246189e-03f, -1.37415882e-02f, -5.75920157e-02f, 3.46308574e-02f, -5.28534688e-03f, -1.56476468e-01f, -1.03667192e-01f, -2.09536031e-02f,
  5.87960426e-03f, 4.87819351e-02f, 1.40050605e-01f, 1.35161495e-03f, -2.27741003e-02f, -9.87056494e-02f, -7.34762475e-02f, -7.76210800e-02f, -1.40808187e-02f, -8.50976408e-02f,
  -7.89615065e-02f, -1.81811694e-02f, 3.92991938e-02f, 2.72242408e-02f, -8.18636119e-02f, 1.05990982e-02f, -8.67792070e-02f, 3.32008786e-02f, 1.08534686e-01f, -5.13274111e-02f,
  1.98085383e-01f, -7.07715377e-02f, 7.47963414e-02f, -7.35690296e-02f, 3.91321518e-02f, 4.71819332e-03f, 1.03892088e-02f, -1.23812295e-01f, -1.00821406e-01f, -2.41934359e-02f,
  1.17895462e-01f, -1.52508067e-02f, 9.48742107e-02f, 7.92058110e-02f, -1.21792130e-01f, -6.51816875e-02f, -1.95957776e-02f, -9.79582779e-03f, -1.08305089e-01f, 1.05408289e-01f,
  8.14596191e-02f, 1.01329610e-01f, 6.31618723e-02f, -4.82247174e-02f, 7.31642842e-02f, -6.41767830e-02f, 2.67846324e-02f, 6.72078282e-02f, -5.66477999e-02f, 6.69213831e-02f,
  -1.24010667e-01f, 3.35144438e-02f, -5.38763441e-02f, -9.67328101e-02f, -8.23391415e-03f, -1.06664687e-01f, 3.83899771e-02f, 7.21432194e-02f, 1.24845050e-01f, -4.66846824e-02f,
  -1.31888036e-02f, -8.37573130e-03f, -6.24006428e-02f, -5.32778539e-02f, 6.01589531e-02f, 6.71792924e-02f, 3.47092710e-02f, -1.01226993e-01f, 7.17826337e-02f, 3.34925838e-02f,
  6.17757589e-02f, 2.77496018e-02f, 4.22529057e-02f, -6.87035322e-02f, -4.00140807e-02f, -6.47301599e-02f, 1.02025948e-01f, -7.68450573e-02f, -3.08277644e-03f, 1.43674821e-01f,
  -1.08023740e-01f, -4.36027758e-02f, 7.13726357e-02f, 1.77482411e-01f, 6.89762384e-02f, 8.58061761e-02f, 5.47824148e-03f, 3.60463522e-02f, 1.17996968e-01f, 1.25396356e-01f,
  6.81420043e-02f, -1.11454204e-02f, -5.86576003e-04f, 7.36062303e-02f, 1.04506738e-01f, 5.13619222e-02f, -5.60026802e-02f, -1.21948384e-01f, -8.01849291e-02f, -7.97891617e-02f,
  -4.66663837e-02f, -6.19922671e-03f, 1.04554124e-01f, -4.89846198e-03f, 9.15685743e-02f, -9.98803601e-02f, 7.94945657e-03f, 4.76831309e-02f, 9.76697281e-02f, 7.86119923e-02f,
  1.05978779e-01f, 1.29121412e-02f, 1.16302527e-01f, 7.35096410e-02f, -4.66003083e-02f, -4.30715177e-03f, 5.19355908e-02f, 7.53245577e-02f, -9.54156592e-02f, -9.59731452e-03f,
  -3.06062605e-02f, -1.13594485e-02f, 7.00226128e-02f, -7.40660951e-02f, 5.10845967e-02f, 4.31679375e-02f, -7.34207407e-02f, -7.26952106e-02f, 1.30259886e-01f, 1.76528424e-01f,
  1.06029242e-01f, -8.86350349e-02f, -5.61278164e-02f, -2.26229634e-02f, -9.45603475e-03f, 1.82044268e-01f, -7.47348666e-02f, -1.19404264e-01f, 1.07408315e-01f, -4.94638011e-02f,
  1.44749582e-01f, -4.98790964e-02f, -1.25542015e-01f, 7.31330663e-02f, 1.09673396e-01f, 1.03668503e-01f, -1.07211247e-01f, 1.91075444e-01f, -1.11137494e-01f, -4.33149710e-02f,
  6.59409910e-02f, -1.20720632e-01f, -9.63968690e-03f, -6.65593669e-02f, 8.59143436e-02f, -1.19996946e-02f, -1.41972220e-02f, -4.29148488e-02f, -3.24044712e-02f, 3.60580310e-02f,
  -7.75759369e-02f, 3.71787213e-02f, -6.05750121e-02f, -1.22521371e-01f, 2.30408721e-02f, 1.20469615e-01f, 1.55574894e-02f, 3.48718278e-02f, 9.19535831e-02f, 1.38692841e-01f,
  -2.62688808e-02f, -5.23516238e-02f, 4.86118831e-02f, 4.12512682e-02f, 1.43849790e-01f, -1.14374101e-01f, 4.74391505e-02f, -4.37590629e-02f, 5.40940911e-02f, 1.25553682e-01f,
  2.04500370e-02f, -8.15049261e-02f, 1.01967826e-01f, -1.46538243e-01f, 8.72120634e-02f, 6.41502365e-02f, -1.01053845e-02f, -4.82424488e-03f, 1.98298357e-02f, -7.22498670e-02f,
  -7.99738318e-02f, -1.08697303e-01f, -2.67636701e-02f, 1.27149343e-01f, 2.04662308e-02f, 3.18932384e-02f, 4.42938805e-02f, -2.64867321e-02f, 1.44733936e-01f, 6.14817552e-02f,
  8.94123316e-03f, 5.50176166e-02f, -5.65075316e-02f, 7.38612935e-02f, 2.55988576e-02f, 9.06517729e-02f, -2.80686375e-02f, 1.01565421e-01f, 3.10089868e-02f, 6.63004741e-02f,
  -4.50700000e-02f, 1.53909087e-01f, 3.08219846e-02f, -1.45138511e-02f, 1.23864878e-02f, 3.41011025e-02f, -6.67793825e-02f, -1.16057470e-01f, 1.20934792e-01f, 1.49771541e-01f,
  1.38193041e-01f, -8.56693015e-02f, -7.55748674e-02f, -3.25769745e-02f, -1.98805630e-02f, 1.18741707e-03f, 8.68497565e-02f, -5.37390783e-02f, 2.04909712e-01f, -1.67749170e-02f,
  2.90454701e-02f, 7.64827728e-02f, 1.07756466e-01f, 8.96949228e-03f, 1.12558551e-01f, -6.01378568e-02f, 1.10502914e-01f, 7.94536173e-02f, 1.41603693e-01f, -8.36887732e-02f,
  1.16710499e-01f, 7.72681087e-02f, -5.54114534e-03f, 4.88072000e-02f, 4.28578584e-03f, -5.74159902e-04f, 8.51681754e-02f, -5.69170490e-02f, -3.39089669e-02f, 9.91267562e-02f,
  4.72778976e-02f, 2.46198736e-02f, -1.84150208e-02f, 1.14040457e-01f, -2.20243428e-02f, 1.22394944e-02f, -1.09833470e-02f, -1.23066433e-01f, 4.66334410e-02f, -1.01801448e-01f,
  4.07270752e-02f, -4.31488901e-02f, 2.09887996e-02f, -7.96327889e-02f, 1.51248891e-02f, -1.21951969e-02f, -1.01207979e-01f, 4.24349215e-03f, 8.89112279e-02f, 1.33949682e-01f,
  -2.43465081e-02f, 7.29151145e-02f, -1.05921328e-01f, 1.03631452e-01f, -2.45291200e-02f, 1.79603845e-02f, -1.27870858e-01f, -7.03466013e-02f, -7.11591244e-02f, 8.63015503e-02f,
  8.55145603e-02f, -6.93494529e-02f, -1.18903974e-02f, 1.31102756e-01f, -4.37239148e-02f, -1.15153305e-02f, -1.19477190e-01f, 9.53597948e-02f, -7.12651908e-02f, -3.69713344e-02f,
  -9.42095742e-02f, 2.59462092e-02f, -4.87952270e-02f, -3.43194120e-02f, -4.97402251e-02f, -7.18050674e-02f, -5.86025082e-02f, 5.70733547e-02f, 1.41208485e-01f, 7.96634480e-02f,
  1.07640363e-01f, 1.05404750e-01f, 8.85041580e-02f, 1.07445233e-01f, 3.08246966e-02f, 6.94389120e-02f, 1.22612193e-01f, -1.12720653e-01f, -4.37973663e-02f, 1.81972355e-01f,
  5.08195534e-02f, 1.13940522e-01f, 1.73312083e-01f, -8.06104019e-02f, 2.09668688e-02f, -1.78992033e-01f, 1.36408970e-01f, -1.65890649e-01f, 1.29951492e-01f, -1.27151832e-01f,
  9.46341231e-02f, -1.98893026e-02f, 1.84334926e-02f, -1.11029409e-01f, 4.66772914e-03f, 2.54655592e-02f, -1.07751176e-01f, 5.93094379e-02f, 9.40110721e-03f, 5.03140502e-04f,
  -9.62555185e-02f, 6.94309324e-02f, -7.68204778e-02f, -1.02687046e-01f, 9.02065784e-02f, 4.87283058e-02f, 9.02800113e-02f, 6.32444397e-02f, 2.26385985e-02f, 1.57915697e-01f,
  5.17381318e-02f, 1.76586136e-01f, 1.65740535e-01f, 8.16287193e-03f, -3.77521589e-02f, 1.90937832e-01f, 8.76307264e-02f, -8.97732973e-02f, 7.86385834e-02f, 2.82071903e-02f,
  -2.98621804e-02f, -3.53069231e-02f, 8.53737909e-03f, 4.69924025e-02f, -1.64321773e-02f, 1.71909615e-01f, 2.15263534e-02f, 7.85227716e-02f, -9.56369638e-02f, -1.19923458e-01f,
  -1.25434464e-02f, 2.08591476e-01f, -9.73312557e-02f, 1.29433021e-01f, 1.31676078e-01f, 8.00295845e-02f, -8.08978155e-02f, -2.64885239e-02f, -5.20182289e-02f, -3.21286432e-02f,
  -5.09557538e-02f, 2.11706311e-02f, 1.44202681e-02f, 1.50782660e-01f, 1.65801316e-01f, -8.52733552e-02f, -1.16968386e-01f, 1.72970459e-01f, -1.38945386e-01f, -9.37484726e-02f,
  -6.49778917e-02f, 1.53904408e-01f, -7.57658854e-02f, -2.57478543e-02f, 8.96035582e-02f, -3.06275375e-02f, -1.19483516e-01f, 4.60663699e-02f, -1.03276029e-01f, 5.88804074e-02f,
  1.09550215e-01f, 4.17317972e-02f, 1.03549071e-01f, 5.51818572e-02f, 1.05702259e-01f, 4.40676324e-02f, -9.55708846e-02f, -4.93321121e-02f, 8.98631588e-02f, 1.97478896e-03f,
  6.88563138e-02f, 5.98151907e-02f, 1.25911683e-02f, -9.25289765e-02f, -7.12934928e-03f, 9.48537737e-02f, -1.07009590e-01f, 5.22428751e-02f, -3.33481905e-04f, -2.78503820e-02f,
  -6.90899491e-02f, -1.09602354e-01f, -8.45600739e-02f, -2.70852465e-02f, -7.75016891e-03f, -3.32988123e-03f, -1.98079217e-02f, -1.60663780e-02f, -1.13439023e-01f, -9.02752951e-02f,
  2.30599195e-02f, -2.07265969e-02f, 1.36371151e-01f, -1.29102126e-01f, -2.02849135e-02f, -7.33764693e-02f, 1.00543946e-01f, 6.05080500e-02f, 9.50722620e-02f, -5.55627346e-02f,
  4.53938581e-02f, 3.37497368e-02f, 7.59045631e-02f, -4.63689640e-02f, -9.41522047e-02f, 5.96186109e-02f, 7.88705125e-02f, 1.05675675e-01f, 9.18373540e-02f, -2.52418872e-02f,
  -1.53680667e-01f, 3.22855404e-03f, -7.86974356e-02f, 1.01632603e-01f, 4.52122837e-02f, -7.09395185e-02f, 2.77534984e-02f, 9.50232521e-02f, 1.44147515e-01f, 1.04289331e-01f,
  -1.37399107e-01f, -1.86847057e-02f, 2.75642122e-03f, -7.05468580e-02f, 4.93110716e-03f, 6.68354239e-03f, 7.59855881e-02f, 4.19440977e-02f, 1.21349126e-01f, 1.97685510e-02f,
  1.37264952e-02f, 1.05199978e-01f, -4.91292998e-02f, -4.49798517e-02f, -7.94079825e-02f, 5.14442399e-02f, -4.54253070e-02f, -1.13190047e-01f, -7.70973116e-02f, -3.55724506e-02f,
  -1.00045130e-01f, -1.16103254e-01f, -1.53545607e-02f, -4.59169149e-02f, 7.80381039e-02f, 1.49003342e-01f, 4.57174815e-02f, -4.28469330e-02f, 1.11577272e-01f, 3.41029875e-02f,
  2.38472503e-03f, 9.89769213e-03f, 4.09080237e-02f, -1.20654084e-01f, 1.87483117e-01f, 7.20686987e-02f, 2.48103216e-02f, -1.19914189e-01f, 3.62666659e-02f, -1.20096192e-01f,
  -5.08012958e-02f, 4.73132357e-02f, -4.89155911e-02f, -1.11914068e-01f, 1.20690934e-01f, -1.04708903e-01f, 1.02477141e-01f, 3.36747169e-02f, 5.37670702e-02f, 1.80191144e-01f,
  1.50446147e-01f, 3.50638032e-02f, 8.21779221e-02f, -2.05481246e-01f, -2.97979191e-02f, 1.24517888e-01f, 1.49576411e-01f, -1.02651641e-01f, -6.61847964e-02f, -7.01570436e-02f,
  7.10204020e-02f, -2.96679176e-02f, 2.92335302e-01f, 1.25210151e-01f, 5.38324937e-02f, 9.51127484e-02f, -1.41249113e-02f, -1.59375086e-01f, 2.31712088e-01f, 5.52090369e-02f,
  1.22806214e-01f, -1.04452245e-01f, 1.27425328e-01f, -4.13185553e-05f, 1.71175018e-01f, 9.15823653e-02f, -1.27248630e-01f, 1.90507069e-01f, 2.09026739e-01f, -1.17152125e-01f,
  8.70530773e-03f, 2.42633551e-01f, 2.14762673e-01f, -1.22895069e-01f, -1.62486300e-01f, 3.30826007e-02f, -5.95737100e-02f, -9.82264280e-02f, 1.38358355e-01f, 8.15031305e-02f,
  1.28015772e-01f, -1.38522446e-01f, -1.40418736e-02f, 1.51306078e-01f, 1.38455838e-01f, -3.10392422e-03f, 7.95431063e-02f, -5.83092012e-02f, 2.44714096e-01f, -6.80483580e-02f,
  -2.30664350e-02f, 1.25915632e-01f, -4.92121018e-02f, 9.75287259e-02f, 4.28080559e-02f, -4.73870747e-02f, -5.88899339e-03f, -9.75205079e-02f, 1.48302212e-01f, -9.74454954e-02f,
  -1.40992701e-01f, -1.20965198e-01f, 4.62706573e-02f, -4.49529327e-02f, -4.36758325e-02f, -3.49091738e-02f, -6.15319870e-02f, 4.52121794e-02f, 9.38010514e-02f, 3.72822285e-02f,
  -6.54986277e-02f, 1.15812093e-01f, 8.83414596e-02f, -3.88365164e-02f, 7.96269700e-02f, -4.28161360e-02f, 7.76943639e-02f, -2.80093146e-03f, 3.01982611e-02f, 6.54964447e-02f,
  3.62916081e-03f, 7.59653300e-02f, 4.86455485e-02f, 5.89442551e-02f, -1.71692818e-02f, 3.40020657e-02f, -1.65664610e-02f, -4.91154082e-02f, 1.31662982e-02f, 4.76661660e-02f,
  -5.31001016e-02f, 2.40325630e-02f, -7.84494132e-02f, -7.75915012e-02f, 3.64274047e-02f, 1.04490541e-01f, 1.02210380e-01f, 8.57130066e-02f, 1.91539973e-02f, 8.44219178e-02f,
  1.23189278e-01f, -3.15626338e-02f, -6.80718124e-02f, 8.40520486e-02f, 3.70363407e-02f, -6.40019551e-02f, 1.15666345e-01f, -1.04873236e-02f, -4.65297289e-02f, -3.44145559e-02f,
  -3.60456705e-02f, -5.90994395e-02f, -1.15382457e-02f, -3.60095836e-02f, 3.63612622e-02f, -2.66010631e-02f, 4.08436060e-02f, -4.61897850e-02f, -1.18136920e-01f, 4.19922024e-02f,
  -2.05931719e-02f, 8.38898718e-02f, 7.32770786e-02f, 6.31343722e-02f, 6.46782219e-02f, 6.51257634e-02f, 1.64057836e-01f, 3.55787091e-02f, 3.82370315e-02f, 1.89290181e-01f,
  -8.11808631e-02f, 3.72946173e-01f, 1.40760168e-01f, -2.75947899e-01f, 2.32253447e-01f, 7.90356323e-02f, -4.33479995e-02f, -5.72691448e-02f, -6.20650463e-02f, -1.08380891e-01f,
  -1.99442711e-02f, -8.58843774e-02f, 1.06409006e-02f, -3.51025886e-03f, -4.74115796e-02f, 3.04644138e-01f, -2.07645163e-01f, -7.46715665e-02f, -1.26522526e-01f, -1.54065669e-01f,
  -1.09733410e-01f, 1.26222998e-01f, 3.26612219e-02f, 2.30940074e-01f, 1.11827351e-01f, -4.92155887e-02f, -8.43571872e-02f, 1.66109297e-02f, 3.36428098e-02f, 5.89383580e-02f,
  2.34807819e-01f, 2.55380142e-02f, 2.41534039e-01f, 8.52503777e-02f, -1.32949539e-02f, 1.06633447e-01f, -5.33868857e-02f, 1.87874034e-01f, 8.17008987e-02f, 1.07269578e-01f,
  1.95647888e-02f, 6.91418871e-02f, -1.43143162e-02f, -9.36305523e-02f, -5.18211387e-02f, 1.28594324e-01f, -5.29938862e-02f, 7.12622553e-02f, -1.09714955e-01f, -1.21577933e-01f,
  1.00031748e-01f, 2.09703818e-01f, 1.11433089e-01f, -2.91544236e-02f, 6.59767445e-03f, 1.10748224e-01f, 9.52943638e-02f, 2.02270839e-02f, 6.79593384e-02f, -4.73002791e-02f,
  1.21261336e-01f, -1.67367622e-01f, -1.33603916e-01f, -8.67094547e-02f, -9.15617719e-02f, 2.21857533e-01f, 2.08133042e-01f, -1.22175813e-01f, 1.82082057e-01f, -1.00192823e-01f,
  1.23227395e-01f, -1.35724649e-01f, -6.02031313e-02f, 2.84924675e-02f, -9.30802822e-02f, -7.16452599e-02f, 1.34817297e-02f, -9.62988809e-02f, -1.14448909e-02f, -3.95530388e-02f,
  2.74862293e-02f, 1.04865544e-01f, 7.93219358e-02f, -1.37240097e-01f, -6.87425882e-02f, 1.32503331e-01f, 9.26345065e-02f, -8.10844004e-02f, 3.30604911e-02f, -5.20496964e-02f,
  9.78836045e-02f, 3.21627334e-02f, -7.59139955e-02f, -8.12785104e-02f, 1.34794474e-01f, 1.08761929e-01f, 2.69634295e-02f, 1.43168494e-01f, -2.15376099e-03f, 1.26373604e-01f,
  -1.32992014e-01f, 1.31267607e-01f, 2.08842248e-01f, 1.34143054e-01f, 1.06179066e-01f, -1.27358437e-01f, 3.00655724e-04f, 2.34433562e-02f, -1.05322644e-01f, 1.41147971e-01f,
  -2.88459826e-02f, 7.52996430e-02f, 6.67214766e-02f, 5.85022122e-02f, 1.14237696e-01f, 5.38286865e-02f, -2.93994434e-02f, -1.59171596e-02f, -3.59278806e-02f, -8.95272195e-02f,
  9.67207402e-02f, -1.15107104e-01f, 3.92870605e-02f, 1.44031435e-01f, 1.32241204e-01f, -7.13752359e-02f, -9.15258843e-03f, -2.97022592e-02f, 9.90964100e-02f, 8.80745277e-02f,
  -4.41673845e-02f, 1.33359149e-01f, 1.61601469e-01f, -1.49940670e-01f, 3.53809521e-02f, 3.38764749e-02f, -7.42702112e-02f, -5.85676394e-02f, 2.30983585e-01f, -1.63792409e-02f,
  1.09161235e-01f, -9.90639478e-02f, -8.13337937e-02f, -1.19358242e-01f, 1.35445163e-01f, -3.05020586e-02f, -2.37050764e-02f, 1.85165182e-02f, 1.54642358e-01f, -7.26952180e-02f,
  8.81277397e-02f, 1.07010916e-01f, 8.48952979e-02f, -1.97217036e-02f, 1.83441773e-01f, 3.74053344e-02f, 9.27776769e-02f, 1.08027421e-01f, -5.19917905e-02f, 7.33463317e-02f,
  -1.36958566e-02f, 7.39033222e-02f, -7.32385218e-02f, -3.05769476e-03f, -7.60357082e-02f, 1.24967590e-01f, 1.83303300e-02f, -1.22453883e-01f, -5.17374873e-02f, -7.51104057e-02f,
  1.53577104e-01f, -1.07015617e-01f, -6.32573068e-02f, -3.64355110e-02f, 9.39035118e-02f, 6.98625073e-02f, -5.27640432e-02f, -6.39177039e-02f, -1.32371604e-01f, 9.47311074e-02f,
  1.22503623e-01f, -1.18169613e-01f, 9.97137576e-02f, -5.94366975e-02f, 1.06903702e-01f, -1.22990161e-01f, -5.32903895e-02f, -7.78022036e-02f, 1.55973196e-01f, -3.96782495e-02f,
  1.76232383e-01f, 1.53765276e-01f, 2.12467328e-01f, -8.98853838e-02f, 1.82859138e-01f, 2.06430271e-01f, 6.63946196e-02f, -1.51981026e-01f, 5.60954958e-02f, -1.43010452e-01f,
  1.01748928e-01f, -1.02804095e-01f, 2.71067396e-02f, 1.29733801e-01f, 8.39450657e-02f, -7.14414520e-03f, 3.90802994e-02f, -6.64198846e-02f, 1.02934383e-01f, -1.26854964e-02f,
  -4.45156917e-02f, 1.30985931e-01f, -5.58128692e-02f, -3.36377397e-02f, -9.24310312e-02f, -1.71651378e-01f, -1.03892922e-01f, 5.15991785e-02f, -3.98269743e-02f, -1.17121331e-01f,
  4.89581153e-02f, 6.24313690e-02f, 9.54273865e-02f, 6.42989576e-02f, 5.09995222e-02f, 1.19634122e-01f, -1.17897764e-01f, 1.51659977e-02f, 3.85932042e-03f, -1.04070500e-01f,
  1.36550441e-01f, -1.65027771e-02f, 1.20632790e-01f, 1.25147149e-01f, 4.48140129e-02f, 9.85925868e-02f, 2.48831399e-02f, 8.45911503e-02f, -1.37071028e-01f, 3.65930609e-02f,
  5.41011393e-02f, 1.81437045e-01f, 8.59642029e-02f, 1.04150191e-01f, -7.60121122e-02f, -3.34633216e-02f, -6.53349757e-02f, -1.45297889e-02f, -3.33986245e-02f, 1.05327904e-01f,
  2.12501436e-01f, 1.53011605e-01f, 1.01035953e-01f, 1.51722580e-01f, 2.42247462e-01f, 1.74287051e-01f, 8.00613165e-02f, 5.58170900e-02f, 1.58078447e-01f, 1.36039779e-01f,
  1.17632791e-01f, -1.20636664e-01f, 9.54592377e-02f, -4.88805957e-02f, -3.76601368e-02f, -1.34152293e-01f, 2.47999862e-01f, 1.25374898e-01f, -1.71973947e-02f, -1.04067892e-01f,
  1.57902092e-02f, 4.49621603e-02f, 1.63843915e-01f, -7.58877471e-02f, -3.53935920e-02f, -5.20499349e-02f, -1.01396807e-01f, -2.35667243e-03f, -2.35831775e-02f, -9.92765576e-02f,
  1.43923685e-02f, 1.97070651e-02f, 1.11151077e-02f, -9.38562229e-02f, 5.89673314e-03f, 1.14297181e-01f, 3.09613436e-01f, 1.08383894e-01f, 4.50618006e-02f, 1.96760505e-01f,
  -4.57612611e-02f, -4.40803021e-02f, 6.04686365e-02f, 6.49675773e-03f, 1.90969691e-01f, 2.89894138e-02f, -4.26644459e-02f, 7.62366205e-02f, 1.51750192e-01f, -3.38317506e-04f,
  9.94695537e-03f, 5.60864061e-02f, 8.33297819e-02f, 5.15890531e-02f, 1.09653845e-01f, 2.12709475e-02f, -1.58017948e-01f, -6.47692159e-02f, 1.50924265e-01f, 2.21486706e-02f,
  9.53562185e-02f, -7.64633715e-02f, 5.88676110e-02f, 1.12213500e-01f, 1.07993424e-01f, 1.88311547e-01f, -1.03560351e-02f, 1.79498807e-01f, 3.04496810e-02f, 1.17715530e-01f,
  1.43485323e-01f, -1.08768605e-01f, -1.39006406e-01f, -4.49402444e-03f, -1.96107209e-01f, 2.26122558e-01f, 6.98657557e-02f, 1.81224972e-01f, -6.60487264e-02f, -1.10706642e-01f,
  1.86607968e-02f, 4.43444811e-02f, -1.13831796e-01f, -8.31211209e-02f, -1.02309316e-01f, 2.75365025e-01f, 2.51774676e-03f, 1.45678995e-02f, 1.44054219e-02f, -6.63231835e-02f,
  6.91426322e-02f, 1.17557466e-01f, -3.90158743e-02f, 7.60734677e-02f, -5.64155541e-02f, 9.28253233e-02f, 1.70862854e-01f, -2.47993208e-02f, -6.59442768e-02f, 1.49550170e-01f,
  6.08181730e-02f, -1.45305187e-01f, 1.43319041e-01f, -9.28390622e-02f, -1.03517942e-01f, -1.67357534e-01f, 6.59857616e-02f, 9.33633372e-02f, 7.46853650e-02f, 6.11806549e-02f,
  1.38466537e-01f, -7.89694637e-02f, -1.14830554e-01f, 3.92080881e-02f, -4.69664820e-02f, -1.58324406e-01f, 2.73417205e-01f, 2.34488491e-02f, 5.69909886e-02f, 6.89450502e-02f,
  6.30615512e-03f, 1.10421322e-01f, -9.92047712e-02f, 2.78268456e-02f, -1.31088644e-01f, -1.36915565e-01f, 1.58261508e-01f, -2.41161622e-02f, 5.87522401e-04f, 1.39275163e-01f,
  6.23350404e-02f, 1.11539461e-01f, 3.75731871e-03f, 2.21655726e-01f, 2.34419242e-01f, -2.58249521e-01f, -1.81172919e-02f, 1.98887110e-01f, -9.21580121e-02f, 6.95066303e-02f,
  1.38175264e-02f, 1.88060433e-01f, 8.56276453e-02f, 5.88735798e-03f, 1.33220583e-01f, -1.19077511e-01f, 1.55328047e-02f, 1.57722216e-02f, -7.64727294e-02f, 6.43737316e-02f,
  1.03512548e-01f, 7.85439387e-02f, 5.36952913e-02f, 1.67241380e-01f, 4.04815413e-02f, -3.57482731e-02f, -2.87840385e-02f, 6.76796585e-02f, -1.34966627e-01f, -6.35695234e-02f,
  4.94728461e-02f, -6.21541291e-02f, -5.96092828e-02f, 7.84806237e-02f, -1.29212052e-01f, -1.21767238e-01f, -8.75541866e-02f, -1.31689861e-01f, -9.70571339e-02f, -1.07874334e-01f,
  -4.33930680e-02f, 5.16386181e-02f, -3.57099362e-02f, 9.98010486e-02f, 4.31790464e-02f, 1.28431007e-01f, -6.75058365e-02f, 1.50227681e-01f, 1.41212149e-02f, -1.51764512e-01f,
  9.73249879e-03f, -1.03285566e-01f, 5.77660874e-02f, 3.54869515e-02f, -8.98708850e-02f, -1.54764444e-01f, 5.08111306e-02f, 1.34421969e-02f, -1.78855974e-02f, -4.09436859e-02f,
  -9.94050354e-02f, 5.35600074e-02f, 1.41086146e-01f, 1.59663022e-01f, 9.56924707e-02f, -2.25569010e-02f, 2.21487992e-02f, 1.83756784e-01f, 2.25562796e-01f, 1.10570807e-02f,
  -2.25823689e-02f, 2.06392035e-01f, -1.90059394e-01f, -3.84000167e-02f, 6.20132871e-02f, -8.94482285e-02f, -7.07015991e-02f, 8.68112445e-02f, -1.77247133e-02f, -4.13272642e-02f,
  1.93563223e-01f, -1.00532643e-01f, -2.16025859e-02f, 1.26030734e-02f, 1.15280375e-01f, 1.38204053e-01f, -3.10682859e-02f, 5.34920990e-02f, 1.46156019e-02f, 8.09688047e-02f,
  -1.70901179e-01f, 7.16810822e-02f, 9.45532098e-02f, 8.82007778e-02f, -9.38545391e-02f, -5.75953610e-02f, 1.68253943e-01f, 1.01277977e-01f, 1.12772249e-01f, 1.06342234e-01f,
  1.49622858e-01f, 1.77884534e-01f, -1.10330269e-01f, 1.57717615e-01f, 1.31628394e-01f, -7.72900581e-02f, 1.23025663e-01f, 1.10589806e-02f, 1.44623891e-01f, 2.72666454e-01f,
  -2.29686555e-02f, -1.18164746e-02f, -6.67071268e-02f, 8.85996744e-02f, -5.45727555e-03f, 5.74342608e-02f, -2.99516749e-02f, 1.89087421e-01f, -1.60359457e-01f, 1.08155414e-01f,
  -1.80490725e-02f, 1.77998301e-02f, 1.41103134e-01f, 9.06977132e-02f, 1.54923042e-02f, 1.44023135e-01f, 1.94666415e-01f, 1.33313760e-01f, 2.13240385e-01f, 1.75717235e-01f,
  1.80299684e-01f, 1.26255602e-01f, 2.89735019e-01f, 2.27294087e-01f, 1.94085091e-01f, 9.92785767e-02f, 1.80071458e-01f, -2.37162724e-01f, 8.07353929e-02f, -1.82995036e-01f,
  7.10831434e-02f, -5.91125228e-02f, 8.91726837e-02f, -1.71731129e-01f, 2.61595845e-01f, 1.41664920e-02f, 1.05962098e-01f, 6.84891045e-02f, -6.29183352e-02f, -1.05015896e-02f,
  -2.06072908e-02f, 8.71461108e-02f, 8.24689344e-02f, -5.50794117e-02f, -1.41803801e-01f, 4.78753410e-02f, 1.16926171e-02f, -7.12559149e-02f, -1.37212845e-02f, -4.61662561e-02f,
  1.58403561e-01f, 1.35072554e-02f, 3.15580398e-01f, 8.23761001e-02f, 1.29116550e-01f, -7.19532967e-02f, 1.22099370e-01f, 5.72307631e-02f, -7.48851076e-02f, -1.45847604e-01f,
  2.24709377e-01f, -3.36039923e-02f, -1.37994394e-01f, 1.66211486e-01f, 2.18547970e-01f, -9.33388174e-02f, -9.22790095e-02f, 1.04454510e-01f, -2.39027932e-01f, 7.78313205e-02f,
  8.54701027e-02f, -6.74999431e-02f, -8.49993005e-02f, 8.37529674e-02f, 1.39189810e-01f, 8.60455213e-04f, 2.30055839e-01f, 1.31261691e-01f, -1.39140248e-01f, 1.84367970e-01f,
  1.41757373e-02f, -1.36237061e-02f, 1.03274465e-01f, -9.37330723e-02f, -9.93817225e-02f, 9.99050215e-02f, 3.14974748e-02f, -2.20766310e-02f, -1.10623151e-01f, -4.70821820e-02f,
  -2.69311685e-02f, 7.79569000e-02f, -1.10604078e-01f, 1.19989447e-01f, 1.07541852e-01f, -8.77000019e-02f, 5.22470251e-02f, 1.00121647e-01f, 1.10041745e-01f, 6.81434125e-02f,
  -7.96178877e-02f, -7.08194450e-02f, 1.77816167e-01f, 1.07762869e-02f, 4.03261632e-02f, 5.71666472e-02f, 7.57853268e-03f, 1.16019882e-01f, 1.10345818e-01f, 3.30665708e-02f,
  4.88598160e-02f, 4.70539555e-02f, 1.27103269e-01f, 9.35576856e-02f, -8.21135491e-02f, 7.35789165e-02f, 7.46146366e-02f, 2.58287136e-02f, 1.98724214e-02f, -2.45879218e-02f,
  3.50460298e-02f, 2.64031552e-02f, -6.21676259e-02f, 1.33449743e-02f, -6.97359219e-02f, -1.17483512e-01f, 7.83938318e-02f, -1.09298341e-01f, -1.16323672e-01f, -4.20204736e-02f,
  -2.66700843e-03f, -2.91799791e-02f, -6.60367534e-02f, -1.00173950e-01f, -5.84650598e-02f, -6.32266328e-02f, -9.97595638e-02f, -2.26397216e-02f, -8.09313506e-02f, -1.33579850e-01f,
  3.20540145e-02f, -9.76684019e-02f, 7.61383474e-02f, -1.28906116e-01f, -4.14135791e-02f, 1.22635290e-01f, -8.34553987e-02f, -2.44660806e-02f, -7.43760318e-02f, 7.25130439e-02f,
  -1.32382393e-01f, 2.99946358e-03f, 1.59890242e-02f, 8.72202888e-02f, -6.81768432e-02f, -1.37178317e-01f, 8.83100182e-02f, -1.02281801e-01f, -1.74168553e-02f, -3.99807375e-03f,
  -1.22053057e-01f, -1.04715228e-01f, 1.38192341e-01f, -6.22543367e-03f, 1.22177504e-01f, -2.55547259e-02f, 8.02986845e-02f, -1.11974925e-01f, 7.41351619e-02f, -4.44226153e-02f,
  -1.20412894e-01f, 4.07883301e-02f, 9.04441997e-02f, -3.81687321e-02f, -5.11930026e-02f, 2.52124146e-02f, 5.94540499e-02f, 7.00604916e-02f, -5.06766774e-02f, 1.36256088e-02f,
  1.08687123e-02f, -4.66238484e-02f, -6.59729838e-02f, 7.59132020e-03f, 7.70997703e-02f, 9.36675258e-03f, 5.19312918e-02f, 7.92992488e-03f, -6.96305484e-02f, -6.57913908e-02f,
  -5.27100451e-02f, -7.24115223e-02f, 9.53459591e-02f, -8.54777023e-02f, -7.27475360e-02f, 1.02971621e-01f, 2.67488137e-02f, -1.01253264e-01f, 1.18396193e-01f, 1.00382611e-01f,
  -5.81664667e-02f, 8.19693655e-02f, 9.64074768e-03f, 5.10239415e-03f, 9.94879454e-02f, -6.46949559e-02f, -1.03401877e-01f, -4.36317585e-02f, 1.43840864e-01f, 1.60566166e-01f,
  4.07779263e-03f, 8.15308094e-02f, 1.35896027e-01f, 3.93376267e-03f, -2.98764464e-02f, -3.03398613e-02f, -5.44737950e-02f, -9.33110639e-02f, -1.09603694e-02f, -9.98865664e-02f,
  -4.17161779e-03f, 1.19207129e-01f, 8.83115605e-02f, 7.61857778e-02f, 8.25908259e-02f, -1.07955717e-01f, 1.53040707e-01f, 2.27210838e-02f, 8.16429332e-02f, -3.52965742e-02f,
  6.21953048e-02f, 1.11507446e-01f, 2.46568993e-02f, 5.56141324e-03f, -7.76115134e-02f, -1.17092215e-01f, 8.73730928e-02f, 3.66310291e-02f, 1.76160876e-02f, 8.74335319e-02f,
  2.46567316e-02f, 6.61687925e-02f, 1.30520150e-01f, -1.15943052e-01f, -6.52911440e-02f, -3.95915918e-02f, 6.50966913e-02f, -3.59683000e-02f, -3.55816353e-03f, -4.72730510e-02f,
  -1.31306052e-01f, 1.66114539e-01f, -1.02978550e-01f, 8.74868035e-02f, -9.76843610e-02f, -1.13346443e-01f, 7.86091089e-02f, -1.13727599e-01f, 1.97577965e-03f, -2.96065453e-02f,
  1.40163034e-01f, 1.29111335e-01f, 1.15300842e-01f, -4.94360738e-03f, 3.17405490e-03f, -4.75876965e-02f, 9.11857635e-02f, 4.34853211e-02f, 1.61210418e-01f, 2.53135972e-02f,
  -1.18364401e-01f, 3.07855792e-02f, 3.00196260e-01f, 3.77074420e-01f, 3.41014415e-01f, 2.71809280e-01f, 3.96792918e-01f, 6.87230751e-02f, 1.20405570e-01f, 6.01356663e-02f,
  -1.81792468e-01f, -2.90572435e-01f, -7.31685609e-02f, 2.35260725e-02f, -1.34950981e-01f, 9.43389013e-02f, 7.19743222e-03f, -9.93439462e-03f, -6.97503313e-02f, -1.28415883e-01f,
  2.70594805e-01f, -1.09368160e-01f, 8.01724717e-02f, 3.94881338e-01f, -2.77096152e-01f, 1.56102076e-01f, 7.12888092e-02f, 2.76190657e-02f, -6.82107583e-02f, -7.40626529e-02f,
  4.13419418e-02f, 4.06885862e-01f, -3.22947092e-02f, 5.55358306e-02f, 1.51776761e-01f, -1.86050728e-01f, 2.46738836e-01f, -1.28046691e-01f, 1.20666407e-01f, -8.02862868e-02f,
  1.26615331e-01f, -1.33453697e-01f, -1.55038342e-01f, 1.32707223e-01f, -8.45025480e-02f, 3.20661783e-01f, -5.48945181e-02f, 3.85064147e-02f, -5.97207546e-02f, -5.86667657e-03f,
  9.03060511e-02f, -1.32356584e-01f, -1.13250114e-01f, 2.05171276e-02f, -1.78821757e-02f, -7.37526361e-03f, -9.18583870e-02f, -1.04857072e-01f, -5.17471321e-02f, 2.21076101e-01f,
  2.08237678e-01f, 3.14842872e-02f, 1.97710544e-01f, -5.07033505e-02f, -8.08619857e-02f, 1.12213634e-01f, 1.18323617e-01f, -2.48601940e-02f, -3.80570367e-02f, -4.75848988e-02f,
  -1.48299247e-01f, -1.37199119e-01f, -2.39599254e-02f, 7.65915066e-02f, 3.81983630e-02f, 9.31896344e-02f, 1.14553437e-01f, 6.08683638e-02f, -5.96378371e-02f, -7.53979608e-02f,
  7.58127272e-02f, -7.81901628e-02f, 2.84096040e-02f, -5.07607944e-02f, 6.33508265e-02f, -1.00737654e-01f, 4.25116643e-02f, 1.22955404e-02f, 2.18198020e-02f, -8.46483484e-02f,
  -2.11988622e-03f, -9.40508470e-02f, -7.48046767e-03f, 4.36512902e-02f, -1.14094660e-01f, 1.57714766e-02f, 3.88625897e-02f, -4.18605059e-02f, 8.56752507e-03f, 4.01364267e-02f,
  -3.67771164e-02f, 3.23156081e-02f, 4.00440469e-02f, -4.87126671e-02f, -6.87510744e-02f, 4.55839969e-02f, -5.67188673e-02f, 1.56454537e-02f, -2.65608355e-02f, 6.03207760e-02f,
  -9.26209763e-02f, -4.04205322e-02f, -1.27276227e-01f, -5.39853051e-02f, -9.98439863e-02f, 2.19965037e-02f, 4.39477190e-02f, 9.74589139e-02f, 7.04596639e-02f, 6.66141659e-02f,
  -8.89921486e-02f, 3.99658009e-02f, -4.23476398e-02f, 1.61278211e-02f, 3.65529135e-02f, -7.27577806e-02f, -5.67468163e-03f, -3.00036483e-02f, 6.08674698e-02f, -1.06578507e-01f,
  2.03846782e-01f, 2.13699549e-01f, 1.44691691e-01f, 2.21068338e-01f, -1.51098920e-02f, 1.46909133e-01f, 2.84158140e-01f, -2.49095142e-01f, 4.31666672e-02f, 1.99688733e-01f,
  -1.16449721e-01f, -1.53523013e-01f, 1.05431311e-01f, -4.52805310e-02f, 3.81021947e-02f, -1.60495415e-02f, 1.25820190e-01f, -9.13712531e-02f, -6.30190298e-02f, -4.23232140e-03f,
  2.22624913e-02f, -1.02387853e-01f, 6.41363263e-02f, -9.55161527e-02f, 1.35085672e-01f, 1.85691327e-01f, 2.69837976e-02f, -1.15918085e-01f, 5.79040721e-02f, 4.31475416e-02f,
  -1.03446297e-01f, -3.75598632e-02f, 8.26657936e-02f, 3.86102907e-02f, 8.11456442e-02f, 1.57033920e-01f, 1.58511698e-01f, -1.09586872e-01f, -1.40185431e-01f, 1.18787549e-01f,
  -7.86879882e-02f, -1.47287503e-01f, -1.07165501e-02f, -1.74727678e-01f, -7.33762607e-02f, -5.61784673e-03f, 3.70247625e-02f, 1.75891556e-02f, 1.83184773e-01f, 1.20607451e-01f,
  -9.94945094e-02f, -7.28424266e-02f, 1.23115972e-01f, 4.48225103e-02f, 9.46137458e-02f, 5.08353580e-03f, 3.39381173e-02f, -2.54184604e-02f, 1.38003752e-01f, 7.88198113e-02f,
  -8.21470022e-02f, -3.38012427e-02f, -1.31568648e-02f, 7.19311237e-02f, -2.51978412e-02f, 1.20416485e-01f, 1.15560301e-01f, 1.01085929e-02f, 1.48301631e-01f, -9.07495841e-02f,
  -1.93511367e-01f, 1.34123787e-01f, -1.23815365e-01f, -5.16752061e-03f, -7.40655139e-02f, 3.98693979e-02f, 1.04812264e-01f, 5.94954379e-02f, -1.23550795e-01f, -4.51611169e-02f,
  -5.03902733e-02f, 1.03743300e-01f, 1.37290344e-01f, 1.30369693e-01f, 1.48708031e-01f, 1.30810365e-01f, 9.05130506e-02f, 1.57714725e-01f, 5.08762076e-02f, 6.10666201e-02f,
  -1.27210811e-01f, 8.74040574e-02f, 1.26345202e-01f, 2.40816921e-01f, -1.35894299e-01f, 1.15603060e-02f, 4.59750071e-02f, -3.63423675e-02f, -3.11052259e-02f, 2.35440228e-02f,
  -8.61987993e-02f, 1.34538904e-01f, 1.80757359e-01f, 1.15676634e-02f, -2.54481416e-02f, -6.93031773e-02f, 2.25070808e-02f, 2.69808639e-02f, -1.34008050e-01f, 8.18858072e-02f,
  -6.64397702e-02f, 9.81706940e-03f, -3.44232991e-02f, 9.02541652e-02f, 3.77428271e-02f, 3.05707585e-02f, 9.70932394e-02f, 1.00380711e-01f, -3.01404055e-02f, -1.21796466e-01f,
  2.61285882e-02f, 1.51686622e-02f, 5.83799835e-03f, 1.58155039e-02f, 5.56901284e-02f, -1.34077027e-01f, -2.31676251e-02f, -6.19310923e-02f, -8.88245925e-02f, 7.46458843e-02f,
  1.55209348e-01f, 6.48510903e-02f, 1.66703388e-01f, 1.09578133e-01f, 1.50772423e-01f, 5.27437776e-02f, 1.54648134e-02f, 1.77208945e-01f, 3.36960666e-02f, -2.22856075e-01f,
  -9.33895111e-02f, -8.26274082e-02f, 3.65106054e-02f, -5.41359745e-02f, 2.66197741e-01f, 2.04079956e-01f, 1.26561135e-01f, 2.78470255e-02f, -6.96628019e-02f, -1.17011517e-01f,
  2.03780569e-02f, 1.66104272e-01f, 5.85874170e-02f, -1.06200114e-01f, -6.28775284e-02f, 6.18453175e-02f, 7.70102590e-02f, -2.80905310e-02f, 7.59463087e-02f, 8.37426484e-02f,
  1.81874529e-01f, 1.40530840e-02f, 1.72156870e-01f, 1.90765381e-01f, 2.35971317e-01f, -9.90224183e-02f, -2.63459459e-02f, 4.45191599e-02f, -7.09090978e-02f, 3.30622904e-02f,
  3.81901003e-02f, 6.65153936e-02f, 7.77069479e-02f, 2.38150749e-02f, 1.74533715e-03f, -2.13685203e-02f, 7.06567615e-02f, -1.74455997e-02f, 2.71541364e-02f, -8.59916881e-02f,
  2.00615272e-01f, 4.79355939e-02f, 6.07430283e-03f, -2.97899805e-02f, 1.10995069e-01f, 1.47852125e-02f, -6.89636618e-02f, 7.36619085e-02f, 1.34975135e-01f, 1.40907452e-01f,
  -4.29262333e-02f, 1.11090101e-01f, 1.32764891e-01f, 1.80147350e-01f, 5.39949946e-02f, 2.63322055e-01f, -2.10958924e-02f, 1.72158554e-01f, -2.75118947e-02f, -1.14997596e-01f,
  -8.42135921e-02f, -1.50122404e-01f, -5.40338866e-02f, -2.16027379e-01f, -4.49035652e-02f, -3.59114148e-02f, 3.19446884e-02f, 1.12878010e-02f, 9.50674117e-02f, 2.61495858e-01f,
  -4.49148081e-02f, 1.71659410e-01f, -1.20239750e-01f, 1.40558407e-01f, -2.00544640e-01f, 1.03905194e-01f, -1.04192533e-01f, 2.36135200e-02f, 1.29279763e-01f, -5.57774678e-03f,
  1.94729999e-01f, 4.80381325e-02f, -1.75536075e-03f, 7.21438834e-03f, 2.26034105e-01f, 2.87022404e-02f, -1.29743502e-01f, 2.80201346e-01f, 5.66470064e-03f, -1.31686941e-01f,
  -1.35459155e-01f, -1.09383442e-01f, 1.29390389e-01f, 4.86842692e-02f, 1.18319377e-01f, -7.28470534e-02f, 1.07359096e-01f, -9.35768038e-02f, 5.54521615e-03f, 8.10993277e-03f,
  8.61734301e-02f, -8.51833224e-02f, -7.70948678e-02f, -1.15535431e-01f, 3.25002462e-01f, 7.50891417e-02f, -3.91793810e-02f, -1.17923237e-01f, 9.46028456e-02f, -2.67361030e-02f,
  6.55241963e-03f, -3.22891884e-02f, -7.40372390e-02f, 3.08131799e-02f, 7.74766132e-02f, -1.55783594e-01f, 6.71350211e-02f, 1.99210364e-02f, 9.11310762e-02f, 1.21039413e-01f,
  1.05663449e-01f, 1.79821607e-02f, 1.07674591e-01f, 1.07382491e-01f, 2.05599312e-02f, -1.21433340e-01f, -6.50983155e-02f, 5.88852689e-02f, 7.45026991e-02f, 3.53383198e-02f,
  1.66159552e-02f, -9.03094262e-02f, -9.82848853e-02f, 9.74807739e-02f, 7.36608729e-02f, -9.61237252e-02f, 7.46888965e-02f, 9.57260188e-03f, -5.94400689e-02f, -8.96263272e-02f,
  -8.92995968e-02f, -7.54365027e-02f, -8.05695504e-02f, -1.20088965e-01f, -1.22973539e-01f, 2.25126427e-02f, 1.11808091e-01f, -3.85127589e-03f, 1.26123235e-01f, -2.91712303e-02f,
  9.21724830e-03f, -4.03086692e-02f, 1.22133009e-01f, 4.09448519e-02f, -1.01045482e-01f, 4.62406576e-02f, 8.79920870e-02f, -1.58124492e-02f, -3.73357870e-02f, 8.61679912e-02f,
  4.55188937e-02f, -8.41934830e-02f, 6.46410370e-03f, 1.48531288e-01f, -8.99619013e-02f, -1.01906307e-01f, -1.24789886e-01f, -6.90539330e-02f, -7.43474811e-02f, 7.76773393e-02f,
  1.02356579e-02f, -3.36068310e-02f, -1.66587885e-02f, -1.20743692e-01f, 2.36838311e-03f, -2.08700635e-02f, -1.32852141e-02f, 9.52562168e-02f, -1.03863084e-03f, -1.06234208e-01f,
  7.63451532e-02f, 1.25934839e-01f, 1.41277909e-01f, 9.74464193e-02f, 1.03790686e-01f, 1.80747107e-01f, 3.93220037e-02f, -3.21500599e-01f, 2.80130170e-02f, 5.27980961e-02f,
  -3.34564447e-02f, 2.34023079e-01f, -7.89357275e-02f, 6.50214478e-02f, -3.58153768e-02f, -5.91198774e-03f, 2.18260199e-01f, 7.95221105e-02f, -1.58726886e-01f, -2.71754134e-02f,
  -4.12309431e-02f, 9.49471667e-02f, 3.37532759e-01f, -5.41996136e-02f, -8.13997537e-03f, 8.52587074e-02f, 1.60140723e-01f, 8.59453306e-02f, -1.28337771e-01f, 2.02499013e-02f,
  -6.56898171e-02f, -3.28424647e-02f, -3.77943963e-02f, 5.65777831e-02f, -3.88357090e-03f, -1.42918646e-01f, -1.46508113e-01f, -1.50204331e-01f, -3.23842503e-02f, 1.33860875e-02f,
  -1.66396834e-02f, -5.50184324e-02f, -7.64357299e-02f, 1.19911097e-01f, 1.44995287e-01f, -1.22966267e-01f, 3.06784455e-02f, -1.18120357e-01f, -1.54052958e-01f, 2.50356067e-02f,
  1.54834867e-01f, -6.55762255e-02f, 1.75936595e-01f, -1.23800747e-01f, 1.39088258e-01f, 1.59053773e-01f, -4.22182605e-02f, -1.32483020e-01f, 9.71466154e-02f, 2.13423055e-02f,
  7.87474914e-04f, -1.37117237e-01f, -3.06558032e-02f, 3.65690775e-02f, 2.36095935e-01f, 9.52968150e-02f, 3.07505548e-01f, 1.94653049e-01f, 2.43792087e-01f, 1.52586356e-01f,
  3.49847883e-01f, -2.55061388e-01f, 6.31606430e-02f, 3.08451712e-01f, -1.81852363e-03f, -8.63934010e-02f, -8.41078609e-02f, -5.61500527e-02f, 4.96882189e-04f, -2.31063403e-02f,
  1.81156009e-01f, -8.14132541e-02f, 1.74030736e-01f, -1.35001853e-01f, -9.22385007e-02f, 2.09871046e-02f, 3.19832087e-01f, 6.22963570e-02f, 1.66259557e-01f, 2.68051654e-01f,
  -3.00503094e-02f, -1.98189002e-02f, 1.26669742e-02f, 1.00452542e-01f, -8.36392585e-03f, -2.34096237e-02f, 1.53128803e-01f, 7.67425299e-02f, -4.00150381e-02f, -2.31216196e-02f,
  -4.05687019e-02f, 5.31095117e-02f, -4.82896790e-02f, -1.24238491e-01f, 6.85557574e-02f, -1.22741304e-01f, -1.10175051e-01f, -2.34132465e-02f, 2.21756011e-01f, -5.16321808e-02f,
  -1.09315047e-03f, 1.30173489e-01f, 2.16919675e-01f, -6.27476946e-02f, 9.25806463e-02f, -1.61911119e-02f, 5.17668054e-02f, -6.85779005e-03f, 1.37786731e-01f, 1.01398125e-01f,
  7.21536716e-03f, -1.17186747e-01f, 6.23172410e-02f, -6.93167597e-02f, -1.22667588e-02f, 6.21262565e-03f, 9.14195478e-02f, 1.08918048e-01f, -2.78173052e-02f, -7.80814141e-02f,
  -3.67713422e-02f, -1.15593038e-01f, -8.05752426e-02f, -2.92927306e-02f, -1.13137513e-01f, -6.69700140e-03f, 3.24374177e-02f, -8.86044130e-02f, -1.43362572e-02f, 1.34408787e-01f,
  -2.05973033e-02f, 1.37612978e-02f, -9.18027293e-03f, 2.92703826e-02f, -7.64211267e-02f, -2.32058391e-02f, 1.02122374e-01f, 9.77296457e-02f, -2.37290990e-02f, 1.39616013e-01f,
  3.09759956e-02f, 5.77772558e-02f, -2.71435063e-02f, -2.32723337e-02f, 8.10074713e-03f, 1.55286789e-01f, 5.43087758e-02f, 8.96185637e-02f, -6.27924204e-02f, 4.22839783e-02f,
  -1.52181918e-02f, 7.50195086e-02f, 1.51969671e-01f, 1.16627729e-02f, 1.42496616e-01f, -3.45625654e-02f, 2.17237815e-01f, 1.23776652e-01f, 5.47637306e-02f, 7.25641325e-02f,
  9.43459347e-02f, 1.37070030e-01f, -5.25898710e-02f, 7.69554451e-02f, -1.44525766e-02f, 1.77725643e-01f, -1.81220677e-02f, 2.90178135e-02f, -1.15521632e-01f, -9.65158641e-02f,
  1.06498569e-01f, -7.27038532e-02f, -3.52036394e-02f, -8.70013610e-03f, -1.19149506e-01f, 4.27290425e-02f, 7.29204863e-02f, 1.52222022e-01f, 1.10630795e-01f, 3.74995731e-02f,
  2.33710036e-02f, 1.85369566e-01f, 2.08586276e-01f, 2.48686507e-01f, 1.37493610e-01f, 2.23216087e-01f, 1.93475142e-01f, 1.39834613e-01f, 2.69356459e-01f, -2.78112963e-02f,
  -5.02812453e-02f, -3.67672704e-02f, -1.26562878e-01f, -1.94644064e-01f, -8.66198093e-02f, -7.80673772e-02f, 9.83045101e-02f, 6.23296946e-02f, 5.14318119e-04f, 1.30155951e-01f,
  7.85071850e-02f, 1.23670079e-01f, 6.20530955e-02f, -1.24195561e-01f, -5.72420433e-02f, 1.02851205e-01f, 9.91818830e-02f, 6.29384741e-02f, 1.01979472e-01f, -5.12644500e-02f,
  1.84519906e-02f, -9.18983221e-02f, -9.09917131e-02f, -1.93830743e-03f, 1.78383946e-01f, 3.29207554e-02f, 1.37835234e-01f, 1.44634470e-01f, 8.61173049e-02f, -3.06965131e-03f,
  -9.20147672e-02f, -1.18826861e-02f, 6.82368651e-02f, 1.89737882e-02f, 1.06776347e-02f, -2.94442456e-02f, 2.54325699e-02f, -1.86966993e-02f, 2.61954330e-02f, 9.35142860e-02f,
  2.05637187e-01f, 1.24306172e-01f, -1.64345741e-01f, -6.36216626e-02f, -2.88964971e-03f, 1.04069464e-01f, 1.29055902e-01f, 1.00143033e-03f, -1.16783522e-01f, 7.62174278e-02f,
  -3.15279979e-03f, -1.11443758e-01f, -7.92804807e-02f, 9.55858454e-02f, 8.94282535e-02f, -6.53362945e-02f, 1.06956050e-01f, 1.59226656e-01f, -3.24782692e-02f, -1.49046481e-02f,
  1.42280892e-01f, 1.60332825e-02f, -1.02744199e-01f, 1.25450194e-02f, -1.92092732e-01f, -1.06742635e-01f, -1.36297001e-02f, 9.88633782e-02f, -1.25106484e-01f, 9.97871980e-02f,
  5.36948852e-02f, -9.25323963e-02f, 6.47045597e-02f, 3.89418975e-02f, -1.06033258e-01f, 3.91409472e-02f, 1.45748302e-01f, 3.71419638e-01f, 3.43200415e-02f, 3.40969153e-02f,
  1.58291589e-02f, 2.53538955e-02f, -2.86015943e-02f, -7.99602866e-02f, 1.34666279e-01f, 1.39435872e-01f, -1.16330825e-01f, 2.00546846e-01f, -1.19252302e-01f, -8.99624154e-02f,
  5.17105833e-02f, -2.72608045e-02f, -1.17621057e-01f, 5.29384203e-02f, 2.17738062e-01f, -9.63841379e-02f, 8.19208473e-03f, -3.03471573e-02f, -1.42318234e-01f, 1.16463773e-01f,
  -1.11539580e-01f, -2.21224073e-02f, -2.35719141e-02f, -7.95575455e-02f, -4.72709611e-02f, -3.59517969e-02f, 2.42188200e-02f, -7.44482055e-02f, 1.79988548e-01f, -8.22390988e-02f,
  2.98752543e-02f, -1.14499152e-01f, -4.26866040e-02f, 8.97613764e-02f, -1.49972811e-02f, 7.54804239e-02f, -3.63577008e-02f, 5.89761660e-02f, 1.49950519e-01f, -3.88714597e-02f,
  -8.45596790e-02f, -1.96142644e-02f, -2.90510245e-02f, 1.43379718e-01f, -4.40881960e-02f, -4.21216600e-02f, -4.67340760e-02f, -1.15015648e-01f, 5.56823574e-02f, 5.78380674e-02f,
  5.77847101e-02f, 9.73035470e-02f, 1.12766899e-01f, -3.89318168e-02f, 1.02296412e-01f, -2.51650363e-02f, 8.56875777e-02f, 9.18809548e-02f, -1.07734576e-01f, -8.22933614e-02f,
  -1.60316266e-02f, -2.32818741e-02f, -8.51939395e-02f, 7.67178237e-02f, 6.56537414e-02f, -6.02218397e-02f, 4.67831753e-02f, 2.63527967e-02f, 9.15328860e-02f, -5.46197928e-02f,
  -8.37617368e-02f, -4.47873473e-02f, -2.55899988e-02f, -1.06706254e-01f, -5.42211235e-02f, 6.14396259e-02f, 1.11247189e-01f, 3.07559595e-02f, -1.42663658e-01f, -6.54804185e-02f,
  5.75424209e-02f, -1.39708742e-01f, 5.71613424e-02f, -1.95488576e-02f, -1.03931077e-01f, -7.37731066e-03f, 4.34807390e-02f, 9.13513601e-02f, -4.31683473e-02f, -8.78519863e-02f,
  -5.96596114e-02f, -3.83845456e-02f, 1.37583777e-01f, 3.09552019e-03f, -3.47555801e-02f, 1.87609680e-02f, -1.00451812e-01f, 9.65851024e-02f, -1.19206205e-01f, 8.17071572e-02f,
  6.86812680e-03f, 5.18692285e-02f, 9.78118367e-03f, -3.92958000e-02f, 2.28154287e-01f, -9.52393040e-02f, -6.07752288e-03f, -1.02698065e-01f, 3.04485001e-02f, 2.72913486e-01f,
  6.54953020e-03f, 9.52991545e-02f, 1.69509098e-01f, 1.74307719e-01f, -2.14991514e-02f, 4.58706915e-02f, -9.50262249e-02f, 2.56781783e-02f, 4.01691906e-02f, -4.90726270e-02f,
  2.81725109e-01f, 6.05125241e-02f, 1.40206486e-01f, -1.20759830e-01f, 9.02483016e-02f, 1.42417550e-01f, 2.29384467e-01f, -1.19393662e-01f, 7.19612166e-02f, 1.45824134e-01f,
  -1.11604683e-01f, 1.20048650e-01f, -1.24787919e-01f, -7.46160150e-02f, 1.46057978e-01f, -7.17569888e-02f, 1.21010914e-01f, -4.38028127e-02f, 1.25451982e-01f, 1.22453935e-01f,
  3.05058986e-01f, 1.13483533e-01f, 1.89420000e-01f, 8.56835842e-02f, -1.19970024e-01f, 2.68844128e-01f, -4.87653017e-02f, -2.05809698e-02f, 3.15757692e-01f, -8.08801427e-02f,
  6.14652559e-02f, 7.14134146e-03f, -2.02163737e-02f, -9.25984606e-02f, 4.77429740e-02f, 1.56074718e-01f, -1.09677240e-01f, 9.20455903e-02f, -9.64797363e-02f, 1.91521525e-01f,
  3.07820719e-02f, 1.09721338e-02f, 5.83632737e-02f, -7.60613456e-02f, 1.92373306e-01f, -2.40382637e-04f, -5.63262366e-02f, 2.46890202e-01f, 2.12985519e-02f, 1.56038791e-01f,
  5.92762008e-02f, 2.11966664e-01f, 1.98138624e-01f, -5.58317751e-02f, -2.11077463e-03f, -1.91974714e-01f, -9.54679400e-02f, 1.25363141e-01f, 1.11988500e-01f, 2.87799872e-02f,
  -4.76657227e-02f, 2.16923684e-01f, -3.90700139e-02f, -3.74337062e-02f, 2.40371004e-02f, -7.59809613e-02f, -4.45244499e-02f, -4.54626083e-02f, -1.36192562e-02f, 1.63305372e-01f,
  2.12620869e-01f, 3.42959911e-02f, -2.83483602e-02f, 2.80767530e-02f, 2.24655326e-02f, -1.09029390e-01f, 4.41529565e-02f, 2.65022516e-01f, -1.00644946e-01f, 1.90642878e-01f,
  2.02101201e-01f, -7.89107010e-03f, -2.63735801e-02f, -1.00755975e-01f, -5.08901291e-02f, -6.32368177e-02f, -1.26617312e-01f, -1.61162347e-01f, 2.96096113e-02f, -1.44666433e-01f,
  -1.79469101e-02f, 1.28022715e-01f, -7.23792473e-03f, -5.70351221e-02f, -3.51411924e-02f, -1.30295023e-01f, 9.28727313e-05f, 8.13608021e-02f, 1.12939887e-01f, 1.66002493e-02f,
  3.22940916e-01f, 2.50865947e-02f, 1.09170035e-01f, -1.06837742e-01f, 1.07929528e-01f, -7.68209696e-02f, 1.47113666e-01f, 1.02794141e-01f, 9.46342293e-03f, 7.60813355e-02f,
  1.54910609e-01f, -1.48095474e-01f, 1.00474581e-01f, 8.81755129e-02f, -6.54713809e-02f, -2.43621669e-03f, 7.19688684e-02f, 5.62255494e-02f, 8.29811767e-02f, -1.46484748e-01f,
  7.42994770e-02f, -4.70006280e-02f, -9.58535448e-02f, 1.30914733e-01f, -9.45533812e-02f, -1.09393997e-02f, -3.57661135e-02f, 8.98878202e-02f, -7.91971684e-02f, -6.43465668e-02f,
  -7.04096481e-02f, -1.17414966e-01f, 2.46369559e-02f, 9.72280800e-02f, 1.79501295e-01f, -6.67269602e-02f, 5.83185665e-02f, -5.47737218e-02f, 5.95372990e-02f, -4.72783484e-02f,
  -1.05192140e-01f, 5.16426796e-03f, -5.73570915e-02f, 8.86013061e-02f, -5.69484793e-02f, -9.19348821e-02f, 3.37851532e-02f, 4.32467870e-02f, -1.08458206e-01f, 7.54773840e-02f,
  -1.12444475e-01f, -2.10771002e-02f, 1.62527207e-02f, 4.27268296e-02f, 6.67026863e-02f, -1.13566346e-01f, 7.55117163e-02f, 6.61345199e-02f, 6.28202483e-02f, -9.71843824e-02f,
  -3.22440751e-02f, 6.90819845e-02f, 1.08348981e-01f, -7.31861815e-02f, -4.03403528e-02f, -7.73082748e-02f, 1.23695053e-01f, 9.75462943e-02f, 1.97115131e-02f, -8.69956836e-02f,
  -1.03212819e-01f, 3.04612760e-02f, -1.04488835e-01f, 8.83514509e-02f, -1.16944816e-02f, 1.58762466e-02f, 7.13462830e-02f, 3.56311053e-02f, 1.43390030e-01f, -2.19413210e-02f,
  1.89380795e-01f, -2.05043480e-01f, -2.42328078e-01f, -1.92311071e-02f, -1.98338002e-01f, -2.37855539e-01f, 5.87754622e-02f, 1.32842585e-01f, 7.17968494e-02f, 1.57546848e-02f,
  -9.14232433e-03f, 1.19235978e-01f, 4.55713198e-02f, 1.18850984e-01f, -6.35706484e-02f, 1.67696457e-02f, 5.31619228e-02f, 4.41334605e-01f, -9.39085260e-02f, 1.22388966e-01f,
  -1.58192605e-01f, -1.18595667e-01f, -1.13569126e-01f, -1.08689412e-01f, -8.22790153e-03f, 3.26946914e-01f, -1.44305781e-01f, 1.49182215e-01f, 4.81110774e-02f, 1.00657381e-01f,
  -1.26693562e-01f, -8.68744701e-02f, 4.74550463e-02f, -5.61583191e-02f, 1.67093530e-01f, -7.39536807e-02f, -1.47237763e-01f, 1.03516527e-01f, 1.17354497e-01f, 2.81492680e-01f,
  -1.60213649e-01f, -4.27937098e-02f, 2.22901143e-02f, -1.14628755e-01f, -4.89700399e-03f, -8.87209028e-02f, 1.09035365e-01f, -2.65703779e-02f, 1.64406538e-01f, -1.37717938e-02f,
  -4.05719243e-02f, -1.09945364e-01f, -1.02545947e-01f, 2.13860229e-01f, 8.67040083e-02f, 1.66866854e-01f, -1.14826620e-01f, 6.32599667e-02f, 1.77831694e-01f, 6.90336078e-02f,
  -3.43038067e-02f, 1.59603432e-02f, -7.65804872e-02f, -7.81240612e-02f, 4.70938310e-02f, 5.68535104e-02f, -4.04782519e-02f, -1.25831768e-01f, -1.13978848e-01f, 7.42999017e-02f,
  4.77437079e-02f, 5.00361174e-02f, 4.02039513e-02f, 1.41259372e-01f, -6.17782138e-02f, -6.91113994e-02f, -5.96083328e-02f, -1.26954345e-02f, -1.08193055e-01f, 9.79817957e-02f,
  1.09326839e-02f, -1.89611875e-02f, 8.91124159e-02f, 2.04084925e-02f, 2.52994802e-02f, 9.15723965e-02f, -1.94032695e-02f, 1.65574756e-02f, -8.39509368e-02f, 8.18414986e-02f,
  -1.18041374e-01f, -8.57318267e-02f, 4.92303707e-02f, 3.30124535e-02f, 1.56517569e-02f, 7.64058232e-02f, -8.39237645e-02f, -1.33805871e-01f, -5.45970462e-02f, 8.01811963e-02f,
  9.06152651e-02f, 8.48897696e-02f, 1.09521002e-01f, 4.90052998e-03f, 7.87776187e-02f, -1.06381059e-01f, -6.87643886e-03f, -6.44863471e-02f, -7.09196925e-02f, 4.91439849e-02f,
  5.33198453e-02f, -7.67373219e-02f, -2.40457729e-02f, -1.01886511e-01f, -1.07448705e-01f, -2.68805735e-02f, 8.29687566e-02f, -3.36677320e-02f, 3.42594497e-02f, 7.43232062e-03f,
  8.00474510e-02f, 1.59548819e-02f, 1.39681876e-01f, 6.43474329e-03f, 1.86400950e-01f, 1.78554639e-01f, -2.12335810e-02f, 1.00020692e-01f, 2.02619255e-01f, 8.39969963e-02f,
  1.04843147e-01f, 1.77384213e-01f, -1.91102214e-02f, -5.89291863e-02f, 7.75951566e-03f, 7.72611424e-02f, -8.94094184e-02f, 4.65265177e-02f, 8.32314715e-02f, 1.20785080e-01f,
  -1.49966449e-01f, -6.73126802e-02f, 2.54558206e-01f, 2.44016526e-03f, 6.79963827e-02f, 5.21776155e-02f, -2.81663425e-02f, 1.09562002e-01f, -3.11996434e-02f, -2.05124505e-02f,
  4.24234681e-02f, 6.31075501e-02f, -7.50814453e-02f, 1.65289685e-01f, 4.71062921e-02f, -1.34070098e-01f, 1.02185994e-01f, -1.44808069e-01f, 2.50739127e-01f, -1.33878291e-01f,
  1.83740914e-01f, 2.21564136e-02f, 9.44149271e-02f, 1.37815714e-01f, -1.17278561e-01f, 2.50059932e-01f, -1.24499857e-01f, 7.44881481e-02f, 2.56951228e-02f, 1.17010623e-01f,
  -4.95806076e-02f, 3.72720100e-02f, 4.08620164e-02f, 4.19200845e-02f, -8.33285227e-02f, -2.53414903e-02f, -2.29969963e-01f, 1.09442227e-01f, 1.93045344e-02f, -1.19333245e-01f,
  -1.30425105e-02f, 1.84115395e-01f, -4.44382764e-02f, -4.45247330e-02f, 1.95467770e-01f, -3.31660360e-02f, 1.97927877e-02f, 1.35534629e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -6.87572435e-02f, -1.20590590e-02f, -4.49867882e-02f, -3.40562426e-02f, 2.51831591e-01f, -5.02901226e-02f, 1.75041214e-01f, -1.59746148e-02f, -1.23802079e-02f, 2.52402984e-02f,
  6.71774596e-02f, -4.27603461e-02f, 7.12109497e-03f, 3.61476233e-03f, -6.95154443e-02f, 3.99375074e-02f, 1.41717196e-01f, -5.54595776e-02f, -9.96156707e-02f, 1.43875018e-01f,
  -7.12260753e-02f, 1.20643973e-01f, 3.96964401e-02f, 8.17015488e-03f, 8.04322138e-02f, 6.35938942e-02f, 1.68622956e-02f, 1.96769312e-01f, -1.48684280e-02f, 2.21135411e-02f,
  -2.02158783e-02f, -7.30543658e-02f, -3.52996513e-02f, 1.31604150e-01f, 7.41740689e-02f, 1.31095558e-01f, -3.47637571e-02f, 3.21520790e-02f, 1.11199312e-01f, 1.63173690e-01f,
  1.94041669e-01f, 7.60863572e-02f, 5.20851277e-02f, 9.01788622e-02f, 8.24016258e-02f, 2.00685449e-02f, 3.39256898e-02f, 2.19212279e-01f, -3.90160903e-02f, 8.08481500e-02f,
  1.49563044e-01f, 7.08362162e-02f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.81287527e-01f, -2.54659392e-02f, 6.25942573e-02f, -5.80261387e-02f, -1.11831561e-01f, -1.80125967e-01f, 9.94649231e-02f, 6.78071603e-02f, -2.97391582e-02f, 9.25690457e-02f,
  1.23312555e-01f, 2.02995911e-01f, 4.82662171e-02f, -1.08618475e-01f, -6.34928048e-02f, 7.77347609e-02f, 1.20989054e-01f, 1.58048630e-01f, -5.09531945e-02f, -5.51095679e-02f,
  -1.56472884e-02f, -1.14110023e-01f, -1.35133430e-01f, -8.79453719e-02f, 7.62310922e-02f, -1.09698549e-01f, 1.64711028e-01f, 9.55560710e-03f, -7.84767345e-02f, 1.46034345e-01f,
  2.48261727e-02f, 2.04313904e-01f, -1.03256971e-01f, -1.57337427e-01f, -1.38479516e-01f, -1.19503833e-01f, -4.95381393e-02f, -8.21460485e-02f, 1.98359918e-02f, 1.78914756e-01f,
  9.18302760e-02f, -9.39777642e-02f, -2.58724801e-02f, 1.31603017e-01f, -1.18841738e-01f, 1.07551599e-02f, 1.96959637e-02f, 2.27308258e-01f, 5.97156361e-02f, -1.15586579e-01f,
  5.25410548e-02f, -1.59330666e-02f, 1.60626441e-01f, 1.22330531e-01f, 5.40184006e-02f, -6.02276064e-02f, -1.03562407e-03f, 1.03415214e-01f, -4.59950976e-02f, 8.28247666e-02f,
  1.06748432e-01f, -1.58846587e-01f, 1.40530348e-01f, -1.93414658e-01f, 7.27936327e-02f, 1.14668533e-01f, 3.77174430e-02f, -8.72110054e-02f, -1.73869163e-01f, -5.59156649e-02f,
  -5.17383814e-02f, 3.41905691e-02f, 1.57906339e-02f, -1.09122708e-01f, -1.73854098e-01f, 9.30777751e-03f, -1.69978049e-02f, 2.54850611e-02f, -3.31078321e-02f, -8.46511722e-02f,
  1.68124795e-01f, 1.57322079e-01f, 6.78825527e-02f, -3.31967361e-02f, -1.09837800e-01f, -3.47502381e-02f, 8.15188885e-02f, 5.20350598e-03f, 4.37683091e-02f, -4.11280394e-02f,
  -9.57357064e-02f, 6.54261326e-03f, -6.82854876e-02f, -5.32387793e-02f, 8.42489004e-02f, 4.25986461e-02f, -6.29312843e-02f, -1.64379310e-02f, 4.80111130e-02f, -9.09312144e-02f,
  -5.81928529e-02f, -1.21025227e-01f, 1.06118754e-01f, -7.52435476e-02f, -1.42538577e-01f, -2.66668558e-01f, -8.31186958e-03f, -1.17991939e-02f, 3.14721726e-02f, 2.20940813e-01f,
  -1.13876954e-01f, -1.74754322e-01f, -2.49932948e-02f, -1.82930619e-01f, -1.77799284e-01f, -1.29210368e-01f, 1.34644285e-01f, 4.44907164e-05f, 1.16565160e-01f, -7.34291002e-02f,
  1.33406594e-01f, -1.31898791e-01f, -1.21648781e-01f, 8.53608735e-03f, -2.05219649e-02f, 1.79856077e-01f, 8.72745141e-02f, 3.92502472e-02f, 5.23205101e-02f, 1.11914888e-01f,
  1.64748952e-01f, 4.38816398e-02f, 1.09550238e-01f, 2.17348352e-01f, 1.69312194e-01f, 9.42239091e-02f, 1.31801099e-01f, 7.64662772e-02f, 1.39649123e-01f, 1.58664361e-01f,
  -3.06937546e-02f, 7.38985762e-02f, 8.23202357e-02f, 1.11052729e-01f, -7.55081177e-02f, 1.14597775e-01f, -5.18981107e-02f, 1.44408137e-01f, -1.03096232e-01f, -1.35989681e-01f,
  -3.51331718e-02f, -3.46233509e-02f, 1.07017331e-01f, 1.16567001e-01f, -2.06269091e-03f, -1.47386556e-02f, 5.53144701e-02f, 1.20635167e-01f, -7.71626756e-02f, 2.27997005e-01f,
  -2.81042513e-02f, 5.08684851e-03f, -1.19618937e-01f, 1.41894474e-04f, -1.65722147e-02f, 1.77143395e-01f, 1.39343571e-02f, 9.63261425e-02f, 5.08385412e-02f, 1.55841142e-01f,
  4.92415726e-02f, -2.68601235e-02f, -4.51614596e-02f, -1.38981551e-01f, -1.22629814e-01f, 6.83013815e-03f, -1.09294876e-01f, 2.30073258e-01f, 8.40035442e-04f, 5.58874682e-02f,
  6.17077574e-02f, 1.99130461e-01f, -1.32531732e-01f, 3.17890756e-02f, -1.44375324e-01f, -9.55319181e-02f, 1.42943963e-01f, -9.93936136e-02f, -6.61438406e-02f, -2.34098434e-01f,
  8.58258978e-02f, -6.29647374e-02f, 1.92777917e-01f, 1.52395964e-01f, -4.93924879e-03f, -1.34190410e-01f, 3.78439873e-02f, 5.99355884e-02f, -2.36317202e-01f, 9.50587243e-02f,
  -1.82677269e-01f, -2.54707456e-01f, -2.19907299e-01f, -2.45286912e-01f, -5.01317112e-03f, 1.41296819e-01f, 1.20474726e-01f, -6.17820993e-02f, -1.13262452e-01f, -1.28306508e-01f,
  -1.10564314e-01f, 1.48151005e-02f, 1.66514218e-01f, -8.51281583e-02f, 2.42649559e-02f, 8.78844783e-02f, 2.61017140e-02f, 3.73863392e-02f, 2.36004889e-02f, -7.29885548e-02f,
  6.71759397e-02f, 3.12593095e-02f, 7.79045224e-02f, -2.09451109e-01f, 9.60403308e-02f, 1.50054410e-01f, -2.32616141e-02f, 5.43203205e-02f, -1.99810684e-01f, -2.02825099e-01f,
  -1.87230453e-01f, -1.10965624e-01f, -6.99507371e-02f, 2.64940530e-01f, -8.89833868e-02f, 8.55278596e-02f, 1.68689564e-01f, 2.22593620e-01f, 1.40476614e-01f, -1.25224054e-01f,
  1.14139467e-01f, -6.54990785e-03f, -1.35896951e-01f, 2.23525725e-02f, -2.49778152e-01f, -3.96424085e-02f, -6.10984117e-02f, -1.59637526e-01f, 2.99172141e-02f, -3.08898836e-02f,
  4.37365919e-02f, -3.51067707e-02f, 7.92861450e-03f, -3.90846021e-02f, 7.26048872e-02f, 2.21750587e-01f, 4.24661078e-02f, 3.12632285e-02f, 6.69256374e-02f, -1.89146295e-01f,
  -7.36185610e-02f, 9.90312025e-02f, -9.49895978e-02f, 1.72085509e-01f, -3.27053927e-02f, 7.76513591e-02f, -1.16714761e-01f, 1.63395882e-01f, 1.05467990e-01f, -9.85154659e-02f,
  -1.42669247e-03f, 9.84313488e-02f, 1.08861446e-01f, -5.17596751e-02f, -1.85551867e-01f, -1.06715038e-01f, 1.42772332e-01f, -4.07002158e-02f, 2.00323611e-01f, 4.31854725e-02f,
  5.97471297e-02f, 9.83172730e-02f, -3.11077293e-02f, -1.11735454e-02f, -6.76942989e-02f, -1.75408442e-02f, -8.02451894e-02f, -1.06944539e-01f, 8.19235742e-02f, -9.06894654e-02f,
  -1.45009935e-01f, -2.42039431e-02f, -1.30252630e-01f, -6.76659122e-03f, -6.72767311e-02f, 9.18991342e-02f, 5.55233508e-02f, -1.78443938e-02f, 3.71384397e-02f, 9.79127064e-02f,
  -7.38138035e-02f, 9.45266560e-02f, -8.88152048e-02f, -9.94724706e-02f, 1.19363494e-01f, -2.89955698e-02f, 1.25346974e-01f, -1.09305657e-01f, -9.22653824e-02f, -5.69118092e-05f,
  1.17504470e-01f, 1.24978766e-01f, 1.22594006e-01f, -7.83839449e-02f, -1.91892102e-01f, 3.62658710e-03f, -7.45387971e-02f, 1.69987381e-01f, 1.27517924e-01f, 8.49413350e-02f,
  2.16291994e-01f, 1.35794178e-01f, 7.61352628e-02f, 3.16604003e-02f, 1.59698814e-01f, 1.95003971e-01f, -1.14902586e-01f, 6.88782930e-02f, 2.25607660e-02f, -8.41405615e-02f,
  -1.52633369e-01f, -1.65315762e-01f, 9.47593749e-02f, 1.88823268e-01f, 5.66966236e-02f, -7.96108041e-03f, -4.49419059e-02f, -1.69285893e-01f, -1.65506992e-02f, 3.02809794e-02f,
  6.52755275e-02f, 1.82562079e-02f, 1.41711086e-02f, 1.90889481e-02f, -1.44181773e-01f, -9.59471166e-02f, -8.46351385e-02f, 9.15476084e-02f, 5.80528304e-02f, -7.43191689e-02f,
  1.78954042e-02f, -1.55889511e-01f, -7.18287528e-02f, 1.48829713e-01f, -1.05779901e-01f, -1.78531057e-03f, -1.15143374e-01f, -1.13088168e-01f, -7.58782476e-02f, -3.02483998e-02f,
  5.76189645e-02f, 1.21356234e-01f, -1.44612804e-01f, 7.20062479e-02f, 7.94394240e-02f, 1.94381118e-01f, 3.78586836e-02f, -6.85695792e-03f, -1.71834510e-02f, 3.03227790e-02f,
  -3.42039466e-02f, 4.37741764e-02f, -1.31377950e-01f, -6.87915310e-02f, -1.80786196e-02f, -1.13647627e-02f, 3.57362963e-02f, 6.60851644e-03f, -1.20316505e-01f, 6.46704584e-02f,
  -8.55159238e-02f, 1.05758928e-01f, -1.31223574e-01f, 1.04602650e-01f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  4.23114337e-02f, -3.83288004e-02f, 9.39420611e-02f, 1.19889788e-01f, -4.41991575e-02f, 4.55640592e-02f, 8.64755586e-02f, -1.90823019e-01f, 1.64250746e-01f, 1.09139480e-01f,
  2.08303615e-01f, 8.59200303e-03f, 1.55280292e-01f, 7.65174553e-02f, 9.51857418e-02f, -1.07723087e-01f, -1.41390547e-01f, -6.71585053e-02f, 1.36907399e-01f, 1.89388499e-01f,
  -4.37809229e-02f, -1.31225318e-01f, -2.17876062e-01f, -1.17433682e-01f, 3.88665311e-02f, -5.14718965e-02f, 5.85736148e-02f, 3.88436690e-02f, -2.42949445e-02f, -9.77223814e-02f,
  1.19778976e-01f, 1.00219391e-01f, -1.51506454e-01f, -1.39798922e-02f, -3.85950506e-02f, 1.21822245e-01f, 1.20210394e-01f, 1.67487949e-01f, -1.54782444e-01f, 8.02998198e-04f,
  -1.42438326e-03f, 2.01784953e-01f, 7.98110813e-02f, 9.93374288e-02f, 7.58642852e-02f, -3.68210562e-02f, -1.04425497e-01f, -1.84076261e-02f, -3.18950564e-02f, -1.26927309e-02f,
  8.98157991e-03f, -1.37704998e-01f, 7.77202621e-02f, 2.92498946e-01f, -1.34552956e-01f, 1.62452050e-02f, 2.81575229e-02f, -1.13070067e-02f, 8.29564556e-02f, 8.62393528e-02f,
  6.09385669e-02f, -6.25579432e-02f, 4.93570231e-02f, 4.87079769e-02f, 1.25577971e-01f, -1.99447013e-02f, 7.67095983e-02f, 4.62708734e-02f, 5.79783171e-02f, -1.00718029e-01f,
  6.51291921e-04f, -7.48845041e-02f, 3.42249358e-03f, 1.45053668e-02f, -4.23439629e-02f, 9.67339985e-03f, -1.06911957e-01f, 1.13460124e-01f, 6.88426346e-02f, -5.13243712e-02f,
  1.28152743e-01f, 9.93034840e-02f, 7.71802217e-02f, 1.85333081e-02f, 2.91300323e-02f, -1.24163483e-03f, 8.74207020e-02f, 3.59147079e-02f, -9.63401571e-02f, 9.79913473e-02f,
  1.10347018e-01f, -2.27029361e-02f, -5.15753441e-02f, 1.47511670e-02f, 3.59186791e-02f, -3.57772969e-02f, -3.77092995e-02f, 6.68279007e-02f, 1.20366342e-01f, 8.97430629e-02f,
  3.93780917e-02f, 8.91927183e-02f, -2.65093390e-02f, 4.45408821e-02f, -3.51198018e-02f, -8.72850046e-02f, -7.04365894e-02f, -1.29060015e-01f, 6.35569394e-02f, 7.86742195e-02f,
  8.81709754e-02f, -9.15924311e-02f, 5.05065583e-02f, -1.53390810e-01f, 4.64482307e-02f, -4.14830111e-02f, -9.44957696e-03f, -4.79112938e-02f, 8.35181624e-02f, -1.25629753e-01f,
  1.65331855e-01f, -9.92490649e-02f, -1.12561859e-01f, 1.84422033e-03f, 1.00400321e-01f, 1.52178377e-01f, -4.57375636e-03f, 8.37500766e-03f, 1.15269618e-02f, 1.99019074e-01f,
  8.54815692e-02f, 4.36590835e-02f, 1.14475332e-01f, -7.73890503e-03f, 8.72399881e-02f, 3.69602628e-02f, 1.15944847e-01f, -1.24509901e-01f, -2.79893689e-02f, -1.00575492e-01f,
  -1.30051628e-01f, -1.22273425e-02f, -7.31219351e-02f, -6.31109104e-02f, 3.46897803e-02f, 6.54761493e-02f, 1.98738687e-02f, -7.27753639e-02f, -1.27908841e-01f, -7.67404214e-02f,
  -7.35230893e-02f, 2.15583597e-04f, -1.07405238e-01f, -4.61959019e-02f, -1.23987488e-01f, -6.14719291e-04f, -4.34443280e-02f, -5.51299229e-02f, 5.13834357e-02f, -3.84106152e-02f,
  1.09242380e-01f, 2.26472408e-01f, 1.23540752e-01f, -1.36386320e-01f, 3.97603475e-02f, -7.67092407e-02f, 8.26692283e-02f, -3.06077786e-02f, -4.93893474e-02f, 7.60823935e-02f,
  -2.92113852e-02f, 1.70837659e-02f, 2.81965546e-02f, -5.34171462e-02f, 1.08033657e-01f, -4.55638729e-02f, -1.91729870e-02f, 2.65797824e-02f, 1.11552812e-01f, -5.88270952e-04f,
  -9.52198952e-02f, 2.30731294e-02f, -1.24354810e-01f, 3.92377414e-02f, 3.97959165e-02f, -1.23531744e-01f, 1.73990592e-01f, -9.47359279e-02f, -7.18920082e-02f, -8.53873864e-02f,
  1.57952495e-02f, 1.52275473e-01f, 1.82560869e-02f, 2.84422189e-02f, -1.18071446e-02f, 1.78465277e-01f, -1.97427534e-02f, 1.42332882e-01f, 9.38294530e-02f, 1.14172451e-01f,
  7.01182187e-02f, 8.61567631e-02f, 7.59281814e-02f, 1.53838731e-02f, 1.12994991e-01f, 1.46235675e-01f, -8.47866014e-02f, 5.03728092e-02f, 4.88684699e-02f, 6.49791285e-02f,
  1.09061241e-01f, 1.37007713e-01f, -2.10931096e-02f, -1.31489590e-01f, 6.33409694e-02f, -2.76321024e-02f, -1.01473719e-01f, -9.38147604e-02f, -8.11910853e-02f, -2.90414840e-02f,
  -5.84370829e-02f, -8.91893581e-02f, -1.36459813e-01f, 2.62524970e-02f, -1.29146904e-01f, -1.03520937e-01f, -3.25134248e-02f, 1.17755651e-01f, -4.91132028e-02f, 1.53133735e-01f,
  -1.15554728e-01f, -7.24493712e-03f, 1.61466688e-01f, 1.47154644e-01f, -1.09435201e-01f, 1.04399249e-01f, 1.06282815e-01f, 2.10832506e-01f, -8.38891715e-02f, 9.19455066e-02f,
  1.26776382e-01f, -1.38557404e-02f, -7.49972016e-02f, 9.46482792e-02f, -1.06057823e-01f, 6.84572682e-02f, -3.43222916e-02f, 1.16268732e-01f, 3.66446655e-03f, -4.04708982e-02f,
  1.19729772e-01f, 6.24974892e-02f, -5.44624664e-02f, -9.84162688e-02f, -1.00067884e-01f, 8.98666382e-02f, -1.51605591e-01f, -1.42952234e-01f, -7.29255676e-02f, -3.17421407e-02f,
  -7.92554766e-02f, -1.42626390e-01f, 1.22883007e-01f, -1.90242067e-01f, -2.01243511e-03f, -7.90603384e-02f, -4.06804308e-02f, 6.45166934e-02f, 8.31201747e-02f, 6.53180182e-02f,
  -3.46694812e-02f, -6.20936463e-03f, 3.48446853e-02f, 7.86989182e-02f, 4.86352071e-02f, 1.30799159e-01f, 9.37358439e-02f, -7.20205009e-02f, -3.73483375e-02f, -2.35549696e-02f,
  6.20180927e-02f, 1.48918061e-02f, -6.84095500e-03f, 1.19486928e-01f, 9.80588645e-02f, 5.34853451e-02f, 4.85706665e-02f, 1.49768084e-01f, -6.34699315e-02f, 3.20159756e-02f,
  -2.29233922e-03f, 1.21320426e-01f, -7.41615370e-02f, -6.49835318e-02f, 3.63150495e-03f, 9.07513276e-02f, -1.11605868e-01f, -1.50701687e-01f, 7.59585500e-02f, 5.43049024e-03f,
  8.76203552e-02f, 9.56906229e-02f, 4.78953160e-02f, 1.17871046e-01f, 7.69037381e-02f, -4.15865071e-02f, 8.76772329e-02f, -3.67579684e-02f, 1.81946754e-01f, 2.23880872e-01f,
  7.94115365e-02f, 4.32569608e-02f, 4.02829424e-03f, 2.50982605e-02f, 9.97355729e-02f, 2.51246691e-01f, -1.82934001e-03f, -5.95144182e-02f, 3.45186666e-02f, 6.74539879e-02f,
  7.09107518e-02f, 6.13871291e-02f, 2.19558757e-02f, -3.56978513e-02f, -1.52084064e-02f, 1.93664744e-01f, 2.23478694e-02f, -3.88351195e-02f, -4.68670577e-02f, 1.03095807e-01f,
  -1.65944379e-02f, -4.91376296e-02f, 1.04413472e-01f, 1.65428162e-01f, -5.49101233e-02f, 3.61745217e-04f, -1.35303691e-01f, 1.40190244e-01f, -4.62597013e-02f, 2.48554125e-02f,
  -6.17899932e-02f, 6.92404509e-02f, -5.90699948e-02f, 5.04467078e-02f, 2.70411726e-02f, -1.01477832e-01f, 7.68615827e-02f, 6.15085140e-02f, 1.37265384e-01f, -8.00644159e-02f,
  -6.42819330e-02f, 2.30652079e-01f, -8.00959542e-02f, 3.96410786e-02f, 5.69342114e-02f, 1.70241520e-01f, 1.96903825e-01f, 1.40670732e-01f, -9.44195092e-02f, 8.76437426e-02f,
  -4.55015786e-02f, 1.74620464e-01f, 2.78243460e-02f, 1.02599584e-01f, 1.03169866e-01f, -4.11818847e-02f, 4.64169011e-02f, 1.56824693e-01f, -1.34824634e-01f, 4.89528589e-02f,
  -7.17334449e-02f, -2.42085215e-02f, 8.56394991e-02f, 1.06430009e-01f, 5.68287335e-02f, 1.26216769e-01f, -1.28062181e-02f, -9.75630581e-02f, 1.50961757e-01f, -1.07857615e-01f,
  3.25655378e-02f, -1.16944291e-01f, -4.19270173e-02f, -2.69519202e-02f, 6.10980354e-02f, 2.07364820e-02f, 1.58930331e-01f, 1.85937971e-01f, 2.32599508e-02f, 1.49314880e-01f,
  -1.77787036e-01f, -8.27726349e-02f, -6.29992113e-02f, -1.60480380e-01f, -2.49552265e-01f, 2.40885019e-01f, -8.11843053e-02f, 1.85043272e-02f, 1.16237462e-01f, -1.38631761e-01f,
  1.95285529e-01f, -4.31136414e-02f, 1.36381507e-01f, -1.70359492e-01f, -7.71721825e-02f, 1.46357119e-01f, -2.03449628e-03f, -7.83203319e-02f, -5.82057871e-02f, 8.25114697e-02f,
  -7.14722276e-02f, -6.68463632e-02f, -1.24920487e-01f, 2.65310854e-02f, -1.20746478e-01f, -8.10869969e-03f, -9.85656008e-02f, 1.09678566e-01f, -2.03571245e-02f, 3.89352441e-02f,
  -6.95393234e-02f, 1.49114747e-02f, 1.37443334e-01f, 2.82333940e-02f, -1.58352666e-02f, 3.42870802e-02f, 9.90543664e-02f, -5.01267463e-02f, 1.31975919e-01f, 2.82609910e-01f,
  7.92570710e-02f, -1.18640386e-01f, 1.48549257e-02f, -2.01955829e-02f, 7.20760897e-02f, -8.29167664e-02f, 3.89215983e-02f, -7.57899657e-02f, -9.10134539e-02f, -8.91461596e-02f,
  1.40212357e-01f, -3.74643244e-02f, -1.99826360e-01f, 2.21251249e-01f, 1.55520681e-02f, 2.08462641e-01f, 3.31879444e-02f, -4.26307023e-02f, 3.71471383e-02f, 6.62407232e-03f,
  1.18019588e-01f, -7.00748013e-03f, 1.72278494e-01f, 1.62973419e-01f, -4.76170965e-02f, -1.20374151e-02f, 8.06106329e-02f, 1.27585113e-01f, -1.79641396e-02f, 1.36109397e-01f,
  -8.03793955e-04f, 6.38006479e-02f, 1.22865729e-01f, 6.96157068e-02f, -2.91948933e-02f, -5.82122616e-02f, 9.54258069e-02f, 5.79762682e-02f, -1.01172991e-01f, -5.18965386e-02f,
  2.86276117e-02f, -5.35828471e-02f, -7.54231736e-02f, 2.95772925e-02f, -4.76443507e-02f, -6.19155094e-02f, 5.35619147e-02f, 1.12755904e-02f, 8.65143463e-02f, -1.47047207e-01f,
  -7.65189296e-03f, 1.57283247e-02f, -9.23841074e-02f, -1.27249118e-02f, -2.04561725e-02f, 5.22695109e-02f, -1.24696054e-01f, -2.79433280e-02f, 4.63986807e-02f, 2.12100327e-01f,
  5.23623405e-03f, 1.25796914e-01f, 9.88500863e-02f, 6.96584061e-02f, 7.48957992e-02f, 1.33678332e-01f, 1.72324628e-02f, 7.17201158e-02f, 2.49281656e-02f, -6.47455677e-02f,
  1.04954781e-03f, 1.33842587e-01f, -1.68684274e-02f, 7.40823746e-02f, -3.71964127e-02f, -6.86077327e-02f, -3.09884679e-02f, -5.61712906e-02f, -7.16584027e-02f, 4.13112454e-02f,
  -1.04225069e-01f, 1.23353921e-01f, 7.17325360e-02f, -8.81684870e-02f, -3.27045023e-02f, 9.76007134e-02f, -8.58904980e-03f, 1.43645197e-01f, 4.92540002e-02f, -1.71693370e-01f,
  1.19723380e-01f, -9.26341340e-02f, 1.92022115e-01f, -9.26213786e-02f, 5.11946827e-02f, 1.67366311e-01f, -2.07220074e-02f, 5.72161889e-03f, -9.33978334e-02f, 1.78334478e-03f,
  7.84215778e-02f, 6.71655610e-02f, -8.58787820e-02f, -7.89821446e-02f, -6.10744543e-02f, -7.73050562e-02f, -7.63760582e-02f, -4.55763564e-03f, -1.07235290e-01f, -2.83620809e-03f,
  1.25584930e-01f, 9.81372781e-03f, 2.64002662e-02f, 2.75442395e-02f, -8.07569697e-02f, 2.67185271e-03f, 1.65478423e-01f, 1.28558770e-01f, -5.31093851e-02f, 2.60740399e-01f,
  -1.27656981e-01f, -1.15920484e-01f, -6.04237691e-02f, 1.54744923e-01f, -7.88657740e-02f, 6.06726781e-02f, -1.03863582e-01f, -1.11844897e-01f, 5.35595454e-02f, 1.16055414e-01f,
  -1.99232083e-02f, -6.98746219e-02f, 5.76300919e-03f, -4.96030264e-02f, -1.16705187e-01f, 1.30844817e-01f, -8.85435939e-03f, 3.16044837e-02f, 9.12677199e-02f, -9.36831683e-02f,
  1.43469676e-01f, -9.85519737e-02f, -6.85646012e-02f, 7.79234245e-02f, 6.30796030e-02f, -6.32573888e-02f, -1.11252315e-01f, -3.00521646e-02f, -8.71095359e-02f, 1.86016895e-02f,
  -5.89537062e-02f, 7.01982901e-02f, -2.86238119e-02f, -1.40467003e-01f, -1.00379316e-02f, -4.23529260e-02f, -1.75512396e-02f, -9.04580504e-02f, 1.31046996e-01f, -7.95319602e-02f,
  1.03580482e-01f, -1.06599167e-01f, -9.67511758e-02f, -1.36724606e-01f, 7.79492110e-02f, -1.02928668e-01f, 9.61963832e-02f, 1.23410881e-01f, 2.37484545e-01f, 1.25716239e-01f,
  9.16434228e-02f, 2.28216662e-03f, 1.16749652e-01f, -1.01977371e-01f, -6.99280947e-02f, 5.17685227e-02f, -9.41857323e-02f, 3.02870840e-01f, -1.89261492e-02f, 8.21122676e-02f,
  -5.22407740e-02f, -4.69033793e-02f, 7.30196759e-02f, 1.60226941e-01f, 9.82834175e-02f, -1.06391869e-01f, 1.44043341e-01f, 2.30445154e-02f, -4.39509377e-02f, -8.54146555e-02f,
  5.73061705e-02f, -5.93966655e-02f, -4.46199626e-02f, 2.09379289e-03f, -5.89926243e-02f, 2.38218859e-01f, 8.26515183e-02f, -5.76224811e-02f, 5.68799004e-02f, 1.43068716e-01f,
  -9.30773839e-02f, 1.07420385e-01f, 6.87339380e-02f, 1.19809106e-01f, 1.83413222e-01f, 9.14471969e-03f, 4.16707955e-02f, -1.03724264e-01f, -1.15891203e-01f, -3.60468812e-02f,
  -7.77227432e-02f, 9.69546065e-02f, -8.49413276e-02f, -7.12101460e-02f, -1.41607225e-01f, 1.09448053e-01f, -2.37390056e-01f, 6.91629425e-02f, -2.54930854e-01f, -1.90879613e-01f,
  -2.63841331e-01f, -2.43158098e-02f, -3.26019228e-02f, -1.20961539e-01f, -3.13961093e-04f, -4.83958684e-02f, 2.20960692e-01f, 1.11234158e-01f, -1.85406078e-02f, -1.53272292e-02f,
  -9.28604156e-02f, 5.87546416e-02f, 2.69831419e-01f, 5.56879863e-02f, 5.63545600e-02f, 2.90245600e-02f, 6.28464520e-02f, 1.45587504e-01f, -1.19568586e-01f, 4.24370356e-02f,
  7.14737326e-02f, 1.25242574e-02f, 1.15741193e-01f, 1.53931633e-01f, 4.44099009e-02f, -1.14925101e-01f, -5.80090880e-02f, 4.03002352e-02f, 1.18674733e-01f, -3.43738273e-02f,
  7.55328238e-02f, -1.52475089e-01f, -4.12826613e-02f, 4.91200164e-02f, -3.16506773e-02f, 4.07165319e-01f, 7.14121759e-02f, -6.34365454e-02f, 2.90204793e-01f, 1.23399310e-01f,
  -1.23068832e-01f, 1.33923562e-02f, 6.19974770e-02f, 6.83713406e-02f, 2.30397597e-01f, -1.89800501e-01f, 2.68169135e-01f, 8.97564292e-02f, 1.58645548e-02f, 1.42041832e-01f,
  2.17062198e-02f, 4.10164624e-01f, -5.27264066e-02f, 1.82829961e-01f, 2.69091874e-01f, 2.32555807e-01f, 3.07964921e-01f, 3.51412982e-01f, 1.17095463e-01f, 4.23562974e-02f,
  2.14691997e-01f, -1.35318831e-01f, -4.52367291e-02f, 9.99365076e-02f, -2.20518693e-01f, 3.33418965e-01f, -8.32899138e-02f, -7.03677982e-02f, 7.74735883e-02f, -5.61838411e-02f,
  3.16903412e-01f, 9.71501917e-02f, 5.13625741e-02f, 1.17740482e-01f, 4.75208722e-02f, 1.04647040e-01f, -2.12561712e-02f, -6.85745180e-02f, -1.41471267e-01f, -2.93109156e-02f,
  -7.97272995e-02f, -1.73467044e-02f, -9.34049860e-02f, -6.71731904e-02f, 1.37640804e-01f, -7.17961043e-02f, -7.62428865e-02f, 4.57993485e-02f, -1.59745201e-01f, 6.40144525e-03f,
  3.15661468e-02f, -3.74427624e-02f, 2.58087456e-01f, 2.31325850e-01f, -1.31157398e-01f, -2.83381753e-02f, 7.71378633e-03f, -7.10970461e-02f, 6.75624702e-03f, 1.23457812e-01f,
  -6.09167330e-02f, 9.94487293e-03f, 4.78596427e-03f, -2.20755011e-01f, -5.12265265e-02f, 4.66333656e-03f, 2.55166143e-01f, 1.68305367e-01f, -1.03219457e-01f, -5.20742871e-03f,
  2.16442987e-01f, 2.01055314e-02f, -9.39035490e-02f, 1.23541906e-01f, 1.67378694e-01f, 3.54273431e-02f, 1.12782292e-01f, -8.12553614e-02f, -5.61540723e-02f, -3.09348349e-02f,
  1.60997491e-02f, 2.26444229e-01f, 3.17126662e-02f, 1.25194252e-01f, -6.17383718e-02f, -9.30720717e-02f, 1.25478983e-01f, -2.87720188e-02f, 2.76412722e-02f, 1.99827880e-01f,
  -1.12952054e-01f, -4.90763411e-02f, 2.59685442e-02f, -9.73367505e-03f, -1.43213887e-02f, -2.80049182e-02f, 2.81448066e-02f, 8.70783255e-02f, 1.09784538e-02f, -8.94705653e-02f,
  4.87046642e-03f, 1.93784125e-02f, -3.12857628e-02f, 1.41281756e-02f, -7.23523647e-02f, 8.84748325e-02f, -1.51003540e-01f, -7.28424489e-02f, -4.51655760e-02f, -7.03180283e-02f,
  -1.06103718e-01f, -3.12441848e-02f, -1.63903646e-02f, 5.95615022e-02f, 4.29326631e-02f, 3.51864323e-02f, 7.62225166e-02f, 9.55565497e-02f, 1.60415933e-01f, -8.27198327e-02f,
  3.31104882e-02f, -1.19754255e-01f, -7.32234269e-02f, 5.26402611e-03f, 3.16656083e-02f, -4.01447527e-02f, -1.13925502e-01f, 9.95677337e-02f, -1.23723879e-01f, -6.97239116e-02f,
  1.50726542e-01f, 1.34406969e-01f, 4.80359048e-02f, -8.39238912e-02f, -6.99214116e-02f, -3.13395113e-02f, 8.76773223e-02f, 7.95129612e-02f, 4.55152877e-02f, -1.17503829e-01f,
  7.23305568e-02f, 6.53889850e-02f, 4.79325838e-02f, -1.54025638e-02f, -4.47631553e-02f, -3.71903293e-02f, -1.02045983e-01f, -5.45619354e-02f, -7.76770562e-02f, 1.37540027e-01f,
  -4.84260581e-02f, -1.23619981e-01f, 1.17174573e-01f, -1.90817446e-01f, 1.11894757e-02f, 1.62470236e-01f, -1.79778710e-02f, 2.67741401e-02f, -3.19797397e-02f, -7.34602287e-02f,
  1.73317090e-01f, -4.15648930e-02f, 1.38191298e-01f, -1.69184599e-02f, 1.56173885e-01f, -3.96596976e-02f, -4.20377254e-02f, -2.21367683e-02f, -4.82566245e-02f, 9.89756510e-02f,
  1.78721637e-01f, -3.20594646e-02f, -1.07994914e-01f, -4.46192883e-02f, -5.59561029e-02f, 8.81959051e-02f, -5.50861582e-02f, 8.11661556e-02f, -3.50714624e-02f, 1.26958564e-02f,
  -7.77919814e-02f, 6.25345409e-02f, 1.98834702e-01f, 7.13181123e-02f, 1.47476541e-02f, -1.69418454e-02f, 8.86668451e-03f, 8.09863769e-03f, -7.75916725e-02f, -1.03076063e-01f,
  -3.80597226e-02f, -1.12438165e-01f, -1.15068331e-02f, -9.49738722e-04f, 1.02271646e-01f, -1.43673375e-01f, 1.38676926e-01f, 6.51770681e-02f, -1.22082293e-01f, -8.74509811e-02f,
  1.71212599e-01f, 1.91770084e-02f, -1.21534131e-01f, -8.58137459e-02f, 7.35005513e-02f, 1.68730363e-01f, 9.75508615e-02f, 9.75893587e-02f, -4.55357544e-02f, 1.57479107e-01f,
  5.37437983e-02f, 1.29526258e-01f, -1.08743355e-01f, -3.00280172e-02f, 1.64230708e-02f, -2.48601045e-02f, 1.00288063e-01f, -3.44850756e-02f, 7.15334117e-02f, 6.94994926e-02f,
  4.06090952e-02f, 1.41612049e-02f, -1.54715016e-01f, -3.53598334e-02f, -1.46992505e-02f, -1.81029867e-02f, 5.33584990e-02f, -2.05426048e-02f, 1.13291368e-01f, 1.21370919e-01f,
  9.10534617e-03f, 1.00535847e-01f, 2.93663926e-02f, -1.03445202e-01f, -3.78350802e-02f, 2.50932463e-02f, -6.51785955e-02f, 9.75700393e-02f, -3.86232790e-03f, 1.01496622e-01f,
  7.46491626e-02f, -1.03856660e-01f, 9.81672257e-02f, 6.54619038e-02f, -8.54046270e-02f, 1.16098495e-02f, 1.26668483e-01f, 1.53450683e-01f, 6.01896867e-02f, -4.40079439e-03f,
  3.57478745e-02f, -2.19085999e-02f, -7.39054009e-02f, 5.09078018e-02f, -9.94496718e-02f, -6.08754857e-03f, 1.48334503e-01f, 8.58059078e-02f, 3.33165862e-02f, 1.30318984e-01f,
  5.60729280e-02f, -3.67448037e-03f, -1.12006009e-01f, -3.79266739e-02f, 8.74770340e-03f, -1.21943347e-01f, -5.21453805e-02f, -1.04203612e-01f, -3.97049338e-02f, 1.53136909e-01f,
  9.70954001e-02f, -1.05053984e-01f, 2.94459779e-02f, 4.84471843e-02f, -6.19845018e-02f, -8.55093300e-02f, 2.57232562e-02f, -1.13629282e-03f, -9.84307379e-02f, 1.35878384e-01f,
  -3.64564992e-02f, 1.30512089e-01f, 6.15133122e-02f, 7.88816586e-02f, -1.05711997e-01f, -4.43231016e-02f, -7.91496783e-02f, 3.84556502e-02f, -9.33167860e-02f, -8.70717317e-02f,
  8.55546910e-03f, -4.19040918e-02f, 1.30880371e-01f, -2.10764967e-02f, 1.91722717e-02f, 1.42229035e-01f, 7.07208589e-02f, -1.04663476e-01f, 1.28241450e-01f, 8.82535949e-02f,
  -9.36810523e-02f, 8.54067504e-02f, -9.70025063e-02f, -2.28297804e-02f, 3.47156040e-02f, 1.08250923e-01f, 4.01189663e-02f, -8.64375569e-03f, 5.85558936e-02f, 1.07006468e-01f,
  -1.17867291e-02f, 6.02881387e-02f, 3.02453376e-02f, 1.85176246e-02f, -6.88499063e-02f, 1.60892121e-02f, -1.19547412e-01f, 1.28245782e-02f, -4.65213433e-02f, -3.55493799e-02f,
  8.32997411e-02f, 2.15897001e-02f, -6.82143047e-02f, -5.21292649e-02f, 7.53297354e-04f, -2.09815484e-02f, 4.09969352e-02f, 1.20845720e-01f, 2.56222356e-02f, 1.09377168e-01f,
  4.80492897e-02f, 6.21370114e-02f, 8.95161852e-02f, -1.37048900e-01f, 3.72058630e-01f, 2.17596918e-01f, 4.10896033e-01f, 3.43306094e-01f, 1.93562284e-01f, 4.55174714e-01f,
  -2.19454065e-01f, -7.88605809e-02f, 5.09032942e-02f, -1.56680346e-01f, -2.93433398e-01f, 1.78914875e-01f, -1.12118274e-02f, 1.79603830e-01f, 1.00799471e-01f, -1.09758340e-01f,
  1.40982509e-01f, -1.14870973e-01f, 8.39028060e-02f, -1.63340732e-01f, 4.15546335e-02f, -3.63364741e-02f, 1.87831193e-01f, -5.43585643e-02f, -1.44929200e-01f, 3.13989669e-02f,
  -9.04065073e-02f, 4.10055295e-02f, 1.82802409e-01f, -8.20834488e-02f, -7.81894177e-02f, -1.30090460e-01f, 7.42587298e-02f, 4.01711673e-01f, -6.16240548e-03f, 4.82382514e-02f,
  -1.09406151e-01f, 1.90879360e-01f, 9.99110639e-02f, -1.96794048e-01f, 4.04313356e-02f, 1.12790346e-01f, -5.12700193e-02f, -9.77312773e-02f, -4.78555262e-02f, 5.88431954e-01f,
  -6.23093406e-03f, -1.77143604e-01f, 1.19162619e-01f, 7.12523935e-03f, 5.66474581e-03f, 1.89503282e-01f, -7.58159310e-02f, -1.61315516e-01f, 1.04879878e-01f, 1.19343348e-01f,
  1.94128469e-01f, -7.24828392e-02f, 1.13147467e-01f, -1.21216528e-01f, -1.45313501e-01f, 1.70118973e-01f, -6.78435117e-02f, 2.62343794e-01f, 9.68389735e-02f, 5.15593495e-03f,
  1.27450615e-01f, 4.90823993e-03f, -5.38069122e-02f, 1.80219114e-01f, -2.08019763e-02f, -1.20818214e-02f, 8.77031535e-02f, 2.04525203e-01f, 1.29453942e-01f, 1.51867568e-01f,
  4.78516240e-03f, 7.02405348e-02f, -1.31307412e-02f, -6.94740191e-02f, -2.88987216e-02f, -1.58030704e-01f, 8.15183446e-02f, 3.21511962e-02f, -6.10952340e-02f, -1.14875324e-01f,
  -5.10936938e-02f, 1.29104361e-01f, 7.59419873e-02f, 3.09767723e-02f, 4.45144735e-02f, 6.88257888e-02f, -2.70249639e-02f, 3.96430157e-02f, -3.56801264e-02f, 1.52703196e-01f,
  -7.77339861e-02f, 6.48217567e-04f, -1.82415470e-02f, 8.17061514e-02f, 1.23737909e-01f, 8.54837745e-02f, 1.63285099e-02f, 8.12359974e-02f, 4.25900565e-03f, 2.20727190e-01f,
  2.79585999e-02f, -8.82935673e-02f, 6.30385205e-02f, 9.01601091e-02f, -2.31828094e-02f, 1.90127686e-01f, -8.37352797e-02f, 2.33378112e-01f, 1.63817957e-01f, 7.27294770e-04f,
  -1.97963342e-01f, 2.04193577e-01f, -1.40170500e-01f, 1.65443301e-01f, -3.58484350e-02f, -7.58633167e-02f, -1.33820295e-01f, 2.40319339e-03f, -1.29286841e-01f, 7.31429756e-02f,
  -5.71231507e-02f, -9.86529514e-02f, -1.96035475e-01f, 2.37286445e-02f, 3.53688225e-02f, 1.38648361e-01f, 2.89117917e-03f, 5.04615381e-02f, 1.57021746e-01f, -1.27409741e-01f,
  -7.93269873e-02f, -4.91843522e-02f, 1.30847052e-01f, -2.14203596e-02f, -4.97057401e-02f, 6.75601214e-02f, -1.70064822e-03f, 1.35940641e-01f, 2.64732316e-02f, 1.65363252e-01f,
  1.65703118e-01f, 1.79947138e-01f, 1.22598447e-01f, -1.31663755e-01f, 5.24232462e-02f, 6.66741133e-02f, 1.19120404e-01f, -1.51338369e-01f, -5.74731566e-02f, 1.25819901e-02f,
  -1.03575505e-01f, 7.93184936e-02f, 9.74710882e-02f, -6.68437220e-04f, -4.08095010e-02f, -1.10595487e-02f, -1.14504643e-01f, 3.85194570e-02f, 3.57807651e-02f, 1.79640740e-01f,
  1.13303423e-01f, 7.71977901e-02f, 1.91490158e-01f, 1.15046009e-01f, 5.45662716e-02f, -2.35208496e-02f, -7.93401971e-02f, -1.12707250e-01f, -1.49939861e-02f, 1.39428899e-01f,
  -8.18699133e-03f, 3.18944268e-02f, -1.10641673e-01f, -6.42005354e-02f, 1.29331902e-01f, 2.24393278e-01f, 1.30886108e-01f, 7.17627257e-02f, 1.01763159e-01f, -1.28970489e-01f,
  2.38547325e-01f, 2.63427198e-02f, -7.68532977e-02f, -1.42187178e-01f, -1.09575596e-02f, 1.16466485e-01f, 3.50325793e-01f, 3.04754943e-01f, 1.90297186e-01f, 1.87979773e-01f,
  2.24116176e-01f, 1.08011402e-01f, 1.00905545e-01f, 1.62395313e-02f, 3.86288241e-02f, 8.70759338e-02f, -7.82600939e-02f, 2.99261957e-01f, -1.34204879e-01f, -6.15218431e-02f,
  -7.54953548e-02f, 1.27628148e-01f, 3.12694848e-01f, -8.97584483e-02f, 3.33539844e-02f, 7.07541173e-03f, -4.04442698e-02f, 8.57692361e-02f, 1.91247627e-01f, -1.15726031e-01f,
  -2.17591655e-02f, 3.94798517e-02f, -3.16832699e-02f, 1.29437000e-01f, -1.78160146e-01f, 1.06871892e-02f, -7.35730827e-02f, 2.21784227e-02f, -9.11045372e-02f, -1.49394616e-01f,
  -1.14653595e-01f, -2.72802860e-02f, -1.61034450e-01f, -8.28509033e-02f, 2.12717056e-01f, -2.62082973e-03f, -2.29385849e-02f, -1.12404324e-01f, -4.86249216e-02f, 1.97807569e-02f,
  -5.39067537e-02f, 2.29223102e-01f, -1.17119394e-01f, 2.08800398e-02f, 1.28139690e-01f, -9.20140669e-02f, 1.43004417e-01f, 1.58395156e-01f, -1.00452483e-01f, 1.31894633e-01f,
  2.22996417e-02f, 1.93874642e-01f, 1.29299387e-01f, -1.86487138e-02f, -1.45063177e-01f, 2.51583904e-01f, 8.18179920e-02f, 1.38646007e-01f, 6.09432682e-02f, 1.16837835e-02f,
  -1.39637709e-01f, 7.89826561e-04f, -2.24038358e-05f, 1.14678135e-02f, -1.17374517e-01f, 1.27634674e-01f, 2.90259253e-02f, -5.35360090e-02f, 1.23391394e-02f, -3.02205347e-02f,
  -1.47203915e-02f, -1.68580562e-01f, -1.37272861e-03f, -9.42479149e-02f, -1.49077801e-02f, -1.12581039e-02f, -7.41015896e-02f, -9.39364806e-02f, -1.47504240e-01f, 1.11294843e-01f,
  -8.67767110e-02f, 6.27550632e-02f, 2.72004485e-01f, -5.03409430e-02f, 2.78582666e-02f, -2.75447126e-02f, -2.17470210e-02f, -7.72222951e-02f, 7.49018937e-02f, 9.78295803e-02f,
  -6.13123849e-02f, -1.16083678e-02f, -4.20629308e-02f, 1.22168861e-01f, 1.05888667e-02f, 1.19425252e-01f, 2.17692684e-02f, -4.72827889e-02f, 1.64935455e-01f, 3.58482227e-02f,
  1.37564063e-01f, -1.16611473e-01f, 1.28510579e-01f, -8.86891708e-02f, -9.03935879e-02f, 9.38749313e-02f, -5.17665520e-02f, -1.23089980e-02f, 5.19218706e-02f, 2.31556669e-02f,
  1.02113977e-01f, -1.21209864e-02f, 6.78987131e-02f, 7.12684095e-02f, 1.55545861e-01f, 3.03889830e-02f, 7.26156235e-02f, 1.30239218e-01f, 9.79971513e-02f, -7.06345737e-02f,
  -1.39371008e-01f, 2.02232927e-01f, -8.55642371e-03f, 3.61867845e-02f, 1.96184456e-01f, 2.47215703e-01f, 1.08585209e-01f, 2.32877601e-02f, 1.92772001e-01f, 7.35749453e-02f,
  -2.07519144e-01f, -1.07812341e-02f, -9.82444808e-02f, -3.34905759e-02f, 8.55329912e-03f, -2.31279343e-01f, -1.24118797e-01f, 1.70524627e-01f, 1.56787589e-01f, 1.83152929e-02f,
  -1.24177463e-01f, 1.04686961e-01f, 1.81492195e-01f, -1.06747232e-01f, 1.24494463e-01f, 1.72910560e-02f, 1.10548886e-03f, 5.83627410e-02f, 9.13649276e-02f, -1.01065315e-01f,
  -9.71581638e-02f, -7.34043419e-02f, 1.49602994e-01f, -1.08923636e-01f, -1.21204302e-01f, 6.87775314e-02f, -2.84392275e-02f, 2.20044747e-01f, 3.41393240e-02f, 2.43790094e-02f,
  -4.22587916e-02f, 4.75729443e-02f, -2.31551751e-01f, 4.80258279e-03f, 1.15951784e-01f, 3.10995668e-01f, 1.01289444e-01f, 1.11904122e-01f, 9.67077836e-02f, 2.79328406e-01f,
  -6.60306262e-03f, -7.22458884e-02f, 1.96357304e-03f, 8.42986405e-02f, -1.31744668e-01f, 1.20779492e-01f, 2.85765249e-02f, 5.65712601e-02f, 1.42349541e-01f, -5.99291772e-02f,
  3.08740512e-02f, 3.27398181e-02f, 2.67018676e-01f, -1.94035068e-01f, -5.11525348e-02f, -8.15580711e-02f, -1.00377418e-01f, 3.46411318e-01f, 1.95457395e-02f, 1.57906115e-01f,
  1.31644502e-01f, 2.33777359e-01f, 3.08547840e-02f, 1.73907876e-01f, 7.89945051e-02f, -7.04200286e-03f, 1.33642033e-01f, 7.71401124e-03f, 1.42636299e-01f, 9.92625132e-02f,
  4.77329791e-02f, 2.08631605e-01f, 1.04420111e-01f, -4.47530113e-02f, 2.47553531e-02f, 2.36274935e-02f, 2.12311015e-01f, 7.74585679e-02f, 1.53718352e-01f, 2.76598111e-02f,
  3.23647112e-02f, 1.10356852e-01f, 7.64197931e-02f, -6.13732710e-02f, -1.12003600e-02f, 4.09657881e-02f, 1.09748974e-01f, 1.01712205e-01f, -4.87213880e-02f, -8.87515843e-02f,
  1.02251217e-01f, -1.45824114e-02f, 3.51787060e-02f, -7.60702118e-02f, 2.28227615e-01f, 1.98562905e-01f, -8.21637958e-02f, 3.04974001e-02f, 2.74592012e-01f, 1.68907970e-01f,
  5.74001595e-02f, -1.23845354e-01f, -4.16928763e-03f, 2.39173040e-01f, -1.12141773e-01f, 3.67844738e-02f, -3.60134020e-02f, -6.77187517e-02f, -1.22048907e-01f, -9.43949725e-03f,
  1.11396769e-02f, 1.88502461e-01f, -6.25332892e-02f, 1.51492193e-01f, -1.51931703e-01f, -9.74117368e-02f, 2.33027473e-01f, -5.72066754e-02f, 1.39763147e-01f, -1.87785104e-01f,
  -5.28966039e-02f, 1.79936945e-01f, 6.89206123e-02f, 1.50236145e-01f, 7.43823946e-02f, 2.52708867e-02f, 2.15637431e-01f, 2.37553284e-01f, 8.89037102e-02f, -1.00275651e-01f,
  2.07876980e-01f, -4.09138165e-02f, 2.15872690e-01f, -6.60166889e-02f, 3.94354425e-02f, 1.74793124e-01f, -1.16338558e-01f, 7.21058249e-02f, -2.05347925e-01f, -1.28652692e-01f,
  3.66566144e-02f, 4.45238166e-02f, 4.36107442e-03f, -6.32584393e-02f, -7.67696723e-02f, 1.40066296e-01f, 5.81981987e-03f, -9.26505774e-02f, -7.87276551e-02f, -6.40668720e-02f,
  2.06626281e-01f, -1.08943611e-01f, -1.82285413e-01f, 3.95269580e-02f, 2.96249967e-02f, 1.98826298e-01f, 1.54437542e-01f, -2.51475796e-02f, 7.15109408e-02f, 2.35120773e-01f,
  -1.85271114e-01f, -9.47485790e-02f, 2.11695448e-01f, 1.87692687e-01f, -1.53391674e-01f, 8.55931547e-03f, 7.13898167e-02f, 9.49718207e-02f, -6.01712503e-02f, 1.50465891e-01f,
  4.32447232e-02f, 1.35140661e-02f, -8.05006549e-02f, 2.47220276e-03f, -1.11651577e-01f, 1.62061065e-01f, 3.73631641e-02f, 1.66196436e-01f, -1.68460011e-01f, -9.08606872e-02f,
  2.60473669e-01f, -2.09738597e-01f, -1.37323618e-01f, -1.51761249e-01f, 2.12962069e-02f, 2.07686275e-01f, 5.63166104e-02f, 5.75372986e-02f, 1.64164864e-02f, 2.29922369e-01f,
  1.21395841e-01f, 1.21435821e-02f, 1.35739058e-01f, -8.32719877e-02f, 5.70307625e-03f, -3.09783630e-02f, 3.83938663e-02f, 3.19411308e-01f, 5.19657694e-02f, -1.02874413e-01f,
  3.71501446e-02f, -1.07198477e-01f, 5.92234582e-02f, 9.64229554e-02f, 2.16307193e-01f, 2.34300971e-01f, 5.41210845e-02f, -4.78753038e-02f, -1.09160773e-01f, -1.43763945e-01f,
  -1.58820882e-01f, -1.26818806e-01f, 1.37683928e-01f, -6.61169589e-02f, -1.09256670e-01f, 9.44871902e-02f, -8.57440233e-02f, 7.92769529e-03f, -3.99806276e-02f, -1.25890851e-01f,
  -6.41769096e-02f, 6.10895082e-02f, -4.45948588e-03f, -7.46330768e-02f, -8.45787954e-03f, 1.05833471e-01f, 3.75497788e-02f, -3.49952877e-02f, 9.81005579e-02f, 1.03803657e-01f,
  1.45748153e-01f, 1.84788838e-01f, 4.69067469e-02f, 6.60926029e-02f, 6.68048337e-02f, -1.04966819e-01f, -6.13285229e-02f, 3.05693913e-02f, 1.69423282e-01f, 1.81547105e-01f,
  -1.40175149e-01f, -8.46020579e-02f, -3.02366223e-02f, -4.16998938e-02f, 1.09388144e-03f, 1.17427111e-01f, 4.12505902e-02f, 6.74932674e-02f, 9.97150391e-02f, -2.41610389e-02f,
  -5.40059023e-02f, -4.67286771e-03f, -1.26491502e-01f, -1.32557387e-02f, -9.22661461e-03f, 1.70121640e-01f, 3.90703091e-03f, -1.34342223e-01f, 8.73271525e-02f, -9.25258622e-02f,
  1.18586771e-01f, -2.15813100e-01f, -4.12298627e-02f, 2.51513831e-02f, -3.63001712e-02f, -1.15653254e-01f, -1.20787472e-01f, -1.19935133e-01f, -4.01899926e-02f, -8.68007075e-03f,
  -4.17474359e-02f, 8.35106075e-02f, 7.96057880e-02f, 1.14941858e-01f, 4.24719080e-02f, 7.15077594e-02f, -8.19202214e-02f, 6.34116009e-02f, 1.26743197e-01f, -2.23563891e-02f,
  1.47401560e-02f, 7.99185485e-02f, -1.49078649e-02f, 2.94727653e-01f, -9.53158513e-02f, -2.26204228e-02f, 1.05265558e-01f, 2.98606865e-02f, 1.05285406e-01f, -1.84428558e-01f,
  1.73871756e-01f, 7.92891160e-02f, 2.26474851e-02f, 9.49060097e-02f, 6.23290837e-02f, 1.66222155e-01f, -2.59317029e-02f, -1.18555792e-01f, -6.16434216e-03f, 1.51853770e-01f,
  -1.12539075e-01f, 7.67010301e-02f, -1.54732987e-01f, -2.68277675e-02f, 8.63558650e-02f, -7.18087107e-02f, 1.06324941e-01f, -9.95520279e-02f, 7.47773349e-02f, -1.04289711e-01f,
  8.74954090e-02f, 2.24735081e-01f, -1.18737385e-01f, 1.35997683e-01f, 5.80187775e-02f, 6.80045858e-02f, -3.20585519e-02f, 1.42939851e-01f, 2.51915283e-03f, 8.76858830e-02f,
  -1.82957035e-02f, -7.45987296e-02f, 1.05321527e-01f, 5.52053787e-02f, 1.38951078e-01f, 3.23845297e-02f, 3.59780341e-02f, 1.35998949e-01f, 1.07896738e-01f, -3.61435534e-03f,
  9.11455881e-03f, -4.99951802e-02f, 1.15515575e-01f, 7.70303011e-02f, 1.34527534e-01f, -6.62567792e-03f, 2.53382362e-02f, -1.39777223e-02f, -2.27094404e-02f, -9.76909697e-02f,
  5.19952178e-02f, 1.07359439e-01f, -1.12103947e-01f, -5.88342473e-02f, -9.12735462e-02f, 8.13634098e-02f, 1.03931874e-02f, 3.29457745e-02f, -5.00066504e-02f, 5.01109753e-03f,
  2.46372238e-01f, 2.23555788e-01f, 2.74072979e-02f, 3.78508829e-02f, 2.08034411e-01f, 2.81753063e-01f, -4.20623645e-02f, 7.98802525e-02f, -7.36005455e-02f, 1.87084690e-01f,
  9.49509889e-02f, -5.78488521e-02f, -1.29655167e-01f, 1.38298601e-01f, -1.57119006e-01f, 4.31786925e-02f, -1.17803574e-01f, 1.20375510e-02f, 5.30255400e-02f, 1.63766444e-01f,
  -1.66286930e-01f, 6.17432445e-02f, 1.35496214e-01f, -9.86164734e-02f, 1.22988552e-01f, -4.81813587e-02f, -1.51085537e-02f, 1.29305288e-01f, -1.16190337e-01f, -1.70826271e-01f,
  -9.52600688e-02f, -7.97386169e-02f, -5.35581745e-02f, -9.76387709e-02f, -4.76958118e-02f, -1.38806254e-01f, 1.09012224e-01f, 5.57656698e-02f, 1.09076537e-01f, 8.11260417e-02f,
  -4.30802926e-02f, -4.04875493e-03f, 3.79592776e-02f, -1.30575210e-01f, -2.40615010e-02f, 1.63576305e-02f, 9.13075134e-02f, 6.72592819e-02f, 6.14062138e-02f, 7.00984523e-02f,
  3.70940007e-02f, -1.48541331e-02f, 5.87824173e-02f, 1.30035937e-01f, 1.44332141e-01f, 9.83901881e-03f, 8.64708796e-02f, -8.39394704e-02f, 1.07248060e-01f, 1.44807488e-01f,
  5.12455702e-02f, -1.13388658e-01f, -2.34547555e-02f, 1.58690423e-01f, -1.95662212e-02f, 1.69208795e-01f, 1.40072852e-01f, -9.84105170e-02f, 5.72498515e-03f, -2.70984452e-02f,
  1.47062112e-02f, -1.81942862e-02f, -1.26197949e-01f, -2.90969238e-02f, -7.93049112e-03f, -3.12365610e-02f, -2.29894500e-02f, 1.09341308e-01f, 1.50857121e-01f, -1.12140134e-01f,
  5.56145906e-02f, -6.77865697e-03f, -3.89797613e-02f, 1.31352380e-01f, -8.04683194e-02f, 1.08209796e-01f, 7.60701820e-02f, -2.63931509e-02f, -1.10494770e-01f, -1.01322010e-01f,
  1.04870483e-01f, 4.06162639e-04f, -8.24693814e-02f, 4.50828634e-02f, 1.33989388e-02f, -7.63629004e-02f, 3.43992524e-02f, -2.04541460e-02f, 1.63858920e-01f, 1.07578546e-01f,
  -5.52982949e-02f, 1.10158836e-02f, 1.71324357e-01f, 1.40915915e-01f, -3.43308374e-02f, -8.60253200e-02f, -1.13011606e-01f, 4.56931703e-02f, -4.48007621e-02f, 1.44445002e-02f,
  2.01526694e-02f, -5.00390492e-02f, -2.20339298e-02f, -9.63221863e-03f, -1.11024924e-01f, 1.09274380e-01f, -1.26930326e-01f, 1.10836430e-02f, 6.68283999e-02f, -8.53834450e-02f,
  6.14820719e-02f, -2.86380062e-03f, -1.05346121e-01f, -4.72236751e-03f, 8.03950354e-02f, -1.19657956e-01f, 7.03149363e-02f, -5.79337999e-02f, 1.02960840e-01f, 6.37816861e-02f,
  4.96902354e-02f, 3.37720327e-02f, 8.56887400e-02f, -1.24049494e-02f, -5.35707809e-02f, -4.91080061e-02f, -2.96732299e-02f, 1.60934858e-03f, 7.25102201e-02f, -1.37649793e-02f,
  9.04944539e-02f, -1.23347871e-01f, 1.04405329e-01f, 7.76483491e-02f, 3.28241140e-02f, 2.26004049e-02f, 9.75139961e-02f, -1.07414134e-01f, 1.83066297e-02f, 4.66872822e-04f,
  3.92566994e-02f, 1.22129127e-01f, 9.46595610e-05f, 4.09039855e-02f, 6.47879466e-02f, -1.49706841e-01f, -4.97311726e-02f, 1.62955314e-01f, -9.45586860e-02f, 1.10569946e-01f,
  -1.11668576e-02f, -1.23058468e-01f, 9.70800072e-02f, 1.36753544e-01f, -4.33847606e-02f, 7.67718926e-02f, -1.56151205e-01f, -1.22803502e-01f, -3.29670012e-02f, -8.99078026e-02f,
  -1.83478128e-02f, -2.52416283e-02f, -5.70670590e-02f, -5.75904176e-02f, 6.76449463e-02f, 8.42316076e-02f, -3.03432792e-02f, 4.84599657e-02f, 1.65207431e-01f, -8.82675499e-02f,
  2.84068771e-02f, 3.33609171e-02f, -1.17368676e-01f, -1.26646027e-01f, -7.92845786e-02f, 1.15884542e-01f, -5.14260568e-02f, -1.09761842e-01f, 9.13280435e-03f, 1.60731703e-01f,
  9.46626738e-02f, -1.22172609e-01f, 2.05841009e-02f, -2.20248494e-02f, 3.49046774e-02f, 1.65620912e-02f, -8.03266615e-02f, -1.08826652e-01f, -6.18957914e-02f, -4.33197208e-02f,
  -6.52725995e-02f, 1.91287100e-01f, 9.93524268e-02f, 6.22828901e-02f, 8.03264230e-02f, -4.00465280e-02f, -1.68179348e-02f, 8.60304609e-02f, 4.88743857e-02f, 3.72454971e-02f,
  1.43904448e-01f, -1.00805081e-01f, 1.08424854e-02f, -6.07393384e-02f, -4.15777275e-03f, -7.55939484e-02f, -1.19688623e-01f, 3.02054491e-02f, 6.64152503e-02f, 4.82331170e-03f,
  1.89807430e-01f, 2.79366702e-01f, 3.00821871e-01f, 8.96501169e-02f, 2.12143287e-01f, -1.21479444e-01f, 2.41688415e-01f, -6.22499324e-02f, -6.01551682e-02f, 5.54097705e-02f,
  -9.29263830e-02f, 4.09690082e-01f, 9.68704373e-02f, -5.84816188e-03f, 8.34004655e-02f, 9.29053873e-02f, 3.32181126e-01f, 3.17201465e-02f, 1.68281943e-01f, 2.97868818e-01f,
  -3.33809783e-03f, 7.69305695e-03f, -5.54424003e-02f, -1.30880579e-01f, -1.47560582e-01f, -5.24092577e-02f, 7.69898179e-04f, 8.40020403e-02f, -1.22661993e-01f, 1.93826005e-01f,
  5.72908409e-02f, -1.62428687e-03f, -3.83341908e-02f, -1.44800603e-01f, -1.99383929e-01f, -1.29090205e-01f, -1.64076567e-01f, -6.12351559e-02f, 1.39817834e-01f, 3.01883548e-01f,
  -6.66196048e-02f, -1.28696039e-01f, 7.86917806e-02f, -1.19613297e-01f, 1.53463930e-01f, 1.70648858e-01f, 2.62864772e-02f, 1.54069737e-01f, -1.08950794e-01f, -2.28901003e-02f,
  -1.84118852e-01f, 1.01281703e-01f, 3.52596223e-01f, 2.95589358e-01f, -9.76050273e-03f, -1.99147630e-02f, 7.30462298e-02f, -2.92160958e-02f, -9.88764465e-02f, 4.52819578e-02f,
  1.07102528e-01f, -1.05496384e-01f, -5.60264662e-02f, 8.68993923e-02f, 9.70812887e-02f, 3.08124483e-01f, 1.82068869e-01f, 7.98321068e-02f, 2.52464503e-01f, 7.05102161e-02f,
  1.15584686e-01f, 4.52630594e-02f, 8.05968195e-02f, 3.37555915e-01f, -1.05033614e-01f, 2.33406901e-01f, 4.74818051e-02f, 2.57457234e-02f, -1.83457974e-02f, -2.08756533e-02f,
  1.57045528e-01f, -1.95806116e-01f, -5.36044464e-02f, -1.11634314e-01f, 1.03843540e-01f, -1.69563577e-01f, -1.46845458e-02f, -7.11269379e-02f, -6.48571504e-03f, 8.36821124e-02f,
  -1.01163946e-02f, 1.30762368e-01f, 2.48705503e-02f, 3.64288688e-02f, -7.66967237e-02f, 2.74102032e-01f, 8.62614587e-02f, -2.16853485e-01f, -1.98954746e-01f, 7.52782598e-02f,
  -1.25177875e-01f, 1.43148825e-01f, 1.20406307e-01f, 1.61093310e-01f, -7.21132979e-02f, 1.01502784e-01f, 4.84347483e-03f, -2.70401146e-02f, 1.04865313e-01f, 2.62311697e-01f,
  -1.30595297e-01f, 3.21024805e-01f, 3.77297704e-03f, 2.15984464e-01f, 2.87397355e-01f, 9.68119651e-02f, -4.59673256e-02f, 1.56288818e-01f, 5.14909215e-02f, 3.16729933e-01f,
  -1.13373779e-01f, 1.51316687e-01f, -1.46381572e-01f, 1.46839410e-01f, -1.11197094e-02f, -1.39120445e-01f, -4.71400768e-02f, 4.71938923e-02f, -2.56516859e-02f, 1.07690521e-01f,
  1.41201556e-01f, -4.21145260e-02f, 1.97535187e-01f, 7.49791563e-02f, -2.81311553e-02f, 4.77526151e-02f, 1.32889360e-01f, 1.21979356e-01f, 1.10764034e-01f, -3.75269018e-02f,
  2.63536219e-02f, 5.67493588e-03f, 1.07258655e-01f, 9.38562527e-02f, 1.00776270e-01f, 4.99168895e-02f, 1.52622312e-01f, 4.31275256e-02f, -2.43641268e-02f, -1.35802999e-01f,
  7.91858733e-02f, 7.20725879e-02f, -3.88118289e-02f, -1.43491223e-01f, -1.34554386e-01f, -3.02569401e-02f, 6.51853532e-02f, 6.53965846e-02f, -4.11113463e-02f, -1.35638028e-01f,
  -1.16461501e-01f, 8.44744593e-02f, 2.40806732e-02f, -1.56053275e-01f, 2.23827753e-02f, 9.19226557e-02f, 7.47168586e-02f, 1.32851109e-01f, 1.69509768e-01f, 1.63502425e-01f,
  -6.58698678e-02f, -1.93459280e-02f, -1.39763737e-02f, 9.96702462e-02f, -4.41887826e-02f, 2.51322072e-02f, 1.14936475e-02f, -3.02607212e-02f, -4.77243774e-02f, -1.88565720e-02f,
  -1.14786729e-01f, 4.43649553e-02f, 1.08564325e-01f, -3.88123095e-02f, -1.73172399e-01f, -3.00833452e-02f, 1.74234465e-01f, -7.28112236e-02f, 6.76518455e-02f, 1.69157088e-02f,
  5.79086244e-02f, -2.16966104e-02f, -4.88171205e-02f, 1.49163604e-01f, -1.07980140e-01f, 7.28094280e-02f, 7.21980706e-02f, -1.19631745e-01f, -8.39963332e-02f, 8.58016312e-02f,
  -9.26793665e-02f, 1.60320058e-01f, -2.64244955e-02f, -3.74354646e-02f, 6.41534664e-03f, 1.13289259e-01f, -8.73012915e-02f, -1.04185976e-01f, -3.09012625e-02f, 8.98910835e-02f,
  6.89309761e-02f, 2.70465296e-02f, 1.17714673e-01f, 1.17570944e-01f, -6.34191260e-02f, -1.24477237e-01f, -4.82110456e-02f, 9.96141508e-02f, -1.21979218e-03f, 1.73771363e-02f,
  -1.11829244e-01f, -1.47155328e-02f, -1.73448399e-02f, 5.28280474e-02f, -3.79023850e-02f, -3.39619480e-02f, -4.86880448e-03f, -9.83622521e-02f, 5.87839484e-02f, -6.80866241e-02f,
  -1.04936056e-01f, 1.51340038e-01f, 1.12448260e-01f, 5.67674823e-02f, -8.94087479e-02f, 4.20073122e-02f, 5.65314852e-02f, 1.13978192e-01f, -6.25563646e-03f, 1.47929356e-01f,
  -4.73191999e-02f, -5.24690449e-02f, -2.80931573e-02f, -5.59711717e-02f, 4.45107967e-02f, 3.11887590e-03f, 4.50328514e-02f, -3.71972024e-02f, 8.30767378e-02f, -7.79439062e-02f,
  -4.57926393e-02f, 6.69715777e-02f, 1.04727365e-01f, -9.55660269e-02f, 1.21302744e-02f, 9.06398799e-03f, 1.55614078e-01f, 2.99635623e-02f, 1.53956741e-01f, 1.13335297e-01f,
  2.19057739e-01f, -8.91440809e-02f, 1.06848605e-01f, 1.18427575e-01f, 6.59191981e-02f, 1.47748306e-01f, -1.25628905e-02f, 2.20750615e-01f, -9.05444473e-02f, 4.41595614e-02f,
  -8.68502557e-02f, 7.49615952e-02f, 2.24259626e-02f, 8.67334232e-02f, 1.59696508e-02f, 1.42118350e-01f, 1.17042616e-01f, 6.24963082e-02f, 7.23871542e-03f, -8.89341831e-02f,
  -7.74957612e-02f, 2.78562624e-02f, 1.12217637e-02f, 3.39014530e-02f, 2.67665018e-03f, 1.53010279e-01f, 4.61484678e-02f, -1.37074497e-02f, -2.73932721e-02f, -1.12461857e-01f,
  -1.15400948e-01f, -8.96803290e-02f, -5.54664806e-02f, -1.45574048e-01f, 1.71894059e-02f, 2.09527873e-02f, 1.42786920e-01f, 3.58830690e-02f, -3.79292108e-02f, -1.24056160e-01f,
  7.03809038e-02f, 1.39893755e-01f, 8.71625766e-02f, 1.08624294e-01f, -1.02149293e-01f, 1.26764430e-02f, 9.03926417e-02f, -1.30101303e-02f, 1.08618662e-01f, 1.42147288e-01f,
  1.08503364e-01f, 1.75825998e-01f, 5.78764193e-02f, 5.01967333e-02f, -7.04432046e-03f, 1.31551057e-01f, 2.89098881e-02f, -1.45398423e-01f, 8.04814622e-02f, 1.35752246e-01f,
  1.42518491e-01f, 1.48628160e-01f, 7.57745933e-03f, 1.17212139e-01f, -3.23945396e-02f, -3.22643928e-02f, -1.52587190e-01f, 1.14928007e-01f, -8.67111459e-02f, -1.79319978e-01f,
  -4.34860103e-02f, 1.94458410e-01f, 6.17078580e-02f, -4.59589735e-02f, -3.16227786e-02f, 1.14899455e-02f, 1.81279525e-01f, 4.28662486e-02f, 3.62325795e-02f, -4.19736207e-02f,
  -4.91079921e-03f, 1.65469676e-01f, 1.31854668e-01f, -2.91972961e-02f, 4.29614000e-02f, -4.03692797e-02f, 1.26229286e-01f, 1.31866410e-02f, -6.59715459e-02f, -1.21661879e-01f,
  1.04804799e-01f, -4.22006138e-02f, 2.44782642e-02f, -3.00873891e-02f, -1.13025650e-01f, 9.90631953e-02f, -1.08638890e-01f, 1.01169936e-01f, -1.83106400e-02f, -6.49867579e-02f,
  1.16114028e-01f, -9.20251682e-02f, -1.72083077e-04f, -4.09349129e-02f, 1.15229160e-01f, 3.18845719e-01f, -1.28711015e-02f, -1.03508890e-01f, -6.03455305e-02f, -1.02187902e-01f,
  -9.28983614e-02f, -6.73702583e-02f, 2.00625852e-01f, 4.88377437e-02f, -6.62323162e-02f, -8.06242898e-02f, 1.27376229e-01f, -6.73856810e-02f, 2.14736238e-02f, 7.15586320e-02f,
  -3.51034477e-02f, 1.40543193e-01f, 7.61722550e-02f, 1.29129529e-01f, -1.02117717e-01f, -7.49424621e-02f, -9.51127037e-02f, -2.34332774e-02f, -1.36137782e-02f, 1.04110926e-01f,
  -8.16323385e-02f, -3.60984989e-02f, -6.99993595e-02f, 4.35229018e-02f, -1.74726713e-02f, 1.50693938e-01f, 3.26778577e-03f, 3.81939635e-02f, 1.01760291e-01f, -2.55292319e-02f,
  -5.56526333e-02f, -4.75790724e-02f, 2.72537507e-02f, 7.80140013e-02f, 4.99633439e-02f, -3.29078473e-02f, 1.50205374e-01f, -8.28006938e-02f, 3.39941233e-02f, -4.86856252e-02f,
  5.57914265e-02f, 1.33306915e-02f, -4.48751375e-02f, 6.92972168e-02f, -8.04651976e-02f, 6.34676665e-02f, -3.02966405e-02f, 1.01277150e-01f, -1.27279833e-01f, 6.55871481e-02f,
  -1.33174106e-01f, 1.04829960e-01f, 6.71650767e-02f, 9.15102437e-02f, 2.03470197e-02f, -9.14974436e-02f, 9.32002382e-04f, -3.64602730e-02f, -1.60910655e-02f, 1.27150312e-01f,
  -1.30899966e-01f, 2.07342785e-02f, 1.55140191e-01f, 6.01398274e-02f, 9.36697796e-02f, 1.77495591e-02f, 9.27149132e-02f, -8.21468383e-02f, 7.78998658e-02f, -8.50155503e-02f,
  1.88797951e-01f, -2.05228068e-02f, -1.17686898e-01f, 1.76635027e-01f, -1.11202359e-01f, 2.03240082e-01f, 9.85552296e-02f, -1.10057160e-01f, -9.22012702e-02f, -8.96907374e-02f,
  -1.31327704e-01f, -1.83312848e-01f, -7.15215802e-02f, 1.85700953e-02f, 5.69025017e-02f, 1.40654817e-01f, 2.03597862e-02f, -5.42058311e-02f, 6.60706162e-02f, -1.10859357e-01f,
  -8.49883556e-02f, 3.30002457e-02f, -2.37592235e-02f, -1.30987819e-02f, 9.55611095e-02f, -7.39819258e-02f, -6.87956363e-02f, -4.44887318e-02f, -2.92928759e-02f, -1.20127015e-03f,
  1.97536975e-01f, -3.10148280e-02f, 1.47295184e-02f, 7.44245248e-03f, 9.41162556e-03f, 9.81778279e-02f, 1.03896176e-02f, -3.78104188e-02f, 7.58215487e-02f, -6.95631057e-02f,
  1.78470649e-02f, 6.42797053e-02f, -1.00764416e-01f, 7.66361132e-02f, -1.47031516e-01f, 2.79859100e-02f, 6.76095188e-02f, -3.26393098e-02f, 4.27150615e-02f, 2.62124427e-02f,
  1.00972988e-01f, 3.97818275e-02f, 1.51151329e-01f, 2.38937587e-01f, -1.12034097e-01f, 5.01681976e-02f, 2.16318712e-01f, 1.36765987e-02f, 1.00432234e-02f, -1.03270486e-01f,
  -1.04280576e-01f, -7.77768642e-02f, 3.71824987e-02f, 8.17740932e-02f, -2.39494182e-02f, -5.30301817e-02f, -1.09518860e-02f, -7.33421892e-02f, 4.49725799e-02f, 2.45481133e-01f,
  -8.76895264e-02f, 4.49876152e-02f, 3.49786915e-02f, -9.22180265e-02f, 1.02380745e-01f, -6.82561100e-02f, -4.62951772e-02f, -1.29610598e-01f, -1.91281538e-03f, 9.86258388e-02f,
  -1.75819285e-02f, 1.16332993e-01f, -1.05599605e-01f, 6.45056888e-02f, -7.56211430e-02f, -1.16802789e-02f, -9.46431458e-02f, 1.00264207e-01f, 1.49856567e-01f, -8.81281123e-02f,
  -4.76991087e-02f, 7.24577084e-02f, -3.98745947e-02f, 1.10903896e-01f, 1.90609932e-01f, 5.69015257e-02f, -4.69179899e-02f, 1.82514265e-01f, 1.35797724e-01f, -1.46855399e-01f,
  6.79246038e-02f, 8.45589042e-02f, 1.81137383e-01f, 2.04803452e-01f, -2.79471334e-02f, -1.61472470e-01f, 7.17241839e-02f, -2.77257175e-03f, -5.82974926e-02f, 3.48566137e-02f,
  1.98319137e-01f, 1.52941808e-01f, -1.25840917e-01f, -7.22203404e-02f, 2.19225567e-02f, -6.80266321e-02f, 6.75254986e-02f, 8.08185562e-02f, 4.15698178e-02f, 1.46656632e-01f,
  -1.39146461e-03f, 1.51393324e-01f, 3.23157638e-01f, 5.46308123e-02f, -1.49079422e-02f, -6.88093603e-02f, 3.98376361e-02f, 1.61553860e-01f, -1.31901936e-04f, 1.53587431e-01f,
  -1.77125439e-01f, 3.19441371e-02f, -7.26820603e-02f, 6.54531866e-02f, 9.05189887e-02f, -5.43738194e-02f, 8.82757828e-03f, 9.23682898e-02f, 1.96958676e-01f, 4.11511250e-02f,
  5.37959561e-02f, -1.62705500e-02f, 5.64532951e-02f, -8.48255381e-02f, 8.91996026e-02f, 1.23256743e-01f, 4.19883542e-02f, 1.35333866e-01f, -7.36923516e-02f, -3.82490456e-03f,
  -6.96208179e-02f, 1.29081845e-01f, 1.54625922e-01f, -8.72652531e-02f, 1.28236383e-01f, 2.57413741e-02f, -2.37216651e-02f, -1.17521048e-01f, -1.13912812e-02f, 3.23558692e-03f,
  2.13819351e-02f, -7.09057078e-02f, -6.37887493e-02f, 2.12288811e-03f, -1.06651723e-01f, -9.17686597e-02f, -4.69483845e-02f, 5.77740790e-03f, -6.13958612e-02f, -1.36702821e-01f,
  -1.16963618e-01f, 2.38896143e-02f, -3.91285866e-03f, -1.58457402e-02f, -7.76779093e-03f, 7.97079504e-02f, 7.64063150e-02f, 7.53884912e-02f, 4.89959307e-02f, -5.10663502e-02f,
  1.02488749e-01f, 1.13578871e-01f, -2.95035578e-02f, 8.88806656e-02f, 6.12879731e-02f, -7.53587782e-02f, 3.20702717e-02f, 8.56775865e-02f, -6.33716630e-03f, 9.40203294e-02f,
  6.02316372e-02f, 1.45192653e-01f, -9.27659050e-02f, -5.29151447e-02f, -1.13065228e-01f, 1.52431959e-02f, 2.67359391e-02f, 4.86731390e-03f, 1.31940410e-01f, 1.86904836e-02f,
  -1.03257149e-02f, 7.95336440e-02f, -7.69896954e-02f, 8.76506716e-02f, -5.15721105e-02f, -4.83812280e-02f, 5.50588928e-02f, 4.71040718e-02f, -2.25139386e-03f, 1.09318241e-01f,
  4.90855910e-02f, 1.36317044e-01f, 1.09545670e-01f, 2.49027996e-03f, 7.95446932e-02f, 1.16199441e-01f, -1.12026244e-01f, 1.20070130e-01f, 9.02617499e-02f, -5.73555715e-02f,
  -2.10362617e-02f, -6.62263706e-02f, -1.22381076e-01f, -5.51436171e-02f, -1.12343416e-01f, 1.74852554e-02f, -1.29105121e-01f, -9.01744068e-02f, 1.24737106e-01f, -8.88436139e-02f,
  1.18169421e-02f, -7.81189874e-02f, -5.87037839e-02f, -1.03092119e-01f, 9.87697318e-02f, 1.36466190e-01f, 7.17934780e-03f, 1.25565723e-01f, -2.96597034e-02f, -9.39108506e-02f,
  3.88858132e-02f, 1.23711944e-01f, -3.35541926e-02f, 2.99095176e-02f, -1.25315517e-01f, -8.32783408e-04f, -3.21913511e-02f, 8.78270939e-02f, 7.32323453e-02f, 7.09668845e-02f,
  8.86731520e-02f, 6.84777042e-03f, 6.34110495e-02f, 9.22810584e-02f, 3.47189829e-02f, 1.58781692e-01f, 6.76101670e-02f, -7.25891367e-02f, 8.06108266e-02f, -9.72678587e-02f,
  -1.06442407e-01f, -1.17189158e-02f, 6.19552992e-02f, -7.70052671e-02f, -1.07456809e-02f, 6.19289987e-02f, 7.80967921e-02f, 2.31882438e-01f, 1.33205563e-01f, 2.38065496e-01f,
  1.95827782e-01f, -7.22974092e-02f, 1.71386972e-01f, 1.83732152e-01f, 2.23410323e-01f, -9.72759649e-02f, 3.36060338e-02f, 1.27235055e-01f, -9.59531590e-02f, 1.50943145e-01f,
  -1.47732556e-01f, -2.16306024e-03f, 1.86864421e-01f, 2.00857684e-01f, 2.78399326e-02f, -1.55716017e-01f, 9.02772620e-02f, 8.58004317e-02f, -8.21952522e-02f, 2.32395642e-02f,
  8.28405470e-02f, 2.57833097e-02f, -5.63489906e-02f, 1.52490407e-01f, -6.30828515e-02f, -3.80359255e-02f, -3.89805958e-02f, 9.24125221e-03f, -1.41697854e-01f, 7.63783231e-02f,
  2.67551064e-01f, 5.59895076e-02f, -6.89018071e-02f, 5.25858067e-02f, 1.90659553e-01f, 1.02643855e-01f, -1.36360794e-01f, -9.46681723e-02f, -7.97813311e-02f, -2.73632444e-03f,
  -1.15924977e-01f, 2.17656434e-01f, -1.29370466e-01f, 1.89210579e-01f, -1.65842742e-01f, 1.07764624e-01f, 6.55933693e-02f, 1.13672599e-01f, 4.89102639e-02f, 5.68478694e-03f,
  -1.08041679e-02f, -9.89926532e-02f, 5.03692627e-02f, -1.77742586e-01f, 1.02732114e-01f, -1.23225003e-01f, -1.90358702e-02f, 1.79338008e-01f, -4.27442044e-02f, 1.50333807e-01f,
  8.10365845e-03f, 2.48169657e-02f, 2.27711067e-01f, 3.87924984e-02f, 5.14779650e-02f, -8.87486488e-02f, 1.70612857e-01f, 2.69173533e-01f, 1.13671236e-02f, 1.97172716e-01f,
  -7.30848014e-02f, -1.10378377e-01f, -6.26603141e-02f, -9.53927338e-02f, -9.38885063e-02f, 1.25134503e-02f, -4.99949697e-03f, 1.22713424e-01f, 1.08995847e-01f, -1.04362033e-01f,
  -3.26549746e-02f, -1.39081385e-02f, -5.73208630e-02f, 1.52923837e-01f, -1.86920948e-02f, -3.96465417e-03f, -8.64865854e-02f, 1.48669034e-01f, 1.04275391e-01f, 2.69146413e-01f,
  7.81764761e-02f, -1.06478281e-01f, -2.90137641e-02f, 1.76215410e-01f, 1.07882835e-01f, -4.35144007e-02f, -2.43428443e-02f, 8.23059753e-02f, -1.66419372e-01f, 1.08287722e-01f,
  2.18090899e-02f, -2.72376910e-02f, 1.52771026e-01f, 8.67716298e-02f, 7.56393224e-02f, 1.05880417e-01f, -2.95655727e-02f, 2.14570180e-01f, 1.90588892e-01f, -2.24288013e-02f,
  8.17084908e-02f, 3.06935251e-01f, -1.20753407e-01f, 2.48275250e-01f, -1.20299965e-01f, -1.96612682e-02f, -1.31482378e-01f, 1.97375610e-01f, 2.64784601e-02f, -1.38332903e-01f,
  -8.50759596e-02f, -7.89220706e-02f, 1.00822642e-01f, 7.12046847e-02f, 3.55039388e-02f, 1.97699189e-01f, 1.87400699e-01f, -6.53100479e-03f, 2.63778120e-01f, 9.49565694e-02f,
  2.16942430e-01f, 5.02671897e-02f, 1.59642454e-02f, 1.26356363e-01f, -4.49348912e-02f, 1.59824770e-02f, 7.44199902e-02f, 1.26576722e-01f, 1.00563481e-01f, -9.68939345e-03f,
  1.95133358e-01f, 2.36285385e-02f, -3.97648774e-02f, -4.59285937e-02f, 1.97080802e-02f, 7.10842609e-02f, -1.30348191e-01f, -1.05315834e-01f, -1.34030059e-01f, 1.33990586e-01f,
  5.81818223e-02f, 2.49443576e-02f, 9.64459851e-02f, 9.52306166e-02f, -1.36111649e-02f, -1.66367799e-01f, -9.60393324e-02f, 3.89292799e-02f, -4.72080372e-02f, 7.29572773e-02f,
  -1.59402508e-02f, 1.52401537e-01f, 1.29257515e-01f, 1.64645404e-01f, 5.36263920e-02f, 6.96673319e-02f, -1.21987104e-01f, -1.32665828e-01f, -6.32768720e-02f, 1.70137167e-01f,
  7.41971051e-03f, -7.14512467e-02f, -1.40155718e-01f, 1.09387800e-01f, 8.98762122e-02f, 2.21803844e-01f, 4.40429747e-02f, 7.64160678e-02f, -1.60373464e-01f, -7.43620619e-02f,
  1.01792656e-01f, 4.00341153e-02f, -2.73488052e-02f, -2.20552593e-01f, -7.04251900e-02f, 1.09048381e-01f, 4.59193747e-04f, -8.27125534e-02f, 1.36359647e-01f, -5.62506281e-02f,
  -5.89201972e-02f, 4.51003350e-02f, -1.27204955e-01f, 6.58760816e-02f, 1.16667815e-01f, -5.02330400e-02f, -9.99080762e-02f, -1.67914242e-01f, 5.43069504e-02f, 1.16548732e-01f,
  1.26427874e-01f, -1.22481726e-01f, -6.09501302e-02f, -9.03384313e-02f, -1.08328894e-01f, -3.80951501e-02f, 8.00896958e-02f, -7.71749206e-03f, 1.10519126e-01f, -3.95457298e-02f,
  -9.22590941e-02f, -4.73027565e-02f, -1.15063742e-01f, -4.16986980e-02f, 8.50061141e-03f, -4.99847010e-02f, 3.74780446e-02f, -8.87347162e-02f, 5.10805324e-02f, -2.41764188e-02f,
  5.54238036e-02f, -8.72100443e-02f, -1.24927595e-01f, 2.95571107e-02f, -3.73299532e-02f, -1.38898930e-02f, -4.31198850e-02f, 1.57696113e-01f, 8.83091092e-02f, 9.86106396e-02f,
  -2.62065995e-02f, -7.89580494e-02f, -7.66228661e-02f, -8.19698498e-02f, 3.04605495e-02f, -1.31338090e-03f, 7.20386654e-02f, -1.16394423e-01f, -1.85528006e-02f, -1.36229843e-01f,
  5.80242835e-02f, 9.21155065e-02f, 7.58611597e-03f, -3.13792303e-02f, 7.10206181e-02f, -1.21778816e-01f, -8.51920098e-02f, -5.77755347e-02f, 4.35690489e-03f, -7.74306059e-02f,
  2.94318590e-02f, -1.23706684e-01f, 6.88782558e-02f, -1.47374779e-01f, -7.62783512e-02f, -1.31068334e-01f, 1.30330101e-02f, -9.04561654e-02f, -5.91130778e-02f, -1.52489301e-02f,
  1.83979407e-01f, 1.21127151e-01f, 8.13586861e-02f, 9.95992217e-04f, 4.04114462e-02f, -1.13305300e-01f, 1.18937092e-02f, -5.12686186e-02f, -6.28170697e-03f, -7.73577020e-02f,
  9.36530232e-02f, 5.75690866e-02f, 6.58210292e-02f, -1.08191997e-01f, 1.06004842e-01f, 6.17152490e-02f, 1.05261087e-01f, -8.61603618e-02f, -3.26314522e-03f, -5.18139079e-02f,
  1.45925000e-01f, 1.23427905e-01f, 5.45540489e-02f, 6.98355511e-02f, 1.05725592e-02f, 1.04904659e-01f, 4.66933176e-02f, 1.43790483e-01f, 6.27647573e-03f, 1.49907917e-01f,
  1.26270745e-02f, 4.44198512e-02f, 8.71495977e-02f, -4.69909571e-02f, 6.74294606e-02f, -8.13570321e-02f, 6.48488998e-02f, -7.55792409e-02f, -7.71784037e-02f, 2.03187138e-01f,
  1.66134939e-01f, -6.03055544e-02f, 1.17771156e-01f, 2.21760511e-01f, -9.35593843e-02f, 1.01597846e-01f, -7.27338791e-02f, 2.05976125e-02f, 1.47662118e-01f, 1.73876777e-01f,
  5.01854867e-02f, -2.62886472e-02f, 1.00952126e-01f, 7.80634433e-02f, -2.32348993e-01f, -1.54282525e-01f, -1.52201820e-02f, -5.39321378e-02f, -1.20202988e-01f, -4.35690023e-02f,
  -6.66369349e-02f, -1.94926471e-01f, 1.91538862e-03f, -7.06918314e-02f, 1.21862270e-01f, -9.04238299e-02f, -1.31455446e-02f, -9.70632806e-02f, -1.07245475e-01f, -1.70178581e-02f,
  1.74350049e-02f, 6.02596626e-02f, 1.46612212e-01f, 1.53767064e-01f, -5.92270792e-02f, -7.36931758e-03f, -3.23117003e-02f, -1.00760803e-01f, 2.56989673e-02f, 1.60097957e-01f,
  1.46813974e-01f, 4.51668538e-02f, -3.77486609e-02f, 1.17123872e-01f, 3.51594239e-02f, 2.43265450e-01f, 5.27932085e-02f, 1.35548726e-01f, 1.00823529e-01f, 8.90049785e-02f,
  -7.67194107e-02f, 1.79637462e-01f, 7.67424852e-02f, 1.55423302e-03f, -6.79331422e-02f, -1.79981455e-01f, -9.60608106e-03f, -2.96860784e-02f, -1.05763590e-02f, -2.73750164e-02f,
  -2.53225416e-02f, -1.31802663e-01f, 1.53448567e-01f, 1.71032190e-01f, 1.49372682e-01f, 6.53383881e-02f, 1.36736512e-01f, 1.09489150e-01f, -2.92159542e-02f, -1.53738130e-02f,
  1.24748364e-01f, -1.04411669e-01f, 2.22481415e-01f, 2.26892173e-01f, -1.00793570e-01f, 1.74601018e-01f, 1.39358163e-01f, 7.98362941e-02f, -4.16047052e-02f, -1.35681480e-01f,
  -9.99789983e-02f, -6.54229522e-02f, 1.84836611e-02f, -2.63844654e-02f, 9.23885629e-02f, 1.26235917e-01f, -6.63386881e-02f, 2.22738553e-02f, 3.38243432e-02f, 3.98179926e-02f,
  9.52577963e-02f, 7.10338652e-02f, -6.68398067e-02f, 6.72451854e-02f, 1.84630267e-02f, 3.77979018e-02f, 1.14161469e-01f, -5.91935180e-02f, -8.45740587e-02f, 1.49532035e-01f,
  4.15762737e-02f, 5.35983853e-02f, -7.45326355e-02f, -1.09762639e-01f, 5.02729118e-02f, 6.34807302e-03f, -1.12018406e-01f, -4.53477986e-02f, 5.63295297e-02f, 1.65063457e-03f,
  4.97909710e-02f, -8.72044265e-02f, 6.32907450e-02f, -9.35361162e-02f, -7.34369978e-02f, 5.97325861e-02f, -2.22951695e-02f, -7.54972324e-02f, 1.00662112e-01f, 1.38666302e-01f,
  -1.21166527e-01f, -2.52871178e-02f, 1.14087313e-01f, 1.83270186e-01f, -6.03292733e-02f, -7.69711807e-02f, 7.10331649e-02f, 7.79365748e-02f, -1.40472934e-01f, -1.21420719e-01f,
  5.28379939e-02f, -9.09511521e-02f, 7.52441138e-02f, 3.27396352e-04f, 1.47362165e-02f, 6.73950538e-02f, 1.91609159e-01f, -9.02281478e-02f, -6.39669131e-03f, 2.06057299e-02f,
  -3.37679274e-02f, -6.47028489e-03f, 8.57708827e-02f, 1.30506471e-01f, -1.14396788e-01f, 2.63962243e-02f, -8.50159302e-02f, -8.53456184e-03f, -3.14008794e-03f, 1.33968875e-01f,
  7.83866122e-02f, -8.71621072e-03f, 4.68147472e-02f, -6.12612814e-02f, 8.34457055e-02f, -6.19567968e-02f, -7.16443658e-02f, 5.92601039e-02f, -9.48158950e-02f, -8.79988819e-02f,
  1.18090861e-01f, 7.58655742e-02f, 1.59220621e-02f, -9.44495946e-02f, -2.17285827e-02f, -1.07873544e-01f, 9.31976289e-02f, 4.73399879e-03f, -1.00852847e-01f, -9.89599228e-02f,
  1.24695644e-01f, 1.00572482e-01f, 8.94959867e-02f, -1.39421612e-01f, 3.26415896e-03f, 3.72387320e-02f, 7.49075115e-02f, 8.35607499e-02f, -2.71029770e-02f, 1.03808388e-01f,
  -6.62018806e-02f, -3.60356644e-02f, 3.72178070e-02f, -7.19940811e-02f, -2.38991156e-02f, -1.03939265e-01f, 1.23420864e-01f, 8.46166536e-02f, -2.52289958e-02f, -1.21340521e-01f,
  3.65479216e-02f, 1.45719815e-02f, 1.01471052e-01f, -6.60360185e-03f, -1.57591254e-01f, -1.19638704e-01f, 1.59475714e-01f, -1.02841489e-01f, 6.83274120e-02f, 7.31229363e-03f,
  -5.86097054e-02f, -5.57431839e-02f, -5.40987030e-02f, 1.37973189e-01f, -1.31286547e-01f, 8.54099691e-02f, 3.40126567e-02f, 1.75746098e-01f, -5.08209765e-02f, -4.62940522e-02f,
  1.78899407e-01f, -1.48705363e-01f, 1.15535684e-01f, -1.28182203e-01f, 4.96488325e-02f, 3.76675390e-02f, -1.29461689e-02f, 1.58894792e-01f, 5.00244945e-02f, -1.19925715e-01f,
  6.54313937e-02f, -2.45310739e-02f, 1.46950483e-01f, 5.25265262e-02f, -2.87848245e-03f, 8.83169547e-02f, -5.89813758e-03f, -1.03102461e-01f, -1.51006147e-01f, 5.56511767e-02f,
  8.05761591e-02f, -5.94360828e-02f, -9.67908129e-02f, 1.07311107e-01f, -1.51164472e-01f, 4.58609425e-02f, -4.44421358e-02f, 3.38686304e-03f, -3.14734168e-02f, -8.07638913e-02f,
  5.45422062e-02f, -8.40926263e-03f, -4.29932438e-02f, -2.58289557e-02f, -6.41335398e-02f, 1.41140327e-01f, 9.35692713e-02f, -1.40454965e-02f, 1.24640904e-01f, 1.91226099e-02f,
  -6.66134953e-02f, -1.26660243e-01f, -8.11758563e-02f, 7.03289732e-02f, 1.13849968e-01f, -8.02567601e-02f, -4.82125022e-02f, 4.88343239e-02f, 2.29618758e-01f, 1.44865349e-01f,
  7.23044649e-02f, -9.33167432e-03f, 1.27787683e-02f, -5.68986312e-02f, 6.47319332e-02f, 1.51841402e-01f, -3.34357098e-02f, -8.17018896e-02f, -5.51969111e-02f, 7.94061869e-02f,
  1.50448605e-01f, 2.08521068e-01f, 1.42887995e-01f, -5.97408824e-02f, 1.35839581e-01f, 1.34735063e-01f, -2.12313995e-01f, -1.00284461e-02f, 2.47336589e-02f, -2.52118230e-01f,
  -8.69770199e-02f, -8.20918977e-02f, 7.70017430e-02f, -1.66896265e-02f, -3.83752249e-02f, -7.74273276e-02f, 2.39961725e-02f, 8.70326236e-02f, 1.07622050e-01f, -1.62561312e-01f,
  -1.73146662e-03f, 1.72949329e-01f, -1.01902589e-01f, -4.93637584e-02f, 7.28062764e-02f, -1.74438655e-02f, 1.64448284e-02f, 6.75188825e-02f, 8.60146284e-02f, -1.40511274e-01f,
  -1.60197884e-01f, 1.40999686e-02f, -8.01219568e-02f, 1.50911391e-01f, 1.90399975e-01f, -5.70231453e-02f, -1.45744637e-01f, -5.04953936e-02f, -8.76959041e-02f, -1.12306476e-01f,
  -1.18535899e-01f, 8.64603594e-02f, 8.52274522e-02f, 1.08039072e-02f, -2.15906501e-02f, 1.43656969e-01f, -1.77755486e-02f, -2.06545606e-01f, 6.34008460e-03f, -1.22570530e-01f,
  4.37760539e-02f, -5.32996021e-02f, -1.53321967e-01f, -1.02776840e-01f, 1.44506752e-01f, -1.75418705e-01f, 1.02756657e-01f, -4.85179052e-02f, 1.28967598e-01f, -9.06141922e-02f,
  7.33312145e-02f, 1.92392662e-01f, -1.83878727e-02f, 3.32045741e-02f, -5.67032918e-02f, -1.72120944e-01f, -5.74692078e-02f, -1.26700222e-01f, -4.91039827e-02f, -1.87241081e-02f,
  -1.03293331e-02f, -1.42062819e-02f, -1.00536995e-01f, -1.58673510e-01f, 1.43189594e-01f, -2.30436385e-01f, 1.00019641e-01f, 6.69102743e-02f, -2.13428419e-02f, 1.01429120e-01f,
  -8.32780451e-02f, 5.50998077e-02f, 1.23144463e-01f, 3.03570684e-02f, 2.47613825e-02f, 1.12349898e-01f, 2.53745839e-02f, 2.81422008e-02f, 8.02163929e-02f, -1.11922160e-01f,
  -7.48246685e-02f, -1.30788445e-01f, 1.04720928e-02f, -2.70785131e-02f, 4.31271978e-02f, 1.55727446e-01f, -8.48811418e-02f, -4.05125655e-02f, 1.47778690e-01f, -5.17312950e-03f,
  -5.47237359e-02f, 8.55245516e-02f, 4.88869436e-02f, 7.78600648e-02f, 7.48658404e-02f, 1.58458263e-01f, 8.36931989e-02f, -5.67614585e-02f, -9.04135332e-02f, 1.13066956e-01f,
  6.56961203e-02f, 1.15393519e-01f, -7.43805245e-02f, 1.54583454e-01f, -1.98122440e-03f, -7.72100314e-02f, 1.05485454e-01f, 8.34419355e-02f, 1.18719704e-01f, -9.14754048e-02f,
  -1.04386844e-01f, 8.27240124e-02f, 1.78820506e-01f, -8.98253545e-02f, -8.02948475e-02f, 2.45584000e-04f, -1.03305198e-01f, 8.32849443e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  1.09986430e-02f, 5.16384169e-02f, -2.66895294e-02f, -6.54573217e-02f, 7.67629296e-02f, -7.20131695e-02f, 6.91627664e-03f, 1.02836505e-01f, 1.13416329e-01f, -3.18543948e-02f,
  1.55533656e-01f, 2.41990954e-01f, 4.34118100e-02f, -7.43684247e-02f, 1.33287296e-01f, -5.28401583e-02f, 3.28561276e-01f, -3.67972627e-02f, -1.19294629e-01f, 1.11462057e-01f,
  1.00080192e-01f, 1.40928358e-01f, 1.81264549e-01f, 2.23434463e-01f, 1.13807067e-01f, 1.55036226e-02f, -6.62988275e-02f, -1.00697890e-01f, -7.18377829e-02f, 1.70546249e-01f,
  1.79064095e-01f, 8.72913450e-02f, 8.45619738e-02f, -8.89308751e-03f, 5.66727780e-02f, -2.18463372e-02f, 2.98343692e-02f, 9.47931483e-02f, 1.40756339e-01f, 8.89531150e-02f,
  1.53090447e-01f, 2.69248318e-02f, 2.03550696e-01f, 8.35003033e-02f, -4.16833833e-02f, -1.63572021e-02f, -1.25744835e-01f, 7.57993460e-02f, -9.01287869e-02f, 1.89233217e-02f,
  1.21842600e-01f, -7.65122175e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -8.16907883e-02f, -4.18950953e-02f, -2.39770919e-01f, 1.60501041e-02f, -3.42662036e-01f, -1.59997031e-01f, 1.01764709e-01f, 3.42050195e-02f, -3.79581638e-02f, -1.11846477e-01f,
  1.16621710e-01f, -7.75993019e-02f, -1.52760461e-01f, -5.32997027e-03f, -1.50707394e-01f, 9.29263160e-02f, 2.36712601e-02f, -3.67560089e-02f, -1.54797360e-01f, 8.67516845e-02f,
  7.42286816e-02f, 1.11615956e-02f, 3.93343210e-01f, -4.04787481e-01f, -1.36068642e-01f, 2.37629503e-01f, -1.38047427e-01f, -6.97288960e-02f, -1.63116381e-02f, -1.38901576e-01f,
  7.86298588e-02f, -2.55496234e-01f, 2.18024507e-01f, 4.58194643e-01f, 6.45574257e-02f, 9.46795121e-02f, -2.23916098e-01f, 3.22081566e-01f, 5.83749488e-02f, 5.70015348e-02f,
  -9.18580890e-02f, 2.07797110e-01f, -8.85449424e-02f, -2.90515304e-01f, 3.85094807e-02f, 7.84707218e-02f, -4.78066280e-02f, 1.62451088e-01f, 1.24618895e-02f, 4.42764640e-01f,
  -2.19805598e-01f, -1.74497932e-01f, -6.57679215e-02f, -1.85670868e-01f, -1.22039542e-01f, -1.18540056e-01f, 8.48817900e-02f, -1.03643924e-01f, 2.06513610e-02f, 2.57108271e-01f,
  1.60969898e-01f, 2.48555746e-02f, 1.55405462e-01f, 1.29860923e-01f, -1.64039597e-01f, -4.36882004e-02f, -1.06572188e-01f, -1.53095603e-01f, -7.37909153e-02f, -8.60682204e-02f,
  1.11717489e-02f, -7.12367073e-02f, 1.62170485e-01f, 4.18966442e-01f, -8.56594816e-02f, 1.62121236e-01f, -1.33050472e-01f, -1.60153925e-01f, 9.24267918e-02f, 6.43188357e-02f,
  -1.60659805e-01f, 1.00753136e-01f, -3.12256724e-01f, -3.50186937e-02f, -1.42051667e-01f, 3.18485290e-01f, -2.09510744e-01f, -3.25794131e-01f, 1.39221236e-01f, 2.24612445e-01f,
  1.98537812e-01f, -1.82403609e-01f, 1.84846267e-01f, -6.22472279e-02f, 2.40043998e-01f, -3.44179094e-01f, 1.40595093e-01f, 1.43423572e-01f, 4.05797303e-01f, 2.75172561e-01f,
  -1.50198206e-01f, 2.84122556e-01f, 3.49514812e-01f, 6.71378970e-02f, -6.78775460e-03f, 1.37675914e-03f, -1.84039548e-01f, -1.03645012e-01f, 2.71137446e-01f, -1.22696474e-01f,
  -7.95433596e-02f, -1.42609820e-01f, -1.49267167e-01f, -1.04646318e-01f, 8.23449664e-05f, -5.02057374e-02f, -1.32072970e-01f, 4.99116749e-01f, -2.86486894e-01f, 1.51020750e-01f,
  -3.08256447e-02f, 2.25711409e-02f, -1.25446189e-02f, 1.06776960e-01f, 1.12629426e-03f, -1.57624096e-01f, -1.72552824e-01f, 2.02140763e-01f, 5.60875773e-01f, 6.13124259e-02f,
  3.11678708e-01f, 8.78153443e-01f, 9.90313962e-02f, 1.80295944e-01f, -3.84101808e-01f, 2.70099252e-01f, -1.50482627e-02f, 2.68874347e-01f, 2.35200971e-01f, 6.11684442e-01f,
  -2.05542669e-01f, 6.28444999e-02f, 1.08591810e-01f, 2.26648241e-01f, -2.38184601e-01f, -1.59690589e-01f, 6.71873987e-02f, 1.30409628e-01f, -1.26381546e-01f, -2.47794449e-01f,
  2.43087746e-02f, 3.24382693e-01f, 7.13588148e-02f, 4.08340320e-02f, 1.39254015e-02f, -5.89153692e-02f, 5.70618629e-01f, 6.89917430e-02f, -3.52436341e-02f, 3.99409622e-01f,
  1.53971761e-02f, 9.78684500e-02f, 2.29682028e-01f, -1.09991536e-01f, 9.86482799e-02f, -1.83624536e-01f, 1.14984140e-01f, -2.17977464e-01f, -1.37489423e-01f, 4.93242331e-02f,
  1.78371593e-01f, 9.27810669e-02f, 7.46188406e-03f, -2.69140750e-02f, 1.37387469e-01f, 1.63793176e-01f, -1.02048315e-01f, 2.20794845e-02f, -5.73417060e-02f, 1.72207221e-01f,
  1.03571922e-01f, -1.04560181e-01f, -2.63759315e-01f, -1.17021585e-02f, 1.16090728e-02f, -2.98823476e-01f, -2.98150510e-01f, 4.45434116e-02f, 2.11678669e-02f, -1.19266093e-01f,
  -9.49265361e-02f, -1.08783036e-01f, -2.59721488e-01f, -4.52149473e-02f, -7.78994486e-02f, 2.75274161e-02f, -8.08381662e-02f, -1.73675135e-01f, -3.46874475e-01f, -6.55247942e-02f,
  -2.05257416e-01f, 3.92663032e-01f, -2.67364122e-02f, 3.51326108e-01f, -1.78154856e-01f, 1.77949101e-01f, -8.50968584e-02f, -1.54554561e-01f, 3.61791216e-02f, -1.16317280e-01f,
  2.21353278e-01f, -1.67133212e-01f, 4.52045724e-02f, 8.71802494e-02f, 6.00417256e-01f, 8.05726126e-02f, -4.07395959e-02f, -1.44705176e-01f, -1.10504150e-01f, -5.52696362e-02f,
  2.21702874e-01f, -2.43824378e-01f, -1.84274942e-01f, 2.03312546e-01f, 3.13021392e-01f, -3.34673077e-01f, -4.65487480e-01f, -2.60582924e-01f, -7.05052614e-02f, 2.43195087e-01f,
  -3.08764368e-01f, -1.33582398e-01f, -4.56833169e-02f, 1.39421403e-01f, -2.68269986e-01f, -3.35321903e-01f, -2.71904171e-01f, -1.19498491e-01f, -2.58153558e-01f, 6.54279813e-02f,
  3.24137866e-01f, 1.80564106e-01f, 4.90814273e-04f, -1.28422394e-01f, -1.30995646e-01f, -2.67136037e-01f, -2.17486188e-01f, -1.02390938e-01f, 9.64431986e-02f, -1.17351763e-01f,
  2.08815351e-01f, -3.60173509e-02f, 4.17613871e-02f, 2.53558476e-02f, 7.20739141e-02f, -4.95171808e-02f, -2.76813596e-01f, -2.82970548e-01f, -1.90925673e-01f, -4.72580910e-01f,
  -1.77453876e-01f, -2.15430722e-01f, -4.03933316e-01f, 3.05121243e-01f, -6.90734148e-01f, 3.76256645e-01f, 1.81509703e-01f, 2.20094487e-01f, -8.87319669e-02f, 6.94737509e-02f,
  -7.72855878e-02f, -1.26472805e-02f, 5.62598631e-02f, 7.53461346e-02f, 4.22279388e-01f, -4.43257913e-02f, -1.38122156e-01f, 4.11576927e-02f, 4.03423578e-01f, 1.15696557e-01f,
  -7.12210760e-02f, -1.05096281e-01f, -1.06914364e-01f, -1.50537908e-01f, 2.76685953e-01f, -1.43796265e-01f, 1.24163501e-01f, 7.73843676e-02f, -1.81779861e-01f, 1.97544843e-01f,
  1.42053524e-02f, -3.12145203e-01f, 8.12473893e-02f, -1.09692276e-01f, 1.72374919e-01f, -9.35669020e-02f, -9.67892781e-02f, -1.49294898e-01f, 1.57788470e-01f, -3.21064219e-02f,
  -1.44583061e-01f, -3.16033587e-02f, -3.58663779e-03f, 3.95363867e-01f, 6.65411279e-02f, -1.33613050e-01f, -1.68065771e-01f, -1.27308900e-02f, -1.70403942e-01f, -2.78180599e-01f,
  -2.44739607e-01f, -2.32451946e-01f, -2.88267136e-02f, 1.14877559e-01f, 1.73415944e-01f, 8.56897011e-02f, -1.19558267e-01f, 2.86127813e-02f, 1.47043943e-01f, 2.21796683e-03f,
  2.53459364e-01f, 6.60611019e-02f, -8.25275630e-02f, 3.85162652e-01f, 2.02466100e-01f, 1.68358967e-01f, -3.45954001e-01f, -2.76709229e-01f, 6.08939640e-02f, 2.41313249e-01f,
  7.05724135e-02f, 2.78841019e-01f, 1.80588067e-01f, -6.49198964e-02f, -1.15366206e-01f, 1.92119583e-01f, 7.34632090e-02f, 1.37071505e-01f, 1.24734342e-01f, 2.93258548e-01f,
  2.98299715e-02f, 1.06930830e-01f, -2.09229022e-01f, -1.13412969e-01f, 7.12604076e-02f, -2.44445413e-01f, 2.03992948e-01f, 2.38863640e-02f, 3.07544023e-01f, 3.83162975e-01f,
  -1.46834239e-01f, 8.73738527e-02f, 8.20132624e-03f, 1.11353695e-01f, 2.06928298e-01f, 1.99921310e-01f, -2.71630958e-02f, -2.14053262e-02f, 1.54426098e-01f, -3.11753284e-02f,
  -1.23228058e-01f, -7.59352446e-02f, -2.38962874e-01f, 4.86504018e-01f, -4.79868725e-02f, 4.06122487e-03f, 6.47675470e-02f, -1.05975114e-01f, 6.47322163e-02f, 4.02589999e-02f,
  -1.35710329e-01f, 8.56946260e-02f, 3.90121788e-02f, 1.27528355e-01f, 3.44279975e-01f, 1.36054710e-01f, -1.11578666e-02f, -6.31135404e-02f, -6.72392249e-02f, -1.47939563e-01f,
  7.07339793e-02f, 4.76937220e-02f, -8.21304172e-02f, -2.04015031e-01f, -9.63568315e-02f, 2.01286435e-01f, -2.08594650e-02f, -2.73602337e-01f, 1.74480483e-01f, 4.18498814e-01f,
  7.12219536e-01f, -6.85992092e-02f, 2.91801959e-01f, -6.85777366e-01f, -5.56536354e-02f, -5.66282511e-01f, -4.71204631e-02f, -1.15659453e-01f, 5.07164374e-02f, -1.16247877e-01f,
  -1.66237783e-02f, -7.29223788e-02f, -2.98783839e-01f, 8.59670937e-02f, -1.70849487e-01f, -1.30574688e-01f, -4.03010666e-01f, 2.61172563e-01f, 8.46175179e-02f, -9.01274905e-02f,
  -1.07133768e-01f, -3.15797292e-02f, -6.10523403e-01f, -4.98157591e-02f, 1.48085594e-01f, 1.94158018e-01f, -1.46602079e-01f, -1.84023380e-01f, 1.02967687e-01f, -1.37639549e-02f,
  1.56584397e-01f, -1.68734327e-01f, -9.98059437e-02f, -2.00257987e-01f, 1.39301285e-01f, -9.38597787e-03f, 6.54073298e-01f, 3.21587980e-01f, 1.25813112e-01f, 1.19108602e-01f,
  3.79378289e-01f, -1.64989695e-01f, -3.17182913e-02f, -1.71306103e-01f, -3.89270410e-02f, 1.79204077e-01f, 5.12753725e-02f, 1.29231840e-01f, 2.12025747e-01f, 3.85988742e-01f,
  -1.81436762e-01f, -7.20719025e-02f, -3.60667348e-01f, -1.59968406e-01f, -1.25278145e-01f, 2.99783885e-01f, -1.75984696e-01f, -2.32857510e-01f, -2.42921829e-01f, -1.84708878e-01f,
  -1.98923394e-01f, -3.29142928e-01f, -5.19359298e-02f, -3.69146168e-01f, 1.71428263e-01f, -1.61640987e-01f, -1.65560078e-02f, -1.57015190e-01f, -4.92770933e-02f, -3.01684052e-01f,
  -1.41444534e-01f, -9.92410854e-02f, -4.32413444e-02f, -1.63208500e-01f, 1.52953744e-01f, 2.08171904e-02f, -5.58364689e-02f, -8.88937265e-02f, -1.53440246e-02f, 2.85969287e-01f,
  -8.65019560e-02f, -4.01198715e-01f, -1.78932786e-01f, -7.72879124e-02f, 9.18937773e-02f, 1.39479488e-01f, -2.55966634e-01f, 2.81452209e-01f, -9.16751102e-03f, -1.17674649e-01f,
  2.07605988e-01f, -1.90847322e-01f, -2.38032013e-01f, -2.18859181e-01f, -2.76463062e-01f, -1.14176884e-01f, -1.59828290e-01f, 2.54583985e-01f, -6.27484247e-02f, -1.55981079e-01f,
  -1.90943420e-01f, 4.30086464e-01f, -2.61149287e-01f, -1.35974482e-01f, 6.93356171e-02f, -1.29415184e-01f, 1.49641901e-01f, 5.66164814e-02f, 5.17486036e-01f, -4.18839715e-02f,
  -6.94630062e-03f, -2.76593655e-01f, 2.20511034e-01f, -2.15390131e-01f, -4.44570370e-02f, 3.10136318e-01f, 2.73868322e-01f, 8.32533762e-02f, -2.40108855e-02f, -1.63678601e-01f,
  -1.82286695e-01f, 1.41106084e-01f, 2.39585578e-01f, -3.15501809e-01f, -1.95864230e-01f, 9.25008133e-02f, -2.98402876e-01f, 1.23067245e-01f, 1.32974073e-01f, -1.44833684e-01f,
  7.09006935e-02f, -5.99888563e-01f, -1.26862824e-01f, -6.62318468e-01f, 4.07614410e-01f, -7.05870315e-02f, -4.67705401e-03f, 1.69072092e-01f, -9.35811643e-03f, 3.36496145e-01f,
  -1.62891984e-01f, 9.37622786e-02f, 4.26637083e-01f, 8.50229934e-02f, -3.09309483e-01f, -3.09412450e-01f, -8.68071094e-02f, -1.56727037e-03f, 3.98360752e-02f, -2.57708747e-02f,
  -6.08950615e-01f, 3.17228824e-01f, 1.62775293e-01f, -2.32302785e-01f, -8.48140642e-02f, -4.74367812e-02f, 2.47884288e-01f, 3.76708746e-01f, -2.71086600e-02f, -3.40264197e-03f,
  2.69349962e-01f, 1.51262000e-01f, 2.55896747e-02f, -1.75624356e-01f, -2.36389235e-01f, -7.39042163e-02f, -3.32810134e-02f, 2.44556386e-02f, -1.36772186e-01f, -2.59205103e-01f,
  -1.24608941e-01f, -6.35690540e-02f, -1.74971387e-01f, -8.51821154e-02f, 2.29970157e-01f, 2.34643921e-01f, 9.28215459e-02f, 9.20685455e-02f, 5.49447201e-02f, 1.00072034e-01f,
  -6.77555576e-02f, 2.31433455e-02f, -2.51500611e-03f, -1.34936124e-01f, -9.88220498e-02f, 1.86590567e-01f, 3.29871595e-01f, 1.67884678e-02f, 4.70035881e-01f, 2.71573842e-01f,
  8.66072550e-02f, 4.57763463e-01f, 3.44347268e-01f, 2.64102697e-01f, -1.89289879e-02f, -4.10782069e-01f, 1.63527613e-03f, 1.19052805e-01f, -7.63638020e-02f, 8.30678642e-02f,
  3.86759453e-02f, 7.84608256e-03f, 1.39990836e-01f, -2.12211862e-01f, 1.70816869e-01f, -2.53185052e-02f, -1.29853219e-01f, -8.31778646e-02f, -3.36870067e-02f, 4.20308620e-01f,
  -5.73345646e-02f, -1.65305808e-01f, -2.08196357e-01f, 7.28419945e-02f, -6.44803196e-02f, 1.15027167e-01f, -2.11158141e-01f, 4.86086071e-01f, -1.93168614e-02f, -2.05991983e-01f,
  -2.23914534e-01f, -2.20939770e-01f, 1.81511715e-01f, -2.62553632e-01f, -1.31454423e-01f, -1.46202847e-01f, -8.45086649e-02f, 1.21362343e-01f, 3.70932460e-01f, 4.26708043e-01f,
  -7.18708634e-02f, -2.26593427e-02f, 1.18711852e-01f, 1.70994818e-01f, 5.74372001e-02f, -2.21090373e-02f, 2.77617753e-01f, 7.89031759e-02f, -5.61116524e-02f, -2.03284338e-01f,
  2.06594735e-01f, -1.01683296e-01f, -6.46526963e-02f, 5.52353896e-02f, -1.45704478e-01f, 7.10249767e-02f, -1.50627136e-01f, 6.93170959e-03f, -1.69798538e-01f, -7.09039867e-02f,
  -3.60424399e-01f, 2.23844931e-01f, 4.86852437e-01f, -9.02396590e-02f, 3.10496807e-01f, -1.19271753e-02f, -4.81900781e-01f, 4.00655940e-02f, -1.60180628e-02f, 4.44015533e-01f,
  -2.39340931e-01f, 5.19989431e-01f, -5.44253327e-02f, 1.20207518e-01f, 2.94386804e-01f, -1.81943268e-01f, -7.91343078e-02f, 6.44371808e-02f, 1.80845312e-03f, 7.45162219e-02f,
  2.31983319e-01f, -1.18305109e-01f, -1.78404301e-01f, -1.56108126e-01f, -1.60468325e-01f, 1.12501949e-01f, 1.31415233e-01f, -9.05075967e-02f, 5.73290050e-01f, -1.86180577e-01f,
  -3.17386717e-01f, -2.92643130e-01f, -2.93373764e-02f, 5.22521496e-01f, 1.75261963e-02f, 3.79749060e-01f, -2.54395902e-01f, 1.75644323e-01f, -9.10032243e-02f, -1.42070860e-01f,
  -1.68400109e-01f, 7.06361085e-02f, -3.75013471e-01f, -3.69065553e-01f, 7.80497044e-02f, -1.56977117e-01f, -2.06488132e-01f, -6.04548827e-02f, -2.31392488e-01f, -9.62912068e-02f,
  -2.70035416e-01f, -1.94549829e-01f, 3.38882878e-02f, -2.30089128e-01f, -2.97924280e-01f, -2.73078233e-01f, 1.97200656e-01f, -5.09001352e-02f, -1.35647103e-01f, -9.31493118e-02f,
  4.81342189e-02f, -2.14088857e-02f, 4.77402955e-01f, 8.44203085e-02f, -2.24967152e-01f, 5.25365248e-02f, -1.73637763e-01f, -1.57833938e-02f, -2.41323724e-01f, -2.52166659e-01f,
  3.14549387e-01f, -1.66101810e-02f, 2.65120808e-02f, 1.55146793e-02f, -3.76069576e-01f, -3.65476876e-01f, 2.96072781e-01f, 1.50545835e-02f, -5.53949401e-02f, 1.87096819e-02f,
  3.43494654e-01f, 2.32230444e-02f, -1.73799217e-01f, -9.24396217e-02f, 6.31164685e-02f, -2.02998780e-02f, -2.30218813e-01f, 1.70803696e-01f, 2.77474821e-01f, 9.50185135e-02f,
  -8.95191208e-02f, -1.18548408e-01f, -2.67542660e-01f, -2.50651278e-02f, 2.78282970e-01f, -2.18479857e-01f, 3.54145579e-02f, -2.47870103e-01f, 7.45024309e-02f, -2.32941806e-01f,
  4.00916725e-01f, -6.03394955e-02f, -1.73643708e-01f, 6.28666580e-02f, 3.11183278e-02f, -1.25903651e-01f, 4.07857627e-01f, -1.63359255e-01f, -1.77798271e-01f, 3.58466466e-04f,
  6.48329481e-02f, 7.74084255e-02f, -4.43120971e-02f, -1.06521167e-01f, -1.47288382e-01f, 7.52879605e-02f, -5.25240563e-02f, 3.54834683e-02f, 6.66666701e-02f, 1.53655469e-01f,
  6.34893999e-02f, 1.59125105e-01f, 3.26954752e-01f, 3.68686975e-03f, -1.27828829e-02f, 1.74796775e-01f, -1.27844185e-01f, -1.18777156e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.47220969e-01f, 1.03345495e-02f, 1.34221271e-01f, -7.96146467e-02f, 3.07058301e-02f, 1.49981230e-02f, 8.79200324e-02f, -2.06872895e-01f, 4.44289744e-02f, -3.62102203e-02f,
  2.09701061e-02f, -4.65540402e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    