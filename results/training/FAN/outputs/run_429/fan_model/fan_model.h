/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.30464989e-02f, 6.21641204e-02f, -2.65874505e-01f, 5.00115231e-02f, 1.62177518e-01f, 1.13179266e-01f, -2.61508971e-01f, 1.94760472e-01f, -3.75803709e-01f, 1.71231836e-01f,
  8.42891186e-02f, 3.16216983e-02f, -2.35690683e-01f, 1.78742975e-01f, 2.52886908e-03f, -3.03607136e-01f, 1.60377681e-01f, 1.16023637e-01f, -1.09645188e-01f, 2.13099465e-01f,
  -5.01309261e-02f, 1.69201419e-01f, 2.02263165e-02f, 3.11715782e-01f, 9.83096212e-02f, 3.39047574e-02f, 1.66089430e-01f, -6.22289488e-04f, 3.84085059e-01f, 4.28669490e-02f,
  1.01994768e-01f, -1.24876298e-01f, -6.56583756e-02f, 5.39494166e-03f, 6.05657548e-02f, -2.94075962e-02f, 1.10536059e-02f, -1.94709394e-02f, -5.45640402e-02f, 5.08038625e-02f,
  -4.60836552e-02f, -5.47659025e-03f, 4.22935793e-03f, -3.69871221e-02f, -7.05600604e-02f, -1.22077810e-02f, 7.98556767e-03f, -1.50724938e-02f, -4.28971834e-02f, -1.29526956e-02f,
  -5.55133112e-02f, 1.04575856e-02f, -1.48083931e-02f, -1.09936274e-03f, -1.05019044e-02f, 2.17636880e-02f, -1.96632426e-02f, 5.56990989e-02f, -8.37655962e-02f, 2.23686881e-02f,
  -4.50335443e-02f, 3.98416771e-03f, 2.24759486e-02f, 1.76957548e-02f, 4.46731970e-03f, -1.72596355e-03f, 2.29397020e-03f, 1.02801546e-02f, -1.57175511e-02f, 4.91580777e-02f,
  1.19020246e-01f, -3.90616916e-02f, -6.95084408e-02f, -4.95503843e-02f, 4.60412838e-02f, -2.93136295e-02f, 7.58929737e-03f, -1.71562377e-03f, 3.48536707e-02f, -5.72117269e-02f,
  -7.14164227e-02f, -3.51600931e-03f, 5.97040877e-02f, -4.65055332e-02f, -5.52636432e-03f, -2.10902095e-02f, -5.67035899e-02f, -5.80235012e-02f, -1.91065688e-02f, 2.60750744e-02f,
  1.68040857e-01f, 1.27251327e-01f, 6.16804622e-02f, 4.67252694e-02f, 7.03911260e-02f, 1.03962809e-01f, -1.84054468e-02f, -5.51600708e-03f, 5.82068637e-02f, 3.07502206e-02f,
  9.36377123e-02f, 3.52478735e-02f, -2.49972064e-02f, 5.27126249e-03f, 2.14571394e-02f, 4.84288484e-02f, -3.49481180e-02f, 7.15771541e-02f, 6.00254424e-02f, 1.76084880e-02f,
  1.27341812e-02f, 2.36092582e-02f, 2.30587535e-02f, 2.34446451e-02f, 6.69577643e-02f, -3.49395834e-02f, 9.80049092e-03f, 2.43370067e-02f, 4.85673882e-02f, -3.01928911e-02f,
  2.49390811e-01f, 1.72326297e-01f, -4.66564968e-02f, 7.20992163e-02f, -1.38809144e-01f, -1.25946909e-01f, -2.45337293e-01f, 5.29957674e-02f, -4.43666875e-02f, 1.14962950e-01f,
  -1.32213071e-01f, -5.22230007e-02f, 4.03837599e-02f, -7.99083561e-02f, -1.29913151e-01f, 1.21171519e-01f, 2.96744127e-02f, 2.32844520e-03f, 4.19156700e-02f, 1.09303400e-01f,
  7.11404905e-02f, -3.86936925e-02f, -1.13684624e-01f, 4.20190729e-02f, -3.18920352e-02f, 1.13665313e-01f, 1.52629554e-01f, -8.33961964e-02f, -9.91526768e-02f, -9.90579948e-02f,
  2.64966227e-02f, 6.04043230e-02f, -1.82410017e-01f, -3.91901433e-02f, 5.59768043e-02f, 4.27100770e-02f, 1.82632764e-03f, 3.72786191e-03f, 6.99175475e-03f, 1.16360821e-02f,
  3.14445458e-02f, 6.66374806e-03f, -6.78454340e-02f, -7.31622875e-02f, 4.17340882e-02f, -7.01211840e-02f, -2.83624902e-02f, -2.45269760e-02f, 4.47662883e-02f, -7.51906410e-02f,
  -4.54352237e-02f, 1.51346410e-02f, 3.16378921e-02f, -6.19956432e-03f, -5.01223914e-02f, 1.75855141e-02f, 8.49192403e-03f, -1.38338134e-01f, 6.23112544e-02f, -6.93039894e-02f,
  2.40604440e-03f, 8.02005976e-02f, -7.63771171e-03f, -8.85023773e-02f, -2.41490658e-02f, -5.17247915e-02f, 8.49087257e-03f, -1.65600590e-02f, -8.39126855e-03f, 4.91293520e-02f,
  2.81794909e-02f, 2.41474677e-02f, -2.88856886e-02f, -1.39909855e-03f, 5.71508966e-02f, 6.27527770e-04f, 9.31852013e-02f, -2.56740325e-03f, 2.20602639e-02f, -6.44213753e-03f,
  6.60857605e-03f, 1.07141599e-01f, -3.39576975e-02f, 1.19964525e-01f, 1.30942222e-02f, -2.04684231e-02f, -6.00728616e-02f, -4.30646501e-02f, -9.41648334e-02f, 2.22714292e-03f,
  2.98168838e-01f, 2.87629515e-01f, -2.25797668e-02f, 7.71516992e-04f, -4.30232100e-02f, -3.72477286e-02f, 1.99067360e-03f, -6.54531345e-02f, 4.12639938e-02f, 1.96132176e-02f,
  -2.74046361e-02f, 1.88121274e-02f, 1.21013775e-01f, 9.04464647e-02f, 1.34717021e-02f, 4.51648086e-02f, 5.18761575e-02f, 3.39631476e-02f, 2.41991021e-02f, 6.43343031e-02f,
  5.78604406e-03f, -1.48819666e-02f, -7.23086447e-02f, 2.90271137e-02f, 7.79450163e-02f, -4.41417396e-02f, 1.47900572e-02f, -6.00389242e-02f, 1.49331102e-02f, 2.87759211e-02f,
  4.55722451e-01f, -4.02290970e-01f, 1.42590880e-01f, -1.18123800e-01f, 2.18001321e-01f, 1.51742235e-01f, 2.08032429e-01f, -1.54537082e-01f, 6.32071123e-02f, -2.29858816e-01f,
  2.35586818e-02f, 4.93139066e-02f, -1.12594791e-01f, -1.26818523e-01f, 3.61100256e-01f, -1.32447183e-01f, 8.61563310e-02f, -2.90103611e-02f, -3.14756297e-02f, -8.05762336e-02f,
  6.26054555e-02f, -8.82858410e-02f, 3.78109771e-03f, -1.69227034e-01f, 6.99425209e-03f, 1.66802965e-02f, 9.74111333e-02f, 3.24141122e-02f, -4.92249504e-02f, 2.42684595e-02f,
  -2.78470316e-03f, -1.74224198e-01f, 6.81460276e-02f, -7.24799233e-03f, -4.88830432e-02f, 2.29907539e-02f, 3.96880098e-02f, 9.46244374e-02f, 3.78453024e-02f, 2.84502693e-02f,
  5.28654866e-02f, -5.77076040e-02f, -3.78625770e-03f, -9.44077037e-03f, 4.43607457e-02f, -1.71545311e-03f, -4.45939936e-02f, -1.06901070e-02f, -3.67045179e-02f, -7.08992034e-03f,
  2.22650287e-03f, -6.00025877e-02f, 7.50378752e-03f, -1.88488588e-02f, 1.44425156e-02f, -1.36924321e-02f, -2.96887010e-02f, 4.65076156e-02f, 2.28320304e-02f, -4.05570418e-02f,
  4.46396647e-03f, 5.84477037e-02f, 3.70128714e-02f, -4.97106696e-03f, -2.59898491e-02f, -1.47966621e-02f, 4.73998711e-02f, -1.76894460e-02f, 1.63152721e-02f, 2.13597175e-02f,
  -2.82426048e-02f, 2.42103636e-02f, 1.79567449e-02f, 4.50187596e-03f, 4.75369906e-03f, 2.60508582e-02f, 3.94187160e-02f, 2.76118256e-02f, -1.86946876e-02f, 5.59414290e-02f,
  1.64535344e-02f, -3.75038199e-02f, -2.17891904e-03f, -1.96418017e-02f, -4.87972982e-04f, 6.35017827e-02f, -1.27112225e-03f, -5.93434423e-02f, 4.85111438e-02f, 3.09342630e-02f,
  -2.06599589e-02f, -5.76428100e-02f, 1.68376435e-02f, -3.95058952e-02f, 3.47413197e-02f, 3.05244233e-02f, 8.62835441e-03f, -2.45279726e-02f, -6.56678379e-02f, 2.20000278e-02f,
  4.02974226e-02f, 3.05065531e-02f, -3.26350890e-02f, -1.14288554e-03f, -3.92109454e-02f, -2.75977086e-02f, 2.05622874e-02f, 1.97887160e-02f, 2.78086197e-02f, -1.57051440e-02f,
  1.82364658e-02f, 5.11353537e-02f, -1.04477908e-02f, -4.95571876e-03f, -1.76922064e-02f, -1.69252965e-03f, 5.25054000e-02f, -2.86844131e-02f, 2.77029630e-03f, -1.88705474e-02f,
  4.63538736e-01f, 5.36852367e-02f, -1.09169930e-01f, 2.06566513e-01f, 2.61938393e-01f, -9.17405412e-02f, -1.14083067e-01f, 1.08988017e-01f, 1.97955251e-01f, 5.87491207e-02f,
  -1.58578619e-01f, 2.68863916e-01f, -2.34290987e-01f, -7.83435907e-03f, 1.31201878e-01f, -2.37518489e-01f, 1.56551123e-01f, 1.90176594e-03f, 4.77217808e-02f, 1.22617647e-01f,
  9.67732146e-02f, -3.07341628e-02f, -1.00832626e-01f, -1.36738807e-01f, 1.94205001e-01f, 5.27840666e-02f, -7.07091466e-02f, -2.49283314e-02f, 8.49012882e-02f, 4.95280027e-02f,
  -1.22295961e-01f, 1.14704952e-01f, -2.02348251e-02f, 5.84927248e-03f, 5.26735261e-02f, -1.73908491e-02f, 2.50313226e-02f, -6.36742190e-02f, -5.99910133e-02f, -2.14543026e-02f,
  6.23254366e-02f, 6.87469691e-02f, -5.51909730e-02f, -7.44611099e-02f, 7.27941692e-02f, -2.07227515e-03f, 1.23204380e-01f, -4.66805138e-03f, -4.22558598e-02f, 1.23870624e-02f,
  -7.28534684e-02f, 1.27761997e-02f, 3.68521325e-02f, 9.24410596e-02f, 5.94562553e-02f, 1.28166854e-01f, 1.05568506e-01f, 7.52938986e-02f, 1.24728449e-01f, 1.13046736e-01f,
  5.01083061e-02f, 6.82259426e-02f, -9.73769352e-02f, -6.87807659e-03f, 3.58543023e-02f, 1.64226778e-02f, -1.72089338e-02f, -1.34227509e-02f, 9.11699459e-02f, -2.83891521e-02f,
  2.05472969e-02f, -1.37826074e-02f, 6.15657680e-02f, -3.41508016e-02f, 2.07807589e-02f, -4.80054170e-02f, -3.75448242e-02f, -6.60970509e-02f, 1.08211212e-01f, -3.35308127e-02f,
  -6.65486231e-02f, 4.24810052e-02f, 2.86820601e-03f, 2.07823664e-02f, -4.53890003e-02f, 3.45471390e-02f, 2.57188119e-02f, -1.72654111e-02f, 3.41708660e-02f, -3.49457585e-03f,
  1.18794300e-01f, 3.03343594e-01f, -4.27577905e-02f, 9.23424959e-02f, -1.82473753e-02f, 4.77084666e-02f, -7.34769925e-02f, 6.93746880e-02f, -5.18030301e-02f, 5.43404631e-02f,
  4.05379990e-03f, -3.32668275e-02f, 1.83848962e-01f, 2.85429936e-02f, -3.92823219e-02f, 6.17864802e-02f, 6.90069841e-03f, 1.84070244e-02f, 9.30339098e-02f, 3.72654870e-02f,
  -4.26778793e-02f, -4.12940467e-03f, 4.46584485e-02f, 4.68836762e-02f, 1.08507033e-02f, 3.43248285e-02f, 5.09555358e-03f, -6.65834453e-03f, -5.89322783e-02f, 6.10872954e-02f,
  -3.08237284e-01f, -2.60709912e-01f, -2.09299192e-01f, -9.70493853e-02f, 7.22965747e-02f, -2.48168543e-01f, -1.29825860e-01f, -2.87805013e-02f, -3.31347287e-01f, 1.54639839e-03f,
  2.40923643e-01f, -2.71128386e-01f, 1.17237143e-01f, 3.56203355e-02f, 9.68519151e-02f, 6.18973598e-02f, 1.18751712e-01f, 9.65541229e-03f, -6.54170439e-02f, 3.16482759e-03f,
  -1.71832964e-02f, 2.79479682e-01f, 1.72097668e-01f, 6.50878027e-02f, 6.11548498e-02f, -4.23747450e-02f, 3.27528268e-01f, -8.70347694e-02f, 1.48775145e-01f, 8.76921937e-02f,
  2.46896241e-02f, 2.79140100e-02f, -6.96752444e-02f, -4.28072922e-02f, 1.17006510e-01f, -2.48827897e-02f, 2.87815519e-02f, 2.30009481e-02f, -2.31197048e-02f, -2.43818723e-02f,
  -6.65773898e-02f, 4.92270067e-02f, -7.82037899e-03f, -5.22329751e-03f, -4.36787866e-02f, -4.86977547e-02f, -6.32755086e-02f, -1.55676240e-02f, -2.55309492e-02f, 2.48851422e-02f,
  -6.32187054e-02f, 4.62682322e-02f, 5.17919548e-02f, 1.76925696e-02f, -6.31691366e-02f, 1.19880503e-02f, -5.62287942e-02f, 3.28445286e-02f, -5.89656876e-03f, -5.30759431e-02f,
  9.39974263e-02f, 1.49360560e-02f, -5.09644486e-02f, 5.94934411e-02f, 7.51960836e-03f, 4.64344434e-02f, 3.58010852e-03f, 7.71206170e-02f, -8.37043300e-02f, 7.43145216e-03f,
  2.63312589e-02f, -5.86712062e-02f, 1.22884056e-02f, -8.02831650e-02f, -2.54212832e-03f, 3.91507149e-02f, 3.01024262e-02f, 3.06320079e-02f, -2.03055684e-02f, 3.29365162e-03f,
  -6.39462890e-03f, 4.20983285e-02f, -2.27741431e-02f, 4.67892736e-02f, 6.88583180e-02f, -2.59092618e-02f, -2.40269974e-02f, -1.53771145e-02f, 5.62831536e-02f, 3.03359069e-02f,
  1.33045092e-01f, 1.45208193e-02f, -5.03871776e-03f, -2.98344949e-03f, -1.14013471e-01f, 3.33749838e-02f, -1.58384144e-02f, 4.00463641e-02f, -8.98953527e-02f, 6.09947480e-02f,
  3.53001058e-02f, -9.17490274e-02f, 2.09209248e-02f, 5.79940751e-02f, -1.59734786e-02f, 5.98791204e-02f, 5.08464612e-02f, -4.57327999e-02f, 4.30106930e-02f, -2.10601017e-02f,
  6.07222952e-02f, -6.30483404e-02f, -6.92413822e-02f, 1.87929366e-02f, 8.85972753e-02f, 1.81808658e-02f, -1.81382522e-02f, -5.59003092e-02f, 7.19391480e-02f, 6.41733815e-04f,
  4.60132621e-02f, -3.58056962e-01f, 1.62789971e-01f, -4.79972273e-01f, 8.79733562e-02f, -2.74537385e-01f, -2.86878377e-01f, -5.81991225e-02f, -1.49760202e-01f, -2.45152324e-01f,
  -1.12813711e-01f, -2.49679089e-02f, -2.10373737e-02f, -4.16515648e-01f, 1.18866682e-01f, -9.67700705e-02f, -3.09665233e-01f, -1.77713841e-01f, 2.20580790e-02f, -1.53567672e-01f,
  4.32381071e-02f, -2.93253481e-01f, -1.87920174e-04f, -7.25506712e-03f, -9.20450240e-02f, 4.42160256e-02f, 6.92824125e-02f, 1.36569649e-01f, -7.53186271e-02f, 1.57906897e-02f,
  -4.09182869e-02f, -1.15977198e-01f, -1.36614740e-02f, 6.58399835e-02f, 1.12458095e-02f, 4.15769182e-02f, -1.94600448e-02f, 4.28806618e-03f, -7.33192218e-03f, -1.54115967e-02f,
  2.97159282e-03f, 2.22824477e-02f, -4.08173501e-02f, 1.87896763e-03f, 1.66202523e-02f, 6.76182806e-02f, 2.45606527e-02f, -2.55706459e-02f, 1.57300252e-02f, -2.51082703e-02f,
  -3.83599196e-03f, 8.07755440e-03f, -3.09589710e-02f, 4.78055794e-03f, 9.45793167e-02f, -4.65376154e-02f, -1.42448954e-02f, 2.10726708e-02f, -6.81485143e-03f, 1.09985964e-02f,
  5.25097735e-02f, 6.93645999e-02f, -1.14772907e-02f, -5.32917911e-03f, 1.07897155e-03f, 3.47384834e-03f, 2.03128974e-03f, 4.19273116e-02f, 7.93179590e-03f, -1.08377161e-02f,
  -3.76170129e-02f, -1.86746716e-02f, -7.35416717e-04f, -1.91637233e-03f, -2.24676654e-02f, -3.26991528e-02f, 3.62258740e-02f, 1.22707365e-02f, -5.96106797e-03f, -1.12725152e-02f,
  1.08544109e-02f, -3.66983423e-03f, -1.02805058e-02f, 3.34297419e-02f, -6.82886969e-03f, 4.95103095e-03f, 5.54580661e-03f, 3.05051357e-02f, -1.33673344e-02f, 3.74964774e-02f,
  -4.90772389e-02f, 2.01414749e-02f, -5.33082187e-02f, -5.58441691e-03f, -3.78163904e-02f, -4.66975681e-02f, 1.01067191e-02f, 4.43859324e-02f, 2.60870196e-02f, 2.31587272e-02f,
  -1.25216171e-02f, -9.16157570e-03f, 3.87948379e-02f, 1.24619734e-02f, -3.30025852e-02f, -1.39544560e-02f, -1.80349324e-03f, 3.53565961e-02f, -1.32962605e-02f, -1.50811775e-02f,
  1.04738194e-02f, -2.68031582e-02f, 1.00924335e-02f, 9.47116688e-03f, -5.18137589e-02f, 5.62936440e-02f, -8.49805307e-03f, 2.23521646e-02f, -1.61487283e-03f, -1.43631203e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.45022130e-01f, -4.43688720e-01f, -5.25550187e-01f, -2.17870265e-01f, 7.93108195e-02f, -4.63887185e-01f, -2.86728680e-01f, -1.55741304e-01f, -4.65393625e-02f, 2.52563417e-01f,
  -6.14324696e-02f, -1.00156888e-01f, 9.49324146e-02f, -3.14188808e-01f, -5.22586346e-01f, -7.27615729e-02f, -4.20677304e-01f, -1.15732856e-01f, -5.95439784e-03f, -2.32482359e-01f,
  -1.81150883e-01f, -1.87728167e-01f, -3.82951677e-01f, -7.55332336e-02f, -2.30461091e-01f, 1.92469627e-01f, 3.92663985e-01f, -7.32581690e-02f, -8.25365558e-02f, -3.19931656e-03f,
  -2.33304247e-01f, -1.97186731e-02f, 1.40920114e-02f, -5.99231422e-02f, -8.93676430e-02f, 1.65724978e-02f, -2.13957895e-02f, 1.02501139e-01f, 1.49360314e-01f, -6.84472769e-02f,
  5.33463992e-02f, 1.52588671e-03f, -4.58709858e-02f, -1.12029433e-03f, 1.03847124e-01f, -1.23130735e-02f, -4.66157608e-02f, 1.87327191e-02f, -5.65368906e-02f, -1.73060060e-01f,
  -1.21835016e-01f, -1.39490999e-02f, 6.80333525e-02f, -1.48622803e-02f, -3.54471020e-02f, -1.81114320e-02f, 6.55926317e-02f, 7.12720528e-02f, 4.25088666e-02f, 1.76546238e-02f,
  -9.32502467e-03f, -4.70134756e-03f, 4.08333093e-02f, 6.69680461e-02f, -3.91899273e-02f, 5.88927045e-02f, -7.69965798e-02f, -8.36393883e-05f, 3.79644334e-03f, -4.53171209e-02f,
  -3.58222499e-02f, -3.14374529e-02f, 2.60489304e-02f, 1.17623704e-02f, -5.27126417e-02f, 5.59581742e-02f, -1.57744158e-02f, 2.14949641e-02f, -9.24072191e-02f, -1.89003386e-02f,
  1.54045708e-02f, -9.51826349e-02f, 2.00679656e-02f, 5.52922934e-02f, -4.64508571e-02f, -8.56729820e-02f, -1.30547835e-02f, -7.53652528e-02f, 2.46312451e-02f, 7.03157336e-02f,
  9.31885391e-02f, -5.00134043e-02f, 1.72059126e-02f, 9.37187672e-03f, 6.81476146e-02f, 1.38188675e-02f, -7.72697255e-02f, -1.08191364e-01f, -1.82555914e-02f, 2.97807008e-02f,
  1.99374165e-02f, 3.83811742e-02f, -4.27401513e-02f, -6.27664104e-02f, -1.05434448e-01f, 2.62409206e-02f, 8.03361684e-02f, -3.78784463e-02f, -1.31218685e-02f, 6.71815351e-02f,
  4.28380705e-02f, 2.88939662e-02f, -1.19678617e-01f, -3.83376167e-03f, -7.46957138e-02f, -2.74586137e-02f, 1.99552290e-02f, 1.95622500e-02f, 1.15661258e-02f, -4.87392023e-03f,
  7.32041836e-01f, -2.41253972e-01f, -3.47740650e-02f, 4.26307321e-01f, 2.84301996e-01f, -2.12515250e-01f, -2.41838008e-01f, 3.16754669e-01f, 2.59114891e-01f, -2.46196821e-01f,
  9.45245102e-02f, -2.39135578e-01f, -2.83151656e-01f, 2.01442853e-01f, 2.12398186e-01f, -2.83425033e-01f, 3.77390534e-01f, 7.51658750e-04f, 1.13106467e-01f, 1.20228477e-01f,
  1.97271481e-01f, 4.49980259e-01f, 1.38102427e-01f, 1.73267007e-01f, 1.73036665e-01f, 1.58141270e-01f, 2.42439896e-01f, -1.14433676e-01f, 1.28171802e-01f, -4.17114496e-02f,
  2.35499348e-02f, 5.52276429e-03f, -5.44085819e-03f, -3.74071929e-03f, 1.12528047e-02f, -9.41293240e-02f, -1.29514337e-01f, -1.58933565e-01f, 2.29491312e-02f, -1.49570089e-02f,
  -8.87967348e-02f, 6.96058124e-02f, 4.01984081e-02f, 2.19696052e-02f, 1.87462047e-02f, -3.94313149e-02f, 7.67307580e-02f, 4.40545380e-02f, 1.21440804e-02f, -4.59969826e-02f,
  2.62649562e-02f, 4.87109236e-02f, 1.37861231e-02f, -6.54766262e-02f, 4.81601059e-02f, 6.89262599e-02f, 4.70646797e-03f, -9.76366177e-02f, 6.73871785e-02f, 5.16305789e-02f,
  2.68936972e-03f, -5.04290983e-02f, -2.28908584e-02f, 5.50167356e-03f, 5.03203720e-02f, 6.56486750e-02f, 7.10964799e-02f, -5.83144538e-02f, 1.98707059e-02f, -4.16097678e-02f,
  5.11759184e-02f, 5.27900979e-02f, 7.80228823e-02f, 3.73178767e-03f, 3.68177481e-02f, -1.73452776e-02f, 1.10563065e-03f, -6.41988516e-02f, -2.74910368e-02f, 7.40858167e-02f,
  -4.91131982e-03f, 1.22587875e-01f, -4.21070047e-02f, 1.86146852e-02f, 5.79478405e-02f, -4.11963165e-02f, 6.24787733e-02f, -7.64211267e-02f, -7.12729916e-02f, -2.10297033e-02f,
  -1.18595824e-01f, -5.84973656e-02f, -7.64219165e-02f, -1.35126449e-02f, -7.34567121e-02f, -7.44847488e-03f, 4.21782695e-02f, 1.45105779e-01f, 5.23754843e-02f, 5.27559686e-03f,
  -1.93132367e-02f, -1.01334257e-02f, -1.03012420e-01f, 7.43467063e-02f, 1.87471248e-02f, 1.00998497e-02f, -1.98479127e-02f, 1.57432016e-02f, -6.78153243e-03f, 5.80297187e-02f,
  -6.86043873e-02f, -5.23558147e-02f, -5.71085252e-02f, 2.67777033e-02f, 1.12345554e-02f, -5.98644139e-03f, -4.63174023e-02f, 5.97373173e-02f, -4.54833582e-02f, 2.08540224e-02f,
  2.09263593e-01f, 4.79883611e-01f, 3.05901349e-01f, 4.69751447e-01f, -1.48467451e-01f, -3.63511652e-01f, -8.15790594e-02f, 1.93013459e-01f, 1.96455479e-01f, -1.44444108e-01f,
  -1.13973275e-01f, 3.62336189e-01f, -1.96836982e-02f, 1.50032192e-01f, 4.50166613e-02f, 3.09773646e-02f, 4.47019376e-02f, -1.03043787e-01f, 1.10784598e-01f, 7.02637583e-02f,
  1.06079303e-01f, 1.17862225e-02f, 8.87296200e-02f, 2.35359892e-02f, 9.00059342e-02f, 8.60077888e-02f, 1.86088547e-01f, 2.30921581e-01f, 7.69069344e-02f, 1.56643633e-02f,
  -7.70842209e-02f, 1.82460681e-01f, 1.04224928e-01f, 2.32786965e-02f, -1.20431427e-02f, -1.89033210e-01f, -4.25371854e-03f, -4.47361544e-03f, -1.18635476e-01f, 3.86012793e-02f,
  -1.28115848e-01f, -1.37244584e-02f, -6.44614995e-02f, 2.20900420e-02f, 7.10462919e-04f, -1.72850993e-02f, -1.16907824e-02f, -9.51604843e-02f, -1.49124926e-02f, 1.19927777e-02f,
  -5.35375997e-02f, -5.21844737e-02f, 2.57603470e-02f, 5.50245680e-03f, 2.27055717e-02f, 5.41928001e-02f, 2.93940846e-02f, 8.86591971e-02f, 5.16949892e-02f, 4.97663058e-02f,
  2.26280149e-02f, 2.04578843e-02f, 4.34446186e-02f, -2.58816574e-02f, -7.35811293e-02f, -8.39857161e-02f, 4.25386541e-02f, -2.79055089e-02f, 9.30333808e-02f, 9.18228086e-03f,
  9.24434513e-03f, 4.38395664e-02f, -8.65981355e-02f, -1.21487908e-01f, -3.30807939e-02f, 2.63773035e-02f, -9.96046513e-02f, 3.77829596e-02f, 4.73242067e-02f, -2.11505387e-02f,
  3.21308225e-02f, 2.49274299e-02f, 4.77733165e-02f, 4.07785140e-02f, 6.75023720e-02f, 2.40253936e-03f, 3.37109156e-02f, -2.88252123e-02f, 1.52671020e-02f, 6.31957054e-02f,
  2.43616730e-01f, 3.66965294e-01f, 1.76481139e-02f, -5.22127412e-02f, 1.84622873e-02f, 6.72694147e-02f, -1.45558668e-02f, 1.41175061e-01f, 2.03345373e-01f, 2.00115070e-01f,
  3.21651697e-02f, -8.90865847e-02f, -3.85872945e-02f, -8.87335613e-02f, 4.69361618e-02f, 2.21253350e-01f, 1.06318884e-01f, -1.25970617e-01f, 8.09045359e-02f, -6.89071044e-03f,
  -9.54132304e-02f, -9.79540870e-02f, -1.01362564e-01f, 3.07420027e-02f, -9.54600424e-02f, 8.49432424e-02f, -7.08738416e-02f, -1.22973002e-01f, -7.51683041e-02f, 9.83588398e-02f,
  4.00964379e-01f, 3.92784387e-01f, 2.48986661e-01f, 2.67345816e-01f, -2.09924161e-01f, -6.60594702e-01f, -3.79943192e-01f, 2.17814483e-02f, -1.07106514e-01f, 9.53560695e-02f,
  -2.14065015e-01f, 4.97501940e-01f, -1.38158128e-01f, 8.86904448e-02f, -5.54084003e-01f, -2.09497079e-01f, -1.95683725e-02f, 1.18187368e-01f, -6.17068522e-02f, 1.32234186e-01f,
  9.03673321e-02f, -2.80292869e-01f, 1.99095756e-01f, -1.59052104e-01f, 1.51981056e-01f, 2.84663230e-01f, 1.76528115e-02f, 3.41848545e-02f, 1.74489424e-01f, -1.52806014e-01f,
  -1.06731541e-01f, 7.81995058e-02f, 8.05890858e-02f, 8.14053193e-02f, 1.73807684e-02f, 4.82334979e-02f, 6.10191263e-02f, -7.22835511e-02f, 1.83546338e-02f, 3.79422270e-02f,
  7.72410706e-02f, -3.66580226e-02f, -6.04401231e-02f, -7.41345901e-03f, -4.96857166e-02f, 7.43668079e-02f, 3.33406739e-02f, 2.24709213e-01f, 1.31943673e-01f, 1.54856473e-01f,
  1.19546980e-01f, 3.94622125e-02f, 9.19973031e-02f, 2.74269022e-02f, 1.11457922e-01f, 2.11050790e-02f, -8.60733911e-02f, 2.63013206e-02f, 5.87618463e-02f, -1.55236144e-02f,
  -2.16897521e-02f, -3.84448245e-02f, -2.68123634e-02f, 7.35852197e-02f, -3.44460234e-02f, 1.76480804e-02f, 9.21139214e-03f, -4.16596346e-02f, -4.23002467e-02f, -1.29134402e-01f,
  -1.24263465e-01f, 2.91248932e-02f, -1.19254842e-01f, -1.07232323e-02f, -2.75605284e-02f, 5.76033480e-02f, -4.64021694e-03f, 5.74596077e-02f, 9.01081860e-02f, 3.59145179e-02f,
  1.35428505e-02f, -5.64180911e-02f, 1.76418945e-02f, 2.92801112e-02f, -7.77237788e-02f, -1.43020218e-02f, -8.39103886e-04f, 1.01608947e-01f, 5.87804825e-04f, -7.73221394e-03f,
  -3.83105390e-02f, 7.37370737e-03f, -1.09401993e-01f, -2.18437761e-02f, 1.52920252e-02f, -3.80698405e-02f, -2.44500283e-02f, 5.88628929e-03f, -4.76110280e-02f, -2.27862686e-01f,
  6.57317117e-02f, 4.04704809e-02f, 6.83318777e-03f, -4.26793844e-02f, 1.73690934e-02f, 9.18607507e-03f, 1.60335973e-02f, 1.64466649e-02f, 3.30093093e-02f, -1.84642691e-02f,
  1.42377242e-01f, -2.19535269e-02f, -1.16762698e-01f, -1.01144582e-01f, -1.37992408e-02f, -4.73519713e-02f, 3.30303609e-02f, 1.29356338e-02f, 1.01784943e-02f, -4.85346727e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  2.93554664e-01f, 1.23240158e-01f, -2.26554379e-01f, -1.47669137e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.24675462e-01f, -3.08138877e-01f, -2.25463793e-01f, 2.72599548e-01f, 1.30958840e-01f, 2.48728916e-01f, 1.89598337e-01f, 2.20045075e-01f, 1.05696797e-01f, -8.13681260e-02f,
  2.76990145e-01f, 1.81812212e-01f, -4.12789553e-01f, 4.55241352e-01f, 1.66302636e-01f, -1.82598799e-01f, 1.39637887e-01f, -2.34554354e-02f, -1.03723682e-01f, 1.85124934e-01f,
  9.29227769e-02f, 7.42857814e-01f, -4.37656417e-02f, -4.67999838e-02f, -5.75187653e-02f, -4.67069335e-02f, -4.99942377e-02f, 6.54081345e-01f, 8.69379789e-02f, -4.37218428e-01f,
  -2.56180912e-01f, -1.66349351e-01f, -9.94732529e-02f, -9.67099965e-02f, 2.28671022e-02f, 2.20284104e-01f, -4.25128601e-02f, -4.97346431e-01f, 4.02198881e-01f, 5.47839522e-01f,
  -2.92335331e-01f, 4.92196500e-01f, 1.94552705e-01f, -2.96982914e-01f, 2.50123322e-01f, -1.64916232e-01f, -2.28122417e-02f, 4.39498425e-01f, 3.44484866e-01f, 5.98279655e-01f,
  -1.80619821e-01f, 6.02559485e-02f, -2.66874552e-01f, 3.60263675e-01f, -3.81659985e-01f, -3.08741421e-01f, -6.20994985e-01f, -2.18134880e-01f, -4.08749640e-01f, -2.25331411e-01f,
  -2.25838512e-01f, -1.11022696e-01f, 2.37139076e-01f, 1.35109693e-01f, -3.47392946e-01f, -2.82557130e-01f, 7.52958477e-01f, 2.35255316e-01f, -1.42647386e-01f, -5.97431266e-04f,
  5.88916302e-01f, 1.34737372e-01f, 3.76841128e-01f, 4.76207614e-01f, 1.16450168e-01f, 3.92003536e-01f, 1.14785559e-01f, 3.15801740e-01f, -1.25440732e-01f, 2.58201838e-01f,
  3.87969196e-01f, 1.68898508e-01f, 3.90691578e-01f, -1.06647596e-01f, -1.21999405e-01f, -4.07130420e-01f, -2.77985871e-01f, 2.64051855e-01f, -3.88434529e-01f, -3.17272991e-01f,
  -1.65156499e-01f, -3.39892745e-01f, 1.17131723e-02f, 6.17843829e-02f, 4.91181344e-01f, 2.77603358e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  8.22314934e-04f, 1.48823246e-01f, 2.23178104e-01f, 1.15792409e-01f, -2.10339442e-01f, 2.57527888e-01f, 1.09152213e-01f, 4.89032149e-01f, 3.03922802e-01f, 4.37751889e-01f,
  -8.42601538e-01f, -5.25537968e-01f, -8.93806219e-01f, -9.21388492e-02f, 3.05759341e-01f, 4.81594771e-01f, 3.14513296e-01f, 4.06740814e-01f, 1.10602289e-01f, 1.54546902e-01f,
  1.86515953e-02f, 6.40321374e-01f, -1.08124115e-01f, -1.06754042e-01f, -1.42830044e-01f, -2.08199576e-01f, -9.42487419e-02f, 4.91862029e-01f, 4.41074669e-01f, -5.29300332e-01f,
  7.34016597e-02f, 2.83656985e-01f, -3.67024615e-02f, 2.12873489e-01f, -1.65771589e-01f, 3.75343412e-01f, 4.23822790e-01f, 2.85443515e-01f, -5.05092382e-01f, -2.06401255e-02f,
  6.55308962e-01f, 2.49545857e-01f, -5.38817286e-01f, -2.81370193e-01f, -3.66074681e-01f, 3.84038419e-01f, -1.30805701e-01f, -6.66256905e-01f, 2.10073814e-01f, 3.71685207e-01f,
  4.47319299e-01f, -7.75190517e-02f, 3.60402688e-02f, 7.54340053e-01f, -2.50648677e-01f, 1.10300928e-01f, 1.58382624e-01f, 9.50208008e-02f, -7.10137427e-01f, -1.19410545e-01f,
  -5.15198708e-01f, 1.95350766e-01f, -2.37345248e-01f, -1.34184649e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  2.06256852e-01f, 3.37000221e-01f, 4.16612566e-01f, 3.30462158e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -4.95206505e-01f, -5.76835759e-02f, 2.77129948e-01f, -4.95154746e-02f, -3.58449407e-02f, -3.47368687e-01f, -4.64464843e-01f, -1.32630378e-01f, 3.09355468e-01f, 2.83870399e-01f,
  5.65054044e-02f, 2.74033695e-01f, 1.85003787e-01f, 2.23280936e-01f, -3.59932899e-01f, -1.08406559e-01f, 1.29798263e-01f, 8.12185854e-02f, -8.44569281e-02f, 2.75851071e-01f,
  -2.08730564e-01f, -3.28571141e-01f, 7.27589846e-01f, -3.35061073e-01f, -2.91466445e-01f, 2.04757571e-01f, -6.32875934e-02f, -2.29329914e-01f, -4.76892106e-02f, -3.86206180e-01f,
  2.05209985e-01f, -1.47338927e-01f, -2.35149279e-01f, -8.02662224e-02f, 2.67627627e-01f, -3.67340684e-01f, -3.62910330e-02f, -9.90467146e-02f, -5.02737880e-01f, -1.87442005e-01f,
  2.23222226e-01f, 5.67334712e-01f, -2.79022127e-01f, 6.12014234e-01f, 1.70232907e-01f, 5.42388596e-02f, -6.36400163e-01f, -5.60445487e-01f, 2.75054872e-01f, -5.24970174e-01f,
  -4.14307952e-01f, -1.93541348e-01f, 8.09686929e-02f, 2.24350631e-01f, 1.38101310e-01f, 7.28947639e-01f, -1.72980294e-01f, 8.82485323e-03f, -2.29146883e-01f, -2.77718753e-01f,
  -5.03783524e-01f, 5.40305495e-01f, -2.88079590e-01f, -2.54719835e-02f, -4.67506871e-02f, 1.00253314e-01f, -3.70143764e-02f, 2.25461219e-02f, -1.49272606e-01f, -1.19908363e-01f,
  -4.66264248e-01f, -4.84249666e-02f, 2.26890907e-01f, -3.99338454e-01f, 4.87177640e-01f, -3.88928987e-02f, -3.58271509e-01f, 1.09094754e-01f, -4.24877793e-01f, -6.55851215e-02f,
  -4.57971096e-01f, 1.48054793e-01f, -2.29196608e-01f, -2.61954963e-01f, 5.86647280e-02f, -1.34836644e-01f, 1.95705041e-01f, -9.47484225e-02f, -1.02001736e-02f, 2.88620754e-03f,
  4.91007537e-01f, 1.00963488e-01f, 6.39280200e-01f, -2.03753963e-01f, -1.48086362e-02f, 6.41539633e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.85498893e-01f, -1.09924830e-01f, 3.10879439e-01f, -7.47028515e-02f, 9.96777713e-02f, -8.95834640e-02f, 2.58614838e-01f, -5.54592967e-01f, 3.43783051e-01f, -8.94329488e-01f,
  1.21130550e+00f, -5.19453362e-02f, 3.33007067e-01f, 1.93632543e-01f, -3.71965706e-01f, -7.01342821e-02f, 2.01164216e-01f, 1.86747313e-01f, -5.19526899e-02f, 2.23636597e-01f,
  2.60461837e-01f, -1.19362988e-01f, -2.75448114e-01f, 9.89972427e-02f, -1.95751652e-01f, 5.63474834e-01f, -1.53724149e-01f, 7.26475298e-01f, 7.06607997e-01f, 2.20818222e-01f,
  3.08716208e-01f, 4.91670221e-01f, 2.88988709e-01f, 6.88760728e-02f, -6.82558119e-02f, 5.80969810e-01f, 4.21842396e-01f, 6.57053471e-01f, 2.09206507e-01f, 1.41568348e-01f,
  -4.18304622e-01f, 2.61880876e-03f, -1.89552918e-01f, -2.21050218e-01f, -2.87988245e-01f, 2.38574177e-01f, 9.31411684e-01f, 3.91844839e-01f, 7.53106534e-01f, 1.41273513e-01f,
  -1.06303051e-01f, 2.25542784e-01f, 5.98113418e-01f, 5.05581081e-01f, -4.50096205e-02f, 6.42177701e-01f, -4.95237887e-01f, 4.49845046e-01f, -9.85581100e-01f, -4.37408715e-01f,
  1.29983351e-01f, 5.02700388e-01f, 3.70460242e-01f, 2.23763689e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  4.00380552e-01f, 2.13019401e-01f, 7.03707457e-01f, 4.79761064e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.43131912e-01f, 3.08162570e-01f, 2.62977660e-01f, 6.11388266e-01f, 4.78782862e-01f, -3.84123772e-01f, 6.63833797e-01f, -5.23175418e-01f, 2.16398448e-01f, -4.53930438e-01f,
  4.64678138e-01f, -1.78146884e-01f, 1.37310520e-01f, 4.85299975e-01f, -1.18985385e-01f, -2.22563908e-01f, 9.58996639e-02f, -1.23229906e-01f, 5.87549806e-01f, 4.19719294e-02f,
  1.60686314e-01f, -6.94309920e-02f, 1.65136475e-02f, -4.40253407e-01f, -9.25202370e-01f, -4.32860941e-01f, 2.78484195e-01f, 7.12409854e-01f, 5.87789118e-01f, 2.57541031e-01f,
  -2.15288371e-01f, -2.20664427e-01f, -8.40071082e-01f, 1.63547680e-01f, -4.36387092e-01f, 2.00452790e-01f, -6.64507300e-02f, -3.44833553e-01f, -4.71822560e-01f, 5.57826281e-01f,
  5.33785582e-01f, 4.02031690e-01f, -4.52455938e-01f, -2.03934222e-01f, -2.17753977e-01f, 1.80227041e-01f, -1.64953619e-01f, 4.66890067e-01f, -1.49652541e-01f, 2.79063042e-02f,
  -6.89886436e-02f, -3.06337804e-01f, -1.25960279e-02f, 2.78351724e-01f, -5.61545372e-01f, 2.18983576e-01f, -8.89133438e-02f, 5.12865365e-01f, -2.46480644e-01f, -3.94487023e-01f,
  -1.78059225e-03f, -3.97520721e-01f, 4.20383751e-01f, 1.03356615e-01f, -8.15352425e-02f, 5.11695683e-01f, -3.79782289e-01f, 1.95303895e-02f, -7.04192892e-02f, -1.28554553e-01f,
  1.36170357e-01f, 9.43912745e-01f, -5.14571033e-02f, -1.00436521e+00f, 2.46962607e-01f, 3.00076038e-01f, 1.67070165e-01f, -3.83360416e-01f, 2.74706006e-01f, -4.00484771e-01f,
  4.93456155e-01f, 3.56351584e-01f, 3.81900907e-01f, 5.26525751e-02f, 5.14673829e-01f, 1.14927694e-01f, -4.40466255e-01f, -1.74189523e-01f, -5.25993109e-01f, -5.57884097e-01f,
  -4.44332361e-01f, 6.51676774e-01f, 1.14694797e-01f, 3.84280950e-01f, -3.35197747e-01f, -3.94210406e-02f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.36312936e-02f, 3.95688638e-02f, 1.82592927e-03f, -8.22350800e-01f, -6.53899789e-01f, -3.24448258e-01f, 1.86289009e-02f, -4.62287903e-01f, -4.94908422e-01f, 1.52678981e-01f,
  -5.10420263e-01f, 5.10677159e-01f, -7.61814713e-01f, 6.37252271e-01f, 6.54504418e-01f, 9.27042305e-01f, 3.07410777e-01f, 3.63145739e-01f, 2.47349758e-02f, 1.33609116e-01f,
  9.32102740e-01f, 4.59073126e-01f, -2.31149659e-01f, -1.52458534e-01f, 4.93634492e-01f, 1.17163217e+00f, -3.93818051e-01f, -1.87103760e+00f, -5.54983795e-01f, -2.47333139e-01f,
  3.61548036e-01f, 7.08396375e-01f, 7.26325870e-01f, 1.53997719e+00f, -2.45516717e-01f, -3.38807732e-01f, 1.10448919e-01f, 7.69645512e-01f, -1.10779858e+00f, 1.33116078e+00f,
  -8.18135202e-01f, -1.14868581e+00f, -1.26462221e+00f, 1.06660461e+00f, 1.45754308e-01f, 1.05415046e-01f, 8.93933177e-01f, 3.71972591e-01f, 4.52569157e-01f, 3.82725328e-01f,
  1.02206492e+00f, 5.80505192e-01f, -6.18942967e-03f, 1.34309494e+00f, -1.01705074e+00f, -8.26471031e-01f, -1.74726641e+00f, 1.53357732e+00f, 6.53592229e-01f, -8.15293908e-01f,
  6.30235136e-01f, -1.32930398e-01f, 4.22976553e-01f, 2.04982206e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  -1.85448974e-01f, 4.74087387e-01f, 8.18907499e-01f, 3.84223014e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.14136493e+00f, 9.14824665e-01f, 6.89515114e-01f, 8.88902962e-01f, 5.15286982e-01f, 5.59808195e-01f, 5.13693929e-01f, -1.33689559e+00f, 5.66573620e-01f, -6.35109782e-01f,
  -1.17418075e+00f, 8.13911736e-01f, -2.69634008e-01f, 6.49680555e-01f, -1.78857863e-01f, -3.97237837e-01f, 1.16642618e+00f, -1.11967109e-01f, -6.39541566e-01f, 1.01400590e+00f,
  -8.82559866e-02f, -6.33246481e-01f, 3.58247042e-01f, 4.65281278e-01f, -6.39868259e-01f, 6.79804206e-01f, 1.03100324e+00f, 1.96241796e-01f, -8.85998547e-01f, -5.52447557e-01f,
  5.52091300e-01f, 3.50894630e-01f, -1.99165672e-01f, 1.19929790e+00f, 7.76716590e-01f, -6.03774011e-01f, -1.18212676e+00f, 1.24482584e+00f, -9.25108433e-01f, -2.41996944e-01f,
  2.04780191e-01f, 9.86234963e-01f, 5.20978808e-01f, 1.76035106e-01f, -5.83175659e-01f, -8.28393161e-01f, 7.32437193e-01f, -9.78436053e-01f, 6.71576679e-01f, -8.22268367e-01f,
  -1.01763286e-01f, 6.18707836e-01f, -5.69373608e-01f, -2.28829280e-01f, 6.64026260e-01f, -8.63178372e-01f, 8.90054047e-01f, 6.75566435e-01f, 6.61454618e-01f, -1.38050938e+00f,
  4.20521945e-01f, 5.99529266e-01f, -1.72564316e+00f, -1.78104848e-01f, 6.34708703e-01f, 8.98267329e-01f, 1.01538606e-01f, -7.87860632e-01f, 1.75240964e-01f, 2.25677907e-01f,
  -5.43748677e-01f, -7.54794776e-01f, 1.08968210e+00f, 8.00374746e-01f, 1.05345786e+00f, 7.35461056e-01f, 1.26071110e-01f, 8.31391811e-02f, -2.08513126e-01f, 6.56483829e-01f,
  4.99197394e-01f, 5.76355815e-01f, 3.58394057e-01f, 5.32128513e-01f, -1.02205120e-01f, -9.63093400e-01f, 9.75964785e-01f, 6.81960464e-01f, 7.07334816e-01f, -4.79947031e-01f,
  -9.17312503e-01f, -1.46916360e-01f, 5.72757423e-01f, -8.75048041e-01f, 2.32972577e-01f, -4.57914770e-01f, 3.43095094e-01f, -3.70715141e-01f, -1.34583557e+00f, -2.50245750e-01f,
  1.25168550e+00f, 1.98310032e-01f, -4.29139674e-01f, -1.44286931e+00f, -3.93039882e-01f, 6.61269903e-01f, 7.91726112e-01f, -8.36552203e-01f, 5.23976445e-01f, -7.49317348e-01f,
  3.06415886e-01f, -9.44567323e-01f, -1.32506537e+00f, -3.05826545e-01f, -9.90836918e-01f, 4.19546098e-01f, 1.10795987e+00f, 1.05734766e+00f, 5.30381918e-01f, 7.43530214e-01f,
  -8.90533686e-01f, -1.22668159e+00f, -7.46229649e-01f, 2.24777773e-01f, -9.41181123e-01f, -1.04216969e+00f, -1.08279288e+00f, 8.31156552e-01f, -1.33710861e+00f, -8.99217606e-01f,
  1.28705788e+00f, -5.32701910e-01f, 9.00776386e-01f, -9.16900158e-01f, 8.00691128e-01f, 8.17029119e-01f, -9.32093143e-01f, -1.35051298e+00f, 1.23900628e+00f, 5.09044766e-01f,
  -1.53543162e+00f, -1.03088832e+00f, 6.00619674e-01f, -1.82804382e+00f, -6.67735457e-01f, -5.67646086e-01f, -8.13841224e-01f, -7.49843478e-01f, 6.41294271e-02f, -1.62766308e-01f,
  -7.61679411e-01f, 1.48703232e-01f, -9.62547898e-01f, -1.01103149e-01f, -6.13654494e-01f, -1.15570867e+00f, 9.95053425e-02f, 3.82020086e-01f, -1.11466302e-02f, 8.63048658e-02f,
  9.97416317e-01f, 7.65204847e-01f, -3.99942473e-02f, 1.26694158e-01f, -6.10596478e-01f, 2.56484419e-01f, -1.13669209e-01f, 8.01024914e-01f, -1.19259059e+00f, 1.34151912e+00f,
  -2.00960517e-01f, -1.03641462e+00f, -4.26402926e-01f, 4.70799804e-01f, -1.14264548e+00f, 8.17809999e-01f, -6.90791368e-01f, -1.13891876e+00f, 6.11825764e-01f, -1.46710944e+00f,
  -1.62821722e+00f, -1.05538535e+00f, -1.52201283e+00f, 9.84703839e-01f, 1.42858315e+00f, -5.04643857e-01f, -1.09162021e+00f, 1.12505436e+00f, 1.48168772e-01f, -8.48168015e-01f,
  -7.54621446e-01f, -2.80641645e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  3.84398162e-01f, 1.11368902e-01f, -5.69006018e-02f, 2.02469513e-01f, -5.46737313e-01f, -3.54436606e-01f, -1.81859076e-01f, 7.03851879e-01f, 6.47663295e-01f, -8.60844135e-01f,
  1.74901828e-01f, 1.10672748e+00f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    