/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.89061065e-02f, -8.12587067e-02f, 1.18262418e-01f, 1.37794778e-01f, 3.63940410e-02f, -2.24861130e-01f, -1.49126977e-01f, -2.02121604e-02f, 3.13551188e-01f, -9.99965891e-02f,
  -1.91516891e-01f, 1.62264407e-01f, -3.19851898e-02f, -2.58995593e-01f, 2.53546648e-02f, -1.08876757e-01f, -1.08227633e-01f, -9.67441276e-02f, 4.02258076e-02f, -8.12499505e-03f,
  4.17339318e-02f, -1.96945965e-01f, -3.26449908e-02f, -5.41360863e-02f, -7.89555460e-02f, 4.91400808e-02f, -6.06176890e-02f, -3.49179879e-02f, -1.92449242e-01f, -2.25839075e-02f,
  -3.93845215e-02f, 9.52708647e-02f, 4.01164256e-02f, 2.94112600e-02f, -2.77870465e-02f, -2.77101318e-03f, -2.29287501e-02f, 4.34437729e-02f, 1.14305653e-01f, 1.26688322e-02f,
  -3.68064530e-02f, -7.46071991e-03f, 6.00324608e-02f, -8.12386908e-03f, 8.36222470e-02f, -2.07394380e-02f, 4.66549397e-02f, 2.31852308e-02f, 6.85567386e-04f, -3.20860036e-02f,
  4.93561178e-02f, -3.41908750e-03f, 4.97106742e-03f, -3.59997153e-02f, 7.54921585e-02f, 2.29180697e-02f, -5.46678491e-02f, -1.07095521e-02f, -1.96530838e-02f, -2.98814494e-02f,
  -4.16807644e-02f, -3.57237123e-02f, -3.98938023e-02f, -8.07940811e-02f, 3.43764164e-02f, -3.46611552e-02f, -2.87860702e-03f, -2.76099760e-02f, 2.87815686e-02f, -3.09125450e-03f,
  2.62551866e-02f, 4.09985892e-02f, -2.85749808e-02f, 7.92560447e-03f, 5.63811278e-03f, 3.74507196e-02f, 9.50464606e-03f, -4.32016253e-02f, 4.69828397e-02f, 5.14500700e-02f,
  9.34155937e-03f, 6.21648226e-03f, -1.92859173e-02f, 9.11711529e-03f, 1.53776631e-03f, 2.37289257e-02f, -6.87842518e-02f, -2.15847157e-02f, 9.29271709e-03f, 1.43671995e-02f,
  -5.53676970e-02f, -1.18308343e-01f, 4.30324450e-02f, 5.54776043e-02f, 3.39190885e-02f, -9.45565403e-02f, -4.77786511e-02f, 7.63982581e-03f, -3.63607295e-02f, -3.13937142e-02f,
  -4.76904958e-02f, 3.21135372e-02f, -8.20738822e-02f, 2.90807523e-02f, 1.84220709e-02f, -2.00468898e-02f, -2.24449914e-02f, 5.48846535e-02f, -1.14050484e-03f, 1.23636844e-02f,
  -7.24469498e-02f, -1.94546431e-02f, 5.29575199e-02f, 1.07103765e-01f, 1.33487638e-02f, -2.88360026e-02f, 9.04980972e-02f, 4.90834787e-02f, -2.62258612e-02f, 5.45036085e-02f,
  -9.86076444e-02f, 3.32386941e-01f, 1.05795577e-01f, 9.84026790e-02f, -2.26296514e-01f, -3.01197380e-01f, -1.24220327e-01f, -4.03361879e-02f, -1.12877786e-01f, 1.39489859e-01f,
  -1.07695431e-01f, 1.19381495e-01f, 9.57001671e-02f, 1.81904305e-02f, -2.60106266e-01f, 7.11300969e-02f, -3.77379507e-02f, 7.21793175e-02f, 9.21071414e-03f, 8.45887884e-02f,
  2.08696350e-02f, -1.57983795e-01f, 3.95196415e-02f, 1.25530493e-02f, 3.01431417e-02f, 1.34069890e-01f, 9.62548256e-02f, -2.46975459e-02f, 4.94247861e-02f, -9.18334126e-02f,
  -9.64984149e-02f, 5.31082787e-02f, -1.74048338e-02f, 8.79377201e-02f, 9.71809551e-02f, 1.72737334e-02f, 3.24434899e-02f, -6.57701418e-02f, -4.86969016e-02f, 7.08760396e-02f,
  -3.97391338e-03f, 1.02614276e-02f, -2.16405764e-02f, -2.08290163e-02f, -3.79880704e-02f, 6.33361191e-02f, -2.78203608e-03f, 1.74657311e-02f, 1.32484771e-02f, 6.63776882e-04f,
  3.39948907e-02f, 4.29363698e-02f, 3.44494134e-02f, 5.31263612e-02f, 6.28740340e-03f, -4.64191772e-02f, 5.24828434e-02f, 2.94100046e-02f, -2.67573316e-02f, -1.32004227e-02f,
  2.48481371e-02f, -1.16560608e-02f, 1.68046504e-02f, -1.29379500e-02f, -4.00993191e-02f, -7.56777823e-02f, 1.59050785e-02f, 6.02151677e-02f, -8.71032476e-03f, 3.25015448e-02f,
  1.27253598e-02f, -2.26090495e-02f, 3.83258834e-02f, -1.40150916e-02f, 1.82870645e-02f, 1.87269021e-02f, 2.43705604e-02f, 5.53169586e-02f, 4.10318561e-02f, -3.80798206e-02f,
  1.41473552e-02f, -3.30134779e-02f, 1.80119015e-02f, 6.98420927e-02f, -1.24048479e-02f, -1.87178422e-02f, 3.81334014e-02f, 2.70809606e-03f, 7.22025475e-03f, -4.06553112e-02f,
  2.45406628e-02f, 2.04971075e-01f, 2.98249479e-02f, -7.49502331e-02f, -1.15315011e-02f, 7.32117593e-02f, -2.70812828e-02f, 7.88489450e-03f, 1.15344010e-03f, -8.28371719e-02f,
  7.57743344e-02f, -1.51459053e-02f, 1.81152895e-02f, -2.52525099e-02f, -2.67664250e-03f, -4.31882553e-02f, 5.57168946e-02f, -8.39844346e-03f, -1.53763900e-02f, 4.93431464e-02f,
  5.10636717e-02f, 1.55631974e-02f, 6.39846548e-04f, -6.79769274e-03f, 2.82178521e-02f, 2.65362859e-02f, -4.41376828e-02f, 4.12995294e-02f, 6.38646632e-02f, 4.27916422e-02f,
  1.37683347e-01f, 2.13797823e-01f, 2.64968455e-01f, -3.89219373e-02f, -9.15277898e-02f, 5.42312041e-02f, 2.08784014e-01f, -1.66728020e-01f, -1.90977622e-02f, -7.91075523e-04f,
  -6.70321360e-02f, 1.76027864e-01f, 1.54959783e-01f, -2.48760940e-03f, -9.09276977e-02f, 1.22986965e-01f, -9.56072137e-02f, 2.63804048e-02f, 1.07534854e-02f, 4.53541894e-03f,
  -8.23782906e-02f, -1.24026939e-01f, 1.69292185e-02f, -1.69527307e-01f, 7.16218203e-02f, -3.22625004e-02f, -2.40937606e-01f, 1.51340768e-01f, -1.20122351e-01f, 3.93754281e-02f,
  1.07604833e-02f, 4.30359170e-02f, -8.83960817e-03f, 2.91358083e-02f, -5.46999574e-02f, -7.44883716e-02f, -3.76159810e-02f, 4.13517766e-02f, 2.93805897e-02f, -1.03384098e-02f,
  5.20356148e-02f, 2.46200915e-02f, -4.40870672e-02f, 4.87511940e-02f, -9.40186065e-03f, 2.34697051e-02f, 2.36734822e-02f, 2.46450081e-02f, -6.37286203e-03f, 1.42878937e-02f,
  7.88797811e-02f, -5.15702274e-03f, 4.78411838e-03f, -1.15656862e-02f, 2.20912602e-02f, -8.97937734e-03f, 4.30032201e-02f, 6.60628974e-02f, 2.63091642e-02f, -4.95315045e-02f,
  -4.29438166e-02f, -9.23214306e-04f, 5.36554195e-02f, 1.27749853e-02f, -3.28096487e-02f, 8.51766672e-03f, 1.52516563e-03f, -5.41108428e-03f, 7.21744895e-02f, -4.10919562e-02f,
  -8.28159880e-03f, -4.54862304e-02f, -6.55189753e-02f, 4.46106354e-03f, -2.73917206e-02f, 5.02826599e-03f, -9.99940094e-05f, -7.96097238e-03f, -7.09346868e-03f, 3.47331841e-03f,
  -4.15014429e-03f, -2.44908165e-02f, 2.85615381e-02f, -6.52690679e-02f, 4.36609760e-02f, 3.07398532e-02f, -5.77326640e-02f, 6.46717921e-02f, -2.28591189e-02f, -1.87088251e-02f,
  -3.37720402e-02f, -8.06143656e-02f, 3.20854597e-02f, -2.46809348e-02f, 1.93598308e-02f, 1.94538869e-02f, 5.42393140e-02f, -1.24518378e-02f, -5.14933979e-03f, 2.74921097e-02f,
  -4.68173213e-02f, -6.63571134e-02f, 4.83191349e-02f, -7.36745521e-02f, -1.17241181e-02f, -1.82177573e-02f, -2.62924209e-02f, 3.99561739e-03f, -7.65717775e-02f, -6.55577034e-02f,
  -4.10567857e-02f, -3.97182778e-02f, -2.29325294e-02f, -1.79799907e-02f, -2.66120536e-03f, -1.14680137e-02f, -6.84941486e-02f, 3.68411373e-03f, -6.64467365e-02f, 1.52369663e-02f,
  -4.00570571e-01f, -1.89131245e-01f, 7.07765892e-02f, -2.32539579e-01f, 8.71886313e-02f, -5.19830640e-03f, 1.68557826e-03f, -6.10759035e-02f, -4.43964638e-02f, -9.48095098e-02f,
  4.23101969e-02f, -9.46639106e-02f, 8.57954249e-02f, -1.39716417e-01f, -6.09100685e-02f, 4.45394069e-02f, -1.65379226e-01f, -1.03825063e-01f, 7.57945031e-02f, -1.24949306e-01f,
  -2.55466942e-02f, -6.62983581e-02f, 9.90874320e-02f, 1.03534319e-01f, -1.49178773e-01f, -3.83732691e-02f, 2.11953912e-02f, 2.38188639e-01f, -1.30451098e-01f, 2.58082412e-02f,
  -1.35173976e-01f, -1.43751293e-01f, 1.34587300e-03f, 3.76112163e-02f, -3.23771872e-02f, 3.64278778e-02f, 1.14732133e-02f, 1.60705373e-01f, 7.88680762e-02f, 3.08206361e-02f,
  -7.78955524e-04f, -3.25510055e-02f, -1.63245220e-02f, 5.22469096e-02f, 1.73906460e-02f, 3.46638449e-02f, 2.27833800e-02f, 1.48753505e-02f, 5.45477793e-02f, -5.43682612e-02f,
  -8.13750252e-02f, -6.51769266e-02f, 3.21843438e-02f, -4.77104932e-02f, 4.94855605e-02f, -2.41825059e-02f, 5.24333641e-02f, 1.78409051e-02f, -1.33945020e-02f, -2.92527732e-02f,
  5.46991080e-02f, -2.97251670e-03f, 2.80044656e-02f, -2.68741492e-02f, 3.26447263e-02f, 1.97419655e-02f, 3.75331123e-03f, 4.96780314e-02f, -4.66599502e-02f, 2.11562347e-02f,
  -7.54736662e-02f, -2.33245101e-02f, -1.59812216e-02f, -2.02906262e-02f, 2.48242239e-03f, -6.22705743e-02f, -2.14690566e-02f, -2.42279600e-02f, -3.15479152e-02f, 1.63861793e-02f,
  3.90509702e-03f, -4.02750298e-02f, -5.31475320e-02f, -2.72761304e-02f, 1.87255349e-02f, 5.86227700e-03f, -2.85087395e-02f, -2.86816563e-02f, 2.65833903e-02f, 2.77996156e-02f,
  -1.67917833e-01f, -4.22024392e-02f, 7.58087561e-02f, -7.04295784e-02f, -5.15819676e-02f, -4.51233871e-02f, 4.38822620e-02f, -4.13126908e-02f, 3.03489491e-02f, 1.49913756e-02f,
  -7.88888335e-03f, 3.30650546e-02f, -5.67314140e-02f, -3.05884499e-02f, -3.56088169e-02f, 5.93405170e-03f, -6.29884079e-02f, -3.90412025e-02f, -8.27288702e-02f, 2.13508680e-03f,
  1.88223924e-02f, 1.05484594e-02f, 2.61030961e-02f, -3.17607746e-02f, -6.39910856e-03f, 1.10199274e-02f, -9.20687541e-02f, 3.04059573e-02f, 3.43836960e-03f, 2.46491209e-02f,
  2.28298947e-01f, 4.87494580e-02f, 2.00918436e-01f, 6.60464764e-02f, 7.92312175e-02f, 7.23712295e-02f, 1.46319151e-01f, 9.59484428e-02f, 1.20373122e-01f, 5.03679598e-03f,
  -8.23028199e-03f, 1.41631588e-01f, -1.08146153e-01f, -1.06843419e-01f, -2.07911059e-01f, -1.87437937e-01f, -5.40768914e-02f, 5.53883985e-03f, 1.90744400e-02f, 1.14106283e-01f,
  -3.57743688e-02f, -1.56083822e-01f, -1.05942391e-01f, 3.45822275e-02f, 8.06608200e-02f, 5.42699285e-02f, -1.81993991e-01f, 1.29963323e-01f, 3.78541611e-02f, -8.52941126e-02f,
  -4.15214710e-02f, -4.12620082e-02f, 8.18181187e-02f, -2.62063313e-02f, 7.94502646e-02f, 3.90630476e-02f, -5.83376661e-02f, -2.83269193e-02f, 1.60532854e-02f, -3.06809340e-02f,
  5.39677963e-03f, -1.52338399e-02f, -6.10433072e-02f, 8.02129321e-03f, 6.66837860e-03f, 7.37883374e-02f, 5.97067177e-02f, 4.38831002e-02f, -1.75729357e-02f, -1.93438027e-02f,
  7.22767189e-02f, 2.69435737e-02f, -1.43289790e-02f, -7.91661534e-03f, 7.13753402e-02f, 3.59157436e-02f, -1.93032045e-02f, -1.28860418e-02f, -5.53706773e-02f, 6.93289423e-03f,
  -9.40682068e-02f, -3.60147096e-02f, -4.67939265e-02f, 1.54480217e-02f, 5.34007065e-02f, -3.58000882e-02f, -1.19025093e-02f, 3.04345563e-02f, 9.67676286e-03f, 1.71117578e-02f,
  -3.73426788e-02f, -5.51608205e-03f, -3.26664187e-03f, -5.95884072e-03f, -3.43308076e-02f, 2.23190468e-02f, 3.12687643e-02f, -3.88937965e-02f, 2.36859955e-02f, 6.49366602e-02f,
  -2.84491200e-02f, -4.56523784e-02f, 3.04413624e-02f, -4.07560803e-02f, -5.77140749e-02f, 9.30812117e-03f, -2.02492578e-03f, 1.71787981e-02f, 1.71681661e-02f, 5.38561940e-02f,
  -8.00940394e-02f, -9.32590757e-03f, -3.17616947e-02f, -2.36841608e-02f, -1.19517492e-02f, -2.55470872e-02f, 3.68582923e-03f, -3.29843760e-02f, -4.90956567e-02f, 4.87714410e-02f,
  -3.94917130e-02f, -3.90666090e-02f, 4.12247851e-02f, -3.94867770e-02f, -5.40797077e-02f, 4.25351821e-02f, -2.83317156e-02f, -7.74263218e-02f, -1.55440839e-02f, -2.76541878e-02f,
  -3.90272611e-03f, 1.60664450e-02f, 6.46026358e-02f, -5.31329587e-02f, -6.77532330e-02f, -3.61238420e-02f, 2.89155860e-02f, -4.65100035e-02f, 4.14242931e-02f, 3.43320332e-02f,
  7.02643543e-02f, -1.81267083e-01f, 2.02504247e-01f, 6.67259917e-02f, 1.95749134e-01f, 1.25719653e-02f, -1.57929435e-01f, 2.01775339e-02f, 1.47579804e-01f, -2.56220609e-01f,
  -4.54553999e-02f, -2.43619811e-02f, -1.72373936e-01f, -2.96958685e-02f, -1.36935964e-01f, -1.92876086e-01f, -5.61073050e-02f, -4.84314114e-02f, 1.26723409e-01f, -5.04247472e-02f,
  1.13421567e-01f, -1.66588366e-01f, 1.44055560e-01f, -5.00605442e-02f, 2.27124374e-02f, 1.45556018e-01f, 1.11479471e-02f, 9.60978121e-02f, 7.98956379e-02f, -5.19988947e-02f,
  5.49617819e-02f, -1.01418816e-01f, 8.44783485e-02f, -7.14268908e-02f, -1.49199762e-03f, -5.48364874e-03f, 4.76835109e-02f, -2.32598167e-02f, 9.17787105e-02f, 1.86966930e-03f,
  -3.05695161e-02f, 4.64186110e-02f, -1.52737508e-02f, 6.70090318e-02f, 7.34790973e-03f, 1.14036568e-01f, 6.71382919e-02f, 2.86378656e-02f, 6.27672747e-02f, 5.72946668e-02f,
  -8.86028260e-03f, 6.33690320e-03f, 5.19522838e-02f, -4.00092863e-02f, -4.80847619e-03f, 4.45341580e-02f, -3.49719226e-02f, -4.30406246e-04f, 1.43382680e-02f, 8.73904601e-02f,
  -2.48115715e-02f, 1.67959556e-03f, -1.96508188e-02f, 6.72915205e-02f, -4.09077033e-02f, 9.65196546e-03f, 3.63798323e-03f, -3.69087160e-02f, -2.13920865e-02f, 4.40890417e-02f,
  -7.76791153e-03f, 5.32089407e-03f, 3.59522738e-02f, 3.55281420e-02f, 2.94160917e-02f, -5.23865111e-02f, 4.87618148e-02f, -2.03546267e-02f, 3.95522490e-02f, 1.24386810e-02f,
  -5.75098209e-03f, -7.00875418e-03f, 2.52862591e-02f, 7.22607970e-02f, 2.30248850e-02f, 2.61457674e-02f, 1.65272057e-02f, 1.22063756e-02f, 1.06372431e-01f, -4.69974130e-02f,
  -1.22764483e-01f, -2.21935168e-01f, -6.77158087e-02f, 4.20086458e-02f, -1.84152387e-02f, -8.18429589e-02f, -3.63796502e-02f, 4.12959978e-02f, -5.05458750e-02f, -6.90157264e-02f,
  1.63225085e-02f, -1.16313836e-02f, 1.04582869e-02f, 1.16283214e-02f, 1.30014755e-02f, -4.49611321e-02f, 2.78498866e-02f, -5.47942109e-02f, -6.68556094e-02f, -2.17367150e-02f,
  1.39285205e-02f, -9.96033382e-03f, 6.37932273e-04f, 3.53622809e-02f, 2.02962066e-04f, -4.35883813e-02f, -4.40529324e-02f, 1.94171455e-03f, 5.09392321e-02f, -4.22182605e-02f,
  -2.96175539e-01f, -1.67181835e-01f, -6.28382638e-02f, 1.08461287e-02f, 2.09633529e-01f, 4.34848547e-01f, 1.93383381e-01f, 1.57998294e-01f, 3.16416292e-04f, -1.78072806e-02f,
  1.41953140e-01f, -2.20725879e-01f, 2.02927608e-02f, 1.24312952e-01f, 2.65280396e-01f, 9.27347094e-02f, 2.47110203e-01f, 1.30116967e-02f, -4.81197163e-02f, 5.68853430e-02f,
  2.97559984e-02f, 9.68611166e-02f, 8.25147182e-02f, 1.14308514e-01f, 1.02072291e-01f, -1.15078539e-01f, 2.15073228e-02f, -3.98039185e-02f, 1.25561599e-02f, 7.65560754e-03f,
  -2.91509330e-02f, -2.40814999e-01f, 3.01889610e-02f, -3.75574306e-02f, 8.73005539e-02f, 4.24783072e-03f, 1.85701530e-02f, -6.06522597e-02f, -4.86464947e-02f, 1.91690661e-02f,
  -5.63830845e-02f, -1.47602858e-03f, 1.32813035e-02f, -2.70478111e-02f, 4.36571650e-02f, -2.77026072e-02f, 5.82176931e-02f, 5.92733994e-02f, 3.65194865e-02f, 5.45003712e-02f,
  8.03400055e-02f, 8.62103850e-02f, 6.30011484e-02f, -3.21235359e-02f, 6.07524477e-02f, 1.22239459e-02f, 1.08281681e-02f, 3.02718505e-02f, 3.15143801e-02f, 7.91260898e-02f,
  2.90698521e-02f, -7.56535605e-02f, 8.21654499e-03f, -1.22858286e-02f, -3.38698886e-02f, -8.10602307e-03f, 1.42717920e-03f, -2.67507974e-02f, -9.05373245e-02f, 4.80065718e-02f,
  6.70946985e-02f, -2.22409349e-02f, 4.86271791e-02f, -2.98421085e-03f, -1.92718245e-02f, -8.71454738e-03f, -2.16807947e-02f, -1.33528896e-02f, 5.61392158e-02f, 9.80310142e-02f,
  -1.63748376e-02f, 8.82913172e-03f, 1.72224194e-02f, -2.27125809e-02f, 6.45224229e-02f, -3.20206583e-02f, 2.46205907e-02f, 2.92575755e-03f, -4.06152830e-02f, 2.55776364e-02f,
  -6.84911385e-02f, -1.01186231e-01f, 4.76352163e-02f, 5.18644638e-02f, -3.02944444e-02f, 5.26663773e-02f, -5.48134884e-03f, 1.31253591e-02f, -5.24060987e-02f, 2.62864977e-02f,
  3.87560911e-02f, -2.69678663e-02f, 7.07041565e-03f, -6.21871278e-02f, -3.98925021e-02f, 2.82249656e-02f, 1.00235883e-02f, -2.44756192e-02f, 3.65278199e-02f, 2.39804741e-02f,
  -1.96307003e-02f, -2.07227152e-02f, 9.03512631e-03f, 6.76139817e-02f, 3.09897438e-02f, 2.65632030e-02f, 1.91547461e-02f, -7.09655955e-02f, 2.99316309e-02f, -2.94580106e-02f,
  2.59667903e-01f, -1.77244321e-01f, -1.45631894e-01f, 9.63972881e-02f, 1.96442515e-01f, -1.37488432e-02f, 2.14828979e-02f, -7.48697370e-02f, -1.42796323e-01f, 7.10514840e-03f,
  1.39934257e-01f, -1.33108765e-01f, 5.96392713e-02f, 1.16668545e-01f, 3.05793062e-02f, -1.30692378e-01f, 1.40355602e-01f, -1.67290308e-02f, -9.58511680e-02f, 1.20955966e-01f,
  -3.45461741e-02f, 2.48581082e-01f, -2.10743002e-03f, 2.48638038e-02f, 1.35396883e-01f, -4.60471511e-02f, 1.16281219e-01f, -1.23236375e-02f, 5.63492673e-03f, -2.60069035e-02f,
  -3.33772674e-02f, 7.49541223e-02f, -7.93214981e-03f, -4.64725792e-02f, -2.02664249e-02f, 3.52203147e-03f, 1.24633266e-02f, 1.00074485e-01f, 6.27515912e-02f, 1.56745352e-02f,
  -2.39312369e-03f, -1.50500918e-02f, 6.97490200e-02f, -5.29148914e-02f, -2.28003971e-02f, -2.42647957e-02f, 2.63495576e-02f, 5.65459281e-02f, -5.19455671e-02f, 1.09689590e-02f,
  -3.28241885e-02f, 6.92349598e-02f, 2.12336015e-02f, -1.00526784e-03f, -7.86545277e-02f, -3.56252585e-03f, -1.08768055e-02f, -3.60426903e-02f, 2.50537740e-03f, -8.17545876e-02f,
  5.71880601e-02f, 2.46108957e-02f, -1.40483882e-02f, 5.70255220e-02f, -9.24840849e-03f, 6.56716079e-02f, 5.09372205e-02f, 7.23092705e-02f, -2.85470970e-02f, 2.67861336e-02f,
  3.27384695e-02f, -2.20773555e-02f, 1.05724558e-02f, -1.20663447e-02f, 3.44854593e-02f, 6.83783367e-02f, 1.96362622e-02f, 1.32189412e-02f, -3.99559066e-02f, 6.52294904e-02f,
  2.96042096e-02f, 1.71580876e-03f, -5.99374585e-02f, 3.94403376e-02f, -4.71779592e-02f, -6.57702312e-02f, -3.20004784e-02f, -8.22662860e-02f, -3.16663575e-03f, 3.81895639e-02f,
  6.98585659e-02f, 6.79110885e-02f, -2.57144254e-02f, 2.14675590e-02f, -6.79674521e-02f, 1.83676388e-02f, 1.90599989e-02f, -1.18406210e-02f, -7.20498413e-02f, 3.04902662e-02f,
  -3.92803410e-03f, 4.85844985e-02f, -3.92431431e-02f, -2.91096661e-02f, 1.92053299e-02f, -4.88388501e-02f, 1.50165204e-02f, 1.67737175e-02f, -9.35419090e-03f, -5.34950420e-02f,
  2.91130170e-02f, -3.35406512e-02f, -4.75165285e-02f, -5.39909163e-03f, 4.70256060e-02f, -4.44963202e-02f, -3.19578964e-03f, -6.20369874e-02f, 4.59001586e-02f, 3.12194694e-02f,
  2.35905588e-01f, -4.18401212e-02f, 4.20668840e-01f, 6.06315099e-02f, -1.43932641e-01f, 3.82232144e-02f, 1.16054505e-01f, -9.98793244e-02f, 2.34898388e-01f, -1.27916977e-01f,
  -1.76351443e-01f, 2.72037476e-01f, 6.01952411e-02f, -6.56174496e-02f, 1.98018745e-01f, 2.10529864e-01f, -2.56355666e-02f, 5.85260317e-02f, 8.81817043e-02f, -6.77668676e-02f,
  1.28394768e-01f, -3.32718611e-01f, 1.56187639e-01f, -2.62281388e-01f, -1.46677658e-01f, 2.77356268e-03f, -1.75197542e-01f, 7.14405999e-02f, -2.06237495e-01f, -5.60475374e-03f,
  -1.14003219e-01f, 3.77279073e-02f, -8.54975581e-02f, 2.68316809e-02f, -8.11176226e-02f, -4.11513932e-02f, 8.80361423e-02f, 7.54084215e-02f, 1.92032307e-02f, -2.13511977e-02f,
  3.25876623e-02f, 3.00393091e-03f, -7.49338930e-03f, 4.87349108e-02f, -8.73978657e-04f, 2.87600067e-02f, -2.75648106e-02f, 3.96537296e-02f, 4.25098166e-02f, 7.89941400e-02f,
  5.59869632e-02f, 7.74728805e-02f, -6.76404801e-04f, 2.17384361e-02f, 4.03881557e-02f, 5.40301250e-03f, 8.95673633e-02f, 4.70681041e-02f, -3.01193520e-02f, 4.87666437e-03f,
  4.67824098e-03f, -7.05814920e-03f, -1.65290534e-02f, -2.78585404e-02f, 7.09088426e-03f, -6.74775094e-02f, 3.55770136e-03f, 2.53432225e-02f, 4.32838947e-02f, 6.06961781e-03f,
  -4.15856913e-02f, -1.99929811e-03f, -9.47728753e-03f, 1.24637019e-02f, 2.37768441e-02f, -4.97746654e-03f, 5.63692115e-02f, -1.75093336e-03f, -3.98163982e-02f, 2.30843318e-03f,
  5.29953167e-02f, 1.48204742e-02f, -3.25533114e-02f, -4.44061719e-02f, -3.44156362e-02f, 3.38467360e-02f, -1.69246718e-02f, 7.02401325e-02f, 2.70009483e-03f, -8.98344815e-03f,
  -2.05179453e-01f, -7.58635551e-02f, -5.25309592e-02f, -6.73646927e-02f, -8.45214073e-03f, -2.18792781e-02f, 4.42842990e-02f, -2.74999402e-02f, -2.44955104e-02f, 5.31216385e-03f,
  7.37587782e-03f, -3.41189578e-02f, 3.85731435e-03f, -3.03941779e-02f, -8.48408602e-03f, -1.04719037e-02f, 4.33360673e-02f, -6.47261590e-02f, -1.35233492e-01f, -2.47975942e-02f,
  -5.04567362e-02f, -4.14361171e-02f, 1.41386362e-02f, -6.50291666e-02f, -7.79440403e-02f, 2.08993219e-02f, -4.65347767e-02f, 1.46066789e-02f, -6.02935553e-02f, -4.01780289e-03f,
  -3.88766915e-01f, 2.46844321e-01f, -1.64778605e-01f, -9.27207917e-02f, -6.06691614e-02f, 1.40760779e-01f, 1.96645092e-02f, -2.23425757e-02f, 2.03716353e-01f, 2.16351584e-01f,
  -7.50175118e-02f, 7.32270703e-02f, 1.42317787e-01f, 2.41670031e-02f, -1.51001945e-01f, 3.33117962e-01f, -3.79610434e-02f, 2.85308529e-02f, 4.70918454e-02f, -1.88273117e-01f,
  -8.99668261e-02f, 4.31404337e-02f, -1.00965470e-01f, -7.42080361e-02f, -1.37071908e-01f, -1.89129531e-01f, -9.62031484e-02f, 6.74390094e-03f, -7.67269284e-02f, 4.56066094e-02f,
  1.27015114e-01f, 9.69126448e-02f, -7.00098127e-02f, 7.05360528e-03f, -1.13715991e-01f, -7.09325671e-02f, -7.82265421e-03f, -1.48216337e-02f, -1.15814611e-01f, 1.11488886e-02f,
  6.90504536e-02f, 2.47882912e-03f, 4.25429381e-02f, 4.05162498e-02f, -3.03862104e-03f, -4.41399813e-02f, 2.57768109e-02f, -4.43397388e-02f, 6.03017733e-02f, 5.76508278e-03f,
  1.19968243e-02f, 2.25751381e-02f, -1.95547547e-02f, 1.06589654e-02f, -6.79824054e-02f, -3.15032946e-03f, 1.36173116e-02f, -2.13074069e-02f, 6.19077086e-02f, 2.55188178e-02f,
  -7.68408105e-02f, -6.04203157e-03f, -6.11729585e-02f, 1.09020192e-02f, -4.55100834e-02f, -2.08741482e-02f, 9.08314064e-02f, 2.24139877e-02f, -5.91689944e-02f, 4.54385132e-02f,
  -5.84847964e-02f, -1.28276804e-02f, 3.96745875e-02f, 2.49046814e-02f, -3.82139571e-02f, 1.42056933e-02f, -8.00029095e-03f, 8.77120253e-03f, -5.33753484e-02f, 6.91921357e-03f,
  6.81839362e-02f, -3.66251683e-03f, 2.38310844e-02f, -5.16702831e-02f, 5.50797768e-02f, -4.42824885e-02f, -6.88631728e-04f, 3.87823656e-02f, -5.66387875e-03f, 4.03474784e-03f,
  -1.59262065e-02f, 6.08757548e-02f, 3.70368920e-02f, 3.00864875e-03f, 1.40871048e-01f, -2.07908768e-02f, 4.33343723e-02f, 3.21107134e-02f, 3.11513455e-03f, 4.16547805e-02f,
  -3.55262905e-02f, -6.47585765e-02f, 4.34389971e-02f, -6.82825595e-03f, 1.51641350e-02f, 4.71339859e-02f, -2.03661639e-02f, -2.72559538e-03f, -2.65165865e-02f, -4.59348448e-02f,
  -7.22132623e-02f, 2.36910991e-02f, 6.87549263e-02f, -6.72966093e-02f, 7.87191000e-03f, 3.48211522e-03f, -3.55825722e-02f, -6.76100999e-02f, 6.32899106e-02f, 2.90810876e-02f,
  -2.57003605e-01f, -3.00142795e-01f, -3.60062197e-02f, -2.44329140e-01f, 1.05991915e-01f, 2.38235846e-01f, 2.97691356e-02f, -1.58009946e-01f, -3.67856264e-01f, -6.51462600e-02f,
  3.49507108e-02f, -2.97415964e-02f, 1.27126619e-01f, -2.46263489e-01f, 2.33875871e-01f, 2.70019546e-02f, -2.14698151e-01f, -2.37916713e-03f, -9.86374244e-02f, -9.49184969e-02f,
  -6.30648211e-02f, -7.26800337e-02f, 3.27857696e-02f, -9.36458185e-02f, -6.35515675e-02f, -3.03398278e-02f, 1.35353774e-01f, 1.30977869e-01f, 3.03525180e-02f, 1.32155567e-01f,
  5.23752160e-02f, -1.55681193e-01f, -5.89686483e-02f, -6.94651157e-03f, -2.09147893e-02f, 4.68213893e-02f, 8.11147466e-02f, 6.01490624e-02f, 1.08655104e-02f, -7.59382769e-02f,
  -1.35007198e-03f, 4.12737019e-02f, -1.03311665e-01f, -3.22633758e-02f, -4.16564271e-02f, -8.12741145e-02f, -7.01476121e-03f, 8.36395659e-03f, -8.55457857e-02f, -3.55311926e-03f,
  1.74742062e-02f, -1.81209650e-02f, 1.30606946e-02f, 9.72262491e-03f, -1.98265184e-02f, -1.45224342e-02f, 1.38708539e-02f, 7.84975588e-02f, 2.68123075e-02f, -9.66705903e-02f,
  -3.31734158e-02f, 2.49227434e-02f, 5.53494096e-02f, -5.87158576e-02f, -1.86319780e-02f, -1.38407107e-02f, -3.12370863e-02f, 6.76962286e-02f, -2.33652461e-02f, -5.31217977e-02f,
  4.16315068e-03f, -1.03493389e-02f, -8.68470371e-02f, 1.83397494e-02f, 4.75125797e-02f, -2.34902781e-02f, 1.77950761e-03f, 9.67670698e-03f, -3.00826058e-02f, 4.89326566e-03f,
  4.08391543e-02f, 6.30590916e-02f, -1.26636624e-02f, -8.78784247e-03f, -1.90951824e-02f, 2.37751268e-02f, -1.36388186e-02f, -4.03294861e-02f, 4.99980748e-02f, 5.40448129e-02f,
  4.90842946e-02f, -9.95655656e-02f, -2.10616384e-02f, 1.39551712e-02f, 2.62481556e-03f, 8.05392116e-03f, 7.59671209e-03f, -5.35609387e-02f, -8.04019347e-03f, 4.90256818e-03f,
  8.48572478e-02f, -6.57794401e-02f, 4.44767922e-02f, 1.95572549e-03f, 6.63268864e-02f, 4.87416331e-03f, 5.79606295e-02f, 1.71001535e-02f, 2.55920123e-02f, 1.69138592e-02f,
  -3.69589515e-02f, 1.03885606e-01f, -5.66018485e-02f, 4.02302705e-02f, 4.75502834e-02f, 2.62434725e-02f, 1.28680246e-03f, 2.29729386e-03f, -1.08918939e-02f, 4.23988104e-02f,
  -3.01868081e-01f, 3.18132550e-01f, -2.92590857e-02f, 2.79482126e-01f, 6.19198047e-02f, -7.72754326e-02f, 5.26556931e-02f, 9.45119113e-02f, 8.06844160e-02f, 2.29868427e-01f,
  4.40726802e-02f, 5.71430400e-02f, 5.83919622e-02f, 1.77283138e-01f, -2.17693090e-01f, -4.21569832e-02f, 1.13748662e-01f, 1.18800722e-01f, -2.57937312e-02f, 1.76112443e-01f,
  -1.35198236e-02f, 2.14578792e-01f, -8.01519006e-02f, 2.66262572e-02f, 7.46436566e-02f, -6.24888465e-02f, 1.15127742e-01f, -8.59064460e-02f, 9.39816386e-02f, -1.80737153e-02f,
  -1.56583879e-02f, 7.58544877e-02f, -3.94056551e-02f, -5.10790795e-02f, -3.46011408e-02f, -5.14098331e-02f, -3.45707163e-02f, -3.45702209e-02f, -3.31559144e-02f, 4.10157330e-02f,
  5.08216675e-03f, 1.86093543e-02f, -1.34854652e-02f, 3.46065871e-02f, 3.54614039e-03f, -2.34495010e-02f, -4.38056188e-03f, -2.60434933e-02f, 1.20490575e-02f, -7.92995542e-02f,
  -5.89495935e-02f, -7.11138472e-02f, 3.68511304e-02f, 2.07805843e-03f, -9.46410000e-02f, 1.89342238e-02f, 1.73034146e-02f, 1.67447794e-02f, 4.55113165e-02f, 6.41676411e-02f,
  -3.86032425e-02f, 2.68044081e-02f, -5.19380439e-03f, -5.20811789e-03f, 4.53275740e-02f, -2.14228183e-02f, 3.41103449e-02f, 9.65382159e-03f, -6.40675128e-02f, 5.76420091e-02f,
  -3.10314447e-03f, 6.22472446e-03f, 8.01075995e-03f, 5.94458915e-03f, 1.09289708e-02f, -2.38862913e-02f, -2.18897648e-02f, 4.50203307e-02f, 1.68667641e-03f, -1.32202022e-02f,
  4.70274836e-02f, -1.67890918e-02f, 4.26348560e-02f, -5.99714890e-02f, 4.99807473e-04f, -4.59013730e-02f, 1.73984654e-02f, -3.88254635e-02f, -2.79628839e-02f, -4.95727435e-02f,
  7.22696036e-02f, 2.80076981e-01f, 4.94628064e-02f, 4.30604182e-02f, 2.43729148e-02f, 2.72131916e-02f, 4.19675447e-02f, -3.63057554e-02f, 7.54635856e-02f, -2.00798791e-02f,
  9.55762807e-03f, -1.88465733e-02f, -2.74930503e-02f, -1.66909005e-02f, -5.06175775e-03f, 3.49856056e-02f, 1.99981183e-02f, 4.07103784e-02f, 5.80421649e-02f, 5.72221503e-02f,
  9.50386748e-02f, 3.62237394e-02f, -9.39917937e-02f, 2.89160851e-02f, -1.12630930e-02f, -3.77177671e-02f, 4.65158746e-02f, -2.27748100e-02f, -6.65525869e-02f, -3.14519927e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.18130961e-01f, 9.45484042e-02f, 2.30149955e-01f, 2.74941564e-01f, 1.31306387e-02f, -7.64061138e-02f, 4.00162898e-02f, 7.24377409e-02f, 1.89540073e-01f, -3.65369432e-02f,
  -1.28856763e-01f, 1.71711564e-01f, -9.04689431e-02f, 2.69383267e-02f, -1.91126689e-01f, -1.64575160e-01f, -2.05909256e-02f, -6.55592009e-02f, -2.42807474e-02f, 2.33112313e-02f,
  -1.11231767e-02f, 6.78735180e-03f, 4.60957885e-02f, 1.65771656e-02f, 1.03408083e-01f, 9.44856256e-02f, -4.81816381e-02f, -7.50571489e-02f, 8.50748792e-02f, -1.77671779e-02f,
  -3.60869733e-03f, 3.19333710e-02f, 1.06342331e-01f, 4.66830507e-02f, 6.71444359e-05f, 3.27740759e-02f, 6.03833795e-02f, -4.91907774e-03f, -2.37960573e-02f, -1.72077940e-04f,
  -4.22894284e-02f, -7.01005608e-02f, 1.21680237e-02f, -5.51371202e-02f, 1.04135692e-01f, 3.05169150e-02f, 8.85277092e-02f, 1.21400945e-01f, 1.09590679e-01f, 5.31411543e-02f,
  1.65225372e-01f, 4.50847000e-02f, 4.56137508e-02f, -4.32245806e-02f, -4.59847860e-02f, 2.04075221e-03f, 8.30274373e-02f, -6.79533333e-02f, -2.27647014e-02f, 6.05963357e-02f,
  8.81835446e-02f, 7.61850327e-02f, 1.98242310e-02f, -6.57737628e-02f, 3.62440682e-04f, 3.96822579e-02f, 3.58960591e-02f, 1.57165807e-02f, 2.48795263e-02f, -5.29228710e-03f,
  5.10640144e-02f, 5.40255979e-02f, 4.57534334e-03f, -3.82913426e-02f, 4.81275544e-02f, -2.68057864e-02f, -6.58047050e-02f, -8.12004581e-02f, 5.31729199e-02f, -1.22909639e-02f,
  7.00868443e-02f, 4.24656980e-02f, 3.05626504e-02f, -8.38049874e-03f, -4.43920791e-02f, -2.60445382e-02f, 3.79684120e-02f, 3.77489366e-02f, -5.96697852e-02f, -5.90527430e-02f,
  -8.41263458e-02f, -1.59073487e-01f, 6.96329176e-02f, 7.46602863e-02f, 2.97594219e-02f, 4.41350304e-02f, 5.90847246e-02f, -2.36698929e-02f, -1.30044075e-03f, 3.21066305e-02f,
  4.29457650e-02f, -3.16732600e-02f, 1.69740263e-02f, -3.06849442e-02f, -2.09819078e-02f, -6.24073967e-02f, -6.69309497e-02f, 6.07755072e-02f, 1.72611903e-02f, -5.02503924e-02f,
  -2.20703725e-02f, 1.80586819e-02f, 1.64928567e-02f, 8.63673687e-02f, 8.11423436e-02f, -5.84066920e-02f, -6.92114905e-02f, 3.61112468e-02f, -1.05442852e-01f, -7.58482814e-02f,
  2.18066633e-01f, -2.35222146e-01f, 6.88700899e-02f, 1.92783952e-01f, 8.19842666e-02f, 1.48273753e-02f, 1.90461185e-02f, -6.33758828e-02f, 2.82980278e-02f, -1.84154853e-01f,
  -1.18469289e-02f, 4.89651561e-02f, -1.32450029e-01f, 8.60369951e-02f, 2.71628171e-01f, -5.88368177e-02f, 8.45555887e-02f, 1.22655712e-01f, 4.23423238e-02f, -3.76254395e-02f,
  1.42479435e-01f, 6.26633316e-02f, 1.06218942e-01f, -2.31794994e-02f, 7.31065944e-02f, -6.43497705e-02f, 1.27734452e-01f, 9.91031229e-02f, 4.80781756e-02f, 1.65934172e-02f,
  -2.55664177e-02f, -5.32618836e-02f, 6.01033196e-02f, 8.47732415e-04f, 2.87681445e-02f, -5.58635825e-03f, -4.93039899e-02f, 8.24024715e-03f, 9.96441469e-02f, -1.06486991e-01f,
  -1.45326219e-02f, 2.85926294e-02f, 2.19225306e-02f, 4.93224822e-02f, 4.07034159e-02f, 5.13520390e-02f, 9.64659359e-03f, -6.71765506e-02f, -5.49329259e-02f, 5.28020449e-02f,
  -3.06316316e-02f, -2.77583883e-03f, -1.73588861e-02f, -7.62022138e-02f, 4.73302411e-04f, 1.45303467e-02f, -3.35145183e-02f, 5.94515204e-02f, -8.32227394e-02f, -4.64359000e-02f,
  -7.88402781e-02f, -3.28755863e-02f, -2.67372243e-02f, 9.50528905e-02f, -3.23150381e-02f, -7.31528029e-02f, 6.07596338e-02f, -3.01962765e-03f, -1.29885515e-02f, 2.63829846e-02f,
  5.78005873e-02f, 2.07799748e-02f, -5.50071672e-02f, -7.11690560e-02f, -3.35795060e-02f, -3.09425816e-02f, -3.16780694e-02f, -5.66714369e-02f, 2.42696349e-02f, -6.11505099e-02f,
  5.71832918e-02f, 2.38638315e-02f, -4.81660198e-03f, -2.98335813e-02f, -7.38874301e-02f, 2.29095295e-02f, -9.65568572e-02f, 5.23456223e-02f, 5.54982871e-02f, 1.01913325e-01f,
  -2.06499510e-02f, -8.96698684e-02f, -1.01426905e-02f, 1.87562481e-02f, 4.49042022e-02f, -4.10826467e-02f, -6.46484420e-02f, 2.37743482e-02f, -2.33517997e-02f, -7.65332580e-02f,
  -1.03092887e-01f, 8.35677460e-02f, -3.81027684e-02f, 2.76540574e-02f, 6.27442300e-02f, 2.22131386e-02f, 4.02484573e-02f, 7.07358941e-02f, 1.05326809e-01f, 2.63727736e-02f,
  -9.97266099e-02f, 3.04323924e-03f, 8.78505558e-02f, -7.89973736e-02f, 2.69285664e-02f, -3.99547033e-02f, -3.92521620e-02f, 7.84264505e-02f, 1.52640874e-02f, -6.97763711e-02f,
  -2.56247699e-01f, 1.51663005e-01f, 1.17144927e-01f, -1.46631911e-01f, -4.43735123e-02f, 1.87675178e-01f, 1.22237332e-01f, 3.59952748e-02f, -1.56195715e-01f, -2.18582712e-02f,
  1.02102710e-02f, -1.84417173e-01f, 1.03412397e-01f, 1.23449750e-02f, 5.16236834e-02f, 1.52328670e-01f, 8.16394314e-02f, -1.08313956e-03f, 6.15007021e-02f, -4.64842543e-02f,
  8.96820705e-03f, -3.72116230e-02f, 9.30267721e-02f, 1.27262563e-01f, -8.60054567e-02f, -4.20116410e-02f, -1.12236254e-01f, 7.45704994e-02f, 3.56720611e-02f, -3.14334594e-02f,
  1.15573257e-01f, 1.47645315e-02f, 4.73993272e-02f, 1.98298506e-03f, -1.83843505e-02f, 2.90906597e-02f, 2.22503748e-02f, -3.63378301e-02f, 4.84231077e-02f, -1.24017503e-02f,
  4.52740006e-02f, 6.40530139e-02f, -1.15192451e-01f, 4.95609306e-02f, -1.17571160e-01f, -6.72663376e-02f, 1.38703045e-02f, -2.33128872e-02f, 9.56132337e-02f, -3.85627635e-02f,
  1.22582978e-02f, 1.28722098e-02f, 5.13131842e-02f, 2.20651738e-02f, 1.87496021e-02f, 3.03892344e-02f, -4.71733250e-02f, 2.71672215e-02f, -2.17855591e-02f, -8.10580775e-02f,
  -1.08449340e-01f, 1.41966036e-02f, 7.37748668e-03f, -2.14588586e-02f, 7.39979148e-02f, -6.37692064e-02f, 3.24540660e-02f, 6.30953759e-02f, -1.11043930e-01f, 5.40555231e-02f,
  -9.60844830e-02f, -8.68040770e-02f, -6.54958040e-02f, 3.40240076e-02f, 4.46456261e-02f, 2.46297959e-02f, 3.19421552e-02f, -7.44629726e-02f, -4.55679633e-02f, -6.48744479e-02f,
  -6.63688108e-02f, -4.11277786e-02f, -7.62845278e-02f, 4.27136011e-02f, 9.50007066e-02f, 2.12494694e-02f, 2.08548643e-02f, 1.20407138e-02f, 8.83455575e-03f, 9.63063836e-02f,
  -1.03980768e-02f, -8.67546648e-02f, 2.96859648e-02f, 5.21496609e-02f, 3.74404453e-02f, 3.23141217e-02f, 3.02680265e-02f, 4.85021062e-02f, -7.69231021e-02f, 6.18427657e-02f,
  6.68905228e-02f, -4.22684103e-03f, -3.96047533e-02f, -4.66311201e-02f, 2.54902430e-02f, -5.59534095e-02f, -7.40345865e-02f, -1.53057755e-03f, 1.79523546e-02f, 8.89362469e-02f,
  -7.37598091e-02f, -4.02067527e-02f, -9.79889371e-03f, -9.04756337e-02f, -1.10671751e-01f, -2.13963371e-02f, -4.72078519e-03f, -2.64152437e-02f, -4.32537124e-02f, 4.96489927e-03f,
  -7.54367933e-02f, -4.38304469e-02f, -9.20798853e-02f, -2.87201524e-01f, -7.16157723e-03f, -2.23362550e-01f, -1.21374510e-01f, -1.30431354e-01f, 6.42271191e-02f, 3.94420922e-02f,
  -2.04228796e-02f, -3.05866338e-02f, 1.54296681e-01f, -9.61671770e-02f, 7.85178691e-02f, 1.91815361e-01f, -2.31986463e-01f, -2.16727927e-02f, 7.44655952e-02f, -1.93588778e-01f,
  -2.08681580e-02f, -1.41623244e-01f, 7.49375671e-02f, 6.25278205e-02f, -7.22262859e-02f, -6.68508112e-02f, -6.74337372e-02f, 7.79068246e-02f, -1.35425195e-01f, 8.85765031e-02f,
  7.03109056e-02f, -1.12004846e-01f, 3.66678908e-02f, -2.35525426e-02f, 2.50084326e-02f, -9.37400460e-02f, -8.98727179e-02f, -2.55290046e-02f, -7.26184174e-02f, -1.47993574e-02f,
  -4.71420698e-02f, 5.69072971e-03f, -9.98790860e-02f, 9.89633426e-03f, 8.10617954e-03f, 7.03977942e-02f, 8.02646130e-02f, 4.25124578e-02f, 3.45067829e-02f, -1.45448539e-02f,
  -4.70314138e-02f, 4.97295968e-02f, -1.33755609e-01f, -5.23339063e-02f, -9.14554857e-03f, 2.94760279e-02f, 3.77881527e-02f, 5.68486713e-02f, -7.74400383e-02f, -8.54458474e-03f,
  -2.01364513e-03f, -5.97693846e-02f, -1.91463698e-02f, 9.29751471e-02f, -3.23843509e-02f, 3.46099809e-02f, 1.64286625e-02f, -1.80410016e-02f, 3.65851261e-02f, -9.90175232e-02f,
  2.28065774e-02f, -5.33968071e-03f, -6.32796064e-02f, -8.79776999e-02f, -1.07718967e-01f, -4.44974490e-02f, -2.96173990e-02f, -4.13697325e-02f, 9.05842613e-03f, -5.76209314e-02f,
  3.54166962e-02f, -5.36083728e-02f, -5.65502793e-02f, -4.17015254e-02f, -7.78361484e-02f, 8.13419372e-02f, -3.00939139e-02f, -4.75478172e-02f, -5.60706444e-02f, 1.02950996e-02f,
  -3.00721405e-03f, -1.46986112e-01f, -9.09452152e-04f, 5.13335876e-03f, 9.98848006e-02f, 2.16388665e-02f, -3.27615477e-02f, -7.98262879e-02f, -8.57689679e-02f, 2.76667587e-02f,
  -9.02407616e-02f, -2.24396642e-02f, 1.12570394e-02f, -3.67565639e-02f, -3.94866429e-02f, 4.51159850e-02f, 8.54269508e-03f, -7.26457089e-02f, 2.31184531e-03f, -5.63213155e-02f,
  -3.74569334e-02f, 4.23022807e-02f, -6.89173713e-02f, 1.36105940e-02f, -5.02041653e-02f, 1.94107108e-02f, -5.90775628e-03f, 4.80807247e-03f, 1.92605946e-02f, 1.05184792e-02f,
  -1.92030519e-02f, 9.06352401e-02f, -1.88812371e-02f, -3.79263870e-02f, -7.84629136e-02f, -4.18156870e-02f, 2.62752920e-02f, -2.49204901e-03f, -2.93229818e-02f, 1.15063228e-01f,
  1.69105753e-02f, -3.24849435e-03f, -3.31349261e-02f, -2.46971056e-01f, -2.55113661e-01f, -1.98164418e-01f, -1.70683876e-01f, 1.14801330e-02f, -5.25427721e-02f, -1.78990401e-02f,
  -1.75426438e-01f, -2.36647770e-01f, -5.43020107e-02f, -6.19894974e-02f, 5.76202609e-02f, 1.93703637e-01f, -6.08868077e-02f, -2.12856531e-02f, -5.18609919e-02f, -8.84786621e-02f,
  -6.27905652e-02f, -2.69017816e-02f, 3.72398384e-02f, -4.79995422e-02f, -7.01134428e-02f, 1.18987507e-03f, 4.23142165e-02f, -3.83512415e-02f, -8.26822445e-02f, 5.99092580e-02f,
  4.62748408e-02f, 4.96556014e-02f, 9.07518435e-03f, -3.29168998e-02f, 4.70546521e-02f, -5.76212332e-02f, -9.62807089e-02f, 8.96303877e-02f, 8.06760862e-02f, -2.28745211e-02f,
  9.25242603e-02f, -2.52790581e-02f, 4.60846797e-02f, 2.81666536e-02f, 9.92552191e-03f, 3.78731862e-02f, 1.12326473e-01f, -2.47966498e-02f, 1.30164519e-01f, -8.30018595e-02f,
  -5.42101339e-02f, -8.35256372e-03f, 4.00401233e-03f, 8.85547474e-02f, -4.77104373e-02f, 2.01014653e-02f, 2.65688859e-02f, 4.91654351e-02f, -7.41527006e-02f, 3.69299613e-02f,
  2.15191748e-02f, 6.41289130e-02f, 3.24860662e-02f, -5.53628802e-02f, -3.88019942e-02f, -7.26831183e-02f, 4.39129118e-03f, 6.08673282e-02f, 2.90636346e-02f, -5.17332070e-02f,
  1.12777576e-03f, -8.79560784e-02f, -2.48427433e-03f, -6.20330498e-02f, 4.40111570e-02f, -2.09112950e-02f, 7.18496740e-02f, -4.76818644e-02f, -1.82260703e-02f, -1.71798002e-02f,
  5.49839996e-02f, 5.86636700e-02f, 5.82503527e-02f, -3.59639563e-02f, 5.05704060e-02f, -4.47611734e-02f, -4.36631814e-02f, 3.70456069e-03f, -8.22437182e-02f, 1.78136341e-02f,
  8.46427754e-02f, -2.68993489e-02f, 2.29826272e-02f, -4.08320390e-02f, -3.96405682e-02f, 9.77961719e-02f, 3.75071876e-02f, 5.73524833e-02f, -4.59201038e-02f, 7.60320574e-02f,
  1.07550388e-02f, 3.62132676e-02f, -4.33219858e-02f, -5.18964678e-02f, -1.19474148e-02f, -6.02166494e-03f, -1.69764198e-02f, 1.09041417e-02f, -5.46572767e-02f, 1.00975357e-01f,
  -1.04222624e-02f, -1.19391540e-02f, -3.26830260e-02f, 1.49052944e-02f, -8.28922465e-02f, 1.23606548e-01f, 1.31453365e-01f, -7.22861886e-02f, -2.66913213e-02f, 5.69221214e-04f,
  -4.23958935e-02f, -2.21979134e-02f, -2.16087569e-02f, -7.49044418e-02f, -3.44086923e-02f, -5.88584356e-02f, -4.70840093e-03f, 8.61097649e-02f, 4.59228382e-02f, 1.36806713e-02f,
  -9.73689109e-02f, 6.31486624e-03f, 7.71978348e-02f, -1.23093463e-01f, -7.48901516e-02f, -1.04050457e-01f, 1.94641221e-02f, 2.71738730e-02f, 5.28748985e-03f, 2.61541666e-03f,
  1.78452320e-02f, 1.97535995e-02f, 4.99689206e-02f, -4.86561656e-02f, -1.40581569e-02f, 5.08266129e-02f, -6.99536921e-03f, 1.98585503e-02f, 2.48283539e-02f, -8.12850744e-02f,
  -5.35580553e-02f, 1.48512404e-02f, -4.79233358e-03f, 8.29993635e-02f, 7.20664114e-02f, 5.04713729e-02f, -7.65778348e-02f, -8.52739513e-02f, 3.64529081e-02f, 7.76872784e-02f,
  -6.14873469e-02f, 3.81730087e-02f, 3.68473455e-02f, -2.89075952e-02f, -2.70481184e-02f, 6.62242845e-02f, 3.32747437e-02f, 5.61886504e-02f, 3.90539356e-02f, -4.00956869e-02f,
  1.69031657e-02f, -2.94753928e-02f, 4.37121280e-03f, -2.59833541e-02f, -7.26279393e-02f, 4.93019866e-03f, 9.01013911e-02f, -2.46010032e-02f, -3.69808823e-02f, 1.15427747e-02f,
  5.56317382e-02f, -7.14891776e-02f, 5.65304467e-03f, -5.48177697e-02f, 5.96380085e-02f, -7.87276328e-02f, 2.05738228e-02f, 3.73156630e-02f, -4.70668338e-02f, 3.66489477e-02f,
  3.41233276e-02f, -1.62004195e-02f, -7.75836036e-02f, 3.05183753e-02f, -3.34523879e-02f, 3.10589727e-02f, -2.39959117e-02f, -1.49034883e-03f, -4.49848436e-02f, 2.73949355e-02f,
  -3.68254483e-02f, 6.93339333e-02f, -7.91669860e-02f, -1.36573976e-02f, -2.84995828e-02f, 4.10425803e-03f, 6.08911850e-02f, 5.75021468e-02f, -5.33873439e-02f, 1.86665859e-02f,
  6.45113811e-02f, -8.07626918e-02f, 5.73046226e-03f, -7.82239288e-02f, -6.62101209e-02f, 2.41816342e-02f, 1.03646159e-01f, -3.16011794e-02f, 6.79849610e-02f, -6.34122193e-02f,
  -1.95374526e-02f, 8.22305083e-02f, 5.06166667e-02f, -7.19520003e-02f, 3.42033543e-02f, -5.71760535e-02f, 5.06533403e-03f, -2.08754395e-03f, -8.72093216e-02f, 9.93215665e-03f,
  -1.75022587e-01f, 3.65077406e-02f, 2.20259260e-02f, -7.80180246e-02f, -8.28520060e-02f, 1.65513277e-01f, 1.52562499e-01f, 1.85815066e-01f, 2.23246619e-01f, 1.00473911e-01f,
  -3.53470668e-02f, 3.32229994e-02f, 1.99346300e-02f, 3.98326144e-02f, -6.13450333e-02f, -6.93304837e-03f, 9.01632186e-04f, 9.38257053e-02f, 3.87284011e-02f, 4.12322693e-02f,
  -9.41849500e-02f, -9.07818303e-02f, -3.43328677e-02f, -1.48350513e-02f, -7.42795393e-02f, -1.83849521e-02f, -1.83614239e-01f, -5.97620569e-02f, -9.63549241e-02f, -5.28034829e-02f,
  4.75712717e-02f, 1.45254254e-01f, -8.01421329e-02f, 8.59342366e-02f, 9.96326208e-02f, 1.67188756e-02f, 2.61654817e-02f, -8.52293745e-02f, 5.01325727e-03f, 5.31362407e-02f,
  5.54196872e-02f, 3.80195901e-02f, -1.66010740e-03f, -9.40955244e-03f, 1.20023131e-01f, -6.07921779e-02f, -4.01180796e-02f, -2.77311057e-02f, -4.50425558e-02f, 8.49120133e-03f,
  -5.46377245e-03f, 1.27535127e-03f, 4.78414521e-02f, 7.02137351e-02f, 6.80062780e-03f, 2.12412756e-02f, 9.75068733e-02f, -7.77580738e-02f, -2.10397001e-02f, 4.06471193e-02f,
  5.62754124e-02f, -3.00388839e-02f, 3.75943519e-02f, -5.17683290e-02f, -8.37212801e-02f, -3.12057082e-02f, -7.35352859e-02f, -8.31491575e-02f, 6.24397993e-02f, -8.86869878e-02f,
  6.12404868e-02f, -1.41076965e-03f, 2.75610611e-02f, 8.37914720e-02f, 7.64494855e-03f, 2.28911936e-02f, -3.37988585e-02f, 2.16712989e-02f, 2.70214733e-02f, 8.66199657e-03f,
  4.55023237e-02f, -1.27744162e-02f, -8.88673365e-02f, -3.90975876e-03f, 2.84199733e-02f, 8.13952211e-05f, 8.31110701e-02f, -1.47642077e-05f, -2.55164448e-02f, -6.36670291e-02f,
  3.42703313e-02f, 7.45519027e-02f, 1.37597360e-02f, 1.19072139e-01f, -6.05107099e-02f, -1.89052541e-02f, 5.49108088e-02f, 1.02149449e-01f, 1.08363712e-02f, 1.25957876e-01f,
  2.49355286e-02f, -2.88061555e-02f, 8.99207965e-02f, -7.92583823e-02f, -3.01026925e-02f, 5.41479234e-03f, 4.06079963e-02f, -2.02724766e-02f, 3.19428071e-02f, -3.49574834e-02f,
  -1.06384106e-01f, 9.52157900e-02f, 8.88880417e-02f, 8.33516344e-02f, -3.43576781e-02f, 4.29503135e-02f, 1.93994269e-02f, 2.90442538e-03f, -5.00025973e-02f, -1.03240879e-02f,
  -1.87113538e-01f, -1.94512904e-02f, -9.46988165e-02f, -2.70724028e-01f, 2.72454098e-02f, -1.33052438e-01f, -3.01468521e-01f, -7.50853121e-02f, -1.06721520e-01f, 4.23528766e-03f,
  -1.24149024e-01f, -1.58924580e-01f, 9.64709595e-02f, -2.65158981e-01f, -1.83212847e-01f, 4.01571132e-02f, -2.70680457e-01f, -1.79769099e-01f, -4.36046235e-02f, -9.38873515e-02f,
  -1.00255504e-01f, -1.05935715e-01f, -1.84559040e-02f, -5.29026706e-03f, -1.61226973e-01f, -7.38725886e-02f, 8.24754611e-02f, 1.24058999e-01f, -1.37691513e-01f, -1.11504890e-01f,
  2.70308200e-02f, 7.61940330e-02f, 4.75518964e-02f, -2.49840897e-02f, 3.25203426e-02f, 5.04245497e-02f, 8.72288086e-03f, 7.73498937e-02f, 2.61222757e-02f, -5.48874121e-03f,
  -8.85104090e-02f, -2.51195617e-02f, 1.81670412e-02f, -7.33175054e-02f, 4.93122898e-02f, -5.26192933e-02f, -1.40911713e-02f, -1.46316001e-02f, 9.82019585e-03f, 7.54738301e-02f,
  3.94168682e-02f, 5.90428710e-02f, -5.07267825e-02f, -3.53308693e-02f, -2.12956779e-02f, -6.71885386e-02f, -6.94932193e-02f, -1.36875035e-02f, 8.46583582e-03f, -9.13311467e-02f,
  -2.80251224e-02f, -3.31525132e-02f, -4.07102071e-02f, 3.78417559e-02f, -3.65126394e-02f, 4.04993221e-02f, 4.76136617e-03f, 9.68093127e-02f, -2.14261618e-02f, 6.28865510e-02f,
  2.66008452e-02f, 6.72762021e-02f, 6.75679045e-03f, 4.53361832e-02f, -7.30553269e-02f, 6.74876869e-02f, 2.93012746e-02f, 1.05629757e-01f, -5.65672331e-02f, -1.43302260e-02f,
  3.93443778e-02f, -4.61688116e-02f, 9.10413265e-02f, 3.23485620e-02f, -5.68355508e-02f, 9.41299368e-03f, -8.78618658e-02f, 8.32003355e-02f, 2.56665777e-02f, -4.27979268e-02f,
  -1.07558921e-01f, 6.02857396e-03f, -2.09154226e-02f, 4.68201712e-02f, -6.80272728e-02f, 1.08564369e-01f, -2.65520476e-02f, -3.08767837e-02f, -4.50167656e-02f, 2.35691965e-02f,
  2.88215168e-02f, -3.54663096e-02f, 5.28295711e-03f, 2.15576999e-02f, -2.59206388e-02f, -8.53771120e-02f, -8.39918554e-02f, 6.41992316e-02f, -2.47634426e-02f, 6.51526600e-02f,
  1.74264554e-02f, -5.95167279e-02f, -1.89773459e-02f, -1.86684579e-02f, 1.69307273e-02f, -5.04663102e-02f, 2.74214242e-03f, -2.76537463e-02f, -7.42345527e-02f, -5.11615537e-02f,
  -4.69962209e-01f, 3.35355967e-01f, -2.37525031e-02f, -1.92869663e-01f, 1.23591736e-01f, -3.56234349e-02f, -4.38649356e-02f, 1.20003507e-01f, -6.93045408e-02f, 6.84610382e-02f,
  -6.49242625e-02f, -1.29515782e-01f, 1.43750891e-01f, -9.77951661e-03f, -3.10351431e-01f, 1.12648041e-03f, -1.49048582e-01f, -2.24491924e-01f, 2.47190427e-02f, -4.05710796e-03f,
  -1.31291419e-01f, 7.03753680e-02f, -1.66441556e-02f, 2.48330086e-01f, -6.12944216e-02f, 5.03078219e-04f, -1.66153759e-01f, 2.56175578e-01f, 3.84485424e-02f, 7.62091428e-02f,
  -1.55669644e-01f, -2.33420968e-01f, -1.35203168e-01f, -1.47638142e-01f, -1.92161039e-01f, -3.63927782e-02f, -5.14477082e-02f, -2.45168172e-02f, -5.88998478e-03f, -5.81156872e-02f,
  -1.41142518e-03f, 7.37947896e-02f, 5.21819592e-02f, 2.05430482e-02f, 4.92389575e-02f, 5.18369712e-02f, -5.44354916e-02f, -4.29036431e-02f, 1.16316127e-02f, 8.41160584e-03f,
  9.58955735e-02f, 3.91050195e-03f, -6.56452402e-02f, -3.38813290e-02f, -1.15585536e-01f, 5.36327325e-02f, -9.44980904e-02f, 1.50689417e-02f, -3.39438580e-02f, -1.12258010e-02f,
  -3.07653453e-02f, -5.26192524e-02f, -4.41778655e-04f, -5.14814556e-02f, 1.71754807e-02f, 2.12761369e-02f, -4.82262634e-02f, -6.41537085e-02f, -6.08873032e-02f, -1.70264170e-02f,
  -3.57214026e-02f, 5.61401248e-02f, 3.31833810e-02f, -1.08932577e-01f, -6.14489336e-03f, -5.68563417e-02f, 4.27192785e-02f, -5.31355478e-02f, -2.34839972e-02f, 1.29003096e-02f,
  2.28383746e-02f, 4.11641411e-02f, 2.47541647e-02f, 4.07379046e-02f, -4.93629016e-02f, -4.12063557e-04f, -1.60054513e-03f, 7.43619129e-02f, -1.93870571e-02f, -7.93075655e-03f,
  -1.70755580e-01f, -2.65853971e-01f, -4.80392203e-02f, 3.93123440e-02f, -4.31380644e-02f, -1.12652332e-01f, -1.03131466e-01f, 5.19199483e-02f, -9.50914845e-02f, -2.39179935e-02f,
  -6.96819946e-02f, 7.08892522e-03f, -1.30193010e-02f, 2.40058638e-02f, 3.80335227e-02f, -5.18468441e-03f, 3.28756459e-02f, -3.11193280e-02f, -3.46785821e-02f, -4.21528816e-02f,
  -1.45771485e-02f, -5.60229784e-03f, -7.38883913e-02f, 2.86843795e-02f, 2.65784678e-03f, -6.05059564e-02f, -7.56278634e-02f, 4.43098508e-03f, 3.08527313e-02f, 2.72943508e-02f,
  -9.35196131e-03f, -2.06017897e-01f, -3.04376006e-01f, 9.98857245e-02f, 1.57351092e-01f, -1.45499967e-02f, -7.19950944e-02f, 3.09211593e-02f, -1.46059245e-01f, -3.33259702e-02f,
  1.59605190e-01f, -5.33263609e-02f, -2.52951652e-01f, 9.82974321e-02f, 1.45839661e-01f, -1.70824230e-01f, 1.37662947e-01f, 5.83625957e-02f, -1.02996759e-01f, 1.06829330e-01f,
  4.54892628e-02f, 3.15227687e-01f, 4.77891043e-03f, 2.80626893e-01f, 9.74399783e-03f, 1.22995013e-02f, 2.80198067e-01f, -4.82791662e-03f, 3.39246839e-01f, 1.08713135e-01f,
  -1.17465362e-01f, -5.16733667e-03f, -6.18529227e-03f, 1.00345090e-02f, 7.41263926e-02f, 4.68851179e-02f, -5.70824072e-02f, -2.32013948e-02f, -2.98946798e-02f, 1.49290182e-03f,
  -2.85162125e-02f, 3.49983834e-02f, 1.16289128e-02f, -4.58322465e-02f, 4.70372066e-02f, 5.75451292e-02f, -6.92042569e-03f, -3.31841111e-02f, -6.86360821e-02f, -4.63901870e-02f,
  -8.78880471e-02f, -8.12094472e-03f, -1.97184086e-02f, -4.39364836e-02f, 1.95946135e-02f, 1.34874862e-02f, -6.17123730e-02f, 7.05647320e-02f, 4.66514379e-02f, 5.73769852e-04f,
  -6.23332942e-03f, -1.63611062e-02f, -7.87564218e-02f, -6.07063435e-02f, -4.84053716e-02f, 7.40322322e-02f, 6.95463717e-02f, 2.60717701e-02f, 1.92122664e-02f, 2.38386355e-02f,
  2.77172588e-02f, -2.38548815e-02f, -6.47710562e-02f, 6.69175014e-03f, 2.46654488e-02f, 2.27024108e-02f, 4.06131633e-02f, 9.27829519e-02f, -3.12216263e-02f, 5.55329286e-02f,
  -6.38381541e-02f, 1.88867170e-02f, 7.21846521e-03f, -5.45630381e-02f, -5.12670316e-02f, 7.79218152e-02f, 1.68806948e-02f, -5.21252975e-02f, 9.48597270e-04f, 1.97691303e-02f,
  7.11706802e-02f, 1.50637358e-01f, -5.34136444e-02f, -5.77279069e-02f, 5.64321391e-02f, 9.84465778e-02f, 8.41864720e-02f, -2.77186814e-03f, 6.51063100e-02f, 1.05707012e-02f,
  9.22372639e-02f, -1.18413307e-02f, 1.10206485e-01f, -1.15016624e-02f, -2.40015909e-02f, 7.80059164e-03f, -3.54762971e-02f, -2.08540503e-02f, 1.33128420e-01f, 1.44050464e-01f,
  -3.62876803e-02f, 2.34487560e-02f, 5.41924089e-02f, 4.47732992e-02f, 9.73570794e-02f, 4.50184196e-02f, 9.00957659e-02f, -2.75818538e-02f, -5.03068836e-03f, 2.30620373e-02f,
  7.41734356e-02f, -4.41577062e-02f, 1.99407972e-02f, 5.50658889e-02f, -1.01068364e-02f, -1.28960952e-01f, -1.34253994e-01f, 1.27836084e-02f, -4.26041149e-02f, 7.65670016e-02f,
  6.89887479e-02f, 1.12672351e-01f, 2.33730096e-02f, 5.01484424e-02f, 1.57793418e-01f, 8.88258591e-02f, -1.22437282e-02f, -7.34720007e-02f, 2.06095669e-02f, 1.04608811e-01f,
  1.44557804e-01f, 5.87670840e-02f, 9.23857987e-02f, 2.72195358e-02f, -2.61527896e-02f, 1.25098050e-01f, 2.50657260e-01f, 2.79414151e-02f, 1.36166662e-01f, 2.32826844e-02f,
  -9.93208662e-02f, 1.76067855e-02f, -9.48875174e-02f, -1.06539845e-01f, -3.01813092e-02f, -2.14880574e-02f, -1.19805208e-03f, 3.23991664e-02f, 5.67702428e-02f, -8.31650272e-02f,
  3.57907568e-03f, -1.04367798e-02f, -4.58002947e-02f, -8.76493603e-02f, -8.07733834e-02f, 9.53019597e-03f, -2.29565166e-02f, 1.33911259e-02f, 5.41040301e-02f, -6.23065904e-02f,
  1.58628169e-02f, -6.35204092e-02f, -1.52350636e-02f, -1.22982198e-02f, -5.23312762e-03f, -6.22277297e-02f, -4.40274142e-02f, 5.03400527e-02f, -6.64046034e-02f, 1.48404511e-02f,
  4.57530320e-02f, -5.26940674e-02f, 8.64484683e-02f, 1.00429552e-02f, 6.08472265e-02f, -6.93311244e-02f, -2.43433844e-02f, 4.93012406e-02f, 7.42251938e-03f, 1.86315421e-02f,
  -8.91319588e-02f, 2.55833101e-02f, 1.37908142e-02f, 5.74772395e-02f, 8.07570219e-02f, -1.65333953e-02f, -3.17644291e-02f, -6.61713118e-03f, -8.77645016e-02f, 5.45712113e-02f,
  -7.13650044e-03f, -1.13826236e-02f, 3.42721120e-02f, -4.51313816e-02f, 4.77459989e-02f, -2.64182705e-02f, 8.76697376e-02f, -3.66735309e-02f, -5.72388843e-02f, -7.59489462e-02f,
  1.21498451e-01f, 1.01725109e-01f, 7.27846920e-02f, 3.71863209e-02f, -1.09819788e-02f, 3.68852261e-03f, 1.20737310e-02f, 3.68949063e-02f, -1.48957549e-02f, -2.19048113e-02f,
  -3.95520851e-02f, -4.02284898e-02f, 5.28012514e-02f, 4.21534665e-02f, -3.73066240e-03f, 9.14479196e-02f, 6.28102943e-02f, -4.92226034e-02f, -4.11434509e-02f, 3.44215482e-02f,
  9.11069810e-02f, -4.41619121e-02f, -5.21576069e-02f, -8.25819448e-02f, 4.64107245e-02f, -3.63743398e-03f, -2.61347443e-02f, -7.28092119e-02f, 2.41453834e-02f, 6.43697975e-04f,
  -4.30165529e-02f, -1.36282012e-01f, -5.70140220e-02f, -7.26102814e-02f, 6.41031042e-02f, 4.98980768e-02f, 1.04528330e-01f, -1.09799184e-01f, -7.25696012e-02f, 6.76859170e-02f,
  9.27063003e-02f, 1.83375515e-02f, 5.50930463e-02f, 2.93940678e-03f, 1.12501785e-01f, 4.54778560e-02f, -9.04552639e-02f, 2.85744853e-02f, -8.73198733e-02f, 3.88195179e-02f,
  -1.08308926e-01f, 7.05369264e-02f, -7.18962029e-02f, 1.82893779e-02f, 2.16369573e-02f, -2.50682626e-02f, 4.66685072e-02f, 1.35674998e-01f, -4.82524000e-02f, -7.08312355e-03f,
  -1.38220027e-01f, -6.56764731e-02f, -7.22339470e-03f, -7.69491047e-02f, -1.82006955e-02f, 8.04738328e-02f, 3.34532820e-02f, 1.17924986e-02f, -8.80379416e-03f, 2.08408646e-02f,
  -1.99544728e-02f, -6.02097362e-02f, 2.33159494e-02f, -5.03218919e-02f, -9.60772932e-02f, -2.37887911e-03f, 3.73112559e-02f, 7.43440315e-02f, -1.47811947e-02f, 4.98336703e-02f,
  4.92276102e-02f, -9.64549035e-02f, -1.56814768e-03f, 7.30398223e-02f, 7.70456865e-02f, 1.22202775e-02f, -7.21227303e-02f, 4.56667803e-02f, -5.49615622e-02f, -4.34358045e-02f,
  2.64439601e-02f, 7.29421005e-02f, 2.87717134e-02f, -3.86729767e-03f, -3.89504991e-02f, -8.03550035e-02f, 7.20225647e-02f, -3.01807113e-02f, -5.53279333e-02f, -1.36672454e-02f,
  -5.51733412e-02f, -6.38718903e-02f, 1.65477004e-02f, 4.82388102e-02f, 8.16603079e-02f, -4.43489254e-02f, -3.42247225e-02f, 4.40287106e-02f, 2.25681346e-02f, 7.31467502e-03f,
  -3.76207270e-02f, -6.21213987e-02f, -7.49140186e-03f, -8.53929482e-03f, -1.09739993e-02f, 8.32269415e-02f, -7.72657394e-02f, -7.68520758e-02f, -7.20869470e-03f, 9.87235643e-03f,
  8.11992399e-03f, -1.93821862e-02f, -5.42342998e-02f, -8.29688311e-02f, 1.81489699e-02f, -4.17015888e-02f, -8.37336108e-02f, -2.41678283e-02f, -1.71096660e-02f, 4.17817980e-02f,
  8.88054073e-02f, 8.14861506e-02f, 1.29943471e-02f, -6.27009124e-02f, -6.49106596e-03f, -8.76754373e-02f, -4.23998013e-02f, 1.02599198e-02f, -6.78263307e-02f, -9.12139490e-02f,
  5.33152819e-02f, 3.87399644e-02f, -8.79125786e-04f, 1.56445021e-03f, -7.62571767e-02f, -1.13954460e-02f, 1.57368314e-02f, 4.95088995e-02f, 1.05336716e-03f, -9.43428054e-02f,
  -1.41606182e-01f, 3.91300619e-02f, -8.61775503e-03f, -4.14927080e-02f, -4.61237459e-03f, 1.43028781e-01f, 4.79955934e-02f, -1.60982218e-02f, 5.65455295e-02f, -9.36439261e-02f,
  -9.94674936e-02f, -1.00347519e-01f, -1.02362871e-01f, 1.37729999e-02f, 4.39502783e-02f, -9.34263598e-03f, -1.50680328e-02f, -5.48011390e-03f, 6.46187887e-02f, -6.43882826e-02f,
  6.85259253e-02f, -4.90456559e-02f, -1.46295670e-02f, 7.82628357e-02f, -4.89367433e-02f, 6.11606427e-02f, 2.29990091e-02f, 3.48514505e-02f, 5.58217727e-02f, 8.77585188e-02f,
  -4.68945578e-02f, 1.78797562e-02f, 9.61299613e-02f, -8.34879186e-03f, 2.22141910e-02f, -7.39077628e-02f, -3.10812723e-02f, 3.27255167e-02f, 2.01826971e-02f, 2.63584647e-02f,
  -1.11135706e-01f, 4.66678888e-02f, 3.82735133e-02f, -8.10682699e-02f, -4.73287255e-02f, 6.08413480e-02f, 6.08774647e-02f, 1.26224710e-02f, 4.59920689e-02f, 1.14912897e-01f,
  9.46683958e-02f, -3.39489318e-02f, -2.13974481e-03f, -6.46964535e-02f, 7.75966644e-02f, 1.11453561e-02f, 6.02336600e-02f, -5.05824611e-02f, -8.51454288e-02f, -7.12526683e-03f,
  -8.50597098e-02f, -1.96311139e-02f, 8.51775482e-02f, 1.05682127e-02f, -6.17713667e-02f, -4.76219542e-02f, -2.37807184e-02f, 5.97297810e-02f, 1.65001564e-02f, 6.22701505e-03f,
  -5.37466109e-02f, -4.23227027e-02f, -6.75394088e-02f, 8.05075914e-02f, 8.83064419e-03f, -1.59436092e-02f, 7.27941245e-02f, 1.11498320e-02f, 2.02440340e-02f, -6.26501739e-02f,
  -3.37655060e-02f, 1.81623027e-02f, 4.39311676e-02f, -9.07584429e-02f, 1.55619951e-02f, -6.62382394e-02f, -3.06080803e-02f, -1.29014561e-02f, 4.53893915e-02f, 3.48896906e-02f,
  2.40454338e-02f, -1.97181016e-01f, -7.19436109e-02f, -1.40304752e-02f, 9.10635740e-02f, -1.13482326e-01f, -1.52196158e-02f, 8.65444988e-02f, -4.93059754e-02f, 6.27183495e-03f,
  2.10190378e-02f, -4.79962081e-02f, -3.79179977e-02f, 4.24678847e-02f, -2.61859200e-03f, -2.22083163e-02f, -7.85629004e-02f, -6.21183291e-02f, 2.94987597e-02f, -2.89213937e-02f,
  1.47233792e-02f, -2.45769173e-02f, -7.16724694e-02f, 4.89544682e-02f, 4.68079522e-02f, -9.91768315e-02f, -5.19724153e-02f, -2.69287149e-03f, -1.35894250e-02f, -3.82652320e-03f,
  -8.71743783e-02f, -6.03677258e-02f, 4.71731089e-02f, 2.40444243e-01f, -1.43907681e-01f, -2.17188403e-01f, -2.35775232e-01f, -3.66804302e-02f, -6.25041574e-02f, -1.31636649e-01f,
  3.39604840e-02f, 5.84983900e-02f, -6.94622397e-02f, 8.27069804e-02f, 1.74600691e-01f, -7.22806144e-04f, 5.33709414e-02f, 6.22087568e-02f, -1.16772773e-02f, 9.36804935e-02f,
  1.59772590e-01f, 1.75886109e-01f, 2.73945063e-01f, 9.87104252e-02f, 8.27970058e-02f, 2.23234192e-01f, 2.10133702e-01f, 1.34638622e-01f, 2.67545700e-01f, 1.55925542e-01f,
  -6.96631819e-02f, 5.02141938e-02f, 4.21114080e-03f, -1.15849890e-01f, -6.14515087e-03f, -7.26501197e-02f, 1.73396841e-02f, 3.49041522e-02f, 3.76135893e-02f, 6.67501166e-02f,
  -1.24815457e-01f, 1.73751581e-02f, -4.37349863e-02f, 6.04377836e-02f, -9.21557248e-02f, -2.83243805e-02f, 3.57662961e-02f, -2.73035020e-02f, -1.27313361e-02f, 4.03685980e-02f,
  2.00125482e-02f, -3.01521961e-02f, 3.27970423e-02f, -3.08257267e-02f, 7.60586783e-02f, 5.62380813e-02f, 7.61336759e-02f, -3.96809122e-03f, 4.07537185e-02f, -1.36205729e-03f,
  -8.42389613e-02f, -3.95708233e-02f, -6.41642511e-02f, 4.11114208e-02f, -4.82857935e-02f, 7.35806450e-02f, 2.65245847e-02f, -3.47847342e-02f, -2.62473207e-02f, 6.49532527e-02f,
  8.39084312e-02f, 7.61115626e-02f, -3.66771296e-02f, 4.49470133e-02f, -5.76245715e-04f, 2.62483768e-02f, 2.92025376e-02f, -3.32595184e-02f, -2.81238109e-02f, -2.25183330e-02f,
  1.92117915e-02f, 7.99597651e-02f, 3.83861028e-02f, -6.57187328e-02f, 4.92110802e-03f, 7.01677650e-02f, 7.83910751e-02f, 3.92377824e-02f, 4.04908136e-03f, 1.21385632e-02f,
  -2.65462026e-02f, 2.29411334e-01f, -5.32757724e-03f, -1.16166353e-01f, -9.89876455e-04f, 5.99742355e-03f, -3.33200656e-02f, 5.31322835e-03f, 2.52283476e-02f, 3.11762225e-02f,
  -5.34199236e-04f, -4.30009402e-02f, -4.76650596e-02f, -1.79291330e-02f, 8.96149427e-02f, 7.63694197e-02f, 9.66896415e-02f, 6.75779488e-03f, -1.31813185e-02f, 1.66855752e-02f,
  8.50364789e-02f, -3.08060218e-02f, 1.29166553e-02f, -9.43496600e-02f, -2.00484763e-03f, -9.44070891e-02f, -6.11808524e-02f, -5.14701493e-02f, -4.36463766e-03f, 1.08307809e-01f,
  -9.53682885e-02f, 1.26244962e-01f, 9.37748849e-02f, -1.24148846e-01f, 9.37590376e-02f, 7.24640787e-02f, -7.72277862e-02f, 4.57368381e-02f, -1.07746750e-01f, 1.14185221e-01f,
  -2.50184368e-02f, -6.97047636e-02f, 2.66776327e-02f, -1.06056631e-01f, -2.14954555e-01f, -1.01843469e-01f, -1.09847412e-02f, 5.22715226e-02f, -1.42864464e-02f, -5.19378716e-03f,
  2.23553088e-02f, -1.73853427e-01f, 6.40472323e-02f, 2.92519815e-02f, 6.26791790e-02f, -4.57804976e-03f, 1.60411205e-02f, 2.62399614e-02f, 2.05360749e-03f, -8.13669339e-02f,
  -1.22799454e-02f, 4.59507154e-03f, -5.13250614e-03f, 2.52260827e-02f, 1.01604134e-01f, 4.09029564e-03f, 9.61576477e-02f, -1.81201436e-02f, 1.24353291e-02f, -4.79129553e-02f,
  5.71869779e-03f, 1.10062733e-01f, -5.93189821e-02f, 4.30859253e-02f, -5.99583611e-02f, 7.96687454e-02f, 5.53325703e-03f, 9.99661535e-02f, 9.99992862e-02f, 6.81423321e-02f,
  3.91960852e-02f, 4.23118472e-02f, 4.61638197e-02f, 1.65343955e-02f, 6.92075342e-02f, -1.54102230e-02f, -1.75882187e-02f, 8.87903050e-02f, -5.53079508e-03f, -3.98723371e-02f,
  1.59192067e-02f, 4.52946872e-02f, -3.86158712e-02f, 1.80446729e-02f, 3.78379524e-02f, -6.56305701e-02f, -2.35133828e-03f, 8.52184277e-03f, 5.82646532e-03f, -3.14792879e-02f,
  3.20310853e-02f, -7.63633400e-02f, 6.46783039e-02f, -2.51844786e-02f, -2.00546980e-02f, -7.53238797e-02f, 6.86612353e-02f, 2.47674547e-02f, 6.90548941e-02f, 2.47002281e-02f,
  -9.38308239e-03f, -9.78861973e-02f, 4.49881628e-02f, 3.61665152e-02f, -5.76025099e-02f, -1.17215421e-02f, 4.74448167e-02f, 6.34427816e-02f, -3.09034940e-02f, -7.69489035e-02f,
  -3.27325650e-02f, -1.36585394e-02f, 1.00951038e-01f, 2.86493525e-02f, -4.22999496e-03f, 7.39848539e-02f, -8.89913924e-03f, 2.19439566e-02f, 2.61580124e-02f, -5.28203649e-03f,
  9.79157016e-02f, -1.71023160e-02f, 3.44297513e-02f, 2.90750172e-02f, -7.83242360e-02f, -5.20379208e-02f, -8.56112614e-02f, -5.13010956e-02f, 2.13856865e-02f, -5.87915555e-02f,
  8.96645635e-02f, -3.17102149e-02f, -3.56675610e-02f, 5.37767224e-02f, 2.91858427e-02f, 4.01845574e-02f, 4.77970131e-02f, 8.86606574e-02f, -2.32227817e-02f, -1.41975367e-02f,
  2.58569479e-01f, -2.46885762e-01f, -6.69128373e-02f, 1.96898744e-01f, 2.04126731e-01f, 2.79708534e-01f, 2.74324298e-01f, 2.81555690e-02f, 3.50469708e-01f, -1.64521992e-01f,
  2.27181166e-02f, -5.45108654e-02f, -1.75244790e-02f, 4.46017347e-02f, 3.54097992e-01f, 6.40004426e-02f, 2.21869826e-01f, 1.16011411e-01f, 9.89510119e-02f, 7.72588924e-02f,
  9.75480527e-02f, 8.94837379e-02f, -2.59794146e-01f, -3.08945715e-01f, -2.61130668e-02f, -2.71314263e-01f, -9.01782438e-02f, -1.78727776e-01f, -2.05822855e-01f, 2.09780000e-02f,
  1.02684833e-01f, 6.29693940e-02f, -7.55789801e-02f, -4.74894345e-02f, 2.67971288e-02f, -1.22371361e-01f, -7.55200088e-02f, -6.05213419e-02f, 4.68027331e-02f, 3.11985333e-02f,
  9.50400624e-03f, 3.57307643e-02f, 1.89342583e-03f, -4.63554338e-02f, 6.35980964e-02f, -2.77796108e-03f, 8.87680613e-03f, -5.22503518e-02f, 2.23220829e-02f, -4.95482422e-02f,
  -8.03375021e-02f, -4.40468080e-03f, 3.09557635e-02f, -1.41252344e-02f, -3.67117934e-02f, 2.16202680e-02f, -2.08037253e-02f, 5.79231679e-02f, 3.12122535e-02f, -7.48730153e-02f,
  -8.63868650e-03f, 2.11691447e-02f, -9.70589966e-02f, -9.09929574e-02f, 6.19566329e-02f, -5.63056320e-02f, -2.69908831e-02f, 4.39477526e-02f, 9.82388947e-03f, 1.33765424e-02f,
  2.10971385e-02f, 2.85004508e-02f, 1.06940299e-01f, 8.73460621e-02f, -1.73916537e-02f, -2.19129138e-02f, 3.50344256e-02f, -1.66893024e-02f, -4.56844307e-02f, -3.60143073e-02f,
  -8.32754001e-02f, 7.19532222e-02f, 1.95014812e-02f, -5.26984483e-02f, 3.64729799e-02f, 2.93431040e-02f, -6.97998777e-02f, 2.50728056e-03f, 9.28198174e-03f, 5.27930446e-02f,
  -3.06670051e-02f, -3.39672305e-02f, 1.07517717e-02f, -3.43109258e-02f, -4.42947857e-02f, -1.02562476e-02f, 8.24430659e-02f, 6.81330264e-02f, 1.89507715e-02f, 7.82142207e-02f,
  6.74284026e-02f, -6.06905222e-02f, 9.09871329e-03f, 6.20836541e-02f, 6.35166615e-02f, -3.92349483e-03f, -4.23095599e-02f, 1.41767226e-02f, 1.90323312e-03f, -1.97020732e-02f,
  -6.92024380e-02f, -3.90007868e-02f, -6.55951500e-02f, -3.05412430e-02f, -8.59873071e-02f, -2.20366307e-02f, -6.37325943e-02f, 1.97664183e-02f, -3.18619162e-02f, 6.09840155e-02f,
  8.47772509e-02f, -7.50142932e-02f, -3.26846950e-02f, 1.29117131e-01f, 2.41205633e-01f, 1.15495667e-01f, 1.91066310e-01f, 1.65191680e-01f, 3.51732284e-01f, -1.98070845e-03f,
  3.99847217e-02f, -2.63777345e-01f, -4.28262092e-02f, 3.69225815e-02f, 4.06030240e-03f, 2.08275001e-02f, 1.37143508e-01f, 6.27513081e-02f, 1.66889176e-01f, 5.90462089e-02f,
  1.02411672e-01f, 1.25504926e-01f, -2.12834775e-01f, 1.66077185e-02f, -5.62354252e-02f, -5.49194589e-02f, -2.12754115e-01f, -2.92806495e-02f, -1.00222565e-01f, -5.97434640e-02f,
  8.93075690e-02f, 1.43122494e-01f, 1.36791188e-02f, -7.51574263e-02f, -2.13798434e-02f, 4.39962745e-02f, -3.51509713e-02f, -2.22101267e-02f, -4.39422466e-02f, 5.23989089e-02f,
  -1.21394992e-01f, -2.42892839e-03f, 1.88542642e-02f, -6.09017573e-02f, -5.49145858e-04f, -6.98429253e-03f, 2.50459812e-03f, 5.85287586e-02f, -8.34350809e-02f, -1.51020950e-02f,
  -8.67996067e-02f, -4.35097031e-02f, 8.74036774e-02f, -8.69988799e-02f, 4.90066782e-02f, -9.17576160e-03f, -1.78936888e-02f, -1.11077070e-01f, 4.92391475e-02f, 9.44697633e-02f,
  -3.26780565e-02f, 1.40977083e-02f, 8.30967352e-02f, 1.35348737e-02f, -9.40940976e-02f, 5.85029162e-02f, -3.65429297e-02f, 3.64391021e-02f, 1.37523906e-02f, 3.86617370e-02f,
  8.24023560e-02f, 1.96221620e-02f, 6.48180395e-02f, -7.47699663e-02f, 3.51132080e-02f, 9.46667045e-02f, -1.03752069e-01f, 8.39972794e-02f, 4.67486233e-02f, -8.05036817e-03f,
  9.14061964e-02f, 1.12925237e-02f, -1.07345857e-01f, -6.50805086e-02f, -8.69584382e-02f, -3.57864909e-02f, 3.16390023e-02f, -1.34505853e-02f, 3.80932987e-02f, -6.83447346e-02f,
  3.49684395e-02f, 7.66903535e-02f, 4.99290377e-02f, -6.74163923e-02f, -8.00131038e-02f, -4.15666625e-02f, 6.67267814e-02f, 7.95696105e-04f, 3.72773036e-02f, 2.04384476e-02f,
  5.64799234e-02f, 5.09647802e-02f, 4.76277247e-02f, -3.40031870e-02f, -9.25792456e-02f, -4.64832559e-02f, -5.72831370e-02f, 1.35324830e-02f, -2.58651040e-02f, -1.29944012e-01f,
  -4.73836549e-02f, 8.17167833e-02f, 3.03787272e-03f, 5.84589802e-02f, 4.28133719e-02f, -9.33260769e-02f, 1.09800380e-02f, -3.12170535e-02f, -7.00591356e-02f, -9.06245038e-03f,
  -7.09551349e-02f, 8.58759955e-02f, -4.89200503e-02f, 1.59893781e-01f, -2.33292148e-01f, -9.36068892e-02f, -5.28688170e-02f, 4.12333161e-02f, 7.96659961e-02f, 1.26365051e-01f,
  7.70791471e-02f, 5.50443530e-02f, 6.22492023e-02f, 9.07715261e-02f, 1.13541193e-01f, 1.38968036e-01f, 1.10209454e-02f, 5.51500358e-03f, -5.73840849e-02f, -2.94460710e-02f,
  1.06792428e-01f, 1.12627268e-01f, 1.60473943e-01f, 5.97671000e-03f, -1.08039021e-01f, 3.55053954e-02f, 6.45820871e-02f, 1.05289498e-03f, 7.46001452e-02f, -6.60327151e-02f,
  4.68228832e-02f, 1.11324392e-01f, -2.53013205e-02f, -9.11323074e-03f, 7.21096918e-02f, -7.88296852e-03f, 4.34186682e-02f, -1.76834613e-02f, 7.70683354e-03f, 1.67646240e-02f,
  -5.01420647e-02f, 7.81939253e-02f, -8.23176652e-03f, -7.16680139e-02f, -2.46179644e-02f, -2.67182421e-02f, -1.58684514e-02f, -3.97750549e-03f, 4.01410125e-02f, -2.89906580e-02f,
  -3.08627766e-02f, 4.81738560e-02f, -5.32988459e-02f, 4.03068541e-03f, 9.18598175e-02f, -1.33608689e-03f, 2.94488780e-02f, 2.03330070e-02f, 9.34206471e-02f, -1.38811246e-02f,
  -2.93087028e-02f, -2.34600659e-02f, 8.92875642e-02f, -1.09214298e-01f, 2.67394092e-02f, -2.75263228e-02f, -3.08035780e-02f, 5.51596005e-03f, -3.63811143e-02f, 6.83403239e-02f,
  -8.02164227e-02f, 6.82531744e-02f, -1.96124651e-02f, 3.81324477e-02f, 1.20293181e-02f, 6.01266623e-02f, 4.45571728e-02f, 9.33733284e-02f, 5.77224046e-02f, -4.04889248e-02f,
  8.28141496e-02f, -1.02136109e-03f, 3.80580500e-02f, -8.20664968e-03f, -3.54520082e-02f, -7.20201507e-02f, 5.73711656e-02f, -3.33847702e-02f, 5.03020585e-02f, -8.11208412e-03f,
  1.35986507e-01f, 2.43799478e-01f, 3.11352368e-02f, -4.85207327e-02f, -3.91829051e-02f, -8.53576213e-02f, -2.92454697e-02f, 5.23796603e-02f, 1.47724031e-02f, -5.47220744e-02f,
  1.41766239e-02f, 8.04914744e-04f, -7.95286745e-02f, -5.83186708e-02f, -9.47663784e-02f, -3.79755422e-02f, 1.11411586e-01f, -1.47197405e-02f, 2.27348208e-02f, 4.27941382e-02f,
  -4.47334945e-02f, -6.01675548e-02f, -6.69305995e-02f, 2.17672344e-02f, 7.71011934e-02f, -2.99037178e-03f, -7.03971684e-02f, -6.27472475e-02f, 8.72609764e-03f, 4.13302407e-02f,
  8.25827271e-02f, -1.88977003e-01f, 2.19952725e-02f, -1.58709317e-01f, -7.05486014e-02f, -1.83085904e-01f, 1.11161852e-02f, -2.55963147e-01f, -1.27511963e-01f, -2.26047069e-01f,
  -6.52144253e-02f, -2.67515332e-02f, 2.11963922e-01f, -1.75296932e-01f, 3.69145840e-01f, 1.10244438e-01f, -1.92916304e-01f, -1.11632697e-01f, 1.91191267e-02f, -2.32667223e-01f,
  -6.31897748e-02f, -2.22990528e-01f, 6.64171129e-02f, -2.49699220e-01f, -2.45279819e-01f, -1.97842076e-01f, -2.60959361e-02f, -1.11106917e-01f, -2.08307788e-01f, -2.99925152e-02f,
  -6.57447278e-02f, -1.85239136e-01f, -9.38772969e-03f, -8.28743204e-02f, -6.75982088e-02f, 1.58200022e-02f, -5.70726395e-02f, 2.39603464e-02f, 4.95523624e-02f, 8.02092068e-03f,
  4.94154207e-02f, -3.66076939e-02f, -1.15476146e-01f, 3.83842252e-02f, -9.46738794e-02f, 1.29375504e-02f, -5.35698384e-02f, -8.68166797e-03f, -1.27535403e-01f, -6.13641813e-02f,
  1.67952385e-02f, 2.11624317e-02f, -2.14088652e-02f, -4.04253975e-02f, -1.90847348e-02f, -3.51218022e-02f, 2.29540821e-02f, 3.03921271e-02f, 1.83705799e-02f, 5.10152653e-02f,
  -1.99766969e-03f, 5.05561307e-02f, 6.41262084e-02f, -3.57890464e-02f, -1.13638043e-02f, -2.13495977e-02f, -6.10914826e-02f, 1.63012892e-02f, -4.88626659e-02f, -6.90663531e-02f,
  6.68797120e-02f, -4.24536429e-02f, 8.48528277e-03f, 4.09232732e-03f, -6.10296754e-03f, 6.82846084e-02f, 7.14225471e-02f, -7.27876872e-02f, 1.60712544e-02f, -1.21540939e-02f,
  5.74371368e-02f, -4.53333259e-02f, -8.06828961e-02f, 5.68707474e-02f, -2.80705485e-02f, -3.20109725e-02f, 3.02403290e-02f, -5.60700567e-03f, 9.34328977e-03f, -3.79559584e-02f,
  -5.10373898e-02f, -6.96614161e-02f, -8.90803561e-02f, -7.87919853e-03f, -4.10539024e-02f, -1.83308367e-02f, 9.80689004e-03f, -1.49442079e-02f, -6.30107448e-02f, -8.89082402e-02f,
  8.37153941e-03f, 5.75615242e-02f, 2.63190176e-02f, -8.74857232e-03f, -5.72298840e-02f, -3.15434858e-02f, -5.60988747e-02f, 4.85631963e-03f, 1.59687493e-02f, -3.73319574e-02f,
  4.94259119e-04f, -9.15171672e-03f, 9.86929983e-02f, -8.20076689e-02f, 3.41309458e-02f, 3.38750035e-02f, 3.40987220e-02f, 5.43174185e-02f, 3.26777510e-02f, 2.55249273e-02f,
  -6.49562702e-02f, -7.13715777e-02f, -2.52810568e-01f, -4.26916033e-02f, -1.80828094e-01f, -1.27065033e-01f, -2.13654011e-01f, -1.46845132e-01f, 8.42137448e-03f, 1.56282097e-01f,
  3.26072946e-02f, 3.46981338e-03f, 1.44511566e-01f, 6.47258833e-02f, -1.20040692e-01f, 1.17395826e-01f, -4.07766700e-02f, -6.15098178e-02f, 5.34472205e-02f, -1.46265313e-01f,
  -3.32303182e-03f, -6.15078723e-03f, -1.10957371e-02f, -4.55179401e-02f, -1.46296099e-01f, -3.99941020e-02f, 1.42706186e-01f, -7.92507604e-02f, 2.89412551e-02f, 4.13883291e-02f,
  -6.59579486e-02f, -1.24747664e-01f, -6.64006248e-02f, -1.29300244e-02f, -1.30800799e-01f, -3.50803733e-02f, -2.26826165e-02f, -3.08498610e-02f, 3.64528969e-02f, 7.67206913e-03f,
  5.67349046e-03f, 1.10861743e-02f, 8.46686773e-03f, 1.03006154e-01f, -7.84275532e-02f, -1.00264855e-01f, -3.00899483e-02f, -7.65577480e-02f, -4.60149087e-02f, -2.34366264e-02f,
  -8.87535512e-02f, -6.53530359e-02f, 6.10522702e-02f, -2.12923456e-02f, 6.35079294e-02f, -4.57198359e-02f, 4.32175072e-03f, -3.10373586e-02f, -1.05496682e-01f, 3.25800665e-02f,
  2.59625278e-02f, -5.11163753e-03f, 6.26214221e-03f, 7.41892681e-03f, 1.34734241e-02f, 5.95218651e-02f, -2.59986483e-02f, 6.39393926e-02f, 4.10761349e-02f, -8.52476060e-02f,
  -6.39845654e-02f, 5.06080780e-03f, -1.73290484e-02f, 1.98711101e-02f, -6.06431402e-02f, -7.05118924e-02f, -2.94042006e-02f, -3.84824909e-02f, -1.72267631e-02f, 4.73170280e-02f,
  -1.29920803e-02f, 1.88222751e-02f, -3.58483419e-02f, 5.96347041e-02f, -5.09521645e-03f, -1.20600304e-02f, 1.36580952e-02f, 1.27623873e-02f, -5.56772724e-02f, 5.32062957e-04f,
  -2.00535074e-01f, -2.27273926e-01f, -3.16954255e-02f, 2.46338490e-02f, -4.13902774e-02f, -9.88867953e-02f, 4.06114496e-02f, 5.72163705e-03f, -5.38943626e-04f, -3.55884358e-02f,
  -4.65108231e-02f, -5.31191472e-03f, 3.88129577e-02f, 6.18207920e-03f, 6.97935745e-02f, -9.31111351e-02f, 2.73294318e-02f, 3.90735231e-02f, -1.07648626e-01f, -2.47044228e-02f,
  -3.60257253e-02f, 7.08323158e-03f, -3.18392962e-02f, 1.99886821e-02f, 6.69412315e-02f, 5.40358350e-02f, -6.76507177e-03f, -1.55888572e-02f, -3.31761432e-03f, -5.17435670e-02f,
  5.82458004e-02f, -3.19159329e-02f, 1.15697816e-01f, 8.55632052e-02f, -1.08156465e-01f, -6.37107119e-02f, 4.15668357e-03f, -1.23924643e-01f, 1.94653627e-02f, -1.11534342e-01f,
  -7.95139223e-02f, 1.90336868e-01f, -4.20722440e-02f, -6.91824853e-02f, -9.33395550e-02f, -3.39495689e-02f, -1.57114521e-01f, -6.53502643e-02f, -3.45563032e-02f, 7.85234943e-03f,
  -1.10117830e-01f, -1.95860416e-01f, 1.81168842e-03f, -8.24194476e-02f, -3.66743319e-02f, 5.38950451e-02f, 2.77135056e-02f, -8.23133588e-02f, 3.54721546e-02f, -2.95746103e-02f,
  5.53235449e-02f, 7.67196938e-02f, 6.40326738e-02f, 4.51859972e-03f, -6.98986696e-03f, -4.68757637e-02f, 1.60313062e-02f, -7.50164315e-02f, 1.03153668e-01f, 5.31657413e-02f,
  1.13933556e-01f, -1.22915860e-02f, 5.44855967e-02f, 2.87485309e-02f, -1.10779461e-02f, 4.84673567e-02f, 6.46244287e-02f, 8.99024233e-02f, 1.31212920e-01f, 2.08814852e-02f,
  -2.47031767e-02f, -2.71998555e-03f, 5.60081601e-02f, 3.35435234e-02f, 1.21145556e-02f, -6.57038540e-02f, -7.59608522e-02f, -5.63215986e-02f, 9.32118222e-02f, -7.30657391e-03f,
  -1.29263438e-02f, -5.76828718e-02f, 7.22220093e-02f, -5.13651706e-02f, 2.18041502e-02f, -5.24358405e-03f, -8.59553963e-02f, -6.87092217e-03f, 2.08274946e-02f, -8.23849870e-04f,
  -3.38527039e-02f, 5.74394017e-02f, 1.69832408e-02f, -4.73769791e-02f, 8.02850425e-02f, 6.63106889e-03f, -4.80470806e-02f, -2.75237132e-02f, -6.68843314e-02f, -3.50562073e-02f,
  -5.62961027e-02f, 1.51486360e-02f, -2.04914957e-02f, -4.30731699e-02f, 3.38671319e-02f, -3.77832241e-02f, 5.43052889e-02f, 7.18570724e-02f, 4.16521765e-02f, -3.66771333e-02f,
  -1.20083250e-01f, -1.12526873e-02f, 5.24617620e-02f, 9.99528319e-02f, 3.16890813e-02f, -3.33277253e-03f, -1.57280620e-02f, 2.06016540e-03f, 2.50985064e-02f, 2.05585416e-02f,
  1.12144565e-02f, 1.66485831e-03f, -2.76956931e-02f, 3.38073485e-02f, 4.32696082e-02f, -5.69661148e-02f, -2.62137633e-02f, -7.29979128e-02f, 9.07567441e-02f, -1.64024942e-02f,
  9.34026390e-02f, -3.90450098e-02f, 9.96082574e-02f, 4.84358706e-02f, 5.23834452e-02f, 4.38335091e-02f, 2.06347462e-02f, 3.47669981e-02f, -2.81387940e-02f, 1.61373094e-02f,
  -3.88119221e-02f, 5.93310175e-03f, -3.44537012e-02f, -1.14214033e-01f, 8.83356854e-02f, 1.49946883e-01f, -5.22326026e-03f, -7.88178877e-04f, -1.38484731e-01f, -5.37715619e-03f,
  -8.20774585e-02f, -4.34239022e-02f, -4.49806713e-02f, 3.31838317e-02f, 1.24335915e-01f, 7.28350654e-02f, 1.59285769e-01f, 2.91994680e-02f, 1.86610222e-02f, -7.51157701e-02f,
  -4.90734242e-02f, 1.01215737e-02f, 1.80168763e-01f, -6.58494979e-02f, 7.35748792e-03f, -1.37076691e-01f, -9.62526873e-02f, -8.85650069e-02f, 6.44693002e-02f, 1.20238163e-01f,
  -6.60088584e-02f, -1.58161432e-01f, -1.12853281e-01f, -9.07290056e-02f, -1.97153930e-02f, -7.37157091e-02f, 5.44126816e-02f, -4.80265319e-02f, -8.87125880e-02f, -4.06355523e-02f,
  -8.28865170e-02f, -1.99013557e-02f, -9.30894017e-02f, -5.12108542e-02f, 5.21020219e-02f, 2.45693605e-02f, -1.08558899e-02f, 7.14873299e-02f, -1.43174492e-02f, 1.14852972e-01f,
  -5.01325093e-02f, -6.98939040e-02f, 2.30738726e-02f, -2.35700491e-03f, -6.73845969e-03f, 5.96849807e-02f, -4.02948894e-02f, 5.54270409e-02f, 3.66778970e-02f, -2.71721259e-02f,
  4.40117046e-02f, -4.35399041e-02f, -1.75357535e-02f, -5.14197238e-02f, -2.89700422e-02f, 2.40238905e-02f, 6.69507161e-02f, 5.35046086e-02f, 2.54200399e-02f, 4.48520342e-03f,
  -6.68331012e-02f, 3.39213908e-02f, 7.05857873e-02f, -1.40205650e-02f, 3.92534733e-02f, 5.49352914e-02f, 8.62537101e-02f, -7.32765496e-02f, -1.06805945e-02f, 6.59338664e-03f,
  -4.11520004e-02f, 4.20325361e-02f, -9.03340057e-04f, -3.31613347e-02f, 9.43149615e-04f, 2.98017971e-02f, -3.69078218e-04f, -3.18752676e-02f, 3.49728130e-02f, -4.13436815e-02f,
  -1.31177515e-01f, -1.11273542e-01f, -5.21024428e-02f, -9.04480368e-02f, -9.57415923e-02f, 2.84220669e-02f, -1.14331180e-02f, -4.93419766e-02f, 3.29459757e-02f, 1.34854568e-02f,
  5.92243299e-03f, -3.53609324e-02f, -3.82347144e-02f, 4.05902043e-02f, 1.36143565e-02f, -1.05641901e-01f, -8.35295618e-02f, 2.18979828e-03f, -1.05588838e-01f, -4.72074635e-02f,
  -9.85403955e-02f, -1.81004722e-02f, 2.26167031e-02f, -6.03564158e-02f, -6.76323101e-02f, -1.85126942e-02f, 1.25203701e-02f, 3.28502664e-03f, 7.18027502e-02f, 8.07045586e-03f,
  -1.39951244e-01f, 8.72862935e-02f, -4.77768891e-02f, -7.18289688e-02f, 5.27618565e-02f, -4.31374684e-02f, 6.15625121e-02f, -5.64834476e-02f, 3.41883078e-02f, 7.95493349e-02f,
  2.10457034e-02f, -1.87419876e-01f, 4.70223982e-04f, -4.47312929e-02f, -1.38510630e-01f, 7.97941834e-02f, -7.57658035e-02f, -2.17846707e-02f, 4.52068821e-02f, -7.00373426e-02f,
  -5.99564873e-02f, 2.19299328e-02f, -8.45889300e-02f, 2.58407127e-02f, -5.97337633e-02f, -5.40381074e-02f, -2.77254544e-02f, 6.17683791e-02f, -1.02064414e-02f, -3.06041203e-02f,
  -1.05358459e-01f, 2.49917712e-03f, 7.12419227e-02f, -5.29662929e-02f, -1.34173036e-01f, 2.79379692e-02f, -1.23407297e-01f, -1.70291141e-02f, -2.81578526e-02f, -2.80594453e-02f,
  -2.61340979e-02f, 2.74317507e-02f, 8.55804048e-03f, 8.91743153e-02f, 7.30332881e-02f, 4.19064723e-02f, 3.31312753e-02f, -6.03063889e-02f, 1.02822902e-02f, -7.20693618e-02f,
  7.90006146e-02f, 5.54005243e-02f, -1.14737917e-02f, -9.53497514e-02f, -1.02454536e-01f, -1.50275547e-02f, -7.14699402e-02f, -3.79391871e-02f, -8.61204043e-02f, 7.06253387e-03f,
  5.72083443e-02f, -2.63612624e-02f, 6.24888986e-02f, 8.13266262e-03f, -2.98041552e-02f, 5.71774058e-02f, 1.11047819e-03f, 9.78855863e-02f, 8.83677416e-03f, -9.40491632e-02f,
  -8.26243013e-02f, -5.72420955e-02f, 2.90355422e-02f, -8.38069245e-02f, 9.52325091e-02f, -6.88228980e-02f, -7.79952928e-02f, 2.31003221e-02f, 6.28595278e-02f, -8.67992789e-02f,
  6.73640817e-02f, -2.74155363e-02f, 5.59792034e-02f, -5.85811548e-02f, -8.46900642e-02f, -5.44206537e-02f, -9.74372104e-02f, 7.10878074e-02f, -1.19145103e-02f, -7.79389497e-03f,
  -1.17032446e-01f, -1.30316749e-01f, 4.12872583e-02f, -3.51307727e-02f, 3.02674305e-02f, 7.22977072e-02f, 3.71832284e-03f, -9.94239748e-02f, -1.04231536e-01f, -3.85284871e-02f,
  4.24118787e-02f, 1.94296464e-02f, -3.57577875e-02f, 9.72837806e-02f, 4.58206385e-02f, 1.98926143e-02f, 2.96718255e-02f, 3.27614248e-02f, -1.14699200e-01f, -2.31380686e-02f,
  -3.24871503e-02f, -8.64903256e-02f, 6.49279263e-03f, -5.44122607e-03f, -2.91085336e-02f, -2.63386406e-02f, -9.99269262e-02f, -5.62751442e-02f, -5.78453206e-02f, 5.90607226e-02f,
  -2.06307039e-01f, -8.47864747e-02f, 1.64240256e-01f, -8.03492516e-02f, 2.51133535e-02f, 1.97361350e-01f, 2.27878153e-01f, 5.17204739e-02f, 9.18764155e-03f, -7.55504817e-02f,
  3.30145434e-02f, -1.15542613e-01f, 6.90541714e-02f, 1.52177142e-03f, 1.67479575e-01f, 1.47925645e-01f, -3.75864431e-02f, -6.02651271e-04f, -3.50476429e-02f, -1.17895178e-01f,
  5.22244163e-03f, -3.83054763e-02f, 5.94825223e-02f, -7.34664798e-02f, -1.28224969e-01f, -2.12319165e-01f, -1.04751430e-01f, -3.87543365e-02f, -1.52922139e-01f, 5.91609580e-03f,
  6.83119707e-03f, -2.32940894e-02f, -5.25756404e-02f, 5.54802492e-02f, -1.91462487e-02f, -2.90012211e-02f, -8.55653808e-02f, 8.31637830e-02f, 2.47024558e-02f, 2.01854892e-02f,
  -3.57489996e-02f, 4.40096818e-02f, -4.69893590e-02f, 3.20477933e-02f, -1.93949305e-02f, 6.71865344e-02f, -5.82310408e-02f, -3.54033038e-02f, 2.32856125e-02f, 2.01106165e-02f,
  1.00971684e-01f, -4.99682054e-02f, 6.27782643e-02f, 1.93067491e-02f, -1.98679939e-02f, -4.17065732e-02f, -7.99484476e-02f, 2.86412090e-02f, -8.72634724e-02f, 8.17704573e-02f,
  -3.93857285e-02f, -6.54489398e-02f, -6.25433102e-02f, -2.25004982e-02f, 1.06728956e-01f, 3.55731882e-02f, 5.16208261e-02f, -6.72509894e-02f, -3.57631370e-02f, 4.30921316e-02f,
  -1.04058320e-02f, 1.10987965e-02f, 1.11181708e-02f, -1.65785160e-02f, -7.08714053e-02f, -8.79413337e-02f, -6.78077713e-02f, -3.19594070e-02f, -7.38841370e-02f, 3.57484184e-02f,
  -6.99739680e-02f, -2.88789403e-02f, -4.64493595e-02f, 6.50203377e-02f, -6.53534308e-02f, -2.70741731e-02f, -8.04632604e-02f, -5.25853187e-02f, -2.88258586e-02f, -4.50004451e-03f,
  -9.20209512e-02f, -1.23359926e-01f, -1.24135643e-01f, -5.58280945e-02f, -7.34977424e-03f, 3.87309007e-02f, -3.64954136e-02f, -4.85457890e-02f, 6.82714209e-02f, 6.36369735e-02f,
  -2.23535951e-02f, -8.78769085e-02f, -2.55127028e-02f, -1.14174308e-02f, 8.31204504e-02f, 6.90035475e-03f, -8.32538605e-02f, -4.87458110e-02f, 3.64430472e-02f, -1.16357811e-01f,
  -6.26655892e-02f, 1.36702871e-02f, 7.73671791e-02f, 4.26149480e-02f, -1.17721967e-01f, 2.08277572e-02f, 1.72852129e-02f, 7.28078559e-02f, 5.07974550e-02f, 1.39582660e-02f,
  -3.30183327e-01f, 2.68418877e-03f, -5.18766232e-02f, -3.97350669e-01f, 1.39568567e-01f, -1.57533586e-01f, -1.47186771e-01f, 8.37065578e-02f, -1.37802556e-01f, 2.39695191e-01f,
  1.03355214e-01f, -1.76819757e-01f, 8.96890312e-02f, -4.30784196e-01f, -4.78949577e-01f, -1.91805393e-01f, -3.65020663e-01f, -1.92004785e-01f, -5.29483929e-02f, -1.68711349e-01f,
  -2.27811754e-01f, -2.93696038e-02f, -2.12849319e-01f, 2.55597591e-01f, -7.40512833e-02f, 1.19533159e-01f, 1.04695536e-01f, 2.91594595e-01f, -4.88166846e-02f, -1.00329779e-02f,
  -9.45874378e-02f, 6.57598227e-02f, 6.89705163e-02f, 7.72952512e-02f, 2.77526882e-02f, -8.97134468e-03f, 1.81812346e-02f, -1.35586485e-02f, -2.37819683e-02f, -7.03387111e-02f,
  -3.75546259e-03f, -7.41530349e-03f, -9.91011187e-02f, 8.45723152e-02f, -3.36783752e-02f, 2.25729700e-02f, -6.55204710e-03f, -1.80575866e-02f, -9.71850567e-03f, 3.56988758e-02f,
  -4.69417758e-02f, -8.87617767e-02f, -9.54383835e-02f, -1.56730190e-02f, 2.92780474e-02f, 3.87132317e-02f, -8.66389498e-02f, -1.82578918e-02f, 3.30155999e-05f, -8.33011046e-02f,
  -2.99272332e-02f, 3.50796990e-02f, 5.04494226e-03f, -4.84391749e-02f, -7.09444331e-03f, 8.70826468e-02f, 7.25181326e-02f, 1.35464417e-02f, 7.82727897e-02f, -1.15739889e-02f,
  -5.86034283e-02f, -2.93808933e-02f, 4.20229025e-02f, 3.89008336e-02f, -6.01369478e-02f, 4.03261296e-02f, 5.52022690e-03f, -1.54366065e-02f, -1.03782982e-01f, 2.30126642e-02f,
  2.80118883e-02f, 8.42613261e-03f, -2.66875587e-02f, 2.26856284e-02f, -3.56931835e-02f, 4.83035520e-02f, 2.39817575e-02f, 2.80326866e-02f, -3.29465233e-02f, -4.30928953e-02f,
  -1.08602922e-02f, -3.37654678e-03f, -2.75788326e-02f, 2.28076987e-02f, 2.83770356e-02f, -9.43840295e-03f, 7.79888546e-03f, -6.87234625e-02f, -1.01690432e-02f, 1.09915510e-02f,
  4.37527783e-02f, -1.18625443e-02f, -4.66151424e-02f, -6.19689226e-02f, -3.47944885e-03f, -1.20565563e-03f, 2.98951976e-02f, -3.60651761e-02f, -2.05883849e-02f, 2.33303364e-02f,
  1.03498604e-02f, 1.00300059e-01f, 6.96567371e-02f, -2.32321769e-02f, -2.85035502e-02f, 1.65865908e-03f, -3.36716473e-02f, 7.27223605e-02f, 2.91442196e-03f, -6.82027712e-02f,
  3.50087672e-01f, -1.57236502e-01f, -4.81541604e-02f, 1.46998271e-01f, 2.30735868e-01f, -1.93471182e-02f, -3.29814143e-02f, 1.15625136e-01f, 1.42881423e-01f, -1.47513255e-01f,
  1.35484161e-02f, -2.16358349e-01f, -2.20276833e-01f, 7.45350868e-02f, 7.26146400e-02f, -1.40804332e-02f, 3.16590555e-02f, -1.54228089e-02f, 3.29538137e-02f, 7.54643083e-02f,
  1.63410336e-01f, 1.47091255e-01f, -1.08488865e-01f, 1.27117604e-01f, 1.77700311e-01f, 6.13622405e-02f, -4.11060229e-02f, -9.50508267e-02f, -1.56862661e-02f, 2.32742954e-04f,
  8.57204050e-02f, 7.33138770e-02f, -4.29821536e-02f, -1.27537129e-02f, -5.48282303e-02f, 1.00549012e-01f, -4.24837098e-02f, -2.84350161e-02f, 2.08071042e-02f, 5.59058899e-05f,
  -4.94669937e-02f, 4.13804874e-02f, -2.45086402e-02f, 1.18167281e-01f, 3.77553888e-02f, 4.64609750e-02f, 2.75132861e-02f, 2.85341591e-02f, -3.52968648e-02f, -5.62514514e-02f,
  -6.32124394e-03f, -4.43735719e-02f, 6.48808479e-02f, -6.64398298e-02f, 6.12305775e-02f, 4.04181927e-02f, -5.80410138e-02f, -9.53587815e-02f, 2.29140185e-02f, -2.74493899e-02f,
  -2.09412109e-02f, -6.48867190e-02f, 7.66945630e-02f, 8.75471458e-02f, 2.31819786e-02f, 5.43349981e-02f, -2.82489285e-02f, -8.68301019e-02f, -7.67703876e-02f, -1.07739784e-01f,
  -1.49692288e-02f, 3.26292887e-02f, 8.63181893e-03f, 4.21838574e-02f, 9.11353305e-02f, -7.50463572e-04f, -4.89791147e-02f, -2.38441769e-02f, 1.71729010e-02f, 3.80312987e-02f,
  -7.65573680e-02f, -7.04494789e-02f, -7.36908168e-02f, -6.48727790e-02f, -7.84490183e-02f, 9.37036350e-02f, 9.08451155e-02f, -7.23253330e-03f, 5.55231795e-02f, -5.96546270e-02f,
  3.44031453e-02f, -1.06999576e-01f, -4.06723842e-02f, -6.84427023e-02f, -1.16346844e-01f, -6.91705123e-02f, -9.71513614e-02f, -3.73789258e-02f, -7.94017166e-02f, 8.75436664e-02f,
  -4.85787466e-02f, -9.94054228e-02f, -8.20448846e-02f, -4.42738496e-02f, -5.50861880e-02f, 1.04670405e-01f, -6.27902672e-02f, -2.16386355e-02f, -7.86170140e-02f, -6.93101808e-02f,
  -1.72537304e-02f, -7.63974339e-02f, -6.03512488e-02f, 3.58553007e-02f, 8.23790021e-03f, -7.45750591e-02f, 5.95312305e-02f, -6.76755235e-03f, -9.16566048e-03f, -6.17335141e-02f,
  1.13336779e-01f, -9.73071456e-02f, -2.33055115e-01f, -1.51705042e-01f, -5.97407185e-02f, 1.38797626e-01f, 7.68818334e-03f, -9.93453190e-02f, -1.89279705e-01f, 7.81877488e-02f,
  4.73953970e-03f, -7.52939656e-02f, 5.15923388e-02f, -6.57620206e-02f, 3.81630734e-02f, -6.54257312e-02f, -7.90725201e-02f, -7.92938620e-02f, 2.28608027e-02f, 1.19416766e-01f,
  -8.13340843e-02f, 2.01172307e-02f, -1.02114543e-01f, 1.38093099e-01f, 6.03244416e-02f, 7.26617202e-02f, -1.18227145e-02f, -2.90889572e-02f, -5.09689078e-02f, -8.54500532e-02f,
  5.82095459e-02f, 9.51895714e-02f, -7.82835111e-02f, -4.32263426e-02f, 1.22267582e-01f, 3.51725705e-02f, 8.44333321e-02f, 4.65535894e-02f, 5.55188283e-02f, 4.20994647e-02f,
  -6.20498545e-02f, -3.99931706e-02f, 6.03734516e-02f, -5.68033084e-02f, -8.78139436e-02f, 1.19042546e-02f, -6.89329486e-03f, -6.77420348e-02f, -2.84495968e-02f, 2.88152713e-02f,
  -4.59561050e-02f, -8.13020691e-02f, -2.78238654e-02f, 1.22028645e-02f, -2.34342087e-02f, -2.38985401e-02f, 6.01523882e-03f, 3.18138413e-02f, 4.36717421e-02f, -6.91169873e-02f,
  4.96901460e-02f, 1.92713272e-02f, 1.68062057e-02f, 8.98198225e-03f, -6.82132095e-02f, -6.61601350e-02f, -2.83552837e-02f, -4.83269021e-02f, -7.47469887e-02f, 8.44144821e-03f,
  6.63014948e-02f, -3.66097167e-02f, -2.19881255e-02f, 3.83630134e-02f, -4.20287251e-02f, -5.37124127e-02f, 1.90282352e-02f, 7.86897838e-02f, -6.23890050e-02f, -1.81400552e-02f,
  7.67294765e-02f, 4.58993651e-02f, -6.80771768e-02f, -6.42523244e-02f, -6.40398338e-02f, -1.24318181e-02f, 8.78228992e-02f, 1.10616917e-02f, 2.07932498e-02f, 7.14380294e-02f,
  9.43821967e-02f, 5.93496859e-02f, -1.87236723e-02f, 2.75675021e-02f, 1.60424262e-02f, 2.33420217e-03f, -5.16658239e-02f, -1.77260451e-02f, -4.19894569e-02f, 4.58201058e-02f,
  8.63709971e-02f, -2.97024753e-02f, -3.50346193e-02f, 7.43953884e-02f, -4.92446199e-02f, 5.67901507e-02f, 8.10645297e-02f, -5.86478524e-02f, -3.12466384e-03f, 6.50242269e-02f,
  -1.42927691e-02f, 7.60776829e-03f, -7.36775994e-02f, -1.93565041e-02f, -1.70105267e-02f, 6.76247030e-02f, 5.25525808e-02f, -4.10882384e-02f, 3.25463898e-03f, 2.54332181e-02f,
  -1.46224955e-02f, 5.76927811e-02f, 3.77824344e-03f, -1.14963576e-01f, -1.80479825e-01f, 1.58549547e-01f, 1.27946258e-01f, 5.57073653e-02f, -1.88746061e-02f, 1.27296716e-01f,
  -5.60250394e-02f, -7.01195076e-02f, 1.75424218e-01f, -4.07492295e-02f, 1.91658124e-01f, 2.44455010e-01f, 1.58720270e-01f, -1.73166785e-02f, -2.41123009e-02f, -4.73213047e-02f,
  3.20414943e-03f, -3.29324827e-02f, -1.22381277e-01f, -9.86719504e-02f, -1.34587318e-01f, -1.99713275e-01f, -1.02488592e-01f, 1.25127344e-03f, -4.20692973e-02f, -1.19131478e-02f,
  2.59233825e-02f, 9.56220999e-02f, 2.50133239e-02f, 1.04832217e-01f, 1.15129501e-02f, 8.73439461e-02f, -9.81986821e-02f, 7.51294270e-02f, 2.51419935e-02f, -4.18632962e-02f,
  -1.01125613e-02f, -4.57473136e-02f, -6.19219355e-02f, -1.57953855e-02f, 3.24776359e-02f, -8.72324854e-02f, 3.80852744e-02f, -5.05472869e-02f, -5.74732721e-02f, -1.04592061e-02f,
  -2.30151694e-04f, 1.55174814e-03f, -4.43196259e-02f, -2.38969252e-02f, 5.69360144e-02f, -5.49004115e-02f, -3.17054875e-02f, -6.73527792e-02f, -6.18361756e-02f, -5.97424656e-02f,
  1.70102138e-02f, 5.34355007e-02f, 4.03967872e-02f, -5.89219341e-03f, -1.82958916e-02f, -2.36826092e-02f, -6.50120974e-02f, -5.09122089e-02f, -8.13062638e-02f, -6.63266405e-02f,
  -1.90904588e-02f, -3.77789699e-02f, -8.46400764e-03f, -6.51909187e-02f, 4.22739312e-02f, -2.60775629e-02f, -4.99999411e-02f, 6.62969425e-02f, -4.27702256e-02f, 5.19279167e-02f,
  1.48842414e-03f, 1.03507088e-02f, 4.70681041e-02f, -6.22321628e-02f, 5.96978888e-02f, -2.18184143e-02f, -8.54456872e-02f, -7.48917609e-02f, -2.66764853e-02f, -4.12527584e-02f,
  7.33654797e-02f, 1.72665134e-01f, -3.24464403e-03f, 9.22297239e-02f, -9.60810203e-03f, -4.71628197e-02f, -1.85545590e-02f, 6.70771748e-02f, 1.90690290e-02f, 7.52398074e-02f,
  -1.92856360e-02f, 8.25976059e-02f, 3.88238132e-02f, -6.49245083e-02f, 1.65537801e-02f, 3.29816602e-02f, 2.57107653e-02f, 2.45346259e-02f, -2.38290578e-02f, 2.37691104e-02f,
  -5.80988787e-02f, 9.46716592e-02f, 1.02219433e-02f, 2.38523297e-02f, 2.76986770e-02f, -6.81623742e-02f, 5.00759371e-02f, -9.16560441e-02f, 2.26850770e-02f, 3.12279779e-02f,
  -1.33072371e-02f, -1.19384967e-01f, -1.18913643e-01f, -1.57410026e-01f, 1.44123524e-01f, 2.16793597e-01f, 6.92794472e-02f, 2.09043976e-02f, -1.57175317e-01f, 9.51355100e-02f,
  4.47134897e-02f, -1.66028306e-01f, -1.96951479e-02f, -1.05445005e-01f, 7.24372491e-02f, -1.46097973e-01f, 2.14616600e-02f, -3.79133523e-02f, -1.42309815e-01f, -4.41288613e-02f,
  -3.17002572e-02f, 3.83610502e-02f, -1.17137387e-01f, 9.87197086e-02f, 1.26092464e-01f, 9.27852690e-02f, 1.91373065e-01f, 1.29971892e-01f, 5.07807657e-02f, 2.60519367e-02f,
  -1.79736838e-02f, -1.46672234e-01f, -1.05313979e-01f, -6.38389355e-03f, -8.54550512e-04f, 1.55208101e-02f, 5.70786372e-02f, 4.13881838e-02f, -3.59812416e-02f, 1.74205862e-02f,
  -3.08485646e-02f, -4.75013033e-02f, 5.12936851e-04f, 3.96344289e-02f, -8.18012357e-02f, 2.97625717e-02f, 4.23618555e-02f, -4.41655964e-02f, -5.02390824e-02f, -9.40130427e-02f,
  1.07052585e-03f, -7.27914833e-03f, 2.57249158e-02f, 2.64458954e-02f, 2.95452233e-02f, -7.13333338e-02f, 7.39842653e-03f, 4.17175405e-02f, -6.15142472e-02f, 5.60181960e-02f,
  -6.29384536e-03f, -4.80523407e-02f, 7.39275217e-02f, -5.10403886e-02f, -2.32442357e-02f, 7.61981588e-03f, -9.37177092e-02f, 4.83244956e-02f, 2.51946822e-02f, 8.86107087e-02f,
  -8.74762759e-02f, 2.08404362e-02f, -8.87776315e-02f, 4.39025983e-02f, -6.28816485e-02f, -1.59035958e-02f, 4.69379723e-02f, 6.01327419e-03f, 6.54069483e-02f, -2.70511415e-02f,
  5.94792776e-02f, 5.61322235e-02f, -3.62533554e-02f, -4.55374718e-02f, -4.86416444e-02f, 3.77542004e-02f, -4.15857919e-02f, 8.86725336e-02f, -5.38211279e-02f, 4.89317551e-02f,
  1.39045924e-01f, 3.14711034e-02f, 2.91230343e-03f, -5.11528924e-02f, -1.42704146e-02f, 5.26254140e-02f, -3.20849158e-02f, -4.29117903e-02f, 2.18893401e-02f, 2.16465034e-02f,
  7.82087371e-02f, 2.31563114e-02f, 9.10102278e-02f, 7.19459131e-02f, 4.06447910e-02f, 8.33080709e-02f, -4.90242429e-02f, 1.11524701e-01f, 8.35046619e-02f, 7.60574937e-02f,
  8.16215724e-02f, 7.14282542e-02f, 8.79077334e-03f, -4.77379598e-02f, 1.05034560e-02f, -1.70058217e-02f, -2.15942729e-02f, -4.62761670e-02f, 1.45533727e-02f, -5.04083857e-02f,
  -5.66022061e-02f, -1.35568991e-01f, 1.41490474e-01f, -6.25444427e-02f, 1.28156424e-01f, 1.75617971e-02f, 7.52939703e-03f, -7.43550509e-02f, -5.46418875e-02f, -8.11949894e-02f,
  -1.63466353e-02f, -2.55782194e-02f, 5.33510111e-02f, -7.03741238e-02f, -5.45780919e-02f, 6.32341132e-02f, -6.29044101e-02f, -1.07073501e-01f, 6.08017854e-02f, -5.86039722e-02f,
  6.48559164e-03f, 5.40438332e-02f, -3.56460661e-02f, 9.72158909e-02f, 1.05076411e-03f, 2.37375721e-02f, -9.80025828e-02f, -5.45295002e-03f, -7.48591200e-02f, -3.55642401e-02f,
  -1.48042917e-01f, 5.78103866e-03f, 3.74741256e-02f, 6.95203021e-02f, 3.47956307e-02f, -1.04896672e-01f, -5.08225523e-02f, 6.51152283e-02f, -5.15544116e-02f, 3.05069331e-02f,
  -3.55848558e-02f, 9.66472998e-02f, 5.35303280e-02f, -4.19569528e-03f, -7.59076029e-02f, -2.66048498e-02f, -3.81346717e-02f, 6.35482557e-03f, -4.16059978e-02f, 1.33224512e-02f,
  4.68563959e-02f, 7.99154192e-02f, -4.59962934e-02f, 6.80517629e-02f, 3.49201486e-02f, -7.27292746e-02f, 5.31660207e-02f, -3.11419424e-02f, 6.14180788e-02f, -7.05937296e-02f,
  -9.27522257e-02f, 3.18051688e-02f, 6.89889938e-02f, 7.94135779e-02f, -6.59434870e-02f, 4.63547409e-02f, 5.89015596e-02f, 3.49464789e-02f, 7.90903419e-02f, 6.58212751e-02f,
  -2.62655653e-02f, 2.71300822e-02f, 7.74399424e-03f, -1.29351323e-03f, -3.29126380e-02f, -1.49156572e-02f, 7.06035718e-02f, 6.36024773e-02f, -7.86368698e-02f, -5.68519458e-02f,
  -5.77534772e-02f, 5.00405654e-02f, -4.98239212e-02f, 7.04562292e-02f, 3.22919488e-02f, 5.23953326e-02f, -7.52888322e-02f, -5.84407449e-02f, 7.78464228e-02f, -3.98660190e-02f,
  -1.87137872e-01f, -6.92294836e-02f, -5.11424020e-02f, -1.77499708e-02f, -2.33301185e-02f, -1.06282241e-03f, 6.50301948e-02f, 2.10253224e-02f, 2.13996915e-04f, -5.19565679e-02f,
  -4.00874652e-02f, -9.41956416e-02f, -8.78217518e-02f, -5.71451150e-02f, 2.89957877e-03f, -7.89472461e-02f, -7.40504414e-02f, 6.19997419e-02f, -5.12140319e-02f, -5.78261167e-03f,
  4.29735668e-02f, -8.61494467e-02f, -6.79240329e-03f, 1.47352545e-02f, -6.14089966e-02f, -7.37862289e-02f, -1.13958344e-02f, -3.80328670e-02f, -3.40699889e-02f, 2.57788077e-02f,
  -1.27357334e-01f, -2.12942630e-01f, 1.34206831e-01f, -6.43586293e-02f, -5.78186288e-02f, 1.69843614e-01f, 1.92499757e-01f, -1.84310153e-01f, -2.69851536e-01f, -9.55492184e-02f,
  -3.23236324e-02f, 3.34118679e-03f, 2.16907144e-01f, 5.54269366e-02f, 2.46057913e-01f, 2.44178101e-01f, 1.07638165e-01f, 1.67729139e-01f, 4.98968363e-02f, 4.13428955e-02f,
  -5.50424866e-02f, -1.49916066e-02f, 2.42907494e-01f, -6.80518569e-03f, 3.07347737e-02f, -1.69509873e-01f, -7.05136359e-02f, 1.85346276e-01f, 6.30637631e-02f, 1.45953029e-01f,
  -7.43222907e-02f, -5.67065142e-02f, 8.76106024e-02f, 5.76806664e-02f, 6.54943585e-02f, -5.60947657e-02f, 7.82694668e-02f, 1.21140882e-01f, -5.24159707e-02f, 1.91874150e-02f,
  -4.26832512e-02f, 2.19466593e-02f, -5.32665662e-03f, 4.32470851e-02f, -4.35344093e-02f, -6.74972832e-02f, 3.81738991e-02f, 1.40536586e-02f, -8.69553536e-02f, 8.78238678e-02f,
  -3.42902332e-03f, 1.80191640e-03f, 4.19932529e-02f, -1.12050900e-03f, 7.66986683e-02f, -1.15885690e-01f, 2.33667418e-02f, -2.20182519e-02f, 2.49442048e-02f, -6.27979413e-02f,
  3.10383309e-02f, 1.01784738e-02f, 6.08610827e-03f, -4.72140796e-02f, -1.24403490e-02f, -1.41543644e-02f, -9.68284085e-02f, 5.01814410e-02f, 3.27413873e-04f, 3.92561667e-02f,
  -1.18002091e-02f, -2.64612529e-02f, 6.66458532e-02f, 2.45211367e-03f, -7.70722851e-02f, -1.95906423e-02f, 6.23289235e-02f, 2.23339144e-02f, 4.37774546e-02f, 3.37544121e-02f,
  2.17670333e-02f, 9.36609693e-03f, 4.68392074e-02f, 2.96999011e-02f, 2.85318010e-02f, 3.75369601e-02f, 3.36955599e-02f, -2.83232592e-02f, 6.88274205e-02f, 5.84925264e-02f,
  -6.05371632e-02f, -1.82196990e-01f, -6.01056032e-02f, -4.27387767e-02f, 3.35406289e-02f, -1.00525051e-01f, 7.35072568e-02f, -2.12670993e-02f, -1.44642852e-02f, -7.02184141e-02f,
  -7.93119892e-02f, -8.22872147e-02f, -1.79051142e-02f, 2.49326825e-02f, 7.20750121e-03f, 1.94665231e-02f, -7.08977925e-03f, 2.36474141e-03f, -3.93001884e-02f, -6.72017187e-02f,
  3.54265608e-02f, -3.76781709e-02f, 3.37014794e-02f, 4.47727814e-02f, -3.06767263e-02f, -9.07397270e-02f, -1.18047170e-01f, 1.79549288e-02f, 7.49598145e-02f, -6.20326325e-02f,
  5.16774170e-02f, -5.24319150e-02f, 2.05313005e-02f, 3.04018687e-02f, -9.37743708e-02f, -1.65879298e-02f, -1.07984699e-01f, -1.14108704e-01f, -2.41973579e-01f, -3.66234244e-03f,
  -2.26715561e-02f, -2.65107136e-02f, -3.32283527e-02f, -1.99643206e-02f, 7.39956945e-02f, -1.50013015e-01f, 9.75061134e-02f, 8.19807649e-02f, -1.66284204e-01f, -3.71240303e-02f,
  -4.82805558e-02f, -6.32467493e-02f, -6.22786433e-02f, -7.22047538e-02f, -1.62425619e-02f, 5.58615616e-03f, 2.24080697e-01f, 5.54258563e-02f, 1.91931024e-01f, 2.41343901e-02f,
  -1.06052801e-01f, -1.41512841e-01f, -5.99921606e-02f, -6.73492625e-02f, 8.19172263e-02f, 9.82395485e-02f, 1.65185809e-01f, 3.59568186e-02f, -9.28088836e-03f, -1.16226077e-01f,
  1.09479986e-01f, -3.66317667e-02f, -1.25090495e-01f, 3.76833230e-02f, 3.41163352e-02f, 3.30635123e-02f, -9.42298248e-02f, 7.57185072e-02f, 5.06426655e-02f, -5.15556000e-02f,
  -1.36476129e-01f, -5.79665676e-02f, 2.75259148e-02f, 3.46006528e-02f, -5.86544611e-02f, 6.38369769e-02f, -2.34315060e-02f, 2.44171880e-02f, 2.13065017e-02f, -3.15379426e-02f,
  6.81192353e-02f, -1.07211517e-02f, -5.82540482e-02f, -3.79779264e-02f, -5.16208336e-02f, -5.30194119e-02f, 8.88486654e-02f, -5.59547171e-02f, 5.99908195e-02f, -7.59880766e-02f,
  -2.27639675e-02f, -2.55653560e-02f, 1.07498184e-01f, -2.49149036e-02f, 6.01219051e-02f, -7.46082887e-02f, 1.78995281e-02f, 1.38043426e-02f, -4.88564633e-02f, 3.15482579e-02f,
  -8.14344138e-02f, -3.99469882e-02f, 5.57372421e-02f, 8.85399505e-02f, -7.05085844e-02f, 2.91970540e-02f, -2.61321831e-02f, 7.06766173e-02f, -2.39702011e-03f, 7.58811086e-03f,
  1.23864777e-01f, 1.35965690e-01f, 4.17174809e-02f, -7.92255178e-02f, -4.02566716e-02f, -3.33036706e-02f, -6.76117688e-02f, 6.00743480e-02f, -5.86203672e-02f, 7.12085143e-02f,
  1.56714380e-01f, -3.70659158e-02f, 6.30407184e-02f, 6.43329620e-02f, -7.70370737e-02f, -6.28372282e-02f, 3.31153274e-02f, 1.84572637e-02f, 8.54741931e-02f, 1.31425878e-03f,
  6.45931363e-02f, 2.37389430e-02f, -6.07327707e-02f, 7.27076083e-03f, -1.79944411e-02f, 9.65661556e-02f, 6.24866150e-02f, 1.10878900e-01f, 1.08372137e-01f, -4.49795127e-02f,
  1.74379528e-01f, -6.80898130e-02f, -1.09828830e-01f, 2.03630581e-01f, 5.00987209e-02f, -5.03805019e-02f, -1.82474419e-01f, 2.70985570e-02f, -1.91949815e-01f, -1.09356456e-01f,
  1.03822567e-01f, 1.32239927e-02f, -1.70880109e-01f, 1.31318778e-01f, 1.83502823e-01f, -2.40350574e-01f, 1.19028367e-01f, -3.70132830e-03f, -1.42965958e-01f, 4.82220612e-02f,
  1.42280862e-01f, 1.46388650e-01f, 1.55343130e-01f, 1.82002634e-01f, 1.31412074e-01f, 1.44652843e-01f, 1.15104280e-01f, -4.81994376e-02f, 3.04892331e-01f, 1.74109966e-01f,
  3.63402488e-03f, -1.29028261e-02f, 3.78161073e-02f, 1.48413796e-02f, -1.13823509e-03f, -7.46020628e-03f, 7.47374520e-02f, 7.14253634e-02f, -1.12005826e-02f, -3.60958539e-02f,
  -4.10063155e-02f, 7.89324939e-02f, 1.08505346e-01f, 7.48283928e-03f, 3.77547480e-02f, 5.61847240e-02f, -8.21859464e-02f, -5.71583305e-03f, -1.07811742e-01f, 4.70798649e-03f,
  -1.13919534e-01f, -4.09479626e-03f, 7.27916211e-02f, -8.23918264e-03f, -5.72980456e-02f, 5.57085723e-02f, 2.88396655e-03f, -1.92715395e-02f, 4.14237939e-02f, 4.35195863e-02f,
  6.34245425e-02f, 3.05452314e-03f, -3.19922380e-02f, -2.16285773e-02f, 4.04019952e-02f, -8.32756888e-03f, -4.53206375e-02f, 8.52163229e-03f, -7.86314160e-02f, 2.07304093e-03f,
  -6.24400564e-02f, 3.85058634e-02f, 8.79812427e-03f, -1.51206935e-02f, 6.82783723e-02f, -4.67320941e-02f, -6.26493096e-02f, 3.80366929e-02f, -6.29839525e-02f, 4.30711806e-02f,
  -1.02341874e-02f, -2.20298730e-02f, -6.42598867e-02f, 2.20935680e-02f, 6.04386739e-02f, -8.28393921e-02f, 2.41137315e-02f, -1.02955094e-02f, -3.95257883e-02f, 3.58760916e-02f,
  1.28770247e-02f, 2.64046118e-02f, -1.00842558e-01f, 6.46202564e-02f, -8.34811255e-02f, -5.99503778e-02f, -4.62771766e-02f, 2.18287464e-02f, 1.66870505e-02f, 3.44504379e-02f,
  6.94682226e-02f, -1.02326777e-02f, 1.87890958e-02f, -3.03751715e-02f, 1.04739517e-01f, -5.80554642e-02f, 3.22404802e-02f, 4.27098945e-02f, 1.36889378e-02f, 4.88245711e-02f,
  6.63831159e-02f, -1.12799056e-01f, 6.88212737e-02f, 2.17825323e-02f, 1.00520663e-01f, 4.57153097e-03f, -4.33284156e-02f, -5.77301392e-03f, -3.86824794e-02f, 4.38885018e-02f,
  -9.70575958e-02f, 7.43698925e-02f, -1.27365381e-01f, -7.24279284e-02f, -1.85437836e-02f, -1.54308125e-01f, -2.83831507e-02f, -4.10719141e-02f, -6.78642392e-02f, 1.05192259e-01f,
  8.52337331e-02f, -1.08069263e-01f, 3.84284295e-02f, 9.26534832e-02f, -2.32849702e-01f, 4.26899828e-03f, -1.13220178e-01f, -1.43973054e-02f, -3.74629498e-02f, 2.17075758e-02f,
  2.34666020e-02f, 7.65521228e-02f, 8.96983314e-03f, 1.70417473e-01f, -6.29274696e-02f, -3.39747616e-03f, -7.22649992e-02f, 1.26830384e-01f, -1.02414854e-01f, 4.46997955e-02f,
  1.04284540e-01f, 3.92784476e-02f, -9.41679701e-02f, -4.14832644e-02f, -8.87564942e-02f, -9.65290442e-02f, -9.10425335e-02f, 1.30738392e-02f, -2.77598090e-02f, -6.48635551e-02f,
  -4.94485311e-02f, -3.34068052e-02f, -5.47935888e-02f, -5.54778147e-03f, 4.85126153e-02f, 4.09315620e-03f, -3.17176282e-02f, 5.02043441e-02f, -9.99404676e-03f, -2.20035166e-02f,
  -2.41268612e-02f, 4.78292592e-02f, -3.84729868e-03f, -7.48489797e-02f, -5.07065170e-02f, -5.11576869e-02f, -3.45600881e-02f, -5.52677996e-02f, 2.55554076e-02f, -5.77467196e-02f,
  2.29178579e-03f, -6.02397285e-02f, -1.63077388e-03f, -4.70581315e-02f, -2.35904865e-02f, 3.65746357e-02f, -6.96871355e-02f, 7.05414712e-02f, -7.02959821e-02f, 7.62923136e-02f,
  9.87060890e-02f, -5.36723249e-02f, 7.60575309e-02f, -4.75533567e-02f, -4.25133631e-02f, 4.88421842e-02f, 5.71182594e-02f, 6.16981313e-02f, -1.99071392e-02f, 1.53414663e-02f,
  -2.25743800e-02f, 4.79403175e-02f, -3.50157060e-02f, 7.49490922e-03f, 5.37279509e-02f, 5.90926223e-03f, 1.40389046e-02f, -1.81945004e-02f, 7.06642643e-02f, -6.37384206e-02f,
  3.53550538e-02f, -4.13002521e-02f, -7.84121733e-03f, -2.94388719e-02f, -8.15657154e-02f, 2.95441672e-02f, 3.71574685e-02f, 1.38614960e-02f, -1.22905493e-01f, -1.00452662e-01f,
  -3.96358483e-02f, -8.52657706e-02f, -7.42165223e-02f, 2.46851868e-03f, -4.14948016e-02f, -1.76807139e-02f, 6.48814486e-03f, 1.09340819e-02f, -2.78146211e-02f, -6.76343441e-02f,
  8.17266181e-02f, -2.43498315e-03f, -1.83512305e-03f, 5.10411114e-02f, -2.40555890e-02f, -3.89470905e-02f, -6.49717301e-02f, -4.22310308e-02f, -3.65443788e-02f, -7.56749809e-02f,
  3.51146832e-02f, 9.13682804e-02f, 1.10003114e-01f, -1.57601610e-02f, -1.51435584e-01f, -2.11572886e-01f, -1.82360515e-01f, -5.62793389e-02f, 1.60451204e-01f, -6.69425353e-02f,
  -1.29203245e-01f, 1.98858336e-01f, -6.58422476e-03f, -7.08291354e-03f, -7.30448663e-02f, 1.05581254e-01f, -1.05936609e-01f, -4.53641564e-02f, 1.09471843e-01f, 5.74658625e-02f,
  -1.31569784e-02f, 5.09682782e-02f, 9.16886106e-02f, -6.05837582e-03f, -3.18650678e-02f, 5.59988990e-02f, -2.66746897e-02f, 1.94118451e-02f, -7.55044352e-03f, 6.23798482e-02f,
  -3.90473343e-02f, 6.81623891e-02f, 1.02675222e-01f, -8.79566092e-03f, 6.60489798e-02f, -2.24166010e-02f, -2.12055184e-02f, -2.18424052e-02f, 3.68214324e-02f, 5.57470731e-02f,
  -5.05478866e-02f, -6.36423156e-02f, -3.45108827e-04f, 3.17908786e-02f, -3.79012637e-02f, 1.13152750e-01f, 9.08214673e-02f, -5.48353121e-02f, -1.72965042e-02f, -1.65071469e-02f,
  3.33148465e-02f, -3.72261107e-02f, 4.16637734e-02f, 6.77012280e-03f, 3.39996554e-02f, -6.26202747e-02f, -6.15665130e-02f, 6.00221008e-02f, -7.40497261e-02f, 2.16828082e-02f,
  2.16845796e-02f, -7.33020157e-02f, -2.75107054e-03f, -3.64211053e-02f, -9.46540758e-02f, 4.59099896e-02f, 8.92622843e-02f, -2.08100714e-02f, 8.73548537e-02f, 2.40278170e-02f,
  -8.79267156e-02f, -6.61707744e-02f, -7.96601549e-02f, -8.49330276e-02f, 8.55619647e-03f, -6.97420537e-02f, -3.28924432e-02f, 8.44422281e-02f, 3.18219624e-02f, -3.67919914e-03f,
  7.76285399e-03f, -9.41794366e-02f, -5.81840472e-03f, -8.94096214e-03f, -5.15925474e-02f, 4.03091833e-02f, 5.17443679e-02f, -4.98761535e-02f, 5.08079268e-02f, 2.26583164e-02f,
  5.56533821e-02f, 1.99156627e-01f, -4.27779630e-02f, 7.62164034e-03f, -7.49627501e-02f, -4.75589186e-02f, 5.73930182e-02f, 1.94850024e-02f, 6.15292788e-02f, 8.29577148e-02f,
  3.30590643e-02f, 4.66567352e-02f, -8.51175934e-02f, -2.21257117e-02f, 7.38386884e-02f, -4.86602858e-02f, -6.80681020e-02f, 1.11343205e-01f, 4.49697264e-02f, 4.34476137e-02f,
  1.88177992e-02f, -5.72332926e-02f, 9.53114778e-03f, -4.42688949e-02f, 6.74588308e-02f, -1.77053474e-02f, -3.91897261e-02f, -1.08842051e-03f, 8.60763863e-02f, 8.64306539e-02f,
  -4.27966565e-03f, -3.87743413e-02f, -1.08655408e-01f, -5.63163944e-02f, 3.39604802e-02f, -3.51441018e-02f, -1.77079305e-01f, -7.35148937e-02f, -3.82418931e-02f, 1.96671784e-02f,
  -7.68017173e-02f, 4.95249741e-02f, -1.01507260e-02f, -2.69178990e-02f, -7.31654763e-02f, 5.04487008e-02f, -1.55730620e-01f, -1.20598726e-01f, 5.11137880e-02f, -1.47983715e-01f,
  7.54421577e-02f, 6.09532988e-04f, 6.37493432e-02f, 6.57743169e-03f, -9.93628204e-02f, 6.32651383e-03f, -7.24478904e-03f, 6.38316646e-02f, 3.02831903e-02f, -4.80336286e-02f,
  7.50976354e-02f, 1.11255579e-01f, -3.31786722e-02f, 7.46770054e-02f, -2.29135016e-03f, 1.62494183e-02f, -2.92724818e-02f, 8.68197531e-02f, -5.38586490e-02f, -6.79248869e-02f,
  -9.02174190e-02f, -5.47944242e-03f, 3.65950428e-02f, 2.11568903e-02f, 2.93972269e-02f, 2.45818719e-02f, -4.61575240e-02f, 8.36110860e-02f, -4.80162986e-02f, 9.45837572e-02f,
  -6.16955794e-02f, -7.99156204e-02f, 8.32393486e-03f, 3.69305909e-02f, 5.39593101e-02f, 5.93542345e-02f, 5.19167108e-04f, -9.94077027e-02f, 5.83333671e-02f, -4.91853207e-02f,
  -7.81014413e-02f, 1.43763535e-02f, 5.70814274e-02f, 5.18079437e-02f, 3.62876393e-02f, -2.83448938e-02f, -6.79667518e-02f, -6.03604242e-02f, -5.03167175e-02f, 7.45008960e-02f,
  9.48460922e-02f, -3.60436812e-02f, -6.36437088e-02f, -1.51078217e-02f, -5.81819005e-02f, -4.23042178e-02f, 3.40952314e-02f, -3.32647786e-02f, 2.96804514e-02f, 3.99393067e-02f,
  9.25249606e-02f, -1.18584029e-01f, 9.18381289e-02f, 3.13449092e-02f, -4.60982025e-02f, -9.19196103e-03f, -9.77757853e-03f, 1.37861483e-02f, -3.36752012e-02f, 1.70038186e-03f,
  -1.15749456e-01f, -9.67847258e-02f, -6.10746555e-02f, 2.75247879e-02f, 5.41204773e-02f, -8.85194093e-02f, 1.64058320e-02f, -4.85716164e-02f, -2.38699000e-02f, -8.05866253e-03f,
  -6.64887652e-02f, 6.77895024e-02f, -9.30935219e-02f, -2.33702245e-03f, -8.31193328e-02f, -6.24147542e-02f, -3.25463079e-02f, 5.21138385e-02f, -7.47147650e-02f, 5.65509349e-02f,
  -8.32319260e-02f, 1.51705686e-02f, 6.53348342e-02f, -6.25446588e-02f, 7.04513118e-02f, -6.17203638e-02f, -5.71215302e-02f, -8.13276842e-02f, 2.88233161e-02f, 4.80865948e-02f,
  5.22437505e-02f, -1.04923107e-01f, -1.11430623e-01f, -1.64627805e-01f, -1.41830668e-01f, -1.60431579e-01f, -1.01620376e-01f, -8.24770927e-02f, -6.82317838e-02f, -2.29129009e-02f,
  6.60843998e-02f, 3.17432992e-02f, 1.88800916e-01f, -9.22307670e-02f, 4.61965092e-02f, 1.66881919e-01f, -9.71582308e-02f, -2.50751730e-02f, -9.79524925e-02f, -1.66961998e-01f,
  -7.05838427e-02f, 9.57399700e-03f, 2.27418332e-03f, -2.17265598e-02f, -1.29586875e-01f, -4.45147045e-03f, -2.75644343e-02f, 1.88526157e-02f, 2.07264931e-03f, -5.40706553e-02f,
  6.91523328e-02f, 2.24385150e-02f, -9.50033739e-02f, -2.42137853e-02f, -6.85027912e-02f, 5.82464524e-02f, -5.05928770e-02f, 4.70427200e-02f, 4.45471890e-02f, 3.06432396e-02f,
  2.83411182e-02f, -5.35157882e-02f, -5.56583330e-02f, 2.78554931e-02f, -6.92082718e-02f, -8.23774561e-02f, -1.41341966e-02f, -4.42822874e-02f, 3.30857038e-02f, 1.89510901e-02f,
  -4.19120230e-02f, -6.49032965e-02f, 1.10639874e-02f, 3.48562375e-02f, -4.40446734e-02f, 6.19898848e-02f, -9.19212401e-02f, 2.58278251e-02f, -1.20055854e-01f, -1.30572766e-01f,
  -9.85028520e-02f, -2.11474393e-02f, -9.79569703e-02f, 3.72496918e-02f, -5.11140004e-03f, -3.98141593e-02f, -2.78101698e-03f, 1.85873359e-02f, 3.51508558e-02f, -7.83716962e-02f,
  7.34613538e-02f, -4.12672646e-02f, 6.07082769e-02f, 3.50902788e-02f, 3.05848680e-02f, -2.27645561e-02f, -3.48096043e-02f, -8.47018603e-03f, 3.24845798e-02f, -2.44249646e-02f,
  8.80046487e-02f, 1.82820775e-03f, 4.84783873e-02f, -7.36278221e-02f, -7.08959550e-02f, 9.17498171e-02f, -5.57245389e-02f, 8.86867475e-03f, 8.13352540e-02f, 6.86332807e-02f,
  -1.26556829e-01f, -1.24813154e-01f, -1.03734201e-02f, 4.43400592e-02f, -9.41741019e-02f, -3.03298961e-02f, -3.75755765e-02f, 2.80123539e-02f, -1.93456355e-02f, -5.36834039e-02f,
  -6.38776869e-02f, -5.85103258e-02f, -7.59726465e-02f, 3.39708515e-02f, -4.05244716e-02f, -6.25853091e-02f, -1.53007009e-03f, -1.05025433e-02f, -3.98862399e-02f, 2.78693810e-02f,
  7.41425678e-02f, -3.23945880e-02f, 9.66763049e-02f, -6.46285787e-02f, 4.72202431e-03f, -7.84614831e-02f, -1.41572291e-02f, 7.77835399e-02f, -6.09790795e-02f, 3.38791870e-02f,
  2.72148699e-01f, -3.72323900e-01f, -1.93179250e-01f, 8.10019597e-02f, 6.14212900e-02f, 8.05379078e-02f, 1.75167724e-01f, -1.89423546e-01f, -2.08587758e-02f, -1.01974972e-01f,
  -5.00474013e-02f, -8.65068138e-02f, -2.28545725e-01f, 1.48573115e-01f, 2.63882101e-01f, -9.51571763e-02f, 2.90853046e-02f, 5.62211983e-02f, -8.37034211e-02f, -1.23662241e-02f,
  4.35676537e-02f, 7.95754567e-02f, -5.16023375e-02f, -3.96813080e-02f, 3.88535559e-02f, -1.36617750e-01f, 1.42318467e-02f, -4.02202234e-02f, 6.10510297e-02f, 1.13405600e-01f,
  6.30843341e-02f, -5.57760224e-02f, 2.16182284e-02f, -4.92796339e-02f, 2.44694743e-02f, 4.24504578e-02f, 8.90339836e-02f, 8.25765356e-02f, 1.06482459e-02f, -3.35955322e-02f,
  5.64378537e-02f, 4.29599062e-02f, 1.31377308e-02f, -2.84388959e-02f, 9.08001512e-03f, -4.36198823e-02f, -4.78752442e-02f, -8.94869640e-02f, -1.79836396e-02f, -1.47405058e-01f,
  -2.58972216e-02f, -7.61496946e-02f, 1.10371376e-03f, -6.91572949e-02f, 2.41253171e-02f, -5.80310114e-02f, 6.52388781e-02f, -1.00591868e-01f, -9.98528078e-02f, 6.11367561e-02f,
  -1.03898436e-01f, -5.23150787e-02f, 6.26841411e-02f, -3.86252515e-02f, -3.01228208e-03f, 6.12229928e-02f, 5.70392720e-02f, 3.76428701e-02f, -3.71015742e-02f, 3.87181528e-02f,
  -4.05356102e-02f, -5.30858859e-02f, 3.26558203e-02f, 6.31783623e-03f, -6.40362501e-02f, 5.51701300e-02f, -2.87401620e-02f, 4.48610485e-02f, -8.28417689e-02f, -5.64861633e-02f,
  9.03177187e-02f, 5.60230343e-03f, -6.11772761e-02f, 5.03146239e-02f, -1.16744067e-03f, -2.90321559e-02f, 6.01830184e-02f, -7.04646111e-02f, -6.41089166e-03f, -8.69708695e-03f,
  -5.19081578e-02f, -1.35541767e-01f, -3.59918713e-03f, -6.02417178e-02f, -5.18033933e-03f, 3.20971981e-02f, 5.99391088e-02f, 9.36082657e-03f, -4.07481119e-02f, -4.98744659e-03f,
  1.95979048e-02f, 8.49989504e-02f, -4.44058776e-02f, 1.10121176e-01f, -8.88448656e-02f, -4.60769981e-03f, -2.84746978e-02f, -4.10226313e-03f, 7.81946555e-02f, -1.14752248e-01f,
  -3.96930054e-02f, -2.83384863e-02f, 2.06262637e-02f, 5.59651963e-02f, 5.69544435e-02f, 1.94269028e-02f, -7.52966478e-02f, -5.40804304e-02f, -2.52312347e-02f, -7.31530339e-02f,
  -5.72185479e-02f, 1.57023132e-01f, 1.18644997e-01f, 2.28229254e-01f, -1.55702829e-01f, 3.04979049e-02f, 6.67903274e-02f, -1.01818562e-01f, -3.03489342e-02f, 1.88818812e-01f,
  5.78410104e-02f, 2.28868444e-02f, -1.78264286e-02f, 2.37667903e-01f, 6.65185824e-02f, 1.81911826e-01f, 2.21942663e-01f, 1.39395623e-02f, 6.93167374e-02f, -9.67081636e-04f,
  -2.68665142e-02f, 8.19906406e-03f, 5.85712604e-02f, -1.57552287e-02f, -6.29905835e-02f, 8.42185989e-02f, -3.25334445e-02f, 4.52925153e-02f, 2.85616927e-02f, 2.14352366e-03f,
  8.00787210e-02f, 7.83787370e-02f, -2.74526607e-03f, 4.82757576e-03f, 6.61607459e-02f, -7.73244798e-02f, 4.56421077e-02f, -2.32766122e-02f, 1.82141329e-03f, -3.69093791e-02f,
  -6.57098144e-02f, 3.74418870e-02f, 3.95241193e-02f, 4.89334539e-02f, 2.41901688e-02f, -2.21042037e-02f, -8.80359039e-02f, -6.60726875e-02f, -7.36100674e-02f, -8.47638026e-02f,
  5.40463403e-02f, -4.39277813e-02f, -2.80684177e-02f, -6.19415194e-03f, -2.58306619e-02f, -2.05448344e-02f, -8.40175990e-03f, 5.18166739e-03f, 5.52146360e-02f, -4.17364761e-02f,
  -6.88382238e-02f, 4.94558970e-03f, 2.40999484e-03f, -8.44898298e-02f, 7.60615915e-02f, -8.43639113e-03f, 4.11241576e-02f, 7.43915811e-02f, -3.50232944e-02f, -2.09617652e-02f,
  2.63202302e-02f, 2.80557722e-02f, 7.24888453e-03f, 5.07251732e-02f, 6.01354986e-02f, 7.51249045e-02f, -4.98264953e-02f, -9.18556824e-02f, -2.74812821e-02f, 3.61616053e-02f,
  4.76549715e-02f, 1.99432764e-02f, -2.74662059e-02f, -5.96512705e-02f, -5.57043683e-03f, 2.41630841e-02f, 6.42118752e-02f, 8.66738781e-02f, 7.94499516e-02f, -7.69057944e-02f,
  4.09106426e-02f, 1.26560658e-01f, 8.74842256e-02f, -7.67441168e-02f, -3.33681740e-02f, -3.68620791e-02f, 8.23137015e-02f, 6.25941753e-02f, 3.73079535e-03f, 7.94076100e-02f,
  -6.06861673e-02f, -1.53385364e-02f, -3.15942056e-02f, -4.91371974e-02f, -3.66546363e-02f, -1.59269627e-02f, 5.51630892e-02f, 6.09595478e-02f, 1.78502891e-02f, -8.18284228e-02f,
  -7.42179528e-02f, -2.35263444e-02f, -5.14182523e-02f, -6.75550625e-02f, -3.48154083e-02f, 1.07859015e-01f, -9.47119296e-02f, 3.83803621e-02f, 3.26871462e-02f, 3.11553422e-02f,
  -4.38166678e-01f, 1.26305893e-01f, -1.33739993e-01f, 6.71575451e-03f, -1.42964363e-01f, 2.74959952e-01f, 2.15055034e-01f, -1.44429952e-01f, 3.98333743e-02f, 3.58649939e-01f,
  2.88288862e-01f, -1.82668030e-01f, 1.91140085e-01f, 3.58576685e-01f, -9.89644900e-02f, 2.34599769e-01f, 3.48112851e-01f, 2.53640592e-01f, -3.69107872e-02f, -1.01691298e-01f,
  -1.57467261e-01f, 2.48262450e-01f, 8.04115832e-02f, -3.88966203e-02f, -8.04673806e-02f, -2.25005016e-01f, -3.28956321e-02f, -1.73408464e-01f, 7.05147684e-02f, 2.46283077e-02f,
  -1.54812083e-01f, -2.38799453e-01f, -3.02044507e-02f, -1.06826037e-01f, -3.65318619e-02f, -2.67488062e-02f, -8.68471060e-03f, -3.13239507e-02f, -3.51811876e-03f, -3.65884304e-02f,
  3.01726349e-02f, -1.27121165e-01f, 1.92800176e-03f, 1.62670165e-02f, -3.23979072e-02f, 4.89539690e-02f, -4.37264293e-02f, 5.90065420e-02f, -9.70995501e-02f, -9.19361971e-03f,
  6.23742603e-02f, -3.52577455e-02f, 3.21913101e-02f, 1.08110435e-01f, -3.66930006e-04f, 9.79597047e-02f, 1.25067942e-02f, -6.02313271e-03f, -1.29756506e-03f, -8.92493203e-02f,
  -2.90974919e-02f, -8.08816254e-02f, 2.63529141e-02f, 4.94245030e-02f, 5.65290302e-02f, -5.09186387e-02f, 2.44518351e-02f, -8.26090276e-02f, 1.78453177e-02f, 5.19375317e-02f,
  -1.76676195e-02f, 4.06753980e-02f, -9.32064131e-02f, 8.10968354e-02f, 7.39942044e-02f, 3.58022712e-02f, 1.17503256e-02f, -1.69999022e-02f, -3.23850773e-02f, -9.71201900e-03f,
  -2.75025610e-02f, -6.31263405e-02f, 5.18492460e-02f, 4.19136286e-02f, 1.02808382e-02f, 5.22145703e-02f, -2.11493969e-02f, -2.40595434e-02f, 2.26916955e-03f, -4.74257357e-02f,
  1.07990177e-02f, -1.15821801e-01f, -2.95184627e-02f, -4.21903692e-02f, 6.44844547e-02f, 4.92870025e-02f, 7.82048237e-03f, -5.42865992e-02f, 1.17997127e-02f, -3.50210741e-02f,
  -7.32547417e-02f, -9.41553339e-03f, -1.47577841e-02f, -2.21838392e-02f, 5.36324307e-02f, 1.32694572e-01f, 4.31568585e-02f, -2.62482483e-02f, 4.11926247e-02f, -1.10666536e-01f,
  -5.04190810e-02f, -5.03507964e-02f, 2.42356677e-02f, -2.31474880e-02f, 6.42848238e-02f, -4.66927001e-03f, -5.04106842e-02f, 1.11554880e-02f, -5.71514741e-02f, 7.74171799e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.10373387e-01f, 1.22896820e-01f, 7.06674010e-02f, 9.31970030e-02f, 1.00812383e-01f, 8.64190422e-03f, 7.65621811e-02f, 1.12531170e-01f, 1.20034792e-01f, 2.47488111e-01f,
  4.29693758e-02f, 5.46162017e-02f, 7.71339014e-02f, 8.15263242e-02f, 1.72139227e-01f, 3.33226025e-01f, 2.49588355e-01f, 1.00253507e-01f, 1.47929981e-01f, 6.27565160e-02f,
  1.10370032e-01f, 3.91263105e-02f, 1.18847951e-01f, 2.08049715e-01f, 2.60005176e-01f, 1.43431053e-01f, -1.06363837e-02f, 1.84895217e-01f, 7.78590590e-02f, 7.28673637e-02f,
  1.49393797e-01f, 1.92771062e-01f, 5.54279871e-02f, 1.26280725e-01f, 1.18326977e-01f, -1.12211443e-02f, 1.22277945e-01f, 1.92726836e-01f, 1.78403072e-02f, 2.15519547e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.06349960e-01f, 4.70752120e-02f, -1.31549567e-01f, 1.21839404e-01f, -3.56749706e-02f, 2.42611200e-01f, 1.82522628e-02f, 3.50311561e-03f, -4.40290719e-02f, -4.65328433e-02f,
  -1.78444073e-01f, 7.69700781e-02f, 3.13351229e-02f, -2.58020133e-01f, -1.24079384e-01f, 4.23048496e-01f, -3.03598344e-02f, 1.77022099e-01f, -3.81999314e-02f, 4.13639769e-02f,
  -8.48216414e-02f, -3.17465398e-04f, 3.69799972e-01f, -3.13749313e-01f, -1.29768938e-01f, 7.07395002e-02f, 3.88385057e-02f, 1.86813772e-01f, 1.14316233e-01f, -5.32331243e-02f,
  -1.10717878e-01f, 2.63671786e-01f, 1.72678709e-01f, 1.29024357e-01f, -1.26642391e-01f, 4.80194055e-02f, 5.72455153e-02f, 1.18800709e-02f, 1.91038512e-02f, -1.39065534e-01f,
  -1.69472665e-01f, -2.01510653e-01f, 2.28784308e-01f, 7.08643943e-02f, -2.54681043e-04f, -5.24292439e-02f, -6.84267506e-02f, 5.02513684e-02f, 3.70168865e-01f, -4.64379415e-02f,
  8.06476623e-02f, -1.53418183e-01f, 1.21490195e-01f, 1.65680364e-01f, 1.00876227e-01f, 6.85792193e-02f, -7.43041262e-02f, 9.47000831e-02f, 6.64638877e-02f, 6.92959130e-02f,
  2.98754200e-02f, 1.48884624e-01f, -2.27921337e-01f, -1.79999590e-01f, 1.16000064e-01f, -1.68006599e-01f, -2.14340314e-02f, 1.25981599e-01f, -1.75130680e-01f, -8.32762867e-02f,
  -5.16745485e-02f, -8.26999024e-02f, 9.39310864e-02f, -3.69034931e-02f, 3.56282592e-02f, -7.94585235e-03f, -5.29461317e-02f, -2.74466630e-02f, 2.34914143e-02f, -2.65291989e-01f,
  -3.42657045e-02f, -8.84261653e-02f, 9.41792130e-02f, 5.40335029e-02f, 2.40296483e-01f, -2.36383826e-01f, -2.23775700e-01f, -6.75012097e-02f, 7.99648985e-02f, 1.45452783e-01f,
  8.47637281e-02f, -3.15189436e-02f, -1.58075497e-01f, 3.73430923e-02f, -1.26637742e-01f, -1.83055207e-01f, -8.15413892e-02f, 4.93614785e-02f, -2.70976480e-02f, -1.21430039e-01f,
  9.29442793e-02f, 1.78934053e-01f, -1.03696071e-01f, -5.48274303e-03f, -9.08298641e-02f, 5.70392422e-02f, -7.60484114e-02f, 1.11697577e-01f, -1.95339043e-02f, 1.80545002e-02f,
  -1.74993157e-01f, -3.39566991e-02f, -2.98329353e-01f, 7.14025199e-02f, -1.24912828e-01f, -5.49550578e-02f, -6.76186159e-02f, -2.35034283e-02f, 3.01385149e-02f, 5.53230420e-02f,
  8.66452232e-02f, -1.52946562e-02f, 1.73623830e-01f, -3.44928205e-02f, -4.95777763e-02f, 1.43453836e-01f, 1.70145065e-01f, 4.19223048e-02f, 1.86795369e-02f, -1.69535838e-02f,
  3.95171978e-02f, -5.34906238e-02f, 2.24049464e-01f, 5.13144955e-02f, 5.75862266e-02f, 3.57410125e-02f, 4.61176857e-02f, 7.16283992e-02f, 1.44321650e-01f, 1.76212937e-01f,
  -7.11879432e-02f, -3.33548963e-01f, 4.71972711e-02f, -5.70768630e-03f, 1.07237600e-01f, 7.77741447e-02f, 3.32834452e-01f, 1.80832624e-01f, -2.99835019e-02f, -3.40223789e-01f,
  6.83087185e-02f, -3.17879051e-01f, -1.94581400e-03f, 1.66639730e-01f, 7.92730004e-02f, -1.13183737e-01f, -1.21420929e-02f, -8.89716744e-02f, 6.46910518e-02f, -1.58768088e-01f,
  -4.16039973e-02f, 3.47421430e-02f, -1.19361848e-01f, -4.24219742e-02f, 1.37335598e-01f, 2.83429679e-03f, 1.16771735e-01f, 1.67614490e-01f, 8.50113556e-02f, -1.58608198e-01f,
  -1.43179432e-01f, -2.91375481e-02f, -9.85172838e-02f, 6.62059113e-02f, -1.86307088e-01f, 7.34088570e-02f, 5.04256859e-02f, 2.13192239e-01f, 3.60176638e-02f, -5.65281175e-02f,
  7.35001042e-02f, 2.23885998e-02f, 3.33823711e-02f, -7.48481452e-02f, 1.69625327e-01f, -1.01570882e-01f, -1.29184052e-01f, -1.76230092e-02f, -1.16119757e-01f, 8.75610858e-02f,
  -1.42005503e-01f, -1.68170944e-01f, 2.42679790e-02f, -2.42653470e-02f, -5.28626628e-02f, 3.77461016e-02f, 8.86690766e-02f, -5.78874685e-02f, -1.74179345e-01f, 2.65197102e-02f,
  -3.34701315e-02f, 5.39522618e-02f, 3.39157581e-02f, -4.47823778e-02f, -2.63457209e-01f, 1.52016580e-02f, -2.28171080e-01f, 1.56285465e-01f, -2.43677095e-01f, -1.14128977e-01f,
  2.76607811e-01f, 2.50390209e-02f, -3.11105758e-01f, 2.42806613e-01f, 6.99341148e-02f, 1.12661868e-01f, -1.86213791e-01f, -1.38452157e-01f, 1.74285010e-01f, -2.86973361e-03f,
  -1.01268858e-01f, 2.29131021e-02f, -9.83145013e-02f, 2.69661043e-02f, 2.78584749e-01f, 1.62840948e-01f, 6.97228611e-02f, 1.33545369e-01f, 6.04566485e-02f, 2.24887319e-02f,
  1.77210979e-02f, -1.28883764e-01f, -7.29951411e-02f, 8.75325594e-03f, -6.19343966e-02f, 1.86181903e-01f, -1.52146414e-01f, 9.90551636e-02f, 8.32242146e-02f, 9.93885025e-02f,
  5.19759059e-02f, -1.10583119e-01f, 2.01880366e-01f, 1.57698784e-02f, 1.83524624e-01f, 1.08261973e-01f, 1.90146029e-01f, -9.13274661e-02f, -9.43197906e-02f, 1.83571056e-01f,
  -1.38915077e-01f, 8.45002383e-02f, 1.32641032e-01f, 5.40510714e-02f, 1.26717836e-01f, 2.29197726e-01f, -1.02387220e-01f, -2.16534540e-01f, -1.13844700e-01f, 5.00965752e-02f,
  1.33044785e-02f, 1.23705469e-01f, 2.92693800e-03f, -1.26480654e-01f, 4.14174125e-02f, -1.24972053e-01f, -8.81701112e-02f, -2.32729033e-01f, -1.60667256e-01f, 2.64480319e-02f,
  -7.85661042e-02f, 1.16751388e-01f, -2.25113422e-01f, -7.65002221e-02f, -1.27748623e-01f, 5.39343357e-02f, 2.53514886e-01f, -4.68524657e-02f, 2.33623073e-01f, 2.02447269e-02f,
  -1.51515692e-01f, 1.37788236e-01f, 2.80350987e-02f, 1.54177800e-01f, -6.96539730e-02f, 1.03421077e-01f, -1.57236591e-01f, 5.39904125e-02f, -1.38412327e-01f, 8.48752111e-02f,
  2.07797304e-01f, 8.47816169e-02f, -8.77582878e-02f, 2.55673558e-01f, -1.93513274e-01f, -4.89274599e-02f, -2.80195862e-01f, -3.90372537e-02f, 3.13962102e-01f, 6.65150359e-02f,
  1.37828767e-01f, 6.00618124e-02f, -7.62531310e-02f, 1.99328479e-03f, -2.46567637e-01f, -1.36158288e-01f, 2.96108052e-02f, 9.67542753e-02f, -9.36278999e-02f, 1.07996389e-01f,
  2.17710614e-01f, 1.34905398e-01f, 1.70889959e-01f, -1.03267498e-01f, -5.50467335e-02f, 1.16296165e-01f, 1.76447228e-01f, 1.72397494e-01f, 3.96958552e-02f, -1.05315834e-01f,
  -9.69184116e-02f, 1.19587518e-01f, 2.52753854e-01f, 5.15839132e-03f, 2.51488504e-03f, -9.26611125e-02f, 1.62350442e-02f, 8.92409161e-02f, 2.10084081e-01f, 2.00035796e-02f,
  1.81348696e-01f, -4.52430286e-02f, -1.53101664e-02f, 1.66735634e-01f, 1.05971068e-01f, -1.20600581e-01f, -4.38504107e-02f, -6.68983907e-02f, -1.95231795e-01f, -2.68775541e-02f,
  5.96061274e-02f, 3.35078001e-01f, -3.17342609e-01f, 1.81936830e-01f, 1.14205018e-01f, -1.42615601e-01f, 7.68304989e-02f, 9.16841552e-02f, 7.85848722e-02f, 7.55063593e-02f,
  1.37340516e-01f, -2.99212858e-02f, -4.04244661e-02f, -2.46876642e-01f, -1.42320376e-02f, -4.85135280e-02f, 7.73200020e-02f, -1.37924135e-01f, -4.32634987e-02f, 3.32873911e-02f,
  1.71109229e-01f, -2.92033944e-02f, -2.31730089e-01f, 1.43887579e-01f, 5.42034097e-02f, -1.80748269e-01f, 1.02853492e-01f, -6.83067143e-02f, -9.12053362e-02f, 8.67545456e-02f,
  -2.02996321e-02f, -3.81058082e-02f, -1.78979799e-01f, -1.23132303e-01f, -4.95943166e-02f, -1.89601943e-01f, -9.57531407e-02f, 1.46305248e-01f, 1.27130374e-01f, -2.92930230e-02f,
  9.41262860e-03f, -6.35151714e-02f, 2.18570650e-01f, 2.46874481e-01f, 5.99345118e-02f, -1.44264877e-01f, -1.33297220e-01f, 1.16241187e-01f, 1.31151691e-01f, 7.44349584e-02f,
  -1.08039181e-03f, -1.21318214e-01f, -5.82266301e-02f, 4.57714833e-02f, -4.95846979e-02f, -1.26739338e-01f, -5.85586019e-03f, -6.48929402e-02f, -1.51545564e-02f, -1.67662159e-01f,
  1.42256275e-01f, 7.22834375e-04f, -1.28119722e-01f, 2.10504100e-01f, -2.53960222e-01f, -2.26192936e-01f, -1.16396569e-01f, 8.11533332e-02f, 1.44947037e-01f, 1.39370054e-01f,
  -1.29492775e-01f, -2.04177573e-01f, 5.12953475e-02f, -1.69282611e-02f, -1.58948094e-01f, -1.22649916e-01f, -2.25444824e-01f, 2.76307374e-01f, 1.40187815e-01f, 8.56114104e-02f,
  6.61267480e-03f, 9.50250328e-02f, -1.53234273e-01f, 1.86959073e-01f, -5.91022260e-02f, -1.93836559e-02f, -7.55456910e-02f, -1.22792959e-01f, -3.73791642e-02f, -7.64792189e-02f,
  -9.64272991e-02f, -2.86937002e-02f, 7.62234777e-02f, 1.37281254e-01f, -6.09182380e-02f, -5.32302968e-02f, 1.18962809e-01f, -1.38245687e-01f, 2.22833045e-02f, 1.78632349e-01f,
  1.76746890e-01f, -5.11202514e-02f, -1.08669735e-01f, -1.33134186e-01f, 4.15992662e-02f, 8.39916915e-02f, -1.90240089e-02f, -2.79838294e-01f, -1.64637819e-01f, -1.30226249e-02f,
  7.45055303e-02f, -1.41324654e-01f, -1.11148573e-01f, 5.05033731e-02f, -2.51484573e-01f, -9.70847756e-02f, 6.76196814e-02f, -1.67413086e-01f, 1.20920464e-01f, -1.11714758e-01f,
  -2.29864091e-01f, 2.14637175e-01f, -1.81815594e-01f, 8.21227431e-02f, -1.81487828e-01f, -2.79210687e-01f, -3.48792821e-02f, 8.24725702e-02f, -3.67298901e-01f, 2.96084583e-01f,
  -1.56423915e-02f, 3.84138674e-01f, -5.79495318e-02f, -3.26188318e-02f, 4.10013348e-02f, 2.38370243e-02f, -7.81897530e-02f, -9.25580487e-02f, 4.35128659e-02f, 1.26771405e-01f,
  1.93760961e-01f, 7.64774829e-02f, 9.22161713e-02f, -7.09929392e-02f, -1.25188532e-03f, 1.71533033e-01f, -8.41806009e-02f, -1.94872767e-01f, -1.18402116e-01f, 1.77274942e-01f,
  -1.11702122e-01f, 1.98075250e-01f, -7.03613833e-02f, -8.68970230e-02f, 9.98103842e-02f, -4.88364547e-02f, 1.77920610e-01f, -1.24898907e-02f, 6.00334108e-02f, -5.52739762e-02f,
  -1.61872685e-01f, 9.78655741e-02f, -3.50181572e-02f, 1.85442921e-02f, 4.09847125e-02f, 1.12454213e-01f, 1.03764363e-01f, 3.97166498e-02f, 7.91924298e-02f, -1.04416102e-01f,
  8.77195746e-02f, 2.84653783e-01f, -8.62100497e-02f, 1.60504766e-02f, -5.52404486e-02f, 3.65434363e-02f, 1.44999595e-02f, 1.48459062e-01f, 2.55446713e-02f, 8.48552771e-03f,
  2.38327328e-02f, -4.11153995e-02f, -2.36438848e-02f, -5.30734882e-02f, 1.94657773e-01f, 2.66480505e-01f, -8.59918222e-02f, -6.24609329e-02f, 2.74903644e-02f, 3.93945649e-02f,
  -3.66706163e-01f, -3.71191949e-02f, -2.09866226e-01f, 2.11446863e-02f, -5.22235930e-02f, 2.00249985e-01f, -6.42033294e-02f, -8.26806352e-02f, -1.93708003e-01f, -1.00356266e-02f,
  7.68005773e-02f, -1.28267780e-01f, 1.86411024e-03f, 1.95412219e-01f, 1.07379809e-01f, 1.78899333e-01f, 1.28958374e-01f, 6.52917549e-02f, -8.13463256e-02f, 7.11787567e-02f,
  -2.41600908e-02f, -3.11627388e-02f, -1.68739595e-02f, 5.03237955e-02f, 5.93447301e-04f, 9.45279095e-03f, 1.46524727e-01f, -1.85081705e-01f, 4.63734046e-02f, -2.13096619e-01f,
  2.58097857e-01f, 3.71761434e-02f, -3.99650540e-03f, -1.18386403e-01f, -1.13256589e-01f, -8.02579150e-02f, -2.57468820e-01f, 1.80296618e-02f, 1.32135034e-01f, -2.22812612e-02f,
  2.24442631e-01f, 1.14833541e-01f, 1.85812898e-02f, -1.83047459e-01f, -1.12414822e-01f, -2.81136394e-01f, 4.84013259e-02f, -7.86552876e-02f, 8.81944895e-02f, -1.86263114e-01f,
  5.89209981e-02f, 1.00837871e-01f, -7.92371854e-02f, -4.30674255e-02f, -6.04719035e-02f, -2.31173559e-04f, 3.51840304e-03f, -8.60528424e-02f, -7.38459080e-02f, 9.83311534e-02f,
  1.14682680e-02f, -1.66607901e-01f, -4.52408455e-02f, -1.27063483e-01f, 6.37473986e-02f, 1.46462813e-01f, -1.05773829e-01f, -1.05008073e-01f, -1.58279702e-01f, 7.02438876e-02f,
  1.27438053e-01f, -4.73517962e-02f, -8.69017914e-02f, 6.14543296e-02f, -6.18355125e-02f, 2.95342840e-02f, -8.80210996e-02f, 3.58889624e-02f, 9.52982605e-02f, 1.64807022e-01f,
  2.47159023e-02f, -7.83101395e-02f, 1.18470460e-01f, -3.10283969e-03f, -8.04007128e-02f, -1.03574403e-01f, 6.00617863e-02f, -3.01263481e-02f, -7.88903460e-02f, -3.86755839e-02f,
  -5.37466863e-03f, 1.12156726e-01f, -3.33725885e-02f, 3.07397731e-02f, -6.77156076e-02f, -3.70092019e-02f, 9.84469056e-02f, -6.19163513e-02f, -9.71570089e-02f, 8.64768252e-02f,
  -4.46431562e-02f, 1.00196317e-01f, -2.40262481e-03f, 1.76110137e-02f, 5.16391955e-02f, 4.06028889e-03f, 4.12022211e-02f, -1.30858362e-01f, -8.86788033e-03f, 1.02716945e-01f,
  1.78434521e-01f, 1.56789735e-01f, 9.38801840e-02f, 6.57292157e-02f, 2.33399913e-01f, 1.43643888e-02f, 2.91273594e-01f, 9.45216343e-02f, -4.42430973e-02f, 1.76805139e-01f,
  3.67549658e-02f, 1.91968843e-01f, 8.86953250e-03f, -1.11727454e-01f, -7.85990879e-02f, 9.54120830e-02f, 2.58842081e-01f, 1.64604589e-01f, 1.27951011e-01f, -1.28403783e-01f,
  4.28483412e-02f, -2.01071560e-01f, 5.15808426e-02f, -3.28943878e-02f, 4.43922617e-02f, -6.04248680e-02f, 1.06139548e-01f, -1.30715460e-01f, -6.30832016e-02f, 1.08146161e-01f,
  1.36251852e-01f, 7.80056641e-02f, 1.69283316e-01f, 6.63165674e-02f, -9.67591032e-02f, -5.31057194e-02f, 7.79842287e-02f, 1.01050258e-01f, -4.62027118e-02f, -5.99269122e-02f,
  4.71199602e-02f, -1.60493806e-01f, -2.15743095e-01f, -1.90779150e-01f, -7.85138234e-02f, -7.71877319e-02f, -2.87412945e-02f, -4.24750932e-02f, 9.65704471e-02f, 1.04994491e-01f,
  7.15352371e-02f, -9.93041992e-02f, 1.11243511e-02f, 4.89219576e-02f, -1.88287050e-02f, -1.07332259e-01f, 1.04267918e-01f, -1.33386061e-01f, 1.39402773e-03f, -9.10156444e-02f,
  -1.17620103e-01f, -9.09326375e-02f, -6.00484461e-02f, -2.80572742e-01f, 1.42700642e-01f, -7.49438955e-03f, 6.87914295e-03f, -2.49460600e-02f, 1.33957816e-02f, 2.02092439e-01f,
  1.65909082e-01f, 1.04442284e-01f, 7.75470361e-02f, -1.85484681e-02f, -2.25626275e-01f, -4.04978059e-02f, -4.30194177e-02f, 1.70851916e-01f, 2.48506337e-01f, 1.58249661e-01f,
  1.54595062e-01f, 5.92303053e-02f, -1.13045245e-01f, -1.12255357e-01f, 3.61329764e-01f, -8.63128453e-02f, 6.82387352e-02f, -8.59782398e-02f, 8.23825300e-02f, 8.07898641e-02f,
  2.93684080e-02f, -5.41801974e-02f, 9.78976339e-02f, -1.06703177e-01f, 6.67946637e-02f, -4.31791972e-03f, -1.19184330e-01f, -1.71341561e-02f, 1.23931214e-01f, 3.59199494e-02f,
  -2.44114287e-02f, 1.65987998e-01f, 1.66445032e-01f, -7.86498114e-02f, -2.20200345e-01f, 1.25214368e-01f, 2.11178854e-01f, -1.71368584e-01f, 9.02723968e-02f, 2.04481538e-02f,
  -3.24154906e-02f, -3.21890451e-02f, -1.92433357e-01f, -2.38802731e-01f, -1.84819698e-01f, -2.53051948e-02f, -2.60467716e-02f, 7.39573762e-02f, 1.38627931e-01f, 1.06504902e-01f,
  -3.75725981e-03f, -1.68500558e-01f, 1.57091975e-01f, 5.77240065e-02f, 7.30144605e-02f, -1.58730224e-01f, 1.24226108e-01f, -1.83005959e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.77876647e-02f, 1.60206869e-01f, 1.75979137e-02f, 1.94515422e-01f, 1.31540135e-01f, -1.33922650e-02f, -4.94632311e-02f, -6.92815240e-03f, 1.95209272e-02f, 1.31331980e-01f,
  8.32468420e-02f, 4.82003279e-02f, -1.81166694e-01f, -1.25261113e-01f, -2.08108038e-01f, -1.20247640e-01f, 1.25709295e-01f, -1.00613147e-01f, 9.05279517e-02f, 2.18383372e-01f,
  -3.44937861e-01f, -8.70539024e-02f, 5.60558401e-02f, 3.17385457e-02f, -2.51845215e-02f, 5.48089221e-02f, 7.31924623e-02f, -8.14187601e-02f, 1.05767012e-01f, 1.47381751e-02f,
  -1.03114940e-01f, -1.01584932e-02f, -1.21262096e-01f, 2.71623939e-01f, 1.44187167e-01f, -7.50316828e-02f, -1.14289172e-01f, -1.94357224e-02f, 1.27829716e-01f, 1.93120763e-01f,
  1.74931467e-01f, 1.02112979e-01f, -2.63539888e-02f, -8.42567161e-02f, 2.68902984e-02f, -9.82519463e-02f, 6.21848106e-02f, -8.90216455e-02f, 1.66120365e-01f, 1.94485381e-01f,
  1.97996259e-01f, 7.82225356e-02f, 1.22412875e-01f, -1.90689415e-02f, -1.45910144e-01f, 7.70769268e-02f, 1.46290615e-01f, 2.01915926e-03f, -5.70032187e-03f, 5.76152615e-02f,
  -9.26452130e-02f, 3.81622687e-02f, -9.68346819e-02f, -9.34244990e-02f, 3.61651927e-02f, 1.10075563e-01f, -1.44715840e-02f, 1.04717821e-01f, 8.66813064e-02f, 3.98356393e-02f,
  2.23273203e-01f, 1.32215749e-02f, -5.81892617e-02f, -3.53255346e-02f, 3.42294984e-02f, 3.59622948e-02f, 1.31572515e-01f, -2.31662858e-02f, 1.28440917e-01f, 1.81326076e-01f,
  1.31540477e-01f, 5.52494545e-03f, 3.65946814e-02f, 8.81300643e-02f, 1.61752403e-01f, 3.50677483e-02f, 1.71766922e-01f, 4.18423973e-02f, -7.83773214e-02f, 3.56251039e-02f,
  -1.02843627e-01f, 2.86494792e-02f, -6.12799302e-02f, 3.37305069e-02f, 4.50422205e-02f, 7.49445930e-02f, -4.26497348e-02f, -9.12376493e-02f, -4.82672006e-02f, -1.37847243e-03f,
  1.11791201e-01f, -8.29641297e-02f, -6.46648630e-02f, 5.53545989e-02f, -9.18260217e-02f, -8.64906013e-02f, -3.16757746e-02f, -1.17927164e-01f, 5.91579080e-02f, -7.89121836e-02f,
  7.91094899e-02f, -1.13643706e-02f, -6.80818111e-02f, -9.50512663e-02f, 4.80892770e-02f, 1.15835942e-01f, 1.08246371e-01f, 9.51677561e-02f, -1.17017692e-02f, 7.23252073e-02f,
  -2.62762439e-02f, 6.77415803e-02f, 1.25635922e-01f, -5.90730123e-02f, 4.57694940e-02f, 4.69121188e-02f, 9.10490751e-02f, -4.02128249e-02f, 2.60419160e-01f, 1.80124119e-01f,
  2.11971492e-01f, 9.60557684e-02f, 4.13185284e-02f, 1.60005707e-02f, 1.44842997e-01f, 2.13692367e-01f, 6.87751696e-02f, 2.47106403e-01f, 4.52428311e-02f, 1.88481942e-01f,
  2.34799255e-02f, -1.26551732e-01f, 7.50248209e-02f, 2.89058596e-01f, 1.48324475e-01f, 2.11688280e-01f, 1.64082572e-01f, 3.43613774e-02f, 6.64352998e-02f, -1.84385851e-01f,
  9.10887495e-02f, -8.91311690e-02f, 9.93715003e-02f, 1.38835967e-01f, 1.13627791e-01f, 2.31076181e-02f, 7.85732120e-02f, 9.40329060e-02f, 5.66069223e-02f, 4.01430763e-03f,
  1.77366957e-01f, -1.59065455e-01f, -1.14300527e-01f, -7.33463932e-03f, 4.92972136e-02f, -3.55725102e-02f, 8.78710300e-02f, -8.30531958e-03f, 8.29826072e-02f, -1.03656247e-01f,
  1.03169531e-01f, -1.99124426e-01f, 1.19925730e-01f, -8.47380161e-02f, -2.78779808e-02f, 1.64549693e-01f, 1.90242574e-01f, 7.12212548e-02f, 3.42092961e-02f, -1.14138991e-01f,
  7.59002641e-02f, 1.09348245e-01f, 2.10988224e-01f, -1.33684471e-01f, -1.47533327e-01f, -5.99505529e-02f, -2.60640718e-02f, -6.37053102e-02f, 7.73054035e-03f, -4.11627069e-02f,
  5.84613606e-02f, -8.82746354e-02f, -4.66589145e-02f, -4.40956000e-03f, 1.73483178e-01f, -4.10413593e-02f, 3.74421179e-02f, -1.65557861e-02f, -1.80070195e-02f, -2.53837798e-02f,
  1.71040982e-01f, -1.76302984e-03f, 7.56013319e-02f, -4.80964370e-02f, -3.57897989e-02f, -8.10411870e-02f, -2.68394165e-02f, -2.98476182e-02f, -7.04467203e-03f, 4.57305647e-02f,
  1.78996220e-01f, -9.90495831e-02f, 1.57605574e-01f, 1.38762310e-01f, 4.59092855e-03f, 4.82959934e-02f, -2.18014382e-02f, 7.73804337e-02f, 3.54392081e-02f, 3.46925780e-02f,
  -1.03591934e-01f, -8.01192299e-02f, -1.68881956e-02f, -2.55310629e-02f, 3.42832804e-02f, 8.22846964e-02f, -2.02246383e-02f, -1.67395696e-02f, 1.11074924e-01f, 1.17247598e-02f,
  -5.64951636e-02f, -3.03079449e-02f, -4.88664508e-02f, -1.55510092e-02f, 1.57031521e-01f, -7.36107826e-02f, -7.01330742e-03f, 9.84412730e-02f, 5.57711571e-02f, 7.76140112e-03f,
  -1.09718805e-02f, 5.87338097e-02f, 5.73283844e-02f, 1.85623080e-01f, -6.61253883e-03f, 6.09654188e-02f, 1.91061050e-01f, 2.96387691e-02f, -1.07483760e-01f, -6.12399206e-02f,
  1.24127254e-01f, -8.32514912e-02f, 1.40055791e-01f, 7.37759024e-02f, 2.73285452e-02f, 7.06673935e-02f, 1.15024969e-01f, 2.49389306e-01f, 1.99742258e-01f, 1.03230327e-01f,
  1.34397089e-01f, 7.10612684e-02f, 5.32764941e-02f, -2.21696645e-02f, 2.64859647e-01f, -4.48212773e-02f, 1.32224947e-01f, 2.92303208e-02f, -1.11242570e-01f, -4.02618060e-03f,
  1.47455901e-01f, 3.37596536e-01f, -9.42995772e-02f, 7.00944141e-02f, -5.76389320e-02f, -1.77594945e-01f, 1.15515880e-01f, 2.86803007e-01f, -7.93557167e-02f, 1.84369907e-02f,
  -2.10816544e-02f, -1.65639490e-01f, 1.88373148e-01f, 1.18108436e-01f, 7.35954866e-02f, -5.97597547e-02f, 1.15672685e-01f, 1.10035837e-01f, 2.80385733e-01f, -2.78359856e-02f,
  -1.02489814e-02f, 4.09530886e-02f, 7.29801357e-02f, -1.06106415e-01f, 1.30601883e-01f, -3.11475694e-01f, -6.07067868e-02f, 2.25977115e-02f, -1.23010911e-01f, 1.79595836e-02f,
  -4.83645871e-02f, 4.45425697e-02f, 2.14702025e-01f, -9.56366211e-03f, 3.14553767e-01f, -1.37895674e-01f, 3.93536612e-02f, -1.97263975e-02f, -8.81010741e-02f, -2.84219481e-04f,
  1.47814080e-01f, -8.61337036e-02f, -3.22881714e-02f, 2.15025231e-01f, -3.68964556e-03f, 1.85344834e-02f, 7.55207706e-03f, -1.91019595e-01f, 8.06263685e-02f, 2.06472561e-01f,
  1.09956913e-01f, 1.96524113e-02f, 1.99611604e-01f, 2.01020941e-01f, 1.56260300e-02f, 7.09311888e-02f, 3.77170630e-02f, 2.28562847e-01f, 3.51289613e-03f, 1.88038960e-01f,
  1.54908523e-01f, 2.52806902e-01f, 2.70612717e-01f, 2.22378761e-01f, 2.18798190e-01f, -6.55294657e-02f, 2.51377046e-01f, 2.04026267e-01f, -3.40595126e-01f, -2.59685129e-01f,
  2.29049265e-01f, 1.27772912e-02f, 9.10075381e-03f, -6.82071820e-02f, 2.26976693e-01f, -1.22890241e-01f, 1.42945731e-02f, 5.77447005e-02f, 2.66719609e-01f, -1.38335330e-02f,
  -8.55067000e-02f, 1.95342988e-01f, 2.03985691e-01f, -1.45321280e-01f, -1.35255128e-01f, -5.54380827e-02f, 1.07471801e-01f, -1.23492805e-02f, 2.36312807e-01f, -1.70469552e-01f,
  -1.12499788e-01f, -1.91613920e-02f, 1.75727293e-01f, 9.00932401e-02f, 1.77258283e-01f, 1.23163708e-01f, 1.51531085e-01f, -5.96713014e-02f, 1.99492171e-01f, -6.09204918e-02f,
  2.20662430e-02f, -9.38319415e-03f, -1.33571699e-01f, 1.38268501e-01f, -1.09511927e-01f, 1.59010023e-01f, -1.09104000e-01f, 1.44756427e-02f, -1.23113990e-02f, -2.51452643e-02f,
  9.83414650e-02f, 7.16980174e-02f, -1.84532657e-01f, -1.18962981e-01f, -3.91005389e-02f, 1.67242482e-01f, -7.72710219e-02f, 1.33267298e-01f, -9.29305479e-02f, 2.13534106e-02f,
  1.07013017e-01f, 1.17902964e-01f, 1.41525537e-01f, 6.30573183e-02f, -1.11715822e-02f, 2.57105500e-01f, 5.36313280e-03f, 7.41148815e-02f, -5.37706539e-02f, -9.07074884e-02f,
  2.33272538e-01f, 2.38499388e-01f, -1.77606102e-02f, -5.15259476e-03f, -1.00407057e-01f, -1.07707651e-02f, -8.19897801e-02f, 5.14181219e-02f, 1.88981488e-01f, -3.44043933e-02f,
  -1.22645028e-01f, -6.46750117e-03f, 1.01428807e-01f, -8.28998256e-03f, -9.32907779e-03f, 1.05420366e-01f, 1.91560045e-01f, 8.76093507e-02f, -1.46286905e-01f, -4.99598943e-02f,
  1.20200939e-01f, -1.39789924e-01f, 1.62593499e-01f, -4.92517687e-02f, -8.29195976e-02f, -1.60311311e-01f, -6.85781986e-02f, 7.39901289e-02f, 1.49521783e-01f, -5.55177778e-02f,
  -4.98508550e-02f, -1.66535333e-01f, 1.31542251e-01f, 3.17139514e-02f, -7.66857341e-02f, -8.02496597e-02f, -1.01536907e-01f, 8.13375860e-02f, -1.59957737e-01f, 2.74413824e-02f,
  9.12230760e-02f, 1.99835058e-02f, 6.21945523e-02f, 1.46563932e-01f, 8.83452967e-02f, -1.04419224e-01f, -3.54083329e-02f, -1.30083233e-01f, 1.59513086e-01f, 4.59444970e-02f,
  1.68487027e-01f, -4.38077860e-02f, 2.32372414e-02f, 1.21891998e-01f, -1.63679153e-01f, 5.03127724e-02f, -1.44441091e-02f, 1.45305712e-02f, 7.53426626e-02f, -2.05930788e-02f,
  2.35396013e-01f, 4.19779234e-02f, -1.01169705e-01f, 2.45519087e-01f, 1.27452370e-02f, 4.90817875e-02f, -8.29826593e-02f, -6.84954002e-02f, 8.64062533e-02f, 1.03720434e-01f,
  -8.69711787e-02f, -2.07392976e-01f, -9.35054943e-02f, -3.12433038e-02f, -4.62813042e-02f, 3.22005361e-01f, 1.63225412e-01f, -1.13623450e-02f, -4.10576761e-02f, 3.36929202e-01f,
  1.47964895e-01f, -1.16365943e-02f, 9.09415260e-02f, -3.09558660e-02f, -5.66469766e-02f, -1.11212870e-02f, 1.33010168e-02f, 7.69969076e-02f, 1.25265077e-01f, 7.18993619e-02f,
  3.42833251e-01f, 2.72064626e-01f, 1.48969963e-01f, -1.12094477e-01f, 6.85874224e-02f, 1.27738461e-01f, 2.51631886e-01f, -1.99943781e-03f, -6.78825676e-02f, 1.11896820e-01f,
  -1.29697710e-01f, 1.37002274e-01f, -1.45218909e-01f, -9.29408893e-02f, -1.23687007e-01f, 1.56913429e-01f, 2.26327404e-01f, 2.22801447e-01f, 2.81732172e-01f, -9.14094299e-02f,
  -7.11281151e-02f, -1.93161368e-01f, 9.02471766e-02f, 2.54514396e-01f, 1.70118883e-01f, 1.91523597e-01f, 1.07425511e-01f, 2.17152879e-01f, 2.43668884e-01f, 1.23802058e-01f,
  5.12461588e-02f, -1.81817710e-02f, -6.73296154e-02f, 2.02013358e-01f, -9.59868282e-02f, 4.33569588e-02f, 2.67703012e-02f, 2.86195129e-01f, -2.29832139e-02f, -2.18059793e-02f,
  5.36393337e-02f, 6.33503720e-02f, -2.50505865e-01f, 7.13686049e-02f, 3.77250850e-01f, 1.91897050e-01f, -1.43979490e-01f, -2.00464293e-01f, 1.55179039e-01f, 1.09956779e-01f,
  1.73126653e-01f, 2.22707000e-02f, 3.80563475e-02f, 1.49976745e-01f, 9.19722766e-02f, -5.94701851e-03f, 5.47063239e-02f, 2.12849110e-01f, -4.54360396e-02f, -7.21187443e-02f,
  8.14054906e-02f, -1.29452825e-01f, 7.58124813e-02f, 9.58302543e-02f, -5.01222014e-02f, 1.51585981e-01f, -7.81631321e-02f, 4.66441959e-02f, 9.29333642e-02f, 1.40265033e-01f,
  4.14336950e-01f, -2.51372963e-01f, 9.76181105e-02f, 1.04936168e-01f, 2.47376278e-01f, 3.35146002e-02f, -3.12079992e-02f, 1.28748104e-01f, -9.00185034e-02f, -4.60439697e-02f,
  -1.55968577e-01f, -4.44581807e-02f, 7.11269397e-03f, 5.97079471e-02f, -3.96143645e-03f, 2.91365653e-01f, -8.16223472e-02f, 1.69996262e-01f, -6.02139917e-04f, 4.97405715e-02f,
  1.17739230e-01f, 1.14072122e-01f, 4.52800980e-03f, -1.59308012e-03f, -5.01492880e-02f, 4.59199734e-02f, 1.52881116e-01f, 8.29329640e-02f, -3.20131212e-01f, 1.46770552e-02f,
  -3.14687341e-01f, -8.86369124e-02f, -1.20755695e-01f, -1.66970104e-01f, 9.35109630e-02f, 1.81042045e-01f, -3.31909359e-01f, -1.65737569e-01f, 1.36662081e-01f, 1.98338613e-01f,
  -1.70050234e-01f, -5.69501035e-02f, -1.22340182e-02f, -1.70919541e-02f, -2.98239086e-02f, 6.32269904e-02f, -1.68869600e-01f, 9.67285559e-02f, 1.35599911e-01f, 3.79218280e-01f,
  -1.72806066e-02f, 1.46207528e-03f, 4.56323773e-02f, 2.02988505e-01f, 4.28989753e-02f, 3.33442017e-02f, -4.31567878e-02f, 1.74815906e-03f, -1.39104396e-01f, 1.48422224e-02f,
  -1.20144434e-01f, -2.72751767e-02f, -5.28566614e-02f, -5.03642075e-02f, 2.31382892e-01f, 1.31596789e-01f, 1.29644377e-02f, 2.14859508e-02f, 2.32348382e-01f, -5.75081445e-02f,
  1.34381026e-01f, 1.12579025e-01f, 3.02064180e-01f, 1.17510132e-01f, -8.86185169e-02f, -8.24194700e-02f, 9.55034345e-02f, 1.73553988e-01f, -2.08660774e-02f, 2.83231378e-01f,
  1.48335904e-01f, 2.31225751e-02f, -3.66237722e-02f, 1.86497629e-01f, 2.74509005e-02f, 1.28488056e-02f, 4.78514247e-02f, 5.12192864e-03f, -8.43004137e-03f, 5.14770262e-02f,
  5.41254207e-02f, -1.27525162e-02f, 5.53556010e-02f, 1.60623133e-01f, -1.95292845e-01f, -3.50275896e-02f, -9.47927833e-02f, -3.80453430e-02f, -7.25522041e-02f, -6.44874871e-02f,
  -1.31410822e-01f, 1.32511361e-02f, 1.79481447e-01f, 1.14732727e-01f, -1.64896753e-02f, 7.19152391e-02f, -7.89481029e-02f, -4.25749496e-02f, 1.41331062e-01f, -5.92974722e-02f,
  7.80922472e-02f, 1.54183552e-01f, -1.31871238e-01f, 1.07034206e-01f, 1.02973476e-01f, 1.09024651e-01f, 1.04920417e-01f, -2.24358737e-02f, 3.50324400e-02f, -7.28521198e-02f,
  8.71291980e-02f, -9.49903652e-02f, 1.16983928e-01f, -5.07236943e-02f, 2.37910282e-02f, -8.49934593e-02f, -1.95295662e-02f, -1.23730063e-01f, 2.52179354e-01f, -7.91616738e-02f,
  1.05031766e-01f, -1.31660849e-01f, 1.34918123e-01f, -1.07523635e-01f, -1.47418529e-01f, 2.12006524e-01f, 1.72191355e-02f, 1.10282507e-02f, 4.77206558e-02f, -1.09336473e-01f,
  -2.76104156e-02f, -5.45265265e-02f, -5.41603379e-02f, -1.23132780e-01f, 6.96906224e-02f, 1.31229192e-01f, 2.49333486e-01f, 1.33583412e-01f, 7.88923725e-02f, 1.38780296e-01f,
  7.48162270e-02f, 1.04024775e-01f, 2.46865973e-01f, 1.33551165e-01f, 1.53074488e-01f, 1.83992490e-01f, 1.11258745e-01f, -2.59126812e-01f, 9.09584165e-02f, 2.62645304e-01f,
  -1.93879213e-02f, -1.22505724e-01f, 1.85478985e-01f, -1.54523134e-01f, 1.04074985e-01f, 1.60670400e-01f, -8.49476177e-03f, 6.18413948e-02f, -1.20267093e-01f, -4.95379381e-02f,
  1.24853112e-01f, 6.98574185e-02f, 2.17909412e-03f, -7.54346326e-02f, 1.47572160e-01f, -7.57560730e-02f, 2.73221225e-01f, -6.71300367e-02f, -1.15294248e-01f, 5.76631315e-02f,
  1.45619720e-01f, -1.31247684e-01f, -2.13220343e-02f, 1.90200016e-01f, 2.77217567e-01f, 8.45205188e-02f, -7.24082664e-02f, -5.61821833e-02f, -8.62226635e-03f, 7.42780790e-02f,
  1.67003497e-01f, 2.32792407e-01f, 9.24984142e-02f, 1.40999839e-01f, -5.84158897e-02f, 1.80479512e-01f, 8.21303502e-02f, 9.36781541e-02f, -8.34860429e-02f, -1.99960753e-01f,
  -2.32096016e-01f, 9.95119959e-02f, 5.91809228e-02f, 3.64149436e-02f, -1.10060118e-01f, 1.86304320e-02f, -6.08948916e-02f, -2.38268953e-02f, 8.75254720e-02f, 1.67113632e-01f,
  2.03892738e-01f, 2.22686231e-01f, 2.12033734e-01f, -4.09224816e-02f, 2.67171115e-01f, 2.18468741e-01f, -6.47684708e-02f, 3.82589400e-02f, 1.14364838e-02f, 1.26808390e-01f,
  1.98996160e-02f, -1.81934074e-01f, -5.62300459e-02f, -1.47350848e-01f, -9.63003635e-02f, -2.31864259e-01f, 1.94397554e-01f, 5.52050956e-02f, -9.54284370e-02f, 1.15960747e-01f,
  -5.94264129e-03f, 1.43218776e-02f, 4.98403013e-02f, 1.39323756e-01f, -6.90345839e-02f, -1.10519037e-01f, -9.03450102e-02f, 4.19426821e-02f, 1.78884029e-01f, -2.42339298e-01f,
  -2.71130323e-01f, 7.45962262e-02f, -5.89093119e-02f, 1.33544011e-02f, -6.19787723e-02f, -6.55459687e-02f, -1.15674742e-01f, 4.50696468e-01f, 1.93883851e-01f, 9.08159912e-02f,
  1.62015274e-01f, 1.04024410e-01f, -2.53899526e-02f, 2.26714108e-02f, -7.48124719e-02f, 1.27643213e-01f, -2.50195771e-01f, -6.94799498e-02f, 8.83604512e-02f, 8.55943188e-02f,
  1.52991429e-01f, -8.84159207e-02f, 1.03260405e-01f, 1.46264881e-01f, 1.23240538e-01f, -1.43606231e-01f, 1.87640674e-02f, -1.43515125e-01f, 2.77611651e-02f, 2.69304723e-01f,
  9.02855098e-02f, 2.46483356e-01f, 5.56246303e-02f, 5.62506765e-02f, 2.21682023e-02f, -7.00354874e-02f, 5.74226789e-02f, -4.95551042e-02f, 7.41559789e-02f, -4.80772778e-02f,
  -5.90029359e-03f, 5.62586673e-02f, 1.25671372e-01f, 6.92567527e-02f, 1.11587588e-02f, 2.78409738e-02f, -9.95724127e-02f, -6.64213821e-02f, -1.09773844e-01f, 3.10384892e-02f,
  5.56508787e-02f, 1.24720000e-02f, -1.41517371e-02f, -1.18774347e-01f, -1.43596381e-01f, 1.13642335e-01f, 1.03963606e-01f, 2.68528573e-02f, -1.12141177e-01f, -1.68565218e-03f,
  3.70884351e-02f, -1.09097205e-01f, 3.43698002e-02f, 2.86038164e-02f, 2.46385094e-02f, 1.96586922e-01f, -6.28355592e-02f, -6.54852986e-02f, 8.95877630e-02f, 7.24687427e-02f,
  1.13666147e-01f, 1.42770603e-01f, 1.54354364e-01f, 1.20552108e-01f, 1.07369376e-02f, -3.85230519e-02f, -1.77982766e-02f, -8.95349085e-02f, -1.22451618e-01f, -9.42406654e-02f,
  -8.79186988e-02f, 1.72579587e-01f, 7.73579255e-02f, 7.01584592e-02f, 3.81647721e-02f, -1.06216088e-01f, -1.29447147e-01f, 1.22053936e-01f, 4.03354540e-02f, 3.40623930e-02f,
  8.42142701e-02f, -9.68432799e-02f, -5.60362637e-02f, 1.15745716e-01f, -3.47071816e-03f, -6.68641701e-02f, 1.37724234e-02f, -8.05472136e-02f, 1.02260061e-01f, 2.19509304e-01f,
  9.76927858e-03f, -5.28610982e-02f, 1.55403763e-01f, 1.48615554e-01f, -1.24367356e-01f, -6.60104603e-02f, 9.85107347e-02f, 2.18279168e-01f, 2.51086742e-01f, -4.23274994e-01f,
  -2.50280887e-01f, 1.25498608e-01f, 3.72060910e-02f, 3.52201402e-01f, 2.78292537e-01f, 2.64532924e-01f, 6.41747788e-02f, -3.90839189e-01f, 6.15359377e-03f, -3.23000699e-01f,
  2.21662328e-01f, 2.73682475e-01f, -1.72833964e-01f, -1.27764776e-01f, -1.98081478e-01f, -1.52485855e-02f, -2.06497788e-01f, -1.69373006e-01f, -1.86682522e-01f, 1.14782862e-01f,
  1.04868377e-03f, 9.51542556e-02f, 1.46493420e-01f, -3.03095840e-02f, -1.59392327e-01f, 3.21945935e-01f, 1.12662435e-01f, -2.17732284e-02f, 9.23919678e-02f, -8.00391361e-02f,
  2.68273223e-02f, 1.28025383e-01f, 1.01995058e-01f, 9.01965946e-02f, -1.19835906e-01f, 2.57191122e-01f, -1.51670098e-01f, -1.52572855e-01f, -7.41776600e-02f, 8.31098258e-02f,
  1.70953870e-01f, -5.69411181e-03f, 2.72600532e-01f, 2.20227465e-02f, -1.54013485e-01f, 1.20291635e-01f, 4.52748016e-02f, 3.69609386e-01f, -5.18912002e-02f, -3.59298997e-02f,
  -8.19303989e-02f, 2.53898561e-01f, 2.52006948e-01f, 1.06485978e-01f, 3.45535316e-02f, 1.00818373e-01f, -2.06930697e-01f, 1.33477710e-02f, 1.36689931e-01f, 4.54789996e-02f,
  2.27027223e-01f, 1.07502460e-01f, -2.12527081e-01f, -2.07697581e-02f, 8.35609287e-02f, 1.21136531e-02f, -3.29344928e-01f, -2.25646585e-01f, 4.97901328e-02f, -1.52598694e-01f,
  -1.20945685e-01f, 3.82888883e-01f, 4.90671694e-02f, 6.46829009e-02f, -8.55016243e-03f, -1.60164088e-01f, 2.24753782e-01f, 1.03636339e-01f, -1.00494549e-01f, -8.91395882e-02f,
  4.75824103e-02f, 2.65311182e-01f, 2.38270372e-01f, 6.61939085e-02f, 1.90448966e-02f, -7.72261024e-02f, 1.35652244e-01f, -7.21801771e-03f, -7.91705493e-03f, -3.92329656e-02f,
  9.24128219e-02f, 9.31576341e-02f, 1.18214116e-01f, 5.45136295e-02f, -4.44277339e-02f, 1.87481254e-01f, -9.67382148e-05f, 1.55664563e-01f, 9.39127877e-02f, -8.79962742e-02f,
  2.28197232e-01f, 1.83548033e-01f, -1.88092217e-02f, -6.16323017e-02f, 1.29867315e-01f, 4.52215336e-02f, 2.93754209e-02f, 1.17177695e-01f, -3.28850895e-02f, 1.50014907e-01f,
  1.74642518e-01f, 2.78699342e-02f, 5.27915470e-02f, 4.45256054e-01f, 1.68250538e-02f, 3.33968475e-02f, 1.59104034e-01f, -6.82588145e-02f, 2.37828982e-03f, -7.08493143e-02f,
  -6.31208858e-03f, -8.37627128e-02f, -6.96686208e-02f, 1.31550029e-01f, -6.39756024e-02f, 8.34226459e-02f, -1.27603173e-01f, 8.93143266e-02f, 8.52695554e-02f, 1.70477808e-01f,
  1.99629199e-02f, -6.04913682e-02f, 5.96071370e-02f, 2.44316049e-02f, 3.55845988e-02f, 9.48433802e-02f, 3.24824564e-02f, 1.40656009e-02f, -1.39785632e-01f, -7.56225064e-02f,
  2.71402439e-03f, -5.58006018e-02f, -9.89144072e-02f, 5.76264895e-02f, -1.18690081e-01f, 8.56909081e-02f, 1.27006978e-01f, 4.91867401e-03f, 8.01632628e-02f, -6.54170290e-02f,
  1.43383563e-01f, 1.11247554e-01f, 1.24264471e-01f, -6.96407855e-02f, -2.62139235e-02f, 5.05067073e-02f, 1.26868617e-02f, -1.07738405e-01f, -4.16579470e-02f, -6.23867661e-03f,
  4.78028990e-02f, 1.63875818e-01f, -3.65315676e-02f, -1.88131705e-02f, -9.12752897e-02f, -4.37960848e-02f, -7.40678236e-02f, 8.97305608e-02f, 1.73332095e-01f, -1.00455254e-01f,
  -5.64069226e-02f, 2.09896988e-03f, -7.13775605e-02f, -1.12665400e-01f, -8.61492380e-02f, 4.36968654e-02f, 5.73962666e-02f, -1.49441492e-02f, 3.72837670e-02f, -4.96410474e-04f,
  1.49568068e-02f, 4.70166691e-02f, 1.99240655e-01f, 1.02960639e-01f, 1.99810907e-01f, 2.12617982e-02f, 1.42910302e-01f, -6.46938756e-02f, 1.52249625e-02f, 2.23097160e-01f,
  -1.91890262e-02f, -1.68330565e-01f, 8.87533948e-02f, -3.24690454e-02f, 1.87842324e-01f, 1.27737179e-01f, 2.14514300e-01f, -1.22770958e-01f, 1.78116828e-01f, -1.57819241e-01f,
  -2.05248863e-01f, 8.96477029e-02f, 9.88377482e-02f, 2.38071452e-03f, 4.05713134e-02f, -1.08217701e-01f, -5.67924138e-03f, -5.13298362e-02f, 6.02802187e-02f, -7.88732525e-03f,
  -4.63121831e-02f, 7.78942928e-02f, -7.88401067e-02f, 1.02878347e-01f, -1.48258731e-02f, -1.23425297e-01f, -1.27337247e-01f, 3.52227718e-01f, 2.45329469e-01f, -1.33189196e-02f,
  4.04720977e-02f, -1.57277048e-01f, 1.61114503e-02f, 1.77569673e-04f, -4.71116416e-02f, 6.68086810e-03f, -1.61367357e-01f, 1.17818061e-02f, -3.60826193e-03f, -4.20633517e-02f,
  -4.72126119e-02f, 9.58557054e-02f, 2.29840055e-02f, -7.77732730e-02f, -3.96351293e-02f, -1.40553549e-01f, -5.80904745e-02f, -3.81128713e-02f, -5.05216755e-02f, 1.38612419e-01f,
  -5.10738641e-02f, -1.04787573e-01f, 8.63543302e-02f, -6.52863383e-02f, -5.98290153e-02f, -6.70197010e-02f, 8.88850763e-02f, 3.92015092e-02f, -1.34289220e-01f, -1.95709672e-02f,
  8.52990150e-02f, -2.92814206e-02f, -5.60825728e-02f, 4.92611788e-02f, -6.95418119e-02f, 1.48729682e-02f, -1.74934387e-01f, -7.70168826e-02f, -7.38313124e-02f, 1.25944689e-01f,
  -9.50711146e-02f, -1.11897007e-01f, -3.85960676e-02f, -5.42416945e-02f, -3.80667369e-03f, -1.13580219e-01f, 1.48258880e-01f, 1.34181455e-01f, -8.61737579e-02f, 1.28109276e-01f,
  -1.42716393e-02f, 5.21152578e-02f, -6.59971312e-02f, 4.34208438e-02f, 2.37375647e-02f, 1.38469070e-01f, 1.05662577e-01f, 1.60700567e-02f, 7.68532827e-02f, 8.87066722e-02f,
  -9.35687404e-03f, -1.69166382e-02f, -7.95146078e-02f, 3.50452773e-02f, 8.50785822e-02f, 5.37672713e-02f, 6.40828311e-02f, 1.01055965e-01f, -2.73409905e-03f, -7.33349025e-02f,
  1.22066431e-01f, 8.82394910e-02f, -1.11947730e-01f, -8.04313049e-02f, 9.92107913e-02f, -1.66482814e-02f, 1.76362917e-02f, 2.99653243e-02f, 1.14828661e-01f, 6.17196374e-02f,
  1.13594150e-02f, -7.87073970e-02f, 7.35844532e-03f, 7.67324865e-02f, 9.43054408e-02f, -1.23520248e-01f, -3.02075292e-03f, 1.37335718e-01f, 1.56231880e-01f, 1.28650248e-01f,
  5.25209010e-02f, 6.45673349e-02f, -3.27129029e-02f, 1.19163752e-01f, -6.49531409e-02f, 1.23496354e-01f, 6.95176795e-02f, 7.07139000e-02f, -1.34112835e-01f, -2.28749499e-01f,
  -3.14841062e-01f, -2.33338237e-01f, -1.53753623e-01f, -1.16261661e-01f, 2.39832714e-01f, 2.14744270e-01f, -3.79691660e-01f, -1.61530167e-01f, -5.05205197e-03f, 7.53259473e-03f,
  -1.05063081e-01f, 1.54899508e-01f, -2.43642349e-02f, -1.04411930e-01f, 3.49099040e-02f, -7.57495165e-02f, 7.58096948e-02f, 1.05747744e-01f, 6.23960085e-02f, 2.61842251e-01f,
  5.55376075e-02f, 1.33502120e-02f, -2.42613978e-03f, -1.51645273e-01f, -5.23148105e-02f, 1.83941036e-01f, 3.35818641e-02f, -1.38669387e-01f, -8.26269481e-03f, -7.41703585e-02f,
  1.20877405e-03f, 3.34331580e-02f, 1.03077568e-01f, 5.65279610e-02f, 7.77061982e-03f, 2.04121947e-01f, 5.59510291e-02f, -7.66424909e-02f, 1.28777206e-01f, 5.39632440e-02f,
  -8.22729319e-02f, 4.83960062e-02f, 2.00881079e-01f, 5.79952151e-02f, -1.12645149e-01f, -9.61681381e-02f, -3.27476859e-02f, 2.46083289e-01f, -7.61667490e-02f, 1.45717025e-01f,
  1.56225935e-01f, 1.64451241e-01f, 1.52133882e-01f, 5.04986346e-02f, 3.88035690e-03f, -1.91357788e-02f, 1.68569773e-01f, 2.27261767e-01f, 1.11638471e-01f, 1.30772904e-01f,
  1.94792092e-01f, 5.33120930e-02f, 1.38550058e-01f, 2.22618282e-01f, 1.05068997e-01f, -3.74707840e-02f, 1.36944428e-01f, -1.51799861e-02f, -2.14166984e-01f, -3.95270661e-02f,
  -1.42589077e-01f, -6.84081614e-02f, -2.77004778e-01f, 2.01095268e-01f, 2.63727665e-01f, -1.08286910e-01f, -8.19645971e-02f, -6.30978942e-02f, 1.21925883e-01f, -1.13030180e-01f,
  7.24187568e-02f, 4.82150763e-02f, 2.80809224e-01f, -9.86061022e-02f, 8.28357711e-02f, 7.68416151e-02f, -5.49008697e-02f, -9.35783163e-02f, 4.70830351e-02f, -1.03195302e-01f,
  -2.78394707e-02f, 8.77633318e-02f, -2.64115840e-01f, -3.75012197e-02f, 1.74148977e-01f, -1.64890364e-01f, -5.33981621e-02f, -1.85474604e-01f, 2.65609026e-01f, -5.09218760e-02f,
  -5.87033629e-02f, -1.75276548e-02f, -1.32351086e-01f, 1.20760888e-01f, -2.07405016e-01f, -1.02786705e-01f, -5.10904342e-02f, 1.96286947e-01f, 1.05626203e-01f, 2.97886115e-02f,
  3.84549908e-02f, -1.43960208e-01f, -3.58037837e-02f, 1.04333330e-02f, 1.72797769e-01f, -3.70175438e-03f, -5.68099059e-02f, 4.48455364e-02f, -3.42856050e-02f, -2.07568202e-02f,
  1.34064615e-01f, -3.59733440e-02f, 2.58583091e-02f, 3.74404378e-02f, 6.54184371e-02f, 1.53570965e-01f, 7.29584545e-02f, 5.97963706e-02f, -1.26622438e-01f, 4.06121649e-02f,
  -8.06600749e-02f, 1.27349302e-01f, 3.36578861e-02f, -5.27007766e-02f, -9.94910076e-02f, -1.58100590e-01f, -1.11313909e-01f, 1.67148814e-01f, -5.39206974e-02f, -8.21107347e-03f,
  -1.10115381e-02f, -1.11901134e-01f, -3.50822508e-02f, -2.00533029e-02f, -1.28027141e-01f, 6.48763217e-03f, 9.45964605e-02f, 2.54353464e-01f, 1.14621960e-01f, -6.93346262e-02f,
  1.84849232e-05f, 1.30197689e-01f, 1.15330771e-01f, 6.02359809e-02f, 6.25866055e-02f, 2.91413181e-02f, -7.90517405e-02f, -4.42142077e-02f, -9.31038037e-02f, -9.05332416e-02f,
  1.08782701e-01f, -7.82274455e-02f, 8.66362378e-02f, -4.90393564e-02f, -1.47870146e-02f, -1.16755858e-01f, -1.20415073e-02f, 4.02553417e-02f, -1.31094590e-01f, 9.43776816e-02f,
  -3.59101705e-02f, -1.10598445e-01f, -6.90334216e-02f, 2.61709839e-02f, -1.31051883e-01f, 7.83352777e-02f, -7.34978095e-02f, -1.11030512e-01f, 9.44840312e-02f, -8.77304077e-02f,
  4.64435555e-02f, -7.68156871e-02f, -3.44330221e-02f, 1.53464660e-01f, 4.68784571e-02f, 5.45597225e-02f, 1.14626199e-01f, -5.71983084e-02f, 6.23407178e-02f, 1.60038434e-02f,
  1.36552691e-01f, -3.23731229e-02f, -4.95020002e-02f, -3.89638469e-02f, -1.22064970e-01f, 1.89434625e-02f, -1.42452046e-01f, -1.08684950e-01f, 4.10499163e-02f, 1.06718428e-01f,
  -5.45780808e-02f, 1.83826700e-01f, -1.41152255e-02f, -6.81549013e-02f, -7.20044971e-03f, -7.32553154e-02f, 9.05145332e-02f, -8.05915669e-02f, 3.73523869e-02f, 3.81212942e-02f,
  1.22010924e-01f, 3.73118781e-02f, 6.17419928e-02f, -1.20687582e-01f, 5.59815355e-02f, 1.95686042e-01f, -1.11130513e-01f, -2.46512610e-02f, -1.02508359e-01f, 1.87574521e-01f,
  3.12611908e-02f, -7.69801736e-02f, 1.36096478e-01f, -8.50690678e-02f, -3.75594608e-02f, -9.73114222e-02f, 4.65651229e-02f, 1.12238787e-02f, -9.87675712e-02f, 6.78123459e-02f,
  -1.67280510e-01f, 2.15575416e-02f, 1.20704703e-01f, -9.29640979e-02f, 9.63208750e-02f, -8.20293427e-02f, 1.97910085e-01f, 7.03076348e-02f, -1.12707810e-02f, -7.38749327e-03f,
  3.60757336e-02f, 6.60200492e-02f, -2.81300452e-02f, 2.32484601e-02f, 7.97974020e-02f, -1.10944368e-01f, 1.01692580e-01f, 3.76207381e-02f, -6.59515858e-02f, -1.07505389e-01f,
  1.34780511e-01f, 4.45893668e-02f, 2.43297033e-02f, -6.99082166e-02f, 1.77473333e-02f, -2.47644354e-02f, 1.04822451e-02f, 6.66347072e-02f, 6.68319464e-02f, 5.51317558e-02f,
  1.44811690e-01f, -7.53850937e-02f, -6.03430457e-02f, -2.48602144e-02f, 3.50008858e-03f, 8.54758173e-02f, 1.22023490e-03f, -5.88909090e-02f, -4.80319038e-02f, -1.18224546e-01f,
  -1.22152574e-01f, -3.00338101e-02f, -1.98180862e-02f, -9.46932882e-02f, 3.59936319e-02f, -5.46867512e-02f, -8.17947537e-02f, 3.76992747e-02f, 1.23759605e-01f, -7.27861151e-02f,
  -6.19576611e-02f, 2.32601408e-02f, 1.03347585e-01f, 3.12956935e-03f, 3.26939523e-02f, -1.15078121e-01f, 1.35746533e-02f, 1.11967593e-01f, -1.21910656e-04f, 4.82372679e-02f,
  1.05934516e-01f, 8.33125934e-02f, -1.19966231e-01f, -2.29910668e-02f, -6.13302700e-02f, -2.14627758e-02f, 6.40398264e-02f, 7.54152564e-03f, -1.05868384e-01f, -7.23611563e-02f,
  5.98682649e-03f, 1.19949788e-01f, 7.16794208e-02f, -6.84317648e-02f, 1.33425947e-02f, 1.07771240e-01f, 2.29595646e-01f, 2.55056649e-01f, 2.03823850e-01f, 2.27847412e-01f,
  2.04588532e-01f, 1.53252751e-01f, 1.86306953e-01f, 3.38241570e-02f, 1.35196388e-01f, 8.07044376e-03f, 2.46685147e-02f, 1.28536552e-01f, 8.24800134e-02f, 6.67124763e-02f,
  3.55822369e-02f, 1.69400543e-01f, -2.49916827e-03f, 4.84572761e-02f, 1.26398891e-01f, -1.65700927e-01f, 3.06259483e-01f, 1.55217618e-01f, 1.50256455e-01f, 4.46352549e-03f,
  4.59082574e-02f, -4.23400812e-02f, 1.91351265e-01f, 3.18299979e-03f, 1.30730122e-01f, 7.34853372e-02f, 1.27735808e-01f, -3.68952863e-02f, 7.75840208e-02f, -1.05424389e-01f,
  -7.33954608e-02f, 4.89684492e-02f, 7.67500177e-02f, -2.71363910e-02f, 5.72037138e-02f, -3.23356427e-02f, -5.05854711e-02f, 1.16567045e-01f, -5.28673343e-02f, -1.57258093e-01f,
  -4.96214181e-02f, 1.28196940e-01f, 5.04908748e-02f, 2.11184904e-01f, -2.44882986e-01f, -2.29454711e-01f, -9.12416652e-02f, 2.29144558e-01f, -1.35075688e-01f, 4.20789560e-03f,
  2.13302761e-01f, 4.42767851e-02f, -6.90079778e-02f, 8.89843777e-02f, 1.45643547e-01f, -1.59753695e-01f, -1.20532729e-01f, -7.83831254e-02f, 3.99540663e-02f, 1.99352950e-01f,
  2.35464517e-02f, 3.56875733e-02f, 1.92804247e-01f, 1.66822106e-01f, 1.20940283e-01f, 2.08122618e-02f, -7.66958343e-03f, 3.58944200e-02f, -1.44807389e-02f, 1.78631902e-01f,
  6.52204594e-03f, -4.79496904e-02f, -1.39814317e-01f, -4.23563123e-02f, 1.70786396e-01f, 1.05135277e-01f, -1.52244627e-01f, -1.46978796e-01f, -1.81553187e-03f, -1.25976905e-01f,
  1.77915484e-01f, 4.90256511e-02f, 2.44239405e-01f, -4.10531424e-02f, -4.84492369e-02f, 3.69539931e-02f, 1.83179125e-01f, 1.08926184e-01f, 1.13420226e-01f, 2.79130731e-02f,
  -6.93758652e-02f, -1.61146745e-02f, -9.39488318e-03f, -8.01828578e-02f, -1.28789544e-01f, 1.37124106e-01f, 8.85611027e-02f, -3.65984477e-02f, 1.28903091e-01f, 4.45205495e-02f,
  -7.03567564e-02f, 6.89409226e-02f, 2.12046742e-01f, 1.31840274e-01f, 8.63381699e-02f, 1.67110741e-01f, 1.24289490e-01f, 2.12285221e-01f, -1.07413583e-01f, -1.22133300e-01f,
  5.62991435e-03f, 3.97153944e-02f, 8.26723278e-02f, 7.48173371e-02f, 3.10523391e-01f, 1.23168774e-01f, -1.76807299e-01f, -4.20577265e-02f, -7.18064010e-02f, 1.18381873e-01f,
  2.19274595e-01f, 1.07789198e-02f, 9.04759318e-02f, 1.53201655e-01f, 2.09875375e-01f, -2.35401187e-02f, 1.38505936e-01f, 5.60001284e-02f, 3.14715430e-02f, 5.13918251e-02f,
  1.48517311e-01f, 1.83946967e-01f, 8.79145190e-02f, -9.55077335e-02f, 3.70003246e-02f, 1.08431078e-01f, -1.32388532e-01f, 1.43969376e-02f, -8.51118416e-02f, -1.05717257e-01f,
  -8.09896886e-02f, -8.97844359e-02f, -2.77069490e-02f, -5.91942631e-02f, -1.24234833e-01f, 8.83818716e-02f, -1.86411202e-01f, 2.41535857e-01f, -1.00369342e-01f, 4.72492836e-02f,
  2.81278305e-02f, -1.26079679e-01f, -1.05372556e-01f, -6.84302077e-02f, 1.82517752e-01f, -6.98476285e-02f, -1.25821412e-01f, 6.21245429e-03f, 3.81397568e-02f, -1.24766372e-01f,
  -7.79029727e-02f, 1.40834644e-01f, 6.53487071e-03f, 8.86765271e-02f, 1.43034101e-01f, 6.88541532e-02f, -7.45190233e-02f, 4.13988791e-02f, -1.30834118e-01f, 1.32198129e-02f,
  9.20000598e-02f, 2.42274348e-02f, -6.32407665e-02f, 7.51923723e-03f, -3.56754325e-02f, 9.53314975e-02f, -6.49398938e-02f, -5.87427616e-02f, -1.48431435e-01f, -6.46369457e-02f,
  -6.65897802e-02f, 5.30323088e-02f, 1.02734186e-01f, -1.55379429e-01f, 1.23696011e-02f, 7.92939588e-03f, 4.80270311e-02f, 1.62636757e-01f, -6.27722740e-02f, -5.48268408e-02f,
  1.55745521e-01f, -1.11146487e-01f, 8.26949999e-02f, -1.13500677e-01f, 9.58590768e-03f, -3.74979153e-02f, 1.09108323e-02f, -4.16499786e-02f, -2.19124816e-02f, 1.03128836e-01f,
  8.05686787e-02f, -5.10037914e-02f, 6.09660856e-02f, -1.11959606e-01f, 1.13248147e-01f, 1.69438213e-01f, 1.64079860e-01f, -2.87771355e-02f, -3.53493877e-02f, -3.68131250e-02f,
  1.06425751e-02f, 5.46273217e-02f, 1.45044774e-01f, -1.43571999e-02f, 1.78767219e-02f, 3.77190597e-02f, -1.18726511e-02f, -1.07738428e-01f, -3.10026668e-02f, 1.04057111e-01f,
  1.15658097e-01f, -1.82287786e-02f, 1.00753196e-01f, -8.56734887e-02f, 2.61859559e-02f, -1.14827737e-01f, -3.07714920e-02f, 3.45238410e-02f, 5.37674949e-02f, -1.26836851e-01f,
  -4.34457511e-02f, -3.31116803e-02f, -3.75419334e-02f, 1.11037262e-01f, 2.43935362e-02f, -1.31602411e-03f, -9.25854445e-02f, 1.19566947e-01f, 9.86063778e-02f, -3.46331038e-02f,
  -5.82425743e-02f, 8.28782246e-02f, -9.60589498e-02f, -1.14051327e-01f, 5.01890779e-02f, 6.19081929e-02f, -5.08011766e-02f, 2.58348305e-02f, -8.85066856e-03f, 1.58735424e-01f,
  -1.16899259e-01f, -1.27698546e-02f, 5.02115898e-02f, -6.15870692e-02f, 1.87347174e-01f, 1.39975697e-01f, 2.16109693e-01f, 1.78184465e-01f, 1.45754963e-01f, 1.25184923e-01f,
  -1.05466535e-02f, 1.28976911e-01f, -1.93997826e-02f, -2.82092090e-03f, -2.19332561e-01f, 2.44674504e-01f, -2.04272732e-01f, -1.33520022e-01f, -5.67614026e-02f, -5.68093881e-02f,
  9.51778516e-02f, -2.15166006e-02f, -1.93628833e-01f, -7.87842199e-02f, -1.11115221e-02f, 2.21813604e-01f, 2.58498080e-02f, 1.12354860e-01f, 1.77476313e-02f, -8.70929882e-02f,
  7.62404576e-02f, 3.92301194e-02f, -7.61315897e-02f, -4.95820791e-02f, -9.20809284e-02f, 2.51941890e-01f, 1.00622237e-01f, 1.45560876e-01f, -7.03045130e-02f, 3.15176994e-01f,
  1.27088293e-01f, -1.10978551e-01f, 8.35407302e-02f, 2.16307938e-01f, 6.37565553e-02f, -2.37322319e-02f, -5.11317048e-03f, -1.08320840e-01f, -1.10249385e-01f, -5.46169356e-02f,
  -9.52521339e-02f, -9.52381939e-02f, -9.05828401e-02f, -6.60397932e-02f, 2.13416684e-02f, -7.04594776e-02f, 6.76483139e-02f, 2.41424575e-01f, 1.04173504e-01f, 5.09737805e-02f,
  6.80740178e-02f, -2.53428277e-02f, 5.36498390e-02f, -1.39815211e-01f, 1.64189622e-01f, 2.46531352e-01f, 2.92652808e-02f, 2.18880609e-01f, 7.81185180e-02f, 2.04092592e-01f,
  1.93003714e-01f, 1.80011898e-01f, 2.04206094e-01f, 2.14587241e-01f, 1.69348121e-02f, 1.49788320e-01f, 6.80753496e-03f, 9.87339541e-02f, 9.32560675e-03f, 1.22555532e-01f,
  2.41390094e-02f, -1.75955340e-01f, 1.85090572e-01f, -1.96050286e-01f, -1.55911401e-01f, -8.81627426e-02f, 9.39713195e-02f, 9.45262834e-02f, -2.69648135e-01f, 3.03930134e-01f,
  9.62817147e-02f, -9.92849991e-02f, -8.78792331e-02f, -1.83004946e-01f, 1.45823538e-01f, 1.19377017e-01f, 1.22628294e-01f, -1.68861866e-01f, -3.93201485e-02f, 6.16936274e-02f,
  -1.73974942e-04f, -4.13445868e-02f, -1.33427590e-01f, 2.74967700e-02f, -3.42724845e-02f, 1.03000768e-01f, 4.96339872e-02f, 8.43268558e-02f, -1.13727689e-01f, -1.73510537e-02f,
  9.50717553e-02f, -1.54516876e-01f, -1.01335019e-01f, -1.11915931e-01f, -2.44973470e-02f, -6.99898079e-02f, 6.41090646e-02f, 1.40465558e-01f, -5.34009524e-02f, -3.00006699e-02f,
  -1.00716919e-01f, 9.73558873e-02f, -2.54304949e-02f, 7.35523775e-02f, -2.12067533e-02f, 1.36265494e-02f, -1.58261716e-01f, -4.63290438e-02f, 1.68807313e-01f, 4.89089489e-02f,
  7.16754720e-02f, -3.15893106e-02f, 1.16185285e-01f, -6.31023431e-03f, 8.15023035e-02f, 5.88903278e-02f, 1.52296901e-01f, 8.39921087e-02f, 7.69739598e-02f, -2.11517904e-02f,
  1.49886668e-01f, 2.00963616e-01f, 1.13221727e-01f, -1.03874065e-01f, 1.33501738e-01f, 3.97443287e-02f, 2.29734182e-02f, 4.97778989e-02f, -1.63022980e-01f, -1.29361972e-01f,
  5.23395464e-02f, 7.95292854e-02f, -7.19526708e-02f, 3.26826498e-02f, 1.12322196e-01f, -2.51248535e-02f, -7.16474876e-02f, -6.23812489e-02f, 1.59770966e-01f, 7.14817345e-02f,
  1.65241778e-01f, -1.86277684e-02f, 6.06688820e-02f, -8.20354838e-03f, -1.88307595e-02f, -1.27392694e-01f, -2.64377277e-02f, 6.98920935e-02f, -5.95825799e-02f, -7.47355595e-02f,
  3.54208350e-02f, -8.12724382e-02f, -1.61778390e-01f, -8.92638862e-02f, -2.82505080e-02f, -6.49144799e-02f, -8.62949900e-03f, -1.21302351e-01f, 1.76594242e-01f, 6.19594194e-02f,
  8.62803757e-02f, -7.41274208e-02f, 7.64977559e-02f, 1.08129479e-01f, -1.46476805e-01f, -9.54921469e-02f, -3.58467847e-02f, 6.92945421e-02f, -8.93484876e-02f, 9.39579606e-02f,
  1.32691450e-02f, -1.19926915e-01f, -8.89895335e-02f, 3.52024063e-02f, 1.57712534e-01f, 1.16540231e-01f, 9.45292264e-02f, -3.83135527e-02f, 8.80743936e-02f, 4.82515581e-02f,
  2.96881348e-02f, -5.48451580e-02f, -2.97089294e-02f, 8.71997699e-02f, -5.83634861e-02f, 6.08162284e-02f, 6.85218424e-02f, -1.57584876e-01f, 1.93570182e-01f, -9.91917029e-03f,
  5.84274307e-02f, -7.47976005e-02f, 1.27196321e-02f, -6.02802597e-02f, 1.55210167e-01f, 1.11935981e-01f, 1.66409895e-01f, 1.32302092e-02f, -6.91647455e-02f, 1.50156304e-01f,
  -5.01367524e-02f, -1.12486504e-01f, -1.14913978e-01f, 8.86547491e-02f, 3.87045555e-02f, -8.39828998e-02f, -7.29612857e-02f, 1.26277089e-01f, 1.09249808e-01f, 1.62356868e-01f,
  6.16728812e-02f, -8.68485048e-02f, -7.58510008e-02f, 2.06663311e-01f, -1.26707986e-01f, -9.51061919e-02f, 6.99565783e-02f, -7.63783976e-02f, 5.10139726e-02f, -2.90032150e-03f,
  -3.72618996e-02f, -5.89616317e-03f, -8.04924518e-02f, -1.08797051e-01f, -3.15768234e-02f, 1.76320016e-01f, -1.00549117e-01f, -9.84109342e-02f, 1.23706661e-01f, 8.39385465e-02f,
  2.76198909e-02f, -4.37674858e-02f, -3.74295376e-02f, -1.35995477e-01f, -4.90231328e-02f, 1.72350913e-01f, 1.25051569e-02f, 1.21747563e-02f, 1.62892610e-01f, -5.32396324e-02f,
  7.90348426e-02f, 1.20732181e-01f, 1.31802663e-01f, -1.07010100e-02f, 1.41168416e-01f, 1.35299996e-01f, 1.87227249e-01f, -1.42088339e-01f, -2.79686339e-02f, -3.85692976e-02f,
  1.05250433e-01f, 1.70387998e-01f, -2.37150908e-01f, -4.61619236e-02f, -1.02128707e-01f, 9.85864028e-02f, 5.17394580e-02f, -2.68447269e-02f, -1.67106807e-01f, -1.80696413e-01f,
  -6.64353222e-02f, 2.33003080e-01f, 1.21086366e-01f, 1.73399836e-01f, 3.24547403e-02f, 3.84429097e-02f, 7.20945895e-02f, -1.06747031e-01f, 3.76900844e-02f, -9.36476663e-02f,
  -2.24920511e-02f, 1.13764890e-01f, 1.47229582e-01f, 4.52054366e-02f, 9.21946838e-02f, 3.60593230e-01f, 2.09375620e-02f, -1.87435672e-01f, -1.20157145e-01f, 1.32041678e-01f,
  -3.03159691e-02f, 8.75387862e-02f, 2.94022895e-02f, 1.85888857e-02f, 5.25706448e-02f, -1.04010321e-01f, 1.19336424e-02f, 8.03393349e-02f, -9.42846537e-02f, -1.16877228e-01f,
  9.91951376e-02f, 5.45886271e-02f, -9.07762870e-02f, 1.40745714e-01f, 2.48599738e-01f, -5.99059016e-02f, 1.50137141e-01f, -8.70012492e-02f, -1.06554531e-01f, -9.31943059e-02f,
  1.56255037e-01f, -2.03067791e-02f, -3.50758620e-02f, -7.43583441e-02f, 2.78004371e-02f, -1.04479238e-01f, 6.59426823e-02f, 6.34930879e-02f, -8.44499022e-02f, 5.31011224e-02f,
  9.17627737e-02f, 5.46881296e-02f, 7.49394968e-02f, -6.99950308e-02f, -1.47631705e-01f, 3.26808915e-02f, -3.70964482e-02f, -7.89769292e-02f, 7.31322095e-02f, -1.16779901e-01f,
  -7.95917679e-03f, 1.42581746e-01f, -1.48069218e-01f, 1.57103881e-01f, -5.50877564e-02f, 1.72733590e-01f, 6.59442320e-02f, 1.78093612e-02f, -4.53751869e-02f, -9.47243124e-02f,
  5.24149872e-02f, 1.20684719e-02f, 5.97509630e-02f, 9.05702114e-02f, 7.22785816e-02f, -1.31995410e-01f, 9.11743864e-02f, 4.56129238e-02f, -7.22951964e-02f, 1.00180045e-01f,
  1.78488567e-02f, 1.71266228e-01f, 1.66729659e-01f, 1.39925152e-01f, -1.65686328e-02f, -9.15865898e-02f, -1.00540675e-01f, 8.20117593e-02f, 1.09597526e-01f, -8.71362090e-02f,
  6.69336766e-02f, -4.57269624e-02f, 1.46008968e-01f, 9.33669284e-02f, -5.83705865e-02f, 6.82526901e-02f, 1.20863013e-01f, -2.81411689e-02f, 8.14196095e-02f, -7.81534091e-02f,
  -1.97768100e-02f, -3.30653638e-02f, 1.08025536e-01f, 8.35399106e-02f, 1.65483639e-01f, 7.82006606e-03f, 1.83249302e-02f, -1.35657238e-02f, 1.14533171e-01f, 1.24875963e-01f,
  1.11410059e-01f, 4.61708531e-02f, -1.15190893e-02f, 2.65177190e-02f, -1.29435882e-02f, 1.63038805e-01f, 9.34219956e-02f, 1.26857623e-01f, -1.84389036e-02f, -2.34287959e-02f,
  1.64549291e-01f, 2.14007720e-01f, -1.86934825e-02f, -1.91871934e-02f, -2.21787989e-02f, 5.69236204e-02f, 1.39250100e-01f, 7.58872032e-02f, 1.39577249e-02f, -1.25468627e-01f,
  1.26031131e-01f, -5.60383610e-02f, 1.01260424e-01f, 6.69827685e-02f, 1.34947672e-01f, -3.93908732e-02f, 4.77375165e-02f, 1.90443434e-02f, 1.30002707e-01f, -4.90042977e-02f,
  -1.04158849e-01f, 1.52957916e-01f, 1.37685195e-01f, -1.20086111e-01f, 1.02469772e-01f, -3.62633504e-02f, 1.29498662e-02f, 4.41211946e-02f, -5.19421324e-03f, 1.74907088e-01f,
  -6.22145552e-03f, -8.13418999e-02f, 1.77494839e-01f, 4.83482778e-02f, 1.67259157e-01f, -1.37917654e-04f, -1.13910004e-01f, -1.46696448e-01f, 8.45638514e-02f, 6.67394772e-02f,
  1.23461977e-01f, -8.28873292e-02f, -1.41633391e-01f, 1.16491906e-01f, 3.66446041e-02f, -8.57193023e-02f, 1.25546128e-01f, -6.80953115e-02f, -1.07053600e-01f, 1.74528733e-01f,
  1.24815196e-01f, -5.65573536e-02f, -5.22530731e-03f, -9.12809465e-03f, 1.34935796e-01f, -1.12900088e-04f, -4.34708875e-03f, -1.90030504e-02f, 1.59492120e-01f, -1.37496188e-01f,
  -3.50289010e-02f, 2.89020054e-02f, 1.29152566e-01f, -3.55974946e-04f, -8.40367526e-02f, 8.07027072e-02f, 7.55859837e-02f, 9.58465636e-02f, 1.00326799e-01f, -1.33772707e-02f,
  5.69653027e-02f, 4.30488102e-02f, -2.61556301e-02f, 7.92744309e-02f, 3.54075022e-02f, 1.53589666e-01f, -8.87170285e-02f, 1.59749035e-02f, -8.20819363e-02f, -1.09138489e-01f,
  4.34805453e-02f, -1.62253082e-01f, 6.02546073e-02f, 1.65158913e-01f, -1.77825578e-02f, -3.35030332e-02f, -3.08022387e-02f, 1.61260664e-01f, -9.63545814e-02f, -7.88731799e-02f,
  1.11381330e-01f, 9.72895548e-02f, 2.43156943e-02f, -5.54642975e-02f, -8.00731871e-03f, 7.49559850e-02f, 7.39855617e-02f, -3.86549011e-02f, -1.55230850e-01f, -4.36400957e-02f,
  6.43371865e-02f, 9.19503719e-02f, 3.15626934e-02f, 1.18608763e-02f, -4.89080064e-02f, -1.03234746e-01f, 1.22288309e-01f, -1.27107829e-01f, -4.58575226e-02f, 9.81244817e-02f,
  -1.17234401e-01f, 9.35592800e-02f, 1.31847247e-01f, -4.32279296e-02f, -7.13756457e-02f, 1.27743304e-01f, 5.81178963e-02f, -5.19903675e-02f, -5.82678765e-02f, 7.21084997e-02f,
  9.58704576e-03f, 1.57960743e-01f, -5.82098067e-02f, 1.91246755e-02f, 8.11547041e-02f, -3.54289375e-02f, 8.98878053e-02f, 1.02735274e-02f, 6.71648979e-02f, -1.02862865e-01f,
  -1.06770575e-01f, -1.63329452e-01f, -1.21238537e-01f, -5.68468217e-03f, -2.68912390e-02f, 2.06591040e-01f, -7.89795145e-02f, 1.29545853e-01f, 3.13572139e-02f, -6.61378875e-02f,
  3.05738649e-03f, 2.24172659e-02f, -2.23672856e-02f, -2.36958414e-02f, 1.01200387e-01f, -6.07718639e-02f, 4.44812141e-02f, -1.54520161e-02f, 6.92201480e-02f, 7.71363825e-02f,
  9.21771526e-02f, 4.54937145e-02f, -1.20034896e-01f, 8.62418488e-02f, 1.51882857e-01f, 5.01596276e-03f, 1.17512278e-01f, 8.33311677e-02f, -5.30886538e-02f, -1.25775695e-01f,
  1.09845504e-01f, -5.27996980e-02f, 1.55945599e-01f, -5.87155893e-02f, -4.88076620e-02f, 6.25992194e-02f, -1.46055564e-01f, 2.88425898e-03f, -1.58394307e-01f, -2.95206765e-03f,
  7.29375109e-02f, -5.58324382e-02f, -3.11133191e-02f, -9.96989831e-02f, 1.44859403e-01f, 6.21503703e-02f, 3.25792804e-02f, 1.97228476e-01f, 8.90282616e-02f, 9.85908136e-02f,
  -7.40532950e-02f, 1.25028163e-01f, 1.31834179e-01f, 2.99287923e-02f, -1.22748334e-02f, 1.27880443e-02f, 9.97034460e-02f, 3.79089788e-02f, 8.16165209e-02f, -2.14265753e-02f,
  3.83956656e-02f, -4.57446389e-02f, 1.42186880e-02f, 1.66689232e-01f, 6.84823841e-02f, 3.27875535e-03f, -1.96626112e-01f, 5.71890548e-03f, -1.61073953e-01f, 1.34377509e-01f,
  4.50798981e-02f, 1.95662335e-01f, 1.00398131e-01f, -8.94100890e-02f, -1.25763744e-01f, -1.94237288e-02f, -3.71381976e-02f, 1.17400959e-01f, -8.76516327e-02f, 7.16049820e-02f,
  2.85991073e-01f, 8.93349573e-02f, -1.27764136e-01f, 3.50694209e-02f, 1.07841389e-02f, 7.20014274e-02f, 1.13007113e-01f, -1.30969375e-01f, -1.23426594e-01f, -1.12536557e-01f,
  -1.35047793e-01f, 3.13875414e-02f, 1.31999131e-03f, -8.84741396e-02f, 5.70866913e-02f, -1.74863696e-01f, 1.18049257e-01f, -5.28789908e-02f, -1.48210347e-01f, -1.34828776e-01f,
  -9.39247981e-02f, -1.31577794e-02f, -3.07808127e-02f, -5.81334606e-02f, 6.51461026e-03f, 1.68395191e-01f, -7.19837798e-03f, 1.28304511e-01f, 1.93259809e-02f, -4.58720289e-02f,
  4.12734337e-02f, -6.07483573e-02f, -4.70875278e-02f, 4.94957156e-02f, 7.61952251e-02f, 8.25417712e-02f, -5.22816591e-02f, 1.54835135e-01f, 4.03606743e-02f, 1.82596445e-02f,
  1.74088433e-01f, -2.06784829e-02f, -3.18323425e-03f, 1.75312720e-02f, 1.74497411e-01f, -4.75919321e-02f, -6.57556430e-02f, 8.09096321e-02f, 7.55642951e-02f, 8.44606608e-02f,
  1.04199700e-01f, -1.39610246e-02f, 2.94510812e-01f, -1.83419127e-03f, 1.03308447e-01f, -2.07921743e-01f, -1.03340089e-01f, -6.53870851e-02f, 1.93296876e-02f, 7.48193115e-02f,
  5.46135101e-03f, 5.73645607e-02f, -5.29913930e-03f, 1.34142265e-01f, -2.39006523e-02f, -1.17256045e-01f, -6.94286451e-02f, 4.23504896e-02f, 4.38371114e-02f, 2.78775916e-02f,
  -9.17176604e-02f, 2.62662768e-01f, 9.88790840e-02f, -2.81543434e-02f, 2.37518191e-01f, 1.71340555e-01f, -3.98640297e-02f, 5.86287118e-03f, -4.31499220e-02f, 1.86540246e-01f,
  4.21078093e-02f, 5.29009011e-03f, 6.40722224e-03f, 8.57387390e-03f, -6.05286881e-02f, 1.02531835e-01f, 1.28322408e-01f, -1.19043961e-01f, -1.17627226e-01f, -7.56070688e-02f,
  7.29901195e-02f, -1.38256932e-02f, 2.48248484e-02f, 4.59601060e-02f, 1.35249123e-02f, -1.35516729e-02f, 1.38020888e-01f, -8.95680860e-02f, -1.99807771e-02f, 6.88887611e-02f,
  4.76192087e-02f, -8.06291252e-02f, -1.49995424e-02f, 4.29517357e-03f, 2.92622205e-03f, 5.13106212e-02f, 1.00821391e-01f, -2.77201552e-02f, 7.77321085e-02f, -1.15844540e-01f,
  -7.59202093e-02f, -2.42648292e-02f, -1.06387965e-01f, 3.33653130e-02f, 1.35678083e-01f, 9.11366493e-02f, 1.94982335e-01f, 5.16310483e-02f, -1.41704574e-01f, 7.93552622e-02f,
  1.00311060e-02f, 4.22192961e-02f, 3.23112821e-03f, 1.46030530e-01f, 1.73104554e-02f, -3.72169279e-02f, -1.05534218e-01f, 2.10979860e-03f, 2.97954977e-02f, 8.27142689e-03f,
  4.86841463e-02f, -4.44990955e-03f, -3.49347703e-02f, -1.16502270e-01f, 3.34474666e-04f, 8.58183280e-02f, 1.75878316e-01f, -8.37961733e-02f, 8.10756087e-02f, -6.51796386e-02f,
  -6.34909719e-02f, 4.22120914e-02f, -1.35580478e-02f, -6.31460967e-03f, -4.09739763e-02f, 1.45118669e-01f, -5.83570115e-02f, 1.70878768e-01f, -3.92187424e-02f, -1.01581834e-01f,
  -1.86601635e-02f, -1.47093430e-01f, -1.26849696e-01f, -9.00861174e-02f, 1.28560197e-02f, 2.41923109e-02f, 6.46884218e-02f, 1.12577854e-02f, -3.50199118e-02f, 2.65938994e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  3.90015505e-02f, -3.94167639e-02f, 6.60893545e-02f, 1.12743065e-01f, 1.03701346e-01f, 2.75699794e-01f, 1.39585555e-01f, 1.20816976e-01f, 1.96935162e-01f, 2.24480569e-01f,
  7.75782242e-02f, 2.19795361e-01f, 2.10775390e-01f, 1.38475418e-01f, 2.32947424e-01f, 1.94967046e-01f, 2.01116186e-02f, 1.40801474e-01f, 1.45442963e-01f, 3.14638577e-03f,
  1.85031936e-01f, -4.54011522e-02f, 7.59103000e-02f, -7.40688592e-02f, 1.81869552e-01f, 7.49540776e-02f, 1.04773697e-02f, -3.79382633e-02f, 3.85987386e-02f, 1.88649222e-01f,
  1.21854264e-02f, 1.09386966e-01f, 5.64444102e-02f, 1.44936154e-02f, 2.95664221e-02f, 5.57412505e-02f, 1.66527256e-01f, 1.40671030e-01f, 3.36387232e-02f, 2.02564299e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.10024422e-01f, 1.17476270e-01f, 3.55268903e-02f, -5.08785903e-01f, 5.96921891e-03f, -4.09219146e-01f, -3.16349298e-01f, -4.61260378e-01f, -1.41076729e-01f, -3.99028435e-02f,
  -1.30269423e-01f, -1.88027292e-01f, -4.24998134e-01f, -1.44175615e-03f, -3.05987090e-01f, 2.48703972e-01f, 7.88240731e-02f, 3.39200020e-01f, -3.06809545e-01f, 4.22681153e-01f,
  -3.75384748e-01f, 7.04437271e-02f, -4.69151407e-01f, -1.29892915e-01f, -2.82982528e-01f, -1.37139082e-01f, -2.21807167e-01f, 2.25755759e-02f, 2.59012312e-01f, -2.23987088e-01f,
  -1.78770810e-01f, -2.75400162e-01f, 3.40333015e-01f, 7.98271373e-02f, -1.32290035e-01f, -5.47566973e-02f, 1.42861679e-01f, -2.31448382e-01f, -1.79092735e-01f, 4.94644672e-01f,
  4.91450951e-02f, -1.94746628e-01f, -2.21947923e-01f, -5.73184155e-02f, 4.21992764e-02f, -1.17969655e-01f, 8.65587145e-02f, 1.12233400e-01f, 1.66609690e-01f, 3.45022619e-01f,
  1.84601039e-01f, 2.00040173e-02f, 1.92107528e-01f, 2.07335968e-02f, -1.62070453e-01f, 8.65818001e-03f, -1.71516445e-02f, 1.28033891e-01f, 1.67960882e-01f, 3.84536833e-02f,
  1.23545639e-01f, 3.78241353e-02f, 2.40382832e-02f, 8.99200514e-02f, -5.93339093e-02f, 2.89987087e-01f, 1.59249678e-01f, -1.76072851e-01f, 6.21093484e-03f, 3.19161683e-01f,
  3.80050987e-01f, 1.16218589e-02f, 2.14767203e-01f, -1.79605428e-02f, 2.34817892e-01f, -1.77568838e-01f, -4.86330599e-01f, 9.80947167e-02f, 3.14326555e-01f, 4.61022824e-01f,
  -1.00439556e-01f, 2.04888999e-01f, 4.48940307e-01f, 4.75111067e-01f, -9.74433348e-02f, 3.41527075e-01f, -2.91645020e-01f, -5.07425070e-01f, 3.68585229e-01f, -2.25429162e-01f,
  -2.14271054e-01f, 5.23562394e-02f, -3.25690597e-01f, -3.92497152e-01f, -1.39046893e-01f, -2.57072836e-01f, -9.30491909e-02f, 4.80459720e-01f, -9.02183354e-02f, -1.10702440e-01f,
  2.95180678e-01f, 1.34324268e-01f, -2.30787382e-01f, 3.42800736e-01f, -8.80795121e-02f, -2.04709861e-02f, -9.99686345e-02f, 5.32498896e-01f, -2.11871877e-01f, -1.13224573e-01f,
  -1.32931530e-01f, 7.62967765e-02f, -3.80478173e-01f, -1.26401946e-01f, 9.71927345e-02f, 1.27529487e-01f, 6.64726421e-02f, 6.16842210e-02f, -2.00914338e-01f, 1.10141188e-01f,
  -2.40115389e-01f, 2.59716839e-01f, -2.38088548e-01f, -1.54850587e-01f, 1.14088900e-01f, -2.07160756e-01f, -2.01059669e-01f, -1.06242066e-03f, -5.06797396e-02f, -4.44099978e-02f,
  -4.81692672e-01f, 6.31019846e-02f, 1.90244205e-02f, -2.54601449e-01f, -1.20622486e-01f, 2.96495080e-01f, -3.59662250e-02f, -2.77176150e-03f, -1.01892963e-01f, -4.29215692e-02f,
  2.99160302e-01f, 3.35835725e-01f, 1.62699595e-01f, 1.97977453e-01f, 2.79372096e-01f, -4.22047943e-01f, 2.43328050e-01f, -1.84171319e-01f, -1.11955561e-01f, 1.14106901e-01f,
  6.92149028e-02f, -2.94770002e-01f, 9.64551568e-02f, -1.90169945e-01f, -2.22240061e-01f, -1.19820811e-01f, -2.87042111e-01f, -2.72732794e-01f, 8.22030827e-02f, -2.21797600e-01f,
  -1.68420166e-01f, 3.48610371e-01f, -7.03478083e-02f, -3.67879748e-01f, 2.06030801e-01f, 3.67678739e-02f, 6.38869822e-01f, -1.89245343e-01f, -7.70193487e-02f, 5.95883988e-02f,
  2.54731327e-01f, 3.57291877e-01f, -2.67584711e-01f, 2.19648927e-01f, 3.22654881e-02f, 5.15484363e-02f, -2.49941841e-01f, -2.06177548e-01f, 9.00391024e-03f, 1.27252162e-01f,
  -1.53269926e-02f, -1.87667564e-01f, -6.59106001e-02f, 5.83599657e-02f, 2.32746705e-01f, -1.54311195e-01f, -2.32268170e-01f, 2.28264153e-01f, -1.30865812e-01f, 1.14728324e-01f,
  -4.71270420e-02f, -9.08925533e-02f, -1.52212977e-01f, -3.58101994e-01f, -9.51417014e-02f, -1.49650678e-01f, -1.05996586e-01f, -1.15563609e-01f, -9.38162729e-02f, -4.54485655e-01f,
  -2.87451088e-01f, -2.25666881e-01f, -3.87198217e-02f, 1.21030705e-02f, 2.36293256e-01f, -1.62017211e-01f, -3.35617453e-01f, 1.55464783e-01f, -1.66719258e-01f, 3.73184621e-01f,
  -8.27898532e-02f, 4.12629843e-01f, 3.71663094e-01f, 9.37756598e-02f, -7.39861429e-02f, -2.99087703e-01f, -1.66598156e-01f, -1.26783000e-02f, 7.36333951e-02f, -1.53997317e-01f,
  4.56066281e-01f, 1.27203047e-01f, 1.25348791e-01f, 3.27239066e-01f, 1.64500237e-01f, -3.10281217e-02f, -1.27283230e-01f, 1.97871208e-01f, -3.70584011e-01f, -1.45774841e-01f,
  -1.55655190e-01f, 9.81846824e-02f, -1.79560222e-02f, -2.11054057e-01f, -1.43231796e-02f, -2.81035483e-01f, 4.98542756e-01f, 1.20330483e-01f, 2.07644895e-01f, -5.91945387e-02f,
  -2.57065892e-01f, -1.18033096e-01f, 6.29961789e-02f, 1.25004083e-01f, -3.34744990e-01f, -7.14158416e-02f, 2.34474182e-01f, -1.11803494e-01f, -3.39284502e-02f, 1.51336893e-01f,
  2.57786244e-01f, -9.19394717e-02f, 1.42992511e-01f, 4.24554676e-01f, -1.21692024e-01f, -8.75621587e-02f, 1.42689452e-01f, 1.03486024e-01f, 7.24851564e-02f, -7.47539848e-02f,
  2.87335724e-01f, 1.85681999e-01f, -2.85032213e-01f, 4.08310652e-01f, 2.79706627e-01f, 9.20918509e-02f, -2.56828349e-02f, 6.07784651e-03f, 5.17476976e-01f, -3.70694965e-01f,
  3.10326874e-01f, 2.58639514e-01f, -1.26795202e-01f, -7.01177865e-02f, -5.14882088e-01f, -2.68746763e-01f, -5.07101238e-01f, 5.75810745e-02f, 4.13051009e-01f, 1.71785519e-01f,
  -2.02727899e-01f, 5.97249232e-02f, 4.19593990e-01f, 2.00047091e-01f, 5.06016731e-01f, 6.02030195e-02f, -8.85883942e-02f, 5.02900395e-04f, 1.39681682e-01f, -1.34432331e-01f,
  -1.24360546e-01f, 3.85775357e-01f, -4.94973719e-01f, -1.22914970e-01f, -2.67247111e-01f, 3.13974530e-01f, 1.95510432e-01f, -1.09406225e-01f, -1.78540852e-02f, -1.00893132e-01f,
  -2.09974721e-01f, -1.59540161e-01f, 6.06264174e-03f, 1.71788990e-01f, 3.83247346e-01f, 2.02418521e-01f, -1.83478594e-01f, 1.29363924e-01f, -2.10105658e-01f, -2.86634117e-01f,
  -3.62968072e-02f, -1.42259270e-01f, -2.03822300e-01f, -7.54437000e-02f, 1.86669976e-01f, 4.60824780e-02f, -2.59388715e-01f, -1.05951473e-01f, 1.26143485e-01f, 1.35953920e-02f,
  -1.54879317e-03f, 2.18320340e-01f, 2.22086012e-01f, 5.01066625e-01f, 1.48719683e-01f, -1.90747082e-01f, -3.80246192e-02f, 4.82309520e-01f, 1.71217218e-01f, 6.55847564e-02f,
  1.29607255e-02f, 1.96065500e-01f, -6.43370211e-01f, -5.22684753e-02f, 9.77762789e-02f, -8.12588856e-02f, -2.36182556e-01f, 5.10611534e-01f, -1.36115015e-01f, -5.49661756e-01f,
  -2.09387869e-01f, -1.95405483e-02f, 1.15711428e-01f, 5.01139723e-02f, -1.58869132e-01f, 1.22213230e-01f, -1.07230768e-01f, 3.93760726e-02f, -1.19075656e-01f, -2.41689056e-01f,
  -2.73586541e-01f, -1.73664689e-01f, -6.82403073e-02f, -3.93855035e-01f, -4.47996482e-02f, 3.10304523e-01f, 4.90882218e-01f, 1.08146839e-01f, -3.25105965e-01f, -4.97934781e-03f,
  -4.47582528e-02f, 2.94288963e-01f, -1.60810381e-01f, -2.09338993e-01f, -2.03899238e-02f, 4.90815490e-02f, 1.20072775e-01f, -1.41088367e-02f, 4.16686833e-01f, 7.61694601e-03f,
  3.70292038e-01f, -1.33468181e-01f, -6.64171800e-02f, 4.79436964e-01f, 1.07936300e-01f, 2.51982361e-01f, -1.27643541e-01f, 5.49713038e-02f, -1.54839024e-01f, 1.23078972e-01f,
  1.94434524e-01f, -9.88587812e-02f, 9.92532894e-02f, 8.14740881e-02f, 2.49974266e-01f, 1.67264134e-01f, -3.27489614e-01f, 1.66553110e-02f, 1.03510387e-01f, 1.59352139e-01f,
  2.44838297e-01f, -3.80820245e-01f, 1.34261176e-01f, -5.26499748e-02f, -5.03209680e-02f, 1.03093840e-01f, -1.29088536e-01f, 1.02675937e-01f, 1.48467749e-01f, -4.40616339e-01f,
  -5.42263269e-01f, 1.23090796e-01f, 1.38426304e-01f, -4.39408243e-01f, -3.00291449e-01f, 1.09182848e-02f, 2.21733451e-01f, -3.37961346e-01f, 1.71695709e-01f, 4.60269721e-03f,
  2.79323548e-01f, -1.82211176e-02f, -1.65955424e-01f, -6.23087399e-02f, 4.55909409e-02f, 1.05954669e-01f, -4.55426395e-01f, -3.40246260e-01f, -1.62369937e-01f, 2.30039150e-01f,
  1.15021259e-01f, 8.06666836e-02f, 7.26435959e-01f, -4.50758576e-01f, -1.58964947e-01f, 3.92561257e-01f, -1.10535607e-01f, 1.56110853e-01f, 3.35395038e-02f, 1.10722005e-01f,
  -1.25243574e-01f, 1.06991895e-01f, -2.58473307e-01f, -2.52241343e-01f, -5.87220564e-02f, 2.52333969e-01f, -2.75161684e-01f, -7.75032938e-02f, 7.86725506e-02f, -1.32032052e-01f,
  -1.16501614e-01f, 2.26002075e-02f, 2.99114995e-02f, 7.47103095e-02f, -1.23908855e-01f, -1.33300319e-01f, 2.00520203e-01f, 2.60493010e-01f, -7.36902654e-02f, -1.21056676e-01f,
  -1.96760833e-01f, 1.98261186e-01f, -1.69099241e-01f, -1.01951398e-02f, -1.08002104e-01f, -2.36405456e-03f, -9.99998227e-02f, -4.99290377e-02f, -2.99552474e-02f, 7.15309754e-02f,
  1.88702941e-01f, 8.59879702e-02f, -5.00051916e-01f, 6.58976361e-02f, 6.22495234e-01f, 3.47070135e-02f, -1.53260335e-01f, 1.48273632e-01f, 3.77337486e-01f, -1.49510568e-02f,
  -6.73874736e-01f, 1.14517681e-01f, -7.22213015e-02f, -7.25374883e-03f, -2.46354222e-01f, 4.49862741e-02f, 4.45454009e-02f, 3.88034105e-01f, -5.09909354e-02f, 7.67122746e-01f,
  -1.44818025e-02f, -2.10489020e-01f, 8.40884671e-02f, -7.93010741e-02f, -1.77182078e-01f, -1.16666146e-01f, -2.40328521e-01f, 3.26552629e-01f, -1.61023185e-01f, -1.98874295e-01f,
  1.29552558e-01f, -1.17860205e-01f, -2.52869368e-01f, -1.38454974e-01f, 1.12089731e-01f, -9.89619568e-02f, -1.05896622e-01f, 2.58516818e-01f, -1.49304181e-01f, -6.92905337e-02f,
  -1.49864182e-01f, -2.33956233e-01f, -8.49246159e-02f, 1.65738561e-03f, -9.45910811e-02f, -6.32032081e-02f, 5.27570993e-02f, -6.49841502e-02f, 1.38449535e-01f, -1.74569935e-01f,
  3.29500943e-01f, 3.94099467e-02f, -1.12747867e-02f, -9.01896507e-02f, 1.79147974e-01f, 1.90297946e-01f, -4.64808308e-02f, 6.64206743e-02f, -1.12571254e-01f, -5.36552481e-02f,
  -2.59038061e-01f, -4.24605794e-02f, -2.88151540e-02f, -3.84828039e-02f, -4.62380916e-01f, 3.91608864e-01f, -2.75070630e-02f, -1.49887115e-01f, 3.83626729e-01f, -1.43710271e-01f,
  5.41771829e-01f, 3.96066517e-01f, 2.40559071e-01f, 2.58542717e-01f, 4.06801980e-03f, 4.03257817e-01f, 8.88154730e-02f, -3.09965312e-02f, -1.99206278e-01f, 1.22606975e-03f,
  -1.41778126e-01f, -2.65511811e-01f, -1.21955194e-01f, -2.41926312e-02f, -3.01444501e-01f, 1.77077338e-01f, 1.41844615e-01f, -4.36524481e-01f, -6.44302070e-02f, 1.43862471e-01f,
  -7.31319264e-02f, -3.05553406e-01f, 6.88404031e-03f, -1.71511561e-01f, 6.24400750e-02f, -1.55556306e-01f, 1.12903893e-01f, 2.39560753e-01f, 2.86370724e-01f, -1.29067391e-01f,
  -8.98394734e-02f, -2.09297597e-01f, 2.50213027e-01f, -1.08817793e-01f, 5.91058433e-01f, 1.86124250e-01f, -1.24313839e-01f, -1.40403107e-01f, 5.71202397e-01f, 6.59584776e-02f,
  -2.04155460e-01f, 1.53214231e-01f, -1.00809552e-01f, -1.84088293e-02f, -1.46855935e-01f, -2.72381608e-03f, -5.02299704e-02f, 6.21973053e-02f, -3.38215381e-02f, 3.01491469e-01f,
  8.67428854e-02f, -1.78653672e-02f, 2.52094954e-01f, -3.29950601e-01f, -1.54989153e-01f, -1.71011016e-02f, 1.47086546e-01f, 4.55613155e-03f, 6.53060436e-01f, -4.08266000e-02f,
  3.31105351e-01f, -1.35741383e-01f, 7.50898957e-01f, -5.26641130e-01f, 3.01175881e-02f, -5.44597626e-01f, -3.09006244e-01f, -8.57969150e-02f, 4.02201451e-02f, 3.93279403e-01f,
  -1.38307512e-01f, 2.47846767e-01f, 3.56402606e-01f, 7.39836693e-02f, -2.79153585e-01f, -2.04631570e-03f, -2.75256455e-01f, -4.20939028e-02f, 4.46501300e-02f, -1.53612882e-01f,
  -1.21174261e-01f, -5.70437983e-02f, 3.06317121e-01f, -2.48436138e-01f, 4.26968664e-01f, -2.51521111e-01f, 7.70167783e-02f, 9.17162746e-02f, -7.67136663e-02f, -1.19852133e-01f,
  -3.12624544e-01f, -1.31940469e-01f, -3.19317542e-02f, -6.79065287e-02f, 1.43986508e-01f, 4.42602009e-01f, -3.10247183e-01f, -9.24976766e-02f, -8.46945271e-02f, -2.30809510e-01f,
  -1.26974314e-01f, 3.70511919e-01f, -2.58574367e-01f, -5.28295264e-02f, 1.39514238e-01f, -1.26794055e-01f, -1.45328760e-01f, -7.66475871e-02f, 2.10253954e-01f, 8.79341457e-03f,
  -1.85631543e-01f, -2.75277793e-01f, 9.77937058e-02f, 9.76255909e-02f, 4.88531813e-02f, 1.77235469e-01f, 1.36077210e-01f, 3.43495697e-01f, -4.35807258e-02f, 8.88153724e-03f,
  -1.98958814e-01f, 1.67987142e-02f, 3.38834286e-01f, -4.40334111e-01f, 1.79706901e-01f, 1.57873049e-01f, -3.39125037e-01f, -4.06092912e-01f, 2.34401509e-01f, 1.56005934e-01f,
  4.77675647e-01f, 6.47402601e-03f, 2.81761497e-01f, -1.41220346e-01f, 3.34104747e-01f, 1.11896709e-01f, 1.49450064e-01f, -2.89261311e-01f, -1.01988018e-02f, 1.10103205e-01f,
  1.27381787e-01f, -1.18315510e-01f, 6.50225282e-01f, 2.94155061e-01f, 4.36313540e-01f, -1.62869409e-01f, -8.47541839e-02f, -1.08006056e-02f, -2.66591609e-01f, -1.58093780e-01f,
  -9.34478045e-02f, -1.62886858e-01f, -4.59342673e-02f, 2.12277412e-01f, 1.28896162e-01f, 2.06447601e-01f, -1.92949757e-01f, -2.99497079e-02f, -1.12052917e-01f, -2.61338986e-02f,
  -2.48126164e-02f, -9.64103267e-02f, 1.42568216e-01f, 1.11660279e-01f, 1.09768949e-01f, -1.71013653e-01f, -7.81661645e-03f, -1.38736978e-01f, -4.08660956e-02f, -2.08243147e-01f,
  -1.17240943e-01f, 9.63842794e-02f, -2.37947509e-01f, -1.34100482e-01f, 2.93465555e-01f, 2.09322736e-01f, 2.30095625e-01f, -2.36276180e-01f, 1.59391522e-01f, -1.40887043e-02f,
  1.80462688e-01f, 2.21076936e-01f, 2.04661507e-02f, 3.24388631e-02f, 1.27720565e-01f, -7.01069087e-02f, -3.21704060e-01f, 3.74185592e-02f, -9.70407426e-02f, -6.57761335e-01f,
  -3.90802622e-01f, 2.92124420e-01f, 3.93354483e-02f, -4.80462760e-01f, 2.97066003e-01f, 7.77712539e-02f, 1.38217911e-01f, 4.81530279e-01f, -2.30732799e-01f, -3.91696766e-02f,
  8.81374329e-02f, -1.91818163e-01f, 3.25182937e-02f, 7.11355031e-01f, 4.06044394e-01f, -1.11175857e-01f, -2.95996904e-01f, -2.96177715e-01f, -4.86399047e-02f, -3.51439953e-01f,
  -2.91083962e-01f, -4.54162508e-02f, -2.55535424e-01f, -2.62637436e-01f, -1.74160033e-01f, 6.14489280e-02f, 4.15976979e-02f, -2.59735703e-01f, 4.86427784e-01f, -9.72250924e-02f,
  1.20519534e-01f, -9.30247009e-02f, 3.08378935e-02f, -5.87478504e-02f, -9.39663947e-02f, 3.94471064e-02f, -1.18572719e-01f, 3.28992695e-01f, 1.92306578e-01f, 4.18903604e-02f,
  6.81738835e-03f, -8.95002112e-02f, 6.81185126e-02f, -4.00639325e-02f, -5.83738014e-02f, 1.09963201e-01f, -1.66295007e-01f, -1.96652234e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.08667277e-01f, -2.06777789e-02f, -1.53092608e-01f, -2.39423200e-01f, 9.52724293e-02f, -5.56969978e-02f, -5.39789200e-02f, -4.64579538e-02f, 8.32610112e-03f, 2.40906216e-02f,
  -1.06771179e-01f, 4.35228422e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    