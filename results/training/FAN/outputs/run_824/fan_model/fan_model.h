/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.39180303e-01f, 3.79161775e-01f, 4.46682900e-01f, 2.08223909e-01f, -9.23050046e-02f, -4.87250276e-02f, 1.51920900e-01f, 1.64213061e-01f, -4.96819243e-03f, 7.64580742e-02f,
  -2.31964126e-01f, -3.89305502e-01f, -1.73503533e-01f, -2.23800063e-01f, 5.74437529e-02f, 3.15885603e-01f, 3.04288983e-01f, 1.39009073e-01f, -1.41150206e-01f, -3.13578546e-01f,
  -1.28588021e-01f, 1.83896217e-02f, 2.22027719e-01f, 5.19610010e-02f, -7.55790547e-02f, -1.19121499e-01f, 1.70173600e-01f, -4.48174626e-02f, -2.90841125e-02f, 1.99769467e-01f,
  -8.51006433e-02f, 3.10420007e-01f, -1.30751580e-01f, -1.43129706e-01f, -7.21167549e-02f, 9.52806473e-02f, -5.42793132e-04f, 1.19433189e-02f, -1.67398565e-02f, 8.04535449e-02f,
  -5.74600250e-02f, -4.62118015e-02f, -1.22287877e-01f, -4.41011712e-02f, 2.49451343e-02f, -1.69892013e-02f, 1.01622336e-01f, 1.81001738e-01f, 1.05514862e-01f, -1.12236282e-02f,
  -1.46667227e-01f, -2.01168340e-02f, 1.01153903e-01f, 2.88862381e-02f, 4.14323471e-02f, -6.49992079e-02f, -3.60874198e-02f, 1.22406460e-01f, 1.21734008e-01f, 3.01878273e-01f,
  -1.16347466e-02f, 1.82709321e-02f, 7.93971866e-03f, 3.39077250e-03f, -4.16796692e-02f, -7.10041896e-02f, -5.30718733e-03f, -8.30277875e-02f, 7.28026330e-02f, 1.53627433e-02f,
  -1.95199938e-03f, 5.83120203e-03f, 4.72313818e-03f, 1.15049221e-02f, -1.77050270e-02f, 6.36718199e-02f, 2.44968035e-03f, 5.52765839e-02f, -9.49916467e-02f, 3.00495215e-02f,
  -3.46960546e-03f, 4.09541698e-03f, 7.55290687e-02f, 7.09249498e-03f, 2.99630803e-03f, 5.19646592e-02f, 3.46312560e-02f, -5.11940718e-02f, -3.01819667e-02f, 2.94297282e-02f,
  -9.62587520e-02f, -6.51507005e-02f, -1.10186469e-02f, 3.52900173e-03f, 5.60127161e-02f, -8.81633162e-03f, -3.02547719e-02f, -4.97029312e-02f, -9.27217379e-02f, 2.05088388e-02f,
  -1.22633567e-02f, 3.12289521e-02f, 1.05005540e-02f, 4.04698849e-02f, 2.40511708e-02f, 9.70132090e-03f, -3.95016409e-02f, -5.24044558e-02f, -1.03176143e-02f, 2.41483003e-02f,
  3.30350809e-02f, 1.07227936e-01f, -1.37220874e-01f, -1.49556696e-02f, 8.71326588e-03f, -1.47336930e-01f, -6.65141642e-02f, -7.60705769e-02f, -9.31492299e-02f, 1.07899226e-01f,
  1.42364293e-01f, -1.59785122e-01f, -2.63588399e-01f, -1.42008319e-01f, -1.77207798e-01f, -9.14613083e-02f, -2.27805793e-01f, 1.32194487e-02f, -6.20068423e-02f, -7.07180798e-02f,
  2.01863885e-01f, 1.79429606e-01f, -6.52254932e-03f, 1.74815908e-01f, 9.26601887e-02f, -2.20645115e-01f, -2.51595944e-01f, -8.63155797e-02f, -6.85376525e-02f, 8.99235979e-02f,
  -1.20784856e-01f, -1.13818988e-01f, 2.45566983e-02f, -1.32066431e-02f, -1.02240138e-01f, 2.62464769e-02f, -1.59102201e-01f, -5.86898848e-02f, 5.42344972e-02f, -2.07306191e-01f,
  -1.70796782e-01f, 3.28061432e-01f, 8.47464874e-02f, 1.31589144e-01f, -9.49143246e-03f, 3.95432524e-02f, -4.81473543e-02f, 4.38105315e-02f, -8.88507161e-03f, 8.82402435e-03f,
  1.03009611e-01f, 1.19905762e-01f, -1.53030374e-03f, 3.06476392e-02f, 4.20668023e-03f, 5.54778017e-02f, 8.99456069e-02f, 3.15716974e-02f, 1.06613539e-01f, 5.40551916e-03f,
  -5.46354018e-02f, -5.58978878e-02f, -1.74801871e-02f, 4.05406617e-02f, 1.44895941e-01f, 2.57240087e-02f, 1.09949633e-01f, 1.82668507e-01f, 1.41441032e-01f, -9.25573856e-02f,
  -5.58084361e-02f, -1.59133133e-02f, 5.53440601e-02f, 2.94207390e-02f, 5.25070960e-03f, -3.45550142e-02f, -1.32549962e-03f, 3.62272561e-02f, 1.44250523e-02f, -4.22337651e-02f,
  8.83028749e-03f, -1.63419377e-02f, -1.27464142e-02f, -4.72780727e-02f, -3.62110045e-03f, -7.28544444e-02f, -7.78243467e-02f, -1.74885942e-03f, 3.27019840e-02f, 1.10845573e-01f,
  -2.21337490e-02f, 5.37112020e-02f, -4.06447537e-02f, -4.11649495e-02f, 3.43115069e-02f, -4.56391275e-02f, 6.62900554e-03f, 4.01567109e-02f, -2.95349006e-02f, 3.28984670e-02f,
  -2.16808096e-01f, 2.60755599e-01f, -7.30414093e-02f, 5.09928688e-02f, -3.22270356e-02f, 2.02776100e-02f, -8.75161290e-02f, -3.96917686e-02f, 1.84959285e-02f, -7.69141167e-02f,
  1.29102394e-01f, -7.72544891e-02f, 1.74181852e-02f, 2.18361225e-02f, -2.27271044e-03f, 3.09169460e-02f, 8.05115036e-04f, -1.18986405e-01f, -1.78622361e-02f, 2.51005050e-02f,
  -1.07427642e-01f, -1.59308448e-01f, -2.17203647e-01f, -1.55310795e-01f, -2.03787405e-02f, -1.27851844e-01f, -1.38836965e-01f, -1.18025564e-01f, -2.03013495e-02f, -3.39055151e-01f,
  1.22894198e-01f, -4.46501076e-01f, 2.24915788e-01f, -8.29334855e-02f, 1.79862559e-01f, 3.03238720e-01f, 1.91976756e-01f, 4.44013067e-03f, -1.79574817e-01f, -2.08380342e-01f,
  -6.35722280e-02f, 2.65924949e-02f, -5.41300625e-02f, 1.15498513e-01f, 1.86735928e-01f, -2.13974610e-01f, -1.08012659e-02f, 3.28172147e-01f, 5.29324174e-01f, 2.20124498e-01f,
  -9.27051380e-02f, -3.13969329e-02f, 1.01124182e-01f, -1.71698481e-02f, -3.82217288e-01f, 1.75953712e-02f, -1.16250135e-01f, 8.77315998e-02f, -6.57072244e-03f, -3.66852611e-01f,
  -7.68730342e-02f, -1.46094218e-01f, 1.93798065e-01f, 5.83187491e-03f, 4.44649532e-02f, -4.62795608e-02f, 7.39752576e-02f, -1.02498773e-02f, 6.14591502e-02f, -1.24600768e-01f,
  3.03327497e-02f, -6.94407299e-02f, 1.23213592e-03f, -1.36349142e-01f, -4.22737710e-02f, 1.27285486e-04f, -1.42133117e-01f, -3.70580964e-02f, 4.53242585e-02f, -1.24436781e-01f,
  -2.72080805e-02f, 8.96495804e-02f, 1.45225346e-01f, 7.86669031e-02f, 1.73270423e-02f, 3.08788180e-01f, -3.03694624e-02f, 6.84318319e-02f, 1.07364424e-01f, -2.74115503e-01f,
  9.07062087e-03f, 2.24806499e-02f, -1.67898759e-02f, -3.35162543e-02f, -3.35350409e-02f, 3.52039449e-02f, -1.88830905e-02f, -2.06566416e-03f, -3.25740017e-02f, -3.30635048e-02f,
  4.99016866e-02f, -6.72188471e-04f, -4.81831655e-02f, 3.05345142e-03f, -6.11818284e-02f, 2.86239740e-02f, 1.13838173e-01f, -8.60959291e-02f, -5.34374490e-02f, -5.01925610e-02f,
  -1.94363703e-03f, 4.65384722e-02f, -3.08937486e-03f, -2.49751989e-04f, 2.48941891e-02f, 5.76109216e-02f, 1.56202987e-02f, 1.86309721e-02f, -8.08393061e-02f, 1.10288514e-02f,
  -1.39605850e-01f, 2.69063085e-01f, -2.53018588e-01f, -4.81649935e-02f, -7.66405314e-02f, -8.47588759e-03f, -9.94416997e-02f, 4.41621915e-02f, 5.42452261e-02f, 2.54007950e-02f,
  8.08955505e-02f, 6.72257841e-02f, -1.25302196e-01f, -1.62200350e-02f, 5.04473671e-02f, 1.81435458e-02f, -1.77590951e-01f, 7.50736371e-02f, 4.94575165e-02f, -1.05390288e-01f,
  -1.42476499e-01f, 8.33337009e-02f, 1.59660041e-01f, 1.25334868e-02f, -6.99147955e-02f, 2.00388834e-01f, 7.06714438e-03f, -1.29272426e-02f, 2.36353889e-01f, -2.11825788e-01f,
  -2.61735935e-02f, -8.20429623e-03f, -1.47210106e-01f, 3.03793669e-01f, 1.84187278e-01f, -8.72605816e-02f, -3.88820082e-01f, -1.71572074e-01f, 8.26189369e-02f, 6.63593560e-02f,
  2.55502224e-01f, 1.10378541e-01f, -2.58250366e-04f, -1.50700346e-01f, -5.10628104e-01f, -3.68419319e-01f, -3.78526956e-01f, -4.90240335e-01f, -2.88778543e-01f, -1.28648430e-02f,
  3.63621712e-02f, 7.01416433e-02f, -5.56965135e-02f, -2.76717655e-02f, 1.01611763e-01f, 1.68349370e-02f, 6.20659962e-02f, 1.25314936e-01f, -7.74985477e-02f, -1.49572536e-01f,
  -1.96441188e-02f, 4.36781384e-02f, -3.93433981e-02f, 8.55163038e-02f, 1.29762307e-01f, -6.02597781e-02f, 9.72805545e-03f, 1.38385883e-02f, 4.31432016e-02f, -3.13473344e-02f,
  9.20512378e-02f, 1.21518679e-01f, -5.03631048e-02f, -3.26272286e-02f, 4.22758684e-02f, -4.57762070e-02f, -4.48280871e-02f, -1.41344175e-01f, -1.83248203e-02f, 5.53992614e-02f,
  1.93615377e-01f, 8.60877708e-02f, 4.09869701e-02f, 5.01545100e-03f, -1.37879595e-01f, 6.17562905e-02f, 6.07195031e-03f, -1.43028442e-02f, -9.89225805e-02f, -7.87963420e-02f,
  2.06933171e-02f, -1.90756042e-02f, 2.55566072e-02f, 2.16053869e-03f, -1.64042171e-02f, 4.90370914e-02f, 3.00475340e-02f, -4.95421253e-02f, -4.95934151e-02f, -1.59438718e-02f,
  -8.46869033e-03f, 4.22820710e-02f, -3.19135301e-02f, -2.10274775e-02f, 2.15520058e-03f, 7.04004392e-02f, -8.37382022e-03f, -6.94185793e-02f, -5.51979057e-02f, 1.82889886e-02f,
  1.61576532e-02f, 3.69679220e-02f, 9.19624567e-02f, 9.66165494e-03f, -4.74414751e-02f, -8.84552207e-03f, -3.17098163e-02f, 5.27821369e-02f, 8.89071729e-03f, 1.55139705e-02f,
  1.64605096e-01f, -8.21295157e-02f, -5.36765605e-02f, -1.39663771e-01f, 2.57654395e-02f, 2.29461510e-02f, 9.10473913e-02f, 3.22154537e-02f, 1.05812490e-01f, 4.75706859e-03f,
  -2.81953309e-02f, -6.61244094e-02f, 5.52832261e-02f, 3.05303633e-02f, -7.16458410e-02f, 3.12261526e-02f, -1.19635614e-03f, -1.31716421e-02f, -5.42020574e-02f, 1.59050599e-02f,
  1.35083525e-02f, -7.36585855e-02f, -2.12712124e-01f, -6.64184391e-02f, 1.72720589e-02f, -1.25384256e-01f, -1.13904893e-01f, -6.66064397e-02f, -3.08951855e-01f, -3.40922952e-01f,
  2.63285249e-01f, -3.10703158e-01f, 1.64273262e-01f, 1.24314383e-01f, -2.21102297e-01f, -2.21819788e-01f, -4.18474823e-01f, -1.86774671e-01f, -1.63118765e-02f, -1.30037680e-01f,
  -3.97117943e-01f, -1.50664970e-01f, 1.14802308e-02f, 2.18793321e-02f, 9.14004073e-02f, -6.17619529e-02f, 9.24520791e-02f, 4.43845868e-01f, 3.18168938e-01f, -1.29434951e-02f,
  -1.75658181e-01f, 6.14859834e-02f, 3.52200955e-01f, 3.24933171e-01f, 5.54768890e-02f, 1.25206023e-01f, 1.12410337e-01f, 2.55677700e-02f, 1.20399572e-01f, 5.17814398e-01f,
  4.82281484e-02f, -7.85276964e-02f, -2.00583600e-02f, -2.51478422e-02f, -7.40324035e-02f, 2.35087257e-02f, -3.25109325e-02f, 9.88112167e-02f, -5.76025136e-02f, -2.10999977e-02f,
  -1.00312069e-01f, 4.97264368e-03f, -3.12905386e-02f, -4.86146025e-02f, 6.33795105e-04f, -2.18392815e-02f, 7.28649944e-02f, 2.00131133e-01f, 1.83404669e-01f, -1.38686135e-01f,
  -1.18109338e-01f, -4.82450053e-02f, 4.99283262e-02f, -1.08484346e-02f, -1.25264435e-03f, 1.63539305e-01f, 3.78426313e-02f, 1.44125640e-01f, 1.37381315e-01f, 3.17714661e-01f,
  7.63892680e-02f, -2.84843915e-03f, 4.56194505e-02f, 3.47577482e-02f, -3.00235413e-02f, 3.04519087e-02f, 3.40435840e-02f, -2.71896422e-02f, 1.10066701e-02f, 7.69991055e-03f,
  9.38791707e-02f, -3.40442592e-03f, -1.77948214e-02f, 5.82967810e-02f, 1.19815441e-02f, -5.43565527e-02f, 2.14997809e-02f, -1.71049237e-02f, -2.09116209e-02f, -4.91029881e-02f,
  6.71883151e-02f, 6.83524227e-03f, -6.61508292e-02f, 6.18894733e-02f, -1.83211546e-02f, 5.22824265e-02f, -3.99894901e-02f, 2.44840533e-02f, -1.16805121e-01f, -4.70906496e-02f,
  -4.67656553e-03f, -6.37430251e-02f, 1.59293577e-01f, 3.84904332e-02f, 4.54637315e-03f, 8.29179678e-03f, -4.58499417e-02f, 3.33526991e-02f, -3.80527563e-02f, 5.97145222e-03f,
  -8.40958133e-02f, 7.22524896e-02f, -3.13938297e-02f, 4.48205210e-02f, 2.60427743e-02f, -4.67997864e-02f, -1.29607618e-01f, 1.23061081e-02f, -7.70918385e-04f, -1.15597472e-02f,
  -6.25482872e-02f, 4.46877396e-03f, 8.84207338e-02f, 3.29341926e-02f, -7.49928551e-03f, 4.69779819e-02f, 2.50812490e-02f, 8.80546644e-02f, 1.50490060e-01f, 6.77043796e-02f,
  4.40115571e-01f, 2.33618826e-01f, -3.98894548e-02f, 2.90710926e-01f, -1.48703754e-01f, -3.03162426e-01f, -1.88889161e-01f, 5.34039252e-02f, 9.96553898e-02f, 1.64722696e-01f,
  -1.29505113e-01f, -2.02255160e-01f, -6.95541874e-02f, -1.38775259e-01f, -1.05039388e-01f, 1.48232520e-01f, 1.17177367e-01f, 4.00907136e-02f, -3.23231786e-01f, -1.50475740e-01f,
  4.83871289e-02f, 2.92048216e-01f, 2.34766424e-01f, 1.35198995e-01f, 2.82830268e-01f, 2.91318055e-02f, 1.07444540e-01f, 8.99598449e-02f, -4.31221388e-02f, 2.88002640e-01f,
  -2.43301630e-01f, 2.02044472e-01f, -1.89947233e-01f, 1.36110401e-02f, -2.73200311e-02f, -5.46875745e-02f, -7.34090805e-02f, 7.83546790e-02f, 6.17623925e-02f, 2.16338672e-02f,
  4.25322764e-02f, -2.59678345e-02f, 6.96055070e-02f, -1.93344373e-02f, -2.74856612e-02f, -4.39591967e-02f, 3.89048867e-02f, 6.91690892e-02f, -2.26297658e-02f, -4.12888750e-02f,
  4.83398661e-02f, -2.65940484e-02f, -9.04116184e-02f, -1.01093195e-01f, -6.79648947e-03f, -6.99462816e-02f, 3.46183106e-02f, -4.04199213e-02f, -1.71163976e-01f, 1.20630562e-01f,
  5.58349676e-02f, 3.18338424e-02f, -3.20612267e-02f, 5.07168882e-02f, -3.17189872e-04f, 3.46165299e-02f, -3.94896232e-03f, 1.71134509e-02f, -3.47898304e-02f, 4.73717637e-02f,
  -2.39159949e-02f, -7.61631830e-03f, 4.32300352e-04f, 6.85210526e-02f, 8.00415408e-03f, 3.23021486e-02f, 4.94730994e-02f, -5.24074072e-04f, -6.02506772e-02f, -9.21209529e-03f,
  1.21005317e-02f, -5.20301163e-02f, 2.74391640e-02f, -8.62104446e-03f, 1.38729699e-02f, -3.09984032e-02f, 2.81666201e-02f, -6.04115315e-02f, 4.19935808e-02f, 6.73772618e-02f,
  3.94217111e-02f, -2.20538035e-01f, 3.23580615e-02f, -2.67420243e-02f, -2.53128372e-02f, 4.14976925e-02f, 1.79105215e-02f, 1.78913735e-02f, 5.47458902e-02f, 1.39793139e-02f,
  -5.62094785e-02f, 3.13163660e-02f, -5.90044679e-03f, 5.08115329e-02f, -1.18914142e-01f, -5.29485717e-02f, 7.98217952e-02f, -9.45704803e-02f, 2.57580448e-02f, 1.31610199e-03f,
  9.83151495e-02f, 7.52652716e-03f, -1.09883182e-01f, -1.36189945e-02f, -3.85874212e-02f, -9.41958800e-02f, -1.70716211e-01f, -8.61073956e-02f, -1.81314662e-01f, 6.87949508e-02f,
  2.40455151e-01f, -6.67789485e-03f, -1.54481277e-01f, 3.63165915e-01f, 1.77515805e-01f, 9.73015726e-02f, 2.63938531e-02f, 4.86645587e-02f, 9.63864382e-04f, -4.25100848e-02f,
  -2.96452530e-02f, -1.60870776e-01f, -1.27022535e-01f, -1.91841424e-01f, -2.18343318e-01f, -1.34650856e-01f, 1.15061067e-01f, 2.34631971e-02f, -7.42382705e-02f, 1.80484578e-01f,
  3.05431306e-01f, 2.87402153e-01f, 6.23061731e-02f, 1.24300376e-01f, 2.15040773e-01f, -2.72661983e-03f, -1.48914456e-01f, 1.29530370e-01f, -2.03792583e-02f, 2.71095365e-01f,
  -1.64891973e-01f, 1.67885087e-02f, 9.54799261e-03f, 1.21792704e-01f, 2.54235184e-03f, 5.11460844e-03f, -6.88185096e-02f, -3.39118913e-02f, -6.70729158e-03f, 8.54291618e-02f,
  5.88064864e-02f, 4.98354472e-02f, 6.08243160e-02f, -3.80513854e-02f, 1.08262837e-01f, 1.00372285e-01f, 1.09017678e-02f, -9.78097618e-02f, -1.43300995e-01f, -6.58477843e-02f,
  1.61939170e-02f, 7.16161802e-02f, 4.82975692e-02f, -1.42919347e-01f, -2.28354242e-02f, 4.31143865e-02f, -1.18487515e-02f, 6.31304309e-02f, -1.65967450e-01f, 6.59717200e-03f,
  -9.85379145e-03f, -2.46885084e-02f, -2.27072835e-02f, 8.22611898e-02f, 3.04798763e-02f, -5.54278903e-02f, -4.34032595e-03f, 5.82819693e-02f, 5.05824424e-02f, -7.20538246e-03f,
  -3.68317366e-02f, -2.70923898e-02f, -5.88170663e-02f, 2.25696713e-02f, -7.07043484e-02f, -5.50560281e-02f, 4.82056476e-02f, -5.39630977e-03f, -4.90908045e-03f, 5.34006627e-03f,
  -6.07559234e-02f, 3.78696471e-02f, 2.45390227e-03f, -2.92247813e-02f, 7.63150956e-03f, -4.22350466e-02f, 2.56981514e-02f, -6.61778916e-03f, 4.18912992e-02f, 4.05893996e-02f,
  -1.98935300e-01f, -3.15292686e-01f, 5.67529574e-02f, 3.46542709e-03f, 5.13878874e-02f, -8.12941194e-02f, -4.55779620e-02f, -2.41729040e-02f, 6.95444224e-03f, 8.72839838e-02f,
  6.05921298e-02f, 5.45298532e-02f, -4.33973745e-02f, 1.14145856e-02f, 7.11373389e-02f, 4.20381548e-03f, -3.95829231e-03f, -4.61919978e-02f, -4.47513051e-02f, 9.13849697e-02f,
  6.17944077e-02f, 5.02184173e-03f, -4.65032756e-02f, -1.33692324e-01f, 1.17314421e-02f, -2.61420384e-02f, -7.44846314e-02f, -9.94017720e-02f, -1.03391036e-01f, -1.59836225e-02f,
  -1.42228276e-01f, 1.22893164e-02f, 3.14694852e-01f, 1.42268345e-01f, 1.91375077e-01f, -3.99053805e-02f, -1.08231403e-01f, -1.91301644e-01f, 3.68377455e-02f, -7.22508505e-02f,
  8.19376186e-02f, 4.56782803e-02f, 2.79372502e-02f, -8.51636305e-02f, -3.66552174e-02f, -1.39950275e-01f, 3.35367993e-02f, -2.13323981e-02f, -7.68112391e-03f, -7.15424195e-02f,
  -1.53394341e-01f, 1.50872976e-01f, 1.07042581e-01f, 4.22774442e-02f, 1.87300861e-01f, 7.44919181e-02f, 2.18295604e-01f, 2.32457742e-01f, -4.92002219e-02f, 1.54751331e-01f,
  2.24175006e-01f, 9.28568169e-02f, -5.74928597e-02f, -6.19440638e-02f, 3.83310243e-02f, -8.66377130e-02f, -5.53196073e-02f, 5.74683435e-02f, -3.45034264e-02f, -6.16528131e-02f,
  8.83071944e-02f, -2.42270809e-03f, 4.78334352e-02f, -1.08907307e-02f, 1.10049009e-01f, 2.33317073e-02f, -3.84750264e-03f, 6.73396066e-02f, 1.42174074e-02f, -4.36567254e-02f,
  -8.47585350e-02f, -5.73923960e-02f, 2.12064702e-02f, -4.77031916e-02f, -7.79427737e-02f, 4.93827090e-02f, 1.22786418e-01f, -1.34924641e-02f, 4.85647693e-02f, -1.29819326e-02f,
  -8.59352723e-02f, 8.29760393e-04f, -3.36463861e-02f, -4.41155806e-02f, -6.17267005e-02f, 9.71899834e-03f, 5.33132069e-02f, -3.75339277e-02f, 2.04316415e-02f, -1.57175753e-02f,
  3.14222500e-02f, 4.26160619e-02f, -3.71047072e-02f, -1.71782132e-02f, 9.39052776e-02f, 9.81323421e-02f, -6.29496053e-02f, 2.17169570e-03f, 2.09764065e-03f, 6.89165806e-03f,
  -1.13103641e-02f, 7.27102831e-02f, 4.75920103e-02f, 4.80205379e-02f, -6.71025971e-03f, -4.33082730e-02f, -7.86240548e-02f, -4.81474586e-02f, -3.81759144e-02f, 8.96252245e-02f,
  1.35645628e-01f, 1.70732271e-02f, 3.35379057e-02f, 2.39270348e-02f, 5.47258854e-02f, 8.01929273e-03f, -2.28931848e-02f, -3.66368927e-02f, 8.71654898e-02f, -4.98211384e-02f,
  2.14673579e-02f, -4.81508486e-02f, 6.42301217e-02f, -4.78926003e-02f, -1.35511067e-02f, -6.96887597e-02f, -9.31235626e-02f, 8.35473984e-02f, -1.22365439e-02f, 1.32677490e-02f,
  -4.68025021e-02f, -1.45690382e-01f, -1.78685606e-01f, -1.36035271e-02f, 1.57777108e-02f, -8.90700594e-02f, 7.85623565e-02f, -5.87239303e-03f, -1.65811509e-01f, -2.30572775e-01f,
  2.07268342e-01f, -3.72731596e-01f, 2.61232741e-02f, -1.12410627e-01f, -3.18930030e-01f, -1.90656394e-01f, -3.00829768e-01f, 2.53899451e-02f, 1.04886800e-01f, -2.42594674e-01f,
  -1.43752545e-01f, -7.64780305e-03f, 1.41108528e-01f, 1.25317290e-01f, 2.30566010e-01f, -9.02581587e-02f, 1.77009590e-02f, 2.19563901e-01f, 2.96776444e-01f, -1.03251450e-01f,
  -3.34551632e-02f, -6.74479678e-02f, 2.35274151e-01f, 1.60537958e-01f, -3.30095559e-01f, -2.26611435e-01f, -7.13078827e-02f, -1.26732364e-01f, -1.14399418e-01f, -4.31409121e-01f,
  -2.93535471e-01f, 5.47098415e-03f, 1.43600792e-01f, 6.02924228e-02f, -1.27533108e-01f, 6.21467605e-02f, 3.64600085e-02f, -3.87939252e-03f, 1.78750139e-02f, 3.06555349e-02f,
  1.70417421e-03f, 9.83958319e-02f, -2.23215297e-02f, 2.80137807e-02f, 3.39501463e-02f, -1.04240300e-02f, 1.59727901e-01f, 2.09018648e-01f, 2.04654336e-01f, -6.81167394e-02f,
  -1.59830064e-01f, -4.23202589e-02f, -1.22515345e-02f, -1.99340582e-02f, 2.05055937e-01f, 5.50341532e-02f, -1.39450014e-01f, -5.59771098e-02f, -3.34804482e-03f, -3.25170338e-01f,
  -7.25512579e-02f, 1.15040550e-02f, 4.21762653e-02f, -5.44944890e-02f, -3.14763598e-02f, 3.43407206e-02f, 3.86411473e-02f, -8.95313621e-02f, 2.40088757e-02f, -5.64566329e-02f,
  3.55452038e-02f, -5.11901313e-03f, 1.35062104e-02f, -5.50911874e-02f, -2.74000615e-02f, 4.72958200e-02f, 6.23800419e-03f, -7.11784465e-03f, -1.47495382e-02f, 1.39337527e-02f,
  -1.58684794e-02f, 6.45209551e-02f, -1.94077846e-03f, 3.24375965e-02f, 3.00644394e-02f, 3.29848975e-02f, 1.16009349e-02f, -5.73327392e-03f, -4.03979681e-02f, 5.70264645e-03f,
  1.87768027e-01f, 2.43443146e-01f, -8.41721222e-02f, 4.96732034e-02f, -7.00719208e-02f, 2.72218604e-02f, -6.95383251e-02f, 1.70347150e-02f, -4.09891531e-02f, -2.17622649e-02f,
  1.04391044e-02f, -3.24668102e-02f, 2.95594968e-02f, -1.09954197e-02f, -4.71951924e-02f, -4.18332592e-02f, -1.06136836e-01f, -4.48693633e-02f, 5.13049848e-02f, -3.61378528e-02f,
  2.39414605e-03f, -4.39520627e-02f, 3.62496972e-02f, 2.45153643e-02f, -7.33491406e-02f, 4.58374321e-02f, -3.30453664e-02f, -1.03046134e-01f, 2.52062529e-02f, -2.45062828e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.47399521e-01f, -1.69842616e-01f, -9.55074608e-01f, 9.90120396e-02f, -3.64584506e-01f, -4.17633921e-01f, -2.52552092e-01f, 1.18525051e-01f, 1.10558346e-01f, -2.05963910e-01f,
  -3.52900177e-02f, 1.60865963e-01f, 1.47611856e-01f, -6.30489970e-03f, -1.70169156e-02f, -3.53019357e-01f, -4.77365255e-01f, -1.92074776e-01f, -1.29553810e-01f, 4.74842601e-02f,
  -5.91865070e-02f, 1.76189646e-01f, 1.27196163e-01f, -1.16844800e-04f, -1.65458173e-01f, -9.30601209e-02f, -4.04472500e-01f, -2.40186274e-01f, -3.05036426e-01f, -4.52074796e-01f,
  -2.95848787e-01f, -1.20906539e-01f, -6.61178976e-02f, 8.61942619e-02f, -1.88928470e-01f, -1.48044303e-02f, -1.43285245e-02f, 2.67688911e-02f, 3.01179159e-02f, -1.46432593e-02f,
  -9.15113315e-02f, -1.40572898e-02f, -3.88060138e-02f, -1.44764744e-02f, -1.56863835e-02f, -9.35973786e-03f, -6.71002492e-02f, -9.02273133e-02f, -1.39299423e-01f, -1.39477909e-01f,
  -1.49237394e-01f, -2.48333678e-01f, -1.62120908e-01f, -2.62923334e-02f, -1.15641497e-01f, -1.19075678e-01f, -1.38445988e-01f, -1.73806697e-01f, -2.16241598e-01f, 1.17413446e-01f,
  -9.05052423e-02f, -4.36547548e-02f, -4.84557040e-02f, 7.13709071e-02f, 7.37214759e-02f, -5.73384669e-03f, -8.27389657e-02f, 5.59133403e-02f, 6.49645030e-02f, 2.54344940e-02f,
  1.77033320e-02f, -4.84935641e-02f, -3.19265649e-02f, 6.82477131e-02f, 9.84369125e-03f, -3.52640934e-02f, 1.80402433e-03f, 4.59038019e-02f, 2.66570412e-02f, -1.38122095e-02f,
  3.02959848e-02f, -6.43168986e-02f, 6.09948440e-03f, 5.52575029e-02f, -1.75634265e-01f, -5.17743602e-02f, 5.52228652e-03f, -8.25828779e-03f, 7.21073942e-03f, 5.00779934e-02f,
  7.26414084e-01f, -2.43947461e-01f, 1.21277384e-01f, 1.69695035e-01f, -6.79418370e-02f, -2.10478511e-02f, 3.76629792e-02f, -7.29890838e-02f, 2.80670933e-02f, 1.83161180e-02f,
  -2.58106217e-02f, 2.18844876e-01f, 1.16748009e-02f, -1.54929003e-02f, 2.15983838e-02f, 6.98896870e-02f, 2.17920877e-02f, -1.71869658e-02f, -3.13932113e-02f, -3.97462994e-02f,
  -2.59542279e-02f, 1.49577141e-01f, 3.60454738e-01f, 1.69512793e-01f, -2.90940627e-02f, 1.84899941e-01f, 6.57450184e-02f, 1.48381963e-01f, 9.00971889e-02f, 3.86455655e-01f,
  -4.46401507e-01f, -2.35231444e-01f, -1.74554497e-01f, -3.57191414e-01f, -1.71811029e-01f, -6.35219812e-02f, -1.85404852e-01f, -1.52723446e-01f, -2.01520488e-01f, -1.29938453e-01f,
  -8.72661322e-02f, -2.11339429e-01f, -1.94543704e-01f, -1.59071952e-01f, -1.96870148e-01f, -2.62833893e-01f, -1.89345539e-01f, -2.64207989e-01f, -1.16273195e-01f, -6.58176765e-02f,
  -2.58539885e-01f, -3.77987921e-01f, -2.25261852e-01f, -1.59223914e-01f, -2.01853037e-01f, -1.39258072e-01f, -2.17049673e-01f, -9.41226259e-02f, -1.68947756e-01f, -2.20902532e-01f,
  -1.80458724e-01f, -1.03788026e-01f, 2.24341936e-02f, -6.08744994e-02f, 4.59182169e-03f, 5.84398955e-02f, -1.32581010e-01f, 5.51323779e-02f, 4.07172963e-02f, -1.23719633e-01f,
  -5.69073707e-02f, -2.63721421e-02f, -1.07706100e-01f, 2.68434901e-02f, -1.35702059e-01f, -4.86660898e-02f, 2.06086207e-02f, -6.02691621e-02f, -6.13760576e-02f, 1.12767825e-02f,
  -2.32107788e-02f, -1.55827314e-01f, -1.82334661e-01f, -2.12897994e-02f, 1.20227234e-02f, 4.75627184e-02f, 2.08498891e-02f, 5.03670275e-02f, 5.69355562e-02f, -5.17004170e-02f,
  -1.83259975e-02f, 3.48024815e-02f, 3.11062038e-02f, 4.68135104e-02f, 5.47135957e-02f, 1.77446858e-03f, -8.23880434e-02f, 1.16264448e-02f, -4.45342995e-03f, -1.13043897e-01f,
  1.85344890e-02f, 3.62555571e-02f, -4.71777236e-03f, -6.55051470e-02f, 2.02284823e-03f, 5.19217178e-02f, 1.27065601e-02f, 6.17534388e-03f, -2.17184946e-02f, 3.10648791e-02f,
  -1.25705466e-01f, 6.32756501e-02f, 2.48507895e-02f, -7.63006369e-03f, 2.93251667e-02f, -3.47281843e-02f, 7.79437274e-02f, 1.40900421e-03f, -4.95370962e-02f, 8.40691999e-02f,
  -1.75356761e-01f, 9.39606503e-02f, -1.36465892e-01f, 2.56371917e-04f, -5.98662272e-02f, -6.72826543e-02f, -2.39917580e-02f, 9.04937461e-02f, -9.52214301e-02f, -1.87758338e-02f,
  -8.48901719e-02f, -5.72986044e-02f, -1.50171891e-01f, -4.61889990e-02f, -3.58799733e-02f, -8.84855837e-02f, -3.42037380e-02f, -1.07201934e-01f, 9.42325126e-03f, -2.50199419e-02f,
  -7.82682598e-02f, -2.56318659e-01f, -2.97153652e-01f, -1.93672092e-03f, -6.39705732e-02f, -1.67560592e-01f, -1.33308679e-01f, -5.11613674e-03f, -8.25090799e-03f, -1.14624530e-01f,
  -2.29762986e-01f, -5.81428735e-03f, -7.18807010e-03f, -1.46857306e-01f, -7.62554258e-02f, -3.24975774e-02f, -8.36458951e-02f, -1.03505723e-01f, -1.31756604e-01f, 4.79195565e-02f,
  1.13603421e-01f, -2.67430376e-02f, -1.16713107e-01f, 4.74546365e-02f, -9.46139544e-02f, -2.44037248e-02f, 2.88760923e-02f, 5.32646775e-02f, -1.14452608e-01f, 1.35444030e-01f,
  1.74190030e-01f, -3.44026163e-02f, 2.83770170e-02f, -3.40409130e-02f, 1.02413557e-01f, 3.28138210e-02f, 1.41716274e-02f, 4.50032465e-02f, 4.16931473e-02f, 1.43243507e-01f,
  1.12234816e-01f, 7.21400138e-03f, -1.48678437e-01f, -1.36114145e-02f, -5.91600984e-02f, 4.08443063e-02f, -7.76806474e-02f, -1.12571307e-02f, -7.16826692e-02f, -1.72668248e-02f,
  1.59608833e-02f, 4.40410860e-02f, 5.05544916e-02f, -4.80857044e-02f, 2.65596248e-02f, -8.90324116e-02f, 2.28296164e-02f, -1.65147305e-01f, -2.01636050e-02f, 7.12787658e-02f,
  7.35019743e-02f, 2.54934896e-02f, -1.61605835e-01f, -1.30598336e-01f, -2.39077453e-02f, 4.11850819e-03f, -9.68036950e-02f, -4.28571552e-02f, -1.43850282e-01f, -1.24147721e-01f,
  2.37473827e-02f, 5.27463742e-02f, -8.83053467e-02f, -9.49811414e-02f, -4.98654172e-02f, -6.98631555e-02f, -2.44523212e-02f, 5.77969477e-02f, 1.13558825e-02f, -4.86898907e-02f,
  -6.47028461e-02f, 2.99207736e-02f, -2.10326128e-02f, -7.65600055e-02f, 1.62158664e-02f, -1.06010973e-01f, 7.28467256e-02f, 3.74800824e-02f, 4.54677902e-02f, -6.70355037e-02f,
  -6.75461739e-02f, 1.30321998e-02f, 2.93751787e-02f, 4.64843698e-02f, -2.49614827e-02f, -3.94591652e-02f, -1.39125511e-02f, -4.68935072e-02f, -1.15488037e-01f, 1.87505838e-02f,
  -2.36063048e-01f, -6.75595254e-02f, 3.00957169e-02f, -4.24892008e-02f, -4.99405898e-03f, -7.81231895e-02f, 2.12210324e-03f, -7.53222685e-03f, -1.07000612e-01f, -3.71776670e-02f,
  -3.31648765e-03f, -3.66151929e-02f, -3.16578671e-02f, 5.66440001e-02f, -2.54474245e-02f, -2.11784560e-02f, 1.37499403e-02f, -6.66499510e-02f, -8.57268721e-02f, -6.51687291e-03f,
  -1.47393942e-01f, -6.44821152e-02f, -2.63628632e-01f, -1.14003316e-01f, -1.67082682e-01f, -7.69234970e-02f, -1.39919877e-01f, -5.85347228e-02f, -2.19382882e-01f, -1.70242965e-01f,
  -9.76926506e-01f, 2.05055520e-01f, 2.50093609e-01f, -3.27090412e-01f, 8.56365636e-02f, 4.06025738e-01f, 4.23081666e-01f, 9.83721483e-03f, -1.26824155e-01f, 1.11652628e-01f,
  -1.94072835e-02f, -1.73432708e-01f, -2.25662142e-02f, -1.12629925e-04f, -2.95995045e-02f, 2.72762328e-01f, 2.76705354e-01f, -9.61210132e-02f, -2.60237277e-01f, -1.27111211e-01f,
  -1.13431737e-01f, -3.76476049e-01f, -4.71480846e-01f, -2.93568492e-01f, -1.11732520e-01f, -9.68377367e-02f, 7.61320964e-02f, -1.13966428e-01f, 1.88341662e-01f, -2.98559256e-02f,
  2.71419853e-01f, -1.23855151e-01f, -1.06151216e-01f, -1.52828619e-01f, 7.08487630e-02f, -1.33564711e-01f, 8.79242027e-04f, -8.31262693e-02f, -1.88512858e-02f, -9.85553768e-03f,
  -5.60560487e-02f, -8.71686563e-02f, -5.28865941e-02f, 3.94845270e-02f, -7.34020025e-02f, -5.89131303e-02f, -1.07341193e-01f, -1.77487135e-01f, 3.06330100e-02f, 1.46511151e-02f,
  6.68800548e-02f, 6.50485456e-02f, 6.33709952e-02f, 5.37672900e-02f, 6.20464273e-02f, 1.95061173e-02f, 1.10601105e-01f, 4.32565957e-02f, 4.26044352e-02f, -8.57263729e-02f,
  -4.53787781e-02f, 4.10328433e-02f, 3.99622805e-02f, 6.94654230e-03f, -9.12526324e-02f, 1.08914383e-01f, 3.61267664e-02f, -2.52301376e-02f, -7.41568208e-02f, -7.17844516e-02f,
  1.71298496e-02f, 7.34250769e-02f, -2.06214841e-02f, 2.63070017e-02f, 1.05440873e-03f, 1.21617233e-02f, 4.59582396e-02f, -1.17838923e-02f, 9.63203385e-02f, -1.85297392e-02f,
  -1.04399938e-02f, 6.00483129e-03f, -3.46495025e-02f, -3.04838587e-02f, 5.66947414e-03f, 3.40858959e-02f, -4.27672639e-02f, -4.54491377e-02f, -2.60033887e-02f, 2.08003842e-03f,
  -9.93790776e-02f, 6.19152337e-02f, -7.86572602e-03f, -1.48084685e-01f, 5.29236048e-02f, -4.99035530e-02f, 2.58221738e-02f, -3.12629677e-02f, -1.41549744e-02f, 5.94444573e-02f,
  4.90540490e-02f, -2.64002271e-02f, 6.76291734e-02f, 3.35364137e-03f, -8.82421434e-02f, 1.32400887e-02f, 1.30322641e-02f, -1.20254479e-01f, 4.51660492e-02f, 1.16312608e-01f,
  8.48150924e-02f, 7.18922988e-02f, -3.81842963e-02f, 1.10341355e-01f, 3.65259685e-02f, -7.69782737e-02f, 1.69037536e-01f, 3.76379192e-02f, 6.33633807e-02f, -9.37667862e-02f,
  2.28685692e-01f, 3.92483890e-01f, 9.24840719e-02f, 1.38463512e-01f, 1.56949297e-01f, 1.82429031e-01f, 3.75349402e-01f, 3.60042870e-01f, 1.98299974e-01f, 1.72931552e-01f,
  1.57724231e-01f, 2.41433859e-01f, 1.88489392e-01f, 2.18373388e-01f, 3.23038846e-01f, 1.99024662e-01f, 1.81426823e-01f, 1.00184947e-01f, 2.00485997e-02f, 8.43389556e-02f,
  1.79758936e-01f, 7.87280202e-02f, 1.67034138e-02f, -4.19301428e-02f, 1.33624822e-01f, 1.25645354e-01f, 9.51246533e-04f, 2.15304624e-02f, -8.13274924e-03f, 2.02121690e-01f,
  8.65972638e-02f, 1.67496279e-01f, 8.75761453e-03f, -7.07960352e-02f, -9.87885594e-02f, -1.01785928e-01f, 6.57281205e-02f, -1.90113515e-01f, -5.45411073e-02f, -8.82666036e-02f,
  -1.17474385e-01f, 1.26101011e-02f, 4.31263186e-02f, -1.16277829e-01f, -5.42825460e-02f, -1.12753041e-01f, -8.57917499e-03f, 1.24938324e-01f, 6.08609878e-02f, 8.91253259e-03f,
  6.54091761e-02f, -1.70086443e-01f, -8.63623992e-02f, -1.89442132e-02f, 1.82190284e-01f, -2.35700142e-02f, -7.64338151e-02f, -3.95282656e-02f, -6.06630258e-02f, 2.24027894e-02f,
  2.27354970e-02f, 6.81650192e-02f, -6.42682388e-02f, 8.15346465e-02f, 3.05800536e-03f, 5.00742644e-02f, 3.24978083e-02f, -3.96023951e-02f, 5.02064712e-02f, -1.26446247e-01f,
  6.14359183e-03f, 6.38934970e-02f, 5.80964144e-03f, -2.80507952e-02f, 3.70518416e-02f, -4.25961949e-02f, 1.92629583e-02f, -3.24675515e-02f, -3.08246911e-02f, -7.90057555e-02f,
  3.11195701e-02f, -9.04928222e-02f, -9.06129479e-02f, 4.92117135e-03f, -1.79900788e-02f, 7.01632276e-02f, -5.32094799e-02f, -1.23607591e-01f, 1.05725334e-03f, -9.48239416e-02f,
  -9.32692066e-02f, -8.48032162e-02f, 1.29573956e-01f, 1.41286448e-01f, -1.00356840e-01f, -1.11066192e-01f, 5.13509177e-02f, -2.21396945e-02f, -4.59172539e-02f, 8.15073773e-02f,
  -1.27823040e-01f, -2.14229170e-02f, 9.95562300e-02f, -6.68411329e-03f, -1.46775380e-01f, -1.21642455e-01f, 3.64880711e-02f, 9.67686623e-02f, 2.90427543e-02f, -6.76557375e-03f,
  -3.87585461e-02f, -1.35929540e-01f, -1.81908906e-01f, -2.48496309e-02f, -4.68384773e-02f, -1.10696167e-01f, -5.79560213e-02f, -1.09773152e-01f, -3.67704444e-02f, -1.43634334e-01f,
  -2.27354988e-01f, 2.36274004e-01f, 6.58739805e-02f, 2.36278623e-02f, -1.99336663e-01f, -2.95520723e-01f, -1.08128808e-01f, -1.93471849e-01f, -1.47352412e-01f, 1.18803740e-01f,
  1.04201145e-01f, -1.05937093e-01f, 1.29739583e-01f, -7.08874092e-02f, -2.70142376e-01f, 2.48890780e-02f, 6.06058091e-02f, -3.12297881e-01f, -3.16160709e-01f, -3.97143394e-01f,
  -1.25562236e-01f, -1.53646857e-01f, -2.40758881e-01f, -1.11489981e-01f, 7.18773305e-02f, 1.41088739e-01f, 2.11950406e-01f, 5.45312390e-02f, 6.22066334e-02f, 1.40993267e-01f,
  4.90728796e-01f, -1.33959845e-01f, -1.45168200e-01f, -3.89173115e-03f, -3.68544948e-03f, 2.69194581e-02f, -1.01666236e-02f, 5.08580133e-02f, -2.55501326e-02f, 5.95563417e-03f,
  1.26685221e-02f, -1.08828833e-02f, -1.66831389e-02f, 9.48826410e-03f, -1.45234883e-01f, -5.38030080e-03f, -8.45616236e-02f, -1.07625529e-01f, -1.53722120e-02f, 3.88265140e-02f,
  -4.15439233e-02f, -1.36591375e-01f, -1.06525876e-01f, 1.73391569e-02f, 2.30999012e-02f, -1.11800499e-01f, 8.24707374e-02f, 5.32720098e-03f, -8.57773796e-02f, 1.63216010e-01f,
  -4.16142792e-02f, 9.99544561e-02f, -6.89086467e-02f, -1.85457300e-02f, -2.14946065e-02f, 7.90236145e-03f, 5.00408486e-02f, 1.00728355e-01f, 1.23075582e-02f, 5.82799315e-02f,
  2.33714208e-02f, 2.32815072e-02f, 5.52324345e-03f, 2.00611241e-02f, 5.66892549e-02f, -6.48813099e-02f, 6.54499512e-03f, 8.19075629e-02f, -4.26580608e-02f, -3.25655229e-02f,
  -1.04938313e-01f, -9.09347013e-02f, 9.49598998e-02f, -1.68675836e-02f, 6.20802678e-03f, -1.78736181e-03f, -1.12833129e-02f, -7.83136562e-02f, -8.64842758e-02f, -7.39298314e-02f,
  4.63275075e-01f, -3.42175007e-01f, 1.79862812e-01f, -8.42018202e-02f, 9.77210030e-02f, 3.84289771e-02f, 1.35397553e-01f, -6.42574206e-02f, 7.75358900e-02f, 1.60008688e-02f,
  -6.06754161e-02f, -7.49835670e-02f, 9.79861841e-02f, -4.64203348e-03f, -5.08381911e-02f, -4.47176918e-02f, -1.21159405e-02f, 5.11855744e-02f, -9.05458331e-02f, 8.20112750e-02f,
  3.01194582e-02f, -1.06641583e-01f, 3.46962288e-02f, 9.61497799e-02f, 9.17506777e-03f, -1.14789501e-01f, 1.72808081e-01f, 8.27233717e-02f, 6.49554357e-02f, 2.69456565e-01f,
  4.02864397e-01f, 4.75952238e-01f, 2.37790719e-01f, -1.11061875e-02f, 5.38419150e-02f, 1.01581134e-01f, 1.41448915e-01f, 7.86680728e-02f, -1.11275777e-01f, 1.06593192e-01f,
  8.98842067e-02f, -1.42439723e-01f, -1.38698071e-01f, -1.29032537e-01f, -9.90449190e-02f, -2.03510299e-02f, -1.32472336e-01f, -8.35876241e-02f, -1.95171207e-01f, -1.60870969e-01f,
  -1.45279571e-01f, -4.95498814e-02f, 1.40790576e-02f, -3.60459322e-03f, 2.45065540e-02f, -1.45316064e-01f, 1.11776091e-01f, 2.20287621e-01f, 1.64426878e-01f, 2.06654910e-02f,
  -1.03592373e-01f, 4.05160218e-01f, -3.76095831e-01f, -2.05397345e-02f, 8.21314007e-02f, -9.12701935e-02f, 5.38231581e-02f, -6.06277250e-02f, 1.39718205e-02f, 3.67138907e-02f,
  -3.20559107e-02f, -7.51559660e-02f, -2.96139866e-02f, 3.42902057e-02f, -5.96262980e-03f, -4.86665592e-02f, -1.04019009e-02f, -3.72126140e-02f, -7.75353387e-02f, 2.08295137e-02f,
  6.76763281e-02f, 1.35533839e-01f, 1.95362434e-01f, -8.35679248e-02f, -3.37221026e-02f, -5.80680035e-02f, 4.30615395e-02f, 9.02912393e-02f, 9.49491784e-02f, -5.97762764e-02f,
  -1.51612163e-01f, -2.72812787e-02f, 3.37533909e-03f, -5.65341376e-02f, -2.96659525e-02f, -9.85964611e-02f, -4.84724157e-03f, -7.34828040e-02f, 3.53567163e-03f, 2.42663063e-02f,
  -1.27429873e-01f, -1.34759462e-02f, -1.09653577e-01f, -7.26319999e-02f, -8.80092382e-02f, 2.71421112e-02f, 2.76247934e-02f, -9.16756541e-02f, 7.86468461e-02f, 5.47091439e-02f,
  -9.15902033e-02f, -7.24372789e-02f, 3.33164260e-02f, -3.10598798e-02f, 2.62671094e-02f, 3.48000526e-02f, -7.39901653e-03f, -1.15416024e-03f, 4.68420200e-02f, -2.64748503e-02f,
  -2.72593617e-01f, 2.99824793e-02f, -1.47748634e-01f, -7.56451935e-02f, 1.37782812e-01f, 6.74186572e-02f, 2.35994067e-02f, -5.49909361e-02f, 6.22149296e-02f, -4.09180187e-02f,
  1.12428837e-01f, 5.66373467e-02f, 1.17718413e-01f, -2.59799697e-02f, -1.42445818e-01f, -8.12990144e-02f, 4.04493436e-02f, -7.40465298e-02f, 2.04885155e-02f, 8.94195586e-02f,
  -1.64663754e-02f, -4.74966690e-02f, -1.65304542e-01f, -1.01270497e-01f, 2.76858062e-02f, -1.35936320e-01f, -6.14729933e-02f, -1.48068428e-01f, -1.27042100e-01f, -1.04365781e-01f,
  -3.98228317e-02f, 3.39272261e-01f, 1.48806825e-01f, -4.79132533e-02f, -9.30357277e-02f, -1.62284076e-01f, 1.23830073e-01f, 7.31399432e-02f, 8.34178329e-02f, -1.43494522e-02f,
  -1.34128019e-01f, -1.71075761e-01f, 3.88962068e-02f, 7.34260753e-02f, 1.19722582e-01f, 1.76202774e-01f, 1.48644924e-01f, 7.77106434e-02f, -8.50581974e-02f, -1.48155794e-01f,
  1.03168963e-02f, 8.60522017e-02f, -1.04011344e-02f, 2.66440492e-02f, 9.61841121e-02f, -9.19887144e-03f, 9.69552696e-02f, 4.16351371e-02f, 3.14902253e-02f, 1.74286440e-01f,
  -1.94413453e-01f, -2.90687531e-02f, -1.89249039e-01f, -1.11889377e-01f, -3.55480500e-02f, 7.86869302e-02f, -2.08372883e-02f, 8.47629383e-02f, -1.01647235e-01f, 5.15636168e-02f,
  -3.96661721e-02f, -2.27390714e-02f, -1.77335124e-02f, 9.92360935e-02f, -2.94308700e-02f, -1.51284765e-02f, 8.23415071e-02f, 1.76472709e-01f, -2.45234650e-02f, -4.12748307e-02f,
  -1.16735809e-01f, -8.17124471e-02f, -6.34437054e-02f, -5.38964123e-02f, 1.41719962e-02f, -2.09947303e-01f, 2.34910380e-02f, 1.18369861e-02f, -9.68901217e-02f, 1.18417099e-01f,
  -6.07625805e-02f, -2.16356274e-02f, -6.58656955e-02f, 1.00234011e-02f, -4.50186292e-03f, 2.68655643e-02f, 7.81758726e-02f, -1.66054033e-02f, -1.83700658e-02f, 8.56871307e-02f,
  3.73500660e-02f, -6.11942708e-02f, -3.37519660e-03f, 1.92179624e-02f, -2.11398024e-02f, 4.71090898e-02f, -4.51811254e-02f, -1.39022199e-03f, -2.72200909e-02f, 1.41914329e-02f,
  -3.09077483e-02f, -5.38227111e-02f, -2.16675270e-02f, 6.78160647e-03f, 3.95641103e-02f, 1.03247143e-01f, -2.84623280e-02f, 1.82889495e-02f, -2.41885129e-02f, 8.21750835e-02f,
  -9.17722955e-02f, -1.32969826e-01f, -1.23572454e-01f, 9.95012596e-02f, -9.97977629e-02f, -5.05554304e-02f, -1.35189489e-01f, 4.85990644e-02f, -8.69141370e-02f, 5.01116589e-02f,
  -1.07660942e-01f, -2.52099000e-02f, 3.63920107e-02f, 4.64617759e-02f, -1.68558106e-01f, 9.92538501e-03f, 2.30355710e-02f, 7.00646192e-02f, -2.12625302e-02f, -8.22872221e-02f,
  -7.64695462e-03f, -4.46553044e-02f, -1.94040537e-01f, -1.26055792e-01f, -4.45485041e-02f, -1.13384210e-01f, -1.31028071e-01f, -1.60084486e-01f, -8.13202709e-02f, -2.25946456e-02f,
  -8.35051596e-01f, -1.00516602e-01f, -3.62252295e-01f, -1.48129642e-01f, 1.56064510e-01f, 1.74319521e-01f, 2.28276029e-01f, 9.18196738e-02f, 4.49590720e-02f, -4.01969859e-03f,
  -1.99186847e-01f, -1.14412487e-01f, -4.29861881e-02f, 8.44893530e-02f, 1.15999758e-01f, 2.03484982e-01f, 2.75750309e-01f, 2.34211758e-02f, 4.12519872e-02f, 6.41834810e-02f,
  2.59391129e-01f, -1.64043400e-02f, -4.86038961e-02f, -1.71767212e-02f, 8.68210271e-02f, -5.89715666e-04f, -3.70899178e-02f, -4.09587547e-02f, 4.90975417e-02f, 3.90858725e-02f,
  -5.30696630e-01f, -4.73352730e-01f, 3.09237633e-02f, 1.24486126e-01f, -9.53525528e-02f, -1.07885666e-01f, -7.86883608e-02f, -1.56313539e-01f, -1.00692891e-01f, -1.12545505e-01f,
  -1.00550488e-01f, -2.39860378e-02f, -4.87121865e-02f, 3.26060280e-02f, -1.08469374e-01f, -6.18410781e-02f, -1.98655706e-02f, -2.21888293e-02f, -1.14238206e-02f, -1.66675210e-01f,
  1.60572097e-01f, -1.36267051e-01f, -1.67189106e-01f, 2.11588833e-02f, -1.06132977e-01f, -4.03751172e-02f, -2.11493924e-01f, -1.46953106e-01f, -2.11972401e-01f, -2.41908804e-01f,
  8.04638490e-02f, -3.97342853e-02f, 2.63013504e-02f, 5.32857850e-02f, 5.92863783e-02f, -6.84902668e-02f, -5.56599861e-03f, 8.78258198e-02f, 5.20152673e-02f, 7.76483491e-02f,
  -7.98610076e-02f, -3.37583981e-02f, -5.50027238e-03f, -7.55529776e-02f, 2.48400234e-02f, 7.42025599e-02f, 6.35566413e-02f, 1.72110170e-01f, -4.50885594e-02f, 4.50876681e-03f,
  -7.91633576e-02f, -3.41937155e-03f, -4.47959155e-02f, 5.67368306e-02f, 8.45716521e-02f, 3.91325355e-02f, 1.06844641e-01f, -4.38881703e-02f, -4.37616669e-02f, 2.92657583e-04f,
  -8.39234591e-02f, 1.67811185e-01f, -1.37866959e-01f, 3.22867595e-02f, -2.58044200e-03f, -4.00563283e-03f, -6.91315206e-03f, -1.22122057e-01f, -1.21651366e-01f, -3.79821137e-02f,
  -1.76621433e-02f, -1.01538830e-01f, -9.24722552e-02f, 2.36467458e-02f, -2.84493132e-03f, -1.80532988e-02f, 5.89362420e-02f, 1.91311426e-02f, 5.31330518e-02f, -1.00090347e-01f,
  1.18848816e-01f, 1.35421362e-02f, -1.80762023e-01f, -9.69496071e-02f, -5.62845282e-02f, -1.33302808e-01f, -1.69476733e-01f, -1.91895545e-01f, -2.04526663e-01f, -1.15616783e-01f,
  -7.60407606e-03f, 2.25742474e-01f, 1.12374201e-01f, 3.57535556e-02f, -4.03443314e-02f, 1.69329658e-01f, 1.61646292e-01f, 4.40800376e-03f, -7.14406446e-02f, -1.08987376e-01f,
  -1.83661319e-02f, -2.17910185e-02f, 3.02677993e-02f, -3.53226326e-02f, -1.46054095e-02f, 3.72359157e-02f, -3.47094648e-02f, -3.85021791e-02f, 6.89511281e-03f, -4.56724688e-03f,
  -1.15251951e-01f, -2.18250118e-02f, 5.56364134e-02f, 1.77592691e-02f, 1.45446416e-02f, -8.21903124e-02f, 1.05051078e-01f, -3.63018480e-03f, -8.77217948e-02f, -1.40590504e-01f,
  2.12282911e-01f, 1.90809965e-01f, -4.74433564e-02f, -1.32435426e-01f, 6.88137114e-02f, -4.60818894e-02f, 5.59576824e-02f, -2.90698186e-02f, 1.52126476e-02f, -1.38528887e-02f,
  -9.88877863e-02f, 2.18822714e-02f, -4.88931686e-02f, -2.71876045e-02f, -3.14540416e-02f, -8.00784901e-02f, -2.02359725e-02f, -3.50835957e-02f, 1.86457597e-02f, -1.40163908e-02f,
  -2.95288581e-02f, 4.72793058e-02f, 1.57434508e-01f, 1.00547925e-01f, -7.56192952e-02f, -2.10335292e-02f, 9.86394584e-02f, -6.02852143e-02f, 8.68502930e-02f, -5.22016175e-02f,
  -8.64885673e-02f, -4.85682301e-02f, -3.97415869e-02f, 5.44269085e-02f, 4.91078906e-02f, -2.51864064e-02f, 1.47299911e-03f, 6.12332821e-02f, 5.84109835e-02f, 5.51396348e-02f,
  -4.75237668e-02f, 5.86572737e-02f, 1.72221456e-02f, 1.07838526e-01f, -6.72199056e-02f, 1.26684397e-01f, -2.06268653e-02f, 3.68203297e-02f, 2.35288087e-02f, 6.64943873e-05f,
  1.45466411e-02f, 8.74579605e-03f, 4.97789867e-02f, 6.02354715e-03f, -9.94240940e-02f, 6.85999990e-02f, 4.91253100e-02f, -7.20927492e-02f, 9.10661444e-02f, -1.55139031e-04f,
  1.16104543e-01f, 1.44673392e-01f, -1.58229023e-01f, -1.44979346e-03f, 4.31326330e-02f, 1.43278996e-03f, 4.90979198e-03f, 1.42105063e-02f, -8.13119113e-02f, -9.16722938e-02f,
  7.21325576e-02f, 8.92176777e-02f, 2.29110178e-02f, 4.50642109e-02f, -6.92276359e-02f, -3.04473471e-02f, 2.19533630e-02f, 3.69984023e-02f, -8.17696303e-02f, -7.00099692e-02f,
  -4.39640507e-02f, 1.59377810e-02f, 3.02215572e-03f, 1.84261408e-02f, 7.50792352e-03f, -9.56351534e-02f, 5.78346848e-02f, -2.49212366e-02f, -4.28662337e-02f, -9.22444090e-02f,
  5.15244782e-01f, -1.35529414e-01f, -7.29245618e-02f, 2.62825817e-01f, 3.14343840e-01f, 2.96787888e-01f, 2.82892972e-01f, 1.45533741e-01f, 3.61082971e-01f, 3.16295847e-02f,
  -8.01921114e-02f, -9.95109007e-02f, -1.02611631e-01f, -1.58467695e-01f, -9.88317430e-02f, 4.55394015e-02f, 1.66456342e-01f, -5.20247631e-02f, 1.43147379e-01f, -2.29917709e-02f,
  7.12807998e-02f, 1.36481017e-01f, 4.13283929e-02f, 1.16619179e-02f, -1.20250225e-01f, 2.51699686e-02f, -1.14981912e-01f, -5.17636612e-02f, -1.89767480e-01f, -1.21575847e-01f,
  -4.06780422e-01f, -2.52456516e-01f, 1.05692707e-01f, -1.52576789e-01f, -1.94596738e-01f, 2.94475071e-03f, 3.60861719e-02f, -1.83713436e-02f, -7.25442320e-02f, 1.35936365e-02f,
  -1.70580685e-01f, -4.19099554e-02f, -6.18604161e-02f, -2.33304445e-02f, 1.97434556e-02f, -6.57312125e-02f, -3.10801324e-02f, -1.52805597e-01f, -1.50201291e-01f, -2.47057006e-01f,
  -1.33685544e-01f, -1.00422904e-01f, -4.91154343e-02f, 4.67354059e-02f, -1.68413207e-01f, -6.10108338e-02f, -2.35889703e-01f, -2.32591778e-01f, -5.14003672e-02f, 6.08428381e-02f,
  6.57680351e-03f, 1.76874120e-02f, -8.44422504e-02f, -1.31077804e-02f, -1.02349622e-02f, 9.22913253e-02f, 4.50982116e-02f, 2.86728959e-03f, 8.73940252e-03f, 5.55218942e-03f,
  7.74598047e-02f, 2.11420450e-02f, 2.92757130e-03f, 7.10312277e-02f, -5.11769801e-02f, 2.65567284e-02f, -6.93086907e-03f, -7.60163441e-02f, -4.49323654e-02f, 4.78311963e-02f,
  2.97649167e-02f, -5.83089367e-02f, 2.00880505e-02f, -1.75086975e-01f, -3.76340635e-02f, -4.61923964e-02f, -8.87038652e-03f, -1.51517580e-03f, -4.58897427e-02f, 5.87723739e-02f,
  1.88558206e-01f, -7.08062127e-02f, 1.74005002e-01f, 1.34618953e-02f, 1.25213740e-02f, -1.01089485e-01f, -4.84686196e-02f, -9.39144120e-02f, -6.71989843e-02f, 4.78861891e-02f,
  -1.57107741e-01f, -1.24595545e-01f, -6.51146770e-02f, -8.12108368e-02f, 1.50710016e-01f, 1.44372433e-01f, 7.62101635e-02f, 7.78635219e-02f, -4.52645682e-02f, -4.96346131e-02f,
  3.67563851e-02f, 2.78900951e-01f, 3.81083220e-01f, 2.25645691e-01f, 6.55809194e-02f, 2.79353142e-01f, 1.60825804e-01f, 7.06508681e-02f, 2.25309268e-01f, 5.40763915e-01f,
  2.07567155e-01f, 3.64960700e-01f, 3.40860188e-01f, 3.40949222e-02f, 1.26527473e-01f, 3.31266403e-01f, 4.46020335e-01f, 1.96764573e-01f, 8.98266025e-03f, 1.56493679e-01f,
  8.18669274e-02f, -2.82200992e-01f, -2.73672014e-01f, -2.66829491e-01f, -7.89899961e-04f, 1.77343279e-01f, 2.29878277e-02f, -2.90175565e-02f, -8.25304464e-02f, -4.01455015e-02f,
  -9.46204439e-02f, -8.73648897e-02f, -3.00202984e-02f, -2.76424224e-03f, -8.80572423e-02f, -2.96815157e-01f, 1.20303027e-01f, 3.19870189e-02f, 1.48568340e-02f, -2.01773033e-01f,
  -1.18286416e-01f, 3.39621753e-01f, -1.59194425e-01f, -2.69914508e-01f, -8.11034814e-02f, 4.48461026e-02f, 1.32032037e-02f, 5.54617569e-02f, 6.01683697e-03f, 1.00284345e-01f,
  2.58302391e-02f, 2.98453476e-02f, 5.75349070e-02f, 6.03556521e-02f, 5.11310063e-02f, 1.61023568e-02f, 1.26239315e-01f, 1.03002697e-01f, -4.27826457e-02f, -3.00228056e-02f,
  -1.04079843e-01f, 7.12380782e-02f, 1.75228596e-01f, 4.74261381e-02f, 4.62853871e-02f, -9.60713997e-02f, 4.18643430e-02f, 4.11105566e-02f, 6.28288761e-02f, -5.90600483e-02f,
  -6.86140582e-02f, 1.31092519e-02f, -7.42102563e-02f, -2.61665732e-02f, -4.01657745e-02f, 1.04207313e-02f, -2.17099898e-02f, 4.97202687e-02f, 2.61024926e-02f, 4.04791869e-02f,
  3.48609984e-02f, 2.98427627e-03f, 3.76864411e-02f, -3.37355807e-02f, -1.11008599e-01f, 5.71884634e-03f, 6.07070699e-02f, 2.42118146e-02f, -1.61649063e-02f, -4.93705198e-02f,
  -1.14102545e-03f, 1.15460515e-01f, 6.34805113e-02f, 2.65883021e-02f, 4.17033732e-02f, -6.49569109e-02f, 5.43422364e-02f, -4.02394347e-02f, -1.90580301e-02f, 9.67801213e-02f,
  -9.19105709e-02f, -3.96133214e-02f, -2.73993194e-01f, -1.00303933e-01f, -1.27223302e-02f, 3.28819104e-03f, -8.90191048e-02f, 5.46157639e-03f, 8.41427594e-02f, 1.41833397e-02f,
  1.04335867e-01f, -5.15630422e-03f, 1.32981353e-02f, -7.31780082e-02f, 5.85727878e-02f, -1.72316823e-02f, -1.22150732e-02f, -8.09037015e-02f, -2.17130035e-02f, 7.22023845e-02f,
  4.92118597e-02f, 3.63838375e-02f, 6.61752969e-02f, 5.97286113e-02f, -6.24409020e-02f, -2.30313659e-01f, 9.40547213e-02f, -9.73251238e-02f, -7.11491555e-02f, 1.16854254e-02f,
  3.86019468e-01f, 1.10006042e-01f, 1.23864718e-01f, 7.08619207e-02f, 1.71902329e-01f, 2.83449054e-01f, 3.22854102e-01f, 2.25907028e-01f, 1.02754347e-01f, 1.59550205e-01f,
  2.49219537e-01f, 1.98439538e-01f, 1.19357333e-02f, 2.41982266e-02f, 1.55366629e-01f, -7.47097209e-02f, -6.60101771e-02f, -1.39262334e-01f, 1.38978742e-03f, 7.04878271e-02f,
  -1.55440390e-01f, -1.36218131e-01f, 2.16846988e-02f, -8.95407870e-02f, -6.71463236e-02f, -1.60144180e-01f, -1.29060159e-02f, -1.13585792e-01f, 5.51644526e-02f, -1.62522599e-01f,
  4.52995785e-02f, 1.75185233e-01f, -2.72789188e-02f, -2.46136412e-02f, 3.95426229e-02f, -2.54859105e-02f, -2.75770742e-02f, -1.50874287e-01f, -1.61576364e-02f, -1.73998192e-01f,
  -6.27243286e-03f, 1.99401807e-02f, 3.46304290e-02f, -1.20278716e-01f, 5.56658097e-02f, 7.82430544e-02f, -9.40692145e-03f, -3.18327881e-02f, -8.67277831e-02f, 5.86893074e-02f,
  -8.19814727e-02f, -2.66172457e-02f, 1.55887812e-01f, -1.15969442e-02f, 1.42039498e-02f, -3.09900776e-03f, 1.14487320e-01f, 1.40538532e-02f, -5.01456074e-02f, -4.20535617e-02f,
  -4.29599434e-02f, 1.04582392e-01f, 1.13918789e-01f, 5.16443029e-02f, 4.48075160e-02f, -5.25716618e-02f, -2.50138678e-02f, -4.54420336e-02f, 9.01345611e-02f, -6.35006353e-02f,
  2.30216999e-02f, 4.87242378e-02f, -1.98408701e-02f, -3.72533426e-02f, -4.48080041e-02f, -3.23149860e-02f, 5.53791784e-02f, 6.90791011e-02f, 5.32095656e-02f, -2.41563004e-03f,
  9.85737443e-02f, -3.12004238e-02f, -2.58823857e-02f, 3.10975816e-02f, 5.81889153e-02f, -1.64712667e-02f, -7.78329298e-02f, -1.08823124e-02f, 1.41659021e-01f, 4.68417108e-02f,
  -1.61082178e-01f, 2.51010865e-01f, -5.47854230e-02f, -7.92345628e-02f, 2.63278484e-02f, -3.45879234e-02f, 3.66669074e-02f, -3.70888859e-02f, -6.38892949e-02f, -2.65886225e-02f,
  4.61743288e-02f, -2.57168375e-02f, -1.34770479e-02f, 7.77549902e-03f, -6.47552535e-02f, -4.56464663e-03f, 9.86899063e-03f, -5.09908535e-02f, -7.50035886e-03f, -4.50107967e-03f,
  -4.28169556e-02f, 1.13236625e-02f, -2.20238119e-02f, -1.02268957e-01f, -2.79227719e-02f, -1.66727006e-02f, -6.38861060e-02f, 2.97969561e-02f, 9.50786099e-02f, -1.62620023e-01f,
  4.89884406e-01f, 7.84822777e-02f, 1.15490414e-01f, 2.00013757e-01f, 3.59107964e-02f, -1.46372736e-01f, -2.93280631e-01f, -2.21158624e-01f, 1.91235282e-02f, 1.68064341e-01f,
  2.99869210e-01f, 1.81729451e-01f, 8.34699497e-02f, 5.99126220e-02f, -2.76922639e-02f, -8.73708576e-02f, -1.66659504e-02f, 1.01272620e-01f, -2.05250569e-02f, 1.57129820e-02f,
  4.68452461e-02f, 5.68687506e-02f, 5.60839241e-03f, -5.71896434e-02f, 2.38593757e-01f, 1.11205474e-01f, 3.61912213e-02f, 6.87150732e-02f, 9.39019322e-02f, 3.13762426e-01f,
  4.47700381e-01f, 2.43062630e-01f, -3.91931795e-02f, -2.57771201e-02f, 5.59871532e-02f, -2.14644548e-04f, 1.40202746e-01f, 1.65285002e-02f, -8.46302509e-02f, -1.33755744e-01f,
  -1.03879999e-02f, 5.62066473e-02f, 3.55287492e-02f, -7.44035468e-02f, -4.13461290e-02f, -1.89320501e-02f, -1.28487945e-01f, 9.83772520e-03f, -9.38626006e-02f, 4.76667956e-02f,
  -4.13536727e-02f, 1.17709801e-01f, 6.61066221e-03f, -6.91789240e-02f, -4.57246900e-02f, 1.03893392e-01f, -5.26993684e-02f, 1.11529954e-01f, 5.92291616e-02f, 4.20269296e-02f,
  1.33121209e-02f, 1.42100021e-01f, 3.21544372e-02f, 9.78158191e-02f, -3.72740207e-03f, 8.27274099e-02f, -4.89736758e-02f, 3.43329795e-02f, -3.85200605e-02f, 6.55012876e-02f,
  -5.38173355e-02f, 1.12818852e-01f, -8.32789466e-02f, 3.57778221e-02f, 9.35130343e-02f, 7.63242245e-02f, 5.33189019e-03f, 3.80721204e-02f, -4.64274287e-02f, 1.62903108e-02f,
  -2.29966883e-02f, 5.91893084e-02f, 1.50826260e-01f, -7.19081163e-02f, 9.20429379e-02f, 2.87136034e-04f, 1.18822843e-01f, 6.87956735e-02f, 1.50663760e-02f, 6.13409355e-02f,
  -1.13478132e-01f, -3.24099064e-01f, 1.59141839e-01f, 2.04437133e-02f, 7.51665533e-02f, 7.48115173e-03f, 5.67794442e-02f, -3.80227491e-02f, -2.39812001e-03f, -1.32134547e-02f,
  6.43756613e-02f, 6.12931326e-02f, 1.53324706e-02f, -1.54583767e-01f, -4.20171693e-02f, -6.56619295e-02f, -1.11517020e-01f, 6.86333328e-02f, -1.72174409e-01f, -7.99297616e-02f,
  -6.95001855e-02f, -7.87936822e-02f, 6.79097744e-03f, -1.65867418e-01f, -9.60154366e-03f, 4.18906435e-02f, -5.60819767e-02f, 3.36360629e-03f, -1.49726108e-01f, -1.38465092e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.40307474e-01f, 1.47124529e-01f, 2.16264278e-01f, 3.96136463e-01f, 1.60590798e-01f, 3.49811792e-01f, 2.90426791e-01f, 2.09724993e-01f, 4.03796703e-01f, 1.69974357e-01f,
  4.53651249e-01f, 3.32109690e-01f, 4.22075093e-02f, 4.78160739e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -6.66633010e-01f, -5.48395216e-01f, 1.76354364e-01f, -5.65812588e-01f, -5.05779207e-01f, -1.14142753e-01f, 1.60467923e-01f, -1.98389485e-01f, -4.55916435e-01f, -1.32998526e-01f,
  9.69022438e-02f, 2.53793180e-01f, 3.10751110e-01f, -4.19984370e-01f, -1.93499029e-01f, 1.44974798e-01f, -1.47606984e-01f, 2.09569484e-01f, 8.06120574e-01f, 5.49198627e-01f,
  3.09098884e-02f, -5.32538116e-01f, -1.48118034e-01f, -6.38965786e-01f, -2.22825468e-01f, -3.37770075e-01f, 1.38985440e-01f, -4.78692576e-02f, -2.55871445e-01f, 1.27076849e-01f,
  1.68342710e-01f, -2.87325472e-01f, -7.21308812e-02f, 1.93109199e-01f, 3.62141617e-03f, 3.34421873e-01f, 4.83581066e-01f, 3.03540170e-01f, -6.12506941e-02f, -2.19709367e-01f,
  -6.31052077e-01f, -3.13632935e-01f, 3.95874828e-01f, 1.07578814e+00f, -4.23681676e-01f, 2.13206023e-01f, -5.41385591e-01f, -3.63279790e-01f, -4.08931702e-01f, 4.04353470e-01f,
  9.36926425e-01f, -2.26033200e-02f, -4.08799320e-01f, -4.82138395e-01f, 5.78386903e-01f, -4.57376033e-01f, -1.86464727e-01f, -3.47864002e-01f, -5.65276384e-01f, -5.22739701e-02f,
  3.39575380e-01f, -3.53750557e-01f, 5.27261734e-01f, 4.24993098e-01f, 5.37847161e-01f, 1.58640623e-01f, 1.68226168e-01f, 6.45526290e-01f, -5.03485017e-02f, 3.85811031e-01f,
  6.59038901e-01f, 3.75200182e-01f, -2.94828773e-01f, 7.21221864e-02f, 2.07676828e-01f, 7.20870316e-01f, 1.34167627e-01f, 9.64858532e-01f, 2.12594554e-01f, -2.81470269e-01f,
  5.45787692e-01f, 9.67571735e-01f, -6.72316015e-01f, 1.85696617e-01f, 3.56785953e-02f, -2.52556503e-01f, -3.76151621e-01f, -2.16309130e-01f, -1.02689341e-01f, 6.02304563e-02f,
  3.86665910e-01f, 3.36910225e-02f, -4.35134858e-01f, -1.00926913e-01f, -2.82509565e-01f, -2.37079740e-01f, 9.60609242e-02f, -1.58547923e-01f, 8.26803222e-02f, 2.45519236e-01f,
  -5.50095677e-01f, -3.04950356e-01f, -2.31805056e-01f, -2.33849555e-01f, 1.14467286e-01f, -3.79454970e-01f, 2.10183114e-01f, -3.88592184e-02f, 3.36454183e-01f, 3.50834653e-02f,
  -5.57062626e-01f, -3.24622691e-01f, -5.30847669e-01f, 1.35472700e-01f, -8.77631664e-01f, 6.45866275e-01f, 2.43528321e-01f, 1.10198760e+00f, -1.52319834e-01f, -1.49694324e-01f,
  5.87805770e-02f, -1.86201468e-01f, 3.39502752e-01f, -1.26942143e-01f, -2.40775123e-01f, 3.03204924e-01f, 1.40406221e-01f, -3.53097111e-01f, 1.93720505e-01f, 2.12120041e-01f,
  -4.77264374e-01f, -9.55412030e-01f, -4.22300309e-01f, 3.12808156e-01f, 1.14134490e-01f, 1.17999598e-01f, -3.26100178e-02f, -1.95823729e-01f, 4.45913792e-01f, -8.01326513e-01f,
  5.41071780e-03f, -6.73269510e-01f, 2.62398779e-01f, -4.91863370e-01f, 3.68826866e-01f, 1.96066856e-01f, -1.93432018e-01f, 6.41613483e-01f, -1.46077517e-02f, 2.28287980e-01f,
  7.31383190e-02f, 6.29653335e-01f, 3.06142688e-01f, -4.81569283e-02f, -4.57598120e-01f, -5.19210426e-03f, -2.22910956e-01f, 2.96268851e-01f, 5.97220361e-02f, 2.88773388e-01f,
  4.22156602e-01f, 5.08202970e-01f, 5.65253273e-02f, 3.70952994e-01f, 1.84318617e-01f, 3.75650257e-01f, 3.39559674e-01f, -3.45926672e-01f, 4.49574977e-01f, 2.23185748e-01f,
  -3.41939569e-01f, -6.56558514e-01f, 1.71138182e-01f, -4.82444406e-01f, 5.71922243e-01f, 1.36190161e-01f, -4.36733663e-01f, 9.29447543e-03f, 8.88045192e-01f, -8.83412883e-02f,
  -2.65409917e-01f, -4.62508321e-01f, 1.44984394e-01f, 2.31972307e-01f, -6.24438226e-02f, -3.51617076e-02f, 1.08775437e-01f, -1.03210375e-01f, 5.91777205e-01f, 1.70573831e-01f,
  -2.54332721e-02f, -2.58614302e-01f, -9.72533762e-01f, 2.62334228e-01f, -5.41137997e-03f, 2.91956514e-01f, -6.16265416e-01f, -5.24487913e-01f, 1.29251955e-02f, 1.08858079e-01f,
  5.43586493e-01f, 7.56757021e-01f, -6.28366172e-02f, -5.52595615e-01f, -3.84820074e-01f, 7.57130444e-01f, 4.04503345e-01f, 3.42249274e-01f, 1.22155271e-01f, -1.80992112e-01f,
  -4.59973484e-01f, -4.80341196e-01f, 8.16756710e-02f, -3.78675252e-01f, 2.91354060e-01f, -1.97958276e-02f, 3.34002793e-01f, 5.24991035e-01f, -5.73301554e-01f, -4.98156026e-02f,
  -3.59723836e-01f, -6.43955991e-02f, -3.28887701e-01f, 3.51869911e-01f, -1.72437266e-01f, -8.82855430e-02f, -3.66631538e-01f, -3.21938694e-01f, 7.87222162e-02f, -2.93508559e-01f,
  -3.17515880e-01f, 2.40223985e-02f, -2.45636001e-01f, -9.43068638e-02f, -2.17400655e-01f, -8.25924799e-02f, -3.72369796e-01f, -1.41141668e-01f, 1.69355407e-01f, 3.58906001e-01f,
  1.52908638e-01f, -1.54571161e-01f, -2.83316642e-01f, -1.19460911e-01f, 2.08032336e-02f, 4.97693509e-01f, 5.92444837e-01f, 3.37147079e-02f, -2.16910675e-01f, 3.92855555e-01f,
  9.80628192e-01f, -4.99165544e-05f, 2.03430817e-01f, -1.92402482e-01f, -2.19719663e-01f, -5.68503916e-01f, 2.68646508e-01f, -3.96199197e-01f, -4.27535206e-01f, -2.20462114e-01f,
  -3.64682684e-03f, 1.14216402e-01f, 1.11699246e-01f, 2.78131694e-01f, 2.67739952e-01f, 4.82092172e-01f, -6.23696327e-01f, 6.85182929e-01f, -6.50106847e-01f, 4.02511805e-01f,
  -2.96527207e-01f, 4.69267398e-01f, -3.22424829e-01f, -4.73119020e-01f, -2.51975685e-01f, -4.86518115e-01f, -2.40061224e-01f, -3.55530232e-02f, -4.33727473e-01f, -2.38278791e-01f,
  -2.19879985e-01f, -2.96630919e-01f, -3.68647054e-02f, -4.91876863e-02f, 1.06655192e+00f, 3.11235398e-01f, -1.42621621e-01f, 1.57084540e-01f, 7.09874928e-01f, 2.74721891e-01f,
  2.43412048e-01f, -5.28823376e-01f, 5.81731737e-01f, -1.06796585e-02f, -1.25399858e-01f, -4.49166074e-02f, 6.89671859e-02f, -9.80431400e-03f, -6.51809871e-02f, -4.71293300e-01f,
  9.61040139e-01f, 4.10803765e-01f, 7.23345935e-01f, 7.17621028e-01f, 2.87934631e-01f, -6.07367992e-01f, -3.23646396e-01f, -2.33758211e-01f, 4.82498527e-01f, -2.76366889e-01f,
  -1.69181582e-02f, 1.82492584e-01f, 1.83950722e-01f, -1.05166845e-01f, 6.47665784e-02f, -1.75125048e-01f, -4.40247476e-01f, -6.27984166e-01f, -2.14958355e-01f, 7.29305506e-01f,
  -4.95905131e-01f, -7.96236396e-02f, 2.28472397e-01f, 2.99361914e-01f, 3.63862157e-01f, -7.26114392e-01f, -4.09961820e-01f, 2.35721692e-01f, 1.92020848e-01f, -5.09043574e-01f,
  -6.96915269e-01f, -1.65404230e-01f, -4.50688690e-01f, -2.11261183e-01f, -5.87228417e-01f, -3.93267453e-01f, 9.32620652e-03f, -7.16952682e-01f, 2.98697978e-01f, -2.42125914e-01f,
  -2.74436752e-04f, 3.81150514e-01f, -3.01297158e-01f, 7.38568127e-01f, -4.53047335e-01f, -1.60233930e-01f, -2.77028203e-01f, 2.39700064e-01f, -7.32242540e-02f, -4.05017957e-02f,
  -1.59721877e-02f, 1.45084992e-01f, -2.37469584e-01f, 9.62797403e-02f, 3.04736853e-01f, 2.14825138e-01f, 7.33799115e-02f, 5.29874265e-02f, -1.02995433e-01f, -2.00300384e-02f,
  -1.64019972e-01f, 4.82047707e-01f, 1.12029001e-01f, 3.91906291e-01f, 1.18943639e-01f, -8.31547797e-01f, 2.42318541e-01f, 1.87921241e-01f, 3.04947495e-01f, -2.85406440e-01f,
  -2.92695552e-01f, -3.31058353e-01f, -1.18291743e-01f, 8.13863575e-02f, -1.23545546e-02f, -1.46923035e-01f, 9.24306750e-01f, 1.34012057e-03f, -5.03320098e-01f, 4.97164637e-01f,
  -2.38805160e-01f, 8.59843493e-01f, 4.83012259e-01f, -4.38545644e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.67918041e-01f, 1.23636601e-02f, 4.47010875e-01f, 1.29753994e-02f, 1.74150214e-01f, -1.16891935e-01f, 1.64478630e-01f, -3.93711209e-01f, -4.31484357e-02f, 2.07938358e-01f,
  3.51315155e-03f, -1.55216279e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    