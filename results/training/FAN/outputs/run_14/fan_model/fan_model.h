/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.02058578e-02f, -2.16596648e-01f, -2.18308643e-01f, -1.18840307e-01f, -4.81813028e-02f, 2.60312021e-01f, 1.64900213e-01f, -1.99664280e-01f, -3.75436544e-01f, 1.62746727e-01f,
  -3.39432471e-02f, -8.59848857e-02f, -2.94412691e-02f, 2.22612038e-01f, 2.60768294e-01f, 1.98085204e-01f, 1.52848288e-01f, 9.74432826e-02f, -2.10851729e-01f, -1.03642039e-01f,
  -3.47631685e-02f, 3.22202772e-01f, 1.16907947e-01f, 6.68638721e-02f, -2.26182252e-01f, -1.57458469e-01f, 1.99805349e-01f, -1.83007121e-02f, 2.93622941e-01f, 2.06219047e-01f,
  1.02883533e-01f, -1.33147895e-01f, -4.63257506e-02f, 2.84144655e-02f, -1.67198793e-03f, 5.18802404e-02f, 1.54257178e-01f, 1.84040554e-02f, 5.06690051e-03f, -3.06057259e-02f,
  2.10962072e-02f, 1.52242795e-01f, -2.71114204e-02f, -1.31590916e-02f, -2.59726699e-02f, 3.81920883e-03f, -2.48880871e-02f, -1.18196495e-01f, -9.43189636e-02f, 1.29092336e-02f,
  -9.54901353e-02f, -2.42834371e-02f, -2.63763387e-02f, 5.37922680e-02f, -7.85941109e-02f, -2.33487301e-02f, 8.87007788e-02f, -6.19816929e-02f, -3.18981567e-03f, 1.70593790e-03f,
  -1.36139216e-02f, -1.28940661e-02f, -7.86348153e-03f, 1.21408068e-01f, -3.47165465e-02f, -4.81295735e-02f, 9.39871520e-02f, 5.22576310e-02f, -1.16347760e-01f, 8.39036554e-02f,
  -6.27166182e-02f, 1.21281408e-02f, 7.75108859e-02f, -1.65904555e-02f, 2.25093439e-02f, 1.77010882e-03f, 1.92282870e-02f, -1.45618878e-02f, -2.47217696e-02f, -5.00746705e-02f,
  1.76686607e-02f, 8.92716739e-03f, -7.47352615e-02f, 5.01153618e-02f, 5.94307669e-02f, -3.50090377e-02f, -1.47251897e-02f, -2.47191750e-02f, -2.46359594e-02f, -1.15928920e-02f,
  -2.73993355e-03f, -8.14364702e-02f, -8.16545114e-02f, 6.42567277e-02f, 3.41877043e-02f, -7.87779093e-02f, -4.49222513e-02f, -3.83272916e-02f, -1.13318309e-01f, -2.91310549e-02f,
  1.07956484e-01f, -3.77113111e-02f, -2.10922793e-03f, 3.84376831e-02f, 2.03522108e-02f, -8.19744542e-02f, 8.85324329e-02f, -1.65240541e-02f, 3.57400137e-03f, -1.73628032e-02f,
  5.23228273e-02f, 6.29616380e-02f, -5.09603927e-03f, -4.26149033e-02f, -2.54626852e-02f, 9.21979472e-02f, -2.05898225e-01f, 5.78456707e-02f, 7.03203678e-02f, 2.44171638e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.63999245e-02f, 1.07455356e-02f, 4.15134549e-01f, -4.20708388e-01f, -1.28927872e-01f, -1.34948313e-01f, -2.55694151e-01f, -1.80883035e-01f, -1.35915339e-01f, -2.39248931e-01f,
  -2.34466642e-01f, 1.95502207e-01f, 4.50906426e-01f, -6.53357863e-01f, 7.84089386e-01f, 3.76071304e-01f, -5.46482742e-01f, -2.19481990e-01f, -3.98936197e-02f, -3.17228734e-01f,
  -1.09618187e-01f, -3.45002532e-01f, 2.11161867e-01f, -3.45435828e-01f, -4.24780339e-01f, -3.54616076e-01f, -2.10155752e-02f, -6.25547543e-02f, -4.17496890e-01f, -2.00665742e-02f,
  -1.26136869e-01f, -4.04248416e-01f, -1.61163449e-01f, 9.75023136e-02f, -6.18225448e-02f, -3.81603874e-02f, 8.85326117e-02f, 9.30642560e-02f, -1.20854661e-01f, 1.30914077e-01f,
  9.73667651e-02f, 1.16219312e-01f, -2.34145537e-01f, 2.19758257e-01f, -1.64465159e-01f, -7.22998753e-02f, 7.12894276e-02f, -1.09639823e-01f, -2.64058486e-02f, 3.70895565e-02f,
  1.78067625e-01f, -1.22007310e-01f, -1.10850036e-01f, 2.11508498e-02f, 6.38250262e-02f, -1.82994008e-01f, 5.06337397e-02f, 1.53549448e-01f, -1.08182155e-01f, -1.06144629e-01f,
  -1.01848327e-01f, 4.61598895e-02f, -3.42070758e-02f, -1.28387511e-01f, -2.22102385e-02f, 8.37407783e-02f, -5.03475778e-02f, 3.65849398e-02f, 1.21835284e-01f, 2.11355295e-02f,
  -3.61985192e-02f, -4.57129776e-02f, -1.48167998e-01f, -4.48028333e-02f, -2.31929924e-02f, 8.53167996e-02f, 1.37364298e-01f, 3.10291499e-02f, -5.51404245e-02f, 3.88287492e-02f,
  8.20749551e-02f, -2.03212481e-02f, -1.11036107e-01f, 2.94452645e-02f, -4.42590052e-03f, 1.69926107e-01f, -8.32980871e-02f, 1.61492810e-01f, -1.03236623e-01f, 5.23913689e-02f,
  -1.31326914e-01f, -4.97834772e-01f, -2.90839989e-02f, 8.29793047e-03f, 1.48044720e-01f, -1.26441019e-02f, -1.36950865e-01f, -2.58180499e-02f, -2.07017958e-02f, -1.92633107e-01f,
  -1.36805892e-01f, 1.03277735e-01f, -1.00987321e-02f, -8.53534639e-02f, 2.75268219e-02f, 7.59778870e-03f, -1.03130512e-01f, 1.26813399e-02f, 8.57271403e-02f, -7.95584619e-02f,
  -3.93516012e-02f, 1.05416141e-02f, 2.23568425e-01f, -1.32438391e-02f, -5.72096743e-02f, 4.69464213e-02f, 5.77718988e-02f, 1.77832022e-02f, 1.23034688e-02f, 2.61167064e-03f,
  -1.78301290e-01f, 2.38784458e-02f, -4.76495177e-01f, -4.57883865e-01f, 1.23756565e-01f, -3.47537488e-01f, -2.09782600e-01f, -4.20690253e-02f, -1.85249180e-01f, 2.90813595e-01f,
  -1.17697209e-01f, -2.53170848e-01f, 1.00632966e-01f, -7.14723587e-01f, -5.23779571e-01f, -1.58387318e-01f, -4.12094563e-01f, -2.23567516e-01f, -4.18750755e-02f, -2.84603406e-02f,
  -1.99646592e-01f, -2.22658247e-01f, -3.67578745e-01f, 7.06221312e-02f, -2.27251098e-01f, 3.24217677e-02f, 5.32787442e-01f, 2.50256270e-01f, -8.13479871e-02f, 3.40178646e-02f,
  -2.44841009e-01f, -2.94176098e-02f, 1.77541061e-03f, -6.75482675e-02f, -2.88886279e-02f, 2.35703960e-01f, 1.68258622e-01f, -1.25096247e-01f, -3.51759456e-02f, -5.58462329e-02f,
  1.56807318e-01f, -4.62992229e-02f, -1.31109148e-01f, 3.90592031e-02f, 8.95844251e-02f, 2.30776146e-02f, -8.08192864e-02f, -3.50276791e-02f, -4.75258827e-02f, -1.81868598e-01f,
  -2.40831167e-01f, 6.99063838e-02f, 1.00134395e-01f, 1.41394451e-01f, -2.69592721e-02f, -1.81546696e-02f, -1.90078914e-02f, 2.77805049e-02f, 6.28217384e-02f, 7.13867620e-02f,
  9.24012959e-02f, 2.25603253e-01f, -8.15341175e-02f, -5.82635067e-02f, -9.68414024e-02f, -5.54886907e-02f, 3.98716144e-03f, 5.15863560e-02f, 2.29784027e-02f, 1.09200731e-01f,
  4.64284793e-02f, -2.24364270e-02f, 2.79287361e-02f, 1.84990559e-02f, -2.51533873e-02f, 8.49863067e-02f, -5.00051677e-02f, -7.61508942e-02f, 2.42804121e-02f, -1.29082128e-01f,
  8.25990140e-02f, 2.35473532e-02f, 3.86726148e-02f, 1.11572266e-01f, -8.25331360e-02f, 5.04439622e-02f, 4.23515216e-03f, -2.74739470e-02f, -6.59311116e-02f, 1.07129298e-01f,
  1.44385109e-02f, 2.36088395e-01f, -6.74282536e-02f, -6.63892180e-02f, 6.07293274e-04f, -4.36445232e-03f, -1.10632502e-01f, -5.62059879e-02f, 2.43125707e-02f, 5.34747494e-03f,
  1.95004091e-01f, -5.16213709e-04f, 3.28062922e-01f, -3.64804119e-02f, -2.98541095e-02f, -1.92168239e-03f, 1.93886772e-01f, 2.64853295e-02f, 2.52905726e-01f, -3.23726460e-02f,
  1.19064979e-01f, 3.53807844e-02f, 1.27760142e-01f, 3.49479765e-02f, 6.35376945e-02f, 1.61502481e-01f, 4.47097458e-02f, 1.46786422e-02f, 8.83338451e-02f, 1.77251458e-01f,
  1.10229142e-01f, -6.07830703e-01f, 3.21032673e-01f, -1.08397007e-01f, 3.77045512e-01f, 4.70420003e-01f, 5.15593052e-01f, 3.62917851e-03f, -1.48066312e-01f, -5.96918702e-01f,
  -1.22597061e-01f, 1.27964104e-02f, 1.65978856e-02f, -2.00673208e-01f, 8.68832588e-01f, 2.49493495e-01f, 2.22205430e-01f, 3.45422998e-02f, 8.53566006e-02f, -1.18983559e-01f,
  2.76546814e-02f, -1.60767674e-01f, 3.07065189e-01f, -2.02150360e-01f, -2.74244677e-02f, -1.27282828e-01f, 6.35832548e-03f, 3.66171062e-01f, -3.13625067e-01f, 3.92258406e-01f,
  -1.40945047e-01f, -1.35984212e-01f, 8.15908164e-02f, -1.71907485e-01f, 4.74853851e-02f, 5.07052019e-02f, 1.33007273e-01f, 3.19131672e-01f, 2.03705758e-01f, -6.52774423e-02f,
  -4.81737740e-02f, -5.28023429e-02f, 6.05816171e-02f, 7.48925433e-02f, 1.76188946e-02f, -1.14706412e-01f, 1.78043656e-02f, -6.66960776e-02f, -1.53386276e-02f, 8.51947756e-04f,
  1.50083061e-02f, 2.71914061e-02f, 4.54394557e-02f, -4.22765203e-02f, 1.46922022e-01f, -6.45745173e-03f, 2.62677334e-02f, 1.86666548e-01f, -1.81200393e-02f, 5.59411906e-02f,
  1.74636662e-01f, 1.06013574e-01f, -6.22279234e-02f, -2.01584190e-01f, -7.32850432e-02f, -1.66093782e-01f, -5.24939559e-02f, 2.76200450e-03f, 2.42255684e-02f, -1.01982087e-01f,
  -3.33804265e-02f, -2.44505182e-02f, -3.20881940e-02f, -1.08710919e-02f, -9.05219167e-02f, -1.23489574e-01f, 3.10302693e-02f, -1.51450053e-01f, -1.91220269e-02f, 7.34615251e-02f,
  6.31254539e-03f, 6.22243024e-02f, -1.71644166e-02f, -7.51017183e-02f, -1.90553013e-02f, 1.00246727e-01f, -1.52399451e-01f, -1.71054602e-01f, 8.91687907e-03f, 1.79534256e-01f,
  -5.63992202e-01f, -4.25751209e-01f, -2.67684907e-02f, -2.16046482e-01f, -1.70530170e-01f, 3.25670205e-02f, 9.41991881e-02f, -8.12220126e-02f, -4.49250154e-02f, -2.74607725e-02f,
  -6.11116886e-02f, -9.85540375e-02f, -2.50609629e-02f, -5.47965951e-02f, 4.68610302e-02f, 1.40563482e-02f, 8.74497667e-02f, 1.43602313e-02f, 4.82443124e-02f, -7.07989037e-02f,
  -2.27645099e-01f, -6.31226450e-02f, -7.26297032e-03f, -7.39754513e-02f, -1.07924119e-01f, 1.26817897e-02f, -1.04823790e-01f, 3.64223011e-02f, -7.36957928e-03f, 3.16562727e-02f,
  3.18060458e-01f, 2.23055497e-01f, 5.37452400e-02f, 3.63963753e-01f, -7.97170699e-02f, -3.61501366e-01f, -2.20987201e-01f, -1.96369663e-02f, 5.26807606e-01f, -1.67859793e-01f,
  -1.50646463e-01f, 4.34368163e-01f, -2.13669077e-01f, 1.19640045e-01f, -1.05654843e-01f, -8.67186934e-02f, -5.27719595e-02f, 3.88372280e-02f, 1.88986734e-01f, -1.01192661e-01f,
  2.42334738e-01f, -2.75854439e-01f, -1.39183044e-01f, -2.08301738e-01f, -1.29794151e-01f, 9.65816751e-02f, -2.43356124e-01f, -4.13650364e-01f, -2.53294140e-01f, -1.42256603e-01f,
  -9.79746580e-02f, 2.25265041e-01f, -5.89999370e-02f, 1.03352956e-01f, 2.49031745e-02f, -2.86975205e-01f, 3.14154327e-02f, -1.01783499e-01f, -6.96435720e-02f, 6.86735064e-02f,
  9.67486799e-02f, 6.07893132e-02f, 9.67760235e-02f, -1.18910387e-01f, 6.35092482e-02f, -7.63386786e-02f, 9.85794589e-02f, 6.01413473e-02f, 2.25375846e-01f, -1.52941979e-02f,
  7.19874054e-02f, -6.62226677e-02f, -7.41871819e-02f, 6.35529384e-02f, 2.39950910e-01f, 1.70154214e-01f, -1.25464043e-02f, -1.17990218e-01f, -1.81216002e-01f, 1.02210835e-01f,
  2.21834615e-01f, -2.45859511e-02f, -1.30264193e-01f, -2.56848335e-01f, -1.66285992e-01f, -6.54775575e-02f, 6.53475849e-03f, -5.46374507e-02f, -1.68635678e-02f, -3.75156067e-02f,
  -9.22192708e-02f, 7.58009851e-02f, 2.84413919e-02f, -1.35642350e-01f, -3.68435644e-02f, 1.51787242e-02f, 2.74671409e-02f, -2.15294152e-01f, 1.82619423e-01f, -1.21494159e-01f,
  8.63121375e-02f, 1.15125187e-01f, -1.45295188e-01f, -1.18700489e-01f, -1.02118887e-01f, -3.19381543e-02f, 1.35574788e-01f, -2.89046317e-02f, -1.51228029e-02f, -1.27941743e-01f,
  5.08762747e-02f, 8.80925953e-02f, 6.56612441e-02f, 1.12192601e-01f, -4.20663841e-02f, -9.45108309e-02f, 4.48284857e-02f, 6.29541650e-02f, 4.33144942e-02f, -6.44893721e-02f,
  -9.19694528e-02f, -1.00111984e-01f, 5.09400889e-02f, -1.30477354e-01f, 1.06496044e-01f, 4.32695709e-02f, 8.64273235e-02f, 1.27460793e-01f, 7.89161548e-02f, 3.79168987e-02f,
  -1.12365104e-01f, -6.47297651e-02f, -5.61099760e-02f, 2.67678406e-02f, -2.60594506e-02f, -1.97359473e-02f, 3.15265660e-03f, 6.34601116e-02f, -1.18852109e-01f, -3.38307358e-02f,
  -8.12867880e-01f, 8.13999534e-01f, -4.06369597e-01f, 7.71524534e-02f, -1.35888150e-02f, 9.44190919e-01f, 7.37762749e-01f, 4.86225545e-01f, 3.74651939e-01f, 6.17483795e-01f,
  3.07007134e-01f, -6.26049861e-02f, 5.00312030e-01f, 5.32616913e-01f, 1.85650408e-01f, 5.33195078e-01f, 4.92604285e-01f, 3.18437696e-01f, 1.55077204e-01f, 1.97369963e-01f,
  3.10141481e-02f, 3.47359031e-01f, -1.07133292e-01f, 5.55396006e-02f, -1.69973806e-01f, -4.21855628e-01f, -2.41876870e-01f, -2.63790488e-01f, -1.37794062e-01f, 2.74841636e-02f,
  5.62264100e-02f, -1.44653812e-01f, -2.53190011e-01f, -5.34444414e-02f, 3.59791964e-02f, -1.05567440e-01f, -1.00809321e-01f, -1.83997259e-01f, -1.40698940e-01f, 1.21533819e-01f,
  1.88894067e-02f, 1.03428178e-02f, 1.12664424e-01f, -1.57303885e-02f, -3.24912257e-02f, -8.26700702e-02f, -1.52472407e-02f, 4.29393724e-02f, 1.32372379e-01f, 1.57685187e-02f,
  -1.44035062e-02f, -5.94191626e-03f, -8.96781757e-02f, 2.02583954e-01f, -1.43548667e-01f, 5.26615605e-02f, 4.82672006e-02f, -4.00011428e-02f, 7.22209141e-02f, 1.28464624e-01f,
  1.85712532e-03f, 8.42122734e-02f, -1.31044723e-02f, -1.13650508e-01f, 2.58947928e-02f, -1.00590952e-01f, -1.57897156e-02f, -1.32531002e-01f, -1.69943765e-01f, -9.51594207e-03f,
  2.93985493e-02f, -8.71608108e-02f, -6.33982494e-02f, 4.92991433e-02f, 5.59383892e-02f, 9.30593908e-02f, -1.32748097e-01f, -3.80843831e-03f, 3.00859623e-02f, 2.27024462e-02f,
  1.01936594e-01f, 1.30515665e-01f, 8.35916027e-02f, -7.27348635e-03f, 1.68683067e-01f, -2.44844090e-02f, -3.99856828e-02f, 1.41322464e-02f, -1.73538364e-02f, -2.24751364e-02f,
  4.88534063e-01f, 2.80705452e-01f, 1.04940124e-01f, 7.66119361e-02f, -2.72732470e-02f, -3.16181444e-02f, 3.72707210e-02f, -6.28257096e-02f, 1.47758320e-01f, 5.87114133e-02f,
  -7.09744822e-03f, -5.81341572e-02f, 1.86382588e-02f, -1.23837814e-01f, 4.78992388e-02f, 1.49582684e-01f, 1.09441452e-01f, 1.27737354e-02f, 9.50753167e-02f, 3.18044983e-02f,
  -1.73603281e-01f, 5.77057265e-02f, -7.75236636e-02f, 1.30460961e-02f, 6.70434767e-03f, 1.50174918e-02f, 2.62163393e-02f, -3.61430384e-02f, -6.37061372e-02f, 1.13798745e-01f,
  1.90719023e-01f, 2.32367255e-02f, -5.94940543e-01f, -5.06491721e-01f, -2.43536785e-01f, -5.18773913e-01f, -3.78584534e-01f, -1.03450939e-01f, -2.04517752e-01f, 2.18060911e-01f,
  8.86863098e-02f, -6.51846975e-02f, 4.02156234e-01f, -1.93288490e-01f, -5.27803004e-01f, 2.29100481e-01f, -6.10386968e-01f, -2.78803855e-01f, 1.85869724e-01f, -2.46716112e-01f,
  -2.79072493e-01f, 1.61600292e-01f, -3.59569848e-01f, 3.68361443e-01f, -1.96840897e-01f, 2.27632821e-02f, 9.53503922e-02f, 3.00339699e-01f, -2.90062308e-01f, -2.71718800e-02f,
  -5.27966134e-02f, 2.35570788e-01f, -7.74556994e-02f, -1.55762397e-02f, -1.97042465e-01f, 5.22392914e-02f, -1.79574236e-01f, 4.35657650e-02f, 7.92198479e-02f, -6.67697117e-02f,
  -4.47126217e-02f, 1.24554418e-01f, 1.39489705e-02f, 1.49299324e-01f, -3.98448780e-02f, -1.14247315e-01f, -2.16170728e-01f, -2.34056950e-01f, -4.81952019e-02f, 2.52411086e-02f,
  -9.62909311e-02f, -2.41527736e-01f, -1.83579117e-01f, -1.88906893e-01f, -3.32717538e-01f, -3.32611911e-02f, -8.68549477e-03f, -1.40025288e-01f, -2.91390479e-01f, 2.73133386e-02f,
  1.33953780e-01f, 1.67406246e-01f, 8.35342854e-02f, -1.11885443e-01f, -5.68274893e-02f, 1.70256436e-01f, -1.07946001e-01f, 9.71663296e-02f, 9.45137069e-03f, 2.22052503e-02f,
  -3.08617383e-01f, -1.32631417e-02f, 9.69623774e-02f, -1.70013636e-01f, 4.16732132e-02f, 9.47619155e-02f, -3.38307507e-02f, 5.03517911e-02f, -2.86408544e-01f, -1.98186517e-01f,
  1.61485925e-01f, -1.51501298e-02f, 1.79718956e-02f, -4.57385592e-02f, -1.42825916e-01f, -9.27574858e-02f, -2.73818225e-02f, -4.21666726e-02f, -9.38859861e-03f, -2.29885846e-01f,
  -1.07020989e-01f, -1.50236385e-02f, 6.26496896e-02f, -4.41726111e-02f, -5.19804768e-02f, -4.62439433e-02f, -3.30219381e-02f, -1.53866380e-01f, -2.15309978e-01f, -8.90471190e-02f,
  -1.27760008e-01f, -4.90171947e-02f, -1.36574179e-01f, 1.46387264e-01f, -1.06777199e-01f, -1.69318020e-01f, -9.02298465e-02f, -7.94447362e-02f, -1.96359023e-01f, -1.18498594e-01f,
  -5.54920696e-02f, 5.66115156e-02f, -1.41298562e-01f, -1.41994193e-01f, -1.11886054e-01f, -1.43078685e-01f, 1.12171657e-02f, 9.05207321e-02f, -1.37898296e-01f, -1.76699534e-01f,
  -1.22089994e+00f, 3.10662448e-01f, 5.08352444e-02f, 2.14907631e-01f, -3.50338995e-01f, 1.03569202e-01f, 3.79500896e-01f, -2.33147040e-01f, -1.52628034e-01f, 3.79624933e-01f,
  5.18029481e-02f, -2.24392861e-01f, 3.58519882e-01f, 4.22757179e-01f, -2.82040805e-01f, 5.43209374e-01f, 1.90190747e-01f, 7.27950484e-02f, 7.31248781e-02f, -1.45802811e-01f,
  -2.09766142e-02f, 4.01301011e-02f, 4.25849915e-01f, 1.90568298e-01f, -1.46351799e-01f, -1.00434765e-01f, 1.98048241e-02f, 1.20015919e-01f, -6.41948134e-02f, -1.23961858e-01f,
  -4.41237539e-01f, -4.34823275e-01f, -3.86964381e-02f, -1.90573156e-01f, -1.17028631e-01f, 1.00028396e-01f, 5.37068211e-02f, -7.48725906e-02f, -1.01723194e-01f, -6.40324457e-03f,
  -1.28255054e-01f, -6.66857511e-02f, -1.00998292e-02f, -1.86585281e-02f, -1.03925943e-01f, 3.03113125e-02f, 3.79271209e-02f, 6.36538565e-02f, 5.29978164e-02f, 1.25262856e-01f,
  1.16926074e-01f, 2.43979320e-02f, 9.34676006e-02f, 1.28452912e-01f, 6.66282848e-02f, 4.68920507e-02f, 6.19458146e-02f, 5.59099577e-02f, -3.20603773e-02f, 4.13842499e-02f,
  -4.62503731e-03f, 1.02175482e-01f, -3.60509083e-02f, -4.54817787e-02f, 3.86493802e-02f, -9.60941426e-03f, 4.58660051e-02f, -1.45138130e-02f, 1.04427211e-01f, 5.83837181e-02f,
  -9.23236832e-02f, -3.69952656e-02f, -1.51190162e-01f, 8.23277906e-02f, -2.20082551e-02f, -3.04129850e-02f, -6.03990853e-02f, -1.27331316e-01f, 8.94738138e-02f, -6.24608770e-02f,
  1.93643831e-02f, -2.00644508e-02f, 8.37489739e-02f, 2.44891513e-02f, -4.54134867e-02f, 5.12433797e-02f, 1.61405769e-03f, 4.53904718e-02f, -1.91378221e-02f, -1.26167178e-01f,
  -5.21943808e-01f, -3.77747238e-01f, -7.75174517e-03f, -1.97255358e-01f, -7.27165341e-02f, 6.84426352e-02f, 5.29093705e-02f, 1.33289853e-02f, -8.43791366e-02f, -1.40695078e-02f,
  -3.09558213e-02f, 1.51454343e-03f, -6.19576573e-02f, -3.99189964e-02f, 1.74942228e-03f, 1.67472869e-01f, 1.01113178e-01f, 8.56905803e-02f, -3.52768861e-02f, 6.91579562e-03f,
  1.31039888e-01f, -5.77313453e-02f, 1.45889059e-01f, -6.32233545e-02f, -2.46259123e-02f, 7.21713379e-02f, -1.32200643e-01f, -4.78647761e-02f, -1.69166774e-01f, 1.39194354e-01f,
  2.67963558e-01f, 2.23950475e-01f, 4.05693650e-01f, 7.21095860e-01f, -1.29449785e-01f, -7.18432009e-01f, -3.92339319e-01f, 1.83961555e-01f, 5.68537176e-01f, -1.80597290e-01f,
  -1.48417503e-01f, 1.05361544e-01f, -1.60304382e-02f, 1.44592047e-01f, 2.26895526e-01f, 2.29553476e-01f, 2.01344579e-01f, -8.02885219e-02f, 8.63658860e-02f, 3.53520483e-01f,
  2.79034078e-01f, 1.50617912e-01f, 3.47670108e-01f, 5.08706495e-02f, -3.87542583e-02f, 2.68856287e-01f, 3.77743423e-01f, 2.02725917e-01f, -1.58183560e-01f, -2.14638457e-01f,
  -2.15643406e-01f, 2.05040067e-01f, 5.70069291e-02f, -9.75180864e-02f, 2.87914816e-02f, -1.03957079e-01f, -1.67376801e-01f, -9.93647203e-02f, 1.11112476e-03f, -9.66369063e-02f,
  -6.88784495e-02f, 6.98735118e-02f, -5.92392404e-03f, 9.66391414e-02f, -5.88451065e-02f, 7.17991516e-02f, 1.68776158e-02f, -2.56696850e-01f, -3.28700878e-02f, -1.15081564e-01f,
  -4.39315662e-02f, 4.80616465e-02f, 9.10944492e-02f, 6.69952929e-02f, 6.13853745e-02f, -3.60657414e-03f, -1.11981921e-01f, 2.89062727e-02f, 9.06037316e-02f, 1.57498479e-01f,
  -1.43089265e-01f, 3.48964892e-02f, 1.37068450e-01f, 1.86521426e-01f, 1.57453656e-01f, -3.26417275e-02f, 5.91914505e-02f, -6.89485669e-02f, 2.38347501e-01f, -1.01368554e-01f,
  1.51934668e-01f, 8.43799487e-02f, 1.09623790e-01f, -2.41892040e-02f, 3.74320783e-02f, 1.37603626e-01f, 4.49559875e-02f, -1.13348439e-01f, -9.03115794e-02f, 1.94581654e-02f,
  2.89597474e-02f, -1.02666594e-01f, 1.46190718e-01f, -9.01486427e-02f, -4.69360463e-02f, 2.04868406e-01f, -8.01325217e-02f, 1.27760768e-01f, 1.78929567e-02f, 9.84029546e-02f,
  -8.32265243e-02f, 4.18328285e-01f, -1.35668367e-02f, -2.38652632e-01f, 6.71891794e-02f, 1.09050415e-01f, 7.68126547e-02f, 9.24787521e-02f, 2.11906880e-01f, -9.42790434e-02f,
  -1.63060561e-01f, 2.26182491e-03f, -1.11230835e-01f, 4.30638939e-02f, 3.51699255e-02f, 5.54747693e-02f, 6.87740594e-02f, 1.08363189e-01f, 1.53759271e-01f, -1.19205266e-01f,
  -3.43045555e-02f, 9.57124052e-04f, 8.35070759e-02f, -3.91080938e-02f, -1.96920350e-01f, -4.72920984e-02f, 7.81345926e-03f, 8.24641883e-02f, 4.06940095e-02f, 1.11922331e-01f,
  5.60606301e-01f, 1.47363678e-01f, 3.41577470e-01f, 1.29952982e-01f, -4.19953346e-01f, -8.77443627e-02f, 2.20315322e-01f, -4.29935336e-01f, -7.98251033e-02f, 8.47476274e-02f,
  -4.10459489e-01f, 7.69978642e-01f, 1.27915040e-01f, -2.54785996e-02f, -1.20494902e-01f, -9.78238732e-02f, -9.02680587e-03f, 1.97404861e-01f, -1.29296213e-01f, 5.89681193e-02f,
  -9.17154476e-02f, -4.34660316e-01f, 6.05514832e-02f, -3.81998271e-01f, 2.56396979e-01f, 1.93864137e-01f, -3.85784209e-01f, 6.67851493e-02f, 8.26087296e-02f, 1.09984681e-01f,
  -1.28002269e-02f, 9.52657014e-02f, 1.09829508e-01f, 1.19951688e-01f, -1.40310347e-01f, -1.40188518e-03f, 1.42301232e-01f, 6.61686808e-02f, 5.68121076e-02f, 8.41405764e-02f,
  2.23664686e-01f, -1.87747348e-02f, -6.28812835e-02f, -7.38072097e-02f, 1.32719139e-02f, -1.50098503e-02f, 2.90012429e-03f, 6.40394837e-02f, 1.69274807e-01f, 1.83092386e-01f,
  1.37370437e-01f, 8.44113007e-02f, 2.56780162e-02f, 1.07061543e-01f, 4.73333411e-02f, -1.88855398e-02f, 1.31558478e-01f, 7.31185675e-02f, 1.01282611e-01f, 3.30485068e-02f,
  -9.61106047e-02f, 3.66217941e-02f, -6.49164394e-02f, -2.72444822e-02f, 6.64270076e-04f, -8.77253618e-03f, 2.58308146e-02f, -2.55006980e-02f, 2.54276805e-02f, 1.17415778e-01f,
  -1.76406913e-02f, -2.49708649e-02f, -5.04782945e-02f, 1.09759914e-02f, -8.31941441e-02f, 3.16472389e-02f, 1.48319423e-01f, 2.68701557e-03f, -7.66027942e-02f, -1.41618773e-01f,
  -8.40319619e-02f, -6.01113588e-02f, 7.82283172e-02f, 1.68730915e-02f, -2.00689644e-01f, 7.62379989e-02f, -2.72113886e-02f, 2.28400826e-01f, -2.18249798e-01f, -1.39421776e-01f,
  -1.25430301e-01f, 9.61786509e-02f, -5.28606921e-02f, -1.63857397e-02f, -1.79198995e-01f, -1.05366126e-01f, -1.09728076e-01f, 5.40921278e-02f, 1.85188893e-02f, -3.95404398e-02f,
  -1.34672478e-01f, 6.28290474e-02f, -3.06402314e-02f, -1.67595655e-01f, -1.52224600e-01f, -2.30673298e-01f, 6.13352694e-02f, -1.01301216e-01f, -9.20891240e-02f, -3.73126827e-02f,
  1.94779009e-01f, 4.04576920e-02f, 1.19368188e-01f, 3.78874317e-02f, -1.67068932e-03f, 5.10966852e-02f, -2.65146773e-02f, -1.71932497e-03f, -7.26076141e-02f, -8.87409672e-02f,
  2.81693757e-01f, 6.87793911e-01f, 5.29185951e-01f, 2.90618718e-01f, -3.18665624e-01f, 4.92185235e-01f, 4.63831365e-01f, 7.69979134e-02f, 4.51150149e-01f, 7.54596107e-03f,
  -5.72897196e-01f, 5.22585094e-01f, -1.38980508e-01f, -4.64495607e-02f, -2.07026079e-01f, -1.70687120e-02f, 1.55138955e-01f, 8.83013085e-02f, 2.98242718e-01f, -3.08816601e-02f,
  -1.43257380e-01f, -5.18181026e-01f, -1.86227202e-01f, -8.05573910e-02f, -9.66752544e-02f, 1.17315836e-01f, -5.58133662e-01f, 6.96297809e-02f, -8.68797824e-02f, -1.29866330e-02f,
  4.38709743e-02f, -5.22703566e-02f, 6.89695403e-02f, 1.10095233e-01f, 8.98898765e-02f, 1.68382242e-01f, 9.89301801e-02f, -3.96878161e-02f, -2.97759585e-02f, 9.99883562e-02f,
  5.14354482e-02f, -1.71984620e-02f, 1.67109251e-01f, 1.94797851e-02f, 1.57342553e-01f, 1.64892763e-01f, 7.71588609e-02f, -7.53906816e-02f, 6.48947880e-02f, 1.50972366e-01f,
  5.58776483e-02f, 3.43824476e-02f, -2.57075205e-02f, -1.49051119e-02f, -5.39575778e-02f, 8.74687135e-02f, 1.65230528e-01f, -4.89532799e-02f, 1.56404935e-02f, 1.97654143e-01f,
  -2.13032961e-02f, 2.62057167e-02f, 7.85036981e-02f, -2.47641429e-01f, 3.67363542e-03f, -1.29157946e-01f, -1.12619177e-02f, 2.29603681e-03f, 4.89893630e-02f, -1.22226387e-01f,
  -1.18616633e-01f, -1.19204640e-01f, -6.67577684e-02f, 2.11401172e-02f, -5.81030063e-02f, -8.28989074e-02f, -9.57644805e-02f, 6.24488741e-02f, 7.49300001e-03f, -6.36107326e-02f,
  -4.13275175e-02f, 4.14775833e-02f, -1.08063124e-01f, -6.65794685e-02f, 3.21195833e-02f, 3.34705482e-03f, 7.34184235e-02f, 6.55019030e-05f, 1.98634993e-02f, -4.76297252e-02f,
  -1.54261244e-02f, -3.02517079e-02f, -2.51764860e-02f, 3.37782949e-02f, 1.36067644e-01f, -2.88902950e-02f, 1.60723418e-01f, -5.47172837e-02f, 1.55632302e-01f, 2.04782188e-02f,
  4.71766442e-02f, -2.14649159e-02f, 7.88851976e-02f, -5.52021787e-02f, 7.88469687e-02f, 8.69595408e-02f, -2.53742735e-04f, -9.18626338e-02f, -1.86471373e-01f, -5.79085313e-02f,
  -7.58210346e-02f, -2.24828832e-02f, -2.43595373e-02f, -1.53350785e-01f, -6.29390404e-02f, -1.58171222e-01f, -4.73535880e-02f, 6.89014047e-03f, -4.36773188e-02f, -3.05390041e-02f,
  3.11299972e-02f, -2.03616753e-01f, -1.16027892e-01f, 2.20583752e-01f, 1.26398727e-01f, -9.96090025e-02f, -1.67710066e-01f, 2.80475914e-01f, -5.63873351e-01f, -1.14108413e-01f,
  -5.98237514e-02f, -1.62289679e-01f, -5.74930191e-01f, -1.18800849e-01f, -3.41999888e-01f, -6.08277440e-01f, 2.95332335e-02f, -4.69025783e-03f, -2.58707523e-01f, 3.23736846e-01f,
  6.55828565e-02f, 6.63991226e-03f, 2.60881990e-01f, 2.87304759e-01f, 2.18887791e-01f, 5.53490400e-01f, 4.15335655e-01f, 6.16865642e-02f, 5.89809597e-01f, 4.75172512e-02f,
  -2.18355983e-01f, -1.35831058e-01f, 1.42457904e-02f, -8.34252983e-02f, 2.07924023e-01f, 2.98435271e-01f, 1.25456080e-01f, 4.81978022e-02f, -4.78831939e-02f, 4.85673826e-03f,
  -3.78097259e-02f, 2.43955608e-02f, 5.82179204e-02f, -9.94309187e-02f, 1.00667268e-01f, 6.81532994e-02f, -4.86680903e-02f, 3.74767147e-02f, -1.53862044e-01f, -6.86884224e-02f,
  1.58042088e-01f, 8.55844542e-02f, 4.07998934e-02f, -1.93261188e-02f, 1.08322110e-02f, 3.76757532e-02f, 2.13176697e-01f, 1.45372838e-01f, 1.31142542e-01f, 1.55379906e-01f,
  3.64888534e-02f, 1.39770523e-01f, 4.00502458e-02f, -6.72024041e-02f, 5.95517308e-02f, -4.16450463e-02f, -1.47478864e-01f, 3.15570906e-02f, 2.89036352e-02f, -1.24573439e-01f,
  1.09299213e-01f, 8.87843035e-03f, -1.55513495e-01f, 1.20214447e-01f, 2.01962635e-01f, 6.54416233e-02f, -4.78191953e-03f, 1.40823424e-01f, 1.05617546e-01f, 2.59739235e-02f,
  -8.65777209e-02f, 1.29794821e-01f, -2.80367434e-02f, 3.81194502e-02f, -6.33379966e-02f, 5.64664491e-02f, 1.50409071e-02f, -1.05096407e-01f, -4.20913249e-02f, 9.58994254e-02f,
  5.63774556e-02f, 1.10486522e-01f, -4.71780710e-02f, -7.33547732e-02f, -6.01877719e-02f, 1.50826080e-02f, -2.00653717e-01f, -7.92058557e-02f, -3.64882424e-02f, -5.58265857e-02f,
  1.38254449e-01f, 1.91042960e-01f, 2.17246637e-02f, 2.29372978e-02f, -4.87696454e-02f, 7.48220319e-03f, 7.55782202e-02f, 9.03190151e-02f, 2.42007405e-01f, 2.06198290e-01f,
  2.07789317e-01f, 9.09077097e-03f, -6.20682770e-03f, 3.13864164e-02f, 1.15366735e-01f, 2.43304651e-02f, 2.16938034e-01f, 7.72446170e-02f, 7.15145692e-02f, -5.65513037e-02f,
  4.12388653e-01f, -4.01695482e-02f, -4.31807607e-01f, 3.43799621e-01f, 1.05255909e-01f, 1.20242491e-01f, -1.32939279e-01f, 7.84217268e-02f, -3.53876203e-01f, -7.62446299e-02f,
  5.58852702e-02f, 4.76185493e-02f, -4.92717981e-01f, 6.30974710e-01f, 9.02017415e-01f, -1.86710522e-01f, 6.77193344e-01f, 1.93898469e-01f, -1.30223528e-01f, 3.73009712e-01f,
  3.89456183e-01f, 8.95926654e-01f, 3.57484296e-02f, 4.32088971e-01f, 4.85498875e-01f, -3.06613185e-02f, 3.66169482e-01f, -2.18869656e-01f, 5.79062104e-01f, 3.43428582e-01f,
  -6.80158064e-02f, 4.60625393e-03f, 5.26949428e-02f, -1.67802870e-01f, 2.76144762e-02f, -4.09066305e-02f, -1.44530207e-01f, 2.31348835e-02f, -3.24186087e-02f, -2.35921323e-01f,
  -7.76546299e-02f, 9.38831940e-02f, 1.13618918e-01f, 1.27410278e-01f, 1.65950924e-01f, 4.23982143e-02f, -4.64481898e-02f, -1.14753462e-01f, -1.36513487e-01f, 5.54865412e-02f,
  -1.89503297e-01f, -7.38313273e-02f, 6.53999448e-02f, -9.92667228e-02f, 4.78248224e-02f, 4.41915356e-02f, -5.20278513e-02f, -1.46294534e-02f, -1.33597419e-01f, 9.99612585e-02f,
  2.53040165e-01f, -5.38230799e-02f, -3.20974039e-03f, -1.49699107e-01f, 1.24447063e-01f, -1.87521651e-02f, 1.21649601e-01f, 5.61243668e-03f, 1.13492586e-01f, 1.33622259e-01f,
  -5.01912944e-02f, 1.34106576e-01f, 5.83315082e-02f, -6.09501079e-02f, 1.05461836e-01f, -9.26989093e-02f, -5.44018820e-02f, -2.18544025e-02f, -1.23665720e-01f, -1.97076681e-03f,
  -2.85290796e-02f, 2.46450491e-02f, 8.90387222e-02f, -1.17150992e-01f, -9.18991342e-02f, 6.41503483e-02f, 1.43651262e-01f, 1.50221914e-01f, -3.47923011e-01f, 7.65970489e-03f,
  7.86851048e-02f, 4.88822669e-01f, -4.68678102e-02f, -2.58303564e-02f, -1.94490198e-02f, 2.26899847e-01f, 9.06171948e-02f, 2.30786800e-01f, 1.44444734e-01f, 9.52383950e-02f,
  4.93984856e-02f, -1.02209538e-01f, 1.65610369e-02f, -1.28530972e-02f, 5.47834374e-02f, 1.12073906e-01f, 5.38304821e-02f, -4.04351093e-02f, 1.00591198e-01f, 1.14818282e-01f,
  -3.57115790e-02f, -7.94291571e-02f, 7.11709335e-02f, -1.55965146e-03f, 1.11228324e-01f, -8.92693475e-02f, 3.04674217e-03f, -1.18873708e-01f, 9.10349283e-03f, -8.43296126e-02f,
  -1.23838508e+00f, 6.98833346e-01f, 4.49016660e-01f, -7.44231641e-01f, 2.97083825e-01f, -1.17053099e-01f, -4.56012547e-01f, 3.68340641e-01f, -3.19465816e-01f, 2.26504177e-01f,
  -1.31067708e-01f, -1.15928814e-01f, 4.01407838e-01f, -3.28030348e-01f, -5.50416589e-01f, -5.59337847e-02f, -5.08837938e-01f, -3.28546435e-01f, -1.82275064e-02f, -8.80894810e-02f,
  -2.52206147e-01f, -6.48431033e-02f, 1.71110496e-01f, 5.74466348e-01f, 1.25712916e-01f, 1.68923780e-01f, -2.03112781e-01f, 4.74800169e-01f, 2.78247036e-02f, 1.10671811e-01f,
  -2.28972852e-01f, 1.53694913e-01f, 1.75667033e-01f, 1.57540992e-01f, 3.52567732e-02f, -5.29360920e-02f, -1.47768646e-01f, -1.89034324e-02f, -1.39006451e-02f, -1.65578034e-02f,
  -7.95381442e-02f, 1.22204617e-01f, -1.22632705e-01f, 9.05596614e-02f, 1.04955554e-01f, 4.26784977e-02f, 1.70963213e-01f, -5.85426856e-03f, 1.21336669e-01f, 4.43767533e-02f,
  1.42278925e-01f, 1.40881136e-01f, -7.85473436e-02f, 1.00620138e-03f, 7.72027224e-02f, 4.46455181e-03f, -2.25459561e-02f, 7.42335618e-02f, -1.21273361e-02f, -7.33286813e-02f,
  -1.37593718e-02f, -3.71956006e-02f, 6.91848695e-02f, 8.67679417e-02f, -4.32672352e-02f, 9.18876845e-03f, -4.55173329e-02f, -5.30665629e-02f, -1.35304192e-02f, -2.42194962e-02f,
  -1.42930031e-01f, -6.23976849e-02f, -9.73475818e-03f, -5.59737682e-02f, -3.95543035e-03f, -9.99917462e-02f, 8.42966661e-02f, 1.95260290e-02f, -9.84737650e-02f, -6.61936477e-02f,
  -3.53121869e-02f, -6.11775853e-02f, 1.25630368e-02f, -4.78119925e-02f, 6.44683540e-02f, 8.84614810e-02f, 6.28078207e-02f, 8.35545659e-02f, -1.00507602e-01f, -1.38540149e-01f,
  -1.90122902e-01f, -2.34145913e-02f, 1.82067491e-02f, 7.51898661e-02f, -6.21997528e-02f, -6.59487844e-02f, -1.62654668e-02f, 2.05203444e-02f, 1.59800034e-02f, -5.24681509e-02f,
  1.87117774e-02f, -1.32213667e-01f, -4.92853373e-02f, -9.77393687e-02f, 3.12871556e-03f, -5.28880879e-02f, -1.48214981e-01f, -1.15108490e-01f, -1.74377322e-01f, 1.83661710e-02f,
  -2.53007952e-02f, -1.09561700e-02f, -2.02589910e-02f, 7.91118518e-02f, -1.05675980e-01f, -8.35186988e-02f, -1.65513650e-01f, 5.70437498e-02f, 4.34628986e-02f, -7.48651847e-03f,
  2.00092182e-01f, -6.33435786e-01f, 1.40911773e-01f, 2.27658376e-01f, 4.98953968e-01f, 3.54455322e-01f, 1.68070942e-01f, 2.55302340e-01f, 4.19913560e-01f, -5.32554924e-01f,
  -1.07388429e-01f, -4.47750568e-01f, -3.88700962e-01f, -4.71234284e-02f, 3.33138704e-01f, -1.83766127e-01f, 1.08828798e-01f, -7.28945062e-02f, 2.41311371e-01f, -1.41476635e-02f,
  2.79846221e-01f, 2.66725458e-02f, 2.01435298e-01f, -1.55362949e-01f, 2.13694364e-01f, -5.78472279e-02f, -2.57755965e-01f, -3.97633687e-02f, -1.29485592e-01f, 4.77915294e-02f,
  1.11237399e-01f, -1.22081004e-01f, 1.30297001e-02f, -2.88384937e-04f, 3.30102853e-02f, -1.30522149e-02f, -1.33648738e-01f, -3.22736241e-02f, 1.38581768e-01f, 5.91347069e-02f,
  -8.07075202e-02f, 1.68243513e-01f, 4.60717604e-02f, 1.06922336e-01f, 2.98415702e-02f, 1.49485767e-01f, 1.49936810e-01f, 1.85099795e-01f, -1.38542987e-02f, 2.51577348e-01f,
  1.51391372e-01f, 6.67869374e-02f, 1.76390588e-01f, -1.02786943e-01f, 1.81700252e-02f, 1.46682486e-01f, 7.59314001e-02f, -7.74189085e-02f, -1.63100287e-02f, 1.36154115e-01f,
  -8.89445767e-02f, 7.29090273e-02f, -6.83768513e-03f, 4.24949639e-02f, 6.54529408e-02f, 2.19406337e-01f, -4.67710895e-03f, -1.17088608e-01f, -3.86031456e-02f, 2.67712064e-02f,
  2.58876979e-02f, -7.29930475e-02f, 3.86633649e-02f, 6.29892126e-02f, -5.85935712e-02f, 5.52641414e-02f, -1.24542536e-02f, -2.45402511e-02f, 8.12264085e-02f, -6.20454736e-02f,
  -1.19864717e-01f, 8.72820690e-02f, -1.07639603e-01f, 1.70150355e-01f, -6.31640032e-02f, -2.56064553e-02f, 5.56822419e-02f, 1.71333820e-01f, -7.27030411e-02f, -1.37786865e-01f,
  -4.15551543e-01f, -8.05254757e-01f, -1.06927350e-01f, 1.74897369e-02f, -6.63404390e-02f, -4.64926548e-02f, 4.54430208e-02f, -3.78124387e-04f, -2.63877034e-01f, 3.79950106e-02f,
  5.38990386e-02f, 1.01782776e-01f, -1.70217916e-01f, 4.15915325e-02f, -9.10269469e-02f, -8.86404328e-03f, -1.61985874e-01f, -2.87373811e-01f, -2.12972328e-01f, -1.47853017e-01f,
  -3.22596356e-02f, -4.12748521e-03f, 1.18280292e-01f, 1.52322918e-01f, 3.16089951e-02f, -1.18003957e-01f, -2.76560560e-02f, -1.35133907e-01f, 4.15983126e-02f, -3.38971652e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.81283343e-01f, 2.91693628e-01f, 7.91063011e-01f, 5.46072662e-01f, 8.96918416e-01f, 5.73213160e-01f, 2.18489692e-01f, 5.76209545e-01f, 8.61283958e-01f, 9.06798065e-01f,
  6.06922746e-01f, 5.85227668e-01f, 9.71282244e-01f, 6.30599856e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -5.13192892e-01f, 6.16327822e-01f, 1.25217542e-01f, -6.76291957e-02f, 4.42680484e-03f, 1.85089543e-01f, 9.29113179e-02f, -7.38212988e-02f, 2.34573066e-01f, -9.41759199e-02f,
  2.83128381e-01f, 1.25481114e-01f, -2.22424790e-01f, -2.47450322e-01f, -5.31158924e-01f, -2.57774413e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.36973810e-01f, 9.90686595e-01f, 6.62350655e-01f, -6.01161301e-01f, 5.90482533e-01f, -8.93170059e-01f, 7.88963020e-01f, 5.67186236e-01f, 7.87379146e-01f, -3.78862411e-01f,
  3.16186666e-01f, 3.35445374e-01f, -5.04640996e-01f, 2.93208629e-01f, 2.14553431e-01f, -1.31836519e-01f, -2.03153174e-02f, 7.41715491e-01f, -5.79405367e-01f, 2.95038760e-01f,
  -4.57787484e-01f, -2.70847827e-01f, 3.43173236e-01f, -6.70068711e-02f, 5.75857222e-01f, 5.00512660e-01f, -4.68327165e-01f, -5.24155736e-01f, 1.00579190e+00f, 6.39347196e-01f,
  2.61995673e-01f, -2.89722681e-01f, 6.96044922e-01f, -3.07206422e-01f, 5.99829376e-01f, 2.00668678e-01f, 1.47312611e-01f, 1.21825844e-01f, 6.20948553e-01f, 4.98777181e-01f,
  -5.51839590e-01f, 3.04152548e-01f, 4.53677893e-01f, 6.45064116e-01f, -1.29964754e-01f, 5.44241905e-01f, -9.93852735e-01f, 1.10669293e-01f, 3.99509698e-01f, -2.04647303e-01f,
  -2.43433386e-01f, -5.16531467e-01f, 6.87336624e-01f, 7.64281571e-01f, 3.81016254e-01f, -4.55645949e-01f, -3.90232891e-01f, 8.22637558e-01f, 6.62347019e-01f, 7.08989918e-01f,
  3.65132540e-01f, 7.84439504e-01f, -6.87491357e-01f, 5.03483355e-01f, 6.47752345e-01f, -5.66530466e-01f, 1.10897258e-01f, 8.36264193e-01f, 7.13365495e-01f, -2.80817300e-01f,
  -1.50931612e-01f, 3.44786733e-01f, -2.34828725e-01f, -1.67801782e-01f, -2.80454606e-01f, 8.04767595e-04f, 3.58518362e-01f, -2.07062408e-01f, 6.06842399e-01f, 6.41428828e-01f,
  -1.10805057e-01f, 2.27913648e-01f, -1.82672620e-01f, -1.30406499e-01f, -5.32637179e-01f, -1.72108501e-01f, 1.20507789e+00f, 5.05780816e-01f, 7.29528844e-01f, 2.59844631e-01f,
  6.96696103e-01f, 6.60366297e-01f, -8.55780318e-02f, 3.98221105e-01f, 7.25984797e-02f, -5.13209105e-01f, 5.45558870e-01f, -1.55815616e-01f, 4.85192329e-01f, -6.39591157e-01f,
  6.81172967e-01f, 1.85032815e-01f, -6.94364309e-02f, -8.93649161e-01f, 1.73633412e-01f, -5.59525639e-02f, 9.20817912e-01f, 8.65815401e-01f, 6.97930828e-02f, -4.10400033e-01f,
  5.82140625e-01f, 2.76679069e-01f, 3.21360081e-01f, -6.01522684e-01f, -2.70527035e-01f, -6.53823674e-01f, -1.76048964e-01f, 3.21473598e-01f, 6.20737553e-01f, 4.57471937e-01f,
  7.28155077e-01f, 5.29193997e-01f, -1.89261824e-01f, 7.68587053e-01f, -4.68981057e-01f, -8.72140884e-01f, 8.26729655e-01f, 6.83876038e-01f, 5.17067254e-01f, -5.77719629e-01f,
  2.79432595e-01f, -3.65611985e-02f, 7.38446355e-01f, 5.75466871e-01f, 5.54792844e-02f, 1.80079922e-01f, -9.65262279e-02f, 8.70482743e-01f, 6.52756244e-02f, 2.74093211e-01f,
  -3.39276552e-01f, -2.69891828e-01f, -5.21186769e-01f, 8.93653035e-01f, -3.14462215e-01f, -4.29300606e-01f, 1.86525717e-01f, 1.18186760e+00f, -7.83843160e-01f, 4.85464543e-01f,
  -5.79454899e-01f, 4.28933740e-01f, -2.24498197e-01f, -1.93333611e-01f, 6.31862521e-01f, 5.53376794e-01f, 8.96832824e-01f, -6.42208099e-01f, 6.90612733e-01f, -1.87685043e-01f,
  1.83397979e-01f, -5.04115403e-01f, 9.06879902e-01f, 1.61042303e-01f, -3.82690579e-02f, 4.82536048e-01f, 3.67396027e-02f, 4.75099504e-01f, 4.02190834e-01f, 7.16324627e-01f,
  -4.26347852e-02f, 9.00191665e-02f, -3.77742410e-01f, 3.03209841e-01f, 9.19486582e-01f, -1.93548694e-01f, -7.07632780e-01f, 1.02973831e+00f, 2.05898866e-01f, -5.85589111e-01f,
  7.34499216e-01f, -5.83625019e-01f, 4.69502717e-01f, 3.54028970e-01f, 4.75747555e-01f, -9.97640073e-01f, -6.07286431e-02f, -4.67791915e-01f, 1.73392996e-01f, 7.09684253e-01f,
  -3.80818695e-01f, 3.08850676e-01f, 3.00019115e-01f, -5.46022415e-01f, 5.65694869e-01f, -7.42794946e-02f, 5.05124807e-01f, 6.39436841e-01f, -6.18724823e-01f, 1.82406247e-01f,
  -3.32410187e-01f, 6.91449046e-01f, 5.21750271e-01f, 3.71281326e-01f, -7.61711672e-02f, -4.61901128e-01f, -1.35143235e-01f, 3.87055546e-01f, 2.16357738e-01f, -6.18575096e-01f,
  -8.55033994e-01f, 1.02497168e-01f, 9.44813713e-02f, 6.42516136e-01f, 6.34965897e-02f, 3.34511906e-01f, -3.22730929e-01f, 3.63240510e-01f, -4.83598799e-01f, -4.63213250e-02f,
  8.36741507e-01f, 7.90256083e-01f, 9.36668515e-01f, 7.61611104e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.51526546e-01f, 3.13143879e-01f, -1.00610696e-01f, 4.46599603e-01f, 5.38272798e-01f, 1.07378811e-01f, 3.14587414e-01f, 2.93154329e-01f, 6.00582242e-01f, -1.74906366e-02f,
  -2.14458942e-01f, 5.69567978e-01f, 1.32331535e-01f, 6.05370641e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  1.83451250e-02f, 7.71226525e-01f, 7.15549707e-01f, 3.33370179e-01f, -7.90824234e-01f, -5.17350316e-01f, -8.97764504e-01f, 6.92280710e-01f, -6.83020055e-01f, 3.96175921e-01f,
  -4.72143888e-01f, -5.29359162e-01f, -4.04956043e-01f, 5.86698532e-01f, -5.73989153e-01f, -1.24490082e+00f, 3.31817269e-01f, -3.03765804e-01f, 3.53277028e-01f, 1.93807572e-01f,
  6.10176563e-01f, 6.19205087e-02f, -4.30088729e-01f, 6.43069446e-01f, -6.27297461e-01f, -1.06150579e+00f, -8.48998368e-01f, 2.93346614e-01f, -5.13962865e-01f, 3.91845077e-01f,
  -4.04335648e-01f, -1.46423310e-01f, 2.47750863e-01f, -9.77973416e-02f, -6.03858054e-01f, 1.72701687e-01f, -6.00401700e-01f, 5.46481550e-01f, -2.29217991e-01f, -1.01720357e+00f,
  -5.30768096e-01f, -6.46325886e-01f, 4.85636760e-03f, -3.65022838e-01f, -6.28801763e-01f, 7.65911043e-01f, -5.52979767e-01f, 5.71051002e-01f, -6.99326843e-02f, -9.32305604e-02f,
  -3.48954409e-01f, -4.86347675e-01f, -1.00602138e+00f, -6.32868230e-01f, 9.01236236e-02f, 3.92349482e-01f, -1.04838586e+00f, 5.99387705e-01f, -8.17914665e-01f, 3.26940238e-01f,
  8.05099130e-01f, -5.24085641e-01f, -5.06924503e-02f, 1.45228177e-01f, 6.52745739e-02f, -5.93415737e-01f, 6.36144817e-01f, -3.29716802e-01f, -2.05517292e-01f, -5.34900069e-01f,
  2.74983048e-01f, -4.47178394e-01f, 5.56316793e-01f, 6.10390544e-01f, -1.21903412e-01f, -5.99602580e-01f, 3.50719988e-01f, -1.49890363e-01f, -1.75511211e-01f, 1.59250095e-01f,
  1.31578431e-01f, 6.21054471e-01f, 1.18866123e-01f, -1.00558019e+00f, 5.65092027e-01f, 6.28719985e-01f, -4.83976662e-01f, 5.19939005e-01f, 2.74397936e-02f, 3.24426293e-01f,
  2.30203494e-01f, -9.08000171e-01f, -2.05306053e-01f, -5.33303201e-01f, -4.32451099e-01f, -5.80690265e-01f, -1.85143903e-01f, -5.34377694e-01f, -7.48547852e-01f, -5.25509298e-01f,
  3.05542778e-02f, 2.87074506e-01f, 3.37042600e-01f, -9.10888135e-01f, 5.89385293e-02f, 4.70251232e-01f, 6.88323736e-01f, -7.10030854e-01f, -5.71112454e-01f, -5.58961391e-01f,
  3.66631448e-01f, 3.67687047e-01f, -3.16057235e-01f, 3.21240127e-01f, -1.76901892e-01f, -3.27216834e-01f, 5.99958181e-01f, -4.09196287e-01f, 1.59041341e-02f, -4.79271859e-01f,
  -4.37189072e-01f, -4.47085857e-01f, 2.32940897e-01f, 3.00453603e-01f, 6.12268567e-01f, -5.34534574e-01f, 6.68744385e-01f, -5.89174330e-01f, -3.26246321e-01f, -1.90379679e-01f,
  -7.66361892e-01f, 7.05777884e-01f, -3.96728516e-02f, 3.07248592e-01f, -7.07547843e-01f, 7.84712881e-02f, -4.11819696e-01f, -3.33484113e-01f, -2.06591472e-01f, -1.87425524e-01f,
  4.44808811e-01f, -9.89916861e-01f, 5.70140518e-02f, 4.04279977e-01f, 6.92633688e-02f, -8.86722207e-02f, 6.29172862e-01f, -3.78320456e-01f, 6.07753061e-02f, 1.84235021e-01f,
  2.44415686e-01f, -9.53000844e-01f, 5.96000850e-01f, -6.40127838e-01f, 2.60860085e-01f, -3.21387380e-01f, -4.80596930e-01f, 3.93360734e-01f, 4.97841150e-01f, -1.11671162e+00f,
  -8.33876505e-02f, -4.65548605e-01f, -5.22144854e-01f, 5.83464265e-01f, -3.42023879e-01f, -6.83738947e-01f, 7.65904427e-01f, -7.11590350e-01f, -3.69636655e-01f, -9.10809875e-01f,
  -3.71718347e-01f, 7.14767933e-01f, -4.16901320e-01f, -3.75292748e-01f, -5.44200778e-01f, 4.09588009e-01f, 1.87667534e-01f, 1.22821510e-01f, -8.65515113e-01f, -5.45676529e-01f,
  -2.71811575e-01f, 2.24988401e-01f, -4.57191199e-01f, -9.15422291e-03f, 6.71258509e-01f, 2.42572471e-01f, -2.26045758e-01f, 8.23187649e-01f, -3.81622285e-01f, -2.62001038e-01f,
  5.07161498e-01f, -2.13727266e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.97276443e-01f, -1.65527150e-01f, 2.70544469e-01f, -2.64944494e-01f, -4.72482963e-04f, -1.12809353e-01f, -4.20762487e-02f, -1.52781218e-01f, -2.81830877e-01f, 3.23498882e-02f,
  2.04455420e-01f, 4.98952828e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    