/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.77198637e-01f, -1.22112967e-01f, -1.75896019e-01f, -3.52304354e-02f, 1.12433262e-01f, 4.20092851e-01f, 2.06311241e-01f, -1.91027939e-01f, -1.55491643e-02f, -1.35629162e-01f,
  9.20944959e-02f, 2.29509901e-02f, -4.95682620e-02f, 1.06364124e-01f, 4.56431925e-01f, -9.37869623e-02f, 1.29280478e-01f, 1.05151340e-01f, 2.10798532e-02f, -9.32400823e-02f,
  4.48026173e-02f, 1.72680184e-01f, -9.57944021e-02f, -9.69200432e-02f, 5.50591350e-02f, -2.87653297e-01f, -2.03347996e-01f, 2.41539925e-02f, -4.95419316e-02f, 1.22402221e-01f,
  3.24079432e-02f, -4.33217734e-02f, -1.06855281e-01f, 7.29909306e-03f, 9.58454504e-04f, 7.10444525e-02f, -1.96823827e-03f, -2.84147318e-02f, -2.94652767e-02f, -3.13721597e-02f,
  6.23635724e-02f, 3.42079364e-02f, 2.81216018e-02f, 6.70085400e-02f, 9.93053392e-02f, -7.18643749e-03f, -1.13455327e-02f, -2.75015291e-02f, -4.13107052e-02f, 1.11351378e-01f,
  4.63912971e-02f, 4.67568776e-03f, 1.73772611e-02f, -1.22675769e-01f, -4.86974306e-02f, 1.29744411e-02f, -6.71536103e-02f, 6.33646036e-03f, 1.91529579e-02f, 2.11676639e-02f,
  7.34108165e-02f, 9.40245092e-02f, 2.01550368e-02f, -2.85165869e-02f, 9.09490213e-02f, -3.51988673e-02f, 8.14051554e-02f, -4.65334430e-02f, -2.93477159e-02f, 2.38127783e-02f,
  -2.04034941e-03f, 7.92361423e-02f, -2.26593763e-02f, 4.65088338e-02f, 1.35852978e-01f, 3.09653375e-02f, 3.39188315e-02f, 7.49274492e-02f, -1.87443513e-02f, 1.21993594e-01f,
  -8.09055343e-02f, 5.53749315e-02f, -3.31889354e-02f, -1.81083661e-02f, -3.89789641e-02f, 3.69773619e-02f, -7.18950061e-03f, 5.54709844e-02f, -4.72520664e-02f, 1.46778271e-01f,
  7.24121835e-03f, -1.59926862e-01f, -8.48486200e-02f, -5.47954673e-03f, -3.22778970e-02f, 3.61932106e-02f, 2.54511088e-02f, -4.23739385e-03f, -7.05942065e-02f, 8.76528025e-02f,
  3.13487314e-02f, 2.29530782e-02f, -7.12083727e-02f, -1.81030333e-02f, -1.24143943e-01f, 3.87383439e-02f, 4.99330126e-02f, -6.35779798e-02f, -3.52987945e-02f, -6.19730130e-02f,
  5.28571419e-02f, 3.75389457e-02f, -6.57620281e-03f, 9.23442319e-02f, 1.30950641e-02f, -4.16131923e-03f, 1.62555259e-02f, -3.45240869e-02f, 4.27313037e-02f, -1.37341276e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.49606624e-01f, 5.23631692e-01f, 4.84003484e-01f, 2.08579138e-01f, -1.21013343e-01f, -5.26918352e-01f, -7.84876719e-02f, 2.17051625e-01f, 6.71784639e-01f, 2.38725692e-01f,
  -3.60656112e-01f, 6.60878360e-01f, -1.35532111e-01f, 3.09985485e-02f, -5.25138319e-01f, -3.04284632e-01f, -3.43859822e-01f, -2.45189384e-01f, -2.33876705e-02f, 5.41987084e-02f,
  -1.73555493e-01f, -4.14160669e-01f, -3.12583685e-01f, -3.52898762e-02f, 2.92845398e-01f, 3.56326103e-01f, -5.20951807e-01f, 1.56233147e-01f, -2.23282024e-01f, 8.30072984e-02f,
  -2.05974177e-01f, 5.39992273e-01f, 3.16265672e-01f, 2.38715187e-02f, -1.92372188e-01f, 5.43050803e-02f, 5.62514029e-02f, -9.86657888e-02f, 3.28249261e-02f, 2.54609287e-02f,
  2.93884963e-01f, -9.56387222e-02f, 7.50888586e-02f, 1.01899104e-02f, 3.50217670e-01f, 1.56112120e-01f, 5.36371917e-02f, -2.03538686e-02f, 4.05521393e-01f, 1.42483991e-02f,
  8.37871581e-02f, 5.97358048e-02f, 4.02302705e-02f, 5.59317274e-03f, 6.26703501e-02f, 1.48267448e-01f, -1.52923316e-01f, -2.68163562e-01f, 1.79890711e-02f, 1.78244606e-01f,
  1.65803492e-01f, -3.50524783e-01f, -1.88314885e-01f, 4.97757494e-02f, -9.12668034e-02f, 1.71595499e-01f, 1.41455635e-01f, -6.51281253e-02f, 1.37472050e-02f, -2.60772146e-02f,
  -2.51515925e-01f, 1.08388156e-01f, 2.42217258e-01f, 2.84220576e-02f, 9.76945162e-02f, 1.20656259e-01f, -9.96094495e-02f, -2.64353067e-01f, 2.80046370e-02f, -7.31051341e-02f,
  5.02568670e-02f, -1.27654567e-01f, 8.27308744e-02f, -1.25909597e-01f, 1.26996875e-01f, 1.29278153e-01f, 1.68465227e-01f, 2.29529232e-01f, -1.60554752e-01f, -1.16168417e-01f,
  -4.78319705e-01f, 2.82524200e-03f, 1.03228681e-01f, 5.76355904e-02f, -3.23743857e-02f, -1.33080706e-01f, -1.79673105e-01f, 1.28944233e-01f, 2.23922744e-01f, -9.89703536e-02f,
  1.63465384e-02f, 7.03521073e-02f, -3.61185037e-02f, -2.10083306e-01f, 3.79087254e-02f, -6.01276122e-02f, 6.32132590e-02f, 3.02386261e-03f, 1.44838065e-01f, -1.52829468e-01f,
  -1.20151369e-02f, 5.77151887e-02f, -6.17053360e-03f, -2.62232050e-02f, -1.60948291e-01f, 4.27594148e-02f, -1.06008917e-01f, -1.84196178e-02f, 1.25011876e-02f, -1.10677831e-01f,
  3.53325129e-01f, -4.63738918e-01f, 3.59789729e-01f, 2.91794270e-01f, 1.28425777e-01f, 2.22381696e-01f, 8.41216862e-01f, -3.25585067e-01f, -2.07828004e-02f, -4.63863909e-01f,
  -2.72622164e-02f, 1.72573775e-01f, 3.32748622e-01f, -2.64830828e-01f, 7.41195440e-01f, 2.12622538e-01f, -1.01619154e-01f, 2.19265312e-01f, -5.58914877e-02f, 8.27017277e-02f,
  7.69050941e-02f, -4.21822667e-01f, 2.24504694e-01f, -6.40860438e-01f, -1.77967131e-01f, -2.38131925e-01f, -4.27297615e-02f, 1.54138327e-01f, -5.09000182e-01f, 1.22747257e-01f,
  -2.71226484e-02f, -1.74705639e-01f, -6.58225641e-02f, -1.70040712e-01f, -6.90352097e-02f, -7.97730219e-03f, 1.95929676e-01f, 3.57080668e-01f, 9.29560587e-02f, -1.23326562e-01f,
  2.38628071e-02f, -2.30384413e-02f, -1.68577328e-01f, 6.75404295e-02f, 9.45405941e-03f, -1.60511240e-01f, -8.35042000e-02f, -1.00364432e-01f, -1.65918618e-01f, 2.48514442e-03f,
  4.79913428e-02f, -7.00371116e-02f, 6.39147088e-02f, 2.90303770e-02f, 1.09427370e-01f, -1.03524052e-01f, 3.17028165e-02f, 2.19652906e-01f, -9.24533606e-02f, -9.91555676e-02f,
  -9.07741860e-02f, 8.98159742e-02f, -7.27343336e-02f, -1.44578978e-01f, 2.66392343e-02f, -1.42607406e-01f, -5.19935675e-02f, 7.58168921e-02f, 1.07093237e-01f, 1.95579663e-01f,
  5.45047708e-02f, 4.42660600e-02f, 9.72534195e-02f, 5.14931567e-02f, -2.76477095e-02f, -1.73524711e-02f, 1.80950120e-01f, -1.25792027e-01f, -3.44476774e-02f, -2.19176114e-01f,
  -5.07574305e-02f, 7.79249892e-02f, 3.30444723e-02f, -7.28797121e-03f, -2.14089062e-02f, 1.80676326e-01f, -2.18631849e-01f, 4.52346504e-02f, -8.01664665e-02f, 1.16190396e-01f,
  -1.73828527e-01f, -4.75078404e-01f, 5.04167145e-03f, -1.79926232e-01f, -7.66562149e-02f, -6.67125285e-02f, 4.00893763e-02f, -2.67304301e-01f, 9.63918790e-02f, -1.41894326e-01f,
  5.63085601e-02f, -2.16178261e-02f, -4.42003198e-02f, 5.83278984e-02f, 5.81037328e-02f, -1.15809135e-01f, 1.47332877e-01f, 3.36034894e-02f, -8.73768795e-03f, -1.86846837e-01f,
  3.01153734e-02f, 1.30050763e-01f, 1.66903242e-01f, -1.70555431e-02f, -9.76339877e-02f, 1.15433566e-01f, -5.03635332e-02f, 6.80150241e-02f, -6.79998547e-02f, 3.09992190e-02f,
  6.31396472e-01f, -4.22020406e-01f, -4.65802670e-01f, 5.08851111e-01f, 4.14548695e-01f, 1.52799562e-02f, -4.94561680e-02f, 3.72634768e-01f, -4.99526830e-03f, -1.79515749e-01f,
  1.23333521e-01f, -1.91055298e-01f, -5.91246545e-01f, 4.55779612e-01f, 5.96377611e-01f, -7.04365134e-01f, 5.58655143e-01f, 7.95885175e-02f, -2.84974009e-01f, 2.90829748e-01f,
  4.30010945e-01f, 9.20729995e-01f, -1.82727620e-01f, 4.99281406e-01f, 6.03395581e-01f, 3.12419217e-02f, 4.47417289e-01f, -3.24573457e-01f, 4.56936359e-01f, 2.87997335e-01f,
  -3.71364988e-02f, -3.21353935e-02f, 8.62449035e-02f, -5.81895858e-02f, 8.88343751e-02f, 1.08001254e-01f, -3.22483331e-02f, -5.43172695e-02f, -4.36001569e-02f, -7.63288438e-02f,
  3.01407278e-02f, 1.36908039e-01f, 1.29156664e-01f, 5.99852130e-02f, 2.65099764e-01f, 9.02293175e-02f, -1.33710504e-01f, -1.34682193e-01f, -2.13889219e-02f, -1.90049317e-02f,
  -1.31877169e-01f, -1.56620145e-02f, 1.94521112e-04f, -8.09812397e-02f, 3.32798809e-02f, 3.47020142e-02f, -1.89650670e-01f, -1.42262712e-01f, -7.16268197e-02f, 1.50461644e-01f,
  1.73349962e-01f, 1.95972957e-02f, -6.79890290e-02f, 5.13164233e-03f, 2.58483887e-02f, 2.90174037e-02f, 2.96926685e-02f, -6.27212152e-02f, -5.21654561e-02f, 4.96036559e-02f,
  -1.11214770e-02f, 9.99132246e-02f, -2.76149269e-02f, 2.53722612e-02f, 7.71132335e-02f, -1.20517481e-02f, 2.25943211e-03f, -1.35391140e-02f, -6.49381056e-02f, -2.21366510e-02f,
  -6.33225590e-03f, 2.09370241e-01f, -1.79220550e-02f, -4.03976887e-02f, -2.55162865e-02f, 5.35619482e-02f, 1.82400942e-01f, 3.74652185e-02f, -1.65251732e-01f, -1.23619540e-02f,
  5.33613302e-02f, 2.96458811e-03f, -9.04702693e-02f, 1.21947732e-02f, -1.29728124e-01f, 1.23562224e-01f, -7.51100555e-02f, 1.35343626e-01f, 6.47579960e-04f, 6.79560378e-02f,
  2.10379720e-01f, -5.68884276e-02f, -1.18009388e-01f, -7.87971728e-03f, -1.88926365e-02f, 1.24922365e-01f, -1.09358467e-01f, 1.00669516e-02f, 2.12990373e-01f, 3.97754684e-02f,
  2.80623194e-02f, -5.59154078e-02f, 6.78765699e-02f, -7.34675974e-02f, -5.28075509e-02f, -9.53186378e-02f, 2.40018815e-02f, -5.55376150e-02f, -5.45623638e-02f, -8.04699287e-02f,
  -1.33053720e+00f, 7.20380306e-01f, 7.85109773e-02f, -5.92496932e-01f, 2.51997173e-01f, -5.16880378e-02f, -3.12353790e-01f, 2.46811435e-01f, -1.13057964e-01f, 1.91268101e-01f,
  4.24746498e-02f, -3.13484460e-01f, 4.63822335e-01f, 8.61374512e-02f, -4.40789789e-01f, 4.25196826e-01f, -1.65025920e-01f, -4.15549994e-01f, 1.25002414e-01f, -2.26225659e-01f,
  -1.05065309e-01f, 2.07469121e-01f, 5.54995313e-02f, 5.04661977e-01f, -1.96235001e-01f, -2.36857906e-01f, -2.09946275e-01f, 2.57982790e-01f, -1.18667841e-01f, 2.32272655e-01f,
  -5.03937185e-01f, -3.73477817e-01f, -4.24767941e-01f, -2.25589126e-01f, -1.74955428e-01f, -8.20345432e-02f, -1.71881080e-01f, -5.75100593e-02f, -7.00723007e-02f, -4.21047881e-02f,
  -1.07241690e-01f, 1.13538846e-01f, 4.94061075e-02f, 9.60419551e-02f, -1.27748236e-01f, 3.14650610e-02f, 1.19582102e-01f, -1.05783150e-01f, -7.20861088e-03f, 1.67273358e-01f,
  1.65828690e-01f, -2.71389820e-03f, -1.24056585e-01f, -1.15025109e-02f, 5.96731668e-03f, 4.82473522e-02f, -1.00903943e-01f, 2.54339818e-02f, -1.09243229e-01f, -3.32840942e-02f,
  1.04126753e-02f, 6.99903667e-02f, -4.01031757e-05f, -8.61714855e-02f, 7.94139877e-02f, -5.45121804e-02f, -1.54438196e-02f, -4.67255190e-02f, 7.22516840e-03f, 5.44723384e-02f,
  3.33800577e-02f, -1.40762433e-01f, 8.26649144e-02f, 1.88351553e-02f, 9.59312369e-04f, -3.67605351e-02f, -1.11927949e-01f, 2.94837356e-02f, 5.10425977e-02f, -1.44239038e-01f,
  -6.76484779e-02f, 2.17501670e-02f, 5.70777468e-02f, -2.18148343e-02f, 3.43042910e-02f, -3.48184854e-02f, 2.22210679e-02f, 4.09870744e-02f, -9.14150774e-02f, -3.87554578e-02f,
  -8.25059295e-01f, -6.25473440e-01f, -5.47856204e-02f, -1.56224579e-01f, -8.40514302e-02f, 5.63688874e-02f, 5.31201996e-02f, -1.24173462e-02f, -4.99934703e-02f, -1.50685376e-02f,
  -7.04295561e-03f, -4.34936285e-02f, -2.74767160e-01f, -6.55149743e-02f, -1.30214654e-02f, -1.84703413e-02f, -1.38013721e-01f, -1.12969734e-01f, -3.11299324e-01f, -5.91566265e-02f,
  -1.28925189e-01f, -5.40350005e-02f, 1.02942027e-01f, -8.17511827e-02f, -1.11132320e-02f, -1.05396338e-01f, -1.58718929e-01f, 7.36527964e-02f, 2.83611636e-03f, 8.84702355e-02f,
  3.85472804e-01f, -4.05482017e-02f, -4.56560582e-01f, -3.18186671e-01f, -1.80701107e-01f, -5.39165199e-01f, -5.90820730e-01f, -3.02533835e-01f, -1.43133283e-01f, -2.45239168e-01f,
  -6.20509505e-01f, 6.48517162e-02f, 4.16986257e-01f, -5.81042409e-01f, 4.15517867e-01f, 2.38472089e-01f, -3.65419239e-01f, -1.85642689e-01f, 8.17494169e-02f, -6.16592504e-02f,
  -7.89945498e-02f, -4.79478613e-02f, -2.07396641e-01f, -2.61509001e-01f, -3.68239552e-01f, -1.05180807e-01f, 2.07408533e-01f, -3.34563434e-01f, -5.59191406e-01f, -1.94725201e-01f,
  -2.87025809e-01f, -9.01271403e-02f, -2.71941930e-01f, 3.72934490e-02f, 3.46368141e-02f, 1.26677737e-01f, -5.38171679e-02f, -1.16456747e-02f, 6.67015538e-02f, 1.06100105e-01f,
  3.61368805e-01f, 1.90639988e-01f, -1.67396322e-01f, 9.37601402e-02f, 1.24518022e-01f, 1.86601058e-02f, 8.77101570e-02f, -1.07504144e-01f, 8.81750509e-02f, 1.14387468e-01f,
  -2.02926770e-02f, 4.69763838e-02f, -7.58326650e-02f, 1.47040069e-01f, -6.30274713e-02f, -8.98760930e-02f, 1.22856498e-01f, -5.70354946e-02f, 2.02028081e-02f, 1.77952647e-01f,
  5.82808862e-03f, 1.43662989e-01f, 1.20673906e-02f, -1.11629635e-01f, -7.65407383e-02f, -8.97170082e-02f, 5.07656038e-02f, 2.00614575e-02f, 8.05158839e-02f, 4.47224043e-02f,
  -3.01348995e-02f, -4.84645031e-02f, 8.65400806e-02f, 9.10479575e-02f, 9.08513516e-02f, 8.91817808e-02f, -3.87824997e-02f, 3.11875492e-02f, -2.80073769e-02f, -1.55818373e-01f,
  -1.46559134e-01f, 1.09428182e-01f, -9.71411690e-02f, 7.28734806e-02f, -7.16173202e-02f, 1.12146333e-01f, 1.37894168e-01f, -8.73665558e-05f, -1.60126492e-01f, 1.87245794e-02f,
  -1.12229370e-01f, 1.14615478e-01f, -1.32637486e-01f, 3.80252511e-03f, -2.05894131e-02f, -5.06973825e-02f, -1.49472013e-01f, -1.10159419e-01f, 9.84887034e-02f, 1.95978925e-01f,
  8.00849050e-02f, -3.95548195e-02f, 9.08620581e-02f, -7.10159987e-02f, -8.12017769e-02f, -1.55552551e-01f, 1.58561885e-01f, 1.00309439e-02f, 6.72859028e-02f, 7.03371316e-02f,
  6.02372587e-02f, 5.70832491e-02f, 2.54570961e-01f, -1.15636876e-02f, 1.33534521e-01f, -5.65231927e-02f, -3.54551710e-02f, -2.94400435e-02f, 2.55830437e-01f, 3.56651992e-02f,
  -3.87747228e-01f, -3.73784691e-01f, -3.76673728e-01f, -5.93884706e-01f, 3.42818201e-01f, -1.60384730e-01f, -4.18341666e-01f, 1.50431484e-01f, -3.61553997e-01f, 2.99506456e-01f,
  -6.55875504e-02f, -3.84189636e-01f, 4.56224149e-03f, -7.57659495e-01f, -7.59974182e-01f, -3.63591403e-01f, -6.92006648e-01f, -2.46124372e-01f, -1.46889508e-01f, -3.69303748e-02f,
  -1.11660361e-01f, -1.46855175e-01f, -4.85723227e-01f, 3.50934625e-01f, -9.59462598e-02f, 3.01565751e-02f, 4.22228575e-01f, 3.02857578e-01f, 5.12364134e-03f, -1.07973501e-01f,
  -2.60157436e-01f, -9.81339738e-02f, -1.00902721e-01f, 3.88454273e-02f, 5.12108095e-02f, 1.96715787e-01f, 5.27267791e-02f, -2.12127920e-02f, -1.27212241e-01f, -6.18577525e-02f,
  4.64730412e-02f, -5.23418747e-02f, -1.20259777e-01f, 3.19235101e-02f, 2.15290442e-01f, 6.63437843e-02f, -5.09896278e-02f, -6.21072948e-02f, -1.74023569e-01f, -6.76418170e-02f,
  -1.12051129e-01f, 5.52778468e-02f, -2.09189169e-02f, -1.24560416e-01f, -4.44540493e-02f, 8.12672973e-02f, -3.06171346e-02f, 7.76000097e-02f, -2.58881822e-02f, 1.02598220e-01f,
  5.05337752e-02f, 1.78073213e-01f, 6.06577657e-02f, -4.02894132e-02f, -1.00979023e-01f, -8.35986510e-02f, -2.24318728e-03f, -1.02218620e-01f, 1.33167095e-02f, -9.83685348e-03f,
  1.84846651e-02f, -2.80929860e-02f, 2.05822550e-02f, 2.43280083e-02f, -5.81660606e-02f, -8.32221061e-02f, 4.24265452e-02f, -6.87231775e-03f, -1.71679258e-01f, -1.70921341e-01f,
  7.15369508e-02f, 7.04877749e-02f, 3.96869145e-02f, 3.07399146e-02f, 1.48880454e-02f, -6.67089876e-03f, 1.47565097e-01f, 1.38404546e-02f, -5.99934421e-02f, 7.91313201e-02f,
  -3.09338626e-02f, 2.09746659e-01f, -4.53980081e-02f, 6.67042285e-02f, -8.75748694e-02f, 1.13053270e-01f, -6.09990880e-02f, -1.02665626e-01f, 2.71395165e-02f, 1.35228977e-01f,
  2.05042168e-01f, 4.36394252e-02f, 2.87164688e-01f, -1.26395658e-01f, -1.12195678e-01f, 2.88396720e-02f, 2.31625557e-01f, -6.66166544e-02f, -4.13050242e-02f, -1.08810082e-01f,
  2.70129889e-01f, 9.78009254e-02f, -1.15135677e-01f, 1.60242110e-01f, 1.13152534e-01f, 9.08733755e-02f, -2.44408343e-02f, -5.20405658e-02f, 1.36319399e-01f, 4.09371890e-02f,
  4.50475872e-01f, -7.57498920e-01f, 2.35484555e-01f, 2.50581652e-01f, 1.26533672e-01f, 3.95394415e-01f, 2.27806777e-01f, -3.36353958e-01f, -2.47668058e-01f, -3.93452227e-01f,
  -1.19780459e-01f, 5.32407910e-02f, -4.47301775e-01f, -6.56155776e-03f, 5.38906693e-01f, -2.86670685e-01f, 1.27589136e-01f, 4.14323471e-02f, -2.32779309e-01f, -2.01446444e-01f,
  5.53194620e-02f, 1.68826468e-02f, 2.12907985e-01f, -4.83499356e-02f, 7.38166347e-02f, 1.38689414e-01f, 2.27836985e-03f, 1.09018683e-01f, 4.16672796e-01f, 2.05989286e-01f,
  -2.88369358e-01f, -2.53891230e-01f, -9.78074446e-02f, -1.88903898e-01f, 2.67622210e-02f, 8.66753161e-02f, 5.66224568e-02f, 1.63568169e-01f, 7.62553439e-02f, 7.29557779e-03f,
  1.10449931e-02f, 9.62498114e-02f, 1.55359134e-01f, 9.43941325e-02f, -1.53244928e-01f, 4.32202220e-02f, 2.77144648e-02f, -1.02850564e-01f, 7.10270777e-02f, -1.33888766e-01f,
  -8.55221003e-02f, 7.60585964e-02f, -6.62820339e-02f, 5.38636521e-02f, -4.15700153e-02f, 1.91778131e-02f, 1.33335456e-01f, -1.67595893e-02f, -1.18839622e-01f, 6.99502304e-02f,
  -1.08241765e-02f, -4.09034230e-02f, -1.89960882e-01f, -1.52890719e-02f, -1.21070080e-01f, 6.68339431e-02f, 1.35580674e-01f, 1.11843571e-01f, -5.65247461e-02f, -6.99228793e-02f,
  9.77566689e-02f, 1.43906176e-02f, -1.12269007e-01f, -1.03500761e-01f, 3.61498520e-02f, -6.01080470e-02f, 1.54972628e-01f, -1.87459942e-02f, 1.00644886e-01f, 5.35583235e-02f,
  2.59995386e-02f, 1.31143210e-02f, -1.09423019e-01f, 1.86049819e-01f, -2.37709284e-02f, 4.63595204e-02f, -2.51399796e-03f, -4.89630774e-02f, -1.36109561e-01f, 1.09323651e-01f,
  -8.59770179e-01f, -7.38813698e-01f, -1.16514318e-01f, -7.08101615e-02f, 7.62900934e-02f, -7.26754367e-02f, 8.02381933e-02f, -3.37538756e-02f, -1.42980292e-01f, -3.64856496e-02f,
  -1.12079293e-01f, 1.22048929e-01f, -4.18216325e-02f, 1.39511712e-02f, 7.98573568e-02f, 2.35228054e-02f, -9.29127447e-04f, -9.21225548e-02f, 6.82390109e-02f, -5.80179170e-02f,
  -2.12285578e-01f, -7.31383860e-02f, 1.56540841e-01f, 8.76764134e-02f, -9.63019729e-02f, 1.18425719e-01f, 2.53610518e-02f, 2.89076306e-02f, 6.82246909e-02f, -2.41654143e-02f,
  -7.90487528e-01f, 3.68252426e-01f, -5.73873997e-01f, 5.44503778e-02f, 1.13545418e-01f, 4.73047763e-01f, 1.54591948e-01f, -3.28575401e-03f, -6.02990568e-01f, 4.21751827e-01f,
  2.83095151e-01f, -5.74588418e-01f, -2.04147175e-01f, 3.65021735e-01f, -5.87419748e-01f, -4.38677222e-01f, 5.21278977e-01f, 1.77534267e-01f, -3.24420422e-01f, 2.20401943e-01f,
  -3.14051330e-01f, 3.53296220e-01f, -9.76205692e-02f, 8.73990208e-02f, 8.41645375e-02f, -4.03925404e-02f, 5.31624138e-01f, -5.13550639e-02f, 5.12370169e-01f, -1.73528165e-01f,
  -5.84942810e-02f, -3.04739803e-01f, -1.55216634e-01f, -3.10895950e-01f, 2.29622781e-01f, 1.80288017e-01f, 9.43551213e-02f, -2.42621705e-01f, -1.44225091e-01f, -5.24279848e-02f,
  -1.07333183e-01f, -2.69157439e-01f, -4.00609970e-02f, -4.60753813e-02f, -7.16150925e-02f, -9.22920480e-02f, -9.09163617e-03f, 1.13411583e-01f, 1.54242858e-01f, -1.86727598e-01f,
  -1.62163302e-01f, 3.18642259e-02f, 8.41156989e-02f, 1.75962836e-01f, -3.08758885e-01f, -4.66991961e-02f, 4.93237898e-02f, 1.07249372e-01f, 1.24107875e-01f, -4.48604636e-02f,
  -6.28771707e-02f, -1.28219306e-01f, -1.04392588e-01f, -4.22174856e-02f, -1.08418003e-01f, 1.42392054e-01f, 1.65875703e-01f, 1.34989927e-02f, -1.31066978e-01f, 4.79883999e-02f,
  6.89539220e-03f, 4.11015339e-02f, 7.71386251e-02f, 1.43668756e-01f, 5.52141555e-02f, -1.30780265e-02f, -8.60844031e-02f, -1.05216675e-01f, 3.85034904e-02f, 6.27439842e-02f,
  -6.19231239e-02f, -8.91979933e-02f, -5.69310541e-05f, 2.01979816e-01f, -6.19345857e-03f, -5.62749133e-02f, 1.32716775e-01f, 4.21006270e-02f, 5.98194003e-02f, -3.55782844e-02f,
  4.68624324e-01f, 1.61023036e-01f, -1.65913999e-01f, -1.66052431e-02f, 3.57454009e-02f, 9.63115841e-02f, 3.79923731e-03f, -2.85308738e-03f, 1.07323982e-01f, 4.05012779e-02f,
  2.41334990e-01f, -3.44864801e-02f, 1.17644154e-01f, -8.22129920e-02f, 8.51338878e-02f, 1.80739239e-01f, 1.44495681e-01f, -1.27275297e-02f, 2.56961167e-01f, 2.77678818e-01f,
  1.64396301e-01f, 5.87697327e-02f, -2.21111346e-02f, 2.14466956e-02f, 1.28207490e-01f, 1.00991167e-01f, 2.08096467e-02f, 9.55745578e-02f, 8.97317231e-02f, -2.19967924e-02f,
  -4.16141972e-02f, -4.54789162e-01f, 5.79764485e-01f, -2.29760423e-01f, 5.63866019e-01f, 5.89844465e-01f, 3.76098156e-01f, 1.48749780e-02f, -9.32679176e-02f, -5.84047318e-01f,
  -2.56935745e-01f, -3.52629155e-01f, 8.84141549e-02f, -2.35298052e-01f, 5.52592635e-01f, 1.10720590e-01f, 1.01803698e-01f, -1.21609017e-01f, 2.78870374e-01f, 1.37319967e-01f,
  1.02930866e-01f, -2.23920554e-01f, 3.91821504e-01f, -1.91031858e-01f, 1.20979905e-01f, -1.83053553e-01f, -2.79476285e-01f, 1.22833751e-01f, -4.36332166e-01f, 1.03589632e-01f,
  2.61578597e-02f, -1.49209350e-01f, 2.81017303e-01f, 3.28989215e-02f, -1.39046786e-02f, 1.28778607e-01f, -1.63210005e-01f, 1.13587044e-01f, 1.40598506e-01f, -4.61677536e-02f,
  3.52159292e-02f, -1.37017846e-01f, -4.66889217e-02f, 1.76071629e-01f, 6.19347468e-02f, 7.40255490e-02f, 2.30198562e-01f, 7.72121102e-02f, 1.22715250e-01f, 1.97104186e-01f,
  2.18832985e-01f, 1.00797348e-01f, 1.44114867e-01f, -2.27514341e-01f, 1.19887285e-01f, -4.85917516e-02f, 1.67118609e-02f, 3.81651265e-03f, 3.07356343e-02f, -5.72711863e-02f,
  6.49690479e-02f, 1.31226212e-01f, 1.09921716e-01f, -4.22806181e-02f, -5.90267330e-02f, -4.34445478e-02f, 4.57036160e-02f, -9.47286710e-02f, -2.53680274e-02f, -4.90752459e-02f,
  -1.93434581e-01f, -5.34490049e-02f, 2.74184067e-02f, 6.63066655e-02f, -1.89789949e-04f, -1.72357097e-01f, -1.06947802e-01f, -1.56929150e-01f, 2.48444118e-02f, 1.12441005e-02f,
  -1.09981671e-01f, -5.48926704e-02f, 2.00624485e-02f, 2.25426834e-02f, 3.50202881e-02f, 1.17831506e-01f, 9.62675840e-04f, 1.62041783e-02f, 8.43330100e-02f, 7.41798505e-02f,
  -3.72935444e-01f, -6.75892830e-01f, 5.65985441e-02f, -2.12170687e-02f, -1.36314824e-01f, 1.22362580e-02f, 9.04716626e-02f, -1.05684578e-01f, -1.51753634e-01f, 4.13591899e-02f,
  7.33970627e-02f, -7.19856247e-02f, 3.42721194e-02f, -6.58758283e-02f, -5.22710420e-02f, 3.03988829e-02f, -5.37517630e-02f, -2.01189965e-01f, -7.23320246e-02f, -1.49940759e-01f,
  2.29788627e-02f, -1.04793474e-01f, 4.79334779e-02f, -5.62690757e-03f, -1.25006407e-01f, -1.25944242e-01f, -1.36711165e-01f, -2.60329619e-02f, 7.61588812e-02f, 1.40197314e-02f,
  6.58980161e-02f, 1.64472848e-01f, -5.54214299e-01f, -1.49930343e-01f, -3.46490026e-01f, 5.26360214e-01f, 5.35071313e-01f, -7.33687058e-02f, -1.96087062e-02f, 7.61188924e-01f,
  4.45937335e-01f, 9.75711364e-03f, 3.17822665e-01f, 8.00713599e-01f, 5.95204858e-03f, 6.20444059e-01f, 5.86205006e-01f, 5.36315143e-01f, -1.42238274e-01f, 1.57580882e-01f,
  -1.14726059e-01f, 6.64878786e-01f, 1.17024602e-02f, 1.60034031e-01f, 2.21025899e-01f, -4.92721468e-01f, -1.87612325e-01f, -3.65375161e-01f, 1.95405155e-01f, 3.27286944e-02f,
  1.60576254e-01f, 4.37297113e-02f, -6.82682265e-03f, -9.24306959e-02f, -1.37690023e-01f, -8.82687494e-02f, -1.33373439e-01f, -5.42625934e-02f, -1.56231523e-01f, 5.97746344e-03f,
  -1.54684214e-02f, -8.31668451e-02f, 7.93286115e-02f, -1.16574407e-01f, -8.60374346e-02f, -1.02416150e-01f, -7.77722802e-03f, 2.73594912e-02f, -9.33518559e-02f, -4.12781201e-02f,
  -1.29728258e-01f, 1.32211387e-01f, 9.56835747e-02f, -6.09597601e-02f, -7.14966282e-02f, -3.91284004e-02f, 1.28506303e-01f, -1.10256545e-01f, -1.69407595e-02f, -4.13004719e-02f,
  8.42437372e-02f, 4.82530966e-02f, 1.41169563e-01f, 6.37268573e-02f, 2.72900127e-02f, 2.05910597e-02f, 1.76149100e-01f, 8.81084725e-02f, -1.13162346e-01f, 1.78733423e-01f,
  -5.51827811e-03f, -6.90217763e-02f, 8.95128101e-02f, 3.44206877e-02f, 9.74421129e-02f, -5.77474432e-03f, -1.32191613e-01f, 1.11354338e-02f, -1.89502463e-02f, -3.66198691e-03f,
  4.29910123e-02f, -5.66103496e-02f, 4.63630147e-02f, 1.58076473e-02f, 1.15368709e-01f, -6.02185950e-02f, 1.08033836e-01f, 6.83118850e-02f, -8.65393505e-02f, -7.70476237e-02f,
  1.53446328e-02f, -5.22148609e-03f, 2.88290847e-02f, 3.21851596e-02f, -7.65480846e-02f, 1.29132792e-02f, 5.65296076e-02f, 1.25674352e-01f, 3.74499299e-02f, -6.21254891e-02f,
  -1.43576548e-01f, 7.65625536e-02f, 6.32338151e-02f, -3.87178287e-02f, -8.86686444e-02f, 9.40543637e-02f, 1.75221249e-01f, -2.01240480e-01f, -4.51581068e-02f, -1.71054780e-01f,
  2.29731458e-03f, -4.92600799e-02f, -2.25084126e-02f, -4.41583730e-02f, 6.92615956e-02f, 5.34151979e-02f, -1.47602528e-01f, -1.04676872e-01f, -6.58991113e-02f, 6.92671314e-02f,
  7.93501318e-01f, 8.42193738e-02f, 2.07679302e-01f, 9.05182242e-01f, 3.73699486e-01f, 2.39702344e-01f, 2.16686025e-01f, 5.25142431e-01f, 1.04968858e+00f, -2.55482018e-01f,
  -2.71511197e-01f, -1.24769852e-01f, -5.89503407e-01f, 2.98215061e-01f, -2.20237091e-01f, -2.64809191e-01f, 4.71212000e-01f, 1.05043732e-01f, 3.44794005e-01f, 1.79901525e-01f,
  2.40935192e-01f, -5.85471541e-02f, -3.89889777e-01f, -2.24597037e-01f, 1.32201627e-01f, 1.87273175e-01f, -5.37990451e-01f, -4.30489302e-01f, -2.13900894e-01f, -2.56158561e-01f,
  2.06572518e-01f, 2.29812428e-01f, -3.28774527e-02f, 7.53006339e-02f, 1.49898931e-01f, 4.81696241e-02f, 3.25957276e-02f, -2.43845895e-01f, 1.51258722e-01f, 9.31892172e-02f,
  -4.41878103e-02f, 2.48051714e-02f, 1.71374083e-01f, -9.09256190e-02f, 1.36079952e-01f, 2.09862500e-01f, 1.42541662e-01f, 1.39051601e-01f, 4.71769422e-02f, -2.75618695e-02f,
  9.80046242e-02f, 1.25726283e-01f, 2.53803372e-01f, 5.95436208e-02f, -3.17488760e-02f, 2.47266352e-01f, 5.30639142e-02f, -7.77038857e-02f, 1.11179464e-02f, 1.58989459e-01f,
  -1.47602290e-01f, 5.54522201e-02f, 4.25355807e-02f, -2.11753957e-02f, 1.12533411e-02f, 1.96627099e-02f, -1.19377993e-01f, -7.35350698e-02f, 7.42668658e-02f, -2.14259475e-02f,
  1.23683609e-01f, 1.51139587e-01f, 1.01251848e-01f, 1.12027362e-01f, -4.48225290e-02f, 4.14829031e-02f, -5.96265830e-02f, 3.40395682e-02f, 1.61621079e-01f, 1.07790455e-01f,
  -9.68610793e-02f, 9.07761157e-02f, -1.60189733e-01f, 2.66874153e-02f, -3.77734601e-02f, -5.78123331e-02f, -1.37651926e-02f, -9.95432865e-03f, -2.74822339e-02f, -1.50803059e-01f,
  -1.18424511e-02f, -1.23010121e-01f, -1.71958536e-01f, -8.40553641e-02f, -6.31631389e-02f, -9.68987793e-02f, 2.17180829e-02f, 6.65363520e-02f, 1.77489184e-02f, 8.12255591e-02f,
  6.13606581e-03f, 1.44417817e-03f, -9.67088044e-02f, -2.92168856e-02f, -6.24925233e-02f, -7.76654556e-02f, 7.41498603e-04f, -3.06275152e-02f, -4.81001586e-02f, -4.17821184e-02f,
  -9.54518393e-02f, -3.03168241e-02f, -5.52715510e-02f, 1.52126804e-01f, 3.42177935e-02f, -1.64459229e-01f, 9.86641496e-02f, 5.23609743e-02f, -8.09159279e-02f, 7.00996071e-03f,
  1.85102686e-01f, 6.17592275e-01f, 2.26449087e-01f, 2.21783683e-01f, -3.23754847e-01f, -1.28992826e-01f, -2.69222915e-01f, -3.81684192e-02f, 1.81061953e-01f, 4.03897256e-01f,
  -3.86642814e-01f, 8.89685214e-01f, 5.80634251e-02f, -9.76771265e-02f, -4.48661506e-01f, -2.84142494e-01f, -2.40537450e-01f, 1.71362817e-01f, -4.04205620e-02f, 5.50003909e-02f,
  -8.21401924e-02f, -5.86488366e-01f, -3.69406402e-01f, -1.46548226e-01f, -1.62890494e-01f, 2.04406366e-01f, -4.84508902e-01f, -1.96519554e-01f, -6.53833002e-02f, -2.78306425e-01f,
  -1.68100312e-01f, -6.67188142e-04f, 1.66845098e-01f, -1.96996797e-02f, -1.00089483e-01f, 9.88448970e-03f, -6.64558783e-02f, -7.72918314e-02f, -5.33610359e-02f, 1.03508085e-01f,
  1.13902524e-01f, -2.39005491e-01f, 2.64433362e-02f, 1.72560319e-01f, -4.85676639e-02f, 5.46692535e-02f, 6.73626140e-02f, -8.63688141e-02f, 1.18127577e-01f, 1.12463884e-01f,
  7.37556219e-02f, 1.67968139e-01f, 2.50858422e-02f, 4.00993116e-02f, -1.33514658e-01f, -2.15121925e-01f, 1.40963063e-01f, 1.56695407e-03f, 1.37025058e-01f, -2.14146022e-02f,
  -1.64381042e-01f, 4.06077355e-02f, -2.72423066e-02f, -1.13762222e-01f, -1.60847157e-01f, -8.61568302e-02f, 2.11895946e-02f, -1.68550447e-01f, -6.71596676e-02f, -1.13293892e-02f,
  -1.11635022e-01f, 8.75071362e-02f, -5.70772402e-02f, 1.74415708e-01f, -5.41590638e-02f, 7.35753332e-04f, 9.71359760e-03f, 1.98907852e-01f, -7.22335652e-02f, -8.88992250e-02f,
  1.77764520e-01f, -2.51923315e-02f, 2.39687949e-01f, -3.81762460e-02f, -1.79024756e-01f, -1.37449935e-01f, 1.36489287e-01f, 2.42282137e-01f, -1.47071416e-02f, -1.08100817e-01f,
  -3.45078319e-01f, -1.81952745e-01f, -5.23518585e-02f, 8.24273676e-02f, -5.33190928e-03f, 9.13588107e-02f, 7.63572156e-02f, 1.69706509e-01f, -3.22907388e-01f, -7.73971260e-04f,
  -1.44626319e-01f, -5.38235195e-02f, -7.21061677e-02f, -3.09962407e-02f, 4.50149663e-02f, 2.08951486e-03f, -1.76379353e-01f, -4.41471301e-02f, -1.26450241e-01f, -1.83905028e-02f,
  -4.27796245e-02f, 1.38550088e-01f, 1.30010284e-02f, -1.41778052e-01f, 4.92312014e-02f, -1.34251207e-01f, 1.92491606e-01f, 2.28567317e-01f, -9.79323238e-02f, -9.99902114e-02f,
  1.69845074e-01f, 4.08635110e-01f, 3.46383005e-01f, 6.23379946e-01f, -1.89123183e-01f, -4.83065724e-01f, -5.63436508e-01f, 1.11727938e-01f, -2.59328544e-01f, -2.78353214e-01f,
  -5.75826652e-02f, 3.21176410e-01f, -4.31059867e-01f, 4.82366025e-01f, 3.77333760e-01f, -3.12034756e-01f, 4.73978966e-01f, 1.42321348e-01f, 9.83678028e-02f, 4.56511736e-01f,
  2.66623050e-01f, 2.19719857e-01f, 4.79257941e-01f, 2.16919303e-01f, 1.69607520e-01f, 6.24085248e-01f, 4.73087609e-01f, 9.15902667e-03f, 6.97388530e-01f, 1.70523494e-01f,
  -2.14075297e-01f, 1.03191957e-02f, 4.74678762e-02f, -1.59844339e-01f, 5.84963383e-03f, -1.32223755e-01f, -1.06075481e-01f, -7.62410834e-02f, -2.04211518e-01f, 2.63583614e-03f,
  -6.77082613e-02f, 3.12069785e-02f, 2.41850823e-01f, -8.92267749e-02f, -6.03629537e-02f, 9.61898118e-02f, 9.21354964e-02f, -5.20826057e-02f, 2.20523290e-02f, 1.31776676e-01f,
  1.48622498e-01f, -1.84275210e-01f, 3.32524963e-02f, 1.31858038e-02f, 1.66922897e-01f, 1.25725791e-01f, 1.32180667e-02f, -1.10314693e-02f, 1.32420242e-01f, 3.61442603e-02f,
  1.14892475e-01f, -6.74215481e-02f, -7.42173344e-02f, -6.86645359e-02f, 1.67227983e-02f, -9.35064554e-02f, -1.42348688e-02f, -6.46719933e-02f, -6.70750812e-03f, 1.61863640e-02f,
  2.15852987e-02f, 9.37052518e-02f, -7.08132843e-03f, -7.61289373e-02f, 4.99069802e-02f, -6.33758083e-02f, -8.90029296e-02f, -1.32936044e-02f, -1.95230693e-02f, 9.87153202e-02f,
  -9.15864334e-02f, -3.09410691e-02f, 9.10044163e-02f, -2.35488620e-02f, 3.00226477e-03f, 8.35348219e-02f, 8.97578821e-02f, -1.80216413e-02f, -7.74843842e-02f, -5.81584238e-02f,
  2.57650614e-01f, 5.88637471e-01f, 7.88928270e-02f, -1.14632271e-01f, 3.61131579e-02f, -6.80822954e-02f, -6.69522136e-02f, 1.50290266e-01f, 2.90245503e-01f, -1.51866466e-01f,
  4.16397862e-02f, -1.54365422e-02f, 3.02573405e-02f, 1.02195434e-01f, -3.02581433e-02f, 1.79180160e-01f, 1.43161222e-01f, 1.04632732e-02f, 8.40198770e-02f, 1.37657598e-01f,
  9.33349952e-02f, -1.20819643e-01f, 6.00420944e-02f, -1.36827394e-01f, 5.72309569e-02f, 2.15821639e-02f, 2.98176836e-02f, 3.08975447e-02f, 1.39951959e-01f, 5.01571186e-02f,
  -4.09446239e-01f, 4.95572418e-01f, 5.17072558e-01f, -4.50592674e-02f, 4.82888639e-01f, 1.02840364e+00f, 5.69277167e-01f, 5.99986196e-01f, 8.34245920e-01f, 2.78838873e-02f,
  -7.76154697e-02f, 1.56695433e-02f, -1.17173567e-01f, -1.21357545e-01f, 5.69419265e-01f, 4.53305244e-01f, 2.90748239e-01f, 7.44990334e-02f, 1.66717947e-01f, 6.15327095e-04f,
  5.18801101e-02f, -2.22295597e-01f, -2.27101728e-01f, -3.53067875e-01f, -4.21789765e-01f, -2.78235495e-01f, -5.56651771e-01f, 6.62283152e-02f, -3.20026159e-01f, 3.10319185e-01f,
  -5.09063713e-02f, -1.91915125e-01f, -2.87298292e-01f, 8.42944458e-02f, 9.32290256e-02f, -2.51995996e-02f, 5.31355515e-02f, -5.99672738e-03f, 1.50504522e-02f, 8.53273869e-02f,
  -5.86184189e-02f, 7.06688762e-02f, 4.77873273e-02f, -1.80840716e-02f, 1.24978006e-01f, -1.85825266e-02f, -9.34108719e-02f, -6.87266886e-02f, 9.20223743e-02f, 6.00271896e-02f,
  -3.39784101e-02f, 1.09313175e-01f, -1.44398510e-01f, 1.70017898e-01f, -1.92952171e-01f, 7.91449193e-03f, 6.01277873e-02f, 7.98009858e-02f, 1.12792715e-01f, 1.99552760e-01f,
  9.42704007e-02f, 2.10238412e-01f, -1.17013566e-01f, 2.15198472e-02f, -1.15223505e-01f, -1.04360580e-01f, -1.88252069e-02f, -1.39702395e-01f, -9.51347500e-03f, -8.91477317e-02f,
  -8.29939023e-02f, -6.15439676e-02f, 8.37818161e-02f, 1.02727465e-01f, 6.62254728e-03f, -1.57459497e-01f, -1.00542242e-02f, -4.87741828e-02f, 4.72678803e-02f, -1.00462139e-01f,
  -6.51356056e-02f, 2.02912107e-01f, -1.22642569e-01f, -7.91533217e-02f, 9.84760523e-02f, -3.51288840e-02f, 5.63794225e-02f, -1.38001246e-02f, -1.28446102e-01f, 9.37319547e-02f,
  3.78464997e-01f, 5.22604465e-01f, -7.92043190e-03f, -9.84220803e-02f, -7.85093813e-04f, -5.90460934e-03f, 2.06291527e-01f, -2.20691133e-02f, 2.32433394e-01f, 8.57405886e-02f,
  2.36378908e-02f, -6.63170218e-02f, 1.14921853e-01f, -1.09325051e-01f, 8.09780657e-02f, 1.24618143e-01f, 1.40465293e-02f, 9.11474004e-02f, 2.59049237e-01f, -7.48457536e-02f,
  -2.40286738e-01f, 2.89015844e-02f, 4.18486409e-02f, -1.46650910e-01f, -1.74000919e-01f, -3.56531627e-02f, 1.50491169e-03f, -4.58312556e-02f, -4.47515259e-03f, 8.01596269e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.10574412e-01f, 6.97272003e-01f, 5.97359955e-01f, 4.17595327e-01f, 4.45489138e-01f, 4.69965935e-01f, 4.64160949e-01f, 7.91036546e-01f, 6.14136517e-01f, 4.37832952e-01f,
  6.13490224e-01f, 7.11969852e-01f, 4.77240413e-01f, 5.69958568e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.39663798e-01f, -2.15236306e-01f, -1.35856301e-01f, -1.14949033e-01f, 3.46202791e-01f, -8.38358901e-05f, -1.68689474e-01f, -3.88567358e-01f, -3.49927805e-02f, -1.49563905e-02f,
  2.08503634e-01f, 1.36374205e-01f, -3.06340270e-02f, -2.08159000e-01f, 2.84768790e-02f, 3.03487122e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.27042389e+00f, -5.54194212e-01f, 7.76827574e-01f, -1.23094253e-01f, -3.76206517e-01f, 6.93814099e-01f, 4.61321115e-01f, -3.71923774e-01f, -2.93974996e-01f, -4.38194603e-01f,
  3.47220093e-01f, -1.05568953e-01f, 8.08358848e-01f, 9.35790718e-01f, 4.94647563e-01f, 8.90025318e-01f, 7.54765347e-02f, -5.62831938e-01f, 1.03579354e+00f, -1.44600794e-01f,
  1.35489345e-01f, 5.66922963e-01f, -2.02237651e-01f, 2.39758879e-01f, -6.40424564e-02f, -1.80338025e-01f, 3.95951390e-01f, -3.19472730e-01f, 1.09567392e+00f, 8.68574619e-01f,
  -3.83077949e-01f, -5.84164977e-01f, 7.14131966e-02f, 9.82560158e-01f, -1.65086195e-01f, 7.20699191e-01f, -6.36911616e-02f, -2.37045363e-01f, 9.84426081e-01f, -7.88403377e-02f,
  7.46660754e-02f, 3.65444541e-01f, 7.96659663e-02f, 8.81299615e-01f, -4.35710013e-01f, 2.24408984e-01f, -1.99532524e-01f, 3.40359777e-01f, -5.20790160e-01f, 8.13327670e-01f,
  -1.91054195e-01f, 1.58459023e-01f, 4.71029222e-01f, -3.05648744e-01f, 1.94955051e-01f, -3.13784510e-01f, -5.74104548e-01f, 1.57805800e-01f, -1.06829219e-01f, 7.71125495e-01f,
  7.10132360e-01f, -5.36686361e-01f, 3.29160213e-01f, 4.12322253e-01f, -1.91094637e-01f, -8.99625123e-01f, 6.77998662e-01f, 1.10837907e-01f, 3.03280890e-01f, 5.78207493e-01f,
  3.99920583e-01f, 7.44059861e-01f, -9.63047087e-01f, 4.98605072e-01f, -8.60831559e-01f, -5.46204112e-02f, -4.35984045e-01f, 3.68483275e-01f, 7.72751093e-01f, -5.15432417e-01f,
  -3.59803624e-02f, 8.13897073e-01f, -1.44285083e-01f, -3.41854095e-01f, 1.09243894e+00f, -1.97885916e-01f, 9.49694812e-01f, -2.23027915e-01f, 9.46879666e-03f, -3.75259072e-01f,
  -4.21213001e-01f, 2.78214753e-01f, 3.90991479e-01f, 7.97784328e-02f, 9.36692834e-01f, 5.08636415e-01f, 3.93682241e-01f, 3.74927193e-01f, -2.60988593e-01f, 6.86467648e-01f,
  6.28609180e-01f, -4.60730083e-02f, -3.95460218e-01f, -2.14187831e-01f, 1.02768934e+00f, -2.78385848e-01f, 7.71761596e-01f, -5.97529888e-01f, 2.33174562e-01f, -4.31243092e-01f,
  -3.37897182e-01f, -3.68974447e-01f, 8.25927973e-01f, -4.98596638e-01f, 5.36694288e-01f, -2.99226642e-01f, -8.02214801e-01f, 9.36832666e-01f, -6.78269446e-01f, -2.09726632e-01f,
  8.66046473e-02f, 5.64543068e-01f, 1.04350716e-01f, 9.68456268e-01f, -1.57700822e-01f, 4.12275374e-01f, -3.44210804e-01f, 2.74130881e-01f, -7.64064193e-02f, 3.07446301e-01f,
  1.52051061e-01f, -1.35939106e-01f, 5.69136322e-01f, 6.14986658e-01f, -1.06503054e-01f, 8.62254441e-01f, 4.82181787e-01f, 6.57649517e-01f, 2.33120233e-01f, 5.71700513e-01f,
  3.79037589e-01f, -7.08928049e-01f, -5.38770676e-01f, -1.44505113e-01f, 7.79719591e-01f, -3.92913908e-01f, 2.21776068e-01f, 4.95669842e-01f, -8.59207869e-01f, 4.76358026e-01f,
  4.47700411e-01f, 3.19088906e-01f, 3.92112970e-01f, 6.43499289e-03f, 1.06794941e+00f, -6.63188636e-01f, -8.71036053e-01f, 2.18973175e-01f, 3.46691720e-02f, 4.13182974e-01f,
  2.06364572e-01f, 4.04050350e-02f, 2.19932944e-01f, 1.20285172e-02f, 8.46299112e-01f, -5.30395925e-01f, -1.98691219e-01f, 1.11835115e-01f, 5.66357672e-01f, 1.09156501e+00f,
  -4.12027717e-01f, 3.17217767e-01f, 4.31729943e-01f, 4.24615979e-01f, 9.31888103e-01f, -3.74256857e-02f, 9.11540866e-01f, 4.51266855e-01f, -1.69440955e-01f, 2.82208592e-01f,
  3.49300057e-01f, 4.88126427e-01f, -2.71260351e-01f, -6.76050603e-01f, 2.65124410e-01f, 1.20726772e-01f, 3.99835378e-01f, 8.07732046e-01f, 6.41957283e-01f, -3.31933558e-01f,
  -4.62235034e-01f, 5.41012228e-01f, 4.55311924e-01f, 2.57411748e-01f, -4.31020200e-01f, -3.46553952e-01f, 4.07658070e-01f, -5.77553391e-01f, 5.78237653e-01f, 7.66076803e-01f,
  -6.67229295e-01f, 7.88920522e-01f, -4.85415518e-01f, 3.58079940e-01f, 1.58591010e-02f, -3.27710181e-01f, -2.70930212e-02f, 8.98043871e-01f, 4.24631983e-01f, 3.69938582e-01f,
  8.00019503e-01f, 9.76509213e-01f, 2.25123733e-01f, -4.18777972e-01f, 7.63292834e-02f, -9.43402648e-01f, 6.38497531e-01f, -6.26387596e-01f, 3.80200803e-01f, -3.85014474e-01f,
  1.04397857e+00f, 6.93842590e-01f, 1.12372376e-01f, 6.88605487e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  6.11604512e-01f, 6.50174081e-01f, 1.56170368e-01f, 2.81235278e-01f, -1.00750141e-01f, 1.24581613e-01f, 4.15948838e-01f, 6.91355467e-01f, 4.35652226e-01f, 9.38478529e-01f,
  2.91915268e-01f, 6.20875657e-01f, 5.38779378e-01f, 3.25271606e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  2.53325850e-01f, 3.00136834e-01f, -5.05986094e-01f, -4.80585396e-01f, 6.11570239e-01f, 2.13783726e-01f, 4.05421741e-02f, -1.03791726e+00f, -2.07445264e-01f, 9.42367494e-01f,
  2.64130205e-01f, -1.04578233e+00f, -9.43425223e-02f, 4.08665091e-01f, 5.42398654e-02f, -1.02845597e+00f, -5.28618991e-01f, -1.85213745e-01f, -8.63653004e-01f, -1.03017771e+00f,
  5.35649300e-01f, 7.14069843e-01f, -4.82646704e-01f, 6.35425806e-01f, -7.39431381e-01f, -2.51976222e-01f, 2.68373609e-01f, -6.51963234e-01f, 3.63695584e-02f, 5.73706627e-02f,
  5.23649931e-01f, -7.75881767e-01f, -4.96829629e-01f, 2.58055151e-01f, -1.30674481e+00f, -5.46242177e-01f, -9.54490244e-01f, -8.29733983e-02f, -3.86607945e-01f, 4.54782486e-01f,
  5.33580720e-01f, -5.66271424e-01f, 2.55742967e-01f, -5.69757521e-01f, 6.78319871e-01f, 2.26396576e-01f, -3.63328636e-01f, -2.28544995e-02f, -3.60208452e-01f, -3.90389860e-01f,
  -1.69606600e-02f, 7.21024990e-01f, -8.33165646e-01f, -9.39967781e-02f, 7.72801161e-01f, -4.77436692e-01f, -3.06177318e-01f, 4.70753640e-01f, 2.47661546e-01f, 1.41162142e-01f,
  -1.13374984e+00f, -8.45744908e-01f, -6.17293537e-01f, -9.56494927e-01f, 5.33015072e-01f, 9.37506616e-01f, 4.80835140e-01f, 2.94172671e-02f, -7.72821963e-01f, -1.08367980e+00f,
  -8.65615845e-01f, -8.17269742e-01f, 1.72792539e-01f, 6.69673383e-01f, 1.79492012e-01f, 8.45950425e-01f, -8.65246415e-01f, 2.88392782e-01f, -2.15222776e-01f, -3.73484194e-01f,
  4.09504725e-03f, 4.44470614e-01f, 6.09889627e-01f, -6.07068241e-01f, 2.41903782e-01f, 6.48159012e-02f, -8.47760320e-01f, 2.89089322e-01f, -1.06871438e+00f, 3.73916402e-02f,
  -5.93270838e-01f, -5.09435117e-01f, -9.57058743e-03f, 1.64762065e-01f, 1.03828698e-01f, 3.96661192e-01f, -2.52530009e-01f, 1.02787420e-01f, -9.82130095e-02f, 5.06666183e-01f,
  -7.35272825e-01f, 1.65820405e-01f, -2.07885951e-01f, -3.12087387e-01f, 4.65878874e-01f, -9.03737545e-01f, 2.69015610e-01f, -3.71837378e-01f, -2.30523452e-01f, 4.48281169e-01f,
  -7.26308286e-01f, 4.58838284e-01f, -3.34462792e-01f, -4.27208453e-01f, 4.72121924e-01f, -1.40354067e-01f, 5.86246133e-01f, -6.85332239e-01f, 4.03574198e-01f, 5.17434299e-01f,
  -2.42047817e-01f, -6.63379431e-01f, -5.60338736e-01f, 4.01702851e-01f, -8.70882630e-01f, -8.51723552e-01f, 3.98948826e-02f, -2.95738369e-01f, -4.00863081e-01f, 3.40659678e-01f,
  -7.97672644e-02f, -6.00475311e-01f, -8.04910839e-01f, 3.53223771e-01f, 8.38608027e-01f, 4.81831193e-01f, -5.11654556e-01f, -7.91305602e-01f, -9.49725986e-01f, -4.87695009e-01f,
  5.71612060e-01f, -5.48201799e-01f, -7.59764761e-02f, -1.25405833e-01f, -3.15523520e-02f, 1.46648556e-01f, -8.53942335e-01f, -1.08053005e+00f, 7.60647893e-01f, -5.34660220e-01f,
  2.21957956e-02f, -8.31192136e-01f, 7.11220801e-01f, -8.91875923e-01f, -1.06203273e-01f, 5.95867693e-01f, -2.79838860e-01f, 9.72219855e-02f, -4.52493966e-01f, 4.48723555e-01f,
  6.28448203e-02f, -4.57459271e-01f, -7.56223798e-01f, -2.12506250e-01f, -1.93697527e-01f, -5.07649601e-01f, 5.83895147e-01f, -9.30263400e-01f, -2.94591814e-01f, -2.30765969e-01f,
  3.41508299e-01f, 1.40828146e-02f, 5.61901093e-01f, -8.60092342e-01f, 8.88131380e-01f, -5.79781234e-01f, 3.64630818e-02f, -6.13757849e-01f, 3.51494253e-01f, 6.33210838e-01f,
  -3.68293911e-01f, -4.97917235e-01f, -1.47243470e-01f, -5.46799064e-01f, -5.05946219e-01f, -3.55779678e-02f, -8.44252944e-01f, -1.79027915e-01f, 5.84394932e-01f, -8.20673406e-01f,
  -7.12721586e-01f, 3.52029920e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.98919520e-01f, -9.65037718e-02f, -2.59370416e-01f, -1.59704089e-01f, 4.19789612e-01f, -1.47830531e-01f, -2.33008325e-01f, -2.66622990e-01f, 7.15282410e-02f, 2.19613343e-01f,
  8.64539146e-02f, -1.01723917e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    