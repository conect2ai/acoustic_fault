/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.01019889e-01f, 2.66250610e-01f, 1.48136199e-01f, 8.60322714e-02f, 7.30610043e-02f, -1.07107617e-01f, 1.57963187e-02f, -1.30154446e-01f, -1.72882136e-02f, 1.50890246e-01f,
  6.93721250e-02f, -1.33443668e-01f, -1.44917756e-01f, -1.36240631e-01f, -1.78817272e-01f, 1.18761994e-02f, 8.66197199e-02f, -1.18576862e-01f, -1.11251719e-01f, -8.73345211e-02f,
  2.60440819e-02f, 8.19394588e-02f, -3.99462134e-02f, -1.15015104e-01f, 1.62597865e-01f, 7.65970945e-02f, 1.70455500e-01f, 6.46086857e-02f, 8.91167969e-02f, 2.01784834e-01f,
  2.81799614e-01f, -3.81571874e-02f, -9.76935029e-02f, -1.48528256e-02f, -2.48372409e-04f, 3.22707668e-02f, 3.58115062e-02f, 3.77774541e-03f, -2.21585054e-02f, 1.01323642e-01f,
  -2.91313529e-02f, -9.74659175e-02f, 8.58710613e-03f, 1.04900291e-02f, 7.95551315e-02f, -1.59658100e-02f, -2.00320911e-02f, -4.30286266e-02f, -9.60562900e-02f, 7.23193958e-02f,
  1.13196820e-02f, 1.81840792e-01f, 9.39454511e-02f, -2.43631750e-02f, 5.45666218e-02f, -1.04415901e-02f, -2.36541349e-02f, 2.12208275e-02f, 3.16929445e-02f, 1.80919513e-01f,
  9.28491652e-02f, 3.40380296e-02f, 1.77595357e-03f, -2.77276859e-02f, -4.99468371e-02f, -3.06129698e-02f, -6.03926517e-02f, 1.09452773e-02f, 9.62613802e-03f, 1.37339637e-03f,
  1.01233339e-02f, 1.22957863e-02f, 6.82619167e-03f, 4.72384319e-02f, 3.74627789e-03f, 7.39345998e-02f, -1.83461178e-02f, -1.83049217e-02f, 5.42484075e-02f, 1.61070693e-02f,
  2.28994656e-02f, -3.72354910e-02f, -7.95100033e-02f, -9.37666222e-02f, -4.25419100e-02f, -6.41198605e-02f, 3.59349931e-03f, 6.62530661e-02f, 1.49382167e-02f, 4.75476459e-02f,
  8.74481425e-02f, -1.26061276e-01f, 7.25266933e-02f, -8.27490389e-02f, 3.14769931e-02f, 4.29924913e-02f, -4.62699160e-02f, -1.08521946e-01f, -4.64326926e-02f, -9.82209072e-02f,
  -9.70629882e-03f, -1.84248071e-02f, 9.47086886e-03f, 5.55127487e-02f, -4.87820730e-02f, -2.57569645e-02f, 6.25655428e-02f, 4.37730514e-02f, -6.75941929e-02f, 4.29816507e-02f,
  1.28188983e-01f, 1.53816566e-02f, 2.13850528e-01f, 8.73911195e-03f, -3.94099653e-02f, -4.23736796e-02f, 8.86537060e-02f, 1.61149919e-01f, -2.73006987e-02f, 1.68558896e-01f,
  -3.94331187e-01f, 2.79400587e-01f, -2.96303760e-02f, -3.05262301e-02f, 1.53136864e-01f, -1.33600652e-01f, -1.79858774e-01f, -1.49537802e-01f, -8.87207910e-02f, 1.60466492e-01f,
  1.49360880e-01f, -6.03538305e-02f, -8.71142745e-02f, -3.09278797e-02f, -1.79454088e-01f, 8.05881545e-02f, 1.63322702e-01f, -1.86695307e-01f, -2.29037479e-01f, -1.86288178e-01f,
  1.34688750e-01f, -8.01789463e-02f, -2.32360601e-01f, -1.16713018e-04f, 2.64230639e-01f, 6.59718663e-02f, 8.05854574e-02f, 1.01600744e-01f, 1.66038260e-01f, 4.93135631e-01f,
  4.08470407e-02f, -4.46183197e-02f, -1.10208444e-01f, 4.91226465e-02f, 5.63361794e-02f, 1.59871485e-02f, 1.36733195e-03f, 2.72919536e-02f, 2.96645314e-02f, 3.39894518e-02f,
  6.93170950e-02f, -1.35286879e-02f, 6.52371347e-02f, 9.56071168e-03f, -4.61463295e-02f, -1.03223532e-01f, -9.88027360e-03f, -7.03824982e-02f, -1.88086671e-03f, -1.55380201e-02f,
  2.33071581e-01f, 1.57405943e-01f, -1.36414036e-01f, -1.01323739e-01f, -2.41691377e-02f, 1.33360748e-03f, -6.82462454e-02f, 9.72725824e-03f, -1.50142452e-02f, 7.92635828e-02f,
  -6.56784559e-03f, -1.55532109e-02f, 7.86921754e-03f, 1.83932669e-02f, -3.57456692e-02f, 1.33793596e-02f, 2.92297117e-02f, -4.34710607e-02f, -1.95999444e-02f, -4.64996733e-02f,
  -1.10086305e-02f, -1.26675721e-02f, 1.09281447e-02f, -2.30845381e-02f, 3.92019637e-02f, 8.36802647e-03f, 3.41892838e-02f, -6.77583739e-02f, -2.83163656e-02f, 1.86510198e-02f,
  -2.31802883e-03f, -5.65370172e-02f, 1.93038490e-02f, 1.38074532e-02f, 2.00933814e-02f, 3.55384648e-02f, -5.87134659e-02f, 5.19429557e-02f, -5.40955327e-02f, 2.34519597e-02f,
  -1.84089839e-01f, -1.04623567e-02f, 5.42358011e-02f, -2.31899265e-02f, 6.94998028e-03f, -5.23445457e-02f, 6.33560419e-02f, 2.45716218e-02f, 1.98592916e-02f, -2.42192522e-02f,
  -4.56551686e-02f, -8.01915899e-02f, -8.87481589e-03f, 5.02853841e-02f, -7.65885040e-02f, -1.86979063e-02f, 2.35164538e-02f, 9.43714636e-04f, -6.98364452e-02f, 8.41337536e-03f,
  -5.08927414e-03f, -1.05759338e-01f, -3.24264586e-01f, -1.59775883e-01f, -9.97077599e-02f, -1.69358730e-01f, -1.12394057e-01f, -1.62105873e-01f, -2.97998548e-01f, -2.73143232e-01f,
  1.33533940e-01f, 1.02698142e-02f, -2.34916300e-01f, -7.35131130e-02f, -1.16951056e-01f, -1.65644482e-01f, -7.43863136e-02f, 1.31953269e-01f, 1.55843664e-02f, -7.29646459e-02f,
  2.62801331e-02f, -3.01809404e-02f, -1.26479596e-01f, -7.42795542e-02f, 1.03074677e-01f, -1.92538261e-01f, -1.90789446e-01f, -2.26242051e-01f, -1.41935319e-01f, -1.44845322e-01f,
  -1.55197695e-01f, -1.92828644e-02f, 1.63801224e-03f, 5.63186035e-02f, -7.68832341e-02f, -1.09165259e-01f, -1.18028827e-01f, -3.16696241e-02f, -2.70954203e-02f, -3.16179067e-01f,
  -3.44704807e-01f, 1.73462287e-01f, -7.18698055e-02f, 5.54776303e-02f, -3.93195078e-02f, -7.41698816e-02f, -6.67078048e-02f, 8.60335305e-02f, 6.94524720e-02f, 4.85923998e-02f,
  7.80620519e-03f, -8.57024044e-02f, -3.01307756e-02f, -4.71907668e-02f, 1.42679010e-02f, -6.32932261e-02f, 8.69387016e-02f, 1.20399490e-01f, 1.10623188e-01f, 5.72748147e-02f,
  -3.77091132e-02f, -6.43188283e-02f, 6.75857514e-02f, 4.68479507e-02f, 7.18808323e-02f, 1.52652981e-02f, 8.92103240e-02f, 7.72178695e-02f, 1.05800167e-01f, 2.64000203e-02f,
  3.20219472e-02f, -5.57886176e-02f, 2.36102287e-02f, 1.23459272e-01f, 7.33055025e-02f, 2.97062714e-02f, -1.95310581e-02f, 1.88400000e-02f, 3.46786063e-03f, 4.27605323e-02f,
  2.89084297e-02f, -4.25181165e-03f, 7.55590526e-03f, 3.22881597e-03f, -5.06253392e-02f, 6.86620129e-03f, -5.27872145e-03f, 5.19624650e-02f, 2.50905976e-02f, -1.89248196e-04f,
  5.84049895e-02f, 1.08404141e-02f, 2.64661480e-02f, -3.67958061e-02f, 2.61738915e-02f, -2.93388572e-02f, 6.06143102e-03f, -1.21676633e-02f, 6.73001856e-02f, -5.79880066e-02f,
  1.63940452e-02f, 1.48060054e-01f, -1.00361645e-01f, -3.76630798e-02f, -9.03998017e-02f, -7.48948231e-02f, -1.10323038e-02f, -1.26724988e-01f, -7.36415908e-02f, -9.16486531e-02f,
  -3.57718393e-02f, -2.26868149e-02f, 1.88634861e-02f, -6.09732606e-02f, -2.76688673e-02f, -5.58675751e-02f, 3.32663977e-03f, -1.00378454e-01f, 7.70711899e-03f, 7.07645267e-02f,
  -2.27541029e-02f, -6.50817826e-02f, 1.58199649e-02f, 1.27729652e-02f, -6.34182990e-02f, -1.30958974e-01f, -1.43596873e-01f, -1.45039648e-01f, -8.02661106e-02f, -1.70167595e-01f,
  8.12835172e-02f, -9.13360938e-02f, -1.00191988e-01f, 2.91538518e-03f, 1.45139053e-01f, -4.77946885e-02f, -1.47492751e-01f, -6.38273582e-02f, -8.11444297e-02f, -3.02605634e-03f,
  2.84512848e-01f, 1.71981871e-01f, -3.07545885e-02f, -1.06754648e-02f, -2.11040676e-01f, -3.88226241e-01f, -4.02922779e-01f, -2.98467994e-01f, -1.21653602e-01f, -4.22473066e-02f,
  1.00777373e-02f, -1.13386303e-01f, -8.80333409e-03f, -1.34625569e-01f, -6.55257702e-02f, -2.18209345e-03f, -8.14834982e-02f, 7.23436475e-02f, -3.25829227e-04f, -1.10354565e-01f,
  -6.91400394e-02f, 1.54777199e-01f, -1.69536173e-02f, 7.87089318e-02f, 1.16061136e-01f, -5.49509600e-02f, -5.35236411e-02f, -2.87133036e-03f, 4.90532927e-02f, -5.66245429e-02f,
  1.36818811e-01f, 1.08242281e-01f, 1.38607761e-02f, 8.40755831e-03f, 2.59953886e-02f, -8.01557396e-03f, 3.74080800e-02f, -2.86746994e-02f, 2.04782542e-02f, 7.47511312e-02f,
  1.11164294e-01f, 1.98230907e-01f, -1.08214561e-02f, -1.59336701e-02f, 6.45645186e-02f, 1.49672134e-02f, 9.38267112e-02f, 8.92698020e-02f, 1.15804896e-01f, -1.20369092e-01f,
  -4.39631892e-03f, -2.28185356e-02f, 1.55230183e-02f, 5.94660640e-03f, -1.85690969e-02f, 4.88391891e-02f, -2.36381274e-02f, -4.26559560e-02f, -6.02932088e-02f, 3.07179205e-02f,
  -2.40073656e-03f, -2.56319884e-02f, -1.47455353e-02f, -1.18833542e-01f, -2.40045637e-02f, 3.13626304e-02f, 2.36148834e-02f, -7.65550509e-02f, -1.09033603e-02f, 6.21447638e-02f,
  -5.67985140e-03f, 4.86086458e-02f, 4.41832095e-02f, -6.59543723e-02f, 8.60455930e-02f, -2.88007222e-02f, 1.55482171e-02f, 3.71236019e-02f, 1.44082112e-02f, 4.58940044e-02f,
  3.26030403e-02f, 1.66980639e-01f, -6.40570894e-02f, -8.25643241e-02f, -2.96950080e-02f, 7.97870383e-02f, 8.89248103e-02f, 1.10807298e-02f, 7.27456957e-02f, -9.79939401e-02f,
  2.71813851e-02f, -7.19906688e-02f, -1.51747484e-02f, -5.89575991e-02f, -1.09013673e-02f, 8.94553587e-02f, -9.58020538e-02f, -5.91525361e-02f, -2.45811585e-02f, 9.67127085e-02f,
  -5.97898625e-02f, -9.76206213e-02f, -6.57396168e-02f, -5.04924431e-02f, 6.69903904e-02f, -4.58930098e-02f, -1.56811014e-01f, 1.96364205e-02f, -4.05316204e-02f, -2.51292884e-01f,
  1.81579039e-01f, -1.98346734e-01f, 4.84576851e-01f, 1.19299918e-01f, 1.25861943e-01f, 8.38415250e-02f, -1.28474608e-02f, -2.11876437e-01f, -1.42850429e-01f, 1.30931064e-02f,
  -1.32633403e-01f, -1.94672570e-01f, -9.26691107e-03f, -1.28582463e-01f, -3.28828692e-02f, 7.04963803e-02f, 1.15529284e-01f, 3.03680539e-01f, 1.06222622e-01f, -1.74867839e-01f,
  -1.63104773e-01f, 9.11482275e-02f, 1.55605510e-01f, 9.49086770e-02f, -9.72137302e-02f, 7.65724555e-02f, 2.05947220e-01f, 9.58669633e-02f, 3.78487930e-02f, 5.66869229e-02f,
  8.78711566e-02f, -4.62462902e-02f, 9.41844285e-02f, -6.09718151e-02f, 4.92284149e-02f, -4.94451486e-02f, 5.61000407e-02f, 5.17805330e-02f, -8.25824142e-02f, -2.09993087e-02f,
  -1.05516668e-02f, -2.08498128e-02f, 6.05803542e-02f, -6.62863627e-02f, -1.07165100e-02f, -3.91868576e-02f, 6.39030859e-02f, 1.23837784e-01f, 7.37132132e-02f, -4.89507467e-02f,
  -9.07770842e-02f, 4.34192307e-02f, 1.91006541e-01f, 5.04555404e-02f, -7.46848583e-02f, 1.03534706e-01f, -2.52385754e-02f, 6.72698244e-02f, 5.80391064e-02f, -2.82822736e-02f,
  -1.55341076e-02f, 2.37602461e-02f, 1.01280073e-03f, -3.22758965e-02f, 7.96037639e-05f, -6.95827138e-03f, -4.05963026e-02f, 6.33305758e-02f, -1.74985621e-02f, 5.29011562e-02f,
  -2.65768189e-02f, -1.26215443e-02f, -2.57760510e-02f, 2.19080527e-03f, -8.24168138e-03f, 2.63602231e-02f, 4.78649773e-02f, -5.16050868e-02f, 1.66776087e-02f, -4.11610529e-02f,
  7.58942589e-02f, 9.98918712e-02f, 4.65362333e-02f, -5.55836186e-02f, -4.80918474e-02f, 3.58889475e-02f, 1.59973314e-03f, -8.43219534e-02f, -7.20068142e-02f, -1.20704686e-02f,
  1.37567502e-02f, 9.03447196e-02f, 4.18928452e-02f, -1.12474009e-01f, 4.83509563e-02f, -1.94756372e-03f, 3.53442132e-02f, 1.89512726e-02f, 1.68437008e-02f, -4.18714024e-02f,
  -3.49293090e-02f, 8.79904069e-03f, -5.97184114e-02f, -9.10462216e-02f, -1.64540112e-02f, 4.87472303e-03f, -4.41719554e-02f, 3.57441530e-02f, -6.15395382e-02f, -6.86268881e-02f,
  5.73139414e-02f, 9.82277244e-02f, 1.52686611e-02f, 5.65930977e-02f, -4.06699395e-03f, 8.97518247e-02f, 1.39286295e-01f, 8.79824907e-02f, 9.31479260e-02f, 1.53338432e-01f,
  2.79816091e-01f, -3.87078971e-01f, -4.31191653e-01f, 3.67191210e-02f, -1.58312380e-01f, -3.62790138e-01f, -4.70269203e-01f, -1.31344572e-01f, 1.02450684e-01f, -1.05160110e-01f,
  -4.64709140e-02f, 2.72970885e-01f, 2.08392873e-01f, 1.73663363e-01f, -6.14204071e-02f, -2.65388578e-01f, -2.25939855e-01f, -2.32112482e-02f, 2.35887468e-02f, 4.34255376e-02f,
  -8.66372231e-03f, 1.27653062e-01f, 1.42578736e-01f, 5.66732027e-02f, 3.94082889e-02f, 2.02677846e-01f, -6.99662429e-04f, -1.81812644e-02f, -5.21660037e-02f, -1.42041489e-01f,
  -4.57809269e-02f, -1.35144889e-01f, 4.59640473e-02f, 1.50136158e-01f, -1.21738813e-04f, 9.13802981e-02f, 8.60217214e-03f, 7.47344717e-02f, -8.94214609e-04f, 1.51500031e-02f,
  -3.06919999e-02f, 3.74949872e-02f, 7.26218745e-02f, 5.36184832e-02f, -5.61346188e-02f, -2.09656358e-02f, 4.65280227e-02f, -6.30489513e-02f, -5.81424087e-02f, -8.64773467e-02f,
  -6.70979321e-02f, -1.06979467e-01f, -8.60937759e-02f, -8.07375535e-02f, -1.37022153e-01f, -4.40610992e-03f, -4.75867987e-02f, 1.78494900e-02f, -1.52896523e-01f, 9.68216881e-02f,
  1.24231502e-02f, 3.98908965e-02f, -1.81618929e-02f, 2.93847974e-02f, 3.07437181e-02f, 1.62824448e-02f, -5.95236495e-02f, 7.40179978e-03f, 8.78777634e-03f, 2.81975884e-02f,
  4.45958553e-03f, -6.17439151e-02f, -2.55602482e-03f, -5.47323897e-02f, 6.80911541e-02f, -8.22396502e-02f, -1.60216186e-02f, -3.37787569e-02f, 1.85168963e-02f, 3.22668776e-02f,
  4.42967042e-02f, 2.69449204e-02f, -1.04572484e-02f, 1.01350239e-02f, -5.30702695e-02f, -7.24781081e-02f, 7.03459829e-02f, 7.66574964e-02f, -1.27506058e-03f, -6.12650998e-02f,
  4.22971338e-01f, -2.19913721e-01f, -3.54537100e-04f, 1.46772936e-02f, -8.76684673e-03f, -2.06182754e-04f, -1.92210439e-03f, 4.77844803e-03f, 6.84109405e-02f, -5.61204031e-02f,
  -4.67829667e-02f, 4.65550311e-02f, -1.26627490e-01f, 2.69850045e-02f, 2.13230010e-02f, -1.09825712e-02f, -1.30527909e-03f, 2.84389239e-02f, 1.13654649e-02f, 1.73086226e-02f,
  -1.77159756e-02f, 1.95889510e-02f, 3.76680791e-02f, 8.01135376e-02f, -1.34673184e-02f, 1.01591989e-01f, -2.54476666e-02f, 5.96216507e-02f, 1.30206915e-02f, 1.00178845e-01f,
  2.84509845e-02f, 2.33559888e-02f, -2.19769832e-02f, 1.36639804e-01f, -3.85228288e-03f, 5.18446937e-02f, 6.50564358e-02f, 1.40944161e-02f, 3.66662331e-02f, -7.15592951e-02f,
  -5.14018908e-03f, -8.69886950e-02f, -1.05614327e-01f, -2.05206312e-02f, 8.48979130e-03f, -1.73188804e-03f, 6.55193850e-02f, -1.15662947e-01f, -8.04769993e-02f, -3.35651375e-02f,
  1.24708831e-01f, 1.14503078e-01f, 1.02084257e-01f, 6.71939403e-02f, 4.70421202e-02f, -4.90451716e-02f, -1.01654746e-01f, 1.13351405e-01f, 9.68273431e-02f, 1.44551978e-01f,
  -2.45054424e-01f, 1.28538460e-01f, -8.55453610e-02f, -1.99084319e-02f, 1.63041316e-02f, -2.20193546e-02f, -6.63646534e-02f, 6.24479316e-02f, -9.66217369e-03f, 8.50562453e-02f,
  -4.55015860e-02f, 4.54604588e-02f, 6.44915253e-02f, 8.91943052e-02f, -1.05901808e-02f, 3.21719386e-02f, 4.07853201e-02f, 6.54048771e-02f, -4.33983691e-02f, -2.24836487e-02f,
  8.33991691e-02f, 8.15495253e-02f, -5.94060607e-02f, -1.48643637e-02f, -2.75550783e-02f, 1.60764828e-02f, -3.35702710e-02f, -7.10823061e-03f, 2.78533809e-02f, 1.26706913e-01f,
  -7.73237944e-02f, 3.25787552e-02f, -4.68206704e-02f, 2.01764703e-02f, 4.11733985e-02f, 1.26464684e-02f, -1.72739588e-02f, -1.25086615e-02f, 6.87942952e-02f, 4.83494950e-03f,
  -3.08528598e-02f, 5.42354360e-02f, -2.25709099e-03f, 7.36918375e-02f, -2.99094785e-02f, 8.98699835e-02f, 5.54435933e-03f, 2.89209746e-02f, -4.48513851e-02f, -1.22058075e-02f,
  2.34979074e-02f, 1.90782864e-02f, 5.17109595e-02f, 9.85925365e-03f, 1.94553621e-02f, 7.85544664e-02f, 1.44362757e-02f, -9.19198617e-03f, -5.18815815e-02f, 7.70730153e-02f,
  -1.55101776e-01f, -1.25793368e-01f, 1.17160734e-02f, -4.35969308e-02f, -8.22927505e-02f, -7.76674002e-02f, 2.67439410e-02f, 2.47953031e-02f, 8.77062604e-02f, 1.06612798e-02f,
  2.20350586e-02f, -6.91249967e-02f, -1.28496706e-01f, -7.33738765e-03f, 2.33549401e-02f, 1.77757125e-02f, 1.87376235e-02f, 2.62884516e-02f, 4.40752320e-02f, 4.03152732e-03f,
  -8.21054801e-02f, -2.14839540e-02f, -2.09684342e-01f, -1.19349673e-01f, -1.06173731e-01f, -2.44241387e-01f, -1.58723623e-01f, -1.39331833e-01f, -1.65991947e-01f, -2.10238710e-01f,
  2.58752078e-01f, -3.30480456e-01f, -1.23215280e-01f, -6.11124821e-02f, -1.44910067e-01f, -3.10361564e-01f, -4.24469829e-01f, -2.75697738e-01f, -1.00495771e-01f, -6.07569776e-02f,
  4.15675202e-03f, 1.28155529e-01f, 1.34002477e-01f, 1.41674578e-01f, 7.14631081e-02f, -7.22809434e-02f, 2.05506794e-02f, 2.82064855e-01f, 2.26465896e-01f, -7.61546046e-02f,
  4.63642664e-02f, -1.02087766e-01f, 6.75741360e-02f, 1.40711278e-01f, 2.97950041e-02f, 1.31035641e-01f, -3.81201096e-02f, -2.83723101e-02f, 5.71212135e-02f, 2.19861284e-01f,
  1.79952160e-01f, 1.24786310e-02f, 1.09396666e-01f, 2.66493317e-02f, -6.61303625e-02f, 1.52673274e-01f, -4.15427312e-02f, -5.99856663e-04f, -5.31660169e-02f, -7.26052606e-03f,
  8.35319832e-02f, 5.53612486e-02f, 7.95230363e-03f, -2.79643033e-02f, -9.63469744e-02f, -5.50126843e-02f, -5.99665707e-03f, 1.10809810e-01f, 8.02752003e-02f, 8.10307451e-03f,
  4.88067716e-02f, 1.15146097e-02f, -1.42807081e-01f, -5.26968241e-02f, -5.26524559e-02f, 5.26622050e-02f, -4.75444160e-02f, 1.04274280e-01f, -9.05340835e-02f, 1.49306459e-02f,
  -4.80973069e-03f, -1.37740029e-02f, -5.42621268e-03f, -1.78664960e-02f, -3.33913639e-02f, -1.71856687e-03f, -5.28822169e-02f, 1.50833162e-03f, -1.98556297e-02f, -6.26251101e-03f,
  -1.51020940e-02f, 2.39392594e-02f, 2.65591759e-02f, 3.46999569e-03f, 6.86341301e-02f, -2.56282147e-02f, -1.96480900e-02f, -1.33928293e-02f, 5.69042824e-02f, -6.35397509e-02f,
  -3.20965312e-02f, 3.74136046e-02f, 1.29117379e-02f, -1.87178534e-02f, 6.56665340e-02f, 4.18058969e-02f, 4.30625007e-02f, -6.25050813e-02f, -6.51694387e-02f, -1.47155579e-02f,
  -8.83431137e-02f, -9.28614736e-02f, 1.66179970e-01f, 9.05960798e-02f, 1.59800742e-02f, 1.63937956e-02f, 4.07526679e-02f, 7.35201910e-02f, 1.50666401e-01f, 1.59127917e-03f,
  -6.08376227e-03f, -3.33681852e-02f, -7.56547973e-02f, -3.06949690e-02f, -3.75473388e-02f, -1.47474725e-02f, -4.91832085e-02f, 7.67344758e-02f, -2.96644255e-04f, -7.22037554e-02f,
  -1.27078235e-01f, -9.53937173e-02f, 2.20549535e-02f, -1.59170493e-01f, -1.21533126e-01f, 9.63983387e-02f, -1.00848615e-01f, 1.72988081e-03f, 4.04689945e-02f, -1.46768078e-01f,
  -3.19792837e-01f, -3.19558352e-01f, -2.79840022e-01f, 1.79089308e-02f, 1.42219201e-01f, -3.45976017e-02f, -4.79557104e-02f, -7.63124228e-02f, 1.00618951e-01f, 4.60524298e-03f,
  1.79257601e-01f, 1.62595958e-01f, 1.37212530e-01f, 9.95007828e-02f, -6.22451454e-02f, -1.42109752e-01f, -1.20702550e-01f, -1.55751690e-01f, 3.73874754e-02f, 3.10242139e-02f,
  6.14451244e-02f, -9.89123285e-02f, -2.74036884e-01f, -1.56580433e-01f, -8.60982388e-02f, -4.02069390e-02f, -2.40219131e-01f, -1.25400975e-01f, -9.98994410e-02f, -6.16004057e-02f,
  2.87540331e-02f, -1.82078630e-01f, 7.21329153e-02f, 1.69663474e-01f, 1.39020577e-01f, -4.43998799e-02f, 6.14552423e-02f, -7.27644637e-02f, 3.07829361e-02f, -3.49941328e-02f,
  1.72209829e-01f, 3.17687094e-02f, 3.97530310e-02f, -1.35221495e-03f, -1.02620095e-01f, 5.61027825e-02f, 2.35016327e-02f, -1.45745605e-01f, -7.05608130e-02f, -4.42735814e-02f,
  4.97260466e-02f, 6.53169379e-02f, -1.89545844e-02f, -1.07103452e-01f, -9.27937925e-02f, 1.03589952e-01f, -5.85566908e-02f, -1.42976463e-01f, -1.73017532e-01f, -3.13845217e-01f,
  6.04431666e-02f, 3.96420322e-02f, 1.37438644e-02f, -9.55570936e-02f, 6.59812335e-03f, -1.52547238e-02f, 2.71396488e-02f, 1.66197997e-02f, 4.22240142e-03f, -6.57841638e-02f,
  -2.54179034e-02f, 4.92394157e-02f, -2.14519259e-03f, -9.35658142e-02f, 9.52642038e-02f, 2.79865135e-02f, -5.33690155e-02f, -3.73568609e-02f, 2.72385664e-02f, -8.64200387e-03f,
  5.08074276e-02f, -2.77979113e-02f, 7.17913806e-02f, -6.18004613e-02f, -9.03785825e-02f, -1.10042177e-01f, -3.15717496e-02f, -1.28002297e-02f, 1.02835089e-01f, -3.85796204e-02f,
  9.31171849e-02f, 3.35335992e-02f, 2.69535817e-02f, -9.48090702e-02f, 7.32302144e-02f, 7.22213537e-02f, 4.93063293e-02f, -4.37808689e-03f, 8.64497200e-02f, -6.55598342e-02f,
  -1.63647234e-02f, -6.07584156e-02f, 4.15825611e-03f, 1.33126341e-02f, 5.84515445e-02f, -7.20103795e-04f, 1.08660562e-02f, -4.17113863e-02f, -2.64302529e-02f, -3.46808918e-02f,
  4.64305427e-04f, -1.12713963e-01f, -1.13350645e-01f, 3.30512151e-02f, -1.01403303e-01f, 9.36000571e-02f, -5.81094921e-02f, -5.52115180e-02f, -8.13922435e-02f, -1.91011533e-01f,
  1.34747848e-01f, 1.06838487e-01f, 2.43268073e-01f, 3.07881594e-01f, 2.21851230e-01f, 1.08218521e-01f, 8.95605832e-02f, 1.08030371e-01f, 3.17941867e-02f, 9.59239304e-02f,
  -1.00882970e-01f, -1.25823975e-01f, -1.01520158e-01f, 2.39198357e-02f, -7.22379759e-02f, 1.22455873e-01f, 2.88611561e-01f, 1.47056177e-01f, 3.90797071e-02f, 1.76858231e-01f,
  2.04964951e-01f, 2.72907406e-01f, 2.46787384e-01f, 8.05136487e-02f, 1.98424667e-01f, 2.96927546e-03f, 1.86821818e-01f, 1.98889896e-01f, 1.51880339e-01f, 1.76856682e-01f,
  -3.96421626e-02f, 2.27633659e-02f, 1.17331967e-02f, 4.37710397e-02f, 4.10502367e-02f, -6.07831106e-02f, -8.30610022e-02f, -1.65582784e-02f, -4.16064896e-02f, -5.42801134e-02f,
  -6.23101741e-02f, -8.33741277e-02f, 1.37716541e-02f, -2.91800685e-02f, 2.33078878e-02f, -6.45188838e-02f, 1.46573894e-02f, -1.11799888e-01f, -2.85103708e-03f, -5.26896454e-02f,
  7.79495388e-03f, 1.42939324e-02f, -8.61067325e-03f, -1.31080359e-01f, -2.90321130e-02f, -5.03991209e-02f, -5.67741916e-02f, 7.28943152e-03f, -1.31648436e-01f, -5.75070605e-02f,
  7.58718327e-02f, -4.03727219e-02f, -3.78160924e-02f, -7.14211864e-03f, -7.08701983e-02f, -6.15866408e-02f, -1.99395716e-02f, -4.56974171e-02f, -7.10720604e-04f, -3.17919180e-02f,
  -2.23058239e-02f, 2.27008760e-02f, -4.31447700e-02f, 4.01147716e-02f, -4.51762974e-02f, -3.97998318e-02f, -1.77060068e-02f, 2.12586438e-03f, -6.09209388e-02f, -1.35113830e-02f,
  6.66010566e-03f, -5.85954301e-02f, 5.27111115e-03f, -5.88019080e-02f, -3.68254669e-02f, -1.46187772e-03f, 1.64998434e-02f, -6.02581799e-02f, 1.82743650e-02f, -3.86176147e-02f,
  -1.08349219e-01f, -9.60196927e-02f, 1.86275085e-03f, 1.23250764e-02f, -1.78147247e-03f, 2.07961760e-02f, 5.96333556e-02f, -5.45698106e-02f, 5.35959117e-02f, -2.58624945e-02f,
  -7.85581011e-04f, 4.28083278e-02f, -7.32841343e-03f, -2.59982627e-02f, 2.17743497e-02f, -2.51275990e-02f, -7.59795075e-03f, 6.98144585e-02f, -1.92114189e-02f, -3.78373601e-02f,
  3.55796563e-03f, 1.63046215e-02f, -9.58232582e-03f, -1.37035236e-01f, 1.96606503e-03f, -5.84928989e-02f, -1.20400839e-01f, -3.18111144e-02f, -2.70024166e-02f, -6.20237961e-02f,
  3.27327400e-02f, -1.07274696e-01f, 2.60022059e-02f, 2.86622234e-02f, -6.79206625e-02f, -9.76424292e-02f, -1.73906367e-02f, -5.71162775e-02f, -3.67351482e-03f, -1.14712194e-01f,
  -1.56020850e-01f, -1.62178546e-01f, -1.81123182e-01f, -6.12459108e-02f, -5.80644759e-04f, 7.16572478e-02f, -5.96279465e-03f, 1.26976058e-01f, 1.64620150e-02f, 1.33707985e-01f,
  6.62014335e-02f, 1.65903494e-01f, 8.78181309e-02f, 1.44373894e-01f, 8.53984058e-02f, -3.44484672e-02f, 2.52396874e-02f, 4.34134640e-02f, 3.49899381e-02f, 9.69349891e-02f,
  8.51684734e-02f, 7.01318309e-02f, -9.01660621e-02f, -1.51379317e-01f, -6.02264777e-02f, 8.56252760e-02f, 1.99370999e-02f, 1.09197818e-01f, -4.82127517e-02f, 1.00577332e-01f,
  -7.73999840e-02f, -2.95972601e-02f, 2.58294009e-02f, 7.72151202e-02f, -2.69248076e-02f, -5.47809787e-02f, 7.68472673e-03f, 1.17256992e-01f, -7.84035474e-02f, -2.01223921e-02f,
  -9.74411443e-02f, -9.65204984e-02f, -6.94089383e-02f, 4.54953164e-02f, 1.01693384e-01f, -4.15917896e-02f, -3.36483680e-02f, 1.82376690e-02f, -3.16288695e-02f, 9.85241085e-02f,
  6.29635667e-03f, -2.38360558e-02f, 6.18636943e-02f, 5.30563705e-02f, -2.59593539e-02f, 2.12178156e-02f, 2.80044172e-02f, -2.34932899e-02f, -2.77423905e-03f, 3.01975794e-02f,
  2.16863342e-02f, -7.56626949e-02f, -4.64460142e-02f, 2.87167523e-02f, -3.35967392e-02f, -2.53445338e-02f, 2.96785310e-02f, -7.49871060e-02f, -3.91155556e-02f, -3.45177762e-02f,
  5.27387895e-02f, 2.23736931e-02f, -1.01835169e-02f, 7.84621164e-02f, -2.53324434e-02f, -6.48941426e-03f, -1.90010350e-02f, -3.47627178e-02f, -2.10183319e-02f, -3.89535539e-02f,
  -1.75363142e-02f, -2.53642291e-01f, -7.57028861e-03f, 1.15771636e-01f, 8.48524868e-02f, 9.59784538e-03f, -4.35790718e-02f, -6.64839596e-02f, -9.46659520e-02f, -1.44804958e-02f,
  5.48281223e-02f, 5.33389151e-02f, 3.00952047e-02f, 7.07909316e-02f, 1.04591273e-01f, 7.30906054e-02f, -1.15466520e-01f, -6.49538040e-02f, -1.36913791e-01f, -2.49827765e-02f,
  -8.90842378e-02f, 5.14728911e-02f, -4.41241302e-02f, -8.55481476e-02f, 6.74441382e-02f, -1.57238349e-01f, 4.14382666e-02f, 1.35516524e-01f, -6.86465874e-02f, 6.79393625e-03f,
  4.19610739e-01f, 3.84308049e-03f, 1.16155617e-01f, -1.73244789e-01f, 1.30290672e-01f, 3.46849680e-01f, 4.12489951e-01f, 1.38772219e-01f, -5.42422906e-02f, 1.26170795e-02f,
  4.69241738e-02f, -1.69173539e-01f, -1.60297498e-01f, -1.36321560e-01f, 1.05405957e-01f, 1.43101916e-01f, 4.25100699e-02f, -9.51691940e-02f, 2.40994114e-02f, 1.27684429e-01f,
  -9.54950824e-02f, -2.02452123e-01f, 7.86114484e-03f, -1.92855358e-01f, -2.66394764e-01f, -2.33439952e-01f, -7.14964047e-02f, -1.58029601e-01f, -4.35901294e-03f, -2.48368517e-01f,
  1.12885579e-01f, 1.96169004e-01f, 2.18957160e-02f, -2.76773516e-02f, -5.48843443e-02f, 6.16151877e-02f, 4.78187390e-02f, 3.56441317e-03f, -8.17956626e-02f, -1.42223816e-02f,
  -2.82270741e-02f, -5.17412312e-02f, 1.13735786e-02f, -1.06557244e-02f, 2.58770827e-02f, 8.36398676e-02f, -3.72934826e-02f, -5.00397617e-03f, 6.62806705e-02f, -4.82082879e-03f,
  -2.07209364e-01f, 7.03437328e-02f, 1.46356001e-01f, 7.46314228e-03f, -6.61392137e-02f, -6.95911944e-02f, 1.58229172e-02f, -1.87812876e-02f, 1.11063257e-01f, 4.67025898e-02f,
  -7.89509043e-02f, 5.42737208e-02f, 3.81562412e-02f, -3.17741483e-02f, -5.28206257e-03f, -2.73641292e-02f, -3.95052247e-02f, -1.65879186e-02f, 2.74044108e-02f, -1.04785785e-02f,
  7.49112619e-03f, 3.60168815e-02f, -3.06970794e-02f, 3.80697288e-02f, -4.92580086e-02f, 3.09121795e-02f, -7.18689803e-03f, -6.69993181e-03f, -1.77991372e-02f, -7.75616709e-03f,
  4.69824858e-02f, 2.45717615e-02f, -8.67606699e-02f, -2.68156026e-02f, 3.36274295e-03f, -4.59331274e-02f, 3.72755062e-03f, -4.59795967e-02f, -2.98997648e-02f, 6.78313151e-02f,
  -1.39644034e-02f, 2.37071738e-02f, 4.15527225e-02f, -4.78365645e-03f, 1.16693545e-02f, -5.29350564e-02f, -4.40469943e-02f, -6.07923744e-03f, -3.31438822e-03f, 3.86173986e-02f,
  -4.00358923e-02f, 9.73698497e-03f, -6.97924495e-02f, 2.78324746e-02f, 4.18980494e-02f, -1.35374200e-02f, -2.98746917e-02f, -5.85690793e-03f, -2.55768411e-02f, -2.01650877e-02f,
  -8.43365490e-02f, 1.42947674e-01f, 1.56382814e-01f, 4.21504118e-02f, -2.94173937e-02f, 7.56376162e-02f, 1.32943258e-01f, 3.58380973e-02f, 2.24071875e-01f, 1.50743037e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.24024007e-02f, -1.00869916e-01f, -1.10290870e-01f, -1.20208345e-01f, -2.10296869e-01f, -1.13157518e-01f, -2.66719580e-01f, -4.23722807e-03f, -1.11010531e-02f, -1.94322571e-01f,
  -8.83916989e-02f, 1.51551515e-01f, 3.60213146e-02f, 7.11767450e-02f, 5.27709946e-02f, -1.12805814e-01f, -1.06274650e-01f, 1.10111266e-01f, 4.55441326e-02f, 6.45997226e-02f,
  -1.23197515e-03f, -3.44428644e-02f, 1.47406504e-01f, 5.65180592e-02f, -1.59656089e-02f, -6.70811832e-02f, -1.44386366e-01f, -1.39043003e-01f, -1.46765396e-01f, -3.09385005e-02f,
  1.30796535e-02f, 1.03131115e-01f, 1.41785383e-01f, 2.38017552e-02f, -2.74493676e-02f, 3.41130495e-02f, 8.31812918e-02f, 4.40769941e-02f, -3.38659286e-02f, 1.84434932e-02f,
  6.16182052e-02f, 1.05337746e-01f, -1.32656908e-02f, 2.24904418e-02f, 8.10957626e-02f, -5.59773780e-02f, 8.58834311e-02f, -4.38071042e-02f, 7.48926848e-02f, -1.28843471e-01f,
  -8.30242038e-02f, -1.13383234e-01f, 6.04385957e-02f, 4.70575616e-02f, 4.22150940e-02f, 1.55637994e-01f, 5.49703389e-02f, 9.68090370e-02f, 3.52641381e-02f, 9.13727470e-03f,
  2.25211382e-02f, 2.39255968e-02f, 6.39842972e-02f, -6.03940487e-02f, 3.77925821e-02f, -2.71158088e-02f, 1.16303097e-02f, -4.42783646e-02f, 1.05313947e-02f, -3.21926363e-02f,
  1.50867188e-02f, -6.01255111e-02f, 3.32835428e-02f, 4.70177382e-02f, 6.77345321e-02f, -6.02445789e-02f, 4.57152985e-02f, 6.72067478e-02f, -2.17916984e-02f, 1.55139398e-02f,
  3.50082591e-02f, 5.99814318e-02f, -1.60525758e-02f, 8.15654919e-03f, -6.01342507e-02f, 2.14114096e-02f, -6.91399798e-02f, -1.71641856e-02f, 6.68632239e-02f, -3.67201120e-02f,
  1.34567946e-01f, 1.72510862e-01f, 5.73394410e-02f, -1.59393400e-02f, -1.04930066e-01f, 6.27185777e-02f, 2.92162094e-02f, -7.04839230e-02f, -4.79176268e-02f, -2.85327826e-02f,
  -6.90352842e-02f, 8.07863548e-02f, 6.16526753e-02f, -8.63614976e-02f, 6.30425811e-02f, -4.55118679e-02f, 4.43292670e-02f, 5.81991822e-02f, 5.93313724e-02f, -4.56356928e-02f,
  -8.24310109e-02f, 3.20351720e-02f, 1.10990845e-01f, 1.55596733e-02f, -2.68930886e-02f, -8.36689770e-03f, 1.02708004e-01f, -5.34231700e-02f, 1.59779992e-02f, -1.35347664e-01f,
  -1.95581868e-01f, -7.14045838e-02f, 1.29061773e-01f, -9.15899500e-02f, -1.27601147e-01f, -2.92681381e-02f, -7.07430765e-02f, -7.22279365e-04f, -1.18834227e-01f, -1.54153854e-01f,
  -6.09391648e-03f, 1.31779358e-01f, 1.69143513e-01f, 1.35745466e-01f, 1.70719504e-01f, 5.74276038e-02f, 7.25350762e-03f, 1.73822179e-01f, 2.18190372e-01f, -5.90287298e-02f,
  1.32810343e-02f, -7.39525482e-02f, -1.96802858e-02f, 1.30994767e-02f, -1.72129601e-01f, -6.08061068e-02f, -5.62727265e-02f, 3.71928811e-02f, -1.34290336e-02f, -5.61973415e-02f,
  2.16901362e-01f, -1.61959812e-01f, 1.11708917e-01f, -8.16520862e-03f, -2.45077331e-02f, -1.18277790e-02f, 1.32055180e-02f, 5.40208146e-02f, -1.06123298e-01f, -2.20872052e-02f,
  -6.05296418e-02f, -9.91305560e-02f, 6.64730743e-02f, 1.00260787e-02f, -1.38586909e-01f, -1.02408804e-01f, 8.14081356e-03f, -3.15542780e-02f, 7.01893866e-02f, -1.50300220e-01f,
  -9.31201354e-02f, -8.66677761e-02f, 8.61862227e-02f, -5.41499332e-02f, -1.38621638e-02f, 6.63502365e-02f, 5.77128753e-02f, -7.40506425e-02f, -6.94217682e-02f, -1.12133697e-01f,
  -5.88079952e-02f, -3.05313673e-02f, -5.20250723e-02f, 8.61494318e-02f, 7.82758817e-02f, 3.76455672e-02f, -5.28205745e-02f, 1.07559077e-01f, -8.13439768e-03f, 8.42382088e-02f,
  7.46448934e-02f, 3.12867109e-03f, 4.03518230e-02f, 5.34995869e-02f, 2.46251188e-02f, 5.74594028e-02f, -8.72340500e-02f, -3.05324439e-02f, -4.17381041e-02f, 6.75475821e-02f,
  -2.96993051e-02f, -1.86897290e-03f, -1.03284009e-01f, 3.24625187e-02f, -1.03494748e-01f, -5.81362844e-02f, 3.69164757e-02f, 3.07378769e-02f, -6.18972927e-02f, -5.28222416e-03f,
  2.26929873e-01f, 5.62612899e-02f, 1.00774199e-01f, 5.60720861e-02f, -5.25943823e-02f, -9.00705531e-02f, 7.67368525e-02f, -6.79909363e-02f, -6.16494119e-02f, -6.32692352e-02f,
  -5.93935736e-02f, 9.91121754e-02f, -4.74516489e-02f, -5.50061390e-02f, 9.41905156e-02f, 3.49216722e-02f, -6.95537031e-02f, -8.70687421e-03f, 5.37038222e-02f, -1.23549849e-02f,
  -4.92423959e-02f, -4.23786081e-02f, 2.02463716e-01f, 1.70587525e-01f, 5.87385744e-02f, 1.04427919e-01f, 1.97716415e-01f, 1.46766184e-02f, 1.73630312e-01f, 5.83747365e-02f,
  -1.17548577e-01f, 1.88255921e-01f, 2.07316205e-01f, 7.07896426e-02f, 1.04331963e-01f, 1.87313512e-01f, 1.10320412e-01f, 1.13103889e-01f, -2.03912649e-02f, -1.10370480e-02f,
  4.60042693e-02f, -1.25893906e-01f, -7.46998489e-02f, -1.70830041e-02f, 6.68103844e-02f, 1.69500306e-01f, 1.31332902e-02f, 2.19745785e-02f, -1.79385900e-01f, -2.68972889e-02f,
  5.07255690e-03f, -1.00838944e-01f, -1.33244783e-01f, -4.77970205e-02f, 3.88401449e-02f, -7.57135674e-02f, 5.14861941e-02f, -5.03373779e-02f, -2.07179375e-02f, -1.32098287e-01f,
  -9.49326530e-02f, 1.02791108e-01f, -1.15735330e-01f, -1.36949241e-01f, -4.10238951e-02f, -1.17258102e-01f, -2.57801055e-03f, -5.16520329e-02f, 1.05068505e-01f, -1.33088836e-02f,
  -1.28585491e-02f, -3.79504561e-02f, 1.43304048e-02f, -9.50574055e-02f, -1.08059607e-02f, 4.86141443e-02f, 4.79600318e-02f, 5.26862070e-02f, -3.01650222e-02f, 1.16553586e-02f,
  5.00287600e-02f, -9.48209167e-02f, -1.37226637e-02f, -9.74962115e-03f, 7.58641362e-02f, -9.87110138e-02f, 8.49933457e-03f, 5.69059364e-02f, -4.00486253e-02f, -9.82182547e-02f,
  -3.81830968e-02f, 4.26920280e-02f, 6.18739687e-02f, 4.15016487e-02f, -5.11959009e-02f, 4.98782620e-02f, 7.65321404e-02f, -6.19474836e-02f, -4.15104032e-02f, -3.81484367e-02f,
  -1.89896990e-02f, 3.25334840e-03f, 5.63704073e-02f, -8.19508955e-02f, -1.08001649e-01f, -3.71982045e-02f, 5.09165376e-02f, -2.70164339e-03f, -1.24113020e-02f, -4.46300730e-02f,
  -8.25026855e-02f, -2.39746254e-02f, -6.38979822e-02f, 7.24546835e-02f, 3.81571352e-02f, -2.72778273e-02f, 3.20174135e-02f, 7.13430867e-02f, 3.73093411e-02f, -4.15906496e-02f,
  -1.90771818e-01f, -6.44486472e-02f, -1.47404805e-01f, -7.05007613e-02f, 2.15303302e-02f, -9.72532779e-02f, -4.96697649e-02f, 1.23937130e-02f, 7.06008002e-02f, -9.27360803e-02f,
  -9.35789496e-02f, -4.92913425e-02f, 1.54121108e-02f, -6.94140047e-02f, -9.40074325e-02f, -3.48339155e-02f, -3.96176279e-02f, -9.02688280e-02f, -1.76797956e-02f, -4.85983037e-04f,
  3.01664006e-02f, -4.24667373e-02f, -2.18758993e-02f, -5.03608100e-02f, -6.20215498e-02f, -1.11378774e-01f, -4.68961224e-02f, -6.45185413e-04f, -2.63844505e-02f, -5.16956151e-02f,
  5.31297684e-01f, -1.41740128e-01f, -4.53640632e-02f, 3.81517522e-02f, -2.04371095e-01f, -1.28074408e-01f, -1.44206509e-01f, 1.53730577e-02f, 8.08307454e-02f, 8.40598624e-03f,
  1.28018752e-01f, 1.56340346e-01f, 2.09136620e-01f, 2.52209336e-01f, 2.52097875e-01f, 3.17981653e-02f, -1.00003377e-01f, 1.35156125e-01f, 1.62409976e-01f, -5.62534891e-02f,
  -3.66640240e-02f, -2.81671565e-02f, -9.25906003e-03f, 4.32410231e-03f, -1.82197869e-01f, -3.95077765e-02f, -1.20460764e-01f, -1.84225485e-01f, -1.37100846e-01f, -5.67659847e-02f,
  6.34706691e-02f, 2.86174249e-02f, 7.73640862e-03f, 5.70897199e-02f, -1.15384474e-01f, -1.87951457e-02f, -2.52116863e-02f, -6.02502674e-02f, 1.24714412e-02f, -1.71187837e-02f,
  -1.38066188e-01f, -6.03838451e-03f, 4.53168005e-02f, -1.27972066e-01f, -2.67672259e-02f, -8.64398703e-02f, 1.95402279e-03f, 9.19679180e-02f, 3.57042030e-02f, -1.03637382e-01f,
  -9.93684456e-02f, -1.43147111e-01f, -4.36061108e-03f, -6.41385885e-03f, -7.73531944e-02f, 9.80092734e-02f, -1.34992719e-01f, -4.92873266e-02f, -2.10566795e-03f, 5.00219353e-02f,
  2.76815444e-02f, 5.89322262e-02f, -3.74067090e-02f, 6.61374331e-02f, -4.89039999e-03f, 6.23499453e-02f, -2.99706664e-02f, 9.34230071e-03f, -2.63032392e-02f, -1.15742363e-01f,
  2.64322143e-02f, 1.08848497e-01f, 3.79809514e-02f, -3.47622447e-02f, -3.24665122e-02f, 1.63867068e-03f, -3.06717642e-02f, 5.09328023e-02f, 2.57080738e-02f, 9.37427804e-02f,
  4.34257686e-02f, -2.37828065e-02f, -5.70474640e-02f, -2.25817226e-03f, 6.56719282e-02f, -7.14245662e-02f, 5.01330383e-02f, -5.38058430e-02f, -1.40339835e-02f, -8.30228701e-02f,
  1.40427062e-02f, 1.48575455e-01f, 8.87235552e-02f, 1.19070999e-01f, -5.84978573e-02f, -5.70080318e-02f, 3.30737755e-02f, -1.06033720e-01f, -4.73543704e-02f, -3.84225957e-02f,
  -9.43007227e-03f, 1.39477272e-02f, -3.43257040e-02f, -7.19796196e-02f, 7.00807571e-02f, 6.30985573e-02f, -2.56397538e-02f, -1.51353860e-02f, -2.58435123e-02f, -5.02037108e-02f,
  -5.72325513e-02f, 1.29062757e-01f, 1.64976880e-01f, 8.97196010e-02f, -9.15090740e-03f, 2.33724937e-01f, 3.29440571e-02f, -4.40110527e-02f, 2.15838104e-01f, 9.29966122e-02f,
  -1.89901501e-01f, 1.65499404e-01f, 6.83603063e-02f, -4.30647917e-02f, 4.88501713e-02f, 9.20123309e-02f, 3.11980963e-01f, 4.74352352e-02f, -1.10235646e-01f, 9.47679132e-02f,
  3.80136468e-03f, -2.02780277e-01f, -6.76921308e-02f, -4.28280123e-02f, 8.67359638e-02f, 8.22865367e-02f, 1.59704655e-01f, 4.70624189e-04f, -5.35087697e-02f, -7.28066033e-03f,
  5.24852090e-02f, -1.76651999e-01f, -2.06010491e-01f, -5.89498952e-02f, -6.29703104e-02f, -7.58528896e-03f, -5.58715761e-02f, -9.97713581e-03f, 4.59529161e-02f, -3.45702022e-02f,
  -2.90626027e-02f, 3.71997394e-02f, -6.81948736e-02f, -2.68999785e-02f, 7.39407446e-03f, -8.49448144e-02f, 6.79866597e-02f, -1.97702385e-02f, -9.87161100e-02f, -5.63916517e-03f,
  -4.10003141e-02f, 2.24314164e-02f, 2.50113138e-04f, -9.99249071e-02f, -6.93482757e-02f, -8.60512182e-02f, -4.31693718e-02f, -8.93381760e-02f, -9.15407315e-02f, 4.33935672e-02f,
  1.38493210e-01f, 1.00090966e-01f, -4.17318195e-02f, -3.08136940e-02f, 1.22090308e-02f, -9.25761014e-02f, -5.68433888e-02f, -3.82333845e-02f, -5.57663105e-02f, -6.88026100e-02f,
  -8.53695255e-03f, -7.93055631e-04f, 6.59562275e-02f, 9.60848480e-03f, 7.68215656e-02f, 1.65472142e-02f, -5.83627671e-02f, -6.03417344e-02f, -1.06381373e-02f, -5.48487082e-02f,
  -4.54136655e-02f, -5.49968109e-02f, 6.32770658e-02f, -1.09445145e-02f, -9.40589905e-02f, 3.96218114e-02f, -4.39475253e-02f, -5.80228753e-02f, 3.14538106e-02f, -8.68953392e-03f,
  2.42217444e-02f, -3.20130214e-02f, -2.45264135e-02f, -4.74984497e-02f, 9.69075933e-02f, -7.46060014e-02f, 6.46072775e-02f, 2.34558545e-02f, -1.01956032e-01f, -2.96260091e-03f,
  -2.74750859e-01f, 1.42719105e-01f, -8.42316896e-02f, -7.83922449e-02f, 1.05976267e-02f, -3.60059217e-02f, 8.65993369e-03f, -6.96862042e-02f, -9.36240852e-02f, -5.98821742e-03f,
  4.94812280e-02f, 4.15022392e-03f, 2.87014861e-02f, -8.97812694e-02f, -5.98289371e-02f, -5.89767881e-02f, -5.46956323e-02f, -4.11072411e-02f, -7.56744593e-02f, -4.06525210e-02f,
  -5.25214598e-02f, -2.53186319e-02f, -3.95506509e-02f, -1.67613663e-02f, -5.31279556e-02f, -1.84504688e-01f, -8.69661123e-02f, -1.33825511e-01f, -6.18140548e-02f, -1.56894967e-01f,
  -4.64936532e-02f, 6.66118562e-02f, -5.50220869e-02f, 7.75920507e-03f, 2.70842947e-02f, -2.72751935e-02f, 1.35186791e-01f, 1.40716091e-01f, -1.77902417e-04f, 7.18665048e-02f,
  -1.13973819e-01f, 7.38536865e-02f, 6.02615289e-02f, -4.08755131e-02f, 1.88485496e-02f, 1.82657897e-01f, 1.54142112e-01f, 4.40226085e-02f, -6.97856173e-02f, -1.97299034e-03f,
  5.74620031e-02f, 5.12066521e-02f, -3.74522842e-02f, 3.46078873e-02f, 1.76281646e-01f, 1.32063907e-02f, 6.89070523e-02f, 4.74071056e-02f, 2.25799507e-03f, 1.56034008e-01f,
  -1.52026236e-01f, -7.99978301e-02f, -1.24398872e-01f, 6.14188472e-03f, -7.39569515e-02f, -4.97112237e-02f, -4.99495752e-02f, -9.70706809e-03f, -4.81603071e-02f, -1.88547261e-02f,
  -7.38662705e-02f, -2.34659947e-02f, 4.92670760e-02f, 6.16148412e-02f, 4.23201621e-02f, 4.82760184e-02f, -7.44178593e-02f, -7.03852996e-02f, 5.96153215e-02f, -9.57089067e-02f,
  3.55524831e-02f, -9.49948207e-02f, -1.61581993e-01f, 2.66070589e-02f, -2.38255225e-03f, -1.41646758e-01f, -7.33071342e-02f, 2.45253239e-02f, -1.53089300e-01f, 1.12823900e-02f,
  3.02379094e-02f, 1.90009978e-02f, -4.12873290e-02f, -3.29118334e-02f, 2.83903796e-02f, 4.39736284e-02f, 5.82268722e-02f, 5.91882132e-02f, -6.16552643e-02f, 5.50163165e-02f,
  7.80082680e-03f, -4.67548147e-02f, -1.51362605e-02f, -1.95780601e-02f, -2.68941782e-02f, -5.66409454e-02f, -4.75313179e-02f, 1.00545317e-01f, -9.51627493e-02f, 2.39002667e-02f,
  8.07709247e-03f, -7.86071047e-02f, 4.68134321e-02f, -3.13195325e-02f, -9.51273367e-03f, -7.10796416e-02f, -1.38222184e-02f, 2.35095490e-02f, -1.05175683e-02f, 6.75453693e-02f,
  5.87630048e-02f, -2.12348461e-01f, 1.30390627e-02f, 3.29445861e-02f, -1.49079813e-02f, -5.31867556e-02f, -9.02942345e-02f, 2.97279414e-02f, -1.07491128e-01f, 1.25877783e-02f,
  -3.99461351e-02f, 4.47148755e-02f, -8.26240554e-02f, -2.67973412e-02f, -5.66341318e-02f, -1.05698712e-01f, 1.08760439e-01f, -4.03996333e-02f, 2.06304137e-02f, -1.05078354e-01f,
  -2.15372071e-02f, -4.96881828e-02f, -3.45001556e-02f, -7.99440965e-02f, -9.03346241e-02f, -1.29525155e-01f, -8.80134627e-02f, -2.50409804e-02f, -1.12027965e-01f, -1.53053040e-02f,
  4.29930575e-02f, 2.30052307e-01f, 1.67800307e-01f, 1.16605863e-01f, 1.28714785e-01f, 2.53740940e-02f, 1.82117984e-01f, 1.51752919e-01f, 6.02918491e-02f, 9.58503336e-02f,
  -8.26007947e-02f, -1.51136294e-01f, -9.03447792e-02f, -4.70860004e-02f, -6.89604506e-02f, -6.06742576e-02f, -2.41357572e-02f, -7.01725781e-02f, -1.23161890e-01f, -1.42300263e-01f,
  -8.02753568e-02f, 8.42626244e-02f, 5.30615635e-02f, 6.77989274e-02f, -5.62569946e-02f, -1.51580513e-01f, 1.17513277e-01f, 6.29433542e-02f, 5.19711804e-03f, -1.11591026e-01f,
  -3.78974974e-02f, 1.25564486e-01f, -7.99919739e-02f, -3.80970985e-02f, 6.05715662e-02f, -7.29882065e-03f, 3.72889861e-02f, 1.33116931e-01f, 1.55685455e-01f, 5.84062822e-02f,
  2.55744196e-02f, 1.09643012e-01f, 2.58468240e-02f, -4.94475849e-02f, 1.07821472e-01f, 1.37139084e-02f, 8.29876307e-03f, 8.58170167e-02f, 1.06364429e-01f, 1.79789308e-02f,
  1.35502908e-02f, -1.08546559e-02f, 2.56512333e-02f, 7.08010271e-02f, -6.92925453e-02f, -1.36510819e-01f, 9.85420030e-03f, -1.00214086e-01f, 2.36291718e-03f, 4.25219722e-02f,
  -4.62068021e-02f, -3.20556224e-03f, -5.84547184e-02f, -5.18372469e-02f, -7.70174414e-02f, -5.59282936e-02f, 8.27867985e-02f, -1.08218100e-02f, 7.33219013e-02f, 8.81687850e-02f,
  1.06601372e-01f, 6.05739169e-02f, 5.88688068e-02f, 7.38035440e-02f, -1.12024806e-01f, 8.37390199e-02f, -5.04888371e-02f, -8.50071106e-03f, -2.21598651e-02f, 5.39185526e-03f,
  -1.38104409e-01f, -3.16106603e-02f, 5.99583089e-02f, 3.72560993e-02f, -6.22363761e-02f, -5.12095876e-02f, -2.85886670e-03f, 4.68463674e-02f, 1.31165951e-01f, 9.77239981e-02f,
  1.02602124e-01f, -6.77812472e-02f, -1.98099107e-01f, 7.27864262e-03f, 1.09938674e-01f, 6.13471530e-02f, -2.46634018e-02f, -1.27772372e-02f, 6.36456311e-02f, 1.01825990e-01f,
  3.55825685e-02f, -5.40785752e-02f, 1.26468644e-01f, 8.45682248e-02f, 2.80360226e-02f, 3.02218776e-02f, 7.35909492e-02f, 7.89764076e-02f, 3.59646454e-02f, 9.04784724e-02f,
  1.34828553e-01f, 4.56761196e-02f, -5.64684048e-02f, 6.32803366e-02f, -7.30936229e-02f, -1.23523600e-01f, 7.35580251e-02f, -5.79029657e-02f, -2.33359486e-02f, -3.33651155e-02f,
  -2.14757681e-01f, -1.38977151e-02f, 3.05906627e-02f, -2.14065298e-01f, 5.98821715e-02f, 1.86409891e-01f, 5.49728982e-02f, -5.12945317e-02f, -2.65751071e-02f, -9.94081646e-02f,
  -1.54656023e-01f, -1.16134986e-01f, 2.18415912e-03f, 2.97204796e-02f, -1.11904163e-02f, 6.88066483e-02f, 1.41395777e-01f, 8.09482709e-02f, 4.65237014e-02f, -7.72583559e-02f,
  -9.59549248e-02f, -6.83255866e-02f, -1.64192587e-01f, 7.92768039e-03f, -1.45455018e-01f, -2.72839982e-02f, -7.76582062e-02f, -1.54396877e-01f, 3.58682834e-02f, 3.87060903e-02f,
  -8.87853801e-02f, -3.35048474e-02f, 2.64664609e-02f, 6.16596714e-02f, -1.23394400e-01f, 7.83127770e-02f, -5.31359948e-02f, -8.35331455e-02f, -7.07889348e-02f, -7.77919367e-02f,
  -9.11349133e-02f, -7.82461613e-02f, -2.53572147e-02f, -3.76753211e-02f, -1.19145261e-03f, 2.38054898e-02f, -4.17262018e-02f, -4.02375758e-02f, -5.82501739e-02f, 6.06142245e-02f,
  3.67991701e-02f, -4.53205369e-02f, 7.08262995e-02f, 8.69532749e-02f, -2.90234182e-02f, 8.89351442e-02f, 3.73204798e-02f, -1.07626813e-02f, -4.65262868e-02f, -1.00614280e-01f,
  -5.52965561e-03f, 6.72552586e-02f, 1.81429889e-02f, -7.51708224e-02f, -3.14820595e-02f, 8.60632211e-02f, 7.80755952e-02f, -3.99490818e-02f, -2.14896612e-02f, -6.68540522e-02f,
  4.87366505e-02f, 8.27302337e-02f, -5.56412991e-03f, 4.48714420e-02f, -1.86422635e-02f, -4.80269492e-02f, 6.59381854e-04f, 5.22303954e-02f, 9.52660739e-02f, -4.50866520e-02f,
  -1.91166196e-02f, 5.83208650e-02f, 6.58559613e-03f, 4.20676172e-03f, 2.80564632e-02f, -7.19319358e-02f, -1.33860791e-02f, -4.47361618e-02f, -4.67484526e-04f, 2.33301874e-02f,
  -2.83747405e-01f, 2.93910075e-02f, 4.73803878e-02f, -9.03509036e-02f, -1.34425955e-02f, -2.76999753e-02f, 4.42642123e-02f, -7.45316148e-02f, 2.05380768e-02f, -7.50220045e-02f,
  -1.23642143e-02f, 4.56996309e-03f, -7.50877187e-02f, 7.35590532e-02f, -2.92524956e-02f, 3.17088999e-02f, 1.87487453e-02f, 4.92215343e-02f, 1.26728520e-01f, -3.53721417e-02f,
  4.80938591e-02f, 1.48394004e-01f, -5.84924035e-03f, 6.95094392e-02f, 1.16415219e-02f, 6.80187792e-02f, -2.51180194e-02f, -6.22431599e-02f, 9.43867639e-02f, 1.31824687e-01f,
  4.03809369e-01f, 4.09994200e-02f, -1.01435184e-01f, 3.65369162e-03f, -1.25160784e-01f, -1.04477808e-01f, -9.92522389e-02f, 2.75438484e-02f, 1.61504716e-01f, 1.59675002e-01f,
  5.49084470e-02f, 1.14402138e-01f, 1.11253940e-01f, 9.37993173e-03f, 4.91703264e-02f, -5.44429980e-02f, 5.66147268e-02f, 9.92962811e-03f, -2.19292734e-02f, -2.78009325e-02f,
  1.11063510e-01f, 1.04304381e-01f, 1.55441687e-02f, 1.06242597e-01f, 5.13157807e-02f, 5.52873686e-02f, -3.01677585e-02f, -1.42215490e-01f, -7.98393786e-02f, -3.78554054e-02f,
  -9.97897834e-02f, -9.80973020e-02f, 1.31538987e-01f, 1.02523677e-01f, 4.49953154e-02f, 1.69087112e-01f, 1.00627162e-01f, 6.33066148e-03f, -3.99489515e-03f, -3.02265044e-02f,
  -4.11432050e-03f, -4.24563838e-03f, -6.20738678e-02f, 2.77282037e-02f, 3.73628363e-02f, 6.39477521e-02f, -5.63036762e-02f, 2.34619547e-02f, 4.95983027e-02f, 6.80280551e-02f,
  9.84926708e-03f, -6.55556843e-02f, -1.08534776e-01f, -7.18244016e-02f, 1.11593790e-02f, -5.90746328e-02f, -6.19716458e-02f, -2.98949201e-02f, 2.15205550e-02f, 7.33654872e-02f,
  1.35422125e-01f, 1.12423584e-01f, 7.78981820e-02f, 3.44417989e-02f, 1.62486155e-02f, -7.34854564e-02f, 6.70789331e-02f, -1.89710837e-02f, -7.21695945e-02f, 2.25061383e-02f,
  -2.93271299e-02f, -6.27915934e-02f, -1.87026188e-02f, 1.09038725e-01f, -4.31840541e-03f, -1.17394075e-01f, 5.56128053e-03f, -1.08144395e-02f, -8.63240212e-02f, -1.68600325e-02f,
  6.72115851e-03f, 5.67511655e-02f, -6.10807389e-02f, 7.99980108e-03f, 3.80291604e-03f, 2.38980502e-02f, 4.49911952e-02f, 6.93369657e-02f, -5.82502484e-02f, 1.45294163e-02f,
  -1.36490837e-01f, -1.01673938e-01f, 1.61216050e-01f, 1.51968911e-01f, -7.94414729e-02f, -4.76203039e-02f, -6.56409655e-03f, -2.06652097e-03f, -3.78161073e-02f, -9.64948460e-02f,
  -1.11461036e-01f, 2.47849450e-02f, 4.60544378e-02f, -8.17544237e-02f, -7.80506209e-02f, 5.05721569e-02f, -2.87419129e-02f, 9.00185555e-02f, 4.92730290e-02f, -1.15562165e-02f,
  -5.37666827e-02f, -2.23195087e-02f, 1.08507469e-01f, -2.92560961e-02f, 7.07079247e-02f, 1.31909639e-01f, 1.96575075e-02f, 3.57885808e-02f, 5.27606010e-02f, 5.36314659e-02f,
  -5.30626118e-01f, -2.02153593e-01f, 2.89584130e-01f, -1.77581087e-01f, 2.18534824e-02f, -9.76877511e-02f, 1.13713497e-03f, -1.49371475e-01f, -1.60705149e-01f, -1.90764964e-01f,
  -1.60531208e-01f, 1.09735373e-02f, -2.68498641e-02f, 1.88410297e-01f, 1.49795130e-01f, 7.13098189e-03f, 1.78266406e-01f, 2.91741341e-01f, 2.03815341e-01f, -1.02694131e-01f,
  -1.18164450e-01f, 4.97584678e-02f, 4.92409691e-02f, -6.11822456e-02f, -1.75247908e-01f, 2.88930517e-02f, 3.16697918e-02f, -4.02082354e-02f, 4.93273921e-02f, -6.15768321e-02f,
  -2.37011850e-01f, -2.39377409e-01f, 1.17153160e-01f, 5.73384129e-02f, -1.60983820e-02f, -7.19781592e-02f, -1.24898732e-01f, 5.33076227e-02f, -7.74898455e-02f, -1.12626040e-02f,
  1.40526500e-02f, -2.09565386e-02f, 2.60480065e-02f, -3.88897657e-02f, -3.53464074e-02f, -6.71298429e-02f, 7.43669495e-02f, 9.88781452e-02f, 4.59985295e-03f, -1.17288075e-01f,
  -9.06268880e-02f, -1.14017770e-01f, -1.19789168e-01f, -5.16075827e-02f, -8.74314830e-02f, 3.00204679e-02f, -8.45230669e-02f, -6.90430403e-02f, -4.83877771e-02f, -2.47355729e-01f,
  -1.87923871e-02f, 8.32007080e-02f, 1.46506785e-03f, 5.29196933e-02f, -5.32212444e-02f, -4.25427593e-02f, 6.54869378e-02f, 2.64626555e-02f, -5.29217459e-02f, 7.13120848e-02f,
  -3.71463108e-03f, 1.15929842e-02f, -3.96645721e-03f, -6.39001280e-02f, -1.01438735e-03f, 2.29044575e-02f, 4.73441482e-02f, -4.97658402e-02f, 4.94845808e-02f, 2.84469835e-02f,
  -3.45367156e-02f, -4.28842157e-02f, 9.00760144e-02f, -3.53336297e-02f, 4.92446311e-03f, 8.74985158e-02f, -4.34169658e-02f, -1.08479953e-03f, -3.47869694e-02f, 5.04172826e-03f,
  -1.75040171e-01f, 4.42903668e-01f, -2.35791728e-01f, -1.40585735e-01f, -4.39911708e-02f, 9.61438417e-02f, -5.92495501e-02f, 6.33420125e-02f, -3.93556133e-02f, -1.08804010e-01f,
  -3.98370959e-02f, -1.27675250e-01f, -4.35472652e-02f, -1.96445379e-02f, -4.42646928e-02f, -3.47601958e-02f, -7.06903115e-02f, 1.09773930e-02f, -5.29205538e-02f, -1.62412133e-02f,
  1.77948177e-02f, -2.10318193e-01f, -1.98139295e-01f, -1.66111831e-02f, -1.12044595e-01f, -1.24747112e-01f, -9.60675478e-02f, -1.10135719e-01f, -3.38415392e-02f, -1.27715617e-01f,
  -8.94381881e-01f, -7.27298781e-02f, 1.92850288e-02f, -5.92479706e-01f, -1.93339929e-01f, 1.20677553e-01f, 2.23796830e-01f, -8.83651152e-02f, -2.78019994e-01f, -1.01448804e-01f,
  2.66817529e-02f, -1.06437862e-01f, -9.03449580e-03f, 7.28566013e-03f, 5.43364882e-02f, 7.20292553e-02f, -2.37832516e-01f, -1.11140117e-01f, -4.72146347e-02f, -5.11705466e-02f,
  -1.49303293e-02f, -2.87852615e-01f, -4.06759471e-01f, -2.32245997e-01f, -9.10492614e-02f, -9.31228995e-02f, -9.88352820e-02f, -2.44315460e-01f, 1.04726374e-01f, -2.49294832e-01f,
  5.37611842e-01f, -2.74253666e-01f, 2.66224090e-02f, -9.51990560e-02f, -1.18001886e-02f, -6.78308234e-02f, -8.79904442e-03f, -8.17382410e-02f, -3.74795906e-02f, 4.93174195e-02f,
  -1.20219491e-01f, -8.68528411e-02f, -5.06503992e-02f, 2.89077535e-02f, -9.81270522e-02f, 1.50147118e-02f, -1.56262398e-01f, -1.52246162e-01f, -4.44861352e-02f, 1.09420300e-01f,
  3.93286906e-02f, -1.30250618e-01f, -2.77093928e-02f, 1.43779531e-01f, 8.48667473e-02f, -6.18572086e-02f, 1.71638653e-01f, 1.09320886e-01f, 6.06134348e-02f, 2.86613274e-02f,
  3.32088806e-02f, 1.06294174e-02f, -3.24902907e-02f, 1.01937708e-02f, -1.88891962e-02f, -4.10937145e-02f, -2.98828501e-02f, 5.44513296e-03f, 7.02259270e-03f, -2.43946519e-02f,
  4.33234759e-02f, 8.54672566e-02f, 6.92562759e-02f, -2.09446140e-02f, -3.23440731e-02f, -1.00538798e-01f, 3.33791524e-02f, 5.79827912e-02f, 4.49433923e-03f, -9.21296254e-02f,
  -5.20783998e-02f, 3.22791561e-02f, -2.07637157e-02f, 4.60864604e-03f, 4.92212661e-02f, -6.89797252e-02f, 2.01519020e-02f, -7.32744299e-03f, -7.11655989e-02f, -2.34342590e-02f,
  1.60680488e-01f, -3.06395628e-02f, -4.25228626e-02f, -1.21115074e-01f, -1.32235333e-01f, -9.98558290e-03f, 5.59081323e-02f, -9.23689157e-02f, 3.03619914e-03f, 8.01202059e-02f,
  1.20287932e-01f, -4.83833477e-02f, 4.42614430e-04f, -6.32687984e-03f, 6.29572719e-02f, 8.98993853e-03f, -6.29392937e-02f, -1.07568063e-01f, 1.97927393e-02f, 1.54818922e-01f,
  6.08021801e-04f, -7.09316880e-02f, 4.37785219e-03f, 1.07826471e-01f, -1.40756620e-02f, -6.42063329e-03f, 2.44006172e-01f, 1.78791448e-01f, 1.35453669e-02f, 1.98137704e-02f,
  -1.10091910e-01f, -2.30863970e-02f, 2.66169459e-01f, 1.31026566e-01f, -1.24067269e-01f, -1.43430710e-01f, -2.62333065e-01f, -8.52166116e-02f, 6.83771595e-02f, -5.13372757e-03f,
  -1.52302697e-01f, -1.07716627e-01f, -5.73580116e-02f, -1.30455583e-01f, -2.11752877e-02f, 1.41734228e-01f, 1.89346269e-01f, 6.99160248e-03f, -1.31548196e-01f, -2.54174381e-01f,
  -1.12798162e-01f, -1.81065992e-01f, -2.12305393e-02f, 6.50730431e-02f, -9.63762961e-03f, -1.05113223e-01f, 3.92005928e-02f, -5.26157916e-02f, -5.00327908e-02f, -2.96301208e-03f,
  1.10195987e-01f, 5.79814315e-02f, -2.12928262e-02f, -1.45246342e-01f, 8.43054615e-03f, 2.12273933e-02f, -1.11878961e-01f, 9.57613215e-02f, -2.24469658e-02f, 2.89238915e-02f,
  9.23140999e-03f, -2.49179862e-02f, -1.36290081e-02f, 4.74519543e-02f, -2.11416767e-03f, 4.52031847e-03f, 1.93058215e-02f, 9.84390080e-02f, 1.15095422e-01f, 5.08017689e-02f,
  -3.53363380e-02f, -1.50254145e-01f, -1.23354226e-01f, 9.18761734e-03f, 1.05488789e-03f, 1.59308743e-02f, -6.57872036e-02f, -1.31040394e-01f, -4.17089798e-02f, -1.17972538e-01f,
  -6.62919581e-02f, 1.06678724e-01f, 1.08909644e-02f, -8.74977857e-02f, -2.13984679e-02f, 1.55725062e-01f, 5.95902316e-02f, -8.35182667e-02f, -5.34104519e-02f, 4.83438373e-02f,
  1.05988815e-01f, 8.36080872e-03f, 1.00215785e-01f, -8.29555932e-03f, -8.76230653e-03f, -5.26861474e-03f, 3.06573659e-02f, -2.07373928e-02f, 1.30739098e-03f, -4.30650450e-02f,
  -5.08557670e-02f, 3.35971266e-02f, -3.05739846e-02f, -3.67531963e-02f, 1.16690500e-02f, 1.27433706e-02f, 7.27834832e-03f, -9.57956389e-02f, 7.25608915e-02f, 7.55071491e-02f,
  1.92945935e-02f, 8.03901106e-02f, -1.98167674e-02f, -8.70463327e-02f, -1.50458673e-02f, 3.47623900e-02f, -4.13856916e-02f, -3.81748378e-02f, -6.49999874e-03f, -5.64731322e-02f,
  -1.08814441e-01f, -1.01471335e-01f, -9.44677566e-04f, 2.94276848e-02f, -7.09175840e-02f, -3.93623067e-03f, -1.05819806e-01f, -3.51168960e-02f, -7.95048103e-02f, 7.43336454e-02f,
  2.97705624e-02f, -1.63921446e-01f, -1.21488981e-01f, -7.69215599e-02f, 3.13377678e-02f, -1.94156840e-01f, -7.47620761e-02f, -4.79986705e-02f, -1.54546976e-01f, -1.26663715e-01f,
  2.71449864e-01f, 7.72304013e-02f, -2.18526810e-01f, 1.35679692e-01f, -1.30953476e-01f, -1.43993467e-01f, -4.40787002e-02f, -3.61253768e-02f, 1.30916342e-01f, -2.70507019e-02f,
  -4.49204072e-02f, -9.53063443e-02f, -8.27965066e-02f, -1.54673204e-01f, -2.07493395e-01f, -5.08956164e-02f, -9.42606553e-02f, -2.70265907e-01f, -2.55993038e-01f, -7.82495886e-02f,
  -7.24209845e-02f, -7.52960742e-02f, -1.63681910e-03f, -6.21090010e-02f, 3.82727161e-02f, -7.36832060e-03f, -1.10694788e-01f, -2.92907860e-02f, -7.85560682e-02f, 6.14689477e-02f,
  -8.37648362e-02f, -7.16201663e-02f, -8.30832645e-02f, 5.66450395e-02f, -1.21394858e-01f, -2.24010292e-02f, 7.86380097e-03f, 6.13290109e-02f, -6.65896982e-02f, 5.99065870e-02f,
  -1.37399569e-01f, 5.23743108e-02f, -5.46764880e-02f, -1.26164849e-03f, -4.99768928e-03f, -1.96243282e-02f, -2.08687279e-02f, -7.67645389e-02f, -1.45474851e-01f, 2.14731563e-02f,
  -6.86760694e-02f, -1.29320502e-01f, -1.96305633e-01f, -5.63253136e-03f, -3.04668956e-02f, -1.47727638e-01f, -7.63473287e-02f, -1.26804714e-03f, -1.39273196e-01f, 1.71978265e-01f,
  4.62025637e-03f, 8.75416398e-03f, -1.06202345e-02f, 6.38802573e-02f, 7.32478499e-02f, 1.10112922e-02f, 5.15052713e-02f, 1.94610786e-02f, 4.77542803e-02f, 7.37993512e-03f,
  -5.57564534e-02f, 8.23201612e-02f, -4.59280461e-02f, 1.09265400e-02f, -8.02012980e-02f, 4.08546031e-02f, -7.47394573e-04f, 2.91245077e-02f, -2.15199105e-02f, 8.61128494e-02f,
  -6.15377799e-02f, -1.91008765e-02f, 5.89657528e-03f, 8.31403658e-02f, -3.08465548e-02f, -2.46140901e-02f, -3.16493437e-02f, 3.97105366e-02f, 1.00192226e-01f, -5.94571605e-02f,
  1.13170989e-01f, -2.62475520e-01f, 2.35645957e-02f, 9.76081267e-02f, -4.97035757e-02f, -3.17962617e-02f, 6.18701279e-02f, -5.56077398e-02f, -1.93190575e-02f, 6.79035038e-02f,
  -4.12636176e-02f, 5.78623004e-02f, -3.13643366e-02f, 4.28736880e-02f, -2.65575224e-03f, -3.88447754e-02f, -2.70353407e-02f, 2.19766311e-02f, -5.73763810e-02f, 9.40816477e-02f,
  9.69108716e-02f, -9.74660590e-02f, 4.09941971e-02f, 5.67275509e-02f, 4.09001075e-02f, -1.18805721e-01f, -8.57286304e-02f, -6.53515309e-02f, -4.18705344e-02f, 2.58896321e-01f,
  3.38739783e-01f, 6.47988245e-02f, -1.54530853e-01f, 1.09088048e-01f, 1.46091998e-01f, -3.22531387e-02f, -2.43599340e-02f, 1.46312937e-01f, 1.72460854e-01f, 1.64729014e-01f,
  1.13065094e-01f, 2.37243071e-01f, 1.25946045e-01f, 1.14147566e-01f, -1.77171137e-02f, -3.83023694e-02f, 7.88411200e-02f, -6.40330315e-02f, 8.94270167e-02f, 4.88707982e-02f,
  7.09687620e-02f, 7.15151280e-02f, -2.91446000e-02f, -6.72895759e-02f, -9.22684520e-02f, 3.77545170e-02f, -4.37652227e-03f, -9.07268152e-02f, 2.24321950e-02f, -1.31607652e-01f,
  -2.72038609e-01f, -1.30668968e-01f, 1.16226070e-01f, 1.54097021e-01f, -1.07578859e-01f, -5.32590039e-02f, 3.77866328e-02f, -1.45114624e-04f, 1.02120219e-02f, -4.54997234e-02f,
  1.69886220e-02f, -4.17543389e-02f, -1.03682261e-02f, -3.95967439e-03f, -6.80553094e-02f, 7.91250635e-03f, -1.09286949e-01f, -2.80763991e-02f, 8.77655763e-03f, -1.91028360e-02f,
  -2.27145571e-02f, 3.30359004e-02f, -2.59214751e-02f, -5.59759513e-02f, -1.08525567e-01f, -4.17268984e-02f, -1.61586449e-01f, -1.46994814e-01f, 1.50314346e-02f, -2.57731578e-03f,
  -3.35646197e-02f, 6.42378256e-02f, -3.77813876e-02f, 2.54669171e-02f, 7.70889968e-02f, -2.88018361e-02f, 2.03627138e-03f, -8.97108484e-03f, 1.05553992e-01f, -3.80215086e-02f,
  -3.11569087e-02f, -7.15634180e-03f, -6.28327802e-02f, 3.87193598e-02f, -2.04141694e-03f, -1.43438987e-02f, 3.66147459e-02f, 2.32046712e-02f, -1.05075072e-02f, -1.79538857e-02f,
  -2.28570607e-02f, 6.23345710e-02f, -2.78277975e-02f, -3.51108685e-02f, 3.85731421e-02f, 4.00633626e-02f, 4.87052239e-02f, 3.03342808e-02f, 3.87962572e-02f, 3.94318253e-02f,
  3.30172479e-02f, -6.42811833e-03f, 6.22902177e-02f, -1.16079329e-02f, 2.30617281e-02f, -8.16554651e-02f, -1.65822990e-02f, -6.06532954e-02f, -1.11229248e-01f, -8.45799372e-02f,
  1.47376610e-02f, 7.96672888e-03f, 3.25526968e-02f, -7.56617710e-02f, -2.72480324e-02f, 2.46905852e-02f, 6.10779785e-02f, 1.90310869e-02f, -2.18743663e-02f, -8.77426863e-02f,
  4.38071154e-02f, 8.30744430e-02f, 2.12882638e-01f, 1.38087735e-01f, 2.06560083e-02f, 1.84458122e-01f, 7.78464451e-02f, 4.81106825e-02f, 1.08042397e-01f, 1.54431537e-01f,
  -1.27909193e-02f, 2.24669993e-01f, 8.57066736e-02f, 1.73978344e-01f, 3.27787966e-01f, 3.47096682e-01f, 3.83167714e-01f, 7.87223503e-02f, -2.97283698e-02f, 1.11155465e-01f,
  2.93906093e-01f, 1.05609037e-01f, 3.68605517e-02f, -5.77068366e-02f, 1.11943007e-01f, 9.84580144e-02f, -9.55653340e-02f, -1.23034656e-01f, -4.75780852e-02f, -2.87438184e-02f,
  5.19807152e-02f, -2.27382388e-02f, -3.83848213e-02f, -3.79991904e-02f, -8.00566226e-02f, -6.71214238e-02f, 6.72529265e-02f, 1.22139841e-01f, 3.95498350e-02f, -9.65111181e-02f,
  -4.59659062e-02f, 2.01621205e-01f, -3.63795087e-02f, -9.16885957e-02f, 2.27085501e-02f, -1.03457376e-01f, -3.96415591e-02f, -1.39276713e-01f, -7.04223365e-02f, 2.76717525e-02f,
  1.22593842e-01f, 1.97871439e-02f, 4.70321402e-02f, -4.65076230e-02f, -1.04919299e-01f, -1.43156014e-03f, -1.40085518e-01f, -7.88531974e-02f, 1.46987038e-02f, -8.55014324e-02f,
  -2.10667197e-02f, 8.06016251e-02f, 1.22332849e-01f, 6.20147921e-02f, 7.51418620e-02f, -4.47976179e-02f, 3.65355164e-02f, 7.39356875e-03f, -6.87526390e-02f, -7.19934255e-02f,
  -7.39388913e-02f, -1.18754769e-03f, 9.02130976e-02f, -4.47586514e-02f, 6.10538982e-02f, -3.74793150e-02f, -5.93489632e-02f, -2.26738174e-02f, -4.28717546e-02f, 2.43835021e-02f,
  -5.77800311e-02f, 2.74299886e-02f, -4.70763259e-02f, 2.34110951e-02f, 6.73664883e-02f, 1.53436009e-02f, 3.55098732e-02f, -2.70446446e-02f, 2.05992330e-02f, -3.86973321e-02f,
  -6.20974675e-02f, 3.52848917e-02f, -5.22437654e-02f, -2.18527727e-02f, -1.61079802e-02f, -3.83153781e-02f, 1.54750710e-02f, -2.63610668e-02f, 2.74236575e-02f, 3.27208266e-03f,
  -1.70055941e-01f, 7.31558576e-02f, -7.75403827e-02f, 1.82340236e-03f, 4.21048664e-02f, -2.52979837e-04f, 6.95539489e-02f, 5.85713936e-03f, 7.28378911e-03f, -7.86319301e-02f,
  -1.07848514e-02f, 4.68450114e-02f, 6.19984884e-03f, -2.79354621e-02f, -3.27446647e-02f, -8.80490318e-02f, -7.65166432e-02f, -5.90081066e-02f, 5.68896625e-03f, -6.76455870e-02f,
  2.00234745e-02f, 2.20074728e-02f, 2.10410282e-02f, -9.27882567e-02f, -7.23707601e-02f, -1.08963944e-01f, -5.75024337e-02f, -1.02276504e-01f, -2.77752522e-02f, -1.86443627e-01f,
  3.70341778e-01f, 1.11942075e-01f, 1.56634137e-01f, 9.07808989e-02f, 2.36419179e-02f, 9.14168730e-03f, -1.01808801e-01f, 4.49761860e-02f, -2.77816840e-02f, 1.86504889e-02f,
  -8.26721340e-02f, -6.21000379e-02f, -8.06083977e-02f, -4.76994477e-02f, -1.21538565e-02f, 1.57952726e-01f, 1.80991113e-01f, 4.14899029e-02f, -1.65512841e-02f, 5.96858114e-02f,
  1.41173303e-01f, 1.43797517e-01f, 1.98381722e-01f, 6.92692176e-02f, 1.48170412e-01f, -6.95584640e-02f, -4.92081791e-02f, 1.65930629e-01f, 4.59069200e-02f, 2.16246590e-01f,
  1.59362048e-01f, 8.35449994e-02f, -1.22128606e-01f, -7.53498152e-02f, -1.42957300e-01f, 9.94271692e-03f, -2.95747500e-02f, 6.90107718e-02f, -2.13054400e-02f, 7.15960115e-02f,
  4.42424491e-02f, 7.77259693e-02f, -9.14794877e-02f, 2.68047117e-02f, -3.07272952e-02f, -9.48481038e-02f, -2.76937019e-02f, 1.14948913e-01f, -7.95594528e-02f, -1.00991400e-02f,
  -3.38022746e-02f, 1.70429628e-02f, 7.86172375e-02f, -8.60720947e-02f, -2.61374973e-02f, -9.08656865e-02f, -6.04856201e-02f, -2.72616744e-02f, -2.50127297e-02f, 1.37210280e-01f,
  -1.04540966e-01f, 7.51727680e-03f, -4.08371538e-02f, 1.94269381e-02f, 7.05968067e-02f, 1.21185174e-02f, 1.18615320e-02f, -1.30983815e-02f, -1.48857385e-02f, -3.11443266e-02f,
  -2.82258559e-02f, 3.22342031e-02f, -4.76639271e-02f, -3.46596469e-03f, -5.95885841e-03f, 8.89620557e-02f, 8.62931740e-03f, 3.67122293e-02f, -7.88778812e-02f, -4.97153625e-02f,
  5.25982194e-02f, 1.34908501e-02f, -7.62047321e-02f, 1.92974806e-02f, -6.91295862e-02f, -2.29564048e-02f, 6.27494324e-03f, 5.59342131e-02f, -1.64673943e-02f, -4.93047014e-02f,
  -1.94429487e-01f, -3.85557413e-01f, -2.27624886e-02f, 3.31717208e-02f, 9.64028835e-02f, -1.17464632e-01f, -7.01306313e-02f, 9.00807604e-03f, -8.42449814e-02f, -1.16659869e-02f,
  -8.47634152e-02f, -8.43014866e-02f, -7.88109675e-02f, -2.97055440e-03f, 8.63566399e-02f, 2.89011747e-02f, -2.75988746e-02f, -2.05468549e-03f, -4.08786014e-02f, 8.00391361e-02f,
  -4.54244725e-02f, 5.21830916e-02f, -8.14791545e-02f, -8.37067515e-02f, -1.17463440e-01f, -3.93958502e-02f, -1.09779239e-01f, 9.19983350e-03f, -1.24187395e-01f, -1.38314934e-02f,
  -5.60124628e-02f, -1.29717559e-01f, -2.48889402e-01f, -6.12212121e-02f, -7.24079926e-03f, -7.38988072e-02f, -2.31881842e-01f, -9.30126011e-02f, 6.08627535e-02f, -8.89611468e-02f,
  -7.06124157e-02f, -8.00545663e-02f, -1.48642957e-01f, -1.22961082e-01f, -2.81476200e-01f, -2.75414556e-01f, -2.22241446e-01f, -2.58215368e-01f, -3.26363593e-01f, -1.59862012e-01f,
  2.63488502e-03f, -1.25829652e-01f, -1.72676727e-01f, -5.13902754e-02f, 7.67748579e-02f, -8.19497705e-02f, -1.01802453e-01f, -1.39590859e-01f, -5.31629100e-02f, -4.22355942e-02f,
  -1.54734716e-01f, -1.97958318e-03f, -7.97895864e-02f, -6.52120337e-02f, -2.20911968e-02f, 8.68710205e-02f, -1.10564129e-02f, -2.77694408e-02f, -4.09361757e-02f, -1.03301078e-01f,
  7.78880855e-03f, 8.51375386e-02f, -8.79719406e-02f, -7.77295455e-02f, -7.52677619e-02f, -4.98141907e-02f, -9.20164958e-02f, -1.73999533e-01f, -1.33511677e-01f, -7.22647309e-02f,
  6.13322631e-02f, -6.10215254e-02f, -1.65322185e-01f, -3.30934189e-02f, -4.39479388e-02f, 3.41802835e-02f, 4.87970486e-02f, 1.00048548e-02f, -6.22242764e-02f, 5.44810966e-02f,
  -1.23407954e-04f, -2.19836012e-02f, -2.81802155e-02f, 7.69942775e-02f, -6.27893060e-02f, 5.06355390e-02f, -6.16085753e-02f, 4.80951257e-02f, -7.25575089e-02f, -4.50725667e-02f,
  -4.98612002e-02f, -5.56644611e-02f, 8.35089013e-02f, -8.11333209e-02f, 2.72052102e-02f, -5.64009808e-02f, -8.35944712e-03f, -4.96021137e-02f, -6.87019676e-02f, -3.65642868e-02f,
  3.50490250e-02f, -4.46662009e-02f, -4.46759909e-02f, 4.88468409e-02f, -1.43896397e-02f, -5.91937266e-02f, 3.70510179e-03f, 2.10393071e-02f, 4.22273241e-02f, 1.26569930e-05f,
  -1.38762712e-01f, -7.51146898e-02f, -4.95091639e-02f, -1.06447257e-01f, 4.05570380e-02f, -3.54924910e-02f, 5.92948720e-02f, -5.75859323e-02f, 1.03699908e-01f, -8.00722986e-02f,
  -4.89911772e-02f, -2.75775585e-02f, -1.74365677e-02f, -6.71701282e-02f, -1.06888801e-01f, 1.58601832e-02f, -9.14577395e-02f, -7.20018847e-03f, -1.11170299e-01f, -4.95073199e-02f,
  -6.02604588e-03f, -2.00312212e-01f, -2.22387597e-01f, -8.48734453e-02f, -6.60653561e-02f, -5.21631949e-02f, -1.44309431e-01f, -2.37787738e-02f, -7.90657550e-02f, -6.41181543e-02f,
  6.49929717e-02f, -5.08051395e-01f, -3.39442492e-01f, -9.13657919e-02f, -2.02536538e-01f, -2.35956237e-01f, -4.72244084e-01f, -1.17950574e-01f, -4.80994880e-02f, -4.14091408e-01f,
  -2.31608450e-01f, 5.76852262e-02f, 1.07449792e-01f, 4.32657115e-02f, -2.11694948e-02f, -3.82407159e-01f, -2.34069929e-01f, 1.29275084e-01f, 3.01157027e-01f, -3.98767041e-03f,
  3.92427705e-02f, -6.00532927e-02f, 1.71332583e-01f, 1.81142129e-02f, -1.80813164e-01f, 3.55940983e-02f, -2.20192239e-01f, -1.65600494e-01f, -1.01150773e-01f, -3.19391608e-01f,
  -3.11790884e-01f, 7.71146491e-02f, 1.10740289e-01f, 7.97517672e-02f, -8.21357444e-02f, 1.06825158e-01f, -1.35079756e-01f, 1.16690882e-01f, 2.60115080e-02f, -7.47881755e-02f,
  -6.79279864e-02f, 5.00117503e-02f, 4.45732102e-02f, 5.62134422e-02f, -3.23815905e-02f, -3.52350846e-02f, -3.06976922e-02f, 1.01297021e-01f, 2.37844698e-02f, -8.30408260e-02f,
  -2.09422540e-02f, 2.53089909e-02f, 5.88280596e-02f, -4.79840897e-02f, 8.63353238e-02f, 7.11454898e-02f, -3.11537124e-02f, -4.74409424e-02f, -4.78856731e-03f, -2.66505063e-01f,
  -1.56875476e-01f, -4.02092561e-02f, 3.96065488e-02f, 3.76778543e-02f, -2.92571317e-02f, 1.56987384e-02f, -6.93768859e-02f, -4.30006124e-02f, 2.20367070e-02f, 2.28492301e-02f,
  2.78270915e-02f, -1.10358000e-01f, 1.97981521e-02f, 7.82411953e-04f, -3.42418738e-02f, -1.33308368e-02f, 3.20408889e-03f, -9.60850641e-02f, 3.14320234e-04f, 5.78288808e-02f,
  3.95808369e-03f, 1.33971097e-02f, -2.98303105e-02f, 7.20615685e-02f, -5.96640818e-02f, -8.97475034e-02f, 3.53923030e-02f, 5.36864065e-03f, 6.31749779e-02f, 3.40996124e-02f,
  -1.24420211e-01f, 1.82548240e-01f, -1.41932681e-01f, 1.61765411e-01f, -3.67980786e-02f, -4.25754115e-02f, -7.42749348e-02f, 2.13273112e-02f, 9.21963528e-02f, -6.22297311e-03f,
  8.22990239e-02f, 1.50869112e-03f, -8.35030004e-02f, -2.56816912e-02f, 7.84394369e-02f, 7.07004368e-02f, -1.25267014e-01f, -1.00869490e-02f, 2.94994805e-02f, -5.16552255e-02f,
  -1.61739811e-01f, -1.05870508e-01f, 4.59606163e-02f, -7.40389079e-02f, 1.06351592e-01f, 5.73360473e-02f, 1.09385960e-02f, -3.37084532e-02f, 1.02604628e-01f, -3.80830437e-01f,
  -1.72395006e-01f, 3.75239961e-02f, 2.91883033e-02f, 1.04138494e-01f, 1.94145709e-01f, 1.72578499e-01f, 7.58154243e-02f, 3.91287962e-03f, 1.39729649e-01f, 1.44089401e-01f,
  1.14353754e-01f, 1.49862111e-01f, 1.39347285e-01f, 5.03451228e-02f, 1.92805864e-02f, 1.32752089e-02f, 1.38966262e-01f, 5.24461679e-02f, -6.70929998e-02f, 2.52848249e-02f,
  3.19556370e-02f, 1.17516354e-01f, -8.91392156e-02f, 1.35351019e-02f, 2.46432573e-02f, 1.71872556e-01f, 9.44222957e-02f, 8.73149782e-02f, 2.05060523e-02f, 9.83898342e-02f,
  -5.48249334e-02f, -1.46859348e-01f, -4.90912097e-03f, 4.95200232e-02f, -1.02066375e-01f, 8.73716362e-03f, -7.54730031e-02f, -1.17975891e-01f, 4.42099087e-02f, 5.11257276e-02f,
  -6.19425289e-02f, -6.46256208e-02f, 4.37675789e-02f, 8.46113041e-02f, -8.81254002e-02f, -2.98888087e-02f, 2.49363445e-02f, 4.23773425e-03f, 4.67935242e-02f, 6.87710568e-02f,
  2.49393713e-02f, 4.44587916e-02f, -8.44486877e-02f, 4.88651171e-02f, 3.02424580e-02f, -6.44415198e-03f, -1.19191492e-02f, -3.82438414e-02f, -1.01836391e-01f, -5.90757206e-02f,
  -6.44485056e-02f, 4.56541181e-02f, -2.80615897e-03f, 1.01441495e-01f, -4.30654101e-02f, -2.39315126e-02f, 1.14869945e-01f, -3.49160773e-03f, 3.39408554e-02f, -4.67644669e-02f,
  -2.11019684e-02f, -4.87779751e-02f, 9.81244296e-02f, 1.07242718e-01f, 5.37259132e-02f, -5.81469722e-02f, -1.85322016e-02f, 7.05523267e-02f, 1.03757586e-02f, 1.52194183e-02f,
  6.08030893e-02f, 9.55865681e-02f, -5.48405573e-02f, -3.52008007e-02f, -5.31763993e-02f, 7.67459124e-02f, -6.45527989e-02f, -2.48527657e-02f, -6.09509908e-02f, -9.24283117e-02f,
  1.80602267e-01f, -1.42751439e-02f, -1.45772398e-02f, 7.53966495e-02f, -8.44692811e-02f, -6.13996126e-02f, 8.87248013e-03f, -2.22340934e-02f, -3.77277732e-02f, 4.08285446e-02f,
  1.69451497e-02f, -1.30962878e-01f, -5.67666208e-03f, -4.99531999e-02f, -2.57656071e-02f, 1.90298762e-02f, -7.33005852e-02f, 8.80998969e-02f, -5.74311130e-02f, 5.85595332e-02f,
  -2.12583095e-02f, 3.30451014e-03f, 9.00205523e-02f, 1.06621653e-01f, -3.91731486e-02f, 1.23453788e-01f, -4.73366538e-03f, 5.78849539e-02f, -4.47127745e-02f, -1.97376795e-02f,
  3.67098391e-01f, -6.79892600e-02f, -1.22941747e-01f, 2.12059289e-01f, 1.02769271e-01f, 2.02845916e-01f, 2.08456382e-01f, 1.39001161e-01f, 1.90393284e-01f, 9.20086503e-02f,
  -1.68370381e-01f, -9.78422165e-02f, -9.64479968e-02f, -1.89171106e-01f, -6.13827109e-02f, 9.51120528e-05f, 2.54456345e-02f, -7.06488565e-02f, 9.07902233e-03f, 5.36878109e-02f,
  5.60421981e-02f, 7.17697144e-02f, 7.80737847e-02f, 5.10831177e-02f, -9.72948298e-02f, -8.39035138e-02f, -1.42534047e-01f, 1.25075765e-02f, -1.75893441e-01f, -1.18579254e-01f,
  -2.70816535e-01f, -3.62373032e-02f, 1.02119774e-01f, -6.78039044e-02f, -1.25902206e-01f, -3.07488870e-02f, -2.18665749e-02f, 4.10744213e-02f, -5.02147421e-04f, -7.78072374e-03f,
  -3.01519735e-03f, 2.12814938e-02f, -1.52494147e-01f, -1.24777034e-01f, 9.80161130e-02f, -7.27118552e-02f, -3.83543521e-02f, -9.19843614e-02f, -1.44748941e-01f, -2.04420723e-02f,
  -8.67390186e-02f, -3.82963978e-02f, 4.60377075e-02f, -8.35490376e-02f, -2.88473554e-02f, -5.02434820e-02f, -1.65418118e-01f, -8.29890072e-02f, -3.20599228e-02f, -9.15856846e-03f,
  4.05413434e-02f, -6.10529259e-02f, -6.14689440e-02f, 3.31570394e-02f, 2.30194349e-02f, -1.99465863e-02f, 7.60361403e-02f, -2.79339105e-02f, -6.29146546e-02f, 7.78240040e-02f,
  -3.59995775e-02f, -1.81249138e-02f, 6.17236039e-03f, -2.85322126e-02f, -8.43246952e-02f, -5.19755892e-02f, -3.25951912e-02f, -6.29138201e-02f, -4.20227908e-02f, 4.78047356e-02f,
  -6.14833608e-02f, -1.85224805e-02f, 1.78488437e-02f, -3.50638367e-02f, -8.01998451e-02f, -7.47226179e-02f, -3.88979539e-02f, 6.81004953e-03f, -1.56116942e-02f, 9.07321200e-02f,
  1.51882455e-01f, -8.33819732e-02f, 7.07215071e-02f, -2.36823913e-02f, -1.13924786e-01f, -2.08091792e-02f, -7.29451925e-02f, -1.42255425e-01f, -1.05831273e-01f, -6.99844882e-02f,
  -4.31705676e-02f, -9.46988165e-02f, 1.01998420e-02f, 1.15022073e-02f, 1.18325002e-01f, 7.92313889e-02f, 7.02943504e-02f, -3.64688371e-04f, -1.87689550e-02f, -8.05077404e-02f,
  -2.69115046e-02f, 2.06868589e-01f, 1.17079198e-01f, 1.04942642e-01f, 3.46294716e-02f, 1.88358679e-01f, 9.10499394e-02f, 1.09046325e-01f, 1.46659762e-01f, 3.07187140e-01f,
  -1.00187153e-01f, -1.74293876e-01f, 1.53655842e-01f, 5.46381399e-02f, 7.77326117e-04f, -2.97502689e-02f, 4.73260246e-02f, 3.24574150e-02f, -1.27590392e-02f, -9.67667028e-02f,
  -7.14446157e-02f, -1.22223444e-01f, -6.36043400e-02f, -1.55803159e-01f, -1.47021189e-01f, -7.54868239e-02f, -6.91284761e-02f, 9.48784407e-03f, 8.59928653e-02f, -6.53029084e-02f,
  -3.17319413e-03f, -7.34931827e-02f, -3.37249339e-02f, 4.80881520e-02f, 4.12172340e-02f, 1.64540182e-03f, 1.33691013e-01f, 9.81642380e-02f, -9.73211378e-02f, -1.95611101e-02f,
  4.57349047e-02f, -1.01620369e-01f, 3.75964753e-02f, -1.23879358e-01f, 4.89757843e-02f, -8.01082607e-03f, 8.94510187e-03f, 4.06372547e-02f, -8.03718343e-02f, 6.89817593e-03f,
  2.67683528e-02f, -7.76752084e-02f, 5.56992553e-02f, 5.49224056e-02f, -3.67572010e-02f, 3.66425924e-02f, 2.89463568e-02f, 3.44923697e-02f, -7.30761215e-02f, 3.08687822e-03f,
  -1.37884364e-01f, -2.98686698e-02f, -5.64550869e-02f, 6.69253394e-02f, 1.13858646e-02f, -6.54310286e-02f, -6.79104123e-03f, 5.12183830e-02f, 7.62004629e-02f, 8.17335248e-02f,
  4.77556000e-03f, -5.28057143e-02f, 2.86992844e-02f, -5.63118942e-02f, 1.12797040e-02f, 7.71571472e-02f, 2.51588393e-02f, -3.26319374e-02f, -2.78802607e-02f, -2.21473221e-02f,
  6.61323071e-02f, -4.38284725e-02f, 1.16902038e-01f, -1.76690947e-02f, 4.65516225e-02f, 5.40329330e-02f, -6.96361214e-02f, 2.34703603e-03f, 3.78043838e-02f, 4.03253548e-02f,
  1.91914793e-02f, 4.48672324e-02f, -3.89661528e-02f, 9.70826447e-02f, 5.58480397e-02f, 3.94855775e-02f, 7.07806870e-02f, 4.23551388e-02f, -7.64170885e-02f, 2.37645097e-02f,
  1.63604185e-01f, -8.64248127e-02f, 9.43740159e-02f, -2.45891474e-02f, 1.12072088e-01f, -3.95307541e-02f, -4.29857261e-02f, 6.37238994e-02f, 5.59595749e-02f, 9.31555778e-02f,
  -1.93649381e-02f, -3.04480679e-02f, 5.39549962e-02f, -5.44035472e-02f, 8.74331668e-02f, 1.38937903e-03f, -1.17234334e-01f, -7.73493126e-02f, -4.44836207e-02f, 3.01701985e-02f,
  -1.04541048e-01f, 9.16521996e-02f, 2.04518810e-02f, 5.78658357e-02f, 4.58165370e-02f, -6.12798147e-02f, 2.10815538e-02f, 9.02455449e-02f, -3.03883590e-02f, 1.92998990e-01f,
  3.38364169e-02f, 4.02681082e-02f, 1.69389784e-01f, -7.64071941e-02f, -2.24019527e-01f, -1.39714777e-01f, -2.49060139e-01f, -9.93567985e-03f, 4.20415401e-02f, -1.33566290e-01f,
  -1.55363485e-01f, -1.44066110e-01f, -1.33853164e-02f, 2.76467353e-02f, 1.70141846e-01f, 7.83369988e-02f, 1.16792426e-01f, 1.59867197e-01f, 9.73442718e-02f, -5.15767261e-02f,
  -1.16820753e-01f, 2.34727412e-02f, 2.21315220e-01f, 1.62813634e-01f, 4.26923670e-02f, -2.15811357e-02f, 9.74372551e-02f, -7.80434639e-05f, 4.31374945e-02f, 2.24308465e-02f,
  -3.10965888e-02f, -4.27828766e-02f, 7.57039413e-02f, -7.82634914e-02f, -3.42606311e-03f, 1.02502361e-01f, -4.22739983e-02f, 5.36436662e-02f, -1.99233964e-02f, 1.70691013e-02f,
  -1.50146196e-02f, 1.73924677e-02f, -2.87329443e-02f, -5.24698943e-02f, -1.87418479e-02f, 5.35683110e-02f, 1.42845213e-01f, 2.38153860e-01f, 3.90236713e-02f, -7.17477649e-02f,
  -1.21736839e-01f, -1.63448021e-01f, -4.37376946e-02f, 1.20391306e-02f, 5.57509512e-02f, -1.36489524e-02f, -9.65483021e-03f, -3.03163510e-02f, 1.74099907e-01f, 1.18513620e-02f,
  -6.47973720e-05f, 8.99274275e-02f, -7.25685619e-04f, 3.53313028e-03f, -6.07260913e-02f, 3.03066638e-03f, -5.68356961e-02f, -6.23211414e-02f, -5.47202975e-02f, -5.44562005e-02f,
  -1.29073206e-02f, 5.27777225e-02f, -1.08334580e-02f, 7.96169192e-02f, 5.66281602e-02f, 3.29424813e-02f, 7.90639445e-02f, -2.14822367e-02f, 1.16455182e-02f, -3.62666324e-02f,
  -2.44368333e-03f, -4.16905852e-03f, 2.59563997e-02f, -2.26068683e-02f, 3.03224381e-02f, 7.82395713e-03f, -6.91086575e-02f, -2.07453892e-02f, -2.89807916e-02f, -8.01141709e-02f,
  -1.02035552e-01f, -6.15733787e-02f, 5.11598587e-02f, -3.74485366e-02f, 4.08191681e-02f, 6.44264137e-03f, -2.13512406e-02f, 8.28097239e-02f, -1.66766699e-02f, -5.78914173e-02f,
  -8.99494216e-02f, -7.41273835e-02f, -9.37609449e-02f, 6.22430891e-02f, -7.02978671e-02f, 3.62606198e-02f, 1.65074524e-02f, -7.28557184e-02f, -5.41563379e-03f, 1.07477065e-02f,
  -4.92176004e-02f, -8.84488672e-02f, -1.10790186e-01f, 5.92170209e-02f, -6.86160251e-02f, -1.44233361e-01f, 4.27028500e-02f, -5.82569242e-02f, -7.02781156e-02f, -7.48320371e-02f,
  1.96434990e-01f, 1.23205282e-01f, -1.99480593e-01f, 5.07688336e-02f, -2.57351905e-01f, -3.03723454e-01f, -1.32664174e-01f, -9.73989367e-02f, 5.17467894e-02f, 7.52334967e-02f,
  -1.29211441e-01f, -6.21458665e-02f, 4.77986075e-02f, -9.97175723e-02f, -5.11105806e-02f, -6.26192167e-02f, 4.21918072e-02f, -1.00336820e-01f, -2.92049408e-01f, -2.69701481e-01f,
  -1.92129642e-01f, 9.69563611e-03f, -1.60546303e-02f, -2.35884748e-02f, 9.09281243e-03f, -3.91574875e-02f, 4.42844862e-03f, -7.89405778e-02f, -1.25837803e-01f, -5.97638451e-02f,
  -7.43052438e-02f, -1.63159698e-01f, -1.31892547e-01f, -1.13283815e-02f, 3.67546901e-02f, 1.59616419e-03f, 2.42412258e-02f, -8.18937272e-03f, 1.04585700e-01f, 7.37585351e-02f,
  2.88780965e-02f, -4.06693071e-02f, -1.32683329e-02f, -5.56155704e-02f, 2.67651472e-02f, 4.41162288e-03f, -3.84859368e-02f, -8.71249586e-02f, -9.46445540e-02f, 2.01488826e-02f,
  -9.12934840e-02f, -1.57724008e-01f, 3.00716553e-02f, -1.28952106e-02f, 2.98124272e-03f, -1.33338466e-01f, 1.64262727e-02f, -1.21651657e-01f, -9.65338871e-02f, 9.38702747e-02f,
  -6.26420826e-02f, -3.70847918e-02f, 8.78914725e-03f, -4.26522503e-03f, 3.56143788e-02f, 3.40506323e-02f, 1.67186148e-02f, -1.37955043e-03f, -2.26131883e-02f, 1.04475833e-01f,
  -2.31897794e-02f, -1.57603677e-02f, 4.51694205e-02f, 5.13055222e-03f, 4.18362841e-02f, 5.31119592e-02f, -4.93824407e-02f, 1.00570796e-02f, -1.63135584e-02f, -4.13607284e-02f,
  6.26325682e-02f, 1.59219070e-03f, 4.96943146e-02f, 6.03259280e-02f, -4.54688221e-02f, 1.65538583e-02f, 4.56895791e-02f, -1.00085370e-01f, 1.97368185e-03f, 4.50846329e-02f,
  2.97154099e-01f, 1.13550611e-02f, 3.51246931e-02f, 4.58317623e-02f, 4.56157178e-02f, -2.19590627e-02f, 9.06472951e-02f, 6.60739839e-02f, 3.23026404e-02f, 5.23367375e-02f,
  -5.37190959e-02f, 2.26395801e-02f, 3.23546976e-02f, -6.13634512e-02f, -4.73100580e-02f, -9.67907235e-02f, 1.82742849e-01f, -1.35227591e-02f, -5.38987070e-02f, -5.75190075e-02f,
  1.19636200e-01f, 3.61804292e-02f, 1.60425082e-01f, 1.18969932e-01f, 7.26795644e-02f, -4.96599488e-02f, 9.88364592e-02f, 1.10551566e-01f, 5.71042635e-02f, 2.16996998e-01f,
  4.28211629e-01f, 2.81173140e-01f, 6.65103272e-02f, 1.11327030e-01f, 1.64565220e-01f, 8.29919875e-02f, -5.87581657e-03f, -1.03207342e-01f, -9.42593142e-02f, 1.51241332e-01f,
  2.92081475e-01f, 1.23591729e-01f, 2.57965289e-02f, -1.68568585e-02f, -1.45113274e-01f, -1.46316946e-01f, -1.12919226e-01f, -6.35863468e-03f, 1.18210784e-03f, 7.52833635e-02f,
  8.94632265e-02f, 1.52743474e-01f, 6.61878139e-02f, -3.71791646e-02f, 9.03724805e-02f, -3.38462181e-02f, -3.87661741e-04f, 1.74063787e-01f, 2.07568422e-01f, 1.87154606e-01f,
  2.25558385e-01f, 2.92675972e-01f, -2.43301943e-01f, 4.46214452e-02f, 1.61804184e-01f, -8.20917357e-03f, -2.61501428e-02f, -7.05711693e-02f, -6.46166354e-02f, -6.73632547e-02f,
  4.53058295e-02f, 4.85265553e-02f, 3.87469269e-02f, 5.27595393e-02f, 9.46857929e-02f, -4.23653275e-02f, -1.03394350e-03f, -1.17338695e-01f, -1.65179342e-01f, 9.69143808e-02f,
  1.21882662e-01f, 2.47908801e-01f, 9.47416574e-02f, -1.18733510e-01f, -6.41459897e-02f, 3.95053141e-02f, -3.60249467e-02f, 1.12991389e-02f, -1.17591277e-01f, -5.55207469e-02f,
  -3.44731845e-02f, 9.94033143e-02f, -3.56524736e-02f, -1.26955882e-02f, -1.41611574e-02f, 4.68644723e-02f, 5.61087802e-02f, 7.45655447e-02f, -2.63927057e-02f, 5.75136999e-03f,
  2.97189318e-02f, 5.48191890e-02f, -7.12564960e-02f, 2.89342888e-02f, -4.61462177e-02f, 5.20400628e-02f, 4.01965231e-02f, -7.76828593e-03f, -2.54769884e-02f, 8.59663263e-02f,
  6.45258650e-02f, 4.10163164e-04f, 7.99442306e-02f, 1.62642170e-02f, -6.39257431e-02f, 1.05960652e-01f, 2.90437266e-02f, 5.94087839e-02f, 7.73612468e-04f, -4.59508784e-03f,
  -1.04821205e-01f, -8.65960047e-02f, 3.00023914e-03f, -1.37786537e-01f, 5.22749722e-02f, -5.83420210e-02f, 8.27813298e-02f, -2.91989073e-02f, 6.60287514e-02f, -1.96861327e-02f,
  9.13586542e-02f, 3.72068142e-04f, -1.90581344e-02f, -3.63851637e-02f, -6.85029402e-02f, -5.44225015e-02f, 6.11926615e-02f, 1.89235806e-02f, -1.09175920e-01f, 6.91243708e-02f,
  -2.20508296e-02f, -1.81130156e-01f, -1.44066319e-01f, -1.11417361e-01f, -6.28616735e-02f, -6.92146942e-02f, 4.98185959e-03f, -7.67877847e-02f, -1.32839710e-01f, -1.91373199e-01f,
  1.62595034e-01f, 7.07510561e-02f, 7.01970384e-02f, -2.71326676e-02f, -1.43849239e-01f, 5.38936816e-02f, 1.56395696e-02f, 3.25898528e-02f, -3.10233198e-02f, -4.28823605e-02f,
  -6.08229786e-02f, -8.59317705e-02f, -2.08372027e-02f, -3.08569018e-02f, -1.15506863e-03f, -3.34801562e-02f, 1.05574735e-01f, 5.40661849e-02f, 9.65095907e-02f, -5.42534282e-03f,
  -5.78461401e-02f, 8.66643786e-02f, 1.37074530e-01f, 1.07848473e-01f, -1.21315181e-01f, -2.84829848e-02f, 4.46622260e-02f, -1.59625709e-02f, -9.83849764e-02f, -9.08968598e-02f,
  -2.01797068e-01f, 2.95353029e-02f, -2.77494583e-02f, -1.27339019e-02f, -4.58881706e-02f, 1.14039995e-01f, 7.51370117e-02f, 1.07876034e-02f, -2.85477694e-02f, -8.14044997e-02f,
  4.41158563e-03f, -4.78283763e-02f, -7.86691457e-02f, -4.16942053e-02f, -1.26381069e-01f, -9.46142003e-02f, -1.34163052e-02f, 6.31724223e-02f, -2.74337996e-02f, 2.07057409e-02f,
  -3.69270258e-02f, 2.05605589e-02f, 2.93465294e-02f, 6.68585524e-02f, -2.33899895e-02f, -2.80965026e-02f, -1.06324054e-01f, -1.03953920e-01f, 8.08823407e-02f, 8.17597583e-02f,
  5.94288185e-02f, 1.41985286e-02f, -4.01848331e-02f, 1.35934958e-02f, 6.90135956e-02f, -4.79821451e-02f, 5.93179911e-02f, -8.93617719e-02f, -9.64005291e-02f, -2.56448109e-02f,
  4.98645902e-02f, -9.97035503e-02f, -5.80762364e-02f, -1.99052561e-02f, 6.26067743e-02f, -6.19710870e-02f, -3.84352468e-02f, -2.87727490e-02f, 1.29565010e-02f, -5.28258346e-02f,
  -6.83678761e-02f, -9.23418161e-03f, -7.57408738e-02f, 3.32330838e-02f, 3.62786502e-02f, 1.77313313e-02f, -9.11107957e-02f, -6.36736676e-02f, 8.01952556e-02f, -4.09131460e-02f,
  -6.26998767e-02f, 3.43660079e-02f, -1.58780941e-03f, 7.77973533e-02f, 4.30517085e-02f, -3.53899673e-02f, 2.09858865e-02f, 8.06113631e-02f, -6.97908737e-03f, 4.42648157e-02f,
  -7.54045323e-02f, 1.29521498e-02f, -9.62647945e-02f, 1.58462655e-02f, -1.67304091e-02f, 5.25439195e-02f, 7.34685361e-02f, -9.04853493e-02f, -4.78805378e-02f, -1.02936523e-02f,
  -8.53439942e-02f, 9.30438042e-02f, 1.14038080e-01f, 3.75637226e-02f, 2.34130267e-02f, 9.77257416e-02f, 1.36910956e-02f, -5.23356944e-02f, 2.61769537e-02f, 6.71335533e-02f,
  2.00059682e-01f, -1.94920987e-01f, -4.16350394e-01f, 1.39597356e-01f, -1.32516995e-01f, -1.46441549e-01f, -1.66803092e-01f, -2.13839989e-02f, 8.41977373e-02f, -1.27634376e-01f,
  -3.08702867e-02f, -1.14167042e-01f, -7.30229169e-02f, -1.41871646e-01f, 2.49043927e-02f, -2.51121461e-01f, -8.01559091e-02f, -1.71054333e-01f, 5.69831431e-02f, 1.17313378e-01f,
  1.59979522e-01f, 1.34236962e-01f, 7.05836192e-02f, 1.07558638e-01f, -7.59944394e-02f, -5.29706180e-02f, -3.72380279e-02f, -1.31878391e-01f, -1.43654794e-01f, -2.44871184e-01f,
  -3.71830136e-01f, -1.70246005e-01f, 8.22015628e-02f, -7.09487218e-03f, -8.54915380e-02f, 3.27041149e-02f, -1.28033832e-01f, -3.65526080e-02f, -8.38250890e-02f, -1.19341873e-01f,
  -1.62411723e-02f, 6.92178458e-02f, -7.86069855e-02f, -1.63609069e-02f, 4.93966825e-02f, -7.18131736e-02f, -1.99123323e-02f, -8.06055441e-02f, 3.86446044e-02f, -1.12167493e-01f,
  -3.49151455e-02f, -3.64330076e-02f, -1.58762783e-01f, -2.06842236e-02f, -5.75549975e-02f, -1.41759351e-01f, -1.39183745e-01f, -2.54846681e-02f, -4.14428897e-02f, 8.60145092e-02f,
  5.97044751e-02f, 6.30089256e-04f, 4.11337800e-02f, 4.63304780e-02f, 8.93665552e-02f, -2.52256449e-02f, 3.37954387e-02f, -3.54638621e-02f, -1.17273927e-02f, 5.85235208e-02f,
  -7.28725130e-03f, -5.93576804e-02f, 5.97086623e-02f, -6.22503050e-02f, -6.47458434e-02f, -5.20848110e-02f, 4.54962291e-02f, -1.91155244e-02f, 3.42026763e-02f, -4.05299403e-02f,
  -1.69205759e-02f, -4.84677814e-02f, 3.45552973e-02f, -5.27096912e-02f, -3.63368839e-02f, -1.51771195e-02f, -7.56646022e-02f, -7.55245090e-02f, 1.37744956e-02f, -3.11869923e-02f,
  1.88555017e-01f, -7.79099837e-02f, -2.54180632e-03f, -5.92332073e-02f, -2.52283681e-02f, 6.34894669e-02f, 6.55412396e-06f, -2.72699520e-02f, -5.71188293e-02f, -7.14205876e-02f,
  -7.84966499e-02f, 8.77395086e-03f, -8.77439529e-02f, -2.37645339e-02f, 4.22062352e-02f, -1.30436094e-02f, 1.31482825e-01f, -9.47153866e-02f, -1.74539704e-02f, 7.56589770e-02f,
  1.67477444e-01f, 1.08182758e-01f, 7.28980405e-03f, 1.71535630e-02f, -4.05774824e-02f, -3.07003800e-02f, -1.43294722e-01f, -6.83179684e-03f, -9.00377184e-02f, 2.20469266e-01f,
  2.66048163e-01f, -2.93748170e-01f, 2.51776844e-01f, 7.25370198e-02f, 2.41184488e-01f, 1.52634218e-01f, 6.06351085e-02f, 4.41933237e-02f, 7.08526671e-02f, -4.76013720e-02f,
  -8.31122026e-02f, -9.02458578e-02f, -4.20475379e-02f, -1.29977822e-01f, 1.45564014e-02f, -2.86447443e-02f, 1.03608251e-01f, 1.54427916e-01f, 1.82964250e-01f, 1.29769221e-01f,
  -5.07675447e-02f, -5.49973920e-02f, 9.52451602e-02f, -4.97059431e-03f, -6.39138594e-02f, -3.32971737e-02f, 1.99647695e-02f, -8.17226022e-02f, -3.00641567e-03f, -7.99932554e-02f,
  -1.28737301e-01f, -7.77102709e-02f, 8.10019672e-02f, -1.41479418e-01f, -6.28713965e-02f, -8.08997974e-02f, 1.58402137e-02f, -5.57270348e-02f, 4.29589078e-02f, -1.47327287e-02f,
  -6.74100146e-02f, -8.46862048e-03f, 4.86639626e-02f, -4.41581160e-02f, 7.10098669e-02f, 7.51374885e-02f, -1.13923900e-01f, -7.25656971e-02f, -9.25379768e-02f, -2.55546402e-02f,
  -1.62756756e-01f, 4.38220166e-02f, 1.69626251e-01f, 8.64806771e-02f, 1.02028456e-02f, 6.97224122e-03f, -6.60514757e-02f, -6.77300170e-02f, -3.61574776e-02f, -5.90722589e-03f,
  -3.34620997e-02f, 4.49343026e-02f, 2.01935973e-02f, 1.25135519e-02f, -1.98105611e-02f, 4.36069667e-02f, 8.36266130e-02f, 4.34659347e-02f, -6.65891217e-03f, 3.60212065e-02f,
  3.41098532e-02f, -1.38598960e-02f, 6.22912869e-02f, 6.08069524e-02f, 5.59199043e-02f, 2.14455575e-02f, -4.32901680e-02f, 2.04852317e-02f, 3.66736576e-02f, -1.12327468e-02f,
  -2.09054863e-03f, -3.02136838e-02f, 4.27253656e-02f, -4.93291430e-02f, 5.19573838e-02f, 8.74776393e-02f, -2.95588225e-02f, -3.16702724e-02f, 6.12811744e-02f, -4.08635587e-02f,
  -1.24217525e-01f, 1.69826955e-01f, -1.26408413e-02f, 4.04498689e-02f, 7.62337372e-02f, -7.69349635e-02f, -1.79460160e-02f, -3.42273749e-02f, -9.41201374e-02f, 2.56266799e-02f,
  -1.03802256e-01f, 6.52919849e-03f, -5.35866134e-02f, -8.76697153e-02f, 1.77633956e-01f, 4.08774940e-05f, -4.91361544e-02f, 1.10731527e-01f, 3.00331376e-02f, -9.59462151e-02f,
  -1.32732913e-01f, 1.19531348e-01f, 1.26444027e-01f, 1.31265596e-01f, 2.20684409e-02f, 2.45953351e-01f, 2.74625868e-02f, 1.09849907e-01f, 1.62399739e-01f, -4.94660288e-02f,
  1.84106544e-01f, 1.83644295e-01f, -2.83742338e-01f, 6.30728900e-02f, -1.55053720e-01f, -1.80023968e-01f, -1.52211087e-02f, 1.00056119e-01f, 1.23544298e-01f, 3.71671095e-02f,
  6.79698735e-02f, 2.04058904e-02f, -1.01293772e-01f, -4.81147878e-02f, -4.34861593e-02f, 4.50969301e-02f, -1.05384462e-01f, -2.51267165e-01f, -2.00939685e-01f, -1.09970309e-01f,
  1.19019032e-01f, 1.51076496e-01f, -3.29722720e-03f, -1.59842649e-03f, 6.88058063e-02f, -2.82079447e-03f, 5.91695011e-02f, -7.32179806e-02f, -1.39148999e-02f, -1.26479104e-01f,
  -4.25613709e-02f, -1.35331973e-01f, -1.56588182e-01f, 2.45275116e-03f, -8.15739706e-02f, 6.78818971e-02f, -4.73099761e-02f, -1.41546562e-01f, -1.01906657e-01f, -4.30627763e-02f,
  -1.51647776e-01f, -1.01007633e-01f, -8.13617185e-02f, -7.37087503e-02f, -6.03212453e-02f, -9.80182085e-03f, 8.92981961e-02f, -1.52269438e-01f, -1.38998941e-01f, 3.80906276e-02f,
  9.45533738e-02f, -3.06255948e-02f, -1.40814245e-01f, -6.61815703e-02f, -5.44418693e-02f, -3.87120098e-02f, -3.68049517e-02f, -1.80391420e-03f, -6.78315684e-02f, 1.33727929e-02f,
  -9.48795211e-03f, -8.39210227e-02f, -7.13721439e-02f, 7.04892725e-02f, 1.97611819e-03f, -6.74551353e-02f, 4.81444923e-03f, -2.66327858e-02f, 2.41404399e-02f, 7.22127110e-02f,
  -1.70063730e-02f, -3.78139429e-02f, -1.99020002e-02f, 6.61971346e-02f, 5.68241626e-02f, -1.11096106e-01f, 2.37871930e-02f, 1.17812142e-01f, 8.17268714e-02f, -3.91848981e-02f,
  -8.66463110e-02f, -4.22421377e-03f, 3.33714634e-02f, -7.68678123e-03f, -6.60890806e-03f, -1.74364191e-03f, -3.75580005e-02f, 2.43916605e-02f, -4.09655198e-02f, -5.11853322e-02f,
  3.00991118e-01f, -1.36998087e-01f, 3.70841920e-02f, 2.25629881e-02f, -1.12335637e-01f, -7.67450733e-03f, 7.27174059e-02f, 2.06443537e-02f, -3.67595851e-02f, -5.95882311e-02f,
  -9.27962884e-02f, -5.87574467e-02f, -4.31780852e-02f, -3.14768329e-02f, 1.68506373e-02f, 6.84404373e-02f, 1.66313007e-01f, 2.26320922e-02f, -4.87736077e-04f, -2.02859323e-02f,
  6.78866804e-02f, 4.67171557e-02f, 5.31019829e-02f, 8.25315639e-02f, -7.53387362e-02f, -3.70518826e-02f, 4.25722301e-02f, -8.28833356e-02f, -7.94050768e-02f, 2.40987331e-01f,
  6.60844818e-02f, -9.95246321e-02f, -2.78836012e-01f, -7.15099499e-02f, -6.10138401e-02f, -6.21557944e-02f, 6.20640777e-02f, -3.27840112e-02f, 3.23688351e-02f, -1.26969084e-01f,
  -5.16632609e-02f, 7.99257904e-02f, -1.22971326e-01f, 1.69058070e-02f, 8.54379907e-02f, -6.32756501e-02f, -1.50195524e-01f, -5.79674542e-02f, 6.78578392e-02f, 5.83794713e-02f,
  8.00402537e-02f, 1.33125512e-02f, -1.67190109e-03f, -1.24747656e-01f, -2.04263061e-01f, -1.12187706e-01f, -2.46348679e-01f, -3.17989327e-02f, -1.73818186e-01f, -1.85639098e-01f,
  -1.85994819e-01f, -7.55709484e-02f, 5.25227450e-02f, 1.16789967e-01f, -3.23476410e-03f, -4.05855067e-02f, -4.57983948e-02f, 1.42577672e-02f, 5.53609617e-02f, -5.62193878e-02f,
  2.36292966e-02f, -8.70602019e-03f, 8.20955560e-02f, 6.77299351e-02f, 3.19556780e-02f, 8.80332142e-02f, -3.80332097e-02f, -7.46243354e-03f, -5.38039729e-02f, -9.06021893e-02f,
  -3.34784039e-03f, -4.30236850e-03f, 5.90465106e-02f, 1.09220482e-02f, 6.33549541e-02f, 9.91122127e-02f, -4.03707102e-02f, -4.38177846e-02f, -2.16244962e-02f, 1.38058718e-02f,
  6.45758361e-02f, 2.72658262e-02f, -7.41641298e-02f, -4.78503369e-02f, -1.03525734e-02f, -1.34858489e-02f, -5.34476293e-03f, 8.92957151e-02f, 7.10544586e-02f, 5.35368919e-02f,
  -7.29011595e-02f, 3.77377756e-02f, 2.98297983e-02f, 1.68513451e-02f, -6.48396611e-02f, -4.34706286e-02f, -5.40326834e-02f, -5.11596948e-02f, -1.91357732e-02f, -2.06417963e-02f,
  7.66470283e-02f, 4.13270816e-02f, -1.15901291e-01f, -2.95145549e-02f, -5.50030768e-02f, -6.27146438e-02f, -9.45754722e-02f, 1.00765182e-02f, 4.27406058e-02f, 4.57549281e-02f,
  -4.06724587e-02f, -1.29384594e-03f, 8.80158693e-02f, 4.90272678e-02f, -1.30724505e-01f, 7.52948076e-02f, 4.03381065e-02f, -1.86040308e-02f, 1.33889038e-02f, 7.27554560e-02f,
  -7.66734853e-02f, 3.40878777e-02f, 5.60073107e-02f, -2.33733673e-02f, 9.18060914e-02f, 1.43298268e-01f, 7.39714317e-03f, -4.13837843e-02f, -1.26859108e-02f, -8.15581381e-02f,
  1.93275046e-02f, 8.84773657e-02f, 1.01203866e-01f, 7.53489137e-02f, 2.39076484e-02f, 1.54633783e-02f, 7.95863867e-02f, 1.11176334e-01f, 6.35427088e-02f, 1.38090774e-01f,
  -2.95686990e-01f, -2.83077180e-01f, -1.57175913e-01f, -4.02441680e-01f, -1.64364744e-02f, 1.45373866e-01f, 1.11559182e-01f, 1.08595170e-01f, -5.15523329e-02f, -1.72733530e-01f,
  1.98396435e-03f, -6.14013895e-02f, -2.10370466e-01f, -5.52563444e-02f, 7.52159208e-02f, -1.36846006e-01f, -1.49696246e-01f, -3.76188220e-03f, 1.30282640e-01f, 1.09340355e-01f,
  7.08687380e-02f, -1.46651506e-01f, -1.68277457e-01f, 1.05685024e-02f, -1.19327858e-01f, -9.92068797e-02f, -2.70767927e-01f, -8.92144367e-02f, 9.49956924e-02f, -1.27671972e-01f,
  -2.43520349e-01f, -3.67696136e-02f, 1.55650854e-01f, -2.77116038e-02f, -1.72014534e-02f, -3.52598284e-03f, 8.40825960e-02f, -3.18036228e-02f, 2.65171900e-02f, 1.98039301e-02f,
  -2.60104761e-02f, 6.71884418e-02f, -3.82430218e-02f, 2.90212967e-02f, 5.44995964e-02f, 4.93861139e-02f, -3.87452319e-02f, -7.64575377e-02f, -1.26777589e-02f, 2.19448898e-02f,
  2.48787124e-02f, 8.82304534e-02f, -9.06223059e-02f, 3.73723619e-02f, 1.40381232e-02f, 2.53875013e-02f, 4.28164192e-02f, 3.08779022e-03f, -2.80874819e-02f, -5.11856899e-02f,
  3.91219743e-02f, -5.41515723e-02f, 8.41403753e-02f, 4.31903265e-03f, -2.09597461e-02f, -5.88998087e-02f, -7.27087185e-02f, 3.42578478e-02f, 3.22206169e-02f, -7.74846375e-02f,
  1.86188221e-02f, -8.46381299e-03f, -4.45769727e-02f, -5.19751534e-02f, -8.66079032e-02f, 8.46404955e-03f, 4.53424789e-02f, 6.64454252e-02f, -8.00732430e-03f, 2.79286001e-02f,
  7.46887270e-03f, -2.24931575e-02f, -9.14088488e-02f, 2.99978890e-02f, 1.95944812e-02f, 3.95043567e-02f, 6.69639707e-02f, 3.60875838e-02f, 5.97502925e-02f, 3.59398127e-02f,
  -2.64430612e-01f, 2.74779409e-01f, -7.48627409e-02f, 2.41011102e-02f, -7.44352164e-03f, -5.33467755e-02f, -1.35224983e-01f, -1.76406037e-02f, -1.13096029e-01f, -3.44501212e-02f,
  9.00977105e-02f, -4.50558029e-02f, -1.78870603e-01f, 7.73097062e-03f, 3.44946720e-02f, 1.10236173e-02f, 4.24480215e-02f, -9.48168114e-02f, 1.34650692e-01f, 1.26899004e-01f,
  -6.09201286e-03f, -3.96963768e-02f, -1.78779811e-02f, -6.12551942e-02f, 2.94129364e-02f, -2.82417387e-02f, -7.56090414e-03f, 6.76006228e-02f, 2.53994018e-02f, -1.66492999e-01f,
  -5.72635949e-01f, 5.83212078e-02f, 4.57338244e-03f, -2.27909043e-01f, 5.00784703e-02f, 2.64274567e-01f, 3.48442137e-01f, 1.67483166e-01f, 1.64418854e-02f, 8.44589248e-02f,
  5.43982014e-02f, -7.09777372e-03f, -3.99269350e-02f, 1.30684048e-01f, 5.60059138e-02f, 8.86753127e-02f, 2.32908964e-01f, -9.50166062e-02f, -1.30708218e-01f, -6.97815791e-02f,
  7.69995749e-02f, -4.93577756e-02f, -3.19864005e-01f, -4.11273986e-02f, 5.15384898e-02f, -7.71954581e-02f, -2.98932660e-02f, -2.43447125e-02f, 5.22032157e-02f, 6.17503151e-02f,
  -2.43228287e-01f, -2.78927505e-01f, 2.53440477e-02f, -6.84379116e-02f, -3.26527422e-03f, -2.72400808e-02f, -9.88031551e-02f, -4.63786833e-02f, -4.92499247e-02f, -2.19979091e-03f,
  -6.68988600e-02f, -8.21474865e-02f, -8.78724456e-02f, 7.99176618e-02f, -9.53086466e-02f, -5.07278107e-02f, 2.29985733e-02f, -1.40698224e-01f, -1.04665212e-01f, -1.91653948e-02f,
  7.97611177e-02f, 1.96393090e-03f, -1.47308767e-01f, 1.16766676e-01f, 3.89044993e-02f, -5.35484515e-02f, -5.31786866e-02f, -9.05274674e-02f, -8.31385106e-02f, -1.52858332e-01f,
  1.95764378e-02f, -1.73948985e-02f, 7.86619931e-02f, -8.98694694e-02f, -3.37385423e-02f, -3.17929089e-02f, 6.15810677e-02f, 6.78416193e-02f, 4.04354632e-02f, -2.53990144e-02f,
  2.10345211e-03f, -7.68025666e-02f, -6.05779812e-02f, -8.12702477e-02f, 2.40125861e-02f, -3.22819017e-02f, 9.48899835e-02f, 4.32488276e-03f, 4.71039601e-02f, -1.98574495e-02f,
  -3.02273547e-03f, 1.58687811e-02f, -2.60044280e-02f, -1.04055111e-03f, 3.74917723e-02f, 5.40392399e-02f, 4.84877229e-02f, 1.59680229e-02f, -8.43946040e-02f, -4.03123535e-02f,
  -7.48327598e-02f, -2.06644973e-03f, 1.92591678e-02f, -9.30673182e-02f, 9.99262091e-03f, 3.97790894e-02f, -2.80685141e-03f, -3.76060978e-02f, 2.56879572e-02f, -2.22413670e-02f,
  -7.38802785e-03f, -1.07490718e-02f, -5.31318039e-02f, -3.09548751e-02f, -3.94310616e-02f, 6.10712618e-02f, 1.62876416e-02f, -4.83375462e-03f, 7.23511428e-02f, -4.86954376e-02f,
  -1.67706155e-03f, 3.84967029e-02f, -1.60321638e-01f, 8.93750321e-03f, -4.20013592e-02f, -1.31411642e-01f, -1.90668404e-02f, -8.05208161e-02f, 3.83026376e-02f, -1.39748648e-01f,
  -6.02935664e-02f, 9.07035097e-02f, -1.23789020e-01f, 1.68723464e-01f, 2.70647295e-02f, -1.39477134e-01f, -1.23003632e-01f, -2.10829586e-01f, 6.74763136e-03f, -2.59170737e-02f,
  8.25304016e-02f, 7.70070106e-02f, -4.57201749e-02f, -1.02132477e-01f, -6.11975789e-02f, -5.17798960e-02f, -1.17812209e-01f, -6.02000244e-02f, -6.67558163e-02f, 3.96493301e-02f,
  1.44800559e-01f, 1.41356274e-01f, 7.13945702e-02f, -2.09556315e-02f, 1.19655363e-01f, 2.07317397e-01f, 8.48489553e-02f, 3.62113640e-02f, 1.10061131e-01f, 2.55468667e-01f,
  2.70882040e-01f, 1.48644382e-02f, -6.76088333e-02f, 1.19021274e-01f, -5.41616231e-03f, -4.22057211e-02f, -2.10063104e-02f, -7.65798017e-02f, 2.54753046e-02f, -1.59546379e-02f,
  -5.74065978e-03f, -2.99853063e-03f, 5.32338470e-02f, -7.28881061e-02f, -1.00604452e-01f, -7.83185437e-02f, -6.66016564e-02f, -9.98959988e-02f, -1.62023082e-02f, 6.67813346e-02f,
  -7.11917644e-03f, 1.18861958e-01f, -4.42803279e-02f, -1.51080728e-01f, -8.44676793e-02f, 7.10408464e-02f, -1.26011044e-01f, -1.57555547e-02f, -1.48411229e-01f, 4.08399478e-02f,
  -6.86420547e-03f, 5.45297302e-02f, 4.64938246e-02f, 5.70906661e-02f, -3.98900434e-02f, 2.95580942e-02f, 3.49476002e-02f, 2.10700033e-04f, -1.92567389e-02f, -1.73056852e-02f,
  -1.08087156e-02f, 5.87010384e-03f, 7.13396519e-02f, -2.02461295e-02f, 9.34036672e-02f, 7.66255930e-02f, 9.51635838e-02f, 6.58611208e-02f, 6.82015792e-02f, -6.25955537e-02f,
  5.17623350e-02f, 8.59870575e-03f, -2.44832691e-02f, -3.25351804e-02f, 4.71266732e-02f, -3.86647321e-02f, -8.33211280e-03f, -6.98912665e-02f, 1.10318244e-01f, -8.04711599e-03f,
  1.31991684e-01f, -9.88091603e-02f, 9.91169810e-02f, 5.17036244e-02f, 1.05581462e-01f, -6.12195097e-02f, 1.36639789e-01f, 6.64054006e-02f, 6.11741506e-02f, 3.27408984e-02f,
  -5.53349108e-02f, 6.62550032e-02f, 7.05005750e-02f, -1.73081644e-02f, -3.03074960e-02f, -5.92005774e-02f, 6.26844540e-02f, -8.28081667e-02f, -6.78213686e-02f, 4.21879478e-02f,
  -1.18815392e-01f, -6.37328550e-02f, -6.28920570e-02f, -1.05381340e-01f, 4.14084531e-02f, 2.39179898e-02f, 1.04856882e-02f, 1.26398299e-02f, -1.95051223e-01f, -8.74436572e-02f,
  -3.31598282e-01f, 3.34423296e-02f, -4.60595340e-02f, 2.09287088e-02f, -5.71977980e-02f, -1.73443884e-01f, -1.48025796e-01f, 2.62543857e-02f, -7.44333342e-02f, 5.67951240e-03f,
  -4.30716015e-02f, -1.48627445e-01f, 2.82743014e-02f, -9.98076126e-02f, -1.52358547e-01f, -8.11440945e-02f, 5.58241457e-02f, -1.39507666e-01f, -2.51727134e-01f, -1.42973974e-01f,
  -1.64399922e-01f, -2.53461629e-01f, -1.34045094e-01f, -1.13289982e-01f, 7.08901836e-03f, -1.23089209e-01f, 1.20241463e-01f, 2.79369410e-02f, 2.51411702e-02f, 1.73670352e-02f,
  -1.39199510e-01f, -3.45544294e-02f, 5.08302748e-02f, -7.79085532e-02f, 3.99724953e-02f, 8.16391334e-02f, -5.11079505e-02f, 9.68665555e-02f, 1.31829837e-02f, 6.20897338e-02f,
  2.97193620e-02f, -1.01072580e-01f, -4.79054041e-02f, -3.13131101e-02f, -8.81302655e-02f, -6.36494160e-02f, 1.80815794e-02f, 9.98933464e-02f, 6.72231019e-02f, 4.13299799e-02f,
  4.08750921e-02f, -1.37896221e-02f, 2.76162140e-02f, 1.51557356e-01f, 1.33962557e-01f, 4.17662114e-02f, 1.02280252e-01f, 5.88866100e-02f, 1.07756875e-01f, 5.45812473e-02f,
  -8.43301602e-03f, 5.44214696e-02f, 4.58870120e-02f, 3.79942022e-02f, -3.74244303e-02f, -5.45353256e-03f, 4.52216249e-03f, -5.58584556e-02f, 5.62006347e-02f, -6.96523637e-02f,
  -4.78155585e-03f, 9.18582529e-02f, -4.76479307e-02f, 2.54977029e-02f, -7.00102840e-03f, -1.68291591e-02f, 6.36826754e-02f, 6.09257212e-03f, 6.84741661e-02f, -2.21881513e-02f,
  1.02783451e-02f, -7.52399582e-03f, -2.50494275e-02f, 3.34173739e-02f, 1.68024190e-02f, -1.41449338e-02f, -1.04219727e-02f, -4.66301031e-02f, 5.13604544e-02f, -2.56960969e-02f,
  7.78652579e-02f, 2.88382801e-03f, -3.08769047e-02f, 7.40799727e-03f, -9.74400551e-04f, 1.09587945e-01f, 2.52807215e-02f, 8.12300071e-02f, 1.63897350e-02f, -1.22472331e-01f,
  -8.69375169e-02f, 1.28302723e-02f, -4.88886014e-02f, -2.20248047e-02f, 3.78841860e-03f, -4.01134714e-02f, 5.66247739e-02f, -3.54071967e-02f, 5.32000288e-02f, 1.58169381e-02f,
  7.82125220e-02f, -1.26963317e-01f, -1.59752980e-01f, -2.46733874e-02f, -3.05008441e-02f, -1.00641906e-01f, -9.32578444e-02f, 7.07334504e-02f, -4.75990251e-02f, 3.98338288e-02f,
  1.00656658e-01f, 3.19841176e-01f, 1.33446112e-01f, -6.26636744e-02f, 2.12892964e-02f, 4.41557877e-02f, 1.02832206e-01f, -9.19038951e-02f, -2.28344817e-02f, 1.37794718e-01f,
  1.47798032e-01f, -1.01996705e-01f, -1.16117030e-01f, -1.18332677e-01f, -1.06678680e-01f, -4.88674119e-02f, -1.63192786e-02f, -1.19873211e-01f, -2.23514348e-01f, -1.30859300e-01f,
  -1.96964130e-01f, -9.02634561e-02f, -1.63643733e-01f, -6.40885532e-02f, 4.12241071e-02f, -7.25607499e-02f, 1.33161873e-01f, 1.05298102e-01f, 1.62378311e-01f, 1.37244806e-01f,
  5.92520945e-02f, 3.58805746e-01f, -2.62063414e-01f, -6.32154495e-02f, 1.49316236e-01f, -1.89082529e-02f, -9.43486951e-03f, 4.67159739e-03f, -3.64497025e-03f, 3.41529548e-02f,
  1.40900075e-01f, -3.74585316e-02f, 4.12053131e-02f, -1.39248164e-04f, 1.72962751e-02f, -6.15283139e-02f, 1.64418351e-02f, -6.25031516e-02f, -9.52111259e-02f, 2.88365185e-02f,
  -4.38601710e-02f, 4.21348872e-04f, 2.22520884e-02f, -9.42807924e-03f, 1.12855667e-02f, 2.14026403e-02f, 8.59556869e-02f, 3.21925338e-03f, 1.04923986e-01f, -6.91956058e-02f,
  -3.19007225e-02f, 6.39020950e-02f, 3.47992480e-02f, 5.94904609e-02f, 5.66354813e-03f, -3.72134000e-02f, -6.50507659e-02f, 2.57644244e-02f, -3.02022900e-02f, -2.38749422e-02f,
  -6.86190575e-02f, 3.49333622e-02f, -3.63317691e-02f, 3.47473212e-02f, -5.71863353e-02f, -3.32916789e-02f, 1.47148026e-02f, -3.85303274e-02f, 1.98441488e-03f, -8.91080312e-03f,
  1.06385155e-02f, 7.91065842e-02f, 7.42630959e-02f, 5.22340760e-02f, 4.53307629e-02f, -1.34598669e-02f, -8.95779431e-02f, -2.87942588e-02f, 2.91838460e-02f, -3.69681083e-02f,
  -1.52507216e-01f, -3.19307707e-02f, -1.05660841e-01f, -1.53015375e-01f, 1.18567057e-01f, -3.74072939e-02f, 9.82578099e-02f, 1.92134399e-02f, 6.76454976e-02f, 1.99920554e-02f,
  -1.53726721e-02f, 4.74296175e-02f, -2.34940536e-02f, -4.62578461e-02f, -8.18619728e-02f, -1.38008120e-02f, -8.82179290e-02f, -1.12023540e-01f, -1.60554215e-01f, -6.74640313e-02f,
  -7.56456405e-02f, -8.30674246e-02f, -2.55822539e-01f, -6.68461844e-02f, -4.68591275e-03f, -1.21019937e-01f, -1.19015530e-01f, -5.67912720e-02f, -1.04808852e-01f, -1.89561531e-01f,
  -2.48598933e-01f, -1.45305172e-01f, -5.38875628e-03f, 2.24450335e-01f, 2.70535260e-01f, 3.13547015e-01f, 1.47434041e-01f, 2.11370170e-01f, 2.26230606e-01f, 6.84503838e-02f,
  6.01823330e-02f, 1.38890177e-01f, 1.44592702e-01f, 4.11139727e-02f, 6.67980760e-02f, 6.53846040e-02f, 2.34274626e-01f, 7.18786716e-02f, -1.68618113e-02f, 5.70043027e-02f,
  1.59123018e-01f, 1.19170770e-01f, -4.00568470e-02f, 2.78039519e-02f, 8.41755569e-02f, 1.48847893e-01f, 7.17082918e-02f, 3.04239187e-02f, 8.31870437e-02f, 1.66249201e-01f,
  -9.57879350e-02f, -1.34506986e-01f, 1.63229361e-01f, 2.08284575e-02f, -1.28175095e-01f, -5.33775613e-02f, 2.81263441e-02f, -1.09832548e-01f, -1.97790302e-02f, 6.09007329e-02f,
  7.14659644e-03f, -9.04047787e-02f, -2.29904917e-03f, 2.96153538e-02f, -8.15189071e-03f, 2.57061366e-02f, -1.51817754e-01f, -6.77101826e-03f, -6.63477182e-02f, -1.41221792e-01f,
  -2.70224120e-02f, 5.58775403e-02f, 3.16707529e-02f, 9.01017860e-02f, -5.25606647e-02f, -6.98181763e-02f, -1.21174134e-01f, -3.35651264e-02f, -1.28378704e-01f, -1.32602632e-01f,
  1.57859083e-02f, -9.77265183e-03f, -3.16424333e-02f, -1.14919040e-02f, 3.22849900e-02f, 2.27000359e-02f, -4.36651334e-02f, 6.51875809e-02f, 5.47942258e-02f, -3.31334621e-02f,
  3.53519507e-02f, 6.74161837e-02f, -7.88902026e-03f, -3.92172282e-04f, 7.16627017e-02f, 1.55199021e-02f, 6.10393398e-02f, -8.43856931e-02f, 3.42731141e-02f, -8.75428244e-02f,
  4.47393507e-02f, -6.43634470e-03f, -1.02943346e-01f, -3.92072797e-02f, 2.15986427e-02f, -7.42718354e-02f, -3.71412709e-02f, -4.32865368e-03f, -3.41123566e-02f, -5.35532758e-02f,
  6.86944053e-02f, 2.89812144e-02f, -1.84269808e-02f, -6.43978566e-02f, 4.47744206e-02f, -1.37406036e-01f, 6.12000115e-02f, -8.60589519e-02f, -8.17446876e-03f, -6.11896366e-02f,
  -8.36526044e-03f, -6.18504845e-02f, -9.18431208e-02f, -3.78462635e-02f, -5.38143218e-02f, -3.60255432e-03f, 6.21274561e-02f, -4.02514935e-02f, -5.34137934e-02f, -6.87268674e-02f,
  1.67043637e-02f, 7.68829584e-02f, 5.53358868e-02f, 3.84618901e-03f, -4.38538758e-04f, 2.48612557e-02f, 9.34072658e-02f, -1.74401328e-02f, 3.64862476e-03f, 6.57480285e-02f,
  -5.71886376e-02f, -8.63691121e-02f, -4.44529355e-02f, 1.53230680e-02f, -2.14470774e-02f, -9.53382924e-02f, -2.40002319e-01f, -1.40075997e-01f, -5.78524917e-02f, 2.92350464e-02f,
  -6.15965761e-02f, 5.23079149e-02f, 7.57484287e-02f, -1.05003878e-01f, -2.19308496e-01f, -6.81893751e-02f, -1.93333440e-02f, -1.30665675e-01f, -1.49294809e-02f, -9.39314514e-02f,
  -3.08051575e-02f, 3.29856537e-02f, -1.22858949e-01f, -9.53801498e-02f, 1.20704770e-01f, 2.24854108e-02f, 5.60124703e-02f, -4.02924754e-02f, -1.96495242e-02f, 1.02438480e-01f,
  1.27667397e-01f, 8.58743768e-03f, -3.32863368e-02f, -8.27133879e-02f, 1.23518892e-01f, -8.95946026e-02f, 9.90251526e-02f, 4.60152924e-02f, -2.94123627e-02f, -3.08957156e-02f,
  1.13044135e-01f, 4.08710577e-02f, 2.30822396e-02f, 5.77849597e-02f, -1.71568971e-02f, -5.51546738e-02f, 5.44563867e-02f, -9.91007406e-03f, -6.79586455e-02f, -5.24355844e-02f,
  9.66540128e-02f, 4.44003083e-02f, -1.25638889e-02f, 6.04759790e-02f, 5.40954582e-02f, -2.49947403e-02f, 3.73214744e-02f, -5.25041260e-02f, 4.25504670e-02f, -6.90668002e-02f,
  -1.04675166e-01f, 4.18387353e-02f, -3.05304844e-02f, 2.86722905e-03f, -8.52692723e-02f, -7.33038932e-02f, -9.83631834e-02f, -8.13277289e-02f, -4.85817604e-02f, -7.92499781e-02f,
  7.99635146e-03f, 3.34622264e-02f, -7.07847252e-02f, -2.32633203e-02f, -8.23928416e-02f, 6.60443977e-02f, -1.14967346e-01f, -8.58832821e-02f, 5.90630844e-02f, -6.32467344e-02f,
  -9.50794816e-02f, -8.04486349e-02f, 8.16330835e-02f, -4.39698286e-02f, -1.13256387e-01f, -3.08008566e-02f, -9.52349901e-02f, -3.00113969e-02f, 7.59703517e-02f, 8.47307071e-02f,
  2.00138748e-01f, -3.23399231e-02f, 4.87830602e-02f, 5.89038525e-03f, 1.09509222e-01f, 6.16195146e-03f, -2.29668058e-03f, 1.16290199e-02f, 1.10101346e-02f, 1.11549040e-02f,
  -1.76412761e-02f, 7.41891712e-02f, 6.69151619e-02f, 4.54628374e-03f, 4.71408926e-02f, -1.92152318e-02f, -1.19159177e-01f, -8.87677521e-02f, 1.58904761e-03f, -2.81696077e-02f,
  -3.18124108e-02f, -1.47312386e-02f, -2.57439539e-03f, 9.17619746e-03f, 6.07720651e-02f, -7.97346327e-03f, -2.97070201e-02f, 2.03422196e-02f, 2.92922389e-02f, -1.17910214e-01f,
  -6.91863429e-03f, -1.09129526e-01f, 1.08859882e-01f, -3.72655615e-02f, 1.86090678e-01f, 9.55284312e-02f, -1.11433014e-03f, 7.23011792e-02f, 7.82674178e-02f, -4.73591946e-02f,
  -1.98865235e-01f, -1.13117941e-01f, -3.15516666e-02f, -1.69688269e-01f, -1.32881075e-01f, 3.16535644e-02f, 1.86062813e-01f, 8.86067823e-02f, 6.75371364e-02f, 9.54508409e-02f,
  1.92771666e-02f, 1.72543023e-02f, 6.20175451e-02f, -7.15839714e-02f, 5.27284928e-02f, 5.34894038e-03f, -1.95803475e-02f, 4.28975001e-02f, -3.61956209e-02f, 3.64083871e-02f,
  -2.36531757e-02f, -1.10194050e-01f, -5.26579991e-02f, -1.10847272e-01f, 5.84093155e-03f, -1.53001649e-02f, 6.10504299e-02f, 9.19063669e-03f, -7.05141127e-02f, 3.00874058e-02f,
  1.96572505e-02f, 8.75674468e-03f, -3.58907413e-03f, -9.65179354e-02f, 3.81879508e-02f, -3.25707272e-02f, 6.02606963e-03f, 2.34676506e-02f, -9.72160697e-02f, -4.43754867e-02f,
  -1.56696066e-01f, 2.78939381e-02f, 1.02837950e-01f, 7.77317435e-02f, -1.06625825e-01f, 5.33909388e-02f, 3.04653049e-02f, 4.70905006e-02f, -2.53296234e-02f, 7.38248602e-02f,
  2.97481623e-02f, -6.46758601e-02f, -6.75927624e-02f, -4.22130227e-02f, 5.64094596e-02f, 7.25449398e-02f, -4.73451987e-03f, 3.11245136e-02f, -5.57456538e-02f, -1.10040344e-02f,
  -8.37417990e-02f, 6.81661740e-02f, 1.19471522e-02f, -5.11616953e-02f, -2.83300560e-02f, -3.27404262e-03f, -1.85891576e-02f, 9.78626311e-03f, -7.65012875e-02f, 9.11549777e-02f,
  -1.13854893e-02f, -2.76776832e-02f, 3.94820645e-02f, -1.22361341e-02f, 1.65747814e-02f, 9.03419107e-02f, -5.69297820e-02f, 5.96121289e-02f, 4.76615038e-03f, 7.18258368e-03f,
  -7.42845908e-02f, 4.42826599e-02f, -5.51769063e-02f, -7.30743110e-02f, 1.59519427e-02f, -1.83405448e-02f, -1.11632474e-01f, -3.18432301e-02f, -1.06925197e-01f, -1.90796107e-02f,
  -3.65950316e-02f, -2.77274046e-02f, -1.07547469e-01f, 5.02574444e-02f, 3.71685103e-02f, -9.30503849e-03f, 5.70354350e-02f, 2.40454990e-02f, -5.03231250e-02f, -3.85790579e-02f,
  4.04429361e-02f, 2.22009048e-01f, 7.96464309e-02f, 1.38931543e-01f, 1.53205218e-02f, 1.31450161e-01f, 7.64735322e-03f, 3.07722464e-02f, 1.73670739e-01f, 6.14397973e-02f,
  4.96752679e-01f, 4.10337627e-01f, 2.69533277e-01f, 7.33490214e-02f, -1.22149520e-01f, 4.43655476e-02f, 1.90478504e-01f, 1.00863799e-01f, 9.63565558e-02f, 4.56568301e-02f,
  -9.81356427e-02f, -5.49326576e-02f, 1.31332308e-01f, 1.96920857e-02f, 2.59992480e-01f, 1.03791095e-01f, 1.33803472e-01f, 1.84675023e-01f, 1.62560344e-01f, -1.13583850e-02f,
  -1.62366986e-01f, -2.55648606e-02f, 1.14109457e-01f, 1.53245077e-01f, 3.49009521e-02f, -1.04465283e-01f, -2.29157787e-03f, 6.62998036e-02f, 2.00407207e-02f, 2.12950166e-02f,
  -2.05687989e-04f, 3.28594774e-01f, -1.25029951e-01f, -6.42128810e-02f, -9.91008133e-02f, 1.74636841e-01f, -3.78446802e-02f, 6.77221045e-02f, 2.20971415e-03f, -2.01219860e-02f,
  -1.14814408e-01f, -5.96699901e-02f, 6.77470118e-02f, -3.59575488e-02f, -8.24147761e-02f, 6.06565587e-02f, 4.77940403e-02f, 2.30698213e-01f, 8.84484202e-02f, 7.07423538e-02f,
  -7.98087791e-02f, -7.59790987e-02f, -1.47506397e-03f, 3.67800449e-03f, 1.74296439e-01f, -6.41008317e-02f, 4.82736938e-02f, 8.76361728e-02f, 7.27467462e-02f, 3.45715061e-02f,
  -8.81060362e-02f, -2.10609771e-02f, 1.08505157e-03f, 4.58517298e-02f, -4.84544933e-02f, -5.97560219e-02f, -6.98705204e-03f, -4.11447026e-02f, 9.45423245e-02f, -7.18425736e-02f,
  3.50079946e-02f, 1.41971912e-02f, 1.00245327e-01f, -3.10546439e-02f, -5.04238121e-02f, 1.91908758e-02f, -3.46702081e-03f, -3.11176404e-02f, 5.12762591e-02f, -5.60536189e-03f,
  6.81609511e-02f, 5.97932469e-03f, -9.46342126e-02f, 3.04744821e-02f, -6.68548197e-02f, 4.50077131e-02f, -3.64854224e-02f, -2.70609674e-03f, 3.18039246e-02f, -9.32371542e-02f,
  -1.43828377e-01f, 7.74992406e-02f, -1.10232852e-01f, 1.31602809e-01f, -7.45744929e-02f, 3.00582382e-03f, 1.05255675e-02f, -3.69595177e-02f, -5.30922487e-02f, -1.29330356e-03f,
  -4.83617419e-03f, 1.45990372e-01f, 5.03151678e-02f, 6.15631416e-02f, -1.31427526e-01f, -2.50183064e-02f, -5.87345660e-02f, 4.68600728e-03f, 4.76721190e-02f, 2.62922514e-03f,
  2.26491392e-02f, -1.59898520e-01f, -1.70803547e-01f, -1.26515284e-01f, -6.21826909e-02f, -1.31718516e-01f, -1.41241372e-01f, -7.58713782e-02f, -1.40746295e-01f, -1.26397416e-01f,
  -1.16970196e-01f, 6.38584048e-02f, 1.99328169e-01f, 2.11726632e-02f, -9.26962271e-02f, -1.95492640e-01f, -1.50854200e-01f, -3.25757079e-02f, 2.13010162e-02f, -2.66789142e-02f,
  7.26144463e-02f, -6.58170506e-02f, -7.19068721e-02f, -1.26946270e-01f, -2.20986120e-02f, 6.17364570e-02f, -5.19069582e-02f, -1.82072967e-01f, -2.15157866e-01f, -2.72284031e-01f,
  -1.29994288e-01f, -7.06241205e-02f, -7.62142614e-02f, -1.29969507e-01f, -3.44467834e-02f, 7.50496835e-02f, 1.20082743e-01f, -1.14125051e-02f, 4.74606380e-02f, 9.58082303e-02f,
  1.65194616e-01f, 1.54472783e-01f, -7.90810063e-02f, -3.72266844e-02f, -3.77684506e-03f, 9.26812813e-02f, 8.23192485e-03f, 9.27946419e-02f, 5.01713417e-02f, 6.78226724e-03f,
  2.42559984e-02f, -6.39580041e-02f, 1.04887830e-02f, -3.36727547e-03f, -5.94281666e-02f, 2.24496219e-02f, -8.48828778e-02f, 4.01673559e-03f, 1.29869515e-02f, 8.89420137e-02f,
  9.83697921e-03f, -1.08833201e-01f, 1.31821111e-02f, 3.52108409e-03f, 7.55448565e-02f, -1.28710166e-01f, 1.28626481e-01f, -1.77748955e-03f, 1.13632403e-01f, 7.68200234e-02f,
  8.80577881e-03f, -5.35206776e-03f, -7.03439936e-02f, -3.60767469e-02f, 4.61214595e-02f, -1.23578310e-02f, 4.86465991e-02f, 5.73547333e-02f, -1.44488672e-02f, 7.68250553e-03f,
  -2.48603784e-02f, -1.39539002e-03f, -4.61897515e-02f, 2.15005782e-02f, 1.14669837e-02f, -5.28302900e-02f, -1.18238423e-02f, -9.78777409e-02f, 3.87561023e-02f, 4.51481603e-02f,
  3.27914557e-03f, 1.90209206e-02f, 4.38067093e-02f, -1.72964111e-02f, 6.65197521e-02f, -1.78772751e-02f, 5.62899001e-02f, -1.15838505e-01f, -9.19916853e-03f, 4.10422087e-02f,
  5.72742261e-02f, -7.68740401e-02f, 3.42816710e-02f, 8.33029598e-02f, -4.68444303e-02f, 4.95136082e-02f, -1.75552648e-02f, 4.07060757e-02f, -5.96809089e-02f, -1.00637190e-01f,
  -1.47175184e-02f, 5.73218279e-02f, 2.68990770e-02f, -8.65557194e-02f, -1.12988599e-01f, -5.97933456e-02f, -2.50230338e-02f, -8.16807002e-02f, 4.45311889e-02f, 8.03828984e-02f,
  -4.92396671e-03f, -6.00680225e-02f, -1.29135489e-01f, 6.09188713e-02f, 1.00716464e-01f, 1.98404044e-02f, -9.24500637e-03f, -6.40673842e-03f, 1.93255302e-02f, -3.87008004e-02f,
  -2.51630694e-01f, -1.32222101e-01f, 2.20537055e-02f, -8.25226232e-02f, 5.26954196e-02f, 1.42249584e-01f, 6.60330951e-02f, 1.04155270e-02f, 3.81860435e-02f, -1.10199109e-01f,
  -1.24355197e-01f, 1.15533341e-02f, -4.33480777e-02f, -4.56799474e-03f, 1.23115554e-01f, 1.17654882e-01f, 3.95595431e-02f, 1.47224784e-01f, 1.41002953e-01f, 1.12869190e-02f,
  -2.12917440e-02f, -4.72268313e-02f, 8.22875462e-03f, 7.37251788e-02f, -2.37908252e-02f, 4.83015664e-02f, 7.60745928e-02f, 2.78490260e-02f, -2.12267023e-02f, 3.77865694e-02f,
  2.56367009e-02f, -1.06718726e-01f, -3.08531690e-02f, -3.37257050e-02f, -9.44191664e-02f, -1.56114642e-02f, -4.33486104e-02f, -3.04227863e-02f, -9.26637352e-02f, -8.22186321e-02f,
  -6.51291246e-03f, -1.18543617e-02f, -6.65694755e-03f, -3.50528629e-03f, -8.90482962e-02f, -3.19009909e-04f, -3.82155627e-02f, 1.09821990e-01f, 1.18439235e-01f, 6.67460039e-02f,
  6.83105662e-02f, 2.47172993e-02f, 1.35231186e-02f, 5.32518700e-02f, -2.53814720e-02f, 1.33402860e-02f, 1.18411751e-02f, 2.28809919e-02f, -3.25685926e-02f, -3.94589268e-02f,
  6.30470812e-02f, 2.34059114e-02f, 3.92022766e-02f, 2.91293375e-02f, 6.41892403e-02f, 8.60418901e-02f, -6.06563687e-02f, -5.00960611e-02f, 6.73834831e-02f, -5.96740749e-03f,
  6.73174933e-02f, -5.73037155e-02f, 4.63790484e-02f, -5.89601062e-02f, -2.70902496e-02f, 7.78064653e-02f, 3.27938423e-02f, -3.95584777e-02f, 1.17850602e-02f, 4.25220616e-02f,
  -9.28153563e-03f, -6.15491942e-02f, 5.59246503e-02f, 9.96154174e-03f, -3.75187881e-02f, -4.53012697e-02f, 1.74991935e-02f, 2.69019906e-03f, 3.63052264e-02f, -1.02878816e-01f,
  2.00771131e-02f, 4.51312959e-03f, 1.06924102e-01f, -1.93822831e-02f, -7.04596192e-03f, -9.61550996e-02f, 7.06229592e-03f, -1.02991061e-02f, -2.02103090e-02f, 4.09462415e-02f,
  -8.58092308e-03f, 1.88676398e-02f, 3.31122093e-02f, 1.53925410e-02f, 1.01972818e-02f, -1.95554867e-02f, -5.32115325e-02f, 1.10086858e-01f, 9.57111940e-02f, 4.48050015e-02f,
  1.24184035e-01f, -3.72624099e-02f, 3.43479812e-02f, 4.71898876e-02f, -5.22452081e-03f, 1.10132374e-01f, -2.63359281e-03f, 4.46343943e-02f, -1.58398773e-03f, 3.70614193e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.34864509e-01f, 2.14622408e-01f, 8.14817324e-02f, 2.89717287e-01f, 9.67389196e-02f, 3.75418458e-03f, 1.24954924e-01f, 1.25101849e-01f, 1.22809745e-01f, 2.47356653e-01f,
  3.14191788e-01f, 3.60842012e-02f, 1.34429783e-01f, 1.89647734e-01f, 1.31443068e-01f, 2.02487990e-01f, 2.17880636e-01f, 9.85677242e-02f, -1.04405154e-02f, 3.20781738e-01f,
  9.08629671e-02f, 1.42833218e-01f, 5.24614044e-02f, 1.97162434e-01f, 1.10655136e-01f, 1.37308255e-01f, 2.36627907e-01f, 1.79919481e-01f, 7.45527595e-02f, 6.39948854e-03f,
  8.97128582e-02f, 9.66400057e-02f, 1.92323193e-01f, 2.45747045e-01f, 4.19270061e-02f, 5.83996880e-04f, 9.55341086e-02f, 2.38707244e-01f, 1.43244579e-01f, 1.40898496e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -4.94309992e-01f, 1.00589179e-01f, -4.16837543e-01f, -3.89709771e-01f, -5.05687118e-01f, -4.21774507e-01f, -1.11722238e-01f, -1.25289977e-01f, -3.45000416e-01f, -1.01006046e-01f,
  -8.46615210e-02f, -3.92981544e-02f, -2.19757631e-01f, -2.51233131e-01f, 2.61236783e-02f, -1.96460430e-02f, -1.30741268e-01f, 3.57476592e-01f, 1.26418859e-01f, -1.23129882e-01f,
  -2.83890311e-02f, -1.06106184e-01f, 2.01892391e-01f, -1.78641882e-02f, 2.46500611e-01f, -1.95460990e-01f, -1.75029516e-01f, -1.87465221e-01f, -2.06689015e-01f, -6.60447180e-02f,
  4.04756740e-02f, -1.77845329e-01f, 2.85006631e-02f, -9.06864032e-02f, 2.23900244e-01f, -3.12316298e-01f, 1.42536908e-01f, -1.85343757e-01f, 3.27570997e-02f, 4.09393497e-02f,
  3.85027051e-01f, 8.72753799e-01f, -7.21979067e-02f, 4.65015769e-02f, 9.10197869e-02f, -1.12060802e-02f, -2.31942132e-01f, -1.43776894e-01f, -1.44322097e-01f, 5.70475876e-01f,
  -8.36841017e-02f, 2.91156266e-02f, 2.92927563e-01f, 5.08964837e-01f, -9.48451236e-02f, -5.46866357e-02f, -4.62348573e-02f, -2.61125326e-01f, -1.67804986e-01f, 1.00670131e-02f,
  -1.77816674e-01f, 2.92143412e-02f, -2.58089632e-01f, -1.87064204e-02f, 7.65508413e-02f, -1.84992149e-01f, -8.91637132e-02f, 5.77108301e-02f, 3.60740036e-01f, -2.50368536e-01f,
  -1.77746296e-01f, 1.46941440e-02f, 2.11719781e-01f, -3.04554671e-01f, 4.03905436e-02f, 1.64126128e-01f, -3.29233319e-01f, -6.47524297e-01f, 1.88902497e-01f, 1.75518706e-01f,
  4.92232069e-02f, 1.39853582e-01f, -4.78078425e-01f, 4.44537520e-01f, 3.33822668e-01f, -2.03464434e-01f, -4.11788613e-01f, 4.51846033e-01f, 3.48906338e-01f, 2.33239546e-01f,
  -1.32322207e-01f, 8.32087815e-01f, -2.50536650e-01f, -1.00666963e-01f, -4.37157482e-01f, 2.53168792e-02f, 3.58046114e-01f, -2.02214420e-01f, -3.36619079e-01f, -2.31679007e-01f,
  -2.45631754e-01f, 4.71905529e-01f, 3.12417686e-01f, -1.29482523e-01f, 5.31518571e-02f, 7.25820124e-01f, 4.96999063e-02f, 9.86139253e-02f, -2.98026413e-01f, -1.10573381e-01f,
  2.04222113e-01f, 1.41802013e-01f, 1.33041739e-01f, 1.76378395e-02f, 3.18259150e-01f, -2.07684591e-01f, 2.68133640e-01f, -6.04313985e-02f, -1.50500372e-01f, -1.87786460e-01f,
  -1.07821181e-01f, -1.93620861e-01f, 7.13222325e-02f, -6.29059300e-02f, -1.18533522e-01f, 3.79715055e-01f, -7.90837407e-02f, -4.63592762e-04f, 1.94684625e-01f, 4.87891644e-01f,
  1.93563953e-01f, 1.88083395e-01f, 1.06902190e-01f, 4.04231131e-01f, 2.84235179e-01f, 1.71443895e-02f, 3.74222994e-01f, 5.20683169e-01f, -1.43265296e-02f, -4.86745052e-02f,
  -3.85627598e-01f, 2.13005915e-01f, 2.14580461e-01f, 4.19889577e-02f, 4.19919670e-01f, 1.93540633e-01f, 1.01144895e-01f, 2.06275940e-01f, -3.70832458e-02f, 1.47455722e-01f,
  6.70344569e-03f, -6.48911238e-01f, 2.98232406e-01f, 1.81256711e-01f, -1.50211214e-04f, -2.80634947e-02f, -3.87711897e-02f, -1.84100747e-01f, 1.70381576e-01f, 1.20156901e-02f,
  -1.06495090e-01f, 9.14750993e-01f, -4.06426907e-01f, 2.58472443e-01f, -2.88175434e-01f, -2.75775671e-01f, -3.16789538e-01f, -3.30115795e-01f, -2.19229266e-01f, 3.89814883e-01f,
  -1.19668141e-01f, -2.91788191e-01f, 9.56702530e-02f, 4.05649573e-01f, -1.00769222e-01f, -4.00615335e-01f, 4.15514894e-02f, 7.97973499e-02f, 1.30132720e-01f, -1.93506718e-01f,
  -1.26351297e-01f, -6.87028021e-02f, -8.55596811e-02f, -1.96302637e-01f, 1.10774323e-01f, -2.30390057e-01f, -2.00766385e-01f, 1.32890427e-02f, -1.12677701e-02f, 1.20010644e-01f,
  -9.29678604e-02f, 6.41248599e-02f, -2.21586034e-01f, -2.17247218e-01f, 6.25757501e-02f, 5.30012734e-02f, -1.89043701e-01f, 3.42285752e-01f, -7.95016438e-02f, -2.68101171e-02f,
  -2.58875579e-01f, 4.72486801e-02f, -7.54528716e-02f, -7.46283606e-02f, 2.82673929e-02f, 2.38769814e-01f, 2.61609733e-01f, 1.73316374e-01f, -3.71130496e-01f, -7.44393170e-01f,
  -7.40726516e-02f, -3.80119950e-01f, 2.04361424e-01f, -1.04886621e-01f, -2.24790514e-01f, 3.80027086e-01f, -2.47260854e-01f, -2.31045708e-01f, 1.80241361e-01f, -2.66560137e-01f,
  4.20202285e-01f, -9.81127657e-03f, -9.06343386e-02f, 4.18028980e-01f, -8.70856494e-02f, 3.81389052e-01f, 8.76188278e-01f, 2.66619269e-02f, -2.27889448e-01f, -1.28993317e-01f,
  7.11853355e-02f, -1.40488803e-01f, 1.59284726e-01f, -2.65545309e-01f, -1.97758630e-01f, -2.18903467e-01f, -1.15719229e-01f, -7.37268254e-02f, -2.73422688e-01f, -1.67818576e-01f,
  2.96602231e-02f, -2.89252460e-01f, -1.62665304e-02f, -1.96563736e-01f, -1.29885934e-02f, 5.79468608e-01f, 4.71474200e-01f, -2.11818859e-01f, 2.55243391e-01f, 1.91649780e-01f,
  -1.91201851e-01f, -2.07800567e-01f, 1.57922924e-01f, -2.41982907e-01f, -1.59750003e-02f, 1.70238689e-01f, 1.06737733e-01f, -7.38855302e-02f, -2.38611698e-01f, -2.09018469e-01f,
  4.56288978e-02f, 9.03034881e-02f, 1.47469804e-01f, -1.95281506e-02f, -3.14319372e-01f, -2.23814715e-02f, -1.05959132e-01f, 1.09990705e-02f, 3.72880809e-02f, 5.30454099e-01f,
  3.22858006e-01f, 4.52025890e-01f, -1.51687220e-01f, 3.00834656e-01f, -6.69231862e-02f, -1.64853469e-01f, 2.82080978e-01f, -4.89020675e-01f, 4.90312241e-02f, -2.12986678e-01f,
  -1.01951234e-01f, -1.69546083e-01f, 1.61530867e-01f, -2.61652291e-01f, -9.53292251e-02f, 2.03490928e-02f, 3.32019120e-01f, -2.64075279e-01f, -1.87648721e-02f, -1.29820704e-01f,
  1.21967666e-01f, 5.36697507e-01f, 2.83794016e-01f, 1.40185012e-02f, -1.57004058e-01f, -1.94987431e-01f, 5.38484991e-01f, -6.23230711e-02f, 2.51119733e-01f, -2.26685137e-01f,
  2.62867570e-01f, 7.39555359e-02f, 2.05225468e-01f, -7.26798251e-02f, -1.77330747e-01f, -1.09776214e-01f, -1.81035221e-01f, -8.03527236e-03f, -3.89848351e-01f, -3.88023406e-01f,
  -2.07654536e-01f, 7.93379173e-02f, 5.17391801e-01f, 4.57946628e-01f, -5.57311475e-02f, 2.55582422e-01f, 3.76869552e-02f, -6.44529760e-02f, 5.37438512e-01f, -1.08064823e-02f,
  1.86983064e-01f, 3.55074704e-01f, -1.53330890e-02f, 2.64327645e-01f, 1.61146998e-01f, 2.20262203e-02f, 2.74773061e-01f, 7.62829855e-02f, 2.57481188e-01f, 9.43583176e-02f,
  2.02827662e-01f, 3.45121384e-01f, 1.79018497e-01f, -4.17633116e-01f, 4.70479637e-01f, -4.42242511e-02f, -2.15419441e-01f, 5.13274431e-01f, -2.54134923e-01f, -4.16408718e-01f,
  -1.37264412e-02f, -1.54919967e-01f, -1.63495660e-01f, 2.22163409e-01f, -1.25515357e-01f, -2.87512153e-01f, -6.20044917e-02f, 5.33053167e-02f, -1.77784130e-01f, 1.13799341e-01f,
  1.41736344e-01f, -3.47860642e-02f, 2.08459392e-01f, -3.03658813e-01f, -2.44581342e-01f, -1.45674825e-01f, 5.85781097e-01f, 3.65533918e-01f, -1.74001290e-03f, -1.22094095e-01f,
  9.63416845e-02f, -4.74300772e-01f, 6.34842068e-02f, 5.42929411e-01f, 3.45413126e-02f, -4.08054814e-02f, 6.40139520e-01f, -1.68802708e-01f, 1.93898112e-01f, 6.29138350e-01f,
  -2.48616084e-01f, 6.99779451e-01f, 2.08214372e-01f, -3.12064081e-01f, -1.67760909e-01f, 2.27616839e-02f, 1.12787075e-01f, -3.04957151e-01f, 1.08679615e-01f, -1.69466332e-01f,
  -4.84716594e-02f, -6.52701855e-02f, -1.04297057e-01f, -2.27888897e-01f, 3.80262174e-02f, 1.48705274e-01f, 2.17327625e-01f, 5.39483316e-02f, 5.92788421e-02f, 3.80751431e-01f,
  -1.03150956e-01f, -1.07472055e-01f, -4.22476172e-01f, -1.25097781e-01f, -1.93333000e-01f, 3.68704319e-01f, 1.28080308e-01f, 3.47889662e-01f, -8.27117935e-02f, -4.44173962e-01f,
  8.60487819e-02f, -2.74110973e-01f, 3.65607709e-01f, 4.37376559e-01f, -6.22170508e-01f, 2.40793064e-01f, 4.06467140e-01f, -3.10692787e-01f, -2.36347951e-02f, -1.00135401e-01f,
  9.06097237e-03f, 9.26406682e-02f, -8.19134116e-02f, 1.70553491e-01f, 3.04955896e-03f, -1.94918818e-03f, 1.32143602e-01f, -2.98406184e-01f, -3.10728192e-01f, 3.99969853e-02f,
  9.86454189e-02f, -3.34360957e-01f, -3.57943118e-01f, 6.18985891e-01f, -4.57612634e-01f, -3.05945218e-01f, -2.69357681e-01f, -1.95704043e-01f, -8.80922601e-02f, 4.03173625e-01f,
  -2.14066785e-02f, 6.17773607e-02f, 1.89101562e-01f, -2.91419923e-01f, -1.30044907e-01f, -6.61219060e-02f, -1.14155792e-01f, -2.12050587e-01f, -3.27093661e-01f, -4.42484915e-02f,
  -2.48327255e-01f, 1.12284884e-01f, -5.40379345e-01f, -1.35144621e-01f, -2.30142251e-02f, 7.28896141e-01f, 8.05420801e-02f, 3.07915751e-02f, -1.77894205e-01f, -3.61847967e-01f,
  -6.83667883e-02f, -4.35776174e-01f, -3.41223404e-02f, -3.43811274e-01f, -1.63145199e-01f, 7.86755234e-02f, 3.83775905e-02f, -3.99675190e-01f, -2.18024462e-01f, -2.40948424e-01f,
  -2.20276430e-01f, 2.11107373e-01f, -2.03375280e-01f, -1.81939796e-01f, -2.25749388e-01f, -3.59585911e-01f, 2.24123165e-01f, -2.14144289e-01f, 1.64986372e-01f, 1.98331952e-01f,
  8.76873173e-03f, -3.98550004e-01f, -1.55280426e-01f, 1.23448975e-01f, 3.24515522e-01f, -2.54660010e-01f, 2.93479621e-01f, 4.37877595e-01f, 2.67158058e-02f, 1.06907219e-01f,
  -6.58154860e-02f, 2.47666106e-01f, -2.14432925e-01f, -1.24537885e-01f, -8.35672989e-02f, 2.29660328e-02f, 1.71454802e-01f, -6.60466328e-02f, -1.63866237e-01f, -1.69222742e-01f,
  3.58594596e-01f, 2.49141976e-02f, -1.27947569e-01f, -7.82138109e-02f, -4.65285927e-02f, -3.02129924e-01f, -1.11751974e-01f, -1.10447496e-01f, -6.53001517e-02f, -4.88859229e-02f,
  2.16857418e-02f, -6.14954866e-02f, 7.04526544e-01f, -3.63656357e-02f, 3.05791907e-02f, -7.34017417e-02f, 4.26834047e-01f, -1.99930176e-01f, -6.66929856e-02f, -6.56719282e-02f,
  -8.87474567e-02f, 3.06255728e-01f, 1.14309460e-01f, -1.55090615e-01f, -6.09943978e-02f, -6.50584623e-02f, -3.24321866e-01f, 2.82192588e-01f, 1.13185868e-01f, 1.20179437e-01f,
  9.28084627e-02f, 1.61571071e-01f, 5.31120636e-02f, -3.50591421e-01f, 2.55464971e-01f, -4.06861633e-01f, -6.08624518e-01f, -2.90003657e-01f, 6.21158779e-01f, -2.77844936e-01f,
  -3.06701094e-01f, -2.44941503e-01f, -1.30220294e-01f, 3.34798008e-01f, 1.96855649e-01f, 4.85226452e-01f, -1.64536819e-01f, 5.64010032e-02f, 2.06319652e-02f, -2.51522782e-04f,
  -5.15744835e-03f, -1.38333276e-01f, -1.08018634e-03f, 1.67467281e-01f, -1.21186860e-01f, -1.57220140e-01f, -2.64332235e-01f, 4.82780673e-02f, -1.36745155e-01f, 1.05768546e-01f,
  -1.08999409e-01f, 2.22653851e-01f, -2.10411608e-01f, -1.77606508e-01f, 1.25120925e-02f, 6.62712872e-01f, 2.97253042e-01f, 1.79136954e-02f, -2.24366173e-01f, -2.29898170e-01f,
  1.48774728e-01f, 2.66804621e-02f, 6.92975044e-01f, -2.80382752e-01f, 6.61116540e-02f, -4.41953540e-02f, -9.16769579e-02f, -1.00716844e-01f, -1.85689792e-01f, -1.98662713e-01f,
  2.60285437e-01f, -9.90455598e-02f, 4.66338873e-01f, -3.89824152e-01f, -1.92900762e-01f, 1.33101657e-01f, 1.85626060e-01f, -4.72543120e-01f, 2.05202606e-02f, 2.40939364e-01f,
  1.81065381e-01f, 2.94829637e-01f, 1.23113371e-01f, 1.68584678e-02f, 4.60427165e-01f, 8.55818093e-02f, 1.10396668e-01f, -2.38537550e-01f, 2.23690033e-01f, 7.17000544e-01f,
  -1.66488513e-01f, 4.97201711e-01f, -1.42715827e-01f, 3.36659163e-01f, 3.99992079e-01f, 7.15380549e-01f, 3.59996617e-01f, 2.22643897e-01f, 4.53169793e-02f, -6.54322326e-01f,
  -2.07544863e-02f, -1.49863556e-01f, -2.10850343e-01f, -1.58757076e-01f, 3.46996225e-02f, 8.79465938e-02f, -9.40355211e-02f, -1.36706561e-01f, 7.03886002e-02f, -1.77749231e-01f,
  -4.33802187e-01f, -2.37758577e-01f, 8.86900425e-02f, -4.83937599e-02f, 5.09139746e-02f, 2.27610916e-01f, 3.33701342e-01f, -5.79167679e-02f, 6.18287586e-02f, -1.29997656e-01f,
  -1.11114383e-01f, -2.97227234e-01f, -1.16810277e-01f, 6.28338337e-01f, -2.22303361e-01f, 3.55540998e-02f, -1.02073394e-01f, 5.28525114e-02f, -1.11166976e-01f, -1.82410568e-01f,
  -2.11740986e-01f, 6.00994289e-01f, -2.20311671e-01f, 1.61422908e-01f, 4.38848995e-02f, 2.20973417e-01f, -9.14850309e-02f, -3.57143968e-01f, -1.09861150e-01f, -1.57217309e-01f,
  7.85792693e-02f, 2.30650534e-03f, 1.67996302e-01f, 1.13706127e-01f, 1.76325902e-01f, -4.06871724e-04f, -3.70628566e-01f, -4.89355102e-02f, -2.53794324e-02f, -1.43056855e-01f,
  1.59758683e-02f, 7.62693211e-02f, 3.11215550e-01f, -3.81791472e-01f, -4.98914570e-01f, -3.11599672e-01f, 2.71504354e-02f, 2.49459326e-01f, -4.25378591e-01f, -1.04380384e-01f,
  1.89463764e-01f, -2.87390590e-01f, 1.13045737e-01f, 1.43854007e-01f, 1.18912689e-01f, 5.55283189e-01f, -1.41231611e-01f, 1.03754178e-01f, -2.29480326e-01f, -1.20085888e-01f,
  -1.69243246e-01f, -1.59329355e-01f, -2.22031206e-01f, -9.77085978e-02f, 1.02888250e+00f, -1.38149261e-01f, -1.22392446e-01f, -1.20286971e-01f, -1.03793763e-01f, -1.63243681e-01f,
  -2.47101665e-01f, -3.54898781e-01f, 4.55178469e-02f, -1.44420058e-01f, 1.83717489e-01f, -2.27606967e-02f, 1.21360518e-01f, -1.05482735e-01f, -2.02481553e-01f, -2.17773363e-01f,
  -1.88641638e-01f, 2.72049401e-02f, -3.94545794e-02f, -2.60819733e-01f, 8.87136757e-02f, 5.18256463e-02f, -1.63546547e-01f, -1.27574146e-01f, -3.29499915e-02f, 8.99198651e-02f,
  -8.95241871e-02f, -2.63595909e-01f, 7.38406554e-02f, 1.72442138e-01f, -5.77884819e-03f, 3.67756516e-01f, 1.85507491e-01f, 2.57773936e-01f, 4.62176353e-02f, -5.42605042e-01f,
  7.81700481e-03f, -1.39959246e-01f, -3.79216000e-02f, 3.90313491e-02f, 8.71463344e-02f, 1.60462260e-01f, 3.24430950e-02f, -1.56424910e-01f, 2.27423385e-01f, 3.01200718e-01f,
  1.07760035e-01f, -5.44777334e-01f, 5.51888645e-02f, -5.99629104e-01f, -3.11615139e-01f, 1.44817248e-01f, -9.36899409e-02f, 6.83879435e-01f, -6.00953847e-02f, -7.24419281e-02f,
  3.32092911e-01f, -2.56604135e-01f, 3.06727558e-01f, -2.04683363e-01f, 3.82251948e-01f, -1.59092486e-01f, -4.01770085e-01f, -5.23853898e-02f, -2.34718129e-01f, -1.85905203e-01f,
  -2.01837972e-01f, -2.34030589e-01f, 5.88745356e-01f, 1.40033681e-02f, -1.11474983e-01f, -2.06458390e-01f, -1.86437801e-01f, 4.50496599e-02f, 4.13376875e-02f, -2.39967942e-01f,
  -1.77436680e-01f, 4.70341802e-01f, 4.83909287e-02f, -1.83759183e-01f, 1.16653234e-01f, -2.23264415e-02f, -1.63846299e-01f, -9.09711123e-02f, -9.57457200e-02f, -1.07890710e-01f,
  -1.00222409e-01f, 5.20652890e-01f, -2.51355559e-01f, -2.27255538e-01f, -6.96652234e-02f, 3.38121623e-01f, 1.54106682e-02f, -2.04676628e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.04486920e-01f, -3.12631764e-02f, 5.83787672e-02f, -8.99226815e-02f, -4.54584099e-02f, 1.05853111e-01f, 1.79108158e-02f, -4.20238599e-02f, 4.24410030e-02f, 1.04177289e-01f,
  -7.39527494e-02f, 1.22449979e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    