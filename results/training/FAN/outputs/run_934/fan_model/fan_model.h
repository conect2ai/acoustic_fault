/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.24241792e-01f, 2.83916970e-03f, 7.94692198e-04f, 1.61127225e-01f, 7.02825263e-02f, -5.47213992e-03f, 1.03477456e-01f, 3.06719262e-02f, -1.35009717e-02f, 7.88490176e-02f,
  8.21591169e-02f, 8.92711282e-02f, 6.97604120e-02f, 3.64965983e-02f, 9.90943052e-03f, -1.39917117e-02f, -4.77837548e-02f, 2.50623208e-02f, -1.34266287e-01f, 2.43616477e-02f,
  2.80238446e-02f, -7.32466131e-02f, 8.72772001e-03f, -1.14954159e-01f, 8.35747346e-02f, 4.19563763e-02f, 3.22546847e-02f, 8.44898894e-02f, 3.39261629e-02f, 2.33996287e-02f,
  1.36530310e-01f, 9.47355404e-02f, 2.84307376e-02f, -1.47436485e-02f, 4.26198207e-02f, 5.74105419e-02f, 8.15239474e-02f, 1.24917477e-02f, -6.23763390e-02f, -2.62214639e-03f,
  -1.98223107e-02f, -2.34043635e-02f, -6.97278976e-02f, -7.18562156e-02f, 4.02813405e-02f, -5.03569543e-02f, 3.40842013e-03f, -3.50955985e-02f, -1.67374872e-02f, 2.14773770e-02f,
  2.76264995e-02f, -1.07505703e-02f, 4.43295985e-02f, -4.77692299e-02f, -6.79804236e-02f, 6.15065061e-02f, 3.06162834e-02f, 7.38567039e-02f, 3.76174808e-04f, 7.54208863e-02f,
  -6.57152310e-02f, 9.91308242e-02f, 1.02721974e-02f, 1.93205979e-02f, -5.21823727e-02f, -2.26470344e-02f, -5.14660515e-02f, -4.88148555e-02f, -9.06997640e-03f, 4.66140732e-02f,
  1.56768952e-02f, 7.27742314e-02f, 9.23566818e-02f, -2.48466954e-02f, 5.08570299e-02f, -3.94846983e-02f, -4.60546762e-02f, -3.55675481e-02f, 2.31471565e-02f, -3.39484513e-02f,
  -2.91947648e-02f, -7.66714513e-02f, 6.47297055e-02f, 8.15563893e-04f, 3.90032530e-02f, -2.41366196e-02f, 4.81211627e-03f, -4.35928851e-02f, 9.53271613e-02f, -3.43803465e-02f,
  7.65472353e-02f, -1.51129663e-01f, 4.60247621e-02f, -2.50366852e-02f, 1.04136929e-01f, -2.72585787e-02f, -4.39459831e-02f, 3.32093611e-02f, -8.11547711e-02f, 8.18448663e-02f,
  7.05498457e-02f, 8.75360239e-03f, -5.93727082e-02f, -3.73120084e-02f, 3.94940823e-02f, 4.37621213e-02f, -6.84361160e-02f, -3.28290015e-02f, -3.95458303e-02f, 7.32057020e-02f,
  -4.02715476e-03f, 8.43355339e-03f, 1.25787303e-01f, 7.60529516e-03f, -2.44713593e-02f, 7.06591904e-02f, 2.60770284e-02f, 7.84535781e-02f, -4.54666950e-02f, -1.26632722e-02f,
  1.60209432e-01f, -9.67880115e-02f, -1.36436418e-01f, 4.41379845e-02f, -1.41577944e-01f, -1.31416008e-01f, -2.75033236e-01f, -3.63979600e-02f, 1.43428102e-01f, 3.54981907e-02f,
  6.94128647e-02f, 1.26327872e-01f, 2.22598448e-01f, 3.94397154e-02f, -1.42999785e-02f, -1.93657324e-01f, -1.85643673e-01f, -2.08742986e-03f, 2.34897509e-01f, 2.19864920e-02f,
  1.18412571e-02f, 1.12926073e-01f, 1.04803346e-01f, 1.36735722e-01f, -4.30675112e-02f, 9.62984003e-03f, -5.90441655e-03f, 3.72015983e-02f, -1.24497563e-01f, -5.06469943e-02f,
  9.41598639e-02f, -1.07667461e-01f, 6.77236170e-02f, -1.59882475e-02f, -2.11191438e-02f, 1.68737001e-03f, -7.89531693e-03f, 9.17666778e-02f, 2.50081755e-02f, -8.07463191e-03f,
  3.71876918e-03f, -2.86462940e-02f, -6.00710772e-02f, 2.82120984e-03f, -7.22302422e-02f, -3.65969017e-02f, -5.47521599e-02f, 3.90560813e-02f, 2.82940567e-02f, -3.36555690e-02f,
  -1.58382189e-02f, -9.94303748e-02f, -1.25003725e-01f, -6.17888495e-02f, -5.20003922e-02f, 5.34235267e-03f, -5.90137653e-02f, -1.00955755e-01f, 2.75032893e-02f, -5.44615760e-02f,
  -5.02539240e-02f, 5.94689995e-02f, -1.13956053e-02f, 3.42468768e-02f, -4.11649272e-02f, -1.77622528e-03f, -3.35144326e-02f, -2.48117317e-02f, -4.60844748e-02f, 9.04692896e-03f,
  -4.15787622e-02f, 5.49127869e-02f, 1.77441016e-02f, 3.31337638e-02f, 3.11557436e-03f, 5.17982282e-02f, -7.65137095e-03f, 6.99637309e-02f, 1.40497014e-02f, -4.47746441e-02f,
  -3.22826616e-02f, 1.28711609e-03f, 1.06100191e-03f, -3.60683389e-02f, -6.08362118e-03f, -6.26363754e-02f, 4.33306471e-02f, 9.46536884e-02f, 6.30566385e-03f, -4.62460965e-02f,
  2.05785930e-01f, -1.08796336e-01f, -2.69995723e-02f, 8.68486613e-02f, -3.94697227e-02f, 4.29892279e-02f, -3.00139692e-02f, -6.38559507e-03f, 5.79902902e-02f, 6.70100749e-02f,
  -9.62677673e-02f, -6.78321160e-03f, -1.38472812e-02f, 5.58963381e-02f, 1.76872015e-02f, -2.53848508e-02f, -7.68567026e-02f, -5.37205487e-02f, 2.96672210e-02f, 3.59222405e-02f,
  -4.08214852e-02f, 1.21484771e-02f, 3.35413441e-02f, 7.71830902e-02f, 6.37758747e-02f, 9.69091952e-02f, 3.90174575e-02f, 1.16406791e-02f, 5.15400358e-02f, 3.34338658e-02f,
  -1.53607979e-01f, -1.30362257e-01f, -2.76131034e-01f, 1.35549512e-02f, -4.51019034e-03f, -1.10032313e-01f, 9.54151899e-03f, 1.15457270e-02f, 8.86373594e-02f, 7.51568452e-02f,
  6.21726029e-02f, 2.54160799e-02f, -2.83998251e-02f, 2.93085687e-02f, -5.50618628e-03f, -4.01949845e-02f, -1.33497193e-02f, -1.19574510e-01f, -3.89575697e-02f, 7.97542483e-02f,
  1.25884548e-01f, 4.44963090e-02f, -1.93156097e-02f, -6.24477267e-02f, 3.95210423e-02f, 1.22062247e-02f, 1.15983877e-02f, 5.43645397e-02f, -3.84563021e-02f, 6.86449483e-02f,
  -7.38000572e-02f, -1.02964036e-01f, -6.70727789e-02f, 8.68073851e-02f, -2.27070116e-02f, -8.25423934e-03f, 3.24871913e-02f, -2.53895298e-02f, 9.95334424e-03f, -1.22264221e-01f,
  1.59729924e-02f, 1.67860347e-03f, 2.37348843e-02f, 4.89964075e-02f, -8.76215994e-02f, -8.70830938e-02f, -1.05146058e-01f, -1.60288870e-01f, -1.63826883e-01f, -4.98594940e-02f,
  8.52047950e-02f, 5.44625446e-02f, -7.56047964e-02f, -1.26646817e-01f, -6.81637228e-02f, -6.76326230e-02f, -4.84282710e-02f, -7.06273094e-02f, -5.73358200e-02f, -3.82731145e-04f,
  2.45034248e-02f, 3.52753326e-02f, -6.90526217e-02f, -6.75742403e-02f, -6.16187751e-02f, 8.93483385e-02f, -7.81880841e-02f, 2.89211683e-02f, -7.66339675e-02f, -1.92739889e-02f,
  1.11575276e-02f, 3.19007114e-02f, -2.31219940e-02f, -1.75226177e-03f, 3.01913321e-02f, -3.82434987e-02f, -7.01919869e-02f, -2.71096677e-02f, -5.09489030e-02f, -1.59422737e-02f,
  9.10162646e-03f, -5.56662343e-02f, -2.56998893e-02f, -4.53796983e-02f, 2.47913487e-02f, -4.85458551e-03f, 4.40438166e-02f, -3.67050767e-02f, -2.15910487e-02f, 2.80814674e-02f,
  1.40935108e-01f, 3.22533697e-02f, 8.27885494e-02f, -8.24204460e-03f, -6.30759895e-02f, 3.76218781e-02f, -5.11344746e-02f, 2.08642264e-03f, -9.94585548e-03f, 5.58218546e-02f,
  -1.27515243e-02f, -2.01632921e-02f, 4.95590083e-02f, 8.35354254e-03f, 4.73514013e-02f, 4.61138263e-02f, 7.20460862e-02f, 3.62733961e-03f, -1.89815052e-02f, -6.84547201e-02f,
  1.08201336e-02f, -8.79676193e-02f, -1.97491422e-02f, 1.77923534e-02f, -8.51584375e-02f, -1.33600375e-02f, -8.80972520e-02f, -1.75724849e-02f, -1.42729804e-01f, -5.22438698e-02f,
  -1.09812640e-01f, 4.61373624e-04f, 1.05235822e-01f, -6.53217658e-02f, -7.68251047e-02f, -2.07943335e-01f, -3.14138204e-01f, -1.96847152e-02f, 5.54606952e-02f, -1.17158838e-01f,
  -9.28938538e-02f, -3.26074585e-02f, 1.80941410e-02f, 5.25073484e-02f, -6.04167022e-02f, -2.55790129e-02f, -3.41007635e-02f, 1.27476320e-01f, 2.31894068e-02f, 2.81108618e-02f,
  -2.02933722e-03f, -6.25353605e-02f, -3.71793844e-02f, 6.65690750e-02f, 6.46186545e-02f, 7.70037621e-02f, -2.78761648e-02f, 1.16109177e-01f, 5.41503839e-02f, 2.13725448e-01f,
  1.06417753e-01f, 5.65006286e-02f, -2.61115376e-03f, 6.44372925e-02f, 3.56116183e-02f, 1.12372935e-02f, -2.32927557e-02f, 1.09241165e-01f, 6.84264451e-02f, -3.84083577e-02f,
  -5.22413366e-02f, 2.52766348e-02f, 5.67649007e-02f, 2.26545390e-02f, 7.08168522e-02f, 2.36673467e-02f, 2.68314546e-03f, 8.72203242e-03f, -2.74813119e-02f, 6.18408397e-02f,
  4.39524315e-02f, -6.44200593e-02f, -1.30715609e-01f, -3.36821191e-02f, 3.70288976e-02f, -2.39368901e-02f, 6.05309010e-02f, 6.51128441e-02f, 1.12374229e-02f, -4.68725041e-02f,
  -4.12320830e-02f, -1.00337518e-02f, 4.46893349e-02f, -2.32731029e-02f, 2.07225811e-02f, 4.18369770e-02f, -1.67053528e-02f, -4.52605337e-02f, -2.50077527e-02f, 5.98543733e-02f,
  -1.94619223e-02f, -4.96793985e-02f, 3.04285716e-02f, -6.05289533e-04f, 6.80820048e-02f, 7.05729127e-02f, -1.75400227e-02f, 4.22737710e-02f, -4.23764437e-02f, 7.81066203e-03f,
  -4.32953471e-03f, -3.24280784e-02f, 4.66708019e-02f, 6.82293922e-02f, 7.09687695e-02f, -9.17891692e-03f, 7.59319589e-02f, 2.15302804e-04f, -4.96591181e-02f, -2.88041472e-03f,
  -8.28060601e-03f, -1.20968424e-01f, 2.57760892e-03f, -6.61697909e-02f, -2.08948590e-02f, -7.42416503e-03f, 3.57470550e-02f, -1.92964450e-02f, 6.19332567e-02f, -4.89096567e-02f,
  -7.27603491e-03f, -7.27705881e-02f, -1.14178360e-01f, -1.45009747e-02f, -1.35715485e-01f, -5.01757301e-03f, -1.39352694e-01f, -4.46576066e-02f, 2.12029666e-02f, -1.94629207e-02f,
  -6.01345971e-02f, -1.29514471e-01f, -2.17606589e-01f, -3.12386174e-02f, 2.18192078e-02f, -1.32003173e-01f, -9.76155773e-02f, -3.44719328e-02f, -6.33008555e-02f, -2.37428904e-01f,
  -1.73227578e-01f, -8.73674266e-03f, 1.83108763e-03f, 1.15284221e-02f, 1.71360433e-01f, 2.19951615e-01f, 2.91426808e-01f, 1.29078031e-01f, -5.51178269e-02f, 8.76258388e-02f,
  4.99039777e-02f, -1.11300042e-02f, -7.24271387e-02f, -1.04757480e-01f, 1.29370969e-02f, 1.00222873e-02f, 6.95045069e-02f, -1.55312598e-01f, -6.10606931e-02f, 2.44101882e-03f,
  2.58711986e-02f, 5.17304055e-02f, -4.91245203e-02f, -1.08895130e-01f, -1.05295647e-02f, -1.47738189e-01f, -1.01362228e-01f, -7.53140152e-02f, 8.90355930e-03f, -1.84364870e-01f,
  -2.91026950e-01f, -5.83478846e-02f, -5.82153983e-02f, -2.16132086e-02f, 7.38827139e-02f, -2.15229280e-02f, 4.14706543e-02f, -2.50867903e-02f, -6.44410402e-03f, -5.85310720e-02f,
  -7.71238580e-02f, -4.81678918e-02f, 6.50403649e-03f, -3.60484794e-02f, -2.55616195e-02f, -1.70243643e-02f, -3.59374732e-02f, -8.82036239e-02f, -9.25576314e-02f, -3.07292268e-02f,
  1.39300069e-02f, -1.33958766e-02f, 5.18562160e-02f, 1.57747008e-02f, 7.18527706e-03f, 3.75159904e-02f, 1.03163347e-01f, 3.13081630e-02f, 9.14414823e-02f, -1.16422512e-01f,
  2.23094150e-02f, 2.14764774e-02f, 6.38565347e-02f, -2.40191482e-02f, -2.45530009e-02f, -4.01679985e-03f, 3.61757614e-02f, -7.01768994e-02f, 8.51686448e-02f, -3.17652412e-02f,
  4.31215651e-02f, -2.00186055e-02f, -5.43683246e-02f, -6.54879361e-02f, -8.80220607e-02f, -2.39845971e-03f, 2.48538330e-02f, 8.82613845e-03f, -3.80490460e-02f, 4.17784192e-02f,
  -7.11004585e-02f, -3.56412530e-02f, 3.92547622e-02f, -4.63817269e-02f, -2.65231449e-02f, -8.58894810e-02f, -4.86732461e-02f, 2.10054051e-02f, -1.38909537e-02f, 8.65727887e-02f,
  -6.11401908e-02f, 7.43304417e-02f, 2.54039722e-03f, -3.86754535e-02f, 5.86578436e-02f, 5.84160425e-02f, -9.63191837e-02f, -1.68972053e-02f, 4.16513085e-02f, -5.67166321e-02f,
  -1.77919343e-02f, -7.75409341e-02f, -6.75797909e-02f, 6.13870732e-02f, -4.81450409e-02f, 1.67810842e-02f, 6.02463745e-02f, -8.50191712e-02f, 3.69484574e-02f, -3.02664600e-02f,
  -1.71377640e-02f, -1.38624562e-02f, -2.11809520e-02f, 2.62227524e-02f, 1.01360090e-01f, 4.89601791e-02f, -9.26613957e-02f, -3.37796099e-02f, 7.95783922e-02f, 5.24366274e-02f,
  -1.77350268e-01f, 5.49918450e-02f, 1.14069343e-01f, -5.76060005e-02f, -5.77644780e-02f, 1.18309855e-01f, 1.83398686e-02f, 1.00231823e-02f, -8.86698365e-02f, 4.49335352e-02f,
  -2.62348983e-03f, -8.93236995e-02f, -2.71445252e-02f, 2.42402144e-02f, 4.72680666e-02f, 1.03482358e-01f, 7.50059187e-02f, -5.59969172e-02f, -1.18086934e-01f, -1.22541085e-01f,
  -1.28832743e-01f, -1.32800087e-01f, -1.65778279e-01f, -5.38932392e-03f, -5.94226420e-02f, -9.98237357e-03f, 2.35951762e-03f, -8.39147344e-02f, 3.73542346e-02f, -1.50987580e-01f,
  2.56597158e-02f, 4.08123247e-02f, -6.12377338e-02f, -6.37236089e-02f, -6.83154836e-02f, -1.07669840e-02f, -2.35823151e-02f, -5.48796356e-02f, 2.57893056e-02f, -5.69324195e-02f,
  8.68664763e-04f, 4.09264467e-04f, -4.69937958e-02f, 1.12475557e-02f, 1.05713960e-02f, -3.73806581e-02f, 2.61374209e-02f, -7.11795613e-02f, -6.44219741e-02f, 8.55807737e-02f,
  -9.99426991e-02f, 8.41895938e-02f, 2.07140073e-02f, 1.12520225e-01f, 5.51526882e-02f, 5.37480600e-02f, 1.06332429e-01f, -7.66732544e-02f, 1.12165287e-01f, 7.27963448e-02f,
  -5.65643609e-02f, 7.66559318e-02f, 4.03803624e-02f, -1.64843686e-02f, -3.74502987e-02f, 1.48781191e-03f, 3.17018963e-02f, -5.04421815e-02f, -1.01855043e-02f, 7.87683874e-02f,
  1.34386308e-02f, -1.11866370e-02f, 7.46297985e-02f, -1.95743190e-03f, -7.28720427e-02f, 4.41522375e-02f, 5.66539094e-02f, -6.63020164e-02f, 4.52551655e-02f, -8.56144428e-02f,
  3.59009691e-02f, -3.21988985e-02f, 6.83443770e-02f, -4.82789353e-02f, 5.54153062e-02f, -6.21081516e-02f, 1.03879571e-02f, -3.09197791e-02f, -8.68443027e-02f, -9.74893272e-02f,
  8.24654009e-03f, 3.45561467e-02f, -4.38875258e-02f, -2.70829629e-02f, 1.09699741e-02f, 6.52992353e-02f, 6.01938330e-02f, -3.99455801e-02f, -3.22317481e-02f, -1.03862339e-03f,
  -1.79064572e-02f, -3.55727412e-02f, -8.61766562e-02f, 2.51269490e-02f, -7.08597973e-02f, -5.64528629e-02f, -5.07069640e-02f, -3.78187187e-02f, -2.36057732e-02f, 9.33258142e-03f,
  5.30111778e-04f, 8.55157599e-02f, -2.36772932e-02f, 6.17000759e-02f, 8.14088434e-02f, -9.67177749e-02f, 1.87829137e-02f, -4.72322572e-03f, 2.72577889e-02f, 7.48329982e-02f,
  2.51824230e-01f, 1.71795622e-01f, -1.37184918e-01f, -9.78401378e-02f, 2.72541940e-02f, 8.81143361e-02f, 9.68827233e-02f, -3.19090416e-03f, -1.50112640e-02f, 8.54591727e-02f,
  1.57436147e-01f, 4.86676134e-02f, 7.56305456e-03f, -5.80640836e-03f, 1.18402906e-01f, 1.29651576e-02f, -1.05730817e-03f, -9.60937366e-02f, -1.02677740e-01f, -9.75032300e-02f,
  -1.50940334e-02f, -9.77580249e-02f, 6.91851676e-02f, 1.50848292e-02f, 1.22453424e-03f, -9.22028646e-02f, -1.03194803e-01f, 3.59116979e-02f, 8.46723542e-02f, -1.23858370e-01f,
  -1.01440668e-01f, 1.66360736e-01f, -7.23398402e-02f, 3.65993604e-02f, 4.71245944e-02f, 1.12724956e-02f, -5.94524248e-03f, 1.60302185e-02f, -2.62584556e-02f, -9.06738266e-02f,
  7.43404031e-02f, 5.21169230e-02f, 2.17158403e-02f, -2.70203911e-02f, -5.83724491e-02f, -1.19421907e-01f, -1.26621395e-01f, -6.57796115e-02f, -6.52149767e-02f, 4.47020158e-02f,
  9.92054939e-02f, 4.93211001e-02f, 1.10200167e-01f, 4.93351184e-02f, 7.68186152e-02f, 7.78138191e-02f, -3.50602455e-02f, 6.60089478e-02f, 9.96619686e-02f, -8.35841671e-02f,
  5.72852185e-03f, 6.76043779e-02f, 2.58123856e-02f, -6.99826181e-02f, 5.95494471e-02f, 2.69523542e-02f, -4.51544672e-03f, 2.22759675e-02f, -6.14042692e-02f, -5.85337617e-02f,
  5.44192083e-02f, -3.97339091e-02f, -6.01175521e-03f, -6.94022402e-02f, 7.31344596e-02f, -3.39716561e-02f, -9.55520291e-03f, -5.22684641e-02f, 3.45561355e-02f, 1.31392693e-02f,
  -4.32548672e-02f, -4.28131111e-02f, 2.51610614e-02f, -1.58222076e-02f, 6.44730031e-02f, -1.10339755e-02f, 2.99465861e-02f, 3.98843810e-02f, -8.79797190e-02f, 2.37911884e-02f,
  1.77574679e-02f, 1.46518275e-01f, -4.35087979e-02f, -1.02929711e-01f, -8.74455795e-02f, -6.04630671e-02f, 6.60822988e-02f, 3.69161256e-02f, -2.99202255e-03f, -9.81092975e-02f,
  4.59944122e-02f, -3.77466269e-02f, -3.10347322e-02f, -9.85529274e-02f, 1.29882004e-02f, 4.85873409e-02f, -2.56515313e-02f, -1.65538937e-02f, 7.16407299e-02f, -1.00834250e-01f,
  1.47281755e-02f, 5.09380624e-02f, 6.79776594e-02f, 9.24014207e-03f, 6.26419932e-02f, 9.58411470e-02f, -3.66806127e-02f, -9.76592824e-02f, 4.57796268e-02f, -1.74432062e-02f,
  -3.07762086e-01f, -5.13185002e-02f, -1.24213159e-01f, 9.04840068e-04f, -3.94776613e-02f, -6.09959885e-02f, -7.74355009e-02f, 4.88963127e-02f, 3.06344591e-02f, 5.82219027e-02f,
  4.09790725e-02f, -1.22441454e-02f, -4.50966209e-02f, -6.18000701e-02f, -6.33868799e-02f, -1.74349789e-02f, -1.49012908e-01f, -4.23199758e-02f, -4.73221345e-03f, -9.53988358e-02f,
  -3.29587720e-02f, 2.46609896e-02f, -1.33129701e-01f, 2.10702196e-02f, 6.20424412e-02f, 1.29030481e-01f, 2.00962760e-02f, -7.29054511e-02f, -3.90947014e-02f, -4.77899201e-02f,
  6.73400834e-02f, 5.57061471e-02f, -5.84540442e-02f, 1.47243636e-02f, 1.09701067e-01f, -3.51030603e-02f, -4.87584509e-02f, 5.77242970e-02f, -1.18660145e-02f, 3.58885247e-03f,
  7.01955855e-02f, -2.24844888e-02f, 1.76323261e-02f, -3.92227396e-02f, -7.38983676e-02f, -9.41100642e-02f, -8.50656852e-02f, -2.13315319e-02f, 3.70443910e-02f, -7.90000483e-02f,
  7.28939427e-03f, -6.15853406e-02f, 1.72134247e-02f, 1.03417516e-01f, 3.58147025e-02f, -9.55343544e-02f, 1.52779138e-02f, 3.55357975e-02f, 4.70030010e-02f, 2.09945459e-02f,
  -6.97523803e-02f, -4.65036593e-02f, -4.00176905e-02f, -3.12593346e-03f, -3.85591947e-02f, -2.04097573e-02f, -2.74971481e-02f, 5.99967577e-02f, 2.28320006e-02f, 5.22529595e-02f,
  9.30550396e-02f, -3.13309096e-02f, -1.34094469e-02f, 9.71978232e-02f, 8.13692808e-02f, -1.54289957e-02f, 6.06478453e-02f, -4.89257276e-02f, 5.57729676e-02f, -4.66061309e-02f,
  -7.15411231e-02f, 2.82911747e-03f, 1.02381542e-01f, -2.06977390e-02f, -4.47639711e-02f, -8.54176134e-02f, 2.75842287e-02f, 1.15899807e-02f, -1.00657651e-02f, 2.15489995e-02f,
  1.69803783e-01f, -8.41985494e-02f, -8.30214620e-02f, -8.47083628e-02f, -5.85390767e-03f, 7.76860416e-02f, 5.02732284e-02f, -6.32333234e-02f, -5.46962172e-02f, -2.41369810e-02f,
  -1.36420587e-02f, 6.05530851e-02f, 1.36679020e-02f, -4.39200588e-02f, -6.27005473e-02f, -5.04463762e-02f, -9.30198375e-03f, -1.08634084e-01f, 6.63947314e-02f, -6.01802506e-02f,
  2.43157949e-02f, -1.40650883e-01f, -1.26424447e-01f, -6.64184391e-02f, -2.88861636e-02f, -2.95493696e-02f, 5.33732548e-02f, -1.58272330e-02f, -3.64136696e-02f, -4.63247597e-02f,
  -5.67963859e-03f, 1.68922752e-01f, -6.66494519e-02f, 1.89509705e-01f, 4.67319787e-02f, 1.18062109e-01f, 8.40990916e-02f, 4.46923450e-02f, 6.21353313e-02f, 1.41290173e-01f,
  3.97973508e-02f, 4.45216149e-02f, 6.23845644e-02f, -1.07584007e-01f, -1.35330379e-01f, 4.87347655e-02f, 9.14239138e-02f, -4.54015061e-02f, -2.91319154e-02f, 4.51167440e-03f,
  1.41294494e-01f, 5.85707873e-02f, 5.07288277e-02f, -8.89480785e-02f, 3.73404324e-02f, 5.50277419e-02f, 2.49279086e-02f, 1.17785364e-01f, -2.36903168e-02f, 1.57996893e-01f,
  3.02531067e-02f, -1.31588548e-01f, -1.36347294e-01f, 8.91285166e-02f, 3.32605951e-02f, -4.07881774e-02f, 7.98749104e-02f, -3.04955486e-02f, 1.01096714e-02f, 6.08873032e-02f,
  -7.48654976e-02f, -4.86994013e-02f, -2.13459488e-02f, -3.50280702e-02f, -5.19497022e-02f, 2.31987070e-02f, -2.59122532e-02f, 1.52105633e-02f, -3.28835174e-02f, 1.35012930e-02f,
  1.49580806e-01f, 7.08343415e-03f, 4.57472391e-02f, -6.78000972e-02f, 4.92667556e-02f, -7.79744238e-02f, -9.97995259e-04f, -9.22148377e-02f, -1.39743373e-01f, 1.01353794e-01f,
  -7.78461546e-02f, 1.47992056e-02f, 2.77540889e-02f, 1.66579038e-02f, -3.20861191e-02f, -1.29873976e-02f, -1.01866804e-01f, -6.36542365e-02f, 6.03966974e-02f, -5.26797995e-02f,
  -7.19766766e-02f, -7.29771033e-02f, 3.50658260e-02f, -4.24638949e-02f, 6.03328575e-04f, 3.67392786e-02f, 5.15903756e-02f, -5.81368804e-02f, -2.98035629e-02f, 2.46084225e-03f,
  5.56021789e-03f, -1.13633573e-01f, 5.58301993e-02f, 1.59250498e-02f, -2.36168597e-02f, 5.11180498e-02f, -6.79749325e-02f, -9.72582027e-03f, 4.26708162e-02f, 3.94596644e-02f,
  -3.07179727e-02f, -2.34834164e-01f, 4.89984825e-02f, 6.41200766e-02f, 3.29857692e-02f, -6.51420653e-03f, 8.19511712e-02f, -2.93642860e-02f, 5.71652725e-02f, -2.23431382e-02f,
  -3.86127234e-02f, -8.25755075e-02f, 1.70627446e-03f, -6.54954463e-02f, 6.73782080e-02f, -2.16871686e-02f, 4.94146682e-02f, 8.86279419e-02f, -1.40381157e-02f, 3.38764265e-02f,
  1.87631771e-02f, 5.23315519e-02f, 8.16664770e-02f, 6.18232340e-02f, -7.85806030e-03f, -3.53028812e-03f, -5.83002865e-02f, 8.04426596e-02f, 3.21479104e-02f, 1.19982973e-01f,
  -1.42080337e-02f, -8.82591978e-02f, -3.51016432e-01f, 5.41350916e-02f, -7.66160414e-02f, 9.00673792e-02f, 9.08289179e-02f, 1.12968139e-01f, 6.05810024e-02f, -3.71579230e-02f,
  1.98026933e-02f, 1.91702664e-01f, 1.73855256e-02f, 1.37525126e-01f, 7.76113048e-02f, 5.85748057e-04f, -1.53988868e-01f, -1.48549914e-01f, -5.76205878e-03f, 8.81170407e-02f,
  1.57541633e-01f, -5.84651483e-03f, 4.05924954e-02f, 8.85635838e-02f, 1.71379037e-02f, 1.10248499e-01f, -1.69709146e-01f, -1.04205109e-01f, 1.64404400e-02f, -1.88501090e-01f,
  -2.47600377e-01f, -2.56218538e-02f, -1.45455496e-02f, 9.35998783e-02f, -1.00779988e-01f, -3.13967168e-02f, -2.52309665e-02f, -1.53192446e-01f, -9.41085294e-02f, 6.47205561e-02f,
  -5.47531955e-02f, 8.25564638e-02f, -7.89542571e-02f, 9.97481681e-03f, -8.36280510e-02f, -3.57144102e-02f, 6.22206694e-03f, -7.60799870e-02f, 5.27535938e-02f, 1.83174538e-03f,
  5.04397824e-02f, 2.47977991e-02f, -5.75505383e-02f, -3.60888988e-02f, 6.91150129e-02f, -5.13669141e-02f, 4.64078076e-02f, 5.27501069e-02f, 6.75227642e-02f, 9.83017869e-03f,
  1.52114155e-02f, -6.66433424e-02f, -3.92740816e-02f, 8.24288428e-02f, 7.74233788e-02f, -1.02234520e-01f, -4.61383238e-02f, 3.58595476e-02f, 1.34273991e-02f, -2.00292207e-02f,
  9.99533683e-02f, -3.73911820e-02f, -1.50238932e-03f, 3.74102704e-02f, -3.05507537e-02f, -7.11772814e-02f, -2.80690975e-02f, -2.91560218e-02f, 8.09933692e-02f, -4.90922295e-02f,
  1.20467758e-02f, 3.48844565e-02f, -2.56901067e-02f, 4.52987803e-03f, -4.10635676e-03f, -7.87949711e-02f, 2.76543498e-02f, 5.16967326e-02f, 2.04654336e-02f, -2.16078595e-03f,
  1.70561783e-02f, -7.08469003e-02f, -2.07571294e-02f, 3.31560373e-02f, -1.13457732e-01f, 3.76805812e-02f, -6.43146187e-02f, -5.07783331e-02f, 3.61025776e-03f, 4.74369107e-03f,
  8.54148641e-02f, 5.70483841e-02f, 5.20506762e-02f, -7.68340826e-02f, 7.32437074e-02f, 1.83261819e-02f, -6.50127158e-02f, 4.48430888e-02f, -1.55050522e-02f, 8.47758949e-02f,
  -1.11961523e-02f, -2.07448490e-02f, 4.17848453e-02f, 8.47782120e-02f, 7.01797195e-03f, 9.85772535e-02f, -1.03542350e-01f, -3.64271440e-02f, -6.75146058e-02f, -7.11630564e-03f,
  -5.36997877e-02f, 2.25585669e-01f, 1.42353743e-01f, 7.92686045e-02f, 1.03571318e-01f, -7.83387199e-02f, -8.99982303e-02f, 2.81389989e-03f, -6.36542216e-03f, -5.38844503e-02f,
  5.01820147e-02f, -8.62698182e-02f, 6.19765781e-02f, -2.25840393e-03f, 5.84906293e-03f, 4.46253531e-02f, 5.97990043e-02f, -6.83557391e-02f, -9.59836394e-02f, 4.65611136e-03f,
  -6.27284423e-02f, -4.83427010e-02f, -1.06254397e-02f, 7.05127977e-03f, 9.79764313e-02f, 6.62272871e-02f, 1.69583827e-01f, 3.34193520e-02f, 2.19132621e-02f, 7.52749965e-02f,
  5.32066599e-02f, 6.65557683e-02f, -1.27125531e-02f, 3.32469717e-02f, 2.28485595e-02f, -5.08845113e-02f, -2.71287393e-02f, 7.30213430e-03f, 5.54837175e-02f, 4.53875866e-03f,
  1.09774090e-01f, -5.21949567e-02f, 8.00765678e-02f, -7.64992740e-03f, 5.58852032e-02f, -3.00651230e-02f, 8.53046253e-02f, 1.96667053e-02f, -7.20902765e-03f, 5.91241755e-02f,
  -3.40218358e-02f, 1.19240224e-01f, -2.35700663e-02f, -5.63235730e-02f, 8.43731593e-03f, 3.66786756e-02f, 5.37469145e-03f, 5.27551174e-02f, -5.70242293e-02f, -3.38676050e-02f,
  -2.59903092e-02f, -5.66312158e-03f, -5.14989980e-02f, 9.95476451e-03f, -8.69932324e-02f, 6.23077108e-03f, 4.14998680e-02f, 4.62998413e-02f, -9.58840102e-02f, 9.81478021e-02f,
  2.62035970e-02f, 3.35185230e-02f, -7.54971663e-03f, -1.13321841e-03f, 8.70444030e-02f, 4.74540628e-02f, -3.31150889e-02f, 6.24137372e-02f, -2.82558799e-02f, 4.06827927e-02f,
  -7.87801668e-02f, -3.05013228e-02f, 6.44224361e-02f, 2.95057129e-02f, -2.81841885e-02f, -3.04359421e-02f, -3.86854038e-02f, -5.20459451e-02f, -5.29024564e-02f, 5.35897240e-02f,
  7.76339099e-02f, -1.19938426e-01f, -4.47014347e-02f, -1.00322179e-01f, 7.63063580e-02f, -4.68661003e-02f, -3.93173173e-02f, 7.13391826e-02f, -5.34060337e-02f, 1.51348505e-02f,
  -7.90965464e-03f, 3.26198637e-02f, 7.98418894e-02f, -6.05460815e-02f, 3.37375551e-02f, -7.11174309e-02f, -3.10544539e-02f, 5.98085672e-02f, 2.30904110e-02f, 5.92917800e-02f,
  3.17333415e-02f, -7.26278201e-02f, -1.49780422e-01f, -9.05258507e-02f, 2.09570513e-03f, -7.29664117e-02f, -7.02007115e-02f, -1.26320243e-01f, -9.74793434e-02f, -3.82948034e-02f,
  1.60724714e-01f, 1.50152117e-01f, -8.15411955e-02f, -1.48890009e-02f, 8.75946060e-02f, 1.28086105e-01f, 5.46840765e-02f, 1.12016857e-01f, -1.84305459e-02f, 8.08659047e-02f,
  1.29834980e-01f, -3.81386024e-03f, -6.05544783e-02f, 9.48492531e-03f, 1.73130892e-02f, 6.25105798e-02f, 5.64086102e-02f, 2.58934032e-02f, -8.43778178e-02f, -5.77739067e-02f,
  -5.99938631e-02f, -6.87808394e-02f, 6.39783368e-02f, 3.17985266e-02f, 6.57810569e-02f, -4.74794321e-02f, -5.71177863e-02f, -8.49642679e-02f, -3.51338722e-02f, 7.02016205e-02f,
  -6.88588694e-02f, 2.99381278e-02f, -9.52562317e-02f, 3.47763523e-02f, -6.52006567e-02f, 1.34259195e-03f, -9.58165601e-02f, -8.04114640e-02f, 8.19883645e-02f, -5.39531559e-02f,
  -4.71425317e-02f, -6.47389970e-04f, -7.19953924e-02f, 3.60921212e-02f, 1.00532537e-02f, 1.09796405e-01f, 9.47414190e-02f, -4.78325076e-02f, 1.66830942e-02f, 7.62402192e-02f,
  2.11600717e-02f, 1.19077072e-01f, 3.67827783e-03f, 8.66505727e-02f, 7.75913000e-02f, 8.60038176e-02f, -2.47854292e-02f, -4.50980850e-02f, -5.68072088e-02f, -1.12329405e-02f,
  -5.39132999e-03f, -2.52055209e-02f, 6.97853863e-02f, -6.17434196e-02f, 6.16695657e-02f, 7.40108490e-02f, -1.40759563e-02f, 7.59738013e-02f, 9.00758132e-02f, -4.36556116e-02f,
  -2.00920515e-02f, 6.68211132e-02f, -7.70538952e-03f, 1.99279655e-02f, 6.95542917e-02f, -4.92502972e-02f, 3.50648463e-02f, 4.42130044e-02f, 3.07468362e-02f, -4.21808511e-02f,
  3.45356151e-04f, -5.59578501e-02f, 2.54866686e-02f, 8.26843455e-03f, 5.18944971e-02f, 5.64553291e-02f, 7.35368878e-02f, 7.70958960e-02f, 3.65403891e-02f, 3.61474007e-02f,
  -2.29995213e-02f, 3.21330950e-02f, 6.81082904e-02f, 1.72236562e-02f, -4.09908630e-02f, 2.24909168e-02f, -8.23496580e-02f, -8.88158381e-02f, 3.76369711e-03f, -5.00036553e-02f,
  4.08070870e-02f, -1.06111811e-02f, 6.21421859e-02f, -4.60867584e-03f, -2.77201347e-02f, -5.19021116e-02f, 6.01945780e-02f, 4.68420312e-02f, 6.09321073e-02f, -3.52760889e-02f,
  2.61403061e-02f, 7.47748390e-02f, -1.71181709e-02f, 4.98749837e-02f, -8.57804567e-02f, 1.25692263e-02f, 7.75207281e-02f, 8.32919329e-02f, 1.11882426e-01f, 3.42974067e-02f,
  7.80864954e-02f, -7.80264214e-02f, 1.14759326e-01f, 7.03200251e-02f, -2.77941711e-02f, 7.73704574e-02f, 1.06101483e-01f, 5.56276366e-02f, 3.80329351e-04f, 3.73157933e-02f,
  2.96170954e-02f, 5.64998239e-02f, 9.18737054e-02f, 1.07227400e-01f, 3.43805850e-02f, 9.30395275e-02f, 1.39001921e-01f, 1.41511679e-01f, 2.30648234e-01f, 1.31035686e-01f,
  5.92637807e-02f, 7.57770613e-03f, 6.40636981e-02f, -4.20503616e-02f, -3.97160538e-02f, -5.80804162e-02f, 5.09162731e-02f, 4.17058617e-02f, 5.82846999e-02f, 8.56950060e-02f,
  -9.05949771e-02f, -4.08003181e-02f, 6.00954257e-02f, 5.26810735e-02f, -5.82751669e-02f, -9.02785808e-02f, 4.48717289e-02f, -3.95461507e-02f, -4.17042244e-03f, 3.64404209e-02f,
  5.38082942e-02f, -4.27091569e-02f, -2.29894952e-03f, 5.00038937e-02f, 5.13939671e-02f, -5.31755351e-02f, -4.02503312e-02f, 2.22586244e-02f, -7.33111724e-02f, -2.88500916e-02f,
  -2.86712311e-02f, -6.26610452e-03f, 1.04812682e-02f, 5.42334206e-02f, -1.44816115e-02f, 9.55851600e-02f, -1.28869176e-01f, -6.42558485e-02f, 6.03803024e-02f, -1.36086866e-01f,
  1.97996590e-02f, -5.07086702e-02f, -7.54073188e-02f, 3.95844430e-02f, -7.93505758e-02f, 4.58804471e-03f, 2.26447433e-02f, -1.58363301e-02f, 2.88617387e-02f, 3.71423480e-03f,
  -3.31817046e-02f, -8.27079918e-03f, -4.12011743e-02f, -8.52829516e-02f, 4.96873818e-02f, 6.00213744e-02f, 9.12394524e-02f, -9.62158851e-03f, 5.86267710e-02f, -4.47315313e-02f,
  -7.10462704e-02f, -3.39525081e-02f, -8.36136863e-02f, 3.41833644e-02f, 3.27509083e-02f, 9.58515406e-02f, 2.57153530e-02f, 4.47715186e-02f, -5.25019616e-02f, 3.36717404e-02f,
  -1.54865041e-01f, 5.75335063e-02f, -1.04114274e-02f, -1.17298411e-02f, -2.00051144e-02f, -2.15959847e-02f, -1.18782401e-01f, -4.53961678e-02f, 4.10588533e-02f, -9.96322259e-02f,
  5.98995388e-02f, 6.84375241e-02f, -2.33282149e-02f, -8.78492966e-02f, 3.87040712e-02f, 4.64369208e-02f, -9.58950892e-02f, -6.80136532e-02f, 4.27942649e-02f, -3.76816764e-02f,
  -1.13758529e-02f, 8.11649784e-02f, 8.55774209e-02f, -6.19281363e-03f, 1.35431590e-03f, 1.41898962e-02f, -6.16861098e-02f, 4.10632193e-02f, 4.56758924e-02f, -5.58596989e-03f,
  3.96298766e-01f, -1.08328059e-01f, 4.91839610e-02f, 1.19660571e-01f, -1.80044860e-01f, -1.54728955e-02f, -7.74905682e-02f, 7.67251998e-02f, 1.27015799e-01f, -9.72770303e-02f,
  -1.72698408e-01f, 4.29846570e-02f, -3.64019498e-02f, -3.17924097e-02f, 1.08464547e-02f, -1.18677020e-02f, -5.43056987e-02f, 6.23833016e-02f, 5.26649430e-02f, 1.01243950e-01f,
  -5.28801195e-02f, 7.48609528e-02f, 2.26431698e-01f, 7.63979256e-02f, 4.06524427e-02f, 1.97578361e-03f, -8.62569064e-02f, -2.80498695e-02f, -1.49556816e-01f, -1.82907864e-01f,
  -1.41648605e-01f, 1.11499771e-01f, -7.26454630e-02f, -1.18739223e-02f, 3.03997435e-02f, 8.52695853e-02f, -3.97751853e-02f, 4.24907915e-02f, -2.76686549e-02f, 8.32052678e-02f,
  -9.44779888e-02f, 2.03234758e-02f, 8.60543773e-02f, 1.80827174e-02f, 1.13861375e-01f, -6.64236676e-03f, 2.09606979e-02f, 8.86513367e-02f, 8.98954645e-02f, -1.10660614e-02f,
  -7.07185566e-02f, -9.21801431e-04f, -8.11199173e-02f, -6.46146834e-02f, 4.22828235e-02f, 8.53182096e-03f, 9.41262208e-03f, 7.88365155e-02f, 1.23150781e-01f, -3.56645808e-02f,
  9.92134586e-03f, -3.73061486e-02f, -4.02955562e-02f, 2.31210403e-02f, -7.60165453e-02f, 4.48748209e-02f, -3.47925164e-02f, 4.59180027e-02f, -6.42979145e-02f, 7.91439321e-03f,
  4.98626046e-02f, -1.32847643e-02f, -2.94566415e-02f, 2.39512566e-02f, -4.66562919e-02f, -3.44978943e-02f, -7.06758723e-02f, 7.01677352e-02f, -1.86457727e-02f, 2.14334596e-02f,
  4.67471071e-02f, -4.30017859e-02f, 4.81154472e-02f, 1.66881531e-02f, 2.91024670e-02f, 1.63303539e-02f, 4.59223092e-02f, -4.98916246e-02f, -3.75082344e-02f, 2.95757037e-02f,
  6.02867119e-02f, -3.50093022e-02f, -6.49186522e-02f, 9.77310240e-02f, -8.04300681e-02f, 4.33240831e-02f, 3.33169252e-02f, 1.01986669e-01f, -8.95539531e-04f, -2.66703479e-02f,
  3.28474604e-02f, 7.26166368e-02f, -2.18698494e-02f, 3.77288535e-02f, 1.47411125e-02f, -1.17394179e-02f, -3.52218002e-02f, 5.11255115e-02f, -1.91629902e-02f, -2.15624401e-04f,
  -1.00716420e-01f, 4.51057144e-02f, -5.81034608e-02f, 4.39896137e-02f, 5.50634563e-02f, 6.36677369e-02f, -1.04325928e-01f, -9.54772439e-03f, 6.86481744e-02f, 4.10156623e-02f,
  -1.29147619e-01f, -6.75568655e-02f, 1.38246730e-01f, -3.24395895e-02f, -1.14609702e-02f, -1.24157079e-01f, -6.84325695e-02f, -1.38200477e-01f, 1.50996316e-02f, 7.77233541e-02f,
  -1.94757015e-01f, -7.26353154e-02f, 7.36840023e-03f, -7.99960420e-02f, -2.22198740e-02f, 1.06087945e-01f, 1.20424703e-01f, 8.08325782e-02f, 4.46376055e-02f, 2.28397977e-02f,
  -2.55978294e-02f, 3.94146778e-02f, -1.05910152e-02f, 5.96097000e-02f, 1.37234062e-01f, 1.33188620e-01f, 7.17314780e-02f, 2.13621873e-02f, -1.33346999e-02f, 3.04955602e-01f,
  1.12028077e-01f, -8.66356120e-02f, 4.77655604e-02f, -2.20806580e-02f, -2.75859907e-02f, 1.30777890e-02f, -5.03230542e-02f, 2.59172525e-02f, -1.11468192e-02f, 1.39307855e-02f,
  -4.63418625e-02f, 1.89613998e-02f, -1.04039587e-01f, -1.85215287e-02f, 2.81350054e-02f, -7.64253782e-03f, -4.96283174e-02f, 9.41264555e-02f, 4.39911485e-02f, 4.93044555e-02f,
  -7.04566315e-02f, -1.71737373e-02f, -1.30458504e-01f, -9.25078690e-02f, -8.96429867e-02f, -2.25358829e-02f, 5.58881573e-02f, 8.80133584e-02f, 6.57773092e-02f, 1.60506099e-01f,
  7.35553280e-02f, 4.62829955e-02f, -9.84688997e-02f, -1.21983176e-03f, 2.31138803e-02f, 4.49399948e-02f, 2.06568111e-02f, -2.01361580e-03f, -1.31193614e-02f, 7.65213568e-04f,
  1.93888077e-03f, -5.08901803e-03f, 2.68420558e-02f, -5.34640625e-02f, 6.28918037e-02f, 2.56907381e-02f, -2.89884899e-02f, 5.67888692e-02f, -8.97477195e-02f, -1.36659499e-02f,
  -7.67037049e-02f, 2.81778332e-02f, 8.60021561e-02f, -1.47931892e-02f, 2.90251896e-02f, -3.08435373e-02f, 9.76612978e-03f, 5.45606483e-03f, -6.69253990e-02f, -2.29643676e-02f,
  1.14827856e-01f, -1.87606052e-01f, 1.15747161e-01f, 5.42679578e-02f, -2.69325450e-02f, 7.09548071e-02f, -1.61412843e-02f, -4.92698476e-02f, -3.05931196e-02f, -3.78027721e-03f,
  -1.07875578e-01f, -3.67451168e-04f, -4.23735455e-02f, -5.72729763e-03f, -1.21536106e-02f, -1.35051841e-02f, -3.63590606e-02f, 2.34223623e-02f, 3.18909474e-02f, 4.19953763e-02f,
  -5.92090003e-02f, 2.15256121e-03f, -6.94773868e-02f, 9.82662365e-02f, 1.01796892e-02f, -5.89550026e-02f, -1.30007369e-02f, 4.06683981e-02f, -4.02533822e-02f, 5.68660833e-02f,
  -2.72744358e-01f, -3.07464749e-01f, 1.07514653e-02f, -5.82121462e-02f, -6.17570430e-02f, -1.32932588e-01f, -7.54607692e-02f, -8.01655278e-02f, -9.56971757e-03f, -2.35251889e-01f,
  -1.63359180e-01f, -6.67146593e-02f, -4.78744097e-02f, 1.06239833e-01f, -7.84930438e-02f, -2.16543555e-01f, -7.99984187e-02f, -4.15246859e-02f, 7.61771202e-02f, -4.13119905e-02f,
  -8.78285617e-02f, 3.88742574e-02f, 9.28333849e-02f, -2.01730421e-04f, -4.20999900e-02f, 2.55218726e-02f, -2.74030827e-02f, -1.67914480e-02f, 8.98365825e-02f, -1.53393179e-01f,
  -1.48595020e-01f, -1.44947112e-01f, 1.39608845e-01f, -3.40447500e-02f, 1.82123315e-02f, -7.97089934e-02f, -6.61385953e-02f, -2.75119413e-02f, -2.97471285e-02f, 1.98137593e-02f,
  -1.70695838e-02f, -2.24722754e-02f, 2.25658920e-02f, -8.27389490e-03f, -3.89331765e-02f, -3.78373079e-02f, 1.09903666e-03f, 5.83437718e-02f, -6.83837757e-02f, -2.00101342e-02f,
  -8.86175558e-02f, -1.88509412e-02f, -4.24641483e-02f, 2.02828813e-02f, 5.41313812e-02f, -2.44604908e-02f, 1.89998262e-02f, 1.51248589e-01f, 1.17334820e-01f, -1.49720818e-01f,
  -1.02162331e-01f, -4.18493375e-02f, 2.14017089e-02f, -1.34086784e-03f, 8.53753369e-03f, -1.89484023e-02f, 1.39132524e-02f, -6.33351803e-02f, -3.91569436e-02f, 5.25591634e-02f,
  -4.67753857e-02f, -1.91049073e-02f, -8.10588524e-02f, -5.92412278e-02f, 3.31804566e-02f, -7.35885724e-02f, -1.75781418e-02f, 3.34167629e-02f, -7.87902344e-03f, 1.46084838e-03f,
  -6.38266420e-03f, -2.44485233e-02f, -3.99022363e-02f, 3.81613299e-02f, -2.68758442e-02f, -4.75646928e-02f, 4.70266081e-02f, 3.65126953e-02f, -5.75001910e-02f, 4.75392751e-02f,
  -1.02576399e-02f, 1.18040256e-01f, -7.91694224e-02f, 1.04737692e-02f, -8.52062646e-03f, -2.87843216e-02f, 5.55513427e-02f, -4.35152464e-02f, 6.15443364e-02f, -7.20843524e-02f,
  1.72648095e-02f, 1.94851663e-02f, -5.54378293e-02f, 2.58459505e-02f, 4.77444828e-02f, 4.04174663e-02f, -1.00461960e-01f, -2.80359555e-02f, 1.70067530e-02f, 3.30499094e-03f,
  -5.78334497e-04f, -8.64317641e-02f, 5.49935177e-02f, 7.69216567e-02f, 8.04457217e-02f, 5.33495471e-02f, 1.35442829e-02f, 2.04608720e-02f, -5.78783043e-02f, -7.35596642e-02f,
  -1.88261554e-01f, -3.66399810e-02f, -1.06078155e-01f, 2.18609464e-03f, 9.29867774e-02f, 3.64922993e-02f, -9.59092900e-02f, 6.53490871e-02f, 5.07815816e-02f, -1.01614878e-01f,
  1.11239299e-01f, 3.84957669e-03f, 4.55985591e-02f, 5.75955100e-02f, -1.98242590e-02f, -9.99680087e-02f, -1.17368080e-01f, 8.47915374e-03f, -1.20152552e-02f, -1.40684387e-02f,
  1.03828661e-01f, -2.91462168e-02f, -6.96439743e-02f, 3.18195075e-02f, 7.51162916e-02f, 8.29095021e-02f, -2.88974345e-02f, -1.32881487e-02f, 2.50907298e-02f, 8.72051641e-02f,
  -8.95721763e-02f, -7.22372383e-02f, 8.49744752e-02f, 5.71094491e-02f, 1.06639061e-02f, -4.71994244e-02f, -2.47312617e-02f, 4.03240733e-02f, 4.33697626e-02f, 5.42774098e-03f,
  -5.39644323e-02f, 1.09161727e-01f, -4.95781079e-02f, 4.40410227e-02f, -6.81564137e-02f, -3.18923257e-02f, -6.41612860e-04f, -9.09119546e-02f, -9.27538704e-03f, -1.46526182e-02f,
  9.12336856e-02f, -6.63195364e-03f, 1.87648013e-02f, 6.58065826e-02f, -1.86002534e-02f, 1.07557215e-01f, -1.59409009e-02f, 3.80361266e-02f, -1.38440877e-02f, -6.53529316e-02f,
  -1.76558085e-02f, 4.48653251e-02f, 4.98932414e-02f, 5.62010854e-02f, 2.44198721e-02f, 9.64485407e-02f, -2.30101570e-02f, 7.53538311e-02f, 7.63626769e-02f, -5.02961874e-02f,
  -4.22427170e-02f, -2.03419421e-02f, -6.43770918e-02f, 1.05258813e-02f, -3.19704041e-03f, 6.96117058e-02f, -6.45563155e-02f, -6.72924705e-03f, 7.30470717e-02f, 5.88318072e-02f,
  -2.46029738e-02f, 2.89023072e-02f, -4.27761301e-02f, 1.04596354e-01f, -6.44221902e-02f, -7.23801851e-02f, -1.12313256e-02f, 3.75855528e-02f, 1.01190880e-01f, 4.23200652e-02f,
  -3.52131128e-02f, -1.74978311e-04f, -5.66974655e-02f, -5.74775375e-02f, 4.17520888e-02f, 4.91376743e-02f, -4.58909124e-02f, 4.84195538e-02f, -4.53957822e-03f, 1.70327816e-02f,
  1.98165532e-02f, -9.99119505e-02f, -3.19647901e-02f, 6.36879504e-02f, 4.16186862e-02f, 3.00256629e-02f, 3.60236615e-02f, -7.58563578e-02f, 7.74738714e-02f, -1.49841541e-02f,
  -1.96489487e-02f, -7.81748816e-02f, -1.51632592e-01f, -1.22872807e-01f, -6.56971931e-02f, -3.88669111e-02f, -2.47744378e-02f, -1.48076210e-02f, -1.13466859e-01f, -1.27989009e-01f,
  -1.93297416e-01f, 3.79735716e-02f, -2.96476167e-02f, 1.89510768e-03f, 1.07877608e-02f, -1.44843146e-01f, -2.48519018e-01f, -1.29991755e-01f, 8.05915594e-02f, -6.68690354e-02f,
  9.66833383e-02f, 6.06118776e-02f, -3.15238833e-02f, 1.33017646e-02f, -1.82025284e-01f, -1.65557921e-01f, -4.12486494e-03f, -3.69646773e-02f, -1.80409148e-01f, -1.32483155e-01f,
  4.70733717e-02f, 4.86929115e-04f, 5.63188829e-03f, -1.65166222e-02f, 5.65547012e-02f, 1.18596390e-01f, 1.01396635e-01f, -6.01519868e-02f, 2.08161790e-02f, -1.22981714e-02f,
  1.43720001e-01f, -3.93485650e-02f, -1.79338828e-02f, -7.24732950e-02f, 7.85436109e-03f, 3.11706234e-02f, -3.02250334e-03f, 1.22299627e-03f, 5.64868040e-02f, 9.73786861e-02f,
  -4.34609577e-02f, -1.48204062e-02f, 5.63593172e-02f, -2.01312099e-02f, 6.78743497e-02f, 2.38303002e-02f, -3.72200832e-03f, 4.19716053e-02f, -3.37090492e-02f, 7.69543201e-02f,
  -2.54382305e-02f, 5.89295216e-02f, -8.11958387e-02f, 2.84899548e-02f, -7.87628666e-02f, 5.02827354e-02f, 5.70150577e-02f, 3.51367667e-02f, -3.56672183e-02f, 1.50649343e-02f,
  -8.75076726e-02f, -6.85356408e-02f, -8.74377266e-02f, 1.35215884e-02f, 6.79055750e-02f, -1.36431903e-02f, -1.32627487e-02f, -3.35233216e-03f, -2.38775294e-02f, 3.57391387e-02f,
  4.01851833e-02f, 1.13871309e-03f, 5.10964692e-02f, 2.59053595e-02f, -1.41780889e-02f, 5.57510108e-02f, -7.41736814e-02f, -5.68187283e-03f, -4.09002379e-02f, 7.94579834e-03f,
  9.67060700e-02f, -2.39471737e-02f, -2.70475950e-02f, -3.66691723e-02f, -4.44579795e-02f, 8.36683139e-02f, -3.91941294e-02f, 2.04184271e-05f, 7.49878213e-02f, 5.00182211e-02f,
  5.35408221e-02f, 4.35898267e-02f, -3.21687609e-02f, -7.85757452e-02f, 7.03266710e-02f, -1.81684662e-02f, 4.73221168e-02f, -2.18576342e-02f, 4.34125736e-02f, 1.62944999e-02f,
  2.10909359e-02f, 5.76201156e-02f, 2.12151371e-02f, 3.95162590e-02f, -5.14570735e-02f, -2.67406460e-02f, -7.94619601e-03f, -3.13758701e-02f, -3.99290323e-02f, 1.00223728e-01f,
  -3.30819935e-02f, -1.02994286e-01f, 6.15799464e-02f, -2.33411100e-02f, -3.17211333e-03f, 2.20240079e-04f, -4.04887721e-02f, 3.46875861e-02f, -4.37802933e-02f, -9.15950462e-02f,
  -3.55819225e-01f, -1.24259494e-01f, 8.33256394e-02f, -1.72923580e-01f, 5.75363636e-02f, 1.77160442e-01f, 1.00051761e-01f, -8.78562871e-03f, -1.72582671e-01f, -1.56780928e-01f,
  -1.84396505e-01f, -1.39600858e-01f, -9.78502482e-02f, 9.17323157e-02f, 1.77491874e-01f, 1.68440551e-01f, 1.45154208e-01f, 1.96126565e-01f, 1.99902445e-01f, -2.73727011e-02f,
  3.95564362e-02f, -1.11712500e-01f, -1.77028298e-01f, 2.90673673e-02f, -2.63616461e-02f, -1.15966246e-01f, -5.31956414e-03f, 1.09420409e-02f, 7.12052956e-02f, 6.76786751e-02f,
  -9.60603543e-03f, -1.43165603e-01f, 8.06637853e-03f, -8.57475996e-02f, -9.68885571e-02f, -3.82713191e-02f, -4.23690863e-02f, -5.58861643e-02f, 4.42257375e-02f, -4.06184644e-02f,
  -7.18732476e-02f, -8.74885619e-02f, -7.20371529e-02f, 4.43311185e-02f, 4.66832630e-02f, -4.11526524e-02f, -3.20006572e-02f, 8.42502862e-02f, 2.77612600e-02f, 7.48126209e-02f,
  -2.48094145e-02f, 1.35481888e-02f, -8.84202570e-02f, -3.09628025e-02f, 1.18175402e-01f, 6.71335682e-02f, -1.20659610e-02f, -1.03556830e-02f, -4.33605388e-02f, -4.42361087e-02f,
  -1.53753199e-02f, -2.07545441e-02f, -2.82227937e-02f, 1.83571260e-02f, -4.40591685e-02f, -2.64156377e-03f, 2.55702045e-02f, -5.12726698e-03f, -2.46550441e-02f, 1.88001618e-02f,
  6.88293111e-03f, -2.71096136e-02f, -4.87376451e-02f, -8.57255906e-02f, -5.00013586e-03f, -5.42197973e-02f, -5.26476139e-03f, 4.74591739e-02f, 5.94903007e-02f, -2.77153216e-02f,
  8.78171921e-02f, 3.21578383e-02f, -1.42572522e-02f, 7.07328990e-02f, 1.42977955e-02f, 4.09065522e-02f, -3.58233526e-02f, 6.04599640e-02f, -3.34782191e-02f, -5.28807789e-02f,
  -2.48896822e-01f, 5.70825525e-02f, 3.19846123e-02f, 4.20429744e-02f, 5.21029644e-02f, 2.37483606e-02f, -1.70292798e-02f, -2.79547255e-02f, -5.50597906e-02f, 3.49953286e-02f,
  -5.19514717e-02f, -3.31248157e-02f, 4.12913188e-02f, -3.59431021e-02f, 8.44840780e-02f, -1.16313891e-02f, -7.21124485e-02f, -1.82663146e-02f, -1.15727936e-03f, -1.06488645e-01f,
  6.18900061e-02f, -5.42172715e-02f, -2.81535424e-02f, 7.52987266e-02f, -6.10161871e-02f, 5.08272573e-02f, 5.08828042e-03f, -7.40333050e-02f, 4.04799096e-02f, -1.07443765e-01f,
  2.52062291e-01f, -2.69215822e-01f, 5.18878996e-02f, 7.55006298e-02f, -1.38319150e-01f, 2.63974965e-02f, -1.63186774e-01f, 3.86563540e-02f, 4.25512493e-02f, -1.11145772e-01f,
  -1.64916590e-01f, 5.00037149e-02f, 2.26556771e-02f, 7.14212134e-02f, -1.67397298e-02f, -5.17567359e-02f, -8.15620050e-02f, 2.37578183e-01f, 1.51227176e-01f, 4.83759642e-02f,
  -1.19541474e-01f, 6.16194531e-02f, 2.07711026e-01f, 5.72181419e-02f, 2.83707548e-02f, 1.09670507e-02f, -8.89794528e-03f, -2.23367270e-02f, -8.03349167e-02f, -1.97336853e-01f,
  1.06621176e-01f, 4.66634631e-02f, 4.58428934e-02f, -3.04273702e-02f, -9.57396850e-02f, 1.21834420e-01f, 6.55283779e-02f, 1.35609627e-01f, 9.09097642e-02f, 3.80128622e-02f,
  -8.31407458e-02f, -2.43295208e-02f, 1.15709163e-01f, 8.09734687e-02f, 1.05957640e-02f, 1.37023360e-01f, 5.31920455e-02f, 4.06502606e-03f, 8.05979893e-02f, 1.01397134e-01f,
  -1.16497733e-01f, -2.44183163e-03f, 1.73659340e-01f, -6.28954247e-02f, 3.36523391e-02f, 1.03910990e-01f, -2.57962048e-02f, 1.08311512e-01f, 8.31162333e-02f, 8.40491988e-03f,
  -7.40886256e-02f, 5.85635006e-02f, -6.70172200e-02f, -8.62895232e-03f, 9.87370405e-03f, -5.38689196e-02f, 8.87024682e-03f, -4.23675850e-02f, 5.08401133e-02f, 1.73294414e-02f,
  7.41379336e-02f, 5.28810099e-02f, -6.57535493e-02f, -7.79555291e-02f, 5.10088429e-02f, -2.92438697e-02f, -6.33506253e-02f, -4.90112754e-04f, -4.73828912e-02f, 3.82727943e-02f,
  -2.53031161e-02f, -2.33889632e-02f, 7.87665471e-02f, 6.12394931e-03f, 1.46216946e-02f, -3.89687880e-03f, 3.23968120e-02f, -6.55651614e-02f, 1.81499682e-02f, 5.29070385e-04f,
  -3.90870906e-02f, 3.21909487e-02f, 5.30096479e-02f, -2.49284133e-02f, -1.03210565e-02f, -2.85762846e-02f, -5.87934628e-02f, -3.14649232e-02f, 6.66824058e-02f, 1.03241513e-02f,
  3.69965397e-02f, 3.30490083e-03f, -7.16623887e-02f, 6.12026118e-02f, 1.09919816e-01f, 1.10228695e-01f, -6.59951419e-02f, 4.13274914e-02f, -4.91669923e-02f, 6.88732564e-02f,
  -5.07234521e-02f, -4.91281375e-02f, 9.18648392e-02f, 3.73078547e-02f, 6.59859031e-02f, 9.68347341e-02f, -1.48946354e-02f, -7.36231506e-02f, 4.66503985e-02f, -5.52041903e-02f,
  -3.36181551e-01f, 1.19519137e-01f, 9.11219567e-02f, 5.03605939e-02f, 1.24242850e-01f, 4.38488722e-02f, 6.96149245e-02f, -1.23790376e-01f, -5.49224466e-02f, -1.92722678e-02f,
  5.67104854e-03f, -5.94505593e-02f, -1.49154007e-01f, -1.17020734e-01f, -1.21953905e-01f, 1.64054453e-01f, 7.19997436e-02f, -1.14489138e-01f, -2.36972064e-01f, 9.78046656e-03f,
  1.51432425e-01f, 2.53773555e-02f, -1.17761262e-01f, -1.08162828e-01f, 1.46625578e-01f, 1.95980091e-02f, 1.87803939e-01f, 3.02024558e-02f, 1.30229145e-01f, 1.62633836e-01f,
  6.26484537e-03f, -5.99670857e-02f, -7.58096874e-02f, 5.10632247e-02f, 2.97610578e-03f, 1.25628617e-02f, 5.00125475e-02f, 5.43119712e-03f, -6.14690334e-02f, 6.39284626e-02f,
  -8.28341302e-03f, 7.20205456e-02f, 5.15519129e-03f, 6.68187961e-02f, 3.74691896e-02f, -7.21978843e-02f, 1.36557901e-02f, -6.27950653e-02f, 5.07963151e-02f, -5.92904016e-02f,
  5.59635237e-02f, 1.06135514e-02f, 4.75911126e-02f, 6.95695505e-02f, -6.61795586e-02f, -2.83636004e-02f, -3.19531523e-02f, -6.63568527e-02f, -1.39770150e-01f, -1.77076869e-02f,
  -5.34028709e-02f, -6.30433410e-02f, -2.07046494e-02f, 5.74793071e-02f, -3.29240747e-02f, -4.15181592e-02f, 2.72144694e-02f, -2.35680351e-03f, -1.70760434e-02f, -3.71770710e-02f,
  2.20676474e-02f, -8.54219124e-03f, -3.32275704e-02f, -3.54936980e-02f, 3.89113091e-02f, -2.30222344e-02f, 3.20938590e-04f, -1.13702090e-02f, -4.81543504e-02f, 4.04778533e-02f,
  -6.10109270e-02f, -3.75365801e-02f, -5.95348945e-04f, -1.83259323e-02f, 1.01106189e-01f, 7.25693032e-02f, 2.51997117e-04f, -1.70299225e-02f, 2.33108271e-02f, 8.43512490e-02f,
  -6.77744821e-02f, 3.10852681e-03f, -2.01336853e-02f, -4.13807016e-03f, -1.20974621e-02f, 7.55601823e-02f, -6.76650330e-02f, 1.41782295e-02f, 1.99046433e-02f, 5.19608781e-02f,
  4.54089604e-02f, -9.14934650e-02f, 4.87906151e-02f, 4.92232926e-02f, -1.71626247e-02f, 2.24866103e-02f, 9.00118798e-02f, -5.50395139e-02f, 7.90453628e-02f, 9.19909999e-02f,
  -1.57751292e-02f, 1.81106888e-02f, -2.22011767e-02f, -6.09922893e-02f, -2.57293582e-02f, -5.00892214e-02f, 3.43386754e-02f, 1.08766090e-02f, -6.99821487e-02f, 2.36500870e-03f,
  -1.50587037e-01f, -6.35927767e-02f, -1.84059530e-01f, 8.36100280e-02f, 5.41441888e-02f, 1.12308916e-02f, -7.62710497e-02f, -4.71508801e-02f, 2.63389889e-02f, 4.49879915e-02f,
  1.47047281e-01f, 1.30898356e-02f, -5.31671941e-03f, -8.10481384e-02f, -1.71170875e-01f, 3.39652644e-03f, 3.15365344e-02f, -1.08844616e-01f, -1.64834097e-01f, -2.86972662e-03f,
  4.53156270e-02f, 2.60489639e-02f, -8.34267065e-02f, -4.64427471e-02f, 1.31519176e-02f, 1.15223154e-01f, 2.32860707e-02f, 1.98815577e-02f, -1.05688849e-03f, 8.38853642e-02f,
  1.61416709e-01f, -1.59516171e-01f, 6.07451983e-02f, 8.34391639e-03f, 5.04458733e-02f, 1.20414188e-02f, -9.08430666e-02f, -1.40138371e-02f, -6.12729266e-02f, -5.29830940e-02f,
  -2.68546380e-02f, -6.09969608e-02f, -3.84879932e-02f, 5.06973118e-02f, -3.52685824e-02f, 7.95210339e-03f, -6.89629167e-02f, -1.16640136e-01f, -1.81298144e-02f, -1.12147927e-01f,
  7.16819540e-02f, -6.58071041e-02f, -1.59247205e-01f, -9.76340100e-02f, -8.25907364e-02f, -2.81652268e-02f, -4.21906039e-02f, -5.02194278e-02f, -1.73714921e-01f, -4.03389931e-02f,
  9.02556181e-02f, 6.57113492e-02f, 8.97925645e-02f, -1.74320955e-02f, -4.81325435e-03f, -9.50530078e-03f, 2.61794850e-02f, 4.33830954e-02f, 5.17122857e-02f, -2.53458600e-02f,
  -6.86950162e-02f, 4.34488840e-02f, -4.68648039e-02f, 1.17152417e-02f, 3.24449167e-02f, -5.31274229e-02f, 4.10737805e-02f, 6.99890703e-02f, -3.54061536e-02f, 3.82550396e-02f,
  5.81031963e-02f, 2.58727036e-02f, 2.22170856e-02f, 1.64209735e-02f, -2.99406350e-02f, -6.11301214e-02f, 6.26341924e-02f, -3.81120257e-02f, 5.89839928e-02f, -5.90632223e-02f,
  1.11808412e-01f, -4.48575802e-02f, 1.50127754e-01f, -7.77366832e-02f, 5.39057329e-02f, -1.12580126e-02f, 6.38831705e-02f, -2.09588883e-03f, 8.40016007e-02f, 1.46614565e-02f,
  1.67380050e-02f, -4.59083952e-02f, 7.97344223e-02f, 6.06528893e-02f, 6.75962567e-02f, 8.41429010e-02f, 5.69810830e-02f, -4.15089205e-02f, 8.68036598e-03f, 3.55630331e-02f,
  8.32470208e-02f, 6.86856583e-02f, 1.86644122e-02f, -1.29086450e-02f, -5.16234003e-02f, 9.48053505e-03f, 9.10572633e-02f, 1.04557201e-01f, -4.04972211e-03f, 1.82698488e-01f,
  2.69455791e-01f, -2.04287961e-01f, -2.30714213e-02f, -8.69002473e-03f, -5.49134202e-02f, 8.89984518e-03f, -8.75634700e-02f, -6.76460043e-02f, 9.43645164e-02f, -1.47364065e-01f,
  -1.72713116e-01f, 7.19753280e-02f, -5.18235639e-02f, 6.00825772e-02f, 1.09281451e-01f, -8.98534209e-02f, -1.45282805e-01f, 1.08860143e-01f, 1.81865692e-01f, 1.47076204e-01f,
  4.32653762e-02f, -3.13087367e-02f, 1.68703914e-01f, 1.43078595e-01f, -1.06602438e-01f, 8.42488278e-03f, -1.67669520e-01f, -2.36234758e-02f, -2.59725321e-02f, -2.15386078e-01f,
  -8.21648687e-02f, -9.55930576e-02f, -4.13340107e-02f, -1.00903027e-02f, 1.29715446e-02f, 1.11845300e-01f, 7.80881271e-02f, -3.34902741e-02f, -1.25659006e-02f, 4.47110645e-03f,
  4.52994555e-02f, -5.91738448e-02f, -2.40718611e-02f, -1.61467586e-02f, 6.76538423e-02f, -6.88925087e-02f, 5.95114939e-03f, 1.08104251e-01f, -2.02217884e-02f, -6.71443045e-02f,
  -7.08680972e-02f, -5.11341207e-02f, -4.27088924e-02f, -5.33470660e-02f, 1.15562947e-02f, 9.89599526e-02f, 3.70445512e-02f, -3.65322866e-02f, -9.10489168e-03f, -1.00634053e-01f,
  6.38308674e-02f, -7.61292428e-02f, 5.16084097e-02f, 5.66838011e-02f, -6.92189112e-02f, 4.23697941e-02f, -5.68548180e-02f, -1.55257462e-02f, -2.27113701e-02f, 9.63836350e-03f,
  6.01086440e-03f, -3.16638909e-02f, 7.65978033e-03f, 3.31973686e-04f, 5.12891971e-02f, -6.22573122e-02f, 6.30632713e-02f, 3.13994847e-02f, 5.65866828e-02f, -8.21752287e-03f,
  4.42642681e-02f, -5.10251243e-03f, -6.82862476e-02f, -2.04043165e-02f, 3.30281556e-02f, -5.11510484e-02f, 1.51621187e-02f, -8.92571658e-02f, 1.71509311e-02f, 4.74267080e-02f,
  -6.82104565e-03f, 3.10529079e-02f, 2.34226529e-02f, -5.28795868e-02f, -5.64471558e-02f, -6.85276836e-03f, -2.80644782e-02f, 3.55934761e-02f, -1.03580475e-01f, 8.09832662e-02f,
  -1.62105355e-02f, 3.36776525e-02f, 2.09055785e-02f, 5.82708493e-02f, 5.42389676e-02f, -4.13608029e-02f, -6.35849731e-03f, -6.60036728e-02f, 6.09003231e-02f, -4.64466140e-02f,
  -6.90076873e-02f, 8.13909769e-02f, 1.12410568e-01f, 8.14991072e-02f, -1.57443676e-02f, 3.12511958e-02f, 7.10904747e-02f, 2.92469058e-02f, 1.22083135e-01f, -3.51859489e-03f,
  1.48230586e-02f, -8.11918825e-02f, 2.76894979e-02f, -2.61666384e-02f, -5.20684756e-02f, 9.46433470e-02f, -1.51085351e-02f, 5.77782691e-02f, 7.14660510e-02f, -3.86818089e-02f,
  3.04730684e-02f, -3.06697693e-02f, 8.40248913e-02f, -7.70590454e-02f, -9.51675624e-02f, -3.83976810e-02f, -3.43699008e-02f, -1.11932382e-02f, -8.84992480e-02f, -8.47459361e-02f,
  -1.25449494e-01f, -2.09535751e-02f, -8.40773657e-02f, -2.53112521e-02f, -6.48605600e-02f, -6.84953108e-03f, 2.40696426e-02f, -5.42333396e-03f, 3.25665297e-03f, -1.69079304e-01f,
  5.72024845e-02f, 2.25796476e-02f, -7.94572979e-02f, 4.83153649e-02f, 1.01667181e-01f, 4.67165932e-02f, -7.45091364e-02f, -7.05222711e-02f, -2.29268125e-03f, -1.49827804e-02f,
  6.01896569e-02f, 7.37022907e-02f, -6.40789196e-02f, -1.06535472e-01f, 5.85593656e-02f, 2.63252831e-03f, -3.28718610e-02f, -5.52743785e-02f, -2.67043374e-02f, -5.30249625e-03f,
  -7.52546415e-02f, -7.89255649e-02f, 1.12640252e-02f, -6.85328916e-02f, 6.64051846e-02f, 7.16714934e-02f, -7.40239620e-02f, -8.12277123e-02f, 2.55784690e-02f, -8.75902623e-02f,
  -4.78425249e-02f, -7.71813020e-02f, -2.20256783e-02f, -1.14702471e-02f, 4.24735174e-02f, -2.80349180e-02f, -6.57744240e-03f, -5.96443638e-02f, 4.58305329e-02f, -7.07377940e-02f,
  -7.58779347e-02f, -2.79571172e-02f, 5.31066097e-02f, -6.23676144e-02f, -3.26192863e-02f, -1.82310045e-02f, 2.11797040e-02f, -2.50638137e-03f, 2.60914862e-02f, 4.15271632e-02f,
  -2.87837721e-02f, -3.70313674e-02f, 7.95948058e-02f, 6.30327761e-02f, 5.29292598e-02f, 6.15866482e-03f, 1.78126823e-02f, 6.35832176e-02f, -2.04164442e-02f, 8.30886364e-02f,
  9.18727443e-02f, 1.15254791e-02f, -3.26644816e-02f, 9.95822996e-03f, 1.84387644e-03f, -4.69216518e-02f, 1.15836136e-01f, -3.12287174e-02f, 1.05165623e-01f, 1.90850664e-02f,
  -2.94638006e-03f, 7.69360177e-03f, 7.63288215e-02f, 3.94210778e-02f, -4.00182381e-02f, -7.03159571e-02f, -4.26096730e-02f, 1.28888395e-02f, -4.94158417e-02f, 2.69427281e-02f,
  -7.21190944e-02f, 9.47812721e-02f, 4.58811112e-02f, -1.84803940e-02f, -6.42616600e-02f, 1.32500827e-01f, 5.75065278e-02f, -5.15946709e-02f, 2.35476159e-02f, 5.93737699e-02f,
  -1.18678309e-01f, -1.28108710e-02f, 1.83692530e-01f, -2.00179517e-01f, -1.83168873e-01f, 7.05564469e-02f, 5.56711666e-03f, -5.34518808e-02f, -8.99484828e-02f, 1.01754829e-01f,
  -1.53143466e-01f, -4.58872505e-02f, -2.45475993e-02f, 9.08438861e-03f, 1.26263604e-01f, 1.81704849e-01f, 3.67948487e-02f, 1.84899956e-01f, 3.05486955e-02f, -6.57276735e-02f,
  -2.11752616e-02f, -5.49536236e-02f, 5.61274067e-02f, 8.38770252e-03f, 6.02932833e-02f, -2.40890104e-02f, 1.06651202e-01f, -8.08539093e-02f, 6.47746027e-02f, 4.17273454e-02f,
  6.94072545e-02f, -2.19374016e-01f, 1.15144119e-01f, 4.40042056e-02f, 7.72716384e-03f, 7.22428486e-02f, 3.40579636e-02f, 7.10776821e-02f, -4.12864843e-03f, 1.08940877e-01f,
  -4.50589284e-02f, 1.56419445e-02f, -5.25424220e-02f, 6.47397339e-02f, -1.14312686e-01f, 5.54720834e-02f, -2.29855832e-02f, 3.30687463e-02f, 1.25623211e-01f, 9.41195861e-02f,
  4.17498089e-02f, -3.83276343e-02f, 6.96569458e-02f, 1.95676126e-02f, 4.06121574e-02f, 8.66913348e-02f, 7.34673440e-02f, 8.48662108e-02f, 1.61903679e-01f, 1.29680485e-01f,
  -3.07785235e-02f, 1.66168138e-02f, -8.64268020e-02f, -3.39038111e-02f, 1.27191367e-02f, -6.74462020e-02f, 3.66518423e-02f, -5.38703538e-02f, -5.01696840e-02f, 2.81855706e-02f,
  3.80632617e-02f, 4.90765367e-03f, -8.06256384e-03f, 4.27743196e-02f, -1.96133982e-02f, 8.34795684e-02f, 3.03127579e-02f, 7.05065355e-02f, 8.35065618e-02f, 1.01429798e-01f,
  -2.82793418e-02f, -9.69301153e-04f, -5.99035248e-02f, 6.61649927e-02f, 5.16844019e-02f, 1.12156058e-05f, 6.60926700e-02f, -3.68514881e-02f, 3.97027992e-02f, -1.00920096e-01f,
  -1.04052722e-02f, 1.08644590e-01f, 1.57872774e-02f, -1.34551581e-02f, -1.42947109e-02f, -7.31795561e-03f, -8.78548697e-02f, -2.42807642e-02f, -9.86710265e-02f, 8.77670944e-02f,
  -6.89154118e-02f, 3.21998517e-03f, -7.00994283e-02f, 4.03766967e-02f, -4.58713397e-02f, -5.07679284e-02f, 5.51504977e-02f, 2.64243726e-02f, 6.72552437e-02f, -2.10923068e-02f,
  9.19787288e-02f, 1.09059565e-01f, 9.90943462e-02f, 1.15705132e-01f, 5.29838614e-02f, 5.60574904e-02f, 7.46336505e-02f, 7.68480897e-02f, 1.86526120e-01f, 1.50846422e-01f,
  -5.43797202e-02f, 1.63511336e-01f, 9.69919842e-03f, -6.28862008e-02f, 8.14809948e-02f, -7.41801923e-03f, 1.38286710e-01f, 6.42874613e-02f, -1.53145622e-02f, 1.65320951e-02f,
  1.05533406e-01f, -8.91053751e-02f, -3.32034901e-02f, 9.66122467e-03f, -8.30942988e-02f, -2.23189555e-02f, -1.47120520e-01f, -1.30956814e-01f, -6.95941318e-03f, -1.19494371e-01f,
  -1.62689775e-01f, -1.64063334e-01f, -7.01883286e-02f, -1.60637543e-01f, -1.23231031e-01f, -9.89576504e-02f, -4.99687623e-03f, -5.56618273e-02f, -1.21803746e-01f, -2.45371118e-01f,
  1.24564767e-01f, 6.17344379e-02f, 5.56488298e-02f, -1.28134176e-01f, 6.26574606e-02f, 1.74233341e-03f, 2.14406364e-02f, -4.23354842e-02f, 6.37891293e-02f, -3.24393027e-02f,
  -1.23654902e-02f, -3.81019823e-02f, 4.20689806e-02f, 3.73514779e-02f, -1.31587647e-02f, 7.52208754e-02f, 7.40923453e-03f, 3.97472158e-02f, 1.72809567e-02f, 1.09398931e-01f,
  5.25726788e-02f, 5.12994565e-02f, 9.94110778e-02f, 9.76408124e-02f, -1.35623179e-02f, 4.79564331e-02f, 3.20863947e-02f, 3.78983319e-02f, -1.83248296e-02f, -4.04342404e-03f,
  2.49095596e-02f, 5.14572263e-02f, -3.01023126e-02f, 4.16461490e-02f, -3.25321853e-02f, 3.25544514e-02f, 2.38013174e-03f, 2.89419722e-02f, 9.18904040e-03f, -6.97169527e-02f,
  8.04178193e-02f, 2.61958037e-02f, -7.15650618e-02f, -1.07528694e-01f, -1.90515406e-02f, 5.31173758e-02f, -1.01447792e-03f, 3.30350995e-02f, 5.03493808e-02f, -3.70077156e-02f,
  3.50026675e-02f, 1.44522637e-02f, -1.14413081e-02f, -6.19578771e-02f, -8.04393962e-02f, -5.47354817e-02f, -9.06374902e-02f, -4.10476699e-02f, -1.43132145e-02f, -8.94155167e-03f,
  -3.40903341e-03f, 9.13941264e-02f, -3.99847291e-02f, -4.20673341e-02f, 7.43412897e-02f, 5.84494649e-03f, 6.59725666e-02f, -4.95036989e-02f, 5.31713925e-02f, 2.41680481e-02f,
  3.48276719e-02f, 2.65092906e-02f, 3.49972248e-02f, -4.09485288e-02f, -7.97844529e-02f, 1.96023099e-02f, 5.44267111e-02f, -6.28789887e-02f, -7.21966475e-02f, 1.06164128e-01f,
  -5.48093505e-02f, -9.80280433e-03f, 5.78893274e-02f, 8.65061134e-02f, 4.23240429e-03f, -3.48479599e-02f, -2.98730284e-02f, 8.84221420e-02f, 4.18747067e-02f, 6.91364035e-02f,
  1.35415554e-01f, -1.28726855e-01f, 1.80787683e-01f, 5.69951832e-02f, 1.66218534e-01f, 1.66248918e-01f, -8.20149574e-03f, -2.90134344e-02f, 4.95087691e-02f, 1.78510863e-02f,
  1.26783028e-02f, 1.17763076e-02f, 1.49239659e-01f, -8.79303832e-03f, 1.55105516e-01f, 1.65997460e-01f, 1.49076492e-01f, 2.10663319e-01f, 2.51933515e-01f, 2.11382508e-01f,
  7.60924369e-02f, 1.91427737e-01f, 1.21557891e-01f, 1.47512868e-01f, 2.06210203e-02f, 7.48725310e-02f, 1.38948224e-02f, 1.49887472e-01f, 1.33968741e-01f, 1.19865224e-01f,
  2.04921365e-01f, 2.76362374e-02f, 1.30442958e-02f, -4.91229445e-02f, -7.38993585e-02f, 3.02861072e-02f, 2.32225750e-02f, -7.39720911e-02f, -6.58553913e-02f, -2.20813919e-02f,
  -1.95040572e-02f, 1.69931576e-02f, -9.60611855e-04f, 2.27680127e-03f, 9.79602039e-02f, 7.02600628e-02f, 1.23004876e-02f, 8.47072341e-03f, -1.87162105e-02f, -2.60378234e-02f,
  -1.13196105e-01f, -2.12984737e-02f, 8.18037912e-02f, -2.40347441e-02f, 3.98624018e-02f, -5.04468475e-03f, 3.47448513e-02f, 1.37449726e-02f, 2.85547506e-02f, 6.39112145e-02f,
  5.03549539e-02f, -1.98537353e-02f, 1.51168667e-02f, -5.84825315e-02f, 2.20579766e-02f, -4.21916842e-02f, -4.29460369e-02f, 6.61639348e-02f, 2.62900721e-02f, 7.38232746e-04f,
  -3.31014767e-02f, -4.65499014e-02f, 3.56724001e-02f, -7.36510754e-02f, 5.94495237e-02f, 4.95549664e-02f, -8.95356238e-02f, -6.51681274e-02f, 2.77750398e-04f, 4.86058332e-02f,
  4.47398238e-02f, -6.77637383e-03f, 3.34129073e-02f, 1.64114013e-02f, -3.32420296e-03f, -2.84568761e-02f, 4.49863188e-02f, -1.44673651e-02f, -3.49623710e-02f, -6.87828436e-02f,
  8.30935314e-02f, -8.40495005e-02f, -6.23355471e-02f, 3.26224566e-02f, 5.15704677e-02f, -3.85469757e-02f, -9.19075385e-02f, -1.95514951e-02f, -2.40646526e-02f, 1.87985189e-02f,
  -7.07053021e-02f, 3.35595757e-03f, 5.14625981e-02f, -6.06465638e-02f, -1.25678228e-02f, 5.14900014e-02f, -5.23494147e-02f, 2.99084932e-02f, 1.26016920e-03f, -8.97164270e-02f,
  7.76303932e-03f, 2.22089086e-02f, -2.03180965e-03f, -8.61907899e-02f, -3.47119160e-02f, 9.43617523e-02f, 3.98746096e-02f, -4.24662977e-02f, -1.25222001e-02f, -1.55950896e-02f,
  1.99239135e-01f, -2.08004043e-01f, -2.73305029e-01f, 5.09061553e-02f, -3.15375775e-02f, -9.34310108e-02f, -4.40305248e-02f, -5.39710298e-02f, 1.60107046e-01f, -1.18132792e-01f,
  1.81833189e-02f, 6.25059009e-02f, 1.22565694e-01f, -3.95200104e-02f, 7.45643750e-02f, -1.55863732e-01f, -7.68194497e-02f, -8.91792327e-02f, 1.44415691e-01f, 1.11591011e-01f,
  6.32016510e-02f, -2.86985133e-02f, 2.72215996e-02f, -2.21648440e-02f, -1.22798555e-01f, 1.24624833e-01f, -2.60133687e-02f, 1.05510755e-02f, -1.11026980e-01f, -2.18855485e-01f,
  -6.52686432e-02f, -6.43080696e-02f, 9.81701761e-02f, 9.15765986e-02f, 9.09437891e-03f, 7.27132037e-02f, -1.33820064e-03f, -2.74764542e-02f, 3.05458233e-02f, 8.10645148e-03f,
  -1.02336351e-02f, 1.09358002e-02f, 2.52554789e-02f, -3.07933660e-03f, -3.67713049e-02f, 7.48428777e-02f, -4.15844284e-02f, 2.78555900e-02f, 6.59164274e-03f, -9.84521508e-02f,
  -4.97683808e-02f, 4.81585898e-02f, 3.69384065e-02f, -5.39564863e-02f, 4.51819971e-02f, -5.61158406e-03f, -1.41348287e-01f, 2.36161128e-02f, -7.66867474e-02f, -1.01168163e-01f,
  2.46571228e-02f, -4.66462299e-02f, -8.70711654e-02f, -2.42436416e-02f, 3.01139858e-02f, 4.86240722e-02f, -1.29462276e-02f, 2.29258440e-03f, 4.84055690e-02f, 1.95123814e-02f,
  9.97668412e-03f, -1.79347638e-02f, -2.76858974e-02f, -6.94398805e-02f, 8.45676586e-02f, -5.71675412e-02f, -4.33665607e-03f, -4.78515923e-02f, 5.68088256e-02f, -1.35701504e-02f,
  -4.50118668e-02f, -7.00130612e-02f, 8.92832410e-03f, 4.26268391e-02f, -2.00441238e-02f, 4.24048491e-02f, 2.29743160e-02f, 1.79702900e-02f, -7.39779919e-02f, 6.69352710e-03f,
  1.75453037e-01f, 1.10518718e-02f, 1.17702864e-01f, 1.19708672e-01f, 2.58875033e-03f, 4.32402268e-02f, -4.36908230e-02f, -3.29035446e-02f, -1.12399831e-01f, 6.66533336e-02f,
  2.31174156e-02f, 7.71075895e-04f, -4.92499731e-02f, -6.16696998e-02f, 9.54893529e-02f, -1.18208481e-02f, 3.95512134e-02f, 2.54710708e-02f, 1.04564667e-01f, -3.19098979e-02f,
  9.07737575e-03f, 7.62341395e-02f, 2.21389100e-01f, 6.93449825e-02f, 1.20017096e-01f, 1.79154202e-01f, 5.35972901e-02f, 1.14204429e-01f, 1.22382611e-01f, 3.11807971e-02f,
  1.19738035e-01f, -2.49499738e-01f, -2.90264152e-02f, 3.41198854e-02f, 1.90098509e-02f, -6.86632842e-02f, -1.58251509e-01f, 1.13200627e-01f, -1.00886007e-03f, -1.64702088e-01f,
  -2.66629439e-02f, 3.46428119e-02f, 5.23773246e-02f, 1.59070492e-01f, 8.87072235e-02f, -8.37695524e-02f, -1.28430769e-01f, 1.44927323e-01f, 1.56266883e-01f, 4.80584539e-02f,
  3.03131454e-02f, 1.17053099e-01f, 1.70631781e-01f, -3.61413658e-02f, -1.43689364e-01f, -4.83586900e-02f, -3.41114439e-02f, -1.20102435e-01f, -1.70115814e-01f, -1.82780012e-01f,
  -4.58742417e-02f, -1.31254569e-01f, 1.34239078e-01f, 5.75000495e-02f, -1.04569487e-01f, -1.56143475e-02f, -2.15222337e-03f, 5.42607531e-02f, 6.31256700e-02f, -7.40560293e-02f,
  -6.08997680e-02f, 4.61043492e-02f, 2.04509832e-02f, -7.80999362e-02f, -5.14663942e-02f, -6.29779473e-02f, 4.78675663e-02f, -1.94370784e-02f, -1.26385530e-02f, -5.11966869e-02f,
  -1.66326929e-02f, -9.28426534e-02f, 2.52132211e-02f, 5.92506975e-02f, 1.09796990e-02f, 9.12233815e-02f, 3.52795012e-02f, -3.40277515e-02f, -1.37543995e-02f, -1.46654010e-01f,
  1.21561124e-03f, -2.64243651e-02f, 1.92926172e-02f, -6.34108037e-02f, 5.43018728e-02f, -3.50852534e-02f, -1.23210223e-02f, -1.92555245e-02f, 4.05556224e-02f, 1.14855403e-02f,
  4.78544906e-02f, 1.89693086e-02f, 6.02627657e-02f, 4.18004729e-02f, 7.00836927e-02f, -7.12654144e-02f, 1.42426770e-02f, 1.51592083e-02f, -5.62278554e-02f, -5.59765212e-02f,
  1.05111524e-01f, -1.96345709e-02f, -7.35594854e-02f, 7.82355815e-02f, -8.93609412e-03f, 2.46619396e-02f, -3.94327790e-02f, 1.50674004e-02f, -6.47041276e-02f, -2.84013096e-02f,
  1.99556172e-01f, 1.34291500e-01f, 3.32655758e-02f, 1.19652160e-01f, 2.53528170e-02f, -2.20465977e-02f, 4.92660217e-02f, 3.54470080e-03f, -7.59534538e-02f, 2.78858710e-02f,
  1.90478712e-02f, 1.35777928e-02f, -8.66497587e-03f, -5.58798611e-02f, 1.25846397e-02f, -4.33925800e-02f, 4.57716687e-03f, 8.91616121e-02f, 9.48307738e-02f, -8.87945946e-03f,
  6.76780343e-02f, 9.48429629e-02f, 3.48940566e-02f, 9.18677747e-02f, -1.50504885e-02f, 2.17374519e-01f, 5.92952147e-02f, 1.07325733e-01f, 1.23482145e-01f, 1.31375477e-01f,
  1.58317775e-01f, -2.34648645e-01f, 7.07468763e-02f, -3.50322276e-02f, -1.11953363e-01f, -6.02483638e-02f, 1.22558000e-02f, 7.83025473e-02f, 4.46199067e-03f, -3.00628524e-02f,
  -7.84694105e-02f, 1.70101553e-01f, 7.61696324e-02f, 1.27491340e-01f, 5.64091727e-02f, -3.30146728e-03f, -5.78096807e-02f, 2.64720544e-02f, 2.77371019e-01f, 4.22590673e-02f,
  1.81923322e-02f, -9.31803361e-02f, 1.32301617e-02f, 3.62162106e-02f, -1.51086137e-01f, 6.00354783e-02f, -1.13169089e-01f, -1.53680637e-01f, -6.67317286e-02f, -1.92476541e-01f,
  1.53807327e-01f, -1.69091299e-02f, 1.11664109e-01f, 3.40446420e-02f, 3.49149518e-02f, -5.19544594e-02f, -7.19405152e-03f, 5.83245605e-02f, -6.72437102e-02f, 4.54147123e-02f,
  -1.11905314e-01f, -2.80259792e-02f, 2.35933419e-02f, -5.19595630e-02f, 1.78226754e-02f, -7.35611320e-02f, -8.30139443e-02f, -5.47419637e-02f, 8.88043344e-02f, -6.74681086e-03f,
  -1.33568794e-01f, -5.16721085e-02f, -1.53980022e-02f, 6.88180700e-02f, 5.97982444e-02f, 2.80166771e-02f, 3.11534218e-02f, -1.04162835e-01f, -3.05595808e-04f, 2.87712310e-02f,
  2.45823078e-02f, 4.15093489e-02f, -1.70404315e-02f, -1.81081556e-02f, -7.30790496e-02f, 9.27353371e-03f, -5.63140772e-02f, 3.22696492e-02f, -9.21758637e-03f, -3.63068469e-02f,
  -8.37741494e-02f, -6.17389306e-02f, 2.86241714e-02f, -6.82746917e-02f, 4.65169922e-02f, -7.73848742e-02f, -8.07131752e-02f, -8.57907012e-02f, 5.57787865e-02f, -3.47684557e-03f,
  1.03639150e-02f, -5.63882058e-03f, -2.46419627e-02f, 3.98496315e-02f, 2.31396928e-02f, 7.14856060e-03f, 2.93260962e-02f, -4.96443128e-03f, -8.32933038e-02f, -7.60923419e-03f,
  1.06621139e-01f, -2.44881436e-02f, 1.13578588e-01f, 2.39450485e-02f, 7.77600929e-02f, 9.82807111e-03f, -1.27268182e-02f, -7.24001527e-02f, 4.87874374e-02f, 4.10866775e-02f,
  -3.92110460e-02f, 4.04021442e-02f, -2.42468808e-02f, 1.04243141e-02f, 6.74993992e-02f, 9.69903395e-02f, -4.80408818e-02f, 1.29860342e-02f, 1.77065842e-02f, -3.38503458e-02f,
  -4.79667485e-02f, 9.30918306e-02f, 8.73467848e-02f, -2.61999406e-02f, -1.48375053e-02f, 8.98048654e-02f, 9.72748548e-02f, 4.02331278e-02f, 1.60232052e-01f, -8.02215800e-05f,
  3.86872113e-01f, 7.76491268e-03f, 8.52163956e-02f, 1.15630083e-01f, -1.62616789e-01f, -2.38330558e-01f, -1.03139512e-01f, 4.46122251e-02f, -2.57845446e-02f, -3.77977267e-02f,
  -9.04629156e-02f, -8.51549208e-03f, 2.93990523e-02f, -5.13475612e-02f, 6.94510564e-02f, -8.85822624e-03f, -1.28449956e-02f, 6.84853643e-02f, 6.86962577e-03f, -2.00422809e-01f,
  -2.00266197e-01f, -3.56227485e-03f, 2.31305007e-02f, 9.27084461e-02f, 9.27011892e-02f, 8.57512429e-02f, 1.07954524e-01f, 5.15836887e-02f, 1.48144048e-02f, 1.56948864e-01f,
  1.99643537e-01f, -3.37341242e-02f, -4.46748324e-02f, -9.24586598e-03f, -8.31240937e-02f, 1.37631595e-01f, 5.77730536e-02f, 3.03839352e-02f, -3.51226665e-02f, 4.21820022e-02f,
  -4.64156643e-02f, 5.31526236e-03f, -9.01571810e-02f, -1.33572295e-01f, -1.53607689e-02f, 3.76771763e-03f, -8.39304030e-02f, 9.38574970e-02f, -1.37873497e-02f, 5.76269887e-02f,
  -1.81671366e-01f, -9.98383388e-02f, 7.89339021e-02f, -4.56729978e-02f, 1.07789367e-01f, 3.58648077e-02f, 1.45921074e-02f, 1.36433184e-01f, 3.66899855e-02f, 2.79799908e-01f,
  -1.88871399e-02f, 1.50686214e-02f, -3.60790342e-02f, 7.25061148e-02f, -8.18296243e-03f, -1.75967887e-02f, 4.72025685e-02f, -3.83472908e-03f, 1.51781728e-02f, 2.18470059e-02f,
  -4.58959229e-02f, -4.66522314e-02f, -4.39914316e-02f, 1.16305076e-01f, -1.80222355e-02f, -1.82324722e-02f, -2.88136080e-02f, -1.57418866e-02f, 8.27023983e-02f, 1.73678286e-02f,
  -3.76421139e-02f, -1.14965541e-02f, -4.11671698e-02f, -5.43523729e-02f, 3.97649333e-02f, 2.45779771e-02f, 2.44379342e-02f, -4.33877716e-03f, 3.58333848e-02f, -5.47553934e-02f,
  1.52309909e-01f, -9.49549899e-02f, 2.11260617e-01f, -1.48562919e-02f, 5.08813411e-02f, -6.65485039e-02f, 2.55414080e-02f, -3.79736573e-02f, -2.77556144e-02f, 6.63423538e-02f,
  -6.27453774e-02f, -3.57756913e-02f, 6.60048276e-02f, -1.30181136e-02f, 2.44728308e-02f, 2.73843035e-02f, 2.95027494e-02f, -1.93879157e-02f, 4.43074154e-03f, -7.52183944e-02f,
  -3.27333957e-02f, 5.96838631e-03f, 1.52991444e-01f, 9.50678438e-02f, 1.70030538e-02f, 1.46562338e-01f, 1.35015160e-01f, 1.15934946e-01f, 2.22916037e-01f, 2.95064002e-01f,
  -1.31998420e-01f, -3.92247401e-02f, -1.10370725e-01f, -1.64583981e-01f, 2.55011357e-02f, 1.51560351e-01f, 1.26579076e-01f, 1.10161722e-01f, -4.97287698e-02f, -1.12096682e-01f,
  1.16506182e-01f, 1.00046419e-01f, -6.31368309e-02f, 5.61319664e-02f, 1.04600348e-01f, -2.51911115e-03f, -4.30492498e-02f, -3.06051262e-02f, -3.14736413e-03f, 6.59027770e-02f,
  -1.05278909e-01f, -2.74078343e-02f, 5.99909201e-02f, -4.48931530e-02f, -1.23384662e-01f, -8.36217031e-02f, 3.43545824e-02f, -9.65373591e-02f, -8.42092112e-02f, -2.11095512e-01f,
  -5.62634654e-02f, -3.47417183e-02f, -8.86709243e-03f, 1.67492144e-02f, -1.05992638e-01f, -5.66137694e-02f, -8.15712288e-02f, -1.39765386e-02f, -1.82798561e-02f, -6.29011691e-02f,
  -3.55513506e-02f, -6.15724251e-02f, 2.78020073e-02f, 2.37881485e-02f, 3.47281359e-02f, -3.69756259e-02f, 3.65759991e-02f, 3.15515436e-02f, 1.17588174e-02f, 7.20551312e-02f,
  -5.33752553e-02f, -5.92387561e-03f, -4.53751795e-02f, 3.53684463e-02f, 1.88072938e-02f, -1.61877796e-02f, 1.44086508e-02f, 9.86208990e-02f, 1.37840047e-01f, -9.46140662e-02f,
  -5.86881861e-02f, -2.12348290e-02f, 1.97348371e-02f, -5.25210686e-02f, 4.62656766e-02f, 6.36303127e-02f, -8.68758485e-02f, -7.12252082e-03f, -1.03415670e-02f, 5.93067892e-02f,
  5.34939133e-02f, 6.29193038e-02f, -4.33558151e-02f, 1.39594125e-02f, 3.20221409e-02f, -6.34457543e-02f, 5.03158011e-02f, -8.72188620e-03f, -4.07349020e-02f, -1.22992892e-03f,
  -3.12135164e-02f, 2.76723295e-03f, -6.73958734e-02f, 3.80517147e-03f, -3.87623236e-02f, 2.25308258e-03f, 9.40932892e-03f, 8.31796601e-02f, -8.85768887e-03f, 2.57362537e-02f,
  8.48211646e-02f, 1.95639819e-01f, -4.61295731e-02f, -6.79754391e-02f, -2.88820136e-02f, 6.28044596e-03f, -5.19515648e-02f, 1.99906863e-02f, 4.57051396e-03f, 3.83847468e-02f,
  -4.12320942e-02f, 3.09803989e-02f, -4.32892665e-02f, 6.23430638e-03f, 3.07144914e-02f, 3.64551730e-02f, -2.18800623e-02f, -1.82943325e-02f, 5.00836372e-02f, 2.96088643e-02f,
  4.72463220e-02f, -2.16804910e-02f, -1.47806462e-02f, 4.30358760e-02f, 5.53370193e-02f, -1.30475033e-03f, 3.70715596e-02f, -2.27090605e-02f, 1.17533028e-01f, 3.71765308e-02f,
  3.51537377e-01f, -1.66625679e-01f, -1.55489281e-01f, 1.49195910e-01f, -2.17507243e-01f, -2.53296018e-01f, -3.28177482e-01f, 1.70060378e-02f, 2.07523927e-02f, 5.04821213e-03f,
  2.20468994e-02f, 1.74124122e-01f, 1.75766364e-01f, -3.01496097e-04f, 9.85817313e-02f, -1.88141242e-01f, -2.04445630e-01f, 5.15426993e-02f, 5.83181605e-02f, 6.92779571e-02f,
  -6.48176670e-02f, 1.58563033e-01f, 2.12896690e-01f, 7.44673833e-02f, -4.57443930e-02f, 1.02875836e-01f, -5.43824248e-02f, 2.43921541e-02f, -2.01431056e-03f, -1.36833135e-02f,
  4.24085148e-02f, -6.72768727e-02f, -9.51364413e-02f, 5.87434433e-02f, -8.24250802e-02f, 3.49302590e-02f, -1.56033377e-03f, 7.08001405e-02f, 2.67394092e-02f, 3.13749090e-02f,
  2.41295062e-02f, 7.80211985e-02f, 1.30629325e-02f, 7.67087713e-02f, 4.96066511e-02f, -5.91198867e-03f, 1.10452510e-01f, 1.25321776e-01f, 5.69532998e-02f, 8.34716111e-02f,
  -1.29028773e-02f, -1.36899993e-01f, -8.51306915e-02f, -9.39914137e-02f, 1.79007258e-02f, 4.61291969e-02f, 5.76938968e-03f, 7.91751817e-02f, -4.84282672e-02f, 1.38665423e-01f,
  -3.23063582e-02f, 3.39911655e-02f, 6.43876195e-03f, -1.57084167e-02f, 4.83845994e-02f, -5.85885234e-02f, 4.28657271e-02f, -9.10879225e-02f, -7.33805646e-04f, 6.85349330e-02f,
  -2.60177758e-02f, -8.24982859e-03f, 8.88823904e-03f, -4.87731062e-02f, -2.80477144e-02f, 2.48218216e-02f, 2.58393469e-03f, -1.90221444e-02f, -4.26232815e-02f, 1.99915823e-02f,
  -9.62338131e-03f, 2.08445489e-02f, 7.65317678e-03f, 6.00521872e-03f, -1.87376812e-02f, -9.06473864e-03f, -5.37917018e-02f, -7.61364959e-03f, 1.01449825e-01f, -4.46880423e-02f,
  5.28416932e-02f, -1.47813827e-01f, 1.58259738e-02f, 8.31526071e-02f, -2.14459375e-02f, 2.62164976e-02f, -4.39959839e-02f, -3.11504658e-02f, 5.65186739e-02f, 6.77983761e-02f,
  -1.64936092e-02f, -1.97609682e-02f, 5.97776584e-02f, -2.58278027e-02f, -5.94496652e-02f, -4.52144369e-02f, -1.29286880e-02f, -9.88306291e-03f, -2.06244495e-02f, -2.15808190e-02f,
  -2.59602871e-02f, -6.65753782e-02f, 9.24360647e-04f, -6.54152781e-02f, -5.54249920e-02f, -8.56596790e-03f, -1.14975534e-01f, -5.34167662e-02f, -4.98281866e-02f, -3.71664464e-02f,
  2.91293673e-02f, 6.69321194e-02f, -8.84493664e-02f, 1.11085221e-01f, -5.23039550e-02f, -1.86831310e-01f, -1.39889449e-01f, -2.02484891e-01f, 1.21994652e-02f, 3.96173187e-02f,
  8.38577524e-02f, 1.44465551e-01f, -4.88462150e-02f, 1.00853937e-02f, -1.46754339e-01f, -1.07058488e-01f, -1.43627375e-01f, -1.72654793e-01f, -1.28234193e-01f, 2.49307156e-02f,
  7.99098834e-02f, 1.08906450e-02f, 2.64306664e-02f, -2.67900992e-02f, 1.98618442e-01f, 4.22940478e-02f, -4.77755442e-03f, 9.69667137e-02f, -4.84550036e-02f, 1.41480148e-01f,
  1.57561779e-01f, 1.57330278e-02f, -4.21746692e-04f, 7.89017156e-02f, -4.46673445e-02f, -9.72271562e-02f, -3.13122896e-03f, -5.84112667e-02f, 4.74856123e-02f, -3.33838835e-02f,
  1.20828845e-01f, -2.53320001e-02f, 1.04052626e-01f, -1.00068944e-04f, -5.99155426e-02f, -4.99172695e-02f, 7.36183971e-02f, -1.02221988e-01f, -5.78072853e-02f, -2.63080020e-02f,
  9.36401859e-02f, 4.26421613e-02f, -6.55911863e-02f, -1.36877269e-01f, -5.45538515e-02f, 5.53505495e-03f, -7.51606151e-02f, -1.39398202e-02f, -5.72221838e-02f, 1.47380769e-01f,
  1.72585398e-02f, 7.30308751e-03f, 5.31919673e-02f, -2.57171299e-02f, 4.22062762e-02f, 7.17020482e-02f, -2.83258334e-02f, 4.73596007e-02f, -5.72227202e-02f, -1.10089844e-02f,
  5.80687523e-02f, -2.47278195e-02f, 2.19785366e-02f, -7.77272061e-02f, 1.06731020e-01f, -5.61200008e-02f, -8.84357467e-03f, 2.14351285e-02f, 4.48866158e-05f, 2.00357847e-02f,
  6.85836822e-02f, -8.35374221e-02f, 9.87759233e-03f, -7.44746551e-02f, 5.38608171e-02f, 2.92937420e-02f, 6.35453612e-02f, -7.16770664e-02f, -6.06502220e-02f, -4.35166284e-02f,
  9.78375748e-02f, -9.01609808e-02f, 1.52773634e-01f, 5.13644144e-02f, 8.09811801e-02f, 7.93654993e-02f, 1.18632562e-01f, 3.55557725e-02f, -3.24987024e-02f, -3.58594395e-02f,
  -8.61780047e-02f, 6.12587966e-02f, 8.49958882e-03f, 2.45206542e-02f, 5.57799563e-02f, -5.47331721e-02f, 7.90243819e-02f, 4.05233279e-02f, -2.37994697e-02f, 1.20060958e-01f,
  -6.00942075e-02f, -4.91932333e-02f, -6.27186596e-02f, -6.98052496e-02f, 2.80595478e-02f, -4.06959355e-02f, -6.88697994e-02f, 9.25028697e-03f, -8.48763660e-02f, -1.80395637e-02f,
  -1.70980334e-01f, 2.27598771e-01f, -1.18008859e-01f, 5.82519872e-03f, 1.18751518e-01f, 7.11890236e-02f, 2.64495671e-01f, 8.72530490e-02f, -3.08764819e-02f, 1.68973818e-01f,
  -8.13408196e-03f, -1.47752613e-01f, -3.65760289e-02f, -1.34456098e-01f, -1.25214174e-01f, 1.73132509e-01f, 8.69272575e-02f, -1.83521882e-01f, -1.84702709e-01f, -1.20016858e-02f,
  1.27428873e-02f, 3.40756103e-02f, -1.50476784e-01f, -8.32516626e-02f, 1.28909960e-01f, 6.02714606e-02f, 2.24632081e-02f, 3.13800164e-02f, 9.82276350e-03f, 1.88148946e-01f,
  -4.34119664e-02f, -8.23398978e-02f, 2.68101580e-02f, -5.56389987e-02f, -3.45431119e-02f, -1.22824870e-02f, 3.64128053e-02f, 4.12229337e-02f, -3.67653184e-02f, 1.91800054e-02f,
  2.49994490e-02f, 1.51241133e-02f, 1.55346785e-02f, -4.77216356e-02f, -4.89560561e-03f, 3.94123644e-02f, -7.59450197e-02f, -6.04439937e-02f, -9.53023881e-03f, -3.99418250e-02f,
  -4.15836200e-02f, 5.54189645e-02f, -7.10635036e-02f, -4.84218933e-02f, -9.79358479e-02f, -2.98696011e-03f, 7.01881498e-02f, -9.25710350e-02f, -7.66752213e-02f, 7.64074624e-02f,
  4.35696356e-02f, -6.86760694e-02f, -8.24909583e-02f, 4.15439010e-02f, 4.29528989e-02f, 1.47404177e-02f, 2.02975073e-03f, 4.18393500e-03f, -3.64180421e-03f, 3.49869914e-02f,
  1.85288042e-02f, 4.75910008e-02f, -2.12718435e-02f, 3.09466179e-02f, 5.55214994e-02f, -3.02923545e-02f, -7.13393167e-02f, 2.23416071e-02f, 4.16385196e-02f, -4.52645905e-02f,
  -3.40231694e-02f, 1.71073824e-02f, 8.71364772e-02f, -2.96007488e-02f, 2.93696579e-02f, -4.32355627e-02f, -1.82111450e-02f, -3.68741900e-02f, -4.77130488e-02f, -8.69596028e-04f,
  8.17664936e-02f, -1.44005939e-01f, 5.88377491e-02f, 3.12866941e-02f, -1.90172680e-02f, 7.92573914e-02f, -5.49418442e-02f, -7.79553503e-02f, 8.64294358e-03f, -6.60873130e-02f,
  -1.24185115e-01f, 5.29740341e-02f, -3.39274621e-03f, 6.06999034e-03f, 5.12371249e-02f, -7.41590038e-02f, -5.90519374e-03f, -6.00007400e-02f, -8.26438591e-02f, 1.62887406e-02f,
  7.17818961e-02f, 1.42714838e-02f, 5.76757155e-02f, 6.58237636e-02f, 8.61952901e-02f, 1.59047004e-02f, 3.81570347e-02f, 5.84508553e-02f, 8.03220794e-02f, 2.85450488e-01f,
  -3.62346545e-02f, -3.60998884e-02f, 1.76048011e-01f, -9.44272578e-02f, 1.28318191e-01f, 2.22151354e-01f, 1.60080969e-01f, 1.18071422e-01f, 1.73853375e-02f, -2.03803796e-02f,
  -3.02482247e-02f, -1.58309210e-02f, -1.95422620e-02f, -5.46082705e-02f, -3.38013023e-02f, 9.96897370e-02f, 2.56925207e-02f, 1.78463995e-01f, 1.89306825e-01f, 4.06246372e-02f,
  8.12472403e-02f, -8.95660296e-02f, -9.65424776e-02f, 3.25685963e-02f, 5.09787351e-02f, -7.81014338e-02f, -1.33011509e-02f, 3.87030914e-02f, -5.45737334e-02f, 8.57517496e-02f,
  1.02648824e-01f, 2.07861420e-02f, 9.66331214e-02f, 6.49368274e-04f, -4.74881828e-02f, 3.57829407e-02f, 3.65189239e-02f, -7.72003978e-02f, -2.99842525e-02f, -4.71534766e-02f,
  -3.22948676e-03f, 3.82590294e-02f, -1.74064899e-03f, 6.83651790e-02f, -1.61345454e-03f, 8.92084092e-02f, -3.79887074e-02f, 2.80520450e-02f, 9.53991115e-02f, -1.24186100e-02f,
  2.24353522e-02f, 4.02202271e-02f, -2.95314547e-02f, 5.66152744e-02f, -4.78153415e-02f, -8.05602521e-02f, 6.52788430e-02f, 4.52167243e-02f, -3.95522267e-03f, -5.70181869e-02f,
  7.12831840e-02f, -1.74320601e-02f, 6.85405359e-02f, -7.58290589e-02f, 3.27815339e-02f, -5.92925623e-02f, 5.98900281e-02f, -1.22153554e-02f, 3.19256522e-02f, 4.00272980e-02f,
  2.97764260e-02f, 8.87871385e-02f, -5.89381531e-02f, -4.28264588e-02f, 4.86330017e-02f, 6.53972775e-02f, 7.81452879e-02f, -8.18411410e-02f, 5.17345183e-02f, -2.78033055e-02f,
  -2.44397633e-02f, 2.90614869e-02f, -6.79576397e-02f, -7.87213445e-03f, 3.58012095e-02f, 5.23840450e-02f, -3.54809910e-02f, -2.90823970e-02f, -4.32794653e-02f, -7.97521416e-03f,
  -1.02103995e-02f, 1.09843656e-01f, 5.13531268e-02f, 4.51647565e-02f, 4.52517532e-02f, 1.09104868e-02f, 5.90726808e-02f, 4.52836379e-02f, -6.42732605e-02f, -2.47470457e-02f,
  9.04849470e-02f, -1.45503627e-02f, -4.39673811e-02f, 4.41075265e-02f, -2.09358912e-02f, 9.14798602e-02f, -9.08881947e-02f, 1.07412510e-01f, -3.59545946e-02f, -2.53613349e-02f,
  -4.07587513e-02f, -1.06046749e-02f, 3.48874964e-02f, 9.04175192e-02f, -3.00371833e-02f, 4.98842411e-02f, 1.22896492e-01f, 4.86811623e-02f, 4.06711176e-02f, 6.81616962e-02f,
  1.16142012e-01f, -8.35600719e-02f, 2.61283182e-02f, 1.16516009e-01f, 1.63102776e-01f, 1.78957984e-01f, 1.31907776e-01f, 6.13271222e-02f, -2.16153637e-02f, 1.20137595e-02f,
  -1.13766100e-02f, 2.50453595e-02f, 7.38970935e-02f, -3.63197252e-02f, 1.34006083e-01f, -8.12985469e-03f, -6.32013828e-02f, 3.83678079e-02f, 2.02593327e-01f, 6.62031174e-02f,
  1.49411364e-02f, -4.85054217e-03f, 5.83094079e-04f, 2.27497648e-02f, -7.74535164e-02f, 5.17194346e-03f, 4.82302085e-02f, -4.87396307e-02f, -1.20105840e-01f, -1.39506295e-01f,
  -1.08357228e-01f, 6.87951967e-02f, 1.11728519e-01f, -4.27138731e-02f, -1.48365907e-02f, -5.91676170e-03f, 5.28297871e-02f, 5.10504609e-03f, 7.71668106e-02f, -5.52971214e-02f,
  -4.68533933e-02f, 7.12909549e-02f, 8.71808529e-02f, 3.86283523e-03f, 6.42001703e-02f, 6.09931201e-02f, 6.59054145e-02f, 8.43392611e-02f, 1.69201344e-02f, -1.14413314e-01f,
  -1.13321654e-01f, 7.23855272e-02f, 8.76035262e-03f, -2.76521686e-03f, -1.16571439e-02f, 5.96490167e-02f, -3.91596742e-02f, -7.78710097e-02f, -6.76016062e-02f, -1.01670884e-01f,
  -1.09506108e-01f, -5.66489287e-02f, 6.70468761e-03f, -6.05377369e-04f, 8.09615850e-02f, 4.73045707e-02f, -5.63248582e-02f, -6.88296510e-03f, -1.81771093e-03f, 8.54595006e-02f,
  -3.44725773e-02f, -6.87396899e-02f, -1.51050827e-02f, 2.73619350e-02f, -8.09360668e-02f, 1.02747470e-01f, -4.16152813e-02f, -7.88040534e-02f, -9.78089217e-03f, -6.44214079e-02f,
  -4.96600717e-02f, -3.76885906e-02f, 5.33085093e-02f, -1.39111243e-02f, -2.60865632e-02f, -7.10037127e-02f, -7.97426179e-02f, -6.85341507e-02f, 1.06562257e-01f, 5.56288585e-02f,
  5.52244410e-02f, 1.46502554e-01f, -2.13510115e-02f, 2.91441480e-04f, 9.90836974e-03f, -2.89575942e-02f, 3.83592118e-03f, -3.82771939e-02f, 7.47768790e-04f, 8.21693689e-02f,
  -3.38107012e-02f, 1.00690126e-01f, -1.47163952e-02f, -2.73438171e-02f, 6.45918027e-02f, 1.22113131e-01f, -1.06146395e-01f, -1.93638552e-03f, -5.40540591e-02f, -8.67844447e-02f,
  3.11182607e-02f, 1.23627082e-01f, 1.14562310e-01f, -1.91205442e-02f, 5.25789075e-02f, 1.50495961e-01f, -1.91036966e-02f, 2.62551792e-02f, 1.34187490e-01f, -2.79388856e-02f,
  -2.35509232e-01f, 1.32009253e-01f, 2.69399881e-01f, 4.22842391e-02f, 2.01974642e-02f, -2.13362426e-02f, 1.91370800e-01f, 6.69297352e-02f, -9.07329172e-02f, 1.32433772e-01f,
  5.03341993e-03f, -1.51572719e-01f, -3.93556803e-02f, 4.31055911e-02f, 3.90851535e-02f, 2.38820866e-01f, 1.92815050e-01f, 4.07880135e-02f, -1.15474746e-01f, -1.30678862e-02f,
  -1.56298667e-01f, 1.82675049e-02f, -7.87329376e-02f, -2.52900999e-02f, 5.07667251e-02f, -4.73338254e-02f, 1.21107846e-01f, -7.80872405e-02f, 7.43616447e-02f, 1.94277409e-02f,
  1.44912228e-01f, -5.62437586e-02f, -3.15091684e-02f, -1.29639685e-01f, -1.44654820e-02f, 3.94734815e-02f, -2.02987511e-02f, -2.99347341e-02f, 8.35709367e-03f, 4.55529727e-02f,
  -4.77465009e-03f, -1.15344763e-01f, 3.35949659e-02f, -8.89510363e-02f, 6.04146114e-03f, -3.83257791e-02f, 1.09054737e-01f, 7.69491568e-02f, 4.51376289e-02f, -4.66976389e-02f,
  5.87151200e-03f, -6.02779426e-02f, 7.45791793e-02f, 5.68478182e-02f, 9.24649835e-03f, -1.07686080e-01f, -2.54530348e-02f, -4.50717248e-02f, 9.48129818e-02f, 1.23498730e-01f,
  6.07107300e-03f, -3.69527214e-03f, -3.90973501e-02f, -2.00053840e-03f, 2.00613104e-02f, -6.80251122e-02f, -3.09123509e-02f, 2.97224848e-03f, 1.33161684e-02f, 4.06095497e-02f,
  -1.91349667e-02f, 6.87116086e-02f, -6.98827878e-02f, -4.19719331e-02f, 5.60424291e-02f, -5.44093549e-02f, -1.98059510e-02f, -1.00584526e-03f, 4.13326435e-02f, -1.05451224e-02f,
  -4.19383049e-02f, 4.28322740e-02f, -4.41416353e-03f, -3.48125994e-02f, 5.43380901e-02f, 1.40406918e-02f, -4.43438478e-02f, 7.45207304e-03f, 4.10874858e-02f, -1.00080609e-01f,
  -1.72074176e-02f, 7.45153129e-02f, -1.10526085e-02f, -1.08297281e-02f, -6.31741881e-02f, -4.73705456e-02f, 4.29229103e-02f, 6.54223934e-02f, 6.55794237e-03f, 6.04083240e-02f,
  -6.74794912e-02f, 6.16465732e-02f, -5.83056640e-03f, -8.00409093e-02f, 2.01307423e-02f, 2.26536533e-03f, -7.26124039e-03f, 3.13576907e-02f, 2.64152568e-02f, 5.30931056e-02f,
  6.25525117e-02f, -6.25405237e-02f, 8.13490748e-02f, 2.32174415e-02f, -2.60326080e-03f, -8.48825052e-02f, 2.03745235e-02f, 7.00070411e-02f, -4.39606942e-02f, 1.67763084e-01f,
  6.22424781e-02f, 1.25695020e-01f, -3.48213986e-02f, 7.02507123e-02f, 6.75444230e-02f, 1.08279079e-01f, 6.69476464e-02f, 6.70891479e-02f, -1.26917483e-02f, -2.95607802e-02f,
  -8.05576742e-02f, -8.50073472e-02f, -1.46988496e-01f, -7.00117499e-02f, 2.04193089e-02f, 7.15577900e-02f, 6.52762875e-02f, 1.04398556e-01f, 6.29044250e-02f, 7.20266392e-03f,
  -6.43573701e-02f, 8.06099251e-02f, 2.78787711e-03f, -5.27760247e-03f, 9.77527201e-02f, 1.11229410e-02f, 4.43987884e-02f, 9.44863930e-02f, 5.68802133e-02f, 5.68728894e-02f,
  -5.41562736e-02f, 1.24190919e-01f, -4.04909365e-02f, -2.79681645e-02f, 2.10315473e-02f, -2.94237882e-02f, 5.56006692e-02f, 6.19970337e-02f, -3.12246885e-02f, -8.04632157e-02f,
  -8.33584517e-02f, 3.28434519e-02f, -8.79570562e-03f, 3.84156741e-02f, -5.54113574e-02f, 4.11087200e-02f, 6.09221272e-02f, 9.76636037e-02f, -1.45540386e-02f, 2.86464952e-02f,
  -4.40739617e-02f, 4.05411795e-02f, -2.38023102e-02f, -4.83822729e-03f, -6.48391154e-03f, -7.91888610e-02f, 7.55489394e-02f, 8.43679905e-02f, 8.52951221e-03f, 1.00226954e-01f,
  8.29354078e-02f, -6.34987950e-02f, 5.07600531e-02f, -2.76618432e-02f, -6.02058806e-02f, 5.00460677e-02f, 8.12910572e-02f, 7.98953474e-02f, 2.22831015e-02f, 6.90312982e-02f,
  -1.07568800e-02f, 1.38950301e-02f, 3.04803569e-02f, -4.31533270e-02f, -7.02362061e-02f, 4.91786338e-02f, 8.54864791e-02f, -7.38117322e-02f, 4.09468114e-02f, -7.87369534e-02f,
  -2.77896114e-02f, 2.42517330e-02f, -5.31137176e-03f, -5.33214882e-02f, -8.66697729e-03f, 3.68529223e-02f, 7.22813979e-02f, -1.37965812e-03f, -1.05072632e-01f, -7.74349794e-02f,
  -6.62252828e-02f, -1.48908338e-02f, 4.63264575e-03f, 8.36469606e-02f, -3.69849764e-02f, -2.49707047e-02f, 2.71015279e-02f, 1.77392829e-02f, -3.19201723e-02f, 3.52077782e-02f,
  3.26019735e-03f, 4.97655384e-02f, -4.74782996e-02f, -1.60643400e-03f, 4.61754343e-03f, 4.18659374e-02f, -5.19717671e-02f, -4.63085398e-02f, -8.00330192e-02f, 4.57958095e-02f,
  8.26720297e-02f, 2.35458314e-02f, -6.86944798e-02f, -5.63847199e-02f, 1.48946512e-02f, -6.35042042e-02f, -9.97587889e-02f, -6.61079735e-02f, -8.38141330e-03f, 6.00633174e-02f,
  1.64108112e-01f, 1.69708118e-01f, 4.57684174e-02f, 1.11776404e-01f, 9.26733762e-03f, 6.57512099e-02f, 2.88311411e-02f, -4.83605228e-02f, -5.10910451e-02f, 1.30155966e-01f,
  -9.62996334e-02f, -8.23203996e-02f, -6.72286600e-02f, -1.45979047e-01f, -4.01174761e-02f, 1.69015333e-01f, 1.40643835e-01f, -1.27500772e-01f, -2.07304209e-01f, -4.21683304e-02f,
  3.44273299e-02f, 8.88743997e-02f, -6.23531193e-02f, -9.42246914e-02f, 9.30303335e-02f, -4.91167530e-02f, -3.37621085e-02f, -5.25934435e-02f, 3.48436050e-02f, 4.72906753e-02f,
  4.27680574e-02f, 5.90288974e-02f, -1.25511706e-01f, -8.03188533e-02f, 3.52093503e-02f, 8.29189122e-02f, -2.14661155e-02f, 6.02983683e-02f, 2.76868958e-02f, 1.82170644e-02f,
  -5.48393950e-02f, -7.48729184e-02f, -1.10284500e-02f, 1.63268447e-02f, -7.92925432e-03f, 1.04306921e-01f, -1.39058642e-02f, -2.42641028e-02f, 2.64920443e-02f, 7.66595379e-02f,
  3.61077897e-02f, 3.17337774e-02f, 8.54550898e-02f, -3.01516633e-02f, 8.13216045e-02f, 2.87578218e-02f, 3.77684459e-02f, 6.82350770e-02f, 5.36716171e-02f, 1.31279811e-01f,
  -6.22964688e-02f, -1.98110361e-02f, -6.51293397e-02f, -2.27192808e-02f, 3.84442583e-02f, -5.92648797e-02f, -1.25329010e-02f, -7.11005926e-02f, -5.12645766e-02f, 8.53661522e-02f,
  -3.55083123e-02f, -3.48106679e-03f, -1.15931081e-02f, 6.46760464e-02f, 1.17123537e-02f, -2.46957759e-04f, -4.44068648e-02f, 4.87902574e-02f, 5.18094748e-02f, -8.69719684e-03f,
  -4.52657789e-02f, -2.89045721e-02f, -1.04117161e-02f, 6.70900494e-02f, -1.68436132e-02f, -8.80981088e-02f, -6.40975162e-02f, -1.96555071e-02f, -6.93671107e-02f, 6.37140721e-02f,
  1.15409628e-01f, -1.42201811e-01f, 4.42522019e-03f, 7.28425607e-02f, 5.61177060e-02f, 3.47426496e-02f, -2.88154576e-02f, -3.62976231e-02f, -6.09063543e-02f, 8.66449177e-02f,
  3.77939641e-02f, 7.30223116e-03f, 1.05019853e-01f, 4.42966335e-02f, 4.56636213e-03f, 2.93820985e-02f, 1.51653752e-01f, 1.84072088e-03f, 3.05656865e-02f, 1.28466696e-01f,
  8.94912332e-02f, -2.55491119e-02f, 8.64490867e-02f, 2.99487542e-02f, 4.70583290e-02f, 6.54241070e-03f, 2.31181793e-02f, 1.64108705e-02f, -5.90885989e-02f, 1.27965450e-01f,
  -2.03546971e-01f, -7.08247200e-02f, 7.02583119e-02f, 6.93596005e-02f, -6.28224462e-02f, -3.56807038e-02f, 4.12162282e-02f, 5.45040220e-02f, 1.13559678e-01f, 1.10134326e-01f,
  -5.40801547e-02f, -7.47154579e-02f, 2.21998300e-02f, 5.87945208e-02f, -7.42482096e-02f, 1.70363516e-01f, 1.03237025e-01f, -3.21459137e-02f, 2.19525360e-02f, 2.86574680e-02f,
  7.67688006e-02f, 4.54581417e-02f, -7.85784349e-02f, -5.27871288e-02f, -1.72147453e-02f, 6.88095689e-02f, 9.17220786e-02f, 4.72861752e-02f, 5.59228249e-02f, -3.10080983e-02f,
  8.63768458e-02f, -2.07189098e-01f, 4.89719659e-02f, -9.47980583e-02f, 3.15518305e-02f, -9.67620593e-03f, 3.71301882e-02f, 2.62000170e-02f, -5.31787015e-02f, -5.18230833e-02f,
  5.96541502e-02f, -2.37481501e-02f, -1.31487548e-01f, 3.82919461e-02f, -5.42691685e-02f, -2.31059305e-02f, 9.03861225e-02f, 9.22953524e-03f, 7.41783530e-02f, 1.05540581e-01f,
  -4.05055843e-03f, 1.98223107e-02f, 5.48782572e-02f, -3.18606347e-02f, -1.11906923e-01f, -1.18141472e-01f, -5.44310808e-02f, 1.03055686e-03f, -3.01267598e-02f, 1.39003664e-01f,
  -8.72379467e-02f, -1.28814653e-01f, 3.58824022e-02f, 4.73380787e-03f, -2.09645405e-02f, 5.28654717e-02f, 3.92577499e-02f, -2.40358207e-02f, 3.71428765e-02f, -7.55476858e-03f,
  -9.30118933e-03f, 4.57531363e-02f, -2.88667362e-02f, -1.26992483e-02f, -2.80379690e-03f, 5.17553017e-02f, 3.26889306e-02f, 1.52942762e-02f, -5.12223169e-02f, -6.11901209e-02f,
  4.62290719e-02f, -5.42932525e-02f, 7.35817999e-02f, 8.67814273e-02f, -7.63330013e-02f, 1.06471451e-02f, 3.61299254e-02f, 3.85453552e-02f, -3.52273248e-02f, 2.20015887e-02f,
  2.00299412e-01f, -1.45988941e-01f, 1.15651479e-02f, 1.64504535e-02f, -3.72271463e-02f, 1.66851226e-02f, -1.02902958e-02f, 7.77460216e-03f, -8.74143317e-02f, 4.46393788e-02f,
  -1.20124323e-02f, -6.32966906e-02f, 7.84062035e-03f, 2.70025874e-03f, -1.98560823e-02f, -3.77238952e-02f, 1.10665716e-01f, 4.49023657e-02f, 8.97058621e-02f, 5.68070542e-03f,
  1.03557751e-01f, 1.54866830e-01f, 1.89240620e-01f, 6.22597560e-02f, -3.67755406e-02f, 1.64232310e-02f, 3.45900352e-03f, 1.21963665e-01f, 9.31879133e-02f, 3.03121716e-01f,
  -1.17257841e-01f, -5.57274111e-02f, -3.20589900e-01f, -2.51908511e-01f, -1.40296623e-01f, -8.00755769e-02f, -1.67211294e-01f, 2.85773203e-02f, -1.45060658e-01f, -1.74011905e-02f,
  -1.43440440e-01f, -8.88946205e-02f, -8.63395184e-02f, -7.59536847e-02f, -1.02796167e-01f, -1.46967381e-01f, -1.45145684e-01f, -1.27736196e-01f, -3.49725299e-02f, -6.97702691e-02f,
  -7.06877112e-02f, -1.62918374e-01f, -8.65331218e-02f, 3.39752389e-03f, -4.37662154e-02f, -9.60287079e-02f, -1.45237520e-01f, -2.24799886e-02f, 2.95797479e-04f, -5.17819747e-02f,
  -1.46000803e-01f, -2.01749280e-01f, 4.25311364e-02f, 4.47614044e-02f, -6.61612907e-03f, 5.96117415e-02f, -7.43045807e-02f, -4.23751846e-02f, 1.07392669e-01f, -5.43630011e-02f,
  -1.02126338e-01f, 3.73119153e-02f, -8.06572363e-02f, 1.95536260e-02f, 1.27554806e-02f, -2.06890740e-02f, 6.38830364e-02f, -4.73852456e-02f, 1.07746897e-02f, 7.39444271e-02f,
  1.43956952e-02f, -1.10533992e-02f, -3.20163295e-02f, -1.03290901e-02f, 3.28668766e-02f, -9.01920274e-02f, 1.44875366e-02f, 1.09468326e-01f, -4.46615554e-03f, 3.93277444e-02f,
  5.94590306e-02f, -3.70356478e-02f, 9.79875308e-03f, -7.32326508e-02f, 1.35348216e-02f, 1.39095141e-02f, -5.51511906e-02f, 2.17766035e-02f, 1.03091793e-02f, 7.72367418e-02f,
  1.19013451e-02f, -8.98452941e-03f, -4.48817126e-02f, -6.78232983e-02f, -1.73056824e-03f, 4.13367674e-02f, 1.19758397e-01f, 8.97723958e-02f, -2.48496365e-02f, 2.81930566e-02f,
  -1.06491502e-02f, 6.48507029e-02f, -5.31720184e-03f, -9.82895028e-03f, -3.65016470e-03f, 2.38645114e-02f, -7.59508414e-03f, 5.36456630e-02f, -1.18453257e-01f, 8.03845841e-03f,
  -1.50143370e-01f, -2.47875191e-02f, -3.00223213e-02f, 2.55173370e-02f, 7.16445316e-03f, 3.24113630e-02f, 4.00815047e-02f, 7.29637519e-02f, 9.94373765e-03f, 1.87537409e-02f,
  3.64851914e-02f, -1.82042364e-03f, -1.27326325e-01f, 1.28408018e-02f, 2.49461904e-02f, 2.49811690e-02f, -2.17627026e-02f, -1.60792936e-02f, -6.15828671e-03f, 1.08242318e-01f,
  4.39714305e-02f, -5.83153730e-03f, 4.46962528e-02f, -3.85535099e-02f, 9.81711596e-02f, -1.11651756e-01f, 9.82349217e-02f, 3.87772620e-02f, 1.10611804e-01f, 1.27639085e-01f,
  -2.50005662e-01f, -5.47588542e-02f, 8.80128741e-02f, -1.17157377e-01f, -3.55350673e-02f, 1.68085709e-01f, 2.48582378e-01f, 2.37404760e-02f, -1.70036536e-02f, 4.13341746e-02f,
  4.04190123e-02f, -8.96096528e-02f, -2.85179764e-02f, 2.03544777e-02f, 3.77406403e-02f, 5.70229590e-02f, -1.58444345e-02f, -6.12420514e-02f, 1.28788665e-01f, 5.19633628e-02f,
  -3.54434066e-02f, -4.57611308e-02f, -4.28387113e-02f, 4.23990302e-02f, -8.50049555e-02f, 8.07237849e-02f, -5.44938482e-02f, -3.99318635e-02f, -4.29860018e-02f, -1.94150582e-01f,
  -8.16385299e-02f, -1.67473823e-01f, 1.21775344e-01f, -2.44531278e-02f, 6.65342668e-03f, 3.38510647e-02f, 1.09396025e-03f, -4.28033359e-02f, -2.09460799e-02f, -4.88545820e-02f,
  -3.40983905e-02f, -1.12886116e-01f, -8.33592005e-03f, 1.84293408e-02f, 9.27789602e-03f, -3.04036383e-02f, -5.26721217e-02f, -1.22468330e-01f, 5.43277711e-02f, -8.24768245e-02f,
  -1.01938695e-01f, -9.44583938e-02f, -7.32914433e-02f, 9.17400122e-02f, 3.59889562e-03f, -1.11743249e-02f, -2.49535646e-02f, -8.26206058e-02f, 2.00287439e-02f, -4.31991927e-02f,
  7.31910542e-02f, 5.84832132e-02f, -5.44499159e-02f, 7.16717914e-02f, 3.95120680e-02f, 5.71653247e-02f, -2.61741225e-02f, 2.92255398e-04f, -1.24125304e-02f, -1.09866390e-03f,
  -8.94337986e-03f, 2.83210780e-02f, 9.79589224e-02f, 1.76305361e-02f, 2.02185307e-02f, -6.92664981e-02f, 6.29530922e-02f, -3.54797542e-02f, 2.75432151e-02f, 1.80093199e-02f,
  1.06937084e-02f, 6.20315820e-02f, -5.83759099e-02f, -3.44419740e-02f, -6.31310344e-02f, 3.55593972e-02f, 2.22245976e-02f, 1.83402188e-02f, -6.69757882e-03f, 1.24779558e-02f,
  1.18734904e-01f, 2.77700424e-02f, 5.69940768e-02f, 5.50544970e-02f, -4.75602187e-02f, -1.09095186e-01f, -5.04178368e-03f, -1.22492090e-02f, 3.55840474e-02f, 5.25724813e-02f,
  4.19657826e-02f, -6.15431368e-03f, -6.49681538e-02f, 3.28543223e-03f, 1.10426858e-01f, -1.66664664e-02f, 1.84685737e-02f, 6.09159432e-02f, 6.09022975e-02f, -6.84765726e-02f,
  1.88006647e-02f, 1.02909453e-01f, 7.26518556e-02f, 1.31139070e-01f, -1.73980109e-02f, 1.14944831e-01f, 2.00227812e-01f, 2.90720277e-02f, 1.65211931e-01f, 1.94413424e-01f,
  2.77812362e-01f, 1.94597661e-01f, 1.31925166e-01f, 1.95582643e-01f, 8.49168077e-02f, 1.94483213e-02f, 1.61985397e-01f, 2.13630293e-02f, 8.87532681e-02f, -1.58554725e-02f,
  -9.53927860e-02f, -5.18373288e-02f, -1.33647934e-01f, -5.95582940e-04f, 8.61420706e-02f, 1.62689418e-01f, 1.48562416e-01f, 8.97049531e-02f, -1.37803517e-02f, -5.58267124e-02f,
  3.68301272e-02f, 7.16359392e-02f, -1.91802334e-03f, 9.50499345e-03f, 1.54992091e-02f, -1.00212954e-01f, -7.75902718e-02f, -4.33603004e-02f, 2.20227782e-02f, 5.62111177e-02f,
  -4.86642160e-02f, 1.09395161e-01f, -7.47467652e-02f, 5.46410345e-02f, -3.40368226e-02f, -8.10457394e-02f, 8.80024284e-02f, -7.90712237e-02f, 3.89069542e-02f, -1.73622649e-02f,
  1.22481929e-02f, -3.49609600e-03f, 5.28554581e-02f, 2.09499747e-02f, -4.38145734e-03f, -7.59795457e-02f, 4.20759209e-02f, 8.83960277e-02f, 7.08967000e-02f, -6.26525143e-03f,
  -6.16540834e-02f, -1.87780801e-02f, 7.10652620e-02f, -8.56187120e-02f, 3.23710889e-02f, -6.85755685e-02f, 5.69148222e-03f, -8.71227533e-02f, 4.92711253e-02f, -5.86280376e-02f,
  -7.31556788e-02f, 1.09272311e-02f, -6.97233388e-03f, 4.35284488e-02f, 3.37188467e-02f, -2.14455593e-02f, -4.57005855e-03f, 1.05605433e-02f, -7.18389153e-02f, 6.08645938e-02f,
  3.79179232e-02f, 7.84151442e-03f, -5.18955328e-02f, 1.02067083e-01f, -1.93959065e-02f, -2.94168424e-02f, 2.14744505e-04f, 4.76609953e-02f, -1.01600759e-01f, 5.13949692e-02f,
  1.18254207e-03f, 4.92651910e-02f, -5.13983928e-02f, 3.74757908e-02f, 4.18404583e-03f, 4.59113196e-02f, 6.02868721e-02f, -1.24363035e-01f, -3.73664424e-02f, 1.74845289e-02f,
  2.54994202e-02f, 5.84242046e-02f, 7.93994442e-02f, 8.39997549e-03f, 7.12786913e-02f, -6.54642209e-02f, 1.67848803e-02f, -7.09528774e-02f, -3.44090424e-02f, 3.89729999e-02f,
  4.42457646e-02f, 7.75129721e-02f, -3.63837406e-02f, 7.22796749e-03f, 4.33137920e-03f, -2.74585970e-02f, -2.01839302e-02f, 4.26181331e-02f, -5.91710992e-02f, -2.03285702e-02f,
  -1.06307231e-01f, 4.46809940e-02f, 2.02245358e-02f, -8.35503079e-03f, -1.14016809e-01f, 5.22836596e-02f, 2.27773339e-02f, 4.17227633e-02f, -1.74731370e-02f, 7.87688345e-02f,
  -1.93082497e-01f, 3.60943116e-02f, -1.74635742e-02f, 6.13560379e-02f, -5.12974188e-02f, 3.81011963e-02f, 1.54158577e-01f, 5.32785989e-02f, 3.59397382e-02f, 2.47239545e-02f,
  -1.31823331e-01f, 1.25550246e-03f, 1.29685784e-02f, -6.19409680e-02f, -8.37375317e-03f, 2.08913311e-01f, 1.17615670e-01f, 3.35561410e-02f, -6.23349473e-02f, 7.52851442e-02f,
  5.91918603e-02f, -4.49787676e-02f, -1.55589497e-02f, 6.18322939e-02f, 7.93809891e-02f, 1.23833463e-01f, 8.35182611e-03f, 1.01201937e-01f, 9.50012580e-02f, 8.08077380e-02f,
  2.38089766e-02f, -1.58771664e-01f, 4.16025221e-02f, -8.56280401e-02f, -3.55560705e-02f, -8.12877193e-02f, 3.68797146e-02f, -1.00223280e-01f, -1.06185876e-01f, -5.07380515e-02f,
  -4.32837754e-03f, -2.19323337e-02f, 2.85878945e-02f, -3.48876379e-02f, 2.44098529e-02f, -2.00652368e-02f, -1.64324101e-02f, -4.74639423e-02f, -4.28453386e-02f, -4.27649560e-04f,
  1.00829273e-01f, 5.95789887e-02f, -4.21320423e-02f, -7.13013336e-02f, -3.62206101e-02f, 2.58488823e-02f, 7.40188733e-02f, 2.56443694e-02f, 7.74729773e-02f, 9.75359231e-02f,
  6.54955804e-02f, 2.54310183e-02f, 6.49124309e-02f, -6.62185252e-02f, 6.65943995e-02f, -6.91943103e-03f, 9.05240420e-03f, -2.06819410e-03f, -6.63957447e-02f, -2.29341052e-02f,
  -1.07618719e-02f, -1.87643971e-02f, -1.15968818e-02f, 4.08243090e-02f, 9.51894522e-02f, -6.04427904e-02f, -4.57780473e-02f, 6.32720441e-02f, -8.42739195e-02f, 7.02840388e-02f,
  -7.46406242e-02f, -3.36728729e-02f, -2.42530983e-02f, -5.35387024e-02f, -4.49879691e-02f, -2.83195544e-02f, 1.28707111e-01f, 4.65278402e-02f, 5.41100577e-02f, 8.69216546e-02f,
  8.38522241e-02f, -1.56972691e-01f, 1.10977821e-01f, 1.66418422e-02f, -6.34349361e-02f, -3.29832919e-02f, -3.38615105e-02f, -4.72301506e-02f, 5.98187000e-03f, -3.04070581e-02f,
  -6.06939234e-02f, 5.36746010e-02f, -2.96480861e-02f, 1.23427873e-02f, 5.94088947e-03f, 6.44549786e-04f, 7.99577981e-02f, 1.67090762e-02f, -6.29469529e-02f, -1.86576433e-02f,
  -3.95338088e-02f, 9.05773267e-02f, 2.42192317e-02f, 2.78580673e-02f, 7.20269382e-02f, 1.10605955e-01f, 1.11543454e-01f, 6.70588166e-02f, 5.10254353e-02f, 4.87259068e-02f,
  1.74942538e-01f, -2.92826742e-02f, 1.55284271e-01f, -1.76678225e-03f, 1.19633608e-01f, 4.33924943e-02f, 1.23219378e-01f, 6.24094494e-02f, 8.25472642e-04f, 4.43126969e-02f,
  -9.92851108e-02f, -8.26957226e-02f, 8.16108286e-02f, 2.03650631e-02f, 2.81276815e-02f, 1.72341049e-01f, 1.03331573e-01f, 2.83977002e-01f, 9.52680483e-02f, 1.18731454e-01f,
  1.67372450e-02f, 1.56574994e-01f, 9.68189910e-02f, 1.40257984e-01f, -6.54313117e-02f, 2.59443652e-02f, 7.26500228e-02f, -2.71200463e-02f, -9.39775407e-02f, 8.14006776e-02f,
  1.10336885e-01f, 1.05474904e-01f, 1.01048745e-01f, -2.71177143e-02f, -1.29505284e-02f, -1.66842956e-02f, -2.90486123e-02f, -1.52857583e-02f, -9.83842984e-02f, 3.08437198e-02f,
  -3.96338552e-02f, 5.92392012e-02f, -7.22022876e-02f, -2.30820216e-02f, 5.94120361e-02f, -4.37554088e-04f, 3.92682664e-03f, 1.09630875e-01f, 4.89768991e-03f, -2.40981057e-02f,
  -1.34209573e-01f, -1.64701417e-02f, 6.59738574e-03f, -6.14281446e-02f, -7.15299174e-02f, 4.72802445e-02f, -1.13005318e-01f, 2.50659250e-02f, -8.35642368e-02f, 4.67614867e-02f,
  -5.53193167e-02f, 6.58688555e-03f, -8.46348181e-02f, 1.20236995e-02f, 1.74996746e-03f, -5.65530034e-03f, 1.66841261e-02f, -3.81960635e-05f, 6.29341155e-02f, -4.79208156e-02f,
  3.22220810e-02f, -6.58106431e-02f, 3.60468589e-02f, 3.63122784e-02f, 3.51086296e-02f, -2.58096699e-02f, 2.00741198e-02f, 3.05776838e-02f, -1.04974762e-01f, -2.55666841e-02f,
  6.43890053e-02f, 2.38377657e-02f, 2.49629002e-02f, -6.03059568e-02f, 1.07883187e-02f, 5.03170863e-03f, -5.09953648e-02f, -6.41257390e-02f, -1.73119809e-02f, 7.45492950e-02f,
  -1.50450662e-01f, 6.67380542e-02f, -8.07998553e-02f, -2.64356639e-02f, 1.01368651e-01f, -3.16826440e-03f, 2.22211722e-02f, 3.55800316e-02f, 4.38788086e-02f, -3.34492549e-02f,
  -8.43361486e-03f, 3.53576280e-02f, -3.21707036e-03f, -5.58253825e-02f, 1.92778301e-03f, -5.13245724e-02f, 1.46773169e-02f, 3.50686796e-02f, -9.31935292e-03f, -3.60532179e-02f,
  -5.38600273e-02f, 2.14315802e-02f, -5.06707467e-02f, -1.14650950e-02f, -6.74693063e-02f, -3.41973044e-02f, 4.46929336e-02f, -4.06762883e-02f, 6.63168281e-02f, 2.75118332e-02f,
  -2.82840908e-01f, -2.06443071e-01f, -1.91423520e-01f, 2.39304136e-02f, -3.50275598e-02f, -8.26492235e-02f, -1.52517051e-01f, -1.99103579e-02f, 1.15966618e-01f, -5.91748431e-02f,
  -9.57968365e-03f, 1.54676437e-01f, 1.37568310e-01f, 3.10031306e-02f, 4.46819980e-03f, -7.06492439e-02f, -7.08216578e-02f, -4.79286723e-02f, -1.29883736e-02f, 1.41692953e-02f,
  2.10106060e-01f, 1.04532205e-01f, -7.78514892e-02f, 8.85495842e-02f, -3.72987203e-02f, -3.33117992e-02f, -9.78859439e-02f, -9.06645060e-02f, -6.33217916e-02f, -8.55277926e-02f,
  -1.74641237e-02f, -2.57273406e-01f, 1.06630139e-01f, 2.38935091e-02f, -6.13796292e-03f, -6.31709546e-02f, 8.95217527e-04f, -5.32165319e-02f, 7.87715390e-02f, 2.45825667e-02f,
  2.96957493e-02f, 1.01822428e-01f, 2.84228455e-02f, -4.01938185e-02f, 9.43108276e-02f, -2.63194907e-02f, 1.94510985e-02f, 6.78163627e-03f, -4.89440337e-02f, 1.25129968e-02f,
  -3.58334929e-02f, -1.65038794e-01f, -1.44634247e-01f, -1.00130811e-01f, -8.64610672e-02f, 1.38304122e-02f, -1.32202879e-01f, -5.41570261e-02f, -1.13362126e-01f, -1.52443975e-01f,
  3.07816695e-02f, -1.49905507e-03f, -2.85515934e-02f, -6.43222779e-02f, 4.88547459e-02f, 3.37604471e-02f, 5.00528477e-02f, -8.87120739e-02f, 4.20666151e-02f, -7.27586122e-03f,
  5.43206446e-02f, -1.20384708e-01f, 1.65712330e-02f, -7.99091086e-02f, 6.21740632e-02f, -1.40487319e-02f, 1.43247042e-02f, 2.29537543e-02f, -6.41730651e-02f, 1.01265439e-03f,
  -5.94994612e-02f, -6.68381676e-02f, 1.82836186e-02f, 3.08287842e-03f, 3.48779522e-02f, 8.62034690e-03f, 1.78126562e-02f, -8.62032082e-03f, -3.14376801e-02f, -1.41599681e-02f,
  1.59202710e-01f, -4.70420830e-02f, -2.93789264e-02f, 4.09746962e-03f, -6.28211200e-02f, 5.48615828e-02f, 5.76519594e-02f, 6.22042157e-02f, -3.82946022e-02f, -2.25108974e-02f,
  -9.02859643e-02f, -4.21882654e-03f, 1.66883916e-02f, 8.25750157e-02f, -9.19170119e-03f, 2.76335292e-02f, 5.09341881e-02f, -5.46125844e-02f, -5.99572361e-02f, 1.12093925e-01f,
  5.92912100e-02f, -6.00454817e-03f, -1.36680424e-01f, 2.84606533e-04f, -5.46477409e-03f, 4.22630506e-03f, -6.03778288e-02f, -4.88536805e-02f, -1.85680553e-01f, -2.13324334e-02f,
  -1.47315904e-01f, -1.74709503e-02f, 1.39084682e-01f, -1.56784236e-01f, -2.86459690e-03f, -9.66049135e-02f, -3.42269763e-02f, -5.84234893e-02f, -3.03734746e-02f, -7.14244395e-02f,
  5.41800484e-02f, 4.88694850e-03f, 1.09755635e-01f, 1.04103968e-01f, 1.03309834e-02f, 1.78960953e-02f, -3.52275595e-02f, -5.67672290e-02f, 1.97319705e-02f, -4.40402552e-02f,
  7.88777173e-02f, -9.74724907e-03f, -2.18673404e-02f, 4.11592200e-02f, 1.03713967e-01f, -6.60789311e-02f, 6.47154599e-02f, 6.48763776e-02f, 3.88965532e-02f, 9.77670774e-02f,
  4.19688411e-02f, 1.14527814e-01f, -9.57492646e-03f, -3.34606953e-02f, 1.09216593e-01f, 2.47082002e-02f, -3.03246956e-02f, -3.23698632e-02f, -4.93829586e-02f, 1.04498472e-02f,
  2.42228936e-02f, 6.80017695e-02f, 7.98238441e-02f, -1.19966501e-02f, -4.31681573e-02f, 5.52049577e-02f, 1.30486593e-01f, -5.65611711e-03f, 1.45806983e-01f, 7.65234306e-02f,
  1.71123132e-01f, 5.12351021e-02f, 1.50759425e-02f, 6.48456365e-02f, 1.56872392e-01f, 4.99753430e-02f, 7.46111348e-02f, 1.72594368e-01f, 5.27154617e-02f, -9.91688669e-02f,
  4.46688570e-02f, 2.19461247e-02f, 1.19780889e-02f, 1.32048260e-02f, -4.78094108e-02f, -5.44570349e-02f, -1.22540179e-04f, -9.75073129e-02f, -7.02836961e-02f, -5.32074571e-02f,
  -2.37496793e-02f, -2.35763285e-02f, -1.48077095e-02f, -6.66101202e-02f, 6.08648397e-02f, 3.00692674e-02f, -3.84719446e-02f, 4.30814747e-04f, 1.40153971e-02f, 2.97026727e-02f,
  -3.36494707e-02f, -5.52832000e-02f, -2.00567604e-03f, 2.88815107e-02f, 9.00972858e-02f, -3.77018154e-02f, 6.32239729e-02f, 6.99074492e-02f, 2.98605207e-02f, 6.76274449e-02f,
  -2.74796516e-01f, 1.68271422e-01f, -6.65162876e-02f, 9.06553026e-03f, -1.49825104e-02f, 3.37403119e-02f, 7.27859419e-03f, 1.16934376e-02f, 1.25273243e-02f, 2.16071345e-02f,
  8.87408294e-03f, -4.73377258e-02f, 4.43909988e-02f, -1.77327935e-02f, -8.26869383e-02f, -1.09994724e-01f, -5.62207736e-02f, -8.30042828e-03f, -3.80052850e-02f, 8.03817529e-03f,
  7.33580254e-03f, -2.01741159e-01f, -2.09528521e-01f, -1.15431204e-01f, 4.46282141e-02f, -1.43339261e-01f, -2.17643026e-02f, -1.63894325e-01f, -9.68756229e-02f, -3.89799833e-01f,
  -5.40089548e-01f, 7.71169439e-02f, 1.14236608e-01f, -1.97010353e-01f, 2.08189279e-01f, 7.33210295e-02f, 2.18789026e-01f, 5.61841913e-02f, -1.81969646e-02f, 1.54456049e-01f,
  -3.48501615e-02f, 7.01138703e-03f, -1.05165318e-01f, 3.82941440e-02f, -8.69534910e-02f, 1.54843524e-01f, 1.31450206e-01f, -1.67373568e-01f, -1.28210321e-01f, -1.33990958e-01f,
  -1.76842720e-03f, -6.53086826e-02f, -1.29825830e-01f, -1.29049033e-01f, 1.05533734e-01f, 8.34169015e-02f, 5.14123291e-02f, -1.52092595e-02f, 8.91657025e-02f, 1.40388206e-01f,
  4.58238721e-02f, -1.40570998e-01f, -1.82108097e-02f, -4.94129695e-02f, -3.93476449e-02f, -4.23441306e-02f, -4.51019593e-02f, 2.91667134e-03f, 3.71934213e-02f, 9.08872038e-02f,
  -1.61735397e-02f, 1.24729890e-02f, 3.47517245e-02f, -2.54352833e-03f, 1.45340338e-02f, -9.92037263e-03f, -7.22109452e-02f, -5.93958683e-02f, -7.99886733e-02f, 7.08482554e-03f,
  1.70837194e-01f, 8.49974230e-02f, -1.69248860e-02f, 6.48239180e-02f, -1.33686215e-02f, -6.64919615e-02f, 4.71066264e-03f, -8.53010267e-02f, -1.61222696e-01f, 4.37494442e-02f,
  -5.38747804e-03f, 1.38512179e-02f, 2.22757030e-02f, 2.87132729e-02f, -3.89736593e-02f, 4.22736332e-02f, 8.07598932e-04f, 2.35892590e-02f, -5.48840836e-02f, 7.14607462e-02f,
  1.36349816e-02f, -3.25817429e-02f, 2.75516161e-03f, -1.11937821e-02f, -4.26955484e-02f, 2.15796828e-02f, 3.28688808e-02f, 4.69315834e-02f, 7.79137248e-03f, -5.16129956e-02f,
  -9.60533097e-02f, 6.62779482e-03f, 7.21174851e-03f, 3.29987854e-02f, 1.04355752e-01f, -3.59305777e-02f, -1.21365720e-02f, -6.55393228e-02f, -1.58055946e-02f, -5.87017760e-02f,
  5.96248955e-02f, -5.03754988e-03f, 2.52454337e-02f, -6.22923523e-02f, 6.10791482e-02f, -5.60090169e-02f, 5.88123240e-02f, -1.08738989e-02f, -1.96069758e-02f, 4.72808778e-02f,
  6.61360100e-03f, -7.99653903e-02f, -3.88468429e-03f, 1.06690161e-01f, -4.57985289e-02f, -6.97924867e-02f, 5.92890382e-02f, -2.19226815e-02f, -3.32823135e-02f, 3.73562612e-02f,
  -2.09658034e-02f, -5.43731339e-02f, -1.01054013e-01f, 4.11129668e-02f, 5.40271476e-02f, -1.02089401e-02f, 5.81450760e-02f, 7.36866370e-02f, 7.03289593e-03f, 1.74490079e-01f,
  6.55806839e-01f, 1.97545722e-01f, -1.26929790e-01f, 2.73541272e-01f, 9.93490871e-03f, -1.30958945e-01f, -1.80577785e-02f, -4.21066992e-02f, 1.60589218e-01f, 1.13089427e-01f,
  -9.12854671e-02f, 1.92556735e-02f, -1.30865663e-01f, -7.35898837e-02f, -1.41796067e-01f, -1.10225558e-01f, -2.01342516e-02f, -1.55654371e-01f, -6.51583672e-02f, 2.39914842e-03f,
  -1.00357249e-01f, 1.29764453e-01f, 3.58652622e-02f, 8.27031583e-03f, -1.72972735e-02f, 2.45904680e-02f, -2.98155583e-02f, 7.77895451e-02f, -1.01380862e-01f, 4.88226209e-03f,
  -8.81757066e-02f, 1.77706540e-01f, -4.50363420e-02f, -4.94534038e-02f, -7.37583116e-02f, 1.03802383e-02f, -4.45315568e-03f, -1.03446338e-02f, -2.54216529e-02f, -5.68450312e-04f,
  3.31261614e-03f, -1.21762473e-02f, 1.97583605e-02f, -5.74775273e-03f, 8.60637203e-02f, 3.00911758e-02f, -1.78541541e-02f, -1.95549559e-02f, -3.38931419e-02f, -3.78724821e-02f,
  -4.35646251e-02f, 4.53353710e-02f, 3.06484085e-02f, -3.84469852e-02f, -7.23267645e-02f, -6.88589737e-02f, -1.26319662e-01f, 4.22102399e-03f, -5.19405585e-03f, 1.87638700e-01f,
  2.29421407e-02f, -5.39401099e-02f, -4.89405580e-02f, 5.07475659e-02f, -1.28704756e-02f, -2.66720235e-05f, -5.96337467e-02f, -3.10963318e-02f, -4.28139046e-02f, 8.17661881e-02f,
  -4.90319468e-02f, -2.93201301e-02f, -1.95894297e-02f, 5.50086349e-02f, -6.38866425e-02f, -2.19433662e-02f, 5.01595922e-02f, -5.02235293e-02f, 2.18669176e-02f, -3.31743360e-02f,
  2.40041055e-02f, -3.40885855e-02f, -2.42738463e-02f, -2.97867637e-02f, -7.97174573e-02f, -7.31137097e-02f, 7.64098018e-02f, -4.45226468e-02f, 6.71706647e-02f, 1.04806803e-01f,
  1.49370506e-01f, -2.14664191e-01f, 5.33644184e-02f, 8.88075028e-03f, 1.43832034e-02f, -3.13346423e-02f, -5.87290479e-03f, 1.93893500e-02f, 3.73354368e-02f, -2.01920234e-03f,
  -3.97438183e-02f, 6.46604002e-02f, 6.38939887e-02f, -1.15087382e-01f, -1.03418576e-03f, -3.22165713e-02f, -2.93810088e-02f, 2.02653166e-02f, -1.07775234e-01f, 2.05323435e-02f,
  5.15276194e-02f, -2.43881624e-02f, 8.56805295e-02f, 7.44129997e-03f, -1.69291012e-02f, -4.71746437e-02f, 2.47540828e-02f, 3.10792010e-02f, -4.38398421e-02f, 1.96001843e-01f,
  1.47208482e-01f, 3.83579582e-02f, -2.92208027e-02f, 1.41032219e-01f, -6.40958771e-02f, -2.73718163e-02f, -9.74931940e-02f, -8.83724317e-02f, -2.69120615e-02f, 6.17875494e-02f,
  -4.25854372e-03f, -2.12871991e-02f, 5.95202297e-02f, 3.75151634e-02f, -9.53226835e-02f, 9.48185567e-03f, 1.32900596e-01f, 5.47101125e-02f, 9.69167277e-02f, -1.42009405e-03f,
  1.13472231e-01f, 1.66354343e-01f, 9.36031993e-03f, 4.61955629e-02f, 1.45154893e-01f, 9.90312546e-02f, 3.85298878e-02f, 9.30984691e-02f, 1.06764764e-01f, 1.87112406e-01f,
  3.28761190e-02f, -8.00725073e-02f, -9.87531170e-02f, 2.89118271e-02f, 1.14370557e-02f, -2.78489739e-02f, 4.47564870e-02f, -6.81395456e-02f, -2.29252526e-03f, -1.48842158e-02f,
  5.34146093e-02f, 3.77059542e-02f, 6.96498305e-02f, -7.57818744e-02f, -6.70525134e-02f, 8.69144648e-02f, -6.41439781e-02f, -1.79698896e-02f, 4.23945412e-02f, -5.78087121e-02f,
  4.31081392e-02f, 1.15234479e-01f, -8.59150365e-02f, 1.27805630e-02f, -6.60834387e-02f, 4.11631651e-02f, 8.18108954e-03f, -4.19207849e-02f, 3.18308733e-02f, 7.38272369e-02f,
  7.72984102e-02f, -8.35072026e-02f, -7.38050640e-02f, 3.78009379e-02f, -1.92093644e-02f, 6.02072813e-02f, -6.27244338e-02f, 3.19169872e-02f, 3.38541344e-02f, 7.57306889e-02f,
  -2.82909796e-02f, -5.82838915e-02f, -4.99032252e-02f, -4.59649190e-02f, 1.81043043e-03f, 5.11449762e-02f, 3.77021506e-02f, 1.08755641e-02f, 9.05367509e-02f, 5.86089157e-02f,
  -2.35376991e-02f, 2.28714589e-02f, 1.78891700e-02f, 2.79664499e-04f, -5.32063432e-02f, 7.80322030e-02f, -6.98976740e-02f, 5.20820245e-02f, -7.61390403e-02f, 4.38038819e-02f,
  -2.78101917e-02f, -2.42759600e-01f, 2.24101674e-02f, 8.46122876e-02f, 4.86613140e-02f, -6.01348765e-02f, 3.33207883e-02f, 9.41149611e-03f, -4.21935581e-02f, 2.93772947e-02f,
  -1.41365835e-02f, -4.45529483e-02f, -7.86535218e-02f, 7.51732895e-03f, -4.03300747e-02f, 4.91689108e-02f, 8.45595226e-02f, 7.84185305e-02f, -5.03953807e-02f, -2.62399148e-02f,
  3.86806242e-02f, 1.10522948e-01f, 4.31379909e-03f, 5.38420081e-02f, 1.16266776e-02f, 1.04734994e-01f, -1.98050346e-02f, 7.69860893e-02f, -1.45343356e-02f, 1.70107976e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.14884803e-02f, -1.42456159e-01f, 1.00188792e-01f, 4.62085865e-02f, 3.78217502e-03f, 2.52762344e-02f, 7.87711740e-02f, 4.17934656e-02f, -7.43753091e-02f, -1.24841090e-02f,
  2.31450088e-02f, -7.16418847e-02f, -7.28986412e-02f, -2.19488349e-02f, -5.95862046e-02f, -8.09564516e-02f, 3.97556983e-02f, 2.07767654e-02f, 9.57483053e-02f, 1.01203889e-01f,
  -8.36216956e-02f, 4.07360047e-02f, 5.30633703e-02f, -6.99264929e-02f, -8.76944959e-02f, 3.32940109e-02f, -4.75921482e-03f, 5.37838899e-02f, 6.21231347e-02f, 7.59639367e-02f,
  8.74951631e-02f, -6.69746771e-02f, 5.83060011e-02f, -6.12084158e-02f, 6.57619387e-02f, -2.05218587e-02f, -3.66796851e-02f, -2.61388696e-03f, -9.33216214e-02f, 4.83050980e-02f,
  -4.23585549e-02f, -7.97128528e-02f, 4.47016135e-02f, 3.30320150e-02f, 6.17832839e-02f, -1.27504542e-02f, -1.00534894e-01f, 4.27274257e-02f, -8.53288472e-02f, 7.60377385e-03f,
  -7.66360238e-02f, -3.02339196e-02f, 2.57833768e-02f, -5.81824314e-03f, 3.35140638e-02f, 7.42554739e-02f, -1.13721043e-02f, -1.70870824e-03f, -2.64525488e-02f, -1.90967470e-02f,
  8.80181938e-02f, 1.03125814e-02f, -4.58247177e-02f, 9.94461775e-03f, -3.88147309e-02f, 1.00807240e-02f, -1.43148634e-03f, -9.30915959e-03f, 8.16019718e-03f, -6.04687966e-02f,
  -2.59746984e-02f, -4.42309268e-02f, 3.01413778e-02f, 7.08141476e-02f, -2.25752182e-02f, 8.16235691e-02f, -9.32818949e-02f, 7.16965459e-03f, 4.43496928e-02f, 7.98100308e-02f,
  -9.10878330e-02f, -1.60704553e-02f, 3.70614082e-02f, 6.50117639e-03f, -2.35916255e-03f, -5.91425337e-02f, -8.00700486e-02f, 3.50132398e-02f, 2.56224871e-02f, -4.28639874e-02f,
  2.62629464e-02f, 5.34630790e-02f, -6.43670037e-02f, -3.52814123e-02f, 6.48027286e-02f, -1.54844159e-02f, -8.33437070e-02f, -4.50386330e-02f, 6.33895630e-03f, 5.24136573e-02f,
  -1.02434345e-01f, 5.92019223e-02f, 1.05327265e-02f, -8.66606534e-02f, 2.26112418e-02f, 4.83046137e-02f, -2.84041706e-02f, -1.31508494e-02f, 4.47153747e-02f, -3.41053754e-02f,
  4.60929126e-02f, 4.60742228e-02f, 4.91263568e-02f, 1.63835399e-02f, -6.23498391e-03f, -2.04275604e-02f, 8.64585862e-03f, -1.75021193e-03f, 8.23299289e-02f, 1.13813661e-01f,
  1.41638801e-01f, 6.61376491e-02f, -3.01292744e-02f, 5.18495739e-02f, -1.89163780e-03f, -4.25912760e-04f, -7.69523978e-02f, -2.95483135e-02f, 6.33300543e-02f, -8.58721659e-02f,
  -5.77461086e-02f, 3.97479627e-03f, 3.92985195e-02f, 4.74941544e-03f, -5.22092022e-02f, 5.35269082e-02f, -6.43717051e-02f, 7.07699880e-02f, -5.62982149e-02f, 7.84811452e-02f,
  3.99178453e-02f, -2.39427723e-02f, -6.03310158e-03f, -6.75606132e-02f, -1.42422542e-02f, -5.72391525e-02f, 5.61582437e-03f, 1.37641057e-02f, 1.01146579e-01f, 1.05117694e-01f,
  8.01805928e-02f, 6.17008135e-02f, -1.47968316e-02f, 5.76853491e-02f, 4.23287041e-02f, 2.99264714e-02f, -3.53124365e-02f, -2.64833327e-02f, 4.24488448e-02f, -8.24288204e-02f,
  6.80022389e-02f, -1.27986344e-02f, 9.80085321e-03f, 3.82599160e-02f, 4.21280153e-02f, -6.24413006e-02f, 2.07683630e-02f, 4.11673933e-02f, 9.05928984e-02f, -4.72000465e-02f,
  3.11197131e-03f, 4.23093997e-02f, 8.90373439e-02f, -9.06949267e-02f, -1.12188291e-02f, -4.27216887e-02f, 9.26108658e-02f, -2.77943462e-02f, 4.30727154e-02f, -6.72297105e-02f,
  -6.98626488e-02f, 7.17811137e-02f, -7.14555904e-02f, -7.72169009e-02f, -3.83447446e-02f, -1.30768623e-02f, 5.31298406e-02f, 2.24954393e-02f, -7.35846013e-02f, 8.69666710e-02f,
  4.52597290e-02f, 6.12158291e-02f, -2.21704971e-02f, -8.77685621e-02f, -9.88431126e-02f, 6.39405698e-02f, 5.08346818e-02f, 1.16360458e-02f, -8.88462439e-02f, 4.93674837e-02f,
  -8.47169850e-03f, 4.03770842e-02f, 7.51603395e-02f, -5.06424569e-02f, 2.24189856e-03f, 7.84620568e-02f, 6.07171878e-02f, -6.49825260e-02f, 3.36863846e-02f, 7.84793347e-02f,
  -7.35553652e-02f, 5.68860359e-02f, -2.69769840e-02f, -4.54048999e-02f, 9.31187496e-02f, 9.15893093e-02f, -5.19107245e-02f, -6.07025512e-02f, 6.86167330e-02f, 2.72789248e-03f,
  -5.16327210e-02f, 7.05260932e-02f, -2.37051137e-02f, -4.35047457e-03f, 1.74992699e-02f, 3.52966459e-03f, 4.83518317e-02f, -7.35705644e-02f, -7.66073763e-02f, -3.36963534e-02f,
  -3.05831488e-02f, -4.84495936e-03f, -6.05817772e-02f, -1.14701234e-01f, 6.71444014e-02f, -2.76953820e-02f, 2.07197648e-02f, 4.03313972e-02f, -5.66942059e-02f, -6.90300092e-02f,
  -2.20245332e-01f, -1.57409851e-02f, -4.96698990e-02f, 4.81460504e-02f, 1.31493673e-01f, 1.08064465e-01f, -4.36007380e-02f, -2.28191130e-02f, -5.49281575e-02f, 6.61785156e-02f,
  8.42359364e-02f, 1.21475510e-01f, 1.00000612e-01f, 5.90040050e-02f, -2.68102828e-02f, 1.27943501e-01f, 5.32530695e-02f, -5.78728467e-02f, -8.28428380e-03f, 7.61134224e-03f,
  -1.72938388e-02f, -3.55827287e-02f, -9.27602053e-02f, -3.57737578e-02f, -2.77097505e-02f, 6.02533408e-02f, 8.35817493e-03f, -2.90203355e-02f, 1.40373528e-01f, 6.70513436e-02f,
  8.42783526e-02f, -5.21244742e-02f, -7.04867318e-02f, 1.80764161e-02f, -5.28797740e-03f, -2.28818022e-02f, 8.50995481e-02f, -1.19297415e-01f, -3.23702805e-02f, 8.18761345e-03f,
  6.95351884e-02f, 7.99736902e-02f, 2.02561282e-02f, -6.95376005e-03f, -1.00992121e-01f, 2.91335732e-02f, -7.80346850e-03f, -1.35218889e-01f, -1.14306174e-01f, -9.23766941e-02f,
  6.36889692e-03f, -6.03392795e-02f, -1.14963755e-01f, -8.76964852e-02f, -1.11418262e-01f, -9.25875679e-02f, -1.89176910e-02f, -7.39438385e-02f, -1.36907604e-02f, 8.09132028e-03f,
  1.80727970e-02f, 8.51091072e-02f, -3.66841964e-02f, 2.90297400e-02f, -6.89449906e-02f, 6.77973554e-02f, 2.59798090e-03f, -3.77036110e-02f, 2.45712698e-02f, 6.77239324e-04f,
  4.63365428e-02f, -7.21214563e-02f, -3.99052538e-02f, -7.22349286e-02f, 2.60455795e-02f, -5.12534976e-02f, -2.84102652e-02f, 8.19841772e-03f, -6.13754578e-02f, -6.19999617e-02f,
  6.03050813e-02f, 2.64472906e-02f, -7.83859715e-02f, 5.39987395e-03f, -3.09591722e-02f, -6.29550070e-02f, -4.72020507e-02f, -8.88429433e-02f, 9.99873318e-03f, -6.72118291e-02f,
  -7.35666826e-02f, 8.10939521e-02f, 9.05899778e-02f, -6.05506524e-02f, -1.95178632e-02f, -8.02489892e-02f, -4.60489355e-02f, -6.99747428e-02f, 7.92220607e-02f, -6.01776205e-02f,
  -7.31641725e-02f, -3.77898626e-02f, 1.10439956e-02f, -5.20817041e-02f, -5.94252385e-02f, -4.75910343e-02f, -1.98366400e-02f, 3.93417887e-02f, -9.16249454e-02f, -8.77290368e-02f,
  -1.42440582e-02f, -9.14178789e-02f, -1.43671006e-01f, -1.28479116e-02f, 3.99613194e-02f, 6.62893057e-02f, -1.31940648e-01f, 2.20891200e-02f, -1.39748484e-01f, -1.22213349e-01f,
  5.82709648e-02f, -1.20341763e-01f, 8.32863338e-03f, 1.70590263e-02f, 1.72643915e-01f, 7.72058442e-02f, 4.71242927e-02f, 1.09377049e-01f, 4.25233468e-02f, -7.30224624e-02f,
  -3.38399928e-04f, -4.90761325e-02f, -2.71278378e-02f, -4.62857671e-02f, -5.49731962e-02f, -1.32968165e-02f, 1.58617795e-01f, 3.02766357e-02f, 5.73642366e-02f, 1.27896264e-01f,
  7.69374892e-02f, 1.22976363e-01f, 3.36189866e-02f, 3.53332795e-02f, 9.14077908e-02f, -2.05249689e-03f, 2.20496152e-02f, -6.72610849e-02f, 6.62150756e-02f, 8.53390545e-02f,
  -1.54857457e-01f, -8.12588111e-02f, 9.66937467e-02f, 2.79887151e-02f, -1.17264293e-01f, 3.06887217e-02f, 6.86868355e-02f, -4.67013940e-02f, -5.26785292e-02f, 7.82486647e-02f,
  -9.61489882e-03f, -3.20485346e-02f, 5.62531017e-02f, 4.98225875e-02f, 5.72462985e-03f, 7.47958124e-02f, 3.39162648e-02f, -7.98606575e-02f, 5.29266745e-02f, -6.08415306e-02f,
  -6.50339276e-02f, -5.46962675e-03f, 4.84529249e-02f, 8.63483548e-02f, -3.46018225e-02f, -7.06177652e-02f, -4.66032661e-02f, -6.37940913e-02f, -9.41725671e-02f, 6.82280287e-02f,
  5.54627329e-02f, 4.88893054e-02f, 5.56675233e-02f, 3.52120325e-02f, 1.76294651e-02f, -3.67981307e-02f, -4.99940440e-02f, -3.99201550e-02f, -5.58155924e-02f, 4.16252129e-02f,
  -6.08156482e-03f, -4.93978225e-02f, -7.49154463e-02f, -2.03296952e-02f, 2.18024366e-02f, -4.37848046e-02f, 4.65024933e-02f, 2.52511036e-02f, 2.88832914e-02f, 8.62433612e-02f,
  -2.90363524e-02f, 2.97858231e-02f, -5.36643043e-02f, -8.72310176e-02f, 3.87455482e-04f, -6.54592216e-02f, -6.31891703e-03f, -8.16440117e-03f, -3.32893133e-02f, 7.20086843e-02f,
  8.64132792e-02f, -4.35300805e-02f, -4.63391989e-02f, -4.18908261e-02f, 2.75370609e-02f, 4.69266175e-04f, -9.73336026e-03f, 3.00053172e-02f, 5.59947900e-02f, 1.40788662e-03f,
  -9.99588668e-02f, -1.00610815e-01f, -5.56507111e-02f, 4.49963063e-02f, 3.11531182e-02f, -3.51752006e-02f, 6.29470125e-02f, 1.69257708e-02f, -4.57517197e-03f, -6.08897954e-02f,
  -4.82554436e-02f, 1.18394054e-01f, 6.96781725e-02f, 9.93861556e-02f, -2.62827594e-02f, 3.80633287e-02f, 4.66818251e-02f, 4.06430215e-02f, 4.71548960e-02f, 8.65827799e-02f,
  -1.22207455e-01f, 1.82324722e-02f, -2.63487194e-02f, -2.10107751e-02f, 9.18442756e-03f, -6.42287359e-02f, 6.75367415e-02f, 5.24487309e-02f, 5.76077849e-02f, -5.90922721e-02f,
  -6.31837547e-02f, 4.64527272e-02f, -9.57398042e-02f, 7.25863129e-02f, 9.11405981e-02f, -3.87247242e-02f, -3.71979326e-02f, 5.84204942e-02f, 3.74688618e-02f, -3.40104960e-02f,
  5.84368259e-02f, 1.12314276e-01f, 8.09828788e-02f, -5.36928736e-02f, 8.06680508e-03f, 4.90374072e-03f, -2.39787567e-02f, -1.07438684e-01f, 2.35163569e-02f, -5.31385690e-02f,
  -2.46606278e-03f, -1.72079951e-01f, -8.13923776e-02f, -5.14174178e-02f, -7.28568016e-03f, -6.66619018e-02f, -3.19072814e-03f, -2.98938453e-02f, 6.49681464e-02f, -4.49243672e-02f,
  -1.30088434e-01f, 5.96687011e-03f, -1.17287539e-01f, -7.13893250e-02f, 5.73957898e-02f, -3.58030386e-02f, -1.05227254e-01f, -4.71456386e-02f, 1.39118526e-02f, -7.27631152e-02f,
  1.52154090e-02f, -1.12234443e-01f, 5.19975685e-02f, 6.46723062e-02f, -7.76464120e-02f, -6.94978237e-02f, -3.83474156e-02f, -7.75067462e-03f, 3.15318853e-02f, -4.30010296e-02f,
  1.65616553e-02f, -2.51792539e-02f, -5.02735972e-02f, 4.28497652e-03f, 7.76789784e-02f, 6.14844635e-02f, 5.51324002e-02f, 4.17067856e-02f, 9.21614468e-02f, 2.28054449e-03f,
  -3.46457995e-02f, 4.74667996e-02f, 5.42064607e-02f, -2.66747624e-02f, -1.94814987e-02f, -4.75151651e-02f, -9.20714289e-02f, -7.52475532e-03f, -1.03207193e-02f, -1.31154340e-03f,
  -7.59183690e-02f, -7.25701898e-02f, -6.83488473e-02f, -4.84344959e-02f, -7.14416206e-02f, -8.49741325e-02f, 5.24028987e-02f, -1.75494943e-02f, 7.70322531e-02f, -1.58933934e-03f,
  1.17197812e-01f, 2.62515377e-02f, 2.41581840e-03f, -4.63889241e-02f, -9.10555571e-02f, -4.61441092e-03f, 5.84387183e-02f, 2.05544587e-02f, -2.75461581e-02f, -1.04123475e-02f,
  8.06796923e-03f, -6.20536059e-02f, 6.93649501e-02f, 5.25799245e-02f, 9.73487943e-02f, 1.11988477e-01f, 5.86177483e-02f, 8.86391923e-02f, -6.08945899e-02f, 4.63173501e-02f,
  1.96102168e-03f, 8.53720009e-02f, 2.21118331e-02f, 1.16466366e-01f, 1.02182098e-01f, 6.18509091e-02f, -1.08142784e-02f, 9.68499333e-02f, 1.23223543e-01f, 1.78065762e-01f,
  6.62365556e-02f, -6.45409375e-02f, 1.17927998e-01f, 8.38820785e-02f, -3.95920314e-02f, -1.44211287e-02f, 6.51264489e-02f, 4.48910110e-02f, -9.57341641e-02f, -1.26406113e-02f,
  6.74346369e-03f, -4.21195738e-02f, -9.68509465e-02f, -4.11424115e-02f, 2.52900291e-02f, 1.03374541e-01f, 9.31173488e-02f, -1.43773034e-02f, -4.89538163e-03f, -4.36082967e-02f,
  -1.15789678e-02f, 8.73015970e-02f, 7.78551251e-02f, 3.17897424e-02f, -9.74905491e-02f, 4.08856682e-02f, -8.75021890e-02f, -3.66101190e-02f, -1.09589271e-01f, -6.62259981e-02f,
  2.83395238e-02f, -7.46527985e-02f, 1.32654784e-02f, -1.01269521e-01f, -3.83663103e-02f, -2.59967055e-03f, -3.32360081e-02f, -8.66038501e-02f, 1.37201045e-02f, 4.96011935e-02f,
  5.63959591e-02f, 7.11294487e-02f, 9.12392512e-02f, -5.54133430e-02f, -2.46221293e-02f, -5.81181422e-02f, 1.27662392e-02f, -5.84095120e-02f, 2.45153066e-02f, -5.26637398e-02f,
  -8.90332535e-02f, 8.16759616e-02f, -3.28444503e-03f, 9.16897506e-02f, 3.11325938e-02f, 1.10823661e-03f, -1.16663948e-02f, 5.12767583e-02f, 1.09634325e-02f, 5.52965626e-02f,
  6.20843358e-02f, 5.84769063e-02f, 6.58970624e-02f, -3.09838578e-02f, 5.61648943e-02f, 8.10162947e-02f, -4.82204743e-02f, 5.76360561e-02f, 4.11744639e-02f, 9.83204469e-02f,
  -3.14364471e-02f, -3.61582451e-02f, 3.35296541e-02f, 6.01082332e-02f, -6.42333925e-02f, 6.04969077e-02f, 6.01690151e-02f, 2.09413823e-02f, 7.02414885e-02f, -4.71843630e-02f,
  7.83383250e-02f, 3.04271039e-02f, -4.18742411e-02f, 4.99569848e-02f, -5.43262847e-02f, 6.44490570e-02f, 8.75494108e-02f, 7.79988170e-02f, 9.33621824e-02f, 6.78849742e-02f,
  -6.44552661e-03f, 9.72669050e-02f, -6.33932129e-02f, 3.94528266e-03f, -3.99722010e-02f, -1.72344467e-03f, 1.26289260e-02f, 2.84572970e-02f, 4.08859365e-02f, 3.86086740e-02f,
  -8.45090114e-03f, -2.73550712e-02f, 1.09232791e-01f, 4.57382575e-02f, 8.85452181e-02f, 1.14005466e-03f, 3.08548305e-02f, 1.72311570e-02f, -9.61359888e-02f, 4.89791390e-03f,
  -8.38506147e-02f, 9.93747935e-02f, 1.32283285e-01f, -4.83285002e-02f, 5.63502386e-02f, 2.24235728e-02f, -2.95312032e-02f, -2.48852111e-02f, 7.01667443e-02f, 4.78366986e-02f,
  4.37896773e-02f, -6.37938827e-02f, 1.95678361e-02f, -1.01672761e-01f, 3.59654911e-02f, 7.88230672e-02f, -6.11501299e-02f, 6.85063750e-02f, -5.79522029e-02f, -1.04321782e-02f,
  -3.68323759e-03f, -3.86939384e-02f, -9.06916112e-02f, 2.68040560e-02f, 7.37477094e-02f, 1.85264964e-02f, -1.21153304e-02f, 7.71508515e-02f, -3.74773480e-02f, -5.27445041e-02f,
  -5.56354858e-02f, -4.60996963e-02f, 1.32215675e-02f, -6.40423521e-02f, 2.26684213e-02f, -3.17349061e-02f, 7.58883059e-02f, -5.84369414e-02f, -5.34416623e-02f, 2.39104386e-02f,
  -1.76171842e-03f, 9.30990726e-02f, -4.48330976e-02f, 1.02480678e-02f, -3.12970765e-02f, -2.27583200e-02f, 5.94077911e-03f, 1.62071660e-02f, -2.16357317e-02f, -2.37196144e-02f,
  -6.35051429e-02f, -2.33898666e-02f, -7.18073966e-03f, -9.10309050e-03f, 7.74252266e-02f, -9.74458270e-03f, -6.49711788e-02f, 4.51577716e-02f, 9.15194750e-02f, 8.66695121e-02f,
  -2.74845790e-02f, 3.96728553e-02f, 7.60579333e-02f, 8.58426392e-02f, -1.62891410e-02f, 1.06540015e-02f, -4.08448614e-02f, -3.68408188e-02f, 5.65130971e-02f, -1.85942519e-02f,
  -5.81391007e-02f, 6.18308829e-03f, 2.88812835e-02f, -4.78415452e-02f, -3.28877345e-02f, -6.23968579e-02f, -8.52808654e-02f, -3.93903404e-02f, -4.74999472e-03f, 6.32267296e-02f,
  -3.56059745e-02f, 9.10489541e-03f, -6.46410510e-02f, 6.77588135e-02f, -5.90740182e-02f, 8.03987980e-02f, -8.79315957e-02f, -7.89439306e-02f, 6.56201020e-02f, -9.65688098e-03f,
  7.01216459e-02f, 9.83255580e-02f, -3.17214392e-02f, 8.52494128e-03f, -5.60395792e-02f, 7.44557008e-02f, 8.17376152e-02f, 5.14544137e-02f, 5.23510948e-02f, -2.06169561e-02f,
  1.54170459e-02f, 5.91526255e-02f, 1.34541467e-02f, 7.53693879e-02f, 6.76010326e-02f, -7.18532428e-02f, 2.87796855e-02f, 2.27665380e-02f, 1.01983257e-01f, 3.61389257e-02f,
  -1.96528956e-02f, 8.79556015e-02f, 6.47349581e-02f, 5.05470950e-03f, 9.36359838e-02f, -6.99455440e-02f, 8.72996747e-02f, 8.87647867e-02f, 1.12940073e-01f, 1.64666232e-02f,
  -5.65040074e-02f, 1.02730811e-01f, 6.56961799e-02f, -8.13076738e-03f, 8.27212632e-02f, -1.90952234e-02f, 2.94572692e-02f, 6.46949857e-02f, 8.01949278e-02f, 5.46806231e-02f,
  -2.67792314e-01f, 2.09108554e-03f, 1.06290251e-01f, -1.36153653e-01f, -9.28112194e-02f, -2.28329096e-02f, -7.49139637e-02f, -8.74684602e-02f, -1.12227060e-01f, -4.25896607e-02f,
  1.21789098e-01f, 3.80936563e-02f, 1.20332032e-01f, 3.61504294e-02f, -4.34396863e-02f, -8.57287645e-02f, -8.61270279e-02f, -1.21230416e-01f, -5.99295795e-02f, 8.45607370e-03f,
  -1.41857773e-01f, -1.56457815e-02f, -1.68933645e-01f, 6.84054708e-03f, 4.61403169e-02f, 1.71694551e-02f, 1.28048792e-01f, -2.10566204e-02f, 2.35516205e-03f, -1.57503411e-02f,
  4.03350890e-01f, -4.82919402e-02f, -2.63857264e-02f, -1.13977239e-01f, 4.70257364e-02f, -2.39496250e-02f, 7.53444135e-02f, -3.26091982e-02f, 2.95981430e-02f, -9.50635411e-03f,
  6.72202185e-02f, 3.64810228e-02f, -2.69888695e-02f, 7.50593171e-02f, 4.91410382e-02f, 5.15690353e-03f, -5.36967218e-02f, -8.61027315e-02f, -4.41515930e-02f, -2.82807536e-02f,
  4.64176200e-02f, 1.83394011e-02f, 4.53356393e-02f, 8.15980062e-02f, 2.19262037e-02f, -7.46754231e-03f, 9.27371457e-02f, 7.86572844e-02f, 5.39909899e-02f, 1.47267774e-01f,
  -5.00214957e-02f, 1.18502909e-02f, 3.48216891e-02f, 3.95949278e-03f, -2.65474040e-02f, 2.76084431e-03f, 9.01113972e-02f, 8.15153029e-03f, -4.54973169e-02f, 7.09866881e-02f,
  1.59244873e-02f, -5.71795069e-02f, 7.12129753e-03f, 2.44940892e-02f, -3.14011574e-02f, -7.23259374e-02f, 1.45197194e-02f, -6.73951209e-03f, -3.21573205e-02f, -5.73465787e-02f,
  6.25570938e-02f, 3.96736376e-02f, -6.19727597e-02f, 5.15401997e-02f, 1.62420291e-02f, -5.25935963e-02f, -6.35900721e-02f, -6.26627654e-02f, 5.78738675e-02f, 5.46871834e-02f,
  2.94695199e-01f, -3.65240276e-02f, 3.72645669e-02f, 8.33315961e-03f, 4.95419353e-02f, -8.44378322e-02f, 3.47540081e-02f, -9.36881453e-03f, 6.22218940e-03f, 5.81678934e-02f,
  7.52968639e-02f, 1.83671117e-02f, 2.68142624e-03f, 5.13322242e-02f, -1.11698657e-01f, -7.02043250e-02f, -6.85297772e-02f, 4.78950031e-02f, 1.92813165e-02f, -5.35379536e-02f,
  -1.05982937e-01f, -4.62867618e-02f, 6.64429814e-02f, -1.78226735e-02f, 8.84325653e-02f, -3.09746768e-02f, 1.68733716e-01f, 7.91143775e-02f, 6.31487891e-02f, 9.12775993e-02f,
  2.34065935e-01f, -2.07647141e-02f, 1.83860101e-02f, 2.82243965e-03f, 8.97754133e-02f, 1.30055189e-01f, 7.05190450e-02f, 1.08819813e-01f, 9.05678868e-02f, 7.20151141e-03f,
  -3.47284935e-02f, -6.40979335e-02f, -5.51226409e-03f, 3.01232934e-02f, 1.98668651e-02f, 6.23583905e-02f, 2.78918035e-02f, -9.00546908e-02f, 3.54886055e-02f, -4.25011702e-02f,
  -1.18955523e-02f, -1.09423986e-02f, 7.82716647e-02f, 3.02641504e-02f, 5.82419708e-03f, -8.72620642e-02f, -2.30687112e-02f, 2.57848036e-02f, 8.11165012e-03f, -1.35186300e-01f,
  -7.76422620e-02f, 1.03576653e-01f, -8.64804089e-02f, -6.12805672e-02f, -2.61514764e-02f, 4.32983004e-02f, 1.53027307e-02f, -8.87066424e-02f, -2.56599616e-02f, 6.39577135e-02f,
  -2.60549989e-02f, -1.09468631e-01f, 1.85779128e-02f, 5.82253747e-02f, -3.47825848e-02f, -1.92879438e-02f, -4.63271774e-02f, 4.88724262e-02f, -2.90073622e-02f, -3.17623876e-02f,
  3.80341783e-02f, -1.66845880e-02f, 1.00048341e-01f, -8.68322924e-02f, -6.57477975e-02f, 9.72763449e-03f, 7.20574334e-02f, 5.07410467e-02f, 9.59584722e-04f, -3.33320610e-02f,
  1.11599155e-02f, 7.91277513e-02f, 7.63793513e-02f, 5.49050979e-02f, -1.09243412e-02f, -7.59615228e-02f, 1.72505677e-02f, -1.07108563e-01f, -5.51337823e-02f, 3.85263376e-02f,
  -6.99920533e-03f, 5.78442886e-02f, 1.14110820e-01f, 9.99084860e-02f, 1.33134788e-02f, -2.35597230e-03f, 3.61983143e-02f, 7.82328248e-02f, -5.17398827e-02f, -8.53770319e-03f,
  7.37952814e-02f, -2.75089610e-02f, 4.12633047e-02f, -2.37233900e-02f, 3.22501250e-02f, -3.46330814e-02f, 8.89550336e-03f, -2.97210161e-02f, 6.35976940e-02f, 3.01265134e-03f,
  1.33759864e-02f, -2.99989376e-02f, -5.35803065e-02f, -1.13624431e-01f, -5.62831648e-02f, 4.79964316e-02f, 5.08130677e-02f, 1.09466473e-02f, 1.60238333e-02f, 6.65431619e-02f,
  1.72585100e-02f, -6.32970221e-03f, -2.37100609e-02f, 2.27229856e-02f, 9.32059437e-02f, 1.15048122e-02f, 3.75637598e-02f, -1.29735153e-02f, -3.87595668e-02f, -9.07291472e-03f,
  -4.37826477e-02f, 8.98287892e-02f, 6.57096654e-02f, 6.50873557e-02f, -1.59572659e-03f, -6.15161061e-02f, 9.14535578e-03f, -8.09872989e-03f, -2.16443948e-02f, 3.37931663e-02f,
  1.60915390e-01f, 2.13717103e-01f, -1.13870874e-01f, 7.09010363e-02f, 9.54967439e-02f, -8.97064731e-02f, -1.28703982e-01f, -2.11095214e-02f, 1.77413970e-02f, 3.93654741e-02f,
  -1.63008869e-02f, -6.33803755e-02f, -5.39502539e-02f, 1.04574906e-03f, -1.46717072e-01f, -9.25888494e-02f, 1.92515291e-02f, -1.64490879e-01f, -1.35761485e-01f, -7.89125711e-02f,
  -7.12571815e-02f, 9.28740725e-02f, -9.67228413e-03f, -3.86163918e-03f, 9.89848450e-02f, -1.78204179e-02f, 7.96968415e-02f, 9.17636976e-02f, 1.01407114e-02f, 1.33702666e-01f,
  -3.92577983e-03f, 5.43849543e-02f, -8.04703683e-02f, 2.89586559e-02f, 5.71778491e-02f, 2.86683887e-02f, -7.10446760e-02f, 7.08480272e-03f, 3.04080024e-02f, 7.03647807e-02f,
  -1.85211431e-02f, 1.09110242e-02f, -4.99543436e-02f, 7.55394921e-02f, -5.88673390e-02f, -7.41368979e-02f, -9.00703669e-02f, -4.79776859e-02f, -1.05561987e-01f, -7.07986280e-02f,
  8.46498534e-02f, 2.36896221e-02f, 3.59794274e-02f, 2.35553589e-02f, -5.24168946e-02f, -2.36517526e-02f, 9.37540904e-02f, 2.58867014e-02f, -1.17041491e-01f, -3.77146602e-02f,
  3.70438024e-02f, -4.79395688e-03f, -4.63483892e-02f, -1.38974087e-02f, 3.22093479e-02f, -7.54565075e-02f, 4.41061147e-02f, -1.92100406e-02f, -5.96197380e-04f, 8.80598277e-02f,
  -3.09568341e-03f, 9.22856778e-02f, -6.08744361e-02f, 6.91911764e-03f, -5.89662523e-04f, -6.48395158e-04f, 4.58233431e-02f, -2.48394255e-02f, 1.51347872e-02f, 2.53984164e-02f,
  3.29446755e-02f, 4.88742888e-02f, 3.61629017e-02f, -4.76045907e-02f, 7.04821050e-02f, 7.33615309e-02f, -3.04697827e-02f, -4.52374816e-02f, -1.43318865e-02f, -9.05101653e-03f,
  -1.66990589e-02f, -6.47580326e-02f, -6.93793297e-02f, -2.90130749e-02f, 3.96935344e-02f, 6.44617677e-02f, -3.60436328e-02f, 9.31712687e-02f, 1.12996288e-01f, 5.26372343e-02f,
  -5.74678928e-02f, -7.04226866e-02f, -7.69870682e-03f, -1.02714293e-01f, 2.95146778e-02f, 1.38653675e-02f, 7.83180594e-02f, 7.99012706e-02f, -6.04480058e-02f, 7.05095679e-02f,
  -1.15619721e-02f, 5.07397242e-02f, -6.30612075e-02f, 1.25432769e-02f, 1.32725779e-02f, -1.52505990e-02f, -1.01224571e-01f, 3.18150334e-02f, -1.41532511e-01f, 9.42390338e-02f,
  -8.46856236e-02f, -6.17370196e-02f, 5.84441684e-02f, 5.81989922e-02f, -3.15976404e-02f, -5.36413863e-02f, 1.16156958e-01f, 7.93528557e-02f, 7.53996000e-02f, 1.12737156e-01f,
  4.07382511e-02f, 1.20094299e-01f, 1.14085369e-01f, 1.23469844e-01f, 3.53844129e-02f, 8.32329690e-02f, 1.33276239e-01f, -6.79565221e-02f, -7.23835677e-02f, 1.00102916e-01f,
  1.35847971e-01f, 8.69909450e-02f, 6.62175566e-02f, 3.96176949e-02f, 1.24101326e-01f, 1.17968954e-01f, 5.34957573e-02f, 2.11356618e-02f, -2.96990909e-02f, 2.64544133e-02f,
  -5.22315428e-02f, 4.92498726e-02f, -3.43188457e-02f, 4.32127826e-02f, -2.33102236e-02f, -1.04347937e-01f, 6.04776889e-02f, -9.39000696e-02f, -4.07851711e-02f, 4.71885428e-02f,
  3.04628257e-02f, -9.57405791e-02f, 8.72108713e-02f, 4.19905484e-02f, 3.09872031e-02f, -1.15315363e-01f, 9.71336383e-03f, -3.54565457e-02f, -2.93576308e-02f, 8.22919607e-02f,
  9.29190144e-02f, -4.07355018e-02f, -4.82117664e-03f, 8.15118328e-02f, 2.09919494e-02f, -3.25144231e-02f, 5.95325558e-03f, -8.60482603e-02f, -3.93613577e-02f, -1.01198323e-01f,
  -6.95389956e-02f, 5.49677946e-02f, -2.04543322e-02f, -1.89016908e-02f, 2.81361658e-02f, 8.31748322e-02f, 4.41133417e-02f, -4.69474234e-02f, 8.85957200e-03f, -6.08349405e-02f,
  -5.31777330e-02f, 3.77044454e-02f, -2.83764414e-02f, -6.28970116e-02f, -5.78876697e-02f, 4.78556789e-02f, 7.11779445e-02f, 5.64393289e-02f, 9.01922211e-03f, 5.53013831e-02f,
  -4.70829718e-02f, -2.94236280e-02f, -1.32340221e-02f, 7.84550160e-02f, -4.57767509e-02f, -9.81611107e-03f, -1.78048182e-02f, 2.71448866e-02f, 8.54854658e-02f, 3.43455002e-02f,
  4.60798368e-02f, 3.50238010e-02f, 5.69588654e-02f, 3.09864851e-03f, 7.26428553e-02f, -9.99967847e-03f, -3.36589888e-02f, -1.01786517e-01f, -1.96417924e-02f, 7.36821443e-02f,
  1.89339332e-02f, -8.88658464e-02f, -2.50600800e-02f, -1.12501532e-03f, -7.61066854e-04f, 6.70111701e-02f, -1.01792186e-01f, 3.74744646e-02f, -6.38067909e-03f, -6.60080314e-02f,
  2.40796953e-02f, 7.60241672e-02f, 7.42464364e-02f, -5.44928536e-02f, 4.48204763e-02f, -6.33214042e-03f, -3.73155549e-02f, -6.28704131e-02f, -7.48776868e-02f, -2.80139986e-02f,
  1.19469397e-01f, 1.22488765e-02f, 4.45592180e-02f, 4.43379432e-02f, 3.03145237e-02f, -1.45469993e-01f, -1.64991319e-01f, -6.93504885e-02f, 5.41188456e-02f, -8.04345496e-03f,
  8.58905837e-02f, 1.02914557e-01f, -6.22203015e-02f, 6.53265859e-04f, -1.49065778e-01f, -1.58933163e-01f, -6.75419495e-02f, -8.73783231e-02f, 6.67478144e-03f, -1.25976771e-01f,
  -8.81551206e-02f, 8.39933455e-02f, 6.93519339e-02f, 7.00186491e-02f, 6.67787269e-02f, 1.66514535e-02f, 1.59329139e-02f, 8.26620534e-02f, -8.03509131e-02f, 1.22344844e-01f,
  5.76150529e-02f, 8.54913741e-02f, 3.10624577e-02f, -1.43010179e-02f, 1.34002104e-01f, -1.01888618e-02f, 8.21976364e-02f, -2.64067706e-02f, -6.84048608e-02f, -8.20004866e-02f,
  -2.25774515e-02f, -3.99647877e-02f, 4.69667930e-03f, -5.13188019e-02f, -5.52319270e-03f, -4.13690396e-02f, -4.34507206e-02f, -1.48180537e-02f, -6.75980449e-02f, 4.65149023e-02f,
  6.64205626e-02f, 6.96037635e-02f, 3.47672775e-02f, 1.56888738e-02f, 7.59645179e-03f, 6.55279979e-02f, -2.61076689e-02f, -5.19047715e-02f, -8.18632450e-03f, 2.42094267e-02f,
  -5.68487532e-02f, -3.15215848e-02f, 4.24424419e-03f, -2.74841208e-02f, 6.93807891e-03f, 7.47350678e-02f, 1.42070400e-02f, -7.48306438e-02f, -8.13085884e-02f, 2.24102661e-02f,
  1.27610276e-02f, 3.53445043e-03f, 8.61608759e-02f, 6.89113885e-02f, -3.35975620e-03f, -7.07728742e-03f, 3.88380177e-02f, -8.60862657e-02f, 5.05850948e-02f, -6.67695403e-02f,
  8.18087310e-02f, -1.81406736e-02f, 4.77790311e-02f, 7.07986131e-02f, -7.71473348e-02f, -6.44956008e-02f, -1.33680403e-02f, 9.87012535e-02f, 7.14445338e-02f, -1.91848725e-02f,
  -1.44156190e-02f, -7.36516491e-02f, 5.55000231e-02f, -5.72537743e-02f, 6.63003186e-03f, 5.32198176e-02f, 3.81740555e-02f, -1.48588512e-03f, 6.69097900e-02f, 2.05982644e-02f,
  7.24594519e-02f, 6.26507327e-02f, -7.33544007e-02f, 3.78167108e-02f, -1.12874813e-01f, 5.36818095e-02f, -8.73001292e-02f, -7.70952925e-02f, -6.75592571e-02f, -7.40097314e-02f,
  -2.12541129e-02f, -7.82504976e-02f, -1.14392795e-01f, -1.05010711e-01f, 1.71332862e-02f, -8.09832364e-02f, 2.51800213e-02f, -3.73963639e-02f, -8.05579200e-02f, -5.13367020e-02f,
  2.61535436e-01f, -5.49526066e-02f, -7.29343668e-02f, 1.00726366e-01f, -1.00619659e-01f, -6.27385154e-02f, -7.52577484e-02f, 2.87367832e-02f, 1.74498819e-02f, 2.35685706e-03f,
  -1.84683520e-02f, 1.30551845e-01f, 1.40664831e-01f, 1.44133359e-01f, 1.43496394e-01f, -4.86660823e-02f, -7.66469836e-02f, 7.14289099e-02f, 1.46753028e-01f, 2.71511171e-02f,
  -2.26903167e-02f, -6.63325787e-02f, 2.39455197e-02f, 7.03016818e-02f, -3.62020582e-02f, 5.66564314e-02f, 1.59721691e-02f, 6.94472417e-02f, -9.72851142e-02f, 3.90727371e-02f,
  3.55312936e-02f, -2.76412908e-02f, 9.71018672e-02f, 9.71228853e-02f, -3.59375924e-02f, 1.62948333e-02f, 7.24957287e-02f, 3.38426232e-02f, -2.99501270e-02f, -9.89769846e-02f,
  3.79985534e-02f, 8.70503336e-02f, 7.43467286e-02f, -4.38027494e-02f, -1.18687823e-01f, -3.50272246e-02f, 3.08171790e-02f, 4.76010554e-02f, -5.07110544e-02f, 4.01462428e-02f,
  -5.23466095e-02f, 5.06898351e-02f, 7.32954592e-02f, -1.15821488e-01f, 1.25276875e-02f, 1.06358096e-01f, -6.86985478e-02f, 4.96219210e-02f, -7.20944256e-02f, 5.10610901e-02f,
  2.10180320e-02f, -1.19007071e-02f, -4.52663377e-02f, 4.38331291e-02f, -6.75991923e-02f, 3.55911665e-02f, -7.47689307e-02f, 3.31967026e-02f, 1.87075529e-02f, 3.63822840e-02f,
  -2.19631474e-02f, 3.65633555e-02f, -2.61940770e-02f, 7.46177435e-02f, 7.04666376e-02f, -3.62882465e-02f, 6.13701418e-02f, -3.35333012e-02f, -5.08104861e-02f, 1.07876351e-02f,
  -2.46784952e-03f, 3.87533307e-02f, 1.04505429e-03f, -9.01738256e-02f, -9.15888548e-02f, -3.37578543e-02f, -4.46855202e-02f, -4.53541391e-02f, 8.56626406e-03f, -6.09303638e-02f,
  -1.03640579e-01f, -2.60360278e-02f, 6.87670410e-02f, 1.08745985e-01f, 1.52373677e-02f, -8.51897746e-02f, 1.32574901e-01f, -4.84351404e-02f, 6.64455742e-02f, -1.81182157e-02f,
  3.68940756e-02f, 4.70811091e-02f, -5.92275942e-03f, 3.88426408e-02f, 6.70274645e-02f, 6.38858676e-02f, -2.93990895e-02f, 1.32587003e-02f, 5.22515401e-02f, -7.61153176e-02f,
  -1.86743438e-02f, 5.14353327e-02f, 4.83608171e-02f, 4.32443209e-02f, 2.24295482e-02f, 1.29291475e-01f, 5.20826019e-02f, 8.37398097e-02f, -2.41778810e-02f, -8.42764825e-02f,
  1.87024727e-01f, -1.52550023e-02f, 2.10504755e-01f, 3.16943154e-02f, 2.40796302e-02f, 1.31143138e-01f, 1.44290686e-01f, 3.73482145e-02f, 4.38731760e-02f, -9.74061787e-02f,
  -4.91644777e-02f, -6.55223504e-02f, -8.48284513e-02f, -5.82722574e-02f, 5.86027279e-02f, -3.61088626e-02f, 8.17503557e-02f, 4.45132367e-02f, 1.35802716e-01f, -4.02339846e-02f,
  -5.21591939e-02f, 4.90835346e-02f, 1.06187105e-01f, -3.13038826e-02f, 7.29198977e-02f, -4.22742479e-02f, 1.01558246e-01f, -2.26404667e-02f, -7.10378587e-02f, 7.35919597e-03f,
  -6.27246797e-02f, 7.23202229e-02f, 5.92377670e-02f, -1.27046853e-01f, -9.16733593e-02f, 6.76003024e-02f, -2.64571570e-02f, -4.66964468e-02f, -4.70118374e-02f, -3.90772596e-02f,
  -7.88320974e-03f, 1.01126479e-02f, -5.54193743e-04f, -2.68080290e-02f, -1.78178935e-03f, -3.29612801e-03f, -4.89743389e-02f, 9.78709161e-02f, 7.18013346e-02f, -1.24970479e-02f,
  -1.26927361e-01f, 6.32550940e-02f, 1.06510475e-01f, -4.17277068e-02f, 9.06146541e-02f, 5.76923117e-02f, 4.38230149e-02f, 7.86698386e-02f, 4.96072955e-02f, 6.06197566e-02f,
  -5.69452085e-02f, -4.67497632e-02f, 8.44113082e-02f, -7.88730606e-02f, 3.74210030e-02f, -1.27317430e-02f, -7.70686343e-02f, -7.03201666e-02f, -3.83039042e-02f, -1.26052962e-03f,
  5.85442558e-02f, 4.90887240e-02f, -5.69952838e-02f, 2.83165537e-02f, -3.52088213e-02f, 6.00299500e-02f, 4.23597507e-02f, -2.61855088e-02f, 5.46018295e-02f, -7.87579417e-02f,
  -1.02998996e-02f, 8.02921578e-02f, 5.78165315e-02f, 6.36488944e-02f, -9.35473945e-03f, -3.85817811e-02f, -5.96820787e-02f, -5.95970899e-02f, 6.39129803e-02f, 5.73206507e-02f,
  -1.37009829e-01f, -7.18192104e-03f, -9.06162150e-03f, -4.24943790e-02f, 9.74993333e-02f, 5.50402030e-02f, -8.30955207e-02f, 5.01275323e-02f, 8.66300613e-02f, 8.05521011e-02f,
  -7.37474337e-02f, 9.49648693e-02f, 4.96495478e-02f, 1.10067884e-02f, 2.68539786e-03f, -5.39613403e-02f, 2.97806524e-02f, 1.89431990e-03f, -9.22736898e-02f, 2.62096431e-03f,
  -1.01632282e-01f, 2.79819500e-02f, 8.04194957e-02f, -6.06757700e-02f, -3.30234393e-02f, -4.43491079e-02f, -7.36657977e-02f, 7.22091123e-02f, 4.95105945e-02f, -5.60212918e-02f,
  7.27672800e-02f, -1.43226400e-01f, -1.68936580e-01f, 1.81591045e-03f, -1.45442650e-01f, -1.69593394e-01f, -1.90132633e-01f, 7.46310949e-02f, 5.66310920e-02f, -1.24267898e-01f,
  4.36948873e-02f, 9.48367938e-02f, 2.99915113e-02f, -4.17549461e-02f, 6.98263049e-02f, -1.33135527e-01f, -2.13071212e-01f, -1.31821126e-01f, 6.27626032e-02f, -3.56621481e-02f,
  -8.60517547e-02f, -8.34222361e-02f, -2.13938188e-02f, 4.30877274e-03f, -7.81272352e-03f, -3.80451838e-03f, 2.54304032e-03f, -1.15370467e-01f, -1.07117727e-01f, -1.80645183e-01f,
  -1.95119187e-01f, 3.43977995e-02f, -3.87103222e-02f, 1.05782850e-02f, -1.08512357e-01f, 2.58095320e-02f, -5.91959357e-02f, -2.33051535e-02f, -4.15384732e-02f, -5.96646406e-02f,
  -8.11499059e-02f, 1.38872303e-02f, 1.08778691e-02f, 7.01588392e-02f, 5.49398251e-02f, 3.35172862e-02f, 7.36393705e-02f, -9.78353247e-02f, 1.69673748e-02f, -4.09091823e-02f,
  -9.87062380e-02f, 3.42247263e-02f, -9.41254422e-02f, -3.20925489e-02f, -6.94963560e-02f, 3.86938639e-02f, -9.87533852e-03f, -2.99994387e-02f, 8.63975845e-03f, -1.40772545e-05f,
  -7.13874102e-02f, -1.64168105e-02f, -7.59460405e-02f, 8.09554830e-02f, 2.48496477e-02f, 5.71516491e-02f, -1.75273530e-02f, 5.13001457e-02f, 1.23911947e-02f, 2.19770782e-02f,
  -5.51441982e-02f, -5.53642921e-02f, -6.59583509e-02f, -4.50002812e-02f, 7.67645463e-02f, -5.19796908e-02f, 7.64319450e-02f, 5.80505840e-02f, -1.72439758e-02f, 5.91917299e-02f,
  -2.51859426e-02f, -3.91343050e-02f, 3.70121896e-02f, -3.04781906e-02f, -7.75589645e-02f, -4.91655730e-02f, 2.99203787e-02f, 4.26687077e-02f, 1.09181456e-01f, -5.61231794e-03f,
  9.21459422e-02f, -5.88441007e-02f, -2.51020901e-02f, 4.79464978e-03f, 1.99518148e-02f, -3.85994017e-02f, -9.50871632e-02f, 5.01437485e-02f, 7.25350976e-02f, -4.22924384e-02f,
  5.15794531e-02f, 6.20946512e-02f, -5.38745560e-02f, -6.88861012e-02f, 5.68311065e-02f, 3.80307399e-02f, -7.12333098e-02f, -2.84886342e-02f, 1.31955538e-02f, -6.17692582e-02f,
  6.89083263e-02f, -7.93183446e-02f, 7.98066929e-02f, 7.00638369e-02f, 1.96190123e-02f, -2.00620480e-02f, -5.75886331e-02f, 7.71909654e-02f, 2.81598978e-02f, 1.02538556e-01f,
  -4.30710055e-02f, -1.10849649e-01f, -1.66338131e-01f, -1.53353572e-01f, -2.17767712e-02f, 6.97031012e-03f, -5.84731996e-03f, 1.28840143e-02f, -6.68419376e-02f, -8.89600515e-02f,
  -3.07692625e-02f, -6.13059402e-02f, -6.75982311e-02f, 8.39683339e-02f, -7.68035278e-02f, -1.15474768e-01f, -6.89290985e-02f, 5.95148727e-02f, 1.19373448e-01f, -1.08259236e-02f,
  -4.23012190e-02f, -6.03609532e-02f, -4.38776501e-02f, 3.85267064e-02f, 1.75252408e-02f, -2.15427801e-02f, -9.36423168e-02f, -8.75611231e-02f, 3.33540491e-03f, -1.67534664e-01f,
  2.50289664e-02f, 6.94765598e-02f, 1.84595846e-02f, -4.79752012e-02f, 1.83877479e-02f, -3.72089781e-02f, 1.45760663e-02f, -8.28802139e-02f, -8.46036244e-03f, 8.21411535e-02f,
  7.37491474e-02f, 6.69040158e-02f, -8.36970434e-02f, 6.07011579e-02f, 1.88421528e-03f, 8.49534646e-02f, 3.64023037e-02f, 5.98475076e-02f, -1.51964268e-02f, 7.91868642e-02f,
  1.68024339e-02f, 8.73809308e-02f, -2.85842139e-02f, 8.04937817e-03f, 1.04712792e-01f, 2.97830615e-04f, 4.04185504e-02f, 6.15754388e-02f, 8.86393040e-02f, 3.00806910e-02f,
  -7.75728822e-02f, -1.00924216e-01f, 8.83440021e-03f, 4.24977913e-02f, -8.54680017e-02f, -5.38984090e-02f, 1.83081608e-02f, 4.53148969e-02f, -5.53265214e-02f, 3.08010131e-02f,
  -1.51681816e-02f, 5.97014166e-02f, 5.10611013e-02f, -1.73105635e-02f, -9.01691914e-02f, 2.61501949e-02f, -2.30294075e-02f, -1.95572106e-03f, 7.86501616e-02f, -1.45501923e-02f,
  -3.18626687e-03f, 7.78746465e-03f, 5.08323908e-02f, 4.73297797e-02f, -3.22327502e-02f, -3.12990099e-02f, 3.53419455e-03f, -6.48142397e-03f, 2.20232271e-02f, 3.56143154e-02f,
  -8.03607404e-02f, 8.54263008e-02f, -1.59321707e-02f, 4.71332110e-02f, 1.40553713e-02f, -3.63685861e-02f, -1.77973602e-02f, -3.46200541e-02f, -5.06752580e-02f, 1.42347226e-02f,
  1.03051841e-01f, -5.04515646e-03f, 1.01677841e-02f, -5.71480133e-02f, -9.57993884e-03f, 5.26554585e-02f, -3.19101214e-02f, 9.43064503e-03f, 6.06878027e-02f, -2.26617884e-02f,
  -6.53480068e-02f, -2.52087507e-02f, -9.15992633e-02f, -4.44278233e-02f, -5.68235070e-02f, -4.15854789e-02f, 5.63001074e-02f, -1.85416546e-02f, 5.31491376e-02f, 4.00446281e-02f,
  5.51753826e-02f, 8.17019343e-02f, -9.98338871e-03f, 1.14284702e-01f, 6.08627312e-02f, -4.54749726e-02f, -1.32168218e-01f, -3.70995030e-02f, 1.15535177e-01f, 9.93214846e-02f,
  7.18596354e-02f, 1.07341349e-01f, 1.12163998e-01f, 6.73729554e-02f, 4.72535640e-02f, -8.61738101e-02f, 6.29091784e-02f, 3.09299920e-02f, -5.11628203e-02f, 8.26932676e-03f,
  -3.83064672e-02f, 3.98906991e-02f, 4.71250340e-02f, 1.58487707e-02f, 1.28232390e-01f, 1.31192461e-01f, 4.31915037e-02f, 5.87265473e-03f, -4.79451604e-02f, 1.02913931e-01f,
  7.28954151e-02f, 6.50269836e-02f, -2.70774961e-02f, 2.38999259e-02f, -7.51267970e-02f, -6.00646846e-02f, 7.89986178e-02f, 2.22478751e-02f, -5.25855087e-02f, 6.87528476e-02f,
  -6.63085002e-03f, -1.88454725e-02f, 9.40618441e-02f, 1.86752770e-02f, -1.96566191e-02f, 8.30246061e-02f, 1.98603589e-02f, -3.09718568e-02f, -4.84833261e-03f, 3.25496271e-02f,
  -2.78526302e-02f, 6.04114458e-02f, -1.37561811e-02f, -5.44349314e-04f, -7.78956637e-02f, 9.84968320e-02f, 8.46568961e-03f, 5.10493889e-02f, 3.38823274e-02f, 3.78397331e-02f,
  -2.10337769e-02f, -6.44993857e-02f, -4.98288870e-02f, 1.88924409e-02f, 4.53721546e-02f, 1.00503765e-01f, -3.12779611e-03f, -6.47131428e-02f, 1.58385597e-02f, 4.61302921e-02f,
  -2.32725069e-02f, -7.61112373e-04f, -8.98166075e-02f, 1.94442738e-02f, -2.98433681e-03f, -5.70523255e-02f, 9.05045718e-02f, 4.86892648e-02f, 1.09386351e-02f, -3.39614600e-02f,
  -7.36461505e-02f, 7.05843419e-02f, -1.64079592e-02f, 5.59791476e-02f, 9.95516479e-02f, 3.51759233e-02f, 3.49899456e-02f, 4.44125198e-02f, -4.86548096e-02f, 9.64596719e-02f,
  5.40644024e-03f, -1.13219514e-01f, 5.13837300e-02f, 4.40026075e-02f, 1.57255435e-03f, -3.98868844e-02f, -4.89175878e-02f, -6.98797181e-02f, -2.67767292e-02f, -8.61791596e-02f,
  -8.01215917e-02f, -7.20676854e-02f, -5.15125096e-02f, -6.56002462e-02f, -6.80913180e-02f, -4.75267181e-03f, 4.57831584e-02f, -3.44133191e-02f, 7.44606405e-02f, -7.51691908e-02f,
  -8.01368207e-02f, 5.27433679e-02f, -4.80305701e-02f, 4.60888818e-02f, -9.17268619e-02f, -5.52723221e-02f, -1.09901533e-01f, -7.01397359e-02f, 2.50987355e-02f, -7.20339268e-02f,
  -4.85026315e-02f, 8.78795832e-02f, -5.41421287e-02f, -4.11536917e-02f, 5.86363934e-02f, -8.15580264e-02f, -5.03343195e-02f, 1.82875954e-02f, 5.84843233e-02f, 4.85330522e-02f,
  -2.71951109e-02f, 1.04806334e-01f, 8.31164047e-03f, 6.49612769e-02f, 7.80147165e-02f, 1.13319948e-01f, 7.97046795e-02f, 1.01372182e-01f, -8.39617252e-02f, 2.60604993e-02f,
  1.15576454e-01f, 2.27994677e-02f, 9.87849236e-02f, 8.14343244e-02f, 2.10867357e-03f, 1.04128227e-01f, -9.44880187e-04f, -4.11492586e-02f, -1.13671329e-02f, 3.48051339e-02f,
  -1.46723151e-01f, -1.10929847e-01f, 2.65274849e-02f, 1.05380058e-01f, -4.57127462e-04f, -1.22589311e-02f, 5.36257103e-02f, -8.73334184e-02f, 7.08752796e-02f, 8.48749205e-02f,
  -2.31730659e-02f, -2.25693430e-03f, 5.27317412e-02f, 4.18273285e-02f, -4.40820679e-02f, -4.67939116e-02f, 9.88091677e-02f, 2.50308271e-02f, -8.98204185e-03f, -8.58906209e-02f,
  -4.92975004e-02f, 7.99002573e-02f, -8.01026747e-02f, -1.49808312e-02f, 1.88401584e-02f, 5.55729680e-02f, 4.21787612e-02f, -6.69288114e-02f, -1.34820901e-02f, 8.31518993e-02f,
  3.68660428e-02f, 7.78057752e-03f, -3.48147787e-02f, 9.19591356e-03f, 4.51463610e-02f, 4.74913195e-02f, 6.08316101e-02f, -8.14346522e-02f, -1.18899392e-02f, -4.22700644e-02f,
  -7.69908831e-04f, -5.88180386e-02f, 6.08149320e-02f, -1.62636992e-02f, 2.98079979e-02f, -8.47979560e-02f, 3.02410610e-02f, -5.09492457e-02f, 5.72301075e-02f, -4.53217281e-03f,
  -2.71774027e-02f, 2.11585462e-02f, -5.11117396e-04f, 1.00818276e-02f, -7.03663826e-02f, -8.20897520e-02f, -1.05147913e-01f, -6.24447279e-02f, 2.86278687e-02f, -3.98843996e-02f,
  1.79695152e-02f, -3.64236869e-02f, 1.83153301e-02f, -7.80573711e-02f, -1.09360658e-01f, -2.64643300e-02f, -7.64570087e-02f, 1.81263853e-02f, 9.41190589e-03f, 2.16239393e-02f,
  -5.92326112e-02f, 6.50866106e-02f, -2.95057725e-02f, -4.64060064e-03f, 4.27112915e-03f, -3.71299451e-03f, 5.72064221e-02f, 6.28748611e-02f, 3.91072361e-03f, 9.59847402e-03f,
  4.88430224e-02f, 4.32367530e-03f, 7.12434128e-02f, -1.60684511e-02f, 4.57902774e-02f, 1.06993085e-03f, -3.74588966e-02f, -9.47229750e-03f, 9.85986087e-04f, 4.98290136e-02f,
  8.92943665e-02f, 1.17241696e-01f, 1.59415200e-01f, 1.11903548e-01f, 1.06658809e-01f, 2.16783017e-01f, 2.72790134e-01f, 1.78094417e-01f, 8.40884671e-02f, 7.88399801e-02f,
  -1.24796972e-01f, -1.02351792e-01f, -1.00404546e-01f, 4.50479761e-02f, 1.05784452e-02f, 1.69717863e-01f, 1.37530521e-01f, 5.35700284e-02f, 7.83522576e-02f, -3.61738726e-02f,
  -1.14101786e-02f, -1.76639985e-02f, -4.39104140e-02f, 3.24757397e-03f, 1.21086463e-01f, 7.35531189e-03f, -5.25442660e-02f, 1.24520823e-01f, 6.99644610e-02f, 7.86317587e-02f,
  -5.20550013e-02f, 8.73821676e-02f, -3.55091244e-02f, -1.07446261e-01f, -1.01750337e-01f, -7.33744213e-03f, 1.28416822e-03f, 8.07973184e-03f, 3.33681144e-03f, 1.48409102e-02f,
  -6.15532473e-02f, 2.94968449e-02f, -5.97873963e-02f, 4.54413481e-02f, 7.27560185e-03f, 6.23329915e-03f, -3.09492834e-02f, 3.89767028e-02f, 1.11008938e-02f, 1.15570597e-01f,
  5.47424965e-02f, -7.27965906e-02f, 3.91544625e-02f, 2.63820421e-02f, 1.25405625e-01f, -1.17969558e-01f, 5.01490310e-02f, -4.87749726e-02f, 6.79888204e-02f, -5.90350553e-02f,
  -1.01749249e-01f, -2.94237491e-02f, -1.71725266e-02f, 3.16876397e-02f, -2.93507259e-02f, -2.26198155e-02f, -4.73551974e-02f, -4.60738279e-02f, 3.14187184e-02f, -3.83245982e-02f,
  -5.49241900e-02f, -6.57163560e-02f, 7.76580274e-02f, -2.40238290e-02f, 3.13322172e-02f, -9.45562031e-03f, 6.70144781e-02f, 7.70721724e-03f, -5.72415888e-02f, 7.92666003e-02f,
  -1.15490947e-02f, 2.78598210e-03f, -6.73534051e-02f, 9.23742652e-02f, -6.41602054e-02f, 7.01239854e-02f, -4.12561372e-02f, -6.90263659e-02f, -1.21654905e-02f, 3.17510702e-02f,
  -5.16807251e-02f, -2.31235474e-03f, 4.57891449e-03f, 4.34655137e-02f, -2.22446881e-02f, -3.75232734e-02f, -6.69251895e-03f, -8.11839849e-02f, -1.53035596e-02f, 2.80553289e-02f,
  5.75687177e-02f, -4.80494089e-02f, 7.19668642e-02f, 4.38513234e-04f, -9.19440836e-02f, -4.78031635e-02f, 2.03936491e-02f, -1.74091253e-02f, -1.61742046e-03f, -2.60171201e-02f,
  7.87154213e-02f, 4.26062047e-02f, -1.24270894e-01f, -3.41386870e-02f, -2.08400022e-02f, -1.16027310e-01f, 3.19757080e-03f, -1.13597952e-01f, -3.14860530e-02f, -1.28403217e-01f,
  -7.57552683e-02f, 6.25949949e-02f, 9.43546370e-02f, 3.36914398e-02f, 8.94150063e-02f, 1.21679440e-01f, 1.82724237e-01f, 7.67569467e-02f, -4.96235266e-02f, 3.13097425e-02f,
  -9.12019424e-03f, -5.15805334e-02f, -9.23150480e-02f, -1.02871284e-01f, -4.48285118e-02f, 1.45475164e-01f, 1.59025133e-01f, -6.50048330e-02f, 2.91020907e-02f, -1.71740178e-03f,
  1.04236647e-01f, -5.02481535e-02f, -1.19128741e-01f, -3.34084569e-03f, 6.76795915e-02f, 1.67321973e-02f, 3.48216146e-02f, -2.03801133e-02f, -9.05130804e-02f, 7.45864213e-02f,
  2.82257032e-02f, -1.18287846e-01f, -1.09109711e-02f, -7.30808005e-02f, -5.22300750e-02f, -1.13045134e-01f, 3.93340737e-02f, -2.42282990e-02f, 6.07028529e-02f, 3.31810862e-02f,
  5.57744727e-02f, -1.10448413e-01f, 3.04456875e-02f, 8.06636512e-02f, 2.72330223e-03f, -3.23775895e-02f, -9.22990218e-02f, 2.21855100e-02f, 4.60319370e-02f, -7.48510426e-03f,
  -8.50779191e-02f, -3.24550793e-02f, 7.16676265e-02f, 4.76775207e-02f, 2.23469511e-02f, -2.89716013e-02f, 4.51970771e-02f, -6.27648756e-02f, 5.16089648e-02f, 4.46214452e-02f,
  -6.43590912e-02f, 6.80246502e-02f, 7.67404810e-02f, -3.17925252e-02f, 7.23963082e-02f, -1.36942538e-02f, 7.24426880e-02f, 1.70702729e-02f, 4.41368222e-02f, 4.18862142e-03f,
  7.83145204e-02f, 4.57674116e-02f, -3.96474004e-02f, 4.59330641e-02f, -5.41109685e-03f, 8.57047588e-02f, -8.32473710e-02f, -7.67515674e-02f, -6.55753538e-02f, 6.83018118e-02f,
  -1.20168142e-02f, -7.79312775e-02f, 2.41055358e-02f, -8.10385048e-02f, 2.02730931e-02f, -6.86511174e-02f, 6.95890328e-03f, -7.79442955e-03f, 1.92641914e-02f, -5.00875972e-02f,
  3.66439484e-02f, -1.00340277e-01f, 7.17868730e-02f, 5.58821671e-03f, -5.57339787e-02f, -8.17705244e-02f, 4.75718342e-02f, 3.36916074e-02f, 8.53682160e-02f, -1.71598531e-02f,
  -7.92916492e-02f, 2.20339466e-02f, 8.20704028e-02f, 4.33783904e-02f, -2.88210679e-02f, -4.30153050e-02f, -5.25945835e-02f, -2.58339643e-02f, -2.41064187e-02f, 7.69805014e-02f,
  -3.42354178e-02f, -1.35060558e-02f, 6.83219731e-02f, 5.90573363e-02f, -1.62780695e-02f, -4.89119217e-02f, 9.65924934e-03f, 5.91767728e-02f, -6.76421374e-02f, -6.03884012e-02f,
  6.69979975e-02f, 4.01613265e-02f, 1.99424610e-01f, -1.08388074e-01f, -1.17884062e-01f, -1.65196601e-02f, -5.95191643e-02f, -8.03922117e-02f, 3.98009978e-02f, -5.68572097e-02f,
  -3.29547711e-02f, 4.82773557e-02f, 4.24159504e-03f, 2.98958030e-02f, 1.01957083e-01f, 9.61891413e-02f, 1.05992258e-01f, 5.38576059e-02f, 1.19819783e-01f, 1.07961215e-01f,
  -5.56102283e-02f, 4.33408469e-02f, 5.69087639e-02f, 3.83981802e-02f, -7.30835497e-02f, 1.16329603e-01f, 1.91643890e-02f, 5.59729710e-02f, 2.90143117e-02f, 3.65496539e-02f,
  2.68340677e-01f, -8.06172118e-02f, 1.06464855e-01f, -5.94117492e-02f, 3.76719162e-02f, 9.47597623e-02f, 4.43863682e-02f, -6.26327517e-03f, -7.55992532e-02f, -3.11545338e-02f,
  8.31671339e-03f, -9.94144902e-02f, 5.00757992e-02f, 3.23739387e-02f, -3.01827136e-02f, -3.63706984e-02f, -6.76579326e-02f, 3.48647535e-02f, -9.20629799e-02f, -1.45121478e-02f,
  -1.30875707e-01f, 3.10035609e-02f, 7.12868273e-02f, 3.09046712e-02f, 1.69404186e-02f, 2.81509338e-03f, 7.91092664e-02f, 4.99352887e-02f, -5.39092608e-02f, -5.28126583e-02f,
  5.52024320e-03f, 6.67297542e-02f, 1.05782356e-02f, -5.81462085e-02f, 2.42763795e-02f, -1.91722158e-02f, 4.55949493e-02f, 1.37325153e-02f, 3.84220332e-02f, -7.19835013e-02f,
  3.06079891e-02f, -2.63861623e-02f, -5.67740807e-03f, 6.11595847e-02f, 3.60112153e-02f, -8.92395452e-02f, 6.45127222e-02f, -2.61005783e-03f, -7.58662075e-02f, -3.97990132e-03f,
  -7.99629092e-02f, 1.53113082e-02f, 3.54387127e-02f, 6.75171167e-02f, -2.79045962e-02f, 3.47090955e-03f, 8.09369534e-02f, -2.11440027e-03f, 3.74157466e-02f, -1.37491152e-02f,
  8.87897760e-02f, 3.57564795e-03f, -8.13851319e-03f, 1.88378505e-02f, -3.43862288e-02f, -8.98670852e-02f, -5.20934463e-02f, -1.14650512e-02f, -8.57258141e-02f, 7.19676539e-02f,
  6.56245202e-02f, 9.61761922e-02f, 6.50294274e-02f, 4.85155806e-02f, -2.64845379e-02f, -9.15809274e-02f, 4.47883569e-02f, 2.35780217e-02f, -7.82866031e-03f, -2.51444504e-02f,
  -2.17305310e-02f, 3.70825045e-02f, 9.09086093e-02f, 4.59430553e-02f, 3.40181813e-02f, 5.37001081e-02f, 6.11211956e-02f, 8.53534043e-02f, -1.96065810e-02f, -5.48295900e-02f,
  2.27711767e-01f, 1.45752430e-01f, 1.10408522e-01f, 5.86607791e-02f, 6.85268780e-03f, 2.35077906e-02f, 7.17996806e-02f, 1.44945860e-01f, 8.46163034e-02f, 9.34535339e-02f,
  1.43100396e-01f, -1.50452862e-02f, 9.55463797e-02f, 8.61920118e-02f, 1.19943038e-01f, 9.91943702e-02f, -9.52688754e-02f, -6.34420961e-02f, 1.30724115e-02f, 8.69242400e-02f,
  -4.36086096e-02f, -5.82553484e-02f, 9.12752897e-02f, 8.42081085e-02f, -9.14919376e-02f, -8.20464566e-02f, 1.26927039e-02f, -7.45114908e-02f, -6.02400489e-02f, 2.59433221e-02f,
  -8.16958845e-02f, 1.22665510e-01f, -3.74021120e-02f, 9.11812633e-02f, -7.84498602e-02f, -8.85511264e-02f, 4.76442277e-02f, 4.15994134e-03f, 4.98798564e-02f, 3.22459005e-02f,
  -4.86741066e-02f, -5.56360371e-02f, -2.13290993e-02f, -1.53894369e-02f, -8.56171772e-02f, -4.95095849e-02f, -4.65943962e-02f, 1.27901947e-02f, -1.36995343e-02f, -4.95721120e-03f,
  -1.42042479e-02f, 5.15442993e-03f, 1.44387195e-02f, 1.07492112e-01f, 7.19835535e-02f, 5.72655573e-02f, 5.94237708e-02f, 3.17032486e-02f, 9.26840529e-02f, 5.31973355e-02f,
  -7.17724636e-02f, 4.91937138e-02f, 5.81257157e-02f, 4.58704047e-02f, -8.91055465e-02f, 7.87629783e-02f, -8.54785144e-02f, 5.54554276e-02f, -4.79285121e-02f, 4.97370549e-02f,
  9.58157033e-02f, -6.02747127e-02f, -5.27500408e-03f, 2.98247598e-02f, 2.75196526e-02f, 3.33399773e-02f, -8.57269615e-02f, -4.55873460e-02f, 4.58685309e-02f, -2.80021504e-02f,
  5.33589572e-02f, 4.04380001e-02f, -3.87989841e-02f, -3.62023525e-02f, -5.74207604e-02f, -8.55126604e-03f, 3.61050703e-02f, 4.81021311e-03f, 9.39386711e-03f, 6.42080829e-02f,
  -2.67697070e-02f, 3.30198072e-02f, -9.99228582e-02f, -1.48148194e-03f, 3.49124260e-02f, -5.05059585e-02f, 3.28800417e-02f, -1.87976342e-02f, -4.57591377e-02f, 9.03203934e-02f,
  -5.35680018e-02f, 9.34619382e-02f, 2.48235092e-02f, 5.81261590e-02f, -5.81819229e-02f, 3.37755904e-02f, 3.16434130e-02f, -3.26984599e-02f, -8.20048302e-02f, -3.04347905e-03f,
  -2.89585739e-02f, -3.59467901e-02f, -2.54963934e-02f, 9.13514793e-02f, -3.57264131e-02f, -1.30144935e-02f, 3.63472290e-02f, -9.97894555e-02f, -9.21401102e-03f, 3.12176105e-02f,
  6.75691292e-02f, -1.23624476e-02f, 1.76761195e-01f, -6.74209446e-02f, -9.61955935e-02f, 3.54216807e-02f, 1.52822444e-02f, -9.58542600e-02f, -8.43844488e-02f, -1.25728607e-01f,
  -6.96267262e-02f, -5.60079329e-02f, 2.06435453e-02f, -2.98307706e-02f, 5.59947677e-02f, -9.97336674e-03f, 8.31237286e-02f, 5.63717782e-02f, 1.13284670e-01f, -4.94901128e-02f,
  6.53547868e-02f, 1.09027743e-01f, 6.02192953e-02f, 6.43462390e-02f, -1.39641939e-02f, 2.78709512e-02f, 9.53324512e-02f, 1.43897504e-01f, 9.93197635e-02f, -3.08926404e-02f,
  -3.05845286e-03f, 1.01521544e-01f, 2.12031677e-02f, -8.83628651e-02f, 8.07226896e-02f, -5.80590814e-02f, -3.98240723e-02f, 4.23942599e-03f, -5.67400083e-02f, 6.94585964e-02f,
  4.27939259e-02f, 2.89926641e-02f, 9.20655355e-02f, 5.52700199e-02f, -5.89376874e-02f, 5.92772402e-02f, 1.35518342e-01f, 1.58797085e-01f, -4.15233001e-02f, -3.38733825e-03f,
  6.19436279e-02f, 5.63246720e-02f, -4.60455827e-02f, -9.84024331e-02f, 2.44115503e-03f, 6.97272792e-02f, 2.47952193e-02f, -5.44422939e-02f, -5.37727475e-02f, -6.70653433e-02f,
  2.05990821e-02f, -2.76302341e-02f, -9.28991754e-03f, 4.27928828e-02f, 8.50339513e-03f, -1.77981355e-03f, -4.09738757e-02f, 3.08422353e-02f, 5.20015433e-02f, -6.45989999e-02f,
  5.05738445e-02f, 5.21414280e-02f, 6.93347156e-02f, 3.63622047e-02f, 4.22526076e-02f, -5.99859692e-02f, -2.82917377e-02f, 5.54036275e-02f, 9.12839919e-02f, -3.42307873e-02f,
  -5.80418482e-02f, -6.51617674e-03f, 1.87272504e-02f, 7.41926879e-02f, 4.90943417e-02f, 7.72788078e-02f, 1.01484247e-01f, -3.81702632e-02f, -4.59637232e-02f, 6.11138297e-04f,
  -2.16427371e-02f, 4.69460934e-02f, -1.52668670e-01f, 2.25541107e-02f, 3.89573202e-02f, -6.54157922e-02f, 4.61081490e-02f, -2.39333622e-02f, -4.26208824e-02f, -6.88787252e-02f,
  -4.99126688e-02f, 5.40717207e-02f, -3.07165869e-02f, 7.29906112e-02f, -3.57634900e-03f, -1.08165480e-01f, 5.58430031e-02f, 9.99754760e-03f, -5.61481230e-02f, -7.21334293e-02f,
  3.78069608e-03f, 4.02442925e-03f, -1.09549947e-01f, -6.64919093e-02f, 6.38492359e-03f, -1.68606833e-01f, -8.18140283e-02f, -1.25655323e-01f, -1.15624167e-01f, -1.66352168e-01f,
  1.45510927e-01f, 7.61261359e-02f, 1.25228558e-02f, 1.08888254e-01f, 1.46007627e-01f, -2.43377984e-02f, 7.21313730e-02f, -2.69318018e-02f, -5.14190225e-03f, 8.79671648e-02f,
  1.92650437e-01f, 2.28069007e-01f, 1.80854946e-01f, 1.08830370e-01f, 1.92380548e-02f, -7.66783208e-02f, -7.08895829e-03f, 5.41964620e-02f, -3.09346127e-03f, 1.47617022e-02f,
  1.13447145e-01f, -6.71371892e-02f, 4.84547466e-02f, 7.16504501e-03f, 7.31257424e-02f, 7.65588433e-02f, 2.85198744e-02f, 7.98093528e-02f, -3.09567470e-02f, -2.87966784e-02f,
  1.10836245e-01f, 2.70123128e-02f, 6.72150850e-02f, 6.64600581e-02f, -4.24840078e-02f, 5.13666980e-02f, 4.93638664e-02f, 4.35133129e-02f, -8.14174023e-03f, -4.37450893e-02f,
  -1.16557600e-02f, -4.72120382e-02f, 3.44858915e-02f, 4.36367989e-02f, 4.00704965e-02f, -2.83534992e-02f, -4.38091345e-02f, 5.78268953e-02f, -3.92279290e-02f, 8.73413980e-02f,
  -7.29592294e-02f, -1.83716440e-03f, -6.95344582e-02f, 1.31636783e-02f, 2.53287684e-02f, -2.31950656e-02f, 3.65165360e-02f, 5.96032850e-02f, -3.87545377e-02f, 4.85698320e-02f,
  1.16551489e-01f, 3.67197320e-02f, 8.73399079e-02f, -5.40782921e-02f, -2.95008086e-02f, 1.57489423e-02f, 6.39749318e-02f, 7.72178248e-02f, -9.61110368e-03f, -3.53785115e-04f,
  4.61283000e-03f, 6.59523383e-02f, 5.62181212e-02f, 1.28900250e-02f, 1.20399848e-01f, 5.66947684e-02f, 1.16510736e-03f, -4.16768268e-02f, 8.63147676e-02f, -6.06169030e-02f,
  9.22219455e-02f, 4.81793210e-02f, 9.76390392e-03f, -6.55707270e-02f, 2.45611165e-02f, -3.69757377e-02f, -4.51248251e-02f, 6.08630255e-02f, -4.43241335e-02f, 8.08581244e-03f,
  -1.20303920e-03f, 1.10651359e-01f, 7.75413439e-02f, 3.45787816e-02f, -3.79714556e-02f, -1.22847222e-03f, 5.35507947e-02f, -6.20606132e-02f, 4.07461114e-02f, 2.61072945e-02f,
  6.47265166e-02f, -1.71624012e-02f, -6.66730255e-02f, 3.28582302e-02f, -3.97087187e-02f, 1.25310440e-02f, -3.68423127e-02f, 6.11197874e-02f, 6.17597811e-02f, -9.06578898e-02f,
  5.25730774e-02f, -5.67696430e-02f, 1.26145601e-01f, 7.74611309e-02f, 4.92061004e-02f, 2.65162513e-02f, -5.27361482e-02f, -4.90347147e-02f, 8.33771657e-03f, 2.81399721e-03f,
  4.22749370e-02f, -3.08772735e-02f, -4.33130153e-02f, 6.86929002e-02f, -3.61569449e-02f, -1.16430439e-01f, -9.20376480e-02f, -6.43695742e-02f, 9.31934565e-02f, -2.88892966e-02f,
  3.33615355e-02f, -4.74567525e-02f, -6.05264567e-02f, 3.44151780e-02f, 8.06852803e-02f, -1.13434106e-01f, -1.17277510e-01f, -7.51358420e-02f, -2.22939719e-02f, 3.30242291e-02f,
  7.31237307e-02f, -6.23347126e-02f, 8.84204805e-02f, -5.07346578e-02f, 5.29630147e-02f, -1.78216062e-02f, -1.18413053e-01f, -1.68761257e-02f, -7.18562976e-02f, -2.77233832e-02f,
  -1.76821649e-01f, -5.62120304e-02f, 8.30482915e-02f, 1.13781460e-01f, -9.38541666e-02f, -8.79890919e-02f, 6.31963685e-02f, 3.36924382e-02f, -2.79851034e-02f, 6.16197661e-02f,
  -8.07695389e-02f, 2.14335714e-02f, -4.10520881e-02f, -3.22209448e-02f, 7.09832907e-02f, 5.31354025e-02f, 9.24973786e-02f, -1.62336193e-02f, -9.59425699e-03f, 6.10116720e-02f,
  3.92945409e-02f, -1.28688086e-02f, -8.55526850e-02f, -8.49133059e-02f, -2.11320296e-02f, 4.95912582e-02f, 5.67663424e-02f, 5.88110946e-02f, 2.46452019e-02f, -2.46094540e-02f,
  2.18420904e-02f, -9.30391550e-02f, 4.36847750e-03f, -1.36250695e-02f, 7.14221299e-02f, 2.92083109e-03f, 2.69019157e-02f, 1.75976194e-02f, 9.59468037e-02f, 1.76518057e-02f,
  -6.13377281e-02f, 6.47184486e-03f, -9.85374004e-02f, 4.96660657e-02f, -8.21047872e-02f, 4.56793606e-02f, 3.02053932e-02f, 6.13264069e-02f, 3.74452472e-02f, -2.88663246e-02f,
  8.95086955e-03f, 1.05196377e-02f, -2.47342102e-02f, 7.76958466e-02f, 5.11230454e-02f, 5.31739779e-02f, 5.43328449e-02f, -4.25405279e-02f, 7.87320659e-02f, 6.77835047e-02f,
  9.16732624e-02f, 7.11408630e-02f, -4.00376692e-02f, 8.41314197e-02f, 3.74158733e-02f, 5.29560521e-02f, -7.40431175e-02f, 9.57371220e-02f, -6.33862913e-02f, -7.23023862e-02f,
  4.86350153e-04f, -6.14550672e-02f, 4.65164566e-03f, 3.08470000e-02f, 2.92089991e-02f, -6.77343532e-02f, -7.90069439e-03f, -9.89477560e-02f, 1.36397658e-02f, -5.92340939e-02f,
  -2.98789386e-02f, 2.78634820e-02f, 7.48058483e-02f, -5.39370365e-02f, 1.09519782e-02f, 7.13693202e-02f, 2.64301356e-02f, 8.48868713e-02f, -1.12684127e-02f, 5.89556135e-02f,
  -7.71859055e-03f, -2.82762814e-02f, 8.93228725e-02f, -1.28727844e-02f, -3.51221748e-02f, 4.16375697e-02f, 1.67877041e-02f, 5.06730862e-02f, 6.38575032e-02f, -6.42971843e-02f,
  2.04292946e-02f, -4.69173677e-02f, 4.85208444e-02f, 5.36402762e-02f, 3.26333791e-02f, 5.23706200e-03f, -7.17538819e-02f, -7.40556940e-02f, -8.57556798e-03f, -6.19465904e-03f,
  -7.31991529e-02f, 6.03869930e-02f, -1.49273349e-03f, -6.20581768e-02f, -7.73717184e-03f, -6.55260310e-02f, 1.04826890e-01f, -1.07535999e-02f, 7.07372129e-02f, -4.29553576e-02f,
  7.57742971e-02f, 5.42890467e-02f, -8.48899782e-02f, 9.28508043e-02f, 9.13991556e-02f, 1.60806365e-02f, -1.14638871e-02f, 8.48023370e-02f, 6.76006302e-02f, 8.48231241e-02f,
  3.08698323e-02f, -3.97156961e-02f, 2.40763165e-02f, 7.19956681e-02f, 2.13917531e-02f, 2.38413755e-02f, 2.71166638e-02f, -7.26321945e-03f, 5.69776483e-02f, -3.76093015e-02f,
  1.62653830e-02f, 7.37663656e-02f, -5.93021475e-02f, 7.73357749e-02f, -8.07215571e-02f, -2.83777248e-02f, -4.60936315e-02f, -6.29624585e-03f, -3.54611489e-04f, -3.82153206e-02f,
  4.21181060e-02f, 7.66856670e-02f, -2.14090478e-03f, -1.19855152e-02f, -3.50238830e-02f, -7.85242915e-02f, -9.55426469e-02f, 1.51280491e-02f, -1.02953710e-01f, -1.31848222e-03f,
  6.99477196e-02f, -3.20340730e-02f, 4.59139422e-02f, -2.39374992e-02f, 6.26074001e-02f, 3.03868856e-02f, 1.59010859e-04f, -7.00347126e-02f, -8.20480287e-02f, -1.47140091e-02f,
  5.58974631e-02f, 8.74276683e-02f, 8.71350542e-02f, 4.79485579e-02f, 6.84267431e-02f, -7.94681534e-02f, 6.14324817e-03f, -5.12792617e-02f, -2.48345956e-02f, 1.39180012e-02f,
  8.78413543e-02f, -9.37796161e-02f, 6.60241097e-02f, -7.00678751e-02f, -2.51147337e-02f, 6.36252463e-02f, 6.17999621e-02f, -2.35327892e-02f, 1.15387820e-01f, 3.78328338e-02f,
  8.89276043e-02f, 8.68849307e-02f, -7.89523944e-02f, 8.87456015e-02f, 5.19192815e-02f, 9.34748575e-02f, 7.09645227e-02f, -4.74792086e-02f, 1.00890197e-01f, 8.72093812e-02f,
  5.04593924e-02f, -2.52862945e-02f, 7.15208575e-02f, 5.98516017e-02f, 2.34894995e-02f, 1.98485516e-03f, 3.80106419e-02f, 8.19995031e-02f, 3.76825850e-03f, 2.00973954e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -4.15904149e-02f, 7.71264313e-03f, 6.52771145e-02f, -2.57964823e-02f, 1.44142464e-01f, -1.37336170e-02f, 1.10036932e-01f, 7.31152669e-02f, 1.10372841e-01f, 1.83696866e-01f,
  5.74987642e-02f, 1.51272178e-01f, 1.23524465e-01f, 1.21187195e-01f, 1.18200913e-01f, 2.19088756e-02f, 1.57832708e-02f, 3.18432413e-02f, 1.62974700e-01f, 1.22337639e-01f,
  1.48427367e-01f, 5.10170404e-03f, 1.45736426e-01f, 2.68141227e-03f, 2.92071011e-02f, -5.41624054e-03f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  1.01112418e-01f, 4.26797271e-02f, 3.30420248e-02f, 4.66653071e-02f, 1.01764746e-01f, 5.48245795e-02f, 2.15766057e-02f, 5.05773313e-02f, 5.08955047e-02f, 2.35842094e-02f,
  8.04032460e-02f, 1.06993839e-01f, 7.34127536e-02f, -5.18948175e-02f, -4.78201099e-02f, 6.22863211e-02f, 1.15723256e-02f, 5.03764264e-02f, 2.98642591e-02f, -8.75162110e-02f,
  -7.97199011e-02f, -1.58855710e-02f, 7.67339766e-02f, -2.52635386e-02f, 6.38430007e-03f, 4.98128347e-02f, -6.49549291e-02f, -6.63197339e-02f, -1.20027728e-01f, 5.80576845e-02f,
  9.22425315e-02f, -3.70074958e-02f, 1.82641763e-02f, 8.09067562e-02f, -4.71772589e-02f, -3.72449681e-02f, 1.57833472e-02f, -2.58821156e-02f, -2.98942532e-02f, -2.84187831e-02f,
  -3.23507339e-02f, -6.92004934e-02f, -7.30158761e-02f, -2.33153105e-02f, 4.04777676e-02f, -6.36333376e-02f, 6.51946068e-02f, 3.65296714e-02f, 3.40005159e-02f, -4.00033686e-03f,
  2.66370233e-02f, 1.17558755e-01f, -1.59023013e-02f, 1.01068942e-02f, -1.46889836e-01f, -2.14241585e-03f, 2.43825372e-02f, 1.32195456e-02f, -1.08796604e-01f, 3.66203338e-02f,
  -5.38667887e-02f, 2.69354880e-02f, 3.04967295e-02f, 5.29103838e-02f, 1.02644324e-01f, 4.85830614e-03f, -1.44062951e-01f, 4.90353582e-03f, -5.42759225e-02f, -1.11291528e-01f,
  1.03190511e-01f, -5.78690134e-03f, 2.79962104e-02f, 1.87677816e-02f, -1.61522012e-02f, -3.27834068e-03f, 1.13346383e-01f, 2.52667740e-02f, 2.45547872e-02f, 8.55724066e-02f,
  7.96182267e-03f, 9.66698229e-02f, -3.63482237e-02f, -4.50428948e-02f, 2.06381939e-02f, 1.21820621e-01f, 9.50156525e-02f, 1.48962036e-01f, 3.22140008e-02f, -5.31477593e-02f,
  1.28548488e-01f, 4.41003814e-02f, -8.08482543e-02f, 2.39711720e-02f, 1.50171712e-01f, 5.46493419e-02f, 1.02265179e-01f, -8.62012804e-02f, -1.72137260e-01f, -6.54127309e-03f,
  1.96206018e-01f, 1.19228669e-01f, -4.47210036e-02f, -2.87221465e-02f, 4.08688150e-02f, 2.67172214e-02f, 1.25776976e-02f, 6.45352826e-02f, -3.71055044e-02f, 9.21746418e-02f,
  1.35362625e-01f, -8.04670453e-02f, 2.47432943e-03f, 1.88621657e-03f, -3.46765891e-02f, -3.99451777e-02f, 1.06921002e-01f, -2.16241758e-02f, -7.08617195e-02f, 5.03682578e-03f,
  1.00774273e-01f, 1.00779332e-01f, 5.88767827e-02f, 4.18401621e-02f, -8.93101022e-02f, 1.02064200e-01f, -5.98633587e-02f, -9.04722884e-02f, -6.42692437e-03f, 3.64505053e-02f,
  5.76959103e-02f, -5.54246008e-02f, 3.00870892e-02f, 3.77291366e-02f, -8.08618590e-02f, -1.00670695e-01f, -3.40002403e-02f, 5.72322160e-02f, -5.09597883e-02f, -2.03011297e-02f,
  -5.11222184e-02f, 1.51133733e-02f, -5.04989084e-03f, 4.36587781e-02f, 4.32881154e-02f, -3.28230038e-02f, -1.15285002e-01f, -2.52241939e-02f, -1.27431834e-02f, 4.31872420e-02f,
  -6.46558478e-02f, -4.87547405e-02f, 6.04442395e-02f, 2.08332185e-02f, 2.92843077e-02f, 4.65779155e-02f, 7.41104111e-02f, -6.66368306e-02f, 9.71742570e-02f, 1.20550990e-02f,
  1.49777913e-02f, -3.96744497e-02f, -1.53181236e-02f, 1.64572464e-03f, -5.48910489e-03f, 3.72688472e-02f, 3.92751135e-02f, 4.85959388e-02f, 3.98966633e-02f, 1.54201567e-01f,
  -1.06356010e-01f, 7.73670748e-02f, -7.01416656e-02f, 4.18740660e-02f, 4.56327386e-02f, 6.40403777e-02f, -9.70220044e-02f, 2.13075820e-02f, -4.20438759e-02f, 6.27696216e-02f,
  -1.97281554e-01f, -5.53098246e-02f, 1.61704376e-01f, 3.54821049e-02f, -3.60190906e-02f, 6.48938771e-03f, -9.77871493e-02f, 8.39297473e-02f, -1.07706510e-01f, 9.36359614e-02f,
  8.42913315e-02f, 5.22875460e-03f, -1.65210143e-01f, 1.84095085e-01f, -2.86877025e-02f, -6.52339496e-03f, 8.97378698e-02f, 5.01019657e-02f, -5.80691062e-02f, 1.91887513e-01f,
  4.59494852e-02f, -1.86763749e-01f, -6.32651597e-02f, -1.23700559e-01f, -7.32285976e-02f, 1.11475170e-01f, -2.50399679e-01f, -2.22116545e-01f, -1.70516565e-01f, -8.78361240e-03f,
  -1.57356516e-01f, -1.08969726e-01f, 1.10723972e-01f, 8.21770430e-02f, 2.07054578e-02f, -1.32769689e-01f, 7.92616457e-02f, 9.00248718e-03f, 9.46723819e-02f, -1.43641392e-02f,
  -1.17097488e-02f, -1.80022016e-01f, -1.94036439e-02f, 9.87562463e-02f, 5.50696887e-02f, -4.43039685e-02f, 1.45574793e-01f, 1.35985002e-01f, 6.15902543e-02f, 3.79440677e-03f,
  -5.63272871e-02f, 1.16114207e-01f, 1.47850886e-01f, -4.99033518e-02f, -3.18154730e-02f, -2.18168031e-02f, 4.72032465e-02f, -5.63261323e-02f, -7.57213160e-02f, 1.36974305e-01f,
  -6.02570437e-02f, 1.49295330e-01f, 3.66883315e-02f, -8.69086608e-02f, -5.02657555e-02f, -1.08327575e-01f, 4.19375822e-02f, 7.67304674e-02f, 4.76553440e-02f, -6.40200265e-03f,
  -8.93491060e-02f, -4.17549051e-02f, 7.18537718e-02f, -4.60645854e-02f, -1.14420421e-01f, -3.36552188e-02f, 4.07835171e-02f, 4.51040156e-02f, -3.45672332e-02f, 1.12689687e-02f,
  -7.05685513e-03f, 5.92324976e-03f, 9.08448547e-02f, 4.04873537e-03f, 4.08396758e-02f, 7.94891417e-02f, -7.06517249e-02f, 2.93220431e-02f, 5.02614342e-02f, 1.15136630e-04f,
  -3.10251191e-02f, 1.25122055e-01f, 5.87213151e-02f, 4.07158099e-02f, -4.17045131e-02f, 4.70408201e-02f, -7.73693994e-03f, 8.93987045e-02f, 9.31691658e-03f, 2.31474452e-02f,
  -3.40869720e-03f, -1.24639966e-01f, 2.98517384e-02f, 9.36228335e-02f, -4.97439224e-03f, -3.15633090e-03f, 4.51572426e-02f, -8.76108035e-02f, -5.03185838e-02f, -6.87350845e-03f,
  9.53250844e-03f, -2.19517164e-02f, -1.86243542e-02f, 1.36867419e-01f, -3.22276056e-02f, 2.25783028e-02f, -4.47792970e-02f, 9.09163877e-02f, -1.16639018e-01f, 3.50359194e-02f,
  1.02974288e-01f, 8.74623097e-03f, 5.78565784e-02f, -7.57140433e-03f, -6.14328571e-02f, -4.40291353e-02f, 3.94781604e-02f, 4.66525592e-02f, -5.47228903e-02f, 7.23402798e-02f,
  8.72468874e-02f, -1.22127995e-01f, -3.77016850e-02f, -6.99800402e-02f, -1.94909591e-02f, 1.17738180e-01f, -9.35183540e-02f, 1.05708100e-01f, -3.91537547e-02f, 2.91398335e-02f,
  -1.99120164e-01f, 2.08331287e-01f, 3.26016210e-02f, -3.18864435e-02f, -3.02437283e-02f, 1.35529578e-01f, -5.89575060e-02f, 2.10209712e-01f, 8.43062922e-02f, -1.56184420e-01f,
  -1.29681274e-01f, -8.08189437e-03f, -5.36906160e-02f, 1.15533816e-02f, -1.41040713e-01f, -1.18062325e-01f, -6.04221374e-02f, -5.17008156e-02f, -9.29375216e-02f, -1.41711190e-01f,
  1.05909072e-01f, 9.32124443e-03f, 1.39438957e-01f, -1.38026774e-01f, 9.34080556e-02f, 6.82831854e-02f, 8.08741003e-02f, 1.23759076e-01f, 4.19037929e-03f, -2.63990904e-03f,
  -8.57566148e-02f, 1.77010641e-01f, 6.11569919e-02f, 5.21903336e-02f, 7.50004575e-02f, 2.51558155e-01f, -1.63902238e-01f, 8.56482536e-02f, 1.90237183e-02f, 6.39650524e-02f,
  1.44034773e-01f, -4.87770028e-02f, 4.64822091e-02f, -2.73801368e-02f, 2.38052271e-02f, 1.39157087e-01f, -1.26704156e-01f, 1.03229918e-01f, 5.97204007e-02f, -3.73718282e-03f,
  -7.66297802e-02f, -9.21179950e-02f, -1.80545300e-01f, 5.19592650e-02f, -1.21269701e-02f, 1.90755017e-02f, -6.80919141e-02f, 4.69549559e-02f, 1.11412667e-01f, -1.37450591e-01f,
  5.07083461e-02f, -5.34146801e-02f, -1.74251497e-02f, -2.35690782e-03f, -2.24195104e-02f, 6.62460029e-02f, -2.41637155e-02f, -3.19756456e-02f, 5.88741675e-02f, -4.17534485e-02f,
  -5.50386496e-02f, 4.00533853e-03f, -1.62494015e-02f, -8.06101486e-02f, -3.95088159e-02f, -8.88681188e-02f, -7.16807097e-02f, 6.35508522e-02f, -5.85757270e-02f, -1.69136554e-01f,
  7.30148563e-03f, 5.74997440e-02f, 8.51591304e-02f, 4.40946668e-02f, 5.20580150e-02f, 1.08202405e-01f, 5.66099584e-02f, -4.66140397e-02f, -1.14975963e-02f, 8.80931988e-02f,
  -1.36560015e-02f, -3.81274670e-02f, -9.58861597e-03f, 7.00389072e-02f, -4.97622266e-02f, 4.77040187e-02f, 5.35236038e-02f, 2.80983858e-02f, 7.58563653e-02f, -3.21802199e-02f,
  1.69742585e-03f, -1.05612442e-01f, -5.07524721e-02f, -6.74790516e-02f, 1.29877195e-01f, -4.96832430e-02f, 8.10532644e-02f, -6.53215721e-02f, -1.53438291e-02f, 5.83718903e-03f,
  -7.17799217e-02f, 1.61577072e-02f, -5.41607328e-02f, -7.38736540e-02f, -4.75101508e-02f, -6.52051568e-02f, 3.63336466e-02f, 4.08577360e-02f, -5.36796972e-02f, 4.66005169e-02f,
  -7.38774985e-02f, -1.16191385e-02f, -1.05831571e-01f, 4.26857024e-02f, 1.31710619e-01f, -7.33937472e-02f, 5.63339479e-02f, -1.43622253e-02f, 1.59221932e-01f, -1.31433666e-01f,
  7.87910745e-02f, 7.38003254e-02f, -6.03998173e-03f, -1.24961816e-01f, 6.96037337e-03f, -8.26827809e-02f, -1.10917993e-01f, 1.35217950e-01f, -6.59496114e-02f, -1.47810474e-01f,
  -7.13887662e-02f, -8.46259370e-02f, 1.12136729e-01f, 6.69718832e-02f, 2.87598222e-02f, 6.09621704e-02f, -6.76105320e-02f, 1.40987098e-01f, 1.34343728e-02f, -6.91731945e-02f,
  -5.85513785e-02f, -4.48286012e-02f, -8.90124366e-02f, 4.76748906e-02f, -4.81187850e-02f, -1.53946236e-01f, 3.49507220e-02f, -6.78330064e-02f, -4.78107482e-02f, -1.50763154e-01f,
  -6.17561080e-02f, -6.70243874e-02f, 5.63701466e-02f, -1.93998113e-01f, 1.06128871e-01f, -6.65709078e-02f, -6.34852126e-02f, -2.51711402e-02f, -1.18643250e-02f, -1.29457880e-02f,
  3.43144052e-02f, -8.99220072e-03f, -3.68705057e-02f, -1.42800137e-01f, 1.10920198e-01f, 7.16037676e-02f, -2.52915211e-02f, 3.33733447e-02f, 8.95240232e-02f, 2.29281746e-02f,
  1.22924551e-01f, -3.60371396e-02f, 4.02379222e-02f, -5.50770983e-02f, 4.40281816e-02f, -7.83548281e-02f, 1.02599589e-02f, 1.15769975e-01f, -3.32553983e-02f, 9.30804834e-02f,
  1.31624803e-01f, 3.70660685e-02f, 5.60898781e-02f, 1.03541635e-01f, 3.09527051e-02f, 7.48425871e-02f, -7.88109303e-02f, -6.86962306e-02f, -6.38935668e-03f, 1.25080779e-01f,
  -9.38046575e-02f, 2.66897194e-02f, -2.51850244e-02f, 2.22129617e-02f, 7.56003484e-02f, 5.83283901e-02f, -3.76775376e-02f, -7.57953376e-02f, -4.82246429e-02f, -1.73279978e-02f,
  -9.11655873e-02f, 6.58235252e-02f, 1.01490386e-01f, 6.44247159e-02f, 1.37190346e-03f, 1.05530985e-01f, -6.49821907e-02f, -1.62913371e-02f, 3.97173464e-02f, 3.93760614e-02f,
  -3.66954878e-02f, 4.63087931e-02f, -1.31539553e-01f, -6.12429194e-02f, -1.75504312e-02f, -3.71084325e-02f, 6.15228899e-02f, 7.83744678e-02f, 1.11858048e-01f, -5.04761375e-02f,
  -1.03248209e-02f, 3.88285555e-02f, 2.97213905e-02f, -7.97007009e-02f, 1.06268443e-01f, 8.89784023e-02f, 1.22662829e-02f, -2.61242893e-02f, 1.13611899e-01f, 6.41023070e-02f,
  1.20868258e-01f, -6.67121410e-02f, -4.65279408e-02f, -2.97860708e-03f, -3.33266780e-02f, 1.44684687e-01f, 2.11435575e-02f, -2.59811468e-02f, -4.09652432e-03f, -7.43922312e-04f,
  1.07275493e-01f, -3.51904482e-02f, 1.59600496e-01f, 8.63259286e-02f, -3.94779518e-02f, -1.07310809e-01f, -1.04611658e-01f, -5.70490696e-02f, -3.89338247e-02f, 4.11610026e-03f,
  -2.04798877e-02f, 1.20180137e-02f, -1.79674357e-01f, 1.19387865e-01f, 3.31565887e-02f, -2.50165705e-02f, -7.31215477e-02f, -1.49246827e-01f, -4.69414704e-02f, -1.14255644e-01f,
  2.90947445e-02f, 1.00777519e-03f, -1.08399987e-01f, -2.22494930e-01f, 1.42024430e-02f, -1.30959228e-02f, -1.91356614e-02f, -4.56641056e-02f, -1.45438790e-01f, 2.15562582e-02f,
  -1.17096819e-01f, -3.11821681e-02f, 2.92197149e-03f, -1.42862931e-01f, -1.16777525e-03f, 1.00683756e-02f, 1.94313638e-02f, -1.22848995e-01f, -3.77265103e-02f, 2.13388857e-02f,
  1.60878867e-01f, -8.66644271e-03f, -2.67097428e-02f, 1.40306177e-02f, 4.85964026e-03f, 3.06526776e-02f, 6.59280047e-02f, -5.84674291e-02f, -3.19293179e-02f, -4.93794605e-02f,
  -6.40702620e-02f, -2.19145492e-01f, -4.02251780e-02f, 1.83100868e-02f, 6.12482168e-02f, 4.01870720e-02f, -1.00111313e-01f, -1.23929337e-01f, -2.98835803e-02f, -9.61379614e-03f,
  7.65715688e-02f, 8.18215385e-02f, -6.62563974e-03f, -8.84490609e-02f, -1.47102818e-01f, -3.81584875e-02f, 6.07526563e-02f, 1.98959489e-03f, -7.27996603e-03f, -8.09661597e-02f,
  2.29679588e-02f, 6.86144978e-02f, -5.87454773e-02f, 5.90867661e-02f, -4.40725014e-02f, -4.33860756e-02f, -6.26686960e-02f, -8.90336633e-02f, -3.40608992e-02f, -3.43965255e-02f,
  5.27436845e-02f, -6.82126209e-02f, -5.26867360e-02f, -8.20808113e-02f, 8.92344583e-03f, 3.92253920e-02f, -8.66531357e-02f, -8.03885162e-02f, 1.17149996e-02f, -5.32486551e-02f,
  3.24560814e-02f, -1.25769302e-01f, 4.88608330e-02f, 3.44955991e-03f, -5.32567874e-02f, 6.74456656e-02f, -7.49359420e-03f, 2.77720317e-02f, 9.30826887e-02f, 4.86565866e-02f,
  2.26821695e-02f, 7.79114068e-02f, -4.51817401e-02f, -1.80706959e-02f, 5.27981929e-02f, -2.03269888e-02f, 4.01375853e-02f, -7.11274296e-02f, -8.88459384e-02f, 1.74008459e-02f,
  -1.20192096e-01f, 7.31377602e-02f, -6.00698814e-02f, 7.15568587e-02f, -4.16544713e-02f, 6.77857324e-02f, -1.05489329e-01f, 1.19306426e-02f, -2.61307918e-02f, 5.87766431e-02f,
  -1.42384032e-02f, 7.72022875e-03f, -1.16581833e-02f, -1.67637039e-02f, 2.45394222e-02f, -1.19029805e-01f, 2.56584529e-02f, 7.88223296e-02f, 3.86705399e-02f, 1.05632797e-01f,
  -3.81860025e-02f, 1.18935972e-01f, -7.41596222e-02f, -1.28848121e-01f, -6.26098737e-02f, 7.53422603e-02f, -8.88884291e-02f, 9.43052396e-03f, 5.45785427e-02f, -4.14758623e-02f,
  -4.74194475e-02f, 4.84394049e-03f, 2.63974629e-02f, -4.56908830e-02f, 7.76923820e-02f, 1.02454366e-03f, 2.52585970e-02f, -3.11244261e-02f, -7.89075494e-02f, -1.06733814e-01f,
  -1.21421427e-01f, 1.24678172e-01f, -5.96591011e-02f, 3.20706666e-02f, 9.11109969e-02f, 2.47096401e-02f, -7.13432431e-02f, -3.30409333e-02f, 4.31779698e-02f, 8.47350582e-02f,
  7.49892741e-02f, 6.57855570e-02f, -5.54436408e-02f, -5.61515149e-03f, 2.37061339e-03f, -1.14888446e-02f, -3.27712367e-03f, -4.80793603e-02f, -5.42703830e-02f, 1.40541703e-01f,
  4.73538935e-02f, 2.34294552e-02f, -6.79655075e-02f, 6.40461370e-02f, -6.84374105e-03f, -1.55766113e-02f, 2.01115683e-02f, 5.61714023e-02f, -5.15918024e-02f, 2.15641260e-01f,
  -2.81026885e-02f, 3.50157246e-02f, -6.80423826e-02f, 1.35858849e-01f, 6.13430701e-02f, -8.14988464e-02f, -8.74668956e-02f, -6.11385480e-02f, 6.18942268e-03f, -1.27928136e-02f,
  -8.95905420e-02f, -6.33258522e-02f, 6.59590289e-02f, 3.12375277e-02f, 8.49321336e-02f, -2.21577287e-03f, -5.19749001e-02f, 1.03101239e-01f, 3.69939841e-02f, 1.52867138e-02f,
  -3.80908214e-02f, 3.80763854e-03f, 7.13326037e-02f, 9.24656913e-02f, 3.20557281e-02f, 3.90006118e-02f, -6.15614615e-02f, 1.44390948e-02f, 6.16163388e-02f, 4.24074233e-02f,
  2.72910856e-02f, 4.63198051e-02f, -9.02063027e-03f, 8.76406059e-02f, -2.46800855e-02f, 9.23698694e-02f, -4.60385717e-02f, -5.67411259e-02f, 8.06972831e-02f, -3.76750566e-02f,
  -2.39091702e-02f, -8.62708837e-02f, -4.66060154e-02f, -9.96722579e-02f, -9.12155062e-02f, 3.98327149e-02f, -7.20993057e-03f, -5.69355972e-02f, 2.35398207e-02f, -6.42697439e-02f,
  -4.35162559e-02f, 8.64850357e-02f, -9.81152337e-03f, 1.74847022e-02f, 3.69179957e-02f, 6.58645555e-02f, 1.34836128e-02f, 1.05314637e-02f, -5.24965078e-02f, 5.09328432e-02f,
  2.52467003e-02f, 1.83510818e-02f, 1.60084572e-02f, -2.41438262e-02f, -6.46445304e-02f, -7.65765384e-02f, -5.34217656e-02f, -9.60597619e-02f, -1.30729023e-02f, -6.82151020e-02f,
  -9.07261856e-03f, -4.94129434e-02f, 2.21918579e-02f, 2.28345282e-02f, -8.26961081e-03f, -1.62296548e-01f, -4.08658013e-02f, 8.99148360e-02f, 1.03313588e-01f, -8.45740065e-02f,
  -1.12194724e-01f, 3.45721729e-02f, -8.18279237e-02f, 1.59496009e-01f, -9.72701702e-04f, 5.57486303e-02f, 5.59392124e-02f, 4.33210144e-03f, -3.71946371e-03f, 8.26451555e-02f,
  1.04547188e-01f, -4.75149602e-02f, -8.41253921e-02f, -5.37795313e-02f, 9.05892998e-03f, 8.72745514e-02f, 6.89920224e-03f, -1.10088475e-01f, -6.32904917e-02f, 7.31553957e-02f,
  -5.60927950e-02f, -2.60321945e-02f, 6.27061427e-02f, 1.22579798e-01f, 2.37370543e-02f, -6.21172301e-02f, 9.69431251e-02f, 4.86277230e-02f, 6.42639548e-02f, 1.20018229e-01f,
  9.38226953e-02f, 3.95124406e-02f, -9.57313254e-02f, 1.44029841e-01f, 6.48209602e-02f, 7.65542835e-02f, -7.59824142e-02f, 5.84457740e-02f, 6.29123449e-02f, 4.66585252e-03f,
  2.54963655e-02f, -8.42998698e-02f, 5.70087619e-02f, -2.32236907e-02f, 1.20031811e-01f, -6.53461963e-02f, -7.13973166e-03f, 3.39978524e-02f, -7.60447755e-02f, -6.71980623e-03f,
  3.72511800e-03f, -1.15560509e-01f, -8.67509097e-02f, -3.82585004e-02f, 4.90432568e-02f, -8.29770342e-02f, 1.40978536e-02f, 3.35765593e-02f, 1.30971605e-02f, 3.23469639e-02f,
  -7.43993148e-02f, -1.05575584e-01f, -3.18982564e-02f, -5.37843369e-02f, 4.15812172e-02f, -8.73448327e-02f, -2.48803254e-02f, 1.13230430e-01f, 5.31646200e-02f, -5.69626056e-02f,
  -5.01028784e-02f, -1.07290745e-02f, 5.81502430e-02f, -8.87729321e-03f, 1.64785807e-03f, 2.24320330e-02f, 4.36347798e-02f, -1.63427219e-02f, 6.86497465e-02f, -1.12673253e-01f,
  4.34578434e-02f, 5.99121563e-02f, -1.34965712e-02f, 9.70378518e-02f, -3.48671386e-03f, -8.66770744e-02f, -4.89127748e-02f, -5.31596281e-02f, 1.00638725e-01f, 4.94634956e-02f,
  9.96086821e-02f, -9.83739365e-03f, 7.27257431e-02f, -3.17885801e-02f, 5.06757833e-02f, -1.92701966e-02f, 2.74404511e-02f, -1.16284519e-01f, -6.75714239e-02f, -6.63300306e-02f,
  -6.92383349e-02f, 1.29152164e-01f, 7.60868341e-02f, 7.13422894e-02f, 6.07766546e-02f, -7.16922572e-03f, -8.35067183e-02f, 1.15679868e-01f, -4.37423475e-02f, -4.67326604e-02f,
  -5.95423691e-02f, 2.75730286e-02f, 3.77124595e-03f, -1.06349438e-01f, -3.92471328e-02f, -1.32632554e-01f, -7.52146319e-02f, -3.73096541e-02f, -8.28513503e-02f, 3.62747572e-02f,
  5.28857633e-02f, 4.43867557e-02f, -3.22198011e-02f, 1.52203357e-02f, 7.80118853e-02f, 1.58593506e-01f, 6.19636960e-02f, 1.06704749e-01f, 1.52448975e-02f, -6.84695244e-02f,
  -1.89445063e-01f, 1.40006423e-01f, -1.80668142e-02f, -3.55935544e-02f, 9.07394961e-02f, 7.49786645e-02f, -1.70411825e-01f, 6.50911331e-02f, 8.08624253e-02f, -5.74578308e-02f,
  -2.05475185e-02f, 4.67586108e-02f, -3.69220339e-02f, 8.47840831e-02f, -1.26527727e-01f, -6.57239482e-02f, -1.72055125e-01f, -8.44512358e-02f, -4.69745137e-02f, -1.08485870e-01f,
  9.25903618e-02f, 1.37375250e-01f, -5.89730926e-02f, -1.22600131e-01f, 1.32096127e-01f, 6.37213290e-02f, -3.91191021e-02f, -1.38775045e-02f, -1.54195298e-02f, 7.19755292e-02f,
  -3.42368074e-02f, 4.53946739e-02f, -8.39217845e-03f, 5.22023849e-02f, 6.65252581e-02f, 1.32934958e-01f, -1.60280347e-01f, 7.93385506e-02f, -6.16279691e-02f, -8.21403190e-02f,
  8.80244747e-02f, 2.97170151e-02f, -1.24784606e-03f, -4.71381620e-02f, 6.38750270e-02f, -3.00198910e-03f, -2.56810077e-02f, -4.61332239e-02f, 2.21354538e-03f, -8.77592564e-02f,
  -1.40131891e-01f, -1.32576391e-01f, -9.45420638e-02f, 2.80259061e-03f, -4.04021190e-03f, 5.86612672e-02f, -5.72437719e-02f, -4.00353111e-02f, 8.50632563e-02f, -2.64267642e-02f,
  2.42151581e-02f, -9.43041444e-02f, -3.58176343e-02f, 1.01487190e-01f, 1.75038166e-02f, 4.76663560e-02f, 3.80515791e-02f, -1.06946945e-01f, -2.74509657e-02f, -8.42902735e-02f,
  -1.88919157e-02f, -3.10974475e-02f, 7.54199326e-02f, 4.01224531e-02f, 7.22227767e-02f, -6.23112768e-02f, -1.43998004e-02f, 2.58754939e-02f, 4.64212894e-02f, 4.00191918e-03f,
  3.27891670e-02f, -3.49378660e-02f, 4.86865826e-02f, 1.19795516e-01f, -5.91949141e-03f, -1.13977425e-01f, 7.65315890e-02f, 5.90934418e-03f, -6.55471534e-02f, -5.33110537e-02f,
  8.20374954e-03f, -3.63659929e-03f, 5.71567789e-02f, 3.32152657e-02f, 9.28150117e-02f, -4.35984917e-02f, 4.35221046e-02f, 3.01014278e-02f, 4.82650548e-02f, -6.77308664e-02f,
  -5.13951406e-02f, -1.14361430e-02f, -2.47710645e-02f, -4.22904603e-02f, -2.74963826e-02f, 4.76255305e-02f, -2.96101370e-03f, -3.89769115e-02f, 8.75201970e-02f, -8.47281218e-02f,
  -1.10986121e-01f, -1.77082866e-02f, 4.17465940e-02f, 2.42333338e-02f, 7.02635124e-02f, -6.33282736e-02f, 4.97073121e-02f, 3.81256975e-02f, 9.69259888e-02f, -1.96183808e-02f,
  -7.96989538e-03f, -1.26340076e-01f, 1.04593925e-01f, -8.42807889e-02f, 3.69673828e-03f, 8.05536658e-03f, -3.81252021e-02f, -1.21100686e-01f, 4.16738726e-02f, 5.11117838e-02f,
  2.47415230e-02f, -7.84555003e-02f, 1.20715208e-01f, -1.47721633e-01f, 4.84599546e-03f, -3.87749926e-04f, -6.57555759e-02f, -2.92863138e-02f, 4.36129645e-02f, -3.40106227e-02f,
  -7.19738528e-02f, -1.05043121e-01f, 3.47693712e-02f, 9.72404853e-02f, 1.99660622e-02f, 8.91382545e-02f, 8.76497030e-02f, 1.97363600e-01f, 1.47791225e-02f, 1.01590574e-01f,
  -1.17807865e-01f, -7.34177455e-02f, -2.66902726e-02f, -9.50889289e-02f, 6.87755197e-02f, -3.37772747e-03f, -1.34057617e-02f, -2.35761069e-02f, -7.41215125e-02f, -4.27561440e-03f,
  -7.35907704e-02f, 1.27117068e-01f, 1.33135105e-02f, 3.78744639e-02f, 7.72452354e-02f, -3.74007374e-02f, -7.83190429e-02f, 3.48172113e-02f, -1.44943029e-01f, -9.36692432e-02f,
  3.40363123e-02f, -7.47561008e-02f, -3.66512276e-02f, 7.62458220e-02f, -1.19812405e-02f, 1.00186870e-01f, -7.27531761e-02f, -1.49590254e-03f, 1.46843940e-02f, -4.93988581e-02f,
  9.45323780e-02f, 1.86128225e-02f, -1.34192733e-02f, -9.64727905e-03f, -1.62948087e-01f, 2.49128677e-02f, 2.74972878e-02f, 6.07459359e-02f, -8.83277133e-02f, 4.49629128e-02f,
  -1.22056184e-02f, -3.20310444e-02f, 1.06777124e-01f, 4.02384475e-02f, 2.56683454e-02f, 1.98730566e-02f, 3.10223717e-02f, 2.23796722e-02f, 5.64240143e-02f, -6.66712150e-02f,
  5.56451902e-02f, 3.66176814e-02f, 1.58888493e-02f, 6.43138587e-02f, -2.87231281e-02f, -5.29769585e-02f, 7.65748844e-02f, 6.03702739e-02f, 3.86209256e-04f, 9.27613303e-02f,
  -5.56998104e-02f, -1.05938509e-01f, 1.97965633e-02f, -9.59739089e-02f, -7.10577667e-02f, 3.34179989e-04f, 2.29015499e-02f, -3.21628228e-02f, -1.88052573e-03f, -9.94164795e-02f,
  4.16712873e-02f, 3.23831066e-02f, -4.79472354e-02f, 7.36307725e-02f, -5.45075610e-02f, 1.10070296e-02f, -7.86056593e-02f, -1.02336239e-02f, 5.97740524e-02f, -8.08612723e-03f,
  3.15081398e-03f, 6.29853010e-02f, -6.94918707e-02f, 1.27959490e-01f, 2.12049391e-02f, -2.30087154e-02f, -6.06072508e-02f, -2.26087384e-02f, 5.68801463e-02f, -4.45143767e-02f,
  -3.89238484e-02f, 4.46099676e-02f, 7.75725320e-02f, -4.34864312e-02f, -6.58945516e-02f, -3.58696729e-02f, 2.27949218e-04f, 1.20638264e-02f, 4.09820769e-03f, -3.03380098e-02f,
  4.00177874e-02f, -2.53968164e-02f, -2.26873020e-03f, 6.82434738e-02f, -3.64471450e-02f, 1.07160203e-01f, 2.78778169e-02f, 1.17549479e-01f, 6.43091723e-02f, 2.25366163e-03f,
  -3.34860682e-02f, 2.12078571e-01f, 3.58706415e-02f, 4.57587577e-02f, -7.54540414e-02f, -6.02009296e-02f, -7.78631642e-02f, 5.90846986e-02f, 1.06968395e-02f, 1.75351024e-01f,
  -1.19951395e-02f, 1.86791550e-02f, 4.01249640e-02f, 7.58946761e-02f, -6.75695688e-02f, -1.42196462e-01f, -3.32761072e-02f, -1.26590896e-02f, 7.08228871e-02f, -4.93181907e-02f,
  2.13166419e-02f, 6.68955501e-03f, -8.13179091e-02f, 1.23393230e-01f, -1.76097173e-02f, 1.07221425e-01f, -7.60716647e-02f, 1.51742771e-01f, 7.21165240e-02f, -5.89015409e-02f,
  -6.49920180e-02f, 1.19700037e-01f, -1.30230039e-01f, -6.04135320e-02f, 1.08416587e-01f, 2.52992474e-02f, -4.24930267e-02f, 8.28991458e-02f, 1.17418408e-01f, 6.78211972e-02f,
  3.27042118e-02f, 6.64030910e-02f, -1.16268463e-01f, -3.98091935e-02f, 8.24593846e-03f, -6.88438788e-02f, -7.68624172e-02f, 6.13017529e-02f, -1.26047134e-01f, -8.78014416e-02f,
  -2.41294168e-02f, -3.33592966e-02f, 4.36316151e-03f, 1.12849757e-01f, 7.86003172e-02f, -2.83692013e-02f, 7.41214603e-02f, -1.06840566e-01f, 1.47301536e-02f, 9.19006020e-02f,
  -8.45845509e-03f, 5.69453873e-02f, -4.24259491e-02f, 7.69589767e-02f, -4.37118150e-02f, -8.03432614e-02f, -6.37906045e-02f, -6.96202964e-02f, -8.33743289e-02f, 4.99350391e-02f,
  4.86899130e-02f, -5.74058332e-02f, 4.89315502e-02f, 5.45341186e-02f, 2.12071128e-02f, 7.55139515e-02f, -8.63304213e-02f, 8.01296830e-02f, -7.41204694e-02f, -7.16818795e-02f,
  4.29626554e-02f, 4.66137491e-02f, 7.22527429e-02f, 6.63709491e-02f, 1.02657735e-01f, -9.45697874e-02f, 1.84554532e-02f, -2.99985707e-02f, -2.74766758e-02f, 7.87930340e-02f,
  -1.16614155e-01f, -2.84677520e-02f, -7.75008127e-02f, 6.33167848e-02f, -6.72099739e-02f, 1.00966774e-01f, 7.95886889e-02f, 1.44612705e-02f, -4.09584828e-02f, 1.88517980e-02f,
  -7.89557621e-02f, -3.59607153e-02f, 7.76309147e-02f, -7.51365125e-02f, -7.74423778e-02f, 2.08077524e-02f, -4.92700115e-02f, -3.35447453e-02f, -2.54292064e-03f, -1.20364159e-01f,
  1.88903380e-02f, 2.05139536e-02f, -1.60259783e-01f, 8.87260661e-02f, -1.49486393e-01f, 1.57161027e-01f, 9.85408109e-03f, -5.46673425e-02f, 2.94875099e-05f, 8.16640854e-02f,
  8.22128952e-02f, -1.21985748e-02f, 9.97954756e-02f, 2.29436085e-02f, -8.86668414e-02f, -6.35135546e-02f, 5.88923087e-03f, 8.30943361e-02f, -9.56178159e-02f, 1.27431467e-01f,
  -2.02448517e-01f, 1.52935416e-01f, 1.35650337e-02f, 8.30149336e-04f, -5.10639101e-02f, -5.41582033e-02f, 5.16416617e-02f, -3.57610770e-02f, -7.92960078e-02f, -1.06856262e-03f,
  -1.00929238e-01f, -1.17235191e-01f, 1.04045019e-01f, -2.22179323e-01f, -1.49491578e-01f, 1.38622731e-01f, -4.85536158e-02f, -9.95483771e-02f, 1.45253479e-01f, 7.17705041e-02f,
  5.78095540e-02f, 2.18876321e-02f, 1.27366737e-01f, 7.30237216e-02f, 4.62600850e-02f, -2.90517136e-02f, 4.95231012e-03f, -3.72915566e-02f, 2.36005485e-02f, 2.06434622e-01f,
  -1.67997837e-01f, -7.14554160e-04f, 7.20605031e-02f, 2.36145910e-02f, 3.55619825e-02f, 9.23397765e-02f, 4.22328636e-02f, 2.63833385e-02f, 1.15207024e-01f, -5.82491010e-02f,
  3.04943509e-02f, 4.02037203e-02f, 7.59271625e-03f, -1.68305218e-01f, -1.12183981e-01f, -5.05244695e-02f, -3.86018679e-02f, 8.68897364e-02f, -1.27607241e-01f, 8.39421675e-02f,
  9.55886170e-02f, 8.07294324e-02f, -1.00625634e-01f, -8.58136863e-02f, -8.72102603e-02f, -1.44134155e-02f, -9.14763287e-02f, -4.15136665e-02f, 8.57659429e-02f, -3.00081261e-02f,
  -1.02936797e-01f, -7.68431127e-02f, 8.50363374e-02f, 6.67929128e-02f, 1.20300129e-02f, -1.34759061e-02f, 3.26860547e-02f, -5.19183502e-02f, -5.65809458e-02f, -2.73927916e-02f,
  -6.00155592e-02f, 7.27864951e-02f, -2.68152021e-02f, -1.13377862e-01f, -7.48498365e-03f, -7.84572288e-02f, -4.37936038e-02f, 8.24199338e-03f, -2.74875276e-02f, -5.05161807e-02f,
  -4.88685183e-02f, 3.45185176e-02f, -1.26886293e-01f, -8.95213038e-02f, -1.03331879e-01f, -4.28220369e-02f, 7.25533068e-02f, -2.50773933e-02f, -1.16149426e-01f, -3.23900729e-02f,
  6.55619577e-02f, -1.13573082e-01f, -7.38061294e-02f, -7.77174607e-02f, 4.67418768e-02f, 2.87252162e-02f, 3.66849117e-02f, -9.79695395e-02f, 6.81029335e-02f, -1.29371047e-01f,
  8.17107260e-02f, -6.52422309e-02f, -7.65424967e-02f, -3.81717435e-03f, -7.75465891e-02f, 9.38208997e-02f, 4.64519858e-03f, -1.01183439e-02f, -1.09301716e-01f, -8.42848734e-04f,
  -7.76525214e-02f, -1.75034292e-02f, -5.75538911e-02f, 1.51373446e-01f, -6.56815693e-02f, -1.41770178e-02f, 5.95532358e-03f, -6.88958839e-02f, 1.47758946e-01f, 3.42276283e-02f,
  -2.43341103e-02f, -4.07613330e-02f, -7.86385965e-03f, -1.54520169e-01f, 2.01768875e-02f, 1.04322262e-01f, 6.95914105e-02f, -1.16770215e-01f, -2.53308173e-02f, 6.25323653e-02f,
  -6.05794415e-02f, -3.73468809e-02f, 5.64888213e-03f, -1.21670410e-01f, -1.90712288e-02f, -1.95282269e-02f, 4.24339548e-02f, -1.27960622e-01f, -8.78549963e-02f, -2.14054972e-01f,
  6.98639825e-02f, -1.04039937e-01f, 6.21845499e-02f, 2.36680042e-02f, -7.60931447e-02f, 9.88196060e-02f, -2.84139346e-02f, -4.25480828e-02f, -6.82580173e-02f, -6.52732281e-03f,
  8.48260969e-02f, -9.99782979e-02f, -1.16383255e-01f, -6.92576915e-02f, -1.25376135e-01f, 9.23433453e-02f, -2.70844577e-03f, 1.67760123e-02f, 1.02581354e-02f, 2.81056459e-03f,
  -8.80542323e-02f, 7.37277493e-02f, 2.81181245e-04f, -2.55982857e-02f, -2.40306985e-02f, -3.57650146e-02f, 5.85757941e-02f, -3.43041308e-02f, 1.48440721e-02f, 1.16803050e-01f,
  2.13885084e-02f, -5.20342812e-02f, -9.99108106e-02f, -4.65154089e-02f, 7.30233416e-02f, -1.88467111e-02f, 2.07689926e-02f, -7.09554181e-02f, 6.39219908e-03f, 6.25301301e-02f,
  4.26914124e-03f, 6.23019747e-02f, -1.01400502e-02f, 3.05124130e-02f, 6.03841580e-02f, 8.19164068e-02f, -5.53697795e-02f, -2.57555135e-02f, 2.54295971e-02f, 4.71668094e-02f,
  7.14364648e-02f, -1.05026886e-01f, -9.72830877e-02f, 3.03040203e-02f, -7.63763562e-02f, -5.04266955e-02f, 5.21335751e-02f, -7.69605786e-02f, 1.26595190e-02f, 3.97347212e-02f,
  -3.87652032e-02f, 4.56906930e-02f, -4.67685983e-03f, 3.06583978e-02f, 5.78924529e-02f, -3.48914750e-02f, 8.41617584e-02f, 1.64877961e-03f, -7.06373155e-02f, 5.95060661e-02f,
  -3.18916291e-02f, 4.56775576e-02f, 1.01546064e-01f, -2.32515968e-02f, -5.84360771e-02f, -4.53175977e-02f, -1.86147075e-02f, 6.25609607e-02f, 7.23093078e-02f, -1.27608357e-02f,
  -1.04332164e-01f, 7.56753907e-02f, -4.22598468e-03f, 1.14431418e-01f, -7.23646060e-02f, 4.24137153e-02f, -1.70093849e-02f, 1.77398138e-02f, 6.05032705e-02f, -1.06618203e-01f,
  -3.14991027e-02f, 3.45374569e-02f, -1.02008410e-01f, 5.84107563e-02f, 2.37213578e-02f, -4.53448072e-02f, 3.77157629e-02f, 5.17978240e-03f, -1.02001756e-01f, -7.01776072e-02f,
  3.80030200e-02f, 1.04826659e-01f, 1.88201144e-01f, -1.03532420e-02f, 6.90696612e-02f, -6.34756908e-02f, -1.15748517e-01f, 1.15005799e-01f, -2.76809242e-02f, -3.40622067e-02f,
  -1.42369986e-01f, 2.75563262e-02f, 8.04776326e-02f, -4.83563654e-02f, 3.02663539e-03f, 1.55108839e-01f, -8.18496570e-03f, 6.54040426e-02f, -9.98529196e-02f, -1.97164580e-01f,
  -2.90544163e-02f, 1.70915611e-02f, 9.56876352e-02f, -4.86555025e-02f, -1.70344919e-01f, -2.08593048e-02f, -1.23892754e-01f, -1.56196520e-01f, 1.54362082e-01f, -1.95143953e-01f,
  -1.56582341e-01f, 3.25283222e-02f, -6.01922814e-03f, 5.09465151e-02f, 1.78116471e-01f, -3.83777432e-02f, -1.50896553e-02f, -7.99875334e-02f, 9.32237357e-02f, 6.84352890e-02f,
  -1.44067436e-01f, 5.09006232e-02f, -7.10394830e-02f, 4.97245640e-02f, 2.03611165e-01f, 1.68602005e-01f, -2.59493381e-01f, -1.52767509e-01f, -3.86726484e-02f, -5.85174188e-02f,
  1.53863896e-02f, 4.00472619e-02f, -6.96014538e-02f, 3.95317897e-02f, 5.83484992e-02f, 1.36429161e-01f, -7.09717348e-02f, -5.13405800e-02f, 5.77853620e-02f, -6.49920180e-02f,
  -1.53729916e-01f, 5.36767542e-02f, -1.41546354e-01f, 5.79407476e-02f, -4.52618487e-02f, -5.53909540e-02f, 7.75991306e-02f, -1.08099915e-02f, -2.52053104e-02f, 3.89356874e-02f,
  4.25933339e-02f, -1.27489775e-01f, -2.31920462e-02f, 4.34698127e-02f, 8.19381326e-03f, 1.14011824e-01f, 1.47874989e-02f, 9.24148411e-02f, -2.83518503e-03f, -5.01372516e-02f,
  -2.74586445e-03f, -2.13712789e-02f, -5.06572761e-02f, 9.23364088e-02f, -3.35026942e-02f, 6.26025945e-02f, 1.30251020e-01f, 8.59386250e-02f, -7.46368095e-02f, -7.23519474e-02f,
  7.59833306e-02f, 1.18031874e-01f, 3.34032290e-02f, -4.81349416e-02f, 4.99681644e-02f, 9.85140502e-02f, -3.06536332e-02f, 4.83036265e-02f, -6.07326664e-02f, -1.93972606e-02f,
  -5.40001467e-02f, -8.23994055e-02f, 6.43560961e-02f, 9.02163088e-02f, 2.89644562e-02f, -4.15583588e-02f, 4.85090464e-02f, 1.00766532e-01f, 6.16595782e-02f, 1.26291469e-01f,
  -5.66789880e-03f, 5.47324903e-02f, -5.83683886e-02f, -3.46160792e-02f, -1.54308733e-02f, 3.84224169e-02f, -4.04678136e-02f, 1.65426601e-02f, 5.94988205e-02f, 1.57100670e-02f,
  2.01078802e-02f, 1.08340301e-01f, -2.90644374e-02f, -1.70874465e-02f, 6.04973845e-02f, -1.02281474e-01f, -5.73066548e-02f, -1.28995389e-01f, 2.34216787e-02f, -3.55742723e-02f,
  -2.22427435e-02f, 7.23697171e-02f, -3.50310430e-02f, -1.71447113e-01f, 1.48795806e-02f, -3.20297517e-02f, 8.14859290e-03f, 5.46662789e-03f, -2.20295694e-02f, -1.33114085e-01f,
  1.47725180e-01f, 6.85120523e-02f, -2.08987277e-02f, 7.33271539e-02f, 9.48955268e-02f, 2.87547931e-02f, -1.63283259e-01f, 9.74805206e-02f, -3.19942050e-02f, 1.09047502e-01f,
  1.92390420e-02f, -9.54522938e-02f, 4.17610593e-02f, -4.17315848e-02f, 3.13751064e-02f, -1.01844944e-01f, 9.11580846e-02f, 4.64139599e-03f, -1.81097593e-02f, -1.70242116e-01f,
  -6.24321587e-02f, -1.10152215e-01f, -6.96306303e-02f, -7.95854721e-03f, 4.39601913e-02f, -1.42328143e-01f, 8.60201940e-02f, -6.35185465e-02f, -9.41188633e-03f, -9.62779745e-02f,
  -3.80406007e-02f, -1.46853477e-02f, 1.00292005e-01f, -1.14664525e-01f, -5.40274195e-02f, -8.23363885e-02f, -7.42076859e-02f, 4.08766344e-02f, -1.43559342e-02f, -8.83407071e-02f,
  -1.11198291e-01f, 8.23037326e-02f, -7.47417435e-02f, -8.50711316e-02f, 1.97523925e-02f, -5.70012890e-02f, -1.43115491e-01f, 6.98881298e-02f, -1.31104186e-01f, 2.43958626e-02f,
  3.47900130e-02f, 3.93849239e-02f, -7.87747651e-02f, -2.18853317e-02f, 8.84051900e-03f, -1.01491190e-01f, -6.83256537e-02f, -2.49741301e-02f, 4.81116064e-02f, -4.82844450e-02f,
  -6.79801330e-02f, -8.03201571e-02f, 1.11265697e-01f, -9.07333975e-04f, 2.86244005e-02f, 4.14368063e-02f, 1.51976412e-02f, -1.54158017e-02f, 2.27686744e-02f, 3.06865629e-02f,
  3.44729680e-03f, -3.83194573e-02f, -3.26902382e-02f, 6.22951649e-02f, 8.84785131e-02f, -2.16586068e-02f, -6.65255403e-03f, 1.76916120e-03f, 3.77503708e-02f, 3.60448770e-02f,
  3.72077450e-02f, -8.48186910e-02f, 5.25584333e-02f, 6.39168872e-03f, 2.70756111e-02f, 5.24580665e-03f, 3.38564366e-02f, 3.74236256e-02f, -3.91186327e-02f, -1.01173766e-01f,
  -1.10879607e-01f, -1.07331790e-01f, -2.43309885e-02f, -3.21208797e-02f, -4.77444716e-02f, 1.14650153e-01f, -6.34647608e-02f, -4.23618481e-02f, 1.37992464e-02f, 1.11863129e-01f,
  -2.73349155e-02f, -1.44041181e-02f, -6.70946240e-02f, 4.17395355e-03f, 1.25134038e-03f, -8.17557275e-02f, 8.57475474e-02f, 7.99269974e-03f, 2.12371331e-02f, 3.88452187e-02f,
  -6.10690787e-02f, 5.56324571e-02f, -8.21509602e-05f, -7.75912330e-02f, -1.75993770e-01f, -1.63650066e-01f, -9.05102119e-02f, 1.02144316e-01f, 1.51104510e-01f, -8.38170424e-02f,
  5.58824325e-03f, -4.70669232e-02f, -6.08055294e-02f, 2.83772359e-03f, 1.49531653e-02f, 4.23598439e-02f, -6.51142225e-02f, 9.85609274e-03f, -2.09058207e-02f, -9.59310532e-02f,
  1.84863731e-02f, 1.61096364e-01f, -1.92893017e-02f, -1.29867624e-02f, -1.05751529e-01f, -9.46009066e-03f, -9.98762995e-03f, 1.39105707e-01f, 3.34653445e-03f, 1.49002254e-01f,
  -3.79594527e-02f, 3.06335650e-02f, 9.62841585e-02f, -7.22926017e-03f, 2.26035668e-03f, -1.84142321e-01f, -9.05112624e-02f, 1.11240536e-01f, 7.06153512e-02f, 1.31530464e-01f,
  1.90081060e-01f, -5.27804457e-02f, 3.48377004e-02f, 1.28041297e-01f, -1.23366296e-01f, 1.39360949e-01f, -2.61017010e-02f, -7.74416327e-03f, 1.06805034e-01f, -9.27938670e-02f,
  4.77643982e-02f, 1.44799143e-01f, -1.60921574e-01f, 1.85800083e-02f, -6.24998473e-03f, 4.05221879e-02f, -2.84840986e-02f, -6.17704242e-02f, 3.36828716e-02f, 7.44191036e-02f,
  7.02439994e-02f, -1.16892364e-02f, 7.57112876e-02f, -7.82308131e-02f, -4.92524989e-02f, -7.55954534e-02f, -1.00430347e-01f, 1.38084488e-02f, -8.31885636e-02f, -7.82722682e-02f,
  -1.12079307e-01f, -2.20521316e-02f, 9.67944488e-02f, 1.41486257e-01f, 1.00763768e-01f, 4.08501960e-02f, 4.45108898e-02f, -6.73572645e-02f, -3.56973754e-03f, 4.02455730e-03f,
  -6.42674491e-02f, 7.63449743e-02f, 2.99563222e-02f, -6.17713016e-03f, -7.99235925e-02f, 1.73118699e-03f, -4.81137224e-02f, -2.61171758e-02f, -5.16056130e-03f, 9.26244333e-02f,
  -5.05450070e-02f, 1.51338726e-02f, 1.87955350e-02f, -7.79538006e-02f, 4.28124107e-02f, -3.50516029e-02f, -1.56342553e-03f, 3.26830894e-02f, 4.61170916e-03f, -3.70141342e-02f,
  -5.47217019e-02f, 6.01021238e-02f, 4.35819924e-02f, 2.82568304e-04f, -4.65314686e-02f, -1.47373468e-01f, 1.63796917e-02f, -3.78597453e-02f, 7.53469840e-02f, -5.96140437e-02f,
  -9.78441164e-02f, 2.72619873e-02f, -3.36757414e-02f, 4.52687591e-03f, 7.16507658e-02f, 4.28342633e-02f, 7.53351450e-02f, -8.57773200e-02f, -3.78121771e-02f, 2.22785082e-02f,
  1.27000199e-03f, -1.05924122e-02f, -4.85191159e-02f, 6.00427724e-02f, -7.03944117e-02f, -5.65498285e-02f, 1.08077079e-01f, -2.90252771e-02f, 2.32175235e-02f, 5.33348508e-02f,
  -1.47424445e-01f, -4.32222709e-02f, -3.43767069e-02f, 9.66227800e-02f, 1.47998154e-01f, -1.06805772e-01f, -4.08288725e-02f, 5.20038372e-03f, 1.75559416e-03f, 5.18626198e-02f,
  3.20493989e-02f, 1.36140808e-02f, 1.57709736e-02f, -4.88371365e-02f, -8.71701092e-02f, 4.90864478e-02f, -1.07377678e-01f, 1.12447567e-01f, 1.40480816e-01f, 5.59342429e-02f,
  -2.22094543e-02f, 1.13696218e-01f, 5.06394580e-02f, -1.09152637e-01f, -9.99126956e-02f, -1.18824184e-01f, 3.10221175e-03f, -9.50314552e-02f, -3.85810845e-02f, -1.84153229e-01f,
  -1.50031611e-01f, -1.42757937e-01f, -1.07553452e-01f, -6.56733438e-02f, 1.66997224e-01f, -1.72618758e-02f, -2.55067106e-02f, -1.25763968e-01f, -9.82200354e-02f, -1.86326262e-02f,
  -4.22590738e-03f, -2.35956647e-02f, 1.25951588e-01f, -9.97239873e-02f, -4.10046577e-02f, 1.07669860e-01f, -1.18707083e-01f, 1.35251820e-01f, 1.59531146e-01f, 2.28998195e-02f,
  -1.39648030e-02f, -1.28575182e-03f, -4.47041326e-04f, 4.03629206e-02f, 1.68819845e-01f, 5.29647283e-02f, -8.60641375e-02f, -2.53870767e-02f, 3.27909663e-02f, 1.16039507e-01f,
  -6.77027181e-02f, 2.85715945e-02f, 7.81818181e-02f, 4.23646420e-02f, -2.91704778e-02f, -3.52556147e-02f, 2.38716602e-02f, 8.17449018e-02f, 4.03860323e-02f, 7.75480792e-02f,
  -9.91714597e-02f, -1.17383320e-02f, 3.13106924e-02f, 1.59080066e-02f, -7.86989778e-02f, 1.55896675e-02f, -7.95666873e-02f, -3.84876058e-02f, -3.98361385e-02f, -1.58553980e-02f,
  -6.04539476e-02f, -5.89036681e-02f, -7.27462173e-02f, -4.82251346e-02f, 3.86275798e-02f, 2.40767859e-02f, -7.73803145e-02f, 5.50125651e-02f, -2.86271889e-03f, -3.42410244e-02f,
  3.37087363e-02f, -3.93217281e-02f, -2.07203962e-02f, -6.67865723e-02f, 7.78594660e-03f, 5.61565906e-02f, -5.42924777e-02f, 7.67734200e-02f, -9.83174741e-02f, 1.03511512e-01f,
  5.02251030e-04f, -9.59917903e-03f, -1.07161209e-01f, 2.24599009e-03f, -8.75159651e-02f, 1.80460582e-03f, 3.92644778e-02f, -4.25968814e-04f, -1.24305394e-02f, 2.25259978e-02f,
  9.32922140e-02f, 2.72492021e-02f, 8.19471478e-02f, -8.41080546e-02f, 8.22187774e-03f, -1.02611840e-01f, 2.94120368e-02f, -3.60834934e-02f, -2.65145227e-02f, -1.48389205e-01f,
  1.41321979e-02f, -1.86311640e-02f, -7.86079913e-02f, -4.00328189e-02f, 2.01986078e-02f, 1.51956407e-02f, -5.69019094e-02f, 4.75052670e-02f, 1.32767744e-02f, 2.10989770e-02f,
  1.79300308e-01f, 9.29111615e-02f, -5.02608754e-02f, 6.89050481e-02f, -9.60581154e-02f, 1.26748800e-01f, -2.89015528e-02f, 2.24174988e-02f, 1.64225414e-01f, 1.98694710e-02f,
  3.58083360e-02f, -6.85898587e-02f, 6.29032915e-03f, -5.96350804e-02f, 1.01570129e-01f, 4.16085199e-02f, 7.34152645e-02f, -1.92487150e-01f, -2.22986080e-02f, -6.68515936e-02f,
  9.79019776e-02f, 8.23877752e-02f, 1.16120130e-01f, -1.51730657e-01f, 1.53995510e-02f, -2.10951120e-01f, 1.89940721e-01f, 5.98729067e-02f, 6.27021343e-02f, -3.34731303e-02f,
  -1.67655144e-02f, 1.05024189e-01f, 4.97014914e-03f, -1.45584136e-01f, -5.67449033e-02f, 1.29081443e-01f, -1.39793754e-01f, -1.40353352e-01f, -4.99935187e-02f, -9.27690193e-02f,
  1.70787141e-01f, 8.33807588e-02f, -1.06380902e-01f, -1.17061883e-01f, -1.47776484e-01f, 1.19856983e-01f, 2.49711685e-02f, -1.01726212e-01f, 9.35285836e-02f, -2.87438687e-02f,
  -2.69242786e-02f, -2.27457266e-02f, -1.80506632e-02f, 9.01231989e-02f, 3.48190181e-02f, -2.11149603e-02f, 4.25481237e-02f, -7.13224113e-02f, 2.79031005e-02f, -2.02582357e-03f,
  -7.40498677e-02f, 1.12713603e-02f, -3.55628668e-03f, -3.16126738e-03f, 1.20598532e-01f, 6.57845661e-02f, -3.84597592e-02f, 6.82125390e-02f, -1.51608914e-01f, -7.66135454e-02f,
  -1.10922210e-01f, 5.92620894e-02f, -5.72851971e-02f, -1.29509997e-02f, 9.94222239e-02f, -1.48804467e-02f, 8.79753381e-03f, 5.74517027e-02f, 5.63234873e-02f, 2.53639016e-02f,
  2.77197901e-02f, -7.43119791e-02f, 1.98706780e-02f, -2.05335934e-02f, 5.29942475e-02f, -9.58566517e-02f, 7.70291165e-02f, -1.45850014e-02f, -4.81681600e-02f, 9.03936923e-02f,
  -2.32220385e-02f, 1.91652421e-02f, 5.06021343e-02f, -2.36277916e-02f, 8.44437536e-03f, -3.98852043e-02f, -7.96464607e-02f, -4.17635255e-02f, 7.66873211e-02f, 7.51446858e-02f,
  -5.05425967e-02f, 4.70558926e-02f, -7.53929988e-02f, 2.67280489e-02f, 1.27818137e-01f, -4.54542972e-03f, 9.50552747e-02f, -2.75537204e-02f, 1.43943646e-03f, -7.44720846e-02f,
  -7.98623115e-02f, -6.57249764e-02f, 6.73792139e-02f, -2.35534320e-03f, 2.52689403e-02f, 9.81392153e-03f, -6.20288514e-02f, -7.90973306e-02f, 3.37095112e-02f, -4.04226743e-02f,
  1.84464306e-02f, -5.35138370e-03f, 2.65059378e-02f, -1.10059731e-01f, -1.50029883e-02f, -6.16250224e-02f, 7.80115947e-02f, -3.95013914e-02f, 5.32298312e-02f, 1.62928790e-01f,
  1.78838950e-02f, -1.66691486e-02f, -1.41280130e-01f, -1.39293626e-01f, -1.13584725e-02f, 1.95194911e-02f, 2.51148995e-02f, 3.87114175e-02f, -9.32388660e-03f, 3.23287733e-02f,
  1.16847895e-01f, 1.02901094e-01f, 5.71347401e-02f, 1.25881312e-02f, 3.45421210e-02f, -2.72168033e-03f, -4.73011173e-02f, -2.72989273e-02f, 1.11996569e-01f, 2.37856321e-02f,
  -1.07613929e-01f, -2.00557220e-03f, -1.96263239e-01f, 3.18016410e-02f, 1.59209013e-01f, 9.49964374e-02f, -8.50717723e-02f, 2.29606163e-02f, -1.01043262e-01f, 2.12213933e-01f,
  1.00348838e-01f, 3.50096403e-03f, -1.14110053e-01f, -8.58655646e-02f, -1.23155594e-01f, 7.79658109e-02f, -7.08616525e-02f, 2.59897076e-02f, 1.01579912e-01f, -7.19860345e-02f,
  4.70809489e-02f, -3.88162993e-02f, -3.07533257e-02f, 8.71578902e-02f, -1.19943283e-01f, 1.24382891e-03f, 2.45754048e-02f, 8.99025872e-02f, -2.24338956e-02f, -7.06204250e-02f,
  8.09609592e-02f, 1.35189667e-01f, 7.95674920e-02f, -7.04241768e-02f, 1.20931705e-02f, -1.13665059e-01f, -5.64290211e-02f, 3.66031043e-02f, 4.43001688e-02f, 1.76645406e-02f,
  3.31302546e-02f, -8.80368799e-02f, 9.35457125e-02f, 2.19625654e-03f, -3.27797752e-04f, 3.20801251e-02f, -6.21870868e-02f, -3.12708579e-02f, -4.91702035e-02f, -7.97610730e-02f,
  -4.55580615e-02f, -8.15408677e-03f, 8.57871845e-02f, 1.07061220e-02f, 2.27426980e-02f, 1.43230194e-02f, 8.60239565e-02f, 8.70474130e-02f, -1.83710679e-02f, -9.92094260e-03f,
  -3.84204499e-02f, 1.08321570e-01f, -1.79270040e-02f, 5.34621887e-02f, 8.62829611e-02f, -3.28917522e-03f, -5.88836968e-02f, -1.01346426e-01f, 3.98088768e-02f, 1.04183681e-01f,
  8.97992626e-02f, 6.83932900e-02f, -4.65888111e-03f, -1.12419054e-01f, 9.69822109e-02f, -1.31554585e-02f, 3.10921930e-02f, -6.21833578e-02f, 7.07699507e-02f, 7.55665675e-02f,
  -3.52796577e-02f, -4.09356542e-02f, -5.20583391e-02f, 5.42865843e-02f, -4.61513884e-02f, 1.43017070e-02f, 6.53800741e-02f, 5.07697463e-02f, 4.75538000e-02f, 9.05530304e-02f,
  -5.24225682e-02f, 1.35958016e-01f, 2.26517897e-02f, -4.04656567e-02f, 1.04968786e-01f, 8.23062807e-02f, 5.02003282e-02f, 4.85576764e-02f, 5.92453703e-02f, 1.17724091e-01f,
  9.57353339e-02f, -1.16600953e-01f, -5.58619462e-02f, -2.33364142e-02f, -1.98337380e-02f, -1.15438364e-03f, -1.81759015e-01f, -2.39269324e-02f, -2.29873806e-01f, 1.19142048e-01f,
  8.11096355e-02f, 4.85357158e-02f, 3.24469097e-02f, 4.84311208e-02f, -5.57302795e-02f, -1.03186049e-01f, 2.54143425e-03f, 4.35602628e-02f, -1.29496515e-01f, -7.58231655e-02f,
  -7.42573589e-02f, -1.10567883e-01f, -1.63021594e-01f, 1.25709251e-01f, -1.23380281e-01f, 2.60267798e-02f, -1.52426781e-02f, -8.48187953e-02f, 8.93438458e-02f, 1.54111341e-01f,
  1.24552980e-01f, -3.90689671e-02f, -9.22797769e-02f, -5.23837432e-02f, -3.09447683e-02f, 1.26270160e-01f, 1.40687197e-01f, -3.04129243e-01f, -1.82852104e-01f, 1.75645530e-01f,
  2.08858754e-02f, 9.30933282e-02f, 6.87087774e-02f, 2.09299754e-03f, 3.87297980e-02f, 1.52239650e-01f, -1.63468253e-02f, 2.14449704e-01f, 1.06367059e-01f, 9.95960087e-02f,
  8.28745365e-02f, -6.66223932e-03f, -1.05018325e-01f, 1.37523979e-01f, -1.11170635e-01f, -7.95842335e-02f, 3.96737196e-02f, -9.40970182e-02f, 1.39894977e-01f, 9.48871076e-02f,
  1.67605430e-01f, 1.08834960e-01f, 3.00269108e-02f, -1.32297929e-02f, 5.23846187e-02f, -9.50762704e-02f, 8.63734335e-02f, -1.82160586e-01f, -1.18340537e-01f, 4.02880274e-02f,
  2.29619164e-02f, 5.30631430e-02f, 3.76327559e-02f, 9.20644477e-02f, 9.20972377e-02f, 7.61508346e-02f, -1.69925205e-02f, -2.33707726e-02f, -1.14152513e-01f, -8.67261663e-02f,
  4.96050389e-03f, 1.02165090e-02f, -4.88884002e-02f, -4.81032953e-03f, 5.07686995e-02f, 9.73582864e-02f, 2.83584036e-02f, 1.24209910e-03f, -4.92668115e-02f, -2.62691844e-02f,
  6.34864867e-02f, 8.76137242e-02f, -5.61847687e-02f, -6.22549243e-02f, -3.47976163e-02f, -2.76786722e-02f, 4.92745861e-02f, 2.72970572e-02f, -2.87600439e-02f, 9.03031379e-02f,
  8.08401182e-02f, -6.44913763e-02f, -5.10710329e-02f, -3.21709923e-02f, 2.59518754e-02f, 2.92250626e-02f, 1.19468616e-02f, -6.21502437e-02f, -3.03682890e-02f, 1.61012374e-02f,
  1.05447359e-01f, 7.56377205e-02f, -8.07008669e-02f, -6.47870079e-02f, 6.53704703e-02f, 4.74831313e-02f, -8.70769545e-02f, 1.18615940e-01f, 4.48001828e-03f, 2.33223662e-02f,
  6.85550347e-02f, 1.67264976e-02f, -4.12813202e-03f, 3.16700526e-02f, 6.54049665e-02f, 7.47860074e-02f, -6.80356324e-02f, 4.24912795e-02f, 1.68710090e-02f, 9.58794653e-02f,
  -7.15111196e-02f, 3.08681838e-03f, -5.42723089e-02f, -2.34154277e-02f, -8.69629756e-02f, 4.50126790e-02f, 2.11039111e-02f, 1.85757801e-01f, 7.40628690e-02f, -1.10920504e-01f,
  9.59362164e-02f, -9.15313233e-03f, 7.79996589e-02f, -1.29309863e-01f, -1.06330082e-01f, 3.60579081e-02f, -2.03200400e-01f, 4.75920662e-02f, 7.81059712e-02f, 5.66091910e-02f,
  -4.31606844e-02f, 1.91243485e-01f, -2.03296617e-02f, 7.32498020e-02f, 8.28869119e-02f, -7.17989821e-03f, -6.43466180e-03f, 5.11644036e-02f, 3.27371657e-02f, 2.75290664e-02f,
  1.85912773e-02f, -8.50107223e-02f, -2.22345311e-02f, -1.67490482e-01f, 1.20512340e-02f, -2.42195874e-01f, -5.26470058e-02f, -3.34821641e-02f, 7.12796524e-02f, 1.07963815e-01f,
  1.19413227e-01f, 7.66912550e-02f, -1.00345060e-01f, 6.57152310e-02f, -6.35407567e-02f, 1.23892620e-01f, -4.89190742e-02f, 1.03922792e-01f, -3.88448127e-02f, 1.15570799e-01f,
  1.87969841e-02f, 1.91228434e-01f, -2.67196149e-01f, -3.48220132e-02f, -6.27514964e-04f, 2.41775699e-02f, 8.53861570e-02f, 6.56638294e-02f, 6.47246614e-02f, 2.77941069e-03f,
  -8.69869441e-03f, 1.33211344e-01f, 6.07707128e-02f, -1.36734471e-01f, -9.36127640e-03f, -5.53980805e-02f, -6.17847405e-02f, 6.12882376e-02f, -1.03728123e-01f, 5.88497147e-02f,
  -7.89631829e-02f, -2.80400030e-02f, 9.89137813e-02f, 2.69859955e-02f, -1.80103146e-02f, -2.47744918e-02f, 1.11015327e-03f, 4.50233892e-02f, -5.27129732e-02f, -7.40617001e-03f,
  5.50727509e-02f, -6.84664468e-04f, -5.52069657e-02f, 4.84213494e-02f, -2.77241506e-02f, 3.03601846e-02f, 4.25500125e-02f, -3.91883682e-03f, -3.43079306e-02f, -5.95542453e-02f,
  -4.25591990e-02f, -7.73087814e-02f, -3.57340351e-02f, 3.41556408e-02f, 4.10740972e-02f, -1.20442562e-01f, -6.26137033e-02f, -3.42952576e-03f, -4.18209359e-02f, 6.81578740e-02f,
  -5.06622978e-02f, 4.39023487e-02f, 2.83448887e-03f, 7.05318674e-02f, 2.30236165e-02f, -9.22062546e-02f, -8.57244581e-02f, 1.65834557e-02f, -4.70950454e-02f, -1.64165292e-02f,
  -9.82496440e-02f, -5.27242124e-02f, 5.06061800e-02f, -6.40581623e-02f, 1.19168185e-01f, 8.60507935e-02f, 3.89804505e-02f, 2.30738167e-02f, -6.61792979e-02f, -2.08627572e-03f,
  -2.94997748e-02f, -2.29811831e-03f, -3.19837891e-02f, 1.67607423e-03f, 5.72133884e-02f, -1.53756943e-02f, 4.51372284e-03f, 7.86587745e-02f, 1.08045578e-01f, 8.99368674e-02f,
  -7.29859397e-02f, -4.74127531e-02f, 6.08960241e-02f, 1.63869292e-01f, 1.26494452e-01f, -1.63794812e-02f, -6.31790832e-02f, 9.00776833e-02f, 2.18091421e-02f, -3.39999162e-02f,
  -1.61379278e-02f, 1.05109308e-02f, -7.38965794e-02f, -1.92720164e-02f, -8.21230039e-02f, -1.13236308e-01f, 5.30483909e-02f, 1.04750469e-01f, 1.77207425e-01f, -7.81724378e-02f,
  1.84314400e-02f, -2.99705379e-03f, 1.20678619e-01f, -6.37513474e-02f, 6.54477626e-02f, -2.44477734e-01f, 4.08869386e-02f, -1.56312078e-01f, 8.92790630e-02f, -6.51058406e-02f,
  4.18910682e-02f, -1.98325515e-01f, -7.40227699e-02f, 7.35049918e-02f, 8.86863247e-02f, -1.02930836e-01f, -1.06704175e-01f, -7.00902566e-02f, -1.88823298e-01f, -1.41863659e-01f,
  -1.08162478e-01f, -6.26161173e-02f, -3.38433832e-02f, -7.63090998e-02f, -9.84452143e-02f, -1.17060207e-01f, -6.80838525e-02f, 5.34020886e-02f, 8.57281536e-02f, 1.16511015e-03f,
  -1.43262118e-01f, -9.24060494e-02f, 3.09459958e-02f, -2.30994243e-02f, 1.68222606e-01f, -6.41327575e-02f, -1.05644859e-01f, 8.54153372e-03f, -7.95548633e-02f, 9.00730211e-03f,
  -2.01595277e-02f, -3.21490429e-02f, 1.23551246e-02f, 1.16624847e-01f, 1.27677590e-01f, -6.31108955e-02f, 3.12438700e-02f, 1.74838528e-02f, 1.12325735e-01f, -4.57578972e-02f,
  -6.11209013e-02f, -3.64620350e-02f, 4.06172089e-02f, -6.85281679e-02f, -1.63320024e-02f, 9.43855718e-02f, 1.17341271e-02f, -3.43760401e-02f, -7.49571919e-02f, 5.26188202e-02f,
  9.54223971e-04f, 9.01542082e-02f, -9.31240395e-02f, -6.55077747e-04f, 3.20692770e-02f, -9.29092523e-03f, -1.01088181e-01f, 8.13941434e-02f, 5.23664467e-02f, -6.73033744e-02f,
  1.17418744e-01f, -8.02668780e-02f, 4.30783629e-02f, -1.26305204e-02f, -3.37109044e-02f, 1.04995864e-02f, -2.80798059e-02f, 1.95435947e-03f, 2.16527488e-02f, 1.06918767e-01f,
  -3.37858275e-02f, 8.58546123e-02f, 9.03911516e-02f, 6.76337164e-03f, -3.67024168e-02f, -3.59883979e-02f, 3.31558362e-02f, 1.37391724e-02f, -1.29259467e-01f, 4.56489958e-02f,
  1.64830200e-02f, -2.67805415e-03f, 6.03304170e-02f, 8.48609880e-02f, 5.20836823e-02f, 1.90882050e-02f, 8.49539936e-02f, -6.51802123e-02f, -4.19502258e-02f, -4.95185517e-02f,
  8.87396559e-02f, 1.69963539e-02f, -2.12511942e-02f, 4.93781641e-02f, 7.63764977e-02f, -7.63708772e-03f, 5.45425015e-03f, -1.09380975e-01f, -9.68166739e-02f, -1.49697840e-01f,
  -7.91642740e-02f, 3.23795900e-02f, 1.87100604e-01f, -1.11312501e-01f, -2.68736742e-02f, -7.92474747e-02f, 5.80759756e-02f, -1.18877478e-01f, -3.54474075e-02f, 7.58451000e-02f,
  -4.10189823e-04f, 9.93082225e-02f, 5.14878780e-02f, -2.13029813e-02f, 2.65758149e-02f, 1.54359326e-01f, -6.78830966e-02f, 1.07066728e-01f, 3.49476412e-02f, 6.47353977e-02f,
  -4.25943322e-02f, 5.81009202e-02f, -1.48809671e-01f, -9.08053145e-02f, -1.24798372e-01f, 1.20395549e-01f, -1.30121335e-01f, -9.25212801e-02f, -4.48070243e-02f, -5.51364869e-02f,
  -7.00249663e-03f, 8.65213424e-02f, -1.99216958e-02f, -1.26817465e-01f, -1.31612808e-01f, -7.35582039e-02f, -1.10123314e-01f, 3.23912315e-02f, -1.31245121e-01f, -1.63386360e-01f,
  -2.87718922e-02f, -2.57223239e-03f, -2.34011859e-02f, -3.96564826e-02f, 6.86273426e-02f, 6.97502866e-02f, 2.62338489e-01f, -1.82341605e-01f, -1.61274940e-01f, -7.30217919e-02f,
  -5.77907786e-02f, -2.89647132e-02f, 6.40234649e-02f, -6.53487146e-02f, -6.32453859e-02f, -4.43132129e-03f, -7.17620328e-02f, -2.12436005e-01f, -6.10617623e-02f, 2.82792933e-02f,
  -3.26816812e-02f, 8.16127136e-02f, 5.92069998e-02f, -1.64276846e-02f, 6.55924156e-02f, 7.38098696e-02f, 1.13970421e-01f, 6.75534876e-03f, 5.85618168e-02f, 5.02779707e-02f,
  -5.79330921e-02f, -4.42670472e-02f, 1.64947674e-01f, -1.05065450e-01f, 2.55212430e-02f, -1.66503638e-01f, -3.28742154e-03f, 6.37656078e-02f, -4.68851738e-02f, 3.81253799e-03f,
  1.32265352e-02f, -6.71117976e-02f, 7.26952925e-02f, 4.53407466e-02f, 1.10265138e-02f, -1.35405734e-01f, -2.83128098e-02f, 1.55284628e-02f, 8.66901055e-02f, -7.64482766e-02f,
  -5.00522740e-02f, -1.78475864e-02f, 4.05887030e-02f, 1.00523792e-01f, -6.51974380e-02f, 9.56679955e-02f, -4.85032622e-04f, -2.48542894e-02f, 6.08580522e-02f, 1.37893418e-02f,
  1.07723977e-02f, 1.02603743e-02f, 6.27544448e-02f, 8.62272754e-02f, 4.33427393e-02f, 3.63992527e-02f, 1.19106092e-01f, 5.50358631e-02f, 2.85282433e-02f, -8.20258483e-02f,
  -8.38370770e-02f, -1.47972638e-02f, -6.50527654e-03f, -2.02211719e-02f, 6.25589117e-02f, 3.29645770e-03f, -4.89732102e-02f, 4.80106175e-02f, 2.27119513e-02f, 7.93647915e-02f,
  7.15542361e-02f, 8.71623233e-02f, -9.58733410e-02f, -1.13016516e-01f, 1.30261853e-01f, -1.39454287e-02f, 2.60557309e-02f, -1.35683920e-02f, 2.76531503e-02f, 6.73403367e-02f,
  -8.78607705e-02f, 1.03333518e-01f, -9.53995287e-02f, 7.53531530e-02f, 1.00247320e-02f, 4.21358347e-02f, 2.79738251e-02f, -6.94499090e-02f, 3.79043519e-02f, -5.15988730e-02f,
  3.87531891e-02f, -5.43203875e-02f, -6.22807927e-02f, -1.78978441e-03f, -9.41551626e-02f, -1.27934262e-01f, 4.68426049e-02f, 7.47715682e-02f, -8.57603177e-03f, 5.69583066e-02f,
  -4.68297824e-02f, -1.31618053e-01f, 8.46148294e-04f, 9.81740095e-03f, 4.17978466e-02f, 3.77346091e-02f, -1.34669438e-01f, -8.52120817e-02f, 1.67386662e-02f, 7.23131821e-02f,
  5.33147603e-02f, 4.62810732e-02f, -1.05077207e-01f, 6.52465373e-02f, 2.13548131e-02f, 2.08062623e-02f, 7.33188465e-02f, -3.75583135e-02f, 4.21405695e-02f, -6.75595319e-03f,
  2.37457943e-03f, -1.12573542e-01f, 1.06793664e-01f, -3.55602987e-02f, -2.38351487e-02f, -9.79996100e-02f, 1.97864950e-01f, -2.34191753e-02f, 5.92467785e-02f, 4.07667048e-02f,
  -1.07413553e-01f, 1.92973334e-02f, 4.22833860e-03f, -3.45737152e-02f, 3.41592878e-02f, -1.35748580e-01f, 6.89871684e-02f, 1.37759238e-01f, -1.12384208e-01f, 6.73408881e-02f,
  -7.17012137e-02f, 1.13224745e-01f, -5.03187487e-03f, 2.29685125e-03f, -1.30019626e-02f, 7.16717020e-02f, -1.48939481e-02f, -9.30443481e-02f, -1.29285306e-01f, 5.90693988e-02f,
  1.09781586e-01f, -1.41913025e-02f, 6.98744357e-02f, 6.39838055e-02f, -7.80599366e-04f, 2.69996170e-02f, -9.06774495e-03f, -5.01099788e-02f, 5.03038801e-03f, -2.77379360e-02f,
  -1.66125204e-02f, 3.07711028e-02f, -9.41069238e-03f, 6.26041042e-03f, -3.37128453e-02f, -4.58341241e-02f, 8.18140432e-03f, 8.47955644e-02f, 5.79525083e-02f, -8.39889795e-03f,
  -3.74320149e-03f, -8.89132847e-04f, 8.69785026e-02f, 1.13292616e-02f, -1.94821823e-02f, -1.35353068e-02f, 3.30335684e-02f, -3.25773396e-02f, 4.37957206e-04f, -4.31875465e-03f,
  1.60462577e-02f, -3.70213427e-02f, -1.93129163e-02f, -2.26922110e-02f, 1.70541629e-01f, -6.61765691e-03f, 4.47357111e-02f, 7.07374290e-02f, 7.89173618e-02f, -3.66185568e-02f,
  5.60887605e-02f, 9.01069045e-02f, 6.74285665e-02f, 1.02343224e-02f, 6.93267360e-02f, 1.35327965e-01f, -1.16109446e-01f, 2.46623415e-03f, 1.03529952e-01f, 2.48108562e-02f,
  1.14240646e-01f, -7.58527487e-04f, 1.15589909e-02f, 9.72318724e-02f, 7.22942501e-02f, -7.02225324e-03f, 1.16036117e-01f, -5.70869632e-02f, -2.01953389e-02f, -1.97168842e-01f,
  -6.33263513e-02f, -3.19852866e-02f, 8.85125902e-03f, 6.06172234e-02f, -1.69060603e-01f, 2.60953363e-02f, 6.23295978e-02f, 2.26788279e-02f, 8.02646205e-02f, 1.12527564e-01f,
  7.20885443e-03f, -1.33824676e-01f, -1.48537457e-02f, -6.05909601e-02f, 1.66931435e-01f, -1.48696929e-01f, 2.72060260e-02f, 3.29523832e-02f, -6.86429441e-03f, 1.64072305e-01f,
  -8.06019679e-02f, 9.61019471e-02f, -6.21065460e-02f, 1.24848239e-01f, 9.63796526e-02f, 1.84542879e-01f, -1.33995071e-01f, 6.17286339e-02f, 7.28801042e-02f, 6.11054245e-03f,
  2.87412591e-02f, 6.69646859e-02f, 3.39847878e-02f, 5.03171124e-02f, 8.54139104e-02f, 1.17694937e-01f, -3.53560480e-03f, -1.53842149e-02f, 9.90520492e-02f, -3.29912044e-02f,
  4.43202183e-02f, -7.90879205e-02f, -6.97621256e-02f, -9.93408784e-02f, 1.42297983e-01f, 6.40512183e-02f, 7.62863681e-02f, 8.78030360e-02f, -5.02464883e-02f, 3.93290333e-02f,
  1.32094733e-02f, 7.57733211e-02f, -8.82912874e-02f, 6.27524927e-02f, 5.02928086e-02f, -8.78426284e-02f, -3.28059793e-02f, 6.17963299e-02f, 9.55907404e-02f, -3.18535902e-02f,
  -3.72549146e-02f, -1.14563599e-01f, -6.68910518e-02f, -1.32815903e-02f, -3.88870388e-02f, 5.33036478e-02f, 1.17551953e-01f, -7.49815032e-02f, 9.17398706e-02f, -8.00817311e-02f,
  5.19512668e-02f, 1.67032890e-02f, 4.55932505e-02f, 8.55170488e-02f, -9.35810897e-03f, -1.35658711e-01f, -2.88109779e-02f, -4.90171164e-02f, 2.04777718e-02f, -9.95241851e-02f,
  -5.89275770e-02f, -4.84751500e-02f, 2.11179163e-02f, -3.65104973e-02f, 3.56439091e-02f, -4.13908400e-02f, -6.71334937e-02f, 8.20395574e-02f, 1.25500457e-02f, -6.06258549e-02f,
  7.90326577e-03f, 1.09347008e-01f, 8.21533501e-02f, 6.71473816e-02f, -6.35053515e-02f, -3.68134379e-02f, -1.73292290e-02f, -3.40257324e-02f, 4.87932526e-02f, 2.68908832e-02f,
  7.11501837e-02f, -1.93757156e-03f, -5.83446864e-03f, -1.92574617e-02f, 6.84558004e-02f, -6.31610975e-02f, 1.51961530e-02f, -8.74141529e-02f, -1.09088235e-01f, -6.56711450e-03f,
  6.76590055e-02f, -2.89303269e-02f, -1.12226054e-01f, 9.37941745e-02f, -1.16389722e-01f, -4.07525804e-03f, -2.75141038e-02f, 1.01778246e-02f, 3.78128625e-02f, -9.59112942e-02f,
  7.50177950e-02f, 6.22764938e-02f, -7.34841749e-02f, 1.03581533e-01f, 1.19982235e-01f, 8.71066898e-02f, 1.72364801e-01f, -1.63430557e-01f, 7.72294849e-02f, -4.95158918e-02f,
  -1.52342385e-02f, -4.62751947e-02f, -1.66048080e-01f, 1.88386347e-02f, -8.59846547e-03f, 3.89637263e-03f, -1.01791285e-01f, 1.63097635e-01f, -2.40632836e-02f, -3.46062966e-02f,
  1.39876798e-01f, -9.32270885e-02f, 1.16322907e-02f, 6.32810146e-02f, 1.05070822e-01f, -5.33421338e-02f, -1.43786641e-02f, 8.66557583e-02f, 4.16929461e-03f, 9.66907218e-02f,
  -1.25703802e-02f, -9.20118913e-02f, 6.77058799e-03f, 4.63723019e-02f, -7.19265416e-02f, 1.33695766e-01f, 1.59381270e-01f, -4.90526892e-02f, -1.02254581e-02f, -1.63911223e-01f,
  2.81826742e-02f, -3.10467463e-02f, 1.13933638e-01f, -3.69639061e-02f, 1.37185752e-01f, -1.12142928e-01f, -2.18468299e-03f, 4.66766283e-02f, -4.63553239e-03f, 8.91047120e-02f,
  -5.15388362e-02f, 9.71802976e-03f, 4.74098921e-02f, 7.53857493e-02f, -6.40653297e-02f, -4.29092757e-02f, 5.47196567e-02f, -1.98480468e-02f, -1.89096220e-02f, -2.94995848e-02f,
  -6.40295818e-02f, 1.90940425e-01f, 1.55363064e-02f, 8.88058394e-02f, 1.03742443e-02f, 9.39721614e-02f, -1.96723733e-02f, -8.67883340e-02f, -1.30248517e-01f, -1.00530632e-01f,
  -1.66767277e-02f, -6.18921630e-02f, -1.62182048e-01f, -4.64957841e-02f, 1.09766878e-01f, -1.02637865e-01f, -4.84258719e-02f, 4.63161282e-02f, -5.30893542e-02f, 4.24786583e-02f,
  2.31397175e-03f, 6.88777193e-02f, -1.71908326e-02f, 6.00458756e-02f, 2.95385346e-02f, 3.11055779e-03f, 6.49106205e-02f, 9.08549353e-02f, -2.41581295e-02f, -2.24911664e-02f,
  6.14026822e-02f, 2.98910290e-02f, -4.12083194e-02f, -3.64533253e-02f, 8.72886330e-02f, 8.59197006e-02f, -6.59296811e-02f, -3.31454575e-02f, -4.37790789e-02f, -9.21327770e-02f,
  -8.31851643e-03f, -1.95568101e-03f, -6.38162419e-02f, 4.63575274e-02f, 1.04733884e-01f, 2.33791471e-02f, 5.70541471e-02f, 6.68600900e-03f, -8.76863450e-02f, 3.51967849e-02f,
  5.99364787e-02f, -9.38133076e-02f, -3.93245630e-02f, 3.95694897e-02f, -1.33385193e-02f, 7.29102120e-02f, 6.97610080e-02f, 7.17219040e-02f, 7.13488534e-02f, 6.56086653e-02f,
  2.93967500e-02f, -3.90539900e-03f, -6.26808330e-02f, 2.62246281e-03f, 5.53713879e-03f, 6.61089420e-02f, 1.23099841e-01f, -1.27258440e-02f, -5.05335853e-02f, -8.25158954e-02f,
  -7.67107680e-03f, 5.81129044e-02f, 1.45477336e-03f, 1.05023958e-01f, -1.80675369e-02f, -1.56458259e-01f, -2.16508135e-02f, 6.98041469e-02f, 9.53926593e-02f, -6.43276274e-02f,
  2.51732320e-02f, -1.67905930e-02f, 1.03405518e-02f, 7.16469139e-02f, -1.16710894e-01f, -3.08392141e-02f, -2.28276979e-02f, 2.64660362e-02f, 3.96196991e-02f, -6.22162484e-02f,
  -8.20705369e-02f, -8.93482268e-02f, 2.47657243e-02f, 4.30119745e-02f, 1.48331234e-02f, 8.58017504e-02f, -3.26347863e-03f, -6.06959239e-02f, 4.09288406e-02f, 1.91654207e-03f,
  1.28817126e-01f, 1.45964473e-01f, 4.30312902e-02f, -1.31485099e-02f, 4.58648056e-02f, 5.86148277e-02f, -6.99438006e-02f, 6.39300346e-02f, -1.25561724e-03f, -2.94716582e-02f,
  1.64278466e-02f, 7.61171523e-03f, 4.23013121e-02f, 1.32379420e-02f, -9.09196958e-02f, 4.81868163e-02f, -5.30422144e-02f, 6.25151470e-02f, -2.88728159e-02f, 5.16898185e-02f,
  -1.52470618e-01f, 2.68299542e-02f, 4.67418320e-02f, 8.02996382e-02f, 3.82109620e-02f, -1.00089327e-01f, -9.69165191e-03f, -8.30196440e-02f, -4.05852161e-02f, 1.46222608e-02f,
  -1.16920993e-01f, -8.03700611e-02f, 3.54058519e-02f, -6.30685985e-02f, 5.90222254e-02f, -1.24099217e-01f, 4.87984680e-02f, -1.00667654e-02f, -6.37530908e-02f, 7.31442049e-02f,
  9.40616243e-03f, 6.10194020e-02f, 6.28867149e-02f, 5.75169325e-02f, -8.56451988e-02f, 6.40029162e-02f, -6.66195452e-02f, -6.01355843e-02f, -9.55729187e-02f, -8.27297270e-02f,
  8.05754662e-02f, -8.96602031e-03f, 6.01132540e-03f, 4.14659120e-02f, -9.18467157e-03f, 1.18995540e-01f, -7.42727667e-02f, 5.41419201e-02f, 3.92370252e-03f, 1.12855500e-02f,
  1.16274819e-01f, -1.23356003e-02f, -3.32174450e-02f, -3.52374427e-02f, -9.33928117e-02f, -4.68277074e-02f, -1.15828253e-01f, -2.98183654e-02f, -4.11948189e-02f, 5.19220531e-02f,
  -2.34633181e-02f, 8.55988488e-02f, 3.46582159e-02f, -5.32769039e-03f, 6.43419549e-02f, -5.65363420e-03f, -1.61161143e-02f, 8.36230293e-02f, -6.75524101e-02f, -7.68230259e-02f,
  6.81887055e-03f, 6.82110040e-05f, -7.74867609e-02f, 8.80327672e-02f, 6.21070638e-02f, 1.15771458e-01f, -7.97609910e-02f, 6.42050579e-02f, 1.94088332e-02f, -9.50466916e-02f,
  8.42048302e-02f, 6.73975870e-02f, 5.83395362e-02f, -8.19349196e-03f, 8.55921432e-02f, 6.77088127e-02f, 2.83470675e-02f, -8.51243809e-02f, -4.08178605e-02f, -9.10861269e-02f,
  -3.33098657e-02f, 1.56213511e-02f, -8.15293640e-02f, -4.79156803e-03f, -8.10184553e-02f, 1.33567989e-01f, -3.02951355e-02f, 2.68334970e-02f, -5.22158220e-02f, 6.46040067e-02f,
  1.20818481e-01f, 1.01710893e-01f, 3.46068479e-02f, 5.94430752e-02f, -5.30797020e-02f, 1.61727201e-02f, -5.55523746e-02f, 3.11173629e-02f, 3.22380103e-02f, -8.63009319e-02f,
  -1.45916998e-01f, 1.25987204e-02f, -2.29744166e-02f, 4.88135852e-02f, -3.35561298e-02f, -2.58063655e-02f, -9.43370759e-02f, -9.91159305e-03f, -1.04171969e-01f, -2.22835224e-02f,
  -1.77456178e-02f, -6.91989949e-03f, -7.34871672e-03f, -4.16989401e-02f, -5.26328422e-02f, -2.20821500e-02f, -1.56390462e-02f, 3.83577980e-02f, -8.23797286e-02f, -8.48090947e-02f,
  -8.10139254e-02f, -1.64606925e-02f, 1.29897907e-01f, -1.01861861e-02f, 1.36197925e-01f, -7.14152455e-02f, 1.21664323e-01f, 3.04666702e-02f, -5.75685278e-02f, -3.52440886e-02f,
  -1.07929036e-01f, -5.58147877e-02f, 6.78882673e-02f, 4.39780764e-02f, -4.77040838e-03f, -7.57320076e-02f, 2.85213664e-02f, -3.40673774e-02f, -5.92886060e-02f, 3.39813195e-02f,
  1.54433295e-01f, -5.53286783e-02f, 6.98144063e-02f, -4.34335358e-02f, -6.98984265e-02f, -3.77715379e-02f, 4.32444736e-02f, 1.21869855e-01f, 1.49350971e-01f, -2.47816928e-02f,
  -1.10909507e-01f, 1.13075845e-01f, 1.23437755e-01f, 8.59485567e-02f, 3.31232287e-02f, 4.73942682e-02f, -4.20340188e-02f, 8.43723193e-02f, -1.36779866e-03f, -3.30901556e-02f,
  7.21112117e-02f, -4.54779947e-03f, -1.45379985e-02f, 8.50463659e-02f, 5.58267571e-02f, -6.36190400e-02f, -1.20126605e-02f, 9.14559811e-02f, 6.38604760e-02f, 1.47341248e-02f,
  -3.97636406e-02f, 1.11722119e-01f, -9.58524793e-02f, 3.68372574e-02f, 1.64943356e-02f, 3.47610004e-03f, 1.98788363e-02f, 8.68117437e-03f, -7.32155982e-03f, -4.60576601e-02f,
  4.80952859e-02f, -7.84315448e-03f, 2.65649911e-02f, 6.20851144e-02f, 1.87788496e-03f, 4.97326665e-02f, 2.16676462e-02f, -1.47493195e-03f, -7.87976757e-02f, 1.72148757e-02f,
  -7.73533061e-02f, 2.08113976e-02f, -1.04651071e-01f, 4.07634526e-02f, 5.60501404e-03f, 1.02088368e-02f, -4.13769335e-02f, -1.34094516e-02f, -1.20499440e-01f, 7.24431500e-02f,
  -8.68848339e-03f, -1.12960569e-03f, 6.87357262e-02f, 3.11671738e-02f, 7.25984201e-02f, -1.84943564e-02f, 8.68829489e-02f, 4.36498038e-02f, -6.29481152e-02f, -6.26592040e-02f,
  -4.90522869e-02f, -7.66441673e-02f, 6.63637966e-02f, 2.02742256e-02f, -8.92228261e-02f, 7.87461847e-02f, -8.12242851e-02f, 4.44382802e-02f, 8.91798288e-02f, 1.05861485e-01f,
  -2.74021048e-02f, 1.38787776e-01f, -1.31726757e-01f, -1.13847092e-01f, -1.31441921e-01f, -2.56713741e-02f, 6.48749173e-02f, 7.45575950e-02f, -3.73307057e-02f, -4.40187715e-02f,
  2.43226485e-03f, 1.11718938e-01f, -1.10921517e-01f, 1.55796334e-01f, -3.48935723e-02f, 1.00348443e-02f, -1.05888404e-01f, 2.29059115e-01f, -1.09204754e-01f, -6.15986660e-02f,
  -2.12748144e-02f, 9.39237177e-02f, 1.33043826e-01f, 2.38426924e-02f, 3.27964649e-02f, 5.02254404e-02f, 1.87444463e-01f, 1.37272524e-02f, -1.53133184e-01f, -2.17557363e-02f,
  1.28234982e-01f, 3.90412696e-02f, 1.62331253e-01f, -1.28818333e-01f, -2.49709729e-02f, 8.11592117e-02f, 1.20873541e-01f, 1.92879722e-01f, 6.62106648e-02f, 7.30076134e-02f,
  9.38550662e-03f, 3.27158235e-02f, 4.01297770e-02f, 3.94034274e-02f, 1.14426762e-03f, -9.90981609e-02f, 2.82034315e-02f, 1.19568296e-01f, -4.74149399e-02f, -8.12689215e-02f,
  -7.68994913e-02f, 2.51644515e-02f, -2.27302741e-02f, -8.13467950e-02f, -4.79340032e-02f, -7.53521323e-02f, 1.00096576e-01f, 1.20312639e-01f, 4.69316840e-02f, 6.71045575e-03f,
  -3.52642424e-02f, -3.59463803e-02f, -7.86409155e-02f, 6.70402646e-02f, -6.79371282e-02f, -2.18189396e-02f, 3.07384469e-02f, 3.72492382e-03f, 6.72787577e-02f, -1.11964315e-01f,
  -6.65814430e-02f, -2.87292730e-02f, -2.90172864e-02f, -1.12038571e-02f, 1.84751600e-02f, -2.48112306e-02f, -1.03639867e-02f, -6.66241301e-03f, 1.04662981e-02f, 3.84836644e-02f,
  7.57080019e-02f, -7.90843815e-02f, -8.17892998e-02f, 4.92384620e-02f, 5.05875982e-02f, 4.98613305e-02f, -4.48475070e-02f, -1.61432456e-02f, -1.29351646e-01f, 9.42946151e-02f,
  -4.77060080e-02f, -6.10889904e-02f, -6.50609359e-02f, 1.02198496e-02f, -3.47756408e-02f, 8.15253109e-02f, 1.48895029e-02f, -3.22223380e-02f, 7.96243735e-03f, -5.53692430e-02f,
  -8.58462676e-02f, 4.50115316e-02f, -7.66065940e-02f, -3.18642668e-02f, -6.02173805e-02f, 2.80063953e-02f, 6.70265928e-02f, 4.68234643e-02f, 5.31216338e-02f, -8.38288665e-02f,
  -4.27327305e-02f, 5.30022122e-02f, 4.82369773e-02f, -1.16782635e-02f, -1.14879057e-01f, 1.16698533e-01f, -9.95072499e-02f, -7.52651915e-02f, -7.24963322e-02f, 6.54016063e-02f,
  1.36850700e-01f, 1.76445067e-01f, 8.48300569e-03f, -4.28112410e-02f, -1.55035049e-01f, 6.03621490e-02f, 1.40122443e-01f, -4.62244563e-02f, -9.33378264e-02f, -1.23708934e-01f,
  -9.84419435e-02f, -3.58616598e-02f, 9.03172120e-02f, -1.66843623e-01f, -9.07844007e-02f, 1.00185685e-01f, -6.77760616e-02f, -2.27781907e-01f, 5.36133014e-02f, -7.86706582e-02f,
  2.05137223e-01f, -1.70481086e-01f, -2.41438989e-02f, -2.15553388e-01f, -1.01788923e-01f, -9.96824205e-02f, -8.67487863e-02f, -1.33238286e-01f, 6.15713000e-02f, 5.65171242e-02f,
  -6.15785010e-02f, -9.01009422e-04f, -2.29879818e-03f, -1.96474604e-02f, 8.20305720e-02f, -1.10367537e-01f, 4.41512428e-02f, -1.25351697e-01f, -5.70584908e-02f, -8.15306008e-02f,
  -1.16448291e-01f, -1.43377632e-01f, 1.52329981e-01f, 7.62534738e-02f, 8.19619298e-02f, -8.15944001e-02f, -4.14272025e-02f, 8.93419161e-02f, 1.00176603e-01f, -3.74481790e-02f,
  -1.63134888e-01f, -1.78557374e-02f, -1.52597378e-03f, -8.21978599e-02f, 3.34086865e-02f, 1.42845944e-01f, -3.29248831e-02f, 1.92308687e-02f, -7.57152066e-02f, -4.63074408e-02f,
  -9.46480036e-02f, -7.76149407e-02f, 9.96929500e-03f, 4.84029669e-03f, -2.23191385e-03f, -8.04179162e-02f, -4.98469844e-02f, -1.64216012e-02f, -1.73370205e-02f, 1.00466795e-01f,
  -6.28023073e-02f, 2.73014326e-03f, 4.70663607e-02f, -1.36901038e-02f, 9.80849937e-02f, -2.57472117e-02f, -5.38915470e-02f, -3.97539586e-02f, -5.77251539e-02f, -1.33041590e-01f,
  4.76671532e-02f, -2.65828632e-02f, -3.46821807e-02f, -2.10266691e-02f, -1.03208594e-01f, 5.94451204e-02f, 6.72385991e-02f, -6.89942092e-02f, 1.02408148e-01f, 4.97442158e-03f,
  3.59662510e-02f, 1.97717790e-02f, 1.70453172e-02f, 4.37778346e-02f, 8.16402435e-02f, -3.84019874e-02f, -1.30358711e-01f, 7.45952800e-02f, -9.48408023e-02f, 8.10680091e-02f,
  -2.87436470e-02f, 9.88498777e-02f, 9.83941853e-02f, -5.11137061e-02f, -1.84070021e-02f, -3.20946500e-02f, 2.04476826e-02f, 1.28206033e-02f, -1.82659160e-02f, 8.69151577e-02f,
  -6.69873059e-02f, 1.05774432e-01f, -9.42834169e-02f, 9.51788276e-02f, 4.04951349e-02f, 4.63770330e-02f, 1.05644815e-01f, -5.19862920e-02f, -4.59547937e-02f, 5.91133982e-02f,
  6.55966327e-02f, -5.09033501e-02f, 1.17506720e-01f, 5.46052903e-02f, 9.65479985e-02f, -9.61858481e-02f, -7.68391788e-02f, -9.54944268e-02f, 1.24374241e-01f, -4.91531119e-02f,
  1.27530783e-01f, 9.10811499e-03f, -1.06556609e-01f, 4.85137813e-02f, -4.15800139e-02f, -1.28590360e-01f, 6.64395243e-02f, -9.09048691e-02f, -1.14987195e-01f, -1.01484641e-01f,
  6.85460642e-02f, -2.06115067e-01f, -1.03520602e-01f, -1.05474517e-01f, 1.02515645e-01f, -3.83704156e-02f, 2.70975810e-02f, 3.78413796e-02f, 1.05735384e-01f, -5.39337099e-02f,
  -5.03315702e-02f, 4.75628413e-02f, -5.65671083e-03f, 8.79598334e-02f, 7.64545798e-02f, 1.68020390e-02f, 1.18058398e-01f, 6.95473626e-02f, -5.39413132e-02f, 3.52137946e-02f,
  1.03795722e-01f, -1.82193220e-02f, 3.64304744e-02f, 9.76759568e-02f, 1.78842209e-02f, 2.78923288e-02f, 3.73326911e-04f, -1.08074985e-01f, -1.67131662e-01f, -1.44149354e-02f,
  -1.16966233e-01f, 4.73937718e-03f, 2.12511674e-01f, -8.64922255e-02f, -3.34044732e-02f, -9.88574103e-02f, -1.03705660e-01f, -5.93346395e-02f, 1.67230275e-02f, 1.03469687e-02f,
  -3.52757648e-02f, 1.56266421e-01f, -4.91670799e-03f, 1.04397878e-01f, 4.87645902e-02f, 8.37387219e-02f, 3.19571197e-02f, 1.47945024e-02f, 1.33193225e-01f, -7.28078485e-02f,
  1.53812896e-02f, -8.71677324e-02f, -2.71814913e-02f, -4.69684191e-02f, 3.29517759e-02f, 1.36582538e-01f, -1.39709920e-01f, -1.97711717e-02f, 7.52298832e-02f, -2.40208637e-02f,
  9.28205401e-02f, -8.36908370e-02f, -8.65338734e-05f, 6.97990060e-02f, 4.17515747e-02f, -2.12520193e-02f, -1.22741908e-02f, -3.79211307e-02f, -1.09202109e-01f, -6.32953942e-02f,
  9.75704789e-02f, -5.16960863e-03f, 2.89698057e-02f, -1.42280813e-02f, 5.17306812e-02f, 6.68154135e-02f, -8.61480087e-02f, -2.66061909e-02f, -1.89043209e-02f, 2.32121367e-02f,
  -5.46660274e-03f, 1.24817928e-02f, 3.47393565e-02f, 1.85548067e-02f, -1.03744328e-01f, 1.01133855e-02f, 5.68709038e-02f, -4.83682193e-02f, 8.95141140e-02f, -3.79465595e-02f,
  4.66827154e-02f, 3.33701037e-02f, 4.97145988e-02f, 3.72672863e-02f, 8.14791322e-02f, 4.95192334e-02f, 3.99949215e-03f, 1.11027986e-01f, -4.17798646e-02f, -3.73795256e-02f,
  -1.24680791e-02f, 5.12378616e-03f, -4.50946577e-02f, -8.88838060e-03f, 1.90580767e-02f, 2.02384833e-02f, 5.33360697e-04f, 5.20978160e-02f, 8.08822140e-02f, -3.36230546e-02f,
  -6.56267181e-02f, 1.50579717e-02f, -2.10049257e-01f, -1.78384222e-02f, -1.66607037e-01f, 1.96404010e-01f, 8.37058499e-02f, 2.05943227e-01f, 6.03679121e-02f, 3.40007804e-02f,
  1.40040619e-02f, 1.20423295e-01f, 7.64465332e-02f, 6.72285631e-02f, -1.18813649e-01f, -1.49874136e-01f, -1.42784917e-03f, -1.05383992e-02f, 4.24015895e-03f, -1.35558859e-01f,
  -1.12494782e-01f, 1.48744270e-01f, 2.46147029e-02f, -5.99536225e-02f, -1.27669210e-02f, -1.68058231e-01f, 1.20769784e-01f, -9.37259346e-02f, -7.74200708e-02f, -1.76669419e-01f,
  -1.65727243e-01f, -2.08551332e-01f, -2.97299735e-02f, -1.84883043e-01f, -6.96257055e-02f, 1.38288498e-01f, -1.53127927e-02f, -8.44854787e-02f, -2.99500898e-02f, 6.54684827e-02f,
  9.90164056e-02f, -1.05229437e-01f, -7.90512040e-02f, 2.18747742e-02f, 1.16248466e-01f, 5.00733778e-02f, -7.65982047e-02f, 1.19550060e-03f, 7.48168826e-02f, -6.45919284e-03f,
  4.59542014e-02f, -1.05543092e-01f, 5.40634058e-02f, -2.67744437e-02f, 9.87229124e-02f, -1.05059884e-01f, -3.02767977e-02f, 9.33282599e-02f, -3.98462527e-02f, 9.56876145e-04f,
  3.61216404e-02f, 1.14514679e-01f, 3.75226960e-02f, 3.68300788e-02f, -1.08431526e-01f, -1.37183499e-02f, -1.16720706e-01f, -9.00236368e-02f, -5.39171137e-02f, -1.02438606e-01f,
  1.35930581e-02f, 5.59443906e-02f, -1.40163153e-01f, 4.56291661e-02f, 7.70238042e-02f, 1.63459890e-02f, 5.07844314e-02f, 7.66144246e-02f, 3.66252549e-02f, -1.57962162e-02f,
  8.00557714e-03f, -4.16905507e-02f, 4.75549698e-02f, 7.11252987e-02f, -1.49470791e-02f, 3.53744552e-02f, -6.29092939e-03f, 8.12838692e-03f, 6.61922023e-02f, 7.86752701e-02f,
  3.36166583e-02f, -3.39034386e-02f, 3.80485803e-02f, 1.02370195e-01f, 3.81692611e-02f, 3.46581154e-02f, 4.00025398e-02f, 8.71749520e-02f, 1.01584442e-01f, 2.20132843e-02f,
  1.06108777e-01f, 7.09702075e-02f, -1.31087704e-02f, 2.48846970e-02f, 5.98565713e-02f, -4.49970085e-03f, 1.37628004e-01f, -2.88743004e-02f, 1.61753520e-01f, 4.17710990e-02f,
  4.10234407e-02f, -6.91702515e-02f, -1.13605738e-01f, -7.85846189e-02f, 7.62095600e-02f, 1.10235922e-01f, -4.30193506e-02f, 2.75701359e-02f, 1.28664058e-02f, 2.08225265e-01f,
  -6.53210729e-02f, 2.37050280e-02f, 1.30433619e-01f, 7.21932203e-02f, 2.33400334e-02f, -3.49307456e-03f, 1.29524216e-01f, 9.79503617e-02f, 3.09034865e-02f, 1.97673887e-02f,
  1.52803540e-01f, -8.95048901e-02f, 6.89936131e-02f, -1.88475594e-01f, -8.40217099e-02f, -1.55692086e-01f, -4.06871401e-02f, -1.99689660e-02f, -1.79304406e-01f, 1.21797189e-01f,
  -1.11416042e-01f, -7.11353943e-02f, 1.48632914e-01f, 1.63159475e-01f, 8.19334760e-02f, 1.04084900e-02f, 9.17238966e-02f, 4.10538726e-02f, 1.12246290e-01f, 8.58226418e-02f,
  -7.18185306e-02f, 7.74788335e-02f, -3.04778274e-02f, -7.86709320e-03f, -3.12230010e-02f, 7.07429089e-03f, -3.68081219e-02f, -1.97966732e-02f, 5.47462665e-02f, 6.07339107e-02f,
  -1.66585341e-01f, 9.98950973e-02f, 3.18246670e-02f, -7.06198737e-02f, 2.26011500e-03f, -9.47120860e-02f, 5.84186018e-02f, 5.10884337e-02f, -8.56359082e-04f, 1.13540433e-01f,
  -5.88845871e-02f, -2.89153215e-02f, -6.29888251e-02f, -1.10894792e-01f, 2.32368410e-02f, 5.22202998e-02f, -2.14519575e-02f, -8.51929709e-02f, 8.88620466e-02f, 1.21442653e-01f,
  7.95033723e-02f, 5.88439740e-02f, -4.96622138e-02f, 9.18360204e-02f, 2.93902401e-02f, -2.76643075e-02f, -9.53214243e-02f, -1.69930626e-02f, 6.23970330e-02f, 8.77474323e-02f,
  -2.99039911e-02f, -4.87714354e-03f, 6.18375931e-03f, 3.81539501e-02f, -6.32848889e-02f, 1.22695118e-02f, -3.62263024e-02f, 8.01405460e-02f, -1.16247214e-01f, -3.58823836e-02f,
  1.03217982e-01f, -7.93259144e-02f, 1.40725836e-01f, -9.08866078e-02f, -3.12692039e-02f, 2.13127285e-02f, 5.50599284e-02f, -3.71117666e-02f, -6.24947250e-02f, 2.74272263e-02f,
  1.73517596e-02f, -2.41451315e-03f, 5.11563644e-02f, 7.05722496e-02f, -1.59477780e-03f, -5.63003384e-02f, -5.75282462e-02f, 9.30975303e-02f, 5.58311418e-02f, -3.95962149e-02f,
  7.11729797e-03f, -7.74723617e-03f, 7.50859901e-02f, -2.94232760e-02f, -4.79195043e-02f, 6.43002763e-02f, -6.98037222e-02f, -1.15106568e-01f, -3.86614986e-02f, -5.65414131e-02f,
  3.34636830e-02f, -3.68438289e-02f, 6.69428632e-02f, -1.22005060e-01f, -7.73501769e-02f, -5.48061319e-02f, 9.72387791e-02f, 2.44542006e-02f, -7.79472813e-02f, -1.55932866e-02f,
  6.38072044e-02f, -5.79376519e-02f, -7.14098662e-02f, 4.03627791e-02f, -2.18318719e-02f, -3.03207189e-02f, -4.03792374e-02f, -2.82123536e-02f, -1.07362904e-01f, 2.17491556e-02f,
  9.76684839e-02f, -5.84560726e-03f, 4.45931777e-02f, -1.11127682e-01f, -1.19598687e-01f, 4.19290699e-02f, 1.17264017e-01f, -4.98481952e-02f, -9.97474864e-02f, -6.35930076e-02f,
  -9.36044827e-02f, 5.69905303e-02f, -6.38495907e-02f, -4.30972949e-02f, -1.06626190e-01f, 9.44837928e-02f, -7.16842711e-02f, -6.12934865e-02f, 9.29069147e-02f, 9.32412520e-02f,
  1.04386859e-01f, -7.25602582e-02f, -1.18378051e-01f, -1.55764461e-01f, -1.09641783e-01f, 3.64638120e-02f, 5.39478846e-02f, 2.58771889e-02f, -1.59164891e-01f, 1.20585468e-02f,
  -6.22160882e-02f, 9.37035680e-02f, 2.16093268e-02f, 1.70517847e-01f, -5.37819527e-02f, -1.05276354e-01f, 7.10452422e-02f, 2.15921164e-01f, 3.23825665e-02f, -8.03238228e-02f,
  -1.05693229e-01f, 9.66906995e-02f, 2.59032063e-02f, 7.76357353e-02f, 6.87831827e-03f, 1.12241320e-01f, 8.50494727e-02f, 4.33395021e-02f, -1.32469803e-01f, 8.34696442e-02f,
  5.74776828e-02f, 1.24107435e-01f, 3.69563214e-02f, -2.09817916e-01f, -1.48076147e-01f, -2.00584028e-02f, 1.98276639e-01f, 7.31084049e-02f, -5.53804711e-02f, -4.28116247e-02f,
  -2.70183459e-02f, -1.04531376e-02f, -5.67359105e-02f, 4.28812802e-02f, 7.90195167e-02f, -1.29056275e-02f, 6.49286285e-02f, -5.82316108e-02f, -1.59053523e-02f, -3.98271084e-02f,
  -5.97158121e-03f, 1.10545337e-01f, -1.15543365e-01f, 4.51838747e-02f, -9.34751183e-02f, -3.38528007e-02f, 1.63347974e-01f, 3.10153253e-02f, -6.16405345e-02f, 1.11137051e-02f,
  4.01843265e-02f, -9.50267985e-02f, -8.28938559e-02f, 2.93211397e-02f, -2.18183845e-02f, -1.46825062e-02f, 7.70207569e-02f, 1.15218910e-03f, 7.77749717e-02f, 3.55579369e-02f,
  6.17845617e-02f, -7.62452632e-02f, 6.90811453e-03f, 1.35981292e-01f, 1.18911691e-01f, 2.72735003e-02f, -6.76027536e-02f, -8.18669498e-02f, 1.78574044e-02f, 8.28324035e-02f,
  9.20116827e-02f, -7.51575902e-02f, 4.37461957e-02f, 2.40483433e-02f, 1.11355139e-02f, -4.43719141e-02f, 1.89432763e-02f, 3.98762450e-02f, -7.07800835e-02f, -1.26769403e-02f,
  5.58861345e-02f, 1.06885247e-01f, 4.68010306e-02f, -2.36887746e-02f, 6.48605898e-02f, 4.67109531e-02f, 2.08680262e-03f, -7.19164163e-02f, -2.01245770e-03f, 9.58690012e-04f,
  3.49403769e-02f, 1.11354128e-01f, 6.96311370e-02f, 1.47190038e-02f, -9.01313648e-02f, 2.27418691e-01f, -9.80327800e-02f, 8.19262564e-02f, -1.53746558e-02f, 6.43872246e-02f,
  1.32743612e-01f, -5.95786013e-02f, -6.07489869e-02f, 2.63219438e-02f, -8.46883208e-02f, -5.55813611e-02f, -1.03431240e-01f, 4.03492972e-02f, 1.46233812e-01f, -7.16441497e-02f,
  1.02183715e-01f, -1.84927016e-01f, 9.17819291e-02f, -8.56384486e-02f, -2.01648727e-01f, -1.34067349e-02f, -7.08626059e-04f, -4.46473584e-02f, -1.63513031e-02f, 1.95477709e-01f,
  6.39894083e-02f, 7.57578909e-02f, 4.96409424e-02f, 1.46062493e-01f, -7.18244314e-02f, 1.41777337e-01f, 1.08414525e-02f, -2.20157369e-03f, -3.04073822e-02f, -1.64830703e-02f,
  -2.45689861e-02f, 1.01158254e-01f, -1.84729367e-01f, -4.42842429e-04f, -1.06001399e-01f, 4.04783450e-02f, 6.22609397e-03f, -3.22077461e-02f, -5.06578051e-02f, 1.87593477e-03f,
  -1.07717048e-02f, -1.60070598e-01f, 1.03311948e-01f, -5.19805998e-02f, 5.11500314e-02f, 1.08981602e-01f, 7.79547961e-03f, -4.04077545e-02f, -5.47518255e-03f, -2.36774310e-02f,
  -9.01121646e-02f, 1.03770308e-01f, 1.56220376e-01f, 2.10042521e-01f, -1.37146026e-01f, 7.57158697e-02f, 3.88745777e-02f, 5.67997470e-02f, -8.24115705e-03f, -4.26628329e-02f,
  4.04702360e-03f, 1.44355753e-02f, -9.07517821e-02f, 1.14224486e-01f, -1.54553160e-01f, -1.71684958e-02f, 3.64764743e-02f, 9.40482616e-02f, -1.56191513e-01f, 8.86366982e-03f,
  -1.05022021e-01f, 6.42921403e-02f, 6.23915121e-02f, 2.77132075e-02f, -1.43106118e-01f, -1.20384842e-02f, 8.06661099e-02f, -4.44682091e-02f, 5.89019693e-02f, -9.13228467e-02f,
  -3.24645899e-02f, -3.82464677e-02f, -2.78220195e-02f, -2.76107043e-02f, 1.85970291e-02f, -7.35259149e-03f, 4.43188883e-02f, 4.76131141e-02f, 9.88783762e-02f, 1.05231531e-01f,
  8.59450996e-02f, 6.41302913e-02f, 6.47029281e-02f, -2.04828829e-02f, 4.86109592e-02f, -5.91280982e-02f, 9.25758574e-03f, 6.44091666e-02f, -4.12976593e-02f, -2.87729278e-02f,
  -6.93415850e-02f, 6.91787452e-02f, 3.50137874e-02f, -5.73846661e-02f, -2.66433712e-02f, -2.85067335e-02f, 1.20471276e-01f, 1.51066203e-02f, -2.63434481e-02f, -7.58663490e-02f,
  5.97205088e-02f, -1.54585484e-02f, 1.13238774e-01f, 1.87154524e-02f, -5.18967174e-02f, -2.77173147e-02f, 1.32301331e-01f, -9.33352783e-02f, -2.83364989e-02f, 5.40859066e-02f,
  4.57010046e-02f, -4.30176593e-02f, 2.05731411e-02f, -2.28712559e-02f, 1.81504190e-02f, 7.32761919e-02f, 1.07114471e-01f, 1.04925103e-01f, 1.03250526e-01f, -1.85647625e-02f,
  1.94420591e-02f, 5.61084710e-02f, -4.49493565e-02f, 1.04678124e-01f, 8.26391354e-02f, -1.92293692e-02f, 1.01252422e-02f, -1.35287330e-01f, -1.37536809e-01f, 7.89779052e-02f,
  -2.03023646e-02f, 9.20293406e-02f, -5.49794585e-02f, 1.03912622e-01f, 7.31655136e-02f, -3.39869745e-02f, -6.28071278e-02f, 2.53948513e-02f, -1.65947005e-01f, -1.77136846e-02f,
  -6.99886531e-02f, -8.99810903e-03f, -1.53728843e-01f, -4.05314378e-03f, 1.05670523e-02f, -1.24412708e-01f, -7.33970255e-02f, -9.56922993e-02f, -5.11146486e-02f, -5.90493530e-03f,
  -3.50942165e-02f, -4.83325422e-02f, -1.34902716e-01f, 1.00737080e-01f, -1.80462807e-01f, 5.98673783e-02f, 8.67658481e-02f, 1.44827753e-01f, -1.00257784e-01f, -1.38111636e-01f,
  -4.77493964e-02f, 4.24885340e-02f, 1.09299375e-02f, 1.26309460e-03f, 2.58255620e-02f, 3.08854645e-03f, 1.03612162e-01f, -5.47564514e-02f, -3.32487486e-02f, -8.96054599e-03f,
  7.18764737e-02f, -2.75673755e-02f, 2.32579902e-01f, 1.19783975e-01f, -9.07918066e-02f, -3.47715728e-02f, 9.71504971e-02f, -3.48798349e-03f, -6.29338482e-03f, -1.93818528e-02f,
  -8.06820393e-02f, -9.54560041e-02f, 5.02528958e-02f, 1.46806061e-01f, 7.63224214e-02f, 3.07838935e-02f, 1.13334388e-01f, 2.33028512e-02f, -5.51715866e-02f, -1.47922948e-01f,
  1.42065138e-01f, 1.49681577e-02f, 5.96850216e-02f, 6.98089153e-02f, -7.97570646e-02f, 6.01871088e-02f, -5.11667021e-02f, 8.60957205e-02f, -2.64648087e-02f, 4.91131283e-02f,
  -5.27160130e-02f, -3.10180094e-02f, -4.23491746e-02f, 5.64173888e-03f, 1.28928141e-03f, -3.54049616e-02f, 1.24000721e-02f, -7.96224996e-02f, 6.22946620e-02f, -3.38046513e-02f,
  -7.56651536e-02f, 8.75064135e-02f, 1.74287334e-02f, -7.79991075e-02f, -9.36750043e-03f, 6.61960170e-02f, 1.06287062e-01f, -5.47848418e-02f, 1.12809213e-02f, 9.60343853e-02f,
  8.26480091e-02f, -2.13526096e-02f, -3.38418707e-02f, -8.87079816e-03f, 9.70972329e-02f, 6.69507161e-02f, -1.09103009e-01f, 1.02448929e-02f, -3.16240601e-02f, -1.26639418e-02f,
  -7.72155598e-02f, -1.22752506e-02f, -6.15565218e-02f, 3.59286778e-02f, 5.73401414e-02f, -7.84285367e-02f, -6.74547032e-02f, -9.56563558e-03f, 2.10283976e-03f, 8.46300870e-02f,
  -3.47074084e-02f, 9.14899036e-02f, -1.62769598e-03f, 1.85755137e-02f, 7.34050870e-02f, -6.23563528e-02f, -1.12162113e-01f, -1.14660850e-02f, -7.67121762e-02f, -5.40902726e-02f,
  5.28368652e-02f, 1.54012395e-02f, -9.18643922e-02f, -9.87536758e-02f, -7.61009306e-02f, -7.02051669e-02f, 6.89494461e-02f, -1.80087294e-02f, -3.26290876e-02f, -4.95909788e-02f,
  -5.59722483e-02f, -7.38118440e-02f, 5.60787134e-02f, -3.77891436e-02f, 1.90960422e-01f, 8.14237148e-02f, -5.88218980e-02f, -1.47182018e-01f, -4.44647148e-02f, -4.72318493e-02f,
  9.72503275e-02f, -1.43129691e-01f, -1.47325441e-01f, 1.08491533e-01f, -4.48721796e-02f, 3.31283659e-02f, -1.06373668e-01f, 1.04724996e-01f, 5.71857095e-02f, 7.32146204e-02f,
  -1.26007292e-03f, 9.05952901e-02f, 4.57130112e-02f, 2.77058948e-02f, -1.87312439e-01f, 5.33774449e-03f, 8.38257596e-02f, -3.01459227e-02f, 1.28234969e-02f, 1.58722177e-01f,
  1.18397176e-01f, 6.32716017e-03f, -4.97120917e-02f, -2.72956491e-02f, 1.58216119e-01f, -3.35777365e-02f, 4.33044732e-02f, -2.23100543e-01f, -9.58373025e-02f, -1.84380054e-01f,
  1.01579204e-01f, 8.94743502e-02f, 2.94311233e-02f, 3.15539204e-02f, -1.28226385e-01f, 9.05967429e-02f, 1.16324956e-02f, -3.51251848e-02f, 3.31856422e-02f, -1.31403625e-01f,
  9.87374559e-02f, -5.87451383e-02f, -1.18445083e-01f, -1.20583802e-01f, -6.45076111e-02f, 8.79040509e-02f, 8.05903152e-02f, 6.75424114e-02f, -3.56724411e-02f, 5.31057864e-02f,
  1.34036794e-01f, -2.06456650e-02f, -1.38480132e-02f, 6.51201010e-02f, -2.75631872e-04f, -1.50140807e-01f, -8.34733099e-02f, 1.73540600e-02f, 1.51349241e-02f, -1.25008570e-02f,
  -1.42375259e-02f, 2.38438156e-02f, 9.48189478e-03f, -4.59102094e-02f, -7.49090314e-02f, 4.64431979e-02f, 6.77735880e-02f, -4.17778920e-03f, 1.04397554e-02f, -2.09459234e-02f,
  6.08678348e-03f, -9.87045541e-02f, -1.62900910e-02f, 6.01151250e-02f, -4.95739095e-02f, -2.91215181e-02f, 3.02961078e-02f, -1.79517008e-02f, 4.41103205e-02f, -8.02005231e-02f,
  4.54543680e-02f, -1.22186262e-02f, 9.56695229e-02f, -2.12576259e-02f, 4.29257974e-02f, 2.53588352e-02f, 9.64122415e-02f, 7.90408328e-02f, 1.25781700e-01f, -4.28541042e-02f,
  -2.21462473e-02f, -2.79103145e-02f, 5.82553744e-02f, -9.23121423e-02f, -5.86748682e-02f, 2.42874008e-02f, 3.99391018e-02f, 3.75492349e-02f, -3.31360288e-02f, 6.21199869e-02f,
  -1.24628514e-01f, 1.02904566e-01f, 1.17527507e-01f, 9.07860883e-03f, 1.13730840e-01f, -1.05733044e-01f, -2.02855580e-02f, -5.68742342e-02f, 1.01768233e-01f, 1.22201853e-01f,
  1.19511455e-01f, 3.41671742e-02f, -1.22205153e-01f, -4.64766733e-02f, -6.50248304e-02f, 5.19865490e-02f, -7.27600455e-02f, 7.17359781e-02f, 5.26198000e-02f, -2.26504654e-02f,
  3.12543884e-02f, -7.91347623e-02f, 2.03411207e-02f, -1.99867766e-02f, -1.20977297e-01f, -1.01934627e-01f, -8.97432417e-02f, -1.43084019e-01f, 5.08087948e-02f, 5.26614338e-02f,
  1.20891929e-01f, -2.41286959e-02f, 6.96731731e-02f, -6.08459227e-02f, 9.78701636e-02f, -8.49552155e-02f, 1.16638444e-01f, -3.65502127e-02f, 8.81845579e-02f, 1.89270630e-01f,
  -9.32293162e-02f, -7.95411691e-02f, 8.14180672e-02f, 7.74791166e-02f, -1.85105205e-02f, 1.02041317e-02f, 3.35747562e-02f, -4.50265221e-02f, 1.43396989e-01f, 8.77360553e-02f,
  -6.55160993e-02f, 1.11161426e-01f, 1.09592834e-02f, 4.89529110e-02f, -1.92660019e-02f, -5.52266389e-02f, -2.07636625e-01f, 5.75474016e-02f, 1.54389814e-01f, 9.45011601e-02f,
  -6.28167540e-02f, -1.58058025e-03f, -4.61373711e-03f, -1.86784007e-02f, 1.30435377e-01f, -1.29578577e-04f, -8.21695030e-02f, 2.11125575e-02f, 3.35066170e-02f, -2.54799277e-02f,
  9.75672714e-03f, 4.92818095e-02f, 9.72460881e-02f, -3.72611396e-02f, 1.30187767e-02f, -6.51349500e-02f, 3.52133438e-02f, 1.44088659e-02f, -6.40378594e-02f, 1.22923534e-02f,
  4.03672643e-02f, 9.41381156e-02f, -1.21347293e-01f, -2.34195609e-02f, -2.84674279e-02f, -8.22992846e-02f, -9.19442698e-02f, 9.06540751e-02f, -5.19344509e-02f, -2.63421368e-02f,
  6.73436448e-02f, -6.84112357e-03f, 9.58976373e-02f, 1.09196797e-01f, -7.80615732e-02f, 5.91087565e-02f, -6.51155561e-02f, -2.81800493e-03f, 4.99219969e-02f, 3.28808278e-02f,
  -2.83174571e-02f, -2.52987701e-03f, 2.44546290e-02f, -2.60320846e-02f, -6.93995655e-02f, -5.37864072e-03f, 6.32037669e-02f, 3.00216749e-02f, -2.32894402e-02f, 1.74441710e-02f,
  -3.52471769e-02f, 4.05197777e-03f, -6.94956183e-02f, 7.50878733e-03f, -6.61195740e-02f, -6.44124374e-02f, -5.15781008e-02f, 6.71806633e-02f, 4.64858823e-02f, -7.84601718e-02f,
  -1.52445268e-02f, 3.52686131e-03f, -1.99033953e-02f, 3.51037458e-02f, -4.15328285e-03f, -5.98357059e-02f, 8.67934078e-02f, -3.16945761e-02f, 1.27687501e-02f, -4.17735726e-02f,
  8.76840483e-03f, 4.81577367e-02f, 6.02245145e-02f, -4.72916290e-02f, -2.88413875e-02f, -5.09279445e-02f, -8.04265290e-02f, 7.34951496e-02f, -1.01780862e-01f, 8.85351822e-02f,
  3.09509486e-02f, 6.93197399e-02f, 8.31198040e-03f, 2.54571252e-02f, -6.35194257e-02f, 1.56666972e-02f, -5.58463810e-03f, 6.36299094e-03f, -4.34592478e-02f, 1.16621315e-01f,
  4.86676842e-02f, 3.30431424e-02f, -1.26478374e-01f, 7.58840665e-02f, -3.27246748e-02f, -6.82185739e-02f, -6.81694131e-03f, -5.14549799e-02f, -8.45988747e-03f, -3.61769050e-02f,
  -4.50166725e-02f, -5.19027337e-02f, -1.43002644e-01f, -1.88159216e-02f, -1.14071228e-01f, 1.26649095e-02f, -7.48804435e-02f, -1.28579689e-02f, -6.03869706e-02f, -3.81822325e-02f,
  1.72606949e-02f, -1.85432006e-02f, 8.17341208e-02f, 7.43501708e-02f, -8.80445838e-02f, 1.10867016e-01f, -4.72542271e-02f, -6.56642020e-02f, -1.58054665e-01f, -6.54790550e-02f,
  6.86132386e-02f, 3.62121463e-02f, 7.09230825e-02f, -1.72801223e-02f, 1.63255129e-02f, -5.39715774e-02f, 7.67767355e-02f, 1.37854576e-01f, -4.52731661e-02f, -1.48845306e-02f,
  9.34112892e-02f, 4.59795110e-02f, -8.33095089e-02f, -5.87127097e-02f, 6.32055849e-02f, -6.09925576e-02f, -3.13406140e-02f, 2.06395052e-02f, 1.47129998e-01f, 2.98599917e-02f,
  3.20132375e-02f, 3.19698602e-02f, -1.13472603e-01f, -1.10401526e-01f, 1.13232680e-01f, 5.21391369e-02f, 1.35070503e-01f, 9.09078028e-03f, -8.30057412e-02f, 2.01889221e-02f,
  1.03276357e-01f, 9.52424332e-02f, 6.55135885e-02f, -7.17044324e-02f, 7.53481165e-02f, -9.95595381e-02f, -8.22632853e-03f, -4.69782837e-02f, -7.76766464e-02f, 5.20140566e-02f,
  7.71011785e-02f, 6.14708625e-02f, 4.87003177e-02f, 5.64652830e-02f, -2.77238972e-02f, 6.31507635e-02f, -5.08271717e-02f, -1.17449343e-01f, -3.07714920e-02f, 1.12382911e-01f,
  -1.06903024e-01f, 3.51695903e-03f, 1.95479859e-03f, -3.95195223e-02f, -6.44068792e-02f, 4.75588217e-02f, 2.07230095e-02f, 3.97825949e-02f, 1.10373013e-01f, 3.98496427e-02f,
  5.78374341e-02f, 5.94230331e-02f, 7.64801577e-02f, 4.87145223e-02f, -2.53929291e-02f, 3.72228287e-02f, -4.83604409e-02f, -8.81903023e-02f, 5.43109886e-02f, -9.90282595e-02f,
  -3.41428630e-02f, -3.33090313e-02f, -1.90683641e-02f, -1.31598264e-02f, 5.75425252e-02f, -1.15374140e-01f, 5.56553639e-02f, 1.74618959e-02f, -6.97129294e-02f, 1.93962809e-02f,
  -8.23750794e-02f, -1.56328738e-01f, -3.63992341e-02f, -2.42128083e-03f, 7.78345168e-02f, -8.77252221e-03f, -2.43459661e-02f, 1.18746474e-01f, -2.07696497e-01f, 1.43470302e-01f,
  9.54047218e-02f, 1.33825675e-01f, -1.12498840e-02f, 1.13893859e-01f, 1.49420217e-01f, -4.74099256e-02f, 1.13546796e-01f, -7.37543777e-02f, -1.13762416e-01f, -5.09890430e-02f,
  -3.55564803e-02f, -4.25067060e-02f, -1.34460613e-01f, 1.24815218e-02f, -1.53858185e-01f, 1.01491854e-01f, 1.42016724e-01f, -7.90487230e-02f, 9.33889076e-02f, 4.48497497e-02f,
  7.72805735e-02f, -1.19653016e-01f, 2.13043112e-02f, 6.71593472e-02f, 2.30447650e-02f, -1.07454054e-01f, 1.23297073e-01f, -2.07305118e-01f, -5.62094338e-03f, 2.52157986e-01f,
  6.42492920e-02f, 1.19797893e-01f, 6.97387829e-02f, -1.65431406e-02f, 8.96634459e-02f, 1.05506435e-01f, -3.89686674e-02f, 5.26523180e-02f, 9.05472711e-02f, 1.32585317e-01f,
  3.11742034e-02f, -3.81941125e-02f, -2.06616908e-01f, 1.50749728e-01f, 7.20609352e-02f, -2.74854638e-02f, -7.88168982e-02f, 5.93849784e-03f, 1.44677656e-02f, 1.31768957e-01f,
  8.69155899e-02f, 5.95654100e-02f, -6.30609982e-04f, -1.32097617e-01f, 1.20585404e-01f, 8.36294442e-02f, 8.99162963e-02f, -1.36236429e-01f, -5.10277823e-02f, 1.48096681e-02f,
  -4.76495549e-02f, -1.80641573e-03f, -3.63765210e-02f, -4.72032204e-02f, 1.87487863e-02f, 9.26477313e-02f, -1.58207625e-01f, 9.46801901e-02f, -2.26290175e-03f, -1.71518605e-02f,
  -3.92931402e-02f, -6.42145872e-02f, -2.46029533e-02f, 7.88835064e-02f, 3.50347161e-02f, 5.15270717e-02f, -8.04959759e-02f, 7.00991824e-02f, 1.13138460e-01f, 1.46277575e-02f,
  5.50970212e-02f, -3.86199281e-02f, 3.85223664e-02f, 7.16295317e-02f, -5.65609057e-03f, -6.94916546e-02f, 3.78192849e-02f, 5.84312342e-02f, -1.19359978e-02f, -8.97780899e-03f,
  -4.55171317e-02f, -5.13254367e-02f, 9.54272449e-02f, -4.20587026e-02f, 4.99936938e-02f, 1.10882139e-02f, -5.73505275e-02f, -1.02089286e-01f, -3.32294740e-02f, 1.21269815e-01f,
  6.16348647e-02f, 4.95661423e-02f, -7.48224407e-02f, -1.73513163e-02f, -2.04824582e-02f, -3.18086222e-02f, -6.14066981e-03f, 5.83337024e-02f, -2.40992308e-02f, 2.64341254e-02f,
  -4.27813269e-02f, 6.05662763e-02f, -3.01231612e-02f, 7.68819377e-02f, -1.11530395e-02f, 3.30158919e-02f, -7.39483088e-02f, -1.34198265e-02f, 8.29988495e-02f, -6.26445841e-03f,
  5.02669923e-02f, -2.75590625e-02f, -1.05073228e-01f, 8.37777704e-02f, 4.47636060e-02f, -2.61985119e-02f, 2.21735463e-02f, -1.11826271e-01f, -2.71816608e-02f, -1.94653586e-01f,
  1.91902481e-02f, 1.01610981e-01f, -1.30264312e-01f, -2.27732910e-03f, -1.35797024e-01f, -1.88290328e-02f, -4.86887731e-02f, 8.15786123e-02f, -8.60963482e-03f, -3.03201154e-02f,
  8.88971016e-02f, 1.27451852e-01f, -3.91302593e-02f, 3.22185010e-02f, 1.09230369e-01f, 6.85535669e-02f, -1.23320222e-01f, 9.73370373e-02f, -1.59333423e-01f, 1.53183132e-01f,
  5.40273674e-02f, 8.05960561e-04f, -4.71499711e-02f, 3.97886448e-02f, -1.19278297e-01f, 2.74989810e-02f, 1.06119223e-01f, 1.09819107e-01f, 7.50354975e-02f, -1.06950626e-01f,
  1.83007065e-02f, 2.96519231e-02f, -8.00078269e-03f, 1.34382695e-01f, 6.33092374e-02f, -6.59697726e-02f, -9.32617188e-02f, 1.46707684e-01f, 1.02346450e-01f, 1.13920912e-01f,
  -6.17339090e-02f, 9.50655341e-02f, -6.37595728e-02f, 1.29382282e-01f, 8.65255892e-02f, 6.65204525e-02f, -4.77695540e-02f, 8.98660868e-02f, 4.62857373e-02f, -7.58252386e-03f,
  -7.14880377e-02f, 2.07228847e-02f, -6.63079098e-02f, 4.69233654e-02f, -5.24481200e-02f, -1.74212456e-02f, 5.58229871e-02f, -2.13445183e-02f, -5.44684604e-02f, 2.10112203e-02f,
  9.72689167e-02f, -1.30133762e-03f, -1.10032953e-01f, -9.99615788e-02f, -1.72667950e-02f, -1.53733507e-01f, 1.00709558e-01f, -6.68063611e-02f, -5.52721769e-02f, -6.79191798e-02f,
  7.31256679e-02f, -3.76600027e-02f, -7.00516801e-04f, 1.86767709e-02f, -6.43426646e-03f, 1.51478210e-02f, -3.48343179e-02f, -8.36076811e-02f, 6.76563308e-02f, 7.89299160e-02f,
  -2.64725219e-02f, -3.71215083e-02f, -4.98210900e-02f, -6.01757802e-02f, -9.12198722e-02f, -2.49715727e-02f, -2.87119374e-02f, 6.25706390e-02f, -2.45218463e-02f, -4.41143140e-02f,
  1.37883509e-02f, 6.98371083e-02f, 4.42989022e-02f, 6.77920729e-02f, 1.15951359e-01f, -8.35660696e-02f, 4.23009992e-02f, 7.55138621e-02f, 4.18325290e-02f, -5.76216839e-02f,
  2.28863806e-02f, -6.80058375e-02f, -3.11126746e-02f, 7.15169832e-02f, -1.80631373e-02f, 7.47450888e-02f, -8.81189033e-02f, 7.17446506e-02f, 5.75257838e-02f, -2.11631060e-02f,
  2.61549558e-02f, 3.77948061e-02f, -7.29880333e-02f, -5.84076159e-02f, 5.75949140e-02f, 5.24519309e-02f, -2.11999184e-04f, -8.91891569e-02f, -7.26367673e-03f, -3.00325640e-02f,
  -8.43708143e-02f, -7.58325756e-02f, -6.57660365e-02f, 9.82727623e-04f, 8.43216404e-02f, 1.30778570e-02f, -3.62985358e-02f, -1.18991891e-02f, 7.87940249e-02f, -7.28928298e-02f,
  -2.30447855e-02f, -3.94768342e-02f, -1.24813281e-02f, 2.61595212e-02f, -6.49385108e-03f, 7.53824553e-03f, -6.82309940e-02f, 2.59561706e-02f, -1.68534797e-02f, 2.52181999e-02f,
  -1.42444462e-01f, 1.03574499e-01f, -8.20002854e-02f, -7.85557777e-02f, 1.99288949e-02f, 1.60775129e-02f, -9.07361433e-02f, -5.40039651e-02f, 2.47799102e-02f, -6.98544160e-02f,
  5.25412755e-03f, -5.52312806e-02f, 6.95186108e-02f, 1.52629158e-02f, -5.49443737e-02f, 1.41263843e-01f, -6.36510644e-03f, -1.29108459e-01f, 1.28923178e-01f, -4.16834541e-02f,
  6.22513145e-02f, 6.42651916e-02f, 6.52644038e-02f, -3.11019234e-02f, 3.85337994e-02f, 1.03885494e-01f, 7.36925006e-02f, 3.71232652e-03f, -1.94193572e-02f, 6.61425069e-02f,
  -8.23026523e-02f, -6.12172717e-03f, -4.32796292e-02f, 3.42808627e-02f, 2.05095904e-03f, -1.53214661e-02f, -5.13086133e-02f, -9.10185799e-02f, 1.08570650e-01f, 7.27807730e-02f,
  -1.95923876e-02f, 5.10736629e-02f, 3.52795832e-02f, 2.39510555e-02f, -7.16994554e-02f, 3.20255682e-02f, -2.42486666e-03f, -7.89860636e-03f, -4.46949601e-02f, 5.08331731e-02f,
  8.72310326e-02f, 7.89195523e-02f, -7.50797763e-02f, 4.51002792e-02f, -3.82438228e-02f, -1.11028656e-01f, 3.67530733e-02f, 5.32098748e-02f, -7.19647016e-03f, 1.71126518e-02f,
  9.01324302e-02f, 4.48155403e-02f, -6.68606311e-02f, -1.91579983e-02f, 7.27144331e-02f, -2.51737703e-02f, 3.00439596e-02f, 1.85715687e-02f, 4.62710820e-02f, -7.71347582e-02f,
  -5.20878434e-02f, -1.00520933e-02f, 3.25380787e-02f, -1.97686795e-02f, -3.37813143e-03f, -2.58343313e-02f, -8.10957700e-03f, -1.01867743e-01f, -7.34069198e-02f, 8.69343281e-02f,
  -8.39671642e-02f, 6.79283170e-03f, -5.54406531e-02f, -4.36897762e-02f, -7.46417716e-02f, -2.20907796e-02f, -4.17310819e-02f, -5.80280237e-02f, -1.70087069e-01f, -3.22856829e-02f,
  -7.62098506e-02f, 3.46268080e-02f, 5.55479750e-02f, 9.43455026e-02f, -4.35685962e-02f, -2.59846374e-02f, -1.10582402e-02f, 3.56959999e-02f, -2.50074863e-02f, -1.24891371e-01f,
  1.02667496e-01f, -4.62859087e-02f, -7.71473721e-02f, -7.71626681e-02f, 3.82498205e-02f, -6.30815923e-02f, -1.16515078e-01f, 6.97587952e-02f, 7.15621794e-03f, -5.39739877e-02f,
  -4.92376983e-02f, 2.63694972e-02f, 3.46934125e-02f, 1.73463210e-01f, 8.56175572e-02f, -3.13325822e-02f, -3.88386450e-03f, -4.69345152e-02f, 1.85549632e-01f, -8.90152231e-02f,
  6.82557002e-02f, -2.67676711e-02f, -7.57166669e-02f, -2.87947785e-02f, 1.22708194e-01f, 7.80852064e-02f, -6.35996163e-02f, 9.56680700e-02f, -6.08481616e-02f, -7.61061087e-02f,
  2.80346945e-02f, 8.79696533e-02f, -3.50581296e-02f, 1.14453204e-01f, 1.87386665e-02f, -5.40908054e-02f, -6.76506246e-03f, 9.39987227e-02f, 6.82937130e-02f, -1.19455546e-01f,
  7.99779668e-02f, -1.30291924e-01f, -1.14048548e-01f, 1.23422481e-01f, -4.67397496e-02f, 1.45361841e-01f, 5.08037433e-02f, -4.18596435e-03f, -3.83071527e-02f, 9.70642567e-02f,
  9.49942693e-02f, 2.16426268e-01f, -1.39559716e-01f, 2.79497970e-02f, -1.17017724e-01f, 1.32271618e-01f, -1.76007897e-02f, 9.71007813e-03f, -1.57608077e-01f, -1.21123844e-03f,
  4.26647551e-02f, -9.43482891e-02f, 1.21407561e-01f, 7.52902701e-02f, 1.32839784e-01f, -6.97768107e-02f, 6.22207671e-02f, 6.73163384e-02f, 2.34336797e-02f, -1.10948332e-01f,
  4.52976190e-02f, -1.23133145e-01f, -9.29741561e-02f, -1.11977160e-01f, 1.45227939e-01f, 1.13722637e-01f, -3.44713777e-02f, 7.40845054e-02f, 8.66104215e-02f, 1.02528157e-02f,
  -5.24261128e-03f, 3.51234376e-02f, -1.35103106e-01f, -3.75048518e-02f, 8.73568133e-02f, -2.77686231e-02f, 3.22468393e-02f, 4.30660993e-02f, 3.38660218e-02f, -9.48366448e-02f,
  2.54098140e-02f, 4.98560742e-02f, 4.00823504e-02f, 6.84831068e-02f, -5.94802164e-02f, 8.12924355e-02f, 7.54536167e-02f, 3.19723669e-03f, -2.12530736e-02f, 2.92157941e-02f,
  4.46390323e-02f, 8.99260342e-02f, -6.03002645e-02f, -3.95382009e-02f, 4.52487543e-02f, 4.57430258e-02f, 8.89223069e-02f, -9.14539322e-02f, 7.06648827e-02f, -2.46464089e-02f,
  2.40778597e-03f, 4.36831862e-02f, 4.05149683e-02f, 1.20601587e-01f, 1.12693563e-01f, 5.80360740e-02f, -1.06312241e-02f, 5.72397299e-02f, 1.00561939e-01f, -6.11254349e-02f,
  2.17554737e-02f, -2.68672383e-03f, -3.06944530e-02f, 6.49451986e-02f, 6.89757839e-02f, -1.33281201e-02f, -1.00320289e-02f, 6.87255114e-02f, 3.05671282e-02f, 4.93076630e-02f,
  -5.17562442e-02f, -1.88349523e-02f, 1.79479644e-02f, -2.21607331e-02f, 5.32998256e-02f, 7.06442147e-02f, -2.65602837e-03f, -1.17358817e-02f, 6.36839792e-02f, 1.35328127e-02f,
  -4.85944189e-02f, 2.33068317e-02f, 5.09490306e-03f, -5.04410267e-02f, 1.04759283e-01f, 1.35858893e-01f, -1.18711457e-01f, 7.69402683e-02f, -5.37578315e-02f, -2.52510738e-02f,
  -3.51158269e-02f, 9.76401567e-02f, -7.63644278e-02f, -8.65708068e-02f, -2.82244515e-02f, -3.10186986e-02f, -1.36497483e-01f, 6.38326854e-02f, 1.42327145e-01f, -9.66015160e-02f,
  -5.00970930e-02f, 1.17468022e-01f, -7.20999464e-02f, 2.42042844e-03f, 5.49823493e-02f, 2.57610250e-02f, -7.51786754e-02f, 1.28069818e-01f, 4.62714816e-03f, -4.20944057e-02f,
  5.18370979e-02f, 2.06189215e-01f, 3.24593000e-02f, -8.92483070e-02f, 5.56138642e-02f, -7.37223253e-02f, 1.01643160e-01f, 1.24615319e-01f, 7.35968798e-02f, 4.73683514e-02f,
  -9.34204310e-02f, 5.65867163e-02f, -1.23101510e-01f, -7.61204283e-04f, -8.90969783e-02f, 1.42527014e-01f, -3.60763147e-02f, 8.52051098e-03f, -3.11040077e-02f, -1.33496628e-03f,
  -6.96671233e-02f, 5.55155389e-02f, 9.00120586e-02f, -5.55004105e-02f, 5.61398901e-02f, 5.41642271e-02f, -5.54489903e-02f, 1.72605012e-02f, -1.50067061e-02f, 1.03140958e-02f,
  -9.40193832e-02f, -6.69479892e-02f, -5.64688891e-02f, -1.14608094e-01f, 1.58531182e-02f, 1.88653148e-03f, -7.78057799e-02f, -1.25131169e-02f, -6.16276860e-02f, -6.82864264e-02f,
  1.37752267e-02f, -1.14130694e-02f, -6.14752322e-02f, 1.08573318e-01f, -8.07795450e-02f, -7.14800432e-02f, 4.50204350e-02f, -8.11170340e-02f, -3.42008099e-02f, 5.87462448e-02f,
  1.16325021e-02f, 2.21415199e-02f, -6.14946568e-03f, -1.02009019e-03f, 5.23404032e-02f, 1.83159336e-02f, 4.28196712e-04f, 4.61272858e-02f, 2.48511434e-02f, -5.37512191e-02f,
  -5.41451350e-02f, 6.02932274e-02f, -3.52711795e-04f, -3.22615802e-02f, 2.19963808e-02f, -1.28769219e-01f, -1.00689791e-01f, 4.45888983e-03f, -7.18282862e-03f, 3.40260640e-02f,
  -7.67912567e-02f, 6.17976375e-02f, -4.60426658e-02f, -9.26363766e-02f, 6.06700592e-02f, -7.04995766e-02f, -7.01393634e-02f, -3.14055644e-02f, 2.35761069e-02f, -2.53579281e-02f,
  -1.11306757e-01f, 8.19857568e-02f, -6.41064867e-02f, 5.68738952e-02f, -2.44159922e-02f, -1.51344249e-02f, -8.30101073e-02f, 4.35173251e-02f, -3.48577462e-02f, 7.42413253e-02f,
  -6.64992630e-02f, -1.16606958e-01f, -1.58726033e-02f, -1.00711145e-01f, -3.43189053e-02f, 3.79203516e-03f, -9.45451707e-02f, -3.83315943e-02f, -5.71770854e-02f, 2.21850947e-02f,
  2.89832838e-02f, -8.12703297e-02f, -1.12537257e-01f, -1.49940746e-03f, -2.38208044e-02f, 4.56241192e-03f, 8.47547427e-02f, 1.73028067e-01f, 1.37906179e-01f, 2.01239046e-02f,
  -1.73835307e-01f, -5.54742180e-02f, -1.37516186e-01f, 3.83771211e-02f, -5.99761866e-02f, 3.60364504e-02f, -1.37758479e-01f, 2.39555892e-02f, 1.73110627e-02f, 3.91139612e-02f,
  -1.24148019e-01f, 2.49159798e-01f, -1.49504378e-01f, -8.76458511e-02f, 4.43996862e-02f, 1.38701200e-01f, -1.33338824e-01f, -2.27046739e-02f, 1.47498231e-02f, -1.40055772e-02f,
  1.24850146e-01f, 7.94987008e-02f, 1.96718305e-01f, 1.23561881e-01f, 1.31391928e-01f, 5.14196344e-02f, -2.46827394e-01f, -1.04240499e-01f, 1.68914244e-01f, 7.07635432e-02f,
  1.25000119e-01f, -1.66250676e-01f, 4.95550707e-02f, 5.09008206e-02f, 8.05907473e-02f, 1.04522988e-01f, 6.49037436e-02f, 4.54827659e-02f, -6.83213696e-02f, 8.48879442e-02f,
  -9.28382427e-02f, -2.56818868e-02f, -6.94765523e-02f, -1.51318103e-01f, 2.05759611e-03f, 3.46509404e-02f, -3.52852233e-02f, 5.60724847e-02f, 5.36985882e-02f, 8.27228799e-02f,
  -1.00958504e-01f, -1.31343335e-01f, 8.75761360e-02f, -4.14223298e-02f, 1.84914410e-01f, 4.74021733e-02f, -2.20580865e-02f, 2.80451290e-02f, 5.29203117e-02f, 4.23084162e-02f,
  -2.99613252e-02f, 2.27083471e-02f, 1.98221183e-03f, 8.26250613e-02f, -3.47744040e-02f, 7.98349231e-02f, -8.25927258e-02f, -3.40676606e-02f, 3.67390364e-02f, 5.88534437e-02f,
  9.49913170e-03f, 4.01909761e-02f, 4.34959456e-02f, 1.44138029e-02f, 6.28983527e-02f, -8.73610005e-02f, -4.53331918e-02f, -1.19479243e-02f, -2.51891855e-02f, -2.80215144e-02f,
  -4.32425588e-02f, -1.44469691e-03f, -7.43698562e-03f, -7.73989707e-02f, -6.81019723e-02f, -1.17504308e-02f, 9.45608169e-02f, 3.25163268e-02f, -7.07491934e-02f, -5.90338297e-02f,
  -6.27394170e-02f, 1.44925704e-02f, -3.42278741e-02f, -1.68503784e-02f, -6.12698048e-02f, -2.52713878e-02f, 1.09430492e-01f, -3.13977413e-02f, 2.13522976e-03f, 1.26940813e-02f,
  9.44105629e-03f, 5.38242832e-02f, -9.91309294e-04f, 6.63338378e-02f, -4.84092832e-02f, 3.64516005e-02f, -2.76393201e-02f, -4.86058630e-02f, 2.41663624e-02f, 2.10043555e-03f,
  2.08649393e-02f, 7.36130178e-02f, -5.83257489e-02f, 7.38598406e-02f, -1.08909160e-01f, -1.19923323e-01f, 3.46516855e-02f, -6.59984797e-02f, 2.12346055e-02f, -1.26887802e-02f,
  -1.62785858e-01f, 1.02692805e-01f, -1.38797779e-02f, 5.16023813e-03f, 1.28588185e-01f, 6.43713996e-02f, -2.84530632e-02f, 1.20136924e-01f, -1.72126457e-01f, -4.53289656e-04f,
  -1.52917162e-01f, 8.28830618e-03f, -7.07848892e-02f, 3.94322351e-02f, -5.35193719e-02f, -5.50708249e-02f, -9.25629064e-02f, -6.97197840e-02f, -3.38813961e-02f, 1.66105196e-01f,
  -1.65831357e-01f, -1.96966946e-01f, -7.49532357e-02f, 5.80853894e-02f, -1.12123527e-01f, -1.12320282e-01f, -2.16898043e-02f, -4.07982841e-02f, 1.19081531e-02f, 1.78065558e-03f,
  3.48577797e-02f, 1.04994357e-01f, 1.34609595e-01f, -5.82670234e-02f, -2.03589156e-01f, -1.33220673e-01f, 2.09022000e-01f, 8.16524103e-02f, 1.23452470e-01f, -1.42901331e-01f,
  8.97813886e-02f, 6.63324222e-02f, 1.11524083e-01f, 1.09667026e-01f, 2.27888417e-03f, 7.39385486e-02f, -5.64456657e-02f, 4.53398190e-02f, -7.67771201e-03f, 2.62651350e-02f,
  -2.77505722e-02f, -5.48867472e-02f, 8.79375711e-02f, 4.76294197e-02f, -4.73839417e-02f, -2.34483592e-02f, -4.18499559e-02f, 1.46123357e-02f, -1.46002308e-01f, 2.01505907e-02f,
  4.19305041e-02f, 4.41856682e-02f, 1.71362162e-01f, 1.13332294e-01f, 4.29466106e-02f, 9.68197957e-02f, -3.79995890e-02f, 2.14291178e-02f, 4.18173037e-02f, -7.89853036e-02f,
  1.08258963e-01f, 1.76063627e-02f, -9.20864567e-02f, 3.68892960e-02f, 1.68339983e-02f, -4.79054488e-02f, -6.04531355e-02f, -8.08604583e-02f, -7.58184567e-02f, 2.40616724e-02f,
  -7.15688989e-02f, -6.50976002e-02f, -7.61679187e-03f, -9.74604189e-02f, -4.28178236e-02f, 9.70378295e-02f, 5.14525138e-02f, -5.86469024e-02f, -1.24805108e-01f, -6.95573762e-02f,
  6.46260455e-02f, 2.66999304e-02f, 4.11665365e-02f, 7.13198036e-02f, 2.49036457e-02f, -5.58144003e-02f, -7.16945902e-02f, 7.66651705e-02f, 1.02291293e-01f, 1.16140269e-01f,
  2.18469024e-04f, 6.41496629e-02f, -3.26580778e-02f, -4.06925082e-02f, -2.41131317e-02f, -7.78552890e-02f, -6.65617660e-02f, 9.92227197e-02f, 6.98500574e-02f, 1.37179168e-02f,
  6.82690516e-02f, -1.14908278e-01f, -4.07742225e-02f, -4.54641804e-02f, -3.55081297e-02f, 8.86535048e-02f, -2.83740219e-02f, -7.62615725e-02f, 1.13147460e-01f, -1.42184034e-01f,
  -1.25372842e-01f, -5.49690761e-02f, -1.15527973e-01f, 6.21781833e-02f, -9.05609429e-02f, 1.31385416e-01f, 1.87186003e-02f, 2.01195292e-02f, -1.86743475e-02f, 1.53245762e-01f,
  2.00521946e-02f, -7.11743440e-03f, 4.47516367e-02f, -8.60716701e-02f, -3.13519798e-02f, 1.63916182e-02f, 1.82686634e-02f, 6.53202757e-02f, 4.63580117e-02f, 1.13083599e-02f,
  -1.42980322e-01f, 1.71322495e-01f, 1.06867790e-01f, -1.06501296e-01f, 2.75097713e-02f, -8.49996954e-02f, -5.50420433e-02f, -1.08955957e-01f, 3.87283638e-02f, -1.51765108e-01f,
  -1.50487855e-01f, -1.60981834e-01f, -6.62189126e-02f, -1.75127462e-01f, -3.19234729e-02f, 2.43178144e-01f, -9.07871127e-02f, -7.93577135e-02f, -7.15021137e-03f, -4.78193536e-02f,
  1.62671238e-01f, 3.16582061e-02f, 6.07580058e-02f, 6.96958005e-02f, 1.44425398e-02f, 1.00961849e-01f, -7.72228986e-02f, 1.07324466e-01f, -2.41577141e-02f, 1.79775268e-01f,
  4.74792160e-02f, 5.42360581e-02f, -4.19200994e-02f, -2.78985817e-02f, 1.85297392e-02f, 1.27544954e-01f, 9.23928339e-03f, -1.55496877e-02f, -7.45620579e-02f, -5.36075234e-02f,
  -6.47638589e-02f, 1.06564745e-01f, 2.15780307e-02f, 4.21039388e-03f, -8.71866718e-02f, -6.56956509e-02f, -4.26585115e-02f, -1.68435872e-02f, 3.07569560e-02f, 7.92233273e-02f,
  -1.14302464e-01f, -1.37169221e-02f, -1.29453719e-01f, 7.72123598e-03f, -1.09040827e-01f, -9.45033506e-02f, -4.31159362e-02f, 1.18620381e-01f, 4.92711663e-02f, 8.06398913e-02f,
  2.64043156e-02f, 8.38849470e-02f, -8.31019040e-03f, 4.71643694e-02f, -7.07406700e-02f, 8.93159509e-02f, 5.67365177e-02f, 4.36982326e-03f, 1.81017835e-02f, -7.41903186e-02f,
  9.04147029e-02f, -4.59649749e-02f, -5.39635755e-02f, -7.16107571e-03f, 8.49589854e-02f, 2.36900244e-02f, 4.78946939e-02f, 1.27667069e-01f, -4.76407111e-02f, -4.05691341e-02f,
  -6.52718081e-05f, 8.09440669e-03f, -6.71291798e-02f, 9.61685553e-02f, 2.76910346e-02f, -2.86590140e-02f, 1.85365416e-02f, 7.11528137e-02f, 1.44576639e-01f, -5.14864288e-02f,
  -5.24606705e-02f, 6.03995621e-02f, -6.25313967e-02f, -4.25081141e-02f, 1.11764811e-01f, 5.83300926e-02f, -7.25132078e-02f, 7.59435399e-03f, -3.87728624e-02f, -9.83445533e-03f,
  -5.93273938e-02f, 4.01779152e-02f, -1.30119314e-02f, 4.88021523e-02f, -3.24964412e-02f, -2.22679153e-02f, 8.34345892e-02f, -3.75491977e-02f, 3.89332250e-02f, 2.76808860e-03f,
  1.04118861e-01f, 3.23411748e-02f, 3.18165086e-02f, -6.26460165e-02f, -1.41485184e-01f, -6.20138310e-02f, 6.09042263e-03f, 4.53924090e-02f, 5.63184768e-02f, 8.16265792e-02f,
  -3.56150307e-02f, -2.91812774e-02f, 2.12144442e-02f, -1.57133844e-02f, -6.60432428e-02f, 2.46899258e-02f, 7.76266605e-02f, -1.12929516e-01f, -7.41932690e-02f, -1.02842219e-01f,
  -8.10941458e-02f, 8.83035455e-03f, -6.82914257e-02f, -4.29143012e-02f, 3.07358559e-02f, -1.38431475e-01f, -4.06080857e-02f, -1.06016640e-02f, 4.65706624e-02f, 6.82826713e-02f,
  -3.67101841e-02f, 2.52746493e-01f, 1.70000345e-01f, -8.66317451e-02f, -1.59298524e-01f, -1.16942180e-02f, -6.52601384e-03f, 5.82572222e-02f, 7.14579523e-02f, 2.94230431e-02f,
  -1.85406115e-02f, -1.90533489e-01f, -5.60866147e-02f, -4.59388904e-02f, -4.26234007e-02f, 1.25678301e-01f, 6.28936738e-02f, -2.60179639e-02f, 3.65663916e-02f, -7.35322088e-02f,
  -1.19276129e-01f, 8.41203257e-02f, -1.28132388e-01f, -2.25980785e-02f, -6.42550811e-02f, -3.19746882e-02f, -2.79350467e-02f, -3.30715664e-02f, -6.44314438e-02f, 1.07569084e-01f,
  -3.06677283e-03f, 5.10688908e-02f, -4.96372469e-02f, -1.24285869e-01f, 7.40272105e-02f, -8.30996782e-02f, 6.78667799e-02f, 3.29973884e-02f, -6.84629828e-02f, -4.27387431e-02f,
  -3.53141800e-02f, 9.64527726e-02f, 8.99533331e-02f, 1.03002556e-01f, 9.84084234e-02f, -1.75390653e-02f, 8.59873928e-03f, -3.35371569e-02f, 6.19692653e-02f, 1.28437892e-01f,
  -4.57211211e-02f, 1.23333046e-02f, 8.67830366e-02f, -1.04896794e-03f, 5.40163554e-02f, -3.19408029e-02f, -4.45044152e-02f, 3.37008610e-02f, 4.16758060e-02f, 3.61736156e-02f,
  -2.59602536e-02f, -2.83890665e-02f, 4.44757156e-02f, 1.07140474e-01f, 1.08737759e-01f, -9.95014422e-03f, 4.63607982e-02f, -3.70552652e-02f, 5.52860089e-02f, 1.14147611e-01f,
  1.08897135e-01f, 9.98267531e-02f, -4.48642345e-03f, 2.96628829e-02f, 4.01026867e-02f, 7.54867643e-02f, -9.51443836e-02f, 4.80847917e-02f, -2.02343483e-02f, 4.06503957e-03f,
  5.31311892e-02f, 4.17617261e-02f, -1.84190441e-02f, -1.89142730e-02f, 3.93763892e-02f, -1.36562157e-02f, 3.38555016e-02f, 5.36164735e-03f, 4.55254242e-02f, 7.34923081e-03f,
  2.43161432e-02f, 6.11114688e-02f, -4.05548811e-02f, -8.16597790e-02f, 1.00948960e-01f, 3.38528454e-02f, -3.54161449e-02f, -4.11573127e-02f, 1.60202205e-01f, 7.50881508e-02f,
  -9.41712931e-02f, 2.84932298e-03f, 1.27782255e-01f, 2.03469396e-02f, 4.27977927e-03f, -4.61662933e-02f, 9.48737711e-02f, -6.37368262e-02f, -6.82109743e-02f, 1.75476018e-02f,
  -5.56256771e-02f, -1.77167222e-01f, 9.97710079e-02f, -1.89572200e-02f, 5.02568781e-02f, 2.34339386e-02f, 4.64784838e-02f, -1.16421796e-01f, 1.08667709e-01f, 1.75757140e-01f,
  4.71186191e-02f, 1.73340682e-02f, 1.52390182e-01f, -1.15741521e-01f, 1.44728184e-01f, 1.76809400e-01f, 4.84528579e-02f, -6.69808760e-02f, 1.54974058e-01f, -2.67740805e-02f,
  5.43426862e-03f, -3.47380079e-02f, 2.08240859e-02f, -1.07093249e-03f, 1.33836186e-02f, -6.69967160e-02f, 4.47062738e-02f, 1.10457160e-01f, 1.29753917e-01f, 1.78486332e-01f,
  -9.29614753e-02f, 1.76242627e-02f, -1.14786498e-01f, -5.78860659e-03f, -1.39259428e-01f, 2.75126938e-02f, -1.13368249e-02f, -3.67305540e-02f, 2.98268385e-02f, -1.27552301e-02f,
  -7.82678425e-02f, -8.36577937e-02f, 1.53082386e-01f, 8.84589478e-02f, 7.89347291e-03f, -6.26706257e-02f, 8.48246552e-03f, -3.85116413e-02f, -3.02791339e-03f, -2.64347009e-02f,
  -8.93859491e-02f, 1.57755762e-02f, 6.65878803e-02f, 1.46634001e-02f, -1.22546494e-01f, -8.32357779e-02f, -1.24188088e-01f, -9.55542251e-02f, 1.05481446e-02f, -4.64984477e-02f,
  -8.04295465e-02f, -6.03502896e-03f, 6.92786649e-02f, -4.08611372e-02f, 7.32482299e-02f, 3.26312073e-02f, 5.77664599e-02f, 1.67717505e-02f, 8.33523348e-02f, 3.00759487e-02f,
  8.62402767e-02f, -1.83585119e-02f, 4.60255891e-03f, 2.19739266e-02f, 8.24020579e-02f, -3.77049036e-02f, -1.02388963e-01f, 6.12060130e-02f, 1.30739316e-01f, 1.62920088e-01f,
  -8.35765004e-02f, 8.74263860e-05f, 3.08256187e-02f, -5.49511090e-02f, 5.05241472e-03f, 1.89800933e-02f, 5.27151451e-02f, -3.18743102e-02f, -8.33311751e-02f, -6.33012727e-02f,
  -3.35803209e-03f, 9.28094611e-02f, 4.23879288e-02f, -5.75914495e-02f, 2.50512250e-02f, 5.56410626e-02f, 6.82156906e-02f, -1.70960441e-01f, 1.84631422e-02f, -9.35928375e-02f,
  -4.88828309e-02f, 9.42623988e-03f, 6.43544570e-02f, 1.08410031e-01f, 1.48739209e-02f, -1.59735270e-02f, -6.30152822e-02f, -1.67858098e-02f, 5.75245433e-02f, 6.67477772e-02f,
  5.82183003e-02f, -4.31947485e-02f, -7.27474391e-02f, 6.00904860e-02f, 6.13397099e-02f, 3.62172201e-02f, -5.87167889e-02f, 1.01704277e-01f, -1.44340977e-01f, 1.12287030e-01f,
  -1.01428732e-01f, -7.06816539e-02f, -7.07909092e-03f, 2.09200189e-01f, -7.68996626e-02f, -2.98730694e-02f, 6.30193949e-02f, 2.23692078e-02f, -1.48270100e-01f, 3.86527255e-02f,
  -5.56502417e-02f, -3.36101614e-02f, -1.10075483e-02f, -5.25305569e-02f, -1.30011320e-01f, 1.34115025e-01f, 1.43192992e-01f, -2.82705314e-02f, -3.10045406e-02f, 1.63819958e-02f,
  7.01249540e-02f, 3.91907617e-02f, 9.14971754e-02f, -5.76987937e-02f, 5.52297523e-03f, -1.88411754e-02f, -3.25408950e-02f, -1.23726040e-01f, 3.87027077e-02f, 1.82060882e-01f,
  1.07779697e-01f, 9.18103755e-02f, 1.97235923e-02f, -1.32449633e-02f, 1.50485605e-01f, 1.50655359e-01f, -6.72194734e-02f, 5.13974093e-02f, 4.05190475e-02f, 1.85515225e-01f,
  -6.58936612e-03f, 3.62246335e-02f, -1.98523790e-01f, 1.43895864e-01f, 1.11083470e-01f, 4.38510291e-02f, 1.01875223e-01f, -2.04967596e-02f, 1.41134664e-01f, 1.38118818e-01f,
  1.01263769e-01f, 8.69033113e-02f, -8.39723926e-03f, 6.62582442e-02f, 9.02465731e-02f, 2.94599961e-02f, 2.29052640e-02f, 2.96490844e-02f, -4.49834615e-02f, 1.48305325e-02f,
  -5.01503088e-02f, -1.47203431e-01f, -9.29215178e-02f, -5.61873429e-02f, -7.36344829e-02f, 8.12107921e-02f, -9.80566964e-02f, -8.14198405e-02f, -1.14403322e-01f, 5.20604514e-02f,
  -3.94294504e-03f, -2.39572451e-02f, 8.97518024e-02f, -2.31595933e-02f, -1.21660335e-02f, -1.00281844e-02f, -8.29126090e-02f, -6.43262863e-02f, 1.03084199e-01f, -6.38096705e-02f,
  -5.72294444e-02f, 2.96093319e-02f, -4.33927476e-02f, 8.19396880e-03f, -1.57783963e-02f, 1.78072043e-02f, 3.68850008e-02f, 5.23003563e-03f, -5.15247956e-02f, -4.67716940e-02f,
  -5.59405349e-02f, 2.07047537e-02f, -3.11151985e-02f, -7.84401502e-03f, 6.37025908e-02f, -3.48385680e-03f, 2.21630763e-02f, -9.77809727e-02f, -1.11141235e-01f, 4.04639468e-02f,
  4.37016040e-03f, 3.80347520e-02f, -4.43196483e-02f, -4.37630862e-02f, -3.06727402e-02f, -3.98857258e-02f, -5.36838286e-02f, -4.82116416e-02f, 5.19397780e-02f, 4.93379235e-02f,
  1.13642469e-01f, 3.77050461e-03f, -1.15419421e-02f, -2.52634659e-02f, -7.67908916e-02f, 2.56905369e-02f, 1.88928563e-03f, -7.83481747e-02f, 5.08641042e-02f, -1.33769447e-02f,
  3.89269851e-02f, -1.05551705e-02f, -5.64045869e-02f, -2.19981167e-02f, -3.48550803e-03f, 1.80062696e-01f, 6.87664747e-02f, 4.62724268e-02f, -3.47636305e-02f, -6.94253370e-02f,
  1.21052928e-01f, 1.30244389e-01f, 5.81717007e-02f, 4.82045151e-02f, -3.73908803e-02f, -7.50831440e-02f, -8.76267105e-02f, 3.08127273e-02f, -3.63885127e-02f, 3.86547931e-02f,
  1.05914138e-01f, -1.43651620e-01f, -5.95741309e-02f, 1.31389320e-01f, 1.93996832e-01f, -5.03424043e-03f, -9.85035971e-02f, -1.20237380e-01f, 2.44231448e-02f, -1.21857308e-01f,
  -1.80125441e-02f, -2.49364246e-02f, -3.18158604e-02f, 4.85900193e-02f, -1.03699088e-01f, 1.33017197e-01f, 1.18724555e-01f, 1.31080687e-01f, -4.21705209e-02f, -1.00274727e-01f,
  -3.83739136e-02f, -6.19601719e-02f, 1.06499523e-01f, 1.16288982e-01f, 2.15493105e-02f, -6.35764981e-03f, -7.21788332e-02f, -1.60278771e-02f, -1.11575909e-01f, 1.05666801e-01f,
  -1.09294511e-01f, 1.37340054e-01f, 1.03595190e-01f, 1.24412186e-01f, -1.39734577e-02f, -1.06189556e-01f, 4.22857068e-02f, 3.53189334e-02f, 1.70427412e-02f, -8.31983462e-02f,
  -2.36550979e-02f, -1.88171361e-02f, 4.28744629e-02f, 8.55013877e-02f, 2.92595085e-02f, -1.29442308e-02f, 3.95233259e-02f, -9.37511399e-02f, 3.49528193e-02f, -5.85076399e-04f,
  1.69203244e-02f, 1.36102885e-01f, -3.63218635e-02f, -3.20265777e-02f, -6.61813244e-02f, -1.12771951e-01f, -1.41999274e-01f, -3.57810520e-02f, 8.74337927e-02f, 5.18872663e-02f,
  -2.00402783e-03f, -7.89024979e-02f, 2.56310198e-02f, -4.60260641e-03f, -1.83409620e-02f, 3.77789736e-02f, 1.02520332e-01f, 8.13878849e-02f, -9.14918780e-02f, -3.09752375e-02f,
  -4.05172296e-02f, -6.55840337e-02f, 1.91631131e-02f, 6.92419186e-02f, 5.98917296e-03f, 2.07479205e-02f, 1.00193404e-01f, 1.92680564e-02f, -1.05359945e-02f, -6.90524131e-02f,
  -5.08018117e-03f, -5.51373092e-03f, 4.12638262e-02f, 7.30018830e-03f, 1.69102363e-02f, 3.39030661e-02f, 9.73328575e-02f, 4.42596413e-02f, 1.18856216e-02f, 4.34528254e-02f,
  -6.55508339e-02f, -8.89140442e-02f, -6.14353828e-02f, -5.95069341e-02f, -8.82175192e-02f, -3.84699740e-02f, 9.13413987e-02f, -5.67129701e-02f, 6.18205890e-02f, -3.92670184e-02f,
  -7.71476030e-02f, 1.23285294e-01f, -5.74564077e-02f, -1.61082149e-02f, 6.08828217e-02f, 9.42832883e-03f, -8.23812485e-02f, -6.07559644e-02f, 6.66197315e-02f, 6.67584389e-02f,
  -2.03168299e-02f, -5.82807371e-03f, -1.33982703e-01f, -1.16187029e-01f, 7.85710663e-02f, 3.22683044e-02f, 1.71749443e-02f, 4.08465303e-02f, -5.97470887e-02f, -1.24051236e-03f,
  -3.62246260e-02f, 8.40755850e-02f, 5.37606925e-02f, 5.86502291e-02f, -8.57487097e-02f, -7.15632290e-02f, 4.21983190e-02f, 1.81338582e-02f, 3.96191664e-02f, 1.27424106e-01f,
  -7.25906249e-03f, 5.92027903e-02f, -1.46278873e-01f, -6.35194257e-02f, -5.69468588e-02f, -6.15030117e-02f, 5.88883124e-02f, 1.07454598e-01f, -1.78044096e-01f, 1.90130412e-03f,
  -1.05202593e-01f, -1.14728071e-01f, 6.83507174e-02f, -1.11296497e-01f, -4.96363752e-02f, -1.34068370e-01f, -6.82181306e-03f, -3.02620977e-03f, 5.30210622e-02f, 3.47995833e-02f,
  -1.02058090e-01f, -1.28651917e-01f, -1.13896184e-01f, -1.12134807e-01f, 1.88155845e-02f, -2.16080826e-02f, 1.19382694e-01f, -1.51325792e-01f, 1.26313165e-01f, 2.68515628e-02f,
  -1.14304662e-01f, -1.57653186e-02f, 1.60214200e-03f, 1.55712115e-02f, -7.77490810e-02f, -3.55011448e-02f, -6.94035087e-03f, -5.12548760e-02f, -3.33024561e-03f, -7.47779831e-02f,
  -4.58510667e-02f, -1.01302460e-01f, -1.00508733e-02f, -4.68780771e-02f, -1.99299064e-02f, 9.55714509e-02f, -6.90308809e-02f, -4.63641435e-02f, -1.07833780e-01f, -6.47397563e-02f,
  1.08447447e-01f, 8.14792812e-02f, 9.14093852e-02f, -9.37537774e-02f, 1.50334656e-01f, -1.34061053e-01f, -7.42049813e-02f, 4.77056354e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  2.42388658e-02f, -6.43524900e-02f, -2.79029328e-02f, -2.05279142e-03f, -4.32816222e-02f, -9.59600229e-03f, -1.88789133e-03f, -7.78032048e-03f, -2.79183071e-02f, -6.39190972e-02f,
  -8.16110149e-03f, 7.71542415e-02f, 1.12795262e-02f, -5.25419191e-02f, 3.49701867e-02f, -3.93449627e-02f, -2.94121858e-02f, 7.45556056e-02f, 2.52417848e-02f, 3.60055678e-02f,
  -3.20271775e-02f, -3.77005935e-02f, -5.56825399e-02f, 3.39972116e-02f, 1.52896605e-02f, -8.15357938e-02f, -6.73404112e-02f, 7.14821592e-02f, -6.13664761e-02f, 6.98736608e-02f,
  -1.69877335e-02f, -7.39535615e-02f, -4.97872457e-02f, 3.35526951e-02f, -2.34227089e-04f, -3.19774053e-03f, 2.79740384e-03f, -7.86114484e-03f, -5.12920171e-02f, -5.99982105e-02f,
  -1.25683565e-02f, -1.38111375e-02f, 5.75532578e-02f, -5.86913601e-02f, 7.69221634e-02f, -2.43062545e-02f, -1.50244096e-02f, 7.85168484e-02f, 6.62747305e-04f, -6.97924476e-03f,
  1.68826450e-02f, 4.97146919e-02f, 5.59013709e-03f, -4.68504289e-03f, 2.83826981e-02f, 6.23152815e-02f, 4.50559817e-02f, -7.98439160e-02f, -1.90422349e-02f, 6.24898821e-02f,
  1.14456117e-02f, 9.80431563e-04f, 3.66654880e-02f, 1.60634797e-02f, 7.67574832e-02f, 8.55340809e-02f, 6.64182678e-02f, 2.51184031e-02f, 6.65705949e-02f, -2.02078968e-02f,
  -5.44824004e-02f, -6.06810190e-02f, 2.38152239e-02f, -3.78683060e-02f, 2.07543280e-02f, 7.92903826e-02f, 3.45696905e-03f, 6.47762939e-02f, -3.94564457e-02f, -4.82292175e-02f,
  -2.39305217e-02f, -1.04075028e-02f, -4.49525677e-02f, -2.43121255e-02f, -6.68669268e-02f, -8.77277404e-02f, 9.17507857e-02f, 4.95471098e-02f, -1.07868416e-02f, -4.48406767e-03f,
  8.65305811e-02f, 7.20785260e-02f, 6.24473579e-02f, -5.80208637e-02f, 1.85312741e-02f, -2.29794402e-02f, -6.38559014e-02f, -1.77026770e-04f, -3.32157537e-02f, -4.39089239e-02f,
  -7.36425444e-02f, 7.98777565e-02f, -9.00522768e-02f, 4.46971729e-02f, -4.30283770e-02f, 6.67393282e-02f, 4.94213887e-02f, -2.50294339e-02f, -3.26187499e-02f, -6.58974573e-02f,
  -7.65225068e-02f, 7.30683729e-02f, -3.93905826e-02f, 4.91798706e-02f, 5.29272929e-02f, 1.55187920e-02f, -7.86271393e-02f, -8.37414898e-03f, -3.29069868e-02f, -8.27267915e-02f,
  -5.72515912e-02f, -8.01718459e-02f, 5.06518185e-02f, 6.52272925e-02f, 7.53061697e-02f, -6.29931986e-02f, 6.20033517e-02f, 6.43697903e-02f, 1.30624712e-01f, 4.09245454e-02f,
  8.17645565e-02f, -9.56147909e-04f, 8.20978805e-02f, 2.77981651e-03f, 9.70089957e-02f, -4.89215693e-03f, 7.18644783e-02f, -4.44710581e-03f, -3.94349638e-03f, 4.98654656e-02f,
  5.62552549e-02f, 8.15597996e-02f, 1.06005818e-01f, 8.27372670e-02f, -1.88322738e-02f, -9.23740398e-03f, 6.10817224e-02f, 4.00755852e-02f, -1.57516245e-02f, -2.15469114e-02f,
  -3.41888401e-03f, 1.09094821e-01f, -1.80317480e-02f, 5.54577308e-03f, 8.71024951e-02f, -4.43465523e-02f, 1.17177574e-03f, 5.51888049e-02f, 1.15393735e-01f, 7.14030932e-04f,
  -5.74265718e-02f, 8.06255490e-02f, 5.61032370e-02f, -6.05591461e-02f, -2.69491342e-03f, 1.22773580e-01f, -4.41090055e-02f, 1.37233688e-02f, -5.37968613e-03f, 1.72551498e-01f,
  1.96040943e-02f, -3.19631957e-02f, -3.76502909e-02f, 1.06804147e-02f, -5.42843416e-02f, 1.24954842e-02f, 1.24979734e-01f, -1.13572311e-02f, 6.88337460e-02f, -6.64926041e-03f,
  -1.84259951e-01f, -1.45736560e-01f, -1.13915587e-02f, 1.15890101e-01f, -1.27336845e-01f, 8.88952427e-03f, -5.79916462e-02f, 6.97737113e-02f, -1.76206604e-01f, 9.18620452e-02f,
  -2.85438332e-03f, 5.64319231e-02f, 7.55552351e-02f, -7.57238269e-03f, 4.28735055e-02f, -2.21305285e-02f, -8.01131055e-02f, 7.98867792e-02f, 3.90543342e-02f, 9.51130018e-02f,
  -1.26845285e-01f, 1.07581038e-02f, -1.72265768e-02f, -4.91559394e-02f, -4.49170023e-02f, 1.16282320e-02f, -9.28316712e-02f, -3.90944518e-02f, -1.51868910e-01f, 4.83740717e-02f,
  -1.36834443e-01f, -6.32551014e-02f, -7.02051818e-02f, 5.09972777e-03f, 1.11580670e-01f, 8.98794234e-02f, -2.78685912e-02f, 1.60103306e-01f, 6.30708411e-03f, -9.98112708e-02f,
  -1.72435418e-01f, -3.97436060e-02f, 8.54798332e-02f, -7.68971667e-02f, 1.60734653e-01f, -1.16113350e-01f, 9.04484540e-02f, 4.95505184e-02f, -1.01603540e-02f, -2.55767629e-02f,
  4.20112722e-02f, -1.55950608e-02f, -7.38164186e-02f, 3.74081321e-02f, -1.00793831e-01f, -6.41846238e-03f, 1.32877409e-01f, -5.08715436e-02f, 4.31524292e-02f, 6.63144290e-02f,
  -2.18579452e-02f, 5.43047264e-02f, -4.07518409e-02f, 1.39842451e-01f, -1.43127054e-01f, 8.46381858e-02f, 1.10483607e-02f, -9.81091335e-02f, 1.31213129e-01f, 8.34588185e-02f,
  2.40941555e-03f, -1.09267242e-01f, 6.59529045e-02f, -9.04482380e-02f, 5.55191822e-02f, 1.90946471e-03f, 7.68231153e-02f, -6.08201697e-02f, 4.17981185e-02f, -4.43703197e-02f,
  -1.15107640e-03f, 3.21012288e-02f, 7.21889585e-02f, -4.51797098e-02f, -6.19575009e-02f, -5.24773821e-02f, 3.41239087e-02f, 5.09957895e-02f, 9.01804268e-02f, -3.24376561e-02f,
  -1.06960069e-02f, -7.88794532e-02f, -2.13399045e-02f, -6.69132546e-02f, 5.43449298e-02f, -4.23524380e-02f, -6.49217516e-02f, 7.62837415e-04f, -8.25956464e-02f, -4.89227474e-02f,
  -3.94347943e-02f, -2.33142928e-04f, -7.85172656e-02f, -3.39146294e-02f, -6.11170232e-02f, -3.17170992e-02f, 4.61441055e-02f, -2.79900078e-02f, 5.68675576e-03f, -4.55767848e-02f,
  1.46266269e-02f, 2.71510333e-02f, 3.06222718e-02f, -3.14123780e-02f, 5.55007160e-02f, -2.97583714e-02f, -3.12083382e-02f, 8.62782646e-04f, 6.28168210e-02f, -2.31721550e-02f,
  7.10858554e-02f, -2.60752160e-02f, 7.86371678e-02f, -1.32920314e-02f, -8.09028223e-02f, -4.27351259e-02f, -7.07919672e-02f, 3.16350870e-02f, 6.77410439e-02f, 3.20789553e-02f,
  -4.99026515e-02f, 4.64504864e-03f, -5.96800596e-02f, 6.31103516e-02f, -2.55739037e-02f, 1.47223491e-02f, -5.78678660e-02f, -1.76819542e-03f, 2.43852697e-02f, 7.56971464e-02f,
  -7.28415400e-02f, 6.54902235e-02f, 4.95873131e-02f, -8.40735808e-02f, -6.41029403e-02f, 3.99399810e-02f, -5.83441816e-02f, 4.36409935e-03f, 5.70040494e-02f, 3.35082412e-02f,
  -3.87456715e-02f, -7.47439126e-03f, -2.61532571e-02f, -7.85443839e-03f, 6.02941513e-02f, 5.75661808e-02f, 5.74042462e-02f, 6.73678890e-02f, -2.67852303e-02f, -6.41616210e-02f,
  8.18657130e-02f, 6.50415123e-02f, 3.81687284e-02f, 8.81992877e-02f, 3.02528944e-02f, 2.68277042e-02f, 1.48020769e-02f, -1.22283251e-04f, -3.71608250e-02f, -2.64540687e-02f,
  -1.74964350e-02f, 7.41548464e-02f, -1.03729423e-02f, -2.52832379e-02f, -5.66943884e-02f, -3.32840569e-02f, 3.16953138e-02f, 5.62238656e-02f, 6.51416481e-02f, 3.73640060e-02f,
  -7.50345737e-02f, 3.83810885e-02f, 8.66755694e-02f, -2.31429394e-02f, -7.10834339e-02f, 1.13804098e-02f, 8.54574740e-02f, 6.96808323e-02f, 4.83295210e-02f, 5.50372759e-04f,
  -6.78217858e-02f, 3.98626737e-02f, 4.25617993e-02f, -5.39436424e-03f, -1.99959185e-02f, -7.82458037e-02f, -3.55092362e-02f, 3.30256857e-02f, -8.21510777e-02f, 2.06246562e-02f,
  5.65670058e-02f, -8.89855027e-02f, 2.61784177e-02f, 1.39783388e-02f, -6.71505630e-02f, 7.89091364e-03f, 3.55282007e-03f, -8.24697316e-02f, -6.69349357e-02f, -1.87327061e-02f,
  -6.76165223e-02f, 7.53658786e-02f, 7.45369345e-02f, -7.19152391e-02f, -4.24973741e-02f, -6.52922094e-02f, 7.46234581e-02f, 6.30492403e-04f, 8.94437730e-02f, 1.55119700e-02f,
  -5.99408224e-02f, 5.45614250e-02f, -7.45094046e-02f, 7.94738084e-02f, 5.21359919e-03f, -5.35879098e-02f, -6.23640008e-02f, 9.23505351e-02f, 9.59864855e-02f, -4.74105477e-02f,
  7.72976317e-03f, 1.07790679e-01f, -6.76478520e-02f, -6.18969463e-02f, -8.08481574e-02f, 5.71284965e-02f, -7.90748447e-02f, -6.73062727e-02f, 2.44108797e-03f, 6.54151663e-02f,
  -1.92818362e-02f, 1.74134579e-02f, -6.14468306e-02f, 1.80054866e-02f, -2.16388404e-02f, 2.45939251e-02f, 7.42192864e-02f, -4.48064432e-02f, 8.81266445e-02f, -2.45785322e-02f,
  1.47431875e-02f, 8.45743939e-02f, 3.64835486e-02f, 7.46273175e-02f, -8.02455191e-03f, -9.10559967e-02f, -2.35362574e-02f, -1.65240876e-02f, 2.23038718e-02f, 7.73241743e-02f,
  1.48372715e-02f, 8.60899910e-02f, 3.75497085e-03f, 1.97871998e-02f, -7.94361085e-02f, 8.04867223e-02f, -5.89696951e-02f, -1.28081413e-02f, -7.75934160e-02f, 6.47273064e-02f,
  9.49541479e-02f, 1.91195458e-02f, 8.68542641e-02f, -2.83381417e-02f, 2.55493373e-02f, 5.96834756e-02f, -3.88947427e-02f, 2.67227534e-02f, -5.07025942e-02f, 2.19356455e-02f,
  5.45060784e-02f, 2.18686908e-02f, 7.75654847e-03f, -1.08014114e-01f, 4.57119085e-02f, 2.90342774e-02f, 2.50252206e-02f, -1.63288824e-02f, -2.36815140e-02f, 1.95994396e-02f,
  2.67787874e-02f, 4.75112535e-02f, -2.72773504e-02f, -4.24064249e-02f, -1.02029210e-02f, 8.78918637e-03f, 9.88794640e-02f, 1.37142390e-02f, 2.07576565e-02f, 2.85393276e-06f,
  -3.28457654e-02f, 6.31323382e-02f, -3.40126939e-02f, -5.15494645e-02f, -1.04967594e-01f, -3.78784463e-02f, -2.23653000e-02f, -5.42722605e-02f, -6.28218353e-02f, -7.20204338e-02f,
  7.39660189e-02f, -4.91469502e-02f, -6.83935732e-02f, 1.73756201e-02f, -3.94934006e-02f, 8.26414600e-02f, -8.74811634e-02f, -7.42500275e-02f, -5.38413301e-02f, -7.43216500e-02f,
  7.04133362e-02f, -3.59281749e-02f, 6.21296577e-02f, -1.51341343e-02f, 3.38104703e-02f, 1.08778598e-02f, -6.85170665e-02f, -1.89892799e-02f, 1.40413176e-02f, 8.37168917e-02f,
  5.18893823e-02f, -4.75537553e-02f, 7.34903812e-02f, -3.98542844e-02f, -7.16998130e-02f, 6.03611805e-02f, -4.48704362e-02f, 1.08265564e-01f, 6.38105050e-02f, 2.57629864e-02f,
  1.62945781e-02f, 8.59280825e-02f, 6.88891765e-03f, 2.42970586e-02f, 1.47322938e-02f, 7.08928853e-02f, 3.54277678e-02f, 7.84408674e-02f, 5.56505397e-02f, 5.20601869e-02f,
  1.26188202e-02f, 6.93521053e-02f, -1.85151100e-02f, 8.43936279e-02f, 5.41574769e-02f, -4.23388109e-02f, 1.12938635e-01f, 2.61082761e-02f, 3.90142798e-02f, 5.51363491e-02f,
  -3.45675200e-02f, 9.75279361e-02f, -3.36787328e-02f, 8.50459188e-02f, -8.59603956e-02f, 5.22978837e-03f, 1.20694572e-02f, -2.07025800e-02f, 5.07091731e-02f, 7.17402529e-03f,
  6.08879514e-02f, 1.00770302e-01f, -6.86598718e-02f, 3.37707973e-03f, -9.47343633e-02f, 4.38357033e-02f, 9.06297639e-02f, 2.48789247e-02f, 1.23444935e-02f, 4.23429757e-02f,
  -4.47298102e-02f, 3.58769149e-02f, -8.08887333e-02f, 5.65633038e-03f, -9.20172036e-02f, 4.70042713e-02f, -6.45049140e-02f, 1.99646726e-02f, -9.40183760e-04f, -4.19763476e-02f,
  -1.19674332e-01f, 1.52567895e-02f, -4.04201858e-02f, 2.59036068e-02f, 4.71340567e-02f, -5.18571883e-02f, 4.92638797e-02f, 8.10667723e-02f, 8.01587254e-02f, -7.37372367e-03f,
  -4.78947982e-02f, 1.20889090e-01f, 9.44681615e-02f, 1.34362448e-02f, -2.49553588e-03f, 1.01741560e-01f, -3.73422578e-02f, -3.07611376e-02f, -9.20775235e-02f, 9.92981270e-02f,
  1.19748721e-02f, -9.05635580e-03f, -6.54091090e-02f, -3.07766870e-02f, -8.19818154e-02f, -7.47001693e-02f, -8.18722770e-02f, 1.70300417e-02f, -5.27743101e-02f, -6.23422116e-02f,
  -1.87900774e-02f, 4.61970037e-03f, -8.84703422e-06f, 6.27602935e-02f, 5.30274063e-02f, 4.20084819e-02f, 5.49748577e-02f, 3.17415334e-02f, 1.22234650e-01f, -9.05566067e-02f,
  -7.77915865e-02f, -5.25158718e-02f, 5.08706607e-02f, 1.61758512e-02f, 1.06904820e-01f, -7.17803612e-02f, -1.65276174e-02f, 1.11424431e-01f, 6.96705505e-02f, 5.38808033e-02f,
  1.13431737e-01f, -3.19302790e-02f, -4.96410914e-02f, -7.19268993e-02f, 4.26830351e-02f, 5.25826141e-02f, 7.99410269e-02f, 9.98885557e-02f, -7.53229111e-02f, -6.80595040e-02f,
  -8.36000443e-02f, 2.55019683e-03f, -7.02243671e-02f, 9.60172862e-02f, 7.68863335e-02f, -6.38365448e-02f, -4.98769544e-02f, -1.14806652e-01f, 5.75992651e-03f, 8.11007842e-02f,
  -3.94350733e-04f, -4.32384014e-02f, 6.08461462e-02f, -4.57529202e-02f, 8.04772079e-02f, -6.26717582e-02f, 8.42207521e-02f, 1.70678739e-02f, -8.32898393e-02f, 3.90255786e-02f,
  6.41593635e-02f, -4.57945950e-02f, 8.84131044e-02f, -6.98866844e-02f, 4.98307794e-02f, 8.86360928e-03f, 4.76837382e-02f, 6.16399311e-02f, -1.95078980e-02f, 3.45928445e-02f,
  -8.53915215e-02f, 6.33186921e-02f, 4.33606394e-02f, 4.95326705e-02f, -4.27405871e-02f, -9.04672220e-02f, -1.92106068e-02f, -5.13632968e-02f, -7.07206428e-02f, -1.41363582e-02f,
  -6.66971207e-02f, -9.15163010e-02f, -2.72620078e-02f, 6.98679015e-02f, 8.30922201e-02f, 3.74344923e-02f, 1.42690949e-02f, 4.46649492e-02f, -7.61076659e-02f, -8.24880600e-02f,
  3.04003637e-02f, -1.18901104e-01f, -2.24155583e-03f, -2.05541290e-02f, -5.21262102e-02f, -4.78081964e-02f, 3.49091068e-02f, 3.62559780e-02f, 4.13530543e-02f, 6.22190647e-02f,
  -2.85526365e-02f, -7.91439414e-02f, 1.98708903e-02f, -3.18369046e-02f, -5.47471456e-03f, -1.81692131e-02f, -3.49119748e-03f, 1.05499417e-01f, -1.84948053e-02f, -9.67206955e-02f,
  -2.46549137e-02f, 1.10649532e-02f, -1.43107362e-02f, -6.30780235e-02f, -3.49037461e-02f, -9.05786455e-02f, 6.56643659e-02f, -9.59626734e-02f, 5.88109978e-02f, -5.58848754e-02f,
  1.00033261e-01f, -5.85655347e-02f, -2.52545010e-02f, 1.08881921e-01f, 7.68309925e-03f, -5.47178090e-02f, -2.57557854e-02f, 2.36921478e-02f, -1.53379445e-03f, 5.91154993e-02f,
  1.03002384e-01f, 2.72225924e-02f, 8.02318156e-02f, -5.10685816e-02f, -1.01675287e-01f, -3.80431339e-02f, -6.32760078e-02f, 5.51042892e-03f, 4.04703245e-02f, 5.25288880e-02f,
  -1.66169070e-02f, 2.08157636e-02f, -7.82637373e-02f, 9.50065535e-03f, 7.84020945e-02f, -4.31038365e-02f, -6.03502849e-03f, -6.61545387e-03f, -3.61381844e-02f, -3.24223526e-02f,
  4.53633144e-02f, 3.95816611e-03f, -1.40838893e-02f, 4.05496582e-02f, 7.68874632e-03f, 1.34801073e-02f, -3.55260447e-02f, -3.13635953e-02f, 1.64075773e-02f, 8.26956145e-03f,
  -4.03080955e-02f, -9.35430676e-02f, 2.52027530e-02f, -4.17427495e-02f, 7.11557046e-02f, -4.53498587e-03f, 9.77212191e-02f, 4.53847758e-02f, 5.23088202e-02f, 8.26690868e-02f,
  5.08282557e-02f, -4.11381461e-02f, 2.53699720e-02f, 8.22629929e-02f, -8.53817239e-02f, 4.86408956e-02f, 8.34508538e-02f, 1.64130554e-02f, 5.31678982e-02f, 9.42197740e-02f,
  5.70340902e-02f, 3.54948863e-02f, 3.26370038e-02f, 3.41715850e-02f, 4.95008305e-02f, 5.92672341e-02f, 4.88761216e-02f, 9.71877109e-03f, 5.56460246e-02f, 8.35188627e-02f,
  2.68580075e-02f, 9.26219225e-02f, 1.26261041e-01f, 1.20068803e-01f, 1.36302024e-01f, 1.17929820e-02f, -2.05867272e-02f, 1.52849639e-02f, 4.76321355e-02f, 8.52926355e-03f,
  -5.14004473e-03f, 6.90917522e-02f, -3.87086160e-02f, 1.52192295e-01f, 7.57027417e-03f, 1.56603137e-03f, 1.31672531e-01f, 7.26218820e-02f, 1.26434863e-01f, -1.45323528e-02f,
  8.76865759e-02f, 4.98172678e-02f, 1.41131029e-01f, -2.11591925e-02f, -4.85300459e-02f, 1.70950413e-01f, -1.37324603e-02f, 9.48394760e-02f, 7.83857480e-02f, 9.54930410e-02f,
  1.12980818e-02f, 4.87366604e-04f, 6.28442466e-02f, 3.53320800e-02f, -4.45339046e-02f, 3.00942343e-02f, 1.64206654e-01f, 8.49197246e-03f, 8.23758394e-02f, 1.41630163e-02f,
  -2.11180761e-01f, -9.28482860e-02f, -6.74885064e-02f, 9.41390097e-02f, 2.56244950e-02f, 4.05151024e-03f, -4.54584025e-02f, 4.55878617e-04f, -2.05920175e-01f, 1.43135279e-01f,
  1.85170919e-02f, -9.16926004e-03f, 4.50339401e-03f, -1.12374656e-01f, -1.25222683e-01f, -1.73672289e-02f, 2.42292937e-02f, -6.96703792e-02f, -1.12922497e-01f, 1.04597256e-01f,
  -1.40713705e-02f, -4.61775288e-02f, -4.20998037e-02f, -3.47252600e-02f, 7.39929453e-02f, -1.58417169e-02f, -2.14441299e-01f, -1.44189060e-01f, -2.63403028e-01f, -9.13617760e-02f,
  -9.65200514e-02f, -1.81351915e-01f, 5.96740358e-02f, 1.31493405e-01f, -6.32232130e-02f, -6.61693588e-02f, 5.37955053e-02f, 1.58340842e-01f, 7.15292692e-02f, -1.15115523e-01f,
  -3.48268189e-02f, -7.76555911e-02f, 1.08096160e-01f, -1.10889800e-01f, 2.42613573e-02f, -2.04848394e-01f, 1.24377742e-01f, -1.06445728e-02f, 1.08605996e-01f, 8.99729878e-02f,
  -2.27879789e-02f, 1.03675738e-01f, 5.57463393e-02f, 2.60276045e-03f, -5.39629236e-02f, 1.02955498e-01f, -2.52165627e-02f, -4.28722464e-02f, 7.66976178e-02f, 1.16652377e-01f,
  -4.43832017e-02f, 1.08568482e-01f, -3.83640826e-02f, 9.95709747e-02f, -5.57680242e-02f, 3.77260521e-02f, 1.02263838e-02f, 4.13688757e-02f, 4.44641970e-02f, 4.29546125e-02f,
  -1.48690701e-01f, 3.09317634e-02f, 5.45707196e-02f, -1.04030587e-01f, -1.31200664e-02f, 5.07327961e-03f, 8.13604146e-03f, 8.49932134e-02f, 7.96146765e-02f, -5.81135415e-02f,
  -2.77419854e-02f, -1.07630370e-02f, -6.57748757e-03f, 5.48909456e-02f, -3.40467580e-02f, 4.93751504e-02f, -1.23568447e-02f, 8.19278806e-02f, -5.03403600e-03f, 8.95016715e-02f,
  -5.28114066e-02f, -8.60563517e-02f, 4.25018668e-02f, 8.83830562e-02f, -5.29604629e-02f, -1.82209704e-02f, -2.87064584e-03f, 8.08851495e-02f, -2.52303630e-02f, -5.17969728e-02f,
  3.93556878e-02f, 3.48157249e-02f, -7.65476096e-03f, -1.85429547e-02f, -9.72480979e-03f, -3.33724059e-02f, -6.64594397e-02f, 5.61101129e-03f, -4.19258140e-02f, -3.16178333e-03f,
  8.52375180e-02f, -4.68403175e-02f, -5.57505265e-02f, 9.29503366e-02f, -6.12315461e-02f, -6.50382042e-02f, 8.22478011e-02f, -8.02111533e-03f, -7.50904158e-02f, 3.26980324e-03f,
  7.84377307e-02f, -3.26218978e-02f, -4.03282493e-02f, -2.44418383e-02f, -1.18453549e-02f, 5.74283078e-02f, -8.65122825e-02f, -4.12792247e-03f, -8.38730335e-02f, -1.60556808e-02f,
  3.98960896e-02f, -2.06498094e-02f, 5.48946783e-02f, -9.92168905e-04f, 3.41611728e-03f, -7.42892250e-02f, 3.35040763e-02f, -1.59914177e-02f, 5.70843294e-02f, -5.09716719e-02f,
  5.17545938e-02f, -6.32207468e-02f, 7.24439248e-02f, 3.06049213e-02f, -2.59647481e-02f, 8.08013305e-02f, -1.35512101e-02f, -6.18138462e-02f, -1.85643474e-03f, 3.97383869e-02f,
  6.52826279e-02f, -8.47994909e-03f, 9.01011974e-02f, 1.96540193e-03f, 2.09662095e-02f, -5.96500300e-02f, 7.90910646e-02f, -1.21368594e-01f, 2.06282623e-02f, -5.07264351e-03f,
  -6.57459646e-02f, -2.34083422e-02f, -2.78533995e-02f, 2.96472367e-02f, 5.75138144e-02f, 1.79255987e-03f, -6.07356466e-02f, -3.57881677e-03f, -3.93390469e-02f, 6.98835328e-02f,
  -4.60554026e-02f, -1.27575276e-02f, 6.15430139e-02f, 7.72327408e-02f, 1.51048219e-02f, 9.14026201e-02f, -8.71112794e-02f, 4.87894267e-02f, -3.82316597e-02f, 6.06196001e-02f,
  -1.72829423e-02f, -6.93824813e-02f, 7.47581199e-03f, -2.36782599e-02f, -2.92045604e-02f, 5.84099628e-02f, -7.67861446e-03f, -3.39425430e-02f, -6.43513799e-02f, -5.70912585e-02f,
  -5.48526011e-02f, -1.43037550e-02f, -4.45628799e-02f, -6.93521723e-02f, -7.93426111e-02f, -1.92474891e-02f, -5.16384803e-02f, -4.44205664e-03f, -1.18894130e-03f, 6.70650676e-02f,
  6.82173222e-02f, -2.54827943e-02f, 1.55366166e-02f, -6.32164031e-02f, 7.93104246e-02f, -3.01135741e-02f, 8.84234905e-02f, 1.61527947e-01f, 1.41000777e-01f, 2.84051094e-02f,
  1.28541887e-01f, 1.53894201e-01f, -4.68384810e-02f, -2.93735992e-02f, 5.70728560e-04f, 1.56279411e-02f, 1.22682564e-01f, 8.13370347e-02f, 9.65644494e-02f, 6.32654428e-02f,
  7.21133724e-02f, 8.22258517e-02f, 8.92967954e-02f, 1.58324376e-01f, 8.16885903e-02f, 7.13574886e-02f, 4.85952236e-02f, 1.14661880e-01f, 1.49901584e-01f, 2.96408366e-02f,
  3.59048950e-03f, 1.59262300e-01f, 9.87664387e-02f, 1.12199336e-01f, 3.12300418e-02f, 1.19404040e-01f, 2.95423754e-02f, 1.24687858e-01f, 1.10142276e-01f, 1.47844210e-01f,
  1.84780564e-02f, 1.04974508e-01f, 1.60099730e-01f, 8.31423625e-02f, 4.16086242e-02f, -4.48599719e-02f, 1.67319790e-01f, 1.41969994e-02f, 1.46495372e-01f, 7.88594261e-02f,
  -3.49564082e-03f, -4.84587997e-02f, 2.58204322e-02f, 3.80340568e-03f, 1.14848204e-01f, -1.36101797e-01f, 4.76288721e-02f, 3.54059339e-02f, -8.03163052e-02f, 1.50512740e-01f,
  1.05725549e-01f, 9.63506326e-02f, 4.02044281e-02f, -9.00099277e-02f, 1.04722761e-01f, -1.73453629e-01f, 6.00270592e-02f, -9.62667242e-02f, -3.32118534e-02f, -1.56258658e-01f,
  1.32337958e-01f, -5.07078990e-02f, 4.55343463e-02f, -3.96881849e-02f, -2.78609525e-02f, -2.75027528e-02f, -2.39617173e-02f, 1.18294314e-01f, -3.43541093e-02f, 9.09035504e-02f,
  1.10803641e-01f, -1.55789286e-01f, 1.75243855e-01f, 2.01302111e-01f, 9.87553075e-02f, -6.21267147e-02f, 1.09289780e-01f, -3.99491154e-02f, -3.94915938e-02f, 3.68249193e-02f,
  -4.68500219e-02f, 6.34416044e-02f, -3.51001844e-02f, -6.40465543e-02f, -5.81202060e-02f, 4.92682075e-03f, 1.61001012e-01f, 1.52626678e-01f, -1.43620878e-01f, -1.31049618e-01f,
  -6.18104972e-02f, 1.14289455e-01f, -1.65494010e-01f, 9.27600712e-02f, -1.58086210e-01f, -1.42161742e-01f, 5.02539463e-02f, -6.32459670e-02f, -2.00668368e-02f, -5.09277843e-02f,
  1.51867807e-01f, 7.52859861e-02f, 5.34857959e-02f, -4.79481854e-02f, -1.20761548e-03f, -9.50242672e-03f, -1.02640934e-01f, -1.67096764e-01f, -4.94300984e-02f, -2.55405232e-02f,
  1.64330024e-02f, 1.22019388e-01f, -4.42059115e-02f, 4.98190373e-02f, -1.55460179e-01f, -8.23737979e-02f, -1.18773105e-02f, -3.33343334e-02f, 2.58071776e-02f, -1.61209737e-03f,
  1.02792799e-01f, -1.94613263e-03f, 5.18474132e-02f, 7.87683576e-02f, -6.67374432e-02f, -8.04064646e-02f, 4.02572704e-03f, -1.80695509e-03f, 4.35108468e-02f, 7.75781721e-02f,
  4.99574468e-02f, -4.06524166e-02f, 6.11376166e-02f, -7.36776367e-03f, -8.44030604e-02f, -4.88016680e-02f, -1.65597461e-02f, -7.33545423e-02f, -5.53510003e-02f, 5.55690750e-03f,
  -6.31174222e-02f, 6.31370321e-02f, 9.16416273e-02f, 7.54663199e-02f, -3.04186251e-02f, -3.49512487e-03f, -2.88898721e-02f, -2.26111822e-02f, -3.26367840e-02f, 7.03005642e-02f,
  -2.91905217e-02f, -2.58597918e-02f, -4.05864464e-03f, -6.18102169e-03f, 4.16256301e-02f, -5.32599026e-03f, -3.88559997e-02f, 3.08552850e-03f, -3.24809738e-02f, -8.67222087e-04f,
  2.17362214e-02f, 3.83105152e-03f, -7.36061186e-02f, 5.45626245e-02f, -1.70396715e-02f, -2.96572447e-02f, -7.62584135e-02f, -2.02310123e-02f, 7.78739676e-02f, 8.56103450e-02f,
  -3.61265987e-02f, 2.40391027e-02f, 6.89904839e-02f, 5.95107935e-02f, -2.78797466e-03f, -5.66213317e-02f, 3.86130624e-02f, -5.77644259e-02f, 1.99046228e-02f, 5.27050234e-02f,
  -1.87083315e-02f, 6.88112900e-02f, 7.08313286e-02f, -3.48083228e-02f, 8.08596015e-02f, -6.79076230e-03f, 4.49358188e-02f, -4.87712920e-02f, 5.71651645e-02f, -8.12794492e-02f,
  6.43631592e-02f, -5.60298525e-02f, 6.24180213e-02f, 3.36249098e-02f, 4.35936004e-02f, -2.26490870e-02f, 2.69991662e-02f, -4.18627672e-02f, -1.60093121e-02f, -1.10289799e-02f,
  -5.06532751e-02f, -2.50976048e-02f, -3.17173153e-02f, -3.42800543e-02f, -5.66717237e-02f, 1.79886613e-02f, -5.80710843e-02f, -8.81259888e-02f, -7.40149915e-02f, -7.93334618e-02f,
  7.63911903e-02f, -5.21093048e-02f, 8.24460536e-02f, 7.35016838e-02f, -8.06370452e-02f, -6.35190159e-02f, -8.35299492e-02f, -2.08234917e-02f, -8.51091892e-02f, -5.24689667e-02f,
  -4.75475676e-02f, 8.22083503e-02f, 9.00691375e-02f, -3.55465501e-03f, -2.38217600e-02f, 8.05542991e-02f, -2.36061513e-02f, 6.55660331e-02f, -3.08959614e-02f, -7.12759867e-02f,
  3.10970172e-02f, -2.80848723e-02f, 3.10550928e-02f, 5.34652174e-02f, -6.07529022e-02f, 1.64907277e-02f, 4.95058484e-02f, -3.57372612e-02f, 1.43969236e-02f, -5.05506136e-02f,
  -4.88655195e-02f, -7.84100071e-02f, 4.31442335e-02f, 4.54271846e-02f, 1.73090920e-02f, 1.43497912e-02f, 1.45021519e-02f, -4.99245822e-02f, 6.84797019e-02f, 9.02369991e-02f,
  5.84206842e-02f, 6.26969859e-02f, 4.32585515e-02f, -5.27512059e-02f, -4.74371575e-02f, 1.26673743e-01f, 8.84347335e-02f, 3.24265696e-02f, -8.76581937e-04f, -2.81497035e-02f,
  -2.92526595e-02f, 7.93663959e-04f, 1.56959444e-01f, 6.56431839e-02f, 1.16396986e-01f, -1.28892381e-02f, -2.08579116e-02f, 1.04613103e-01f, 1.37364879e-01f, 7.75039494e-02f,
  1.21254563e-01f, 1.84323136e-02f, -1.05777429e-02f, 6.56161532e-02f, 1.47658676e-01f, 1.20021969e-01f, 8.53776932e-02f, 8.63724649e-02f, 6.80936649e-02f, -2.17250530e-02f,
  8.85199383e-02f, -4.21975441e-02f, -5.00233881e-02f, 9.44624916e-02f, 4.54422273e-02f, -2.72914860e-02f, 1.72588062e-02f, 1.06588408e-01f, -3.34760593e-03f, 9.43255797e-02f,
  1.05189510e-01f, 1.82394952e-01f, -5.77091947e-02f, 8.42965916e-02f, 1.60635188e-01f, 1.09272793e-01f, 8.91598221e-03f, -2.77792588e-02f, -6.49887696e-02f, 1.51663601e-01f,
  2.15652585e-02f, -4.56219353e-02f, 1.08776256e-01f, -1.42289802e-01f, 4.54887301e-02f, -2.69513279e-02f, -8.53316709e-02f, 1.23112975e-02f, -6.81871623e-02f, -1.34530976e-01f,
  -1.07021317e-01f, -1.17198825e-01f, -7.52167106e-02f, 1.19238995e-01f, 5.40638119e-02f, 5.27416915e-02f, -2.86943838e-02f, -3.11372653e-02f, -3.28274742e-02f, 2.79416796e-02f,
  1.48447439e-01f, -7.81684816e-02f, -1.02584347e-01f, 1.82598576e-01f, 1.10161854e-02f, 1.22084290e-01f, -1.13649694e-02f, 9.25643891e-02f, 4.57178876e-02f, 1.87214091e-02f,
  3.53178643e-02f, 2.19811261e-01f, -3.33176516e-02f, 2.96711270e-02f, -5.98329976e-02f, -1.04341932e-01f, -5.90094849e-02f, 1.02269076e-01f, 4.45278659e-02f, -2.74811685e-02f,
  -5.87685443e-02f, -4.65658531e-02f, -1.38093859e-01f, -8.76694394e-04f, 9.19666588e-02f, -4.58566584e-02f, 1.35408878e-01f, -1.42647043e-01f, -1.32809309e-02f, -2.32665300e-01f,
  1.27390074e-02f, 6.80215806e-02f, 9.46976896e-03f, 4.96997796e-02f, -5.98427579e-02f, 1.47948898e-02f, 8.11842978e-02f, 1.02697790e-01f, 4.83398475e-02f, -4.92309332e-02f,
  4.43615727e-02f, -6.92113414e-02f, 4.72827535e-03f, -6.65029287e-02f, 3.15228924e-02f, 1.73890293e-01f, -6.23612851e-02f, 1.86134633e-02f, 1.17204487e-02f, -7.72851035e-02f,
  4.06951681e-02f, -8.88099745e-02f, 1.46703288e-01f, -8.14597160e-02f, 5.25536388e-02f, 7.11772069e-02f, 1.35145169e-02f, -8.09855312e-02f, 3.72873582e-02f, 1.07664168e-01f,
  9.30787101e-02f, 4.63244431e-02f, -7.42332498e-03f, 3.87788139e-04f, 6.48473427e-02f, -2.84242444e-02f, 1.14235915e-01f, 7.80984014e-02f, -2.44981144e-02f, 7.00249746e-02f,
  -5.32849506e-02f, -4.52498570e-02f, 3.74627002e-02f, 7.98882470e-02f, 7.21280947e-02f, -4.95699327e-03f, 1.15853451e-01f, 1.54070765e-01f, 1.06630705e-01f, 6.18510693e-02f,
  4.60205115e-02f, -4.11938690e-02f, 9.51783955e-02f, 1.10932693e-01f, -6.98305517e-02f, 8.94775838e-02f, -3.03023271e-02f, 2.59474069e-02f, 1.61356360e-01f, 1.16620786e-01f,
  -1.26758125e-02f, -3.51113104e-03f, 5.85087202e-03f, -5.43018170e-02f, 1.59172993e-02f, 1.17754355e-01f, -3.41359265e-02f, 1.04982130e-01f, -3.74474600e-02f, 6.42211139e-02f,
  7.85192698e-02f, 1.38539433e-01f, 3.27163041e-02f, 2.97863092e-02f, 1.06752016e-01f, -4.83154766e-02f, 1.17062509e-01f, -1.25293462e-02f, 1.67229578e-01f, -4.70783636e-02f,
  -1.48947658e-02f, 9.06179994e-02f, -1.36837736e-01f, -1.11479171e-01f, 8.76890793e-02f, 1.04940822e-02f, -3.53392772e-02f, 3.23767550e-02f, 1.57515090e-02f, -2.33351067e-02f,
  5.04813083e-02f, -9.33243856e-02f, 3.94030586e-02f, 5.93153499e-02f, 1.09735690e-02f, -8.27162415e-02f, 6.35450054e-03f, -9.35292095e-02f, 2.97979619e-02f, -1.32606953e-01f,
  4.33156826e-02f, 1.29349530e-01f, -1.12695899e-02f, 1.11081161e-01f, 8.96255001e-02f, -3.61678470e-03f, 1.37799233e-01f, -1.27632460e-02f, 6.56126887e-02f, 1.82104483e-01f,
  -4.13541198e-02f, -1.23920878e-02f, 8.26287493e-02f, 1.39458656e-01f, 4.84720841e-02f, -1.46816368e-04f, 6.29785657e-02f, 3.78875881e-02f, 1.80484742e-01f, 1.61152795e-01f,
  -2.77456846e-02f, 5.30956686e-02f, 4.99745980e-02f, 4.97348458e-02f, 2.69497894e-02f, -9.79705676e-02f, -1.81573257e-01f, -1.26577139e-01f, 3.14776748e-01f, 6.97029978e-02f,
  3.27876136e-02f, 1.78010501e-02f, 3.31132370e-03f, 1.57858819e-01f, 1.29465712e-02f, 1.31522983e-01f, -2.98285508e-03f, -1.08502656e-02f, 2.26395056e-02f, -3.60109773e-03f,
  3.37753892e-02f, 3.88174541e-02f, 7.47549459e-02f, 1.06267251e-01f, 8.50188956e-02f, -1.20858394e-01f, 3.61345299e-02f, 2.40164716e-03f, -3.44832204e-02f, 3.52907740e-02f,
  1.65256616e-02f, -7.81299546e-03f, -1.26167178e-01f, 7.76443630e-02f, -1.21211540e-02f, -4.28118668e-02f, -7.09274262e-02f, -3.94306183e-02f, -8.02751537e-03f, -1.42974183e-02f,
  4.35305536e-02f, 2.48692669e-02f, 1.97980516e-02f, -3.20416987e-02f, -1.65755358e-02f, 5.03692068e-02f, -3.28065753e-02f, 1.95212141e-02f, 2.61453278e-02f, 6.18485399e-02f,
  -5.18293865e-03f, 7.02244192e-02f, 1.03097474e-02f, 1.67738572e-02f, -7.20882975e-03f, 4.68773022e-03f, -5.68355247e-02f, 1.63371097e-02f, 2.09677685e-02f, 2.95876451e-02f,
  5.70514165e-02f, -9.30919964e-03f, -7.41201788e-02f, 8.06630552e-02f, -5.33086061e-02f, -2.68874038e-02f, -2.41798498e-02f, -5.04763760e-02f, -1.59586314e-02f, 3.73894386e-02f,
  -7.18608499e-02f, -2.58922800e-02f, -3.87336127e-02f, 6.17995709e-02f, 5.20904101e-02f, -2.79700570e-02f, -6.36086017e-02f, -5.96504658e-02f, -7.36481026e-02f, -3.70228253e-02f,
  9.21375677e-02f, 8.05955976e-02f, -2.26146560e-02f, -7.79927373e-02f, 8.64006579e-02f, -3.37839685e-02f, -4.37150188e-02f, -6.14240803e-02f, -6.62933812e-02f, 3.07355728e-02f,
  2.48389464e-04f, 8.00448880e-02f, -4.51108404e-02f, 1.02211544e-02f, -7.92359859e-02f, 7.45949149e-02f, 7.00978749e-03f, -5.43293953e-02f, 2.29935125e-02f, -8.26959684e-02f,
  -8.50119442e-02f, 1.88030340e-02f, -5.71023151e-02f, -3.09320465e-02f, 1.03485594e-02f, 1.45793743e-02f, -6.60711005e-02f, -4.45010215e-02f, 1.60884000e-02f, -7.61019364e-02f,
  8.23762566e-02f, -2.73898318e-02f, -7.32014030e-02f, -4.06091809e-02f, -1.74729452e-02f, -1.08067011e-02f, 1.10723590e-02f, -8.73697326e-02f, -7.32880831e-02f, -3.85032929e-02f,
  6.32592440e-02f, -8.43447745e-02f, 1.98585819e-02f, 4.13446464e-02f, -6.73257336e-02f, 6.71110228e-02f, -1.18622398e-02f, -3.67187522e-02f, 1.91137176e-02f, -7.98194036e-02f,
  6.64524660e-02f, -3.93201644e-03f, -4.94749285e-02f, -1.26920976e-02f, 5.43120056e-02f, 9.63806510e-02f, 3.44598591e-02f, -7.99764395e-02f, 5.94352372e-02f, 8.63208100e-02f,
  -4.66244780e-02f, -8.61960128e-02f, 5.16781211e-02f, 1.33570563e-02f, 1.24750715e-02f, 3.94436009e-02f, -8.06178525e-02f, 4.63992544e-02f, 5.23906946e-02f, 1.17110927e-02f,
  -4.10660543e-02f, -1.39144221e-02f, 6.26784787e-02f, 4.52843308e-02f, 2.32803952e-02f, 7.85337240e-02f, 4.84284759e-02f, -6.45165741e-02f, -6.63802549e-02f, -6.32811338e-02f,
  8.03349689e-02f, -3.52568850e-02f, -9.05531943e-02f, -8.72696862e-02f, 1.09407291e-01f, -1.17540378e-02f, -7.27569088e-02f, 3.72119173e-02f, 1.82082821e-02f, 8.74985680e-02f,
  9.36188847e-02f, -2.87471730e-02f, 5.16224131e-02f, -2.12642811e-02f, 1.18139356e-01f, 1.71401389e-02f, 7.96650499e-02f, 6.83687180e-02f, 6.54074103e-02f, -6.52800724e-02f,
  5.20559363e-02f, 6.47012219e-02f, 2.76097432e-02f, 7.88934901e-02f, 1.08676895e-01f, 1.60520133e-02f, 3.10630035e-02f, 8.68995190e-02f, -1.35995463e-01f, -6.91555580e-03f,
  -9.22589377e-02f, 8.45404267e-02f, 1.13644853e-01f, 1.37648895e-01f, -1.93543155e-02f, 4.77803424e-02f, 4.98814881e-02f, -1.03926985e-02f, 1.59563422e-01f, -6.27640784e-02f,
  -3.07772052e-03f, -6.87465519e-02f, 8.13150406e-02f, 6.49581403e-02f, -6.57429397e-02f, -7.47131258e-02f, 3.29242125e-02f, 2.52340026e-02f, 1.13302514e-01f, 1.75145473e-02f,
  -1.46425813e-01f, 1.44391835e-01f, 1.39545009e-01f, 4.54980657e-02f, 4.65266369e-02f, 3.94740961e-02f, 2.94055212e-02f, 6.64730743e-02f, 1.14176311e-01f, -8.05624127e-02f,
  5.20491675e-02f, 2.65730824e-02f, 6.87091574e-02f, 3.79761048e-02f, 1.24855481e-01f, 1.11835442e-01f, -6.01403601e-02f, -8.80028009e-02f, 5.72298579e-02f, -2.98323762e-02f,
  -1.28169656e-01f, 6.67748451e-02f, 2.47386098e-02f, -2.08253399e-01f, 4.16642614e-02f, 9.80865955e-03f, -8.69241282e-02f, 6.00836659e-03f, 2.13969499e-02f, -2.08194301e-01f,
  1.43057138e-01f, -1.35258242e-01f, 8.49367082e-02f, -8.21268111e-02f, -3.27460952e-02f, -1.80604309e-02f, 6.03479333e-03f, 4.99644540e-02f, 1.62775442e-01f, 3.45375873e-02f,
  -1.31947979e-01f, -1.89282577e-02f, -1.40425056e-01f, -2.95830648e-02f, 1.02161251e-01f, -1.43776685e-01f, -3.96315707e-04f, -7.06010982e-02f, -1.05044343e-01f, -1.26306251e-01f,
  -1.24754161e-01f, -9.79090482e-02f, 1.07746169e-01f, -1.24525547e-01f, 1.44457087e-01f, -1.00522690e-01f, 2.02086531e-02f, 9.96553153e-02f, -2.61884718e-03f, -5.27986251e-02f,
  -1.03839524e-01f, -2.16349084e-02f, 7.41731375e-02f, 7.71410614e-02f, 8.49293079e-03f, 1.67543054e-01f, -3.99683267e-02f, 7.79856369e-02f, 2.73660365e-02f, -1.53056299e-02f,
  1.08885854e-01f, 1.02433302e-01f, 7.25574270e-02f, 9.59619228e-03f, -9.86345764e-03f, -4.81743328e-02f, 1.80116519e-02f, 4.47537750e-02f, 6.79278225e-02f, -4.09274139e-02f,
  -4.08600494e-02f, 3.69506404e-02f, 7.53322020e-02f, -2.10656207e-02f, 7.06653520e-02f, -4.06219158e-04f, -2.46772394e-02f, 1.55471563e-01f, -4.41729017e-02f, -2.37585269e-02f,
  -7.15623498e-02f, -6.05231039e-02f, -8.53360351e-03f, 1.06957145e-01f, 1.09181963e-01f, 6.40585348e-02f, 1.09455199e-04f, -1.29682552e-02f, 3.77684161e-02f, 6.41173199e-02f,
  -3.12580578e-02f, 1.15178779e-01f, -4.49424908e-02f, -4.80032107e-03f, -7.54310638e-02f, -5.52726761e-02f, -1.32763013e-02f, 8.17607492e-02f, 8.68725032e-02f, -7.42882490e-02f,
  -4.99892682e-02f, -2.85653640e-02f, -1.09871197e-03f, 8.34697559e-02f, 4.37516645e-02f, 1.77466646e-01f, -6.19167797e-02f, 1.00733534e-01f, 1.26819402e-01f, -6.51622340e-02f,
  8.57061446e-02f, -5.23137189e-02f, 7.51879215e-02f, -1.04065694e-01f, 1.16379671e-01f, -9.82417986e-02f, 8.46364573e-02f, 2.60647032e-02f, -5.62425815e-02f, 1.58906505e-02f,
  -6.14889860e-02f, -3.93161625e-02f, 7.07675004e-03f, 4.34658863e-03f, 9.32083204e-02f, -6.40044734e-02f, -7.47009814e-02f, -1.70103833e-02f, -1.12523556e-01f, 2.91538481e-02f,
  -1.93104763e-02f, -1.43465996e-01f, 1.91141263e-01f, -4.78155538e-02f, -8.36396292e-02f, 1.14395082e-01f, 1.84622422e-01f, -1.11782171e-01f, 9.64351445e-02f, 6.54733106e-02f,
  -2.15099640e-02f, 5.26725873e-02f, 1.91429019e-01f, -2.18527034e-01f, -1.42150789e-01f, 1.29163012e-01f, -6.96840584e-02f, -8.90042931e-02f, -2.23259144e-02f, -5.60821146e-02f,
  3.08066923e-02f, 1.97492063e-01f, 7.69194886e-02f, -1.99011154e-02f, 5.53878676e-03f, 1.42967850e-01f, -1.87444445e-02f, -1.99657530e-01f, 2.48584747e-02f, 8.35897177e-02f,
  -5.06321341e-02f, 2.98435725e-02f, -1.39784709e-01f, -1.43342420e-01f, -6.00160658e-02f, -5.70575036e-02f, -1.05013289e-02f, -7.02342987e-02f, 8.73371437e-02f, 5.82986996e-02f,
  6.95638731e-02f, -2.38368049e-01f, -9.56771672e-02f, -7.52177462e-02f, -6.49524927e-02f, 7.16833631e-03f, -3.33924107e-02f, -8.74117091e-02f, 9.95052140e-03f, -6.31124340e-03f,
  3.93056311e-02f, 2.15046126e-02f, 2.79623456e-02f, -4.69480455e-02f, -5.31724188e-03f, -1.45636313e-02f, 1.28595233e-01f, 6.20744973e-02f, 1.11446306e-01f, 1.00918666e-01f,
  4.72027995e-02f, 7.79586136e-02f, 7.07474537e-03f, 3.06788534e-02f, 1.01740338e-01f, 9.02826190e-02f, 2.74049584e-02f, 1.25393391e-01f, 3.42203043e-02f, -2.29593944e-02f,
  -2.87419539e-02f, -1.56335272e-02f, 1.70783866e-02f, -4.77564819e-02f, -5.86258397e-02f, -8.68037641e-02f, 3.55335027e-02f, -4.00969945e-02f, -1.69762745e-02f, -7.27907335e-03f,
  3.12643833e-02f, 3.86744477e-02f, 4.01460640e-02f, 6.12441935e-02f, 1.09749380e-03f, 3.81663791e-03f, -8.08903277e-02f, 5.47419339e-02f, -3.88591737e-02f, 9.08580795e-03f,
  -3.13289277e-02f, -2.53660921e-02f, -4.85771224e-02f, 3.11283618e-02f, -7.38986805e-02f, 3.56104597e-02f, -1.62941404e-02f, -6.37073070e-02f, 4.95772772e-02f, 6.32158518e-02f,
  -2.94577591e-02f, 5.49770109e-02f, 5.44881299e-02f, -5.71206212e-02f, 4.28267419e-02f, -7.01283887e-02f, -5.77787310e-02f, -2.82383747e-02f, 2.70295516e-02f, 4.20984719e-03f,
  -2.72135176e-02f, -4.86055091e-02f, -8.48739687e-03f, 4.20781970e-02f, 2.00310461e-02f, -3.86585412e-03f, -5.50855361e-02f, -1.80265103e-02f, -5.61747886e-02f, -2.89101023e-02f,
  -2.39729416e-03f, -3.46507579e-02f, -8.43192786e-02f, -8.08212161e-02f, 1.09218014e-02f, 2.65962947e-02f, -8.27055145e-03f, 4.20923159e-02f, -6.51641786e-02f, 1.00626349e-02f,
  -1.84935946e-02f, -7.37409517e-02f, 5.04632592e-02f, -2.28475705e-02f, 5.14270179e-02f, 2.77079213e-02f, -4.61652614e-02f, 5.54593727e-02f, 1.09172857e-03f, 3.67810130e-02f,
  1.35963866e-02f, -6.60062255e-03f, 1.53808305e-02f, -6.15621768e-02f, 3.49911936e-02f, 9.28827934e-03f, -5.48446290e-02f, -3.44608836e-02f, -5.41802980e-02f, 3.85887250e-02f,
  7.97632039e-02f, 6.80592731e-02f, -6.73309118e-02f, -6.54509217e-02f, 1.48037365e-02f, 5.64503819e-02f, -6.00666702e-02f, 7.82264546e-02f, -3.73418406e-02f, -6.84066415e-02f,
  5.69376126e-02f, -8.32927823e-02f, 2.57207528e-02f, 3.65466885e-02f, -4.88132834e-02f, -2.57411208e-02f, 1.10464739e-02f, 1.74059384e-02f, -4.39680330e-02f, -2.20606811e-02f,
  -6.56105950e-02f, 5.33311442e-02f, 5.91660514e-02f, 3.47897895e-02f, 7.47215375e-02f, -6.72183782e-02f, -8.30765720e-03f, 2.85409018e-02f, -2.35600881e-02f, 8.18900540e-02f,
  -2.26569083e-02f, -4.17489521e-02f, -4.82960753e-02f, -7.82876983e-02f, 5.39305061e-02f, -2.57283971e-02f, -7.15764388e-02f, -4.86335345e-02f, -5.29911704e-02f, -5.94369359e-02f,
  -7.33244196e-02f, 6.16488829e-02f, -8.35258961e-02f, 2.69584917e-02f, -1.07581113e-02f, -5.31228725e-04f, -5.38618118e-02f, -1.94244273e-02f, 5.00690527e-02f, 1.16849616e-01f,
  4.19106595e-02f, -5.72993904e-02f, 4.37895097e-02f, -3.19166132e-03f, 9.71007943e-02f, 3.43529545e-02f, 1.09734133e-01f, 7.21895099e-02f, 9.84495208e-02f, -4.99952771e-02f,
  -2.02615485e-02f, -9.46477696e-04f, 5.58472164e-02f, 1.92195401e-02f, 1.09881409e-01f, 2.35376339e-02f, 1.38991952e-01f, 1.23014547e-01f, 9.14427787e-02f, -3.75630297e-02f,
  9.14413705e-02f, -3.15069705e-02f, 6.88364580e-02f, -4.58733086e-03f, 3.20768282e-02f, 9.64938551e-02f, 9.31089371e-02f, -1.49575705e-02f, 6.00803196e-02f, 2.06470303e-02f,
  2.37033870e-02f, -6.07980788e-02f, 4.09588916e-03f, -3.59555446e-02f, 1.65660549e-02f, 1.03592247e-01f, -1.27916848e-02f, 3.82881425e-02f, 4.12551090e-02f, 1.09829120e-01f,
  7.94066787e-02f, 8.50262567e-02f, 5.18253334e-02f, 4.10129167e-02f, 6.74632043e-02f, -1.17962714e-02f, -3.81901339e-02f, 4.79712188e-02f, -2.79235337e-02f, 1.28619317e-02f,
  1.49173573e-01f, -3.93081196e-02f, 7.85418302e-02f, -1.35296300e-01f, 5.13496660e-02f, -6.36673942e-02f, -1.27773350e-02f, 1.81180686e-02f, -6.93244338e-02f, 9.80552007e-03f,
  3.23417112e-02f, -7.84018412e-02f, -1.78034641e-02f, 1.47753775e-01f, 1.24444790e-01f, 2.65734699e-02f, 1.58892237e-02f, -1.58217121e-02f, 1.74177855e-01f, -7.26835523e-03f,
  7.07583874e-02f, 2.16155685e-02f, -4.87376004e-03f, 1.35620922e-01f, 3.40782776e-02f, -1.13669690e-02f, 3.29598114e-02f, -3.57532222e-03f, 1.10459000e-01f, 2.93865823e-03f,
  -5.93480729e-02f, 9.13449191e-03f, -7.42186457e-02f, 2.74214782e-02f, 3.17877233e-02f, 6.17516674e-02f, 5.76766320e-02f, -1.14938818e-01f, -1.24933958e-01f, 1.24305837e-01f,
  -4.65865955e-02f, 9.90389660e-02f, -1.18646540e-01f, 8.19763169e-02f, 7.45168999e-02f, -6.40368089e-02f, -3.26529853e-02f, -3.74447834e-03f, -9.77147892e-02f, -6.60966635e-02f,
  4.79969010e-02f, -3.30603160e-02f, 1.15448423e-02f, 7.38201067e-02f, -3.62102650e-02f, 6.81843013e-02f, 2.59761065e-02f, 1.10430129e-01f, -9.35833901e-02f, 7.27013359e-03f,
  -1.08454816e-01f, 7.90633261e-02f, -3.76974605e-02f, -3.51781584e-02f, 9.34771914e-03f, -7.70447552e-02f, 3.61503065e-02f, 2.31758393e-02f, -7.29494691e-02f, 1.89798176e-02f,
  -3.33402641e-02f, -1.12854935e-01f, -1.65932178e-02f, -6.79399744e-02f, -7.65763894e-02f, 2.65512448e-02f, -3.23981903e-02f, -2.74190158e-02f, -1.49684651e-02f, -8.31189752e-02f,
  -7.03246146e-02f, -8.27956423e-02f, 6.14220239e-02f, 6.62794635e-02f, 4.23165448e-02f, -8.64294246e-02f, -8.09945539e-02f, 2.14343667e-02f, 5.09402268e-02f, 2.26021279e-02f,
  -7.56873861e-02f, -5.70581779e-02f, -3.04819196e-02f, 4.38284241e-02f, 5.31792827e-02f, 1.17760869e-02f, 2.38279626e-02f, 2.43901592e-02f, -9.48112365e-03f, 8.55567232e-02f,
  -2.70755012e-02f, -3.94425206e-02f, -3.75222117e-02f, -3.23316902e-02f, -8.85962620e-02f, 5.40470332e-02f, 2.29978487e-02f, 6.32071197e-02f, -6.93843886e-02f, -6.82800040e-02f,
  4.71683480e-02f, -4.70123589e-02f, 2.71519329e-02f, -2.23605821e-04f, -7.17916563e-02f, -8.28106552e-02f, 5.48841804e-02f, 5.70560843e-02f, -8.43604952e-02f, 5.51395118e-03f,
  -6.09971881e-02f, -4.42717001e-02f, 5.57816401e-02f, 4.55309339e-02f, -8.50461423e-02f, -8.17316175e-02f, 3.43807228e-02f, 5.05531169e-02f, 5.45373522e-02f, -7.92907737e-03f,
  -3.76486070e-02f, -2.35005096e-02f, 8.09816420e-02f, 1.48152998e-02f, -6.28606826e-02f, 2.15921476e-02f, -3.22642699e-02f, 6.03614785e-02f, 7.43135996e-03f, -1.42576946e-02f,
  -5.15969619e-02f, -1.84663211e-03f, -1.70605991e-03f, 8.45556110e-02f, -1.49600767e-02f, 4.83807921e-02f, 6.79275393e-02f, -2.09365599e-02f, -3.80940805e-03f, 6.56411424e-02f,
  -6.60450757e-03f, -1.07847946e-02f, 7.42549226e-02f, -5.98874204e-02f, -7.70863518e-02f, -7.25820586e-02f, -3.87643166e-02f, -4.40394171e-02f, -4.04757187e-02f, -6.61408007e-02f,
  5.66110909e-02f, -7.88966492e-02f, 1.12020932e-02f, -4.38345857e-02f, 4.89131585e-02f, -7.49779493e-02f, 3.14792693e-02f, 6.48293719e-02f, 7.18349069e-02f, 6.90597221e-02f,
  -2.12534983e-02f, -1.15216221e-03f, -3.86391059e-02f, -1.49812102e-02f, 6.23974241e-02f, -2.09216103e-02f, -2.79175881e-02f, 1.03290752e-02f, 8.21016803e-02f, -2.47056666e-03f,
  1.76255368e-02f, 8.01238716e-02f, -5.97787835e-02f, -9.41728335e-03f, -6.07830053e-03f, 6.92592412e-02f, 4.94174920e-02f, -8.72693839e-04f, 1.93577632e-02f, -6.85423687e-02f,
  -3.31233325e-03f, -2.55312212e-02f, -6.39590621e-02f, -7.08304271e-02f, -2.71233767e-02f, -3.27030942e-02f, -5.10945320e-02f, 6.49980083e-02f, 3.03136986e-02f, 6.77550584e-02f,
  -3.94969508e-02f, -1.00012450e-03f, -2.68427026e-03f, 2.41637155e-02f, 5.84688671e-02f, 9.60603654e-02f, -5.24782129e-02f, 2.34257430e-02f, 7.61243096e-03f, -1.82563793e-02f,
  -3.80714657e-03f, 7.96542689e-02f, 7.68159181e-02f, 6.97787553e-02f, 3.11440080e-02f, -3.98619808e-02f, 4.96698841e-02f, 1.39659252e-02f, 1.45853683e-02f, 9.30869132e-02f,
  8.85661989e-02f, -3.50254700e-02f, -4.23262529e-02f, -3.74959991e-03f, 5.76703250e-02f, -3.99823599e-02f, 3.13289911e-02f, -2.18895879e-02f, 3.56390700e-02f, 7.25023309e-03f,
  8.15628991e-02f, -4.79873881e-04f, -2.98664458e-02f, 9.66528896e-03f, 9.98530537e-02f, 6.62233680e-02f, 4.78401333e-02f, -4.63999920e-02f, 9.48838368e-02f, 3.26530673e-02f,
  -8.45984221e-02f, 1.17585346e-01f, -4.83548939e-02f, -8.12730927e-04f, 8.47418979e-02f, -2.22601974e-03f, 2.00981852e-02f, 1.11640468e-01f, -8.90409946e-02f, 5.58178406e-03f,
  5.15803099e-02f, 8.63958523e-02f, -1.82543113e-03f, -5.27997762e-02f, -5.79819679e-02f, 4.36097980e-02f, -8.29027295e-02f, 4.06354330e-02f, 4.71453927e-02f, -1.07229194e-02f,
  1.39366701e-01f, 4.53556515e-02f, -1.28596919e-02f, 2.64463238e-02f, 4.53398563e-03f, 7.90102482e-02f, 1.88913103e-02f, 3.67513187e-02f, -8.57825503e-02f, 4.92167659e-02f,
  -4.15267795e-02f, 4.52148467e-02f, 7.22802430e-02f, -1.40228532e-02f, -1.33493245e-01f, 8.51461366e-02f, -6.79034889e-02f, -1.35008678e-01f, 6.81442767e-03f, -6.48987480e-03f,
  -2.64387541e-02f, -1.03740193e-01f, -1.44512922e-01f, -1.82660267e-01f, -7.66181201e-02f, 3.75315733e-02f, -9.13595930e-02f, -1.39111243e-02f, 6.40749410e-02f, 8.79873931e-02f,
  5.38558401e-02f, -6.84560910e-02f, 4.99275662e-02f, -4.68840683e-03f, 4.48223129e-02f, -8.60718340e-02f, 9.49864313e-02f, -1.12590663e-01f, -8.73178244e-02f, 7.30764195e-02f,
  -3.20901088e-02f, 9.60490033e-02f, 6.48223385e-02f, 5.00219539e-02f, -5.76005876e-03f, 4.97754589e-02f, -5.81996962e-02f, 3.07219923e-02f, 3.97339463e-02f, 4.89576422e-02f,
  4.87592481e-02f, 7.85257295e-02f, 2.97806808e-04f, 2.50598621e-02f, 1.85831171e-02f, 9.71976668e-03f, 9.68298502e-03f, 9.27098468e-03f, -8.60418603e-02f, 2.44019795e-02f,
  6.77390397e-02f, 7.56026059e-03f, -1.70834176e-02f, 1.30639687e-01f, 7.78887197e-02f, 6.96430206e-02f, 5.21243699e-02f, -5.94075248e-02f, 7.42115229e-02f, 2.72864792e-02f,
  -3.24235708e-02f, 1.12752013e-01f, -4.00737002e-02f, 1.07891813e-01f, -1.53852077e-02f, 7.93902129e-02f, -3.92509103e-02f, 6.96281530e-03f, 8.66898447e-02f, 6.12013638e-02f,
  9.38158929e-02f, 5.18656969e-02f, -3.38115171e-02f, -1.99877061e-02f, 1.07309416e-01f, 6.46482781e-02f, 1.05316155e-01f, -2.93841716e-02f, 1.76571999e-02f, 9.54276696e-03f,
  -7.94083811e-03f, -3.30123305e-02f, -6.71182945e-02f, -4.11848761e-02f, 8.42830837e-02f, -2.04479974e-03f, 1.09886989e-01f, -5.94650656e-02f, 1.09846219e-02f, 5.07796928e-02f,
  -3.11768111e-02f, 6.90989345e-02f, 1.59381449e-01f, -1.52023649e-02f, -5.30734435e-02f, -3.32100019e-02f, 1.03866450e-01f, -4.06687520e-02f, 1.21764585e-01f, 3.08447052e-03f,
  8.54157060e-02f, 9.59695056e-02f, 5.36901597e-03f, 6.62733912e-02f, -5.05632954e-03f, 6.15314357e-02f, 7.32054338e-02f, 9.10484791e-02f, 1.54179603e-01f, 6.74285963e-02f,
  2.76600476e-02f, 7.85856843e-02f, 5.22433557e-02f, -9.83399898e-02f, -4.02604043e-03f, -9.27193463e-03f, 1.23171993e-01f, -9.91492942e-02f, -1.69833601e-01f, -8.60994384e-02f,
  -1.10992817e-02f, 6.98179156e-02f, 5.95531128e-02f, 1.23785578e-01f, -6.40382916e-02f, -3.51856649e-03f, -8.31632093e-02f, 7.63875321e-02f, -9.85047743e-02f, -2.27768486e-03f,
  6.40983880e-02f, -3.89299355e-02f, -1.22789949e-01f, 4.31125797e-02f, -6.67129979e-02f, -9.85002369e-02f, -2.03399751e-02f, -9.93168131e-02f, -2.27785688e-02f, -3.66812060e-03f,
  1.75376404e-02f, -3.63664404e-02f, -1.42864689e-01f, -5.05011790e-02f, -1.60476759e-01f, 1.26505315e-01f, 1.34126276e-01f, -7.29110986e-02f, 1.31288229e-03f, -3.41721661e-02f,
  4.70095985e-02f, 1.02879852e-01f, -4.07771170e-02f, -5.43669201e-02f, -1.01764716e-01f, -1.64899558e-01f, 7.54204020e-02f, 5.67876622e-02f, 1.31512523e-01f, -1.06203128e-02f,
  1.28747791e-01f, -1.00244790e-01f, 4.78260294e-02f, 5.43889441e-02f, 2.61752475e-02f, 6.18459983e-03f, 6.39685988e-02f, -1.18106185e-02f, 4.81574126e-02f, -5.70508316e-02f,
  2.52089147e-02f, -8.65261927e-02f, -3.69300433e-02f, 1.32560149e-01f, 9.09819901e-02f, 4.58159819e-02f, 2.52518747e-02f, -2.73817498e-02f, -7.93946832e-02f, -5.53321391e-02f,
  1.35934539e-02f, 7.64098391e-02f, 8.68717730e-02f, 5.77267632e-02f, 5.31582385e-02f, -8.14025924e-02f, 1.32608429e-01f, -5.67827038e-02f, 5.41723073e-02f, 1.67975090e-02f,
  -5.79272248e-02f, 2.13585608e-02f, 6.24479316e-02f, -2.28805132e-02f, 6.95906505e-02f, 2.06712745e-02f, 3.33183748e-03f, 7.37645011e-03f, -3.92574519e-02f, 4.29434404e-02f,
  6.64602816e-02f, 4.86865900e-02f, 5.52663915e-02f, -4.21265624e-02f, 1.06895827e-01f, -4.03155275e-02f, 7.98859298e-02f, 8.11539143e-02f, 1.00603662e-01f, -1.53861828e-02f,
  -2.62433221e-03f, 1.06155418e-01f, -2.48051286e-02f, -2.34712493e-02f, 5.22133335e-02f, 1.09869719e-01f, 7.39454776e-02f, -9.44565907e-02f, -8.97750724e-03f, 7.69021437e-02f,
  1.28459319e-01f, 8.46192688e-02f, 5.83339110e-02f, 2.73849629e-03f, -3.27118523e-02f, 9.31100771e-02f, 9.63638499e-02f, -3.08826653e-04f, -5.23811914e-02f, 1.51276842e-01f,
  1.62755966e-01f, 1.09965853e-01f, 1.37431920e-01f, -1.09610148e-02f, -5.68439476e-02f, 6.07334822e-02f, 7.46698380e-02f, -1.47117777e-02f, -6.61182478e-02f, 4.17107753e-02f,
  1.11311868e-01f, -9.95609909e-03f, -5.79004958e-02f, 1.62989891e-03f, 9.51630399e-02f, -4.48191427e-02f, -3.67084593e-02f, -6.78940043e-02f, -7.75919780e-02f, -5.56357391e-02f,
  -9.85673815e-02f, -2.42644958e-02f, 6.24053925e-03f, 1.53481781e-01f, 8.52654409e-03f, -5.95653802e-02f, -5.05621918e-02f, 1.25628486e-02f, -9.59108323e-02f, 4.80194725e-02f,
  1.48694694e-01f, -4.58079129e-02f, -1.32444024e-01f, -1.68083911e-03f, -6.91404119e-02f, -3.42863845e-04f, -1.08920962e-01f, 1.11851923e-01f, -1.06037883e-02f, 1.00974239e-01f,
  -3.38167287e-02f, 1.44631356e-01f, -3.51344012e-02f, 1.88848730e-02f, -1.43185511e-01f, 1.34929374e-03f, -7.48215541e-02f, 4.98837382e-02f, -2.70143896e-02f, 6.17665350e-02f,
  -4.83460613e-02f, 6.17291825e-03f, -7.06384107e-02f, -9.92991403e-02f, 7.33068958e-02f, 2.81422446e-03f, 1.27353877e-01f, -4.52173166e-02f, -9.92250517e-02f, -1.88288957e-01f,
  7.39773810e-02f, 8.74521285e-02f, 4.82329838e-02f, 7.68372938e-02f, -9.53269191e-03f, 1.01491250e-01f, -2.19144318e-02f, 6.72437549e-02f, 9.77433026e-02f, -4.68099527e-02f,
  -1.02172596e-02f, -1.11799121e-01f, 1.12322509e-01f, -9.06838924e-02f, 2.39267219e-02f, 8.02962407e-02f, -1.80153847e-02f, 7.97609165e-02f, 2.91031022e-02f, 1.84204932e-02f,
  1.65256828e-01f, 1.17147505e-01f, 8.56465995e-02f, 1.18816406e-01f, 5.12317829e-02f, 2.55241431e-02f, -3.67211998e-02f, 5.61786955e-03f, -4.47226986e-02f, 8.98911208e-02f,
  4.24150787e-02f, 9.47831422e-02f, 5.99564724e-02f, 9.12179425e-02f, 4.64170910e-02f, 1.17384724e-01f, 6.23331442e-02f, 7.81280547e-03f, 4.84738015e-02f, 7.18774498e-02f,
  -1.49385473e-02f, -1.00506730e-02f, 9.24221650e-02f, 4.40900214e-02f, 9.64029655e-02f, -2.80903541e-02f, -2.25577708e-02f, 9.33460444e-02f, 5.98914735e-02f, -3.76242548e-02f,
  -5.98897450e-02f, 9.21076834e-02f, 1.46967098e-01f, 8.49116407e-03f, 3.68671231e-02f, -4.28600237e-02f, -8.49088877e-02f, 3.82664986e-02f, -1.87557060e-02f, -3.20494995e-02f,
  2.47043408e-02f, 8.78772065e-02f, 7.65871815e-03f, 4.27225977e-03f, 8.23652074e-02f, -4.31766994e-02f, -2.30066734e-03f, 4.84463274e-02f, 1.32677093e-01f, 6.45850450e-02f,
  -3.31386775e-02f, 7.49360844e-02f, 2.02306099e-02f, -7.69496635e-02f, -2.03751884e-02f, -3.93820703e-02f, 6.25385642e-02f, 1.20712161e-01f, 4.43858914e-02f, -3.23977992e-02f,
  9.74085480e-02f, 1.26201706e-03f, -3.17423604e-02f, -3.20044570e-02f, -1.37012064e-01f, 4.07935083e-02f, -1.27464965e-01f, 2.94781066e-02f, 3.33244503e-02f, 6.89197006e-03f,
  -1.02152556e-01f, 2.33288798e-02f, 1.24234162e-01f, 6.87929094e-02f, 9.12240148e-02f, -3.89628559e-02f, -1.32298425e-01f, 7.05745593e-02f, 1.53131887e-01f, -1.68651402e-01f,
  -3.59289162e-02f, 1.07670918e-01f, 2.22074185e-02f, -1.10568022e-02f, -6.45386204e-02f, 1.45485669e-01f, 1.03131250e-01f, -5.18157845e-03f, 9.71442834e-02f, 1.51668772e-01f,
  5.87243438e-02f, 6.88007250e-02f, -3.39426883e-02f, -1.50527567e-01f, 1.50699606e-02f, 1.33021519e-01f, 3.09557952e-02f, -6.24117181e-02f, -9.71105397e-02f, -9.88684744e-02f,
  -3.52390930e-02f, 1.46017233e-02f, 6.68864027e-02f, -2.37842165e-02f, 1.38599306e-01f, -1.23248354e-01f, -4.92207855e-02f, -8.12644213e-02f, 5.31560294e-02f, 1.09367575e-02f,
  1.85885746e-02f, 3.64991054e-02f, 4.20892574e-02f, -7.93563873e-02f, -7.86219898e-05f, 6.04527220e-02f, 3.06850392e-02f, -5.01190089e-02f, 3.12233865e-02f, -1.02917641e-01f,
  3.59358708e-03f, -3.32514085e-02f, 1.54636368e-01f, 4.56205830e-02f, 1.55414408e-02f, 2.63076462e-03f, -3.22779827e-02f, -1.13980975e-02f, -2.44194940e-02f, -4.59249243e-02f,
  2.98421904e-02f, 5.08501343e-02f, 1.00290321e-01f, 1.05906770e-01f, 6.17038310e-02f, -9.12296548e-02f, -1.55473528e-02f, -1.31711075e-02f, 3.93726397e-03f, 1.19637750e-01f,
  -1.73173808e-02f, 2.31922343e-02f, 6.91536441e-02f, 9.06840488e-02f, 6.00244431e-03f, 1.03384294e-01f, 9.43937674e-02f, 2.82879304e-02f, -6.47332193e-03f, 9.98661816e-02f,
  9.56722498e-02f, 2.36307904e-02f, 6.49183467e-02f, -4.94514517e-02f, -6.96072727e-02f, 4.94706780e-02f, -3.72059457e-02f, 9.23406631e-02f, 1.89236994e-03f, 8.63547847e-02f,
  1.58737469e-02f, -9.74348187e-03f, 3.60668935e-02f, 6.04115650e-02f, -1.47258323e-02f, -8.18476304e-02f, -3.45500745e-02f, 7.73239732e-02f, -1.03352424e-02f, 6.60876483e-02f,
  8.89735743e-02f, 1.40723303e-01f, 9.22355428e-03f, 5.52246422e-02f, -1.35484952e-02f, 2.88433172e-02f, 9.01089422e-03f, 9.43071991e-02f, -4.32150289e-02f, 8.85077044e-02f,
  3.94452550e-02f, 1.69974528e-02f, 1.92794487e-01f, 9.48367342e-02f, 3.55243757e-02f, -3.49338129e-02f, 4.82132398e-02f, 4.74232323e-02f, -1.01087168e-01f, 1.23096399e-01f,
  9.88173708e-02f, 5.88907972e-02f, 5.59397005e-02f, -8.60930309e-02f, 1.42993659e-01f, 5.12068234e-02f, -1.22076340e-01f, 9.69221145e-02f, 8.10219254e-03f, -2.56671105e-02f,
  -1.89561799e-01f, -2.38446835e-02f, 1.08955167e-01f, 7.11883381e-02f, 8.93401504e-02f, 8.50587338e-02f, -1.90252379e-01f, 1.48438781e-01f, 2.47345101e-02f, -1.52617559e-01f,
  2.36798134e-02f, 7.52302334e-02f, 2.07408741e-02f, 5.30231968e-02f, -1.73302084e-01f, -5.03893569e-02f, -1.83468554e-02f, -1.55702010e-01f, 9.83477905e-02f, -1.50617912e-01f,
  8.99028406e-03f, 1.06296875e-01f, 1.29566535e-01f, -1.37347087e-01f, 9.18430015e-02f, -1.42791970e-02f, -1.47949994e-01f, 6.40613660e-02f, -2.93582231e-02f, 8.49378556e-02f,
  -1.79945841e-01f, 1.68864742e-01f, -1.20502852e-01f, 9.24095958e-02f, 1.39417946e-01f, 2.81109661e-01f, -3.09459925e-01f, -3.94364931e-02f, -2.40195892e-03f, -3.32652293e-02f,
  1.78199589e-01f, 6.57819360e-02f, 6.42844215e-02f, 1.37547478e-02f, 1.68870005e-03f, 2.53676295e-01f, -1.38866946e-01f, 9.78114782e-04f, 9.10566300e-02f, -2.75640804e-02f,
  -3.38896997e-02f, -8.09969604e-02f, -1.09952770e-01f, -3.30662983e-03f, -2.71360632e-02f, 1.04702383e-01f, -3.53525877e-02f, 1.28419220e-01f, -9.83735174e-03f, -5.32976985e-02f,
  6.30965084e-02f, 1.91466063e-02f, -3.54577005e-02f, -3.01515441e-02f, 1.06224483e-02f, 6.80729449e-02f, 5.42002497e-03f, -3.07533592e-02f, -5.29821329e-02f, -2.62295716e-02f,
  -7.43830651e-02f, 7.21081644e-02f, 8.92936960e-02f, -6.76738918e-02f, 2.40947008e-02f, 5.47479950e-02f, -7.76050687e-02f, 9.48775634e-02f, 3.64273712e-02f, -4.07815725e-02f,
  -9.55078693e-04f, -5.47312088e-02f, -7.18744993e-02f, -6.81057125e-02f, -2.18855385e-02f, 3.00991777e-02f, 6.37662783e-02f, -6.83605745e-02f, 7.86830485e-02f, -3.76372859e-02f,
  -7.57073686e-02f, -4.72832657e-02f, 7.51815736e-02f, -4.73251641e-02f, 6.61939085e-02f, -3.65131721e-02f, 1.19411005e-02f, 4.70661605e-03f, -6.27907366e-02f, 3.28845046e-02f,
  -8.70593265e-02f, 2.95415539e-02f, 7.72848651e-02f, -4.16727737e-02f, 1.58287808e-02f, -3.91921215e-02f, 4.14312482e-02f, -8.23876187e-02f, 6.35901466e-02f, 2.48482302e-02f,
  2.13921573e-02f, 8.96453708e-02f, 7.78227374e-02f, -3.12447175e-02f, 4.83779749e-03f, 4.44063209e-02f, -8.40128139e-02f, 4.13388060e-03f, -1.30867856e-02f, 5.83096854e-02f,
  -7.58297369e-02f, 4.28769700e-02f, 9.05283447e-03f, -7.92154390e-03f, 6.47123605e-02f, 3.91546115e-02f, 8.81020650e-02f, 4.63971682e-02f, 6.36529028e-02f, -8.81516114e-02f,
  5.93989454e-02f, -3.39462049e-02f, -6.59657568e-02f, -8.47230256e-02f, -5.66973388e-02f, 1.64278354e-02f, -4.60800044e-02f, 3.12038623e-02f, -3.04638990e-03f, 9.49217752e-03f,
  7.49854371e-02f, 8.22077692e-03f, -2.51001865e-02f, -3.82408127e-02f, -6.45037293e-02f, -1.30532756e-02f, 2.69280579e-02f, 4.13135402e-02f, -8.04272853e-03f, 7.96274468e-02f,
  3.76694761e-02f, -6.54154271e-02f, -8.51489082e-02f, 2.98716631e-02f, 8.71207342e-02f, 8.98146350e-03f, 4.14532535e-02f, 7.08747283e-02f, -7.72417858e-02f, 5.48228770e-02f,
  -8.40960592e-02f, 2.64867749e-02f, -3.79884318e-02f, 8.37720558e-02f, 8.32613781e-02f, -1.19715836e-02f, 4.15956825e-02f, 8.84887204e-02f, -5.07627353e-02f, 1.06410589e-02f,
  -4.47436906e-02f, 3.16625908e-02f, -4.59113158e-02f, 4.59986664e-02f, -2.91331857e-02f, -1.61666311e-02f, -5.39626181e-02f, 1.08237639e-02f, 8.77668932e-02f, -3.60715166e-02f,
  -4.37836573e-02f, 8.44643936e-02f, 7.36777410e-02f, 2.86214780e-02f, -3.01598087e-02f, -8.05544481e-02f, -3.93130556e-02f, 7.55549967e-03f, -5.57338037e-02f, 6.84134150e-03f,
  -7.52674341e-02f, 3.07768006e-02f, -8.35862234e-02f, 2.49559954e-02f, -3.54659371e-02f, 7.93418363e-02f, -3.23388651e-02f, -2.35588793e-02f, 5.81766739e-02f, -2.21507307e-02f,
  -4.00891863e-02f, 3.76209468e-02f, 4.77492772e-02f, -5.01743518e-02f, -1.37281120e-02f, 2.39772946e-02f, -6.55001253e-02f, -6.70018122e-02f, 7.15855807e-02f, -5.44676511e-03f,
  -1.24339378e-02f, -6.31355196e-02f, -1.03787845e-02f, -7.43823051e-02f, 3.32072154e-02f, -7.21900463e-02f, 1.05311573e-02f, -1.82365477e-02f, -5.44733144e-02f, -5.43634593e-02f,
  8.23692605e-02f, -8.19031671e-02f, 8.63794982e-03f, 3.53878364e-02f, 8.15451369e-02f, -3.87986116e-02f, -3.80594879e-02f, -3.61775160e-02f, -5.56537025e-02f, -6.74197748e-02f,
  7.78638273e-02f, 5.63904718e-02f, 7.70187229e-02f, -8.74236822e-02f, -1.20667201e-02f, 3.68808657e-02f, -1.09431492e-02f, -8.62030983e-02f, 1.17528979e-02f, -6.04706965e-02f,
  -1.04483850e-02f, 3.30561632e-03f, 1.01731177e-02f, 8.28351453e-02f, -2.35159658e-02f, 5.75266555e-02f, 5.03738001e-02f, -2.46720435e-03f, -3.75965796e-02f, -5.76633587e-02f,
  4.73759361e-02f, -7.13767558e-02f, -2.27434747e-02f, 3.66483517e-02f, 6.77948538e-03f, 5.26102521e-02f, 4.18756492e-02f, -2.27886103e-02f, -1.13218278e-02f, -5.23174144e-02f,
  3.19973659e-03f, -5.15694730e-02f, -1.94363408e-02f, 3.06824688e-03f, 3.20979394e-02f, -5.98305278e-03f, 4.09437567e-02f, 5.17314076e-02f, -2.73268819e-02f, -7.35902339e-02f,
  -1.90690607e-02f, 3.37854610e-03f, 5.75703792e-02f, 6.77638277e-02f, 7.12451786e-02f, 5.67821190e-02f, -4.36120294e-02f, -7.39661455e-02f, 2.79322434e-02f, 4.23437804e-02f,
  3.10961474e-02f, -5.06348908e-02f, 2.16990225e-02f, 4.93347719e-02f, -6.66645765e-02f, -1.94529295e-02f, -3.09881177e-02f, 6.05062395e-02f, -6.69272244e-03f, -4.15847301e-02f,
  -4.00445834e-02f, -3.83861549e-02f, -3.70613337e-02f, -4.82807308e-02f, -2.54739579e-02f, 6.35290146e-02f, -4.23284993e-02f, -5.63190579e-02f, 6.92918301e-02f, -9.73512884e-03f,
  8.17567334e-02f, 8.41446072e-02f, 4.12159450e-02f, -3.59828025e-02f, -8.27042852e-03f, -4.24949639e-02f, -7.35309497e-02f, -8.40649661e-03f, -6.95042536e-02f, 4.80267182e-02f,
  6.06669784e-02f, 7.12740943e-02f, 9.47531313e-03f, -7.66502470e-02f, 6.76573664e-02f, -1.65613405e-02f, -4.40501943e-02f, -1.98013969e-02f, -7.54437223e-02f, 1.24762449e-02f,
  8.50949436e-02f, 8.24711770e-02f, -4.06855457e-02f, -2.11997870e-02f, 9.04673263e-02f, 8.89379680e-02f, 1.59735177e-02f, -6.01948760e-02f, 2.70189531e-02f, -2.13854834e-02f,
  8.20873007e-02f, 2.55498420e-02f, 1.77448895e-03f, 2.84106415e-02f, 6.46191165e-02f, 1.81719847e-02f, 2.61846650e-02f, -8.05678889e-02f, 1.55908726e-02f, -5.02403267e-02f,
  1.54291792e-02f, 2.08273586e-02f, 7.20197037e-02f, -4.77794185e-02f, -2.77009625e-02f, 4.54650447e-02f, -6.46238259e-05f, -9.17327311e-03f, 7.84925073e-02f, -1.46755921e-02f,
  5.70766665e-02f, 6.51397929e-02f, 6.50810897e-02f, -6.74640909e-02f, 1.83542166e-02f, -4.70080003e-02f, 5.33021502e-02f, -3.59514169e-02f, 8.15356672e-02f, 6.72766045e-02f,
  3.80300097e-02f, 2.82873996e-02f, -2.35273708e-02f, 9.45623126e-03f, 7.24811573e-03f, -8.35398361e-02f, -4.14194800e-02f, -8.18323530e-03f, 4.75963093e-02f, 1.14148378e-01f,
  -4.10015322e-02f, 1.79925794e-03f, 9.84021872e-02f, 1.31063789e-01f, 1.02031872e-01f, -7.90869631e-03f, -1.25108324e-02f, -7.45775402e-02f, 1.44872770e-01f, 8.14095587e-02f,
  2.96800546e-02f, 6.55167773e-02f, 4.80108447e-02f, -5.00216484e-02f, -4.11490351e-02f, 5.73578551e-02f, 3.44477855e-02f, 8.24062154e-02f, 3.70358303e-02f, -1.84751645e-01f,
  -7.18356073e-02f, 2.30995473e-02f, 1.34019881e-01f, -8.62237364e-02f, 8.53513367e-03f, -1.96022242e-01f, 3.95950153e-02f, -7.20343664e-02f, -4.34812792e-02f, -7.89882094e-02f,
  -3.10645401e-02f, -3.27397473e-02f, -1.07108736e-02f, 5.33771291e-02f, 1.69937775e-01f, 1.03288412e-01f, -5.87030165e-02f, -2.61988789e-02f, -2.35735103e-02f, 7.39218108e-03f,
  -4.93993945e-02f, 6.28543049e-02f, 1.25819504e-01f, -6.46110177e-02f, 2.53587328e-02f, 7.61799142e-02f, -8.61971304e-02f, 1.28663350e-02f, -1.11166544e-01f, 3.55956927e-02f,
  1.13164693e-01f, 4.91579510e-02f, 9.54716094e-03f, 5.33815995e-02f, -2.46395152e-02f, -2.82196365e-02f, -7.44480714e-02f, 8.04902166e-02f, 9.20890719e-02f, 1.59807473e-01f,
  -7.51189590e-02f, 3.43906917e-02f, 1.44988280e-02f, 5.70829846e-02f, 4.44344990e-02f, -8.83313417e-02f, 5.64885624e-02f, -6.19310932e-03f, 3.45762037e-02f, 1.00873291e-01f,
  -1.00699477e-01f, -6.21161330e-03f, 8.00199211e-02f, -2.38853227e-03f, -4.00853120e-02f, 1.24391451e-01f, 6.92252219e-02f, 7.32790353e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.49767601e-02f, 4.36016209e-02f, -1.44660315e-02f, -5.30934893e-03f, -7.89442509e-02f, -1.71384886e-02f, 2.34761797e-02f, 3.34030874e-02f, 1.32703349e-01f, -4.43062745e-02f,
  -4.18542549e-02f, 8.09688270e-02f, 1.73447020e-02f, 3.79803814e-02f, 5.23324385e-02f, -4.56321575e-02f, 7.23726451e-02f, 4.85609099e-02f, 8.57991502e-02f, -2.32299254e-03f,
  1.37016934e-03f, 6.09884225e-02f, -3.88785172e-03f, -3.62298042e-02f, -1.23445056e-02f, 2.74005365e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  1.83229111e-02f, -2.89758563e-01f, -1.64530009e-01f, -1.60497203e-01f, -6.90581501e-02f, -6.87298179e-02f, 1.00148700e-01f, -2.03474667e-02f, 1.22980773e-02f, -1.07058380e-02f,
  2.55434718e-02f, -9.61136259e-03f, 9.40706581e-02f, -5.93782626e-02f, -1.67961776e-01f, 1.12091139e-01f, -2.33472854e-01f, -5.44157811e-02f, 2.77410168e-02f, 1.01167008e-01f,
  -1.83347180e-01f, 4.24898900e-02f, -1.31489001e-02f, -4.36186977e-02f, -2.60913279e-02f, 9.09180641e-02f, 4.93063517e-02f, -3.31368119e-01f, -6.16677739e-02f, 1.07828319e-01f,
  2.26248018e-02f, 1.57957990e-02f, -2.74094492e-01f, 2.07590342e-01f, 6.31290823e-02f, 1.46353409e-01f, -1.20325252e-01f, 1.01963142e-02f, -9.44004729e-02f, 6.42205179e-02f,
  9.47400406e-02f, -9.27453339e-02f, 1.86932072e-01f, -1.93185493e-01f, -2.09448740e-01f, 1.25392944e-01f, -1.94428433e-02f, -1.79148510e-01f, -4.39640582e-02f, 6.20520301e-02f,
  7.81476274e-02f, -1.25384510e-01f, -2.96148032e-01f, -3.26609284e-01f, 2.68039107e-01f, 1.63686797e-01f, -1.45644560e-01f, -4.08294164e-02f, -2.12874472e-01f, 2.12113410e-01f,
  -1.82636872e-01f, -7.69663677e-02f, 2.24181250e-01f, -1.59919515e-01f, 1.56660974e-01f, -5.23623489e-02f, 5.20137846e-02f, 2.02001899e-01f, 2.10397929e-01f, -3.58340174e-01f,
  1.18777029e-01f, 1.04516298e-01f, 2.09482014e-01f, 8.70072171e-02f, -2.63486564e-01f, -1.14246644e-01f, -1.21836975e-01f, -2.02047482e-01f, -1.63189024e-01f, -2.17350125e-01f,
  -1.01335160e-03f, -1.83199093e-01f, -1.15564413e-01f, -1.30607873e-01f, -1.73761010e-01f, -3.06776196e-01f, -1.36478335e-01f, -1.99144527e-01f, -1.53480947e-01f, -8.70205313e-02f,
  -6.38734475e-02f, -8.53930041e-02f, 1.92077011e-01f, -1.65109217e-01f, -1.32748140e-02f, -2.05135494e-01f, -8.03337768e-02f, 1.27486452e-01f, 8.65345374e-02f, -2.13577807e-01f,
  8.26504305e-02f, -8.99567753e-02f, -7.71167055e-02f, -6.57003894e-02f, -7.99511373e-03f, -4.86972295e-02f, -7.39421397e-02f, 7.36829042e-02f, -3.94042313e-01f, 3.59076634e-02f,
  2.69733012e-01f, 5.71737140e-02f, -2.12672114e-01f, -2.99229115e-01f, -3.69169153e-02f, 3.79741073e-01f, 4.14432287e-01f, 8.62746835e-02f, -8.32019448e-02f, 5.31740077e-02f,
  -2.21014991e-01f, -1.92917824e-01f, -1.12191163e-01f, 4.65394137e-03f, -2.22517028e-01f, -4.38202871e-03f, 3.42684314e-02f, 1.39052838e-01f, -6.41006231e-02f, -1.31163761e-01f,
  -1.64870143e-01f, -1.22707054e-01f, 2.17913523e-01f, -5.63676171e-02f, -8.55061263e-02f, -3.34856629e-01f, 1.56856254e-02f, 8.01865458e-02f, -1.46552980e-01f, 7.75509104e-02f,
  -9.54218954e-02f, -1.22073241e-01f, 8.51969048e-02f, 1.23420194e-01f, -1.49048612e-01f, 1.03831798e-01f, 1.73650354e-01f, 5.01858890e-02f, 1.84882849e-01f, 2.97180474e-01f,
  1.65508732e-01f, -3.51101831e-02f, -6.01641573e-02f, -8.47044960e-02f, -2.16872003e-02f, 2.67469883e-02f, 5.15849888e-02f, 9.13059637e-02f, -5.40034436e-02f, 1.87908098e-01f,
  2.33606294e-01f, -3.47726382e-02f, -1.58155225e-02f, 1.92782506e-01f, 1.43918991e-01f, -1.25420615e-01f, 1.50897667e-01f, -9.11547020e-02f, -3.06938519e-03f, 5.20987846e-02f,
  8.15120637e-02f, -1.37498468e-01f, -1.13447547e-01f, -3.27583313e-01f, -9.94568598e-03f, -1.16587877e-01f, 4.31816243e-02f, -3.59181091e-02f, -2.10559610e-02f, 2.11325109e-01f,
  -2.38535926e-01f, -3.07473332e-01f, 2.28411064e-01f, -1.65556446e-01f, -1.87345713e-01f, -2.98445195e-01f, -2.57392347e-01f, -1.50674313e-01f, -1.86369345e-01f, -3.18220049e-01f,
  -1.29770070e-01f, -2.93051869e-01f, -7.90027156e-02f, -4.98721115e-02f, -1.99105710e-01f, 2.30484828e-01f, -3.56663130e-02f, 1.52537093e-01f, -1.19209751e-01f, 1.45752639e-01f,
  -6.96600080e-02f, -1.48951843e-01f, 1.51943356e-01f, -2.38789648e-01f, 1.98308587e-01f, 6.39970899e-02f, -1.58479393e-01f, -1.96229741e-01f, 6.10641390e-02f, -2.26046637e-01f,
  -1.41627908e-01f, -1.23521341e-02f, -4.71226662e-01f, -3.35687399e-02f, 9.23300385e-02f, 1.87614381e-01f, 6.87027350e-02f, -7.88318440e-02f, -2.68175751e-01f, -2.56999642e-01f,
  1.18852086e-01f, -2.40069166e-01f, 4.44218628e-02f, 6.30406439e-02f, -3.27127457e-01f, 1.01865241e-02f, -1.18142799e-01f, -1.44500718e-01f, -2.81802654e-01f, -2.81970173e-01f,
  -4.33328226e-02f, -2.34493941e-01f, -4.68617715e-02f, -1.62309203e-02f, -1.65952027e-01f, 2.47289062e-01f, -3.75611424e-01f, -9.51998755e-02f, 1.06077164e-01f, -6.55000806e-02f,
  2.23089457e-01f, 1.74815148e-01f, -3.67469678e-04f, -1.12186842e-01f, 3.91847432e-01f, 7.40229711e-02f, -1.06279152e-02f, -2.52792910e-02f, -2.15073183e-01f, -1.33900866e-01f,
  2.62174577e-01f, 3.64501148e-01f, -2.48742074e-01f, -9.52161849e-02f, -8.59105214e-02f, -1.42246246e-01f, 5.50327972e-02f, 2.09324092e-01f, -1.11159578e-03f, 5.70176579e-02f,
  -4.50976007e-02f, -2.95445248e-02f, -8.33777189e-02f, 2.72849156e-03f, 5.76519780e-02f, -1.31012527e-02f, 6.93759769e-02f, -1.69152431e-02f, 3.17828879e-02f, -2.45167017e-01f,
  2.52666026e-02f, 1.36422470e-01f, 1.41305119e-01f, 3.57215176e-03f, 1.51253015e-01f, 4.44626100e-02f, 1.42929330e-01f, -2.46774197e-01f, -4.91773374e-02f, 6.90858737e-02f,
  6.75597638e-02f, 1.91048882e-03f, -9.43493545e-02f, 1.93442479e-01f, -5.81359006e-02f, 7.40736648e-02f, 9.23653916e-02f, -3.94791454e-01f, -1.03371158e-01f, -1.52971581e-01f,
  2.68244803e-01f, -3.05838753e-02f, -1.06434129e-01f, 1.30270272e-01f, -2.11169958e-01f, -5.91550581e-02f, -3.53585817e-02f, 9.16272588e-03f, 6.97829872e-02f, 2.51643449e-01f,
  3.32126141e-01f, -1.92671210e-01f, -4.49214317e-02f, 1.71906918e-01f, 2.37761382e-02f, -1.09741524e-01f, 1.71978958e-02f, -3.00930560e-01f, -4.98810709e-02f, 1.49153853e-02f,
  -4.37106341e-02f, 1.86860468e-02f, -1.45356208e-01f, -1.35868117e-01f, 9.90784820e-03f, 2.28880439e-02f, 9.64905471e-02f, -1.25142202e-01f, -1.31953537e-01f, 1.88819572e-01f,
  1.51575312e-01f, 2.42310036e-02f, -1.18446939e-01f, -1.28152296e-01f, 1.24323733e-01f, -1.83042631e-01f, 1.12670794e-01f, 8.04131851e-02f, 2.61131048e-01f, 5.02200201e-02f,
  1.57977775e-01f, -3.34187597e-02f, 5.04061803e-02f, 7.65041560e-02f, -1.80347219e-01f, -2.51964152e-01f, -2.21198842e-01f, -1.43264294e-01f, -2.35812087e-02f, -1.98733017e-01f,
  2.45467916e-01f, -3.26408930e-02f, -5.51792085e-02f, -3.07043821e-01f, 4.81050787e-03f, -3.24012965e-01f, 8.36306736e-02f, -1.35976151e-02f, -1.26336455e-01f, -2.05589775e-02f,
  -2.45365232e-01f, -2.99285382e-01f, -9.51207280e-02f, 9.80555192e-02f, 1.22375116e-01f, -3.55001479e-01f, -2.63295829e-01f, 2.05301538e-01f, 4.13772054e-02f, 8.74091610e-02f,
  5.33774495e-02f, 4.64479364e-02f, -1.67111475e-02f, -2.98495330e-02f, -3.37092802e-02f, -1.54173523e-02f, 2.21238688e-01f, 3.64747308e-02f, 2.84652859e-01f, -2.44958237e-01f,
  -1.10770404e-01f, -2.37928584e-01f, 2.80587822e-01f, 2.74056625e-02f, 1.90310031e-01f, 7.21909478e-02f, -1.13810644e-01f, 1.09203286e-01f, 1.32663444e-01f, 1.27666146e-01f,
  5.33664152e-02f, 6.42279238e-02f, -9.82488040e-03f, -1.92500234e-01f, -4.20417897e-02f, 7.31721818e-02f, 4.29479554e-02f, 1.66384101e-01f, -1.42631009e-01f, -2.04426367e-02f,
  1.29095009e-02f, 1.47068888e-01f, 2.17614070e-01f, 6.77878875e-03f, -1.60378903e-01f, 1.37869462e-01f, -1.54657632e-01f, -2.13928018e-02f, 6.81375340e-02f, -3.22212614e-02f,
  1.83458850e-01f, 8.36425200e-02f, -1.64144486e-01f, -3.00840765e-01f, -1.29830122e-01f, -1.01051815e-01f, 5.44229187e-02f, -1.06456228e-01f, 3.78076732e-02f, 6.01843223e-02f,
  1.80611566e-01f, -8.59713331e-02f, 1.05335891e-01f, 1.69718519e-01f, -7.25306896e-03f, 2.38518447e-01f, -1.40860662e-01f, -5.99302910e-02f, 1.79197058e-01f, -2.10614782e-02f,
  2.64044348e-02f, 1.16812363e-01f, 1.30283117e-01f, 1.28321022e-01f, 6.08656146e-02f, 2.91762818e-02f, -7.57097751e-02f, -1.43994972e-01f, 1.91531688e-01f, 7.82087445e-02f,
  8.51318166e-02f, 3.63970385e-03f, 6.09486699e-02f, 2.79137623e-02f, 1.23189636e-01f, -2.32829764e-01f, 8.42106063e-03f, 2.15642214e-01f, -1.26689211e-01f, 1.00392208e-01f,
  -1.43155649e-01f, 5.97605482e-02f, 3.33958864e-01f, -1.40304521e-01f, 2.77211647e-02f, 4.22874957e-01f, -7.99065921e-03f, 3.61038178e-01f, 2.33052149e-01f, 1.14930943e-01f,
  1.71802461e-01f, 7.47905448e-02f, -2.44765088e-01f, 4.17631954e-01f, 2.65721023e-01f, 9.87985879e-02f, 7.68369660e-02f, -1.74322397e-01f, -2.69446313e-01f, -1.15716286e-01f,
  1.74447387e-01f, 9.51309595e-03f, -2.15563938e-01f, 2.47034460e-01f, -1.18825689e-01f, 2.68999040e-01f, -2.32327342e-01f, -1.50553599e-01f, 1.34077340e-01f, -1.18504316e-01f,
  -1.14906840e-01f, -1.59556136e-01f, -1.11505181e-01f, 1.51565880e-01f, -1.32325282e-02f, 1.22096330e-01f, 3.05945009e-01f, -4.97057624e-02f, -2.62050569e-01f, -1.69721991e-01f,
  2.82694757e-01f, -2.35752806e-01f, 1.83197141e-01f, -7.54738450e-02f, -6.07589781e-02f, 1.00410640e-01f, 2.86789667e-02f, -1.23643361e-01f, -3.36288884e-02f, 1.14229091e-01f,
  -2.64119338e-02f, 1.11084148e-01f, 3.23762670e-02f, 1.37579098e-01f, 3.86817455e-01f, -1.25399996e-02f, -1.32976577e-01f, -2.41624460e-01f, 9.41933393e-02f, -1.17297493e-01f,
  -1.79516241e-01f, -9.11078323e-03f, -5.22564352e-02f, 6.38774782e-03f, 7.32998028e-02f, -2.26521522e-01f, -2.43205637e-01f, -1.64941460e-01f, 3.66132915e-01f, -2.99500544e-02f,
  -2.17740871e-02f, -2.28374287e-01f, 5.96713787e-03f, 3.42659533e-01f, 1.49783418e-01f, 1.64759502e-01f, 9.24874023e-02f, 1.24078616e-01f, -2.84722969e-02f, 1.43762305e-01f,
  -8.68403632e-03f, 1.06350752e-02f, 1.82540849e-01f, 1.32561043e-01f, 1.12172388e-01f, 6.81795627e-02f, -3.01171988e-02f, -1.44320615e-02f, 7.77528062e-02f, 2.54674219e-02f,
  2.89198458e-01f, 2.28626773e-01f, -2.00090885e-01f, 1.78576320e-01f, 7.78529197e-02f, 2.01211065e-01f, 5.12218550e-02f, 1.08582243e-01f, 5.63308075e-02f, -1.53228223e-01f,
  1.47940535e-02f, -2.18883395e-01f, -1.08008850e-02f, 1.29529074e-01f, -2.63290673e-01f, -5.65414093e-02f, 9.94846448e-02f, -6.43655134e-04f, 1.01324834e-01f, -1.46040544e-02f,
  1.40877918e-03f, -9.23447311e-02f, 7.29003325e-02f, 2.16436163e-01f, -6.88424334e-03f, -1.05724320e-01f, 8.25363845e-02f, 1.67227849e-01f, 5.93866706e-02f, 2.24034682e-01f,
  1.75032318e-01f, 1.12808924e-02f, 1.34471521e-01f, -1.50852680e-01f, 1.18624575e-01f, -7.61719793e-02f, 5.97312674e-02f, -3.65387253e-03f, 1.89270437e-01f, 4.13262360e-02f,
  -9.67240259e-02f, 1.69793963e-01f, -1.56795412e-01f, -1.47614598e-01f, 1.76427394e-01f, 2.80615658e-01f, 2.87922826e-02f, -2.44216114e-01f, 2.48796299e-01f, 2.34311417e-01f,
  4.43610642e-03f, -1.90683320e-01f, 6.85808584e-02f, 1.06189355e-01f, 1.39033822e-02f, -1.16804279e-01f, -1.66123033e-01f, 2.73392797e-01f, -5.70871606e-02f, -2.03517064e-01f,
  -1.79762349e-01f, 4.24252868e-01f, 3.40971261e-01f, 1.08855367e-01f, 2.28236392e-01f, -4.89240773e-02f, 2.89556593e-01f, 4.49657552e-02f, -1.56967029e-01f, -2.02605501e-01f,
  -5.37504591e-02f, -2.14114770e-01f, -5.60615445e-03f, 5.27088158e-02f, -5.99258654e-02f, 1.89324483e-01f, -1.24329984e-01f, -1.63068011e-01f, 1.37869194e-01f, 1.26860157e-01f,
  1.10378392e-01f, -1.43866967e-02f, 1.67227179e-01f, -1.95946559e-01f, -7.46515393e-02f, -1.60674453e-01f, -4.49261554e-02f, 6.22522309e-02f, -1.79569155e-01f, -1.07409008e-01f,
  2.06704393e-01f, -5.88301830e-02f, -1.73048183e-01f, 6.95384219e-02f, -3.52188379e-01f, -7.29981484e-03f, -1.57242883e-02f, 3.10216099e-01f, -2.57753015e-01f, -6.26625568e-02f,
  1.53702199e-01f, -1.60183944e-02f, 2.35022411e-01f, -1.03066348e-01f, -2.63934642e-01f, -3.32431167e-01f, 1.57471746e-01f, 6.87315837e-02f, -2.68519167e-02f, 3.11563969e-01f,
  -1.72864199e-02f, 1.07885413e-01f, 2.52401978e-01f, 1.70667589e-01f, 2.53043950e-01f, 9.30125490e-02f, 1.34712355e-02f, 1.40618250e-01f, -8.47186297e-02f, -1.40844798e-02f,
  1.78304538e-01f, 1.17469594e-01f, -9.91694629e-02f, 2.07048878e-01f, 8.97412747e-02f, 1.05599381e-01f, 2.32081577e-01f, -1.82022378e-02f, -9.43960249e-02f, 8.67890269e-02f,
  1.15731485e-01f, 2.55045205e-01f, -1.76676780e-01f, 1.38116315e-01f, 3.87023692e-03f, -1.52021525e-02f, 1.05073797e-02f, 1.48119017e-01f, 4.28083614e-02f, -1.69801682e-01f,
  8.66158679e-02f, 3.32923979e-02f, 8.03584978e-02f, 6.81342632e-02f, -8.78287181e-02f, 8.82874876e-02f, -1.14121124e-01f, -2.13806294e-02f, 7.12570101e-02f, 4.47202846e-02f,
  -2.42936760e-02f, 1.58148587e-01f, -1.65723041e-01f, 1.04953967e-01f, 8.82663205e-02f, 2.99052089e-01f, -2.86876094e-02f, -2.13699877e-01f, -3.65441218e-02f, -3.42102833e-02f,
  -1.72473148e-01f, 1.23308964e-01f, -3.06456536e-01f, -3.17626745e-01f, 1.89734772e-01f, 1.33374214e-01f, -8.75127017e-02f, 9.78634059e-02f, -1.21091858e-01f, 1.52735934e-01f,
  -1.66355133e-01f, 8.01099390e-02f, -5.21348864e-02f, -3.40280563e-01f, -7.15951398e-02f, -2.53291816e-01f, -1.56421259e-01f, 2.92703748e-01f, 3.35199565e-01f, 1.23078734e-01f,
  -1.98660478e-01f, -1.41866893e-01f, -2.58067667e-01f, 3.11737478e-01f, 9.53299031e-02f, -7.31811598e-02f, 5.44614904e-02f, 4.14577574e-02f, 2.39655878e-02f, -7.19644576e-02f,
  1.15054265e-01f, 8.86966959e-02f, 1.27038822e-01f, -6.38756976e-02f, -1.64290786e-01f, 2.83503801e-01f, 6.50574192e-02f, 2.87056983e-01f, -3.54848593e-03f, 4.46260393e-01f,
  -4.31955568e-02f, 5.60533740e-02f, -6.86558010e-03f, 2.54488498e-01f, -2.51017481e-01f, -1.14030160e-01f, 2.70293176e-01f, 1.73884988e-01f, 1.16936930e-01f, 3.49581867e-01f,
  2.88658679e-01f, -2.08521441e-01f, -7.96892941e-02f, -2.10208938e-01f, 2.12744959e-02f, 3.50595191e-02f, -6.47923630e-03f, -3.87000777e-02f, 1.05775177e-01f, -5.72001748e-02f,
  3.46280038e-01f, 2.47963574e-02f, -1.58572957e-01f, 4.09020066e-01f, 1.27326427e-02f, 5.10433912e-02f, -1.40413299e-01f, -7.37363175e-02f, -1.03713736e-01f, 8.04991201e-02f,
  3.24231107e-03f, -1.49825551e-02f, -7.49188438e-02f, -8.20787027e-02f, -3.10648590e-01f, -1.87561498e-03f, 3.63183804e-02f, 1.27046317e-01f, 3.88665460e-02f, -7.68020675e-02f,
  2.53048930e-02f, -7.71305114e-02f, 1.04792356e-01f, -4.86696698e-02f, -6.31518811e-02f, 6.25105053e-02f, 4.10592481e-02f, -7.81090409e-02f, -9.26802829e-02f, -2.36778587e-01f,
  -1.20907448e-01f, -3.15639377e-02f, 6.24461323e-02f, 9.62753296e-02f, -2.67166346e-01f, -7.85676856e-03f, 1.55460179e-01f, 6.21787123e-02f, 1.48079708e-01f, -1.42998457e-01f,
  -2.32175607e-02f, -2.24223271e-01f, 1.36232108e-01f, 4.59790677e-02f, -5.81430085e-02f, -1.55818224e-01f, -6.83872541e-03f, 1.09857313e-01f, 1.49927437e-01f, -2.59911269e-01f,
  2.03410968e-01f, 4.31766510e-02f, -2.62743264e-01f, 3.22608510e-03f, -1.80836711e-02f, 1.22680357e-02f, -2.25078374e-01f, 1.39261493e-02f, -6.72880635e-02f, -3.11985970e-01f,
  2.78521106e-02f, -1.30526319e-01f, -3.14120948e-01f, -1.34944707e-01f, -9.59380865e-02f, -1.31187975e-01f, 1.36145890e-01f, -2.24716738e-02f, -2.83228271e-02f, 4.45217825e-02f,
  2.49133587e-01f, 1.86383858e-01f, 3.98083106e-02f, -5.67553267e-02f, 7.56325945e-02f, 1.05012499e-01f, 3.36897210e-03f, -1.33163566e-02f, 9.79236662e-02f, -2.01163203e-01f,
  -1.77204505e-01f, -2.25924626e-01f, 6.18221983e-02f, 2.08686981e-02f, 4.02095634e-03f, -1.71376169e-01f, 6.37536794e-02f, -2.75131702e-01f, -3.44449133e-01f, -2.00605571e-01f,
  1.23990990e-01f, 1.62715446e-02f, 1.77662358e-01f, 1.98536411e-01f, -3.50298807e-02f, 1.82024106e-01f, 2.02301294e-01f, -1.55749217e-01f, -6.24803565e-02f, -2.14058995e-01f,
  1.59866679e-02f, 3.19711506e-01f, 1.23093247e-01f, 6.89000776e-03f, 4.10425395e-01f, -1.96715202e-02f, 1.04428247e-01f, -3.61859828e-01f, 1.48846969e-01f, 1.16323426e-01f,
  -7.22283870e-02f, 2.20460650e-02f, 4.40883309e-01f, 2.47973934e-01f, -2.27974400e-01f, 1.24115981e-01f, -2.87111938e-01f, -3.34146172e-01f, -9.58406031e-02f, 1.03008069e-01f,
  9.65474695e-02f, 1.59244046e-01f, 8.04539323e-02f, 5.92809729e-02f, 5.78687638e-02f, 3.25163715e-02f, 6.66593984e-02f, 1.26817776e-02f, -4.93666172e-01f, 8.03649649e-02f,
  3.07863355e-01f, 1.19062528e-01f, -8.78466740e-02f, 1.43836029e-02f, 6.04788847e-02f, 7.64930248e-02f, -7.54968002e-02f, -8.73268917e-02f, 3.15311477e-02f, 2.04768062e-01f,
  2.25229815e-01f, 1.94114223e-01f, -3.28501880e-01f, -5.00590950e-02f, -7.42672309e-02f, -1.66532591e-01f, 9.06663164e-02f, -2.64614314e-01f, -2.10461602e-01f, 2.68654004e-02f,
  -4.14511487e-02f, -6.62759244e-02f, -3.20086926e-02f, -6.38283789e-03f, -1.50294796e-01f, -1.48888677e-01f, -1.81236535e-01f, 3.34644467e-02f, 7.15993568e-02f, 6.09076619e-02f,
  1.52395284e-02f, -1.06050290e-01f, -2.00609654e-01f, 7.75773153e-02f, -2.19687849e-01f, -1.85456052e-01f, 1.14143956e-02f, -1.83221847e-01f, 3.36830243e-02f, 1.65752813e-01f,
  -1.29953519e-01f, 3.12327314e-02f, -2.11627886e-01f, 4.14776541e-02f, -3.82512063e-03f, -8.67784619e-02f, -6.69806749e-02f, 1.83953121e-01f, 9.02114213e-02f, 4.94723544e-02f,
  -9.12311971e-02f, -3.90270203e-02f, 3.10885776e-02f, -1.19759493e-01f, 2.72861850e-02f, 6.24334961e-02f, 2.20868941e-02f, 4.38728109e-02f, 9.22336057e-02f, 7.05951080e-02f,
  -5.46115600e-02f, 1.15468934e-01f, 3.53854485e-02f, -1.01956628e-01f, -5.50497472e-02f, 1.14674896e-01f, -3.53619345e-02f, 1.29525468e-01f, 4.95832041e-02f, 1.93591878e-01f,
  -1.55416414e-01f, 1.77761599e-01f, -2.56355070e-02f, 2.26174206e-01f, 2.42699787e-01f, -2.05749854e-01f, 2.29089424e-01f, 3.21140110e-01f, 1.18364625e-01f, 2.77582973e-01f,
  -2.63789952e-01f, 2.13628307e-01f, 1.66729972e-01f, -1.69166088e-01f, 2.65641287e-02f, 1.53921634e-01f, 1.76651374e-01f, -6.13573864e-02f, 1.19573735e-01f, -1.75482601e-01f,
  -2.50575781e-01f, -1.76943794e-01f, 3.91458422e-02f, 1.44798860e-01f, 1.34187013e-01f, -1.10051662e-01f, -3.04735214e-01f, 1.77503064e-01f, -2.44910091e-01f, 1.17520384e-01f,
  5.94798662e-02f, 6.61475584e-02f, -1.57247111e-01f, -2.09263861e-01f, 1.95253566e-01f, 2.24493876e-01f, 5.36140762e-02f, 2.38702536e-01f, 2.48351902e-01f, 4.77871932e-02f,
  2.48882338e-01f, 1.41293541e-01f, 1.91167042e-01f, -1.57890633e-01f, -2.23451331e-01f, 1.70112893e-01f, 3.72858420e-02f, 1.52207062e-01f, 2.15862244e-02f, 1.48751035e-01f,
  -3.33981551e-02f, -2.52123047e-02f, -1.74435843e-02f, -9.18801001e-04f, 8.82448107e-02f, -9.53214616e-02f, -3.22295099e-01f, -3.61492448e-02f, -2.57815659e-01f, -2.34805137e-01f,
  -2.55550016e-02f, -3.09771091e-01f, 2.85014976e-02f, -2.48100422e-02f, -2.31975257e-01f, 1.10571399e-01f, 2.34650701e-01f, 2.39524141e-01f, 1.60573810e-01f, -4.92606573e-02f,
  4.21330333e-01f, 4.70582247e-02f, 2.57395431e-02f, 8.80586803e-02f, -1.86704814e-01f, -7.02568330e-03f, -3.81172225e-02f, -8.26230273e-02f, -1.26710460e-02f, -4.64223623e-02f,
  4.74226587e-02f, -4.01012190e-02f, -1.11530848e-01f, -1.64185241e-01f, 3.27208042e-02f, -1.19393587e-01f, 5.21897934e-02f, -4.07918822e-03f, -8.61508325e-02f, -8.46064761e-02f,
  -4.71030101e-02f, -6.85833469e-02f, -2.51297206e-01f, -4.62937765e-02f, -1.99824035e-01f, 4.72700186e-02f, -3.57423276e-02f, -1.18832320e-01f, 1.51532395e-02f, 2.58347597e-02f,
  1.39154226e-01f, -2.56157488e-01f, -1.87860683e-01f, 8.56087431e-02f, 1.23539694e-01f, -9.88206938e-02f, -7.54159018e-02f, 1.31512851e-01f, 1.07448578e-01f, -1.74331918e-01f,
  -1.58588029e-02f, 1.15963295e-01f, -5.24913073e-02f, -2.19144188e-02f, -9.97492000e-02f, -1.21669821e-03f, -3.94171886e-02f, 1.06275409e-01f, 6.67183921e-02f, -1.17672300e-02f,
  -1.77362502e-01f, 1.49217655e-03f, -3.97266746e-01f, -1.46648407e-01f, 1.25499353e-01f, 3.27551216e-02f, -5.95623367e-02f, 5.57484515e-02f, -1.47161067e-01f, -3.19651544e-01f,
  -1.18668087e-01f, 1.14015214e-01f, -1.11960083e-01f, -2.22878024e-01f, 2.67371058e-01f, 3.21558639e-02f, -1.82232056e-02f, -1.71314999e-01f, -1.65644988e-01f, 2.84295499e-01f,
  -2.94562727e-01f, -1.54350430e-01f, -3.02136177e-03f, 2.53231488e-02f, 1.45121247e-01f, -2.75721073e-01f, -2.47280151e-01f, 3.89271304e-02f, 1.26023576e-01f, -1.79328453e-02f,
  -1.21716201e-01f, -1.66130334e-01f, 2.30210260e-01f, -1.75192326e-01f, -1.28136426e-01f, -1.61631137e-01f, 1.38707846e-01f, 4.02516365e-01f, -3.91492397e-02f, -5.98057248e-02f,
  2.42208123e-01f, 1.43087089e-01f, 4.74358052e-02f, 1.81361690e-01f, 2.36747339e-01f, -1.73918847e-02f, 6.68655783e-02f, 8.14512148e-02f, 3.01398575e-01f, 2.45529309e-01f,
  2.91624237e-02f, -3.63723367e-01f, 1.17605872e-01f, 1.30762041e-01f, -1.03200890e-01f, 2.31162179e-02f, -3.34863178e-02f, 2.66891718e-01f, 5.96915968e-02f, 4.91572991e-02f,
  3.06879163e-01f, -2.98432913e-02f, 7.04955012e-02f, 8.21612850e-02f, -5.34488000e-02f, -1.07288016e-02f, 3.17392915e-01f, 3.31721932e-01f, 2.23944169e-02f, -2.78188854e-01f,
  -1.86932132e-01f, -5.31957150e-02f, 1.66849419e-01f, -8.93030912e-02f, -1.91158235e-01f, -1.87248036e-01f, 1.96713045e-01f, 1.89814627e-01f, -1.52639046e-01f, -9.02584866e-02f,
  1.31136868e-02f, -7.85736963e-02f, 1.17607258e-01f, -6.26271814e-02f, -1.81513458e-01f, -2.74154991e-02f, -1.63915068e-01f, 1.18909635e-01f, 1.97215322e-02f, -4.37097549e-02f,
  7.21608326e-02f, -3.00173443e-02f, -2.88764257e-02f, 1.02972902e-01f, -9.52432305e-02f, -2.36494318e-02f, -2.33836383e-01f, -1.48290023e-01f, 2.34336525e-01f, -1.10408023e-01f,
  9.44801942e-02f, 8.13850164e-02f, -1.46715030e-01f, -7.63030946e-02f, -7.85133243e-02f, 5.72972298e-02f, 3.48912664e-02f, 3.49550210e-02f, 9.01237205e-02f, 2.83941299e-01f,
  1.16036601e-01f, 5.41057996e-02f, 1.12641349e-01f, -1.34101540e-01f, 7.75609612e-02f, 2.21151765e-02f, -3.35934252e-01f, -9.17019770e-02f, -8.15664884e-03f, -5.05117886e-02f,
  -6.42248020e-02f, -8.65518972e-02f, 9.56035033e-02f, -2.69282639e-01f, 9.22794938e-02f, 2.84174204e-01f, 1.78805977e-01f, 1.16210110e-01f, -1.73890844e-01f, 1.71356767e-01f,
  -6.97683403e-03f, 1.97874326e-02f, 1.12018190e-01f, -1.83541086e-02f, 3.18691343e-01f, 2.69009292e-01f, -6.20401604e-03f, 2.40635112e-01f, 7.87334815e-02f, -4.31734920e-02f,
  1.31996363e-01f, -5.81745245e-02f, -2.00151682e-01f, -1.50002435e-01f, -2.52607819e-02f, -3.49328637e-01f, -1.13736704e-01f, -3.23163003e-01f, 3.61202061e-01f, 6.49362877e-02f,
  2.41017729e-01f, -3.98529977e-01f, -1.00701869e-01f, 4.18995976e-01f, 1.49982318e-01f, 1.10898696e-01f, 9.29457620e-02f, 3.51528019e-01f, 1.12183459e-01f, 2.34625041e-02f,
  9.54231918e-02f, 1.13147520e-01f, -1.44645035e-01f, 1.57934681e-01f, 9.66944546e-02f, -3.14857334e-01f, 1.55135438e-01f, 1.31545484e-01f, -3.73174727e-01f, 1.24688938e-01f,
  1.71669051e-01f, -1.53478280e-01f, 1.94228455e-01f, -1.28523484e-01f, -3.35877448e-01f, 8.82956311e-02f, -1.04062200e-01f, 1.98556915e-01f, 6.41447306e-02f, 9.52355564e-02f,
  -1.86858729e-01f, 1.31390139e-01f, 2.17928752e-01f, -6.42422028e-03f, 4.09749225e-02f, 2.60230359e-02f, 8.03182572e-02f, -7.80747533e-02f, -5.30066714e-02f, -2.40098927e-02f,
  1.74462467e-01f, -5.80706857e-02f, -2.12164477e-01f, 6.08470999e-02f, -5.05707189e-02f, -4.55638580e-02f, 1.88499354e-02f, 1.90911815e-01f, -1.89917639e-01f, 4.06416468e-02f,
  -8.04514214e-02f, 2.11816300e-02f, 4.60535772e-02f, 3.98680329e-01f, -1.25008911e-01f, -8.98026079e-02f, 8.72004554e-02f, -5.02466448e-02f, -4.31744196e-02f, 2.35697240e-01f,
  1.81849836e-03f, 5.19336239e-02f, -8.98890421e-02f, -1.75613150e-01f, 4.30528186e-02f, 8.69901180e-02f, 4.11394499e-02f, 1.54231759e-02f, 5.21863885e-02f, -1.26133472e-01f,
  7.12832958e-02f, -1.33337528e-01f, -1.01455851e-02f, 1.50710732e-01f, 1.81589872e-02f, 4.73661209e-03f, 5.63240312e-02f, 8.65405276e-02f, -1.76197872e-01f, -6.18799888e-02f,
  1.49531350e-01f, -1.33524537e-01f, -3.01095098e-02f, -9.95228514e-02f, 5.87248355e-02f, -1.27463460e-01f, -1.76589247e-02f, 1.45067200e-01f, -1.42362818e-01f, -1.70111984e-01f,
  9.96266231e-02f, -1.25277236e-01f, 1.57817319e-01f, -1.97671801e-01f, 8.42405632e-02f, -5.81144392e-02f, -8.89905691e-02f, -1.84410527e-01f, 9.30273384e-02f, 5.29981498e-03f,
  4.55559092e-03f, 1.08171679e-01f, -3.33532274e-01f, -2.74653453e-02f, -9.92082991e-03f, 3.41977626e-02f, 1.06486253e-01f, -1.69800043e-01f, -1.58161685e-01f, -2.06300039e-02f,
  -4.81926389e-02f, 1.42673895e-01f, -1.04861632e-01f, 3.07747841e-01f, -3.84600937e-01f, -2.94381976e-01f, 2.10369900e-01f, 1.50859594e-01f, 1.48125768e-01f, 2.51339257e-01f,
  2.22535685e-01f, -4.87966165e-02f, -1.84240058e-01f, 1.53418764e-01f, -2.24338949e-01f, 1.93282411e-01f, -8.67013484e-02f, -1.19194336e-01f, -6.67470545e-02f, 1.71363309e-01f,
  2.54423678e-01f, -8.52682814e-02f, -2.53926277e-01f, -2.30314955e-01f, 1.59980208e-01f, 2.82630056e-01f, 2.15028584e-01f, -2.77639091e-01f, -1.50342071e-02f, -2.43627355e-01f,
  2.18021080e-01f, -1.87610969e-01f, 9.74300727e-02f, -7.28316903e-02f, 3.18805546e-01f, -1.64179802e-01f, -1.75888270e-01f, 2.24216968e-01f, -2.53445089e-01f, 2.54425630e-02f,
  2.47988760e-01f, 5.59798144e-02f, 1.08097486e-01f, 1.19228147e-01f, -1.20745905e-01f, -1.29650816e-01f, -1.19963340e-01f, 1.92989898e-03f, 1.90152064e-01f, 2.25967064e-01f,
  5.29839322e-02f, -8.66860151e-02f, 2.71871686e-02f, -2.43144527e-01f, -3.03217191e-02f, -1.25972424e-02f, -1.04838498e-01f, -1.22809835e-01f, -2.80063301e-01f, -4.92676683e-02f,
  2.24293634e-01f, 5.75261265e-02f, -7.69335032e-03f, 1.28856584e-01f, 6.75184280e-02f, -1.13149412e-01f, -1.76682517e-01f, 3.54761025e-03f, 2.53416240e-01f, 5.68699464e-02f,
  -3.96130010e-02f, -1.62849739e-01f, -1.51799276e-01f, -1.04268156e-01f, 3.66948694e-01f, -7.12686926e-02f, 3.65888700e-02f, 1.03085682e-01f, -7.57666454e-02f, 1.01737767e-01f,
  2.34662041e-01f, -5.86643517e-02f, 1.86371729e-02f, 7.78020024e-02f, -7.16115534e-02f, 3.68402191e-02f, 1.49908727e-02f, -1.73415132e-02f, 9.38225351e-03f, 1.66051954e-01f,
  1.31844908e-01f, 9.95514989e-02f, -2.51759887e-02f, 1.14706926e-01f, -2.55746190e-02f, -1.90534055e-01f, -4.93648052e-02f, 1.13394760e-01f, 3.64723569e-03f, 1.07439056e-01f,
  -1.10682793e-01f, 9.04042050e-02f, -1.91450939e-01f, -9.10121351e-02f, -2.16844734e-02f, -4.16183136e-02f, 3.13742831e-02f, 9.43975598e-02f, -3.81739587e-01f, 1.69070080e-01f,
  -2.57012900e-02f, 1.01257645e-01f, 4.89530116e-02f, -5.02470089e-03f, -4.34631892e-02f, 2.13753115e-02f, 1.69829130e-01f, -3.51840220e-02f, 8.10153559e-02f, -1.29669309e-01f,
  1.43138364e-01f, -2.32386938e-03f, -1.04790777e-01f, -4.33729365e-02f, 1.04977988e-01f, 1.50160700e-01f, 4.49604206e-02f, -2.74741560e-01f, -4.90370877e-02f, 1.86551288e-01f,
  1.41859293e-01f, -1.05340570e-01f, 2.37799566e-02f, 8.42493866e-03f, 4.78240177e-02f, -2.59422332e-01f, -1.36197254e-01f, -1.71417460e-01f, -8.28037634e-02f, 8.95325318e-02f,
  3.65519263e-02f, 2.17883065e-01f, 1.38916954e-01f, 2.41525099e-01f, -2.61950433e-01f, -1.56449541e-01f, -3.15450817e-01f, 1.95504338e-01f, -4.88478057e-02f, -7.99172372e-02f,
  -5.22102080e-02f, 2.35916451e-01f, -6.27985829e-03f, -9.13345143e-02f, -1.69959873e-01f, 1.60839185e-01f, 1.07833140e-01f, 4.90482330e-01f, 6.42774776e-02f, 3.75632793e-01f,
  2.72522704e-03f, 2.58493155e-01f, -1.78235054e-01f, -2.11631134e-03f, 1.81356832e-01f, -3.83514017e-02f, 4.44846414e-02f, 1.44256368e-01f, -3.82473528e-01f, -9.97226778e-03f,
  -2.12151825e-01f, -1.01760402e-01f, 1.30279154e-01f, 2.10897461e-01f, -5.87113649e-02f, 1.34135373e-02f, -3.08613870e-02f, -1.53940124e-02f, -2.35464439e-01f, 3.31830323e-01f,
  7.23626241e-02f, 3.77893478e-01f, 8.43001604e-02f, 5.49113341e-02f, -6.91400096e-02f, -6.75754547e-02f, 5.19994199e-01f, -5.72743565e-02f, -6.27677888e-02f, 4.64494526e-02f,
  9.25555602e-02f, -6.23934194e-02f, -2.86016334e-02f, 1.84911594e-01f, 6.58618435e-02f, 4.54108082e-02f, -2.83641249e-01f, 2.16973424e-02f, -1.33038489e-02f, 8.26332904e-03f,
  8.05196911e-02f, -2.50436142e-02f, -1.37797043e-01f, -5.76166622e-02f, 3.06189265e-02f, -8.57594162e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.56506877e-02f, 8.65043253e-02f, -2.00914908e-02f, -4.41303886e-02f, 6.18311316e-02f, 1.74382161e-02f, -6.72499612e-02f, 5.92789464e-02f, 3.45424116e-02f, 5.43992855e-02f,
  7.64124021e-02f, -6.02884479e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    