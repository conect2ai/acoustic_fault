/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.48762047e-01f, -5.54542899e-01f, -2.50160564e-02f, 2.81452030e-01f, 2.80371696e-01f, 9.25226733e-02f, -2.21966863e-01f, -1.24994047e-01f, 9.07504037e-02f, -1.45021319e-01f,
  1.72655415e-02f, 1.36722058e-01f, 3.67574953e-02f, 1.15166930e-02f, 2.90612620e-03f, -2.49806687e-01f, 1.77199710e-02f, 7.53961056e-02f, 2.84609437e-01f, 9.90618914e-02f,
  -1.12091843e-02f, 6.14734739e-02f, 6.00628257e-02f, -6.40158877e-02f, -1.30655706e-01f, 1.30657002e-01f, -1.36064971e-02f, -6.89590871e-02f, -1.76979035e-01f, -1.49835050e-01f,
  -8.01634640e-02f, -1.53859496e-01f, 1.87070936e-01f, 2.64413971e-02f, 8.42525586e-02f, 2.54516620e-02f, 9.90117248e-03f, 5.25667854e-02f, 8.62599686e-02f, 8.48136172e-02f,
  3.30871083e-02f, 1.15350150e-01f, 6.48310706e-02f, 1.03010163e-01f, 1.00062877e-01f, 9.07641724e-02f, -2.08816808e-02f, 7.73193911e-02f, 2.97512542e-02f, -8.38165507e-02f,
  -2.90709734e-02f, 9.26544219e-02f, 1.08615141e-02f, -5.39165065e-02f, -7.67103955e-02f, 1.06253445e-01f, -4.14141919e-03f, 4.80476953e-02f, -3.81617025e-02f, -1.09265022e-01f,
  -7.98458382e-02f, 6.98543806e-03f, -1.14881195e-01f, -2.17684470e-02f, -4.87164259e-02f, -2.02570786e-03f, 5.35186045e-02f, -2.75335629e-02f, -9.66936257e-03f, -7.53509998e-02f,
  -9.07715932e-02f, 1.54651504e-03f, -4.58407253e-02f, 1.84777528e-02f, 4.81924079e-02f, -7.01941326e-02f, 4.80351895e-02f, -5.94585761e-02f, -6.38343021e-02f, 7.34961778e-02f,
  -2.48197429e-02f, -3.83731537e-02f, 3.45232338e-02f, -6.51613697e-02f, -6.26088828e-02f, -5.08197621e-02f, -2.30568592e-02f, -1.18947238e-01f, -6.80843592e-02f, -4.46007733e-04f,
  1.57442048e-01f, 2.51372874e-01f, 3.83149907e-02f, -1.10302880e-01f, 1.34359673e-01f, 7.61976540e-02f, 5.29724248e-02f, 1.84310116e-02f, 7.64079094e-02f, -3.29823978e-02f,
  7.90931955e-02f, 2.78633032e-02f, 1.60567854e-02f, 9.02806371e-02f, 9.96359438e-02f, 3.15565467e-02f, 4.51505631e-02f, 3.11505552e-02f, 5.73864169e-02f, 9.26828310e-02f,
  8.84586945e-02f, 4.97422367e-02f, 1.51044726e-01f, 1.08186647e-01f, -2.61329357e-02f, 2.28418946e-01f, 8.93470198e-02f, 9.15450975e-02f, 1.67307667e-02f, 3.62128019e-02f,
  -2.05612838e-01f, -1.51942000e-01f, -1.35519236e-01f, 2.89305896e-01f, 1.36309728e-01f, -1.50723895e-02f, -1.39109120e-01f, -4.89833429e-02f, 2.60671586e-01f, 1.86309330e-02f,
  -5.55532612e-02f, 1.39552325e-01f, 1.11550935e-01f, -6.90569356e-02f, -2.41261542e-01f, 2.01480798e-02f, 1.30710378e-01f, -4.40379269e-02f, 6.27613887e-02f, 1.67697981e-01f,
  2.25513756e-01f, 1.75595850e-01f, 1.83908846e-02f, 1.67104229e-01f, 2.37746075e-01f, 2.72605896e-01f, 1.95662037e-01f, 7.45158494e-02f, -2.92549878e-02f, 2.41531238e-01f,
  1.59271136e-01f, 2.74348469e-03f, 1.21684156e-01f, 1.17329173e-01f, -3.69874947e-03f, 8.75038505e-02f, 1.34967789e-01f, 1.93241432e-01f, 1.30001664e-01f, 9.61387306e-02f,
  9.77579504e-02f, 5.99734932e-02f, 3.98785584e-02f, 1.88538298e-01f, 1.05274037e-01f, 9.44896415e-02f, 1.03167467e-01f, 2.69119497e-02f, 1.82454530e-02f, 1.04153842e-01f,
  8.07770565e-02f, -7.25228293e-03f, -9.91517901e-02f, 5.71796931e-02f, 1.89117268e-02f, -5.63418716e-02f, 1.06264882e-01f, 2.41445210e-02f, 6.37325495e-02f, 2.29122594e-01f,
  -1.36052743e-01f, -5.95546626e-02f, -4.06359918e-02f, -3.73550244e-02f, -8.24228302e-02f, -8.38126019e-02f, -5.54266647e-02f, -1.13868929e-01f, -8.84278640e-02f, -1.14371695e-01f,
  -1.30654037e-01f, -1.10207066e-01f, -1.32854611e-01f, -8.20784718e-02f, -4.73205410e-02f, -1.31444722e-01f, -1.46647125e-01f, -6.99538589e-02f, -1.62625745e-01f, -3.09950225e-02f,
  -1.80291712e-01f, -8.53493810e-02f, 1.63558479e-02f, -1.51136711e-01f, -9.68818888e-02f, -3.95023152e-02f, -5.37639633e-02f, -1.39815629e-01f, -1.03715889e-01f, -8.31939131e-02f,
  2.61642367e-01f, -1.43212721e-01f, 1.52199671e-01f, 1.53479561e-01f, 1.60223067e-01f, 1.17753871e-01f, 5.51563166e-02f, 6.95373490e-02f, 6.39570281e-02f, 1.65375024e-01f,
  1.17780743e-02f, 1.12579182e-01f, 3.89485806e-02f, 1.12794302e-01f, 1.42175972e-01f, 1.60190225e-01f, 3.51902768e-02f, 1.52563289e-01f, 1.67597104e-02f, 8.38069767e-02f,
  1.67037785e-01f, 1.68629035e-01f, 5.68714887e-02f, 9.88950953e-02f, 5.20874113e-02f, 1.07071638e-01f, 2.86311992e-02f, 1.37888357e-01f, 1.36692403e-02f, 1.15837738e-01f,
  2.30040699e-01f, 1.24989435e-01f, 1.29105553e-01f, 1.88621432e-01f, -1.17765509e-01f, 2.69847605e-02f, 3.93048525e-02f, 1.38346002e-01f, 4.21439074e-02f, 7.68853817e-03f,
  -2.12247565e-01f, -1.56007499e-01f, -2.48736143e-02f, 7.53504112e-02f, 3.63381743e-01f, 3.58590692e-01f, 4.12146896e-01f, 3.18455219e-01f, 1.05047368e-01f, -8.20953026e-02f,
  -1.38504831e-02f, 7.21846074e-02f, 1.42215505e-01f, 1.55320600e-01f, -8.68816823e-02f, -1.54995903e-01f, -7.35644475e-02f, -3.54799628e-03f, 2.00083591e-02f, 1.42393559e-01f,
  -1.08549044e-01f, -1.26133725e-01f, 5.97288311e-02f, -2.05907077e-02f, -1.45978287e-01f, -1.84254139e-03f, -3.26243043e-02f, 8.95535760e-03f, 1.46136880e-02f, -9.96856391e-02f,
  -4.44350429e-02f, -1.86446309e-03f, -8.11011996e-03f, -5.47735617e-02f, -2.51353960e-02f, -9.78944972e-02f, 4.14692760e-02f, 1.74165592e-01f, 1.41617963e-02f, -9.63219851e-02f,
  -6.80450797e-02f, -6.52167539e-04f, -6.44596517e-02f, 9.18751359e-02f, -4.47471105e-02f, -5.52906506e-02f, -6.00516759e-02f, -5.85972145e-02f, -4.69241068e-02f, -6.41049594e-02f,
  1.47206441e-01f, 8.86958092e-02f, -9.93846580e-02f, -1.72525436e-01f, -8.56880993e-02f, -1.54323921e-01f, 3.84168699e-02f, -8.36856943e-03f, -9.35941120e-04f, -1.28595056e-02f,
  -3.55686992e-02f, -8.68368298e-02f, 1.77479871e-02f, 3.94598134e-02f, 1.52572533e-02f, 9.54494923e-02f, 3.43696997e-02f, 4.73380685e-02f, -2.24192487e-03f, -1.55954193e-02f,
  -1.18650671e-03f, -9.93547216e-02f, -8.16533864e-02f, -3.29567865e-02f, -4.07344475e-02f, -2.99529843e-02f, -6.27807900e-02f, -9.63300746e-03f, 3.23964246e-02f, 3.06937508e-02f,
  -1.98647738e-01f, 7.25068972e-02f, 4.38034758e-02f, 2.17939362e-01f, 3.18770409e-02f, 7.30217770e-02f, -9.94336233e-03f, 1.18818052e-01f, -4.02610265e-02f, 3.82091217e-02f,
  -1.03950009e-01f, -6.69308156e-02f, 2.95755211e-02f, -7.31227919e-03f, -6.23844080e-02f, 6.13359967e-04f, 6.66047409e-02f, 1.17898487e-01f, 1.07769310e-01f, -4.17599231e-02f,
  7.67790005e-02f, 6.46580532e-02f, 1.47881418e-01f, -7.49241700e-03f, 6.16445057e-02f, 8.41270685e-02f, -8.62400455e-04f, -5.87076657e-02f, 5.85351214e-02f, 1.35482952e-01f,
  -7.23001882e-02f, -8.32470879e-02f, 2.18700916e-01f, 1.60272732e-01f, 4.37153503e-03f, -1.15174517e-01f, -2.69766033e-01f, -4.14844416e-03f, 9.08555165e-02f, -2.19595321e-02f,
  -1.30295098e-01f, -9.77302641e-02f, 1.82756949e-02f, 3.93613474e-03f, -4.34582680e-02f, 7.46328756e-02f, 1.97865158e-01f, 8.53988230e-02f, 1.55332242e-03f, -1.92749292e-01f,
  -2.04160556e-01f, -8.88363719e-02f, 9.01491567e-02f, 1.82623401e-01f, 1.08688116e-01f, 1.70016795e-01f, 1.47570685e-01f, 1.28210083e-01f, -2.73152348e-02f, 1.50957510e-01f,
  -1.92688301e-01f, 1.57760873e-01f, -4.89595719e-02f, -9.75309834e-02f, -4.76241149e-02f, -2.85306443e-02f, -8.81310925e-02f, 7.20897838e-02f, 4.78509627e-02f, 4.41541560e-02f,
  -5.86071126e-02f, -1.00002281e-01f, 9.51748267e-02f, 8.18374008e-02f, -4.70432639e-02f, 2.85141543e-02f, -3.11375558e-02f, 2.00795271e-02f, 4.68373336e-02f, 5.48371172e-04f,
  -7.23835155e-02f, -7.14136511e-02f, 5.92312105e-02f, -3.46772522e-02f, 3.03062890e-02f, 2.38164607e-02f, -5.65877222e-02f, 1.65477455e-01f, 3.00118774e-02f, -4.93454561e-02f,
  -1.71571299e-01f, -1.44586965e-01f, -4.33949865e-02f, 3.06041795e-03f, -1.44295782e-01f, -3.26246247e-02f, -5.17730452e-02f, -1.56947166e-01f, -8.01042542e-02f, -6.32032603e-02f,
  -6.20470010e-02f, 6.96334615e-03f, -4.36492898e-02f, -6.50319308e-02f, 1.81996245e-02f, -3.46902050e-02f, -6.72834218e-02f, -2.07739845e-02f, -3.94764654e-02f, -6.48560375e-02f,
  -7.17206076e-02f, 3.95245515e-02f, -3.84777449e-02f, -8.76565836e-03f, -3.07716131e-02f, 5.99195510e-02f, -5.97478859e-02f, -4.00244333e-02f, -3.86598147e-02f, -6.30861297e-02f,
  -2.85985172e-01f, -8.79510641e-02f, -4.71446700e-02f, 2.91139539e-02f, 2.83799432e-02f, 9.87160355e-02f, -2.16735173e-02f, -7.22798333e-02f, 2.74002925e-02f, -2.74080709e-02f,
  -5.61233908e-02f, 1.67710278e-02f, -2.38470025e-02f, 2.12760679e-02f, -7.46454224e-02f, -3.78005095e-02f, -8.23096111e-02f, 4.18286696e-02f, 7.41112698e-03f, 7.65446350e-02f,
  -1.00567140e-01f, -7.90794939e-02f, -1.47898197e-01f, -1.71190035e-03f, 2.38637011e-02f, -5.66557422e-02f, -1.32775530e-01f, -7.96193331e-02f, -8.82913321e-02f, -1.90969393e-01f,
  -2.66634017e-01f, 2.03600690e-01f, -1.58205982e-02f, -1.40235811e-01f, -2.33832672e-01f, -8.28748047e-02f, -9.65138599e-02f, -1.07903061e-02f, -2.14274764e-01f, -1.16934910e-01f,
  1.39344573e-01f, -4.40237746e-02f, -1.91334393e-02f, -1.69303715e-01f, -1.59228548e-01f, -1.59266576e-01f, -1.60442889e-01f, -3.16853464e-01f, -2.25194454e-01f, -2.62561500e-01f,
  -2.91281015e-01f, -1.74448729e-01f, -1.90345705e-01f, -1.43268153e-01f, -1.73052251e-01f, -1.32892862e-01f, -8.77426490e-02f, -2.15513021e-01f, -1.43363655e-01f, -1.90079659e-01f,
  9.17699710e-02f, 1.14592925e-01f, -1.67027749e-02f, -3.48011889e-02f, 3.01722530e-02f, -3.03461459e-02f, 9.01963562e-03f, 7.69061223e-03f, 1.44602554e-02f, 1.18477698e-02f,
  -6.83134943e-02f, -4.98985127e-02f, -1.65984835e-02f, -1.20119443e-02f, -8.10198635e-02f, -7.94726908e-02f, 4.80091460e-02f, 1.21825105e-02f, 4.34406251e-02f, 1.08582199e-01f,
  -9.86894518e-02f, -6.34048358e-02f, -7.41000623e-02f, -1.11606810e-02f, 2.89406981e-02f, -1.55679420e-01f, 8.53507444e-02f, 5.47898449e-02f, -5.16409054e-03f, -9.06947181e-02f,
  -3.38377990e-02f, -1.13506867e-02f, 1.12638194e-02f, 8.25082976e-03f, -3.88091840e-02f, -1.65988132e-03f, -7.20445737e-02f, 2.67536603e-02f, -6.04239814e-02f, 6.41693100e-02f,
  6.75610155e-02f, 6.03778809e-02f, 4.32464108e-02f, -5.81127927e-02f, 4.58317809e-03f, -1.58880483e-02f, 5.15967123e-02f, -3.38779800e-02f, 3.35259475e-02f, -4.24343534e-02f,
  3.40918079e-02f, -1.92477868e-03f, 6.69224113e-02f, 3.89918089e-02f, 8.92538056e-02f, -7.66355023e-02f, -6.36721253e-02f, -1.97354294e-02f, 1.14033083e-02f, 6.64087338e-03f,
  6.60258904e-02f, 1.21638723e-01f, -5.56393862e-02f, -1.15195572e-01f, -1.93774458e-02f, 8.50986317e-02f, 1.05015978e-01f, -4.18734178e-02f, -1.46011859e-02f, 4.24307398e-02f,
  5.07879211e-03f, -4.97849025e-02f, 4.78363596e-02f, 3.21966410e-02f, -9.04167518e-02f, -1.12037435e-01f, -9.78408158e-02f, -1.11085601e-01f, -1.16373524e-01f, 7.74727464e-02f,
  4.41931374e-02f, -5.27919605e-02f, -7.80013502e-02f, 5.20603210e-02f, -9.46802869e-02f, -1.07618801e-01f, 4.82564941e-02f, 3.11030783e-02f, -1.52008548e-01f, -5.70059977e-02f,
  1.57483771e-01f, -1.78366348e-01f, 2.53175646e-01f, 1.27444416e-01f, 1.09504767e-01f, 1.97384551e-01f, -4.70628999e-02f, -3.76072787e-02f, 1.17202006e-01f, -5.63775860e-02f,
  -2.13936105e-01f, -1.04588449e-01f, -2.24216352e-03f, -3.91987115e-02f, -1.02721434e-02f, 1.90015987e-01f, 1.61202401e-01f, 2.35840976e-01f, 2.02108845e-01f, 1.09981664e-01f,
  -1.68333983e-03f, -9.01851952e-02f, -8.43077675e-02f, 5.92584796e-02f, 1.14526711e-02f, -2.60858405e-02f, 1.28759779e-02f, -8.66166800e-02f, -6.05251044e-02f, 2.97481984e-01f,
  4.08116654e-02f, 1.67266861e-01f, 9.23729539e-02f, 7.06487522e-02f, 2.88858339e-02f, 1.37421340e-01f, 7.07562044e-02f, 4.46606688e-02f, -2.30586138e-02f, 3.83656807e-02f,
  7.50525370e-02f, 2.95140557e-02f, 6.06050529e-02f, 4.46424223e-02f, 9.93665010e-02f, 5.89785092e-02f, 1.18029326e-01f, 4.98312786e-02f, 5.23275770e-02f, 9.93800312e-02f,
  6.24556504e-02f, 8.77423733e-02f, 1.03560746e-01f, -1.41870398e-02f, 6.17136098e-02f, 1.29981041e-01f, -3.34970765e-02f, 2.08950385e-01f, 6.93945587e-02f, 1.30613789e-01f,
  -2.72139106e-02f, -1.43089471e-02f, -1.96928941e-02f, -5.29118329e-02f, -1.20256454e-01f, -1.46233112e-01f, 1.64622571e-02f, -1.34539664e-01f, -5.10815009e-02f, -7.08020031e-02f,
  -8.00229907e-02f, -2.55823825e-02f, -7.63654783e-02f, -9.90697369e-02f, -6.31741881e-02f, 3.77439149e-02f, -8.78825188e-02f, -7.90319219e-02f, -1.42400920e-01f, -7.06002340e-02f,
  5.65928146e-02f, 4.33691293e-02f, -4.11160886e-02f, -9.55807492e-02f, 1.69983078e-02f, 1.42748458e-02f, 8.34073871e-03f, -4.32252735e-02f, -4.74373847e-02f, -5.13701327e-02f,
  -2.67524213e-01f, 8.74971375e-02f, 1.13508984e-01f, 9.33501497e-02f, 1.60912454e-01f, 1.08027376e-01f, -2.92061623e-02f, 9.13413092e-02f, 4.01973650e-02f, 1.25274122e-01f,
  -3.04513928e-02f, 7.95036256e-02f, 9.39513221e-02f, 1.07724473e-01f, 2.31077801e-02f, 8.14066529e-02f, 3.23035717e-02f, 1.72035530e-01f, 1.28457472e-01f, 1.35487899e-01f,
  1.12080529e-01f, 6.41612485e-02f, 1.10899597e-01f, -8.81441310e-03f, 5.59474751e-02f, 1.72350988e-01f, -7.60108605e-02f, 9.87266675e-02f, 2.21686419e-02f, -1.06958725e-01f,
  -4.53071237e-01f, 2.92963851e-02f, 2.61315823e-01f, -2.77474165e-01f, -8.08626413e-02f, 3.19762751e-02f, 2.47270927e-01f, 8.94407704e-02f, -1.29881844e-01f, -6.22075349e-02f,
  3.92628424e-02f, -1.12055048e-01f, -7.57174417e-02f, -4.68545184e-02f, 1.01952486e-01f, 6.37078583e-02f, -5.01002185e-02f, 6.29518405e-02f, 8.14591572e-02f, 7.33602718e-02f,
  -2.16068439e-02f, 3.28701362e-02f, 1.63355589e-01f, 6.24305755e-02f, -4.91637923e-02f, 3.17116082e-02f, 2.16238678e-01f, 6.32593408e-02f, 7.85388276e-02f, -1.94433093e-01f,
  2.05554464e-03f, -1.91487167e-02f, -3.47588630e-03f, -8.53964910e-02f, -1.59716327e-02f, 9.98900738e-03f, -3.94270606e-02f, -1.26426416e-02f, -9.31738243e-02f, 5.19839041e-02f,
  -8.70632976e-02f, 1.69682894e-02f, -8.09000954e-02f, 4.65875827e-02f, 8.39282200e-02f, -6.29335493e-02f, 5.87931126e-02f, 8.66202265e-02f, -3.14706527e-02f, -3.49599458e-02f,
  -2.94542266e-03f, -7.11410791e-02f, 6.47443682e-02f, 8.28171000e-02f, 5.19322082e-02f, -6.63595647e-02f, 1.69594809e-01f, 4.97440947e-03f, 9.85402763e-02f, 9.03658271e-02f,
  -2.56765112e-02f, -1.73900370e-02f, 8.75619873e-02f, 1.75213460e-02f, 1.33947030e-01f, 3.08447182e-02f, -1.61346309e-02f, 1.34502679e-01f, 2.33911797e-02f, 1.08184785e-01f,
  1.33564815e-01f, -8.67356546e-03f, 1.26711547e-01f, 2.81521380e-02f, 5.68974726e-02f, -4.67781760e-02f, -2.69944165e-02f, -1.55810043e-02f, 8.00337791e-02f, 7.85780232e-03f,
  1.06087774e-01f, 1.00712888e-02f, 6.29560351e-02f, 1.33864835e-01f, 3.00332997e-02f, -4.97539993e-03f, 3.85362208e-02f, 2.74711009e-02f, 1.30253315e-01f, 3.68718058e-02f,
  -5.47982194e-03f, -1.69563200e-02f, -1.04179874e-01f, -1.34039640e-01f, -5.00216819e-02f, -1.47478962e-02f, -1.39450669e-01f, -5.82781434e-02f, -3.10052745e-02f, -5.44032198e-04f,
  2.18329672e-02f, 2.67534908e-02f, -6.43005297e-02f, -1.51184034e-02f, -5.45230545e-02f, -2.47873762e-03f, -3.22205350e-02f, -5.24273925e-02f, 3.64702307e-02f, 7.45585412e-02f,
  3.16232070e-02f, -1.27361283e-01f, -1.44406274e-01f, 4.02726419e-02f, -6.21121190e-02f, -1.66635826e-01f, -1.59014594e-02f, 2.21340619e-02f, -5.55541702e-02f, 5.90006709e-02f,
  -2.38708258e-01f, -3.93386707e-02f, -1.91704407e-01f, -1.31530957e-02f, -1.66976839e-01f, -2.00781375e-01f, -1.77701205e-01f, 5.51710697e-03f, 9.23656225e-02f, 6.07348979e-02f,
  -5.53061366e-02f, -7.55122006e-02f, 1.92819834e-02f, 1.07033409e-01f, -5.71430381e-03f, 1.19693443e-01f, 1.18563786e-01f, -3.38966772e-02f, -4.99284826e-02f, -4.40770350e-02f,
  7.16874301e-02f, -1.51422203e-01f, -1.69883102e-01f, 1.00916382e-02f, 1.40933275e-01f, -2.53828727e-02f, -5.88210747e-02f, -5.15038753e-03f, 3.55238840e-02f, 1.68404818e-01f,
  -1.66647270e-01f, -2.12590862e-02f, -1.16941199e-01f, -2.34008916e-02f, -1.06674545e-01f, 9.08754095e-02f, 2.99113151e-02f, -4.96122912e-02f, 4.33916710e-02f, -6.49696738e-02f,
  -1.29438922e-01f, 3.13469432e-02f, 1.67250093e-02f, -5.85847825e-04f, -8.02476034e-02f, -8.42430592e-02f, -2.10744943e-02f, 1.83310118e-02f, -8.56218711e-02f, -2.33071148e-02f,
  -3.08315698e-02f, -4.52647135e-02f, -2.59447098e-01f, -2.04020292e-02f, -2.50959117e-02f, -1.09744780e-01f, -1.30592078e-01f, -5.58348708e-02f, -3.22055072e-02f, 2.28579976e-02f,
  3.97254601e-02f, -1.46399498e-01f, -7.22831115e-02f, 8.21260661e-02f, -2.28675064e-02f, 9.81625989e-02f, 2.20302641e-02f, -4.31034938e-02f, -5.30217476e-02f, -1.10303223e-01f,
  -2.76711453e-02f, -8.16061795e-02f, 1.37470840e-02f, -1.09162182e-01f, -5.50743788e-02f, -9.43887234e-02f, -4.65716235e-02f, -1.00101948e-01f, -5.12098633e-02f, 1.08576808e-02f,
  -5.65444119e-03f, -4.39240187e-02f, -8.21357444e-02f, -4.46479097e-02f, -2.05189977e-02f, -4.24141549e-02f, -3.28078717e-02f, -5.55112511e-02f, -1.29410774e-01f, -1.25139192e-01f,
  -2.52229363e-01f, -1.14803188e-01f, 6.12214915e-02f, -3.72511335e-02f, -3.04649174e-02f, -2.81092916e-02f, -1.16349861e-01f, -1.11117736e-02f, -9.16863456e-02f, -3.32773030e-02f,
  -1.52802646e-01f, -2.76554730e-02f, -2.75472682e-02f, 9.21032671e-03f, -8.67844895e-02f, -9.55325961e-02f, -5.73453382e-02f, -1.11987822e-01f, 2.59303953e-02f, -3.69823650e-02f,
  -1.07025214e-01f, -8.48823562e-02f, -2.10871071e-01f, -1.59748584e-01f, -6.74701780e-02f, -1.29997194e-01f, -1.60131395e-01f, -2.08898172e-01f, -2.61064261e-01f, -2.23699793e-01f,
  2.86180794e-01f, -4.42787349e-01f, -2.71135658e-01f, 5.26840053e-02f, -1.86926246e-01f, -4.39516038e-01f, -4.57522511e-01f, -2.55792439e-01f, -7.73753077e-02f, -2.58719176e-01f,
  -2.05193892e-01f, -2.85340380e-02f, -1.71477697e-03f, -5.77695295e-02f, -1.45042107e-01f, -3.03640097e-01f, -2.38059059e-01f, -1.10451251e-01f, -2.02851035e-02f, -2.98434913e-01f,
  -1.11903556e-01f, -4.77493033e-02f, 4.68752086e-02f, -1.65293053e-01f, -1.17251679e-01f, 2.58992631e-02f, -2.18860283e-01f, -1.91398472e-01f, -2.92644918e-01f, -3.41004461e-01f,
  -1.62323907e-01f, -2.38790661e-01f, -1.60321593e-01f, -1.77346915e-02f, -7.03267604e-02f, -1.85428843e-01f, -1.99986517e-01f, -1.99238583e-01f, -5.56959212e-02f, -2.02338248e-01f,
  -1.77326620e-01f, -1.28092766e-01f, -1.91730499e-01f, -2.54623264e-01f, -1.55260652e-01f, -1.46072805e-01f, -9.61541682e-02f, -9.50181931e-02f, -1.33541912e-01f, -2.70212859e-01f,
  -2.55226195e-01f, -2.10077733e-01f, -3.16183388e-01f, -2.18222991e-01f, -2.81097531e-01f, -9.35840830e-02f, -2.16321751e-01f, -2.25428179e-01f, -1.96602613e-01f, -6.77193850e-02f,
  5.71752191e-02f, 3.96650098e-02f, 8.71081203e-02f, 7.60251880e-02f, 1.55453578e-01f, 1.60816669e-01f, 8.57406929e-02f, 1.86600208e-01f, 2.74817646e-02f, 1.59610063e-01f,
  1.09001838e-01f, 3.65558006e-02f, 1.42021641e-01f, 7.93518499e-02f, 7.64350742e-02f, 2.56233793e-02f, 2.96327453e-02f, 1.47032231e-01f, 1.38091996e-01f, 1.41955540e-01f,
  2.04872295e-01f, 9.18023437e-02f, 1.82026595e-01f, 9.93191004e-02f, 3.25225070e-02f, 4.13512848e-02f, 1.33611023e-01f, 2.28925906e-02f, 6.60354495e-02f, 1.17144354e-01f,
  6.76161498e-02f, -2.62727916e-01f, 8.96733720e-03f, -1.18522145e-01f, -2.15511829e-01f, -1.06234126e-01f, -4.40737791e-02f, -9.61024836e-02f, -1.56093970e-01f, -8.45907405e-02f,
  -2.19828933e-01f, -1.35442272e-01f, -1.18570805e-01f, -1.56481981e-01f, -1.31957889e-01f, -8.77867043e-02f, -1.79098770e-01f, -1.63556248e-01f, -1.24198548e-01f, -1.43502817e-01f,
  -3.22863683e-02f, -1.44049257e-01f, 2.30914857e-02f, -1.35708377e-01f, -1.47455439e-01f, 2.40049884e-02f, -7.46615231e-02f, -1.58757448e-01f, -7.11906776e-02f, 9.03523415e-02f,
  -1.27732024e-01f, -3.43124010e-02f, 4.78654914e-02f, -1.90349445e-01f, -1.83677599e-01f, 5.33615006e-03f, 4.92009036e-02f, -1.02032898e-02f, -4.17748690e-02f, -3.28824744e-02f,
  3.35037112e-02f, 1.24047637e-01f, 2.81978339e-01f, 3.07725191e-01f, 3.03988725e-01f, 2.71610349e-01f, 2.53326714e-01f, 2.63769031e-01f, 1.33066490e-01f, -5.38020544e-02f,
  1.56058837e-02f, -2.61769533e-01f, -3.28526981e-02f, 2.99043749e-02f, -1.81276664e-01f, 2.87674088e-02f, -1.74584478e-01f, -1.70067370e-01f, 6.29740208e-02f, 4.52751592e-02f,
  -6.77031279e-02f, -2.09331274e-01f, 2.21677035e-01f, 1.19532056e-01f, -3.33870463e-02f, 4.56466340e-02f, 3.47308479e-02f, 4.40769158e-02f, 1.90907288e-02f, 1.04170829e-01f,
  4.12366167e-02f, 6.28020167e-02f, 1.82011649e-02f, 4.92271930e-02f, -7.86134601e-02f, -7.49506848e-03f, 2.01555340e-05f, 9.26803723e-02f, 1.11258887e-01f, 6.08181767e-02f,
  6.37721345e-02f, 6.47498993e-03f, 3.25627178e-02f, 7.66960755e-02f, 2.31481493e-02f, 1.26126781e-01f, -1.62634533e-02f, -7.47103021e-02f, 2.61203777e-02f, -8.47121999e-02f,
  3.70691195e-02f, -9.96385962e-02f, -7.21021146e-02f, -1.31962284e-01f, -7.95557871e-02f, -9.58562121e-02f, -3.32102254e-02f, -1.27997354e-01f, -5.44955842e-02f, -1.85904220e-01f,
  -7.71364570e-02f, -7.91501030e-02f, -8.28460753e-02f, -1.58431455e-02f, -4.26129475e-02f, -5.13590276e-02f, -1.01766244e-01f, 1.61117706e-02f, -6.12227544e-02f, -1.76133141e-01f,
  -4.45943102e-02f, -8.88263807e-02f, -1.58661515e-01f, -8.90935957e-02f, -1.75171793e-02f, -7.44485259e-02f, -7.69541711e-02f, -1.65712163e-01f, -1.37398794e-01f, -1.21405177e-01f,
  -5.99683225e-02f, 2.28924647e-01f, 1.13077074e-01f, 7.62195587e-02f, 8.12936351e-02f, 3.25743034e-02f, -1.15566398e-03f, 1.02105141e-01f, 6.51639104e-02f, 1.26408473e-01f,
  -1.60807557e-02f, 2.98028514e-02f, -3.69976386e-02f, -3.36071253e-02f, 1.28196418e-01f, 2.76683215e-02f, 1.63168795e-02f, 8.90983194e-02f, 1.59907192e-01f, 5.25807589e-02f,
  2.34790482e-02f, 8.44478011e-02f, 2.01033399e-01f, 1.43330410e-01f, 6.55294210e-02f, 2.40290865e-01f, 4.60760184e-02f, 7.60062188e-02f, 1.71581909e-01f, 3.02244127e-02f,
  -2.26841792e-01f, -2.99864829e-01f, -4.59369346e-02f, 2.20242485e-01f, 1.90430894e-01f, -1.81272760e-01f, -3.87443870e-01f, -1.85160205e-01f, 9.88283306e-02f, 2.78301761e-02f,
  -1.31943733e-01f, -2.18214728e-02f, 8.19153860e-02f, 4.38236855e-02f, -1.46820098e-01f, -6.87242076e-02f, 2.21579865e-01f, 1.35603175e-01f, 1.13958083e-01f, -2.40809433e-02f,
  1.62812188e-01f, 2.03078091e-01f, 1.23200603e-01f, 7.49271438e-02f, 1.85450375e-01f, 2.48261496e-01f, 1.36155874e-01f, 1.29143104e-01f, -3.02014221e-02f, 2.80740887e-01f,
  -1.09636113e-01f, -1.09439023e-01f, 1.17015727e-01f, 2.75693778e-02f, 1.48647532e-01f, 1.82024501e-02f, -4.09081765e-02f, 1.49255201e-01f, 3.19556668e-02f, -5.73406145e-02f,
  1.50827065e-01f, -1.94124244e-02f, 1.06302693e-01f, 1.28333598e-01f, 9.11537856e-02f, 5.85464854e-03f, 1.89142659e-01f, 1.19715802e-01f, 5.74228019e-02f, -7.66876712e-02f,
  1.79366603e-01f, 2.17910334e-02f, 6.43840479e-03f, 5.60430735e-02f, -2.88444590e-02f, 7.39644021e-02f, 3.31620760e-02f, 1.55174229e-02f, -3.47323194e-02f, 1.07672624e-01f,
  1.07776327e-02f, -2.32509542e-02f, -1.25367157e-02f, 9.46992263e-03f, 1.67922992e-02f, 3.60149592e-02f, 3.48512940e-02f, -8.04907456e-02f, 3.91868092e-02f, 4.69385879e-03f,
  1.65267419e-02f, -1.01934150e-01f, -6.26434758e-03f, 1.41487382e-02f, -3.55694294e-02f, 5.11200586e-03f, -8.94862413e-02f, -6.60275221e-02f, -1.66651513e-02f, -1.66762732e-02f,
  -9.46319383e-03f, -4.76078168e-02f, 2.48796344e-02f, -1.04694534e-02f, -3.48696262e-02f, 3.67551856e-02f, 3.18715125e-02f, -8.34501982e-02f, 3.43827009e-02f, 2.34734477e-03f,
  9.71158743e-02f, -2.55807005e-02f, 2.91815167e-03f, -7.90708407e-04f, 4.95907553e-02f, -3.08110639e-02f, 3.83558273e-02f, -3.27131711e-03f, -3.87883559e-02f, -7.16407492e-04f,
  1.30206002e-02f, 4.18677554e-02f, 7.14018568e-02f, 9.37189534e-02f, 3.76443658e-03f, -1.33778166e-03f, 6.24247417e-02f, 8.41429159e-02f, 1.58046540e-02f, 6.44730404e-02f,
  1.84080284e-02f, -8.90649930e-02f, -1.41808331e-01f, -9.92446393e-02f, 2.99423784e-02f, -2.51067989e-02f, 1.78300086e-02f, -5.37961461e-02f, -6.31647557e-02f, -1.42372668e-01f,
  -3.33977677e-02f, 1.88043520e-01f, 3.92943136e-02f, 5.12622595e-02f, 1.62018970e-01f, 3.09989601e-02f, 5.58154844e-03f, 1.39837548e-01f, 2.36762509e-01f, 1.30040899e-01f,
  1.74831331e-01f, 3.25672299e-01f, 2.91986704e-01f, 2.74129122e-01f, 7.82711208e-02f, 8.71316418e-02f, 1.88577548e-01f, 1.63019076e-01f, 2.84569059e-02f, 6.76561147e-02f,
  5.76454401e-02f, 1.78068265e-01f, 1.11337490e-01f, 1.19271465e-01f, 5.61376959e-02f, 1.24633849e-01f, 2.15207506e-02f, 9.42357033e-02f, -4.01602909e-02f, -1.01725847e-01f,
  -1.18944617e-02f, -8.94499943e-03f, 2.19748035e-01f, 1.53686851e-01f, 1.76726729e-01f, 1.24322571e-01f, 1.53584063e-01f, 1.18815504e-01f, 2.30211705e-01f, 1.20249532e-01f,
  1.49162352e-01f, 2.32781753e-01f, 1.60458103e-01f, 1.93728521e-01f, 8.27073753e-02f, 1.87461615e-01f, 1.58571169e-01f, 2.04334423e-01f, 1.77436054e-01f, 1.38528571e-01f,
  8.14922228e-02f, -5.31550497e-02f, 5.53622432e-02f, 7.27773383e-02f, 3.04540675e-02f, 7.36497268e-02f, 1.03869084e-02f, 1.08717633e-02f, 1.05126619e-01f, 2.00766269e-02f,
  -3.82586084e-02f, 2.00474560e-02f, -7.54354447e-02f, -6.03228516e-04f, -1.16842069e-01f, -1.34289145e-01f, -5.40453084e-02f, -8.33366588e-02f, -3.17889787e-02f, -1.00887351e-01f,
  -1.21804893e-01f, -2.25338265e-02f, -5.99834369e-03f, -8.80887359e-02f, -1.48141652e-01f, -9.88922566e-02f, -8.54031965e-02f, -4.64631692e-02f, -6.23846799e-02f, -1.65730610e-01f,
  -1.35050461e-01f, -1.64097100e-01f, -6.61047101e-02f, -3.52022462e-02f, -1.43052135e-02f, -5.03614880e-02f, -7.45655783e-03f, 9.53957962e-04f, -1.97774805e-02f, -6.03481457e-02f,
  2.82517314e-01f, 3.24446738e-01f, 1.39524698e-01f, 1.91330031e-01f, 1.41251698e-01f, 1.80824280e-01f, 2.11506844e-01f, 1.85992926e-01f, 2.12077618e-01f, 1.61929503e-01f,
  2.25128070e-01f, 2.12160543e-01f, 1.27745360e-01f, 2.04058826e-01f, 1.40098587e-01f, 9.01619047e-02f, 2.03045964e-01f, 2.37319827e-01f, 1.14729606e-01f, 1.69858202e-01f,
  2.57211179e-01f, 2.10305937e-02f, 2.01521710e-01f, 1.76423147e-01f, 1.56517029e-01f, 2.03506500e-01f, 1.50048241e-01f, 4.89518680e-02f, 8.74445215e-02f, 1.60915822e-01f,
  4.74953428e-02f, -2.71733850e-01f, -6.11131668e-01f, 1.36159375e-01f, 1.13166139e-01f, -1.37150809e-01f, -1.13631643e-01f, -2.14583129e-02f, 3.09249341e-01f, 3.22472937e-02f,
  -7.64196068e-02f, 2.59131223e-01f, 2.02212296e-02f, -4.77311835e-02f, -4.79755476e-02f, -1.69223845e-01f, 2.83498019e-02f, -1.55267105e-01f, -6.32813713e-03f, 2.13104904e-01f,
  3.37206244e-01f, 1.65249079e-01f, 6.89507499e-02f, 1.37139544e-01f, 6.33807331e-02f, 1.09928407e-01f, -9.87799913e-02f, -1.00601658e-01f, -2.00496167e-01f, -3.85806300e-02f,
  -2.05598444e-01f, -1.36970595e-01f, 1.30542234e-01f, 3.17509115e-01f, -2.60817800e-02f, 5.07203415e-02f, 5.96342757e-02f, -3.51309329e-02f, 9.34041291e-02f, -3.80923599e-02f,
  4.07585725e-02f, 1.11636929e-01f, 1.05372041e-01f, 9.30309594e-02f, -4.57013361e-02f, 1.18934214e-02f, 1.42690122e-01f, -3.64326909e-02f, 4.14188579e-03f, -4.86991890e-02f,
  1.69029310e-01f, 8.54934976e-02f, -4.81396057e-02f, 3.77069935e-02f, -3.99586521e-02f, 5.41069321e-02f, -1.44056886e-01f, -5.06791174e-02f, -1.15950212e-01f, -4.26312983e-02f,
  1.41985640e-01f, -4.03153598e-02f, -1.09933384e-01f, -1.65555269e-01f, 9.92167834e-03f, -6.74843695e-03f, 2.93649286e-02f, -8.18543881e-03f, -2.18349006e-02f, -4.29157987e-02f,
  -3.60738090e-03f, -1.24309421e-01f, 2.67062541e-02f, -2.79538929e-02f, 2.85225883e-02f, 8.33024923e-03f, -2.64482982e-02f, -6.08203597e-02f, -1.59946177e-02f, -7.07386732e-02f,
  -1.14521436e-01f, 1.24346176e-02f, -3.79149020e-02f, 1.29278703e-02f, -7.13972673e-02f, -4.75821160e-02f, -5.77681661e-02f, -4.36705016e-02f, 2.05248618e-03f, -6.65978119e-02f,
  1.40076548e-01f, 5.49403317e-02f, 1.98966525e-02f, 1.63524761e-03f, 4.50499542e-02f, 1.31960839e-01f, 5.61655685e-02f, 1.07858405e-02f, -8.02539811e-02f, -1.35122174e-02f,
  3.32718249e-03f, -4.57980186e-02f, -5.51861748e-02f, 1.33331986e-02f, 8.50903392e-02f, 8.53122324e-02f, 9.88763720e-02f, 1.15147553e-01f, 1.56746863e-03f, -4.37963847e-03f,
  1.02645963e-01f, 1.31132469e-01f, -7.40220845e-02f, -7.63757229e-02f, 3.98308486e-02f, 6.37338907e-02f, -3.97460610e-02f, 8.39382038e-03f, -8.16317126e-02f, 7.37552419e-02f,
  8.83477852e-02f, -3.48807603e-01f, -1.34994090e-01f, -8.76032859e-02f, 4.70840856e-02f, -1.30073711e-01f, -3.13662946e-01f, -7.27234855e-02f, -3.59017774e-02f, -1.19371794e-01f,
  1.87471464e-01f, 2.59605378e-01f, 1.66676000e-01f, 1.41214162e-01f, 8.40590298e-02f, -2.50270784e-01f, -2.37107217e-01f, 5.74789606e-02f, 1.24327280e-01f, 2.98725590e-02f,
  5.46364300e-03f, 1.26047581e-02f, -6.97271451e-02f, 1.96589939e-02f, -2.09988341e-01f, -3.99262905e-02f, -1.51395261e-01f, -1.72920123e-01f, -1.09332800e-01f, -2.15715706e-01f,
  -3.92361358e-02f, -1.02795638e-01f, 3.03292051e-02f, 1.76887773e-02f, -3.96814235e-02f, -7.69271702e-02f, -1.00673378e-01f, -3.08567681e-03f, -2.64152847e-02f, -1.72448412e-01f,
  9.32134688e-02f, 6.06616028e-03f, 2.40549333e-02f, -6.65357336e-02f, -3.60163748e-02f, -5.15596159e-02f, -1.71444893e-01f, -1.04612283e-01f, -4.23753485e-02f, -3.74630317e-02f,
  -3.46729383e-02f, 2.47871522e-02f, -5.49312904e-02f, -1.27205132e-02f, -9.18616876e-02f, -6.31964728e-02f, -1.03978068e-01f, -2.10953560e-02f, -1.39279217e-01f, -2.06242219e-01f,
  5.14947884e-02f, 1.40763566e-01f, 1.59571413e-02f, -6.63815364e-02f, 3.39014530e-02f, 9.28399116e-02f, -3.46711874e-02f, -2.65851468e-02f, 1.34534389e-02f, 3.48512195e-02f,
  -2.84491628e-02f, 6.98865056e-02f, -4.14270051e-02f, -6.38624132e-02f, 1.64644476e-02f, 5.05346470e-02f, 5.32320216e-02f, -3.03828157e-02f, -7.97274113e-02f, -1.59088783e-02f,
  -5.11018112e-02f, 4.61293086e-02f, 2.73343530e-02f, -2.60883626e-02f, -2.83131599e-02f, -8.91074315e-02f, -1.13377832e-01f, 3.06250136e-02f, 5.66084385e-02f, 1.50115872e-02f,
  -9.72128436e-02f, 1.63266957e-01f, -1.57724872e-01f, 4.37819073e-03f, -3.93779762e-02f, 4.72402899e-03f, -1.16194203e-01f, -6.87705427e-02f, -2.81609129e-02f, -7.16918409e-02f,
  -9.22633484e-02f, -1.18981034e-01f, -4.36689295e-02f, -1.08594447e-01f, -4.34660465e-02f, -1.13824122e-01f, -8.83261114e-02f, -9.00560711e-03f, 3.02327168e-03f, -7.71796629e-02f,
  -1.91556379e-01f, -1.22618087e-01f, -6.96223155e-02f, -1.41402811e-01f, -9.90847796e-02f, 5.04411496e-02f, -2.41644979e-01f, -1.74939483e-01f, -1.24392435e-01f, -3.48511934e-01f,
  3.84170383e-01f, 2.48814896e-01f, 1.78058729e-01f, -2.63580140e-02f, -1.78702369e-01f, 8.44785497e-02f, 1.85304686e-01f, 1.12899460e-01f, -3.70115461e-03f, 1.61712810e-01f,
  -3.07614729e-02f, -5.68849891e-02f, 2.23078206e-02f, -3.74292880e-02f, 1.14966854e-01f, 1.66031167e-01f, 2.02416200e-02f, 1.70065731e-01f, 8.56589004e-02f, -3.71937118e-02f,
  -2.56912075e-02f, 1.69223901e-02f, 8.19774270e-02f, 7.21548637e-03f, -8.23797584e-02f, -8.74232724e-02f, -5.18331155e-02f, -2.61712912e-03f, -3.48414332e-02f, -1.17917687e-01f,
  2.41662934e-01f, 1.49745852e-01f, 1.72335673e-02f, 4.86549288e-02f, 2.05355342e-02f, 1.34297073e-01f, 9.45544764e-02f, 4.23465669e-02f, -2.65825484e-02f, 1.22967094e-01f,
  3.94536927e-02f, 6.54291958e-02f, 1.48224458e-01f, 1.38091430e-01f, 5.66889495e-02f, 1.96182325e-01f, 1.62763312e-01f, 1.63420260e-01f, 6.57453015e-02f, 2.45442260e-02f,
  2.73757186e-02f, 1.41557023e-01f, 1.92021847e-01f, 1.44502267e-01f, 5.19348793e-02f, 9.03243199e-02f, 8.16350877e-02f, 5.00924923e-02f, 1.51595592e-01f, 1.20823875e-01f,
  -1.42601490e-01f, 2.48228828e-03f, -9.38824192e-02f, 3.77964973e-02f, -7.07832202e-02f, 6.29756078e-02f, -6.05246834e-02f, -9.03839543e-02f, -1.02320081e-02f, -6.37479010e-04f,
  4.67900112e-02f, 4.33057509e-02f, -6.45568296e-02f, -5.97952418e-02f, -5.29682077e-02f, -5.42131215e-02f, -1.21312000e-01f, -1.88980475e-02f, 4.40709628e-02f, 1.31823053e-03f,
  5.79703376e-02f, 8.99283737e-02f, 3.72708477e-02f, -7.69258812e-02f, 1.52303576e-02f, -1.46644078e-02f, -5.42920753e-02f, 3.08105033e-02f, 5.30824400e-02f, -6.73393458e-02f,
  7.85786361e-02f, 6.18097708e-02f, 2.68151045e-01f, 1.53146893e-01f, 5.99945560e-02f, 1.12679325e-01f, 7.66589642e-02f, 4.85741459e-02f, 9.50744003e-02f, 1.99683383e-01f,
  4.21634167e-02f, 1.12837866e-01f, 1.03547089e-01f, 5.57654873e-02f, 1.08502634e-01f, 1.77899569e-01f, 1.40873149e-01f, 1.95723742e-01f, 1.74178153e-01f, 7.41221756e-02f,
  1.90253586e-01f, 1.31610021e-01f, 1.87665120e-01f, 1.53244913e-01f, 1.02159932e-01f, 2.37381145e-01f, 2.37507418e-01f, 2.51529425e-01f, 2.36857548e-01f, 2.60446399e-01f,
  4.34199721e-02f, -3.39361250e-01f, 2.28343427e-01f, -1.20580882e-01f, 1.38633415e-01f, 1.71120644e-01f, 3.80933173e-02f, -9.49367806e-02f, -8.22542757e-02f, -6.04614839e-02f,
  -6.35790974e-02f, -1.14093959e-01f, 2.88636945e-02f, -4.39922549e-02f, 3.52937169e-02f, 1.05406478e-01f, 4.10726592e-02f, 2.64464229e-01f, 2.32888639e-01f, 2.31322553e-02f,
  -1.93308011e-01f, -3.28576177e-01f, -2.18593165e-01f, -1.62623867e-01f, -5.95436059e-02f, -5.57652442e-03f, 4.54598740e-02f, 1.72119588e-02f, 8.78408775e-02f, -1.25854248e-02f,
  1.14812687e-01f, -4.35542762e-02f, 8.71404931e-02f, 2.84949970e-02f, -4.68395045e-03f, -6.84810570e-03f, -1.98574457e-02f, 2.24486366e-02f, -9.41553712e-02f, -5.99595346e-02f,
  3.76338698e-02f, -5.05050644e-02f, -5.59501071e-03f, -8.99912268e-02f, 5.97954802e-02f, 6.62717037e-04f, -1.26687631e-01f, -6.12653829e-02f, -5.28274365e-02f, -3.53695191e-02f,
  -1.75729185e-01f, 5.25225550e-02f, 1.16237529e-01f, 4.56951894e-02f, 5.81626706e-02f, 1.89076051e-01f, 4.85298038e-02f, 6.81487620e-02f, 1.43107399e-01f, -1.40552640e-01f,
  -1.16125621e-01f, 1.62139535e-02f, 4.79624942e-02f, -1.14660077e-01f, 1.04096788e-03f, 1.78748742e-02f, 3.56051363e-02f, -8.90750065e-03f, -5.68678379e-02f, -7.07068443e-02f,
  -1.55439852e-02f, -8.84201899e-02f, -1.05286054e-01f, -5.05227931e-02f, -1.07730418e-01f, 1.09061562e-02f, -6.31219475e-03f, -3.06458957e-02f, -5.40495031e-02f, -4.92694676e-02f,
  -8.61234665e-02f, 2.93095373e-02f, -1.26635376e-02f, -3.49459285e-03f, -3.83098028e-03f, -3.16541418e-02f, -5.89428842e-02f, -1.13904312e-01f, -1.23035237e-01f, -3.73834446e-02f,
  -1.25848874e-01f, 1.99234873e-01f, 1.03950106e-01f, -2.78529106e-03f, 6.11881800e-02f, 1.60291996e-02f, -2.46932693e-02f, -4.35574464e-02f, 8.10224488e-02f, 6.57714810e-03f,
  2.19812747e-02f, 3.27831767e-02f, 1.55342333e-02f, -3.18454690e-02f, 1.36830464e-01f, -5.75118326e-02f, -6.39562085e-02f, 1.16467506e-01f, 1.18095450e-01f, -8.01878497e-02f,
  2.71555595e-02f, 9.06891301e-02f, 9.47810113e-02f, 1.43759012e-01f, 1.36387460e-02f, 1.34384245e-01f, 1.79439306e-01f, 5.20124175e-02f, 2.47954845e-01f, 4.44462411e-02f,
  -1.97080925e-01f, 2.35618651e-01f, -3.36551145e-02f, 4.88704368e-02f, 3.45466167e-01f, 3.24256808e-01f, 3.11731875e-01f, 2.96057075e-01f, 1.51284441e-01f, 1.81779876e-01f,
  6.78140223e-02f, 1.03681728e-01f, 1.08703338e-01f, 4.68894131e-02f, 1.01395383e-01f, 3.67091507e-01f, 2.93374151e-01f, -7.92136863e-02f, -1.27427742e-01f, 2.23197159e-03f,
  2.26530150e-01f, -1.50347017e-02f, -1.95292473e-01f, 3.07367034e-02f, 1.12196997e-01f, 1.84485182e-01f, 1.49308592e-01f, -4.25350154e-03f, -4.45431611e-03f, 1.48036331e-01f,
  -2.87475530e-02f, -1.28981635e-01f, 1.55680314e-01f, 1.00108758e-01f, 5.45499958e-02f, 2.92576887e-02f, 9.97395813e-02f, -2.36267727e-02f, -5.38624078e-03f, 1.49718881e-01f,
  4.10479940e-02f, -6.83220848e-03f, 1.96749140e-02f, 9.68401581e-02f, 9.07848254e-02f, 5.05043268e-02f, 6.82806298e-02f, 4.49071005e-02f, 6.45551309e-02f, 1.58564255e-01f,
  2.46628806e-01f, -1.17060766e-02f, 6.57528341e-02f, 1.82841539e-01f, 4.01999094e-02f, 1.59434825e-01f, 3.04915272e-02f, 1.33121803e-01f, 1.32666752e-01f, 1.71670467e-01f,
  -8.23505223e-02f, -1.04591310e-01f, -4.21173535e-02f, -5.75274862e-02f, -7.39527866e-02f, -8.71095899e-03f, -6.99947253e-02f, -7.54464045e-02f, -1.46960378e-01f, -1.19216025e-01f,
  -1.37255773e-01f, -2.14206986e-02f, -1.64841086e-01f, -1.57219574e-01f, -7.22887143e-02f, -1.28981784e-01f, -7.33670741e-02f, -7.70481974e-02f, -6.99410811e-02f, -1.73520029e-01f,
  -6.41873851e-02f, -1.23565890e-01f, -8.52143690e-02f, -9.91559550e-02f, -9.12302360e-02f, -1.04550816e-01f, -1.00271486e-01f, -1.17638998e-01f, -1.07154138e-01f, -9.56858024e-02f,
  2.88348973e-01f, -2.30559446e-02f, 1.13103211e-01f, 5.10116294e-02f, 1.53624758e-01f, 1.14396781e-01f, 1.07426554e-01f, 1.54283300e-01f, 5.31498678e-02f, 4.85505201e-02f,
  1.01339549e-01f, 6.39845505e-02f, 1.05403610e-01f, 1.91188827e-01f, 1.23066731e-01f, 1.95968196e-01f, 1.95726857e-01f, 2.04528585e-01f, 1.21834122e-01f, 1.93812296e-01f,
  3.15779716e-01f, 3.10393482e-01f, 2.32503325e-01f, 3.14918637e-01f, 1.61678150e-01f, 1.93743482e-01f, 2.45628998e-01f, 2.09992528e-01f, 1.75334543e-01f, 3.83766800e-01f,
  -5.41135430e-01f, -2.52001315e-01f, -2.53856212e-01f, -1.28122196e-01f, 1.02392152e-01f, 3.17130536e-01f, 2.33440027e-01f, 2.40969196e-01f, 9.36943144e-02f, 3.72752622e-02f,
  5.09848967e-02f, -6.57936977e-03f, -1.74078852e-01f, 3.17230821e-02f, 9.81653929e-02f, -3.35646868e-02f, -1.02926433e-01f, -1.92121446e-01f, 1.63366243e-01f, 3.16094607e-01f,
  1.77668408e-01f, 6.24782369e-02f, -9.89848077e-02f, 1.17730975e-01f, -7.70800263e-02f, 1.36951566e-01f, -8.01911503e-02f, -1.23177499e-01f, 3.38038802e-02f, -1.23195395e-01f,
  -3.19520772e-01f, -2.78444827e-01f, 1.43684492e-01f, 9.84343886e-02f, -3.27101871e-02f, 1.17161907e-01f, 2.43020672e-02f, 5.36888018e-02f, 4.27887179e-02f, -3.85918804e-02f,
  3.94909680e-02f, 1.10908046e-01f, 4.76383418e-02f, 4.34053577e-02f, -4.91564209e-03f, 4.19488996e-02f, 8.53610039e-02f, 4.79474142e-02f, -1.10347103e-02f, -2.62792706e-02f,
  -3.66010703e-03f, -5.07498011e-02f, -2.58182213e-02f, 1.20937541e-01f, 4.60656695e-02f, 6.00825548e-02f, 1.18579715e-01f, 1.23774901e-01f, 3.06285266e-02f, 2.85847336e-02f,
  7.01397732e-02f, 1.78686175e-02f, -1.49843935e-02f, 1.00817960e-02f, -1.15801953e-02f, -1.33822151e-02f, -3.06168683e-02f, 5.00128679e-02f, -4.57803234e-02f, 2.11342610e-02f,
  6.19378537e-02f, -1.87671781e-02f, -2.84209568e-02f, -6.25382736e-03f, -9.32925791e-02f, -1.41993895e-01f, -7.60671273e-02f, 3.93158458e-02f, -5.41660450e-02f, 8.19273591e-02f,
  -4.90305107e-03f, 5.96727128e-04f, -8.56776163e-02f, -1.91832017e-02f, -1.57709308e-02f, -8.09261650e-02f, 1.93541348e-02f, -5.86599903e-03f, 1.43410489e-02f, -7.53759965e-02f,
  4.90796566e-02f, 1.98549524e-01f, -2.47593205e-02f, 1.35201588e-01f, -8.28203093e-03f, 2.80991849e-02f, 2.93113384e-02f, 5.98419048e-02f, 4.20068651e-02f, 1.15766622e-01f,
  6.98074624e-02f, 7.57233873e-02f, -3.46549191e-02f, 7.11654052e-02f, 4.52814475e-02f, 4.69112433e-02f, 7.27376565e-02f, 2.50606928e-02f, 9.78221595e-02f, 3.84448692e-02f,
  1.45107463e-01f, 1.62917078e-01f, 7.30775222e-02f, 7.22582191e-02f, 1.00914843e-01f, 1.30714834e-01f, 4.90584411e-02f, 8.01381767e-02f, 2.33581275e-01f, 1.37516946e-01f,
  2.75127232e-01f, 7.68067390e-02f, 1.08140931e-01f, 8.76711607e-02f, -1.23203240e-01f, -2.45611846e-01f, -1.34012461e-01f, -9.95343029e-02f, -1.94876656e-01f, -1.09378360e-01f,
  1.75461367e-01f, 2.70369679e-01f, 2.65049487e-01f, 1.69839889e-01f, 5.49640246e-02f, -6.73690438e-02f, -8.43906477e-02f, 1.38427079e-01f, 1.30628347e-01f, -5.68548637e-03f,
  -1.18013829e-01f, 1.36458918e-01f, 2.18027368e-01f, 1.24571927e-01f, 5.49415946e-02f, 8.84742737e-02f, -4.99805948e-03f, 5.12574129e-02f, 2.47276332e-02f, 4.39858995e-02f,
  8.42667148e-02f, 1.18524015e-01f, -5.34316478e-03f, 3.99387926e-02f, 7.27904364e-02f, 6.34644032e-02f, 1.27019390e-01f, 7.45491758e-02f, 2.49996688e-02f, 7.68629387e-02f,
  5.10146432e-02f, 1.50154397e-01f, 6.02826923e-02f, 1.33714661e-01f, 4.54205945e-02f, 2.58583575e-03f, 9.06526670e-02f, 2.09555387e-01f, 6.80999532e-02f, 6.48209751e-02f,
  1.13760255e-01f, 4.37960848e-02f, 1.21855289e-01f, -2.72718910e-02f, -1.29624391e-02f, 7.07832426e-02f, 1.31228536e-01f, 1.15583695e-01f, 1.76741872e-02f, 2.21155267e-02f,
  -7.78807998e-02f, -2.67866068e-02f, -1.14477433e-01f, -9.01475549e-02f, -1.91644296e-01f, -9.14564505e-02f, -1.59852281e-01f, -1.12672169e-02f, -1.15029052e-01f, -9.75316912e-02f,
  -4.94122021e-02f, -1.75989658e-01f, -7.03587830e-02f, -4.58858795e-02f, -6.94258809e-02f, 1.04234572e-02f, -1.04808472e-01f, -2.24900022e-02f, -4.69036065e-02f, -6.37257621e-02f,
  -3.01307030e-02f, -1.15532830e-01f, -9.77851450e-03f, -4.88811731e-02f, -6.97811320e-02f, -6.12487830e-02f, -1.42108560e-01f, -1.31160349e-01f, -5.80830798e-02f, -5.87201938e-02f,
  -3.58771184e-03f, 8.39620456e-02f, -5.80880269e-02f, 1.10757805e-01f, 5.54307513e-02f, 9.06114429e-02f, 3.66309546e-02f, -4.77928668e-02f, 9.00293812e-02f, 8.38206857e-02f,
  1.00695334e-01f, 8.91564265e-02f, 9.01188105e-02f, -1.83207565e-03f, 4.17406932e-02f, 2.42227111e-02f, 2.57387087e-02f, 5.41101433e-02f, -2.32846215e-02f, 5.15746372e-03f,
  5.30865416e-02f, 4.59831813e-03f, -2.56651398e-02f, -8.35296214e-02f, -3.18501368e-02f, 8.53261575e-02f, -3.94910946e-02f, 2.36270130e-02f, -4.83454242e-02f, -2.02929765e-01f,
  1.38674527e-01f, 1.67511359e-01f, -2.96399355e-01f, -5.61254509e-02f, -1.31013364e-01f, -2.60134876e-01f, -2.56755143e-01f, -1.98527277e-01f, -8.64562169e-02f, -1.84464782e-01f,
  1.60872281e-01f, 4.14389260e-02f, -1.42528728e-01f, -1.87346727e-01f, -3.02940398e-01f, -3.02043229e-01f, -4.70671743e-01f, -4.07043815e-01f, -3.18520725e-01f, -2.75588065e-01f,
  -1.31525233e-01f, -1.37783974e-01f, -1.66183963e-01f, -1.88337550e-01f, -2.25100979e-01f, -1.19257137e-01f, -1.79607362e-01f, -1.89298078e-01f, -8.75926912e-02f, -2.68804550e-01f,
  -1.91478714e-01f, 3.61088924e-02f, -1.03906512e-01f, -7.36958683e-02f, -5.89670502e-02f, -1.76538229e-02f, -1.63468625e-02f, -1.22471727e-01f, -7.86576141e-03f, -4.20254543e-02f,
  -6.76254854e-02f, -1.08036503e-01f, -1.21781781e-01f, -4.96287048e-02f, -1.77539602e-01f, -1.51582614e-01f, -2.38049641e-01f, -1.19575076e-01f, -9.35895070e-02f, -7.74038434e-02f,
  -1.14194743e-01f, -7.66419396e-02f, -5.78182787e-02f, -1.73614994e-01f, -2.15842620e-01f, -1.10387139e-01f, -4.55965437e-02f, -8.38165879e-02f, -1.76609308e-01f, -1.66958302e-01f,
  -1.91746000e-02f, -4.33557071e-02f, 4.18404490e-02f, 3.50888856e-02f, 7.21507296e-02f, 2.69669795e-06f, 5.47528118e-02f, -7.46865869e-02f, 4.93255965e-02f, -1.89080164e-02f,
  4.95928451e-02f, -5.80558786e-03f, -1.34602124e-02f, -1.59876663e-02f, -1.10701052e-03f, -3.69322374e-02f, 4.32061739e-02f, -1.92438494e-02f, 7.19551072e-02f, 5.56935780e-02f,
  3.03056780e-02f, -1.12041514e-02f, 8.68255049e-02f, 3.71563956e-02f, 5.78039151e-04f, -6.91707879e-02f, 5.85892797e-02f, -1.44045101e-02f, 2.49831052e-03f, 8.02836865e-02f,
  7.39196613e-02f, -9.54098441e-03f, 1.82961151e-02f, -5.32645881e-02f, -7.74836019e-02f, -1.24209069e-01f, -5.14164241e-03f, -1.00532956e-02f, -2.91695241e-02f, -1.15641415e-01f,
  -8.87780730e-03f, -1.51379645e-01f, -4.47944142e-02f, -1.47090942e-01f, -4.83204052e-02f, -3.33714150e-02f, -9.47824046e-02f, -5.62250875e-02f, -2.07793593e-01f, -1.69071108e-01f,
  -1.83410600e-01f, -7.45655075e-02f, -1.52841032e-01f, -1.28915325e-01f, -6.19496219e-02f, -2.69889142e-02f, -5.10115623e-02f, -4.44807187e-02f, -1.65000275e-01f, -1.41674846e-01f,
  -6.10669076e-01f, 1.41392142e-01f, -8.29598382e-02f, -1.37894899e-01f, -1.93159783e-03f, 2.37668287e-02f, 2.81681240e-01f, 5.96900620e-02f, -8.82124379e-02f, 8.83644633e-03f,
  -9.08103734e-02f, -2.26207063e-01f, -1.73789486e-01f, -2.19915569e-01f, -1.12433918e-01f, 1.89156249e-01f, 1.12625673e-01f, -2.68515050e-01f, -3.16518039e-01f, -1.48300558e-01f,
  -7.46688247e-02f, -1.78856432e-01f, -3.12141478e-01f, -2.32540324e-01f, -1.05911478e-01f, -1.85603127e-01f, 1.87627859e-02f, -1.23270728e-01f, -1.06666079e-02f, -1.34922221e-01f,
  -2.19504744e-01f, -1.82806328e-01f, -1.63780794e-01f, -1.68768167e-01f, -1.90200388e-01f, -1.23274989e-01f, -1.48993015e-01f, -1.43386006e-01f, -1.51107654e-01f, -7.58930817e-02f,
  -1.88553110e-01f, -2.08884105e-01f, -1.88882530e-01f, -1.33481100e-01f, -9.02245268e-02f, -1.05576441e-01f, -7.96035379e-02f, -1.80505782e-01f, -2.09157407e-01f, -4.08504531e-02f,
  -1.56051933e-03f, -1.51264891e-01f, -1.19543836e-01f, 1.31064989e-02f, -6.20372891e-02f, -1.91060647e-01f, -5.71148731e-02f, -1.54980630e-01f, -9.59236845e-02f, -1.06632032e-01f,
  2.40050256e-02f, 4.00754176e-02f, 7.04798773e-02f, 5.74137308e-02f, 3.31171490e-02f, 2.18279120e-02f, 3.07609309e-02f, 1.08100146e-01f, 1.12708546e-02f, -2.07592584e-02f,
  6.27476051e-02f, 7.67786950e-02f, 2.69028861e-02f, 1.98870781e-03f, 9.58911888e-03f, 8.00900087e-02f, 2.07662247e-02f, 4.38376516e-02f, 1.44324750e-02f, 6.57418147e-02f,
  3.79471742e-02f, 1.08219041e-02f, 6.17572591e-02f, 1.63026731e-02f, 5.52937388e-02f, 5.28285168e-02f, 4.65595797e-02f, -1.04357046e-03f, 1.75901093e-02f, 6.74815327e-02f,
  2.47585159e-02f, -1.15724020e-02f, -4.71995547e-02f, -1.57139584e-01f, 7.98544195e-03f, -1.47404045e-01f, -2.52051800e-02f, -1.44921646e-01f, -1.13082618e-01f, 3.77424620e-03f,
  -9.56808701e-02f, -7.47657642e-02f, -3.51991206e-02f, -1.09445512e-01f, -1.11134239e-01f, -1.63405642e-01f, -8.59026983e-02f, -9.78159606e-02f, -1.08220745e-02f, 4.40588109e-02f,
  -3.69370691e-02f, -5.84817044e-02f, -6.58294857e-02f, 4.70388040e-04f, -3.59892696e-02f, -2.31588662e-01f, 2.68575680e-02f, -5.01879770e-03f, -1.96931455e-02f, -7.39141628e-02f,
  4.10567164e-01f, 1.98507849e-02f, 1.68427333e-01f, -5.70680797e-02f, -2.35455871e-01f, -1.51478067e-01f, -1.04167171e-01f, 2.68728454e-02f, 2.59194206e-02f, -5.56566045e-02f,
  -1.04574047e-01f, -7.70935342e-02f, 1.80751439e-02f, -5.09684011e-02f, 6.04773648e-02f, 8.13211780e-03f, -2.61597596e-02f, 9.14390683e-02f, -2.71520652e-02f, 3.57886292e-02f,
  -5.71698956e-02f, -5.72547354e-02f, 2.19276503e-01f, 1.76190272e-01f, 3.74413766e-02f, 5.63354045e-02f, 1.66155338e-01f, 8.38906914e-02f, -5.53518254e-03f, 8.78886729e-02f,
  -1.07734157e-02f, 3.90576482e-01f, 3.42476107e-02f, -5.99626079e-02f, -6.20675199e-02f, 6.46135360e-02f, -5.32453991e-02f, 1.12348795e-01f, 5.78648485e-02f, -3.28156836e-02f,
  -9.72014219e-02f, -5.09606628e-03f, -1.67743210e-02f, 7.68783092e-02f, 1.06419146e-01f, 7.14163184e-02f, 1.07219085e-01f, 6.90890774e-02f, -2.20346060e-02f, 3.92367393e-02f,
  -3.35705802e-02f, -5.67659996e-02f, 1.26918070e-02f, 2.62881462e-02f, 6.40760362e-02f, 3.39186676e-02f, 1.00647941e-01f, 3.83227430e-02f, 3.21904235e-02f, 1.37234643e-01f,
  -8.81092176e-02f, 2.50125360e-02f, 2.97137275e-02f, -4.21998603e-03f, -5.12961522e-02f, -1.56898480e-02f, -1.24498727e-02f, -2.46233717e-02f, -2.76815295e-02f, -8.04755464e-02f,
  5.87115921e-02f, -4.01007533e-02f, 4.72181216e-02f, 4.15205434e-02f, 9.39469635e-02f, 9.40512400e-03f, 4.34205160e-02f, 3.38892899e-02f, -1.59028359e-02f, 8.27339441e-02f,
  1.61251556e-02f, 2.84602270e-02f, 2.59669181e-02f, 6.81363642e-02f, 7.36937486e-03f, 7.10449740e-03f, 6.27673715e-02f, 2.33711507e-02f, 7.56867528e-02f, 8.46304595e-02f,
  -1.77926943e-01f, 9.36823562e-02f, 1.95309725e-02f, 9.50312018e-02f, -5.63037023e-02f, 4.39340733e-02f, -5.91892330e-03f, 7.98524991e-02f, -3.85448411e-02f, 7.11842701e-02f,
  3.28593818e-03f, -1.07546626e-02f, 5.57992682e-02f, -6.34188801e-02f, -3.91765758e-02f, -7.62941018e-02f, -1.33111507e-01f, -2.00869367e-02f, -5.27320281e-02f, 4.64190133e-02f,
  -1.60895601e-01f, -9.31458250e-02f, -2.18031019e-01f, -1.73549563e-01f, -5.98406270e-02f, -1.60824046e-01f, -4.78499383e-02f, -1.39966458e-01f, -1.21158510e-02f, -7.47467652e-02f,
  6.82952166e-01f, -2.48715222e-01f, -2.57241309e-01f, 2.14958444e-01f, -1.83100514e-02f, -8.53161737e-02f, -7.07862824e-02f, 1.04241647e-01f, 6.50953725e-02f, -3.00932843e-02f,
  4.79639135e-02f, 1.44115239e-01f, 1.15624160e-01f, 4.44890223e-02f, 6.85365498e-02f, -2.13295817e-01f, -9.83346030e-02f, 1.26547679e-01f, 3.06458563e-01f, 2.19567597e-01f,
  9.74515975e-02f, 1.85226485e-01f, 2.56970257e-01f, 1.43310875e-01f, -1.45068020e-01f, 6.48863688e-02f, -1.27933800e-01f, 2.20744796e-02f, -1.09501705e-01f, -5.40128313e-02f,
  -6.60175830e-02f, 7.11621493e-02f, 1.23231962e-01f, 1.85012504e-01f, -5.41306213e-02f, 1.33921802e-01f, 1.01672977e-01f, -4.02757339e-02f, 5.07194735e-02f, 6.02119155e-02f,
  1.15707489e-02f, 1.68318778e-01f, 5.59148118e-02f, 5.76060861e-02f, 3.71887758e-02f, 1.63112581e-01f, -5.93878590e-02f, 1.35422617e-01f, 9.41492710e-03f, 8.18435177e-02f,
  -5.52808009e-02f, 2.41923388e-02f, 5.13628572e-02f, 1.01376092e-02f, 1.52394585e-02f, 2.70345863e-02f, -3.31210718e-03f, 2.05863323e-02f, -3.74137005e-03f, 9.17750970e-02f,
  2.26164535e-02f, -1.03951082e-01f, -3.90600301e-02f, -2.86945738e-02f, 6.89346064e-03f, -1.11628219e-01f, -9.32515934e-02f, -7.90330544e-02f, 1.14528891e-02f, -9.15623903e-02f,
  -3.15756574e-02f, -3.62808742e-02f, -2.58015245e-02f, -1.85712203e-02f, -8.98659825e-02f, -8.03292692e-02f, 1.17605515e-02f, -8.80357921e-02f, -2.07071602e-02f, -2.41979640e-02f,
  -1.36839440e-02f, -5.25487401e-02f, -6.55237883e-02f, -1.60331912e-02f, -1.17621496e-02f, -3.00424453e-02f, 1.89597737e-02f, 1.18187889e-02f, 3.09900823e-03f, -9.27912965e-02f,
  9.19531137e-02f, 1.78269431e-01f, 1.03125796e-01f, 2.18369067e-01f, -2.63832207e-03f, 6.18191995e-03f, 5.03156520e-02f, 1.17364921e-01f, 9.86389518e-02f, 5.91942342e-03f,
  1.66186780e-01f, 9.82681960e-02f, -2.06162501e-02f, -1.96695440e-02f, 9.13261846e-02f, 3.64637449e-02f, -1.62075628e-02f, 8.89274776e-02f, 6.81523681e-02f, 5.63387983e-02f,
  -4.90778312e-02f, 1.61500692e-01f, 2.10415393e-01f, 3.27398404e-02f, -3.04839071e-02f, 1.95128560e-01f, -6.48119673e-02f, 6.14068806e-02f, 1.12898767e-01f, 6.09247163e-02f,
  -2.28839144e-01f, -2.02267855e-01f, -1.15818061e-01f, -2.40548868e-02f, 3.46666686e-02f, -3.83217521e-02f, -1.27353400e-01f, -1.47393972e-01f, -5.53550236e-02f, 1.91854965e-02f,
  -1.61605000e-01f, 3.78273390e-02f, -4.34441939e-02f, -2.38866005e-02f, -1.83758259e-01f, -1.80176757e-02f, 7.57241175e-02f, 1.50621817e-01f, -3.33125070e-02f, 1.21207133e-01f,
  1.61234796e-01f, -5.10332324e-02f, -7.91309401e-02f, 7.27750584e-02f, 2.45352969e-01f, 2.05435634e-01f, 1.22623570e-01f, 1.35344326e-01f, 2.44909823e-01f, 3.40471953e-01f,
  1.18615247e-01f, -3.31159115e-01f, -2.84214795e-04f, -6.90723211e-02f, -1.29454568e-01f, -4.40729968e-02f, -1.17276818e-01f, -9.58267152e-02f, -9.81930345e-02f, -3.91157120e-02f,
  -8.56385231e-02f, -1.58252433e-01f, -1.14889473e-01f, -8.73776302e-02f, -7.82145262e-02f, -4.54379134e-02f, -7.26052001e-02f, -1.37596950e-01f, -7.91617855e-02f, -7.11401403e-02f,
  -4.43991572e-02f, 2.76176613e-02f, -9.51223001e-02f, -1.41185537e-01f, -2.50639990e-02f, 4.81122248e-02f, -3.76041159e-02f, 2.23740446e-03f, -7.16668889e-02f, 1.01234280e-01f,
  2.34674856e-01f, 4.40558828e-02f, -3.25508155e-02f, -9.63115692e-03f, 3.98248136e-02f, -1.48110231e-02f, 5.91854267e-02f, 4.47935686e-02f, 2.91869952e-03f, -2.55487859e-02f,
  -2.09794659e-02f, -4.70504425e-02f, -5.94146401e-02f, 7.38127232e-02f, 1.43665090e-01f, -6.25981987e-02f, 8.42918903e-02f, 6.96473792e-02f, 7.37679228e-02f, 3.19754370e-02f,
  1.85026005e-02f, 3.15300142e-03f, 3.87108028e-02f, 4.33495007e-02f, -4.04610444e-04f, -6.53794501e-03f, -5.62932454e-02f, -3.73832285e-02f, -8.30904543e-02f, -7.01909512e-02f,
  -1.16436996e-01f, -1.55583739e-01f, 1.14249878e-01f, -4.41861525e-02f, -5.96474782e-02f, -8.35108906e-02f, -5.05487174e-02f, -1.16303310e-01f, -1.59581248e-02f, -7.35976025e-02f,
  -1.24720573e-01f, -6.46025017e-02f, -8.02781656e-02f, 2.15890296e-02f, -7.74071738e-02f, -1.03672827e-02f, -3.74168493e-02f, 4.45825420e-02f, 2.89893616e-02f, -7.17923343e-02f,
  -8.26762430e-03f, 3.83456908e-02f, 8.46976712e-02f, 9.45722088e-02f, 1.62758827e-02f, 1.34418428e-01f, 3.86291519e-02f, 1.05521180e-01f, 9.06854644e-02f, 1.22768782e-01f,
  -7.50430394e-03f, -2.61817724e-01f, -2.67362714e-01f, -2.78167158e-01f, -3.07759553e-01f, -2.85583567e-02f, -1.79637864e-01f, -2.77508553e-02f, -1.55518726e-01f, -2.80530542e-01f,
  -3.39909315e-01f, -3.13327938e-01f, -1.82628140e-01f, -1.92294240e-01f, -1.33671239e-01f, -2.24636108e-01f, -1.79372281e-01f, -1.19608738e-01f, 1.65194762e-03f, -8.40308517e-02f,
  -2.36232296e-01f, -2.62276679e-01f, -1.85850725e-01f, -6.33443147e-02f, -1.54409364e-01f, -1.57919675e-01f, -1.20858029e-01f, -1.25868574e-01f, -9.72235873e-02f, -1.41568065e-01f,
  -1.07572615e-01f, -4.48316000e-02f, -1.55058980e-01f, -1.83800831e-01f, -2.31788635e-01f, -5.21575361e-02f, -5.69194481e-02f, -1.08028896e-01f, -1.45060956e-01f, -9.14219394e-02f,
  -3.02807868e-01f, -9.44542959e-02f, -1.71636552e-01f, -1.26597837e-01f, -3.65715735e-02f, -9.60597992e-02f, -1.53949112e-01f, -1.28343299e-01f, -7.33054876e-02f, -1.63533837e-01f,
  -3.00711840e-01f, -1.11812949e-01f, 4.28617522e-02f, -5.62224500e-02f, -6.88429624e-02f, -1.30881622e-01f, -3.50191183e-02f, -1.32879913e-01f, -4.01890390e-02f, -5.21535461e-04f,
  -7.21322671e-02f, 9.55335274e-02f, 1.39288411e-01f, 5.33390120e-02f, 1.25942245e-01f, 6.71413094e-02f, 5.91979399e-02f, 9.99592468e-02f, 9.51457843e-02f, 8.41178298e-02f,
  4.59735692e-02f, -1.90970059e-02f, 2.16861181e-02f, 4.75839041e-02f, 1.23964027e-01f, 8.45687389e-02f, 6.07292876e-02f, 5.58562875e-02f, 1.85984716e-01f, 1.70798197e-01f,
  1.07141614e-01f, 1.61600351e-01f, 1.10495783e-01f, 9.42341834e-02f, 1.73963811e-02f, 1.14166401e-01f, 9.87985209e-02f, 9.54059437e-02f, 1.36577338e-01f, 1.76466092e-01f,
  -1.08905725e-01f, -1.82437137e-01f, -6.48092628e-02f, -1.07599810e-01f, -8.82430971e-02f, -1.65845249e-02f, -2.35222533e-01f, -5.54194823e-02f, -5.13866432e-02f, -5.37508093e-02f,
  -1.57902285e-01f, -1.50060669e-01f, -1.55541047e-01f, -5.57786711e-02f, -6.86899647e-02f, 7.50316400e-03f, -5.77079728e-02f, -1.81753710e-01f, -1.08391240e-01f, -3.28825600e-02f,
  -1.17623329e-01f, -9.00385752e-02f, 7.71147162e-02f, 1.14662070e-02f, -6.45424426e-02f, -1.54530600e-01f, -9.91121083e-02f, 4.21856418e-02f, -4.04760838e-02f, -3.16697098e-02f,
  -4.42340136e-01f, 8.94487053e-02f, 2.38826603e-01f, -3.29312086e-01f, -1.95451617e-01f, -1.26403272e-01f, -1.56954810e-01f, -1.02226652e-01f, -1.71267644e-01f, 1.06658442e-02f,
  2.79049575e-02f, 6.32286221e-02f, 8.44454840e-02f, 1.27348468e-01f, 1.26390979e-01f, 1.59907475e-01f, 2.14919254e-01f, 2.23528475e-01f, 1.21927718e-02f, -9.48879719e-02f,
  -1.12701535e-01f, -2.31866553e-01f, -8.82341042e-02f, -4.38918844e-02f, 1.14708953e-02f, 3.17510106e-02f, 1.50400788e-01f, 1.15023609e-02f, 2.99366564e-02f, 2.71066010e-01f,
  2.28348508e-01f, -1.20813221e-01f, -2.06686612e-02f, -7.18554808e-03f, -1.80050675e-02f, 3.05305552e-02f, 5.69747873e-02f, 1.09156288e-01f, -4.96979542e-02f, 1.20564036e-01f,
  -3.77189443e-02f, -2.54297126e-02f, -2.34866962e-02f, 5.91436401e-02f, 1.59099437e-02f, 1.98695399e-02f, 7.28273243e-02f, 1.62040114e-01f, 2.10693642e-01f, 8.00606534e-02f,
  9.49903131e-02f, -1.19110793e-01f, 5.67100197e-03f, 3.95489521e-02f, 2.13779509e-01f, 4.50083502e-02f, 1.32629380e-01f, 1.10027075e-01f, 9.51968953e-02f, 1.06803797e-01f,
  -2.58476306e-02f, -3.83068696e-02f, 3.40328403e-02f, -6.92108423e-02f, -7.07854480e-02f, -1.42353158e-02f, -6.09712675e-03f, -1.18591055e-01f, -1.22838922e-01f, -6.93004057e-02f,
  -2.11141314e-02f, 1.21836131e-02f, -8.06257203e-02f, -1.07502572e-01f, 3.68917882e-02f, -9.65773612e-02f, -4.78850789e-02f, 1.00947348e-02f, -6.36344329e-02f, -5.77230267e-02f,
  -1.11451589e-01f, 2.10428014e-02f, -4.27551568e-02f, -6.17654361e-02f, 1.08465970e-01f, 5.17186970e-02f, -4.56074066e-02f, -6.06288724e-02f, -1.15384892e-01f, -9.56419408e-02f,
  -7.94057995e-02f, 4.06453758e-02f, 6.81475401e-02f, 8.86221677e-02f, 1.01451874e-02f, 2.96298638e-02f, 1.25517234e-01f, 9.03609619e-02f, -2.46910341e-02f, 1.07100703e-01f,
  1.21572062e-01f, 7.15343654e-02f, -8.77898652e-03f, 1.26315989e-02f, -4.13615331e-02f, 5.72079495e-02f, -3.22672017e-02f, 6.74184039e-02f, 7.35475495e-02f, 6.29838705e-02f,
  -2.66138911e-02f, -9.97207090e-02f, -7.94496462e-02f, -9.09441430e-03f, 1.36587303e-02f, -5.14872037e-02f, 3.76206040e-02f, -2.14766376e-02f, 1.41456071e-03f, -1.79123536e-01f,
  -3.02582234e-01f, -2.69225806e-01f, 2.03821912e-01f, -4.10588622e-01f, 1.54172435e-01f, 4.23687726e-01f, 4.82283145e-01f, 1.83425605e-01f, -1.83339044e-01f, -7.58406147e-02f,
  -2.00415462e-01f, -2.32959002e-01f, -3.19353729e-01f, -9.95528325e-02f, 1.43095553e-01f, 2.77339697e-01f, 1.88527614e-01f, 2.26603851e-01f, 3.31148297e-01f, 3.50560457e-01f,
  -3.15692574e-02f, -2.74626240e-02f, -1.10624388e-01f, -6.93633268e-03f, -2.44190544e-01f, -5.14558330e-02f, -1.62457928e-01f, -5.45006096e-02f, 7.05535859e-02f, -2.01617584e-01f,
  -4.94453944e-02f, -1.36901110e-01f, -2.23437157e-02f, -2.40314484e-01f, -1.07426211e-01f, -7.71067068e-02f, -8.64722952e-02f, -9.96655375e-02f, -1.78547323e-01f, -1.25404060e-01f,
  -1.70884952e-01f, -1.27802238e-01f, -2.09868938e-01f, -3.87825035e-02f, 4.94594406e-03f, -2.36914586e-02f, -5.52942343e-02f, -2.67646951e-03f, -3.08575034e-02f, -9.50875953e-02f,
  -1.10077426e-01f, -1.09404698e-01f, 5.74234799e-02f, -3.58299608e-03f, 4.61034514e-02f, -9.05490443e-02f, -1.07249029e-01f, -7.91579671e-03f, 5.35123572e-02f, -1.39298871e-01f,
  5.32506965e-02f, -1.74206886e-02f, 7.52676427e-02f, -3.88996452e-02f, 2.48792265e-02f, -8.21414441e-02f, 6.67991117e-02f, 3.78662422e-02f, 7.06163496e-02f, 6.64733872e-02f,
  1.00709191e-02f, 1.07804932e-01f, 7.99381435e-02f, -2.87003666e-02f, -3.02316826e-02f, -3.62526439e-02f, 1.04145966e-01f, -5.09745022e-03f, 2.56666578e-02f, -4.72072931e-03f,
  2.08501127e-02f, 2.57051755e-02f, -5.44811413e-02f, 3.45709808e-02f, 2.77069956e-02f, -5.67911863e-02f, 6.12164997e-02f, 8.07248875e-02f, 2.68964209e-02f, -4.57805581e-02f,
  -4.66104120e-01f, -5.44969626e-02f, -1.27548665e-01f, 8.81972141e-04f, -1.95232369e-02f, -1.10609405e-01f, -1.37518719e-01f, -9.66820642e-02f, -1.30505577e-01f, -7.02965334e-02f,
  3.31497788e-02f, 1.95530672e-02f, -8.32544640e-02f, -2.81230528e-02f, -3.70262824e-02f, 6.94100745e-03f, -1.75560072e-01f, -1.45091236e-01f, -2.36420967e-02f, -1.49854600e-01f,
  -1.18052959e-01f, 8.31940994e-02f, 5.89253195e-02f, -1.11741766e-01f, -6.82794377e-02f, -1.22230016e-01f, 3.08171511e-02f, 4.58318107e-02f, 4.74069305e-02f, -1.12195842e-01f,
  -5.11521816e-01f, -3.98202330e-01f, -1.78404376e-01f, -7.13410452e-02f, -3.68567966e-02f, -2.43856400e-01f, -3.54251564e-01f, -1.01966538e-01f, -8.84407666e-03f, -1.56338766e-01f,
  -6.80690110e-02f, 4.41027358e-02f, -7.05761835e-02f, 2.35053878e-02f, 1.66383144e-02f, -3.76008824e-02f, -5.08998930e-02f, 4.52005640e-02f, 8.39787275e-02f, 3.27667855e-02f,
  5.70519790e-02f, -6.57510310e-02f, -9.62827280e-02f, -2.54962351e-02f, 4.57813181e-02f, 2.83810683e-02f, -2.39985734e-02f, 1.89335681e-02f, 5.35241663e-02f, 7.48693198e-02f,
  -3.28894779e-02f, -2.12046713e-01f, 5.29113784e-02f, -1.56196192e-01f, -6.32960051e-02f, -1.56783927e-02f, -1.16437040e-01f, -9.60756391e-02f, -1.40400246e-01f, -7.92481527e-02f,
  -2.68329941e-02f, -7.25451037e-02f, -7.56478012e-02f, -1.84444860e-02f, -3.11857183e-02f, -5.46187609e-02f, -5.50218299e-02f, -8.37225318e-02f, -1.66013256e-01f, -5.61017804e-02f,
  -9.64739025e-02f, -7.34617785e-02f, -1.57349527e-01f, -6.69837520e-02f, -7.60600343e-02f, -5.49046174e-02f, -1.90030962e-01f, 6.53201155e-03f, -6.27219453e-02f, -1.51564062e-01f,
  6.96722120e-02f, 5.13858534e-02f, 1.18793808e-01f, 5.78842610e-02f, 1.82526201e-01f, 5.77530079e-02f, 1.51870072e-01f, 9.92905125e-02f, 1.28448799e-01f, 1.11428753e-01f,
  5.64165972e-02f, 6.78557828e-02f, 6.93526864e-02f, 7.23403320e-02f, 1.16948858e-01f, 1.05666993e-02f, 5.04192375e-02f, 1.10496014e-01f, 1.20096877e-01f, 3.91405150e-02f,
  9.30329710e-02f, 5.43711223e-02f, 1.82344615e-01f, 1.10120483e-01f, 8.17725733e-02f, 3.27243358e-02f, 1.60977885e-01f, 1.70297518e-01f, 6.35704026e-02f, 1.15276948e-02f,
  -4.34807613e-02f, -1.83255509e-01f, -4.02383469e-02f, 6.32581040e-02f, -4.32857983e-02f, -8.47355574e-02f, -8.80108327e-02f, 4.59868573e-02f, -6.50691763e-02f, -4.24041003e-02f,
  7.37183867e-03f, 1.30445324e-03f, -1.94327123e-02f, -7.75320381e-02f, -2.58223265e-02f, -8.42209160e-02f, -1.03877969e-01f, -1.03400432e-01f, -1.05714463e-01f, 4.72007552e-03f,
  -9.54794213e-02f, -2.24648729e-01f, -1.21500395e-01f, -1.15670510e-01f, -1.27057746e-01f, -2.10954472e-01f, -2.57279780e-02f, -1.65963054e-01f, -9.22057405e-02f, -1.31086871e-01f,
  -4.29250836e-01f, -4.61224794e-01f, 5.74598052e-02f, -2.19560102e-01f, 9.32160020e-02f, 2.85826996e-02f, -2.43370563e-01f, -2.88007259e-01f, -2.02579454e-01f, -2.84944892e-01f,
  -8.99647474e-02f, 2.87149381e-02f, -1.07770404e-02f, 1.05960190e-01f, -2.04274729e-01f, -1.34449407e-01f, -6.20665811e-02f, 8.77349600e-02f, 2.39021376e-01f, 1.87846065e-01f,
  -1.50743360e-02f, -6.49511069e-02f, -1.88435763e-01f, -1.17802992e-01f, -1.36051774e-01f, 5.58697097e-02f, -1.16681390e-01f, -1.72795579e-01f, 2.36049555e-02f, -1.02129936e-01f,
  1.26562759e-01f, -4.01763529e-01f, 1.49665281e-01f, -8.34152400e-02f, 4.05260333e-04f, -1.61520317e-01f, -2.99461721e-03f, -1.53355762e-01f, -1.11251488e-01f, -9.52589437e-02f,
  -1.48410618e-01f, -8.50958973e-02f, -1.55098662e-01f, -7.88889304e-02f, -1.24845892e-01f, -1.03247911e-01f, -8.45460594e-02f, -2.35152259e-01f, -6.60952553e-02f, -1.11847512e-01f,
  -5.21474108e-02f, -4.28721830e-02f, -1.46843895e-01f, -9.12772045e-02f, -1.64921865e-01f, 2.49576289e-02f, -9.54137146e-02f, -1.24535359e-01f, -1.10298492e-01f, -1.56853348e-01f,
  1.07646711e-01f, 9.02968943e-02f, 3.35723609e-02f, -1.17633573e-03f, -1.26853632e-02f, 4.35655713e-02f, 5.17452620e-02f, 1.58961378e-02f, 9.44977626e-02f, -5.03822267e-02f,
  7.06623569e-02f, 6.21793456e-02f, -2.39473991e-02f, -5.21580875e-02f, 6.53128698e-02f, -4.51161601e-02f, 8.74578133e-02f, -4.63197567e-02f, 5.46468887e-03f, -2.61307973e-02f,
  6.84766993e-02f, 6.06671348e-02f, -4.77628456e-03f, -1.37071358e-03f, 3.53842564e-02f, 1.10686300e-02f, 3.09363808e-02f, 3.20910402e-02f, 2.67667323e-02f, -1.01693928e-01f,
  -1.12813555e-01f, -2.73018591e-02f, -8.06391612e-02f, -3.47146504e-02f, -1.29631341e-01f, 2.69850176e-02f, -4.70594736e-03f, 7.46876970e-02f, -1.07762195e-01f, -4.81598116e-02f,
  -8.27667937e-02f, -5.89885004e-02f, -8.28959271e-02f, 2.00857744e-02f, -5.51277352e-03f, -2.95939315e-02f, -1.52388826e-01f, -4.98068966e-02f, -1.43983573e-01f, -1.12803511e-01f,
  -6.42601922e-02f, -1.23184502e-01f, -8.06934461e-02f, -7.86517709e-02f, -6.98157027e-02f, -4.05212045e-02f, -1.59707968e-03f, -1.07091973e-02f, -1.50593920e-02f, -8.46849307e-02f,
  1.89445898e-01f, -2.34187692e-01f, 3.68594155e-02f, -7.98327662e-03f, -1.89081535e-01f, -1.82889670e-01f, -3.05398941e-01f, -1.19458765e-01f, 1.95387099e-02f, -1.18734702e-01f,
  -1.29658088e-01f, 1.09126046e-01f, 3.73663455e-02f, 1.80265814e-01f, 1.75272450e-01f, -1.30807534e-01f, -6.42589256e-02f, 2.17532456e-01f, 2.22099856e-01f, -3.98074053e-02f,
  -9.27822739e-02f, -2.47950070e-02f, 3.11929822e-01f, 1.81006148e-01f, -5.60378768e-02f, 9.42349508e-02f, 1.02499098e-01f, 6.91336840e-02f, 5.04395664e-02f, 2.96281446e-02f,
  -8.58957469e-02f, 3.77112292e-02f, 1.31525412e-01f, 9.56777930e-02f, 3.60155925e-02f, 2.32064068e-01f, 3.32326517e-02f, 1.89176843e-01f, 1.30289644e-01f, 6.56919107e-02f,
  1.34499326e-01f, 8.89805779e-02f, 1.38963029e-01f, 5.31706437e-02f, 6.39245585e-02f, 7.54159242e-02f, 1.27044871e-01f, 1.77751094e-01f, 1.65409207e-01f, -3.02093569e-02f,
  9.17246472e-03f, -6.16468862e-02f, 1.54393256e-01f, 1.45712569e-01f, 1.81200132e-01f, 1.62291616e-01f, 1.31914333e-01f, 1.77441195e-01f, 2.51683056e-01f, 3.75757739e-02f,
  -8.17100108e-02f, -9.34552923e-02f, -3.45795415e-02f, -1.45458251e-01f, -1.75632805e-01f, -1.44924238e-01f, -1.39037386e-01f, -1.40019134e-01f, -1.30740598e-01f, -3.50825973e-02f,
  -1.60038933e-01f, -1.23175748e-01f, -2.04461381e-01f, -1.34252533e-01f, -1.49933681e-01f, -1.69820234e-01f, -1.08529821e-01f, -2.05137730e-01f, -1.76867262e-01f, -9.19993892e-02f,
  -1.03499345e-01f, -8.60815421e-02f, -9.86313820e-02f, -6.73667938e-02f, -1.41327605e-01f, -1.72963828e-01f, -1.31055921e-01f, -6.68369904e-02f, -9.55610648e-02f, -1.82914570e-01f,
  1.60212144e-01f, 2.87683874e-01f, 2.44843401e-02f, 1.74382389e-01f, 1.52906641e-01f, 2.02206239e-01f, 4.01543751e-02f, 1.49720013e-01f, 1.48324415e-01f, 4.42079529e-02f,
  9.63599384e-02f, 1.17557645e-01f, 1.20211191e-01f, 4.32390794e-02f, 7.81103671e-02f, 1.07165046e-01f, 9.43295807e-02f, 1.57245442e-01f, 7.39041939e-02f, 1.28706679e-01f,
  4.81774174e-02f, 1.10592626e-01f, 5.55929169e-02f, 1.28721043e-01f, 1.22063607e-01f, 1.93040848e-01f, 1.46960318e-01f, 1.28779456e-01f, 2.15529576e-01f, -1.60631980e-03f,
  1.03142828e-01f, 1.42878126e-02f, -9.97424200e-02f, 1.40763834e-01f, -3.91152538e-02f, 3.14743035e-02f, 4.51016203e-02f, 2.56927699e-01f, 1.73749566e-01f, 1.08769372e-01f,
  1.61177337e-01f, 3.02791655e-01f, 2.15842515e-01f, 1.53523847e-01f, -2.45224200e-02f, 9.63873789e-02f, -5.96626624e-02f, -1.76474124e-01f, -1.10023990e-01f, -3.44027206e-02f,
  6.30024821e-02f, -4.82963845e-02f, -6.28379434e-02f, -5.94082139e-02f, -1.60620790e-02f, 9.45591182e-02f, 6.36736304e-02f, -4.17884476e-02f, -1.66313708e-01f, -3.22659723e-02f,
  1.80663586e-01f, -9.49276686e-02f, 5.58586791e-02f, 3.66604142e-02f, -1.06525615e-01f, -4.73191142e-02f, -2.81157084e-02f, -2.72094295e-03f, 4.00433363e-03f, 1.19238399e-01f,
  4.72388742e-03f, -6.05546422e-02f, 1.88852027e-02f, -5.62827997e-02f, 1.06708817e-01f, 3.14008445e-02f, -4.29702997e-02f, 6.46098107e-02f, 3.80452611e-02f, -7.08234832e-02f,
  -1.29859477e-01f, -1.24916099e-01f, 5.89488260e-03f, 1.08742692e-01f, -3.92357484e-02f, -1.01917922e-01f, -6.76699728e-03f, -8.91480818e-02f, -1.13827735e-01f, 1.48527786e-01f,
  -4.31514680e-02f, -2.17835046e-02f, -4.61439602e-02f, 4.49371245e-03f, 2.38639805e-02f, 9.37281996e-02f, -6.40824959e-02f, 3.06581073e-02f, 1.87964160e-02f, 1.71572890e-03f,
  1.36085578e-06f, 2.83409446e-03f, 1.00064054e-02f, -5.35927266e-02f, 4.34091128e-02f, 9.89552401e-03f, -1.05522878e-01f, -2.14958824e-02f, -4.34764177e-02f, 4.85394616e-03f,
  -6.64226562e-02f, -5.39961979e-02f, 1.17440419e-02f, -1.73190664e-02f, -2.13351734e-02f, -1.27234710e-02f, -4.26035039e-02f, 1.91578344e-02f, -7.96901360e-02f, -6.16155788e-02f,
  3.92259121e-01f, -1.09073341e-01f, 1.14308745e-01f, 7.38191009e-02f, 4.02131304e-02f, 1.08427042e-02f, 6.70590177e-02f, -5.24702780e-02f, 2.01787185e-02f, 2.88754553e-02f,
  -1.07627101e-02f, -5.61139770e-02f, 4.51999977e-02f, -1.10731437e-03f, 7.56729320e-02f, 1.15244120e-01f, 4.04976606e-02f, 3.78676988e-02f, -5.17170131e-03f, 8.09848309e-02f,
  9.93785784e-02f, 1.71672970e-01f, 1.95284307e-01f, 1.89170346e-01f, 1.57577932e-01f, 1.36506483e-01f, 1.11606553e-01f, 2.18412161e-01f, 1.19792551e-01f, 2.95628220e-01f,
  3.79245579e-01f, 9.31329876e-02f, 1.66669294e-01f, 5.03151342e-02f, -1.31504416e-01f, -3.82080413e-02f, 6.00152314e-02f, 1.23815387e-01f, 1.65245403e-02f, -6.52494580e-02f,
  -8.19421411e-02f, 5.08990921e-02f, 6.32543638e-02f, 2.05088452e-01f, 3.57275307e-01f, 1.59544796e-01f, 2.16212824e-01f, 3.58408779e-01f, 2.12117285e-01f, 5.39492108e-02f,
  -2.58283634e-02f, 8.95843133e-02f, 1.66505843e-01f, 2.07538426e-01f, 1.45704597e-01f, 1.72048062e-01f, 1.43743798e-01f, 1.48219734e-01f, 1.91810668e-01f, 2.44018808e-01f,
  1.57073066e-01f, 1.43778175e-01f, -3.86544364e-03f, 1.12111315e-01f, 4.44550589e-02f, 1.17584527e-01f, 1.03332773e-01f, 7.50806183e-02f, 1.13689341e-01f, 1.12403475e-01f,
  6.17020912e-02f, 5.10336459e-02f, 1.82525575e-01f, 2.49795541e-02f, 8.00935924e-02f, 7.70599023e-02f, 8.19389895e-02f, 2.59091198e-01f, 1.11175150e-01f, 1.50757015e-01f,
  -5.22727855e-02f, 7.76266754e-02f, 1.45887390e-01f, 1.49654716e-01f, 1.43880725e-01f, 1.46093562e-01f, 1.03933834e-01f, 1.34871632e-01f, 3.02269131e-01f, 2.53826886e-01f,
  -7.36195147e-02f, -6.40498623e-02f, -1.29999116e-01f, -1.29027992e-01f, -1.70168400e-01f, -1.29349574e-01f, -1.88079938e-01f, -1.88106850e-01f, -1.02617189e-01f, -1.60027325e-01f,
  -9.35060680e-02f, -2.02500015e-01f, -1.20832138e-01f, -1.03395589e-01f, -1.15771398e-01f, -1.00831315e-01f, -1.44234613e-01f, -1.61901161e-01f, -1.98970497e-01f, -1.16243288e-01f,
  -1.92808226e-01f, -9.75256041e-02f, -2.26483777e-01f, -1.06979236e-01f, -1.07695498e-01f, -1.47678688e-01f, -1.13023981e-01f, -2.88808674e-01f, -2.34334677e-01f, -2.71232456e-01f,
  -4.34039943e-02f, 4.46228236e-02f, 1.38595849e-01f, 1.44413561e-01f, 7.13810325e-02f, 1.01223618e-01f, 1.93200577e-02f, 1.03492320e-01f, 1.22379348e-01f, 1.58774763e-01f,
  5.83098233e-02f, 1.71563655e-01f, 1.47511050e-01f, 4.72204611e-02f, 1.52908966e-01f, 2.31635775e-02f, 4.18548025e-02f, 1.82111323e-01f, 1.14050202e-01f, 6.87127188e-02f,
  1.34186417e-01f, 2.05222934e-01f, 2.15629816e-01f, 8.15797597e-02f, 1.02241851e-01f, 1.33861661e-01f, 1.63783833e-01f, 2.29894906e-01f, 2.97247320e-01f, 2.40411624e-01f,
  8.24057087e-02f, -2.28859127e-01f, 3.62902284e-02f, -1.80864438e-01f, -2.42266044e-01f, -2.62732685e-01f, -1.73852459e-01f, -5.76918982e-02f, -4.84663062e-03f, -1.58967912e-01f,
  -6.47323951e-02f, 4.73000221e-02f, 1.75328821e-01f, 1.12451725e-01f, 1.19100682e-01f, -8.11775923e-02f, -1.48467243e-01f, 1.81135401e-01f, 2.10885942e-01f, 1.96187962e-02f,
  -8.53070915e-02f, -1.18729651e-01f, 1.40209317e-01f, 4.02701385e-02f, -6.48275837e-02f, -6.89975694e-02f, -1.11454666e-01f, -1.06498390e-01f, -3.35044339e-02f, -3.27397250e-02f,
  2.09891200e-01f, 1.06371090e-01f, 8.93105865e-02f, -2.43868749e-03f, -9.27537903e-02f, 3.89802791e-02f, -7.01878965e-02f, 7.07218200e-02f, 6.38169795e-02f, 2.11555008e-02f,
  -8.64354968e-02f, -3.39373872e-02f, -9.55452025e-02f, -4.33212481e-02f, -7.61178061e-02f, 8.58731121e-02f, 7.71514401e-02f, 9.23713222e-02f, 3.87782343e-02f, -1.64313633e-02f,
  -2.01965541e-01f, -2.11240515e-01f, -1.01772748e-01f, -1.80561896e-02f, 1.05141453e-01f, 2.67862771e-02f, 6.17406741e-02f, 6.80807829e-02f, 2.07141507e-02f, 7.90918618e-02f,
  -9.48421583e-02f, 7.22007379e-02f, -5.17783314e-02f, -5.54111116e-02f, -6.61101863e-02f, -3.25500919e-03f, -2.30804319e-03f, 4.46238043e-03f, 2.82383915e-02f, -1.01988101e-02f,
  5.70150092e-02f, -7.14447647e-02f, -1.65128913e-02f, 4.29693833e-02f, 3.62380184e-02f, -7.17256218e-02f, -1.81706939e-02f, -1.97622925e-02f, 4.07162793e-02f, -1.33076515e-02f,
  -4.79905047e-02f, 6.21121116e-02f, -7.45479539e-02f, 1.05617188e-01f, 4.41634357e-02f, 7.13478848e-02f, 8.30074921e-02f, 5.29172868e-02f, -3.94581854e-02f, -5.29946536e-02f,
  1.08173806e-02f, -5.97094593e-04f, 3.54092866e-02f, 4.91473898e-02f, -1.12648547e-01f, 4.79990505e-02f, -3.14221308e-02f, 1.64359082e-02f, -1.41449077e-02f, 1.52916443e-02f,
  5.79367168e-02f, -1.65381953e-02f, -1.18740723e-02f, -2.88709197e-02f, -4.77534533e-02f, -2.53407136e-02f, -7.90849552e-02f, 4.36641686e-02f, 6.31495491e-02f, -6.20255508e-02f,
  -1.33211076e-01f, -2.47667097e-02f, -1.17280753e-03f, 3.76818981e-03f, 6.82997033e-02f, -2.14617029e-02f, 4.11385261e-02f, -3.74706239e-02f, 9.12528932e-02f, -1.47079900e-01f,
  -2.73825675e-01f, 3.76120925e-01f, -1.19970255e-01f, -2.02463150e-01f, 9.48477089e-02f, 7.65393674e-02f, 2.22831413e-01f, -1.11008525e-01f, -1.25413999e-01f, 2.10133776e-01f,
  4.12615389e-01f, 8.15856904e-02f, -1.85475107e-02f, 3.08234598e-02f, -6.03370368e-02f, -8.12531412e-02f, -1.35000885e-01f, -2.77091056e-01f, -2.91176349e-01f, 1.25414640e-01f,
  1.38937607e-01f, -6.13090135e-02f, -1.35671213e-01f, -1.38479903e-01f, 1.34040609e-01f, 5.12159616e-02f, 6.65764585e-02f, 4.13788259e-02f, 2.44340986e-01f, 1.81505486e-01f,
  1.52339160e-01f, 2.13480204e-01f, -9.88154411e-02f, 6.88279197e-02f, 1.53713822e-01f, 6.29449338e-02f, 2.17029061e-02f, -2.38232985e-02f, 5.00764437e-02f, 7.39474744e-02f,
  1.56013191e-01f, 5.00925668e-02f, 3.10549419e-02f, 7.09287673e-02f, 2.36870795e-02f, 2.53446549e-02f, -1.82889644e-02f, -3.15985754e-02f, -7.51255080e-02f, 1.56653851e-01f,
  3.10357362e-01f, 1.73775211e-01f, 9.05096307e-02f, 1.73336994e-02f, 1.89252701e-02f, -6.84457943e-02f, 3.49709801e-02f, 9.48695540e-02f, 5.88527285e-02f, 7.86703303e-02f,
  -5.48448674e-02f, -5.58724105e-02f, -7.76120424e-02f, -4.61930558e-02f, -5.38528487e-02f, -2.85242945e-02f, -1.17916562e-01f, 4.33263816e-02f, -5.82801439e-02f, -9.57636610e-02f,
  -8.50748867e-02f, -3.71119417e-02f, -2.48874184e-02f, 2.35728715e-02f, 2.57051662e-02f, -5.36624268e-02f, -7.26931393e-02f, 5.84088787e-02f, -5.71307354e-02f, -1.09995566e-01f,
  2.10067369e-02f, -3.48918289e-02f, -7.15999454e-02f, -3.88295874e-02f, -4.05679010e-02f, -3.99064319e-03f, -4.80608866e-02f, 8.93081129e-02f, -4.46528085e-02f, -3.19326296e-02f,
  1.16840631e-01f, 8.87119025e-02f, 1.03659056e-01f, 4.79282029e-02f, 1.01618655e-01f, 8.62659812e-02f, 2.23217696e-01f, 3.88917373e-03f, 9.59071666e-02f, 9.74845663e-02f,
  2.21019745e-01f, 1.20865382e-01f, 1.34729490e-01f, 1.42370462e-01f, 2.64967568e-02f, 8.00833479e-02f, 9.89832431e-02f, 1.01353531e-03f, 6.56751171e-02f, 1.18890204e-01f,
  9.60284173e-02f, 6.68802112e-02f, 1.40904924e-02f, -2.68525667e-02f, 1.10796228e-01f, 4.66215201e-02f, 1.13815330e-01f, 7.99157917e-02f, -1.03221625e-01f, -9.38645825e-02f,
  -1.90440029e-01f, -2.52450883e-01f, -4.54021066e-01f, 1.50897682e-01f, 5.32479351e-03f, -1.70591772e-01f, -2.25237459e-01f, -7.74070919e-02f, 1.65455848e-01f, 6.74943328e-02f,
  9.96028483e-02f, 2.14491069e-01f, -7.93801323e-02f, 6.81044683e-02f, -1.17744476e-01f, -2.08800748e-01f, -5.15745729e-02f, -4.84231785e-02f, -8.76517445e-02f, 1.89349353e-01f,
  2.96448201e-01f, 1.26453072e-01f, 1.95334375e-01f, 1.27928317e-01f, 1.41632587e-01f, 1.33803308e-01f, 7.31775016e-02f, 1.09124631e-01f, 8.73825997e-02f, 1.14273287e-01f,
  -1.51713371e-01f, -1.45618856e-01f, -3.35517153e-02f, 2.05469146e-01f, 7.35867843e-02f, 3.66207995e-02f, 5.27397580e-02f, 5.93221337e-02f, 1.07667081e-01f, 7.01354221e-02f,
  1.50156081e-01f, 7.26343766e-02f, 8.40577483e-02f, 2.81098317e-02f, 1.16876289e-01f, -3.25556360e-02f, 1.64292872e-01f, -9.21320450e-03f, -4.39760536e-02f, 1.25101551e-01f,
  1.35783240e-01f, 5.89376241e-02f, -1.46063417e-01f, 4.29641679e-02f, 3.62030156e-02f, -4.17282395e-02f, -6.48311973e-02f, 9.61255059e-02f, -4.56771739e-02f, 5.02672493e-02f,
  -7.04718113e-04f, -6.77484795e-02f, -7.53857642e-02f, -6.14642911e-02f, -7.77870417e-02f, -5.93374064e-03f, -1.45539805e-01f, 1.61098910e-03f, -2.08465308e-02f, -6.25760406e-02f,
  -8.94014239e-02f, -1.00878216e-01f, -1.24530382e-01f, -1.63556889e-01f, -9.22176018e-02f, -7.92116448e-02f, -7.60090724e-02f, -6.37533888e-02f, -4.78090644e-02f, -7.12382570e-02f,
  -9.11025777e-02f, -8.40771645e-02f, -1.70999169e-02f, -4.17684540e-02f, -5.64666241e-02f, -7.26352856e-02f, -8.86886865e-02f, -4.53695953e-02f, -5.58313467e-02f, -6.53271889e-03f,
  1.51570067e-01f, -1.33883163e-01f, -9.23233107e-02f, -3.54048759e-02f, -3.60057466e-02f, 1.12525128e-01f, -1.53688546e-02f, 5.72770350e-02f, -7.23126009e-02f, -9.70170554e-03f,
  -6.53483048e-02f, -3.27084437e-02f, 3.46810967e-02f, 1.23605058e-01f, 7.27347210e-02f, 1.64039154e-02f, 1.16807655e-01f, 1.34298978e-02f, 7.72910193e-02f, 4.23022397e-02f,
  1.00158527e-01f, -5.72266914e-02f, -9.97388884e-02f, -9.63338539e-02f, -2.18377467e-02f, 5.67424670e-03f, -1.13532707e-01f, -2.95066871e-02f, -2.11919963e-01f, -1.69657975e-01f,
  1.87539548e-01f, -1.60206735e-01f, -2.71561056e-01f, -8.30123127e-02f, -1.27477301e-02f, -3.83198671e-02f, 9.89654809e-02f, 2.74257928e-01f, 6.22293763e-02f, -7.60677084e-02f,
  -1.04373328e-01f, -1.12934776e-01f, -4.79312725e-02f, -6.01411685e-02f, 2.45072856e-03f, 6.15463890e-02f, -1.22861549e-01f, -7.59308636e-02f, 5.33693321e-02f, 9.64125097e-02f,
  1.12318330e-01f, 2.21990570e-01f, 1.28740191e-01f, 9.25770029e-02f, 2.61690971e-02f, -6.21615583e-03f, -8.20218176e-02f, -5.55319600e-02f, -3.97356302e-02f, -3.02155055e-02f,
  -3.07780683e-01f, -1.12578191e-01f, -2.12893169e-02f, -1.32676482e-01f, -2.12186992e-01f, -5.40904887e-02f, -4.92253751e-02f, -3.59109342e-02f, -7.89865702e-02f, -3.17175649e-02f,
  -9.97882113e-02f, -1.18322223e-01f, -2.08633468e-01f, -6.00895956e-02f, -1.05128340e-01f, 1.34711312e-02f, 4.19323295e-02f, 1.83672458e-02f, -9.98943672e-02f, -1.08983181e-01f,
  -2.09432304e-01f, -1.71280429e-01f, -1.20717056e-01f, -1.52242512e-01f, -2.49945689e-02f, -2.07238421e-01f, -1.24791890e-01f, -5.40280119e-02f, -1.42098907e-02f, 3.21329162e-02f,
  -2.27236431e-02f, -4.11817580e-02f, 3.92542295e-02f, 1.33610666e-01f, 1.20073460e-01f, 1.09049186e-01f, -2.39052400e-02f, 1.11838877e-02f, 9.67407599e-02f, 8.85275379e-02f,
  6.47282004e-02f, -1.22586843e-02f, 4.54629399e-02f, 1.30570918e-01f, 2.70241704e-02f, 6.91125961e-03f, 1.12158224e-01f, 1.44566908e-01f, 8.70766863e-03f, 5.67191578e-02f,
  5.62967584e-02f, 8.07618573e-02f, 5.14828190e-02f, 1.62357226e-01f, 1.16022788e-01f, -6.52839169e-02f, 4.53379797e-03f, 3.26902308e-02f, 2.43883226e-02f, 5.26937060e-02f,
  2.06622615e-01f, -1.88206568e-01f, 1.07206814e-02f, -2.64014117e-02f, -1.24530070e-01f, -1.10963978e-01f, -2.19971649e-02f, -1.29622579e-01f, -1.22875184e-01f, -2.51688845e-02f,
  -2.04323560e-01f, -6.38758540e-02f, -1.79166228e-01f, -8.50390717e-02f, -1.17116578e-01f, -1.32036135e-01f, 4.57279868e-02f, -7.02794492e-02f, -9.89705622e-02f, 2.27301698e-02f,
  -1.38839290e-01f, 5.40232360e-02f, 1.34744719e-01f, -2.90069431e-02f, -9.23457518e-02f, 3.19161527e-02f, 4.36638184e-02f, 2.03171168e-02f, 1.50742708e-02f, 8.84086937e-02f,
  5.21499157e-01f, 1.21443599e-01f, 1.15562163e-01f, 1.59477517e-01f, -5.06657846e-02f, 3.07360943e-02f, -7.17998296e-02f, 4.42954823e-02f, 6.76220134e-02f, 1.76689520e-01f,
  -1.25261977e-01f, -1.77451834e-01f, -2.03627329e-02f, -1.23212941e-01f, -7.51842782e-02f, 2.10135028e-01f, 1.85868293e-01f, 2.09700301e-01f, 5.16780466e-02f, -1.39581546e-01f,
  -6.00084811e-02f, 1.48559868e-01f, 1.34279788e-01f, 3.04755569e-02f, -1.21555282e-02f, -1.08285911e-01f, 1.66178510e-01f, -3.13903880e-03f, -3.86594646e-02f, 3.35817069e-01f,
  1.07032567e-01f, 1.99153602e-01f, 4.38360572e-02f, -1.96679123e-02f, 9.99450870e-03f, 7.03700557e-02f, 1.69700041e-01f, 5.81317283e-02f, 1.99715123e-02f, 7.81904086e-02f,
  3.68135273e-02f, -2.38891761e-03f, -3.62987928e-02f, 1.14417076e-01f, 1.64920330e-01f, 8.78305435e-02f, 1.19031362e-01f, 1.06701143e-01f, 1.61910281e-02f, 3.17565799e-02f,
  -8.42252597e-02f, 1.33062333e-01f, 9.53870043e-02f, -3.50560546e-02f, -1.22569269e-02f, 6.45633265e-02f, 1.45490572e-01f, 1.14322029e-01f, 2.82625630e-02f, 1.59547061e-01f,
  -9.12828073e-02f, -9.25202146e-02f, -8.53586867e-02f, 5.20530231e-02f, -6.41579628e-02f, -5.83912544e-02f, -1.30034692e-03f, -1.01675525e-01f, -3.16215418e-02f, -6.63389564e-02f,
  -6.30725548e-02f, 6.95668384e-02f, -3.88509147e-02f, 1.86486505e-02f, -1.25167713e-01f, 2.36607678e-02f, -6.57024160e-02f, -1.51986256e-01f, -7.22721592e-02f, -1.34994775e-01f,
  -2.65380498e-02f, -1.40632346e-01f, 1.46214925e-02f, -6.10291995e-02f, -1.62179407e-03f, 6.60975883e-03f, -4.46673855e-02f, -3.55506092e-02f, -1.36651874e-01f, 2.06192918e-02f,
  6.01803921e-02f, -8.76649544e-02f, 1.24467634e-01f, -5.75417541e-02f, 5.97490482e-02f, -1.17662430e-01f, -3.88486907e-02f, 4.58221845e-02f, -1.31312842e-02f, 7.01203570e-02f,
  -6.48631752e-02f, 7.12635741e-02f, 4.56104241e-02f, -2.07099877e-02f, 4.28113900e-02f, -5.01215197e-02f, 4.19068858e-02f, 3.43742035e-02f, 6.33038878e-02f, 1.06826033e-02f,
  -6.86894869e-03f, 5.40509261e-02f, 4.00797836e-02f, 1.19728297e-01f, 6.77300170e-02f, 5.56302555e-02f, 1.14354676e-04f, 2.35084910e-02f, 1.46737620e-01f, 2.45745778e-01f,
  1.47483021e-01f, 1.33989751e-01f, -2.41263099e-02f, 6.71474263e-02f, -9.45584178e-02f, -2.27990840e-02f, 1.90155078e-02f, 1.60562605e-01f, 1.06285691e-01f, 1.63235143e-01f,
  2.41088897e-01f, 2.59122908e-01f, 2.15797052e-01f, 1.75965726e-01f, 1.23796672e-01f, 9.83999856e-03f, 1.61528273e-03f, 4.49812375e-02f, 1.80938467e-01f, 4.21373434e-02f,
  3.30571756e-02f, 6.48500025e-02f, 1.00113399e-01f, 5.77858575e-02f, 1.37765467e-01f, 1.36064753e-01f, 9.30763632e-02f, 8.37437510e-02f, -3.56744579e-03f, 1.41178295e-01f,
  2.59824514e-01f, 1.01848558e-01f, 1.56679466e-01f, 1.10894933e-01f, 1.01634115e-01f, 1.82629004e-01f, 1.49639890e-01f, 2.19101742e-01f, 1.46660835e-01f, 1.16719708e-01f,
  9.60843638e-02f, 2.09893152e-01f, 1.06822118e-01f, 7.82912672e-02f, 1.32365242e-01f, 1.55531704e-01f, 2.42316648e-01f, 1.58094481e-01f, 1.24524221e-01f, 1.45414338e-01f,
  1.68643430e-01f, -1.86639410e-02f, 1.21666767e-01f, 1.16940036e-01f, 1.28662378e-01f, 1.33039296e-01f, 1.18523166e-01f, 1.93227530e-01f, 1.88511759e-01f, 1.39200032e-01f,
  -1.27205372e-01f, -2.45197341e-01f, -2.50090033e-01f, -2.20630303e-01f, -1.88154548e-01f, -1.54090181e-01f, -2.53584564e-01f, -2.63633072e-01f, -2.70304739e-01f, -1.81590647e-01f,
  -2.26153165e-01f, -1.33178011e-01f, -1.95997611e-01f, -1.97465733e-01f, -1.50427833e-01f, -2.91654199e-01f, -2.32940376e-01f, -2.04239503e-01f, -1.84618697e-01f, -1.64736554e-01f,
  -2.59034574e-01f, -2.87658304e-01f, -2.74705887e-01f, -1.78843841e-01f, -2.07555130e-01f, -1.62475765e-01f, -2.17848703e-01f, -1.89634725e-01f, -2.97971010e-01f, -2.82725930e-01f,
  2.72407979e-01f, 4.70478833e-02f, 2.71438628e-01f, 2.47731090e-01f, 1.08921282e-01f, 1.98485777e-01f, 1.35414779e-01f, 1.87132373e-01f, 1.91116706e-01f, 1.04524150e-01f,
  1.88315719e-01f, 1.52987406e-01f, 1.76892415e-01f, 1.40109509e-01f, 1.80281341e-01f, 9.46081951e-02f, 1.08778276e-01f, 1.84515968e-01f, 1.97846338e-01f, 2.18288913e-01f,
  4.92200926e-02f, 1.08314008e-02f, 1.31235626e-02f, 1.96061969e-01f, 1.12104468e-01f, 1.62545532e-01f, 1.83916554e-01f, 1.16842568e-01f, 6.88747913e-02f, 1.92477122e-01f,
  -4.42022175e-01f, 1.39480606e-01f, -5.49122356e-02f, -1.20371073e-01f, -7.94709772e-02f, -7.88322985e-02f, -1.19083092e-01f, -1.61748186e-01f, -1.98666885e-01f, 5.15535381e-03f,
  -2.43121162e-02f, -1.71407208e-01f, -1.12339862e-01f, -1.37285501e-01f, -6.37666881e-02f, 5.76936826e-02f, 8.95257741e-02f, 1.40569620e-02f, -1.98736519e-01f, 2.96368934e-02f,
  8.99731815e-02f, -3.62427831e-02f, -4.36935425e-02f, 9.35230702e-02f, 1.99223712e-01f, -6.74605742e-03f, 1.58147186e-01f, 1.25610888e-01f, 7.78408796e-02f, 3.17698777e-01f,
  -3.70581914e-03f, -1.22392766e-01f, -1.68798789e-01f, -8.11524093e-02f, 5.84644303e-02f, -9.20230225e-02f, -2.68545542e-02f, 7.42148533e-02f, -3.29822302e-04f, -5.95971309e-02f,
  2.38323063e-02f, -2.54988540e-02f, -5.77959418e-02f, 5.14498726e-02f, -4.63926084e-02f, -1.24198142e-02f, -8.79546851e-02f, -8.08725208e-02f, -1.30187646e-01f, 2.01728754e-02f,
  -5.90187609e-02f, 2.23757457e-02f, -1.87654927e-01f, -4.87565249e-02f, -1.41708523e-01f, -6.10124059e-02f, -1.13768898e-01f, -1.16009615e-01f, -9.67878699e-02f, -8.48397240e-02f,
  2.00119510e-01f, 3.76610421e-02f, 1.36903971e-01f, 6.39858395e-02f, 1.57231279e-02f, 8.92674699e-02f, 1.71653152e-01f, 1.55692607e-01f, 9.65109766e-02f, 1.60411775e-01f,
  -7.17789307e-03f, 9.03293341e-02f, 7.80957118e-02f, 7.43189380e-02f, 7.85112903e-02f, 9.06196684e-02f, 1.65037423e-01f, 1.79164633e-01f, 1.15800902e-01f, 8.67016166e-02f,
  6.75363466e-02f, 9.42355487e-03f, 1.11521356e-01f, 1.69309750e-01f, 8.72975364e-02f, 1.15076654e-01f, 8.13226402e-02f, 1.99874807e-02f, 9.46522057e-02f, 1.61585007e-02f,
  -2.90288836e-01f, -1.44258469e-01f, -7.94456005e-02f, -1.14091761e-01f, -3.38962465e-03f, 1.18591348e-02f, -7.22445026e-02f, -1.46331504e-01f, -6.60799220e-02f, -6.63006902e-02f,
  -1.40052915e-01f, -6.42726123e-02f, -1.34599015e-01f, -1.03225090e-01f, -1.43413335e-01f, -1.64784670e-01f, -4.86924052e-02f, -1.03571028e-01f, -6.34567142e-02f, -1.08322158e-01f,
  -1.05988242e-01f, -1.91349640e-01f, -2.45164722e-01f, -1.72828227e-01f, -2.08398134e-01f, -2.04830781e-01f, -1.35637999e-01f, -1.22107551e-01f, -3.04885983e-01f, -9.55853313e-02f,
  1.38096541e-01f, 1.00711472e-01f, 3.85870039e-02f, 2.41751164e-01f, 1.27829518e-03f, -1.42222464e-01f, -1.17360912e-01f, -2.18254194e-01f, 1.73655346e-01f, 1.81908444e-01f,
  7.34791979e-02f, -7.88686275e-02f, 2.42621955e-02f, -2.02907547e-01f, -2.29670838e-01f, -5.72844185e-02f, -7.09922537e-02f, -2.99707651e-01f, -2.92776346e-01f, -2.47508407e-01f,
  -5.78792989e-02f, -4.81122211e-02f, -6.13382645e-02f, -2.04074472e-01f, 4.75650318e-02f, -9.02509093e-02f, 5.11041209e-02f, 2.68793646e-02f, -5.53811826e-02f, 1.35588691e-01f,
  1.58382490e-01f, -1.60451740e-01f, 1.33905374e-03f, 7.50724152e-02f, 5.74777387e-02f, 3.09283659e-02f, -1.12098202e-01f, -8.80640931e-03f, -1.98034756e-02f, -9.64383315e-03f,
  5.69227114e-02f, -7.09495842e-02f, 4.96083200e-02f, 5.95189855e-02f, 1.24490084e-02f, -6.81094155e-02f, -1.05904050e-01f, -6.16127290e-02f, -9.91939232e-02f, -3.88138294e-02f,
  -4.75318879e-02f, 5.35417907e-02f, 4.72773165e-02f, -1.30268008e-01f, -1.07541680e-01f, -9.56983864e-03f, -4.84588742e-02f, -1.21959813e-01f, -6.38424531e-02f, 1.10188901e-01f,
  8.88562500e-02f, 3.72829214e-02f, -2.08314173e-02f, 2.38847919e-02f, 4.70461175e-02f, -1.10054659e-02f, 7.81816710e-03f, 4.12269458e-02f, -5.37062399e-02f, 8.50921273e-02f,
  -7.49832839e-02f, 5.39394021e-02f, 1.61561240e-02f, -1.41250389e-03f, -2.44812644e-03f, -5.86326830e-02f, -1.15736136e-02f, 3.19422856e-02f, -1.01378197e-02f, 3.84600125e-02f,
  4.13599834e-02f, -7.80091509e-02f, 5.65696880e-02f, -2.39818115e-02f, -7.85354301e-02f, -6.41886219e-02f, 2.22812910e-02f, -3.85088809e-02f, -9.58478078e-03f, 4.04342450e-02f,
  2.91792810e-01f, -2.39627033e-01f, 1.33876845e-01f, -1.10687755e-01f, 1.13190882e-01f, -4.40663360e-02f, 1.05320022e-01f, -1.04338182e-02f, 4.49162461e-02f, -1.81965027e-02f,
  1.26837939e-02f, -4.59294170e-02f, 3.28322798e-02f, -3.91625986e-02f, 8.77555162e-02f, 4.43435572e-02f, 1.61409855e-01f, 2.23628953e-02f, 2.29342021e-02f, 1.01069339e-01f,
  1.30678892e-01f, 7.57642165e-02f, 1.48264349e-01f, 4.81080636e-02f, -4.97173555e-02f, 4.30445001e-02f, -1.74595509e-02f, 1.39354363e-01f, 1.70115456e-02f, 1.35002077e-01f,
  2.65422612e-01f, 1.19637877e-01f, 2.86603034e-01f, 1.01017661e-01f, 6.32596537e-02f, 5.89521565e-02f, -4.05488685e-02f, -1.11374199e-01f, -6.97967932e-02f, -2.76975567e-03f,
  -6.46311566e-02f, -5.77980541e-02f, -1.55887082e-01f, -1.11362226e-01f, 2.51820721e-02f, -4.92877476e-02f, 7.72699192e-02f, 1.66568875e-01f, 1.70782924e-01f, 6.96723536e-03f,
  -5.62067470e-03f, 7.02813715e-02f, 9.85197872e-02f, 7.38208592e-02f, -1.44635469e-01f, -6.36746883e-02f, -6.10570647e-02f, 1.00787528e-01f, -5.18658943e-02f, -5.85027300e-02f,
  -7.52973324e-03f, 1.34289160e-01f, -4.22427393e-02f, 1.02984212e-01f, 4.37366143e-02f, 1.30072817e-01f, -1.78890303e-02f, 4.44184765e-02f, 9.68687385e-02f, 3.99707397e-03f,
  1.30689114e-01f, -3.14746471e-03f, -2.30343174e-02f, 1.04921274e-01f, 6.31719753e-02f, 6.56941533e-02f, 4.18090411e-02f, 1.44346878e-01f, 1.94415636e-02f, 1.31927520e-01f,
  2.61300355e-02f, 1.36550769e-01f, 2.97628134e-01f, -1.39129041e-02f, 1.26504719e-01f, 7.05914199e-02f, 8.37597549e-02f, 6.65497184e-02f, 1.68837383e-02f, 1.34703135e-02f,
  1.21677676e-02f, 9.35286209e-02f, -5.03244959e-02f, -5.38568124e-02f, -5.69531955e-02f, -8.64574462e-02f, -1.62666932e-01f, -3.17038372e-02f, -7.40460828e-02f, -6.50984868e-02f,
  -5.95239177e-02f, -1.64538564e-03f, -1.26067862e-01f, -6.10190928e-02f, -1.23053849e-01f, 3.74579765e-02f, 5.06938295e-03f, -1.16927519e-01f, -2.23668441e-02f, -3.58738676e-02f,
  -2.37633102e-02f, -3.27490792e-02f, -1.40257508e-01f, -1.44014284e-01f, -5.91632240e-02f, -8.50254521e-02f, -6.79728296e-03f, -4.79533151e-02f, -8.18558782e-02f, -2.08709445e-02f,
  -2.16583163e-01f, 8.32484365e-02f, -7.22710043e-02f, 4.41372059e-02f, 7.43964836e-02f, -9.73315444e-03f, 2.32080389e-02f, 1.10732637e-01f, 1.61001168e-03f, 1.31586611e-01f,
  3.88048030e-02f, 8.99634585e-02f, -6.10413924e-02f, 1.16692469e-01f, 3.37221622e-02f, 1.59787834e-02f, 5.55446260e-02f, -7.66605930e-03f, 8.14807490e-02f, 1.51738644e-01f,
  1.29743487e-01f, 2.10265309e-01f, 1.57135129e-01f, 8.06266740e-02f, 7.54256397e-02f, 9.20920521e-02f, 1.97983328e-02f, -7.42918402e-02f, 4.38373722e-02f, -6.02619611e-02f,
  2.87930280e-01f, 3.84505428e-02f, 3.00009936e-01f, 3.01760048e-01f, 9.68272239e-02f, -4.67769690e-02f, -1.01676473e-04f, 1.15221038e-01f, 1.90074429e-01f, 1.93513393e-01f,
  -1.51466010e-02f, 4.20121215e-02f, 1.17707722e-01f, -4.71991524e-02f, -8.92247930e-02f, -7.61914849e-02f, 4.03114073e-02f, 7.70212784e-02f, -5.07937558e-02f, -2.05271125e-01f,
  -1.28557459e-01f, -5.97068034e-02f, -4.68208604e-02f, -1.49053380e-01f, 2.70526446e-02f, -2.19104998e-02f, 1.22400433e-01f, 8.01222920e-02f, -6.54439032e-02f, -1.94960106e-02f,
  1.71603516e-01f, 1.15949623e-01f, 3.55001949e-02f, -2.07670331e-01f, 2.22655130e-03f, -6.02850020e-02f, -2.13941932e-02f, 1.05398357e-01f, -2.10968032e-02f, -5.98173030e-02f,
  -9.99349654e-02f, 4.27113427e-03f, -7.49919340e-02f, -6.09321631e-02f, 4.37037088e-02f, 2.41725985e-02f, -8.69015604e-02f, -7.40813790e-03f, -5.16261123e-02f, 1.97767764e-02f,
  -1.45022795e-01f, -8.73248503e-02f, 6.07482195e-02f, -1.78801566e-02f, 8.89589265e-03f, 1.53873325e-03f, -6.34703636e-02f, -2.14504190e-02f, 3.22412960e-02f, -5.52696399e-02f,
  -8.63411799e-02f, 5.86902117e-03f, 5.28898370e-03f, 3.18995640e-02f, 2.33387388e-02f, 9.45382342e-02f, 8.14319029e-02f, -4.48217168e-02f, -1.66345555e-02f, 4.44417521e-02f,
  -1.83753874e-02f, 2.14075390e-02f, 4.46207710e-02f, 7.95780569e-02f, 6.71784356e-02f, 4.08460200e-02f, -5.61860157e-03f, -2.39894837e-02f, -3.82602029e-02f, 7.98293669e-03f,
  -3.28289904e-03f, 1.32874949e-02f, 1.41772494e-01f, -5.31306416e-02f, -4.45327014e-02f, 3.93745974e-02f, 2.84157172e-02f, 5.53867687e-03f, 8.14697966e-02f, -1.94430668e-02f,
  2.35357910e-01f, -1.67527288e-01f, 1.89679284e-02f, 7.25960359e-02f, 5.35393432e-02f, -4.53190841e-02f, 5.64321391e-02f, -4.93591540e-02f, 8.80176276e-02f, 6.15604147e-02f,
  -2.07766164e-02f, 6.04501218e-02f, 3.74511406e-02f, -7.57352337e-02f, -2.29824577e-02f, 4.71811295e-02f, 4.40098047e-02f, 1.14068121e-01f, -6.91612139e-02f, 1.37543716e-02f,
  -1.36049092e-01f, 3.76411006e-02f, 2.01535136e-01f, 1.79449663e-01f, 1.80638228e-02f, 1.73447877e-01f, 1.77957028e-01f, 1.35657355e-01f, 6.75158277e-02f, 1.18772484e-01f,
  -1.41293019e-01f, 3.55508208e-01f, -3.79244417e-01f, -2.64368355e-01f, -3.12890530e-01f, -5.27938008e-02f, 2.47603998e-01f, 1.21222474e-01f, 2.90625021e-02f, -1.38457082e-02f,
  -2.19464183e-01f, -1.36838615e-01f, -7.86787197e-02f, 4.10697870e-02f, 1.34015307e-01f, 1.59547776e-01f, 4.40558884e-03f, -2.57675111e-01f, -1.49112940e-01f, 1.29442643e-02f,
  1.51816076e-02f, -1.73468646e-02f, -1.14927039e-01f, 1.12181202e-01f, 1.00655362e-01f, -1.25374660e-01f, 3.56108969e-04f, -9.61155221e-02f, 5.44538833e-02f, -2.75782868e-02f,
  -1.95129320e-01f, -1.21388063e-01f, -1.31044284e-01f, -1.33660451e-01f, -2.23488480e-01f, -3.51018235e-02f, -1.13707781e-01f, -5.76730482e-02f, -4.75571789e-02f, -7.51947761e-02f,
  -1.58522725e-01f, -1.76947955e-02f, -2.12641343e-01f, 2.29131561e-02f, -9.20930579e-02f, 4.11050133e-02f, 8.91838074e-02f, 4.98002842e-02f, -5.15817851e-02f, 1.43661769e-02f,
  5.13529181e-02f, -1.37594596e-01f, -2.44266987e-01f, -1.26593851e-03f, -5.00939339e-02f, -1.58292279e-01f, -4.15052399e-02f, -4.46949676e-02f, -2.88308528e-03f, 2.20586196e-01f,
  6.39844388e-02f, -9.24172811e-03f, 1.10216886e-01f, 9.83244255e-02f, 2.04129100e-01f, 3.86410877e-02f, 5.70815615e-02f, 5.07785492e-02f, 1.70082018e-01f, 1.63803384e-01f,
  1.25755101e-01f, 1.36588197e-02f, 1.24193355e-01f, 5.98939061e-02f, 1.23481840e-01f, 5.36899455e-03f, 7.07007498e-02f, 1.43819660e-01f, 4.79058772e-02f, 6.86298087e-02f,
  5.10942340e-02f, 7.09397942e-02f, -2.29873545e-02f, 1.35730043e-01f, 4.99385670e-02f, 4.96834330e-02f, 1.40005261e-01f, 9.86191481e-02f, 1.08939894e-01f, 4.94545028e-02f,
  1.82180386e-02f, -3.20358694e-01f, -1.09626316e-01f, -6.09193183e-02f, -1.16202541e-01f, -9.01769921e-02f, -1.25182450e-01f, -8.36869180e-02f, -2.70604640e-01f, -7.65961111e-02f,
  -7.89906904e-02f, -2.25030556e-02f, -4.03953679e-02f, 3.78863737e-02f, -8.67764279e-02f, -1.07480250e-01f, 2.09659780e-03f, -2.34635845e-01f, -4.65086028e-02f, -3.63291167e-02f,
  4.60029095e-02f, -1.53434515e-01f, -6.39942959e-02f, -6.40140027e-02f, -3.22924219e-02f, -1.85622349e-01f, -1.28549680e-01f, -5.42160980e-02f, -8.65836591e-02f, 2.20768422e-01f,
  -3.49425435e-01f, -1.47974819e-01f, -2.35303223e-01f, -2.02191472e-01f, 1.72340915e-01f, 3.97102121e-04f, -1.66394144e-01f, -1.97312221e-01f, 3.34528205e-03f, -1.09227881e-01f,
  1.86724320e-01f, 4.17488247e-01f, 1.85319558e-01f, 3.03485394e-01f, 9.80099365e-02f, -2.32896104e-01f, -1.28351316e-01f, 1.01286639e-02f, 8.34717453e-02f, 2.33402953e-01f,
  1.71454266e-01f, -1.57036588e-01f, -1.11216284e-01f, -1.14344999e-01f, 1.27018958e-01f, 2.28670225e-01f, -1.09305501e-01f, -5.32146394e-02f, 1.87050387e-01f, 8.41346979e-02f,
  1.77750930e-01f, -8.03066641e-02f, 1.78306758e-01f, 1.57781914e-01f, 5.06979302e-02f, -4.95532937e-02f, -4.10475843e-02f, -6.11113310e-02f, 1.07510025e-02f, -7.98170120e-02f,
  8.93422887e-02f, 1.04370080e-01f, 1.55808151e-01f, 1.15257926e-01f, -2.39892993e-02f, 8.92208442e-02f, -1.15355544e-01f, -6.86433986e-02f, -8.88890773e-02f, 9.82538015e-02f,
  2.52870440e-01f, 4.29363288e-02f, -7.32703581e-02f, -1.04737379e-01f, -3.49979438e-02f, 2.13574052e-01f, -2.46631401e-03f, 1.05625540e-02f, 4.25404217e-03f, -2.01875895e-01f,
  -1.15236297e-01f, -9.54509005e-02f, -4.77025993e-02f, -1.20892182e-01f, -8.24945122e-02f, 2.14548763e-02f, 1.84364468e-02f, 3.82436230e-03f, -4.50376309e-02f, -1.36846766e-01f,
  5.68476841e-02f, -2.47355737e-02f, 3.89442258e-02f, -1.19812571e-01f, 2.70130783e-02f, -6.32075295e-02f, -3.29328515e-02f, -1.72759742e-02f, 4.97083440e-02f, -7.27131218e-02f,
  1.29427329e-01f, -3.83079574e-02f, -3.16610411e-02f, 1.18345226e-04f, 3.65966931e-02f, -7.50444680e-02f, 3.56003307e-02f, 7.88835809e-02f, -1.99473817e-02f, -6.36515114e-03f,
  -4.69545014e-02f, 1.98948756e-01f, 1.31017208e-01f, 1.13734171e-01f, 6.31912947e-02f, 3.90826911e-02f, 1.80690542e-01f, 2.94163339e-02f, 8.55751261e-02f, 1.20960429e-01f,
  1.01988226e-01f, 3.16797420e-02f, 9.25307497e-02f, -5.33804521e-02f, 4.67863232e-02f, 1.96473431e-02f, 7.82967880e-02f, 3.83652076e-02f, 6.05584681e-02f, 1.66959893e-02f,
  2.12283786e-02f, -9.50288847e-02f, 2.71702502e-02f, 4.48371619e-02f, 1.04478136e-01f, 1.48502454e-01f, 1.41420048e-02f, 7.60736093e-02f, -2.44144369e-02f, -2.07689703e-01f,
  -3.34099114e-01f, 3.54231983e-01f, 6.03807718e-02f, -2.15895802e-01f, 2.28731167e-02f, -1.34150997e-01f, -6.91007748e-02f, -1.99529216e-01f, -1.06316425e-01f, 2.17697751e-02f,
  1.74646303e-01f, 9.14308131e-02f, -4.47098836e-02f, -6.18881285e-02f, -1.48507416e-01f, -1.02648422e-01f, -1.25137344e-01f, -3.31891149e-01f, -3.81992847e-01f, -2.32060149e-01f,
  -1.17349565e-01f, -1.91325068e-01f, -1.65980801e-01f, -1.14564717e-01f, 7.54850358e-02f, -8.04494023e-02f, 1.12290502e-01f, 4.78739329e-02f, 1.49026543e-01f, 1.04613304e-01f,
  5.50792813e-02f, 1.10659696e-01f, -3.11489016e-01f, -6.63390905e-02f, 4.16067354e-02f, -9.21414718e-02f, -1.44427195e-02f, -5.59405889e-03f, 4.09748070e-02f, -8.70454311e-03f,
  -7.33601227e-02f, -1.58976819e-02f, -3.38494591e-02f, -9.62070301e-02f, -1.58853158e-01f, -5.26214130e-02f, -1.14890240e-01f, -1.66041896e-01f, -1.22341469e-01f, -4.92805131e-02f,
  5.15331514e-02f, 1.24896411e-02f, -4.69622947e-02f, -7.26659149e-02f, -6.74720705e-02f, -1.88651487e-01f, 1.73965283e-02f, -6.65965155e-02f, -1.33220658e-01f, -1.71436355e-01f,
  -8.20896477e-02f, 6.83884323e-02f, 1.54819086e-01f, 1.16551936e-01f, 7.83975348e-02f, 2.41848528e-02f, 7.13630170e-02f, 7.17208982e-02f, 6.38716072e-02f, 8.52576792e-02f,
  2.89831609e-02f, 3.34664807e-02f, 6.82430789e-02f, 3.55660804e-02f, 1.64303437e-01f, 9.57813188e-02f, 1.41273186e-01f, 6.39958829e-02f, 2.19427496e-01f, 8.04022923e-02f,
  1.06981285e-01f, 2.43808771e-03f, 1.36017770e-01f, 1.10360645e-01f, 1.92377150e-01f, 1.58122241e-01f, 4.80874479e-02f, 4.16017137e-02f, 7.76436478e-02f, 1.04641154e-01f,
  -1.82787269e-01f, 3.59231909e-03f, -1.58250034e-01f, -5.48768602e-02f, -4.28635925e-02f, -3.52023169e-02f, -5.68914153e-02f, 1.27775874e-03f, -2.15912219e-02f, -8.39925185e-02f,
  -8.97022113e-02f, -1.28921956e-01f, -1.34721398e-02f, -3.27891894e-02f, -1.11821987e-01f, -5.41216619e-02f, -2.00639870e-02f, -3.06259226e-02f, -4.01297510e-02f, -1.00430995e-01f,
  -1.42787710e-01f, -1.37353480e-01f, -2.56989539e-01f, -1.32314309e-01f, -1.53892338e-01f, -1.62607193e-01f, -1.81133524e-01f, -1.63076892e-01f, -2.70728022e-01f, -2.01174796e-01f,
  3.17454696e-01f, 1.52070954e-01f, 3.98138687e-02f, -1.04620330e-01f, -1.80784911e-01f, 4.51059751e-02f, 3.29231083e-01f, 2.08159223e-01f, -7.37062991e-02f, -8.37964714e-02f,
  -2.90767610e-01f, -4.26752776e-01f, -3.49073231e-01f, -3.42791051e-01f, -7.44022653e-02f, 1.23703651e-01f, -2.93140691e-02f, -1.44815534e-01f, -1.18499100e-01f, -1.11909173e-01f,
  -1.80417076e-01f, 5.21813110e-02f, 9.94593874e-02f, -7.22901151e-02f, -1.72699228e-01f, -3.53792995e-01f, -1.49533730e-02f, -3.05823353e-03f, -2.17039417e-03f, -2.68743515e-01f,
  -2.33352959e-01f, 2.53098279e-01f, -1.99955702e-01f, -2.62709618e-01f, -2.22003609e-01f, -7.92958438e-02f, -1.34864539e-01f, -8.34077746e-02f, -9.09173340e-02f, -1.08391233e-01f,
  -2.27136508e-01f, -9.86596644e-02f, -1.15798309e-01f, -1.48375943e-01f, 1.02497116e-02f, -6.09706901e-02f, -4.63096760e-02f, -4.03070897e-02f, -9.58402529e-02f, -9.85055715e-02f,
  -2.26557195e-01f, -4.59640473e-02f, 2.55864020e-02f, -2.61002649e-02f, -9.28809941e-02f, -2.26359040e-01f, -4.94794026e-02f, -1.13310747e-01f, -4.48901989e-02f, 6.08553179e-04f,
  -2.94248834e-02f, 4.42050211e-02f, 5.70049621e-02f, 1.37669608e-01f, 1.76300704e-02f, 7.73928314e-02f, 1.69212148e-02f, 6.10732771e-02f, 1.69663914e-02f, 1.23377830e-01f,
  -3.04521285e-02f, 1.55286983e-01f, 5.74445948e-02f, 1.44414961e-01f, 3.28148305e-02f, 3.55022773e-02f, 9.87989455e-02f, 1.72456965e-01f, 1.16270915e-01f, 1.83621317e-01f,
  2.61149332e-02f, 6.57548904e-02f, 7.30026066e-02f, 9.27604139e-02f, 9.59735289e-02f, 6.53749853e-02f, -7.26145878e-03f, 5.03435433e-02f, 9.95107293e-02f, 1.43889606e-01f,
  -1.88746512e-01f, -2.47181524e-02f, -1.35731041e-01f, -1.45344332e-01f, -6.31655660e-03f, -8.46156627e-02f, -2.04292953e-01f, -1.02662250e-01f, -1.46100566e-01f, -3.17864493e-02f,
  -4.99066785e-02f, -3.54568474e-02f, -9.45563763e-02f, -1.34659827e-01f, -5.45544364e-02f, -1.70965493e-01f, -5.66079803e-02f, -2.24851936e-01f, -1.23472601e-01f, -1.57633543e-01f,
  -9.40305665e-02f, 2.58661825e-02f, -1.28314450e-01f, -1.02538139e-01f, -8.50303397e-02f, -2.64128864e-01f, -9.04922560e-02f, -8.63170549e-02f, -3.58217321e-02f, 5.33044059e-03f,
  4.42258827e-02f, 3.36574405e-01f, -2.80053586e-01f, 5.07823266e-02f, -2.03115754e-02f, -2.81270146e-01f, 2.80288178e-02f, -3.91956195e-02f, -4.05103900e-02f, 4.06469256e-02f,
  9.04101413e-03f, -2.55751014e-01f, -2.38649845e-01f, -2.65134603e-01f, -1.91626325e-01f, 8.60277042e-02f, 3.75868194e-02f, -2.63051480e-01f, -2.94399828e-01f, -9.99404043e-02f,
  1.93657503e-01f, 2.24100068e-01f, 8.58868062e-02f, 8.47958326e-02f, 6.18817806e-02f, -1.32788315e-01f, -5.40409647e-02f, 4.22811061e-02f, -9.09222588e-02f, 1.11617111e-01f,
  -3.37111324e-01f, -1.20309137e-01f, -2.91415632e-01f, -8.66643935e-02f, -6.80273399e-02f, -1.06245980e-01f, -8.89514610e-02f, -1.36003971e-01f, -7.92384967e-02f, -5.73561825e-02f,
  -1.34052008e-01f, -1.08550563e-01f, -1.08698934e-01f, -2.12856662e-02f, 3.02660074e-02f, -1.69770241e-01f, -1.22184768e-01f, -1.30242571e-01f, -1.86513424e-01f, -7.47934580e-02f,
  3.62711884e-02f, -5.15404716e-02f, -2.06826150e-01f, -1.28927365e-01f, -1.83555752e-01f, -2.91906416e-01f, -1.04337409e-01f, -2.30633900e-01f, -3.30209732e-01f, 5.60355820e-02f,
  1.63478732e-01f, 1.36335060e-01f, -8.53471551e-03f, 1.29935384e-01f, 8.61971825e-02f, 2.45342627e-02f, 5.70448376e-02f, 9.63699147e-02f, 8.66287947e-02f, 1.85104370e-01f,
  -2.47643106e-02f, 3.43044586e-02f, 4.65430878e-02f, 3.89407538e-02f, 9.21396315e-02f, 6.36154264e-02f, 2.24562977e-02f, 1.05978310e-01f, 2.13032793e-02f, 4.10466045e-02f,
  3.60709392e-02f, 6.23796077e-04f, 4.44547981e-02f, 1.39175639e-01f, 1.22979373e-01f, 3.84162404e-02f, 4.50491570e-02f, 1.06797300e-01f, 6.78927302e-02f, 6.98067173e-02f,
  -1.07300766e-02f, -3.52006972e-01f, -1.35536462e-01f, -5.84124364e-02f, -1.04457833e-01f, -5.24728559e-02f, -1.17714904e-01f, -4.19445373e-02f, -4.55771722e-02f, -4.15139906e-02f,
  -1.08777523e-01f, -1.65427346e-02f, -9.00601000e-02f, -7.59727955e-02f, -2.00642034e-01f, -1.02484994e-01f, -6.72053397e-02f, -7.85142705e-02f, -1.76072046e-01f, -1.03470668e-01f,
  2.45527942e-02f, -1.86750516e-01f, -2.70677060e-01f, -9.04333740e-02f, -1.65718451e-01f, -2.65247911e-01f, -8.51961225e-02f, -9.54319462e-02f, -3.02197367e-01f, 4.00268547e-02f,
  2.14431226e-01f, -2.41755068e-01f, -3.64694536e-01f, -1.69448256e-01f, -3.89742777e-02f, -5.76845296e-02f, -2.18057334e-01f, -4.45819683e-02f, -7.70813506e-03f, -1.07219592e-01f,
  -3.85223739e-02f, 1.61913067e-01f, -1.46627501e-01f, -6.64536357e-02f, -3.10733467e-01f, -3.47661078e-01f, -3.77733380e-01f, -3.09376866e-01f, -1.76917419e-01f, 7.11429715e-02f,
  8.14188868e-02f, 2.40100687e-03f, -5.86539097e-02f, -6.54488429e-02f, -1.28356889e-01f, -1.13149874e-01f, -1.61926597e-01f, -1.86616909e-02f, -2.57909726e-02f, -2.92311072e-01f,
  -2.24829078e-01f, 5.52706979e-02f, -1.13545498e-02f, 9.10657272e-02f, -6.48194328e-02f, -1.10199697e-01f, 8.68718885e-03f, -4.75113355e-02f, 1.53771304e-02f, -3.05181835e-02f,
  -4.57413048e-02f, 3.54443863e-03f, 4.45283391e-03f, 1.80341955e-02f, -6.09629564e-02f, -1.10759912e-02f, -1.39579579e-01f, -2.24127650e-01f, -7.20404014e-02f, -3.61379310e-02f,
  -6.00579344e-02f, -5.33142011e-04f, -1.67625308e-01f, -1.19023539e-01f, -1.11866631e-01f, -1.28961965e-01f, -8.02054554e-02f, -2.64627952e-02f, -1.56487152e-01f, -1.60124958e-01f,
  1.39812017e-02f, 3.73718664e-02f, 1.31025612e-01f, 9.91767645e-02f, 1.10453114e-01f, 1.10960640e-01f, 5.72525291e-03f, 2.97632404e-02f, 1.22799054e-01f, 5.61315268e-02f,
  6.66957870e-02f, 6.16109818e-02f, -4.45463546e-02f, -6.59026951e-02f, 3.40215676e-02f, 4.38968055e-02f, -2.03163773e-02f, 7.57402182e-02f, 5.99089190e-02f, 9.40447450e-02f,
  1.35792390e-01f, 8.55133682e-02f, 3.96188200e-02f, 2.24102829e-02f, 8.95228535e-02f, -6.01851121e-02f, 1.22934714e-01f, 1.92036852e-01f, 1.85773343e-01f, 9.14275125e-02f,
  -4.35758531e-02f, -1.38170347e-01f, 1.35383271e-02f, -1.17892861e-01f, -1.92434806e-02f, 2.29555592e-02f, -3.93722691e-02f, -9.40172002e-02f, -1.52265467e-02f, -1.02450751e-01f,
  -3.26830782e-02f, -1.61089040e-02f, -1.27924562e-01f, -2.23782361e-02f, -5.44069819e-02f, -6.90955520e-02f, -8.04216862e-02f, -4.83142547e-02f, -7.86189809e-02f, 4.80178893e-02f,
  -8.89267623e-02f, -1.24630794e-01f, -3.78827415e-02f, -5.58605343e-02f, -5.94890751e-02f, -2.90086493e-02f, -1.05677240e-01f, -2.38686353e-02f, -5.72936749e-03f, -1.35012478e-01f,
  -4.81451035e-01f, -1.14970073e-01f, 1.17868423e-01f, -1.60524592e-01f, 2.58698583e-01f, 3.77185464e-01f, 3.67770910e-01f, 1.68863416e-01f, -1.88456550e-02f, -1.06995841e-02f,
  2.56910399e-02f, -1.65409446e-01f, -5.25214747e-02f, 6.95433840e-02f, 1.26184344e-01f, 1.83067143e-01f, 1.06718086e-01f, -1.53898783e-02f, 1.60997972e-01f, 2.74995506e-01f,
  5.64415865e-02f, -2.08861992e-01f, -1.52965933e-01f, 2.52316557e-02f, -6.70597777e-02f, -5.77510186e-02f, 1.00264307e-02f, 7.39189014e-02f, 5.61780185e-02f, -1.90548271e-01f,
  -3.96458898e-03f, 1.75732300e-01f, 1.20300703e-01f, -3.44373249e-02f, 1.31079316e-01f, -2.76377201e-02f, 3.81563678e-02f, 5.64404503e-02f, 8.72314498e-02f, -3.84959690e-02f,
  1.11354969e-01f, 2.69399229e-02f, 7.76351392e-02f, 5.76429851e-02f, -1.36837317e-02f, 6.46499991e-02f, -7.52050877e-02f, -6.36321902e-02f, 1.05308525e-01f, 9.32855532e-02f,
  1.12855844e-01f, 1.44380316e-01f, 5.42918146e-02f, 7.03634247e-02f, 2.08098605e-01f, -3.82862575e-02f, 2.04611257e-01f, 1.82821929e-01f, 1.10674255e-01f, -1.36563241e-01f,
  -1.74805090e-01f, -4.34649326e-02f, 6.02219580e-03f, -2.43562777e-02f, -8.14935789e-02f, -2.06639729e-02f, 4.20651166e-03f, -5.23075312e-02f, 8.27615559e-02f, -5.33670932e-02f,
  -6.58527166e-02f, 1.80064011e-02f, -6.56490773e-02f, 3.23021202e-03f, -8.42843801e-02f, -4.55459487e-03f, 2.49289242e-05f, -1.13308899e-01f, 7.74269179e-02f, -4.99593765e-02f,
  -9.82676297e-02f, 4.13431451e-02f, 1.56164740e-03f, -5.59939537e-03f, -9.52486228e-03f, -7.83733726e-02f, -2.19833031e-02f, -1.06351785e-01f, -4.97702956e-02f, -6.33138567e-02f,
  -2.55264312e-01f, 2.20963880e-01f, -8.49070996e-02f, 9.60032865e-02f, 5.77326752e-02f, 1.11216553e-01f, 1.52688697e-01f, 7.67401755e-02f, 7.45025501e-02f, 4.42626365e-02f,
  2.02465698e-01f, 1.18166931e-01f, 1.01929478e-01f, 9.12090987e-02f, 1.32109329e-01f, 1.78856924e-01f, 7.71930441e-02f, 9.64278951e-02f, 1.32995322e-01f, 9.48367789e-02f,
  4.59033139e-02f, 7.92951882e-02f, -4.85794283e-02f, 1.55517086e-01f, 1.52437404e-01f, 1.46511316e-01f, 4.60220277e-02f, 7.83507004e-02f, 9.48690102e-02f, -3.34623680e-02f,
  -1.76680550e-01f, -1.05264656e-01f, -7.74158910e-02f, -2.42388956e-02f, 2.13474333e-01f, -8.54168683e-02f, -2.00391471e-01f, -1.39630571e-01f, -1.01128384e-01f, -3.75481173e-02f,
  -3.11926659e-02f, -6.78745434e-02f, -2.28269771e-01f, -1.06709160e-01f, -2.18022630e-01f, -1.39027372e-01f, -1.46399647e-01f, -1.19887397e-01f, -5.41059859e-02f, 9.23786238e-02f,
  8.91635865e-02f, 7.56977201e-02f, 1.80635035e-01f, 1.42041266e-01f, 1.98963732e-02f, -1.44111598e-02f, -1.04407361e-02f, 2.49586120e-01f, 3.40588540e-02f, 1.22734373e-02f,
  -2.27479681e-01f, 5.70774861e-02f, -2.93396339e-02f, 3.34824398e-02f, -5.95704978e-03f, -7.44464472e-02f, 8.79210606e-03f, -6.76993933e-03f, -2.54309084e-02f, -5.97144514e-02f,
  4.72856760e-02f, -9.33947265e-02f, -7.64878616e-02f, 5.77870943e-02f, 2.32167710e-02f, -2.80490369e-02f, 5.26126884e-02f, -2.10401230e-02f, -1.20227106e-01f, 2.79239547e-02f,
  2.43180618e-02f, 7.99577460e-02f, -5.59455007e-02f, -7.92773962e-02f, -7.52630234e-02f, -1.12060435e-01f, -3.53069566e-02f, 8.07300955e-02f, -5.58465607e-02f, -5.55767827e-02f,
  -9.46875960e-02f, 1.48055609e-02f, 6.72765821e-03f, 8.48936103e-03f, -3.14175263e-02f, 2.28416380e-02f, -2.71678772e-02f, 5.93526885e-02f, 6.24916796e-03f, 1.66767202e-02f,
  -4.00965428e-03f, -5.82568720e-02f, -3.21669467e-02f, 4.26462889e-02f, 8.30702484e-02f, 8.39406028e-02f, 2.23296639e-02f, 8.64287000e-03f, 7.64336437e-02f, 1.19213322e-02f,
  1.11219510e-02f, 3.76020968e-02f, 3.22388560e-02f, 2.12702285e-02f, 2.37744898e-02f, 6.85403123e-02f, 6.47711530e-02f, 7.00045526e-02f, 3.74250137e-03f, -2.76929326e-03f,
  -2.64274001e-01f, 1.51928425e-01f, -2.29196027e-01f, -1.12650171e-01f, 5.47167026e-02f, -7.87186697e-02f, 3.46903428e-02f, -5.68977650e-03f, 2.66801994e-02f, 3.86679880e-02f,
  1.09141961e-01f, -7.12125972e-02f, 4.88392897e-02f, 1.56023894e-02f, -1.83829945e-02f, -1.97310839e-02f, -8.15305263e-02f, -9.47487131e-02f, 4.48999219e-02f, 7.42891356e-02f,
  -8.79921834e-04f, -1.46104783e-01f, -2.06909984e-01f, -1.71382815e-01f, 3.40184420e-02f, -1.31127879e-01f, -1.56320795e-01f, -1.07326552e-01f, -1.00718789e-01f, -2.78530747e-01f,
  -3.92028779e-01f, -1.86961517e-01f, 1.64381623e-01f, -3.62170786e-01f, -1.46255180e-01f, -7.98453093e-02f, -1.44831151e-01f, -1.61854997e-01f, -2.29109362e-01f, -3.14805418e-01f,
  -2.39027277e-01f, 8.90129730e-02f, 1.50654957e-01f, 2.25612625e-01f, 2.42482498e-01f, 2.35519633e-02f, 5.30502684e-02f, 2.65752167e-01f, 2.72261739e-01f, -6.19550347e-02f,
  -1.51683897e-01f, -8.03320110e-02f, -2.05631945e-02f, -7.59721994e-02f, -2.12169558e-01f, 2.03460716e-02f, -3.08283865e-02f, -7.40763396e-02f, 3.52913290e-02f, -1.18152268e-01f,
  1.13502808e-01f, -2.67494321e-01f, -5.25298296e-03f, -1.05152139e-02f, -4.02283818e-02f, -1.52552709e-01f, -1.66066572e-01f, -1.36590183e-01f, -2.11490080e-01f, -1.87750801e-01f,
  -4.97681573e-02f, -3.21476720e-02f, -3.05079278e-02f, -9.54018757e-02f, -1.87042385e-01f, -1.34354666e-01f, -1.09969556e-01f, -1.20816201e-01f, 7.21278321e-03f, -9.40419585e-02f,
  -1.43990368e-01f, -8.81222263e-02f, -1.24211438e-01f, -6.83607832e-02f, -5.70446216e-02f, 1.80516411e-02f, -5.20181954e-02f, -6.92322925e-02f, -5.90324104e-02f, -2.28800371e-01f,
  1.34305775e-01f, 1.52782142e-01f, -2.35794410e-02f, -2.45198086e-02f, -3.94752994e-02f, 3.60921733e-02f, 7.91511312e-02f, 8.66975114e-02f, 9.38798636e-02f, 6.02097288e-02f,
  1.53816247e-03f, 8.27860739e-03f, 1.13380127e-01f, 1.90724805e-02f, 1.09883592e-01f, 1.04881816e-01f, 2.83507444e-02f, 4.19179760e-02f, 3.38853672e-02f, 2.81111989e-02f,
  4.88094725e-02f, 4.62794229e-02f, 3.59755196e-02f, 6.87481314e-02f, 1.21776715e-01f, 4.02376540e-02f, 1.02265790e-01f, 4.78543676e-02f, 4.79636751e-02f, -2.93080378e-02f,
  -7.72378147e-02f, 1.59148082e-01f, -1.36473998e-01f, 1.50062796e-02f, -1.18337914e-01f, -8.51544961e-02f, -1.37271404e-01f, -1.14997789e-01f, -4.26650830e-02f, -7.22153187e-02f,
  3.32803912e-02f, -1.20850414e-01f, -5.28111234e-02f, 1.07816262e-02f, -3.13112536e-03f, -1.58721991e-02f, -1.78848162e-01f, -9.67113581e-03f, 2.94663552e-02f, -7.88445324e-02f,
  -1.76579803e-01f, -9.09756497e-02f, -1.70722485e-01f, -1.24855146e-01f, -9.43945721e-02f, 1.20756375e-02f, 3.16063575e-02f, -1.65387169e-01f, -6.63318262e-02f, -2.78058678e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.40873945e-01f, 5.32863915e-01f, 3.55376989e-01f, 2.66482867e-02f, 3.14959019e-01f, -5.30516617e-02f, -1.13121718e-01f, -1.77741185e-01f, -8.81769974e-03f, 1.48896128e-01f,
  1.81955650e-01f, -1.63978577e-01f, -1.49992138e-01f, -3.54792416e-01f, -4.31326002e-01f, -2.11011365e-01f, -2.06379727e-01f, -2.97001928e-01f, -6.48845375e-01f, -4.57408220e-01f,
  -4.03536707e-01f, -1.36116847e-01f, -1.05201520e-01f, -1.15448825e-01f, 3.80242884e-01f, -1.28362283e-01f, 3.85632694e-01f, 4.46613818e-01f, 3.50923181e-01f, 4.42661136e-01f,
  5.20968676e-01f, 7.41597593e-01f, -5.47503471e-01f, -1.03666276e-01f, 1.95789680e-01f, -3.57044600e-02f, -1.64283186e-01f, 2.25238368e-01f, -4.77616750e-02f, 1.98412705e-02f,
  6.82013482e-02f, 7.50891715e-02f, 1.41253144e-01f, 2.66849473e-02f, -8.66808444e-02f, -1.19880907e-01f, 2.75778659e-02f, -1.38783112e-01f, -2.49906585e-01f, -1.82825997e-02f,
  -2.48168260e-01f, 1.21398784e-01f, 1.67522490e-01f, -1.36842266e-01f, -1.14996079e-02f, -2.47417569e-01f, 1.84773803e-01f, 1.54110447e-01f, -2.75161825e-02f, 3.11607152e-01f,
  -1.71409488e-01f, -4.31255028e-02f, -3.22177485e-02f, -1.22961439e-02f, -2.62024194e-01f, 8.10740292e-02f, 6.04154132e-02f, -7.62967691e-02f, -5.71269393e-02f, -5.75436912e-02f,
  -1.12793379e-01f, 2.38425341e-02f, -1.08432598e-01f, -1.10901482e-01f, -5.53629771e-02f, 5.68794198e-02f, -4.53122742e-02f, -1.95500419e-01f, 2.30353512e-02f, 4.54745255e-02f,
  -1.30808011e-01f, -1.09168384e-02f, 1.74680531e-01f, -9.91410688e-02f, 1.02808714e-01f, -1.63313493e-01f, -9.18550789e-02f, -1.50385946e-01f, -1.37619033e-01f, 9.49354023e-02f,
  -2.92998224e-01f, -1.91700384e-01f, -5.98361790e-02f, -1.46051675e-01f, 1.84935242e-01f, 2.48250321e-01f, 2.40616292e-01f, 6.44246265e-02f, 2.40002036e-01f, -4.64808755e-02f,
  1.10493422e-01f, -7.44221127e-03f, 1.62072867e-01f, -6.92767277e-03f, -2.60479003e-01f, 9.34961364e-02f, -1.01658002e-01f, -5.22229783e-02f, -2.71038651e-01f, -3.26666944e-02f,
  -2.34368190e-01f, -5.55716395e-01f, -4.34441864e-01f, -2.89867133e-01f, -1.79519489e-01f, -5.03583431e-01f, -1.63521156e-01f, -9.54613388e-02f, -4.39721882e-01f, -4.64446604e-01f,
  5.61210752e-01f, 5.21746241e-02f, 8.86825025e-02f, 1.63266435e-01f, -2.66223431e-01f, -6.14192128e-01f, -1.16355300e+00f, -4.68327731e-01f, 2.03572780e-01f, -6.80259466e-02f,
  -1.07647665e-01f, 2.16693208e-02f, 1.27715245e-01f, 2.48643011e-02f, -4.31878835e-01f, -2.36505911e-01f, 8.39590728e-02f, 2.05018409e-02f, -3.36286128e-01f, -3.17972243e-01f,
  -5.12294006e-04f, 2.02326000e-01f, 2.22722128e-01f, 6.13585580e-03f, 4.83003795e-01f, 2.73119479e-01f, 3.38590354e-01f, 3.43381286e-01f, 1.16876392e-02f, 5.99774420e-01f,
  3.82321596e-01f, 3.30626786e-01f, -4.31932688e-01f, 1.02893904e-01f, 2.40781531e-01f, 1.09630018e-01f, 3.92157510e-02f, 3.82907510e-01f, -5.80178648e-02f, 5.81883127e-03f,
  1.45649821e-01f, 1.29108608e-01f, -7.79895950e-03f, 4.44099046e-02f, -8.05280954e-02f, -2.35782191e-01f, 1.84095114e-01f, -7.34225437e-02f, 3.76536846e-02f, -4.48534489e-02f,
  -2.12757245e-01f, -9.20502990e-02f, -2.62537301e-01f, -3.54308039e-01f, -8.73338953e-02f, 7.96277076e-02f, -1.57491148e-01f, 7.26909935e-02f, -5.11015281e-02f, 4.56270546e-01f,
  -1.49818733e-01f, -1.62128862e-02f, 2.52532989e-01f, 1.09718442e-01f, -1.08485455e-02f, -1.06940456e-02f, 1.31963000e-01f, -3.46153602e-02f, -6.02374822e-02f, 3.92511906e-03f,
  -2.61520207e-01f, -3.66810970e-02f, 1.26368731e-01f, -1.06153816e-01f, 3.29807424e-03f, 1.50286049e-01f, -9.61197168e-02f, 2.67517939e-02f, -1.30353048e-01f, 8.44246447e-02f,
  -3.04770973e-02f, 3.54080498e-02f, 3.16809177e-01f, 7.86158163e-03f, -4.85391691e-02f, 1.61875844e-01f, 2.18072012e-01f, 4.56138588e-02f, 1.10980727e-01f, 1.60610989e-01f,
  1.01268530e-01f, -5.30244768e-01f, 2.16908038e-01f, 6.47125393e-02f, 1.80838779e-02f, 4.26548086e-02f, 8.73738006e-02f, -9.07725468e-02f, 4.96337116e-02f, -1.35742396e-01f,
  -1.50603786e-01f, -1.85475394e-01f, 9.21325907e-02f, -2.44845107e-01f, -2.96610236e-01f, -1.53639326e-02f, -6.87828884e-02f, -1.41152412e-01f, -3.47596705e-01f, 7.19467551e-02f,
  -7.12564066e-02f, -7.35570967e-01f, -7.61599958e-01f, -5.66101134e-01f, 1.57720130e-02f, -4.03183192e-01f, -1.32413015e-01f, -2.96157748e-01f, -4.60885704e-01f, -4.02426124e-01f,
  -6.23650312e-01f, 9.10497129e-01f, -3.63771766e-01f, -3.77789706e-01f, 2.00689603e-02f, 2.96916008e-01f, 9.14995074e-01f, 2.98388332e-01f, -2.90149480e-01f, 5.24535596e-01f,
  1.49822444e-01f, -5.78658402e-01f, -4.63060617e-01f, -1.65872335e-01f, 2.06993267e-01f, 8.22923481e-01f, 6.28038287e-01f, -3.18324387e-01f, -6.48220003e-01f, -1.99215800e-01f,
  3.02800745e-01f, -2.02907547e-01f, -4.46415573e-01f, -2.92946339e-01f, -1.91473201e-01f, -3.53781492e-01f, 1.39111087e-01f, -1.62205666e-01f, 2.43502870e-01f, 8.05355236e-02f,
  -3.75051677e-01f, -1.95315734e-01f, -1.87501848e-01f, -2.02521279e-01f, -2.12229401e-01f, -7.94549659e-02f, -6.64186925e-02f, -5.00986218e-01f, -9.52794254e-02f, -4.48485240e-02f,
  -2.47472197e-01f, -1.72930270e-01f, -4.25740004e-01f, 1.74741801e-02f, -1.67668596e-01f, -1.93343535e-01f, -4.11512926e-02f, -1.88522279e-01f, -3.27734679e-01f, -1.34502560e-01f,
  3.83854747e-01f, -7.66939223e-02f, -3.88195962e-01f, 2.60760218e-01f, -3.42562459e-02f, -2.97908217e-01f, -8.23939666e-02f, -3.30822527e-01f, -2.85451591e-01f, 2.24560238e-02f,
  1.47854522e-01f, 3.24563421e-02f, 1.18544959e-01f, 1.34080231e-01f, 9.24792811e-02f, 5.41286916e-02f, 8.58061574e-03f, 3.87605391e-02f, -8.07168409e-02f, -7.19066113e-02f,
  -8.77687037e-02f, -1.16771713e-01f, -1.66966811e-01f, -8.03029016e-02f, -5.99298179e-02f, -5.33091836e-03f, 2.95567829e-02f, 3.87551151e-02f, 1.73124537e-01f, -1.60164237e-02f,
  -1.32150948e-01f, -1.02038585e-01f, -6.80697039e-02f, -9.11224633e-02f, 2.96283334e-01f, 2.48952936e-02f, -4.80642682e-03f, -9.18442681e-02f, -5.34744188e-02f, 1.16324052e-01f,
  7.29819462e-02f, 4.86607850e-01f, -1.40601054e-01f, 1.21754706e-01f, 1.63331881e-01f, -3.77267152e-02f, 4.74693887e-02f, 7.94339105e-02f, -8.07512328e-02f, -2.09519386e-01f,
  -1.38893008e-01f, -6.34309351e-02f, -7.07409391e-03f, -8.17708597e-02f, -2.75566965e-01f, 3.57510857e-02f, 5.07066607e-01f, -1.13622602e-02f, -1.24785788e-02f, -1.11518122e-01f,
  4.29239571e-01f, 2.65112519e-01f, -7.33792260e-02f, 1.73161358e-01f, 1.01187915e-01f, -1.95839271e-01f, -1.40599892e-01f, -1.59032539e-01f, 9.98412073e-02f, 7.39151895e-01f,
  -7.64062822e-01f, -7.76837707e-01f, 4.12164301e-01f, -8.30800474e-01f, -4.33911324e-01f, 7.11639225e-03f, -6.70085192e-01f, -2.78727293e-01f, -2.00873747e-01f, -5.53004563e-01f,
  -1.24482503e-02f, 8.95205215e-02f, 9.44526028e-03f, 2.57760525e-01f, 2.19047368e-01f, -3.58265132e-01f, -1.19695552e-01f, 3.36851537e-01f, 3.80714566e-01f, -1.45395905e-01f,
  -3.16461354e-01f, -4.06252444e-01f, 4.93411906e-02f, 2.35363827e-04f, -6.45081878e-01f, -9.70595330e-02f, -1.81558207e-01f, -4.68792081e-01f, -1.13170907e-01f, -6.83595598e-01f,
  -4.91338730e-01f, -2.03303024e-01f, 4.34680015e-01f, 2.81432122e-01f, -2.23673452e-02f, 6.50487766e-02f, -5.52146472e-02f, 7.92610273e-02f, 1.12638697e-01f, 7.01893568e-02f,
  6.91941157e-02f, 1.78148836e-01f, -1.66444048e-01f, 1.21782552e-02f, -2.21350536e-01f, 1.61428362e-01f, 1.94330245e-01f, 2.09470958e-01f, -5.03180176e-03f, 2.89880224e-02f,
  -7.47305453e-02f, -2.47169957e-02f, 1.53598756e-01f, 1.29226476e-01f, -4.82139038e-03f, 3.59289229e-01f, 1.02771185e-01f, 6.90149516e-02f, 3.81464601e-01f, -7.63458967e-01f,
  -3.95388575e-03f, 3.46008576e-02f, 7.80443773e-02f, 5.54521047e-02f, -8.51526484e-03f, 3.16713452e-02f, -5.43577783e-02f, -1.05361730e-01f, 1.53184354e-01f, -7.24572912e-02f,
  1.22003667e-01f, 1.06539056e-01f, -5.62721938e-02f, -2.73916692e-01f, 8.52917060e-02f, 1.48573155e-02f, -8.17784294e-02f, -9.63274166e-02f, 9.76750106e-02f, -4.11967970e-02f,
  7.25472346e-02f, 2.52287928e-02f, -9.74721238e-02f, -7.85584673e-02f, 1.13952823e-01f, 2.93802060e-02f, -2.55497210e-02f, 8.18734989e-02f, -1.09238178e-01f, 1.12563014e-01f,
  -3.53894055e-01f, 5.43955207e-01f, -5.46109915e-01f, 8.70367438e-02f, -1.48951963e-01f, 2.51129389e-01f, -9.07723531e-02f, 1.06461912e-01f, -3.21818963e-02f, -2.08086252e-01f,
  5.61386198e-02f, -1.85646638e-01f, -7.98468143e-02f, 1.22620642e-01f, -4.58729565e-02f, 1.48735881e-01f, -3.57271172e-02f, -1.29728019e-01f, 1.64205208e-01f, -7.27730570e-03f,
  -5.27191907e-02f, -6.64506331e-02f, -2.13453233e-01f, -1.16265535e-01f, -3.08363765e-01f, 1.68194041e-01f, -7.60606006e-02f, -1.70400649e-01f, 1.43422391e-02f, -6.92057014e-01f,
  -9.76876915e-01f, 3.75184625e-01f, 4.05424237e-01f, -3.71752828e-01f, -1.41822755e-01f, 1.85160674e-02f, 1.69727683e-01f, -1.43782198e-01f, -2.32143760e-01f, 4.10253316e-01f,
  1.95602193e-01f, -4.70082939e-01f, -1.88148648e-01f, -2.82024920e-01f, -1.89597070e-01f, 3.74581218e-01f, 1.78877369e-01f, -4.64873046e-01f, -9.92371857e-01f, -7.11866260e-01f,
  -5.57878256e-01f, -5.35231590e-01f, -6.36497259e-01f, -4.34971243e-01f, -7.68551007e-02f, -3.35074693e-01f, 2.55115241e-01f, -4.64195497e-02f, -7.06053227e-02f, 1.30899800e-02f,
  2.97430277e-01f, -1.24065496e-01f, -3.70855838e-01f, -2.59310842e-01f, 7.64207393e-02f, 1.34090096e-01f, -4.50168997e-02f, 8.09509754e-02f, 9.82622281e-02f, 1.29467651e-01f,
  5.10938093e-02f, 4.53721695e-02f, 3.88431735e-02f, 1.33144334e-01f, -7.69149512e-02f, 2.08029002e-02f, 1.25827104e-01f, -1.44968003e-01f, 2.73920130e-02f, 2.07769349e-01f,
  2.47605324e-01f, 4.50390801e-02f, 1.67074278e-01f, 1.21615998e-01f, 4.77398708e-02f, -4.01544087e-02f, 4.50647064e-02f, -6.38510138e-02f, 7.33229965e-02f, 6.28501326e-02f,
  1.82716027e-01f, 1.33675247e-01f, -3.54229957e-02f, -4.63790968e-02f, 5.49159721e-02f, 6.48539886e-02f, 6.40400350e-02f, 1.46220371e-01f, 4.48312052e-02f, 1.74235459e-02f,
  5.88871799e-02f, 1.79329529e-01f, 1.76236749e-01f, 1.41285419e-01f, -5.50096929e-02f, -2.99585164e-02f, 4.14234400e-02f, 1.33881494e-01f, 1.05157010e-01f, 3.22294049e-02f,
  -1.25378385e-01f, 1.28298178e-01f, 2.62667239e-02f, -4.97902045e-03f, 1.67809576e-01f, 3.42610222e-03f, 2.02146128e-01f, 4.56083193e-02f, 3.01668197e-02f, -1.35419285e-02f,
  -1.98617995e-01f, -1.47187546e-01f, 2.72145960e-02f, -2.92916536e-01f, 1.13580994e-01f, 1.08109668e-01f, 1.02045491e-01f, -5.36926165e-02f, 4.30506095e-02f, -8.06763843e-02f,
  3.22383456e-02f, 9.95154306e-02f, 1.90124005e-01f, 5.04220165e-02f, -1.21846952e-01f, -1.11292772e-01f, 1.14626437e-01f, -1.17936246e-01f, 2.27067452e-02f, 2.13234097e-01f,
  3.63108635e-01f, 9.26739653e-04f, -1.16976984e-01f, 1.26868606e-01f, 2.80356444e-02f, -1.12031646e-01f, 7.93973356e-02f, 1.46947326e-02f, 4.82002720e-02f, 6.92462996e-02f,
  -9.61012542e-01f, 4.20919925e-01f, 1.72763631e-01f, -3.82944286e-01f, 7.21505523e-01f, 5.32609165e-01f, 3.34612668e-01f, 8.57781246e-03f, -2.47622048e-03f, -1.09568909e-01f,
  4.83177692e-01f, 8.93174037e-02f, -9.19779241e-02f, -2.80161947e-01f, -8.00022662e-01f, -3.46462309e-01f, -3.22976977e-01f, -6.47146523e-01f, -3.96951258e-01f, 1.02697939e-01f,
  2.88548976e-01f, -1.21135734e-01f, -6.25364542e-01f, -4.09107685e-01f, 1.55665308e-01f, -1.62870035e-01f, 3.68889943e-02f, 7.03597255e-03f, 4.99706417e-02f, -2.24874526e-01f,
  -4.11230594e-01f, 3.01746368e-01f, 2.50803709e-01f, 1.28413185e-01f, 1.87674016e-01f, -3.60816836e-01f, -1.34634256e-01f, -1.08156249e-01f, 1.27164759e-02f, -1.46966383e-01f,
  4.31084514e-01f, -3.02423220e-02f, 2.22443506e-01f, 5.00219166e-02f, -1.40028328e-01f, -2.50799417e-01f, -2.44840905e-01f, -2.81097233e-01f, -5.11562407e-01f, 1.42804282e-02f,
  5.62250853e-01f, 5.06572008e-01f, -1.13269575e-01f, 5.00332564e-02f, -3.22163165e-01f, -3.04639757e-01f, -8.17949027e-02f, -3.00253391e-01f, -5.23371279e-01f, -7.93266714e-01f,
  -5.75005375e-02f, 6.22931831e-02f, 1.37023538e-01f, -1.51634365e-01f, -1.45337015e-01f, 1.01295732e-01f, 5.89999817e-02f, -5.68448491e-02f, -8.68515894e-02f, -2.17914566e-01f,
  1.29221261e-01f, 3.38197537e-02f, 9.57380459e-02f, 5.79835922e-02f, -3.06831777e-01f, 2.21335024e-01f, 7.12186396e-02f, -2.30977610e-01f, -2.50758566e-02f, -5.96075952e-02f,
  2.53657382e-02f, 6.66956753e-02f, 2.04390556e-01f, -1.21455416e-01f, -1.08090797e-02f, -6.88340217e-02f, -3.02417744e-02f, 1.64202854e-01f, -1.04952902e-02f, -8.12422708e-02f,
  -3.85227829e-01f, 1.63337335e-01f, -3.17657351e-01f, 1.12255953e-01f, 1.87813640e-02f, -8.91963206e-03f, 4.43732813e-02f, 2.09685732e-02f, 3.93616296e-02f, -1.60873771e-01f,
  1.20987073e-01f, -6.13225363e-02f, 6.50139153e-02f, 8.50787237e-02f, -1.47867352e-01f, -8.31174627e-02f, -3.14096600e-01f, -3.82790715e-03f, -9.59606282e-03f, 7.07900748e-02f,
  -1.70162290e-01f, -4.16397601e-01f, -7.96268344e-01f, -3.81400436e-01f, -2.50451952e-01f, -5.43780208e-01f, -6.70286119e-01f, -5.92779040e-01f, -7.75961637e-01f, -1.24553239e+00f,
  1.12815356e+00f, 7.85454333e-01f, -2.15360060e-01f, 1.19923633e-02f, -1.69170365e-01f, 7.73003995e-02f, 5.14979899e-01f, 4.03576165e-01f, 1.74868613e-01f, 1.48596913e-01f,
  1.37713566e-01f, 4.35811281e-02f, 7.74913356e-02f, -5.85789373e-03f, 2.02651560e-01f, 1.77751370e-02f, -3.90602998e-03f, -9.42836776e-02f, 4.98813167e-02f, 1.73328854e-02f,
  7.29114041e-02f, 1.22129165e-01f, 3.69252324e-01f, 1.07550830e-01f, -7.69488141e-02f, -1.97796732e-01f, -4.32224609e-02f, -8.94289091e-02f, -1.89495996e-01f, -1.24408498e-01f,
  -6.52191103e-01f, 7.04720914e-02f, -1.20495327e-01f, 5.20849414e-02f, -1.13332778e-01f, 2.66392857e-01f, 1.73938256e-02f, 1.35127315e-02f, 1.41273901e-01f, 3.95493731e-02f,
  -1.00163028e-01f, -1.32561073e-01f, -9.57616642e-02f, 1.82601367e-03f, -1.22789592e-02f, -5.43310866e-02f, 8.65477473e-02f, 3.05997971e-02f, -1.45086125e-01f, -1.09404594e-01f,
  -5.03892489e-02f, -2.58471191e-01f, -5.78544065e-02f, -8.20074137e-03f, -5.87766990e-02f, -1.90514252e-01f, -1.13184743e-01f, 1.60614755e-02f, -1.24728702e-01f, 5.24531156e-02f,
  -1.55903369e-01f, 8.26587230e-02f, -1.44411251e-01f, -2.11995736e-01f, -5.94828799e-02f, 2.30469722e-02f, -9.50501114e-02f, 1.84992049e-02f, 3.43716238e-03f, 4.77008112e-02f,
  -1.16230873e-02f, -2.86391854e-01f, -1.66537493e-01f, -5.11446148e-02f, -2.05311507e-01f, -6.29897043e-02f, -3.29483375e-02f, -4.53699566e-02f, -1.85855523e-01f, -1.21459380e-01f,
  -1.14314966e-01f, -2.41480190e-02f, 3.02757360e-02f, -1.38150036e-01f, -1.69920221e-01f, -1.95639685e-01f, -1.46088928e-01f, 1.61905549e-02f, 1.16955459e-01f, 1.89178884e-01f,
  -1.36708796e-01f, -4.64924395e-01f, -4.61619981e-02f, 2.21548945e-01f, -8.01949054e-02f, 2.02059999e-01f, -1.22585565e-01f, -2.37808764e-01f, -1.19385682e-01f, -1.16032198e-01f,
  5.11506498e-02f, 1.10639453e-01f, 1.45096825e-02f, 2.04078391e-01f, -4.20935899e-02f, -1.31568179e-01f, 6.69484138e-02f, 9.25705433e-02f, -5.52946404e-02f, -5.93401454e-02f,
  1.44259840e-01f, 3.59413475e-02f, 5.76695241e-02f, -3.45071517e-02f, -1.25909093e-04f, -1.26370758e-01f, 2.52424311e-02f, -4.72535044e-02f, 3.02481074e-02f, 1.75708845e-01f,
  -4.19417359e-02f, -1.29819319e-01f, -2.49026015e-01f, 4.18274581e-01f, 5.31625330e-01f, 1.42383918e-01f, -5.42709902e-02f, -1.39787212e-01f, 1.69271380e-01f, 2.66714543e-01f,
  3.42951059e-01f, 4.72345531e-01f, 3.69531095e-01f, 2.70009428e-01f, -1.29636705e-01f, -4.79343459e-02f, 1.13718033e-01f, -3.08911875e-02f, 8.02567378e-02f, 2.20337853e-01f,
  4.40395594e-01f, 2.09627569e-01f, 6.94124028e-02f, -3.10744457e-02f, 3.90423238e-01f, 4.54578131e-01f, 7.82961026e-02f, 2.78602153e-01f, 2.63908684e-01f, 2.94690013e-01f,
  1.36199594e-02f, -2.58740276e-01f, 4.53799069e-02f, 8.29540193e-02f, 3.68547742e-03f, -2.46085048e-01f, -7.26797357e-02f, -2.19601497e-01f, -4.20225859e-02f, -9.37757865e-02f,
  -5.34298364e-03f, -1.35264054e-01f, 6.99299052e-02f, -9.52772722e-02f, -1.38295114e-01f, -9.90693122e-02f, -2.72440106e-01f, -2.48170435e-01f, -1.73024669e-01f, -1.92797378e-01f,
  2.11291835e-01f, 1.37911111e-01f, -2.43751630e-01f, -2.25012749e-01f, -1.51767373e-01f, 1.43263370e-01f, -3.20859030e-02f, -2.00023875e-02f, -2.04750448e-01f, -1.87951133e-01f,
  2.93842882e-01f, -1.55593589e-01f, -1.35295600e-01f, -1.40517145e-01f, 3.88610587e-02f, 7.23926350e-02f, -1.61946103e-01f, -6.70472905e-03f, -1.82947004e-03f, -1.05694868e-01f,
  -1.14357725e-01f, -9.91178900e-02f, -2.11522385e-01f, -1.29641071e-01f, 2.20041409e-01f, -9.83156040e-02f, -4.92218882e-02f, -1.36308327e-01f, 2.43923180e-02f, -1.36053711e-02f,
  7.23857656e-02f, 2.25862134e-02f, 1.39542416e-01f, -1.56926215e-01f, 5.59388734e-02f, 8.69807135e-03f, 1.20264068e-01f, -4.67270687e-02f, 9.98311043e-02f, 1.27941817e-01f,
  -1.32473812e-01f, 3.73898749e-03f, 1.64924994e-01f, -1.67778313e-01f, -1.19005866e-01f, -8.98408815e-02f, 5.82405142e-02f, -2.59444881e-02f, 5.01758680e-02f, 3.08072958e-02f,
  4.13268618e-03f, -1.07986331e-01f, -1.49698749e-01f, -9.27546769e-02f, -4.70529050e-02f, -5.08271866e-02f, 9.37124118e-02f, 7.59601295e-02f, -1.91816941e-01f, -1.86599568e-01f,
  -1.49943680e-01f, -1.49382517e-01f, -1.86920837e-01f, -1.06952712e-01f, 5.40389605e-02f, 8.13066065e-02f, -1.86676830e-01f, -1.33242846e-01f, -2.60176301e-01f, -2.27513358e-01f,
  -1.14476418e+00f, 7.89686441e-02f, -4.31460030e-02f, -2.59333432e-01f, 3.05024415e-01f, 3.71101648e-01f, 4.72341210e-01f, 1.16532952e-01f, -2.05641940e-01f, 6.25121593e-02f,
  6.60784468e-02f, -4.88543771e-02f, 2.62929332e-02f, -3.78425419e-02f, 5.66112362e-02f, 3.22733760e-01f, 2.86444545e-01f, 2.17759274e-02f, -3.87362689e-02f, 2.09693894e-01f,
  2.88152814e-01f, -6.95738848e-03f, -3.22016895e-01f, -1.10034250e-01f, 9.07576010e-02f, 1.67064533e-01f, 5.92274070e-02f, 2.28900731e-01f, 1.90712467e-01f, 1.45841479e-01f,
  4.42517966e-01f, -3.65791947e-01f, -5.78038096e-02f, -2.57644951e-01f, -1.00263648e-01f, -2.50383943e-01f, -3.47809941e-02f, -1.91915527e-01f, -4.26031724e-02f, 1.37299642e-01f,
  1.11892179e-03f, -1.41962931e-01f, -6.59390837e-02f, 1.36363462e-01f, 5.70283718e-02f, -8.32379237e-02f, -1.78868189e-01f, 4.67447704e-03f, 1.20837115e-01f, 2.20595784e-02f,
  9.87568498e-02f, 1.16429441e-01f, 2.73363322e-01f, 1.94824904e-01f, -9.14462004e-03f, -9.95465890e-02f, 4.47516963e-02f, -1.02882601e-01f, 3.79694588e-02f, 1.98331997e-02f,
  1.43602148e-01f, 6.07435443e-02f, -1.21172324e-01f, -7.30596483e-02f, -9.80103239e-02f, -9.66877863e-02f, 1.28146291e-01f, 1.66940302e-01f, 1.13741197e-01f, 7.13463202e-02f,
  1.02922253e-01f, 4.65942994e-02f, 7.26866536e-03f, -3.63800079e-02f, -6.14586435e-02f, 8.99501070e-02f, 3.14148888e-02f, -3.11458241e-02f, -6.11344874e-02f, -5.44156991e-02f,
  -5.02742231e-02f, 1.20043196e-01f, -1.13343067e-01f, 9.94683281e-02f, 3.09003275e-02f, -2.66793743e-02f, 3.54422890e-02f, 5.40063493e-02f, -3.74864824e-02f, 5.02903089e-02f,
  4.62491184e-01f, -2.73963124e-01f, -2.69865412e-02f, -5.74698560e-02f, 4.93500568e-03f, -1.32490128e-01f, -1.78300261e-01f, -6.46278784e-02f, 4.02127355e-02f, 6.25520870e-02f,
  -4.94864187e-04f, -9.80003700e-02f, -2.57551055e-02f, 4.62330095e-02f, 2.92498954e-02f, 7.09893033e-02f, -1.68408304e-01f, 6.68357760e-02f, 1.02720916e-01f, 1.15626864e-01f,
  -4.12652502e-03f, 8.26826617e-02f, 1.61781341e-01f, 1.23272538e-01f, 8.30734894e-02f, 6.49927184e-02f, 1.33509338e-01f, 9.14791971e-02f, 1.26903981e-01f, 1.62915438e-01f,
  -5.19174933e-01f, 1.12127014e-01f, 4.63562876e-01f, -3.99057120e-01f, -2.90742725e-01f, -4.44166698e-02f, 6.71594739e-02f, -2.26232961e-01f, -5.23909807e-01f, -1.41049698e-01f,
  -3.67539316e-01f, -4.07458216e-01f, -1.89790979e-01f, 2.16919392e-01f, 4.34755147e-01f, 5.09014070e-01f, 7.09555030e-01f, 6.82089925e-01f, 2.89104640e-01f, 5.39109893e-02f,
  8.10974240e-02f, 5.62513387e-03f, 2.26876512e-01f, 3.18827957e-01f, -3.75358909e-02f, -1.48778513e-01f, 2.61830874e-02f, 6.12050295e-02f, 3.12000334e-01f, 5.28422236e-01f,
  -1.33859247e-01f, -2.75432914e-01f, -6.77762553e-02f, -1.81951463e-01f, 9.24711823e-02f, 9.96907875e-02f, 7.32702836e-02f, 4.97456379e-02f, 5.76752238e-02f, 2.38783300e-01f,
  3.66843157e-02f, 5.04264534e-02f, -1.55187756e-01f, 5.24310470e-02f, -1.45523891e-01f, -1.94522232e-01f, 1.47931665e-01f, 3.47073823e-01f, 1.03739724e-01f, 5.89115731e-02f,
  1.58023164e-01f, -1.52125150e-01f, -3.17989379e-01f, -1.13176577e-01f, -4.06662049e-03f, -1.98652685e-01f, -1.25802591e-01f, -9.72047299e-02f, -1.75067812e-01f, -1.28147975e-01f,
  -1.85073346e-01f, 1.12354197e-01f, -1.02208620e-02f, 1.77856371e-01f, -3.02449148e-02f, 3.85956280e-02f, 2.33536720e-01f, 9.20537114e-02f, 8.14536884e-02f, -1.29252806e-01f,
  -8.22042897e-02f, -6.97448384e-04f, 1.51135936e-01f, -3.60269994e-02f, -1.83052659e-01f, -1.22925229e-01f, -1.48820579e-02f, 5.19103557e-02f, 2.17762683e-02f, 3.07147950e-02f,
  -2.02393025e-01f, 7.75991976e-02f, 4.15580682e-02f, 3.45608562e-01f, -2.41507478e-02f, 1.43116444e-01f, -1.57768980e-01f, -9.02336389e-02f, -2.91133016e-01f, -6.89153895e-02f,
  -8.60575378e-01f, 3.11397940e-01f, -1.86413765e-01f, 1.16239220e-01f, -1.08739667e-01f, -6.32916316e-02f, 1.77093875e-02f, -2.22204626e-02f, -1.28298298e-01f, 1.08214431e-01f,
  -1.02828508e-02f, 7.49684125e-02f, -1.60579473e-01f, 2.31598645e-01f, -1.67769954e-01f, -2.28571117e-01f, -2.92255706e-03f, 3.06185484e-02f, 2.86710206e-02f, -1.19848579e-01f,
  8.11798871e-02f, -2.76613891e-01f, -5.45232236e-01f, -3.38960618e-01f, -4.92584556e-01f, -7.22620547e-01f, -2.33316109e-01f, -2.51561165e-01f, -3.92375827e-01f, -5.23112476e-01f,
  1.10648525e+00f, 1.32202804e-01f, -1.45146835e+00f, 4.71046597e-01f, -2.26876110e-01f, -5.79737961e-01f, -1.58721760e-01f, 2.17286289e-01f, 3.52315843e-01f, 7.67587312e-03f,
  5.55975772e-02f, -2.74457447e-02f, -3.78377199e-01f, -3.71026069e-01f, -2.91295350e-01f, -5.87554991e-01f, -7.33142972e-01f, -7.54291058e-01f, -2.05495179e-01f, 3.18359107e-01f,
  4.22346830e-01f, 6.51500046e-01f, 4.00779903e-01f, 1.63861156e-01f, 5.28981686e-02f, -1.29033208e-01f, -5.39868712e-01f, -2.47272253e-01f, -3.60118628e-01f, -5.53450584e-01f,
  -6.90428019e-01f, -4.00122017e-01f, -2.66277462e-01f, 1.11769468e-01f, -1.44652016e-02f, 8.35195929e-02f, 1.21605150e-01f, 3.73795368e-02f, 2.47062728e-01f, 7.85106346e-02f,
  6.76306412e-02f, 1.68921128e-01f, 9.64893848e-02f, -3.76899987e-02f, 2.36238182e-01f, 5.14244512e-02f, -1.12064704e-01f, -1.61448017e-01f, -7.54818842e-02f, -1.24420211e-01f,
  3.41358222e-02f, -1.55778617e-01f, -4.63146597e-01f, -2.67290175e-01f, -2.39493385e-01f, -3.99647921e-01f, -1.77242979e-01f, -3.38620991e-01f, -4.90223259e-01f, -9.21212062e-02f,
  -5.34813181e-02f, -2.35943161e-02f, 9.75176841e-02f, 3.26898396e-02f, 2.94358164e-01f, 4.09680046e-02f, 2.09372099e-02f, -1.04874105e-03f, 8.41409490e-02f, 1.93336546e-01f,
  -1.04920246e-01f, -2.10939385e-02f, 4.07033600e-02f, 6.10872684e-03f, -5.64520471e-02f, -3.38159278e-02f, -2.27479935e-01f, 1.28411740e-01f, -5.70451021e-02f, 1.00897133e-01f,
  7.78455660e-02f, -5.08775041e-02f, 1.36922538e-01f, 4.85603325e-02f, -1.14695169e-01f, -1.32553279e-01f, -4.98427786e-02f, 2.53119081e-01f, 1.24375463e-01f, -1.10722542e-01f,
  6.06945813e-01f, -5.47814310e-01f, 2.92534358e-04f, 5.31293713e-02f, -2.56149378e-02f, 5.53467572e-02f, 7.69710913e-02f, 1.64920211e-01f, 8.21878985e-02f, 8.38053301e-02f,
  4.72108684e-02f, 2.40884036e-01f, -5.25144599e-02f, 1.33086205e-01f, 1.53091222e-01f, -8.30432251e-02f, 2.93264866e-01f, -1.16594180e-01f, 5.29822744e-02f, 7.59200230e-02f,
  2.41057858e-01f, 1.28242210e-01f, 3.20290998e-02f, -4.64020222e-02f, 1.93533283e-02f, -9.77804326e-03f, -3.26115862e-02f, -9.83387977e-02f, -3.39473218e-01f, 4.91279811e-01f,
  9.07800078e-01f, 7.57240653e-01f, 3.22734654e-01f, 2.43438214e-01f, -1.93792749e-02f, 9.69468653e-02f, 3.60775977e-01f, 3.67526650e-01f, 2.34270453e-01f, 2.14416862e-01f,
  1.96120158e-01f, 1.29933879e-01f, 2.71304458e-01f, 2.74417341e-01f, 2.26852000e-01f, 2.50389755e-01f, 1.91973433e-01f, 1.38895050e-01f, 5.69684319e-02f, 5.76039664e-02f,
  -3.74547802e-02f, -7.63924979e-03f, 1.35062724e-01f, 1.03943102e-01f, 1.37582317e-01f, -5.27771860e-02f, 1.23501629e-01f, -4.40116264e-02f, 1.04140632e-01f, 1.91776067e-01f,
  -1.20177105e-01f, 2.47430980e-01f, 3.89762372e-02f, 5.29870242e-02f, 1.50004579e-02f, 6.60394654e-02f, -5.61900735e-02f, 1.80136077e-02f, -1.41164228e-01f, -1.38170809e-01f,
  -9.76927131e-02f, -1.17156565e-01f, -9.61231068e-02f, -7.67083466e-02f, -2.41345510e-01f, -2.12738305e-01f, 1.18966483e-01f, 1.47721082e-01f, 1.62594684e-03f, 9.12998095e-02f,
  6.08131774e-02f, -1.73199773e-01f, -9.54865888e-02f, -7.85909668e-02f, 1.19613074e-01f, -5.78418151e-02f, 8.97413585e-03f, 4.25902158e-02f, -9.81652737e-02f, 6.89885300e-03f,
  1.69216722e-01f, 2.72320211e-01f, 9.31406617e-02f, 5.51530868e-02f, -6.91107586e-02f, -1.58491477e-01f, -2.00957194e-01f, -6.48901090e-02f, 1.82847530e-02f, -1.12922415e-02f,
  -2.57592708e-01f, -1.07744858e-01f, 1.23351058e-02f, -2.72405058e-01f, -2.99240872e-02f, 8.81963894e-02f, 2.21531689e-02f, 2.93173753e-02f, -1.28867865e-01f, 7.23040104e-02f,
  1.69272963e-02f, -2.53951345e-02f, -1.03463568e-01f, -8.05575624e-02f, -9.50792059e-02f, -1.51325986e-01f, -1.39732689e-01f, -4.65641581e-02f, 1.52179669e-03f, 4.50415947e-02f,
  1.44643113e-02f, -1.77073345e-01f, 4.97572161e-02f, 3.49869370e-01f, 1.84505936e-02f, 9.46189165e-02f, 1.76097438e-01f, -1.05842762e-01f, -1.46158412e-01f, -8.94264579e-02f,
  -8.90084729e-02f, 1.26040168e-02f, 3.18502933e-02f, -5.22944070e-02f, -2.61738658e-01f, -2.25983143e-01f, 5.85392341e-02f, 1.38670161e-01f, -6.81890594e-03f, -5.19167520e-02f,
  1.24504298e-01f, -7.41815120e-02f, -9.34527144e-02f, -8.65565836e-02f, 1.42381061e-02f, -1.19717643e-01f, -2.98864573e-01f, -6.64515048e-02f, -7.42770284e-02f, -1.42440140e-01f,
  4.71647620e-01f, 3.36943477e-01f, 2.29755417e-01f, 2.84153610e-01f, 4.46815073e-01f, 4.58594710e-01f, 6.08829319e-01f, 3.41776222e-01f, 1.57097757e-01f, 2.34311268e-01f,
  2.50851631e-01f, 1.22093931e-01f, 1.93926975e-01f, 5.36247976e-02f, 1.59884140e-01f, -7.26470258e-03f, -2.12382562e-02f, -5.58504723e-02f, 3.04672979e-02f, -2.64593447e-03f,
  9.25140232e-02f, 6.70015663e-02f, -2.80347629e-03f, -2.11877562e-02f, -7.58793876e-02f, 5.09150811e-02f, 1.05947770e-01f, 1.69056207e-01f, 9.90773272e-03f, -4.08949435e-01f,
  -3.74258041e-01f, 1.83297560e-01f, -1.82327181e-01f, -1.12175241e-01f, -4.70033102e-02f, -1.39805809e-01f, 1.29035220e-03f, -1.13990523e-01f, -5.31821921e-02f, -1.79186568e-01f,
  -2.93068923e-02f, -1.36004895e-01f, 6.36954531e-02f, -4.24039401e-02f, -4.49238829e-02f, 1.99306477e-02f, -7.59453252e-02f, 1.16357382e-03f, -5.28975539e-02f, -7.76473805e-02f,
  1.01484116e-02f, -6.92657903e-02f, -2.69109998e-02f, 1.03045210e-01f, 6.89161047e-02f, 1.62570812e-02f, -6.49643838e-02f, -6.79744035e-02f, 9.34962258e-02f, -9.01923552e-02f,
  -1.57945395e-01f, 1.94354914e-02f, 3.96210812e-02f, -1.06533222e-01f, 3.61395180e-02f, -1.00665674e-01f, -1.96325988e-01f, -9.56745876e-04f, 1.39519088e-02f, 1.44991511e-02f,
  -1.49783745e-01f, -1.03695653e-01f, -1.60778567e-01f, 7.96075258e-03f, 7.14391246e-02f, 5.64906187e-02f, -4.38772328e-02f, 4.41324785e-02f, 8.13419148e-02f, 1.25375703e-01f,
  1.58360060e-02f, -8.00871924e-02f, -1.12001449e-01f, -1.07429817e-01f, -1.55685052e-01f, 4.96725626e-02f, 2.86546983e-02f, -6.71700537e-02f, -2.11274661e-02f, 6.50760084e-02f,
  -3.26368898e-01f, 3.77963543e-01f, -2.08379626e-01f, -9.43346620e-02f, -1.19419165e-01f, -4.68877479e-02f, 2.14068685e-02f, 3.56486440e-02f, 7.76673704e-02f, -1.71296522e-01f,
  -6.69685900e-02f, -5.01623787e-02f, -4.91064712e-02f, 2.20447518e-02f, -1.72622472e-01f, -1.89704280e-02f, -1.02752000e-02f, -9.83952135e-02f, -9.63576511e-02f, -2.47883633e-01f,
  -9.08319131e-02f, -1.79853946e-01f, -1.43264666e-01f, 5.34631312e-02f, -1.68082565e-01f, -1.18183799e-01f, -5.27552813e-02f, -1.44962281e-01f, 1.04474589e-01f, 3.34531851e-02f,
  -9.61807892e-02f, -4.78232920e-01f, -2.59747207e-01f, -7.14853466e-01f, -8.58015269e-02f, 3.18077177e-01f, 7.46164247e-02f, -3.01124342e-02f, -2.81231046e-01f, -2.64188975e-01f,
  1.21305637e-01f, 5.32062292e-01f, 2.75545180e-01f, 3.60516131e-01f, 2.98706591e-01f, -2.74198383e-01f, -4.20030743e-01f, 2.85229594e-01f, 8.65682781e-01f, 4.79338288e-01f,
  3.99234612e-03f, -2.80162215e-01f, -1.84267297e-01f, -2.42512986e-01f, -5.24047852e-01f, 1.31239176e-01f, -6.11100912e-01f, -4.19081688e-01f, -2.40342438e-01f, -7.64899075e-01f,
  3.95573437e-01f, -2.83387631e-01f, 1.12055629e-01f, -2.65478473e-02f, -2.30785191e-01f, 5.17782941e-03f, -6.31675571e-02f, -2.07289159e-01f, -1.77789524e-01f, -1.64815769e-01f,
  -3.19156319e-01f, 2.99369195e-03f, 3.11260088e-03f, -2.15627514e-02f, -2.41832972e-01f, -9.27076638e-02f, -2.06416160e-01f, -1.38952747e-01f, -1.14854187e-01f, -3.01190820e-02f,
  -7.20648170e-02f, -6.64088428e-02f, 1.72162578e-02f, -8.91269818e-02f, -1.44928634e-01f, 2.05164298e-01f, -6.61204383e-02f, -4.05934155e-02f, -3.30467965e-03f, -3.42764318e-01f,
  1.77364815e-02f, 1.15654077e-02f, -3.60864438e-02f, -1.22307457e-01f, 7.74988532e-02f, -7.82105420e-03f, -6.47768704e-03f, 9.77763720e-03f, 8.49753059e-03f, 9.85062215e-03f,
  -9.75002795e-02f, -1.08139940e-01f, 1.26949577e-02f, -1.72317237e-01f, -9.09748673e-02f, 3.23655121e-02f, 8.40385631e-02f, -2.84289066e-02f, 6.73336117e-03f, -2.24933866e-02f,
  2.46182401e-02f, 3.37974937e-03f, -2.44830246e-03f, 5.88938706e-02f, 1.20602436e-02f, 8.31504259e-03f, 5.30375168e-02f, 2.15468764e-01f, 5.91624230e-02f, 7.60129169e-02f,
  -1.52129099e-01f, 1.82362750e-01f, 7.24535016e-03f, 2.38624420e-02f, -1.05685428e-01f, -2.22411990e-01f, -7.76813999e-02f, -7.89169297e-02f, -1.95927873e-01f, -1.77411847e-02f,
  5.97372428e-02f, 1.18341967e-01f, -1.94580153e-01f, 2.27640998e-02f, 1.34501278e-01f, 8.16312879e-02f, -1.30219012e-01f, 6.87700510e-02f, 9.78277475e-02f, -5.25413416e-02f,
  -4.76290286e-02f, 2.32956514e-01f, 2.40241915e-01f, 1.76118195e-01f, 4.18788604e-02f, 3.64144892e-01f, 2.78305918e-01f, 2.27605179e-01f, 2.81494558e-01f, 7.89938569e-02f,
  3.52040857e-01f, -3.11163127e-01f, -4.08398249e-04f, 3.01960289e-01f, 1.88826546e-01f, 2.18301654e-01f, 2.39823863e-01f, 9.80060026e-02f, 2.18926892e-01f, 6.48270622e-02f,
  -1.24897435e-02f, 8.38739499e-02f, 1.71277031e-01f, 9.27175060e-02f, 2.05285370e-01f, 1.11631840e-01f, 1.50469720e-01f, 1.30314454e-01f, 3.76062989e-02f, -3.46634798e-02f,
  -1.23096563e-01f, -3.07106804e-02f, -1.06495604e-01f, -1.47617772e-01f, -2.72858530e-01f, 4.74808849e-02f, -7.12136179e-02f, -2.45034799e-01f, -2.34345749e-01f, -2.63644338e-01f,
  -4.00168717e-01f, -1.34318233e-01f, 8.29382986e-02f, -1.06145702e-01f, -1.03889272e-01f, -1.06721550e-01f, -8.79354924e-02f, -2.68661827e-01f, -1.05561770e-01f, -1.31609410e-01f,
  -1.11588195e-01f, -1.46648049e-01f, -1.18440308e-01f, -4.56308387e-02f, -9.80174616e-02f, -1.74659416e-01f, -1.95657134e-01f, -1.10110655e-01f, -2.23092288e-02f, -1.74833670e-01f,
  -1.46830045e-02f, -8.37871358e-02f, -5.06969402e-03f, 1.35740593e-01f, 2.53509015e-01f, 1.27864331e-01f, -1.02466881e-01f, -5.40758967e-02f, -3.41606140e-02f, -7.78435022e-02f,
  -2.47708380e-01f, -1.25523180e-01f, 1.95394289e-02f, 5.46630248e-02f, 1.93316117e-01f, 1.83475599e-01f, 1.01156108e-01f, 1.52975559e-01f, 1.79665372e-01f, 4.18337733e-02f,
  -3.02974172e-02f, 1.48867115e-01f, 9.81886014e-02f, -1.12176733e-02f, 4.57966104e-02f, -7.50349835e-02f, -1.33549199e-01f, -1.20698676e-01f, 3.26173194e-02f, 4.54593040e-02f,
  1.59825802e-01f, -1.19314708e-01f, -2.44715825e-01f, -2.52518713e-01f, -2.19355971e-01f, -1.91613603e-02f, -1.08865097e-01f, -7.78312758e-02f, -2.24675592e-02f, -1.69046432e-01f,
  -2.08495110e-01f, 3.88473481e-01f, 1.93012193e-01f, -7.30129704e-02f, -5.44043146e-02f, -5.02131805e-02f, 7.19046816e-02f, -1.04714081e-01f, -5.35902083e-02f, 2.74684653e-02f,
  1.13863479e-02f, -6.07363470e-02f, 4.11075838e-02f, -2.32679043e-02f, 1.20622732e-01f, -1.01940585e-02f, -8.80835205e-02f, 7.46004134e-02f, -2.29380243e-02f, -5.91947772e-02f,
  -4.90263030e-02f, 2.02139303e-01f, 2.07668483e-01f, 3.07167977e-01f, 2.04945236e-01f, 2.63103664e-01f, 1.50245816e-01f, 8.29399303e-02f, 2.16956586e-01f, 1.02970928e-01f,
  9.16774750e-01f, -1.76765695e-01f, -1.23708799e-01f, 1.62790537e-01f, -1.15695953e-01f, -1.50708035e-01f, -3.38147551e-01f, -1.42337933e-01f, 1.89547613e-01f, 2.00681761e-01f,
  1.66224271e-01f, 3.22717667e-01f, 2.01427281e-01f, 7.87635297e-02f, 2.91553456e-02f, -7.34725371e-02f, -3.54632214e-02f, 4.04525325e-02f, 1.29575238e-01f, 2.71531343e-01f,
  2.07383230e-01f, 1.30580887e-01f, 1.99531481e-01f, 9.84309167e-02f, 1.90537840e-01f, 1.95938900e-01f, 1.31860515e-02f, 5.12627363e-02f, 9.72883105e-02f, 1.55685142e-01f,
  2.46643052e-01f, 2.17086017e-01f, 3.64254378e-02f, 1.11552246e-01f, -1.53485443e-02f, 6.71668444e-03f, 9.94999036e-02f, 1.37778744e-02f, -1.52367586e-02f, -7.71689564e-02f,
  -2.38011349e-02f, 1.61553681e-01f, -7.94254430e-03f, 2.35665037e-04f, -4.16147448e-02f, -2.17905305e-02f, 2.75049713e-02f, 4.51191254e-02f, 3.11363805e-02f, 4.69241068e-02f,
  9.03985351e-02f, 6.46543503e-02f, -4.83628400e-02f, -1.86799601e-01f, -1.27164364e-01f, 5.29412238e-04f, -1.12479784e-01f, -1.46993669e-02f, -9.92388278e-02f, 1.95643708e-01f,
  1.97125569e-01f, 2.87172168e-01f, 3.76782864e-01f, 2.84759194e-01f, 2.40766376e-01f, 2.34289318e-01f, 6.43743575e-02f, 3.28950360e-02f, 1.80856228e-01f, 2.28769362e-01f,
  1.07087661e-02f, 2.34752208e-01f, 1.59413874e-01f, 7.33821914e-02f, 5.18346690e-02f, 2.91193247e-01f, 1.92805976e-01f, 6.26113452e-03f, 1.67778164e-01f, 1.22897953e-01f,
  1.00194030e-01f, 7.82430097e-02f, 1.85791090e-01f, -4.37921350e-04f, 6.75790459e-02f, 1.62000805e-01f, 3.43107760e-01f, 1.53001457e-01f, 1.70883507e-01f, 2.57804960e-01f,
  -3.96250218e-01f, -1.27397791e-01f, 2.29601219e-01f, 5.33765974e-03f, -1.40044838e-03f, -9.29937065e-02f, 8.70833546e-02f, -8.53563026e-02f, -1.16942860e-01f, -1.74818128e-01f,
  -1.36260360e-01f, 2.57870778e-02f, -1.41874373e-01f, -2.22261995e-02f, 6.60164580e-02f, -7.97048733e-02f, 1.40347376e-01f, 1.66196376e-02f, -4.17765677e-02f, -3.52029838e-02f,
  -3.85206193e-02f, -2.68575046e-02f, -5.48582040e-02f, -1.15464218e-01f, -9.72448513e-02f, 6.46122219e-03f, -3.59699652e-02f, -6.05117483e-03f, -1.39100626e-01f, 9.79561880e-02f,
  4.68426585e-01f, 3.01315725e-01f, 3.86459470e-01f, 3.18775058e-01f, 4.42966998e-01f, 5.56095004e-01f, 7.05388844e-01f, 3.53349537e-01f, 2.39806369e-01f, 3.07049632e-01f,
  3.47574621e-01f, 6.37157485e-02f, 2.21713379e-01f, 1.03670657e-02f, 1.23122148e-01f, 1.93809003e-01f, 1.21549889e-01f, 1.65144533e-01f, 2.35276490e-01f, 2.15262428e-01f,
  8.60082507e-02f, -1.09074591e-02f, 5.42688631e-02f, 8.82715434e-02f, -4.70274054e-02f, -4.86233085e-02f, 1.15351431e-01f, 1.01668090e-01f, 5.49835712e-02f, -3.21409881e-01f,
  -2.94272989e-01f, 6.80363178e-02f, -1.77640304e-01f, -6.93575889e-02f, -1.41972393e-01f, -1.70676097e-01f, -7.83542693e-02f, -7.53243566e-02f, -6.44329637e-02f, -7.23492056e-02f,
  -6.14198595e-02f, 6.31864965e-02f, 5.69949597e-02f, 5.04205236e-03f, 1.79576930e-02f, -6.90936819e-02f, 2.55147573e-02f, 1.89129874e-01f, 1.87209956e-02f, -2.41493452e-02f,
  -1.18817566e-02f, 1.57978490e-01f, 1.27582505e-01f, 1.16029724e-01f, 1.26605377e-01f, 2.63500828e-02f, 1.03428243e-02f, 6.94897324e-02f, 8.22502449e-02f, 6.86332583e-02f,
  1.43554434e-01f, 1.52589262e-01f, 2.43353799e-01f, 2.36724272e-01f, 1.08015142e-01f, 4.01583388e-02f, 3.73408422e-02f, 7.96207488e-02f, 1.86834767e-01f, 1.42141625e-01f,
  -2.44894717e-02f, 7.64791295e-02f, 1.70500487e-01f, 1.80054400e-02f, 6.66768115e-04f, 9.19845328e-02f, 3.45676132e-02f, 1.77349504e-02f, 1.84724376e-01f, 1.55961126e-01f,
  1.63562298e-01f, -3.54897715e-02f, 8.29728041e-03f, 8.23362097e-02f, 7.19942823e-02f, 7.67990947e-02f, -1.24812722e-01f, -4.45243757e-04f, -2.65502115e-03f, -2.21675821e-02f,
  -3.45507003e-02f, 1.83650613e-01f, -1.04629204e-01f, -1.50095016e-01f, -1.58587962e-01f, -9.78543982e-02f, 9.21793282e-02f, -1.88158378e-01f, -2.38755703e-01f, -2.93578625e-01f,
  -9.09895971e-02f, -1.68535277e-01f, 2.82727033e-02f, 3.09366528e-02f, -1.02075629e-01f, -4.08513844e-02f, 9.59459394e-02f, 1.66283816e-01f, -5.42327724e-02f, -5.63524589e-02f,
  -7.06571639e-02f, 2.21974164e-01f, 1.54000923e-01f, 2.18964485e-03f, 1.44951232e-02f, 4.03592251e-02f, 2.88715027e-02f, -1.11023568e-01f, 1.47466287e-01f, 2.43950710e-02f,
  -3.57006133e-01f, -6.85600221e-01f, -5.37708461e-01f, -3.02521944e-01f, 2.79371858e-01f, 5.33828259e-01f, 6.83721781e-01f, 5.62906027e-01f, 1.18234195e-01f, 1.87834143e-04f,
  -6.37179539e-02f, -3.17009896e-01f, -6.58832669e-01f, -1.95941821e-01f, 6.03333786e-02f, -7.40834102e-02f, -2.56705254e-01f, -1.20646007e-01f, 5.29216290e-01f, 9.49271917e-01f,
  2.90912122e-01f, 1.89925712e-02f, -5.51237054e-02f, -5.29535562e-02f, -2.15449631e-01f, -1.52647316e-01f, -5.82182944e-01f, -4.50733691e-01f, -2.10177347e-01f, -6.64089441e-01f,
  -4.20493364e-01f, -3.67206305e-01f, 2.18986571e-01f, -9.89932120e-02f, -1.81524709e-01f, -7.18315458e-03f, 1.95869312e-01f, -3.56715955e-02f, -5.24298213e-02f, 2.67340448e-02f,
  -1.66144714e-01f, 7.06674382e-02f, -1.14022598e-01f, 2.78704632e-02f, 1.09614797e-01f, 1.88501537e-01f, -2.09260285e-01f, -1.23627707e-01f, -2.54518270e-01f, -3.22569162e-02f,
  -1.20678537e-01f, -7.41844401e-02f, -1.54445320e-01f, -1.39570497e-02f, -4.72380929e-02f, -5.89628890e-02f, 4.03231271e-02f, 1.57414392e-01f, -1.05335802e-01f, -1.85705706e-01f,
  1.09084584e-01f, -1.51911631e-01f, 2.64688488e-02f, -1.35967648e-02f, 3.71666215e-02f, -9.78764519e-02f, -1.24062657e-01f, -6.85935691e-02f, 5.46890423e-02f, -4.56504822e-02f,
  4.26448099e-02f, -6.85392469e-02f, 2.89454851e-02f, -6.18171543e-02f, -1.56775266e-01f, -1.41473413e-01f, -5.22498898e-02f, -6.80526718e-02f, -2.06159845e-01f, -9.02992040e-02f,
  1.59933008e-02f, 6.71273656e-03f, -1.28926575e-01f, 8.14047903e-02f, -7.99662471e-02f, -1.05625484e-02f, -1.61046404e-02f, 5.21845818e-02f, 3.70636247e-02f, 1.55996025e-01f,
  -6.76673502e-02f, -9.37270373e-02f, -1.70714393e-01f, -2.04624273e-02f, -1.83655247e-01f, -1.13812633e-01f, -3.24810684e-01f, -4.89884242e-02f, -1.56870648e-01f, 3.13759670e-02f,
  1.39258727e-01f, -5.59539162e-02f, -1.89125881e-01f, 8.48094001e-02f, 2.27601215e-01f, 2.58209426e-02f, -8.27270746e-03f, -7.54890367e-02f, -3.92034613e-02f, 5.45581952e-02f,
  -1.71532497e-01f, 1.92544073e-01f, 1.15384556e-01f, -2.23742239e-02f, 1.01386555e-01f, 1.35406867e-01f, 7.79608861e-02f, 1.10712267e-01f, 1.51491225e-01f, 1.43156976e-01f,
  -2.76489139e-01f, 1.25587761e-01f, -1.02390516e+00f, -4.83427405e-01f, -5.47343612e-01f, -2.84988225e-01f, -1.40286788e-01f, 2.20575601e-01f, 3.12219024e-01f, 6.51949048e-02f,
  -6.51349500e-02f, -2.78516620e-01f, -4.16659623e-01f, -2.83637732e-01f, -2.16526836e-01f, -4.36381176e-02f, -2.52749234e-01f, -6.87580466e-01f, -8.04578483e-01f, -2.76772320e-01f,
  -1.41758114e-01f, -5.15166640e-01f, -5.33998549e-01f, -3.01478386e-01f, -5.04240654e-02f, -3.49788517e-01f, -3.46207857e-01f, -2.83041865e-01f, 1.31703755e-02f, -2.68250078e-01f,
  -5.36881566e-01f, -2.01357201e-01f, -2.17759281e-01f, 1.25167206e-01f, -1.94749579e-01f, 1.98592171e-02f, -2.26522520e-01f, -1.33232936e-01f, 4.14228551e-02f, -1.40960902e-01f,
  -2.81466395e-01f, -1.84360929e-02f, -3.70942235e-01f, -1.79372251e-01f, -2.94851214e-01f, -1.35891691e-01f, -1.11405486e-02f, -1.04522906e-01f, -7.77975237e-03f, 2.06561267e-01f,
  2.50362754e-01f, 5.36718294e-02f, -1.10850222e-01f, 2.43374854e-01f, 2.02848136e-01f, -2.86656376e-02f, 3.12774116e-03f, 3.02806236e-02f, -4.17922027e-02f, 2.05732241e-01f,
  3.45911264e-01f, 5.09606823e-02f, -5.12981154e-02f, -2.97464896e-03f, -5.71459718e-02f, 2.60521658e-02f, -3.84424627e-03f, -3.52772884e-02f, -9.76590142e-02f, -9.92182419e-02f,
  -9.59753152e-03f, 4.99777049e-02f, -1.52607374e-02f, 1.98384188e-02f, -1.31981581e-01f, -8.32499191e-02f, 8.19381699e-02f, 5.29633425e-02f, -5.51653132e-02f, -1.20799057e-01f,
  -1.22220911e-01f, -5.31200180e-03f, -1.41757980e-01f, 8.80602300e-02f, 4.98311371e-02f, 2.78934743e-02f, 2.58242972e-02f, 5.70846386e-02f, 1.12020341e-03f, 3.30244675e-02f,
  -3.44460070e-01f, -7.77032822e-02f, -4.44875397e-02f, 5.57150180e-03f, -6.44510239e-02f, 1.05871655e-01f, -2.60518461e-01f, -9.09452066e-02f, -4.11349125e-02f, -1.19405448e-01f,
  -5.75711653e-02f, 1.80838909e-02f, -2.89207399e-01f, 3.37125584e-02f, -2.62782812e-01f, -3.05284932e-02f, 1.80192471e-01f, -1.43539727e-01f, 1.08820975e-01f, 1.71686128e-01f,
  1.91169724e-01f, 1.61573321e-01f, -4.79429215e-03f, 3.07792798e-02f, 2.01063022e-01f, -7.97123387e-02f, -2.49827355e-01f, 2.42287312e-02f, 2.69743651e-02f, 3.04204971e-01f,
  9.72554147e-01f, -7.01647222e-01f, -5.87657750e-01f, 2.85848171e-01f, -6.26384795e-01f, -6.11924887e-01f, -9.68510211e-01f, 3.89423929e-02f, 1.90231889e-01f, -8.06092560e-01f,
  -2.35137433e-01f, 4.63242829e-01f, 3.44304770e-01f, 4.25911844e-01f, 6.91481590e-01f, -6.69105172e-01f, -3.94843727e-01f, 4.61235940e-01f, 6.83767617e-01f, -2.55244136e-01f,
  -4.31910455e-01f, 1.49660826e-01f, 7.05004334e-01f, 4.15529728e-01f, -7.83405781e-01f, 1.35685047e-02f, -5.63525498e-01f, -3.80618513e-01f, -6.52548611e-01f, -9.91462231e-01f,
  -5.17166555e-01f, -3.22656006e-01f, -1.11396136e-02f, 3.41555387e-01f, -2.17923701e-01f, 1.02622122e-01f, -1.09677926e-01f, -1.59274265e-01f, -1.75594557e-02f, -1.13532938e-01f,
  -8.86676833e-02f, 1.31890878e-01f, 1.08397134e-01f, -4.66864072e-02f, -2.57774052e-04f, 9.86800343e-02f, 2.44015437e-02f, 2.00552374e-01f, 7.97998011e-02f, -3.98277521e-01f,
  -3.94324958e-01f, -2.15337425e-01f, -3.25760320e-02f, -2.58805633e-01f, -9.54831392e-03f, 2.89431930e-01f, -3.49281311e-01f, -2.91469723e-01f, 9.48106721e-02f, -7.61576116e-01f,
  4.88272123e-02f, 6.51931716e-03f, -3.01423311e-01f, -1.01626895e-01f, 8.25808290e-03f, -2.00742595e-02f, 1.68146025e-02f, -8.83868560e-02f, -1.24554537e-01f, -1.42546594e-01f,
  6.25692457e-02f, 2.57839654e-02f, 1.42345339e-01f, -6.49729446e-02f, -1.62803397e-01f, 1.25186816e-02f, -2.33839005e-02f, -4.01328430e-02f, 8.62788782e-03f, -8.03141575e-03f,
  2.22358573e-02f, 2.86642443e-02f, 1.69829167e-02f, 1.61268651e-01f, -1.71926126e-01f, 1.58124328e-01f, 6.91650212e-02f, -3.17665748e-02f, 1.88170791e-01f, -1.10286303e-01f,
  6.58263505e-01f, 4.87691045e-01f, -1.16462678e-01f, 3.19950253e-01f, -1.49448082e-01f, -2.59986699e-01f, -2.19733477e-01f, -4.47569117e-02f, 2.66352803e-01f, 8.32784623e-02f,
  -1.50877491e-01f, 2.21826553e-01f, -1.44532755e-01f, -1.82047680e-01f, -3.98738794e-02f, -1.05891086e-01f, -5.21701574e-02f, -2.92546321e-02f, 1.20079592e-01f, -3.17913324e-01f,
  4.55823652e-02f, 1.06691405e-01f, 2.00571060e-01f, 1.33617386e-01f, -2.49590054e-01f, 3.40101600e-01f, -2.31192902e-01f, -5.16743124e-01f, 2.73796350e-01f, -1.72237590e-01f,
  -9.27169919e-01f, 4.78207320e-01f, -2.59484589e-01f, -4.37401347e-02f, 1.20380074e-01f, -3.42985749e-01f, -7.16502592e-02f, -4.00781780e-01f, -1.19884782e-01f, 1.37043327e-01f,
  1.66114226e-01f, 4.18885648e-01f, 4.58845049e-01f, 2.84833550e-01f, -2.43259370e-02f, 4.25425738e-01f, 3.82311821e-01f, -2.76265681e-01f, -4.84392941e-01f, -1.86348811e-01f,
  3.83076221e-01f, 1.15883738e-01f, -4.59756643e-01f, -2.26446465e-01f, 2.30797753e-01f, 2.15756178e-01f, 1.99077591e-01f, 1.55092061e-01f, 1.47499144e-01f, 4.02532369e-01f,
  3.49150717e-01f, -6.18847787e-01f, -1.86298907e-01f, -6.81802407e-02f, -2.89809983e-02f, -2.88828850e-01f, -2.27419227e-01f, -2.76707143e-01f, -2.44077012e-01f, -1.72882348e-01f,
  5.67906275e-02f, -2.73337543e-01f, 7.25411326e-02f, 2.24937294e-02f, -1.69341803e-01f, -2.87241191e-01f, -9.25681517e-02f, -2.67124414e-01f, -2.15137213e-01f, -1.48982480e-01f,
  3.99436057e-01f, -1.02006800e-01f, -2.18220428e-01f, -1.44264504e-01f, -2.81019658e-01f, -1.62548393e-01f, -1.75532296e-01f, -3.32797080e-01f, -3.81618142e-01f, -2.29353443e-01f,
  -2.79444493e-02f, -2.95999479e-02f, -7.13984072e-02f, 6.84674084e-02f, 1.43227205e-01f, 1.24804385e-01f, -1.86592136e-02f, -3.42578925e-02f, 1.14472338e-03f, -6.21463992e-02f,
  5.73709123e-02f, 3.62580270e-02f, -9.72465426e-02f, -9.35979709e-02f, 4.53625321e-02f, -1.34508058e-01f, -3.14224958e-02f, -2.84510851e-02f, -5.47225103e-02f, -1.41021267e-01f,
  -4.65093143e-02f, -1.19535901e-01f, -1.49057498e-02f, -1.37177199e-01f, -1.61660120e-01f, -2.08256841e-01f, -1.28696889e-01f, -6.23854809e-02f, 3.95705216e-02f, -5.67144752e-02f,
  5.79502642e-01f, -3.78099263e-01f, 9.42820087e-02f, 6.02058806e-02f, -1.31820247e-01f, -5.00307791e-02f, 2.39655394e-02f, -1.92964077e-01f, 1.46335168e-02f, -1.65966153e-01f,
  -3.16352606e-01f, -2.04204991e-01f, 3.20519924e-01f, 8.96445066e-02f, -1.75439358e-01f, 1.48354759e-02f, 2.62197584e-01f, 1.62755787e-01f, 2.92230044e-02f, -1.47936031e-01f,
  1.72855541e-01f, -1.33533357e-02f, 2.22733155e-01f, 2.31968701e-01f, 7.85721466e-03f, 1.88790038e-01f, 3.06877375e-01f, 1.45209908e-01f, 5.92034915e-03f, 1.50421500e-01f,
  -4.95980293e-01f, -2.51775384e-01f, -3.87040555e-01f, -3.36862594e-01f, -3.78586173e-01f, -4.68027353e-01f, -6.78395033e-01f, -2.98597902e-01f, -1.16665393e-01f, -5.12443542e-01f,
  -2.26576284e-01f, 8.21282715e-02f, -5.49205840e-02f, -3.00791889e-01f, -4.60166723e-01f, -6.90494180e-01f, -5.98795533e-01f, -5.79158485e-01f, -5.06974339e-01f, -4.05358762e-01f,
  -5.13966680e-01f, -3.20236236e-01f, -2.45776370e-01f, -1.59910098e-01f, 1.41605973e-01f, 1.08254634e-01f, -9.55844820e-02f, -1.87681377e-01f, -3.00640941e-01f, -1.95253670e-01f,
  -1.39912963e-01f, 8.76930580e-02f, -5.81235364e-02f, -4.53003943e-02f, -1.72697008e-01f, 1.05929151e-01f, 8.73771962e-03f, 8.54460001e-02f, 9.23581272e-02f, -1.49950877e-01f,
  -9.61429700e-02f, -5.26900887e-02f, 1.13152869e-01f, 4.27355133e-02f, -1.64191708e-01f, -1.72154859e-01f, -1.93394810e-01f, -2.18523800e-01f, -3.34647647e-03f, 3.57366819e-03f,
  -9.79164317e-02f, -1.63005531e-01f, 2.91187074e-02f, 3.92347164e-02f, 7.27093965e-02f, -3.63077857e-02f, 1.57272875e-01f, 1.39155895e-01f, 1.30716011e-01f, -2.13793870e-02f,
  -2.42783837e-02f, 1.18081786e-01f, -6.93692639e-02f, 1.03343695e-01f, -9.11905318e-02f, -5.72083890e-03f, 5.76776862e-02f, 7.28724822e-02f, 4.33582626e-02f, -1.47611246e-01f,
  -2.15147004e-01f, -8.72287229e-02f, -2.24675909e-02f, -8.25773105e-02f, -1.23011500e-01f, -1.88420024e-02f, -2.07454413e-01f, -1.85695142e-01f, -1.28011435e-01f, -1.82635933e-01f,
  -1.51798710e-01f, -6.75289407e-02f, -6.63217455e-02f, -2.63254419e-02f, -1.05165012e-01f, -1.72331288e-01f, -8.55653211e-02f, -1.31683201e-02f, -1.18864700e-01f, -9.58511978e-02f,
  2.19765231e-01f, -2.89014548e-01f, 6.27103075e-02f, 1.13658480e-01f, -4.61690240e-02f, -3.27748694e-02f, 1.94972754e-01f, -1.91636365e-02f, 5.73370606e-02f, -3.17665525e-02f,
  -1.39905199e-01f, -7.14194775e-02f, -1.02669358e-01f, 1.49155915e-01f, -1.19663171e-01f, -1.72838748e-01f, -2.26144895e-01f, -4.38104011e-02f, 9.59906355e-03f, 5.43221049e-02f,
  -1.05621159e-01f, -2.02350125e-01f, -1.64102808e-01f, 2.50037760e-02f, 1.86097577e-01f, -1.23263123e-02f, 1.26929611e-01f, 1.74583375e-01f, -8.24603662e-02f, -1.82717934e-01f,
  -1.26686826e-01f, -4.82922316e-01f, 1.84398055e-01f, 4.48274046e-01f, 6.93871751e-02f, 2.96431733e-03f, -4.46444184e-01f, 8.75605717e-02f, 3.88890743e-01f, 1.03476413e-01f,
  6.15230687e-02f, 4.55807388e-01f, 3.06988209e-01f, 2.32211024e-01f, 1.55867442e-01f, 2.43618384e-01f, 3.35174769e-01f, 2.01041058e-01f, 1.51051208e-01f, 1.26811996e-01f,
  5.59759215e-02f, -1.39240056e-01f, -8.73224586e-02f, 2.23259002e-01f, 8.61745887e-03f, 2.10934281e-01f, 1.67993903e-01f, -2.56858259e-01f, -2.36205831e-01f, 8.64114910e-02f,
  -1.56925321e-01f, -2.31541246e-01f, 4.09102768e-01f, 6.29824251e-02f, -5.65753691e-02f, 1.06831059e-01f, 2.36196741e-01f, 1.11911735e-02f, -2.16697175e-02f, 1.58848852e-01f,
  1.84204243e-02f, 3.34871039e-02f, -5.45783788e-02f, -1.60471380e-01f, -1.67063877e-01f, -4.43831906e-02f, -1.37032479e-01f, -1.78916857e-01f, 7.01734200e-02f, 2.91312505e-02f,
  2.80301906e-02f, -7.06933215e-02f, -8.04786906e-02f, -4.57406230e-02f, 1.27830170e-02f, -2.11489648e-02f, -1.35790408e-01f, -4.10182960e-02f, 9.11654681e-02f, -1.99280251e-02f,
  1.51576608e-01f, 9.18114707e-02f, -9.17101726e-02f, 3.71482037e-02f, 5.57467937e-02f, -7.38271102e-02f, -1.69673841e-02f, -8.72901008e-02f, 4.83598523e-02f, -1.65157989e-02f,
  -3.03502493e-02f, 1.15028493e-01f, -5.70068397e-02f, 3.92481945e-02f, 1.98377430e-01f, -1.15050808e-01f, -2.71815628e-01f, -2.61022542e-02f, -1.34130381e-02f, 2.86799911e-02f,
  -4.75836359e-03f, 6.32118341e-03f, 3.33217420e-02f, -1.47326976e-01f, -1.17496215e-01f, 1.38568714e-01f, 1.47505417e-01f, -8.13445002e-02f, 1.25185817e-01f, -2.04823818e-02f,
  -1.59443781e-01f, 1.88114956e-01f, 2.90713102e-01f, 3.45080495e-02f, -2.00494984e-03f, -2.00273562e-02f, 1.28163025e-01f, -5.42814992e-02f, -4.83856127e-02f, 2.48274192e-01f,
  1.53367162e-01f, 6.20825849e-02f, -6.31290972e-02f, 6.97637871e-02f, 1.51789591e-01f, 1.13190161e-02f, -4.87275496e-02f, -2.80995928e-02f, 6.28110543e-02f, 1.69550419e-01f,
  3.26324478e-02f, 1.74806803e-01f, 4.37628217e-02f, 2.48376891e-01f, 1.93780512e-01f, 3.88167739e-01f, -9.09831598e-02f, -4.90418114e-02f, 1.20088704e-01f, 4.92211506e-02f,
  5.49796820e-01f, -6.88981831e-01f, 3.07822675e-01f, 3.23420018e-01f, 4.29169148e-01f, 2.35103250e-01f, 6.99787661e-02f, 7.65530169e-02f, 2.40090266e-01f, 2.63800919e-02f,
  -5.91167152e-01f, -7.83672214e-01f, -5.73859215e-01f, -4.65344965e-01f, -5.74249566e-01f, 1.12908535e-01f, 3.40821445e-01f, 1.60818264e-01f, 5.13159558e-02f, -3.18285041e-02f,
  -3.58176619e-01f, 8.38007703e-02f, -2.34906990e-02f, -4.57827747e-02f, 1.80499658e-01f, -1.59155905e-01f, 4.67425175e-02f, 5.81009388e-02f, -2.10046336e-01f, 2.20876664e-01f,
  1.15761712e-01f, 6.91227019e-02f, 2.75480058e-02f, -1.98111951e-01f, -1.86370641e-01f, -1.11394316e-01f, -1.34518147e-01f, 8.53405446e-02f, -1.80121865e-02f, 1.49715260e-01f,
  -1.94169447e-01f, -8.07232261e-02f, 1.30780907e-02f, -2.29334994e-03f, 9.10165459e-02f, 9.46200788e-02f, -1.52532473e-01f, -1.37618810e-01f, -2.08762079e-01f, -1.43299416e-01f,
  -3.78709048e-01f, 2.72306632e-02f, 7.21408427e-02f, -1.54571861e-01f, -1.38769388e-01f, -6.79318607e-02f, -1.26143023e-02f, 2.37957276e-02f, 2.45493576e-02f, 1.95911676e-01f,
  1.13560118e-01f, 1.20150320e-01f, -1.98836789e-01f, -1.06007099e-01f, -9.30206031e-02f, 8.79401118e-02f, -1.80351567e-02f, -3.91124189e-02f, -1.45958379e-01f, 1.78502519e-02f,
  -7.15137646e-03f, -1.61538690e-01f, -1.66676536e-01f, 6.74268045e-03f, -1.72527269e-01f, 3.09541505e-02f, 4.54417281e-02f, -1.61603674e-01f, -6.71132430e-02f, -5.00998721e-02f,
  -6.60042837e-02f, 5.66840954e-02f, -5.94830550e-02f, -1.49670064e-01f, -3.03862784e-02f, -1.21801555e-01f, -1.69617161e-02f, -2.51747876e-01f, -2.76290420e-02f, -2.52810139e-02f,
  -3.39952588e-01f, -4.49909240e-01f, 3.31567615e-01f, -8.89337808e-02f, 7.38910213e-02f, -1.67732462e-01f, -2.42831036e-01f, -8.09255391e-02f, -5.08793034e-02f, -2.00906321e-02f,
  -1.44062459e-01f, -1.43495545e-01f, -1.89706143e-02f, 6.96789101e-02f, 2.71014512e-01f, 5.02928793e-02f, -1.78042188e-01f, 9.05256569e-02f, -5.12635894e-02f, 1.67784505e-02f,
  -1.80280097e-02f, 9.27814990e-02f, 1.87584847e-01f, 3.64351422e-02f, 7.17185484e-03f, 1.92190558e-01f, 3.94606553e-02f, 1.74691305e-01f, 2.67131235e-02f, 3.23934913e-01f,
  5.06536722e-01f, -3.31798553e-01f, -2.03961372e-01f, -9.37725455e-02f, -3.66793573e-02f, 6.21580966e-02f, -1.49249300e-01f, 5.21039870e-03f, 2.12893840e-02f, -3.14577729e-01f,
  -1.31414384e-01f, 7.80374045e-03f, -2.23276123e-01f, -1.07777983e-01f, -1.34030223e-01f, -5.29614687e-01f, -3.80892128e-01f, -1.04928821e-01f, 1.03430577e-01f, 4.58831489e-02f,
  -1.60633728e-01f, -1.31845832e-01f, -4.08212990e-02f, -1.31748676e-01f, -3.65931422e-01f, -2.29573280e-01f, -3.13263446e-01f, -2.97519207e-01f, -3.62907469e-01f, -5.98159671e-01f,
  -2.74531841e-01f, 3.31976593e-01f, -3.18007916e-02f, 8.23506713e-02f, 1.17128171e-01f, 1.22198522e-01f, 6.51368275e-02f, 5.72878718e-02f, 2.72861719e-02f, -5.25371842e-02f,
  8.77077803e-02f, 1.96401440e-02f, 1.57955825e-01f, 1.51079357e-01f, 7.77272880e-02f, 2.41599396e-01f, 1.93966493e-01f, 1.43228486e-01f, 5.99805042e-02f, -4.47424836e-02f,
  1.60970926e-01f, 2.57186204e-01f, 1.82126597e-01f, 1.52506575e-01f, 3.87018144e-01f, 2.57740259e-01f, 1.37546629e-01f, 2.82657892e-01f, 1.90885812e-01f, 1.85723960e-01f,
  4.50079031e-02f, 1.20814024e-02f, 2.80450255e-01f, 2.24870741e-01f, 3.58221650e-01f, 2.76745766e-01f, 2.90755890e-02f, -2.04839334e-02f, 1.12758897e-01f, 2.00865030e-01f,
  -1.14003211e-01f, 2.94495299e-02f, 1.63668752e-01f, -6.28983453e-02f, -9.55872890e-03f, -2.50522979e-02f, 1.38531387e-01f, 3.20996083e-02f, 1.21219248e-01f, 5.35855964e-02f,
  -2.25590914e-02f, -1.76854394e-02f, -1.72953129e-01f, -7.86791891e-02f, 4.13745269e-02f, 2.76796836e-02f, -3.52426469e-02f, 1.42523855e-01f, 4.49441969e-02f, -2.39960045e-01f,
  -1.84904903e-01f, 2.78063923e-01f, -1.10097229e-01f, -2.26682633e-01f, -5.82141010e-03f, -7.94290453e-02f, -6.65018857e-02f, -1.11050434e-01f, -2.55951703e-01f, -9.06275585e-02f,
  2.85852216e-02f, -5.23198359e-02f, 1.24596551e-01f, 4.68032174e-02f, 4.42565279e-03f, 1.91778794e-01f, 2.27889225e-01f, -5.90996817e-03f, -3.82952467e-02f, -7.80565441e-02f,
  2.80434731e-02f, 1.22208312e-01f, 1.68994188e-01f, 1.20698512e-01f, 1.80507571e-01f, 9.60619748e-03f, -3.72382216e-02f, 1.13856085e-01f, 8.20539817e-02f, -5.56608699e-02f,
  4.41209435e-01f, -1.27859935e-01f, 1.21279411e-01f, 2.45240107e-01f, 1.94425151e-01f, -1.68972388e-02f, 5.87629080e-02f, 3.38313729e-02f, 3.31449844e-02f, 4.25840579e-02f,
  4.86781076e-02f, 2.07828924e-01f, 1.48836046e-01f, 1.28789470e-01f, 1.86341301e-01f, 1.05515793e-01f, 1.55763939e-01f, 2.07159460e-01f, 2.20653147e-01f, 2.67220557e-01f,
  2.49724999e-01f, 5.95756881e-02f, 4.46830923e-03f, 2.22401381e-01f, 3.06571275e-01f, 1.65273622e-01f, 5.53933792e-02f, 2.90086977e-02f, 7.35733807e-02f, 3.55204105e-01f,
  1.73291624e-01f, 8.87481570e-02f, -1.94226913e-02f, 9.40436646e-02f, 1.07098557e-01f, -5.00817448e-02f, 5.01208231e-02f, -2.06952736e-01f, -8.58827457e-02f, -1.93333536e-01f,
  6.03422262e-02f, 1.49601121e-02f, 1.21374153e-01f, 5.16881421e-02f, -7.83172995e-03f, -1.02031603e-01f, 9.59040225e-02f, 8.01845863e-02f, 2.04394553e-02f, 5.09339310e-02f,
  1.06543191e-01f, 4.55278642e-02f, 5.94806559e-02f, -6.39270917e-02f, 1.47229463e-01f, -7.32304109e-03f, 6.19301088e-02f, 1.43090963e-01f, -9.98768434e-02f, 1.53443351e-01f,
  3.75461698e-01f, 3.41758788e-01f, 3.07736278e-01f, 1.68532059e-01f, 2.58442253e-01f, 8.43601152e-02f, 1.07316338e-01f, -7.34225288e-03f, 9.74409431e-02f, 1.81606248e-01f,
  1.92482084e-01f, 2.03173280e-01f, 9.18990001e-02f, 9.46836248e-02f, 1.17252663e-01f, 1.07895900e-02f, -4.77136001e-02f, -1.38661921e-01f, 2.93545146e-02f, -1.29500493e-01f,
  4.29691523e-02f, 1.18266866e-01f, -1.77083001e-01f, 8.53351727e-02f, -8.50946903e-02f, 5.41245900e-02f, 1.12843022e-01f, -3.48627605e-02f, -7.48990104e-02f, 1.08792828e-02f,
  -7.29808033e-01f, -1.74679533e-01f, 1.45121723e-01f, 1.71146505e-02f, -8.77991021e-02f, -1.15291655e-01f, -6.86170012e-02f, -1.87353864e-01f, -3.17032784e-01f, -1.88692704e-01f,
  -2.45473519e-01f, -4.95129228e-02f, -1.10487193e-01f, -2.97496794e-03f, -9.51071084e-02f, -2.04288512e-01f, 6.40304610e-02f, 6.15043901e-02f, -1.47848323e-01f, -1.62892327e-01f,
  -9.41940304e-03f, -1.33451477e-01f, -1.50405332e-01f, -3.52115184e-02f, -1.90192461e-02f, -7.84372240e-02f, -1.39300734e-01f, -6.52645752e-02f, -1.43444091e-01f, -1.39085680e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.72962224e-01f, 8.57043087e-01f, 9.18574214e-01f, 6.15103662e-01f, 8.25645447e-01f, 7.28324354e-01f, 4.72836673e-01f, 2.85718769e-01f, 6.63209379e-01f, 1.00522256e+00f,
  6.72043383e-01f, 1.48739010e-01f, 7.04617858e-01f, 7.02974916e-01f, 6.25131547e-01f, 6.10933602e-01f, 5.55587411e-01f, 6.53719783e-01f, 7.28941798e-01f, 6.61247790e-01f,
  8.20673406e-01f, 4.02511656e-01f, 3.02001745e-01f, 1.01438844e+00f, 1.89205870e-01f, 3.68417203e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  3.88578996e-02f, -6.57072291e-02f, -1.42588526e-01f, -2.23439205e-02f, 4.28696312e-02f, -7.19859898e-02f, 4.99455258e-02f, 2.87666153e-02f, 1.19316094e-01f, 2.64231227e-02f,
  -3.00008673e-02f, -6.55339211e-02f, -3.66910517e-01f, -1.41938776e-01f, -9.35642980e-03f, -9.41378772e-02f, 7.35225454e-02f, -4.56685394e-01f, -7.78908841e-03f, 9.21701826e-03f,
  2.24503856e-02f, -2.82326303e-02f, 1.08889520e-01f, -2.09534302e-01f, -8.37863088e-02f, 1.51085947e-02f, -1.18963361e-01f, -8.57957155e-02f, 8.15788284e-03f, -4.40762155e-02f,
  2.35308893e-02f, -1.79188147e-01f, 2.92956978e-02f, 5.38318604e-02f, -2.87292600e-01f, -1.29071906e-01f, -2.42773578e-01f, -1.51410580e-01f, -1.01895347e-01f, 4.97719599e-03f,
  1.13075323e-01f, 2.52893325e-02f, 5.38348109e-02f, -8.01341012e-02f, 2.31752545e-01f, -2.21689548e-02f, -8.32409039e-02f, -2.71195263e-01f, 4.54744324e-02f, -1.27890840e-01f,
  1.48534076e-03f, 1.35389745e-01f, 2.58907676e-01f, -7.27497116e-02f, -1.08443640e-01f, 3.56087578e-03f, -1.27628043e-01f, 1.31252483e-01f, 1.47434399e-02f, 5.69430627e-02f,
  -1.05342247e-01f, 1.45613939e-01f, 6.16147332e-02f, 3.17519724e-01f, 2.41133180e-02f, -1.21262223e-01f, -7.46100619e-02f, -1.56864941e-01f, 2.23669097e-01f, -3.92974019e-02f,
  3.78949754e-03f, -2.98637331e-01f, 9.92214754e-02f, 4.72293675e-01f, -1.40697256e-01f, -3.85551155e-02f, -1.33819848e-01f, 1.93820102e-03f, 2.11074993e-01f, 2.86934245e-02f,
  1.19417340e-01f, -8.00830871e-03f, 4.27621230e-02f, 1.91925511e-01f, -4.90198024e-02f, 2.44992837e-01f, 2.84143835e-01f, -4.10472900e-02f, 9.52165797e-02f, -9.21693370e-02f,
  -2.89679587e-01f, -1.23874553e-01f, -2.65269488e-01f, 1.02536052e-01f, 2.65690774e-01f, -3.11483536e-02f, -5.26484065e-02f, -1.79319963e-01f, 6.62523210e-02f, 1.77205071e-01f,
  1.42630875e-01f, 4.13602069e-02f, -5.62978446e-01f, -4.79756266e-01f, -7.55762696e-01f, 1.76213667e-01f, -7.93582797e-01f, 2.42838308e-01f, -3.64410281e-01f, 8.08007121e-02f,
  -3.19512814e-01f, -4.59491014e-01f, 4.51877058e-01f, -7.89596587e-02f, -3.81149858e-01f, 2.68000126e-01f, -6.73036218e-01f, -7.21449196e-01f, -6.74447358e-01f, 6.90189302e-01f,
  1.08632118e-01f, 2.09454581e-01f, -8.96024287e-01f, 2.30295286e-01f, -1.54932924e-02f, -8.62992525e-01f, 3.83156836e-01f, 2.73523852e-02f, 3.64505611e-02f, -1.00058146e-01f,
  1.19093701e-01f, -6.12721108e-02f, 4.37279195e-02f, -8.22097734e-02f, -1.29187867e-01f, -9.43879187e-02f, -1.65142864e-01f, -1.28445864e-01f, 8.47852379e-02f, 2.86150593e-02f,
  1.25477925e-01f, 2.08759569e-02f, 5.93895987e-02f, -3.38647515e-02f, 1.80957690e-01f, -2.79173478e-02f, 7.68787488e-02f, -1.43921882e-01f, -3.62103395e-02f, 1.48205012e-01f,
  -1.92955449e-01f, 9.18554217e-02f, -1.49105102e-01f, -4.44839783e-02f, 3.26483920e-02f, 1.26774535e-01f, 6.08715452e-02f, -1.64283589e-01f, 8.40155333e-02f, 3.20696272e-02f,
  -9.88590494e-02f, 1.85516104e-02f, -5.16252778e-02f, -1.32411823e-01f, 1.22991204e-01f, 1.01990722e-01f, -8.23879018e-02f, 1.44292846e-01f, 1.71469167e-01f, 7.68220006e-03f,
  -7.13120624e-02f, 9.70660523e-02f, 4.90714684e-02f, 1.28320664e-01f, 4.51872014e-02f, -1.16904415e-01f, 2.87902839e-02f, 9.22692865e-02f, 3.57213281e-02f, 7.34438598e-02f,
  -9.60449055e-02f, 5.15737683e-02f, 3.42574407e-04f, -2.42787246e-02f, -1.86924264e-02f, -1.01691172e-01f, -8.42721853e-03f, 1.91519931e-01f, 1.28065437e-01f, -1.66200027e-01f,
  1.32535324e-01f, 1.96184516e-01f, 2.64842957e-01f, 1.32536501e-01f, 2.93506116e-01f, -2.65214920e-01f, -2.04340920e-01f, 1.46972731e-01f, 5.05332649e-02f, -2.22563282e-01f,
  -7.00792968e-02f, 1.28503010e-01f, -2.24355653e-01f, -4.44557592e-02f, -2.51180641e-02f, -2.26550326e-01f, 8.16594623e-03f, -2.77645281e-03f, 1.87606309e-02f, 1.83866948e-01f,
  1.76107973e-01f, 2.21341103e-01f, -1.59089267e-01f, -2.18749315e-01f, -3.19795422e-02f, -1.10944331e-01f, 4.09484096e-02f, -3.04732174e-01f, -1.20448517e-02f, -3.57308425e-02f,
  1.38082176e-01f, -9.88046452e-02f, 2.00623751e-01f, -2.12588504e-01f, 4.86858282e-03f, -3.22395176e-01f, 3.46940383e-02f, -1.07982367e-01f, -1.11429125e-01f, 2.20390007e-01f,
  -3.45523924e-01f, -9.45972621e-01f, -1.46107876e+00f, 2.87788719e-01f, -6.23885751e-01f, -1.32198751e+00f, 1.36727849e-02f, 3.44320893e-01f, -4.31265146e-01f, -7.07117915e-01f,
  -1.74722433e-01f, 3.26089859e-02f, 3.54212403e-01f, 6.51223063e-01f, 5.58243692e-01f, 1.31280884e-01f, 1.30614236e-01f, -4.05870646e-01f, 2.20469180e-02f, 1.06054449e+00f,
  -5.53887844e-01f, 1.59509152e-01f, 3.89651284e-02f, -6.61829710e-01f, 1.06820635e-01f, 3.05593908e-01f, 3.40011157e-02f, 6.57158867e-02f, 4.40331399e-02f, 1.63912117e-01f,
  1.15118325e-01f, 1.47861661e-02f, -6.31613061e-02f, 9.89464298e-02f, 7.29902182e-03f, 9.43467617e-02f, -3.68337482e-02f, 1.63997635e-01f, 1.58903971e-02f, 7.25878701e-02f,
  -1.53952047e-01f, 4.49749716e-02f, -2.11984321e-01f, 2.76747227e-01f, 2.50879861e-02f, 9.45889875e-02f, 4.65855785e-02f, 6.36993954e-03f, 9.91602764e-02f, 9.90785062e-02f,
  1.49003729e-01f, 8.81202966e-02f, 1.23216525e-01f, 6.03888603e-03f, -5.05216140e-03f, -5.25467433e-02f, 8.05122033e-02f, 1.05802365e-01f, -1.39337748e-01f, -1.02840126e-01f,
  7.06823841e-02f, 1.71327665e-01f, 1.00321956e-01f, 2.53989905e-01f, 8.57748613e-02f, -1.91622138e-01f, 1.15195028e-01f, -1.51114941e-01f, 6.57978700e-03f, 8.74212012e-02f,
  -6.96189702e-04f, 1.30939260e-01f, 1.46301135e-01f, 3.07047348e-02f, 8.13804343e-02f, 1.47068456e-01f, -1.34600177e-01f, 3.74563426e-01f, -1.44313172e-01f, 2.12889612e-01f,
  2.16928422e-01f, -1.53829195e-02f, 4.48620208e-02f, 2.91933030e-01f, 3.66197415e-02f, 7.59173185e-02f, 1.18283764e-01f, 2.24865749e-01f, 2.19496012e-01f, -2.38519814e-02f,
  2.66505241e-01f, -1.02223776e-01f, -2.87915929e-03f, -5.86038642e-02f, 9.86598730e-02f, 2.63456434e-01f, -3.06252956e-01f, -2.62717932e-01f, 1.38212666e-01f, -9.42570269e-02f,
  1.29344776e-01f, -1.29032284e-01f, 1.13775730e-01f, 1.57625936e-02f, 1.59740955e-01f, 3.89169872e-01f, 2.48142272e-01f, -3.06895703e-01f, -5.77355251e-02f, 1.76785648e-01f,
  -3.48358601e-01f, 3.19155544e-01f, -1.86658651e-01f, -1.07318297e-01f, -1.61837518e-01f, 4.24840674e-02f, -2.84911692e-01f, 2.04175889e-01f, -9.71188471e-02f, -1.29512444e-01f,
  8.36444274e-02f, -1.65537521e-01f, -1.52319223e-01f, -1.79139793e-01f, -3.02231759e-01f, -7.55420625e-02f, 1.46588475e-01f, 2.31330141e-01f, -3.63784403e-01f, 2.27239072e-01f,
  -2.61072367e-01f, 9.86087918e-01f, -6.26792967e-01f, -3.01044166e-01f, -3.98115337e-01f, -3.13875347e-01f, -6.45733476e-01f, 8.11589301e-01f, -9.44285512e-01f, -1.23422228e-01f,
  -3.67389679e-01f, -1.29672676e-01f, 1.91694475e-03f, -2.66260713e-01f, -1.43089801e-01f, -1.79848626e-01f, -9.08961356e-01f, 8.68667543e-01f, -2.11970389e-01f, -4.83024895e-01f,
  1.92213848e-01f, -2.38130674e-01f, 1.14225700e-01f, -2.02697620e-01f, -2.06239507e-01f, 2.19274778e-02f, 1.29773960e-01f, 1.85822725e-01f, 2.93119282e-01f, 2.29807757e-02f,
  -1.97054461e-01f, -2.02572551e-02f, -8.30879733e-02f, -5.62614799e-02f, -1.63064897e-01f, -9.46002454e-02f, 1.53065875e-01f, 1.09178059e-01f, 6.14516176e-02f, -5.89891151e-02f,
  4.28259512e-03f, -3.29810590e-01f, -1.03327803e-01f, 2.74946064e-01f, 4.83967401e-02f, -1.76285148e-01f, -9.83748436e-02f, -2.47422084e-01f, 7.84640945e-03f, -7.86518678e-02f,
  -3.07902128e-01f, -4.47230116e-02f, -3.48025821e-02f, 2.03584462e-01f, 4.71189693e-02f, -1.35076419e-01f, 7.04164207e-02f, -2.16586307e-01f, 9.82770473e-02f, 1.49907678e-01f,
  -2.53714770e-01f, -1.61453053e-01f, -3.55995074e-02f, -2.30004974e-02f, -3.88347358e-02f, -1.95314765e-01f, 6.47803396e-02f, -1.37168951e-02f, 1.17110252e-01f, 6.75760955e-02f,
  9.07621905e-03f, 2.34864295e-01f, -1.09106816e-01f, 7.44906962e-02f, 4.16712575e-02f, -2.02645376e-01f, 3.06463372e-02f, -8.63385201e-02f, -1.25344709e-01f, 2.94287711e-01f,
  9.11562368e-02f, 2.27863505e-01f, 1.42927557e-01f, -4.42162752e-01f, 3.40434760e-01f, -3.93417984e-01f, 7.91558474e-02f, -3.21806937e-01f, 1.00337513e-01f, -2.32313991e-01f,
  2.14922756e-01f, 9.79223326e-02f, 3.25223714e-01f, -8.46965089e-02f, 8.53193104e-02f, 2.65367568e-01f, -1.79937128e-02f, -3.62671733e-01f, -2.55050268e-02f, 1.68849379e-01f,
  3.89837444e-01f, 4.67044413e-01f, -1.85023278e-01f, 1.77833661e-01f, 1.30487293e-01f, -3.39192271e-01f, -9.87486318e-02f, 3.85635113e-03f, 2.28500009e-01f, -1.55671135e-01f,
  -2.81288236e-01f, -5.89149036e-02f, -9.73670464e-03f, 2.98182577e-01f, -3.33086520e-01f, 2.18994290e-01f, -4.74244833e-01f, 1.63592055e-01f, 1.38802737e-01f, 1.26257867e-01f,
  -1.01557985e-01f, -2.19128713e-01f, 1.14117071e-01f, 4.82513547e-01f, 4.36151065e-02f, 9.47486907e-02f, -3.25650871e-02f, -1.22672701e+00f, 8.65413547e-01f, 4.02312070e-01f,
  5.29565036e-01f, 3.05905819e-01f, -6.23258650e-01f, -5.51018178e-01f, 1.57605931e-01f, 4.66157705e-01f, -9.67011273e-01f, -3.45727086e-01f, -3.15684468e-01f, 2.26337686e-01f,
  -2.05966279e-01f, -6.26436949e-01f, -2.13877171e-01f, 4.01836336e-01f, 3.14381033e-01f, -9.40462470e-01f, -2.89794713e-01f, -1.34525970e-01f, -4.37973410e-01f, -6.60472095e-01f,
  -3.30910474e-01f, -3.64457458e-01f, -1.12720244e-01f, 1.60611458e-02f, -2.66910970e-01f, -1.43992230e-01f, -2.13552177e-01f, 4.24765795e-02f, 5.11323698e-02f, -1.17890067e-01f,
  1.27390251e-01f, -1.54221833e-01f, 8.80069211e-02f, -6.16334230e-02f, -4.16247398e-02f, -4.38547507e-02f, -2.16198359e-02f, -5.21370433e-02f, 6.46594092e-02f, 4.20414060e-01f,
  3.72963324e-02f, -1.33494467e-01f, 6.49200901e-02f, -2.12948635e-01f, -1.05115816e-01f, -1.43185034e-01f, -3.19651477e-02f, -7.74494633e-02f, -3.23041662e-04f, 6.61001354e-02f,
  3.01080216e-02f, -1.13257289e-01f, -3.51186888e-03f, -3.23320717e-01f, 5.87072074e-02f, 1.24929035e-02f, 2.14898020e-01f, 8.89942870e-02f, 4.93902825e-02f, -6.92758188e-02f,
  2.93888841e-02f, -8.52180421e-02f, -3.57519984e-02f, 2.26959497e-01f, 1.03280391e-03f, -5.51085100e-02f, -1.35163620e-01f, 5.34543060e-02f, -1.54255658e-01f, -6.99713454e-02f,
  2.90935356e-02f, 7.94923753e-02f, -5.72632290e-02f, -4.21562530e-02f, 9.04547647e-02f, -7.98028708e-02f, 7.52584636e-02f, -3.29023376e-02f, -1.13567717e-01f, 1.57742232e-01f,
  1.20271891e-01f, -3.49695347e-02f, -1.21143632e-01f, 1.46740600e-01f, 1.81435913e-01f, 2.69308574e-02f, 1.24071270e-01f, -2.97797024e-02f, -1.28901750e-01f, 7.28091225e-02f,
  -8.66997465e-02f, -4.08339612e-02f, 9.18531120e-02f, -2.23095492e-02f, 2.59562954e-02f, -2.41457298e-01f, -1.58614844e-01f, 3.08599211e-02f, 1.14129409e-01f, -3.41763079e-01f,
  -9.95600969e-02f, -2.23562360e-01f, 2.15776235e-01f, 2.11769387e-01f, -1.26735598e-01f, -2.39511468e-02f, 8.73317290e-03f, 1.95366621e-01f, 8.53829645e-03f, -1.97380066e-01f,
  7.09575713e-02f, -1.38667330e-01f, 2.30007201e-01f, -1.69582367e-01f, 2.85608292e-01f, -2.02203259e-01f, -1.19792290e-01f, 7.01161921e-02f, -4.15350050e-02f, -4.53760661e-02f,
  1.82357118e-01f, -1.13794297e-01f, -2.80421264e-02f, -1.38713449e-01f, 4.73457932e-01f, 5.36434650e-01f, -3.19155157e-01f, 3.68385762e-02f, 6.14864171e-01f, 2.81727433e-01f,
  3.67942005e-02f, -6.79300547e-01f, -1.39370114e-01f, -1.12230265e+00f, -3.61280620e-01f, 1.47597522e-01f, -2.50557899e-01f, -8.14826012e-01f, -4.61632699e-01f, -1.82232752e-01f,
  1.92483887e-01f, -1.03468215e+00f, 1.03755236e-01f, -2.61266619e-01f, -1.12043200e-02f, 4.14947093e-01f, 2.43514441e-02f, -3.71359326e-02f, -2.17245504e-01f, -3.61225367e-01f,
  6.09347336e-02f, 2.83649508e-02f, 1.68087065e-01f, 1.66536048e-02f, 8.30054134e-02f, 1.61737874e-02f, 1.74442932e-01f, 2.18981132e-01f, -8.79995897e-02f, 1.29696503e-01f,
  1.45475924e-01f, 3.22970599e-02f, 3.84204090e-02f, 1.16892919e-01f, 8.88857916e-02f, 1.98585734e-01f, -2.49836911e-02f, 1.38854444e-01f, -1.09320089e-01f, 7.04900995e-02f,
  1.18544467e-01f, -1.22953979e-02f, 2.34943822e-01f, 1.93011165e-01f, -5.84870502e-02f, 7.26613309e-03f, -2.26291493e-02f, 1.08433627e-01f, -2.98540369e-02f, 1.00652419e-01f,
  9.44872294e-03f, 8.66110548e-02f, 1.37075201e-01f, 8.59905779e-02f, 8.47526491e-02f, -1.40837863e-01f, 5.76640554e-02f, 3.18710171e-02f, 3.21727127e-01f, -8.24825838e-02f,
  -2.12416872e-02f, 2.12152094e-01f, -2.83769146e-02f, 7.51447007e-02f, -3.97233060e-04f, -2.93558780e-02f, 9.41691026e-02f, 6.59117848e-02f, -1.61729082e-02f, 1.46248460e-01f,
  -1.86869323e-01f, -4.10897136e-02f, 1.15698121e-01f, 1.70467626e-02f, -1.66422412e-01f, 1.15531698e-01f, -1.45051748e-01f, -1.15128420e-01f, 3.93748982e-03f, 2.24512801e-01f,
  -1.34623021e-01f, -7.96122029e-02f, 1.28636926e-01f, 3.42878580e-01f, -5.25588579e-02f, -2.53111534e-02f, -4.66523468e-01f, 2.55123228e-01f, 7.44211599e-02f, -1.17983766e-01f,
  2.86114097e-01f, 1.93237662e-01f, 4.25502658e-02f, 2.03094468e-01f, 1.91103257e-02f, 6.30751699e-02f, -2.66739458e-01f, -2.97574937e-01f, -1.16888069e-01f, -2.00671792e-01f,
  -1.18162729e-01f, 3.58547688e-01f, -1.68142334e-01f, -2.03825817e-01f, -1.44894430e-02f, 2.18480259e-01f, 4.07229602e-01f, 1.17395192e-01f, -2.84364633e-02f, -5.39392345e-02f,
  2.11934775e-01f, -1.83614805e-01f, 3.66111062e-02f, 2.92583287e-01f, -3.52470577e-01f, -2.62504146e-02f, 1.68963298e-01f, 4.32233334e-01f, 2.10766047e-01f, -4.07990634e-01f,
  -1.22272432e-01f, -2.31319562e-01f, -7.97313869e-01f, 4.31298651e-02f, 6.02432787e-01f, -9.88734186e-01f, 1.86955389e-02f, -1.01254821e+00f, 3.91168237e-01f, 2.06076488e-01f,
  -6.98074996e-02f, -9.69325542e-01f, 1.06411445e+00f, -4.26800214e-02f, 7.29480535e-02f, -7.47339129e-01f, -7.39471167e-02f, 3.03227492e-02f, -2.53803998e-01f, 1.74252763e-01f,
  4.02199119e-01f, 8.40676352e-02f, 2.91299164e-01f, -1.72575846e-01f, 2.90969051e-02f, 9.31881890e-02f, -1.98455676e-01f, -6.07558966e-01f, -1.14150532e-01f, 2.34975945e-02f,
  -1.80586353e-02f, -1.35451674e-01f, 2.83321552e-02f, 1.51121896e-02f, -6.66521341e-02f, -8.94330665e-02f, 1.20515801e-01f, 2.05354765e-02f, 7.09551051e-02f, -1.71507880e-01f,
  1.21093288e-01f, 1.87095612e-01f, 6.41400516e-02f, -3.91836129e-02f, -1.36128962e-01f, -4.23283547e-01f, -1.20184638e-01f, 8.39202777e-02f, -9.66329649e-02f, -2.83045709e-01f,
  -4.84400168e-02f, 1.30493656e-01f, 5.21247014e-02f, 5.49252108e-02f, 9.88058150e-02f, 1.35742053e-01f, -5.04380055e-02f, 7.99925625e-02f, -8.97059590e-02f, -1.35082901e-01f,
  1.41583845e-01f, -3.59974685e-04f, 2.58612961e-01f, -5.04935905e-03f, -3.32182199e-01f, 3.61971091e-03f, 3.61212082e-02f, -8.60737078e-03f, -7.21507445e-02f, 1.58703238e-01f,
  -7.24834949e-02f, -7.03810900e-02f, 1.46592781e-01f, 1.09265149e-01f, -2.75555905e-02f, -7.00388029e-02f, -1.93045020e-01f, 1.26536965e-01f, 1.41653031e-01f, -3.14127743e-01f,
  4.42018658e-02f, 4.31888908e-01f, 1.97451711e-01f, -2.89663732e-01f, 1.18681759e-01f, 1.03281334e-01f, 2.12211803e-01f, 1.60466880e-02f, -5.01186438e-02f, 8.49034712e-02f,
  -1.12630442e-01f, -4.86859530e-01f, -3.77624512e-01f, 1.89976051e-01f, -1.94470778e-01f, -7.63032511e-02f, -1.88755661e-01f, 1.58600897e-01f, -2.80501604e-01f, -1.51711494e-01f,
  2.64355659e-01f, 1.62754327e-01f, 1.14193812e-01f, -4.98970598e-02f, 2.78170973e-01f, -1.01574033e-01f, 1.88011453e-02f, -4.69869316e-01f, -4.55508903e-02f, -5.00032380e-02f,
  2.17037991e-01f, 1.99108109e-01f, -3.11673522e-01f, 9.71640721e-02f, -2.44950950e-02f, 4.24149603e-01f, -8.50477964e-02f, 1.51955068e-01f, -5.16590700e-02f, 2.28223681e-01f,
  6.72057718e-02f, 3.42436194e-01f, -5.93317270e-01f, 7.30894431e-02f, 1.86360165e-01f, 2.58753926e-01f, -3.37444782e-01f, -1.65195614e-01f, -1.42700970e-01f, -4.66595106e-02f,
  3.41142386e-01f, 5.41828275e-01f, -3.08193952e-01f, -6.86997950e-01f, -8.13491642e-01f, -1.23841238e+00f, 4.96262521e-01f, -3.90282482e-01f, -9.43290949e-01f, 6.52760804e-01f,
  -6.04056001e-01f, 3.73041928e-01f, -6.40910566e-01f, -2.25707784e-01f, -5.31717181e-01f, 2.05362156e-01f, -5.21572828e-01f, -3.59129131e-01f, -6.65337324e-01f, -4.43485528e-01f,
  -7.41192877e-01f, -1.00441778e+00f, 1.03906840e-02f, 2.42605999e-01f, -6.15425885e-01f, 2.25285545e-01f, -5.34616597e-02f, 3.10060158e-02f, -6.66609183e-02f, -6.40900806e-02f,
  -3.43176797e-02f, -3.03406846e-02f, -1.64906234e-01f, -2.52999306e-01f, 7.50940889e-02f, -4.34529893e-02f, 1.76919550e-02f, -7.30309784e-02f, -9.56247225e-02f, 9.68825724e-03f,
  -2.04531610e-01f, -1.23804277e-02f, 1.08866937e-01f, 1.41816810e-01f, 1.54764399e-01f, -1.64333910e-01f, -1.69754431e-01f, 1.45119438e-02f, -2.13066757e-01f, -1.69553619e-03f,
  -1.89328402e-01f, -2.62363348e-03f, -6.50196970e-02f, -1.12791136e-01f, -2.37088818e-02f, -1.17727585e-01f, -1.16359450e-01f, 1.01436824e-01f, -2.46266335e-01f, -3.68800871e-02f,
  -6.53885230e-02f, 2.19214614e-02f, 7.88283497e-02f, -1.37412816e-01f, -1.94246620e-01f, -1.28456742e-01f, -1.13753177e-01f, -1.52919784e-01f, -1.30712435e-01f, 2.65132971e-02f,
  5.53009324e-02f, -4.50490303e-02f, -1.15735576e-01f, -2.08217539e-02f, -5.26473150e-02f, 5.84919304e-02f, -4.34537083e-02f, -2.32479256e-02f, 8.28921795e-02f, 9.94120166e-02f,
  2.36341804e-01f, -1.08465247e-01f, 1.10426113e-01f, 2.17977744e-02f, 1.53163970e-01f, -1.00884356e-01f, 2.39615212e-03f, 1.46502823e-01f, -1.60625488e-01f, 2.38674700e-01f,
  -1.56778470e-01f, -3.86609398e-02f, -3.73747386e-02f, 2.15958208e-01f, 2.48212561e-01f, -8.62890482e-03f, -1.97567418e-01f, 2.06471026e-01f, -1.85604721e-01f, -1.91094950e-01f,
  9.41696241e-02f, -2.17354119e-01f, 4.61137779e-02f, 3.07550244e-02f, 8.51656944e-02f, -1.13008469e-01f, 1.43753216e-02f, 5.95886186e-02f, -7.55797029e-02f, -9.22646075e-02f,
  3.13180350e-02f, 1.47068193e-02f, -2.57386696e-02f, -3.93564664e-02f, -1.27379611e-01f, 1.71269044e-01f, -2.17762776e-02f, -1.22451931e-01f, -4.40574698e-02f, 1.69944540e-01f,
  -3.03883534e-02f, 8.70124772e-02f, -2.12947384e-01f, -5.47674038e-02f, -1.16710380e-01f, 1.36630446e-01f, -5.59052872e-03f, 8.85588974e-02f, -5.15334070e-01f, -8.15812767e-01f,
  7.47945547e-01f, -5.70431650e-01f, -3.65494490e-01f, 7.08693504e-01f, -4.25524056e-01f, 1.70315221e-01f, 3.87749374e-01f, 4.04999375e-01f, -3.97353508e-02f, -2.02161744e-02f,
  -1.98418066e-01f, -6.39868021e-01f, 5.86371869e-02f, -5.82332134e-01f, 6.83429316e-02f, -5.24539016e-02f, -6.74676239e-01f, -3.07315350e-01f, 6.00178182e-01f, -5.25452018e-01f,
  1.15208484e-01f, -4.60918516e-01f, -5.26258409e-01f, 4.07822356e-02f, -1.35872573e-01f, 2.20242426e-01f, -4.26365174e-02f, 6.38906136e-02f, -2.52286851e-01f, -2.30670348e-02f,
  1.16254739e-01f, -5.43791056e-02f, 1.97127536e-02f, 3.36650759e-02f, 1.70204908e-01f, 8.63221586e-02f, 1.85770243e-01f, -1.56919539e-01f, 7.03300014e-02f, -2.32034162e-01f,
  1.67393759e-01f, 9.02825743e-02f, -1.44705242e-02f, -1.35516852e-01f, -2.63246102e-03f, 8.34526867e-02f, -1.51237687e-02f, 7.07838684e-02f, 2.32011322e-02f, -3.59033570e-02f,
  -6.34502172e-02f, 4.64086905e-02f, 1.05109528e-01f, -6.55557588e-02f, 8.40922445e-02f, 2.17164546e-01f, 8.19280222e-02f, -5.66123985e-02f, -1.22782066e-01f, 7.58808330e-02f,
  -2.04312474e-01f, 2.45888028e-02f, -7.40005746e-02f, 1.97245717e-01f, 1.09491274e-01f, -1.55466333e-01f, 1.37616560e-01f, 8.66312310e-02f, -1.58502460e-01f, -1.10489933e-03f,
  8.79026111e-03f, -3.34893204e-02f, 7.64451921e-02f, 5.70504852e-02f, 6.60860911e-02f, 3.26026022e-01f, 5.70825189e-02f, 3.21763158e-01f, 2.57332046e-02f, -2.50442564e-01f,
  2.88686365e-01f, -1.37253508e-01f, -2.10021198e-01f, 6.75772429e-02f, -3.49123939e-03f, -6.94116112e-03f, -2.44936138e-01f, -2.57214755e-02f, -2.83766389e-01f, 1.44268215e-01f,
  3.03868711e-01f, 2.13761568e-01f, 3.83345336e-01f, -3.33143175e-01f, -2.12147623e-01f, 5.65810017e-02f, -9.22424123e-02f, 2.05899984e-01f, 2.42959782e-01f, 5.84759340e-02f,
  -2.17304975e-01f, 4.62356448e-01f, -6.13317490e-02f, 6.24280423e-03f, -1.48439482e-01f, 7.73569196e-02f, 1.62892923e-01f, -3.56826521e-02f, -4.00652736e-01f, -2.26006791e-01f,
  -2.39758436e-02f, 2.42937967e-01f, -2.27512106e-01f, -1.34681210e-01f, 9.44020674e-02f, 2.19699591e-01f, 2.30764285e-01f, -2.48505935e-01f, -2.98373908e-01f, -2.51072824e-01f,
  8.90950561e-02f, -1.54633045e-01f, -1.60012960e-01f, 2.49559373e-01f, -1.15382716e-01f, -1.32148981e-01f, -6.77492201e-01f, -4.61901575e-01f, -2.94661541e-02f, -4.00305778e-01f,
  -1.67368934e-01f, -2.66082793e-01f, -2.20561057e-01f, -1.68998852e-01f, 1.47645697e-01f, 1.01936936e-01f, -3.86019140e-01f, -6.09331191e-01f, -3.54564153e-02f, 8.04620087e-02f,
  2.70526379e-01f, 1.70078471e-01f, 1.61344767e-01f, 8.98949683e-01f, -6.75953925e-01f, -5.38581669e-01f, -2.48141915e-01f, -5.41858554e-01f, 9.79877543e-03f, 1.20121098e+00f,
  -2.90964663e-01f, 4.26706374e-02f, 1.37621939e-01f, 3.00675668e-02f, 2.07388833e-01f, 1.72222525e-01f, 1.53392151e-01f, -4.30428535e-02f, -1.85650699e-02f, -3.85075882e-02f,
  1.94990277e-01f, -2.69137770e-01f, -2.74809271e-01f, 2.17752740e-01f, -1.56876650e-02f, -2.78390441e-02f, -1.93257153e-01f, -1.05113424e-01f, -1.03706747e-01f, -3.04637700e-02f,
  -1.82743475e-01f, 1.41066134e-01f, -8.20309296e-02f, 3.10222238e-01f, 7.47130886e-02f, -3.82405333e-02f, -3.08665051e-03f, -3.00999992e-02f, -2.37632185e-01f, 5.37531497e-03f,
  2.92828321e-01f, -9.94207114e-02f, -4.39789481e-02f, 1.54597893e-01f, -3.38761657e-02f, 1.88639566e-01f, -4.48392808e-01f, -1.26027197e-01f, 7.47664869e-02f, -8.71042609e-02f,
  -2.30705261e-01f, 1.75408099e-03f, 1.50280446e-01f, -1.74246967e-01f, 1.65874690e-01f, 1.33107901e-01f, -6.90082684e-02f, 4.48343977e-02f, -1.41444936e-01f, -8.00237656e-02f,
  -1.85398936e-01f, -5.00908680e-02f, -6.93192184e-02f, 1.72096923e-01f, 1.62192658e-01f, -3.11973423e-01f, -8.16624016e-02f, 4.43449542e-02f, 4.01140004e-02f, -5.22178352e-01f,
  2.13715300e-01f, 1.79566920e-01f, -7.66243102e-05f, 3.24056655e-01f, -2.90002450e-02f, 7.10356593e-01f, 4.53355014e-01f, -2.75410950e-01f, -2.27467969e-01f, -8.90663564e-02f,
  -3.65280032e-01f, 2.11535126e-01f, 5.97118378e-01f, -1.37903959e-01f, -6.18422329e-02f, -1.50106056e-02f, 2.86193371e-01f, -9.89487618e-02f, -1.50296614e-01f, -4.95371729e-01f,
  8.60763192e-02f, 2.83670902e-01f, -2.14460522e-01f, -3.80476981e-01f, -2.53501415e-01f, -2.99833894e-01f, 4.17227507e-01f, 3.61907512e-01f, -4.79216546e-01f, -2.72108167e-01f,
  3.19409482e-02f, 2.25255713e-01f, 5.07358134e-01f, 1.93397835e-01f, -4.06448811e-01f, -5.63819468e-01f, 7.19244599e-01f, 1.57612666e-01f, -4.53081548e-01f, 2.57896990e-01f,
  3.92600834e-01f, -2.76443034e-01f, 3.98386210e-01f, -6.09466396e-02f, 3.83925468e-01f, 5.40980399e-01f, -7.74604023e-01f, -7.48254359e-01f, -1.29313946e-01f, 2.33851135e-01f,
  -5.03876448e-01f, 6.86124384e-01f, -2.56541669e-01f, -1.29120827e-01f, 1.45778045e-01f, -2.05237582e-01f, -5.76258004e-01f, -6.93917632e-01f, -1.87547684e-01f, 4.35846448e-01f,
  -5.06135046e-01f, -4.93169874e-01f, -2.74786830e-01f, -7.17365742e-01f, 4.45483208e-01f, -1.74929008e-01f, 2.24309504e-01f, -1.94079131e-01f, -3.35899591e-01f, 1.06047280e-01f,
  1.26679629e-01f, -9.64326262e-02f, -1.71860635e-01f, -3.70089374e-02f, -2.93801315e-02f, -9.60430205e-02f, -1.10296704e-01f, 3.52887586e-02f, 1.41090035e-01f, 8.30904767e-02f,
  7.03792879e-03f, 1.44572720e-01f, -5.03216349e-02f, 1.25293419e-01f, -1.59272440e-02f, 6.03061654e-02f, 4.55559604e-02f, 2.53221989e-01f, 4.44950256e-03f, 6.79757223e-02f,
  -6.30891994e-02f, -3.08258850e-02f, 8.45898762e-02f, 1.71431944e-01f, -8.62349272e-02f, -1.26187488e-01f, 1.04242384e-01f, 1.39743701e-01f, -6.79775998e-02f, 4.43581212e-03f,
  -2.71653622e-01f, 2.24041529e-02f, -1.00897253e-01f, -1.03711650e-01f, 4.73926552e-02f, 6.07237481e-02f, 7.14675710e-02f, 1.26812428e-01f, 1.91213205e-01f, 2.51910444e-02f,
  6.03421070e-02f, 9.43369567e-02f, 9.71002877e-02f, 3.05535039e-04f, 1.54324859e-01f, 3.99357229e-02f, -2.81695295e-02f, -2.20944062e-02f, 1.09491915e-01f, -2.52483904e-01f,
  8.28413665e-02f, -8.22956394e-03f, 1.72615051e-02f, -1.59082174e-01f, -2.74139285e-01f, 2.83389658e-01f, -1.44191578e-01f, 2.10954770e-01f, -2.86666304e-01f, 1.20217450e-01f,
  5.95057681e-02f, -2.70289540e-01f, 2.10701264e-02f, -3.29669118e-01f, -1.23568796e-01f, 1.44262731e-01f, 1.81870088e-01f, 2.13006571e-01f, 1.91734925e-01f, -9.48047638e-03f,
  6.27776533e-02f, -8.21687188e-03f, -1.65284142e-01f, -2.27369979e-01f, 2.03030661e-01f, 1.91552848e-01f, 1.85492083e-01f, -2.90408134e-02f, 2.38216698e-01f, 2.42102504e-01f,
  -4.77191396e-02f, 3.22340935e-01f, -1.13327622e-01f, 8.57511312e-02f, 3.27190995e-01f, -4.56651181e-01f, 1.62966549e-01f, -1.70196801e-01f, 1.81493640e-01f, -1.56186476e-01f,
  2.72567302e-01f, -1.52513042e-01f, 2.63636023e-01f, 1.78720772e-01f, 3.14256877e-01f, -8.56781453e-02f, -2.47469813e-01f, -2.40031958e-01f, -9.31790750e-03f, 1.48385808e-01f,
  -4.36239451e-01f, 2.21728876e-01f, -4.34967488e-01f, -2.18474269e-01f, -1.97106212e-01f, -3.49870741e-01f, 3.20516884e-01f, -7.15558171e-01f, -2.47416660e-01f, -3.97401899e-01f,
  7.38855302e-01f, -4.13461745e-01f, -5.72695792e-01f, -3.51906329e-01f, -1.85240656e-01f, 7.86862850e-01f, -1.67695612e-01f, -1.30472943e-01f, -7.55757630e-01f, 9.15292874e-02f,
  -7.52168655e-01f, -5.05683064e-01f, 1.06558228e+00f, 4.30954456e-01f, -5.13269961e-01f, -3.44359100e-01f, -4.03399915e-01f, -1.59289598e-01f, 2.16171682e-01f, -9.56601575e-02f,
  1.51994660e-01f, 9.82986540e-02f, 2.35578299e-01f, 1.13583393e-01f, 2.17818707e-01f, 9.24625769e-02f, -1.42488331e-01f, -1.82581358e-02f, -1.29451593e-02f, -2.37451419e-02f,
  -1.20934248e-01f, -7.35698119e-02f, 6.61690980e-02f, 1.58910736e-01f, -9.79151577e-02f, -1.21354118e-01f, -2.98757087e-02f, 2.29059905e-02f, -5.55103272e-02f, 1.53339431e-01f,
  1.17157727e-01f, -1.35221645e-01f, -4.90007736e-02f, -3.57670384e-03f, 1.57548100e-01f, -2.33897895e-01f, -2.59411395e-01f, 5.78571996e-03f, 1.84112117e-02f, 1.53397411e-01f,
  -1.35388076e-01f, -6.79081529e-02f, 1.98434517e-02f, -1.25344824e-02f, -6.09142371e-02f, -2.33689845e-02f, 3.26163955e-02f, 3.90612558e-02f, -2.73087859e-01f, 2.05930412e-01f,
  5.87105639e-02f, 1.15119317e-03f, 3.49745974e-02f, -3.05203944e-01f, 1.48134634e-01f, -1.28780464e-02f, 4.16790023e-02f, 8.02694708e-02f, -5.27734607e-02f, -1.45540461e-01f,
  -2.91363090e-01f, 2.68816594e-02f, -3.97378840e-02f, 1.36679918e-01f, -2.82103457e-02f, 1.58895001e-01f, -4.76775587e-01f, -2.73429573e-01f, -1.82903990e-01f, -5.16160488e-01f,
  -1.86039940e-01f, -5.48435152e-01f, -2.65845563e-02f, -2.59475764e-02f, 4.00789350e-01f, -2.44451389e-01f, -3.78253669e-01f, 1.72904059e-01f, 2.19643727e-01f, 1.69932321e-01f,
  8.02487060e-02f, -1.60716653e-01f, -3.86920810e-01f, -9.62510258e-02f, -1.47520751e-01f, 1.33261830e-01f, -3.81682903e-01f, -2.08525807e-01f, -7.39494637e-02f, -2.26972327e-01f,
  2.79307533e-02f, -1.76812157e-01f, 4.22930300e-01f, -5.76154947e-01f, -2.84344196e-01f, 1.70162514e-01f, -2.85627563e-02f, -1.87039927e-01f, -2.70859957e-01f, 1.34262413e-01f,
  2.18450680e-01f, -2.70814478e-01f, -3.21324587e-01f, 1.97255269e-01f, 2.32851267e-01f, 2.48019263e-01f, -1.38473153e-01f, 3.29172939e-01f, 7.84845427e-02f, -1.10116981e-01f,
  7.47097850e-01f, -6.06132746e-01f, 1.04560047e-01f, -5.64684629e-01f, 4.35056388e-01f, 5.76139927e-01f, 3.64558458e-01f, -4.32433218e-01f, 1.03121363e-01f, -2.60459960e-01f,
  -4.19171065e-01f, 7.44726807e-02f, 4.80301440e-01f, -4.48362291e-01f, -2.77973711e-01f, -7.62305558e-02f, 4.29892063e-01f, -4.00146306e-01f, -7.75827050e-01f, -5.82266748e-01f,
  -7.14051843e-01f, -4.44397539e-01f, -9.63306248e-01f, -5.75701036e-02f, 1.33024827e-01f, -2.81806812e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.35413998e-01f, -3.23298760e-02f, 2.82093048e-01f, -2.30719537e-01f, -2.24541366e-01f, 4.93621593e-03f, 7.09623396e-02f, -9.34109390e-02f, -1.36134297e-01f, 4.11702424e-01f,
  1.85924873e-01f, 9.25333500e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    