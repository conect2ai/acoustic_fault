/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.07897604e-01f, 6.06045201e-02f, -2.06974030e-01f, -3.36362928e-01f, -1.98133558e-01f, 4.89015728e-01f, 2.52119713e-02f, -5.48565947e-02f, -2.08624139e-01f, 2.50047654e-01f,
  1.50154099e-01f, -1.96679682e-01f, 2.53828049e-01f, 4.06328851e-04f, -2.67212629e-01f, 2.12272897e-01f, 6.66973591e-02f, 3.55473682e-02f, -7.66819865e-02f, 1.02846720e-03f,
  -1.70732498e-01f, 2.00716570e-01f, -1.66263059e-01f, 2.05166340e-02f, -6.19032606e-02f, -2.98501134e-01f, -1.38756409e-01f, -2.92950477e-02f, -9.71541554e-02f, -4.89927456e-02f,
  -1.27890278e-02f, 1.37777746e-01f, -1.27547264e-01f, -1.14058536e-02f, 1.95995253e-02f, -2.72009876e-02f, -4.44699377e-02f, 5.08154184e-03f, -1.22006414e-02f, -7.21385777e-02f,
  2.53532287e-02f, 5.18841520e-02f, -1.24619231e-02f, -5.20756990e-02f, -8.23469162e-02f, 1.60488542e-02f, 3.98494536e-03f, 3.38927992e-02f, -5.80353439e-02f, -7.68954959e-03f,
  -1.52864810e-02f, -8.32350552e-02f, -3.13394666e-02f, -2.56153662e-02f, -7.23019168e-02f, -2.41504703e-02f, 1.70941893e-02f, 2.38589570e-02f, 4.05272022e-02f, -3.12303603e-02f,
  2.18980107e-02f, -7.31519097e-03f, 3.87495682e-02f, 3.71202640e-03f, 3.10285063e-03f, -2.07695886e-02f, 7.25607562e-04f, 5.30093163e-02f, -6.46964386e-02f, 9.83127803e-02f,
  2.09892094e-02f, -1.08176664e-01f, 4.62628305e-02f, -4.78113778e-02f, -5.94892120e-03f, 4.87325080e-02f, 2.47413088e-02f, 2.16505565e-02f, 3.19844931e-02f, -9.02580097e-02f,
  -3.70189138e-02f, -2.45714635e-02f, 7.61010498e-02f, -4.84887287e-02f, 5.99458553e-02f, 6.99415850e-03f, -2.82576066e-02f, -1.23584373e-02f, -2.30652262e-02f, 6.49013743e-02f,
  1.30551025e-01f, 1.20859265e-01f, 6.34625480e-02f, -5.71191981e-02f, -1.14138657e-02f, 7.40161389e-02f, -3.55796814e-02f, -3.24579515e-02f, -1.06564583e-02f, 9.29309502e-02f,
  2.26510931e-02f, -5.93176372e-02f, 3.43290679e-02f, 3.89985591e-02f, 3.94812711e-02f, -1.83843952e-02f, -7.18573434e-03f, -2.75820252e-02f, 3.15174013e-02f, -2.41005551e-02f,
  7.64885312e-03f, 9.23370197e-02f, -3.11655877e-03f, -1.35216885e-03f, -3.19257379e-02f, 1.05067678e-01f, -5.09035997e-02f, -4.05750684e-02f, 2.05711201e-02f, 2.96677127e-02f,
  6.62488818e-01f, 3.11160415e-01f, 9.65995714e-02f, 1.87435523e-01f, -6.33973777e-02f, 1.38078883e-01f, 5.00384688e-01f, -1.44083947e-01f, 1.58803448e-01f, 1.63731754e-01f,
  -1.11939788e-01f, 2.62463778e-01f, 2.41897404e-01f, 2.17906743e-01f, 3.44978064e-01f, 1.33631527e-01f, 2.32621938e-01f, 1.52273819e-01f, -4.84017022e-02f, 1.03211366e-01f,
  6.86731339e-02f, 1.54024750e-01f, 4.50667590e-02f, -1.61732122e-01f, 1.53752733e-02f, -2.17909560e-01f, 2.32003853e-02f, -1.44980401e-01f, -3.37005928e-02f, -8.21572356e-03f,
  -4.60508019e-02f, -1.23522945e-01f, -1.13713697e-01f, 5.94613887e-02f, 9.42163449e-03f, 2.85207573e-02f, 5.09130768e-02f, -3.90367582e-02f, -5.06460816e-02f, -4.43472564e-02f,
  1.45871332e-02f, -3.38385031e-02f, 6.12011999e-02f, -5.57050481e-02f, -4.10897918e-02f, -1.02934308e-01f, -9.29368064e-02f, -3.02977599e-02f, 4.56323288e-02f, 1.72744971e-02f,
  -1.31848171e-01f, -6.54966906e-02f, 1.40980873e-02f, 7.44589120e-02f, -2.99964063e-02f, 5.27097695e-02f, 5.28382026e-02f, -9.41491686e-03f, -1.96109380e-04f, -1.37676038e-02f,
  -1.24774471e-01f, 5.32134324e-02f, -5.49303666e-02f, -4.78497148e-02f, -4.80081253e-02f, -2.40137763e-02f, -6.26898482e-02f, -6.78665820e-04f, 4.37173881e-02f, 2.91182986e-03f,
  2.53717043e-02f, 2.13184319e-02f, -4.01768163e-02f, 2.21149549e-02f, 5.54514267e-02f, -9.25242677e-02f, 5.13101295e-02f, 2.71535218e-02f, 2.73769405e-02f, -2.17102561e-02f,
  7.38765905e-03f, 7.91375041e-02f, 1.34898229e-02f, 8.62353295e-03f, 2.94324905e-02f, 2.95427125e-02f, 3.18916328e-02f, -4.99113426e-02f, -4.35562618e-02f, 3.99043187e-02f,
  4.53941643e-01f, 3.95626187e-01f, 1.20351128e-02f, 5.57471393e-03f, 5.49508221e-02f, -7.98151270e-02f, -2.58515459e-02f, -4.08919640e-02f, 1.49033263e-01f, 8.59045237e-02f,
  -2.02901871e-03f, 6.88566938e-02f, -2.11472251e-02f, 3.19625363e-02f, 8.45037997e-02f, 4.95341457e-02f, 1.04708962e-01f, 5.70625514e-02f, 3.82962334e-03f, 2.71902494e-02f,
  4.02795747e-02f, -3.43702361e-02f, -7.15504363e-02f, -3.34835239e-02f, 4.21195552e-02f, -8.04461315e-02f, 2.79539917e-02f, -4.36185449e-02f, -5.87556977e-03f, 1.18279465e-01f,
  -2.04575822e-01f, -5.51021278e-01f, -5.47926545e-01f, -9.68001261e-02f, 1.22079186e-01f, 1.41992746e-02f, 3.32483649e-02f, -2.18057573e-01f, -8.95281881e-02f, -2.73667220e-02f,
  8.02378207e-02f, -1.81605041e-01f, 3.04143652e-02f, -1.90198213e-01f, 1.93636082e-02f, -3.45315747e-02f, -6.32774606e-02f, 5.48389368e-02f, -3.64322886e-02f, -9.18850079e-02f,
  -1.42719252e-02f, 1.37731135e-01f, -2.40350649e-01f, -4.13865708e-02f, -1.24194190e-01f, -1.21464677e-01f, 8.67322236e-02f, -7.37194642e-02f, -8.05357657e-03f, 6.70443922e-02f,
  -4.92643975e-02f, -1.85787026e-02f, -1.59388304e-01f, -4.62097973e-02f, -5.27158789e-02f, 1.28450885e-01f, 4.13307808e-02f, 1.21342771e-01f, -1.83577072e-02f, 4.79306141e-03f,
  9.31719095e-02f, 5.95608875e-02f, -3.93736362e-02f, 5.28343953e-02f, -5.74725382e-02f, -1.26037508e-01f, -1.07813835e-01f, -4.82750237e-02f, -1.29587263e-01f, -4.21764664e-02f,
  -4.97643724e-02f, -1.30603630e-02f, 3.68069559e-02f, 2.83464994e-02f, -1.00539975e-01f, -2.67673619e-02f, 4.51534130e-02f, 1.79601032e-02f, 3.18334624e-03f, 4.10295576e-02f,
  1.12370171e-01f, 6.66175634e-02f, -9.26121045e-03f, 5.50752180e-03f, -3.45966369e-02f, 4.76055667e-02f, 6.12082109e-02f, 4.63514365e-02f, 1.70519836e-02f, -1.70746408e-02f,
  4.77748215e-02f, -7.39550823e-03f, 1.38717089e-02f, -2.86884625e-02f, 2.27724644e-03f, 6.07617833e-02f, 3.42399837e-03f, 6.36336301e-03f, 4.04332988e-02f, -2.92628855e-02f,
  2.32558399e-02f, 3.86420339e-02f, -5.30031435e-02f, 6.96523488e-02f, 3.82404216e-02f, -9.82217956e-03f, 8.47657993e-02f, -3.13559510e-02f, -3.58543955e-02f, 6.68032691e-02f,
  1.16731025e-01f, -1.72304824e-01f, -4.96538728e-02f, 5.46370000e-02f, -3.58111486e-02f, -1.86481941e-02f, -2.85294503e-02f, -9.08070207e-02f, -3.40138003e-02f, -9.25612915e-03f,
  1.02793150e-01f, -1.44345136e-02f, 6.88233823e-02f, 4.83288057e-03f, 6.72339574e-02f, 6.51037991e-02f, 1.37723595e-01f, 4.42245156e-02f, 5.49547225e-02f, -2.82623153e-02f,
  1.52309323e-02f, 6.30656853e-02f, 1.06504085e-02f, 2.11485494e-02f, 1.08113892e-01f, 9.41637009e-02f, 2.39642896e-02f, 1.25481130e-03f, 7.03265443e-02f, 1.24683017e-02f,
  6.87818050e-01f, -7.32848644e-02f, 3.86255324e-01f, -8.99912789e-02f, 4.83069196e-02f, -3.33769768e-01f, -3.91198620e-02f, -3.67287919e-02f, -2.22497135e-02f, -6.38913289e-02f,
  5.01498207e-02f, 1.49537146e-01f, 2.01205522e-01f, -1.81518868e-01f, 1.53933605e-02f, -1.00356832e-01f, -6.78716153e-02f, 1.47115648e-01f, -1.90581992e-01f, 1.24133758e-01f,
  5.61640859e-02f, -4.37283099e-01f, 1.51539221e-01f, -1.85054511e-01f, 6.70816600e-02f, -2.24775262e-02f, 8.11978951e-02f, -7.73667265e-03f, 9.77418795e-02f, -5.86037040e-02f,
  -1.50393143e-01f, 1.83798894e-01f, 5.40375896e-02f, 8.71025845e-02f, 9.35217068e-02f, 1.44644603e-01f, 3.50669995e-02f, 4.31777686e-02f, 1.10152541e-02f, 6.53543230e-03f,
  8.57065395e-02f, -3.68656963e-02f, -6.88719079e-02f, -2.00608801e-02f, -3.17221507e-03f, 1.06827334e-01f, -8.65826011e-02f, -7.86719322e-02f, 3.13915648e-02f, -3.71870324e-02f,
  -2.10966058e-02f, 1.17328847e-02f, 3.18021886e-02f, 2.52748411e-02f, 5.38093112e-02f, -4.03559990e-02f, 2.42665429e-02f, 7.49721006e-02f, 1.00925408e-01f, -6.87715784e-02f,
  -2.51228325e-02f, 3.34687941e-02f, -5.50994873e-02f, -3.80259968e-04f, 2.73062959e-02f, -8.82907305e-03f, -1.22883106e-02f, 3.54478024e-02f, -2.93594785e-02f, -1.00236489e-02f,
  -4.08390388e-02f, 3.31291854e-02f, 4.18919921e-02f, -4.68484089e-02f, 3.74140292e-02f, -6.83637485e-02f, 6.54563354e-03f, -8.61386359e-02f, -8.80779326e-03f, -2.54455432e-02f,
  -6.67074472e-02f, -3.90862152e-02f, 3.79476622e-02f, 5.01879938e-02f, -1.08733639e-01f, 4.80609871e-02f, 5.56063838e-02f, 2.68044788e-02f, -3.16736773e-02f, 3.51688601e-02f,
  1.43653914e-01f, 3.95584732e-01f, -1.08366519e-01f, -9.40756276e-02f, -3.50512564e-02f, -1.66759685e-01f, 9.13102087e-03f, -3.65901850e-02f, -9.30278376e-02f, -7.32835457e-02f,
  -1.87141150e-02f, 5.12836576e-02f, 6.73218518e-02f, 1.97580433e-03f, -6.98968098e-02f, -1.11646943e-01f, 6.42007291e-02f, 6.26526698e-02f, 4.34330739e-02f, -1.11188814e-02f,
  5.03176004e-02f, 6.25307187e-02f, -2.03422327e-02f, 5.89196989e-03f, -3.61456387e-02f, -5.96201941e-02f, 6.22630566e-02f, -1.46694463e-02f, 3.18178125e-02f, 5.18899448e-02f,
  1.40059322e-01f, 9.33038071e-02f, -1.96681187e-01f, 2.76947111e-01f, 1.53696418e-01f, 4.73852456e-01f, 3.89766008e-01f, 1.34291396e-01f, 2.98112661e-01f, 1.44048855e-01f,
  3.14973593e-01f, 1.25626937e-01f, 3.41977435e-03f, 4.89148885e-01f, 6.83383942e-02f, 2.07781225e-01f, 1.68746650e-01f, 1.64203852e-01f, -3.75417061e-02f, 1.21458322e-01f,
  -7.26571977e-02f, 2.90913582e-01f, 8.24819058e-02f, -3.29587422e-02f, 1.61381230e-01f, -1.19076118e-01f, -1.11535497e-01f, -1.13524526e-01f, 3.26210074e-02f, 7.46837351e-03f,
  -7.75735676e-02f, 1.56135455e-01f, 3.89885120e-02f, -2.79768091e-03f, 8.12278166e-02f, -7.04054311e-02f, -5.96755296e-02f, -1.03640057e-01f, 8.04646835e-02f, 7.20074177e-02f,
  3.18650529e-02f, -1.05527751e-01f, 3.49143073e-02f, -9.82856303e-02f, 4.38376479e-02f, 1.06434133e-02f, -2.71589332e-03f, -2.48062946e-02f, 4.59317714e-02f, -5.30355684e-02f,
  -5.72088454e-03f, -2.24983525e-02f, 6.99844584e-02f, 2.70436741e-02f, -1.75659433e-02f, 3.61697213e-03f, -1.44722406e-02f, -4.92876507e-02f, 6.79545254e-02f, -1.65960304e-02f,
  -7.25677907e-02f, -1.15868308e-01f, -2.05111559e-02f, 1.26202255e-02f, -5.27985096e-02f, -1.05364935e-03f, 2.28735134e-02f, -2.20093410e-02f, -3.24245580e-02f, 2.37397812e-02f,
  6.89919591e-02f, 6.06579334e-02f, -1.28655266e-02f, 5.70630059e-02f, 7.22863823e-02f, 2.38567814e-02f, 6.71856850e-03f, -7.00355172e-02f, 9.86468121e-02f, 5.85340932e-02f,
  1.87084358e-02f, -7.09907487e-02f, 4.97249775e-02f, -1.07126394e-02f, 3.98407392e-02f, -8.56996700e-02f, -3.41088474e-02f, -3.55597883e-02f, 1.62633806e-02f, -3.37974057e-02f,
  1.11969247e-01f, -2.53670663e-01f, 2.70283618e-03f, 1.10300764e-01f, 7.91882572e-04f, -3.36818993e-02f, 8.25703815e-02f, 2.17095222e-02f, -1.83645803e-02f, -7.70452991e-02f,
  -8.47029239e-02f, 6.56898543e-02f, -3.01259048e-02f, 1.12221271e-01f, -6.55550957e-02f, -5.48256189e-02f, -4.59172018e-02f, -2.26272773e-02f, 2.37302575e-02f, 2.94983033e-02f,
  -2.33899225e-02f, -3.67909321e-03f, -3.72503549e-02f, 3.72915231e-02f, 4.03327905e-02f, 9.74779762e-03f, -5.92195317e-02f, -1.33316789e-03f, -9.81676877e-02f, 3.42924707e-02f,
  -6.19618416e-01f, 1.93937078e-01f, 8.62843394e-02f, -3.06382477e-01f, -2.59198666e-01f, -1.64551049e-01f, 1.20574236e-03f, -8.03773999e-02f, -7.06247985e-02f, 3.11320424e-01f,
  -2.51339972e-02f, 1.55835733e-01f, 1.12446070e-01f, -2.71693747e-02f, -6.06721401e-01f, 1.97248235e-01f, -2.16147199e-01f, 9.12837535e-02f, -9.88876671e-02f, -1.37496084e-01f,
  -1.76882982e-01f, -1.89177543e-01f, -8.88521448e-02f, 5.14033101e-02f, -9.94122252e-02f, 1.13539532e-01f, -1.63174078e-01f, 1.96442485e-01f, -1.26242384e-01f, 4.54784371e-02f,
  2.09585186e-02f, 6.40988126e-02f, -7.23852739e-02f, 8.07628855e-02f, -2.95647066e-02f, -4.19410225e-03f, 2.54184939e-02f, 1.02613322e-01f, -1.51757732e-01f, 2.17162911e-02f,
  4.16646525e-02f, -4.84063178e-02f, -4.88857739e-02f, -3.20171788e-02f, -3.31279673e-02f, -5.89058473e-05f, -1.14806727e-01f, -6.26384541e-02f, 1.16539322e-01f, -5.87507710e-02f,
  7.16663525e-03f, -1.41993975e-02f, -5.28615452e-02f, 2.42964234e-02f, -2.45959591e-03f, 4.30710502e-02f, 5.76109588e-02f, 7.94903487e-02f, 1.06904302e-02f, -2.76732855e-02f,
  3.95820738e-04f, -2.89763268e-02f, 3.80715318e-02f, -2.55062226e-02f, -6.09793067e-02f, -4.46277075e-02f, -3.73967886e-02f, 1.80345017e-03f, 1.23544885e-02f, -5.84045574e-02f,
  3.52625512e-02f, -4.08966132e-02f, -2.58173775e-02f, -1.27632068e-02f, -5.72856739e-02f, -1.64995417e-02f, -1.15378089e-02f, 1.08206727e-01f, -1.74077544e-02f, -7.19095916e-02f,
  7.81373829e-02f, -1.16789259e-03f, 5.24020195e-02f, -1.21999439e-02f, 5.21512842e-03f, -8.45615938e-02f, 3.00442632e-02f, 4.06327024e-02f, 2.04943642e-02f, -6.69727623e-02f,
  1.12461625e-02f, 1.69661313e-01f, 1.49528041e-01f, -1.65555961e-02f, 8.07033181e-02f, 3.25798914e-02f, -6.16209283e-02f, -7.53020048e-02f, 1.61359906e-01f, -6.33822978e-02f,
  -4.58276086e-02f, 5.11480495e-02f, 9.19745490e-03f, -2.47023664e-02f, -4.86856103e-02f, -2.46595163e-02f, 1.24195203e-01f, 7.05364719e-02f, -7.43026659e-02f, 3.23983915e-02f,
  1.26825906e-02f, 6.91728340e-03f, -2.68402677e-02f, -5.38955666e-02f, -7.76028112e-02f, 6.21274067e-03f, -1.26223937e-01f, -1.78793957e-03f, 7.01758731e-03f, 2.38887202e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.04420471e-01f, -7.74754107e-01f, 1.21762538e+00f, -5.80127120e-01f, 3.46303314e-01f, 9.87357616e-01f, 9.33979928e-01f, -9.13766846e-02f, 1.20810479e-01f, -8.96528065e-01f,
  -5.10759532e-01f, -3.47328424e-01f, 3.39629889e-01f, -4.72354680e-01f, 1.76438940e+00f, 8.97385001e-01f, 2.96068996e-01f, -7.92503729e-02f, 2.83681273e-01f, -5.44137597e-01f,
  1.19114444e-01f, -3.35937917e-01f, 5.15460253e-01f, -5.86583376e-01f, -3.79530817e-01f, -3.57402831e-01f, -4.47064608e-01f, 3.89011055e-01f, -6.46934211e-01f, 3.62575442e-01f,
  -1.48130789e-01f, -7.14122415e-01f, -4.28774744e-01f, -3.04031540e-02f, 8.90458375e-02f, 1.19837523e-01f, 1.15361042e-01f, 4.91011530e-01f, 8.44399557e-02f, 8.10275823e-02f,
  -1.28912464e-01f, 5.65824211e-02f, -2.91568935e-01f, -3.91927399e-02f, -1.20294124e-01f, -1.20023549e-01f, 1.04683988e-01f, -1.52492344e-01f, 5.42791784e-02f, 2.37711146e-01f,
  5.61669059e-02f, 1.11407340e-01f, 4.28586314e-03f, 1.26699045e-01f, 7.67968073e-02f, -3.01480908e-02f, 2.34075442e-01f, 2.82896131e-01f, -1.30442083e-01f, -1.32801145e-01f,
  -2.72628572e-02f, 8.45040157e-02f, -4.60314564e-02f, -2.40489960e-01f, -9.44387019e-02f, -1.48921847e-01f, -6.82806820e-02f, -3.57363150e-02f, 1.39853403e-01f, -1.48075065e-02f,
  4.10425616e-03f, -1.51028112e-01f, -3.54829896e-03f, 5.69602987e-03f, -9.98818353e-02f, -2.90470570e-01f, -1.59287229e-01f, -1.34561852e-01f, 4.65828702e-02f, 6.05147332e-02f,
  -4.07652333e-02f, 2.02058524e-01f, -2.63994902e-01f, -1.70075484e-02f, 3.91848907e-02f, 9.12039727e-02f, -1.57958835e-01f, 1.86397880e-01f, -1.37544200e-01f, 1.48975924e-01f,
  -3.96426708e-01f, -3.78376216e-01f, -3.18942964e-01f, -2.64384776e-01f, 5.67398407e-03f, -1.90481365e-01f, 1.04483828e-01f, -2.00871199e-01f, 1.77990749e-01f, -1.33385211e-01f,
  -6.04224280e-02f, -9.88326222e-02f, 8.63294676e-02f, -4.54114750e-02f, 8.48179124e-03f, 8.01135451e-02f, -1.67899922e-01f, -1.89183116e-01f, -2.83078074e-01f, -2.29939654e-01f,
  -4.28149074e-01f, -1.33885458e-01f, 2.76528984e-01f, -2.53910840e-01f, -2.72009104e-01f, -1.22955060e-02f, -4.42739204e-02f, -1.14013581e-02f, 1.63946934e-02f, 1.89659819e-01f,
  -1.97847462e+00f, 5.23329794e-01f, -4.54843014e-01f, -6.14958286e-01f, -7.65560985e-01f, -9.48064208e-01f, -4.86748815e-01f, -3.01282573e-02f, 2.17721358e-01f, 7.02541888e-01f,
  -5.11598110e-01f, 2.03591481e-01f, 5.01069129e-01f, -2.68795997e-01f, -6.20298266e-01f, 1.20925999e+00f, -5.57957172e-01f, 1.45291552e-01f, 3.49526972e-01f, -4.78920907e-01f,
  -4.67344999e-01f, -5.58639169e-01f, -1.98566034e-01f, -2.52454251e-01f, -1.14850676e+00f, -2.05775797e-01f, -4.42098677e-01f, -3.66995752e-01f, -4.02977824e-01f, -1.76478505e-01f,
  -8.62257540e-01f, -1.03854626e-01f, -2.16296121e-01f, 9.36020911e-02f, -2.64830947e-01f, -3.79180640e-01f, -1.56562492e-01f, -1.52956113e-01f, -6.13883790e-03f, -7.16988975e-03f,
  9.76006165e-02f, -4.96078692e-02f, -1.27179578e-01f, -1.33751072e-02f, -1.03860870e-01f, 3.81241292e-02f, 1.01163723e-01f, -1.85500562e-01f, 1.74407408e-01f, 2.30815113e-01f,
  2.15700231e-02f, 5.48796654e-02f, -5.00065722e-02f, 1.96696490e-01f, -2.05739528e-01f, 1.61815118e-02f, -3.21124345e-02f, -1.59541387e-02f, -2.00582877e-01f, -2.36831993e-01f,
  4.34217714e-02f, -1.70048401e-01f, 8.62940699e-02f, -2.10931189e-02f, 3.15082669e-02f, 3.72194313e-02f, 1.18880831e-02f, 4.26096730e-02f, 3.26498598e-02f, -1.79658741e-01f,
  -2.22867399e-01f, -2.11882144e-02f, -5.23990206e-02f, -3.91344205e-02f, -1.06619082e-01f, 6.71004876e-02f, 1.32511556e-01f, -1.67230144e-01f, 2.10905209e-01f, 1.17865147e-03f,
  5.25393374e-02f, 1.41873844e-02f, 8.76545534e-02f, -7.90615454e-02f, -9.51546207e-02f, 1.49900481e-01f, -7.10253567e-02f, 7.22957328e-02f, -3.23023051e-02f, -2.22549662e-01f,
  -1.11279058e+00f, -8.84189665e-01f, -1.94554731e-01f, -9.79137123e-02f, 1.20308138e-02f, -3.10559422e-01f, 1.91671044e-01f, -2.08442837e-01f, -1.10744447e-01f, -1.84137255e-01f,
  -2.82933861e-01f, 1.31300718e-01f, -4.08357292e-01f, -1.51587799e-01f, 8.22575837e-02f, -8.40046108e-02f, -1.56517208e-01f, -6.00396246e-02f, -4.74670082e-01f, -2.93913692e-01f,
  -3.12429726e-01f, 7.44864643e-02f, 6.60990626e-02f, 2.04826482e-02f, 1.13169767e-01f, -2.37216473e-01f, 1.32018942e-02f, 3.06944866e-02f, -1.52271897e-01f, 1.83688745e-01f,
  1.12876177e+00f, 3.66756529e-01f, 2.17252180e-01f, 6.96188748e-01f, 4.51097488e-01f, 5.81620514e-01f, 1.02752045e-01f, 7.19740093e-01f, 1.53651404e+00f, 8.37666765e-02f,
  -4.59601849e-01f, 1.71415180e-01f, -8.02635670e-01f, 4.12659682e-02f, -8.78930807e-01f, -2.54801482e-01f, 4.73419160e-01f, 3.09315145e-01f, 7.11261034e-01f, 3.98763776e-01f,
  2.77478874e-01f, -4.36480999e-01f, -7.91033089e-01f, -2.26275042e-01f, 2.33462021e-01f, 4.55991089e-01f, -9.51375544e-01f, -2.95675695e-01f, -1.79258496e-01f, -2.27139682e-01f,
  -1.03850402e-01f, 2.83889967e-04f, -1.02342337e-01f, 2.13782534e-01f, 1.43029571e-01f, 2.40046337e-01f, -6.19578771e-02f, -2.22417548e-01f, -6.96039572e-02f, 1.26347542e-01f,
  7.66892433e-02f, -1.21059641e-01f, 1.15443446e-01f, -1.04260355e-01f, 2.74634808e-01f, 1.99612334e-01f, 1.79735959e-01f, 1.94317073e-01f, 1.63405031e-01f, 1.61370665e-01f,
  8.08539689e-02f, -2.44229790e-02f, 1.46872133e-01f, 1.07314378e-01f, -1.62691817e-01f, 2.09384888e-01f, 1.32680982e-01f, 3.01833265e-03f, 1.23342769e-02f, 1.39991879e-01f,
  1.29296243e-01f, 1.86300352e-01f, -2.49929223e-02f, -1.33346975e-01f, -7.15421587e-02f, 8.67415816e-02f, -9.21589658e-02f, -1.27492860e-01f, 1.36905402e-01f, -1.23010002e-01f,
  1.58975124e-01f, -1.40400520e-02f, 3.44631337e-02f, 1.73614174e-01f, -4.06056717e-02f, 1.49896085e-01f, -2.86853373e-01f, 8.65740702e-02f, 8.91306251e-02f, -2.41309982e-02f,
  -5.62618747e-02f, 3.26590352e-02f, -2.63656676e-01f, 1.86357964e-02f, 2.38052867e-02f, -1.01050541e-01f, 2.90834963e-01f, 1.34221002e-01f, -2.21791491e-02f, -1.05461694e-01f,
  2.85059512e-01f, 3.56567264e-01f, -2.67843544e-01f, -1.71921536e-01f, -8.76817852e-02f, -1.50393188e-01f, 2.30916843e-01f, 2.18935296e-01f, 1.55351683e-01f, 1.30201831e-01f,
  2.58171320e-01f, 2.60735285e-02f, 2.18944073e-01f, -2.78183445e-02f, -3.27140391e-02f, 1.03064269e-01f, -1.25711411e-01f, -1.93177927e-02f, -2.10118681e-01f, -1.92857236e-01f,
  -6.15323596e-02f, 3.53426486e-03f, 7.02041164e-02f, 1.20370425e-01f, 4.16960679e-02f, -1.23874292e-01f, 2.95625329e-01f, -3.28437015e-02f, -1.49359465e-01f, 1.99572504e-01f,
  8.83432105e-03f, 2.19292268e-01f, -5.63963354e-01f, 7.41518149e-03f, -4.33973342e-01f, 3.19287837e-01f, -2.09258184e-01f, 3.79647881e-01f, -5.67807555e-01f, 6.23368025e-01f,
  7.60104179e-01f, -5.38901627e-01f, -1.70398131e-01f, 1.08310807e+00f, 4.62558836e-01f, 2.16924399e-01f, 1.22602260e+00f, 8.20140958e-01f, 1.09181084e-01f, 5.41321874e-01f,
  3.92829448e-01f, 1.05987859e+00f, 4.02940750e-01f, 8.78970802e-01f, 2.02503912e-02f, 9.81709436e-02f, 5.92822015e-01f, 1.29587650e-01f, 1.36505413e+00f, 3.58157963e-01f,
  1.32841608e-02f, -2.06107914e-01f, -2.73153335e-01f, 3.15497071e-02f, 1.94947541e-01f, 2.98271120e-01f, 1.20261222e-01f, -1.95007116e-01f, -9.73937958e-02f, 1.58619583e-01f,
  -3.14859241e-01f, -2.40749493e-02f, 6.73221648e-02f, -1.96930483e-01f, -4.96176593e-02f, -1.60971344e-01f, -1.75778583e-01f, -6.70849085e-02f, -2.00656161e-01f, -2.55730987e-01f,
  -2.86810070e-01f, 7.35611245e-02f, -2.04724893e-02f, 2.48999000e-01f, -1.50268972e-01f, 2.44437959e-02f, 4.67490442e-02f, 4.84888889e-02f, -1.30549118e-01f, 6.35483041e-02f,
  3.55252236e-01f, 8.46013650e-02f, 9.83115137e-02f, 2.01967452e-03f, -9.70691219e-02f, 5.18905222e-02f, 1.91007376e-01f, 6.75865039e-02f, -1.07985422e-01f, 1.79533318e-01f,
  1.42156303e-01f, -1.57393262e-01f, -4.03870754e-02f, 8.72486383e-02f, -1.54543214e-03f, -1.59465745e-02f, -2.28670165e-01f, 1.80542931e-01f, -1.13678329e-01f, 5.31831905e-02f,
  -5.47215492e-02f, 4.45248075e-02f, 3.91238090e-03f, 2.50570327e-02f, -1.02339312e-01f, -1.16476111e-01f, 2.69848526e-01f, 9.62014720e-02f, -8.79277363e-02f, -3.05530224e-02f,
  2.68768251e-01f, 8.73209238e-01f, -3.41946721e-01f, -1.84741527e-01f, 2.32754294e-02f, -4.34114859e-02f, 9.48351845e-02f, 1.38734102e-01f, 2.55809367e-01f, 5.37690558e-02f,
  2.72528291e-01f, -6.34020939e-02f, 2.14442089e-01f, -2.10119322e-01f, 1.23549633e-01f, 3.23852837e-01f, 1.95884049e-01f, -8.86418074e-02f, 1.47628546e-01f, 2.48248011e-01f,
  -3.74015830e-02f, 7.91626144e-03f, 1.18126357e-02f, -3.07825774e-01f, -2.20775511e-03f, -1.01038273e-02f, -1.04156844e-01f, -1.56431749e-01f, 1.91963375e-01f, 2.02002481e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.53085625e+00f, 9.17790055e-01f, 1.35386932e+00f, 1.41893733e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.82152712e+00f, 6.61567688e-01f, -9.91021097e-02f, -1.59290195e+00f, -1.09098971e+00f, 4.80901778e-01f, 8.70494008e-01f, 1.66470802e+00f, 4.18346614e-01f, -1.02709031e+00f,
  1.99145544e+00f, 1.55045819e+00f, -3.62375766e-01f, 5.78029037e-01f, -1.75232685e+00f, 3.80862921e-01f, 1.87061727e-01f, -1.36664796e+00f, 4.64175045e-01f, -2.46422753e-01f,
  -2.45012236e+00f, -8.42815265e-02f, 3.03886104e+00f, 1.87426829e+00f, 1.30972207e+00f, -1.10813749e+00f, -1.14015788e-02f, -2.04457140e+00f, -8.98716986e-01f, -2.01329041e+00f,
  -2.45999157e-01f, 8.11772227e-01f, -5.46152949e-01f, 2.71919638e-01f, 1.87796801e-01f, -2.43290514e-01f, 1.04121149e+00f, -2.05654550e+00f, -2.59867358e+00f, -1.68991232e+00f,
  1.81571019e+00f, -1.69747090e+00f, 1.45587480e+00f, -6.42481923e-01f, -2.19428286e-01f, -1.65971279e+00f, -5.04194319e-01f, 5.33124506e-01f, 7.35349894e-01f, -9.23453391e-01f,
  1.13098407e+00f, -2.98325479e-01f, 1.00502110e+00f, -2.22510695e+00f, 1.30245852e+00f, -1.17191744e+00f, -5.75883806e-01f, -1.62634301e+00f, -1.73516297e+00f, 3.06679364e-02f,
  -2.32954144e+00f, 8.65846932e-01f, -1.95213944e-01f, -1.77984083e+00f, 3.81121218e-01f, 6.34625614e-01f, -3.03850770e-01f, -7.21698105e-01f, 1.40618563e+00f, 7.63219178e-01f,
  7.51704156e-01f, -2.63420916e+00f, -2.39077902e+00f, -2.02294874e+00f, -5.09674907e-01f, 1.49356806e+00f, 8.39654267e-01f, -4.00850289e-02f, -6.32384837e-01f, -3.88885260e-01f,
  -1.16023630e-01f, -2.66183496e+00f, 8.06543827e-01f, 6.92419767e-01f, 3.51878732e-01f, 1.98755932e+00f, 1.17690301e+00f, 1.98948038e+00f, -9.59584236e-01f, 1.00998789e-01f,
  1.26771641e+00f, 6.81842029e-01f, 1.08052023e-01f, -2.82447755e-01f, 7.10014284e-01f, -4.16108787e-01f, -4.17468905e-01f, 9.53856945e-01f, 8.74193251e-01f, 8.03906798e-01f,
  -6.60340667e-01f, -2.40367198e+00f, -1.30128956e+00f, -4.83293235e-01f, -5.22135317e-01f, 2.15136528e-01f, 1.45704150e+00f, -2.27983642e+00f, 3.12794864e-01f, -1.72520971e+00f,
  8.56611371e-01f, -2.41126561e+00f, -2.20657438e-01f, -3.93171638e-01f, -9.35571015e-01f, -1.09962761e+00f, -2.11068678e+00f, 1.15986896e+00f, -1.37118483e+00f, -1.21926345e-01f,
  1.59198284e+00f, 2.65312266e+00f, 4.75333393e-01f, 1.00114256e-01f, -1.96024418e-01f, 1.03637981e+00f, -1.35790932e+00f, -1.23591256e+00f, 1.08275399e-01f, -1.87243402e-01f,
  -1.84012830e+00f, 9.38467011e-02f, 1.82738110e-01f, 1.12175643e-01f, -2.12988043e+00f, 1.35769534e+00f, -2.24503374e+00f, 2.09300947e+00f, -1.34708607e+00f, -6.59429848e-01f,
  -1.16357744e+00f, -1.13383377e+00f, -7.33430505e-01f, 8.28710556e-01f, 1.54669449e-01f, 8.49750817e-01f, 1.66475743e-01f, 5.39798081e-01f, 6.11428976e-01f, 1.83136031e-01f,
  -9.91691768e-01f, 1.38951993e+00f, 1.11031461e+00f, 2.10497952e+00f, 1.37781844e-01f, -1.04949951e+00f, 1.43456054e+00f, -1.17462218e+00f, -1.99610269e+00f, -1.43713522e+00f,
  1.10816526e+00f, 2.19966739e-01f, -2.35949144e-01f, 1.88588142e+00f, 3.18145812e-01f, 9.30583477e-01f, 1.78882897e+00f, -2.03862453e+00f, 2.41539979e+00f, 9.81297791e-01f,
  -2.09983921e+00f, 2.49847651e+00f, -1.47289860e+00f, -8.67557049e-01f, 2.01546609e-01f, 1.75906360e-01f, 8.96864235e-01f, 1.42980623e+00f, -1.81340873e+00f, -7.44597673e-01f,
  1.52908242e+00f, 7.24231124e-01f, -2.02416372e+00f, -9.90609303e-02f, -1.97986233e+00f, 1.75208163e+00f, -4.68404233e-01f, 1.55653739e+00f, -1.71644402e+00f, -1.15690604e-01f,
  1.02448332e+00f, -1.28182006e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.25368690e-01f, -1.10540725e-01f, -2.63859421e-01f, 5.42096019e-01f, -4.96710747e-01f, -2.76610941e-01f, 4.40222025e-01f, 4.73823309e-01f, -3.52309495e-01f, -3.13552111e-01f,
  4.13977146e-01f, 2.24224642e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    