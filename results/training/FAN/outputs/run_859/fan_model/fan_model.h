/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.51767462e-01f, -1.56422496e-01f, -1.33643657e-01f, -9.43791419e-02f, -3.84029076e-02f, -3.61427441e-02f, -3.32448393e-01f, -1.29445687e-01f, 2.37111319e-02f, -1.28562659e-01f,
  -2.19325386e-02f, 1.52203977e-01f, 1.51895583e-01f, 9.56937969e-02f, -1.04569368e-01f, -1.83653340e-01f, -8.00362825e-02f, -4.01168205e-02f, 1.57032963e-02f, 4.30189930e-02f,
  8.77947360e-02f, 7.12277666e-02f, 1.48803517e-01f, 7.74918869e-02f, 4.42224033e-02f, 1.85892224e-01f, 7.78904408e-02f, -4.70693484e-02f, -2.89194356e-03f, -1.15855500e-01f,
  3.52119207e-02f, -2.30598658e-01f, -7.22006187e-02f, 1.01158194e-01f, 2.52784193e-02f, -1.17834494e-01f, -8.56831949e-03f, -5.36645725e-02f, -1.98375471e-02f, -6.03468493e-02f,
  8.00391585e-02f, 7.80183971e-02f, -3.92204821e-02f, 2.02825293e-02f, 9.74843204e-02f, -3.85717452e-02f, 2.75957678e-02f, -1.57423884e-01f, -7.99833164e-02f, -2.67190784e-02f,
  5.25785098e-03f, -7.82783553e-02f, -2.61948854e-02f, -8.51534121e-03f, -5.33051714e-02f, -1.62031185e-02f, -5.26333787e-02f, -5.75704202e-02f, -1.42185697e-02f, 7.76963383e-02f,
  -1.16471425e-02f, -1.00489765e-01f, -1.51233440e-02f, 2.58905906e-02f, 5.30343018e-02f, 1.13457046e-03f, -1.94977056e-02f, 1.45850377e-02f, 6.63754195e-02f, -1.13626253e-02f,
  -2.34957393e-02f, -6.24731705e-02f, -4.86722961e-02f, 2.02668086e-02f, 8.45007449e-02f, -7.98719153e-02f, -1.83457951e-03f, 3.00020259e-02f, -5.58601040e-03f, -7.10085407e-03f,
  4.64743339e-02f, 6.59532025e-02f, 2.11752001e-02f, -5.10388277e-02f, 1.95663814e-02f, -2.07304419e-03f, 1.46505069e-02f, -1.37837380e-02f, 4.89070900e-02f, -7.76166171e-02f,
  2.22833976e-01f, -1.95384696e-01f, 4.50463220e-02f, 4.73374575e-02f, -3.13741192e-02f, -1.37997987e-02f, -2.28634272e-02f, -3.51250470e-02f, -6.17280006e-02f, 7.08601251e-02f,
  -1.72550101e-02f, 5.20906001e-02f, -3.01656928e-02f, -4.62901071e-02f, 4.31698859e-02f, 5.13838343e-02f, 1.91120412e-02f, 1.30572682e-02f, 3.95014249e-02f, -3.87053601e-02f,
  -1.98834110e-02f, 3.32021974e-02f, 3.43738608e-02f, 8.11371133e-02f, 1.03085734e-01f, -2.27959938e-02f, 1.47093441e-02f, 1.88217405e-02f, 8.26494917e-02f, -9.58285481e-03f,
  1.71827510e-01f, -3.64483669e-02f, 1.45701379e-01f, 1.63262431e-02f, 7.84789398e-02f, -2.07451120e-01f, -1.51775301e-01f, -2.20237657e-01f, -1.28729627e-01f, -3.94849200e-03f,
  2.24968549e-02f, 1.90606967e-01f, 1.13425642e-01f, 7.91609138e-02f, 1.05982862e-01f, 7.15348348e-02f, 1.34993466e-02f, 2.20992506e-01f, 1.06225312e-01f, 1.08858366e-02f,
  8.32161754e-02f, 5.00152968e-02f, 9.78083313e-02f, 6.94843475e-03f, 3.55225503e-02f, -2.95026675e-02f, 1.17549762e-01f, 7.02189952e-02f, 3.51218916e-02f, 3.50935847e-01f,
  2.00910494e-01f, -1.88113883e-01f, 8.33689142e-03f, 7.71744028e-02f, 7.06287697e-02f, -1.84173528e-02f, -2.15368085e-02f, 8.33372921e-02f, -4.38926294e-02f, -3.52085866e-02f,
  1.62896186e-01f, -4.69268411e-02f, -9.05072317e-03f, 2.66586244e-02f, -5.05872034e-02f, 1.20595070e-02f, -1.54041965e-02f, 5.07724136e-02f, 1.21960128e-02f, -8.02558213e-02f,
  6.08103834e-02f, 1.70236044e-02f, -2.28740014e-02f, -1.93874881e-01f, -7.20369294e-02f, -5.81863429e-03f, -3.32820676e-02f, -1.09290063e-01f, -1.70132853e-02f, 3.30673195e-02f,
  -7.36037195e-02f, 1.59663670e-02f, -5.99585921e-02f, -6.89773709e-02f, 3.10412645e-02f, -7.24844486e-02f, 9.23057646e-02f, 5.72101586e-02f, -1.28319031e-02f, -2.75123548e-02f,
  -9.18866042e-03f, 7.55980834e-02f, 4.95159701e-02f, -7.60163367e-02f, 7.27099851e-02f, -1.02205090e-02f, -3.48554924e-02f, 2.48827077e-02f, 4.96215634e-02f, 1.93874910e-02f,
  1.53034935e-02f, -3.84575687e-02f, -1.01575907e-02f, -3.06580141e-02f, -2.44220626e-02f, 6.73712045e-02f, -2.15950683e-02f, -6.37674779e-02f, 1.03012184e-02f, -9.83902290e-02f,
  -2.31467132e-02f, 1.66255951e-01f, 1.88174136e-02f, -2.91785616e-02f, 1.16909416e-02f, -1.40508544e-03f, 6.57264609e-03f, -2.19825357e-02f, 1.68967769e-02f, -7.26482226e-03f,
  -4.32130881e-02f, 5.61217330e-02f, -3.49787762e-03f, -2.29028473e-03f, 2.26409324e-02f, -6.47029430e-02f, 3.07606679e-04f, 2.08195001e-02f, -2.60879584e-02f, -3.12699899e-02f,
  -7.01942816e-02f, 1.24495085e-02f, 1.13106063e-02f, -2.66232714e-02f, 8.16066097e-03f, 3.07760742e-02f, -3.15859132e-02f, -7.36749172e-02f, -7.03320429e-02f, -1.72555462e-01f,
  6.71511114e-01f, 9.96448472e-02f, -1.04449347e-01f, 1.61663234e-01f, -4.42298017e-02f, 1.51575774e-01f, 3.58777314e-01f, 8.47987980e-02f, -4.20350349e-04f, 4.89430875e-02f,
  2.46863682e-02f, 2.52447953e-03f, 7.74831846e-02f, -1.05850093e-01f, 1.13836840e-01f, 2.41396744e-02f, -2.28382766e-01f, -1.67651698e-01f, 9.28360745e-02f, -3.83034125e-02f,
  -1.71894863e-01f, -3.96150723e-02f, -3.46922986e-02f, -1.18906662e-01f, -4.96113002e-02f, 2.17391998e-01f, 1.22909777e-01f, -7.12610595e-03f, 5.78511916e-02f, -2.32096374e-01f,
  2.52022538e-02f, -2.76156105e-02f, 2.46094819e-02f, 1.15549147e-01f, -4.80127484e-02f, 5.94832003e-02f, -2.72101033e-02f, -7.62682855e-02f, 6.37598932e-02f, -8.23568478e-02f,
  -4.54164483e-02f, -5.57044633e-02f, 2.64071748e-02f, -5.19521944e-02f, 3.30758281e-02f, -7.38163814e-02f, -1.72483698e-01f, -8.35829899e-02f, -9.54400077e-02f, -2.76487805e-02f,
  -5.92917167e-02f, -1.28078207e-01f, 1.11011557e-01f, -3.35161611e-02f, 9.33483616e-03f, -1.57712936e-01f, 4.77019548e-02f, -9.57966223e-02f, -2.81799734e-02f, 1.32766172e-01f,
  3.87040079e-02f, -1.11117270e-02f, -3.49525996e-02f, 4.64999042e-02f, -5.34044951e-03f, 3.30653302e-02f, -2.85958908e-02f, 6.73428625e-02f, 1.00625940e-02f, 7.80132413e-02f,
  -8.92537013e-02f, 1.75807923e-02f, -3.50722633e-02f, -2.12933775e-02f, 6.46295473e-02f, -6.84189796e-02f, 6.60594320e-03f, 3.71399187e-02f, -2.43398715e-02f, 4.91820928e-03f,
  7.28634000e-02f, -3.94882932e-02f, 2.01827940e-02f, -7.53348544e-02f, -2.70615332e-02f, -1.59303159e-01f, -7.14661703e-02f, 1.56708825e-02f, 4.32639010e-02f, 1.79267377e-02f,
  3.22032273e-01f, -2.24017259e-02f, 9.56379063e-03f, 1.03400331e-02f, -2.84276828e-02f, -5.68788499e-02f, 2.78982949e-02f, -2.06282623e-02f, -4.90242280e-02f, 5.45248762e-02f,
  2.98182331e-02f, 5.44581749e-02f, 1.87083725e-02f, -3.28877904e-02f, 7.85208493e-02f, 6.80257306e-02f, 1.12528428e-01f, 7.56226480e-02f, 5.25156446e-02f, -7.62711540e-02f,
  1.65675450e-02f, 2.83229530e-01f, 3.07846546e-01f, 9.35122222e-02f, 1.11223459e-01f, 2.54564404e-01f, 1.99460238e-01f, 1.11523159e-01f, 3.52613032e-01f, 4.67902452e-01f,
  6.31111413e-02f, 3.54329012e-02f, -4.30588536e-02f, 2.02363893e-01f, 1.99148022e-02f, -7.71509297e-03f, -3.36970724e-02f, -6.32822365e-02f, 3.60576846e-02f, 1.54388309e-01f,
  -1.03291862e-01f, -2.84262411e-02f, -4.09670360e-02f, -3.21931962e-04f, -1.39348581e-01f, 7.89525211e-02f, 6.00995757e-02f, 5.04744379e-03f, -7.52832592e-02f, 8.82638618e-02f,
  8.97854865e-02f, 4.18660194e-02f, 9.04718712e-02f, -4.54750136e-02f, 2.69841105e-01f, -2.50266735e-02f, 4.01996933e-02f, 6.23805933e-02f, -2.87526902e-02f, 2.62237221e-01f,
  6.23511337e-02f, 9.23829079e-02f, -8.14459249e-02f, 1.85470860e-02f, -1.00008778e-01f, -3.39812301e-02f, -3.52358818e-02f, 1.71110418e-03f, -5.79446219e-02f, 8.13783240e-03f,
  8.75899196e-02f, 3.51983006e-03f, -3.60509031e-04f, 1.58014614e-02f, 9.31319967e-02f, -2.09035724e-03f, 3.40892188e-02f, -3.44844162e-02f, -9.55980122e-02f, 1.04482956e-01f,
  -2.94261575e-02f, 1.05147190e-01f, 7.14990869e-02f, -1.28933221e-01f, 4.07255217e-02f, 5.68577610e-02f, -6.00890703e-02f, -2.52268519e-02f, -2.80059390e-02f, -6.14820048e-04f,
  9.05500948e-02f, -8.82765353e-02f, 1.91536564e-02f, 7.54723838e-03f, 1.29287150e-02f, 4.23990376e-02f, -2.80260295e-02f, -2.79539544e-02f, 3.56929679e-03f, 8.13693106e-02f,
  1.34350713e-02f, -1.25015145e-02f, 1.71365682e-02f, 1.62520166e-03f, -5.84062859e-02f, -2.07444951e-02f, 5.83490655e-02f, -1.76854972e-02f, -8.31688941e-02f, -8.70455895e-03f,
  -4.54690978e-02f, 4.95835999e-03f, -3.21682133e-02f, 6.72960132e-02f, -4.50001806e-02f, 2.76663285e-02f, 3.88347656e-02f, 1.01242311e-01f, 4.79282103e-02f, 1.16903186e-01f,
  3.71744856e-02f, -2.29171529e-01f, 1.33084208e-01f, 8.12686458e-02f, 1.88395823e-03f, 2.03240532e-02f, 3.71643044e-02f, 2.40463801e-02f, 4.01607007e-02f, 4.26707417e-02f,
  5.50784208e-02f, 2.96823382e-02f, -8.97304341e-03f, 1.45178363e-02f, -5.71281612e-02f, 1.83880422e-03f, 7.00026080e-02f, -4.41596992e-02f, 8.33083969e-03f, -1.30701531e-02f,
  8.93199071e-02f, -1.27563365e-02f, 5.59537187e-02f, -8.69165435e-02f, 1.03836291e-01f, 2.01728959e-02f, 3.48942168e-02f, -3.01320497e-02f, -1.12713337e-01f, 6.47990853e-02f,
  2.35085234e-01f, -6.39562756e-02f, -6.21139295e-02f, -5.61035722e-02f, -7.89820123e-03f, 1.30862594e-01f, 2.09008858e-01f, 4.27973904e-02f, 5.42344190e-02f, 3.49840336e-02f,
  -1.12792149e-01f, -1.58044532e-01f, -1.25528812e-01f, -9.34834331e-02f, 9.91024002e-02f, 1.46897197e-01f, 1.25700772e-01f, 5.35596758e-02f, 1.15464948e-01f, 8.43437687e-02f,
  1.11100078e-02f, 5.42632379e-02f, 7.29595050e-02f, 8.04501995e-02f, -1.57177612e-01f, -1.06599011e-01f, -6.57930076e-02f, -1.45057648e-01f, 2.78839171e-02f, -2.93306857e-01f,
  -3.52850229e-01f, 9.74897109e-03f, 2.82862727e-02f, -1.88420657e-02f, -3.93792875e-02f, 2.20466480e-02f, -6.55769324e-03f, 2.00577197e-03f, -8.22417885e-02f, -2.95061385e-03f,
  -1.07826233e-01f, 8.34445953e-02f, -1.28756255e-01f, -4.46298718e-02f, -2.30581313e-02f, 2.59857364e-02f, 1.02872267e-01f, 7.19052255e-02f, 1.38294336e-03f, 3.70059698e-03f,
  -3.01854145e-02f, 1.59905236e-02f, -1.07070900e-01f, -9.49378014e-02f, -5.50552867e-02f, 2.95812637e-02f, -2.92732660e-02f, -9.63163748e-02f, -1.35358376e-02f, -1.89740241e-01f,
  -6.01656828e-03f, 3.98687311e-02f, -5.17905876e-02f, -1.05739888e-02f, 5.06542176e-02f, 3.22523378e-02f, -9.11234096e-02f, -3.68361510e-02f, 1.00184433e-01f, -1.90336965e-02f,
  2.67815236e-02f, -7.37884454e-03f, 4.74565802e-03f, -1.57104451e-02f, -2.69583752e-03f, -9.94426571e-03f, 3.78324580e-03f, 3.36283185e-02f, -8.05015862e-02f, -1.76592451e-02f,
  -4.48708721e-02f, -8.19154307e-02f, -2.95774010e-03f, -8.06262996e-03f, 4.39217649e-02f, 5.33886589e-02f, 4.26821522e-02f, -3.08672898e-02f, 5.07600904e-02f, 4.05637883e-02f,
  -8.02968368e-02f, 1.07791983e-01f, 2.64289938e-02f, 8.26305151e-03f, 6.77272230e-02f, 2.09164694e-02f, -9.66817141e-02f, 5.68242483e-02f, 8.39230046e-03f, -1.63021672e-03f,
  3.93805169e-02f, -6.89425170e-02f, 1.06944684e-02f, -2.66445111e-02f, -1.96999982e-02f, -1.44750262e-02f, 4.20109071e-02f, -8.74436796e-02f, 5.11211483e-03f, -5.68164028e-02f,
  1.76923368e-02f, 5.48961572e-02f, -1.83670539e-02f, -7.48816505e-02f, -3.82869095e-02f, 2.18098424e-02f, -1.15953505e-01f, -5.73766902e-02f, 1.14023954e-01f, 1.44096777e-01f,
  -6.19934320e-01f, -3.27047240e-03f, -6.28249124e-02f, -1.02812640e-01f, 1.32529810e-01f, 4.37340319e-01f, 5.31586111e-01f, 1.43157110e-01f, -9.13895573e-03f, -5.55927046e-02f,
  7.09677394e-03f, -2.94977259e-02f, -3.69928665e-02f, 4.35599573e-02f, 9.59653184e-02f, 7.24251345e-02f, 1.82257816e-01f, -4.63937037e-02f, -6.83913603e-02f, 6.38622269e-02f,
  5.42581361e-03f, -1.54873416e-01f, -2.95518845e-01f, -4.01135981e-02f, -1.36793226e-01f, 4.16504480e-02f, 1.63944155e-01f, -4.51096557e-02f, 2.74626389e-02f, -1.19482175e-01f,
  -1.47037745e-01f, -5.77252731e-02f, 2.17333436e-02f, -7.55904764e-02f, 5.40496930e-02f, -1.22646071e-01f, 2.47552618e-02f, -6.77972585e-02f, 4.69102524e-03f, -5.02881147e-02f,
  4.10678014e-02f, -2.59388667e-02f, 4.05786745e-02f, 1.30732432e-02f, 2.66480446e-02f, 2.61098277e-02f, -9.57808495e-02f, -1.37923853e-02f, -1.31507264e-02f, 1.63683556e-02f,
  7.10891886e-03f, 1.54013522e-02f, 6.81806058e-02f, 5.74927106e-02f, 8.70667174e-02f, 2.88577937e-02f, -1.28723728e-02f, -6.81581199e-02f, 1.18446700e-01f, -1.60384372e-01f,
  3.80772762e-02f, -1.66184790e-02f, 4.86000739e-02f, -1.79522745e-02f, -2.12783739e-03f, -3.04585695e-02f, 4.00731266e-02f, 1.93692371e-02f, -5.35521191e-04f, -5.07185347e-02f,
  3.05020027e-02f, -3.14727761e-02f, -9.71728843e-03f, -2.76367646e-02f, -1.87960751e-02f, 7.50786588e-02f, 2.19670553e-02f, -7.66602755e-02f, 8.98589939e-03f, -6.37286925e-04f,
  -1.87823847e-02f, 2.64645033e-02f, -1.91748794e-02f, 1.43022854e-02f, -1.54039236e-02f, -4.64205928e-02f, 1.93527676e-02f, -2.10600458e-02f, 2.64412817e-02f, 1.13768997e-02f,
  2.23330408e-03f, 2.75211245e-01f, -1.66601300e-01f, 1.80340968e-02f, -1.46091776e-02f, -2.61482745e-02f, 2.62938980e-02f, -2.91093383e-02f, 3.99570093e-02f, -3.66183668e-02f,
  7.28833824e-02f, -3.66136283e-02f, 5.73423654e-02f, -7.39959180e-02f, -2.78491285e-02f, -8.61073285e-02f, -1.35216592e-02f, 8.08036998e-02f, 2.85558719e-02f, -7.59320036e-02f,
  -8.19930434e-03f, -2.06381436e-02f, -9.44437385e-02f, 7.78028667e-02f, -2.59503461e-02f, 8.99370667e-03f, 7.66428187e-02f, 4.21499796e-02f, 1.39828309e-01f, -1.32946521e-01f,
  1.14022091e-01f, -1.05010390e-01f, 2.02182531e-01f, -1.58252362e-02f, -6.37476891e-02f, -7.71388113e-02f, -1.61311015e-01f, -1.66354522e-01f, 2.30470113e-02f, 6.65320968e-03f,
  5.52213416e-02f, 3.86210755e-02f, 1.66326970e-01f, 1.19679205e-01f, 3.59457508e-02f, -4.69219349e-02f, -1.08892851e-01f, 1.20882854e-01f, -2.40559410e-02f, -3.26078720e-02f,
  -2.01782235e-03f, 4.65358384e-02f, -3.87368202e-02f, -8.80225748e-02f, -3.92708369e-02f, 9.13743526e-02f, 8.34527612e-02f, -2.94149946e-02f, -5.16006611e-02f, 1.74653545e-01f,
  1.44986972e-01f, -3.66644226e-02f, -3.14947255e-02f, 3.97815276e-03f, -5.35866581e-02f, -3.93408723e-02f, 4.15490717e-02f, 3.39242630e-02f, 4.30391133e-02f, -5.58680929e-02f,
  -1.61459483e-02f, -5.41215800e-02f, -2.20952258e-02f, 3.45530570e-03f, -1.05061978e-01f, -1.00828908e-01f, -6.50211498e-02f, 4.60342830e-03f, 5.76986652e-03f, -8.00352842e-02f,
  -3.61602791e-02f, -1.59589332e-02f, 3.75591069e-02f, -5.65825216e-02f, -6.46007154e-03f, 7.51108825e-02f, 3.86170931e-02f, -6.84640855e-02f, 4.64478433e-02f, -7.39679160e-03f,
  1.52104739e-02f, 9.23302323e-02f, 3.05958353e-02f, -6.80597201e-02f, 4.80412412e-03f, 2.79087294e-02f, -4.80079614e-02f, -5.13969641e-03f, -2.53160615e-02f, -1.12103773e-02f,
  3.13236415e-02f, -7.01278597e-02f, -9.85859260e-02f, 4.28222455e-02f, -8.12244490e-02f, -1.12180347e-02f, 2.59057973e-02f, 1.10911153e-01f, 9.47427899e-02f, -8.10585171e-02f,
  -2.95657478e-02f, 2.89656073e-02f, -8.63356367e-02f, 3.51192690e-02f, 9.14180502e-02f, 3.74604575e-02f, -7.08849803e-02f, -1.05510250e-01f, 5.60198463e-02f, 3.52691822e-02f,
  4.82300669e-03f, 1.66214183e-01f, 1.41591743e-01f, 1.73624009e-02f, -8.22678581e-02f, 2.43498795e-02f, -2.18774788e-02f, -1.22419931e-02f, -7.56663037e-04f, 1.39558828e-02f,
  -5.34035787e-02f, 1.18842535e-02f, 5.79446778e-02f, -2.41496321e-02f, -6.84982762e-02f, -7.67433047e-02f, -1.04069524e-01f, 3.86614278e-02f, 4.74376902e-02f, -9.04875696e-02f,
  -3.06659508e-02f, -4.05922271e-02f, -1.08420089e-01f, -7.24611282e-02f, -3.26361619e-02f, -8.91657453e-03f, -1.72835216e-03f, 7.08267763e-02f, 5.69571229e-03f, -2.77725961e-02f,
  -1.17609128e-01f, 1.79382756e-01f, -7.10312948e-02f, -1.68640822e-01f, 2.27004960e-02f, 3.00052743e-02f, 3.54240149e-01f, 4.07063887e-02f, -2.05667347e-01f, 1.25222892e-01f,
  -2.49224305e-01f, -3.05927604e-01f, -1.36190608e-01f, -1.69194266e-01f, 5.43392710e-02f, 2.90898323e-01f, 2.38849863e-01f, 8.81432444e-02f, -1.02578275e-01f, 3.70800234e-02f,
  1.63602173e-01f, -6.25162572e-02f, -1.32666975e-01f, -7.71069974e-02f, 1.34086043e-01f, -8.96274373e-02f, -5.66330254e-02f, -6.75706267e-02f, 4.98527363e-02f, 2.27870449e-01f,
  1.69599280e-01f, -1.40069276e-01f, -7.60922059e-02f, -1.51496336e-01f, -4.06867564e-02f, -6.87057292e-03f, -2.06156038e-02f, -2.15724707e-02f, -2.12354511e-02f, -4.89436497e-04f,
  -7.41127580e-02f, -1.73149668e-02f, -9.62336361e-03f, -4.85105030e-02f, 2.87036113e-02f, 6.43093437e-02f, -2.42821798e-02f, 2.97148079e-02f, -3.35179418e-02f, -5.46612125e-03f,
  5.31245098e-02f, -9.04501379e-02f, 2.39701960e-02f, 5.14883511e-02f, 1.04185157e-01f, 1.85517222e-02f, -9.74095315e-02f, -2.53087375e-02f, -6.97853044e-02f, -4.06862907e-02f,
  2.78593390e-04f, 3.82523946e-02f, -3.62588046e-03f, -4.98576798e-02f, -3.77628915e-02f, -2.36370303e-02f, 2.21297815e-02f, 3.36378887e-02f, -5.18676825e-02f, 1.20790033e-02f,
  -5.93397431e-02f, 2.71324888e-02f, -3.32120284e-02f, -1.67868554e-03f, 6.20691031e-02f, 3.30985226e-02f, 3.37492749e-02f, 3.01979911e-02f, 2.25213468e-02f, 2.21990347e-02f,
  -1.26242740e-02f, -4.87719523e-03f, -1.74428374e-02f, 5.65822981e-03f, 4.70622405e-02f, -5.39265610e-02f, 1.12722414e-02f, -8.61187130e-02f, -6.56600669e-02f, -4.87210937e-02f,
  1.44256130e-02f, -2.36026451e-01f, -4.28705709e-03f, -1.25180688e-02f, -4.37142365e-02f, -6.95953444e-02f, -4.85235415e-02f, -3.27865663e-03f, -6.41122684e-02f, 3.04647768e-03f,
  -1.29056927e-02f, 5.98418489e-02f, -1.91316474e-02f, -3.22745764e-03f, 3.47250775e-02f, -1.69001352e-02f, -1.70714557e-02f, 3.78212370e-02f, -1.75184570e-02f, 6.11743927e-02f,
  -7.18333386e-03f, 1.57267749e-02f, -5.50774038e-02f, 4.51032184e-02f, 3.97261828e-02f, -7.71101341e-02f, 8.87567997e-02f, 6.22474737e-02f, -3.38344909e-02f, 1.10890307e-01f,
  4.95124429e-01f, -5.94606204e-03f, 1.98551282e-01f, 5.07408261e-01f, 3.06271553e-01f, 1.38774097e-01f, 3.16290297e-02f, 6.28639534e-02f, 8.46795589e-02f, 4.29189205e-02f,
  -9.52209309e-02f, 2.21854206e-02f, -9.55579355e-02f, -1.08094200e-01f, -5.50893508e-02f, -3.64913009e-02f, 2.01560259e-01f, 4.01894934e-03f, 2.08159029e-01f, 2.21216813e-01f,
  4.37132269e-02f, 3.87180775e-01f, 2.00252578e-01f, 2.17918493e-02f, 7.71002620e-02f, -7.34275654e-02f, 1.41442344e-02f, 2.11993843e-01f, -1.07219391e-01f, 1.34338960e-01f,
  -1.06137566e-01f, 1.89600572e-01f, 2.06184387e-02f, 7.32731000e-02f, 3.09305768e-02f, -1.56292200e-01f, 6.11576401e-02f, 1.16136009e-02f, -3.13230194e-02f, -4.49854415e-03f,
  4.25825417e-02f, -7.43591115e-02f, -2.87908618e-03f, -1.81367658e-02f, 7.47268647e-02f, 5.93329594e-02f, 5.87796383e-02f, 3.26107778e-02f, -5.63223958e-02f, 2.06644051e-02f,
  -6.56453334e-03f, 4.00316231e-02f, 5.56574762e-02f, 2.03169640e-02f, 1.61495004e-02f, 5.80714904e-02f, -1.25754634e-02f, 2.39004660e-02f, -8.42700824e-02f, -2.24992838e-02f,
  2.69177910e-02f, -4.35560197e-02f, 7.99646880e-03f, 4.35959101e-02f, -4.19780873e-02f, -9.06509720e-03f, -3.34808752e-02f, -6.80328766e-03f, -1.30186910e-02f, 5.91316074e-03f,
  -4.63937223e-02f, 2.50509400e-02f, -5.55947460e-02f, 4.27140445e-02f, -9.44527984e-02f, 1.04016602e-01f, -6.07052706e-02f, -5.06875888e-02f, 3.16666439e-02f, -3.67944725e-02f,
  3.64582203e-02f, -1.31319966e-02f, 5.03345951e-02f, -1.04244463e-01f, 8.96813497e-02f, -1.32657848e-02f, 1.88019071e-02f, 3.32146231e-03f, 2.64680423e-02f, 2.17572935e-02f,
  5.28143309e-02f, -8.68250895e-03f, -1.13599207e-02f, -1.12582058e-01f, 6.15641922e-02f, 2.71229558e-02f, -5.65629676e-02f, -6.16567209e-02f, -4.57733572e-02f, -3.33273746e-02f,
  3.64165418e-02f, -8.85609090e-02f, -2.55688336e-02f, -5.00589907e-02f, 1.10467924e-02f, -5.54030156e-03f, -4.12532762e-02f, 1.95296612e-02f, -5.08013256e-02f, -1.22583926e-01f,
  -7.51484111e-02f, -9.94795933e-02f, -1.49991568e-02f, -2.49638539e-02f, -8.98703262e-02f, 3.64110060e-02f, -1.22784600e-02f, 4.96114120e-02f, 5.51689090e-03f, -1.19710766e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.41219482e-01f, 4.57825288e-02f, 5.16212359e-02f, 3.74401845e-02f, -2.11553089e-02f, 7.97385275e-02f, -4.89945225e-02f, 1.39538031e-02f, -6.41515702e-02f, 9.91050038e-04f,
  1.58260576e-02f, -6.69004098e-02f, 7.69657195e-02f, 9.93805751e-02f, -4.52233776e-02f, -6.96739107e-02f, 9.02819782e-02f, 8.16374421e-02f, 9.38210711e-02f, -2.54586320e-02f,
  4.29172777e-02f, -4.24781516e-02f, 9.36460271e-02f, -5.65656275e-02f, -1.02780744e-01f, -7.99786747e-02f, -2.89860051e-02f, -7.25441128e-02f, -4.76336218e-02f, -2.85934824e-02f,
  -4.08071131e-02f, 2.61140913e-01f, 1.18506514e-01f, 6.31396696e-02f, -3.94824473e-03f, 1.22719772e-01f, 1.08658202e-01f, -2.24909149e-02f, 6.21565199e-03f, 1.84318889e-02f,
  1.00490354e-01f, 6.38768822e-02f, -6.64179772e-02f, -3.14232544e-03f, 2.49625742e-02f, 3.21883685e-03f, -3.86051945e-02f, 3.81285176e-02f, 9.25807003e-03f, 1.21529721e-01f,
  -8.33428055e-02f, 3.22374539e-03f, 9.62512642e-02f, -7.53785297e-02f, 3.92676406e-02f, 4.94782366e-02f, 1.10856697e-01f, 9.07155573e-02f, 1.35054126e-01f, 9.76453945e-02f,
  3.40120718e-02f, -8.14894587e-03f, 6.28606379e-02f, -3.84705886e-02f, -1.05394796e-01f, -1.57218538e-02f, -1.25006184e-01f, 2.91039683e-02f, 3.75217050e-02f, -1.20976850e-01f,
  -3.46891470e-02f, 4.14733253e-02f, 1.04449438e-02f, -4.74664345e-02f, -6.67272434e-02f, 4.75335820e-03f, 2.61426512e-02f, -1.19656213e-01f, -1.48843434e-02f, -2.71550170e-03f,
  7.21246749e-02f, 1.11442478e-02f, -2.70757382e-03f, 4.84002680e-02f, 1.78807136e-02f, 5.58391437e-02f, -5.54725118e-02f, -6.22820407e-02f, -7.81422257e-02f, 6.36252314e-02f,
  9.04676020e-02f, 1.00064240e-01f, -3.03889569e-02f, 5.80703914e-02f, 9.31311324e-02f, -5.09391837e-02f, 2.77961232e-02f, -4.97490226e-04f, -1.38511211e-02f, 4.78894785e-02f,
  -9.73122120e-02f, 3.94547619e-02f, 1.95955057e-02f, -3.50688994e-02f, 9.51723475e-03f, 7.58366585e-02f, 7.97007815e-05f, 1.17704928e-01f, 1.12150788e-01f, -6.09531114e-03f,
  -3.48581150e-02f, 7.04872385e-02f, 1.62298586e-02f, -6.88279644e-02f, 1.94065608e-02f, 6.47603651e-04f, 1.04376435e-01f, -4.86279279e-02f, 9.84333009e-02f, -7.70915113e-03f,
  3.14342648e-01f, -1.14809453e-01f, -2.52321929e-01f, -1.18007593e-01f, 4.04980071e-02f, -1.05447531e-01f, -2.92275529e-02f, -5.19409515e-02f, 8.48911982e-03f, 5.58844651e-04f,
  -5.05355336e-02f, 1.04230620e-01f, 4.76856269e-02f, 7.47053176e-02f, 4.82406877e-02f, -5.14857247e-02f, -2.23117530e-01f, 1.14518367e-01f, 3.46345425e-01f, 1.37130618e-01f,
  1.35257497e-01f, -3.68796699e-02f, 1.97572149e-02f, 3.97287086e-02f, -2.28473246e-02f, 1.57918558e-01f, -1.42068461e-01f, -1.57203183e-01f, -1.39426053e-01f, -2.98528165e-01f,
  9.16633289e-03f, -1.12180017e-01f, -8.42016004e-03f, 1.09737301e-02f, -5.41390739e-02f, 8.55218172e-02f, -5.36766686e-02f, 7.63222352e-02f, 6.67281970e-02f, -1.48566188e-02f,
  -4.05265167e-02f, -3.82562610e-03f, 3.39136161e-02f, 5.04184701e-02f, -2.77280752e-02f, 3.79539584e-03f, -6.65378943e-02f, -5.56355715e-02f, -8.64256769e-02f, -6.77197650e-02f,
  2.85956096e-02f, -9.18686837e-02f, 8.40192288e-03f, -1.34158298e-01f, 1.45579008e-02f, -9.11262780e-02f, -1.02222264e-01f, -6.61084801e-02f, -1.52647883e-01f, -8.32382068e-02f,
  -2.28310376e-02f, 5.03472378e-03f, -1.06352773e-02f, 4.75034937e-02f, 3.52839157e-02f, -1.27975978e-02f, -1.18768876e-02f, -1.58465316e-03f, 5.75132668e-02f, 1.70301273e-02f,
  -5.68862669e-02f, -9.81208216e-03f, 1.45748828e-03f, -3.14440504e-02f, -2.39317715e-02f, -6.70114532e-02f, -1.94557011e-02f, 3.20752412e-02f, 3.01872380e-02f, 2.07238160e-02f,
  7.31569380e-02f, -2.20630355e-02f, -4.28847298e-02f, 2.66016312e-02f, -5.72800748e-02f, -2.69558318e-02f, -2.26018596e-02f, 1.46418950e-02f, -6.12762570e-03f, 1.05820268e-01f,
  1.06531546e-01f, -9.74127278e-02f, 1.06262580e-01f, -4.22254801e-02f, -5.19489720e-02f, 2.27433480e-02f, 7.90161826e-03f, -4.42062020e-02f, -2.59999558e-02f, -3.45588638e-03f,
  -5.67549504e-02f, -3.71495634e-02f, -7.71183446e-02f, 9.77050141e-03f, 6.13118522e-02f, -3.29927132e-02f, 4.62356955e-02f, 6.22142553e-02f, -1.40683418e-02f, -1.07359244e-02f,
  -4.35398482e-02f, 1.92352623e-01f, 2.71838397e-01f, 1.02729075e-01f, 5.00085056e-02f, 1.70955285e-01f, 1.52014911e-01f, 1.13389596e-01f, 1.32928401e-01f, 3.77655417e-01f,
  -9.63870436e-02f, 2.98561212e-02f, -1.82466313e-01f, -6.76775947e-02f, -8.08224827e-02f, 9.86743271e-02f, 8.98660347e-02f, -1.61095224e-02f, 4.42821011e-02f, -3.47821862e-02f,
  -7.98716024e-02f, 1.77836884e-02f, -1.30657002e-01f, -2.75881160e-02f, -2.77553312e-02f, -1.23783246e-01f, -7.89588168e-02f, -2.98548359e-02f, 4.90591004e-02f, 1.10038288e-01f,
  5.86503446e-02f, -2.36352906e-02f, 5.02565764e-02f, -7.20412750e-03f, -5.75098442e-04f, -7.69523606e-02f, -6.67510182e-02f, 4.04433496e-02f, 2.08390336e-02f, -9.57116708e-02f,
  -1.68316990e-01f, -6.42304271e-02f, -7.89656565e-02f, 1.92535985e-02f, -1.12093233e-01f, 1.19643174e-02f, -3.14061902e-02f, 5.62452595e-04f, -2.55711079e-02f, 4.49529253e-02f,
  -1.13488346e-01f, 8.62517357e-02f, -7.66337439e-02f, -6.54617324e-03f, 2.58443784e-02f, -9.24191698e-02f, -1.69250332e-02f, -7.37315193e-02f, 5.22539578e-03f, -8.07810649e-02f,
  -1.87594946e-02f, 7.26995757e-03f, -1.00485012e-01f, -1.90701298e-02f, -1.06327124e-02f, -3.06432322e-02f, -8.11789334e-02f, 1.19755454e-02f, 5.99442981e-02f, 8.35991353e-02f,
  1.11150540e-01f, -3.67140099e-02f, 1.24681610e-04f, -1.22763645e-02f, -9.92526263e-02f, -6.21057898e-02f, -3.13879512e-02f, 8.76057446e-02f, 4.95355763e-02f, -5.37340753e-02f,
  -6.74435520e-04f, -5.96350543e-02f, 1.73941832e-02f, 7.97912404e-02f, -5.22499681e-02f, -2.16119587e-02f, 6.88159764e-02f, -2.61878967e-02f, 8.18891898e-02f, -8.79937261e-02f,
  1.78891942e-02f, 8.54472369e-02f, -8.42755288e-03f, -3.24463658e-02f, -1.57903153e-02f, 4.86745723e-02f, -4.48303036e-02f, -3.13506243e-05f, 5.39961532e-02f, 1.03781514e-01f,
  9.21888277e-02f, -3.12792580e-03f, -6.59948587e-02f, 4.33722027e-02f, -4.53452393e-02f, -2.48090550e-02f, -6.43593147e-02f, -5.10802902e-02f, 1.31385187e-02f, 7.10808933e-02f,
  1.58348586e-03f, -5.64137027e-02f, -7.01525807e-02f, -2.07383535e-03f, -1.56662539e-01f, -8.97282660e-02f, 5.68620637e-02f, -2.17969455e-02f, 1.79127418e-02f, -2.61737052e-02f,
  7.05942586e-02f, -8.96444470e-02f, -1.05809487e-01f, -7.35813007e-02f, -3.24180797e-02f, 1.23657994e-02f, -3.57417166e-02f, 8.24427977e-02f, 3.03154215e-02f, 1.62321124e-02f,
  -1.09726481e-01f, -2.37851247e-01f, 2.04679817e-01f, -3.90043892e-02f, 8.37958604e-02f, 6.48957044e-02f, 1.65815994e-01f, 2.91127823e-02f, -6.43425733e-02f, -1.65574364e-02f,
  -1.39571708e-02f, 9.36322883e-02f, 9.56322849e-02f, 3.12571116e-02f, 6.78416044e-02f, -5.87599352e-02f, 7.19257258e-03f, 7.20766410e-02f, 3.08038175e-01f, 2.41869286e-01f,
  3.13282060e-03f, -6.59680143e-02f, -1.38266712e-01f, 2.06580684e-02f, 1.73888788e-01f, 1.82371005e-01f, -5.91161773e-02f, -1.16391301e-01f, 6.22175969e-02f, -1.31524324e-01f,
  4.34126437e-01f, -6.76818341e-02f, 2.13775560e-01f, 4.26148139e-02f, 1.40136238e-02f, -4.41095717e-02f, 9.39297304e-02f, -5.09255640e-02f, -9.97873545e-02f, -6.10400364e-02f,
  -5.95730878e-02f, -9.17081013e-02f, 8.23326930e-02f, -1.27413040e-02f, -8.06816891e-02f, 1.33490011e-01f, -1.24141552e-01f, -9.24924910e-02f, -4.58149686e-02f, 1.06227517e-01f,
  3.14176343e-02f, -1.16312593e-01f, -1.76315606e-02f, 1.11824296e-01f, -3.27540226e-02f, 2.08736751e-02f, 3.30103524e-02f, -1.00752525e-01f, -1.90725420e-02f, -1.19524650e-01f,
  1.06800094e-01f, 4.55263443e-02f, 2.68281903e-02f, 6.68466389e-02f, 3.16461548e-02f, 3.41613218e-02f, -8.31218138e-02f, 7.99470022e-02f, -6.81959614e-02f, 2.24382877e-02f,
  -1.09710833e-02f, 4.44250032e-02f, -4.75351326e-02f, 1.69182811e-02f, 3.20534110e-02f, -1.06961749e-01f, -6.41865060e-02f, -8.65775347e-03f, -3.11213955e-02f, -1.48545057e-02f,
  5.79240471e-02f, -6.77287653e-02f, 4.36725058e-02f, 2.78509930e-02f, 1.97853521e-02f, 3.99092846e-02f, 7.77265206e-02f, 7.16416165e-02f, -3.22438031e-02f, -1.07286543e-01f,
  9.61801037e-02f, -1.28351733e-01f, -7.93320872e-03f, -1.09045900e-01f, -9.69113633e-02f, -3.73850279e-02f, 1.03160061e-01f, -3.08060087e-02f, 3.35843506e-04f, -7.11292867e-03f,
  4.37253043e-02f, 6.18530624e-02f, 4.96795662e-02f, -1.03224792e-01f, 5.88367172e-02f, -1.27962723e-01f, -6.86589554e-02f, 6.15833998e-02f, -8.09006393e-02f, 3.73515598e-02f,
  2.35615149e-02f, -4.61576581e-02f, 1.81313679e-01f, 1.64098758e-02f, 2.52865460e-02f, 8.58456418e-02f, 2.43943688e-02f, 1.37433335e-01f, 8.74208212e-02f, 1.84781298e-01f,
  -2.71913670e-02f, -6.36387244e-02f, 5.97350672e-02f, 2.55396706e-04f, 2.82147666e-03f, -2.14884020e-02f, -2.65982095e-02f, -9.97883305e-02f, -7.29483028e-04f, -1.09642290e-01f,
  -1.18345186e-01f, -2.93264575e-02f, -5.19104712e-02f, -9.08971857e-03f, 1.52281602e-03f, -2.79654898e-02f, -1.03661790e-01f, -2.83413474e-03f, 2.71071363e-02f, -5.96060343e-02f,
  -8.97444040e-02f, -9.77092423e-03f, -7.47161657e-02f, -1.23136997e-01f, 5.90284988e-02f, -6.45180745e-03f, -2.92967279e-02f, 6.63292706e-02f, 4.03032489e-02f, -1.03924140e-01f,
  -9.29951519e-02f, 3.66101861e-02f, -7.61640146e-02f, -2.04814281e-02f, 2.65893582e-02f, 4.63507548e-02f, -8.16199705e-02f, -3.77362035e-02f, 7.71042779e-02f, 8.99119899e-02f,
  -5.77746332e-02f, -6.18337542e-02f, 1.08916022e-01f, 4.81871627e-02f, -1.37539105e-02f, -6.07465617e-02f, 1.03214987e-01f, -2.00596936e-02f, -4.99695353e-02f, -8.54670629e-02f,
  -9.48369130e-02f, -6.59497082e-03f, -1.01307198e-01f, -3.21211293e-03f, 5.19582890e-02f, 8.07098895e-02f, -7.81178251e-02f, 2.81109363e-02f, 1.85044724e-02f, -3.11757531e-02f,
  -7.06830323e-02f, -3.07091679e-02f, -3.49459276e-02f, -2.23687366e-02f, -7.81714246e-02f, 9.26328357e-04f, -1.49758933e-02f, -5.33777401e-02f, 8.21129084e-02f, 5.87956905e-02f,
  -2.38603130e-02f, 3.31504387e-03f, 1.83788571e-03f, 5.91916942e-05f, 2.31388491e-03f, 6.39158487e-02f, -1.78762320e-02f, -7.16975406e-02f, -7.77281076e-02f, 2.21250802e-02f,
  5.19545116e-02f, -7.10450858e-02f, -1.52993053e-02f, 2.69453973e-02f, -6.54476583e-02f, 1.71198715e-02f, 5.25769442e-02f, -3.87036917e-03f, 4.19631973e-02f, 1.06474921e-01f,
  4.01008734e-03f, -6.48964047e-02f, -5.99089675e-02f, -5.08446619e-02f, -1.01815715e-01f, -1.49402935e-02f, -2.55782660e-02f, 3.58772911e-02f, 3.03673912e-02f, -8.37324411e-02f,
  4.56647836e-02f, -7.84733370e-02f, 3.95593159e-02f, -3.81033979e-02f, 1.82183757e-02f, -7.28535876e-02f, 8.70243087e-03f, 1.18842069e-02f, -4.81291898e-02f, -1.20099574e-01f,
  -7.18300492e-02f, -3.11422907e-02f, 4.35611196e-02f, 5.61984852e-02f, 7.54768401e-02f, -7.14278296e-02f, 8.16906393e-02f, -4.88670878e-02f, 7.63465911e-02f, -6.44026473e-02f,
  -6.15733378e-02f, -2.08021581e-01f, 1.99243668e-02f, 1.58011645e-01f, 1.61495313e-01f, -2.70938184e-02f, -2.75774270e-01f, -1.53493226e-01f, 1.93860725e-01f, -9.09913406e-02f,
  -9.32655856e-02f, -5.96497580e-03f, 1.84104908e-02f, -2.52030957e-02f, -1.71426430e-01f, -2.17162475e-01f, -9.37898532e-02f, -1.25248916e-02f, -9.00204927e-02f, -3.30613293e-02f,
  5.60289212e-02f, 1.36924693e-02f, 8.03123713e-02f, -2.79751066e-02f, 6.30086809e-02f, 2.84751337e-02f, 9.87883359e-02f, 1.58756394e-02f, -3.65245081e-02f, 5.21118492e-02f,
  -8.40115454e-03f, -4.46997806e-02f, 1.83884390e-02f, -5.53351780e-03f, 7.09069222e-02f, -4.73793261e-02f, -8.23301449e-02f, 5.87767176e-02f, -1.88046210e-02f, 5.46779372e-02f,
  1.48473494e-02f, -1.09975738e-02f, -2.81350967e-02f, -5.86703047e-02f, -2.96720304e-02f, -2.78502144e-02f, -6.11257786e-03f, 9.18892398e-02f, -4.66887914e-02f, -4.36424557e-03f,
  1.12851314e-01f, 3.89828682e-02f, 2.48125871e-03f, -1.49259821e-01f, -4.16164026e-02f, 5.37211224e-02f, -5.21911271e-02f, -2.82909758e-02f, -1.33645788e-01f, -8.94944817e-02f,
  1.94108405e-03f, 2.67982166e-02f, -5.01488931e-02f, -5.35799889e-03f, 1.56630967e-02f, 1.65156685e-02f, -3.09537370e-02f, 5.09808697e-02f, -7.51133496e-03f, -3.14064324e-02f,
  -4.24114130e-02f, 3.13710384e-02f, 6.30479082e-02f, -6.42395485e-03f, 2.36939769e-02f, -2.29222085e-02f, 4.12233826e-03f, -5.34179732e-02f, 5.39224362e-03f, 4.14955467e-02f,
  -4.95846868e-02f, -9.72375870e-02f, 4.52401191e-02f, 3.49777192e-02f, -1.56342320e-03f, -7.52133504e-02f, 1.22833243e-02f, -2.73111593e-02f, 2.63326615e-02f, -9.03766826e-02f,
  6.96149319e-02f, -1.05232187e-01f, -3.54854092e-02f, -5.30563071e-02f, 9.74884927e-02f, 8.45182762e-02f, -3.21298577e-02f, 5.67893535e-02f, 4.23812456e-02f, -5.62792225e-03f,
  -8.23536143e-02f, -5.92636457e-03f, -1.29159400e-02f, 1.34065580e-02f, -8.63668323e-03f, -9.42136571e-02f, -3.07557918e-02f, -3.32906619e-02f, -5.84335551e-02f, 1.57237962e-01f,
  6.03034114e-03f, -1.02175228e-01f, -1.02084890e-01f, -4.69093546e-02f, -8.48641098e-02f, 3.12838610e-03f, -7.07845688e-02f, 4.12046164e-02f, -1.88635260e-01f, -1.38244271e-01f,
  3.26005742e-02f, -1.28971666e-01f, -9.11903232e-02f, 3.93154211e-02f, 5.30003384e-02f, 6.29126653e-02f, -4.77625057e-02f, 6.96304366e-02f, 3.10606286e-02f, 7.60540441e-02f,
  1.75449416e-01f, 1.78608015e-01f, 1.74283728e-01f, 1.01187853e-02f, 1.11346349e-01f, -3.53023224e-02f, -1.01012565e-01f, -4.47871462e-02f, 7.16504157e-02f, 5.23916185e-02f,
  1.92750730e-02f, 2.55561117e-02f, 4.83412817e-02f, 5.29117770e-02f, -1.19737452e-02f, -3.33019271e-02f, 5.59050068e-02f, -3.24839242e-02f, -1.36875454e-03f, -1.77223869e-02f,
  9.39578712e-02f, 1.58536844e-02f, 1.24157377e-01f, 4.29695509e-02f, -8.41393694e-02f, 6.83910400e-02f, 5.90506718e-02f, -9.05047506e-02f, -8.51809792e-03f, -7.66639560e-02f,
  -2.09144857e-02f, -6.02607653e-02f, -5.61320931e-02f, 1.02926679e-01f, 1.10257026e-02f, -6.32433668e-02f, 5.36494516e-02f, 3.97086069e-02f, -8.62677553e-05f, -1.06295623e-01f,
  -4.65201288e-02f, 3.61936563e-03f, -5.38150445e-02f, -9.47368741e-02f, 1.61210261e-02f, -2.70087775e-02f, -1.79547053e-02f, 1.71652399e-02f, 2.62494106e-02f, 3.70957628e-02f,
  9.07562450e-02f, -2.20161621e-02f, -6.03546156e-03f, -8.04127008e-02f, 5.05482145e-02f, 1.66535296e-03f, -5.31749465e-02f, 3.68962064e-02f, -2.40235273e-02f, -3.69201079e-02f,
  4.85192537e-02f, 5.73451817e-02f, 4.83148918e-02f, 2.88050831e-03f, 7.84066543e-02f, -3.96651663e-02f, -7.39195198e-02f, 1.59049090e-02f, -9.73794535e-02f, 3.64597933e-03f,
  4.81916443e-02f, -8.18092600e-02f, -1.22262001e-01f, -4.16158885e-03f, -3.21155204e-03f, 3.58737335e-02f, 6.78621456e-02f, -2.30867160e-03f, 2.52289474e-02f, 6.82307705e-02f,
  -5.36006540e-02f, 2.18827464e-03f, 4.67103608e-02f, -1.15426471e-02f, -4.06940244e-02f, -7.44012445e-02f, -3.14085907e-03f, -8.85827765e-02f, -3.86202410e-02f, -8.05259794e-02f,
  2.99091823e-02f, -3.24777141e-02f, 5.83838895e-02f, 2.93739815e-03f, -1.61540173e-02f, -2.57459711e-02f, -8.01349711e-03f, -1.28203541e-01f, 6.25308678e-02f, -9.83272940e-02f,
  -4.72651273e-02f, -5.23495302e-02f, -5.31956181e-02f, -3.76515934e-04f, 2.75635943e-02f, 5.82946390e-02f, 2.48225462e-02f, -2.79583652e-02f, -2.19036378e-02f, 7.44865164e-02f,
  -2.49915302e-01f, -2.64887542e-01f, 2.54079461e-01f, -1.31658893e-02f, 1.94575265e-01f, 1.73205554e-01f, 5.30167595e-02f, -5.97494021e-02f, -5.39320074e-02f, -4.48831692e-02f,
  -7.95733184e-02f, -1.01087481e-01f, -1.29943743e-01f, 1.19813997e-02f, -5.43905236e-02f, 1.09373130e-01f, 7.08998516e-02f, 1.97579265e-01f, 2.09867641e-01f, 1.28094926e-01f,
  -3.48160155e-02f, -1.26967400e-01f, -9.17671919e-02f, -6.50001988e-02f, 3.43968743e-03f, 1.55680135e-01f, -2.40284223e-02f, 6.57365918e-02f, -1.70870665e-02f, 8.28874260e-02f,
  2.98956037e-01f, -1.35009289e-01f, 9.49962810e-02f, -1.05084121e-01f, 2.28333008e-02f, 2.55624373e-02f, 5.26975095e-02f, -1.12274893e-01f, 1.07268784e-02f, 5.67946583e-04f,
  -6.51680902e-02f, -7.15553835e-02f, 6.87728962e-03f, -1.43694011e-02f, -1.73511773e-01f, -6.79491262e-04f, -6.18591830e-02f, 3.27805318e-02f, -6.63196295e-02f, 1.14655919e-01f,
  8.40980932e-03f, 4.19926420e-02f, -1.67733300e-02f, 5.83815202e-02f, -1.11069903e-02f, -7.20520765e-02f, 5.90323806e-02f, -1.12297246e-03f, -1.19624892e-02f, 6.39938340e-02f,
  3.54381949e-02f, -8.45279172e-02f, -2.55196858e-02f, 2.18643248e-02f, -7.03234747e-02f, 3.15464772e-02f, 3.79892513e-02f, -1.05477758e-02f, 5.64521514e-02f, 8.71805027e-02f,
  -5.13226911e-02f, 3.18601020e-02f, -4.31246497e-02f, -2.29431838e-02f, 4.84485775e-02f, -5.99023439e-02f, 6.04500584e-02f, -5.90673983e-02f, -1.54464785e-02f, 2.05886997e-02f,
  -1.54980868e-02f, -1.97504479e-02f, 4.99175005e-02f, -8.10960308e-02f, 1.93948168e-02f, -2.43683737e-02f, 4.65629064e-02f, -5.30360639e-02f, -3.34852412e-02f, -4.95031923e-02f,
  6.48831129e-02f, -1.22849271e-01f, 4.69591655e-02f, -2.32288502e-02f, -1.18106613e-02f, -1.95593759e-02f, -9.35948938e-02f, 5.17050400e-02f, -5.24025820e-02f, 8.48701075e-02f,
  2.39010174e-02f, 7.20261708e-02f, -8.06499720e-02f, 3.38718318e-03f, 7.49053583e-02f, 1.17837630e-01f, -4.56137918e-02f, 1.19616464e-01f, -4.79769101e-03f, 1.70814302e-02f,
  -3.37677374e-02f, 1.56351551e-01f, 2.01114729e-01f, 9.72456411e-02f, 2.29470711e-02f, 1.38606280e-02f, 2.53778726e-01f, 8.51433799e-02f, 7.82362744e-02f, 1.27936557e-01f,
  2.67598122e-01f, 1.78136081e-01f, -2.67850216e-02f, -2.77099386e-02f, -1.30789373e-02f, -2.85441708e-02f, 4.97705443e-03f, -5.95487878e-02f, -7.58144408e-02f, -2.23482586e-02f,
  -4.59041558e-02f, 4.07808870e-02f, -1.95857938e-02f, -3.41691785e-02f, 2.98862923e-02f, -3.69574130e-02f, 3.44869457e-02f, -7.30159879e-02f, 5.00897430e-02f, 4.34060693e-02f,
  6.91242367e-02f, 5.28343283e-02f, 1.10724181e-01f, 1.97791215e-02f, -1.46002918e-02f, -2.39924360e-02f, 4.65301424e-02f, 3.11619416e-02f, -2.69704894e-03f, 3.00234836e-02f,
  4.73795971e-03f, 6.22277483e-02f, -1.07054107e-01f, -8.19696635e-02f, -9.15179551e-02f, 5.32287098e-02f, 1.29536822e-01f, -2.35347766e-02f, -5.14925644e-02f, -9.37260315e-02f,
  4.85466048e-02f, -6.44790530e-02f, 2.40699425e-02f, -7.37705603e-02f, 4.98306602e-02f, 1.69202802e-03f, 1.66624021e-02f, 6.76674247e-02f, -7.95739591e-02f, -1.55543471e-02f,
  -6.58125654e-02f, 1.13050923e-01f, 8.12250078e-02f, 1.18403668e-02f, -8.46670792e-02f, -1.39638968e-02f, 2.00070422e-02f, 4.58155423e-02f, -4.00679782e-02f, 2.91507449e-02f,
  -1.04891263e-01f, -1.03077747e-01f, -1.15398495e-02f, 5.66930436e-02f, 1.06424838e-02f, -2.48628203e-02f, 1.02669019e-02f, 4.36098501e-02f, -6.77075461e-02f, 1.64897088e-02f,
  -7.57184997e-02f, -4.46192324e-02f, -8.75480473e-02f, 2.18253285e-02f, -7.48454913e-05f, 5.82541488e-02f, -8.45828056e-02f, -3.16462503e-03f, -9.65833813e-02f, 7.52625405e-04f,
  4.83315773e-02f, -1.82368271e-02f, -7.95947481e-03f, 3.38536315e-03f, -2.23990083e-02f, -4.80660573e-02f, 6.08762838e-02f, -2.52499152e-02f, -5.70935644e-02f, 3.31971161e-02f,
  9.55368206e-02f, -1.15063310e-01f, -5.07848822e-02f, 1.43523300e-02f, -2.91185062e-02f, 3.19949649e-02f, 3.33163477e-02f, -8.42658728e-02f, -4.18736190e-02f, 4.09005247e-02f,
  1.12011163e-02f, 5.49547374e-02f, -1.33040864e-02f, 3.75880077e-02f, 5.09354882e-02f, -5.02159074e-02f, 8.01379140e-03f, 3.42347063e-02f, -1.00591183e-01f, -1.03439987e-02f,
  6.92928908e-03f, 6.58704340e-02f, 6.10635355e-02f, -7.87795037e-02f, -7.73854628e-02f, 4.08987552e-02f, -5.24781412e-03f, 1.02192359e-02f, -5.21441102e-02f, -6.41142130e-02f,
  -6.46489933e-02f, 8.04744475e-03f, 1.27773359e-01f, 2.07875744e-01f, 3.23036283e-01f, 1.98896185e-01f, 3.24999511e-01f, 1.08399726e-01f, 4.34918702e-02f, 6.26198947e-02f,
  -2.14911513e-02f, 7.63645256e-03f, -9.78052095e-02f, -1.19780507e-02f, 2.88834367e-02f, 5.24841398e-02f, 2.02320859e-01f, -3.26574109e-02f, 9.22362953e-02f, 4.15168703e-02f,
  9.76229981e-02f, -4.63874405e-03f, -1.75301030e-01f, -4.93242629e-02f, 1.81850076e-01f, 2.92545334e-02f, 1.04553901e-01f, 5.33915423e-02f, -9.39728320e-02f, -5.85221462e-02f,
  -1.73546568e-01f, 5.76468222e-02f, 7.91815817e-02f, -8.66720751e-02f, 1.07788227e-01f, 6.67826738e-03f, 5.83462010e-04f, -4.61212359e-02f, 4.54803966e-02f, -1.46321163e-01f,
  -6.23778533e-03f, -1.08753713e-02f, -1.42182540e-02f, 1.78326424e-02f, 2.96111349e-02f, -7.06067905e-02f, 3.33242267e-02f, -4.33893278e-02f, 7.39007369e-02f, -6.07731193e-02f,
  3.41193192e-02f, 2.51356140e-02f, 5.28562926e-02f, 7.95967877e-02f, 7.15958774e-02f, 5.18363304e-02f, 7.53895938e-02f, -9.53372475e-03f, 5.20123914e-02f, -1.20937385e-01f,
  -1.42756896e-02f, -4.70832773e-02f, -2.44292915e-02f, -3.20533663e-02f, -2.91706044e-02f, 8.82282108e-02f, -9.34882984e-02f, 6.38331100e-03f, 6.71309307e-02f, -8.48987550e-02f,
  1.80512536e-02f, -4.75609340e-02f, 5.93295768e-02f, -2.15553050e-03f, -6.72478741e-03f, 2.73061004e-02f, 7.86211342e-03f, 1.06658489e-02f, -5.04473001e-02f, 2.02637091e-02f,
  -7.13275746e-02f, 1.40896544e-01f, 7.05254301e-02f, 2.21667085e-02f, -2.55875383e-02f, 8.30837563e-02f, 6.54451847e-02f, 1.33701432e-02f, 5.64292297e-02f, -3.60783897e-02f,
  -7.00431168e-02f, 4.30731587e-02f, -1.40238598e-01f, -6.84112832e-02f, -4.66668159e-02f, -2.01624781e-01f, -5.69058694e-02f, -5.90784699e-02f, 2.77920961e-02f, -7.90635645e-02f,
  -3.66924591e-02f, -8.00393149e-03f, -8.94010663e-02f, 3.96055207e-02f, 6.23163991e-02f, -2.16312762e-02f, 4.56161574e-02f, 1.07364602e-01f, 4.34654057e-02f, 3.82701904e-02f,
  -5.37063293e-02f, 1.07585885e-01f, 1.22804075e-01f, 5.12820296e-02f, -1.44139901e-02f, 1.11643113e-01f, 5.65873599e-03f, 1.07265897e-01f, 1.93221644e-01f, -6.59405813e-02f,
  3.85791473e-02f, 1.00273162e-01f, -1.72538638e-01f, -7.22190142e-02f, 2.57286076e-02f, -4.49169390e-02f, -1.40675958e-02f, 5.48924319e-03f, -3.88815887e-02f, 1.72695629e-02f,
  -8.84538442e-02f, 2.69007720e-02f, 5.73934577e-02f, 9.35882255e-02f, 1.31286472e-01f, 1.21045291e-01f, 1.57264620e-01f, -4.46584588e-03f, 1.24470498e-02f, 9.03300270e-02f,
  9.05641019e-02f, -5.61541542e-02f, -6.05002306e-02f, 1.53025508e-01f, 1.75324336e-01f, -1.06553502e-01f, -8.53489414e-02f, 3.41781676e-02f, -2.48152129e-02f, 1.32120907e-01f,
  -1.13310978e-01f, 9.91852283e-02f, -2.80125644e-02f, 7.53074884e-02f, -6.97917715e-02f, 5.68728745e-02f, -5.91376051e-02f, 2.07030177e-02f, -2.23642644e-02f, 7.64621049e-02f,
  -9.59685147e-02f, -7.39746019e-02f, -3.63196097e-02f, -4.16558646e-02f, -7.07287043e-02f, -5.78633435e-02f, 2.61492338e-02f, 1.12954184e-01f, -1.46338781e-02f, 4.01183777e-02f,
  7.66335404e-04f, -1.23967014e-01f, -2.77763288e-02f, -2.83430498e-02f, -5.13599329e-02f, -5.40859997e-02f, -3.00815646e-02f, 5.32805622e-02f, -5.85637167e-02f, -6.25769049e-02f,
  -3.17061506e-02f, 8.46265703e-02f, -1.98860131e-02f, 6.06674515e-02f, 5.56632169e-02f, -1.23651968e-02f, 2.19876003e-02f, -2.10981574e-02f, 1.03036121e-01f, 3.12100966e-02f,
  -2.35356987e-02f, -7.71344975e-02f, 1.49686476e-02f, -7.76016526e-03f, 1.34613076e-02f, -8.83677974e-02f, 4.67462502e-02f, 2.90019792e-02f, -1.99424569e-02f, -3.25352419e-03f,
  3.18590971e-03f, -8.34435746e-02f, 1.25869205e-02f, 1.92815717e-02f, 5.13578169e-02f, -1.09425604e-01f, -4.78482768e-02f, -1.44103393e-02f, 5.38143963e-02f, 8.84489417e-02f,
  -1.40623391e-01f, -2.89755873e-02f, -7.56759271e-02f, -1.07778851e-02f, 7.08636716e-02f, -4.34924290e-02f, 8.89811013e-03f, 2.13512387e-02f, 6.99997395e-02f, 2.01227963e-02f,
  -1.35159194e-02f, 2.13091611e-03f, 4.09936719e-02f, -6.89558014e-02f, -1.02790810e-01f, -9.37065333e-02f, -1.79585870e-02f, -5.97729161e-02f, 6.28853887e-02f, -7.51460940e-02f,
  -1.91444457e-02f, 3.17198224e-02f, -6.58433661e-02f, 8.23944062e-02f, 5.10931900e-03f, 3.99526395e-03f, -5.61030656e-02f, 2.31518950e-02f, -3.56119499e-02f, -3.06934696e-02f,
  -9.01201293e-02f, -1.91859901e-01f, -9.58760902e-02f, -3.20858695e-02f, -1.15931883e-01f, -6.14002682e-02f, -6.92938864e-02f, 1.35126740e-01f, 1.10452332e-01f, -1.89507455e-01f,
  -8.18969980e-02f, 1.38992175e-01f, 8.04668106e-03f, 1.48158386e-01f, 5.68694845e-02f, -1.08570829e-01f, -1.94932684e-01f, 3.26979086e-02f, 1.70816630e-01f, 1.90517247e-01f,
  2.69802585e-02f, -9.57483724e-02f, 5.40378466e-02f, 1.28919125e-01f, -1.19324721e-01f, -7.33877718e-02f, -2.19600394e-01f, -1.59496650e-01f, -1.25211747e-02f, -3.12429547e-01f,
  -1.78527534e-02f, 8.32902268e-02f, 3.49811837e-02f, -7.22695664e-02f, -1.59112394e-01f, 1.14890695e-01f, 1.38955731e-02f, -3.76855247e-02f, 3.66869643e-02f, -5.76027073e-02f,
  4.04814184e-02f, 1.74067076e-02f, 3.55978496e-03f, -9.57908183e-02f, -4.09120768e-02f, 5.22783026e-02f, 9.35332105e-03f, 1.88936312e-02f, -3.02261226e-02f, 5.49539458e-03f,
  -9.11247917e-03f, 5.32915555e-02f, 6.00829944e-02f, 1.00877807e-01f, 1.06077127e-01f, 5.98826185e-02f, -9.19014886e-02f, 6.85676038e-02f, -1.04540149e-02f, -2.15083078e-01f,
  -5.36758676e-02f, 4.34126258e-02f, -5.83995581e-02f, -5.39118005e-03f, -5.63739091e-02f, 3.90580148e-02f, 7.43600428e-02f, -7.35903904e-02f, -5.94270192e-02f, 5.11001237e-02f,
  2.35265363e-02f, 5.52679785e-02f, -8.81617051e-03f, -9.98237263e-03f, 2.38549113e-02f, -1.76774655e-02f, 9.92054939e-02f, -1.01096090e-02f, -8.70885234e-03f, 2.04726513e-02f,
  -1.38579914e-02f, 1.02698654e-02f, 4.69525605e-02f, 1.20970137e-01f, -2.69220136e-02f, -8.48918855e-02f, -3.95228108e-03f, 4.68930416e-02f, 1.76461041e-02f, 1.57837272e-02f,
  5.14059961e-02f, -1.06533058e-02f, -7.27939382e-02f, 9.38391015e-02f, -5.01742475e-02f, -8.19951817e-02f, -2.68484019e-02f, -6.86265435e-03f, 5.22732995e-02f, -1.12723894e-02f,
  5.93465231e-02f, 7.20515326e-02f, 1.82818109e-03f, 4.85036476e-03f, 4.08622138e-02f, 8.95918161e-02f, -9.23612714e-02f, -1.62787241e-04f, 9.11180675e-02f, 9.83344018e-02f,
  -5.32909222e-02f, -3.56863290e-02f, 4.29246128e-02f, -3.37350033e-02f, 1.03361987e-01f, 7.68133346e-03f, 7.88803697e-02f, -1.30119443e-01f, -7.21597075e-02f, -2.30808213e-01f,
  -8.63742922e-03f, -9.67247561e-02f, -1.27705680e-02f, -5.70943058e-02f, -7.98694044e-02f, -8.79650041e-02f, -1.18962064e-01f, 5.40269092e-02f, -4.61232401e-02f, -1.37302637e-01f,
  -4.28657159e-02f, 4.40653376e-02f, -9.70193893e-02f, 4.95365076e-02f, -6.38555139e-02f, -7.43154623e-03f, -1.33618027e-01f, -9.20368880e-02f, 8.07844326e-02f, -2.47965548e-02f,
  -2.35748682e-02f, -6.23700209e-02f, -4.64667343e-02f, 6.52988330e-02f, -1.16183087e-01f, -2.45646220e-02f, -9.08127651e-02f, 1.38913300e-02f, -1.37949735e-01f, -6.76774085e-02f,
  -1.51866496e-01f, 2.58360486e-02f, -6.07287697e-02f, -6.59155622e-02f, -1.07935339e-01f, 2.32885145e-02f, -4.71280739e-02f, 8.32412168e-02f, -7.33766109e-02f, 7.08682835e-02f,
  5.26362583e-02f, -6.17297404e-02f, -1.27717527e-02f, 1.13950327e-01f, 2.93135699e-02f, -1.89367998e-02f, 1.80211030e-02f, -3.74323427e-04f, 1.61421001e-02f, 6.77230582e-03f,
  2.81606335e-03f, -7.32243583e-02f, 1.01455860e-01f, 1.19251482e-01f, -2.69459188e-02f, 3.94072644e-02f, 6.52700663e-02f, 3.60189714e-02f, -7.50659779e-02f, -4.15423512e-02f,
  -7.61673674e-02f, 1.03318319e-01f, -4.29320335e-02f, -6.00067824e-02f, 8.99773538e-02f, -1.70201436e-02f, -1.89449731e-02f, 6.05667979e-02f, -2.49022804e-02f, -3.96258421e-02f,
  -5.15188165e-02f, -7.32929036e-02f, 6.05422072e-02f, -7.53821507e-02f, -7.95256793e-02f, 3.63308825e-02f, -4.81225289e-02f, 4.62383516e-02f, 8.48328415e-03f, -1.33958813e-02f,
  -1.21575460e-01f, -1.06094413e-01f, -8.99000913e-02f, -6.42569289e-02f, -1.93066094e-02f, 1.85231306e-02f, -3.79836820e-02f, 1.42471856e-02f, -8.14776197e-02f, -5.58802076e-02f,
  7.25569129e-02f, -1.97242022e-01f, 8.62064883e-02f, 1.12369567e-01f, 6.40883818e-02f, 1.07404910e-01f, 3.74064110e-02f, 1.11579947e-01f, -5.63474484e-02f, -3.02625895e-02f,
  -3.05630341e-02f, 6.15697913e-02f, -7.04127625e-02f, 1.35414347e-01f, 1.04899909e-02f, 2.62612794e-02f, 1.04801478e-02f, 5.93315549e-02f, -2.16775620e-03f, 5.56209050e-02f,
  -4.46625203e-02f, 9.02229846e-02f, -1.50357466e-02f, -2.31191721e-02f, 1.51240434e-02f, -1.55714387e-03f, -4.10511345e-02f, 5.63466400e-02f, -3.74622419e-02f, 3.91492248e-02f,
  1.78603932e-01f, -1.87575325e-01f, 1.68035761e-01f, 3.95678245e-02f, -1.53607637e-01f, -1.04758687e-01f, -2.71624714e-01f, -1.68006688e-01f, 6.59777597e-02f, -3.82605493e-02f,
  8.29243362e-02f, 1.46253094e-01f, 7.89785832e-02f, 2.80134398e-02f, -5.40528893e-02f, -1.41095206e-01f, 1.28076524e-01f, 1.96633697e-01f, 1.19571552e-01f, 7.80467167e-02f,
  -8.13551620e-02f, 1.13872856e-01f, 2.14430183e-01f, 1.12239895e-02f, 1.08770214e-01f, 1.43981516e-01f, 1.67366177e-01f, 1.48731932e-01f, 1.15962170e-01f, 1.32176101e-01f,
  1.32170960e-01f, -1.66500255e-01f, 9.98869836e-02f, 5.15938550e-02f, 3.63729894e-02f, -1.44693851e-01f, -1.10965848e-01f, 1.31734535e-01f, -4.43603173e-02f, 4.69730347e-02f,
  1.09754326e-02f, 3.27174701e-02f, -7.24373087e-02f, 1.28732277e-02f, -6.59174770e-02f, -6.46185316e-03f, 3.08008119e-02f, 2.51267888e-02f, -6.30074739e-02f, -4.17798795e-02f,
  -4.06590365e-02f, -2.83941869e-02f, -1.06085036e-02f, -9.38868970e-02f, 1.86349824e-02f, 7.27595463e-02f, 7.22118169e-02f, 8.51789564e-02f, 1.29013984e-02f, 6.32339865e-02f,
  1.28236905e-01f, 6.22932650e-02f, 6.51884675e-02f, -2.23298874e-02f, 6.09460799e-03f, 4.43522781e-02f, 3.74601521e-02f, 5.06598838e-02f, 1.07101426e-01f, 1.76761094e-02f,
  6.07139710e-03f, 5.58624184e-03f, -5.76958805e-02f, -4.56982143e-02f, 3.51800025e-03f, 1.96835231e-02f, 2.53828205e-02f, 6.68492988e-02f, 1.02218814e-01f, -5.88448569e-02f,
  1.10576287e-01f, -1.84140448e-02f, 1.72573179e-02f, 1.25692356e-02f, -1.09184999e-02f, -2.32421476e-02f, 7.15042204e-02f, -7.80643150e-02f, -2.28510313e-02f, 3.65673490e-02f,
  -5.27482815e-02f, 1.69814508e-02f, 7.90081918e-02f, -5.44211343e-02f, -5.03774919e-03f, -2.60820556e-02f, 4.78190894e-04f, 1.89824644e-02f, -4.80388943e-03f, -1.01356665e-02f,
  -1.51879877e-01f, -3.91509850e-04f, -1.62297282e-02f, 1.90316830e-02f, 3.72628346e-02f, -2.21029446e-02f, 3.94524150e-02f, 5.46607152e-02f, 5.45952395e-02f, -4.48716152e-03f,
  -1.27633642e-02f, -1.00321490e-02f, -7.85765201e-02f, -1.31523535e-01f, -3.70184891e-02f, -2.36978550e-02f, -2.25996766e-02f, 7.59984553e-02f, 3.56817991e-02f, -1.12491369e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -1.38762994e-02f, 2.68865108e-01f, 1.07144572e-01f, -2.25193165e-02f, -3.49313170e-02f, -9.02298987e-02f, 1.13297462e-01f, -6.82642907e-02f, -3.03078070e-02f, -3.32342810e-03f,
  2.81694531e-02f, 1.12280950e-01f, -3.50677930e-02f, 8.72319490e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  8.46355632e-02f, -1.41906887e-02f, 7.04392269e-02f, 9.55647603e-02f, 2.47175813e-01f, -8.73999074e-02f, 1.22424945e-01f, 2.32127935e-01f, -1.47823885e-01f, -2.90976912e-01f,
  2.76682854e-01f, -4.82354194e-01f, 4.33735491e-04f, -2.10184120e-02f, 1.99667141e-01f, 1.11372694e-01f, -5.36373556e-02f, 3.48122656e-01f, -7.19969049e-02f, -4.26728785e-01f,
  -1.41677305e-01f, -1.79277539e-01f, -1.51662946e-01f, -6.51433840e-02f, 2.33950745e-02f, -1.87753141e-01f, 1.81959500e-03f, 1.06825203e-01f, 5.83862625e-02f, -2.43010864e-01f,
  2.31761746e-02f, 6.15400858e-02f, 3.10676582e-02f, -7.58879483e-02f, 9.92455631e-02f, 2.62906086e-02f, -1.11605667e-01f, 1.76987171e-01f, -8.79141539e-02f, -2.98925281e-01f,
  9.64250565e-02f, 2.16861144e-01f, 6.74277321e-02f, 4.14864272e-02f, 2.66982913e-02f, -2.43540749e-01f, 2.08629798e-02f, 1.78426996e-01f, -3.53004068e-01f, -4.45924938e-01f,
  -1.00194566e-01f, 1.81966260e-01f, -5.18384911e-02f, 1.85122788e-01f, -5.47985733e-02f, 2.69685626e-01f, 8.20293650e-02f, 1.11146010e-01f, -1.18123926e-01f, -2.50467002e-01f,
  -1.74115315e-01f, 3.40160638e-01f, 1.21977972e-02f, -1.26155898e-01f, -1.24669351e-01f, -1.36691585e-01f, -2.42052883e-01f, 8.29136074e-02f, 2.05061018e-01f, -1.92378148e-01f,
  4.40523289e-02f, 1.04199983e-01f, 1.26496442e-02f, 7.10826665e-02f, -1.93769306e-01f, -3.37328345e-01f, 1.24600790e-01f, -9.70685184e-02f, -1.65689856e-01f, -2.31808543e-01f,
  -1.48935258e-01f, 6.10571094e-02f, 3.99403200e-02f, -3.21882278e-01f, 2.90984690e-01f, -4.26319420e-01f, -1.09495251e-02f, 1.42186582e-01f, 8.90238285e-02f, -4.93774712e-01f,
  2.11579874e-01f, -7.01058283e-02f, 6.63348753e-03f, 3.50976884e-01f, 2.19863951e-01f, 2.48495474e-01f, 6.77642673e-02f, -1.40969500e-01f, 1.46880552e-01f, -3.10046673e-01f,
  -1.62121966e-01f, -4.72830951e-01f, -2.60205299e-01f, -2.38469630e-01f, 4.00087796e-02f, 6.12693280e-02f, 3.28828186e-01f, -2.22550616e-01f, 2.29950964e-01f, -3.87394160e-01f,
  -7.26307034e-02f, 2.54995227e-01f, -4.34338301e-02f, 1.01111084e-01f, 2.76682913e-01f, -3.34394246e-01f, -2.02843219e-01f, 2.28740070e-02f, -1.33406948e-02f, 1.16638958e-01f,
  1.01452351e-01f, -7.14712068e-02f, 4.74154390e-02f, 1.21149629e-01f, 1.55038655e-01f, -9.50476900e-02f, -2.66155899e-01f, 5.63248731e-02f, -9.65807512e-02f, 1.44361898e-01f,
  -1.12906210e-01f, -9.21465009e-02f, 2.30332851e-01f, -1.92774951e-01f, 2.75214583e-01f, -1.98936075e-01f, -2.75288343e-01f, -1.59566790e-01f, -1.11344039e-01f, 4.72431481e-01f,
  -1.31120563e-01f, 3.84683043e-01f, 3.54046434e-01f, -5.88559359e-02f, 1.60208091e-01f, 8.49592462e-02f, 9.74955335e-02f, 3.75128180e-01f, 1.66015327e-01f, 3.41671377e-01f,
  -1.56855702e-01f, -3.79296184e-01f, 4.90686446e-02f, 2.60181222e-02f, -1.41065404e-01f, 4.03454453e-01f, 2.57674873e-01f, -4.98138973e-03f, -1.42447591e-01f, -4.28548515e-01f,
  2.45610982e-01f, -2.73223162e-01f, -1.35474086e-01f, -1.56982958e-01f, -1.20024562e-01f, 1.65213481e-01f, -6.92368671e-02f, -1.72776327e-01f, 1.33330986e-01f, 3.48774940e-01f,
  -2.33229399e-02f, -3.44472826e-01f, 5.36678284e-02f, -1.90831259e-01f, -1.52229726e-01f, 2.72778217e-02f, 8.05563703e-02f, -2.10732460e-01f, -2.89588660e-01f, -1.12610823e-02f,
  9.12757367e-02f, 5.24462089e-02f, 8.49249735e-02f, 3.18887115e-01f, 1.83135197e-01f, -6.44167885e-02f, -1.07622296e-01f, -9.86430869e-02f, -9.36012119e-02f, -5.77286743e-02f,
  -9.94393304e-02f, 8.08610320e-02f, -9.17674974e-02f, 2.59218454e-01f, 2.34637260e-02f, -3.28225903e-02f, -8.36539045e-02f, 2.12024912e-01f, 1.20768748e-01f, -7.63981193e-02f,
  -1.52255505e-01f, -3.84324566e-02f, -9.38448682e-02f, 3.26414853e-01f, 2.13883221e-02f, 7.04155490e-02f, -4.64510098e-02f, -1.19164944e-01f, -9.30881128e-02f, -4.54991572e-02f,
  2.26683006e-01f, 2.12520689e-01f, -6.64828047e-02f, 2.12534606e-01f, 9.93992612e-02f, -9.58444774e-02f, -8.96579102e-02f, 7.63758644e-02f, 4.09845486e-02f, 1.22301608e-01f,
  -2.25142762e-01f, 1.41526952e-01f, 7.35210925e-02f, -2.05838472e-01f, 2.25061670e-01f, -2.63391256e-01f, -3.61959010e-01f, -2.99161822e-01f, -1.52588174e-01f, 8.50125849e-02f,
  -4.09278646e-02f, -9.27099437e-02f, 1.24939449e-01f, 1.01749428e-01f, -3.08857024e-01f, -1.40888244e-01f, -2.48279363e-01f, 4.55516279e-02f, -1.38308911e-03f, -1.94702998e-01f,
  -3.93228740e-01f, -1.25311017e-01f, -5.16297258e-02f, -1.33626938e-01f, 1.47200182e-01f, -3.21102560e-01f, -6.60719946e-02f, 2.96883345e-01f, 5.84894083e-02f, -2.77447790e-01f,
  1.98742431e-02f, -3.18489373e-01f, 3.10272053e-02f, 1.43676639e-01f, 1.01449087e-01f, 2.05654562e-01f, 4.20405455e-02f, -1.82895392e-01f, 8.05028081e-02f, 1.29129097e-01f,
  -4.96459976e-02f, 2.15493977e-01f, -1.53925762e-01f, 1.89363807e-01f, 4.59276363e-02f, -7.62723982e-02f, 1.75812319e-01f, -2.75881924e-02f, -9.86731648e-02f, -2.08046168e-01f,
  -6.90325946e-02f, 5.12777343e-02f, -3.03553522e-01f, -8.73361081e-02f, 2.87055802e-02f, -2.31970936e-01f, -1.01724021e-01f, -1.09602407e-01f, 2.09299207e-01f, 1.29917637e-01f,
  2.23182261e-01f, -1.51314467e-01f, 9.99450684e-02f, -4.61044088e-02f, 8.12048540e-02f, 1.45871252e-01f, -3.29453386e-02f, 3.00580472e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.47042096e-01f, 5.63752800e-02f, 1.94800034e-01f, -2.82109771e-02f, -1.95518643e-01f, -5.46246096e-02f, -1.10971391e-01f, 1.54100751e-04f, -1.59948006e-01f, 1.07168995e-01f,
  1.40481338e-01f, 1.04300410e-01f, -1.25896603e-01f, 4.42235917e-02f, 1.87039956e-01f, -6.44508749e-02f, 8.60296413e-02f, -1.07600473e-01f, -1.49452537e-01f, -9.93484538e-03f,
  -1.43224329e-01f, 1.96871385e-01f, -1.04585491e-01f, -1.61522180e-01f, 1.44911289e-01f, 2.90913612e-01f, 1.01400957e-01f, 7.03991801e-02f, 1.40456021e-01f, -6.07303008e-02f,
  6.29646033e-02f, 2.68129945e-01f, -1.37348250e-01f, 6.53696731e-02f, 6.54711723e-02f, -8.02521706e-02f, -1.65615961e-01f, -3.50747481e-02f, -1.51256546e-01f, -2.19978187e-02f,
  -1.24051400e-01f, -1.68074444e-02f, 1.25231713e-01f, -1.27591500e-02f, -6.52765110e-02f, -1.22555397e-01f, 9.78693962e-02f, -8.91440436e-02f, -9.91467834e-02f, -1.29335839e-02f,
  -5.91131002e-02f, 1.57901347e-01f, -2.00451408e-02f, 2.06061482e-01f, 1.18576223e-02f, 2.74095759e-02f, -9.33422148e-02f, 7.78790861e-02f, -5.11717536e-02f, 2.39047781e-02f,
  4.78518344e-02f, 1.46012172e-01f, -5.64052388e-02f, 3.66412080e-03f, -1.93745978e-02f, -5.20824939e-02f, 1.13559790e-01f, -1.08962037e-01f, 1.32051669e-03f, -1.34356305e-01f,
  -1.58586487e-01f, -8.45583677e-02f, -9.50587690e-02f, -1.38352076e-02f, -4.93754484e-02f, -1.16519585e-01f, -8.60648695e-03f, 6.19458742e-02f, 1.14030324e-01f, 7.16448650e-02f,
  8.15441739e-03f, 8.35044235e-02f, 3.06370966e-02f, 5.27186505e-02f, -1.35950133e-01f, -2.71528549e-02f, -1.54959047e-02f, 6.86531216e-02f, -1.37192503e-01f, 6.36067241e-02f,
  -9.54983383e-02f, 5.75210620e-03f, -1.13319784e-01f, 7.25723952e-02f, -1.72200769e-01f, 8.76980126e-02f, -7.53581971e-02f, -1.70597896e-01f, -2.09529996e-01f, 1.67205017e-02f,
  1.71038568e-01f, -7.76867662e-03f, -1.31317079e-01f, -2.27761660e-02f, 1.23422958e-01f, -1.48622975e-01f, -1.22366235e-01f, 1.09545805e-01f, 1.62547007e-01f, 7.12732226e-02f,
  -3.26173101e-03f, -1.84124365e-01f, 2.13861704e-01f, -1.39199356e-02f, 1.15663938e-01f, -3.10543813e-02f, -7.08239898e-02f, 7.18250498e-02f, -9.81797501e-02f, 9.90310609e-02f,
  -4.48793434e-02f, 1.30288154e-01f, 7.24434480e-02f, 5.93158826e-02f, 3.33437659e-02f, -1.68790996e-01f, 3.29413190e-02f, 6.23477623e-02f, -1.21992894e-01f, -9.32873562e-02f,
  -4.76141199e-02f, -1.13543205e-01f, 1.46879554e-01f, 1.97296828e-01f, 1.51201621e-01f, 3.86011526e-02f, -5.25868870e-02f, 2.40767464e-01f, 1.60168573e-01f, 1.33170620e-01f,
  -1.67919591e-01f, -1.10716701e-01f, -6.10648319e-02f, 1.42430276e-01f, -1.18998677e-01f, -8.38825330e-02f, 1.66098904e-02f, 2.16524258e-01f, -6.95194155e-02f, 2.60766834e-01f,
  -1.89677209e-01f, -1.77957192e-01f, 2.49342352e-01f, -8.77640792e-04f, -1.72150865e-01f, 2.74375021e-01f, -8.28124210e-02f, 2.24438235e-01f, 7.68193677e-02f, 1.47315979e-01f,
  1.52528077e-01f, 2.25258663e-01f, -1.77827887e-02f, 2.35647917e-01f, 1.40410811e-01f, 3.04866374e-01f, 1.91483453e-01f, 8.73340741e-02f, -5.99867702e-02f, 2.85638571e-01f,
  -2.05205560e-01f, 1.74984932e-01f, -2.41092414e-01f, 2.04212934e-01f, 1.70354217e-01f, -8.27480629e-02f, -1.41137615e-01f, -3.28857511e-01f, -1.09183073e-01f, 4.28573072e-01f,
  1.46256566e-01f, 2.02885032e-01f, 1.54741034e-01f, -3.29039656e-02f, 2.18646452e-01f, 2.77776748e-01f, -2.09499091e-01f, 4.76296730e-02f, -1.11403264e-01f, 2.55220354e-01f,
  2.83094466e-01f, 1.40700951e-01f, 1.07095778e-01f, 2.60287765e-02f, 8.06856528e-02f, -1.74969807e-01f, -1.61761686e-01f, 2.22111251e-02f, 2.47548893e-02f, -9.72907245e-02f,
  -8.48019961e-03f, -1.58994153e-01f, 7.64117315e-02f, -1.17150716e-01f, 1.41766608e-01f, 7.82781988e-02f, 7.28457868e-02f, 1.00188032e-01f, -1.76106840e-01f, -6.45813644e-02f,
  8.42839405e-02f, -1.29554421e-01f, 1.01281181e-01f, 1.42043054e-01f, 1.93621144e-02f, -2.39745639e-02f, 9.22229607e-03f, 4.84947152e-02f, -1.38035014e-01f, -1.83713034e-01f,
  -4.00188267e-02f, -1.39680892e-01f, -1.43035334e-02f, -6.14850433e-04f, 9.01928097e-02f, 4.01559770e-02f, -4.60612774e-02f, -7.31487125e-02f, -1.52659997e-01f, 1.14530019e-01f,
  5.95170483e-02f, -2.91508790e-02f, 1.38826758e-01f, -7.65025318e-02f, 1.09202124e-01f, 1.06785938e-01f, -8.49144012e-02f, 1.06152102e-01f, 3.76454578e-03f, 1.73311606e-01f,
  -1.51451424e-01f, 1.53165534e-01f, -1.42652005e-01f, -1.45695135e-01f, 9.97864380e-02f, -7.49125257e-02f, -7.29258060e-02f, 1.36935905e-01f, -7.89792314e-02f, -3.84501591e-02f,
  -1.38327107e-01f, 2.29105540e-02f, 7.94190243e-02f, -1.81105971e-01f, 6.33057579e-02f, 2.49185618e-02f, -6.57865405e-02f, -2.82419007e-02f, -9.26736370e-02f, -1.25300800e-02f,
  -1.25213891e-01f, -1.53015286e-01f, -6.71397895e-02f, 7.93728009e-02f, 1.03346750e-01f, -8.86998326e-02f, 1.72279462e-01f, -3.88335511e-02f, -1.31580949e-01f, 1.53792828e-01f,
  6.74512610e-02f, 9.82943401e-02f, -1.01964772e-01f, -8.36388394e-02f, -5.05839027e-02f, 7.73472488e-02f, 6.93484247e-02f, 8.64343941e-02f, -1.68910757e-01f, -5.79055399e-02f,
  -4.40791957e-02f, 8.73503461e-02f, -1.59587249e-01f, 9.62717235e-02f, -3.93728986e-02f, 9.58962459e-03f, -1.99420471e-02f, 1.24050044e-01f, 3.33051294e-01f, -7.36356080e-02f,
  4.04542461e-02f, 1.52470442e-02f, 3.36762875e-01f, -2.98987567e-01f, 3.14749837e-01f, 4.80294460e-03f, 1.11257300e-01f, 4.64883167e-04f, 1.32406130e-01f, -1.46847025e-01f,
  2.78187156e-01f, 9.68688130e-02f, 4.24260721e-02f, -1.79007947e-01f, 3.63270968e-01f, 3.32901359e-01f, 8.49374086e-02f, 8.87156352e-02f, 2.98050474e-02f, 1.77502200e-01f,
  -1.81185409e-01f, 6.66550547e-02f, -1.47249833e-01f, 1.79896429e-01f, 2.07011491e-01f, 3.18338960e-01f, 2.05986485e-01f, -1.51681438e-01f, -3.90935019e-02f, 7.33518079e-02f,
  1.15333330e-02f, -5.03079779e-02f, -3.46959606e-02f, -9.73749608e-02f, 1.48226947e-01f, 1.59979254e-01f, 1.18103102e-01f, -7.40433186e-02f, -1.59777090e-01f, -5.59781715e-02f,
  7.93295726e-02f, 1.49689868e-01f, 1.34535089e-01f, 9.32540931e-03f, -1.81931153e-01f, 6.92885965e-02f, 1.08798660e-01f, -5.20426929e-02f, 2.13755250e-01f, -7.07464889e-02f,
  -1.65548101e-01f, 1.24115255e-02f, -4.95098680e-02f, -1.28881127e-01f, 1.00694083e-01f, 4.28395718e-02f, 1.79479551e-02f, 3.61517295e-02f, -7.85161704e-02f, -5.37305102e-02f,
  -3.88543010e-02f, 3.66959050e-02f, 2.78653264e-01f, 2.23443303e-02f, 8.08495209e-02f, 2.24767122e-02f, 1.50405020e-01f, 5.05926460e-02f, 1.83978975e-01f, -4.47058640e-02f,
  8.68561342e-02f, -7.12742954e-02f, -2.54358172e-01f, 7.92154446e-02f, 1.72820121e-01f, 1.12678818e-01f, 7.61365518e-02f, -1.04707852e-01f, 1.48264691e-01f, 4.19271812e-02f,
  -1.23092927e-01f, 1.02395691e-01f, 1.10704668e-01f, 3.53163630e-02f, -1.52759641e-01f, -1.44948527e-01f, -1.97055891e-01f, 2.88233966e-01f, -8.23932514e-02f, 4.96177236e-03f,
  -6.25605881e-02f, -1.21794641e-01f, 2.30950676e-02f, -2.06288755e-01f, 1.45057395e-01f, -1.52723625e-01f, 9.16428119e-02f, 5.92067130e-02f, -1.51316207e-02f, 4.26667601e-01f,
  8.25498179e-02f, -5.05068991e-03f, 4.94317785e-02f, -6.43885136e-02f, -7.30073778e-03f, -8.67145807e-02f, -2.47771353e-01f, 4.10212092e-02f, 1.23212412e-02f, 1.85995236e-01f,
  -3.71710747e-01f, -7.17870742e-02f, 2.70821542e-01f, -1.58165826e-03f, 1.87877595e-01f, 2.65827417e-01f, 1.90765202e-01f, 2.77934492e-01f, 9.37607884e-02f, 1.43792287e-01f,
  -1.85197666e-01f, -1.45613002e-02f, -1.14185929e-01f, 4.03103620e-01f, 2.19791591e-01f, 1.57765701e-01f, 4.09602255e-01f, -6.89945929e-03f, 1.80491116e-02f, 4.33771238e-02f,
  2.20785454e-01f, 1.48772271e-02f, 1.81959709e-03f, -8.11575055e-02f, -7.44807348e-03f, -2.56177366e-01f, 2.27932081e-01f, -2.69023150e-01f, 4.24264697e-03f, 5.38082831e-02f,
  1.85776040e-01f, 5.68033941e-03f, -6.74503222e-02f, 4.08370644e-01f, 2.10667308e-02f, -2.14105006e-02f, -8.09135213e-02f, 2.01502040e-01f, 1.04699425e-01f, -1.97294354e-01f,
  -3.31339575e-02f, 2.66229808e-01f, -1.52405545e-01f, 2.66515136e-01f, 2.87656426e-01f, -4.48828824e-02f, -3.39305997e-02f, 8.63403901e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.53963104e-01f, -8.84436965e-02f, -7.83603638e-02f, 1.98645890e-01f, -1.76870868e-01f, 3.21493000e-01f, -8.45904946e-02f, -1.59621343e-01f, -1.53977841e-01f, 2.86405355e-01f,
  -1.43379718e-01f, 5.88274039e-02f, 1.15558967e-01f, 1.29126146e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.92284495e-01f, -1.51219577e-01f, -5.17989285e-02f, -2.53942817e-01f, 1.81480348e-01f, -1.28597558e-01f, -9.40390751e-02f, -1.14022322e-01f, 2.69838005e-01f, -9.38436761e-02f,
  -1.18506894e-01f, 7.12120160e-02f, 1.80192534e-02f, 2.30815902e-01f, -2.84688741e-01f, 1.63016096e-01f, -2.93632388e-01f, -1.21285550e-01f, -1.00063287e-01f, 3.46507877e-02f,
  -3.10688913e-02f, -2.31477749e-02f, -2.30362624e-01f, -1.28649577e-01f, 5.62673286e-02f, 7.30713308e-02f, 7.23684654e-02f, 2.04726532e-01f, -1.57369584e-01f, 1.10373966e-01f,
  -2.44301870e-01f, 1.82635859e-02f, -2.14034289e-01f, -3.20242252e-04f, 1.28581792e-01f, 9.14813802e-02f, -2.74992436e-01f, 1.26213476e-01f, -1.29745081e-01f, 1.58116087e-01f,
  -2.51511157e-01f, 1.88668609e-01f, -2.43752852e-01f, 6.62133023e-02f, 5.09683907e-01f, 2.69047558e-01f, 3.32800373e-02f, -3.13764632e-01f, -1.31932944e-01f, -7.73974285e-02f,
  -2.18697816e-01f, 1.36866078e-01f, -4.61037531e-02f, 1.99897602e-01f, -2.25704357e-01f, -2.50055641e-01f, 8.77792835e-02f, 9.50543582e-02f, -9.15391520e-02f, 4.02778983e-01f,
  -9.66104940e-02f, 1.93559453e-01f, 5.79200387e-02f, 1.99631333e-01f, 8.26293603e-02f, 2.91843504e-01f, 2.04418942e-01f, 1.86212361e-01f, 1.77430302e-01f, 1.39464557e-01f,
  -6.92239404e-02f, 1.38667539e-01f, 6.40600314e-03f, -3.92666669e-04f, -8.74218568e-02f, -2.85374671e-01f, 1.21473130e-02f, 1.40182272e-01f, 2.73738485e-02f, -2.71368593e-01f,
  -4.66059297e-01f, -3.46676201e-01f, 9.42786336e-02f, -3.00699621e-02f, 5.53701855e-02f, 2.34805539e-01f, -2.95861900e-01f, -1.52453512e-01f, 6.26111627e-02f, 1.31085115e-02f,
  -2.73574516e-02f, 2.67222643e-01f, 8.75184983e-02f, 2.04866827e-01f, -3.17953289e-01f, 3.29514176e-01f, -2.76385605e-01f, -1.24306001e-01f, -2.91922122e-01f, 3.50553654e-02f,
  3.55943501e-01f, 2.05162406e-01f, -1.67277798e-01f, -2.75057375e-01f, 1.36955768e-01f, -2.17411444e-01f, 1.34973451e-01f, -6.54729269e-03f, -1.41592279e-01f, 3.71394366e-01f,
  -1.35811910e-01f, 2.67611295e-01f, -5.61056621e-02f, -2.15631351e-01f, 1.66978925e-01f, 1.08581305e-01f, 1.47449389e-01f, -1.83220059e-01f, 9.45122167e-02f, 1.59134910e-01f,
  -7.35486150e-02f, -1.31765082e-01f, 2.99297944e-02f, -8.93719611e-04f, -1.72433496e-01f, 9.59621221e-02f, 1.62663296e-01f, 4.50834185e-02f, 1.34084299e-01f, -1.09460205e-02f,
  2.79801220e-01f, -2.97470748e-01f, 2.45371368e-02f, 1.51964948e-01f, 1.73338950e-01f, 1.21630891e-03f, -1.12153463e-01f, 7.32140392e-02f, -5.39717853e-01f, -1.29084378e-01f,
  -2.70943455e-02f, 4.10515845e-01f, -3.56051356e-01f, 1.88970581e-01f, 2.72504631e-02f, -2.19467834e-01f, -2.93948025e-01f, -1.65302530e-01f, 2.70712059e-02f, -8.55339319e-02f,
  -2.03803137e-01f, -1.83741018e-01f, -2.66801547e-02f, -5.63030392e-02f, 9.10006315e-02f, 2.33719453e-01f, -1.17339924e-01f, 1.02187417e-01f, -3.95594865e-01f, 1.53541565e-01f,
  1.50257666e-02f, -4.15653847e-02f, 3.91842797e-03f, -9.60814357e-02f, 9.14851576e-02f, -1.13485023e-01f, -7.25150704e-02f, 2.46638641e-01f, -6.93862066e-02f, -1.61993839e-02f,
  1.15127750e-01f, 1.50712550e-01f, -1.98672041e-01f, -3.52618456e-01f, 1.63699225e-01f, 1.48860691e-02f, 3.19085985e-01f, -2.30894536e-02f, 1.05937660e-01f, -1.51305124e-01f,
  -9.03317630e-02f, -4.42452580e-02f, -1.45735800e-01f, 4.12258089e-01f, -1.31960973e-01f, 1.71277687e-01f, -8.06799084e-02f, -3.07411045e-01f, -1.37822390e-01f, -4.83887382e-02f,
  -9.06417668e-02f, -4.32114869e-01f, -1.20711878e-01f, -2.62708124e-03f, -2.44790822e-01f, 7.50029460e-02f, 2.17174038e-01f, -4.71565947e-02f, -2.26923630e-01f, -2.53091156e-01f,
  -5.40049300e-02f, 1.27873361e-01f, -2.72277653e-01f, -3.30210149e-01f, -1.12049691e-01f, 2.24188685e-01f, -2.48119205e-01f, 2.94261221e-02f, -3.10423225e-01f, -2.58132100e-01f,
  6.07049325e-03f, 2.84872297e-02f, 1.68702342e-02f, 1.76483821e-02f, 2.09878698e-01f, -4.45497409e-02f, -3.25985886e-02f, -4.86743003e-02f, -8.85937661e-02f, 1.29186362e-01f,
  3.91949303e-02f, 5.27384095e-02f, -8.85359645e-02f, 3.58187795e-01f, 2.04104800e-02f, 2.53644556e-01f, -2.29334339e-01f, -1.05554484e-01f, 2.17633858e-01f, 9.88981500e-02f,
  1.51441824e-02f, -1.71743467e-01f, -1.63120344e-01f, -2.24202126e-01f, 1.53937638e-01f, -1.98927492e-01f, -4.70244467e-01f, 1.81309238e-01f, -2.90399522e-01f, 6.53066486e-02f,
  1.04514666e-01f, -2.08105624e-01f, 3.34528759e-02f, -4.95410860e-02f, -4.48729806e-02f, 4.11117934e-02f, 6.41577318e-02f, 2.62443453e-01f, -3.07132620e-02f, -1.16578110e-01f,
  9.22446847e-02f, -8.94216150e-02f, 1.09828942e-01f, -1.83646195e-02f, 2.12483361e-01f, 8.58017206e-02f, -5.31777442e-02f, -1.37304783e-01f, -4.21700664e-02f, -2.12759208e-02f,
  1.37410074e-01f, -1.76283807e-01f, -1.03376292e-01f, -1.63171560e-01f, -8.28257650e-02f, -2.39506856e-01f, 2.56296307e-01f, -1.67870969e-01f, -5.38624883e-01f, -1.30035225e-02f,
  -3.39261472e-01f, 3.51749420e-01f, 2.31148928e-01f, 1.72178254e-01f, 4.70177345e-02f, -1.43224373e-01f, 4.95071635e-02f, -1.53028071e-01f, 8.28907192e-02f, 1.49262354e-01f,
  1.29301220e-01f, 8.12084228e-02f, 7.73236454e-02f, -2.94521034e-01f, -8.09165686e-02f, -5.86673208e-02f, 2.96123028e-01f, -1.93429053e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.83731809e-01f, -7.25612640e-02f, -1.44880369e-01f, 1.18023120e-01f, 2.88483739e-01f, 1.66700482e-01f, 1.97423980e-01f, -8.78748745e-02f, 2.42483094e-01f, -3.44195187e-01f,
  2.47415036e-01f, -5.33052623e-01f, -4.35209721e-01f, 4.94155794e-01f, -2.79932648e-01f, 3.60936880e-01f, -3.85385990e-01f, -3.12581211e-01f, 1.87656641e-01f, -1.67803522e-02f,
  -1.24245316e-01f, -1.11965604e-01f, 3.07641536e-01f, 7.27618575e-01f, -2.10723393e-02f, 4.79556154e-03f, -1.25723958e-01f, 1.48494884e-01f, -2.56420612e-01f, 3.09498519e-01f,
  5.46677858e-02f, 8.97129029e-02f, -8.46105292e-02f, -2.41983071e-01f, -3.13008487e-01f, 1.53863072e-01f, -6.13706708e-02f, 7.77230486e-02f, 7.62456581e-02f, -2.21762866e-01f,
  1.81098819e-01f, -1.45111233e-01f, 3.77132744e-01f, -1.70424312e-01f, 3.94738503e-02f, 1.06107309e-01f, -8.19814205e-02f, 1.91486612e-01f, -5.10986522e-02f, 1.83788925e-01f,
  9.45999697e-02f, -1.26748029e-02f, -5.07927462e-02f, -2.24329859e-01f, 9.11463127e-02f, 1.80349708e-01f, 9.79313627e-02f, -1.36435747e-01f, 4.50728498e-02f, -2.84961998e-01f,
  9.90523472e-02f, -2.36520022e-01f, 3.40528399e-01f, -3.32822092e-02f, 3.53213064e-02f, 1.21997304e-01f, -1.63071007e-01f, 1.27884150e-01f, -9.80762467e-02f, -8.71649832e-02f,
  4.95010708e-03f, -6.19315356e-02f, 1.29473349e-02f, -5.76416105e-02f, 7.88263138e-03f, -1.10749872e-02f, 3.46038565e-02f, 1.85399458e-01f, -5.57300746e-02f, 1.28070012e-01f,
  3.65871117e-02f, -1.21454880e-01f, 1.97477639e-01f, -1.47789046e-02f, 3.77383195e-02f, -1.77528411e-01f, 8.51728171e-02f, 3.97851178e-03f, -1.54586673e-01f, -1.02558143e-01f,
  1.21200413e-01f, 1.17178448e-01f, -6.36435002e-02f, -9.13432911e-02f, 1.19439155e-01f, 3.10423791e-01f, -1.10809445e-01f, 1.78420112e-01f, 9.67246518e-02f, 3.85605381e-03f,
  -3.34945694e-02f, -2.13206895e-02f, 1.93002881e-04f, -1.00086935e-01f, -1.48586079e-01f, 1.30693763e-01f, 1.88673392e-01f, 1.44710273e-01f, 1.88774943e-01f, -1.65866658e-01f,
  2.69738492e-02f, -1.25319526e-01f, 1.49040014e-01f, 2.24510636e-02f, -1.60838053e-01f, -1.59930229e-01f, -1.61220074e-01f, 1.51300579e-01f, 1.55947268e-01f, -1.40402019e-01f,
  1.73053797e-02f, -1.18240967e-01f, 6.85525313e-02f, 1.72581393e-02f, 1.46756902e-01f, -5.23716994e-02f, -1.02666430e-01f, 3.68401520e-02f, 2.54417602e-02f, 1.49375111e-01f,
  2.79942960e-01f, -9.65533480e-02f, -7.61034340e-02f, 2.38757566e-01f, -2.89065372e-02f, 3.40719581e-01f, 1.70576051e-02f, -2.45588832e-02f, 2.75585443e-01f, 1.58552587e-01f,
  -2.56721348e-01f, -1.25632808e-01f, 2.45315433e-01f, 1.63714379e-01f, 3.63276094e-01f, 2.56926298e-01f, -1.77544996e-01f, -6.43153787e-02f, -1.31056458e-01f, -1.87555477e-01f,
  2.84473479e-01f, 3.27354878e-01f, 1.13452166e-01f, 1.60225689e-01f, 9.76930093e-03f, -2.84472972e-01f, 1.25700429e-01f, -1.47525519e-01f, 3.15730095e-01f, -4.31088284e-02f,
  9.79067311e-02f, -5.05918004e-02f, -8.42045695e-02f, 1.71374902e-01f, 4.05464182e-03f, 9.87189636e-02f, 1.37919053e-01f, -8.88631120e-02f, -1.18206017e-01f, -8.42194818e-03f,
  2.36689165e-01f, -1.19211398e-01f, 5.43383397e-02f, -1.97059195e-02f, 1.96259201e-01f, -1.22075649e-02f, 6.10040016e-02f, 1.12455674e-01f, 7.79138654e-02f, -1.39035612e-01f,
  -9.68077183e-02f, -1.20125107e-01f, 1.41332187e-02f, 1.18250601e-01f, -1.54837906e-01f, -1.40128722e-02f, -2.19253805e-02f, 9.54387859e-02f, 7.35112512e-03f, 1.57201350e-01f,
  3.22739869e-01f, 6.99421316e-02f, 2.04822496e-01f, 2.92123437e-01f, 3.98015618e-01f, 3.19760889e-01f, 4.50177565e-02f, 9.94227231e-02f, 1.81070864e-01f, 9.69496369e-02f,
  1.89481050e-01f, 4.36515242e-01f, 8.47149640e-03f, 2.28483617e-01f, 2.00459272e-01f, -1.77499071e-01f, 9.63800624e-02f, -1.59624189e-01f, -1.29141450e-01f, 1.93819925e-01f,
  -2.15318605e-01f, 7.02500269e-02f, -1.29189596e-01f, 7.74421915e-02f, -2.30468243e-01f, -2.58204341e-01f, -2.77085919e-02f, -1.23680942e-01f, -3.45090181e-02f, 3.04906815e-01f,
  -1.76044032e-02f, -1.81020901e-01f, 2.49508638e-02f, 2.10885972e-01f, 1.29342571e-01f, -1.54110968e-01f, -1.34242013e-01f, 1.47436693e-01f, -1.31534442e-01f, -1.59552470e-01f,
  -1.00313082e-01f, -1.06627427e-01f, -4.12692502e-03f, 9.15128440e-02f, 5.26094139e-02f, 1.22222506e-01f, 9.88644361e-02f, -5.48633076e-02f, 1.62088171e-01f, 6.59679249e-02f,
  -2.81040091e-03f, 1.85478125e-02f, -4.66976836e-02f, -1.49584919e-01f, 1.29769556e-03f, 1.40853226e-02f, 4.43056300e-02f, -2.69214716e-02f, 8.57199449e-03f, -1.26322776e-01f,
  -3.76062132e-02f, -1.07339844e-01f, -6.60999343e-02f, -8.54340792e-02f, -1.59185544e-01f, 2.70304810e-02f, 2.54372805e-01f, 2.00884432e-01f, 4.18181062e-01f, 3.19702536e-01f,
  -6.16403669e-02f, 3.00738722e-01f, 2.45825529e-01f, 2.81644464e-01f, -5.43674827e-02f, 3.78900766e-01f, -4.31912020e-02f, 2.46250540e-01f, 1.12232707e-01f, -3.54436129e-01f,
  2.40956500e-01f, -1.74049526e-01f, -5.81331477e-02f, 3.03433210e-01f, -4.90908250e-02f, 1.27382728e-03f, 5.84167726e-02f, 4.41001803e-02f, 2.74729710e-02f, -1.09365374e-01f,
  1.53560102e-01f, -1.52953729e-01f, 8.50386396e-02f, 3.29298228e-01f, 4.52057049e-02f, -2.19898000e-01f, 1.35617271e-01f, 2.47927681e-01f, 1.66761708e-02f, -1.28069490e-01f,
  5.39066792e-02f, -1.08194031e-01f, -1.91339627e-01f, -1.85047120e-01f, -4.53269593e-02f, 9.15538147e-02f, 7.49827251e-02f, 1.21508025e-01f, -1.23766065e-01f, 1.15846120e-01f,
  -5.40702492e-02f, -1.41101908e-02f, -1.10073440e-01f, 5.20477481e-02f, -7.63793215e-02f, 4.94183823e-02f, -1.75145790e-01f, 1.15619607e-01f, -8.56729597e-02f, -9.63285789e-02f,
  -5.66243343e-02f, 1.38033712e-02f, -7.84104690e-02f, -1.66611135e-01f, 1.02304459e-01f, -1.24263547e-01f, -1.41267806e-01f, -1.26400709e-01f, 1.54788019e-02f, -4.94054854e-02f,
  2.53303964e-02f, -1.06733732e-01f, 1.30523980e-01f, 8.30095783e-02f, -2.88578980e-02f, -3.15436646e-02f, -1.58756152e-01f, -1.51506886e-01f, 1.56050310e-01f, -3.05574317e-03f,
  1.33044973e-01f, -8.31092149e-02f, -1.02781309e-02f, -9.55238789e-02f, -6.85164854e-02f, 1.53972909e-01f, -9.41308588e-02f, 7.34242797e-02f, 1.98869910e-02f, 1.24393299e-01f,
  1.76684856e-01f, -3.50641161e-02f, -5.60819134e-02f, 2.11774418e-03f, 1.42498553e-01f, 8.93892571e-02f, 1.10311903e-01f, -1.49479017e-01f, -1.43029079e-01f, -3.27203944e-02f,
  1.16005138e-01f, 3.82708311e-02f, 2.88603336e-01f, 1.09137319e-01f, 3.65737557e-01f, 2.29010448e-01f, 1.23257553e-02f, 1.99390456e-01f, 3.00411016e-01f, 2.82304764e-01f,
  9.87256244e-02f, 2.12546274e-01f, -2.86923617e-01f, 2.65230447e-01f, 2.90594757e-01f, -9.62143317e-02f, 1.41088963e-01f, -1.19708329e-01f, -4.87391241e-02f, 3.09761643e-01f,
  -1.85133778e-02f, 4.51578274e-02f, -1.67673513e-01f, -1.34170234e-01f, -6.18757121e-02f, 1.49761736e-01f, 6.58148900e-02f, -6.24848902e-03f, -4.75086048e-02f, 2.50879407e-01f,
  -6.45554289e-02f, -9.21813771e-02f, 1.26817167e-01f, 2.89326906e-03f, 3.50261390e-01f, 4.87067074e-01f, 2.03952134e-01f, 2.92169869e-01f, -2.23484769e-01f, 2.08249643e-01f,
  3.58994514e-01f, 4.82140630e-01f, -1.37106227e-02f, 1.93187576e-02f, 7.30900913e-02f, 2.86037624e-01f, -6.93990663e-02f, -5.17807305e-01f, 3.30341130e-01f, -1.26813501e-02f,
  3.21841240e-01f, 2.64217347e-01f, -1.24626510e-01f, -7.81282783e-02f, -1.47822663e-01f, -1.10674269e-01f, -5.89278266e-02f, 2.16200367e-01f, -1.33447632e-01f, 5.67269176e-02f,
  -1.72305048e-01f, -2.31934249e-01f, 1.35863513e-01f, 1.17280078e-03f, 3.53707701e-01f, -1.12585388e-01f, 1.13490276e-01f, -3.57542746e-02f, -6.55867830e-02f, 4.05136570e-02f,
  3.26776132e-02f, -2.02832982e-01f, -3.65129970e-02f, -5.59697710e-02f, 7.93252215e-02f, -4.80227172e-02f, -1.46950364e-01f, -1.03214875e-01f, -1.26371220e-01f, -6.94997311e-02f,
  2.37754751e-02f, -1.49887070e-01f, 2.74650492e-02f, 1.39234662e-01f, -6.90140650e-02f, -1.25722408e-01f, -1.61609992e-01f, -2.25951765e-02f, -1.92633295e-03f, 1.16467059e-01f,
  -1.21453837e-01f, 9.73188728e-02f, -9.06997398e-02f, -1.18413083e-01f, 7.27121681e-02f, -1.53694019e-01f, -4.87437211e-02f, 8.68438706e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.50293314e-01f, 1.92224383e-01f, -6.23627380e-02f, 8.77973139e-02f, 2.46879175e-01f, -8.97982568e-02f, 3.18006933e-01f, -5.10171205e-02f, 1.38708726e-01f, 2.31371373e-02f,
  -4.01369818e-02f, 5.58650047e-02f, 1.55409560e-01f, -1.93056270e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.89169466e-01f, 2.18173027e-01f, 1.01439893e-01f, 1.80151314e-01f, 2.15787917e-01f, -7.64927417e-02f, -1.86835393e-01f, -8.68315399e-02f, -9.24041420e-02f, 1.90627724e-01f,
  1.97013736e-01f, 2.75104046e-01f, -3.98901492e-01f, 1.32082552e-01f, -3.28582637e-02f, 9.53668728e-02f, -3.13819587e-01f, -2.92494416e-01f, -2.52925485e-01f, -2.22679809e-01f,
  -7.93494508e-02f, 1.58421099e-01f, -2.43937075e-01f, -8.41001794e-02f, 1.16598979e-01f, 7.99718127e-03f, 2.46651486e-01f, -9.49726924e-02f, 2.02764975e-04f, 2.20441356e-01f,
  2.44678915e-01f, 1.23168871e-01f, -6.96541965e-02f, -1.89564437e-01f, -1.00687211e-02f, -1.59622476e-01f, 8.71551037e-02f, -8.39382783e-02f, -1.66336671e-01f, 2.08153278e-01f,
  -5.27130701e-02f, -2.75221735e-01f, 1.62241689e-03f, -3.51671308e-01f, 4.39958610e-02f, -3.28189671e-01f, -1.72274131e-02f, -2.63585269e-01f, -1.85671955e-01f, -2.05558315e-01f,
  -3.30203205e-01f, 2.50704497e-01f, -1.24489535e-02f, -5.93156293e-02f, 2.48113409e-01f, 2.78127670e-01f, 1.38002589e-01f, -1.39197990e-01f, 4.70622391e-01f, -6.41400665e-02f,
  2.12111021e-03f, 2.38776356e-01f, 1.10383920e-01f, -1.69642568e-01f, 1.80816650e-01f, -4.36824262e-01f, -1.10540308e-01f, -1.83626190e-02f, 1.12452507e-01f, -8.12922344e-02f,
  2.56491452e-01f, -2.03889951e-01f, -3.24978419e-02f, 1.47086084e-01f, 1.46711379e-01f, 2.70170569e-01f, 3.11321378e-01f, 2.06597611e-01f, -3.68128031e-01f, 4.53391224e-01f,
  1.07600547e-01f, -6.37071058e-02f, 3.83383572e-01f, 2.26002991e-01f, 7.65820369e-02f, -9.79984328e-02f, -1.37114808e-01f, 4.58921045e-02f, -4.45918329e-02f, -4.29537557e-02f,
  -1.85863972e-01f, -1.61751896e-01f, 1.29521012e-01f, -2.01041982e-01f, -4.45199132e-01f, -1.06455564e-01f, 6.70248941e-02f, -2.32331492e-02f, 7.83509165e-02f, -1.89876735e-01f,
  1.05989672e-01f, 2.03598499e-01f, -2.28603616e-01f, -1.48913085e-01f, 4.06888992e-01f, -1.93356499e-01f, -4.67800289e-01f, 1.54586453e-02f, 2.61894733e-01f, -1.66615412e-01f,
  1.12318300e-01f, 5.63914664e-02f, 3.81260544e-01f, 3.30839939e-02f, 3.36917847e-01f, -1.24782264e-01f, -3.39096896e-02f, 1.38619170e-01f, -2.91533303e-02f, 1.11315206e-01f,
  -4.57918018e-01f, -8.67401063e-02f, -3.54488075e-01f, 4.76929657e-02f, -4.14661840e-02f, -8.13440084e-02f, 1.97272480e-01f, -1.02171406e-01f, 1.16533458e-01f, -5.13260543e-01f,
  -4.28894371e-01f, -1.90320387e-01f, -2.49176174e-01f, -1.71499565e-01f, -3.42978776e-01f, -1.95087522e-01f, -4.59845304e-01f, -1.30188674e-01f, 1.50824413e-01f, 1.49913307e-03f,
  3.42368372e-02f, -1.94112688e-01f, -3.48430187e-01f, 4.01089579e-01f, -8.85542631e-02f, 8.70117992e-02f, 3.06996793e-01f, 2.20455438e-01f, 9.37758535e-02f, 1.56460658e-01f,
  -1.45171493e-01f, 2.75471926e-01f, 3.55863124e-02f, -2.22357251e-02f, -1.27646729e-01f, -1.99522041e-02f, 2.91379280e-02f, -2.59210557e-01f, -3.15878153e-01f, 1.16379723e-01f,
  -9.19395760e-02f, 1.03739068e-01f, 7.42305741e-02f, 7.78493881e-02f, -5.72424270e-02f, -2.39397824e-01f, -2.52783805e-01f, -9.34847295e-02f, -2.81335246e-02f, -5.50001375e-02f,
  3.48557204e-01f, 3.97846192e-01f, -2.39243627e-01f, 3.36004138e-01f, -3.02362889e-01f, 3.47533256e-01f, -1.51313663e-01f, -2.40202904e-01f, -3.04072589e-01f, -2.00562730e-01f,
  1.64349526e-01f, 1.07339852e-01f, -3.42513412e-01f, -9.37772095e-02f, 1.75198764e-01f, -1.00148223e-01f, 2.18189046e-01f, 5.73356776e-03f, 1.20019950e-01f, 2.03597695e-01f,
  3.82627547e-02f, 8.62919763e-02f, 2.47019663e-01f, -5.10595381e-01f, -2.08956465e-01f, -2.75939656e-03f, 2.18342647e-01f, -1.43157676e-01f, 1.58705026e-01f, 7.38266185e-02f,
  -1.36891380e-01f, 1.12817340e-01f, 1.64825290e-01f, -1.72161143e-02f, 2.79829055e-01f, 1.07717775e-01f, -3.03408921e-01f, 4.92884904e-01f, 2.70861715e-01f, -1.61806121e-02f,
  6.13554299e-01f, 6.53955862e-02f, 3.12042423e-02f, -8.57598037e-02f, -3.49893540e-01f, -1.89390723e-02f, -1.64250508e-01f, -1.63570121e-01f, -1.06151827e-01f, 4.99266237e-02f,
  5.37962504e-02f, -1.34004265e-01f, -4.95771438e-01f, -9.41744596e-02f, 3.41109559e-02f, -9.45680737e-02f, -2.15190828e-01f, 1.24366703e-02f, -2.50076890e-01f, -1.72634169e-01f,
  -1.54036567e-01f, -1.88451558e-01f, -4.38312590e-01f, -2.13506911e-02f, 5.03593564e-01f, 2.26908594e-01f, -2.37437949e-01f, 2.79033661e-01f, -3.06450486e-01f, 1.30958349e-01f,
  -2.07044840e-01f, -3.51093262e-01f, -1.43506546e-02f, 9.99149308e-02f, 3.53900850e-01f, 4.42048647e-02f, -1.84859157e-01f, -3.91315185e-02f, 1.25827193e-01f, 1.68865249e-01f,
  1.40677214e-01f, 1.64841294e-01f, -1.73264965e-01f, 2.54780263e-01f, -1.79249257e-01f, -9.60333869e-02f, -1.02855049e-01f, -1.19918130e-01f, -8.35209265e-02f, -1.58510894e-01f,
  -2.29835987e-01f, -8.81701894e-03f, -2.78234392e-01f, 7.26279765e-02f, -1.11157343e-01f, 1.99347921e-02f, -2.54771024e-01f, -1.51837021e-01f, 7.52992406e-02f, -3.94156337e-01f,
  1.58709660e-01f, -1.43263832e-01f, -2.67929733e-02f, -7.84084946e-03f, 1.37803301e-01f, 2.95772672e-01f, 7.04327598e-02f, 5.78123182e-02f, 2.18241885e-01f, 2.25694418e-01f,
  -8.50892812e-02f, -3.66481836e-03f, 1.01958893e-01f, 1.17226459e-01f, 1.29960731e-01f, 7.88281485e-02f, 5.63758127e-02f, -5.66139258e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -2.33157491e-03f, 4.24190611e-01f, 2.86267102e-01f, 1.29834220e-01f, -1.70138031e-02f, 2.93202668e-01f, 5.19617051e-02f, 1.42241955e-01f, 2.96356052e-01f, -1.47183081e-02f,
  -1.04942722e-02f, -2.81878151e-02f, -3.58140320e-02f, 9.94343311e-02f, -1.55018911e-01f, 2.19881162e-02f, 8.87351409e-02f, -9.01716873e-02f, -1.79588988e-01f, -5.44110052e-02f,
  -7.94220641e-02f, 1.11548454e-02f, -9.36059840e-03f, 1.30505979e-01f, 2.70792484e-01f, 7.15787187e-02f, 1.14534050e-01f, -8.99011642e-02f, 1.64637193e-01f, 4.09924537e-02f,
  8.99669379e-02f, 9.63751152e-02f, 9.75443125e-02f, 2.43002977e-02f, 6.05488941e-02f, -3.90820146e-01f, -1.09602682e-01f, 1.89617053e-01f, 7.70304725e-02f, -2.29246512e-01f,
  -2.83115268e-01f, -9.33111086e-02f, -1.62223116e-01f, 8.70449245e-02f, -9.08651724e-02f, -7.28625432e-02f, 5.27563877e-02f, 3.90017182e-01f, 1.54869303e-01f, 4.30001058e-02f,
  5.21993876e-01f, 2.44143546e-01f, -5.51027581e-02f, -8.74705762e-02f, -2.30469227e-01f, -2.24837381e-02f, -1.50147498e-01f, 1.96188092e-02f, -8.59202668e-02f, 6.82840450e-03f,
  1.32968530e-01f, -3.87813509e-01f, -2.60100514e-01f, -1.43977910e-01f, -6.09904639e-02f, 2.40815252e-01f, 1.97267607e-01f, 2.44060438e-02f, 1.83281168e-01f, -1.05191581e-02f,
  1.09669395e-01f, 4.72159088e-02f, 8.42499435e-02f, -2.42277905e-01f, 2.65381694e-01f, 1.68979898e-01f, -4.46650207e-01f, -1.97533369e-01f, 9.47336853e-02f, -2.23848328e-01f,
  -1.98092028e-01f, -3.15672159e-01f, -2.49233171e-01f, -4.24710736e-02f, -4.15980853e-02f, 1.78770155e-01f, 6.87199309e-02f, -4.02769223e-02f, 1.80246666e-01f, -2.68561356e-02f,
  1.31771728e-01f, 1.63672268e-01f, 5.54763116e-02f, -8.67301133e-03f, 3.52282912e-01f, 1.61110491e-01f, 2.46849403e-01f, -2.63908446e-01f, -1.29192695e-02f, -5.81725165e-02f,
  1.78731143e-01f, -1.25371804e-02f, 1.38615936e-01f, -1.37413919e-01f, -4.26068842e-01f, 1.60760120e-01f, 4.89279658e-01f, 2.92857796e-01f, -9.82078016e-02f, -5.49249910e-02f,
  -8.11700895e-02f, 4.62285839e-02f, -3.56398553e-01f, -1.82266116e-01f, -2.35197023e-01f, 2.23776023e-03f, -1.06390528e-01f, -4.63784784e-02f, -3.16379398e-01f, -6.68039173e-02f,
  2.91194826e-01f, 2.64744274e-03f, 2.16242135e-01f, 1.15171470e-01f, 3.39303818e-03f, 1.50051251e-01f, -5.69279045e-02f, -1.28170252e-02f, 1.70477614e-01f, -6.76971152e-02f,
  1.15841411e-01f, -1.88583463e-01f, 1.15085632e-01f, -1.22803800e-01f, 2.61536688e-01f, -1.39858052e-01f, -1.62513271e-01f, 9.35310721e-02f, -1.52848721e-01f, -2.54373521e-01f,
  3.02317552e-02f, -4.71120067e-02f, 1.53131336e-01f, 4.57957722e-02f, 2.24851221e-01f, 1.36686698e-01f, 1.36304423e-01f, 1.33099809e-01f, 1.34636894e-01f, 5.67664132e-02f,
  2.50618279e-01f, -1.53996736e-01f, -3.89586911e-02f, 8.77427869e-03f, -9.01992396e-02f, -1.05722964e-01f, 8.36171210e-02f, 6.66455999e-02f, 4.49887663e-02f, -1.44663498e-01f,
  1.28295839e-01f, 1.09149359e-01f, -5.13786227e-02f, -1.72398873e-02f, -1.89141467e-01f, 1.26924902e-01f, -2.32952386e-01f, -1.68662801e-01f, -7.10668415e-02f, 8.54500383e-03f,
  5.68936989e-02f, 1.46271810e-01f, -9.51748043e-02f, 9.01263058e-02f, -1.95295513e-01f, 1.36504278e-01f, 1.37711614e-01f, 1.18301272e-01f, 6.97475895e-02f, -8.35592151e-02f,
  -1.16974406e-01f, -1.08930515e-02f, 1.14016667e-01f, -9.06111151e-02f, 4.29669917e-02f, -1.23814814e-01f, 4.91681881e-03f, 1.54051691e-01f, 4.02211472e-02f, -1.26674205e-01f,
  -2.98216864e-02f, 3.98862734e-02f, 4.02955770e-01f, 8.94103758e-03f, -1.12535525e-02f, 2.38772348e-01f, 8.25710297e-02f, 4.77339737e-02f, 3.77977878e-01f, 2.90633082e-01f,
  -2.62461692e-01f, 2.19621450e-01f, 3.63320857e-01f, 3.90041888e-01f, -2.96715170e-01f, 2.97368944e-01f, -3.38831902e-01f, 1.42132267e-01f, -3.08409363e-01f, -4.56406623e-01f,
  -2.79786855e-01f, 9.52683464e-02f, -1.18382327e-01f, 1.18701786e-01f, -2.29590043e-01f, -1.01074137e-01f, 7.38074660e-01f, 1.04805969e-01f, 4.97359186e-01f, 1.29862770e-01f,
  -1.32722761e-02f, 5.24121881e-01f, -4.08945791e-02f, -1.40213892e-01f, -5.66593520e-02f, 1.35841399e-01f, -1.30653754e-01f, -3.03443950e-02f, -1.87039729e-02f, 2.05111399e-01f,
  -1.32810399e-01f, 1.40184417e-01f, -2.12354716e-02f, 1.15755647e-01f, -1.38937935e-01f, 1.54391095e-01f, -9.70808864e-02f, 5.24908789e-02f, -2.82472879e-01f, 1.79024830e-01f,
  -3.68303433e-02f, -1.86725944e-01f, 3.31082702e-01f, 4.50298488e-02f, -1.70316309e-01f, 1.58722028e-01f, -2.74555296e-01f, 1.26274675e-01f, 6.63798302e-02f, 1.34181336e-01f,
  -1.57082543e-01f, -1.00634962e-01f, 2.66682096e-02f, -2.19858259e-01f, -2.40003411e-02f, 4.78752628e-02f, 4.00846690e-01f, 5.78972340e-01f, 5.00933170e-01f, 1.71527877e-01f,
  4.48637754e-01f, 5.41316211e-01f, 3.24286848e-01f, 1.08862452e-01f, 5.78037083e-01f, 2.19167113e-01f, -3.99309635e-01f, 4.58995581e-01f, 3.79839629e-01f, 5.67846656e-01f,
  6.55521378e-02f, 9.61252451e-02f, 2.10354954e-01f, 1.32161930e-01f, 4.93767023e-01f, -3.33865345e-01f, -1.28388613e-01f, 1.53886959e-01f, 1.37548372e-01f, -1.43672109e-01f,
  -1.67960450e-01f, -3.83466259e-02f, -4.72623035e-02f, -1.88769847e-02f, -1.02491587e-01f, 6.93890229e-02f, 4.32487065e-03f, 3.64923216e-02f, -1.58916861e-01f, 3.05913910e-02f,
  -1.10616446e-01f, -9.96339917e-02f, -1.35021225e-01f, -5.17041981e-02f, -6.67288080e-02f, -8.36384371e-02f, 1.07175685e-01f, -7.75133213e-03f, -2.78338641e-01f, -3.78473736e-02f,
  5.48748486e-02f, -3.82496566e-01f, 9.18654650e-02f, -4.90428060e-02f, -4.72973939e-03f, 1.37122974e-01f, 7.81315938e-02f, 3.19363743e-01f, 1.44071028e-01f, -6.77214488e-02f,
  2.16743916e-01f, 9.84987468e-02f, -1.60498679e-01f, -4.44626845e-02f, -1.49447963e-01f, 1.53111532e-01f, -8.14751238e-02f, 2.42217649e-02f, 5.71309663e-02f, -1.68534908e-02f,
  2.47423068e-01f, 3.44671085e-02f, -1.06224865e-01f, 1.33577183e-01f, 1.69876546e-01f, 1.42027289e-01f, 1.05021276e-01f, -1.06523052e-01f, 1.46077415e-02f, -3.02523971e-01f,
  4.29289825e-02f, -7.72426501e-02f, 1.38039991e-01f, -5.16914845e-01f, 4.33940023e-01f, -3.32115293e-01f, 2.77113408e-01f, 2.28156731e-01f, 1.30900919e-01f, 3.36200953e-01f,
  -8.49081129e-02f, -1.23468176e-01f, 4.15986210e-01f, 1.31116226e-01f, -6.71930388e-02f, -2.02392265e-02f, 3.64772677e-01f, -2.57139863e-03f, -3.98110598e-02f, 1.35635212e-01f,
  5.15604794e-01f, -1.51819140e-01f, -5.50495945e-02f, 5.76738238e-01f, 2.81721562e-01f, 1.11166105e-01f, -3.11931930e-02f, 3.97265047e-01f, -2.91348286e-02f, 3.20931673e-01f,
  2.69162297e-01f, -3.54305446e-01f, 1.80435166e-01f, -1.08927518e-01f, -3.96281481e-01f, -4.90883917e-01f, 2.21079275e-01f, -3.37732315e-01f, -1.46990970e-01f, -1.33683264e-01f,
  -7.52426863e-01f, 6.19085394e-02f, -8.99080485e-02f, -1.07810669e-01f, 3.27059627e-01f, 2.80038174e-02f, 3.11282039e-01f, 1.73428386e-01f, 4.95363057e-01f, -1.61830276e-01f,
  1.03683174e-01f, 3.49551022e-01f, 7.54938006e-01f, -1.15587816e-01f, -1.30881146e-01f, 1.08296633e-01f, 3.13731912e-03f, 4.29741964e-02f, -7.45254308e-02f, -9.75748152e-02f,
  -7.84057975e-02f, 6.67019114e-02f, 9.98908356e-02f, 1.33008987e-01f, -2.77621318e-02f, 2.73003466e-02f, 1.47077665e-01f, -3.97834554e-02f, -4.76451367e-02f, -1.14565484e-01f,
  -1.06732942e-01f, 7.13708103e-02f, -6.55400231e-02f, -8.08028039e-03f, 6.04277924e-02f, 8.79254043e-02f, 1.34938598e-01f, 1.45418778e-01f, -7.92945921e-02f, -1.02341145e-01f,
  -1.14150941e-02f, -6.10063337e-02f, 3.79920676e-02f, -7.34569728e-02f, -6.99187890e-02f, 1.19233787e-01f, 1.81322068e-01f, 3.28156322e-01f, -1.74333960e-01f, 3.34865242e-01f,
  7.19681606e-02f, -2.17150435e-01f, -2.44932383e-01f, -6.49129972e-02f, 6.63066879e-02f, 1.97124347e-01f, 3.71716440e-01f, 1.45160705e-01f, 1.84880108e-01f, 5.14292121e-01f,
  -5.80048740e-01f, 4.90927905e-01f, -7.26093026e-03f, -2.13236008e-02f, 2.46231392e-01f, -2.28450328e-01f, 2.45119452e-01f, -7.10238889e-02f, -2.63701886e-01f, -6.34100512e-02f,
  1.16054647e-01f, -1.28473595e-01f, 2.80809134e-01f, 6.81049973e-02f, -6.23399718e-03f, 1.91447958e-01f, -3.92197669e-01f, -1.57161891e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.46853514e-02f, -6.27552792e-02f, 1.75320417e-01f, 1.70453861e-01f, -5.44151198e-03f, 1.07566845e-02f, 3.82340729e-01f, -9.89897847e-02f, 9.84544456e-02f, -1.21220537e-01f,
  2.84028083e-01f, 6.59731850e-02f, -2.00377628e-01f, 4.88878377e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -5.08849680e-01f, -2.20260069e-01f, 9.10977125e-02f, -6.04805499e-02f, 5.29045820e-01f, -2.47119263e-01f, 2.37619430e-01f, 3.07354499e-02f, -3.12150180e-01f, -3.36437941e-01f,
  3.64773393e-01f, -7.01334417e-01f, 2.45603070e-01f, -2.82326281e-01f, 5.46251349e-02f, -5.10976195e-01f, -3.13975483e-01f, 7.52084255e-02f, -2.21424133e-01f, -3.83899003e-01f,
  -3.78555775e-01f, -1.08658895e-01f, 7.13791326e-02f, -6.14373162e-02f, -4.53684866e-01f, 7.31112659e-02f, -5.25683403e-01f, 4.43748623e-01f, 6.45663321e-01f, 1.51063114e-01f,
  -4.00995128e-02f, -1.03671752e-01f, -1.40111342e-01f, 5.81306338e-01f, 4.39117342e-01f, -5.56132868e-02f, 9.25399899e-01f, 3.57751966e-01f, 1.76092997e-01f, 1.49798930e-01f,
  4.44805361e-02f, -6.10563606e-02f, 2.93988168e-01f, 3.82762462e-01f, 4.00403887e-01f, 1.83085024e-01f, -5.19680344e-02f, 1.01861012e+00f, -3.22156101e-02f, 3.28185886e-01f,
  -9.24581960e-02f, 1.67497769e-01f, -9.76056978e-02f, -1.48583218e-01f, 4.88920152e-01f, -1.43319711e-01f, -3.23218554e-01f, -3.39112848e-01f, 2.20954463e-01f, 4.30236012e-02f,
  4.06650811e-01f, -4.38684404e-01f, 1.61452860e-01f, 2.77947515e-01f, 1.60881817e-01f, -3.81485343e-01f, -4.23523426e-01f, 4.89108413e-01f, -3.53013575e-01f, 6.93250775e-01f,
  -8.06958601e-02f, 4.08001781e-01f, 1.09207496e-01f, 7.21437395e-01f, 5.81002869e-02f, -1.33747220e-01f, -4.46458846e-01f, 4.66618121e-01f, -5.32192476e-02f, -3.17178100e-01f,
  -1.70273244e-01f, 1.85449004e-01f, 2.54002631e-01f, -7.22787231e-02f, 4.35357302e-01f, -4.69268650e-01f, -3.08135748e-01f, 3.68095078e-02f, 7.57802650e-02f, -2.19988450e-02f,
  -2.14510575e-01f, -2.00812176e-01f, 1.88264474e-01f, 7.77264178e-01f, -2.76362002e-02f, -3.35638523e-01f, 5.43818653e-01f, 4.35178280e-01f, 2.30606303e-01f, 1.72828570e-01f,
  -3.66022021e-01f, 1.37592301e-01f, 4.21850234e-01f, 5.21195196e-02f, 3.51287901e-01f, -2.60569930e-01f, 3.79701138e-01f, -6.98071003e-01f, 2.00221956e-01f, -2.97527969e-01f,
  -4.75810349e-01f, -5.12810528e-01f, -4.31590140e-01f, 1.81358550e-02f, 2.66038090e-01f, -5.41314110e-02f, 1.36631295e-01f, -2.32338011e-01f, 3.52084748e-02f, -1.11177489e-01f,
  -3.38465231e-03f, 1.67905435e-01f, 6.15535200e-01f, -2.11641148e-01f, 6.07041344e-02f, 4.40467060e-01f, 1.74757987e-02f, -1.56921819e-01f, 6.61834717e-01f, -2.12896943e-01f,
  -6.41471803e-01f, 4.21682119e-01f, -3.44954550e-01f, -2.56910264e-01f, -4.49023902e-01f, -1.77599743e-01f, -2.16141731e-01f, -2.88272411e-01f, 6.42674640e-02f, -2.97252923e-01f,
  4.13086236e-01f, -3.95003706e-01f, -5.64718246e-01f, -2.89038926e-01f, -2.29043394e-01f, 8.12631026e-02f, -9.38496441e-02f, -3.93170565e-02f, 2.42972001e-01f, -1.07616462e-01f,
  -1.40800372e-01f, 1.69824753e-02f, -6.52364254e-01f, 2.99888588e-02f, -2.82721490e-01f, 1.99134529e-01f, 3.28977972e-01f, 8.39953542e-01f, -1.19395904e-01f, 2.77978671e-03f,
  8.03761631e-02f, 1.30384684e-01f, 7.10521162e-01f, -6.60277084e-02f, 1.29334896e-03f, -6.36533022e-01f, 4.34133738e-01f, -1.91464946e-01f, 4.52109456e-01f, -6.63644493e-01f,
  -1.98468640e-01f, 2.09137619e-01f, 1.74466580e-01f, -7.07956910e-01f, -4.41388369e-01f, 6.91335440e-01f, -1.43251374e-01f, 2.38127977e-01f, -2.18770966e-01f, -3.03221762e-01f,
  -2.51994468e-02f, -1.68348476e-01f, -1.94473099e-02f, -2.12763563e-01f, -2.09963232e-01f, -2.86509603e-01f, 9.47393775e-01f, -2.28315800e-01f, 2.34801009e-01f, -5.32572627e-01f,
  2.35407464e-02f, -4.07438904e-01f, -3.70128453e-01f, -2.17873767e-01f, 4.37773287e-01f, -2.23612025e-01f, 1.09467328e-01f, 5.74109750e-03f, 5.13693333e-01f, -1.78850412e-01f,
  1.66373234e-02f, 1.15004778e-01f, 2.83389628e-01f, -1.44313142e-01f, -3.74592841e-02f, -2.32955769e-01f, 1.16200641e-01f, -5.86477697e-01f, 4.54992294e-01f, -5.50863385e-01f,
  -1.08290553e-01f, -4.70920838e-02f, 1.78183094e-01f, 6.39073968e-01f, 1.19646214e-01f, -5.39378263e-02f, 7.36831129e-01f, -1.77076504e-01f, -4.93732899e-01f, -4.34393138e-02f,
  -9.44540203e-02f, -1.35227982e-02f, 2.12526452e-02f, 1.67538315e-01f, -2.73969071e-03f, 1.21493146e-01f, 1.92757145e-01f, -3.68232340e-01f, 1.99683070e-01f, -4.42757532e-02f,
  -2.10970178e-01f, -5.67932367e-01f, 4.04752931e-03f, 2.64690161e-01f, 2.25016207e-01f, 4.18428510e-01f, -5.11114538e-01f, 7.26336300e-01f, 4.34823722e-01f, 2.69374192e-01f,
  2.37539336e-01f, -7.42804036e-02f, -3.78821582e-01f, 5.40360548e-02f, -3.25564623e-01f, 3.87843162e-01f, -9.15222690e-02f, -1.43073648e-01f, 7.96782553e-01f, -3.82714160e-02f,
  -7.19595850e-01f, -8.02620277e-02f, -9.41052362e-02f, -6.30259037e-01f, -1.19561680e-01f, 4.76995379e-01f, 1.96189597e-01f, -4.65766579e-01f, -1.94598898e-01f, -3.60182405e-01f,
  -1.56072840e-01f, 2.34864622e-01f, -1.81414172e-01f, 2.09735602e-01f, 1.31385893e-01f, -3.08392972e-01f, -1.87684655e-01f, 2.17974856e-01f, 2.70410091e-01f, 2.10702196e-01f,
  -4.56497043e-01f, 6.02452531e-02f, 2.32168123e-01f, -1.00570105e-01f, -1.44389704e-01f, 3.68488967e-01f, -1.97015598e-01f, -2.01574013e-01f, -2.08035648e-01f, 7.56423771e-02f,
  -4.71951783e-01f, 3.70500565e-01f, 3.84334743e-01f, -2.31087789e-01f, -7.08523333e-01f, -4.07258242e-01f, 1.87785458e-02f, 6.68055534e-01f, -5.19440413e-01f, -1.15442820e-01f,
  -6.77555740e-01f, -1.60274848e-01f, -2.43950561e-01f, 2.04345509e-01f, -6.80879414e-01f, 7.05796927e-02f, 2.46000793e-02f, 1.43175185e-01f, 8.54639709e-02f, -1.69865832e-01f,
  -2.46820748e-01f, -1.93051040e-01f, 4.67856497e-01f, -2.95904815e-01f, 5.45432091e-01f, -4.79108617e-02f, 3.70221883e-02f, -1.42138591e-02f, 5.17496586e-01f, 3.89996022e-01f,
  -1.79289967e-01f, 1.73981056e-01f, 4.56375420e-01f, -1.17901765e-01f, -4.07316148e-01f, 1.37154534e-01f, -6.90801591e-02f, 5.39435208e-01f, 1.18272588e-01f, -5.18203437e-01f,
  -4.17573780e-01f, 1.10631041e-01f, -3.03576589e-01f, -3.81015748e-01f, -1.29323423e-01f, -5.29588997e-01f, -5.48261762e-01f, 7.31617734e-02f, -1.28792971e-01f, 1.23169497e-01f,
  -3.31597418e-01f, 2.70918250e-01f, 1.21471375e-01f, 6.20295346e-01f, 9.59144980e-02f, -1.47193700e-01f, -4.68659371e-01f, 2.00652450e-01f, -2.40459904e-01f, 7.46231735e-01f,
  4.70533967e-03f, -9.29426327e-02f, 9.00337324e-02f, -1.31722882e-01f, -1.39206424e-01f, 2.03805014e-01f, 1.12471797e-01f, 1.78044215e-01f, -7.93860033e-02f, -4.92272109e-01f,
  -1.24427095e-01f, -6.15855694e-01f, 1.50311649e-01f, 2.49909498e-02f, 9.13417712e-02f, 4.46097165e-01f, 2.46220186e-01f, 2.66202271e-01f, 5.33423498e-02f, 2.69933909e-01f,
  5.99304885e-02f, 2.46474922e-01f, -3.53157967e-01f, 3.78042519e-01f, -6.30324960e-01f, -4.06345904e-01f, 2.54720449e-01f, 3.00513089e-01f, 5.32538474e-01f, -4.98797357e-01f,
  3.41940105e-01f, -2.83845454e-01f, -1.45370606e-02f, -7.40365237e-02f, -5.79178473e-03f, 2.74410769e-02f, 5.27401149e-01f, 2.45329753e-01f, 3.41585189e-01f, 5.90214841e-02f,
  -4.87898678e-01f, -1.24603987e-01f, 9.47456583e-02f, 2.86948204e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.98503390e-01f, 3.30943525e-01f, -3.05095136e-01f, 6.44533560e-02f, -4.22691032e-02f, 1.47914603e-01f, -3.03759545e-01f, 3.35436799e-02f, -1.14837036e-01f, -2.32211769e-01f,
  6.20356537e-02f, 8.62076208e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    