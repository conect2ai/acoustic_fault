/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.85974228e-01f, -9.47494432e-02f, 1.14177931e-02f, -1.40747890e-01f, -6.95150346e-02f, -7.52738416e-02f, -2.24628419e-01f, -1.03896402e-01f, -5.11109158e-02f, -1.11695506e-01f,
  4.36529480e-02f, 9.61779058e-02f, 1.27163872e-01f, 1.29358575e-01f, 3.10353991e-02f, -1.63525626e-01f, -1.17643930e-01f, -1.34087354e-01f, -6.83879778e-02f, -1.03250720e-01f,
  -8.91005844e-02f, -2.84039825e-02f, 7.87525550e-02f, 7.66036510e-02f, -3.64704728e-02f, 3.78193371e-02f, 7.26952106e-02f, 1.41311660e-02f, 8.93147215e-02f, -2.20020898e-02f,
  4.36800020e-03f, -2.21495628e-02f, 3.33217457e-02f, -6.36876822e-02f, 1.30902931e-01f, 3.29353549e-02f, -9.91862416e-02f, 3.81365493e-02f, -2.77319122e-02f, -1.46395378e-02f,
  8.30892920e-02f, -4.66031469e-02f, 5.38974777e-02f, 1.20752543e-01f, -7.32962936e-02f, -9.30138752e-02f, 3.06865294e-02f, 4.95867208e-02f, 8.95438865e-02f, 1.00547291e-01f,
  8.28222185e-02f, 5.78492135e-02f, -4.45310920e-02f, 1.12911776e-01f, -2.15366092e-02f, -2.95938235e-02f, 1.14403464e-01f, 4.33725566e-02f, 9.94374603e-02f, -7.13649169e-02f,
  -8.46733712e-03f, -1.54339783e-02f, 3.86779010e-02f, 3.60851251e-02f, -8.91275704e-03f, 8.84373486e-02f, -3.40008959e-02f, 1.43098906e-02f, -4.13214862e-02f, -1.80525966e-02f,
  4.94338572e-02f, 3.39062251e-02f, 5.24165221e-02f, -1.04691181e-03f, -1.62264984e-02f, -1.64759178e-02f, -6.95924088e-02f, -4.85799909e-02f, 2.53377240e-02f, 5.93484454e-02f,
  -2.91127749e-02f, 1.88844055e-02f, -8.24065600e-03f, 4.65324819e-02f, -1.20083317e-02f, -5.80163673e-03f, 1.82078723e-02f, 4.00478579e-02f, -1.91157646e-02f, 5.38807809e-02f,
  -1.09682597e-01f, 1.37597203e-01f, -1.15796626e-01f, -3.46886069e-02f, -2.79141311e-02f, 6.56907931e-02f, 1.53699908e-02f, 9.62320715e-02f, 8.61560702e-02f, -6.27149493e-02f,
  1.37178143e-02f, -8.18492547e-02f, 4.87078205e-02f, -1.61134545e-02f, -3.11778206e-02f, 5.60525693e-02f, -3.86401340e-02f, -4.62119142e-03f, 1.13219976e-01f, 8.45093373e-03f,
  9.17625800e-02f, -9.33490396e-02f, -6.73871040e-02f, -2.13060975e-02f, -3.28123122e-02f, -9.18859318e-02f, 7.05933869e-02f, -8.87640417e-02f, -7.27366507e-02f, -2.21497878e-01f,
  1.56407222e-01f, 8.48210901e-02f, 1.19129747e-01f, 7.59605691e-02f, -1.05110947e-02f, -9.63910073e-02f, -3.27590108e-02f, -6.54419363e-02f, -4.45355177e-02f, 3.96314487e-02f,
  -1.80107262e-02f, -1.05862796e-01f, -7.38159269e-02f, -9.79683623e-02f, -4.19245139e-02f, -4.12948132e-02f, -4.49264050e-02f, 4.34835777e-02f, -1.04715414e-01f, -1.97895274e-01f,
  -1.22434892e-01f, -2.92398911e-02f, 1.48760945e-01f, -5.57766221e-02f, 4.63325307e-02f, 1.03627518e-02f, 6.21672533e-02f, 2.05253184e-01f, 9.18205455e-02f, 9.26970690e-02f,
  3.74014005e-02f, 3.08203608e-01f, -1.42173603e-01f, -7.01567978e-02f, 6.56265765e-02f, 4.44019865e-03f, -1.78900976e-02f, 1.36297271e-01f, -1.84165705e-02f, 9.29560810e-02f,
  8.03849027e-02f, -5.10931807e-03f, 6.15935549e-02f, 7.27243572e-02f, 9.53447632e-03f, 6.22012727e-02f, 9.49507877e-02f, 4.14678566e-02f, 1.19659761e-02f, -2.69341525e-02f,
  6.62204344e-03f, 1.35028973e-01f, 5.83602749e-02f, 1.74696930e-02f, 8.32227692e-02f, -7.12777823e-02f, 1.59447521e-01f, 3.83703299e-02f, -2.35442836e-02f, 9.96485278e-02f,
  -4.28200513e-02f, -5.21126501e-02f, 4.58718501e-02f, -1.20906811e-02f, -1.37447659e-02f, -5.54308370e-02f, 6.85971156e-02f, -9.01370272e-02f, -2.81835310e-02f, 8.91751945e-02f,
  -3.43825817e-02f, -1.14269778e-02f, 1.97376590e-02f, 4.16611508e-02f, -2.86978707e-02f, 8.93410891e-02f, 6.42683404e-03f, 1.53865237e-02f, 1.04490528e-02f, -1.81886163e-02f,
  3.53339203e-02f, 4.24318295e-03f, 6.23450689e-02f, -1.25451814e-02f, 2.16150787e-02f, -2.07024906e-02f, -5.81532791e-02f, -5.67839853e-02f, 3.57784405e-02f, 5.93353529e-03f,
  -1.40947476e-01f, 5.40612899e-02f, -1.83961838e-02f, -3.91959958e-02f, 3.57658938e-02f, 1.53664667e-02f, -5.25613390e-02f, -3.38038057e-02f, -6.60187518e-03f, -4.17149365e-02f,
  8.52012483e-04f, 4.22759168e-02f, 9.87368226e-02f, -1.22038759e-02f, -1.06302410e-01f, -6.85504377e-02f, 1.46352379e-02f, -1.10794909e-01f, -1.11493886e-01f, -1.99350622e-02f,
  -7.07702711e-02f, -1.58805162e-01f, -1.54419839e-01f, -1.29043669e-01f, -8.37469026e-02f, -1.91289067e-01f, -6.65990412e-02f, -1.29659787e-01f, -1.24826737e-01f, -2.55281061e-01f,
  1.19277626e-01f, -1.29847853e-02f, -1.04928963e-01f, -2.13874906e-01f, -1.96591452e-01f, -1.79373529e-02f, 2.83940565e-02f, 1.70240462e-01f, -6.95619658e-02f, -1.14705071e-01f,
  -1.87867729e-03f, -8.00021589e-02f, -3.20969112e-02f, 4.17573266e-02f, 1.20952763e-01f, -5.05787581e-02f, -1.47533342e-01f, 3.18572335e-02f, 1.51181817e-01f, 4.01174836e-02f,
  -1.44042432e-01f, -4.78598811e-02f, 2.32483614e-02f, -5.15770689e-02f, -1.55535251e-01f, -8.41738507e-02f, -1.23943135e-01f, -6.44660816e-02f, -5.48514538e-02f, -2.46336132e-01f,
  -1.80153444e-01f, 4.40752916e-02f, 3.02459579e-02f, -5.85232712e-02f, 1.04286723e-01f, 9.76173393e-03f, 3.09447981e-02f, 7.09196255e-02f, 5.57467006e-02f, 3.17336768e-02f,
  -5.25399670e-02f, 1.44457845e-02f, -1.60590131e-02f, 2.33061183e-02f, -5.42558990e-02f, 2.63536703e-02f, 7.21415728e-02f, -4.76285294e-02f, -6.15658984e-02f, -6.14274032e-02f,
  -2.02027366e-01f, -2.96526905e-02f, 4.09272360e-03f, -1.81117877e-02f, 2.18879078e-02f, -1.26380295e-01f, 1.26381521e-03f, -7.14541301e-02f, 1.57509297e-01f, -6.06135875e-02f,
  -5.42439567e-03f, 1.49603439e-02f, 3.31157707e-02f, 4.15517613e-02f, -1.04538556e-02f, 2.53410134e-02f, -6.16037026e-02f, 2.64260080e-02f, -9.45238583e-03f, 3.86538021e-02f,
  5.00208773e-02f, -1.98717192e-02f, -1.83776449e-02f, 4.69260477e-03f, -8.30255970e-02f, -3.98699977e-02f, -3.75989452e-02f, 4.58170734e-02f, -6.62137344e-02f, 3.87537144e-02f,
  -9.32512805e-03f, -1.76448822e-02f, -2.54208352e-02f, 3.95278037e-02f, -2.70617194e-02f, -2.09066849e-02f, -6.88706487e-02f, 2.96759140e-02f, 5.57878464e-02f, 2.18104180e-02f,
  1.49307862e-01f, 1.74918249e-01f, -1.30192980e-01f, -4.39306226e-04f, -7.27888271e-02f, 2.98612211e-02f, -1.22294985e-01f, 1.71050988e-02f, 6.96495781e-03f, -7.11931800e-03f,
  5.85385263e-02f, 3.76726650e-02f, -4.38942388e-02f, -2.18973234e-02f, 7.40233660e-02f, 5.68355471e-02f, 1.11555522e-02f, -1.54993217e-02f, 2.04228014e-02f, -6.55347481e-02f,
  -9.06288400e-02f, -5.37566841e-02f, 6.29216135e-02f, -4.76288460e-02f, -3.37081216e-02f, 1.40218884e-02f, 5.05238809e-02f, 1.54979927e-02f, 1.31030187e-01f, 8.47603381e-02f,
  -4.44790334e-01f, -4.12355304e-01f, 9.31084678e-02f, -9.37966257e-02f, -3.72678712e-02f, -3.60238962e-02f, -8.16860348e-02f, 8.49245861e-02f, 6.68961331e-02f, -1.25879571e-01f,
  -6.77013174e-02f, 1.23421207e-01f, 2.08840713e-01f, 5.70447221e-02f, 3.68447118e-02f, -4.03688140e-02f, -3.46641615e-02f, 1.78298444e-01f, 2.88731903e-01f, 1.72821313e-01f,
  3.97532620e-02f, -6.63945302e-02f, -9.73788649e-02f, -2.34251400e-03f, -6.60786107e-02f, -6.42011836e-02f, -1.49221003e-01f, -2.03473195e-01f, -1.66342050e-01f, -3.08795214e-01f,
  -1.53136328e-01f, -3.16275924e-01f, 1.78899378e-01f, -2.21198592e-02f, 1.45072280e-03f, -1.82512309e-02f, -1.15643004e-02f, -2.74682958e-02f, 5.90307303e-02f, 8.55914317e-03f,
  5.94101474e-03f, -6.74786717e-02f, -6.75671771e-02f, 1.27760703e-02f, 3.78039666e-02f, -2.00249683e-02f, 6.43616170e-02f, 4.37944755e-02f, 8.20159093e-02f, 1.41455326e-02f,
  2.40104448e-04f, -1.62635684e-01f, -1.12597771e-01f, 8.28904361e-02f, 1.02071725e-01f, 9.70463529e-02f, -1.14542969e-01f, -1.23873450e-01f, -9.92858633e-02f, -3.25286835e-01f,
  -6.97736666e-02f, -4.34192829e-02f, -6.44133240e-02f, -1.23625189e-01f, 4.30667736e-02f, 2.43293457e-02f, 1.08479813e-03f, -2.71678977e-02f, 5.50183542e-02f, -1.26440376e-02f,
  8.62207729e-03f, 5.00780717e-03f, 2.62916014e-02f, 3.56681943e-02f, 2.48365700e-02f, -4.49082628e-02f, 4.17549871e-02f, 6.15822326e-04f, 1.07338496e-01f, -7.99544230e-02f,
  6.35882765e-02f, 1.73388720e-02f, 5.63597381e-02f, 1.77338216e-02f, 1.18068270e-02f, 2.93814559e-02f, -1.29924286e-02f, 1.84465442e-02f, 4.22484837e-02f, -7.49282259e-03f,
  8.81171897e-02f, 2.41021752e-01f, -9.03778244e-03f, -1.00233816e-02f, -1.00412175e-01f, 1.90037526e-02f, -2.28402913e-02f, 1.80264525e-02f, -1.14664361e-02f, 1.64213851e-02f,
  -5.74208535e-02f, -3.89382592e-03f, 2.76116859e-02f, 8.56619626e-02f, -6.54256418e-02f, 3.69331101e-03f, 5.02449088e-03f, 6.41530603e-02f, 1.04402326e-01f, 1.51641490e-02f,
  7.29176356e-03f, 5.87302335e-02f, 1.09053656e-01f, -4.00182270e-02f, -5.47052547e-02f, 7.35367611e-02f, 7.85106979e-03f, 6.41200691e-02f, -4.95714601e-03f, -1.70593619e-01f,
  2.55936742e-01f, 8.52295235e-02f, 1.01712197e-01f, -5.68974018e-03f, 7.15395808e-02f, 1.72532752e-01f, 3.08931470e-01f, 9.10776183e-02f, -4.92704287e-03f, -1.17568877e-02f,
  -2.60600206e-02f, -1.42232487e-02f, 5.56783341e-02f, -9.23858373e-04f, 1.70652673e-01f, 1.65051982e-01f, 4.41045724e-02f, 1.08155854e-01f, 1.28608821e-02f, -7.26557821e-02f,
  -6.46000057e-02f, -8.49301070e-02f, -2.46019885e-02f, -8.86344165e-02f, -1.92842156e-01f, -2.27707513e-02f, -1.49488837e-01f, -1.66324079e-01f, -7.81404879e-03f, -1.38908729e-01f,
  -1.23549663e-01f, 2.95540616e-02f, 3.65216732e-02f, 1.00057960e-01f, -9.83040109e-02f, 8.04298818e-02f, 5.37983626e-02f, -8.33475869e-03f, -8.92139375e-02f, -2.13904809e-02f,
  -1.17315345e-01f, -8.29043984e-02f, 8.38181973e-02f, -6.18719272e-02f, 4.14364450e-02f, -5.65670663e-04f, -8.91726837e-02f, -4.35389504e-02f, 3.64708006e-02f, -2.42304690e-02f,
  2.26588715e-02f, -9.19336453e-02f, -7.81535811e-04f, 9.34947357e-02f, -5.53763807e-02f, -1.79065019e-02f, -1.98558886e-02f, -4.92204390e-02f, -2.16819867e-02f, -4.98752967e-02f,
  3.43932994e-02f, -3.87760135e-03f, -4.09707986e-02f, 9.58201066e-02f, 3.53363194e-02f, -2.79744081e-02f, -3.25405039e-02f, -5.79065830e-02f, -6.11932874e-02f, 2.66686577e-04f,
  -8.20175931e-03f, -1.55042736e-02f, 6.55286014e-02f, -2.66362727e-02f, -5.52673303e-02f, -4.52707149e-02f, 3.05647980e-02f, -3.71648446e-02f, 1.91624928e-02f, -3.57834697e-02f,
  -6.96193501e-02f, 5.71531337e-03f, -1.28216460e-01f, -1.12842694e-02f, 2.95206141e-02f, -3.34246121e-02f, 1.63151640e-02f, -3.38491090e-02f, 4.07608151e-02f, -5.76907955e-02f,
  9.27462149e-03f, 1.71173021e-01f, 7.73353176e-03f, 1.47569645e-03f, -7.51364511e-04f, -3.53839435e-02f, -6.40660450e-02f, 2.03895085e-02f, -6.32201210e-02f, 6.57585310e-03f,
  -1.63652319e-02f, -7.53601707e-05f, 8.43172222e-02f, -7.31692985e-02f, 4.61287610e-02f, 3.17993201e-02f, 9.73997191e-02f, 9.28112958e-03f, 7.29362620e-03f, 4.12844820e-03f,
  4.43799756e-02f, 1.28511965e-01f, 8.37498307e-02f, 1.10099688e-01f, 4.73503210e-02f, 1.62897199e-01f, 4.50398885e-02f, 5.38123660e-02f, 2.22251758e-01f, 2.16684058e-01f,
  3.61970752e-01f, -3.54925245e-02f, -1.25974074e-01f, 3.54119539e-01f, 2.95001268e-02f, 1.13866143e-01f, 1.65460944e-01f, 1.11644782e-01f, 1.08899280e-01f, 1.19261675e-01f,
  -1.05039507e-01f, -8.18073452e-02f, 4.14992981e-02f, -4.82748002e-02f, -8.12145509e-03f, 1.96595162e-01f, 1.12842001e-01f, 1.64559297e-02f, 6.71390370e-02f, -4.83400784e-02f,
  -4.02406184e-03f, 1.16059482e-01f, -2.41594352e-02f, 1.05190556e-02f, 3.76816355e-02f, 4.38472107e-02f, 8.35153237e-02f, -2.52893046e-02f, -1.41201332e-01f, 9.91340503e-02f,
  -1.94447681e-01f, -4.01628427e-02f, -7.30508268e-02f, -7.03112409e-02f, -1.20771296e-01f, 5.87360822e-02f, -4.05742824e-02f, 1.78405717e-02f, -1.20526599e-02f, -1.50043871e-02f,
  -5.07179722e-02f, -1.01780621e-02f, 2.36075502e-02f, -7.08916709e-02f, 4.10473831e-02f, -3.25237513e-02f, 9.18251052e-02f, 9.36462581e-02f, 3.27118002e-02f, -7.19530061e-02f,
  -1.26075186e-02f, -2.04369146e-03f, 2.69707432e-03f, 2.34287102e-02f, 1.10792462e-02f, -1.17225900e-01f, -4.52844426e-02f, -4.01774757e-02f, -2.03912538e-02f, -1.63361635e-02f,
  5.17563708e-02f, -7.05756918e-02f, -6.51019737e-02f, 4.79335375e-02f, 5.16654328e-02f, -3.51337790e-02f, 3.13760377e-02f, 1.14934690e-01f, -1.25685725e-02f, -3.63818035e-02f,
  -9.25230384e-02f, 3.72282825e-02f, 3.69637124e-02f, 9.30619016e-02f, -1.75748467e-02f, 1.97309535e-02f, -7.40813650e-03f, -2.63686050e-02f, 2.38032565e-02f, 2.91543044e-02f,
  -3.77368480e-02f, -2.91397274e-02f, 7.83089995e-02f, -2.48411838e-02f, -8.15122798e-02f, -5.78180095e-03f, -3.66472155e-02f, -3.86440046e-02f, 2.17866264e-02f, -1.62347052e-02f,
  1.31512940e-01f, -2.06380680e-01f, 3.94352935e-02f, 8.70396569e-02f, 5.18227369e-02f, -1.31612062e-01f, -7.47418404e-02f, -1.02870101e-02f, -4.60517146e-02f, 5.02949171e-02f,
  -1.16424501e-01f, -4.40488942e-02f, 5.24778804e-03f, -2.35848259e-02f, 5.75268120e-02f, 3.33658122e-02f, 3.03941313e-02f, 4.62000854e-02f, -3.04073356e-02f, -4.48127016e-02f,
  8.99722725e-02f, 1.25935301e-01f, 5.47810532e-02f, 1.12524077e-01f, 1.68380253e-02f, 5.17519042e-02f, -7.34232292e-02f, -2.40574609e-02f, -8.95403232e-03f, 1.98739827e-01f,
  -4.02358733e-02f, -9.78076234e-02f, 2.72026479e-01f, -2.47910008e-01f, 2.21452504e-01f, 3.86681527e-01f, 2.23719597e-01f, -3.75018157e-02f, -9.04697701e-02f, -8.31400380e-02f,
  1.84005558e-01f, 2.73278654e-02f, 4.35103141e-02f, 4.44339663e-02f, 3.51377465e-02f, 6.38889521e-02f, -2.99575482e-03f, 7.72959590e-02f, 2.04744548e-01f, 1.82418540e-01f,
  -1.15707874e-01f, -2.11250007e-01f, -1.62275761e-01f, -6.86438531e-02f, -2.96590060e-01f, 5.78794163e-03f, -1.68589786e-01f, -1.42585468e-02f, -3.47561091e-02f, -2.24615574e-01f,
  7.67441317e-02f, 6.02048934e-02f, 8.13217163e-02f, -1.74247827e-02f, 2.07149927e-02f, -9.62448679e-03f, 1.13835439e-01f, 1.30521636e-02f, 8.28497186e-02f, -7.12435767e-02f,
  3.51212323e-02f, 5.77946007e-03f, -1.15858652e-02f, 5.01187379e-03f, -8.40489939e-02f, -1.87332910e-02f, -7.71690905e-02f, -1.66050494e-02f, -1.99969634e-02f, 3.17260586e-02f,
  -1.41210156e-02f, 1.17805921e-01f, 2.23802939e-01f, 4.69285771e-02f, 8.39309096e-02f, 1.14624478e-01f, 9.15563330e-02f, 5.36601394e-02f, 1.61149472e-01f, -1.60930127e-01f,
  -2.83987839e-02f, -1.91367045e-02f, 5.39809130e-02f, -7.13859871e-02f, -3.48304994e-02f, 3.91419493e-02f, -6.99803159e-02f, -8.39230195e-02f, -1.14437798e-02f, -8.99232775e-02f,
  1.77239925e-02f, 5.89480065e-02f, -7.09996969e-02f, 3.93157378e-02f, -1.82378776e-02f, -1.45506347e-02f, 5.30091748e-02f, -9.66721922e-02f, 5.11429608e-02f, 2.49578916e-02f,
  2.24001259e-02f, 4.35869396e-02f, -9.54948273e-03f, -8.63178521e-02f, 9.17694420e-02f, -3.92894223e-02f, -1.08647356e-02f, 5.15940301e-02f, -4.86802720e-02f, 7.82929510e-02f,
  -2.30728298e-01f, 2.91686147e-01f, -8.64012539e-02f, -5.90092465e-02f, -2.47747544e-02f, -8.06099102e-02f, 4.14812639e-02f, -5.23589626e-02f, -3.04924399e-02f, 2.08437759e-02f,
  2.91313678e-02f, 2.90028146e-03f, -1.54693322e-02f, -3.55475880e-02f, 3.10260039e-02f, -2.25687046e-02f, -4.74244691e-02f, 4.19021957e-02f, -7.76819438e-02f, -6.63645640e-02f,
  -1.46734685e-01f, -5.29627502e-02f, 5.03596514e-02f, 5.26953414e-02f, -2.90288832e-02f, 1.39362365e-01f, 4.91709597e-02f, -3.15813497e-02f, 9.91510972e-02f, -1.67108238e-01f,
  -6.58780038e-01f, 2.29232162e-01f, -2.79955752e-02f, -6.88026696e-02f, 1.35044813e-01f, -3.62558216e-02f, 9.77136418e-02f, -9.74205658e-02f, -5.86454161e-02f, 6.10545650e-02f,
  3.13569367e-01f, 5.49878879e-03f, 9.28073972e-02f, -4.67028506e-02f, -1.15951888e-01f, 3.11144278e-03f, -2.52511334e-02f, -2.75153518e-01f, -3.65339667e-01f, -9.45029557e-02f,
  1.60828799e-01f, -1.63708299e-01f, -3.05589825e-01f, -1.52270541e-01f, 1.24116912e-01f, -6.85157813e-03f, 1.77037254e-01f, 3.29010710e-02f, 2.41264582e-01f, 3.06630969e-01f,
  3.62018347e-02f, -1.83132924e-02f, -1.00409321e-01f, 1.03409760e-01f, 1.50812492e-01f, -8.86615068e-02f, -3.58952992e-02f, 5.64368404e-02f, 1.75507162e-02f, -5.25755668e-03f,
  -1.60998185e-04f, 6.52383268e-02f, 5.62982820e-02f, 5.02679832e-02f, 1.19472817e-02f, -1.80471912e-01f, -5.92776202e-02f, -1.86445013e-01f, -8.61858875e-02f, -2.40614004e-02f,
  1.05458751e-01f, 6.53283447e-02f, -1.53629228e-01f, -3.59372832e-02f, -4.78701433e-03f, 3.74079049e-02f, 4.65560518e-02f, 5.23533374e-02f, -5.19902967e-02f, -1.94010846e-02f,
  1.92131270e-02f, 4.57534604e-02f, 4.07577716e-02f, 9.38318763e-03f, -3.35504375e-02f, 1.58211198e-02f, -9.60004982e-03f, 1.98936425e-02f, -5.79311326e-03f, -7.15192705e-02f,
  2.62595601e-02f, 1.47270830e-02f, 1.43751793e-04f, -8.67512003e-02f, 1.19639412e-02f, -1.29574006e-02f, 1.99692920e-02f, -3.36252153e-02f, -7.46301413e-02f, -8.09402205e-03f,
  -9.49259549e-02f, 1.67536433e-03f, 5.31404987e-02f, -4.53426614e-02f, 7.03063086e-02f, -2.09493209e-02f, 1.24741038e-02f, -1.73449200e-02f, 8.48033000e-03f, -2.84760427e-02f,
  -2.33271047e-01f, 1.15390934e-01f, -5.34593388e-02f, -1.50085554e-01f, -2.07482465e-02f, 3.88506465e-02f, 5.72046498e-03f, 2.19550375e-02f, 7.56890327e-02f, -8.56978521e-02f,
  7.99371675e-03f, -1.59890696e-01f, 5.12551665e-02f, -4.32004482e-02f, -3.58238965e-02f, -3.40077579e-02f, 5.64458519e-02f, 1.85556710e-02f, -6.22721761e-02f, 3.98193859e-02f,
  -3.25990468e-02f, -1.35992303e-01f, -2.53767967e-01f, -1.20188110e-01f, 2.74501275e-02f, -7.35190287e-02f, -4.69555855e-02f, -1.05491869e-01f, -1.80692583e-01f, -2.59027362e-01f,
  -3.18255633e-01f, 5.32287173e-02f, 1.16546430e-01f, -1.83624372e-01f, 2.60040522e-01f, 3.63357872e-01f, 4.11357582e-01f, 1.86568871e-02f, -1.56016767e-01f, 7.74442106e-02f,
  -8.89376998e-02f, -1.58169940e-01f, -3.11328679e-01f, -1.45505741e-01f, -3.61020528e-02f, 1.78457648e-01f, 2.35536963e-01f, -9.94272977e-02f, -1.72985427e-04f, 1.59410506e-01f,
  4.07302715e-02f, -1.01289116e-01f, -9.26252455e-02f, -1.24295488e-01f, -3.31235565e-02f, -6.91356584e-02f, 3.00905928e-02f, -6.58940002e-02f, 1.29343182e-01f, 3.25693865e-03f,
  6.82456866e-02f, 2.40577515e-02f, 1.51705081e-02f, -1.71557199e-02f, 6.08524270e-02f, -9.50475186e-02f, -2.25618947e-02f, -1.34366170e-01f, -3.85774486e-02f, -3.42459825e-04f,
  3.82011682e-02f, -7.95409381e-02f, -6.30683228e-02f, 1.21388705e-02f, -4.38450240e-02f, 7.80899674e-02f, -5.11946082e-02f, -4.36232798e-02f, -4.06903215e-02f, -5.40514030e-02f,
  -1.53301586e-03f, 6.13520108e-03f, 8.07057992e-02f, 8.42786878e-02f, 1.03662116e-02f, -7.39559904e-02f, 1.13352254e-01f, -3.76411304e-02f, 1.39397336e-02f, -1.52422354e-01f,
  4.22567576e-02f, -3.04318946e-02f, 2.47126240e-02f, -1.35286488e-02f, -3.22963409e-02f, -4.41614129e-02f, -3.98978777e-03f, 1.01118488e-02f, 2.44150274e-02f, 4.46286127e-02f,
  4.81976680e-02f, -3.66618810e-03f, -3.30971442e-02f, -4.28480357e-02f, -1.08579509e-01f, 3.77176218e-02f, 4.05516103e-02f, 6.17110776e-03f, 1.00710457e-02f, -1.82448775e-02f,
  -3.95019501e-02f, 5.41442148e-02f, -1.78588890e-02f, 4.26071025e-02f, 5.84043888e-03f, -2.54501645e-02f, -1.57875419e-02f, -4.68124039e-02f, -2.73456164e-02f, 1.32825896e-02f,
  -1.55670792e-01f, 4.90381494e-02f, -4.37868480e-03f, -3.22636887e-02f, -1.89750008e-02f, -1.04686311e-02f, -2.00938508e-02f, 6.12726770e-02f, 2.16527022e-02f, 3.41021195e-02f,
  1.08141840e-01f, -1.00360224e-02f, -5.04520461e-02f, 6.79823756e-02f, 7.57212564e-02f, 7.75622055e-02f, 8.09960812e-03f, -2.47668941e-02f, 2.20031720e-02f, -1.19695431e-02f,
  2.09579878e-02f, 6.08089641e-02f, -7.67518952e-02f, -2.12750323e-02f, -3.12602744e-02f, 1.45950485e-02f, 7.33853132e-02f, 7.51197711e-02f, 4.05929657e-03f, -3.32965441e-02f,
  2.83040740e-02f, -1.36149079e-01f, -1.76570147e-01f, 7.35869072e-03f, -6.15493171e-02f, -2.20228672e-01f, -3.43382597e-01f, -4.61831465e-02f, -3.07089053e-02f, -8.50367248e-02f,
  -4.00765166e-02f, 1.97649702e-01f, 8.77453163e-02f, -3.79185528e-02f, -7.48002157e-02f, -2.36739144e-01f, -2.10132480e-01f, -1.78019330e-01f, -5.64054772e-02f, 1.34486379e-02f,
  -4.98029254e-02f, 6.74723461e-02f, 3.20407972e-02f, -4.41152044e-02f, 3.49955484e-02f, 5.99926747e-02f, 5.81844673e-02f, 2.67186631e-02f, 2.53734477e-02f, 1.05670787e-01f,
  1.70873329e-02f, -4.62387055e-02f, -2.48425342e-02f, 2.63625905e-02f, -5.57613187e-02f, 7.28620514e-02f, 7.72579610e-02f, -2.35775486e-02f, 2.62891483e-02f, -8.12129900e-02f,
  6.14296533e-02f, 2.05468275e-02f, 8.80049393e-02f, -1.09552182e-02f, 4.21314128e-02f, 4.42806147e-02f, -3.88931260e-02f, 2.60123219e-02f, -1.05417363e-01f, 6.15447462e-02f,
  -2.69346647e-02f, -3.65427621e-02f, -7.87957832e-02f, 2.59071793e-02f, -5.63868582e-02f, 9.72114429e-02f, -4.81093489e-02f, -2.74151638e-02f, 1.04544582e-02f, 1.56329144e-02f,
  -7.06067868e-03f, -9.97589231e-02f, -4.52599153e-02f, 2.89055947e-02f, 3.00579853e-02f, 5.04720919e-02f, 7.26130605e-02f, -3.72814909e-02f, -5.94360493e-02f, 5.43681942e-02f,
  -5.86805716e-02f, -1.06585817e-02f, -1.16587896e-02f, -8.45045447e-02f, 8.39195773e-02f, 2.81778187e-03f, 6.11970201e-02f, -6.03312775e-02f, 4.66802530e-02f, 6.16316646e-02f,
  5.74026816e-02f, -8.32856167e-03f, -7.71117434e-02f, 6.96608871e-02f, -6.36944100e-02f, -7.02413023e-02f, 2.65800729e-02f, 1.93945486e-02f, 3.06281243e-02f, -8.49257410e-02f,
  1.36962786e-01f, -1.67924747e-01f, 4.30521891e-02f, 6.60778061e-02f, -4.88202833e-02f, 3.81887183e-02f, -9.60430130e-03f, -6.66705966e-02f, 7.23826140e-02f, 6.26452640e-02f,
  5.97158931e-02f, 3.59271988e-02f, -1.02955237e-01f, 5.84119000e-02f, -2.84193959e-02f, -2.92588249e-02f, -9.99756902e-02f, -2.98616104e-02f, -2.83985529e-02f, -4.91542928e-02f,
  -1.10403774e-02f, -2.77471952e-02f, 6.74841329e-02f, 4.97435406e-02f, 1.84564143e-02f, -2.61864141e-02f, 5.67250773e-02f, 9.09919515e-02f, -8.93239751e-02f, 1.12182703e-02f,
  -8.17784369e-02f, 2.71095306e-01f, 3.48466694e-01f, -1.24543734e-01f, 3.82571407e-02f, 1.16401479e-01f, 3.73376071e-01f, 1.11111782e-01f, -1.96084544e-01f, 4.62609231e-02f,
  -2.47470543e-01f, -3.50369126e-01f, -2.36703902e-01f, -1.70402527e-01f, 7.15580061e-02f, 2.94533283e-01f, 2.66578823e-01f, 1.32062808e-02f, -1.78193420e-01f, -2.36528382e-01f,
  -1.87507346e-01f, -5.45231253e-02f, 1.39577184e-02f, -3.86639908e-02f, 1.08905450e-01f, -1.39015140e-02f, 7.53825828e-02f, 1.14040151e-01f, 6.07174374e-02f, 1.49407998e-01f,
  -4.23626527e-02f, 8.37168917e-02f, -5.68947308e-02f, -1.66550919e-01f, 3.53545696e-02f, -5.60727976e-02f, 1.11635840e-02f, 2.60004587e-02f, -5.33286929e-02f, -1.26183862e-02f,
  -1.24489078e-02f, -5.42984083e-02f, -9.53973830e-02f, 5.76909352e-03f, 3.32209133e-02f, -5.58036864e-02f, 4.31984589e-02f, 8.76238421e-02f, 7.06601441e-02f, 1.35305017e-01f,
  -4.76460606e-02f, 6.45788833e-02f, 9.56801698e-02f, 1.02060698e-01f, 8.05901811e-02f, -2.98001077e-02f, 1.16964087e-01f, 2.54178178e-02f, 1.52026802e-01f, 2.29648709e-01f,
  -1.36787491e-02f, -2.12739408e-02f, 8.05316027e-03f, 4.94827144e-02f, -6.37880042e-02f, 1.54136233e-02f, -2.82740239e-02f, -1.98268183e-02f, -1.08547071e-02f, 5.39706685e-02f,
  -1.41798528e-02f, -7.97104742e-03f, 2.02575885e-02f, 5.91984503e-02f, -6.17639124e-02f, 1.04045346e-01f, 1.90542042e-02f, 2.23427601e-02f, -4.71137799e-02f, 7.20614893e-03f,
  -5.14475256e-02f, 3.15333344e-02f, 8.33343901e-03f, -1.39927128e-02f, 1.39644649e-02f, 4.59475592e-02f, 1.11646822e-03f, -5.37662674e-03f, 1.08423699e-02f, -3.14801820e-02f,
  -1.47535235e-01f, 3.04550603e-02f, -7.67999515e-02f, 1.95783600e-02f, -3.61838937e-02f, -2.36745887e-02f, -3.16631794e-02f, -2.17643213e-02f, -6.50574267e-02f, -9.25996061e-03f,
  -2.26995219e-02f, -3.76339629e-02f, -3.73416557e-03f, 2.31313705e-03f, -4.41844240e-02f, -7.62473792e-02f, 1.19861802e-02f, 2.35182941e-02f, 8.06411670e-04f, -2.56252829e-02f,
  3.40186208e-02f, 1.01718605e-01f, -1.00478478e-01f, -1.49969319e-02f, 3.32060456e-02f, -1.17639445e-01f, 1.00329863e-02f, 8.36461782e-02f, 5.48120551e-02f, 1.56587288e-01f,
  2.71885544e-01f, 2.54339635e-01f, -7.74123743e-02f, 2.38671347e-01f, -9.34455171e-02f, -2.43919879e-01f, -2.15179756e-01f, 4.40994725e-02f, 1.04051255e-01f, 2.32503742e-01f,
  1.18037894e-01f, 2.99647804e-02f, 9.15611535e-02f, -1.05649143e-01f, -6.50643557e-02f, 3.73700149e-02f, -1.08941421e-01f, -1.92655295e-01f, -2.70813078e-01f, -2.26627871e-01f,
  8.10918864e-04f, 7.20641539e-02f, 7.99705926e-03f, -1.18229985e-01f, 4.84759063e-02f, 7.31607974e-02f, 1.63138494e-01f, 1.37258142e-01f, -3.21133845e-02f, 1.93116292e-01f,
  2.60624349e-01f, 1.45932645e-01f, -9.44788530e-02f, -8.47269818e-02f, 1.14980698e-01f, 5.69643686e-03f, -3.27174179e-02f, 8.41078237e-02f, -6.04089685e-02f, 7.68458992e-02f,
  3.25359334e-03f, -4.94425930e-02f, -3.11995354e-02f, -5.32226153e-02f, 4.27763015e-02f, 9.49284434e-03f, -1.55747393e-02f, 4.03506402e-03f, -8.04600492e-02f, 4.63815965e-02f,
  6.52567819e-02f, -3.98521312e-02f, -1.72788203e-02f, -1.38537332e-01f, -3.18960696e-02f, -8.18762630e-02f, -2.62403600e-02f, -6.60026819e-02f, -2.00260758e-01f, 1.56439051e-01f,
  -1.12199374e-01f, 3.25089097e-02f, -5.29261567e-02f, -2.58496031e-03f, 1.29357316e-02f, 6.49790540e-02f, -8.86705052e-03f, 4.30949628e-02f, -2.62917932e-02f, 7.32874796e-02f,
  3.90163437e-02f, 9.71933361e-03f, 1.57153942e-02f, 4.00874317e-02f, 2.67223846e-02f, -5.15061058e-02f, 5.08844294e-02f, -2.75848582e-02f, 5.53654246e-02f, -2.47132070e-02f,
  -1.33117326e-02f, -3.00712720e-03f, 4.30992357e-02f, 2.89999470e-02f, -8.27497616e-02f, -3.73459719e-02f, -4.23556417e-02f, -1.46659948e-02f, 1.02736406e-01f, 5.05636334e-02f,
  3.24748039e-01f, -1.79348648e-01f, 1.95311308e-01f, -5.18180057e-03f, -3.68194166e-03f, 2.86149327e-02f, 9.11697969e-02f, 8.26017186e-03f, 5.56022786e-02f, 1.40499175e-02f,
  -7.08638653e-02f, 4.33039665e-03f, 8.51105824e-02f, -2.63019893e-02f, -3.65892909e-02f, 2.16542333e-02f, 3.36705856e-02f, -2.07491294e-02f, 4.35220115e-02f, 1.68116558e-02f,
  -5.16605272e-04f, 4.38814750e-03f, 8.41521248e-02f, 1.51355695e-02f, -4.09362949e-02f, 7.57069374e-03f, 5.25533222e-02f, -1.91098396e-02f, -8.57776478e-02f, 1.21375687e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.37102306e-01f, -2.07742769e-02f, -9.78671983e-02f, 6.97533414e-02f, -8.79180506e-02f, 3.82876315e-04f, -1.96122155e-01f, -9.16489139e-02f, -1.14206374e-02f, -1.12984538e-01f,
  -6.68715909e-02f, -2.61906628e-02f, 7.73429871e-02f, 1.23916017e-02f, 1.06147537e-02f, -1.25876546e-01f, -1.03673413e-02f, -8.56183246e-02f, -4.97326776e-02f, 3.66620533e-02f,
  -8.70011672e-02f, 2.70082075e-02f, 7.80495107e-02f, -4.65552211e-02f, -1.97068956e-02f, 1.66102983e-02f, -1.02771230e-01f, -6.40119761e-02f, -9.00627077e-02f, -6.30046949e-02f,
  -7.01325387e-02f, 1.25820376e-02f, -5.30699417e-02f, -1.68514494e-02f, 1.83827206e-02f, 4.14249599e-02f, -5.88062219e-02f, 8.95664990e-02f, -2.04472803e-02f, -2.33603250e-02f,
  7.03176111e-02f, 1.01593852e-01f, -4.77034301e-02f, -7.01399371e-02f, -3.73832248e-02f, 7.74346739e-02f, -8.32305104e-02f, 3.19026262e-02f, 6.84100240e-02f, 3.43218818e-02f,
  4.18468304e-02f, 4.57801595e-02f, 1.03938570e-02f, 5.25993109e-02f, -3.47241387e-02f, 5.25393710e-02f, -7.90030882e-02f, 7.62452632e-02f, -4.93855327e-02f, 1.76649708e-02f,
  -5.05747907e-02f, -3.85409668e-02f, -4.84890714e-02f, -6.05611727e-02f, 5.12265675e-02f, 1.86499748e-02f, 2.11692955e-02f, -1.00256033e-01f, -5.45763876e-03f, -1.08274840e-01f,
  -4.89819050e-02f, 6.94973907e-03f, -5.60670532e-02f, 2.30355021e-02f, -8.78347084e-02f, -5.11484370e-02f, 7.75791630e-02f, 2.47258041e-02f, -1.15680426e-01f, -6.66738627e-03f,
  8.08313191e-02f, 6.08240627e-02f, -1.01571456e-01f, 4.10122611e-02f, 5.56231923e-02f, 1.50724652e-03f, -6.31451979e-02f, -5.39438389e-02f, 2.06605978e-02f, -6.47804365e-02f,
  9.89914387e-02f, 4.12374623e-02f, 4.39663185e-03f, 8.24924186e-02f, 1.00427985e-01f, 4.36957926e-02f, 2.45195720e-02f, -4.42495979e-02f, 4.25102562e-02f, 3.38241011e-02f,
  2.96551697e-02f, 5.97845875e-02f, -5.60608543e-02f, -3.45720313e-02f, -2.55522095e-02f, -4.19052094e-02f, 3.01929228e-02f, 1.48517760e-02f, 5.45962900e-02f, -1.38338711e-02f,
  -3.36021036e-02f, 4.63046953e-02f, -6.49380162e-02f, -8.40937644e-02f, 4.72033247e-02f, 6.00607544e-02f, 2.75080488e-03f, -6.12505106e-03f, -8.15920010e-02f, -1.23509668e-01f,
  -1.79000020e-01f, -1.34783253e-01f, -2.73787081e-01f, -1.42317235e-01f, 2.62457300e-02f, 6.84177428e-02f, -3.25636640e-02f, 5.96346073e-02f, 5.24824560e-02f, -5.74679635e-02f,
  -1.63942743e-02f, 7.87806958e-02f, -3.73750925e-02f, -3.38920839e-02f, -1.26009643e-01f, -2.06793636e-01f, -2.86250442e-01f, -2.22050354e-01f, 9.33156291e-04f, 7.87355676e-02f,
  -1.85231436e-02f, -6.15660511e-02f, -1.69852242e-01f, 2.62082964e-02f, -7.47573450e-02f, -1.50847837e-01f, -3.02774966e-01f, -1.73452839e-01f, -1.70456350e-01f, -3.23835135e-01f,
  -1.85775533e-01f, 1.43284708e-01f, 1.06999621e-01f, -4.00113873e-02f, -7.67822489e-02f, -2.41673235e-02f, -2.22440995e-02f, -3.84452865e-02f, -6.08120896e-02f, 3.85175901e-03f,
  -3.71651351e-02f, 6.25116900e-02f, 2.15110332e-02f, 1.22846350e-01f, 1.00293294e-01f, 2.10461188e-02f, 2.10271645e-02f, -5.60088567e-02f, -2.75314804e-02f, 1.25872180e-01f,
  3.13089713e-02f, -9.94965136e-02f, -1.11761585e-01f, 3.34571628e-03f, -6.23475388e-02f, -1.07467391e-01f, -1.05345957e-01f, -6.45337626e-02f, -7.72393867e-02f, -1.57436669e-01f,
  9.21099782e-02f, 1.07537443e-02f, 6.29351139e-02f, 7.34657496e-02f, -4.60962765e-02f, 3.38630155e-02f, -1.30331870e-02f, 6.31268311e-04f, -2.61453670e-02f, -3.31239663e-02f,
  -1.99429644e-03f, -2.06073206e-02f, 4.69958596e-02f, -2.55102087e-02f, -5.47723286e-02f, -1.10311126e-02f, -7.10355630e-03f, -6.39462695e-02f, -3.70626189e-02f, -8.27761292e-02f,
  -8.57301205e-02f, 1.24250427e-02f, 3.59692350e-02f, 6.21649586e-02f, -3.89032736e-02f, -9.33009014e-02f, 4.06860560e-02f, 7.32674077e-02f, 3.73411477e-02f, 2.68945452e-02f,
  -2.01005697e-01f, 4.04398218e-02f, -1.99169949e-01f, -4.70806286e-02f, -1.49484333e-02f, -2.30233930e-02f, 5.19247446e-03f, 2.77397111e-02f, 4.99444492e-02f, -2.65266113e-02f,
  1.29988883e-02f, 7.84172192e-02f, -1.29096583e-01f, 1.19758118e-02f, 3.02105136e-02f, 7.23441839e-02f, -1.12680243e-02f, -1.04368269e-01f, -5.30892499e-02f, 8.96306038e-02f,
  -5.01027405e-02f, -1.29146606e-01f, -1.86138391e-01f, -1.10413052e-01f, -4.04223334e-03f, -1.49466157e-01f, -1.62180513e-01f, -1.40838400e-01f, -2.14607865e-01f, -2.64531404e-01f,
  9.20654833e-03f, 1.12494878e-01f, 1.56798556e-01f, 1.44281209e-01f, 1.77858904e-01f, 2.09454119e-01f, 1.06951170e-01f, 1.64284512e-01f, 1.87066466e-01f, 1.81562573e-01f,
  4.07226123e-02f, 2.44826917e-03f, 6.88912719e-02f, 4.22889926e-03f, 1.53994381e-01f, 2.49936283e-01f, 2.19046578e-01f, 1.96453944e-01f, 1.43052429e-01f, 1.90347910e-01f,
  1.63671330e-01f, 1.71863303e-01f, 8.55536014e-03f, 1.40871089e-02f, 1.53493419e-01f, 6.26989976e-02f, 1.22830689e-01f, 1.79605365e-01f, 1.12566024e-01f, 2.38397703e-01f,
  -4.52675447e-02f, 7.73081258e-02f, -2.94959377e-02f, 1.27378106e-02f, -3.87167223e-02f, -1.25891328e-01f, 4.19718735e-02f, -1.45195946e-01f, -3.50495172e-03f, 2.56174970e-02f,
  -4.74104919e-02f, -5.08836582e-02f, -2.15298589e-02f, 1.72493216e-02f, -3.17639261e-02f, 1.58986524e-02f, 3.00882440e-02f, -6.63592070e-02f, -7.50524327e-02f, 6.84901550e-02f,
  6.09365851e-02f, 5.64846024e-02f, -3.22673917e-02f, 1.90599840e-02f, 3.66477557e-02f, 7.40879104e-02f, -3.16669717e-02f, -3.49557698e-02f, -5.57621382e-02f, -3.45936939e-02f,
  1.09916061e-01f, -2.64741741e-02f, 6.31464124e-02f, 7.46777430e-02f, 4.09239829e-02f, -6.12168498e-02f, 4.06837044e-03f, 1.92886982e-02f, 9.71167013e-02f, -6.75074458e-02f,
  3.88637893e-02f, 4.94531058e-02f, 6.23194613e-02f, 1.25685737e-01f, 5.32619506e-02f, -5.82449771e-02f, 3.12150102e-02f, 5.68951219e-02f, -2.49012914e-02f, -2.21054368e-02f,
  -3.55049036e-02f, -1.35474754e-02f, 1.53901614e-02f, 4.81781475e-02f, -2.23103706e-02f, 1.12412989e-01f, 4.14874079e-03f, -6.00641295e-02f, -1.25229787e-02f, -8.40235781e-03f,
  -1.19053259e-01f, -1.46835670e-01f, 3.98870073e-02f, 3.16285598e-03f, -2.73618270e-02f, -6.93085268e-02f, 3.55573297e-02f, -1.31627083e-01f, -2.11456255e-03f, 5.78294061e-02f,
  -4.54758741e-02f, 7.91136324e-02f, -4.21087258e-02f, -3.93259525e-02f, -5.98943383e-02f, -6.87689781e-02f, -5.62352948e-02f, 6.82502389e-02f, 5.70186181e-03f, -1.20900780e-01f,
  2.29241196e-02f, -5.82300462e-02f, -3.72856185e-02f, -1.86987966e-03f, 7.33122975e-02f, 5.38041741e-02f, -9.58401337e-02f, -1.16132982e-01f, -1.18933342e-01f, -1.14221491e-01f,
  -4.13571000e-01f, -1.03099778e-01f, -2.30902836e-01f, 5.55738583e-02f, 1.17043629e-01f, 3.32095660e-02f, 2.83288471e-02f, -3.45466658e-02f, 1.13575578e-01f, 4.56851311e-02f,
  5.13299853e-02f, 1.33259997e-01f, 3.28468904e-02f, 6.35863096e-02f, 2.27011298e-03f, -5.23298271e-02f, 4.46974561e-02f, -8.32310617e-02f, -8.22122470e-02f, 1.03610739e-01f,
  2.56034672e-01f, 7.28115961e-02f, -7.49207735e-02f, -3.26192304e-02f, 1.82754606e-01f, 3.24330628e-02f, -7.88637772e-02f, 6.76556528e-02f, 4.95071597e-02f, 1.26139089e-01f,
  -2.08829001e-01f, -1.41023412e-01f, -5.74918836e-02f, 1.07681014e-01f, -1.62677430e-02f, -1.26187950e-01f, -8.05901363e-02f, -9.91711840e-02f, -4.30126190e-02f, 3.71602923e-03f,
  -2.16891244e-02f, 4.90194522e-02f, 1.04128070e-01f, -6.05054423e-02f, -4.07311842e-02f, -6.18434809e-02f, -1.37633120e-04f, -2.19199225e-01f, -1.81920275e-01f, -1.50333732e-01f,
  1.31922662e-01f, -2.70220563e-02f, -1.59882128e-01f, -8.68225321e-02f, -1.80305585e-01f, -1.00269159e-02f, -1.14735782e-01f, -5.38340583e-02f, -9.99194980e-02f, -2.19331324e-01f,
  2.20043864e-02f, 3.43474708e-02f, 8.62570200e-03f, 2.13806867e-03f, -2.44061388e-02f, 7.44683146e-02f, 4.68223616e-02f, 1.66077651e-02f, 3.39958631e-02f, 2.69957613e-02f,
  1.85973570e-02f, -7.78630078e-02f, 7.39051104e-02f, 6.03172854e-02f, -3.50271501e-02f, 6.48615416e-03f, 1.53213264e-02f, 3.99342179e-02f, 1.12221744e-02f, -1.14705795e-02f,
  5.77187277e-02f, -6.31875619e-02f, -9.42315608e-02f, 5.11833020e-02f, -7.15345964e-02f, -5.67517094e-02f, 7.40134045e-02f, 3.84840928e-02f, -5.98213971e-02f, -8.93733501e-02f,
  -7.43566304e-02f, -1.09233819e-01f, -8.92903581e-02f, 1.19706906e-01f, 1.28285345e-02f, 2.38582841e-03f, -6.24489635e-02f, -1.54941436e-02f, -2.29590815e-02f, -4.71550226e-02f,
  -5.65864444e-02f, -9.37195793e-02f, -3.05691939e-02f, 1.05638904e-02f, -2.87578963e-02f, -2.52076369e-02f, -5.91128804e-02f, -8.57974738e-02f, -2.81612482e-02f, 6.61838241e-03f,
  -1.30899459e-01f, -1.11477800e-01f, -1.00104347e-01f, -1.88098893e-01f, 2.53147297e-02f, -7.43774846e-02f, -6.74367100e-02f, -1.45321503e-01f, -1.55531526e-01f, -3.26956898e-01f,
  3.33829194e-01f, -2.96615250e-02f, 9.65480600e-03f, -4.23398800e-02f, -2.29621649e-01f, -2.82324791e-01f, -2.57713020e-01f, -1.56929299e-01f, -7.98387046e-04f, -7.91188255e-02f,
  8.53318349e-03f, -5.92507981e-02f, 2.72554327e-02f, 6.69037551e-02f, 1.49494857e-01f, 3.94212455e-02f, 1.09966874e-01f, 1.91084206e-01f, 2.10584357e-01f, 1.44046351e-01f,
  5.28462231e-02f, 1.29174992e-01f, 2.14936525e-01f, 1.21882416e-01f, 5.39307483e-02f, 6.46000728e-02f, -5.58966361e-02f, 1.26917660e-01f, 2.82015447e-02f, 2.84026265e-01f,
  1.67748407e-01f, 8.11852291e-02f, 1.75587852e-02f, -1.30390683e-02f, -4.27055098e-02f, 1.43692821e-01f, -6.96072355e-02f, 1.08998083e-01f, 3.43446806e-02f, -6.34526983e-02f,
  3.66171896e-02f, 6.93816226e-03f, -1.16897961e-02f, 7.73357749e-02f, 4.45325226e-02f, 8.37906748e-02f, 1.98566522e-02f, 7.02807978e-02f, -2.94305547e-03f, 8.34999010e-02f,
  -9.49186832e-02f, -1.02785364e-01f, -5.16275167e-02f, -1.50228858e-01f, 7.00967461e-02f, -4.27678339e-02f, -1.68471672e-02f, 4.18423209e-03f, 1.50998561e-02f, 9.26243961e-02f,
  -2.23727450e-02f, -2.87660975e-02f, -1.12635465e-02f, 6.98309066e-03f, 1.63361933e-02f, -1.07261308e-01f, 4.21844088e-02f, -7.14579150e-02f, 1.31174317e-03f, -4.46109436e-02f,
  4.35814522e-02f, 9.77198128e-03f, 4.13650386e-02f, -8.17722380e-02f, 2.13232450e-02f, -2.35468540e-02f, 2.89814509e-02f, -5.42989895e-02f, 6.69578537e-02f, -2.89472975e-02f,
  -1.39255924e-02f, -1.03696592e-01f, 4.80256602e-02f, -2.58315708e-02f, 4.09744084e-02f, -4.40817140e-02f, 2.88446574e-03f, -2.09813868e-03f, -7.12174550e-02f, 5.06338780e-04f,
  -4.57773395e-02f, -5.13211787e-02f, 1.07914671e-01f, 1.57990959e-02f, 5.96917607e-03f, -3.67387012e-02f, 1.34248612e-03f, -7.28613464e-03f, -5.87706687e-03f, -3.46091129e-02f,
  5.47206327e-02f, 8.55147168e-02f, -7.23073930e-02f, 9.49723348e-02f, 1.56284757e-02f, -3.38069797e-02f, 1.63199417e-02f, -7.00259209e-02f, -1.60292909e-02f, -3.60980034e-02f,
  -9.81592089e-02f, -1.36449382e-01f, -1.59439191e-01f, -1.34326965e-01f, -2.04322133e-02f, -3.66590321e-02f, -6.59384727e-02f, -4.87026013e-02f, -4.35681008e-02f, -1.85720667e-01f,
  -6.06464408e-02f, 2.80740678e-01f, 1.23126984e-01f, 1.23554736e-01f, 2.14572251e-01f, 3.03495705e-01f, 3.46375674e-01f, 1.46077156e-01f, 8.47424287e-03f, 7.31799826e-02f,
  4.80220169e-02f, -1.73886746e-01f, -8.08368325e-02f, -6.06305040e-02f, 1.07823908e-01f, 2.15137497e-01f, 2.20266238e-01f, 3.83564942e-02f, -7.49576837e-02f, -3.30690457e-03f,
  9.58281308e-02f, 1.49735063e-01f, 8.81808996e-02f, 3.83599773e-02f, 5.36198877e-02f, 4.43766229e-02f, 4.42034304e-02f, 1.17065735e-01f, 1.34190872e-01f, 5.54561391e-02f,
  -1.59832805e-01f, 1.49190009e-01f, -6.87508956e-02f, -1.43275842e-01f, -2.56160647e-02f, -6.62000477e-02f, -8.56365729e-03f, -8.54705945e-02f, -4.83251326e-02f, 3.48060280e-02f,
  3.25999372e-02f, -2.60196850e-02f, -2.18664221e-02f, 1.24760019e-02f, 6.92523494e-02f, 1.47172986e-02f, -1.95242427e-02f, 6.47285674e-03f, 2.60099247e-02f, -5.00624664e-02f,
  4.05668356e-02f, 3.68524827e-02f, 4.40574475e-02f, 5.74964099e-02f, -1.79728214e-03f, -2.42259726e-02f, 5.29019274e-02f, -1.48797901e-02f, -1.00573540e-01f, -8.55478272e-02f,
  -1.04769655e-01f, -1.66947953e-02f, 5.71723506e-02f, 7.16848671e-02f, -4.32113446e-02f, 4.58439328e-02f, 9.30046663e-03f, -1.19807003e-02f, -2.03549471e-02f, 4.89483662e-02f,
  -8.45550969e-02f, -1.18143305e-01f, 4.21873759e-03f, -9.26430151e-02f, -5.33459671e-02f, -2.92160572e-03f, 2.88351867e-02f, -1.06604196e-01f, -6.94815069e-02f, -5.65871932e-02f,
  -3.36084664e-02f, -7.10174488e-03f, 2.91727316e-02f, -8.81364495e-02f, -4.80945185e-02f, -1.24134593e-01f, 3.58272865e-02f, 1.51344221e-02f, -5.66257462e-02f, 2.34948900e-02f,
  -1.20289095e-01f, -4.90382910e-02f, -7.32803121e-02f, -2.53438000e-02f, -4.85962676e-03f, -7.51561075e-02f, 3.18193920e-02f, -8.93059373e-02f, 1.12845905e-01f, -8.23295116e-02f,
  8.23841393e-02f, 4.74330001e-02f, 9.66738984e-02f, -6.85175434e-02f, -4.85128090e-02f, 4.88752387e-02f, -5.70731536e-02f, 6.38601333e-02f, -3.42269130e-02f, -3.67001928e-02f,
  4.30086665e-02f, -1.75126605e-02f, -3.58293625e-03f, -3.70097347e-02f, -8.58367458e-02f, -8.00008029e-02f, 3.02319024e-02f, -9.24089551e-02f, 1.56959146e-02f, -8.92873257e-02f,
  -9.11379009e-02f, 5.47185875e-02f, -8.16545635e-02f, -4.81699929e-02f, 2.25366573e-04f, -5.24509093e-03f, -2.73570810e-02f, 8.72539356e-02f, -7.95261934e-02f, -1.02970786e-01f,
  3.44719030e-02f, -1.14021711e-02f, -3.01873423e-02f, -5.83360717e-02f, 3.34784818e-05f, -1.38452902e-01f, -1.16431072e-01f, -1.46583721e-01f, 3.73270288e-02f, 4.80228446e-05f,
  -5.01440689e-02f, -9.29727554e-02f, 8.16229440e-04f, -4.47841249e-02f, 5.18343449e-02f, 1.12709455e-01f, -4.75985892e-02f, 5.46250902e-02f, 4.82607521e-02f, 1.02498417e-03f,
  7.10326359e-02f, 8.33770186e-02f, 9.07078106e-03f, 1.31242517e-02f, -3.70028913e-02f, -2.21488699e-02f, -3.48073840e-02f, -6.17572144e-02f, -1.34017458e-02f, -1.98860690e-02f,
  7.30029419e-02f, -1.85349919e-02f, 1.02891222e-01f, -2.86817998e-02f, 3.07115689e-02f, -4.23431285e-02f, 5.89626282e-02f, 7.78112710e-02f, -1.84711851e-02f, -5.68402058e-04f,
  1.20326370e-01f, 1.39365852e-01f, 1.00753687e-01f, 1.57262921e-01f, 5.75663298e-02f, -4.22068406e-03f, 8.78735706e-02f, 1.53038904e-01f, 1.50868282e-01f, 3.16524990e-02f,
  4.51264940e-02f, 3.23208980e-03f, 9.64228958e-02f, -5.51196784e-02f, 5.45818098e-02f, -5.49612923e-05f, 1.08239101e-02f, -3.15045901e-02f, -5.04372828e-02f, 2.92174853e-02f,
  6.45596907e-02f, 8.69257823e-02f, -1.22204851e-02f, -4.04301323e-02f, 1.04010455e-01f, 9.96332392e-02f, 5.70833124e-02f, 7.39261284e-02f, 8.55434760e-02f, 3.69188078e-02f,
  4.71794531e-02f, -5.16620539e-02f, -3.72975171e-02f, -5.43106832e-02f, 1.09237760e-01f, 9.36838761e-02f, 5.20827435e-02f, 2.43944097e-02f, 6.67469874e-02f, 4.76685055e-02f,
  2.58541964e-02f, -3.15767266e-02f, -2.49632839e-02f, -3.84844057e-02f, 9.22146589e-02f, -1.53402630e-02f, 9.36642662e-02f, -3.26164551e-02f, -6.82989601e-03f, -6.00747997e-03f,
  7.76266977e-02f, 2.55024787e-02f, -4.12815325e-02f, 7.59149566e-02f, -8.81736130e-02f, 2.18953881e-02f, 1.56892538e-02f, -2.29111109e-02f, -4.20321450e-02f, 6.91396892e-02f,
  1.14122361e-01f, 3.32421027e-02f, -6.99358955e-02f, 3.10812658e-03f, 1.20690688e-01f, 5.64618446e-02f, 5.52475080e-03f, 7.73167759e-02f, 4.00817133e-02f, -8.97631049e-02f,
  -1.91731393e-01f, -1.52240574e-01f, 2.64107645e-01f, -1.25836477e-01f, 1.02162190e-01f, 1.63393766e-01f, 1.63707107e-01f, -1.02817506e-01f, -5.30925393e-02f, -9.32619497e-02f,
  -9.70474705e-02f, -5.79267787e-03f, -1.04925379e-01f, 4.16802354e-02f, 9.22853593e-03f, 1.07865006e-01f, 2.03314591e-02f, 5.89894988e-02f, 6.38419911e-02f, 8.80342722e-02f,
  -7.52954260e-02f, -6.36690930e-02f, -1.73091833e-02f, -5.41069955e-02f, 3.77970971e-02f, 1.84247103e-02f, -1.48264691e-02f, 4.65033539e-02f, -3.08507998e-02f, 2.44709048e-02f,
  2.40584821e-01f, -2.66568121e-02f, 1.39550731e-01f, -9.90767330e-02f, 5.78374751e-02f, -4.07586619e-02f, -5.45263663e-02f, -2.91367178e-03f, -6.74104914e-02f, -5.18341325e-02f,
  -9.05478373e-02f, -8.42510313e-02f, 1.05985049e-02f, -1.12895995e-01f, -7.99577311e-02f, 6.21040128e-02f, -6.50183782e-02f, -2.44240891e-02f, -1.61796212e-02f, -2.08979864e-02f,
  -5.69385923e-02f, -8.55911970e-02f, 8.00460875e-02f, 1.27157658e-01f, -1.03635399e-03f, 7.37253577e-02f, 2.21817512e-02f, 6.94534779e-02f, 6.79768017e-03f, 1.48491180e-02f,
  5.81043027e-02f, -3.42974477e-02f, 6.79731295e-02f, 4.04287688e-03f, -6.95509017e-02f, 8.70817378e-02f, 5.75826131e-02f, 3.53704877e-02f, -1.87375173e-02f, 1.50780920e-02f,
  7.97923305e-04f, 8.59037340e-02f, 4.42840420e-02f, 4.14656959e-02f, 6.91493675e-02f, -9.97662917e-02f, 9.90426354e-03f, -4.86215055e-02f, -1.24629783e-02f, -5.93656115e-02f,
  3.52890119e-02f, -3.84241007e-02f, -4.20056731e-02f, 3.39520313e-02f, -8.85825157e-02f, -5.39935715e-02f, 5.57153970e-02f, -4.02501132e-03f, 2.85559837e-02f, -7.98074082e-02f,
  7.65349641e-02f, 2.57716030e-02f, 1.22200303e-01f, 6.73675463e-02f, 4.14007939e-02f, -9.25959423e-02f, -2.78309062e-02f, -2.80459411e-02f, -5.06748483e-02f, 6.89054206e-02f,
  2.10366976e-02f, 7.99024701e-02f, -6.55888841e-02f, 8.34189728e-02f, 1.67221501e-01f, -2.94355284e-02f, -1.27603725e-01f, -2.31960174e-02f, 2.06943713e-02f, 9.63069405e-03f,
  -8.89662281e-02f, 5.88448308e-02f, 1.49900168e-01f, 1.48399800e-01f, -4.19143811e-02f, 1.17417790e-01f, 1.04498066e-01f, 3.47963832e-02f, 2.14221731e-01f, 2.19020136e-02f,
  3.09856713e-01f, -2.88558245e-01f, -7.32788071e-02f, 4.57099006e-02f, 1.27991065e-01f, 4.61231321e-02f, -9.83116031e-02f, 4.50429413e-03f, 1.01819083e-01f, -5.48224151e-02f,
  2.27145702e-02f, 6.40129969e-02f, -7.30833262e-02f, -5.24041392e-02f, 1.16528332e-01f, -5.13299853e-02f, -6.92280307e-02f, 9.14654806e-02f, 1.88070744e-01f, 1.22087061e-01f,
  3.42177856e-03f, -3.36000659e-02f, 1.08587503e-01f, -5.50341569e-02f, -1.73562542e-01f, -2.72229481e-02f, -1.53108947e-02f, -1.19301155e-01f, -7.53209144e-02f, -2.36561611e-01f,
  -8.22100043e-02f, -3.18337588e-05f, 3.51417325e-02f, 3.62610519e-02f, -1.11332610e-01f, -1.55656291e-02f, 7.42803290e-02f, 1.10715255e-02f, 4.89023104e-02f, -1.60797946e-02f,
  -5.87498806e-02f, 9.34406649e-03f, 1.91101935e-02f, -4.10716459e-02f, 4.02152613e-02f, 2.15160213e-02f, -3.19225267e-02f, 4.96294871e-02f, 5.16618267e-02f, -4.88762669e-02f,
  -2.05182806e-01f, 1.51530737e-02f, 1.40736904e-02f, -2.88336584e-03f, 3.26748304e-02f, 1.12517715e-01f, 2.92816795e-02f, -1.33373104e-02f, 1.07379317e-01f, 1.63102411e-02f,
  -8.06236058e-04f, 9.61695239e-03f, 4.02994975e-02f, -5.08031882e-02f, -7.19164684e-03f, 5.35658114e-02f, 1.34077892e-02f, 2.79303491e-02f, -6.20965660e-02f, 1.95093583e-02f,
  -1.53431538e-02f, 8.40073600e-02f, -3.28081362e-02f, -4.86753918e-02f, 5.40630743e-02f, -1.76641643e-02f, 5.04266322e-02f, -1.18666783e-01f, -9.20956284e-02f, 3.92238945e-02f,
  -2.78760679e-02f, -3.44187431e-02f, -3.52980234e-02f, -2.78692809e-03f, 3.23380269e-02f, -5.33318222e-02f, 1.64696407e-02f, -1.04502976e-01f, -3.95452566e-02f, 6.40079975e-02f,
  -3.79392616e-02f, 8.09351504e-02f, -3.42366844e-02f, -3.23027559e-02f, -1.41702965e-02f, -2.58476771e-02f, -2.18853224e-02f, -2.99002137e-03f, -5.33379428e-03f, -7.46074766e-02f,
  8.59368220e-03f, -4.72775623e-02f, -3.03805042e-02f, -7.93632343e-02f, 7.85524398e-02f, 6.60148859e-02f, -6.10097311e-03f, 3.12921107e-02f, -6.54863417e-02f, -5.91023676e-02f,
  -4.92054522e-02f, 1.13775104e-01f, 1.88349023e-01f, 2.26981137e-02f, 7.56767541e-02f, 8.96536782e-02f, 1.00796342e-01f, -3.57495397e-02f, 2.54419953e-01f, 4.27096859e-02f,
  6.53292686e-02f, -1.32124960e-01f, -1.78363428e-01f, 2.40166076e-02f, 3.58207077e-02f, 5.36990166e-02f, 8.59442130e-02f, -1.52777564e-02f, -1.87453013e-02f, -1.25069708e-01f,
  -8.08467343e-02f, 1.01373076e-01f, -2.42229830e-02f, -4.45140041e-02f, -1.59621239e-02f, 4.63733561e-02f, -4.88064997e-03f, -9.66022760e-02f, -9.26495157e-03f, 4.64944392e-02f,
  6.43840060e-02f, -1.07459456e-01f, 9.33765492e-04f, 3.41560803e-02f, -1.64164335e-01f, -8.62395763e-02f, -1.37794375e-01f, -6.95096329e-02f, -1.09570891e-01f, -9.56241339e-02f,
  -4.53800574e-04f, -1.42591879e-01f, 9.41165835e-02f, 8.92080143e-02f, -5.77501627e-03f, 1.60126630e-02f, 3.59101291e-03f, 1.11666846e-03f, 7.16123283e-02f, -9.34775770e-02f,
  4.49153706e-02f, -5.13319299e-02f, 5.67120174e-03f, -9.65931639e-02f, -1.81946531e-02f, -4.34974208e-02f, 6.24651313e-02f, 6.16624281e-02f, 2.77317520e-02f, -1.19659463e-02f,
  -8.62625986e-02f, 2.69498210e-02f, 6.43062266e-03f, 5.09098470e-02f, 7.52667338e-02f, 4.44345810e-02f, -1.09021991e-01f, 2.91591743e-03f, 9.26532969e-03f, 9.38847959e-02f,
  -7.00221732e-02f, 1.23542445e-02f, 2.61761667e-03f, 1.41733335e-02f, -3.44618130e-03f, -1.28332758e-02f, 9.52687562e-02f, 1.10850811e-01f, 5.89358844e-02f, -9.99593511e-02f,
  -4.11244407e-02f, -8.23689103e-02f, -3.04709524e-02f, 5.25961854e-02f, 1.56195285e-02f, 2.72266362e-02f, -4.34871688e-02f, 1.85449105e-02f, -6.95179328e-02f, -9.29825827e-02f,
  1.23295067e-02f, -7.69714862e-02f, 2.97153350e-02f, -3.40959616e-02f, -1.06059901e-01f, 5.66222444e-02f, 2.97152363e-02f, -7.60250539e-02f, 5.52437156e-02f, 1.79304592e-02f,
  5.51182814e-02f, -4.59888652e-02f, -8.46292675e-02f, 2.42713243e-02f, -3.97698171e-02f, -2.24723164e-02f, 4.30672206e-02f, 6.47274107e-02f, 1.52906738e-02f, 2.58985683e-02f,
  -3.22850496e-02f, 7.60382861e-02f, -3.29337306e-02f, -4.63488288e-02f, -3.87497358e-02f, 5.53776603e-03f, 1.01472009e-02f, 1.41658681e-02f, -7.87872747e-02f, -7.97382966e-02f,
  1.36211766e-02f, 5.99489920e-02f, 4.63623032e-02f, 7.37985969e-02f, 1.11729845e-01f, 5.13818190e-02f, 2.32680365e-02f, 2.51391251e-03f, 5.23560420e-02f, 1.50170341e-01f,
  -1.81915220e-02f, -4.93155941e-02f, -7.63332769e-02f, -1.42827347e-01f, -1.60586182e-02f, -1.29134236e-02f, 1.56361389e-03f, 4.21806946e-02f, 7.60328770e-02f, -4.15441580e-02f,
  7.59895220e-02f, -1.11542596e-02f, -2.52442956e-02f, -2.79679173e-03f, -3.57051529e-02f, -1.01558745e-01f, -1.73561707e-01f, -1.28674299e-01f, 6.58486933e-02f, -5.74448407e-02f,
  -3.74558941e-02f, -3.13533843e-02f, -8.26867670e-02f, -4.93709147e-02f, -1.19861908e-01f, -1.95454843e-02f, -1.23411864e-02f, -1.89818367e-02f, -3.21102254e-02f, -1.05587974e-01f,
  -1.72460172e-02f, 1.85931642e-02f, 5.41954525e-02f, -6.22683838e-02f, -9.36191157e-02f, 9.10219848e-02f, 3.63340117e-02f, -5.52384928e-02f, 7.32827336e-02f, 3.12465690e-02f,
  -4.23900671e-02f, -7.34144524e-02f, -6.67437613e-02f, -2.57778559e-02f, -5.71787916e-02f, 3.23497527e-03f, -3.68197300e-02f, -4.73814569e-02f, 6.29952624e-02f, -4.23674239e-03f,
  6.99066967e-02f, -4.42819111e-02f, -1.40959918e-02f, 4.77014780e-02f, -2.72518266e-02f, 5.97351864e-02f, 2.21473947e-02f, 5.99684380e-02f, -7.78540373e-02f, 2.10395716e-02f,
  2.07243506e-02f, 8.08775574e-02f, -3.47964210e-03f, -6.90413080e-03f, 3.11262198e-02f, -2.21110117e-02f, -2.80268546e-02f, 7.47199282e-02f, 6.34363294e-02f, -4.71690157e-03f,
  1.07698031e-02f, -3.58429886e-02f, 9.27599892e-02f, -4.04912680e-02f, -1.30229676e-03f, 4.95276134e-03f, 6.84498474e-02f, -2.70576607e-02f, -3.25803757e-02f, 4.02203500e-02f,
  -2.21872982e-02f, 2.20501572e-02f, 3.52436192e-02f, -1.33037930e-02f, -3.30798030e-02f, 4.94050980e-03f, 3.13059799e-02f, 7.87618682e-02f, 8.14756565e-03f, -5.26466146e-02f,
  8.32044147e-03f, 1.18514784e-02f, 6.69332640e-03f, -4.67881262e-02f, -8.41421336e-02f, -6.63415715e-02f, 2.67560706e-02f, -4.90110479e-02f, -9.50805917e-02f, 4.35385294e-02f,
  5.77612855e-02f, 5.26143461e-02f, 6.66319765e-03f, 7.37314746e-02f, -6.16663955e-02f, 4.45793308e-02f, -5.49679846e-02f, -3.75460051e-02f, -9.15403366e-02f, 6.70655742e-02f,
  3.80174778e-02f, 3.11640352e-02f, -2.00390518e-02f, 8.43650922e-02f, -4.35101278e-02f, -2.93754376e-02f, 7.06023648e-02f, 6.35119528e-02f, 3.77965644e-02f, 1.05205655e-01f,
  -3.00420195e-01f, -1.05147943e-01f, -5.21603450e-02f, 9.75670591e-02f, 4.95548435e-02f, 1.33128673e-01f, 1.80416718e-01f, 1.40792385e-01f, 8.52602124e-02f, 2.67029982e-02f,
  5.04567698e-02f, 1.19801834e-01f, 1.36704221e-01f, 5.70550561e-02f, 1.14849612e-01f, 7.58813471e-02f, 1.82436585e-01f, -2.21868008e-02f, 2.48516239e-02f, 1.26729533e-01f,
  8.84784460e-02f, -7.81026334e-02f, -4.76424359e-02f, 8.30793977e-02f, 4.06069122e-02f, 1.05530567e-01f, 9.40457545e-03f, -5.67028783e-02f, 6.26686662e-02f, 4.80009383e-03f,
  -8.44349414e-02f, -2.25652263e-01f, 9.71392989e-02f, -2.00478677e-02f, -1.52074425e-02f, -7.38409683e-02f, -6.30418137e-02f, -4.48956303e-02f, -9.17759016e-02f, 4.34623882e-02f,
  -9.92892869e-03f, -4.80684340e-02f, 1.82360262e-02f, 5.79243861e-02f, 1.67101044e-02f, -5.87027743e-02f, -1.09637961e-01f, -1.12346940e-01f, 5.19729368e-02f, -7.26953000e-02f,
  1.23857573e-01f, -1.05316922e-01f, 2.50950772e-02f, 4.54273224e-02f, 1.67158861e-02f, 1.45665640e-02f, -1.14093889e-02f, -6.84150383e-02f, -2.45464910e-02f, -2.47329623e-02f,
  -3.90304998e-03f, 1.96565278e-02f, -1.19708590e-02f, -3.56096029e-02f, -7.64757255e-03f, 2.01412733e-03f, 8.39751493e-03f, 4.87110354e-02f, 4.71518114e-02f, -8.94975737e-02f,
  -1.21621583e-02f, 2.91670337e-02f, 1.00276479e-02f, -7.94007778e-02f, 1.07225291e-01f, -1.38425659e-02f, 3.85766476e-02f, 6.35969490e-02f, -4.62961830e-02f, 6.79728342e-03f,
  -7.28226081e-02f, 5.41289635e-02f, -1.19596295e-01f, 8.89711156e-02f, 5.25693297e-02f, -5.99170811e-02f, -3.97003926e-02f, 3.61596793e-02f, 8.84797610e-03f, -6.32870123e-02f,
  8.13177526e-02f, 3.40145864e-02f, 2.97407694e-02f, 2.09456030e-02f, -7.75392130e-02f, 3.98866907e-02f, 1.92430969e-02f, 4.67942003e-03f, 2.79218759e-02f, 4.43052016e-02f,
  -8.20402205e-02f, -7.26590827e-02f, -1.27578482e-01f, 1.91113297e-02f, -6.69130757e-02f, -3.07839569e-02f, -5.27540445e-02f, 3.70544158e-02f, 6.51669949e-02f, 3.80506143e-02f,
  5.21834008e-02f, -7.53259286e-02f, -6.18262663e-02f, 6.19675666e-02f, 8.21571872e-02f, 9.28002000e-02f, -7.81487152e-02f, 1.07027240e-01f, -1.89325009e-02f, 1.81600191e-02f,
  4.02937718e-02f, 9.42826346e-02f, -1.11517429e-01f, 2.50133835e-02f, 5.82465939e-02f, 6.73577189e-02f, -1.52602149e-02f, 8.22477490e-02f, 1.12965830e-01f, -2.04092655e-02f,
  -8.53032060e-03f, -1.11246392e-01f, 3.99774164e-02f, -1.67764525e-03f, -2.69252192e-02f, 2.44313534e-02f, 2.85146348e-02f, 1.32209174e-02f, -1.05586834e-01f, -1.36394184e-02f,
  6.44678995e-02f, 1.23848356e-01f, -1.51939970e-02f, 6.05696775e-02f, 7.21228542e-03f, -2.71993806e-03f, -6.93906620e-02f, -9.21360180e-02f, -8.32566991e-02f, 1.43681131e-02f,
  -9.56427082e-02f, -1.22161917e-01f, -3.79098803e-02f, -1.33297620e-02f, -8.77252296e-02f, 7.44148195e-02f, 3.61493342e-02f, -1.91877671e-02f, 6.05110191e-02f, -2.56305560e-02f,
  -2.33386010e-02f, -1.90728232e-02f, 1.00255482e-01f, 7.48837590e-02f, 8.95874053e-02f, 7.45096281e-02f, 5.20950556e-03f, -8.96392912e-02f, -2.95633618e-02f, -8.49402025e-02f,
  -7.27318302e-02f, 2.39450857e-02f, -8.47420283e-03f, -3.54767442e-02f, 3.67482975e-02f, -1.77308209e-02f, -2.83487011e-02f, -8.94665776e-04f, -1.22347496e-01f, 1.37878239e-01f,
  -3.96753177e-02f, -6.15930967e-02f, -1.19216986e-01f, 1.33417761e-02f, -3.83608192e-02f, -2.16787774e-02f, 3.69270220e-02f, 4.44577262e-02f, 6.33503199e-02f, 4.02629115e-02f,
  -2.72675436e-02f, 7.63716772e-02f, 6.25339895e-02f, 6.66804016e-02f, -7.23341331e-02f, -5.45770861e-03f, 1.02586813e-01f, 1.03396930e-01f, 1.29547147e-02f, -2.35449262e-02f,
  2.87952833e-02f, 7.33261034e-02f, 3.42828408e-02f, 3.99351679e-02f, -1.21145453e-02f, -5.50594144e-02f, 7.52357170e-02f, -8.57389271e-02f, -3.56918685e-02f, -2.29873229e-02f,
  1.15424216e-01f, -1.09596610e-01f, 6.84673665e-03f, 6.00946927e-03f, 1.06963264e-02f, 7.26193339e-02f, -9.75566581e-02f, -5.54218888e-03f, -2.51893513e-02f, 7.38536641e-02f,
  -4.66133915e-02f, -3.98145579e-02f, 3.59103852e-03f, 1.01826921e-01f, -1.10437144e-02f, 3.08543015e-02f, 1.56657293e-01f, -1.33992285e-02f, -2.96756458e-02f, -4.20656279e-02f,
  1.45950541e-02f, 6.33107424e-02f, 1.13361925e-01f, 1.06826439e-01f, 4.74493159e-03f, -2.47837119e-02f, 7.42217824e-02f, 3.92082259e-02f, 7.88316056e-02f, 2.61433780e-01f,
  -5.56036308e-02f, 1.45877570e-01f, -5.63192926e-03f, -5.25762551e-02f, -1.24621190e-01f, -2.02956609e-03f, -4.09171358e-02f, 4.75878567e-02f, -4.53181602e-02f, 1.28607437e-01f,
  -3.03837899e-02f, -1.24361619e-01f, 8.07040185e-03f, -1.46378025e-01f, -1.72626972e-01f, 6.92063384e-03f, 6.44684806e-02f, -1.76235870e-01f, -1.46566734e-01f, -2.55610466e-01f,
  -1.06192026e-02f, -1.44552112e-01f, -1.90380320e-01f, -1.94251277e-02f, -4.46491167e-02f, -1.24147885e-01f, -1.78345013e-02f, -1.06823027e-01f, -9.96811613e-02f, 7.58031532e-02f,
  2.06676926e-02f, -2.72067413e-02f, -5.07623032e-02f, -1.27027854e-01f, 1.55485757e-02f, -7.08508343e-02f, 7.68369213e-02f, -4.28219549e-02f, -6.38204142e-02f, 6.06184565e-02f,
  -4.31560874e-02f, -7.57828802e-02f, -5.72354384e-02f, -1.43542737e-02f, -7.14745149e-02f, -1.43367812e-01f, -4.02737930e-02f, -4.59279977e-02f, 1.38849616e-02f, -1.55747598e-02f,
  -3.45745347e-02f, -1.16000541e-01f, -7.49258790e-03f, -2.41580810e-02f, -5.81094772e-02f, -1.13447919e-01f, -9.95936245e-03f, -1.54414251e-01f, -8.09968710e-02f, 9.60674062e-02f,
  6.71864375e-02f, 1.03409879e-01f, 4.05037701e-02f, -1.83301177e-02f, 6.81323186e-02f, 7.64178410e-02f, -4.18935940e-02f, 2.08729822e-02f, -4.67356145e-02f, 1.70290880e-02f,
  -4.28190641e-02f, 7.70901665e-02f, 8.09332728e-02f, 8.04696158e-02f, 5.32395355e-02f, -4.60020117e-02f, -4.89060469e-02f, 9.44611952e-02f, 6.73118532e-02f, 1.83757599e-02f,
  -7.05076009e-02f, -8.96898508e-02f, -1.68747436e-02f, -4.60034562e-03f, 5.38624451e-02f, 5.63924126e-02f, -7.19676018e-02f, -1.02443737e-03f, 4.93652336e-02f, 2.16448354e-03f,
  2.00816080e-01f, -1.39525056e-01f, 2.91069783e-02f, -8.89174342e-02f, -1.41097950e-02f, -9.35707316e-02f, 8.36913213e-02f, -4.15068306e-02f, 1.00875907e-02f, -1.88141351e-03f,
  -1.43299829e-02f, 6.44174963e-02f, -3.76046300e-02f, 5.30906059e-02f, -9.25207064e-02f, -7.04293847e-02f, 5.70893213e-02f, -2.07066294e-02f, -1.10233940e-01f, 9.12608728e-02f,
  2.54406407e-02f, 6.55401573e-02f, 3.39240171e-02f, 2.19770856e-02f, 2.55835131e-02f, -8.07246864e-02f, 4.24605906e-02f, 7.51418471e-02f, -6.69726729e-02f, 2.24384904e-01f,
  2.00304464e-01f, 2.48304475e-02f, 1.01326294e-01f, 5.96041381e-02f, 3.55712585e-02f, 3.75019126e-02f, 2.05197297e-02f, 1.74000617e-02f, 6.41736090e-02f, 4.85773981e-02f,
  1.06356561e-01f, -1.08321145e-01f, -6.28969446e-02f, -1.10544831e-01f, -1.25706628e-01f, 2.61832792e-02f, 4.84313369e-02f, -1.16440669e-01f, -1.04782023e-01f, -5.96698225e-02f,
  4.91045788e-02f, 8.88400748e-02f, -6.63272440e-02f, 2.50782389e-02f, -1.94761658e-03f, -8.71868506e-02f, 1.46780126e-02f, -4.66430373e-03f, 2.31345110e-02f, 7.59608112e-03f,
  -3.82134784e-03f, 1.59192383e-01f, -7.46063842e-03f, -1.46706313e-01f, 7.50565678e-02f, -7.66941905e-02f, 6.08909409e-03f, -7.41872117e-02f, 3.00264433e-02f, 7.09454790e-02f,
  -1.57172959e-02f, 2.75352132e-02f, 7.22272769e-02f, -6.44672215e-02f, 4.68060784e-02f, -1.64551567e-02f, -9.60294157e-02f, -4.78190482e-02f, -6.97529092e-02f, -3.52061377e-03f,
  2.43589748e-02f, 9.15511623e-02f, 9.02037919e-02f, 3.24885249e-02f, 5.51433861e-02f, -8.80581662e-02f, -2.24711802e-02f, 2.46187299e-02f, -5.41422851e-02f, 6.48583770e-02f,
  -5.58338836e-02f, 1.59534463e-03f, -6.41681850e-02f, 6.02546297e-02f, 5.62486686e-02f, 7.56015182e-02f, -4.83487174e-02f, -5.28323576e-02f, -5.51902167e-02f, 7.75550976e-02f,
  1.45918392e-02f, 8.14825147e-02f, 9.49117988e-02f, 8.22517499e-02f, -6.78768232e-02f, 1.08546153e-01f, 5.67045324e-02f, 6.52042264e-03f, -2.25565936e-02f, 5.66896535e-02f,
  -3.93210072e-03f, -3.90016511e-02f, -3.30434577e-03f, -4.99916375e-02f, 9.72800404e-02f, 4.35043462e-02f, -3.21901962e-02f, 1.17881030e-01f, 6.47077858e-02f, 9.52280909e-02f,
  -1.81117896e-02f, 9.99380648e-02f, 5.45297936e-02f, -7.66362622e-02f, 1.01553805e-01f, -1.24282409e-02f, -5.39931171e-02f, -9.57611278e-02f, -5.65678738e-02f, 2.76361052e-02f,
  -8.37485939e-02f, 4.27816175e-02f, -2.66261119e-02f, 7.58521333e-02f, 3.73751693e-03f, -2.78024040e-02f, 5.41451313e-02f, -1.08668744e-03f, -1.09582618e-01f, -5.10660671e-02f,
  -3.44934873e-02f, 9.03911889e-02f, 1.07149616e-01f, -2.91703525e-03f, 4.01726849e-02f, -6.32248528e-04f, 1.24365725e-02f, 6.98372349e-02f, -6.39395118e-02f, 1.05178274e-01f,
  9.26414058e-02f, -2.18659058e-01f, 6.69703707e-02f, 2.71836333e-02f, -1.54872416e-02f, 5.19467257e-02f, -1.03259839e-01f, -2.95927618e-02f, -6.06293604e-02f, 3.94461192e-02f,
  -2.63384631e-04f, 1.67818278e-01f, 6.55840710e-02f, 8.60346779e-02f, 1.36799872e-01f, -6.04327582e-02f, 8.83844942e-02f, 1.45575151e-01f, 1.70135096e-01f, 1.12600446e-01f,
  4.13342454e-02f, 7.15198293e-02f, 9.35725793e-02f, 4.90177795e-02f, 7.04747364e-02f, 1.16794541e-01f, -3.43617126e-02f, 2.95344796e-02f, 7.39268437e-02f, -4.93803574e-03f,
  1.72977656e-01f, -1.41081557e-01f, 1.37429595e-01f, 7.90969655e-02f, 1.71953696e-03f, 1.90685429e-02f, 6.35867715e-02f, -9.09934053e-04f, -1.00309521e-01f, 4.87069152e-02f,
  -9.43940654e-02f, -6.10213690e-02f, -7.04411790e-02f, -1.04468390e-01f, -3.64402086e-02f, -4.69994023e-02f, 1.40540721e-02f, 3.06467675e-02f, 7.74659635e-03f, -8.01283121e-02f,
  -8.12548306e-03f, -8.53415504e-02f, 2.81165689e-02f, -3.13223675e-02f, 3.37852985e-02f, -3.45618650e-02f, 1.02943117e-02f, 8.30793194e-03f, -5.54240011e-02f, -2.12844331e-02f,
  9.08902586e-02f, 7.91273173e-03f, -5.72324656e-02f, 3.27907763e-02f, -4.42109518e-02f, 1.05317727e-01f, -6.73533091e-03f, -1.46197900e-02f, -4.94703418e-03f, -6.60107210e-02f,
  8.14251751e-02f, 6.89579695e-02f, 8.41436535e-02f, -3.40816081e-02f, 1.03384070e-01f, -6.34871125e-02f, -7.10427910e-02f, 4.26649228e-02f, -2.13850401e-02f, 1.95339229e-02f,
  -1.45672411e-02f, -2.38978900e-02f, -7.86849558e-02f, 1.00794628e-01f, -2.90184189e-02f, 1.05496421e-01f, 3.31364088e-02f, 1.71332806e-02f, 4.75442298e-02f, 9.35980293e-04f,
  6.01452179e-02f, -1.41015900e-02f, 7.66971186e-02f, -7.11020380e-02f, -7.01367408e-02f, -5.71465679e-02f, -7.87043199e-02f, -2.90387515e-02f, 9.49142780e-03f, 3.97623703e-02f,
  6.34401059e-03f, 4.89775427e-02f, 4.89222892e-02f, -7.01263696e-02f, 3.40389572e-02f, -4.46319729e-02f, -1.29152805e-01f, 9.98807847e-02f, -7.08919615e-02f, -8.27632993e-02f,
  -1.55122755e-02f, -4.35953625e-02f, -1.22766942e-02f, -7.32497661e-04f, -2.52238344e-02f, -7.63454055e-03f, 8.75459053e-03f, -7.16644749e-02f, 2.51593050e-02f, 4.45207395e-02f,
  -8.21239352e-02f, 1.72307059e-01f, 7.67337084e-02f, -1.59032196e-02f, 9.32547376e-02f, 1.00569181e-01f, 1.30506411e-01f, 5.75715601e-02f, 1.01773083e-04f, 1.02652296e-01f,
  -6.48511294e-03f, -5.66001758e-02f, -9.34173726e-03f, -1.16894871e-01f, 5.86489104e-02f, 2.64335796e-02f, -1.29607711e-02f, -1.40685420e-02f, -1.24899432e-01f, -4.79832515e-02f,
  -2.33215466e-03f, -8.80193263e-02f, -1.41668350e-01f, -2.06804322e-03f, -6.21809736e-02f, 7.92487711e-03f, -1.22394096e-02f, 6.54696196e-04f, 8.26301426e-02f, 6.12921268e-02f,
  9.97019187e-03f, -9.13585722e-02f, -1.06333904e-01f, -1.89069286e-02f, -3.00292764e-02f, 3.99535894e-03f, -1.61407925e-02f, -7.40603358e-02f, 1.85100473e-02f, 6.63058273e-03f,
  -6.68864623e-02f, -2.29403842e-02f, 3.49962735e-03f, -1.43794129e-02f, -1.21109836e-01f, -5.29601090e-02f, 5.65539822e-02f, 2.07729099e-04f, -3.30267847e-02f, 4.02533486e-02f,
  -8.20106547e-03f, -4.70971167e-02f, -4.15995009e-02f, 9.64550581e-03f, -1.38613703e-02f, -9.80003327e-02f, -4.23415676e-02f, -1.48632780e-01f, -7.21301325e-03f, -3.94498482e-02f,
  -6.04708008e-02f, 9.51775163e-03f, -1.90647189e-02f, -7.82796592e-02f, -4.15068567e-02f, 5.26913516e-02f, 1.14897741e-02f, -6.07367046e-02f, -2.46194582e-02f, 1.69337951e-02f,
  -2.16375701e-02f, 4.90137972e-02f, -9.04676542e-02f, 8.67719110e-03f, 6.52629212e-02f, 2.73223221e-02f, -3.67760248e-02f, 9.09066796e-02f, 2.29486804e-02f, 1.79306008e-02f,
  6.83749616e-02f, 3.31446086e-03f, -8.40276629e-02f, 1.97361205e-02f, -2.89218388e-02f, -5.95008731e-02f, -1.66743100e-02f, -2.40917932e-02f, 1.17851133e-02f, -4.60764244e-02f,
  -3.96010727e-02f, -6.92226784e-03f, -4.14478742e-02f, -2.45810468e-02f, 5.66707253e-02f, -2.25979928e-02f, 4.14968804e-02f, 6.95839524e-02f, 1.48295173e-02f, -4.18033525e-02f,
  -9.74349603e-02f, -1.00994132e-01f, -6.68633357e-02f, 8.55783839e-03f, -1.02851070e-01f, 1.11920731e-02f, 4.03110199e-02f, -8.77580419e-03f, -3.25956196e-02f, -5.99427372e-02f,
  -1.75218645e-03f, -5.28426170e-02f, -1.35525942e-01f, 4.16825078e-02f, -1.35782631e-02f, -1.18569732e-01f, -1.07750028e-01f, -4.70547378e-03f, -1.61994651e-01f, -7.02916533e-02f,
  8.61973688e-02f, 1.34453788e-01f, -6.30638823e-02f, 5.98340258e-02f, -2.03807000e-02f, 2.63972450e-02f, 9.16402638e-02f, 7.29504228e-02f, 1.86771899e-02f, 4.26589251e-02f,
  9.93116572e-02f, -3.05888671e-02f, -1.13140330e-01f, -1.29150301e-01f, -4.98513579e-02f, -8.48265439e-02f, -5.23577398e-03f, -2.99487263e-02f, -1.04523733e-01f, -1.89094376e-02f,
  5.45911156e-02f, 1.64104942e-02f, 8.33294243e-02f, 2.42110286e-02f, -4.80372570e-02f, -5.42094372e-02f, 7.14476332e-02f, 6.26105964e-02f, -3.08175199e-03f, 1.21920437e-01f,
  -5.17433695e-02f, 4.10861149e-02f, -1.31274208e-01f, 4.65520471e-02f, 1.13137253e-01f, -6.08970262e-02f, 9.58643705e-02f, 6.52903095e-02f, 1.26140341e-01f, -1.46186510e-02f,
  1.23120479e-01f, 6.22914173e-02f, -1.59760413e-03f, 1.72948483e-02f, 1.21727280e-01f, 7.17926845e-02f, 6.18147738e-02f, 8.71998519e-02f, -5.88438101e-02f, 8.81413221e-02f,
  1.00828424e-01f, 3.89537923e-02f, 5.83590083e-02f, 2.77524777e-02f, 7.89399222e-02f, 4.14222665e-02f, -3.95371802e-02f, 2.28544883e-02f, -1.52433049e-02f, 5.69460988e-02f,
  3.81848514e-02f, 4.25000079e-02f, -1.13131357e-02f, -5.66932075e-02f, -7.21756741e-03f, 3.53806205e-02f, 5.34822382e-02f, 3.40199172e-02f, 1.86338474e-03f, 1.22957444e-02f,
  -6.08871654e-02f, 6.01821952e-02f, 5.40177710e-02f, 3.49335000e-02f, -3.68792750e-02f, 2.86728535e-02f, -3.80883552e-02f, 5.60033061e-02f, 3.96141261e-02f, -3.60415615e-02f,
  1.06424708e-02f, 3.73569764e-02f, 3.45494747e-02f, 2.98387911e-02f, 8.54324549e-02f, 6.19185790e-02f, -3.06577832e-02f, 8.20363238e-02f, 3.51237482e-03f, 9.15424377e-02f,
  -9.93629321e-02f, -9.10331979e-02f, 9.00417101e-03f, -4.05602381e-02f, 1.52146677e-05f, 3.63870040e-02f, 3.78946364e-02f, 5.30533120e-03f, 6.69599790e-03f, -1.73081912e-03f,
  -6.39239745e-03f, -9.37745161e-03f, 1.04770064e-02f, 4.49360460e-02f, 2.45636534e-02f, 1.28428983e-02f, 1.05989307e-01f, 3.33217233e-02f, -1.12694353e-01f, 1.28113749e-02f,
  -4.62387688e-02f, 3.91857652e-03f, 5.24290316e-02f, -5.48144877e-02f, -6.05248213e-02f, -5.51612265e-02f, 4.55947369e-02f, 4.37014252e-02f, -1.53661771e-02f, -4.47087809e-02f,
  1.29817843e-01f, 9.13314000e-02f, 5.32655567e-02f, 7.39519745e-02f, 7.83828273e-02f, 5.44831157e-03f, -3.24410461e-02f, 4.13077511e-02f, -7.95317292e-02f, 1.74269546e-02f,
  -9.01724026e-02f, -5.94740175e-02f, 3.62504809e-03f, 2.93250903e-02f, -4.71275672e-02f, 6.92600245e-03f, -5.17851394e-03f, -2.78495438e-03f, 5.06940819e-02f, 1.06980316e-01f,
  -5.16427532e-02f, 9.12092030e-02f, 8.96445960e-02f, -1.29090510e-02f, 4.43974888e-04f, 8.81615579e-02f, 9.89375785e-02f, -2.82597952e-02f, 7.28995400e-03f, 2.91147344e-02f,
  8.99391770e-02f, 1.38215303e-01f, 1.15899872e-02f, -2.13797744e-02f, 1.52549474e-02f, 7.57102892e-02f, -5.75052574e-02f, -1.84165407e-02f, -4.03040834e-02f, -2.98505854e-02f,
  -1.50171230e-02f, 3.87053862e-02f, 3.91629301e-02f, -9.14585590e-02f, -2.45448761e-02f, 6.34575710e-02f, 3.10677905e-02f, -3.90024483e-02f, 4.60597798e-02f, 7.39082173e-02f,
  -5.80183789e-02f, -6.12098835e-02f, 2.04019472e-02f, -8.02508965e-02f, -2.81703155e-02f, -1.23060076e-02f, 8.72332752e-02f, 6.50843838e-03f, -4.28780494e-03f, 1.59381703e-02f,
  -1.87406708e-02f, 1.98543333e-02f, -7.41447657e-02f, 6.58611506e-02f, 1.71689894e-02f, 1.47226629e-07f, 9.21541452e-02f, 2.07317397e-02f, -2.81120967e-02f, -6.92623779e-02f,
  -1.41179916e-02f, 4.40718494e-02f, -1.96880456e-02f, -3.96331660e-02f, 5.98252006e-02f, 2.43484955e-02f, 5.71030118e-02f, 8.27959329e-02f, -2.68325005e-02f, 2.15154421e-02f,
  6.14819415e-02f, 6.01802841e-02f, 3.27298678e-02f, -4.66332026e-02f, 1.28431320e-02f, 4.55874912e-02f, -5.48803471e-02f, -6.81085587e-02f, -7.29792118e-02f, -8.74497369e-03f,
  -1.11903861e-01f, 5.59980683e-02f, 4.55760546e-02f, -4.46625520e-03f, 5.72591759e-02f, 1.09630816e-01f, -5.62644824e-02f, -5.87493777e-02f, -2.48172358e-02f, 1.04725778e-01f,
  -5.85634522e-02f, 4.06358987e-02f, -6.82769567e-02f, -8.28289613e-02f, 5.82294092e-02f, 5.59283271e-02f, 4.11367230e-02f, -1.79232145e-03f, -1.97277796e-02f, 8.18747375e-03f,
  -8.70892256e-02f, -1.52712381e-02f, -2.65592877e-02f, 4.29418720e-02f, -9.29299071e-02f, 3.00051123e-02f, 5.25304638e-02f, -7.06630796e-02f, -3.15927118e-02f, 1.70618705e-02f,
  1.91565678e-01f, -2.08736569e-01f, -6.99579194e-02f, 8.36501941e-02f, 6.31064596e-03f, -5.46504706e-02f, -4.02951576e-02f, 7.46927932e-02f, 7.28026554e-02f, -2.06360556e-02f,
  -1.18535519e-01f, 6.42061681e-02f, 5.54938018e-02f, -4.98226248e-02f, 1.25026196e-01f, 3.62627357e-02f, 1.36239246e-01f, 6.13976568e-02f, 1.45419063e-02f, -4.56946455e-02f,
  1.16907293e-02f, 1.17241405e-02f, 3.97938378e-02f, 8.74552280e-02f, 4.60018367e-02f, 2.25481149e-02f, 2.03873008e-03f, -9.72096473e-02f, 3.97057310e-02f, -2.67286710e-02f,
  -1.08017325e-01f, -4.22399156e-02f, 1.16360009e-01f, -4.89999689e-02f, 3.14227603e-02f, -5.13100587e-02f, 4.90284860e-02f, 4.77966033e-02f, -8.34911913e-02f, -1.01276912e-01f,
  -8.64894614e-02f, 1.78521965e-02f, 5.86129241e-02f, 3.48193832e-02f, -1.74930040e-02f, -3.93510833e-02f, -1.04947671e-01f, 1.61830231e-03f, 7.39575773e-02f, -9.78354290e-02f,
  -6.74709901e-02f, 2.64185909e-02f, 8.79316106e-02f, 1.08206160e-02f, 6.19921088e-02f, 1.17858909e-01f, -1.09061599e-01f, -6.15744572e-03f, -3.04988697e-02f, -3.57149704e-03f,
  -1.39289442e-02f, 3.63130169e-03f, -6.13184907e-02f, 9.23135951e-02f, 9.42200720e-02f, 4.14834619e-02f, -3.31924297e-02f, -5.42421117e-02f, 8.10058340e-02f, 7.42378756e-02f,
  -5.44270277e-02f, -5.98633848e-02f, -2.59338748e-02f, -1.63105968e-02f, -7.05267042e-02f, 4.12216671e-02f, -6.09222166e-02f, -9.11340266e-02f, 6.83994452e-03f, 3.74876596e-02f,
  1.11435488e-01f, 1.03735954e-01f, 4.40376997e-02f, -8.88551995e-02f, 4.67984453e-02f, -5.65794259e-02f, 9.34315398e-02f, 5.53351303e-04f, 3.01426426e-02f, 1.07810505e-01f,
  -1.21109717e-01f, 1.71683118e-01f, 4.48696986e-02f, 5.78551926e-02f, 6.16011284e-02f, 8.85297135e-02f, -8.44097231e-03f, -8.23302120e-02f, 1.37516400e-02f, -8.77973065e-02f,
  -4.97964807e-02f, -4.68176082e-02f, 7.10290745e-02f, -5.08301631e-02f, 2.01061182e-02f, -1.46753769e-02f, -1.38438940e-02f, -3.34289894e-02f, 3.39772552e-02f, -7.71409199e-02f,
  -8.35372582e-02f, 6.80783987e-02f, 1.49114653e-01f, 9.77210626e-02f, -1.79903861e-02f, 7.29782283e-02f, 9.52685699e-02f, 5.10855168e-02f, 3.91100347e-02f, 5.59028722e-02f,
  -6.82467371e-02f, 6.91172406e-02f, -1.39813751e-01f, 6.84894845e-02f, -7.15401322e-02f, -2.12232638e-02f, -1.86280593e-01f, -1.83406416e-02f, 5.66698611e-03f, -3.75681855e-02f,
  -6.06597327e-02f, 8.86988416e-02f, 1.62928260e-03f, -1.43261030e-01f, -2.13992700e-01f, -1.89910024e-01f, -1.42595440e-01f, -8.70665014e-02f, -2.03426048e-01f, -7.42058977e-02f,
  4.94220220e-02f, -1.98506415e-02f, -1.26867965e-01f, 4.01013009e-02f, 1.46580040e-01f, -5.32381870e-02f, 5.29186465e-02f, -7.53072724e-02f, -1.16644979e-01f, 4.56004310e-03f,
  1.30248353e-01f, -8.51273984e-02f, -2.81175110e-03f, 5.50271943e-02f, 6.67749904e-03f, 8.03637318e-03f, -4.08997573e-02f, -1.09108642e-03f, -4.49918211e-02f, 2.93769930e-02f,
  9.00448188e-02f, -1.70634333e-02f, 3.35150994e-02f, 7.21789971e-02f, -1.28713846e-02f, 7.12659955e-02f, -1.01191707e-01f, -1.10170476e-01f, -2.76386850e-02f, -3.99897918e-02f,
  7.76294246e-02f, -4.50859442e-02f, 5.36044389e-02f, -9.80656445e-02f, 3.88625935e-02f, -1.33277895e-02f, 9.63696167e-02f, 3.64563242e-02f, -8.56324211e-02f, 3.94135788e-02f,
  -5.04866987e-02f, 6.02025799e-02f, 6.61736801e-02f, 8.80301744e-02f, -4.81055155e-02f, 6.27906024e-02f, -9.43998545e-02f, 4.38196845e-02f, -1.44420015e-02f, 5.15644029e-02f,
  2.27480307e-02f, 5.25933243e-02f, -1.26786232e-02f, -4.69669588e-02f, 5.87199302e-03f, -3.83191742e-02f, -9.38583314e-02f, -5.01800738e-02f, -8.37623328e-02f, 2.09626853e-02f,
  7.39605427e-02f, 1.58970654e-02f, -1.92203745e-02f, -1.09197311e-02f, -1.07957982e-01f, -4.45068479e-02f, 7.40322843e-02f, -3.89938802e-02f, -3.31241521e-03f, 2.99030207e-02f,
  1.87916934e-01f, -2.10283250e-01f, 9.16479826e-02f, 4.96212952e-02f, 1.60906240e-02f, -4.24182080e-02f, 8.90359804e-02f, -2.93628266e-03f, 1.18203633e-01f, -6.35594428e-02f,
  8.56894534e-03f, 3.63360569e-02f, 3.19080576e-02f, 2.40870919e-02f, 3.20475525e-03f, -8.38147402e-02f, 3.86536084e-02f, -9.83162224e-02f, 4.93681058e-02f, -3.34084295e-02f,
  1.00519769e-01f, -7.60631114e-02f, -4.07171883e-02f, 7.02226087e-02f, -4.54332009e-02f, -3.88649032e-02f, 2.28626188e-02f, 1.15918048e-01f, -9.41836908e-02f, 1.27353117e-01f,
  -1.91652119e-01f, 3.20687424e-03f, 7.47530758e-02f, -8.43649209e-02f, 1.45712486e-02f, 8.98338184e-02f, -6.90748021e-02f, -1.65448815e-01f, 1.03959786e-02f, 4.13073314e-04f,
  -6.34308718e-03f, -7.52643719e-02f, 5.06884754e-02f, 6.76546022e-02f, -1.71284564e-02f, 7.47966990e-02f, -2.00490933e-02f, 1.15554444e-02f, -3.02621089e-02f, -5.32639101e-02f,
  9.91785750e-02f, -1.03070773e-01f, -5.76182455e-02f, 3.70840840e-02f, 4.49422933e-02f, -3.69866639e-02f, 5.02582714e-02f, 9.95092839e-02f, 1.09531932e-01f, 1.13229163e-01f,
  7.53875747e-02f, -4.51734196e-03f, 2.40710806e-02f, -7.13755237e-03f, -1.87549647e-03f, -1.33783862e-01f, -3.85831781e-02f, 2.25850251e-02f, -4.11313474e-02f, -8.20329189e-02f,
  2.85744928e-02f, -2.18270179e-02f, -8.57771114e-02f, -5.76172508e-02f, -5.77131137e-02f, -4.21468578e-02f, -2.18973272e-02f, -3.16510797e-02f, -1.50873289e-02f, -4.47447635e-02f,
  1.55473426e-01f, 1.08128823e-01f, -1.69147924e-02f, -1.15498133e-01f, 2.78256293e-02f, -2.24899072e-02f, -6.65098578e-02f, 2.94259214e-03f, -1.67242646e-01f, -1.65828913e-01f,
  6.51530474e-02f, 7.06253871e-02f, -3.76122259e-02f, -2.88766287e-02f, 4.07373942e-02f, 7.13288262e-02f, 8.16742852e-02f, 1.20550841e-01f, -3.24159325e-03f, -7.04661384e-02f,
  1.29371397e-02f, 1.70508027e-02f, 4.15543504e-02f, 6.28259499e-03f, 7.35742003e-02f, -5.53134782e-03f, 6.57207519e-02f, -5.62871015e-03f, -4.13939841e-02f, 4.24663611e-02f,
  4.58634496e-02f, -8.34364966e-02f, 4.45020907e-02f, 1.99943222e-02f, 2.67106462e-02f, 7.78347254e-02f, -3.67557071e-02f, -2.06659529e-02f, -1.78087074e-02f, -7.35729411e-02f,
  -1.08870022e-01f, 1.12579629e-01f, -5.34629412e-02f, -9.95772257e-02f, -5.14869615e-02f, -4.53250147e-02f, 5.04260436e-02f, -6.01855628e-02f, 1.76832881e-02f, -1.55997686e-02f,
  -5.25094531e-02f, -6.58738539e-02f, 2.41582375e-02f, 2.49320064e-02f, -1.14425167e-01f, -1.18319504e-01f, -8.38200301e-02f, -3.60703021e-02f, -5.69990054e-02f, -3.95270064e-02f,
  -8.03680494e-02f, -1.45681240e-02f, -1.34758770e-01f, -1.34244666e-01f, -8.78604203e-02f, -1.48271412e-01f, -8.37354884e-02f, -1.83760911e-01f, -2.36191437e-01f, -1.33629993e-01f,
  1.51659057e-01f, -2.88174927e-01f, -2.33594015e-01f, 4.09056619e-02f, -1.38639793e-01f, -1.07299909e-01f, -2.09856972e-01f, 1.76665187e-02f, 8.15402940e-02f, -2.23521680e-01f,
  -1.55566096e-01f, 1.26981854e-01f, 5.97689040e-02f, 3.19579169e-02f, -9.24166664e-02f, -3.17689419e-01f, -2.79328644e-01f, -5.26296273e-02f, 8.52269232e-02f, 1.30202487e-01f,
  -5.08611053e-02f, -3.01793367e-02f, 6.43869266e-02f, -1.37167843e-02f, -8.85127634e-02f, 4.08591982e-03f, -2.89016992e-01f, -1.38395146e-01f, -1.90415949e-01f, -1.97868243e-01f,
  -1.03457868e-01f, 7.61127546e-02f, 3.70559916e-02f, 1.00779653e-01f, -7.77891779e-04f, -7.68459216e-02f, -4.76463586e-02f, -1.74197927e-02f, 3.81745514e-03f, -1.90635379e-02f,
  -5.91419749e-02f, -2.39290278e-02f, -6.60309196e-02f, 3.12212948e-02f, 2.20300555e-02f, 8.98801982e-02f, -6.30467311e-02f, 2.20118789e-03f, 7.18365908e-02f, 2.33858116e-02f,
  -6.29068464e-02f, 3.13459826e-03f, -5.22942580e-02f, -6.63220659e-02f, -1.14678973e-02f, 9.19132084e-02f, -7.65000284e-02f, 1.19590990e-01f, 4.82999571e-02f, -1.21064454e-01f,
  -7.42916390e-02f, 3.41173373e-02f, -4.02974151e-03f, -1.78332552e-02f, -1.43373106e-02f, -6.38488308e-02f, -6.87877238e-02f, -4.47013304e-02f, 1.10423498e-01f, -4.35418375e-02f,
  5.15027158e-02f, -3.28931771e-03f, 2.74788812e-02f, 3.33785415e-02f, 1.07923904e-02f, 2.62842663e-02f, -6.23327270e-02f, 5.20535819e-02f, -6.77347183e-02f, 3.31044234e-02f,
  4.02269065e-02f, 6.92032203e-02f, 1.02082454e-02f, -2.56403517e-02f, -4.75648828e-02f, -4.08819243e-02f, 4.48474698e-02f, 6.21892512e-02f, 6.32989332e-02f, -1.68151725e-02f,
  1.11345865e-01f, 2.60196310e-02f, -2.94412952e-02f, 1.35538191e-01f, -6.64823875e-02f, -8.22268948e-02f, 1.52803957e-02f, 9.39557329e-02f, 7.84781352e-02f, 2.10047700e-02f,
  5.12213483e-02f, 7.76920840e-02f, 5.10608368e-02f, 4.81855273e-02f, 8.94383937e-02f, 2.65074968e-02f, -1.28649622e-01f, 7.60505795e-02f, -3.24919587e-04f, -9.48521271e-02f,
  4.80839983e-03f, -4.25974466e-03f, 4.90156822e-02f, -4.75023724e-02f, 6.96206838e-02f, 1.11037411e-01f, 4.30738218e-02f, 1.15992635e-01f, 8.42065644e-03f, -3.98886912e-02f,
  -1.75664946e-02f, -2.09770594e-02f, -1.53605253e-01f, -1.25211999e-01f, -2.75628958e-02f, 5.03259301e-02f, -5.99696040e-02f, 7.90853333e-03f, -6.58052647e-03f, -1.26123682e-01f,
  -1.15743645e-01f, 4.38494533e-02f, -6.64485842e-02f, -7.03876540e-02f, 2.31352225e-02f, -1.43412217e-01f, -4.75195758e-02f, -1.18947521e-01f, 1.07764572e-01f, 7.44870380e-02f,
  -9.53406468e-02f, -1.54742196e-01f, -5.18668853e-02f, -1.00450203e-01f, -1.37608632e-01f, -2.23143655e-03f, -1.87194198e-01f, -1.48055643e-01f, 1.75882541e-02f, -2.05650523e-01f,
  -5.73943891e-02f, 8.91303867e-02f, -5.08255213e-02f, -2.58057285e-02f, -2.03556083e-02f, 3.13988589e-02f, -2.84327213e-02f, 3.57327126e-02f, -1.76691748e-02f, 5.71408123e-02f,
  5.92417307e-02f, 4.50048558e-02f, 6.74561709e-02f, 1.50643129e-04f, -7.70950094e-02f, -3.76196168e-02f, -6.27271459e-02f, -2.26840377e-02f, -4.47761593e-03f, 6.65774122e-02f,
  5.30359223e-02f, 6.87899217e-02f, 6.75380835e-03f, 1.12399772e-01f, 1.05633080e-01f, 3.45869921e-03f, 7.01806694e-02f, 9.45394263e-02f, 8.23279321e-02f, -4.64940593e-02f,
  -7.01578259e-02f, -2.81043425e-02f, 1.25486448e-01f, 8.98624025e-03f, 5.36533035e-02f, 1.41507275e-02f, -5.05353175e-02f, 2.53586005e-02f, -7.37800309e-03f, -3.19095212e-03f,
  2.79719047e-02f, 5.03240153e-02f, 5.82547262e-02f, -1.40745584e-02f, -1.03541300e-01f, -4.95404862e-02f, -5.17606211e-04f, 6.85893521e-02f, 6.36009872e-02f, -1.85067113e-02f,
  -1.97742078e-02f, 6.23588152e-02f, -2.09166203e-02f, 1.83088686e-02f, 3.14505994e-02f, -4.55443806e-04f, -4.89556119e-02f, 3.05344444e-02f, -1.21284038e-01f, -6.56468421e-02f,
  -7.35152438e-02f, 1.58456907e-01f, -6.12199903e-02f, 7.60259926e-02f, -3.38715389e-02f, 2.12263167e-02f, -1.02453828e-01f, -1.02123700e-01f, -7.76189864e-02f, -7.59156607e-03f,
  3.38777900e-02f, 5.74639486e-03f, -8.88468549e-02f, 4.56351526e-02f, -2.95991614e-03f, 5.93130440e-02f, 5.58576994e-02f, -7.47629106e-02f, 1.21538907e-01f, -4.15060762e-03f,
  -1.08243644e-01f, 1.26954719e-01f, 4.84190173e-02f, 2.27866651e-04f, -7.96218310e-03f, 1.28961995e-01f, 2.01975238e-02f, 9.84059088e-03f, 1.84531137e-01f, 7.30154663e-02f,
  3.22186530e-01f, 1.59330919e-01f, -9.70017388e-02f, 5.86656965e-02f, -9.10051167e-02f, -1.77748919e-01f, -6.79772720e-02f, 8.63146335e-02f, -2.92719505e-03f, 4.62910719e-02f,
  -9.20210853e-02f, 7.98674524e-02f, 2.25603394e-02f, 3.59293558e-02f, 8.92665330e-03f, 9.02770311e-02f, -7.08641261e-02f, -3.62204947e-02f, 2.34968290e-02f, -2.48442739e-02f,
  8.69113132e-02f, 5.76762781e-02f, -1.27925968e-03f, 1.66493859e-02f, 1.16506256e-01f, 4.07558344e-02f, 4.67815399e-02f, 3.24929245e-02f, 4.72496115e-02f, 2.25944240e-02f,
  -1.99033525e-02f, 7.54164755e-02f, -9.90604013e-02f, 3.33259329e-02f, -1.23909131e-01f, 2.28748331e-03f, -2.18300335e-02f, -3.15699913e-02f, 3.80653664e-02f, 7.46481791e-02f,
  -4.29991819e-02f, 1.27020921e-03f, 3.86164188e-02f, -2.75262762e-02f, 9.16792750e-02f, -5.07655479e-02f, -5.45844622e-02f, 5.01017943e-02f, 4.25032787e-02f, 4.32163365e-02f,
  -6.79789782e-02f, 4.62350585e-02f, 2.22324650e-03f, 1.90636925e-02f, 6.90148398e-03f, -2.05131657e-02f, -1.05520040e-01f, -2.15735380e-02f, -9.71734077e-02f, 9.86726657e-02f,
  5.42211942e-02f, 8.83830711e-02f, 2.96109281e-02f, -8.04493949e-03f, 7.65589178e-02f, 2.34008650e-03f, 3.23040672e-02f, 8.68249685e-02f, 2.26519145e-02f, 2.94114207e-03f,
  4.88631614e-02f, -9.99754062e-04f, -1.48072536e-03f, -6.02103025e-02f, 4.16490957e-02f, 1.49086770e-02f, -2.23486908e-02f, -2.53284927e-02f, 7.75596276e-02f, -6.64732605e-02f,
  8.40842575e-02f, -2.90581025e-02f, -1.85545087e-02f, 6.74218014e-02f, -5.37850969e-02f, 9.05042216e-02f, 5.35775255e-03f, 3.64176594e-02f, -1.00913206e-02f, 6.80547487e-03f,
  5.67650869e-02f, -2.13219896e-01f, -4.12156470e-02f, 5.08655459e-02f, -6.37252107e-02f, -7.92883113e-02f, -3.68318260e-02f, -1.07226502e-02f, -8.94805640e-02f, 9.24867541e-02f,
  2.40355190e-02f, 6.48201481e-02f, -5.37690818e-02f, 6.48218393e-02f, 4.72004525e-02f, -8.99739116e-02f, -5.67970835e-02f, 2.04710923e-02f, 3.89202274e-02f, 2.02311967e-02f,
  7.69222230e-02f, 3.84664536e-02f, 1.16518175e-03f, -4.14866246e-02f, 7.68341636e-03f, -9.45076495e-02f, 4.97418456e-02f, 3.86666730e-02f, -1.52127743e-01f, 1.44385761e-02f,
  5.61454833e-01f, 1.18575312e-01f, 1.87538579e-01f, 1.05835073e-01f, -2.36482829e-01f, -1.20401427e-01f, -1.05558157e-01f, 2.92109069e-03f, 8.35960880e-02f, 9.34634730e-02f,
  -5.81366718e-02f, -6.94745183e-02f, 1.50651634e-01f, 1.68586783e-02f, 9.38301533e-02f, 4.69690599e-02f, -4.56140451e-02f, 2.66006976e-01f, 1.22509979e-01f, 9.27554220e-02f,
  -8.67408589e-02f, 1.06507413e-01f, 1.56830072e-01f, 1.10250086e-01f, 3.00982594e-02f, -1.05544351e-01f, 8.85225236e-02f, 6.63370565e-02f, -7.69688115e-02f, 7.24617019e-02f,
  7.05882609e-02f, 2.45014757e-01f, -8.89370441e-02f, 1.01212701e-02f, -9.04100612e-02f, 1.27912432e-01f, -2.62570963e-03f, 4.76520509e-02f, -1.34850051e-02f, 4.13995683e-02f,
  -1.18552603e-01f, 1.49383759e-02f, -2.26671882e-02f, 3.28142643e-02f, -2.88748574e-02f, -2.83163600e-02f, 1.04843378e-01f, 8.83035064e-02f, 2.85626389e-02f, -1.83774401e-02f,
  -1.20244905e-01f, -1.07543975e-01f, 4.19416055e-02f, -9.45447758e-02f, 1.00709833e-01f, 1.60101708e-02f, -2.06836406e-02f, 6.17706887e-02f, 6.33738190e-02f, 7.85043016e-02f,
  7.56657496e-02f, 8.29865113e-02f, 7.74239525e-02f, 1.12749031e-02f, -5.98254986e-02f, -3.10046654e-02f, -2.50994377e-02f, -7.93623105e-02f, -2.59225089e-02f, 1.03359763e-02f,
  -5.43798506e-02f, 7.34250322e-02f, -3.46387103e-02f, 9.29823518e-02f, -3.75170670e-02f, 5.58391921e-02f, 4.64654565e-02f, -3.35349962e-02f, 1.08301893e-01f, 5.10580987e-02f,
  6.75345287e-02f, -4.36880961e-02f, 4.57025059e-02f, 7.03310966e-02f, -4.74622287e-02f, 2.55800830e-03f, 4.79304604e-02f, -4.09979746e-02f, 8.83746892e-02f, 1.24395518e-02f,
  -2.13141233e-01f, 1.10135619e-02f, 4.22361828e-02f, 8.89229849e-02f, -4.72587794e-02f, -2.20830180e-03f, 1.64593961e-02f, 3.14243808e-02f, 4.83585056e-03f, -5.84882721e-02f,
  -5.76101504e-02f, 6.04356900e-02f, 3.84548716e-02f, -2.06596721e-02f, -1.06028736e-01f, 5.16668372e-02f, -1.14370987e-01f, 3.35910730e-02f, 6.18849583e-02f, 1.47862602e-02f,
  -3.41054946e-02f, -1.11152701e-01f, -6.82848087e-03f, -6.72021285e-02f, 1.13681732e-02f, -2.30196584e-02f, -8.15389156e-02f, -8.24374706e-03f, 9.94338989e-02f, 1.61526203e-02f,
  6.94761202e-02f, -2.18321115e-01f, 2.05836460e-01f, -3.55834290e-02f, -9.77761149e-02f, -1.34525821e-01f, -2.48887300e-01f, -7.36108124e-02f, 8.64743888e-02f, -1.57400146e-01f,
  -1.36641845e-01f, 1.66760460e-01f, 2.69943208e-01f, 2.32980177e-01f, 2.51167327e-01f, 3.04483399e-02f, 1.09026700e-01f, 3.33916575e-01f, 3.16230446e-01f, -5.77876857e-03f,
  -7.63804987e-02f, 7.96599612e-02f, 1.96586505e-01f, 1.59147143e-01f, 4.41400334e-03f, 9.79754329e-03f, -4.68617529e-02f, 1.23028562e-03f, -3.93933989e-02f, -2.48265173e-02f,
  -2.14514986e-01f, -2.19249457e-01f, 1.58123031e-01f, 6.19332753e-02f, -1.29556581e-01f, 1.04414369e-03f, -1.02697566e-01f, -1.18225534e-02f, 3.89077440e-02f, -1.14603035e-01f,
  -1.14354588e-01f, 1.80745572e-02f, -3.64866778e-02f, -5.22108786e-02f, -1.15629956e-02f, -6.15906045e-02f, 1.48102874e-02f, 1.17536038e-01f, 4.83746380e-02f, -3.72669753e-03f,
  -6.49203733e-02f, -1.83111921e-01f, -2.96950061e-02f, -2.39627864e-02f, 6.91654608e-02f, 1.23846956e-01f, 2.89698020e-02f, -6.10125847e-02f, 9.23507139e-02f, -9.54787582e-02f,
  9.52682365e-03f, 7.70644248e-02f, 5.35344221e-02f, 7.10519850e-02f, -6.77994788e-02f, 5.86783476e-02f, -5.52111259e-03f, 1.05455015e-02f, 3.07052396e-02f, 2.75104381e-02f,
  6.14138432e-02f, 4.15691659e-02f, 7.07653910e-02f, 1.03640661e-03f, -2.71947496e-02f, 1.71842857e-03f, 5.31474128e-02f, 5.11400867e-03f, 5.60756549e-02f, -4.19072583e-02f,
  -4.57467362e-02f, 1.12100942e-02f, -3.45716774e-02f, 3.10570598e-02f, 8.90997646e-04f, 5.31901605e-02f, 6.40647709e-02f, -1.17736846e-01f, 3.35952938e-02f, -5.02881743e-02f,
  -8.58731195e-02f, 1.51152760e-01f, 2.73450781e-02f, 6.06869161e-02f, -2.82280128e-02f, 1.22533075e-03f, -1.64248496e-02f, 8.44171550e-03f, -6.00232277e-03f, -4.92947437e-02f,
  -1.70814507e-02f, -3.61681730e-02f, 4.35481174e-03f, -4.49078940e-02f, -5.84430583e-02f, -3.94751690e-02f, -7.96934403e-03f, 1.28729850e-01f, 4.82487306e-02f, -1.50785118e-01f,
  -6.31592274e-02f, 2.57457737e-02f, 1.35559607e-02f, -2.45769676e-02f, -6.11710921e-02f, 6.58745766e-02f, -5.60939638e-03f, -8.77028555e-02f, 6.26948699e-02f, -1.12410069e-01f,
  -2.79032439e-01f, 3.59296985e-02f, 9.93765667e-02f, 2.31626513e-03f, 6.10230081e-02f, -3.51044610e-02f, -4.37630005e-02f, -6.17764965e-02f, -5.38942479e-02f, -1.48152411e-02f,
  3.24651040e-02f, -8.80331621e-02f, -7.62379542e-02f, -8.79603028e-02f, -1.34312823e-01f, 5.86016737e-02f, 7.02550858e-02f, 1.00503499e-02f, -1.01002604e-01f, -1.86527401e-01f,
  -1.70393869e-01f, -2.09368810e-01f, -1.22134030e-01f, -1.75358295e-01f, 2.41971370e-02f, -1.13010123e-01f, 4.09868434e-02f, -8.76383334e-02f, 3.34040099e-03f, 6.99378178e-03f,
  1.11239098e-01f, 4.57986593e-02f, -7.23695084e-02f, -1.43307418e-01f, -1.53382253e-02f, 9.65945050e-02f, 4.46003349e-03f, 1.25885969e-02f, -1.37101067e-02f, 5.55986986e-02f,
  -7.07966238e-02f, 1.23546859e-02f, -3.70393470e-02f, -7.74785355e-02f, -9.06241871e-03f, -1.54800452e-02f, -9.46478993e-02f, -2.22317316e-02f, 6.95775747e-02f, -4.80532134e-03f,
  -1.03210546e-01f, -4.85783555e-02f, 2.07276791e-02f, 8.43258873e-02f, 1.19134667e-03f, 5.01467139e-02f, 4.44584526e-02f, -7.95598477e-02f, -6.75851107e-02f, -6.75523579e-02f,
  -4.39548232e-02f, -3.18019651e-02f, 5.48464507e-02f, -5.32938093e-02f, 6.07926305e-03f, -4.41584773e-02f, 1.64176710e-03f, 1.65971536e-02f, 2.80783046e-02f, 3.23127247e-02f,
  -3.27382982e-02f, 3.49202417e-02f, 2.65961178e-02f, 1.74340624e-02f, 6.91051856e-02f, 2.92711216e-03f, -7.07324222e-02f, 4.03762832e-02f, 4.10855263e-02f, -5.98124079e-02f,
  -9.34460610e-02f, -3.89415175e-02f, -3.11737489e-02f, -2.30082721e-02f, -1.93791254e-03f, 1.86375957e-02f, 2.26820260e-02f, 5.22048473e-02f, 3.45588811e-02f, 3.78070921e-02f,
  2.75272373e-02f, 1.53751979e-02f, -4.54501025e-02f, -1.94504168e-02f, 2.24087480e-02f, 5.82089722e-02f, 1.25349194e-01f, 7.52051324e-02f, 1.01787575e-01f, -7.29649663e-02f,
  -4.93811071e-02f, 3.31422538e-02f, 3.75401266e-02f, -8.23718160e-02f, -5.26790172e-02f, 4.25527133e-02f, -3.30503425e-03f, -7.09053427e-02f, 5.50249889e-02f, -7.01357750e-03f,
  4.54836749e-02f, -9.06700417e-02f, -2.70679295e-02f, -6.26632571e-02f, 5.91032095e-02f, 6.26512915e-02f, 1.23023376e-01f, -4.24486957e-03f, 8.46749824e-03f, 8.41064379e-03f,
  2.12932646e-01f, 2.29844879e-02f, -2.33347237e-01f, 9.60471556e-02f, -1.49736539e-01f, -6.44907951e-02f, -1.74737036e-01f, -8.36491957e-02f, 7.94898868e-02f, 5.47125982e-03f,
  1.54672293e-02f, 5.12421951e-02f, 9.91666168e-02f, 1.11953273e-01f, -1.71064902e-02f, -1.43179387e-01f, -3.80984657e-02f, 3.57612199e-03f, -6.08435879e-03f, -1.75990441e-04f,
  1.40225351e-01f, 8.77282545e-02f, 1.43537596e-01f, -9.83514450e-03f, 3.11052334e-02f, 7.29673430e-02f, 1.28110137e-03f, -4.29354515e-03f, -8.91138986e-02f, 7.05143288e-02f,
  -3.09760850e-02f, -3.35843936e-02f, 9.21469480e-02f, 9.55176204e-02f, -2.52257083e-02f, 1.55423591e-02f, -7.10187033e-02f, 1.67332459e-02f, -1.31198147e-03f, 4.80009317e-02f,
  4.55734134e-02f, 8.48057792e-02f, -2.76350453e-02f, -7.04692909e-03f, -1.84161849e-02f, -3.02036060e-03f, 8.68689790e-02f, 8.78492221e-02f, -7.69476071e-02f, -5.13369888e-02f,
  -2.05904562e-02f, 5.19404635e-02f, -1.18700765e-01f, -3.49910930e-02f, 4.63305088e-03f, 3.36702839e-02f, -6.24630935e-02f, -1.85730048e-02f, -2.08758730e-02f, -3.87788117e-02f,
  4.21935841e-02f, -4.45055775e-02f, 3.31290029e-02f, 1.22345157e-01f, -5.55557199e-03f, -3.91938016e-02f, 1.20609831e-02f, -3.57949547e-02f, 5.36360703e-02f, 1.19284932e-02f,
  -3.35783437e-02f, -8.99031833e-02f, -5.46385832e-02f, -7.84027651e-02f, -7.52161220e-02f, -9.87459645e-02f, -6.76854048e-03f, -2.06216890e-02f, -6.01987280e-02f, 7.16625974e-02f,
  -2.82220803e-02f, -1.02024898e-01f, -1.00765303e-01f, -5.22828326e-02f, 8.75816867e-02f, -7.67729953e-02f, -1.54860178e-03f, -7.12808222e-02f, -7.29809627e-02f, -3.60120609e-02f,
  7.46229757e-03f, -1.50247961e-02f, 1.23181388e-01f, 6.00199141e-02f, -6.10701889e-02f, -1.98442508e-02f, 2.04249807e-02f, 5.42103983e-02f, -6.06121160e-02f, -2.41211820e-02f,
  -5.99913113e-02f, 6.95968699e-03f, -7.57606402e-02f, -2.31179111e-02f, -5.76257892e-02f, 4.81421389e-02f, 9.38844979e-02f, -4.39831465e-02f, -7.97585025e-02f, -3.20240967e-02f,
  -5.35209179e-02f, -4.05056775e-02f, 6.73323348e-02f, 7.16407597e-02f, -6.92051128e-02f, -4.84512262e-02f, 2.62877112e-03f, -1.06348798e-01f, -1.34518117e-01f, -4.17157710e-02f,
  9.70320925e-02f, 6.07224600e-03f, -6.75449613e-03f, -4.92188260e-02f, 1.20748300e-03f, -2.95877247e-03f, -4.25220951e-02f, 7.57779479e-02f, -1.18650207e-02f, -3.29895085e-03f,
  1.70854792e-01f, 1.28981590e-01f, 1.40436068e-01f, 7.43581429e-02f, 1.16909824e-01f, 3.84027213e-02f, 4.33002971e-02f, 8.64370540e-02f, 8.06292221e-02f, 3.03496812e-02f,
  7.62940198e-03f, 8.96329619e-03f, 6.68607503e-02f, -1.99150983e-02f, -7.55333900e-02f, 9.44098905e-02f, 1.47621846e-02f, -3.52446437e-02f, 8.53199959e-02f, -8.04805849e-03f,
  1.58013210e-01f, 1.18881486e-01f, 5.81758954e-02f, 2.84854565e-02f, 6.42481670e-02f, -1.42701538e-02f, -3.39992046e-02f, 3.44455475e-03f, 1.30102392e-02f, 4.21503484e-02f,
  7.79406205e-02f, 4.42679748e-02f, 7.21120387e-02f, 2.91561075e-02f, -4.63204496e-02f, 3.60620245e-02f, 7.07157468e-03f, -9.43163689e-03f, 5.66011779e-02f, 3.98360156e-02f,
  -5.58214560e-02f, 1.88043490e-02f, 5.85978925e-02f, 8.23546201e-02f, 8.27172175e-02f, 5.89237101e-02f, -6.89080954e-02f, 3.39171812e-02f, 9.36855823e-02f, -1.85929500e-02f,
  4.16407026e-02f, -4.44642715e-02f, 3.55416760e-02f, 6.36756271e-02f, -3.67315710e-02f, 4.89479629e-03f, 5.08312806e-02f, -2.94658467e-02f, 6.06667772e-02f, -5.47149740e-02f,
  5.96302487e-02f, -2.79678013e-02f, -4.49780561e-02f, -4.96002845e-02f, -5.09411134e-02f, -1.72098204e-02f, -3.83829549e-02f, 9.50656235e-02f, 1.02215279e-02f, -5.11615239e-02f,
  6.50107190e-02f, 7.71794170e-02f, -7.23394752e-02f, -1.12779823e-03f, -6.68525696e-02f, 3.91440541e-02f, 1.90574245e-03f, -4.05716300e-02f, -4.08062711e-02f, -1.14991246e-02f,
  -3.81112620e-02f, -5.46338619e-04f, -6.95811361e-02f, -1.17100058e-02f, -1.36709251e-02f, 4.33975011e-02f, 7.03842565e-02f, 7.97689781e-02f, -1.44118583e-02f, 8.45777988e-02f,
  8.84330571e-02f, -1.24568501e-02f, 4.00123373e-02f, -8.07469264e-02f, -1.08055130e-01f, -5.25674559e-02f, -7.56124854e-02f, -2.24062800e-02f, -1.32330600e-02f, 7.37374946e-02f,
  7.40868524e-02f, -5.29861636e-02f, 6.59757853e-02f, 2.73586921e-02f, -3.53331491e-02f, 1.04444399e-01f, -2.65216883e-02f, -3.04553434e-02f, -3.10780890e-02f, -8.80651101e-02f,
  1.79262966e-01f, 1.39912784e-01f, -4.89706034e-03f, -8.26924294e-03f, -7.03248382e-02f, -6.82769641e-02f, 6.63529197e-03f, -3.59105468e-02f, -5.75278401e-02f, -4.27856622e-03f,
  6.19827658e-02f, 8.41049328e-02f, 5.01687676e-02f, -2.13658698e-02f, -1.35562196e-02f, -1.11843701e-02f, 6.48156330e-02f, 6.06232062e-02f, -1.25423566e-01f, 4.39419001e-02f,
  -2.20144894e-02f, 1.07280172e-01f, 9.39289033e-02f, -5.45825921e-02f, -1.15973083e-02f, -1.28086545e-02f, 7.03094304e-02f, -3.44580226e-02f, -2.67050769e-02f, 2.51514837e-02f,
  7.61852488e-02f, 8.09814706e-02f, -4.00732830e-02f, -8.48927721e-02f, -6.89026639e-02f, 1.75406132e-02f, -7.21745417e-02f, 1.02019850e-02f, 4.56917062e-02f, 3.39262411e-02f,
  1.01820931e-01f, 1.04225986e-01f, -9.10725370e-02f, -4.36061854e-03f, 3.86035927e-02f, 6.87812343e-02f, -3.14299762e-02f, 6.87891319e-02f, 1.21987890e-02f, 5.26634306e-02f,
  2.17333604e-02f, 1.10751595e-02f, 1.32961292e-02f, -9.72396731e-02f, -6.82896003e-02f, -1.73904765e-02f, -3.81140672e-02f, 7.60453194e-02f, -9.14857090e-02f, 7.66841769e-02f,
  -1.12947717e-01f, 4.53523174e-02f, 1.97809320e-02f, 8.91956408e-03f, -5.50720021e-02f, 7.79170822e-03f, -5.79764321e-02f, 1.47011252e-02f, 8.74960236e-03f, -5.26046120e-02f,
  -1.01499736e-01f, 3.00093573e-02f, -7.96250924e-02f, -4.95050438e-02f, 6.80940179e-03f, -6.67793900e-02f, -4.15963046e-02f, -6.80895150e-02f, -8.36737975e-02f, 2.88489498e-02f,
  6.69117197e-02f, 5.29130735e-02f, 5.80541417e-03f, 6.78309426e-02f, -4.04326133e-02f, -9.34253708e-02f, -2.18668580e-02f, 7.93480873e-03f, 8.40954706e-02f, -4.56118733e-02f,
  -4.12420109e-02f, -1.94590703e-01f, 1.14484283e-03f, 6.70997202e-02f, -5.21175154e-02f, 6.43911138e-02f, 1.37224654e-02f, 7.68055245e-02f, 6.69777691e-02f, -7.37592503e-02f,
  1.16741704e-02f, -8.50065574e-02f, 6.17248826e-02f, 4.71307933e-02f, -8.99482220e-02f, -7.76175857e-02f, -2.53106188e-02f, -1.35112638e-02f, 6.78917617e-02f, 4.57423143e-02f,
  -3.84231322e-02f, -4.32257317e-02f, -9.76804793e-02f, 4.02402468e-02f, -2.16014944e-02f, -4.92591597e-02f, 3.19572948e-02f, 3.41973603e-02f, -7.33073354e-02f, -7.53202438e-02f,
  5.87030947e-02f, -5.12062348e-02f, 2.53630895e-02f, -4.24814085e-03f, -1.59029126e-01f, -1.03428170e-01f, -3.17659713e-02f, -2.82542361e-03f, 3.10653616e-02f, 4.30619530e-02f,
  -9.21503007e-02f, -5.51753454e-02f, 4.35531698e-02f, 1.14394948e-01f, -1.32921236e-02f, 8.00608918e-02f, -2.41966192e-02f, 8.17949697e-02f, 1.52404243e-02f, -9.08064544e-02f,
  6.99357614e-02f, 8.65931958e-02f, 6.84045181e-02f, 7.84509629e-02f, -3.21216919e-02f, -1.20398151e-02f, 4.53915186e-02f, 5.71200475e-02f, 6.65246546e-02f, -5.18475920e-02f,
  -5.60860895e-02f, 2.50247773e-02f, -1.46311661e-02f, -7.33544976e-02f, 6.72686324e-02f, 6.74401373e-02f, -7.72321671e-02f, 1.13549538e-01f, 9.05113667e-02f, -4.09538820e-02f,
  5.94073609e-02f, 2.02470869e-02f, -4.92748059e-02f, 4.90604527e-02f, -9.55150463e-03f, 8.08092356e-02f, 3.18070166e-02f, 1.45926282e-01f, 3.79774943e-02f, 4.92964573e-02f,
  2.40658112e-02f, -9.40188691e-02f, -4.19535600e-02f, 3.23841237e-02f, 4.18334976e-02f, -1.02861635e-02f, -4.96551171e-02f, -1.19494945e-02f, -3.60795856e-02f, 8.08609277e-03f,
  -4.32697013e-02f, -6.27334863e-02f, 1.09288050e-02f, -9.43089649e-02f, -5.19137420e-02f, -1.52014028e-02f, 4.62804697e-02f, 3.67768891e-02f, 7.19184577e-02f, 6.73646629e-02f,
  4.34417203e-02f, 4.61570062e-02f, -9.59388763e-02f, 7.53612891e-02f, -1.87246557e-02f, -7.72627816e-03f, -1.72905289e-02f, -5.43052629e-02f, -5.65313697e-02f, -2.62345821e-02f,
  -8.78311023e-02f, 3.58388759e-02f, 4.91952822e-02f, 2.16606464e-02f, -6.86204433e-02f, 3.26285176e-02f, 5.66636585e-02f, 4.80746962e-02f, 6.51665358e-03f, -8.45237225e-02f,
  2.86678057e-02f, 1.36262663e-02f, 3.48879024e-02f, -7.04205967e-03f, -2.06411611e-02f, -6.51169848e-03f, -9.16395430e-03f, 4.13586153e-03f, -3.68715785e-02f, 1.02440074e-01f,
  -7.80953914e-02f, 5.10907061e-02f, -9.28289630e-03f, 8.80907625e-02f, 6.94651678e-02f, -1.15355067e-02f, 6.51816428e-02f, -2.92352475e-02f, 1.16738386e-01f, 1.00480560e-02f,
  1.66657416e-03f, -1.10073499e-01f, -8.76574740e-02f, 3.14306119e-03f, 5.96278198e-02f, 5.10946810e-02f, -7.37894252e-02f, -4.86602485e-02f, 9.54841375e-02f, -5.88587672e-02f,
  1.10160075e-01f, -5.85451350e-02f, -6.30419422e-03f, -7.65791759e-02f, -1.21958189e-01f, 4.39147912e-02f, -5.47499247e-02f, 1.46195451e-02f, 5.69988787e-02f, 1.02684312e-01f,
  1.28446013e-01f, 2.55632550e-01f, 2.52526820e-01f, 2.25582257e-01f, 3.31750363e-02f, 1.57194771e-02f, -2.69384254e-02f, 5.59108369e-02f, 5.61937355e-02f, 8.25118553e-03f,
  4.05701287e-02f, -7.87648410e-02f, -5.13847768e-02f, -6.75347373e-02f, -7.68826902e-02f, 1.12524308e-01f, 1.30288089e-02f, 3.42277996e-02f, -6.07031658e-02f, -7.90982321e-02f,
  1.39596194e-01f, -5.13978824e-02f, 8.51885900e-02f, 1.06431574e-01f, -9.83473379e-03f, -5.16559072e-02f, 7.01233977e-03f, -4.48825210e-02f, -1.58079956e-02f, 7.35276937e-02f,
  1.37381935e-02f, -3.55259120e-03f, -2.10297499e-02f, -5.37553169e-02f, 1.27978167e-02f, -1.96185727e-02f, -7.32244551e-02f, 2.90101469e-02f, -2.33165827e-02f, -7.62162507e-02f,
  1.96708390e-03f, -1.73392182e-03f, -8.52336828e-03f, -7.48673007e-02f, 2.79913414e-02f, 9.36284214e-02f, 4.54326160e-02f, -9.89768952e-02f, -9.42639634e-03f, 8.17991570e-02f,
  2.89838091e-02f, -1.16290543e-02f, -6.00432083e-02f, 1.02113076e-02f, -2.45435666e-02f, 8.28123465e-02f, -3.25633623e-02f, 4.93130721e-02f, 4.99137677e-02f, 4.10582051e-02f,
  5.37674874e-02f, -3.93334068e-02f, 3.35545721e-03f, 3.01630795e-02f, 3.35687213e-02f, -5.61789349e-02f, -7.60062188e-02f, 6.73362389e-02f, -1.85787175e-02f, -1.14447922e-02f,
  6.78755417e-02f, 5.54997139e-02f, 2.22613309e-02f, 2.72934344e-02f, -4.16185148e-02f, -6.09792210e-02f, -3.53944860e-02f, 2.37179156e-02f, -1.11882975e-02f, -9.26416367e-02f,
  2.44434357e-01f, 1.80482715e-02f, 1.32968396e-01f, 1.07135244e-01f, -9.67149099e-04f, 5.50074577e-02f, 6.34921342e-02f, -4.33538370e-02f, -2.99506467e-02f, -6.79292008e-02f,
  3.40151638e-02f, 4.54352126e-02f, 4.11747918e-02f, -7.26653934e-02f, -1.06839249e-02f, -6.87773526e-02f, 3.44762020e-02f, 1.65740419e-02f, 6.25818875e-03f, -6.62460327e-02f,
  -5.94692677e-02f, -1.64940935e-02f, 7.48110265e-02f, 1.80412173e-01f, -5.94417285e-03f, 4.22123149e-02f, 1.15215629e-01f, 1.59757845e-02f, 8.32790062e-02f, 5.76878041e-02f,
  -5.51735044e-01f, -1.02862693e-01f, 1.78367943e-01f, -3.31116557e-01f, -1.16564497e-01f, -2.81696152e-02f, 1.06233530e-01f, -1.58513948e-01f, -1.72920495e-01f, 5.87763730e-03f,
  7.50086382e-02f, -4.44268779e-04f, 1.17833741e-01f, -2.64993124e-02f, -3.40401083e-02f, -2.56896634e-02f, -5.83071187e-02f, -1.32548809e-01f, -1.65809598e-02f, -1.00900061e-01f,
  -6.50992990e-02f, -1.87120453e-01f, -2.77615458e-01f, -1.38659865e-01f, 3.84281762e-02f, 4.52642441e-02f, 1.17587643e-02f, 1.89014652e-03f, 5.10866530e-02f, -2.19972283e-02f,
  5.56084633e-01f, -2.53892064e-01f, -4.18561101e-02f, -1.35496885e-01f, 3.19079943e-02f, -9.55906510e-02f, -8.10981169e-02f, 2.33283397e-02f, -3.23841944e-02f, 2.32470930e-02f,
  -3.00181527e-02f, 2.64728442e-03f, -5.92477098e-02f, -3.09949424e-02f, 2.23110914e-02f, 4.12043035e-02f, -9.60363001e-02f, -2.47307261e-03f, -3.35370116e-02f, 1.41474873e-01f,
  -8.63225758e-02f, -7.90520310e-02f, 1.28579484e-02f, 9.18236598e-02f, 2.83635892e-02f, -1.13400035e-01f, 1.48614779e-01f, -4.63616326e-02f, 8.81310403e-02f, 3.23766284e-02f,
  9.27468389e-02f, 6.06647208e-02f, -8.26704875e-03f, -2.20128149e-02f, 4.24906239e-02f, -3.42427492e-02f, 3.18424813e-02f, 1.19359218e-01f, -3.65782678e-02f, -1.76695846e-02f,
  -5.63892797e-02f, -1.64493285e-02f, -4.52245325e-02f, -3.58000360e-02f, 7.80104008e-03f, -6.11058949e-03f, -4.99249510e-02f, -5.76112121e-02f, 6.01067692e-02f, 3.95993236e-03f,
  6.34041266e-04f, -3.29851173e-02f, -2.89268815e-03f, 4.86292206e-02f, -5.23717515e-02f, -1.74105037e-02f, -8.06510076e-03f, -1.69098787e-02f, -8.43838155e-02f, -4.40051071e-02f,
  2.03972369e-01f, -2.02883601e-01f, -2.75044478e-02f, 1.47508848e-02f, -6.31286437e-03f, -4.51068878e-02f, 1.57638565e-02f, 1.44866221e-02f, -1.25691351e-02f, -1.63033810e-02f,
  -8.74211416e-02f, -9.99672711e-03f, 1.01139769e-01f, 1.02194399e-01f, -1.65709276e-02f, -5.57661988e-02f, -9.14988518e-02f, -9.71065369e-03f, -5.93285635e-02f, 9.35095102e-02f,
  1.44427903e-02f, 2.42611561e-02f, 7.67622143e-02f, 1.94108084e-01f, 1.90393478e-02f, 6.08246028e-02f, 2.36161426e-01f, 8.41237009e-02f, 1.16892137e-01f, 1.88051865e-01f,
  1.24397472e-01f, 6.28736541e-02f, -1.43158603e-02f, -6.54910505e-02f, -7.22577283e-03f, -3.61702740e-02f, -2.26316927e-03f, 1.61538292e-02f, -4.28936929e-02f, 2.43880693e-02f,
  1.52178458e-03f, 4.96328659e-02f, 3.04097049e-02f, -7.72260316e-03f, -3.14079933e-02f, 7.75675476e-02f, -5.25693297e-02f, -2.47775223e-02f, 5.12337200e-02f, 1.81011297e-02f,
  8.90623182e-02f, -4.37926352e-02f, 1.75172538e-02f, 6.52820691e-02f, -9.46149416e-03f, 3.09430864e-02f, 4.21774723e-02f, -4.15594913e-02f, -3.30702253e-02f, 1.49184823e-01f,
  1.55872092e-01f, -1.58854704e-02f, -6.90791681e-02f, -2.26275567e-02f, -2.48000044e-02f, -4.97100689e-02f, 8.21142867e-02f, -3.70179191e-02f, -6.16436563e-02f, 3.07745971e-02f,
  4.22955258e-03f, -2.18406916e-02f, -4.79018614e-02f, 8.91520754e-02f, 3.76305468e-02f, 3.62375304e-02f, -2.63630152e-02f, -4.74294573e-02f, 5.47156259e-02f, 9.29853767e-02f,
  4.27762009e-02f, -3.63634750e-02f, -8.36443752e-02f, -8.49849358e-02f, -4.50817309e-02f, -5.39317131e-02f, 6.39764741e-02f, 5.60729951e-02f, -9.67285410e-02f, 1.66295096e-02f,
  -7.43557280e-03f, 5.49779050e-02f, -4.07026708e-02f, -1.09048069e-01f, -4.07213308e-02f, 6.08950071e-02f, -2.73324884e-02f, -9.62864235e-02f, -8.40409622e-02f, 2.96301488e-02f,
  -8.23190585e-02f, -1.39425714e-02f, 3.08719557e-02f, 7.02329446e-03f, -7.22530037e-02f, -2.77967118e-02f, 2.75826585e-02f, -5.04614189e-02f, -4.70127799e-02f, -1.40796369e-02f,
  5.30539639e-02f, -5.04870862e-02f, 8.30297768e-02f, -9.40361917e-02f, -3.39452364e-02f, -8.47042128e-02f, -8.43007341e-02f, -4.26698215e-02f, -6.79677501e-02f, -3.92978899e-02f,
  1.34192869e-01f, -1.67434365e-01f, 8.82168934e-02f, 2.56684348e-02f, -2.08332296e-02f, 5.76680750e-02f, -8.48613530e-02f, 1.79571658e-02f, -1.42944735e-02f, -7.81236887e-02f,
  6.06344976e-02f, 4.87152562e-02f, -3.66678685e-02f, -6.58882335e-02f, 7.61321336e-02f, -6.54521137e-02f, 7.18204007e-02f, -4.26975712e-02f, -1.75029691e-02f, 1.58700403e-02f,
  7.71422125e-03f, -7.96549097e-02f, 3.57601196e-02f, -1.00001909e-01f, 7.14071989e-02f, 4.21893671e-02f, 7.08379149e-02f, -1.79668162e-02f, 4.39092182e-02f, 8.22142139e-02f,
  6.07722588e-02f, -7.34142512e-02f, -1.27904549e-01f, -1.09958701e-01f, -1.29108295e-01f, -1.97191797e-02f, 2.24486422e-02f, 7.89148659e-02f, 7.04381764e-02f, 3.35614830e-02f,
  3.75003368e-03f, 3.24197859e-02f, 2.46867072e-02f, 4.36583068e-03f, 6.84275106e-02f, -6.41208366e-02f, -6.95706904e-02f, -1.65720999e-01f, -9.81697440e-02f, -5.53202480e-02f,
  -1.23453379e-01f, -7.20226541e-02f, -1.13862433e-01f, 1.71664301e-02f, -1.46906018e-01f, -5.35958186e-02f, -3.09240408e-02f, -1.63016677e-01f, -6.87780529e-02f, -2.04670444e-01f,
  -2.25346372e-01f, 5.59693351e-02f, 1.52167231e-02f, -7.07131550e-02f, -8.28150585e-02f, -6.77772760e-02f, -6.97475076e-02f, 3.73051204e-02f, 6.75133318e-02f, -7.11238608e-02f,
  4.02196236e-02f, 4.77986895e-02f, -4.54937704e-02f, 7.19909696e-03f, -9.30088013e-02f, -1.84749737e-02f, -6.93495497e-02f, -8.07788894e-02f, -1.38226673e-02f, 4.54609171e-02f,
  2.61723474e-02f, 3.43069620e-02f, -1.87047739e-02f, -5.47008812e-02f, 8.77489671e-02f, -8.09943490e-03f, 4.94589806e-02f, -2.55202539e-02f, -9.77355838e-02f, 2.46992484e-02f,
  5.68378940e-02f, -5.91934286e-02f, 1.04679152e-01f, -4.91761938e-02f, -7.04574725e-03f, 2.58997604e-02f, 4.87714401e-03f, -3.67156416e-02f, 6.09502122e-02f, 6.31864881e-03f,
  -4.49579954e-02f, 4.04840596e-02f, -6.93937987e-02f, 6.57618418e-02f, 6.81691766e-02f, -7.15367943e-02f, -3.94608341e-02f, -1.94895882e-02f, 2.91792452e-02f, 1.23128302e-01f,
  8.06520879e-02f, -3.70903537e-02f, 7.14704245e-02f, -5.24819605e-02f, -6.78117201e-02f, -6.40434921e-02f, 4.96416762e-02f, -4.81032208e-02f, 1.03081562e-01f, 8.83823037e-02f,
  -4.56076562e-02f, -4.20316122e-02f, -1.99908651e-02f, 1.07439473e-01f, 4.32752892e-02f, 5.52753285e-02f, 6.55360967e-02f, 3.87643166e-02f, -1.57882348e-02f, -2.00726129e-02f,
  4.09313515e-02f, 5.87362088e-02f, 7.00253248e-02f, 4.72910283e-03f, 2.26446744e-02f, -4.36092876e-02f, 1.31220862e-01f, -2.28281319e-02f, 9.03911665e-02f, 3.95174399e-02f,
  4.89726737e-02f, 3.58425081e-02f, 6.30796626e-02f, 7.69031644e-02f, 5.78719787e-02f, -6.42590411e-03f, -8.79425928e-03f, -8.47556815e-02f, -5.56632224e-03f, -3.19679361e-03f,
  -1.26727939e-01f, 1.16773777e-01f, 7.11513832e-02f, 9.78028029e-02f, -5.64464852e-02f, -1.03273958e-01f, -3.85311544e-02f, -3.83855999e-02f, -4.15480807e-02f, -7.12748757e-03f,
  -2.20656558e-03f, 6.44805953e-02f, 6.80427905e-03f, -4.35545333e-02f, -3.47260572e-02f, -2.37355139e-02f, -2.93235835e-02f, 3.52912135e-02f, -6.99865818e-02f, 3.67319472e-02f,
  2.99341772e-02f, 7.59723857e-02f, 2.51661744e-02f, 5.26570491e-02f, 1.30764216e-01f, 5.82466125e-02f, 1.10131890e-01f, 8.35700855e-02f, 9.11879167e-02f, 1.98130071e-01f,
  1.67117745e-01f, 6.14014314e-03f, 4.75576296e-02f, 7.53404349e-02f, 1.09668128e-01f, -9.11419615e-02f, 3.16477288e-03f, 6.09478801e-02f, 5.94600886e-02f, 1.55414557e-02f,
  4.89386097e-02f, 6.72744762e-04f, 8.82174447e-02f, 6.07262440e-02f, -6.09611161e-02f, -2.99370103e-02f, -2.65683774e-02f, -8.36904198e-02f, -2.99660787e-02f, 9.16884765e-02f,
  -1.18771987e-02f, 3.53644751e-02f, -7.51068816e-02f, -8.80487561e-02f, 2.66910195e-02f, 7.34264206e-04f, 3.21810097e-02f, 5.55002838e-02f, 1.00955591e-02f, 9.72387288e-03f,
  -7.01718405e-02f, 8.28701071e-03f, 5.31688817e-02f, -4.30399068e-02f, 7.69565813e-04f, -3.82696204e-02f, -8.02885368e-03f, 2.73309201e-02f, -7.82408491e-02f, -8.96005183e-02f,
  -5.04293665e-02f, -2.60327035e-03f, -3.25398035e-02f, 5.78896441e-02f, -8.29556957e-02f, 1.91671625e-02f, 3.70346382e-03f, 9.64799374e-02f, 5.55425920e-02f, -6.77066967e-02f,
  1.51650868e-02f, 6.59776554e-02f, -5.55410646e-02f, 3.58934328e-02f, -2.95445342e-02f, 5.56341186e-02f, 4.91690226e-02f, 4.14258130e-02f, -2.29443945e-02f, 4.45796587e-02f,
  5.92158325e-02f, -4.12512152e-03f, 8.43332037e-02f, 5.88046871e-02f, -2.31743287e-02f, 6.95084482e-02f, 6.71895370e-02f, 3.26008326e-03f, 6.33511543e-02f, 6.34294972e-02f,
  -6.87514320e-02f, 1.92563254e-02f, -4.63807769e-02f, -1.47366978e-03f, 1.78728215e-02f, -2.10746918e-02f, 9.82510671e-02f, 1.11324877e-01f, -8.68807081e-03f, 6.79217800e-02f,
  -8.72790888e-02f, -1.61495075e-01f, -1.49902746e-01f, -1.08641177e-01f, -7.38889053e-02f, -3.54919769e-02f, -6.81455880e-02f, -5.03794849e-02f, -6.34342432e-02f, -5.48015274e-02f,
  7.98813701e-02f, 4.01486158e-02f, -3.68580759e-01f, -5.07293828e-02f, -5.53076826e-02f, -2.40923926e-01f, -1.66362435e-01f, -6.56856410e-03f, 3.68828773e-02f, -9.28606018e-02f,
  -9.02736373e-03f, -8.03110600e-02f, -1.43134193e-02f, -9.47489738e-02f, -8.89760479e-02f, -1.57269225e-01f, -2.80948818e-01f, -2.90669948e-01f, -3.03027928e-01f, -2.32006252e-01f,
  -2.00030863e-01f, -1.19192339e-01f, -7.44905025e-02f, -1.34828657e-01f, 7.40644857e-02f, -5.59630198e-03f, -1.52314484e-01f, -1.25071406e-01f, -7.98835084e-02f, -8.26228186e-02f,
  -1.93403125e-01f, 1.63160749e-02f, -8.09133351e-02f, 6.54073358e-02f, -4.24698927e-02f, 2.96260063e-02f, -6.18614294e-02f, 7.88100436e-02f, -3.42003852e-02f, -5.43825254e-02f,
  1.30735561e-02f, -8.50403756e-02f, -8.46451074e-02f, 1.75609048e-02f, -4.18711752e-02f, -1.53984474e-02f, 3.91036160e-02f, 8.31510685e-03f, -1.17553867e-01f, 4.76348996e-02f,
  -6.53833374e-02f, -1.03315726e-01f, -1.16272442e-01f, 3.33224833e-02f, 6.22339174e-02f, -1.56465210e-02f, 7.16904411e-03f, 8.90846946e-04f, 1.25232385e-02f, 1.30412281e-01f,
  7.28207678e-02f, -2.62671672e-02f, -1.02887310e-01f, 1.55008622e-02f, -5.74050546e-02f, 4.99559902e-02f, -4.81097475e-02f, -5.26782759e-02f, 4.04253826e-02f, 5.71800508e-02f,
  4.20075171e-02f, 1.57999489e-02f, -7.60768652e-02f, 7.28758499e-02f, -1.65411849e-02f, -2.11642701e-02f, 5.19492812e-02f, 5.03581278e-02f, 1.23530673e-02f, 4.17029075e-02f,
  -4.49109301e-02f, -4.07816144e-03f, 5.46990037e-02f, 4.11487930e-02f, -4.17741239e-02f, -2.23048348e-02f, -1.78480856e-02f, -1.17418326e-01f, 4.37726304e-02f, -1.35141939e-01f,
  1.94596231e-01f, -1.29091978e-01f, 6.82986677e-02f, 8.84566978e-02f, -5.74006438e-02f, 3.47752571e-02f, 8.01803023e-02f, -8.46451521e-03f, -6.73639029e-02f, 3.10450401e-02f,
  -4.99309599e-02f, 4.55247296e-04f, 8.53991657e-02f, -6.72954023e-02f, 5.51414005e-02f, 5.92315122e-02f, -6.80525303e-02f, -6.63372427e-02f, -7.03570247e-02f, 1.06787682e-01f,
  2.34819725e-02f, 1.62093304e-02f, -3.10641597e-03f, 6.12908751e-02f, 3.33273932e-02f, 1.02920994e-01f, -6.50497153e-02f, 6.82643577e-02f, 6.29422516e-02f, 1.53993398e-01f,
  -5.96475899e-02f, -1.79153144e-01f, 7.71689042e-02f, -3.72173041e-02f, -7.26610646e-02f, -1.66710764e-01f, -7.97758698e-02f, 1.14736231e-02f, -3.15722637e-02f, -1.41328454e-01f,
  -1.14149459e-01f, 1.75918359e-02f, -7.15774810e-03f, 4.71048765e-02f, 5.13498532e-03f, -5.92481233e-02f, -4.27904576e-02f, 7.43253902e-02f, -7.58458897e-02f, -3.15787680e-02f,
  -9.49483085e-03f, 6.27461746e-02f, 3.85616496e-02f, -5.99176176e-02f, -6.86535016e-02f, 3.97754982e-02f, -2.34125331e-02f, -5.58253098e-03f, -1.33827224e-01f, 1.33690871e-02f,
  4.04257812e-02f, -7.43281702e-03f, -2.69306116e-02f, -9.23675578e-03f, -3.52488109e-03f, 2.46736221e-02f, -9.98834819e-02f, 6.07933924e-02f, 5.01057506e-02f, -5.94226867e-02f,
  -2.59971265e-02f, -5.56251518e-02f, -9.13324431e-02f, -6.90519661e-02f, -8.17079321e-02f, -7.15340823e-02f, 2.55246516e-02f, 5.72013818e-02f, 4.10112031e-02f, -4.79963794e-02f,
  -1.10621937e-01f, -4.31566797e-02f, -9.51154798e-04f, -4.09573913e-02f, -5.58794141e-02f, -1.87684298e-02f, 4.71869260e-02f, -1.03446998e-01f, -8.26558024e-02f, -8.71376172e-02f,
  -1.58749763e-02f, 2.96696257e-02f, -6.55950457e-02f, -1.01245709e-01f, -1.10702634e-01f, -7.86547959e-02f, 6.99890405e-02f, 3.04680560e-02f, -8.56069177e-02f, -5.80783188e-02f,
  -2.95665078e-02f, 2.61057988e-02f, -2.73997895e-02f, -6.90178797e-02f, -6.22767583e-02f, -9.66293085e-03f, -5.79007417e-02f, 2.41072215e-02f, 1.95466951e-02f, -6.28839582e-02f,
  -1.15902126e-01f, -3.54546644e-02f, -3.03880032e-02f, 4.78640497e-02f, -6.59858957e-02f, -2.05269232e-02f, 6.40949830e-02f, 2.26982664e-02f, -8.54878873e-03f, 3.91311012e-02f,
  -1.94123704e-02f, 1.34830577e-02f, -3.79883908e-02f, -7.51750693e-02f, 8.78471285e-02f, -7.67820403e-02f, -6.57993555e-02f, -5.10362163e-02f, -6.86143339e-02f, -2.37396900e-02f,
  -1.14403881e-01f, -7.38992020e-02f, 3.96209583e-02f, -7.73661584e-02f, -8.53749886e-02f, -1.26805585e-02f, -1.26451492e-01f, 5.53009845e-02f, -9.14091319e-02f, -8.98714811e-02f,
  4.45609577e-02f, -1.19163051e-01f, -1.05858192e-01f, -9.54530109e-03f, -4.86683697e-02f, -9.17819738e-02f, -7.29462951e-02f, 2.42011771e-02f, -4.52669226e-02f, -2.12971326e-02f,
  1.69664137e-02f, 1.18788458e-01f, -8.33950192e-02f, 5.61860837e-02f, 3.31892483e-02f, -1.20103555e-02f, 1.68628842e-02f, -6.28154427e-02f, 3.93432453e-02f, 3.66641916e-02f,
  1.19851604e-01f, 1.63775846e-01f, -7.22468318e-03f, 5.75255044e-02f, -5.72483018e-02f, -3.41835879e-02f, -7.28658494e-03f, -9.97639075e-02f, -6.72060996e-02f, 4.53464091e-02f,
  -1.11832460e-02f, 2.68369541e-02f, 7.42886662e-02f, -1.33659616e-02f, -1.03333406e-03f, 4.88984101e-02f, 4.56490964e-02f, 5.94194792e-02f, 8.61386210e-02f, 9.08359811e-02f,
  1.90018900e-02f, 1.69053953e-02f, -1.04502374e-02f, 8.56262147e-02f, 5.57734892e-02f, 4.38388027e-02f, -1.90208340e-03f, 7.94457570e-02f, -1.27858520e-02f, -1.70100038e-03f,
  2.05155779e-02f, 4.06562239e-02f, 4.24084850e-02f, 6.45862222e-02f, -1.15386639e-02f, -1.54822478e-02f, -5.58270607e-03f, 3.99598554e-02f, -7.79260546e-02f, -5.62119484e-02f,
  9.44527760e-02f, 3.24151739e-02f, -7.42405653e-02f, -8.01433250e-02f, -7.73738325e-02f, 1.03495382e-01f, 9.43710580e-02f, 7.48441443e-02f, 1.07689962e-01f, 1.29332706e-01f,
  -3.24957026e-03f, -5.07930964e-02f, 5.02067618e-02f, 1.76394526e-02f, 8.90317932e-02f, 8.90175439e-03f, -1.05100885e-01f, 3.51956338e-02f, -6.81664571e-02f, -5.83103001e-02f,
  3.28655317e-02f, -3.21596041e-02f, 1.93558377e-03f, -9.11419652e-03f, 1.54109998e-02f, 7.19668437e-03f, 5.93724512e-02f, -6.54339567e-02f, -8.80586132e-02f, -3.54780257e-02f,
  -8.05733576e-02f, -6.53892532e-02f, -2.09308062e-02f, 4.59816307e-02f, -5.12898676e-02f, -1.90721583e-02f, -5.08227721e-02f, -6.55391216e-02f, -7.60697871e-02f, 1.29374349e-02f,
  -1.25055909e-02f, 1.65067669e-02f, 2.54321825e-02f, 2.67463624e-02f, 2.79301703e-02f, 2.80409753e-02f, -6.85261423e-03f, -3.07392124e-02f, -8.62581059e-02f, 3.48822512e-02f,
  -8.80645961e-02f, 1.90792643e-02f, 5.97903430e-02f, -4.37173620e-02f, -5.49549386e-02f, -1.94409229e-02f, 5.57932109e-02f, 2.89538037e-02f, -8.72753784e-02f, 4.37929258e-02f,
  7.69963302e-03f, 2.96432972e-02f, -1.17541067e-02f, -8.31388086e-02f, -7.56257400e-02f, 3.23672667e-02f, -6.15076870e-02f, -2.24362798e-02f, -5.81478812e-02f, -1.14885569e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  7.57727250e-02f, 1.88473955e-01f, 2.03386411e-01f, 1.86048687e-01f, 9.84719023e-02f, 1.94486856e-01f, -1.64173637e-02f, 1.55932337e-01f, 2.20477402e-01f, 8.66077319e-02f,
  1.02781236e-01f, 1.37795866e-01f, 3.79675180e-02f, 1.58990264e-01f, -1.02752994e-03f, 1.43047601e-01f, 4.54226397e-02f, -2.27756668e-02f, 6.23517111e-02f, -3.22646946e-02f,
  6.09867498e-02f, 1.39895501e-02f, 5.87687418e-02f, 2.40369797e-01f, -5.37070911e-03f, 1.73441052e-01f, 3.40340346e-01f, 3.98014300e-02f, 1.17683448e-01f, -1.02840690e-02f,
  -2.86278804e-03f, 2.43646465e-02f, 1.76959112e-01f, 2.52734512e-01f, 9.43853408e-02f, 1.97529748e-01f, 1.32419080e-01f, 1.89756006e-01f, 2.38734838e-02f, 5.49650081e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.86275095e-03f, -6.72688037e-02f, -1.47999963e-02f, -1.20507844e-01f, -3.57189514e-02f, 9.60012525e-02f, -2.92191021e-02f, -8.62520654e-03f, 3.33946943e-02f, 6.58957288e-02f,
  -2.34371394e-01f, -1.01567768e-01f, 2.16521263e-01f, 3.93075570e-02f, 4.74061929e-02f, 2.38028020e-01f, -1.69999748e-01f, -1.92108199e-01f, -3.05383117e-03f, 3.09746981e-01f,
  5.95449992e-02f, 1.82090744e-01f, -8.98042843e-02f, -9.34618711e-02f, 5.37825376e-02f, 2.16037899e-01f, -2.25595713e-01f, -8.77929628e-02f, -1.22331113e-01f, -8.02836940e-02f,
  1.52712047e-01f, 9.66464058e-02f, 4.08666730e-02f, 5.68527579e-02f, 1.89994834e-02f, -2.03251885e-03f, 8.20406079e-02f, -1.00935072e-01f, -1.00751162e-01f, -6.99183419e-02f,
  -7.35688880e-02f, -8.72721747e-02f, 1.00231573e-01f, -2.05986083e-01f, 5.63548431e-02f, 8.19287673e-02f, -1.20580634e-02f, -3.46866287e-02f, -8.69813096e-03f, -4.77646710e-04f,
  -2.07216546e-01f, 1.24662980e-01f, -9.06086043e-02f, -1.04096554e-01f, -1.99723383e-03f, -1.13801986e-01f, -3.94547321e-02f, 2.40004689e-01f, 3.70009765e-02f, 5.67911146e-03f,
  1.01523899e-01f, -1.50618870e-02f, -6.77024201e-02f, -8.25261697e-02f, 1.90884992e-02f, -8.38939622e-02f, -1.53420223e-02f, 3.07714771e-02f, 1.61520392e-02f, -1.88685298e-01f,
  -1.24874376e-01f, -4.56181094e-02f, 1.14247784e-01f, 1.41760185e-01f, 1.69069350e-01f, 1.20784566e-01f, -2.81426162e-01f, 7.45883733e-02f, -1.96665183e-01f, -3.71365666e-01f,
  7.46571571e-02f, 2.51129121e-01f, 6.16376810e-02f, -1.54585779e-01f, 1.76448137e-01f, -3.34229410e-01f, 1.17344834e-01f, -9.48544741e-02f, 3.49856354e-02f, -5.93027025e-02f,
  3.13542187e-01f, 6.47443831e-02f, 2.45191380e-01f, 2.07422778e-01f, -1.57112926e-01f, 1.11355290e-01f, 5.25995158e-02f, -7.91075602e-02f, -1.31567106e-01f, 8.60818103e-03f,
  -8.03361014e-02f, -1.62408739e-01f, 7.28518292e-02f, 1.27510414e-01f, 1.35265306e-01f, 2.17207819e-02f, 3.23614553e-02f, 1.27339616e-01f, -3.11365700e-03f, 1.57919392e-01f,
  -1.01350859e-01f, -4.31714766e-02f, 8.70482475e-02f, 1.89098060e-01f, 1.53541014e-01f, -1.12992391e-01f, 6.97217807e-02f, -7.43566081e-02f, 3.70320491e-03f, 4.80974242e-02f,
  -1.08980164e-01f, -1.94916964e-01f, 5.79721630e-02f, -1.90175638e-01f, 7.02601150e-02f, -1.27385035e-01f, -1.18264340e-01f, 4.36699204e-02f, -8.95632058e-02f, 4.87177931e-02f,
  2.18553901e-01f, -1.37458265e-01f, -1.33968234e-01f, -9.43227634e-02f, -5.25944419e-02f, -2.89705127e-01f, -1.12855732e-02f, 1.38974022e-02f, -1.03218935e-01f, 1.93414465e-02f,
  -2.45350506e-02f, -7.01617599e-02f, -1.03567109e-01f, 6.83206394e-02f, -1.56358987e-01f, -1.79574694e-02f, 2.60232538e-01f, 9.08000916e-02f, 1.24460272e-01f, -4.78695184e-02f,
  5.36279939e-02f, -1.86676264e-01f, 4.00175750e-02f, 1.79009289e-01f, -4.10377271e-02f, 9.87505838e-02f, 3.64761576e-02f, -1.57873388e-02f, 8.26285779e-02f, 1.86871156e-01f,
  -7.80866146e-02f, -6.73040049e-03f, -5.04660457e-02f, -1.43620089e-01f, -1.00805007e-01f, 3.32819410e-02f, 6.58105761e-02f, -1.41319968e-02f, -9.24843475e-02f, 5.29658720e-02f,
  7.07104057e-02f, -1.19893186e-01f, -6.70141205e-02f, 1.12380041e-02f, 2.78187133e-02f, 9.00466517e-02f, -1.31855324e-01f, -1.26441047e-01f, -1.11598074e-01f, 1.07498676e-01f,
  -1.13161266e-01f, -3.64586674e-02f, -1.06791988e-01f, -1.17564954e-01f, -1.41731933e-01f, 2.63663381e-01f, 1.97494924e-02f, 1.91055574e-02f, -1.21044684e-02f, -1.37960002e-01f,
  -8.08669068e-03f, 1.30661493e-02f, -4.27663065e-02f, 1.98368076e-02f, -9.16701928e-02f, -1.51790693e-01f, 1.21650264e-01f, 1.34203374e-01f, -7.68825691e-03f, 2.41766229e-01f,
  -2.98601016e-02f, -1.21237762e-01f, 8.18477124e-02f, -6.85281381e-02f, 1.72015607e-01f, 4.60573211e-02f, 8.55222642e-02f, 3.83958668e-02f, 8.14633071e-02f, -2.43186593e-01f,
  3.05952489e-01f, -2.74606973e-01f, -2.05786183e-01f, -9.45562683e-03f, 9.25096944e-02f, -1.14977751e-02f, -1.55007038e-02f, -1.65050216e-02f, -1.13981269e-01f, -2.97879875e-01f,
  2.10409075e-01f, 1.36466110e-02f, 9.69430730e-02f, -5.30888066e-02f, -1.22355223e-01f, -1.18698686e-01f, 1.16905190e-01f, -2.32643798e-01f, -1.86838806e-01f, -2.11854473e-01f,
  -1.02889217e-01f, -1.62538234e-02f, -1.73845757e-02f, 6.80572242e-02f, 1.49209946e-01f, -8.78676772e-02f, -1.59597158e-01f, -1.03164278e-03f, 6.71084300e-02f, 1.28708005e-01f,
  -6.63521467e-03f, 3.41618866e-01f, 1.79581568e-01f, -1.07501030e-01f, -9.63456705e-02f, 2.07939833e-01f, -1.26624320e-04f, 1.53885752e-01f, 1.09990828e-01f, -2.91026887e-02f,
  -1.04306996e-01f, -2.89264247e-02f, 4.01491561e-04f, -1.64072305e-01f, 4.73154932e-02f, 6.94025308e-02f, 1.39504343e-01f, 7.59657621e-02f, -2.05003261e-03f, -1.61043122e-01f,
  -5.63156493e-02f, 1.55059576e-01f, -9.04793516e-02f, -5.21193678e-03f, 1.47568554e-01f, -5.35471737e-02f, -2.14770377e-01f, 1.40329272e-01f, -1.40929207e-01f, 1.35086745e-01f,
  -5.41017093e-02f, -3.29284102e-01f, -7.63776302e-02f, 9.58570018e-02f, -2.35247806e-01f, -3.52636017e-02f, -2.05848277e-01f, 1.95060566e-01f, -5.72798178e-02f, 3.05592537e-01f,
  1.91603795e-01f, 2.22101018e-01f, 8.27078000e-02f, 3.66626531e-02f, 2.27743670e-01f, -3.58132087e-02f, 2.82165315e-02f, -2.78034151e-01f, -1.06044918e-01f, -6.00925833e-02f,
  3.08620315e-02f, -2.68202007e-01f, -8.13803896e-02f, -3.42484228e-02f, 1.61701202e-01f, -1.29111320e-01f, -2.45404821e-02f, 1.39582679e-01f, -1.04417251e-02f, -5.99755198e-02f,
  1.88116387e-01f, -6.82057664e-02f, 1.39321089e-01f, -7.43562877e-02f, 2.02583537e-01f, 2.35455319e-01f, -2.28006721e-01f, -2.59827413e-02f, 1.58979714e-01f, 5.62520735e-02f,
  9.88739431e-02f, -2.03361232e-02f, -3.83537225e-02f, -2.67747223e-01f, -3.86511646e-02f, 2.22127829e-02f, 1.27460375e-01f, 2.30599925e-01f, 9.73986015e-02f, 2.01161504e-01f,
  -8.39360431e-02f, 7.11995140e-02f, -1.97970003e-01f, 2.33922116e-02f, -4.66718785e-02f, 4.16360460e-02f, 1.23019904e-01f, -1.75149813e-01f, 4.03919406e-02f, -3.48935500e-02f,
  -2.66122609e-01f, -2.32348833e-02f, 8.66297409e-02f, 6.44067451e-02f, 9.30214822e-02f, 1.82566568e-02f, 4.33839522e-02f, -1.85901970e-01f, 3.08082134e-01f, 1.71477854e-01f,
  1.50249556e-01f, -2.39550248e-02f, -2.52666354e-01f, -4.41067815e-01f, -7.80316666e-02f, 2.01008990e-01f, -8.40460882e-02f, 2.33517960e-01f, -7.58489966e-02f, -6.64083287e-02f,
  3.24116647e-02f, -5.68424948e-02f, 2.42881432e-01f, 1.54592209e-02f, 2.30028643e-03f, 1.18619122e-01f, -1.58900917e-01f, -1.90214083e-01f, -9.98120978e-02f, -3.83497477e-02f,
  -8.79065394e-02f, 3.93410772e-02f, 8.52327123e-02f, 1.58986688e-01f, 4.37845709e-04f, -2.49247048e-02f, 2.04997912e-01f, 2.22260654e-01f, -7.27842823e-02f, 4.26907949e-02f,
  -2.84436159e-02f, -1.57741949e-01f, 1.58487242e-02f, 1.03266470e-01f, 4.40350249e-02f, -8.75362754e-02f, -5.75397387e-02f, -1.79139629e-01f, -1.41758293e-01f, 1.28504276e-01f,
  -6.21025190e-02f, -1.27369687e-01f, -3.93469855e-02f, -3.39733921e-02f, 7.15295523e-02f, -1.90582946e-02f, 8.92044827e-02f, -1.51985243e-01f, 2.40427610e-02f, 6.33069724e-02f,
  -5.98311536e-02f, 1.50316492e-01f, 4.45599332e-02f, 1.71855271e-01f, 1.98893361e-02f, -6.63910210e-02f, 4.89683673e-02f, 3.23176473e-01f, -1.52026385e-01f, -3.05053085e-01f,
  -1.91371202e-01f, 2.02897880e-02f, -1.09347880e-01f, 1.74944952e-01f, 1.20800368e-01f, -8.40566158e-02f, 3.85396004e-01f, -5.04864054e-03f, 6.47010803e-02f, -2.02477295e-02f,
  1.34696076e-02f, 2.35450156e-02f, 1.46511376e-01f, 6.15394525e-02f, -8.25458094e-02f, -1.17823100e-02f, -2.24861160e-01f, -9.77372080e-02f, -1.71050295e-01f, -4.80593666e-02f,
  -8.98718163e-02f, 7.06204623e-02f, 7.63469040e-02f, 1.95667967e-02f, -2.79280301e-02f, 9.60750282e-02f, 1.39169425e-01f, -5.27738333e-02f, -3.57603445e-03f, 6.56737685e-02f,
  -1.80261865e-01f, -2.07582951e-01f, 8.59454274e-02f, 5.90071678e-02f, -1.37247279e-01f, -2.22632922e-02f, 3.93503532e-02f, 3.14212926e-02f, 6.59878105e-02f, 1.16721645e-01f,
  -1.11007579e-01f, -3.83664444e-02f, 5.33424057e-02f, 3.58694382e-02f, 1.41905859e-01f, -1.23892426e-01f, -3.74257602e-02f, -4.96213548e-02f, 1.43948197e-01f, 1.46221608e-01f,
  -9.42049623e-02f, -1.29221603e-02f, 1.38710320e-01f, -3.52108851e-02f, -5.36908433e-02f, 1.68456495e-01f, -9.84239578e-03f, -1.83980599e-01f, -2.43697271e-01f, -1.23514421e-01f,
  1.15679838e-01f, -1.59757152e-01f, -8.91878549e-03f, 1.97430313e-01f, -1.10563256e-01f, -4.75934781e-02f, 4.29267474e-02f, 9.50152613e-03f, 2.14470271e-02f, -8.74814242e-02f,
  -1.32597804e-01f, -4.17320162e-01f, 4.94509563e-02f, 2.44359329e-01f, 1.35805517e-01f, 1.80988491e-01f, -5.67777865e-02f, 5.78073747e-02f, 1.26055002e-01f, -1.15973406e-01f,
  1.52960688e-01f, 1.46087945e-01f, -4.47814167e-03f, 1.37615293e-01f, -3.56435739e-02f, -1.83342189e-01f, -7.12470487e-02f, -1.31850377e-01f, -1.96467023e-02f, -5.67739606e-02f,
  5.29920533e-02f, 1.28175899e-01f, 5.81976259e-03f, 9.98443887e-02f, 1.98634222e-01f, 1.44684613e-01f, -1.47949323e-01f, -2.14354381e-01f, 2.15125874e-01f, -1.70916677e-01f,
  1.28256055e-02f, -3.44130560e-03f, -1.26776859e-01f, -3.33231986e-02f, 6.11712225e-02f, -5.35545647e-02f, -1.28853902e-01f, 4.68087904e-02f, 1.82310957e-02f, -5.74514754e-02f,
  -1.26806527e-01f, -2.98843440e-03f, 8.44501331e-02f, -5.80684515e-03f, 5.62269911e-02f, 1.16169296e-01f, 7.13083521e-02f, 5.98669983e-02f, -2.62006950e-02f, -1.29559278e-01f,
  -2.06367578e-03f, -1.16849966e-01f, 7.85240009e-02f, -7.00126821e-03f, -7.10452870e-02f, -4.15697433e-02f, 1.66263767e-02f, -1.33999899e-01f, -3.43601145e-02f, 2.01728661e-02f,
  -1.38633922e-01f, -9.15217698e-02f, -2.50331849e-01f, 1.11705221e-01f, -4.21642125e-01f, 4.88162518e-01f, 5.57156354e-02f, -9.11092684e-02f, -2.35860795e-02f, -2.06758082e-01f,
  -6.85732290e-02f, -1.61646813e-01f, 2.60232575e-02f, 3.70412208e-02f, 1.16890274e-01f, -1.00364931e-01f, -7.13625029e-02f, -2.66145244e-02f, 4.16333713e-02f, 1.69833109e-01f,
  -3.28146927e-02f, 2.11765673e-02f, -4.94281985e-02f, 1.40323574e-02f, -1.83031000e-02f, -3.63561740e-05f, 2.22866207e-01f, -1.64881468e-01f, 6.25933111e-02f, -3.18678953e-02f,
  3.15152481e-02f, 8.30934346e-02f, -9.20702368e-02f, -4.24386375e-02f, -2.05140337e-02f, 1.71993956e-01f, 5.24906330e-02f, -9.43071842e-02f, 2.65373319e-01f, 1.41427636e-01f,
  1.57790437e-01f, -8.18997845e-02f, 4.37045619e-02f, 1.56447545e-01f, -1.02516420e-01f, 6.79554641e-02f, 7.24626556e-02f, -1.24092892e-01f, -1.33452639e-02f, -4.44277972e-02f,
  6.87604770e-02f, 6.85870498e-02f, -8.86033997e-02f, -1.49237299e-02f, -5.35153039e-02f, 1.26515940e-01f, 6.35089055e-02f, -1.06307387e-01f, -2.84166813e-01f, 3.74976397e-02f,
  9.47903693e-02f, -2.76083976e-01f, 2.02875316e-01f, 3.28242213e-01f, -2.56421655e-01f, -1.60819963e-01f, 7.79023990e-02f, -1.97599888e-01f, 4.85102743e-01f, 5.48758768e-02f,
  -9.28000137e-02f, -1.99566394e-01f, 2.70775594e-02f, -9.77589786e-02f, 1.25978636e-02f, 2.12672129e-01f, -2.05876172e-01f, -1.05195187e-01f, -1.84308123e-02f, 7.35355541e-02f,
  1.85674918e-03f, 5.86232729e-02f, 1.88132674e-01f, 2.03999534e-01f, -9.01932344e-02f, -2.08724990e-01f, 2.10442413e-02f, -3.89677510e-02f, 1.13547191e-01f, 6.77925348e-02f,
  -7.71953017e-02f, -8.44781101e-02f, -1.85823813e-01f, -1.68953240e-01f, 1.71669737e-01f, 2.05555841e-01f, -1.73195809e-01f, -1.04115173e-01f, 5.78516833e-02f, -8.14581364e-02f,
  1.11913957e-01f, 1.19035326e-01f, 4.13490012e-02f, -9.04072374e-02f, 8.52488577e-02f, 9.36796889e-02f, 4.38144915e-02f, 1.58892468e-01f, -6.24967739e-02f, -1.29391253e-01f,
  -8.14471096e-02f, -1.65069923e-01f, -7.91618451e-02f, 4.11563404e-02f, 1.07348256e-01f, -1.10633731e-01f, 6.09685779e-02f, -1.64681867e-01f, -8.32046270e-02f, -2.63547841e-02f,
  -1.68259367e-01f, -1.54321017e-02f, -1.99038804e-01f, -1.34075075e-01f, 1.04077362e-01f, 2.01075897e-02f, 3.52715254e-01f, -1.00820884e-01f, 5.60958803e-01f, -3.20047200e-01f,
  2.16580808e-01f, -6.02034945e-03f, -2.75250729e-02f, 5.15622161e-02f, 2.50417553e-02f, -1.70485452e-01f, -1.44904824e-02f, -9.82963443e-02f, -2.03535527e-01f, -4.28974926e-02f,
  -1.84459258e-02f, 1.21163465e-01f, 1.95093364e-01f, 1.81397513e-01f, 1.12579353e-01f, 1.06830478e-01f, -1.53811604e-01f, -8.75458568e-02f, 8.07165578e-02f, 1.61862865e-01f,
  3.83154862e-02f, -1.35097116e-01f, 1.64562702e-01f, 1.24325015e-01f, 1.49598438e-02f, -4.83909585e-02f, 9.10065472e-02f, 1.58352658e-01f, -1.56725153e-01f, 3.73954251e-02f,
  -8.74860734e-02f, 1.10831097e-01f, -1.89329162e-01f, 1.94880530e-01f, 3.36059183e-02f, -2.71446761e-02f, 1.79250583e-01f, 2.89900929e-01f, 7.54345134e-02f, 9.60285068e-02f,
  -4.48375940e-02f, -1.05357237e-01f, -1.39792681e-01f, -8.68761819e-03f, 1.04975812e-01f, -2.47070640e-02f, 1.03371441e-01f, 3.48862484e-02f, -1.10435188e-01f, 8.72443020e-02f,
  2.36028284e-01f, -3.64504531e-02f, 1.59192994e-01f, -7.02198446e-02f, 7.41275549e-02f, -9.61921066e-02f, 4.76663381e-01f, 2.99053699e-01f, -6.04498573e-03f, 2.49613635e-02f,
  -2.84576237e-01f, -3.03378314e-01f, -9.91378259e-03f, 4.32678550e-01f, -8.28202218e-02f, 3.23019084e-03f, -2.24601422e-02f, -5.68462629e-03f, 6.79486059e-03f, 1.04319729e-01f,
  -1.32677620e-02f, 1.62334323e-01f, -6.84061795e-02f, -7.18581304e-02f, 1.43552229e-01f, 3.12941782e-02f, -2.09506050e-01f, -5.35781756e-02f, 1.01414829e-01f, 1.29451275e-01f,
  -1.58860475e-01f, -8.12341496e-02f, -2.43336931e-02f, -5.31615056e-02f, 8.18071514e-02f, -1.55239642e-01f, -2.72228420e-02f, -3.78057323e-02f, -6.49695843e-02f, 1.87961370e-01f,
  6.12443648e-02f, -4.37057912e-02f, -1.00455061e-01f, -3.03150397e-02f, 1.64403677e-01f, 1.41577302e-02f, 7.64259025e-02f, 1.12226680e-01f, -6.82958215e-02f, 1.28432766e-01f,
  -6.84572617e-04f, 1.08753167e-01f, -8.56848434e-02f, -1.19662292e-01f, 1.88986838e-01f, -4.60192503e-04f, 1.45627588e-01f, 1.14166938e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  8.20105523e-02f, 1.60292700e-01f, -1.12799266e-02f, -1.06769487e-01f, -2.66279355e-02f, -4.36891839e-02f, 4.67299717e-03f, 1.15678608e-01f, 8.01039934e-02f, -3.35544278e-03f,
  -6.32823333e-02f, 8.87974277e-02f, -2.76418477e-02f, -5.47730327e-02f, -2.55188327e-02f, -1.09472916e-01f, -1.85979735e-02f, -5.92237413e-02f, 9.15874764e-02f, -5.25063463e-02f,
  -2.31335592e-02f, -6.69202879e-02f, -1.88636214e-01f, -9.78126153e-02f, 1.52245507e-01f, 2.67830014e-01f, 1.23835586e-01f, 6.78023398e-02f, 1.46593407e-01f, -1.03279412e-01f,
  1.14874713e-01f, -1.12342974e-02f, 1.13744751e-01f, 2.47595869e-02f, -1.53436000e-02f, -1.65563419e-01f, -7.66872021e-04f, -1.79660395e-01f, 8.90718549e-02f, -3.76107581e-02f,
  -3.87203582e-02f, 1.11652642e-01f, 1.13893196e-01f, 1.15350537e-01f, -1.08713120e-01f, 8.87409747e-02f, 2.62046278e-01f, 2.17697531e-01f, -9.33090299e-02f, 1.56937540e-01f,
  -1.34395259e-02f, 5.74416295e-02f, 6.02203570e-02f, -9.78751853e-02f, -1.19998321e-01f, 6.85125887e-02f, -3.89593244e-02f, -6.21005073e-02f, 9.70469043e-03f, -3.55401225e-02f,
  -5.64394593e-02f, 6.96214363e-02f, -8.73038396e-02f, -3.82302701e-02f, 6.05193786e-02f, -1.30976345e-02f, -1.44803813e-02f, 1.76620260e-02f, 9.16962773e-02f, -9.87674370e-02f,
  -9.95492283e-03f, -2.84561049e-02f, -2.14181412e-02f, 7.99148679e-02f, -7.65444785e-02f, -4.71370341e-03f, -1.28060235e-02f, 9.67378542e-02f, 1.22974500e-01f, 8.53945538e-02f,
  -9.44389328e-02f, -1.99457765e-01f, 5.39052077e-02f, 2.43103579e-01f, 1.56300869e-02f, 1.87635079e-01f, -1.18921779e-01f, 1.01447731e-01f, -5.73702864e-02f, 2.44143620e-01f,
  6.37224736e-03f, 1.63800806e-01f, 9.07325819e-02f, 6.81549385e-02f, 1.17633596e-01f, 3.44724879e-02f, -8.38100687e-02f, -8.29094350e-02f, 4.03310545e-02f, 1.15331419e-01f,
  -1.32045478e-01f, 1.37914866e-01f, 1.17326938e-01f, -8.38151053e-02f, -7.79796541e-02f, -6.77108625e-03f, 3.98634039e-02f, -7.10338503e-02f, 1.39707401e-01f, 1.54608369e-01f,
  -8.14740211e-02f, -3.02878916e-02f, -7.89894685e-02f, -1.19330913e-01f, -7.74133578e-02f, 2.87793763e-02f, -7.84700215e-02f, 8.08817446e-02f, -5.75849637e-02f, -4.88927402e-02f,
  -4.25363481e-02f, 1.63184822e-01f, -1.12199299e-02f, 6.70797154e-02f, 5.75736444e-03f, 1.46793574e-01f, 1.49936661e-01f, 1.00869328e-01f, 8.82914364e-02f, 1.95641652e-01f,
  -1.27094127e-02f, 1.62771821e-01f, 2.50689656e-01f, -1.29385665e-01f, 2.30065048e-01f, -1.29980162e-01f, -1.33652519e-02f, 1.11318044e-01f, 2.17840523e-01f, 5.87291084e-02f,
  8.66808295e-02f, -1.37607500e-01f, -1.28473938e-01f, 1.55425012e-01f, -3.42231840e-02f, -5.90164736e-02f, 1.18509024e-01f, 4.18280631e-01f, 3.39459866e-01f, -6.70325831e-02f,
  5.02949059e-02f, -2.71297991e-01f, -6.31790282e-03f, 2.54919618e-01f, 1.33179221e-02f, 3.91042352e-01f, -9.79096889e-02f, 1.77158847e-01f, 1.75371841e-01f, 1.01976775e-01f,
  -1.99283972e-01f, -1.00217916e-01f, 1.60009861e-02f, 1.96194172e-01f, -2.58996841e-02f, 1.20235212e-01f, -1.11420140e-01f, -1.07210964e-01f, 2.42480665e-01f, -8.64987168e-03f,
  -9.24047455e-02f, 3.22188623e-02f, -1.02969475e-01f, 2.05553621e-01f, -1.99943230e-01f, 1.15507938e-01f, -1.51031002e-01f, -2.32912466e-01f, 8.77539739e-02f, 1.98978752e-01f,
  -1.21610053e-01f, 3.73051278e-02f, -9.95245054e-02f, -3.14353555e-02f, 5.62849864e-02f, 2.49528870e-01f, -2.64643393e-02f, 1.66201398e-01f, 4.21572849e-02f, 1.11274131e-01f,
  7.84269273e-02f, 1.28794372e-01f, 4.13674712e-02f, -1.08336501e-01f, 1.72658592e-01f, 1.33943195e-02f, 6.77949190e-02f, 2.80495062e-02f, 3.01619293e-03f, -1.92577895e-02f,
  6.75945804e-02f, 2.17769444e-01f, 5.43619357e-02f, 1.86600551e-01f, -1.17954969e-01f, 1.43434733e-01f, -1.40621871e-01f, -2.17844635e-01f, -8.83385539e-03f, 1.78353012e-01f,
  -9.41996798e-02f, -8.43218565e-02f, 1.58545867e-01f, -1.12506598e-01f, 3.74023914e-01f, -2.41978117e-03f, -5.27070165e-02f, 7.55239129e-02f, 1.94404408e-01f, -1.74897224e-01f,
  8.93665776e-02f, 1.60262689e-01f, 1.16155662e-01f, 7.41137415e-02f, -1.97507236e-02f, 5.01085259e-02f, 1.21684624e-02f, -1.31504893e-01f, 1.17066391e-01f, -3.73790376e-02f,
  1.12678058e-01f, -1.64182976e-01f, 3.44107524e-02f, -9.46697686e-03f, 1.61106989e-01f, -8.90262228e-08f, 8.28292668e-02f, -1.24710172e-01f, -9.19441283e-02f, 2.92173885e-02f,
  9.88084599e-02f, 2.29882821e-01f, -6.38904124e-02f, 1.29530430e-01f, -8.88741910e-02f, -7.82325193e-02f, 6.66057458e-03f, 1.10316306e-01f, -1.26035526e-01f, 2.85721011e-02f,
  2.52411962e-02f, -5.26903942e-02f, -5.78670315e-02f, 5.20632938e-02f, 3.19398567e-02f, -1.93186719e-02f, 9.20269191e-02f, 1.63632959e-01f, 3.38897020e-01f, 1.28622139e-02f,
  1.70449525e-01f, 2.62852967e-01f, 1.04773939e-01f, 2.41241664e-01f, 5.80009520e-02f, -5.30019253e-02f, 4.06793039e-03f, 2.21686766e-01f, -3.12712789e-01f, 1.53382152e-01f,
  1.08054765e-01f, -3.00419360e-01f, 1.91586614e-01f, 3.38865370e-01f, 1.57632902e-01f, -8.54936466e-02f, 3.96409035e-01f, -2.71777481e-01f, 5.42493343e-01f, -2.05452777e-02f,
  -2.03243438e-02f, -9.65025574e-02f, 9.69531536e-02f, 1.88315902e-02f, -1.75256521e-01f, 5.15574872e-01f, 5.51828509e-03f, 6.47297725e-02f, 9.93526950e-02f, -6.27302099e-03f,
  -8.13145936e-03f, -1.34580553e-01f, 1.09004259e-01f, 6.52135760e-02f, 1.70289904e-01f, -1.01690121e-01f, 1.75546736e-01f, 1.65326118e-01f, -4.33164164e-02f, 5.15049808e-02f,
  -1.80777892e-01f, 5.36003932e-02f, -1.28660455e-01f, 1.42007247e-01f, 5.25847562e-02f, -2.69372035e-02f, -2.52762139e-01f, -8.99597332e-02f, -1.51130438e-01f, 5.12807705e-02f,
  5.29024825e-02f, -1.15982972e-01f, -1.46404803e-01f, 1.68688037e-02f, -4.17831950e-02f, 1.44068569e-01f, 9.33037177e-02f, -1.19439378e-01f, -1.77814692e-01f, -1.18100569e-01f,
  -6.36414066e-02f, 1.31522670e-01f, -1.64282396e-01f, -1.25357762e-01f, 1.26335785e-01f, 3.85794044e-02f, 1.11342579e-01f, 1.04795672e-01f, 6.35734051e-02f, -1.74594313e-01f,
  -1.04853883e-02f, 4.05373685e-02f, 1.50683537e-01f, -8.12578946e-02f, 7.97964036e-02f, 1.35652587e-01f, 5.67992739e-02f, -1.47471055e-01f, 1.67673267e-02f, 9.29562747e-02f,
  3.36851999e-02f, -2.18158308e-02f, -1.39621615e-01f, -4.62586991e-02f, 3.14787999e-02f, 2.92826951e-01f, -1.29450649e-01f, 1.06562607e-01f, -8.23095292e-02f, 1.11472681e-01f,
  1.39689103e-01f, -8.88539702e-02f, 1.47466138e-01f, 3.12489290e-02f, 2.02081084e-01f, 1.13162138e-01f, -3.00159566e-02f, 2.61483807e-02f, -1.29906535e-01f, -2.95284465e-02f,
  1.56521685e-02f, 7.35035539e-02f, -3.90854627e-02f, -6.50751069e-02f, -1.71891507e-02f, -7.07084835e-02f, 1.96135685e-01f, 1.94787204e-01f, -2.42160656e-03f, 2.24055182e-02f,
  -1.52451262e-01f, 2.86482684e-02f, -8.74544084e-02f, 1.38979089e-02f, 6.78246692e-02f, -1.09644972e-01f, -3.63208503e-02f, 1.10983802e-03f, 2.30741352e-02f, 1.86437756e-01f,
  -1.41059086e-01f, 2.32784510e-01f, 1.81090981e-02f, -1.31333629e-02f, 1.52667403e-01f, -2.07715258e-02f, 1.08662784e-01f, -1.22991297e-02f, 1.82376251e-01f, -4.21841703e-02f,
  3.43028642e-02f, -3.47708203e-02f, 4.59541231e-02f, -4.54870500e-02f, -2.15278682e-03f, -1.03176087e-01f, 4.96574081e-02f, 9.05102678e-03f, -6.64349124e-02f, 5.07684462e-02f,
  -3.14232707e-02f, 8.96492749e-02f, -1.85826216e-02f, -7.41448775e-02f, 2.24438891e-01f, -1.38203755e-01f, 1.18258446e-01f, 1.27998246e-02f, 1.95436496e-02f, 1.07009172e-01f,
  1.47797078e-01f, 1.14076780e-02f, -1.37703672e-01f, 2.04001978e-01f, 1.05249844e-01f, 1.27106488e-01f, -1.31987939e-02f, -7.28105232e-02f, -1.08435273e-01f, -1.92849152e-02f,
  -1.03143878e-01f, 3.39704938e-02f, 4.51923274e-02f, -9.95266214e-02f, 1.58468530e-01f, 1.12071699e-02f, -3.73333250e-03f, -1.10303365e-01f, -1.25910759e-01f, -7.42375478e-02f,
  -5.68868257e-02f, 4.46794182e-02f, -1.16074912e-01f, -1.02032691e-01f, -1.03322640e-01f, -4.12325710e-02f, 1.44483671e-02f, 7.39356577e-02f, 2.79437751e-02f, -1.64040215e-02f,
  -6.39123321e-02f, 1.19224034e-01f, -6.00593984e-02f, 2.41395254e-02f, 1.11120142e-01f, -7.96072111e-02f, -7.24851042e-02f, -1.08462013e-01f, 1.82891265e-02f, 1.36827618e-01f,
  -7.15275705e-02f, -1.60241440e-01f, 4.79214452e-02f, -5.92906866e-03f, 1.88957244e-01f, 1.90546051e-01f, 8.26302245e-02f, 5.63097559e-02f, 2.77338084e-03f, 8.41126591e-02f,
  1.67991649e-02f, 1.61889151e-01f, -2.26830512e-01f, -2.08388194e-01f, -2.57181764e-01f, 7.51555264e-02f, -2.13311955e-01f, 5.83919361e-02f, -1.13982350e-01f, 1.00125276e-01f,
  3.75512056e-02f, 8.42996165e-02f, 1.32432699e-01f, 1.08968206e-01f, 1.96901247e-01f, -2.03945711e-02f, 2.20297396e-01f, -1.06757879e-01f, 5.17689064e-02f, 6.99634552e-02f,
  -8.19165260e-03f, -1.17986597e-01f, -7.20132962e-02f, -1.42371461e-01f, 1.91694908e-02f, -1.36878699e-01f, -5.36449216e-02f, 1.69053778e-01f, -2.61528092e-03f, 4.62933443e-02f,
  1.22767821e-01f, -1.30074948e-01f, -4.61737663e-02f, 1.13063999e-01f, 2.76894197e-02f, -5.03954850e-02f, -1.72999296e-02f, 1.00941114e-01f, -5.92580251e-02f, -6.85441718e-02f,
  8.34758282e-02f, 7.97133371e-02f, 4.97678556e-02f, -6.36908337e-02f, -1.58178080e-02f, 1.07279889e-01f, 1.35574460e-01f, -6.82058632e-02f, 1.69394717e-01f, -7.98365474e-02f,
  2.35555153e-02f, 7.15469792e-02f, -8.07646364e-02f, 1.11879501e-02f, -6.71380535e-02f, 1.53948754e-01f, -1.19728863e-01f, 6.75924495e-02f, 1.47136999e-02f, -6.33838624e-02f,
  -1.40217063e-03f, -3.56243700e-02f, 2.59888615e-03f, -4.41660173e-02f, 6.91235438e-02f, 1.43946454e-01f, 6.22887127e-02f, -6.70617819e-02f, -1.29497409e-01f, -8.70502144e-02f,
  -1.25412360e-01f, -7.90201426e-02f, 6.25346079e-02f, -8.37498903e-02f, 4.37165797e-02f, -1.84822790e-02f, 9.48764831e-02f, -9.03130323e-02f, -9.09762923e-04f, -3.27614918e-02f,
  8.95928815e-02f, -2.57930532e-02f, 4.13547680e-02f, 8.79180059e-03f, 1.46754026e-01f, -4.05132174e-02f, -5.46775684e-02f, 6.88084587e-02f, 9.09622610e-02f, 4.56190705e-02f,
  -1.10251084e-01f, -7.01753348e-02f, 9.56475511e-02f, 4.13666666e-02f, 1.11761369e-01f, -1.96751934e-02f, 4.87819593e-03f, -5.66029996e-02f, 5.50977066e-02f, 9.60176140e-02f,
  -6.72843680e-02f, -7.21116364e-02f, 1.31451502e-01f, 3.52277011e-02f, 1.05560765e-01f, -6.38300329e-02f, -2.07827855e-02f, 1.43336892e-01f, 1.17517680e-01f, -1.34659082e-01f,
  8.40698462e-03f, -6.40068948e-02f, 1.16668165e-01f, -1.26423106e-01f, -5.07956967e-02f, -1.69088822e-02f, 1.62367895e-01f, 2.77823389e-01f, 3.23209077e-01f, 2.94545501e-01f,
  2.00935856e-01f, 1.54294625e-01f, 1.37429342e-01f, 3.49161178e-01f, 3.98717016e-01f, 1.09251164e-01f, 1.66023269e-01f, 2.77170599e-01f, -1.85409468e-02f, 2.25775108e-01f,
  7.80604184e-02f, -1.00080505e-01f, -3.20664763e-01f, -1.15180947e-01f, -4.86768007e-01f, 7.29661956e-02f, -3.85793209e-01f, 2.63436794e-01f, -1.49577796e-01f, 4.13156301e-01f,
  8.82031545e-02f, -5.95108457e-02f, -5.55529669e-02f, -4.85221781e-02f, 2.65436113e-01f, -1.83980718e-01f, -9.61889103e-02f, -3.58333029e-02f, -8.67930800e-02f, -1.19438782e-01f,
  -2.50362512e-02f, -7.18327388e-02f, 7.03554600e-02f, -3.81576247e-03f, -1.56063944e-01f, 2.00201511e-01f, -1.00452527e-01f, -2.43639927e-02f, 6.03001751e-03f, -1.78836454e-02f,
  2.18037173e-01f, -5.20145483e-02f, 1.29903853e-01f, -1.59876421e-01f, 1.18247807e-01f, 7.16808736e-02f, 1.67023838e-01f, 1.22305728e-01f, 2.13763177e-01f, 7.06434995e-02f,
  1.38958991e-01f, 1.50198042e-01f, 1.94510743e-01f, 1.02984026e-01f, 1.92964554e-01f, -1.12168737e-01f, 4.63234186e-02f, 1.07875392e-01f, 1.49067178e-01f, 1.07124329e-01f,
  1.66333131e-02f, 7.49776959e-02f, 1.91934988e-01f, -3.41865681e-02f, -4.65642177e-02f, 2.15450600e-01f, 6.05208874e-02f, -1.74265355e-02f, 1.47388786e-01f, 3.79839018e-02f,
  1.26892209e-01f, 1.71550915e-01f, 3.02085094e-02f, 1.64244547e-01f, 1.29608095e-01f, -1.86037153e-01f, 6.51300624e-02f, -8.26843157e-02f, 5.34942970e-02f, 2.30339348e-01f,
  4.69436273e-02f, 6.43610135e-02f, -8.01713094e-02f, 2.96578765e-01f, -8.91993120e-02f, 2.03399837e-01f, -2.18753535e-02f, 1.42178312e-01f, -1.77958578e-01f, 1.17292538e-01f,
  3.25997919e-02f, -7.67859221e-02f, -1.36784822e-01f, 7.86843374e-02f, 1.23856463e-01f, -3.37406062e-02f, 3.56264934e-02f, 2.11534992e-01f, 1.85632363e-01f, -7.90188834e-02f,
  1.28684819e-01f, 2.02441961e-01f, 1.09687380e-01f, -5.51871322e-02f, 2.38069996e-01f, 1.42587535e-02f, -8.70574117e-02f, 5.82159087e-02f, -2.21045222e-02f, 7.92236024e-05f,
  -2.80904531e-01f, 2.53926851e-02f, 6.57564327e-02f, -7.94636980e-02f, 1.26045704e-01f, -8.33138451e-02f, 1.86958797e-02f, 7.55238980e-02f, -6.39600381e-02f, 3.74296345e-02f,
  7.77814612e-02f, 2.55221128e-01f, -8.83426517e-02f, 1.43125460e-01f, -8.00686777e-02f, 3.10827494e-02f, 9.79937315e-02f, -1.18889645e-01f, 1.25706613e-01f, 4.10912037e-02f,
  1.27565349e-03f, 8.00622404e-02f, -6.52903169e-02f, -1.53677374e-01f, -1.53768018e-01f, 1.04522347e-01f, -6.31036237e-02f, 1.51784912e-01f, 7.08328709e-02f, -7.79828876e-02f,
  1.32385194e-01f, 5.27283028e-02f, -1.43852765e-02f, -1.16995256e-02f, 3.08063664e-02f, -1.03282541e-01f, 8.97838473e-02f, -4.57014777e-02f, 3.13967355e-02f, -5.89908985e-03f,
  4.90025915e-02f, 7.03568384e-02f, -2.28866357e-02f, 5.41646741e-02f, -1.76358726e-02f, 1.35176376e-01f, 1.58665776e-02f, -5.59286699e-02f, -9.67695713e-02f, 3.28869186e-02f,
  -4.46697883e-02f, -3.37106958e-02f, 6.09395318e-02f, -4.69258688e-02f, -5.41282333e-02f, 7.83790741e-03f, -8.90670866e-02f, 9.56317037e-02f, -7.11400509e-02f, 3.82624380e-02f,
  9.57729388e-03f, 3.11355153e-03f, 5.02066351e-02f, -9.94488075e-02f, -1.38785345e-02f, 1.41283333e-01f, 3.31038539e-03f, -4.07625511e-02f, 1.25083685e-01f, -8.01255628e-02f,
  7.73512051e-02f, -1.02903089e-02f, -7.39358589e-02f, 3.08697857e-02f, -1.10935368e-01f, 1.07253090e-01f, -1.81376599e-02f, -1.14394076e-01f, 4.76099644e-03f, 3.92807126e-02f,
  -8.71392041e-02f, -4.59457561e-02f, -3.93711701e-02f, 1.95555491e-04f, 3.44055519e-02f, -1.08649895e-01f, -7.26212487e-02f, -1.09178133e-01f, -4.23285440e-02f, 2.20323607e-01f,
  -2.36693136e-02f, 2.24886090e-02f, -5.55277131e-02f, 1.39042929e-01f, 1.64248690e-01f, 3.33383642e-02f, 1.71073571e-01f, -2.62967885e-01f, -1.26857623e-01f, -1.27782524e-01f,
  -1.61440447e-02f, 3.01265959e-02f, 1.73454478e-01f, 6.77424669e-02f, 1.34011462e-01f, -1.03004053e-01f, 3.41977291e-02f, 2.94306614e-02f, -6.13744408e-02f, 4.31264825e-02f,
  1.74448252e-01f, 1.76594704e-01f, -3.32284123e-02f, 1.37181818e-01f, 1.63436923e-02f, -1.11644037e-01f, 8.45497772e-02f, 7.75357708e-02f, -7.80108869e-02f, -4.98019047e-02f,
  -3.50357685e-03f, 1.82718188e-02f, -7.95721859e-02f, -1.50973633e-01f, 2.00255662e-01f, 1.03605092e-01f, 6.07747063e-02f, 1.51802162e-02f, 1.25164852e-01f, 8.78524184e-02f,
  8.33606627e-03f, 9.47626159e-02f, 4.04021107e-02f, -1.39212385e-01f, 1.56749591e-01f, -1.14542648e-01f, -3.01917270e-02f, 1.46171361e-01f, -1.23791605e-01f, 6.83796257e-02f,
  1.19807431e-02f, -1.75192524e-02f, -1.01208314e-02f, 2.77876332e-02f, 5.06861927e-03f, -2.54914220e-02f, 4.56607193e-02f, -3.94528098e-02f, -3.90859284e-02f, 1.31320274e-02f,
  -3.68074849e-02f, 9.45052654e-02f, 1.48710623e-01f, 1.59739062e-01f, 4.56734821e-02f, 1.32851332e-01f, 1.13392761e-02f, -3.26696187e-02f, -8.63283575e-02f, -2.12048497e-02f,
  1.22203328e-01f, 6.22313991e-02f, 2.01099306e-01f, -1.35658486e-02f, 1.77118182e-01f, -1.13765068e-01f, 1.41594961e-01f, 2.63737947e-01f, 7.79111385e-02f, -4.03362736e-02f,
  -2.22197510e-02f, 1.75913319e-01f, -2.96402425e-02f, 1.03496365e-01f, -7.44295344e-02f, -6.29940182e-02f, 2.27949545e-02f, 3.12987641e-02f, -1.30861655e-01f, 6.45734146e-02f,
  -9.56251100e-02f, -4.51670103e-02f, -1.95192117e-02f, -2.45161075e-02f, 1.07914433e-01f, -5.55045940e-02f, 5.60937158e-04f, 1.81565195e-01f, 7.56287202e-02f, 7.41354004e-02f,
  -1.41256213e-01f, 1.60657585e-01f, 2.97958348e-02f, -4.28620614e-02f, 3.44572552e-02f, -7.07621574e-02f, -3.61370184e-02f, 1.27427524e-03f, -1.39872972e-02f, -1.15189984e-01f,
  -4.10137773e-02f, -5.14270589e-02f, 8.68535265e-02f, -1.15599185e-01f, 8.55884999e-02f, -3.98914744e-05f, -4.30022962e-02f, 9.03693661e-02f, -1.58629060e-01f, -1.41789792e-02f,
  7.86070302e-02f, -1.04376182e-01f, 1.32169858e-01f, 5.41894175e-02f, -2.97471997e-03f, 4.24804762e-02f, -5.96599989e-02f, 2.08570482e-03f, -9.62065905e-02f, -7.57514313e-02f,
  -8.40040743e-02f, 9.83628407e-02f, -2.06161104e-02f, 1.16774449e-02f, -1.18214250e-01f, -1.07801799e-03f, -1.54879205e-02f, -4.15731445e-02f, 1.57950092e-02f, -8.81749466e-02f,
  -8.64747539e-02f, 7.70913512e-02f, 8.23786855e-02f, 2.29347453e-01f, -7.98174459e-03f, 7.40093365e-02f, -6.36849776e-02f, 4.43025929e-04f, -9.89549533e-02f, 1.40356831e-02f,
  1.48276269e-01f, 2.85145156e-02f, 8.56428742e-02f, 2.59194691e-02f, -1.28311664e-01f, 1.42123839e-02f, -8.61340240e-02f, 1.03829749e-01f, -6.84485724e-03f, -8.48689899e-02f,
  -1.50127690e-02f, 7.38040209e-02f, -4.88260053e-02f, 1.08293250e-01f, -3.05099469e-02f, -2.06290454e-01f, -3.63172614e-03f, 1.33112520e-02f, 7.23676458e-02f, -1.49147287e-02f,
  -3.63262929e-02f, 1.08589724e-01f, -2.92695276e-02f, 2.99471021e-02f, -6.35983571e-02f, -7.52580911e-02f, -5.79642020e-02f, 5.76039813e-02f, -1.33646494e-02f, -4.10067216e-02f,
  3.58108655e-02f, 1.11621752e-01f, 2.21936151e-01f, 1.78300053e-01f, 1.13080472e-01f, 1.53726250e-01f, 6.43891767e-02f, 1.00499712e-01f, -9.44491650e-04f, 2.33018667e-01f,
  1.92426801e-01f, 2.01596454e-01f, 7.64983743e-02f, -8.33397806e-02f, 1.12935401e-01f, 2.97072053e-01f, 3.34881432e-02f, -6.16252124e-02f, 7.89633691e-02f, -2.96508729e-01f,
  4.65093181e-02f, 7.96194971e-02f, 3.02322097e-02f, -1.23870566e-01f, 1.51881754e-01f, -1.10570572e-01f, -2.51455214e-02f, -1.73364118e-01f, 2.49720871e-01f, -7.43759125e-02f,
  -9.66171846e-02f, 1.62737101e-01f, 1.45120740e-01f, -3.05610802e-02f, 1.12059630e-01f, -6.47631139e-02f, -3.05668917e-02f, -1.26010552e-01f, -3.45636196e-02f, 1.33274674e-01f,
  -1.47251710e-02f, -9.47085917e-02f, -4.12118882e-02f, 1.78032562e-01f, -3.83100100e-02f, 3.61034013e-02f, -1.71618015e-02f, 2.28801612e-02f, -1.08500920e-01f, 2.65798658e-01f,
  2.68781453e-01f, 1.09750152e-01f, -2.05487739e-02f, 1.25801582e-02f, 9.66935754e-02f, 1.67213932e-01f, 6.69249222e-02f, 9.84056219e-02f, -7.77793825e-02f, -9.49761719e-02f,
  -8.22034776e-02f, -1.05182514e-01f, 8.56248587e-02f, -5.77622876e-02f, -1.81414969e-02f, 1.59307137e-01f, -7.75369629e-02f, 4.94313128e-02f, 1.06851263e-02f, -8.33420306e-02f,
  5.78469187e-02f, 1.15540840e-01f, 8.74356851e-02f, -4.22973279e-03f, 4.49125320e-02f, -9.80139747e-02f, 3.98620144e-02f, -1.67480055e-02f, -2.49002893e-02f, 4.75523993e-02f,
  -1.22689093e-02f, 1.53034208e-02f, 6.09262139e-02f, 2.04874501e-02f, -1.19668484e-01f, -2.92255939e-03f, 4.09744382e-02f, 3.20633240e-02f, -3.53322364e-02f, 4.53061350e-02f,
  -6.28510043e-02f, 1.68895617e-01f, 4.66821343e-02f, -1.03878893e-03f, -1.30258650e-01f, -3.85150164e-02f, -8.53154287e-02f, 3.18365917e-02f, -9.55239534e-02f, 1.13065928e-01f,
  3.45490873e-02f, -7.68724903e-02f, -2.92554069e-02f, 1.31212935e-01f, 7.70982578e-02f, -7.63588995e-02f, -1.04309373e-01f, 7.60486200e-02f, 1.13852754e-01f, 3.80877815e-02f,
  6.51468113e-02f, 1.14628198e-02f, 1.49810491e-02f, -1.27992108e-01f, 1.41606659e-01f, -1.47361327e-02f, 8.94275960e-03f, -1.11664474e-01f, -5.69729246e-02f, 7.69394785e-02f,
  1.23973690e-01f, -7.47281313e-02f, -1.87142361e-02f, 6.47058785e-02f, 5.75751513e-02f, -4.34123762e-02f, -4.58065830e-02f, -4.99446876e-02f, -4.47256602e-02f, -1.46176042e-02f,
  -2.56138779e-02f, -5.50512224e-02f, -1.07529625e-01f, 6.83724508e-02f, 1.02700152e-01f, -9.73629430e-02f, 5.57454340e-02f, 5.66808283e-02f, 1.23344623e-02f, 5.19980444e-03f,
  6.53666109e-02f, 1.64137930e-01f, -2.62246169e-02f, 7.92305619e-02f, -3.67143676e-02f, -1.34753779e-01f, 1.41406789e-01f, 7.61570409e-02f, 1.70293879e-02f, 1.62529036e-01f,
  -6.97652549e-02f, 1.55777782e-01f, 3.18508558e-02f, 1.34311587e-01f, 1.49717972e-01f, -6.80196732e-02f, -7.78844953e-02f, 1.45205349e-01f, 1.45015912e-02f, -8.42039734e-02f,
  4.16959487e-02f, -1.25078121e-02f, -1.55657448e-03f, -1.15390614e-01f, 3.94306593e-02f, 7.22590974e-03f, 1.32959262e-01f, -6.89253286e-02f, -5.69911376e-02f, 7.48734623e-02f,
  -3.37578915e-02f, -1.41220629e-01f, 1.63705260e-01f, 1.28841817e-01f, 5.16030863e-02f, -5.23873270e-02f, -5.66292554e-02f, -7.40924291e-03f, -1.41970575e-01f, 1.32917553e-01f,
  -1.38661012e-01f, 2.55571380e-02f, -6.37274422e-03f, -4.25151214e-02f, -1.02665268e-01f, 1.56393975e-01f, -2.40768455e-02f, 1.30472332e-01f, 8.86982083e-02f, 1.68453991e-01f,
  -2.56118216e-02f, 5.22170886e-02f, 8.04371238e-02f, -4.56313789e-02f, -9.64153633e-02f, -8.64515156e-02f, 7.55744576e-02f, 3.08264419e-02f, -7.26764947e-02f, -2.16149446e-02f,
  3.66038200e-03f, 4.48657461e-02f, 7.35167712e-02f, -9.95674133e-02f, 8.43633786e-02f, -6.40305355e-02f, 8.44721571e-02f, -1.19086511e-01f, -9.51926783e-02f, -6.68970495e-02f,
  4.06770185e-02f, 6.61264136e-02f, -7.74639621e-02f, -1.48752615e-01f, -1.08949542e-02f, -1.01549655e-01f, -7.52877966e-02f, -5.25209978e-02f, -1.08161464e-01f, -1.22088090e-01f,
  -8.75304565e-02f, -1.76503379e-02f, 8.45772251e-02f, 1.25034302e-01f, -3.46667469e-02f, 5.30819073e-02f, 4.08420935e-02f, -6.97145462e-02f, -2.06570122e-02f, 1.32730464e-02f,
  -1.03487976e-01f, 9.63282064e-02f, 8.81649437e-04f, 7.56577700e-02f, -3.32372338e-02f, 8.80723968e-02f, 7.56556243e-02f, 1.11833841e-01f, -1.10427380e-01f, -1.11716926e-01f,
  -1.22690924e-01f, 2.74704844e-02f, 4.54373918e-02f, -9.17080641e-02f, -4.56021838e-02f, 8.09768513e-02f, -4.28567380e-02f, -7.14427307e-02f, -1.64074264e-02f, 1.12120427e-01f,
  -7.35678971e-02f, -1.29896939e-01f, -7.08932951e-02f, -5.90903200e-02f, -8.70214626e-02f, -2.59723910e-03f, 6.95187524e-02f, 1.15908484e-03f, 2.38198757e-01f, 2.40473494e-01f,
  8.96923169e-02f, 1.97898932e-02f, 1.07994705e-01f, -8.09475929e-02f, 9.12947953e-02f, 1.63605407e-01f, 1.36572659e-01f, -1.19083598e-02f, -1.36657551e-01f, -2.11972922e-01f,
  -9.39779729e-03f, -7.43076876e-02f, 2.62537569e-01f, 1.80206686e-01f, 9.85749066e-02f, -8.23587924e-03f, 3.24371397e-01f, -1.85655594e-01f, 1.16350032e-01f, -8.70230943e-02f,
  -1.14465207e-01f, -4.28857058e-02f, 1.73972622e-01f, 6.99925870e-02f, -1.98399410e-01f, 2.59929210e-01f, 6.48866743e-02f, 1.59559324e-01f, 1.28152251e-01f, 7.60865808e-02f,
  1.44149929e-01f, 1.76627591e-01f, 1.27565578e-01f, 5.43334670e-02f, 9.66529623e-02f, -9.47221294e-02f, 3.85039151e-02f, 4.57990058e-02f, 5.63795194e-02f, -8.73629302e-02f,
  5.06982543e-02f, -1.28548771e-01f, 5.57983760e-03f, 7.72362873e-02f, -1.39287353e-01f, -8.74283090e-02f, -8.16752166e-02f, -9.07405280e-03f, -3.04451622e-02f, -6.36594668e-02f,
  5.08262143e-02f, -4.96658720e-02f, -8.46966635e-03f, 1.65913954e-01f, 7.38771185e-02f, 7.34031498e-02f, -1.21960633e-01f, 1.62838921e-02f, -8.39705616e-02f, -4.41340692e-02f,
  -6.85631484e-02f, 1.03691563e-01f, -1.36846244e-01f, -2.32604356e-03f, 6.15196601e-02f, -7.08289593e-02f, 2.09736209e-02f, -6.37021661e-02f, -6.81758523e-02f, -3.77455428e-02f,
  -2.33555675e-01f, -8.53821449e-03f, 1.26138991e-02f, -7.11599439e-02f, -1.14397027e-01f, 1.26814499e-01f, -1.83607638e-01f, 8.81378204e-02f, 1.42554380e-02f, 5.45726046e-02f,
  6.50644768e-03f, -6.70174658e-02f, 6.70421794e-02f, 2.54375907e-03f, 5.80569021e-02f, 2.30496213e-01f, -6.58774823e-02f, 1.89334884e-01f, 3.97458300e-02f, -8.16307217e-02f,
  9.72346291e-02f, 1.56275518e-02f, 3.09444107e-02f, -5.71010411e-02f, -2.35679727e-02f, 3.02899554e-02f, -5.48271425e-02f, -1.67405799e-01f, -7.40268454e-03f, 4.75723408e-02f,
  -1.25411391e-01f, 3.68322209e-02f, -1.26942292e-01f, 7.53458366e-02f, 6.11430928e-02f, 6.85631856e-02f, 2.46718213e-01f, -2.60944813e-02f, -7.61082917e-02f, 4.50314842e-02f,
  3.25054564e-02f, 3.70529806e-03f, 1.16202541e-01f, -7.30575472e-02f, -8.09521303e-02f, 7.99990743e-02f, 3.02202790e-03f, 1.16938658e-01f, 3.14152166e-02f, 6.30515739e-02f,
  -3.64602692e-02f, 1.06558338e-01f, 1.28943726e-01f, 7.02347681e-02f, 1.55907303e-01f, 2.15228591e-02f, 9.40462798e-02f, 9.57670808e-02f, 7.91774224e-03f, 1.53841928e-01f,
  2.96373237e-02f, 1.32132441e-01f, 2.62484234e-02f, 3.61383334e-02f, 5.33634983e-02f, 1.95788309e-01f, 2.78373640e-02f, 2.75175162e-02f, 2.44322315e-01f, 1.44901007e-01f,
  -3.11091002e-02f, 1.55703515e-01f, -3.46246928e-01f, 2.82439552e-02f, -2.79410541e-01f, 1.19203940e-01f, -1.51766732e-01f, 2.01895148e-01f, -2.32687015e-02f, 2.75827408e-01f,
  -1.31917968e-01f, 1.03902251e-01f, -2.20510457e-02f, -5.34373000e-02f, 8.62147659e-02f, -2.08747745e-01f, 9.90448333e-03f, 4.73594889e-02f, 1.52064741e-01f, -3.43875438e-02f,
  3.17932703e-02f, 8.31384733e-02f, 1.06315911e-01f, -1.13805816e-01f, 5.86106777e-02f, 5.53504378e-02f, -6.72834069e-02f, -5.47810420e-02f, 1.85366735e-01f, -1.51253432e-01f,
  2.01011762e-01f, 1.38025165e-01f, 5.55579178e-03f, 1.97810456e-02f, -6.90720528e-02f, -5.45290671e-03f, 1.30332455e-01f, -1.34983227e-01f, 7.25436630e-03f, 1.34097159e-01f,
  -9.81515832e-03f, -1.34202734e-01f, 6.47415370e-02f, 2.54995137e-01f, -5.36708683e-02f, 3.61337602e-01f, 1.14377432e-01f, 1.00880876e-01f, 1.97048187e-02f, -2.48243697e-02f,
  -5.70554771e-02f, 7.84862414e-03f, 3.62546146e-02f, 4.14951295e-02f, 1.71420068e-01f, -3.05272609e-01f, -1.14221834e-01f, 1.71939671e-01f, 2.15665042e-01f, 1.46686900e-02f,
  2.06236206e-02f, -1.71003371e-01f, -5.75671420e-02f, 8.06127414e-02f, 4.47296612e-02f, 6.97692782e-02f, 2.56303221e-01f, 4.83313687e-02f, 2.24651843e-01f, 2.62580756e-02f,
  7.60772899e-02f, -2.17675939e-01f, -9.20503661e-02f, 2.02437237e-01f, 1.61930993e-01f, -7.02875853e-02f, -6.92265406e-02f, 9.50205773e-02f, -1.95473824e-02f, 1.43504232e-01f,
  9.02577713e-02f, -1.97488759e-02f, 3.17969620e-02f, 2.27569547e-02f, -9.72350314e-02f, -7.44848652e-03f, 4.53456640e-02f, 8.29843283e-02f, 8.47866833e-02f, -1.19985148e-01f,
  -7.35716894e-03f, 4.41714860e-02f, -2.46051024e-03f, 7.65438825e-02f, 8.18913132e-02f, 1.45690754e-01f, -8.24950710e-02f, -8.77438486e-02f, 5.12403920e-02f, 2.13202402e-01f,
  2.96204761e-02f, -4.71256189e-02f, -1.31228313e-01f, -1.08657308e-01f, 9.52970162e-02f, 2.22799197e-01f, -5.24320565e-02f, -6.44886643e-02f, -1.02567166e-01f, 1.64951067e-02f,
  8.81427377e-02f, 2.53377669e-02f, 1.15297489e-01f, 1.27266599e-02f, 1.94970757e-01f, 5.26017882e-02f, 1.79197669e-01f, 1.95348889e-01f, 1.25307947e-01f, 2.99189184e-02f,
  1.15351707e-01f, 3.66769060e-02f, 2.24478543e-01f, 4.22257707e-02f, 1.32366195e-01f, 1.58013538e-01f, -9.06452090e-02f, -1.48159325e-01f, -3.92549746e-02f, -7.48862028e-02f,
  2.31216811e-02f, 1.11223377e-01f, -1.00636847e-01f, 7.43604973e-02f, -1.24062255e-01f, 9.55536366e-02f, -7.94695839e-02f, -1.65341079e-01f, 1.30588025e-01f, -9.07594934e-02f,
  1.07700862e-01f, 1.00513920e-01f, 9.55406800e-02f, -9.48422104e-02f, -3.02220639e-02f, -3.93120125e-02f, -1.20171733e-01f, -6.01249374e-02f, -1.67509779e-01f, 1.00446887e-01f,
  1.00937933e-01f, -5.28103784e-02f, -3.32620330e-02f, 5.97286178e-03f, 7.47163445e-02f, -9.62551981e-02f, -1.24867363e-02f, 5.77359647e-02f, -7.69357458e-02f, 5.85886016e-02f,
  -7.13813603e-02f, 5.42779006e-02f, 8.48378316e-02f, 6.54587448e-02f, -7.92597458e-02f, 1.02950623e-02f, -1.56201068e-02f, -5.75044006e-02f, 1.32568702e-01f, -1.62569769e-02f,
  -3.75027210e-02f, -6.36784881e-02f, 1.46858513e-01f, 4.16251505e-03f, 1.03505060e-01f, -7.83824325e-02f, 2.03489751e-01f, 1.42140195e-01f, -5.48960716e-02f, -9.03141275e-02f,
  1.01737849e-01f, 9.07271653e-02f, 4.34672553e-03f, 2.01205909e-01f, 8.37380588e-02f, 9.37558636e-02f, 6.77210391e-02f, 1.89011514e-01f, -1.44627869e-01f, -2.33983286e-02f,
  -2.53623314e-02f, -1.25845253e-01f, -2.85902042e-02f, 9.08342525e-02f, -1.70463070e-01f, -1.38306111e-01f, -1.52254686e-01f, 2.08012164e-01f, -1.59344956e-01f, 1.38444483e-01f,
  1.31804973e-01f, -3.60263861e-03f, 2.02478826e-01f, 3.31107154e-02f, 2.20756903e-01f, 4.54387218e-02f, -7.28314072e-02f, -1.97155759e-01f, 3.09612621e-02f, 1.07033528e-01f,
  5.55578321e-02f, 2.30603907e-02f, -7.06665739e-02f, 1.30411442e-02f, -1.28001705e-01f, 6.01596758e-02f, -1.56963348e-01f, -1.21514089e-01f, 1.42455578e-01f, 1.03697680e-01f,
  1.05199348e-02f, -9.48494077e-02f, 2.42111042e-01f, 4.15982716e-02f, 1.65086076e-01f, 3.06351691e-01f, 2.43196532e-01f, -1.62589476e-01f, 2.67595798e-01f, 2.18579881e-02f,
  1.63453683e-01f, -3.02184299e-02f, -5.43869957e-02f, -1.79459155e-01f, -2.15438809e-02f, 1.52856722e-01f, -7.23134503e-02f, 2.31301174e-01f, 3.39673944e-02f, 3.70453820e-02f,
  -4.26203869e-02f, -5.78307286e-02f, -5.58684506e-02f, 8.54424685e-02f, -6.00477979e-02f, -1.04570776e-01f, 1.50361247e-02f, -1.26562238e-01f, 3.46296169e-02f, 4.08583768e-02f,
  1.05582669e-01f, -7.02761710e-02f, -7.04302490e-02f, -3.07081100e-02f, 2.05027256e-02f, -1.35949720e-03f, 1.19549096e-01f, -5.52168489e-03f, 8.98597538e-02f, -8.72539803e-02f,
  -9.51608494e-02f, -9.62008089e-02f, 7.84318224e-02f, -1.44770384e-01f, -9.50197503e-02f, 1.03430614e-01f, -4.63929810e-02f, 1.20167486e-01f, -8.59074667e-02f, -2.91134026e-02f,
  -8.72719288e-02f, 2.36166529e-02f, -5.17483354e-02f, -7.05371574e-02f, 2.41779089e-02f, 1.24898523e-01f, -1.43565051e-02f, -7.72641376e-02f, -5.68912178e-02f, 7.42017999e-02f,
  1.14235058e-01f, -1.21589005e-01f, 2.37244256e-02f, 6.16885722e-02f, 4.93822992e-02f, -8.65161046e-03f, -1.20826848e-01f, 5.68696111e-02f, -8.46326128e-02f, 2.73776855e-02f,
  1.17735252e-01f, -1.53814405e-02f, 1.02869026e-01f, -1.13950938e-01f, 1.72759425e-02f, -4.68412712e-02f, 1.33567117e-02f, -1.55650545e-02f, -9.65647846e-02f, 1.16128474e-01f,
  -1.27830073e-01f, 1.42127469e-01f, 3.04512847e-02f, 1.80587694e-02f, 1.16947621e-01f, 6.65304437e-02f, 1.29613757e-01f, -2.06951406e-02f, 1.56215116e-01f, 1.62619762e-02f,
  1.45713285e-01f, 2.27805033e-01f, 2.71766521e-02f, -6.05582120e-03f, -9.37528759e-02f, -5.36884367e-02f, 4.93838750e-02f, -1.27200738e-01f, 3.85713987e-02f, -9.36590955e-02f,
  9.62789580e-02f, -7.28286281e-02f, 1.53929949e-01f, -3.15455943e-02f, 2.62986183e-01f, -6.96579888e-02f, 8.08177516e-02f, -6.15646131e-02f, -9.20927897e-02f, 1.83219180e-01f,
  -3.42813730e-02f, 5.30380830e-02f, 8.92420262e-02f, 9.71486866e-02f, -5.32458611e-02f, 7.22179711e-02f, 9.78283957e-02f, 1.60077903e-02f, 1.70366690e-01f, -1.07086115e-01f,
  -7.92454928e-02f, 1.00100547e-01f, 4.35034335e-02f, -3.68043706e-02f, 1.83951966e-02f, 1.13733560e-01f, -8.96773860e-03f, -1.31662309e-01f, 1.13285229e-01f, -3.86400148e-02f,
  1.07791074e-01f, 5.79967089e-02f, -2.17128117e-02f, -1.51686985e-02f, -2.23741919e-01f, -5.20823747e-02f, -6.04789183e-02f, -4.25195880e-02f, -2.47897785e-02f, 1.09613789e-02f,
  -8.86200517e-02f, 1.95635527e-01f, 1.16176799e-01f, -4.85668369e-02f, -9.30230096e-02f, -2.04988495e-02f, -5.13590723e-02f, 4.86341789e-02f, 5.61584942e-02f, -1.39719499e-02f,
  3.46673787e-01f, -1.34669840e-01f, 1.67956371e-02f, 2.26622194e-01f, 1.39327154e-01f, 1.30570978e-01f, 2.41878793e-01f, 3.17599135e-03f, 3.41780446e-02f, 2.25822270e-01f,
  2.18500361e-01f, 3.98478687e-01f, 5.31387925e-02f, -6.80370033e-02f, 6.33544009e-03f, -4.13659550e-02f, 4.11526002e-02f, 1.95203781e-01f, -1.05609588e-01f, -9.81803536e-02f,
  2.87646681e-01f, 9.44108069e-02f, -2.13437341e-02f, 4.53432575e-02f, 5.16056456e-02f, -1.05525227e-02f, 4.17922661e-02f, 4.04486842e-02f, -3.62782218e-02f, -6.28027245e-02f,
  -5.40712178e-02f, -3.90183292e-02f, -1.10374540e-01f, -1.35757223e-01f, 2.74234936e-02f, 7.17220008e-02f, -7.53114074e-02f, -9.48798358e-02f, 7.96795636e-02f, 1.77636087e-01f,
  1.98033415e-02f, -1.05801240e-01f, -1.22978196e-01f, 1.41192949e-03f, -8.29613209e-02f, 1.23085499e-01f, 8.93382821e-03f, 2.45387152e-01f, 1.12892851e-01f, 8.75989497e-02f,
  -8.28525275e-02f, 9.24008638e-02f, 1.77373171e-01f, 1.05995007e-01f, -9.77469459e-02f, -6.45271093e-02f, 3.64791825e-02f, 5.04031517e-02f, -4.12649475e-02f, -1.79813746e-02f,
  1.26409590e-01f, 8.51860866e-02f, 1.35453060e-01f, 9.96936485e-02f, -5.59312850e-02f, 1.58425167e-01f, 2.15488523e-01f, -3.32146399e-02f, -3.83675583e-02f, 5.57262301e-02f,
  6.20995136e-03f, 1.93606839e-02f, -3.99030484e-02f, 1.39981970e-01f, -6.74552247e-02f, -3.17592591e-01f, 1.37583002e-01f, 2.09571049e-01f, 9.20801982e-02f, -3.07777827e-03f,
  -1.40517622e-01f, 7.61709660e-02f, -9.82685909e-02f, -1.71646476e-02f, -3.06033492e-01f, -1.91119850e-01f, -8.06699768e-02f, 1.32337317e-01f, 1.39931947e-01f, 1.40693337e-01f,
  -6.60692379e-02f, 7.26363361e-02f, 3.48295756e-02f, -1.22068793e-01f, -3.26198637e-02f, 1.45171642e-01f, -3.90418842e-02f, 1.51237562e-01f, -9.07514393e-02f, 3.35198529e-02f,
  -1.63570330e-01f, 1.34622544e-01f, -3.03504448e-02f, 5.95035553e-02f, -7.97084123e-02f, -4.81468961e-02f, -3.42141166e-02f, 3.77417803e-02f, -8.30305740e-03f, 2.01808184e-01f,
  -1.23616392e-02f, -1.56102851e-01f, 2.53437072e-01f, 1.14128768e-01f, 6.07079715e-02f, 1.66583002e-01f, -1.48540735e-01f, 7.48338997e-02f, 1.84977934e-01f, 9.28777605e-02f,
  -7.77597576e-02f, 1.94242999e-01f, 5.57846650e-02f, 1.71170503e-01f, 5.45537621e-02f, 1.15484223e-01f, -2.07496695e-02f, 2.27603018e-01f, 1.33021086e-01f, 2.52856374e-01f,
  1.06337912e-01f, 8.04852396e-02f, 6.05972148e-02f, -2.62358963e-01f, 1.28180653e-01f, 1.42014638e-01f, 6.34096190e-02f, 2.47130081e-01f, -1.14239879e-01f, -2.49244824e-01f,
  4.91427518e-02f, 3.00980091e-01f, 2.66730368e-01f, 1.29385563e-02f, 2.05723330e-01f, -9.30411741e-02f, 1.29955292e-01f, -8.27400163e-02f, 1.36087611e-01f, -3.13509077e-01f,
  5.68932556e-02f, -1.40916169e-01f, 2.97433645e-01f, 1.65338948e-01f, -2.77268533e-02f, 2.03488506e-02f, -6.65494986e-03f, 2.64526188e-01f, 2.95323074e-01f, 4.87270989e-02f,
  -1.06971242e-01f, 1.79768503e-01f, -6.43685833e-02f, -3.37717794e-02f, 7.57085904e-03f, 2.09431782e-01f, 3.98439765e-02f, -4.76032980e-02f, -1.90576799e-02f, 2.58925587e-01f,
  -1.30406439e-01f, -5.19437455e-02f, 1.72576666e-01f, 4.64103371e-02f, -3.40028778e-02f, 1.34933129e-01f, 3.76716495e-01f, 4.78073843e-02f, -9.25304275e-03f, -5.37878685e-02f,
  -1.04235202e-01f, -1.30796926e-02f, -3.83255556e-02f, -1.02455869e-01f, -9.27726030e-02f, -6.30493388e-02f, -5.90226389e-02f, -1.30194366e-01f, 1.43841267e-01f, -4.82264720e-02f,
  -7.68337324e-02f, -5.81549760e-03f, -1.33750111e-01f, -7.35569932e-03f, 2.07214002e-02f, 1.66509487e-02f, 3.69501300e-02f, 2.91414022e-01f, -2.51807319e-03f, -2.45137233e-02f,
  -1.68734640e-01f, 7.89438561e-02f, -8.13412666e-02f, 9.76564642e-03f, 8.74131396e-02f, -6.91223890e-02f, -8.42309073e-02f, 1.21374857e-02f, 7.73588270e-02f, -1.89605951e-01f,
  4.59571145e-02f, -1.46806415e-03f, -5.60348369e-02f, 2.08510086e-02f, 1.15220092e-01f, 2.50490695e-01f, 9.54269990e-02f, 7.38423169e-02f, -4.17408459e-02f, -3.27706337e-02f,
  1.05851978e-01f, -1.23357706e-01f, -4.36673686e-03f, 3.72595973e-02f, 8.89186934e-02f, 9.78682041e-02f, 1.52169019e-01f, -6.20457418e-02f, -5.78208528e-02f, 8.51600841e-02f,
  -1.43897936e-01f, -1.03636280e-01f, -1.16700217e-01f, 5.11738248e-02f, 5.09542003e-02f, -1.67234227e-01f, 1.71178341e-01f, 1.44681498e-01f, 1.90642457e-02f, -1.29616678e-01f,
  -1.33244410e-01f, -1.12122141e-01f, -6.41064048e-02f, 1.73133686e-02f, -1.23911656e-01f, 5.90529628e-02f, -3.62516865e-02f, -7.14820251e-02f, -1.13983750e-01f, 2.45623738e-02f,
  -1.53904125e-01f, 2.08977014e-01f, 2.47628335e-02f, -3.32887508e-02f, 2.52920121e-01f, 2.74211138e-01f, 2.94968426e-01f, 3.34515601e-01f, 2.69244939e-01f, 1.04377083e-01f,
  1.19670391e-01f, 3.77428055e-01f, 6.96086092e-03f, 2.39652187e-01f, 1.72352657e-01f, 1.09245606e-01f, -2.51921892e-01f, -1.84147894e-01f, 2.68253714e-01f, 2.10532844e-01f,
  2.16776773e-01f, 1.89718753e-01f, -5.91015406e-02f, -4.28205162e-01f, -4.66808304e-02f, -6.33903369e-02f, 3.53865214e-02f, 1.33676603e-01f, -1.00548781e-01f, -2.19763324e-01f,
  -1.03972539e-01f, -1.16351709e-01f, 5.10052964e-03f, 1.13288946e-01f, -1.65840209e-01f, -1.79282539e-02f, 8.19245055e-02f, 1.63618684e-01f, 6.68385848e-02f, 2.74097603e-02f,
  1.72529072e-01f, 1.57751501e-01f, 9.16588530e-02f, 8.42224993e-03f, -8.37011635e-02f, -1.34852007e-01f, 8.74491315e-03f, -4.73986268e-02f, -3.02927066e-02f, -1.05354249e-01f,
  1.19808026e-01f, 6.21311143e-02f, -9.08886641e-02f, 8.24836418e-02f, 4.89373282e-02f, -9.83863175e-02f, 8.17385875e-03f, -1.09520108e-02f, -1.32445410e-01f, 1.08934548e-02f,
  6.01306036e-02f, 2.35328376e-01f, -1.40673285e-02f, 6.71896935e-02f, -1.73745871e-01f, 1.81695935e-03f, 7.58366659e-02f, 6.46232534e-03f, 1.05214924e-01f, -4.08725627e-02f,
  6.19298443e-02f, -1.98602770e-02f, 1.19588740e-01f, 1.74664840e-01f, 1.38275936e-01f, 1.96760967e-01f, -2.48565804e-02f, 6.78455606e-02f, 2.37834781e-01f, 4.98633943e-02f,
  7.47353351e-03f, -1.79316953e-01f, -3.49355265e-02f, 1.45686015e-01f, 3.36196683e-02f, -5.24519570e-02f, -8.81462991e-02f, -1.41423479e-01f, -5.96077144e-02f, -8.01543370e-02f,
  4.42805402e-02f, 2.92201410e-03f, -3.93246077e-02f, -1.78275302e-01f, -1.29098758e-01f, -2.90345810e-02f, 1.48761943e-01f, -4.06168327e-02f, -1.03237651e-01f, 1.79259524e-01f,
  -6.02481999e-02f, 2.24341429e-03f, -2.13767029e-03f, 2.89798006e-02f, -4.15485399e-03f, 1.05399452e-02f, -6.27640560e-02f, 1.98816821e-01f, -9.93787944e-02f, -8.20946600e-03f,
  9.88118351e-02f, -1.22079648e-01f, 6.96562305e-02f, -8.13515261e-02f, -2.24636798e-03f, -8.02022815e-02f, 1.20767787e-01f, -9.85332653e-02f, 1.74717233e-01f, 5.22530787e-02f,
  -1.11640908e-01f, 2.22529471e-02f, -2.28429586e-02f, 6.63475841e-02f, 5.79598136e-02f, 2.69856513e-01f, 1.58388644e-01f, -1.49616152e-01f, 1.36866897e-01f, 4.23900038e-02f,
  1.23297043e-01f, -1.33597359e-01f, -1.99403428e-02f, 2.03160532e-02f, 1.68580323e-01f, -1.15731388e-01f, 8.15277323e-02f, -5.95711805e-02f, 2.07258344e-01f, 2.18976140e-01f,
  3.54512632e-02f, -3.00691929e-03f, -5.77132516e-02f, 5.71437143e-02f, 1.18902713e-01f, -2.22796034e-02f, 1.19879372e-01f, 2.53596783e-01f, -1.19336464e-01f, -2.94874489e-01f,
  4.19469783e-03f, -1.57392509e-02f, 9.81575698e-02f, 1.45258963e-01f, -1.77209005e-01f, 5.89844845e-02f, 5.66260852e-02f, -1.96840055e-03f, 5.92091382e-02f, 7.77787790e-02f,
  -1.68921531e-03f, -1.06528491e-01f, 4.30191569e-02f, 2.27343976e-01f, -1.40936226e-01f, 9.66918394e-02f, 2.58553913e-03f, 1.62103027e-01f, -6.73257932e-02f, 3.21638286e-02f,
  -1.06058463e-01f, 1.33366749e-01f, -4.40461151e-02f, -1.69865623e-01f, -1.06406048e-01f, -1.06213540e-01f, 1.52258977e-01f, -7.76548088e-02f, 1.50998086e-01f, 7.74412751e-02f,
  -8.18568021e-02f, -1.78246900e-01f, -6.65369704e-02f, 1.81124732e-02f, -1.54451251e-01f, 1.03334442e-01f, -1.01764826e-02f, 9.88791790e-03f, 1.64563596e-01f, 4.86459583e-01f,
  -7.06511885e-02f, -1.00829499e-02f, -5.83073497e-02f, 1.72937531e-02f, 1.23815358e-01f, -8.07295367e-02f, -3.51521969e-02f, -7.20521286e-02f, 2.37452369e-02f, -2.44227815e-02f,
  4.10691798e-02f, -2.69837328e-03f, 1.01848263e-02f, 3.04464586e-02f, 3.75039876e-02f, 2.31863391e-02f, 1.44469798e-01f, -5.71205541e-02f, 1.17614776e-01f, 9.10675004e-02f,
  -4.76625450e-02f, 1.69817582e-02f, -7.40576535e-02f, -1.02468766e-01f, 1.06545158e-01f, 8.27903226e-02f, 2.71295151e-03f, -5.46812490e-02f, 1.15135074e-01f, 1.53142273e-01f,
  -1.29569739e-01f, -3.42217423e-02f, 2.19465215e-02f, 5.38985059e-03f, -7.10908696e-02f, -7.26890713e-02f, -9.71049815e-02f, -1.13139977e-03f, 7.63177350e-02f, -9.97831393e-03f,
  1.32826060e-01f, -2.29310542e-02f, 6.11790381e-02f, 9.16358903e-02f, 1.37996271e-01f, 2.27794591e-02f, 1.26590624e-01f, 3.36194299e-02f, -1.11177295e-01f, -5.22022434e-02f,
  1.59778282e-01f, 1.44206658e-01f, 5.00445664e-02f, -3.36281508e-02f, 1.06699523e-02f, -1.17516309e-01f, -4.04247791e-02f, 1.17366225e-01f, -1.47953406e-01f, -5.21926284e-02f,
  1.15746729e-01f, 2.48012263e-02f, 1.45738907e-02f, 1.14827938e-01f, 1.07234202e-01f, 9.29336995e-02f, 1.43848598e-01f, -2.72827446e-02f, 4.40889448e-02f, -1.36273261e-02f,
  2.95364529e-01f, 1.78218529e-01f, -1.41289115e-01f, 9.80933383e-02f, 4.54134643e-02f, -9.06226318e-03f, 2.43699029e-01f, -4.74082626e-04f, 1.10419683e-01f, 4.56418470e-03f,
  6.84216991e-02f, 7.57517889e-02f, 4.88473773e-02f, 9.87520814e-02f, -3.90018553e-01f, -4.18435723e-01f, -1.51900485e-01f, 1.41772991e-02f, -2.41644070e-01f, 5.08802652e-01f,
  1.73296720e-01f, 1.15414493e-01f, -9.07250345e-02f, 2.10339323e-01f, -7.00680092e-02f, -5.20604402e-02f, 2.65780240e-01f, 4.35039669e-01f, 7.84619153e-02f, 1.67088509e-01f,
  5.43497466e-02f, -4.82483916e-02f, -2.13190973e-01f, -1.13403291e-01f, 1.72449518e-02f, 1.74562037e-01f, 7.24550262e-02f, 1.11336157e-01f, -6.75147250e-02f, 2.48136818e-02f,
  1.36163116e-01f, 3.90005149e-02f, 2.11488735e-02f, -1.35690480e-01f, 1.57066882e-01f, 2.51559436e-01f, -6.11572713e-02f, -9.84130800e-02f, 1.55665487e-01f, -2.38486096e-01f,
  -2.17224091e-01f, -9.23985094e-02f, 2.81817676e-03f, -3.56463119e-02f, 1.28613338e-01f, -1.22103617e-01f, 1.02525584e-01f, 1.65942892e-01f, 2.03773510e-02f, -3.81066240e-02f,
  1.89789683e-01f, -1.29512221e-01f, -3.60117550e-03f, 6.97770119e-02f, 1.43533602e-01f, -5.13751507e-02f, 1.07168863e-02f, 1.96980357e-01f, 2.05813706e-01f, 1.75950285e-02f,
  1.78816363e-01f, -1.09303638e-01f, 1.06051192e-01f, 1.42274201e-01f, 1.98190231e-04f, 6.68526161e-03f, -1.69008672e-01f, -2.82453001e-01f, -1.61450282e-02f, -2.48417202e-02f,
  2.09209427e-01f, 1.15693823e-01f, -1.50089085e-01f, -1.95465669e-01f, -3.34673487e-02f, 1.09911032e-01f, 2.38497239e-02f, 2.58492589e-01f, 1.00526989e-01f, -1.00753270e-01f,
  -8.36493373e-02f, 6.72614351e-02f, -1.36711844e-03f, -7.81864226e-02f, -6.75970539e-02f, 9.63334218e-02f, -5.89792132e-02f, 1.00777201e-01f, -1.79395787e-02f, 1.05161197e-01f,
  1.39668018e-01f, 1.96729362e-01f, 1.20748840e-01f, -4.17734571e-02f, -5.93146905e-02f, -1.30492583e-01f, -8.16472992e-02f, -7.03388229e-02f, 1.71930060e-01f, -1.69408828e-01f,
  -1.98599193e-02f, -2.56194714e-02f, 1.13068856e-01f, 4.19760123e-02f, -7.48776719e-02f, 1.50859341e-01f, 4.07618620e-02f, -9.48472228e-03f, -2.94859130e-02f, 6.29964098e-02f,
  1.08551368e-01f, 2.78966963e-01f, 7.06485286e-02f, 5.68858869e-02f, -1.53594777e-01f, 2.19972476e-01f, -1.20257728e-01f, 3.80508974e-02f, -1.27286855e-02f, 1.80242881e-01f,
  -2.27469638e-01f, 1.06298849e-02f, -6.34137914e-02f, 1.41003385e-01f, 8.00046790e-03f, 1.55652449e-01f, 1.38674855e-01f, -1.94586173e-01f, -6.44763112e-02f, 5.35253249e-02f,
  7.55439326e-02f, -1.34769902e-01f, 1.04686163e-01f, 8.34957510e-02f, 9.73171219e-02f, -1.00529501e-02f, -1.40528888e-01f, -9.09023955e-02f, -2.39106819e-01f, 6.41324967e-02f,
  -3.88688773e-01f, 1.54497451e-03f, 1.50863931e-01f, 1.79029703e-01f, 3.48598212e-01f, 2.99011935e-02f, 7.90920183e-02f, 1.51754856e-01f, 2.50277501e-02f, -2.16906853e-02f,
  2.37124220e-01f, 1.12630114e-01f, 1.08921304e-02f, 9.54568014e-03f, 3.07444166e-02f, -2.56429352e-02f, -2.74059922e-02f, 1.48820803e-01f, -7.75966570e-02f, -1.23197176e-01f,
  7.38628721e-03f, 7.98171014e-02f, 8.33526701e-02f, -1.71764627e-01f, 2.84732610e-01f, 1.07933149e-01f, 1.58999130e-01f, 2.33354539e-01f, 1.74631163e-01f, -1.75448701e-01f,
  1.75846010e-01f, 1.30753115e-01f, 2.11682520e-03f, -1.16707541e-01f, 2.33037218e-01f, -2.39907652e-01f, 1.50252338e-02f, 1.58758640e-01f, 3.84202115e-02f, 2.87139982e-01f,
  1.47236856e-02f, 7.66419023e-02f, 2.41489280e-02f, 9.01908651e-02f, -8.45042840e-02f, -8.97924751e-02f, -2.18646880e-02f, 4.45287041e-02f, -6.65627271e-02f, 8.05026814e-02f,
  9.96341407e-02f, 6.53852224e-02f, -3.25240120e-02f, 2.04756632e-02f, -6.25759587e-02f, -1.07857347e-01f, 1.16496086e-02f, 1.96624128e-03f, -5.10620996e-02f, -1.06623203e-01f,
  4.12590876e-02f, -1.01966910e-01f, -1.38980761e-01f, 9.99916196e-02f, -2.38100991e-01f, -8.35974738e-02f, 9.06029642e-02f, 2.42513210e-01f, -5.45100011e-02f, 1.88416436e-01f,
  1.74043044e-01f, -1.38907105e-01f, -3.56796645e-02f, -2.51077078e-02f, 1.44555852e-01f, 8.41323212e-02f, -4.39358577e-02f, 5.65807000e-02f, -1.14266925e-01f, -1.26043633e-01f,
  -5.93951717e-03f, 1.46387056e-01f, -1.37655303e-01f, 8.96721110e-02f, 1.38796344e-02f, -9.98765528e-02f, 4.35864851e-02f, 7.17071220e-02f, 2.31261984e-01f, 1.42176747e-01f,
  -3.50217074e-02f, 6.06963076e-02f, -3.56599465e-02f, -1.93172023e-01f, 1.84579208e-01f, -1.07183345e-02f, 5.12240343e-02f, -8.68041962e-02f, 1.50542527e-01f, -6.95286095e-02f,
  -8.08477681e-03f, -1.50819682e-02f, 6.05122894e-02f, 4.51185517e-02f, -4.32621650e-02f, -9.69840214e-02f, 1.34316429e-01f, 3.96005772e-02f, 1.68983221e-01f, 2.26190522e-01f,
  5.61558791e-02f, -5.15319034e-03f, 7.30899796e-02f, -6.03033938e-02f, 4.72868457e-02f, 1.14854481e-02f, 1.40711963e-01f, 1.20079115e-01f, 3.14587541e-02f, -2.50299484e-01f,
  1.66573510e-01f, 9.97337922e-02f, 1.14302255e-01f, 8.25366527e-02f, -1.49468258e-01f, -2.07588449e-01f, -6.95854500e-02f, 1.20812677e-01f, -3.84199657e-02f, 3.93593684e-02f,
  9.65021923e-02f, -3.93109955e-02f, 1.41907066e-01f, -1.13436334e-01f, -2.13964909e-01f, 8.99794772e-02f, -6.92741526e-03f, 1.47225142e-01f, 8.76350626e-02f, 1.59023598e-01f,
  5.08361533e-02f, -5.30499849e-04f, -9.82852001e-03f, 2.27908328e-01f, 1.24799512e-01f, -5.65825365e-02f, 1.72687341e-02f, 1.06896304e-01f, 1.19342268e-01f, -8.38786960e-02f,
  1.88000560e-01f, -1.22598894e-01f, -4.62398604e-02f, 1.20011456e-01f, 7.83653557e-02f, -1.26520380e-01f, -5.50207011e-02f, 8.49631950e-02f, 1.90583412e-02f, -4.56701219e-03f,
  3.56696770e-02f, 2.54408661e-02f, 1.62445217e-01f, 3.08286846e-01f, -7.34401941e-02f, 1.45037426e-02f, -6.84939921e-02f, 2.31750160e-01f, 7.67688006e-02f, -8.46785866e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  2.14208186e-01f, 1.71805322e-01f, 2.52201855e-01f, 1.02444574e-01f, 2.31851891e-01f, 1.71237141e-01f, 1.26297340e-01f, 9.11215842e-02f, 1.30889386e-01f, 1.51253566e-01f,
  1.32998824e-01f, 1.44964820e-02f, 8.29017386e-02f, 7.37658888e-02f, 9.05247107e-02f, 1.16811059e-01f, -7.87993297e-02f, 1.96674451e-01f, -9.27956700e-02f, 2.22356319e-01f,
  7.00637745e-03f, 1.31097004e-01f, 1.60915047e-01f, 7.17510134e-02f, 7.90049359e-02f, 5.92842512e-03f, 6.71021044e-02f, 2.71511197e-01f, 2.50599802e-01f, 8.52119103e-02f,
  -2.22883057e-02f, 2.39501104e-01f, 1.06286304e-02f, 1.42293081e-01f, -4.79479581e-02f, 2.00828552e-01f, 1.06494986e-01f, 1.90570638e-01f, 1.62060291e-01f, 1.46269500e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.69805586e-01f, -8.94235149e-02f, -6.99769333e-02f, 1.72838550e-02f, -2.70408750e-01f, -3.56344074e-01f, -1.80004641e-01f, -5.68352997e-01f, 1.96415987e-02f, -3.60866129e-01f,
  -5.04438393e-02f, -9.93741751e-02f, 1.67548269e-01f, -2.75889903e-01f, 1.25745699e-01f, 6.48775175e-02f, 1.38972387e-01f, 3.91817391e-01f, -8.52005407e-02f, 3.89279388e-02f,
  -9.88611206e-02f, -1.62997141e-01f, -7.60988891e-03f, 1.33614078e-01f, 3.41496944e-01f, 2.86412742e-02f, -1.51981995e-01f, -1.14487298e-01f, -1.55855909e-01f, 4.26692307e-01f,
  -1.41625971e-01f, 8.69221762e-02f, -1.87862609e-02f, 9.59124602e-03f, -4.99798656e-02f, 6.88602552e-02f, -9.68071818e-03f, -3.07747200e-02f, 1.96693882e-01f, -4.68050055e-02f,
  1.10122457e-01f, -1.82756502e-02f, -2.15125512e-02f, -1.26947850e-01f, 3.23601127e-01f, 3.23084474e-01f, -2.31473744e-01f, -2.96436846e-01f, 1.99761674e-01f, -8.36737975e-02f,
  2.45143577e-01f, -2.37618327e-01f, 2.13032603e-01f, -2.23476097e-01f, 4.08066392e-01f, -2.14868233e-01f, -3.47233713e-02f, 3.24348390e-01f, -1.95232660e-01f, -2.03179479e-01f,
  -1.90930560e-01f, 4.50208634e-01f, 4.45849180e-01f, -6.03573732e-02f, 4.62222937e-03f, -2.51743406e-01f, 7.17654601e-02f, 1.80185914e-01f, 2.16880873e-01f, 1.43161446e-01f,
  -4.15343821e-01f, -2.22414522e-03f, -7.51623362e-02f, 1.87597051e-01f, 9.53057334e-02f, 2.98002481e-01f, -1.32144541e-01f, -2.31087357e-01f, -3.38727772e-01f, 4.11770016e-01f,
  -5.10397740e-02f, 1.67306229e-01f, -2.19797134e-01f, 1.90337494e-01f, 4.19470996e-01f, -2.88497478e-01f, 7.74626374e-01f, -3.61885816e-01f, 1.67734057e-01f, -1.39129341e-01f,
  -4.10646439e-01f, -2.51413256e-01f, -2.88549393e-01f, 3.50655355e-02f, -9.14797410e-02f, -1.09376833e-01f, -1.20712496e-01f, -1.45180508e-01f, -1.36306658e-01f, -1.62597396e-03f,
  4.88564968e-01f, 1.06140021e-02f, -1.33312464e-01f, 2.67529488e-01f, 2.86426581e-03f, -1.05574541e-02f, -1.31441414e-01f, -1.62083074e-01f, -4.82676476e-02f, 1.32778242e-01f,
  9.07280296e-02f, -2.07808800e-02f, 3.38057309e-01f, 1.02832541e-01f, -2.73724675e-01f, -2.57872671e-01f, 2.87887335e-01f, 4.09471273e-01f, -2.79652011e-02f, 1.95486158e-01f,
  -4.72087525e-02f, -3.35657634e-02f, -2.15617642e-01f, -3.16590875e-01f, 1.18651830e-01f, 6.63462698e-01f, 1.62971780e-01f, 1.39231950e-01f, 3.94463927e-01f, 5.09746253e-01f,
  1.27950341e-01f, 1.42033115e-01f, 2.94465780e-01f, 1.58157572e-01f, 3.42435956e-01f, 8.42603222e-02f, 1.88533917e-01f, 9.28777456e-02f, -1.05159283e-01f, -3.17547619e-01f,
  1.55280447e-02f, 1.92714304e-01f, -1.68789789e-01f, 3.83380532e-01f, -1.90481305e-01f, 1.61282033e-01f, 1.65251836e-01f, 3.00095290e-01f, -3.66600215e-01f, -4.08934951e-01f,
  -5.69800138e-01f, 4.05071765e-01f, 3.18064950e-02f, -1.22327670e-01f, 3.69133875e-02f, -2.21891955e-01f, -4.07343477e-01f, -1.69319391e-01f, -1.18090967e-02f, -1.27905225e-02f,
  1.22669801e-01f, 4.32312012e-01f, -3.19250107e-01f, -9.71224084e-02f, -1.09334894e-01f, 1.40702903e-01f, -7.06086829e-02f, 4.84529972e-01f, 1.43065616e-01f, -1.70377493e-01f,
  6.18723745e-04f, -3.27304393e-01f, -7.39342496e-02f, -2.83435956e-02f, -1.11003734e-01f, 1.82209477e-01f, -9.06801224e-02f, 3.06936540e-02f, -1.13484196e-01f, 2.63400584e-01f,
  1.76352501e-01f, 2.03147620e-01f, -9.23081785e-02f, 1.94323748e-01f, 1.92795560e-01f, 6.16658255e-02f, -4.95442934e-02f, -4.37086821e-01f, -3.54948044e-01f, -3.56514938e-02f,
  9.23756510e-02f, -1.46148026e-01f, -6.75514564e-02f, 2.93770432e-01f, -7.77296722e-02f, 9.71031263e-02f, 3.24725866e-01f, -5.05058048e-03f, 7.67039731e-02f, 4.75607775e-02f,
  1.96309447e-01f, -1.67497918e-01f, 3.32891434e-01f, -3.50186862e-02f, 5.04067242e-01f, -4.75530446e-01f, 3.93372804e-01f, -1.02744564e-01f, -2.13562727e-01f, 5.03387213e-01f,
  -1.30710065e-01f, 2.92649597e-01f, -3.55261356e-01f, -4.98244613e-01f, 1.36106774e-01f, 2.15897754e-01f, 6.52752221e-02f, 2.69271344e-01f, 7.31528044e-01f, -1.30352853e-02f,
  -9.08979550e-02f, 1.83943778e-01f, 8.71644914e-02f, -2.49410376e-01f, -1.60542563e-01f, -5.77807903e-01f, 1.36535689e-01f, 4.35379706e-02f, -4.96539138e-02f, 2.11563662e-01f,
  9.02455449e-02f, 5.79589531e-02f, -4.93139178e-02f, 1.36238977e-01f, 1.04521275e-01f, 1.67884931e-01f, -6.64410293e-02f, -1.31065741e-01f, 4.16698694e-01f, -1.93668798e-01f,
  -3.95875841e-01f, 1.46829903e-01f, 2.03700438e-01f, -9.20653169e-04f, 1.94087610e-01f, -1.43658578e-01f, -9.12113935e-02f, -1.98954493e-01f, -1.94605321e-01f, 1.19929813e-01f,
  5.90747893e-02f, -2.13806052e-02f, -7.57255554e-02f, -3.64801526e-01f, 1.36786029e-02f, 4.55909260e-02f, -1.60057917e-01f, -2.49026150e-01f, 9.39680785e-02f, -2.18566418e-01f,
  -2.24103794e-01f, 2.42039949e-01f, 2.45338529e-01f, 3.67582351e-01f, 6.64301366e-02f, -2.65124798e-01f, -1.06470525e-01f, -3.89472932e-01f, 3.82903367e-01f, -5.20434618e-01f,
  3.41985315e-01f, -6.37615472e-02f, 2.88843155e-01f, -3.49633698e-03f, -9.19365883e-02f, -1.70429215e-01f, 3.69422585e-01f, -3.48897338e-01f, -2.67137587e-01f, -6.55991351e-03f,
  -7.59749636e-02f, 2.99170077e-01f, 5.42585179e-02f, 1.32274285e-01f, -1.81639627e-01f, 7.24853277e-02f, -8.55870619e-02f, 1.05403773e-01f, -2.81358603e-02f, 3.85962903e-01f,
  4.23541546e-01f, 9.51220617e-02f, -8.72973651e-02f, -2.26469580e-02f, -1.19859949e-01f, -2.29425013e-01f, -1.25111520e-01f, 3.78145039e-01f, -5.18255383e-02f, -2.72643995e-02f,
  8.76430720e-02f, 3.61440539e-01f, -8.00641626e-02f, -3.99036929e-02f, -1.69561386e-01f, -7.53196776e-02f, -1.99796796e-01f, 2.82934099e-01f, -1.43137677e-02f, -2.59567201e-01f,
  -2.43120149e-01f, -5.06129980e-01f, -1.54739842e-01f, 1.88346609e-01f, 1.51184812e-01f, 5.77081628e-02f, 3.14087979e-02f, 3.60121415e-03f, -2.06218362e-01f, 1.53391495e-01f,
  -4.87960614e-02f, 1.71990111e-01f, -1.93103880e-01f, -2.17615608e-02f, 1.54650137e-01f, -1.19685540e-02f, 2.29999408e-01f, 8.79854932e-02f, 2.50482932e-02f, 1.38852999e-01f,
  4.79338139e-01f, 3.01224470e-01f, -1.71093941e-01f, -1.18572243e-01f, -3.17266941e-01f, -3.53347838e-01f, 3.22266102e-01f, -4.61322218e-01f, -3.24376285e-01f, -1.40510276e-01f,
  3.20799470e-01f, 4.06035751e-01f, -2.55425304e-01f, -4.76776928e-01f, -1.82881773e-01f, -1.40109479e-01f, -1.66523784e-01f, -1.92747135e-02f, 1.32486090e-01f, -2.55961437e-02f,
  -1.32718193e-03f, -2.14250520e-01f, -2.74823569e-02f, 3.36492240e-01f, 2.58948982e-01f, -2.03889888e-02f, -5.10697849e-02f, -2.30118945e-01f, 6.02959730e-02f, -1.90973863e-01f,
  2.83221807e-02f, -4.20573503e-02f, -1.11316375e-01f, 1.66284129e-01f, -2.18076259e-01f, 5.05388260e-01f, -2.97015488e-01f, -1.31447941e-01f, 1.57781124e-01f, 1.20733231e-01f,
  -2.45487858e-02f, -1.84796855e-01f, 2.40520790e-01f, -2.37400025e-01f, 1.13494262e-01f, 4.88444597e-01f, -5.11861667e-02f, -3.39227051e-01f, -7.52830356e-02f, -1.94747254e-01f,
  3.43445301e-01f, 1.25633731e-01f, -3.98640521e-02f, 3.14279169e-01f, -9.25641209e-02f, -5.47007322e-01f, -5.57185188e-02f, -7.98614398e-02f, -3.87844145e-01f, -4.35308009e-01f,
  -4.11573380e-01f, 9.40934569e-02f, -5.47562912e-03f, -2.87508041e-01f, -2.02599391e-01f, 3.07500184e-01f, -2.89131522e-01f, 2.88043469e-01f, -1.29674166e-01f, 3.81607056e-01f,
  3.00431550e-01f, -3.15421760e-01f, 1.86698988e-01f, -4.16100234e-01f, -1.70474257e-02f, 6.13429964e-01f, -3.76908362e-01f, -6.39169365e-02f, 3.62157971e-02f, -2.30824009e-01f,
  -4.63160634e-01f, 3.35994899e-01f, 1.16154121e-03f, -2.67003298e-01f, -3.92998271e-02f, 4.13951337e-01f, 7.81358108e-02f, 3.62338364e-01f, -2.82876700e-01f, -1.37449298e-02f,
  -5.75463064e-02f, 6.82829022e-02f, -1.49951488e-01f, 1.28403738e-01f, -1.16432577e-01f, -1.61062002e-01f, 1.01641737e-01f, -3.12149167e-01f, -1.46045491e-01f, -1.20663233e-01f,
  -1.71773374e-01f, 1.31425783e-01f, 4.26793754e-01f, 1.36132929e-02f, -1.58634752e-01f, 3.26794028e-01f, -3.60761374e-01f, -2.54255474e-01f, -1.44135863e-01f, -1.27130598e-01f,
  1.25820249e-01f, -2.03797579e-01f, -3.93662453e-02f, 4.62514907e-03f, -1.06821097e-01f, 3.11278598e-03f, -6.08269870e-02f, -2.86873162e-01f, -1.23281226e-01f, -2.23394692e-01f,
  -5.96079864e-02f, -2.09225580e-01f, -8.04650635e-02f, 6.35719523e-02f, -6.78553879e-02f, -3.74677360e-01f, -3.58959705e-01f, -1.25225559e-01f, -1.64728492e-01f, 2.87850434e-03f,
  -2.65028387e-01f, 5.04673980e-02f, -6.75296504e-03f, -3.74307811e-01f, -2.41618022e-01f, -1.74493212e-02f, 2.94261068e-01f, 2.47878566e-01f, -2.96199203e-01f, 2.53158629e-01f,
  -2.73484766e-01f, 2.30143055e-01f, -1.79419249e-01f, -4.13102210e-02f, 5.22433996e-01f, -6.74958974e-02f, 1.69814304e-01f, -4.62003388e-02f, 2.75828749e-01f, -6.30804002e-02f,
  1.42172549e-03f, -4.71359134e-01f, -1.73264980e-01f, 9.54977125e-02f, 8.40530992e-02f, 1.03922807e-01f, 2.39578977e-01f, -2.33799204e-01f, 8.46717432e-02f, -1.56199232e-01f,
  3.04992665e-02f, 1.93122655e-01f, 1.18837833e-01f, -2.35597387e-01f, 1.81412131e-01f, -8.18850622e-02f, -1.89650282e-01f, 1.82579756e-01f, -1.81936637e-01f, -2.11740091e-01f,
  2.51619458e-01f, 2.85891861e-01f, -7.12388679e-02f, -3.07129025e-01f, -4.91212383e-02f, 2.16024052e-02f, -2.68196743e-02f, 5.83104193e-01f, -3.70203443e-02f, 4.21791635e-02f,
  -3.36679928e-02f, -7.53972009e-02f, 4.13896888e-02f, -6.38899878e-02f, 1.84967425e-02f, -7.49701858e-02f, 6.25732020e-02f, -2.98785679e-02f, 1.35531470e-01f, 1.16946086e-01f,
  4.93686721e-02f, 2.46687364e-02f, -1.08471895e-02f, -1.61037013e-01f, -1.51995853e-01f, 3.83206755e-01f, 3.51664662e-01f, -2.81891614e-01f, -5.54299235e-01f, 5.31979240e-02f,
  -1.94728538e-01f, -1.32135540e-01f, -8.02423209e-02f, 2.95804620e-01f, 4.66566324e-01f, -4.88084286e-01f, 1.04792744e-01f, -2.61390448e-01f, -1.17699958e-01f, 2.86732942e-01f,
  4.57802474e-01f, -2.27922574e-01f, 7.84866661e-02f, -1.72906652e-01f, 5.11536300e-02f, -4.26696032e-01f, -2.17672110e-01f, 4.96960282e-02f, 1.60742521e-01f, -8.23080465e-02f,
  3.75649072e-02f, 2.71729499e-01f, -6.49501830e-02f, -1.38316482e-01f, -2.49146228e-03f, 4.88219380e-01f, 2.68789250e-02f, -3.92840058e-01f, 2.15786457e-01f, -1.09378643e-01f,
  -1.96566254e-01f, 6.40322268e-02f, 8.44594911e-02f, -1.60376325e-01f, -1.99838847e-01f, 6.30689025e-01f, -3.01876534e-02f, 2.26441681e-01f, 5.51113598e-02f, -2.08260551e-01f,
  1.07602514e-01f, -2.78804064e-01f, 1.00875236e-01f, -2.56415844e-01f, -1.21796705e-01f, 1.68099836e-01f, 3.32147956e-01f, 2.36961380e-01f, 1.14062756e-01f, 7.43758902e-02f,
  -3.02082360e-01f, 1.08402461e-01f, -5.41983470e-02f, 1.08310908e-01f, 7.30263367e-02f, 5.11440277e-01f, -3.04614305e-01f, -1.44196719e-01f, 2.02270150e-02f, 5.01101494e-01f,
  -7.05590239e-03f, -2.32185125e-01f, 5.23698509e-01f, -5.94063513e-02f, 4.10184085e-01f, -1.21982925e-01f, 3.06928873e-01f, -2.35346168e-01f, -3.50823909e-01f, 2.13849247e-01f,
  1.73927739e-01f, 4.33166586e-02f, -3.80246677e-02f, -2.53230214e-01f, -4.30016577e-01f, -3.27633977e-01f, -1.32681295e-01f, 3.44510972e-01f, 5.51895909e-02f, 4.29066867e-01f,
  1.96191743e-01f, -1.86641753e-01f, -1.35849208e-01f, -1.97338071e-02f, 5.63537329e-02f, -3.24939400e-01f, 2.56839506e-02f, -1.57847637e-04f, 2.76577566e-02f, -2.83795357e-01f,
  -4.03891578e-02f, -2.58535575e-02f, -1.39101595e-01f, 2.61770844e-01f, 2.02375725e-01f, -1.19706012e-01f, 3.92807066e-04f, -1.49822429e-01f, -9.46454629e-02f, -3.13757688e-01f,
  -1.82210594e-01f, -4.86986816e-01f, -1.33404776e-01f, -1.61123812e-01f, 8.23146626e-02f, 8.10772181e-01f, -2.30655298e-01f, 6.40531480e-02f, 2.31084377e-01f, -3.12443644e-01f,
  3.42050046e-02f, -4.80725877e-02f, 4.87747341e-02f, -9.25046578e-02f, -7.31090084e-02f, -3.87535751e-01f, -1.46583900e-01f, -7.62864128e-02f, -2.00030595e-01f, 1.07633345e-01f,
  3.77702005e-02f, 6.91483095e-02f, 3.32878083e-01f, -3.85698915e-01f, 5.41011170e-02f, 3.26644890e-02f, -6.46355033e-01f, -3.05686086e-01f, -2.45625488e-02f, -2.57972211e-01f,
  2.31480181e-01f, -2.03874767e-01f, 3.74028862e-01f, 1.77337918e-02f, -3.24350119e-01f, -8.53591040e-03f, 2.15635020e-02f, -9.96226594e-02f, -8.84501040e-02f, -2.13540256e-01f,
  7.02717900e-02f, 3.98319401e-03f, -1.44188985e-01f, 2.73648560e-01f, 5.23570776e-02f, 1.00465566e-02f, -2.12119728e-01f, -1.93691343e-01f, 4.62022126e-02f, 1.52250350e-01f,
  8.46633967e-03f, -3.22863646e-02f, 1.50095969e-02f, 1.79035529e-01f, -7.48313069e-02f, -3.22542280e-01f, 3.99815924e-02f, 1.14411235e-01f, -3.15462172e-01f, -1.08988650e-01f,
  2.01264098e-01f, -1.33219242e-01f, 5.06094582e-02f, -2.23019853e-01f, -6.71435967e-02f, 3.65246803e-01f, 4.62294430e-01f, 5.65998018e-01f, 1.82358146e-01f, 1.23970993e-01f,
  3.34172994e-01f, -3.23756695e-01f, -4.89537753e-02f, 3.17191303e-01f, 1.81916192e-01f, -5.71739897e-02f, 1.09351940e-01f, 1.14813708e-01f, 1.96186200e-01f, 9.73055735e-02f,
  -1.95728481e-01f, -1.30460830e-02f, 1.21746836e-02f, -2.22745594e-02f, 4.73494560e-01f, 2.85576075e-01f, -1.67363614e-01f, 3.08743238e-01f, 2.59289574e-02f, 3.26046139e-01f,
  2.39559248e-01f, -4.15729918e-02f, 4.59706455e-01f, -8.98425058e-02f, -3.20671499e-01f, 2.28916913e-01f, -7.02857878e-03f, 1.12522664e-02f, 1.30952910e-01f, -8.61662105e-02f,
  -1.60345465e-01f, 3.54148477e-01f, 9.33498204e-01f, -8.43740255e-02f, 2.67091125e-01f, -7.73646086e-02f, -1.24677829e-01f, -3.69244218e-01f, 2.31779948e-01f, 2.25653574e-01f,
  8.02880377e-02f, 2.54797071e-01f, -1.21220782e-01f, -1.32434323e-01f, -1.56172320e-01f, 1.33919552e-01f, 8.37904662e-02f, 1.37703016e-01f, -5.33689931e-02f, -1.31100386e-01f,
  -8.52067322e-02f, 2.11784899e-01f, -1.92649812e-01f, -1.14696354e-01f, 2.56395608e-01f, 4.19161677e-01f, -3.63654792e-01f, -2.01806828e-01f, 8.27872902e-02f, 1.27872406e-02f,
  -1.88639164e-01f, -4.91908267e-02f, 7.88716674e-02f, 4.03396748e-02f, -2.19092965e-01f, -1.96973339e-01f, -1.84140593e-01f, -1.63257733e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -8.59278888e-02f, -6.66041300e-02f, 1.37012437e-01f, 3.88957444e-03f, 9.51206908e-02f, -7.60834217e-02f, 6.72245249e-02f, -1.27283275e-01f, -1.35745496e-01f, 1.46709949e-01f,
  -1.28307760e-01f, -7.16429204e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    