/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.17675352e-01f, 1.83194622e-01f, -4.30834383e-01f, -5.62286787e-02f, -7.74821937e-02f, -2.58234620e-01f, -2.92509019e-01f, -2.10967362e-01f, 6.10835142e-02f, -5.46238907e-02f,
  3.45116615e-01f, 3.11741889e-01f, 1.85662314e-01f, 4.15657572e-02f, -8.62705708e-02f, -1.23535663e-01f, -2.46336356e-01f, -1.17461994e-01f, -1.72085017e-01f, -7.66730383e-02f,
  8.25552940e-02f, -3.23787071e-02f, 6.73129363e-03f, -1.63441636e-02f, -1.17786927e-02f, 1.71091869e-01f, -3.68715543e-03f, 8.99893884e-03f, 7.01950118e-02f, -2.70219058e-01f,
  -1.18312061e-01f, -1.97575659e-01f, -4.07980420e-02f, 1.10385880e-01f, 6.77003432e-03f, 1.02810962e-02f, -3.88031378e-02f, -5.95423654e-02f, 1.03788063e-01f, -5.24230637e-02f,
  5.52883856e-02f, 8.54577422e-02f, -1.92897599e-02f, -5.49456365e-02f, -5.74994758e-02f, -3.88847142e-02f, 4.41053659e-02f, -1.58714339e-01f, -1.01272024e-01f, -9.46702063e-03f,
  7.14013651e-02f, -5.28381132e-02f, -6.15688302e-02f, -7.61576667e-02f, -8.01730230e-02f, 5.60565665e-02f, -3.91616896e-02f, -1.01719588e-01f, 4.51139733e-02f, 1.94027219e-02f,
  1.52881248e-02f, -1.94770172e-02f, -3.22108790e-02f, 2.15392020e-02f, 1.28689799e-02f, 8.70173723e-02f, 2.33484861e-02f, 5.79276793e-02f, -1.10601813e-01f, 3.06640118e-02f,
  2.82038026e-03f, -6.20604903e-02f, 2.68564932e-02f, -9.01390314e-02f, 5.60971051e-02f, -2.81590950e-02f, 1.07589727e-02f, 4.31546457e-02f, 2.21058000e-02f, -2.76807118e-02f,
  2.54247636e-02f, -4.44338024e-02f, -1.37874903e-02f, 1.46917095e-02f, -1.11917909e-02f, 5.49288131e-02f, -4.37105075e-02f, -2.06620265e-02f, 2.21577566e-02f, -2.08683237e-02f,
  9.34567600e-02f, 4.96265069e-02f, 1.40973842e-02f, -1.65965892e-02f, -1.12815611e-02f, 1.01157278e-02f, 9.14409086e-02f, -9.58478171e-03f, 4.95270491e-02f, 7.28447586e-02f,
  -2.67454349e-02f, -5.27458601e-02f, 1.61162019e-02f, 2.05726475e-02f, -1.89212691e-02f, 4.57243733e-02f, 3.24195363e-02f, -2.58313324e-02f, -9.80390236e-03f, -6.35434315e-02f,
  1.22628666e-01f, 1.11433677e-02f, -1.12318415e-02f, -4.49995324e-02f, 6.90860301e-02f, 1.81112683e-03f, -1.99549436e-03f, 1.04511492e-02f, -6.97384030e-02f, 1.81109250e-01f,
  -2.76809305e-01f, 2.69690663e-01f, 1.15487233e-01f, -1.45317510e-01f, 1.80786639e-01f, 1.51989132e-01f, 3.58263284e-01f, 8.88370872e-02f, -5.80536835e-02f, 1.13747843e-01f,
  4.56822366e-02f, 1.78985484e-02f, -1.07186705e-01f, -1.16834700e-01f, 2.97535453e-02f, 2.19927832e-01f, 2.08669469e-01f, -8.17215666e-02f, -1.79709211e-01f, 1.07569881e-02f,
  1.66502833e-01f, -5.65572158e-02f, -2.68939972e-01f, -1.31179452e-01f, 6.75819023e-03f, -2.00048909e-01f, 8.57161209e-02f, -9.53930393e-02f, 4.08486761e-02f, 9.77395251e-02f,
  -1.01653233e-01f, 1.00824885e-01f, -5.08331396e-02f, -1.85934380e-02f, -1.50304125e-03f, -9.32311267e-02f, -2.46415637e-03f, -4.64861766e-02f, -8.24337602e-02f, -1.61802098e-02f,
  -7.70622212e-03f, -2.64960211e-02f, 2.42237630e-03f, -1.19308971e-01f, -6.05435781e-02f, -2.67237984e-02f, -1.91856325e-01f, -1.50890797e-02f, -8.24399367e-02f, 5.42422161e-02f,
  5.44553101e-02f, 4.60156240e-02f, 1.26031801e-01f, -3.24689150e-02f, -1.09792156e-02f, -4.78065386e-02f, -2.70570461e-02f, -1.52701110e-01f, 4.63135960e-03f, -1.70695670e-02f,
  -1.97020452e-02f, 1.20618626e-01f, 5.12092449e-02f, -2.62395181e-02f, -2.20432223e-04f, 1.44686503e-02f, 4.37965244e-02f, -5.34978919e-02f, -3.53104733e-02f, -4.71992791e-02f,
  8.15516396e-04f, 2.70840283e-02f, -5.10145016e-02f, -9.82005447e-02f, -3.68162915e-02f, -1.39191886e-02f, -8.31076968e-03f, 1.49784703e-02f, -5.31823970e-02f, -5.94422296e-02f,
  -1.69701613e-02f, -7.05656856e-02f, 1.85500563e-03f, -1.48440435e-04f, 5.96968494e-02f, 3.04604284e-02f, -2.17537694e-02f, -6.99996427e-02f, 2.93633789e-02f, 3.76007333e-03f,
  -1.65249318e-01f, 8.74147266e-02f, 1.43964607e-02f, 7.77771026e-02f, 9.70479974e-04f, 4.99794222e-02f, -2.05446174e-03f, 6.39924034e-02f, 7.40994662e-02f, 2.03395300e-02f,
  5.82287740e-03f, 3.68152186e-02f, -3.90061550e-02f, -6.03780821e-02f, 3.25456783e-02f, 4.55967262e-02f, 1.12825092e-02f, -8.20286348e-02f, 4.49377596e-02f, 4.26816456e-02f,
  6.42696172e-02f, 1.52040780e-01f, -4.40257750e-02f, 1.88855603e-02f, 8.83740559e-02f, 8.45271200e-02f, 8.19297954e-02f, 8.92717205e-03f, 1.91789400e-02f, -3.29942368e-02f,
  2.09605098e-01f, -3.23857248e-01f, 1.05152421e-01f, 3.09777595e-02f, -3.14613193e-01f, -9.80162323e-02f, -2.46244565e-01f, -2.99775824e-02f, -1.30174920e-01f, -5.27612008e-02f,
  -1.35956019e-01f, 1.17423914e-01f, 1.58980370e-01f, 3.70179564e-02f, 1.13104336e-01f, -1.11322768e-01f, -1.67027265e-01f, 1.44727126e-01f, 3.30196947e-01f, 1.36432126e-01f,
  1.31116090e-02f, 1.05398454e-01f, 2.41525993e-01f, 1.86848491e-01f, -1.56172484e-01f, 2.54642367e-01f, -1.15914419e-01f, -3.11143044e-03f, -6.59941807e-02f, -3.26297469e-02f,
  2.98637629e-01f, -1.21720277e-01f, 1.55764818e-01f, -1.43202664e-02f, -4.52659167e-02f, -8.05032719e-03f, 6.63496330e-02f, -6.65127393e-03f, -6.54955357e-02f, 7.79975429e-02f,
  -1.94672216e-02f, -1.35347873e-01f, -2.48197629e-03f, -1.37285283e-02f, -3.08991745e-02f, 4.97797541e-02f, -2.24299561e-02f, 6.53311759e-02f, -1.05394283e-03f, -8.56183618e-02f,
  -1.90165728e-01f, -9.69284624e-02f, -1.55303225e-01f, -2.13316437e-02f, -5.81897423e-02f, -7.48875961e-02f, -6.98420256e-02f, -7.87409917e-02f, 7.24917501e-02f, 2.64712726e-03f,
  -7.15597570e-02f, 7.00954199e-02f, 4.39891107e-02f, -8.58328585e-03f, -4.95552346e-02f, -3.96121331e-02f, 2.72772592e-02f, 1.18158543e-02f, 7.81297162e-02f, -6.35552779e-02f,
  -1.51812695e-02f, -1.51076019e-02f, 1.30500356e-02f, 6.12257794e-03f, 2.78521962e-02f, 2.12928671e-02f, 3.79666165e-02f, 4.61678542e-02f, 6.37136251e-02f, -5.63994087e-02f,
  -3.90778854e-02f, -2.44505443e-02f, -7.84228146e-02f, 3.77278775e-02f, 2.32821628e-02f, -1.73196010e-02f, -6.06682822e-02f, -6.35221228e-02f, 1.09323412e-01f, 3.52688337e-04f,
  1.84535757e-01f, -1.11234365e-02f, 9.54683870e-02f, -1.15864668e-02f, -6.02165684e-02f, 2.35654488e-02f, 4.10734974e-02f, 3.47935152e-03f, -2.73902738e-03f, -3.25444005e-02f,
  -1.28964921e-02f, 1.47234779e-02f, -1.34985354e-02f, 7.91769400e-02f, 7.14998245e-02f, 6.72140568e-02f, -9.44830626e-02f, 8.89848247e-02f, -7.86468610e-02f, 2.19578762e-02f,
  -3.22838388e-02f, 9.16852802e-02f, 2.58809347e-02f, 3.54227833e-02f, -6.32638868e-04f, 7.73745999e-02f, 1.93423256e-01f, 1.23009823e-01f, 1.06382310e-01f, 1.61288708e-01f,
  2.55028546e-01f, -2.96213418e-01f, -6.19299076e-02f, 1.33770391e-01f, -5.70286401e-02f, 1.15316652e-01f, -1.42887205e-01f, -3.00255567e-02f, 1.60642162e-01f, -1.06364675e-01f,
  -1.20213963e-01f, 2.36687995e-02f, -8.41315389e-02f, -1.42971560e-01f, -1.47558868e-01f, -2.68942937e-02f, -6.79986998e-02f, -7.30518922e-02f, 1.53166741e-01f, 6.48756847e-02f,
  -3.83922607e-02f, -4.56952453e-02f, 3.64527367e-02f, -3.24767223e-03f, 5.29695228e-02f, 2.23533154e-01f, 6.43079057e-02f, -3.24174413e-04f, -5.19956760e-02f, -2.51058668e-01f,
  3.12886238e-02f, -2.29889840e-01f, 5.29857576e-02f, -1.76973119e-02f, 1.43677136e-02f, 7.93907195e-02f, -6.52358285e-04f, 1.65404007e-02f, -1.04375128e-02f, -7.51091093e-02f,
  -1.03214152e-01f, -4.63268235e-02f, -3.83246653e-02f, -4.36175503e-02f, -4.48561274e-02f, -6.81612492e-02f, -3.84334438e-02f, -7.81544968e-02f, -5.98829910e-02f, 4.63382490e-02f,
  -1.19402058e-01f, -3.80160436e-02f, -1.54234067e-01f, -1.00288399e-01f, -9.66354832e-02f, -1.74475275e-02f, -9.43950862e-02f, -1.22708037e-01f, 2.79366858e-02f, 8.35667849e-02f,
  9.14746150e-02f, -2.12627426e-02f, 7.95411039e-03f, 1.05258599e-02f, -2.88628992e-02f, 3.27777825e-02f, -3.96484807e-02f, -4.70023006e-02f, 4.58097756e-02f, -2.71870159e-02f,
  1.84577331e-02f, 2.65738778e-02f, -1.32926898e-02f, 5.94069287e-02f, 1.52021321e-02f, -3.12425643e-02f, -3.54272127e-02f, -6.33274838e-02f, -2.24825572e-02f, 3.12703359e-03f,
  3.76575664e-02f, 1.61594078e-02f, 2.20120568e-02f, -5.85846826e-02f, -2.20078342e-02f, -3.96679640e-02f, 1.00375108e-01f, -1.05741158e-01f, 5.15034087e-02f, -5.23527823e-02f,
  2.48839304e-01f, -8.41563195e-02f, 1.08923614e-01f, 1.20089075e-03f, -2.38086786e-02f, 1.05500845e-02f, -7.37250829e-03f, -2.81972252e-02f, -1.64934713e-02f, 1.61263552e-02f,
  -2.28394009e-02f, 2.89131198e-02f, -7.87313208e-02f, -9.09836218e-02f, 1.21039473e-01f, -1.41004464e-02f, 3.51056568e-02f, 2.20851284e-02f, 2.04310995e-02f, 7.88233504e-02f,
  4.79162931e-02f, 1.39007717e-01f, 1.10488221e-01f, 7.26661235e-02f, 1.29487813e-01f, 1.37569264e-01f, 1.37296459e-02f, 1.66894361e-01f, 7.94399306e-02f, 2.00663775e-01f,
  4.20056237e-03f, -7.93345124e-02f, 8.73463228e-02f, 1.51472939e-02f, -1.36822119e-01f, 9.65448022e-02f, 3.49055976e-02f, 6.91373944e-02f, -6.79634064e-02f, 5.66623500e-03f,
  -7.57376403e-02f, -5.77524677e-02f, -6.93709701e-02f, -4.35917899e-02f, -7.93470368e-02f, -8.32967982e-02f, -1.27754658e-01f, -1.20134920e-01f, 1.70127191e-02f, -6.71152994e-02f,
  -7.56629929e-02f, -7.98197687e-02f, 1.57082931e-03f, 9.26158577e-03f, -9.28372443e-02f, -1.46381278e-03f, 6.56529367e-02f, -2.74667088e-02f, 2.52147410e-02f, -2.10750684e-01f,
  1.28632098e-01f, 6.08441569e-02f, 8.35801382e-03f, -1.65885761e-01f, -6.41945302e-02f, 6.81533590e-02f, 1.22797824e-02f, 2.96334084e-02f, 9.75168031e-03f, 6.98335990e-02f,
  7.60476477e-03f, 3.87768038e-02f, -7.93413818e-02f, 1.23324007e-01f, -1.20021701e-01f, -4.31310870e-02f, -3.64391282e-02f, -1.35738105e-02f, -3.34157906e-02f, -3.21452022e-02f,
  -6.98119700e-02f, -7.86506981e-02f, 9.41982679e-03f, -5.55605553e-02f, 2.02296823e-02f, -2.80289482e-02f, 5.18083479e-03f, 3.17216255e-02f, 5.53241223e-02f, 7.71347620e-03f,
  4.08892296e-02f, 4.48952876e-02f, 1.09719299e-01f, -5.17375488e-03f, 4.69078659e-04f, 1.92941315e-02f, -1.31824249e-02f, -3.36959846e-02f, -6.42630681e-02f, -2.01865733e-02f,
  7.19486326e-02f, 5.88709339e-02f, -5.93170859e-02f, 7.22445920e-02f, -5.38514592e-02f, -3.75440866e-02f, 4.71210070e-02f, -2.25768741e-02f, -7.30320737e-02f, -7.66363414e-03f,
  -6.84359670e-02f, 4.56071310e-02f, -8.52518994e-03f, 3.04187424e-02f, -1.03453480e-01f, -9.01884120e-03f, -4.30623107e-02f, -1.31559800e-02f, 3.74408700e-02f, 4.25740518e-02f,
  5.77744506e-02f, -9.00100321e-02f, -3.05097774e-02f, -3.37688588e-02f, -5.94689958e-02f, -3.85214128e-02f, -4.36335010e-03f, -2.56057009e-02f, -4.43636961e-02f, -7.22044986e-03f,
  7.76632577e-02f, -1.33004235e-02f, -6.46740422e-02f, 1.36181563e-01f, -2.45459173e-02f, -1.80123537e-03f, 8.47022682e-02f, -4.18876112e-02f, -2.32955217e-02f, -5.50702140e-02f,
  -4.87805754e-02f, 1.16621323e-01f, 6.33744746e-02f, -1.34541271e-02f, -5.03943413e-02f, -6.18727971e-03f, 1.91477746e-01f, 2.37207152e-02f, 1.06297821e-01f, 3.98072507e-03f,
  -7.93229640e-01f, 3.07188511e-01f, 1.42806768e-01f, -3.80126923e-01f, 8.81540254e-02f, -1.70138195e-01f, 4.97283340e-02f, -1.51959106e-01f, -7.94716701e-02f, -5.10794446e-02f,
  1.53623655e-01f, 3.06781009e-02f, 7.05214739e-02f, 9.65448618e-02f, -8.69554561e-03f, 7.51343369e-03f, 2.50904430e-02f, -5.96150011e-02f, -1.67879328e-01f, -1.56643422e-04f,
  1.14258029e-01f, 1.81708746e-02f, -6.99595436e-02f, 8.63168910e-02f, 1.12732105e-01f, -1.25899002e-01f, 4.05141450e-02f, 6.61316961e-02f, 1.43356606e-01f, 5.83644845e-02f,
  1.73761696e-01f, 2.25722473e-02f, -6.19724318e-02f, -5.41807301e-02f, 1.07396647e-01f, -1.37551710e-01f, -2.07789689e-02f, 1.07293306e-02f, -2.87246965e-02f, 1.31325349e-02f,
  5.59899621e-02f, 1.58043634e-02f, -4.95519340e-02f, 3.68202105e-02f, 7.93583393e-02f, -4.67507867e-03f, 4.38047238e-02f, 4.37356718e-02f, -5.84506579e-02f, -5.71824377e-03f,
  -8.54247250e-03f, 4.75270450e-02f, -6.23872969e-04f, -1.61050505e-03f, -6.98396638e-02f, 4.57503684e-02f, 1.36948541e-01f, 3.14679667e-02f, 6.22852184e-02f, 1.05344109e-01f,
  -1.35187693e-02f, 2.95219794e-02f, -2.42486876e-02f, 2.99675167e-02f, -4.45332788e-02f, -7.04201534e-02f, -6.75429851e-02f, 1.07560501e-01f, 7.14962557e-03f, 5.42595051e-02f,
  4.02631797e-02f, 4.53369208e-02f, 3.08739133e-02f, -1.49395857e-02f, -4.63872664e-02f, -1.37512758e-02f, -1.37889897e-02f, 2.16623675e-02f, 1.33902971e-02f, -3.67368162e-02f,
  6.83188764e-03f, -5.43121472e-02f, 8.50019138e-03f, 1.34980371e-02f, 2.45703366e-02f, -1.24141723e-02f, -4.94471099e-03f, 2.37085354e-02f, -1.95715181e-03f, -4.76337522e-02f,
  1.14920020e-01f, -7.53084421e-02f, 1.25223491e-02f, -6.79174578e-03f, -5.13941161e-02f, 5.55860214e-02f, 6.27667177e-03f, 1.52932219e-02f, 2.85216211e-03f, -7.66688436e-02f,
  -3.77279744e-02f, -6.48451746e-02f, 5.31874187e-02f, 3.41231786e-02f, -4.61794250e-03f, -6.96640275e-03f, 2.32580975e-02f, -8.84569809e-02f, -2.89736632e-02f, 6.04504570e-02f,
  -6.47040159e-02f, -9.65329781e-02f, -2.77761333e-02f, -7.23359436e-02f, 1.22518060e-04f, -9.08829793e-02f, 1.08289354e-01f, -8.98549450e-04f, -1.44626051e-01f, -3.52087393e-02f,
  2.33424336e-01f, 1.90567151e-01f, 2.02256460e-02f, -1.86253324e-01f, -4.14121412e-02f, -1.45361513e-01f, -1.83184370e-01f, -9.88237634e-02f, -1.17815346e-01f, -2.46602166e-02f,
  5.44479415e-02f, -1.71288103e-01f, -1.68830693e-01f, -1.20375745e-01f, -2.13086113e-01f, -1.93854168e-01f, -1.10791132e-01f, -6.64934367e-02f, -2.25316495e-01f, -9.66446623e-02f,
  1.03540393e-02f, -3.94295491e-02f, 1.81294158e-01f, 4.05828543e-02f, -5.79257682e-02f, -8.54224265e-02f, 4.80496921e-02f, 1.58773810e-01f, 1.52809676e-02f, 6.49081767e-02f,
  8.40527043e-02f, 2.39472643e-01f, -5.20912223e-02f, -5.55913970e-02f, -5.57248900e-03f, -6.85518282e-03f, 2.28988677e-02f, 6.06084205e-02f, -2.87382957e-02f, 8.58846232e-02f,
  -5.67138866e-02f, -1.15870424e-01f, -7.32355937e-02f, -8.09791405e-03f, 4.37566917e-03f, 2.38321675e-03f, 1.08251527e-01f, -5.06682647e-03f, 1.87966991e-02f, 9.24606994e-02f,
  9.60570667e-03f, 1.56917095e-01f, 1.67689338e-01f, 4.87281755e-02f, 5.92294987e-03f, 6.45666197e-02f, 1.32837430e-01f, 5.50528755e-03f, 1.37670383e-01f, 4.25489880e-02f,
  5.36841340e-02f, -7.85477087e-02f, 3.06737982e-02f, 6.52799848e-03f, -2.94570792e-02f, -1.00306965e-01f, -4.55746390e-02f, -8.82834494e-02f, -3.60401385e-02f, 2.33299984e-03f,
  -3.28210331e-02f, -4.94544618e-02f, 5.44073209e-02f, -1.25544602e-02f, 3.60240377e-02f, -5.30601032e-02f, -7.58869499e-02f, 4.81072478e-02f, 1.20828025e-01f, 5.18935639e-03f,
  -2.75768396e-02f, 3.88247408e-02f, -1.50193032e-02f, 4.65550572e-02f, 4.94108573e-02f, 1.37252326e-03f, -2.16405541e-02f, 4.87569682e-02f, -2.86283344e-02f, 4.33346368e-02f,
  -1.49108604e-01f, -5.34521267e-02f, -7.48868510e-02f, 6.51164278e-02f, -4.30513658e-02f, 1.64434880e-01f, -2.94382144e-02f, 1.38140872e-01f, 1.82973836e-02f, -3.94048281e-02f,
  -2.63919868e-02f, 2.81971116e-02f, 5.61759435e-02f, 7.17186034e-02f, -1.29979327e-01f, 4.16403674e-02f, -2.90200990e-02f, 2.61306167e-02f, -8.42810422e-02f, 1.48668385e-03f,
  -3.01003847e-02f, -4.98143993e-02f, -9.74385664e-02f, -2.03461405e-02f, 2.06949823e-02f, -1.18341602e-01f, 3.45202349e-02f, 3.26194577e-02f, -8.95106643e-02f, -9.16602686e-02f,
  2.78360099e-01f, 6.13158867e-02f, 2.18670994e-01f, 2.79319584e-01f, 3.42090964e-01f, 1.28005236e-01f, 1.65395528e-01f, -1.69003755e-01f, -5.34889102e-02f, 4.99707796e-02f,
  5.90121970e-02f, 1.66551486e-04f, -1.22190423e-01f, -2.00131282e-01f, -6.20826073e-02f, -5.47988527e-02f, 9.15198401e-02f, 1.47389695e-01f, 3.78623279e-03f, 2.46811092e-01f,
  1.54950276e-01f, 2.49880537e-01f, 4.17936035e-02f, -1.83032304e-02f, 8.07411894e-02f, -3.35676521e-02f, -6.40179962e-02f, 1.11190237e-01f, -5.24830930e-02f, 2.44150296e-01f,
  1.25768155e-01f, 2.10160464e-01f, 3.79145667e-02f, 1.62565127e-01f, 1.48198411e-01f, -1.02709524e-01f, 8.59195068e-02f, 2.39258092e-02f, 7.05057662e-03f, -7.33661419e-03f,
  7.62396958e-04f, -3.22945118e-02f, -1.19102011e-02f, 7.78682008e-02f, -1.64636895e-02f, -5.18055893e-02f, -1.02495335e-01f, 4.30023186e-02f, 1.78924762e-02f, 2.40546092e-02f,
  1.52578903e-02f, 1.24511354e-01f, 2.89768475e-04f, -2.57405769e-02f, -1.10968210e-01f, 7.95239210e-02f, 1.53387021e-02f, 1.96688566e-02f, 4.60052043e-02f, -9.25240889e-02f,
  -2.38051098e-02f, -4.37301621e-02f, -8.94125104e-02f, 5.85384993e-03f, -4.03114744e-02f, 7.25334436e-02f, 5.81028834e-02f, 8.42583366e-03f, -1.36166606e-02f, 1.21027706e-02f,
  -3.06707062e-02f, 2.23481786e-02f, 1.96368471e-02f, -8.11608359e-02f, -5.37256412e-02f, 4.54359166e-02f, -1.31611619e-02f, 3.50518413e-02f, 1.19092772e-02f, -2.21365578e-02f,
  2.25433651e-02f, 4.66366485e-02f, -4.51425910e-02f, -5.15889451e-02f, 5.20776287e-02f, -2.18578540e-02f, 2.14364342e-02f, 1.46754098e-03f, -2.08465848e-02f, 7.74448216e-02f,
  -1.57318935e-01f, 6.59148097e-02f, -6.54987665e-03f, -8.75108168e-02f, -7.04695433e-02f, -1.01684034e-02f, -6.52541080e-03f, -6.54955283e-02f, -4.37802076e-02f, -2.29459666e-02f,
  5.07482849e-02f, -6.38889819e-02f, 7.66362529e-03f, -1.52059495e-02f, 3.61424126e-02f, 4.15441208e-03f, -1.95338652e-02f, 9.05203372e-02f, 6.45604134e-02f, -1.03333429e-01f,
  -4.32937145e-02f, -1.18801579e-01f, -9.10740271e-02f, -1.91369325e-01f, -2.23904327e-02f, 4.43511195e-02f, -9.61453840e-02f, 1.05430670e-02f, -6.25211895e-02f, -1.19432114e-01f,
  2.49635279e-01f, 5.63598536e-02f, 6.00186698e-02f, 3.43229398e-02f, -1.10886171e-01f, -9.05970391e-03f, -9.60620269e-02f, -5.72812110e-02f, 1.33738061e-02f, 5.05390875e-02f,
  2.32967716e-02f, 3.27183343e-02f, 8.16016495e-02f, 3.35423276e-02f, 1.41684979e-01f, -5.45193963e-02f, 8.91869217e-02f, 4.62951837e-03f, -6.89957738e-02f, -9.12513584e-02f,
  8.97154305e-03f, 1.42291011e-02f, 1.41480744e-01f, 5.96881956e-02f, -1.71964929e-01f, -1.31017957e-02f, 6.63377270e-02f, 5.34163378e-02f, 4.10684720e-02f, -6.79485733e-03f,
  -5.65788746e-02f, 6.13479391e-02f, 5.54874614e-02f, 6.33885190e-02f, -4.36049234e-03f, -3.38110067e-02f, 4.39595915e-02f, 6.38252720e-02f, 6.43847957e-02f, -6.85774535e-02f,
  -5.04611135e-02f, -2.90493332e-02f, 3.73497456e-02f, -1.75582990e-02f, 5.04041724e-02f, 2.35761907e-02f, -5.74915819e-02f, -1.61771588e-02f, 4.34166053e-03f, 2.81317644e-02f,
  -3.14993993e-03f, -1.16105564e-02f, -7.70576969e-02f, -6.47064596e-02f, 2.62744371e-02f, -4.60307039e-02f, -1.38233677e-01f, -9.23757181e-02f, -7.46754184e-02f, -2.72719096e-02f,
  4.48098266e-03f, 4.27464917e-02f, -6.66282997e-02f, -3.11914575e-03f, 7.31959343e-02f, -9.95378420e-02f, -6.60931021e-02f, -6.15456561e-03f, 6.72286004e-02f, -2.51721106e-02f,
  8.49471390e-02f, -5.14702033e-03f, -9.13681686e-02f, -5.66555336e-02f, 7.78460829e-03f, -5.66266477e-02f, -5.81351705e-02f, -2.84959320e-02f, -4.79901908e-03f, 2.95966472e-02f,
  5.09412885e-02f, -7.86283985e-02f, 2.91173644e-02f, 5.93547197e-03f, 4.49489020e-02f, -4.96312417e-02f, 2.55172029e-02f, 1.61325699e-03f, 1.09088995e-01f, 5.14479131e-02f,
  2.65672384e-03f, 1.47746235e-01f, -1.54188778e-02f, 2.73320042e-02f, 3.57081592e-02f, -4.15297374e-02f, 8.48844722e-02f, 6.25394285e-02f, 3.37018818e-03f, -2.21718289e-02f,
  -4.62187864e-02f, 1.85476709e-02f, -2.84568612e-02f, -6.07672632e-02f, -4.19979729e-02f, -9.09518376e-02f, 6.61839694e-02f, 3.33288349e-02f, 6.03593104e-02f, -2.19080858e-02f,
  -6.54418021e-02f, -1.08327210e-01f, -2.45216247e-02f, -1.08263388e-01f, -6.08132826e-03f, 6.80801645e-02f, -9.70521197e-02f, -7.78448731e-02f, -2.48290580e-02f, -1.73441749e-02f,
  7.08772063e-01f, 2.69512028e-01f, 1.49421275e-01f, -1.14681371e-01f, -2.06188455e-01f, -9.44331568e-03f, 1.34479254e-01f, -1.20293591e-02f, -5.61060309e-02f, 1.88776791e-01f,
  -1.54454000e-02f, -8.91684219e-02f, -8.24013948e-02f, -6.07701093e-02f, 1.00204356e-01f, 2.75781527e-02f, -1.01807341e-01f, 4.43631783e-02f, -1.79947242e-01f, -1.17445335e-01f,
  -2.47510225e-01f, 8.50435272e-02f, 2.10448220e-01f, 2.15367582e-02f, 9.10369009e-02f, 3.37087028e-02f, -3.44393551e-02f, 7.32050613e-02f, 3.09244152e-02f, 1.23490281e-01f,
  1.67866588e-01f, 8.78279507e-02f, -1.86744258e-01f, 3.21789980e-02f, 3.68112058e-04f, 8.37159529e-02f, 5.79367951e-02f, -4.55432348e-02f, -1.32967187e-02f, -6.15104567e-03f,
  -9.34160873e-02f, -2.39193738e-02f, -1.13367327e-01f, -1.01583093e-01f, 1.32363141e-01f, 2.62571877e-04f, -3.34103480e-02f, 2.43230793e-03f, -1.35013638e-02f, 2.05696691e-02f,
  -3.05513609e-02f, -5.10679223e-02f, -5.62852360e-02f, -5.63671403e-02f, 7.09654912e-02f, -1.05330884e-01f, -1.46912644e-02f, 8.48813504e-02f, -1.09524606e-02f, 2.71631122e-01f,
  3.00242216e-03f, 8.20951816e-03f, -3.51513969e-04f, 1.07095286e-01f, -2.53267884e-02f, 3.16521823e-02f, -4.15045731e-02f, 4.26421054e-02f, -3.24636064e-02f, 7.09497705e-02f,
  -4.18270789e-02f, 2.46226322e-02f, 7.31354346e-04f, 3.76847386e-02f, 4.45571765e-02f, -2.53160913e-02f, 7.84669816e-03f, 1.97810587e-02f, -1.47133274e-02f, -3.75568611e-03f,
  5.13633229e-02f, -6.46559596e-02f, -1.78920999e-02f, -2.07225792e-02f, 2.99725053e-03f, 3.30096036e-02f, -2.41682827e-02f, -4.92216088e-03f, 1.12691736e-02f, -2.82888580e-02f,
  1.69000655e-01f, -9.19140428e-02f, 4.61610556e-02f, -4.02891487e-02f, -1.98067036e-02f, -5.37655167e-02f, 5.50429933e-02f, 4.75559719e-02f, 3.46738994e-02f, 4.27436829e-02f,
  9.39879473e-03f, 8.54570791e-02f, 3.01103573e-02f, -3.74652329e-03f, 4.76726033e-02f, -1.91686787e-02f, -2.07705870e-02f, 4.43882793e-02f, -4.94523123e-02f, -3.79726477e-02f,
  1.68387536e-02f, 9.71393064e-02f, 2.22424686e-01f, 3.55106592e-02f, 2.42774989e-02f, 2.60152575e-02f, 1.50651038e-01f, 7.12026954e-02f, 1.15250960e-01f, 3.99489224e-01f,
  -1.81768313e-01f, 1.94245592e-01f, 1.52268872e-01f, -9.70401019e-02f, 6.03536330e-02f, -1.81382149e-01f, -1.04860783e-01f, -1.46767050e-01f, -2.02875301e-01f, -4.28143963e-02f,
  1.22579180e-01f, -3.44375260e-02f, -1.06190100e-01f, -1.02462517e-02f, -1.48625195e-01f, -1.29215792e-01f, 3.44851427e-02f, -2.72507817e-02f, -1.34688646e-01f, -1.01013789e-02f,
  -7.40208477e-03f, 1.64281622e-01f, 1.19737931e-01f, 1.19565144e-01f, 4.87666689e-02f, -3.68076563e-02f, 9.16392282e-02f, 2.26519689e-01f, 1.80143967e-01f, -9.72559117e-03f,
  -1.29568856e-02f, 2.10555509e-01f, -1.88118890e-01f, -5.99439628e-02f, 4.81458232e-02f, -6.94960058e-02f, 1.48691274e-02f, 1.73663013e-02f, 1.74565259e-02f, -2.07063314e-02f,
  9.51958522e-02f, -6.57396093e-02f, -9.07728449e-02f, 9.36610699e-02f, 5.95130809e-02f, -3.02589722e-02f, 4.20143716e-02f, 4.44475971e-02f, 4.73577119e-02f, -1.60713047e-02f,
  7.77327120e-02f, 1.87182128e-01f, 1.30152926e-01f, 5.40907159e-02f, 1.07324146e-01f, 8.98919776e-02f, 1.70622841e-01f, 9.29702595e-02f, 7.00351894e-02f, 1.05174622e-02f,
  4.41266075e-02f, -5.20580448e-02f, 6.75491709e-03f, 5.53782880e-02f, -4.49964497e-03f, 1.13216722e-02f, 5.97560499e-03f, -1.87853798e-02f, -4.35039811e-02f, -5.94348907e-02f,
  1.17797521e-03f, -6.39521927e-02f, -1.84438843e-02f, 2.68931147e-02f, 1.31094590e-01f, -7.07170460e-03f, 6.28380477e-02f, 4.05442566e-02f, 1.06925435e-01f, 6.30344003e-02f,
  -1.80442557e-02f, 3.11247203e-02f, -1.00634240e-01f, -6.18223846e-02f, -1.41221043e-02f, 1.26441136e-01f, -6.40535960e-03f, -4.63045165e-02f, 1.87525321e-02f, -7.08275661e-02f,
  -1.22194700e-01f, 1.38925821e-01f, -1.22469634e-01f, -2.66934820e-02f, -1.78193003e-02f, 5.29701151e-02f, -2.04955097e-02f, 4.91956063e-02f, 5.52554913e-02f, -9.76047441e-02f,
  1.64302308e-02f, -3.53550352e-02f, -2.14216541e-02f, 9.78197232e-02f, -1.04838692e-01f, -1.07238814e-01f, 2.08508670e-02f, 1.78684932e-04f, -6.69757053e-02f, 2.15829797e-02f,
  -1.50012359e-01f, -1.48682252e-01f, -3.16631377e-01f, -2.02024519e-01f, -6.42524064e-02f, -2.44427577e-01f, -2.01702088e-01f, -6.09066226e-02f, -1.20650887e-01f, -3.49368542e-01f,
  6.10018253e-01f, 1.77378617e-02f, -2.28735268e-01f, 4.88333225e-01f, 1.42145753e-01f, -5.82429953e-02f, 1.00020111e-01f, 2.77738329e-02f, 1.37967587e-01f, 1.19623050e-01f,
  -3.57582420e-02f, 3.79064158e-02f, 2.11333726e-02f, -1.06057441e-02f, -3.58220330e-03f, 1.04977511e-01f, 8.65872726e-02f, -2.23204028e-02f, -9.91978273e-02f, 3.07738651e-02f,
  1.22442506e-01f, 1.72004774e-01f, 1.27303764e-01f, -3.44999433e-02f, 1.14424758e-01f, -1.02103025e-01f, -1.17478140e-01f, 1.16379648e-01f, -6.62869290e-02f, 2.52668917e-01f,
  -1.28986359e-01f, -2.00429466e-02f, -1.07622191e-01f, -6.62849564e-03f, 5.04839094e-03f, -7.40282536e-02f, -1.65387206e-02f, -1.05368532e-02f, -1.84044186e-02f, -3.98431495e-02f,
  1.07397817e-01f, -1.41613763e-02f, 5.86843900e-02f, 1.74522318e-03f, 1.70009769e-02f, 8.80533680e-02f, 2.49353405e-02f, -1.02789113e-02f, -6.59997389e-02f, -5.44474646e-02f,
  7.79266655e-02f, 9.03528407e-02f, 3.09067369e-02f, -1.08921416e-01f, -1.03405625e-01f, 1.73801500e-02f, -7.71459565e-02f, -5.24562448e-02f, -1.27079666e-01f, -6.92838356e-02f,
  3.94736044e-02f, -6.74665943e-02f, 9.88806710e-02f, -2.53336783e-02f, 2.83364952e-02f, 2.75021773e-02f, -1.04958769e-02f, 2.85181869e-02f, -7.31948316e-02f, 5.76138124e-02f,
  -1.62457060e-02f, -5.36929630e-02f, -3.55963558e-02f, 7.27895796e-02f, 8.13262723e-03f, 8.23891461e-02f, 1.48130627e-02f, -1.04319677e-02f, -3.50110494e-02f, -4.67789918e-03f,
  3.33501101e-02f, -8.71436521e-02f, 1.04851378e-02f, -4.92070802e-03f, -1.99122708e-02f, -1.90549120e-02f, 7.74257854e-02f, -9.29314271e-03f, 2.77643036e-02f, 3.14642750e-02f,
  1.98022187e-01f, -1.38374597e-01f, 3.20694316e-03f, 1.32374093e-03f, 1.01113349e-01f, -4.40258235e-02f, 1.58552937e-02f, -1.58458296e-02f, 7.26859123e-02f, 3.70112801e-04f,
  -1.55119989e-02f, -2.09002104e-02f, 1.17402794e-02f, -3.87076661e-03f, -7.70288035e-02f, -4.63379771e-02f, 4.69661318e-02f, 2.17510909e-02f, -1.17087387e-01f, -2.15973705e-02f,
  -1.80626046e-02f, 1.03825800e-01f, 3.01244352e-02f, 7.35963136e-02f, -3.56089883e-02f, 6.89229965e-02f, -4.90740575e-02f, -9.89848599e-02f, -6.79283217e-02f, -3.16536683e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.90574938e-01f, -1.30106971e-01f, 6.88561276e-02f, 1.07731834e-01f, -2.31800586e-01f, -2.24412546e-01f, -2.19054073e-01f, -1.08035468e-01f, -6.64946884e-02f, -5.00081368e-02f,
  -1.56665519e-01f, -9.53935012e-02f, -1.49432957e-01f, -6.41519129e-02f, -1.07220244e-02f, 4.41377275e-02f, 1.15384035e-01f, 5.33741117e-02f, 6.09195717e-02f, -1.73962936e-02f,
  2.38148235e-02f, 1.27494568e-02f, 2.27135107e-01f, 9.91775617e-02f, -1.60588347e-03f, 6.79192767e-02f, -3.26399803e-02f, 3.25552225e-02f, -4.09092046e-02f, 1.29699782e-01f,
  -8.28650296e-02f, -3.97053882e-02f, -4.99329232e-02f, -6.86297193e-02f, -8.30616653e-02f, 4.91976440e-02f, -1.08096801e-01f, 4.76379916e-02f, 6.47424012e-02f, -2.25891918e-02f,
  7.15905940e-03f, 6.27146959e-02f, -4.58283760e-02f, 1.19140200e-01f, 7.81709049e-03f, 4.43170443e-02f, 1.37647152e-01f, 2.90065333e-02f, 6.80492297e-02f, -2.66938489e-02f,
  -1.50725216e-01f, -1.26388133e-01f, -8.41778051e-03f, -4.56906632e-02f, 6.40033931e-02f, 1.37517275e-02f, -3.07498388e-02f, 1.05218403e-02f, -1.86738353e-02f, 8.16442519e-02f,
  6.65809261e-03f, -4.42772917e-02f, -6.09818809e-02f, -2.64688879e-02f, 7.11558759e-02f, -7.85902441e-02f, -1.11890621e-02f, 4.28202376e-02f, -1.18483067e-01f, 2.96073761e-02f,
  7.19879717e-02f, 1.00364044e-01f, -3.03891557e-03f, -8.25878084e-02f, -1.21103324e-01f, -3.41734141e-02f, 4.21988964e-02f, -1.58539936e-02f, -9.89507418e-03f, -5.22444583e-02f,
  -3.75449508e-02f, 1.11388844e-02f, 2.53027994e-02f, 4.49460894e-02f, 4.40383777e-02f, 7.21726508e-04f, -2.26266794e-02f, 1.14505161e-02f, -3.95106934e-02f, 4.78262790e-02f,
  -1.39506251e-01f, -1.97024822e-01f, -1.08521000e-01f, 9.04663578e-02f, 1.94449965e-02f, -1.69294458e-02f, -1.24523401e-01f, 4.96283844e-02f, -2.81111840e-02f, 4.83266450e-03f,
  -8.26688409e-02f, -3.66458446e-02f, -2.00468823e-02f, -3.82053927e-02f, -2.75226608e-02f, 7.96701480e-03f, 1.16416737e-02f, -1.16426416e-01f, 8.01438391e-02f, 9.02725160e-02f,
  2.07091272e-02f, 2.68755797e-02f, -2.71659307e-02f, -6.73281178e-02f, -1.24610677e-01f, -9.19773709e-03f, -4.71463762e-02f, -6.66758884e-03f, -3.67785320e-02f, -8.93172473e-02f,
  7.69469738e-02f, 6.65363064e-03f, -4.53583688e-01f, 1.24352559e-01f, -1.44967988e-01f, -1.27215646e-02f, -8.51216689e-02f, 9.45894644e-02f, 1.92633033e-01f, -1.96191236e-01f,
  2.80584600e-02f, 1.85472623e-01f, 1.06457639e-02f, 7.54041970e-02f, 1.89407498e-01f, -1.83999300e-01f, -2.40293071e-01f, -8.85275826e-02f, 4.81550582e-02f, -2.25987956e-02f,
  6.91000000e-02f, 9.32029188e-02f, 1.36430845e-01f, 1.96946915e-02f, -8.59041288e-02f, -3.36526223e-02f, -1.82846963e-01f, -3.37267220e-02f, -1.45153388e-01f, -3.32990974e-01f,
  -3.91907781e-01f, 7.39346370e-02f, -1.47590071e-01f, 2.57274155e-02f, -1.46690095e-02f, 1.09895235e-02f, 3.12909819e-02f, -6.96838722e-02f, -3.97552922e-02f, 2.44569760e-02f,
  5.57067506e-02f, -2.90090479e-02f, 1.51304640e-02f, -4.90718894e-02f, -8.92743096e-03f, -3.03330086e-02f, 2.98278835e-02f, 1.76189356e-02f, -1.26811922e-01f, -1.42204985e-02f,
  -1.95977110e-02f, 5.53306974e-02f, 4.94818836e-02f, 3.42251323e-02f, 7.53809139e-02f, 1.82999764e-02f, -3.95364016e-02f, 6.56757224e-03f, -4.21916619e-02f, -1.52500227e-01f,
  -2.27546580e-02f, 6.48691144e-04f, -2.36680899e-02f, -5.23163378e-03f, 1.40920937e-01f, -5.51791526e-02f, 1.44262603e-02f, -6.15098476e-02f, -4.59362724e-04f, 4.77710217e-02f,
  -1.16453797e-01f, 3.78269032e-02f, 2.77621206e-02f, -3.02863773e-02f, -1.73184052e-02f, -5.32725491e-02f, 3.52024548e-02f, 4.92466688e-06f, 5.86328059e-02f, 1.89109333e-02f,
  -7.41762109e-03f, -2.54637636e-02f, 2.09792759e-02f, 9.56949815e-02f, -4.04470861e-02f, -3.32485214e-02f, -2.55916789e-02f, -7.67799318e-02f, 7.61172175e-02f, -7.30999932e-02f,
  1.47839785e-01f, 6.07436039e-02f, -1.65605899e-02f, -2.03102604e-02f, -3.44603620e-02f, 1.96838565e-02f, -5.16014397e-02f, 2.51380913e-02f, 6.91244155e-02f, -4.02511954e-02f,
  -1.15476390e-02f, -3.63482758e-02f, 2.56291665e-02f, -5.72306756e-03f, -1.91695634e-02f, -2.65197852e-03f, -3.02849319e-02f, -6.53459132e-02f, -1.80116557e-02f, 1.78553327e-03f,
  -4.39171456e-02f, 3.92332897e-02f, 2.63802577e-02f, -4.73515168e-02f, 1.46655187e-01f, 1.07705794e-01f, 6.78970590e-02f, 3.83344628e-02f, 3.58431163e-04f, -8.55136588e-02f,
  8.28647614e-02f, -3.29989418e-02f, -1.16587028e-01f, 4.74078804e-02f, -9.83344615e-02f, -9.28920880e-03f, -1.19722016e-01f, -7.40597919e-02f, -4.98752445e-02f, -9.00796130e-02f,
  -3.56465578e-02f, -4.98648454e-03f, 1.11811899e-01f, 3.28113348e-03f, 1.28436834e-01f, -1.32765630e-02f, -5.06929755e-02f, 9.27372724e-02f, -3.40399169e-03f, -8.27909261e-02f,
  3.27693447e-02f, 1.89311262e-02f, -6.63914084e-02f, -1.40510872e-02f, -1.17843607e-02f, -8.55390355e-02f, -1.18948653e-01f, -5.69521263e-02f, 2.33834982e-03f, -1.98785239e-03f,
  4.38529700e-02f, 1.26081958e-01f, 1.69515423e-02f, 4.01654877e-02f, 1.35896739e-03f, -4.71717082e-02f, 6.76374212e-02f, 3.42814662e-02f, 7.39360079e-02f, 9.67839733e-02f,
  -9.78726544e-04f, -1.49631733e-02f, 3.18085998e-02f, -4.17555422e-02f, -4.69124690e-03f, -4.86236773e-02f, -5.37353456e-02f, 2.37272568e-02f, -4.09866311e-02f, 3.55319344e-02f,
  -3.21223438e-02f, 2.00623050e-02f, 1.27045780e-01f, 5.11369146e-02f, 1.63350720e-02f, 9.42413360e-02f, 2.95052473e-02f, 8.67765322e-02f, 6.00824468e-02f, 2.45809071e-02f,
  5.77370450e-02f, -3.76699828e-02f, -3.83876786e-02f, 7.94314966e-02f, 1.83513984e-02f, 3.70905851e-03f, 6.49866834e-02f, 4.98564839e-02f, 7.94754922e-02f, -1.67077780e-02f,
  4.78384038e-03f, -2.31742114e-02f, 3.61997052e-03f, 3.55235511e-03f, -1.14643447e-01f, 6.05714433e-02f, -9.90104079e-02f, 5.32914288e-02f, -2.25624014e-02f, -8.16058666e-02f,
  4.14308906e-02f, 8.15295652e-02f, 1.81289986e-02f, -1.28355414e-01f, -1.63104180e-02f, -6.51542936e-03f, 2.74870340e-02f, -5.66693246e-02f, -3.33678164e-02f, -2.72914357e-02f,
  -1.15044542e-01f, 1.15789466e-01f, 8.70756060e-02f, 3.14999446e-02f, 5.24994498e-03f, -3.20679210e-02f, 1.18003003e-02f, -2.24012826e-02f, 5.88790514e-02f, 7.31146485e-02f,
  8.55480228e-03f, 1.49578387e-02f, 1.41674364e-02f, -4.47169691e-02f, -5.20655178e-02f, 1.45916315e-02f, -7.05630183e-02f, 4.39061560e-02f, 1.32948849e-02f, 1.41395153e-02f,
  -6.19553402e-02f, 8.62304792e-02f, 4.38537076e-02f, 1.06841981e-01f, 7.72052184e-02f, 1.37988716e-01f, -6.97861984e-02f, -5.59694879e-02f, 1.03167228e-01f, -4.85378057e-02f,
  -4.40674871e-02f, -7.02109188e-02f, -1.09388843e-01f, 2.02710837e-01f, -6.37297928e-02f, 1.16841897e-01f, -1.70354351e-01f, 1.69725493e-01f, 1.44152030e-01f, -1.66172236e-01f,
  -1.44951614e-02f, 1.29142448e-01f, -5.18520921e-02f, -2.16550510e-02f, -1.27397656e-01f, -1.56419858e-01f, -2.02330485e-01f, -1.12058911e-02f, 1.36485741e-01f, 1.17296197e-01f,
  -3.80758084e-02f, 3.05736568e-02f, -1.83132887e-02f, 3.72219160e-02f, -1.11288205e-01f, -5.53042330e-02f, -2.35569030e-01f, -7.39534423e-02f, -1.19730532e-01f, -3.47620010e-01f,
  -3.68381113e-01f, 2.21971512e-01f, -2.73650810e-02f, 6.12545721e-02f, -7.13178217e-02f, -2.17201021e-02f, -9.38352868e-02f, -9.05347615e-03f, 5.34135140e-02f, -5.51470406e-02f,
  2.37394013e-02f, 6.45036474e-02f, -4.40658629e-02f, 1.36930466e-01f, 1.86190698e-02f, 7.59347454e-02f, 3.20323482e-02f, 1.35407913e-02f, 1.12708714e-02f, -6.84254151e-03f,
  -2.57640090e-02f, 4.64298315e-02f, -5.97814806e-02f, -8.19562282e-03f, -3.04410886e-02f, 5.17670549e-02f, -9.32499915e-02f, -3.17683667e-02f, -3.49934548e-02f, -1.16019152e-01f,
  -4.70688790e-02f, -2.55420338e-02f, -3.81188132e-02f, 5.44803292e-02f, -1.09355217e-02f, -2.98255682e-02f, -1.29587587e-03f, -1.44419773e-02f, -8.16590898e-03f, -1.29228281e-02f,
  6.77997246e-02f, -4.24563959e-02f, -3.02270148e-02f, -7.13789538e-02f, -3.28758359e-02f, 3.30024026e-02f, -3.23865265e-02f, -6.66406974e-02f, -5.31214774e-02f, -5.18299490e-02f,
  3.51355970e-02f, -4.53582257e-02f, -2.10981909e-03f, 1.95563436e-02f, 5.28478101e-02f, -1.38159171e-02f, 4.82412986e-02f, 7.02245906e-02f, 9.30213854e-02f, 6.03805110e-02f,
  8.08901638e-02f, -1.03927203e-01f, -1.20636135e-01f, 1.37811869e-01f, 1.14641502e-01f, -4.16186936e-02f, 4.70170043e-02f, 1.53773651e-02f, 5.68063408e-02f, 9.94204953e-02f,
  1.18547782e-01f, 3.93434204e-02f, -3.03423535e-02f, -1.16556294e-01f, 1.13054281e-02f, 2.96547953e-02f, -2.78263837e-02f, 3.04798819e-02f, 6.16943371e-03f, 7.26022869e-02f,
  6.00310564e-02f, 3.93255726e-02f, 9.25278291e-03f, 1.76728535e-02f, -4.61524166e-02f, -3.84770557e-02f, -1.07232295e-01f, -3.13654579e-02f, -5.55281974e-02f, -9.63466242e-02f,
  -3.28107700e-02f, -2.24577859e-02f, 6.26166314e-02f, 1.56588137e-01f, 1.05325684e-01f, 1.95153847e-01f, 4.94889095e-02f, 6.09574690e-02f, 8.08887333e-02f, 9.79468226e-02f,
  6.18297793e-02f, 9.77083370e-02f, 1.82702035e-01f, 8.40638801e-02f, 1.64128572e-01f, 1.44573539e-01f, 8.18743706e-02f, 3.06349713e-02f, 1.21641889e-01f, 9.74947661e-02f,
  7.89727122e-02f, -1.08057605e-02f, 5.35571501e-02f, 1.12827487e-01f, 5.44929057e-02f, 1.23176306e-01f, 6.48629293e-02f, -8.28891098e-02f, 4.53204550e-02f, 3.92450988e-02f,
  -4.18210356e-03f, 7.43329152e-02f, 3.07029597e-02f, -6.00055493e-02f, -8.83011594e-02f, 4.69536074e-02f, -8.96108970e-02f, -5.35048693e-02f, -1.02446415e-01f, 9.59037617e-02f,
  -4.76594158e-02f, -1.13469474e-01f, 3.56812924e-02f, -4.81535196e-02f, -4.97676106e-03f, -5.98844793e-03f, 3.65583561e-02f, 1.82818305e-02f, 6.03495911e-02f, -1.46768114e-03f,
  9.41144302e-02f, 1.03627257e-02f, 6.13142774e-02f, -6.68986468e-03f, 1.10523991e-01f, -1.65455826e-02f, -1.25192702e-01f, 7.21702203e-02f, -7.40592554e-02f, 7.34275877e-02f,
  4.26788554e-02f, 2.45381556e-02f, -7.45201781e-02f, -8.03188421e-03f, -4.50168625e-02f, 2.14826362e-03f, -3.13735604e-02f, 5.45873865e-02f, 2.38762535e-02f, -4.41038981e-02f,
  -7.26892725e-02f, 7.19209909e-02f, 1.59233448e-03f, 1.02752991e-01f, 3.79672833e-02f, -3.66602726e-02f, 4.04160097e-02f, -1.01883812e-02f, 3.10935695e-02f, -3.65642011e-02f,
  1.97712965e-02f, -5.89253567e-02f, -7.26311952e-02f, -4.28237282e-02f, 3.39960237e-03f, -4.13895361e-02f, 7.24041834e-02f, -1.99211091e-02f, 1.12649589e-03f, -3.88066396e-02f,
  -3.25742736e-02f, -3.44891474e-02f, 1.14761382e-01f, 6.24078475e-02f, -2.25747824e-02f, -7.55536719e-04f, -1.32810965e-03f, -6.46621212e-02f, -8.59422311e-02f, 8.42474848e-02f,
  4.92425710e-02f, 1.08926455e-02f, -2.44299080e-02f, 4.15987335e-02f, 7.02243522e-02f, 5.15625440e-02f, 2.21531522e-02f, 1.46114291e-03f, -5.92431724e-02f, -8.31741765e-02f,
  1.09936439e-01f, -7.81056136e-02f, -5.27561605e-02f, 8.09049681e-02f, 6.47683814e-02f, -3.00917681e-02f, -1.59308761e-02f, -8.45286250e-02f, -7.76055753e-02f, 7.05754980e-02f,
  1.13488566e-02f, -8.70594382e-03f, -4.35230285e-02f, -7.38466159e-02f, -1.23124935e-01f, -1.99035667e-02f, -4.40656915e-02f, -1.08690128e-01f, -7.65341073e-02f, -2.26315688e-02f,
  3.55359763e-02f, -8.47792625e-02f, 8.92752707e-02f, 2.44542900e-02f, 9.53516830e-03f, -8.49497616e-02f, -9.94782709e-03f, -3.62241152e-03f, 5.68358414e-02f, -8.60090107e-02f,
  -8.67137089e-02f, 1.84910595e-02f, -6.30947994e-04f, -2.44944934e-02f, -9.53272134e-02f, -3.68965976e-02f, -6.29789010e-02f, 3.65813859e-02f, -3.37189659e-02f, -9.11225304e-02f,
  6.01873137e-02f, 6.47770911e-02f, 7.39918873e-02f, 1.08745731e-01f, 9.13921669e-02f, -4.11441475e-02f, 7.24024847e-02f, 9.01203975e-02f, 1.05210811e-01f, -3.43767479e-02f,
  9.54785198e-02f, 9.50185955e-02f, 4.53916751e-02f, -4.21630442e-02f, -5.53552359e-02f, 1.09387115e-01f, 1.29271656e-01f, 5.08700609e-02f, -5.21421693e-02f, 2.34005414e-02f,
  1.32432058e-01f, 1.22306630e-01f, 7.52312168e-02f, 2.16863677e-02f, -8.77246261e-02f, 3.84331271e-02f, 3.00044250e-02f, 3.34237702e-02f, 2.38299780e-02f, 4.15710397e-02f,
  -5.29841147e-03f, -6.14640415e-02f, 9.62439831e-03f, -7.73023739e-02f, 7.84431845e-02f, -2.40665935e-02f, -5.76258637e-02f, 7.83158392e-02f, -7.28283748e-02f, 5.64650074e-02f,
  4.22945507e-02f, -4.30760533e-02f, -8.67169574e-02f, -2.65878569e-02f, -5.64435795e-02f, -7.44106621e-02f, 4.35748789e-03f, -1.06552597e-02f, 4.69972612e-03f, 2.83583160e-03f,
  3.66219990e-02f, 5.97522408e-02f, -3.20192031e-03f, -8.13212991e-02f, -5.45545965e-02f, 9.15563405e-02f, 8.31279755e-02f, -1.43955015e-02f, -4.79199411e-03f, -1.02447337e-02f,
  -1.30469188e-01f, 1.00636585e-02f, 1.24392487e-01f, -8.36238861e-02f, -2.34927684e-02f, 8.47603232e-02f, -5.60124591e-02f, -5.47392741e-02f, 1.42404055e-02f, -3.44490749e-03f,
  3.79096381e-02f, 2.44721733e-02f, -1.10691473e-01f, 3.26913036e-02f, 6.31234944e-02f, 5.09306379e-02f, -5.87995388e-02f, -8.78067464e-02f, -1.36589259e-01f, -9.81311426e-02f,
  4.61230017e-02f, -5.55461571e-02f, 1.07013686e-02f, -2.01845076e-02f, -1.18599255e-02f, -8.01296439e-03f, -2.54425779e-03f, 4.15817462e-02f, -5.63240238e-02f, 1.93248950e-02f,
  -2.34109089e-02f, 4.18892987e-02f, 5.49759753e-02f, -7.25089386e-02f, -1.07504018e-01f, -2.28041671e-02f, 1.42048253e-02f, 2.23496724e-02f, -1.09047465e-01f, -7.37380013e-02f,
  1.25150293e-01f, 9.09173936e-02f, 2.64239699e-01f, 1.66995510e-01f, 1.17790207e-01f, 7.83512592e-02f, -3.83519307e-02f, 1.09639481e-01f, 4.47237529e-02f, 7.75071010e-02f,
  -7.43260682e-02f, -8.58200043e-02f, -6.44430891e-02f, 8.26752186e-02f, -8.38673338e-02f, -3.61606036e-03f, -1.19141869e-01f, -6.23687357e-02f, -5.74014848e-03f, -7.87049681e-02f,
  2.28796437e-01f, 3.84329609e-03f, 1.63662639e-02f, 5.52372262e-02f, -1.06563061e-01f, 3.99864689e-02f, 1.32674426e-01f, -6.77035749e-02f, -4.48071547e-02f, 8.31033289e-02f,
  4.10056636e-02f, 6.74535781e-02f, -8.69221762e-02f, -9.69691426e-02f, 8.57313164e-03f, 6.42433167e-02f, -2.47292742e-01f, -4.92475666e-02f, 8.41961205e-02f, 1.31597802e-01f,
  -1.80371609e-02f, 3.79430540e-02f, 1.35699749e-01f, -1.11634815e-02f, -7.16184378e-02f, 6.79453909e-02f, -4.31059068e-03f, -1.13642775e-02f, 7.44321989e-03f, -1.12436891e-01f,
  2.19390113e-02f, 3.86493616e-02f, 1.90044753e-02f, -5.80459498e-02f, 2.23688292e-03f, 2.19056997e-02f, -5.48562668e-02f, 2.09500175e-02f, -9.48291868e-02f, -3.95813212e-02f,
  -1.87771227e-02f, -2.55765934e-02f, 6.17207773e-02f, 5.61694875e-02f, 2.88709439e-02f, 8.67586769e-03f, -5.25105223e-02f, -2.14324780e-02f, 8.42738897e-02f, -3.31430323e-02f,
  -3.17618288e-02f, -9.43498835e-02f, 1.43582495e-02f, -1.98353399e-02f, 5.59996627e-02f, -2.60030106e-02f, 7.95229971e-02f, 1.32155064e-02f, 4.13460806e-02f, 1.25777861e-02f,
  1.52770892e-01f, 4.02046219e-02f, -4.69334312e-02f, 3.08084115e-02f, -1.43321920e-02f, -1.89779792e-02f, 3.45925912e-02f, -6.03278726e-03f, 8.19713697e-02f, 1.52644301e-02f,
  9.32404697e-02f, 5.35410270e-02f, 2.70567574e-02f, -1.09043293e-01f, -8.41498673e-02f, 9.26781446e-03f, -4.03707586e-02f, 1.19217457e-02f, 7.15395762e-03f, 2.11902894e-02f,
  -8.65710005e-02f, 5.68677904e-03f, 1.73589289e-01f, 2.49885041e-02f, 1.86030590e-03f, 1.19656704e-01f, 6.18975423e-03f, 7.44816735e-02f, 1.14801347e-01f, -5.40562831e-02f,
  2.25020140e-01f, -1.40699983e-01f, 1.32237032e-01f, 1.42013192e-01f, -7.54218549e-02f, -3.58393155e-02f, -2.51868099e-01f, 3.33471373e-02f, -1.42661901e-02f, -1.44619420e-02f,
  2.44277269e-02f, 1.84386045e-01f, 1.62149400e-01f, 1.42539278e-01f, 1.72734678e-01f, -5.04354713e-03f, -4.05107550e-02f, 1.86851069e-01f, 1.17298514e-01f, -3.94233279e-02f,
  -1.06761172e-01f, -7.79476464e-02f, 5.38332500e-02f, -4.72302828e-03f, -1.81568518e-01f, 1.31643787e-01f, -1.40753746e-01f, -5.90506010e-02f, -1.08102784e-01f, -9.47917104e-02f,
  2.53359489e-02f, -7.41246477e-05f, 1.78981369e-04f, 6.27894774e-02f, -3.34141999e-02f, -4.32857894e-04f, -6.40332559e-03f, -1.33762546e-02f, -4.32625711e-02f, -9.73014757e-02f,
  -3.31723690e-02f, 5.45929074e-02f, -2.31954884e-02f, -9.75783691e-02f, -1.50390016e-02f, -5.98692521e-02f, -5.77676445e-02f, 1.04920320e-01f, 7.22515732e-02f, -1.75265204e-02f,
  -5.01756556e-02f, 4.44787852e-02f, -6.47569948e-04f, -3.59116569e-02f, -3.14845406e-02f, -1.25026321e-02f, 9.70881525e-03f, -6.81080073e-02f, 1.67218111e-02f, -1.60087943e-02f,
  5.75054344e-03f, 2.27986425e-02f, -3.05750333e-02f, -2.34994255e-02f, -6.87846914e-02f, 1.41659414e-03f, -1.18108820e-02f, -5.08975945e-02f, -3.55229080e-02f, 6.68770075e-03f,
  3.53502408e-02f, 3.13714556e-02f, 1.13730915e-01f, -4.48203608e-02f, 5.04241213e-02f, -4.82457737e-03f, -4.51891199e-02f, 7.68817514e-02f, -4.86821868e-02f, -8.93057361e-02f,
  3.80034298e-02f, -7.72441402e-02f, -5.28113246e-02f, 1.48049789e-02f, -3.03420611e-02f, 1.13168634e-01f, 8.01686570e-02f, 1.03465088e-01f, -6.68578669e-02f, 7.49004260e-02f,
  -1.69132277e-01f, 2.29403868e-01f, -3.91543061e-02f, 5.76458983e-02f, -4.24943818e-03f, 5.84763996e-02f, -1.57380011e-02f, 4.05190699e-02f, -2.64681019e-02f, -1.23002648e-01f,
  -6.32279441e-02f, 7.82904401e-02f, 3.50410119e-02f, -4.42946777e-02f, -5.71870394e-02f, -6.85041770e-02f, -2.90493648e-02f, 3.93482521e-02f, 4.45050746e-02f, -5.50675727e-02f,
  4.40227240e-02f, 9.07924101e-02f, 8.45640674e-02f, -2.11680010e-02f, -1.33361071e-02f, 4.95608188e-02f, 3.89552675e-02f, -1.10404700e-01f, 8.83164909e-03f, -7.17324540e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.93880135e-01f, -1.08760014e-01f, -1.17414683e-01f, -1.21612936e-01f, -3.46528627e-02f, 4.49589407e-03f, 1.60726886e-02f, 1.26265034e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.33424429e-02f, 1.43849656e-01f, -3.65147516e-02f, -9.03153569e-02f, -1.16487235e-01f, -2.39765063e-01f, 2.46672183e-01f, -1.37292206e-01f, -1.86283499e-01f, 1.98678169e-02f,
  -2.44139165e-01f, 7.25418031e-02f, -1.07521519e-01f, -1.92155927e-01f, 3.95704061e-01f, 5.80784865e-02f, -6.63335845e-02f, -2.84060001e-01f, 1.50370196e-01f, -2.66541719e-01f,
  2.10717976e-01f, 2.19050214e-01f, 6.10077642e-02f, -5.97396269e-02f, 3.01683128e-01f, 3.54100257e-01f, 1.44487232e-01f, 1.87634349e-01f, -3.09204590e-03f, 2.12617069e-01f,
  3.21363986e-01f, 1.88891426e-01f, -1.89830437e-01f, 1.42399266e-01f, -1.99457169e-01f, 7.29484782e-02f, 1.51242375e-01f, -2.86424588e-02f, 1.02309555e-01f, -9.71883684e-02f,
  -1.47579893e-01f, -2.65895516e-01f, -1.90853268e-01f, -1.06332310e-01f, 1.29649445e-01f, 1.03392713e-02f, -1.03716314e-01f, -2.72310749e-02f, 7.18855113e-02f, 1.86269030e-01f,
  2.57873654e-01f, -2.45115772e-01f, -3.41538578e-01f, 1.48163526e-04f, 3.50513756e-01f, -3.33380729e-01f, -8.73653293e-02f, 2.49126423e-02f, -1.07413352e-01f, 3.36085320e-01f,
  -3.32157046e-01f, 6.89492002e-02f, -1.09909654e-01f, -2.78204948e-01f, 2.48619020e-02f, -4.49883007e-02f, -3.92455682e-02f, -2.85963535e-01f, -6.36678096e-03f, 1.57143146e-01f,
  7.40785226e-02f, 1.39071748e-01f, 8.20008889e-02f, -1.93324283e-01f, 1.69746354e-01f, 1.39641717e-01f, -1.00724906e-01f, 3.03136677e-01f, -2.64999986e-01f, -1.00764506e-01f,
  -2.61309624e-01f, 2.50337839e-01f, 1.64436221e-01f, 3.16202730e-01f, 9.30180922e-02f, -1.71267346e-01f, 2.23301306e-01f, 1.73181415e-01f, 1.27200544e-01f, -1.68650895e-01f,
  2.36665662e-02f, -4.97299321e-02f, -3.96363921e-02f, 3.33041400e-02f, -1.46162555e-01f, -1.90225840e-01f, -2.20592812e-01f, 2.17452049e-02f, -9.68393907e-02f, -2.83180654e-01f,
  -5.53935766e-02f, 9.03210863e-02f, 3.43195088e-02f, 1.10929392e-01f, 4.22883034e-02f, -2.33881131e-01f, 1.68860674e-01f, 6.15084264e-03f, -1.36769295e-01f, 2.63582677e-01f,
  -1.00864537e-01f, -2.04723701e-01f, 6.31922930e-02f, 2.57459164e-01f, 2.27024034e-01f, 6.72315881e-02f, -1.92281887e-01f, 2.23552912e-01f, 3.47723737e-02f, 2.16831222e-01f,
  2.68148743e-02f, -3.10258269e-01f, -7.37478584e-02f, -2.63055831e-01f, -1.22293539e-01f, 4.21337523e-02f, -1.01810306e-01f, -3.17244560e-01f, -3.52727145e-01f, -2.43512705e-01f,
  -1.72966734e-01f, -3.04750830e-01f, -3.03799540e-01f, -5.38420565e-02f, -4.47996110e-01f, 5.61403371e-02f, -7.79678971e-02f, -3.28464955e-01f, -4.29753587e-02f, 9.85290334e-02f,
  -6.21528685e-01f, 2.37045005e-01f, -8.20509046e-02f, 4.79338281e-02f, -9.72148255e-02f, -2.97759354e-01f, -2.98180819e-01f, 4.53714639e-01f, -1.54919997e-01f, 7.74788782e-02f,
  -1.04075871e-01f, 3.43565285e-01f, 1.95587739e-01f, -2.83908159e-01f, 1.41067477e-02f, -1.08497649e-01f, 1.75843999e-01f, -1.92442566e-01f, 3.05956099e-02f, -1.68749303e-01f,
  -1.17484733e-01f, 2.06249893e-01f, -5.28555661e-02f, -7.73969144e-02f, 8.05602819e-02f, -1.10831089e-01f, 9.91498008e-02f, 7.44822025e-02f, 1.64613441e-01f, 4.32027802e-02f,
  9.15284157e-02f, 1.52743189e-02f, -2.58022517e-01f, -2.66890585e-01f, 1.93378851e-01f, 1.60625696e-01f, 9.62394178e-02f, -9.94004905e-02f, 1.22029416e-01f, 3.29896323e-02f,
  -5.67677543e-02f, 3.46855521e-01f, -1.34055726e-02f, -1.04832485e-01f, 2.54850715e-01f, 3.28421384e-01f, -3.01265717e-02f, 1.37944415e-01f, -1.94014102e-01f, -1.04334272e-01f,
  7.91609362e-02f, -5.91404773e-02f, -9.73980352e-02f, -3.55180465e-02f, -8.23848620e-02f, -8.47994611e-02f, 1.42559111e-01f, -2.47538149e-01f, -3.23333517e-02f, -1.19139499e-03f,
  -1.59395158e-01f, 2.13838816e-01f, -4.03446238e-03f, 3.46206315e-02f, -1.35578841e-01f, -1.79553464e-01f, 4.49276954e-01f, 2.79439837e-02f, 1.01856522e-01f, -2.53927201e-01f,
  -2.97462970e-01f, -4.62174378e-02f, -1.15659423e-01f, 3.26037645e-01f, -4.18085307e-01f, 6.00427650e-02f, -1.66553065e-01f, 4.52972651e-02f, -5.51779233e-02f, -2.02633843e-01f,
  4.62588891e-02f, 1.76623538e-01f, 1.85480848e-01f, 2.85993069e-01f, -9.57131479e-03f, 3.18902805e-02f, -2.74767969e-02f, -1.20164320e-01f, -1.48552060e-01f, -2.61107683e-01f,
  -2.28735179e-01f, 9.82192606e-02f, 6.22328743e-02f, -2.27562338e-01f, -7.13326484e-02f, -9.96861607e-02f, -3.71734537e-02f, 2.18856245e-01f, -3.40897106e-02f, 5.76336496e-02f,
  9.22311395e-02f, -7.93668926e-02f, -6.09583668e-02f, -7.57917389e-02f, -2.16875911e-01f, -4.46465202e-02f, -2.67788649e-01f, -3.60103883e-02f, -2.29628757e-01f, -2.15108152e-02f,
  2.16563091e-01f, -1.13219954e-01f, -2.89738737e-02f, 2.04558179e-01f, -8.11739080e-03f, -1.48790911e-01f, 1.72211230e-01f, -7.57871121e-02f, 3.64274718e-02f, -3.95267233e-02f,
  -3.81195620e-02f, 2.24304274e-01f, 1.40709639e-01f, -2.25400135e-01f, 3.93664017e-02f, -4.65084277e-02f, 1.75431579e-01f, -1.78458020e-01f, -1.56974554e-01f, 1.12900123e-01f,
  -2.11352989e-01f, -3.96220654e-01f, -2.79255927e-01f, 3.23224187e-01f, 2.57004648e-01f, 2.18842566e-01f, 1.67684451e-01f, -2.40843326e-01f, 5.01342535e-01f, -1.10159241e-01f,
  1.73498422e-01f, -3.36839437e-01f, 1.35791227e-01f, -1.32396081e-02f, 3.49113606e-02f, 1.79669663e-01f, 1.43698663e-01f, 2.20865924e-02f, 1.00234553e-01f, -3.15583013e-02f,
  1.99546833e-02f, -8.84652585e-02f, -2.84450911e-02f, 9.66434926e-03f, 5.66239469e-02f, -5.12330346e-02f, -7.84280524e-02f, -9.11381468e-02f, 1.10211574e-01f, 1.14307459e-02f,
  -1.33309826e-01f, -1.91859573e-01f, 6.80396333e-02f, -5.65582775e-02f, 1.39768571e-01f, 9.15336311e-02f, -1.02234289e-01f, -1.16860464e-01f, 1.10888273e-01f, -2.44266674e-01f,
  1.12677999e-01f, -5.20441346e-02f, 8.24975222e-02f, 2.28161022e-01f, 1.68691203e-01f, 2.64758706e-01f, -1.89301714e-01f, 2.05555245e-01f, -8.15336555e-02f, 1.98918954e-01f,
  -1.00232065e-01f, 1.52587369e-01f, 1.10137925e-01f, 1.00537892e-02f, 4.87752706e-02f, 1.80947259e-02f, 1.26288757e-01f, 8.53020176e-02f, -5.75214811e-02f, -3.75785232e-02f,
  -8.53125677e-02f, 2.16548312e-02f, -9.84824300e-02f, 1.65592015e-01f, -3.07583034e-01f, -2.38412067e-01f, -6.63191751e-02f, 3.16095471e-01f, 3.21997076e-01f, 2.06358075e-01f,
  -2.10887496e-03f, 7.03748167e-02f, 1.55009955e-01f, 5.03918193e-02f, -3.18871252e-02f, -1.69084221e-01f, -2.64310569e-01f, -1.98895156e-01f, -1.55331507e-01f, -4.12706323e-02f,
  -2.51128972e-01f, 2.61757299e-02f, -3.38427067e-01f, -9.27507356e-02f, 5.49619459e-02f, -1.21609367e-01f, -5.72451763e-02f, -2.92673986e-02f, -2.22921721e-03f, -1.00538336e-01f,
  -3.23556252e-02f, 8.36513117e-02f, -4.14230004e-02f, 1.29194275e-01f, -2.59562761e-01f, 8.26710016e-02f, 6.72806501e-02f, -8.44880007e-03f, -1.49748608e-01f, -4.51667368e-01f,
  2.34314594e-02f, 2.68936872e-01f, 2.44699031e-01f, 2.03662291e-01f, -2.41016775e-01f, 3.20999235e-01f, 1.19747311e-01f, -1.27954721e-01f, 1.08497642e-01f, -2.37512484e-01f,
  1.12762973e-01f, 1.62766963e-01f, -1.42651185e-01f, -5.09928819e-03f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.04904301e-01f, -7.22914115e-02f, 1.74705744e-01f, -9.57859010e-02f, 1.20145589e-01f, -2.33109761e-02f, -4.30051349e-02f, 4.82479595e-02f, -7.27212280e-02f, -8.26224312e-02f,
  1.30787924e-01f, 1.25049083e-02f, -1.77616611e-01f, 4.81252111e-02f, -1.60960183e-01f, -2.25906051e-03f, 6.81083575e-02f, -1.46122694e-01f, 1.08463421e-01f, 3.91094275e-02f,
  1.49950497e-02f, 1.40595183e-01f, -2.85858326e-02f, 1.36491191e-02f, -1.20787628e-01f, -1.70736805e-01f, 8.07363093e-02f, 1.76204339e-01f, 2.74370071e-02f, -1.89917356e-01f,
  7.51981810e-02f, -9.23540220e-02f, 1.59113985e-02f, 1.79544002e-01f, 2.69294232e-01f, 9.06521380e-02f, 1.16873905e-01f, 2.99370348e-01f, 1.88257590e-01f, 1.02804758e-01f,
  4.65482883e-02f, -2.45268092e-01f, 1.24249496e-01f, -3.15329880e-02f, 2.21044853e-01f, -1.02129258e-01f, -3.37770544e-02f, 2.62617115e-02f, -5.72775602e-02f, 4.45847660e-02f,
  9.40272063e-02f, -2.03542635e-01f, 9.07851681e-02f, -2.17933059e-01f, -1.06472440e-01f, -2.07472116e-01f, 1.03226237e-01f, 2.63425022e-01f, -8.41128752e-02f, 4.56900001e-01f,
  -1.63002625e-01f, -7.85112232e-02f, -7.33182728e-02f, 4.84807193e-02f, -9.69614163e-02f, 1.35254130e-01f, 2.44871363e-01f, -1.13289550e-01f, 2.34353021e-01f, 3.27877849e-01f,
  3.28056604e-01f, -3.11974040e-03f, 1.41660318e-01f, 1.44503921e-01f, 1.30694802e-03f, 1.68369010e-01f, -2.23927170e-01f, -1.25661463e-01f, -1.78153366e-01f, -2.60528568e-02f,
  -1.35164395e-01f, -1.32578969e-01f, 1.81277141e-01f, 1.33176178e-01f, 7.07344487e-02f, 3.28142017e-01f, 1.10092573e-01f, 2.65684009e-01f, 4.73073542e-01f, 5.20442761e-02f,
  -1.93401799e-01f, -2.24215493e-01f, -3.86637077e-02f, 1.26616703e-02f, -2.37293765e-01f, -1.98881984e-01f, -1.25522181e-01f, -1.39424041e-01f, -5.17420024e-02f, 1.77251860e-01f,
  -9.26339999e-03f, -1.48494929e-01f, -1.10377520e-01f, 1.30580515e-01f, 9.42064226e-02f, 1.13626949e-01f, -1.50703847e-01f, -1.42448276e-01f, 1.47508532e-01f, 4.77747135e-02f,
  -9.65272933e-02f, 7.76861832e-02f, 2.08185613e-02f, 3.77175063e-02f, -9.97454375e-02f, 1.30306572e-01f, -1.31215513e-01f, -6.16882741e-03f, -9.79159027e-02f, 8.21948275e-02f,
  9.72132087e-02f, 1.64800733e-01f, -4.74861749e-02f, -7.53902271e-02f, -1.10506751e-01f, -1.25531539e-01f, 6.06952310e-02f, -1.28494069e-01f, -5.23136891e-02f, -4.48453315e-02f,
  -1.57758240e-02f, -1.50814861e-01f, 2.29994822e-02f, -7.70328194e-02f, 5.89208938e-02f, 6.21464401e-02f, 8.92454460e-02f, 2.30457019e-02f, 3.56223271e-03f, -1.03349976e-01f,
  8.22205003e-03f, -1.61713082e-02f, 1.23314112e-01f, -3.19790766e-02f, -1.66915849e-01f, 9.35947970e-02f, 6.58364296e-02f, -6.52844757e-02f, 1.06114656e-01f, -7.09610358e-02f,
  -1.00130811e-01f, 3.96695286e-02f, -1.34860530e-01f, -1.03453182e-01f, 3.15831006e-02f, 5.26664667e-02f, -9.73976776e-02f, -2.21204162e-02f, -5.10539599e-02f, -1.26121081e-02f,
  -5.44675700e-02f, -1.30321458e-01f, -7.29442239e-02f, -7.15496689e-02f, -1.10052012e-01f, 1.51243538e-01f, -3.59974504e-02f, 1.45697951e-01f, 2.22448647e-01f, 3.47473770e-02f,
  2.64963210e-01f, -7.78719410e-02f, 1.00767322e-01f, 2.78591504e-03f, 2.95136776e-02f, -8.75538513e-02f, 1.44562423e-01f, -1.26244038e-01f, -4.34971834e-03f, 7.83135369e-02f,
  5.53292558e-02f, -1.27209157e-01f, -5.53098582e-02f, -6.80617243e-02f, 3.15075740e-02f, 1.05994321e-01f, 2.20958188e-01f, -3.51362824e-02f, 3.01928163e-01f, -1.66637778e-01f,
  -2.98477896e-02f, 2.23603755e-01f, 1.24826446e-01f, -8.30962807e-02f, 1.71994805e-01f, 2.36231640e-01f, -1.46627888e-01f, 1.72952220e-01f, -2.79624369e-02f, 1.91100836e-01f,
  2.68936232e-02f, 3.66651267e-02f, -8.34074914e-02f, 1.51920943e-02f, 4.58118767e-02f, -2.62911230e-01f, 2.18336478e-01f, -2.90444866e-03f, -1.86771795e-01f, 3.59771214e-02f,
  -2.38093045e-02f, -2.75652166e-02f, 1.37610078e-01f, -2.47236684e-01f, 1.84775606e-01f, -4.79421429e-02f, 6.10548668e-02f, 1.22049704e-01f, 7.30166510e-02f, -7.37000778e-02f,
  -9.85813737e-02f, -1.73247769e-01f, -1.19371764e-01f, 2.43872657e-01f, -1.25601992e-01f, 2.15860516e-01f, 3.18441063e-01f, 2.58556038e-01f, 2.65437871e-01f, 5.12654474e-03f,
  2.86189076e-02f, 3.50025028e-01f, 3.03208400e-02f, 8.01413730e-02f, 5.47026433e-02f, 3.06826025e-01f, -5.57040870e-02f, -3.59437287e-01f, 3.41941923e-01f, 1.63845554e-01f,
  1.22383656e-02f, -2.82010883e-01f, 3.42041776e-02f, -1.65244758e-01f, -1.57689735e-01f, 2.27254450e-01f, -1.65685132e-01f, 6.45461455e-02f, 4.40458059e-01f, 3.96644890e-01f,
  7.61291683e-02f, 2.44783327e-01f, 8.74668583e-02f, 1.75895378e-01f, -3.30975980e-01f, 1.53370962e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -1.43914968e-01f, -7.21044764e-02f, 1.36524841e-01f, -1.55449271e-01f, -8.77054781e-02f, 4.70795706e-02f, 1.76701352e-01f, -7.57020712e-03f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.78971410e-01f, 1.61345422e-01f, 4.92595732e-02f, -1.67453870e-01f, 1.07213303e-01f, -1.32955521e-01f, 1.47226006e-01f, 2.76418090e-01f, -3.99245284e-02f, 7.45189711e-02f,
  -1.19940653e-01f, -1.14447623e-01f, 2.01718152e-01f, -5.16052395e-02f, -3.74260806e-02f, 2.65258372e-01f, 4.17009771e-01f, 2.24221990e-01f, 1.59118399e-01f, 1.22126490e-01f,
  -2.93304920e-01f, 7.86601678e-02f, -6.01363815e-02f, 2.84377635e-01f, -1.44267023e-01f, -2.18456343e-01f, -1.54829593e-02f, 1.12783991e-01f, 8.35682526e-02f, 1.44095272e-01f,
  -1.71471149e-01f, 1.53341889e-01f, 2.63522565e-02f, 5.61967194e-02f, 1.25298515e-01f, 1.89962406e-02f, 1.04669914e-01f, 4.47103195e-03f, 1.04309563e-02f, -3.51997942e-01f,
  -1.06301829e-01f, 2.26115640e-02f, 6.33997247e-02f, 6.20708913e-02f, 1.43702447e-01f, 7.63634741e-02f, 2.89070427e-01f, 7.98648782e-03f, -1.29512578e-01f, -4.92393263e-02f,
  -1.42390713e-01f, -1.14806272e-01f, 3.63836855e-01f, 1.04272582e-01f, 3.78770620e-01f, -1.92798078e-02f, -1.10329688e-01f, -1.54299643e-02f, 2.94767588e-01f, -1.66303471e-01f,
  -9.04911533e-02f, 7.16937855e-02f, 2.43645400e-01f, -1.71678752e-01f, 1.91485822e-01f, 2.21535265e-01f, 1.34528756e-01f, 3.05770367e-01f, -1.96542412e-01f, -4.51209471e-02f,
  2.33580425e-01f, -8.29684455e-03f, -1.70126393e-01f, 2.39494517e-01f, -7.26330653e-02f, 1.42264798e-01f, -3.59800577e-01f, 1.80156589e-01f, 1.41381219e-01f, 6.74668923e-02f,
  -2.92581052e-01f, -2.39085630e-01f, -2.22913757e-01f, -2.95653343e-02f, 2.01653466e-01f, -2.87267584e-02f, 7.75337666e-02f, -3.28727424e-01f, 1.10203624e-01f, -2.25694254e-02f,
  -2.56387498e-02f, 4.16658558e-02f, -4.12193500e-02f, -1.55368268e-01f, -1.05934717e-01f, -4.04847592e-01f, -2.30031461e-01f, -3.11809517e-02f, -8.85813162e-02f, 1.84762269e-01f,
  -7.73990005e-02f, -4.77975532e-02f, 4.07188721e-02f, 3.12989295e-01f, 1.10291146e-01f, 1.58785582e-01f, 6.35089576e-02f, -1.89006612e-01f, -3.15776587e-01f, 1.47816420e-01f,
  7.16338307e-02f, 5.26387356e-02f, 1.93684071e-01f, 6.35032207e-02f, -9.95176136e-02f, 1.79542616e-01f, -8.72423500e-02f, -1.83485329e-01f, 1.23853765e-01f, -2.03516096e-01f,
  7.15281591e-02f, -1.42894566e-01f, -2.02257365e-01f, 5.48253618e-02f, -7.59014785e-02f, 1.72768924e-02f, -2.64626473e-01f, -1.88986227e-01f, -1.34750053e-01f, 2.57259756e-01f,
  -1.54164918e-02f, 2.12765947e-01f, -1.86632592e-02f, 2.11296648e-01f, -9.42570716e-02f, 1.84801042e-01f, -9.18450207e-02f, 2.52128281e-02f, 1.58839539e-01f, 1.18871570e-01f,
  -5.56330621e-01f, 1.43213887e-02f, 8.21492523e-02f, 1.90210149e-01f, 1.20277241e-01f, -3.42301816e-01f, -4.00480419e-01f, -2.07044389e-02f, 9.22088549e-02f, 4.10642549e-02f,
  3.29331785e-01f, -4.31037229e-03f, 4.54853922e-02f, -3.94624025e-02f, -2.40613401e-01f, -5.27285412e-02f, -4.73223664e-02f, -1.67749356e-02f, -1.01852886e-01f, -5.55800080e-01f,
  -1.24094617e-02f, -2.63875574e-01f, 4.74456046e-03f, -2.52724260e-01f, -2.83057630e-01f, -1.33929282e-01f, -1.89003587e-01f, -2.34641567e-01f, 1.85319006e-01f, -3.99246849e-02f,
  -7.75441676e-02f, 2.23378564e-04f, 2.31386200e-01f, 3.06533158e-01f, -3.38970631e-01f, -3.68339092e-01f, -2.94999897e-01f, 1.03953317e-01f, -5.90734668e-02f, -2.52398074e-01f,
  3.99789922e-02f, 2.44129807e-01f, -2.84425050e-01f, -2.68160552e-01f, -9.74554121e-02f, 2.61984944e-01f, -3.54345739e-01f, -2.62088049e-02f, -2.59794779e-02f, -1.11001566e-01f,
  2.09686533e-01f, 9.01596546e-02f, 1.55983612e-01f, -1.01699801e-02f, 1.40487522e-01f, 2.94025391e-02f, -7.53783286e-02f, 7.97249377e-03f, -3.91829088e-02f, -1.61281630e-01f,
  -1.31509572e-01f, -1.66545331e-01f, 1.74596801e-01f, 8.67404789e-02f, -1.15643941e-01f, 3.42472136e-01f, -5.88183897e-03f, -1.95803806e-01f, -4.30713147e-01f, 1.17936760e-01f,
  -1.00514777e-01f, 7.01938048e-02f, 1.66942582e-01f, 1.00512221e-01f, -3.28811184e-02f, -2.77711838e-01f, 9.22439212e-04f, 5.22736199e-02f, -1.75610483e-01f, -6.10377593e-03f,
  9.57930386e-02f, -1.01478063e-01f, 1.50413111e-01f, -1.72240138e-01f, -9.70586091e-02f, 2.96324700e-01f, -2.22005427e-01f, 4.47081365e-02f, 9.57575068e-02f, -8.79006460e-02f,
  -4.07675840e-02f, 2.20313966e-01f, 1.49246335e-01f, 1.24601103e-01f, -1.14939427e-02f, 3.71181548e-01f, -1.04966097e-01f, -4.38108265e-01f, 2.56687820e-01f, 1.87871397e-01f,
  6.28299356e-01f, -1.11578248e-01f, 5.46190627e-02f, 1.58072740e-01f, 1.21248931e-01f, -3.15736681e-02f, 1.04382962e-01f, 4.65478122e-01f, 1.32002369e-01f, -1.56000078e-01f,
  3.79877657e-01f, -6.46217912e-02f, -1.18069462e-01f, 2.12211832e-01f, -8.96403473e-03f, 2.00295731e-01f, -1.81830809e-01f, -2.32838273e-01f, -1.21841608e-02f, -1.10825956e-01f,
  6.04902906e-03f, -3.56020331e-02f, -2.75013536e-01f, -8.80514607e-02f, -7.49130845e-02f, 1.29136503e-01f, -3.27675417e-02f, -1.72924265e-01f, 1.71816677e-01f, 6.70196190e-02f,
  -3.47395867e-01f, -4.95806038e-02f, -1.38488770e-01f, 1.25865877e-01f, 2.10672393e-01f, -1.39302593e-02f, -1.71344653e-01f, 1.47233248e-01f, -6.24469630e-02f, -2.92354226e-01f,
  2.08108686e-02f, 8.12219307e-02f, -1.49204984e-01f, 1.25264570e-01f, 9.97499749e-02f, 4.47389036e-02f, -1.62895218e-01f, -1.05589889e-01f, -1.04401909e-01f, 1.09435476e-01f,
  6.15777336e-02f, -3.39511633e-02f, 2.90852904e-01f, -5.61921857e-02f, 2.60262161e-01f, -5.58791533e-02f, -1.00828804e-01f, -1.11990623e-01f, -9.74045768e-02f, 3.01077485e-01f,
  -4.26466689e-02f, -2.55313188e-01f, 1.28362849e-01f, -1.34234792e-02f, 1.15332447e-01f, 1.04149349e-01f, -9.26944148e-03f, -2.33820707e-01f, 1.58243597e-01f, 1.14805207e-01f,
  1.76508456e-01f, 3.43823642e-01f, -1.41234726e-01f, 5.13641350e-02f, 2.76031286e-01f, -1.35845482e-01f, 5.93497679e-02f, -4.36889678e-02f, 8.67314339e-02f, 1.05960250e-01f,
  -2.71468431e-01f, -8.67134258e-02f, -3.29309344e-01f, -1.45241156e-01f, 3.00953090e-02f, -1.47535115e-01f, -1.32540446e-02f, -1.23538800e-01f, 1.34090811e-01f, -1.46438146e-03f,
  -3.63142014e-01f, 3.07421744e-01f, -7.38148838e-02f, -4.09521103e-01f, -4.89904620e-02f, 1.46612018e-01f, 5.12275696e-01f, 1.16503369e-02f, 4.45436120e-01f, -4.75753807e-02f,
  -3.47361684e-01f, -2.40992248e-01f, -1.41437547e-02f, 3.57861638e-01f, -3.86781432e-02f, -3.57662767e-01f, 1.48507893e-01f, -1.06937952e-01f, -1.62910655e-01f, 2.27138832e-01f,
  -1.39123410e-01f, 2.24137053e-01f, -1.29695699e-01f, -2.17573568e-01f, 1.56955607e-02f, -1.98587000e-01f, -1.67130888e-01f, -1.28702328e-01f, -2.79738784e-01f, 1.27136245e-01f,
  -8.13867301e-02f, -4.15857285e-02f, -3.82416919e-02f, -6.08100295e-02f, 2.50380691e-02f, 1.47232398e-01f, -1.63070243e-02f, -1.73670784e-01f, 1.18959270e-01f, -1.75695285e-01f,
  -5.12882806e-02f, -6.98193237e-02f, -7.73523673e-02f, 8.20297003e-02f, 7.84385800e-02f, 3.07796746e-02f, -2.92101521e-02f, 2.15782776e-01f, -2.19592769e-02f, -3.50684300e-02f,
  1.32423729e-01f, -4.72457968e-02f, -1.77221984e-01f, 1.87623322e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  5.98807298e-02f, 1.53528869e-01f, 6.05963431e-02f, -1.41909420e-01f, -1.59316063e-01f, 7.06902891e-02f, 1.74101221e-03f, -1.33873910e-01f, -1.57701224e-02f, -1.49274454e-01f,
  2.78821960e-02f, 1.23842426e-01f, -3.81465927e-02f, 1.03519447e-01f, 1.00309834e-01f, 1.41401440e-01f, 1.74476981e-01f, -1.13352083e-01f, 1.41800195e-01f, -1.30442291e-01f,
  -1.20935276e-01f, -9.00573097e-03f, 1.59557648e-02f, -1.46086290e-01f, -1.29962368e-02f, -1.74431577e-01f, -2.34941263e-02f, -1.33710355e-01f, -1.45745397e-01f, -1.66933686e-01f,
  -1.67758111e-03f, 1.19670667e-01f, 2.94390827e-01f, 1.88877046e-01f, 1.32034957e-01f, 1.59961879e-01f, -1.34158880e-03f, 1.74441397e-01f, 1.60548702e-01f, 1.99437127e-01f,
  1.28525108e-01f, 2.97424495e-01f, 1.85661837e-01f, 2.09883854e-01f, -4.74440157e-01f, -1.08556338e-01f, 3.86134654e-01f, 1.44594356e-01f, -1.75355613e-01f, -4.71870333e-01f,
  -4.47569430e-01f, -1.66201577e-01f, 5.86619318e-01f, 2.07580272e-02f, 2.39989668e-01f, -1.66496977e-01f, 1.35343462e-01f, 7.89443776e-02f, 1.92856282e-01f, 6.06702082e-02f,
  -1.31930247e-01f, 1.84582934e-01f, 2.26769343e-01f, -4.27400440e-01f, 2.08269194e-01f, 1.90716967e-01f, -5.26099093e-02f, 2.72086322e-01f, -2.52795190e-01f, 2.59251028e-01f,
  5.88738099e-02f, 2.64402293e-02f, -6.33210912e-02f, 9.22278911e-02f, 2.51010597e-01f, 3.46301892e-03f, 3.37130134e-03f, -8.82610828e-02f, 1.58279479e-01f, -1.06831044e-02f,
  -2.29098380e-01f, -9.38550532e-02f, -2.82759547e-01f, -8.15001354e-02f, 2.34005824e-01f, -9.87543911e-02f, 1.03270702e-01f, -2.82363921e-01f, 8.92780051e-02f, 2.27480397e-01f,
  1.75836146e-01f, 1.48659050e-01f, -1.39035964e-02f, 9.58684459e-02f, 3.69664538e-03f, -5.09469435e-02f, 8.15323181e-03f, 8.18544254e-03f, -1.54159367e-01f, 1.81172386e-01f,
  -1.24510683e-01f, -3.62145714e-02f, -1.50907040e-02f, 1.18349362e-02f, 1.52500952e-02f, -5.78665622e-02f, -7.56445825e-02f, 1.76900327e-01f, -1.93279713e-01f, -1.61179781e-01f,
  8.92879441e-02f, 2.39876825e-02f, 8.10706615e-03f, 1.08759470e-01f, 9.55979079e-02f, -3.12122665e-02f, 5.45066856e-02f, -1.30779162e-01f, 4.07726038e-03f, 8.06243643e-02f,
  1.02103621e-01f, -8.96240957e-03f, -1.08305745e-01f, -3.91091146e-02f, 9.76210982e-02f, 1.82992905e-01f, 1.49671406e-01f, -1.40756220e-01f, 4.18256998e-01f, 6.15233481e-01f,
  1.64185703e-01f, 5.21543801e-01f, 2.83093929e-01f, 7.63577074e-02f, 4.05012399e-01f, -1.40556231e-01f, -3.28731388e-02f, 4.07927126e-01f, 1.69228911e-01f, 3.59305531e-01f,
  3.62048715e-01f, -3.10050905e-01f, 4.75496687e-02f, 2.40513757e-01f, -8.25961605e-02f, 2.82672197e-01f, 5.29796220e-02f, -2.75898904e-01f, -6.05504587e-02f, -2.68878043e-01f,
  2.60089129e-01f, 3.65942150e-01f, -1.21455655e-01f, -2.10113332e-01f, 6.61198497e-01f, 1.10650614e-01f, 1.33294016e-02f, -3.22900653e-01f, -2.67848849e-01f, 2.88765579e-01f,
  1.46454975e-01f, 3.44160087e-02f, 3.04024573e-02f, 5.84493997e-03f, -1.75862551e-01f, 4.95767780e-02f, 2.52441149e-02f, -1.42778441e-01f, -1.48478776e-01f, 1.30774021e-01f,
  -1.04111671e-01f, -4.85687740e-02f, -9.12035909e-03f, 5.15601188e-02f, -1.55387461e-01f, 5.09550646e-02f, 8.02528262e-02f, 1.09966971e-01f, 6.56384081e-02f, 1.40987160e-02f,
  -6.37009516e-02f, 1.56578735e-01f, -1.17203563e-01f, 7.14405179e-02f, -7.22480416e-02f, -1.03177354e-01f, 1.01985246e-01f, 1.43945605e-01f, 1.22179516e-01f, -1.64566981e-03f,
  9.01987180e-02f, 4.82239164e-02f, -7.43944496e-02f, -2.72704568e-02f, 6.13891240e-03f, 2.09917128e-02f, -1.38489142e-01f, -1.20096751e-01f, 2.40651853e-02f, -9.89536792e-02f,
  9.02614444e-02f, -1.65762559e-01f, -1.70417681e-01f, -1.65240347e-01f, -9.67620090e-02f, -8.46114084e-02f, 6.18562959e-02f, -1.95226267e-01f, 1.69861943e-01f, -1.10134244e-01f,
  1.25352843e-02f, 7.61035713e-04f, -2.75365971e-02f, 6.73681051e-02f, -5.55538796e-02f, 1.53935656e-01f, -1.58267152e-02f, 1.11118570e-01f, -7.30297156e-03f, 1.46311283e-01f,
  -1.61424011e-01f, -1.06507398e-01f, -1.54026430e-02f, 2.72386432e-01f, 2.45637998e-01f, -2.16364786e-01f, 2.10385740e-01f, -9.99711454e-04f, 8.93127825e-03f, 1.72982626e-02f,
  -9.98455286e-02f, 7.62934834e-02f, 2.41882026e-01f, -1.71543151e-01f, -1.09115548e-01f, -1.63285688e-01f, 9.66525599e-02f, 9.58342552e-02f, -7.77644217e-02f, -3.38457316e-01f,
  -2.61998773e-01f, 1.16971761e-01f, -1.00020766e-01f, -1.68943197e-01f, -3.55282664e-01f, 7.02022910e-02f, -1.57759264e-01f, 9.52375471e-04f, -3.78164910e-02f, 4.37167913e-01f,
  2.74689078e-01f, 2.72048749e-02f, -9.79907811e-03f, 1.42570868e-01f, 3.38960052e-01f, 6.12304449e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -1.80468082e-01f, 3.38416457e-01f, 2.28985116e-01f, 1.32415071e-01f, 1.60238922e-01f, -5.07011376e-02f, 1.72669739e-01f, 1.98443577e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.30232662e-01f, -8.14655498e-02f, -4.42991331e-02f, -1.89964414e-01f, 1.00749508e-01f, 8.26088488e-02f, -5.41686406e-03f, 8.33916292e-03f, -2.51538396e-01f, -2.62135684e-01f,
  1.33254036e-01f, -1.75386682e-01f, -1.45677760e-01f, 4.24127221e-01f, 1.87057003e-01f, -9.19357687e-02f, 3.53209257e-01f, -7.07820011e-03f, -8.24818760e-02f, 2.63107747e-01f,
  -1.63177356e-01f, 3.73757273e-01f, -2.75488198e-01f, -1.52206257e-01f, -1.16272733e-01f, 5.10395646e-01f, 7.11266473e-02f, 1.64213642e-01f, -6.38673082e-02f, 1.44506440e-01f,
  1.00529917e-01f, -3.56411606e-01f, 1.71883747e-01f, -9.05327350e-02f, -3.50203924e-02f, 4.80962954e-02f, -3.22251529e-01f, 1.54180348e-01f, -7.46831819e-02f, -6.74213916e-02f,
  1.81459948e-01f, 2.14220345e-01f, -1.81420535e-01f, 2.00582191e-01f, -1.86706156e-01f, -2.37745136e-01f, 8.63292515e-02f, 2.05741510e-01f, 2.65701354e-01f, 2.04564810e-01f,
  2.32476205e-01f, -2.98877388e-01f, 2.71004856e-01f, -2.09043860e-01f, 1.13418609e-01f, 2.51990974e-01f, 1.41096711e-01f, 5.05274422e-02f, 1.05037898e-01f, 3.56534198e-02f,
  -5.81044436e-01f, -8.81843865e-02f, -7.96663463e-02f, 2.98988193e-01f, 1.26321718e-01f, 1.20822273e-01f, 5.47432341e-02f, 8.20531473e-02f, 6.73892796e-02f, -1.28902063e-01f,
  1.45682052e-01f, -3.21649499e-02f, 2.35294178e-01f, -1.16532229e-01f, 4.23847258e-01f, -1.08290441e-01f, 2.11857244e-01f, 7.15892985e-02f, -2.18143150e-01f, -2.07414940e-01f,
  -2.25232899e-01f, -1.19838538e-03f, -2.56117105e-01f, 2.52833366e-01f, 1.20120987e-01f, 2.73363292e-01f, 3.65056753e-01f, -9.70425233e-02f, -1.35309890e-01f, -3.50889057e-01f,
  -2.67515838e-01f, 6.28637746e-02f, 3.72012943e-01f, -6.44827783e-02f, -8.57990235e-02f, -2.26091594e-02f, -2.79304951e-01f, -9.40193385e-02f, -2.08292425e-01f, -4.05115709e-02f,
  -2.04425678e-01f, 2.07466200e-01f, 6.99502677e-02f, 1.31271482e-01f, -1.77254990e-01f, -1.62411090e-02f, -5.32198429e-01f, 6.41693249e-02f, -1.98947236e-01f, 1.51432276e-01f,
  2.71795064e-01f, 3.16864200e-04f, -4.02575433e-02f, 1.24544948e-01f, 2.75597870e-01f, -3.54609072e-01f, -8.81124567e-03f, -1.43064111e-01f, -2.45594993e-01f, 2.25754455e-03f,
  -3.21239792e-02f, 2.16895528e-02f, 1.29848972e-01f, -4.62710522e-02f, -4.40289050e-01f, -8.22443590e-02f, 4.18996103e-02f, 3.58323872e-01f, 1.37884505e-02f, -1.21966310e-01f,
  -6.80149198e-02f, 1.91804245e-01f, -1.18104950e-01f, -1.90990921e-02f, -1.85803980e-01f, -2.56688088e-01f, -1.82764232e-01f, -8.36949497e-02f, 2.59097576e-01f, -3.86713892e-02f,
  2.94966131e-01f, -3.87895368e-02f, -4.58629429e-02f, 2.15579957e-01f, 1.97036192e-01f, -4.30226356e-01f, -3.67631614e-01f, 3.31754774e-01f, -7.07402825e-02f, -4.25199978e-02f,
  3.41439515e-01f, -6.38746768e-02f, 1.62472814e-01f, 1.60164699e-01f, -5.06521389e-02f, 1.89723298e-01f, 3.01204890e-01f, -1.76115558e-02f, -6.84010014e-02f, -3.70884001e-01f,
  1.23733699e-01f, -1.06918029e-01f, 1.60680369e-01f, 1.98120959e-02f, -1.29757211e-01f, -4.68864478e-02f, -1.31783098e-01f, -5.39964356e-04f, -1.70869365e-01f, -8.65861624e-02f,
  3.87853503e-01f, -1.11467808e-01f, 2.10642874e-01f, -4.26466167e-02f, 9.96475220e-02f, 4.79743071e-02f, -1.56973824e-01f, -1.63704231e-01f, -4.77579497e-02f, 1.26517326e-01f,
  -1.45341918e-01f, -1.45343632e-01f, -1.01116896e-01f, -2.76500255e-01f, -1.64320543e-01f, -1.16789140e-01f, -1.33450523e-01f, 1.26655042e-01f, 5.47005355e-01f, 5.27323484e-02f,
  -9.56839919e-02f, -2.87224293e-01f, 2.63204068e-01f, 5.40407673e-02f, 7.15078935e-02f, -1.86626539e-02f, 1.12415038e-01f, -1.94610476e-01f, -4.24074084e-02f, -3.43934983e-01f,
  -2.61101991e-01f, -1.20829366e-01f, 4.62600887e-01f, 8.92476439e-02f, -2.57192068e-02f, -7.87190422e-02f, 1.53708398e-01f, -1.97224077e-02f, 2.41231620e-01f, -3.23042542e-01f,
  -7.52627850e-02f, 3.84100787e-02f, -3.68127115e-02f, 1.71959937e-01f, -2.34941065e-01f, -1.51980326e-01f, -4.57321592e-02f, 1.63061723e-01f, 2.31583878e-01f, 1.64454177e-01f,
  3.27632457e-01f, -1.10128686e-01f, -1.59542933e-01f, -4.27473605e-01f, -5.63564040e-02f, -2.85081446e-01f, -2.66344436e-02f, -3.38177949e-01f, -1.16918191e-01f, -7.96894357e-02f,
  -1.94551140e-01f, -7.41055980e-02f, 1.83425401e-03f, -1.99472636e-01f, 2.39161387e-01f, -1.12190969e-01f, 7.69822598e-02f, 1.27193674e-01f, -2.20524445e-01f, -2.71313757e-01f,
  -2.77518094e-01f, -1.75046653e-01f, -1.54557480e-02f, 3.46580356e-01f, -1.81640342e-01f, 1.13533370e-01f, -1.30194649e-01f, 8.79221410e-03f, 1.26179472e-01f, -2.36998647e-01f,
  -2.21040741e-01f, -4.72487099e-02f, 5.68629622e-01f, -6.42983913e-02f, 1.27669781e-01f, -1.13123178e-01f, -9.18082520e-02f, -2.74702072e-01f, 3.86941046e-01f, -3.65312099e-01f,
  1.02222212e-01f, 1.03918202e-01f, 1.41441405e-01f, 2.36919895e-01f, 2.88128573e-02f, -5.66657335e-02f, 1.95970386e-01f, -1.76460743e-01f, -2.09878385e-01f, 1.35679588e-01f,
  -2.02682570e-01f, -2.43124813e-01f, -4.43929255e-01f, 2.22984999e-01f, 1.82335392e-01f, -8.54662508e-02f, -1.35983989e-01f, -3.95634957e-02f, -4.38218594e-01f, -2.52375722e-01f,
  -6.72202781e-02f, -2.53400356e-01f, 1.67868301e-01f, 1.32992536e-01f, 2.71483928e-01f, 1.90225914e-02f, -1.20813737e-03f, 2.02954084e-01f, -3.28391075e-01f, -4.70122471e-02f,
  -1.15693532e-01f, 3.83651145e-02f, -1.72720194e-01f, 1.23110093e-01f, -1.46499187e-01f, -9.74357948e-02f, -2.07761452e-01f, -2.20433742e-01f, 2.15507030e-01f, -1.00714415e-01f,
  2.40687400e-01f, -2.68385172e-01f, -1.11797571e-01f, 1.79442726e-02f, -2.56155610e-01f, -3.09046209e-01f, -2.80657977e-01f, 1.48359314e-01f, 6.03050217e-02f, 1.49811849e-01f,
  2.17385255e-02f, 3.76642239e-03f, 5.96885122e-02f, -2.26978436e-01f, -5.72437681e-02f, -7.92837292e-02f, 4.85279411e-01f, -9.46466550e-02f, 2.40861680e-02f, -4.84169647e-02f,
  -1.34746328e-01f, 7.57714435e-02f, 1.25116840e-01f, -3.32970805e-02f, 1.37721866e-01f, 2.10128039e-01f, 1.39289601e-02f, 2.37210959e-01f, -2.20665127e-01f, 3.67401540e-02f,
  4.73750234e-02f, -1.38988569e-02f, -4.05540645e-01f, 4.50213104e-01f, 2.64824718e-01f, 5.28191291e-02f, 4.45169747e-01f, 1.64339412e-02f, 3.32644880e-01f, 6.37011677e-02f,
  -2.25423470e-01f, 1.00995436e-01f, -3.84738833e-01f, 8.49928614e-03f, 1.64413005e-02f, 1.55236840e-01f, 2.22799212e-01f, -1.57578647e-01f, 1.06963262e-01f, -5.28928190e-02f,
  -1.31588176e-01f, 5.76474182e-02f, 1.49416372e-01f, 4.50642891e-02f, -2.94686973e-01f, 2.10487515e-01f, -1.57433346e-01f, -3.59171897e-01f, 1.31229863e-01f, -4.00818199e-01f,
  5.72409779e-02f, 1.31319046e-01f, 1.38613969e-01f, 1.42697766e-02f, 4.30612713e-01f, 3.06667257e-02f, -1.91977412e-01f, 2.73228198e-01f, 3.29843253e-01f, -5.10056257e-01f,
  -3.88656676e-01f, 3.04431409e-01f, -8.30276385e-02f, 3.90253887e-02f, 4.95928198e-01f, -4.18599602e-03f, 3.96346934e-02f, 1.01534620e-01f, -1.87204748e-01f, -1.75767764e-02f,
  2.08845153e-01f, 1.71921030e-01f, 4.30607311e-02f, -8.30885917e-02f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.97816864e-01f, -1.08508535e-01f, 3.15077096e-01f, -9.54320878e-02f, -1.07369043e-01f, 1.14404447e-01f, 1.55910579e-02f, 4.80257198e-02f, -2.46770188e-01f, -2.44512246e-03f,
  1.34448975e-01f, -8.50242376e-02f, -1.54144410e-02f, 2.59015143e-01f, 2.95961779e-02f, -2.01637715e-01f, -8.52541104e-02f, -1.76495776e-01f, -6.12597689e-02f, 1.06878541e-01f,
  -2.31811672e-01f, 3.88505161e-01f, -4.63094264e-02f, -8.74124616e-02f, 1.74669310e-01f, 8.25716034e-02f, 2.64048249e-01f, -1.80172965e-01f, 6.86097980e-01f, 5.28262481e-02f,
  -4.62978780e-02f, 9.04747192e-03f, 1.99958041e-01f, -4.93127033e-02f, 1.78225726e-01f, -8.78586899e-03f, 1.90346599e-01f, -2.48506889e-01f, 1.01467192e-01f, 1.25872552e-01f,
  6.07378110e-02f, 2.81798184e-01f, -2.52033681e-01f, -1.10226804e-02f, 5.85210472e-02f, -3.28948013e-02f, -8.26100409e-02f, -3.23374718e-02f, -2.39560008e-01f, -5.98259037e-03f,
  -4.46513221e-02f, -2.60665238e-01f, 1.19588450e-01f, -2.63422698e-01f, -7.59617686e-02f, 2.34082639e-01f, -2.53819544e-02f, -1.32359520e-01f, 6.75042868e-02f, -5.84837124e-02f,
  -7.60823414e-02f, -5.66097535e-02f, 4.40950654e-02f, 2.18925804e-01f, -1.62164948e-03f, 1.58153221e-01f, -9.10192281e-02f, -1.32751435e-01f, 3.51529457e-02f, -5.47885858e-02f,
  -1.27602071e-01f, -1.58021793e-01f, 1.62972823e-01f, 9.16550532e-02f, 1.46794900e-01f, 1.32700637e-01f, 1.52750999e-01f, -4.85138707e-02f, 4.38362472e-02f, 1.19935744e-01f,
  1.72110900e-01f, 4.03896347e-02f, 1.00620195e-01f, 8.02303702e-02f, -3.94102708e-02f, -9.97146815e-02f, -1.80883303e-01f, 1.76845193e-01f, 1.76610462e-02f, -8.95681903e-02f,
  -1.70981869e-01f, -1.43303901e-01f, -1.76695287e-01f, 7.03068674e-02f, 3.85938250e-02f, -4.80079986e-02f, -4.36435789e-02f, -7.30509833e-02f, 7.60499015e-02f, -1.28672644e-01f,
  7.26290941e-02f, -1.30239099e-01f, 2.14636642e-02f, 6.30511940e-02f, -1.29625827e-01f, -1.83304995e-01f, 4.12138030e-02f, -2.07663439e-02f, -1.48562137e-02f, -4.52229008e-02f,
  -4.71592098e-02f, -1.49136633e-02f, -8.04671198e-02f, 4.52172719e-02f, -4.15040888e-02f, 1.55375779e-01f, 1.61428586e-01f, 1.53334826e-01f, -3.19650397e-04f, -1.54065013e-01f,
  1.29392073e-01f, -1.51040241e-01f, 1.50068045e-01f, 1.35282397e-01f, -3.00573036e-02f, -9.95500907e-02f, -1.65216804e-01f, -2.73206830e-03f, -7.95451850e-02f, 5.99022917e-02f,
  -1.33786246e-01f, -1.21910296e-01f, -7.63609931e-02f, 1.80283431e-02f, 1.85195103e-01f, -5.92958592e-02f, 1.43344119e-01f, -3.04960571e-02f, 8.56366530e-02f, 2.31006980e-01f,
  3.76456320e-01f, -4.37639691e-02f, -4.69778538e-01f, -3.99596363e-01f, -4.21202779e-01f, -1.27547577e-01f, -3.25731665e-01f, 3.95292312e-01f, -1.32315844e-01f, 1.32101327e-01f,
  3.44544619e-01f, 3.80516425e-02f, -3.20663080e-02f, -3.61668319e-01f, -1.98339954e-01f, -7.34009892e-02f, 5.51943183e-01f, 3.72633524e-02f, 2.66590744e-01f, 6.23443663e-01f,
  7.83174038e-02f, 2.51470715e-01f, 1.53865218e-01f, 6.83299778e-03f, 2.18705013e-01f, 2.30286941e-01f, 9.38658416e-02f, 1.42883077e-01f, -1.50471032e-01f, 8.09149072e-02f,
  -6.89280778e-02f, 2.20155045e-01f, -2.90141433e-01f, 4.71024513e-01f, 4.56570536e-01f, -4.72204462e-02f, 5.30170500e-01f, -3.26676339e-01f, 1.28861666e-01f, 1.54539496e-01f,
  -2.66860187e-01f, 7.76748955e-02f, -2.54964441e-01f, -1.93433151e-01f, 1.53754905e-01f, 8.23111832e-01f, 3.62436831e-01f, 5.85869364e-02f, 6.82878718e-02f, -3.88436690e-02f,
  -5.66435680e-02f, -2.98538357e-01f, 9.44582671e-02f, -7.78242871e-02f, -2.27535620e-01f, 2.96433777e-01f, -5.59994951e-02f, 1.38575584e-01f, -9.76100713e-02f, -2.10463941e-01f,
  -1.17234755e-02f, -2.63796113e-02f, 4.92406897e-02f, 1.61206171e-01f, 6.25050291e-02f, -6.27982020e-02f, 1.84148237e-01f, 2.97474653e-01f, 2.37456948e-01f, -7.87202194e-02f,
  2.03759875e-02f, -1.74985707e-01f, -1.23056047e-01f, 8.23345631e-02f, 1.14392579e-01f, 3.18813585e-02f, -1.18577927e-02f, 4.34765399e-01f, 1.50384411e-01f, -6.77234679e-02f,
  -5.12071364e-02f, -7.89088085e-02f, -2.91067250e-02f, -2.15731457e-01f, -1.12984821e-01f, 1.74843855e-02f, 2.18170360e-01f, 2.41538495e-01f, 5.44277668e-01f, 5.07048309e-01f,
  3.60440701e-01f, 4.44734842e-01f, 2.92423993e-01f, 3.82720791e-02f, -2.48406798e-01f, 2.77413636e-01f, -4.05815333e-01f, 2.54639059e-01f, 3.90917361e-01f, 2.07400527e-02f,
  2.05095544e-01f, 2.99999565e-01f, 3.19533139e-01f, 8.04164335e-02f, -5.29189855e-02f, -1.75787523e-01f, -5.27517080e-01f, -1.85124144e-01f, 3.73993851e-02f, 4.87165630e-01f,
  2.51663923e-01f, -8.24861079e-02f, 4.00806814e-01f, 1.30866915e-01f, -1.69952795e-01f, -1.54811190e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  8.26184005e-02f, -2.89670303e-02f, 8.04848373e-02f, 1.04732938e-01f, 2.05417737e-01f, 3.00852060e-01f, -4.79284711e-02f, 7.78240412e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -5.17701030e-01f, -3.34064037e-01f, 1.04438625e-01f, -3.16828370e-01f, -4.11833107e-01f, -2.80360073e-01f, -2.93942899e-01f, -1.69677176e-02f, -1.30801141e-01f, 1.51098594e-01f,
  5.00362813e-01f, 1.73960999e-01f, -1.86096296e-01f, 3.45776796e-01f, -3.90121520e-01f, 7.08494067e-01f, -6.62957951e-02f, -4.29957211e-01f, -4.47239578e-01f, -4.73008931e-01f,
  1.57281056e-01f, -6.02495372e-01f, -1.50178894e-01f, -5.14052331e-01f, -3.34273279e-01f, 4.25610989e-01f, 1.87297955e-01f, 4.86164838e-02f, 3.83868128e-01f, -3.99789244e-01f,
  -1.53895363e-01f, -4.11288649e-01f, -2.31436789e-01f, 2.92831182e-01f, 8.52746796e-03f, 3.79449248e-01f, 3.59005570e-01f, 3.77861947e-01f, -1.24546848e-01f, 5.15725911e-01f,
  5.10808945e-01f, 3.56439233e-01f, 9.82860401e-02f, 2.36098632e-01f, -3.37860018e-01f, 2.27982789e-01f, 5.13281882e-01f, -4.20691848e-01f, -2.48276144e-02f, -7.02467784e-02f,
  -4.00188506e-01f, 1.89813778e-01f, 1.43804669e-01f, 3.37033570e-01f, -6.64455414e-01f, 5.59409380e-01f, -3.88139844e-01f, -5.34118414e-02f, -3.48906480e-02f, -8.86824355e-02f,
  6.05397224e-01f, -3.56226116e-01f, 4.48345430e-02f, -7.88142860e-01f, 5.76922596e-01f, 3.99238080e-01f, 2.07524836e-01f, 4.28322345e-01f, -2.90621221e-01f, 3.14635277e-01f,
  5.29488921e-01f, 3.26522410e-01f, -6.30105376e-01f, 1.10435456e-01f, -5.27657807e-01f, -1.10889010e-01f, 5.21981299e-01f, -4.91793811e-01f, -1.91269577e-01f, 4.10752267e-01f,
  -4.90645975e-01f, -2.45149180e-01f, 4.49581854e-02f, 1.88736737e-01f, -4.08046514e-01f, -2.70217538e-01f, 2.23756939e-01f, -4.26599056e-01f, 2.11348593e-01f, -2.16214776e-01f,
  1.22553930e-02f, -6.54216036e-02f, -9.33880210e-02f, 1.44676521e-01f, -1.40568063e-01f, 3.35817665e-01f, 2.65622795e-01f, -2.22466424e-01f, -6.52955174e-01f, -2.09264830e-01f,
  1.68047816e-01f, -1.85510769e-01f, 1.64383173e-01f, -4.87631023e-01f, 3.54579866e-01f, -3.06704491e-01f, -3.35435778e-01f, 2.34590709e-01f, 4.73749340e-01f, 2.09571317e-01f,
  5.69663495e-02f, 3.97457749e-01f, -3.24810296e-01f, -2.92005330e-01f, -2.91982830e-01f, 1.40528813e-01f, -6.63069665e-01f, -3.78036082e-01f, -1.59655549e-02f, -2.45075151e-01f,
  -5.29755175e-01f, -3.81825179e-01f, 2.04637516e-02f, -7.54850209e-02f, -1.65016532e-01f, 5.60117960e-01f, 4.91149485e-01f, 3.54628533e-01f, 2.08953708e-01f, 1.99878693e-01f,
  -1.60415158e-01f, -2.66184449e-01f, -3.72524232e-01f, -2.60739356e-01f, 6.31699339e-02f, -4.43368703e-01f, 2.08062068e-01f, -2.55767882e-01f, -1.27878830e-01f, -3.26755613e-01f,
  -5.84839225e-01f, 6.99088752e-01f, -5.22040725e-01f, 6.81881428e-01f, 1.10000949e-02f, -2.75398076e-01f, -5.43297291e-01f, -3.86572957e-01f, 2.55430996e-01f, -3.57367456e-01f,
  1.28870949e-01f, -3.38165730e-01f, -3.27628136e-01f, 1.93148494e-01f, -1.29371300e-01f, 1.20254114e-01f, -4.66422349e-01f, 4.42033634e-02f, -1.96770459e-01f, 6.95346415e-01f,
  -2.77093679e-01f, 3.55144978e-01f, -9.93159860e-02f, 1.89955443e-01f, 2.41173133e-01f, 2.09304303e-01f, 4.42999870e-01f, -2.04502437e-02f, -7.82410979e-01f, 3.54925729e-02f,
  3.88167948e-01f, 5.21393776e-01f, -5.34021258e-01f, -5.53004861e-01f, 2.03281626e-01f, -5.80853045e-01f, -1.19458444e-01f, 3.12655687e-01f, 7.75437057e-02f, 5.60916483e-01f,
  3.90447266e-02f, 4.44313645e-01f, 3.16352993e-01f, 2.11595938e-01f, 3.63177925e-01f, -1.85528815e-01f, -6.56163394e-02f, -1.43242016e-01f, 3.71274233e-01f, -3.55476260e-01f,
  -1.57890558e-01f, -1.27849340e-01f, 6.09524250e-01f, -1.93285421e-01f, -1.53720573e-01f, -4.32232916e-01f, -1.07796237e-01f, -3.01905304e-01f, -6.75988317e-01f, -3.33648145e-01f,
  -3.45064461e-01f, -2.29535654e-01f, 1.87265173e-01f, -9.40828323e-02f, 5.55735469e-01f, 2.12945342e-01f, 2.45717019e-01f, -2.37479001e-01f, 4.55826551e-01f, -5.22141159e-02f,
  2.22904459e-01f, 9.54439864e-02f, 9.08595622e-02f, 3.74572814e-01f, 4.81522024e-01f, 3.50411773e-01f, 4.16218072e-01f, 7.54226418e-03f, 1.01330757e-01f, 7.10887685e-02f,
  2.89370179e-01f, -1.04206264e-01f, -9.82420444e-02f, -1.88287213e-01f, -1.02381788e-01f, 1.44316077e-01f, 4.41439629e-01f, 4.84476686e-02f, -8.67456049e-02f, 1.06357299e-01f,
  -5.05247355e-01f, 3.90836388e-01f, 4.67119902e-01f, 3.93032908e-01f, -9.22163054e-02f, -3.67147595e-01f, 4.48257685e-01f, -5.27944565e-01f, -6.51369691e-02f, -5.64291418e-01f,
  4.68427151e-01f, 8.30222890e-02f, 1.03612840e-02f, -5.02940595e-01f, -8.40129852e-01f, -2.33854294e-01f, 1.08208343e-01f, 5.24185836e-01f, -6.12271242e-02f, -2.48349141e-02f,
  4.36787121e-02f, 8.97900164e-02f, -6.44301176e-01f, 6.54500544e-01f, 3.44757795e-01f, -1.67735189e-01f, -1.61206946e-01f, -4.41991866e-01f, -2.37213448e-01f, -2.36855090e-01f,
  -8.17657188e-02f, 2.49996446e-02f, 2.23002359e-01f, -1.62574366e-01f, 3.38766336e-01f, -5.34861326e-01f, -9.57767591e-02f, -9.21669841e-01f, -3.80089849e-01f, -1.74200878e-01f,
  1.54391870e-01f, -4.41752821e-01f, 7.58318424e-01f, 3.67606282e-01f, 2.43903190e-01f, 2.81645227e-02f, 9.25980955e-02f, 5.83336875e-03f, -2.66484082e-01f, 1.66244701e-01f,
  -4.91571613e-02f, -1.86106279e-01f, 1.20871507e-01f, 3.70248482e-02f, 6.98629081e-01f, -6.54795170e-01f, -7.90188164e-02f, -7.84098506e-01f, -2.01849088e-01f, -3.17776978e-01f,
  2.34326124e-01f, 6.18274152e-01f, 7.06151426e-01f, -1.15184858e-01f, -4.71706718e-01f, -2.16241814e-02f, -1.88054636e-01f, 2.25912835e-02f, -5.40426910e-01f, 7.50334084e-01f,
  3.63165289e-01f, -3.13272029e-01f, -2.19216794e-01f, -3.15806866e-01f, 1.09513551e-01f, 2.45752990e-01f, 7.79911220e-01f, 2.18787163e-01f, -1.60073265e-02f, 2.84471393e-01f,
  -1.91984013e-01f, -3.76625329e-01f, 6.78251013e-02f, -1.15534082e-01f, -2.05506124e-02f, -1.43324956e-02f, -6.52150139e-02f, 4.44631100e-01f, -3.02662909e-01f, 4.31573033e-01f,
  -4.19533432e-01f, 5.13770938e-01f, 6.55976653e-01f, 6.32829726e-01f, -1.02012046e-01f, 3.83913457e-01f, 5.11262357e-01f, 3.53174925e-01f, -5.85848451e-01f, 3.91141564e-01f,
  3.54955971e-01f, 6.03692569e-02f, -3.92905086e-01f, 2.20296144e-01f, 3.89156267e-02f, 1.29214972e-01f, -6.63590729e-01f, 3.55412692e-01f, -1.43711224e-01f, -3.45181465e-01f,
  3.42291921e-01f, -6.00109883e-02f, -1.07355423e-01f, -6.36138082e-01f, -2.15614945e-01f, 1.11756526e-01f, -1.09664783e-01f, 1.59043044e-01f, -2.64789283e-01f, -4.54394937e-01f,
  -9.18741226e-02f, 3.86888117e-01f, -2.17497826e-01f, -5.45461059e-01f, 1.10431373e-01f, -2.87273467e-01f, -1.94597635e-02f, -4.50297922e-01f, -3.60166013e-01f, -5.43772094e-02f,
  5.83101034e-01f, 2.36530080e-01f, -4.20732707e-01f, -2.07314894e-01f, 2.53759325e-01f, 1.79660216e-01f, 6.05971932e-01f, -1.15686812e-01f, 2.19431639e-01f, 1.19387060e-01f,
  -1.32308573e-01f, 5.02777219e-01f, 2.50272602e-01f, 4.21537966e-01f, 2.53123522e-01f, 5.26496828e-01f, 2.00256899e-01f, -1.07038029e-01f, 9.65271890e-02f, -1.31727621e-01f,
  -4.32340235e-01f, 4.42388088e-01f, 2.16093600e-01f, 1.38999552e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  5.20075709e-02f, 1.92018002e-02f, -9.04689506e-02f, -1.96035892e-01f, 4.60697301e-02f, -5.24013229e-02f, -1.51222274e-02f, -8.05228576e-02f, 1.52169466e-01f, -2.89047837e-01f,
  1.13228068e-01f, -7.20006451e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    