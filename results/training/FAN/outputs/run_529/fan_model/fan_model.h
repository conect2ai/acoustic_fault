/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.47624081e-02f, -1.64276347e-01f, -3.04293096e-01f, 2.47795567e-01f, 8.43209401e-02f, -1.28158838e-01f, 9.02706832e-02f, 4.89051305e-02f, -1.77538861e-02f, 2.31330886e-01f,
  3.85821879e-01f, -4.04326171e-01f, -1.08073533e-01f, 3.89060616e-01f, -1.70227811e-01f, -1.42192289e-01f, 1.84037566e-01f, 1.04745343e-01f, -1.50526866e-01f, 7.39369392e-02f,
  -2.72457171e-02f, 4.90000337e-01f, -1.21246288e-02f, 7.03657493e-02f, 2.43276507e-01f, -8.89973268e-02f, 3.77126455e-01f, -1.35198876e-01f, 1.45952553e-01f, -1.42773911e-01f,
  2.08546221e-03f, -5.61915431e-03f, -2.58367229e-02f, -5.69031052e-02f, 3.90682295e-02f, 1.11439832e-01f, -5.22903800e-02f, -7.75006935e-02f, -8.80164057e-02f, -2.21330882e-03f,
  -4.28933352e-02f, -6.73540160e-02f, -4.93879020e-02f, -4.48585488e-04f, 7.98227638e-02f, 2.38498636e-02f, -1.35181949e-03f, 2.00747773e-02f, 5.87297231e-03f, 1.99732501e-02f,
  -4.56509627e-02f, -3.47270817e-02f, -2.23544426e-02f, 2.50645950e-02f, -1.45349249e-01f, -7.56182745e-02f, -8.76553655e-02f, -3.50176357e-02f, 2.92981360e-02f, -5.67104034e-02f,
  -3.88045592e-05f, 9.11367964e-03f, -6.04561269e-02f, 2.78100241e-02f, -9.28702392e-03f, 8.72315690e-02f, -4.82227877e-02f, 4.40203473e-02f, -5.32111488e-02f, 6.94196075e-02f,
  4.91390154e-02f, 1.56747326e-02f, -1.79573102e-03f, 8.75424817e-02f, 6.52806982e-02f, -4.40776087e-02f, -4.28099856e-02f, -6.72697276e-02f, 7.69660771e-02f, -3.48144695e-02f,
  -2.58964263e-02f, 1.12666441e-02f, -4.28437516e-02f, 7.89933503e-02f, 8.16798806e-02f, -1.03680544e-01f, 1.21483639e-01f, -5.08191716e-03f, 2.15594508e-02f, 5.87043241e-02f,
  2.58270390e-02f, -8.59553218e-02f, 3.12804654e-02f, -3.82711329e-02f, 1.15386415e-02f, 3.80387194e-02f, -1.73042025e-02f, -6.20309040e-02f, -1.20555542e-01f, -5.83968237e-02f,
  6.99250922e-02f, 1.05383508e-01f, -2.96289218e-03f, 6.70078024e-02f, 3.45341861e-02f, -2.05791108e-02f, -1.00408224e-02f, -7.59057999e-02f, 4.82424535e-02f, -1.59710869e-02f,
  6.26425147e-02f, 3.80605906e-02f, 3.12061533e-02f, -1.43712973e-02f, 8.92499387e-02f, -1.78500079e-02f, -2.56408527e-02f, -7.01991981e-03f, -3.56542459e-03f, -4.66551296e-02f,
  -4.07520413e-01f, 2.70986825e-01f, -1.41522497e-01f, -1.00449927e-01f, -2.95036644e-01f, 5.36997057e-02f, -1.31617054e-01f, -2.14439519e-02f, 3.43453661e-02f, 3.20245922e-01f,
  2.86872815e-02f, -1.51819661e-01f, 1.06269687e-01f, 2.51753390e-01f, -3.63973469e-01f, 3.61254662e-01f, 1.93317965e-01f, 1.32475480e-01f, 3.01864222e-02f, -1.18042216e-01f,
  -1.51309863e-01f, -2.34037470e-02f, -1.17134400e-01f, 8.16694796e-02f, -2.03349680e-01f, -1.59673437e-01f, -1.11174852e-01f, -1.53680146e-01f, 5.86241949e-03f, -1.35625362e-01f,
  7.24654719e-02f, 9.28360522e-02f, 1.25868106e-02f, 5.25366887e-02f, 4.66656238e-02f, -3.81259806e-02f, 4.98878285e-02f, -7.56430551e-02f, -1.35837823e-01f, 7.27305189e-02f,
  4.98915948e-02f, -8.34927987e-03f, 6.35619313e-02f, -7.03027323e-02f, -5.53987063e-02f, 4.90684137e-02f, 6.66396245e-02f, 8.84860009e-03f, -5.12671173e-02f, 3.92183065e-02f,
  -7.79888257e-02f, 2.42856424e-02f, 1.57392230e-02f, 4.52468619e-02f, -9.71536115e-02f, 6.69035548e-03f, 5.43810129e-02f, -8.81916285e-02f, 5.41120581e-02f, -6.86941072e-02f,
  5.62224090e-02f, 3.29107791e-02f, -8.50641653e-02f, 2.02648714e-02f, -6.86868280e-02f, -1.75318662e-02f, 8.25726762e-02f, 7.20745549e-02f, -6.65117949e-02f, -1.57949086e-02f,
  -4.17320132e-02f, -3.95041220e-02f, 3.59264091e-02f, 6.60038441e-02f, -4.65590060e-02f, -1.07849408e-02f, -2.05923133e-02f, -9.59589705e-02f, 2.75502000e-02f, -1.49116740e-02f,
  8.23063254e-02f, -1.15914969e-02f, -6.42854497e-02f, 3.15731466e-02f, 9.43852440e-02f, -6.51340708e-02f, 3.28054167e-02f, -1.69144571e-02f, -1.10058617e-02f, -1.03231616e-01f,
  1.22144341e-01f, 9.37133282e-02f, -2.95431986e-02f, -2.63075400e-02f, 5.11592329e-02f, 3.63289975e-02f, 5.37354387e-02f, 7.62784258e-02f, 2.64259987e-02f, 1.47280656e-02f,
  -5.68254702e-02f, 2.44932882e-02f, 1.91757716e-02f, -3.83690465e-03f, 4.30158786e-02f, -5.21701239e-02f, -2.62870640e-03f, 3.75217688e-03f, 7.14227883e-03f, -3.17620300e-02f,
  1.11337071e-02f, 2.15591341e-02f, 1.77113479e-03f, -6.39843792e-02f, 9.26761255e-02f, -1.30796861e-02f, -1.31215706e-01f, 5.01580872e-02f, 2.56358944e-02f, 1.46084934e-01f,
  2.03474417e-01f, 2.33828038e-01f, 3.29193532e-01f, 3.04598540e-01f, -1.36744022e-01f, -1.96596742e-01f, -1.63017020e-01f, 9.41777229e-02f, 1.89549670e-01f, -8.78953412e-02f,
  -1.58629566e-01f, 1.61702737e-01f, -2.53435582e-01f, 1.61673188e-01f, -1.08415574e-01f, -2.52274662e-01f, 1.38408080e-01f, -7.11000618e-03f, 5.88309253e-03f, 1.09641507e-01f,
  5.74248321e-02f, 3.51127870e-02f, 1.37361035e-01f, 1.23644933e-01f, -3.15166488e-02f, 2.25502893e-01f, -1.00175209e-01f, 6.87045082e-02f, 2.59344988e-02f, -7.59907886e-02f,
  -1.11499712e-01f, 9.94316041e-02f, 8.20304379e-02f, -3.40615585e-02f, -3.98464650e-02f, -1.02230422e-01f, -1.04928434e-01f, -7.53203109e-02f, -2.25824844e-02f, 5.62511347e-02f,
  -7.06667900e-02f, -5.60643822e-02f, 1.49904668e-01f, 6.62636012e-03f, 1.55875329e-02f, 1.27112404e-01f, -4.76452848e-03f, -8.17326456e-02f, 6.75082803e-02f, -4.68483865e-02f,
  1.29813319e-02f, -5.87171987e-02f, 2.06516013e-02f, 5.34765143e-03f, 3.27810645e-02f, 7.15176240e-02f, 5.61447553e-02f, -6.87247962e-02f, -3.69207412e-02f, 7.61278421e-02f,
  1.19657286e-01f, -4.16519586e-03f, -3.40679623e-02f, 4.86175343e-03f, -5.61407842e-02f, -6.09814785e-02f, -1.84153039e-02f, -5.76458685e-02f, 3.35420370e-02f, -9.35543850e-02f,
  -5.51004186e-02f, 3.85257713e-02f, -2.14264113e-02f, -2.83775609e-02f, 4.03604619e-02f, 9.21987146e-02f, -1.31381257e-02f, 3.20965704e-03f, 1.00185148e-01f, -4.08317894e-03f,
  3.45568843e-02f, -8.60393941e-02f, -4.82638143e-02f, -1.45965323e-01f, -1.65766254e-02f, 2.57825237e-02f, 6.63536936e-02f, 1.00843281e-01f, 1.22224428e-02f, 3.53750703e-03f,
  -3.96926738e-02f, 1.88003361e-01f, 1.37106040e-02f, -6.49491251e-02f, 9.01654586e-02f, -7.80004933e-02f, 3.71643491e-02f, 2.91803125e-02f, 7.20908642e-02f, 9.62300599e-03f,
  -8.61371867e-03f, -1.15074635e-01f, -7.73284361e-02f, -7.82552510e-02f, 2.33985111e-03f, -1.21914325e-02f, 1.81668438e-03f, -4.23216894e-02f, -4.84485999e-02f, -2.02045515e-02f,
  4.30703647e-02f, -3.58031653e-02f, 4.36065197e-02f, -8.87502283e-02f, -7.20493719e-02f, -4.58523817e-02f, 1.16394527e-01f, 4.50176857e-02f, -3.64725441e-02f, 5.44020347e-02f,
  9.64156687e-02f, -6.66911006e-02f, -2.56486982e-01f, 3.16038907e-01f, -3.87723334e-02f, 1.49408132e-01f, 2.03008994e-01f, 4.79690358e-02f, 7.67050609e-02f, 2.22444668e-01f,
  2.23421872e-01f, -2.13715047e-01f, 1.11318938e-02f, 3.79948199e-01f, 5.09144478e-02f, 1.54531226e-01f, 3.25899631e-01f, 2.14317515e-01f, -1.94944404e-02f, 1.08917378e-01f,
  1.03424214e-01f, 3.68052959e-01f, 8.10292736e-02f, 9.65368897e-02f, 1.42671183e-01f, -1.71146140e-01f, 1.81401148e-01f, -9.95895118e-02f, 2.30167821e-01f, -5.85434698e-02f,
  8.61053169e-02f, -1.08859919e-01f, -6.17416836e-02f, -9.14292857e-02f, 3.70088555e-02f, -6.69552237e-02f, 3.12092379e-02f, -9.32914838e-02f, -6.41401932e-02f, -3.49755511e-02f,
  -8.64551440e-02f, -7.50409365e-02f, 3.25681791e-02f, -5.40535413e-02f, -7.21580070e-03f, -2.89340932e-02f, 1.97157357e-02f, -8.89712013e-04f, -3.75924632e-02f, -4.83407499e-03f,
  -5.19520487e-04f, 6.57591736e-03f, -2.05340441e-02f, 5.96861430e-02f, -4.45679948e-02f, 1.97100937e-02f, -2.08328925e-02f, -3.18023227e-02f, 5.13099916e-02f, 6.94733113e-03f,
  4.04059701e-02f, -1.21823710e-03f, 1.30736558e-02f, -1.40671255e-02f, -1.85797608e-03f, 2.96565276e-02f, 6.58616424e-02f, 1.63711086e-02f, -2.24578399e-02f, 5.22569530e-02f,
  7.86693767e-02f, -2.40908485e-04f, 4.99924086e-02f, -1.50250439e-02f, 1.05997361e-01f, -4.69536260e-02f, -3.23186740e-02f, -2.95632542e-03f, 4.63187546e-02f, 3.90030108e-02f,
  -3.66346315e-02f, 7.43025839e-02f, -1.85457729e-02f, 2.02900507e-02f, -2.26608547e-03f, -1.35140978e-02f, 3.87803987e-02f, 2.72350069e-02f, -1.78121310e-02f, 7.73702515e-03f,
  8.07897374e-02f, 1.56052411e-01f, -3.00864913e-02f, -3.94739327e-04f, 2.83971801e-02f, 1.02396142e-02f, -2.05263812e-02f, -3.16315070e-02f, 2.57720100e-03f, -1.14350403e-02f,
  6.05310984e-02f, 2.38170009e-02f, 1.22205028e-02f, 9.27846320e-03f, 1.62484739e-02f, 2.51962189e-02f, 1.19254719e-02f, -8.33606115e-04f, 6.10425472e-02f, -3.29693384e-03f,
  6.98138028e-02f, 6.00030161e-02f, 5.54551603e-03f, -4.75736521e-02f, 6.21532314e-02f, 5.20517677e-03f, -2.34646164e-02f, -2.64519490e-02f, -2.15228293e-02f, 5.08845374e-02f,
  -3.69060606e-01f, 3.58120918e-01f, -3.28624010e-01f, -1.47126123e-01f, 6.28691539e-02f, 2.79835254e-01f, 1.40215352e-01f, 1.40884534e-01f, 1.19452132e-02f, 1.97647795e-01f,
  1.78708613e-01f, 4.63289805e-02f, 6.61507770e-02f, 2.81923890e-01f, -1.57127738e-01f, 4.81142178e-02f, 1.47460759e-01f, 1.66914657e-01f, -4.75917235e-02f, 1.00435282e-03f,
  -9.47386324e-02f, 2.49997839e-01f, -2.14038476e-01f, 2.05003068e-01f, 3.93525735e-02f, -9.53242406e-02f, -1.84969470e-01f, 4.95310351e-02f, 8.87508318e-02f, 9.39496309e-02f,
  6.70182798e-03f, -3.95616814e-02f, -7.52805322e-02f, -5.24145551e-02f, -1.75286997e-02f, -3.73568721e-02f, -3.31180319e-02f, 1.66691765e-02f, -6.34091944e-02f, -1.75228007e-02f,
  1.57428533e-02f, -3.48247588e-02f, 7.15844557e-02f, 5.60101047e-02f, -1.41444372e-03f, -9.39307585e-02f, -8.93969759e-02f, -1.50377499e-02f, 1.25175536e-01f, -5.99101782e-02f,
  -2.82043926e-02f, -5.21548577e-02f, -7.30307177e-02f, 2.28898767e-02f, 3.28473300e-02f, 2.39416622e-02f, -9.67740454e-03f, -4.44044620e-02f, 1.90759692e-02f, -3.71171981e-02f,
  -1.23561779e-02f, -3.31077166e-02f, -1.70120113e-02f, -8.78766030e-02f, 7.02879503e-02f, 3.43142562e-02f, -2.02148012e-03f, 3.11354939e-02f, -1.98283251e-02f, 1.28445700e-02f,
  -2.55889427e-02f, 1.75567362e-02f, -4.69022058e-03f, -3.10549587e-02f, 2.55486034e-02f, -5.48837334e-02f, -3.71129662e-02f, 6.29547685e-02f, -2.48159561e-02f, -3.62345949e-02f,
  4.03719805e-02f, 6.00078180e-02f, -1.33627243e-02f, -3.41464430e-02f, 4.42682728e-02f, -6.30548075e-02f, 6.62015304e-02f, -9.68450122e-03f, 1.04883220e-02f, 3.69193056e-03f,
  1.75923511e-01f, 2.52275109e-01f, 5.41635528e-02f, 4.21658680e-02f, 1.27778249e-02f, -4.52886373e-02f, 1.19973281e-02f, -1.53951235e-02f, 1.69334300e-02f, 3.68571579e-02f,
  -6.11581840e-02f, 6.17510872e-03f, -8.33300427e-02f, -1.62669234e-02f, -1.34362988e-02f, 4.00893874e-02f, 2.96198204e-02f, 8.21312144e-02f, 2.76178238e-03f, 4.64503653e-03f,
  -2.61642337e-02f, 2.66778059e-02f, -1.94982179e-02f, 1.24110699e-01f, 3.09648253e-02f, -2.60875709e-02f, 4.78459187e-02f, -2.35360749e-02f, -2.11085449e-03f, 5.28765433e-02f,
  4.21205074e-01f, -5.88695891e-02f, -8.54741335e-02f, 3.20617519e-02f, 1.18250981e-01f, 3.05550307e-01f, 2.40566462e-01f, 2.16674656e-01f, 1.93865180e-01f, 2.13182628e-01f,
  4.02195379e-03f, 1.36769369e-01f, -4.41997759e-02f, -7.11725978e-03f, -2.73408949e-01f, -3.72209251e-01f, -2.42568931e-04f, 1.54598057e-01f, -4.94644418e-02f, 9.69613716e-02f,
  -5.62890172e-02f, -2.24566311e-01f, -2.35791862e-01f, -6.70766532e-02f, 1.24281392e-01f, 7.11674467e-02f, -1.19477943e-01f, -6.70744702e-02f, -5.79254925e-02f, -9.62182432e-02f,
  -8.72227624e-02f, 2.11971272e-02f, 5.60552068e-02f, 5.68205193e-02f, 8.10601041e-02f, 1.87473267e-01f, 1.18776850e-04f, -4.17396240e-02f, -7.77351577e-03f, 2.88964547e-02f,
  4.99818809e-02f, -1.44648761e-01f, 3.94571712e-03f, -3.90388891e-02f, 1.32598728e-01f, 4.02115807e-02f, -9.37766507e-02f, 8.76131728e-02f, 5.95481768e-02f, -1.51199661e-02f,
  1.35518447e-01f, 8.30204189e-02f, 7.90394023e-02f, -9.97179523e-02f, 1.27970043e-03f, -1.53708393e-02f, -5.95690385e-02f, 3.27974111e-02f, -1.49999391e-02f, 7.05771148e-02f,
  -4.56103906e-02f, -2.16907505e-02f, -4.38953098e-03f, 3.98515165e-02f, 2.12393422e-02f, -8.02407414e-02f, 5.28474897e-02f, -1.06764726e-01f, -1.99765451e-02f, -5.63527644e-03f,
  -1.45575181e-02f, 4.51960750e-02f, 5.25122955e-02f, 9.50036279e-04f, -3.57954092e-02f, 2.34382991e-02f, 6.76106960e-02f, -2.30413824e-02f, 1.04779840e-01f, 1.10622458e-02f,
  -4.88794446e-02f, -5.32880463e-02f, -3.89995091e-02f, -4.44368683e-02f, -7.90057890e-03f, -1.32127665e-04f, 2.87994109e-02f, -7.87954777e-02f, -6.43954501e-02f, 3.50348055e-02f,
  -9.47394315e-03f, -1.27871618e-01f, -4.61971089e-02f, -5.84744737e-02f, -7.53069520e-02f, -4.35891636e-02f, -6.60010660e-03f, -1.79500915e-02f, -1.53347656e-01f, -3.90238576e-02f,
  4.30278219e-02f, 6.19997717e-02f, 1.74855024e-01f, -5.66507056e-02f, -6.86783716e-02f, 4.52671759e-02f, 4.61862572e-02f, 4.06053513e-02f, -1.33592963e-01f, 3.96866389e-02f,
  -1.09977603e-01f, -3.80028598e-02f, -9.54204425e-02f, 4.71231947e-03f, -1.67799536e-02f, 1.54536944e-02f, 2.32029092e-02f, 4.63260300e-02f, -1.04263835e-01f, 2.12604888e-02f,
  3.06724519e-01f, -2.63997644e-01f, -1.80739075e-01f, 3.30979943e-01f, 1.71993703e-01f, 2.79705167e-01f, 2.33605102e-01f, 1.61998570e-01f, -2.74360608e-02f, -5.15617356e-02f,
  2.41341144e-01f, -1.85907409e-01f, -8.49897489e-02f, 6.31363615e-02f, 4.09024715e-01f, -1.48213267e-01f, 2.27608815e-01f, 9.17178318e-02f, -1.39774621e-01f, 8.25275332e-02f,
  1.63279817e-01f, 1.85185820e-01f, 2.29345076e-02f, -5.71984835e-02f, 7.84600601e-02f, 4.77778614e-02f, 1.11601777e-01f, -1.62467167e-01f, -3.67948823e-02f, -1.19310440e-02f,
  1.51442468e-01f, 8.43292400e-02f, -1.30508631e-01f, -1.20305493e-01f, 5.65725341e-02f, -1.70013197e-02f, 9.65565145e-02f, -1.82144437e-02f, 4.01333943e-02f, -1.53485704e-02f,
  -3.50022614e-02f, 9.15209576e-02f, 2.73785219e-02f, -8.33654925e-02f, -5.15379885e-04f, -3.45513448e-02f, -9.24661085e-02f, -1.02903306e-01f, -4.61128615e-02f, -1.51871992e-02f,
  -4.37172465e-02f, -7.46004581e-02f, -2.45978814e-02f, -9.69573949e-03f, 9.15504247e-03f, -2.74456404e-02f, -5.29402047e-02f, 5.39731374e-03f, 1.30487964e-01f, 5.90477027e-02f,
  4.28200141e-02f, -4.19490114e-02f, -1.11255106e-02f, -5.12550026e-02f, 5.12441956e-02f, -5.18999286e-02f, -4.80924696e-02f, -1.96770392e-02f, -6.48810863e-02f, 1.11277699e-01f,
  4.39349748e-02f, 3.86973470e-02f, 9.31431819e-03f, 3.23675051e-02f, 1.65403057e-02f, -1.48333693e-02f, -5.74784987e-02f, 4.45609819e-03f, -3.28335427e-02f, 8.56443346e-02f,
  -1.11625325e-02f, 3.09794694e-02f, -3.73685248e-02f, 7.65693486e-02f, -1.33420117e-02f, 3.47963795e-02f, -1.53992772e-01f, -2.30366774e-02f, 1.09258117e-02f, 6.49999008e-02f,
  1.98585674e-01f, 2.34016284e-01f, 6.03519417e-02f, 7.69399405e-02f, 5.05660810e-02f, 2.73205880e-02f, -1.43665075e-01f, -2.81193890e-02f, -5.10034971e-02f, 7.41485879e-03f,
  4.00679708e-02f, 4.39584777e-02f, 1.81473687e-03f, 3.07775196e-02f, -1.42777746e-03f, 2.06375178e-02f, 5.28868139e-02f, 1.44414268e-02f, 2.02889144e-01f, 9.30933133e-02f,
  1.13032766e-01f, 8.10108781e-02f, 3.39451358e-02f, 2.91222762e-02f, 1.82230417e-02f, 4.49046083e-02f, 9.24700126e-02f, -7.12623894e-02f, 3.32671143e-02f, -8.27364773e-02f,
  2.88052559e-01f, 1.85168937e-01f, -3.00573725e-02f, 2.74927795e-01f, -3.20446640e-01f, 2.43416145e-01f, 1.34892270e-01f, -3.29898931e-02f, -2.51213193e-01f, 2.45544285e-01f,
  4.97441590e-02f, 1.12960368e-01f, -1.79484755e-01f, 3.61610353e-01f, 1.05586447e-01f, -1.69246018e-01f, 3.70445013e-01f, 1.64589569e-01f, -2.38595083e-01f, 1.06480695e-01f,
  5.12326360e-02f, 1.59903973e-01f, 1.04443066e-01f, -1.25905424e-01f, 2.70402104e-01f, -3.21204960e-03f, 1.52859792e-01f, -3.35606635e-01f, 3.40244383e-01f, -1.17917031e-01f,
  4.30244729e-02f, -1.55168129e-02f, 4.60804850e-02f, 1.51013024e-02f, 9.47211534e-02f, -3.58462259e-02f, 4.63253073e-02f, -6.45685345e-02f, -1.10168457e-01f, 2.29783502e-04f,
  3.79163511e-02f, 8.33474193e-03f, 4.85447757e-02f, -5.82387187e-02f, -2.05766652e-02f, 4.75546829e-02f, 5.03653847e-02f, 5.39059937e-02f, -5.60846850e-02f, 3.35762948e-02f,
  6.51902407e-02f, 7.47198239e-02f, 1.35777041e-01f, 1.07223041e-01f, -9.77575686e-03f, -1.33951744e-02f, 1.35965953e-02f, 2.00639684e-02f, 6.80812821e-02f, 2.05142610e-02f,
  5.09891734e-02f, -1.31823942e-01f, 3.67540419e-02f, -8.43252763e-02f, -1.02745704e-02f, -6.29027560e-03f, 3.90692540e-02f, 8.39118939e-03f, -5.79840923e-03f, 4.78793047e-02f,
  -3.39077972e-02f, 5.91533594e-02f, -3.09445653e-02f, 4.80467565e-02f, 1.16005585e-01f, 3.45532112e-02f, -6.72722654e-03f, -4.31309082e-03f, 1.38702197e-02f, -2.54011378e-02f,
  -2.89665237e-02f, -1.55914417e-02f, -5.10866232e-02f, 5.78520559e-02f, -2.45056096e-02f, 3.77369225e-02f, 2.90804915e-02f, 4.21039388e-02f, -9.57554355e-02f, -2.21607704e-02f,
  3.46233621e-02f, 2.05726460e-01f, -1.50721282e-01f, 5.51315509e-02f, -7.91806504e-02f, 8.21720064e-03f, 3.78899388e-02f, -1.80080999e-02f, 2.99794134e-02f, -2.90195793e-02f,
  1.36709258e-01f, 1.93167869e-02f, 4.23545130e-02f, -2.72076055e-02f, 1.17841596e-02f, 1.49728246e-02f, 6.95501715e-02f, -3.57712433e-02f, 7.64560252e-02f, -2.02303398e-02f,
  1.05047431e-02f, -6.17748909e-02f, -3.29549126e-02f, -7.73473876e-03f, 2.64034458e-02f, 6.87833056e-02f, -2.26058792e-02f, -4.37017493e-02f, -1.38090663e-02f, -3.78638096e-02f,
  2.77254343e-01f, -2.77737349e-01f, 3.72579783e-01f, 2.57245511e-01f, -1.27832219e-01f, 1.54553995e-01f, 2.71709412e-01f, 1.63443182e-02f, 2.21588507e-01f, -3.87514472e-01f,
  -3.00250977e-01f, 5.64865842e-02f, -2.77279973e-01f, -5.55215999e-02f, 2.13330761e-01f, -9.66009498e-02f, 2.15003699e-01f, 6.81462660e-02f, 4.85527106e-02f, 3.70259285e-02f,
  1.25756428e-01f, -2.10810661e-01f, 1.86374336e-01f, -9.98039842e-02f, -5.94868585e-02f, 2.84153581e-01f, -1.28759935e-01f, 2.86757331e-02f, -9.16300267e-02f, -6.59741759e-02f,
  -2.53321528e-02f, -3.79984118e-02f, 6.37531728e-02f, 2.50503421e-02f, 8.46271738e-02f, -1.05889533e-02f, 1.00268517e-02f, 2.50636283e-02f, 1.00740734e-02f, 4.96984497e-02f,
  -2.18720897e-03f, -2.80800927e-02f, 7.59556070e-02f, 5.55845350e-02f, 2.38735620e-02f, 4.36470704e-03f, 2.30565537e-02f, 2.42250543e-02f, 5.03335893e-02f, 5.47586903e-02f,
  5.13527468e-02f, 3.17082219e-02f, 1.15640268e-01f, -1.35909067e-02f, 1.35404184e-01f, -1.11266440e-02f, 1.09424956e-01f, 4.79216464e-02f, 2.81729419e-02f, -3.75888608e-02f,
  3.31635922e-02f, 1.16004450e-02f, -6.45678565e-02f, -5.58154583e-02f, -1.53565314e-02f, 3.21725383e-03f, -6.54289350e-02f, -8.11809450e-02f, -9.24847089e-03f, -4.81246447e-04f,
  -2.32032165e-02f, -3.25670019e-02f, 3.73665579e-02f, 4.02996428e-02f, -7.42976591e-02f, 5.98136149e-02f, 2.82319542e-02f, -4.03895527e-02f, 6.29126802e-02f, 1.18173305e-02f,
  6.66572899e-03f, 3.77317481e-02f, -4.14411165e-02f, -7.10213855e-02f, 1.42552834e-02f, 3.88811156e-02f, 1.70189980e-02f, 4.26904485e-02f, 2.83022095e-02f, 6.85822517e-02f,
  -2.53017753e-01f, -1.88102677e-01f, -3.21450122e-02f, -7.98698440e-02f, -6.79664388e-02f, -8.28524008e-02f, 2.82421093e-02f, -1.94134712e-02f, 1.42682511e-02f, -4.25539911e-02f,
  3.98729509e-03f, 3.44717456e-03f, -4.15221235e-04f, 4.80918549e-02f, -3.13962586e-02f, -3.67637910e-02f, 3.19651589e-02f, -2.56317519e-02f, 1.41365277e-02f, -9.88688692e-02f,
  1.17684444e-02f, -1.61285009e-02f, 8.59795231e-03f, 3.97867113e-02f, -4.50392514e-02f, -4.22363803e-02f, -2.58307271e-02f, 2.72834003e-02f, -1.80844348e-02f, -1.74034489e-04f,
  1.42513543e-01f, 4.14666325e-01f, -1.77109018e-02f, 3.35663944e-01f, -2.01065950e-02f, 3.29393968e-02f, 2.90006697e-01f, 2.80868918e-01f, 2.09671736e-01f, 3.64055246e-01f,
  7.67966639e-03f, 2.75951028e-01f, 4.44211699e-02f, 2.57891238e-01f, -2.04457596e-01f, -6.96937442e-02f, 2.13036597e-01f, 1.15106747e-01f, 2.59638950e-02f, 1.61720544e-01f,
  -1.65879428e-01f, 2.08851099e-02f, -1.30146027e-01f, -8.18331987e-02f, 5.81885017e-02f, -7.26251677e-03f, -4.52653542e-02f, -2.09707037e-01f, 1.00908026e-01f, -3.55156511e-02f,
  -2.97274943e-02f, 1.42903373e-01f, 6.21960498e-02f, 2.60968804e-02f, -3.28023024e-02f, -6.96167443e-03f, -4.88751866e-02f, -1.89435259e-01f, 1.38251977e-02f, -3.04173809e-02f,
  5.36225699e-02f, -1.29429502e-02f, -3.41089480e-02f, -2.50641163e-02f, 1.05490915e-01f, 1.13606481e-02f, 5.60193807e-02f, 9.98006947e-03f, 1.35943457e-01f, -5.70284249e-03f,
  -1.90485716e-02f, -2.53673829e-02f, -3.12393438e-02f, -4.05766070e-03f, 8.12526792e-03f, 6.15120120e-02f, 7.26659000e-02f, 4.97463457e-02f, 1.02234244e-01f, 1.31853968e-01f,
  4.04789895e-02f, -1.00127622e-01f, 2.58515701e-02f, -5.65368012e-02f, 5.84439468e-03f, 4.00124416e-02f, -1.85249536e-03f, -4.29934375e-02f, -4.72331457e-02f, 5.21845743e-02f,
  -5.09302244e-02f, 8.78582001e-02f, 5.79168722e-02f, 3.51632461e-02f, -1.08167240e-02f, -3.14073451e-02f, -1.04865707e-01f, 7.00919777e-02f, -1.98199023e-02f, 3.04961428e-02f,
  1.55536982e-03f, -6.56740963e-02f, 6.74443915e-02f, -1.22545771e-01f, -2.90288404e-02f, -4.31098649e-03f, -2.65281852e-02f, 8.72282311e-02f, -9.23668444e-02f, -5.83358780e-02f,
  1.18411675e-01f, 1.71782821e-01f, -1.00898165e-02f, -2.53047161e-02f, -3.43674235e-02f, 1.01847555e-02f, -8.18759575e-02f, 2.47639269e-02f, 9.53582227e-02f, 4.85383831e-02f,
  -1.25144288e-01f, -5.23025030e-03f, -4.75734398e-02f, -2.20834464e-02f, -9.11846459e-02f, -1.26375332e-02f, -8.42008218e-02f, -6.50831964e-03f, -1.04743794e-01f, 3.47310118e-02f,
  2.60598566e-02f, 4.42626029e-02f, -3.35170841e-03f, 5.34883551e-02f, 2.30284855e-02f, 1.05762137e-02f, -1.03992866e-02f, -9.11779106e-02f, 4.26028715e-03f, 6.11663200e-02f,
  1.08854234e-01f, 2.96246678e-01f, 3.94815624e-01f, 1.04002636e-02f, -1.69638842e-01f, 2.57697165e-01f, 2.71490216e-01f, 2.59722583e-02f, 1.54868528e-01f, 1.67130545e-01f,
  -1.68741941e-01f, 1.10608347e-01f, 1.54383153e-01f, -1.56868160e-01f, 3.90071683e-02f, 4.25380580e-02f, -2.08756879e-01f, -1.78837106e-02f, -2.37986058e-01f, -1.46546766e-01f,
  -4.82671000e-02f, -3.12891781e-01f, -2.04481274e-01f, -2.59747058e-01f, -7.84078613e-02f, -1.69386163e-01f, -2.35631809e-01f, 1.72619119e-01f, -8.04825500e-02f, 8.62433016e-02f,
  -6.25337213e-02f, -5.23309894e-02f, -1.07195690e-01f, 1.13537855e-01f, -6.51511922e-02f, 1.02841549e-01f, 4.33685593e-02f, 4.33636084e-02f, -3.20615992e-02f, 4.41448065e-03f,
  7.33662322e-02f, -6.59688935e-02f, -9.28987339e-02f, -7.29598990e-03f, 1.19887479e-01f, -6.89802552e-03f, -1.08821262e-02f, -4.06795889e-02f, 2.24175323e-02f, 7.48428777e-02f,
  3.61755565e-02f, 5.51610999e-03f, 8.64323005e-02f, 7.10295700e-03f, 2.01687273e-02f, 2.32940000e-02f, 3.85491736e-02f, 8.80805589e-03f, 2.19373871e-02f, 8.75735357e-02f,
  4.40030247e-02f, 2.77663209e-02f, -7.85263535e-03f, 7.42180422e-02f, -4.11782078e-02f, -3.95474955e-02f, 9.09709111e-02f, -4.20919321e-02f, 3.64499720e-04f, -7.45066404e-02f,
  1.48474034e-02f, -6.41563982e-02f, -2.12189760e-02f, -8.51812884e-02f, -3.10320295e-02f, 5.59186898e-02f, -2.35505756e-02f, -4.93743122e-02f, -8.05130787e-03f, -4.20253277e-02f,
  -5.53348276e-04f, 9.24182236e-02f, -8.19223523e-02f, -2.62266509e-02f, 5.21942452e-02f, -3.99029814e-02f, -1.38254073e-02f, 7.35894516e-02f, -1.24738507e-01f, 4.27006111e-02f,
  2.34088744e-04f, 1.22293212e-01f, -1.35105073e-01f, -1.01300538e-01f, 1.68135818e-02f, -1.01707906e-01f, -1.29088759e-03f, -6.69801384e-02f, 6.70635402e-02f, -2.91258339e-02f,
  -5.23061529e-02f, -4.74981740e-02f, 2.08217800e-02f, 5.28522730e-02f, -5.37070120e-03f, 5.77860922e-02f, 4.93858978e-02f, -7.14373440e-02f, 1.96178425e-02f, -1.00519076e-01f,
  -1.31322339e-01f, -5.21270148e-02f, 2.35121418e-02f, -1.22649468e-01f, -7.13547021e-02f, -1.18845906e-02f, 1.89394616e-02f, -2.03781035e-02f, -5.36396429e-02f, -2.91053131e-02f,
  -5.08084372e-02f, 1.96908846e-01f, -3.46323699e-01f, -2.12075248e-01f, -2.00837795e-02f, 2.22912151e-02f, 2.29864031e-01f, -1.89876243e-01f, -4.34488012e-03f, 2.46374115e-01f,
  3.67136210e-01f, -3.34615782e-02f, 1.88166514e-01f, 1.16620772e-01f, -2.13757485e-01f, 1.63084686e-01f, -1.14654809e-01f, 5.25743663e-02f, -2.01921612e-01f, -2.10338846e-01f,
  -1.60396695e-01f, -6.76138625e-02f, -1.19268999e-01f, -2.44186506e-01f, -9.40468311e-02f, -1.36096776e-01f, -3.99232395e-02f, -1.21725619e-01f, -2.25290526e-02f, -5.00396118e-02f,
  1.83984995e-01f, 5.50594889e-02f, -4.76611638e-03f, -5.34881502e-02f, -2.73930412e-02f, 6.68046176e-02f, -3.41047458e-02f, 3.16904113e-02f, -2.43025497e-02f, 1.27552114e-02f,
  4.56554294e-02f, -1.17227070e-01f, -8.91497731e-02f, -7.08394498e-02f, 4.20127733e-04f, -9.60423276e-02f, 8.40884000e-02f, 5.48633933e-02f, -9.03863907e-02f, 1.21657457e-02f,
  -1.73710193e-02f, 9.04460326e-02f, 3.38288234e-03f, -1.59915946e-02f, -4.00096327e-02f, -1.45767499e-02f, -3.86032984e-02f, -1.96032529e-03f, 3.03101670e-02f, -1.61343157e-01f,
  5.31040542e-02f, -8.75877365e-02f, 3.59912701e-02f, -3.51959281e-02f, 4.57455441e-02f, 6.81373626e-02f, 2.15843674e-02f, -5.00689708e-02f, -8.52496624e-02f, 4.04031239e-02f,
  -2.60645729e-02f, 4.31965999e-02f, -3.01052835e-02f, -5.34369424e-02f, -2.93712448e-02f, -1.21758049e-02f, -2.66221277e-02f, -4.54308726e-02f, -7.78402165e-02f, 1.88048612e-02f,
  1.11501664e-02f, -2.03873161e-02f, -1.28838955e-03f, 5.25702350e-03f, -1.92745193e-03f, -5.92612289e-02f, 1.45568734e-03f, -8.56003840e-04f, -4.35062572e-02f, -9.81528237e-02f,
  1.03108600e-01f, -9.05322209e-02f, -3.53717990e-02f, 4.70037386e-02f, 5.03988601e-02f, 1.18638743e-02f, -4.68468815e-02f, -6.92723617e-02f, 7.47220870e-03f, 1.45767396e-02f,
  -3.62950265e-02f, 2.73046102e-02f, -2.49147732e-02f, 4.75094207e-02f, -1.02758883e-02f, 9.44567472e-02f, -3.77937704e-02f, -1.71371587e-02f, -3.35743204e-02f, -1.12764975e-02f,
  -2.20503230e-02f, 8.94508362e-02f, -6.61584735e-02f, -1.03132553e-01f, 4.17835871e-03f, 7.18756095e-02f, -2.07118243e-02f, 2.21300647e-02f, -1.46957070e-01f, 5.32131307e-02f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.73213974e-01f, -1.79173738e-01f, -6.73486441e-02f, -2.32648194e-01f, -8.44871849e-02f, -2.23826677e-01f, -1.12089343e-01f, -1.01618364e-01f, -9.12155733e-02f, -1.62126556e-01f,
  -1.35871097e-01f, 2.60901779e-01f, -1.11292258e-01f, -2.89466288e-02f, 1.26916707e-01f, 1.78175047e-01f, -2.56775290e-01f, 7.35707358e-02f, 3.47527042e-02f, -2.58439392e-01f,
  -1.20490059e-01f, -2.89813280e-01f, 2.92924745e-03f, -1.73171312e-01f, -1.99310537e-02f, 9.13997833e-03f, 8.58171210e-02f, -9.18297172e-02f, 3.08283903e-02f, 1.36117786e-01f,
  4.03593332e-02f, 2.54497994e-02f, 4.49423157e-02f, -3.33060585e-02f, -4.90696020e-02f, 2.79568252e-04f, 4.08640802e-02f, 4.89826724e-02f, 3.58552188e-02f, -5.76570034e-02f,
  1.75101385e-01f, 1.67162508e-01f, -2.69381818e-03f, 1.39110461e-01f, -1.28335118e-01f, 1.43070705e-02f, -1.18206795e-02f, 7.91814551e-02f, -1.95508245e-02f, 4.07775044e-02f,
  -5.85384443e-02f, -1.91501006e-02f, -6.13888353e-02f, 8.17108601e-02f, -3.12162638e-02f, 3.20635107e-03f, -9.85443871e-03f, 1.94384977e-01f, -3.44694778e-02f, -1.07858874e-01f,
  4.26438786e-02f, 2.10451428e-02f, -8.67373403e-03f, -4.81402352e-02f, -1.04881031e-02f, 7.76041821e-02f, 3.42996828e-02f, 3.82328667e-02f, -6.55004149e-03f, -9.87976938e-02f,
  3.93472612e-03f, -4.04827297e-02f, -8.90666619e-02f, -7.62270093e-02f, 5.59667572e-02f, 5.01671210e-02f, 1.89037621e-02f, -2.30802074e-02f, -5.58565967e-02f, 1.18073076e-02f,
  -7.11696595e-02f, -5.11322767e-02f, -3.82408313e-02f, 1.02845162e-01f, 8.81181955e-02f, -9.41779464e-02f, -1.31271020e-01f, 6.10629320e-02f, -5.07643223e-02f, -2.27555074e-02f,
  -1.76770836e-02f, -2.74917662e-01f, 6.92099053e-03f, 3.13028805e-02f, 7.10232779e-02f, 6.46638917e-03f, 8.15479737e-03f, -9.36676040e-02f, 2.51405425e-02f, -6.49348646e-02f,
  -6.65810192e-03f, 8.81124288e-02f, 3.64287123e-02f, -4.27989922e-02f, -1.61790941e-02f, -1.30043283e-01f, -1.15434676e-01f, -3.23394015e-02f, -1.14041433e-01f, 5.76125309e-02f,
  -3.20362523e-02f, -3.28164808e-02f, 1.80151403e-01f, -8.88541266e-02f, 1.56650487e-02f, 3.37210037e-02f, -3.87495868e-02f, 8.20937455e-02f, 5.15066460e-02f, -2.51033269e-02f,
  3.65435402e-03f, 1.01056635e-01f, 1.31084947e-02f, -1.14328116e-01f, -1.57785431e-01f, -8.06920230e-02f, 1.84741952e-02f, 5.36171533e-02f, 2.01255202e-01f, 6.52772188e-02f,
  -1.73176259e-01f, 1.98032826e-01f, 3.35131526e-01f, -2.67806470e-01f, 3.53269845e-01f, 2.04666972e-01f, -1.71101451e-01f, 8.33474216e-04f, -9.37726647e-02f, 1.61742330e-01f,
  1.18162669e-01f, 1.48425084e-02f, 1.58814732e-02f, -1.66549042e-01f, -2.44141296e-01f, -2.15375423e-01f, -1.57723442e-01f, -1.26471922e-01f, -3.93776953e-01f, -3.01894367e-01f,
  -4.33116108e-01f, -1.31161273e-01f, -1.25763819e-01f, -8.89087543e-02f, -2.47298628e-01f, -6.12757169e-02f, 1.55303888e-02f, 9.12370980e-02f, -6.28477260e-02f, 1.13468364e-01f,
  1.30042091e-01f, -3.26383226e-02f, -8.31735656e-02f, 1.10874429e-01f, 6.96305856e-02f, -1.07025281e-01f, -2.12412477e-01f, -1.43534347e-01f, -7.67674223e-02f, -9.77403447e-02f,
  -1.04723834e-01f, -1.20032668e-01f, -2.14380518e-01f, -4.54533733e-02f, -1.81252301e-01f, -2.04870224e-01f, 8.52982923e-02f, 6.23080023e-02f, -1.88943997e-01f, -1.43611133e-01f,
  4.90480624e-02f, 4.88209203e-02f, -5.39162382e-02f, 1.41408011e-01f, -4.17525955e-02f, -1.18024990e-01f, -1.83897726e-02f, -5.78876026e-02f, -1.05154581e-01f, -5.83542362e-02f,
  -4.44669612e-02f, -1.09978868e-02f, -1.09093383e-01f, 4.70154583e-02f, -4.00787778e-02f, 1.58183455e-01f, 1.44103318e-01f, -7.92092681e-02f, 1.36211449e-02f, -1.21798247e-01f,
  7.15842769e-02f, 3.64603959e-02f, -1.46476120e-01f, -1.39220059e-01f, -1.00643292e-01f, 1.23580862e-02f, -7.27485791e-02f, -1.37598887e-01f, 8.22064131e-02f, 1.47734992e-02f,
  -3.51253934e-02f, 3.00966024e-01f, 2.34964658e-02f, -1.36165291e-01f, -9.49388556e-03f, 9.77399349e-02f, 8.15908760e-02f, -1.09575562e-01f, 1.11811988e-01f, 1.83876112e-01f,
  2.72235125e-02f, -1.32288009e-01f, -6.83375448e-02f, -4.13638689e-02f, 1.91611797e-01f, -9.61422697e-02f, 6.24485686e-02f, 7.36643523e-02f, 2.70805713e-02f, 1.72478035e-02f,
  -5.50215133e-02f, 1.98553935e-01f, 1.79302573e-01f, -2.13058129e-01f, -1.66633204e-01f, 2.98024621e-02f, 1.16039380e-01f, -1.31274313e-01f, -5.26628233e-02f, -3.43373977e-02f,
  2.19235078e-01f, -4.08349514e-01f, 3.24581295e-01f, 2.27395874e-02f, 2.15794280e-01f, 2.23858997e-01f, 1.09146535e-01f, 1.38450503e-01f, 1.52217120e-01f, -2.41197854e-01f,
  -1.47902593e-01f, -3.18875849e-01f, -9.48958006e-03f, -2.56898344e-01f, 2.64016747e-01f, -3.80143858e-02f, -1.22063540e-01f, -2.58468658e-01f, 2.01919705e-01f, -2.59258114e-02f,
  9.64867547e-02f, -2.15496436e-01f, 8.89930278e-02f, -2.04718485e-01f, -4.46672626e-02f, -8.95836055e-02f, -7.76265338e-02f, 2.80938633e-02f, -3.35717440e-01f, 4.84349653e-02f,
  -1.50598675e-01f, -7.58611597e-03f, -1.21916085e-01f, -5.81361493e-03f, 7.11933002e-02f, -4.73712459e-02f, -2.39102487e-02f, -1.96661483e-02f, 4.92585003e-02f, -3.06312740e-03f,
  -9.43577364e-02f, -2.70974338e-02f, -5.70530891e-02f, 1.17386386e-01f, 2.93382145e-02f, 4.12772223e-02f, 1.05396666e-01f, 3.57473679e-02f, -3.42752114e-02f, 2.00666294e-01f,
  7.95049220e-02f, 2.13511717e-02f, 1.24186547e-02f, -1.32034719e-01f, 1.01764172e-01f, 7.86295608e-02f, 4.58051302e-02f, 1.76910800e-03f, -9.20738354e-02f, 4.87811230e-02f,
  -2.64331866e-02f, -6.73190653e-02f, 4.84345369e-02f, -3.64712179e-02f, -7.21200258e-02f, -3.30553926e-03f, -6.24358952e-02f, 2.00560726e-02f, -5.31042367e-02f, -1.31452665e-01f,
  6.64621890e-02f, -4.91014719e-02f, 1.00303851e-02f, 1.73701788e-03f, 9.91687272e-03f, 3.54787633e-02f, -7.88340047e-02f, -3.13613028e-03f, 3.21158096e-02f, 3.88379581e-02f,
  -1.59481950e-02f, -1.71258580e-02f, 1.86540419e-03f, 8.47197231e-03f, -1.83264501e-02f, 1.09459028e-01f, -1.11671261e-01f, 1.69437960e-01f, 7.60292709e-02f, -3.28044430e-03f,
  -4.33902621e-01f, -4.73934323e-01f, -1.25920296e-01f, -1.05414629e-01f, -1.51305899e-01f, -6.66844472e-03f, -7.21728504e-02f, 4.03177924e-02f, -6.79949671e-02f, 4.00332026e-02f,
  -8.23325068e-02f, -1.01731718e-02f, -3.60855274e-02f, 5.26548363e-02f, -1.58749655e-01f, 5.10603040e-02f, -7.04145655e-02f, -2.09899411e-01f, -1.47950873e-01f, -7.01453462e-02f,
  -3.26093808e-02f, -4.81229946e-02f, 7.08828494e-02f, 6.43562675e-02f, 4.81019318e-02f, 3.22782099e-02f, 3.42036299e-02f, -7.65962973e-02f, -1.48285448e-03f, -1.29195511e-01f,
  -2.79708263e-02f, 1.58947501e-02f, 9.89152193e-02f, -3.43728542e-01f, 1.15089349e-01f, 5.47531068e-01f, 3.16140465e-02f, -1.33254975e-01f, -3.38059962e-01f, -2.14046270e-01f,
  -2.73581952e-01f, -7.30637312e-02f, -6.15305640e-03f, -6.96327835e-02f, 4.77999836e-01f, 2.23977670e-01f, -1.84557393e-01f, -2.28093952e-01f, -1.37654603e-01f, -2.89206803e-01f,
  -9.74156782e-02f, -7.90322274e-02f, 1.19824335e-01f, 6.88001141e-02f, -2.78970152e-01f, -2.31547490e-01f, -8.29500258e-02f, 1.87132098e-02f, 1.51411118e-02f, 9.87646356e-02f,
  4.52559590e-02f, -2.78010309e-01f, -4.41616811e-02f, 2.22543254e-02f, 7.31571764e-02f, 8.72890204e-02f, -4.48802672e-02f, 1.12250604e-01f, -1.03352986e-01f, -3.15082669e-02f,
  -1.88471396e-02f, 6.41580075e-02f, -9.66850594e-02f, 6.54578432e-02f, -2.10068166e-01f, -1.51683107e-01f, -8.77807066e-02f, -1.33423045e-01f, 5.41002937e-02f, 5.30885309e-02f,
  -5.94202355e-02f, -5.15954532e-02f, -1.64247483e-01f, -1.20818503e-01f, -1.75486729e-01f, -1.34228215e-01f, -3.50566357e-02f, 1.03864260e-01f, -1.00666627e-01f, 1.34093463e-01f,
  -3.93018462e-02f, -6.68738782e-02f, 8.80430937e-02f, -3.25875427e-03f, 8.33657682e-02f, 3.13832331e-03f, 2.68002432e-02f, -8.29489827e-02f, -9.21943411e-02f, -8.60887095e-02f,
  -1.55579880e-01f, -1.51562840e-01f, -8.32187608e-02f, -5.78412339e-02f, 1.56028330e-01f, -6.05689688e-03f, 2.00145505e-02f, -7.94801712e-02f, -1.68246757e-02f, 9.62984189e-02f,
  -7.94817731e-02f, -8.99821222e-02f, -1.47381380e-01f, -4.69961762e-02f, 1.20595410e-01f, 6.65599182e-02f, -5.30784391e-02f, 1.43503606e-01f, -1.36389703e-01f, 4.28519510e-02f,
  7.96426237e-02f, -4.10402045e-02f, 3.33102196e-02f, -6.46991879e-02f, 5.55304438e-02f, 1.45484537e-01f, 5.97886406e-02f, 2.67780945e-02f, 3.65966093e-03f, -1.51003674e-01f,
  5.41786328e-02f, -4.96069230e-02f, 2.98489798e-02f, 7.28656426e-02f, 7.23680332e-02f, -6.10179901e-02f, 3.86250508e-03f, -1.01938173e-01f, -6.83500767e-02f, 7.47188553e-02f,
  -2.68850140e-02f, -1.31627426e-01f, 5.81140106e-04f, -2.71053016e-01f, -3.14273149e-01f, -1.15782864e-01f, 6.12587407e-02f, -4.34745029e-02f, -1.84580863e-01f, -2.33826544e-02f,
  -2.97205150e-01f, 1.12170532e-01f, 3.70481223e-01f, 7.61673376e-02f, 2.57890254e-01f, 3.47372413e-01f, 2.35231191e-01f, 2.75310606e-01f, 3.43495429e-01f, -3.34733695e-01f,
  -3.56544197e-01f, 4.60551232e-02f, 2.37728804e-02f, -1.64832339e-01f, 1.83745459e-01f, 1.59354582e-01f, 1.20134972e-01f, -9.86967585e-04f, 3.32986683e-01f, 4.73304652e-02f,
  7.65947551e-02f, -2.75795877e-01f, -2.12060083e-02f, -1.25233695e-01f, -4.25412841e-02f, -1.27748579e-01f, -3.29146981e-01f, 3.50880593e-01f, -3.60295504e-01f, 6.13674633e-02f,
  -1.83861092e-01f, -8.60453323e-02f, -9.58398059e-02f, 7.30958674e-03f, -1.09233633e-01f, -1.10819163e-02f, -4.87100445e-02f, -4.05475177e-04f, 1.10429354e-01f, -7.84905851e-02f,
  -6.12951107e-02f, -4.23842948e-03f, -5.90553582e-02f, -3.99173461e-02f, 2.20856279e-01f, -6.57970756e-02f, 4.18474674e-02f, 1.76420078e-01f, -1.99649744e-02f, 1.64746806e-01f,
  1.30523220e-01f, 3.55377793e-02f, -5.11762798e-02f, -3.49870212e-02f, 2.96708499e-03f, -2.83975247e-02f, 3.75692025e-02f, 6.37337044e-02f, 1.20072350e-01f, 9.82822999e-02f,
  2.52839085e-02f, 4.98953052e-02f, 5.91572896e-02f, -2.44281488e-03f, 4.47247922e-02f, -5.19313514e-02f, -8.48421901e-02f, -1.58430070e-01f, 1.23225152e-01f, -4.37054262e-02f,
  -2.96960901e-02f, 4.47375402e-02f, 5.68056591e-02f, 8.18948261e-03f, -6.32508323e-02f, -1.20895598e-02f, 1.02471802e-02f, 3.85159776e-02f, 9.10444558e-02f, -8.76667872e-02f,
  2.68657692e-03f, 6.38922527e-02f, -6.04680106e-02f, -7.63199031e-02f, -9.16900020e-03f, 4.54863571e-02f, -1.64980412e-01f, -3.10164616e-02f, 3.23671326e-02f, 4.58245771e-03f,
  -6.43412098e-02f, -5.16263917e-02f, -1.60345078e-01f, -1.97517961e-01f, -7.56454766e-02f, -1.55778289e-01f, 5.59574626e-02f, -1.24155134e-01f, 4.31184247e-02f, 8.33831131e-02f,
  -4.53922302e-02f, -1.54486224e-01f, 1.50168641e-02f, -1.95895415e-02f, -7.65867939e-04f, -8.83279741e-02f, -8.52072388e-02f, -3.31029519e-02f, -1.00609586e-01f, 1.31119811e-03f,
  -5.85495159e-02f, -2.77468413e-02f, -9.60262045e-02f, -6.89086691e-02f, -4.41919118e-02f, -6.17002212e-02f, -2.07547322e-02f, 3.00099328e-02f, -1.59842670e-02f, 8.21209624e-02f,
  4.12981987e-01f, 1.17811270e-01f, 1.84931438e-02f, 2.08424151e-01f, -6.52054846e-02f, -2.08807573e-01f, -3.26087117e-01f, 6.24589287e-02f, 4.22744960e-01f, -5.60706928e-02f,
  -1.05281591e-01f, 6.58131987e-02f, -1.24981955e-01f, -1.19266696e-02f, 5.21899164e-02f, -5.27759120e-02f, -4.43611890e-02f, -1.61813572e-01f, 1.52480260e-01f, -5.78122307e-03f,
  2.16057435e-01f, -2.71733373e-01f, -9.59676653e-02f, -2.43405327e-01f, -1.92782916e-02f, 1.03926487e-01f, -9.65157747e-02f, -2.20622391e-01f, -1.03486903e-01f, -2.82572478e-01f,
  2.04021242e-02f, 1.26124188e-01f, 6.79509491e-02f, -9.35767889e-02f, 6.37431964e-02f, 1.02853926e-03f, 2.99918242e-02f, -7.13404417e-02f, 5.16125970e-02f, -3.74960937e-02f,
  8.41821637e-03f, -5.49042225e-02f, 1.88550111e-02f, -1.68930143e-01f, -4.89249602e-02f, -2.29475787e-03f, 1.63966522e-01f, 8.07204470e-02f, -1.44053444e-01f, 7.99985081e-02f,
  1.50592610e-01f, 1.59290403e-01f, 1.41960651e-01f, -4.45398036e-03f, 1.29899979e-01f, 2.55921744e-02f, -3.26576903e-02f, -2.17425125e-03f, -5.06178141e-02f, 1.16952471e-02f,
  -8.93337652e-04f, -3.48959491e-02f, -1.06462747e-01f, -1.35562466e-02f, -2.76244786e-02f, 6.61237910e-02f, -8.40005279e-02f, -1.72898009e-01f, -6.31503388e-02f, -1.15779221e-01f,
  8.22568014e-02f, -7.15770274e-02f, -9.64943543e-02f, -3.16985585e-02f, -2.14081742e-02f, -3.21099497e-02f, -6.43760264e-02f, -5.58343716e-02f, 6.05659522e-02f, 5.97027317e-02f,
  -1.84985653e-01f, -1.34394139e-01f, 2.19682883e-02f, 4.69678454e-02f, -3.66279334e-02f, 6.44227192e-02f, 3.63969542e-02f, 2.62528588e-03f, 1.41934976e-01f, -1.54729471e-01f,
  -3.32059637e-02f, -3.55501771e-02f, -5.57959871e-03f, -5.89543991e-02f, 1.69381350e-02f, -1.21699218e-02f, -1.46948025e-01f, 4.21351790e-02f, -6.29357845e-02f, -8.54632258e-02f,
  5.92526011e-02f, -1.30208910e-01f, 5.92950312e-03f, 7.29578957e-02f, -3.62475850e-02f, 1.68828350e-02f, -3.88699286e-02f, 1.05837464e-01f, -6.99108392e-02f, 1.20699935e-01f,
  1.49952732e-02f, 1.83042251e-02f, 3.83871645e-02f, 1.05942115e-01f, 7.23102018e-02f, -1.75285414e-02f, 6.58170357e-02f, 2.79218312e-02f, 4.81320880e-02f, 5.16929552e-02f,
  3.56762052e-01f, 2.28053078e-01f, 2.16292307e-01f, 3.28888267e-01f, 1.63661726e-02f, -2.61628702e-02f, 4.26925153e-01f, -1.49909779e-01f, 1.64275542e-01f, 7.54216835e-02f,
  1.53419852e-01f, 1.17513813e-01f, -1.22544743e-01f, 2.66162723e-01f, -2.80661345e-01f, -1.75377727e-01f, 2.46422023e-01f, 2.33237565e-01f, 5.84536754e-02f, 5.00577576e-02f,
  1.41887426e-01f, -7.31294900e-02f, 4.79786582e-02f, -2.31427491e-01f, 1.59127712e-01f, -1.80126410e-02f, -3.01904708e-01f, -1.30272999e-01f, -1.62504502e-02f, -2.00183198e-01f,
  1.45001397e-01f, 1.50283068e-01f, 9.20833275e-02f, -1.10940784e-02f, 2.59138606e-02f, 1.16020590e-01f, 2.44219252e-03f, -9.93458703e-02f, 2.52375379e-02f, 7.82904550e-02f,
  2.73842178e-02f, -1.08444020e-01f, 1.83978048e-03f, -6.96252882e-02f, 9.71665531e-02f, -1.27342464e-02f, 7.58086741e-02f, 1.09359227e-01f, 6.21781871e-02f, 6.32943073e-03f,
  1.99639738e-01f, 1.56818748e-01f, 1.24399267e-01f, -1.49371587e-02f, -7.50833005e-02f, -9.32676531e-03f, -2.27257572e-02f, 2.97618248e-02f, 4.97459322e-02f, -4.51235212e-02f,
  -1.44921783e-02f, 1.73125658e-02f, 1.35233656e-01f, 3.99970077e-02f, 6.50774408e-03f, 1.04941159e-01f, -4.86432128e-02f, -6.03856631e-02f, 1.50504243e-02f, 5.43867797e-02f,
  4.36047092e-02f, 5.68709671e-02f, -6.85907379e-02f, 1.96558740e-02f, 7.33139962e-02f, 1.89247727e-01f, -1.21578693e-01f, -4.25797738e-02f, 2.06713289e-01f, 8.66096690e-02f,
  -1.03112566e-03f, -1.26259578e-02f, 3.53098963e-03f, -3.89722548e-02f, -6.14953302e-02f, -1.26962692e-01f, -8.70154947e-02f, 8.95415097e-02f, -3.00654676e-03f, 4.76439223e-02f,
  -1.92796793e-02f, -2.04003394e-01f, 1.07461456e-02f, -5.96031584e-02f, -1.31670116e-02f, 3.77743617e-02f, -3.20992991e-02f, -3.07093430e-02f, -2.30426360e-02f, -6.38789237e-02f,
  6.42395467e-02f, 1.38581753e-01f, 1.13588758e-01f, -1.27781212e-01f, -1.48085905e-02f, 2.35064570e-02f, 7.05206953e-03f, -1.28860429e-01f, 1.52947670e-02f, -1.33725196e-01f,
  2.54487209e-02f, 4.90513407e-02f, 3.98859158e-02f, 7.05897361e-02f, 7.54794851e-02f, 3.27057205e-02f, -7.22868741e-02f, 3.98471542e-02f, -2.26152409e-03f, -3.49806808e-02f,
  -1.74780250e-01f, -2.79604584e-01f, -3.43685061e-01f, 6.45784363e-02f, 2.09409311e-01f, -1.92253187e-01f, -4.85304147e-02f, -3.53458524e-02f, 4.20693681e-02f, 1.31723315e-01f,
  -1.08100131e-01f, -4.15512741e-01f, -8.04231390e-02f, -5.01280487e-01f, -6.46392822e-01f, -3.09624434e-01f, -5.84442556e-01f, -3.04381281e-01f, -1.25790283e-01f, -1.84380010e-01f,
  -1.95688456e-01f, 6.22425117e-02f, -3.57869595e-01f, 3.17120075e-01f, 2.76297301e-01f, 2.79995978e-01f, 3.51220667e-01f, 3.06402236e-01f, 1.64237082e-01f, -5.78256771e-02f,
  -1.03711389e-01f, -5.78286648e-02f, -3.24320570e-02f, -7.96664804e-02f, -5.16518531e-03f, 8.92168134e-02f, -3.83251789e-03f, -3.22603546e-02f, -1.07661217e-01f, -1.20473690e-01f,
  -3.63713130e-02f, 3.08861192e-02f, 7.30786398e-02f, -5.90141211e-03f, 3.69074219e-03f, -6.95742890e-02f, 2.44760215e-02f, 6.82162941e-02f, 4.61409763e-02f, -1.62826747e-01f,
  -1.14994161e-02f, -3.80269401e-02f, -9.07777399e-02f, 3.76109891e-02f, -9.96233616e-03f, -1.64860994e-01f, 2.40682196e-02f, -6.69193789e-02f, 6.45049214e-02f, 4.17146757e-02f,
  -1.57187749e-02f, -6.60487413e-02f, -7.27180839e-02f, 1.20672233e-01f, 4.47832569e-02f, -8.18352867e-03f, -7.01927487e-03f, 1.33358702e-01f, 6.05235361e-02f, 7.10743964e-02f,
  3.27427895e-03f, -1.73727080e-01f, -5.34128211e-03f, -4.86234166e-02f, -1.41007872e-02f, 1.69970259e-01f, 2.54597552e-02f, -3.41276117e-02f, 1.23441778e-01f, -1.11248083e-01f,
  7.01628625e-02f, 9.56217498e-02f, 7.74438158e-02f, 8.59426856e-02f, -1.37931705e-01f, 1.36585906e-01f, 5.69604114e-02f, -6.41553774e-02f, 4.29067872e-02f, 3.10296547e-02f,
  -3.08665335e-02f, -6.74286101e-04f, 3.47506106e-02f, 5.28399609e-02f, -8.52765962e-02f, 1.65178906e-02f, -8.76041129e-02f, -3.78382802e-02f, -1.30321413e-01f, -1.40017355e-02f,
  -1.96318347e-02f, 1.69781774e-01f, 1.41772002e-01f, 8.99145305e-02f, 1.25914559e-01f, -1.08396478e-01f, 8.78906101e-02f, 6.54628649e-02f, 1.22743823e-01f, -8.73997342e-03f,
  8.88815746e-02f, 1.03169523e-01f, 1.15653910e-01f, 1.64106101e-01f, -3.08797453e-02f, 1.20461836e-01f, 4.29264642e-02f, -3.18069980e-02f, 9.61042568e-02f, 4.12842929e-02f,
  3.07558954e-01f, -2.40067631e-01f, -2.54177153e-01f, -2.95448676e-02f, 2.60867011e-02f, -1.12623244e-03f, -2.97124356e-01f, 8.46146643e-02f, 1.75676242e-01f, 7.78064504e-03f,
  -4.58714403e-02f, 8.06073546e-02f, -2.41376847e-01f, -1.17797656e-02f, 2.45048419e-01f, 9.48126316e-02f, 1.23046637e-01f, 1.00186080e-01f, 6.39903694e-02f, -1.66511431e-01f,
  3.05686668e-02f, 1.10432006e-01f, -3.31803858e-01f, -2.11851988e-02f, -1.19335264e-01f, -1.78021356e-01f, -1.48152979e-02f, -2.26690859e-01f, 7.72138266e-03f, 1.87845957e-02f,
  1.82185806e-02f, 2.59679966e-02f, -1.24654822e-01f, 3.86888571e-02f, -2.33560324e-01f, -8.79996084e-03f, 2.47847158e-02f, 4.98089716e-02f, 8.22814628e-02f, -2.24983059e-02f,
  -3.69331017e-02f, 6.01592734e-02f, 4.03066054e-02f, -6.28204569e-02f, 5.15017472e-02f, 1.07345834e-01f, -3.26423161e-02f, 3.45259942e-02f, -8.94695148e-03f, -1.96549922e-01f,
  -9.49131921e-02f, -5.09878844e-02f, 9.74193513e-02f, -9.63720307e-02f, -6.69220984e-02f, 2.41407100e-02f, 1.56863313e-02f, -3.87296788e-02f, 1.34062260e-01f, 1.63418457e-01f,
  -8.82149190e-02f, 7.49513358e-02f, 6.11895397e-02f, 9.31658298e-02f, -1.41513884e-01f, -7.69868866e-02f, 1.83160678e-01f, 1.09876722e-01f, -3.32378112e-02f, -4.06266488e-02f,
  3.69587652e-02f, -1.16541736e-01f, 5.95853552e-02f, 1.33759128e-02f, 6.87419996e-02f, 7.34060779e-02f, 1.17971033e-01f, -1.40001960e-02f, -2.07483899e-02f, 1.42613634e-01f,
  2.01027701e-03f, 4.27300446e-02f, -1.38031617e-01f, -2.95080990e-02f, 5.00179976e-02f, -1.96911126e-01f, 6.46488294e-02f, 3.17677371e-02f, -4.08083275e-02f, -1.49107343e-02f,
  3.14154290e-02f, -9.40036476e-02f, -1.63469180e-01f, 6.19042926e-02f, -1.41730487e-01f, 1.09281920e-01f, 1.33733109e-01f, 1.61420424e-02f, 5.55304140e-02f, 3.49008553e-02f,
  -2.40503494e-02f, -8.94425511e-02f, 6.06074482e-02f, 1.03821149e-02f, 1.24830194e-01f, 3.82218100e-02f, -1.57362856e-02f, 4.54476289e-02f, 1.07512988e-01f, 2.05327719e-02f,
  -1.46440655e-01f, -5.39702475e-02f, 4.75626476e-02f, 2.48165391e-02f, 7.66631812e-02f, 3.07682399e-02f, 8.69866163e-02f, -2.83145532e-02f, -6.98033199e-02f, 1.41087592e-01f,
  -4.84802246e-01f, 2.25212768e-01f, -2.62461692e-01f, -2.25549832e-01f, 4.73385565e-02f, 3.78091097e-01f, 3.51567417e-01f, 1.57562092e-01f, 1.52095437e-01f, 4.13031280e-01f,
  2.68075705e-01f, -6.50529414e-02f, 3.69542450e-01f, 1.54016823e-01f, -2.18107462e-01f, 2.04612598e-01f, 2.25648969e-01f, 1.60443142e-01f, 8.69235210e-03f, -1.46767110e-01f,
  -2.11103678e-01f, 1.41249537e-01f, -3.07466805e-01f, 6.72788695e-02f, -3.93929183e-02f, -1.13180503e-01f, 5.68361469e-02f, 6.10804521e-02f, 1.03257038e-01f, 2.06857041e-01f,
  1.29793212e-01f, 6.85403049e-02f, 7.20584579e-03f, 7.92776421e-02f, -8.38508606e-02f, -5.70325963e-02f, -1.75521672e-02f, -4.92683016e-02f, -9.96683463e-02f, -3.25935967e-02f,
  6.78973198e-02f, 4.15843539e-02f, -3.92826609e-02f, -1.20365269e-01f, 6.67034835e-03f, -6.35412410e-02f, 2.19261646e-02f, -3.57261673e-02f, 1.50043247e-02f, -1.27613917e-02f,
  -3.94410528e-02f, -8.35366733e-03f, 4.57036048e-02f, -3.46234068e-02f, -3.22186500e-02f, 1.06414676e-01f, 4.69402485e-02f, -4.42029387e-02f, 1.06910877e-01f, 2.58418452e-03f,
  -9.19959918e-02f, 6.18413277e-02f, 5.44247068e-02f, -7.99909383e-02f, 3.54229026e-02f, 1.10306954e-02f, -5.00648608e-03f, 3.27079440e-03f, -1.43629938e-01f, 1.76028609e-01f,
  -1.02193825e-01f, -9.40185860e-02f, 1.01877190e-01f, 9.89484601e-03f, 8.18784758e-02f, -3.76403406e-02f, -7.01717213e-02f, 8.12606215e-02f, -5.45259826e-02f, 5.70355058e-02f,
  8.85064006e-02f, 2.48784218e-02f, 1.02261961e-01f, 6.36069998e-02f, 1.19393192e-01f, -1.92804247e-04f, 8.71873870e-02f, -1.24760635e-01f, -5.09085972e-03f, -4.06626333e-03f,
  1.53586209e-01f, 2.97319829e-01f, 5.78316934e-02f, 3.91315520e-02f, 7.02519864e-02f, -4.12281826e-02f, 3.86782326e-02f, -4.07056957e-02f, 7.70323053e-02f, 1.23895556e-01f,
  -4.23022285e-02f, -3.96223664e-02f, -2.70607583e-02f, 1.75352804e-02f, -6.43411800e-02f, 1.67228639e-01f, 1.50237873e-01f, -3.95681076e-02f, 3.53780985e-02f, 4.72596660e-02f,
  5.34270005e-03f, 2.23601274e-02f, -5.19894063e-02f, 1.04242908e-02f, 2.42140926e-02f, 3.99162434e-02f, 9.37371552e-02f, -7.19589647e-03f, -1.58685036e-02f, -3.22807655e-02f,
  -1.56819105e-01f, -4.48947586e-02f, 3.55260335e-02f, -2.15637699e-01f, -6.39080405e-02f, 1.93801135e-01f, -2.56683111e-01f, 1.11932926e-01f, -1.36032933e-02f, 2.19350052e-03f,
  6.43087998e-02f, -3.11812162e-01f, 2.63990853e-02f, -2.56252587e-01f, 1.21169277e-01f, 5.67856245e-02f, -1.34733804e-02f, -2.13881731e-01f, -7.86012188e-02f, 6.29545823e-02f,
  1.75811490e-03f, -3.78442496e-01f, 4.81060669e-02f, 1.04529738e-01f, -2.01251760e-01f, 1.53630441e-02f, 2.60479361e-01f, -2.05810554e-02f, -8.81218016e-02f, -1.14522330e-01f,
  2.03902628e-02f, -4.04894613e-02f, 2.06195936e-02f, -3.51679362e-02f, 2.54190087e-01f, -1.11254133e-01f, 8.40217173e-02f, -1.29949287e-01f, 1.58340540e-02f, 7.61958137e-02f,
  -3.02579552e-02f, -1.41988590e-01f, 1.73426270e-02f, -1.20988019e-01f, -5.46590611e-02f, -9.12394468e-03f, 7.59439766e-02f, 1.87909409e-01f, -2.28913724e-02f, -1.27139362e-02f,
  -1.72808231e-03f, 8.34374106e-04f, 3.72671746e-02f, 1.43393025e-01f, -7.06659779e-02f, -4.87027057e-02f, 1.60492226e-01f, -1.08318754e-01f, 2.09151469e-02f, 8.52167085e-02f,
  3.64700966e-02f, -5.41664325e-02f, 4.34465483e-02f, -1.32590309e-01f, 1.56368613e-02f, 4.58614193e-02f, 3.16165052e-02f, 4.31397259e-02f, 1.35262460e-01f, 1.77276637e-02f,
  4.12745923e-02f, -2.37965286e-02f, 1.59013182e-01f, -6.29504099e-02f, 1.61751583e-02f, -1.56002238e-01f, 8.09771046e-02f, -3.83110414e-03f, 1.05290674e-01f, 1.37124509e-01f,
  1.38916045e-01f, -8.39033052e-02f, -8.30278099e-02f, 6.95081651e-02f, -1.31805256e-01f, 3.05342134e-02f, -1.27197327e-02f, 3.46942395e-02f, 4.02906276e-02f, 9.26031470e-02f,
  7.29240105e-02f, 2.61316448e-01f, 5.68919331e-02f, -9.36790705e-02f, 3.01706064e-02f, -2.43952516e-02f, -1.31634161e-01f, 4.96500209e-02f, 6.16427623e-02f, -1.11939199e-01f,
  -1.33819580e-01f, 8.16761330e-03f, 9.66924131e-02f, -7.78294876e-02f, 1.41367868e-01f, 9.32917744e-02f, 5.76002933e-02f, 8.46738815e-02f, 1.38221517e-01f, 1.65249221e-02f,
  -3.00581530e-02f, 1.18120853e-02f, -7.80530646e-02f, 9.75812078e-02f, -1.13472693e-01f, 1.64411142e-02f, 1.92288440e-02f, -8.49084854e-02f, 3.09382211e-02f, 1.11471318e-01f,
  2.87590742e-01f, 3.25084299e-01f, -5.49785458e-02f, 1.93641022e-01f, 2.39307851e-01f, 2.35248342e-01f, 1.25111327e-01f, 3.39191556e-01f, 3.65522474e-01f, -1.75340772e-02f,
  6.88105822e-02f, 1.62104234e-01f, -1.38114035e-01f, 5.61313219e-02f, 1.66204005e-01f, 1.93522312e-02f, 3.25703293e-01f, 1.21634714e-01f, 1.11056477e-01f, 7.94724524e-02f,
  2.31817484e-01f, 1.29124910e-01f, -3.15632641e-01f, -1.56043038e-01f, 1.34624928e-01f, -4.45805378e-02f, -2.91635662e-01f, -1.67263567e-01f, -1.28079295e-01f, 4.04846249e-03f,
  1.68023296e-02f, 8.97515789e-02f, -9.35331658e-02f, -7.52930641e-02f, -3.43668051e-02f, 7.59090558e-02f, -7.64663741e-02f, -2.02314600e-01f, -5.51578887e-02f, 9.40238591e-04f,
  -3.93328555e-02f, -4.97260736e-03f, 1.19425662e-01f, -3.21900398e-02f, 1.00886591e-01f, -2.20564916e-03f, -1.05618693e-01f, 6.72625378e-02f, -1.39898837e-01f, -4.72798012e-03f,
  -2.12374389e-01f, -9.78410542e-02f, 1.36254504e-01f, -5.92572019e-02f, -5.40867746e-02f, 4.94417883e-02f, -1.51441498e-02f, 1.92311348e-03f, -9.85779092e-02f, 6.95983320e-02f,
  1.13559298e-01f, 3.94212455e-02f, 6.46820515e-02f, -1.28427967e-01f, -4.06964570e-02f, 4.94496152e-02f, 6.95241094e-02f, 6.27998039e-02f, 1.35717824e-01f, -4.48334441e-02f,
  -4.68320176e-02f, 2.22794097e-02f, 1.44560565e-03f, -1.60956960e-02f, 7.13168457e-02f, -4.83641140e-02f, 8.71506482e-02f, 1.22953713e-01f, 1.68799207e-01f, -1.50162280e-01f,
  6.48155203e-03f, 5.92068695e-02f, -1.43712640e-01f, -7.04359338e-02f, -9.20319930e-03f, 4.17280383e-02f, 1.36762992e-01f, 2.19176919e-03f, -1.42353848e-01f, 7.60032982e-02f,
  7.98273385e-02f, 4.33833361e-01f, 6.17027245e-02f, -3.41910869e-03f, 1.63749815e-03f, 5.23585193e-02f, 5.28309457e-02f, 1.62345126e-01f, 1.77322067e-02f, 1.43051937e-01f,
  8.47591832e-02f, -1.47089297e-02f, 8.62125978e-02f, -3.58275808e-02f, -1.02254301e-01f, 2.36351281e-01f, 7.71557912e-02f, 4.03252915e-02f, 5.50854206e-02f, -1.78114921e-02f,
  -5.20127118e-02f, 7.17242062e-02f, -8.79297107e-02f, 1.13447696e-01f, 7.01853307e-03f, -6.50268272e-02f, 1.32362217e-01f, -7.88415447e-02f, -5.07542118e-02f, 1.00259990e-01f,
  -1.88627332e-01f, 3.36876124e-01f, 2.33718783e-01f, -2.87944615e-01f, -1.42720509e-02f, 1.67312115e-01f, 7.32000768e-02f, 1.53088227e-01f, 1.25862882e-01f, 1.34381577e-01f,
  -1.12203784e-01f, 6.49394765e-02f, 9.64936707e-03f, -1.92919552e-01f, -3.95180613e-01f, -1.85525313e-01f, -1.37778655e-01f, 3.26191857e-02f, 9.87239853e-02f, 1.64519370e-01f,
  -2.19848961e-01f, -3.75151813e-01f, -1.74906388e-01f, 8.22411180e-02f, 1.63633704e-01f, 2.63697654e-01f, -1.14103965e-01f, 1.73923954e-01f, -5.90029471e-02f, -2.74840370e-02f,
  -4.61823307e-02f, 5.24619780e-02f, 5.35184704e-03f, -6.32312298e-02f, -6.15602778e-03f, -2.53926832e-02f, 1.58764228e-01f, 8.23503137e-02f, -1.47227049e-01f, -1.44270003e-01f,
  -9.38011929e-02f, -1.44606873e-01f, -2.63644382e-02f, -1.78067014e-01f, -6.41393056e-03f, 3.18873003e-02f, 3.22358636e-03f, -6.52952567e-02f, 3.63646541e-03f, -4.57794406e-02f,
  -1.96650892e-01f, -1.00746602e-01f, -1.35721609e-01f, -3.76191735e-02f, -5.59395291e-02f, 5.77907674e-02f, 1.88940652e-02f, -1.42321125e-01f, 2.37933192e-02f, -3.48851308e-02f,
  1.27135431e-02f, -4.91807535e-02f, -9.76106972e-02f, 4.97106686e-02f, -1.43833727e-01f, -3.10580917e-02f, -7.91038498e-02f, -1.23409644e-01f, -6.41916972e-03f, -1.52868822e-01f,
  3.12157627e-02f, 8.96940976e-02f, 7.23930523e-02f, 2.60043256e-02f, -4.88716476e-02f, 6.19471213e-03f, -5.60828950e-03f, -9.55425650e-02f, 1.12760179e-01f, 1.17304496e-01f,
  -1.09102637e-01f, 5.79654686e-02f, 5.66796362e-02f, 5.23521416e-02f, 3.62131819e-02f, 5.89494295e-02f, 7.94733316e-02f, -1.09223820e-01f, -9.48653650e-03f, -6.59547597e-02f,
  2.02070177e-01f, 2.59344220e-01f, 1.89029530e-01f, 4.55351323e-02f, 4.08602469e-02f, 1.07809389e-02f, 4.00451235e-02f, -2.11160257e-02f, 5.78851886e-02f, -4.62683737e-02f,
  -5.00774719e-02f, 9.34812427e-02f, 1.05858639e-01f, -1.47908702e-01f, 7.32295886e-02f, -7.47383684e-02f, -1.94750838e-02f, 1.29525691e-01f, 7.75933042e-02f, -2.07567886e-02f,
  -1.76958129e-01f, 3.87714580e-02f, -1.08854279e-01f, -5.46517782e-02f, -8.30784738e-02f, 4.82298285e-02f, -1.31048942e-02f, 5.44639006e-02f, -2.72727441e-02f, 5.43150567e-02f,
  9.74481329e-02f, -7.70359933e-02f, -2.78441161e-01f, -3.05134524e-02f, -5.79254292e-02f, 1.53888300e-01f, 3.00511807e-01f, -3.75805311e-02f, -2.84319490e-01f, 2.84127980e-01f,
  4.20400083e-01f, -1.70324147e-02f, 2.33282670e-01f, 4.51865017e-01f, 2.66176403e-01f, 2.73454994e-01f, 2.84386933e-01f, 1.22260079e-01f, -7.26632103e-02f, 8.17641430e-03f,
  -4.66322675e-02f, 3.44000667e-01f, 1.19276710e-01f, 9.30277444e-03f, 3.14741075e-01f, -2.38447711e-01f, 2.57557124e-01f, -1.06523328e-01f, 2.44388551e-01f, 1.40314028e-01f,
  3.83467674e-02f, 1.13571240e-02f, 1.96325927e-04f, -6.57858551e-02f, 6.25574775e-03f, 6.57318607e-02f, -1.52953202e-02f, 4.99108210e-02f, 1.85560081e-02f, -1.08289858e-03f,
  -7.82960057e-02f, -5.11895418e-02f, -6.55997405e-03f, 3.69076664e-03f, -1.27058789e-01f, -9.17005241e-02f, -7.37325773e-02f, -1.10248797e-01f, 9.97914001e-03f, 1.06579848e-02f,
  -3.30773629e-02f, -9.45425183e-02f, -2.68642027e-02f, 8.28532130e-02f, 2.74975095e-02f, -1.15567625e-01f, -1.13857307e-01f, -5.89920394e-02f, -3.39200310e-02f, 7.79082766e-03f,
  -2.73530651e-02f, -6.18792921e-02f, 3.73578705e-02f, 1.17967375e-01f, -4.41827066e-02f, 7.53015354e-02f, 1.65274795e-02f, 3.76230218e-02f, -7.03736267e-04f, 1.11634977e-01f,
  -2.57780571e-02f, -1.16447702e-01f, 4.87742126e-02f, -9.13358182e-02f, 3.33708711e-02f, -7.52065405e-02f, -5.53320646e-02f, 3.33610103e-02f, -1.78757422e-02f, 2.68402882e-02f,
  -1.64739452e-02f, -1.22703284e-01f, 3.85273434e-02f, 5.11878543e-02f, 4.74041961e-02f, -3.95343862e-02f, 3.53015214e-02f, 2.84684426e-03f, 6.80179223e-02f, 2.79978272e-02f,
  7.83950686e-02f, -5.82658276e-02f, -1.00521244e-01f, -2.20955908e-02f, 1.41928727e-02f, 3.91296782e-02f, 5.66542596e-02f, -1.04769886e-01f, -5.91149777e-02f, -2.88846791e-02f,
  5.58215082e-02f, -4.01893035e-02f, -5.62982680e-03f, 2.48453729e-02f, 3.43432464e-02f, 2.92083584e-02f, 1.86489448e-02f, -5.12990654e-02f, -8.34695920e-02f, -1.73898358e-02f,
  -2.48827953e-02f, 5.30001596e-02f, 3.81084271e-02f, 1.74103659e-02f, -1.05454311e-01f, 2.55376436e-02f, -9.98326316e-02f, -7.07587600e-02f, 6.94602132e-02f, 1.73998661e-02f,
  4.43855315e-01f, -2.31335998e-01f, 3.59445922e-02f, 2.79490620e-01f, 3.04331988e-01f, 2.84586161e-01f, 4.55553055e-01f, 2.48274341e-01f, 4.01843488e-01f, -3.10468107e-01f,
  -1.34462938e-01f, -1.48614526e-01f, -2.81949759e-01f, 1.20878994e-01f, 3.33308488e-01f, -8.01886665e-04f, 2.55432189e-01f, 2.24654183e-01f, 2.19366670e-01f, 2.01519236e-01f,
  1.81818262e-01f, -2.28402857e-03f, -2.57171869e-01f, -1.52244866e-01f, 6.99571818e-02f, -1.11417189e-01f, -2.39324704e-01f, -8.37730020e-02f, -2.89581418e-01f, 1.75839305e-01f,
  -6.79120198e-02f, 8.04942995e-02f, 2.47565713e-02f, -6.99641854e-02f, 2.31621079e-02f, -8.95708799e-02f, -5.54293767e-02f, -5.72575405e-02f, 4.06879140e-03f, -1.08678199e-01f,
  -8.45222548e-02f, -8.22863281e-02f, -8.46869219e-03f, 4.44713868e-02f, 1.36514515e-01f, -1.18044384e-01f, -1.11528374e-01f, -1.15201652e-01f, -7.24983290e-02f, -1.03855550e-01f,
  2.09686020e-03f, -3.51615138e-02f, 6.27417862e-02f, -1.16152326e-02f, -7.53209442e-02f, 6.93666041e-02f, 5.17054498e-02f, -1.67042986e-02f, -2.30401871e-03f, 1.45934328e-01f,
  2.44086031e-02f, 5.74199185e-02f, 1.65289629e-03f, 7.70469289e-03f, 7.33295158e-02f, -3.99071574e-02f, 2.99228765e-02f, -5.59272952e-02f, 5.69532178e-02f, -1.02850357e-02f,
  8.86487439e-02f, 1.24360258e-02f, 2.71431897e-02f, -4.11514640e-02f, 1.55592695e-01f, 2.17313040e-02f, -9.05704945e-02f, 2.38480736e-02f, 7.82322437e-02f, 7.53065804e-03f,
  6.16509616e-02f, -3.20047773e-02f, -1.92111582e-02f, -3.37830223e-02f, -3.22124436e-02f, -4.87559475e-02f, 3.55011062e-03f, 7.37374416e-03f, 2.80957427e-02f, 3.93508859e-02f,
  1.03718162e-01f, 2.43162718e-02f, 2.85074357e-02f, -8.93035904e-03f, -1.05126083e-01f, -1.22798786e-01f, 1.51151225e-01f, 6.50415495e-02f, 3.08272410e-02f, -9.46078915e-03f,
  1.60459802e-02f, -2.18498483e-02f, -3.48923877e-02f, -2.93816458e-02f, -6.67989776e-02f, -5.89502566e-02f, -1.00239471e-01f, 6.85786009e-02f, 1.09817617e-01f, -1.48317292e-01f,
  -1.10171460e-01f, 1.28793418e-01f, 1.36753283e-02f, 7.66463354e-02f, -6.00528680e-02f, -4.58032601e-02f, -4.97659668e-02f, -7.56878331e-02f, -8.75221044e-02f, -3.37423682e-02f,
  4.56976771e-01f, -3.34804207e-01f, -2.85130918e-01f, 1.27457291e-01f, 3.34776282e-01f, 2.28965431e-01f, 1.94274262e-01f, 1.90594628e-01f, 1.40534401e-01f, -1.62270963e-01f,
  2.94068098e-01f, -2.26847097e-01f, -1.22377388e-01f, 1.74520582e-01f, 2.88181871e-01f, -1.02374353e-01f, 1.40194476e-01f, 6.97811171e-02f, -3.37392464e-02f, 2.03191012e-01f,
  2.70835429e-01f, 3.40470970e-01f, 6.04443438e-02f, -1.40488809e-02f, 2.83747792e-01f, 8.44571926e-03f, 2.57858150e-02f, -2.09254190e-01f, -1.05049219e-02f, -8.54454413e-02f,
  1.08005814e-01f, 5.44981621e-02f, -4.19226959e-02f, -1.65197626e-01f, 7.86864161e-02f, -4.93261404e-02f, -1.97924659e-01f, -1.19861988e-02f, 5.21714576e-02f, 1.37068510e-01f,
  -4.01802287e-02f, -1.10022416e-02f, 1.61355361e-01f, -2.08878256e-02f, 1.59779176e-01f, -4.17697069e-04f, 1.58741288e-02f, 5.53999320e-02f, -1.83664039e-02f, 9.03760046e-02f,
  -2.93758623e-02f, 7.32212961e-02f, 4.56248783e-02f, -1.78688675e-01f, 1.17670968e-01f, -1.49859767e-02f, -1.13806598e-01f, -1.17893234e-01f, 3.93706448e-02f, 6.19778335e-02f,
  1.08442269e-01f, -1.19785562e-01f, 4.26726863e-02f, 2.68703736e-02f, -2.30450165e-02f, -7.02833058e-03f, 7.44170919e-02f, -5.63262887e-02f, -1.08369000e-01f, -7.23120421e-02f,
  5.70451887e-03f, 9.72947329e-02f, 6.34128749e-02f, -6.22554086e-02f, 3.67080495e-02f, -8.79269689e-02f, 3.83919803e-03f, -4.81640100e-02f, -5.36263399e-02f, 1.40316198e-02f,
  -1.24463871e-01f, 4.12563682e-02f, 4.76199314e-02f, 9.16453674e-02f, -6.69956952e-02f, -4.32865582e-02f, -5.53520918e-02f, -4.20849510e-02f, 2.47387607e-02f, -1.80119965e-02f,
  -8.76324996e-02f, -2.08263216e-03f, -2.08081361e-02f, -1.75871402e-02f, -1.46464437e-01f, 9.84036326e-02f, -1.58692241e-01f, -4.95933788e-03f, -2.60181930e-02f, 8.47586095e-02f,
  4.87996787e-02f, -2.09460333e-02f, -2.45447494e-02f, -2.62689851e-02f, -1.25756850e-02f, 3.37945372e-02f, -7.15641305e-02f, -8.44532251e-03f, -6.65229112e-02f, 3.51856649e-02f,
  -7.36719221e-02f, 3.79100218e-02f, -7.78120831e-02f, 6.09232411e-02f, -5.35949282e-02f, 5.16463034e-02f, -3.51323560e-02f, 2.38545518e-02f, 2.35327259e-02f, -6.85453862e-02f,
  1.65959656e-01f, -3.15573990e-01f, 3.02083433e-01f, 1.17020514e-02f, 1.94433212e-01f, 2.07806587e-01f, 2.48623237e-01f, -2.47207865e-01f, -1.33216113e-01f, -4.22490060e-01f,
  -3.76115292e-02f, 3.96467559e-02f, 2.18169346e-01f, -3.53876442e-01f, 3.43011916e-01f, 7.34222308e-02f, -2.79393435e-01f, -2.06264243e-01f, 1.32897841e-02f, -2.01151073e-01f,
  -8.67594630e-02f, -4.49368209e-01f, 5.90846017e-02f, -4.38126504e-01f, -8.36752430e-02f, -1.54987618e-01f, -2.42873747e-02f, 4.96512167e-02f, -2.53143042e-01f, 4.86681685e-02f,
  -1.02707930e-01f, -2.51741111e-01f, -2.79647857e-02f, 7.60558061e-03f, 3.93252783e-02f, 6.44986145e-03f, 8.74349698e-02f, 1.65175617e-01f, 3.21935602e-02f, 3.18309944e-03f,
  -1.20243160e-02f, 5.82549423e-02f, -9.03378576e-02f, -1.98518066e-03f, -5.44495024e-02f, -6.16667047e-02f, 9.99214873e-02f, 7.03753307e-02f, 7.63141597e-03f, 1.64455041e-01f,
  1.25995353e-01f, 1.24867365e-01f, 1.70103177e-01f, -4.35339771e-02f, 1.32549331e-01f, 7.45374188e-02f, 1.13108225e-01f, 1.17574081e-01f, -1.29449135e-03f, -4.59277891e-02f,
  -6.71656579e-02f, 3.00097466e-03f, 2.53131986e-02f, 1.43815326e-02f, -5.10036647e-02f, 2.82579884e-02f, -8.52555260e-02f, 4.77279574e-02f, 7.14511499e-02f, 6.93138912e-02f,
  -2.90280376e-02f, 6.37164339e-02f, -1.08718006e-02f, -6.51997849e-02f, 2.80398224e-03f, -1.39048565e-02f, 8.37751254e-02f, 7.41861239e-02f, 1.09472563e-02f, 5.19863665e-02f,
  4.11275141e-02f, -2.90483739e-02f, 1.66877881e-02f, 1.60800219e-02f, -3.27753872e-02f, 4.55044471e-02f, -9.36198607e-02f, -2.12148502e-02f, -8.55545979e-03f, 6.46370649e-02f,
  -3.59433115e-01f, -4.76338893e-01f, -7.51271993e-02f, -3.86808030e-02f, -4.25793380e-02f, 1.77232902e-02f, -4.20224369e-02f, -4.50247414e-02f, 1.04759512e-02f, -2.39500888e-02f,
  5.55250561e-03f, -6.96737245e-02f, -1.22788996e-01f, 2.32182685e-02f, -1.56816393e-01f, 1.55522367e-02f, -8.53701308e-02f, -1.71283577e-02f, 3.37437019e-02f, -8.24327692e-02f,
  -9.31029618e-02f, 2.07020678e-02f, -6.19306341e-02f, -1.05682865e-01f, -6.64484650e-02f, 2.58484781e-02f, -1.02333672e-01f, -5.44910468e-02f, -1.04688276e-02f, -8.01543742e-02f,
  -2.20367149e-01f, -2.20481724e-01f, 2.43308805e-02f, 2.16288492e-01f, -4.77864174e-03f, -2.98374146e-01f, -2.37551942e-01f, 2.30638519e-01f, -2.28466213e-01f, -2.44377151e-01f,
  -8.13126490e-02f, -1.77174747e-01f, -3.75684917e-01f, -4.71900292e-02f, 9.88651887e-02f, -3.25975686e-01f, 1.26172528e-01f, -9.94482562e-02f, -7.63759986e-02f, 9.11401883e-02f,
  1.28354013e-01f, 5.67400679e-02f, 9.34008807e-02f, 2.46696085e-01f, 3.85852531e-02f, 3.26046199e-01f, 4.01343107e-01f, 1.11709222e-01f, 3.85881096e-01f, 6.21804483e-02f,
  2.60608420e-02f, -9.67342779e-03f, -1.31480759e-02f, 1.14919115e-02f, 1.69493482e-01f, 2.59359963e-02f, 1.29312754e-01f, -7.98880681e-02f, 1.85309932e-01f, 6.88824281e-02f,
  -1.08181186e-01f, 7.22768605e-02f, -1.22230873e-02f, -9.60975364e-02f, -7.84762576e-02f, -1.85139908e-03f, 5.38881905e-02f, -5.31569496e-02f, 2.28636321e-02f, -7.10758120e-02f,
  -4.30735908e-02f, -5.58864884e-02f, -1.72828436e-02f, 9.77701321e-02f, 5.57788350e-02f, -1.28144631e-02f, -2.35410910e-02f, 1.15399500e-02f, -5.26848882e-02f, 7.66235739e-02f,
  -3.31871659e-02f, -4.47349250e-02f, -5.91785237e-02f, -6.78102598e-02f, -1.00434802e-01f, 1.01278126e-01f, 7.56956562e-02f, -4.13804427e-02f, -4.70812209e-02f, -1.42787009e-01f,
  5.71840890e-02f, 1.12579085e-01f, 5.78357987e-02f, -4.51949723e-02f, 4.46249498e-03f, -4.84839603e-02f, 1.15142472e-01f, -4.10777591e-02f, 1.22778527e-01f, -4.62302342e-02f,
  -5.21918051e-02f, -2.80041061e-02f, 7.68041834e-02f, 1.39336199e-01f, -2.85728592e-02f, 1.40641361e-01f, 7.93099031e-03f, -9.53458399e-02f, -9.01755840e-02f, -1.30133564e-02f,
  4.38101478e-02f, 9.47980806e-02f, 3.16037685e-02f, -7.14843944e-02f, -4.26382609e-02f, -1.22079276e-01f, -6.37992620e-02f, 4.99886461e-02f, 1.82268858e-01f, -7.63606727e-02f,
  8.60390961e-02f, -1.80174839e-02f, 4.05486971e-02f, -4.20660526e-03f, 1.65968642e-01f, 9.87566337e-02f, 6.39860798e-03f, 7.70891532e-02f, 1.80087134e-01f, 1.38130039e-01f,
  6.57928512e-02f, -7.75397941e-02f, 5.94158694e-02f, 6.04138970e-02f, 4.25055809e-02f, 1.12806521e-01f, 2.10475009e-02f, 3.18300352e-02f, -2.60730032e-02f, 4.51980606e-02f,
  -6.09073380e-04f, 3.42009902e-01f, -5.23978919e-02f, 9.80372727e-02f, -1.39241051e-02f, -5.17913163e-01f, -3.41049641e-01f, -2.13319063e-02f, 1.84392661e-01f, 1.46384135e-01f,
  7.63468295e-02f, 4.36669797e-01f, 3.28185767e-01f, -4.03203070e-02f, -3.66634697e-01f, 1.24248657e-02f, -4.20078427e-01f, -1.40007347e-01f, 1.21372618e-01f, -8.16781968e-02f,
  -1.69299692e-01f, -1.67540625e-01f, -1.44765958e-01f, 1.42822415e-01f, -1.90952346e-01f, 8.75990912e-02f, -1.89635620e-01f, 2.40122989e-01f, -2.75636703e-01f, -1.10448509e-01f,
  -2.68512070e-01f, 2.67395765e-01f, 4.32156771e-02f, -4.73776348e-02f, -1.54718518e-01f, -1.39218926e-01f, -1.33605316e-01f, 1.06606977e-02f, 1.48620695e-01f, -6.39516301e-03f,
  1.75069477e-02f, 9.13890004e-02f, 2.00826600e-02f, -3.15202959e-02f, 8.73198062e-02f, 1.75587181e-02f, 2.07054559e-02f, -1.68894500e-01f, 1.05913751e-01f, -4.66599828e-03f,
  -2.02087760e-02f, 2.97171585e-02f, -2.05914360e-02f, -5.53211337e-03f, 2.66193170e-02f, -4.03502882e-02f, -1.57759219e-01f, -6.00170270e-02f, -1.15948603e-01f, -1.10623568e-01f,
  9.55749154e-02f, -1.46626756e-01f, -8.51164339e-04f, -4.13830355e-02f, 9.13462341e-02f, 3.66371684e-02f, 9.70655978e-02f, 4.65087481e-02f, 9.94827822e-02f, 5.30502014e-02f,
  -4.29363735e-02f, 1.46908507e-01f, 7.56461741e-05f, -1.36376679e-01f, 3.03305537e-02f, -2.54270397e-02f, -6.30027130e-02f, 1.28779829e-01f, -5.27719073e-02f, 1.07767060e-03f,
  1.55874267e-01f, -4.58688103e-02f, 2.59510148e-02f, -1.00518234e-01f, -1.57797784e-01f, 1.54640768e-02f, 3.15305777e-02f, -9.74223483e-03f, -9.05125737e-02f, 2.70613600e-02f,
  -2.87006974e-01f, 3.99377644e-02f, 7.90022761e-02f, 6.92438036e-02f, -1.13279140e-02f, -9.93987396e-02f, 4.90789153e-02f, -3.87632772e-02f, -1.09651342e-01f, 1.57286916e-02f,
  -8.08447897e-02f, -8.75737742e-02f, -1.24155417e-01f, -4.71614078e-02f, 5.18955998e-02f, -1.38953954e-01f, -6.10208232e-03f, -1.06220972e-02f, -1.12814397e-01f, 8.42438266e-03f,
  1.65448532e-01f, 6.40462199e-03f, 8.17745328e-02f, -4.99637164e-02f, 6.06847554e-02f, -1.28215268e-01f, 1.03474833e-01f, 3.58121619e-02f, -8.93296152e-02f, 3.89414541e-02f,
  1.11645810e-01f, -5.70786893e-02f, -3.00222516e-01f, -9.85413343e-02f, -1.47303075e-01f, 3.42322052e-01f, 2.29891494e-01f, -7.81351924e-02f, -2.53066838e-01f, 3.28744411e-01f,
  1.43710479e-01f, -7.97498599e-02f, -5.58801517e-02f, -7.13070333e-02f, -2.75753915e-01f, -2.11818889e-01f, 1.86261326e-01f, 2.32122093e-01f, -1.67710066e-01f, 1.66451752e-01f,
  -1.47093892e-01f, 9.73308533e-02f, -2.55617797e-01f, -6.16324246e-02f, 8.48821253e-02f, -6.13411516e-02f, 1.73273817e-01f, -5.18072322e-02f, 2.03189433e-01f, -1.69829890e-01f,
  8.89617056e-02f, -1.73967257e-01f, -5.82947582e-02f, 1.95716694e-02f, 1.25100791e-01f, 9.09986794e-02f, 1.34952590e-01f, -9.05592367e-02f, -9.20510069e-02f, -9.34018493e-02f,
  1.89148158e-01f, -5.05653443e-03f, 2.51783971e-02f, -1.69714689e-01f, 1.29899740e-01f, -9.00923759e-02f, -1.14381984e-01f, -7.57468939e-02f, -3.21930945e-02f, 8.82021785e-02f,
  -9.12481844e-02f, -3.40363085e-02f, 7.09473416e-02f, 3.16371918e-02f, 7.38297217e-03f, -1.15368590e-01f, 5.87377287e-02f, 5.29508442e-02f, 1.31208986e-01f, -1.08857989e-01f,
  9.78747532e-02f, 1.35380358e-01f, 4.01907936e-02f, -1.07874982e-01f, -1.21981055e-01f, -8.61103833e-02f, -4.95299464e-03f, 7.66029954e-02f, -1.06706448e-01f, -3.45053524e-02f,
  -1.67258717e-02f, 1.26036322e-02f, 7.62248831e-03f, 9.63812321e-02f, 5.27682900e-02f, -7.98546374e-02f, 7.85974711e-02f, 4.74914834e-02f, 1.01501353e-01f, -9.81379300e-02f,
  -6.75158650e-02f, -3.82697806e-02f, 6.52451860e-03f, 2.11801261e-01f, 1.08973935e-01f, -2.09809057e-02f, 1.02913767e-01f, -1.33921787e-01f, -1.04049735e-01f, 1.10300273e-01f,
  6.97022751e-02f, 1.99080557e-01f, -1.61349088e-01f, 7.20537603e-02f, -1.48009416e-02f, 3.37405652e-02f, -8.93375874e-02f, -7.44554354e-03f, 1.05088707e-02f, 5.42686023e-02f,
  2.03439787e-01f, 9.65093225e-02f, 1.46803752e-01f, 3.17742452e-02f, 1.92098375e-02f, -4.71473821e-02f, 1.79201692e-01f, -4.99279983e-02f, 2.13538721e-01f, 7.38961697e-02f,
  1.19468652e-01f, 1.25921205e-01f, 1.08324789e-01f, 7.02906027e-02f, 6.27553910e-02f, 8.44164118e-02f, -4.22668410e-03f, -6.09779321e-02f, 1.77264929e-01f, -2.84481738e-02f,
  -6.56588018e-01f, 4.48673278e-01f, -1.00501746e-01f, -2.55900353e-01f, 9.50824916e-02f, 3.96576256e-01f, 1.19839348e-01f, 1.53507739e-01f, 1.75149649e-01f, 3.07771713e-01f,
  2.33018875e-01f, -1.16539098e-01f, 2.60299504e-01f, 2.15346500e-01f, 1.32773539e-05f, 2.53796816e-01f, 1.62239581e-01f, -9.49188787e-03f, 8.86943843e-03f, -8.58417377e-02f,
  -1.15661524e-01f, 6.62711263e-02f, -4.50988673e-02f, 6.94984794e-02f, -1.30388290e-01f, -2.69364506e-01f, -2.24973440e-01f, 9.66744777e-03f, 3.88221927e-02f, 1.21903323e-01f,
  -1.31335035e-01f, -2.07374632e-01f, -4.23033088e-02f, -1.21030055e-01f, -1.73208103e-01f, -9.23316851e-02f, -2.14880884e-01f, -4.38372716e-02f, -4.93466109e-02f, 2.79590879e-02f,
  -7.90622607e-02f, 1.78684220e-02f, 3.79119590e-02f, 4.07955535e-02f, -5.31092659e-02f, 8.34838673e-02f, -5.18298056e-03f, 1.37433531e-02f, 9.24552418e-03f, 9.42336489e-03f,
  1.13451347e-01f, 7.21520782e-02f, -6.36377037e-02f, 7.79940328e-03f, -3.68504785e-03f, 8.32320005e-03f, -8.66287202e-02f, 6.01725131e-02f, -3.72899175e-02f, -5.00719361e-02f,
  -7.57938698e-02f, -3.16040702e-02f, 8.31449926e-02f, 1.01634137e-01f, 9.11833346e-02f, -8.54386985e-02f, 1.56944972e-02f, 2.01721322e-02f, -1.14047199e-01f, -1.34496465e-02f,
  1.21400744e-01f, 1.72772501e-02f, -1.07179925e-01f, -5.94139546e-02f, -1.35581657e-01f, -3.85244302e-02f, -2.97594676e-03f, -3.57562266e-02f, 3.19399461e-02f, 7.06533669e-03f,
  6.37734607e-02f, -3.65797244e-02f, 2.91242320e-02f, -8.56592208e-02f, 9.53178257e-02f, 4.00347225e-02f, -3.22761349e-02f, -1.09891221e-01f, 8.02263021e-02f, 3.47340517e-02f,
  7.10880905e-02f, -8.81452262e-02f, 7.29985386e-02f, -5.45710139e-02f, 4.57083508e-02f, 9.26826522e-02f, 2.19590887e-02f, 1.74343903e-02f, 1.62137281e-02f, 5.78950159e-02f,
  -1.14380457e-01f, -9.38631371e-02f, -7.02708215e-02f, 8.15627351e-02f, -4.52521853e-02f, 6.46255463e-02f, -8.13815817e-02f, -5.14372177e-02f, -1.60659626e-02f, -5.91911227e-02f,
  -7.64672682e-02f, -4.84992377e-02f, -4.91910055e-02f, 8.73172749e-03f, 1.26734618e-02f, -4.08228748e-02f, -1.11398257e-01f, 9.61382873e-03f, -8.96877199e-02f, 9.73718390e-02f,
  7.42902517e-01f, 3.59874964e-01f, 1.68895021e-01f, 4.94939685e-01f, 8.30904394e-02f, 1.78870857e-02f, 4.37635630e-01f, -6.90692570e-03f, 6.23481214e-01f, -5.40495478e-02f,
  -2.56360561e-01f, 2.90763676e-01f, -2.65994608e-01f, 2.46939227e-01f, -3.29848051e-01f, -1.83030352e-01f, 3.40199172e-01f, 1.97819069e-01f, 9.08919945e-02f, 2.83940554e-01f,
  2.00452790e-01f, -1.91875756e-01f, -1.22847624e-01f, -2.92219967e-01f, 1.64571196e-01f, 1.62735894e-01f, -3.58875036e-01f, -1.93660885e-01f, -1.44024417e-01f, -1.33832127e-01f,
  8.61728564e-02f, 2.53841221e-01f, 8.07718411e-02f, -3.73970456e-02f, 1.00296460e-01f, 9.03673321e-02f, -9.66149867e-02f, -1.17396668e-01f, -2.02010423e-02f, -2.74519790e-02f,
  3.97751741e-02f, -1.14756584e-01f, 6.66851029e-02f, -1.91771656e-01f, 2.01491833e-01f, 1.46118477e-01f, 5.97859398e-02f, 1.20270938e-01f, 7.28169754e-02f, -2.90733650e-02f,
  2.08487257e-01f, 1.60187539e-02f, 1.99855030e-01f, 1.77631266e-02f, 4.58299220e-02f, 8.06760415e-02f, 6.31350353e-02f, -2.42602285e-02f, -4.19220701e-02f, 1.56142965e-01f,
  -5.61393090e-02f, 4.87845717e-03f, 4.05569151e-02f, 6.46748304e-05f, 1.69482678e-02f, -3.90276089e-02f, 5.36705814e-02f, -8.45760256e-02f, 7.91993961e-02f, -4.68791984e-02f,
  -4.32490855e-02f, -2.15565059e-02f, 6.50003627e-02f, 5.63732833e-02f, 5.81239201e-02f, 1.12033293e-01f, -1.00492820e-01f, -1.12080395e-01f, 1.05757192e-01f, -7.96497986e-02f,
  -1.05720207e-01f, 1.19548693e-01f, -2.66466103e-02f, -7.83193931e-02f, -2.73070484e-02f, -2.80267242e-02f, -1.25385225e-01f, 5.28405681e-02f, -1.18158618e-03f, -1.33693680e-01f,
  -1.22414485e-01f, -1.12040490e-01f, 8.02922100e-02f, 6.29684031e-02f, 4.62774299e-02f, 7.53399953e-02f, 1.34661719e-01f, 9.93504599e-02f, 4.98065203e-02f, 2.39078328e-02f,
  6.13463037e-02f, 6.45485073e-02f, -5.91541640e-02f, -6.27352484e-03f, -4.05770466e-02f, -2.61113532e-02f, 6.21883422e-02f, -8.27444717e-02f, -2.35144552e-02f, -1.52398005e-01f,
  -1.12561388e-02f, 4.85728942e-02f, 1.09071150e-01f, 1.22413293e-01f, -7.01179430e-02f, -7.73269832e-02f, 1.04572594e-01f, 6.74313679e-02f, -1.80597275e-01f, -2.31368244e-02f,
  5.45800924e-02f, -2.24001676e-01f, -4.31436032e-01f, -3.75441998e-01f, 2.68758535e-01f, 4.53589648e-01f, -2.22623199e-01f, -6.42945915e-02f, -3.56642842e-01f, 1.42351270e-01f,
  2.16339439e-01f, -1.54005185e-01f, -2.14242116e-01f, -3.06067206e-02f, -9.73072499e-02f, -2.99458921e-01f, 5.86706400e-02f, 1.22228317e-01f, -1.89315781e-01f, 1.12753287e-01f,
  -6.44735172e-02f, 3.92136842e-01f, -1.78856015e-01f, 3.29310656e-01f, 1.87962145e-01f, 1.48569494e-01f, 3.19984317e-01f, 4.38607931e-02f, 2.70599335e-01f, 2.64940321e-01f,
  1.81296915e-02f, -6.93110004e-02f, -1.11459881e-01f, -6.62527885e-03f, 8.11754242e-02f, 1.50277615e-01f, 1.25834689e-01f, 1.09692197e-02f, -1.28293693e-01f, -1.63581371e-02f,
  3.60709243e-02f, -4.10957150e-02f, 3.51505429e-02f, 6.94308877e-02f, 9.28157941e-02f, 3.80043574e-02f, -1.52152941e-01f, -5.70468828e-02f, -5.51130921e-02f, 3.03955860e-02f,
  -1.66967198e-01f, -6.69575557e-02f, 2.33320240e-02f, -1.41641945e-01f, -9.59907770e-02f, 5.88166416e-02f, 9.12994891e-02f, 1.23596773e-01f, -2.05775164e-02f, 3.31086596e-03f,
  3.94392200e-02f, 1.85496524e-01f, 1.54469842e-02f, -1.70748103e-02f, 4.92916908e-03f, -3.09975911e-03f, -4.79197502e-02f, 2.72184052e-02f, -6.45703124e-03f, 7.32381130e-03f,
  -1.06950581e-01f, -2.18281802e-02f, -2.08145119e-02f, 1.87666416e-02f, 1.28980219e-01f, 7.32279047e-02f, 2.88456511e-02f, 1.09657675e-01f, -2.41402686e-02f, -7.78902993e-02f,
  -5.28998300e-02f, 1.55088520e-02f, 1.33112138e-02f, 1.62655674e-02f, 5.60894087e-02f, -4.30592336e-03f, 2.46024039e-02f, 1.38674542e-01f, -7.75570646e-02f, 2.44428143e-02f,
  -2.65130922e-02f, -3.06115001e-02f, -4.35609706e-02f, 1.86254065e-02f, -1.34207001e-02f, -3.89857148e-03f, -3.75391953e-02f, -5.55609949e-02f, 1.85123459e-02f, 6.59035146e-02f,
  1.42396897e-01f, 2.37434711e-02f, 8.69105756e-02f, 3.33216563e-02f, -2.70755831e-02f, 7.53150210e-02f, 3.45236771e-02f, 6.17026873e-02f, 5.86241968e-02f, 2.20694412e-02f,
  8.53784457e-02f, 3.38976905e-02f, 2.36749128e-02f, -6.42189607e-02f, -5.44183468e-03f, 2.78881080e-02f, 9.88115445e-02f, 7.03041106e-02f, -6.49807602e-02f, 1.41196861e-03f,
  -4.27285224e-01f, 4.21510488e-01f, 3.05982053e-01f, -2.99244702e-01f, 2.98485607e-01f, 2.60446131e-01f, -1.20777801e-01f, 2.84325898e-01f, -2.77113393e-02f, -1.06985517e-01f,
  -2.63669521e-01f, -1.30597618e-03f, -1.31774455e-01f, -2.43290305e-01f, -3.19567651e-01f, -2.40677446e-01f, -2.22485945e-01f, -3.65336627e-01f, 4.13212106e-02f, -1.29307479e-01f,
  -1.20856717e-01f, -2.37389490e-01f, 7.19153807e-02f, 1.97466627e-01f, 2.03487813e-01f, 1.32775664e-01f, -2.90689558e-01f, 1.64561361e-01f, 4.59734276e-02f, -5.27463146e-02f,
  5.23879044e-02f, -1.70266122e-01f, 5.06640971e-02f, 1.25446349e-01f, 7.58210644e-02f, 9.90242437e-02f, -2.01114446e-01f, -3.73114087e-03f, 4.82455716e-02f, 1.30255520e-01f,
  7.66845196e-02f, 7.30711371e-02f, -3.42588834e-02f, 1.23753503e-01f, 1.13968328e-01f, 1.20119750e-01f, 1.67207927e-01f, 1.34320214e-01f, 7.39221200e-02f, 1.05601467e-01f,
  6.53807372e-02f, 7.89981931e-02f, 1.00532658e-01f, 4.60831635e-02f, -1.79464594e-02f, 7.22159371e-02f, 3.80295329e-02f, -6.78517818e-02f, 1.27669042e-02f, 1.03175364e-01f,
  -1.35376498e-01f, -1.37076220e-02f, 6.05397746e-02f, -4.83552143e-02f, -7.32240528e-02f, 1.27853053e-02f, 7.09670484e-02f, -2.41189804e-02f, 4.55078892e-02f, 8.49869996e-02f,
  -1.36382645e-02f, 3.71838026e-02f, -7.04396293e-02f, 5.02823219e-02f, -1.25631019e-01f, -4.90091294e-02f, 1.06492057e-01f, -1.40491023e-03f, -1.48760289e-01f, -6.76171780e-02f,
  -2.12982908e-01f, -1.07918553e-01f, 6.38951808e-02f, 1.43671662e-01f, 7.98694137e-03f, 1.44525737e-01f, -9.34553891e-02f, 1.25848487e-01f, 6.02884497e-03f, -1.44107252e-01f,
  -1.49104163e-01f, -3.40461671e-01f, 5.03070690e-02f, -5.06689809e-02f, -3.66635062e-02f, 3.30620445e-02f, 7.43786544e-02f, 4.51637320e-02f, 4.72372072e-03f, -3.64548080e-02f,
  1.59056559e-01f, -5.15078604e-02f, 4.50359378e-03f, 8.21848586e-03f, -1.04000323e-01f, 7.78247416e-02f, -1.71748504e-01f, -1.65748134e-01f, -1.20913580e-01f, -8.33424479e-02f,
  -6.05660789e-02f, -2.94615310e-02f, 3.67294699e-02f, 8.53041261e-02f, -8.93207267e-02f, -1.18921503e-01f, -2.97736302e-02f, -1.06204063e-01f, -9.64501202e-02f, 4.19442765e-02f,
  -3.50999951e-01f, -3.42866816e-02f, 3.92848074e-01f, -3.84780206e-02f, -1.94998294e-01f, -1.46430477e-01f, 1.50104135e-01f, -1.86632156e-01f, -2.12311760e-01f, -3.20220113e-01f,
  -9.93859209e-03f, 4.65433076e-02f, 2.14008957e-01f, -7.03448951e-02f, 4.53866273e-01f, 2.58869529e-02f, 1.26485527e-01f, 6.21512420e-02f, 1.49064422e-01f, 6.73988760e-02f,
  1.99813381e-01f, -5.94038665e-02f, 3.16101372e-01f, 1.10830337e-01f, -4.86597195e-02f, 8.02696943e-02f, 2.28459507e-01f, 3.54671329e-01f, 2.71547824e-01f, 1.14048466e-01f,
  -1.27138525e-01f, 1.91637792e-03f, -4.50083390e-02f, 1.64586037e-01f, -2.05444805e-02f, -6.14068061e-02f, 1.86023459e-01f, 1.68407530e-01f, 3.58982161e-02f, 9.33575928e-02f,
  -8.46415907e-02f, 3.24584506e-02f, -8.25422555e-02f, 7.42871314e-02f, -1.44880340e-01f, -6.20202757e-02f, 7.39177018e-02f, -2.94186939e-02f, 2.14717425e-02f, -1.34607598e-01f,
  3.37039381e-02f, -1.31269738e-01f, 1.38458777e-02f, 1.31580561e-01f, 1.09282754e-01f, 4.24877927e-02f, -6.03869446e-02f, 1.89329728e-01f, -4.27045301e-02f, -1.49993021e-02f,
  -3.28126363e-02f, 7.97094926e-02f, -1.01772211e-01f, -4.42076214e-02f, -4.63805012e-02f, -4.16139141e-02f, -5.58340363e-03f, -7.12618530e-02f, -1.58190042e-01f, -2.75233872e-02f,
  -1.67228691e-02f, 1.64017491e-02f, 9.20473319e-03f, -8.06655828e-03f, -1.86657786e-01f, -2.00327024e-01f, 4.18279916e-02f, -7.30371103e-03f, 3.21837440e-02f, -3.12185269e-02f,
  -1.31972075e-01f, 1.03737600e-01f, -7.22792521e-02f, -6.47738483e-03f, -6.01096526e-02f, -2.72199344e-02f, 6.09091334e-02f, 3.37372310e-02f, -2.89749168e-02f, 3.35278749e-01f,
  1.26554653e-01f, 2.42057800e-01f, 3.64484601e-02f, 1.35056391e-01f, 2.37456337e-02f, 6.98734820e-02f, 1.93183720e-02f, -2.44512968e-03f, 1.00091457e-01f, 8.99755731e-02f,
  -2.68143304e-02f, 1.14810921e-01f, -2.28834823e-02f, 4.19235788e-02f, -2.65110638e-02f, -1.29076848e-02f, 2.83833072e-02f, 1.13115072e-01f, 1.06480168e-02f, 1.66155342e-02f,
  1.79727562e-02f, -4.43058312e-02f, 2.82716267e-02f, -9.85823572e-02f, -6.17436580e-02f, -3.14065367e-02f, -2.05212399e-01f, 2.16417201e-02f, 2.15591088e-01f, 1.26734972e-01f,
  3.90711397e-01f, -4.68128435e-02f, 3.84400129e-01f, 2.96795458e-01f, 1.51962608e-01f, 1.32323533e-01f, -1.81473151e-01f, 2.16191649e-01f, 3.21984410e-01f, -2.42450610e-01f,
  -1.67473853e-01f, 7.26011815e-03f, -3.63274813e-01f, 1.25391498e-01f, -1.21384308e-01f, -2.61849642e-01f, 1.82445589e-02f, -1.02190457e-01f, 2.71285996e-02f, -7.86154494e-02f,
  2.78356243e-02f, -2.90458292e-01f, -1.06791891e-02f, -1.72953039e-01f, 1.97600171e-01f, 6.88315183e-02f, -2.27719724e-01f, -1.58846065e-01f, 9.86589193e-02f, -2.20538173e-02f,
  5.84837571e-02f, 7.88285434e-02f, 3.74468528e-02f, 6.90624788e-02f, 1.77280046e-02f, -8.39767791e-03f, -2.79848762e-02f, -6.41364232e-02f, 1.20458849e-01f, -3.23705375e-02f,
  -1.65845174e-02f, 8.00294131e-02f, 1.60592124e-01f, -9.66536105e-02f, 1.58869967e-01f, 1.58380821e-01f, 1.76290691e-01f, 2.98140664e-02f, 7.97768682e-02f, 1.22368068e-01f,
  1.61594171e-02f, 6.55412003e-02f, 1.99859753e-01f, 2.85652485e-02f, 5.43077476e-02f, 1.22753210e-01f, 3.28429579e-03f, 2.16981955e-02f, 3.16097513e-02f, 1.67373478e-01f,
  9.57122445e-03f, -2.85627004e-02f, -1.47125185e-01f, -3.56103256e-02f, -1.04537278e-01f, 6.73832297e-02f, -6.13715388e-02f, -8.14411119e-02f, -3.83943110e-03f, -4.61545512e-02f,
  7.66143873e-02f, -1.64271463e-02f, -2.38678791e-02f, -5.08320751e-04f, -8.42282921e-02f, 1.88883692e-01f, -7.93757811e-02f, -1.23651046e-02f, -1.46912737e-02f, 7.17006102e-02f,
  -3.18069570e-02f, 1.70044843e-02f, -1.13709986e-01f, 8.18607062e-02f, 2.83561982e-02f, -5.55993952e-02f, 1.03117712e-01f, 1.39843971e-01f, 1.44767649e-02f, -1.79325357e-01f,
  -4.21118945e-01f, -3.77847701e-01f, -4.38955873e-02f, -3.84987742e-02f, -4.80836295e-02f, 1.95350405e-02f, 8.54851156e-02f, 1.74137503e-02f, -1.50110334e-01f, 3.84322107e-02f,
  1.16398828e-02f, -4.19117510e-02f, -4.44255508e-02f, -1.43353492e-02f, -2.17291832e-01f, -3.81784178e-02f, -1.12673625e-01f, -8.80988128e-03f, -2.01959815e-02f, -1.10222027e-02f,
  -8.43168050e-02f, -1.34723619e-01f, 9.69456732e-02f, -3.52167641e-03f, -5.75998873e-02f, -4.57258523e-02f, -5.30293509e-02f, -4.97977361e-02f, -3.42518277e-02f, 2.88738795e-02f,
  4.06407118e-01f, -4.90151823e-01f, -1.56651482e-01f, 1.68247342e-01f, 4.02757108e-01f, 3.33267838e-01f, 2.74049848e-01f, -5.00894710e-02f, 6.16004020e-02f, -2.85238087e-01f,
  2.19193045e-02f, 6.28122389e-02f, -3.41443747e-01f, 2.17240855e-01f, 4.00316119e-01f, -2.22470105e-01f, 3.19326162e-01f, 2.52595216e-01f, -9.32926834e-02f, -1.14780374e-01f,
  1.70610845e-01f, 2.78317779e-01f, -1.64632238e-02f, -1.36133239e-01f, 2.14560807e-01f, -2.47147843e-01f, -9.54114199e-02f, -1.28896594e-01f, 8.56269300e-02f, 1.71632230e-01f,
  8.32854509e-02f, 1.16713103e-02f, 1.25246033e-01f, 9.41941689e-04f, -1.08799012e-02f, 6.05984367e-02f, 8.26080367e-02f, 1.13586515e-01f, 9.65301469e-02f, -1.05832987e-01f,
  -1.22371204e-02f, 2.51665059e-02f, -9.87248216e-03f, -4.14951630e-02f, 9.40642059e-02f, 9.25704911e-02f, -8.65215808e-02f, -8.28952342e-02f, -1.19573012e-01f, 4.00560722e-03f,
  -7.61798471e-02f, -1.22224733e-01f, -3.55267674e-02f, -7.92832673e-02f, 2.11947709e-02f, -2.59950310e-02f, -1.24749467e-02f, -2.05656495e-02f, -9.73211543e-04f, 9.58837420e-02f,
  -2.36342587e-02f, 1.00864366e-01f, -1.59365460e-02f, -1.04870908e-01f, 6.97261319e-02f, 5.23809865e-02f, -1.09618586e-02f, 1.68369394e-02f, -7.96097703e-03f, 5.95951937e-02f,
  9.65894759e-02f, 6.97554126e-02f, 7.16980696e-02f, 7.12284446e-03f, 5.33613898e-02f, -3.49563286e-02f, 1.12174764e-01f, -5.63120954e-02f, 3.28442268e-02f, 6.49550231e-03f,
  -3.42778191e-02f, -3.60138789e-02f, -3.50735784e-02f, -1.81259289e-01f, 4.91634905e-02f, 1.00513123e-01f, -2.30070110e-02f, -3.11823394e-02f, -1.11186177e-01f, 8.74984935e-02f,
  2.06857082e-02f, -3.12126100e-01f, -1.30810142e-01f, -4.83830459e-02f, -3.05266064e-02f, -6.13144375e-02f, 9.72246751e-02f, -1.88463833e-02f, -1.17137432e-02f, 2.56062504e-02f,
  -5.15649579e-02f, -5.81962019e-02f, -2.00482756e-02f, 3.25908177e-02f, 8.95772725e-02f, -1.52322844e-01f, -2.32238658e-02f, 1.89832952e-02f, 6.96667060e-02f, -6.49811700e-02f,
  8.56251456e-03f, -1.70304537e-01f, -1.38530433e-02f, 3.36632840e-02f, 2.37869546e-02f, 6.73445594e-03f, -1.41142905e-01f, -2.09119767e-02f, -1.00351550e-01f, -2.69560795e-02f,
  1.09371739e-02f, -1.63977876e-01f, -2.68104840e-02f, -5.62326685e-02f, -1.31617475e-03f, -3.63558307e-02f, -2.83963472e-01f, 1.43992290e-01f, -2.38028690e-01f, 1.16949759e-01f,
  9.53818187e-02f, -3.20384234e-01f, -2.22172633e-01f, -2.03486636e-01f, -1.84652954e-02f, -3.68302882e-01f, 9.10536274e-02f, 6.39808597e-03f, -5.60926050e-02f, 1.98623791e-01f,
  1.12752587e-01f, 1.12673886e-01f, 1.31180584e-01f, 3.16748321e-01f, 1.83168083e-01f, 3.21315467e-01f, 3.68619829e-01f, 1.23485945e-01f, 2.58314610e-01f, -1.12753779e-01f,
  -8.36829543e-02f, -3.25629711e-02f, 3.90028805e-02f, -8.40577483e-02f, 1.96027189e-01f, 7.36617967e-02f, 1.15339138e-01f, -2.31553055e-03f, -1.85622871e-02f, -1.13171339e-01f,
  1.15594305e-01f, 4.09202389e-02f, -7.86597952e-02f, -1.71999633e-01f, 4.07503843e-02f, -8.37610476e-03f, -1.03215627e-01f, -1.23718344e-02f, -2.41500139e-01f, -3.88374478e-02f,
  -8.42905268e-02f, 5.62252179e-02f, -1.02954898e-02f, 3.34253013e-02f, -1.75116193e-02f, -8.15628767e-02f, -8.57960805e-02f, 1.93097472e-01f, -1.36855975e-01f, 3.57550383e-02f,
  1.37433454e-01f, 3.10299937e-02f, -4.38391976e-02f, -8.14374164e-02f, -9.54748690e-02f, -8.17895681e-03f, -1.05320849e-01f, 2.31604418e-03f, -7.57296607e-02f, -3.19906734e-02f,
  -7.07310718e-03f, 1.67635437e-02f, -1.41414866e-01f, 3.90919000e-02f, 1.24410868e-01f, -8.33462700e-02f, -5.18957637e-02f, -1.02833204e-01f, 1.23036057e-02f, -1.25694916e-01f,
  -2.10367352e-01f, 3.19259148e-03f, -2.88075861e-02f, -8.27034861e-02f, -1.50868699e-01f, -3.93503010e-02f, 1.44796669e-01f, 7.81227835e-03f, 3.03910077e-02f, 2.50271335e-02f,
  8.02873373e-02f, 1.41588062e-01f, -7.67246634e-02f, -8.03286582e-03f, -1.30421221e-02f, 3.85086909e-02f, -1.39005587e-01f, 2.09802724e-02f, 1.37530103e-01f, 5.32986112e-02f,
  1.75273851e-01f, 4.36894074e-02f, 8.83842409e-02f, 3.60985845e-02f, -3.00415754e-02f, 2.36047745e-01f, 1.47246718e-01f, -1.88380480e-02f, -4.68891375e-02f, 2.17766613e-01f,
  1.63627699e-01f, -2.73042154e-02f, 5.39268926e-02f, -2.41975281e-02f, 1.33724317e-01f, 7.33257160e-02f, -8.83215014e-03f, 6.16404861e-02f, -2.24281885e-02f, -8.19852017e-03f,
  -4.18297559e-01f, 1.20682314e-01f, -1.26018435e-01f, -3.46131086e-01f, -2.11869702e-01f, -2.28548780e-01f, -2.00350434e-01f, -1.27601415e-01f, 4.15390171e-02f, 3.32974494e-01f,
  3.65478434e-02f, -2.03057647e-01f, 2.78808236e-01f, -1.15367256e-01f, -2.09623292e-01f, 4.80179369e-01f, -3.42198648e-02f, -6.52664229e-02f, 1.29025683e-01f, -3.46033543e-01f,
  -2.15846598e-01f, -1.77883118e-01f, -4.32537822e-03f, 3.22933346e-02f, -2.63206363e-01f, -3.03324789e-01f, -1.91974957e-02f, -1.93364561e-01f, -2.00202078e-01f, -6.13276437e-02f,
  -4.60442342e-02f, -5.65259121e-02f, -8.92890692e-02f, -2.29238160e-02f, -7.38746375e-02f, 4.59953435e-02f, -5.62445596e-02f, -9.48184729e-02f, -9.83429253e-02f, -2.27431469e-02f,
  2.05639079e-02f, -4.83690053e-02f, 1.05700359e-01f, 1.49831370e-01f, -5.75811230e-02f, -8.28415081e-02f, 1.76767930e-02f, -3.50141563e-02f, -1.62482172e-01f, 6.43266598e-03f,
  -1.40724033e-01f, -6.97997492e-03f, 1.52926827e-02f, 1.12679660e-01f, -1.24460772e-01f, 2.86124889e-02f, 8.46230388e-02f, -6.44763783e-02f, -5.02042845e-02f, -9.20524672e-02f,
  -1.65972002e-02f, -3.77801768e-02f, -2.40779277e-02f, 4.95353602e-02f, -4.01328914e-02f, 1.70747973e-02f, 8.06240290e-02f, 8.12303126e-02f, 1.14396568e-02f, -5.53325703e-03f,
  9.73534491e-03f, 5.49414521e-03f, 7.58347148e-03f, 4.09393795e-02f, -1.13599992e-03f, 8.98504257e-02f, -1.18970787e-02f, -5.89149855e-02f, 9.04727653e-02f, -1.92885827e-02f,
  -4.57036793e-02f, 3.11161000e-02f, 6.97834641e-02f, 8.66383612e-02f, -4.09961678e-02f, 7.89478049e-03f, 8.64788517e-02f, -1.52626559e-02f, -5.36537692e-02f, -5.32187372e-02f,
  -2.31374145e-01f, -1.82461113e-01f, -1.73665397e-02f, -1.18314020e-01f, -4.47610319e-02f, -4.06779684e-02f, 7.51483440e-02f, -2.87879277e-02f, -1.64719641e-01f, 2.49566436e-02f,
  6.26940876e-02f, 4.49163094e-02f, -6.71430770e-03f, -4.14158329e-02f, 1.12093844e-01f, -1.32709825e-02f, -3.86590846e-02f, 1.47957355e-01f, -1.05860300e-01f, -1.40420934e-02f,
  -5.54417334e-02f, 3.22506614e-02f, -6.68401346e-02f, 3.26930098e-02f, 5.44905923e-02f, -1.33529127e-01f, -3.84219065e-02f, -3.32417786e-02f, -5.75177111e-02f, 7.58264363e-02f,
  1.84993044e-01f, 6.90915585e-02f, -7.70988315e-02f, -7.71462768e-02f, 2.48229787e-01f, 5.24780810e-01f, 9.76098105e-02f, 1.77263528e-01f, -4.85709086e-02f, -1.02802441e-01f,
  2.86557786e-02f, -1.67826727e-01f, -3.15574795e-01f, 1.22722462e-01f, 3.38934779e-01f, -5.93969896e-02f, 1.51738316e-01f, 1.15311578e-01f, 5.81016839e-02f, 2.70700711e-03f,
  -4.47721267e-03f, 2.68388331e-01f, -2.01454014e-01f, 2.52393275e-01f, -4.22057183e-03f, -2.22508699e-01f, -1.81439638e-01f, -1.76256686e-01f, 2.63753179e-02f, 2.71769971e-01f,
  1.02697343e-01f, -5.73164634e-02f, -8.50338340e-02f, -7.50200227e-02f, 1.36405706e-01f, -1.85031667e-02f, -1.32235764e-02f, 1.03001878e-01f, 2.37848107e-02f, 3.32992617e-03f,
  -8.11331943e-02f, -5.18273078e-02f, 1.25477184e-02f, -4.29668687e-02f, 6.77087083e-02f, -5.51020578e-02f, 1.20084453e-02f, -1.88067108e-01f, -1.37779310e-01f, 1.95667177e-01f,
  -7.01833069e-02f, -6.42327741e-02f, -1.57715097e-01f, -5.85251302e-02f, 4.21722084e-02f, -7.76823908e-02f, -1.67029262e-01f, -1.38255671e-01f, -1.59406103e-02f, 5.00562936e-02f,
  9.85668153e-02f, 1.32626340e-01f, 1.05658889e-01f, -2.43251026e-02f, 2.12536797e-01f, 1.20552313e-02f, 2.67016422e-02f, -7.69736990e-02f, 4.03108336e-02f, 1.01717953e-02f,
  -7.99150243e-02f, -1.14382222e-01f, 7.01329708e-02f, 1.05743773e-01f, -3.57097685e-02f, 9.12670195e-02f, -7.29343444e-02f, 5.55381849e-02f, -3.07235681e-02f, -7.38690123e-02f,
  4.62843999e-02f, 8.55119526e-02f, -6.69497997e-02f, -1.56933770e-01f, 1.11603588e-01f, -7.39508588e-03f, 1.71161413e-01f, -2.45886501e-02f, -1.15043491e-01f, -7.40500391e-02f,
  3.84715833e-02f, 3.78777012e-02f, -1.87325269e-01f, 4.87718619e-02f, -7.43151307e-02f, 1.08731113e-01f, -7.02892393e-02f, 2.19153270e-01f, 3.55292782e-02f, -1.08559988e-03f,
  6.94542453e-02f, -3.39226164e-02f, 5.53080589e-02f, -5.16883805e-02f, 2.63711400e-02f, 9.69000906e-02f, -1.38443382e-02f, -2.35881247e-02f, -3.73579189e-02f, 2.39461977e-02f,
  -1.36206523e-01f, -1.05617300e-01f, -1.11582719e-01f, 1.37000039e-01f, 1.63030908e-01f, -1.55548975e-01f, 6.66257665e-02f, -1.39537916e-01f, 7.48422369e-02f, -9.69300047e-02f,
  4.20250706e-02f, 1.21785775e-01f, -1.90712988e-01f, 1.19461149e-01f, -4.07340050e-01f, 2.33167440e-01f, 5.44733822e-01f, -1.08608946e-01f, -3.78489904e-02f, 3.39295119e-01f,
  2.01882407e-01f, 1.11703195e-01f, 2.67261803e-01f, 1.88061073e-01f, -1.09155066e-01f, 2.99964547e-01f, 2.21782044e-01f, 2.68113017e-01f, -9.08651203e-02f, 2.04441160e-01f,
  -1.28042370e-01f, 2.57611752e-01f, -2.55313609e-02f, -1.25295013e-01f, 1.33028448e-01f, -2.54903048e-01f, -2.04712197e-01f, -4.75527197e-02f, -1.58441052e-01f, 6.36060676e-03f,
  9.98229012e-02f, -4.11129072e-02f, 1.41525334e-02f, -1.32756457e-02f, -3.69819216e-02f, 7.32832924e-02f, 6.79077394e-03f, 2.35874671e-02f, -8.98812152e-03f, 5.08562848e-03f,
  1.93895951e-01f, -3.06736515e-03f, -3.76623427e-03f, -2.51427274e-02f, -2.63199080e-02f, -1.54604316e-01f, -6.25631362e-02f, 7.68007115e-02f, 6.49837404e-02f, -6.00812137e-02f,
  4.83113602e-02f, 6.84813932e-02f, -9.25519764e-02f, 6.47244975e-02f, -1.05517916e-01f, 6.41831160e-02f, 1.59038618e-01f, -9.26373675e-02f, -4.16107960e-02f, 1.40299350e-02f,
  -1.62189994e-02f, 3.40006277e-02f, 3.19006406e-02f, -7.92809054e-02f, -1.00790471e-01f, 7.18443394e-02f, 9.20238495e-02f, -9.02376696e-02f, -1.42283812e-02f, -3.63538712e-02f,
  -5.07411920e-02f, 3.60538736e-02f, 1.64069682e-02f, 5.05218171e-02f, -3.38246413e-02f, 1.50299266e-01f, 1.10267662e-01f, 9.07088518e-02f, -4.60691974e-02f, -9.76378843e-02f,
  -2.36201417e-02f, 5.52059673e-02f, 3.32153961e-02f, 6.24233903e-03f, 1.04382195e-01f, -1.50936963e-02f, -3.17433150e-03f, -2.16445816e-03f, 9.27566215e-02f, -4.44924310e-02f,
  -2.51822174e-02f, -4.77027632e-02f, 8.63665789e-02f, 7.80932158e-02f, 1.88204926e-02f, -5.76597266e-02f, -4.64160033e-02f, 3.62734385e-02f, 5.34246815e-03f, 7.14462027e-02f,
  -1.20065503e-01f, 6.70261309e-02f, -1.40069664e-01f, -3.30507010e-02f, -3.88708264e-02f, -3.86495925e-02f, 9.50700566e-02f, -1.86940134e-02f, 6.72578346e-03f, -1.81134909e-01f,
  -5.09459875e-04f, 1.64094493e-01f, 1.24246463e-01f, 1.01669468e-01f, 4.27876413e-02f, 1.00481972e-01f, 5.98409288e-02f, -8.87276083e-02f, -8.45187251e-03f, 2.70117614e-02f,
  -5.42156845e-02f, -4.68181193e-01f, 1.89194888e-01f, -1.53977409e-01f, 1.14304587e-01f, -3.35099064e-02f, 1.06611192e-01f, -1.77399531e-01f, -1.30190730e-01f, -3.40326220e-01f,
  -1.07372031e-01f, 3.33816521e-02f, 1.63312465e-01f, -1.09239154e-01f, 5.07019520e-01f, 2.57997245e-01f, -8.50382354e-03f, -1.07261799e-01f, 1.03454597e-01f, -8.71558487e-02f,
  1.38803959e-01f, -1.68394342e-01f, 2.79193997e-01f, -2.46121585e-01f, -7.87445009e-02f, -1.96494177e-01f, 9.72391143e-02f, 1.61030486e-01f, -1.12834997e-01f, 1.43191651e-01f,
  -1.39754161e-01f, -1.95631996e-01f, 9.53401402e-02f, -7.52967522e-02f, -1.86977178e-01f, 2.81627122e-02f, -2.17440762e-02f, 9.63901281e-02f, 3.15335430e-02f, 4.02506813e-02f,
  8.19602329e-03f, 6.41539507e-03f, -5.01211919e-02f, 3.75634283e-02f, -1.65239740e-02f, -4.46066633e-02f, -3.13392887e-03f, -6.51064962e-02f, 8.36704765e-03f, 1.99006796e-02f,
  1.28381988e-02f, -1.71471331e-02f, 5.89869358e-02f, -7.60314912e-02f, 1.51840657e-01f, -1.95601286e-04f, -1.38277523e-02f, 2.32938747e-03f, -2.92397477e-02f, -2.01199073e-02f,
  7.43138343e-02f, 1.36234671e-01f, 8.39978270e-03f, 2.94781313e-03f, 9.56384372e-03f, 6.12649973e-03f, 4.25046124e-02f, -2.18968168e-02f, -4.03225869e-02f, -3.83312553e-02f,
  -4.78920937e-02f, -2.40246188e-02f, 7.29200691e-02f, -4.29734513e-02f, -5.06549366e-02f, -2.67302692e-02f, 4.22602482e-02f, -3.74605618e-02f, 4.06254828e-02f, -8.75737742e-02f,
  -4.43482324e-02f, 8.98848400e-02f, 1.95305217e-02f, 5.46418466e-02f, -1.00535080e-01f, 5.97710013e-02f, -1.21600583e-01f, -1.04283229e-01f, -3.17156650e-02f, 1.53755471e-01f,
  -2.62190700e-01f, -3.60856116e-01f, -1.47301659e-01f, -4.61186208e-02f, -9.34928283e-02f, -1.16105624e-01f, -3.90857644e-02f, -9.03258398e-02f, -8.34622607e-02f, 3.18522169e-03f,
  -2.91670337e-02f, 6.99717104e-02f, -3.19707319e-02f, -7.02357292e-02f, -6.12958781e-02f, -8.83938372e-02f, -4.80438955e-02f, 8.50255340e-02f, 5.48509397e-02f, -6.76950961e-02f,
  -1.37172326e-01f, -8.44276883e-03f, 1.20635040e-01f, -3.39261070e-02f, -7.60187954e-02f, 3.32118683e-02f, -4.52653803e-02f, 5.02312072e-02f, 6.63143322e-02f, -3.88369486e-02f,
  5.46761788e-02f, 1.64296329e-01f, -9.19214934e-02f, -1.16583586e-01f, -1.45810857e-01f, -4.52566326e-01f, -3.23036730e-01f, 7.18573853e-02f, 4.27933671e-02f, 7.61348102e-03f,
  2.60437327e-03f, 2.14325249e-01f, 2.08641484e-01f, -2.90376097e-01f, -3.89148712e-01f, 2.16215737e-02f, -3.88436228e-01f, -1.70888320e-01f, -5.64346984e-02f, -1.85523063e-01f,
  -5.36610670e-02f, -9.54167172e-02f, 1.57683669e-03f, 7.88446143e-02f, -1.28540963e-01f, 1.02778658e-01f, 2.10168853e-01f, 1.37629390e-01f, -2.41007581e-01f, -9.46310908e-02f,
  -1.23750530e-01f, 1.88449442e-01f, 7.41981110e-03f, -1.07873760e-01f, -1.11932538e-01f, -1.39181271e-01f, -1.63735345e-01f, -6.72907606e-02f, 5.31773716e-02f, -7.36166015e-02f,
  3.65040563e-02f, 1.63839519e-01f, 1.19668348e-02f, 3.71392220e-02f, 1.20164841e-01f, -1.08253453e-02f, 1.33601716e-02f, -7.68018961e-02f, -3.67631167e-02f, -2.62202672e-03f,
  3.55791785e-02f, -5.65285571e-02f, -9.70724523e-02f, 1.27667144e-01f, 3.54274102e-02f, 3.13798664e-03f, -2.06089728e-02f, -1.76331718e-02f, 2.67709363e-02f, 9.63765308e-02f,
  9.85675007e-02f, 3.42832936e-04f, -2.38808487e-02f, -1.77310524e-03f, -4.00329866e-02f, 3.36928852e-02f, 5.43662868e-02f, 4.77493182e-02f, 1.16622195e-01f, -3.13892588e-02f,
  -6.74977005e-02f, -2.39428710e-02f, 1.54093793e-02f, -1.24817818e-01f, 5.45000210e-02f, -4.41665649e-02f, 4.78138123e-03f, 1.93074327e-02f, -1.13001414e-01f, -4.51417156e-02f,
  1.62515953e-01f, -9.10587460e-02f, -4.03786674e-02f, -2.27703564e-02f, -2.16531642e-02f, 2.78299954e-03f, 8.05990919e-02f, 2.53979620e-02f, 3.13487686e-02f, -1.22029491e-01f,
  4.33735065e-02f, 1.59468025e-01f, -2.06308886e-02f, 7.21952990e-02f, -3.96028049e-02f, -7.97413513e-02f, 8.78644064e-02f, -1.19751923e-01f, 6.87327832e-02f, -8.77491608e-02f,
  -6.86665922e-02f, -2.00473033e-02f, 2.97340229e-02f, 1.04039186e-03f, -1.58410370e-02f, -4.83434759e-02f, -2.91046202e-02f, 1.01566777e-01f, -8.61766785e-02f, 1.78167149e-02f,
  1.20569259e-01f, -9.07722581e-03f, -3.66857275e-02f, -1.22398488e-01f, 8.85233581e-02f, 6.92135617e-02f, 5.04751801e-02f, 1.07967719e-01f, 8.46511871e-02f, 8.45761523e-02f,
  -1.97486654e-01f, -1.66681349e-01f, -1.06659740e-01f, -1.24196611e-01f, 5.01687899e-02f, 1.92642406e-01f, -2.93130398e-01f, -6.89141080e-02f, -2.59308696e-01f, -2.92593449e-01f,
  -9.84793678e-02f, -1.55233055e-01f, -2.17719600e-01f, 1.21109709e-01f, 3.93529654e-01f, -2.03844249e-01f, 3.05697680e-01f, 9.59072728e-03f, 1.08271949e-01f, 8.50828290e-02f,
  2.22836778e-01f, 2.85037398e-01f, 2.85891116e-01f, 4.66794014e-01f, 1.32759497e-01f, 2.26160228e-01f, 1.67625457e-01f, 3.02282631e-01f, 3.78197849e-01f, 2.38600016e-01f,
  7.80837983e-03f, -1.30570605e-01f, 7.16581196e-02f, 1.51072890e-01f, 1.31474063e-01f, -9.22903270e-02f, 6.08302169e-02f, -4.68131602e-02f, -3.06672845e-02f, 7.60226920e-02f,
  5.70487343e-02f, 1.59277722e-01f, 4.02866118e-02f, 6.95808325e-03f, 1.36121521e-02f, 3.28477696e-02f, 1.44802839e-01f, -1.10451527e-01f, 1.05179347e-01f, -5.61010726e-02f,
  -6.00707084e-02f, -9.60764065e-02f, 8.97200331e-02f, 1.46252483e-01f, 4.90417005e-03f, 1.26059115e-01f, 3.69048044e-02f, -3.17337140e-02f, -8.44176635e-02f, 1.83268279e-01f,
  8.52872506e-02f, -2.44642958e-01f, -9.90181416e-03f, -7.59322196e-02f, 7.60116205e-02f, -2.75765005e-02f, 7.51953349e-02f, 4.11710218e-02f, 3.78740653e-02f, 3.03322319e-02f,
  -3.15112881e-02f, 3.68320160e-02f, -1.29042193e-01f, -8.22772682e-02f, 6.40423447e-02f, -1.94659173e-01f, -1.77983996e-02f, 2.79604960e-02f, -4.28211838e-02f, -5.58625720e-03f,
  -1.40269682e-01f, 1.58899408e-02f, 6.18325546e-03f, -7.28496015e-02f, -2.72422954e-02f, -8.21076557e-02f, -1.10873096e-01f, -1.03499994e-01f, 1.33227795e-01f, 1.14312008e-01f,
  -1.17760204e-01f, 7.55238235e-02f, 1.10525265e-01f, 4.13638838e-02f, 2.09927931e-02f, 1.38299149e-02f, -5.23026772e-02f, -8.08837414e-02f, -7.84465522e-02f, 6.54015541e-02f,
  4.50416170e-02f, 9.71019566e-02f, -1.57339483e-01f, 4.78074811e-02f, -2.99322903e-02f, -3.47312056e-02f, -2.05566082e-02f, -1.16154097e-01f, 5.46491034e-02f, -9.42412764e-03f,
  -1.49496958e-01f, 4.34428006e-02f, 3.38275284e-02f, 2.34145582e-01f, 4.81253583e-03f, -1.26301516e-02f, 4.79802899e-02f, -3.09603699e-02f, 2.12495178e-01f, 1.12093128e-01f,
  -5.96272171e-01f, 3.25244844e-01f, -2.00257346e-01f, -8.16765521e-03f, -1.69831946e-01f, 3.19728181e-02f, 2.11384371e-01f, 1.71581745e-01f, 2.05640793e-01f, 2.05376953e-01f,
  -4.23130356e-02f, 3.48939635e-02f, 3.77138823e-01f, 8.43785256e-02f, -2.51732618e-01f, 1.38425559e-01f, 4.45321575e-02f, -8.47630948e-03f, 3.55247051e-01f, -1.43283725e-01f,
  7.83560425e-03f, 1.19337980e-02f, -3.06157768e-01f, 7.70500749e-02f, -2.88282722e-01f, -1.37657940e-03f, -2.02280775e-01f, -7.85137713e-03f, -2.73556083e-01f, -1.26575321e-01f,
  -4.18549985e-01f, -2.67838836e-02f, -2.76572257e-01f, -3.02258246e-02f, -2.06820086e-01f, 6.96659759e-02f, -7.22976103e-02f, -1.31980926e-02f, 1.09666958e-01f, 9.58977938e-02f,
  -1.04644120e-01f, 6.37015328e-02f, 9.98777226e-02f, 5.28112799e-02f, -2.02982239e-02f, -5.31242266e-02f, -7.10339705e-03f, -1.17872447e-01f, -1.19282275e-01f, -9.38564241e-02f,
  -1.29763987e-02f, -8.22583884e-02f, -1.64953619e-01f, 1.19564213e-01f, -1.53263118e-02f, -6.43357858e-02f, 1.18268207e-02f, -1.02446890e-02f, -1.79018840e-01f, -8.44661742e-02f,
  9.76005867e-02f, 1.90698758e-01f, -1.05453350e-01f, 9.38568935e-02f, 5.28423861e-02f, -9.90143046e-02f, -3.99973094e-02f, -9.75213666e-03f, 1.37622014e-01f, 2.34825723e-02f,
  4.52268682e-02f, -1.06341071e-01f, 2.77268030e-02f, -7.63966143e-02f, 9.66724604e-02f, -5.61827533e-02f, 2.52040550e-02f, 5.63328639e-02f, -2.20437702e-02f, -3.00926100e-02f,
  1.81337707e-02f, -1.95444122e-01f, 3.39536257e-02f, 3.51884067e-02f, 9.29151773e-02f, 5.23554981e-02f, 1.33169428e-01f, -6.32550940e-02f, -3.53934206e-02f, -8.17753822e-02f,
  -3.99433941e-01f, -7.31210858e-02f, -1.91153437e-02f, -1.63820910e-03f, 8.26102942e-02f, -2.63771210e-02f, 5.86477341e-03f, -9.93489753e-03f, -4.75490242e-02f, 1.25417769e-01f,
  -3.20162401e-02f, 3.52695920e-02f, -8.89982954e-02f, 1.59331094e-02f, 2.03474779e-02f, -1.65209934e-01f, -7.65350387e-02f, 1.07651383e-01f, -1.12448223e-01f, 1.24891244e-01f,
  -1.25901207e-01f, -1.82522945e-02f, -7.43417218e-02f, -6.86291307e-02f, -7.26581141e-02f, -1.09505147e-01f, -7.61371031e-02f, 5.40696792e-02f, -1.15993917e-01f, 7.03040287e-02f,
  -1.20019034e-01f, 1.34796470e-01f, 8.15290213e-02f, 5.55615947e-02f, 2.11792871e-01f, -1.99277923e-01f, 1.33454755e-01f, 2.40737766e-01f, 1.41116351e-01f, 1.30481765e-01f,
  -8.85261893e-02f, 3.35203633e-02f, 1.12811230e-01f, -2.70518035e-01f, -4.60649550e-01f, -3.50418389e-01f, -3.19571227e-01f, -1.65613934e-01f, 1.24145551e-02f, 2.90349033e-02f,
  -1.37203977e-01f, -1.85992971e-01f, -1.76380649e-01f, 2.31072128e-01f, 1.99019551e-01f, 2.80688196e-01f, 1.19248750e-02f, 2.39531279e-01f, -9.71486568e-02f, -9.71345752e-02f,
  -3.29312198e-02f, 1.46631077e-01f, 1.88654438e-01f, 1.00848518e-01f, 1.33740738e-01f, 1.05696641e-01f, 4.78669256e-02f, -2.49998048e-02f, 7.23904297e-02f, -7.51771545e-03f,
  2.46915072e-02f, 4.01967652e-02f, -1.12971336e-01f, 8.03731829e-02f, 1.82177424e-01f, 1.07593186e-01f, 4.63647535e-03f, 2.03087963e-02f, 1.42409042e-01f, 4.95140813e-03f,
  5.09312004e-02f, -7.22934231e-02f, -8.13385844e-02f, -3.62458751e-02f, -5.70031703e-02f, 1.31033063e-01f, -3.72607596e-02f, -3.14714983e-02f, 2.56405165e-03f, 8.31107050e-03f,
  -9.47815180e-03f, -9.71797854e-02f, -6.58354014e-02f, 8.05020779e-02f, -4.75998521e-02f, 7.11974278e-02f, 4.70339879e-02f, -1.83021259e-02f, -1.68880410e-02f, -2.50316653e-02f,
  -2.02400759e-02f, 2.89098509e-02f, -4.06646430e-02f, 8.89006034e-02f, -9.18219890e-03f, 8.11345577e-02f, 3.40636298e-02f, -4.04649414e-03f, -4.44917418e-02f, -2.12712726e-03f,
  4.49019223e-02f, 2.38482468e-02f, 2.46701017e-02f, 6.34098649e-02f, 2.45226757e-03f, 3.33936214e-02f, -8.40098113e-02f, -3.05670574e-02f, -3.59343700e-02f, -2.16149725e-02f,
  -5.58020957e-02f, -1.10888049e-01f, 1.06298150e-02f, -1.54674621e-02f, 5.11046425e-02f, -1.11667164e-01f, -1.21461324e-01f, 7.43902754e-03f, -7.39562735e-02f, -3.92909907e-02f,
  7.13243037e-02f, 4.76095304e-02f, -7.69356564e-02f, -1.18711345e-01f, -8.30597579e-02f, -1.11730406e-02f, 2.95578415e-04f, -7.13287890e-02f, -3.59158684e-03f, 1.52364944e-03f,
  1.01689689e-01f, 7.28139356e-02f, -4.03076336e-02f, 3.97629887e-02f, 9.82437283e-02f, 8.37119669e-02f, -7.76490048e-02f, -2.73006558e-02f, 2.52425540e-02f, -5.89646436e-02f,
  3.19968984e-02f, -1.72299072e-01f, 8.18870664e-02f, -1.60725951e-01f, -9.01930928e-02f, 1.83354110e-01f, 1.71261892e-01f, -1.85025394e-01f, -8.96662846e-02f, -1.00671858e-01f,
  -2.57712752e-01f, 4.32823747e-02f, 3.06287855e-01f, -2.94235945e-01f, 5.02984524e-01f, 3.39822710e-01f, -2.60570258e-01f, -1.47557050e-01f, -1.05848484e-01f, -2.51222491e-01f,
  1.25558423e-02f, -3.36674333e-01f, 9.86520573e-02f, -4.30354416e-01f, -3.38685185e-01f, -2.76023537e-01f, -5.13902493e-03f, 3.15774754e-02f, -2.76541770e-01f, -1.46477465e-02f,
  -1.44355536e-01f, -2.42519140e-01f, -1.55200422e-01f, -4.01664414e-02f, -1.57726899e-01f, 7.72842616e-02f, 7.18367770e-02f, 9.57777724e-02f, -3.33421864e-02f, 6.65993467e-02f,
  3.42528485e-02f, -3.65489498e-02f, -1.10142253e-01f, 1.47924975e-01f, -3.72737125e-02f, -6.98676184e-02f, -8.38062316e-02f, -1.46840006e-01f, -5.24654947e-02f, 1.31703138e-01f,
  3.74279395e-02f, -7.77360946e-02f, -4.94900309e-02f, -7.90129676e-02f, 3.47213782e-02f, -1.43065333e-01f, 9.64967608e-02f, 8.87529552e-02f, -7.36264884e-02f, -6.81937933e-02f,
  4.72598188e-02f, -4.91342470e-02f, -1.12512015e-01f, -3.78615037e-02f, -4.83434238e-02f, -1.09865315e-01f, 1.19615294e-01f, -7.61735952e-04f, -3.65304463e-02f, -8.94533768e-02f,
  -8.37298408e-02f, -5.72130047e-02f, -1.50106484e-02f, 1.10704571e-01f, -1.02935180e-01f, 1.18817473e-02f, 1.50152799e-02f, -3.64069045e-02f, -1.03518397e-01f, -1.27941053e-02f,
  -5.46848699e-02f, -7.36316144e-02f, 6.45812135e-03f, 8.93378928e-02f, 3.09784506e-02f, 1.49671212e-01f, -4.08619456e-02f, 2.01454386e-02f, -5.93371354e-02f, 6.98166266e-02f,
  -6.54282197e-02f, -2.55967826e-01f, -1.29008532e-01f, -8.99082571e-02f, 3.03421039e-02f, -1.57130942e-01f, -3.72168720e-02f, -2.11333986e-02f, 1.64514426e-02f, -5.07885292e-02f,
  -5.07027432e-02f, -2.59226263e-02f, 1.34676439e-03f, 5.19725420e-02f, 9.35683697e-02f, -2.42440565e-03f, -7.89451823e-02f, -1.11220725e-01f, 7.86942467e-02f, -1.77434728e-01f,
  4.72935699e-02f, -2.61184163e-02f, 1.11632161e-01f, 3.72215618e-05f, -5.80128953e-02f, 2.40604375e-02f, 4.82201427e-02f, -9.12837498e-03f, -4.79840413e-02f, 3.88227291e-02f,
  1.06182946e-02f, 2.19037697e-01f, 9.89225041e-03f, -7.74806291e-02f, 1.36031523e-01f, 4.97701406e-01f, 3.14601868e-01f, 1.42019082e-04f, -8.30442682e-02f, 1.55269906e-01f,
  -1.00633420e-01f, 1.03392608e-01f, 1.82191581e-02f, -7.05646202e-02f, 1.51627362e-01f, -3.63666601e-02f, 8.05071443e-02f, 1.23715207e-01f, -3.26744527e-01f, 1.88993558e-01f,
  -2.65881736e-02f, 2.33915031e-01f, -2.68562824e-01f, -1.60674945e-01f, 1.04647741e-01f, -2.36195713e-01f, -3.08320314e-01f, -1.38994101e-02f, -1.20723844e-01f, 2.70429626e-02f,
  -2.88792682e-04f, -1.27730072e-01f, 1.13600371e-02f, 1.78630110e-02f, 5.80186285e-02f, -6.64649382e-02f, -1.03471130e-02f, 1.06495067e-01f, -8.01421106e-02f, -2.65121497e-02f,
  1.65726617e-01f, 5.18358722e-02f, 1.31688297e-01f, -8.49053413e-02f, 1.83976755e-01f, 1.16303237e-03f, 4.90145721e-02f, -1.24620264e-02f, 5.27692474e-02f, 1.91012323e-01f,
  8.65378454e-02f, 1.06912531e-01f, 4.51283343e-02f, 4.80639935e-02f, -2.42425445e-02f, -1.56084541e-02f, 1.32170081e-01f, 1.09906577e-01f, 1.12015948e-01f, 1.17574528e-01f,
  -3.35042812e-02f, 3.64297666e-02f, 1.80002645e-01f, -9.66532305e-02f, -1.50362281e-02f, -1.49303734e-01f, 2.12714784e-02f, 7.91834947e-03f, 1.01615340e-01f, 3.64406258e-02f,
  2.11373512e-02f, -1.22687951e-01f, -9.69714969e-02f, 1.19134732e-01f, 1.36072114e-01f, -1.23188324e-01f, -1.85511947e-01f, -3.17589205e-04f, -3.79669443e-02f, -1.89283467e-03f,
  -1.17534138e-01f, 4.33108211e-02f, -9.96436831e-03f, -8.61107707e-02f, -1.24896601e-01f, 6.65858611e-02f, -4.24390957e-02f, -1.28265545e-01f, -1.59962252e-01f, 2.35444400e-02f,
  1.21593997e-01f, 2.58613229e-01f, -3.12289279e-02f, -2.38395650e-02f, -8.64868313e-02f, -9.64414552e-02f, -7.62816370e-02f, 2.42182035e-02f, 6.04934543e-02f, 8.76038447e-02f,
  -4.49300036e-02f, -5.56985848e-02f, 1.13717146e-01f, -2.00078934e-01f, -3.66188511e-02f, 7.11349174e-02f, 8.19140896e-02f, 7.70895034e-02f, 1.07683912e-01f, 5.73161878e-02f,
  -6.02837391e-02f, 9.56388116e-02f, -1.07593499e-02f, -8.70779604e-02f, 1.48400979e-03f, -4.80980352e-02f, 1.45332664e-01f, -8.27574520e-04f, 1.36988267e-01f, -1.10174544e-01f,
  4.62855659e-02f, -1.56137973e-01f, -2.18017131e-01f, -4.12178561e-02f, 7.67519325e-02f, 1.99912675e-02f, -2.01230600e-01f, 4.51177396e-02f, -3.94244909e-01f, 1.69871464e-01f,
  -9.13871266e-03f, -5.94617017e-02f, -1.81197882e-01f, -7.97941461e-02f, -5.92072401e-03f, -4.42407519e-01f, 1.30937114e-01f, -1.53026998e-03f, -2.39080846e-01f, 2.69236177e-01f,
  1.39366928e-02f, 2.36985371e-01f, -1.31581351e-01f, 2.39624590e-01f, 1.51433021e-01f, 8.55753198e-02f, 3.07163209e-01f, -6.99644759e-02f, 2.69503564e-01f, -7.41393771e-04f,
  -6.86094537e-02f, -1.23229206e-01f, -6.45122081e-02f, -2.69459598e-02f, 3.60435210e-02f, 2.09259659e-01f, 8.07224289e-02f, -5.39840609e-02f, -2.33151764e-02f, -1.05572246e-01f,
  2.20811218e-02f, -3.03797238e-02f, 4.61848862e-02f, -4.40592086e-03f, 9.66486149e-03f, -6.44853013e-03f, -8.41467232e-02f, -3.95087432e-03f, -2.09590390e-01f, 2.31943261e-02f,
  -1.47415772e-01f, 6.65679052e-02f, -1.22155705e-02f, -5.66723337e-03f, -5.83341010e-02f, -6.06111474e-02f, -4.14266586e-02f, 1.52113587e-01f, -6.70987293e-02f, 3.16387378e-02f,
  7.53429979e-02f, 2.18416005e-02f, -2.30520256e-02f, -1.62291974e-01f, 4.83539514e-02f, -4.62509021e-02f, -7.14841634e-02f, -9.96294841e-02f, -7.81451985e-02f, 2.19315588e-02f,
  4.60811891e-02f, 4.84265015e-02f, -1.32101879e-01f, 2.49096025e-02f, 9.07991379e-02f, -7.99753219e-02f, -5.58575653e-02f, 3.53230722e-02f, 8.65102857e-02f, -1.37229830e-01f,
  -1.94353089e-01f, 7.27688968e-02f, 7.67261684e-02f, 6.11168034e-02f, -9.06902030e-02f, 1.13591656e-01f, 1.45249069e-01f, 2.62936521e-02f, 3.54523472e-02f, 5.38864285e-02f,
  2.47316584e-02f, 2.71903664e-01f, 5.24378084e-02f, -1.79359056e-02f, -3.72447930e-02f, 6.74039423e-02f, -4.92671728e-02f, 8.35744888e-02f, 7.39189833e-02f, 3.91926132e-02f,
  2.70173669e-01f, 3.61851156e-02f, 6.77618431e-03f, -2.43464001e-02f, -6.09719791e-02f, 2.33186573e-01f, 6.96301088e-02f, 1.36792958e-01f, 6.25710562e-02f, 1.56189814e-01f,
  1.22447319e-01f, 1.38249233e-01f, 3.81973200e-02f, -4.40825447e-02f, 3.78340855e-02f, 1.83270395e-01f, 1.28822863e-01f, -4.66155522e-02f, 4.23824936e-02f, -5.67323528e-02f,
  -1.89010561e-01f, -1.98644087e-01f, 1.88556343e-01f, -2.37436727e-01f, -2.54147351e-01f, 1.38589755e-01f, 1.75998300e-01f, -2.47316539e-01f, -3.27400714e-01f, 3.57475504e-02f,
  -2.01265559e-01f, 9.30987522e-02f, 3.65835279e-01f, -1.48108393e-01f, 3.77719074e-01f, 2.17250928e-01f, -1.29954696e-01f, 1.96867600e-01f, -2.36918464e-01f, -1.71987817e-01f,
  -1.24915250e-01f, -2.36490294e-01f, 1.59233540e-01f, -3.31661791e-01f, -2.18659014e-01f, -1.55371428e-01f, 4.12947219e-03f, 5.41753843e-02f, -1.87360331e-01f, -5.42414188e-02f,
  -2.41113409e-01f, -2.82185078e-01f, -4.82404195e-02f, -1.25807878e-02f, -1.22726530e-01f, 5.39562292e-02f, 1.26503989e-01f, 1.11939408e-01f, 1.08813912e-01f, -3.35095450e-02f,
  1.65983155e-01f, 2.87665389e-02f, -1.15434386e-01f, 1.03843860e-01f, -1.49104804e-01f, -9.17487368e-02f, 1.37424730e-02f, -2.01443750e-02f, -3.54118235e-02f, 6.87908009e-02f,
  5.83373047e-02f, -1.60720814e-02f, -6.63768724e-02f, 5.94518613e-03f, 8.09713975e-02f, -3.55567373e-02f, 4.01591957e-02f, 1.02482326e-01f, -2.62169540e-02f, -1.62363008e-01f,
  -6.41747862e-02f, -1.07223438e-02f, -1.08341172e-01f, -3.70345600e-02f, 1.28772091e-02f, -1.05590224e-01f, 2.65791491e-02f, 2.37476844e-02f, 6.69997483e-02f, -1.50592811e-02f,
  1.74285788e-02f, 5.91641180e-02f, -7.33957440e-02f, 5.16972244e-02f, -1.13051236e-01f, -5.74763753e-02f, 1.09421819e-01f, 2.91948882e-03f, -9.86019988e-03f, 2.87721716e-02f,
  -2.05150992e-02f, -1.87591240e-02f, 4.92968969e-02f, -5.07286973e-02f, -2.75761317e-02f, 9.74004939e-02f, -2.10605878e-02f, 8.04191753e-02f, 2.62889601e-02f, 2.29431186e-02f,
  -1.41363159e-01f, -1.28627777e-01f, -9.32430029e-02f, 4.01315391e-02f, -2.25928091e-02f, -3.08277123e-02f, 4.39516455e-02f, -6.53298125e-02f, -2.71738805e-02f, -9.42269638e-02f,
  4.62192185e-02f, 1.60096362e-01f, -4.39802855e-02f, -1.45523390e-02f, 8.43198597e-02f, 4.53553423e-02f, -3.69793735e-02f, -3.35466824e-02f, -2.53208838e-02f, -5.93823045e-02f,
  9.98273864e-02f, -3.01504950e-03f, 3.50575820e-02f, -8.43002126e-02f, 3.08950357e-02f, 4.62981723e-02f, 8.70844070e-03f, -2.80520152e-02f, 1.61345731e-02f, 3.09398212e-03f,
  -4.41953868e-01f, -8.30927864e-03f, 3.25889438e-01f, -1.70227364e-01f, -1.99806854e-01f, 3.15311909e-01f, 4.41199392e-01f, -1.97361618e-01f, -1.85038656e-01f, 2.13292480e-01f,
  -1.70121416e-01f, -5.30705266e-02f, 3.69177550e-01f, -5.00270985e-02f, 2.98968107e-01f, 4.29441750e-01f, -2.10094973e-02f, 1.88597679e-01f, -1.85589552e-01f, -2.50883162e-01f,
  -1.83367342e-01f, -2.22971231e-01f, 4.00670797e-01f, -3.05337697e-01f, -2.11875632e-01f, -2.08865091e-01f, -4.97198850e-02f, 5.02135977e-02f, -1.16935305e-01f, -8.16344768e-02f,
  -4.03200328e-01f, -2.19159454e-01f, -7.90335834e-02f, -1.96405407e-02f, -4.62896340e-02f, 1.32756270e-02f, 1.41897336e-01f, 1.61659539e-01f, -3.75888608e-02f, -6.55328855e-02f,
  4.72948402e-02f, -1.29950106e-01f, -1.87628314e-01f, 3.83010623e-03f, -1.42249703e-01f, -8.71335343e-02f, -5.32877892e-02f, -2.51717679e-02f, 9.88049805e-03f, 4.51651737e-02f,
  4.92021302e-03f, 2.72385892e-03f, 2.24794308e-03f, -4.96570319e-02f, 7.61261806e-02f, -6.27658591e-02f, 2.53569963e-03f, -3.34150977e-02f, -3.08066215e-02f, -9.23751220e-02f,
  2.24250391e-01f, -1.42304655e-02f, 1.43822074e-01f, -1.44294828e-01f, 4.64610867e-02f, -8.09740126e-02f, -5.03809052e-03f, -3.81820984e-02f, -4.35112836e-03f, -4.93688043e-03f,
  -4.73828651e-02f, -5.70262549e-03f, -1.17941968e-01f, 1.45180356e-02f, 6.70803115e-02f, -6.13480024e-02f, 1.25045523e-01f, -9.22796652e-02f, -7.91687146e-02f, -5.32372966e-02f,
  7.83286616e-02f, 3.96592356e-02f, -2.49485858e-02f, 2.14205217e-02f, -4.22917567e-02f, -2.86974222e-03f, -8.48819688e-02f, 1.30614698e-01f, 4.47745528e-03f, 1.57478284e-02f,
  -2.33496875e-01f, -1.31574005e-01f, -2.73616258e-02f, -1.86679095e-01f, -2.35583028e-03f, -4.50335033e-02f, -2.23293956e-02f, -1.23152286e-01f, -1.20226704e-01f, -5.12575097e-02f,
  -5.27540632e-02f, 4.81375605e-02f, -4.88750488e-02f, 5.66805899e-02f, 8.78627002e-02f, 6.63978159e-02f, 8.83589089e-02f, -1.64983064e-01f, -1.39233068e-01f, -1.33819222e-01f,
  -4.70862053e-02f, 5.76608740e-02f, 1.58094317e-01f, 5.60398735e-02f, 9.93613079e-02f, -1.25800502e-02f, -2.39861086e-01f, 1.99288018e-02f, 4.99032401e-02f, 4.68802154e-02f,
  1.98773891e-01f, -3.43826741e-01f, 2.01687396e-01f, 4.47044410e-02f, 4.43548262e-02f, 2.45452896e-01f, 3.77201945e-01f, -2.20679790e-01f, -2.64416397e-01f, -2.09502488e-01f,
  2.55442373e-02f, 1.36319742e-01f, 1.93550140e-01f, -1.38789043e-01f, 2.40599170e-01f, 1.09278619e-01f, -3.01225483e-02f, 1.22368343e-01f, -8.69610235e-02f, -7.44465366e-02f,
  -6.23433590e-02f, -1.64715424e-02f, 2.81259149e-01f, -2.13567466e-01f, 1.15063250e-01f, -1.59646556e-01f, -2.93379038e-04f, 3.47471893e-01f, -1.31235600e-01f, 1.11046776e-01f,
  -1.17280886e-01f, -8.78651887e-02f, 7.89993182e-02f, -1.47834241e-01f, 5.53263985e-02f, 4.36079577e-02f, 1.85875759e-01f, 1.08294666e-01f, 1.87316298e-01f, 9.42642801e-03f,
  1.18979745e-01f, -1.57496817e-02f, -1.86135054e-01f, 1.07597783e-01f, -2.30549499e-02f, -6.26660436e-02f, -7.73295239e-02f, -1.38714775e-01f, 3.66188921e-02f, -6.19282499e-02f,
  1.06331490e-01f, -1.15940414e-01f, -2.82803141e-02f, -4.26116027e-02f, 1.20290108e-01f, -3.26223187e-02f, 2.37824693e-02f, 1.66433975e-01f, -1.43459633e-01f, -6.56365454e-02f,
  -1.75711531e-02f, 8.00659880e-02f, -3.73241752e-02f, -1.45079613e-01f, 5.19677289e-02f, -1.32234842e-02f, -4.97073792e-02f, 3.83776836e-02f, 1.37299486e-02f, -8.56496394e-03f,
  6.96956366e-03f, 5.71925901e-02f, -3.24137323e-02f, 5.12884967e-02f, 1.49704702e-02f, -4.51584347e-02f, 1.69663116e-01f, -4.74467538e-02f, 6.19623298e-03f, -1.23154325e-02f,
  1.20049886e-01f, 3.01197972e-02f, 3.56906131e-02f, 3.17630591e-03f, 2.46182233e-02f, 8.28598440e-02f, 6.02421612e-02f, 1.18758269e-02f, -5.08479699e-02f, 9.80664119e-02f,
  -2.50711087e-02f, -9.45360884e-02f, 5.82295842e-03f, -1.40834749e-01f, 7.39319101e-02f, 1.84030719e-02f, 1.14203822e-02f, -1.97923020e-01f, 4.14058147e-03f, -6.24395236e-02f,
  -2.25239303e-02f, 7.04602571e-03f, -1.37806565e-01f, -1.87618379e-02f, 4.39982582e-03f, 2.51499303e-02f, 8.24590251e-02f, 2.24153651e-03f, -6.31936220e-03f, -2.12121475e-02f,
  7.55423307e-02f, -9.32229459e-02f, -3.03036664e-02f, -1.04355864e-01f, -1.11604549e-01f, 9.05954652e-03f, 4.23434488e-02f, -1.14522852e-01f, 4.76300158e-03f, -2.52870023e-02f,
  2.68092632e-01f, 8.88283774e-02f, -2.18717441e-01f, 6.89568892e-02f, -1.29957616e-01f, -6.03136839e-03f, -1.20946437e-01f, -1.79905191e-01f, 4.03339148e-01f, -1.22098081e-01f,
  4.43395367e-03f, 6.31424189e-02f, 7.73514211e-02f, 4.93724048e-02f, 7.53566772e-02f, 3.39601070e-01f, 2.05476925e-01f, 1.39890164e-01f, 3.35875064e-01f, -2.37747952e-01f,
  1.55751202e-02f, -2.95531124e-01f, -1.49995610e-01f, -3.48571569e-01f, -3.20029467e-01f, -1.31528333e-01f, -2.89512813e-01f, -2.21332073e-01f, -3.03071439e-01f, -1.56381235e-01f,
  1.01376856e-02f, 1.95535839e-01f, 2.72747483e-02f, -1.67328697e-02f, 1.52479455e-01f, -1.36304749e-02f, -1.98321834e-01f, -1.14133522e-01f, -5.99608757e-03f, 5.25597967e-02f,
  -6.49730861e-02f, -1.39870662e-02f, 1.51024193e-01f, -4.15891111e-02f, -1.45760939e-01f, -6.37051761e-02f, 9.77560505e-02f, -2.06485298e-02f, -7.78351650e-02f, -2.20833253e-02f,
  1.42302522e-02f, 1.31510600e-01f, -6.52206549e-03f, -3.56521681e-02f, 1.82177611e-02f, -1.35579333e-03f, -1.03825971e-01f, -2.31310129e-02f, 1.30765945e-01f, 7.74919018e-02f,
  -9.86806974e-02f, 1.60592780e-01f, -9.34874937e-02f, -8.90866593e-02f, -3.42208967e-02f, 1.03123905e-02f, 2.59351768e-02f, -1.00745563e-03f, 4.22313958e-02f, 8.91828835e-02f,
  3.60778049e-02f, 8.92694853e-03f, 8.95037279e-02f, 1.24230705e-01f, 1.06685810e-01f, -1.61584139e-01f, -1.26238376e-01f, 3.89014743e-02f, 1.07680745e-02f, 7.98101537e-03f,
  -2.14177012e-01f, 4.89500575e-02f, 6.23088852e-02f, -8.55259225e-02f, 1.22051183e-02f, 7.88858458e-02f, -7.12161884e-02f, 1.66055635e-02f, 6.57685548e-02f, -2.84790508e-02f,
  1.80068433e-01f, 2.60297749e-02f, 1.50683269e-01f, 1.24812827e-01f, -2.69509703e-02f, 3.72534338e-03f, 2.55821534e-02f, -4.39168559e-03f, -5.26814833e-02f, -3.29209156e-02f,
  -3.21683735e-02f, -6.13434091e-02f, -4.25359644e-02f, -1.98539421e-02f, 4.89773117e-02f, -9.80947763e-02f, 1.16171343e-02f, 3.26615795e-02f, -1.70277521e-01f, -6.07058266e-03f,
  -1.31132528e-01f, 1.52738485e-03f, -5.93114831e-02f, -3.78936194e-02f, 1.93076599e-02f, -5.45566939e-02f, -1.92833540e-03f, 1.33673668e-01f, -6.64915815e-02f, 1.01362199e-01f,
  -2.98008114e-01f, 2.22457305e-01f, 1.60912231e-01f, -4.13753152e-01f, 2.08927676e-01f, 2.48075709e-01f, -1.92423686e-01f, 3.31300408e-01f, -2.17657283e-01f, -8.36238563e-02f,
  -1.02820322e-01f, -3.31453681e-01f, 2.25407872e-02f, -3.57931823e-01f, -1.65418297e-01f, -3.40273790e-02f, -7.33409449e-02f, -2.71879613e-01f, 3.86735871e-02f, -9.36568901e-03f,
  5.08055948e-02f, -1.84191212e-01f, 1.37866408e-01f, 1.70985624e-01f, -8.28570500e-02f, 1.00613376e-02f, -1.89183187e-02f, 2.68830121e-01f, 9.15815830e-02f, -1.97526142e-02f,
  4.76766564e-02f, -4.10491824e-02f, -1.36051271e-02f, -7.17380047e-02f, 2.87980773e-02f, 9.43594426e-02f, 3.90180834e-02f, -8.96130577e-02f, -3.63995619e-02f, -5.90043440e-02f,
  -4.93560582e-02f, 1.26934741e-02f, -1.38130233e-01f, 5.96692637e-02f, 6.58637881e-02f, -2.10432243e-02f, 8.50859191e-03f, 1.12561859e-01f, -9.71684754e-02f, 1.34971403e-02f,
  -3.65280397e-02f, -4.37147617e-02f, -2.14320961e-02f, -8.39441642e-02f, 8.19677263e-02f, -2.31114607e-02f, -2.53476412e-03f, 5.58024412e-03f, -1.58587694e-02f, -5.75641543e-02f,
  7.87778720e-02f, 4.23839316e-03f, -3.07428911e-02f, -1.28815576e-01f, -1.68578029e-01f, -7.83353969e-02f, 7.55488873e-02f, -1.83554851e-02f, 7.44247362e-02f, -3.78225185e-02f,
  5.34490049e-02f, -7.93890134e-02f, 6.99416399e-02f, 1.72884744e-02f, -1.08461380e-01f, 8.78324325e-04f, -4.60390514e-03f, -1.05400540e-01f, -2.33760830e-02f, -8.19993950e-03f,
  1.03919894e-01f, 9.71090868e-02f, -1.16107069e-01f, -6.99539259e-02f, -5.51523827e-02f, -9.48531926e-02f, 1.39479414e-01f, -1.59868971e-01f, -1.46789588e-02f, 2.34933887e-02f,
  6.02291338e-02f, 5.76608256e-02f, -4.23520356e-02f, 1.75851444e-03f, -8.29659402e-02f, 2.76976563e-02f, -6.71473220e-02f, 9.64725241e-02f, 8.25813189e-02f, -1.22555628e-01f,
  1.69565737e-01f, -6.13983758e-02f, 1.02877624e-01f, 5.05263172e-02f, 4.32922728e-02f, 1.00799706e-02f, -1.56237349e-01f, -9.95488316e-02f, 4.24044430e-02f, 1.15431987e-01f,
  -1.80821031e-01f, 7.07191154e-02f, 3.28131057e-02f, 4.29006554e-02f, 1.18860677e-01f, -4.77112941e-02f, -3.11326571e-02f, 1.29811168e-02f, 2.91272327e-02f, 1.82080731e-01f,
  -3.31800759e-01f, 2.02839062e-01f, 2.94386625e-01f, -2.98079941e-02f, 5.44001520e-01f, 5.85319996e-01f, 1.33326933e-01f, 5.00655651e-01f, 5.68558037e-01f, -5.72544672e-02f,
  -1.53270187e-02f, -4.02384728e-01f, -3.04243825e-02f, -3.78640392e-03f, 3.14300388e-01f, 1.56837091e-01f, 2.05683872e-01f, -7.45703876e-02f, 1.39024094e-01f, -3.29450220e-02f,
  7.50872791e-02f, -5.05211279e-02f, -8.29042569e-02f, -9.72560197e-02f, -9.68889296e-02f, -1.11785382e-01f, -3.51895005e-01f, -6.53739572e-02f, -1.73554242e-01f, 1.69983640e-01f,
  1.18247584e-01f, -2.89414469e-02f, -2.83189744e-01f, -1.73456129e-02f, 1.08344689e-01f, -2.44213175e-02f, -9.10476744e-02f, -1.09768212e-01f, -2.37061568e-02f, 8.43490884e-02f,
  -6.51418045e-02f, -4.55521271e-02f, -5.08916900e-02f, -5.23590557e-02f, 4.00479883e-02f, 1.06127813e-01f, 5.13876267e-02f, 8.72102976e-02f, 8.85477886e-02f, 1.47102982e-01f,
  -1.21461088e-03f, 2.12297477e-02f, 6.04344569e-02f, 1.75098419e-01f, 5.77742159e-02f, 3.49850990e-02f, -1.57863870e-02f, 7.37838373e-02f, 1.23193249e-01f, 9.21785757e-02f,
  4.79867347e-02f, 7.83151463e-02f, -7.79702067e-02f, 2.20003296e-02f, -8.46071243e-02f, 7.32494891e-02f, -1.06914155e-01f, -7.86955431e-02f, 7.94551373e-02f, 3.72268585e-03f,
  -1.47931203e-02f, -5.97306900e-02f, 8.44938755e-02f, 3.87414135e-02f, -1.59826487e-01f, 6.49793595e-02f, -1.95696745e-02f, -7.21981972e-02f, 1.08481377e-01f, 3.26178148e-02f,
  2.34349687e-02f, 5.45203984e-02f, 5.49519015e-03f, -6.89234138e-02f, 7.86370113e-02f, 4.71215360e-02f, 4.02006842e-02f, 3.64149697e-02f, -4.50730100e-02f, 5.32223694e-02f,
  3.06139708e-01f, 7.60339275e-02f, -5.42681478e-02f, -6.68930113e-02f, 1.72840431e-02f, 3.58602905e-04f, 5.51500209e-02f, 1.59089103e-01f, 3.49324085e-02f, 4.95139174e-02f,
  -1.02229685e-01f, -1.63143128e-01f, 2.50673499e-02f, 5.00221131e-03f, 4.89532389e-02f, 1.40223399e-01f, -1.33290719e-02f, 3.31475213e-02f, 7.04762638e-02f, -6.05506375e-02f,
  -1.31203130e-01f, -2.13278867e-02f, -7.47237206e-02f, 6.55735433e-02f, -1.82984723e-03f, -1.62347108e-01f, -1.58465922e-01f, 3.60183720e-03f, 9.49339569e-02f, 1.87101196e-02f,
  2.07932070e-02f, -1.04257949e-01f, -2.27328494e-01f, -1.69143990e-01f, -2.91101988e-02f, -2.19845146e-01f, -2.62473583e-01f, -1.46862060e-01f, 1.28643569e-02f, 2.08983153e-01f,
  -1.81684211e-01f, -9.83833242e-03f, 9.11382437e-02f, -3.08040500e-01f, -1.25307024e-01f, -9.15131271e-02f, -2.09106822e-02f, 1.08077012e-01f, 3.38697992e-02f, -9.11547244e-02f,
  -9.86516103e-02f, -8.26376081e-02f, -2.95028090e-01f, -1.38010591e-01f, -2.39252523e-01f, -4.05201390e-02f, 1.68657959e-01f, -2.68272132e-01f, -1.36138082e-01f, -2.12607950e-01f,
  -1.70744672e-01f, -1.96637183e-01f, -3.73510458e-02f, -1.01592854e-01f, -8.79508536e-03f, 6.84662312e-02f, 7.33404383e-02f, -1.02006949e-01f, -1.24946244e-01f, -9.73977596e-02f,
  2.10961908e-01f, 1.12160683e-01f, 4.05554026e-02f, -5.81581257e-02f, -1.04678102e-01f, 1.07915336e-02f, -7.58432746e-02f, -6.22058660e-02f, -1.48326948e-01f, -5.91915846e-02f,
  -1.02087744e-01f, 7.53560737e-02f, -8.85365158e-02f, 4.51916903e-02f, 1.91018172e-03f, -2.03158855e-01f, -8.54812469e-03f, -9.30770710e-02f, 2.12428212e-01f, 1.36743672e-03f,
  -1.59366410e-02f, 6.42961357e-04f, 3.58558856e-02f, 7.15254173e-02f, -1.69754773e-02f, -3.41746882e-02f, -9.18088928e-02f, 5.27365990e-02f, 6.07100353e-02f, -1.05474330e-01f,
  1.54791856e-02f, -2.80513219e-03f, -8.24159160e-02f, 6.80093840e-02f, -6.79266527e-02f, 2.73594279e-02f, 8.06338433e-03f, 4.04746644e-02f, 1.59275264e-01f, 8.08277577e-02f,
  6.85556531e-02f, 8.97232350e-03f, -2.49080583e-02f, 3.35016265e-03f, -5.89811541e-02f, 5.44350483e-02f, -8.88750702e-02f, -4.69093993e-02f, 8.99040997e-02f, 3.63343731e-02f,
  3.67819108e-02f, 7.91221783e-02f, -2.50467341e-02f, -1.15819268e-01f, -3.39885242e-02f, 6.51468858e-02f, -3.19010802e-02f, -1.07843921e-01f, -5.11103543e-03f, -9.95051786e-02f,
  2.04086646e-01f, 1.02711871e-01f, 1.81767151e-01f, 7.69789368e-02f, -8.28274339e-03f, -5.02102971e-02f, 9.82000679e-02f, 6.05954304e-02f, 8.70474055e-02f, 3.58029678e-02f,
  1.47464991e-01f, 1.30865857e-01f, 3.93534936e-02f, 3.70917432e-02f, 2.02510640e-01f, -2.13269163e-02f, 1.06312089e-01f, -1.20555088e-01f, 1.77608311e-01f, -6.08168095e-02f,
  3.46816421e-01f, 1.08823523e-01f, 3.35262328e-01f, 5.50706625e-01f, -1.51338726e-01f, -3.29228729e-01f, -1.27872199e-01f, 2.12548152e-01f, 5.65988898e-01f, -1.86130747e-01f,
  -7.94273093e-02f, 2.94904917e-01f, -2.11916968e-01f, -1.81711033e-01f, 7.47585967e-02f, 1.85933620e-01f, 7.15239346e-02f, -1.24737471e-02f, 3.25563729e-01f, 1.61329843e-02f,
  2.70922631e-01f, -2.73137599e-01f, -2.46758461e-02f, -1.96124330e-01f, -1.30082846e-01f, 1.67639732e-01f, -1.63891554e-01f, -1.34034589e-01f, -2.44256288e-01f, -4.86222357e-02f,
  -1.92529425e-01f, 1.27251640e-01f, -3.99589911e-02f, -7.92837515e-02f, -1.02465250e-01f, -9.89804044e-02f, -1.58388447e-02f, -1.10893205e-01f, -6.14901334e-02f, -1.15424961e-01f,
  8.12168717e-02f, 4.14254926e-02f, -1.38683841e-01f, -4.87348139e-02f, 2.18674131e-02f, 1.17563576e-01f, 2.29454562e-02f, 2.99459370e-03f, -8.91055018e-02f, 8.48325714e-02f,
  -6.96471706e-02f, -5.79655927e-04f, -4.39382792e-02f, -9.18636695e-02f, -3.49722430e-02f, 6.03190586e-02f, 6.26985654e-02f, -1.24364443e-01f, 1.70460399e-02f, 6.09233454e-02f,
  2.85537820e-03f, 2.68786103e-02f, -1.70994103e-01f, -5.87690808e-02f, -4.66907509e-02f, -1.91424415e-02f, 8.55920464e-02f, -3.06394212e-02f, 8.84835050e-02f, -8.63123238e-02f,
  1.20265111e-02f, -5.48847020e-02f, 5.45084924e-02f, 8.64087939e-02f, 7.14835674e-02f, 9.18771792e-03f, -9.39859003e-02f, 1.35153066e-03f, -2.61129159e-03f, 9.99714732e-02f,
  -1.66991606e-01f, 2.69203763e-02f, -4.33610380e-02f, 7.19100982e-02f, -2.25304980e-02f, -6.31094500e-02f, 9.92119312e-02f, 2.70567425e-02f, 6.19143061e-02f, 7.38634169e-03f,
  -5.26639670e-02f, 1.58061802e-01f, -6.61628172e-02f, -2.39470467e-01f, -4.70819101e-02f, -1.22797005e-02f, -4.41491865e-02f, 1.08635724e-02f, 2.34006196e-02f, 1.36611527e-02f,
  5.08354008e-02f, -1.04203418e-01f, -4.79173660e-03f, 1.12604886e-01f, -1.57997400e-01f, 8.86328891e-02f, -1.28873214e-01f, -1.02575934e-02f, -1.47178501e-01f, 4.93093878e-02f,
  -6.20964654e-02f, -2.45079063e-02f, -6.06106743e-02f, 1.74346697e-02f, -4.70421948e-02f, -1.09302990e-01f, 5.92860505e-02f, -1.94648448e-02f, -9.65171605e-02f, 4.65107225e-02f,
  2.11418673e-01f, 3.75470012e-01f, -4.57705697e-03f, 1.67050748e-03f, -4.77248430e-02f, -4.77502763e-01f, -2.09109768e-01f, -1.36172622e-01f, 1.02956928e-01f, 2.16063902e-01f,
  -2.66971111e-01f, 3.41801792e-01f, -1.19934238e-01f, 3.94266192e-03f, -5.43971598e-01f, -2.44510993e-01f, -3.77015859e-01f, 2.79511642e-02f, 5.52926473e-02f, -1.65292006e-02f,
  -1.16038024e-01f, -2.39296243e-01f, -5.92381284e-02f, -7.33133629e-02f, 1.14789687e-01f, 2.34169483e-01f, -1.64774209e-01f, 6.14771433e-02f, -4.67425591e-04f, -7.05061778e-02f,
  4.06098180e-02f, 1.71260655e-01f, 5.51092066e-02f, 3.48771885e-02f, -2.12976530e-01f, 9.58635956e-02f, 1.86800342e-02f, -3.55592929e-02f, 1.07230777e-02f, 6.57606646e-02f,
  1.04811318e-01f, -4.18884084e-02f, -3.76095716e-03f, 7.26445019e-02f, 1.56762764e-01f, 4.37526740e-02f, 2.84826737e-02f, -1.30022347e-01f, 8.30839723e-02f, 1.11705475e-01f,
  1.58832110e-02f, -8.76524113e-03f, -1.08456939e-01f, -1.06939552e-02f, -1.33977085e-01f, -3.21056955e-02f, 8.04281142e-03f, -1.59257022e-03f, 1.11667089e-01f, 9.63064358e-02f,
  3.22534367e-02f, 2.06811428e-02f, 5.54422140e-02f, 3.77880931e-02f, -7.20462352e-02f, 5.46327494e-02f, -1.36959562e-02f, -4.10845829e-03f, -2.14893818e-02f, -8.22057873e-02f,
  -6.72087669e-02f, 3.56397405e-02f, 9.91573185e-03f, 3.35381692e-03f, -1.12398071e-02f, 9.61256176e-02f, -2.18446422e-02f, 1.19628139e-01f, -4.54227738e-02f, -3.24791204e-03f,
  1.41221387e-02f, -1.62637249e-01f, 1.44971879e-02f, -1.45135624e-02f, -1.24204867e-01f, -2.09372249e-02f, 1.33870151e-02f, 8.08389187e-02f, 7.74125522e-03f, -1.49000183e-01f,
  -2.99946219e-01f, -1.31130397e-01f, -1.30301854e-02f, 1.32565781e-01f, 9.81495157e-03f, -5.85269220e-02f, -6.74492773e-03f, 1.05012141e-01f, -1.41239181e-01f, -1.27690462e-02f,
  -3.70621569e-02f, -3.98151688e-02f, -7.60868788e-02f, -6.61836341e-02f, 8.01187754e-03f, -2.18395829e-01f, -4.46030088e-02f, -6.89601749e-02f, -1.01109058e-01f, 5.07041588e-02f,
  3.71835493e-02f, -5.82204945e-02f, -6.23028763e-02f, -3.56663615e-02f, 1.52941216e-02f, -1.59125961e-02f, -1.04138302e-02f, 3.21115963e-02f, -3.45021822e-02f, -2.53053028e-02f,
  9.77697596e-02f, -1.53553799e-01f, -2.46308163e-01f, 6.86304346e-02f, 2.61694819e-01f, 1.11250974e-01f, -1.72240719e-01f, 1.93637952e-01f, 1.70418974e-02f, -8.73070583e-02f,
  2.61283785e-01f, -8.13543499e-02f, -3.30009729e-01f, 3.97503167e-01f, 3.04123938e-01f, -1.37066826e-01f, 2.77731329e-01f, 1.78760752e-01f, 6.11157604e-02f, 2.64646649e-01f,
  1.77022144e-01f, 3.37212294e-01f, -7.88152590e-02f, 1.88327849e-01f, 2.48429224e-01f, -2.44538244e-02f, 2.41762489e-01f, -2.47930273e-01f, 1.61101162e-01f, 1.68223351e-01f,
  -7.35900626e-02f, 5.93457147e-02f, 3.18085612e-03f, -1.25665992e-01f, -1.95108149e-02f, -8.40432197e-02f, -1.75786391e-01f, -2.29079439e-03f, -4.30046804e-02f, -6.33644834e-02f,
  -4.68336493e-02f, 6.02873648e-03f, 1.87305614e-01f, 8.71446952e-02f, -3.84196261e-04f, -2.47642212e-02f, 3.39633003e-02f, -5.87061457e-02f, 3.85461329e-03f, 5.30396542e-03f,
  -1.15356259e-01f, 6.24496583e-03f, -4.27982807e-02f, -2.97153145e-02f, -4.13476303e-02f, 1.38425842e-01f, -7.46867433e-02f, -1.26686186e-01f, 1.36273563e-01f, 1.29047364e-01f,
  1.38474414e-02f, -1.24822952e-01f, -5.36576845e-02f, 2.70820763e-02f, -6.22111000e-02f, 9.14350431e-03f, -3.37556824e-02f, 9.95603297e-03f, -1.51643693e-01f, -5.55128120e-02f,
  1.48296386e-01f, 7.73353353e-02f, 2.29518097e-02f, 6.66278824e-02f, -3.60778905e-02f, 2.81553864e-02f, -2.76871268e-02f, 5.24238646e-02f, 5.39321527e-02f, -9.54588689e-03f,
  7.23008439e-02f, 1.07547708e-01f, -8.79262574e-03f, 3.99296023e-02f, 1.44695526e-03f, 4.22078967e-02f, 5.53981401e-02f, 6.21871874e-02f, -1.04876280e-01f, 6.04641624e-03f,
  9.27347094e-02f, 1.95971519e-01f, 6.04236266e-03f, -2.55426439e-03f, -6.20310381e-02f, 3.46371159e-02f, -1.02420308e-01f, 1.37193039e-01f, 5.67171164e-02f, 7.60239363e-02f,
  -9.52613913e-03f, -1.08428068e-01f, 3.16603780e-02f, 8.66069645e-02f, 2.65217256e-02f, 1.70744568e-01f, -5.81197068e-02f, 2.21343641e-03f, 1.29870504e-01f, 1.50120646e-01f,
  -3.15101109e-02f, 1.88272670e-02f, 3.61945629e-02f, 5.39252199e-02f, 7.78890401e-02f, -7.31319860e-02f, 4.04906943e-02f, -1.67352855e-02f, 6.28333762e-02f, -8.85877833e-02f,
  -7.01308548e-01f, 2.05678254e-01f, 8.29514638e-02f, -3.29958797e-01f, 2.95502637e-02f, 4.72850204e-02f, -1.37291759e-01f, -2.49021370e-02f, -2.61252284e-01f, 2.67645180e-01f,
  1.97033852e-01f, -2.42440298e-01f, 1.77706748e-01f, 9.95749086e-02f, -2.92762905e-01f, 2.46633217e-01f, 7.44788498e-02f, -1.07439265e-01f, -5.54914512e-02f, -1.85381606e-01f,
  -6.78083524e-02f, 1.33181110e-01f, 1.74181208e-01f, 1.74341932e-01f, 4.38360423e-02f, -1.52066797e-01f, -1.42208198e-02f, 2.26110414e-01f, 1.54977636e-02f, 1.05165364e-03f,
  -1.38520971e-01f, -3.08337271e-01f, -4.29994203e-02f, -3.97963217e-03f, -3.06118224e-02f, -7.93223381e-02f, 3.46422903e-02f, 1.70126818e-02f, -4.77344505e-02f, -1.10999405e-01f,
  -3.12310550e-02f, -3.96813564e-02f, -5.52572012e-02f, -9.03438330e-02f, -6.22074446e-03f, 5.79766221e-02f, 1.02613509e-01f, 1.15506954e-01f, 6.07200079e-02f, 1.25495329e-01f,
  7.47158378e-02f, 1.23754218e-02f, 2.61117378e-03f, 8.44529718e-02f, 6.84842020e-02f, -1.40272500e-02f, 1.19662285e-01f, -1.91418864e-02f, -6.20758645e-02f, 2.55958061e-03f,
  -1.16849914e-01f, 2.59587113e-02f, -1.50156673e-03f, 5.57390004e-02f, -1.45170912e-01f, 1.27760977e-01f, -2.01754663e-02f, -3.21957767e-02f, 3.00870445e-02f, -1.20725287e-02f,
  3.93847264e-02f, -5.70240431e-02f, -7.34521523e-02f, -4.74846847e-02f, -5.32091148e-02f, -2.88299378e-02f, -1.43215721e-02f, -8.99112374e-02f, 2.19382136e-03f, -5.69095984e-02f,
  1.06490329e-02f, -2.57914606e-02f, -2.89897155e-02f, 1.43575193e-02f, -3.15981470e-02f, -2.59532183e-02f, 4.07217853e-02f, 1.25429392e-01f, -5.04514351e-02f, -5.15380539e-02f,
  -3.68768603e-01f, -2.39694640e-01f, -2.76425816e-02f, -6.14632852e-02f, -1.01907924e-01f, -1.26234010e-01f, -6.01534620e-02f, 1.07254628e-02f, -2.57108714e-02f, -1.73317805e-01f,
  -3.62925082e-02f, -2.14109849e-02f, -3.17195468e-02f, -1.07691765e-01f, -2.94794217e-02f, 1.27482131e-01f, -5.30377589e-03f, -1.37423053e-01f, -2.95227990e-02f, -4.30102497e-02f,
  8.87260437e-02f, 1.33807480e-03f, 1.50503339e-02f, 6.18895739e-02f, -1.21666014e-01f, 2.84718629e-02f, -1.22163586e-01f, -6.82804659e-02f, -7.28649180e-03f, 1.19540952e-01f,
  -3.41830589e-02f, 8.01262408e-02f, 2.47982293e-01f, 1.92931235e-01f, -1.59213528e-01f, -2.15202168e-01f, -1.33040994e-01f, -8.07812288e-02f, -2.77798563e-01f, 5.08475453e-02f,
  1.36616081e-02f, 4.11408514e-01f, -2.83051789e-01f, 2.76478648e-01f, -5.70420474e-02f, -2.85490274e-01f, -6.26451448e-02f, 3.31179678e-01f, -8.18378106e-02f, 1.05433799e-02f,
  -3.24165868e-03f, -2.84133017e-01f, 1.87654331e-01f, -2.43505955e-01f, 3.66134614e-01f, 2.09791273e-01f, -9.11870822e-02f, 2.38445047e-02f, 1.97663769e-01f, 1.27898246e-01f,
  6.94832504e-02f, -2.11779639e-01f, 8.33522305e-02f, 1.13531336e-01f, -3.80185782e-03f, 6.26283810e-02f, 2.55397886e-01f, 1.63251594e-01f, 9.93960649e-02f, 8.38887319e-02f,
  8.83233473e-02f, -9.27205104e-03f, 5.64631261e-02f, -8.47042259e-03f, 1.89889688e-02f, 5.61898872e-02f, -2.47299373e-02f, 1.91675246e-01f, 5.95711619e-02f, 8.73896033e-02f,
  -5.15326997e-03f, 8.84167776e-02f, -1.57707706e-02f, -3.54687609e-02f, -8.51857886e-02f, -1.39267355e-01f, -2.41688117e-02f, 1.44713491e-01f, 1.40626639e-01f, -4.60667908e-02f,
  -3.73048545e-03f, -7.24337846e-02f, 4.88656424e-02f, 1.49001032e-01f, -2.41253823e-02f, -4.50119190e-02f, -4.35993448e-02f, 1.72764510e-01f, -5.74832819e-02f, -5.63058704e-02f,
  9.77161005e-02f, 1.29752457e-01f, 3.15637067e-02f, -1.00306198e-01f, -1.28057480e-01f, -4.12252806e-02f, 1.91745624e-01f, 1.09425381e-01f, -9.07340124e-02f, 1.15574412e-01f,
  -8.05795118e-02f, 5.71113899e-02f, 2.82733142e-03f, 1.67159736e-01f, -1.10592712e-02f, -1.01613916e-01f, 9.72913802e-02f, 6.68398067e-02f, 1.15405910e-01f, 1.05737679e-01f,
  -1.30181119e-01f, -2.50423491e-01f, -1.30091403e-02f, 1.20662533e-01f, -9.66200978e-02f, -1.10348389e-02f, -2.28381399e-02f, 8.45928639e-02f, 1.01653501e-01f, -7.13751242e-02f,
  1.09334737e-01f, 5.04688323e-02f, -1.09746549e-02f, 5.39932810e-02f, -5.88207357e-02f, -2.13624075e-01f, -3.07287071e-02f, 6.97742626e-02f, 4.76189293e-02f, 7.52201155e-02f,
  -7.79238120e-02f, 4.87634093e-02f, -1.44574419e-02f, -7.26085454e-02f, 2.74820086e-02f, -1.39825821e-01f, -3.01948469e-02f, -3.68293189e-02f, -8.18859227e-03f, 2.00613160e-02f,
  -4.95986640e-01f, 1.76423728e-01f, -1.83723360e-01f, 1.91132538e-02f, -2.19828054e-01f, 3.83428514e-01f, 2.30355397e-01f, -1.53067619e-01f, -6.73232153e-02f, 3.50975662e-01f,
  6.66406751e-02f, -3.89617793e-02f, -3.03147912e-01f, 3.98497760e-01f, -1.44767031e-01f, 1.94019288e-01f, 4.18803632e-01f, 2.46320710e-01f, -4.82010171e-02f, -1.66977376e-01f,
  -3.05479653e-02f, 1.83519468e-01f, 1.03882954e-01f, 8.73057693e-02f, 3.86878476e-02f, 3.04646697e-02f, -4.91686575e-02f, -2.74161845e-01f, 4.27190721e-01f, 1.61729172e-01f,
  9.34285286e-04f, -2.30674088e-01f, -8.48990232e-02f, -1.16949923e-01f, -7.60755762e-02f, -3.85694876e-02f, 8.96556750e-02f, -1.00791745e-01f, -1.03880070e-01f, -7.20649883e-02f,
  -1.17113888e-01f, -1.54960966e-02f, -4.37593386e-02f, -1.16848812e-01f, -7.64752775e-02f, -3.29906307e-02f, -6.13163859e-02f, 4.64789867e-02f, -1.13264374e-01f, -1.93398148e-01f,
  -1.68005347e-01f, 3.00742164e-02f, 8.46258923e-02f, -1.96647830e-02f, -3.58886570e-02f, 1.48873985e-01f, 4.90964837e-02f, -1.43474877e-01f, 4.00073975e-01f, 5.07414043e-02f,
  -7.38087744e-02f, -7.66721889e-02f, -8.49154815e-02f, 3.76156047e-02f, -8.34364742e-02f, 5.48273288e-02f, 2.61818081e-01f, 1.03831878e-02f, -2.91081462e-02f, -5.49971387e-02f,
  3.63633931e-02f, 5.04871458e-03f, 2.63476390e-02f, 8.62996802e-02f, 5.33647239e-02f, 5.69367222e-02f, -2.23364704e-03f, -1.94844529e-02f, 4.74148942e-03f, 7.33467191e-02f,
  2.37359572e-02f, 5.58868311e-02f, -4.64261472e-02f, 3.78437936e-02f, 1.31706074e-01f, -7.33882487e-02f, -6.78593889e-02f, -3.67947482e-02f, 2.25009080e-02f, -2.82575767e-02f,
  6.75812960e-02f, -1.79868117e-01f, -5.57375662e-02f, -5.49835488e-02f, 2.85273977e-02f, -4.21202332e-02f, -4.50440571e-02f, -2.38801595e-02f, 7.77815580e-02f, -9.18176323e-02f,
  -1.54970869e-01f, 1.05225652e-01f, 5.58506213e-02f, -2.41162032e-02f, 1.60587043e-01f, -1.01441547e-01f, 2.18840819e-02f, -1.67997718e-01f, 4.65397984e-02f, 4.40588482e-02f,
  -1.28139079e-01f, -3.66965905e-02f, 1.14346258e-01f, -2.21607042e-03f, 1.83308125e-01f, -7.21781477e-02f, -4.30396311e-02f, -1.89770982e-02f, 1.68237314e-01f, 1.65382586e-02f,
  -4.71259147e-01f, 3.15768421e-01f, 1.62730604e-01f, -1.74706832e-01f, -6.25713319e-02f, 1.68985769e-01f, -4.49117422e-02f, 2.10654631e-01f, 2.40263909e-01f, 2.56035268e-01f,
  -1.87568113e-01f, 1.76011562e-01f, 2.75528252e-01f, -4.43680361e-02f, -1.98771134e-01f, 2.47345790e-01f, -1.47159383e-01f, -8.56971517e-02f, 1.35521770e-01f, -7.51598105e-02f,
  -5.04836142e-02f, -2.25523949e-01f, -1.57280698e-01f, 2.34558120e-01f, -5.56132905e-02f, -7.14354366e-02f, -2.81866312e-01f, 1.59826633e-02f, -2.42556319e-01f, 3.14390883e-02f,
  -3.67295593e-01f, -8.11123848e-02f, 5.87080903e-02f, 9.20522492e-03f, -1.11222520e-01f, -5.35192154e-02f, -2.18940347e-01f, 1.74884778e-03f, 6.08649999e-02f, 1.41985208e-01f,
  -6.26836438e-03f, 6.41701296e-02f, 1.42129632e-02f, 5.53455688e-02f, -1.32247517e-02f, 6.43263906e-02f, 2.47850828e-02f, -1.35276303e-01f, 1.69557035e-01f, 9.67133418e-02f,
  2.06956536e-01f, 7.22831935e-02f, -4.99335565e-02f, -1.51341841e-01f, 2.30354033e-02f, 6.91946819e-02f, -1.44469172e-01f, -2.14262739e-01f, -6.90826550e-02f, 9.54079255e-03f,
  1.28257498e-01f, 2.57884264e-02f, 2.81595420e-02f, -5.11922278e-02f, 1.45149246e-01f, -1.10317878e-01f, 8.83625001e-02f, -1.59364179e-01f, -7.07124844e-02f, -8.05177018e-02f,
  -2.07510293e-01f, 4.85895853e-03f, 1.54959355e-02f, -1.38665726e-02f, -5.11566214e-02f, 5.86661473e-02f, -1.24541387e-01f, -3.11139915e-02f, -7.79569428e-03f, -3.04808356e-02f,
  3.92193235e-02f, -3.98909301e-02f, 1.16141528e-01f, 1.14295390e-02f, -2.09784359e-02f, 2.70709139e-03f, -4.03365074e-03f, 3.57581936e-02f, 5.53014576e-02f, -4.76191640e-02f,
  -2.82869071e-01f, -2.45353431e-01f, 5.94857754e-03f, 2.11068280e-02f, -1.10301614e-01f, -4.15573977e-02f, 7.84366112e-03f, -3.91609482e-02f, 8.36120024e-02f, 6.65107071e-02f,
  -2.75385398e-02f, 1.28350586e-01f, -1.04764692e-01f, 5.03417328e-02f, 5.22017181e-02f, -5.79021052e-02f, -1.56763688e-01f, -1.16829529e-01f, -6.50254190e-02f, 1.64786875e-02f,
  7.24187791e-02f, 3.14323530e-02f, -4.35340637e-03f, -3.34445089e-02f, -6.28782585e-02f, -3.24489945e-03f, -1.57712981e-01f, 1.51092529e-01f, -1.36090815e-01f, -2.45738067e-02f,
  8.89051631e-02f, -1.17807232e-01f, -2.28307713e-02f, 2.06788346e-01f, -2.97131866e-01f, 1.57058716e-01f, 3.73529106e-01f, -2.94284850e-01f, 1.01121694e-01f, 8.27900693e-02f,
  -2.97498643e-01f, 3.72322559e-01f, 1.45622000e-01f, -2.16090992e-01f, 2.93214172e-01f, 2.56902307e-01f, 1.77472129e-01f, 3.23968917e-01f, 1.94455460e-02f, 2.94336136e-02f,
  -5.81675358e-02f, -2.55525768e-01f, -2.54338890e-01f, -1.75965905e-01f, -1.93635792e-01f, -1.46857440e-01f, -2.16037452e-01f, -2.66491957e-02f, -2.31989026e-01f, 2.46695447e-04f,
  2.21352410e-02f, -2.40332074e-02f, 1.16970176e-02f, 1.54073879e-01f, -8.04277211e-02f, -3.30487750e-02f, 1.52425095e-01f, 4.49992232e-02f, 3.66290733e-02f, -1.05937004e-01f,
  1.90248653e-01f, -3.53602543e-02f, 5.69826066e-02f, 6.58631250e-02f, -1.29115969e-01f, -5.88435419e-02f, 4.05379804e-03f, -1.49738252e-01f, -7.66940489e-02f, -2.76466478e-02f,
  -1.94099639e-02f, -1.33399352e-01f, -2.43666582e-03f, 1.14312395e-01f, 4.70593944e-02f, 1.26640961e-01f, 5.89640252e-02f, 1.21336862e-01f, 7.26833269e-02f, -3.88595043e-03f,
  -6.19639605e-02f, -1.91348977e-02f, 5.12970351e-02f, -4.44008261e-02f, -8.28115344e-02f, -1.35692775e-01f, 8.53195637e-02f, -4.80830222e-02f, 4.17933911e-02f, -3.71947438e-02f,
  1.01520903e-01f, -8.62464085e-02f, -6.30088821e-02f, 4.02349383e-02f, -1.18017048e-01f, 1.28285900e-01f, 4.62953150e-02f, -3.68308052e-02f, 2.29511019e-02f, -1.62837043e-01f,
  -8.21218118e-02f, -6.68392424e-03f, -1.47872772e-02f, -4.40694243e-02f, 7.21429586e-02f, -6.31610379e-02f, -1.15887947e-01f, -3.57754864e-02f, -1.27872884e-01f, 2.06784443e-05f,
  -1.91994235e-02f, 2.19175711e-01f, -6.09455667e-02f, 1.15699187e-01f, 5.38082011e-02f, -5.23309372e-02f, 1.06139950e-01f, -1.08145744e-01f, 8.55914503e-02f, -5.21327136e-03f,
  4.25865650e-02f, 7.45616034e-02f, 8.07109941e-03f, -4.99230027e-02f, 1.86515488e-02f, -7.65168667e-02f, 1.73140973e-01f, 7.68348947e-02f, 1.34600654e-01f, -1.23914607e-01f,
  -6.38769343e-02f, 5.19592278e-02f, 6.93502724e-02f, 1.33203939e-01f, 1.22691188e-02f, -2.08140928e-02f, -2.23612282e-02f, 4.80223112e-02f, 1.74889579e-01f, 4.17997390e-02f,
  -4.83372919e-02f, -9.29426551e-02f, -1.52913198e-01f, -1.30493090e-01f, -2.11500481e-01f, 2.76362449e-02f, -7.49664605e-02f, -2.92699076e-02f, 1.68169767e-01f, -7.01954663e-02f,
  -1.88745797e-01f, 1.87096447e-01f, 8.23050216e-02f, -3.50858599e-01f, 3.24117035e-01f, 2.07555503e-01f, -2.11599067e-01f, 5.32170199e-02f, -1.19402204e-02f, -1.28886402e-01f,
  -9.64376926e-02f, -2.69384831e-01f, -2.63687223e-01f, -2.35899374e-01f, -3.00083131e-01f, -1.02649495e-01f, -1.30841479e-01f, -2.44211927e-01f, -3.64444107e-01f, -2.19669655e-01f,
  2.31508426e-02f, -1.19947232e-01f, 1.56449880e-02f, -2.16591842e-02f, 5.63900508e-02f, 1.68858171e-02f, -2.64145195e-01f, -1.72985420e-02f, 1.16389140e-01f, -1.28825763e-02f,
  -5.19829104e-03f, -2.39770412e-02f, -1.23010337e-01f, 1.16561055e-01f, -2.35196322e-01f, 2.47587031e-03f, -1.21144086e-01f, -2.12211981e-02f, 1.38630737e-02f, 2.34569106e-02f,
  1.08234905e-01f, -2.35025715e-02f, -4.78593819e-02f, 7.01490417e-02f, -4.86451276e-02f, -2.95020994e-02f, 1.84618235e-01f, -1.32346097e-02f, -3.50771882e-02f, -2.37008352e-02f,
  -1.08489759e-01f, 5.44917062e-02f, 4.15376872e-02f, -1.41461730e-01f, 1.49448831e-02f, 5.63484803e-02f, 7.01551884e-02f, -5.48703857e-02f, 8.97687674e-02f, 9.29131731e-02f,
  7.79731153e-03f, -1.44482655e-02f, -1.08337231e-01f, 6.36482090e-02f, 9.95661840e-02f, 4.95704375e-02f, -6.65996298e-02f, 1.26636684e-01f, -1.57607836e-03f, 9.50647891e-02f,
  1.26508504e-01f, -4.05370817e-02f, 5.69941476e-02f, -5.40955961e-02f, 4.35976200e-02f, -9.53076258e-02f, -9.34204757e-02f, 9.68537182e-02f, 7.75449425e-02f, -4.36473340e-02f,
  -3.38667841e-03f, 1.41105250e-01f, 1.39132231e-01f, 2.17416715e-02f, 8.39461014e-02f, -5.52941933e-02f, -1.12246029e-01f, 3.43716028e-03f, 1.64028183e-01f, -5.61418347e-02f,
  -3.60514154e-04f, 5.91731519e-02f, -1.74405426e-02f, -2.01711822e-02f, 6.72360882e-02f, -5.23746386e-02f, 8.60273242e-02f, 9.77686942e-02f, 1.65439069e-01f, -1.01839542e-01f,
  1.81656629e-01f, 5.92074543e-02f, 9.51367170e-02f, 1.47070736e-01f, 5.06971925e-02f, -1.77373402e-02f, 1.20190293e-01f, -6.86034709e-02f, -5.32459877e-02f, 3.69049162e-02f,
  2.13843048e-01f, -5.03409028e-01f, 3.22038919e-04f, 5.17656982e-01f, 1.56973824e-01f, -9.63553227e-03f, 1.71247736e-01f, -4.81328256e-02f, 3.52743149e-01f, -5.21887302e-01f,
  -7.98571259e-02f, -2.14986116e-01f, -2.67332971e-01f, 1.48435950e-01f, 1.38658613e-01f, -2.57748514e-01f, 1.37765378e-01f, -1.25009149e-01f, 1.47307381e-01f, -1.52141705e-01f,
  2.26012602e-01f, 1.48278669e-01f, 5.85519113e-02f, -9.66117531e-02f, 4.33668308e-02f, 1.39549255e-01f, 4.98864660e-03f, 5.09993359e-02f, 1.90660074e-01f, 1.42615512e-01f,
  1.66863665e-01f, 3.62534113e-02f, 4.59806733e-02f, 5.07008657e-02f, 1.55589152e-02f, -8.99545327e-02f, 5.43890521e-03f, 5.34850219e-03f, 2.14224786e-01f, 1.02037810e-01f,
  -8.09993371e-02f, 8.02908316e-02f, 2.91313957e-02f, 5.62530905e-02f, 1.19619846e-01f, 1.61769122e-01f, 7.74105489e-02f, -4.67031077e-02f, 5.54568805e-02f, -9.83923674e-02f,
  1.62961148e-02f, 1.85054857e-02f, -7.91865215e-02f, -4.02232558e-02f, 3.64725888e-02f, 3.90608646e-02f, -2.66011078e-02f, -5.12560755e-02f, -1.28952265e-02f, -7.79993013e-02f,
  -1.24969617e-01f, 3.11618019e-02f, -5.53239323e-02f, 7.08862990e-02f, 5.75745106e-02f, 1.62100136e-01f, 2.24272348e-02f, 2.78295763e-03f, 1.65316388e-02f, 5.14089316e-02f,
  1.44818678e-01f, 3.83256599e-02f, 1.57105327e-01f, -6.11812016e-03f, 8.80831406e-02f, -3.34468409e-02f, -6.75691739e-02f, -6.09678030e-02f, -1.50100728e-02f, 5.67748882e-02f,
  -2.97333952e-02f, 6.10594526e-02f, -4.81680781e-02f, 1.50186801e-02f, 7.45950490e-02f, -6.89982921e-02f, -8.71259198e-02f, -5.41395620e-02f, 9.08927247e-02f, -1.04891397e-01f,
  -4.79063578e-02f, -3.77046168e-01f, 6.24838732e-02f, 1.31557167e-01f, -4.90267277e-02f, -1.21920109e-01f, 8.62533674e-02f, -4.22101021e-02f, 1.06604293e-01f, -1.01822585e-01f,
  -1.20379485e-01f, 1.10853299e-01f, -5.73870167e-02f, 4.52047156e-04f, 1.05831236e-01f, 3.12335859e-03f, -3.28666940e-02f, 3.50501426e-02f, -3.06442603e-02f, -1.21151499e-01f,
  1.15140211e-02f, -2.14746641e-03f, 9.20869317e-03f, 8.97757709e-02f, 3.56992744e-02f, -8.50042179e-02f, -7.87960738e-02f, 8.74613747e-02f, -6.55598613e-03f, 1.33352559e-02f,
  2.65325218e-01f, 4.25259858e-01f, 4.64424379e-02f, -1.94701046e-01f, -2.25023374e-01f, -1.44684717e-01f, -2.91855067e-01f, -4.70901420e-03f, -2.34615013e-01f, -2.24024802e-02f,
  -9.97277200e-02f, -1.13987535e-01f, 2.44215146e-01f, 1.92131788e-01f, 1.26985043e-01f, 2.54123658e-01f, 1.08293742e-01f, 1.53581128e-01f, 1.85487464e-01f, 3.05607826e-01f,
  2.04014167e-01f, 1.14432611e-01f, 3.30184519e-01f, 4.12299842e-01f, 3.69757682e-01f, 1.17730975e-01f, -7.77257532e-02f, 6.12077154e-02f, 4.14851271e-02f, -4.49425839e-02f,
  1.15643762e-01f, 1.36879414e-01f, 6.88199922e-02f, -6.26792833e-02f, 1.37587950e-01f, 2.32522525e-02f, 3.64888906e-02f, -8.30365643e-02f, -3.83287296e-02f, -1.93259120e-02f,
  -4.97502759e-02f, -2.36434862e-03f, 2.35229004e-02f, -1.01829350e-01f, -1.02671772e-01f, -7.49023557e-02f, 2.22093500e-02f, -1.76408805e-03f, -2.57313345e-02f, 1.75050944e-01f,
  1.00939237e-01f, -5.11919186e-02f, -5.76293878e-02f, 1.62285864e-02f, -6.44335225e-02f, -2.21354783e-01f, -8.71118233e-02f, 3.54060344e-03f, 2.31706072e-02f, 2.24699806e-02f,
  8.07745904e-02f, 2.43957285e-02f, -1.53095610e-02f, 5.11544980e-02f, 1.01968512e-01f, -7.96505287e-02f, -1.05368122e-01f, 2.22292263e-02f, 2.01204829e-02f, 1.40088379e-01f,
  -8.49804133e-02f, 5.55875339e-02f, -4.33770828e-02f, -6.61130473e-02f, 5.44582978e-02f, 4.38560769e-02f, -5.11636101e-02f, 2.46234573e-02f, 1.71581544e-02f, -3.24014425e-02f,
  -9.82331634e-02f, -4.47292179e-02f, 2.29974817e-02f, 1.55154103e-02f, 8.23655073e-03f, 2.47207563e-02f, 6.29579425e-02f, 1.44159317e-01f, 1.12946808e-01f, 4.18267623e-02f,
  3.09751350e-02f, 2.79210657e-01f, 3.08637228e-02f, -1.13620356e-01f, 1.34696916e-01f, 1.53892338e-01f, 9.78262872e-02f, 5.69505729e-02f, -5.72418794e-03f, 4.94908206e-02f,
  -1.12125531e-01f, -3.17928009e-02f, -1.35998845e-01f, -1.29894465e-02f, 2.79346742e-02f, -5.09254262e-02f, -9.29278880e-03f, -9.95264575e-02f, 2.36890726e-02f, 5.42927086e-02f,
  2.83459872e-02f, -1.95202976e-02f, 1.91395469e-02f, -7.98025280e-02f, -5.34455813e-02f, -3.39222550e-02f, 4.78749536e-02f, 5.20154741e-03f, 1.09280013e-01f, -3.25631201e-02f,
  5.23628831e-01f, -3.75027597e-01f, 6.53316975e-02f, 3.04214358e-01f, 9.07808468e-02f, -1.74398229e-01f, 4.05269206e-01f, -1.36292309e-01f, -2.06497088e-02f, -2.42221013e-01f,
  2.66424119e-01f, -1.49854392e-01f, 3.37109059e-01f, -5.36385253e-02f, 2.70539016e-01f, 2.19262853e-01f, 2.27645598e-02f, -3.85489799e-02f, -2.02679485e-02f, 8.81180242e-02f,
  1.24819532e-01f, 4.08945754e-02f, 2.52747148e-01f, -3.08965623e-01f, 6.90746903e-02f, -1.44021511e-01f, 1.31699711e-01f, 3.52286883e-02f, -1.93178982e-01f, -8.14433023e-02f,
  4.29569781e-02f, 1.82133257e-01f, 5.85795147e-03f, -1.42287731e-01f, -8.37009922e-02f, -7.67596886e-02f, 7.26582035e-02f, 1.50237054e-01f, 6.17551543e-02f, 1.25710629e-02f,
  -8.54942016e-03f, -1.65658910e-02f, -1.90074816e-01f, -1.42004132e-01f, -3.39606926e-02f, -1.39353693e-01f, -4.56037819e-02f, 1.17675059e-01f, -6.69503212e-02f, 1.22350641e-01f,
  1.04993865e-01f, 5.23144864e-02f, 1.41527116e-01f, -5.30012324e-02f, 9.45358947e-02f, 3.20831798e-02f, -7.27325007e-02f, -3.16449292e-02f, -1.88089665e-02f, -5.00248708e-02f,
  5.43006882e-02f, 2.53309608e-02f, 4.59281839e-02f, 6.12026416e-02f, 3.57994735e-02f, 8.49531442e-02f, 2.59729847e-02f, -6.26395494e-02f, 5.73356934e-02f, 1.11766520e-03f,
  -1.68894213e-02f, -1.01119410e-02f, -7.73377642e-02f, -2.81816274e-02f, 4.83946614e-02f, 3.79377068e-03f, 2.17144471e-02f, -5.42513654e-02f, 2.07390431e-02f, -6.99075982e-02f,
  4.18810286e-02f, -9.98739060e-03f, -3.94856818e-02f, -5.15072644e-02f, 2.25301534e-02f, 7.99907446e-02f, 9.27813202e-02f, 4.42237891e-02f, 8.28065723e-02f, 5.65385222e-02f,
  4.08583041e-03f, -2.86494225e-01f, -9.24442708e-03f, -1.14525318e-01f, -1.48105443e-01f, -1.36205167e-01f, -3.14257368e-02f, 2.88197584e-02f, -2.59505175e-02f, -4.37675491e-02f,
  -1.25439376e-01f, 5.57116568e-02f, 5.80507219e-02f, -1.46072641e-01f, -7.65040517e-02f, 5.38004152e-02f, -5.54974377e-02f, -1.34177342e-01f, 1.31380104e-03f, 2.77589075e-03f,
  -7.77170286e-02f, -7.83035457e-02f, 6.46278188e-02f, -3.20559926e-02f, -6.54438138e-02f, -1.12310955e-02f, -5.91330081e-02f, -1.51594896e-02f, -2.90380474e-02f, 3.78850624e-02f,
  2.31448025e-01f, 1.59852624e-01f, 4.35484201e-02f, 1.26844704e-01f, -7.63348639e-02f, 2.69611597e-01f, 3.24464858e-01f, -8.59307274e-02f, -5.72704189e-02f, -1.19928919e-01f,
  -1.68260440e-01f, 2.10325241e-01f, -1.58177927e-01f, 2.77073801e-01f, 3.16562384e-01f, -2.79960394e-01f, 2.74080992e-01f, 2.11340383e-01f, 3.38000315e-03f, -9.29096937e-02f,
  -2.70280987e-01f, 1.18906148e-01f, -1.28109083e-01f, -9.78107452e-02f, 2.55813807e-01f, 1.28624424e-01f, 1.47992121e-02f, -5.51540032e-02f, 3.38854909e-01f, 3.38794589e-01f,
  5.32366186e-02f, -5.66052794e-02f, -1.49347284e-03f, -6.45960169e-03f, 3.93985286e-02f, 1.30318597e-01f, 5.11980541e-02f, 1.40896946e-01f, -2.28958912e-02f, -7.91188776e-02f,
  1.06903985e-01f, 4.09344584e-02f, 8.46445635e-02f, 1.94699448e-02f, -8.24087560e-02f, 3.77053656e-02f, -9.83587094e-03f, 2.07324838e-03f, -1.27540221e-02f, 6.40655383e-02f,
  -7.57982656e-02f, -1.92432813e-02f, -3.29680778e-02f, 2.02380955e-01f, 5.63201942e-02f, 9.63591784e-02f, 1.00752316e-01f, 1.29656926e-01f, 4.92372140e-02f, 5.85704595e-02f,
  1.21867113e-01f, 3.04630236e-03f, -4.33092788e-02f, -6.58969283e-02f, 1.04043819e-01f, 9.45240557e-02f, -1.36405649e-02f, -1.33161873e-01f, 8.40134621e-02f, -6.89307600e-02f,
  -1.35484949e-01f, -4.44683023e-02f, 1.98660120e-02f, -1.40198488e-02f, -1.70269236e-02f, -2.01572120e-01f, 7.43319765e-02f, 1.93111137e-01f, 1.10196415e-02f, -1.21221974e-01f,
  5.66723198e-02f, 1.60314769e-01f, 8.52494240e-02f, -5.84208630e-02f, 5.34268580e-02f, -1.96689256e-02f, 6.91346359e-03f, -9.12061781e-02f, -1.41925320e-01f, -6.67165443e-02f,
  8.94352496e-02f, 1.57932192e-01f, -1.01300506e-02f, 1.34143904e-02f, 7.14130839e-03f, 8.35682377e-02f, 3.52287777e-02f, -1.19664138e-02f, 7.25764334e-02f, -1.20321900e-01f,
  -7.84307569e-02f, 6.52708486e-02f, 8.19847137e-02f, -2.38074400e-02f, -6.46018330e-03f, -7.98310637e-02f, -3.85879986e-02f, 5.35612181e-02f, -6.84790537e-02f, 1.09422160e-02f,
  1.02050602e-01f, -3.17996368e-02f, -3.85130644e-02f, -1.23667410e-02f, -3.00826244e-02f, 1.04039118e-01f, 1.16118617e-01f, -6.80712238e-02f, 1.14645837e-02f, 1.42754242e-01f,
  -5.95690310e-01f, 1.20017327e-01f, -2.98588127e-01f, -3.00497979e-01f, 4.56554368e-02f, -3.15187991e-01f, -3.92734110e-02f, -3.04412004e-02f, -2.73931295e-01f, 3.98511797e-01f,
  1.98604643e-01f, -3.65020037e-01f, 1.10311233e-01f, -2.07097426e-01f, -3.79189342e-01f, -1.86424211e-01f, -1.29930824e-01f, -5.14181554e-02f, -2.39257306e-01f, -1.79025367e-01f,
  -2.62432396e-01f, 3.24418843e-02f, -2.21698880e-01f, 1.58723816e-01f, -5.22159748e-02f, 2.88490243e-02f, 1.75529003e-01f, 5.06624952e-02f, -1.34403203e-02f, -4.79052141e-02f,
  -2.49488071e-01f, -1.44926950e-01f, 4.77414876e-02f, -5.52359130e-03f, -6.71844557e-02f, 7.33397976e-02f, 2.56534945e-02f, 7.63858482e-02f, -5.15410155e-02f, -2.06505135e-01f,
  7.84813985e-02f, -4.92388792e-02f, -1.31640360e-01f, -9.98477191e-02f, -7.26733916e-03f, -1.84272751e-02f, -1.25434145e-01f, -8.27441216e-02f, -9.47275162e-02f, -1.26803368e-01f,
  -7.83450231e-02f, -1.27858177e-01f, -1.69766415e-02f, -8.59492086e-03f, -5.02981693e-02f, 3.04001197e-02f, -7.13923126e-02f, 4.54664715e-02f, -7.49770552e-02f, -7.51401670e-03f,
  -8.12571123e-03f, 3.81824858e-02f, -4.86552492e-02f, -7.02219009e-02f, -1.99698899e-02f, 1.80997476e-02f, 4.75473255e-02f, 4.49382560e-03f, 6.18721619e-02f, 2.80235633e-02f,
  -1.87209733e-02f, 1.32010309e-02f, -6.00866191e-02f, 1.08586490e-01f, 4.73963432e-02f, -5.86903840e-02f, 3.29701677e-02f, -3.71794477e-02f, -8.85352716e-02f, -5.23062944e-02f,
  5.76244816e-02f, -7.16351867e-02f, 3.31360139e-02f, 7.27943555e-02f, -2.43811328e-02f, -7.27204084e-02f, 1.09472528e-01f, 9.25680622e-03f, 6.93584308e-02f, -2.39015128e-02f,
  -4.71628122e-02f, 4.15005907e-02f, -1.69368777e-02f, 2.72466410e-02f, 5.90373874e-02f, 9.24404431e-03f, 6.33529946e-02f, -9.37457606e-02f, -5.21063767e-02f, -1.25888318e-01f,
  -7.61229098e-02f, 4.31229696e-02f, -6.92386404e-02f, -2.83351447e-02f, 1.94405913e-02f, 6.79821521e-02f, 1.04797229e-01f, -5.35086787e-04f, -3.85519937e-02f, -2.59943958e-02f,
  8.71278718e-02f, 5.57915345e-02f, -4.49772887e-02f, 3.89274880e-02f, 3.66235748e-02f, 4.72913012e-02f, 1.38449576e-02f, -4.87313718e-02f, 2.23330259e-02f, 8.66558552e-02f,
  4.02820669e-02f, -5.17514385e-02f, 1.64430082e-01f, 2.19454646e-01f, -4.58056078e-04f, -9.84048396e-02f, -1.00201935e-01f, 3.28452103e-02f, -1.02792665e-01f, -3.74489091e-02f,
  -1.31309852e-01f, 3.19657438e-02f, -4.24364805e-01f, 2.77198907e-02f, -1.39394149e-01f, -3.00561666e-01f, 1.88710660e-01f, 5.86844468e-03f, -1.02061182e-01f, 2.34744906e-01f,
  1.76056966e-01f, 6.52693138e-02f, 1.37223616e-01f, 2.31392846e-01f, 2.30884016e-01f, 3.44663739e-01f, 3.13788146e-01f, 7.95653313e-02f, 3.47357810e-01f, -1.38880238e-01f,
  -1.25387698e-01f, -1.02406643e-01f, 1.98657498e-01f, -1.05574049e-01f, 1.31187439e-01f, 5.01241833e-02f, -3.30843702e-02f, -1.37609914e-01f, 6.94503039e-02f, 7.81473070e-02f,
  7.66529096e-03f, 5.99334836e-02f, 1.92486905e-02f, 5.32808416e-02f, 5.44773508e-03f, 1.04384370e-01f, -2.69020014e-02f, -1.76912416e-02f, 5.75577654e-02f, -3.94597277e-02f,
  1.28566250e-01f, -4.39562239e-02f, 1.08718008e-01f, 7.84164760e-03f, 1.04935929e-01f, 1.66159179e-02f, 1.32210493e-01f, 1.46877691e-01f, 1.90196276e-01f, 8.64479989e-02f,
  -1.41494736e-01f, 3.42958234e-02f, -1.13471374e-01f, 4.51397672e-02f, 1.20011866e-01f, 1.59600955e-02f, -3.91758792e-02f, 2.01073959e-02f, -6.15569726e-02f, 1.29279643e-01f,
  1.05491534e-01f, 9.72151905e-02f, -4.69766045e-03f, 1.02180786e-01f, -1.40351001e-02f, 1.73860446e-01f, -2.26363242e-02f, -3.70878614e-02f, -4.41021547e-02f, 8.46511424e-02f,
  -1.03608526e-01f, -8.80981460e-02f, 1.06675282e-01f, -1.33288324e-01f, -9.07292515e-02f, -6.34633675e-02f, 2.98789982e-03f, 8.78359564e-03f, 3.35541256e-02f, -8.61126482e-02f,
  5.38903996e-02f, 1.08934090e-01f, 8.18994716e-02f, -1.13650061e-01f, 8.60500894e-03f, -7.83071071e-02f, -4.12339158e-02f, -6.55444115e-02f, -5.10878004e-02f, -1.01462752e-01f,
  8.39620233e-02f, 1.00374058e-01f, -3.26614901e-02f, -3.06373928e-02f, 4.35980260e-02f, 8.01477805e-02f, 6.17609210e-02f, 1.01754189e-01f, 5.60426414e-02f, 1.71847031e-01f,
  7.44660124e-02f, -6.68602344e-03f, 1.64062887e-01f, 6.96272478e-02f, -1.51632605e-02f, 6.98434711e-02f, 7.53020942e-02f, 1.59510195e-01f, -1.63706299e-02f, -1.65701106e-01f,
  -2.63869524e-01f, 2.49221623e-01f, 3.67831796e-01f, 3.45725626e-01f, -9.32222903e-02f, 3.15434873e-01f, 2.12109923e-01f, 2.23018616e-01f, 4.16167080e-01f, 1.78266689e-01f,
  -3.68153863e-02f, -1.66034661e-02f, -3.19268964e-02f, 2.29477748e-01f, -8.71035457e-02f, 2.63758421e-01f, 3.31872046e-01f, 3.68662365e-02f, 7.09040985e-02f, -4.03641798e-02f,
  1.16667256e-01f, -2.74737805e-01f, 1.61439985e-01f, -2.43516132e-01f, 1.15798675e-01f, -9.22450945e-02f, -2.13225827e-01f, -8.95077810e-02f, -5.73779196e-02f, -9.60673541e-02f,
  -3.11432093e-01f, -1.27335995e-01f, -7.09160343e-02f, 1.90329887e-02f, -2.07697935e-02f, -6.09170683e-02f, 2.02283636e-02f, -4.75432314e-02f, -4.26487662e-02f, -5.94487600e-02f,
  -2.57823127e-03f, 6.29201159e-02f, -1.20755866e-01f, -9.31655020e-02f, 9.03033316e-02f, 4.78728674e-02f, 5.96433543e-02f, 1.08854793e-01f, 1.00662723e-01f, 2.03101888e-01f,
  1.62401497e-01f, 1.26617879e-01f, 9.52609777e-02f, 8.17060992e-02f, -5.06755933e-02f, 8.42216313e-02f, 8.36321861e-02f, 7.69786462e-02f, 4.94679622e-02f, 8.64063110e-03f,
  5.18588610e-02f, -6.19790554e-02f, 2.06598509e-02f, -1.45110143e-02f, 5.29496074e-02f, -7.64476135e-02f, -2.66758651e-02f, -9.28826183e-02f, 3.24045271e-02f, 1.22607602e-02f,
  -2.06083804e-02f, 5.59272245e-02f, -1.70800127e-02f, 9.41361561e-02f, 2.54152846e-02f, 2.75566913e-02f, 8.66234526e-02f, -2.22853720e-02f, 5.12865297e-02f, 5.23087047e-02f,
  -5.98827787e-02f, -1.88380992e-03f, -2.15202738e-02f, 5.66376671e-02f, -8.62472598e-03f, -5.10209277e-02f, -9.30133685e-02f, 1.45943493e-01f, 6.90169558e-02f, -2.24676669e-01f,
  -4.39987600e-01f, -2.70451248e-01f, -1.98101699e-02f, 1.50709553e-02f, -1.18207164e-01f, -1.21435784e-01f, 1.26688797e-02f, -4.34761979e-02f, -1.40156433e-01f, 5.21893539e-02f,
  -7.82600138e-03f, 8.87927264e-02f, -1.69834569e-01f, -8.83313492e-02f, -5.67553751e-02f, -3.94019149e-02f, 3.35485972e-02f, -8.02537426e-03f, -1.16560437e-01f, -6.80177733e-02f,
  -8.07269290e-02f, -6.54068915e-03f, 8.55956692e-03f, 5.55748232e-02f, -1.42480042e-02f, -5.56458198e-02f, -6.61574230e-02f, -2.70641763e-02f, -9.67588723e-02f, 1.20857675e-02f,
  -1.44340128e-01f, 3.76016535e-02f, -2.40428329e-01f, -2.19023630e-01f, 2.88268238e-01f, -1.67046264e-01f, -8.62546712e-02f, 5.59609616e-03f, 1.80659443e-01f, 1.69245020e-01f,
  2.96635106e-02f, 7.54009411e-02f, 9.88598540e-02f, -3.16553086e-01f, -2.82997727e-01f, -8.52051675e-02f, -1.94250643e-01f, -2.02754065e-01f, -1.71707831e-02f, -6.68751001e-02f,
  -1.76110059e-01f, -4.39943187e-02f, -2.84468204e-01f, 2.75941014e-01f, -2.21981138e-01f, 6.58962652e-02f, -1.79342330e-01f, 3.25299680e-01f, -1.32531524e-01f, -4.53642868e-02f,
  -7.06029236e-02f, 1.77067406e-02f, 9.56375245e-03f, 8.30078439e-04f, -3.21606547e-02f, -4.17004600e-02f, 1.03524290e-01f, -1.10382974e-01f, 9.67624038e-03f, -4.11418565e-02f,
  -7.17343986e-02f, 1.82464812e-02f, 2.16317307e-02f, 6.68393970e-02f, 1.17391773e-01f, 1.67970229e-02f, -8.76846313e-02f, -1.15643539e-01f, -6.04894273e-02f, -1.09052517e-01f,
  -2.56914586e-01f, 3.51617066e-03f, 8.04662481e-02f, 1.12942971e-01f, 9.78282001e-03f, 5.95769882e-02f, -1.12379111e-01f, -7.52915964e-02f, 2.43105069e-02f, -4.53778878e-02f,
  9.31278057e-03f, 8.59315842e-02f, -4.00172779e-03f, 8.36323723e-02f, -8.14766344e-03f, -1.34826200e-02f, -5.44821545e-02f, -6.78055212e-02f, 5.96162230e-02f, -1.92624573e-02f,
  1.40263647e-01f, 9.06795561e-02f, 7.68538788e-02f, 2.15416886e-02f, -1.43190309e-01f, 7.38274679e-03f, 7.48685822e-02f, 1.32962167e-01f, -7.54324496e-02f, -7.20715225e-02f,
  1.25307947e-01f, -7.73195103e-02f, -6.95295483e-02f, 6.99518472e-02f, -1.63822398e-01f, 1.27823427e-01f, -6.72580153e-02f, -1.41991407e-01f, -1.35903865e-01f, 2.82824738e-03f,
  4.71499264e-02f, 1.71674311e-01f, -3.30141485e-02f, -5.51765896e-02f, -5.50409853e-02f, -5.99555150e-02f, 7.32787624e-02f, -8.17902610e-02f, 2.45334748e-02f, -3.62005532e-02f,
  -1.99147426e-02f, 5.24205505e-04f, 4.85374965e-02f, 1.56306788e-01f, -1.00559078e-01f, -1.68016315e-01f, 3.58120468e-03f, -4.54284064e-02f, -4.63011228e-02f, -1.18879750e-02f,
  3.98626877e-03f, 2.15489715e-01f, 9.44465995e-02f, 1.02488041e-01f, 1.82609353e-02f, -3.56597155e-02f, 5.44335544e-02f, 6.93820715e-02f, -6.44327030e-02f, -1.08790487e-01f,
  -4.30433363e-01f, 4.37580496e-01f, -7.23618492e-02f, 1.67679995e-01f, -7.68080428e-02f, 3.68456155e-01f, 3.60035241e-01f, 1.08832374e-01f, 2.85282522e-01f, 2.07296655e-01f,
  -1.47985697e-01f, 4.48873937e-02f, 6.85263500e-02f, 1.50479421e-01f, 2.39550080e-02f, 1.91927999e-01f, 3.47006142e-01f, 2.96210617e-01f, 1.63451493e-01f, -4.34684530e-02f,
  6.43719807e-02f, -1.37260064e-01f, -2.69910395e-01f, -3.58062834e-02f, -2.28167713e-01f, -7.60002360e-02f, -2.84298122e-01f, -6.21147752e-02f, -6.85115010e-02f, 4.82406691e-02f,
  -9.67637524e-02f, -1.95305385e-02f, -4.37162369e-02f, 3.19312550e-02f, -1.24913178e-01f, -1.44713717e-02f, -6.08487651e-02f, 2.92101828e-03f, 8.77206922e-02f, 5.80050945e-02f,
  -3.97881530e-02f, -6.95675462e-02f, 6.28647283e-02f, 2.75142607e-03f, 4.40188013e-02f, -8.29939321e-02f, -4.91658263e-02f, -3.30958143e-02f, 2.36208178e-02f, 7.82332325e-04f,
  -4.06316482e-02f, -9.64187831e-03f, 9.51371249e-03f, -1.87950116e-02f, 6.83957934e-02f, 1.46725848e-01f, 4.63335328e-02f, -1.33856475e-01f, -5.54445088e-02f, 3.13875116e-02f,
  9.82728377e-02f, 9.61103737e-02f, 2.34123897e-02f, -8.34153518e-02f, -8.45854580e-02f, -1.25087336e-01f, 2.86732018e-02f, -4.09124307e-02f, 3.69338202e-03f, -1.41506165e-01f,
  4.03127372e-02f, -1.13869384e-01f, 3.49752069e-03f, -3.63796460e-03f, 5.45433117e-03f, -3.80132273e-02f, -6.23743609e-02f, -8.68192911e-02f, -6.25634007e-03f, -1.47471830e-01f,
  -4.61811833e-02f, 1.82437465e-01f, -1.06119039e-02f, -2.20648553e-02f, -1.80058144e-02f, -1.47045050e-02f, -2.90588066e-02f, 9.39600095e-02f, 5.51386829e-03f, -4.17819712e-03f,
  3.28209549e-01f, 1.82758406e-01f, 2.54912837e-03f, -4.16681841e-02f, -2.94678267e-02f, 4.34946492e-02f, 8.09696317e-02f, 1.73194974e-03f, 1.18448228e-01f, 3.11482958e-02f,
  4.08132896e-02f, 1.97940059e-02f, -5.27105182e-02f, -6.00731894e-02f, -8.83138552e-02f, 5.83501086e-02f, 9.51123424e-03f, 9.30630937e-02f, -2.29507815e-02f, -6.21993467e-02f,
  -8.36956352e-02f, 7.64897466e-02f, 7.83931240e-02f, -9.79035944e-02f, 2.48892587e-02f, -1.19366519e-01f, 4.78326052e-04f, -6.28240183e-02f, -1.25949383e-01f, 1.36856839e-01f,
  -2.22143412e-01f, -5.58291040e-02f, 2.70571023e-01f, -3.81246842e-02f, 3.19117755e-01f, 3.13166499e-01f, 2.29663849e-02f, 5.01134507e-02f, -2.69552708e-01f, -4.15021360e-01f,
  -1.94395706e-01f, 1.16399415e-01f, -1.36314362e-01f, 1.45586329e-02f, 5.53074703e-02f, -1.64250806e-01f, -2.33915094e-02f, -6.06603920e-02f, -5.78535758e-02f, -1.11507259e-01f,
  -3.38407047e-02f, -2.65296847e-02f, 1.12820856e-01f, 7.46790916e-02f, 2.43235767e-01f, 7.73865506e-02f, -2.46131420e-01f, 6.90768957e-02f, 1.82258978e-01f, 2.08598152e-01f,
  -3.05167973e-01f, -2.45711401e-01f, -1.65254921e-01f, -7.25280344e-02f, -8.52850899e-02f, -4.94649969e-02f, -1.37189806e-01f, -1.26286000e-02f, -1.15560390e-01f, -5.71199656e-02f,
  -8.13548267e-02f, 9.26488489e-02f, 9.31206197e-02f, 3.40798944e-02f, -2.29223445e-02f, 1.10854156e-01f, 1.11396872e-01f, 2.90632676e-02f, 1.27358735e-01f, 1.05642967e-01f,
  1.26342431e-01f, 9.89805013e-02f, -4.78942953e-02f, -7.24250153e-02f, 8.56580585e-02f, 1.10737652e-01f, 9.99477804e-02f, 1.13524683e-01f, -1.96385458e-02f, -3.66811492e-02f,
  1.06334820e-01f, -9.53410715e-02f, 1.37394920e-01f, 8.76566097e-02f, 9.28028822e-02f, 1.70360412e-02f, -5.28808311e-02f, 8.37240741e-02f, -8.96435529e-02f, -8.32565427e-02f,
  -1.75311859e-03f, 4.05891985e-02f, -1.23688374e-02f, -1.07050806e-01f, -6.82768300e-02f, 2.47337073e-02f, 7.09770769e-02f, -1.22299306e-01f, 3.71904187e-02f, -2.39777956e-02f,
  4.95487750e-02f, -5.89547306e-02f, 6.55175447e-02f, 6.72727916e-03f, -3.35697830e-02f, -1.27024442e-01f, -4.03749980e-02f, 9.41604227e-02f, -1.15762249e-01f, 5.32063236e-03f,
  -5.80504477e-01f, -4.63689387e-01f, -1.80205271e-01f, -5.84495887e-02f, -2.02608440e-04f, -2.73253433e-02f, -9.30039808e-02f, 1.18542919e-02f, -1.42962232e-01f, -6.05390742e-02f,
  -6.71086237e-02f, -6.61983714e-03f, -6.80868477e-02f, -6.55444711e-02f, -1.25026321e-02f, -1.19120710e-01f, -1.03467070e-01f, -4.32890980e-03f, -5.67870550e-02f, -1.26025490e-02f,
  -9.71768349e-02f, -5.82828782e-02f, 5.90786412e-02f, -1.70654580e-02f, 1.86283644e-02f, -1.05272606e-01f, 1.73316356e-02f, 9.11362842e-02f, 8.20612386e-02f, 2.64226943e-02f,
  -2.10925385e-01f, 3.16973954e-01f, 1.35590360e-01f, -1.80975959e-01f, -8.42967164e-03f, -3.25132795e-02f, 5.70852160e-02f, 1.44519106e-01f, -9.16246325e-02f, 2.90234059e-01f,
  -7.27696419e-02f, 1.64234877e-01f, -9.05660540e-03f, -2.97700047e-01f, -4.35894281e-01f, -3.41378242e-01f, -2.87700504e-01f, -1.61741957e-01f, -1.77759126e-01f, 1.46387303e-02f,
  -1.19281642e-01f, -3.88465941e-01f, -2.43049979e-01f, 8.44842717e-02f, 9.75845456e-02f, 2.46939853e-01f, -8.19091052e-02f, 2.59952188e-01f, 3.31683643e-02f, -8.43977928e-02f,
  1.31373450e-01f, 1.63297467e-02f, 2.31260911e-01f, 6.04850203e-02f, 7.09719583e-02f, 4.92565781e-02f, 5.23729175e-02f, -5.78706227e-02f, 7.52621666e-02f, 3.69972251e-02f,
  9.28161107e-03f, -6.73233867e-02f, -7.52329379e-02f, -4.30647358e-02f, -1.92748401e-02f, 1.64734498e-02f, 8.37869123e-02f, 8.23134184e-02f, 1.32020833e-02f, 1.07740490e-02f,
  -4.60996628e-02f, 1.17633536e-01f, -6.92803636e-02f, -1.58746213e-01f, -2.87544299e-02f, 1.08079031e-01f, -8.41545910e-02f, 1.14859574e-01f, 9.64383930e-02f, -1.12115033e-01f,
  -1.55398548e-01f, -1.23878613e-01f, 5.80551997e-02f, 4.42481339e-02f, -6.70160130e-02f, 4.77241389e-02f, 2.01241788e-03f, 2.54807342e-03f, 7.98616111e-02f, 2.78691109e-02f,
  2.03758907e-02f, 3.67987007e-02f, -4.43136133e-02f, -1.92776337e-04f, -4.22231406e-02f, -2.35516410e-02f, -6.22244887e-02f, 4.85842489e-02f, -3.78082097e-02f, 6.42079338e-02f,
  1.90570671e-02f, -7.15334266e-02f, -3.95864919e-02f, 1.46810124e-02f, 4.27245582e-03f, 4.67854775e-02f, -2.78897341e-02f, -2.70423330e-02f, 1.12145334e-01f, -1.23441722e-02f,
  1.39009759e-01f, -1.81101620e-01f, 8.58787596e-02f, 1.43106893e-01f, -1.31402155e-02f, 3.36646847e-02f, -1.22226931e-01f, 4.25256267e-02f, -1.65432021e-02f, -1.03002444e-01f,
  -2.10858732e-02f, -9.25221387e-03f, 1.33129135e-01f, 1.25636142e-02f, -7.55646592e-03f, -2.58888621e-02f, -3.28244045e-02f, 4.92058098e-02f, 1.28686234e-01f, 8.98134056e-03f,
  1.03893280e-01f, -6.25294819e-02f, -1.59432784e-01f, -8.33603367e-02f, 3.25680561e-02f, 2.25298051e-02f, 1.00531869e-01f, 1.13690905e-01f, -1.54704332e-01f, -3.44288312e-02f,
  9.56001505e-02f, -3.78101557e-01f, -1.69432372e-01f, 3.66059721e-01f, -2.61873662e-01f, -1.30768791e-01f, 3.55333179e-01f, -2.38197207e-01f, 2.11670429e-01f, -1.60576925e-01f,
  2.03010604e-01f, -1.09811738e-01f, 3.21634114e-01f, 2.51354516e-01f, 2.88366705e-01f, 2.96792507e-01f, 1.45526007e-01f, 2.10199550e-01f, -5.39620519e-02f, -2.32542604e-01f,
  1.23736568e-01f, -8.01044181e-02f, 1.44659713e-01f, -5.04921377e-01f, -1.34856552e-01f, -2.54168808e-01f, -5.00027426e-02f, -1.46344438e-01f, -2.63295203e-01f, -8.04571435e-02f,
  -7.02000782e-02f, 7.83118233e-02f, 1.09345704e-01f, -1.18782483e-01f, 1.41288666e-02f, 6.98054954e-02f, 9.91834048e-03f, -6.74011605e-03f, 1.46845907e-01f, 4.72586378e-02f,
  -1.44148646e-02f, -6.02035457e-03f, -1.37990341e-01f, -2.59801019e-02f, -9.50855017e-03f, -1.25729591e-01f, 2.70530935e-02f, 1.16762169e-01f, -2.61811092e-02f, 6.94913566e-02f,
  3.14664245e-02f, 3.73366214e-02f, 1.14262819e-01f, 4.11632806e-02f, 6.18388094e-02f, 1.53468475e-01f, -6.93403697e-03f, -1.57660395e-02f, -1.68451592e-01f, 9.93069541e-03f,
  -3.12182233e-02f, -3.72075662e-02f, 2.71506514e-02f, -4.81142662e-02f, -3.28897908e-02f, -6.32377947e-03f, 3.51994368e-03f, -3.89653854e-02f, -1.75130758e-02f, -7.13613480e-02f,
  -1.29910111e-01f, -2.88702510e-02f, -4.23530154e-02f, -5.22619188e-02f, -5.26347198e-02f, 1.05728850e-01f, -1.52487149e-02f, -1.88511580e-01f, 3.68603766e-02f, 1.43796459e-01f,
  2.94320993e-02f, -2.39705257e-02f, -1.52851548e-02f, 2.27535293e-02f, 4.99756895e-02f, -1.72362197e-02f, 8.43054429e-02f, -8.08492005e-02f, 1.35378122e-01f, 7.58319721e-02f,
  -2.20521629e-01f, -4.49940979e-01f, -5.85697368e-02f, 7.96348613e-05f, -8.31127167e-02f, -6.78357184e-02f, 5.45187853e-03f, -4.51728664e-02f, -1.71382681e-01f, 2.37395428e-02f,
  -1.39076874e-01f, -2.38156598e-02f, -1.97714627e-01f, 2.87859011e-02f, -8.94802213e-02f, -2.07844973e-02f, -3.52303758e-02f, 3.56355198e-02f, -2.29354426e-02f, -1.54226005e-01f,
  2.55864989e-02f, -6.12366423e-02f, -6.48471639e-02f, -9.41446498e-02f, 7.37930648e-03f, -5.06043667e-03f, -3.85619327e-03f, -2.74314377e-02f, -1.25430346e-01f, 3.39146033e-02f,
  5.59196472e-01f, 2.55592287e-01f, 2.03814760e-01f, 2.35279545e-01f, -1.67790800e-01f, -4.69173491e-01f, -2.40215242e-01f, 2.03052700e-01f, 1.13449112e-01f, -5.22988103e-02f,
  -1.95058107e-01f, 4.23990488e-02f, -1.06087059e-01f, 1.71718732e-01f, -7.75439814e-02f, -1.47917643e-01f, 1.53799370e-01f, -1.59376681e-01f, 1.01219647e-01f, 2.91046321e-01f,
  3.31717908e-01f, 1.03781791e-02f, 3.25358927e-01f, 1.73411667e-01f, 2.75223643e-01f, 3.72515917e-01f, 8.71163830e-02f, -5.56028150e-02f, 2.10981313e-02f, -2.31689543e-01f,
  -7.41782337e-02f, 2.00341895e-01f, 7.48276263e-02f, -1.12930767e-01f, 1.03356123e-01f, 1.69145763e-02f, -7.81577602e-02f, -1.59648076e-01f, -2.69940626e-02f, -1.27942130e-01f,
  1.50018662e-01f, 5.30148819e-02f, -1.28271103e-01f, -1.69787288e-01f, 4.94647725e-03f, 1.01869442e-01f, 8.33719224e-02f, 2.95040552e-02f, 6.09830059e-02f, 1.26115844e-01f,
  3.40720788e-02f, 6.63310438e-02f, 8.70198384e-02f, -5.76288588e-02f, 1.44361794e-01f, -4.61763963e-02f, -4.74385843e-02f, -7.96699524e-02f, -1.13181345e-01f, 1.22673549e-01f,
  9.71149132e-02f, 5.54429218e-02f, -3.08578908e-02f, -2.89630815e-02f, -1.09536901e-01f, -1.94870494e-02f, -1.00978658e-01f, -1.19572148e-01f, 5.69910631e-02f, -8.84312615e-02f,
  -5.13519254e-03f, 1.02363162e-01f, -4.93809506e-02f, -9.00003910e-02f, 1.62527248e-01f, 1.78777978e-01f, -3.54829505e-02f, -7.96954557e-02f, -7.07159843e-03f, 2.83878688e-02f,
  -2.74032056e-02f, 4.55627292e-02f, -3.70679572e-02f, 6.19674437e-02f, -1.38895944e-01f, -1.09371357e-01f, 5.02391532e-02f, 3.81751321e-02f, 4.59766425e-02f, 1.52951060e-02f,
  -1.33787142e-02f, 1.33308932e-01f, -1.41386569e-01f, -2.30098814e-02f, -2.02617601e-01f, -1.58308133e-01f, -5.78585416e-02f, -8.31925496e-02f, -4.98068780e-02f, -2.18925849e-01f,
  1.30127952e-01f, 2.38304101e-02f, -5.89613356e-02f, -2.76762526e-02f, -2.67649163e-02f, -8.80593061e-02f, -6.57607168e-02f, -9.53357145e-02f, 5.81701286e-02f, 8.31080303e-02f,
  1.03107587e-01f, 2.66180579e-02f, -6.23285137e-02f, -7.41258487e-02f, -4.62003462e-02f, -3.17134857e-02f, -4.76138368e-02f, 2.85079330e-02f, 8.35106447e-02f, -1.05301954e-01f,
  4.01783556e-01f, -3.20238918e-01f, -2.50087947e-01f, 1.11423932e-01f, 4.24475819e-02f, 3.83830428e-01f, 4.46002781e-01f, 8.03945139e-02f, 1.93140149e-01f, -1.95125230e-02f,
  3.49668674e-02f, 8.97829607e-02f, -8.52480605e-02f, 1.95548490e-01f, 3.09286147e-01f, 6.16040379e-02f, 3.16312283e-01f, 2.02540100e-01f, -1.72932986e-02f, 1.00857228e-01f,
  1.04828335e-01f, 2.95875221e-01f, -1.12994567e-01f, -1.02991238e-01f, -3.87960337e-02f, -2.12450966e-01f, -2.16331124e-01f, -2.08804548e-01f, -6.14451729e-02f, 1.86766997e-01f,
  -2.41784565e-02f, -5.63021637e-02f, -3.79440673e-02f, 3.34462002e-02f, -2.69788131e-02f, -1.68304741e-02f, -1.72668453e-02f, -1.08320817e-01f, 7.76710734e-03f, 4.31903899e-02f,
  2.05326397e-02f, 1.29619120e-02f, 2.18963236e-01f, -1.07719265e-02f, 5.38177155e-02f, 7.30080158e-02f, -2.81488225e-02f, -1.93494886e-01f, 2.47837957e-02f, -1.07661195e-01f,
  -3.37053090e-02f, 1.88924056e-02f, -5.82194664e-02f, -3.18521112e-02f, -2.79073957e-02f, 2.90445574e-02f, -5.60312532e-02f, -1.63974702e-01f, -9.69607849e-03f, 2.74214987e-02f,
  3.92938219e-02f, -6.39818201e-04f, -1.26784012e-01f, -9.48478058e-02f, 1.00700080e-01f, -8.48490894e-02f, -7.84899294e-03f, 3.06607299e-02f, -5.57575412e-02f, -4.86802086e-02f,
  9.47031602e-02f, 9.78314551e-04f, 2.14842539e-02f, 6.95445240e-02f, 6.69035241e-02f, -6.23719506e-02f, -2.81756576e-02f, 5.93025647e-02f, -9.63103995e-02f, 4.60118114e-04f,
  -3.52809839e-02f, 9.73525830e-03f, -2.33789198e-02f, 3.79137881e-02f, 2.16277596e-02f, -1.19245142e-01f, -6.24057651e-02f, -8.18158761e-02f, 5.21487668e-02f, 1.48093989e-02f,
  -6.85867369e-02f, -5.26907407e-02f, 8.71387031e-03f, 4.15601730e-02f, -9.05873967e-05f, 4.16086838e-02f, -6.10875599e-02f, -2.87758885e-03f, 4.64653894e-02f, 1.42459482e-01f,
  -1.16559565e-01f, -1.52624622e-02f, 7.20374733e-02f, -8.55591968e-02f, -6.89650923e-02f, -3.77798676e-02f, 1.09829053e-01f, -3.37017663e-02f, 3.94551232e-02f, 6.84477612e-02f,
  -3.08143198e-02f, 4.00115587e-02f, -2.88257599e-02f, 4.20899168e-02f, -4.54460308e-02f, 9.17753801e-02f, 9.76016745e-02f, -2.76657119e-02f, -2.25970522e-02f, -4.66080345e-02f,
  1.60567969e-01f, 2.57890671e-01f, -2.08595753e-01f, -5.67077426e-03f, -2.68946022e-01f, -2.30598524e-01f, -3.09949815e-01f, -3.78166325e-02f, -1.84159264e-01f, 1.49191186e-01f,
  7.47092739e-02f, -2.00987846e-01f, 1.61979839e-01f, 8.76153708e-02f, -2.22971756e-02f, 4.22180027e-01f, -1.74373463e-01f, -1.96301565e-01f, -1.48943148e-03f, 2.01575726e-01f,
  1.51407838e-01f, 3.35773021e-01f, 2.62771815e-01f, 5.58426715e-02f, 6.48382083e-02f, 4.02409881e-02f, 3.02621514e-01f, 9.06752124e-02f, -1.76188678e-01f, -1.04432695e-01f,
  -1.63877569e-02f, 2.31702358e-01f, 1.07736737e-02f, -6.59466833e-02f, 1.13016918e-01f, -1.03019662e-01f, -7.80300871e-02f, 7.18594864e-02f, -6.70686290e-02f, -1.21724844e-01f,
  1.19999992e-02f, 5.55878095e-02f, -2.21877638e-02f, -7.76740015e-02f, -9.21746790e-02f, -1.27034932e-01f, 2.39470080e-02f, -2.51223385e-01f, 1.13111727e-01f, 1.00549005e-01f,
  1.44096455e-02f, -3.90910171e-02f, 7.50903413e-02f, 5.26009426e-02f, -8.45852122e-03f, -4.07966785e-02f, -4.72509079e-02f, -7.78781716e-03f, -4.94874120e-02f, -1.05692543e-01f,
  4.11490798e-02f, -1.08850159e-01f, 1.26219019e-01f, -1.06952541e-01f, 5.43903932e-02f, 4.45765816e-02f, 6.42091036e-03f, 2.93594059e-02f, 5.07652685e-02f, 1.33770332e-01f,
  -1.27832547e-01f, -4.85062525e-02f, 1.11082204e-01f, 2.09952407e-02f, 3.87664996e-02f, 7.05746636e-02f, -5.61593063e-02f, 7.41977021e-02f, -5.23001961e-02f, -7.25817680e-02f,
  4.96086664e-02f, -6.57154396e-02f, 1.45966215e-02f, -1.91519260e-02f, -8.42175260e-02f, 5.26313893e-02f, 1.08142579e-02f, 1.75788049e-02f, -1.50179774e-01f, -1.04372963e-01f,
  8.24515596e-02f, 3.41395229e-01f, 8.94628689e-02f, 2.23814566e-02f, 5.19758649e-02f, 7.96839520e-02f, 1.04061309e-02f, -1.17019609e-01f, -5.79824634e-02f, 8.36369619e-02f,
  7.62881935e-02f, 4.37939428e-02f, -1.18369430e-01f, 3.82828824e-02f, -1.74536988e-01f, -8.79991949e-02f, 7.84729719e-02f, -1.24682777e-01f, 2.47955043e-03f, 5.88057712e-02f,
  1.06379855e-02f, -1.30557260e-02f, 1.75339088e-01f, 4.37908396e-02f, -4.27959003e-02f, 1.07906520e-01f, -1.04094278e-02f, 1.09465476e-02f, 1.29938900e-01f, -1.30128384e-01f,
  1.19636044e-01f, -1.96071371e-01f, -4.01997298e-01f, -3.51413339e-01f, 3.13328981e-01f, 3.23561847e-01f, -4.77676988e-02f, -8.07746798e-02f, -2.82795668e-01f, 2.29773253e-01f,
  2.63644785e-01f, -9.56140831e-02f, -3.32809031e-01f, -4.84853834e-02f, 1.18890293e-01f, -2.24476621e-01f, 8.26550275e-02f, 6.24927543e-02f, -1.44317299e-01f, 4.55996431e-02f,
  -4.36056592e-02f, 3.71511430e-01f, -1.30043909e-01f, 2.41565153e-01f, 3.11107367e-01f, -1.47209853e-01f, 2.20875382e-01f, 6.02454785e-03f, 1.93742633e-01f, 2.31593624e-01f,
  5.14259785e-02f, -7.98093379e-02f, -2.81277075e-02f, -5.17371632e-02f, 4.67132330e-02f, 2.73220330e-01f, 7.84125775e-02f, 8.64980891e-02f, -4.26039565e-03f, -3.45199704e-02f,
  1.00549981e-02f, 8.45566392e-02f, -7.65589327e-02f, 4.72291522e-02f, -2.05013882e-02f, -8.16977844e-02f, 1.08570606e-02f, -1.72145907e-02f, -2.17859447e-01f, -5.04702190e-03f,
  -1.33878380e-01f, 2.59193890e-02f, -4.06239741e-02f, -5.56133613e-02f, -1.18266158e-01f, -4.26530913e-02f, -9.72331986e-02f, -1.39321992e-02f, -5.54722399e-02f, 1.45279178e-02f,
  8.84878561e-02f, 1.55235603e-01f, -1.03645496e-01f, -1.61200911e-01f, 2.95852069e-02f, 2.46896106e-03f, -7.73079768e-02f, -4.63160500e-02f, -5.30958967e-03f, 8.84350836e-02f,
  -4.66953702e-02f, -6.49561919e-03f, -5.79702370e-02f, 6.15272857e-02f, -1.48227103e-02f, -1.39508089e-02f, 7.67090246e-02f, 1.23813249e-01f, 5.65265957e-03f, -8.58514663e-03f,
  -4.99568209e-02f, -1.03103667e-01f, 3.12168170e-02f, -1.96694490e-02f, 7.43490234e-02f, 1.13507891e-02f, 3.91256064e-02f, 1.60008743e-01f, -1.70407239e-02f, 1.31865293e-01f,
  4.76775952e-02f, -1.77198071e-02f, -5.34265377e-02f, -1.22284181e-01f, -9.57944915e-02f, 4.38291468e-02f, 6.47275224e-02f, -4.26689573e-02f, 3.60090509e-02f, -4.65526944e-03f,
  1.58502206e-01f, 6.60026222e-02f, 8.09574053e-02f, -7.48725235e-02f, -1.04208328e-01f, 1.14256643e-01f, 1.39095327e-02f, -1.73097402e-02f, -2.19402346e-03f, 6.89631850e-02f,
  8.70421305e-02f, 9.04977173e-02f, -1.11677848e-01f, 5.70492521e-02f, 2.42295042e-02f, 1.13660820e-01f, 1.48774251e-01f, -1.21890768e-01f, 2.95565143e-04f, -1.77953646e-01f,
  -6.61550686e-02f, -2.32030764e-01f, -1.68167442e-01f, -1.50661618e-01f, 1.07305519e-01f, 3.19509357e-01f, 8.61651897e-02f, -7.05351159e-02f, -3.99355799e-01f, 6.33228272e-02f,
  2.70936098e-02f, -3.67707759e-01f, 1.15012534e-01f, -1.54428124e-01f, -1.25246227e-01f, -2.15840325e-01f, 3.92295755e-02f, -1.15224961e-02f, -6.47955686e-02f, 1.66479602e-01f,
  -5.66602461e-02f, 5.81103340e-02f, -4.18330431e-02f, 7.68233761e-02f, 6.11051507e-02f, 1.60245359e-01f, 1.66882902e-01f, 2.78873052e-02f, 7.19305053e-02f, -2.51914680e-01f,
  1.37069330e-01f, -5.66534847e-02f, -1.30994003e-02f, 2.90978737e-02f, 3.09580952e-01f, 2.49243394e-01f, 7.29646608e-02f, -1.63740478e-02f, -5.04434295e-02f, -1.04181796e-01f,
  -9.92546231e-02f, -1.06635317e-01f, -7.01486841e-02f, -1.93794504e-01f, -1.57038316e-01f, -8.93036053e-02f, 1.41326906e-02f, 1.10584346e-03f, -6.87425165e-03f, 1.31251160e-02f,
  -3.72592509e-02f, 6.29665470e-03f, -6.28714859e-02f, -4.90898825e-02f, -1.30276740e-01f, -6.58170879e-02f, 3.77411023e-02f, 1.45812228e-01f, -1.76209837e-01f, -8.88182968e-02f,
  -2.07773056e-02f, 1.79627210e-01f, 1.64781585e-01f, -7.98154548e-02f, 1.58548534e-01f, -6.40488416e-02f, -1.21587172e-01f, -1.09951384e-02f, -6.43272325e-02f, -7.74271926e-03f,
  1.17963381e-01f, -4.60931249e-02f, -1.87522575e-01f, 3.51609290e-02f, 1.55417278e-01f, -9.85397547e-02f, -6.64510438e-03f, 1.99232996e-02f, 5.44540845e-02f, 1.25110224e-01f,
  -1.21209569e-01f, 8.19911212e-02f, 5.02980165e-02f, -1.55848553e-02f, 2.04126276e-02f, 8.01910162e-02f, -6.94988146e-02f, -4.22787108e-02f, -3.04454770e-02f, -2.60970518e-02f,
  2.83858001e-01f, 1.77553874e-02f, 4.90558669e-02f, -3.25771272e-02f, 1.18445829e-01f, 2.84289777e-01f, 7.91960657e-02f, -1.30674005e-01f, 7.56500661e-02f, 5.81558496e-02f,
  1.62997499e-01f, 6.42445758e-02f, 3.83760743e-02f, -7.59144798e-02f, -2.03490257e-01f, 9.19061527e-02f, -1.90129112e-02f, 2.83701159e-02f, 1.24256089e-02f, -5.57110831e-02f,
  6.57718256e-02f, 1.69503853e-01f, -1.12146206e-01f, 4.84434627e-02f, -1.91382810e-01f, 5.19982353e-02f, 4.94219400e-02f, -6.14429601e-02f, -9.98923555e-02f, 1.62197426e-02f,
  2.37340063e-01f, -2.68807653e-02f, 2.22634614e-01f, 1.58540264e-01f, -1.14815891e-01f, -1.54417768e-01f, 9.14153382e-02f, -3.28547627e-01f, -2.28669986e-01f, -3.43985260e-02f,
  -2.11586386e-01f, 4.27267939e-01f, -1.81981456e-02f, -2.10087344e-01f, 1.50076086e-02f, -1.71320513e-01f, -1.52519584e-01f, 6.54245242e-02f, -1.52631298e-01f, -6.10933937e-02f,
  -1.24326594e-01f, -3.51343721e-01f, -2.71178111e-02f, -4.15317416e-01f, 1.28952757e-01f, 6.31760582e-02f, -2.63642222e-01f, 8.26540142e-02f, -2.05469169e-02f, 1.05052220e-03f,
  -3.51159871e-02f, -1.37355417e-01f, 1.29808217e-01f, 1.02315759e-02f, 1.00306179e-02f, 5.27310371e-02f, 1.49814516e-01f, 6.01968244e-02f, 2.63428409e-02f, 5.43693192e-02f,
  8.91757756e-02f, -8.62886384e-02f, -9.27023590e-02f, -4.30460647e-02f, -1.17390873e-02f, -5.55103719e-02f, 7.98579454e-02f, 8.57905969e-02f, 4.41419221e-02f, 2.00835034e-01f,
  1.68362796e-01f, 1.83330253e-01f, -2.25431770e-02f, 1.23247787e-01f, 8.91793221e-02f, -4.94534187e-02f, 8.78130123e-02f, 2.58901238e-01f, 1.89775422e-01f, 1.44135468e-02f,
  -1.03325844e-01f, 1.42453909e-02f, -4.87387665e-02f, -4.92962077e-02f, -5.55816442e-02f, -8.08611512e-02f, -3.32544371e-02f, -7.75633147e-03f, 5.61193638e-02f, -3.58679704e-02f,
  -2.52516232e-02f, 3.78839858e-03f, -1.64472178e-01f, -1.73940662e-05f, 9.91267432e-03f, 1.13457004e-02f, 1.46312350e-02f, 3.83757837e-02f, -3.69306169e-02f, -7.62575679e-03f,
  -9.04645324e-02f, 2.29806025e-02f, -8.16943496e-02f, -3.22600193e-02f, -4.29108068e-02f, 8.40142369e-02f, -1.00272633e-01f, 2.74586137e-02f, -1.69507876e-01f, 1.64660290e-02f,
  -1.81923747e-01f, -2.92095929e-01f, -7.90289938e-02f, -4.33066525e-02f, -9.41541791e-02f, 4.52196375e-02f, -1.05941229e-01f, -1.79943889e-02f, -3.22088450e-02f, -9.12613496e-02f,
  -1.54322367e-02f, 4.17972580e-02f, -1.62651844e-03f, 1.19742997e-01f, -2.19364613e-02f, -1.68390378e-01f, 5.31680807e-02f, 6.76949248e-02f, -4.38584350e-02f, -8.18966422e-03f,
  3.14086638e-02f, -8.51835532e-04f, -2.52966094e-03f, -3.01001724e-02f, -8.78572017e-02f, 8.28464553e-02f, -1.31626464e-02f, 2.06531882e-02f, 7.09643811e-02f, 6.03256300e-02f,
  -1.26034245e-01f, -2.02259398e-03f, -1.83344021e-01f, -2.65405625e-01f, 8.73940215e-02f, -2.60445356e-01f, -1.92105412e-01f, -7.40257949e-02f, 1.78745240e-01f, 1.98751166e-02f,
  -5.41364364e-02f, 2.15909436e-01f, 3.34246814e-01f, -1.73932299e-01f, -1.73964113e-01f, 2.45970532e-01f, -2.96002239e-01f, -2.33786702e-01f, 1.08923160e-01f, -1.92374989e-01f,
  -1.71181902e-01f, -1.18397139e-01f, -7.29225278e-02f, -8.08064267e-02f, -2.29436785e-01f, -4.88810726e-02f, -3.58430147e-02f, 2.61085123e-01f, -2.82843560e-01f, 2.10806102e-01f,
  -2.80786186e-01f, -2.03427188e-02f, -2.40634028e-02f, -1.15257002e-01f, -2.26744741e-01f, -7.77288079e-02f, -3.58978920e-02f, 1.49856433e-01f, 9.00094584e-02f, -2.90297214e-02f,
  9.54984426e-02f, -1.69573259e-02f, -4.82042432e-02f, 2.17625007e-01f, -6.84562400e-02f, 7.64492080e-02f, 3.87553982e-02f, -1.39674395e-01f, -1.02275489e-02f, 2.65104510e-02f,
  -1.05870971e-02f, -1.49151057e-01f, -4.32909206e-02f, -1.34073362e-01f, -1.57454126e-02f, -1.31906953e-03f, -7.55554363e-02f, 2.10833699e-02f, -2.05147415e-01f, -1.44342571e-01f,
  8.37038830e-02f, 5.92584983e-02f, 2.11265534e-02f, -2.24734992e-02f, -5.27296960e-03f, 1.85727384e-02f, 4.76632752e-02f, -2.50755250e-02f, 1.15275038e-02f, -4.26787250e-02f,
  -7.21509159e-02f, 1.56296534e-03f, 5.38133495e-02f, 2.59641949e-02f, -4.39898856e-03f, 6.92880759e-03f, -1.69813782e-02f, -8.67711380e-02f, -1.52550474e-01f, -8.37779045e-02f,
  1.79360416e-02f, -4.75239754e-02f, 1.23736903e-01f, -4.40115109e-02f, -7.68687502e-02f, 5.75014092e-02f, -7.88741782e-02f, -1.20713219e-01f, 8.12413916e-02f, 4.86817621e-02f,
  -3.59131694e-01f, -3.21689695e-01f, 6.51664734e-02f, -8.32925662e-02f, 1.07840769e-01f, -3.01560368e-02f, -3.04047186e-02f, -6.10527992e-02f, -3.38967666e-02f, -1.57064870e-02f,
  -1.26319438e-01f, -3.00818905e-02f, -1.88791990e-01f, -7.21936114e-03f, -1.09202391e-03f, -9.42902192e-02f, 4.73658033e-02f, -8.71836394e-02f, -1.13260195e-01f, 4.67195287e-02f,
  -8.63135904e-02f, 7.26622939e-02f, 6.88310564e-02f, 8.13727826e-02f, 3.17618288e-02f, 3.26207802e-02f, -6.41407296e-02f, 1.60696998e-01f, -5.78638203e-02f, -9.05413106e-02f,
  2.66852260e-01f, -4.79326874e-01f, -3.47319007e-01f, 6.07488379e-02f, 3.66422296e-01f, 2.71967828e-01f, 1.71458587e-01f, -1.46627305e-02f, -1.71583951e-01f, -2.19596654e-01f,
  2.07117915e-01f, -6.37281612e-02f, -2.34525710e-01f, 1.06322594e-01f, 4.41262186e-01f, -1.54332951e-01f, 1.48793399e-01f, 5.53739965e-02f, -5.06140552e-02f, 3.40923015e-03f,
  1.02866381e-01f, 3.57860267e-01f, -6.42355764e-03f, -3.78248394e-02f, 2.85697699e-01f, -3.16693544e-01f, -6.09672517e-02f, -7.66149908e-02f, 1.39873289e-02f, 1.69431135e-01f,
  1.22128241e-01f, 6.73486665e-02f, 6.09499589e-02f, 3.31322551e-02f, 2.77826991e-02f, 1.07037023e-01f, -5.75544573e-02f, 6.44293660e-03f, 3.33449803e-02f, 5.63605130e-02f,
  2.04752199e-02f, 8.32458362e-02f, -1.39620185e-01f, 5.89435063e-02f, -1.24380207e-02f, 8.23966414e-02f, -4.06876169e-02f, 9.49371457e-02f, -1.31341726e-01f, -1.66076433e-03f,
  -6.27268553e-02f, -1.35397285e-01f, 4.35788669e-02f, -9.41096246e-02f, -1.41614586e-01f, -4.58228998e-02f, -6.06039986e-02f, -3.47307697e-02f, -1.42046824e-01f, 1.08450681e-01f,
  -7.36236107e-03f, -1.11934487e-02f, 3.28784436e-02f, 4.73327877e-04f, -7.18274328e-04f, -1.43959932e-02f, 1.58197343e-01f, 2.62178890e-02f, -1.11566536e-01f, 2.35454477e-02f,
  -5.91849685e-02f, 1.19493879e-01f, 7.18021765e-02f, 9.93587673e-02f, 9.12627652e-02f, -8.59297067e-03f, 3.03705819e-02f, -1.35119736e-01f, -7.51412064e-02f, 4.12902199e-02f,
  -5.96726798e-02f, 2.76828650e-04f, 3.17046233e-02f, -6.48988411e-02f, -2.24827025e-02f, 6.77094460e-02f, -4.95344810e-02f, -1.67708844e-02f, 2.69672647e-02f, 1.95781477e-02f,
  -5.21348976e-02f, -2.85853863e-01f, -8.19042549e-02f, -1.05925925e-01f, -8.94519389e-02f, 1.16665326e-01f, 1.02943433e-02f, -4.77117933e-02f, -5.29824235e-02f, 1.47793293e-01f,
  5.56547344e-02f, -1.08914703e-01f, -1.18894093e-01f, 5.62358387e-02f, -8.85574296e-02f, -6.57306686e-02f, -2.39685830e-02f, 2.49226633e-02f, -6.60503209e-02f, -1.45424888e-01f,
  -8.02476034e-02f, -4.08817492e-02f, 6.53249994e-02f, 3.34397256e-02f, 1.83933633e-04f, 7.65291750e-02f, 5.96078932e-02f, -5.54361716e-02f, -1.03777073e-01f, -4.36834432e-02f,
  -2.83386737e-01f, -1.68216884e-01f, 9.61262658e-02f, 7.54924640e-02f, 6.12342581e-02f, -2.38116533e-01f, -4.12620038e-01f, -2.71858796e-02f, -2.59140640e-01f, -3.30597639e-01f,
  -2.47914612e-01f, -1.98171243e-01f, -2.49435812e-01f, 1.48384690e-01f, 3.98734838e-01f, 1.28150871e-02f, 4.19267356e-01f, 9.27083120e-02f, 1.74593851e-01f, 2.38780901e-01f,
  2.95512378e-01f, 3.42295170e-01f, 3.58858258e-01f, 3.15791637e-01f, 1.34627134e-01f, 1.46353692e-01f, 2.08256379e-01f, 5.56114130e-02f, 1.80600643e-01f, 1.76194996e-01f,
  -7.99394213e-03f, -7.09634945e-02f, 4.44106422e-02f, 9.95413885e-02f, 8.37334525e-03f, -1.75128892e-01f, -8.50136131e-02f, 1.24544287e-02f, 1.61089785e-02f, -3.17266509e-02f,
  -7.54366964e-02f, 9.43356529e-02f, 1.14795692e-01f, 1.20266015e-03f, 6.18523993e-02f, 2.30762083e-02f, 8.80053714e-02f, 1.73439253e-02f, -3.91115464e-05f, -2.91321147e-02f,
  4.44060862e-02f, 4.32686545e-02f, -5.39844036e-02f, 4.90710475e-02f, -4.62769950e-03f, 1.75347063e-03f, -9.98886898e-02f, -7.30323568e-02f, -1.06591294e-02f, 1.20240636e-03f,
  -3.86941992e-02f, -3.89511585e-02f, -5.73960878e-02f, -2.60702800e-02f, -2.34879963e-02f, 4.72446568e-02f, 5.80147095e-02f, -1.11180246e-02f, -3.71770374e-02f, -1.34825736e-01f,
  -6.14452548e-02f, -5.67869917e-02f, -1.85904447e-02f, -2.14223703e-03f, -1.75107475e-02f, 3.91555615e-02f, 5.25725596e-02f, -1.84263512e-02f, -2.00278759e-02f, -2.44207475e-02f,
  -1.40813831e-02f, 1.01614915e-01f, 2.55865008e-02f, 1.02532998e-01f, 2.84824260e-02f, -8.00024420e-02f, -1.24769816e-02f, -1.01764105e-01f, -6.17256686e-02f, -2.97467019e-02f,
  -6.12355024e-02f, 1.77157149e-01f, 1.65246576e-02f, 5.67253353e-03f, 3.26085975e-03f, -8.44630413e-03f, 1.26196936e-01f, 1.39294490e-01f, -1.97528508e-02f, -1.32167935e-01f,
  -5.23281395e-02f, -7.82236308e-02f, -9.16131958e-02f, -9.53424838e-04f, 1.19916432e-01f, -6.36177659e-02f, 2.81177741e-02f, -8.00046399e-02f, -4.12887521e-02f, 1.38350084e-01f,
  2.98195817e-02f, -2.01264825e-02f, 1.96185173e-03f, 7.11149648e-02f, 1.10639602e-01f, -1.75644025e-01f, -6.41444325e-02f, 3.64057235e-02f, -1.30874766e-02f, 1.65382749e-03f,
  -4.21005227e-02f, 4.37117815e-01f, 4.86894697e-01f, 4.19674873e-01f, -3.36212099e-01f, -3.13206524e-01f, 3.43688160e-01f, -1.81408394e-02f, 3.59808445e-01f, 4.14127409e-02f,
  -2.22863361e-01f, 2.64831692e-01f, -1.94650143e-02f, 2.32886523e-01f, 4.43142392e-02f, 2.59354442e-01f, 2.07299054e-01f, 9.13805738e-02f, -2.36947481e-02f, 1.23316109e-01f,
  7.74153918e-02f, -2.03558728e-01f, 2.95198262e-01f, -1.82781667e-01f, 4.67053205e-02f, 1.80253163e-01f, 9.73467380e-02f, 6.04590960e-02f, 2.22564191e-02f, -1.70759678e-01f,
  7.73728937e-02f, 1.41805589e-01f, -7.35066039e-03f, -1.60833877e-02f, 1.22180104e-01f, -1.11781292e-01f, 9.05949902e-03f, 7.22214160e-03f, -6.37288615e-02f, 9.92807969e-02f,
  5.37646636e-02f, -1.43217072e-01f, 7.44063780e-02f, 1.50304260e-02f, -5.64638563e-02f, 1.42999068e-01f, 4.48434874e-02f, -1.78821851e-02f, -4.17250879e-02f, -1.40565252e-02f,
  2.59871501e-02f, -1.48715097e-02f, -1.12689100e-02f, 1.32276386e-04f, 5.94788650e-03f, 1.73852649e-02f, 2.37583984e-02f, 9.05104429e-02f, -1.20458901e-02f, 7.66207650e-02f,
  -1.87794670e-01f, 6.71979338e-02f, 1.50488317e-01f, 5.23984320e-02f, -4.49097194e-02f, -7.71022737e-02f, -2.79783141e-02f, 4.86038700e-02f, 1.45889008e-02f, 4.97325100e-02f,
  8.17095637e-02f, 4.35626507e-02f, -4.84945923e-02f, 7.44518684e-03f, -5.78299239e-02f, 8.09260756e-02f, -6.75566345e-02f, 1.19735198e-02f, -2.63139363e-02f, -2.14991253e-02f,
  8.91983360e-02f, -7.07313567e-02f, 6.08720183e-02f, -3.41550745e-02f, 4.99730073e-02f, 7.73406308e-03f, -4.07799743e-02f, 3.87293026e-02f, 7.66247883e-02f, -2.04230011e-01f,
  8.75474438e-02f, 2.62583196e-01f, -2.98610087e-02f, -6.02940209e-02f, 1.08353578e-01f, -2.99181659e-02f, 5.03310747e-02f, 8.72387886e-02f, 7.40923733e-02f, -1.22770824e-01f,
  1.51617581e-03f, 9.55062509e-02f, 7.97623023e-03f, -9.53983739e-02f, -1.65557608e-01f, 2.10244283e-02f, 2.00113907e-01f, 6.33646995e-02f, -5.78337349e-03f, -1.94642190e-02f,
  -8.21003765e-02f, -5.09810038e-02f, -3.15799676e-02f, 2.05989722e-02f, -1.10274248e-01f, -4.23350856e-02f, -1.46316681e-02f, -1.21789135e-01f, 4.07344960e-02f, -3.08252368e-02f,
  2.29507908e-02f, -3.76415960e-02f, 2.76245415e-01f, 3.99358273e-01f, 2.24821329e-01f, -2.17462227e-01f, 7.61449039e-02f, 3.48341584e-01f, 5.69613039e-01f, -2.45708264e-02f,
  2.59827543e-02f, -2.39809841e-01f, 1.81153193e-01f, 2.02533513e-01f, -4.58465487e-01f, -1.75007135e-02f, -3.20449829e-01f, 4.70890896e-03f, 1.44855976e-01f, 2.61892341e-02f,
  -3.53129320e-02f, -1.03221372e-01f, 3.12922299e-02f, 4.05340567e-02f, 1.71931937e-01f, 1.13190576e-01f, -3.04539859e-01f, 8.14718679e-02f, -1.52317747e-01f, -1.68703273e-01f,
  3.62374187e-02f, 3.84136260e-01f, 8.49535540e-02f, 9.07766148e-02f, -3.85509692e-02f, -1.82506680e-01f, -1.39098661e-02f, 7.06846341e-02f, 1.41380027e-01f, 9.87734050e-02f,
  -3.15431855e-03f, 1.88702904e-02f, 1.01820722e-01f, 1.90240994e-01f, 1.34459764e-01f, 6.80773705e-02f, 1.59206808e-01f, -2.09414065e-02f, 1.63257167e-01f, -1.20655093e-02f,
  1.43748894e-01f, 1.40218154e-01f, 7.36465212e-03f, -1.86014056e-01f, 9.20811966e-02f, 7.98495114e-02f, -9.00892466e-02f, -1.76599786e-01f, 2.88789859e-03f, -1.42378554e-01f,
  -1.51702642e-01f, -5.89507446e-02f, 1.59783974e-01f, -1.43752638e-02f, 9.41453204e-02f, 1.52307481e-01f, 3.22661847e-02f, -1.14952372e-02f, -1.81450285e-02f, -2.29466446e-02f,
  -1.63731113e-01f, 4.67470400e-02f, 8.97809267e-02f, 9.09748450e-02f, -1.67783629e-02f, 1.46195935e-02f, -2.50059694e-01f, 4.01554108e-02f, -5.14825694e-02f, -1.98265836e-01f,
  7.77998427e-03f, -3.08422875e-02f, -1.22539420e-02f, -3.07490285e-02f, 1.16853885e-01f, 1.15773901e-01f, 1.12276651e-01f, 2.33364463e-01f, 7.07900822e-02f, -1.24228984e-01f,
  -1.72336757e-01f, -1.48494765e-01f, 9.10628363e-02f, 1.52600065e-01f, 3.50690819e-02f, 3.01902443e-02f, 1.98801011e-02f, -4.08612415e-02f, -2.94058844e-02f, 3.97934020e-02f,
  -5.05476855e-02f, 1.30762532e-01f, -4.63894345e-02f, -6.05890825e-02f, -2.52692670e-01f, 5.13542332e-02f, -9.70892310e-02f, -4.88241427e-02f, -2.05699250e-01f, -2.19429016e-01f,
  -6.41995743e-02f, -4.54642139e-02f, -5.95226027e-02f, 1.13370731e-01f, -1.92884952e-01f, -1.08766109e-01f, -1.96626410e-01f, -5.68622723e-04f, -4.72949222e-02f, -2.04694524e-01f,
  -5.09746969e-01f, 2.57162511e-01f, -1.01287916e-01f, -2.72332996e-01f, -3.02244704e-02f, 2.92703927e-01f, 6.06169477e-02f, 7.73542672e-02f, -3.88028443e-01f, 2.38754228e-01f,
  1.92771107e-01f, -3.21653396e-01f, 2.69490749e-01f, 3.69469911e-01f, -1.87620744e-01f, 2.25989088e-01f, 2.12260395e-01f, 1.88628212e-01f, -1.29401520e-01f, -1.72127381e-01f,
  -9.40032080e-02f, 1.27644584e-01f, 7.82324895e-02f, 9.80105698e-02f, 3.72926146e-02f, -1.46802858e-01f, 1.39973879e-01f, -9.26825181e-02f, 1.64398000e-01f, -2.31951918e-03f,
  -6.46780729e-02f, -3.03428411e-01f, 5.68564469e-03f, -1.51316494e-01f, -5.08440845e-02f, -3.92175876e-02f, -4.25154530e-02f, -2.20318083e-02f, -1.63875997e-01f, -1.38907973e-03f,
  -1.54839694e-01f, 3.77750816e-03f, -3.90243232e-02f, -1.05361298e-01f, 8.14870466e-03f, -9.88630578e-02f, 1.51928723e-01f, 1.21550485e-01f, 6.01336993e-02f, -3.66442800e-02f,
  5.87143488e-02f, 8.70171711e-02f, 2.33554408e-01f, 1.61725998e-01f, -4.03848663e-02f, 9.80610214e-03f, 1.04644537e-01f, 2.73351129e-02f, 1.16143167e-01f, 2.11445317e-02f,
  -8.75694975e-02f, 4.83365282e-02f, 5.78231774e-02f, 5.09790778e-02f, 1.14862295e-02f, 5.39492350e-03f, 1.59131140e-01f, 7.59371743e-02f, -1.35341942e-01f, -1.44744329e-02f,
  -7.97161311e-02f, 2.38333307e-02f, -1.11757591e-01f, -5.35683706e-02f, 3.57464068e-02f, -1.89460851e-02f, -1.10762484e-01f, 1.77536644e-02f, -7.05516040e-02f, 1.32487519e-02f,
  -6.89062104e-02f, -1.58349154e-04f, -1.36931583e-01f, 3.55405807e-02f, 2.22908519e-02f, -4.85585667e-02f, 1.18522011e-02f, -2.22899504e-02f, 7.14049414e-02f, 2.60151345e-02f,
  9.18844789e-02f, -2.43153617e-01f, -2.98124645e-02f, -3.89268845e-02f, -6.63344562e-02f, 7.08385184e-02f, 3.12214792e-02f, 3.80489603e-03f, 1.56344771e-02f, -5.77789620e-02f,
  6.27717227e-02f, -8.77836253e-03f, 1.28657194e-02f, -1.38874188e-01f, -9.70364641e-03f, 9.40874666e-02f, -9.98762473e-02f, -7.69032016e-02f, 5.62204085e-02f, -4.99435961e-02f,
  -1.30631551e-01f, -8.30975920e-02f, 9.76919904e-02f, 4.10568938e-02f, 1.18795834e-01f, 9.53273773e-02f, -9.17567033e-03f, -9.34460759e-02f, 9.66416299e-02f, 1.04676850e-01f,
  9.52280965e-03f, 6.00980595e-02f, -1.35938466e-01f, -1.47154421e-01f, -1.81333736e-01f, -9.43116918e-02f, -1.04532197e-01f, -6.12379275e-02f, 4.27633494e-01f, 1.20611511e-01f,
  -1.09337471e-01f, 1.56874567e-01f, 5.43444658e-05f, -3.31527591e-01f, 9.16237757e-02f, 2.17977107e-01f, -1.85679123e-01f, 1.87771011e-03f, 1.44416764e-01f, -1.42618909e-01f,
  -1.12367250e-01f, -1.30462289e-01f, -3.58913213e-01f, -1.16909765e-01f, -7.17775747e-02f, -4.74192910e-02f, -1.86390996e-01f, -6.45413175e-02f, -1.71053246e-01f, -4.12091129e-02f,
  -9.40664634e-02f, 4.63671088e-02f, -2.15878859e-01f, 8.09438750e-02f, -3.04049458e-02f, -7.27379620e-02f, -2.18010396e-02f, 2.95431563e-03f, -5.76185621e-02f, 7.62428641e-02f,
  1.34046197e-01f, 1.03236042e-01f, -3.48332748e-02f, -5.56304790e-02f, -2.31561773e-02f, -9.46731642e-02f, -2.75336578e-02f, 1.94556464e-03f, -7.07874447e-03f, -1.79645076e-01f,
  -1.94877937e-01f, -1.39894292e-01f, 1.13191167e-02f, 1.69452593e-01f, -6.08084090e-02f, 1.57959796e-02f, -5.23632318e-02f, -9.33879614e-02f, -4.35617566e-02f, 1.39997110e-01f,
  -7.51383677e-02f, 4.45986874e-02f, -1.62886381e-02f, 5.08837588e-02f, -1.28530257e-03f, -6.21006601e-02f, -7.06765894e-03f, -1.75597297e-03f, 1.75307468e-02f, -8.05826411e-02f,
  6.73451349e-02f, -1.23387061e-01f, 2.58859713e-02f, -1.52444271e-02f, 1.17247753e-01f, 1.44302160e-01f, -5.06571829e-02f, 3.16085666e-02f, 6.76166192e-02f, 4.27715573e-03f,
  1.31182838e-02f, 5.13605773e-02f, -1.25587374e-01f, -5.05868457e-02f, -8.76362529e-03f, 4.76264097e-02f, -4.31564376e-02f, 6.05166983e-03f, -2.19702702e-02f, -3.96966748e-02f,
  2.30868328e-02f, 3.11312467e-01f, -4.91024218e-02f, -8.48194361e-02f, -2.61415299e-02f, -8.07623118e-02f, 8.98360312e-02f, 1.86586436e-02f, 1.78150043e-01f, 6.56714886e-02f,
  -6.07289411e-02f, 9.03962031e-02f, -4.90727685e-02f, -6.75097778e-02f, -2.84131966e-03f, 6.67773560e-02f, 1.78308710e-01f, 6.11538179e-02f, 8.23386312e-02f, -1.61879748e-01f,
  -2.30456740e-01f, 7.60769174e-02f, 5.69110103e-02f, 1.65261957e-03f, 6.07832484e-02f, 5.01810275e-02f, 9.72795412e-02f, -6.91720692e-04f, 7.46136680e-02f, 3.08025610e-02f,
  -2.74378330e-01f, 2.97814131e-01f, -2.37065017e-01f, -1.99398939e-02f, 3.37741196e-01f, -5.73194206e-01f, -1.77555963e-01f, 3.49231899e-01f, 8.70331600e-02f, 1.75196111e-01f,
  1.51124865e-01f, -9.55711827e-02f, 2.46653005e-01f, -3.68155867e-01f, -3.19277287e-01f, -3.69160652e-01f, -2.23459005e-01f, -4.04536486e-01f, 4.39143404e-02f, 1.97685689e-01f,
  -3.62190492e-02f, 2.57013351e-01f, -5.14440238e-02f, 4.78296816e-01f, 1.60350949e-01f, 1.24771275e-01f, 4.25328791e-01f, 1.61741406e-01f, -1.35759458e-01f, -3.83883156e-02f,
  -2.40308866e-01f, 1.80871904e-01f, 8.92352872e-03f, -6.01967275e-02f, -7.82147422e-03f, 2.95503009e-02f, -1.21827029e-01f, 3.20367934e-03f, -3.20824236e-02f, -1.38055477e-02f,
  2.59111468e-02f, 3.20603102e-02f, -3.65640596e-02f, 1.20391369e-01f, -9.48738679e-03f, 8.42736587e-02f, -1.30877972e-01f, -1.54793084e-01f, 1.48024648e-01f, -1.70002088e-01f,
  -1.28190592e-01f, -1.94639936e-01f, 6.00064872e-03f, -1.05746947e-01f, -1.05433457e-03f, 2.22193580e-02f, -9.22270641e-02f, -1.22895576e-01f, -6.51175529e-02f, -1.07600741e-01f,
  1.80843119e-02f, 1.31044062e-02f, 1.08522974e-01f, 1.03685729e-01f, 9.03072581e-02f, 5.72239421e-02f, 1.12899132e-02f, -2.28100438e-02f, 2.41236500e-02f, -3.01352367e-02f,
  -2.17989143e-02f, 2.18467992e-02f, 6.84322789e-02f, -4.91613485e-02f, -2.17101742e-02f, 1.47559876e-02f, -4.17961031e-02f, -2.88565028e-02f, 2.15771385e-02f, -4.19814959e-02f,
  1.40038148e-01f, -1.05853215e-01f, 8.47819000e-02f, -3.49984020e-02f, -1.47174485e-02f, 3.00445650e-02f, 1.13453798e-01f, -1.24437399e-01f, -7.23199919e-02f, 1.30520016e-01f,
  -3.27379778e-02f, 2.65221953e-01f, 1.63366243e-01f, 8.56000558e-03f, -6.82766289e-02f, -1.65397907e-03f, -1.17667437e-01f, -1.01631083e-01f, 1.48070440e-01f, 9.89282653e-02f,
  -1.31185837e-02f, 6.96619228e-02f, -5.88025674e-02f, -4.58688140e-02f, -1.00577600e-01f, 9.14368182e-02f, 5.07586077e-02f, -2.01702006e-02f, 1.32886961e-01f, -2.81505603e-02f,
  1.47013351e-01f, 2.73325536e-02f, 2.74996981e-02f, 1.27662703e-01f, 2.31540259e-02f, -9.94224772e-02f, 6.69241250e-02f, 7.56671876e-02f, 1.81818418e-02f, 6.10374212e-02f,
  3.80962580e-01f, -4.91069376e-01f, 1.84694484e-01f, 3.05195481e-01f, 2.52475291e-01f, 2.02083990e-01f, 3.15566391e-01f, -5.63258156e-02f, 2.88051665e-01f, -2.99929559e-01f,
  -1.24816932e-01f, -9.00665149e-02f, -1.47783369e-01f, -5.41820627e-05f, 4.19228226e-01f, -1.13554023e-01f, 1.40848890e-01f, 1.72596686e-02f, 7.35709071e-02f, 1.08685941e-01f,
  1.34269640e-01f, -3.56114283e-02f, 2.00683088e-03f, -2.56563395e-01f, -2.51564328e-02f, 2.34525301e-03f, -2.23061353e-01f, 1.80867940e-01f, -2.59163201e-01f, 1.88418284e-01f,
  1.59518700e-02f, 3.30206677e-02f, -3.28081511e-02f, -1.42247742e-03f, -1.12061650e-01f, 5.55413365e-02f, -6.97119907e-03f, 1.58502683e-01f, 2.28675157e-01f, 3.41026555e-03f,
  -2.64672022e-02f, 5.16455062e-02f, -4.95182797e-02f, 1.56083077e-01f, 1.40620276e-01f, 1.43596549e-02f, -3.43274735e-02f, -4.81863990e-02f, -4.49897200e-02f, -4.18666676e-02f,
  -7.09976256e-02f, -7.72408694e-02f, 3.83954979e-02f, -2.76992228e-02f, -9.54279006e-02f, 3.90556566e-02f, 8.47383440e-02f, 7.44319409e-02f, -8.36267024e-02f, 4.54232953e-02f,
  -1.36766240e-01f, -3.40759382e-02f, -7.73051754e-02f, 1.12876765e-01f, -2.38495190e-02f, 3.93575579e-02f, 5.34340851e-02f, -7.08647370e-02f, -5.14843054e-02f, -1.42139941e-02f,
  9.27583799e-02f, 1.08008571e-02f, -1.63976923e-02f, 9.34980661e-02f, 3.52383405e-02f, -5.39287068e-02f, 7.44013488e-02f, -6.74274638e-02f, -6.14188313e-02f, 2.22192034e-02f,
  7.57396445e-02f, 1.47869512e-01f, -1.75666176e-02f, 6.59629330e-02f, 1.16418220e-01f, -3.24721895e-02f, 2.22021695e-02f, 5.25661334e-02f, 4.58684005e-03f, -9.20792110e-03f,
  -1.32772207e-01f, -3.19523931e-01f, -8.46392214e-02f, -7.17184916e-02f, -1.03106134e-01f, -1.19698450e-01f, 4.50372398e-02f, 2.96668168e-02f, 5.90523984e-03f, 6.50553703e-02f,
  -6.72511980e-02f, -1.77373346e-02f, -9.45202783e-02f, 8.23841617e-02f, -6.92112520e-02f, -1.26655370e-01f, 4.46619764e-02f, -1.69963539e-01f, 8.22665319e-02f, -7.78847933e-02f,
  4.17847484e-02f, 1.08709514e-01f, -5.10567650e-02f, -7.81871453e-02f, -2.60493066e-02f, -3.39511260e-02f, -2.84821671e-02f, -2.89796330e-02f, -1.38339847e-02f, 3.79491504e-03f,
  -5.39115608e-01f, 3.73787612e-01f, 4.25204247e-01f, -4.50799555e-01f, 2.64825016e-01f, 4.71656650e-01f, -1.85182184e-01f, 2.45268077e-01f, -1.84335828e-01f, -1.25426605e-01f,
  -2.38961801e-01f, 1.87351108e-01f, 9.94989276e-02f, -1.98196352e-01f, -8.53312854e-03f, 9.15570483e-02f, -1.79237068e-01f, -1.87647074e-01f, 8.67976472e-02f, 6.50197715e-02f,
  2.43842565e-02f, -1.73664585e-01f, -1.03218064e-01f, 1.08865783e-01f, 3.08065694e-02f, -2.30307207e-02f, -3.14130366e-01f, 2.05933765e-01f, -2.53781736e-01f, -3.00476477e-02f,
  -9.92550794e-03f, -2.62679935e-01f, 1.15092769e-01f, 4.50835451e-02f, -3.61046055e-03f, 6.62284642e-02f, -1.49135720e-02f, -8.29095244e-02f, -6.73295930e-02f, 1.78611558e-02f,
  1.22607974e-02f, 1.41141057e-01f, -1.56412348e-02f, 3.74449492e-02f, 4.58313003e-02f, 8.68381176e-04f, 1.22566521e-01f, 4.30544913e-02f, 2.15680525e-02f, 7.43811131e-02f,
  2.09886938e-01f, 2.18617126e-01f, 4.10584994e-02f, -6.93822280e-02f, 1.29417712e-02f, -4.29613553e-02f, 6.96041668e-03f, 4.89179790e-02f, 6.19847840e-03f, -4.42865901e-02f,
  -6.25676736e-02f, 2.73738559e-02f, -4.76496806e-03f, -9.81936697e-03f, -1.06128894e-01f, 4.08005901e-02f, 5.80221824e-02f, -1.06102847e-01f, 1.17384922e-03f, 2.75148191e-02f,
  -2.63199992e-02f, 5.53780608e-02f, -1.86163746e-02f, 3.81894410e-02f, -1.89769864e-02f, -1.61980838e-01f, 4.48920876e-02f, 2.20247228e-02f, 5.97349368e-02f, 8.42834041e-02f,
  -8.73703137e-02f, -3.26990969e-02f, 7.41593093e-02f, -6.38658404e-02f, 6.38929233e-02f, 3.27164605e-02f, 1.00480676e-01f, -6.66769594e-03f, 9.85388905e-02f, -7.75006739e-03f,
  -4.21887673e-02f, -8.59375224e-02f, -1.60280764e-02f, 1.14034481e-01f, 3.87667865e-02f, 3.00222635e-02f, 2.75316462e-02f, 1.98864145e-03f, -7.42456019e-02f, 6.64778128e-02f,
  -1.06626302e-01f, -8.25145245e-02f, 8.69734883e-02f, -7.21225562e-03f, 1.62872434e-01f, -7.44581521e-02f, -2.37467304e-01f, -5.56236506e-02f, 1.76150464e-02f, -4.67999279e-03f,
  5.31669557e-02f, -7.50807598e-02f, -9.99523252e-02f, -5.53958975e-02f, -9.87777635e-02f, -5.67537360e-02f, -2.78006438e-02f, 7.59557113e-02f, 8.91253874e-02f, 2.33614556e-02f,
  3.54263186e-01f, -2.63516754e-01f, -7.14819580e-02f, -1.13503970e-01f, 1.58267617e-01f, 2.58916289e-01f, 1.96041524e-01f, -1.69127971e-01f, -3.03022474e-01f, -3.44985276e-01f,
  7.32947737e-02f, -1.02748014e-02f, -1.13772275e-02f, 1.63059354e-01f, 3.83096427e-01f, 3.67051587e-02f, 2.19685256e-01f, 1.59167275e-01f, 8.87913555e-02f, -5.80447912e-03f,
  -7.65089840e-02f, 2.53482670e-01f, 2.44074911e-02f, 2.34286617e-02f, 1.33249328e-01f, -9.95105803e-02f, 4.57088947e-02f, -2.19254568e-02f, -2.51199678e-02f, 1.30288303e-01f,
  1.50571719e-01f, -5.57532534e-02f, 1.16528593e-01f, 6.79867193e-02f, 3.31982151e-02f, 1.44514859e-01f, 1.26411468e-01f, 1.88246980e-01f, 7.18961358e-02f, -1.14149541e-01f,
  2.80563347e-02f, 3.11224046e-03f, 4.91550751e-02f, 7.66051002e-03f, -3.68671529e-02f, 2.56117270e-03f, -1.27509162e-02f, -7.52774253e-02f, -5.71793839e-02f, 1.60134714e-02f,
  -1.11249983e-02f, 5.61133139e-02f, -6.98508620e-02f, -1.96892805e-02f, -9.36322734e-02f, -2.45003961e-02f, 2.70994771e-02f, 2.67936755e-02f, 1.15561550e-02f, -3.70386653e-02f,
  -4.05826606e-02f, 7.21500814e-02f, -8.57161125e-04f, 3.01945712e-02f, 7.52857104e-02f, -2.45027170e-02f, 1.30851790e-01f, 8.52220319e-03f, -5.44892922e-02f, 2.00358182e-02f,
  -4.19608913e-02f, -2.02319212e-02f, -5.07939933e-03f, 3.52064259e-02f, -1.94952916e-02f, 2.99823787e-02f, 1.26408473e-01f, -2.70711947e-02f, -1.01912528e-01f, -2.39410531e-02f,
  7.29095489e-02f, 7.27986172e-02f, 1.54283345e-02f, 1.69608258e-02f, 2.34561916e-02f, -8.42205286e-02f, -5.77535201e-03f, -1.41032696e-01f, 1.20778298e-02f, -1.79827381e-02f,
  6.95529729e-02f, -1.79548174e-01f, -7.42669404e-02f, 1.16848750e-02f, -5.47596440e-02f, 3.45796943e-02f, 4.05271687e-02f, 5.64950854e-02f, -7.51606151e-02f, 3.74384858e-02f,
  -5.76221123e-02f, -2.57554818e-02f, 4.16098954e-03f, 4.24571661e-03f, 1.52814109e-02f, -1.06757924e-01f, 4.21547033e-02f, -9.97801647e-02f, -5.99857457e-02f, -9.22753215e-02f,
  -3.43657732e-02f, 3.50440927e-02f, 1.03319816e-01f, 1.94545258e-02f, -9.03654993e-02f, 2.32444387e-02f, 1.26935586e-01f, -1.24479838e-01f, -3.03968904e-03f, -5.00754677e-02f,
  3.69505472e-02f, 3.94540876e-01f, -2.18412593e-01f, 9.86698940e-02f, -1.99485913e-01f, 3.80823493e-01f, 3.05674016e-01f, 8.90504196e-02f, 1.60167992e-01f, 4.90962416e-01f,
  1.19898856e-01f, 8.84317160e-02f, 1.28223538e-01f, 4.23828661e-01f, 2.65395015e-01f, 3.56905609e-01f, 3.67507339e-01f, 3.00574958e-01f, -4.44743223e-02f, 2.81927437e-01f,
  -5.92399389e-04f, 5.04835486e-01f, -3.65003273e-02f, 6.36409074e-02f, 6.42490834e-02f, -2.19036072e-01f, 2.65752841e-02f, -3.72578502e-01f, 2.21582353e-02f, -3.83312367e-02f,
  -3.69478986e-02f, 1.77134946e-02f, -9.96160656e-02f, -1.66003574e-02f, 1.25117013e-02f, -2.44966391e-02f, -1.00553684e-01f, -1.14513695e-01f, -1.27970681e-01f, -5.77652529e-02f,
  2.20143683e-02f, -2.02468596e-02f, 8.49211738e-02f, 5.29689007e-02f, -2.59053539e-02f, -1.21002709e-02f, -4.16326337e-02f, -7.91962147e-02f, 7.14256316e-02f, -4.35112184e-03f,
  3.73395458e-02f, -4.79849614e-02f, -4.84424941e-02f, 8.65953416e-02f, -1.21344112e-01f, 1.09929154e-02f, 3.74553837e-02f, -8.02549347e-02f, 1.00133270e-02f, 7.77020454e-02f,
  -2.69648228e-02f, 1.38656855e-01f, 5.51093817e-02f, 1.14064086e-02f, 2.93295737e-02f, -8.43734294e-02f, 3.25403996e-02f, -7.47054815e-02f, -1.06329031e-01f, 6.61617517e-02f,
  -9.15115476e-02f, 5.57855889e-03f, 3.89097556e-02f, 3.86096761e-02f, 4.33294773e-02f, 7.79091492e-02f, -1.62033424e-01f, 2.07310319e-02f, -1.29963309e-01f, -1.25911579e-01f,
  -2.33804807e-02f, 4.23904993e-02f, 1.19081791e-02f, -2.25995444e-02f, 4.59554307e-02f, -7.75975510e-02f, 9.24312472e-02f, -7.76645988e-02f, -5.79926856e-02f, -1.23281986e-03f,
  2.04463482e-01f, 4.24151152e-01f, 3.78401466e-02f, 8.62278566e-02f, -5.42077273e-02f, 4.95142415e-02f, -2.10339110e-02f, -6.46205992e-02f, 6.45975620e-02f, 3.67409103e-02f,
  7.19316229e-02f, 9.39717516e-03f, 3.10101435e-02f, -7.29035120e-03f, -7.20419958e-02f, 8.47425461e-02f, 8.74239355e-02f, -2.32755579e-02f, -4.48053190e-03f, 1.11872051e-02f,
  -6.27458245e-02f, 1.18428960e-01f, 3.08728982e-02f, -1.51183074e-02f, 1.03233457e-01f, 4.73061949e-02f, 6.02397695e-02f, -1.00244761e-01f, -6.86054081e-02f, 1.39988139e-01f,
  -7.71616876e-01f, 2.41064951e-01f, -2.66784698e-01f, -1.58772707e-01f, -2.03690723e-01f, -2.51474053e-01f, -9.05832127e-02f, -9.76418182e-02f, 1.44317642e-01f, 2.81582266e-01f,
  1.62405998e-01f, -1.83610648e-01f, 4.30041641e-01f, 7.73891434e-02f, -4.09157425e-01f, 4.55329329e-01f, -2.05302790e-01f, 2.29001045e-02f, 7.68774077e-02f, -2.33847976e-01f,
  -1.54257327e-01f, 1.16348691e-01f, -2.77732052e-02f, 3.43458261e-03f, -3.00624073e-01f, -6.09526597e-02f, -7.74613097e-02f, 1.55736148e-01f, -1.13467500e-01f, -6.94164112e-02f,
  -4.89875913e-01f, -1.44330710e-01f, -1.98424101e-01f, -2.19137952e-01f, -1.75421908e-01f, -6.36537746e-02f, -1.34447649e-01f, 6.05810545e-02f, -9.42836329e-02f, 7.07642827e-03f,
  4.72939247e-03f, -1.84863321e-02f, -2.35377513e-02f, 1.80637330e-01f, -5.93277253e-02f, -7.59630278e-02f, 9.15249996e-03f, -1.07203797e-01f, 4.31614965e-02f, 2.46735048e-02f,
  6.02809750e-02f, -1.81965139e-02f, -9.85800177e-02f, 7.29162917e-02f, -6.70541301e-02f, 5.34210466e-02f, -1.02698551e-02f, -1.71625763e-02f, -3.98419276e-02f, -7.54704028e-02f,
  3.36063706e-04f, -8.23433250e-02f, -3.05643920e-02f, 1.33357756e-02f, 1.42180532e-01f, 4.82043400e-02f, -4.62536067e-02f, -3.21277441e-03f, -4.34144959e-02f, -2.08757780e-02f,
  4.97922897e-02f, -5.44023961e-02f, -3.57520878e-02f, -2.15284619e-02f, -5.27761457e-03f, 2.01874282e-02f, -1.10699557e-01f, -3.59193385e-02f, 1.46771958e-02f, 2.29544844e-02f,
  -6.21817000e-02f, -5.21586835e-02f, 1.15179494e-01f, -3.92325269e-03f, -4.76769246e-02f, -4.56114486e-03f, 6.08162694e-02f, 5.09295203e-02f, -1.95249710e-02f, -7.12860823e-02f,
  -6.05603755e-01f, -4.39372391e-01f, -1.11840352e-01f, -5.67838214e-02f, -4.01510857e-02f, 2.12464258e-02f, -4.84854123e-03f, -5.41320853e-02f, -1.42033339e-01f, -1.77574679e-02f,
  -5.08972369e-02f, -2.40068650e-03f, -6.13266155e-02f, 4.55647334e-02f, 3.95704946e-03f, -2.05600653e-02f, -9.58530977e-02f, 3.60159203e-02f, -2.58832455e-01f, -1.54891208e-01f,
  -8.89981091e-02f, 8.71289242e-03f, 3.86763811e-02f, 1.07293148e-02f, -3.61276828e-02f, -7.37131536e-02f, -9.24766511e-02f, 3.28205712e-02f, -1.12835065e-01f, -2.47450173e-02f,
  -1.85133651e-01f, -2.80472010e-01f, -2.33645886e-01f, 5.41848429e-02f, 2.13466853e-01f, -1.04250483e-01f, -4.93241772e-02f, 1.49772828e-02f, 1.11457547e-02f, 2.82855798e-02f,
  -1.52506351e-01f, -2.88031638e-01f, -1.96375951e-01f, -1.05564788e-01f, -3.71288568e-01f, -5.33982277e-01f, 9.35440660e-02f, -1.16977490e-01f, -1.31615832e-01f, -3.80267669e-03f,
  3.92820574e-02f, 1.34088874e-01f, -1.92931779e-02f, 1.71175122e-01f, 9.21326950e-02f, 1.69584468e-01f, 1.95352510e-01f, 1.43095516e-02f, 2.65392542e-01f, 1.60882492e-02f,
  -1.01592526e-01f, -1.32645652e-01f, -6.85738353e-03f, 1.18735489e-02f, 1.52295962e-01f, 2.54608512e-01f, -5.56238890e-02f, -1.30021766e-01f, -6.94294795e-02f, -2.84530967e-02f,
  2.96626780e-02f, -2.25336626e-02f, -8.43195766e-02f, -1.86660290e-01f, 1.28968343e-01f, 3.15351486e-02f, -9.02585238e-02f, 6.80746883e-02f, -1.11339521e-02f, -1.76367208e-01f,
  -3.05161718e-02f, -4.44285683e-02f, 1.68604121e-01f, 6.86812855e-04f, -2.72134952e-02f, 2.32674815e-02f, 1.28473967e-01f, -6.47158222e-03f, 5.89540415e-03f, -8.00012499e-02f,
  8.39731023e-02f, 9.95706115e-03f, 2.84231547e-02f, -7.12593421e-02f, -7.78034180e-02f, -3.34769078e-02f, -1.91010274e-02f, 2.47431942e-03f, -4.57021818e-02f, -1.51061177e-01f,
  8.50973353e-02f, -9.08183530e-02f, -1.20733427e-02f, 9.83748958e-02f, -3.01625282e-02f, 6.85577020e-02f, -7.93690607e-02f, 5.34561370e-03f, 1.21717453e-01f, 3.82920504e-02f,
  4.10720408e-02f, -1.48172481e-02f, -3.33499312e-02f, -4.46713343e-02f, -1.54999554e-01f, -1.53011143e-01f, 1.47897340e-02f, -3.60536762e-02f, 6.89849705e-02f, 9.62436423e-02f,
  -1.88689470e-01f, -2.12013181e-02f, -5.36850281e-02f, -4.59551103e-02f, -2.45709810e-02f, -1.61197048e-03f, -1.26405004e-02f, -7.53705576e-02f, -1.46641523e-01f, 5.06368503e-02f,
  6.12628832e-02f, 1.12389565e-01f, 1.04839846e-01f, 2.02536881e-02f, 5.14177280e-03f, -6.33708835e-02f, 7.72402883e-02f, 9.71863791e-02f, 1.50291264e-01f, 5.33666834e-02f,
  1.01364747e-01f, 6.90149888e-02f, 1.23483591e-01f, 1.21573851e-01f, 1.69385493e-01f, 9.65151284e-03f, -3.25955190e-02f, 1.94639675e-02f, -2.50361934e-02f, -1.59452751e-01f,
  2.33471543e-01f, 1.48238212e-01f, -1.22631174e-02f, -2.70129472e-01f, -2.87774891e-01f, 9.78655764e-04f, -8.02751109e-02f, 1.35459036e-01f, 1.06724463e-01f, 1.13053136e-02f,
  -1.91648722e-01f, 8.88759047e-02f, 6.56800158e-03f, -1.02985509e-01f, 2.68349409e-01f, 2.07693130e-01f, 1.30681703e-02f, -1.41025662e-01f, 7.91524425e-02f, -2.86092520e-01f,
  -4.61825952e-02f, -3.50356787e-01f, -4.96422276e-02f, -2.30858520e-01f, -1.47328228e-01f, -1.56671837e-01f, -3.22149426e-01f, -7.35618472e-02f, -2.71205574e-01f, -1.11178242e-01f,
  7.15377927e-02f, 4.04286012e-02f, 1.20233178e-01f, 2.80263543e-01f, 2.62781475e-02f, 2.69134976e-02f, -8.17838758e-02f, -3.86359286e-03f, -3.66076976e-02f, 1.12536386e-01f,
  2.16136612e-02f, 1.66828781e-01f, 2.09132768e-02f, 3.07202619e-02f, -5.14379330e-02f, 2.49241223e-03f, 1.94641184e-02f, -5.01851477e-02f, -1.32168678e-03f, 5.56530394e-02f,
  -8.38537589e-02f, 1.52641624e-01f, -9.95330438e-02f, 5.56350872e-02f, -1.38163110e-02f, 2.85863085e-03f, 3.90328243e-02f, -1.34358227e-01f, -7.82832950e-02f, 8.93559828e-02f,
  -9.15196817e-03f, 1.35779483e-02f, 2.49874108e-02f, 1.15632284e-02f, 7.43867606e-02f, -1.05637260e-01f, -1.23894505e-01f, -2.98854653e-02f, -3.97729874e-02f, -5.94885685e-02f,
  -6.99650347e-02f, 8.03132653e-02f, -1.27949817e-02f, -5.14119416e-02f, -6.82638586e-02f, 8.67636949e-02f, -1.15744866e-01f, 6.39523426e-03f, -2.58379965e-03f, 9.17431638e-02f,
  -1.09288938e-01f, -3.68832573e-02f, 1.93971843e-02f, -1.05966575e-01f, -1.63653530e-02f, -8.67380798e-02f, -1.07478360e-02f, 5.34408092e-02f, 9.18999016e-02f, -1.15739435e-01f,
  1.59456104e-01f, 1.30260348e-01f, 5.16422875e-02f, 9.45232958e-02f, -1.82276703e-02f, 8.11248049e-02f, -9.94292740e-03f, 1.13834202e-01f, 2.50412095e-02f, 8.47783014e-02f,
  -5.19888885e-02f, 1.08609021e-01f, -1.18849114e-01f, 1.30678946e-02f, -4.45664022e-03f, -1.13925780e-03f, -1.58493683e-01f, 1.99702233e-02f, -3.86549532e-02f, 3.03554479e-02f,
  -4.57480215e-02f, -6.58711046e-02f, 1.18520364e-01f, -5.06443344e-02f, -1.83555737e-01f, -1.12863416e-02f, -2.67671179e-02f, 1.27221465e-01f, -1.21881902e-01f, -3.55911069e-02f,
  -1.36716366e-01f, 3.24701488e-01f, 2.54582494e-01f, 2.83162296e-01f, -3.18651080e-01f, -9.25497413e-02f, -1.19323678e-01f, 7.26235509e-02f, 1.56300917e-01f, 7.61652291e-02f,
  -2.62871504e-01f, 2.51508296e-01f, -5.29593378e-02f, 1.09014399e-01f, 1.79910272e-01f, -3.93840224e-02f, 1.24086790e-01f, 4.14434075e-02f, 9.82029885e-02f, 2.41927132e-01f,
  4.50868979e-02f, 3.09303869e-04f, 6.80856109e-02f, 2.39501186e-02f, -3.25913727e-02f, 2.37051845e-01f, 1.81548335e-02f, 1.48692764e-02f, 1.21045485e-01f, -3.93291041e-02f,
  -1.00838311e-01f, 6.01360612e-02f, -6.99833259e-02f, 1.69252660e-02f, 6.69488385e-02f, -6.70503080e-02f, 3.26250941e-02f, -7.27170408e-02f, 4.48701382e-02f, 7.78368115e-02f,
  -1.72731895e-02f, -1.58813468e-03f, 1.13967374e-01f, -1.97669137e-02f, -1.01302855e-01f, 7.44439214e-02f, 6.68970495e-02f, -3.98062170e-02f, 5.05363271e-02f, 6.53675273e-02f,
  1.57010466e-01f, 4.83874269e-02f, 2.22252309e-02f, 3.89187522e-02f, 7.04298988e-02f, 1.42094448e-01f, 1.35974595e-02f, 5.18948957e-02f, 6.28386345e-03f, 4.76901680e-02f,
  -1.85463596e-02f, -3.49669792e-02f, -2.68630665e-02f, -7.78004080e-02f, 5.86914830e-02f, 3.05349510e-02f, -3.01897377e-02f, -1.34122699e-01f, -1.76305491e-02f, 3.47187407e-02f,
  -7.35690966e-02f, -3.67161259e-02f, -3.35494950e-02f, 1.00512318e-01f, 7.09657837e-03f, -8.11621174e-02f, -3.33284698e-02f, 6.64971629e-03f, -2.79588625e-02f, -1.97653510e-02f,
  7.61346752e-03f, 5.08364178e-02f, 1.48414318e-02f, -1.28982678e-01f, -1.11274146e-01f, 2.47094687e-02f, 9.52619612e-02f, -4.26631887e-03f, -1.18725337e-01f, 8.96582901e-02f,
  1.75962791e-01f, 3.87639225e-01f, 1.20989598e-01f, -3.03398035e-02f, -1.20988060e-02f, 3.55426297e-02f, -4.41436768e-02f, 4.23452184e-02f, 1.71616241e-01f, -1.63436830e-02f,
  -6.97056651e-02f, -5.37851192e-02f, -1.81796346e-02f, -7.74164200e-02f, 1.24008559e-01f, 1.00184433e-01f, 1.08846776e-01f, 1.73588768e-01f, 8.54859278e-02f, 8.98288488e-02f,
  1.48333609e-01f, -2.41188444e-02f, 3.67404372e-02f, -1.05017645e-03f, 1.40778050e-02f, -6.07464276e-03f, 1.01442724e-01f, 6.91941902e-02f, 6.64784387e-02f, 5.88519089e-02f,
  4.22073126e-01f, 6.37538284e-02f, -2.75218904e-01f, -3.13354552e-01f, -2.14286357e-01f, 7.06906617e-02f, -2.74000168e-01f, -1.35620594e-01f, -1.80129439e-01f, 1.56295106e-01f,
  -1.89282566e-01f, -1.11972569e-02f, -1.64418966e-02f, -1.12583220e-01f, 1.49234563e-01f, 7.62258470e-02f, -6.52583092e-02f, -1.21293142e-01f, -5.96355610e-02f, 1.06184572e-01f,
  -4.72120419e-02f, 7.28004277e-02f, -1.42960235e-01f, -2.84907321e-04f, 2.32533514e-02f, 2.11502127e-02f, 6.22171611e-02f, -2.04812035e-01f, -1.94097891e-01f, -2.21710000e-02f,
  -1.19511299e-01f, -4.18718867e-02f, -1.57828212e-01f, 4.53775339e-02f, -3.21002714e-02f, 3.22249793e-02f, -1.58169435e-03f, -2.44725905e-02f, -6.43021539e-02f, 5.16247936e-02f,
  1.08046141e-02f, 1.33011818e-01f, 1.21103106e-02f, -2.72603203e-02f, 1.51086390e-01f, -7.77724758e-02f, 8.09674561e-02f, 7.48818368e-02f, 1.04493439e-01f, 9.00497660e-02f,
  9.93610844e-02f, 8.08523297e-02f, -1.86620858e-02f, -7.84487464e-03f, -1.19354650e-02f, -6.33733645e-02f, 4.30252478e-02f, 1.11172698e-03f, 1.44635811e-01f, 1.18087098e-01f,
  -2.78735664e-02f, 6.27223775e-02f, 4.87731732e-02f, 6.21119933e-03f, -1.45825529e-02f, -1.12734087e-01f, 2.33610906e-02f, -7.49646202e-02f, -2.47028489e-02f, 7.46935531e-02f,
  -8.39610621e-02f, -5.67675345e-02f, 6.32396108e-03f, 5.80224134e-02f, 1.40840828e-01f, 2.14698881e-01f, -5.74871153e-03f, -5.72657809e-02f, -1.84167683e-01f, -5.56169078e-02f,
  -1.29445627e-01f, 1.36242613e-01f, -5.70325181e-02f, -5.84264658e-02f, 2.62641050e-02f, -8.03511590e-02f, 7.13639408e-02f, -7.29189487e-03f, -6.26037419e-02f, 6.05559498e-02f,
  -2.23383866e-03f, 2.94843372e-02f, -5.02867140e-02f, 2.56000292e-02f, -4.91365641e-02f, 8.49772319e-02f, -5.71853518e-02f, 8.83342996e-02f, -8.09887797e-02f, 1.25768527e-01f,
  -2.75333654e-02f, -1.23665869e-01f, 4.47436348e-02f, -1.06505267e-01f, -1.37144569e-02f, 4.79856133e-02f, 3.65935750e-02f, -6.77766874e-02f, -9.58099365e-02f, 7.52474740e-02f,
  -6.08278252e-02f, 9.81789902e-02f, -3.31141502e-02f, -1.11169405e-01f, -2.69560926e-02f, 3.00721303e-02f, 1.23399086e-01f, -8.31688344e-02f, 4.24272893e-03f, -3.01701091e-02f,
  3.17307860e-02f, -4.12165612e-01f, -5.97563051e-02f, -3.22225988e-02f, -2.51785051e-02f, -1.26328260e-01f, -3.67538929e-01f, -1.77724794e-01f, -3.03231001e-01f, -3.32515836e-01f,
  9.76215079e-02f, 4.45163883e-02f, -3.31142306e-01f, 3.92412812e-01f, 3.75634164e-01f, 5.45249470e-02f, 1.21458732e-01f, 9.15923417e-02f, 2.84631178e-02f, -4.75249067e-02f,
  1.51632324e-01f, 3.43745261e-01f, 3.23896408e-01f, 2.04600587e-01f, 1.29280597e-01f, 1.94766581e-01f, 3.03860366e-01f, 2.04613730e-01f, 3.58170539e-01f, 3.25904280e-01f,
  1.75987184e-02f, 8.36695507e-02f, -1.13924764e-01f, 2.21377425e-03f, -6.82980493e-02f, 1.42509006e-02f, -4.41197827e-02f, 2.63130188e-01f, 9.85667948e-03f, -1.61119979e-02f,
  -2.76173484e-02f, 1.60748988e-01f, 8.95789564e-02f, 3.10266986e-02f, -1.23969965e-01f, -9.50624943e-02f, -2.68064309e-02f, 3.10606621e-02f, -5.50842173e-02f, -4.07371745e-02f,
  -7.22448230e-02f, -2.73810979e-02f, -1.48683107e-02f, 4.61766943e-02f, -1.15547748e-02f, -9.37733278e-02f, -8.51558819e-02f, -2.58100517e-02f, 1.14528975e-02f, -5.46533763e-02f,
  1.32589163e-02f, 6.26917034e-02f, -8.55865702e-02f, -6.36015385e-02f, -5.71272001e-02f, -2.17459910e-02f, -5.01535945e-02f, -3.05268317e-02f, 8.72691870e-02f, -1.29952967e-01f,
  2.78423131e-02f, -1.32763773e-01f, -8.81444812e-02f, -7.62867257e-02f, -1.10402722e-02f, -5.25690354e-02f, -4.90114838e-02f, 3.42451446e-02f, -1.02313779e-01f, 7.71554932e-02f,
  6.30478710e-02f, -1.52682206e-02f, 2.14834441e-03f, 3.42989229e-02f, -2.99333446e-02f, 1.47363693e-02f, -4.78727780e-02f, -1.21461220e-01f, -3.90316956e-02f, 1.23714879e-02f,
  -1.13119371e-01f, 1.09371834e-01f, 1.88158136e-02f, -6.32777289e-02f, 4.40925173e-02f, 5.68581410e-02f, 7.73234889e-02f, -4.79169935e-02f, 5.92163652e-02f, 5.46488315e-02f,
  1.31065138e-02f, -3.36260796e-02f, 7.81264082e-02f, 7.88654312e-02f, 6.54827058e-02f, -1.45786181e-01f, 5.58517836e-02f, -5.08650914e-02f, 3.45393270e-02f, -3.75160724e-02f,
  5.04819229e-02f, 2.76734289e-02f, 9.46762040e-02f, -4.24334556e-02f, 1.88378673e-02f, 6.60639778e-02f, 4.32222448e-02f, -3.35560292e-02f, 3.69382836e-02f, 1.52517706e-02f,
  1.58856045e-02f, -5.56073844e-01f, -2.00935379e-01f, 1.33206785e-01f, 1.49650320e-01f, -8.76141042e-02f, -1.94611967e-01f, -1.98610336e-01f, 1.77435786e-01f, -3.36845547e-01f,
  -2.38935485e-01f, -7.85389990e-02f, -2.42427185e-01f, -1.87203348e-01f, 3.68406445e-01f, -6.21910393e-02f, -2.06655681e-01f, -8.75619575e-02f, -5.15006557e-02f, -1.48089811e-01f,
  7.43259117e-02f, -1.63306072e-01f, -2.61548102e-01f, -2.38472268e-01f, -1.67493105e-01f, 2.54657381e-04f, 2.55532771e-01f, -3.25111784e-02f, -4.97474410e-02f, 1.75354794e-01f,
  2.91769318e-02f, -4.57791910e-02f, -9.75548103e-02f, 6.45705238e-02f, 1.22784618e-02f, -1.01091661e-01f, -6.56231269e-02f, -5.89275584e-02f, 8.94680247e-02f, 5.70915379e-02f,
  -5.46565130e-02f, 3.83239612e-02f, 9.81755555e-02f, -4.53929864e-02f, 3.28808837e-03f, 3.23143974e-02f, 8.18496644e-02f, 6.16541095e-02f, 1.16648870e-02f, -8.01555999e-03f,
  -5.53329028e-02f, -3.55897211e-02f, 1.44889340e-01f, 1.36444867e-01f, -5.49059920e-03f, 2.07154229e-02f, 2.64600720e-02f, 1.48979137e-02f, 2.02979922e-01f, 3.34697776e-02f,
  -1.03203617e-01f, 3.25216986e-02f, 2.27722526e-02f, -3.93101685e-02f, 3.97246927e-02f, 1.14491791e-01f, -3.23775895e-02f, 7.94290528e-02f, 1.95497319e-01f, -5.38194068e-02f,
  -3.55003774e-02f, -1.99465439e-01f, -3.62716131e-02f, -3.67776453e-02f, 3.66612040e-02f, 7.46957632e-03f, 7.56635070e-02f, 1.22981034e-01f, 7.98048601e-02f, -3.37102115e-02f,
  -5.19910716e-02f, 1.27131008e-02f, -6.80859387e-02f, 1.73589885e-02f, -2.73418333e-02f, -1.00050621e-01f, -7.59440139e-02f, -5.85223846e-02f, -4.23789434e-02f, -7.43301287e-02f,
  -3.88298742e-02f, -1.78951025e-01f, -9.07264203e-02f, 2.52427738e-02f, 9.92608257e-04f, -3.16949077e-02f, -5.72377518e-02f, -7.36838579e-02f, -6.63544461e-02f, -1.10123888e-01f,
  -1.08560711e-01f, 1.36271000e-01f, 2.19827399e-01f, 8.93921256e-02f, -2.47803051e-02f, -1.13158830e-01f, 1.62821651e-01f, 7.04912543e-02f, 7.98282623e-02f, -6.95105866e-02f,
  -2.13929638e-02f, 1.07078915e-02f, 1.55023575e-01f, 9.19061825e-02f, 2.81663388e-02f, 1.20172799e-02f, 1.34865597e-01f, 8.27666745e-02f, 9.82270539e-02f, 1.46517649e-01f,
  -4.00858849e-01f, 4.88672197e-01f, 3.76332730e-01f, -2.03524083e-01f, -6.66962788e-02f, -9.38092694e-02f, -6.68489113e-02f, 8.40272009e-02f, -1.38445869e-01f, 2.52281010e-01f,
  -7.47474432e-02f, 2.01812163e-01f, 3.20924968e-02f, 1.64612800e-01f, -4.59035337e-01f, -1.84068605e-01f, -2.23819748e-01f, -4.23787422e-02f, -1.72229037e-01f, -5.65020666e-02f,
  -1.61938384e-01f, -2.18260631e-01f, 3.87105681e-02f, 6.90233111e-02f, 1.21162429e-01f, 1.90240517e-01f, -2.35582814e-01f, 1.12226464e-01f, 6.55958727e-02f, 6.39356524e-02f,
  -1.43339122e-02f, 5.12020737e-02f, 5.20553030e-02f, 8.16042498e-02f, -1.34170756e-01f, 6.00671954e-03f, 8.24847892e-02f, 2.37332862e-02f, -1.76707864e-01f, -1.16794512e-01f,
  5.20326644e-02f, -5.55689633e-02f, 8.28088075e-02f, -6.99795783e-02f, 5.55582717e-02f, 1.29283831e-01f, 1.12634450e-01f, 6.46099448e-02f, 1.37156889e-01f, 1.28686920e-01f,
  6.85052872e-02f, 1.36490732e-01f, 2.41454970e-02f, 7.31274262e-02f, 2.02690735e-02f, -1.91122014e-02f, -8.84917676e-02f, 1.83572531e-01f, 9.44494233e-02f, -1.37725035e-02f,
  -1.50095997e-02f, -1.54675171e-01f, -3.06738205e-02f, -3.93637605e-02f, -2.29695886e-02f, 3.79510187e-02f, -7.92915225e-02f, 7.11019188e-02f, -8.61057118e-02f, -2.10190918e-02f,
  3.27347629e-02f, 1.09336987e-01f, -1.30203357e-02f, -1.01271026e-01f, -5.33611253e-02f, -1.61466282e-02f, 1.83056165e-02f, 5.83652314e-03f, -5.13655394e-02f, -2.43902281e-02f,
  -1.00151211e-01f, -9.03000459e-02f, 4.87588113e-04f, 2.82499958e-02f, 5.21229692e-02f, -6.22776151e-02f, 3.85983363e-02f, 1.08500667e-01f, -6.87797219e-02f, 5.57599729e-03f,
  -2.62873590e-01f, -2.58266628e-01f, -4.04976755e-02f, 4.93256608e-03f, -8.47477838e-02f, -2.26683915e-02f, 1.56209683e-02f, 3.01265735e-02f, -4.45442274e-02f, -1.28466468e-02f,
  -9.39119309e-02f, 4.36079688e-02f, -7.04341903e-02f, -8.56762230e-02f, -1.14617832e-01f, -9.96633619e-02f, -8.71248618e-02f, -4.27073836e-02f, -1.36835441e-01f, 6.97258115e-02f,
  1.15071177e-01f, 7.73328692e-02f, 2.51114257e-02f, -6.72010183e-02f, -4.39089499e-02f, -8.25407133e-02f, 7.43753836e-02f, 6.76449984e-02f, -1.39164880e-01f, 1.01511218e-02f,
  2.43739232e-01f, 3.93195391e-01f, 1.47974640e-01f, 3.77353698e-01f, -1.96369797e-01f, -6.72497302e-02f, 7.39678442e-02f, -6.57482147e-02f, -3.65932919e-02f, 2.71139055e-01f,
  -1.30607903e-01f, 3.24662209e-01f, -2.94280529e-01f, 4.76761311e-01f, -3.70876610e-01f, -2.74163812e-01f, 3.09295505e-01f, 2.87477225e-01f, -8.68862048e-02f, 1.91124439e-01f,
  -1.59120291e-01f, 1.43331811e-01f, 3.01065259e-02f, -6.33528829e-03f, 8.92239511e-02f, 3.89780067e-02f, -1.62233651e-01f, -1.80015773e-01f, 4.62098628e-01f, -1.00026049e-01f,
  1.02198824e-01f, 4.05566916e-02f, 1.10545903e-01f, 7.68513978e-02f, 3.61849144e-02f, 4.96420935e-02f, 1.16487116e-01f, -1.29502177e-01f, -1.34423390e-01f, 2.13057771e-02f,
  5.98727241e-02f, -4.84404527e-02f, 2.57993843e-02f, -3.48439650e-03f, 1.84456736e-01f, 1.89609885e-01f, -7.66414180e-02f, 1.05576597e-01f, 1.30176842e-01f, 6.91286325e-02f,
  1.27077788e-01f, 3.30111757e-02f, 4.11364026e-02f, 1.16584577e-01f, -8.06594715e-02f, 2.46536173e-02f, 2.22946312e-02f, 1.29144853e-02f, 3.46300676e-02f, 6.06819503e-02f,
  -9.94402766e-02f, 1.16453357e-02f, 3.59708406e-02f, 8.20411071e-02f, 1.76182576e-02f, -2.67336462e-02f, -9.54083353e-02f, -1.23163939e-01f, 4.57373857e-02f, -7.86054134e-02f,
  -4.77546863e-02f, 7.05391467e-02f, 3.98801640e-02f, -6.94739893e-02f, 1.46078551e-02f, 7.02395290e-02f, -8.46707076e-02f, -1.08085368e-02f, 1.45504484e-02f, 4.11966406e-02f,
  -6.89144880e-02f, 1.50912618e-02f, 1.03974037e-01f, 4.67280559e-02f, -1.89760216e-02f, -6.52907193e-02f, 1.46191362e-02f, 5.58063239e-02f, -1.32434249e-01f, -9.83649343e-02f,
  -2.45974716e-02f, -8.13182071e-02f, -7.35980868e-02f, 2.63834801e-02f, 1.46851772e-02f, -1.98512729e-02f, 8.34750906e-02f, 2.78879311e-02f, -3.87691148e-02f, 3.97271849e-02f,
  6.82375059e-02f, -6.26982898e-02f, 1.21149793e-03f, 6.27081469e-02f, -4.11728509e-02f, 5.61656058e-02f, -4.27916124e-02f, 5.58519177e-02f, -2.34066788e-02f, 1.80081837e-02f,
  7.96741769e-02f, 2.04448793e-02f, -5.16279675e-02f, -3.34204398e-02f, 9.82416123e-02f, -4.24002334e-02f, -2.98368465e-02f, -8.85027274e-03f, -4.20215391e-02f, 3.94585368e-04f,
  -5.43812633e-01f, 4.20668125e-01f, -2.94382930e-01f, 1.05856936e-02f, 1.40974566e-01f, 9.66057554e-02f, 2.56951898e-01f, 7.76566740e-04f, 2.58444458e-01f, 3.20468575e-01f,
  3.16285133e-01f, -6.11394756e-02f, 3.22344303e-01f, 2.67084837e-01f, -3.50409776e-01f, 2.53836691e-01f, 2.44646445e-02f, 1.34936124e-01f, 1.89588964e-01f, -3.84390801e-02f,
  2.16643922e-02f, 3.31627101e-01f, -1.29992500e-01f, 2.10834488e-01f, -1.63183734e-01f, -2.51907468e-01f, -1.39574289e-01f, 1.11157987e-02f, -1.30402312e-01f, -9.87790450e-02f,
  -1.98561624e-01f, 1.36998901e-02f, -1.39312744e-01f, -1.39509499e-01f, -1.63889825e-01f, -1.17002487e-01f, -1.55692324e-01f, 3.27092037e-02f, 4.81895730e-02f, 5.63535467e-02f,
  -1.99783295e-02f, 5.19835763e-02f, 1.48823723e-01f, 3.27805281e-02f, 2.35035624e-02f, -3.66158746e-02f, 3.92485410e-02f, -9.20045227e-02f, 1.41781673e-01f, 1.79043375e-02f,
  7.76648335e-03f, -1.61643937e-01f, -3.18778157e-02f, 5.46068698e-02f, -1.77741107e-02f, 1.37855876e-02f, -2.83834301e-02f, -1.45372555e-01f, -9.63644087e-02f, -1.12478476e-04f,
  4.99358065e-02f, 7.50983059e-02f, 1.52523071e-01f, 3.41524519e-02f, 3.89552265e-02f, -1.14796066e-03f, -3.47555652e-02f, 6.28333725e-03f, -6.39512017e-03f, 5.88786639e-02f,
  -1.46718603e-02f, -3.90342139e-02f, 4.91787940e-02f, -5.97778149e-03f, 1.67206135e-02f, 3.93227823e-02f, 1.46508683e-02f, 7.51305968e-02f, -2.68078055e-02f, -9.66142863e-02f,
  7.72117600e-02f, 1.86988283e-02f, -1.33875441e-02f, 1.33344661e-02f, -8.31360295e-02f, -1.53998984e-02f, -1.73496976e-02f, -7.67128216e-03f, 1.67369545e-02f, -1.49836605e-02f,
  -3.12139213e-01f, -1.83590144e-01f, 1.02506407e-01f, -1.63363442e-02f, 9.97394547e-02f, -3.42968479e-03f, -3.13041992e-02f, -5.90654239e-02f, 7.39816725e-02f, -1.64578967e-02f,
  2.67951284e-02f, -5.93732893e-02f, -2.00837135e-01f, 9.19268280e-02f, -3.79920639e-02f, 1.26350135e-01f, -6.63194209e-02f, 1.55650303e-02f, 2.59376355e-02f, -1.17175177e-01f,
  -5.55247478e-02f, 1.62622780e-02f, 9.12491456e-02f, 7.93179646e-02f, 9.04598087e-03f, -1.12209152e-02f, -1.40795290e-01f, 5.12413168e-03f, -5.25167622e-02f, -3.42466831e-02f,
  1.55103326e-01f, 2.53220975e-01f, 3.23964000e-01f, 1.81710333e-01f, -2.06414610e-01f, -2.17690885e-01f, -3.02927613e-01f, 3.93738449e-02f, -1.68964360e-02f, -3.85275148e-02f,
  -7.71245873e-03f, 3.34566027e-01f, -9.78120863e-02f, 1.89977974e-01f, 9.96586233e-02f, -1.88976124e-01f, 1.81769654e-01f, -2.36209966e-02f, -5.75453937e-02f, 1.94254696e-01f,
  2.01417565e-01f, 7.24435747e-02f, 2.55134195e-01f, 1.76539533e-02f, 2.16650844e-01f, 2.66872227e-01f, 1.63224787e-01f, -8.70601311e-02f, 3.33493412e-01f, -1.05525613e-01f,
  1.34587800e-02f, 1.20727718e-01f, 8.80322009e-02f, 4.82673943e-03f, -2.26229429e-02f, -9.34979916e-02f, 6.27630055e-02f, 1.38058662e-02f, -1.01408109e-01f, 4.31177169e-02f,
  1.37804151e-01f, -3.47263739e-02f, 1.08159855e-01f, 2.45793201e-02f, -3.76628302e-02f, 1.47758946e-01f, 4.83965874e-02f, -1.21152159e-02f, -2.85021216e-02f, 2.14109756e-02f,
  1.03074782e-01f, 2.86779273e-02f, -1.58039946e-02f, 1.38834804e-01f, 1.43313736e-01f, 2.82247886e-02f, 8.48608613e-02f, -2.26890408e-02f, -2.23293286e-02f, 1.83063075e-01f,
  9.19784382e-02f, -1.05427384e-01f, 1.29767759e-02f, -2.40301769e-02f, 3.35793160e-02f, 5.04577905e-02f, 5.16286343e-02f, 3.37414593e-02f, 4.56205234e-02f, 6.04914222e-03f,
  -1.01417921e-01f, 6.71570376e-02f, -1.06560424e-01f, -6.64943531e-02f, 1.58999100e-01f, -4.54210257e-03f, 3.68926190e-02f, -5.49582578e-02f, 9.11489651e-02f, 1.04652472e-01f,
  -2.59934962e-02f, -8.81144926e-02f, -2.72496250e-02f, -1.02545694e-01f, -1.06785037e-01f, -6.81238770e-02f, 5.64314499e-02f, 5.18634468e-02f, -4.71412726e-02f, 5.65332398e-02f,
  3.74852717e-02f, 2.22064346e-01f, 3.86451418e-03f, -1.10649288e-01f, 1.66978929e-02f, 1.34903744e-01f, 2.97669638e-02f, 2.03410611e-01f, 1.03605948e-01f, 3.22325975e-02f,
  1.14947028e-01f, -1.42010972e-02f, 3.93495485e-02f, -5.91404140e-02f, 1.85398106e-03f, 5.47772869e-02f, 2.49211546e-02f, 2.65732780e-02f, 3.81380506e-02f, 1.23224296e-01f,
  1.35685019e-02f, -4.04636785e-02f, 2.09302679e-01f, -6.31341115e-02f, 6.86683878e-02f, 9.68450159e-02f, -4.63670418e-02f, -1.47720547e-02f, 7.30672702e-02f, 8.14783573e-02f,
  4.16443765e-01f, -4.18126613e-01f, -3.89492095e-01f, 1.28569648e-01f, 2.86743373e-01f, 1.00505948e-01f, -3.30552697e-01f, 1.38750255e-01f, -9.88069624e-02f, -2.67724812e-01f,
  1.64884925e-01f, -2.90083110e-01f, -3.01683336e-01f, 2.07596317e-01f, 2.34038040e-01f, -2.76378334e-01f, 3.33479851e-01f, 1.78531438e-01f, 1.07875271e-02f, 5.88217452e-02f,
  2.06349000e-01f, 3.89883846e-01f, -1.14845723e-01f, 1.76107928e-01f, 2.09071547e-01f, 6.37051761e-02f, 1.48917437e-01f, -1.92439914e-01f, 1.46545053e-01f, -2.11613881e-03f,
  3.96883041e-02f, -6.25705859e-03f, -4.28803936e-02f, 3.06150434e-03f, -1.60470292e-01f, 2.09912919e-02f, -2.38906965e-02f, -3.54548879e-02f, 4.10904139e-02f, -1.14727452e-01f,
  -1.00775018e-01f, 1.65376306e-01f, 7.96803385e-02f, 5.26212566e-02f, 6.40994236e-02f, 3.02682221e-02f, 7.67261162e-02f, -1.43619001e-01f, -6.49073571e-02f, -6.72481805e-02f,
  -2.71492656e-02f, 2.84499265e-02f, 1.74689621e-01f, 9.55866054e-02f, -5.10475338e-02f, -9.24637914e-03f, -8.43298063e-02f, -2.21901178e-01f, 5.57644293e-02f, -1.80555917e-02f,
  1.05659053e-01f, -2.20361114e-01f, 4.74512801e-02f, 8.31713602e-02f, -1.02514163e-01f, -8.00314099e-02f, 1.71365216e-02f, 3.35445218e-02f, -5.81027940e-02f, -9.44312066e-02f,
  1.27721071e-01f, 3.40298116e-02f, 4.84114550e-02f, 5.42136878e-02f, -2.58680955e-02f, 7.36852363e-02f, 2.18244828e-02f, 1.00415207e-01f, -8.37229341e-02f, 2.62011383e-02f,
  2.65098531e-02f, 1.00323208e-01f, -1.41260296e-01f, 1.11569360e-01f, 6.93091154e-02f, -5.85173965e-02f, 5.97334653e-03f, -5.94704486e-02f, 3.39132324e-02f, 9.61583406e-02f,
  -5.00387773e-02f, -2.34306648e-01f, -1.50916189e-01f, 5.87615371e-02f, -8.75204429e-02f, 8.47809166e-02f, -4.20269258e-02f, 1.01271398e-01f, 6.83626682e-02f, 3.33822821e-03f,
  -1.71928480e-02f, 9.95011069e-03f, -2.64075380e-02f, 9.64673385e-02f, 1.00909308e-01f, -2.42368574e-03f, -8.81718025e-02f, -4.27003019e-02f, -2.14484986e-02f, 2.94022188e-02f,
  2.20021829e-02f, 1.33833840e-01f, -8.92433822e-02f, -2.33088918e-02f, 7.39360752e-04f, -1.45729497e-01f, 1.68550417e-01f, -1.04631282e-01f, 1.56242773e-01f, -4.22763675e-02f,
  -3.37289535e-02f, -1.41438842e-01f, -1.89675689e-01f, -6.14631847e-02f, -1.11117072e-01f, 2.58713454e-01f, 3.03532928e-01f, -1.46680146e-01f, -2.83938557e-01f, 2.92878360e-01f,
  3.89070094e-01f, -2.39402831e-01f, 2.16531679e-01f, 3.38802874e-01f, 8.17644969e-02f, 2.73306876e-01f, 2.25195035e-01f, 2.68944412e-01f, -1.11191742e-01f, 7.66335353e-02f,
  5.68730682e-02f, 3.29384923e-01f, 3.56052190e-01f, -2.40181834e-01f, 2.09069327e-01f, -2.64807940e-01f, 2.46619090e-01f, -7.27979839e-02f, 1.46855116e-01f, 1.11084752e-01f,
  2.36338899e-01f, -8.31557736e-02f, 1.99289583e-02f, 3.32376845e-02f, 2.03932021e-02f, -6.11258484e-03f, -1.57965291e-02f, -5.23640849e-02f, -1.01827003e-01f, -2.56576147e-02f,
  -6.37542382e-02f, -1.45758376e-01f, -1.00174613e-01f, -2.90421117e-02f, -1.09816715e-01f, -7.65050575e-02f, -1.09056644e-01f, 1.15587026e-01f, -7.38336742e-02f, -1.56996865e-03f,
  -1.03815898e-01f, -8.02605152e-02f, 1.24844044e-01f, -1.30146882e-03f, -9.14002657e-02f, -8.01814198e-02f, -6.38243929e-02f, -9.22772065e-02f, -5.63706532e-02f, -1.46522507e-01f,
  -1.17484406e-01f, 8.00704509e-02f, -3.15331332e-02f, 1.64152294e-01f, -7.32756853e-02f, -2.82584447e-02f, 8.75322893e-03f, 4.99256253e-02f, -5.47089763e-02f, -4.81449887e-02f,
  -7.50323460e-02f, -4.55257371e-02f, 7.56684318e-02f, 2.22722236e-02f, 1.42476456e-02f, 3.55049409e-02f, 1.97226442e-02f, -3.11398250e-03f, 1.34074405e-01f, 2.32288353e-02f,
  -7.50550767e-03f, -1.20007768e-01f, 9.59947705e-02f, 3.64749855e-03f, 5.21749705e-02f, 1.04156137e-01f, 4.16313745e-02f, -4.81236773e-03f, 1.00458808e-01f, 3.73524018e-02f,
  -3.09632570e-02f, -1.32145122e-01f, 3.96378823e-02f, 4.22528237e-02f, -6.80055469e-02f, -8.80533606e-02f, 7.49582499e-02f, -3.26138213e-02f, -8.27485975e-03f, 4.61078584e-02f,
  -7.80202821e-02f, -6.40405640e-02f, 2.93132830e-02f, 1.33206844e-01f, -1.00476993e-02f, 6.01046998e-03f, 4.63160612e-02f, -8.54647011e-02f, 6.71638474e-02f, -1.20832222e-02f,
  -7.67503818e-03f, -1.44294411e-01f, -1.18816227e-01f, -4.61688563e-02f, -5.23304939e-02f, 3.43230516e-02f, -1.94099128e-01f, 3.80057953e-02f, 8.58046114e-03f, -5.40416650e-02f,
  1.62927255e-01f, 2.23482450e-04f, -2.00145066e-01f, -2.31535062e-01f, 2.31235147e-01f, 3.17162484e-01f, 8.35717097e-02f, 2.13819697e-01f, -1.38149364e-02f, 3.60292137e-01f,
  2.13144809e-01f, 5.85503988e-02f, 1.74828902e-01f, 2.79829830e-01f, 1.61059856e-01f, 8.69221091e-02f, -3.61931957e-02f, 2.03437313e-01f, -2.93194614e-02f, -5.58862314e-02f,
  -2.12405816e-01f, 2.19925091e-01f, -1.67907819e-01f, 1.84468701e-01f, 1.67033240e-01f, -1.84748113e-01f, -7.23878145e-02f, 2.48228721e-02f, -5.56626357e-02f, 3.04785132e-01f,
  8.44087303e-02f, 9.91153643e-02f, 4.60542291e-02f, -1.34060504e-02f, -1.62103042e-01f, -1.39426170e-02f, -2.05398053e-01f, -4.33290042e-02f, -5.90621419e-02f, -1.94173176e-02f,
  -1.62255377e-01f, -9.00161117e-02f, 8.37737788e-03f, 2.90946830e-02f, -2.55052354e-02f, -7.02053756e-02f, -2.46142689e-02f, -1.81631651e-02f, -1.16329983e-01f, -6.94068670e-02f,
  2.10217554e-02f, -6.20535240e-02f, 1.07058790e-02f, -2.65856851e-02f, -6.40929118e-02f, 8.04009438e-02f, -1.54112011e-01f, -6.95266128e-02f, -4.14289087e-02f, -1.03486732e-01f,
  2.45734602e-02f, -9.44761559e-02f, 1.52406637e-02f, 4.50050496e-02f, 8.10578316e-02f, 3.29273120e-02f, 8.19107220e-02f, 6.65373355e-02f, -1.17666773e-01f, 5.86580262e-02f,
  -6.20000549e-02f, -2.75232568e-02f, 9.15534273e-02f, -3.29776108e-02f, -7.15540797e-02f, -7.02344477e-02f, -6.54930249e-02f, 5.23502864e-02f, -4.46253084e-02f, -5.49394041e-02f,
  -1.52633078e-02f, 1.22592999e-02f, 1.51577547e-01f, -1.86435685e-01f, -3.26936394e-02f, 1.96541980e-01f, 1.45050049e-01f, 1.36202767e-01f, -2.22598277e-02f, 8.35634544e-02f,
  -4.70987335e-02f, 5.07455766e-02f, 1.51119530e-01f, 7.39440024e-02f, -1.72388762e-01f, 7.35829771e-02f, -5.28003350e-02f, 1.50062405e-02f, 1.11931041e-01f, -7.31878877e-02f,
  -8.62178877e-02f, -6.16338998e-02f, 4.33323793e-02f, 5.12396283e-02f, -7.37168491e-02f, 2.65200943e-01f, -9.24668312e-02f, 1.16369955e-01f, -5.21055497e-02f, -6.89295083e-02f,
  1.14954624e-03f, 8.01753104e-02f, -9.03284401e-02f, -1.67959884e-01f, -7.70197511e-02f, -2.04054676e-02f, 8.31341445e-02f, -8.12885910e-02f, 1.28334746e-01f, -1.59522921e-01f,
  -7.25794911e-01f, 1.18788719e-01f, 4.64928225e-02f, -2.40207136e-01f, -1.78467423e-01f, 3.83143812e-01f, 2.13350326e-01f, -5.09943627e-02f, -2.99579978e-01f, 1.57576218e-01f,
  5.54899499e-02f, -2.28108093e-01f, 3.17088254e-02f, 3.38265598e-01f, 3.51849467e-01f, 3.28134745e-01f, 2.22228885e-01f, 1.45326227e-01f, 4.24591079e-02f, -1.84085324e-01f,
  -4.53446917e-02f, 1.77810982e-01f, 2.11284786e-01f, 8.67474079e-02f, -2.22694352e-01f, -9.57055688e-02f, 1.88911485e-03f, -3.57992649e-02f, 3.05355579e-01f, 6.49802536e-02f,
  -2.40225077e-01f, -3.62739801e-01f, -1.07003473e-01f, -4.18645479e-02f, -2.53813993e-02f, -7.27050528e-02f, 1.16381366e-02f, 5.72351143e-02f, -6.37129396e-02f, 4.38785627e-02f,
  -1.32621750e-01f, -9.17197615e-02f, -3.50248776e-02f, -1.47040496e-02f, 4.89369743e-02f, -8.16180930e-02f, 7.93612599e-02f, 5.09470217e-02f, -3.11440211e-02f, -3.16250101e-02f,
  7.33754262e-02f, 2.05473229e-01f, 8.97830203e-02f, 1.68466091e-01f, -5.54743074e-02f, -4.60623167e-02f, 2.21096039e-01f, -6.50555491e-02f, 2.39631236e-02f, 6.98863566e-02f,
  7.38263056e-02f, -9.62629020e-02f, 6.94452226e-03f, -1.45433908e-02f, 5.12488047e-03f, 1.82579368e-01f, 1.76520050e-02f, -5.08822384e-04f, 1.62062094e-01f, 9.93478820e-02f,
  -1.20554060e-01f, -1.43865436e-01f, -9.41284671e-02f, 1.17307343e-01f, -3.60645205e-02f, -9.10126120e-02f, -1.00193694e-01f, -8.78693610e-02f, -5.09689674e-02f, 4.02933126e-03f,
  -1.97743364e-02f, 2.96444353e-02f, 1.70337148e-02f, 3.84790786e-02f, 1.90557609e-03f, 4.01174240e-02f, -9.87290125e-03f, 6.94725439e-02f, 7.34960437e-02f, -3.96973342e-02f,
  -2.30394393e-01f, -3.19136322e-01f, -1.37186661e-01f, -1.29809543e-01f, -2.04853490e-02f, -3.59787755e-02f, -1.06483512e-02f, -8.74975994e-02f, 4.41174768e-02f, -3.73045243e-02f,
  -2.58323513e-02f, 2.14536544e-02f, -5.35412841e-02f, -9.18991193e-02f, 1.69628449e-02f, -3.37603875e-02f, -1.16924420e-01f, -1.60682704e-02f, -8.62762798e-03f, -3.54481116e-02f,
  3.60570895e-03f, 6.33746907e-02f, -1.86117720e-02f, 2.35202871e-02f, 5.53005859e-02f, 1.05302684e-01f, -9.41564143e-02f, -7.74270669e-03f, 5.42057790e-02f, 4.45845127e-02f,
  -8.09085131e-01f, 2.82742977e-01f, 4.98716533e-01f, -2.96624541e-01f, -8.25262368e-02f, 2.58418918e-01f, 2.99327612e-01f, -1.12140596e-01f, -1.89818323e-01f, 9.81031656e-02f,
  1.43362448e-01f, -9.81821120e-02f, 3.08321089e-01f, 9.37345922e-02f, 9.67205130e-03f, 1.46135226e-01f, -3.74951884e-02f, 7.39511997e-02f, -3.16287130e-02f, -1.75866246e-01f,
  -1.39267743e-01f, -8.08351561e-02f, 3.30904633e-01f, -2.38937326e-02f, 1.11458562e-01f, -1.11601137e-01f, -9.25255641e-02f, 2.26668119e-01f, -1.77058831e-01f, 1.43290207e-01f,
  -3.85529101e-01f, -2.16027096e-01f, -3.47239450e-02f, 9.28144231e-02f, -4.89129610e-02f, 5.59019931e-02f, 5.96158393e-02f, 5.59049323e-02f, -1.38524130e-01f, -1.04726486e-01f,
  -8.52119527e-04f, 5.71265332e-02f, -1.96751654e-01f, -7.18212798e-02f, -9.90113765e-02f, -1.58010870e-02f, 9.43094790e-02f, 2.97079720e-02f, 4.86622378e-02f, 1.30241692e-01f,
  1.27231285e-01f, 7.62576088e-02f, 2.56759636e-02f, 8.33964124e-02f, 1.21085174e-01f, -1.79827213e-02f, 6.43261522e-02f, 3.03899683e-02f, -7.26012588e-02f, -1.07238702e-01f,
  1.13657229e-01f, -8.31279680e-02f, 1.18707577e-02f, -1.51918139e-02f, -4.06646542e-02f, 7.01351091e-02f, 6.34565055e-02f, 5.65565284e-03f, -3.00601162e-02f, -7.62362918e-03f,
  -7.11426958e-02f, -6.33788109e-02f, -1.00766078e-01f, -1.56542249e-02f, -7.04372376e-02f, -9.09725502e-02f, 7.22766370e-02f, 4.20430228e-02f, -4.96995077e-02f, 3.48556451e-02f,
  3.97578441e-02f, -1.08714225e-02f, 1.32590964e-01f, 8.94813798e-03f, -9.23218802e-02f, 5.77970073e-02f, -2.21494976e-02f, -9.14257579e-03f, -6.20572120e-02f, -1.34262778e-02f,
  -4.61673021e-01f, -3.64356875e-01f, -3.58646661e-02f, -1.18973680e-01f, 3.09110172e-02f, -6.52960688e-02f, -1.16801588e-02f, -7.47721940e-02f, -1.38255462e-01f, -2.64707282e-02f,
  -5.91322826e-03f, -7.19445432e-03f, 5.11779450e-03f, 6.77298680e-02f, -1.43930893e-02f, 3.04296520e-03f, 7.27834329e-02f, 6.96916878e-03f, -1.02832451e-01f, -6.57576472e-02f,
  -2.90201753e-02f, -7.04397932e-02f, 1.09478906e-01f, -4.50569130e-02f, -7.27173463e-02f, 2.60173399e-02f, -1.19580969e-01f, 4.00056764e-02f, 1.49550964e-03f, 6.38470724e-02f,
  -1.05436236e-01f, 1.67334788e-02f, -3.23453158e-01f, -1.68081835e-01f, 8.28935280e-02f, -2.15562552e-01f, -2.21422538e-01f, 1.25271529e-01f, -2.40689859e-01f, 2.24723771e-01f,
  3.45403373e-01f, -2.70727783e-01f, 2.74657786e-01f, -1.55937195e-01f, -2.18453288e-01f, -1.06634848e-01f, -1.03054671e-02f, -1.05434962e-01f, -1.73259974e-01f, 1.84377521e-01f,
  -1.32062018e-01f, 1.46249622e-01f, -4.67718653e-02f, 1.65536672e-01f, 4.66055349e-02f, 7.72126764e-02f, 3.43146324e-01f, 2.22449467e-01f, 6.81099370e-02f, -5.60117252e-02f,
  -2.56460942e-02f, 1.03877388e-01f, -8.84383693e-02f, -6.38993680e-02f, 1.77862197e-01f, 7.05919266e-02f, -7.40002841e-03f, -5.10600694e-02f, -1.48714781e-01f, 6.35675713e-02f,
  -1.18223643e-02f, -1.27965584e-01f, -1.08111925e-01f, -7.55068734e-02f, 3.10670044e-02f, -3.06900162e-02f, -1.53107420e-01f, -9.60143879e-02f, -2.11004362e-01f, -3.09070367e-02f,
  -2.03276593e-02f, -3.51694636e-02f, 6.39088601e-02f, -5.98079525e-02f, 1.40054189e-02f, 6.64765909e-02f, -7.45673552e-02f, 7.03758234e-03f, 7.44288489e-02f, 4.98496480e-02f,
  1.21692315e-01f, 6.63293713e-06f, -2.33849175e-02f, 8.13257918e-02f, 1.15604490e-01f, 8.81169960e-02f, -6.81051910e-02f, -1.10822760e-01f, -3.36774252e-02f, 1.40849501e-01f,
  -3.63441072e-02f, -1.16793796e-01f, -4.47751116e-03f, -4.53710556e-02f, 3.84976203e-03f, -1.00218073e-01f, -8.22880045e-02f, 7.52745643e-02f, -1.02363579e-01f, -4.42374796e-02f,
  4.72141104e-03f, 5.54020256e-02f, -9.88233685e-02f, 8.51570219e-02f, 1.10279517e-02f, 7.20372573e-02f, 1.47718310e-01f, 7.12179169e-02f, 1.51271289e-02f, -5.71248084e-02f,
  1.59726799e-01f, 3.43822986e-01f, -1.35626495e-02f, -3.78994830e-02f, 8.46423730e-02f, 9.90398228e-02f, 6.57873973e-02f, -6.98274449e-02f, 8.40904489e-02f, 1.55277878e-01f,
  5.81569150e-02f, -5.51862493e-02f, 9.10947546e-02f, -5.01588359e-02f, -7.60598332e-02f, 8.24382678e-02f, 9.12862346e-02f, -5.22997268e-02f, 7.22234026e-02f, 7.78312385e-02f,
  1.40159115e-01f, 4.26600426e-02f, 8.65607429e-03f, -6.08727746e-02f, 6.13838695e-02f, 1.14361830e-01f, 5.62607870e-02f, 5.09851286e-03f, -2.72478014e-02f, -6.22256845e-02f,
  -8.72599706e-02f, 1.62079170e-01f, -1.87272444e-01f, -5.99521212e-02f, 2.29915809e-02f, -4.57009435e-01f, -2.51435429e-01f, -2.94202603e-02f, -1.41736582e-01f, 3.17603707e-01f,
  -2.10010856e-01f, 2.41731286e-01f, 1.31492719e-01f, -4.15517747e-01f, -4.15034294e-01f, -2.44413421e-01f, -2.38858223e-01f, -9.45765749e-02f, 1.06059453e-02f, 3.13951038e-02f,
  -1.75655842e-01f, -2.52410233e-01f, -2.46377215e-01f, 5.03003830e-03f, -4.24686782e-02f, 2.59138972e-01f, 2.20840171e-01f, 8.20436403e-02f, 1.49600087e-02f, -3.28323767e-02f,
  -1.23153329e-01f, 8.83744135e-02f, 9.50030237e-03f, -4.49663308e-03f, 7.35611096e-02f, 2.31293426e-03f, 3.11230756e-02f, -7.16317296e-02f, -9.71938893e-02f, -1.77595799e-03f,
  6.55377433e-02f, 1.05102535e-03f, 1.99282728e-02f, 7.09024966e-02f, 3.51625197e-02f, 9.29606110e-02f, -2.73013413e-02f, 3.62606235e-02f, 1.17970116e-01f, 5.65291243e-03f,
  3.36910784e-02f, 5.90581857e-02f, -4.06445935e-02f, 1.80876181e-01f, 1.04091112e-02f, 4.96941656e-02f, -7.56255984e-02f, 5.29215252e-03f, 5.72856341e-04f, -1.61558408e-02f,
  -2.37871869e-03f, 2.84560118e-02f, 2.59280961e-04f, -1.70406085e-02f, -1.45495579e-01f, -7.02302009e-02f, -3.66754755e-02f, -3.61360684e-02f, -2.00191159e-02f, 5.10204062e-02f,
  8.70881751e-02f, 7.99774006e-02f, -4.47374582e-02f, -7.71218585e-03f, -2.11787149e-02f, -8.86862576e-02f, -7.68051222e-02f, 6.46821633e-02f, -3.66521738e-02f, -4.66875508e-02f,
  1.15819409e-01f, -2.97793224e-02f, -1.50653413e-02f, -2.19946411e-02f, -1.32353857e-01f, 5.93400858e-02f, -2.36412175e-02f, -3.68002690e-02f, 3.98187675e-02f, 7.38926157e-02f,
  9.95100513e-02f, 1.59771666e-01f, 5.62536716e-02f, 6.18996769e-02f, 7.80550018e-02f, 5.05191572e-02f, -1.29610673e-01f, -4.42871638e-02f, -1.82669461e-02f, -4.54937257e-02f,
  1.04832165e-01f, 7.39125609e-02f, 4.42186259e-02f, -1.98336085e-03f, 8.57617427e-03f, -6.10924922e-02f, 1.18798487e-01f, 9.21022072e-02f, 1.12140968e-01f, 7.57464543e-02f,
  8.72413367e-02f, 1.41831025e-01f, 1.36208888e-02f, 2.91778781e-02f, 1.35255471e-01f, 1.22641020e-01f, 7.41827190e-02f, 5.65747283e-02f, 1.48401842e-01f, 8.64609927e-02f,
  -6.13824368e-01f, 1.51500985e-01f, 2.70215541e-01f, 3.62699270e-01f, -3.94301504e-01f, 1.95566624e-01f, 4.27248478e-01f, -3.20531756e-01f, 3.70387547e-02f, 8.67119431e-02f,
  -1.72297005e-02f, 2.81066537e-01f, 1.97580770e-01f, 2.68158823e-01f, 3.68278295e-01f, 3.51119012e-01f, 2.47713402e-01f, 1.09691530e-01f, -1.32325575e-01f, 5.34283929e-02f,
  4.65180911e-02f, 2.75638588e-02f, 2.42109478e-01f, -1.05708264e-01f, 1.71797186e-01f, 2.35194474e-01f, 3.81008178e-01f, 2.19454348e-01f, 1.96460024e-01f, 9.87726599e-02f,
  -1.19077437e-01f, -1.33470237e-01f, -1.59452811e-01f, 1.69664323e-02f, -6.80814460e-02f, 6.13909736e-02f, 1.36162773e-01f, 2.57735047e-02f, 1.38577670e-01f, 5.89108020e-02f,
  -5.12454286e-02f, -1.24332637e-01f, 1.00521203e-02f, -5.52504659e-02f, -2.21905231e-01f, -3.69883217e-02f, -1.38909429e-01f, -5.43076769e-02f, 5.94501244e-03f, -1.54023170e-01f,
  -7.79143646e-02f, -5.74451275e-02f, -1.91707872e-02f, -5.28366417e-02f, -3.40835042e-02f, -1.74665004e-01f, 2.40838349e-01f, -1.89585403e-01f, 1.11040674e-01f, 1.25977695e-02f,
  -4.83801998e-02f, 2.35877126e-01f, -2.09896937e-02f, 3.34878489e-02f, 1.95255131e-02f, -6.19856007e-02f, 4.63462695e-02f, -7.77742267e-02f, 1.65093653e-02f, 1.71484992e-01f,
  -3.96830067e-02f, -1.28342018e-01f, -1.52593762e-01f, -4.50772680e-02f, -1.14130333e-01f, 1.46244645e-01f, -5.36990585e-03f, -3.86634767e-02f, 1.81094930e-02f, -1.15560450e-01f,
  -1.01361796e-02f, -1.41313165e-01f, -5.81748299e-02f, -8.42082351e-02f, 6.03243411e-02f, 3.92150469e-02f, 8.24579969e-02f, -2.26755701e-02f, 1.75583035e-01f, -7.11555332e-02f,
  2.11520284e-01f, 4.44916725e-01f, -5.60872965e-02f, -2.27680653e-01f, 8.93316120e-02f, -5.26967086e-02f, -1.26745477e-01f, -1.38755783e-01f, 1.10679798e-01f, -9.02935117e-03f,
  -6.92660660e-02f, -3.32146846e-02f, 2.95746233e-02f, 5.14636748e-02f, 7.04214126e-02f, 7.34827593e-02f, 4.82747816e-02f, 1.69341847e-01f, 5.34894057e-02f, -7.93486461e-02f,
  4.42671739e-02f, 1.01203151e-01f, -1.95051685e-01f, -1.13512613e-01f, -8.47334117e-02f, 4.28122953e-02f, -1.28704026e-01f, -9.91867036e-02f, -1.55890688e-01f, 6.88817203e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  1.78996697e-01f, 1.44625604e-01f, 3.20846528e-01f, 2.85593778e-01f, 4.62344885e-01f, 2.87755191e-01f, 3.31391513e-01f, 3.19225013e-01f, 2.98977762e-01f, 5.59551060e-01f,
  2.93534905e-01f, 2.17405573e-01f, 4.74746227e-01f, 2.32732847e-01f, 2.24180996e-01f, 2.49552220e-01f, 2.32481673e-01f, 2.40765989e-01f, 3.33855748e-01f, 4.21077400e-01f,
  3.49725127e-01f, 3.82240295e-01f, 2.58085549e-01f, 3.15480798e-01f, 2.82904446e-01f, 3.11038792e-01f, 2.48099998e-01f, 2.59715199e-01f, 3.33733588e-01f, 4.11304444e-01f,
  2.68673658e-01f, 2.94055045e-01f, 3.36416334e-01f, 2.72522539e-01f, 7.06007481e-02f, 2.87839830e-01f, 2.08357945e-01f, 3.30884337e-01f, 2.34576732e-01f, 3.54515344e-01f,
  3.24642509e-01f, 2.37227380e-01f, 1.88171580e-01f, 2.54608840e-01f, 2.93891102e-01f, 9.90674123e-02f, 4.40170795e-01f, 3.20608377e-01f, 1.37791947e-01f, 2.18216598e-01f,
  1.90418512e-01f, 2.89805770e-01f, 3.57214451e-01f, 2.41633713e-01f, 1.59119189e-01f, 1.71541989e-01f, 2.15891987e-01f, 2.78990537e-01f, 2.88675696e-01f, 2.48033702e-01f,
  3.54568422e-01f, 3.55399281e-01f, 3.06886166e-01f, 1.95089251e-01f, 4.53326106e-01f, 3.76223147e-01f, 1.91350162e-01f, 4.06255662e-01f, 3.76976460e-01f, 2.22821623e-01f,
  1.73928440e-01f, 1.65379182e-01f, 3.92394572e-01f, 1.78510621e-01f, 2.53424168e-01f, 2.08085090e-01f, 3.97477597e-01f, 2.61914313e-01f, 1.76660016e-01f, 2.77711183e-01f,
  2.58145273e-01f, 4.01645839e-01f, 3.83887231e-01f, 1.64275974e-01f, 2.27657557e-01f, 1.50250673e-01f, 3.39015067e-01f, 3.28329265e-01f, 2.48804539e-01f, 1.69988886e-01f,
  9.29593965e-02f, 3.60959828e-01f, 3.75362784e-01f, 3.83186668e-01f, 3.07936460e-01f, 1.70709878e-01f, 2.22489491e-01f, 2.11105034e-01f, 7.51712769e-02f, 2.66906768e-01f,
  3.10845852e-01f, 3.56758803e-01f, 2.63536930e-01f, 3.87335241e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.13598205e-01f, -4.32293117e-01f, -5.46818227e-02f, -2.38256007e-01f, -3.88007052e-02f, -5.05961888e-02f, 1.68621242e-02f, 4.97591048e-02f, -1.01232141e-01f, -2.97762416e-02f,
  -9.77554992e-02f, -2.78858751e-01f, 3.21916074e-01f, 2.47741550e-01f, -1.99223623e-01f, 3.08913738e-01f, 2.53890097e-01f, -1.69561639e-01f, -1.83333218e-01f, 3.80931884e-01f,
  -9.40209702e-02f, 1.18791193e-01f, -2.89453734e-02f, 2.11414635e-01f, -1.09596901e-01f, -1.55970901e-01f, -2.58858383e-01f, -2.26941645e-01f, -3.73505831e-01f, -2.26667255e-01f,
  1.85176015e-01f, -1.28700435e-01f, -1.43147498e-01f, 2.70644873e-01f, 1.40820406e-02f, -3.84087563e-01f, -2.11887687e-01f, 2.57661343e-01f, -4.21997815e-01f, -1.95183173e-01f,
  -2.06006810e-01f, -1.08322777e-01f, -2.33020350e-01f, 1.56950518e-01f, 2.37317041e-01f, -1.30104735e-01f, -2.38446325e-01f, -3.96300226e-01f, -1.05680242e-01f, -2.42414042e-01f,
  -3.27300280e-01f, -2.40373299e-01f, 2.99719244e-01f, -1.81988195e-01f, 3.16648990e-01f, -1.29246026e-01f, -2.64468431e-01f, -4.22834635e-01f, 2.53515422e-01f, -2.16693878e-01f,
  -1.20276853e-01f, -1.11400999e-01f, -2.34079301e-01f, 1.73891380e-01f, 3.27879548e-01f, -6.26442954e-02f, 9.92207602e-02f, -4.95151490e-01f, -1.90509558e-01f, 2.62265541e-02f,
  -2.58559108e-01f, -1.67621106e-01f, -2.29484916e-01f, 3.11983556e-01f, 3.44397314e-02f, 4.20116603e-01f, -7.48246536e-02f, -3.49298008e-02f, -1.32265404e-01f, 6.33107405e-03f,
  -4.94479500e-02f, 7.92906284e-02f, -1.62015080e-01f, 2.20628530e-01f, -1.63005903e-01f, 2.52775490e-01f, -5.62653899e-01f, 1.31005645e-01f, -2.49265775e-01f, -1.12239905e-01f,
  3.07044834e-01f, -4.20462847e-01f, -1.17858432e-01f, 8.81130919e-02f, -2.40354612e-01f, 1.86912119e-01f, -1.79440826e-01f, -2.16240376e-01f, -1.87529787e-01f, -2.47799367e-01f,
  1.99840590e-01f, 3.56046557e-02f, 3.98967594e-01f, -2.26546645e-01f, -2.57902235e-01f, -3.49669337e-01f, -4.89228755e-01f, -2.59059165e-02f, 1.94239214e-01f, 2.88943827e-01f,
  7.56093860e-02f, -1.16213568e-01f, -1.40721053e-01f, -3.97923857e-01f, -2.32665643e-01f, -2.18004212e-01f, 2.47149952e-02f, 9.83088985e-02f, 3.17018270e-01f, -2.68892795e-01f,
  -4.62055951e-01f, 4.08303827e-01f, -4.78790440e-02f, 3.44825119e-01f, 2.24934936e-01f, 9.73124504e-02f, -1.09736457e-01f, 2.20863566e-01f, -2.39655692e-02f, 1.27768487e-01f,
  1.42675444e-01f, -2.05334425e-01f, -2.63648480e-01f, -3.94773223e-02f, -2.83366621e-01f, -1.80151612e-01f, 1.22511648e-01f, -2.21603632e-01f, 2.06609830e-01f, 1.28902495e-01f,
  2.69567519e-01f, 1.21898986e-01f, -2.63446510e-01f, 2.19955057e-01f, 2.83640444e-01f, 1.39285788e-01f, 3.10514063e-01f, 2.36336395e-01f, -5.11076391e-01f, 2.06809089e-01f,
  -1.89849645e-01f, 3.42106104e-01f, 6.14381246e-02f, -3.56409371e-01f, -3.17115039e-01f, 1.72196940e-01f, -3.61144811e-01f, -7.28033260e-02f, 6.66797310e-02f, -3.98836911e-01f,
  1.84976697e-01f, 1.77284628e-01f, -2.34741375e-01f, 2.68970549e-01f, -5.37073076e-01f, 3.34593326e-01f, 9.05104056e-02f, 3.71721596e-01f, -2.61623889e-01f, -3.87371212e-01f,
  -2.62067258e-01f, 2.18859628e-01f, 1.67575359e-01f, -6.61263317e-02f, 3.56137216e-01f, -1.87070251e-01f, -3.87014478e-01f, -3.86800647e-01f, 1.95188686e-01f, 5.65764308e-02f,
  -4.93585020e-01f, 2.99831569e-01f, 1.62438884e-01f, -3.62708926e-01f, 1.81570426e-02f, -2.37689614e-02f, -3.34932387e-01f, -2.94053465e-01f, -2.54628152e-01f, 2.84122020e-01f,
  1.76834062e-01f, -4.74258542e-01f, -4.26034868e-01f, -6.39250055e-02f, -1.15093812e-01f, -3.04611117e-01f, 2.74041533e-01f, 4.83591147e-02f, -5.87918401e-01f, 1.27304799e-03f,
  2.88500726e-01f, -2.34753028e-01f, -1.35400295e-01f, 1.68348327e-01f, -4.98225272e-01f, -1.52316555e-01f, -3.03366661e-01f, -4.57876295e-01f, 1.73831552e-01f, 1.28604144e-01f,
  1.66333199e-01f, -3.40343982e-01f, -1.38633519e-01f, -1.57297850e-01f, -1.61224350e-01f, 1.21769467e-02f, -2.16631383e-01f, -4.39913809e-01f, -1.91712394e-01f, 1.35117188e-01f,
  2.81142026e-01f, 1.40619233e-01f, 3.15251052e-01f, 7.41180927e-02f, -1.41131222e-01f, -2.16473863e-01f, 2.74752587e-01f, -1.61038563e-01f, -2.94848293e-01f, -2.12140530e-01f,
  2.07202747e-01f, -1.48299798e-01f, -1.37535334e-01f, -2.58009017e-01f, -1.91912666e-01f, 1.88198462e-01f, 3.33005160e-01f, -5.63205838e-01f, -2.36873239e-01f, -6.21342771e-02f,
  -1.87023893e-01f, 3.11945945e-01f, 1.89042967e-02f, -4.25483763e-01f, -3.26614082e-01f, 8.66583660e-02f, 1.54662982e-01f, -7.18401894e-02f, 1.60540357e-01f, 2.60670364e-01f,
  4.68880832e-01f, -2.55150488e-03f, -3.08001071e-01f, 1.06264420e-01f, -2.76503801e-01f, -9.31008384e-02f, -8.81557539e-02f, -2.93147713e-02f, -7.18412399e-02f, -1.32566160e-02f,
  9.28426385e-02f, 1.16490629e-02f, -9.47608724e-02f, 8.80808607e-02f, 1.72267687e-02f, -1.25096887e-01f, -1.58699572e-01f, -1.87571406e-01f, 1.82113916e-01f, -2.24738166e-01f,
  6.23339228e-02f, 1.91124812e-01f, -6.65959492e-02f, -2.35287279e-01f, 1.14965402e-01f, 2.02143669e-01f, 1.85249612e-01f, -2.59958237e-01f, -2.79303640e-01f, -2.25091994e-01f,
  9.99057814e-02f, -1.62241429e-01f, -1.60196438e-01f, 9.50319394e-02f, -3.65142435e-01f, -2.65184164e-01f, -3.51081789e-01f, 1.96601436e-01f, 2.57771403e-01f, -3.20600212e-01f,
  -2.84350127e-01f, -2.33193919e-01f, -9.20299292e-02f, 7.80180620e-04f, -9.44048516e-04f, 1.02123395e-01f, -4.04975891e-01f, 2.41469011e-01f, -2.06265837e-01f, -1.41652733e-01f,
  -3.19468349e-01f, -3.24757904e-01f, 3.02082002e-01f, -1.04121827e-01f, 1.23863928e-02f, 1.41961560e-01f, 3.35900486e-01f, 7.74209350e-02f, -7.98482075e-02f, 1.96347207e-01f,
  -2.82519192e-01f, 1.12426221e-01f, -1.73088983e-01f, 3.71888816e-01f, -1.88167378e-01f, -2.85428256e-01f, -3.83293718e-01f, -2.19258413e-01f, 7.18180388e-02f, -1.65638313e-01f,
  -2.99861223e-01f, -1.27637029e-01f, -1.70545846e-01f, -1.09861352e-01f, -1.94056049e-01f, -1.05955586e-01f, -3.11840683e-01f, -5.24799107e-03f, 2.83959568e-01f, -2.75349885e-01f,
  2.18117177e-01f, 2.50774354e-01f, -2.50338793e-01f, 1.29590025e-02f, -2.11530492e-01f, 3.07942361e-01f, -4.64808404e-01f, -2.51371384e-01f, 1.78679913e-01f, -2.89755035e-03f,
  1.76395252e-01f, -2.87161618e-01f, -1.05691627e-01f, -3.08345348e-01f, 2.33161733e-01f, -1.62098616e-01f, -7.75469393e-02f, -2.19743848e-01f, 2.00402290e-01f, -5.45215428e-01f,
  1.69481277e-01f, -1.45031348e-01f, -1.42996103e-01f, -2.68499434e-01f, 2.54999697e-01f, 3.60208273e-01f, -3.58796656e-01f, -2.57932842e-01f, -2.31612056e-01f, -2.46174425e-01f,
  -3.21427494e-01f, 1.41252518e-01f, -2.45811015e-01f, 2.09853724e-01f, -2.63194978e-01f, -1.99793443e-01f, 2.85691053e-01f, -1.66143224e-01f, -2.26208985e-01f, -2.96167523e-01f,
  3.70253444e-01f, 2.24069834e-01f, 5.36052659e-02f, 5.58497161e-02f, -2.04535916e-01f, -4.01951298e-02f, 3.99225533e-01f, -5.75162098e-02f, -1.52946115e-01f, 1.38862520e-01f,
  -2.85134256e-01f, -4.05012310e-01f, -3.18984866e-01f, -9.99086201e-02f, -1.04224207e-02f, 4.53551523e-02f, -9.31066182e-03f, -6.60066828e-02f, 8.68147239e-03f, -6.10007271e-02f,
  -3.70395064e-01f, -3.40875149e-01f, -2.82522053e-01f, -9.27431062e-02f, 1.27588019e-01f, -7.41638336e-03f, 1.57793332e-02f, 1.37574121e-01f, 1.25983015e-01f, -2.71916777e-01f,
  2.30068818e-01f, -1.78910866e-01f, -1.01582788e-01f, -1.13405265e-01f, -2.64288157e-01f, -1.49269858e-02f, 9.55149010e-02f, 1.92654997e-01f, -1.16161980e-01f, 2.17077835e-03f,
  -1.80596158e-01f, -2.47158423e-01f, -1.13519512e-01f, -2.24071145e-01f, -2.18782783e-01f, 1.33491322e-01f, -2.17101261e-01f, 1.39186189e-01f, -1.31528720e-01f, -2.38917530e-01f,
  1.77835777e-01f, -1.23751611e-01f, -1.99227408e-01f, -3.00626665e-01f, -4.21659499e-01f, -3.35639745e-01f, 3.43059689e-01f, -2.97905564e-01f, 1.87580362e-01f, -1.51876196e-01f,
  -1.22730039e-01f, 1.10272892e-01f, -3.06462765e-01f, -4.23350871e-01f, -1.53207883e-01f, -2.85004109e-01f, 2.11829737e-01f, -2.84052700e-01f, -1.69313177e-02f, -1.49447203e-01f,
  3.72266829e-01f, -3.72909486e-01f, 3.43205124e-01f, 2.30621830e-01f, -3.33833277e-01f, -3.85527998e-01f, -3.64119858e-01f, -2.63820440e-01f, -2.21715078e-01f, -2.08224803e-01f,
  -3.29419404e-01f, 6.33120164e-02f, -4.33228254e-01f, -1.99955612e-01f, -2.13112816e-01f, 2.62381613e-01f, -8.23230669e-02f, 2.53790677e-01f, -2.74859875e-01f, -4.12258506e-01f,
  2.02145755e-01f, -1.29019842e-01f, -1.92658916e-01f, -5.96689694e-02f, -1.99450016e-01f, -1.55398384e-01f, -1.41070992e-01f, 3.14614385e-01f, -4.03947920e-01f, -3.53754073e-01f,
  3.10672313e-01f, -7.50551000e-02f, 3.67667750e-02f, 1.87407434e-01f, -3.08466077e-01f, -3.25089917e-02f, -4.77581285e-02f, 2.39519611e-01f, -2.05994859e-01f, -3.82175028e-01f,
  -3.05975348e-01f, 3.34542245e-01f, -1.36967525e-01f, -1.88172549e-01f, -1.86193585e-01f, 3.35121870e-01f, -5.15970495e-03f, 8.26989412e-02f, 4.30374652e-01f, -1.30954772e-01f,
  1.42096534e-01f, -1.66636124e-01f, -1.51447669e-01f, 3.56288940e-01f, -6.06179088e-02f, -2.10216329e-01f, -1.17792860e-01f, -3.38437796e-01f, -4.60097305e-02f, -2.18405932e-01f,
  2.49948382e-01f, 5.97113138e-03f, 3.99439782e-01f, -2.18513325e-01f, -1.27351686e-01f, -2.27715120e-01f, 2.06410527e-01f, -2.43693531e-01f, 7.43625909e-02f, 1.45177886e-01f,
  2.06656113e-01f, -4.41924065e-01f, 1.68132447e-02f, 2.47140333e-01f, 1.75476968e-01f, -3.64980241e-03f, 1.28510132e-01f, -2.77741626e-02f, 1.67577956e-02f, 9.27828401e-02f,
  1.07617564e-01f, -3.63292396e-02f, -1.90782651e-01f, -6.44959807e-02f, -3.76019925e-01f, 2.37875611e-01f, -1.78889826e-01f, -1.93284944e-01f, 7.25065619e-02f, -2.51281410e-01f,
  -3.65565598e-01f, -2.84612596e-01f, 1.22647554e-01f, -1.66550890e-01f, -2.99303159e-02f, -1.52198583e-01f, -1.68715343e-02f, -1.76960766e-01f, 2.12143421e-01f, 4.17693943e-01f,
  3.17892343e-01f, -1.23609982e-01f, -3.30103278e-01f, -6.51399016e-01f, -1.08985320e-01f, 6.34696856e-02f, 2.61035115e-01f, -2.55879223e-01f, 1.37872025e-01f, -1.35327727e-01f,
  -4.39641535e-01f, -2.20842317e-01f, 9.85939875e-02f, -1.46647543e-01f, -2.14301944e-01f, -4.76727515e-01f, 2.52100170e-01f, -3.21935952e-01f, -8.74447525e-02f, 3.33908767e-01f,
  2.31613830e-01f, 1.82059973e-01f, -4.26151156e-01f, -7.66272377e-03f, 7.97201842e-02f, 1.50898099e-01f, -2.96028763e-01f, 1.13147363e-01f, -2.60197550e-01f, 2.93117762e-01f,
  -1.25020056e-03f, -3.89186665e-02f, 9.41165835e-02f, 1.76739097e-02f, -1.69120267e-01f, 1.17262848e-01f, 2.52227366e-01f, -9.43755731e-02f, -1.10246859e-01f, 3.60398203e-01f,
  3.73056710e-01f, -3.50931972e-01f, -1.44392341e-01f, -3.05683523e-01f, -1.65939033e-01f, 3.48975927e-01f, 3.16181057e-03f, 3.88211794e-02f, 2.35075936e-01f, -5.01157880e-01f,
  1.52552836e-02f, -2.40847975e-01f, 3.08711559e-01f, -3.55756551e-01f, -3.64397258e-01f, -1.67583182e-01f, -1.41998887e-01f, 2.12744370e-01f, -1.58404201e-01f, -1.07326349e-02f,
  2.76789695e-01f, 1.54967979e-01f, -4.82563525e-01f, -1.20561264e-01f, -5.11480391e-01f, -3.19331735e-02f, -8.36250372e-03f, 2.35829562e-01f, -8.74928087e-02f, -5.66189550e-02f,
  -9.51655507e-02f, 3.11747938e-01f, -1.11211479e-01f, 1.54233456e-01f, 2.61270642e-01f, -1.52219549e-01f, -4.46930498e-01f, -1.45467594e-01f, 4.33571994e-01f, 7.63679892e-02f,
  -4.19690520e-01f, 7.35968649e-02f, -2.56110787e-01f, 1.88558936e-01f, 2.11151075e-02f, -1.17855676e-01f, 3.17839049e-02f, -2.19673738e-01f, 2.52421468e-01f, -4.85934168e-01f,
  3.99356075e-02f, -1.72822714e-01f, -1.07436702e-01f, -7.50187486e-02f, 1.16879851e-01f, 3.37137461e-01f, 3.75286490e-01f, -7.47494549e-02f, -3.00566852e-01f, -7.96524435e-02f,
  2.68941462e-01f, 2.21797377e-02f, 1.14561714e-01f, 2.27488339e-01f, 5.90743050e-02f, -1.77488755e-02f, 3.03059787e-01f, 1.48190126e-01f, 1.75371811e-01f, -2.89460607e-02f,
  -1.10020153e-01f, 1.72615513e-01f, -3.32137108e-01f, 1.47981822e-01f, 2.06997007e-01f, 2.09473625e-01f, 3.86048883e-01f, 7.62493163e-02f, 2.43220091e-01f, 8.64339527e-03f,
  3.04464787e-01f, 3.44454139e-01f, 4.29546535e-01f, 9.71023645e-03f, -1.57981753e-01f, 4.64114815e-01f, -2.94927210e-01f, 5.46020530e-02f, 2.85436660e-01f, -6.22728840e-02f,
  7.09795742e-04f, -2.30619475e-01f, 5.97145297e-02f, 9.69825760e-02f, 6.56406358e-02f, 3.44475389e-01f, 1.44208953e-01f, -3.03850293e-01f, 2.83831716e-01f, -2.84906507e-01f,
  -5.79428911e-01f, -7.71636739e-02f, -8.12796578e-02f, 4.74578626e-02f, 8.10475051e-02f, 2.09523186e-01f, -5.14515996e-01f, -3.41172010e-01f, 1.97240070e-01f, -2.18853310e-01f,
  -1.21362567e-01f, -3.06825101e-01f, 5.51497517e-03f, 1.10727780e-01f, 2.50199497e-01f, -2.91726530e-01f, -3.17698181e-01f, -2.29099412e-02f, 2.48712063e-01f, -2.81424135e-01f,
  4.63443995e-02f, 2.64238596e-01f, -1.33915216e-01f, 5.36381751e-02f, 1.18972160e-01f, -1.04585573e-01f, 1.95167467e-01f, -1.41681924e-01f, 3.25108856e-01f, 8.88781250e-02f,
  1.58825621e-01f, -2.05916896e-01f, -1.13376446e-01f, -4.74091828e-01f, -3.05010706e-01f, 4.59568053e-02f, 1.48574308e-01f, 4.01569217e-01f, 2.72336155e-01f, -2.00957190e-02f,
  -1.61841288e-01f, -3.56024772e-01f, 2.69503057e-01f, -4.63407964e-01f, 7.96452835e-02f, 1.20307244e-01f, 1.23041026e-01f, 3.90814841e-01f, -4.33106780e-01f, -3.35876167e-01f,
  -8.52549002e-02f, -2.79729038e-01f, 2.27436721e-01f, -4.38133962e-02f, -5.18735766e-01f, -1.74006820e-01f, -8.08263421e-02f, -1.80853277e-01f, -4.00347203e-01f, -1.33819863e-01f,
  3.17384571e-01f, -9.90949012e-03f, -3.64501774e-01f, 3.54472637e-01f, -2.25071073e-01f, 6.92071021e-02f, 3.07448301e-02f, -8.82706419e-02f, 2.26718694e-01f, -2.32731119e-01f,
  -1.55196577e-01f, 2.24274740e-01f, 3.53372484e-01f, 9.89770293e-02f, -2.78725535e-01f, -1.19884685e-01f, -3.58557791e-01f, 3.64247821e-02f, 1.16836928e-01f, 1.57448575e-02f,
  -4.55326080e-01f, -4.20207500e-01f, -1.15682535e-01f, -1.17590234e-01f, -2.74483532e-01f, -2.70276397e-01f, -1.08519681e-01f, 2.46612012e-01f, -8.18334967e-02f, -1.35904700e-01f,
  5.97667247e-02f, 7.39187673e-02f, 7.03523606e-02f, -1.30675528e-02f, -7.50043690e-02f, 7.32065514e-02f, -3.11976850e-01f, 2.37331718e-01f, 2.13902012e-01f, -1.14496484e-01f,
  2.47257873e-01f, -2.27476507e-01f, 6.54913783e-02f, 7.16328174e-02f, -3.65657717e-01f, 2.91868955e-01f, 1.85404524e-01f, -1.78135291e-01f, 1.70460269e-01f, 1.27787352e-01f,
  -8.45247433e-02f, 3.28707742e-04f, -2.52612680e-01f, -3.18542004e-01f, 3.97906661e-01f, -3.08864623e-01f, 1.69460565e-01f, 3.51371258e-01f, 2.93464273e-01f, 1.24606483e-01f,
  1.90656736e-01f, -4.44669515e-01f, -1.23726325e-02f, 2.03051284e-01f, -1.45176291e-01f, -2.58757293e-01f, 4.08027083e-01f, 3.84763569e-01f, 1.04437709e-01f, -5.61233098e-03f,
  -4.66337413e-01f, -3.68063807e-01f, -2.88041502e-01f, 3.77324849e-01f, -3.41453761e-01f, 1.03430457e-01f, -5.84442496e-01f, 3.73701036e-01f, 2.04811797e-01f, -7.08337650e-02f,
  -2.95997441e-01f, 9.95537788e-02f, -1.86276570e-01f, 4.94111665e-02f, -2.23390371e-01f, -1.26670718e-01f, -4.82349843e-02f, 2.09456503e-01f, -2.30341583e-01f, -2.73425281e-01f,
  -2.49498069e-01f, -4.27372009e-01f, -2.79010475e-01f, -9.33314264e-02f, 2.81111240e-01f, 5.51951453e-02f, 1.92913622e-01f, -2.39955783e-01f, 3.45858246e-01f, -2.74874032e-01f,
  -5.45739094e-05f, -3.22302133e-01f, -3.59727442e-01f, -4.29176837e-01f, -5.37593141e-02f, -2.04397142e-01f, -9.42102373e-02f, 3.17112744e-01f, -1.89132050e-01f, 2.82766014e-01f,
  -2.08111450e-01f, -2.59311587e-01f, 5.54470085e-02f, 2.42784604e-01f, -1.43836811e-02f, -1.35823265e-01f, 5.56726418e-02f, -9.34156328e-02f, 3.23834240e-01f, 2.44278654e-01f,
  1.77006841e-01f, -1.58333957e-01f, -1.92266494e-01f, 3.34047750e-02f, -1.21662691e-01f, -3.11661929e-01f, 1.78061396e-01f, -1.42814606e-01f, 4.25202847e-02f, 4.17226076e-01f,
  -1.93362132e-01f, -1.03121184e-01f, 2.69776940e-01f, 3.58249307e-01f, -3.91611010e-01f, -1.57174412e-02f, -3.45681876e-01f, -8.34760368e-02f, 1.93646342e-01f, 3.55944745e-02f,
  -3.63631189e-01f, -2.65978009e-01f, -4.38431948e-01f, 2.15574831e-01f, -3.55711222e-01f, -3.10741365e-01f, -9.98441949e-02f, -2.43862614e-01f, 1.68887362e-01f, -8.82245153e-02f,
  -2.00178325e-02f, -4.81106341e-01f, -2.92103976e-01f, -1.04139864e-01f, -2.33896926e-01f, -6.89065218e-01f, -1.12929881e-01f, -1.62267517e-02f, -5.54763861e-02f, -1.88470617e-01f,
  -2.39743963e-01f, -1.12205774e-01f, -4.46023047e-02f, -1.51121557e-01f, -6.76018223e-02f, -8.02031755e-02f, -2.07244575e-01f, -8.24929252e-02f, -2.06259653e-01f, 5.61093017e-02f,
  -1.59347534e-01f, -7.42327496e-02f, -2.48588383e-01f, -2.31776252e-01f, -2.17396930e-01f, -4.55091856e-02f, -6.76831901e-02f, -2.26367518e-01f, -1.27889171e-01f, 3.25565338e-02f,
  2.93014884e-01f, 2.89339602e-01f, 1.46937937e-01f, 7.35492706e-02f, -1.36669755e-01f, 2.67100364e-01f, -2.07001477e-01f, -1.66316256e-02f, 2.02320710e-01f, -2.51838475e-01f,
  1.88051164e-01f, -8.46565217e-02f, -3.19528520e-01f, -2.66623288e-01f, -2.30404437e-01f, -1.60061359e-01f, 2.17712685e-01f, -9.47940350e-02f, 1.54001415e-01f, -1.83033913e-01f,
  2.39493400e-02f, -2.27474511e-01f, -1.19114265e-01f, -2.01615408e-01f, -2.13597585e-02f, -5.10246977e-02f, -1.04432918e-01f, -1.33400694e-01f, 2.87888288e-01f, -1.59890562e-01f,
  -2.99329579e-01f, 1.80044636e-01f, 3.00117105e-01f, -1.97906733e-01f, -4.59895357e-02f, -2.90252328e-01f, 2.27207109e-01f, -3.51207644e-01f, -4.12876345e-02f, 2.19812497e-01f,
  6.16807118e-02f, -3.43623579e-01f, 2.10620418e-01f, -8.13929215e-02f, -8.39373544e-02f, 3.14255148e-01f, 2.70923167e-01f, 1.01925038e-01f, -1.77612826e-01f, -1.46227419e-01f,
  1.04220882e-01f, -1.97678134e-01f, -5.01669338e-03f, 1.14310414e-01f, 2.99647540e-01f, -2.63732821e-01f, -1.02252066e-01f, -1.95432566e-02f, -1.39702156e-01f, 4.55978252e-02f,
  -2.66272813e-01f, -2.56797850e-01f, 9.87567008e-02f, -1.73093721e-01f, -2.80550450e-01f, -2.01475158e-01f, 1.11626796e-01f, 7.65870744e-03f, -1.69312701e-01f, 9.49874446e-02f,
  -8.98208171e-02f, -9.93723869e-02f, 1.08104773e-01f, 2.77601302e-01f, -1.06917985e-01f, -2.34929118e-02f, -9.65578631e-02f, -2.16855988e-01f, -1.10978425e-01f, 2.21917897e-01f,
  -1.65525064e-01f, -2.30141491e-01f, -1.14058048e-01f, -1.16063491e-01f, -9.29482058e-02f, 1.28516838e-01f, -1.16589785e-01f, 2.28306949e-01f, -1.47559777e-01f, 1.55442685e-01f,
  1.45146176e-01f, 2.20145628e-01f, -3.27881455e-01f, -3.02104026e-01f, -2.84030348e-01f, -2.21452247e-02f, -1.71618402e-01f, -3.18179995e-01f, -2.03712970e-01f, -1.73032567e-01f,
  -2.30382070e-01f, -1.37115791e-02f, 1.59184799e-01f, -2.42426679e-01f, -1.20837754e-02f, -6.98364154e-02f, -2.74048269e-01f, -8.79245251e-02f, 4.92231399e-02f, -1.77968577e-01f,
  8.92772619e-03f, -6.48024678e-02f, 2.36965213e-02f, -7.52515122e-02f, -4.11471426e-02f, -8.63128453e-02f, 1.23312451e-01f, -2.17836425e-01f, 2.34666750e-01f, 1.48376524e-01f,
  -2.32293725e-01f, -2.68907487e-01f, 2.15569213e-01f, 7.17053711e-02f, 4.13152166e-02f, 7.26779476e-02f, -2.09777042e-01f, -3.16212684e-01f, -1.29206389e-01f, 1.35315284e-01f,
  -1.27743840e-01f, -2.58811474e-01f, -2.25066870e-01f, 1.85865358e-01f, -8.31852704e-02f, -2.58234382e-01f, -2.31397644e-01f, -2.20425695e-01f, 1.51314110e-01f, 1.39813930e-01f,
  -1.61263108e-01f, 6.56765187e-03f, -2.31874257e-01f, 7.65860602e-02f, -1.88931301e-01f, 3.01217705e-01f, 6.90841898e-02f, -1.16985515e-01f, -2.35689640e-01f, -1.05699226e-01f,
  -2.29087278e-01f, -3.16093564e-01f, 3.12867582e-01f, -1.18593834e-01f, -2.15865105e-01f, 2.25101754e-01f, -1.63502589e-01f, -2.66166121e-01f, -3.64669740e-01f, -6.83574453e-02f,
  1.73410058e-01f, 1.48299769e-01f, -1.71667382e-01f, -1.63475409e-01f, -1.88989952e-01f, -8.62789974e-02f, 2.09490374e-01f, -2.41590142e-01f, -1.24559209e-01f, -4.42390740e-02f,
  -1.31283194e-01f, 3.74415033e-02f, -1.35706916e-01f, -7.93284774e-02f, 3.12101483e-01f, -2.01661721e-01f, 2.42715135e-01f, -7.52674788e-02f, 1.46013992e-02f, -3.02243352e-01f,
  -1.77840754e-01f, -2.07013950e-01f, -2.53956169e-01f, -1.75428048e-01f, 1.93434507e-01f, 1.10850602e-01f, 6.18075132e-02f, -2.82590777e-01f, 2.13571191e-01f, -3.53292301e-02f,
  -3.24520409e-01f, -1.28830001e-01f, -2.86888719e-01f, -3.21660072e-01f, -9.50913429e-02f, 2.93520510e-01f, -2.71532744e-01f, 2.06593290e-01f, -2.35715121e-01f, -1.96229085e-01f,
  -3.23124647e-01f, -1.96900368e-01f, -2.99559712e-01f, 3.10209006e-01f, 3.18060130e-01f, 4.52250764e-02f, -1.55860409e-01f, -2.22015381e-01f, 3.16283941e-01f, -2.69177765e-01f,
  -2.34964758e-01f, -1.67247325e-01f, 9.53714475e-02f, -1.51806071e-01f, 1.40506402e-03f, -9.36281756e-02f, 3.26422960e-01f, -1.77692384e-01f, 2.09128156e-01f, -2.70130008e-01f,
  -4.16365489e-02f, 6.33050203e-02f, -2.13553876e-01f, 3.43383491e-01f, -4.70229089e-02f, -4.86568473e-02f, -2.98484266e-01f, -2.23569348e-01f, -6.22723289e-02f, 1.28693089e-01f,
  6.24658838e-02f, 3.06321979e-01f, 1.10267274e-01f, -1.44821152e-01f, -3.69964330e-03f, 1.68310732e-01f, 7.03792647e-02f, 6.02878556e-02f, 2.56107356e-02f, 1.20772049e-01f,
  -4.87648547e-02f, -3.51416715e-03f, -1.65243428e-02f, 8.49295482e-02f, -2.98673958e-01f, -3.41006994e-01f, -2.81533927e-01f, -1.80692226e-01f, -2.51996458e-01f, -1.23860024e-01f,
  1.80942267e-01f, -1.45113617e-01f, 1.65512115e-01f, -2.62136132e-01f, 2.70585686e-01f, 3.89950983e-02f, 1.96895912e-01f, 2.26854503e-01f, 1.81240603e-01f, 2.47752905e-01f,
  1.22491524e-01f, -4.01044101e-01f, -4.89636846e-02f, -1.67036727e-01f, -2.09922642e-01f, -1.36849985e-01f, -9.58979800e-02f, -4.69288468e-01f, -1.55877456e-01f, 1.10393211e-01f,
  -8.17210972e-03f, -1.95316076e-02f, 4.30072039e-01f, -2.01784819e-01f, -9.18165594e-02f, -4.52456810e-02f, -2.85479218e-01f, -3.79627019e-01f, -1.90399572e-01f, -4.98565376e-01f,
  2.89871454e-01f, -2.14246660e-01f, 1.74453288e-01f, -2.40957811e-01f, -3.03275645e-01f, -3.58246602e-02f, 1.58570692e-01f, 4.35788751e-01f, -1.35163501e-01f, -9.80032086e-02f,
  -3.74961972e-01f, -1.83854461e-01f, 3.71806115e-01f, 1.82697311e-01f, -1.92054585e-01f, 3.88616949e-01f, 3.79990995e-01f, 3.99874598e-01f, -2.40051553e-01f, -4.06265050e-01f,
  -1.76930159e-01f, -2.09964558e-01f, -2.64118344e-01f, -3.56919259e-01f, -3.11144769e-01f, -2.25818902e-01f, 2.06368536e-01f, -4.04837012e-01f, -3.07157665e-01f, 2.18924373e-01f,
  1.01559289e-01f, -2.19567139e-02f, -2.51695633e-01f, 3.42887074e-01f, 1.70405403e-01f, -1.29281610e-01f, -4.06618834e-01f, -8.13710317e-02f, -1.61182880e-01f, -4.79034096e-01f,
  1.76899061e-01f, -9.00555849e-02f, 2.70977139e-01f, -4.28227037e-01f, 1.08256325e-01f, -1.44158676e-01f, -2.53509264e-02f, -2.86940672e-02f, 3.13572168e-01f, 1.69088125e-01f,
  1.82824358e-01f, -2.30786100e-01f, 1.69564579e-02f, -3.45438004e-01f, -3.31910878e-01f, -1.94464087e-01f, -1.65586546e-01f, 3.10480863e-01f, -7.37024695e-02f, 2.54922509e-01f,
  -4.61706161e-01f, -2.89711356e-01f, -3.07416379e-01f, -1.57388270e-01f, -2.77793825e-01f, -1.72722891e-01f, 1.14048548e-01f, 1.43717483e-01f, -2.91533712e-02f, -4.31838125e-01f,
  -3.13051611e-01f, -1.98599160e-01f, -2.21286803e-01f, 1.65243372e-01f, 3.11631570e-03f, -4.23398949e-02f, 3.11959654e-01f, -1.99671298e-01f, -1.65840998e-01f, 2.24550515e-01f,
  7.11128712e-02f, 1.26913846e-01f, 1.05115324e-01f, 1.82200462e-01f, 8.06766376e-02f, 1.47527084e-01f, 9.00875553e-02f, 2.09238350e-01f, 9.14261192e-02f, 9.85409543e-02f,
  8.55373144e-02f, 1.21197604e-01f, 2.20006749e-01f, -1.54016182e-01f, -2.38403633e-01f, -1.67721063e-01f, 1.58731103e-01f, 2.26189420e-01f, 1.82507813e-01f, -3.37965935e-02f,
  -3.21429461e-01f, -1.97001293e-01f, -2.10936248e-01f, 5.96347190e-02f, -2.36547753e-01f, -3.18806380e-01f, -2.45834328e-02f, -5.45453764e-02f, -1.96733639e-01f, 2.11495534e-02f,
  -1.00077942e-01f, 3.21269035e-01f, 6.26184717e-02f, 1.56776980e-01f, 2.61524051e-01f, 2.81521995e-02f, 2.70668596e-01f, -2.95867056e-01f, -1.51446536e-01f, -9.68640596e-02f,
  -1.26683876e-01f, 2.23843366e-01f, -2.36738399e-01f, 3.29786450e-01f, -2.77120233e-01f, -2.40351871e-01f, 3.90287310e-01f, 4.73215841e-02f, 5.36563620e-02f, -1.48672283e-01f,
  -2.95530438e-01f, 3.36918920e-01f, -4.45876904e-02f, -3.77303660e-02f, -2.22717196e-01f, -2.48513490e-01f, 2.42019375e-03f, -3.02633233e-02f, -4.62900013e-01f, 1.61507800e-01f,
  -2.31941149e-01f, 1.68319166e-01f, 4.19932395e-01f, -2.11251602e-02f, -1.15441330e-01f, -5.81476241e-02f, -3.29877377e-01f, 3.06256056e-01f, -8.98085013e-02f, 3.55408877e-01f,
  -2.21896380e-01f, -1.55891433e-01f, -9.66616273e-02f, -3.63889597e-02f, -6.30423725e-02f, 1.04560353e-01f, -3.84856611e-01f, -9.63215455e-02f, 1.12560801e-02f, -2.27449551e-01f,
  -3.92050475e-01f, -2.10078135e-01f, -2.46033251e-01f, 3.67954761e-01f, 1.67135835e-01f, -3.00457984e-01f, 2.31679931e-01f, -1.09995812e-01f, -3.77994776e-01f, 2.62910724e-01f,
  -2.50148475e-01f, -1.16016671e-01f, -1.31721199e-01f, -8.93940479e-02f, 2.95345217e-01f, 3.86495650e-01f, -4.22516577e-02f, -3.28115284e-01f, -6.38789907e-02f, -3.69745374e-01f,
  -4.43384439e-01f, -3.01839292e-01f, 1.39943302e-01f, -2.66190842e-02f, 1.98770672e-01f, -1.79951400e-01f, 1.78278182e-02f, -4.12563771e-01f, -2.93244243e-01f, -3.94970566e-01f,
  3.25097531e-01f, -4.77043480e-01f, -6.16020784e-02f, -1.46017298e-02f, -3.80882442e-01f, 2.14201033e-01f, -1.47251030e-02f, -2.20167026e-01f, -4.27947789e-01f, -1.74572140e-01f,
  -8.03863108e-02f, -1.63130194e-01f, -2.34201878e-01f, 1.18611222e-02f, -3.82815421e-01f, 2.93556035e-01f, 2.42088363e-01f, -4.48943563e-02f, -5.07315435e-02f, 1.20481374e-02f,
  2.05538492e-03f, -1.85312610e-02f, 1.89074930e-02f, -9.44546387e-02f, 5.56515194e-02f, 1.27895519e-01f, 4.45485711e-02f, -1.52304247e-01f, -2.84188502e-02f, 9.64751765e-02f,
  -1.36321157e-01f, -1.15652069e-01f, 2.63808608e-01f, -2.78165549e-01f, -1.10662945e-01f, 2.92008430e-01f, -3.05465728e-01f, 2.98863381e-01f, 2.72251189e-01f, 3.17963272e-01f,
  2.25768343e-01f, -4.52443883e-02f, 1.70457289e-01f, -2.45266125e-01f, -1.68741927e-01f, -3.24766576e-01f, 6.77887872e-02f, 2.30083331e-01f, 3.52624059e-01f, -1.14629827e-01f,
  -2.73272004e-02f, -3.82944256e-01f, -2.78325826e-01f, -6.45681424e-03f, 1.71698868e-01f, -1.58057004e-01f, -2.80931383e-01f, -2.73199588e-01f, -4.01092321e-02f, -1.15336135e-01f,
  1.95909813e-01f, 5.24444245e-02f, -3.26119572e-01f, 4.03660297e-01f, -2.09746599e-01f, 2.20040292e-01f, -3.37380022e-01f, 3.33855897e-01f, -2.24095330e-01f, -1.01576328e-01f,
  -2.70479888e-01f, -3.11072707e-01f, 2.21396647e-02f, -3.46438199e-01f, 1.02102354e-01f, -2.44490027e-01f, -1.83026150e-01f, 1.71073765e-01f, -2.82324821e-01f, 3.09870914e-02f,
  -1.22038819e-01f, 3.76195833e-02f, -7.12319314e-02f, -2.06227586e-01f, -9.20453891e-02f, -1.14414833e-01f, -4.19778287e-01f, -3.44618708e-02f, 2.42149010e-01f, 4.08235282e-01f,
  -2.74450898e-01f, -2.68659979e-01f, 4.01415259e-01f, 1.19591668e-01f, 6.38919845e-02f, 1.52927786e-02f, -1.84358299e-01f, -2.04063043e-01f, 6.53581992e-02f, -2.87025064e-01f,
  1.72669694e-01f, -2.06716537e-01f, 1.80309698e-01f, 2.17034727e-01f, -3.48504372e-02f, -8.07150975e-02f, 2.17188597e-01f, 3.03466886e-01f, -2.44734302e-01f, 2.25970328e-01f,
  -3.12664181e-01f, -2.91720957e-01f, -2.51844347e-01f, -2.34517708e-01f, 3.82437289e-01f, -1.58179864e-01f, -2.89422214e-01f, -3.05061728e-01f, 2.36419261e-01f, 1.47596151e-01f,
  -1.69703394e-01f, -1.50322512e-01f, -3.67974043e-01f, -1.38541326e-01f, 1.42614499e-01f, -1.80473074e-01f, -3.57670218e-01f, -3.04587126e-01f, -8.52171518e-03f, 8.06352217e-03f,
  8.15588906e-02f, 6.57432992e-03f, -3.03489566e-01f, -1.70578644e-01f, 3.69376957e-01f, 3.92251700e-01f, -2.31205508e-01f, 2.25101560e-01f, -2.25880012e-01f, -1.65481940e-01f,
  -2.35855788e-01f, -1.63727835e-01f, 6.02484448e-03f, -2.56421268e-01f, 1.91244364e-01f, -1.08550183e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -7.72075653e-02f, 5.54236434e-02f, -1.06093667e-01f, 2.58614663e-02f, 1.22709185e-01f, 5.26054204e-02f, 6.12843856e-02f, -1.62142903e-01f, -5.25809219e-03f, -6.06870791e-03f,
  -2.51653641e-02f, 7.85399079e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    