/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.66728020e-01f, 1.19866438e-01f, -2.79444635e-01f, 2.71023691e-01f, 1.59254614e-02f, 1.01948678e-01f, 4.17582452e-01f, -8.08495134e-02f, -1.03214726e-01f, 1.81427166e-01f,
  -9.70503539e-02f, -8.74021463e-03f, 9.32497606e-02f, 9.30026546e-02f, 1.42645329e-01f, 1.34453073e-01f, 9.31141078e-02f, 4.10871506e-02f, 1.31341815e-01f, 2.26980314e-01f,
  2.24689469e-01f, 1.45153537e-01f, -1.43190950e-01f, -1.49635032e-01f, 8.65926966e-02f, 4.32587229e-02f, -1.61465243e-01f, -1.01612076e-01f, -1.14180788e-01f, 7.47002512e-02f,
  2.14914918e-01f, -7.86594115e-03f, 2.58644857e-02f, -6.06344789e-02f, -2.22296845e-02f, -7.44928196e-02f, 2.85349581e-02f, -6.51396215e-02f, -6.41876459e-02f, 4.14897874e-03f,
  -9.81690437e-02f, -1.17603146e-01f, 1.16747264e-02f, -6.03689440e-02f, 3.67833376e-02f, -2.77791861e-02f, -8.44623744e-02f, 3.14280167e-02f, -4.45344038e-02f, 1.30025283e-01f,
  9.73543152e-02f, -2.41836123e-02f, -1.16854191e-01f, -7.92268477e-03f, 3.81575637e-02f, -8.36470947e-02f, 1.88650563e-02f, -9.75164995e-02f, -1.94756463e-01f, 1.58588197e-02f,
  -4.50368650e-04f, -1.70638803e-02f, 1.45811783e-02f, 1.48792816e-02f, 8.71886835e-02f, -4.12694328e-02f, -3.59682292e-02f, -1.30513171e-02f, 1.77808404e-02f, -3.50314239e-03f,
  -2.45399661e-02f, -3.81352045e-02f, -5.47447649e-04f, 9.70120821e-03f, 7.88539574e-02f, -5.30805252e-02f, 2.27321647e-02f, 3.77960987e-02f, -3.05171330e-02f, -3.38141993e-02f,
  6.80214092e-02f, -5.57028316e-02f, 1.54190408e-02f, -5.65205282e-03f, 4.64621224e-02f, 8.16499293e-02f, 3.50677408e-02f, -9.47407633e-03f, 3.79992686e-02f, -1.16467752e-01f,
  1.08215198e-01f, -9.57194343e-02f, 4.28438671e-02f, -5.53981459e-04f, -5.15830107e-02f, -1.11342045e-02f, -3.15995030e-02f, 2.44493484e-02f, -7.31444955e-02f, -3.53334025e-02f,
  -4.50022426e-03f, 7.06287026e-02f, -2.97251847e-02f, -2.69764531e-02f, 2.15448923e-02f, 2.91463323e-02f, -5.91378426e-04f, 1.01778461e-02f, -7.26781189e-02f, -8.43739808e-02f,
  -6.65838048e-02f, 6.82040229e-02f, 1.36247963e-01f, -2.27090679e-02f, 2.05898862e-02f, 7.74897337e-02f, -3.11922766e-02f, 1.14087872e-01f, -4.07130793e-02f, 1.76345259e-01f,
  8.07610452e-02f, 9.60768759e-02f, 2.03137785e-01f, -2.66855001e-01f, 1.42205343e-01f, 3.12179416e-01f, 6.01453602e-01f, 1.75537035e-01f, -3.03042471e-01f, 8.94419998e-02f,
  1.63152888e-01f, -2.18888611e-01f, -4.37823609e-02f, -1.22031510e-01f, 1.60664842e-01f, 1.66524932e-01f, -1.34035468e-01f, -1.35253578e-01f, 3.70325260e-02f, -3.44597511e-02f,
  -1.26690477e-01f, 1.64907780e-02f, -1.22492492e-01f, -3.67207304e-02f, -1.59613863e-01f, -3.04918252e-02f, 2.02997610e-01f, 2.33940571e-03f, 1.19466558e-01f, -4.33937073e-01f,
  1.47158474e-01f, 5.65958843e-02f, -7.89858028e-02f, -2.74889134e-02f, 6.97041452e-02f, -4.62175757e-02f, -2.01302078e-02f, 2.22721905e-03f, 6.25686198e-02f, 7.04303663e-03f,
  -9.46520492e-02f, -7.07832947e-02f, 5.19494563e-02f, -2.03627869e-02f, 6.98910877e-02f, 2.46416125e-03f, -2.53096335e-02f, -7.43371323e-02f, -4.95511480e-02f, 5.75774759e-02f,
  -1.52780801e-01f, 9.78314579e-02f, 2.60373294e-01f, 1.56376764e-01f, 9.27678272e-02f, -1.73562970e-02f, 9.97973830e-02f, -2.81478819e-02f, 5.05282804e-02f, 5.23168780e-02f,
  -1.36398226e-02f, -3.61589640e-02f, 1.79121476e-02f, -7.40249222e-03f, -3.87103707e-02f, 4.65554781e-02f, -3.72712165e-02f, 1.94149632e-02f, -8.20999369e-02f, -2.76874267e-02f,
  6.92545772e-02f, -1.01583516e-02f, 1.19113643e-02f, 4.48485464e-02f, -4.48453426e-03f, -4.06916365e-02f, 4.85753873e-04f, 8.44429210e-02f, -1.69112645e-02f, 3.69989835e-02f,
  2.28246837e-03f, -5.33101000e-02f, 3.87084000e-02f, -3.09690256e-02f, 5.15445322e-02f, -6.31159544e-02f, -7.05537423e-02f, 1.83590520e-02f, -4.61140424e-02f, 1.78277194e-02f,
  -5.07148951e-02f, 1.33338660e-01f, -4.83607650e-02f, -6.74280748e-02f, -6.59016892e-02f, -7.07346387e-03f, -1.56546906e-02f, -7.51411468e-02f, 1.86000839e-02f, 2.82234661e-02f,
  4.44721840e-02f, 1.16905931e-03f, 6.92306738e-03f, -3.16191278e-02f, 2.39643492e-02f, -2.78371219e-02f, -3.75880860e-02f, 3.46736200e-02f, -7.12887803e-03f, -5.75669017e-03f,
  -2.29545403e-03f, 3.70563157e-02f, 5.99222742e-02f, 4.34696190e-02f, -1.78256538e-02f, 8.52737855e-03f, 1.72253117e-01f, -3.35274898e-02f, 1.94822058e-01f, 1.20227411e-01f,
  3.26414049e-01f, 4.29860875e-02f, 4.02531296e-01f, 1.73184261e-01f, 9.62249935e-02f, 1.05857015e-01f, 1.79369360e-01f, 7.07192793e-02f, -1.48282826e-01f, 1.21662214e-01f,
  -1.05126850e-01f, -2.48204842e-01f, -2.35643312e-01f, -1.39898002e-01f, 3.14589143e-02f, 1.32305950e-01f, 1.44396245e-01f, 1.08303450e-01f, 1.95798669e-02f, 2.53032446e-02f,
  -1.71534657e-01f, 8.89165029e-02f, 2.57662833e-01f, 8.11672211e-03f, 4.49258126e-02f, -3.19985032e-01f, 1.69704705e-01f, 1.42736837e-01f, -1.18162610e-01f, 2.22729340e-01f,
  6.52099550e-02f, 2.12186217e-01f, 5.57732061e-02f, 8.31988677e-02f, -1.47404969e-02f, -3.56707610e-02f, -4.75758724e-02f, 3.12492810e-03f, -7.07288235e-02f, 1.00381553e-01f,
  -1.51408501e-02f, -2.79655773e-03f, -1.80164184e-02f, -1.01121543e-02f, 8.46590921e-02f, 3.96594554e-02f, 6.26302436e-02f, 6.01382591e-02f, 9.14109347e-04f, 6.19996265e-02f,
  -9.31293145e-02f, 1.58605978e-01f, 1.85388044e-01f, -6.15944806e-03f, -5.61566697e-03f, -1.21630486e-02f, 7.06940843e-03f, 4.08220775e-02f, 3.26745845e-02f, -3.63356713e-03f,
  2.90893968e-02f, 1.35267861e-02f, -2.05958802e-02f, 2.75109019e-02f, -2.25868598e-02f, -7.14351283e-03f, 1.93128418e-02f, -4.12635952e-02f, -1.86669230e-02f, 3.75002474e-02f,
  -3.55831683e-02f, 7.62915537e-02f, -9.44553129e-03f, 1.18347235e-01f, -2.56320871e-02f, 4.43105735e-02f, -1.25522539e-02f, 1.91905573e-02f, 1.75611209e-02f, 6.04937226e-03f,
  -5.88286147e-02f, -2.36812104e-02f, -1.46574788e-02f, -1.00254849e-01f, 6.19756877e-02f, -4.46791127e-02f, -7.82778580e-03f, 2.71593835e-02f, -1.08306855e-02f, 3.45146544e-02f,
  -1.73717797e-01f, 1.13728652e-02f, -3.01893838e-02f, -1.04616053e-01f, 6.15167543e-02f, -5.30448416e-03f, 2.80782748e-02f, -3.37664448e-02f, 1.37759680e-02f, -5.67627139e-02f,
  9.58066210e-02f, -2.18619686e-02f, 2.49870662e-02f, 9.04950202e-02f, 3.06039564e-02f, -3.05995885e-02f, -6.15354851e-02f, 1.05119646e-01f, -7.81099079e-03f, -2.80134697e-02f,
  -3.40894610e-02f, -1.40542295e-02f, -3.13121453e-02f, 1.21828755e-02f, -6.13070503e-02f, -1.29822828e-03f, -3.40399258e-02f, 4.35170271e-02f, -5.80587201e-02f, -1.09209448e-01f,
  1.77858472e-01f, -3.45232189e-01f, 1.92878395e-01f, -1.03013776e-01f, -2.02344537e-01f, 1.50980204e-01f, -4.59900908e-02f, 9.92832780e-02f, -7.07499608e-02f, -1.12931989e-01f,
  -5.89614846e-02f, 1.93385836e-02f, -1.66409373e-01f, 3.54036726e-02f, 2.78033555e-01f, -1.09362133e-01f, -4.20825779e-01f, 1.89061128e-02f, 5.39699674e-01f, 4.37226593e-01f,
  -1.73274890e-01f, -1.21192615e-02f, 1.24679752e-01f, 1.42078251e-01f, -3.12943667e-01f, 1.00322859e-02f, -2.79623300e-01f, -4.44578044e-02f, -6.99591860e-02f, -7.84965277e-01f,
  2.98358407e-02f, 2.26227138e-02f, 6.07625619e-02f, -7.54497424e-02f, -1.51770517e-01f, -1.18070291e-02f, 1.56358834e-02f, -1.26681417e-01f, 1.95944440e-02f, 3.89752313e-02f,
  1.03716087e-02f, 6.15963191e-02f, 4.55250638e-03f, -6.31412119e-02f, 5.71948104e-02f, 1.51556376e-02f, 4.20591459e-05f, 9.95307565e-02f, -6.60763821e-03f, 9.90454666e-03f,
  -2.01255634e-01f, -1.69340745e-01f, -7.15192109e-02f, 2.25604065e-02f, 2.26294726e-01f, 2.41368096e-02f, 2.51719616e-02f, 7.14319870e-02f, 7.75198117e-02f, -2.06626058e-01f,
  -1.43222576e-02f, 4.93183024e-02f, -4.54984531e-02f, 2.45861541e-02f, 2.97562452e-03f, -3.16512324e-02f, 2.66989172e-02f, 4.04922031e-02f, -7.45092565e-03f, 2.75110062e-02f,
  -1.71597663e-03f, 1.45408632e-02f, -6.69589937e-02f, 5.88117093e-02f, -9.31031723e-03f, -2.71757822e-02f, 6.60585463e-02f, -5.29622585e-02f, -2.92834677e-02f, -3.09755653e-02f,
  1.15246335e-02f, -2.91810371e-02f, -7.54827634e-02f, 2.02558544e-02f, -4.77674082e-02f, 4.18340378e-02f, -4.61435964e-04f, 1.69112161e-02f, 1.02740422e-01f, -4.87920716e-02f,
  -1.12040177e-01f, -5.41042089e-02f, -9.80649218e-02f, 3.85090448e-02f, 2.34769024e-02f, -4.59943078e-02f, -8.87535438e-02f, 4.45658527e-02f, -7.08575845e-02f, -1.59750339e-02f,
  8.90192911e-02f, -1.01154484e-02f, -3.80396806e-02f, 8.17991719e-02f, 6.96372539e-02f, 4.27810140e-02f, -2.29103602e-02f, 1.41518470e-02f, -2.95373984e-02f, -2.87041739e-02f,
  -8.52617435e-03f, -2.18938794e-02f, 3.58043090e-02f, -1.61130100e-01f, -4.05765064e-02f, -4.33083735e-02f, -5.87151460e-02f, 1.06201498e-02f, -1.19439475e-02f, -1.30043462e-01f,
  -6.49733067e-01f, 3.84076349e-02f, -2.12083399e-01f, 9.92727578e-02f, 1.09746773e-02f, -6.98532090e-02f, -3.01646292e-01f, -2.00097766e-02f, 1.80253416e-01f, -8.72973129e-02f,
  -4.49687475e-03f, 1.75773531e-01f, 2.46081576e-01f, 5.07584475e-02f, 2.17402689e-02f, -1.43889457e-01f, -1.36938110e-01f, -1.20708145e-01f, 1.01420537e-01f, 4.12125885e-02f,
  8.26504380e-02f, -8.04356858e-02f, -9.08166841e-02f, 1.51909992e-01f, -1.59810886e-01f, 1.56601831e-01f, -2.24764958e-01f, -2.90879726e-01f, 6.29945695e-02f, -9.25253853e-02f,
  -1.79342806e-01f, -1.74653530e-01f, 1.04106277e-01f, 3.33986580e-02f, -6.47598784e-03f, 1.61924735e-02f, 8.21244270e-02f, -2.91272625e-02f, 6.80917948e-02f, 1.75471548e-02f,
  -4.91524823e-02f, 4.50432673e-02f, 1.47560090e-02f, -3.50887775e-02f, -6.07659929e-02f, -6.20526895e-02f, -7.87521899e-02f, -1.10169481e-02f, -6.49041533e-02f, 5.60462289e-02f,
  7.65671358e-02f, -2.01227799e-01f, -6.29861057e-02f, -2.55857594e-04f, -5.99292070e-02f, 2.11629062e-03f, -7.53736686e-06f, -2.96546216e-03f, -6.34952709e-02f, 1.83731085e-04f,
  -5.71788587e-02f, -1.08050838e-01f, -5.34264781e-02f, 2.20007991e-04f, 4.98595349e-02f, -5.02797775e-02f, -8.44839204e-04f, -8.32791403e-02f, 3.13301049e-02f, -7.38001987e-02f,
  4.71078232e-02f, -3.26763541e-02f, 2.98626963e-02f, 8.28898102e-02f, 5.03858663e-02f, -1.67197421e-01f, -2.04158593e-02f, -2.04847548e-02f, 5.64386733e-02f, 9.80309118e-03f,
  -9.01559368e-03f, 4.28629592e-02f, -1.99167859e-02f, -3.72419544e-02f, 2.15445124e-02f, 2.65049934e-03f, 4.46686223e-02f, 6.08646460e-02f, 4.02507419e-03f, -1.57857388e-02f,
  3.21831316e-01f, 1.22900859e-01f, -4.84852456e-02f, 6.35076687e-02f, -8.28033686e-02f, -7.81644043e-03f, 8.22130367e-02f, -4.68509868e-02f, -5.60354441e-03f, 2.10192502e-02f,
  1.02816336e-01f, 9.22859684e-02f, -2.25856621e-03f, 3.46351899e-02f, 8.33172649e-02f, 8.21901485e-02f, -4.52895053e-02f, 1.97193734e-02f, 1.49830822e-02f, -1.03844851e-01f,
  7.56290508e-03f, 2.92313639e-02f, -3.69598605e-02f, 1.31133482e-01f, 6.36517107e-02f, -2.01212410e-02f, 6.62043542e-02f, 7.18539804e-02f, -3.43759693e-02f, 1.30670154e-02f,
  1.70495674e-01f, -1.92625076e-02f, -2.46697262e-01f, -1.14666834e-01f, -9.89769306e-03f, 3.28848809e-01f, 3.56503308e-01f, 2.63285697e-01f, 7.67674521e-02f, 6.49421513e-02f,
  1.89591825e-01f, -2.47781068e-01f, -1.67467535e-01f, -1.52004302e-01f, 7.33769238e-02f, 9.23724920e-02f, -3.35367918e-01f, -3.96159858e-01f, -7.73001686e-02f, 1.50545910e-01f,
  -7.52019063e-02f, -2.89503366e-01f, -2.31581807e-01f, -1.21709123e-01f, -1.67965800e-01f, -2.40846366e-01f, -1.31483048e-01f, 5.58832437e-02f, 2.54424304e-01f, -6.03455365e-01f,
  4.27330611e-03f, 6.46874309e-02f, 3.59622985e-02f, 1.75891370e-02f, -3.35609242e-02f, 3.80792953e-02f, -7.35259196e-03f, -1.85908392e-01f, 4.80969390e-03f, 5.27839467e-04f,
  -1.35703072e-01f, -3.69915627e-02f, -1.89500656e-02f, -1.84051961e-01f, -6.34352043e-02f, 8.66265371e-02f, -6.26019016e-02f, -6.67110905e-02f, -5.43835275e-02f, 1.15989365e-01f,
  -5.28912805e-02f, -1.13745339e-01f, 2.89455820e-02f, 3.38343084e-02f, 1.92780748e-01f, -1.55759320e-01f, 1.47329107e-01f, 4.23278520e-03f, 1.09632805e-01f, -1.46609828e-01f,
  5.79007342e-02f, -7.05323815e-02f, 1.22216307e-01f, 4.77831177e-02f, -4.89656180e-02f, 7.04775825e-02f, -1.01343855e-01f, -1.92191657e-02f, 1.25184357e-02f, -2.26353407e-02f,
  -4.23675030e-03f, -1.37842949e-02f, 2.71932576e-02f, 2.42097285e-02f, -6.70100451e-02f, -4.84353527e-02f, 3.81491855e-02f, -2.86791604e-02f, -9.43214521e-02f, 3.32060680e-02f,
  3.26043777e-02f, 2.73613799e-02f, -2.69500185e-02f, -5.79594560e-02f, -1.74908563e-02f, -2.05993541e-02f, -8.09805654e-03f, -1.86848659e-02f, 6.28310908e-03f, 4.39166054e-02f,
  6.60970360e-02f, -9.51465592e-03f, -6.47013560e-02f, 1.24851223e-02f, 1.62896067e-02f, 3.74939926e-02f, -4.65139858e-02f, 1.00115553e-01f, -3.75777818e-02f, -1.44979442e-02f,
  4.37004976e-02f, -1.79953910e-02f, 3.60265397e-03f, 5.80772273e-02f, 6.26936480e-02f, 3.11451592e-02f, 2.41438076e-02f, -1.04453705e-01f, 1.93787795e-02f, 3.38337533e-02f,
  -1.63597353e-02f, 2.37635523e-01f, 1.47049367e-01f, 3.84153351e-02f, 2.30371836e-03f, 5.72901256e-02f, -5.70112467e-02f, 7.30118528e-02f, 1.10470749e-01f, 3.16418558e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.92689252e-01f, -3.69994313e-01f, 1.41456634e-01f, 1.56672969e-01f, 1.03032976e-01f, 1.61056265e-01f, 1.41365811e-01f, 9.56131816e-02f, 5.66180497e-02f, 2.09962670e-02f,
  1.01114780e-01f, 3.88817579e-01f, 3.63064438e-01f, 2.69027147e-02f, 9.15603265e-02f, -2.07103327e-01f, -2.40687698e-01f, 1.63659245e-01f, 2.88158685e-01f, 7.78255835e-02f,
  -2.21348368e-02f, -4.40059938e-02f, 4.59067570e-03f, -1.63672552e-01f, -3.99066657e-01f, 3.04410011e-01f, -6.09904341e-02f, -3.92450660e-01f, -8.87116417e-02f, -3.79220277e-01f,
  2.08595339e-02f, 1.51284471e-01f, 2.10292563e-01f, 1.69929862e-01f, -7.70305470e-02f, 8.42004046e-02f, 5.95187917e-02f, -1.15281139e-02f, 5.76430447e-02f, -1.20103210e-01f,
  -7.20312595e-02f, -8.58632848e-02f, 2.52159517e-02f, -1.58620864e-01f, -1.03397138e-01f, 1.60721485e-02f, -1.55248657e-01f, -5.04557826e-02f, -2.22153664e-02f, 9.65159014e-03f,
  -8.49621147e-02f, 7.20034689e-02f, 5.63824847e-02f, -1.24255545e-01f, -4.10292298e-02f, -3.35827805e-02f, -2.08582386e-01f, -1.87222391e-01f, 1.02922097e-01f, -1.34413600e-01f,
  4.91216891e-02f, -1.10053539e-01f, 1.51673988e-01f, 2.49157678e-02f, 6.06170110e-02f, 7.33190328e-02f, -5.79404123e-02f, -1.60143375e-01f, 9.52347517e-02f, -1.77944712e-02f,
  -7.84526169e-02f, 7.27232620e-02f, -2.61876341e-02f, 8.85351747e-02f, 3.40393255e-03f, -1.42516598e-01f, -1.70527063e-02f, 2.77888924e-02f, -7.70149603e-02f, 5.88065945e-03f,
  6.55690730e-02f, 6.35059103e-02f, -7.60636181e-02f, -1.27886504e-01f, 5.77158853e-02f, 3.28342021e-02f, 4.11710292e-02f, 5.15595712e-02f, -2.99196653e-02f, -8.36481005e-02f,
  1.07650273e-01f, 1.34941027e-01f, 1.60166267e-02f, -9.36782882e-02f, -3.35828364e-02f, 2.62295119e-02f, 2.73701642e-02f, -3.56819555e-02f, -1.35365054e-02f, -3.92245203e-02f,
  -7.87854195e-02f, 1.81454688e-01f, -6.29678667e-02f, -1.38510242e-01f, 1.02613024e-01f, -2.09913217e-02f, 2.70564202e-02f, 1.49313927e-01f, 7.06983451e-03f, -1.19888783e-01f,
  -1.85391426e-01f, 2.49805555e-01f, 3.06269944e-01f, 2.25458458e-01f, 3.46569046e-02f, 3.62131178e-01f, 1.41496062e-01f, 2.89268810e-02f, 3.21427792e-01f, 2.89391756e-01f,
  -1.08217084e+00f, 6.71437830e-02f, -7.89577290e-02f, -2.60075063e-01f, 4.36646283e-01f, 2.78907895e-01f, 2.18797401e-02f, -1.27921969e-01f, -5.68759721e-03f, -4.02526297e-02f,
  7.53302053e-02f, 1.17969783e-02f, -1.54417723e-01f, 8.63439441e-02f, -3.33082825e-02f, 1.94580883e-01f, 2.53718138e-01f, -6.35480136e-02f, -7.52121061e-02f, 4.46521677e-02f,
  2.36467704e-01f, -2.74845302e-01f, -3.30384910e-01f, -5.74652925e-02f, -9.84539166e-02f, -4.58228625e-02f, -1.15687586e-01f, -4.85104024e-02f, 1.39311209e-01f, 1.56790808e-01f,
  -2.10391983e-01f, -1.47834912e-01f, 1.15097687e-01f, -7.83096924e-02f, -1.37208020e-02f, -1.91412240e-01f, -9.81825367e-02f, -8.03442150e-02f, -3.81600372e-02f, 8.83965492e-02f,
  3.15408735e-03f, 7.79522657e-02f, -2.99072079e-02f, 2.49485616e-02f, -1.06893800e-01f, 5.48088700e-02f, 3.96648422e-03f, -8.01424459e-02f, 6.43067285e-02f, 5.30723780e-02f,
  2.10768834e-01f, 1.85185626e-01f, -4.20722961e-02f, 5.01410440e-02f, -4.73500341e-02f, 8.99611041e-02f, -3.13584916e-02f, -1.86448393e-03f, 4.51741442e-02f, -2.30563655e-01f,
  3.89793292e-02f, 1.43868206e-02f, 7.45815188e-02f, 6.51123514e-03f, -1.27493711e-02f, -5.20619899e-02f, 5.09375185e-02f, 5.81165850e-02f, 2.67093517e-02f, -7.11544827e-02f,
  4.10140716e-02f, 1.86594948e-03f, 4.99322265e-02f, -6.99187666e-02f, 1.14342207e-02f, 4.34806794e-02f, 9.56392474e-03f, 1.10741137e-02f, -1.38608422e-02f, -1.71081387e-02f,
  -2.41311789e-02f, 4.29011062e-02f, -3.58144827e-02f, 2.67791022e-02f, 9.61081460e-02f, -3.33248191e-02f, 2.90291086e-02f, -3.38666365e-02f, -7.00863376e-02f, -2.69495677e-02f,
  -1.70450807e-01f, 1.52416974e-01f, -2.20185816e-01f, 3.34096816e-03f, 3.79188806e-02f, 6.76669851e-02f, -4.96889241e-02f, 1.67122518e-03f, -9.49753225e-02f, 2.37981565e-02f,
  -5.92545979e-02f, -4.52265739e-02f, -7.12513030e-02f, 2.87629571e-02f, -7.08252713e-02f, -8.26863274e-02f, 7.18265027e-02f, 2.22254656e-02f, -3.22287753e-02f, 5.66810854e-02f,
  1.04966760e-02f, -7.57763237e-02f, -2.43884638e-01f, -7.78210014e-02f, -9.58771408e-02f, -1.54629588e-01f, -2.54126459e-01f, -1.95675313e-01f, -2.25202784e-01f, -3.66290122e-01f,
  -6.44255802e-02f, -5.14971197e-01f, 6.41515255e-01f, -1.97203338e-01f, 2.77291507e-01f, 4.24222887e-01f, 2.05503210e-01f, -7.14421794e-02f, -1.09995201e-01f, 1.14169076e-01f,
  -1.15925685e-01f, -5.46551608e-02f, 1.06055997e-01f, 3.12284492e-02f, -1.15615040e-01f, 1.74855426e-01f, -1.18977785e-01f, 1.84783131e-01f, 4.14506257e-01f, 3.29276651e-01f,
  -1.93773285e-01f, -3.87646258e-01f, -4.35932875e-01f, -1.75989583e-01f, 1.55033305e-01f, 3.29802722e-01f, 7.98275918e-02f, -1.68855384e-01f, 1.73585683e-01f, 6.41489029e-02f,
  5.39621234e-01f, -2.90654510e-01f, 2.64958382e-01f, -4.35331501e-02f, 1.67933330e-02f, -5.18783089e-03f, -1.79701522e-02f, -1.57916844e-01f, -9.31575000e-02f, -6.26935735e-02f,
  -1.31975740e-01f, -1.58367157e-01f, 4.80457954e-02f, -5.71674109e-02f, -7.05018118e-02f, 5.94883561e-02f, -2.72786051e-01f, -1.35342509e-01f, 1.04141243e-01f, 2.05236346e-01f,
  1.36300579e-01f, 1.72433615e-01f, 1.86525017e-01f, 4.54890467e-02f, 2.72778068e-02f, -1.00968532e-01f, 3.27194692e-03f, 2.50319149e-02f, -2.87211519e-02f, 7.77998343e-02f,
  4.79147173e-02f, 3.82187851e-02f, 3.83421332e-02f, 8.43187142e-03f, -9.21545103e-02f, 6.05627038e-02f, 1.07987644e-02f, 1.14148982e-01f, -2.92546712e-02f, 3.17560956e-02f,
  -9.55463424e-02f, 1.42508954e-01f, 1.17225088e-02f, -2.24851798e-02f, 7.67004117e-02f, 1.89390387e-02f, 5.61606586e-02f, -1.58929043e-02f, -9.74471569e-02f, 1.12410486e-02f,
  -9.85821988e-03f, 1.23327285e-01f, -8.81657153e-02f, -7.57939890e-02f, -5.45426719e-02f, -7.38828853e-02f, 6.39689565e-02f, 2.14960240e-02f, -1.29174650e-01f, -4.14858088e-02f,
  -1.63183305e-02f, -1.37173623e-01f, 1.20285414e-01f, 1.84798017e-02f, 7.50332549e-02f, 2.93262433e-02f, 1.21427320e-01f, -1.43183380e-01f, -5.82367443e-02f, 2.05769464e-02f,
  9.99639928e-02f, -9.61032044e-03f, -1.61236301e-02f, 8.32009129e-03f, 4.43529449e-02f, 4.98562939e-02f, -1.69717699e-01f, 1.52787954e-01f, 2.65582744e-02f, 1.17317192e-01f,
  1.05256326e-02f, 2.08787471e-01f, 3.22351396e-01f, 1.05909824e-01f, 9.87559184e-02f, 1.92352414e-01f, 1.76524490e-01f, 2.69446909e-01f, 2.38143146e-01f, 1.34871542e-01f,
  -3.37449014e-01f, -4.38557148e-01f, -4.72747833e-01f, -1.33440554e-01f, 2.25305870e-01f, 1.43592685e-01f, -3.08390319e-01f, 2.06572432e-02f, 1.93140492e-01f, -2.48129949e-01f,
  2.19267253e-02f, 3.23932648e-01f, 2.17930987e-01f, 3.05348337e-01f, 5.85842468e-02f, -1.50982067e-01f, 4.73960638e-02f, 1.69018999e-01f, 3.19703072e-01f, 3.54041427e-01f,
  3.60303581e-01f, 1.43223526e-02f, 8.75496492e-02f, 2.91432679e-01f, -1.03476927e-01f, 2.28050232e-01f, -2.41158545e-01f, -1.72367305e-01f, 8.61109234e-03f, -1.94791749e-01f,
  -3.40745836e-01f, -2.65695363e-01f, 2.07743511e-01f, 6.57554865e-02f, -9.64772925e-02f, -1.70225754e-01f, -1.69965044e-01f, -1.65973410e-01f, 2.00170949e-02f, -7.97061250e-02f,
  2.18102112e-02f, -3.33727449e-02f, 7.65662938e-02f, 5.90177141e-02f, -1.21754125e-01f, -2.00047903e-02f, 4.53335345e-02f, -8.64011142e-03f, 2.13146023e-02f, -1.15998507e-01f,
  1.74253985e-01f, 1.65340453e-01f, -5.87723963e-02f, 1.61445066e-01f, 3.35416757e-02f, 2.11959794e-01f, 9.85386670e-02f, 8.31845552e-02f, 7.51906931e-02f, -3.05323780e-01f,
  1.07122160e-01f, -6.77501597e-03f, -5.45293093e-02f, 8.81076977e-03f, 5.18511534e-02f, -1.57170910e-02f, -6.11027284e-03f, -1.45881036e-02f, 1.55135706e-01f, -1.20086096e-01f,
  8.07937384e-02f, -3.61006074e-02f, 1.64259538e-01f, 9.21944529e-03f, 1.64657384e-01f, -2.33355276e-02f, -2.05001887e-02f, -6.57985583e-02f, 7.07709864e-02f, 4.56126258e-02f,
  2.72370875e-02f, -1.98041484e-01f, -8.20107292e-03f, 7.06755221e-02f, 1.17192872e-01f, 6.55466616e-02f, 9.42864120e-02f, -1.08264722e-01f, -8.51564333e-02f, 2.82830652e-02f,
  -6.16993010e-01f, 3.33009303e-01f, 3.36919278e-02f, 2.04700604e-02f, -9.56820846e-02f, 7.07507804e-02f, 2.54084580e-02f, -2.44325846e-02f, -3.44327502e-02f, -1.84165180e-01f,
  9.21798944e-02f, -1.24712195e-02f, -1.12566195e-01f, 1.01021919e-02f, 8.78313184e-02f, -7.03332201e-02f, -1.04241364e-01f, 1.82914454e-02f, -1.61024593e-02f, -1.66670345e-02f,
  6.69174790e-02f, -1.48794027e-02f, -6.59131929e-02f, 1.67833513e-03f, 1.38811529e-01f, 1.66675691e-02f, -4.54794466e-02f, -4.71275598e-02f, -4.61254604e-02f, -2.77166098e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  6.08071014e-02f, 5.42438328e-02f, 6.34321570e-02f, 3.12749565e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.15941355e-01f, -9.44228172e-02f, 4.42439735e-01f, 7.62765408e-01f, 1.89042494e-01f, 2.07491577e-01f, 2.28252724e-01f, -4.48301286e-02f, -1.34887546e-01f, 2.69720107e-01f,
  -2.09742948e-01f, 1.58530042e-01f, 1.12186804e-01f, -9.66883749e-02f, -2.95843065e-01f, -3.89799148e-01f, 2.07157701e-01f, -1.97006032e-01f, -2.82356858e-01f, 2.84399807e-01f,
  -6.97334763e-04f, -8.69051144e-02f, 2.78661489e-01f, 9.99319106e-02f, 4.48890746e-01f, -5.44363633e-02f, -3.30237865e-01f, 2.87923545e-01f, -1.78987235e-01f, -8.33329737e-01f,
  1.50616899e-01f, -2.89079934e-01f, -2.08337516e-01f, -7.35970959e-02f, 2.70277321e-01f, -1.01664349e-01f, 1.22126423e-01f, -2.13379979e-01f, -3.59514058e-01f, 4.03517894e-02f,
  -2.29089901e-01f, -1.54459670e-01f, 7.87958503e-02f, 1.00359417e-01f, 5.83371408e-02f, 2.79557824e-01f, -2.97146380e-01f, -2.79626369e-01f, 1.43845201e-01f, 1.35695219e-01f,
  4.87922162e-01f, -4.75823879e-03f, 2.34913766e-01f, -6.03025079e-01f, -4.87599941e-03f, -5.05927324e-01f, 6.11826241e-01f, -2.60827780e-01f, 1.28436461e-01f, -3.24435025e-01f,
  1.81300595e-01f, -2.20133942e-02f, -1.96757272e-01f, 3.00641179e-01f, -1.35185853e-01f, 3.85938257e-01f, 2.37739921e-01f, -2.57589435e-03f, 1.56844288e-01f, 9.93461236e-02f,
  -2.19237134e-01f, 1.01263866e-01f, -3.30624759e-01f, 4.60428953e-01f, 1.69580162e-01f, 1.70411021e-02f, 9.22462642e-02f, 1.72733843e-01f, 4.42685246e-01f, 1.34192571e-01f,
  -9.58473235e-02f, -6.59465715e-02f, 3.91667098e-01f, -3.90554160e-01f, 1.06337875e-01f, -3.42205733e-01f, -5.51309645e-01f, 1.05869994e-01f, -3.02232862e-01f, -1.70028418e-01f,
  4.91393693e-02f, 1.57813523e-02f, -2.91441858e-01f, 5.73575556e-01f, 1.76729411e-02f, 9.54985917e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.55265434e-02f, 3.32917601e-01f, 4.27772582e-01f, -6.77130669e-02f, 2.16063365e-01f, -1.33241966e-01f, -1.91518404e-02f, -5.63900888e-01f, 1.38464615e-01f, -1.78436041e-01f,
  1.12975806e-01f, -4.15744483e-01f, -9.97139812e-01f, 3.51127028e-01f, -3.18682909e-01f, 4.91192222e-01f, -2.65679598e-01f, 3.39291245e-01f, 1.83787733e-01f, 6.27931297e-01f,
  3.05248797e-01f, 4.02928412e-01f, -3.27143908e-01f, -6.53611422e-01f, 1.94468662e-01f, 4.43046719e-01f, -1.45748883e-01f, 1.01294540e-01f, 2.66199321e-01f, -4.12801504e-01f,
  1.43411234e-01f, -6.77035600e-02f, -1.54148579e-01f, 5.37512124e-01f, 3.60122055e-01f, 4.24320698e-01f, 4.77970302e-01f, 2.76556730e-01f, -4.86478627e-01f, 1.75556526e-01f,
  -5.42887986e-01f, 8.21746349e-01f, 1.39449671e-01f, 1.76861018e-01f, 4.79438275e-01f, 2.14285284e-01f, 3.17574084e-01f, 4.72227573e-01f, 3.31028134e-01f, -1.89245611e-01f,
  -9.31202471e-01f, -1.22882879e+00f, -3.89366657e-01f, -2.62731194e-01f, -3.95981073e-01f, -3.32060784e-01f, -4.64882791e-01f, 4.04806435e-01f, 2.59417951e-01f, 1.32883966e-01f,
  -2.77903885e-01f, -5.38993061e-01f, -4.86284345e-01f, 2.72949785e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.45195591e-01f, 5.04779220e-01f, 5.20092130e-01f, -1.66313276e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.29561299e-01f, -2.20741063e-01f, -3.85307968e-01f, 1.71094850e-01f, -5.45377254e-01f, -3.41812283e-01f, -2.38530949e-01f, 5.85751355e-01f, -1.71964794e-01f, -2.52701849e-01f,
  -2.70382255e-01f, -3.29355150e-01f, -3.65074813e-01f, -1.07685275e-01f, 1.17949612e-01f, 6.19419336e-01f, 2.44144171e-01f, 3.20259959e-01f, 1.12896301e-01f, -2.02860370e-01f,
  8.54592845e-02f, 3.88622075e-01f, 5.33417761e-01f, 2.94764549e-01f, -2.89730728e-01f, -9.90889445e-02f, -1.84478864e-01f, -2.88288832e-01f, -3.39398474e-01f, 5.91601849e-01f,
  -1.25734583e-01f, -4.56615478e-01f, 3.74044627e-01f, 4.90825891e-01f, 6.12525716e-02f, -1.49055287e-01f, -2.76743859e-01f, 2.44506925e-01f, 1.86238959e-01f, 5.89006901e-01f,
  -4.67098475e-01f, -5.18007815e-01f, 1.07898839e-01f, -2.54466891e-01f, -3.23538706e-02f, 1.64592527e-02f, -3.58801544e-01f, -3.16402018e-01f, 7.00574294e-02f, -4.79711778e-02f,
  -3.53902131e-01f, 2.79032141e-01f, -2.44371146e-02f, 4.39883024e-03f, -2.79231779e-02f, 1.10555381e-01f, -3.82903308e-01f, -1.37206689e-01f, 1.62656039e-01f, -1.24483205e-01f,
  -2.22197518e-01f, 2.22103477e-01f, 2.81681895e-01f, 4.40303117e-01f, 8.89628306e-02f, -2.74381518e-01f, -2.93225586e-01f, 8.60957131e-02f, -1.84839331e-02f, 3.37621897e-01f,
  -1.63833186e-01f, 8.34081054e-01f, -4.54139441e-01f, 6.48243055e-02f, 2.59469181e-01f, -7.64986157e-01f, -5.66756785e-01f, 1.62902415e-01f, 8.05288646e-03f, 5.06753385e-01f,
  2.03055993e-01f, -2.44711991e-02f, -2.80706048e-01f, 5.28703988e-01f, -5.84460013e-02f, 6.23527169e-03f, 4.39453155e-01f, 5.65391123e-01f, -6.71728075e-01f, 6.85416013e-02f,
  4.02758509e-01f, -9.04177606e-01f, -5.75062215e-01f, -9.21065211e-02f, 1.07555054e-01f, -2.88063109e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.09699088e-01f, 4.33988929e-01f, 7.65055954e-01f, -3.03654224e-02f, 7.66396523e-01f, 7.91353166e-01f, 4.21037465e-01f, 8.33712280e-01f, -4.55426633e-01f, 1.12407923e+00f,
  -7.35433996e-01f, -7.98015594e-01f, 8.35570574e-01f, 1.69189900e-01f, -4.08860832e-01f, -8.47374320e-01f, 2.62788177e-01f, 1.34849191e-01f, -1.41025305e-01f, 3.16080272e-01f,
  -2.13017985e-01f, 3.96276683e-01f, 2.05520600e-01f, -9.52244163e-01f, 7.63747469e-02f, -7.67296553e-02f, 7.33004808e-01f, -2.16061369e-01f, -3.94601077e-01f, 5.36690593e-01f,
  5.84051549e-01f, -1.28812361e+00f, 7.87317082e-02f, -1.32332966e-02f, 4.25062001e-01f, -3.71962748e-02f, 4.39886183e-01f, -1.07688718e-01f, 1.42134964e-01f, -8.89528930e-01f,
  4.80774790e-01f, 6.66816235e-01f, 9.73262489e-02f, 2.87561089e-01f, 8.66844118e-01f, 2.75502771e-01f, 5.70129901e-02f, 3.05698998e-02f, 1.11397254e+00f, -1.01619646e-01f,
  3.26839656e-01f, -1.84465513e-01f, 2.31405906e-02f, 1.46283492e-01f, 8.12151849e-01f, 3.71128291e-01f, -9.10352319e-02f, -8.96521285e-02f, 2.25950196e-01f, -1.26104593e-01f,
  -1.26556739e-01f, 2.92840451e-01f, 3.11237484e-01f, -1.24731076e+00f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  8.67598534e-01f, 4.13205355e-01f, 4.69528109e-01f, 5.57966113e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  6.25816941e-01f, -7.51156867e-01f, -5.93390882e-01f, 4.52838317e-02f, -1.63574919e-01f, 6.44258380e-01f, 5.92645645e-01f, 4.50288914e-02f, -4.73706663e-01f, 2.34706417e-01f,
  6.59641683e-01f, 4.03033078e-01f, -2.39016876e-01f, 2.61781424e-01f, -2.42942438e-01f, 1.45186350e-01f, -5.55371702e-01f, 6.28738642e-01f, 1.94031391e-02f, 2.38715157e-01f,
  1.28826732e-03f, -3.19358170e-01f, -2.95436114e-01f, 2.87840426e-01f, 2.42490202e-01f, -2.13479087e-01f, 6.75836205e-02f, -4.87589687e-02f, 5.02496958e-01f, -2.86057740e-01f,
  1.65167951e-03f, -1.98387697e-01f, 1.53966829e-01f, 1.03340864e+00f, 4.26117480e-02f, -2.37601116e-01f, 1.60979331e-01f, 7.70865567e-03f, -2.84765750e-01f, 4.60830122e-01f,
  -2.41398424e-01f, 7.91359186e-01f, 4.33393031e-01f, 6.42302155e-01f, -3.81259203e-01f, 5.03992558e-01f, 6.28566071e-02f, -9.44757909e-02f, 6.22712314e-01f, -5.75010657e-01f,
  -2.62473285e-01f, 1.96556896e-02f, 2.72728950e-01f, 3.93010139e-01f, -1.66384220e-01f, -5.27246356e-01f, -5.52169502e-01f, -4.79994148e-01f, -3.89384389e-01f, -1.61348149e-01f,
  3.48447561e-01f, -2.07682148e-01f, 1.79427147e-01f, -5.24658024e-01f, -2.26374995e-02f, -2.37091824e-01f, 4.33679014e-01f, 3.38408142e-01f, 4.67017114e-01f, 4.24822234e-02f,
  -1.68145686e-01f, -1.37831584e-01f, -3.41897517e-01f, 1.93248272e-01f, -2.77783602e-01f, 2.39833310e-01f, -4.93601978e-01f, -1.54236391e-01f, 4.13336426e-01f, -4.31425929e-01f,
  2.76207546e-04f, -1.11201763e-01f, 1.56859308e-01f, -4.68838006e-01f, -1.72319502e-01f, -5.59324980e-01f, 5.19417405e-01f, -3.13234746e-01f, -2.60558009e-01f, -3.43854260e-03f,
  -2.21140921e-01f, -7.27997541e-01f, 1.04486540e-01f, -2.88977385e-01f, 5.07233500e-01f, -4.76087570e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -7.20741987e-01f, 6.86394572e-01f, 6.09590590e-01f, -8.38075697e-01f, -1.19753659e+00f, -8.43839169e-01f, -1.04519445e-02f, -2.77812947e-02f, -1.32097042e+00f, -5.40718675e-01f,
  -3.70112151e-01f, -6.28098607e-01f, 4.50122893e-01f, 3.20824087e-01f, 6.12953842e-01f, 2.54914552e-01f, 3.73944417e-02f, 3.42545182e-01f, 2.03643978e-01f, 1.07632697e+00f,
  6.53640509e-01f, 3.34470034e-01f, -7.08779275e-01f, 5.79870343e-01f, 3.75666350e-01f, -8.89875829e-01f, -1.88556865e-01f, 5.53726733e-01f, 1.58602369e+00f, -7.18268871e-01f,
  2.12121516e-01f, -2.71934438e-02f, -2.36933976e-01f, 6.06890798e-01f, 6.35125279e-01f, 3.29405069e-01f, 6.29035473e-01f, 9.77781773e-01f, -4.52921242e-01f, -2.76706100e-01f,
  -1.32300985e+00f, 7.25044236e-02f, -5.56827784e-01f, -1.22644484e-01f, 3.75600249e-01f, 3.34288329e-01f, 1.19038594e+00f, 9.08884555e-02f, 1.06204689e+00f, 2.10390627e-01f,
  2.31298909e-01f, -1.44361243e-01f, 6.65611923e-01f, -5.61896384e-01f, -1.30037165e+00f, 9.23195302e-01f, 1.17473567e+00f, 9.24083650e-01f, 8.55398476e-01f, 9.24359560e-01f,
  6.36166573e-01f, 4.83264208e-01f, -2.69597530e-01f, 5.13714850e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  2.29408637e-01f, 3.11048180e-01f, 2.75055259e-01f, 4.17660922e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  1.34007609e+00f, 6.82356358e-01f, 5.73135674e-01f, 4.28332895e-01f, -3.33775073e-01f, -8.13654542e-01f, 2.06899911e-01f, -9.85872388e-01f, -1.52253538e-01f, 1.26100826e+00f,
  1.78543925e+00f, 1.70936704e+00f, -3.25019151e-01f, -8.53542089e-01f, 3.22289854e-01f, -3.65442634e-01f, -1.01848364e+00f, -6.66298032e-01f, 9.64897156e-01f, -5.27959228e-01f,
  -4.02274638e-01f, 2.18337253e-02f, 3.53900492e-01f, 5.36697745e-01f, -4.29636449e-01f, -4.40086991e-01f, -7.28204489e-01f, 3.75123709e-01f, -1.95107087e-02f, -1.32241523e+00f,
  2.39891529e-01f, 9.35963169e-02f, -3.69211882e-01f, 5.86956620e-01f, 7.92337954e-01f, 6.13246739e-01f, -5.94339631e-02f, 6.09599829e-01f, -8.69889259e-01f, 1.10443115e+00f,
  -1.65547654e-01f, -6.86627746e-01f, -5.92831314e-01f, 9.51979339e-01f, 6.21109962e-01f, -4.19190645e-01f, 1.41988024e-01f, -5.50239563e-01f, -5.45443416e-01f, -1.76342988e+00f,
  1.10361922e+00f, 1.21810985e+00f, 9.67158675e-01f, 1.39646494e+00f, 1.42166817e+00f, -3.35536778e-01f, 6.79584086e-01f, 7.94121921e-01f, -1.11506162e-02f, -1.17358243e+00f,
  -1.88777283e-01f, -9.62813079e-01f, 4.52729970e-01f, -8.31145465e-01f, 1.21102262e+00f, 5.15117109e-01f, -1.60223794e+00f, -2.77077258e-01f, 7.49454558e-01f, 8.09676796e-02f,
  -9.99262214e-01f, -5.91061234e-01f, 3.67690712e-01f, -1.10455751e+00f, 2.72305757e-01f, -1.01462770e+00f, 2.02194929e-01f, -1.58803499e+00f, 3.88030857e-01f, -6.04780018e-01f,
  7.08237648e-01f, 1.20384192e+00f, -7.13169694e-01f, 1.75800145e-01f, 4.65858430e-01f, -5.43081462e-01f, -6.26652360e-01f, 1.67627171e-01f, 5.61788321e-01f, -9.05105591e-01f,
  -7.17863798e-01f, 6.90987885e-01f, -4.44293231e-01f, 3.01693112e-01f, 3.77341956e-02f, 1.53240696e-01f, -2.65078515e-01f, -1.00725800e-01f, -9.26710665e-01f, -3.78047042e-02f,
  -8.19764659e-02f, 5.60920358e-01f, -4.96313959e-01f, -2.69960344e-01f, -1.01947200e+00f, 7.12306976e-01f, -4.11998145e-02f, -1.59632051e+00f, -8.43214869e-01f, 5.82853615e-01f,
  -1.41649276e-01f, 1.51740208e-01f, -6.82330966e-01f, 5.67403615e-01f, -6.55185521e-01f, -1.77291501e+00f, 2.88314402e-01f, -6.15727603e-01f, -5.16683877e-01f, 8.78202200e-01f,
  -4.99295592e-01f, 3.27875435e-01f, 1.58387423e+00f, -2.71489650e-01f, 5.38357913e-01f, 2.36533582e-01f, -1.47910431e-01f, -4.01072800e-01f, 2.43169546e-01f, -3.16453725e-01f,
  2.99164385e-01f, -6.31961405e-01f, -6.42536938e-01f, -9.73859251e-01f, 5.28166890e-01f, -5.44856906e-01f, 1.37948799e+00f, -1.46990836e-01f, 1.10112011e+00f, -6.48229897e-01f,
  2.51016170e-01f, -2.13254347e-01f, -1.11289251e+00f, 3.33898932e-01f, -1.33592665e-01f, -9.70452964e-01f, -8.51281941e-01f, 4.29136306e-01f, -2.93406874e-01f, 1.81596979e-01f,
  8.58398318e-01f, -7.61662900e-01f, -4.80274886e-01f, 8.05112183e-01f, -1.26605320e+00f, 1.24299788e+00f, 3.89099151e-01f, 5.22078216e-01f, -2.74957001e-01f, -5.58959186e-01f,
  -8.38516187e-03f, -6.66910887e-01f, -8.58974338e-01f, 3.43370527e-01f, -4.19481784e-01f, 6.97205782e-01f, 7.45473385e-01f, -5.97403526e-01f, -9.86540496e-01f, 1.10042191e+00f,
  -4.31011796e-01f, 9.13238406e-01f, -2.37676883e+00f, -1.00085068e+00f, -5.76775908e-01f, 7.27330625e-01f, 4.73662466e-01f, 6.46119475e-01f, 1.19153905e+00f, -1.74927637e-01f,
  -2.58537412e-01f, -6.00864947e-01f, 7.29764581e-01f, 9.15896952e-01f, -2.87690341e-01f, -1.38970208e+00f, -5.88349700e-01f, -4.75558698e-01f, -1.41528523e+00f, 5.86705446e-01f,
  -1.39285839e+00f, 4.16813344e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  8.63191247e-01f, -2.96914130e-01f, -3.74793142e-01f, 1.92449972e-01f, -1.71340108e-01f, -7.96105638e-02f, -2.45402753e-02f, -1.77979067e-01f, -2.20970046e-02f, -1.10847428e-01f,
  6.85106367e-02f, 5.06983578e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    