/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.51506203e-01f, 3.33500981e-01f, -1.47436470e-01f, 1.05254404e-01f, -7.88404047e-02f, 5.53855300e-02f, 6.27322719e-02f, -2.72065438e-02f, 1.30758613e-01f, 1.41049504e-01f,
  -3.95103842e-02f, -4.57444927e-03f, -3.51175405e-02f, 1.39853299e-01f, -1.34356946e-01f, 1.90095633e-01f, 3.90748233e-02f, -1.27727196e-01f, 1.07943825e-01f, -1.50844127e-01f,
  -6.08599633e-02f, 6.58223778e-02f, -2.50104424e-02f, -1.39291622e-02f, -1.43955678e-01f, -9.08131748e-02f, -1.93434525e-02f, 4.67670076e-02f, 4.00311649e-02f, 3.71442400e-02f,
  -5.41216172e-02f, -1.95418492e-01f, -1.95818990e-01f, -3.56032141e-02f, -2.76643932e-02f, -3.37199792e-02f, -4.79043722e-02f, 7.00890273e-02f, -5.33377416e-02f, 4.94392291e-02f,
  -1.50788222e-02f, -7.41768554e-02f, 4.11067270e-02f, -3.94159704e-02f, 1.07057653e-02f, 4.00577299e-02f, -3.27978022e-02f, 6.02738746e-02f, 4.06933278e-02f, -1.05108179e-01f,
  6.56983182e-02f, -5.20572662e-02f, -3.46078761e-02f, 3.94402072e-03f, -3.15340683e-02f, 3.73507887e-02f, 4.29007336e-02f, -4.71843034e-03f, -4.30594198e-02f, -4.75249253e-03f,
  -1.72567777e-02f, -2.43720189e-02f, 2.53512952e-02f, 1.01806549e-02f, 2.41942853e-02f, -6.12451173e-02f, 6.39170036e-02f, -6.19700365e-02f, 9.92029086e-02f, -3.48574743e-02f,
  -4.69777137e-02f, -5.84773682e-02f, 4.09371220e-03f, 8.98059085e-02f, 2.83325650e-02f, -2.01911218e-02f, -2.15652399e-02f, 2.71328762e-02f, -2.39312481e-02f, -9.36428551e-03f,
  6.54917285e-02f, 3.33886221e-02f, 5.68146743e-02f, -6.04512123e-03f, -4.95592728e-02f, 3.23205963e-02f, 4.57820781e-02f, 4.94946865e-03f, 3.52067575e-02f, -7.85720497e-02f,
  3.11100502e-02f, 9.63008702e-02f, 4.65637967e-02f, -3.97989526e-02f, -5.04976511e-03f, -9.20075551e-02f, -8.07735231e-03f, 2.94543561e-02f, 9.33240131e-02f, -5.31994887e-02f,
  6.95468532e-03f, -7.85923824e-02f, -5.65633702e-04f, -3.01742945e-02f, 2.07177643e-02f, 7.03728124e-02f, 5.02282865e-02f, 4.11267541e-02f, 8.29990208e-03f, 1.60178461e-03f,
  3.31140570e-02f, 3.74254696e-02f, -4.37317006e-02f, -7.25079998e-02f, -6.85851350e-02f, -3.30018834e-03f, -5.51515631e-02f, 2.57156361e-02f, -4.30923477e-02f, 4.26437818e-02f,
  3.93119276e-01f, 3.20702344e-02f, 2.73126774e-02f, 2.16904715e-01f, -7.88372234e-02f, 1.90257892e-01f, 2.61388183e-01f, -1.94708928e-01f, 1.99109867e-01f, 6.48790002e-02f,
  8.81872848e-02f, 1.40593559e-01f, -6.65193871e-02f, 3.32546532e-01f, 9.02939662e-02f, 4.82996181e-02f, 2.74892926e-01f, 1.72787964e-01f, 3.00537404e-02f, 2.79068071e-02f,
  -1.24820357e-03f, 7.24886432e-02f, -4.60524336e-02f, -1.62905291e-01f, 9.91605297e-02f, -1.52120650e-01f, -2.51696497e-01f, -1.08459488e-01f, 1.68354884e-02f, -2.04070881e-02f,
  1.03882924e-01f, 5.76410741e-02f, 3.98950279e-02f, -5.37727103e-02f, 9.68447234e-03f, -1.67793948e-02f, -9.32475273e-03f, -6.29085153e-02f, -3.15764323e-02f, 5.86285256e-02f,
  3.00183594e-02f, 3.81163210e-02f, 4.35288250e-02f, -3.47961634e-02f, 2.19056569e-02f, 1.63924471e-02f, 6.18755119e-03f, -6.02956600e-02f, 2.14609187e-02f, 3.58353332e-02f,
  -1.74266491e-02f, 3.74505594e-02f, 3.28244790e-02f, -3.51089798e-02f, -8.03171024e-02f, 1.28568793e-02f, -3.13532166e-02f, 1.42079415e-02f, -1.15800491e-02f, 1.36100315e-02f,
  1.77962221e-02f, -4.80817966e-02f, -7.45517537e-02f, 5.68675715e-03f, 3.91991846e-02f, -2.64806696e-03f, 1.60559602e-02f, 9.12023243e-03f, -3.31169106e-02f, 7.72257894e-02f,
  -1.26102299e-04f, 2.77459226e-03f, -1.90512948e-02f, 7.01632909e-03f, 3.31191421e-02f, -4.40478744e-03f, -2.24014674e-03f, -1.48609551e-02f, -2.03426331e-02f, -2.32979879e-02f,
  9.91464313e-03f, -4.10521403e-02f, -2.62868144e-02f, 2.08387636e-02f, -6.33806549e-03f, 1.48215787e-02f, 3.01519819e-02f, 2.61442713e-03f, 9.52572748e-03f, -2.82857250e-02f,
  -2.88989171e-02f, -1.20866589e-01f, 1.81765687e-02f, 5.06041348e-02f, 1.84627753e-02f, 7.14853480e-02f, 3.12779583e-02f, 4.30584215e-02f, -2.65217759e-02f, -2.42962297e-02f,
  -3.70977037e-02f, -2.54196883e-03f, -5.93187772e-02f, 1.93992835e-02f, -5.69227338e-02f, -1.48056420e-02f, -3.98883037e-02f, -2.87557263e-02f, -6.20892309e-02f, -2.02770787e-03f,
  -9.71246213e-02f, 2.60904878e-02f, -5.23432195e-02f, -6.06506094e-02f, 5.23851439e-02f, 2.96143964e-02f, -4.69103828e-03f, 1.92082115e-02f, -1.26293581e-02f, 5.26245944e-02f,
  -6.03367567e-01f, 4.77432460e-03f, -7.50825182e-02f, -8.92692618e-03f, -1.03664957e-01f, -1.29344568e-01f, -8.29811394e-02f, -4.60842960e-02f, -1.12235278e-01f, 1.01155832e-01f,
  -3.23643088e-02f, -1.05418719e-01f, 5.31508736e-02f, 9.43581238e-02f, -2.63536781e-01f, 1.64016917e-01f, -3.97734456e-02f, 7.88291395e-02f, 4.10376303e-02f, 7.05925077e-02f,
  4.74987738e-02f, 1.13970250e-01f, 8.41798782e-02f, 7.56511986e-02f, 2.53006909e-02f, 5.66249229e-02f, 9.83675718e-02f, 1.34771066e-02f, 3.88983227e-02f, -8.88400245e-03f,
  3.36484350e-02f, 1.02875620e-01f, 2.62646526e-02f, -4.57597189e-02f, -3.28167118e-02f, -5.24967350e-02f, -1.74244158e-02f, -7.38391578e-02f, 3.71993810e-04f, -1.66341092e-03f,
  -2.27728561e-02f, -1.44215887e-02f, 7.19410414e-03f, 2.71969661e-02f, 6.94527233e-04f, 1.44248884e-02f, -9.30518936e-03f, -2.57262331e-03f, 6.62143715e-03f, -6.66973647e-05f,
  -5.02643548e-02f, -9.55747813e-03f, 2.11305283e-02f, -1.69505626e-02f, -4.34497036e-02f, -6.12382777e-03f, -5.44819757e-02f, 1.05050749e-04f, -2.89157517e-02f, -5.85561357e-02f,
  -1.20900916e-02f, -1.99189149e-02f, -3.03807203e-03f, 4.13836129e-02f, -1.64960772e-02f, 1.46320192e-02f, -1.20651098e-02f, 2.78368425e-02f, -6.53747991e-02f, 1.29624875e-02f,
  -4.03427966e-02f, -1.74834710e-02f, -2.45504100e-02f, -1.71185490e-02f, 1.16597414e-02f, 1.41461296e-02f, -2.21632142e-02f, 2.46873628e-02f, -1.54546555e-02f, -1.31280180e-02f,
  -4.57230417e-05f, -2.23617684e-02f, 2.31212154e-02f, 3.04842535e-02f, 1.50957685e-02f, -1.58877652e-02f, 1.45332748e-02f, -6.00325968e-03f, 6.97682891e-03f, -4.83135916e-02f,
  5.48992641e-02f, 6.56122118e-02f, 2.70307306e-02f, 1.53876869e-02f, 8.70875549e-03f, 2.76674442e-02f, -7.37713138e-03f, 1.24673126e-03f, 2.38989349e-02f, -4.57039103e-02f,
  -7.64227584e-02f, -1.70265976e-02f, -1.35380449e-02f, -4.60639782e-02f, -5.38588837e-02f, -1.76704973e-02f, 7.46971089e-03f, -6.80633914e-03f, 1.36698307e-02f, 1.10481353e-02f,
  1.84625592e-02f, -1.25640649e-02f, -1.85088590e-02f, 2.12428859e-03f, 8.78927484e-03f, 2.19077207e-02f, 1.50481984e-02f, -4.20890711e-02f, -2.58676969e-02f, 2.48687919e-02f,
  1.09707452e-01f, 2.69974172e-01f, 2.86456257e-01f, 2.43395820e-01f, -1.46179184e-01f, -3.59021485e-01f, -1.21936731e-01f, -8.92962739e-02f, -5.19612096e-02f, -5.25921844e-02f,
  -2.28349268e-01f, 3.42794746e-01f, 1.25507144e-02f, -1.19433343e-01f, -2.21462213e-02f, -4.94720228e-02f, -1.41026042e-02f, 6.95174560e-02f, -1.24262245e-02f, -4.14478928e-02f,
  4.80406769e-02f, -1.89312190e-01f, 1.31264567e-01f, -7.57438540e-02f, 1.28668278e-01f, 1.40363365e-01f, 1.80628132e-02f, 8.09018314e-02f, 9.48915705e-02f, -2.48696860e-02f,
  -4.50018309e-02f, -1.24397449e-01f, 8.14609751e-02f, -2.09949072e-03f, -7.15424269e-02f, -2.96680927e-02f, 3.64475325e-02f, 5.69482520e-02f, -5.05503193e-02f, -2.04536635e-02f,
  2.16634218e-02f, -7.21466215e-03f, -3.30501236e-02f, 3.26262228e-02f, 2.08823625e-02f, 5.68406358e-02f, 6.63008541e-03f, -4.06383388e-02f, 4.37627658e-02f, 9.68113262e-03f,
  5.77336662e-02f, 1.27387550e-02f, -4.30408749e-04f, -3.16820294e-02f, 1.55431470e-02f, -5.27229421e-02f, -5.91834495e-03f, 4.25405689e-02f, 1.77581143e-02f, -8.91900901e-03f,
  -3.15614007e-02f, -2.14330796e-02f, 7.03072781e-03f, -4.60237777e-03f, 2.44491957e-02f, -9.70903132e-03f, 7.25077838e-02f, -6.51847720e-02f, -1.04240039e-02f, -1.19321831e-02f,
  -7.24242702e-02f, 4.45960090e-02f, -2.40129139e-02f, -6.52606487e-02f, 1.76901948e-02f, -2.57538632e-02f, 5.45629486e-03f, -2.01764167e-03f, -5.51761873e-03f, 1.48593644e-02f,
  2.09239195e-03f, -4.45863381e-02f, 1.81655344e-02f, -2.06358079e-02f, -5.10556810e-02f, 1.53542673e-02f, -1.26191124e-03f, 1.07545769e-02f, 4.70687039e-02f, -6.64420351e-02f,
  -6.89517260e-02f, -1.95273710e-03f, 4.07530414e-03f, 3.48977447e-02f, 4.54215705e-02f, 3.10540814e-02f, 1.77629886e-03f, 1.01871686e-02f, 4.32740077e-02f, -2.71929651e-02f,
  -2.31577866e-02f, 1.03594800e-02f, -3.75015438e-02f, -7.70136248e-05f, 7.92351179e-03f, -1.91043541e-02f, 1.39089208e-02f, 1.29903713e-02f, 6.89850363e-04f, 3.67131792e-02f,
  -2.18910407e-02f, -9.65504814e-03f, -3.17475870e-02f, -1.71179269e-02f, -3.86731364e-02f, -1.13038020e-02f, -8.00524093e-03f, -9.63690598e-03f, -3.74362431e-02f, -1.13519151e-02f,
  -6.65347651e-02f, -8.59374031e-02f, 2.09889784e-01f, -4.27014707e-03f, 9.01536644e-03f, -8.79459456e-02f, 1.20810926e-01f, -1.14873067e-01f, 1.53893288e-02f, -2.18461037e-01f,
  -1.11493856e-01f, -9.72588807e-02f, 1.00374155e-01f, -1.44626787e-02f, 2.37561405e-01f, 5.91959320e-02f, -3.98610272e-02f, -1.32234782e-01f, 6.04846841e-03f, -1.35265633e-01f,
  6.52897730e-02f, -3.94842476e-02f, 2.17238784e-01f, -1.13335765e-04f, -4.04648595e-02f, -2.67451513e-03f, 7.50879496e-02f, 1.38870835e-01f, -7.81516284e-02f, 1.66361034e-01f,
  -8.44181702e-02f, -4.25836071e-02f, 4.42915596e-02f, -1.41932759e-02f, -7.43089095e-02f, 1.41252717e-03f, -1.78116243e-02f, 1.59786329e-01f, 8.00610706e-02f, 1.57604588e-03f,
  -5.19820228e-02f, 9.47525539e-03f, 1.86530186e-03f, 2.77242763e-03f, -5.40855043e-02f, -7.09202932e-03f, -1.19408201e-02f, -1.41182030e-02f, -1.27304997e-02f, 2.82512861e-03f,
  -1.61091276e-02f, 1.20302681e-02f, -5.68304732e-02f, -3.09565514e-02f, 6.54607862e-02f, 8.24055169e-03f, 6.16211444e-02f, 5.00488915e-02f, -4.00509238e-02f, -2.70111486e-02f,
  1.77219789e-02f, 6.27582148e-02f, 3.21860388e-02f, -5.46479365e-03f, -1.48350270e-02f, -1.06625184e-02f, -4.05115932e-02f, 3.92034538e-02f, 7.94663280e-02f, -4.03580442e-02f,
  -4.42857742e-02f, -8.61506630e-03f, 1.98516436e-03f, -9.12287831e-03f, 4.03761417e-02f, -5.81784993e-02f, 1.51619557e-02f, -8.00908878e-02f, 8.97859875e-03f, 4.02706377e-02f,
  1.47349539e-03f, -5.32632805e-02f, -3.55617888e-02f, 2.13184021e-02f, -2.44912542e-02f, 4.62364443e-02f, -3.43717681e-03f, -3.57472636e-02f, -1.40457833e-02f, 2.67660916e-02f,
  -2.89297312e-01f, -1.33950189e-01f, -4.21685688e-02f, -4.99905907e-02f, -1.72031298e-02f, 6.68560714e-03f, 7.55947977e-02f, -3.79886776e-02f, -2.09170002e-02f, 4.55783904e-02f,
  2.04095710e-02f, -4.14983034e-02f, -6.85532093e-02f, 3.78497853e-03f, -1.82554349e-02f, 1.71563029e-02f, 5.58307255e-03f, 1.27951466e-02f, -5.08205406e-02f, -1.98156480e-02f,
  -1.11011885e-01f, -3.01739126e-02f, 1.86835937e-02f, -3.33832391e-02f, 6.82290271e-02f, 3.22064181e-04f, -9.96871963e-02f, 2.13233363e-02f, 6.18261024e-02f, 4.35604155e-02f,
  4.18077022e-01f, 8.86964351e-02f, 4.27949637e-01f, 3.12108044e-02f, -5.63134626e-02f, -1.58661470e-01f, -3.88324521e-02f, 9.79407951e-02f, 2.69197792e-01f, -1.03558645e-01f,
  -1.19767584e-01f, 1.74001485e-01f, 1.72582150e-01f, -7.32587799e-02f, 8.22286010e-02f, 9.49177593e-02f, -2.05218755e-02f, 1.10647371e-02f, 1.14691667e-01f, 6.72146901e-02f,
  7.82909319e-02f, -2.51109719e-01f, 5.73448017e-02f, -2.68421680e-01f, 3.05509864e-04f, 1.08411618e-01f, -1.71092868e-01f, -3.10506411e-02f, -1.40712604e-01f, -1.13579780e-01f,
  -1.32097796e-01f, 1.26091361e-01f, 9.92982090e-02f, 1.11946560e-01f, -1.99822355e-02f, -1.05019305e-02f, -3.45816389e-02f, -2.15017051e-02f, 4.44262065e-02f, 7.78344944e-02f,
  4.23276685e-02f, 7.24334083e-03f, 2.94837616e-02f, -3.19203064e-02f, -8.72933213e-03f, 1.75561532e-02f, 3.20475288e-02f, 2.76314840e-02f, 4.49260734e-02f, 1.45686418e-02f,
  -8.12099408e-03f, 3.74177564e-03f, -4.49756645e-02f, 1.03306328e-03f, 3.70163545e-02f, 3.68733454e-04f, 1.80852637e-02f, -4.01221365e-02f, -4.41753864e-02f, 6.78093955e-02f,
  -7.52033712e-03f, 4.05074954e-02f, 1.67983379e-02f, -3.33613344e-02f, -2.36133654e-02f, -5.94723634e-02f, -4.31042537e-02f, -1.25831971e-02f, 5.39642870e-02f, -2.87691355e-02f,
  -4.16766331e-02f, -5.37517108e-03f, -5.37526235e-03f, 4.71974537e-02f, 5.24789318e-02f, -5.83353192e-02f, 3.17107961e-02f, 1.43267950e-02f, -1.41150476e-02f, -1.32729942e-02f,
  2.36036330e-02f, 3.07369344e-02f, -2.76880655e-02f, -5.95493503e-02f, -1.01630213e-02f, 9.49900001e-02f, 1.30624911e-02f, 7.37121403e-02f, 1.53852301e-02f, -4.25052866e-02f,
  -5.33030275e-03f, 7.17656240e-02f, -6.13146871e-02f, -4.96042706e-02f, 2.97615514e-03f, -8.57877061e-02f, 1.28089711e-02f, 4.39723302e-03f, 3.57657522e-02f, -2.39810292e-02f,
  -5.38609400e-02f, -1.69247091e-02f, -3.26469205e-02f, 5.82240894e-02f, 2.57749017e-02f, -3.63532044e-02f, 5.46404277e-04f, 4.71945107e-03f, -1.06496051e-01f, -4.99442518e-02f,
  -2.47898605e-02f, -7.17814416e-02f, -1.35173481e-02f, -8.81780759e-02f, -8.71042535e-02f, -3.46841814e-04f, -3.88775505e-02f, 4.94410843e-02f, -4.42322753e-02f, -4.07118723e-02f,
  -3.47020864e-01f, -1.55154601e-01f, -1.44360706e-01f, -3.46721977e-01f, -5.48014566e-02f, 6.65477291e-02f, -1.11040525e-01f, -1.20931812e-01f, -2.02841491e-01f, -3.60459387e-02f,
  4.02485542e-02f, -1.23448618e-01f, 2.54569709e-01f, -1.46856248e-01f, 1.06205441e-01f, 2.44161114e-01f, -2.09926233e-01f, -6.03623800e-02f, 1.97628681e-02f, -2.29779124e-01f,
  -3.58353965e-02f, -3.64640951e-02f, -1.75991841e-02f, 4.52449173e-02f, -2.00241476e-01f, -5.91236986e-02f, -6.26748204e-02f, 8.95080045e-02f, -4.06299159e-02f, 2.75711473e-02f,
  -9.35391262e-02f, -1.62700489e-01f, -3.03328484e-02f, 8.28088671e-02f, -4.94575202e-02f, 3.69083770e-02f, 4.41701151e-02f, 1.12110794e-01f, 2.17676554e-02f, 1.65494904e-02f,
  3.38848867e-02f, -1.14124166e-02f, -3.56624350e-02f, 1.03525586e-01f, -2.60452693e-03f, -5.60673513e-03f, -4.04895805e-02f, -8.69941860e-02f, -2.49171425e-02f, 5.12174889e-02f,
  -5.86852357e-02f, -1.78198470e-03f, -8.29556584e-02f, 2.95761190e-02f, -1.99183170e-02f, -9.09841247e-03f, -5.86320311e-02f, 4.67844196e-02f, -5.86227067e-02f, -7.92302936e-02f,
  1.11692183e-01f, 2.12898999e-02f, 3.18824984e-02f, -1.49042141e-02f, -1.82529842e-03f, -2.62704063e-02f, 6.05454110e-02f, 1.93074206e-03f, 9.21961199e-03f, -2.48254910e-02f,
  3.16724734e-04f, -5.94290532e-02f, -4.06935588e-02f, 4.31452990e-02f, 9.30280366e-04f, -2.64355391e-02f, 6.45608502e-03f, -3.01282965e-02f, -4.89282943e-02f, -3.12236026e-02f,
  -2.77082771e-02f, -3.45688239e-02f, -1.70732532e-02f, -8.73232260e-03f, -1.77460769e-03f, 5.20088375e-02f, 3.75422873e-02f, -3.00972126e-02f, 1.81202795e-02f, 2.03665979e-02f,
  -9.34368148e-02f, -2.49841630e-01f, -2.87511405e-02f, -5.83838746e-02f, -1.68560818e-02f, -2.58034817e-03f, -4.92658131e-02f, 2.08223984e-03f, -1.72885675e-02f, 3.36306952e-02f,
  -3.27010602e-02f, -2.87428331e-02f, -5.35628274e-02f, 1.71402618e-02f, -1.17994018e-03f, -6.62247017e-02f, -5.85664809e-02f, 1.43460708e-03f, -1.12730943e-01f, -1.62919909e-02f,
  1.61708286e-03f, 2.05268227e-02f, 3.16011272e-02f, -7.08965585e-02f, 6.51265383e-02f, -5.49039319e-02f, -7.11135045e-02f, -4.07584608e-02f, 9.73423272e-02f, -9.12993960e-03f,
  -1.01112656e-01f, -6.28245845e-02f, -5.67325540e-02f, 6.91182577e-05f, 1.85109526e-02f, 2.19189271e-01f, 2.64391214e-01f, -9.88259763e-02f, -1.87424704e-01f, 1.75948311e-02f,
  1.21767566e-01f, -2.04758257e-01f, 1.44007593e-01f, 1.61215380e-01f, 3.59372020e-01f, 1.20703816e-01f, 1.90491438e-01f, 8.93932134e-02f, -6.92363009e-02f, 4.76277992e-03f,
  6.59162924e-02f, 1.64442942e-01f, 1.88275829e-01f, -7.33068446e-03f, 4.60710414e-02f, -5.83332665e-02f, 1.37258649e-01f, 5.91149814e-02f, 5.06820381e-02f, 6.23456649e-02f,
  8.71035457e-03f, -1.02082632e-01f, -1.59582943e-02f, -4.64309417e-02f, 6.72455952e-02f, 2.52003465e-02f, 5.18614203e-02f, 1.12280222e-02f, -1.20826717e-02f, 1.92072988e-02f,
  -1.56614371e-02f, 9.01354128e-04f, -3.44845168e-02f, -2.28577238e-02f, -1.11373678e-01f, -1.00070879e-01f, -1.84738636e-02f, 2.06386466e-02f, -7.12544098e-02f, -5.88746294e-02f,
  -5.19401059e-02f, -4.26675789e-02f, 1.04911067e-01f, -1.56549439e-02f, 2.30616331e-02f, 3.20790447e-02f, 3.05232313e-02f, -2.86333822e-02f, -2.93510295e-02f, 2.54773125e-02f,
  -3.26556563e-02f, -1.25402138e-02f, 4.81036790e-02f, 1.44532537e-02f, -9.76515654e-03f, 3.11449692e-02f, 2.75395755e-02f, 2.74295621e-02f, -8.67990106e-02f, 3.45121212e-02f,
  -2.38230731e-02f, -1.47082219e-02f, -4.49733250e-02f, -3.89965512e-02f, -1.27120409e-02f, 1.58542935e-02f, 1.17845449e-03f, -4.34663408e-02f, -3.49301472e-02f, 4.18235846e-02f,
  8.40961293e-04f, 6.36763871e-02f, 2.95697420e-04f, 4.03217524e-02f, -1.34299193e-02f, 1.93780288e-02f, -2.48671267e-02f, -2.54542958e-02f, -4.46738824e-02f, 3.77162769e-02f,
  9.39084738e-02f, 1.05927773e-01f, -6.03975654e-02f, -4.05919775e-02f, 1.57209560e-02f, 3.52557227e-02f, 8.12402368e-02f, -6.05321908e-03f, 5.76679781e-02f, -2.14639679e-02f,
  -5.56631014e-03f, -3.51116173e-02f, 6.46131560e-02f, -7.00275367e-03f, 4.00954783e-02f, 8.95571485e-02f, 9.16273743e-02f, -4.67023067e-02f, -1.88388675e-02f, 1.57270227e-02f,
  2.87642665e-02f, 6.62138760e-02f, -4.33110222e-02f, 9.71184764e-03f, -2.09464245e-02f, -1.79187898e-02f, -6.55678436e-02f, -8.10768548e-03f, 3.04168966e-02f, 4.31835316e-02f,
  3.31353575e-01f, 1.13762692e-01f, 1.34811252e-01f, 1.92715779e-01f, 9.85339358e-02f, 9.38048363e-02f, -1.06666096e-01f, 1.18096665e-01f, 9.43578854e-02f, -5.25122732e-02f,
  3.38235535e-02f, -6.65598735e-02f, -1.21535964e-01f, 1.83560655e-01f, -6.97666556e-02f, -1.73000157e-01f, 1.60504445e-01f, 4.95054293e-03f, -7.20186299e-03f, 1.46755353e-01f,
  5.01530804e-02f, 1.47450998e-01f, 1.27654616e-02f, 7.93946609e-02f, 1.36443153e-01f, 1.02805614e-01f, 4.95019257e-02f, 2.30752565e-02f, 1.35235727e-01f, -2.75471266e-02f,
  -5.05570024e-02f, -2.11646371e-02f, -2.96243466e-02f, -6.28761202e-02f, 9.27050691e-03f, -2.38576010e-02f, -2.19696052e-02f, -1.50120053e-02f, -1.80119351e-02f, -2.92395893e-02f,
  -3.92380916e-02f, -4.37035859e-02f, 2.67043170e-02f, 1.21016963e-03f, 3.22547629e-02f, 3.37046683e-02f, -1.86341126e-02f, -2.29441803e-02f, -1.71880201e-02f, -1.94759145e-02f,
  -1.65527419e-03f, 2.94993091e-02f, 6.96295872e-02f, -8.24110731e-02f, 6.44434569e-03f, 3.38232182e-02f, -3.94007079e-02f, -4.41616550e-02f, 3.08942585e-03f, 4.79595475e-02f,
  3.81453000e-02f, 4.58164103e-02f, 6.25730008e-02f, 2.48961262e-02f, 2.78610904e-02f, 1.55196758e-02f, 2.73076799e-02f, -1.65737756e-02f, 1.97561365e-02f, -3.11582703e-02f,
  6.05773479e-02f, -1.32377853e-03f, 8.92887823e-03f, 4.43352647e-02f, 9.45375338e-02f, 1.66060943e-02f, 4.00870517e-02f, -2.66654287e-02f, 2.67260801e-02f, 4.55172546e-02f,
  -2.89302804e-02f, 4.06548120e-02f, 1.54562956e-02f, 6.02661371e-02f, -3.64746451e-02f, -6.45990297e-02f, 6.10163696e-02f, -3.04666366e-02f, 2.18970999e-02f, 2.02895515e-02f,
  8.05154536e-03f, 1.27540529e-01f, -1.22044971e-02f, -6.20141849e-02f, -4.65603583e-02f, 3.39572728e-02f, -5.40934652e-02f, 5.95479235e-02f, 2.48149689e-02f, 7.08505139e-02f,
  3.55082750e-02f, -3.76192965e-02f, 5.65494550e-03f, 6.18602112e-02f, -8.26806501e-02f, -2.08808971e-03f, 1.64677352e-02f, 3.72518450e-02f, 2.73701008e-02f, 2.22032387e-02f,
  5.29414117e-02f, -3.81968990e-02f, -1.57396551e-02f, 1.49393557e-02f, 8.90691727e-02f, -6.50555789e-02f, -7.28868023e-02f, -3.64064276e-02f, 8.61645117e-02f, -3.58962715e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.70165229e-02f, -8.88290629e-02f, -2.44565055e-01f, 2.79291179e-02f, 8.81941915e-02f, 8.78856517e-03f, -2.36180693e-01f, 7.49372542e-02f, -4.52652842e-01f, 1.08488582e-01f,
  -5.62041514e-02f, -6.38340190e-02f, -2.21125856e-01f, -5.08314185e-02f, -2.04115780e-03f, -2.95340836e-01f, 2.00926542e-01f, -1.23976255e-02f, -1.64174914e-01f, 1.13310024e-01f,
  1.54867377e-02f, 2.09511474e-01f, 1.80655271e-02f, 2.37090319e-01f, 8.44901800e-02f, 1.45321831e-01f, 3.84853214e-01f, 4.50854897e-02f, 3.25978816e-01f, 1.47629768e-01f,
  -8.04618895e-02f, -1.96491256e-01f, -7.81320333e-02f, 1.54751465e-02f, 1.08856127e-01f, 1.58943221e-01f, 1.02679789e-01f, -1.39786657e-02f, 7.99903870e-02f, -2.19673533e-02f,
  4.61465642e-02f, 3.48985032e-03f, 6.16096556e-02f, 2.45745517e-02f, -3.88841815e-02f, -1.89744812e-02f, -8.98502395e-02f, -6.09242842e-02f, -9.79618728e-02f, -8.57069939e-02f,
  -6.04039952e-02f, -3.88335213e-02f, 3.62956002e-02f, 6.65719658e-02f, -6.72227442e-02f, -1.89899635e-02f, -1.05689522e-02f, 3.79465073e-02f, 3.21162753e-02f, 3.88294496e-02f,
  8.25013444e-02f, 4.23005130e-03f, 2.26544645e-02f, -1.09187260e-01f, -4.86387759e-02f, -5.39410785e-02f, -5.88323623e-02f, -8.02715961e-03f, -1.80020630e-02f, -4.82519940e-02f,
  5.22277467e-02f, 8.20229761e-03f, -1.03494190e-01f, 3.23529541e-02f, 1.43466555e-02f, -9.51596648e-02f, 4.17443812e-02f, 3.32749449e-02f, -3.52432998e-03f, -4.32933755e-02f,
  -3.04642506e-02f, 5.53937070e-03f, -4.58410867e-02f, 7.17537478e-02f, -4.94037522e-03f, 6.71490878e-02f, 2.97124451e-03f, -2.61536092e-02f, -2.93620341e-02f, 7.43488735e-03f,
  1.37023315e-01f, 1.54863775e-01f, -6.31166548e-02f, 6.26760796e-02f, -6.33709580e-02f, -4.91726473e-02f, -7.59905502e-02f, 2.14704666e-02f, 2.11484544e-02f, -3.46620306e-02f,
  6.45719245e-02f, 5.51703721e-02f, 1.26897004e-02f, -3.93590145e-03f, 4.31427769e-02f, 3.81235555e-02f, 1.81009397e-02f, 9.31561068e-02f, 4.31986041e-02f, 2.47643515e-02f,
  9.04506445e-02f, 6.86776936e-02f, -1.01721603e-02f, -1.49999233e-03f, -5.38168289e-03f, 9.51935500e-02f, 5.12128100e-02f, 3.93685587e-02f, -1.67969484e-02f, -1.29807904e-01f,
  1.20727502e-01f, -8.90011191e-02f, -1.02359407e-01f, 9.47440937e-02f, -7.01897070e-02f, -2.88476318e-01f, -2.46591911e-01f, -7.90767223e-02f, 6.33587688e-02f, -1.23715214e-01f,
  -4.95055430e-02f, -2.12927591e-02f, 4.27222531e-03f, -5.14793731e-02f, 2.84313619e-01f, 1.74633443e-01f, -1.53795153e-01f, -2.04750933e-02f, 6.28677756e-02f, -2.64584552e-02f,
  1.28639489e-01f, -1.33095130e-01f, -1.00319773e-01f, -1.05062447e-01f, -2.05508828e-01f, -7.37771839e-02f, 1.48579612e-01f, -1.01522706e-01f, -1.31701738e-01f, -5.27491458e-02f,
  -3.70789282e-02f, -3.82756395e-03f, -4.80014682e-02f, -8.56498480e-02f, -1.01492845e-03f, -1.35900512e-01f, -2.21367422e-02f, -6.41736165e-02f, -7.74406865e-02f, -3.25469412e-02f,
  5.49290271e-04f, -2.58928686e-02f, -5.96814714e-02f, -2.80768219e-02f, -9.62354839e-02f, -3.74027975e-02f, 1.25795482e-02f, -8.11127387e-03f, -2.86597162e-02f, 1.46401552e-02f,
  -2.29888712e-03f, -5.93631268e-02f, 2.59872936e-02f, -2.94566303e-02f, 1.03126928e-01f, 9.51758493e-03f, -1.07561953e-01f, 5.82001545e-02f, 2.63249353e-02f, 5.54645360e-02f,
  -1.11290067e-01f, 2.47856472e-02f, -3.42887156e-02f, 4.57955599e-02f, -4.55650426e-02f, 3.95432077e-02f, 1.14317954e-01f, -2.05621542e-03f, 6.16277307e-02f, -6.37212172e-02f,
  3.87629084e-02f, 1.85228419e-02f, 6.50173649e-02f, 4.97472733e-02f, -3.56465182e-03f, 1.08673591e-02f, 3.05883009e-02f, 4.41859663e-02f, 4.52803746e-02f, 8.23718088e-04f,
  -2.51379684e-02f, 4.75370027e-02f, 4.23053987e-02f, -4.84506115e-02f, -6.45278916e-02f, 8.71448964e-02f, -6.39580637e-02f, -3.68767567e-02f, -2.48129927e-02f, -5.71191050e-02f,
  -2.38081790e-03f, -8.10432360e-02f, -4.54720668e-02f, -9.10877958e-02f, -3.03914640e-02f, 2.09517200e-02f, -4.30155471e-02f, 1.34819951e-02f, 2.42452454e-02f, 8.19581095e-03f,
  3.18224654e-02f, -3.34470719e-02f, 6.65105805e-02f, 4.15015360e-03f, -2.78415680e-02f, -6.54043406e-02f, -2.75274310e-02f, 4.97996993e-02f, -4.68273722e-02f, 4.66813371e-02f,
  3.47543731e-02f, 7.00694323e-02f, -1.31073697e-02f, 1.41868312e-02f, -1.90908182e-02f, -5.02950288e-02f, 3.42485122e-02f, 1.05586005e-02f, -1.73335113e-02f, 1.28809956e-03f,
  1.29788116e-01f, 1.02334887e-01f, 3.80669883e-03f, 1.51264653e-01f, 5.66811152e-02f, -7.16966316e-02f, 4.71750759e-02f, 4.72046472e-02f, 6.93097860e-02f, -4.94911224e-02f,
  -8.78835469e-02f, 3.35804820e-02f, -1.14542488e-02f, 5.83864599e-02f, -4.56445031e-02f, -3.88961844e-02f, 5.65736666e-02f, 4.99799363e-02f, 1.17729969e-01f, 6.34014159e-02f,
  3.41092832e-02f, -5.83356768e-02f, -6.06083348e-02f, -1.40831813e-01f, 4.63708453e-02f, -3.35037895e-02f, -1.08178966e-01f, -1.35927815e-02f, -2.11339463e-02f, 1.11745708e-02f,
  4.81321961e-02f, -4.50308085e-04f, 5.04932553e-02f, 1.40383570e-02f, 1.29358657e-02f, 7.28022307e-02f, 1.58162732e-02f, -8.96474347e-02f, 5.68037406e-02f, -6.16822839e-02f,
  2.77700946e-02f, -8.43907371e-02f, 1.32554963e-01f, -4.72302511e-02f, -7.46212946e-03f, -1.99139826e-02f, -4.59258966e-02f, 2.31004655e-04f, 9.69167724e-02f, -4.93401140e-02f,
  6.99496269e-02f, 4.51559089e-02f, 8.85033607e-02f, -2.18518972e-02f, 4.51601576e-03f, 3.36946151e-03f, -3.33300009e-02f, -2.57228743e-02f, 8.22248217e-03f, -6.33639023e-02f,
  -6.18820153e-02f, -4.63562384e-02f, -7.30980262e-02f, -6.41062260e-02f, -4.89850938e-02f, -6.59860224e-02f, 6.31233081e-02f, 2.75028665e-02f, -2.00425331e-02f, 4.30244729e-02f,
  4.42513824e-02f, -2.50741336e-02f, 9.32121929e-03f, 6.20108992e-02f, 4.01523933e-02f, 3.33389379e-02f, 4.96737696e-02f, 3.92241217e-02f, -9.20593645e-03f, -3.64347994e-02f,
  6.16036095e-02f, -6.51497841e-02f, -4.35817838e-02f, 7.03702867e-02f, 1.87994279e-02f, 1.98562909e-02f, 5.11833392e-02f, -5.06313853e-02f, -7.40225147e-03f, -7.96485469e-02f,
  -7.60769248e-02f, 5.16597107e-02f, -3.47049087e-02f, -1.60575192e-02f, 4.99071889e-02f, 7.30759874e-02f, -4.10686135e-02f, -2.26301197e-02f, -4.51919623e-02f, 1.00553624e-01f,
  6.59286976e-03f, 1.72483753e-02f, 2.34000478e-02f, -8.63793939e-02f, 4.91245724e-02f, 1.04672881e-03f, -6.36819601e-02f, 8.49146023e-03f, -3.50283571e-02f, -6.00038394e-02f,
  4.58107926e-02f, -7.33975619e-02f, 1.59119871e-02f, 4.56424616e-02f, -4.60862555e-02f, 7.07029402e-02f, 8.98826197e-02f, -8.54136795e-02f, 9.87204630e-03f, -7.18903355e-03f,
  1.50141284e-01f, -6.28512353e-02f, -1.37150183e-01f, 1.49392173e-01f, -4.46994454e-02f, 2.87742708e-02f, -5.57466149e-02f, 1.67058110e-02f, -4.18540016e-02f, -1.32527752e-02f,
  4.59396206e-02f, -6.53138682e-02f, 5.45017347e-02f, 2.13361531e-01f, 1.00051448e-01f, 3.01497299e-02f, 5.23961782e-02f, 1.23085514e-01f, -5.99322207e-02f, 1.71386059e-02f,
  1.35366812e-01f, 1.08012781e-01f, 1.71193518e-02f, 9.56950784e-02f, -4.21166085e-02f, 2.25424748e-02f, 7.74869397e-02f, -8.50729421e-02f, 9.62634534e-02f, 1.67937316e-02f,
  3.30168791e-02f, -1.35299843e-02f, 6.61298931e-02f, 3.62917744e-02f, -3.25244814e-02f, -3.87862362e-02f, 5.56699671e-02f, 6.32311180e-02f, 7.03333039e-03f, -3.05597596e-02f,
  3.44550684e-02f, 6.12100028e-02f, -4.38522100e-02f, 6.07616547e-03f, -7.58346841e-02f, 1.80442426e-02f, 2.04899088e-02f, 1.10746203e-02f, -7.57845789e-02f, -3.37392315e-02f,
  -8.50505605e-02f, -8.32826123e-02f, -9.83525217e-02f, 2.41536442e-02f, -8.35397542e-02f, 3.80234160e-02f, -7.19275400e-02f, -4.65742275e-02f, -2.36897245e-02f, -4.07938361e-02f,
  5.00418991e-02f, 4.32564951e-02f, 3.07367072e-02f, 9.20496285e-02f, 6.97293878e-02f, 5.16293161e-02f, 1.21811805e-02f, 2.89372802e-02f, -3.37888002e-02f, 2.95178406e-02f,
  -7.15648979e-02f, 3.27430740e-02f, 2.38747392e-02f, 5.53914858e-03f, -1.90246366e-02f, 2.14185547e-02f, -3.45993303e-02f, -2.65873354e-02f, -1.38954045e-02f, -6.32954249e-03f,
  4.37761582e-02f, -4.40099128e-02f, -3.05370819e-02f, 2.29822658e-02f, 4.74070832e-02f, -6.62204847e-02f, 1.00597285e-01f, -3.87585722e-02f, -1.43722504e-01f, -5.85240163e-02f,
  4.68413606e-02f, 7.12733567e-02f, -6.86005205e-02f, -1.16163706e-02f, 4.77475971e-02f, 8.42916667e-02f, 4.52172868e-02f, 4.55436148e-02f, 1.12365102e-02f, -3.77459005e-02f,
  -3.66381928e-02f, -6.06871657e-02f, 1.34991910e-02f, -7.40687773e-02f, -3.16742472e-02f, 8.43572691e-02f, -3.87028493e-02f, -1.99849699e-02f, -6.71175048e-02f, 7.49097615e-02f,
  1.30631328e-02f, -1.08617097e-01f, -7.34761506e-02f, -4.44435105e-02f, -2.30002105e-02f, -1.55217692e-01f, 1.84639972e-02f, -8.32066033e-03f, 3.24045680e-02f, 2.69822925e-02f,
  2.08815411e-01f, -3.38495910e-01f, -5.71466424e-02f, 1.93641365e-01f, 1.53635293e-01f, 2.17852555e-02f, -7.37479627e-02f, 1.78625230e-02f, -3.74944843e-02f, -1.88810483e-01f,
  2.55322549e-02f, -1.53282687e-01f, -2.96677202e-01f, 4.30280194e-02f, 1.97014719e-01f, -2.17494264e-01f, 1.29784286e-01f, -7.07621574e-02f, -2.55609141e-03f, -1.03361025e-01f,
  5.35365492e-02f, 7.50943944e-02f, 9.78690237e-02f, 1.84435293e-01f, 9.06898826e-02f, 1.52972817e-01f, 1.05946444e-01f, -4.19119969e-02f, 1.25723734e-01f, 6.24817722e-02f,
  9.93520170e-02f, -7.41764531e-02f, -1.49256680e-02f, -7.44095817e-03f, -3.22858430e-02f, -3.30743776e-03f, 1.17828799e-02f, 6.02947141e-04f, -1.74436979e-02f, -9.49119404e-02f,
  -1.13486700e-01f, 2.84879860e-02f, 5.82983531e-02f, 4.27176878e-02f, 1.16532266e-01f, 3.46864201e-02f, -2.53094826e-02f, 8.41683745e-02f, -7.54164606e-02f, -8.69311690e-02f,
  -1.06523439e-01f, 6.86786417e-03f, -2.53871251e-02f, 4.58787307e-02f, -6.69459766e-03f, 4.03362364e-02f, -8.47899243e-02f, -5.09236716e-02f, -3.37274410e-02f, -1.42853074e-02f,
  -1.10835008e-01f, 7.76181966e-02f, -3.02579254e-02f, 1.21046342e-01f, -9.31632519e-03f, 4.70833853e-02f, 1.14623033e-01f, 1.04401289e-02f, 1.16961613e-01f, -8.63935575e-02f,
  8.74984860e-02f, 3.01936711e-03f, 3.91499698e-02f, -2.13777144e-02f, -2.80034430e-02f, -1.51366740e-02f, 1.84257701e-02f, 2.93700602e-02f, 5.57470368e-03f, 3.93623374e-02f,
  -2.16639135e-02f, 4.59271595e-02f, -7.82468915e-02f, -8.32117908e-03f, -3.77717689e-02f, -4.06068936e-02f, -4.35029566e-02f, -1.10325068e-01f, 7.94474110e-02f, -5.12949228e-02f,
  -7.00713694e-02f, -1.91008106e-01f, 3.75285074e-02f, 3.11401933e-02f, -3.21960710e-02f, 2.09011300e-03f, 9.59354192e-02f, 1.02483621e-02f, -7.15898396e-03f, 2.04900671e-02f,
  -1.71025209e-02f, -5.03667980e-04f, 8.68209451e-03f, 6.25280887e-02f, -6.48241863e-03f, -3.04226894e-02f, 9.98839736e-03f, -9.26030055e-03f, 2.86600105e-02f, -1.99259780e-02f,
  -7.57909641e-02f, -2.74939034e-02f, 5.38200177e-02f, 5.59803247e-02f, 4.89018559e-02f, -7.60621205e-02f, -3.08365282e-02f, -1.66433919e-02f, -3.38486098e-02f, 5.36215771e-03f,
  3.48595530e-02f, -1.25223550e-03f, -2.38853052e-01f, -7.31267780e-02f, -9.98435635e-03f, -1.40426429e-02f, 5.94875962e-03f, -3.41799334e-02f, -4.68409285e-02f, 1.41224265e-01f,
  7.30926618e-02f, -8.99448246e-02f, -3.51801552e-02f, 1.18580908e-02f, -7.75846466e-02f, -1.30602688e-01f, 1.28544152e-01f, 5.45370430e-02f, -1.11407019e-01f, 5.24939559e-02f,
  -5.20380512e-02f, 3.97465937e-03f, -1.69909939e-01f, 3.29535604e-02f, 8.58822837e-02f, -5.47960103e-02f, 4.90837544e-02f, -6.71706200e-02f, 8.54060352e-02f, 3.43425274e-02f,
  3.96926366e-02f, -3.60699482e-02f, -1.17484457e-03f, 4.84398156e-02f, 5.23088127e-02f, 7.41838152e-03f, -6.60487264e-02f, 3.91166052e-03f, -5.78164645e-02f, 7.61156306e-02f,
  -4.89829630e-02f, 3.77968140e-02f, -1.24066453e-02f, 9.81562398e-03f, 1.97997428e-02f, -2.24142894e-02f, -2.63561797e-03f, -3.60667221e-02f, -2.39865091e-02f, 3.74638587e-02f,
  -8.63671973e-02f, -1.38784312e-02f, -9.51285958e-02f, -2.37938333e-02f, 5.70546500e-02f, -4.33974601e-02f, 5.81460595e-02f, 3.63579653e-02f, 4.13362384e-02f, 7.97545910e-02f,
  4.31732982e-02f, 5.95507538e-03f, -6.79037767e-03f, -6.37951493e-02f, 4.26047156e-03f, 2.83191353e-02f, -6.47960454e-02f, -1.98081303e-02f, -2.54165977e-02f, 9.01697949e-02f,
  7.65543943e-03f, -2.34588366e-02f, -3.18160951e-02f, -1.83275342e-02f, -4.66140732e-02f, -5.85760251e-02f, 6.44276142e-02f, -2.42791083e-02f, -1.74979232e-02f, -4.86310273e-02f,
  -2.55187172e-02f, -3.75166759e-02f, 3.59966941e-02f, -3.72452773e-02f, -4.27233875e-02f, -1.91881470e-02f, -5.91832213e-02f, 3.74496914e-02f, 2.22145244e-02f, -4.49192524e-02f,
  7.06254467e-02f, 7.12281764e-02f, -1.93049229e-04f, -7.29202479e-02f, -4.54428829e-02f, 1.27416253e-01f, 1.04888324e-02f, -1.88544709e-02f, -4.26651351e-02f, 7.59631842e-02f,
  7.49688521e-02f, -4.40299623e-02f, -4.27824557e-02f, 6.09754175e-02f, 7.80940056e-03f, 2.05846597e-02f, 6.47348389e-02f, -6.20640479e-02f, -5.38876653e-02f, -9.79449600e-02f,
  -5.28824255e-02f, 1.42062632e-02f, 2.43085623e-02f, -2.33012508e-03f, 5.38735203e-02f, 6.87165335e-02f, -9.23656896e-02f, 4.31080237e-02f, -5.04136458e-02f, 7.75582939e-02f,
  -3.46300542e-01f, 3.86624150e-02f, 6.51250482e-02f, -2.59902552e-02f, -2.11368978e-01f, 4.97791991e-02f, 6.53219670e-02f, -7.63980374e-02f, -1.43354073e-01f, 1.86804265e-01f,
  6.40221164e-02f, 9.35210381e-03f, 1.52287275e-01f, 2.19891042e-01f, -6.94022030e-02f, 3.30887511e-02f, -1.10040076e-01f, 5.65871298e-02f, -1.30124003e-01f, -4.92581502e-02f,
  -1.70222268e-01f, 6.45886213e-02f, 9.34927762e-02f, 2.86601447e-02f, 2.90071988e-03f, -1.47643864e-01f, -4.28747088e-02f, 1.24932751e-02f, -1.02484182e-01f, -4.08955589e-02f,
  -1.79567859e-01f, -1.26447544e-01f, 1.64065044e-02f, -1.09509014e-01f, 7.20208697e-03f, -1.04991838e-01f, 5.10885613e-03f, 4.33395989e-02f, -1.03708945e-01f, -6.43865168e-02f,
  -1.87021196e-02f, 5.20060323e-02f, 1.51713695e-02f, 5.28194234e-02f, -5.72996400e-02f, 2.48287618e-02f, -9.11227986e-02f, -8.32965970e-02f, -5.03034741e-02f, -4.62114736e-02f,
  6.30334243e-02f, 2.23783730e-03f, -2.71956101e-02f, 2.98236404e-02f, 3.31560448e-02f, -4.90637049e-02f, -6.65654689e-02f, 6.82405755e-03f, 5.83417760e-03f, 7.93886371e-03f,
  -8.32062885e-02f, 4.29480411e-02f, -6.01433143e-02f, 5.83445355e-02f, -8.94990191e-03f, 7.58542418e-02f, 6.12336546e-02f, -2.95888688e-02f, -4.29570079e-02f, -2.72630956e-02f,
  2.98566781e-02f, 4.74432223e-02f, -1.31458947e-02f, -2.45412271e-02f, -2.19454225e-02f, -5.58539368e-02f, 6.71407655e-02f, 1.24258818e-02f, 1.78793799e-02f, 1.04994299e-02f,
  2.09819358e-02f, 9.60057750e-02f, -1.26241939e-02f, 6.05819225e-02f, -2.84039583e-02f, 2.36864872e-02f, -7.04580769e-02f, 6.97016641e-02f, 3.45169120e-02f, 9.31249745e-03f,
  -2.29029551e-01f, -8.56334418e-02f, -9.56092775e-02f, -7.03339949e-02f, -3.51751372e-02f, -5.86757213e-02f, -8.96821078e-03f, -1.43032044e-01f, -8.33410546e-02f, 2.49065887e-02f,
  -1.11368520e-03f, 8.55583549e-02f, -5.46084158e-03f, -1.44423507e-02f, -4.49070409e-02f, -2.52612997e-02f, 1.47282872e-02f, 9.09423642e-03f, -2.16448940e-02f, -6.17766678e-02f,
  7.72042722e-02f, -8.44424218e-02f, 4.07794267e-02f, 3.40988971e-02f, -9.13109779e-02f, -6.40628710e-02f, -7.55933002e-02f, 5.76234311e-02f, -6.40921891e-02f, 2.50439662e-02f,
  1.59637824e-01f, -6.04726017e-01f, 1.72169968e-01f, 2.80496955e-01f, 3.51349950e-01f, 9.87589359e-02f, 1.89535439e-01f, -2.22052876e-02f, 1.08265676e-01f, -3.83558035e-01f,
  2.45391522e-02f, -1.65435836e-01f, -1.84527367e-01f, -7.84184560e-02f, 2.18136102e-01f, -1.84871256e-03f, -2.87814792e-02f, 4.18609306e-02f, 6.45123944e-02f, 8.41483325e-02f,
  2.73770005e-01f, 8.52884352e-02f, 7.11218491e-02f, -1.85926914e-01f, 1.55765876e-01f, 4.97909375e-02f, 3.61449681e-02f, 6.49959967e-02f, -9.32065174e-02f, 3.27305645e-02f,
  -8.57826415e-03f, -3.99849787e-02f, -4.43971679e-02f, -5.64650707e-02f, 1.65196490e-02f, -6.27453104e-02f, -1.01686805e-01f, -1.50941173e-02f, 3.33035588e-02f, 4.19126898e-02f,
  -6.97371587e-02f, 1.37708876e-02f, 1.20634668e-01f, 7.01171607e-02f, 5.94974346e-02f, 1.27484620e-01f, 8.05501416e-02f, -2.46642195e-02f, -5.07939309e-02f, -3.89697105e-02f,
  -3.64166759e-02f, -5.40998988e-02f, 2.56087873e-02f, -1.33559898e-01f, -3.30585316e-02f, -7.72127584e-02f, -1.73922796e-02f, 1.25037460e-02f, -4.46919985e-02f, 4.91350563e-03f,
  -1.09700359e-01f, -5.76510578e-02f, 1.87248066e-02f, 3.97798885e-03f, 9.50948298e-02f, 5.95094077e-02f, -3.96068022e-02f, -5.13200238e-02f, -1.66960414e-02f, 2.58967038e-02f,
  -3.05319391e-02f, -8.52742046e-03f, 1.86244156e-02f, 4.56596799e-02f, 5.17899636e-03f, -5.38563207e-02f, 3.52919661e-02f, 1.97876301e-02f, -4.61841039e-02f, -5.41290268e-03f,
  -6.27858266e-02f, 5.11822328e-02f, 4.53633331e-02f, 1.07798040e-01f, -1.36896605e-02f, 2.16956735e-02f, 9.98908002e-03f, 5.80515750e-02f, 6.58786818e-02f, -4.88094576e-02f,
  -2.24427506e-01f, -3.04300696e-01f, -3.63430195e-02f, 1.43213868e-02f, -2.89090611e-02f, -1.02491513e-01f, -8.37240964e-02f, -4.99416292e-02f, -2.71319412e-02f, -3.14694308e-02f,
  -3.58126722e-02f, -4.94129526e-05f, -5.15299551e-02f, 2.42203455e-02f, -8.06494504e-02f, -1.40575320e-02f, 7.01887358e-04f, -1.31744042e-01f, 1.72355380e-02f, -1.18319504e-02f,
  4.75462638e-02f, 1.57216396e-02f, 6.29797876e-02f, 4.24415693e-02f, -4.12938334e-02f, 2.95138229e-02f, 1.34510361e-02f, -5.50793037e-02f, -6.63481802e-02f, -8.85411352e-03f,
  -3.00018471e-02f, -7.00169727e-02f, -2.14667499e-01f, -2.89661258e-01f, 5.13049215e-03f, -1.80392399e-01f, -2.11957544e-01f, -5.51184174e-03f, -3.01006455e-02f, 2.04759970e-01f,
  6.46945238e-02f, -5.60120493e-02f, 1.70097835e-02f, -2.03571454e-01f, -1.30066797e-01f, -1.05670966e-01f, -2.99582034e-01f, -1.85600162e-01f, 5.75496443e-03f, -1.86802268e-01f,
  -1.89383626e-01f, -6.66505843e-02f, -3.51673394e-01f, -4.96062078e-02f, -1.96026921e-01f, -2.61894818e-02f, 1.16089225e-01f, 3.42428870e-03f, -8.36504102e-02f, -2.85695437e-02f,
  3.03259259e-03f, 1.74707156e-02f, -7.33663142e-02f, -1.22364260e-01f, -2.39463784e-02f, 8.37718993e-02f, -8.23236331e-02f, 2.84720827e-02f, 2.02731360e-02f, -8.71306006e-03f,
  7.11741373e-02f, -1.19221965e-02f, 7.83686154e-03f, -7.65487226e-03f, -2.90249363e-02f, -2.55393870e-02f, 3.28889536e-03f, -3.00030969e-02f, -1.13111570e-01f, -9.96553451e-02f,
  -1.13117412e-01f, -1.02418626e-03f, -8.74140188e-02f, 2.56480761e-02f, -7.52225369e-02f, 8.75183102e-03f, 2.73393169e-02f, -1.03015423e-01f, -6.90407231e-02f, -1.22083339e-03f,
  -3.99229825e-02f, -2.51456406e-02f, 1.54651394e-02f, 1.87836848e-02f, 1.63989719e-02f, 3.25790793e-02f, -1.74401440e-02f, 9.97432247e-02f, 5.35952784e-02f, 4.65268977e-02f,
  4.86386903e-02f, -2.22633616e-03f, -2.24323533e-02f, 8.16441141e-03f, -2.77500320e-02f, 6.14502504e-02f, 1.78448204e-02f, 1.73663907e-02f, -6.24109954e-02f, 2.19735410e-02f,
  8.80371314e-03f, -2.49669584e-03f, 5.79351149e-02f, 6.96190745e-02f, 6.53672358e-03f, -3.67166437e-02f, -3.51165123e-02f, 6.05209032e-03f, -6.02456443e-02f, -4.79537509e-02f,
  6.70986576e-03f, 1.01703301e-01f, 7.72024170e-02f, 3.60986069e-02f, 4.69557941e-02f, -2.24111751e-02f, 7.02784583e-02f, -1.08245686e-02f, 3.53862308e-02f, -1.17115758e-03f,
  -4.26608417e-03f, -7.42274895e-02f, 6.84731081e-02f, -3.23996581e-02f, 7.40095647e-03f, 8.37013870e-02f, 7.94856101e-02f, 5.91999851e-02f, -6.72438368e-02f, 2.55673975e-02f,
  -5.64158596e-02f, 1.08395591e-02f, 7.19577372e-02f, -3.05643622e-02f, -4.66710739e-02f, 1.39681503e-01f, 1.87461786e-02f, 1.97260100e-02f, -3.02449167e-02f, 2.11920813e-02f,
  3.81678082e-02f, -3.03537965e-01f, -1.05983697e-01f, 1.07277706e-01f, 1.39682233e-01f, 1.27422154e-01f, 1.15974741e-02f, -7.47997314e-02f, 3.29131191e-03f, -2.34158263e-01f,
  -2.35260706e-02f, -5.45332320e-02f, -1.63180709e-01f, 6.88696876e-02f, 1.09787256e-01f, -1.31588653e-01f, 9.55242664e-02f, 1.26596661e-02f, 4.10076007e-02f, -2.52107810e-02f,
  1.03864335e-01f, 6.06391989e-02f, 1.12568513e-01f, 1.43158466e-01f, 4.48543299e-03f, -9.83448606e-03f, 1.25730783e-01f, 4.48172465e-02f, 4.20997590e-02f, 9.29507986e-02f,
  -4.53003459e-02f, 5.12398742e-02f, 7.28492439e-02f, -6.71211332e-02f, 4.06205431e-02f, 3.56498137e-02f, 6.06606789e-02f, 1.14107437e-01f, 8.83553512e-05f, 2.43027527e-02f,
  -1.68494396e-02f, 6.65063038e-03f, -4.55713831e-02f, -3.49130668e-02f, 1.22664357e-02f, 5.72264334e-03f, -5.26050478e-03f, 4.29412089e-02f, 9.47939903e-02f, -5.43921292e-02f,
  9.65313707e-03f, -5.96687719e-02f, 2.55596563e-02f, 1.46604935e-02f, 4.32131626e-02f, 6.70114681e-02f, 5.67742623e-02f, 1.20194983e-02f, -1.65672507e-02f, -1.98687054e-02f,
  1.00967251e-02f, 7.99291730e-02f, -3.88560072e-02f, -8.43595788e-02f, -3.68378349e-02f, 1.68162510e-02f, 6.98365793e-02f, -2.61147451e-02f, -9.78370905e-02f, -1.09930420e-02f,
  -5.85383996e-02f, 3.20148915e-02f, -4.17652540e-02f, 3.58359590e-02f, -2.17123106e-02f, 8.89057219e-02f, -6.02836050e-02f, -5.58818169e-02f, -1.35605112e-02f, -2.03827973e-02f,
  5.75554296e-02f, 4.59776372e-02f, -4.99912500e-02f, -7.01063126e-02f, 1.91342998e-02f, 2.80892365e-02f, -3.30505669e-02f, 4.88101458e-03f, 8.06278735e-03f, 8.25096518e-02f,
  -2.06500560e-01f, -1.70160919e-01f, 6.80674836e-02f, -5.47720119e-02f, -8.11209157e-02f, 2.75574066e-02f, -7.78271407e-02f, -3.38141806e-02f, 7.27314595e-03f, -9.10251886e-02f,
  -2.49254312e-02f, 2.09100023e-02f, -3.16156745e-02f, -4.16038372e-02f, 9.93654132e-02f, -3.47713083e-02f, -8.47951323e-02f, -2.90186610e-02f, -2.52904650e-02f, 4.36110571e-02f,
  3.75985750e-03f, -7.37490132e-02f, -4.84090149e-02f, -7.52700195e-02f, 2.53199134e-02f, -5.30398563e-02f, 2.12042220e-02f, 1.41383139e-02f, 6.97791725e-02f, -2.91776173e-02f,
  2.50844024e-02f, 1.16427317e-02f, 7.03680590e-02f, 4.88951337e-04f, -9.05343369e-02f, -1.52505681e-01f, -1.29085690e-01f, -6.39567897e-02f, 4.07416634e-02f, 2.97742318e-02f,
  2.98605748e-02f, 1.13811202e-01f, -1.04326509e-01f, 4.56088148e-02f, -6.16008230e-02f, 4.91198152e-02f, 6.46941215e-02f, 4.79979552e-02f, 4.21645977e-02f, 5.86071275e-02f,
  2.98584644e-02f, -6.65989593e-02f, 8.72180909e-02f, 7.36947954e-02f, 5.82422577e-02f, 6.02762625e-02f, 1.54373765e-01f, -4.96242754e-02f, -1.21517386e-03f, 7.84995556e-02f,
  -8.88613090e-02f, -1.16334902e-02f, -5.24606444e-02f, -6.32039234e-02f, 4.44124974e-02f, -2.07062308e-02f, -5.76245263e-02f, 6.47097155e-02f, 6.91641495e-02f, -1.82059165e-02f,
  4.96708974e-02f, 3.86647834e-03f, -6.73623681e-02f, -2.55891066e-02f, -7.01398924e-02f, 8.82305428e-02f, -8.17601457e-02f, -2.59840544e-02f, 2.81802006e-02f, -4.09643240e-02f,
  -6.72382042e-02f, -4.49532755e-02f, -3.99441570e-02f, -7.34442845e-02f, -5.38144400e-03f, -4.94945236e-02f, -3.73738557e-02f, 5.06783202e-02f, -2.70392969e-02f, -7.75838792e-02f,
  5.94659746e-02f, 6.81003034e-02f, 1.07075460e-02f, -6.57305717e-02f, 1.76681466e-02f, 5.76792322e-02f, 4.64934446e-02f, 3.18668559e-02f, 7.46397115e-03f, 2.83681769e-02f,
  -7.22537690e-04f, 4.52872626e-02f, -1.64204035e-02f, 7.93607906e-02f, -1.50319538e-04f, 1.86360758e-02f, 2.28473339e-02f, -4.12572641e-03f, -5.45853786e-02f, -2.43049338e-02f,
  5.93556948e-02f, -5.42967096e-02f, -3.56967300e-02f, 2.45367754e-02f, -9.92674306e-02f, -1.88862663e-02f, 1.77922975e-02f, -7.95145519e-03f, 5.09346020e-04f, 6.07164241e-02f,
  7.75877684e-02f, 1.07810246e-02f, -2.53336853e-04f, -1.76932029e-02f, -4.71817590e-02f, 5.93544682e-03f, -1.97020005e-02f, -7.49903768e-02f, -2.51992475e-02f, 7.56741539e-02f,
  8.16892236e-02f, -8.57688636e-02f, 1.01127684e-01f, -8.44928715e-03f, 5.32945804e-02f, 1.76455583e-02f, -6.77395687e-02f, -2.75673755e-02f, 1.51125491e-02f, -6.17215224e-02f,
  5.74140213e-02f, 8.70035067e-02f, -6.29436225e-02f, 3.65873054e-02f, 7.13985134e-03f, 7.57411495e-02f, 4.99280505e-02f, 3.14582512e-02f, 7.74562657e-02f, 4.49783616e-02f,
  -7.77318776e-02f, -5.71437329e-02f, -1.53210491e-01f, 2.68418312e-01f, -2.72003680e-01f, -3.02433163e-01f, -1.67606637e-01f, 2.22687609e-02f, -1.24557585e-01f, 3.52905393e-02f,
  1.28207788e-01f, -3.51304784e-02f, 5.07672876e-02f, 4.36063945e-01f, 3.30874741e-01f, 2.27644518e-01f, 3.18634242e-01f, 8.50011408e-02f, 6.95400015e-02f, 1.44693598e-01f,
  2.62317777e-01f, 3.28673601e-01f, 2.70408660e-01f, 2.13204801e-01f, 1.36140203e-02f, 7.93773606e-02f, 2.63611197e-01f, -5.74222431e-02f, 2.38761440e-01f, 1.00964941e-01f,
  -5.84714152e-02f, 2.28162706e-02f, 6.06988035e-02f, -3.14656273e-02f, 2.67364588e-02f, -1.22872613e-01f, -9.94866043e-02f, -6.76206499e-02f, -5.92818148e-02f, -1.36178639e-02f,
  -1.29916459e-01f, 6.38457835e-02f, 3.16514112e-02f, 1.58467237e-03f, -5.99736981e-02f, 1.28707821e-02f, -1.36284987e-02f, -5.77418916e-02f, 5.96268773e-02f, -5.62160509e-03f,
  -8.09649527e-02f, 3.32159176e-02f, -6.17600221e-04f, -2.15511136e-02f, 5.28086461e-02f, 6.84982678e-03f, 2.47797612e-02f, -3.89010012e-02f, -9.08644423e-02f, 2.61685830e-02f,
  -7.85358846e-02f, -3.48022841e-02f, -5.63234091e-03f, 1.25738112e-02f, 3.85743380e-02f, 2.72591263e-02f, 5.71118854e-02f, 3.74754687e-04f, 2.96489969e-02f, 8.21099151e-03f,
  -3.50214466e-02f, 7.48553604e-04f, 1.85105205e-02f, -2.06069145e-02f, 3.09516657e-02f, -4.01633419e-02f, -6.36091754e-02f, 3.86796705e-03f, -1.22085316e-02f, -4.16597538e-02f,
  -4.10147943e-02f, 3.71251591e-02f, 5.85101917e-02f, -5.64889610e-02f, 4.21033753e-03f, 3.13740633e-02f, 1.21042252e-01f, 5.54629602e-02f, 1.81406122e-02f, -2.84512024e-02f,
  1.18558146e-01f, 9.33834538e-02f, -5.24290279e-02f, -1.05235755e-01f, 1.33723980e-02f, -5.32719865e-02f, 5.95043227e-02f, 2.90529840e-02f, 2.67647058e-02f, -1.89474784e-02f,
  -9.91965830e-03f, 1.42695205e-02f, -6.21851012e-02f, 2.86651533e-02f, 1.05161108e-01f, 3.01397461e-02f, 3.02782785e-02f, -2.07035821e-02f, 5.20316623e-02f, 8.16223398e-02f,
  -5.14541194e-02f, -9.20675918e-02f, 2.09855512e-02f, -7.81740621e-02f, 3.39337774e-02f, -1.48398094e-02f, -1.10901007e-02f, -6.21481575e-02f, 3.96302901e-02f, 5.46744168e-02f,
  -1.63230106e-01f, -1.59316733e-01f, 6.29526600e-02f, -3.17761898e-02f, 1.78037792e-01f, 1.54873833e-01f, -4.91620377e-02f, 1.04981132e-01f, 5.32555357e-02f, 3.44694033e-02f,
  1.28058288e-02f, -1.89599007e-01f, -3.65199819e-02f, -1.27081931e-01f, -4.62201424e-02f, -1.90665841e-01f, -5.23924567e-02f, -1.50815826e-02f, -8.41598734e-02f, 4.63424549e-02f,
  -9.63632911e-02f, -4.02344111e-03f, -1.09280027e-01f, 7.03676641e-02f, 1.03708632e-01f, 1.18314900e-01f, 6.86037615e-02f, 4.64920513e-02f, 5.41415028e-02f, -5.41503206e-02f,
  1.31309003e-01f, -4.86147478e-02f, -2.85649672e-02f, 2.57502832e-02f, 9.82620567e-02f, 1.28421754e-01f, -5.22951595e-02f, 4.96520214e-02f, 2.49062590e-02f, 2.38624346e-02f,
  4.60456684e-02f, 1.06409956e-02f, -5.05217947e-02f, 1.22161992e-02f, -5.96673153e-02f, -7.91718215e-02f, -4.09233384e-02f, -1.24866273e-02f, 6.25345707e-02f, 1.30988117e-02f,
  1.78538226e-02f, 2.98282579e-02f, 6.48520282e-03f, -3.98264378e-02f, 4.47020605e-02f, -6.25702962e-02f, -4.48442474e-02f, 6.47172034e-02f, -6.10042028e-02f, -5.73877580e-02f,
  -8.37669000e-02f, -6.72980994e-02f, 6.50518313e-02f, -7.43640065e-02f, 4.38498296e-02f, 1.21512180e-02f, 5.84793910e-02f, 4.28638346e-02f, -6.42977059e-02f, -8.70362371e-02f,
  4.62618507e-02f, 3.86915542e-02f, -8.05360323e-04f, 1.27568946e-03f, 5.94626404e-02f, 3.92370522e-02f, -2.78814286e-02f, -1.06847780e-02f, 2.46309005e-02f, -1.81225836e-02f,
  4.83902358e-02f, -8.08238611e-02f, -6.80107400e-02f, -2.75249947e-02f, -6.81165159e-02f, 6.15936331e-02f, 6.74521700e-02f, 9.87732597e-03f, -6.06263168e-02f, 2.35202964e-02f,
  3.65763642e-02f, 1.09429723e-02f, -1.49180996e-03f, 3.71027291e-02f, -3.08421697e-03f, 1.34469435e-01f, -2.25483831e-02f, 3.05496752e-02f, -2.47089062e-02f, 7.67312869e-02f,
  3.39148827e-02f, 2.14473382e-02f, -3.38883661e-02f, -6.55589774e-02f, -4.96456251e-02f, 8.09938014e-02f, -5.29084280e-02f, 1.41866598e-02f, 6.75310418e-02f, -7.15242326e-02f,
  -2.70951502e-02f, 5.77673092e-02f, -8.03618580e-02f, 6.29601553e-02f, -6.76119924e-02f, -1.05838934e-02f, 8.80424082e-02f, 9.34008509e-02f, 3.64811718e-02f, 5.30871712e-02f,
  -1.61710139e-02f, -5.13209365e-02f, 7.20387744e-03f, 6.72836006e-02f, -2.38529429e-01f, 2.32175991e-01f, 3.86204094e-01f, -1.22185260e-01f, -9.97816212e-03f, 1.87026754e-01f,
  1.17213875e-01f, 1.65490031e-01f, 2.23968640e-01f, 2.42583305e-01f, 1.93221316e-01f, 2.48994455e-01f, 2.94277251e-01f, 1.96224764e-01f, -3.08717676e-02f, 3.29451226e-02f,
  -2.05768421e-02f, 6.39353245e-02f, 1.29736856e-01f, -2.72272259e-01f, -7.19037578e-02f, -1.63092226e-01f, -3.52694206e-02f, -6.08578697e-02f, -6.30087852e-02f, 1.45128984e-02f,
  8.01685080e-02f, -9.83835459e-02f, -3.72323282e-02f, -1.11965565e-02f, -1.61467418e-02f, 1.29496790e-02f, 2.97221914e-02f, 9.00454372e-02f, -2.99688950e-02f, -2.99062766e-02f,
  3.56666483e-02f, -7.43062869e-02f, 7.00780600e-02f, -1.01495825e-01f, -3.76593508e-02f, -5.36611350e-03f, -2.96527389e-02f, -6.53538704e-02f, 8.94673914e-03f, -3.64150549e-03f,
  5.58810569e-02f, 1.12657892e-02f, 2.75905505e-02f, 4.92112637e-02f, 1.88181978e-02f, 3.58692035e-02f, 1.25219688e-01f, -2.53635030e-02f, -6.40429230e-03f, -2.98089385e-02f,
  -6.13845587e-02f, -4.41654399e-03f, 2.09988523e-02f, -8.36717486e-02f, -7.58779119e-04f, -3.32371593e-02f, 6.12769909e-02f, 7.56446049e-02f, -1.53399846e-02f, 6.39272928e-02f,
  8.60403776e-02f, -3.98014262e-02f, 6.63423538e-02f, 1.60007812e-02f, -6.10378745e-04f, 8.09045658e-02f, 4.80304053e-03f, 7.09675848e-02f, 4.05383185e-02f, -2.35648025e-02f,
  1.37400264e-02f, -7.46638253e-02f, 1.97462225e-03f, 6.80101961e-02f, 7.99101070e-02f, -3.44598927e-02f, -4.42937128e-02f, -4.20782529e-02f, 2.73658894e-03f, 5.74720725e-02f,
  3.23583446e-02f, 1.36735901e-01f, 8.70981142e-02f, -3.62681900e-03f, 2.22696327e-02f, -2.34406460e-02f, -7.11912587e-02f, -1.30635202e-01f, 3.32643129e-02f, 4.73106764e-02f,
  4.35541682e-02f, 3.40593085e-02f, -4.08343785e-02f, 3.06673069e-02f, -1.62811596e-02f, -5.46722449e-02f, 3.99014056e-02f, 5.32342643e-02f, 1.03244707e-02f, -2.68341061e-02f,
  -9.29948539e-02f, -1.75789241e-02f, 4.95671630e-02f, -2.27511488e-02f, -2.37009693e-02f, 7.38042742e-02f, 1.06106363e-02f, -6.15119599e-02f, 1.20728398e-02f, -4.60883453e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.11074127e-02f, 1.31168902e-01f, 1.49595086e-02f, -4.49142382e-02f, 1.05734780e-01f, 5.34113348e-02f, 1.71810299e-01f, 2.25248322e-01f, 6.51730597e-02f, 1.01920828e-01f,
  5.23968004e-02f, 1.01792224e-01f, 1.00749113e-01f, 2.76554912e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -6.10675365e-02f, 3.90940420e-02f, 1.31044360e-02f, -3.97887789e-02f, -1.05776303e-02f, 6.52323514e-02f, -1.34591788e-01f, 2.12871097e-02f, -1.95153765e-02f, 1.67960748e-01f,
  -5.06955087e-01f, 5.42776763e-01f, -2.90275455e-01f, 1.17016725e-01f, -4.32935297e-01f, 2.96688974e-01f, -1.79709613e-01f, -2.57048845e-01f, -4.41258177e-02f, -6.96543753e-02f,
  -3.90478782e-02f, -9.29917842e-02f, -8.48432779e-02f, -4.18722024e-03f, 1.19745485e-01f, -8.65984932e-02f, 2.44896099e-01f, 2.22686641e-02f, -1.58378303e-01f, -5.55798225e-02f,
  2.50789255e-01f, -3.14173877e-01f, -2.35193735e-03f, -2.03468695e-01f, -1.62408501e-01f, -2.84945399e-01f, 1.52501166e-01f, -2.77952477e-02f, -6.19581081e-02f, -2.39585176e-01f,
  -1.73527718e-01f, 1.35873139e-01f, 3.15845162e-01f, 2.07341146e-02f, 2.94692785e-01f, -3.69724512e-01f, 1.28990516e-01f, -1.75404608e-01f, -1.52234912e-01f, 2.66942382e-01f,
  -7.33467042e-02f, 7.29696453e-02f, 1.27282590e-01f, 7.37298355e-02f, -8.01445097e-02f, 1.28595456e-01f, -2.34618597e-03f, -4.43048269e-01f, -5.83162867e-02f, -2.19645277e-01f,
  1.48831591e-01f, 2.96864301e-01f, -1.67644069e-01f, 2.36652851e-01f, -3.56069021e-02f, 1.94883972e-01f, 6.66745473e-03f, -5.85380420e-02f, 7.53412917e-02f, 2.78086096e-01f,
  -1.19126432e-01f, -1.47506371e-01f, -4.26147319e-02f, 1.02922015e-01f, -7.63471499e-02f, 2.08937183e-01f, 2.93901384e-01f, 2.93266684e-01f, 1.37191474e-01f, 7.37623796e-02f,
  -1.97844371e-01f, -3.17266524e-01f, -3.84804040e-01f, -1.19498350e-01f, -8.52819940e-04f, -1.76679894e-01f, 3.72529402e-02f, -1.42039910e-01f, 3.20600152e-01f, -3.28953229e-02f,
  -2.73135845e-02f, 2.72330400e-02f, 2.55471729e-02f, -1.64438616e-02f, -7.14403838e-02f, 7.82271102e-02f, 2.50012696e-01f, 2.67819178e-05f, 1.74963549e-01f, -2.15803340e-01f,
  1.82271078e-01f, 5.06515033e-04f, 1.30585791e-03f, -7.06985891e-02f, 1.27773672e-01f, -1.60194099e-01f, -2.36752361e-01f, -5.08298762e-02f, -1.73111409e-02f, -2.27869391e-01f,
  5.59734777e-02f, -2.41420284e-01f, -4.19038504e-01f, 6.56399727e-02f, 1.07259348e-01f, 2.29003116e-01f, 7.33876899e-02f, -1.98362812e-01f, -1.13831043e-01f, 1.96165115e-01f,
  -2.14076400e-01f, 1.85161829e-01f, 2.07843602e-01f, -3.10067227e-03f, 8.92310068e-02f, -4.20948528e-02f, 1.46977082e-01f, -1.37536064e-01f, 1.59902245e-01f, -1.87714130e-01f,
  8.72853547e-02f, -2.37510987e-02f, 6.02216311e-02f, -2.29844600e-01f, -9.98734757e-02f, 1.90441594e-01f, -1.89859852e-01f, -2.83740759e-01f, 4.09961231e-02f, -3.99799943e-01f,
  4.31258008e-02f, -4.75296415e-02f, 2.50477195e-01f, -1.72272533e-01f, 1.06244152e-02f, 1.44825637e-01f, 2.60452330e-01f, 1.91206306e-01f, -8.03070515e-02f, 7.66313076e-02f,
  2.58727461e-01f, -1.79138303e-01f, -2.47238293e-01f, -1.18787317e-02f, 9.59493965e-03f, 4.03989851e-02f, -1.99211412e-04f, 2.46239498e-01f, -1.93049267e-01f, -2.95193225e-01f,
  -1.95569154e-02f, 3.93919684e-02f, 4.14049402e-02f, -2.90604115e-01f, -4.24735947e-03f, -1.59727395e-01f, -2.02888101e-01f, 6.22439943e-03f, -1.79113105e-01f, -3.89763378e-02f,
  -2.95178026e-01f, 3.15482408e-01f, 3.02754074e-01f, -1.07748844e-01f, -4.16794568e-02f, 9.30223316e-02f, -1.31894648e-01f, -3.33062112e-02f, 1.57437995e-01f, 1.17603771e-01f,
  -1.70426175e-01f, -1.45961285e-01f, -1.46389991e-01f, 6.02851473e-02f, 5.50852604e-02f, -4.07047987e-01f, 1.72246248e-01f, 9.13796108e-03f, 7.79105648e-02f, 1.08334817e-01f,
  1.58003137e-01f, -3.04785311e-01f, -2.81993479e-01f, 2.07572788e-01f, 1.23711698e-01f, 2.62829900e-01f, -2.37226002e-02f, -7.22241029e-02f, 6.19878173e-02f, 3.75740952e-03f,
  1.14832625e-01f, 1.51226848e-01f, 3.34743142e-01f, -2.59577006e-01f, -3.09124410e-01f, 2.62799084e-01f, -1.65369004e-01f, 2.72948653e-01f, 2.17159986e-01f, -3.05325806e-01f,
  -7.25258067e-02f, -1.39421627e-01f, -3.87056842e-02f, -9.42490622e-02f, 2.66358763e-01f, -1.51265264e-01f, -6.05036989e-02f, 5.01897605e-03f, -2.90993124e-01f, 7.01110512e-02f,
  -6.47334680e-02f, -6.77966997e-02f, 1.37318224e-01f, 3.22700500e-01f, 7.64366761e-02f, 1.44494057e-01f, 1.89593837e-01f, 8.98064822e-02f, -5.91660477e-02f, 2.30072767e-01f,
  3.08324903e-01f, -1.23774379e-01f, 1.16439685e-01f, 4.74944890e-01f, 3.12292635e-01f, 1.16932943e-01f, -2.86461532e-01f, -2.47185096e-01f, -2.71924824e-01f, 2.63526082e-01f,
  8.40902030e-02f, -4.45220396e-02f, -2.34379366e-01f, -2.92678922e-01f, -2.33194772e-02f, 4.06387169e-03f, -6.62886351e-02f, 1.08620189e-01f, 1.13244765e-01f, -1.85871631e-01f,
  1.29005268e-01f, -1.17875487e-01f, -9.40595791e-02f, -1.75158173e-01f, 1.18896037e-01f, 3.13465804e-01f, 1.07729413e-01f, 1.12832844e-01f, 1.70649737e-01f, 1.21254725e-02f,
  -1.93533912e-01f, 9.06193480e-02f, 1.55984119e-01f, 1.40955999e-01f, -9.93100926e-02f, -2.18437225e-01f, 2.58561283e-01f, -4.07326728e-01f, -1.28420651e-01f, 6.00569099e-02f,
  3.31425875e-01f, -2.40112096e-01f, -7.08267763e-02f, 1.01670653e-01f, -1.53767154e-01f, 2.99158692e-02f, 1.74341455e-01f, 1.10576138e-01f, 2.18631893e-01f, -7.16400594e-02f,
  2.14389674e-02f, 2.57319003e-01f, 4.50550253e-03f, 1.18608706e-01f, -9.33105722e-02f, -3.17557305e-01f, 9.87890661e-02f, 1.41285226e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  6.72398657e-02f, 1.98951706e-01f, 5.45763969e-02f, 3.73052210e-01f, -1.85201466e-01f, 3.92216712e-01f, 1.69695765e-01f, 1.90502867e-01f, 1.32229239e-01f, -5.05488634e-01f,
  1.07477330e-01f, -4.30689663e-01f, 5.79732358e-02f, 4.85577315e-01f, 2.09447872e-02f, 1.94761083e-01f, 2.77530432e-01f, -2.84204990e-01f, -5.65167749e-04f, 1.68936253e-01f,
  -1.32660478e-01f, -1.88687772e-01f, 2.62865245e-01f, -2.42150411e-01f, 7.53520727e-02f, 6.80023611e-01f, -1.47408426e-01f, 3.69022757e-01f, -1.57483920e-01f, -2.79630452e-01f,
  8.09612870e-02f, 1.91360131e-01f, -4.92509501e-03f, -6.51809992e-03f, 2.17249040e-02f, 2.39802852e-01f, 1.33998692e-01f, -7.88607001e-02f, 1.60414446e-02f, -5.51449433e-02f,
  2.86276340e-02f, -9.37665440e-03f, 3.02058682e-02f, 1.92816898e-01f, -1.19242482e-01f, 1.07123882e-01f, -3.55946392e-01f, 1.34331003e-01f, 2.68262267e-01f, -4.26340476e-02f,
  -3.80764417e-02f, 6.36227429e-02f, -1.80387855e-01f, 1.97619990e-01f, 1.82732847e-02f, -4.62010577e-02f, 2.52685875e-01f, -5.78463599e-02f, -2.50515789e-01f, 7.69995749e-02f,
  -4.88483384e-02f, 3.69998127e-01f, 2.48626508e-02f, 1.39168667e-04f, -8.88761878e-02f, 8.00406635e-02f, -1.08361423e-01f, 3.81944209e-01f, 1.47190869e-01f, 1.90448444e-02f,
  4.17068377e-02f, 2.39896908e-01f, 5.33059277e-02f, 2.81071603e-01f, 9.37538743e-02f, 3.20650727e-01f, -8.56416896e-02f, 1.63065106e-01f, -4.10545245e-02f, 2.64681131e-01f,
  1.74909964e-01f, -2.50445813e-01f, -9.20751169e-02f, -2.04465494e-01f, -1.58909723e-01f, -1.49606586e-01f, 2.91867293e-02f, -1.15144901e-01f, 2.75246382e-01f, -2.13247780e-02f,
  1.46731064e-01f, -1.26285106e-01f, -1.30237848e-01f, 2.39143327e-01f, -2.42277812e-02f, 3.48775089e-01f, 1.54089898e-01f, -5.13330884e-02f, -1.02436161e-02f, 5.12283966e-02f,
  8.12141970e-02f, -6.79842085e-02f, 1.17971741e-01f, 1.35204196e-02f, 2.80914336e-01f, -6.55645356e-02f, -1.09661162e-01f, -1.83711290e-01f, -8.86669382e-02f, -1.20967187e-01f,
  -1.43367156e-01f, -1.51115060e-01f, -1.12462662e-01f, 8.71962532e-02f, -5.70811369e-02f, -4.36558425e-02f, 1.37350395e-01f, -1.60913214e-01f, 1.36716291e-01f, 8.57031494e-02f,
  -1.44976586e-01f, -3.67339849e-02f, 7.43526444e-02f, 5.10218330e-02f, 1.70445174e-01f, -2.00683191e-01f, 2.39458159e-01f, 7.19807064e-03f, 1.50545657e-01f, 1.98351517e-01f,
  1.45563826e-01f, 1.66573554e-01f, -8.02512374e-03f, 8.97489116e-02f, -6.94767460e-02f, 6.43522665e-02f, -6.55023381e-02f, 2.07114428e-01f, -3.78527969e-01f, 3.72580051e-01f,
  1.04653612e-01f, -7.54970089e-02f, -1.27956376e-03f, 2.48845667e-01f, -5.52362436e-03f, -2.18566805e-01f, -1.61686853e-01f, 2.66828686e-01f, -1.77095369e-01f, -9.44689754e-03f,
  -1.61592662e-01f, -1.06460363e-01f, 1.88247755e-01f, 6.89596757e-02f, 1.87724158e-01f, 7.50113875e-02f, 1.44424051e-01f, 1.73300505e-01f, 1.53620362e-01f, -1.45071757e-03f,
  -6.92300647e-02f, 1.35060176e-01f, 1.25109687e-01f, 1.47673473e-01f, -9.40911993e-02f, -4.70502861e-02f, 3.29454914e-02f, -1.40195303e-02f, 7.34501798e-03f, 1.85328647e-02f,
  2.51439631e-01f, -1.62092876e-02f, 6.69686869e-02f, 1.63243748e-02f, -1.34011172e-02f, 1.10238314e-01f, 3.15743059e-01f, -1.52383834e-01f, 2.79814545e-02f, 6.53016940e-02f,
  -1.33027628e-01f, 3.04443785e-03f, 3.73313837e-02f, 5.00975586e-02f, 2.11996064e-01f, 1.34951621e-01f, -1.25507087e-01f, 1.43031165e-01f, 1.72453091e-01f, 2.25721389e-01f,
  -7.41346255e-02f, 2.18818903e-01f, 1.24510147e-01f, -8.97293314e-02f, 1.41364187e-01f, 1.67779356e-01f, 2.49534503e-01f, -2.99998783e-02f, -1.28594279e-01f, -3.45023535e-02f,
  -1.03625648e-01f, 4.15758565e-02f, -2.52026528e-01f, 1.12845615e-01f, -3.89575884e-02f, 1.78117648e-01f, -8.54751691e-02f, -1.58133842e-02f, 6.50173519e-03f, -7.83826038e-03f,
  2.51870990e-01f, 2.41288841e-01f, 1.01026841e-01f, 9.80744511e-03f, 1.47092953e-01f, -5.48854358e-02f, -1.43175811e-01f, 1.56894803e-01f, 9.86330211e-03f, 1.55311957e-01f,
  5.29083759e-02f, 3.17807704e-01f, -6.72083944e-02f, 7.00140595e-02f, 2.30482131e-01f, 1.50960162e-01f, 1.94452718e-01f, 1.71977296e-01f, 1.82123140e-01f, 1.54549256e-01f,
  -1.44127876e-01f, 2.11617336e-01f, 4.55582514e-02f, 1.75073743e-02f, -1.37448004e-02f, -1.03594698e-01f, 1.57300740e-01f, 2.06009224e-01f, 5.20861074e-02f, 7.24167526e-02f,
  6.30229805e-03f, -1.31272405e-01f, -1.71262085e-01f, 3.42111886e-01f, -6.90075457e-02f, -1.70952678e-01f, 1.66719109e-02f, -1.72055349e-01f, 6.92824125e-02f, 2.76062906e-01f,
  3.17035407e-01f, -3.48825753e-02f, 1.09151542e-01f, 1.48532599e-01f, 1.50338098e-01f, 3.87855880e-02f, 1.31201550e-01f, -1.43030986e-01f, -1.51622608e-01f, 1.76261649e-01f,
  2.90656872e-02f, -1.37505502e-01f, 1.10897804e-02f, -9.36771929e-02f, -8.79137889e-02f, 2.86793709e-02f, -1.23131193e-01f, 1.10497192e-01f, -1.47322789e-01f, 1.05383553e-01f,
  -1.78040907e-01f, -3.50232236e-02f, 1.31413147e-01f, 1.02503769e-01f, -1.70257747e-01f, -2.94255447e-02f, -1.77178010e-01f, 1.40675493e-02f, 8.70785937e-02f, 7.30556296e-03f,
  -1.80813186e-02f, -1.47631332e-01f, 3.58129595e-03f, 4.11196984e-02f, -5.31979389e-02f, 2.52059079e-03f, -6.71266243e-02f, 1.52390346e-01f, 3.11583549e-01f, -9.64962542e-02f,
  1.67187482e-01f, 1.90758303e-01f, 2.04037458e-01f, -8.54752287e-02f, 4.12888080e-01f, 4.08172518e-01f, 1.85376853e-01f, -1.96895868e-01f, -1.01454504e-01f, -6.76454306e-02f,
  -5.00586987e-01f, -3.96546215e-01f, -4.51957196e-01f, -5.01641691e-01f, 1.50618598e-01f, 4.45697397e-01f, 7.13614941e-01f, -9.80596021e-02f, -2.18826756e-02f, 1.87116385e-01f,
  5.61157763e-01f, 1.12754390e-01f, -3.38977426e-02f, 2.92978764e-01f, 1.09459318e-01f, 2.61187464e-01f, 2.29377933e-02f, 4.61736947e-01f, 2.20200628e-01f, 8.85622278e-02f,
  -1.82941198e-01f, -9.85135511e-02f, -8.97873566e-02f, 1.30288810e-01f, -9.21145529e-02f, 5.99763989e-02f, 2.56249428e-01f, -2.67227087e-02f, 2.96751082e-01f, 3.49459559e-01f,
  3.53918970e-01f, -7.68987983e-02f, -2.90704966e-01f, -1.19308032e-01f, -5.27904816e-02f, 3.45121808e-02f, 2.28391930e-01f, -3.60444151e-02f, 1.47021741e-01f, 8.23155884e-03f,
  -4.50738855e-02f, 6.59864917e-02f, -1.14495471e-01f, 1.78365946e-01f, 1.96186498e-01f, -1.32051036e-01f, 1.54987320e-01f, -7.95665476e-03f, -1.14416681e-01f, 1.89065307e-01f,
  9.53915566e-02f, 2.50362694e-01f, 1.24159031e-01f, -8.82581770e-02f, 2.62499213e-01f, 3.99203360e-01f, 5.91311343e-02f, 2.23888204e-01f, 4.80738655e-02f, 2.46837363e-01f,
  3.87123019e-01f, -1.01523168e-01f, -1.18578553e-01f, 2.81124443e-01f, -3.54395658e-02f, -8.05114508e-02f, -5.92894144e-02f, 3.29794079e-01f, -7.00144321e-02f, 3.11717596e-02f,
  -1.38024062e-01f, -9.27972198e-02f, -8.78683478e-02f, -1.81772456e-01f, -2.58500800e-02f, 1.89897373e-01f, 9.67591330e-02f, 1.01123989e-01f, 1.79817304e-01f, -1.16959378e-01f,
  9.67238024e-02f, -3.49885225e-01f, 1.37442276e-01f, -2.06827790e-01f, -1.37244940e-01f, -8.60620439e-02f, -1.52066305e-01f, -5.18741608e-02f, 1.71959728e-01f, -6.23823404e-02f,
  -2.34818030e-02f, -5.24757616e-03f, -8.77648965e-02f, -4.03740220e-02f, 1.08001411e-01f, 2.59463373e-03f, -8.96255448e-02f, 1.23114280e-01f, -1.43386116e-02f, 1.61226451e-01f,
  -1.32463083e-01f, 1.37343943e-01f, 8.92543122e-02f, -1.19891107e-01f, -8.78424793e-02f, 1.05891764e-01f, 1.52848959e-01f, 1.22019285e-02f, 1.21795692e-01f, -9.52531770e-02f,
  9.20520201e-02f, -1.56898350e-01f, -9.44638103e-02f, -6.31965548e-02f, 1.17846407e-01f, -6.11318089e-02f, 1.68192267e-01f, -1.06334865e-01f, 1.64320543e-01f, 4.84117940e-02f,
  2.21800789e-01f, -8.03128132e-05f, -2.29386911e-01f, -8.32588598e-02f, -8.89338553e-02f, -1.33935928e-01f, -2.16347456e-01f, -3.53456959e-02f, 1.84808388e-01f, 8.17224011e-02f,
  9.65525284e-02f, -4.38442416e-02f, -1.24473311e-01f, -7.21544772e-02f, -4.11307886e-02f, 1.67468786e-01f, -1.25778615e-01f, 1.15908653e-01f, 7.23938942e-02f, 7.40858214e-03f,
  2.12282091e-02f, 9.92756113e-02f, 3.72315407e-01f, -1.57360956e-01f, -1.66276041e-02f, 2.72384852e-01f, -2.02715769e-01f, -1.68572113e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.99540168e-01f, 2.19213843e-01f, 1.23124853e-01f, 1.26721010e-01f, 2.78917253e-01f, 8.54387954e-02f, 2.62531906e-01f, -2.22324184e-03f, -1.07641071e-01f, 2.11967081e-01f,
  1.10071018e-01f, 2.88876325e-01f, -4.24871258e-02f, -1.42945893e-04f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -4.86569703e-02f, -1.84203535e-01f, 1.95024684e-01f, 1.61083579e-01f, 9.53457206e-02f, 2.64917672e-01f, -1.01332523e-01f, -6.16896246e-03f, 2.17234164e-01f, 6.33084029e-02f,
  4.99875285e-02f, 4.37014908e-01f, -2.02589512e-01f, -2.34198600e-01f, 1.83842078e-01f, -3.37838709e-01f, 1.37688026e-01f, -8.25548545e-02f, -2.97992351e-03f, 2.60924369e-01f,
  6.53753430e-02f, -2.56745189e-01f, 3.61472428e-01f, 2.04371706e-01f, 1.23315580e-01f, 1.82598382e-01f, 9.53012779e-02f, -4.61554587e-01f, -1.39213428e-01f, -2.16222946e-02f,
  1.51533321e-01f, 3.80037888e-03f, 3.03534836e-01f, 4.54764441e-02f, 2.59635717e-01f, -6.85358122e-02f, 4.32041824e-01f, 7.10163042e-02f, -6.96842968e-02f, 2.69322455e-01f,
  -2.20773667e-01f, -3.85238945e-01f, 1.72055677e-01f, 1.38993844e-01f, 3.93597782e-02f, 1.20795615e-01f, -1.30623624e-01f, 2.55488586e-02f, 5.53183742e-02f, 5.06743252e-01f,
  2.69854158e-01f, -2.53256798e-01f, -2.59714156e-01f, 1.73494056e-01f, -2.53453255e-01f, 8.80721956e-02f, -5.42550348e-02f, -2.99311767e-04f, -1.60392597e-01f, -2.35190436e-01f,
  4.61532772e-02f, -1.25991851e-01f, -1.86811492e-01f, 7.61605203e-02f, 1.27093196e-01f, 4.31429548e-03f, -1.26566246e-01f, -1.33985281e-01f, -8.35728645e-02f, -7.08343163e-02f,
  5.36376536e-02f, -1.12151772e-01f, -1.68732658e-03f, -1.77837759e-01f, 2.94600338e-01f, -1.58193111e-01f, 2.81932294e-01f, 2.84191877e-01f, 1.48998544e-01f, -4.01794612e-01f,
  -5.01263082e-01f, -4.81308583e-04f, -1.54646814e-01f, 1.65077716e-01f, -2.37696350e-01f, 7.51693174e-02f, -5.45191206e-02f, -7.01566786e-02f, -6.96664825e-02f, -2.04311639e-01f,
  1.19444676e-01f, 3.52877617e-01f, -7.44690597e-02f, -2.45203063e-01f, 1.86341200e-02f, 7.85971712e-03f, 1.12426162e-01f, 2.42716253e-01f, 8.24228451e-02f, 2.73813605e-01f,
  3.30078185e-01f, -1.38001628e-02f, -1.84774429e-01f, -2.35255621e-02f, 1.56566679e-01f, -4.51972723e-01f, 1.03586376e-01f, 7.16782548e-03f, -3.76665592e-01f, -2.40940586e-01f,
  -3.58583212e-01f, 5.63632131e-01f, 5.06523311e-01f, 3.41403186e-01f, 2.62682796e-01f, 6.50570169e-02f, 9.49668363e-02f, 3.69987600e-02f, -2.44416699e-01f, 2.15268031e-01f,
  -1.06200606e-01f, -1.23178437e-01f, -6.07139282e-02f, 1.06630273e-01f, 4.90491986e-02f, -1.16345905e-01f, -3.41298766e-02f, -2.51101792e-01f, 1.02159657e-01f, 2.46244088e-01f,
  -9.73773524e-02f, 7.16486387e-03f, 7.57292286e-02f, -3.81612778e-02f, -1.45979643e-01f, -9.67314392e-02f, 1.53498381e-01f, -6.25557303e-01f, 3.72666448e-01f, -2.14328930e-01f,
  -4.35575604e-01f, 9.34954509e-02f, -3.27196509e-01f, 2.04085708e-01f, 9.10760984e-02f, 4.72180843e-01f, -1.79125369e-02f, 5.88183627e-02f, 1.00192562e-01f, -2.33969957e-01f,
  -4.71417010e-02f, 1.96226969e-01f, 1.52461842e-01f, 7.37747252e-02f, -1.17422253e-01f, 2.58728676e-02f, 1.68908283e-01f, -2.60078698e-01f, 2.61464659e-02f, -1.35989994e-01f,
  1.30615771e-01f, 1.70095682e-01f, -8.55473503e-02f, -1.73714221e-01f, -3.07550460e-01f, 4.13404666e-02f, 1.96125004e-02f, -3.61226946e-01f, 7.93325379e-02f, -4.67270851e-01f,
  2.37022147e-01f, -3.31588835e-01f, -2.66579986e-01f, 1.84904143e-01f, 1.73379537e-02f, 6.53079599e-02f, 1.29193589e-01f, 1.36672765e-01f, -2.76856482e-01f, 1.34424210e-01f,
  -4.77500148e-02f, -2.50961501e-02f, -1.82121798e-01f, 2.27540225e-01f, -1.15942210e-01f, -6.62226754e-04f, -6.98226169e-02f, 3.49487126e-01f, 2.23612174e-01f, -2.90873796e-01f,
  -1.60902381e-01f, -1.23574913e-01f, -1.76180139e-01f, -5.45444265e-02f, -2.33890399e-01f, -7.45136216e-02f, -4.15294796e-01f, 1.00933008e-01f, 3.42719397e-03f, -3.45607460e-01f,
  -4.51635644e-02f, 4.81344551e-01f, -2.27598026e-01f, -1.40351251e-01f, -2.74743140e-01f, -1.25535935e-01f, 1.57389969e-01f, 6.55041933e-02f, -1.38371140e-02f, -2.18343779e-01f,
  -1.83846563e-01f, 2.44692147e-01f, 1.65060058e-01f, 7.45977387e-02f, 2.52668988e-02f, -5.30458763e-02f, 9.45748836e-02f, -3.71483356e-01f, 6.70765713e-02f, 3.75752628e-01f,
  1.09832153e-01f, 1.27950922e-01f, -1.58128589e-02f, -1.02992110e-01f, 9.48212072e-02f, -1.75170183e-01f, 1.85740273e-02f, -1.50089219e-01f, -1.72797635e-01f, -1.80778787e-01f,
  -2.20957771e-01f, 6.22819085e-03f, -1.89276993e-01f, 4.33523953e-02f, -3.20267379e-01f, 3.99385542e-02f, -3.80272746e-01f, -2.00040609e-01f, -5.00788391e-01f, 6.22997463e-01f,
  1.60435095e-01f, 6.22122549e-02f, 2.57009506e-01f, 1.41104385e-01f, 1.51177526e-01f, 9.96291786e-02f, -2.09645286e-01f, 2.91767329e-01f, -2.25953415e-01f, -7.60539249e-02f,
  6.58582300e-02f, 6.32410571e-02f, 1.99220821e-01f, -1.82245970e-01f, 1.70962140e-01f, -2.04946250e-01f, 1.03777222e-01f, -3.95861939e-02f, -3.55867371e-02f, -2.14269608e-02f,
  -1.12349309e-01f, 1.97976250e-02f, -1.12863742e-02f, -3.14798713e-01f, 3.95097062e-02f, -1.42541781e-01f, 3.46992880e-01f, -1.48382902e-01f, -1.91202879e-01f, 4.36282814e-01f,
  -8.00240412e-02f, -2.92479862e-02f, -2.53053457e-01f, 1.03337914e-02f, -3.30195963e-01f, -3.20923179e-02f, -2.16775298e-01f, -1.50339112e-01f, -1.61470518e-01f, 1.36310875e-01f,
  -4.63726260e-02f, -1.27320915e-01f, 1.34055823e-01f, 4.00364310e-01f, -7.76527599e-02f, -2.59109735e-01f, 1.39553532e-01f, 1.59452364e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.23439267e-01f, 1.43945977e-01f, 2.93982178e-01f, -1.20615564e-01f, 1.39233708e-01f, 4.18230146e-02f, -5.66926412e-03f, -8.79267976e-02f, 2.00429365e-01f, 1.39905393e-01f,
  -1.28119141e-02f, -1.44597022e-02f, 2.55103827e-01f, 2.69652128e-01f, 5.25610805e-01f, -4.89577383e-01f, -3.95284981e-01f, -3.27608883e-01f, 1.68822687e-02f, -2.09448524e-02f,
  9.42189340e-03f, -2.25805372e-01f, 2.21658155e-01f, 1.24549262e-01f, 3.85059208e-01f, 3.98095608e-01f, -1.30253181e-01f, 2.76324034e-01f, -2.62373924e-01f, -1.67306051e-01f,
  3.78838032e-02f, 4.57676381e-01f, -4.88062277e-02f, -3.18236239e-02f, -3.99352647e-02f, -1.19123377e-01f, -1.51278183e-01f, -2.60682497e-02f, -1.16349876e-01f, 2.59996438e-03f,
  1.83040142e-01f, -4.74910252e-02f, -3.50901634e-02f, -3.93885262e-02f, 7.37738013e-02f, 1.51888251e-01f, -9.11589786e-02f, 1.54665738e-01f, 1.22477971e-01f, 5.10808565e-02f,
  3.07728592e-02f, 6.17625713e-02f, 1.79972038e-01f, 6.58192933e-02f, -1.18747670e-02f, 6.13675416e-02f, 8.53434056e-02f, -1.27336174e-01f, 1.35634899e-01f, 1.74105778e-01f,
  -5.73920421e-02f, -4.69904132e-02f, 1.31182298e-01f, 5.78346774e-02f, 9.50745419e-02f, -1.07594699e-01f, -3.32099497e-02f, 2.90416628e-01f, 8.06046203e-02f, 9.96193197e-03f,
  1.27369538e-01f, -1.91395525e-02f, -1.97224513e-01f, -2.29803711e-01f, -1.34175807e-01f, 8.26941282e-02f, 2.58621555e-02f, 7.80743062e-02f, -2.23386407e-01f, 2.59281278e-01f,
  -1.11004122e-01f, 3.43168378e-02f, 4.50956821e-01f, -1.52920008e-01f, 8.68568197e-02f, 9.01218131e-02f, -7.72302747e-02f, 2.91059427e-02f, -8.99540633e-02f, 2.52741247e-01f,
  -6.23021424e-02f, -2.19202802e-01f, 1.07986210e-02f, 2.03268111e-01f, -1.27289549e-01f, -1.17613897e-01f, 3.94586362e-02f, -2.75601476e-01f, 2.19862387e-01f, 3.22160184e-01f,
  3.91090512e-01f, -2.41304055e-01f, 1.29472092e-01f, 5.41503847e-01f, -1.33182898e-01f, -2.37727478e-01f, -6.14590883e-01f, -2.02943951e-01f, 1.03062369e-01f, -1.20880045e-01f,
  -3.87754619e-01f, 6.86502695e-01f, 1.09755851e-01f, 5.38944960e-01f, 8.57987642e-01f, -9.92846265e-02f, -1.08482810e-02f, 1.45954769e-02f, -1.03833165e-03f, -5.43790571e-02f,
  9.76025015e-02f, 1.40937090e-01f, -1.11280799e-01f, 2.65313387e-01f, -1.91156521e-01f, 1.53223261e-01f, 3.83261144e-02f, -4.49400432e-02f, 2.51043767e-01f, -5.27357683e-03f,
  2.83077091e-01f, -3.46875866e-03f, 5.17685413e-02f, 7.25515559e-02f, -4.34569083e-02f, 1.95720166e-01f, 2.54492640e-01f, -4.97019947e-01f, 2.39856169e-01f, -2.21008826e-02f,
  1.20531589e-01f, 2.49293864e-01f, -1.33264214e-01f, -1.48118675e-01f, -4.34130281e-01f, -8.60075131e-02f, -1.00690320e-01f, 6.87150359e-02f, -1.03272893e-01f, 2.69274544e-02f,
  -1.41092807e-01f, 2.51791198e-02f, 2.43580848e-01f, -4.38234657e-02f, -1.61132552e-02f, 3.73729140e-01f, -1.71928719e-01f, -2.79930145e-01f, 9.79370475e-02f, -4.93994057e-02f,
  1.36459455e-01f, 2.44783148e-01f, -1.83307782e-01f, 2.47385874e-01f, 2.57188559e-01f, -1.04317609e-02f, 1.89994290e-01f, 1.16290741e-01f, 2.70285338e-01f, -2.46310905e-01f,
  -1.80688757e-03f, -6.14768565e-01f, 3.22785676e-01f, 2.50166059e-01f, -1.14016458e-01f, -2.33926684e-01f, 7.96161219e-02f, 1.19111687e-01f, -1.98492676e-01f, 4.70238253e-02f,
  -3.67429823e-01f, 1.99968636e-01f, -2.35917434e-01f, -1.28119543e-01f, 1.72687456e-01f, -2.46069431e-01f, -1.00077681e-01f, 9.92183983e-01f, 1.73058704e-01f, -1.22822262e-01f,
  -7.03869611e-02f, -2.04335317e-01f, 1.45449311e-01f, -1.25271067e-01f, -6.57801554e-02f, 1.10255986e-01f, 2.19734125e-02f, -1.72410846e-01f, -9.25073177e-02f, -5.45573458e-02f,
  -2.43018940e-01f, -2.50981212e-01f, -2.68510878e-01f, 5.94414100e-02f, -1.12993240e-01f, 1.96821868e-01f, -8.74663591e-02f, 1.75501242e-01f, -1.50077209e-01f, 7.50875846e-02f,
  2.81654358e-01f, -1.14662647e-01f, -1.90511331e-01f, -1.12914383e-01f, -8.48256573e-02f, 5.63298203e-02f, -9.02983248e-02f, -1.64772868e-02f, 1.45727023e-01f, 2.41265818e-01f,
  -2.17169717e-01f, 8.23807940e-02f, -1.89047486e-01f, 2.71487888e-02f, 2.16993868e-01f, -1.53269783e-01f, -1.37913346e-01f, 3.18523869e-02f, 1.96785375e-01f, 1.00106597e-01f,
  2.29064062e-01f, 2.61332929e-01f, 9.23402086e-02f, 4.68690068e-01f, -2.04436436e-01f, -2.79022187e-01f, 2.91134059e-01f, 4.92163077e-02f, -3.55000682e-02f, -5.52076614e-03f,
  4.91597168e-02f, -9.12451223e-02f, 1.58394381e-01f, 1.00733668e-01f, -2.11181909e-01f, 1.18165419e-01f, 1.13437146e-01f, -2.00972948e-02f, 5.81547199e-03f, 2.51815408e-01f,
  -6.56519411e-03f, 3.21370512e-01f, -1.77408233e-01f, 1.88465565e-01f, 5.45348972e-02f, 6.31179512e-02f, 2.40738124e-01f, 8.60317051e-02f, -5.09029776e-02f, -1.85813755e-01f,
  7.96608478e-02f, 9.52529013e-02f, 1.23302117e-01f, 2.32332781e-01f, 1.06744468e-01f, -3.86034772e-02f, -1.16909117e-01f, -1.10485911e-01f, 1.32738382e-01f, 1.56714588e-01f,
  1.74729332e-01f, -1.26565740e-01f, 2.15752516e-02f, 9.63537097e-02f, 2.62396148e-04f, 5.66768609e-02f, -1.54474154e-01f, 2.09638193e-01f, 2.51827165e-02f, -1.55542821e-01f,
  -4.45346124e-02f, -1.19055070e-01f, 2.20277216e-02f, 1.51048541e-01f, -1.79718837e-01f, 2.65286446e-01f, -2.63842251e-02f, 8.28301832e-02f, 6.51234314e-02f, -2.34218344e-01f,
  -6.30265772e-02f, 5.17136231e-02f, -1.07619025e-01f, 2.59565301e-02f, -3.35364997e-01f, 2.05251753e-01f, -1.51724607e-01f, -1.25342518e-01f, -3.62464488e-01f, 1.91834401e-02f,
  -1.67538851e-01f, 1.52028590e-01f, 5.48172556e-02f, 3.19255412e-01f, -2.95064628e-01f, -7.20233023e-02f, 4.94997144e-01f, 1.24849603e-01f, 7.91838244e-02f, 3.29607486e-04f,
  -2.11673945e-01f, 1.26506656e-01f, 2.50426233e-01f, 1.43745407e-01f, 1.36510849e-01f, 5.35225689e-01f, -3.94860618e-02f, -9.61900055e-02f, 1.06693238e-01f, -1.52001843e-01f,
  1.60734326e-01f, 2.67971337e-01f, -3.79135087e-02f, 4.42072421e-01f, -4.59609628e-02f, 1.29161462e-01f, 2.86899358e-01f, -1.04233272e-01f, 3.20460260e-01f, -1.60281494e-01f,
  3.32250893e-01f, -8.54563862e-02f, -1.62550077e-01f, -2.53081769e-01f, -3.39963049e-01f, -3.63616087e-02f, 4.11336571e-01f, -1.80604383e-01f, -3.11227649e-01f, 3.54519248e-01f,
  3.58002573e-01f, -1.63657546e-01f, 2.63119042e-01f, 1.84776902e-01f, -5.12178568e-03f, -6.34820983e-02f, 1.63254857e-01f, 1.94900230e-01f, 2.51625836e-01f, -8.87296163e-04f,
  -4.90231477e-02f, -1.95657667e-02f, 2.27185771e-01f, -5.90415485e-02f, 7.02756783e-03f, 9.90284234e-03f, 2.09531605e-01f, 7.73553774e-02f, -3.82912233e-02f, 7.82313123e-02f,
  1.63574710e-01f, -6.35590032e-02f, -1.87209293e-01f, 5.84014170e-02f, 8.99868086e-02f, -9.59763974e-02f, 1.20717622e-01f, 9.15822759e-03f, 2.05009654e-02f, 1.59708321e-01f,
  -1.40768029e-02f, -1.43751472e-01f, 4.02131379e-02f, 1.77069187e-01f, 2.39399955e-01f, -1.24574780e-01f, 6.31201193e-02f, 1.11411139e-02f, -1.99575022e-01f, -2.97968209e-01f,
  -6.14198437e-03f, 5.60324565e-02f, -7.82832503e-02f, 1.27460629e-01f, 1.29021809e-01f, 1.50532797e-01f, 7.83845782e-03f, 3.77850145e-01f, 1.98250741e-01f, 1.84183210e-01f,
  1.29906476e-01f, -1.97829843e-01f, 2.33940378e-01f, 1.99028611e-01f, -5.80870397e-02f, -1.24938540e-01f, -1.90154329e-01f, -2.82053798e-01f, -3.20613563e-01f, 2.61602610e-01f,
  4.26526457e-01f, 7.44050890e-02f, -2.51970440e-01f, 1.23163670e-01f, 4.01416093e-01f, 7.73314834e-02f, 2.47608237e-02f, -4.91855629e-02f, 1.19694047e-01f, -9.49676335e-02f,
  -1.08549841e-01f, 2.39704385e-01f, 4.44403499e-01f, 3.19008440e-01f, 1.02743469e-01f, -1.74757734e-01f, -3.32879797e-02f, 3.21790725e-01f, 2.41879150e-01f, 2.36286551e-01f,
  3.43452632e-01f, 2.28666037e-01f, 3.11037809e-01f, 6.54650927e-02f, 2.17832312e-01f, -2.30831981e-01f, -8.49178582e-02f, 2.32107386e-01f, 3.80941749e-01f, -2.67765671e-01f,
  -1.21810623e-01f, -1.54963166e-01f, 4.16752726e-01f, 2.00802401e-01f, -2.45922014e-01f, -2.92309791e-01f, 2.28448678e-02f, 1.27861962e-01f, 8.84474348e-03f, -8.13405886e-02f,
  -1.92849070e-01f, 1.73405692e-01f, 7.24847689e-02f, 1.84546545e-01f, 5.75392060e-02f, 3.54696751e-01f, 7.47673959e-03f, -1.43603981e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.81757748e-01f, 5.13542332e-02f, 8.75688195e-02f, 2.17190981e-01f, 1.09582148e-01f, 1.85326517e-01f, -1.40758872e-01f, 1.09366842e-01f, 1.27622828e-01f, 2.68195421e-02f,
  3.96612108e-01f, 6.19741865e-02f, 4.37826872e-01f, 1.48861736e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  3.18453938e-01f, -1.03520699e-01f, 5.40681630e-02f, -4.67397630e-01f, 6.66921167e-03f, 7.00322017e-02f, -1.56905740e-01f, -1.85136318e-01f, 3.03855062e-01f, 3.40754360e-01f,
  -4.77751374e-01f, -3.51471454e-01f, 4.51446354e-01f, 4.67707247e-01f, 5.54804146e-01f, 6.28453612e-01f, 4.79896247e-01f, -1.03355616e-01f, -2.07300171e-01f, 7.95906708e-02f,
  -1.39526516e-01f, -6.71890438e-01f, -1.49655119e-01f, -3.71069461e-01f, -2.49857664e-01f, -4.28724289e-01f, -2.65934974e-01f, 9.49937254e-02f, 6.60811007e-01f, -2.70518661e-01f,
  4.72147584e-01f, -1.12002790e-01f, -4.32402015e-01f, 2.10105315e-01f, 9.84856039e-02f, -1.88865364e-01f, -1.75409645e-01f, -5.46710789e-01f, 3.29160780e-01f, 1.54031694e-01f,
  -1.42603904e-01f, -6.07727885e-01f, 1.38304636e-01f, 4.31255013e-01f, 1.54748829e-02f, 4.37849611e-01f, 5.66545010e-01f, 1.83921233e-01f, 6.44888077e-03f, 5.50996244e-01f,
  -5.11592329e-01f, 5.15899584e-02f, -2.22222015e-01f, -2.41040960e-01f, -3.28185111e-02f, 7.72861958e-01f, -2.15531200e-01f, 3.18332165e-02f, -2.43859440e-02f, -2.02612430e-01f,
  4.33096826e-01f, 6.62354976e-02f, 2.96948463e-01f, -1.15582463e-03f, -5.63958228e-01f, -4.10631076e-02f, -8.21042433e-02f, -5.35781831e-02f, -3.05364758e-01f, -4.46644694e-01f,
  -4.13064867e-01f, -2.12554738e-01f, -2.46038139e-01f, -6.09069690e-02f, -2.99786538e-01f, 3.82147163e-01f, 2.71564752e-01f, 6.52109385e-02f, 2.22599044e-01f, 3.20133239e-01f,
  2.59143621e-01f, 2.31391355e-01f, -4.35000174e-02f, 2.24767059e-01f, -1.89003363e-01f, 3.17304432e-01f, 3.22735578e-01f, 2.46163905e-01f, 1.35379106e-01f, -9.04743001e-03f,
  -1.21671818e-01f, 5.96849680e-01f, -3.18470150e-01f, 9.50889289e-02f, -2.08759025e-01f, -4.01233912e-01f, -1.47066221e-01f, -2.04936549e-01f, -1.23989411e-01f, 4.08475429e-01f,
  -4.98102069e-01f, -2.88350701e-01f, 3.93405527e-01f, -9.42941681e-02f, -2.16981634e-01f, 5.83404660e-01f, -4.71856415e-01f, -4.56648618e-01f, -8.85039806e-01f, -6.10945165e-01f,
  -6.07350111e-01f, 3.52513582e-01f, -5.18705010e-01f, -2.44072855e-01f, 3.14313993e-02f, -1.17205806e-01f, -8.25973898e-02f, -4.93152082e-01f, -2.68564016e-01f, -4.93968695e-01f,
  6.30286783e-02f, -1.31234229e-02f, -1.00027077e-01f, -4.03365552e-01f, 3.18834692e-01f, 7.60018229e-02f, 2.14473560e-01f, 4.81499553e-01f, 1.31264993e-03f, 4.09030080e-01f,
  -3.31733495e-01f, 5.63296497e-01f, 5.98432481e-01f, 8.04604813e-02f, 2.16918305e-01f, 7.17572451e-01f, -1.90246835e-01f, 6.32397354e-01f, -1.74315095e-01f, -3.04876536e-01f,
  7.46941745e-01f, -4.30993646e-01f, -6.78286254e-01f, 4.24510390e-02f, 4.56951797e-01f, -2.91238457e-01f, -3.19306761e-01f, 7.73982257e-02f, 2.07994372e-01f, 4.55270886e-01f,
  -3.80733758e-01f, -5.20810843e-01f, -1.80895090e-01f, 3.42714399e-01f, -1.38582438e-01f, -5.01535013e-02f, 2.27505639e-01f, 2.54822642e-01f, 3.40644270e-01f, 6.08995790e-04f,
  4.44841087e-01f, 2.24002436e-01f, -1.13260046e-01f, -6.54532909e-01f, -3.59153032e-01f, 5.00384212e-01f, 4.33881849e-01f, 4.87529427e-01f, 2.24238843e-01f, -2.57966876e-01f,
  6.45774901e-01f, -4.54777658e-01f, 8.98308232e-02f, 6.67811036e-01f, 4.97074425e-01f, -6.19038105e-01f, 5.49254060e-01f, -2.36369476e-01f, -3.95805597e-01f, 1.01807520e-01f,
  1.54593989e-01f, 3.16342682e-01f, -9.17531848e-02f, -3.83238941e-02f, -1.71713997e-02f, -3.48985404e-01f, -1.97074741e-01f, -3.90538931e-01f, 2.22589463e-01f, 7.30907917e-02f,
  2.47794166e-01f, 5.02715886e-01f, -7.13577688e-01f, -2.47274101e-01f, 4.65514302e-01f, 1.34784073e-01f, 1.94388732e-01f, 2.45996758e-01f, -1.35371298e-01f, 2.43858933e-01f,
  1.25810891e-01f, -5.51748514e-01f, 3.03848445e-01f, 2.06417106e-02f, 5.62917888e-01f, -9.37986597e-02f, -2.65278757e-01f, -3.25359732e-01f, 6.35335147e-01f, -1.71184480e-01f,
  -1.52920946e-01f, -8.76860172e-02f, 3.05554479e-01f, 5.54311991e-01f, 3.35488543e-02f, -4.62847799e-02f, 3.11102927e-01f, 1.58084393e-01f, -9.63494927e-02f, 3.90065610e-01f,
  -3.68783116e-01f, -1.79573387e-01f, -5.27267814e-01f, -1.80681258e-01f, -1.97051223e-02f, 5.86599782e-02f, 2.63308674e-01f, -3.35116446e-01f, -2.17236616e-02f, -1.75881639e-01f,
  -2.67232597e-01f, -5.05637646e-01f, 3.20002615e-01f, 4.52287704e-01f, 2.64818639e-01f, 1.88511416e-01f, -6.42893314e-01f, -1.65743008e-01f, -4.33742642e-01f, -5.52442253e-01f,
  -1.98339641e-01f, -3.15389305e-01f, 8.48856688e-01f, -1.77951664e-01f, -1.80230677e-01f, -3.88495445e-01f, -1.65585428e-01f, -3.03666264e-01f, -2.45975181e-01f, 1.83425575e-01f,
  5.22629060e-02f, -3.36972892e-01f, -3.15806895e-01f, 2.47744814e-01f, -4.48926717e-01f, -6.94443807e-02f, 9.02709458e-03f, -1.86634921e-02f, -3.08110893e-01f, 1.89275101e-01f,
  1.35428861e-01f, -1.70212477e-01f, 8.39503855e-02f, -5.74737430e-01f, -4.50958312e-01f, 1.66726275e-03f, -2.01299205e-01f, 5.83427906e-01f, -5.41493297e-01f, 2.95268387e-01f,
  4.63271111e-01f, 6.01655655e-02f, -4.73539531e-01f, 4.78673875e-01f, 5.52600324e-01f, 7.91583881e-02f, 6.29744157e-02f, -7.12679029e-01f, 5.88697135e-01f, 2.69981891e-01f,
  6.06354028e-02f, -8.61246884e-02f, -1.50946319e-01f, 1.57199055e-01f, 2.47850597e-01f, -2.41308525e-01f, -2.67343283e-01f, -3.57035726e-01f, 4.88394529e-01f, -3.25322121e-01f,
  -3.37876856e-01f, -4.70276207e-01f, -9.72286910e-02f, -3.27267721e-02f, -3.23802263e-01f, -4.54910338e-01f, -4.85812664e-01f, 9.94363576e-02f, 3.16194713e-01f, -5.03261387e-01f,
  -2.82183915e-01f, 4.64470953e-01f, -1.10306464e-01f, -2.47593075e-01f, 3.96675348e-01f, -2.89294302e-01f, -2.15252697e-01f, -6.29385933e-02f, 4.07873422e-01f, 7.37818718e-01f,
  -1.33244738e-01f, -5.82198083e-01f, 2.45816141e-01f, -2.49580637e-01f, -1.83608279e-01f, 3.50766093e-01f, -2.82424092e-01f, -7.59894252e-02f, -3.08596700e-01f, -2.16430724e-01f,
  -1.18460059e-02f, -1.99751873e-02f, 1.86255053e-01f, 3.70691538e-01f, -3.05242002e-01f, 4.06864971e-01f, -1.97102770e-01f, 1.42808288e-01f, 2.37828448e-01f, -5.16215205e-01f,
  -4.30185497e-01f, 1.63602591e-01f, -2.72067249e-01f, -7.96695232e-01f, 1.82729475e-02f, 5.14540613e-01f, -4.58417654e-01f, -6.07079864e-02f, -2.53000502e-02f, 3.61863226e-02f,
  -4.40261215e-02f, -9.98287126e-02f, -1.95654377e-01f, 5.68947136e-01f, -1.35756299e-01f, 5.13678253e-01f, 3.60383600e-01f, -4.44116183e-02f, -3.02638471e-01f, -9.21327546e-02f,
  4.19739299e-02f, 1.96482137e-01f, 5.72457254e-01f, -2.67706782e-01f, 5.05303085e-01f, 7.47068703e-01f, 5.27793646e-01f, 5.72606504e-01f, -3.48000854e-01f, -4.53565530e-02f,
  3.94141018e-01f, 1.74179301e-02f, 7.45504856e-01f, 3.81337821e-01f, 3.29202443e-01f, 1.89957157e-01f, 3.46477493e-04f, -6.67770267e-01f, -5.95269799e-01f, -1.03052154e-01f,
  -1.03431933e-01f, 3.22400033e-03f, 9.13615599e-02f, -6.39975294e-02f, 4.12391603e-01f, 1.14620693e-01f, -2.29718551e-01f, -1.54009387e-01f, 2.76208997e-01f, -3.93562794e-01f,
  -6.39019012e-02f, 2.16932863e-01f, -2.04120338e-01f, 4.55728143e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.65218085e-01f, -1.54872686e-01f, -1.59598291e-01f, 1.43330067e-01f, 2.16061994e-01f, 5.59021756e-02f, -2.98071742e-01f, 1.51506841e-01f, 9.81326252e-02f, -2.37670049e-01f,
  -5.48131429e-02f, 2.54555762e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    