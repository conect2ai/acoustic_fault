/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.32858315e-01f, 6.21557355e-01f, 1.15917455e-02f, 2.31634572e-01f, -2.47267410e-01f, 1.43067017e-01f, 2.10466422e-02f, 1.65381536e-01f, 9.68339760e-03f, 4.09283429e-01f,
  3.56477052e-02f, 4.64978255e-02f, 9.55840480e-03f, 3.34488243e-01f, -4.38683540e-01f, 5.89037463e-02f, 2.38834530e-01f, 1.60664290e-01f, -3.13802697e-02f, 1.11796521e-01f,
  -4.09400836e-02f, 6.64655715e-02f, 3.97099415e-03f, 1.45147089e-02f, 1.10921420e-01f, 7.25869983e-02f, -1.24045946e-01f, -1.38394445e-01f, 1.44658282e-01f, -6.54008910e-02f,
  7.65251443e-02f, 1.01179287e-01f, 9.27270763e-03f, -2.07893420e-02f, 3.30613926e-02f, 2.23674476e-02f, 4.64413054e-02f, -1.13269091e-01f, -5.35673043e-03f, 6.27331343e-03f,
  -2.10860930e-03f, -1.07036540e-02f, 2.03157403e-03f, -6.90523610e-02f, 3.44850831e-02f, -2.65454557e-02f, 9.48564336e-03f, 3.89349647e-02f, 7.64469579e-02f, -1.88138559e-02f,
  3.86877470e-02f, 6.41004667e-02f, 1.62137914e-02f, 7.25640208e-02f, -5.08680977e-02f, 1.42184924e-02f, 2.40914840e-02f, 7.98248593e-03f, 6.23495653e-02f, 3.07688266e-02f,
  6.45535951e-03f, 6.90501183e-03f, 3.73340584e-02f, -1.91285461e-02f, 3.69543545e-02f, -1.38103375e-02f, 4.20677621e-04f, 2.23021616e-05f, -5.42453825e-02f, 1.25707407e-02f,
  -1.86306518e-02f, 1.35064758e-02f, -3.14223059e-02f, 2.39472445e-02f, 2.19443981e-02f, -6.33217255e-03f, -3.84129435e-02f, 2.40048468e-02f, 1.01171369e-02f, -3.01406579e-03f,
  -2.92956475e-02f, -2.53124931e-03f, 3.30355428e-02f, -3.43465731e-02f, 1.37571283e-02f, -2.48256121e-02f, 2.79929042e-02f, 1.97256431e-02f, -6.26456132e-03f, -3.73942405e-02f,
  8.96766484e-02f, 1.82383463e-01f, -2.17285976e-02f, -1.26804493e-03f, 2.42649243e-04f, -2.89096180e-02f, -6.28881827e-02f, 4.47627567e-02f, -2.70653726e-03f, -2.16713939e-02f,
  3.22303213e-02f, -9.52554215e-03f, 2.86436155e-02f, 1.67111997e-02f, -6.08732253e-02f, 4.59805764e-02f, 3.21137756e-02f, -5.23150899e-02f, -4.23016660e-02f, 2.60332040e-02f,
  -1.57571118e-02f, -7.15637282e-02f, 1.92238076e-03f, 1.64589286e-02f, 2.11493876e-02f, -2.51953304e-02f, -7.47975335e-03f, -6.88057346e-03f, -6.56223390e-03f, 1.15843350e-02f,
  -2.70982146e-01f, 1.03229612e-01f, -4.43987846e-01f, -5.02174832e-02f, -1.32216692e-01f, -1.59130156e-01f, -2.19254140e-02f, -1.67809613e-02f, 2.71519404e-02f, 3.68210763e-01f,
  1.92450553e-01f, -1.47338182e-01f, 2.60105729e-01f, 2.17219703e-02f, -1.48328200e-01f, 1.74822614e-01f, 3.56084816e-02f, 1.02061324e-01f, -4.40090969e-02f, 8.00022855e-03f,
  -7.25097284e-02f, 2.10318878e-01f, -1.73508242e-01f, 7.38839954e-02f, -1.40100881e-01f, -6.53403029e-02f, 2.19261304e-01f, -2.56164353e-02f, -3.54208872e-02f, -1.17734922e-02f,
  -1.32717788e-01f, 7.42590651e-02f, -6.84049204e-02f, -6.18977249e-02f, 2.71932371e-02f, 1.91177893e-02f, -2.47487463e-02f, -3.06581166e-02f, -7.98687562e-02f, -1.84510723e-02f,
  -1.45504717e-02f, -1.07081532e-01f, -6.82150899e-03f, 7.32478220e-03f, -3.22360843e-02f, -9.69488397e-02f, -1.07925981e-01f, -4.82776575e-02f, -1.08644433e-01f, -8.89516696e-02f,
  -1.72777567e-02f, -1.05952680e-01f, -4.95983623e-02f, 3.35216112e-02f, -6.32994995e-02f, -1.56713743e-02f, -7.28766844e-02f, 1.74035579e-02f, -4.26357379e-03f, 5.07709617e-03f,
  1.03940092e-01f, 6.59500360e-02f, -1.65187977e-02f, -1.51250595e-02f, -2.77015399e-02f, -2.47441642e-02f, -1.83486324e-02f, 2.35725511e-02f, -3.25362943e-02f, 2.25984361e-02f,
  -5.96661195e-02f, -7.64816254e-03f, -1.16540650e-02f, -5.79441153e-03f, 8.47453810e-03f, 3.59113375e-03f, -4.21532132e-02f, 2.80236769e-02f, 1.34628145e-02f, -2.58486550e-02f,
  1.43902085e-03f, -1.46722207e-02f, 5.03962785e-02f, -3.61666200e-04f, 2.94755977e-02f, -1.63340196e-02f, 8.69373325e-03f, -5.77730462e-02f, 2.44648010e-03f, -1.46572283e-02f,
  2.32007414e-01f, 3.77072245e-01f, 1.00945994e-01f, -4.16125618e-02f, 4.67640609e-02f, 4.51194569e-02f, 2.57913140e-03f, 7.32045388e-04f, 6.82584196e-02f, 1.09073473e-02f,
  2.47770380e-02f, 6.75756764e-03f, 1.64996274e-02f, -3.14979516e-02f, 1.76733301e-03f, 6.96622729e-02f, 7.24957809e-02f, 4.26755659e-02f, 4.56102118e-02f, 2.75723413e-02f,
  -5.65583212e-03f, 6.48371279e-02f, -3.40148769e-02f, -4.23038900e-02f, 5.01421466e-02f, 2.56465469e-03f, 5.39002344e-02f, -7.73856649e-03f, 2.75981822e-03f, 1.70521438e-02f,
  5.13012886e-01f, -1.68949008e-01f, 1.76999688e-01f, -3.80438007e-02f, 3.57033350e-02f, -2.38710418e-01f, -6.64324611e-02f, -9.85147357e-02f, 1.42689526e-01f, -1.59351215e-01f,
  -2.41862178e-01f, 2.00253613e-02f, -1.49386272e-01f, -3.51993322e-01f, -1.67729482e-01f, -2.56736577e-01f, -5.88497967e-02f, -2.83517689e-02f, -3.05170263e-03f, 3.29078957e-02f,
  6.63267896e-02f, -3.35516274e-01f, -1.54566407e-01f, -1.46466538e-01f, -6.82820231e-02f, 1.78865746e-01f, -3.78452055e-02f, -4.79953457e-03f, -1.03081875e-01f, -1.20003030e-01f,
  5.73694594e-02f, 1.13567747e-02f, 3.35112661e-02f, 7.53960460e-02f, 1.04568042e-01f, 1.15986183e-01f, 6.29019812e-02f, -1.65164378e-02f, 5.26212677e-02f, -1.29820071e-02f,
  1.30836004e-02f, -2.06658896e-02f, -4.79770564e-02f, 6.70372555e-03f, 6.37734681e-02f, 3.36716399e-02f, -5.50815873e-02f, -3.41133284e-03f, 3.10786115e-03f, -5.71756810e-02f,
  -2.96860412e-02f, -4.72400747e-02f, 5.40440844e-04f, -3.28625590e-02f, 4.08275165e-02f, -1.49273332e-02f, -4.58030216e-03f, 1.21670691e-02f, -1.51563529e-02f, -2.61780135e-02f,
  -1.40684275e-02f, 7.74216205e-02f, -1.77757479e-02f, 1.39253428e-02f, -1.06421430e-02f, -1.59739498e-02f, 1.97887775e-02f, 1.47785805e-02f, 6.97337016e-02f, 2.04429124e-03f,
  -4.67899861e-03f, 6.08047610e-03f, -1.24102496e-02f, 3.80278714e-02f, 4.78952937e-02f, 1.64016464e-03f, 6.21219128e-02f, -3.23594138e-02f, 3.81445251e-02f, -1.12863975e-02f,
  8.54417775e-03f, -2.82203760e-02f, -2.17993148e-02f, 1.93872005e-02f, -5.31587787e-02f, -1.17857261e-02f, -2.77890787e-02f, -2.94271335e-02f, 2.23261472e-02f, 3.56560503e-03f,
  1.23329237e-01f, 1.05230868e-01f, -3.90352197e-02f, -8.35801363e-02f, 3.20585892e-02f, -8.82445276e-02f, -2.58851461e-02f, -1.59736024e-04f, -2.10683011e-02f, 4.19421121e-02f,
  5.45759276e-02f, 7.18537346e-02f, 3.84874083e-02f, -4.00039256e-02f, -5.60316183e-02f, -5.32695614e-02f, 1.59132145e-02f, 8.54849368e-02f, -1.95460636e-02f, 7.91777950e-03f,
  4.00796439e-03f, -1.12680905e-02f, 2.76101343e-02f, 2.78534759e-02f, -3.83772962e-02f, -6.70521799e-03f, 8.25947449e-02f, 3.43972519e-02f, -3.24129723e-02f, 1.12485914e-02f,
  2.90893018e-01f, -2.90491909e-01f, -1.47461399e-01f, 1.28021136e-01f, 5.12164878e-03f, 3.69906455e-01f, 4.54367936e-01f, -9.36618373e-02f, 8.77090842e-02f, -1.11201620e-02f,
  1.34512901e-01f, -4.93485518e-02f, 6.56511486e-02f, 2.38983676e-01f, 4.23901588e-01f, 1.75860658e-01f, 3.26076508e-01f, 1.17887504e-01f, 1.59655772e-02f, -3.06004547e-02f,
  4.55482341e-02f, 2.12358847e-01f, 7.42371231e-02f, -1.99779212e-01f, 4.29114848e-02f, -2.03114256e-01f, -6.06672950e-02f, -1.32271767e-01f, -3.79295871e-02f, 5.87795675e-02f,
  9.33772400e-02f, -1.03311457e-01f, -7.85972774e-02f, -1.19778030e-02f, -1.71095156e-03f, -1.78662874e-02f, 1.94608998e-02f, 6.74142390e-02f, -6.01746957e-04f, 4.81118448e-03f,
  3.41286585e-02f, -3.57720070e-02f, 3.22068296e-02f, 2.90046185e-02f, -2.78628487e-02f, -8.55502188e-02f, -8.43181387e-02f, -3.15085165e-02f, -2.94159539e-02f, 2.83886958e-03f,
  -3.06988455e-04f, 9.09919851e-03f, -1.33325369e-03f, 1.82776060e-02f, -2.19682343e-02f, 2.26243818e-03f, 5.08571118e-02f, -6.80097146e-03f, -1.47733912e-02f, 5.15778549e-03f,
  -2.56985817e-02f, 6.20501442e-03f, 4.18830775e-02f, -3.60823944e-02f, 6.60960376e-03f, -2.50884853e-02f, 2.92466488e-02f, -7.88743887e-03f, -3.15387174e-02f, 1.91142492e-03f,
  3.13407853e-02f, 6.60321396e-03f, 1.09170917e-02f, 2.24705450e-02f, 3.05485614e-02f, 3.74692190e-03f, -6.67816587e-03f, -1.79929137e-02f, 3.97614576e-02f, 4.44532223e-02f,
  -1.90201290e-02f, 3.85233834e-02f, -1.85238812e-02f, 1.69615038e-02f, 1.73639935e-02f, 2.23529264e-02f, -1.05505213e-02f, -3.87424007e-02f, 1.17012262e-02f, 4.41803038e-02f,
  3.35282385e-02f, -1.28999367e-01f, 3.73478304e-03f, 3.44688771e-03f, -2.41949148e-02f, 3.85119929e-04f, 3.09770685e-02f, -3.33407447e-02f, 1.17916148e-02f, 1.72278583e-02f,
  -4.05022576e-02f, 1.95440743e-02f, 6.45649154e-03f, -5.26919290e-02f, 3.22953127e-02f, 4.89128232e-02f, 4.45283800e-02f, 1.70486737e-02f, 2.95532625e-02f, -4.85094637e-02f,
  -3.04902829e-02f, 2.66846642e-02f, 4.54515815e-02f, -4.58581634e-02f, 5.66007532e-02f, 9.19678435e-03f, -2.75710709e-02f, -2.65186466e-02f, 4.45429701e-03f, 1.18987085e-02f,
  -5.07127762e-01f, 3.66204947e-01f, -1.75603449e-01f, -2.09009439e-01f, 4.33385037e-02f, 2.59841502e-01f, -9.87940654e-02f, 8.96010995e-02f, -1.25985742e-01f, 2.79849321e-01f,
  -3.54043767e-02f, 5.21833710e-02f, -1.51221663e-01f, 2.54658043e-01f, -4.17852879e-01f, -7.95914382e-02f, 1.26937225e-01f, 1.02298290e-01f, -6.18887789e-05f, -2.06699315e-02f,
  -9.27477032e-02f, 3.51128317e-02f, -1.42190918e-01f, 1.92094281e-01f, -1.08144823e-02f, -1.28510948e-02f, -1.61561638e-01f, -8.65521729e-02f, 1.54024661e-01f, 2.05562487e-02f,
  -8.45456496e-03f, -2.35086054e-01f, 1.99368149e-02f, 1.02492198e-02f, -6.03494160e-02f, -1.96895897e-02f, -1.61975939e-02f, -4.15732116e-02f, -6.01516105e-02f, 1.15054725e-02f,
  1.07581931e-04f, 6.20265417e-02f, 7.31748268e-02f, -5.59553970e-03f, 5.30950911e-02f, 4.08213511e-02f, 8.77607763e-02f, 4.19545993e-02f, 4.55232970e-02f, -3.28805968e-02f,
  4.83683273e-02f, 4.04325463e-02f, 3.09385750e-02f, 5.29178567e-02f, -5.89253157e-02f, 5.45132011e-02f, -7.58674834e-03f, -5.87533899e-02f, 8.86055157e-02f, 2.20208783e-02f,
  1.61503255e-02f, -9.44772288e-02f, -2.78437836e-03f, -3.88297960e-02f, 6.67343196e-03f, -5.41475825e-02f, 3.31977196e-02f, -4.05451283e-02f, -5.18055595e-02f, -2.16330420e-02f,
  -2.55765859e-02f, -1.00979279e-03f, -7.40327081e-03f, -4.22886238e-02f, -7.14652194e-03f, -2.31679920e-02f, -1.78701356e-02f, -8.83681979e-03f, 3.23947109e-02f, -2.13701837e-02f,
  -4.49529104e-02f, -7.33137422e-04f, -1.40459407e-02f, 6.23693084e-03f, -1.68676965e-03f, -5.55529296e-02f, -2.22783983e-02f, 2.49182582e-02f, -3.52663398e-02f, -7.08234385e-02f,
  7.49203637e-02f, -2.49256447e-01f, 4.56784219e-02f, 6.16031047e-03f, 6.37386069e-02f, 7.32217208e-02f, 1.67013332e-02f, 4.76537421e-02f, 4.64015268e-02f, -3.71045060e-02f,
  1.51673192e-02f, -6.01805635e-02f, -3.29296105e-02f, 3.70711982e-02f, 2.20689978e-02f, 8.31987709e-03f, -7.72316754e-02f, -3.72117609e-02f, -4.16877773e-03f, 4.62844856e-02f,
  -3.97043154e-02f, -3.58381346e-02f, -3.70217557e-03f, -1.72578376e-02f, 5.50579205e-02f, -3.53712253e-02f, -1.63403731e-02f, 6.79933503e-02f, -2.69768517e-02f, 4.25041914e-02f,
  9.59547907e-02f, 1.75890878e-01f, 1.67679414e-01f, -1.28381953e-01f, -1.10811345e-01f, -4.29846570e-02f, 2.54813075e-01f, -1.35686234e-01f, 1.43613979e-01f, 1.41530275e-01f,
  -8.24681073e-02f, 3.06077391e-01f, 2.12014019e-01f, -5.00388779e-02f, -7.07880780e-02f, 1.00691125e-01f, -2.74619401e-01f, -6.07020445e-02f, -7.94014633e-02f, -2.21855670e-01f,
  -1.77893162e-01f, -2.33616307e-01f, -8.37071389e-02f, -3.03223282e-01f, -8.97539780e-02f, -5.08765541e-02f, -1.08190417e-01f, 5.23023680e-02f, -1.73443303e-01f, 1.97768342e-02f,
  -1.91590898e-02f, 5.91407306e-02f, 4.94392850e-02f, 2.15166509e-02f, -1.68404564e-01f, -4.41341437e-02f, -4.33801897e-02f, 1.41612858e-01f, -3.62581722e-02f, 1.43646374e-02f,
  1.06110446e-01f, -4.01864527e-03f, -5.53797223e-02f, 3.49826254e-02f, 6.01423299e-03f, 1.25282491e-02f, -2.97180582e-02f, -4.71383706e-02f, 3.00568845e-02f, 5.95933571e-03f,
  2.22899634e-02f, -1.42713764e-03f, -4.84189279e-02f, -4.88390252e-02f, 1.63600706e-02f, 1.56155434e-02f, 4.62567322e-02f, 4.67625186e-02f, -2.32736114e-02f, -4.42838706e-02f,
  -8.75476096e-03f, -5.48463985e-02f, 3.55361663e-02f, -2.07053609e-02f, 1.87101308e-02f, -5.28142676e-02f, 2.39727814e-02f, -1.27162281e-02f, 2.68076025e-02f, 3.41656804e-02f,
  -5.62146604e-02f, 2.14491859e-02f, -1.28012029e-02f, -3.09579028e-03f, -1.87491756e-02f, 8.42536986e-03f, 6.18863292e-03f, 5.24379313e-03f, -2.19397936e-02f, -5.66464588e-02f,
  -2.69517163e-03f, -2.71346625e-02f, 9.47260484e-03f, -3.74438204e-02f, -2.23569549e-03f, 4.11865152e-02f, -8.78867414e-03f, 1.02085024e-02f, -1.84528921e-02f, -2.75990199e-02f,
  -6.96307719e-02f, -2.01157302e-01f, -1.97682921e-02f, 3.03435642e-02f, 1.07565587e-02f, 3.39854099e-02f, -5.20688407e-02f, -7.89045915e-02f, -2.67182291e-02f, -2.26016995e-02f,
  -9.56217796e-02f, 1.61717962e-02f, -2.82659326e-02f, 3.08512012e-03f, -1.82676148e-02f, 9.69744846e-03f, -1.66448113e-02f, -4.02351134e-02f, -7.28726909e-02f, -4.88759875e-02f,
  4.82596643e-02f, -2.66459789e-02f, 4.24069352e-02f, -9.31670517e-02f, -9.96109173e-02f, -7.61100836e-03f, -4.78429087e-02f, 1.83874704e-02f, -4.55902331e-03f, 4.73091379e-02f,
  2.36859605e-01f, -8.66200328e-02f, -3.90369049e-03f, 2.91079491e-01f, -8.30100104e-02f, -5.04036061e-03f, 3.49154919e-02f, 6.83132410e-02f, -1.45796478e-01f, -4.27832529e-02f,
  7.25353509e-02f, -7.33803883e-02f, -1.97665364e-01f, 2.78164446e-01f, 1.86194420e-01f, -1.66194543e-01f, 2.87440866e-01f, 1.01869695e-01f, -1.06553204e-01f, 8.59373286e-02f,
  9.95165482e-02f, 1.43465623e-01f, 1.45968765e-01f, -1.22691020e-02f, 7.38896653e-02f, 2.65577938e-02f, 2.70121485e-01f, -1.59446254e-01f, 2.77384996e-01f, 1.59237832e-02f,
  -3.53646167e-02f, -1.52786687e-01f, 3.82875353e-02f, -2.03588139e-02f, 3.68287005e-02f, 4.18842174e-02f, 5.12505621e-02f, -4.10688519e-02f, -4.64311466e-02f, -2.41204668e-02f,
  -4.08926345e-02f, -2.05979105e-02f, -2.38403515e-03f, -5.02093062e-02f, 3.69720324e-03f, 5.22912364e-04f, -7.01672025e-03f, -1.73434392e-02f, -4.20167893e-02f, -6.80586845e-02f,
  -2.85790637e-02f, 3.65897939e-02f, 5.38787730e-02f, 5.23449928e-02f, 2.59628519e-02f, -2.60580350e-02f, 1.73912547e-03f, -2.29980443e-02f, -1.36834290e-03f, 1.11910393e-02f,
  6.36763200e-02f, -2.17158422e-02f, -1.89546254e-02f, -5.32416627e-02f, 1.17981695e-02f, 1.58658940e-02f, 3.81546393e-02f, 1.19104912e-03f, 1.51301278e-02f, 1.79170221e-02f,
  1.91959646e-02f, 1.64485611e-02f, 3.25949602e-02f, 1.22181624e-02f, 8.34852904e-02f, 2.12936625e-02f, 3.75816710e-02f, -4.76664864e-02f, 5.50956056e-02f, 3.61218862e-02f,
  -2.78362595e-02f, 3.87301296e-02f, -1.01489890e-02f, 5.42855449e-02f, -6.35346351e-03f, -1.22293923e-02f, 5.15222065e-02f, 4.28727042e-04f, -1.60525292e-02f, 3.61308940e-02f,
  4.13697287e-02f, 3.75500172e-02f, -8.23993832e-02f, -5.24683297e-02f, -2.04029884e-02f, 2.05181539e-02f, 3.66463885e-02f, 4.63055894e-02f, 5.17933294e-02f, 2.58884262e-02f,
  4.66104373e-02f, 6.83839992e-03f, 1.86013486e-02f, 4.11679745e-02f, 2.35783663e-02f, 1.15682529e-02f, 3.36008891e-02f, 8.67038146e-02f, 1.01349406e-01f, 4.67232987e-02f,
  2.75890436e-03f, -4.03519943e-02f, -2.02468038e-02f, -8.08542687e-03f, 5.70608675e-02f, 5.11209741e-02f, -1.18880998e-02f, -2.22624950e-02f, 5.81656490e-03f, 5.62551245e-03f,
  -6.64683819e-01f, -1.48620427e-01f, -1.13325544e-01f, -2.44725540e-01f, 3.22933346e-02f, -2.16469288e-01f, -4.58523035e-01f, 9.48099792e-02f, -7.97316581e-02f, -2.59285257e-03f,
  -5.95298447e-02f, -2.62690008e-01f, -1.66157261e-02f, -2.00863034e-01f, -3.52324963e-01f, -5.03793620e-02f, -3.38638455e-01f, -2.13853836e-01f, 1.14921711e-01f, -1.73018679e-01f,
  -8.60794932e-02f, -1.07473262e-01f, -2.23313365e-02f, 2.59648293e-01f, -1.18334152e-01f, 1.69730753e-01f, 9.24720690e-02f, 1.61335841e-01f, 2.98228208e-02f, -1.37603628e-02f,
  -1.37966201e-01f, 2.21832208e-02f, 5.53699210e-02f, 5.20612746e-02f, -8.29631537e-02f, -4.11751457e-02f, -5.77477105e-02f, 7.75310993e-02f, 1.69790555e-02f, -1.12301372e-02f,
  -5.54640219e-02f, -3.12182191e-03f, 3.77092771e-02f, 1.14014283e-01f, 1.23824570e-02f, 8.31137449e-02f, 4.04015891e-02f, -1.25755742e-02f, 2.76375264e-02f, 4.92776930e-03f,
  4.87538278e-02f, 5.41861216e-03f, -2.81274039e-02f, -2.40406655e-02f, 5.47788281e-04f, -1.03435488e-02f, -3.27191502e-02f, -2.98258122e-02f, -5.20471158e-03f, 4.79769846e-03f,
  4.84277159e-02f, -1.24146761e-02f, -4.58303886e-03f, 5.17526306e-02f, -2.83758100e-02f, 7.37020671e-02f, -3.14097963e-02f, 2.64832582e-02f, -2.15781340e-03f, -6.00291081e-02f,
  -2.38625053e-02f, -3.65066901e-02f, 2.85436325e-02f, -2.18626000e-02f, -3.92875858e-02f, -1.30339293e-03f, -5.01699299e-02f, -1.55659765e-02f, -9.92027950e-03f, 3.06279194e-02f,
  3.32786329e-02f, -5.25491796e-02f, -2.27740128e-02f, 1.86559986e-02f, 4.00293730e-02f, 1.07145235e-02f, 2.30738949e-02f, 1.65314432e-02f, 1.56389717e-02f, -3.34612913e-02f,
  -3.21478903e-01f, -2.16799736e-01f, 3.43331918e-02f, 1.16587952e-02f, 4.17300239e-02f, 5.05473763e-02f, -4.24812920e-03f, -2.51652393e-02f, -2.38505453e-02f, -2.45736726e-02f,
  -8.00392299e-04f, -1.83809586e-02f, -6.26993999e-02f, -5.55784851e-02f, -3.31043191e-02f, -5.23467921e-02f, -7.47403800e-02f, 4.34716651e-03f, -8.02400559e-02f, -2.99193747e-02f,
  -4.44716588e-03f, 2.02297093e-03f, 4.71670218e-02f, -3.86592792e-03f, -1.37446746e-02f, -2.97217071e-03f, -2.80420501e-02f, 8.33122879e-02f, -1.38130144e-03f, -6.33049756e-02f,
  3.19958150e-01f, -6.13421760e-02f, 2.31787294e-01f, -1.14733882e-01f, 1.23589352e-01f, 1.02754617e-02f, 1.60992280e-01f, 4.30895351e-02f, 2.72747893e-02f, 1.47386342e-02f,
  -2.59454325e-02f, 1.68799877e-01f, 3.13815251e-02f, -2.47661799e-01f, -2.52529174e-01f, -3.21051329e-01f, -1.04453869e-01f, 3.71946692e-02f, -5.10849580e-02f, 7.78201446e-02f,
  -7.04331398e-02f, -4.19695050e-01f, -1.20055154e-01f, -1.56690195e-01f, 1.01982176e-01f, 3.49009484e-02f, 3.03143635e-02f, 2.53394246e-02f, -2.73243729e-02f, -9.10874307e-02f,
  -1.15193069e-01f, -7.54893944e-02f, 1.63092971e-01f, 4.14590724e-02f, 6.39677122e-02f, 1.39795959e-01f, 8.82045552e-02f, -1.95536651e-02f, -2.68441774e-02f, 3.91207337e-02f,
  9.23271775e-02f, -2.78682485e-02f, -6.76094070e-02f, -3.84590477e-02f, 6.99750930e-02f, 4.20854017e-02f, -2.47727018e-02f, 3.00712362e-02f, 2.37196777e-02f, 6.73286319e-02f,
  1.29748015e-02f, 3.46789509e-02f, 5.24131507e-02f, -3.92823778e-02f, -2.77726483e-02f, 1.09392283e-02f, -2.26806458e-02f, 6.41066656e-02f, 9.30498764e-02f, 1.31457234e-02f,
  -2.95486711e-02f, 2.31181253e-02f, -2.07238775e-02f, -1.92042887e-02f, -2.35151052e-02f, 2.66607236e-02f, -2.15991167e-03f, 8.89563933e-03f, 2.74166334e-02f, -5.47630526e-02f,
  -1.47429500e-02f, 2.65065525e-02f, -7.95733277e-03f, -3.96581925e-03f, -1.04118204e-02f, -2.84078084e-02f, -3.65041606e-02f, -2.75334213e-02f, 4.99994941e-02f, -5.41972741e-02f,
  -6.08673170e-02f, -2.86591146e-03f, -1.27698872e-02f, -4.31054831e-03f, -3.54265533e-02f, 2.23363261e-03f, 7.32444972e-03f, 5.98602276e-03f, -2.91110519e-02f, 6.06167782e-03f,
  -2.71635186e-02f, -4.96402904e-02f, -9.18668360e-02f, -7.01640993e-02f, -4.69748005e-02f, -9.89118125e-03f, -2.22472791e-02f, -3.32949646e-02f, -3.20609622e-02f, -1.97452940e-02f,
  3.27514037e-02f, -9.27742978e-04f, 7.17295781e-02f, -3.91516462e-03f, -6.37936667e-02f, -2.28139702e-02f, 3.09840702e-02f, 1.45731494e-03f, 1.49815520e-02f, 2.19476596e-02f,
  6.86637405e-03f, 5.12104295e-03f, 2.16300339e-02f, 3.41444314e-02f, 6.47100583e-02f, 4.08288315e-02f, 5.95706180e-02f, 1.81336906e-02f, -4.97967973e-02f, -1.53562902e-02f,
  -2.55814791e-01f, -3.10887098e-01f, 1.07760064e-01f, -2.36536130e-01f, -1.39715433e-01f, -3.63705158e-02f, 9.04777348e-02f, -2.20317692e-01f, -1.45483553e-01f, -1.79374710e-01f,
  -1.15322538e-01f, -5.60204312e-02f, 1.29348829e-01f, -7.33832791e-02f, 2.46060058e-01f, 1.88202411e-01f, -1.47036791e-01f, -8.45602304e-02f, -1.59625262e-02f, -2.65132457e-01f,
  2.13797800e-02f, -1.60081416e-01f, 1.75705865e-01f, -1.36383638e-01f, -1.54044017e-01f, -1.61066070e-01f, -1.05968677e-01f, 4.55457643e-02f, -9.07306299e-02f, 1.21926770e-01f,
  -4.99711446e-02f, 4.96541057e-03f, -2.89152116e-02f, 5.10995947e-02f, -3.91356200e-02f, -1.16807297e-02f, 1.83935780e-02f, 9.83046442e-02f, 4.51528020e-02f, 1.01167141e-02f,
  -1.78874470e-02f, -2.21145852e-03f, 3.66961621e-02f, 3.42823751e-02f, -6.21185377e-02f, -2.91072857e-02f, 1.73621550e-02f, 1.23582268e-02f, 7.78805511e-03f, 5.94887547e-02f,
  3.61273475e-02f, 3.45627107e-02f, -4.36500907e-02f, 5.66921802e-03f, 4.22800034e-02f, -3.94550944e-03f, 2.76991390e-02f, 5.40936552e-02f, -5.66837899e-02f, -4.43670228e-02f,
  9.53542888e-02f, -2.82209031e-02f, -3.22692730e-02f, 2.96031199e-02f, -1.41996685e-02f, 3.61865722e-02f, -2.96974424e-02f, 1.60451196e-02f, 2.25757267e-02f, -3.33689936e-02f,
  -2.88217086e-02f, -1.57883614e-02f, -3.72200049e-02f, 1.09457513e-02f, -5.87000549e-02f, -1.17631648e-02f, -5.58859222e-02f, -1.07844844e-02f, -1.21417027e-02f, 4.40154485e-02f,
  8.24603997e-03f, 7.82758277e-03f, -4.67924662e-02f, 3.84723544e-02f, -6.06796890e-03f, 5.52896895e-02f, -5.98586164e-02f, -7.09849596e-03f, -1.13432538e-02f, 2.38770898e-03f,
  -2.94867098e-01f, -3.79853815e-01f, -4.93195057e-02f, -4.76732738e-02f, -5.82203306e-02f, -4.66689318e-02f, -2.94684973e-02f, -2.17806697e-02f, -6.03480600e-02f, -5.57094291e-02f,
  -5.81837855e-02f, -2.86743511e-02f, -5.17594889e-02f, -6.23699687e-02f, 1.04660923e-02f, -2.60874964e-02f, -2.00965852e-02f, -7.56917149e-02f, -1.14727922e-01f, 2.11391062e-03f,
  -6.60809651e-02f, 6.99921278e-03f, 2.21204758e-02f, -2.21828334e-02f, 6.25308743e-03f, -1.55539224e-02f, -4.84912656e-02f, 4.71011810e-02f, 5.20026833e-02f, -1.03756106e-02f,
  -5.21545149e-02f, -1.52841985e-01f, -2.32087344e-01f, -1.75545156e-01f, 3.19683343e-01f, 1.39348537e-01f, -1.06551066e-01f, 1.22732930e-01f, -3.80874455e-01f, -5.26477098e-02f,
  1.73786625e-01f, -9.30982679e-02f, -1.44418731e-01f, -1.73386857e-02f, -1.40259057e-01f, -3.23699653e-01f, -9.49020311e-02f, -4.53190953e-02f, -1.14167415e-01f, 1.41544016e-02f,
  -1.39060378e-01f, 1.52273268e-01f, -1.37476489e-01f, 2.42016673e-01f, 1.94696829e-01f, 4.79263179e-02f, 1.91815719e-01f, 1.44536227e-01f, 2.14825362e-01f, 9.10733119e-02f,
  3.27356569e-02f, -1.69354724e-03f, 2.35945284e-02f, -9.01290923e-02f, 4.18244973e-02f, 1.05694763e-01f, 4.99307029e-02f, 8.87168124e-02f, 5.32016978e-02f, -4.96998578e-02f,
  7.97012169e-03f, 4.33380231e-02f, -3.31566744e-02f, 5.56981098e-03f, 4.04550396e-02f, -2.26751063e-02f, 8.04792903e-03f, 1.30762458e-02f, -2.05203798e-02f, 6.91388324e-02f,
  -3.02271955e-02f, 1.43647296e-02f, -2.15814705e-03f, -3.90864983e-02f, 1.10018039e-02f, -2.11728141e-02f, -3.52250971e-02f, 2.64133625e-02f, -8.70264228e-03f, -2.13563666e-02f,
  4.18394580e-02f, -4.67234589e-02f, 4.06875648e-02f, 1.33692799e-02f, 3.75498645e-03f, 6.85749948e-02f, -3.07603553e-02f, 2.44891439e-02f, -3.11589092e-02f, 2.70350184e-02f,
  -5.58428233e-03f, 1.74848756e-04f, 1.12537192e-02f, -3.85688543e-02f, 1.63652655e-02f, -5.14717326e-02f, -2.60761776e-03f, 4.13284004e-02f, -5.68102524e-02f, 4.58415747e-02f,
  -5.40998690e-02f, -3.13108005e-02f, -3.92569648e-03f, 5.02982512e-02f, -6.08874895e-02f, -1.85807683e-02f, -7.03175226e-03f, -2.60341614e-02f, -1.81814167e-03f, 5.41024469e-02f,
  -1.58551574e-01f, -1.10162795e-01f, -5.16242310e-02f, 2.84338202e-02f, -6.03090562e-02f, 4.48244018e-03f, -9.50225592e-02f, 3.85303833e-02f, -9.44371000e-02f, 1.37175433e-02f,
  5.84059916e-02f, 2.07592510e-02f, -1.08663701e-02f, 3.39369923e-02f, -1.35025764e-02f, 3.71023826e-02f, -3.90135832e-02f, -4.86596068e-03f, 5.22918627e-02f, 5.17729390e-03f,
  7.54760876e-02f, 4.54207845e-02f, 3.77442650e-02f, 5.15997037e-02f, 5.06847911e-02f, 6.59102723e-02f, 4.87128012e-02f, -1.34952106e-02f, 4.87410612e-02f, -4.20377329e-02f,
  -6.51067615e-01f, -1.87127721e-02f, -2.22047940e-01f, -1.94311380e-01f, 8.52578431e-02f, 7.30455071e-02f, -3.31520997e-02f, 9.08715874e-02f, -3.33943546e-01f, 2.34302834e-01f,
  3.02975506e-01f, -2.71372318e-01f, 8.85704160e-02f, 1.32234737e-01f, -1.67218685e-01f, -1.34917861e-02f, -9.62975249e-02f, -2.70948205e-02f, -1.01828031e-01f, -1.11029409e-02f,
  -1.19668588e-01f, 2.37739533e-01f, 3.76478955e-02f, 2.36719385e-01f, 1.16142919e-02f, -3.10868956e-02f, 2.30990782e-01f, 1.25197321e-01f, 1.92540556e-01f, 1.75052155e-02f,
  3.93692367e-02f, -3.43626216e-02f, 1.99747067e-02f, -3.63782346e-02f, 4.15594969e-03f, 3.26011665e-02f, -5.75287221e-03f, 4.46206257e-02f, -4.75367578e-03f, -2.55083740e-02f,
  1.76567547e-02f, 2.62897555e-02f, -3.26110423e-02f, -5.33544682e-02f, 4.79227863e-03f, 9.28792730e-03f, -4.67863195e-02f, -1.64782517e-02f, -6.97871717e-03f, -9.07567609e-03f,
  -6.48331493e-02f, 2.34277453e-02f, 2.76697613e-02f, -1.07311420e-02f, -1.99821722e-02f, 2.71171972e-04f, -2.46363208e-02f, -3.11041363e-02f, -1.98366251e-02f, -8.09819773e-02f,
  -4.71973158e-02f, -1.64401773e-02f, -4.46155347e-04f, 2.36179549e-02f, 7.49394065e-03f, 6.68189377e-02f, 3.00415102e-02f, 6.05998673e-02f, -6.63143396e-02f, 4.52507101e-02f,
  3.50719481e-03f, -1.92992482e-02f, 1.75115447e-02f, -5.27219661e-03f, -1.38729671e-02f, 1.30450411e-03f, 2.20412426e-02f, 2.77126655e-02f, -3.60355154e-02f, -3.61126289e-02f,
  1.20038185e-02f, -9.21607367e-04f, 4.58003022e-03f, 2.74481811e-02f, 2.34448593e-02f, -3.01719662e-02f, 7.28549138e-02f, -2.75507867e-02f, 3.36487368e-02f, 2.66753361e-02f,
  3.50903422e-02f, 7.57992938e-02f, -9.73459426e-03f, 4.84916866e-02f, 3.42612565e-02f, 2.17759572e-02f, 2.93855229e-03f, -8.52075592e-02f, -6.86904322e-03f, 7.64086563e-03f,
  -4.63143848e-02f, -2.70633325e-02f, -6.41459425e-04f, 8.74397438e-03f, -3.21468823e-02f, 1.04250154e-02f, 6.46642521e-02f, 1.12013416e-02f, 1.03937723e-02f, 9.95458476e-03f,
  9.61790234e-02f, -2.85395957e-03f, -5.04154898e-02f, -4.23020683e-03f, 1.59163512e-02f, 5.35682291e-02f, -7.45738018e-03f, -3.70084196e-02f, -3.47884581e-03f, 1.45887432e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.00105570e-02f, -6.89676821e-01f, -1.81141347e-01f, 1.50198966e-01f, 3.90271276e-01f, 1.87444240e-01f, 1.14035942e-01f, -1.66600794e-01f, -3.06700885e-01f, -2.43863925e-01f,
  -7.32963439e-03f, -1.43490285e-01f, -2.35135943e-01f, -1.30561352e-01f, 1.79059163e-01f, -3.74399126e-01f, -4.78870720e-02f, 7.38022029e-02f, -1.86943024e-01f, -2.76894402e-02f,
  1.06041610e-01f, 1.11937359e-01f, -1.30365312e-01f, 9.63079557e-03f, 1.61508814e-01f, 1.28894642e-01f, 2.59473503e-01f, 1.34295896e-01f, 1.98989466e-01f, 1.06540896e-01f,
  2.94327028e-02f, -9.06453878e-02f, -6.14947975e-02f, -1.28465414e-01f, -2.21966533e-03f, 5.43909036e-02f, 1.29958913e-01f, 8.94699469e-02f, 7.71208256e-02f, -3.93429808e-02f,
  2.14465149e-02f, 4.86940145e-02f, 8.66289958e-02f, 4.08084914e-02f, -3.48773748e-02f, -4.67911270e-03f, 3.42878625e-02f, -1.51726231e-02f, -7.34089166e-02f, -7.98707381e-02f,
  1.14576882e-02f, -6.97945729e-02f, 3.55949812e-02f, -2.17873566e-02f, 7.52855986e-02f, -2.16296576e-02f, 5.58792576e-02f, 4.01715524e-02f, -1.11809503e-02f, 7.22486079e-02f,
  7.75461942e-02f, 1.02892056e-01f, -8.92635901e-03f, -4.99045290e-02f, 2.14338694e-02f, -3.65649313e-02f, 2.96144281e-03f, -2.66563352e-02f, 3.90681736e-02f, 1.36264013e-02f,
  1.48645714e-02f, 3.14423516e-02f, -5.63624650e-02f, 5.14901429e-02f, 6.44247979e-02f, -2.15528887e-02f, 5.55489697e-02f, 7.60759488e-02f, 6.91430122e-02f, -1.52580757e-02f,
  -6.36681542e-02f, 2.77772988e-03f, -5.94165325e-02f, -1.17136193e-02f, -9.87740830e-02f, -2.09802408e-02f, -7.76679590e-02f, -3.95842157e-02f, 3.88870314e-02f, 6.13495223e-02f,
  -2.26026233e-02f, -2.49672502e-01f, -1.79787464e-02f, 3.26959752e-02f, -3.28076594e-02f, 1.34824678e-01f, -8.41850042e-02f, -3.26018184e-02f, -1.18402652e-01f, -1.07710660e-01f,
  1.06932662e-01f, 1.25606209e-01f, -7.30425492e-02f, 4.06651422e-02f, 4.11858968e-02f, -5.35849296e-02f, 3.17240739e-03f, 1.70912000e-03f, 8.13745037e-02f, -2.85713878e-02f,
  2.89585758e-02f, 2.64801532e-02f, 7.38775358e-02f, 1.33236155e-01f, -2.85265408e-02f, 1.92452688e-02f, 1.13705397e-01f, 1.01716496e-01f, 1.03569731e-01f, -6.37990306e-04f,
  2.40576446e-01f, 1.54180095e-01f, 1.82041079e-01f, 1.68862715e-01f, -2.37899825e-01f, -7.28041530e-01f, -5.76684415e-01f, -7.71663908e-04f, -8.18382278e-02f, -2.04520255e-01f,
  -1.54708594e-01f, 3.00718188e-01f, -5.82413003e-02f, 1.42255038e-01f, 1.05839446e-01f, 4.18661498e-02f, -2.84025166e-02f, -1.54843792e-01f, 1.48785681e-01f, 1.85298130e-01f,
  2.09964350e-01f, 9.38300937e-02f, 3.78727645e-01f, 1.23816624e-01f, 4.15802822e-02f, 3.34171742e-01f, 3.07352692e-01f, 7.13130832e-02f, 1.65003225e-01f, -7.43045136e-02f,
  -1.14099286e-01f, 1.31609976e-01f, 2.62990445e-02f, -3.22355852e-02f, 4.15563919e-02f, -5.64066246e-02f, -3.21516022e-02f, -5.53240553e-02f, 2.41513178e-02f, -3.91514599e-02f,
  5.13278656e-02f, -3.90279032e-02f, 4.79211695e-02f, 1.96169522e-02f, -4.28808294e-02f, 2.81125698e-02f, 1.24516062e-01f, 7.20025599e-02f, 6.90991282e-02f, 6.30276799e-02f,
  1.05665281e-01f, 2.33543105e-02f, 1.55139226e-03f, 1.36304488e-02f, 1.26390293e-01f, -7.52914473e-02f, -4.48523313e-02f, 4.71790545e-02f, -1.90306231e-02f, -3.74598312e-03f,
  1.04426071e-01f, -7.42826089e-02f, -1.05459653e-02f, -8.34542662e-02f, -5.19844182e-02f, 2.92972254e-04f, 3.82082239e-02f, -1.67516842e-02f, -4.16452102e-02f, -5.44523560e-02f,
  -6.48634434e-02f, 1.33929336e-02f, -1.48649476e-02f, -1.07819043e-01f, 5.31999245e-02f, 4.71592844e-02f, -2.05198973e-02f, -4.29855809e-02f, -6.18136786e-02f, 3.10111772e-02f,
  -2.18844935e-02f, -3.40730809e-02f, -5.41169709e-03f, 1.41207539e-02f, -6.81807920e-02f, -3.97807773e-04f, 7.92889297e-02f, -5.24854437e-02f, 3.83513384e-02f, -3.71508896e-02f,
  3.78238522e-02f, 1.59054026e-01f, -2.29433104e-02f, -5.59082590e-02f, -3.88871618e-02f, 1.33260079e-02f, -3.10461745e-02f, 2.07825173e-02f, 4.06387262e-02f, 2.31918078e-02f,
  -3.32071329e-03f, -5.92408739e-02f, -2.01628413e-02f, 5.34019358e-02f, -1.38950376e-02f, 4.48838696e-02f, -2.19254196e-03f, 2.37378739e-02f, 2.67178640e-02f, 1.83471799e-01f,
  6.42886534e-02f, -8.79514441e-02f, 7.48366117e-02f, -6.58172593e-02f, 1.47993220e-02f, 3.39280665e-02f, 4.79173847e-02f, 6.64532334e-02f, 1.05455317e-01f, 7.94735104e-02f,
  -5.71662128e-01f, 1.46496817e-01f, 5.16378343e-01f, -3.53929073e-01f, -3.40882614e-02f, 4.78418946e-01f, 4.66982156e-01f, -9.33266729e-02f, -3.12125534e-01f, -1.21324286e-01f,
  -7.63728693e-02f, -2.33225882e-01f, 4.61777478e-01f, -4.24516723e-02f, 2.42557868e-01f, 3.95270586e-01f, 1.74760476e-01f, 1.37228951e-01f, 9.16712359e-02f, -1.46072432e-01f,
  -7.62556344e-02f, -1.56218693e-01f, 3.05936277e-01f, -1.05311356e-01f, -1.78734869e-01f, -2.45292559e-01f, -1.63191795e-01f, 2.51371056e-01f, -1.93620414e-01f, 6.25427738e-02f,
  1.00759126e-03f, -2.80664653e-01f, 2.61789188e-02f, 3.75219360e-02f, 3.02475858e-02f, 5.33027053e-02f, 4.18031514e-02f, 1.20080970e-01f, -8.46974030e-02f, -4.75655161e-02f,
  -4.66834232e-02f, -9.46811400e-03f, -1.75983503e-01f, 2.39343122e-02f, -3.19014378e-02f, -6.71699941e-02f, 2.88791489e-02f, 2.74618268e-02f, -6.31690491e-03f, 3.59800830e-02f,
  1.27278194e-01f, -6.62140839e-04f, -3.82833034e-02f, -1.39580145e-02f, -4.00253106e-03f, 3.83163989e-03f, -3.51216714e-03f, 7.72739127e-02f, -2.90165506e-02f, -6.15270622e-02f,
  -6.34201318e-02f, 7.31885955e-02f, 5.14865033e-02f, -2.64764633e-02f, -4.69515473e-02f, -7.96650946e-02f, 3.29179540e-02f, -3.23597193e-02f, -1.80446524e-02f, 3.59485671e-02f,
  -1.13687672e-01f, -3.63694206e-02f, -3.10948621e-02f, 1.31764663e-02f, 1.83242885e-03f, -6.33798987e-02f, 6.53736517e-02f, 1.81309413e-03f, -1.18208095e-03f, -3.72341275e-03f,
  1.57770570e-02f, -3.98987345e-02f, 4.89348136e-02f, -1.85176767e-02f, 6.00760207e-02f, 6.55123126e-03f, -2.94287521e-02f, 4.65023294e-02f, -7.12530501e-03f, 5.30571491e-02f,
  -6.49039894e-02f, -1.00349128e-01f, -8.34762380e-02f, -7.81924948e-02f, 6.26631379e-02f, -4.70465012e-02f, 7.16941580e-02f, -7.37609863e-02f, 6.40477985e-02f, 5.30701950e-02f,
  1.24759348e-02f, -2.70972159e-02f, -3.66715267e-02f, 3.09276115e-02f, 3.39307003e-02f, -4.74150144e-02f, -5.74053600e-02f, -1.28818126e-02f, 4.49232124e-02f, 1.36619210e-02f,
  -8.04660991e-02f, -3.39282937e-02f, 1.95846632e-02f, -7.27379844e-02f, -3.84415351e-02f, -5.35194278e-02f, -9.02103484e-02f, -1.07272426e-02f, 3.03819422e-02f, -9.51549411e-03f,
  -1.72155425e-01f, 2.88342863e-01f, 2.36406475e-01f, 6.05073795e-02f, -2.30193928e-01f, 4.99504134e-02f, 7.18400851e-02f, -8.75281394e-02f, -6.97131529e-02f, 2.87072837e-01f,
  -6.75445944e-02f, 1.54459536e-01f, -1.81339886e-02f, 1.30564243e-01f, -3.19006115e-01f, -1.61862262e-02f, 1.44832790e-01f, 2.54098803e-01f, -1.63709566e-01f, -8.24300796e-02f,
  -7.38983378e-02f, -1.54043168e-01f, 9.53037739e-02f, -2.13629246e-01f, 1.05429307e-01f, 6.84887916e-02f, -1.80123031e-01f, -2.05977425e-01f, 8.68830979e-02f, -6.73271716e-02f,
  -2.33298372e-02f, -1.14087857e-01f, 1.65746212e-01f, 6.85801059e-02f, -8.26789215e-02f, 2.37018429e-02f, 5.36178537e-02f, -3.11059915e-02f, -4.71088924e-02f, -6.89704716e-02f,
  9.37291682e-02f, -5.21923415e-03f, -4.25188504e-02f, -6.66700453e-02f, -7.97749776e-03f, 8.20370540e-02f, 6.30449504e-02f, 4.20288257e-02f, 1.21785626e-01f, 1.42860457e-01f,
  1.71618417e-01f, 1.32118538e-01f, 1.48100838e-01f, 7.41593763e-02f, -2.16300376e-02f, 2.26270296e-02f, 6.39257655e-02f, 8.49738196e-02f, -1.36296367e-02f, -5.31003904e-03f,
  7.25940429e-03f, -1.24602586e-01f, 8.66587311e-02f, -6.33404106e-02f, -1.30585050e-02f, -3.65357436e-02f, -2.31959950e-02f, -6.24975972e-02f, -6.82068989e-02f, -3.87394987e-02f,
  3.83259729e-02f, 1.11526018e-02f, 3.40629220e-02f, 6.94978386e-02f, -1.53073994e-02f, 1.92356308e-03f, 5.61348498e-02f, -1.06159905e-02f, 3.89536470e-02f, 4.90902625e-02f,
  -1.10315233e-02f, -3.23405862e-02f, -5.92257492e-02f, 3.36951314e-04f, -6.10962510e-02f, -5.97404614e-02f, -4.97935601e-02f, -1.68573204e-02f, -2.41621118e-02f, -1.90895814e-02f,
  -1.80198759e-01f, -1.39942184e-01f, -1.13600846e-02f, 3.34050804e-02f, 6.45671710e-02f, 5.81918731e-02f, -7.22984821e-02f, 2.61204410e-02f, 2.49494668e-02f, 8.80201254e-03f,
  3.39265279e-02f, 1.38147583e-03f, 2.56192293e-02f, -1.19034303e-02f, 2.21093707e-02f, -2.71562524e-02f, -7.66092315e-02f, 7.21845403e-02f, -4.31995615e-02f, -8.42009261e-02f,
  3.65469567e-02f, -4.42212671e-02f, 4.72359918e-02f, 1.03964319e-03f, 8.41801539e-02f, 9.17530879e-02f, 3.20075749e-04f, -7.60550499e-02f, -1.71198174e-02f, 3.66868861e-02f,
  3.90616685e-01f, -3.73793274e-01f, -5.94316050e-02f, 3.35528970e-01f, 3.81602257e-01f, 7.20663508e-03f, 3.22693050e-01f, 2.36037225e-01f, 6.20676875e-01f, -2.65953392e-01f,
  1.38365909e-01f, -3.85941356e-01f, -1.14951573e-01f, 8.33720267e-02f, 1.08552417e-02f, -5.69145121e-02f, 1.73103884e-01f, -8.92902762e-02f, 2.50186801e-01f, 6.02068864e-02f,
  2.67270625e-01f, 5.31819882e-03f, -7.65486509e-02f, -1.57032669e-01f, 1.37905583e-01f, -1.00052297e-01f, -2.48711988e-01f, -2.08392128e-01f, -2.60324001e-01f, -1.77027106e-01f,
  1.58407971e-01f, 1.97343767e-01f, 1.56686697e-02f, -1.02405138e-01f, 9.00635719e-02f, 4.06423919e-02f, -2.11088613e-01f, -1.07846655e-01f, 7.12465271e-02f, 4.19422165e-02f,
  -1.27128512e-01f, -4.93662842e-02f, -1.13081401e-02f, 7.70830037e-03f, 1.63315997e-01f, 1.69283822e-02f, 5.59178106e-02f, 6.93773106e-02f, -7.18333200e-02f, -4.10157293e-02f,
  4.59552370e-03f, -8.25461522e-02f, 8.96420702e-02f, -1.23278841e-01f, 1.31228415e-03f, 4.77673337e-02f, -1.19381480e-01f, -1.39511228e-01f, -8.58287439e-02f, 6.87391981e-02f,
  -9.64382663e-03f, -4.23825718e-02f, 1.33681437e-03f, 3.14692445e-02f, -2.42135469e-02f, 7.42183998e-02f, -1.10370331e-02f, -2.07080729e-02f, -2.62551419e-02f, 5.73503692e-03f,
  3.71146537e-02f, 3.07998285e-02f, 6.61430508e-02f, -3.26591134e-02f, 3.60613950e-02f, 2.50596069e-02f, -5.44010326e-02f, -7.44627267e-02f, 1.13437690e-01f, -2.88666803e-02f,
  -2.28882078e-02f, -5.60500920e-02f, 4.04852144e-02f, -1.13770580e-02f, -4.98640630e-03f, 2.37369910e-02f, 1.26352785e-02f, -1.79471765e-02f, 3.57938185e-02f, 2.66186590e-03f,
  -1.71732709e-01f, -1.93254441e-01f, -9.15625412e-03f, -4.96173687e-02f, -9.56831947e-02f, -3.04425322e-02f, 5.53811081e-02f, 1.03610139e-02f, -1.30205065e-01f, 3.03801615e-02f,
  1.06016742e-02f, 2.20419765e-02f, -4.38108519e-02f, 1.09587684e-02f, -1.01887047e-01f, 9.49653015e-02f, -1.11297354e-01f, -1.00394979e-01f, -2.56116502e-02f, -9.51707363e-02f,
  -2.75006462e-02f, 3.91220581e-03f, -3.67818996e-02f, 8.26220140e-02f, 9.21519380e-03f, -1.69976335e-02f, 1.64831243e-03f, -3.47357094e-02f, -1.13800742e-01f, -3.89513262e-02f,
  4.06486124e-01f, 2.23374404e-02f, -4.44731921e-01f, -2.33637854e-01f, 1.08999625e-01f, 2.97059327e-01f, 1.79793775e-01f, -7.79308751e-02f, -2.55692214e-01f, 1.52734876e-01f,
  1.19972870e-01f, 6.08390830e-02f, 4.04294953e-02f, 2.26077884e-01f, 2.34428376e-01f, 9.84872878e-02f, 1.42881617e-01f, 2.42717296e-01f, -1.18907809e-01f, 9.34594050e-02f,
  -7.56359994e-02f, 3.57494086e-01f, -1.57583773e-01f, 1.70438550e-02f, 1.57829359e-01f, -1.99330091e-01f, 4.70528752e-02f, -1.62922427e-01f, 8.30122679e-02f, 1.61756501e-01f,
  1.39377773e-01f, 1.38062295e-02f, -3.50591242e-02f, -3.56460325e-02f, -3.45108733e-02f, 4.22269963e-02f, -3.73586416e-02f, 3.69015932e-02f, -1.44737795e-01f, -5.16624795e-03f,
  -9.97666921e-03f, -4.98460606e-02f, 3.53435501e-02f, 6.21105134e-02f, -3.76120992e-02f, -6.39690086e-02f, -1.17165754e-02f, -2.20592935e-02f, -5.04767187e-02f, 5.35280555e-02f,
  -9.65452120e-02f, 7.65870046e-03f, -4.61143851e-02f, -3.05145532e-02f, -7.69596696e-02f, -8.61281976e-02f, -5.50806560e-02f, 9.71604660e-02f, -2.09920369e-02f, -1.40155237e-02f,
  1.29402488e-01f, 6.47298694e-02f, 6.18856736e-02f, 1.64445732e-02f, 1.39683289e-02f, -6.56029657e-02f, 3.91160324e-02f, 2.66693272e-02f, -3.18942443e-02f, 6.42832592e-02f,
  -3.27415839e-02f, -9.04537290e-02f, -8.24731961e-03f, 3.75915356e-02f, 5.11543229e-02f, 3.62733603e-02f, 5.36612198e-02f, -1.51820276e-02f, -7.93216377e-02f, -8.58738348e-02f,
  1.44933062e-02f, 4.75661037e-03f, 2.56631952e-02f, -2.14957576e-02f, 1.73103213e-02f, -3.17701846e-02f, 1.23831173e-02f, 4.23730314e-02f, -7.98204169e-02f, -4.86895554e-02f,
  1.04092732e-01f, -4.97476570e-02f, -9.98655707e-02f, -1.08392917e-01f, -6.44155890e-02f, 1.83853149e-01f, 1.80242397e-02f, 2.42356062e-02f, 1.68802887e-02f, 4.71511073e-02f,
  3.70741934e-02f, -1.48131037e-02f, 3.19120809e-02f, -5.88661879e-02f, -1.30079657e-01f, 3.30521800e-02f, -7.78157637e-02f, -7.86139965e-02f, -3.05093378e-02f, 5.88432606e-03f,
  -7.82148261e-03f, 6.76284917e-03f, -1.23532545e-02f, 3.42359170e-02f, -1.46271000e-02f, -2.29370464e-02f, 8.88046548e-02f, -8.89767930e-02f, 3.98766845e-02f, -4.47337367e-02f,
  -3.50293785e-01f, -1.26935601e-01f, -3.65522802e-01f, -1.92711294e-01f, -2.89134532e-01f, -3.95871609e-01f, -1.05254538e-01f, -4.19670701e-01f, -1.58311039e-01f, 2.79608160e-01f,
  1.98308334e-01f, -8.92839804e-02f, 3.78422856e-01f, 3.42092942e-03f, -2.60475755e-01f, 3.53224158e-01f, -1.28847241e-01f, 5.96693680e-02f, -6.24110512e-02f, -2.78781563e-01f,
  -1.70154795e-01f, -1.07354715e-01f, -3.04143764e-02f, -1.46238610e-01f, -2.60357976e-01f, -1.67812899e-01f, 1.91702172e-01f, -2.09386926e-02f, -2.03770176e-01f, -5.75691685e-02f,
  -2.94510096e-01f, -2.24129140e-01f, -5.43926023e-02f, -8.61018077e-02f, -1.21125452e-01f, -1.44151738e-02f, -1.99380424e-02f, 2.13394146e-02f, -2.56293081e-02f, -1.46507815e-01f,
  4.22544405e-02f, -1.06325388e-01f, -2.38498803e-02f, 6.83326125e-02f, -5.93572296e-02f, -4.66735028e-02f, -4.93210480e-02f, 3.80157009e-02f, -5.67293875e-02f, -1.45968527e-01f,
  -4.47164215e-02f, -6.41554892e-02f, -6.06980510e-02f, 1.70177780e-02f, 3.87401134e-02f, -7.44946897e-02f, 1.66964680e-02f, -1.40078617e-02f, -9.00300816e-02f, -1.15214273e-01f,
  -3.30632068e-02f, 1.70790427e-03f, -9.40345414e-03f, 3.43053713e-02f, -6.30912185e-02f, 1.81176290e-02f, -2.42913347e-02f, 4.62901853e-02f, 1.06446212e-02f, -5.30597828e-02f,
  -4.87447195e-02f, -4.80004102e-02f, 6.46083383e-03f, -5.72913093e-03f, 5.61079569e-03f, 1.10953569e-03f, 7.02265650e-02f, -1.18485659e-01f, 4.28047851e-02f, -6.95846528e-02f,
  9.96162817e-02f, -7.46245459e-02f, 9.34529752e-02f, 6.18065745e-02f, -8.09704959e-02f, 8.13815370e-02f, 5.23062330e-03f, -3.86114530e-02f, 2.01588403e-02f, -5.05880453e-02f,
  -3.85355145e-01f, -3.48726422e-01f, -5.50472178e-02f, -4.81107971e-03f, -9.06011015e-02f, -1.14357993e-01f, 6.77573085e-02f, -2.70061865e-02f, -1.85148090e-01f, -3.89381088e-02f,
  -6.92866445e-02f, 6.96245953e-02f, -1.38512045e-01f, 3.67607325e-02f, -4.90330644e-02f, -6.58671111e-02f, 3.00679393e-02f, -4.29301262e-02f, -1.81602444e-02f, -9.29365009e-02f,
  -4.91924584e-02f, -2.67200340e-02f, 1.14294980e-02f, 6.24889396e-02f, 6.95730792e-03f, 1.45828130e-03f, -5.16380258e-02f, 5.94043992e-02f, -1.01003386e-01f, -1.62851159e-02f,
  -4.14803267e-01f, 2.84790486e-01f, -1.02770001e-01f, -2.79228866e-01f, 1.68111455e-02f, 4.64156969e-03f, -4.08177590e-03f, 2.60383636e-01f, 3.97277594e-01f, 1.28119707e-01f,
  2.15784200e-02f, -8.56924355e-02f, 2.57779568e-01f, -6.09794073e-02f, -7.74000809e-02f, 2.44069308e-01f, -1.19877204e-01f, -9.66944695e-02f, 2.15471506e-01f, -2.18693554e-01f,
  -1.88831225e-01f, -1.81648657e-01f, -1.77091271e-01f, -1.29336476e-01f, -3.89331698e-01f, -2.07681775e-01f, -1.54245332e-01f, -5.80383167e-02f, -2.96043932e-01f, 7.99921528e-02f,
  -8.80065337e-02f, 6.71415851e-02f, -1.91562667e-01f, 7.59508088e-02f, -1.72962144e-01f, -1.21656016e-01f, -9.84032974e-02f, -1.95789728e-02f, -7.92640150e-02f, 2.90368050e-02f,
  -9.37732831e-02f, -3.73849981e-02f, -4.33363654e-02f, 4.32879888e-02f, 5.54302484e-02f, 4.39757742e-02f, -1.39048979e-01f, -1.00607783e-01f, 5.61992964e-03f, 4.02377248e-02f,
  -7.09581748e-02f, 9.23100021e-03f, -7.02437609e-02f, 3.31150144e-02f, -6.60429001e-02f, 2.09496152e-02f, -2.75442638e-02f, -5.82374707e-02f, -9.76313651e-02f, -8.02419055e-03f,
  -1.82954110e-02f, 1.01312645e-01f, 2.86117938e-05f, -2.18273085e-02f, -6.77459873e-04f, -2.16304213e-02f, -4.57775369e-02f, -5.91053534e-03f, 1.42459315e-03f, -5.12834415e-02f,
  5.78057468e-02f, 6.09956793e-02f, 8.11074525e-02f, -2.86430940e-02f, 3.43475789e-02f, -4.55451868e-02f, 3.25879119e-02f, -1.18445018e-02f, -2.05879249e-02f, -8.69981595e-04f,
  -2.40783114e-02f, 6.91960379e-02f, -6.55825660e-02f, -6.02762634e-03f, -1.11977579e-02f, -4.05236222e-02f, 6.73439503e-02f, 6.35388047e-02f, -6.17769845e-02f, -2.39116885e-02f,
  6.59342855e-02f, 2.00434595e-01f, 8.62128939e-03f, -1.54624134e-02f, -5.23603559e-02f, 7.38653727e-03f, 1.90984029e-02f, -2.25344822e-02f, 1.18487790e-01f, 5.73260300e-02f,
  -8.15643221e-02f, -1.50071830e-02f, -1.14261240e-01f, 6.69724345e-02f, 6.49170671e-03f, 2.08691303e-02f, 5.11424756e-03f, -2.36853044e-02f, 6.50577201e-03f, -3.60232568e-03f,
  -1.30726501e-01f, 2.15552915e-02f, -2.71463189e-02f, 6.18868992e-02f, 3.02350316e-02f, -2.00247252e-03f, 5.88729233e-02f, 3.22687812e-02f, 3.68330330e-02f, 3.55452895e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.61623526e-01f, 2.43314892e-01f, 4.54452723e-01f, 1.56094730e-01f, 9.43550766e-02f, 2.26611465e-01f, 3.37928832e-01f, 2.77068913e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.65218633e-01f, -3.89355153e-01f, -4.86119360e-01f, -1.31394148e-01f, -3.38256896e-01f, 7.09624961e-03f, 1.71672896e-01f, 4.66001272e-01f, -2.19175786e-01f, 8.72071534e-02f,
  -2.87825111e-02f, -1.78940445e-01f, 5.59502840e-01f, 4.49808270e-01f, -4.20892298e-01f, 5.28142393e-01f, 3.93224716e-01f, 1.53049277e-02f, 2.14654535e-01f, -2.13145882e-01f,
  -4.32728559e-01f, 3.31522405e-01f, -4.89285350e-01f, 6.30660176e-01f, -3.49726081e-01f, -3.94844145e-01f, 3.64255756e-01f, 5.26931286e-01f, -1.12837702e-01f, 2.06983034e-02f,
  7.11582899e-01f, -9.59294196e-03f, 1.21399038e-01f, -5.98375164e-02f, -5.89171171e-01f, -2.72744566e-01f, 7.15434402e-02f, 1.62124380e-01f, 8.81510600e-02f, -4.83826250e-01f,
  1.12275347e-01f, -1.63108468e-01f, 1.96834981e-01f, 3.01036052e-03f, 6.50165379e-01f, 3.96379411e-01f, -6.61754429e-01f, 3.94577026e-01f, 5.39624274e-01f, -4.31121111e-01f,
  7.13679612e-01f, -6.09277964e-01f, -1.82871670e-01f, -4.89608169e-01f, 4.99696225e-01f, 2.91180134e-01f, -1.31746545e-01f, -1.11897647e-01f, -3.66937369e-01f, -1.54508561e-01f,
  1.59869239e-01f, 9.55570281e-01f, -4.75707799e-01f, -1.30948186e-01f, 1.68893471e-01f, 1.51455700e-01f, 1.55566761e-03f, 4.94408496e-02f, 2.49973685e-01f, -4.54380423e-01f,
  -7.23669469e-01f, 3.18292618e-01f, 5.44978492e-03f, 2.90598571e-01f, -3.56653214e-01f, 9.33039784e-02f, -6.58262372e-01f, -7.68939257e-01f, -3.43447089e-01f, 4.21281725e-01f,
  1.10519007e-01f, -4.75583315e-01f, 7.77488887e-01f, 2.12191448e-01f, -6.31739438e-01f, 1.60087705e-01f, 5.22667229e-01f, 2.76158124e-01f, 8.11592638e-01f, -3.87700349e-02f,
  -5.13560891e-01f, -1.80728301e-01f, -1.56563953e-01f, -2.45582014e-02f, -9.54898149e-02f, -3.05508852e-01f, 2.94401348e-01f, 6.96017817e-02f, 3.94649535e-01f, -7.03135133e-01f,
  -2.83939004e-01f, -1.31008446e-01f, -5.88846624e-01f, -7.70032346e-01f, 3.12795453e-02f, 4.22579944e-01f, 3.10350358e-01f, -1.70494422e-01f, 9.17529389e-02f, 5.45220912e-01f,
  -1.79534569e-01f, -5.56174219e-01f, 3.28368187e-01f, 5.15334368e-01f, -7.94007361e-01f, 2.96122134e-01f, -8.13976824e-02f, -1.18946202e-01f, 4.51253235e-01f, 6.74397707e-01f,
  -4.20493126e-01f, -9.46947709e-02f, -2.35638499e-01f, -1.46539792e-01f, -2.41396978e-01f, -2.64850110e-01f, 5.35593271e-01f, 5.18088818e-01f, 2.97573805e-01f, 2.85023510e-01f,
  1.38629347e-01f, 7.52639234e-01f, -6.15401368e-05f, -1.96695045e-01f, 3.68205197e-02f, 3.10667634e-01f, 7.90955424e-02f, -1.25449628e-01f, 3.31521243e-01f, 4.25272226e-01f,
  -9.17732567e-02f, -6.08783662e-01f, -4.66213733e-01f, -4.01203007e-01f, 5.08495867e-01f, -1.08412869e-01f, -6.84940755e-01f, 9.70453799e-01f, -3.33794326e-01f, 6.69279337e-01f,
  -7.01741427e-02f, 2.26051778e-01f, -2.34613091e-01f, -1.86715648e-01f, 8.88581157e-01f, 9.20099914e-02f, -2.58274227e-01f, -2.02545211e-01f, -3.14839840e-01f, 3.76733065e-01f,
  4.82174158e-01f, 6.06616199e-01f, 4.24616367e-01f, 2.19567329e-01f, 4.23326850e-01f, 1.32517487e-01f, 1.64758831e-01f, -1.97834224e-01f, 5.07755578e-01f, 3.47340137e-01f,
  -3.84377301e-01f, 6.39996901e-02f, 5.41665316e-01f, 4.00099337e-01f, 1.28206573e-02f, 8.42629433e-01f, 1.34417355e-01f, 2.05456242e-01f, -2.82446235e-01f, -8.80277276e-01f,
  -1.36548102e-01f, -3.86714667e-01f, -8.29155505e-01f, -7.59723604e-01f, -3.08516592e-01f, -3.59837085e-01f, 1.73798859e-01f, 4.44733771e-03f, -9.69317406e-02f, -8.04834366e-02f,
  -4.47837025e-01f, 5.40638506e-01f, 2.13235646e-01f, -2.59605795e-01f, -7.89904445e-02f, 1.74854714e-02f, 3.33534069e-02f, 3.45882386e-01f, 2.28884816e-01f, 1.90687954e-01f,
  4.37495597e-02f, 3.44764501e-01f, 5.83009794e-02f, -1.86365813e-01f, -6.40099227e-01f, -4.57924098e-01f, 4.40310270e-01f, 4.68973577e-01f, -4.32893962e-01f, -1.45615041e-01f,
  9.33039933e-02f, 1.05529457e-01f, 2.14802340e-01f, 5.90892062e-02f, -1.32274270e-01f, -6.11597538e-01f, 1.77767962e-01f, -3.50643307e-01f, -5.64927936e-01f, -1.03526711e-01f,
  1.30256915e+00f, -4.02549714e-01f, -4.10000950e-01f, -1.80490211e-01f, -5.34919381e-01f, -7.66130239e-02f, -4.09240663e-01f, 1.76687092e-01f, -1.34750262e-01f, -1.91528127e-01f,
  -2.37309322e-01f, -1.85815230e-01f, 9.94535983e-02f, -3.52164865e-01f, -2.75709212e-01f, -1.59291387e-01f, -4.94508088e-01f, 3.40207040e-01f, 3.47812295e-01f, -4.09335494e-01f,
  -6.86277568e-01f, 3.30754757e-01f, -1.72698855e-01f, 5.36411166e-01f, -1.11984715e-01f, 2.18727082e-01f, -4.37165588e-01f, -5.56883216e-01f, -1.89621791e-01f, 4.66323048e-01f,
  -2.28690878e-01f, -1.91622108e-01f, -8.64084214e-02f, -9.14896652e-02f, 7.64055729e-01f, 4.78906393e-01f, 1.72737792e-01f, 1.70636788e-01f, 6.85422048e-02f, 2.39033684e-01f,
  -1.50731847e-01f, -3.33350271e-01f, -6.61115885e-01f, 1.54067650e-01f, 5.50952516e-02f, -4.65025097e-01f, 6.86630458e-02f, 2.01541901e-01f, 1.20913915e-01f, 2.56923795e-01f,
  -1.19419962e-01f, -4.32612300e-01f, -6.10771894e-01f, -3.27338755e-01f, 5.66427827e-01f, -3.46138477e-01f, -2.97653258e-01f, -5.21996617e-01f, -1.03971899e-01f, 1.59120530e-01f,
  -2.73875326e-01f, 1.00281465e+00f, -2.07823649e-01f, -2.53958166e-01f, -2.58417040e-01f, -4.36963022e-01f, -3.25536489e-01f, -2.83430874e-01f, -5.14605820e-01f, -2.07131565e-01f,
  2.25885645e-01f, -3.27588856e-01f, -2.58117646e-01f, 6.07609041e-02f, 4.08491641e-01f, 1.28726646e-01f, 8.41494128e-02f, -4.52004969e-01f, 3.75229456e-02f, 2.11805403e-01f,
  -6.83622301e-01f, -5.25363564e-01f, 2.55890358e-02f, 6.28246129e-01f, -7.52359092e-01f, 6.20027602e-01f, -7.01493844e-02f, -6.47021174e-01f, 2.18487993e-01f, 5.21217048e-01f,
  1.53306574e-01f, -2.50586540e-01f, 4.11283225e-01f, -3.45317781e-01f, 7.02940285e-01f, -8.14206824e-02f, -2.26223767e-01f, 6.98582642e-03f, 1.71547472e-01f, -4.02123570e-01f,
  2.88266987e-01f, 3.26722264e-01f, 1.49226934e-01f, -1.82946220e-01f, 1.47540942e-01f, 2.78739989e-01f, 5.82990646e-01f, 1.43794373e-01f, 9.30555612e-02f, -4.82927077e-02f,
  -3.45569670e-01f, -2.72400618e-01f, -2.00663339e-02f, 7.52553999e-01f, 6.76324427e-01f, -8.41588318e-01f, 3.66275847e-01f, -4.09571081e-01f, -7.80717283e-02f, 7.56323695e-01f,
  6.84972465e-01f, -4.62710142e-01f, 8.23242366e-01f, 6.80481911e-01f, 4.82621431e-01f, -3.22099090e-01f, -3.66089821e-01f, 2.52073221e-02f, -1.83627710e-01f, -1.15715377e-01f,
  -1.97728593e-02f, -2.03755826e-01f, 5.51298959e-04f, -1.35751188e-01f, -6.11291267e-02f, -1.43827721e-01f, 1.55640602e-01f, 1.40293688e-01f, 4.06158894e-01f, 3.77868146e-01f,
  -3.99510890e-01f, 2.01008901e-01f, 4.27601576e-01f, -5.34834415e-02f, 6.33709908e-01f, -6.35419428e-01f, 6.83236539e-01f, -7.02964604e-01f, 3.56366724e-01f, 6.57409489e-01f,
  -3.41962129e-01f, -1.90068915e-01f, 6.99164748e-01f, -4.34016407e-01f, -1.36902362e-01f, -7.78000832e-01f, -2.16811240e-01f, 2.80319422e-01f, -3.09808165e-01f, 6.76203191e-01f,
  -3.23610246e-01f, -1.29049391e-01f, -3.18717778e-01f, -3.63871902e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.31586331e-01f, 1.51991189e-01f, 1.74674243e-01f, 3.90935363e-03f, -8.40388760e-02f, 1.61374919e-02f, -1.44181281e-01f, -1.23425260e-01f, -7.44571388e-02f, 7.11226389e-02f,
  1.65089071e-01f, 8.47096816e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    