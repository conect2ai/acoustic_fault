/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.73488069e-01f, 1.41752109e-01f, -4.72157896e-01f, -2.49821216e-01f, -2.66677320e-01f, -1.19960018e-01f, -2.40041614e-02f, -8.96285623e-02f, -6.37251884e-02f, 5.39041646e-02f,
  4.40644361e-02f, 1.50112018e-01f, 1.17553100e-01f, 1.53651819e-01f, 5.21678217e-02f, 2.53901500e-02f, 1.45365298e-02f, -1.49859682e-01f, -2.05059320e-01f, -1.90634325e-01f,
  2.18811646e-01f, -2.17815101e-01f, -2.55092800e-01f, -6.42894283e-02f, -5.52132018e-02f, -8.34693573e-03f, -8.74686241e-02f, -1.63861617e-01f, 3.67124099e-03f, 1.29076034e-01f,
  -2.04784572e-02f, -2.93839216e-01f, -1.92010198e-02f, 7.74225891e-02f, 7.37350434e-02f, 3.07314806e-02f, 5.67401685e-02f, -5.94166033e-02f, 1.26978010e-01f, -1.26389107e-02f,
  5.08129671e-02f, 4.17248197e-02f, 1.36824362e-02f, 7.14645982e-02f, -7.68495277e-02f, 9.17159952e-04f, -4.42225784e-02f, -5.12068421e-02f, 5.86108677e-03f, -8.23027082e-03f,
  9.61172059e-02f, -6.35096952e-02f, -1.36645287e-01f, 6.68058125e-03f, 5.15639558e-02f, -8.19280595e-02f, -5.10211289e-02f, -6.58317506e-02f, -6.53660670e-02f, -2.54314505e-02f,
  1.05317291e-02f, -1.11120958e-02f, 4.33595479e-03f, -1.06924279e-02f, 1.14076072e-02f, 1.32600898e-02f, 6.24042237e-03f, 6.34026453e-02f, 3.41669209e-02f, -3.34226452e-02f,
  6.27577454e-02f, -6.15517236e-03f, -1.57419350e-02f, 2.91765202e-02f, -4.21760157e-02f, -2.29965779e-03f, 3.37336846e-02f, 3.82656828e-02f, -2.77005602e-03f, 1.38452342e-02f,
  3.84602472e-02f, -3.16298641e-02f, -9.69086140e-02f, 1.09755576e-01f, -4.58194539e-02f, -1.54816192e-02f, -6.04758337e-02f, -1.91878937e-02f, -1.18345842e-02f, -3.35906520e-02f,
  6.27089739e-02f, 2.24065240e-02f, -1.88589133e-02f, 3.81798595e-02f, 2.84862122e-03f, -1.95804797e-02f, 7.11021572e-03f, 2.75877640e-02f, 1.61426086e-02f, 2.43618097e-02f,
  -7.42266178e-02f, 3.41224461e-03f, -5.81298992e-02f, -3.49615589e-02f, 5.91994375e-02f, -3.54784802e-02f, 9.84529778e-02f, -1.94979664e-02f, -3.92921595e-03f, -1.95897985e-02f,
  8.22891444e-02f, 7.21300766e-02f, 1.79240126e-02f, 4.79850732e-02f, -5.79670537e-03f, 1.65865831e-02f, -3.36705297e-02f, -1.24258501e-02f, 3.55090760e-02f, 2.02226609e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.22378111e-01f, -2.41911650e-01f, 1.53465662e-03f, 2.01792449e-01f, 1.19036011e-01f, 2.09411621e-01f, 1.24865353e-01f, 2.55781617e-02f, 1.60142690e-01f, 1.78111896e-01f,
  -1.58735309e-02f, 1.10285230e-01f, 6.47285506e-02f, -7.90346786e-03f, -9.89127234e-02f, 9.67298001e-02f, 6.05247095e-02f, 4.41791862e-02f, 2.79365759e-02f, 1.35606006e-01f,
  -2.28739846e-02f, 6.47331625e-02f, -2.75737280e-03f, -1.81654468e-02f, -6.44269958e-02f, 1.53960377e-01f, -1.15799913e-02f, -7.29173645e-02f, -3.54244336e-02f, -7.47868791e-02f,
  -7.21850712e-03f, -5.12374099e-03f, 1.92880705e-01f, -4.66195345e-02f, -9.65040922e-03f, 1.44125083e-02f, 1.98575109e-02f, -3.87317911e-02f, -2.61342805e-02f, 1.07760906e-01f,
  -8.05586949e-02f, -4.75555845e-02f, -1.30894491e-02f, 5.48396073e-03f, 1.89644303e-02f, 1.19741485e-01f, -7.89071321e-02f, -9.25242435e-03f, 8.66409689e-02f, -1.22769676e-01f,
  -7.01111704e-02f, -2.54874937e-02f, -2.48071123e-02f, 1.68374320e-03f, -2.29053423e-02f, 6.57268688e-02f, 1.06198624e-01f, 2.38662288e-02f, -8.90576839e-03f, -1.89119074e-02f,
  9.67396423e-02f, -9.34943184e-02f, -7.91730955e-02f, 5.91785721e-02f, -3.21294069e-02f, 1.60669666e-02f, 3.89249041e-03f, -1.21884882e-01f, -9.48154852e-02f, 2.79582683e-02f,
  1.08005196e-01f, 9.98990983e-02f, 8.84337537e-03f, 1.17157593e-01f, -3.99066545e-02f, -3.97720821e-02f, 3.09192911e-02f, -5.45390807e-02f, 5.51799452e-03f, 4.96569183e-03f,
  4.34719473e-02f, -1.77349746e-02f, 2.59879138e-02f, -1.48258880e-01f, 8.09163004e-02f, -3.10398033e-03f, 3.45500931e-02f, 3.22708525e-02f, -1.29779372e-02f, 4.79710624e-02f,
  2.13749707e-01f, 8.63893852e-02f, 8.98064673e-02f, -1.43613562e-01f, -1.26715943e-01f, -7.48776495e-02f, 1.47475572e-02f, -8.94536600e-02f, -1.05809622e-01f, 1.28232073e-02f,
  5.18719368e-02f, 9.59751289e-03f, 7.55263567e-02f, 3.95634472e-02f, 5.88808022e-02f, 6.74497290e-03f, -5.42885810e-02f, -8.50792676e-02f, -2.11191494e-02f, 1.36383148e-02f,
  -3.07893939e-02f, 4.47633862e-02f, 8.75886008e-02f, -9.76700615e-03f, -2.64359843e-02f, 1.09169073e-01f, 5.25375493e-02f, 1.46628037e-01f, 1.09091707e-01f, 2.34780207e-01f,
  3.53196152e-02f, -6.79530352e-02f, -1.24715194e-01f, 7.10474700e-02f, -4.77103982e-03f, -2.12651435e-02f, -1.42264619e-01f, 6.18949048e-02f, 7.71942735e-02f, -4.16079946e-02f,
  7.69722685e-02f, 4.90085185e-02f, -3.42375413e-02f, 5.56758046e-02f, -2.49666154e-01f, -3.05821419e-01f, -2.86381274e-01f, -1.71746463e-01f, 5.89415506e-02f, 9.69421268e-02f,
  -2.90912688e-02f, -4.66283150e-02f, -5.34830429e-02f, -5.97634725e-02f, 1.02261342e-01f, 1.02773614e-01f, 7.50978366e-02f, 4.45637070e-02f, -5.95521647e-03f, 6.66446006e-03f,
  -1.05306000e-01f, 1.95005029e-01f, -1.69324856e-02f, -1.15297223e-02f, 1.04824945e-01f, 1.18008312e-02f, -1.00418955e-01f, 1.61426570e-02f, -1.95244849e-02f, -3.16768810e-02f,
  3.24544422e-02f, 1.93975586e-02f, -3.72911384e-03f, -1.16703901e-02f, 4.58237529e-02f, -4.12890315e-02f, -6.76680962e-03f, -1.11490160e-01f, -1.22922316e-01f, -8.47501829e-02f,
  -1.74546883e-01f, 3.36435740e-03f, 5.41053712e-02f, -1.18961766e-01f, 2.85332538e-02f, -2.83724256e-02f, -2.72128545e-02f, 5.40609509e-02f, 5.70816584e-02f, 8.94360095e-02f,
  3.61582972e-02f, -7.10488781e-02f, -2.28866860e-02f, 4.09295373e-02f, -2.90095545e-02f, 6.27728254e-02f, -2.64249351e-02f, -4.93252417e-03f, -2.44791154e-02f, 4.96297851e-02f,
  7.99917895e-03f, 1.86914615e-02f, 3.76398601e-02f, 5.54203056e-03f, 1.45442411e-02f, -6.20097201e-03f, 7.27750435e-02f, -9.00988355e-02f, -9.72956792e-03f, 3.27359848e-02f,
  -7.70034492e-02f, -6.69367015e-02f, 1.21163493e-02f, 8.11435059e-02f, -9.93073359e-03f, -6.62233904e-02f, 2.53119003e-02f, 2.85208207e-02f, 5.91759421e-02f, 3.94333377e-02f,
  3.58723216e-02f, -5.09648398e-02f, -3.86418849e-02f, -1.03290379e-02f, -3.36698368e-02f, 4.04666699e-02f, 3.39460373e-02f, -3.02757602e-02f, 3.27397697e-02f, 4.99329977e-02f,
  -2.80749090e-02f, 2.46038671e-05f, -6.75447285e-02f, -9.55604576e-03f, 8.51931646e-02f, -1.38548195e-01f, -3.88893522e-02f, 1.92793813e-02f, -1.50509505e-02f, -5.76465763e-02f,
  -1.23608328e-01f, -9.83255506e-02f, 4.73497882e-02f, -4.13460061e-02f, -2.32756529e-02f, 2.22055260e-02f, 6.68344051e-02f, -4.90950886e-03f, -5.02180718e-02f, -6.38957741e-03f,
  1.14545286e-01f, 2.30177000e-01f, 2.34019026e-01f, -9.95120257e-02f, -1.93347987e-02f, 8.50408897e-02f, 3.85038346e-01f, 6.24422133e-02f, -1.15226910e-01f, 1.35702178e-01f,
  2.01906338e-02f, -1.72835156e-01f, -6.82133734e-02f, -7.75961503e-02f, 1.02025405e-01f, 1.31776020e-01f, -5.53957522e-02f, -1.48783829e-02f, -1.33906445e-02f, -2.84717511e-02f,
  6.71635754e-03f, -5.58802411e-02f, 1.83095053e-01f, 1.49200946e-01f, -4.96293418e-02f, -1.72143027e-01f, 7.95033760e-03f, 3.90025340e-02f, 1.11651964e-01f, 9.26033128e-04f,
  7.20464364e-02f, 1.66151688e-01f, -2.93689609e-01f, -6.60054311e-02f, -1.08453045e-02f, 1.07309356e-01f, 4.79075424e-02f, 1.83460396e-02f, -5.26300222e-02f, 8.97274725e-03f,
  2.71724444e-02f, 1.12773059e-02f, -2.60850769e-02f, 2.08070595e-03f, 1.14072144e-01f, -1.00110294e-02f, 2.58113425e-02f, 4.43429640e-03f, -5.75948283e-02f, -1.29085034e-02f,
  1.23846717e-02f, -7.63983577e-02f, 2.52926517e-02f, 1.30275801e-01f, 1.99388471e-02f, -1.36206850e-01f, -4.65386128e-03f, 5.51430732e-02f, 3.64884287e-02f, 9.20107663e-02f,
  -1.11539155e-01f, 1.19494647e-02f, -5.76378740e-02f, 2.48991828e-02f, -3.37051339e-02f, -7.62136728e-02f, -4.26733568e-02f, 6.57142624e-02f, -4.10546362e-02f, 1.08155303e-01f,
  8.74286592e-02f, -2.47845780e-02f, 1.85316890e-01f, 9.74560156e-02f, -8.37540179e-02f, 4.30547073e-02f, 7.69192725e-02f, 5.44248670e-02f, -2.96625588e-02f, 8.14351588e-02f,
  -2.21887343e-02f, 1.09123038e-02f, 5.62798530e-02f, 6.24490455e-02f, -6.63780316e-04f, 5.04239611e-02f, 1.23320214e-01f, -2.61722747e-02f, 1.95460264e-02f, -2.06168126e-02f,
  -1.92805454e-01f, 7.16659352e-02f, -1.56359926e-01f, 1.07491305e-02f, -2.48467829e-02f, -4.44265492e-02f, 2.81353742e-02f, 5.40980734e-02f, 7.70345610e-03f, 1.70710862e-01f,
  9.36611444e-02f, 1.10183999e-01f, 1.31185770e-01f, 4.76591289e-02f, -4.35971143e-03f, 5.59840351e-02f, 4.54003317e-03f, -7.90377408e-02f, -1.44270048e-01f, -4.51345649e-03f,
  -2.48043127e-02f, -1.44902527e-01f, -1.49390370e-01f, -4.37303334e-02f, 1.36729926e-02f, -2.26284489e-01f, -7.40464265e-03f, -8.42102319e-02f, -4.78949361e-02f, -6.70608133e-02f,
  1.44130617e-01f, -1.27243521e-02f, -2.01316684e-01f, 2.12877333e-01f, 1.62933514e-01f, -3.47513966e-02f, 8.56464207e-02f, 1.40827611e-01f, 2.16385871e-01f, 1.67619660e-01f,
  -1.95572257e-01f, -2.44653180e-01f, -2.18502507e-01f, -1.78517506e-01f, -2.18920127e-01f, 4.84379306e-02f, 1.26419859e-02f, -2.16242135e-01f, -2.00815871e-01f, 1.27937585e-01f,
  5.02470583e-02f, 2.59819180e-01f, -4.41456446e-04f, 1.24002188e-01f, 1.08063743e-01f, 2.21893206e-01f, 2.20597893e-01f, -7.66535625e-02f, -2.22452413e-02f, 5.17914332e-02f,
  -2.63437867e-01f, -2.28251278e-01f, 2.87432540e-02f, 5.20065576e-02f, -2.72099636e-02f, -1.03346221e-01f, -7.70109668e-02f, -9.96568426e-02f, -1.79864578e-02f, 1.38735585e-03f,
  -1.25523955e-01f, -1.23531252e-01f, -1.90330490e-01f, 2.84724422e-02f, -7.83966482e-02f, -3.08953300e-02f, -4.11593877e-02f, -5.91506399e-02f, -2.02108622e-02f, 2.42200252e-02f,
  -5.30997664e-02f, -1.22819826e-01f, -4.02117856e-02f, 9.36638191e-03f, -1.36082545e-01f, -1.76453993e-01f, -3.26376259e-02f, -6.85863569e-02f, -4.57780659e-02f, 1.38477415e-01f,
  -7.63837770e-02f, -1.79981291e-02f, -5.17458729e-02f, 2.33851485e-02f, 7.32118636e-02f, 1.09108007e-02f, -5.37274592e-02f, -1.07494909e-02f, 2.96944343e-02f, 3.17785814e-02f,
  -2.94857584e-02f, 1.17268576e-03f, 1.33429086e-02f, 3.18636745e-02f, 1.78981852e-02f, -1.97355188e-02f, -6.55601248e-02f, 7.00950697e-02f, 4.32765186e-02f, -1.89070180e-02f,
  3.44917215e-02f, -6.56986283e-03f, 6.70654848e-02f, -5.52524664e-02f, -2.83326469e-02f, -4.96711396e-03f, 2.42202636e-02f, -5.63513152e-02f, 5.86619712e-02f, 8.40471983e-02f,
  2.25250632e-01f, -1.75890535e-01f, 1.71284063e-03f, -5.89932129e-02f, 1.08773328e-01f, 3.68097648e-02f, 3.20076593e-03f, 5.28281666e-02f, -3.98271494e-02f, -3.54420803e-02f,
  1.92947984e-02f, -4.32107337e-02f, 4.16599140e-02f, 5.33632338e-02f, -3.15041691e-02f, 4.38262746e-02f, 4.42447998e-02f, 5.46913929e-02f, -3.56388539e-02f, 3.96959633e-02f,
  1.17172785e-01f, 2.30355993e-01f, 1.28751740e-01f, 1.60372853e-02f, 5.03947586e-02f, 6.11608140e-02f, 7.56161734e-02f, 8.13271180e-02f, -3.86159085e-02f, 4.75437015e-01f,
  1.86982065e-01f, 4.24648896e-02f, 4.55528915e-01f, -2.46773407e-01f, 1.03807203e-01f, 2.75723010e-01f, 3.89858037e-01f, -6.14560135e-02f, -1.73804641e-01f, 1.37449697e-01f,
  -2.89984290e-02f, -4.12217945e-01f, -2.89258093e-01f, -2.01683581e-01f, 1.15013063e-01f, 3.34388077e-01f, 1.97756335e-01f, 4.99579571e-02f, 3.97670968e-03f, 1.65382147e-01f,
  -2.14113295e-01f, -1.55816525e-01f, -3.00232098e-02f, -5.63087966e-03f, -1.37911618e-01f, -2.83505112e-01f, -5.45898341e-02f, -7.78437331e-02f, 1.69107512e-01f, 5.66382834e-04f,
  1.96673006e-01f, 1.24769211e-01f, 8.57804995e-03f, -1.29396752e-01f, -6.27692118e-02f, -4.80557345e-02f, -5.42869531e-02f, -9.74796191e-02f, -9.03478041e-02f, 4.03382778e-02f,
  -1.48013711e-01f, -8.47299173e-02f, -3.16047631e-02f, -1.20162256e-01f, 5.46942279e-02f, 5.48069440e-02f, -2.43144725e-02f, -1.79555062e-02f, -3.74288186e-02f, 1.02843195e-01f,
  -6.93993121e-02f, 4.82327007e-02f, 1.02962159e-01f, 2.62675565e-02f, 2.45032813e-02f, 4.82112430e-02f, 3.80017736e-04f, 8.99659768e-02f, 4.63798270e-02f, -5.92859238e-02f,
  1.46798506e-01f, 1.07521778e-02f, -2.04549823e-02f, 1.08352955e-02f, 2.63263937e-02f, 4.87492420e-02f, 4.78308015e-02f, -5.54499216e-02f, -3.73836868e-02f, 1.54879177e-02f,
  -4.68735993e-02f, 8.84824693e-02f, -1.62198078e-02f, -3.58051956e-02f, -3.76692340e-02f, 1.09350622e-01f, -7.16540962e-02f, -3.02889501e-03f, -2.01810487e-02f, -4.05782349e-02f,
  -9.94564220e-02f, 5.45428433e-02f, -1.04542427e-01f, -2.09743995e-02f, 8.29122514e-02f, -6.01856261e-02f, -6.40638769e-02f, -3.56658958e-02f, -1.02793667e-02f, 8.24929848e-02f,
  -3.93011570e-01f, -5.95335662e-03f, -2.86704600e-02f, -3.18689533e-02f, -3.44723798e-02f, -1.94766943e-03f, -1.31490100e-02f, -6.33256603e-03f, 5.02445623e-02f, 1.63557045e-02f,
  1.95254516e-02f, 1.21710133e-02f, -8.78934041e-02f, -3.17338016e-03f, -6.11893646e-02f, -3.73210609e-02f, 1.03717092e-02f, -4.86434028e-02f, 1.24559924e-02f, 2.35783309e-03f,
  9.99946799e-03f, 1.52964473e-01f, -7.43663236e-02f, -1.61129124e-02f, -4.82941046e-02f, 4.53221388e-02f, 1.34605984e-03f, -5.75280748e-02f, 3.00135519e-02f, -5.17770946e-02f,
  -4.12225038e-01f, 2.54742265e-01f, 3.04441392e-01f, 5.60577102e-02f, -1.09450035e-01f, -3.48222395e-03f, -5.09873815e-02f, -1.07155032e-01f, -1.36508554e-01f, 5.71055114e-02f,
  7.40848482e-02f, 4.51904759e-02f, 1.69891566e-01f, 1.39207542e-01f, 4.84217666e-02f, -8.20227712e-02f, -1.93439797e-01f, -9.57750455e-02f, 8.39004200e-03f, 9.96184051e-02f,
  5.45386188e-02f, 3.03684771e-02f, -8.07028264e-02f, 4.58833352e-02f, -4.79091667e-02f, 2.58875061e-02f, 1.05296873e-01f, -5.27606718e-02f, 8.19249451e-03f, 7.74293095e-02f,
  5.91341138e-01f, -6.26433194e-02f, 7.76193142e-02f, -1.39706984e-01f, -4.97753918e-02f, -2.19850801e-02f, 5.87262921e-02f, 1.03789456e-02f, -9.20217708e-02f, -4.78657428e-03f,
  -5.42791747e-02f, -5.22124656e-02f, -2.09427569e-02f, -1.35723036e-02f, -6.22980110e-02f, -3.78172062e-02f, -2.28219144e-02f, 5.85248545e-02f, -6.31954148e-02f, 1.19180769e-01f,
  -9.85583737e-02f, 2.82204803e-03f, 1.23954527e-01f, 5.90315796e-02f, -2.27953233e-02f, -8.22686553e-02f, 3.79743874e-02f, -7.96922520e-02f, -4.45395447e-02f, 6.32232800e-02f,
  -2.52146758e-02f, -9.25699808e-03f, -3.44391651e-02f, -1.35915063e-03f, 2.30281986e-02f, 3.59555408e-02f, -1.33231068e-02f, 3.11480593e-02f, -2.60538794e-02f, -5.69492094e-02f,
  6.48525208e-02f, -9.79494769e-03f, 5.99532463e-02f, -3.31571698e-03f, -1.01169705e-01f, 7.43288640e-03f, 8.94218311e-03f, 3.96134108e-02f, 8.63383263e-02f, 2.28296150e-03f,
  -2.26015151e-02f, 4.90020476e-02f, 1.16687613e-02f, 5.03553674e-02f, -1.11440532e-01f, 4.07430679e-02f, -1.16817445e-01f, -7.29009360e-02f, 2.06415299e-02f, -8.13480020e-02f,
  2.55179554e-01f, -1.57822326e-01f, 4.96432036e-02f, -7.97788128e-02f, -4.56090691e-03f, -5.31720407e-02f, 3.98881175e-02f, -8.30636418e-04f, -2.96857841e-02f, 6.99239671e-02f,
  1.12578096e-02f, -3.13463174e-02f, 2.45449692e-02f, -2.76027862e-02f, -2.86371130e-02f, -8.41627736e-03f, -1.29922569e-01f, 1.39318705e-01f, -7.31141269e-02f, 3.89956459e-02f,
  -1.25761434e-01f, -3.69909941e-03f, 7.28916451e-02f, 8.01519156e-02f, -5.59595972e-02f, -5.83301634e-02f, 1.38158038e-01f, 8.98424014e-02f, -3.32356431e-02f, 1.24737501e-01f,
  6.70039058e-02f, -1.26113936e-01f, -5.14759496e-02f, -1.49934784e-01f, -1.64190054e-01f, -2.69751161e-01f, -3.35542262e-01f, -1.64245799e-01f, -6.63454533e-02f, -1.87394187e-01f,
  2.96468288e-02f, 4.40438651e-02f, 9.27321687e-02f, 2.65356172e-02f, -2.75916345e-02f, -3.06633234e-01f, -2.79190242e-01f, -9.78802517e-03f, -1.79014110e-04f, -3.19391698e-01f,
  -2.32648343e-01f, -2.19413802e-01f, -4.27492149e-02f, -1.49011970e-01f, -1.26437142e-01f, 3.79456091e-03f, 6.65891692e-02f, -1.08015969e-01f, -2.30965272e-01f, -1.34421781e-01f,
  -4.96513322e-02f, 5.79390712e-02f, -3.25995609e-02f, -2.69169956e-02f, 3.46851498e-02f, -1.78092401e-02f, -1.23942629e-01f, -3.42939561e-03f, 1.06790140e-02f, -5.08140586e-02f,
  -3.99480797e-02f, -7.98696876e-02f, 1.43220238e-02f, 5.71539719e-03f, -1.06223822e-01f, -3.41627561e-02f, -9.15350169e-02f, -3.66701521e-02f, 1.43033555e-02f, -1.09086625e-01f,
  -9.22850519e-02f, -6.25774264e-02f, 4.71790172e-02f, -1.47300232e-02f, -1.26583964e-01f, -3.30022871e-02f, 5.37415929e-02f, -6.14180900e-02f, 2.79702544e-02f, -2.41625197e-02f,
  -1.47348076e-01f, 1.49797693e-01f, -9.20162424e-02f, 4.60037263e-03f, 1.96746405e-04f, 9.72232148e-02f, -4.69948687e-02f, -4.92234118e-02f, -8.80861804e-02f, 7.42881373e-02f,
  1.17707327e-02f, 2.44187918e-02f, 4.73320205e-03f, -7.71943596e-04f, 7.96145201e-02f, 5.82755245e-02f, -2.59215292e-02f, -4.04727198e-02f, 1.42919809e-01f, -5.79279251e-02f,
  2.58093271e-02f, -5.74075840e-02f, 7.22875670e-02f, -6.05267808e-02f, -3.48099247e-02f, 2.29899976e-02f, 4.31462675e-02f, 3.24661843e-02f, 9.31042880e-02f, -5.96837886e-02f,
  1.64227262e-01f, 1.73927531e-01f, 9.69306305e-02f, 1.50612807e-02f, -5.03289104e-02f, 5.89393005e-02f, 5.24326712e-02f, -6.63585514e-02f, 1.12547792e-01f, 1.63308103e-02f,
  1.14575196e-02f, -1.92491394e-02f, 1.42765343e-01f, 9.38797668e-02f, 2.64856964e-02f, 2.50657629e-02f, -4.44341227e-02f, -4.34365198e-02f, -8.69792327e-02f, -4.20021936e-02f,
  -4.14167158e-02f, 2.80430950e-02f, 1.71813726e-01f, 1.07192680e-01f, -8.15286487e-02f, 9.82688926e-03f, 1.72480464e-01f, -1.88867226e-02f, 1.43372968e-01f, 1.37514547e-01f,
  -1.07142583e-01f, 2.26770509e-02f, -1.02724090e-01f, 6.57892078e-02f, 1.12245604e-01f, 4.38751690e-02f, 7.07518682e-02f, 1.32371567e-03f, -2.27385163e-02f, 6.70315921e-02f,
  1.36145055e-02f, 1.84835605e-02f, 1.23241082e-01f, 1.41258404e-01f, 1.59050211e-01f, 8.59869570e-02f, 9.13900733e-02f, -1.58149004e-02f, -7.15072975e-02f, -7.19871894e-02f,
  1.50038777e-02f, 4.70064320e-02f, -1.39838494e-02f, -1.13503285e-01f, 7.82140158e-03f, 7.72301033e-02f, -2.34053042e-02f, -6.30986318e-02f, -7.33336061e-02f, 3.74698006e-02f,
  -2.15204880e-01f, 7.25175301e-03f, 5.87643795e-02f, -6.70043975e-02f, 1.44606875e-02f, -7.02434331e-02f, -8.78032148e-02f, -1.15179271e-01f, 5.60543174e-03f, -2.85368208e-02f,
  -3.95639380e-03f, -7.44357780e-02f, 4.19730991e-02f, -1.65171534e-01f, -2.14098580e-02f, -2.07150690e-02f, -7.22852815e-03f, 1.10667899e-01f, 7.21747801e-02f, -5.71823344e-02f,
  1.25041315e-02f, 1.40795195e-02f, -7.27186948e-02f, -8.06680471e-02f, 6.90213963e-02f, -1.77151132e-02f, 2.88591324e-03f, -8.70828032e-02f, 3.18209827e-02f, -1.38548672e-01f,
  -8.48271325e-03f, 4.33339318e-03f, 3.28761041e-02f, 3.73634808e-02f, -5.56033887e-02f, 1.63890366e-02f, -6.41258061e-02f, -3.16630490e-03f, 8.39792415e-02f, 1.88154392e-02f,
  -4.79632467e-02f, -2.04225071e-02f, 6.04436286e-02f, 4.71092761e-02f, 6.10170588e-02f, -6.17290847e-02f, 5.07914051e-02f, 6.36620447e-02f, -5.99889979e-02f, 5.95004447e-02f,
  -3.75615656e-02f, 5.86921573e-02f, -3.44172004e-03f, -5.84884062e-02f, 7.02078119e-02f, 5.56367524e-02f, -7.15613738e-02f, -6.77992776e-02f, -6.75539002e-02f, -6.91614226e-02f,
  4.04868834e-02f, 1.34359360e-01f, 6.48855651e-03f, 9.11809132e-02f, 8.45735967e-02f, 3.85122970e-02f, 6.78434595e-02f, 7.12367371e-02f, -5.74810617e-02f, 1.34622899e-03f,
  -4.74258848e-02f, 1.16356593e-02f, -7.43535012e-02f, -4.86073978e-02f, -2.12855414e-02f, 2.22802926e-02f, 7.19431192e-02f, 8.77086222e-02f, 4.56977710e-02f, 9.28236265e-03f,
  -9.75195691e-03f, 2.18096003e-02f, -9.38524231e-02f, 5.83260208e-02f, -5.23835272e-02f, 1.07383050e-01f, 5.75393774e-02f, -1.39122214e-02f, 9.26583856e-02f, -1.12591267e-01f,
  -3.21439505e-02f, -2.47564707e-02f, -4.95255925e-02f, -8.17485228e-02f, -6.56904206e-02f, -3.87346484e-02f, -9.19049531e-02f, 4.58157286e-02f, 7.04077035e-02f, -1.00246057e-01f,
  1.29633807e-02f, 1.05568193e-01f, 5.05857430e-02f, 6.73132464e-02f, 8.60987157e-02f, 1.29141167e-01f, 1.36083022e-01f, 9.96650755e-02f, -3.74784209e-02f, 5.92700541e-02f,
  2.41320883e-03f, 1.53014138e-02f, 3.13939527e-02f, -6.13522641e-02f, -1.90698244e-02f, -1.28854904e-02f, 1.59009844e-02f, -1.21751782e-02f, 1.14685424e-01f, 4.10069004e-02f,
  5.51903434e-02f, 1.27477154e-01f, -7.04320287e-03f, 9.17716883e-03f, 8.95342454e-02f, -9.14533958e-02f, 1.13533482e-01f, -4.45372984e-02f, -2.88208611e-02f, -9.99873504e-03f,
  6.75304756e-02f, 3.51600572e-02f, -1.15267670e-04f, 1.22752227e-01f, -5.89611344e-02f, -3.61424610e-02f, -2.89262459e-02f, -3.51298228e-02f, 9.87915769e-02f, -3.88512178e-03f,
  -4.12040539e-02f, -1.51396552e-02f, 7.65246674e-02f, 3.09646521e-02f, -4.03764285e-02f, 8.81199390e-02f, 3.61702777e-02f, 4.76799756e-02f, 1.39665559e-01f, 8.82797539e-02f,
  -5.37550375e-02f, -7.02708215e-03f, -6.14787675e-02f, 5.79152480e-02f, -1.28119569e-02f, 4.23082151e-02f, 1.16511364e-03f, -6.03008755e-02f, 4.44150902e-02f, -1.99053138e-02f,
  4.70075523e-03f, -2.86536533e-02f, 8.35166033e-03f, 4.07346264e-02f, -4.26844433e-02f, 3.04631274e-02f, 1.58716496e-02f, -2.21954557e-04f, -3.36378999e-02f, 3.54846865e-02f,
  -9.72669348e-02f, -2.85038985e-02f, -6.22704662e-02f, 7.02200457e-02f, -3.32872011e-02f, 3.04687694e-02f, -8.53654835e-03f, 2.44252868e-02f, 1.77605115e-02f, 3.20359468e-02f,
  5.05348817e-02f, -3.10873389e-02f, 1.01782046e-01f, 4.60802130e-02f, 3.48329544e-02f, -1.43182995e-02f, 1.24765178e-02f, 4.07999121e-02f, 4.96948808e-02f, 2.63158493e-02f,
  -2.63208747e-02f, 8.07425082e-02f, -1.17528290e-02f, 6.97045550e-02f, -1.33794069e-03f, 1.41358760e-03f, 8.65164548e-02f, 3.74226458e-02f, 2.23060381e-02f, 3.28122079e-02f,
  -2.34237816e-02f, 5.34808300e-02f, 2.82076020e-02f, -1.70957893e-02f, -1.31064281e-02f, 2.09352989e-02f, 2.44229138e-02f, 1.31927013e-01f, 1.09451808e-01f, -1.24504499e-01f,
  -2.12633714e-01f, -2.01506503e-02f, -2.83420999e-02f, 3.74148220e-01f, 3.57445031e-01f, 4.10219073e-01f, 2.50916392e-01f, 2.58406073e-01f, 1.03425995e-01f, 4.36526276e-02f,
  1.15638465e-01f, 2.29955211e-01f, 3.21637571e-01f, 2.76523203e-01f, 1.43977612e-01f, 1.76077217e-01f, 3.29773754e-01f, 2.33903695e-02f, -8.88425484e-02f, 8.08810294e-02f,
  2.19928488e-01f, 5.38472645e-02f, -1.19350061e-01f, -6.18546177e-03f, 6.78424761e-02f, 1.83129907e-01f, 9.49675217e-02f, -3.50173078e-02f, -1.70022510e-02f, 1.84710935e-01f,
  -1.98712513e-01f, 3.84437889e-02f, 1.28014445e-01f, -4.13795076e-02f, -1.01317391e-01f, -2.31188625e-01f, -7.04653263e-02f, -2.42567033e-01f, -5.23190759e-02f, -8.49816576e-02f,
  -6.40548766e-02f, -8.66952166e-02f, 2.64175851e-02f, 2.46244371e-02f, -9.94257182e-02f, -9.38487649e-02f, -9.53611061e-02f, -1.19613782e-01f, 1.08642466e-02f, -3.24039347e-02f,
  2.01843649e-01f, -3.29825468e-02f, -1.49400523e-02f, 7.33895525e-02f, 5.25622405e-02f, 4.65829074e-02f, 1.91492289e-02f, 2.20164955e-02f, -1.52091816e-01f, -3.09044365e-02f,
  1.74356058e-01f, -7.27682561e-02f, -2.44438294e-02f, -4.96892678e-03f, 5.32817431e-02f, 9.52167902e-03f, 4.56929952e-03f, 5.32888435e-03f, -1.08157238e-02f, -6.69903159e-02f,
  2.95758024e-02f, 2.93814838e-02f, -8.97139776e-03f, 5.12269326e-02f, 8.07337984e-02f, -4.45095710e-02f, 7.34044984e-02f, 1.81785114e-02f, -1.08493716e-02f, -6.81636781e-02f,
  4.31357604e-03f, -4.08366211e-02f, -3.76987942e-02f, -5.61784133e-02f, -2.27350891e-02f, 6.01531416e-02f, 3.64160389e-02f, 7.03409687e-02f, 9.53122899e-02f, 1.18771577e-02f,
  -1.71921238e-01f, 2.52362847e-01f, 3.25090289e-02f, -8.76918286e-02f, -8.40671808e-02f, -7.95652866e-02f, 6.89032152e-02f, -8.65629539e-02f, -9.66555551e-02f, 6.41849637e-02f,
  -1.35297760e-01f, 7.65260868e-03f, 1.05366865e-02f, -6.82442486e-02f, -1.62160069e-01f, -1.78042671e-03f, 3.11990920e-02f, 9.43165570e-02f, 8.18567947e-02f, -9.18391719e-03f,
  1.74004491e-02f, 3.46254259e-02f, -1.56289056e-01f, 1.82428602e-02f, -1.01751590e-03f, 5.68532720e-02f, -1.13425419e-01f, -9.00176093e-02f, -4.03136946e-03f, -1.15344457e-01f,
  3.12738083e-02f, 2.53183283e-02f, 2.29774490e-01f, -1.38809547e-01f, -8.90273303e-02f, 2.87414305e-02f, 6.62645232e-03f, 2.68130042e-02f, -2.10012689e-01f, -1.98063739e-02f,
  -1.11069940e-01f, -2.18178928e-01f, -1.44376591e-01f, 6.44186288e-02f, 1.42469153e-01f, 1.31177410e-01f, 1.04848325e-01f, 1.69588298e-01f, 5.10055646e-02f, -4.98055806e-03f,
  3.69508713e-02f, 4.21519950e-02f, 9.43829268e-02f, 8.02352354e-02f, -2.22636089e-02f, -1.41746458e-02f, 1.05918929e-01f, 1.01927910e-02f, 9.60611925e-02f, -4.95542847e-02f,
  4.73753028e-02f, 1.49128854e-01f, -8.84966627e-02f, -1.26679465e-02f, 6.83362782e-02f, -7.08748773e-02f, 2.43685930e-03f, -3.29627916e-02f, -1.85287334e-02f, -9.95744318e-02f,
  -3.61099914e-02f, 5.19358031e-02f, -7.75029999e-04f, -1.13194063e-02f, 3.30535620e-02f, -1.20702296e-01f, 3.33308540e-02f, 1.51840180e-01f, 1.51207834e-01f, 5.79393432e-02f,
  -1.32039832e-02f, 2.63464171e-02f, -5.91562130e-02f, -3.62836458e-02f, 7.74570107e-02f, -2.21303310e-02f, -2.02227551e-02f, -8.97816420e-02f, 1.65916771e-01f, -2.49170903e-02f,
  1.81194730e-02f, 1.88918412e-02f, -8.68959259e-03f, 6.42276481e-02f, -1.50938351e-02f, -4.30079959e-02f, -2.92193647e-02f, -5.44324629e-02f, -8.12750251e-04f, -8.30987245e-02f,
  -8.87268037e-02f, 7.56048784e-02f, -6.98639229e-02f, 1.19694155e-02f, -9.97334346e-02f, -2.63623018e-02f, 5.93644753e-02f, -2.27160566e-02f, 1.06304012e-01f, 5.03832139e-02f,
  -8.16826429e-03f, 3.02595575e-03f, 4.10938822e-02f, 8.84601548e-02f, 2.06565112e-02f, -3.37486379e-02f, -1.10864230e-01f, 8.22466239e-03f, 1.45865446e-02f, -1.82534512e-02f,
  -5.83480559e-02f, 1.84200346e-01f, -3.79432552e-02f, -4.89724539e-02f, 5.96620329e-02f, -7.18743950e-02f, -1.42768115e-01f, -1.06250532e-01f, -7.31311813e-02f, -7.86680207e-02f,
  -1.19951978e-01f, -3.26710790e-02f, 4.44264803e-03f, -6.27581030e-03f, -6.89913929e-02f, -9.71030220e-02f, 7.44739128e-03f, 6.47706166e-03f, 4.00097892e-02f, 2.15294259e-03f,
  -1.28324136e-01f, -1.39276475e-01f, -1.46985576e-01f, 2.49834992e-02f, -8.45563933e-02f, -1.57678276e-01f, -9.32955742e-02f, -1.10247061e-01f, -2.84872726e-02f, -1.14270687e-01f,
  -3.53893638e-01f, 1.26211286e-01f, 1.73045605e-01f, 1.14096701e-01f, -1.27491904e-02f, -1.55084133e-01f, -2.46653065e-01f, -1.80753946e-01f, 3.31348777e-02f, 7.59873912e-03f,
  -1.41618192e-01f, -1.85692057e-01f, -1.55393094e-01f, -6.65275007e-02f, -1.64547622e-01f, 4.75119501e-02f, 3.00621271e-01f, 1.15431182e-01f, -2.18807667e-01f, -2.63229579e-01f,
  1.67239413e-01f, 3.47924009e-02f, -2.00766865e-02f, -3.48915569e-02f, 2.15610102e-01f, -1.49956373e-02f, 1.38451681e-01f, 1.91109642e-01f, -8.56883600e-02f, 8.49068165e-01f,
  9.59804934e-03f, 3.14984322e-02f, -6.71214163e-02f, -3.59650254e-02f, 2.98390780e-02f, -4.22416441e-02f, -1.28498077e-01f, 1.20677784e-01f, -1.37910292e-01f, 1.25916554e-02f,
  8.24803934e-02f, -8.25328603e-02f, 1.16630681e-01f, 1.45702260e-02f, -2.57469378e-02f, -5.41135557e-02f, 7.20844716e-02f, 1.00415304e-01f, 6.66501671e-02f, 8.39680806e-02f,
  1.86345458e-01f, 2.39833184e-02f, -8.78619701e-02f, -1.60971865e-01f, 3.52574922e-02f, -1.01219164e-02f, 4.25940044e-02f, 5.49014360e-02f, -9.09005404e-02f, 1.46249413e-01f,
  4.99827936e-02f, 5.31591941e-03f, -2.65123378e-02f, 9.46744252e-03f, -4.97969985e-02f, -1.08942995e-03f, 1.09506667e-01f, -5.91140389e-02f, 4.04477939e-02f, -7.90217668e-02f,
  5.65062240e-02f, -2.41739042e-02f, 4.03258950e-03f, -4.09899876e-02f, 6.84719952e-03f, 5.41044362e-02f, -2.92184465e-02f, 6.40491489e-03f, -1.39726885e-02f, -1.59748662e-02f,
  -4.06846888e-02f, 3.56244855e-02f, -3.80807146e-02f, 2.52548736e-02f, 8.52527935e-03f, 6.00829720e-02f, 2.07723062e-02f, -6.46834224e-02f, -1.57906376e-02f, 6.44839853e-02f,
  -1.82853207e-01f, -1.93567649e-01f, -1.09444834e-01f, -7.48716518e-02f, 5.20152859e-02f, 3.27105038e-02f, 2.99664419e-02f, 6.67552501e-02f, 2.79473985e-04f, -2.39034574e-02f,
  -2.10737716e-02f, -1.83130931e-02f, -4.51419167e-02f, 1.08516531e-03f, -1.54284179e-01f, -5.96693135e-04f, -1.77662764e-02f, -6.31230250e-02f, -4.21688631e-02f, 1.53062880e-01f,
  -1.00600831e-02f, -2.13836238e-01f, -4.49447215e-01f, -1.33116663e-01f, 1.98762827e-02f, -3.66578698e-01f, -2.34179989e-01f, -2.40473285e-01f, -4.38733816e-01f, -3.46976370e-01f,
  -6.51098311e-01f, -2.22744480e-01f, 5.73447496e-02f, -1.62407503e-01f, -6.41542599e-02f, -1.31071720e-03f, -2.44710058e-01f, -1.15664415e-02f, -1.36254001e-02f, -3.07148665e-01f,
  -6.54989555e-02f, -1.20528787e-01f, -2.14101031e-01f, 7.79177099e-02f, 4.72961627e-02f, -1.51326209e-01f, -1.67246833e-01f, 4.57044356e-02f, 1.43088222e-01f, 2.68831104e-01f,
  1.09651223e-01f, -1.61441916e-03f, 1.18371941e-01f, 2.74519742e-01f, -2.04583421e-01f, 1.21487537e-02f, -1.02907233e-01f, -6.06885366e-02f, -3.58134881e-02f, -5.91032386e-01f,
  -1.95152432e-01f, -8.81395265e-02f, 9.38392878e-02f, -9.04143900e-02f, -2.81655439e-03f, -8.00976604e-02f, -2.30264328e-02f, -1.85066822e-03f, 1.29380403e-02f, -9.67063606e-02f,
  2.11063270e-02f, 4.35744338e-02f, 4.69247922e-02f, 5.39726801e-02f, -5.76529428e-02f, -1.35532707e-01f, 4.75735366e-02f, 7.47885182e-02f, 1.08318347e-02f, 8.45454410e-02f,
  4.35582325e-02f, -5.96774779e-02f, -1.97271809e-01f, 1.09503612e-01f, 9.68845338e-02f, 9.66866463e-02f, 1.01915665e-01f, 1.64030343e-02f, -2.57604532e-02f, -2.50128984e-01f,
  -6.43401220e-02f, 3.33852768e-02f, 3.48288566e-03f, -3.60241719e-02f, -6.54701367e-02f, 1.68420244e-02f, 2.84701176e-02f, -6.07688092e-02f, 5.16650565e-02f, -7.58527294e-02f,
  9.84081626e-02f, -8.90979450e-03f, 5.45741990e-02f, -9.42012761e-03f, -6.29069507e-02f, 5.76250628e-02f, 2.39974968e-02f, -5.88087440e-02f, 3.98237482e-02f, 2.61998852e-03f,
  -3.11641637e-02f, -6.38250336e-02f, 6.60936683e-02f, 3.37806307e-02f, -1.97980888e-02f, 8.55877548e-02f, 2.34747361e-02f, -1.47815198e-02f, -2.46141665e-02f, 1.61376763e-02f,
  -2.52065688e-01f, 2.70168662e-01f, -2.61872083e-01f, -3.77563611e-02f, -4.67535965e-02f, 3.61968167e-02f, -2.93826945e-02f, 8.99510384e-02f, -3.14739682e-02f, 3.83350835e-03f,
  2.69323606e-02f, -7.67209306e-02f, -1.97733678e-02f, 3.94055471e-02f, -2.20775306e-02f, 1.45347361e-02f, 1.16692549e-02f, -1.04102857e-01f, -3.98659520e-02f, 7.28305951e-02f,
  -1.02883838e-01f, -2.08887488e-01f, -4.45321888e-01f, -2.39985704e-01f, -3.07898931e-02f, -3.21484953e-01f, -2.44000643e-01f, -2.54461825e-01f, -3.37536335e-01f, -4.62320119e-01f,
  -7.15673447e-01f, 1.85603753e-01f, -4.28824984e-02f, -2.89119989e-01f, -1.46744922e-01f, 1.03960950e-02f, -4.34207693e-02f, 5.46502545e-02f, -6.11000657e-02f, -6.28155172e-02f,
  4.65619564e-02f, 1.35201849e-02f, -5.97695559e-02f, 5.23613878e-02f, -8.29388052e-02f, -9.43065137e-02f, -5.41056395e-01f, -4.17980909e-01f, -5.10960855e-02f, 1.31485686e-01f,
  -2.79395767e-02f, -4.13874209e-01f, -3.73854548e-01f, -9.01115984e-02f, 1.20280914e-01f, 3.36086452e-02f, -1.89542830e-01f, -9.37631577e-02f, 2.37798274e-01f, -2.45579332e-01f,
  1.95772409e-01f, -3.75357121e-02f, 5.49042225e-02f, -1.28840923e-01f, 3.07360943e-02f, -4.10066498e-03f, 2.01796852e-02f, -1.05530545e-01f, 1.87718254e-02f, 7.10869208e-02f,
  -2.73302142e-02f, 7.80577585e-03f, -2.05854923e-02f, 3.05757336e-02f, 1.84017867e-02f, -3.59050818e-02f, 4.02717963e-02f, -1.99922025e-02f, -1.41369170e-02f, 9.68519971e-02f,
  1.28708318e-01f, -4.38493351e-03f, -6.54892102e-02f, 1.61477581e-01f, 9.21027958e-02f, -1.68453544e-01f, 2.57960975e-01f, 1.87807098e-01f, 8.92265141e-02f, 2.26300225e-01f,
  9.45750475e-02f, 6.16340488e-02f, -1.66241734e-04f, -2.45688832e-03f, 5.92284696e-03f, 1.33458730e-02f, 2.42332518e-02f, 1.35479579e-02f, -3.83376256e-02f, 4.14347127e-02f,
  -3.74269821e-02f, 1.39826192e-02f, 2.22584438e-02f, -2.20486429e-02f, -1.30311102e-02f, -9.59154218e-04f, -9.87798050e-02f, 8.12679455e-02f, -3.16353329e-02f, 2.64289267e-02f,
  4.13939431e-02f, 1.37863800e-01f, -8.91712457e-02f, 1.07635021e-01f, -1.79584511e-02f, -6.95923762e-03f, -7.24477693e-02f, 6.85704965e-03f, 1.30775860e-02f, -1.00705177e-01f,
  5.95042855e-02f, -1.84830219e-01f, -5.06127030e-02f, 3.10355816e-02f, 2.59121489e-02f, 2.03857291e-02f, -1.15957465e-02f, 6.65119588e-02f, 5.16977720e-02f, 1.09630320e-02f,
  5.04176579e-02f, -1.45309255e-03f, 1.64101627e-02f, 3.33592854e-03f, -2.04495359e-02f, 4.38408367e-02f, -5.25472388e-02f, -8.23940337e-02f, 1.94785576e-02f, 4.58850004e-02f,
  4.26000096e-02f, 1.27360607e-02f, -8.43793899e-02f, 6.88328594e-02f, -4.59909206e-03f, -1.41194046e-01f, -1.11481445e-02f, 7.47488588e-02f, -9.07605439e-02f, -3.91089693e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -8.71904492e-02f, 1.89328492e-02f, 8.61308202e-02f, 6.74625561e-02f, 2.64982343e-01f, -6.20202124e-02f, 2.29027867e-01f, 2.10532710e-01f, -7.13943392e-02f, 1.28248587e-01f,
  1.96595967e-01f, 4.82283890e-01f, 3.31804901e-01f, 1.89793169e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -3.80305588e-01f, -4.64019068e-02f, 2.98473656e-01f, 2.32690111e-01f, -3.95968169e-01f, 5.47284484e-01f, 2.25227222e-01f, -4.04265672e-01f, -1.64412856e-01f, -2.17748374e-01f,
  -2.80114040e-02f, -9.09595266e-02f, 2.48496775e-02f, -3.29524130e-01f, 5.93262970e-01f, -6.42357469e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  7.60822073e-02f, -2.52237320e-01f, -6.08027101e-01f, -1.41470209e-01f, 3.98268968e-01f, -5.76733410e-01f, 3.37858200e-01f, 1.15916459e-02f, 4.04308587e-01f, -7.40334541e-02f,
  1.59370929e-01f, 9.36313421e-02f, 4.78403062e-01f, 8.44748795e-01f, 1.07917301e-01f, -3.27625811e-01f, -2.33827382e-01f, -1.63498104e-01f, 5.58637977e-02f, -1.47725537e-01f,
  -8.25951025e-02f, -1.45621315e-01f, -1.27675042e-01f, -1.61326587e-01f, 1.14228968e-02f, -8.76800418e-02f, 6.17955849e-02f, -1.91393271e-01f, 1.04951389e-01f, 7.08191320e-02f,
  3.14813405e-01f, 2.83722520e-01f, 2.21768096e-02f, 2.29661599e-01f, 2.54801214e-01f, -1.15193412e-01f, 1.27064779e-01f, 3.30535948e-01f, -2.19715224e-03f, 2.10709363e-01f,
  -1.32369921e-01f, 2.79084384e-01f, 9.96179283e-02f, 6.62706852e-01f, 9.27900001e-02f, -8.94947648e-02f, 2.63353407e-01f, 2.78673172e-01f, 1.23138927e-01f, -7.22519762e-04f,
  -5.30224629e-02f, 1.67124301e-01f, -1.66853040e-01f, -1.85451984e-01f, -3.93775642e-01f, 1.43916175e-01f, -4.00519967e-02f, 2.31527507e-01f, 2.82025844e-01f, 1.67051941e-01f,
  -9.22360644e-02f, 8.08469534e-01f, 3.08060855e-01f, -1.09481670e-01f, 7.91020215e-01f, 2.03734145e-01f, -2.14856684e-01f, 1.95451766e-01f, -1.56099990e-01f, 4.81041491e-01f,
  6.80273622e-02f, -1.08620048e-01f, 1.56427264e-01f, 1.66278601e-01f, -2.48821691e-01f, -8.31838474e-02f, 3.78755890e-02f, -1.27377093e-01f, 1.23719203e+00f, 9.43925738e-01f,
  -2.78752297e-01f, 1.59267023e-01f, 2.49416064e-02f, -2.07833260e-01f, 1.83191806e-01f, 6.29544072e-03f, 5.11776567e-01f, -4.22628582e-01f, -1.92708477e-01f, 9.79760513e-02f,
  -1.92832172e-01f, 5.88526905e-01f, 2.07294956e-01f, 1.15949072e-01f, 3.41694862e-01f, 5.11562884e-01f, -2.02322066e-01f, 3.69183980e-02f, -1.68268338e-01f, 2.32064113e-01f,
  -1.38743877e-01f, -1.07965611e-01f, 9.10503194e-02f, -1.66936204e-01f, -1.96069747e-01f, -1.08566537e-01f, 7.26426318e-02f, -1.93867728e-01f, 7.52473623e-02f, 1.84478723e-02f,
  -7.20668286e-02f, -1.03794947e-01f, 4.27008182e-01f, -1.20376665e-02f, -8.22440237e-02f, 1.66073501e-01f, -1.48379982e-01f, -2.05591202e-01f, -1.55623108e-01f, -1.64642304e-01f,
  1.65931553e-01f, 7.34143192e-03f, -1.70817450e-01f, -3.00537609e-02f, 2.29464456e-01f, 3.78570408e-01f, 5.82178533e-01f, 6.33776039e-02f, 3.44419897e-01f, 3.12012792e-01f,
  -2.79255956e-01f, 2.31951088e-01f, -1.84494540e-01f, 1.32219270e-01f, -2.41991758e-01f, 4.69894528e-01f, 3.68756384e-01f, -2.60265201e-01f, 8.55801255e-02f, -1.37299478e-01f,
  -4.87959348e-02f, -1.68128997e-01f, 2.10545540e-01f, 4.25471067e-01f, 4.47220773e-01f, 2.16836229e-01f, 2.39176899e-02f, 2.53331572e-01f, 2.65136629e-01f, -1.07644007e-01f,
  -2.75165707e-01f, 4.90776420e-01f, 2.52795011e-01f, -9.87717137e-03f, -6.48523420e-02f, -2.00562090e-01f, -2.81523347e-01f, -3.26953381e-01f, -7.65810981e-02f, 4.33333844e-01f,
  2.57308811e-01f, 6.37643486e-02f, -1.94412291e-01f, -2.64479090e-02f, -2.19519556e-01f, -1.21896334e-01f, -2.63815045e-01f, -5.79366945e-02f, 1.15305604e-02f, 3.43266279e-02f,
  3.36557664e-02f, 7.08881095e-02f, 1.39480820e-02f, 6.82417035e-01f, 1.57661706e-01f, -1.78680733e-01f, -6.60399571e-02f, -5.21005653e-02f, 4.59984057e-02f, 4.26159538e-02f,
  -5.66455768e-03f, -1.84692666e-01f, -1.52815372e-01f, 1.54977128e-01f, -2.05521826e-02f, 1.06343172e-01f, -1.66594952e-01f, 4.03072357e-01f, -8.48412737e-02f, 4.72183466e-01f,
  7.51918331e-02f, -1.84791028e-01f, -2.70167261e-01f, -2.00582013e-01f, -2.39128619e-02f, -3.09274763e-01f, 5.48564374e-01f, 4.73924011e-01f, 8.31444025e-01f, -9.16489661e-02f,
  3.36261421e-01f, 1.66961715e-01f, -1.15118176e-01f, -3.81123334e-01f, 5.45104086e-01f, 4.96611707e-02f, -3.60445976e-02f, 1.17572844e-02f, 1.89430237e-01f, 5.25529265e-01f,
  -2.49294192e-02f, 2.29526639e-01f, -3.17137539e-01f, -3.09350546e-02f, -5.65985799e-01f, 2.95270354e-01f, 8.29914927e-01f, 3.47150475e-01f, -1.62166253e-01f, 6.54634178e-01f,
  -9.29187387e-02f, 5.99164724e-01f, -1.78501204e-01f, 3.03569108e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.16159719e-01f, 9.04940218e-02f, -1.42404795e-01f, 2.21682832e-01f, 3.80824327e-01f, 8.52727517e-03f, 9.33846757e-02f, 3.24939728e-01f, 2.70663708e-01f, 1.01351500e-01f,
  1.90453947e-01f, -6.42317235e-02f, 3.44813079e-01f, 3.69523495e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.24994881e-01f, 1.81362480e-01f, 1.61652684e-01f, -8.96850154e-02f, -3.54002774e-01f, -4.09067161e-02f, -4.15242195e-01f, -3.66927266e-01f, -3.14125349e-03f, 1.87972128e-01f,
  -6.88739568e-02f, -2.58052558e-01f, -1.03837503e-02f, 7.42721260e-02f, 4.35903035e-02f, 1.32863432e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.03355283e-01f, -1.23053476e-01f, 7.81641126e-01f, -6.07945547e-02f, -2.53243774e-01f, 6.85541987e-01f, 1.17278285e-01f, -1.64492607e-01f, 8.30005854e-02f, 4.31140184e-01f,
  -2.56783694e-01f, -2.25718647e-01f, 6.06588304e-01f, 3.48609447e-01f, -3.82051349e-01f, 3.07892621e-01f, 5.85564710e-02f, -1.30491154e-02f, -1.84175745e-01f, -2.13304415e-01f,
  -3.40389833e-02f, -1.41105905e-01f, 1.29071727e-01f, -1.43529430e-01f, -5.14176348e-03f, -5.33585176e-02f, -1.91696092e-01f, -8.56532995e-03f, -1.81452900e-01f, -3.71321067e-02f,
  1.91258475e-01f, -2.37077072e-01f, -9.53012183e-02f, 2.46035770e-01f, -8.36790875e-02f, 1.80670381e-01f, 2.93907613e-01f, 9.05819014e-02f, -7.78169408e-02f, -2.69664228e-01f,
  -4.71698605e-02f, 2.05051228e-01f, -3.91742811e-02f, 1.69423804e-01f, -1.09673902e-01f, -2.43562579e-01f, 1.59480006e-01f, 8.71755928e-02f, 3.26134861e-01f, 6.92212045e-01f,
  1.55247882e-01f, 1.82708159e-01f, -1.99537218e-01f, -2.43401423e-01f, 6.30720973e-01f, 4.71961915e-01f, 2.38651425e-01f, 4.81323898e-01f, 6.85601383e-02f, -4.16999072e-01f,
  2.11218774e-01f, 6.65799156e-02f, 5.39339662e-01f, -3.95830095e-01f, 6.21002734e-01f, 5.26834905e-01f, -3.47634286e-01f, 2.65046030e-01f, 1.88313171e-01f, -2.62432963e-01f,
  1.10226953e+00f, 6.91488624e-01f, 2.31819376e-01f, 1.33530185e-01f, 9.27379057e-02f, -9.89091843e-02f, -4.61302996e-01f, 4.56992276e-02f, 4.28500861e-01f, -4.67284862e-03f,
  8.71960759e-01f, -5.50877154e-01f, 1.16027415e+00f, -3.22320610e-01f, -1.47283420e-01f, 4.59960163e-01f, -5.43825924e-01f, -1.94033578e-01f, -7.08382055e-02f, 3.63821507e-01f,
  -3.71212363e-02f, 4.30710427e-02f, 3.84896845e-01f, 8.78439322e-02f, 3.93017709e-01f, 8.87083828e-01f, 2.11016268e-01f, -8.84836838e-02f, -3.47425222e-01f, -7.14914948e-02f,
  2.69601434e-01f, 4.10973877e-01f, 1.06540394e+00f, -1.14713535e-01f, -1.98461756e-01f, 4.92298961e-01f, 7.52503932e-01f, 4.68576729e-01f, -5.68760419e-03f, 3.18035394e-01f,
  -7.26909220e-01f, 7.10075855e-01f, -1.80765316e-01f, -2.69886330e-02f, 1.50074482e-01f, -1.77891716e-01f, -1.46409124e-01f, -1.80800781e-01f, 5.11607751e-02f, -1.25324979e-01f,
  -9.42624360e-02f, 7.01343492e-02f, -1.15209907e-01f, -1.81231778e-02f, -1.48391485e-01f, 2.24558547e-01f, -1.48691922e-01f, -1.41659200e-01f, -2.34153107e-01f, 2.37910300e-01f,
  1.67925850e-01f, -1.27194881e-01f, 5.74415803e-01f, 6.97012059e-03f, -1.52860120e-01f, 4.62286115e-01f, -1.28394991e-01f, 6.11595716e-03f, -2.95159191e-01f, -1.20956767e-02f,
  -9.18089151e-02f, 3.26013088e-01f, -2.18077451e-01f, 3.46022487e-01f, -2.29247406e-01f, -4.84707206e-02f, -9.99951139e-02f, -1.95853740e-01f, -1.70143489e-02f, 3.14475775e-01f,
  -6.64524809e-02f, -1.62962005e-02f, -2.26723433e-01f, -1.13680445e-01f, -5.25631830e-02f, 2.31845632e-01f, -2.26609409e-01f, 2.34887730e-02f, -1.99343905e-01f, 4.16218787e-02f,
  3.10772061e-01f, -3.55895936e-01f, -3.42317104e-01f, -1.77796364e-01f, -9.67458487e-02f, -2.62067109e-01f, 4.49256718e-01f, 1.07927136e-01f, 2.05268487e-01f, -8.92162882e-03f,
  5.04613280e-01f, 5.49768507e-01f, -4.36064862e-02f, 2.48159781e-01f, -3.43130380e-01f, 8.99510801e-01f, -2.25809261e-01f, -1.92469567e-01f, 4.93407696e-02f, -9.37727690e-02f,
  -9.63408351e-02f, -9.85558033e-02f, -1.66975871e-01f, 6.27731681e-02f, -1.81137794e-03f, -1.90545827e-01f, 4.86340970e-02f, 7.99358860e-02f, -2.24851176e-01f, 2.14792192e-01f,
  -2.32220188e-01f, -1.84351295e-01f, -1.30762920e-01f, 7.45263835e-03f, -1.57274783e-01f, 1.83928117e-01f, 8.71055797e-02f, -2.42295042e-01f, 8.84609669e-02f, 1.09003760e-01f,
  4.74358397e-03f, -1.57087192e-01f, -6.11497235e-05f, -1.95663437e-01f, -3.95701267e-02f, 1.26241460e-01f, -1.74636245e-01f, -1.00056469e-01f, 5.57415247e-01f, 1.40687943e-01f,
  1.88351363e-01f, -7.56268203e-02f, 3.00025731e-01f, -3.57289523e-01f, -1.96502969e-01f, 3.94276828e-01f, -1.89308584e-01f, -2.68862247e-01f, 3.16499859e-01f, 2.79331058e-01f,
  6.53602704e-02f, 4.68816198e-02f, 7.63080657e-01f, 1.47889912e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -1.13831222e-01f, -1.44111931e-01f, -1.26218840e-01f, 4.62583721e-01f, 6.55794322e-01f, 6.73095226e-01f, -9.33227167e-02f, 1.43074691e-01f, -6.35721385e-02f, -2.55359858e-01f,
  2.28784308e-01f, -1.73715666e-01f, 9.01255831e-02f, 2.51921177e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  4.05725315e-02f, 4.56884593e-01f, 5.82630141e-03f, 4.10554092e-03f, -3.73732865e-01f, 1.16050318e-01f, 2.58057207e-01f, -3.56962770e-01f, 1.79691687e-02f, 2.10560635e-01f,
  -1.04844652e-01f, 1.35425506e-02f, 1.22647859e-01f, -2.25556701e-01f, -5.67993559e-02f, -3.14811587e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.81678161e-01f, -7.23896325e-02f, -2.55202115e-01f, 1.59159735e-01f, 1.21331118e-01f, 1.11712985e-01f, -2.36292377e-01f, 1.26469538e-01f, -1.82723030e-01f, -5.36211580e-02f,
  1.79260328e-01f, 2.40124777e-01f, 1.40652344e-01f, 1.62042484e-01f, 1.39090404e-01f, -8.86176676e-02f, 5.30302644e-01f, -2.80004114e-01f, -1.12470478e-01f, 2.10195288e-01f,
  1.25475183e-01f, 1.69603586e-01f, -1.44749403e-01f, 6.01051450e-01f, -1.54666016e-02f, -1.08964056e-01f, -6.50546491e-01f, -2.27216527e-01f, 2.09815875e-01f, -1.24353528e-01f,
  1.19354352e-01f, -1.47972301e-01f, 3.47280949e-01f, 1.27511203e-01f, 1.39543908e-02f, 1.59677342e-01f, 1.35403395e-01f, -8.28022882e-02f, -1.75261691e-01f, 3.59986544e-01f,
  -1.24858376e-02f, 2.39138246e-01f, -5.04952259e-02f, 9.75042582e-02f, -2.07065418e-01f, -5.12063652e-02f, -1.85266649e-03f, 7.40806460e-02f, -2.27918968e-01f, 1.42314091e-01f,
  -6.21325970e-02f, 1.89970016e-01f, -5.60735948e-02f, -1.40436247e-01f, -3.60204503e-02f, 3.00307199e-02f, -1.76453725e-01f, -2.47249916e-01f, 3.12735438e-02f, 7.74275213e-02f,
  -1.46747440e-01f, 2.03336149e-01f, -6.55825958e-02f, -2.04118580e-01f, 8.48134995e-01f, -1.63793236e-01f, -9.86325070e-02f, 6.27089739e-02f, 6.95525631e-02f, 9.05775368e-01f,
  9.34358835e-01f, 2.54491538e-01f, -6.09656513e-01f, 1.51286557e-01f, -1.81328148e-01f, 1.71440691e-01f, -2.88655341e-01f, -6.37366176e-02f, 1.60250768e-01f, 6.43057644e-01f,
  6.51468337e-01f, -2.61263728e-01f, -5.05648434e-01f, 1.02455197e-02f, 1.15838293e-02f, 2.97225058e-01f, 9.37009394e-01f, -1.02368340e-01f, 1.62121370e-01f, -4.79341224e-02f,
  4.57358569e-01f, 1.03597261e-01f, 2.77553231e-01f, -1.19025536e-01f, 1.94801867e-01f, 1.66245714e-01f, -9.23596025e-02f, 2.48511732e-01f, 2.37335309e-01f, -2.18800399e-02f,
  2.46723592e-02f, -2.73166925e-01f, -4.57456291e-01f, 4.10981148e-01f, -8.58146176e-02f, 1.91808537e-01f, -2.30306849e-01f, 2.03708619e-01f, -6.15972281e-03f, -1.85366087e-02f,
  -1.35637103e-02f, -2.47281045e-01f, -1.33950248e-01f, 1.73529029e-01f, -1.83591530e-01f, 1.44077480e-01f, -1.09439557e-02f, 6.02953471e-02f, -4.09377106e-02f, 4.85597290e-02f,
  -8.62574354e-02f, -2.27307096e-01f, 1.96302757e-01f, 1.18172839e-02f, -2.48080209e-01f, -1.06105596e-01f, -1.28320800e-02f, -1.91644475e-01f, -5.04916668e-01f, -7.75494650e-02f,
  5.47136605e-01f, -1.63182437e-01f, -2.06348464e-01f, 5.94592750e-01f, 7.84580112e-01f, -3.92788380e-01f, 1.39871049e+00f, -1.46340623e-01f, 4.11759205e-02f, 2.37349555e-01f,
  2.68945634e-01f, -1.41093537e-01f, -4.40847278e-02f, -7.09228694e-01f, 3.00472856e-01f, -2.48864397e-01f, -3.37488502e-01f, -1.86678886e-01f, -2.29428321e-01f, 6.85767710e-01f,
  7.35148072e-01f, 3.35721880e-01f, -5.02045512e-01f, -2.24830732e-01f, -2.45397463e-01f, 1.99458033e-01f, -2.39835322e-01f, -2.26750702e-01f, -2.15253904e-01f, 5.04426777e-01f,
  4.58443820e-01f, 1.64217234e-01f, 7.37852275e-01f, -6.25941753e-02f, 1.93532944e-01f, 2.40861684e-01f, -1.39295403e-02f, 1.07794321e+00f, -1.64493024e-02f, 2.13313133e-01f,
  -5.13704121e-02f, -2.72887759e-02f, -4.95408446e-01f, -8.29731897e-02f, -2.41403535e-01f, -1.23473391e-01f, 4.30096209e-01f, -4.31148142e-01f, 7.33548343e-01f, -9.48682427e-02f,
  -1.10294364e-01f, -5.03187656e-01f, -3.38352025e-01f, 1.51268768e+00f, 1.41701847e-01f, 1.14081077e-01f, 2.96225637e-01f, -1.47764653e-01f, 2.64164686e-01f, 1.71588853e-01f,
  2.29192987e-01f, 2.99219042e-01f, -1.98296130e-01f, -5.05607903e-01f, -5.15838563e-01f, -1.23427898e-01f, -1.02758072e-01f, -5.77188313e-01f, 2.55438477e-01f, -2.42974274e-02f,
  9.98282075e-01f, 1.61997631e-01f, -2.28687748e-01f, 7.55824223e-02f, 1.17875457e+00f, -2.05510259e-01f, -3.03175505e-02f, 1.18631415e-01f, -1.22245438e-01f, -1.26884028e-01f,
  -2.44140372e-01f, 1.47316456e-01f, 1.93422318e-01f, -6.02876917e-02f, -2.06068963e-01f, -1.42350599e-01f, -2.08287239e-01f, -1.61371678e-02f, 1.13237947e-01f, 9.42891985e-02f,
  5.04079834e-02f, -1.50123805e-01f, 1.53606921e-01f, -2.33571514e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -8.09659585e-02f, 4.72216278e-01f, 4.06138092e-01f, -3.82776782e-02f, 7.71541238e-01f, 3.24459761e-01f, -1.24287717e-01f, -5.98681718e-02f, 2.99488958e-02f, 5.12268722e-01f,
  3.05366993e-01f, 4.92190301e-01f, 2.78041065e-01f, 2.04343960e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -7.08042026e-01f, -3.69707197e-01f, 1.37723505e-01f, -5.22770524e-01f, 1.25550255e-02f, 1.80442020e-01f, -6.32621467e-01f, 2.52369463e-01f, -1.35187387e-01f, -2.38785446e-01f,
  1.03060019e+00f, -5.33834875e-01f, -3.62485856e-01f, -9.82545733e-01f, 8.93645883e-02f, -2.48243645e-01f, 2.95983583e-01f, -3.44943523e-01f, 2.67257970e-02f, 1.36159778e-01f,
  -1.12686470e-01f, 6.81599900e-02f, -3.06440920e-01f, 4.93280798e-01f, 1.64211348e-01f, -1.52784035e-01f, -3.35545719e-01f, -2.00423717e-01f, -9.10319611e-02f, 6.33320510e-01f,
  4.51019377e-01f, -1.86528295e-01f, -5.83117530e-02f, -3.40057015e-01f, -6.02832576e-03f, 3.94971967e-01f, -1.13240056e-01f, 8.89596064e-04f, 2.45195448e-01f, -1.79234654e-01f,
  -4.23981190e-01f, -8.22592378e-02f, 4.61535424e-01f, 6.90688118e-02f, 4.51738119e-01f, 6.14822619e-02f, -5.06983399e-01f, -1.82109132e-01f, -5.41980624e-01f, 2.13941187e-01f,
  -1.48877382e-01f, -5.19443154e-01f, -1.81300625e-01f, -1.38574645e-01f, 3.23905289e-01f, 4.91619706e-01f, -1.91678628e-01f, 9.59109217e-02f, 5.27336061e-01f, 5.43931842e-01f,
  -2.16374263e-01f, -8.77891898e-01f, -5.36896698e-02f, 2.44347781e-01f, -2.73832440e-01f, 9.68314230e-01f, 1.97164163e-01f, -2.49865115e-01f, 1.08992212e-01f, -1.02302628e-02f,
  -6.66717887e-01f, 6.64596707e-02f, -1.39352620e-01f, -2.41784260e-01f, 6.88516378e-01f, -1.39335215e-01f, 8.35442841e-02f, -2.68691927e-01f, 4.26864475e-01f, 1.65041462e-01f,
  5.49687088e-01f, 9.93353035e-03f, 2.09322125e-01f, 3.16698879e-01f, -3.73942792e-01f, 6.87269261e-03f, 4.52866077e-01f, 5.32770276e-01f, 2.05357075e-01f, -2.04530671e-01f,
  -1.21648014e-01f, 2.85343319e-01f, -5.52525759e-01f, -2.45045409e-01f, 6.23192668e-01f, 2.30767637e-01f, -4.45888728e-01f, -3.19887772e-02f, 2.27882728e-01f, 3.22296023e-01f,
  4.81205225e-01f, 6.41058683e-02f, 2.24309906e-01f, -6.49225652e-01f, 1.74520403e-01f, 2.10179806e-01f, -1.02165890e+00f, 6.92666993e-02f, 6.97207689e-01f, 5.63181341e-01f,
  -6.58465922e-01f, -1.00741982e-01f, -6.28636703e-02f, 6.86837256e-01f, 6.32508174e-02f, -5.49134135e-01f, -3.31485301e-01f, 1.34186640e-01f, -4.12450433e-01f, -2.06254981e-02f,
  5.29337898e-02f, 3.90930697e-02f, 9.66543481e-02f, -6.02488399e-01f, 1.62803203e-01f, 9.33049560e-01f, -1.82585359e-01f, 1.13040462e-01f, 6.33748293e-01f, -1.39053360e-01f,
  -1.03477821e-01f, -1.58730730e-01f, 7.84434080e-02f, 2.35756427e-01f, 9.24741745e-01f, 8.11818182e-01f, -4.42721099e-02f, 5.31621166e-02f, -4.64852870e-01f, 5.85288644e-01f,
  -2.34532103e-01f, -5.35969198e-01f, -3.38219792e-01f, -1.62098691e-01f, -3.93872380e-01f, -6.48551762e-01f, 2.14577302e-01f, 3.91570300e-01f, 2.39406317e-01f, 1.88308151e-03f,
  -1.55281007e-01f, -5.96069336e-01f, 5.12243748e-01f, -1.78502694e-01f, -1.43611103e-01f, -6.21316135e-01f, 5.20059943e-01f, 6.88261688e-01f, -5.56798697e-01f, -2.46295735e-01f,
  6.65293276e-01f, 1.25089407e-01f, 1.41758040e-01f, -1.54865935e-01f, -1.19436033e-01f, 1.90961063e-01f, -8.99095714e-01f, -1.65661559e-01f, -9.94366184e-02f, 1.40196085e-01f,
  9.34772938e-03f, -3.32335740e-01f, -9.57595527e-01f, -5.33793345e-02f, 1.22128725e+00f, 1.45160407e-01f, -1.78592950e-01f, -3.39659661e-01f, -1.81711391e-01f, 3.88572626e-02f,
  6.01999648e-02f, -1.41908810e-01f, 9.21505153e-01f, -1.00393211e-02f, -3.20208430e-01f, -1.51384056e-01f, -1.09064651e+00f, 6.04469836e-01f, 2.79650658e-01f, 2.84218848e-01f,
  -5.82117438e-01f, -2.21682736e-03f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.90078306e-01f, 8.42719227e-02f, -2.07144961e-01f, -4.62180257e-01f, -3.55782390e-01f, 8.24110284e-02f, 2.13148147e-01f, -9.19962153e-02f, 4.05037731e-01f, 2.69296467e-01f,
  5.83215952e-02f, 3.89019400e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    