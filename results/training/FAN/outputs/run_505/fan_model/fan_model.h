/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.37282664e-01f, -2.81131733e-03f, -2.38838032e-01f, -1.34657100e-01f, 5.16492501e-02f, 7.62786949e-03f, -2.10052922e-01f, -1.97627675e-03f, -1.03338920e-01f, 1.29218012e-01f,
  1.39215469e-01f, -2.64848888e-01f, 2.58377176e-02f, 3.66785266e-02f, -2.56288767e-01f, 1.34846764e-02f, 3.72217633e-02f, 1.15789473e-02f, -7.27494508e-02f, -1.61401695e-04f,
  -3.93115263e-03f, 1.60744295e-01f, -9.55845341e-02f, 2.18534648e-01f, -6.15380667e-02f, 1.67822707e-02f, 1.78040758e-01f, -9.49486941e-02f, 1.42065406e-01f, 2.00495757e-02f,
  -2.63208281e-02f, -6.47190958e-02f, -6.28566220e-02f, -7.44155496e-02f, -1.94473770e-02f, -1.62816532e-02f, -4.92632054e-02f, 7.08928611e-03f, 1.40809491e-02f, 1.43305827e-02f,
  -2.05656607e-02f, -1.53244147e-02f, -4.79075679e-04f, 1.75502934e-02f, 2.54269838e-02f, 3.05715855e-02f, -7.75589719e-02f, -3.09863244e-03f, -4.95960079e-02f, -4.02457081e-02f,
  5.78722730e-03f, -5.24757318e-02f, 1.14047341e-02f, 6.58781305e-02f, -1.70350615e-02f, -2.45464705e-02f, -6.32472187e-02f, 3.88016030e-02f, 1.23664346e-02f, 1.14130517e-02f,
  -5.54274954e-02f, -5.21546043e-02f, -3.76274660e-02f, 2.82603968e-02f, -1.05784070e-02f, 2.50285957e-02f, -2.66927090e-02f, -1.70730650e-02f, -8.06707516e-02f, 2.94582583e-02f,
  4.93666083e-02f, -1.13872187e-02f, -1.98254827e-02f, 5.86950965e-02f, -3.23367603e-02f, 2.43559144e-02f, -7.02758431e-02f, 7.92728141e-02f, -4.29437421e-02f, 1.93397272e-02f,
  1.64250322e-02f, -6.49431720e-02f, 3.16877328e-02f, -5.59534645e-03f, 1.67447643e-03f, -5.53782769e-02f, 3.33896466e-02f, -1.26809133e-02f, -2.53463592e-02f, -3.72121334e-02f,
  2.53639388e-04f, 4.43780459e-02f, 1.46411806e-02f, -2.82628816e-02f, 6.28160015e-02f, -1.68547919e-03f, 9.47764330e-03f, 2.49163248e-03f, -4.43351306e-02f, -5.33825066e-03f,
  4.64806147e-02f, 5.72894178e-02f, 4.40604202e-02f, -4.77073900e-03f, -5.34107313e-02f, 3.54679115e-03f, 1.07176334e-03f, -3.13253999e-02f, 4.57906276e-02f, 7.78898224e-02f,
  -2.75631435e-02f, -2.84567419e-02f, 1.47815086e-02f, -1.52850198e-02f, 8.01515207e-02f, -1.53317349e-02f, -1.07320666e-01f, -4.96271206e-03f, 1.42210713e-02f, 4.96830270e-02f,
  2.55554855e-01f, -2.89607167e-01f, 4.58273701e-02f, -6.21381812e-02f, 1.99354743e-03f, -1.49579912e-01f, -2.24878013e-01f, 1.97474309e-03f, 3.87175605e-02f, -1.73386410e-01f,
  -9.12537724e-02f, -8.67474452e-02f, -9.81620327e-02f, -7.02923685e-02f, -5.51915951e-02f, -2.05653626e-02f, -1.26447216e-01f, -6.51715845e-02f, 8.71251300e-02f, -1.45674214e-01f,
  1.76553190e-01f, -1.76136076e-01f, -1.20627377e-02f, -2.05982067e-02f, -8.43385756e-02f, 6.23255372e-02f, -9.44667384e-02f, 6.41368181e-02f, -1.63349956e-01f, -3.41185853e-02f,
  3.76431122e-02f, 8.84044319e-02f, 1.48848770e-02f, 7.09472150e-02f, -6.52178749e-03f, -1.73617993e-02f, -1.73586197e-02f, 3.61395702e-02f, 9.00329128e-02f, 1.03139626e-02f,
  -1.34463264e-02f, 3.54219899e-02f, -8.03837832e-03f, -7.91322812e-02f, 3.13083082e-02f, 6.85978308e-02f, 3.17628006e-03f, -1.45000210e-02f, -7.17461035e-02f, -5.14243841e-02f,
  -2.57570855e-02f, -3.71219404e-02f, -3.85564230e-02f, -1.48898736e-02f, 6.43060803e-02f, -6.98730256e-03f, -4.30593975e-02f, 4.97228801e-02f, -3.74481156e-02f, 4.98832427e-02f,
  9.83213168e-03f, 3.32969949e-02f, -3.50066125e-02f, 4.70742732e-02f, -4.68442589e-02f, -2.15834137e-02f, 1.73316393e-02f, -1.46386493e-02f, 2.37161200e-02f, -3.42818126e-02f,
  -3.70246079e-03f, -3.13971564e-02f, 2.12024860e-02f, -2.57028788e-02f, 1.61881801e-02f, -5.60503267e-03f, 4.06969413e-02f, -1.73864998e-02f, 3.58926617e-02f, 1.53192300e-02f,
  -1.71623528e-02f, 2.19590608e-02f, 4.78691841e-03f, 3.14197391e-02f, -2.38939701e-03f, -1.05876746e-02f, -2.86145532e-03f, 3.71957235e-02f, -3.60898301e-02f, -3.86381149e-02f,
  -1.67246893e-01f, -2.43061200e-01f, -1.02744820e-02f, -6.48577437e-02f, -1.77032221e-02f, 6.60917014e-02f, 1.54523691e-02f, -2.81273009e-04f, -7.99268559e-02f, -5.24954721e-02f,
  3.85934003e-02f, -1.06393263e-01f, -1.88991483e-02f, 3.33809946e-03f, -6.20523542e-02f, -2.57867891e-02f, 1.56823900e-02f, -4.89405589e-03f, 1.84842926e-02f, -4.47445251e-02f,
  -3.39955129e-02f, 2.09840126e-02f, 9.59898382e-02f, 9.29958280e-03f, -3.81810926e-02f, 4.10052873e-02f, -2.87784543e-02f, -1.17650572e-02f, 5.13882898e-02f, -5.47828972e-02f,
  8.01289380e-02f, -1.44609198e-01f, -6.12540916e-02f, 7.43150786e-02f, 1.56857267e-01f, 1.02386430e-01f, 1.18580066e-01f, 7.45920278e-03f, -1.54431969e-01f, 4.61299270e-02f,
  9.25546363e-02f, -6.42787665e-02f, 4.54606998e-05f, 2.73405332e-02f, 6.58951998e-02f, -1.23497315e-01f, 1.36516556e-01f, -3.30913663e-02f, -1.66827470e-01f, 2.96444502e-02f,
  1.55160325e-02f, 1.57025501e-01f, 3.52455638e-02f, 2.57159248e-02f, 9.84022245e-02f, -2.41552778e-02f, 3.02560385e-02f, -5.53177819e-02f, 6.42201379e-02f, 3.30971889e-02f,
  1.23107053e-01f, -8.19351897e-02f, -6.82937428e-02f, -6.94286898e-02f, 3.09312232e-02f, 3.59035842e-02f, 2.10733619e-02f, 3.46685597e-03f, -2.19909400e-02f, -2.27762926e-02f,
  -3.14375851e-03f, 2.83294115e-02f, -6.37215748e-02f, -4.60021086e-02f, -2.88362559e-02f, 7.84497336e-03f, 3.29376687e-03f, 7.90910944e-02f, 5.80656230e-02f, -4.35760878e-02f,
  -5.91198215e-03f, 4.12219949e-02f, 7.17269555e-02f, 4.63774651e-02f, -1.18714646e-02f, 3.46691422e-02f, -3.49460356e-02f, -1.13113225e-02f, -3.37779634e-02f, 1.37260277e-02f,
  5.19334301e-02f, 1.09291431e-02f, -7.22904205e-02f, 6.13980405e-02f, -6.80860458e-03f, -1.33860568e-02f, 1.48704061e-02f, 6.65899515e-02f, 5.01931533e-02f, -2.73315515e-02f,
  8.12370107e-02f, -2.04834417e-02f, 2.88881678e-02f, -3.60751636e-02f, 5.15210442e-02f, -1.99964475e-02f, -2.03379290e-03f, 4.57616989e-03f, -1.74094606e-02f, -5.43318037e-03f,
  9.41305142e-03f, -5.03136180e-02f, 5.90676535e-03f, 6.99208751e-02f, 4.44924720e-02f, -5.50559312e-02f, 1.33887902e-02f, -6.47838563e-02f, -2.75331996e-02f, 8.02690759e-02f,
  1.34007215e-01f, 4.94529642e-02f, -5.18888198e-02f, 6.82489723e-02f, 4.56966050e-02f, 3.75450104e-02f, -8.19105655e-02f, -1.36023434e-03f, -6.08028732e-02f, 9.82489139e-02f,
  2.00219434e-02f, 1.99953970e-02f, 4.17731553e-02f, 1.47364987e-02f, -2.06156392e-02f, 1.11608235e-02f, 5.04327007e-02f, -3.72567065e-02f, 4.85610329e-02f, -1.70919690e-02f,
  1.30805984e-01f, 1.33480281e-01f, 1.58865601e-02f, 4.16311063e-02f, 3.82756479e-02f, 5.78644387e-02f, -5.03282323e-02f, -4.58678454e-02f, 7.07256645e-02f, -4.93161008e-02f,
  2.14877069e-01f, -6.09351508e-02f, -7.59298354e-02f, 1.72452733e-01f, -3.95133495e-02f, -7.55453780e-02f, 2.77919360e-02f, 4.06438746e-02f, 8.47174376e-02f, -1.71280921e-01f,
  4.84421179e-02f, 6.21239981e-03f, 6.25645742e-02f, 9.19841137e-03f, 2.50575662e-01f, 1.21579327e-01f, 1.20314270e-01f, 2.20072586e-02f, -3.97284999e-02f, 1.62419736e-01f,
  9.86198038e-02f, 4.97116223e-02f, 9.91560519e-03f, -1.90139145e-01f, -5.90403937e-02f, -5.47045879e-02f, 8.48313794e-03f, -3.75581048e-02f, -1.34882867e-01f, -8.69580582e-02f,
  2.04077642e-03f, 4.30898070e-02f, -4.88997549e-02f, -4.86022979e-02f, -7.82637298e-03f, -8.44417587e-02f, 2.77865175e-02f, -1.10720275e-02f, 3.64590809e-02f, -1.39407804e-02f,
  -1.05850890e-01f, 2.04052590e-02f, 3.46087851e-02f, 6.14985302e-02f, -1.05232419e-02f, -6.75014779e-02f, -1.35134220e-01f, -5.17966822e-02f, -4.39252704e-02f, -4.72260155e-02f,
  3.08011286e-02f, -6.23462573e-02f, -4.29367498e-02f, -2.57088318e-02f, 3.58512788e-03f, -1.14858132e-02f, -4.73904200e-02f, -3.55787612e-02f, 4.06985655e-02f, -4.56265397e-02f,
  -8.67959931e-02f, -2.74817981e-02f, -2.79913377e-02f, 1.66479591e-02f, 2.53987461e-02f, -2.13772021e-02f, 7.51804337e-02f, -1.98093336e-02f, -1.83237847e-02f, 3.82881612e-02f,
  9.31828097e-02f, 5.13410419e-02f, -3.95199843e-02f, 1.75033591e-03f, -2.54424498e-03f, 2.13681720e-02f, 7.21510919e-03f, 1.37817254e-02f, 3.86183411e-02f, -1.10678487e-02f,
  1.43262511e-02f, 1.49818193e-02f, -1.80328693e-02f, 1.17218234e-02f, -8.21191072e-03f, 4.69266176e-02f, -1.00968659e-01f, -1.24562345e-02f, 5.45836170e-04f, 3.03766709e-02f,
  2.19208270e-01f, 1.48962140e-01f, -4.28940840e-02f, 3.38878743e-02f, 3.81477252e-02f, -1.27050271e-02f, -1.53632639e-02f, -9.10620391e-02f, 6.89284652e-02f, 5.01727276e-02f,
  4.67484863e-03f, -3.70389558e-02f, -3.10518034e-02f, -2.03567813e-03f, -1.03650995e-01f, 8.89097247e-03f, 1.05581626e-01f, 6.12656511e-02f, 5.07501699e-02f, 5.35931811e-02f,
  4.54110801e-02f, 4.34134416e-02f, -4.17698286e-02f, -1.48198390e-02f, -1.16490141e-01f, 2.72068251e-02f, -2.08466705e-02f, -8.57934356e-02f, 3.35893128e-03f, -5.30719347e-02f,
  -8.36303160e-02f, 1.45491061e-03f, -3.12732370e-03f, -4.57411632e-02f, -2.45418072e-01f, -9.06280279e-02f, -1.33727537e-02f, -2.36423969e-01f, -5.75515963e-02f, 2.18294282e-02f,
  -1.53680161e-01f, 8.37283880e-02f, 1.38733178e-01f, -9.92254019e-02f, -6.00874498e-02f, 1.81750804e-01f, -1.06459655e-01f, -4.09329236e-02f, 5.65702096e-02f, -8.80759209e-02f,
  -1.37322918e-01f, -1.05864063e-01f, 4.12857309e-02f, -8.80395770e-02f, -1.25935048e-01f, -7.85185918e-02f, -3.68811786e-02f, 9.08634812e-02f, -1.96566842e-02f, 1.14122018e-01f,
  7.47963861e-02f, 2.90772505e-02f, -8.41912720e-03f, 1.30642027e-01f, 1.93906371e-02f, 4.16041212e-03f, -4.32505980e-02f, 4.14192379e-02f, -3.86390947e-02f, -6.10636696e-02f,
  4.84151430e-02f, -6.52190372e-02f, 7.61944354e-02f, 2.88934652e-02f, -9.18908194e-02f, -6.55476674e-02f, -3.52011323e-02f, -6.94062486e-02f, -1.09450564e-01f, -5.78731939e-04f,
  -3.95077653e-02f, -5.83027638e-02f, 3.13929059e-02f, 4.26787734e-02f, -6.06490411e-02f, -2.96252277e-02f, 1.08625583e-01f, 1.45102916e-02f, -4.89040427e-02f, -6.49300963e-03f,
  6.21446967e-02f, 4.47007418e-02f, -6.41149562e-03f, 3.38322818e-02f, 1.36158299e-02f, 1.47826793e-02f, -1.99541301e-02f, 6.76546246e-02f, 2.32625958e-02f, -2.15009488e-02f,
  -4.39874530e-02f, 1.05749294e-02f, 2.14831112e-03f, 1.17891999e-02f, -8.45895931e-02f, -2.95727607e-02f, -1.08305272e-02f, 6.18249737e-02f, -5.68335690e-02f, -7.34247640e-03f,
  4.79038730e-02f, -4.26329747e-02f, 4.84776348e-02f, 5.86061589e-02f, 3.39228436e-02f, -3.09634418e-03f, -3.73910815e-02f, -8.32321309e-03f, -1.41621958e-02f, 2.54355874e-02f,
  1.54336030e-02f, 4.31456678e-02f, 2.60216855e-02f, -3.84955257e-02f, 1.47990152e-01f, 1.71006694e-02f, 4.81537394e-02f, -1.06107248e-02f, 2.12054569e-02f, 6.61254078e-02f,
  -1.04765408e-01f, -3.70230824e-02f, -6.52617514e-02f, -2.25862712e-02f, 6.39948025e-02f, -4.69335951e-02f, 4.15672269e-03f, -4.00784239e-03f, -1.15362152e-01f, -7.34162703e-02f,
  -5.50645664e-02f, 2.08255998e-03f, -4.64835651e-02f, -5.55055402e-02f, -2.33295932e-02f, 2.49445532e-02f, -8.83234665e-02f, -4.65449505e-02f, 6.28279522e-02f, -3.71100157e-02f,
  1.49572819e-01f, -4.92468886e-02f, 9.18975249e-02f, 1.36770174e-01f, 2.73964424e-02f, -1.24021724e-01f, -1.06574418e-02f, -6.11929176e-03f, -8.05217624e-02f, -2.37266749e-01f,
  -7.68984929e-02f, 1.15071207e-01f, -1.47754103e-01f, -7.29358122e-02f, 2.30755657e-02f, -1.50198266e-01f, 2.13217232e-02f, -9.57561471e-03f, 5.00606857e-02f, 3.65785956e-02f,
  9.09241065e-02f, -1.47466123e-01f, 2.08741724e-01f, -5.64542748e-02f, 2.40548421e-02f, 1.79838255e-01f, -2.22177021e-02f, -4.58228886e-02f, 1.30032133e-02f, -9.98674519e-03f,
  4.03816327e-02f, -1.37197552e-02f, 7.28094280e-02f, -6.30635815e-03f, -4.48353142e-02f, 6.98090717e-02f, 5.21713123e-02f, 1.78812537e-02f, -2.65660249e-02f, -4.48096842e-02f,
  -2.28126347e-02f, 6.83906078e-02f, -8.41137171e-02f, -3.40037271e-02f, -5.31070419e-02f, 5.35802655e-02f, 1.58581510e-01f, 6.52268678e-02f, -2.65672859e-02f, -3.76818851e-02f,
  6.49506003e-02f, 1.81245673e-02f, 5.25163487e-02f, 1.03987269e-02f, 2.33416595e-02f, 7.54386932e-03f, -3.16024944e-02f, 7.81349242e-02f, -4.13902327e-02f, 5.40600121e-02f,
  3.27514969e-02f, 5.64252818e-03f, -3.63824144e-02f, -7.93920532e-02f, -7.25106278e-04f, 4.00519930e-02f, -7.11807832e-02f, -1.30617898e-03f, -2.95324456e-02f, -7.80184269e-02f,
  6.02299348e-02f, 7.95074478e-02f, -6.07849658e-02f, 7.33686909e-02f, -1.57669298e-02f, 3.05853821e-02f, 3.63653526e-02f, 9.24975332e-03f, 7.62366205e-02f, 6.38389289e-02f,
  1.73797980e-02f, 1.03092678e-02f, -1.39908446e-02f, 2.31970847e-02f, 2.14843210e-02f, 1.56442672e-02f, 1.87150948e-02f, -2.11308245e-02f, 7.11814761e-02f, 5.94278984e-02f,
  -1.75010830e-01f, -1.79063410e-01f, -2.80332342e-02f, 6.04044758e-02f, -3.01645566e-02f, -1.38134837e-01f, -5.49132824e-02f, -2.30995268e-02f, -1.03990166e-02f, -7.00493678e-02f,
  8.21499527e-02f, -7.00174570e-02f, 2.00494584e-02f, 3.76343951e-02f, 8.00022781e-02f, -8.57628658e-02f, -2.52064932e-02f, -9.47651193e-02f, -1.38882026e-02f, -4.63225693e-03f,
  -6.22152537e-02f, -8.37563947e-02f, -2.49373801e-02f, -2.71439888e-02f, 6.65328801e-02f, 7.71138351e-03f, -1.48776360e-02f, -7.22544342e-02f, -4.66925316e-02f, 1.41536882e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.73006731e-02f, 1.31867632e-01f, -7.56033286e-02f, -6.70038313e-02f, -2.02555463e-01f, -1.47435680e-01f, -8.06541443e-02f, -2.25055050e-02f, 1.24034487e-01f, 1.99446619e-01f,
  7.05794916e-02f, 3.06906160e-02f, 2.03874737e-01f, 8.09837878e-02f, -3.67853381e-02f, 2.16972142e-01f, -1.29595429e-01f, -2.08871718e-02f, -1.37001276e-01f, -1.44576386e-01f,
  -1.20933995e-01f, -6.82150051e-02f, 8.75710882e-03f, -3.08392961e-02f, -1.60668284e-01f, -1.15670741e-01f, -1.00515746e-01f, -6.65176660e-02f, -9.29546952e-02f, -3.66291590e-02f,
  -2.39559449e-02f, -7.19587356e-02f, 1.07316887e-02f, -4.35445309e-02f, -7.68779078e-03f, -9.08481181e-02f, -2.48982087e-02f, 4.87371460e-02f, -1.58511996e-02f, -4.09211442e-02f,
  3.69380675e-02f, 6.28654212e-02f, 7.81846195e-02f, 4.57382388e-02f, -9.94101688e-02f, -3.94689676e-04f, 5.95928654e-02f, -6.30616546e-02f, 5.84532600e-03f, 1.12382695e-01f,
  -8.30765963e-02f, -1.09749965e-01f, -1.49533954e-02f, 6.24115653e-02f, -2.50593275e-02f, -1.82185601e-02f, 5.79842627e-02f, 1.31976902e-02f, -1.73728511e-01f, -7.05164671e-02f,
  -2.92395931e-02f, -3.70242223e-02f, 3.51976557e-03f, 2.85762958e-02f, -4.17864174e-02f, 7.94445165e-03f, -9.31154713e-02f, 4.09183614e-02f, -1.24845318e-01f, 9.53762382e-02f,
  8.32436159e-02f, -4.38094549e-02f, 5.28278686e-02f, -1.23337992e-01f, -8.33646879e-02f, 5.00976257e-02f, 1.91268213e-02f, 4.58581708e-02f, 2.51162760e-02f, -5.94761036e-02f,
  -1.86982993e-02f, -2.53471155e-02f, -7.18518347e-02f, 6.30287395e-04f, -2.07054578e-02f, -3.51569541e-02f, -1.12972319e-01f, -3.87931475e-03f, 5.88598521e-03f, -2.67949775e-02f,
  -1.58698246e-01f, -2.38475323e-01f, 2.36263201e-02f, -9.00841430e-02f, 5.04782125e-02f, -6.87303320e-02f, 1.09742917e-02f, 6.03761077e-02f, 4.83443365e-02f, 8.05371627e-03f,
  -1.94217768e-02f, 6.33164123e-02f, -2.58591324e-02f, 2.97083110e-02f, 3.15577351e-02f, -1.25236511e-01f, -2.45482288e-02f, -3.32459062e-02f, -1.08994707e-01f, -7.12790862e-02f,
  6.36676997e-02f, 2.42314790e-03f, 8.77148509e-02f, -2.51366161e-02f, 7.65211461e-03f, 1.12046087e-02f, -3.39628756e-02f, 6.29165247e-02f, -1.12187259e-01f, -7.94647485e-02f,
  2.16341868e-01f, -1.41111627e-01f, -1.27491936e-01f, 5.67891523e-02f, 1.67956680e-01f, 8.03897306e-02f, 4.67440709e-02f, 1.35770112e-01f, 1.71347603e-01f, -1.73734263e-01f,
  4.66391072e-02f, -8.89118016e-02f, -1.67057484e-01f, 9.47399214e-02f, 1.06638044e-01f, -1.00338243e-01f, 1.91305444e-01f, 5.37566394e-02f, -1.40538067e-02f, 7.15982243e-02f,
  1.45431198e-02f, 1.17164023e-01f, -1.89695209e-01f, -1.54243419e-02f, 1.34530738e-01f, -9.10496861e-02f, -3.65216769e-02f, -1.02469735e-01f, -1.61184147e-02f, 9.92650539e-02f,
  3.70573588e-02f, -2.90261190e-02f, 1.33303506e-02f, -5.12176901e-02f, 4.34269644e-02f, -1.01260707e-01f, 1.11110825e-02f, -1.19071588e-01f, 1.14818634e-02f, -1.98837761e-02f,
  -3.17937403e-04f, -4.64303046e-02f, 1.02164626e-01f, -7.97024295e-02f, 1.56558618e-01f, -2.00202558e-02f, 8.69727060e-02f, -1.14509471e-01f, -2.04867534e-02f, 1.79077815e-02f,
  -9.22892168e-02f, -2.08638906e-02f, -1.67555232e-02f, 5.58519624e-02f, 9.34339687e-03f, 4.51094992e-02f, -2.32084803e-02f, 3.30755748e-02f, -7.92455971e-02f, 9.94604900e-02f,
  8.20600837e-02f, 2.00907513e-02f, -6.92639351e-02f, -4.91060689e-02f, 4.70397621e-02f, 2.75141671e-02f, 5.69160692e-02f, 1.69376843e-02f, 1.13761099e-02f, 2.05095746e-02f,
  -3.68292443e-02f, -1.10905813e-02f, 5.21445135e-03f, 1.44595951e-02f, -5.62452413e-02f, 5.27071916e-02f, -1.05286986e-01f, -3.89079563e-02f, -5.87842651e-02f, 5.23570292e-02f,
  -6.54406101e-02f, -4.29476351e-02f, 7.00471690e-03f, -2.81314999e-02f, 3.48139293e-02f, -5.52126020e-02f, -5.56719583e-03f, -3.72869102e-03f, -8.07511508e-02f, -1.10488288e-01f,
  1.04254752e-01f, -1.06908709e-01f, 3.46119702e-02f, 2.79939715e-02f, -1.37458503e-01f, -3.60898450e-02f, -2.80109122e-02f, 9.66005251e-02f, 7.32157528e-02f, -4.12189774e-02f,
  -8.63269493e-02f, -3.32807526e-02f, 6.99102320e-03f, 8.40870589e-02f, 2.49040816e-02f, -8.51290077e-02f, 1.78145710e-02f, 2.94365920e-02f, 8.13590884e-02f, -3.26329693e-02f,
  -5.38786873e-02f, -4.84835058e-02f, -8.92010257e-02f, 4.11650585e-03f, 5.13388179e-02f, -1.26712779e-02f, -1.44310212e-02f, 1.81842018e-02f, -1.19819082e-01f, -5.31551093e-02f,
  9.28935036e-02f, -1.60749611e-02f, -1.74402639e-01f, -1.53132707e-01f, -2.64556766e-01f, -1.08737573e-01f, -2.52757836e-02f, -4.71333154e-02f, -4.95366566e-02f, 1.37334496e-01f,
  -4.81490158e-02f, -4.17272151e-02f, 1.62658289e-01f, -1.72034338e-01f, 1.59114227e-01f, 2.37299979e-01f, -2.27153003e-02f, 6.34248331e-02f, -5.06504439e-02f, 1.14224963e-02f,
  -3.73748951e-02f, -3.29087488e-02f, -9.56781432e-02f, -6.87520057e-02f, -9.81578082e-02f, -2.01183602e-01f, -6.19352460e-02f, -2.02041775e-01f, -2.22139403e-01f, -2.07487285e-01f,
  3.92008908e-02f, -6.87900707e-02f, -2.80269179e-02f, -5.74969351e-02f, -8.11911002e-02f, -4.63223234e-02f, -1.66770026e-01f, 4.15610103e-03f, 6.87647313e-02f, 3.09976991e-02f,
  1.73207432e-01f, 7.84227476e-02f, 7.67004117e-02f, 2.90852934e-02f, -1.40155409e-03f, -5.09349555e-02f, -2.41288985e-03f, -5.20216115e-02f, 7.70268813e-02f, -8.79448280e-03f,
  -3.21829878e-02f, -6.57825693e-02f, -1.17569089e-01f, 1.26691982e-01f, -1.25281721e-01f, -6.24181740e-02f, -6.05409183e-02f, -4.11694013e-02f, 5.96075729e-02f, 1.28544271e-02f,
  1.11102633e-01f, -3.11183501e-02f, 9.23778638e-02f, 2.25295126e-02f, -5.54941557e-02f, 5.45031428e-02f, 1.71978343e-02f, -6.44393340e-02f, 1.88163742e-02f, -8.97901598e-03f,
  -9.91476774e-02f, 4.96924222e-02f, 3.39199677e-02f, 7.26123154e-02f, 3.94878238e-02f, 1.52652234e-01f, 9.13709216e-03f, -2.64449250e-02f, -1.21884746e-03f, -3.70499119e-02f,
  5.43716103e-02f, 8.37620348e-02f, -3.55680124e-04f, -6.74838498e-02f, -4.70062010e-02f, -1.54304104e-02f, -1.54016481e-03f, -2.37130298e-04f, -4.04728809e-03f, 5.58445137e-03f,
  -2.85022948e-02f, -6.63150623e-02f, -1.99557319e-02f, -5.56310080e-03f, -5.87285124e-02f, 2.65494995e-02f, -9.20935720e-03f, -7.74214789e-02f, -8.88473913e-02f, -8.04314669e-03f,
  3.29102762e-02f, -4.29131575e-02f, 2.35766303e-02f, 5.12659512e-02f, -8.07610303e-02f, -4.24383470e-04f, 8.23977217e-02f, -2.43278295e-02f, 9.94739383e-02f, -7.34313019e-03f,
  -8.77508074e-02f, 6.12656809e-02f, 1.28563091e-01f, -1.62892342e-02f, 6.91617131e-02f, 5.65143935e-02f, -7.74508044e-02f, 2.44199596e-02f, 8.55862796e-02f, -1.02283061e-01f,
  -2.40530267e-01f, 1.04779646e-01f, 1.67432934e-01f, -2.35456362e-01f, 6.27274737e-02f, 3.38696130e-02f, -1.51379660e-01f, 1.05771245e-02f, -1.32653385e-01f, -1.78149626e-01f,
  -8.76705050e-02f, 2.53219437e-02f, 1.66488573e-01f, -1.32152200e-01f, 8.48277062e-02f, 1.98890403e-01f, -1.35484457e-01f, -8.74363035e-02f, -2.42758356e-02f, -1.18730277e-01f,
  -3.96411754e-02f, -9.47879404e-02f, 1.06098130e-01f, -2.14744548e-04f, -8.64332542e-02f, -1.20934032e-01f, -2.05203760e-02f, 1.54424682e-01f, -5.38146608e-02f, 4.43998910e-02f,
  -1.06154777e-01f, -1.12408608e-01f, -1.16251282e-01f, -8.12801719e-03f, -8.58461410e-02f, -5.03669754e-02f, -1.76631007e-02f, -1.03233391e-02f, -2.56140251e-02f, -6.44724891e-02f,
  -8.77457857e-03f, -1.24719981e-02f, 5.37232496e-03f, -7.15346821e-03f, -2.72288900e-02f, -6.04642928e-02f, 5.41270664e-03f, 1.21768210e-02f, 4.87126149e-02f, 5.53921685e-02f,
  4.71907109e-02f, -8.22100565e-02f, -1.09183878e-01f, 3.71129671e-03f, 6.37319088e-02f, 2.04175618e-02f, 3.19190659e-02f, -6.36752844e-02f, -1.88166387e-02f, -4.51273173e-02f,
  1.34098351e-01f, 2.38252152e-02f, -7.06186593e-02f, -5.70749529e-02f, -1.42901009e-02f, -7.64487162e-02f, -6.80882707e-02f, 6.64732829e-02f, 1.10798574e-03f, -6.79378361e-02f,
  -5.52842990e-02f, -9.67073441e-02f, 3.73771861e-02f, -6.02424406e-02f, -6.90434054e-02f, -1.71027444e-02f, -5.69140390e-02f, -7.35335350e-02f, -6.91854581e-03f, 2.20358986e-02f,
  -2.44938564e-02f, -2.11444194e-03f, 2.33636908e-02f, -6.63395450e-02f, -2.17616279e-02f, -3.85054760e-02f, -7.03523168e-03f, 1.97641775e-02f, -6.25353307e-02f, 6.10671863e-02f,
  -2.19081685e-01f, -2.88560778e-01f, -2.31682714e-02f, -1.50401875e-01f, -9.06480551e-02f, 8.08507428e-02f, -3.64619978e-02f, -3.99608351e-02f, -5.02817854e-02f, -2.57697143e-02f,
  1.44097274e-02f, -9.82191134e-03f, 2.87576970e-02f, -6.03142602e-04f, 8.39663371e-02f, 2.54886579e-02f, -8.72854367e-02f, -1.33589061e-03f, -1.42630696e-01f, 3.12827043e-02f,
  -2.49992870e-02f, -1.03720248e-01f, 9.62133892e-03f, -7.44156059e-05f, -5.90914078e-02f, -5.64821512e-02f, 2.84572486e-02f, -3.31895016e-02f, 1.02392370e-02f, 5.41382171e-02f,
  2.79642165e-01f, -6.04769588e-02f, 5.74927740e-02f, 7.15619847e-02f, -1.12244293e-01f, -3.30993161e-02f, 1.82557896e-01f, -1.04417838e-01f, -1.17057197e-01f, -1.31787613e-01f,
  3.34914811e-02f, 1.26165226e-01f, -1.66557562e-02f, 1.13690518e-01f, 3.28460842e-01f, 6.08340874e-02f, 2.79020406e-02f, -5.84641472e-03f, -1.01639986e-01f, 4.32887189e-02f,
  7.41132768e-03f, 2.54896786e-02f, 7.64040053e-02f, -1.33982703e-01f, 3.89491357e-02f, -9.51751918e-02f, -4.26351763e-02f, 1.02116339e-01f, 8.49200180e-04f, 1.35110736e-01f,
  4.55964729e-03f, -6.79100081e-02f, -2.68287174e-02f, -6.10135607e-02f, -9.02553350e-02f, 1.02866739e-01f, 1.26137376e-01f, 1.47035614e-01f, 6.43584803e-02f, 1.02781825e-01f,
  9.79558080e-02f, 9.66018215e-02f, -6.55358285e-02f, -7.60443360e-02f, 1.61492117e-02f, 4.28115278e-02f, -1.41649330e-02f, 2.63375062e-02f, -3.84259187e-02f, -4.84695509e-02f,
  7.45692179e-02f, 4.34175134e-02f, -3.32437009e-02f, 4.07732986e-02f, 6.85046539e-02f, -2.39555957e-03f, 2.72785835e-02f, -8.15339759e-03f, -7.00454740e-03f, 1.99798383e-02f,
  -9.59951505e-02f, 1.76284648e-02f, 1.21282935e-01f, -3.12687680e-02f, 5.76009676e-02f, -3.86645757e-02f, 7.10876286e-02f, 2.66653150e-02f, 3.43418196e-02f, -4.38690139e-03f,
  2.19327435e-02f, 4.69173230e-02f, 6.17106110e-02f, -3.78011800e-02f, 5.93514740e-02f, 2.93965731e-02f, 8.02298933e-02f, -3.78137752e-02f, -1.11952931e-01f, 3.29105295e-02f,
  -1.15575150e-01f, 6.96786419e-02f, 7.29318112e-02f, -3.93462963e-02f, -6.71280921e-02f, 1.06524071e-02f, 3.22568677e-02f, -1.14896074e-01f, -1.39640942e-01f, -3.98197137e-02f,
  2.33874954e-02f, 9.01710168e-02f, -5.70302829e-02f, 3.05935517e-02f, -6.41303584e-02f, 7.15756640e-02f, -4.17258032e-02f, 6.63728714e-02f, 6.68492690e-02f, 8.35371241e-02f,
  -8.30806270e-02f, -1.57656881e-03f, -1.24463834e-01f, 2.90953810e-03f, -8.99764057e-03f, 5.82978651e-02f, 1.25674576e-01f, -4.70795669e-02f, 9.46605280e-02f, 6.93549812e-02f,
  -1.71847176e-03f, -3.15419547e-02f, 1.14505991e-01f, 2.91575529e-02f, 9.50089470e-02f, -5.02650067e-02f, 8.64109173e-02f, -2.39990186e-03f, -7.29701146e-02f, 9.83067416e-03f,
  1.43260434e-01f, 1.56689152e-01f, 2.00661168e-01f, 1.67832464e-01f, -6.22964464e-02f, -1.38867766e-01f, -1.74454913e-01f, -3.91946323e-02f, -9.39629301e-02f, 1.94421545e-01f,
  -7.72973374e-02f, 3.19768906e-01f, -1.73867092e-01f, 3.30535285e-02f, -2.87096053e-01f, -2.79160619e-01f, 3.02307028e-02f, -1.16436463e-02f, 6.05893768e-02f, 3.59373540e-02f,
  -1.12463862e-01f, -3.02488089e-01f, -8.47894475e-02f, -8.37181229e-03f, 1.38797656e-01f, 1.36815593e-01f, -8.23563412e-02f, -1.29267231e-01f, 1.18535280e-01f, -1.00300618e-01f,
  -2.60336436e-02f, 2.80325823e-02f, 2.24098656e-02f, -6.03064299e-02f, -6.73295371e-03f, 4.48669717e-02f, 8.48991214e-04f, -1.16067193e-01f, 1.97458616e-03f, 5.55486679e-02f,
  5.78163043e-02f, -7.20827729e-02f, 5.90807907e-02f, -1.68921109e-02f, -5.28161265e-02f, -4.82299849e-02f, -4.74615358e-02f, 3.72098722e-02f, 1.30121931e-01f, 9.30003524e-02f,
  -3.40921879e-02f, 1.31133934e-02f, 6.42961413e-02f, 8.46944656e-03f, -8.22565407e-02f, -1.40697118e-02f, 4.85740043e-02f, 9.86308530e-02f, -4.47148504e-03f, 3.09382472e-02f,
  3.03951111e-02f, 5.87172359e-02f, 1.13620311e-01f, -4.67527993e-02f, -4.03318228e-03f, -5.87671101e-02f, 1.60667412e-02f, -9.05091017e-02f, -2.85597965e-02f, -4.25386708e-03f,
  -6.05273470e-02f, -2.73687690e-02f, -2.78519071e-03f, -2.30981372e-02f, -1.33212367e-02f, -4.78794761e-02f, 6.53594583e-02f, -1.23057971e-02f, -2.22147405e-02f, 4.05776538e-02f,
  -1.05815127e-01f, -9.06529557e-03f, -6.75674751e-02f, 9.81941149e-02f, 8.41039643e-02f, -2.77325120e-02f, 7.83096552e-02f, 1.25462547e-01f, -3.82818654e-02f, 2.44443994e-02f,
  -2.15688631e-01f, -9.17848274e-02f, -3.23647484e-02f, -7.06200078e-02f, 2.22838521e-02f, 4.87160571e-02f, -1.21899642e-01f, -3.80128138e-02f, -4.97856140e-02f, -5.40760867e-02f,
  -7.55599365e-02f, -4.14891653e-02f, 7.81769231e-02f, 4.29895148e-03f, -1.27128959e-01f, -2.80867070e-02f, -1.20395854e-01f, -2.47914940e-02f, -2.66492274e-02f, 2.73973495e-02f,
  2.02961918e-02f, 3.70758176e-02f, 7.72402212e-02f, 3.05382684e-02f, -6.86304197e-02f, -3.84701639e-02f, -3.68314236e-02f, 2.20932160e-02f, 3.90839167e-02f, 7.47966170e-02f,
  -4.23899561e-01f, -7.89751112e-02f, 2.24018812e-01f, -3.23599130e-01f, 2.97408514e-02f, 1.82250589e-01f, 1.73284709e-01f, 1.50336213e-02f, -2.53049314e-01f, 4.07154346e-03f,
  -5.86455539e-02f, -6.38092086e-02f, 1.34707004e-01f, 2.49554664e-02f, 1.10673569e-01f, 1.04690075e-01f, -8.19238648e-02f, -8.77428204e-02f, -5.71709536e-02f, -1.28913075e-01f,
  -6.74695149e-02f, -6.67413324e-02f, 2.56184697e-01f, -7.06478730e-02f, -1.24729648e-01f, -8.84701610e-02f, -6.32483959e-02f, 1.69328511e-01f, -1.49545483e-02f, 4.41364534e-02f,
  -2.41534948e-01f, -2.68111140e-01f, -6.52311072e-02f, -5.80729991e-02f, -1.02152437e-01f, 3.06037143e-02f, 5.33574112e-02f, 9.45202932e-02f, 5.35804108e-02f, 9.66823753e-03f,
  3.57260555e-02f, -7.95310177e-03f, -9.96612385e-02f, 3.44194397e-02f, -4.38543335e-02f, -4.22306955e-02f, -2.96239909e-02f, 9.10007022e-03f, -1.47962826e-03f, 5.96625954e-02f,
  9.61567387e-02f, -2.15513515e-03f, 3.25925797e-02f, -1.06455088e-01f, 7.39579499e-02f, -5.76624051e-02f, -1.76199600e-02f, 9.22227278e-02f, -1.83480233e-02f, -6.77456483e-02f,
  6.88882321e-02f, 7.37211807e-03f, -9.54479501e-02f, -1.01466522e-01f, 6.62621036e-02f, -2.31537111e-02f, 3.84383798e-02f, -2.57922728e-02f, 7.86920823e-03f, -9.10424888e-02f,
  -1.34384513e-01f, -1.20248655e-02f, -4.08565067e-02f, -8.14324915e-02f, -8.29279944e-02f, -1.53366476e-01f, -1.98143497e-02f, -1.30257159e-01f, -3.46613787e-02f, 6.04145043e-02f,
  -2.53576506e-02f, 1.01907495e-02f, 2.94446461e-02f, -4.12251949e-02f, 2.57085692e-02f, -1.29749840e-02f, 9.25953593e-03f, -4.68146689e-02f, -3.29635926e-02f, 3.00634019e-02f,
  -2.83863664e-01f, -2.76940882e-01f, -3.20477635e-02f, -8.87225643e-02f, 1.64911225e-02f, 7.99520239e-02f, -2.87655252e-03f, 3.08018290e-02f, 3.04467976e-02f, 6.75757974e-03f,
  -8.42928700e-03f, -7.47593194e-02f, -1.32476147e-02f, 8.13566986e-03f, -3.35988849e-02f, 3.52376588e-02f, 3.52663621e-02f, 4.78876336e-03f, 1.22798057e-02f, -2.23579183e-02f,
  -6.38699681e-02f, -2.65612565e-02f, 8.43633339e-02f, -1.22111231e-01f, -3.89837176e-02f, -2.49395426e-02f, -5.87861054e-03f, -5.52154072e-02f, 2.25748196e-02f, 1.13186210e-01f,
  -9.63816121e-02f, 2.85884321e-01f, -7.71394819e-02f, -7.20786825e-02f, 7.44680017e-02f, -6.09067790e-02f, -1.11548185e-01f, 7.33892843e-02f, 1.20783359e-01f, 5.55909425e-02f,
  -1.27705619e-01f, 9.23644081e-02f, 2.10346859e-02f, -1.35534436e-01f, -2.12845743e-01f, -7.48744160e-02f, -1.38040811e-01f, -1.75456733e-01f, 1.67750463e-01f, -1.61329299e-01f,
  -5.20047396e-02f, -1.45203486e-01f, 1.39284106e-02f, 1.12533644e-01f, -5.59445657e-03f, 1.04264997e-01f, -9.00187790e-02f, 1.45525396e-01f, -1.39091462e-01f, 2.18144432e-02f,
  5.41606061e-02f, 9.69493762e-02f, 8.02787244e-02f, 6.33662492e-02f, -1.17949776e-01f, -1.31884933e-01f, -3.46918106e-02f, 1.46360159e-01f, -6.00700453e-02f, 2.42927298e-03f,
  -1.17226601e-01f, -4.69734035e-02f, -1.82360467e-02f, -4.46321182e-02f, 1.04566161e-02f, -3.21672447e-02f, 1.09622017e-01f, -1.06232792e-01f, 6.59162328e-02f, 4.46651317e-02f,
  7.15810135e-02f, 2.99163423e-02f, -1.52632982e-01f, -1.36994943e-01f, -7.29383305e-02f, 8.80041346e-02f, -6.20295107e-02f, -7.35008642e-02f, 4.65092473e-02f, -1.05583742e-01f,
  -3.85752358e-02f, -1.42167300e-01f, 2.84238756e-02f, 1.38009354e-01f, 6.97841728e-03f, 4.72022556e-02f, -6.97353408e-02f, -1.06416032e-01f, 9.75627173e-03f, -2.84418687e-02f,
  -1.17207160e-02f, 4.91441004e-02f, 1.14740003e-02f, -1.61653712e-01f, -8.50290731e-02f, -2.62358617e-02f, -6.29255665e-04f, -2.43888181e-02f, -6.78481311e-02f, -1.46668330e-02f,
  1.84878930e-02f, -1.00869715e-01f, 3.05965934e-02f, -2.47179251e-02f, 5.40516786e-02f, -5.59378937e-02f, -5.56637086e-02f, -3.23014241e-03f, 1.07277170e-01f, -1.31093532e-01f,
  -5.50320484e-02f, -1.03899561e-01f, 7.47011974e-02f, 1.77060679e-01f, 9.76859778e-02f, 5.77107482e-02f, -1.18137747e-01f, -6.71486780e-02f, -1.11694269e-01f, 5.50704040e-02f,
  -1.38979688e-01f, 3.08741946e-02f, -1.86047077e-01f, 6.99082091e-02f, 3.41522247e-02f, 2.90734526e-02f, -1.55493855e-01f, 6.19806498e-02f, -5.88246062e-02f, 1.48599148e-02f,
  -3.45868506e-02f, -9.28717777e-02f, -6.47238269e-02f, -2.27820575e-02f, -3.51743922e-02f, -7.14071169e-02f, 2.73709688e-02f, 1.53368950e-01f, -4.86366823e-02f, 2.15336811e-02f,
  1.05857074e-01f, 2.58169398e-02f, -2.94824302e-01f, -1.85887329e-02f, -9.05733109e-02f, 2.34305128e-01f, 1.55629218e-01f, -1.57684878e-01f, -1.92761049e-01f, 2.34044194e-01f,
  1.74189031e-01f, -6.10911734e-02f, -6.81078508e-02f, 3.07373047e-01f, -7.10094571e-02f, 3.19699869e-02f, 1.72833458e-01f, 1.15320541e-01f, -1.57428727e-01f, 3.29053812e-02f,
  -9.48478580e-02f, 2.32858717e-01f, -6.34755641e-02f, 7.18422830e-02f, 1.48333743e-01f, -1.77997202e-01f, 1.30405203e-01f, -1.42162427e-01f, 7.38708973e-02f, -6.35214010e-03f,
  9.28416550e-02f, -4.06290404e-02f, 1.31974593e-02f, -8.44296888e-02f, 1.61786061e-02f, -7.77266361e-03f, -1.40786786e-02f, 4.66322303e-02f, -1.43521473e-01f, -8.57468545e-02f,
  3.28735411e-02f, -4.83443923e-02f, 2.50233952e-02f, -7.40251318e-02f, 8.45319685e-03f, 1.43800387e-02f, -8.09964910e-02f, -5.97924553e-02f, -2.74471678e-02f, 3.40902656e-02f,
  -1.13664396e-01f, -3.24872113e-03f, -2.70381924e-02f, 6.97992928e-03f, -1.39813229e-01f, -5.28998561e-02f, 3.38415010e-03f, -6.65935352e-02f, -2.58337799e-02f, -7.43825585e-02f,
  3.08116395e-02f, 8.23956430e-02f, 3.23902555e-02f, 8.84051323e-02f, -1.81584228e-02f, 2.35085618e-02f, 1.01618484e-01f, -9.32661071e-03f, -4.88589257e-02f, 8.06401670e-02f,
  5.91221685e-03f, -5.05875237e-02f, -1.97000280e-02f, 6.74285963e-02f, 5.24477586e-02f, 1.03400201e-01f, 9.95790027e-03f, 5.47975339e-02f, -1.47577599e-01f, 1.22722313e-02f,
  -6.24963408e-03f, 1.17066689e-02f, -5.08184768e-02f, -3.86188948e-03f, 1.23730302e-02f, -1.51770890e-01f, 6.05628155e-02f, -1.43827992e-02f, 1.27827236e-02f, 4.78709415e-02f,
  7.84327451e-04f, -1.41190693e-01f, -6.28240258e-02f, 3.14963944e-02f, -1.48329036e-02f, -2.62113418e-02f, 4.43440815e-03f, 6.60249032e-03f, -8.48682597e-02f, -6.31178841e-02f,
  -6.02195077e-02f, 4.05946895e-02f, 6.70850128e-02f, -6.61223754e-02f, 5.95532591e-03f, -2.74766386e-02f, 6.02377728e-02f, -1.07134536e-01f, 6.16751686e-02f, 3.87503356e-02f,
  1.39284998e-01f, -2.25191787e-02f, 1.08880699e-01f, -8.82281587e-02f, 1.67997200e-02f, 1.18543074e-01f, 2.81349327e-02f, -9.53220278e-02f, 5.36100119e-02f, 2.07160842e-02f,
  9.94971301e-03f, -1.79172177e-02f, -9.52771008e-02f, -7.66647682e-02f, -1.54028246e-02f, -1.56612620e-01f, -2.29704510e-02f, -5.07467389e-02f, 8.69029537e-02f, -8.78680721e-02f,
  -1.84919924e-01f, 1.26275048e-01f, 1.23578615e-01f, -1.18386656e-01f, 1.24013312e-01f, 2.25085407e-01f, -1.17268749e-01f, 6.55615777e-02f, 1.16746828e-01f, -2.23878592e-01f,
  8.55178281e-04f, -1.23460852e-01f, 4.29605730e-02f, -1.49950609e-01f, -1.87574044e-01f, -1.87996961e-02f, 9.32799280e-03f, 1.82511043e-02f, -4.78991233e-02f, 4.55747955e-02f,
  -2.59039607e-02f, 1.64018601e-01f, 1.86063647e-02f, 5.83019713e-03f, -9.03650075e-02f, -1.56313367e-02f, 3.19497921e-02f, -2.34392602e-02f, 1.07324459e-01f, -2.35422105e-02f,
  -9.33402851e-02f, -7.70101463e-03f, 8.73803720e-03f, 1.82743371e-02f, 1.55584386e-03f, -9.27431881e-02f, 4.37886789e-02f, -7.67717287e-02f, 4.85225953e-02f, -4.32267152e-02f,
  -3.77125591e-02f, -9.91270225e-03f, -3.71548943e-02f, 2.43258476e-02f, 3.77702303e-02f, 6.47281930e-02f, -2.66187731e-02f, 7.76643157e-02f, -6.39000721e-03f, 1.75465941e-02f,
  3.43817547e-02f, 1.91849470e-01f, 1.31366821e-02f, -4.74562459e-02f, -9.85036790e-02f, -4.75983620e-02f, -4.14611921e-02f, 7.31122270e-02f, -1.68535616e-02f, 9.83158574e-02f,
  3.87463495e-02f, 7.35351741e-02f, 1.05821602e-01f, -6.89052939e-02f, -3.98443490e-02f, -6.50868788e-02f, -9.57608894e-02f, -4.53590369e-03f, -7.50200748e-02f, 8.58541019e-03f,
  -7.78173357e-02f, 9.39188339e-03f, 3.76452245e-02f, 1.40639972e-02f, 7.49236941e-02f, -2.96596643e-02f, -8.88758153e-02f, 5.91268158e-03f, -3.76111791e-02f, 7.27626830e-02f,
  9.46047008e-02f, 1.78207919e-01f, 4.95454185e-02f, 7.28643239e-02f, -4.10831235e-02f, -6.25770018e-02f, 1.56432167e-01f, -8.33365619e-02f, -3.75128314e-02f, 3.30761038e-02f,
  -4.49791066e-02f, 1.14625935e-02f, -1.03748448e-01f, 9.39341933e-02f, -7.30153685e-03f, -9.35526043e-02f, -2.65361797e-02f, 7.42878905e-03f, 2.96509508e-02f, -3.29574235e-02f,
  -2.55720988e-02f, 7.19603077e-02f, 1.86415054e-02f, 2.77520753e-02f, 4.43512574e-02f, -1.63000710e-02f, 8.60155523e-02f, 1.30520746e-01f, -1.22555636e-03f, -3.08157448e-02f,
  -3.91465187e-01f, 2.82528996e-01f, -1.56362846e-01f, 1.63534135e-01f, -1.69419721e-01f, 1.29152134e-01f, 2.90920854e-01f, 7.00138882e-02f, 2.42200404e-01f, 2.17604160e-01f,
  4.80614528e-02f, 5.79149276e-02f, 1.42148972e-01f, 2.16621265e-01f, -9.16675702e-02f, 2.54203737e-01f, 2.40510210e-01f, 1.31011426e-01f, 1.18665528e-02f, -9.61747319e-02f,
  -1.99668426e-02f, 3.30932252e-02f, -7.60321617e-02f, -7.02159405e-02f, -9.17581096e-02f, -3.99218127e-02f, -8.53258148e-02f, -4.31434810e-02f, 1.01416007e-01f, -6.82030097e-02f,
  8.04148614e-02f, 4.46455739e-02f, -7.29120970e-02f, 4.75845747e-02f, -5.42484857e-02f, 1.10085541e-02f, 5.04064411e-02f, -8.85374658e-03f, -6.06983453e-02f, -2.50841882e-02f,
  -5.73142245e-02f, -2.51845922e-02f, -2.39582174e-02f, 1.27630839e-02f, 1.25869745e-02f, -1.20562598e-01f, 1.26063274e-02f, 1.14837281e-01f, 1.18447073e-01f, -4.93325740e-02f,
  2.26780046e-02f, 7.61757717e-02f, -6.78059757e-02f, 9.19419751e-02f, -2.67422553e-02f, -7.81714693e-02f, 1.31483629e-01f, 2.91699395e-02f, 3.94398638e-04f, 1.37280496e-02f,
  -5.99218756e-02f, 7.71505311e-02f, -1.62366293e-02f, 3.90397361e-03f, -5.82340360e-02f, -5.36788367e-02f, 6.41716570e-02f, -1.45019311e-02f, 5.39499633e-02f, -7.44801313e-02f,
  8.56367201e-02f, -2.96314768e-02f, -7.76180858e-03f, 5.16170114e-02f, -2.10791770e-02f, 1.09683886e-01f, -2.84740552e-02f, 2.75748465e-02f, 1.14975855e-01f, 5.76224141e-02f,
  9.71004888e-02f, -1.23275697e-01f, -6.23496762e-03f, 8.35744366e-02f, 7.75285438e-02f, -8.06802735e-02f, 2.15203874e-02f, 3.75111997e-02f, -3.82044204e-02f, 5.61202094e-02f,
  7.25974664e-02f, 2.35390007e-01f, 4.63708080e-02f, 1.40511841e-02f, 9.14388150e-02f, -1.03644721e-01f, 7.11068138e-02f, -3.94037776e-02f, 3.16564590e-02f, -1.95274279e-02f,
  -3.09318081e-02f, 3.29718813e-02f, -6.65828288e-02f, 3.78002636e-02f, 9.87322722e-03f, -4.44231331e-02f, -4.58488576e-02f, 6.77499250e-02f, 2.58538201e-02f, -7.97345489e-02f,
  3.20510566e-02f, -2.41186190e-02f, -2.24278141e-02f, 8.24260414e-02f, 2.04114430e-02f, 3.69007140e-02f, -1.82941463e-02f, -6.69421479e-02f, -1.06780324e-03f, -2.62937844e-02f,
  1.07246764e-01f, -7.10002854e-02f, 2.15611905e-01f, 1.39817104e-01f, -4.37453985e-02f, 5.39926514e-02f, -3.10447556e-03f, -8.70320350e-02f, -2.05288336e-01f, -1.67305708e-01f,
  6.98115258e-03f, 2.20875606e-01f, -1.78035006e-01f, 2.04963945e-02f, 3.99024338e-02f, -2.63036609e-01f, -5.73516637e-02f, 1.01300880e-01f, -6.60545155e-02f, 4.51519191e-02f,
  -3.89384963e-02f, -6.04173541e-02f, 1.37922078e-01f, 6.61132410e-02f, 6.39697313e-02f, 1.45638555e-01f, -1.03395863e-03f, 7.44530652e-03f, 2.68982261e-01f, 1.87395707e-01f,
  -8.72031525e-02f, -1.09672345e-01f, 6.52412400e-02f, -2.96868272e-02f, -7.30734505e-03f, 3.14677544e-02f, 4.34086695e-02f, 1.31993353e-01f, 6.19373322e-02f, -1.18925259e-01f,
  2.31558904e-02f, 1.28335714e-01f, 1.37410954e-01f, 5.97550869e-02f, -1.00312963e-01f, 1.33864880e-01f, 6.75511807e-02f, -3.70409973e-02f, 6.71134964e-02f, -3.11371014e-02f,
  5.96507452e-02f, 9.63743553e-02f, 4.03408632e-02f, 5.38467355e-02f, 8.95534467e-04f, -5.93138263e-02f, 4.71335836e-02f, 8.81020352e-02f, 8.66559055e-03f, 6.94945380e-02f,
  -4.99249548e-02f, -1.07139431e-01f, -7.40424395e-02f, 3.26056182e-02f, -2.23389063e-02f, -1.40637588e-02f, -7.36533478e-02f, 3.92867960e-02f, -2.65190029e-03f, -3.04456446e-02f,
  -6.01059534e-02f, -4.01374996e-02f, 4.60661985e-02f, -1.21758230e-01f, -5.97845018e-02f, -1.17801987e-02f, 6.35328516e-02f, 7.04607591e-02f, -4.17378061e-02f, 1.03619637e-03f,
  4.58684973e-02f, -9.41040516e-02f, 2.93658469e-02f, 7.78207462e-03f, -9.47437435e-03f, 4.52463105e-02f, -6.66832272e-03f, -1.21756922e-02f, -1.13629654e-01f, 6.76445365e-02f,
  -3.03177595e-01f, -2.31160462e-01f, -6.13632984e-02f, 9.19040665e-02f, -5.33386283e-02f, -8.46759751e-02f, 4.75999415e-02f, -6.15753718e-02f, -4.22176942e-02f, -1.10424705e-01f,
  -1.24374986e-01f, 4.41110209e-02f, -4.00970317e-02f, 1.00681357e-01f, -1.72464009e-02f, -8.11502337e-02f, -2.93333065e-02f, 3.87955308e-02f, 3.04777343e-02f, -2.20530629e-02f,
  -4.87327836e-02f, 2.87360363e-02f, -1.12139783e-03f, 1.02727696e-01f, 1.66916512e-02f, 1.06516875e-01f, -2.82846484e-02f, 7.73825496e-02f, 4.09238525e-02f, -1.32318974e-01f,
  1.46777913e-01f, 7.63131678e-02f, -2.43536159e-01f, -7.99230300e-03f, 4.61705625e-02f, 2.62997448e-01f, 6.54133186e-02f, 8.56368616e-02f, -4.95922975e-02f, 2.24295765e-01f,
  7.90751204e-02f, 2.06166543e-02f, -1.31544575e-01f, 2.78955817e-01f, 1.47446036e-01f, 4.05555917e-03f, 1.77133784e-01f, 2.43232638e-01f, -1.24108762e-01f, -7.06381630e-03f,
  1.58542972e-02f, 2.30395928e-01f, -6.64209425e-02f, 1.46184027e-01f, 2.59528495e-02f, -3.62446681e-02f, -4.40227538e-02f, -1.56136170e-01f, 4.26114760e-02f, 1.41013548e-01f,
  7.13346750e-02f, -4.13539074e-02f, -3.99202593e-02f, 7.52407685e-02f, -1.03132814e-01f, 2.32411046e-02f, 7.34888762e-02f, -1.02433734e-01f, -3.15874517e-02f, 8.58525559e-03f,
  -6.85955957e-02f, -2.23385692e-02f, 1.09676965e-01f, -2.99645718e-02f, -2.42569447e-02f, -3.35856644e-03f, 4.57457714e-02f, -7.41554797e-02f, -1.12297729e-01f, -6.18878528e-02f,
  -9.92184132e-02f, -4.75820005e-02f, 7.41314366e-02f, 2.77577024e-02f, 1.76693518e-02f, 1.37079269e-01f, 7.95506388e-02f, -7.20333457e-02f, 3.11153904e-02f, 1.15945011e-01f,
  1.02528974e-01f, -5.93898781e-02f, 1.22051246e-01f, -1.16601391e-02f, -5.00054806e-02f, 4.03754488e-02f, -5.38274869e-02f, -7.87186921e-02f, -3.85252424e-02f, -5.07379472e-02f,
  4.00418416e-02f, 6.01399736e-03f, -2.81798970e-02f, 3.81232016e-02f, 3.07456516e-02f, -3.47971395e-02f, 9.28527955e-03f, -3.98651101e-02f, -3.80527787e-02f, -7.69873783e-02f,
  -5.08680083e-02f, -2.59143580e-02f, -1.01781981e-02f, 5.27908988e-02f, -2.95063946e-02f, 6.29382133e-02f, 9.54086557e-02f, -1.39252562e-02f, -1.21105917e-01f, -1.15196360e-02f,
  7.29622915e-02f, 1.17030717e-01f, 1.68113247e-03f, 1.00389346e-01f, 2.55842526e-02f, 4.09718715e-02f, -1.62329189e-02f, 1.70092717e-01f, -6.46148473e-02f, 1.43085029e-02f,
  9.25734267e-02f, -1.00098602e-01f, 1.37513950e-01f, -7.33649433e-02f, 1.89795326e-02f, -2.75888611e-02f, 1.18688799e-01f, -6.50292635e-02f, -3.35356742e-02f, -8.02404210e-02f,
  -2.26863287e-02f, 3.40391765e-03f, -1.04301639e-01f, 2.51856279e-02f, 6.51993304e-02f, -3.04261073e-02f, -5.97877577e-02f, -1.04356788e-01f, 4.29690741e-02f, 7.77349994e-02f,
  -2.72427797e-01f, 1.50875151e-01f, 2.10575145e-02f, -1.42711610e-01f, 7.95477480e-02f, -2.03441098e-01f, -4.20165397e-02f, 1.41631052e-01f, -1.15303390e-01f, 1.05017930e-01f,
  -1.30862482e-02f, -7.59046748e-02f, 9.11690593e-02f, -2.56221384e-01f, -2.94819832e-01f, -2.46257439e-01f, -1.62132189e-01f, -3.97884212e-02f, -1.71334043e-01f, 1.51729271e-01f,
  -1.75378948e-01f, -1.00960732e-01f, -1.64664373e-01f, 1.65995173e-02f, 2.61090901e-02f, 1.63102910e-01f, 2.75554389e-01f, 4.16189209e-02f, 1.09474868e-01f, -2.93466076e-02f,
  -7.04318509e-02f, 1.44531026e-01f, 2.32758448e-02f, -5.95007204e-02f, 1.17336139e-01f, 9.26380679e-02f, 1.28881484e-01f, -3.86798126e-03f, -4.27085236e-02f, 3.13852504e-02f,
  4.41230871e-02f, 4.40740995e-02f, 8.82886630e-03f, -5.05318567e-02f, 1.32220695e-02f, -6.69936538e-02f, -3.63008156e-02f, 2.17031185e-02f, 6.02521487e-02f, -2.96542756e-02f,
  -5.66754863e-02f, -1.78542864e-02f, 2.88919657e-02f, -4.25895639e-02f, -2.39161607e-02f, -4.98483926e-02f, -4.25707698e-02f, -3.89716239e-03f, 4.38906923e-02f, 6.27061864e-03f,
  1.35059264e-02f, 3.46954726e-02f, -2.62046512e-02f, -6.74329326e-02f, -5.68733513e-02f, 7.05088452e-02f, 1.26824109e-03f, 3.92931310e-04f, -5.41757084e-02f, 2.36708913e-02f,
  3.08450777e-02f, 2.11529583e-02f, -3.50469537e-03f, 3.27535197e-02f, 2.39997562e-02f, -4.51852232e-02f, -6.67977408e-02f, 2.67354604e-02f, -3.93228382e-02f, -8.65877792e-02f,
  1.04642689e-01f, -4.57422249e-02f, -3.58805730e-04f, 7.67116025e-02f, -5.05881421e-02f, -4.31905240e-02f, 3.27976719e-02f, 2.02176925e-02f, 4.59961258e-02f, -9.61316051e-04f,
  1.55781105e-01f, 1.68568581e-01f, 8.92828591e-03f, -1.41777694e-02f, -8.61577597e-03f, -3.48054543e-02f, -8.21253210e-02f, 1.68135427e-02f, -3.73143610e-03f, -2.47421935e-02f,
  1.94018468e-01f, -4.79767323e-02f, 5.54411113e-02f, -9.07882079e-02f, 2.14389358e-02f, 2.96335984e-02f, 8.33880305e-02f, 2.65796222e-02f, 2.07602046e-02f, -4.84514832e-02f,
  7.15124980e-02f, 6.03671558e-02f, -1.01162009e-01f, 5.56100858e-03f, -1.62858944e-02f, -5.91629557e-03f, 1.86693203e-02f, 8.81939083e-02f, 6.65305853e-02f, 5.96838929e-02f,
  -2.97671527e-01f, 4.62861568e-01f, 1.93664312e-01f, 3.10016666e-02f, -7.47279152e-02f, 2.41824225e-01f, 1.90312952e-01f, -3.74459140e-02f, 2.71257669e-01f, 1.50194377e-01f,
  -1.67577833e-01f, 2.10295141e-01f, -1.79658215e-02f, 2.85360124e-02f, 2.27205288e-02f, 5.51447645e-02f, 1.20532766e-01f, 1.24768756e-01f, 1.13242537e-01f, -7.70946741e-02f,
  1.13957899e-03f, -1.85116574e-01f, -1.20198160e-01f, -1.37047201e-01f, -1.50467113e-01f, -4.51272130e-02f, -2.77658612e-01f, 9.57858339e-02f, 5.91209754e-02f, 7.15611577e-02f,
  -1.23626776e-01f, -5.24584539e-02f, -1.34646833e-01f, 1.75294187e-02f, -1.20080425e-03f, 2.30573602e-02f, 5.95269501e-02f, -5.74835688e-02f, -3.86925181e-03f, 6.80102780e-02f,
  6.83432538e-03f, -1.52889704e-02f, 1.53912917e-01f, -3.08313943e-03f, -1.24598462e-02f, 9.36697125e-02f, 5.54067157e-02f, -2.02430822e-02f, 1.01581290e-01f, -5.02183139e-02f,
  8.28215480e-02f, 5.57344034e-03f, -7.01376125e-02f, 8.96518379e-02f, 3.04985121e-02f, 1.43729150e-01f, 3.46861929e-02f, -3.65418419e-02f, 6.94750696e-02f, 1.47695363e-01f,
  1.28459167e-02f, 9.79204625e-02f, -7.32608065e-02f, -1.32005755e-02f, 4.02025506e-02f, -1.30783230e-01f, 2.39611715e-02f, -1.48213044e-01f, 8.48823488e-02f, -4.18257304e-02f,
  -8.19339305e-02f, -6.88856691e-02f, -3.21593434e-02f, 7.51588643e-02f, 9.25176814e-02f, -8.94131698e-03f, -8.74767080e-02f, 1.50649920e-02f, -1.73568483e-02f, -3.94890979e-02f,
  -2.77052075e-02f, 9.00924280e-02f, 1.24742119e-02f, -8.86470601e-02f, 4.63772044e-02f, -1.90272033e-02f, -1.01405740e-01f, 2.97752582e-03f, 2.68987734e-02f, -9.43139866e-02f,
  1.37779579e-01f, 8.58183354e-02f, 2.29158923e-02f, 1.00222558e-01f, -6.34066612e-02f, 4.88555804e-02f, 2.58959588e-02f, 3.42096388e-03f, 7.64743313e-02f, -1.69263743e-02f,
  3.65462713e-02f, 2.28610728e-02f, -7.19628409e-02f, -1.01393595e-01f, 1.65266007e-01f, 8.52426961e-02f, 2.84959171e-02f, 1.12760574e-01f, -9.22165737e-02f, -1.50885340e-03f,
  -6.07693940e-02f, -2.98697632e-02f, -4.11116369e-02f, -1.10560590e-02f, 3.41277989e-03f, -1.72292534e-02f, -2.00274978e-02f, -2.73856800e-02f, -9.23718661e-02f, 1.36133386e-02f,
  1.05895296e-01f, 2.20548764e-01f, -1.29364833e-01f, 6.69524819e-02f, -2.62904279e-02f, 1.17425874e-01f, 1.02370344e-01f, 2.19817296e-01f, 1.62515953e-01f, 1.62486985e-01f,
  7.54671991e-02f, 5.44699393e-02f, -5.61612844e-02f, 3.06435317e-01f, 1.82915688e-01f, 1.29991854e-02f, 2.34329596e-01f, 7.57739544e-02f, 1.01467408e-01f, 2.49402836e-01f,
  -1.28510185e-02f, 2.01306865e-01f, 3.28960828e-02f, 3.99051346e-02f, 3.16716656e-02f, -1.19982518e-01f, -9.43479910e-02f, -8.85918662e-02f, -4.46541235e-02f, 2.29135784e-03f,
  -2.12988281e-03f, 6.60614744e-02f, 5.29666282e-02f, -8.10621530e-02f, -5.30860238e-02f, 1.34621412e-02f, -1.54598877e-01f, -1.54784739e-01f, -5.81504889e-02f, 5.41271158e-02f,
  1.09955035e-02f, 3.63875255e-02f, 1.00016976e-02f, -8.40635449e-02f, 3.81388590e-02f, 3.77418436e-02f, 9.21986550e-02f, -4.94297873e-03f, 6.14529662e-02f, -6.60101697e-02f,
  -3.28468829e-02f, -2.26307008e-02f, 7.89647400e-02f, -8.28742906e-02f, -5.83155490e-02f, -8.42485670e-03f, -6.00949600e-02f, -3.06486897e-02f, 4.76853773e-02f, -4.36227284e-02f,
  1.67165212e-02f, 4.45606411e-02f, 1.01733170e-02f, 2.20162887e-02f, 3.31422165e-02f, 2.26399675e-02f, 5.58062457e-02f, -4.25525531e-02f, -3.62229496e-02f, 1.13684900e-01f,
  2.53876485e-02f, -5.81695735e-02f, 6.34437129e-02f, 2.71700080e-02f, -5.95722087e-02f, 2.11204849e-02f, 1.90590578e-03f, -1.05318241e-02f, 3.81147303e-02f, -2.31225453e-02f,
  -6.27477700e-03f, 6.17952049e-02f, -6.37403652e-02f, -1.19776905e-01f, 3.99550311e-02f, -1.05488151e-01f, -7.54162669e-03f, 2.57969722e-02f, -7.63000688e-03f, 6.78934455e-02f,
  1.26208952e-02f, 5.57453409e-02f, -4.56271060e-02f, -7.68850446e-02f, 2.29273234e-02f, 5.09992801e-02f, 1.23962145e-02f, 6.65894970e-02f, -2.35151183e-02f, -2.67810244e-02f,
  1.07097253e-02f, -1.08447019e-02f, -6.02725223e-02f, 7.69766718e-02f, 1.84597913e-02f, 9.57315043e-02f, -5.13512269e-02f, -1.40523333e-02f, 1.67616099e-01f, 3.67042795e-02f,
  -4.27857265e-02f, 1.14754168e-02f, 5.95246851e-02f, 3.86129096e-02f, -2.11802982e-02f, 2.70062182e-02f, 3.91831286e-02f, 1.37793412e-02f, 4.73367684e-02f, 9.84491631e-02f,
  -5.32836020e-02f, -1.54738680e-01f, 8.57219659e-03f, 1.35236740e-01f, 1.08693555e-01f, -2.04625264e-01f, -1.40672043e-01f, 1.28287345e-01f, -2.50685602e-01f, -2.04321966e-02f,
  -3.19056842e-03f, -9.48257372e-02f, -1.16598070e-01f, 2.81031597e-02f, 1.93395659e-01f, -1.91318348e-01f, -1.01446770e-02f, -9.27335173e-02f, -2.94176000e-03f, 9.85672548e-02f,
  1.30248860e-01f, 1.73549101e-01f, 1.52632833e-01f, 3.05080116e-01f, 2.56818291e-02f, 1.28937319e-01f, 2.95667470e-01f, 9.61130112e-03f, 2.71027535e-01f, 1.08262181e-01f,
  -2.07088813e-02f, -4.41139005e-02f, 4.30840291e-02f, -7.43277445e-02f, 2.14954708e-02f, -1.60615109e-02f, 1.57364514e-02f, 7.92568848e-02f, 2.28151605e-02f, -1.60283074e-02f,
  -3.89123559e-02f, 3.40145193e-02f, 7.01784492e-02f, -1.33900130e-02f, -9.26619302e-03f, 1.03536956e-02f, 4.46675457e-02f, -2.21211221e-02f, -1.10998876e-01f, 5.56116775e-02f,
  -4.38397266e-02f, -1.49075910e-02f, 7.74998916e-03f, 5.14810719e-02f, -2.08171494e-02f, 5.23721091e-02f, 6.65301010e-02f, -9.11356509e-02f, 1.84474159e-02f, -4.91860416e-03f,
  -5.17503358e-02f, -1.08875539e-02f, -4.83272411e-02f, 6.63350224e-02f, 3.83437946e-02f, -4.48973328e-02f, -6.29260996e-03f, 6.48341700e-02f, 6.46614656e-02f, -3.77060920e-02f,
  1.05570955e-02f, 8.80796313e-02f, 1.44168381e-02f, 2.86108684e-02f, 5.31125478e-02f, -7.93540403e-02f, 4.90494780e-02f, -6.23253174e-02f, -2.15484425e-02f, -2.12639049e-02f,
  1.60154933e-03f, 1.20553598e-02f, -4.84257899e-02f, -7.01120198e-02f, -4.81097624e-02f, -4.66269348e-03f, -3.40102687e-02f, -6.90186843e-02f, 6.88519701e-02f, -3.60064358e-02f,
  -5.64043596e-02f, 1.16087183e-01f, 2.69087497e-02f, -2.71128421e-03f, 1.09128011e-02f, -7.76041597e-02f, -5.35951853e-02f, 5.77181205e-02f, -4.82811444e-02f, 2.61606760e-02f,
  6.01996994e-03f, 1.04631118e-01f, 1.53652150e-02f, 2.98357643e-02f, 1.03283755e-01f, -1.76196285e-02f, 5.44082746e-02f, 7.33733773e-02f, -2.89257150e-02f, 9.97876450e-02f,
  5.66633679e-02f, -3.94626968e-02f, 4.57949862e-02f, 9.89122167e-02f, 2.66705137e-02f, -6.17359728e-02f, 6.83996603e-02f, 5.40344343e-02f, 2.09597033e-03f, 4.46503498e-02f,
  -4.51169133e-01f, 5.50242625e-02f, 2.71961868e-01f, -2.11157039e-01f, -1.57080814e-01f, 1.82554826e-01f, 2.00239703e-01f, -1.73271578e-02f, -1.72994137e-02f, 1.29733056e-01f,
  6.16550334e-02f, 3.11594624e-02f, 1.80293292e-01f, -1.74239259e-02f, 3.93249802e-02f, 1.15894176e-01f, 9.44280028e-02f, -1.48324361e-02f, 6.92327097e-02f, -5.98152280e-02f,
  -7.80337751e-02f, -1.16871625e-01f, 6.51934594e-02f, -5.95840886e-02f, -5.46698198e-02f, -2.69380100e-02f, -1.12277001e-01f, 8.68171677e-02f, -1.02462046e-01f, 2.57004928e-02f,
  -1.39043033e-01f, -2.83301366e-03f, 6.16784720e-03f, 1.33575303e-02f, 2.32000835e-02f, -3.94024402e-02f, 6.39893860e-02f, -5.38745709e-03f, 1.00986063e-02f, 1.18066438e-01f,
  4.04394902e-02f, 4.68191169e-02f, -3.68507802e-02f, -1.26285302e-02f, -2.44783293e-02f, 1.38660870e-03f, -6.21578395e-02f, 4.60018925e-02f, -6.42792284e-02f, 5.26170544e-02f,
  1.33420885e-01f, 4.48427275e-02f, -1.52829783e-02f, 4.99774478e-02f, 3.65297659e-03f, -8.07197019e-02f, 8.34829733e-02f, 7.67534450e-02f, -8.79944563e-02f, -4.90925796e-02f,
  2.68840697e-02f, -6.65826872e-02f, 1.18535720e-01f, 1.23490102e-03f, 4.66288850e-02f, -1.79312602e-01f, -6.69533527e-03f, 5.40798828e-02f, 1.97165762e-03f, 7.27756023e-02f,
  -4.15633544e-02f, -2.22364962e-02f, -1.92781985e-02f, -1.41757717e-02f, -5.01951389e-02f, 5.56634329e-02f, -4.83438708e-02f, -1.29529372e-01f, -1.30050378e-02f, -9.56298262e-02f,
  4.23525274e-02f, -8.46443772e-02f, 3.12536098e-02f, 6.56600371e-02f, -3.98262404e-02f, 1.62590051e-03f, 8.28994960e-02f, 9.37483683e-02f, -1.32774413e-02f, 1.92627888e-02f,
  -2.37835109e-01f, -1.94078580e-01f, -1.68158114e-01f, -6.61818534e-02f, 3.12054604e-02f, -3.01346602e-03f, -2.83850003e-02f, -9.66371223e-02f, -9.95723456e-02f, -3.65448669e-02f,
  -6.33524135e-02f, -3.39630023e-02f, -7.21426606e-02f, 1.12176752e-02f, -1.34820007e-02f, -9.93184838e-03f, 3.44321616e-02f, -7.31043294e-02f, 1.45639265e-02f, 1.98517758e-02f,
  -1.05438326e-02f, 3.18523124e-02f, 3.61014120e-02f, -5.36616892e-02f, 1.51373409e-02f, -4.99705374e-02f, -7.74308220e-02f, 1.69752520e-02f, 8.86434689e-02f, -3.75473388e-02f,
  1.49725407e-01f, -9.06072184e-02f, -5.58277257e-02f, 3.96362990e-02f, -2.09409501e-02f, 1.00493208e-01f, 2.68567000e-02f, -1.05004542e-01f, -2.08389908e-01f, -1.75397515e-01f,
  1.01346977e-01f, 4.99209464e-02f, 8.31872299e-02f, 2.65670359e-01f, 2.45662764e-01f, -8.91596824e-02f, 9.47785228e-02f, 7.79144615e-02f, -9.66288298e-02f, 4.16435068e-03f,
  7.66278878e-02f, 2.32021093e-01f, 1.42665043e-01f, 6.40820619e-03f, 5.43100908e-02f, -1.48772728e-02f, 1.72846898e-01f, 7.76227564e-02f, 2.13535026e-01f, 1.38049364e-01f,
  6.35276958e-02f, -1.67643614e-02f, 2.16997694e-02f, 5.43204807e-02f, -9.42379311e-02f, -5.91915622e-02f, 9.91968885e-02f, 1.01889670e-01f, -1.50665119e-02f, 1.24483490e-02f,
  5.48307784e-02f, 5.81463575e-02f, 9.00983438e-03f, 7.09104612e-02f, -1.11499622e-01f, 3.78073077e-03f, -1.49250835e-01f, 1.98840741e-02f, 3.00526172e-02f, -7.53762946e-03f,
  -7.17706457e-02f, 7.81214144e-03f, -1.16047217e-02f, 9.36321169e-03f, -9.40057710e-02f, -3.36353853e-02f, 9.31921080e-02f, -5.05920127e-02f, 4.69411016e-02f, -1.28237426e-01f,
  8.03525671e-02f, 2.06903387e-02f, -2.72103911e-03f, 1.00475863e-01f, 9.38474238e-02f, -3.54864337e-02f, 3.62475514e-02f, 4.69902381e-02f, 8.02503601e-02f, -7.21176118e-02f,
  -4.34601121e-02f, -1.09364793e-01f, -4.54491824e-02f, -8.47071409e-02f, 2.08170172e-02f, -9.77486148e-02f, 6.01037294e-02f, -6.16219081e-02f, -1.68777376e-01f, -6.86567426e-02f,
  -3.69132753e-03f, 3.29796667e-03f, 1.72881316e-02f, -1.08941470e-03f, 3.24410982e-02f, -8.43353942e-02f, -1.76816192e-02f, 9.64793004e-03f, -1.88909620e-02f, -1.45554254e-02f,
  -7.25315809e-02f, -7.93991163e-02f, -7.69067034e-02f, -8.99304356e-03f, -4.03975360e-02f, -4.93626408e-02f, 9.56764631e-03f, -8.28525573e-02f, -1.71418376e-02f, -4.46307473e-02f,
  7.55691454e-02f, -1.84702016e-02f, -6.82854727e-02f, -3.48415524e-02f, 1.26665324e-01f, -1.19890377e-01f, -3.45054157e-02f, -1.67149901e-02f, -8.19466189e-02f, -1.67993046e-02f,
  -7.31822029e-02f, -7.30733946e-02f, 1.25497067e-02f, -4.50539701e-02f, 5.75415231e-03f, -6.01931661e-02f, -5.52577749e-02f, -7.19929934e-02f, 3.87880541e-02f, 1.97987705e-02f,
  2.35937193e-01f, -2.16400698e-01f, 3.04542124e-01f, -7.72986282e-03f, 2.54715472e-01f, 2.39075139e-01f, 2.88730055e-01f, 6.61232090e-03f, 8.59487802e-02f, -1.81717381e-01f,
  -1.11699596e-01f, 5.22959828e-02f, 1.39231667e-01f, -1.57312840e-01f, 3.05608004e-01f, 4.52868156e-02f, -1.22524828e-01f, -6.43471777e-02f, 2.82479520e-03f, -9.90670081e-03f,
  5.35295308e-02f, -1.89481348e-01f, -3.67171764e-02f, -3.51586461e-01f, -2.07173735e-01f, -7.71365762e-02f, -9.83699262e-02f, 7.40375463e-03f, -2.38776043e-01f, -1.06519759e-02f,
  4.48172316e-02f, -6.37318343e-02f, -4.26316448e-02f, -1.08179571e-02f, -1.03780612e-01f, 5.26768826e-02f, -2.17477567e-02f, 6.18938319e-02f, 8.79182592e-02f, 1.71750765e-02f,
  2.27293093e-02f, 4.86350283e-02f, -1.97675452e-02f, 4.15565819e-02f, 5.09907082e-02f, 1.24027608e-02f, 2.94237994e-02f, 7.44099321e-04f, 7.00709969e-02f, 2.67025698e-02f,
  2.85417382e-02f, 8.89424793e-03f, 3.40399742e-02f, -2.34208126e-02f, 2.36387048e-02f, 3.70686874e-02f, 6.71245381e-02f, 4.55574282e-02f, -2.66056731e-02f, -1.99751053e-02f,
  -1.04192808e-01f, -4.05667312e-02f, 6.25430197e-02f, -1.15098059e-01f, 2.51164772e-02f, -3.84847820e-02f, -2.55966485e-02f, 2.97160298e-02f, -1.17167993e-03f, 3.93066369e-02f,
  5.71618266e-02f, -4.14746627e-02f, -2.46345177e-02f, 4.93241884e-02f, -1.22886106e-01f, 6.73794597e-02f, 5.24225160e-02f, -4.31294106e-02f, -2.53960676e-02f, -2.52253823e-02f,
  8.20623115e-02f, 4.54193018e-02f, -9.40642878e-02f, -1.44650391e-03f, -1.60315204e-02f, 8.93839374e-02f, -4.37060222e-02f, -2.64368225e-02f, -3.85938957e-02f, 3.17579322e-02f,
  -1.64373949e-01f, -7.73050413e-02f, -4.87248115e-02f, -1.10206529e-01f, -2.04375014e-02f, -5.58462702e-02f, 5.83157614e-02f, -3.51487398e-02f, -6.17982969e-02f, -4.28353716e-03f,
  -6.58812895e-02f, -6.89388067e-02f, 1.12211011e-01f, -6.99056163e-02f, -7.55216777e-02f, -3.11731994e-02f, -4.56806784e-03f, -2.97142789e-02f, -1.60420537e-02f, -9.79707390e-02f,
  -1.39247021e-02f, -4.79822569e-02f, 2.66597290e-02f, -6.32786527e-02f, -1.42000303e-01f, -4.40381393e-02f, 2.69214902e-03f, -1.11963286e-03f, -1.09441932e-02f, 3.47631276e-02f,
  2.09876850e-01f, -1.15324520e-01f, 4.97912988e-02f, -3.53359133e-02f, -1.57806545e-01f, -1.00633472e-01f, -2.41821125e-01f, -1.04639672e-01f, -3.08857083e-01f, -1.75302133e-01f,
  -9.06435549e-02f, -1.11473436e-02f, 3.48225944e-02f, -1.82660520e-01f, 2.12415233e-01f, -1.23988979e-01f, -1.36283278e-01f, -5.96951209e-02f, 4.79792617e-02f, 8.18984136e-02f,
  1.78618997e-01f, 4.00740020e-02f, 1.17964827e-01f, 1.10332325e-01f, -5.57107888e-02f, 1.71616599e-01f, 3.19944233e-01f, 8.46966505e-02f, 2.00393975e-01f, 3.61721367e-02f,
  -1.45890266e-01f, 1.47760464e-02f, -4.00769971e-02f, -1.83125827e-02f, 1.08869307e-01f, 3.38831842e-02f, 6.11888394e-02f, 9.11894441e-02f, 4.07400765e-02f, -2.94470135e-02f,
  -5.88685200e-02f, 1.72246881e-02f, -3.87647445e-03f, 5.58226788e-03f, -3.34182456e-02f, -1.29244208e-01f, -4.83599445e-03f, -3.51996976e-03f, -1.90283787e-02f, 7.15382248e-02f,
  -6.86176196e-02f, 2.95809917e-02f, 2.77065746e-02f, 3.69060859e-02f, -1.02618866e-01f, -7.36493170e-02f, 4.73516770e-02f, 6.40655905e-02f, -1.50227323e-01f, 1.22235626e-01f,
  4.96150106e-02f, -2.80717388e-02f, -5.61176315e-02f, 2.52694804e-02f, 9.21170507e-03f, 2.88961511e-02f, -8.11099727e-03f, -8.49347338e-02f, 1.00477032e-01f, 2.92735873e-03f,
  -2.35711336e-02f, 1.78076457e-02f, 3.81516069e-02f, -3.54007422e-03f, 5.28865159e-02f, -1.06373936e-01f, 5.89676946e-03f, -5.37931873e-03f, 6.06576912e-02f, -7.68750533e-02f,
  8.02762508e-02f, 9.04106274e-02f, 9.56149995e-02f, 2.75076646e-02f, -4.47054580e-02f, 1.12847403e-01f, 5.29235639e-02f, 1.08780727e-01f, -5.98518774e-02f, 1.00090533e-01f,
  3.35976891e-02f, 6.75305724e-02f, -5.88048548e-02f, -8.45029131e-02f, 2.93368809e-02f, 1.56870410e-02f, 7.99570084e-02f, -1.41913611e-02f, 9.75398496e-02f, -2.50974447e-02f,
  2.97817588e-02f, 1.27958536e-01f, 9.80465580e-03f, 1.70318428e-02f, 1.24845639e-01f, -6.58157319e-02f, 1.80880129e-02f, 1.26903756e-02f, 4.49422710e-02f, 7.50483871e-02f,
  4.61773295e-03f, -1.12574309e-01f, 1.03329621e-01f, -1.41512016e-02f, -1.37567312e-01f, 5.01714833e-02f, 8.82358253e-02f, 3.97771634e-02f, 5.41005358e-02f, 5.19062839e-02f,
  4.79018986e-02f, -4.66561943e-01f, -1.75299063e-01f, -1.95672526e-03f, 1.60029665e-01f, 2.11531535e-01f, 6.54900149e-02f, -2.17163667e-01f, -2.64623016e-01f, -2.40191787e-01f,
  6.83647320e-02f, -6.06088974e-02f, -1.19635738e-01f, -2.03571599e-02f, 2.03483775e-01f, -2.29500860e-01f, -6.35368563e-03f, 1.08164907e-01f, -5.11428975e-02f, -5.18171005e-02f,
  -9.25163180e-03f, 1.63091362e-01f, 1.74224190e-02f, -5.03759924e-03f, 6.24970794e-02f, -7.60258883e-02f, 8.23231339e-02f, 1.16839230e-01f, 1.60366714e-01f, 7.90707320e-02f,
  2.14361195e-02f, -3.36247198e-02f, 2.81837620e-02f, 5.88413131e-05f, 7.97667447e-03f, 1.00949205e-01f, 4.90476862e-02f, 6.64690882e-02f, 1.38742551e-01f, -8.20883587e-02f,
  4.99236621e-02f, -5.21146692e-02f, -1.19404271e-01f, 1.02105200e-01f, -4.08717394e-02f, -5.23708239e-02f, -4.24717106e-02f, 2.96773831e-03f, -1.76010862e-01f, -1.17337272e-01f,
  -7.37687051e-02f, -1.50333166e-01f, -1.68071330e-01f, -7.24394768e-02f, -5.06023876e-02f, -9.23394039e-02f, -7.63271973e-02f, 3.00094280e-02f, -5.05072847e-02f, -7.80875385e-02f,
  4.85475175e-02f, 7.42588863e-02f, -1.06609985e-01f, -1.23020494e-02f, 2.63808016e-02f, -4.84155975e-02f, 9.94824711e-03f, -6.95738895e-03f, 1.99611951e-02f, -6.01723492e-02f,
  -7.63588073e-03f, -6.10108022e-03f, -1.41914738e-02f, 4.56926785e-02f, -7.13104457e-02f, -6.19403794e-02f, 1.05460003e-01f, -2.25662850e-02f, 8.92991871e-02f, 6.57959580e-02f,
  -3.67637165e-02f, -2.29610838e-02f, -3.00373454e-02f, 6.47362545e-02f, 2.01863833e-02f, 6.09441176e-02f, -2.09910572e-02f, -1.94275565e-02f, 4.54735793e-02f, 4.31387238e-02f,
  2.32642796e-02f, -2.66249329e-01f, -5.72218113e-02f, 5.32535128e-02f, 1.61646511e-02f, 1.37634560e-01f, 8.87051821e-02f, -5.48575819e-02f, -1.13062486e-02f, -4.65841256e-02f,
  6.00307360e-02f, 4.32611705e-04f, -1.08556710e-01f, 4.11277004e-02f, -2.35997960e-02f, 1.74698681e-02f, -4.34990786e-03f, 2.39400025e-02f, 3.88728157e-02f, -2.69117318e-02f,
  -1.41171059e-02f, 5.18198982e-02f, -7.58464262e-02f, 3.74313518e-02f, -3.47190234e-03f, -2.44379472e-02f, 1.30307805e-02f, -1.69585794e-02f, 1.92507058e-02f, -1.88927492e-03f,
  -5.23733199e-01f, 2.08085626e-01f, -9.26969871e-02f, -1.56674383e-03f, -3.88085772e-03f, 1.19358324e-01f, 1.38991132e-01f, -2.81882342e-02f, -1.25186607e-01f, 2.08064094e-01f,
  1.41695932e-01f, -1.57895878e-01f, 1.70990989e-01f, 2.37817898e-01f, -2.15620250e-01f, 2.00390384e-01f, 1.36458024e-01f, 3.30153406e-02f, -2.36149319e-03f, -9.79498848e-02f,
  -6.60586134e-02f, 1.25188395e-01f, 9.17626172e-02f, 9.74497944e-02f, -1.85098618e-01f, -7.70831034e-02f, -6.21866584e-02f, -4.95240614e-02f, 1.12249414e-02f, -8.53089392e-02f,
  -2.68924415e-01f, -1.70238197e-01f, -1.40523657e-01f, -1.05285935e-01f, -1.85186073e-01f, -7.21449107e-02f, -1.00055136e-01f, -9.63065699e-02f, -8.99024308e-02f, 4.13548872e-02f,
  -1.02671549e-01f, -1.92211987e-03f, 4.38845977e-02f, 2.37673684e-03f, -4.86429147e-02f, 1.46221938e-02f, 4.89065051e-02f, 6.28484860e-02f, -2.13098507e-02f, 1.10415760e-02f,
  -1.45766316e-02f, 2.18675490e-02f, -4.70706038e-02f, 1.02005064e-01f, 1.39245391e-02f, 4.97103147e-02f, 4.67262454e-02f, -8.78143162e-02f, -1.11789657e-02f, 9.84934419e-02f,
  -8.96495651e-04f, 3.00813224e-02f, 3.16248015e-02f, -1.08854808e-02f, -1.48761636e-02f, 6.84745163e-02f, 7.60166794e-02f, -2.05456205e-02f, 1.52999267e-03f, 3.49036604e-02f,
  1.64042469e-02f, -5.58225475e-02f, 2.52612270e-02f, 3.44272330e-02f, 1.42300259e-02f, -6.44975230e-02f, 6.97403699e-02f, -6.66700006e-02f, 5.46855405e-02f, -2.14861296e-02f,
  -7.16554224e-02f, -1.03555195e-01f, 3.07556093e-02f, 1.68837607e-02f, -1.20315840e-02f, 4.52447459e-02f, 3.16897844e-04f, 1.55697586e-02f, 1.30433207e-02f, 2.02761013e-02f,
  -1.46695048e-01f, -1.64863259e-01f, 2.55013593e-02f, -1.17272757e-01f, -8.90238490e-03f, 9.07216966e-03f, -2.00623572e-02f, -7.91567191e-02f, 1.67297814e-02f, -2.44073197e-02f,
  -1.34862736e-01f, -9.75527018e-02f, -4.85203117e-02f, 3.36728357e-02f, 3.62126678e-02f, 1.22468419e-01f, 1.83329191e-02f, -5.94220608e-02f, 1.33415265e-02f, -3.43311131e-02f,
  1.60936508e-02f, -1.35734146e-02f, 1.49494056e-02f, 8.73005688e-02f, -5.43621331e-02f, -5.84828928e-02f, -8.70050043e-02f, -4.53351699e-02f, 3.94561850e-02f, 5.24105765e-02f,
  1.45065859e-01f, 3.84034514e-02f, 2.78282613e-01f, 2.70039678e-01f, 1.69014752e-01f, 1.37997985e-01f, 2.42461577e-01f, 1.69863924e-01f, 3.82566363e-01f, 7.31013529e-03f,
  -1.18851826e-01f, 1.41749829e-01f, -6.06302880e-02f, -1.72168389e-02f, 5.70918545e-02f, 8.18569399e-03f, 2.00876798e-02f, 5.93356788e-02f, 1.71664774e-01f, 9.87732112e-02f,
  4.24683057e-02f, -1.32931337e-01f, -1.46819457e-01f, -1.53680980e-01f, -1.25618309e-01f, 2.37766355e-02f, -2.50932574e-01f, -8.53054523e-02f, -2.48629108e-01f, -7.06711188e-02f,
  5.12795933e-02f, 1.53093368e-01f, -2.77931914e-02f, -1.93322506e-02f, 5.67126041e-03f, -3.58403809e-02f, -9.88187343e-02f, -4.95421588e-02f, 2.63812263e-02f, -7.18320385e-02f,
  1.15670692e-02f, -6.53597787e-02f, -2.87966561e-02f, -9.32150148e-03f, -4.61789488e-04f, -2.58702207e-02f, 1.73363611e-02f, -1.00447470e-02f, 8.17518774e-03f, -4.38313037e-02f,
  1.44720674e-02f, 1.36849567e-01f, -1.42463641e-02f, 7.35010812e-03f, -1.72808254e-03f, 2.18380010e-03f, 7.03476295e-02f, 2.05582082e-02f, 3.55218612e-02f, -5.54982154e-03f,
  2.56335665e-03f, 6.50772825e-02f, -9.71347839e-02f, 3.50231491e-02f, 1.97014268e-02f, 2.69244295e-02f, 1.00096622e-02f, -6.58511650e-03f, 2.40178895e-04f, -6.09599128e-02f,
  -6.30077124e-02f, -7.32692033e-02f, 2.27192100e-02f, 7.79027492e-02f, 1.22833475e-02f, -3.23085412e-02f, -7.55451173e-02f, -4.18182537e-02f, 7.37660527e-02f, -1.04705514e-02f,
  4.76017110e-02f, -5.18874936e-02f, -6.57694265e-02f, -6.44330978e-02f, -3.49284825e-03f, 6.13484439e-03f, 1.40400147e-02f, 8.86817202e-02f, -7.50533789e-02f, 3.72290649e-02f,
  8.17965418e-02f, 1.44359663e-01f, -6.06727377e-02f, -9.18936208e-02f, 7.27659911e-02f, -5.38508687e-03f, 6.39796332e-02f, 1.10141747e-02f, 1.04532100e-01f, 3.66257764e-02f,
  1.39593268e-02f, 3.90254222e-02f, -7.36699924e-02f, -7.47378320e-02f, -5.10447063e-02f, -2.74425205e-02f, -5.59447799e-04f, -1.13138380e-02f, -7.48363808e-02f, -2.69640237e-02f,
  -2.70943381e-02f, 4.18169945e-02f, 4.19246666e-02f, -1.43074036e-01f, -5.50347157e-02f, -2.83792093e-02f, -8.96573626e-03f, -3.13814245e-02f, 6.32028934e-03f, 5.61034270e-02f,
  1.18039688e-02f, -2.97081351e-01f, 5.41517623e-02f, 2.17150062e-01f, 3.19073088e-02f, -1.42475456e-01f, 3.84406112e-02f, -1.00871203e-02f, -2.22834632e-01f, -3.37126613e-01f,
  -5.96224181e-02f, -4.99662273e-02f, 4.76047471e-02f, -3.93628068e-02f, 2.86229640e-01f, 3.81412706e-03f, 1.26620576e-01f, -1.52747557e-02f, 8.73710588e-02f, 1.41272575e-01f,
  1.34083465e-01f, 9.65130776e-02f, 2.61189580e-01f, 1.66605264e-01f, 1.54429510e-01f, 6.39842376e-02f, 1.81059554e-01f, 1.52308345e-01f, 1.66601017e-01f, 8.73606652e-02f,
  -1.05320267e-01f, -2.00900398e-02f, -3.91842946e-02f, -9.16907340e-02f, 6.46688277e-03f, 5.46414871e-03f, 3.41205224e-02f, 1.05210215e-01f, 7.96604827e-02f, 3.99682745e-02f,
  -5.42921647e-02f, 8.08846429e-02f, 7.23207090e-03f, 2.40628794e-02f, 1.32336980e-02f, 2.28475351e-02f, 7.75331482e-02f, -7.85066858e-02f, 1.16643636e-02f, -9.67674796e-03f,
  -4.07931171e-02f, -8.01113471e-02f, 2.99939681e-02f, 5.34728058e-02f, 8.36418718e-02f, -2.67720446e-02f, 5.34950644e-02f, 8.01327601e-02f, -8.85692164e-02f, 3.29735167e-02f,
  -5.40190041e-02f, -4.69151959e-02f, 8.11763927e-02f, 3.78817157e-03f, -7.79609531e-02f, 4.89183851e-02f, 6.83108671e-03f, -2.42228433e-02f, 6.36982620e-02f, 1.89529825e-02f,
  5.93838096e-02f, -4.55780700e-02f, -6.11094087e-02f, -1.02292839e-02f, -3.12380791e-02f, -2.24228837e-02f, 9.10826176e-02f, 1.42441280e-02f, -1.71316117e-02f, -5.16705140e-02f,
  8.28941986e-02f, 5.90369292e-02f, -3.73231396e-02f, 3.97550836e-02f, -3.42629366e-02f, -1.10805249e-02f, -4.87391762e-02f, -4.58716080e-02f, 5.85097075e-02f, 1.51055396e-01f,
  -3.90184335e-02f, -1.10505559e-01f, 3.17787975e-02f, -2.09285449e-02f, 3.91645636e-03f, -7.94727281e-02f, -1.01845689e-01f, 4.24998477e-02f, -7.10254982e-02f, -4.51031514e-02f,
  -3.37137505e-02f, 1.33585125e-01f, -1.56520173e-01f, 6.64422214e-02f, -2.71104020e-03f, -4.21908610e-02f, -1.55550083e-02f, -9.69604999e-02f, -8.88471007e-02f, -2.06179973e-02f,
  2.35669352e-02f, 6.29364476e-02f, 5.48963249e-02f, 9.41830575e-02f, 4.30005938e-02f, -7.58979619e-02f, -4.71408144e-02f, -9.46291015e-02f, 8.90172645e-02f, 8.02888572e-02f,
  -1.24861293e-01f, 5.70090637e-02f, 6.14965372e-02f, -9.17638242e-02f, -1.13460205e-01f, -2.63126999e-01f, -2.97438323e-01f, 2.09936071e-02f, -4.96384092e-02f, -1.09662453e-03f,
  -6.92592189e-02f, 7.57529587e-02f, 2.29349136e-02f, -1.23599574e-01f, -1.25544280e-01f, -1.73411325e-01f, -1.67599142e-01f, -5.94630577e-02f, -4.76813503e-02f, 8.92569348e-02f,
  4.74748537e-02f, -1.23048045e-01f, 7.06821457e-02f, 3.36886048e-02f, -5.57827502e-02f, 2.17176139e-01f, 2.24576384e-01f, 4.34037624e-03f, 7.53087411e-03f, -1.49421185e-01f,
  -6.18026182e-02f, 6.09032921e-02f, -5.00090867e-02f, -6.28732368e-02f, 1.22614220e-01f, -4.25742082e-02f, -4.96861665e-03f, 1.52528957e-02f, 2.58700773e-02f, -8.34768340e-02f,
  -1.37512535e-02f, -1.53579926e-02f, -4.36110683e-02f, -8.33523124e-02f, -3.49981301e-02f, 3.07073463e-02f, 4.25795726e-02f, 1.14893191e-01f, -1.39002472e-01f, -3.88868600e-02f,
  -1.56937726e-03f, -5.91487475e-02f, 6.56211451e-02f, 1.07433520e-01f, 4.45942916e-02f, -4.03982997e-02f, 4.76947613e-02f, 2.44855490e-02f, 6.40206337e-02f, 7.14878291e-02f,
  1.32733509e-01f, -2.94660199e-02f, -2.79797111e-02f, -3.78071479e-02f, -5.28947040e-02f, 8.62325355e-03f, -9.42492113e-02f, -6.16295747e-02f, 1.97980404e-02f, 2.09974777e-02f,
  -8.00088122e-02f, -7.59229362e-02f, -6.10399544e-02f, 6.04540184e-02f, 4.58229445e-02f, -3.58185209e-02f, 2.71961372e-03f, 6.14919886e-02f, -5.15057631e-02f, 8.81831646e-02f,
  -4.88854758e-03f, -3.13053839e-02f, -1.49492882e-02f, -2.81585306e-02f, -1.25711769e-01f, 8.97595007e-03f, -1.03070609e-01f, -1.34495974e-01f, 1.86674893e-02f, -6.32482693e-02f,
  7.53435194e-02f, 1.31480128e-01f, -2.88771503e-02f, 5.18780481e-03f, -7.99177364e-02f, -1.78657994e-02f, -7.03331754e-02f, -9.04823244e-02f, 1.12986401e-01f, -4.25538868e-02f,
  1.14945263e-01f, 7.75031149e-02f, -6.83969781e-02f, 5.02674542e-02f, 1.95424147e-02f, 3.95814069e-02f, 9.97746736e-02f, 8.23693424e-02f, -2.42844317e-02f, 2.16794051e-02f,
  4.74139936e-02f, 8.95507857e-02f, -1.17887966e-01f, 5.19683510e-02f, 3.17619853e-02f, 9.86545756e-02f, -7.04152286e-02f, 5.61294854e-02f, -2.74078194e-02f, -1.04408907e-02f,
  1.03838235e-01f, -1.27217084e-01f, -2.83125155e-02f, -1.77684054e-02f, 2.27580220e-01f, -4.85041365e-03f, 8.15470144e-02f, 1.45367160e-01f, 1.73435837e-01f, -2.60508776e-01f,
  -6.44565672e-02f, -3.04345548e-01f, -1.87632099e-01f, -1.23665355e-01f, -9.56947133e-02f, 3.55085209e-02f, 4.19535600e-02f, -2.35143274e-01f, 1.03629507e-01f, 7.88223743e-03f,
  4.75363582e-02f, -3.59281078e-02f, -3.65480818e-02f, -4.06141207e-02f, 1.06398962e-01f, 1.14593297e-01f, -1.36097491e-01f, -5.29658869e-02f, -1.20456792e-01f, -1.09214865e-01f,
  1.27545983e-01f, 3.67543250e-02f, 6.79925680e-02f, -2.25994866e-02f, 9.88764763e-02f, -1.32315740e-01f, -2.39340402e-02f, -7.36418068e-02f, 1.74216896e-01f, 4.14661281e-02f,
  -8.92451406e-02f, -8.71384740e-02f, 2.98820790e-02f, 1.02598548e-01f, 7.65175298e-02f, 7.25516751e-02f, 1.48398038e-02f, 1.05756253e-01f, -4.34244052e-02f, -8.10956489e-03f,
  4.03633825e-02f, -1.05384365e-01f, 7.74521530e-02f, -6.81026280e-02f, 5.92541955e-02f, 1.97928399e-02f, -3.36951762e-02f, -1.75711289e-01f, -2.74273418e-02f, -5.34426095e-03f,
  -6.53326586e-02f, 9.24112573e-02f, 9.33776349e-02f, 8.66776928e-02f, 5.67617938e-02f, 2.56824885e-02f, -2.66515259e-02f, 2.23418977e-02f, 4.27058451e-02f, -1.24706998e-01f,
  -3.58229619e-03f, 3.97592708e-02f, 4.07606140e-02f, 1.57685190e-01f, 3.14174630e-02f, 5.38145825e-02f, -8.71169046e-02f, 8.63282308e-02f, 3.02681457e-02f, -6.65076077e-02f,
  1.27582669e-01f, 2.98080668e-02f, -8.71924385e-02f, -5.42110391e-02f, -5.44657297e-02f, 5.91480173e-02f, -5.29751442e-02f, 3.85476463e-02f, -1.25182550e-02f, 1.58738699e-02f,
  7.74721289e-03f, -2.48680979e-01f, -5.52628636e-02f, 7.82958418e-02f, -1.64870638e-02f, -7.07052369e-03f, 7.46238232e-02f, 2.23813597e-02f, 8.50483775e-03f, 1.88070461e-02f,
  -2.43254583e-02f, -1.02089271e-01f, -1.46669447e-01f, 3.44889611e-02f, 2.51496024e-02f, 2.57364493e-02f, -8.30639228e-02f, -1.05917931e-03f, -9.37546864e-02f, -8.94059613e-02f,
  3.88192711e-03f, 8.13086890e-03f, -2.76877079e-02f, 7.64024118e-03f, -4.04130332e-02f, -1.30716577e-01f, 3.01846359e-02f, -6.21715467e-03f, -9.15476084e-02f, -6.89723436e-03f,
  -1.87297031e-01f, -5.50225116e-02f, 1.08463205e-02f, -1.50368840e-01f, 7.53225610e-02f, -1.63869008e-01f, -1.68782637e-01f, 1.96539685e-01f, -4.49260883e-02f, 1.93816014e-02f,
  1.03215002e-01f, -2.63210207e-01f, 1.56341240e-01f, -2.96200123e-02f, -2.24425793e-01f, 2.24746000e-02f, -2.38043830e-01f, -6.06165566e-02f, -4.67801914e-02f, -1.78009237e-03f,
  5.72004020e-02f, 1.34405762e-01f, 3.52165252e-02f, 2.21611634e-01f, -4.45333533e-02f, 1.74852721e-02f, 1.59393266e-01f, 2.29819477e-01f, -7.17821121e-02f, -3.11436923e-03f,
  -1.60014898e-01f, 1.40792474e-01f, -3.41498330e-02f, 1.20845988e-01f, -6.48919865e-02f, 8.34354013e-02f, -6.75252676e-02f, -8.84606317e-02f, -3.93219367e-02f, 4.18841802e-02f,
  4.38084779e-03f, 1.45720139e-01f, 5.42899445e-02f, 2.96059791e-02f, -4.74169552e-02f, -8.33138730e-03f, -4.70300876e-02f, -5.07671945e-02f, 1.01488091e-01f, -9.18132886e-02f,
  8.99230540e-02f, -5.88091426e-02f, 4.41974327e-02f, 3.40689607e-02f, 2.53053685e-03f, 2.77706562e-03f, -1.04422376e-01f, 3.13579813e-02f, -5.64773232e-02f, -5.19521534e-02f,
  1.00773498e-01f, 9.70098097e-03f, -3.85238305e-02f, 1.26085076e-02f, -3.81626822e-02f, 6.03269674e-02f, 2.78152875e-03f, 3.04720718e-02f, -8.37276280e-02f, -5.83197251e-02f,
  1.12810209e-02f, -4.88169789e-02f, 4.29748036e-02f, 4.22988608e-02f, -7.99380764e-02f, 2.49682702e-02f, 6.99650571e-02f, 5.96188987e-03f, -6.22106250e-03f, -1.11822002e-01f,
  -1.10090859e-02f, -1.98510457e-02f, 5.55306748e-02f, -2.03452967e-02f, 7.64726624e-02f, 3.73309329e-02f, 6.31664917e-02f, 8.25514086e-04f, -8.25120807e-02f, -4.29494567e-02f,
  8.31241235e-02f, 3.13927457e-02f, 4.97964919e-02f, -8.08079541e-02f, -7.36196265e-02f, -5.02205640e-02f, -1.47690773e-02f, 7.83254877e-02f, -3.51934433e-02f, -2.33793706e-02f,
  5.09458669e-02f, -1.27054472e-02f, -3.65198366e-02f, 2.55438518e-02f, -5.48411720e-02f, -9.45154205e-02f, 9.95207857e-03f, -5.79223670e-02f, -1.01984749e-02f, 4.18726308e-03f,
  7.81972427e-03f, -1.14290431e-01f, -5.94740473e-02f, 7.31465667e-02f, 1.23927601e-01f, -1.85318142e-02f, -6.47647604e-02f, 1.86623018e-02f, -2.79252026e-02f, -5.63412905e-02f,
  -3.71310860e-01f, -4.60294038e-02f, 2.72875220e-01f, -2.58268982e-01f, -1.08603880e-01f, 1.72693297e-01f, 2.15578854e-01f, -1.97790384e-01f, -1.63841620e-01f, -1.17201827e-01f,
  1.82149448e-02f, 2.57961731e-02f, 2.48747766e-01f, 6.40197843e-02f, 1.92198604e-01f, 2.26973757e-01f, 4.58212057e-03f, 6.56700060e-02f, -4.59756255e-02f, -1.20777182e-01f,
  -1.00268640e-01f, -8.66050273e-02f, 2.70141184e-01f, -1.41236678e-01f, -1.55660454e-02f, -8.28890502e-02f, -7.77590200e-02f, 7.45832399e-02f, -7.98632950e-02f, 1.10606521e-01f,
  -2.13277936e-01f, -2.52192199e-01f, -2.14972496e-02f, -2.96078529e-02f, 1.12526761e-02f, -5.52232079e-02f, 6.61571473e-02f, 1.35964006e-01f, 1.88022926e-02f, 3.05284522e-02f,
  5.35603799e-02f, -3.01683266e-02f, -1.05386660e-01f, 3.53969820e-02f, -3.79486308e-02f, -2.37384345e-03f, 4.18567508e-02f, 6.99854083e-03f, 8.43832716e-02f, 8.89471695e-02f,
  -2.88778287e-03f, 2.86630560e-02f, -6.31332099e-02f, -1.39156589e-02f, -7.47599825e-03f, -4.48971465e-02f, 2.95398152e-03f, 1.03048451e-01f, 2.89010033e-02f, -6.31703064e-02f,
  -2.66059097e-02f, -1.33220609e-02f, 7.98720866e-02f, -3.15890014e-02f, -4.85709161e-02f, -1.00522013e-02f, -5.69640659e-03f, -2.61542127e-02f, -1.43860206e-02f, 5.42951077e-02f,
  -1.24286888e-02f, -9.15148482e-03f, -1.59266833e-02f, 2.32421905e-02f, 5.45607023e-02f, -2.14842595e-02f, 5.53092882e-02f, 2.90094428e-02f, -7.98254088e-02f, -1.09236483e-02f,
  -3.05742659e-02f, -7.81139955e-02f, 4.79906946e-02f, 1.86705701e-02f, -5.22099398e-02f, 1.81044266e-02f, -9.44879726e-02f, -3.36171985e-02f, -4.00520526e-02f, 1.59439351e-02f,
  -2.52087086e-01f, -1.73386827e-01f, -8.65727756e-03f, 7.46567454e-03f, 2.45119445e-02f, -7.62035772e-02f, -2.98832683e-03f, -8.83343369e-02f, 1.24573121e-02f, -6.76366761e-02f,
  9.22786351e-03f, -1.75401289e-02f, -4.66468967e-02f, -3.46225426e-02f, -3.58611867e-02f, -1.88444406e-02f, 3.97648402e-02f, -1.74070187e-02f, -3.63797769e-02f, -7.30335265e-02f,
  -3.59363407e-02f, -3.52809429e-02f, 6.88808262e-02f, -8.19981322e-02f, 6.45192759e-03f, 3.64860781e-02f, -9.44575146e-02f, 3.93957719e-02f, 1.66974068e-02f, 2.78505869e-02f,
  7.63708353e-02f, 1.10539049e-01f, -8.06203410e-02f, 2.26196915e-01f, -1.26058966e-01f, -1.30949393e-01f, -1.09817520e-01f, 1.17644623e-01f, 6.50153533e-02f, -8.04315880e-02f,
  9.46708694e-02f, -5.08904867e-02f, -3.48169096e-02f, 2.50918359e-01f, 2.24341795e-01f, -8.85307882e-03f, 1.94458395e-01f, 8.77182186e-02f, 1.27545260e-02f, 1.23020612e-01f,
  1.33884951e-01f, 2.42121905e-01f, 7.26931468e-02f, 5.59844486e-02f, 1.68194771e-01f, 1.45889580e-01f, 1.55331492e-01f, -8.29022098e-03f, 1.45034969e-01f, -6.50297403e-02f,
  2.01468691e-02f, 3.64451818e-02f, -1.56804547e-02f, -5.31560555e-02f, 7.59703368e-02f, -2.41219513e-02f, -8.79533738e-02f, -4.35105264e-02f, -9.34099108e-02f, -4.55749035e-02f,
  -1.16774246e-01f, 1.13315366e-01f, -1.07376345e-01f, 7.71149769e-02f, -1.31867053e-02f, -6.93085138e-03f, 1.08420728e-02f, -4.67834473e-02f, 4.75927517e-02f, -1.23498458e-02f,
  -1.57405641e-02f, 3.90320905e-02f, 4.10548374e-02f, 1.79934017e-02f, -3.82690094e-02f, 7.29562575e-03f, -7.11724088e-02f, 8.49531069e-02f, -3.99369597e-02f, 6.27533793e-02f,
  3.10848118e-03f, -6.37130365e-02f, 1.78049679e-03f, -6.15687966e-02f, 3.30712497e-02f, -4.88473140e-02f, 3.29651199e-02f, -3.86864096e-02f, -4.57887128e-02f, 3.27293463e-02f,
  5.77311553e-02f, 5.67213707e-02f, -6.52550720e-03f, -6.96874708e-02f, 4.80120629e-03f, 6.38376400e-02f, -6.58361986e-02f, -6.42284602e-02f, -1.03773572e-01f, 2.19157264e-02f,
  -7.56124258e-02f, -1.19546456e-02f, 5.86841330e-02f, -8.30239803e-02f, -5.95215224e-02f, -6.15104893e-03f, 4.53234948e-02f, 5.76583669e-02f, -4.28552628e-02f, -4.26696502e-02f,
  4.59735282e-02f, 1.84328929e-02f, 1.08979968e-02f, -3.40696499e-02f, 8.06974340e-03f, 5.59818037e-02f, -7.68455267e-02f, -3.59323844e-02f, 4.85867355e-03f, 2.57065054e-02f,
  6.41095191e-02f, -1.28825530e-01f, -2.15809271e-02f, 8.93186703e-02f, -1.53585589e-02f, 6.74637780e-02f, 1.00446023e-01f, 1.04076378e-02f, 3.77339460e-02f, 1.73901096e-01f,
  2.01898459e-02f, -6.11457787e-02f, -6.45623282e-02f, -9.00992155e-02f, -5.57843857e-02f, -1.74127594e-02f, 3.53662334e-02f, 2.50545591e-02f, 2.58730259e-02f, 5.95303550e-02f,
  5.63533418e-02f, 1.50235280e-01f, -4.89197820e-02f, -2.73968885e-03f, -1.38124928e-01f, -3.28553498e-01f, -1.70555159e-01f, -1.24137953e-01f, 1.68037906e-01f, 1.51072234e-01f,
  -1.79651547e-02f, 2.24150166e-01f, 5.67148887e-02f, -9.99873355e-02f, -1.56257406e-01f, -1.01771787e-01f, -2.21484169e-01f, 3.43224853e-02f, 9.78915840e-02f, -8.13741162e-02f,
  -2.82221809e-02f, -1.50632039e-01f, -1.90204114e-01f, -7.30977505e-02f, 1.20795611e-02f, 7.39306957e-02f, -2.67276559e-02f, -2.64718924e-02f, -3.48194316e-02f, -9.96195618e-03f,
  -1.64983898e-01f, -8.73186514e-02f, 1.16867693e-02f, 4.46581915e-02f, -7.50235021e-02f, -9.71442908e-02f, -4.60265577e-02f, 2.75185015e-02f, 5.14648436e-03f, 3.25696506e-02f,
  6.59400970e-02f, 8.71959776e-02f, 7.33082741e-02f, 1.82734549e-01f, 7.50458390e-02f, 1.31170720e-01f, -1.26589805e-01f, -7.46962279e-02f, 2.93911733e-02f, -3.50998640e-02f,
  5.64767607e-02f, 7.40353391e-02f, -1.41089544e-01f, -5.53886825e-03f, 5.12467138e-02f, -2.75568292e-02f, -1.34171266e-03f, 4.68291901e-02f, -4.59176823e-02f, 3.95089015e-02f,
  -5.17642833e-02f, 1.13597568e-02f, 3.01356595e-02f, 2.21572854e-02f, -1.03618661e-02f, -6.81323335e-02f, 5.42620607e-02f, -3.20398882e-02f, 7.70666748e-02f, -1.03063270e-01f,
  -2.10249331e-02f, 1.08404927e-01f, -4.21158969e-02f, 2.39368435e-02f, -1.65612381e-02f, 5.78177683e-02f, -9.29083303e-02f, 1.13400385e-01f, -6.71106726e-02f, -4.07494642e-02f,
  5.44535220e-02f, -3.79065983e-02f, -1.01831071e-02f, -9.61062759e-02f, -8.59400108e-02f, 8.43520761e-02f, 1.03527993e-01f, 6.33074790e-02f, -6.29969314e-02f, -1.54436221e-02f,
  -3.04404348e-01f, -1.87207952e-01f, -1.22739235e-02f, 6.13254234e-02f, 2.38664132e-02f, 3.35891135e-02f, 2.93860286e-02f, 7.71785751e-02f, 4.98607866e-02f, -1.98403671e-02f,
  1.73990300e-03f, -3.49773094e-02f, 1.38029419e-02f, 8.15731734e-02f, -1.54855987e-02f, -2.22100373e-02f, 4.45196219e-02f, -4.80363667e-02f, -5.32857664e-02f, -4.83826920e-02f,
  1.32929003e-02f, -1.57929808e-02f, -9.83625501e-02f, -8.79279897e-02f, -7.46426433e-02f, -7.20511079e-02f, 6.87247366e-02f, -1.52783673e-02f, 5.99085959e-03f, 4.46820259e-02f,
  -4.20245051e-01f, 1.94075853e-01f, -1.02982588e-01f, -2.04154611e-01f, 2.52278030e-01f, -1.14892863e-01f, -1.88840851e-01f, -5.13609424e-02f, -2.14840069e-01f, 6.73492923e-02f,
  1.06406491e-02f, -1.26952901e-01f, 1.73380207e-02f, -1.17028542e-01f, -2.72071987e-01f, -3.43380794e-02f, -1.61935344e-01f, -1.37289613e-01f, 7.41064847e-02f, 1.30655104e-03f,
  -1.01254024e-01f, 5.85638024e-02f, -4.89625037e-02f, 2.78575361e-01f, -4.36065085e-02f, 9.46479216e-02f, 4.81363712e-03f, 1.86292216e-01f, -7.49989413e-03f, 4.19927686e-02f,
  -1.55708060e-01f, -6.42774478e-02f, -7.20609576e-02f, -9.18851271e-02f, -7.14142993e-02f, -7.10986834e-03f, -2.97227129e-03f, 5.35350118e-04f, -3.22134830e-02f, -5.37032448e-02f,
  -5.55174761e-02f, 2.25862022e-02f, -5.85075654e-02f, 3.76427062e-02f, -5.93450926e-02f, -3.07399919e-03f, 6.78500254e-03f, -4.77050021e-02f, 9.65081602e-02f, -4.87440154e-02f,
  -1.06504209e-01f, 6.66900352e-02f, -5.89871332e-02f, -9.03142542e-02f, -1.08132422e-01f, -2.75144242e-02f, -9.94211957e-02f, -7.72928149e-02f, 5.99591993e-02f, -9.47833955e-02f,
  3.54978032e-02f, 7.19152316e-02f, 9.56662372e-03f, -1.47566823e-02f, -6.85738772e-02f, -2.50869542e-02f, -9.33303777e-03f, 2.35000718e-02f, 6.03538938e-02f, -5.30220233e-02f,
  8.82211421e-03f, -9.02316496e-02f, 1.29044587e-02f, -8.21229741e-02f, 3.67020001e-03f, 6.72315583e-02f, 1.48523793e-01f, -6.69687381e-03f, 3.30905803e-02f, -3.99570689e-02f,
  -2.82404982e-02f, -8.31683725e-03f, 1.28005003e-03f, 6.38110936e-02f, -9.39755887e-03f, -5.16082160e-03f, 4.16221544e-02f, 3.61159593e-02f, 1.90895405e-02f, 1.97656285e-02f,
  -1.50400400e-01f, -8.95698741e-02f, -6.12196438e-02f, 7.21663684e-02f, -1.17291540e-01f, 3.35861207e-03f, 3.12705971e-02f, -1.10839002e-01f, 5.07875159e-02f, -3.61169688e-02f,
  -5.20496592e-02f, 5.85654415e-02f, 4.26207259e-02f, 5.18087260e-02f, 9.98003874e-03f, -1.20958127e-01f, -9.13069174e-02f, -4.20009755e-02f, 5.33676855e-02f, 2.57216096e-02f,
  9.69522148e-02f, 1.06306583e-01f, -2.00461727e-02f, 9.78915915e-02f, 4.86905240e-02f, 6.47939220e-02f, 2.34145876e-02f, -3.60802151e-02f, 3.09057906e-02f, -5.14187030e-02f,
  -2.82042176e-01f, 2.23197520e-01f, 8.18623230e-02f, 3.26174647e-02f, -1.17249332e-01f, -3.88965160e-01f, -2.72692978e-01f, -1.11221056e-02f, 9.11082625e-02f, -4.46508154e-02f,
  -6.91275392e-03f, 1.98439196e-01f, 2.03372374e-01f, 6.96953163e-02f, -4.96799424e-02f, 1.23502806e-01f, -1.09120302e-01f, 8.56699981e-03f, 5.40784933e-02f, 1.06868327e-01f,
  6.72482327e-02f, 1.21757500e-01f, 1.88982248e-01f, 2.10146084e-01f, 1.12140123e-02f, 5.36191761e-02f, 4.83489558e-02f, 6.09608851e-02f, -1.16930768e-01f, -4.49518152e-02f,
  -1.12690896e-01f, 7.83609524e-02f, -1.51748275e-02f, -1.61573276e-01f, -6.33726940e-02f, -1.26217932e-01f, -7.36051872e-02f, -9.70497876e-02f, 6.78683892e-02f, -2.01484840e-02f,
  -4.89702113e-02f, 3.42638604e-02f, -9.57419071e-03f, 9.78792533e-02f, -9.47059393e-02f, -6.17571808e-02f, 4.08252887e-03f, -9.56279710e-02f, 9.92632061e-02f, 2.19031647e-02f,
  8.96349475e-02f, -8.35250765e-02f, 6.15513325e-02f, -2.75948960e-02f, -1.02639996e-01f, 2.04968564e-02f, -1.01445965e-01f, -3.85262743e-02f, -4.54153754e-02f, -5.87916076e-02f,
  -6.24540821e-02f, -2.07255781e-02f, -6.99843764e-02f, -5.50025201e-04f, 1.06218994e-01f, 3.18470448e-02f, 9.45032761e-03f, -9.29312035e-02f, 7.88158365e-03f, -1.06401250e-01f,
  -1.25114411e-01f, -6.45568222e-02f, 1.00896977e-01f, -5.59145287e-02f, 3.95684801e-02f, -5.91484196e-02f, 8.28642100e-02f, -4.09052260e-02f, -9.56549570e-02f, -1.18269280e-01f,
  4.34316061e-02f, -2.62818541e-02f, 2.95752920e-02f, -6.91193193e-02f, -4.98032235e-02f, 6.38983473e-02f, 1.95567042e-01f, 1.26931265e-01f, -5.94937615e-02f, -1.82738826e-02f,
  -1.93457734e-02f, 1.71704337e-01f, -2.33065952e-02f, -7.62571543e-02f, -4.37135063e-02f, 7.21357092e-02f, 1.09199351e-02f, -6.16609380e-02f, 4.27057743e-02f, -8.49786252e-02f,
  -1.08517639e-01f, -1.23392353e-02f, 4.30286722e-03f, -4.79120128e-02f, 3.15459631e-02f, -1.03494311e-02f, 4.39382866e-02f, -4.71759588e-02f, 3.58203240e-02f, 6.58702105e-02f,
  1.42060071e-01f, 9.68289226e-02f, 8.40587839e-02f, 8.48442763e-02f, -9.16179791e-02f, 3.02389860e-02f, 6.37875590e-03f, 8.51149578e-03f, -5.68789169e-02f, 1.25693262e-01f,
  3.96604985e-02f, 2.11183488e-01f, 1.00972287e-01f, -3.95610444e-02f, -1.40425086e-01f, -2.48229697e-01f, -1.92107737e-01f, -6.79628924e-02f, 7.57484511e-02f, 1.14404283e-01f,
  -2.26998046e-01f, 2.97868222e-01f, -6.74653500e-02f, -8.46051201e-02f, -2.98586994e-01f, -7.95271918e-02f, -2.45200187e-01f, -1.20207533e-01f, -9.77616310e-02f, -7.84463808e-03f,
  -1.29169136e-01f, -1.97421968e-01f, -1.80965692e-01f, -9.88847688e-02f, -3.27849910e-02f, 1.14188604e-01f, -8.88305083e-02f, -3.47218364e-02f, 2.16324963e-02f, -7.94788450e-02f,
  -1.02465749e-01f, 5.06536961e-02f, 6.80134594e-02f, 6.05303384e-02f, -7.79523998e-02f, -4.17002290e-02f, 4.17197719e-02f, -5.99675663e-02f, -7.37940967e-02f, 1.24745928e-02f,
  8.36870223e-02f, -1.79637726e-02f, -5.58251850e-02f, 1.95699800e-02f, 7.05955252e-02f, 6.61143139e-02f, -4.69999611e-02f, -8.90689250e-03f, 1.01966828e-01f, -4.09595817e-02f,
  9.88309160e-02f, 3.44594792e-02f, 6.74010292e-02f, -4.73077297e-02f, -1.36068529e-02f, 2.35210899e-02f, 2.68495735e-02f, -3.29507818e-03f, -4.94337529e-02f, -4.66900170e-02f,
  6.10676780e-02f, -4.35902551e-02f, -1.20848194e-01f, -3.18479873e-02f, -1.38806198e-02f, -4.00245488e-02f, 8.45040455e-02f, 3.48292142e-02f, 6.59235492e-02f, -2.85963528e-02f,
  -5.25157414e-02f, -2.63282117e-02f, -4.14505973e-02f, -6.51261210e-02f, -1.04343742e-01f, -8.88578221e-02f, -1.55537697e-02f, -3.44703272e-02f, 8.93000364e-02f, -3.38968411e-02f,
  -7.67989531e-02f, 1.34090446e-02f, 1.12824235e-02f, -6.93178698e-02f, -1.02730088e-01f, -5.87872304e-02f, -1.80473402e-02f, 1.39336353e-02f, -1.24380656e-01f, 9.69058555e-03f,
  -1.20878196e-03f, -8.50463361e-02f, -2.65952777e-02f, 2.34677587e-02f, 3.23309042e-02f, -5.08068092e-02f, -2.86982600e-02f, 7.91954473e-02f, 4.66401167e-02f, 1.29050259e-02f,
  6.90383017e-02f, -3.66415940e-02f, 5.87475523e-02f, -6.72879741e-02f, -2.43193144e-03f, 2.22192947e-02f, -1.35396682e-02f, 2.30660941e-02f, 3.20398249e-02f, -1.57993039e-04f,
  -3.32055427e-02f, 1.47133395e-02f, 4.46499847e-02f, -9.99839753e-02f, 2.77800625e-03f, 3.96079347e-02f, 4.04601358e-02f, -7.29203150e-02f, 5.34718446e-02f, 4.00741026e-02f,
  5.84801659e-02f, 3.08011770e-01f, 2.98418522e-01f, 2.49382257e-01f, -8.35843310e-02f, -2.32522443e-01f, -1.99237883e-01f, 7.03757256e-02f, -6.34309500e-02f, 1.59916952e-01f,
  -1.58354074e-01f, 2.67943174e-01f, -8.22528973e-02f, 3.28944959e-02f, -1.91080198e-01f, -6.15579076e-02f, 5.10529876e-02f, 7.83306372e-04f, 2.93539166e-02f, 1.46245182e-01f,
  1.15127817e-01f, -1.93365023e-01f, 9.07068849e-02f, -4.40608636e-02f, 1.36432022e-01f, 1.43747598e-01f, 6.91749826e-02f, 2.15063114e-02f, 1.18725188e-01f, -1.29260972e-01f,
  -7.16243684e-03f, -4.58368510e-02f, 7.13805631e-02f, 2.99500190e-02f, -1.26775727e-02f, 2.85160914e-02f, 2.75059864e-02f, -1.64792910e-01f, -4.23263898e-03f, -3.74467671e-03f,
  4.40106690e-02f, 3.31764333e-02f, 4.69787531e-02f, -1.77362969e-03f, -7.62508661e-02f, 8.31893906e-02f, 6.04603589e-02f, 1.51270479e-02f, -6.31832555e-02f, 6.96937889e-02f,
  1.39371291e-01f, 1.27069652e-01f, 1.29045162e-04f, -2.77841445e-02f, 1.43376216e-01f, -7.51692057e-02f, 1.05522729e-01f, 5.35367467e-02f, 9.70012546e-02f, 1.94364460e-03f,
  -8.60503837e-02f, 7.73122832e-02f, -1.52152767e-02f, 1.65227614e-02f, 3.52457203e-02f, -1.14714511e-01f, -8.38227421e-02f, -1.87068526e-02f, -3.28109749e-02f, -9.94204655e-02f,
  8.75121504e-02f, 9.55795720e-02f, -9.04310495e-02f, 5.21203093e-02f, 1.11762278e-01f, 1.20364400e-02f, 5.26699685e-02f, -4.80743647e-02f, 5.45130186e-02f, 8.71515572e-02f,
  -2.10322943e-02f, -1.16718911e-01f, -1.61731672e-02f, -8.01168010e-02f, -1.03190430e-01f, 1.16957389e-01f, 5.70938848e-02f, 9.18121170e-03f, 3.81316096e-02f, -4.03675549e-02f,
  -4.35436927e-02f, 1.65076286e-01f, 7.73926377e-02f, -8.28576833e-02f, -1.78641803e-03f, 1.35765541e-02f, -3.35590281e-02f, 1.11358978e-01f, 6.70557320e-02f, -5.77587374e-02f,
  4.42501111e-03f, -5.51352166e-02f, 1.38333309e-02f, -4.35692109e-02f, -9.58696008e-03f, -1.83126219e-02f, 6.47772774e-02f, 3.94335277e-02f, 3.08840610e-02f, 2.52423640e-02f,
  1.15032770e-01f, 8.91890013e-05f, -7.60052679e-03f, -1.40938256e-02f, -4.53328080e-02f, 4.94100824e-02f, 1.56500598e-03f, 1.11768275e-01f, 4.50421572e-02f, 1.10522714e-02f,
  2.57913582e-02f, -7.42299780e-02f, -1.52266607e-01f, -7.35815987e-02f, -8.41391981e-02f, 1.42819965e-02f, -1.43441632e-01f, 3.74011658e-02f, 1.49772614e-01f, -4.54624146e-02f,
  -6.42462820e-02f, -6.97361305e-02f, 1.23509355e-01f, -2.20715791e-01f, 2.70520806e-01f, 1.91837758e-01f, -9.75582153e-02f, -1.01321355e-01f, 2.97989789e-02f, -1.15918733e-01f,
  6.22018278e-02f, -2.01427996e-01f, 4.09621187e-02f, -1.80179581e-01f, -2.58305699e-01f, -5.80001399e-02f, -8.73259827e-02f, -3.84792760e-02f, -1.02474205e-01f, -1.05865560e-01f,
  -2.45503381e-01f, -2.63936788e-01f, -1.26821250e-01f, -6.38965808e-04f, -8.89405906e-02f, -6.95970282e-02f, -1.92687824e-01f, 1.21868566e-01f, -9.88844782e-02f, 1.29008945e-02f,
  4.30567972e-02f, -5.94572425e-02f, -1.18248656e-01f, 5.50713912e-02f, 3.38545331e-04f, 1.40936272e-02f, 4.59140725e-02f, -5.29031232e-02f, 6.56086300e-03f, 2.28532068e-02f,
  9.23029706e-02f, -2.59835348e-02f, -8.10108148e-03f, 3.91610805e-03f, 2.54069529e-02f, 3.29789408e-02f, 9.78415273e-03f, -4.78115827e-02f, 1.97919831e-02f, -3.06946551e-03f,
  1.48485554e-02f, 3.67883481e-02f, -5.29880971e-02f, 4.20295484e-02f, 3.63115668e-02f, -9.97233763e-02f, -7.02103525e-02f, -3.75827998e-02f, -1.11279890e-01f, -3.86718996e-02f,
  -7.91574046e-02f, -5.46004176e-02f, -1.08908817e-01f, 9.24266726e-02f, 7.46266618e-02f, 9.64197293e-02f, 2.49555707e-03f, 3.05795092e-02f, -3.83136868e-02f, 3.28466631e-02f,
  1.56236559e-01f, -5.76155707e-02f, -1.18571863e-01f, -5.19291498e-02f, -3.10520399e-02f, 5.63065149e-02f, -1.21098235e-02f, 8.08850527e-02f, 9.16841440e-03f, 9.28509608e-02f,
  -1.14724711e-01f, -2.05785379e-01f, -6.67892769e-02f, -8.27820301e-02f, -4.33891378e-02f, -4.38947156e-02f, -6.63867667e-02f, -2.83546653e-02f, -8.53979811e-02f, -5.72609268e-02f,
  -9.93137136e-02f, 5.90768782e-03f, -6.53321147e-02f, -1.67247374e-02f, 4.74878810e-02f, 1.50842397e-02f, -1.06106736e-01f, -1.15593247e-01f, -3.66577506e-02f, -4.79074232e-02f,
  -1.97912734e-02f, -5.19014113e-02f, 9.16814059e-02f, 3.56792100e-02f, 7.30040744e-02f, 5.81992092e-03f, -1.45855322e-01f, 6.12508692e-02f, -2.89211944e-02f, 3.39718163e-02f,
  -4.34024632e-01f, 1.29855752e-01f, -2.08366081e-01f, -4.81245201e-03f, -1.32681727e-02f, -1.15884773e-01f, 1.01929508e-01f, 6.00324534e-02f, -2.50804693e-01f, 8.85839835e-02f,
  9.80065241e-02f, -1.97990730e-01f, 1.11686021e-01f, 5.52762002e-02f, -3.36018920e-01f, 5.54666631e-02f, -7.74690062e-02f, -3.70706618e-02f, 6.88167661e-02f, 1.02606311e-01f,
  -9.44897756e-02f, 2.14912780e-02f, 3.01400125e-02f, 2.38370433e-01f, -2.40053628e-02f, -3.10685206e-02f, 2.67918631e-02f, 9.72981900e-02f, 3.47781479e-02f, -9.05879065e-02f,
  6.24037534e-02f, -1.88030358e-02f, 1.59376431e-02f, -3.62605974e-02f, -8.89204219e-02f, 5.92782162e-03f, -2.67351549e-02f, 3.78787741e-02f, -6.79473113e-03f, -6.10530414e-02f,
  -6.62946375e-03f, -6.64259940e-02f, -4.64228541e-02f, -3.81907001e-02f, -1.03206053e-01f, 4.32148874e-02f, 7.58965388e-02f, -6.35826960e-02f, 1.38553027e-02f, -3.48712690e-02f,
  -3.00553031e-02f, -1.14679933e-02f, 2.11278889e-02f, -6.24729134e-02f, -9.76987556e-03f, -2.31965557e-02f, -5.81288757e-03f, -8.44856445e-03f, -8.15344751e-02f, -6.87831715e-02f,
  -8.81440863e-02f, -3.64391394e-02f, 5.36057353e-02f, -6.82419445e-03f, 1.04063518e-01f, 2.78401617e-02f, -4.26735170e-03f, 4.09828275e-02f, -6.79095164e-02f, 9.53841209e-02f,
  -6.20714538e-02f, -4.69025411e-02f, -6.08101822e-02f, 7.20705604e-03f, 4.00357507e-03f, -7.82307684e-02f, 3.69660556e-02f, -4.60312739e-02f, -2.09094975e-02f, 5.03743999e-02f,
  8.03513452e-02f, 5.75410314e-02f, -2.15386841e-02f, -1.91389956e-02f, 4.03274260e-02f, 4.13379818e-02f, 1.87515952e-02f, -5.38221374e-03f, 4.33457680e-02f, -4.58477400e-02f,
  3.47399712e-02f, -1.46621957e-01f, 2.72401273e-02f, 3.02932840e-02f, -6.28731819e-03f, 1.29268765e-02f, 3.09269931e-02f, -3.80299725e-02f, 7.22865015e-03f, -3.25533189e-02f,
  5.03216311e-02f, 2.19645090e-02f, -7.75313973e-02f, -2.38818564e-02f, 3.10666077e-02f, -3.23036984e-02f, 1.02952428e-01f, -2.29598526e-02f, -5.19928373e-02f, -5.89190088e-02f,
  -2.51084249e-02f, 1.93162728e-02f, -6.03421405e-02f, -4.38900944e-03f, -9.74340662e-02f, 6.31247833e-02f, -3.66356559e-02f, -4.88795005e-02f, -7.04908445e-02f, 4.94968072e-02f,
  -2.18607485e-01f, 1.82946287e-02f, -4.64628413e-02f, -2.10792944e-01f, 5.19763418e-02f, 1.95027404e-02f, -1.54017270e-01f, -1.20783262e-02f, -7.93705806e-02f, 2.35173300e-01f,
  -1.14093177e-01f, 5.43405078e-02f, 4.25253483e-03f, -3.07418436e-01f, -3.27410430e-01f, -3.01476240e-01f, -2.96587884e-01f, -2.68398989e-02f, -8.12344924e-02f, 2.57605668e-02f,
  -6.29550070e-02f, -7.09912702e-02f, -3.02269012e-01f, 1.48219969e-02f, 3.09713483e-02f, 1.12356953e-01f, 1.37860999e-01f, 7.33089596e-02f, 9.14368555e-02f, -1.22630253e-01f,
  -2.95075811e-02f, 4.41635773e-02f, 1.06143713e-01f, -6.06115423e-02f, 9.75792576e-03f, 8.69180262e-02f, -2.78912857e-02f, -6.26630615e-03f, 4.07086946e-02f, 2.23491844e-02f,
  4.32561226e-02f, -6.53861538e-02f, -2.43754350e-02f, -6.31844327e-02f, -2.73317210e-02f, -6.99812695e-02f, 1.57113336e-02f, 5.47967181e-02f, -1.08805805e-01f, -4.88455780e-02f,
  3.89048234e-02f, 5.31202368e-02f, -1.36306854e-02f, 7.69457687e-03f, -3.99802765e-03f, 5.80143966e-02f, 3.89705449e-02f, -6.79646246e-03f, 9.20997858e-02f, -5.23294099e-02f,
  -2.30723824e-02f, -5.55915870e-02f, 8.20383709e-03f, 2.48437449e-02f, -1.87816843e-02f, 1.51245091e-02f, -5.97998919e-03f, -5.94752319e-02f, 2.84962151e-02f, 5.46040535e-02f,
  -1.78580303e-02f, -5.18509075e-02f, -5.66821955e-02f, 3.44199911e-02f, 1.02759236e-02f, 6.01180717e-02f, 2.65085325e-02f, 7.45549472e-03f, 1.25477426e-02f, -5.46024218e-02f,
  1.25980780e-01f, -6.21790290e-02f, -4.08587083e-02f, 1.12796061e-01f, -4.11927700e-04f, -3.68063562e-02f, 4.79213260e-02f, -1.18080461e-02f, -5.45713007e-02f, 8.74255747e-02f,
  -1.71509404e-02f, 1.41741231e-01f, 7.92719051e-02f, -6.40823245e-02f, -3.09066046e-02f, 1.41185196e-02f, -4.01877239e-02f, -1.06502697e-01f, -3.92880514e-02f, -7.65616028e-03f,
  2.09974088e-02f, 4.64247577e-02f, 1.03962757e-02f, 6.85253292e-02f, -2.49216221e-02f, 3.82323302e-02f, -5.64653054e-03f, -3.33141126e-02f, -2.38888077e-02f, 1.44357190e-01f,
  -3.36263631e-03f, -6.82737455e-02f, 4.48726825e-02f, -1.70462430e-02f, 1.95067581e-02f, 7.35022426e-02f, 4.52073179e-02f, 4.34718020e-02f, -6.50366545e-02f, -6.91844150e-03f,
  -1.83286890e-01f, 1.25716910e-01f, -1.54683933e-01f, -6.22592717e-02f, 1.85653210e-01f, -9.22476202e-02f, -7.89166242e-02f, 9.81553048e-02f, -8.80035236e-02f, 1.45038351e-01f,
  9.73326117e-02f, 6.78194314e-02f, -1.20375097e-01f, -6.55385479e-02f, -3.67689654e-02f, -1.83971778e-01f, 2.72804182e-02f, -2.81579308e-02f, -7.61489645e-02f, 2.05758289e-01f,
  -1.25689462e-01f, 1.09443925e-01f, -7.67823160e-02f, 1.52710006e-01f, 6.74672201e-02f, 1.49228022e-01f, 1.68877125e-01f, 2.98426207e-02f, 1.55496433e-01f, -4.52698246e-02f,
  -4.27965298e-02f, 6.13108138e-03f, -1.10717103e-01f, -1.17014483e-01f, 1.12670593e-01f, 1.07820749e-01f, 8.94215554e-02f, -1.96283489e-01f, 1.18832206e-02f, -7.02311322e-02f,
  2.43855007e-02f, -6.80765137e-02f, -1.19032443e-01f, -4.13324572e-02f, -6.94159865e-02f, 1.99284945e-02f, -6.83352798e-02f, 4.58749384e-02f, 3.00635118e-02f, -8.84423554e-02f,
  -5.48367808e-03f, 2.55330782e-02f, 7.82604367e-02f, 5.64334542e-02f, -2.49230620e-02f, 4.95549366e-02f, 1.13639869e-01f, 2.45307200e-02f, -5.71756884e-02f, -1.50615387e-02f,
  -4.05535921e-02f, 9.08983648e-02f, -1.11670420e-02f, -7.84507394e-02f, 1.38326762e-02f, -1.09175734e-01f, -8.06335807e-02f, -6.35341834e-03f, -1.51948370e-02f, 2.55287345e-02f,
  8.46645162e-02f, -7.76512697e-02f, -4.77846712e-02f, 9.36447550e-03f, 1.14503153e-01f, 1.75902490e-02f, -6.82747550e-03f, -6.16231412e-02f, 3.18970941e-02f, 1.34388255e-02f,
  -7.27427006e-02f, -3.90098840e-02f, 7.93360621e-02f, -4.64255318e-05f, -6.81220368e-02f, 6.90504014e-02f, -5.23987189e-02f, 2.86557879e-02f, -8.93476140e-03f, 1.81167070e-02f,
  8.94318223e-02f, 1.29178375e-01f, -5.71044311e-02f, 3.68003286e-02f, -5.96821085e-02f, 1.26708075e-01f, 7.15232119e-02f, -1.32857427e-01f, 1.33537516e-01f, -1.73105777e-03f,
  1.02755412e-01f, -8.80174562e-02f, 3.20801958e-02f, 9.21164006e-02f, -6.81093484e-02f, 1.14771746e-01f, 4.03681658e-02f, 7.53220767e-02f, 5.51368445e-02f, 5.38514629e-02f,
  1.51405260e-01f, 1.25181913e-01f, -3.09724677e-02f, 3.01979221e-02f, 2.18359865e-02f, 9.79367793e-02f, 1.09598339e-01f, 6.11765124e-02f, 1.97256692e-02f, -3.75335924e-02f,
  1.08021222e-01f, 1.28471013e-02f, -3.78122777e-02f, 1.37850508e-01f, -1.41700014e-01f, -1.37614593e-01f, -2.07347035e-01f, 1.04518920e-01f, -8.59955996e-02f, 1.85712259e-02f,
  9.80079100e-02f, -4.02122699e-02f, -1.53993070e-02f, 1.64992794e-01f, 1.52603596e-01f, -1.24323919e-01f, 1.92419112e-01f, 4.05882522e-02f, 4.95015904e-02f, 1.44565344e-01f,
  2.17361733e-01f, 2.01611608e-01f, 2.01934591e-01f, 1.78041324e-01f, 6.04473501e-02f, 1.55773982e-01f, 2.17265233e-01f, 1.01283584e-02f, 2.85575479e-01f, 4.16988842e-02f,
  5.06395325e-02f, 7.54692405e-02f, 1.97283868e-02f, -8.69998336e-02f, 3.05351615e-02f, -5.30021191e-02f, -5.14010433e-03f, -1.39635606e-02f, 4.80397455e-02f, 9.16664228e-02f,
  -6.27435818e-02f, 5.63409515e-02f, -1.52306715e-02f, -2.15652101e-02f, 5.62402941e-02f, -1.81232225e-02f, -3.27065550e-02f, -2.72262041e-02f, -3.06359958e-02f, 3.25159878e-02f,
  -9.20732394e-02f, -6.08330742e-02f, -5.39742038e-02f, -1.43501490e-01f, 3.56250703e-02f, 3.60027738e-02f, -8.78090858e-02f, -1.20211300e-02f, 3.87947112e-02f, -3.08719072e-02f,
  4.12978865e-02f, 5.72024519e-03f, -1.16503211e-02f, -1.20070770e-01f, 7.31815547e-02f, 5.57772117e-03f, 1.52938683e-02f, 3.05345245e-02f, -2.44154129e-02f, 5.56622557e-02f,
  -5.52556440e-02f, 1.21062184e-02f, 9.04184058e-02f, -3.39748561e-02f, -9.16792918e-03f, -7.98209235e-02f, -8.91259406e-03f, 3.98150869e-02f, 5.09236157e-02f, 3.68682146e-02f,
  -2.65329666e-02f, -1.05220238e-02f, -1.16792927e-02f, -4.65093255e-02f, 4.38071936e-02f, 4.51419204e-02f, 8.82797390e-02f, -1.00343185e-03f, -1.33183494e-01f, -1.10645875e-01f,
  -5.18372245e-02f, 1.07412815e-01f, 7.96182267e-03f, -8.02023057e-03f, -4.93149161e-02f, 2.72497479e-02f, -5.54435188e-03f, 3.75960185e-03f, -7.59634329e-03f, 1.32938949e-02f,
  5.11702038e-02f, -5.02108745e-02f, -5.55640385e-02f, 5.45034781e-02f, -2.46707499e-02f, 3.14031877e-02f, -5.27339131e-02f, 6.31293282e-03f, 5.72011806e-02f, 1.53870741e-02f,
  2.04198509e-02f, -5.17278071e-03f, 2.82849260e-02f, -1.31180570e-01f, -7.05656037e-03f, -3.15684788e-02f, -8.79957154e-03f, 3.45914811e-02f, -3.94473784e-03f, -2.97783613e-02f,
  -5.53913824e-02f, 1.22719139e-01f, -1.65925518e-01f, -1.49587840e-01f, -1.36824161e-01f, -2.19092876e-01f, -2.44037703e-01f, -5.57795241e-02f, 8.04338530e-02f, 9.07620713e-02f,
  -2.02695318e-02f, 6.69123456e-02f, 1.12081192e-01f, -1.08912490e-01f, -6.92125708e-02f, 1.04147576e-01f, -1.00267559e-01f, 1.90729015e-02f, 1.07869416e-01f, -5.76245077e-02f,
  3.44403312e-02f, -7.33493222e-03f, -9.40877646e-02f, 2.40992196e-02f, -1.58795729e-01f, -1.96236316e-02f, -4.76388745e-02f, -3.33780535e-02f, -1.81218758e-01f, -7.10189044e-02f,
  -2.22583175e-01f, -2.13532031e-01f, -2.02302277e-01f, -1.56682923e-01f, -2.20578253e-01f, -1.84644818e-01f, -5.61248511e-03f, -6.40773401e-02f, -5.40561881e-03f, -1.39761521e-02f,
  4.69986126e-02f, 7.25916475e-02f, -5.59892468e-02f, 4.49400768e-02f, -5.05202217e-03f, 6.14022836e-02f, 4.17504422e-02f, -8.34863782e-02f, -4.79495451e-02f, 5.66459671e-02f,
  -6.20618323e-03f, -2.22159568e-02f, -1.00931704e-01f, 1.50255049e-02f, -1.44972369e-01f, -9.19751450e-02f, -6.83287978e-02f, -1.12810329e-01f, -8.13274905e-02f, 5.14973514e-02f,
  -1.23073526e-01f, 1.48753762e-01f, -7.27566406e-02f, 8.33356977e-02f, -7.51766469e-03f, -9.51213911e-02f, 2.02815961e-02f, 1.86615263e-03f, 7.35601783e-02f, -2.09815316e-02f,
  -9.36783329e-02f, -3.48234139e-02f, -4.52873334e-02f, -1.69905629e-02f, 2.98139136e-02f, -6.91618323e-02f, -8.64726752e-02f, -5.68540432e-02f, -7.71417692e-02f, -5.75808771e-02f,
  -2.00238209e-02f, 5.02464324e-02f, -2.77819205e-02f, -2.89700683e-02f, 2.20167749e-02f, 1.15200514e-02f, -1.59384478e-02f, -5.06882332e-02f, 2.73576155e-02f, -9.32170153e-02f,
  -1.79693520e-01f, -2.21796498e-01f, 4.62308154e-02f, -2.08390802e-02f, 1.05286285e-01f, -7.53818303e-02f, -2.85915043e-02f, 1.56153077e-02f, -1.73583552e-02f, -9.32936072e-02f,
  2.92701628e-02f, -1.79984067e-02f, -4.20143679e-02f, 4.39356901e-02f, 8.60733315e-02f, -4.58964668e-02f, -3.53260115e-02f, -4.80966568e-02f, -5.23130074e-02f, -7.15714991e-02f,
  -5.76592907e-02f, 1.04866475e-01f, 3.43482234e-02f, -5.91740720e-02f, -5.17035797e-02f, 3.77006060e-03f, 2.32376400e-02f, -5.18097393e-02f, -1.05996393e-01f, -3.30396183e-02f,
  2.29699671e-01f, -1.71709359e-01f, -1.11994714e-01f, 1.46682352e-01f, 1.76915705e-01f, 3.06050122e-01f, 1.81847334e-01f, 1.28432170e-01f, 1.84342295e-01f, -5.12857921e-02f,
  7.14432150e-02f, -1.58154622e-01f, -1.42130271e-01f, 1.02573171e-01f, 1.50875598e-01f, -5.11466041e-02f, 2.21931487e-01f, 4.48506214e-02f, 9.70665291e-02f, -1.32554397e-02f,
  1.35781914e-01f, 2.06615373e-01f, -1.22657895e-01f, 5.19827977e-02f, 1.49169475e-01f, -1.44329965e-01f, -1.02137417e-01f, -2.25938842e-01f, -7.19143823e-02f, 3.35494727e-02f,
  1.05087079e-01f, 4.51186597e-02f, 7.28314295e-02f, -4.57615266e-03f, -4.53425758e-02f, -1.07227145e-02f, -5.57837263e-02f, 4.15776819e-02f, -1.27499476e-02f, -4.45910683e-03f,
  4.66149114e-02f, -5.12894429e-03f, 1.14202023e-01f, 6.62405044e-02f, -3.67726795e-02f, -2.52367035e-02f, -4.19100337e-02f, 6.68909997e-02f, -1.40860245e-01f, 4.73242812e-03f,
  4.25142981e-02f, 1.67891234e-02f, -1.93459599e-03f, -8.95313472e-02f, -5.59003353e-02f, -1.16917593e-02f, -7.06495121e-02f, -1.48833364e-01f, -7.11314529e-02f, 4.21572253e-02f,
  2.32290085e-02f, -3.39857787e-02f, 6.34331331e-02f, -1.14102475e-03f, 1.35129746e-02f, -2.17480538e-03f, -6.27160296e-02f, -5.39476015e-02f, 2.44756714e-02f, -2.62291338e-02f,
  -7.20804855e-02f, 6.52590990e-02f, -7.82454666e-03f, 8.33241176e-03f, 6.22821972e-02f, -1.58470534e-02f, -4.16030176e-02f, 4.79341820e-02f, 3.32125947e-02f, 1.23272929e-02f,
  -4.60597873e-02f, 1.05471738e-01f, 9.77173373e-02f, 2.04816181e-02f, 1.71596259e-02f, 2.26837341e-02f, 7.49297813e-02f, -3.31577621e-02f, -4.85670343e-02f, -5.72213307e-02f,
  7.39553869e-02f, -8.84305388e-02f, 2.50514727e-02f, 2.54952325e-03f, -1.21185839e-01f, 1.22802831e-01f, 9.73637253e-02f, 5.01853935e-02f, -8.51921663e-02f, 1.07792720e-01f,
  2.43590213e-03f, 4.47389297e-02f, -5.30459657e-02f, -7.08979229e-03f, -7.24367425e-02f, 8.31842050e-02f, -4.63765562e-02f, -2.07780413e-02f, -8.03186074e-02f, -1.60139814e-01f,
  -3.59929679e-03f, 1.09344460e-01f, -4.67538424e-02f, 5.60910590e-02f, -5.82359284e-02f, 1.10963983e-02f, 1.07145019e-01f, -7.78517872e-02f, -5.91755249e-02f, 3.90096121e-02f,
  4.36442971e-01f, -2.19363719e-01f, 1.87009335e-01f, 3.19585919e-01f, 8.56717229e-02f, 2.82410830e-02f, 1.01344548e-01f, 1.45226106e-01f, 3.33639443e-01f, -1.33097976e-01f,
  -7.62326568e-02f, 7.65959546e-02f, -2.95428365e-01f, 5.72146103e-02f, -3.35554816e-02f, -1.78949058e-01f, 9.40733105e-02f, 9.85024124e-02f, 3.68476287e-03f, 8.22457150e-02f,
  2.28944439e-02f, -4.95274663e-02f, -5.51556870e-02f, -7.82895312e-02f, 1.17374115e-01f, 8.65819901e-02f, -1.46334514e-01f, -1.52471274e-01f, 2.43631955e-02f, -7.97381401e-02f,
  -5.97775728e-02f, 3.05409413e-02f, -5.80763519e-02f, -1.32394701e-01f, 1.09062091e-01f, -4.85792086e-02f, -3.21257720e-03f, -1.72342643e-01f, 3.27950381e-02f, -1.42921349e-02f,
  -4.96941358e-02f, -1.12372069e-02f, 2.07350522e-01f, -3.37290838e-02f, 5.54809794e-02f, 5.39384410e-02f, 3.87800671e-03f, 3.70324291e-02f, 5.33261821e-02f, 2.92449556e-02f,
  -3.88574367e-03f, -1.89034678e-02f, 1.24222152e-01f, -6.53584003e-02f, -5.24226539e-02f, -4.08811122e-02f, 7.17480704e-02f, -4.04620059e-02f, -4.52764370e-02f, 4.10120226e-02f,
  7.47342929e-02f, -1.12109788e-01f, -8.28741118e-02f, -3.27016264e-02f, 4.75069555e-03f, 3.61045972e-02f, -1.37420734e-02f, -2.53471676e-02f, 5.93718737e-02f, 4.32587378e-02f,
  1.11884721e-01f, -8.00528005e-03f, 1.00408964e-01f, -6.08393736e-02f, -7.29217529e-02f, 7.94199705e-02f, 5.30766463e-03f, 1.96751468e-02f, -1.03875948e-02f, -6.92259578e-04f,
  5.82834817e-02f, -2.44778059e-02f, -7.36208484e-02f, -8.59930832e-03f, 3.86911966e-02f, -8.03649500e-02f, 7.90747255e-03f, 1.09684117e-01f, 2.18009911e-02f, 2.49608979e-02f,
  -3.17319870e-01f, -2.47116923e-01f, -2.52136365e-02f, 1.61778618e-04f, 4.46508043e-02f, -2.38691159e-02f, 9.82144102e-03f, -1.81339812e-02f, -6.69488907e-02f, -1.24877077e-02f,
  -1.07972383e-01f, 4.88223648e-03f, -6.31183609e-02f, 3.51807699e-02f, -3.55733410e-02f, -4.48084734e-02f, -5.29236682e-02f, -2.13548522e-02f, -2.28815805e-02f, -4.88699116e-02f,
  -5.86417541e-02f, 4.57948223e-02f, 3.18173729e-02f, 2.99977604e-02f, 3.62277627e-02f, 7.99059030e-03f, -2.48125773e-02f, -8.31196085e-03f, 4.63663377e-02f, 1.41306035e-03f,
  2.99181626e-03f, 2.00021759e-01f, 2.71495014e-01f, 3.33578549e-02f, 1.84908867e-01f, 5.40624298e-02f, -9.07336771e-02f, 1.27556890e-01f, 1.04113504e-01f, -1.57646850e-01f,
  -1.36981487e-01f, 6.95247808e-03f, -9.46692601e-02f, -2.24378202e-02f, -1.57502592e-01f, -8.83603469e-02f, -4.45671678e-02f, -9.74248052e-02f, 1.92628235e-01f, 1.13740176e-01f,
  1.34533972e-01f, -4.97247763e-02f, 1.64784402e-01f, 1.56118646e-01f, 1.06994227e-01f, 3.36587131e-02f, -3.06924552e-01f, 1.33366942e-01f, 9.44109187e-02f, 8.22334737e-02f,
  -1.22511074e-01f, -1.80417988e-02f, -1.95670296e-02f, 7.26402365e-03f, -8.39601457e-03f, -6.25443086e-02f, -1.30786225e-01f, -5.35256714e-02f, 1.26076052e-02f, 6.84965625e-02f,
  1.15101589e-02f, 9.07818228e-02f, -3.32869850e-02f, -7.23332688e-02f, 1.94150340e-02f, 2.14038100e-02f, 1.57397687e-01f, 1.45341367e-01f, 1.07760079e-01f, 1.53421089e-01f,
  1.40813157e-01f, 3.76836844e-02f, 3.26999128e-02f, -9.17844567e-03f, 7.20696850e-03f, -1.19867194e-02f, -9.79650840e-02f, -1.36098295e-01f, 7.22939223e-02f, 1.18805850e-02f,
  9.78259668e-02f, 5.99866621e-02f, -5.80446124e-02f, 8.23713914e-02f, -4.53472808e-02f, -1.29354801e-02f, 8.07973891e-02f, -1.45008519e-01f, 4.41014171e-02f, 3.15142386e-02f,
  -9.18721706e-02f, -2.56581046e-02f, -6.46162406e-02f, -2.62199268e-02f, -6.06824718e-02f, 5.49199469e-02f, -1.38843268e-01f, -3.77051122e-02f, 2.87568234e-02f, -4.08393666e-02f,
  -1.26560852e-01f, -1.55112565e-01f, 1.63788617e-01f, 4.29754257e-02f, -1.17827184e-01f, -8.93927068e-02f, 9.53489915e-02f, 2.70120054e-02f, 2.03465521e-02f, -9.54872444e-02f,
  -4.24843788e-01f, -1.37682170e-01f, -1.51443467e-01f, -5.38471192e-02f, -6.22314028e-02f, -6.99797049e-02f, -1.01277800e-02f, -3.37664634e-02f, -4.83197533e-02f, 1.16558604e-01f,
  7.84102306e-02f, 7.36253485e-02f, -9.35087055e-02f, -9.11803991e-02f, -1.80252027e-02f, -1.23030268e-01f, 1.97648220e-02f, -1.68727152e-02f, -1.08187787e-01f, 2.78089885e-02f,
  1.28264884e-02f, -3.40092625e-03f, 3.32886577e-02f, 6.06859289e-02f, -1.24287955e-01f, -7.93341026e-02f, 7.53518613e-03f, -5.65526076e-02f, 4.73666750e-02f, -3.75155881e-02f,
  1.67510703e-01f, 6.33661002e-02f, 2.09065780e-01f, 1.34219557e-01f, -1.27019346e-01f, -9.74399522e-02f, -2.30792001e-01f, -2.29758378e-02f, 7.28349835e-02f, -2.02948853e-01f,
  -1.27742082e-01f, 2.53070116e-01f, -1.54463887e-01f, 2.67896891e-01f, -1.24879099e-01f, -2.35966086e-01f, 1.69562940e-02f, 3.04465760e-02f, -9.30469334e-02f, 5.80071546e-02f,
  1.01249233e-01f, -1.15319543e-01f, 2.15354323e-01f, 2.28366759e-02f, 3.34602930e-02f, 2.11207628e-01f, 4.25495878e-02f, 2.95332773e-03f, 2.38505095e-01f, 4.73208688e-02f,
  -2.43402384e-02f, 1.93672497e-02f, 1.04498968e-01f, 6.22503310e-02f, -4.45188805e-02f, 1.88623741e-02f, 4.32044901e-02f, 2.30578054e-02f, 3.53980809e-02f, 6.98498264e-02f,
  1.27820939e-01f, 4.98846807e-02f, 1.24987513e-01f, 3.80684584e-02f, -3.26580442e-02f, 4.17327285e-02f, 5.22906519e-02f, 1.16244592e-02f, 1.06911339e-01f, 9.23879966e-02f,
  1.15964450e-01f, 1.17256939e-01f, 8.64632335e-03f, 3.04184202e-02f, 3.29025574e-02f, 8.70197862e-02f, -9.36575830e-02f, 6.04908029e-03f, 7.49243125e-02f, 6.33015484e-02f,
  -1.17264524e-01f, -1.16763994e-01f, -1.21225063e-02f, 9.61043462e-02f, -4.21162583e-02f, 1.05455548e-01f, 6.52382821e-02f, 2.26217359e-02f, 7.33955950e-02f, -4.07296084e-02f,
  6.89615384e-02f, 7.49078989e-02f, -5.00021763e-02f, 4.33114357e-02f, 3.68325152e-02f, -2.04592329e-02f, 1.29022166e-01f, 2.83946060e-02f, 1.85788721e-02f, 3.32349055e-02f,
  -7.13333637e-02f, 1.60010310e-03f, -2.33838912e-02f, 1.03242211e-01f, -1.04177199e-01f, -6.36550114e-02f, -1.35885393e-02f, -6.29731119e-02f, 9.39461496e-03f, -3.73431854e-02f,
  -5.17580360e-02f, -1.43726096e-01f, -7.94204473e-02f, 2.84957141e-02f, 3.44197713e-02f, 4.00368012e-02f, -3.86436023e-02f, 1.56522229e-01f, -8.44571274e-03f, -4.48569134e-02f,
  1.08494148e-01f, 6.01130240e-02f, -7.93062896e-02f, 1.59516484e-01f, -1.12367496e-02f, -5.52645810e-02f, -2.92516570e-03f, -4.73653041e-02f, 1.16535768e-01f, -1.08107835e-01f,
  4.81524225e-03f, -1.77273701e-03f, -6.01324849e-02f, 1.45124003e-01f, 7.51925260e-02f, -7.05762813e-03f, -8.74879733e-02f, -4.36567003e-03f, -9.86765232e-03f, 4.90915775e-02f,
  9.80626047e-02f, -1.81354418e-01f, -1.78117052e-01f, -9.52914655e-02f, -1.07098244e-01f, -2.87624747e-01f, -2.32521042e-01f, -1.18987717e-01f, 5.14856465e-02f, -7.30447397e-02f,
  -1.28681427e-02f, -9.88295004e-02f, 1.18926726e-01f, -2.17392161e-01f, 2.51648668e-03f, 1.72083005e-01f, -2.52468050e-01f, -1.79529011e-01f, -3.75099964e-02f, -1.00371130e-01f,
  5.04263118e-02f, -8.50906149e-02f, -1.37103423e-01f, -4.88663092e-02f, -1.18505403e-01f, -7.04600569e-03f, 9.01559070e-02f, -1.36015872e-02f, -9.01829377e-02f, 6.18248582e-02f,
  -9.21416804e-02f, 1.58218846e-01f, 5.85559104e-03f, -5.79685532e-03f, 1.42619349e-02f, 4.09552343e-02f, -7.22114667e-02f, -1.40406834e-02f, -2.89124791e-02f, -8.56779143e-02f,
  7.07261711e-02f, 9.61519182e-02f, -8.60990435e-02f, 4.21522334e-02f, -3.05448864e-02f, 2.91539333e-03f, 4.42372337e-02f, 6.31796867e-02f, -1.22226700e-01f, -2.06318055e-03f,
  -7.09920302e-02f, -1.55348824e-02f, 2.02829279e-02f, 5.64084128e-02f, -1.09689441e-02f, -4.10564952e-02f, 8.08784366e-03f, 1.10813335e-01f, 9.99069028e-03f, -3.68905184e-03f,
  -4.05578911e-02f, 4.81622219e-02f, -8.08627065e-03f, -1.75699480e-02f, -2.66736690e-02f, 4.03775424e-02f, -2.09438670e-02f, -1.44594926e-02f, -1.07585199e-01f, -4.32710163e-02f,
  1.75807551e-02f, -3.46933268e-02f, 8.03326517e-02f, -2.86638620e-03f, -1.47414580e-01f, 5.13627790e-02f, 4.54372130e-02f, 9.04095098e-02f, -2.53503043e-02f, 5.92738353e-02f,
  2.41059214e-02f, 6.18615970e-02f, -1.27442375e-01f, -1.21550754e-01f, -4.20440286e-02f, -7.15882257e-02f, -7.52847968e-03f, -7.77239576e-02f, -2.70155608e-03f, -7.00649470e-02f,
  6.81382092e-03f, 7.47652724e-02f, 4.65439111e-02f, -1.41882345e-01f, -6.11951984e-02f, 3.84794138e-02f, -8.32671393e-03f, -7.18631819e-02f, -7.69433156e-02f, 2.77049076e-02f,
  4.44282256e-02f, -2.63344906e-02f, -3.72070484e-02f, 9.33325142e-02f, -2.24295259e-02f, -5.25711440e-02f, -6.04638346e-02f, 4.48964313e-02f, -9.28151309e-02f, 4.58655544e-02f,
  -5.97076453e-02f, 4.82758358e-02f, -6.82257041e-02f, -4.99770939e-02f, -9.98966396e-02f, -2.43616849e-03f, 5.31569682e-02f, -6.74290350e-03f, 1.39563261e-02f, -1.33529175e-02f,
  -2.17058375e-01f, 7.12605715e-02f, 2.13926986e-01f, -1.95023462e-01f, 3.25714946e-02f, 6.12742156e-02f, -1.05842672e-01f, -6.60293400e-02f, -3.89479436e-02f, -9.45102274e-02f,
  -1.41570523e-01f, 1.14423826e-01f, -1.30513217e-02f, -2.27250904e-02f, -2.57021859e-02f, 3.57437432e-02f, -1.07199453e-01f, -5.28472252e-02f, -4.12112474e-02f, -4.97366786e-02f,
  -1.00698292e-01f, -1.72639310e-01f, 1.16999969e-02f, -1.55341506e-01f, 2.64405515e-02f, -3.31966579e-02f, -6.42083138e-02f, 7.83104673e-02f, -6.24588178e-03f, 2.16836166e-02f,
  4.09580097e-02f, -1.38619542e-01f, 1.81197330e-01f, 3.82245146e-02f, 9.33580101e-02f, -4.14110087e-02f, -3.92994508e-02f, 1.80960800e-02f, -9.79051813e-02f, 1.61327899e-01f,
  -3.96281555e-02f, 3.61342132e-02f, -1.92770623e-02f, 5.14140688e-02f, -2.52937973e-02f, 8.99223164e-02f, 9.35110003e-02f, -4.61495221e-02f, 1.32197931e-01f, 1.05801374e-01f,
  1.51288077e-01f, 1.19985811e-01f, 6.65742829e-02f, 4.12865132e-02f, -1.09330319e-01f, -3.52514796e-02f, 3.41461226e-02f, 1.06775105e-01f, 3.60065736e-02f, -5.09605706e-02f,
  -1.33708850e-01f, -1.09078452e-01f, 1.18663251e-01f, 1.06756970e-01f, -9.33400989e-02f, 1.55510213e-02f, 1.56052619e-01f, -6.64755479e-02f, -7.97037631e-02f, -3.52692083e-02f,
  -7.94887319e-02f, 6.07480202e-03f, 3.38433757e-02f, 6.88883960e-02f, -9.68515128e-03f, 2.78888419e-02f, 1.28643410e-02f, 5.27259298e-02f, -1.64171420e-02f, -7.17016011e-02f,
  -7.42654428e-02f, -2.01191287e-02f, 1.47214150e-02f, -2.50044540e-02f, 1.32327974e-01f, 1.14560969e-01f, -3.03821806e-02f, 1.85528979e-01f, -7.71012008e-02f, -2.29111668e-02f,
  -6.02491871e-02f, -2.33080208e-01f, 3.30326967e-02f, 1.59527622e-02f, 8.98569673e-02f, -2.29249950e-02f, -2.72326358e-02f, 1.35193020e-02f, 2.33634468e-02f, -8.15317705e-02f,
  7.89429620e-02f, -2.39631291e-02f, 1.08183458e-01f, 3.87375392e-02f, -1.11548170e-01f, -8.34534690e-02f, -1.13050885e-01f, 3.12443040e-02f, -1.32012125e-02f, -5.15934043e-02f,
  -5.82613982e-02f, -3.29124182e-02f, -8.72815847e-02f, -3.52045745e-02f, -1.02542251e-01f, 6.23445697e-02f, -1.29418090e-01f, -3.42837186e-03f, 6.50430173e-02f, 4.01715860e-02f,
  -1.15504198e-01f, -3.30813043e-02f, -7.73424357e-02f, -1.15259595e-01f, -2.34553307e-01f, -7.73657858e-02f, -3.80040854e-02f, 9.64426529e-03f, -2.70320885e-02f, 2.14965507e-01f,
  7.34450147e-02f, 1.00034431e-01f, 1.89231411e-01f, -1.20504098e-02f, -4.19962071e-02f, 1.90272465e-01f, -3.13618109e-02f, 2.67529357e-02f, -6.97826594e-02f, -1.50346383e-01f,
  -5.34859896e-02f, 4.17905524e-02f, 7.03868121e-02f, -6.91669211e-02f, -1.88017935e-01f, -9.82588232e-02f, 3.57457931e-04f, -8.75541717e-02f, -1.48879960e-01f, -2.71663889e-02f,
  7.93977752e-02f, 1.09512404e-01f, -3.18686813e-02f, 1.29902527e-01f, 2.11829320e-02f, -5.12265228e-02f, -5.70259541e-02f, -5.67195006e-03f, 9.63660236e-03f, 3.34535427e-02f,
  -9.15506259e-02f, 2.75923894e-03f, -8.69024079e-03f, -1.59051735e-02f, -1.78783968e-01f, 2.91154962e-02f, 2.97645070e-02f, -1.46199465e-01f, -5.17967679e-02f, -7.02916980e-02f,
  -5.24820574e-03f, -1.34593155e-03f, 1.79584306e-02f, -1.73490997e-02f, -3.67111154e-02f, 3.78112979e-02f, 2.84948759e-02f, -9.15239751e-02f, -1.17613014e-03f, 3.84485349e-02f,
  4.80081141e-02f, -4.95578125e-02f, 4.44503799e-02f, 3.61844786e-02f, 8.34801868e-02f, 5.63984923e-02f, -2.65566688e-02f, 1.19320624e-01f, 8.82427692e-02f, -2.04969812e-02f,
  -1.69115923e-02f, -3.33259813e-02f, -7.49744326e-02f, -2.82244496e-02f, -3.89833115e-02f, -5.31615391e-02f, 7.73270950e-02f, -6.73652068e-03f, 5.62221855e-02f, 3.37844044e-02f,
  9.82512087e-02f, -6.23921379e-02f, -5.75274006e-02f, 1.16513390e-03f, 2.90111303e-02f, -7.69435912e-02f, -1.04431689e-01f, -7.66375428e-03f, -7.27694249e-03f, -8.36486369e-02f,
  -3.13818902e-02f, 1.16928779e-01f, 6.08889349e-02f, 1.01966314e-01f, 8.64515379e-02f, -9.03593898e-02f, -7.97183886e-02f, -7.97752887e-02f, -3.06148529e-02f, 4.60597826e-03f,
  4.81110252e-02f, 9.09667984e-02f, -1.00476377e-01f, 1.86954662e-02f, 1.40888104e-02f, -3.72687019e-02f, 3.58556223e-04f, -1.32730359e-03f, -6.54862970e-02f, -9.86515656e-02f,
  -1.05878994e-01f, 6.76579550e-02f, 3.81155647e-02f, 1.06589280e-01f, 7.81919062e-02f, -1.81975756e-02f, -1.51027262e-01f, -1.78292915e-02f, -1.26588494e-01f, -1.86359026e-02f,
  3.10463179e-03f, 6.27728179e-02f, -1.51401579e-01f, -9.73634794e-02f, -1.94490060e-01f, -1.46221435e-02f, -1.19908899e-01f, -1.54267028e-01f, -1.39317110e-01f, 1.22435667e-01f,
  2.50636283e-02f, 6.76128864e-02f, 7.89361354e-03f, 1.63651660e-01f, -1.53778523e-01f, 1.13876112e-01f, 1.59799576e-01f, 7.87888318e-02f, 1.11999065e-01f, -1.03439428e-02f,
  1.04808152e-01f, 1.17790975e-01f, 5.47456518e-02f, -3.79120596e-02f, 1.57214403e-01f, 1.30877987e-01f, 5.83131537e-02f, -1.20613143e-01f, -1.04299542e-02f, 2.13152729e-02f,
  -1.71889123e-02f, 3.29779945e-02f, -1.20452255e-01f, 3.38212140e-02f, 8.14997181e-02f, 1.28511369e-01f, -9.68419109e-03f, -1.70709286e-02f, -7.27458671e-02f, 1.10650785e-01f,
  6.69310838e-02f, 3.05282213e-02f, -9.34431143e-03f, -8.22741017e-02f, 4.84054200e-02f, 3.17195915e-02f, -2.62716971e-02f, -6.83249980e-02f, -1.02482155e-01f, 2.20939349e-02f,
  -1.14770688e-01f, 4.14018817e-02f, -6.01901561e-02f, 1.21539049e-01f, -3.76498653e-03f, -7.75815323e-02f, 4.19356301e-02f, 6.15875907e-02f, -8.72562826e-03f, 7.72727281e-02f,
  1.12727858e-01f, -1.23304196e-01f, 9.76384804e-02f, -6.88983798e-02f, 4.78749387e-02f, 5.37788570e-02f, -1.14251688e-01f, 2.91121546e-02f, 7.09934607e-02f, 5.06915748e-02f,
  -3.63150612e-02f, -2.98178140e-02f, -1.05727240e-02f, -3.79994959e-02f, -5.26436865e-02f, 8.30659352e-04f, -4.20781635e-02f, 1.84660442e-02f, -4.91912626e-02f, -5.10192700e-02f,
  3.39816958e-02f, -1.23112071e-02f, 4.33686487e-02f, -1.00526419e-02f, -6.90953359e-02f, 1.90329421e-02f, 1.46725997e-01f, 9.71161481e-03f, -2.51970887e-02f, 7.93548301e-02f,
  1.42810434e-01f, 1.17127784e-01f, -1.06950358e-01f, -8.42141658e-02f, -2.12450270e-02f, 3.70587818e-02f, 8.32633302e-03f, 7.46678784e-02f, -1.33106466e-02f, -1.74361821e-02f,
  2.29875505e-01f, -1.11258537e-01f, 8.32817331e-02f, -1.03729688e-01f, -4.50348146e-02f, 1.14081159e-01f, -3.68705764e-02f, 5.45727648e-02f, 6.44449983e-03f, -1.26340851e-01f,
  -8.87853801e-02f, 7.54330382e-02f, 8.01484957e-02f, 7.70561621e-02f, -7.24874213e-02f, -5.22929095e-02f, -7.20670372e-02f, 1.09530307e-01f, 1.50408400e-02f, 2.84049641e-02f,
  1.77045185e-02f, 1.24083690e-01f, 1.09555475e-01f, 1.61142722e-01f, -8.41682702e-02f, -2.53795117e-01f, -1.30040795e-01f, 1.14493601e-01f, 1.84863321e-02f, -1.73649434e-02f,
  1.04465969e-01f, 2.41769552e-02f, 3.71630415e-02f, 2.06776336e-01f, 1.50729895e-01f, -8.24227333e-02f, 1.77650630e-01f, -3.18102427e-02f, 1.44475520e-01f, 1.91414371e-01f,
  1.27027873e-02f, 8.18086341e-02f, 1.93078756e-01f, -3.09425611e-02f, 8.89836624e-02f, 4.53832932e-02f, 1.29978970e-01f, -1.09142333e-01f, 1.86546788e-01f, -3.54784504e-02f,
  -8.62529129e-02f, -3.58536560e-03f, 4.37131673e-02f, 4.27712426e-02f, 4.98765744e-02f, -4.15196382e-02f, -9.81933996e-02f, 7.91972950e-02f, -2.41809338e-02f, -2.27641929e-02f,
  -4.93954681e-02f, 7.35949948e-02f, 1.01175025e-01f, -8.62841085e-02f, -5.79658039e-02f, 7.51907229e-02f, 9.00541395e-02f, -1.12231269e-01f, -6.77036569e-02f, 6.07297849e-03f,
  -4.81854752e-02f, -7.65129700e-02f, -4.13954556e-02f, 4.17124927e-02f, 9.40627679e-02f, -6.72771260e-02f, -6.20798431e-02f, -1.96688324e-02f, -2.71284152e-02f, 9.82301086e-02f,
  7.56460428e-02f, -1.18311659e-01f, 5.15009314e-02f, 7.07586855e-02f, 6.71140850e-02f, -5.43938130e-02f, -5.41372690e-03f, 8.94722417e-02f, -3.25879082e-02f, 8.99053439e-02f,
  -2.35540904e-02f, 8.59063417e-02f, 4.40159664e-02f, 7.76702464e-02f, 2.97208894e-02f, 5.65408915e-03f, -1.18911184e-01f, -2.03084089e-02f, 5.71396276e-02f, 4.02678140e-02f,
  -1.28515242e-02f, 1.40479475e-01f, -4.52758223e-02f, 2.72116028e-02f, 2.54951101e-02f, 1.59196910e-02f, 9.85238105e-02f, 3.64911743e-02f, -9.94884316e-03f, 4.39856481e-03f,
  8.32786560e-02f, 2.72695363e-01f, -8.13093632e-02f, -5.94318397e-02f, 5.91935329e-02f, -2.86667254e-02f, 5.82371131e-02f, 1.21873848e-01f, 1.48213476e-01f, 8.63188505e-02f,
  1.62779745e-02f, -1.65087074e-01f, -3.15650590e-02f, -8.23418871e-02f, -9.46604367e-03f, 9.73460153e-02f, 8.30487385e-02f, 4.75173406e-02f, 8.73094723e-02f, 7.40950182e-02f,
  2.96527017e-02f, -2.97878627e-02f, 6.15761243e-02f, -3.73163708e-02f, 1.14499331e-01f, -3.91266346e-02f, -3.84980068e-02f, 1.88801661e-02f, -3.92597243e-02f, 4.20339890e-02f,
  -1.57808363e-01f, 6.73015490e-02f, -1.36266844e-02f, -1.50772318e-01f, -2.21766569e-02f, -2.03384638e-01f, -1.32922336e-01f, 8.35628808e-02f, 3.08062173e-02f, 1.20196670e-01f,
  2.04258319e-02f, 2.31024206e-01f, 3.33026312e-02f, -1.70948446e-01f, -3.12703490e-01f, -5.00899516e-02f, -2.87527561e-01f, -1.36958435e-01f, -5.44089638e-03f, -2.15404090e-02f,
  -1.19131342e-01f, 2.54680514e-02f, -2.24834532e-01f, 4.48804088e-02f, -7.15618730e-02f, 9.98473391e-02f, -1.74999014e-01f, 8.46989080e-02f, -9.92996693e-02f, -8.62956941e-02f,
  4.42949161e-02f, 1.49579048e-01f, 7.06622154e-02f, -3.45265344e-02f, -1.49652094e-01f, -9.60293189e-02f, -4.38023172e-02f, -1.37294699e-02f, -5.10384589e-02f, -9.05368105e-02f,
  -5.25514930e-02f, -1.12836028e-03f, 1.68872308e-02f, 8.28267336e-02f, 5.47180139e-02f, -3.22312675e-02f, 7.25300834e-02f, 7.29865208e-02f, 8.75806510e-02f, 2.68283151e-02f,
  -1.00084707e-01f, 3.78462262e-02f, -5.17793261e-02f, 2.58758012e-02f, -2.82002315e-02f, -8.19978304e-03f, -5.55281304e-02f, -1.01016015e-02f, 1.66231059e-02f, 1.94486901e-02f,
  -4.37114909e-02f, -7.88819566e-02f, -4.41647433e-02f, 3.79675180e-02f, -3.84011790e-02f, -6.13700859e-02f, -2.15010252e-02f, 3.25480625e-02f, 7.81621784e-02f, -7.85000622e-02f,
  -7.05696866e-02f, 8.43875334e-02f, 2.77077723e-02f, -4.15109843e-02f, 4.61710729e-02f, 1.20514520e-01f, -8.90530795e-02f, -5.84232137e-02f, -2.38400437e-02f, 2.49471869e-02f,
  1.40771136e-01f, -2.36030538e-02f, -1.47347397e-03f, -4.99470206e-03f, 1.19108222e-02f, 1.50198981e-01f, -1.52497292e-02f, -9.11816433e-02f, -9.66368169e-02f, 9.02980343e-02f,
  -5.49890101e-02f, 7.95504227e-02f, -6.47907332e-02f, 4.12187614e-02f, -5.70540503e-02f, -7.30725005e-02f, 8.27723369e-03f, 6.09061262e-03f, -8.95806998e-02f, -2.11588126e-02f,
  -9.63947177e-03f, -6.59387410e-02f, -3.61774713e-02f, -5.40495589e-02f, -3.49426381e-02f, -4.44290079e-02f, -6.59400458e-03f, -4.25689248e-03f, 4.22229478e-03f, -2.06590258e-02f,
  6.99521452e-02f, 8.29798952e-02f, 7.77299255e-02f, 2.84751821e-02f, 5.36525138e-02f, -8.85305256e-02f, 2.80677695e-02f, 2.26863492e-02f, -7.60421040e-04f, -5.70958667e-02f,
  8.52455199e-02f, 1.27364412e-01f, -1.15480088e-01f, -1.08486496e-01f, -2.31348425e-01f, -1.12278342e-01f, -1.94459140e-01f, -9.70827881e-03f, 1.78801790e-01f, 5.13800867e-02f,
  -2.18769610e-01f, 2.41357967e-01f, 9.51952711e-02f, -1.41673014e-01f, 5.20430803e-02f, 9.18254480e-02f, -1.62485003e-01f, -7.73334280e-02f, 1.24684617e-01f, -1.58972263e-01f,
  -1.11375377e-01f, -1.52176425e-01f, -1.83786333e-01f, -1.57355264e-01f, -1.86559588e-01f, 6.07986748e-02f, 3.14065255e-03f, -8.18266869e-02f, -1.54124536e-02f, 1.27868950e-02f,
  2.52708308e-02f, -3.49445082e-02f, 4.67408560e-02f, -2.69347467e-02f, -9.34471264e-02f, -6.75532827e-03f, -1.46921650e-01f, -4.50947620e-02f, -4.76809107e-02f, 1.29699007e-01f,
  9.34161991e-02f, 2.12892387e-02f, -1.83035422e-03f, -7.45560080e-02f, 1.31758545e-02f, 6.68627322e-02f, 4.44180556e-02f, -4.43176068e-02f, -2.88016181e-02f, 5.38766645e-02f,
  -4.63880822e-02f, 1.55840348e-03f, -6.34259731e-02f, 2.26522684e-02f, 2.51957867e-02f, -6.83495998e-02f, -1.06770217e-01f, 3.60870399e-02f, 3.23020853e-02f, 1.12035915e-01f,
  6.14983588e-02f, -4.04343419e-02f, 4.07908671e-03f, -7.70753175e-02f, -2.35905647e-02f, -2.89666820e-02f, -1.74215138e-02f, 1.15553094e-02f, -5.62617816e-02f, -9.78113264e-02f,
  4.87380251e-02f, -2.16667410e-02f, -7.19013214e-02f, 8.52045044e-02f, 4.62581031e-02f, 3.96178961e-02f, -1.97712556e-02f, 4.57752263e-03f, -9.07468125e-02f, 3.10698710e-02f,
  7.10200146e-02f, -5.85924536e-02f, 7.78644159e-02f, -2.69608162e-02f, -5.01059741e-02f, 1.43052675e-02f, 5.63169047e-02f, -6.79240003e-02f, 1.08086765e-01f, -6.49881065e-02f,
  -4.09780666e-02f, 9.78938267e-02f, 3.54263820e-02f, 1.41891196e-01f, -2.27203500e-02f, -9.49232373e-03f, 2.93772556e-02f, 5.13227321e-02f, -1.42421238e-02f, 5.20145297e-02f,
  -1.44724280e-01f, 1.81971528e-02f, 2.53815134e-03f, 6.20414615e-02f, -6.28121989e-03f, 2.89445501e-02f, -1.51617108e-02f, 1.01102844e-01f, -5.56724891e-02f, -7.60772824e-02f,
  3.67788523e-02f, -4.53257561e-02f, -5.35802683e-03f, 4.09371331e-02f, -5.68812452e-02f, -5.77465817e-02f, -3.95204201e-02f, -1.39881931e-02f, 7.15372264e-02f, 9.51224193e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  4.90756258e-02f, 2.10346982e-01f, 3.05007137e-02f, 1.20582402e-01f, 2.00235829e-01f, 1.57722548e-01f, 2.65471160e-01f, 1.83180690e-01f, 1.27943605e-01f, 1.63862035e-01f,
  2.12733001e-01f, 1.05405733e-01f, 2.69529313e-01f, 1.26439959e-01f, 1.91977903e-01f, 2.76553810e-01f, 4.13803495e-02f, 2.04779178e-01f, 7.49745220e-02f, 2.41347894e-01f,
  3.02143157e-01f, 1.68177634e-01f, 2.05379695e-01f, 1.34293154e-01f, 2.28418335e-01f, 1.71867162e-01f, 2.68885911e-01f, 1.40052646e-01f, 2.13238567e-01f, 1.48433045e-01f,
  1.08088352e-01f, 1.90083638e-01f, 2.12223575e-01f, 2.54648596e-01f, 2.14949161e-01f, 1.26325324e-01f, 9.22707990e-02f, 2.21636236e-01f, 2.18989700e-01f, 1.08535893e-01f,
  5.33195883e-02f, 2.03615814e-01f, 2.03088909e-01f, 2.21888468e-01f, 1.01785332e-01f, 1.53100193e-01f, 1.51342019e-01f, 1.50652766e-01f, 2.33558193e-01f, 4.02323492e-02f,
  1.08915761e-01f, 8.73216242e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.32686257e-01f, -2.29128614e-01f, -8.88266489e-02f, -1.14350460e-01f, -7.81224594e-02f, -1.29139060e-02f, 1.39679909e-01f, -7.83350691e-02f, -1.57732293e-01f, -5.28825559e-02f,
  7.83752352e-02f, 3.06233112e-03f, 1.49803281e-01f, -1.40965492e-01f, 5.67058325e-02f, 1.03326015e-01f, -1.74549192e-01f, -2.32479677e-01f, 6.63368925e-02f, 2.26349309e-02f,
  7.61468560e-02f, 1.57398701e-01f, 7.92867839e-02f, -1.64160237e-01f, -6.62083700e-02f, 6.90711588e-02f, -1.70570016e-01f, -2.04506457e-01f, -2.20972791e-01f, 1.15150124e-01f,
  2.23269071e-02f, -6.04936630e-02f, -1.03297373e-02f, 1.23817779e-01f, 1.97189480e-01f, -2.83734411e-01f, -1.68310273e-02f, -3.57048842e-03f, -7.03295693e-02f, 1.95037603e-01f,
  4.32422459e-02f, -9.95938554e-02f, 8.34007636e-02f, 3.75619084e-02f, 3.92113402e-02f, -1.29310951e-01f, -2.56079346e-01f, 1.58503592e-01f, 2.11712658e-01f, 1.02822490e-01f,
  -1.79744020e-01f, -3.23750302e-02f, 1.42226011e-01f, -7.62230009e-02f, -1.45524979e-01f, -5.12974262e-02f, -5.84192127e-02f, 2.91756876e-02f, 9.60097536e-02f, 7.38110542e-02f,
  2.28520650e-02f, -1.98362470e-01f, -1.55863771e-02f, 7.42465779e-02f, 6.87499866e-02f, -1.03694715e-01f, -8.72329697e-02f, 1.06124848e-01f, 4.96678427e-02f, -1.20520657e-02f,
  1.94701508e-01f, -1.23928346e-01f, 1.39127448e-01f, -1.86386079e-01f, -1.46932185e-01f, -1.05175495e-01f, 1.09563358e-02f, 3.83004434e-02f, 3.82204838e-02f, -2.02046394e-01f,
  7.67002441e-03f, -1.92891091e-01f, -1.24030923e-02f, -1.93292737e-01f, 2.94913858e-01f, -1.69700339e-01f, 4.11034897e-02f, -7.54803568e-02f, 1.11483619e-01f, 2.41214205e-02f,
  7.17688128e-02f, -3.78329046e-02f, 8.17074813e-03f, -2.71615805e-03f, 7.89688975e-02f, -1.46680653e-01f, 2.00674012e-02f, 2.34604672e-01f, 1.99654594e-01f, -8.62292945e-02f,
  -1.20858431e-01f, -1.17787234e-01f, -2.12991312e-02f, -3.46742272e-02f, -1.27540350e-01f, 2.75554527e-02f, -2.25152895e-01f, 2.39628684e-02f, -2.84290820e-01f, -5.66207580e-02f,
  -1.40834048e-01f, 3.09413858e-02f, -7.41888285e-02f, -3.86464992e-03f, 1.71971843e-01f, -4.81405817e-02f, -3.18714306e-02f, 6.74780384e-02f, 4.27068248e-02f, -1.98420107e-01f,
  1.76983476e-02f, -1.46825105e-01f, -5.86998537e-02f, 3.49264108e-02f, -3.07748504e-02f, -8.31482932e-02f, -8.45724866e-02f, -1.26496643e-01f, -5.49742617e-02f, 5.11894487e-02f,
  1.34014532e-01f, -9.68238190e-02f, 5.69157973e-02f, -4.52890843e-02f, 1.75533876e-01f, -1.54784769e-01f, 1.09136835e-01f, -1.06513411e-01f, 5.84714450e-02f, -8.77198577e-03f,
  -3.33934687e-02f, -9.02025998e-02f, -4.34929840e-02f, -1.96097065e-02f, 9.00202394e-02f, 1.82957143e-01f, 2.47760579e-01f, -2.24474549e-01f, 2.59579718e-01f, -1.83074892e-01f,
  1.04993396e-01f, 2.33004719e-01f, 5.08719534e-02f, 1.00819334e-01f, -1.92757219e-01f, 4.34201770e-03f, 1.16618454e-01f, -6.64274320e-02f, 2.52886027e-01f, -1.16948597e-01f,
  5.91432303e-02f, 1.69388369e-01f, 1.37447357e-01f, -2.31834576e-01f, 1.48475870e-01f, 1.42679378e-01f, -2.50154614e-01f, 3.27437371e-02f, 2.45830402e-01f, 8.92304704e-02f,
  7.81382620e-02f, 8.36521387e-02f, 7.76308626e-02f, 5.37768528e-02f, 1.47516370e-01f, -7.05374628e-02f, 1.27896339e-01f, -4.24333513e-02f, 3.13334353e-02f, 1.10118777e-01f,
  1.03800166e-02f, -6.74998537e-02f, -2.08811209e-01f, -1.37150183e-01f, 7.09911585e-02f, -8.95104110e-02f, 2.40025595e-01f, -8.94013643e-02f, 1.22165672e-01f, 1.23084567e-01f,
  -1.00267619e-01f, -9.49259773e-02f, 1.12497240e-01f, 1.20753124e-01f, 1.27431871e-02f, -1.06125660e-01f, 1.83911070e-01f, 9.43582356e-02f, -1.42573208e-01f, 1.72536105e-01f,
  -1.68531258e-02f, -1.60278574e-01f, -1.71192959e-01f, 2.21895888e-01f, -1.06240086e-01f, -3.92341912e-02f, -1.24052748e-01f, 8.33116695e-02f, 6.86359406e-02f, 4.86306064e-02f,
  1.76443588e-02f, 1.33669555e-01f, -1.06074236e-01f, -1.38444215e-01f, -3.59310657e-02f, 8.48743320e-02f, -1.88234434e-01f, 7.48853981e-02f, 7.68359601e-02f, 9.30496901e-02f,
  1.62642807e-01f, 1.52514547e-01f, -2.53555514e-02f, 3.54193561e-02f, 1.37801031e-02f, 2.57297866e-02f, -9.77048799e-02f, 2.75727105e-03f, 2.11668119e-01f, -6.35754317e-02f,
  1.35228485e-01f, 4.17774208e-02f, 9.54348892e-02f, 5.95335662e-02f, -1.18754454e-01f, 3.17082815e-02f, 2.97715217e-02f, -5.11381552e-02f, 1.39001161e-01f, 7.57093281e-02f,
  -4.60379198e-02f, -9.61906984e-02f, 4.32165433e-03f, 1.02384083e-01f, -1.81632206e-01f, -7.30805099e-02f, 1.88652232e-01f, 1.40924826e-01f, 2.13781685e-01f, -1.61498338e-01f,
  1.73396170e-02f, -1.76220760e-02f, -1.38671815e-01f, 2.79794522e-02f, -9.18530226e-02f, -1.20593324e-01f, -4.78201956e-02f, -6.15738109e-02f, -1.29264131e-01f, -1.18409187e-01f,
  -2.88342368e-02f, -1.06923915e-01f, -1.16591126e-01f, -5.79173714e-02f, 1.29568860e-01f, 1.03840873e-01f, -1.71782542e-02f, 1.28471196e-01f, -1.97239935e-01f, -6.57942742e-02f,
  -1.05626788e-02f, 5.76374978e-02f, 1.74800903e-01f, -9.55258589e-03f, -9.25721228e-02f, -1.59441203e-01f, 1.12388581e-01f, -1.01283528e-01f, -8.05883929e-02f, 6.65126543e-04f,
  7.77499005e-03f, -2.55650021e-02f, -1.27622709e-01f, 6.12909906e-02f, 7.23466799e-02f, -6.96631754e-03f, 2.20775217e-01f, 1.16135351e-01f, 2.18972892e-01f, 6.99834600e-02f,
  -8.87637213e-02f, -7.97970220e-02f, 2.01966077e-01f, -4.94760238e-02f, -1.56619519e-01f, -2.04343684e-02f, 1.73062325e-01f, 1.32898256e-01f, -5.92042841e-02f, -4.51399982e-02f,
  -2.37247050e-02f, -1.04342178e-01f, 1.37029402e-02f, 3.39651597e-03f, -9.73593295e-02f, -7.77958930e-02f, 9.94000733e-02f, -8.73768050e-03f, -4.47003804e-02f, -2.32455563e-02f,
  -2.87939142e-02f, -4.70448285e-02f, 2.61676405e-02f, 3.93237919e-02f, -1.33663461e-01f, -1.35556817e-01f, -5.39759323e-02f, 2.07701653e-01f, -1.38325125e-01f, -1.60468191e-01f,
  3.88815738e-02f, 1.38399063e-03f, 3.38028371e-02f, 4.54240143e-02f, -4.56010215e-02f, 4.50338796e-02f, -5.38233295e-02f, 6.52048597e-03f, 2.22030535e-01f, 1.19147405e-01f,
  -1.94619298e-01f, -8.52191672e-02f, -9.73360017e-02f, 1.93719298e-01f, 1.96520254e-01f, -2.10473627e-01f, -5.33968061e-02f, -1.25139490e-01f, -1.48057014e-01f, -9.31635201e-02f,
  4.21399362e-02f, 5.13051590e-03f, -1.71622704e-03f, -7.28767514e-02f, 1.43842116e-01f, 1.01516685e-02f, 1.08543150e-01f, 2.12641463e-01f, 1.54084593e-01f, -6.03308342e-02f,
  -6.14011995e-02f, 5.49876466e-02f, 6.31176084e-02f, -2.71563791e-02f, -3.56350578e-02f, 1.11380987e-01f, -1.00346722e-01f, -6.86380044e-02f, 1.17600694e-01f, -4.17400822e-02f,
  -2.11017519e-01f, -1.08088762e-01f, -1.46157239e-02f, -8.39833915e-02f, -1.34745419e-01f, -1.18421271e-01f, -9.50647220e-02f, -2.97397521e-04f, -1.43726140e-01f, 4.10927348e-02f,
  1.90098152e-01f, -9.74243507e-02f, -3.32284458e-02f, 2.23319307e-01f, 9.22423378e-02f, -2.74936226e-03f, -1.82859063e-01f, 4.81915399e-02f, -1.15018502e-01f, 2.44046710e-02f,
  -1.36273429e-02f, 1.55756352e-02f, -9.60076526e-02f, -6.02933727e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.21509330e-02f, 1.58847988e-01f, 1.43902719e-01f, 1.53822035e-01f, -5.44032231e-02f, 4.26682495e-02f, 3.20663601e-01f, 1.46000296e-01f, 9.80165228e-02f, -2.77484059e-01f,
  -1.14472717e-01f, -1.73583493e-01f, 3.77854221e-02f, 1.51786327e-01f, -1.57487094e-02f, 1.52459592e-01f, -7.11770952e-02f, -6.77502528e-02f, 2.03102738e-01f, 2.25417495e-01f,
  1.31356893e-02f, 2.00529099e-02f, -6.15500100e-02f, -1.47580773e-01f, -4.04399112e-02f, 2.86978126e-01f, -1.27065629e-01f, -1.46037303e-02f, 2.93533444e-01f, 2.27090884e-02f,
  -7.35949427e-02f, -2.25369796e-01f, 5.66460043e-02f, 2.28592932e-01f, 7.12317675e-02f, -2.24177018e-01f, 1.30295590e-01f, 2.60026723e-01f, 2.57996231e-01f, 3.63597184e-01f,
  -1.04461230e-01f, -5.62165603e-02f, -4.07900698e-02f, 3.20482761e-01f, -5.37013123e-03f, 1.68888286e-01f, 1.03504822e-01f, -4.46736999e-02f, 1.70751005e-01f, 2.57607847e-01f,
  2.42493629e-01f, 1.30980179e-01f, 8.70829448e-02f, 9.72427353e-02f, -1.30858272e-01f, 1.62034288e-01f, -1.03264954e-02f, 1.09314233e-01f, 1.29564628e-01f, -9.06054154e-02f,
  1.62380293e-01f, 4.34867777e-02f, 2.08148852e-01f, -5.32912835e-02f, 1.61823824e-01f, 1.93135768e-01f, -5.05401008e-03f, -3.05855870e-02f, 1.49712801e-01f, 1.14793591e-01f,
  -1.95717022e-01f, 1.21642388e-02f, -2.16181889e-01f, -7.91214556e-02f, 1.18765444e-01f, 3.19284052e-02f, 1.58716083e-01f, 2.16292944e-02f, 4.31794412e-02f, 1.59043327e-01f,
  1.33716732e-01f, 3.06042999e-01f, -3.58376876e-02f, 2.04749778e-01f, -2.05025166e-01f, 1.73043773e-01f, 1.02217473e-01f, 3.96188535e-02f, 6.22819066e-02f, 4.84730601e-02f,
  1.76976115e-01f, -2.80462522e-02f, 1.66425668e-02f, -6.10727221e-02f, -1.02263585e-01f, 1.41815916e-01f, -8.41253176e-02f, -2.47313231e-01f, -7.75899738e-02f, 1.03750281e-01f,
  -9.20425504e-02f, 6.41081333e-02f, 4.87238951e-02f, -3.10816616e-02f, -2.50094738e-02f, -2.59289076e-03f, 3.06304336e-01f, 1.25007167e-01f, 3.19461286e-01f, 2.60483354e-01f,
  1.86277434e-01f, 1.32399291e-01f, 5.46299368e-02f, 1.06939405e-01f, 3.33710834e-02f, -1.43177524e-01f, 1.92661628e-01f, -1.28418207e-01f, 1.08378656e-01f, 1.81469813e-01f,
  2.12410331e-01f, 8.91894847e-02f, 9.86124724e-02f, 1.79690510e-01f, 6.67630136e-02f, 1.57178089e-01f, 1.93083316e-01f, 2.94160038e-01f, 1.34700894e-01f, 1.59786671e-01f,
  4.05947901e-02f, 1.37260765e-01f, 1.97632730e-01f, 1.74643397e-02f, 2.17534211e-02f, -3.06486517e-01f, -1.45521611e-01f, 1.74360454e-01f, 2.34410688e-01f, -7.04766512e-02f,
  2.84608930e-01f, -3.58047113e-02f, 2.25775242e-01f, -4.06052582e-02f, 1.36286601e-01f, -1.46614105e-01f, 1.90295652e-02f, 1.14695393e-01f, 1.80370122e-01f, 8.24258700e-02f,
  2.22662181e-01f, -2.73509502e-01f, 1.33978814e-01f, -1.54576004e-01f, 1.10975869e-01f, 1.75131768e-01f, -1.87359884e-01f, 2.25906804e-01f, 1.95673807e-03f, -1.50809092e-02f,
  -1.28054261e-01f, -1.65418416e-01f, 1.90035522e-01f, 7.75416270e-02f, -8.01479593e-02f, -1.48967784e-02f, 1.23293936e-01f, -3.45263071e-02f, 5.81370853e-02f, 5.29893227e-02f,
  2.32763976e-01f, -5.22778295e-02f, 2.40349725e-01f, 5.55801066e-03f, -4.73947525e-02f, 1.22435965e-01f, 1.35282144e-01f, 7.37045929e-02f, 6.52035847e-02f, -1.06279053e-01f,
  2.88928777e-01f, 4.76113223e-02f, 1.19749576e-01f, -1.46135673e-01f, -1.24831736e-01f, 4.36216220e-03f, 1.18913921e-02f, 7.62190372e-02f, 2.27877438e-01f, -1.07738078e-01f,
  1.79708228e-01f, 1.36413723e-01f, 2.06554204e-01f, 9.86295044e-02f, 1.30023912e-01f, 1.54670298e-01f, 1.30612656e-01f, 4.32190262e-02f, 2.19382465e-01f, -2.04922289e-01f,
  1.96183193e-02f, 6.99752271e-02f, -1.79328591e-01f, 9.24420282e-02f, -2.49853075e-01f, 2.43229389e-01f, 8.40278268e-02f, -1.47299066e-01f, 1.32382378e-01f, 1.81015953e-01f,
  -1.27646700e-01f, -2.17317894e-01f, 5.14919572e-02f, 1.16851917e-02f, -2.16390193e-02f, 1.91416427e-01f, 9.49468762e-02f, 1.48554936e-01f, 9.10290331e-02f, 1.38466939e-01f,
  1.61216825e-01f, -2.49244407e-01f, 2.08099723e-01f, -1.58056840e-01f, 3.26170363e-02f, 1.19302407e-01f, -3.54640819e-02f, 1.07892364e-01f, 7.39109516e-03f, 1.43007830e-01f,
  3.41520198e-02f, -3.16833742e-02f, -1.29763916e-01f, 2.22069174e-01f, -1.05297469e-01f, -2.41586231e-02f, 6.84505850e-02f, 1.64197251e-01f, 2.93313384e-01f, -9.19230729e-02f,
  -1.42927632e-01f, 2.03056023e-01f, 1.92058563e-01f, 2.47482911e-01f, -1.49421036e-01f, 3.70850088e-03f, 1.63556173e-01f, 1.58299163e-01f, 2.71908939e-01f, -1.16144314e-01f,
  -3.29129468e-03f, -1.46571770e-01f, -3.93889705e-03f, 2.82348603e-01f, 7.94751197e-02f, -6.10932335e-02f, 1.74013793e-01f, -1.69824567e-02f, 1.58696562e-01f, 1.39572695e-01f,
  -1.56734604e-02f, 2.99767908e-02f, 2.56992579e-01f, -9.84901637e-02f, 1.14852898e-01f, -6.64484277e-02f, -1.79118708e-01f, -6.62674904e-02f, -1.67076543e-01f, 1.66601554e-01f,
  1.24258533e-01f, -9.31536481e-02f, -2.35619387e-04f, 2.58873254e-01f, 3.03072818e-02f, 4.36814725e-02f, 1.36825845e-01f, 5.67046180e-02f, -9.20889750e-02f, 5.12271002e-03f,
  1.95667386e-01f, 8.76045749e-02f, -1.68285161e-01f, 4.99732001e-03f, 2.12241739e-01f, -2.20526606e-01f, 7.23130777e-02f, -2.88023472e-01f, 2.39724413e-01f, 1.54166862e-01f,
  -1.37624234e-01f, -1.25298351e-01f, 1.92317694e-01f, 2.64615715e-01f, 7.40345716e-02f, 2.17773840e-01f, -2.19155058e-01f, 8.69253129e-02f, -8.10990669e-03f, 9.60326940e-02f,
  -1.21800400e-01f, 1.47726849e-01f, 2.21483216e-01f, -8.18321854e-02f, -5.19453511e-02f, 2.57708937e-01f, 3.20187002e-01f, 2.37468451e-01f, -1.03272721e-01f, -3.47291045e-02f,
  -1.24166504e-01f, -8.19786787e-02f, 1.51100010e-01f, 1.32030189e-01f, 8.53648558e-02f, -1.20422155e-01f, 6.35883957e-02f, 1.83418348e-01f, 2.07203835e-01f, 5.26753366e-02f,
  5.69062633e-03f, -5.77114485e-02f, 1.11157350e-01f, 1.04695313e-01f, 8.88289437e-02f, 8.43813792e-02f, -1.63684651e-01f, -2.07772464e-01f, 1.09221637e-01f, 2.71531641e-01f,
  -1.91545561e-01f, 4.85181101e-02f, 1.83507428e-02f, 1.79121837e-01f, 1.01339765e-01f, -1.89308196e-01f, 2.16178775e-01f, 1.64967537e-01f, -2.32968077e-01f, -9.84134525e-02f,
  -6.68779314e-02f, 7.66396821e-02f, -1.90744810e-02f, 1.74760595e-01f, 1.91663206e-01f, -6.23369887e-02f, 9.12398249e-02f, 2.65161246e-01f, 1.66992247e-01f, -1.66767016e-01f,
  7.79946893e-02f, 9.92135331e-03f, 8.78427178e-02f, -2.01231107e-01f, -1.73603356e-01f, 1.90788835e-01f, 9.13331658e-02f, 2.08680078e-01f, 1.07190469e-02f, -2.27776580e-02f,
  -2.39227891e-01f, 1.43460616e-01f, 1.46533191e-01f, 1.01746850e-01f, 2.30742797e-01f, 2.37597395e-02f, 1.54390439e-01f, 1.70359407e-02f, -2.80400813e-01f, -1.28482208e-01f,
  1.65626585e-01f, 2.18214720e-01f, 9.75900739e-02f, 5.29119633e-02f, 1.52603149e-01f, 1.18465453e-01f, 2.50529289e-01f, 2.39917021e-02f, -9.26865488e-02f, -1.24510713e-02f,
  9.88248140e-02f, 2.65247047e-01f, 4.19597067e-02f, 1.69316620e-01f, 1.92109108e-01f, 5.05588688e-02f, 1.00348547e-01f, 1.13040857e-01f, 2.03195244e-01f, 1.89227432e-01f,
  -4.03959639e-02f, -1.24068365e-01f, 1.10250242e-01f, -9.00483951e-02f, 2.30193943e-01f, -2.15259165e-01f, 6.84491619e-02f, 4.35534306e-02f, 1.78484350e-01f, 1.64476722e-01f,
  1.47568777e-01f, -2.19529435e-01f, 2.15896204e-01f, -9.99712050e-02f, 1.64962545e-01f, -6.38640719e-03f, 2.05453426e-01f, 2.03653768e-01f, 1.45617589e-01f, -1.27402872e-01f,
  1.92865446e-01f, 1.17747709e-01f, 2.39488661e-01f, 2.10707054e-01f, 3.79476815e-01f, 1.51314571e-01f, 2.67430067e-01f, 1.61256865e-01f, 1.29208371e-01f, -1.22225173e-01f,
  1.35111809e-01f, -1.84144378e-01f, -2.03319296e-01f, -8.96996781e-02f, 3.33422154e-01f, 4.06995043e-02f, -1.74950615e-01f, -1.84028879e-01f, 9.85217467e-02f, -1.64185435e-01f,
  -1.69906358e-04f, 2.04944894e-01f, -7.94126168e-02f, -1.75871357e-01f, 1.19745500e-01f, 1.56954363e-01f, -2.94920448e-02f, 1.06208503e-01f, -1.26712158e-01f, -3.51177603e-02f,
  -1.02554545e-01f, -6.09808154e-02f, 1.80513814e-01f, 2.30297610e-01f, 1.35246634e-01f, 5.48337959e-02f, -1.78052291e-01f, -6.52930439e-02f, 6.57496974e-02f, 5.17522618e-02f,
  1.46324802e-02f, 1.34763718e-01f, -3.75138968e-02f, 1.00833394e-01f, 3.47114414e-01f, -1.53825898e-02f, -1.16764277e-01f, -2.84327447e-01f, -4.33576368e-02f, -2.59078801e-01f,
  4.08746153e-02f, -1.81476548e-01f, -1.21809766e-01f, 2.34780461e-01f, -2.48923004e-01f, 2.09163036e-02f, 1.64422691e-01f, 3.57683927e-01f, 1.25297710e-01f, 8.15997124e-02f,
  -2.49724090e-03f, -1.28190532e-01f, 8.28518793e-02f, 2.56100327e-01f, 1.00306720e-01f, 2.77468581e-02f, -2.63782796e-02f, 1.75235525e-01f, -1.13938376e-01f, -9.35121551e-02f,
  -4.64609452e-02f, -1.07759133e-01f, 3.59763235e-01f, -1.60764933e-01f, -1.82988204e-03f, 1.29094049e-01f, 2.44934708e-01f, 3.78371626e-01f, 1.20078586e-01f, 8.04557800e-02f,
  7.92536810e-02f, 1.22337915e-01f, 2.92711318e-01f, -1.68052241e-02f, -4.01284099e-02f, 5.95887937e-03f, 2.45434046e-01f, 1.33777261e-01f, 1.19278980e-02f, 1.20171718e-01f,
  2.06799239e-01f, -1.53267056e-01f, -2.78380752e-01f, 2.67905891e-01f, -1.63567945e-01f, 1.15962550e-01f, 1.45922437e-01f, 4.16634530e-02f, 1.88337535e-01f, 5.71655408e-02f,
  2.95748115e-01f, 1.09085836e-01f, 1.57094866e-01f, -2.91251801e-02f, -7.53649622e-02f, 1.08707219e-01f, 1.35087417e-02f, -3.52585292e-03f, -4.09369171e-02f, -3.53172392e-01f,
  -7.55829588e-02f, 8.30493942e-02f, 1.66964307e-01f, -1.39724359e-01f, 2.18838245e-01f, 3.04254517e-02f, 2.23589718e-01f, 7.95385242e-03f, -8.38258490e-03f, -4.75237295e-02f,
  5.88853750e-03f, 9.22159776e-02f, 2.41435096e-01f, 1.78549856e-01f, 2.31816933e-01f, -2.74972141e-01f, 1.30250618e-01f, 1.25577226e-01f, 2.34783545e-01f, 3.10286619e-02f,
  -4.85087894e-02f, -5.53151444e-02f, -5.94206527e-02f, -5.20974509e-02f, -2.37881988e-02f, -1.95024863e-01f, 2.75408417e-01f, 1.81847766e-01f, -4.91130874e-02f, -9.54032764e-02f,
  -1.27899542e-01f, 1.96577102e-01f, -7.88019523e-02f, 3.42275575e-02f, 4.59118336e-02f, 8.30192640e-02f, 1.25877962e-01f, 1.64230820e-02f, -1.62322938e-01f, 5.10778725e-02f,
  2.93633398e-02f, 3.99166346e-02f, 1.30852565e-01f, 1.48966849e-01f, 2.51557291e-01f, 7.23550171e-02f, -1.95735961e-01f, -2.01931000e-01f, -2.58004759e-02f, 1.21961720e-01f,
  1.27027947e-02f, 2.85958022e-01f, 6.55039176e-02f, 3.91942449e-02f, 1.89905286e-01f, 1.96195856e-01f, 1.26308873e-01f, 7.67715648e-02f, 1.46539584e-01f, 1.45907298e-01f,
  7.63852447e-02f, 1.40755802e-01f, -5.83083220e-02f, -5.64855672e-02f, 2.23036826e-01f, 1.54332086e-01f, -1.05613098e-01f, -9.36693847e-02f, 6.93960562e-02f, 1.92750975e-01f,
  3.76002602e-02f, -3.00459517e-03f, 2.21317798e-01f, -1.91032097e-01f, 7.69289508e-02f, -9.80261341e-02f, 3.29410344e-01f, 5.06735519e-02f, 2.43801236e-01f, 7.84278363e-02f,
  1.99507579e-01f, -1.23029649e-01f, 1.70616865e-01f, 2.61060178e-01f, 1.89295724e-01f, 1.03471436e-01f, 1.30317494e-01f, 5.94700724e-02f, 2.76438184e-02f, 2.29074270e-01f,
  1.52954563e-01f, 1.52699247e-01f, 2.52994269e-01f, -1.09295458e-01f, 9.56933107e-03f, -1.03044108e-01f, 1.70818999e-01f, 4.45841104e-02f, -1.63262725e-01f, 7.42545053e-02f,
  -1.46065697e-01f, -1.48847833e-01f, -3.47446837e-02f, 1.44326299e-01f, 5.36253639e-02f, -2.07937434e-02f, 1.24379219e-02f, 1.46501362e-01f, 5.56782894e-02f, 3.22313249e-01f,
  1.95012271e-01f, -3.75232995e-02f, -7.61075541e-02f, -1.14937015e-01f, -8.54025111e-02f, -4.01980951e-02f, 1.94619410e-02f, 1.31076321e-01f, -1.22486368e-01f, 7.25784078e-02f,
  1.40195459e-01f, 5.77062964e-02f, 6.14412092e-02f, 1.16907723e-01f, -3.78537364e-02f, 3.05830576e-02f, -8.97318497e-02f, 2.91683674e-01f, 7.39043951e-02f, -7.25276023e-02f,
  -2.14230001e-01f, 2.32402444e-01f, -1.97556928e-01f, 2.61310399e-01f, 5.72140375e-03f, -1.78121731e-01f, 6.85825944e-02f, -7.82194138e-02f, -3.25061113e-01f, 2.36990407e-01f,
  2.32128337e-01f, -8.26806668e-03f, -1.16392240e-01f, 2.10646354e-02f, 2.34719634e-01f, -2.00105384e-01f, -8.24549049e-02f, 1.37324184e-01f, 1.76397134e-02f, -9.10455734e-02f,
  -1.24983832e-01f, -7.30417222e-02f, -9.94613320e-02f, 9.40585807e-02f, -2.81747729e-02f, 7.34979063e-02f, 9.56304371e-02f, -8.52129608e-03f, 2.56358147e-01f, 4.64533530e-02f,
  -1.81289911e-01f, 1.78566441e-01f, -6.91233575e-02f, 2.17888638e-01f, -1.72881648e-01f, -1.17247216e-01f, -5.78316413e-02f, 7.10266754e-02f, -1.75502092e-01f, 1.04371451e-01f,
  1.26459420e-01f, -9.57562681e-03f, 7.04131201e-02f, 3.46554518e-01f, 3.07329655e-01f, 2.40808859e-01f, 2.54947484e-01f, 3.13037410e-02f, -2.13070139e-01f, -7.41392896e-02f,
  -1.24837339e-01f, -1.22772217e-01f, -3.59205566e-02f, -1.02591708e-01f, 1.54853776e-01f, -5.81761065e-04f, 1.33432627e-01f, 3.19335088e-02f, -2.52628922e-02f, -4.25060317e-02f,
  3.09888422e-01f, 7.70871192e-02f, -4.12487797e-03f, -1.76133558e-01f, -2.34868173e-02f, -8.02732706e-02f, 1.67407289e-01f, 1.71322804e-02f, 3.25826555e-02f, 9.30651426e-02f,
  -2.22073153e-01f, 2.22098246e-01f, 2.43504167e-01f, 1.93058252e-01f, -8.90025720e-02f, -1.78788379e-02f, -7.72737265e-02f, -7.97481313e-02f, -7.25171855e-03f, 2.66764402e-01f,
  -1.01467520e-01f, -1.67039305e-01f, 6.70167282e-02f, -5.21633215e-02f, -4.43861000e-02f, -5.54561950e-02f, 1.56983316e-01f, 1.53369084e-01f, 9.22118649e-02f, -1.87216893e-01f,
  -6.33402821e-03f, 1.37376636e-01f, 7.68183395e-02f, 2.39220396e-01f, 1.00518681e-01f, 3.30695696e-02f, 1.61362767e-01f, 3.60249728e-01f, 1.77995548e-01f, 2.77182400e-01f,
  1.28265679e-01f, 2.92922240e-02f, 3.52470249e-01f, 2.98569351e-01f, 1.62138045e-01f, -3.77838127e-02f, 1.48751467e-01f, -1.61952704e-01f, -2.71365404e-01f, 3.37591022e-02f,
  8.94671232e-02f, 1.71417400e-01f, 1.49697244e-01f, 4.73326370e-02f, 6.29787520e-02f, 2.09015626e-02f, 2.93797612e-01f, 1.02006197e-02f, 3.61339375e-02f, 1.89271823e-01f,
  4.78031784e-02f, 1.85392842e-01f, 1.09240592e-01f, 6.58401325e-02f, -1.28095239e-01f, -6.36897460e-02f, -1.79978266e-01f, 1.10012069e-01f, -1.55871660e-01f, -4.23842445e-02f,
  1.99252460e-02f, 1.65981188e-01f, -1.17517985e-01f, -6.35808986e-03f, -2.26891916e-02f, 2.28469342e-01f, -1.63823247e-01f, 1.39801368e-01f, -2.35730752e-01f, -2.82919202e-02f,
  6.65425062e-02f, -6.22892268e-02f, 3.48022883e-03f, 2.04896525e-01f, 2.17421189e-01f, 2.82288790e-01f, 4.80000488e-02f, 4.31578793e-02f, -9.02441964e-02f, -9.91929248e-02f,
  -1.13394499e-01f, -2.82623678e-01f, 6.07077442e-02f, 3.79982531e-01f, -5.97907193e-02f, 1.36225984e-01f, 5.76156154e-02f, 1.60384953e-01f, -2.17050314e-01f, 1.97626859e-01f,
  2.99708009e-01f, 1.05645142e-01f, 3.02569509e-01f, 3.47510874e-01f, 2.94360727e-01f, 8.27427208e-03f, 8.53389502e-03f, 2.52134800e-01f, 1.73678473e-01f, 2.13339522e-01f,
  1.23654924e-01f, -2.06865761e-02f, 2.69349754e-01f, 3.63065898e-01f, 2.19450057e-01f, 1.02227896e-01f, 1.49587259e-01f, 1.77795589e-02f, 1.84963159e-02f, 3.53121191e-01f,
  3.25679451e-01f, 1.77491054e-01f, 3.20268646e-02f, 1.00860782e-01f, 8.58105496e-02f, 8.74529853e-02f, 1.02901027e-01f, 9.13299471e-02f, -2.12271288e-01f, -2.55986959e-01f,
  -1.12202533e-01f, 1.81385741e-01f, 1.32560521e-01f, -4.53249514e-02f, 1.71486780e-01f, 6.91719726e-02f, 1.87781572e-01f, 6.30310131e-03f, 8.76299664e-02f, 1.32693246e-01f,
  -1.19033635e-01f, -2.44180486e-02f, -1.55588880e-01f, 2.57525742e-01f, 2.18570739e-01f, 1.66196171e-02f, 6.03714064e-02f, -1.90286011e-01f, 2.88262129e-01f, 9.81468149e-03f,
  -3.48070893e-03f, 3.38918753e-02f, -1.20372519e-01f, 7.60220513e-02f, 1.39191315e-01f, -2.69288123e-01f, -5.99544458e-02f, 2.94407368e-01f, -1.11236058e-01f, 1.65472612e-01f,
  -5.14470786e-03f, -1.24344258e-02f, -7.18896911e-02f, 1.50388867e-01f, 9.15799290e-02f, -1.44672170e-01f, 2.50372767e-01f, 1.83581337e-01f, 2.44062021e-01f, 8.55094120e-02f,
  -3.94471213e-02f, -2.65025906e-02f, -4.25361022e-02f, -6.44703433e-02f, 1.55145288e-01f, 8.63802060e-02f, 2.31575400e-01f, 9.48495325e-03f, 8.94873515e-02f, -1.59387232e-03f,
  1.18084282e-01f, 2.06730962e-01f, 1.65542811e-01f, 7.42310807e-02f, 1.12001091e-01f, 1.34574905e-01f, 1.10524066e-01f, 8.29767510e-02f, 7.79011101e-02f, 1.74969584e-01f,
  2.63510883e-01f, 1.15566015e-01f, -2.48200059e-01f, 1.59034543e-02f, 3.18318754e-02f, -1.52594462e-01f, 3.34407203e-02f, 2.45597020e-01f, -4.50837202e-02f, 1.99139025e-02f,
  -4.10598218e-02f, 1.76309764e-01f, 9.04089189e-04f, 1.81931362e-01f, 1.45269707e-01f, -2.48271096e-02f, -1.64695293e-01f, -7.69305881e-03f, -1.29578188e-01f, 3.20708781e-01f,
  -8.29929039e-02f, -1.95711255e-01f, 1.22029610e-01f, -6.69614971e-02f, 1.65635690e-01f, 2.59551406e-01f, 2.16003522e-01f, 2.98219979e-01f, 1.11735158e-01f, 2.62986481e-01f,
  -2.24991068e-02f, 7.77877569e-02f, 2.71467328e-01f, -1.57759309e-01f, 1.68983206e-01f, -1.21340282e-01f, 3.16036433e-01f, -3.17982361e-02f, -1.29782483e-01f, -5.43567128e-02f,
  -8.74268189e-02f, 6.79185092e-02f, 2.85884785e-03f, 9.33400169e-02f, -6.56082928e-02f, 9.60444275e-04f, -1.33827925e-01f, -6.08950704e-02f, -9.95614901e-02f, -8.46140012e-02f,
  3.55204828e-02f, 2.08289757e-01f, 1.48295686e-01f, -1.18838914e-01f, 2.85819918e-01f, -1.95599362e-01f, -1.56731904e-01f, -6.96447194e-02f, 4.29170346e-03f, -6.49934113e-02f,
  1.20001741e-01f, 5.07480502e-02f, 7.79057443e-02f, 1.06224984e-01f, -1.73766743e-02f, 1.28112435e-02f, 1.02902636e-01f, 1.84588253e-01f, -1.89324364e-01f, -1.97207138e-01f,
  -1.77385360e-01f, -2.82003284e-02f, 3.45516950e-02f, 2.33152092e-01f, -2.37928480e-01f, -6.28012195e-02f, -1.10570304e-01f, 9.21272784e-02f, 6.16753288e-02f, 1.63158432e-01f,
  1.29596338e-01f, -1.72010794e-01f, -6.64427727e-02f, 1.74819544e-01f, 1.37792647e-01f, -1.99170541e-02f, 2.27665633e-01f, 2.33345255e-01f, -6.78087249e-02f, -6.39916882e-02f,
  -1.25065416e-01f, 2.30473373e-02f, -1.33181915e-01f, -5.52272573e-02f, 1.41384006e-01f, 2.56931365e-01f, 2.01164726e-02f, -1.19504951e-01f, 3.10682952e-01f, -1.86003430e-03f,
  4.84906649e-03f, -5.14655840e-03f, 3.16436291e-02f, 8.17939118e-02f, -1.28628969e-01f, 7.88004845e-02f, 1.90086588e-01f, -1.31902575e-01f, 4.09779772e-02f, -2.78535020e-02f,
  1.91002619e-02f, -7.46970996e-02f, -8.19071680e-02f, 2.14055926e-01f, 2.48829603e-01f, 3.87677163e-01f, 1.85156152e-01f, -5.16651645e-02f, 2.36269370e-01f, -1.10695995e-01f,
  1.38039246e-01f, -1.03261080e-02f, 1.88806951e-02f, 1.73553303e-01f, 9.74388197e-02f, 1.91161513e-01f, 1.64307263e-02f, 1.62359327e-01f, 2.08851859e-01f, 7.09465565e-03f,
  1.06086932e-01f, 7.67244175e-02f, 1.05580986e-01f, -6.37976173e-03f, -7.66683817e-02f, 1.57830149e-01f, -4.14070711e-02f, 2.45111197e-01f, 2.99697071e-02f, -1.54645324e-01f,
  2.22472161e-01f, 2.21355006e-01f, -7.02179968e-02f, -3.67372148e-02f, 8.71120840e-02f, -1.52385816e-01f, -8.47111717e-02f, 2.08493054e-01f, 2.11470008e-01f, 2.10203528e-01f,
  -1.20737158e-01f, 9.55942646e-03f, 1.52778372e-01f, -2.14797705e-01f, 1.63059533e-01f, -9.59742069e-02f, 2.07657084e-01f, 1.63127348e-01f, -2.72440493e-01f, -2.75179911e-02f,
  2.58070827e-01f, 1.51286036e-01f, -5.68015873e-02f, -4.96696234e-02f, -1.84504747e-01f, 1.77575916e-01f, 8.03660974e-02f, 1.35488287e-01f, -1.96700394e-01f, 1.82411075e-01f,
  1.94488570e-01f, -1.48336664e-01f, -1.27565652e-01f, 1.89513326e-01f, 1.42225713e-01f, 1.01580478e-01f, -2.04357058e-01f, -9.81806144e-02f, 1.28648147e-01f, -2.84889098e-02f,
  2.85054237e-01f, 9.35189724e-02f, 1.90563485e-01f, -8.69019106e-02f, 1.35892734e-01f, 8.60885158e-02f, 1.45777091e-01f, 1.10676261e-02f, 4.66843583e-02f, 1.77048042e-01f,
  7.35004917e-02f, 3.73529387e-03f, -8.80383551e-02f, 7.68964812e-02f, -2.43623912e-01f, 2.91154891e-01f, -4.79347333e-02f, 1.45810265e-02f, 4.99240384e-02f, 7.48542622e-02f,
  1.56829819e-01f, 5.87187819e-02f, 4.74959351e-02f, 2.80920237e-01f, 2.22493395e-01f, 1.40621308e-02f, 8.65605101e-02f, 1.99036866e-01f, 1.17016360e-02f, 1.33161724e-01f,
  -1.49107575e-01f, 7.23732188e-02f, 5.13325743e-02f, -1.09032892e-01f, 5.67955337e-02f, -5.25721610e-02f, -1.68223549e-02f, 1.27725691e-01f, -1.04986809e-01f, 4.39252108e-01f,
  8.23198780e-02f, 7.77137876e-02f, 3.03405691e-02f, 1.99431315e-01f, 1.27305835e-01f, -9.64272991e-02f, 2.20982432e-01f, -7.84011260e-02f, 1.98099185e-02f, 1.27042606e-01f,
  1.27802536e-01f, 5.11684343e-02f, 4.85431924e-02f, 7.92278871e-02f, -1.83308162e-02f, 2.02487707e-01f, -1.22549824e-01f, 5.50787933e-02f, -2.07975879e-01f, 1.69787481e-02f,
  7.73301860e-03f, 2.97252953e-01f, 3.82639259e-01f, 1.17383897e-01f, 1.52439684e-01f, 1.55832887e-01f, 2.49090105e-01f, 3.08596287e-02f, -2.43335553e-02f, 9.71828103e-02f,
  -2.66436045e-03f, 1.77793667e-01f, 1.04876019e-01f, 2.52733886e-01f, 1.21696927e-01f, 5.42301126e-02f, 3.27921472e-02f, 2.03517452e-01f, -3.22930276e-01f, 1.75193086e-01f,
  -2.54441977e-01f, 3.01814359e-03f, 1.03051275e-01f, 8.49779174e-02f, 6.12748116e-02f, 2.48177610e-02f, 1.74411848e-01f, 2.50766873e-01f, 2.09150001e-01f, 2.32040733e-01f,
  2.72492543e-02f, 1.19569004e-01f, -8.92150849e-02f, 1.18588172e-01f, -7.05648437e-02f, 2.35298634e-01f, -8.44783634e-02f, -1.62263870e-01f, 9.28076133e-02f, -8.79273042e-02f,
  -2.79541016e-02f, 1.16273150e-01f, -8.22155774e-02f, 2.74809092e-01f, -6.06009811e-02f, -5.44293635e-02f, -1.62701204e-01f, 2.03663185e-01f, 5.06107286e-02f, 1.87687218e-01f,
  1.64465129e-01f, -1.15149014e-01f, 4.40163985e-02f, 5.11085019e-02f, 2.41166711e-01f, -8.36829096e-03f, 2.79282361e-01f, 1.06054433e-01f, 1.66228026e-01f, 7.48087764e-02f,
  -1.35089144e-01f, -3.81275602e-02f, -2.92968377e-02f, 1.80546846e-02f, 7.28308633e-02f, 6.95172371e-03f, 1.47226587e-01f, 2.85432756e-01f, 1.88986614e-01f, -5.67777175e-03f,
  5.49574196e-02f, 1.31547123e-01f, 8.78309947e-04f, 1.30327046e-01f, 1.20518662e-01f, 2.54837781e-01f, 1.76033750e-01f, 7.99439102e-02f, -3.78395915e-02f, 2.15723246e-01f,
  1.07683707e-02f, -1.95189286e-02f, 8.42636004e-02f, 1.00690825e-02f, 1.45199969e-01f, 5.30672632e-02f, 1.42328115e-02f, -4.04468961e-02f, -1.00805191e-02f, 2.67644644e-01f,
  2.73271412e-01f, -4.73800898e-02f, 2.34618291e-01f, 1.73432808e-02f, 2.96350140e-02f, 2.25511659e-02f, 1.40471891e-01f, 5.71918376e-02f, 2.19298769e-02f, 1.45458579e-01f,
  1.73954830e-01f, -2.58601636e-01f, 4.10572588e-02f, 3.71858082e-03f, -9.51720551e-02f, -5.41452207e-02f, 1.77002743e-01f, 3.99049930e-02f, 7.95980915e-02f, 1.76734716e-01f,
  7.77632743e-02f, 8.08566660e-02f, -1.00204855e-01f, -1.17112480e-01f, 1.41879752e-01f, -2.30027676e-01f, 1.05974518e-01f, 3.54733132e-02f, 1.83208495e-01f, -6.34708107e-02f,
  -5.78729808e-03f, -1.11332819e-01f, -2.45221123e-01f, 1.68239012e-01f, -3.29916365e-02f, 2.23540887e-02f, 4.23527099e-02f, 4.88855280e-02f, 1.40217900e-01f, 2.00523317e-01f,
  2.22518697e-01f, -1.05653368e-01f, 4.43350784e-02f, 1.47977114e-01f, 9.19559076e-02f, -1.69428438e-02f, 1.14393868e-01f, -1.29726261e-03f, -1.16749480e-01f, 4.57753278e-02f,
  1.17088176e-01f, 9.46765170e-02f, 2.72665441e-01f, 3.29658650e-02f, 8.27178210e-02f, 2.09888622e-01f, -1.00583136e-01f, 3.06694023e-02f, 2.09529981e-01f, 1.90183267e-01f,
  -3.23312581e-01f, 1.51961088e-01f, -3.99471819e-02f, 2.68657804e-01f, -8.56121555e-02f, 5.78233004e-02f, 9.54781845e-02f, -2.26359675e-03f, 8.04830417e-02f, -5.94036505e-02f,
  3.68575752e-02f, 6.38716146e-02f, -1.33372620e-02f, 1.92509294e-01f, 2.11315081e-01f, -4.96333838e-02f, -6.54922053e-02f, 1.76843703e-01f, 1.51498005e-01f, -8.28766152e-02f,
  9.47001353e-02f, 6.08257093e-02f, 2.47027874e-01f, 1.29239962e-01f, -1.73128620e-01f, 1.34947881e-01f, 1.50475055e-01f, 3.79211493e-02f, 2.22082436e-01f, 3.68463248e-02f,
  -5.30960523e-02f, 1.86937228e-01f, 5.64398654e-02f, 1.47560254e-01f, -1.06368435e-03f, -1.26057640e-01f, 1.07180104e-01f, 9.65437889e-02f, -4.61514257e-02f, 7.19804764e-02f,
  9.58819687e-02f, 2.15470061e-01f, -1.95373520e-01f, 2.76088566e-01f, 3.25831950e-01f, 1.17800616e-01f, 2.80873179e-01f, -1.02802806e-01f, -9.25536752e-02f, -1.30909830e-01f,
  7.01948702e-02f, 3.53239523e-03f, 5.64331338e-02f, -5.31162992e-02f, 1.44931570e-01f, 3.29836197e-02f, 1.83795124e-01f, 1.62572667e-01f, 1.98453560e-01f, 7.66654238e-02f,
  1.24291055e-01f, 1.40945047e-01f, 1.43087178e-01f, -1.91381276e-01f, -1.41566753e-01f, -1.08194709e-01f, -1.29042804e-01f, 4.77661677e-02f, -9.13127661e-02f, -3.48096378e-02f,
  -8.31121951e-02f, -8.07752833e-02f, 3.35200839e-02f, 1.12330824e-01f, 2.86683324e-04f, -9.19144899e-02f, -8.65790397e-02f, -1.66248507e-03f, 8.45864136e-03f, 2.90454626e-01f,
  -1.61166802e-01f, 6.46881685e-02f, 2.74442434e-01f, -7.81478360e-02f, 3.13057415e-02f, -1.27815783e-01f, 1.11908086e-01f, 2.54478991e-01f, 2.18560055e-01f, -1.17104225e-01f,
  7.01798499e-02f, 1.47369951e-01f, 1.69266105e-01f, 3.37642461e-01f, -1.99191585e-01f, 3.89203951e-02f, -2.07776036e-02f, 2.02871948e-01f, -8.91876891e-02f, 4.43364121e-02f,
  9.48562026e-02f, 8.37710407e-03f, 2.76803732e-01f, 2.90236801e-01f, 1.92983374e-01f, 1.53655246e-01f, 6.60192296e-02f, -9.93983471e-04f, -5.53138070e-02f, 2.10684091e-02f,
  -1.02060787e-01f, 1.36724189e-01f, 1.12227142e-01f, -1.51858076e-01f, -8.74702558e-02f, 9.77382436e-03f, 1.30786613e-01f, 9.13820136e-03f, 2.51325667e-01f, -1.28846049e-01f,
  3.34760994e-02f, 2.72617996e-01f, 7.77585357e-02f, 1.49116619e-02f, -2.69565210e-02f, -2.74918616e-01f, 5.77320196e-02f, 2.13636979e-01f, 9.58243906e-02f, -2.41971314e-01f,
  2.14243323e-01f, 7.76215568e-02f, 2.47901380e-01f, -3.78445834e-02f, 5.85327186e-02f, -2.02621743e-01f, -1.44552514e-01f, -1.48652524e-01f, 2.38289937e-01f, 1.54167295e-01f,
  2.18146369e-01f, -2.15830997e-01f, 2.43866444e-01f, -8.33173320e-02f, 2.87623078e-01f, 2.05455586e-01f, -1.20143168e-01f, 1.20609112e-01f, 1.40267745e-01f, -7.40718693e-02f,
  8.39062110e-02f, 1.85396930e-03f, 2.18515873e-01f, 1.92381263e-01f, -2.70117391e-02f, 9.08519030e-02f, -7.91426674e-02f, -1.57756135e-01f, 1.77093074e-02f, 7.39046261e-02f,
  -4.73505072e-03f, -8.65519345e-02f, -4.96200891e-03f, -3.82980593e-02f, 3.76123078e-02f, 1.37920737e-01f, -9.46034342e-02f, -3.44570242e-02f, 6.94019794e-02f, 1.28286734e-01f,
  1.59280017e-01f, 1.31404236e-01f, -1.82309782e-03f, -9.12204236e-02f, -1.54502809e-01f, 1.85005039e-01f, -1.37589008e-01f, 2.08886757e-01f, 2.33789593e-01f, 2.03642115e-01f,
  -1.66809753e-01f, 7.08987936e-02f, 3.28349322e-02f, 3.11732888e-01f, 2.64821857e-01f, 1.13491401e-01f, 2.89193869e-01f, 9.38367173e-02f, -9.43472311e-02f, -6.96328981e-03f,
  -6.97783455e-02f, -2.40378305e-01f, -9.00255740e-02f, 7.87000507e-02f, 1.12606615e-01f, 5.68490066e-02f, -3.53312530e-02f, 1.27959959e-02f, -3.28755267e-02f, 2.95627415e-01f,
  1.63991913e-01f, 3.31026793e-01f, -1.48324251e-01f, 1.29475877e-01f, 1.65165633e-01f, 2.98248857e-01f, -2.66380631e-03f, 1.42708227e-01f, 2.64302880e-01f, -1.28551170e-01f,
  8.58324114e-03f, 1.73223466e-01f, -4.77590151e-02f, 1.51245847e-01f, 1.24397874e-01f, 9.82534662e-02f, -4.13445681e-02f, 3.13760757e-01f, 1.80485383e-01f, 9.32975113e-02f,
  9.10666212e-02f, -7.31269717e-02f, 1.29377201e-01f, -1.40652895e-01f, 6.54883757e-02f, 1.51159495e-01f, 1.52296200e-01f, 2.69004673e-01f, 1.38363197e-01f, -1.43813372e-01f,
  2.26307940e-02f, 2.07466394e-01f, 8.82537067e-02f, 1.03705106e-02f, -3.77823152e-02f, -1.81724742e-01f, 1.09078541e-01f, 2.81692892e-01f, 2.44555280e-01f, -1.61259770e-01f,
  2.31283948e-01f, 1.16407797e-02f, -5.24671897e-02f, 1.24959052e-01f, 2.25470737e-01f, 3.30619700e-02f, 2.34337911e-01f, 1.55502642e-02f, -5.97268604e-02f, 1.95751209e-02f,
  6.28755316e-02f, 9.66143906e-02f, -1.56077981e-01f, 1.85219705e-01f, -1.24852173e-01f, 2.32058734e-01f, -7.49000954e-03f, 1.75639987e-01f, -7.93996230e-02f, 1.01011582e-01f,
  5.83572611e-02f, 1.83113635e-01f, 1.44293960e-02f, 1.41294166e-01f, -1.09069617e-02f, 2.27678597e-01f, -1.70036107e-01f, 1.87633827e-01f, 7.93540312e-05f, -1.65909100e-02f,
  -4.23939861e-02f, -1.23691320e-01f, 7.01865181e-02f, 1.44844294e-01f, 2.47322708e-01f, -8.01864564e-02f, 7.05559254e-02f, 1.74289882e-01f, 2.20484287e-01f, -2.12932199e-01f,
  4.61203093e-03f, 2.07042098e-01f, 2.21061781e-01f, 1.83578953e-01f, 6.92011639e-02f, 7.15685785e-02f, 1.28842026e-01f, 2.23112240e-01f, 3.20179015e-02f, -7.80275092e-02f,
  1.61484063e-01f, 1.52802914e-01f, 1.74347535e-01f, 2.35879600e-01f, -3.53504047e-02f, -1.91164225e-01f, -4.00023311e-02f, 1.41821891e-01f, 1.24825433e-01f, 1.54059291e-01f,
  1.29119456e-01f, 3.39485943e-01f, 3.86944741e-01f, 1.09066054e-01f, 6.68507144e-02f, 6.55507073e-02f, -3.65510732e-02f, 2.11765602e-01f, -3.75251584e-02f, 1.88138738e-01f,
  5.86424163e-03f, 1.81530446e-01f, 1.22881398e-01f, 6.11642078e-02f, 8.44948664e-02f, 1.72959194e-01f, 1.90027311e-01f, 1.67368889e-01f, 1.73574284e-01f, -4.11916822e-02f,
  -2.42006853e-01f, 1.56606883e-01f, -1.11053243e-01f, 4.36301418e-02f, -1.26383379e-02f, 3.23697254e-02f, 9.58494749e-03f, 2.60150164e-01f, -9.48403552e-02f, -8.23583733e-03f,
  1.09226992e-02f, -7.14741498e-02f, -8.76629278e-02f, 2.45068595e-01f, -3.52807455e-02f, 1.31867811e-01f, -2.54543126e-01f, -4.01706360e-02f, 2.51364857e-01f, -1.18138276e-01f,
  1.90103263e-01f, -2.03873634e-01f, 2.29523063e-01f, 1.23981737e-01f, -2.63765901e-01f, -5.88753968e-02f, 1.84362382e-01f, 2.39054486e-01f, 1.44687146e-01f, -5.88028505e-02f,
  -9.11459774e-02f, 9.32837948e-02f, 3.07042003e-02f, 6.75546527e-02f, -5.99025227e-02f, 2.03432500e-01f, 2.78241038e-01f, 5.63762747e-02f, -1.51805520e-01f, 2.72445321e-01f,
  1.14449941e-01f, 1.79273397e-01f, -1.64599195e-01f, -1.89758483e-02f, 1.76275522e-01f, 9.23468098e-02f, 1.74283147e-01f, 9.73653644e-02f, -2.49996353e-02f, -1.36888206e-01f,
  1.53005183e-01f, 8.31724107e-02f, -9.27914158e-02f, 7.08744526e-02f, 6.65307343e-02f, 1.43322751e-01f, 1.48139387e-01f, 2.35061616e-01f, 8.31521377e-02f, 4.82599512e-02f,
  2.07432453e-02f, -2.19358474e-01f, -1.36919171e-01f, 6.49196282e-02f, 1.05608478e-01f, -2.10281014e-01f, 2.46318057e-01f, 1.00142866e-01f, 1.52314767e-01f, 3.68823744e-02f,
  1.20113067e-01f, 9.65537038e-04f, 2.85859495e-01f, 1.51422158e-01f, 6.40948936e-02f, 2.44252548e-01f, 2.74153471e-01f, -1.64224997e-01f, 3.60581204e-02f, -1.59377865e-02f,
  3.12746555e-01f, 3.15778442e-02f, -1.11086391e-01f, 1.29137546e-01f, 1.49785802e-01f, 7.09082335e-02f, 4.34658192e-02f, -5.99738304e-03f, 2.04739407e-01f, 1.85537383e-01f,
  -1.38886631e-01f, 1.68391783e-02f, -8.19518492e-02f, -2.10542027e-02f, 3.21324348e-01f, 1.26267672e-01f, 1.22625669e-02f, -4.96721528e-02f, 1.50258899e-01f, 1.37463465e-01f,
  1.03436299e-02f, 1.14870422e-01f, 1.87346101e-01f, -1.13756217e-01f, -4.92234528e-03f, -1.21371865e-01f, 2.99434364e-01f, 1.22936182e-01f, -1.45420179e-01f, -2.51075793e-02f,
  -6.15147538e-02f, 8.37992504e-02f, 9.83400494e-02f, 2.88884252e-01f, 2.47785836e-01f, 1.32231624e-03f, 1.08025610e-01f, 1.33331761e-01f, 1.42898098e-01f, 1.21300407e-01f,
  8.65891352e-02f, 1.79943889e-02f, 1.20657958e-01f, 5.63522354e-02f, -2.95857668e-01f, 8.55479538e-02f, -1.52214319e-01f, 1.92486495e-01f, -1.22838415e-01f, -6.96963072e-02f,
  -4.90306020e-02f, 1.00319639e-01f, 9.25097838e-02f, 1.33932978e-01f, 1.92809731e-01f, -2.45414212e-01f, 2.40554154e-01f, 1.91512495e-01f, -2.43014380e-01f, 8.34584087e-02f,
  -5.64798946e-03f, -1.25654861e-01f, 1.20802969e-02f, -1.50351748e-01f, 4.67352681e-02f, -3.53721268e-02f, -6.13722280e-02f, 6.49565458e-02f, -2.20415607e-01f, 4.09895658e-01f,
  8.86133388e-02f, 8.49872753e-02f, 7.55818784e-02f, 3.18760276e-01f, 1.15200087e-01f, -9.59008634e-02f, 3.75521272e-01f, -2.16923561e-02f, 3.50828953e-02f, -1.36235714e-01f,
  4.74236012e-02f, -2.27438170e-03f, 4.27080877e-03f, 2.18500681e-02f, -1.31053612e-01f, 2.88929015e-01f, -6.93340600e-02f, 7.40956590e-02f, -7.82992691e-02f, -1.86369345e-01f,
  2.13179663e-01f, 2.85499096e-01f, 9.30458903e-02f, 2.65474528e-01f, -1.53753445e-01f, 1.35738654e-02f, 1.61833689e-02f, 8.93803909e-02f, 1.05769774e-02f, -4.68450561e-02f,
  4.56413329e-02f, 3.45724449e-02f, 4.89606038e-02f, 5.93965836e-02f, 1.25718638e-01f, -8.38837549e-02f, 1.21666394e-01f, 6.04855595e-03f, -6.22590706e-02f, -1.44444078e-01f,
  1.31035656e-01f, 1.75502434e-01f, -1.67456493e-01f, -1.19292364e-01f, 1.10786557e-01f, -2.29953825e-02f, 9.21045914e-02f, -1.14362150e-01f, 1.01737067e-01f, -1.29638851e-01f,
  7.75160268e-02f, -4.06159647e-02f, -3.60499769e-02f, -9.88631696e-03f, 1.80770576e-01f, -1.89476028e-01f, 4.32437323e-02f, 4.91515398e-02f, 9.15259644e-02f, 2.46915787e-01f,
  1.15126092e-02f, 1.42721850e-02f, -3.07685579e-03f, -2.15530351e-01f, 8.84485990e-02f, -2.51224250e-01f, 9.59989280e-02f, 1.15796447e-01f, 1.47897035e-01f, 1.21472441e-01f,
  -1.02790773e-01f, 2.69662976e-01f, 6.36527166e-02f, 2.26082608e-01f, -6.40364587e-02f, 3.09232138e-02f, 3.92853767e-01f, 8.34806859e-02f, 2.31340945e-01f, -1.15706623e-01f,
  2.65973955e-01f, -9.27889273e-02f, 1.71544135e-01f, 2.87693620e-01f, 1.35303900e-01f, -7.69212423e-03f, -2.70930886e-01f, 2.87083555e-02f, 6.89427555e-03f, -1.67130604e-02f,
  -1.62434205e-01f, 7.81160295e-02f, 8.93506855e-02f, 3.30758601e-01f, 2.17822418e-02f, 3.90394963e-02f, 5.82871325e-02f, 4.65878844e-02f, 8.02055821e-02f, 8.50267112e-02f,
  1.97623968e-01f, 2.02779219e-01f, 1.68719292e-02f, -3.77928525e-01f, 2.22555771e-01f, 1.13703705e-01f, 1.63316846e-01f, -3.20660323e-01f, 9.12931338e-02f, -5.24180233e-02f,
  1.45445481e-01f, 2.68392581e-02f, 2.34871581e-01f, -1.95072606e-01f, 2.37976879e-01f, -2.00058460e-01f, 2.20926970e-01f, -6.18795007e-02f, 3.11408937e-01f, -1.13381639e-01f,
  1.53410181e-01f, -1.26910880e-01f, 3.22060496e-01f, 1.51478797e-01f, -1.88835934e-02f, 2.71130592e-01f, 6.09378815e-02f, 1.58475429e-01f, 9.95358899e-02f, 1.66674688e-01f,
  1.05993666e-01f, -2.71952562e-02f, 1.05854146e-01f, -1.34120822e-01f, -1.12802804e-01f, -9.58499163e-02f, 2.25774035e-01f, 1.49603203e-01f, -1.01643629e-01f, -1.19869731e-01f,
  7.18449727e-02f, -1.39233485e-01f, 6.95088804e-02f, 5.67047074e-02f, 1.03006504e-01f, -1.45725474e-01f, 1.87187597e-01f, 7.23117515e-02f, -7.56589323e-02f, 1.15309693e-01f,
  -2.22380146e-01f, -3.92154567e-02f, -4.86828685e-02f, -1.65575579e-01f, 1.50288139e-02f, 1.50249809e-01f, 1.63308024e-01f, 5.84598556e-02f, -8.53731036e-02f, -7.64424577e-02f,
  -1.65145844e-02f, 3.06584656e-01f, 1.81771457e-01f, -9.72935371e-03f, 2.20917836e-01f, -3.56498029e-04f, 1.26216516e-01f, 9.67024714e-02f, 7.93965533e-02f, -2.50762045e-01f,
  -2.18029339e-02f, 8.70046988e-02f, 7.83160329e-03f, -6.36299625e-02f, -1.44740671e-01f, 1.14772283e-01f, -5.80116510e-02f, 2.13382527e-01f, 8.25001523e-02f, 2.90689766e-01f,
  -5.30152917e-02f, -1.07012138e-01f, 2.98486911e-02f, 1.86188951e-01f, -5.67981675e-02f, 1.49737790e-01f, 9.98856053e-02f, -2.43369900e-02f, 2.74540246e-01f, 1.10676929e-01f,
  4.72018160e-02f, 2.23944243e-02f, -6.67885691e-02f, 1.61702007e-01f, 2.18933046e-01f, 5.29856645e-02f, 2.40223899e-01f, 5.77048399e-02f, 1.20285004e-01f, 2.76464783e-02f,
  1.03407942e-01f, 6.94533587e-02f, 9.79735516e-04f, 5.52397408e-02f, 3.13129053e-02f, -2.79099364e-02f, 1.48054436e-01f, -1.33691877e-01f, 2.43355110e-01f, 1.04138479e-01f,
  1.52957859e-02f, 1.85646608e-01f, -8.98558199e-02f, 2.11119726e-02f, 3.10631335e-01f, 3.45320195e-01f, 1.49647787e-01f, -1.72237188e-01f, 1.73311904e-01f, 1.21317253e-01f,
  1.67856570e-02f, -9.39381719e-02f, 1.14047989e-01f, -3.05137597e-02f, 1.77468255e-01f, 1.75085545e-01f, 2.26100340e-01f, 6.85308874e-02f, 3.41713205e-02f, 2.11416204e-02f,
  -2.56238014e-01f, 3.11662793e-01f, 3.51223573e-02f, 2.73701958e-02f, -1.41598716e-01f, 2.70249486e-01f, 9.87330675e-02f, 1.47008508e-01f, -7.45420307e-02f, 1.33190900e-01f,
  1.05906986e-01f, 2.75652587e-01f, 1.05338186e-01f, 1.67622507e-01f, -1.21487677e-01f, 4.31728847e-02f, -1.41676024e-01f, 2.31479153e-01f, -2.76498534e-02f, -2.05431506e-01f,
  1.01024702e-01f, 5.66882044e-02f, -8.00464228e-02f, 2.20435083e-01f, -1.10445425e-01f, 2.45798647e-01f, -1.06288888e-01f, 1.51563540e-01f, -4.11737971e-02f, 3.01016092e-01f,
  1.45184267e-02f, -1.36424705e-01f, 3.65348250e-01f, -1.29567310e-01f, 5.82933798e-02f, 8.07425231e-02f, 1.48814216e-01f, -6.01952635e-02f, -1.24466270e-02f, 5.65978698e-02f,
  1.73798770e-01f, 3.33507992e-02f, -2.14067474e-01f, 6.68884516e-02f, -1.98448807e-01f, -6.31123930e-02f, 7.21537769e-02f, 1.78171858e-01f, 3.25334787e-01f, 2.52679139e-01f,
  2.63455808e-01f, -6.30845595e-03f, 1.57959744e-01f, 1.11300357e-01f, 3.72274332e-02f, -1.39878094e-01f, -4.84311283e-02f, 3.82044837e-02f, -6.21556211e-03f, 7.93015510e-02f,
  2.07183644e-01f, 2.19516084e-01f, 1.14543356e-01f, 2.03189358e-01f, -3.03439438e-01f, 2.93116838e-01f, 1.07399791e-01f, 4.22721878e-02f, -1.23796850e-01f, 2.05992684e-01f,
  -3.01305414e-03f, 2.75274277e-01f, 4.69589271e-02f, 8.13350305e-02f, 2.38259912e-01f, 2.87676811e-01f, 1.12101575e-03f, 8.84459615e-02f, -2.07539052e-01f, 2.97577262e-01f,
  -5.60167432e-02f, 1.35518849e-01f, -2.12411415e-02f, 1.54012427e-01f, 1.29811764e-01f, 7.40125403e-02f, 1.74067885e-01f, -4.24418598e-02f, -2.44348291e-02f, 2.10252300e-01f,
  2.06713378e-01f, 8.73733163e-02f, -2.34387413e-01f, 2.03564107e-01f, 7.83241838e-02f, 3.02677333e-01f, 1.39525786e-01f, 4.97878119e-02f, -3.97247784e-02f, 5.92651330e-02f,
  2.47892305e-01f, 4.44684252e-02f, 1.01477690e-01f, 2.20203534e-01f, 1.24840781e-01f, 1.64976910e-01f, -2.17027143e-01f, 6.28279448e-02f, 3.34412861e-03f, 4.94526885e-02f,
  1.58446327e-01f, 6.39568130e-03f, 2.24606693e-01f, 1.93968415e-01f, 1.43607810e-01f, 2.14051068e-01f, 1.55434534e-01f, 9.28424373e-02f, 1.40574783e-01f, 9.34772715e-02f,
  6.63771061e-04f, 7.97032863e-02f, 1.55905038e-01f, 1.55464292e-01f, 2.59276032e-01f, 2.43133321e-01f, 6.40989095e-02f, 8.81835818e-02f, 2.15917617e-01f, -3.15984398e-01f,
  9.96550918e-02f, 3.68430354e-02f, -1.63889840e-01f, -3.13784897e-01f, -5.14486991e-02f, -2.30431259e-02f, 6.79041669e-02f, -1.57188296e-01f, -3.25736292e-02f, -1.20146990e-01f,
  3.52439284e-02f, -4.52927127e-02f, 1.50304824e-01f, -1.45093538e-02f, 3.09454203e-01f, -2.11684003e-01f, 2.61954725e-01f, 2.74218202e-01f, 1.16056472e-01f, 2.94522464e-01f,
  5.83947897e-02f, 8.50709081e-02f, 1.87094789e-02f, -1.62570462e-01f, 1.00466073e-01f, -1.01175927e-01f, 1.73515365e-01f, 2.43352056e-01f, 2.91008186e-02f, -3.00517436e-02f,
  1.38816401e-01f, 9.21513289e-02f, -2.95023452e-02f, 1.90171361e-01f, -1.01878636e-01f, 2.20673606e-01f, 2.07193531e-02f, 5.68793230e-02f, -4.53928113e-02f, -9.50723365e-02f,
  2.79764712e-01f, 1.26922578e-01f, 1.98699415e-01f, 1.40733123e-01f, -2.24844553e-02f, 1.15759730e-01f, 2.89642420e-02f, 1.12137437e-01f, -1.84711158e-01f, 6.45411536e-02f,
  -7.11140549e-03f, 1.40884310e-01f, 4.97333482e-02f, 2.10973263e-01f, -4.99578379e-02f, -9.15934369e-02f, -4.25984431e-03f, 2.10370123e-01f, 2.84195635e-02f, 1.81982115e-01f,
  1.11687835e-02f, -2.56356727e-02f, -6.21788651e-02f, 3.91018614e-02f, -2.23301038e-01f, -8.04396719e-02f, 1.18132845e-01f, -1.29651189e-01f, 2.68307537e-01f, 3.18043418e-02f,
  1.88100234e-01f, 2.21680716e-01f, 1.14257157e-01f, 8.80117193e-02f, 2.50644237e-01f, 8.34311023e-02f, -1.53982565e-02f, 1.79236591e-01f, 1.25766441e-01f, 5.11110993e-03f,
  -7.30738789e-02f, -8.64765514e-03f, 6.21058978e-02f, 3.89357172e-02f, -9.12733302e-02f, 2.80945152e-01f, -7.63549358e-02f, 7.22899437e-02f, 1.49689019e-01f, -6.52154908e-02f,
  9.83843133e-02f, 8.27610306e-03f, 6.57251328e-02f, -5.86540997e-02f, -4.11702543e-02f, -4.37231511e-02f, 1.92607388e-01f, -1.26557529e-01f, 5.96934445e-02f, 1.58493277e-02f,
  8.19821134e-02f, 2.03914538e-01f, 8.74794424e-02f, 2.40461692e-01f, 1.41348049e-01f, -6.12746626e-02f, 6.34561479e-03f, -1.09871507e-01f, 1.56890184e-01f, -1.79409251e-01f,
  -3.68197486e-02f, 7.04609416e-03f, 1.27778143e-01f, 1.59213170e-01f, 2.00913385e-01f, 8.48404765e-02f, -9.93029308e-03f, -2.99737323e-02f, 1.23141631e-01f, 1.83527127e-01f,
  4.72277515e-02f, 3.10039520e-01f, 6.85572252e-02f, 5.99319041e-02f, 9.48134810e-02f, 1.36225283e-01f, -1.31597981e-01f, 1.89389959e-01f, 1.51080832e-01f, -1.22518398e-01f,
  -2.11152792e-01f, 2.15449408e-01f, -5.67614995e-02f, 2.63149440e-01f, 6.77299276e-02f, 9.04590189e-02f, 1.42955452e-01f, 7.34629855e-02f, 1.45407960e-01f, 1.92839637e-01f,
  9.03169066e-02f, -3.06510702e-02f, -6.81393733e-03f, 2.01814786e-01f, 9.16970819e-02f, -4.67271246e-02f, 1.05408341e-01f, 8.26459303e-02f, 1.18051715e-01f, 1.77242950e-01f,
  2.45642409e-01f, 1.30847231e-01f, 8.42346177e-02f, 2.90466249e-01f, -1.00456670e-01f, 8.39898884e-02f, 1.62216663e-01f, -1.75766826e-01f, 8.83785412e-02f, -1.80370316e-01f,
  1.06023118e-01f, -6.44397736e-02f, 4.43145297e-02f, 3.39923054e-02f, -1.77015692e-01f, 1.87160652e-02f, 1.90901421e-02f, 1.49779022e-01f, -2.11082622e-01f, -1.05729364e-01f,
  -1.67994887e-01f, -7.18707591e-02f, -8.76448452e-02f, 2.44094118e-01f, 3.55441421e-01f, 2.37876579e-01f, 1.16217405e-01f, -3.85629535e-02f, 8.18632394e-02f, -8.67907926e-02f,
  -1.72480240e-01f, 3.40698473e-02f, 6.61379918e-02f, -9.38804671e-02f, 1.20187849e-01f, 1.37841120e-01f, 3.31404246e-02f, 5.93695529e-02f, 1.38426468e-01f, 1.12598792e-01f,
  -1.24456570e-01f, 1.92926571e-01f, -1.27907526e-02f, 1.59753889e-01f, 1.07438914e-01f, 3.02683990e-02f, 8.28389451e-02f, 3.35180154e-03f, 7.72302970e-02f, 2.02707499e-01f,
  2.60199934e-01f, -2.26709116e-02f, 2.87559867e-01f, -6.03005402e-02f, -1.28073916e-01f, 1.54646501e-01f, -1.77000061e-01f, 3.03073116e-02f, -1.13849267e-01f, -2.31109828e-01f,
  -7.06112385e-02f, -1.93768591e-01f, 2.21061222e-02f, 5.69985993e-02f, 1.21742643e-01f, 3.44687849e-01f, 1.14393033e-01f, 2.57405937e-01f, -1.29106849e-01f, 1.29748791e-01f,
  3.30374688e-01f, 1.24108503e-02f, 1.89116254e-01f, 8.06640461e-03f, 2.43538484e-01f, -9.43209007e-02f, 2.08877884e-02f, 3.64191867e-02f, 8.10659155e-02f, -2.00024307e-01f,
  -5.34475669e-02f, 2.63945580e-01f, -2.33807400e-01f, -2.60080071e-03f, -2.16783568e-01f, -7.29600266e-02f, 6.62434697e-02f, 1.22657202e-01f, 5.68875158e-03f, -1.81525890e-02f,
  -9.97438505e-02f, 1.51471019e-01f, 2.29910776e-01f, -5.78846876e-03f, -6.28141612e-02f, -8.73068869e-02f, -5.04151098e-02f, 1.05335407e-01f, -5.91506474e-02f, 1.77056298e-01f,
  5.03725335e-02f, 1.30475566e-01f, 3.42546664e-02f, 3.77952936e-03f, 9.91872922e-02f, 5.90332365e-03f, -2.37355426e-01f, -8.63448903e-02f, 1.91745833e-01f, 6.95639895e-03f,
  1.03449345e-01f, -9.28571820e-02f, 1.50387764e-01f, 1.91111982e-01f, -6.82491958e-02f, 2.62650698e-01f, 4.82420661e-02f, 2.60357708e-01f, -2.64353026e-02f, 1.13192700e-01f,
  1.30736724e-01f, 4.42981720e-02f, 1.10484146e-01f, 2.31220365e-01f, 1.59690946e-01f, -4.57865000e-03f, -1.80314779e-01f, -2.09163409e-02f, -1.52546585e-01f, -1.18292421e-01f,
  -1.03597909e-01f, -2.01494664e-01f, -6.03562221e-02f, 1.67008027e-01f, -1.92378715e-01f, 8.44420865e-03f, -6.40919209e-02f, 9.82260481e-02f, -1.04637854e-01f, 1.65518431e-03f,
  3.20309550e-01f, 2.54168659e-01f, 1.97758615e-01f, 2.65222162e-01f, 6.28301688e-03f, -1.23993326e-02f, 2.27149025e-01f, 2.20097959e-01f, 3.00187580e-02f, -1.38054356e-01f,
  1.62207186e-01f, -8.82756934e-02f, 2.98101306e-02f, 2.04518944e-01f, 9.65361670e-03f, 1.32241845e-01f, 1.41152650e-01f, 1.93989605e-01f, 6.72316775e-02f, -6.07997067e-02f,
  3.26114148e-01f, 2.66112775e-01f, 1.62402824e-01f, -8.89350027e-02f, -6.50264844e-02f, 2.67878268e-02f, -2.38368637e-03f, 1.83172241e-01f, 2.51731902e-01f, -1.35409728e-01f,
  2.02072531e-01f, 2.16815442e-01f, -9.97717753e-02f, -1.21606477e-01f, -2.57893596e-02f, 1.31903514e-01f, 2.85841018e-01f, 1.26269925e-03f, -1.74717735e-02f, 7.03634508e-03f,
  1.08068103e-04f, -1.82735667e-01f, 8.65643024e-02f, -3.52341570e-02f, 2.08869949e-01f, -1.84596583e-01f, 1.97068632e-01f, 3.06563597e-05f, 2.73249056e-02f, 1.80876628e-01f,
  1.73773304e-01f, -9.72474590e-02f, 4.34238054e-02f, -1.63899198e-01f, 3.19994688e-01f, -5.49127460e-02f, 1.40421033e-01f, -1.04874171e-01f, -4.14693616e-02f, 2.27689266e-01f,
  -7.63696358e-02f, 1.37397587e-01f, 2.74182111e-02f, 2.20735341e-01f, -3.55318822e-02f, 1.89915653e-02f, 7.98893347e-02f, 4.16369587e-02f, 2.11183548e-01f, 1.94811031e-01f,
  -7.38204084e-03f, -2.01432873e-02f, 2.31767669e-01f, 2.92172492e-01f, 1.30787104e-01f, 1.77223906e-01f, -2.08372235e-01f, -1.75418258e-01f, -2.30730977e-02f, 1.04025759e-01f,
  6.78951666e-02f, 2.87986305e-02f, 2.77783781e-01f, 1.05060309e-01f, -1.35979772e-01f, 1.56943351e-01f, 9.09266993e-02f, -3.15408319e-01f, 8.62224549e-02f, -3.13111395e-02f,
  -2.14376837e-01f, 1.05981790e-01f, -4.15655524e-01f, 2.61792690e-01f, 9.56595913e-02f, 2.61098117e-01f, 3.94769281e-01f, -5.30681126e-02f, 1.93785071e-01f, -1.73405781e-01f,
  4.42957431e-01f, 3.43917429e-01f, 1.21346466e-01f, -2.17426449e-01f, 1.55873463e-01f, -3.72740142e-02f, 7.75954351e-02f, 1.36985719e-01f, -3.16573709e-01f, 5.75786282e-04f,
  -1.86073080e-01f, -4.43675108e-02f, -6.17692053e-01f, -1.83099970e-01f, -1.60527304e-01f, -2.40415987e-03f, 2.31197193e-01f, 6.15490079e-01f, 3.78700078e-01f, 1.02642953e-01f,
  -2.75989592e-01f, -2.36540228e-01f, 1.53995275e-01f, 1.16312064e-01f, 4.25485522e-02f, -2.52426118e-02f, 1.80257827e-01f, -8.04210603e-02f, 7.01926351e-02f, -7.87319466e-02f,
  2.27356181e-01f, -2.10537408e-02f, -8.17661583e-02f, 5.83526969e-01f, -8.65850598e-02f, 5.75068407e-02f, -1.11764660e-02f, 1.73998371e-01f, 4.87694442e-01f, -4.21701781e-02f,
  -5.40437579e-01f, -4.92684931e-01f, -1.41035259e-01f, 4.42859113e-01f, 2.36985579e-01f, 7.45177688e-03f, 2.46742532e-01f, -2.99599469e-02f, -4.94347252e-02f, 2.85140485e-01f,
  4.87124510e-02f, -2.48164181e-02f, -1.80268474e-02f, 5.56952693e-02f, 1.69977367e-01f, -4.99556214e-03f, 7.35072866e-02f, -1.48946792e-01f, 1.14566207e-01f, 2.05722347e-01f,
  -4.78161387e-02f, -5.86654060e-02f, 1.81462079e-01f, 6.13304935e-02f, 1.72652051e-01f, -8.62523615e-02f, 1.75722063e-01f, 2.69673795e-01f, -1.35369122e-01f, -1.93278156e-02f,
  2.04747304e-01f, 3.08444183e-02f, 2.90257752e-01f, 1.62422702e-01f, 2.81929195e-01f, 1.73776284e-01f, 2.10121349e-01f, 1.46874830e-01f, 7.94859976e-02f, -1.96680101e-03f,
  4.70085517e-02f, -1.91259161e-01f, 1.78979188e-01f, -1.40921861e-01f, -9.39779729e-02f, 1.74510479e-01f, 7.95255508e-03f, 2.39670277e-01f, -2.11767897e-01f, -9.03566182e-02f,
  -1.46777615e-01f, 6.50533140e-02f, 1.78892121e-01f, 1.58062093e-02f, -6.34686649e-02f, 2.10323989e-01f, 3.34306747e-01f, -4.39366587e-02f, -1.99926987e-01f, 7.57449195e-02f,
  2.39554167e-01f, 1.82538137e-01f, 1.74135163e-01f, 1.21926464e-01f, 1.34977758e-01f, -1.12005239e-02f, 1.87376902e-01f, -2.29241047e-02f, -3.61960940e-02f, 1.42474463e-02f,
  2.63360292e-01f, 2.53310055e-01f, 1.43412575e-01f, 1.46257997e-01f, 1.59244433e-01f, 2.26010591e-01f, 6.22793585e-02f, 2.54037939e-02f, 1.52924031e-01f, 3.03467978e-02f,
  3.05535514e-02f, -1.49450675e-01f, 2.61192799e-01f, 5.66234514e-02f, -4.85753417e-02f, -1.10943250e-01f, 3.88993435e-02f, 1.93856895e-01f, 1.44500941e-01f, 1.79387674e-01f,
  1.23027377e-01f, -2.15147287e-01f, 2.25617602e-01f, -7.68447248e-03f, 1.58508137e-01f, 9.78413671e-02f, 2.04854816e-01f, 1.94062531e-01f, 1.62002638e-01f, -7.50595257e-02f,
  6.94183782e-02f, 2.72719622e-01f, 1.76466241e-01f, 2.03209162e-01f, 2.63392448e-01f, 2.28048906e-01f, 9.96850133e-02f, 3.80146801e-01f, 1.93383142e-01f, -1.72007494e-02f,
  2.94976354e-01f, -9.28600132e-02f, 4.19316851e-02f, -3.71775264e-03f, 3.56018156e-01f, 7.56147802e-02f, -2.06198692e-01f, -6.81741387e-02f, 3.80775407e-02f, -1.88420489e-01f,
  -6.30844906e-02f, 1.05293438e-01f, -9.85190570e-02f, -2.50138670e-01f, 8.44854414e-02f, 1.85395092e-01f, -2.96462215e-02f, 2.38942191e-01f, 4.60388809e-02f, 6.42591417e-02f,
  1.40614994e-02f, -5.01778647e-02f, 5.52462041e-02f, 3.13322060e-03f, -1.34175234e-02f, -3.97661142e-02f, -2.86155492e-02f, -1.21554524e-01f, 9.01220739e-02f, 9.01854858e-02f,
  2.13685915e-01f, -3.58337089e-02f, 8.05383474e-02f, 7.43834153e-02f, 5.44719212e-02f, -2.10695013e-01f, 2.48476909e-03f, -2.49163136e-01f, 1.05960242e-01f, 2.21423004e-02f,
  -3.46801169e-02f, -6.52692989e-02f, -3.40185016e-02f, 3.91918123e-02f, -6.05214052e-02f, 2.01329097e-01f, 2.63889551e-01f, 5.39532155e-02f, 2.17526540e-01f, -1.40965864e-01f,
  1.08844794e-01f, 2.87290007e-01f, 8.13894421e-02f, 3.56267005e-01f, 1.07843600e-01f, -5.19286357e-02f, 2.55367875e-01f, 1.77877977e-01f, 2.40630403e-01f, -4.13176194e-02f,
  8.30219239e-02f, 3.05902719e-01f, 1.80984288e-01f, -1.10008404e-01f, 9.34181288e-02f, 2.05903292e-01f, -1.71531782e-01f, 2.06453074e-02f, 2.84278423e-01f, -4.92912077e-04f,
  -4.30283099e-02f, 1.92904845e-01f, 1.07822336e-01f, 2.48416886e-01f, 1.27038032e-01f, -8.12785327e-03f, 2.97539055e-01f, 3.14475477e-01f, 3.52008790e-02f, 1.99523866e-01f,
  -9.44475830e-02f, -9.90642533e-02f, 2.57193521e-02f, 1.09506369e-01f, 1.47257030e-01f, -1.09759994e-01f, 1.15434453e-01f, 7.54584149e-02f, 6.27257600e-02f, -2.84504285e-03f,
  -2.16206349e-02f, -1.33353591e-01f, 1.40847424e-02f, 1.68621078e-01f, 5.40206060e-02f, 3.28791067e-02f, 2.17078269e-01f, 8.02248642e-02f, 1.34087950e-01f, -1.27994165e-01f,
  -1.67302102e-01f, -2.09177673e-01f, 6.78345710e-02f, 1.98794603e-02f, -7.97482282e-02f, -1.45249432e-02f, -2.33854493e-03f, 1.11862011e-01f, -9.86335650e-02f, 1.86136663e-01f,
  -2.58002430e-02f, 2.61311501e-01f, -4.56719957e-02f, -1.06749833e-01f, 1.14590265e-01f, 1.40877038e-01f, -7.17537999e-02f, 3.50472063e-01f, 1.56238571e-01f, 3.09257768e-03f,
  -8.96487087e-02f, 1.79833546e-02f, -1.01796821e-01f, -1.29812986e-01f, -8.44068304e-02f, 1.43068517e-02f, -2.18803715e-02f, 3.06199100e-02f, -7.50460252e-02f, 9.81132612e-02f,
  1.12348087e-01f, 2.20386773e-01f, 1.69582069e-02f, -6.08385131e-02f, 1.21624455e-01f, 1.61941230e-01f, -5.12615405e-02f, 1.04229912e-01f, 2.59110659e-01f, -7.95080960e-02f,
  8.28696042e-02f, 3.71449560e-01f, 1.11028478e-01f, 8.83572772e-02f, -1.04169592e-01f, -1.71651259e-01f, 1.38830423e-01f, 1.60668880e-01f, 5.24497069e-02f, -1.54504865e-01f,
  1.28125846e-01f, 4.30787504e-02f, -6.41473802e-03f, 1.21678750e-03f, 2.97369123e-01f, 5.12509272e-02f, -5.75972125e-02f, 1.25351682e-01f, -3.49237286e-02f, 3.02659208e-03f,
  7.19996244e-02f, 1.87762007e-01f, 1.83597460e-01f, 2.87774317e-02f, 2.11990997e-01f, -1.63042188e-01f, 1.14996620e-02f, 5.86323477e-02f, 4.54515181e-02f, -5.66413924e-02f,
  7.45715424e-02f, 1.38921976e-01f, 1.50151938e-01f, -5.22496179e-02f, 3.62364292e-01f, -1.10577017e-01f, 2.59007424e-01f, -1.32703438e-01f, 1.92338079e-01f, 2.42923290e-01f,
  1.60383880e-01f, 1.82973653e-01f, -1.42889336e-01f, 3.38198580e-02f, 3.07651043e-01f, 1.45120546e-01f, 1.75110668e-01f, -8.99443924e-02f, 3.03001493e-01f, 3.81972581e-01f,
  2.01847270e-01f, -2.14937732e-01f, 2.12802440e-01f, 1.57893196e-01f, 5.45616355e-03f, 1.62068397e-01f, 3.20719391e-01f, 7.34752836e-03f, -1.42048851e-01f, 2.39662901e-01f,
  1.04738064e-02f, 4.65336069e-02f, -1.14556238e-01f, 1.23673737e-01f, 2.90933162e-01f, 8.58494341e-02f, 1.22776829e-01f, 1.21566467e-01f, -1.37284517e-01f, -8.34858194e-02f,
  -1.54674739e-01f, -5.69805391e-02f, -8.31069201e-02f, 1.30340094e-02f, 1.37627244e-01f, 9.69603807e-02f, -1.18971150e-02f, 1.12814225e-01f, -9.96014401e-02f, -2.24330351e-01f,
  1.98534518e-01f, 1.39206737e-01f, -4.03030142e-02f, -3.59565541e-02f, 5.08231781e-02f, 1.99022993e-01f, -1.10545278e-01f, 8.85741487e-02f, -2.08889052e-01f, -4.61041704e-02f,
  1.46355018e-01f, -5.25532402e-02f, 1.55092999e-01f, 9.74672437e-02f, 1.73309714e-01f, 2.85986662e-01f, -6.08936921e-02f, -1.04620852e-01f, 3.13564956e-01f, 1.83183536e-01f,
  -1.82195291e-01f, 2.00015470e-01f, -2.56730951e-02f, 1.61104146e-02f, -9.81180966e-02f, -2.15321705e-01f, 1.54503167e-01f, -3.89686190e-02f, -8.24608207e-02f, 2.85579294e-01f,
  -6.53862730e-02f, 1.83775038e-01f, 1.07870266e-01f, -1.19304750e-02f, 1.58897251e-01f, 1.87544018e-01f, 1.20152883e-01f, -1.73099935e-02f, 2.03124449e-01f, -2.63155792e-02f,
  2.04132915e-01f, 2.25977786e-02f, 3.03853042e-02f, -2.33424678e-02f, 2.68990844e-01f, 6.79609478e-02f, 5.00529446e-02f, 1.11627236e-01f, -2.95941550e-02f, -5.50201982e-02f,
  -1.65937319e-01f, -8.89831409e-02f, 1.02297202e-01f, -9.56845582e-02f, 1.22914955e-01f, 9.09062475e-02f, 7.87505805e-02f, 2.09531888e-01f, 9.75299180e-02f, 4.59750146e-02f,
  8.70743394e-02f, -9.08231363e-02f, -3.69962864e-02f, 1.46724880e-01f, 1.05332464e-01f, 1.55817136e-01f, -5.54568414e-03f, 7.90447071e-02f, 5.25905415e-02f, -1.62699148e-02f,
  2.00852990e-01f, -1.63318999e-02f, 3.03840879e-02f, -1.64509982e-01f, 5.38212098e-02f, -1.49073407e-01f, 1.90932840e-01f, -1.01690270e-01f, -3.63387614e-02f, 2.14881971e-01f,
  -2.23993376e-01f, -5.08621708e-02f, 2.78974503e-01f, 2.77964771e-01f, 4.76546288e-02f, -5.83972000e-02f, 1.11118466e-01f, -1.05138376e-01f, 1.93578348e-01f, 1.09311774e-01f,
  -9.33381729e-03f, -4.13782112e-02f, -1.03188269e-01f, 1.23373315e-01f, 9.62869730e-03f, -6.77210912e-02f, -7.54698738e-02f, 1.38116032e-01f, 2.90335447e-01f, -6.12375736e-02f,
  3.72695550e-02f, -1.81888808e-02f, 5.66789620e-02f, 1.72932789e-01f, 2.01837182e-01f, -7.80257769e-03f, 1.07435159e-01f, 2.68856883e-01f, 1.59795418e-01f, -1.03172220e-01f,
  -1.71870008e-01f, 1.98369130e-01f, 3.98846686e-01f, 1.50888726e-01f, 1.22087337e-01f, -9.02214497e-02f, 2.05218688e-01f, -5.92772907e-04f, -2.37947345e-01f, 4.38577384e-02f,
  -1.70303583e-01f, 1.73174903e-01f, 1.13142526e-03f, 2.04098910e-01f, 2.21047595e-01f, -1.09891921e-01f, 1.16380937e-01f, -3.54191773e-02f, 6.56076446e-02f, 1.82405755e-01f,
  1.52316332e-01f, 7.33418565e-04f, 4.10673507e-02f, 3.98260653e-02f, 4.39540409e-02f, -2.57197112e-01f, -1.25049412e-01f, -1.54821053e-01f, 1.07749648e-01f, -2.02970907e-01f,
  2.75232732e-01f, -3.25701162e-02f, 1.52149737e-01f, 1.17906265e-01f, 1.95320509e-02f, 1.25013024e-01f, 2.01515377e-01f, 1.32129401e-01f, 1.26718283e-01f, 4.34362963e-02f,
  3.13664347e-01f, 4.98784110e-02f, 1.13177598e-01f, -2.86060292e-02f, 3.31814110e-01f, 5.70923872e-02f, -2.07249954e-01f, 2.02026293e-01f, -8.80276486e-02f, -5.90042509e-02f,
  -7.46446522e-03f, -1.14773855e-01f, 1.81975052e-01f, 1.47201270e-01f, -1.46075845e-01f, -3.05940267e-02f, 5.60957901e-02f, 1.51514351e-01f, 1.61172152e-01f, -1.22842364e-01f,
  7.50362054e-02f, 1.69557095e-01f, 8.99752304e-02f, 2.48465508e-01f, 6.88957348e-02f, -2.85243765e-02f, 3.10377717e-01f, 7.35607073e-02f, 4.20291871e-02f, -1.56597421e-01f,
  1.11222185e-01f, -1.86884496e-02f, -6.32075872e-03f, 1.34993821e-01f, 2.19894666e-02f, 1.03309453e-01f, 2.71065831e-01f, 2.05470979e-01f, 5.93493544e-02f, 1.01487674e-01f,
  1.73011154e-01f, 1.56655595e-01f, -2.22094823e-02f, 1.58345997e-01f, 4.82276194e-02f, 1.36383206e-01f, 1.42990917e-01f, 4.63153459e-02f, -1.55564129e-01f, 4.43036072e-02f,
  -7.91337900e-03f, 1.04068946e-02f, 2.29739681e-01f, 8.42477083e-02f, 1.61179721e-01f, 1.69637427e-02f, 8.87505189e-02f, 7.01037347e-02f, 2.65000910e-01f, -5.58956750e-02f,
  3.20114702e-01f, -7.25966319e-02f, 1.72366619e-01f, 1.73445672e-01f, 1.47595048e-01f, 1.65138677e-01f, -9.96584520e-02f, 8.98009259e-03f, 1.67435154e-01f, -2.49245301e-01f,
  2.39784420e-02f, 1.96295291e-01f, 1.69295609e-01f, 2.58625627e-01f, 3.74280699e-02f, 2.55162030e-01f, 6.65340573e-02f, 1.97121613e-02f, 8.25551152e-02f, -1.35623202e-01f,
  -1.25644937e-01f, -2.93900549e-01f, 2.96514958e-01f, 3.26187546e-05f, -2.55051762e-01f, -9.91251916e-02f, 9.30400193e-02f, -1.61145523e-01f, -2.13539265e-02f, 3.30225080e-02f,
  5.46380654e-02f, 3.06485035e-03f, 1.17605850e-01f, -1.76486269e-01f, -1.44996852e-01f, 5.58952941e-03f, -1.39628634e-01f, -7.28299990e-02f, -1.71506092e-01f, -1.21011762e-02f,
  1.60443887e-01f, 1.46971866e-01f, 1.04532905e-01f, 7.12467451e-03f, -5.12090735e-02f, -1.09331504e-01f, 1.67972699e-01f, 2.40134951e-02f, 1.00678273e-01f, 1.04772761e-01f,
  1.61517598e-02f, 1.19508550e-01f, 1.73030734e-01f, -3.08847870e-03f, 2.15552628e-01f, 8.59885514e-02f, -1.89712048e-01f, -7.83521831e-02f, -2.13752612e-01f, 1.09001100e-01f,
  2.68165413e-02f, -5.02008423e-02f, 1.17212872e-03f, 8.64321366e-03f, 5.25550842e-02f, -2.14641467e-01f, -6.28831536e-02f, -2.06955522e-02f, 4.19392921e-02f, 7.02508315e-02f,
  1.38682216e-01f, 2.42816538e-01f, -2.43645877e-01f, 5.15568107e-02f, 1.98494270e-01f, -1.69945836e-01f, 1.82512119e-01f, -1.87394500e-01f, 2.60906309e-01f, -3.92925143e-02f,
  -1.74640134e-01f, -9.21660513e-02f, 6.49288222e-02f, 2.23439679e-01f, -1.33056000e-01f, 8.96839984e-03f, -1.57632470e-01f, 1.38388366e-01f, -1.50467649e-01f, 1.57507583e-01f,
  1.24288298e-01f, -7.27890432e-02f, 1.96063936e-01f, -1.22155949e-01f, -4.58202995e-02f, 2.17937320e-01f, 7.35945106e-02f, 2.59683728e-01f, -2.25179270e-01f, -8.41323957e-02f,
  -1.82657838e-01f, 5.20977527e-02f, 9.24459994e-02f, 1.03129879e-01f, 2.31713429e-03f, -8.19039270e-02f, -4.15998846e-02f, 1.31256610e-01f, -6.75677788e-03f, -2.74557620e-02f,
  -1.39868367e-04f, -9.87532511e-02f, -1.02617778e-01f, -6.32185563e-02f, -7.44729638e-02f, -4.77846675e-02f, 1.25123024e-01f, -3.30038518e-02f, -9.79562849e-02f, 8.57746601e-02f,
  1.55735582e-01f, -1.81909353e-01f, 2.17909127e-01f, -1.43440008e-01f, -1.82607528e-02f, 2.05415368e-01f, -1.40882894e-01f, -1.42271399e-01f, 1.74414843e-01f, 1.71545357e-01f,
  -9.03608650e-02f, 1.76738456e-01f, -1.43165961e-01f, -1.30965278e-01f, -1.37923583e-01f, 7.06351176e-02f, -1.18596233e-01f, 6.21449649e-02f, 2.44182795e-01f, 1.07255690e-01f,
  2.87373513e-02f, -2.26335004e-01f, 6.29015639e-02f, -1.66946441e-01f, 2.09229648e-01f, -1.41722411e-01f, 6.91961646e-02f, 1.80726871e-01f, 8.59423652e-02f, 4.17079896e-01f,
  8.56718719e-02f, 1.16760843e-01f, 1.89903527e-01f, 3.12349528e-01f, 2.72617429e-01f, 1.27675116e-01f, -6.61081672e-02f, 1.75449267e-01f, 2.24879488e-01f, 6.34977892e-02f,
  -5.71392961e-02f, 2.79816300e-01f, 1.35044038e-01f, -1.84366144e-02f, -2.39967078e-01f, 1.65932596e-01f, 9.80033204e-02f, 1.04924202e-01f, 2.26424746e-02f, 1.92886908e-02f,
  3.33030894e-02f, 1.66495010e-01f, 2.92472392e-01f, 9.82800275e-02f, 1.56868622e-01f, 1.10868856e-01f, -3.29489331e-03f, 7.04735518e-02f, 1.08697135e-02f, 1.38682634e-01f,
  9.56476666e-03f, 8.29205140e-02f, 1.57818168e-01f, 1.53997289e-02f, -2.64987528e-01f, 6.50138184e-02f, -5.10102585e-02f, 3.12695563e-01f, 8.68428797e-02f, -1.45671576e-01f,
  7.32996985e-02f, -1.08843101e-02f, -2.10544914e-01f, 4.83184494e-02f, 2.56720513e-01f, -7.01128170e-02f, 5.26601216e-03f, 3.42224874e-02f, 1.93953469e-01f, -2.51039326e-01f,
  -5.45780919e-02f, 1.71965763e-01f, 5.43658696e-02f, -7.21628368e-02f, 1.08336449e-01f, 1.93482473e-01f, -1.21214688e-02f, 9.68087465e-02f, -7.98802972e-02f, 1.89161405e-01f,
  -4.57766689e-02f, -1.28723338e-01f, 2.61004806e-01f, 9.66189802e-02f, -1.71246126e-01f, 8.86237398e-02f, -3.53102274e-02f, -6.26868531e-02f, -2.92626202e-01f, -2.89438695e-01f,
  -2.81008661e-01f, 1.75585076e-01f, -6.04180023e-02f, -1.25244632e-01f, -5.87616116e-02f, 4.83792312e-02f, -1.49972113e-02f, 3.55325431e-01f, 3.17802906e-01f, 1.32647365e-01f,
  5.10047674e-02f, 1.26033008e-01f, -1.53102949e-01f, -8.41876417e-02f, -3.40659209e-02f, -1.43423066e-01f, -5.43873608e-02f, -6.84198439e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.02693491e-01f, -3.36096361e-02f, 3.93446796e-02f, 8.92712548e-02f, 1.77338749e-01f, 1.87774211e-01f, 2.33714521e-01f, -7.14913756e-03f, 1.13042779e-01f, 2.50012130e-01f,
  2.08722614e-02f, 7.50477090e-02f, 1.41402513e-01f, -2.82655638e-02f, 1.79407313e-01f, 1.76619306e-01f, 4.81127165e-02f, 9.13857520e-02f, -1.70866493e-02f, 8.47626626e-02f,
  5.86996339e-02f, -1.81954186e-02f, -2.42940187e-02f, 1.27277493e-01f, 1.01053938e-01f, 1.11023270e-01f, 5.94767369e-02f, 1.18482165e-01f, -5.11587560e-02f, 5.07320315e-02f,
  2.16605887e-01f, 9.45314243e-02f, 1.25458520e-02f, 1.17253266e-01f, 1.35093138e-01f, 9.55465883e-02f, 1.21374153e-01f, 1.72835857e-01f, 1.49907485e-01f, 1.67916536e-01f,
  6.90914467e-02f, 1.82123795e-01f, 2.63106152e-02f, 1.60555422e-01f, 1.69697061e-01f, 1.61288098e-01f, 9.51575413e-02f, 1.89824671e-01f, 1.37306675e-01f, -4.39095236e-02f,
  9.97399688e-02f, 1.65177003e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  7.77270272e-02f, 6.72981292e-02f, 1.03976183e-01f, 4.26425189e-02f, 5.84308617e-02f, -1.71330776e-02f, -1.11270256e-01f, 1.74356043e-01f, 4.84247208e-02f, -1.03170209e-01f,
  -8.66347626e-02f, 1.86773539e-01f, 3.47885080e-02f, 8.97713229e-02f, 1.03982359e-01f, -1.25304982e-01f, 7.48270154e-02f, 1.21412508e-01f, 7.16136992e-02f, -4.78464598e-03f,
  9.15583074e-02f, 8.83105770e-02f, -2.02567764e-02f, -7.37867206e-02f, 1.22155763e-01f, 9.09661278e-02f, -2.02668205e-01f, -2.40261685e-02f, -1.11569010e-01f, -2.88914144e-02f,
  -3.78109962e-02f, 1.05188303e-01f, -9.43819657e-02f, 1.18344039e-01f, 4.26817536e-02f, -1.12657368e-01f, -1.57161713e-01f, -1.46874472e-01f, 1.72496289e-01f, 1.47319175e-02f,
  -8.26247782e-02f, 1.21163115e-01f, 1.93428267e-02f, -1.47606388e-01f, -1.56455740e-01f, 1.56168863e-01f, 4.87535931e-02f, -8.37965086e-02f, -1.01240918e-01f, -2.78556757e-02f,
  -4.48076315e-02f, 3.69054126e-03f, 6.90704063e-02f, -1.31669343e-01f, 5.07672876e-02f, 5.94219789e-02f, -1.36065364e-01f, -1.60459548e-01f, -1.45948892e-02f, 4.14051972e-02f,
  1.13893904e-01f, -1.10535555e-01f, -7.20705017e-02f, 1.37046963e-01f, 1.97611507e-02f, 8.58097747e-02f, 2.27479823e-02f, 6.59008622e-02f, -2.83071380e-02f, 1.13259584e-01f,
  -8.51577669e-02f, 1.60526812e-01f, -1.53357804e-01f, -1.05948672e-01f, -4.66872156e-02f, 2.22790420e-01f, -9.71110538e-02f, -1.56467766e-01f, 5.94053380e-02f, 4.01957333e-02f,
  -1.00894291e-02f, 1.48369312e-01f, -4.29209806e-02f, -2.51159910e-02f, 6.54424131e-02f, 1.74694389e-01f, 2.42659282e-02f, -3.58716287e-02f, -1.42120020e-02f, 3.61228362e-02f,
  -2.07778171e-01f, -5.62071837e-02f, 1.18523158e-01f, 3.96391638e-02f, 4.37125750e-02f, 9.82180610e-02f, -3.87208536e-02f, 1.63198654e-02f, 1.22120176e-02f, -4.47704904e-02f,
  -6.37952238e-02f, -5.46062505e-03f, -5.72674349e-02f, 1.59089584e-02f, 1.54918045e-01f, 2.05153495e-01f, 4.67065945e-02f, -1.89159557e-01f, -8.89702812e-02f, 9.94241536e-02f,
  -1.36380121e-01f, -1.04843266e-01f, -9.78638679e-02f, -1.69553623e-01f, 5.27389795e-02f, -7.43656605e-02f, 1.14853881e-01f, 1.79415047e-01f, 3.26542743e-02f, 5.64649627e-02f,
  -1.28326684e-01f, -7.59941936e-02f, 3.64799127e-02f, 6.98302314e-02f, -1.05559573e-01f, 2.13787064e-01f, 1.01604179e-01f, 8.58753398e-02f, 1.05817012e-01f, -1.23130932e-01f,
  4.84862663e-02f, 6.97578341e-02f, -8.15372765e-02f, 4.02110815e-02f, -1.22354999e-01f, -9.80313495e-02f, 1.24208041e-01f, 1.51348710e-01f, 1.39437437e-01f, 2.54210085e-02f,
  8.23620781e-02f, -1.11427516e-01f, -9.87014547e-02f, 3.86164784e-02f, 1.54716372e-01f, -5.68214431e-02f, -3.44429985e-02f, -2.13956945e-02f, -2.62617972e-02f, -1.08259637e-02f,
  -9.90911797e-02f, 7.55512714e-02f, 6.58983663e-02f, -1.71843812e-01f, 9.85558629e-02f, -3.64809223e-02f, 9.53599140e-02f, -9.67936218e-02f, 1.60066057e-02f, 6.43885732e-02f,
  -3.36434804e-02f, 1.53971575e-02f, 5.87125048e-02f, -7.88472965e-03f, 9.50925425e-02f, 1.03812717e-01f, -6.49489537e-02f, -5.68009121e-03f, 9.83497128e-02f, 6.54567555e-02f,
  -1.45902112e-01f, 3.58939581e-02f, 1.40344158e-01f, -3.95926312e-02f, -1.12554826e-01f, 1.70789212e-01f, 1.29706085e-01f, -6.13823021e-03f, 8.11009482e-02f, -7.34492838e-02f,
  -7.53806010e-02f, 1.35147244e-01f, 5.00479005e-02f, -1.06852025e-01f, -4.37103882e-02f, -1.30054027e-01f, -1.62343681e-01f, -1.38506278e-01f, 3.58270854e-02f, 3.85473147e-02f,
  -6.80609941e-02f, 1.30805910e-01f, 1.17934100e-01f, 1.62336847e-03f, 5.39955171e-03f, -7.15996027e-02f, 6.61035553e-02f, -8.91844258e-02f, 1.10926218e-01f, -1.31557360e-01f,
  -1.87506080e-01f, -3.90982106e-02f, 3.08089033e-02f, 2.67052650e-02f, 1.74285814e-01f, 7.27481616e-04f, 7.56694004e-02f, -1.66267082e-01f, -3.45820300e-02f, -1.13681026e-01f,
  -7.61527121e-02f, 1.97102368e-01f, -1.10430911e-01f, -1.00993484e-01f, 2.43284956e-01f, 1.24555938e-01f, -3.88035960e-02f, -1.42308310e-01f, -1.11140989e-01f, 4.89185117e-02f,
  -1.07146971e-01f, 1.48313850e-01f, 5.43524325e-02f, -5.46672046e-02f, 1.16831236e-01f, 2.03773573e-01f, 3.56579348e-02f, -9.96477157e-02f, -5.33582233e-02f, 5.32970615e-02f,
  2.36868784e-02f, 1.97936743e-01f, 3.58991846e-02f, -2.03905310e-02f, 2.11008620e-02f, -6.31284043e-02f, 1.18497960e-01f, 1.11511931e-01f, 1.10643305e-01f, -6.87447637e-02f,
  5.19928671e-02f, -4.31530215e-02f, -1.73333883e-01f, -8.10430124e-02f, -1.52602285e-01f, -2.29114257e-02f, -7.33222812e-02f, 4.39795945e-03f, -1.54693380e-01f, -2.53309980e-02f,
  2.17416629e-01f, -3.56928036e-02f, 2.50784084e-02f, -3.70864570e-02f, 1.02412321e-01f, -3.38771231e-02f, 1.08011067e-01f, 2.05437397e-03f, 4.05100062e-02f, 3.48651633e-02f,
  1.18891858e-01f, 4.20075050e-03f, 9.92364883e-02f, 2.06017777e-01f, -1.27495944e-01f, -6.37169331e-02f, -1.57774478e-01f, 2.38728747e-01f, 3.42501067e-02f, -1.60754964e-01f,
  -2.49912608e-02f, -2.58882716e-02f, -1.25068547e-02f, -2.95347404e-02f, 2.35640127e-02f, 1.10845067e-01f, 9.29746702e-02f, 5.50933369e-03f, 1.27587199e-01f, 4.98274565e-02f,
  8.05926174e-02f, 5.43328039e-02f, -1.67070311e-02f, 6.20043576e-02f, 2.40877122e-02f, -1.10595644e-01f, -1.20382838e-01f, 1.37576401e-01f, 1.23841994e-01f, -1.10618188e-03f,
  1.84229210e-01f, -1.63111225e-01f, -1.48941847e-02f, 7.26711378e-02f, 7.27633387e-02f, 8.59205648e-02f, -1.89184695e-01f, -1.25994891e-01f, 3.54263075e-02f, 7.20327534e-03f,
  7.31373578e-02f, 5.55442311e-02f, -6.52749836e-02f, -1.28871396e-01f, -9.06179547e-02f, -7.62422532e-02f, 1.91161692e-01f, -2.22915737e-03f, -6.09005429e-02f, 3.86796147e-02f,
  -8.14755931e-02f, -2.85833534e-02f, 7.42578460e-03f, -7.76297748e-02f, 9.84250605e-02f, -2.76958686e-03f, 2.31078174e-02f, 1.42216086e-01f, -1.24838673e-01f, 2.25603640e-01f,
  2.43444387e-02f, 1.16339400e-01f, 4.20282520e-02f, -6.42699152e-02f, -9.44384038e-02f, -9.47422981e-02f, -1.59924477e-01f, 9.44009796e-02f, 6.68907389e-02f, 1.45301059e-01f,
  -4.01939601e-02f, 1.88189700e-01f, -1.32873058e-01f, -8.33558440e-02f, -9.64997262e-02f, 1.00198321e-01f, 1.34511322e-01f, 1.53370291e-01f, 1.66252144e-02f, -4.98466901e-02f,
  2.58310735e-02f, -5.87718599e-02f, 1.05206661e-01f, -1.78808898e-01f, -3.72904427e-02f, -1.12831155e-02f, -1.08505249e-01f, -1.21903330e-01f, 8.82554278e-02f, 7.51318261e-02f,
  -8.42093974e-02f, -3.60687710e-02f, -4.32699472e-02f, -1.94871958e-04f, 4.05265391e-02f, 6.41415343e-02f, 3.46207693e-02f, 1.33320197e-01f, -1.16360985e-01f, -3.74741554e-02f,
  -5.01485215e-03f, -1.36350051e-01f, 2.31794491e-02f, -9.37497988e-02f, 2.10110322e-02f, 1.49899960e-01f, 6.93265498e-02f, 6.06233962e-02f, -1.06956335e-02f, 2.92726234e-02f,
  3.82449701e-02f, -1.75378487e-01f, 1.18296497e-01f, -3.62492050e-03f, -1.27656847e-01f, -5.17824702e-02f, 9.94986817e-02f, 7.50920624e-02f, -2.05662593e-01f, -1.79117136e-02f,
  9.90368500e-02f, 7.81324208e-02f, 5.79547882e-02f, 9.00447965e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  6.00559004e-02f, -7.17920884e-02f, 1.04828179e-01f, 1.57827303e-01f, 8.59679375e-03f, -1.40483633e-01f, -1.52764589e-01f, 2.18921527e-01f, 1.14647239e-01f, -1.20966911e-01f,
  2.21163750e-01f, 1.99260339e-01f, 3.92485447e-02f, -1.70480654e-01f, -9.25375056e-03f, 1.51432857e-01f, 8.42224211e-02f, 1.29675448e-01f, 1.35625541e-01f, -1.86273996e-02f,
  -1.81327127e-02f, 4.55628298e-02f, 3.75001878e-02f, 1.73038635e-02f, -4.69442233e-02f, -1.65649071e-01f, -1.66244537e-01f, 1.35215491e-01f, -3.07055172e-02f, -1.47869542e-01f,
  -2.38106921e-01f, 1.68021038e-01f, 1.73907280e-01f, 1.02576375e-01f, 1.32369071e-01f, -2.75697917e-01f, -1.32705435e-01f, -1.43325359e-01f, 2.37406325e-03f, -1.08202375e-01f,
  1.35246560e-01f, 8.08787271e-02f, -9.81320515e-02f, -3.24244536e-02f, -1.49221614e-01f, -4.22869856e-03f, -2.23153561e-01f, 7.51185045e-02f, -1.22339837e-01f, -1.41392395e-01f,
  1.24874555e-01f, 4.32020634e-01f, -5.67688197e-02f, 1.90373808e-01f, -6.53598085e-02f, -2.17099160e-01f, -6.46522194e-02f, -1.51409462e-01f, 1.10948019e-01f, 3.06457747e-02f,
  -6.98714331e-02f, 6.10651486e-02f, 3.32339145e-02f, 2.31468126e-01f, 2.82305591e-02f, 3.80419418e-02f, -1.54172275e-02f, 9.83105693e-03f, -9.08398703e-02f, 2.78966092e-02f,
  8.45297053e-02f, -2.54614085e-01f, -2.48556256e-01f, 9.17035565e-02f, -1.06566422e-01f, -2.25469638e-02f, -1.65410936e-01f, 2.16253370e-01f, 1.73133358e-01f, -8.71433094e-02f,
  -2.93282345e-02f, 3.57684419e-02f, 1.09946355e-01f, 1.60786752e-02f, 5.53769507e-02f, -1.58418432e-01f, -1.07845917e-01f, 8.19143876e-02f, 1.69134483e-01f, 2.47963518e-01f,
  2.30148807e-01f, -2.15789657e-02f, 6.48023095e-03f, 2.39541516e-01f, 3.66703361e-01f, 6.81346580e-02f, -2.81545985e-02f, -2.39127815e-01f, -1.14175744e-01f, 2.37378016e-01f,
  2.29423076e-01f, 6.06616586e-02f, 1.32692188e-01f, 1.81516945e-01f, 1.15447976e-01f, 7.01560527e-02f, -3.45206894e-02f, 2.03223020e-01f, 1.14397690e-01f, -1.75386444e-02f,
  2.81661272e-01f, 3.96854468e-02f, 2.75920153e-01f, 2.03740552e-01f, -1.06967635e-01f, 1.26274884e-01f, -5.92358373e-02f, -5.17616682e-02f, 1.23146866e-02f, 1.07399359e-01f,
  -1.50141984e-01f, 2.19400749e-01f, 1.00561582e-01f, 9.61964652e-02f, 1.62192449e-01f, -1.05662845e-01f, 2.24507481e-01f, -1.31573945e-01f, 2.23640893e-02f, 2.17425320e-02f,
  -9.56503153e-02f, -9.96469185e-02f, -1.81669712e-01f, -1.42046198e-01f, -4.77382913e-02f, -1.55334756e-01f, 2.40271285e-01f, -3.94319929e-02f, 1.45151779e-01f, -4.00661677e-01f,
  2.09486663e-01f, 4.69079316e-02f, -6.14134297e-02f, 1.02837570e-01f, 1.97738886e-01f, 1.31380424e-01f, 5.83776906e-02f, 8.16951916e-02f, -1.85046926e-01f, -6.92752004e-02f,
  -1.33998632e-01f, 2.90544569e-01f, 7.18094185e-02f, -6.44942150e-02f, 2.97208160e-01f, -1.13321774e-01f, 2.25998744e-01f, 2.21707523e-01f, 2.45842859e-01f, -5.38095608e-02f,
  -5.44087263e-03f, 2.15261862e-01f, -2.42003411e-01f, 5.63303158e-02f, 8.97851884e-02f, 2.30659544e-01f, 2.44359188e-02f, 7.44791701e-03f, -8.88200626e-02f, -1.88296139e-01f,
  1.27467038e-02f, -1.46613829e-03f, 2.34129325e-01f, -2.46494889e-01f, 7.94676021e-02f, -4.78046648e-02f, 2.19744369e-01f, -1.43627301e-02f, -1.91676132e-02f, 3.63626599e-01f,
  5.46111874e-02f, -3.51236537e-02f, 2.38249958e-01f, -1.34118013e-02f, 2.37641573e-01f, 1.77297130e-01f, -8.83768424e-02f, -4.49140482e-02f, 3.81663069e-02f, 1.02260493e-01f,
  2.48664513e-01f, -1.22062944e-01f, 1.36717051e-01f, -6.69390112e-02f, -9.71559901e-03f, 1.34419605e-01f, -5.25438823e-02f, 7.06001967e-02f, 1.67476758e-01f, 1.79800868e-01f,
  3.01567078e-01f, -5.11609726e-02f, 2.32555881e-01f, 8.71826708e-02f, 4.44984771e-02f, -1.24415636e-01f, 9.15682316e-02f, 1.12777397e-01f, 1.32477134e-01f, 1.49623796e-01f,
  2.83419549e-01f, 2.09021382e-02f, 1.93675801e-01f, 2.07358688e-01f, -1.53312668e-01f, 7.69613981e-02f, 4.79409732e-02f, -1.14545017e-01f, -1.46133944e-01f, -1.35421902e-01f,
  8.24097171e-02f, 5.95312752e-02f, -7.04251975e-02f, 7.34475628e-02f, 7.20837489e-02f, 3.74663323e-02f, 9.43483189e-02f, 7.01306015e-02f, -8.57210606e-02f, -5.43284863e-02f,
  1.89658836e-01f, -4.73646186e-02f, 3.37335795e-01f, 3.32674533e-01f, 1.17295675e-01f, -1.84123814e-01f, -1.18680760e-01f, 2.30295479e-01f, 1.84424091e-02f, -1.17178001e-01f,
  -7.82655105e-02f, -8.10604990e-02f, 1.58820659e-01f, 7.60072693e-02f, 1.38052002e-01f, 1.93023622e-01f, 2.69125581e-01f, 2.16274206e-02f, 2.69783139e-01f, -1.63252115e-01f,
  1.74134716e-01f, 4.90167066e-02f, 2.01801971e-01f, 1.42614260e-01f, 1.05766341e-01f, 1.88002679e-02f, -2.98179891e-02f, 9.26112235e-02f, 7.04690963e-02f, -4.59660627e-02f,
  -5.73054105e-02f, 1.44001484e-01f, 1.94175676e-01f, 5.62362298e-02f, 1.41511830e-02f, 2.47808591e-01f, 7.50098825e-02f, -1.37308553e-01f, -1.65254518e-01f, 7.18268976e-02f,
  1.25254601e-01f, -3.16440091e-02f, -4.92001362e-02f, -3.06498576e-02f, 2.37049252e-01f, 1.16313651e-01f, -1.06514104e-01f, -2.10225731e-02f, 5.26458845e-02f, -1.00746013e-01f,
  -3.14884596e-02f, 9.43062901e-02f, 2.80171275e-01f, 3.78871034e-03f, -9.68821719e-02f, -1.61191879e-03f, -5.57237826e-02f, 9.27386582e-02f, -7.36898603e-03f, -7.84740001e-02f,
  3.71323749e-02f, 1.51288480e-01f, -1.10401837e-02f, 1.69650782e-02f, 3.78870331e-02f, -1.07848063e-01f, -1.93391442e-01f, 1.14554733e-01f, 2.04038814e-01f, 8.54986459e-02f,
  -9.42361280e-02f, -1.58828795e-01f, 1.42624900e-01f, 2.13463753e-01f, -1.64378751e-02f, 1.21942773e-01f, -1.33297026e-01f, -2.00804025e-01f, -3.11240479e-02f, 2.18295962e-01f,
  2.67445773e-01f, 1.17268085e-01f, 1.18125111e-01f, -7.10534602e-02f, 1.68526210e-02f, 1.21988021e-01f, 2.33986899e-01f, -1.64768234e-01f, 1.37532819e-02f, -1.08396217e-01f,
  -3.71033326e-02f, 1.39306664e-01f, 1.31897986e-01f, 1.74489133e-02f, 1.44553697e-02f, 8.34029764e-02f, -2.98065513e-01f, -2.63499711e-02f, -2.01098174e-01f, 1.19269602e-01f,
  -8.24565291e-02f, 7.41727874e-02f, 9.52905938e-02f, 8.16297159e-02f, -1.92971870e-01f, 2.07249478e-01f, 1.48450226e-01f, 1.59584850e-01f, -6.22027554e-03f, 8.08312222e-02f,
  2.64131110e-02f, 1.06217854e-01f, 3.29255044e-01f, 8.74334946e-02f, 3.01451266e-01f, 5.78797981e-02f, 9.84384269e-02f, 2.95386612e-01f, 1.99922115e-01f, 2.59302538e-02f,
  8.80010575e-02f, -3.28331031e-02f, 3.15402746e-01f, 3.01947951e-01f, 3.87385720e-03f, 2.62701601e-01f, 1.74338564e-01f, 1.50634989e-01f, -7.90334046e-02f, 9.17108208e-02f,
  1.66513801e-01f, -9.41705517e-03f, 2.50122517e-01f, 9.97572020e-02f, 1.87058702e-01f, 1.87178612e-01f, -1.39928326e-01f, 2.42067307e-01f, -1.93858609e-01f, -8.86815563e-02f,
  -9.46140811e-02f, -3.05492073e-01f, 6.39581084e-02f, 1.34397984e-01f, -3.19627784e-02f, 2.39612773e-01f, -1.46157473e-01f, -1.36368454e-01f, -1.39421999e-01f, -8.39201733e-02f,
  -9.74769294e-02f, 2.47999102e-01f, -1.35631680e-01f, 6.71122000e-02f, 4.59481999e-02f, 2.22771298e-02f, 1.11609280e-01f, 4.01849374e-02f, 2.05824748e-02f, 1.79828089e-02f,
  4.41618077e-02f, -2.71517958e-04f, 3.32581699e-01f, -2.16939583e-01f, 1.92841724e-01f, -2.73411781e-01f, -1.28857121e-01f, -3.65748852e-02f, 6.99663535e-02f, -2.40312696e-01f,
  -1.51710927e-01f, -2.52763182e-01f, 3.08917016e-01f, 5.95793407e-03f, 2.25891657e-02f, 1.06226750e-01f, -3.74700427e-01f, 3.34247611e-02f, -3.42349470e-01f, 6.21601902e-02f,
  2.29563266e-01f, -2.52887726e-01f, 1.20938785e-01f, 7.45287538e-02f, 1.31077036e-01f, 1.86379805e-01f, -1.57589670e-02f, -7.03591108e-02f, 1.17370240e-01f, 2.31920704e-02f,
  -1.02485426e-01f, 1.24552976e-02f, 1.80647567e-01f, 8.52061436e-03f, -3.69044691e-02f, 2.79316783e-01f, 1.90769136e-02f, -9.30594504e-02f, 1.69046074e-01f, -1.33344561e-01f,
  2.37784550e-01f, 1.11951135e-01f, 2.77551740e-01f, -1.05292670e-01f, 1.61494482e-02f, 6.40438855e-01f, -1.43134922e-01f, 2.31765047e-01f, 1.57728940e-01f, -1.28936410e-01f,
  2.85588086e-01f, 2.15260476e-01f, 1.97194010e-01f, -7.43689463e-02f, 4.25087541e-01f, 7.44597912e-02f, -1.31348833e-01f, -2.59934217e-02f, 5.31776063e-02f, 1.83167439e-02f,
  1.47311032e-01f, 3.07073575e-02f, 1.96615398e-01f, 3.76752317e-02f, -3.15442085e-01f, 6.59538582e-02f, 3.22139598e-02f, 8.92416239e-02f, 2.34747410e-01f, 2.56962389e-01f,
  2.67648548e-02f, 1.42205488e-02f, 3.32550220e-02f, 6.38055205e-02f, 4.10685427e-02f, 3.08708530e-02f, 1.86266512e-01f, -2.27684513e-01f, -3.67325135e-02f, 1.80442154e-01f,
  2.39539504e-01f, -1.49895862e-01f, -1.71804532e-01f, 8.64400566e-02f, 4.65844497e-02f, 9.06752869e-02f, 2.38492563e-01f, 1.50186285e-01f, 1.15458935e-01f, 3.09364200e-01f,
  2.35728785e-01f, -1.40951425e-01f, 7.01886714e-02f, 9.90837663e-02f, 4.99446541e-02f, 1.26540288e-01f, -1.07723996e-01f, 9.75108221e-02f, -5.91209196e-02f, 1.15195088e-01f,
  -9.68114380e-03f, 2.05484480e-01f, 2.33832121e-01f, -1.68367475e-01f, -8.58605094e-03f, 3.25764745e-01f, 1.05162576e-01f, -2.08973363e-02f, -8.75951350e-02f, 2.11113617e-01f,
  1.12010069e-01f, 2.29184583e-01f, -1.14689857e-01f, -1.52098700e-01f, -8.82815421e-02f, -9.01551396e-02f, -2.20851153e-01f, -6.00940622e-02f, 2.79092729e-01f, -8.31455439e-02f,
  -2.91257918e-01f, 2.44233489e-01f, 1.27340361e-01f, 1.82841927e-01f, 2.23068267e-01f, 1.77734911e-01f, 1.15246527e-01f, 2.23886713e-01f, 5.78183569e-02f, 2.69031189e-02f,
  -3.35245430e-02f, 1.51805371e-01f, -7.93288276e-02f, 3.23258503e-03f, -8.06451961e-02f, -1.02137864e-01f, 2.47906297e-01f, -1.01870045e-01f, -2.42287695e-01f, -1.92836359e-01f,
  1.88007221e-01f, 6.03701584e-02f, 1.15390062e-01f, 1.58362314e-01f, -2.56940633e-01f, -1.45153582e-01f, -2.86203995e-02f, 1.15581810e-01f, 2.38685519e-01f, -1.63824819e-02f,
  -1.89754561e-01f, 6.33568019e-02f, -2.14733351e-02f, 8.93119373e-04f, -2.28899252e-02f, -1.33967951e-01f, 1.12659976e-01f, 1.85253426e-01f, -7.16254860e-03f, -2.16095001e-01f,
  2.19536901e-01f, 2.03626603e-01f, 3.01830117e-02f, 1.92079842e-01f, 1.30006634e-02f, 1.61869720e-01f, -6.45332411e-02f, 2.27138638e-01f, -4.53066975e-02f, -1.77779153e-03f,
  1.00994771e-02f, -9.89885703e-02f, -8.47216249e-02f, -2.03201566e-02f, -1.75620228e-01f, 2.90355593e-01f, 9.88705680e-02f, -9.84783918e-02f, 1.74655601e-01f, 1.93466529e-01f,
  8.19727555e-02f, 2.01297879e-01f, 4.27359641e-01f, -1.54843464e-01f, -1.90473914e-01f, 5.31980507e-02f, 1.65621698e-01f, 6.37540594e-02f, 1.15848303e-01f, 7.93259591e-02f,
  1.24461554e-01f, 1.23055652e-01f, 7.62162954e-02f, -8.73477161e-02f, 1.04510002e-01f, 9.10466090e-02f, -2.27504177e-03f, -3.21573704e-01f, 7.11555108e-02f, -1.26866642e-02f,
  -5.78864627e-02f, -6.15929291e-02f, -1.67818829e-01f, -2.42296919e-01f, 3.50506097e-01f, 1.08899280e-01f, 9.54686403e-02f, 2.18741730e-01f, -1.40118778e-01f, -5.94171928e-03f,
  -2.61913061e-01f, -2.81897467e-02f, 3.03913236e-01f, -1.57159641e-01f, -1.51651561e-01f, 6.04176633e-02f, 1.23243675e-01f, 1.78759009e-01f, -2.89122551e-03f, -1.66914701e-01f,
  1.00536339e-01f, 4.94625606e-02f, -3.65785360e-02f, -1.93292379e-01f, 2.43514627e-01f, 1.09425925e-01f, -1.73285771e-02f, 3.36525857e-01f, -2.78389566e-02f, -4.96661142e-02f,
  -3.70026641e-02f, -1.11309320e-01f, 2.33486623e-01f, 3.49000059e-02f, 3.26418012e-01f, -1.31667554e-01f, 8.59137028e-02f, 3.77882153e-01f, -1.03872262e-01f, 2.93394953e-01f,
  2.01343387e-01f, -1.69153377e-01f, 1.28316954e-01f, 2.41083547e-01f, 5.60598411e-02f, 7.67030120e-02f, 3.92920315e-01f, -5.93085065e-02f, 4.58302833e-02f, -1.58852309e-01f,
  7.30435625e-02f, 7.64924660e-02f, 1.46152601e-01f, 1.68528005e-01f, -7.82393850e-03f, -5.81861027e-02f, -7.38708824e-02f, -8.47306848e-03f, 1.95227787e-01f, 1.49800748e-01f,
  -2.17132363e-02f, 1.06983058e-01f, 1.66456208e-01f, -6.92662224e-02f, -6.74121454e-02f, -3.81297469e-02f, 1.50888711e-01f, -1.93248332e-01f, -8.66481066e-02f, 5.56509681e-02f,
  1.30133536e-02f, 1.40886515e-01f, 1.10030152e-01f, 1.74151301e-01f, -7.68521130e-02f, -1.21606663e-01f, 2.19564617e-01f, -6.71456978e-02f, 2.04670191e-01f, -1.95512478e-03f,
  -3.59635167e-02f, -1.72867160e-02f, 1.84278116e-01f, 3.19646955e-01f, -1.89396739e-01f, 1.71956271e-01f, -1.72044083e-01f, 4.76452634e-02f, -1.37909576e-01f, 5.82392290e-02f,
  -2.91443497e-01f, -1.84451938e-01f, 2.24441379e-01f, 3.64271291e-02f, 7.76560307e-02f, -8.52142870e-02f, -6.75270781e-02f, 1.92592710e-01f, 2.22897366e-01f, 7.25525916e-02f,
  -1.66964740e-01f, -2.65263945e-01f, -1.84793726e-01f, 8.33483189e-02f, 3.53125334e-02f, 1.59465075e-01f, 2.50558972e-01f, 6.68020323e-02f, 1.67822197e-01f, -4.41527292e-02f,
  1.36905015e-01f, -5.85680343e-02f, 8.95436183e-02f, 2.82313526e-01f, -1.22385003e-01f, 5.44857867e-02f, 3.21523007e-03f, -3.97910811e-02f, -4.20816056e-02f, 4.20003384e-02f,
  2.94504892e-02f, -9.02317911e-02f, 6.92217574e-02f, -7.18763769e-02f, 5.49597405e-02f, 1.13272138e-01f, -2.49605030e-02f, -4.27190885e-02f, 4.21872512e-02f, -6.78383633e-02f,
  5.66409118e-02f, 5.19094095e-02f, -1.70309022e-02f, 1.03202894e-01f, 1.03440806e-01f, 9.52185877e-03f, 3.22113112e-02f, 1.23428255e-02f, -1.16229169e-01f, 2.75928378e-02f,
  1.00199081e-01f, -7.68939108e-02f, -7.02047348e-02f, 7.68127292e-02f, -1.56548957e-03f, -1.32854253e-01f, -1.94547735e-02f, 7.71970600e-02f, -3.71419005e-02f, -5.06920367e-02f,
  -2.04531271e-02f, -6.45386875e-02f, -7.30283260e-02f, -4.94666547e-02f, 6.68483749e-02f, -4.88900989e-02f, 1.26294605e-02f, -9.01050940e-02f, 2.38637477e-02f, -6.22292757e-02f,
  9.23584700e-02f, -1.04067013e-01f, -1.09958574e-02f, -6.90976977e-02f, 4.91583720e-02f, -7.99079239e-02f, -1.17906049e-01f, 1.15641445e-01f, -1.12151705e-01f, 1.03039876e-01f,
  -1.14902608e-01f, 2.02776119e-02f, -3.54453572e-03f, -1.20676309e-01f, -1.27579093e-01f, -1.26161397e-01f, -1.36627853e-02f, 9.15409029e-02f, -1.09844893e-01f, 1.27113059e-01f,
  -4.96224798e-02f, 1.31570086e-01f, 3.65547612e-02f, 4.15346846e-02f, -2.82669812e-01f, -1.38732046e-01f, 1.40034944e-01f, 2.21858591e-01f, -1.76690742e-01f, 1.16718799e-01f,
  -2.47434929e-01f, 1.94359913e-01f, 2.23011479e-01f, 2.68447012e-01f, -1.43419459e-01f, 2.12408885e-01f, 6.48125857e-02f, -2.15419292e-01f, -4.87318598e-02f, 3.09597165e-03f,
  6.79459423e-02f, -2.46103212e-01f, 2.53891736e-01f, 2.35255331e-01f, 3.76316421e-02f, 6.94962218e-02f, 2.39155188e-01f, 1.26824500e-02f, 1.77740723e-01f, 1.13852531e-01f,
  2.93699149e-02f, -3.01078498e-01f, 1.68962792e-01f, 2.28509486e-01f, 5.50855361e-02f, 2.00177282e-01f, 2.18782440e-01f, -5.65883666e-02f, 4.88829240e-02f, 1.55605346e-01f,
  1.01664536e-01f, 1.73438519e-01f, -2.80757435e-03f, 1.02343693e-01f, 1.86260007e-02f, 1.59280345e-01f, -1.20889172e-01f, 4.42878231e-02f, -1.36232050e-03f, -1.71159670e-01f,
  3.22430223e-01f, 3.38449143e-02f, 1.10311568e-01f, 4.04272974e-02f, -1.54266044e-01f, -2.25645062e-02f, -2.14737728e-01f, 1.18787795e-01f, 1.00825988e-01f, -2.71588005e-02f,
  -1.64981961e-01f, -5.85710965e-02f, 6.30854294e-02f, 1.33924574e-01f, 1.82980718e-03f, -6.52522892e-02f, 2.71707267e-01f, 1.74909979e-01f, -1.15597792e-01f, 8.37959200e-02f,
  -1.41179547e-01f, 2.54982978e-01f, 1.44736201e-01f, 2.46156022e-01f, -6.98126107e-02f, -1.71158880e-01f, 1.30172148e-01f, -6.66142553e-02f, -1.11969955e-01f, -5.06424066e-03f,
  1.56427786e-01f, 1.22105792e-01f, -5.57077490e-02f, 1.73874840e-01f, 2.94416338e-01f, -1.10865377e-01f, -1.02068186e-01f, 2.28574853e-02f, 2.02388316e-01f, 2.42977530e-01f,
  4.48058322e-02f, 1.12434953e-01f, -1.26442127e-02f, 1.35161027e-01f, 3.02798986e-01f, -4.15393151e-03f, 3.84487025e-02f, 3.67602669e-02f, 2.36882210e-01f, -5.82542494e-02f,
  5.08257486e-02f, 2.64696509e-01f, -3.76515985e-02f, 1.64367795e-01f, 1.84981346e-01f, 1.70355767e-01f, 1.27245888e-01f, 1.25920326e-01f, 1.24746822e-01f, 3.14781994e-01f,
  1.75505280e-01f, -2.28976697e-01f, -1.48383165e-02f, 3.37702073e-02f, -8.28031451e-02f, 1.23860762e-01f, -1.23246968e-01f, -2.22467229e-01f, 8.27145204e-02f, 1.89087898e-01f,
  2.04210822e-02f, -6.23851940e-02f, 1.31517306e-01f, 9.93822142e-02f, 3.22150029e-02f, 3.67690623e-01f, -2.16188226e-02f, 1.48526147e-01f, 8.25573578e-02f, 1.60213411e-01f,
  -1.43707320e-01f, 1.38984054e-01f, 1.56096056e-01f, -2.09812179e-01f, 6.23652991e-03f, -9.31080505e-02f, -1.03600845e-01f, -1.45814821e-01f, 5.74670844e-02f, 2.37689853e-01f,
  1.12648480e-01f, 1.32987006e-02f, -1.48584649e-01f, -1.40000433e-02f, 1.22137450e-01f, 2.82952964e-01f, 2.69603848e-01f, -1.26853064e-01f, -4.02717829e-01f, 2.64519274e-01f,
  2.76345640e-01f, 1.65598437e-01f, -4.35058288e-02f, 1.57730773e-01f, -2.20770808e-03f, 1.98083352e-02f, 3.71314920e-02f, -2.14094728e-01f, -9.10866857e-02f, -5.55792637e-02f,
  1.34369463e-01f, 2.31465653e-01f, 1.29270032e-01f, -1.31649345e-01f, 1.92599356e-01f, 5.04877679e-02f, 1.72451019e-01f, 1.41181603e-01f, 2.37319574e-01f, -1.16153859e-01f,
  -2.22470611e-02f, -1.36879086e-02f, 2.53880054e-01f, -1.61856815e-01f, -4.21208963e-02f, 2.73145020e-01f, 1.54335216e-01f, -6.76795840e-02f, 7.41317272e-02f, 2.87781619e-02f,
  9.15709883e-02f, 2.95986712e-01f, 2.90253107e-02f, 2.01732755e-01f, 2.80511856e-01f, 2.10290328e-01f, -6.07754849e-03f, 2.64297780e-02f, 2.78132141e-01f, -3.25396985e-01f,
  9.90527570e-02f, -1.04966335e-01f, -1.22951575e-01f, -2.10820585e-01f, -8.37407708e-02f, -2.01170921e-01f, 5.18209375e-02f, -2.75414646e-01f, -3.30309093e-01f, 9.71944109e-02f,
  -7.33908117e-02f, -1.12691581e-01f, 1.06732599e-01f, 4.67830189e-02f, -1.19144753e-01f, -1.19138345e-01f, -1.57970220e-01f, 9.80682448e-02f, -5.85801713e-02f, 2.78559536e-01f,
  -8.31981227e-02f, -6.63207173e-02f, 2.65021384e-01f, 5.03140017e-02f, 7.43596628e-02f, -5.86922355e-02f, 1.78250056e-02f, 1.39652029e-01f, -1.71978652e-01f, 1.33276954e-01f,
  1.37293071e-01f, -5.98924533e-02f, 6.90658391e-02f, 1.25136107e-01f, 5.00184000e-02f, -5.47363944e-02f, 2.54008800e-01f, -3.81717719e-02f, -2.67886966e-02f, 2.34391302e-01f,
  1.30378790e-02f, -2.21516624e-01f, 8.63857940e-02f, 1.62115172e-01f, 1.57258183e-01f, -6.16645440e-02f, 1.62383597e-02f, -7.98471645e-02f, 1.32440120e-01f, 1.35844409e-01f,
  1.02068270e-02f, 1.80354759e-01f, -1.99961871e-01f, -5.61150610e-02f, -6.18801452e-02f, 2.23444533e-02f, -2.30693165e-02f, 1.01722039e-01f, 1.48741612e-02f, -3.01962439e-02f,
  -3.84976855e-03f, 2.31688414e-02f, 2.08706811e-01f, -6.58073574e-02f, 3.92736495e-02f, -8.76338407e-02f, -5.83170988e-02f, 1.49725810e-01f, 6.27696812e-02f, 4.45022173e-02f,
  1.87492490e-01f, 9.77831408e-02f, -2.58575141e-01f, -6.78568706e-02f, -5.61300404e-02f, 2.04594761e-01f, 2.12097038e-02f, 1.69908956e-01f, 2.98478156e-01f, -3.02724838e-02f,
  -1.03610247e-01f, -3.30865942e-02f, -1.14204831e-01f, 1.90510154e-01f, 9.42751765e-02f, -1.04432739e-01f, 2.07789510e-01f, 7.84418061e-02f, 1.14603065e-01f, 1.95964128e-01f,
  -2.98817009e-01f, 1.09201387e-01f, 6.82580471e-02f, 2.00672075e-01f, 1.15094997e-01f, 2.14612603e-01f, 2.58510262e-02f, -8.87037292e-02f, 1.56455144e-01f, -2.89285667e-02f,
  7.48233348e-02f, -1.50577994e-02f, 2.55548209e-01f, 9.66705829e-02f, -6.84967861e-02f, -8.35222774e-04f, -7.46096373e-02f, 1.57273971e-04f, 1.21640414e-01f, 6.96878210e-02f,
  2.09063649e-01f, -6.55007511e-02f, 1.58119518e-02f, 2.87323296e-01f, 1.33663163e-01f, -1.13135632e-02f, 1.70588717e-01f, -1.24381334e-01f, 2.61687674e-02f, 8.83844495e-02f,
  -1.76614851e-01f, 2.96416152e-02f, 1.99413881e-01f, 1.87488243e-01f, -2.08841518e-01f, -1.02859795e-01f, 1.88543886e-01f, 6.16819672e-02f, 2.43039668e-01f, -1.12216718e-01f,
  5.86505458e-02f, 2.87584066e-01f, 1.69841409e-01f, -8.63085762e-02f, -1.20393328e-01f, 4.44587499e-01f, 6.96100831e-01f, -4.23097551e-01f, -8.25800409e-04f, 1.30506298e-02f,
  2.82491386e-01f, -3.91317248e-01f, 1.03200629e-01f, 4.06131931e-02f, 1.45306975e-01f, -6.04982227e-02f, 1.65506467e-01f, 1.08294100e-01f, 2.35422030e-01f, 1.62615046e-01f,
  1.13971047e-02f, 1.17553331e-01f, 2.79720742e-02f, -1.46160543e-01f, -7.44974136e-01f, 1.24935955e-01f, -6.31582811e-02f, -1.43913344e-01f, -4.54885781e-01f, 3.14543545e-02f,
  2.24020965e-02f, 1.56470403e-01f, 1.32867888e-01f, -3.34916323e-01f, -1.49704605e-01f, -4.65478301e-02f, 2.09657192e-01f, -7.77841657e-02f, 7.83769861e-02f, 2.57117093e-01f,
  -2.45304272e-01f, -3.46139550e-01f, -3.04418802e-01f, 2.26654574e-01f, -1.61333546e-01f, -3.04797292e-02f, -4.38611954e-01f, -1.40418619e-01f, 1.88886568e-01f, 3.65025848e-01f,
  2.21216813e-01f, 7.95444399e-02f, 1.99160621e-01f, -6.08014800e-02f, 1.57070115e-01f, -3.59913677e-01f, 2.76795834e-01f, 1.88183725e-01f, -3.06908842e-02f, 7.50512332e-02f,
  -1.54663667e-01f, 1.30122498e-01f, -2.12992176e-01f, 5.27007394e-02f, -9.01107024e-03f, -1.61387697e-01f, -6.60592318e-03f, 5.95349707e-02f, -1.69849116e-02f, -9.35083777e-02f,
  -9.01413187e-02f, 2.14091361e-01f, 6.86587254e-03f, 1.23393819e-01f, 1.20998107e-01f, -1.27957305e-02f, -1.29972562e-01f, 1.55814245e-01f, 1.23387724e-01f, 2.09937230e-01f,
  -8.76983162e-03f, -2.21882433e-01f, -7.15445653e-02f, 1.90936580e-01f, 3.72002304e-01f, -2.44105910e-03f, 1.68241933e-01f, 1.21770576e-01f, 3.01259123e-02f, 7.36937821e-02f,
  3.64527362e-03f, 1.83031157e-01f, 6.93279505e-02f, 1.78806201e-01f, 7.72222653e-02f, 1.10852450e-01f, -1.07412204e-01f, -2.90006306e-02f, 2.36549392e-01f, 1.91311866e-01f,
  -2.67392069e-01f, 4.40283939e-02f, -9.08151269e-02f, -1.80709571e-01f, 7.63362646e-02f, 2.88358092e-01f, 5.95818739e-04f, -5.36959730e-02f, -1.96048781e-01f, 2.75563240e-01f,
  -5.27345613e-02f, -1.93349808e-01f, 1.78749803e-02f, -3.79934758e-01f, 1.25366107e-01f, 5.92697263e-02f, -2.12003887e-02f, -1.23199798e-01f, -9.06348526e-02f, 8.74917060e-02f,
  -2.15943083e-01f, -2.94794887e-01f, -7.70857930e-02f, -2.44970135e-02f, 1.27434004e-02f, 1.45529568e-01f, -1.62092209e-01f, -2.76562333e-01f, -1.86761126e-01f, 1.63772441e-02f,
  -1.65793270e-01f, -2.23630369e-02f, 2.79240012e-01f, -3.58754806e-02f, -2.04737872e-01f, -2.36287951e-01f, 1.51095212e-01f, -8.70106667e-02f, 1.72139958e-01f, 8.03674385e-02f,
  1.28986999e-01f, 1.08047292e-01f, 4.60047498e-02f, 2.81522185e-01f, -1.98606148e-01f, 1.91120714e-01f, -3.09247337e-03f, -2.50469029e-01f, -1.66609958e-01f, 7.67038614e-02f,
  4.23706025e-02f, 3.54986894e-03f, -1.68565154e-01f, -2.74368167e-01f, -6.24245107e-02f, -1.93623826e-02f, 1.23559013e-01f, 1.26106381e-01f, 1.00653887e-01f, -4.88985777e-02f,
  5.43686654e-03f, -1.44317374e-01f, 2.33553395e-01f, 6.91583753e-02f, -1.83137450e-02f, 1.46923423e-01f, 3.31240565e-01f, -3.13808739e-01f, -5.33025898e-03f, -1.89236253e-02f,
  2.45043725e-01f, -8.78267288e-02f, 8.81953984e-02f, -2.70775408e-01f, 1.23421192e-01f, 1.83197156e-01f, 1.74924269e-01f, 4.63996351e-01f, 2.99317203e-02f, -1.65547714e-01f,
  -9.96626168e-02f, -1.60085917e-01f, 1.79015808e-02f, 5.84187135e-02f, 1.15846425e-01f, 4.09939736e-02f, -2.55616337e-01f, 1.66435868e-01f, 3.99818301e-01f, -5.26070520e-02f,
  1.94221780e-01f, -1.37870520e-01f, -9.16264579e-02f, 3.91908027e-02f, 8.73989463e-02f, 4.11684550e-02f, 2.84999102e-01f, 1.42256826e-01f, -7.88095742e-02f, 2.72165947e-02f,
  1.42808417e-02f, -1.51610404e-01f, 4.40857559e-01f, -5.78107424e-02f, 1.84771866e-01f, -2.81779110e-01f, -1.58091486e-01f, -4.24228340e-01f, -1.37228951e-01f, 6.09319389e-01f,
  1.92932114e-01f, -1.05449006e-01f, 1.04209848e-01f, 5.81245303e-01f, -2.14148704e-02f, -6.69491112e-01f, 4.31756154e-02f, 1.52784094e-01f, -1.23806506e-01f, -1.82607129e-01f,
  -3.31502050e-01f, 2.54537463e-02f, -3.06636572e-01f, 5.58038473e-01f, -1.77273899e-01f, 2.70888805e-02f, -4.69865203e-01f, -3.05190712e-01f, 1.51000157e-01f, 2.59055287e-01f,
  -2.85215154e-02f, -2.48755410e-01f, 2.62156755e-01f, -2.42444471e-01f, -2.56533269e-02f, 3.66189867e-01f, 1.10152118e-01f, -1.62545756e-01f, -1.06648579e-01f, 1.07618935e-01f,
  -1.22650668e-01f, -4.36002016e-01f, -2.99846053e-01f, 1.15582608e-02f, 2.61524618e-01f, 4.46618408e-01f, 2.35156938e-01f, 1.30288914e-01f, 5.65943480e-01f, 1.93070516e-01f,
  1.98665559e-01f, -1.65532961e-01f, 5.39816260e-01f, -3.24364007e-02f, 1.41491130e-01f, 1.50918618e-01f, 1.98806170e-03f, 8.46563876e-02f, -5.43307588e-02f, 1.33454397e-01f,
  1.29963979e-01f, -6.24685995e-02f, -2.78224833e-02f, 1.92700014e-01f, -1.39111891e-01f, -8.21877941e-02f, 2.36119300e-01f, 1.77644774e-01f, 1.64384291e-01f, -4.83325869e-02f,
  -2.25217804e-01f, -2.91982472e-01f, 8.77178162e-02f, 3.16598266e-01f, -1.68978388e-03f, -3.82654183e-02f, -1.28885970e-01f, 6.95720240e-02f, -7.86285773e-02f, -1.45811006e-01f,
  1.65197924e-01f, 1.74947664e-01f, -2.11334243e-01f, 1.60906874e-02f, 6.83365539e-02f, -3.94477695e-02f, -1.72789544e-01f, 1.12771921e-01f, -9.59228650e-02f, 1.49011791e-01f,
  -2.44839974e-02f, -2.17038020e-01f, 2.15997770e-01f, 2.31762812e-01f, -8.55048839e-03f, 4.97754887e-02f, 2.49029785e-01f, 1.45525545e-01f, -1.21039972e-01f, 5.34417778e-02f,
  2.34225273e-01f, 9.49600115e-02f, 2.21931323e-01f, 6.03400655e-02f, -5.09875305e-02f, -1.02781683e-01f, -1.36383235e-01f, 6.79483712e-02f, 4.82470281e-02f, 1.44132212e-01f,
  1.97029203e-01f, 2.02507675e-01f, 3.46373796e-01f, 1.99856892e-01f, 8.53159055e-02f, -1.86275944e-01f, 4.32026796e-02f, -1.62486240e-01f, 6.08242676e-02f, 5.18538542e-02f,
  -2.99703628e-02f, 7.56111443e-02f, 1.45667806e-01f, -4.23405766e-02f, -2.37870105e-02f, 1.14721350e-01f, 2.32771948e-01f, 1.41065016e-01f, 1.27863780e-01f, 1.20664783e-01f,
  1.23190418e-01f, -1.98860615e-01f, -7.95131549e-03f, 2.71277577e-01f, 1.60609543e-01f, 1.71261728e-01f, 4.56941314e-02f, -1.32854581e-01f, -1.20835073e-01f, 2.05997333e-01f,
  1.44666225e-01f, 2.57440228e-02f, 6.16446100e-02f, -2.24154755e-01f, -1.51575759e-01f, 5.66810332e-02f, 1.13268904e-01f, 5.03257066e-02f, -6.00810070e-03f, 1.04433574e-01f,
  2.83136845e-01f, 1.89132631e-01f, 2.18850762e-01f, -1.07756123e-01f, -1.90623861e-03f, 2.07947850e-01f, -3.45640667e-02f, -1.19802862e-01f, 8.73160139e-02f, 1.89918369e-01f,
  -1.11759277e-02f, -1.97434649e-01f, 1.68869272e-01f, 2.18271375e-01f, -9.97949243e-02f, 2.63990220e-02f, 1.27851851e-02f, -1.95933685e-01f, 1.92557678e-01f, -1.74174048e-02f,
  1.87501147e-01f, 8.06385502e-02f, -3.35488771e-03f, -5.88870049e-02f, 2.00659409e-01f, -1.44697845e-01f, -5.69798090e-02f, -6.00078665e-02f, 8.63608345e-02f, 3.26576620e-01f,
  5.59876114e-02f, 1.31559700e-01f, 1.91474780e-01f, 1.56610474e-01f, -1.67245809e-02f, 1.75102204e-01f, 2.21260488e-01f, 4.15713675e-02f, -2.34878168e-01f, 4.17481288e-02f,
  -5.33012412e-02f, 2.10523069e-01f, 4.58245762e-02f, 2.04964653e-01f, -2.14785282e-02f, -1.35922924e-01f, -5.88728599e-02f, 2.61516243e-01f, 1.55708507e-01f, 2.86950141e-01f,
  1.74464926e-01f, -7.94778168e-02f, -2.38605216e-02f, 2.96493798e-01f, 3.23143333e-01f, -1.99693799e-01f, 7.73520544e-02f, 2.49350846e-01f, 1.68510541e-01f, -1.93736255e-02f,
  2.69657914e-02f, 1.84181631e-01f, -5.13774948e-03f, -1.54244481e-02f, 3.11541408e-01f, -1.00916393e-01f, 2.60949194e-01f, 7.91694000e-02f, 1.44573987e-01f, 1.43126234e-01f,
  1.66969016e-01f, 3.23478818e-01f, 1.33165538e-01f, 2.68676490e-01f, 1.71267539e-01f, 1.28680468e-01f, 2.03873545e-01f, 2.03378052e-01f, 1.01656735e-01f, 2.85955161e-01f,
  1.75864249e-01f, -2.24484086e-01f, 2.25761726e-01f, -7.29119033e-02f, 8.94211754e-02f, 2.40132153e-01f, 8.45252443e-03f, -7.69012123e-02f, 9.45217982e-02f, 1.09947398e-01f,
  -1.23166427e-01f, -1.19198039e-02f, 8.67312998e-02f, 2.31439203e-01f, -7.36248046e-02f, 2.64162481e-01f, 1.03651270e-01f, -2.91741956e-02f, -1.06413856e-01f, -8.46673101e-02f,
  2.05450654e-01f, 1.11420006e-01f, 1.55811712e-01f, 3.59526217e-01f, 2.79851973e-01f, -8.11144859e-02f, -1.50576830e-01f, 6.09135106e-02f, 4.85068299e-02f, -2.04630241e-01f,
  -7.71238934e-03f, 6.81326538e-02f, 2.06130999e-03f, -1.69680148e-01f, 2.79061675e-01f, 9.94573012e-02f, 4.54915278e-02f, 2.36937981e-02f, -6.27108663e-02f, 3.29410881e-02f,
  -1.86897874e-01f, -1.23717777e-01f, 6.39931709e-02f, 3.71537451e-03f, -4.47685793e-02f, -2.54021436e-02f, -1.12804152e-01f, 2.29894727e-01f, 6.36118352e-02f, 3.80296484e-02f,
  3.72214951e-02f, -8.29380527e-02f, 5.34889847e-02f, 1.34373382e-01f, 1.89742088e-01f, -2.76854765e-02f, -1.53268546e-01f, 2.89913327e-01f, 9.26029235e-02f, -4.12417166e-02f,
  -8.23681727e-02f, 5.50143123e-02f, 1.40588880e-01f, -1.06410496e-02f, -9.80646983e-02f, -7.30872601e-02f, 6.68469742e-02f, 1.11550212e-01f, 7.10102916e-02f, 1.82853103e-01f,
  1.23539105e-01f, -2.26257928e-03f, 1.62736490e-01f, 1.02155574e-01f, 1.62187070e-01f, 1.84334232e-03f, 1.98491618e-01f, 7.25278854e-02f, -1.06367946e-03f, 6.51119556e-03f,
  2.65304353e-02f, -4.44634892e-02f, -5.62722497e-02f, -6.67640865e-02f, -2.26190537e-02f, -1.34702906e-01f, -5.95905073e-03f, -8.78275745e-03f, -8.83477032e-02f, -1.67481843e-02f,
  -7.70557392e-03f, -6.10995339e-03f, -2.62459293e-02f, 8.51041973e-02f, -7.89342597e-02f, -6.12437129e-02f, 2.61875242e-03f, 7.51993060e-02f, -1.14518078e-02f, -7.69935399e-02f,
  -6.69176728e-02f, 8.05568397e-02f, 3.85552645e-02f, 4.36371565e-02f, -8.03625584e-02f, -1.01311594e-01f, -1.68679394e-02f, -8.89765471e-02f, -7.25696534e-02f, -1.09036103e-01f,
  1.47900851e-02f, 9.05143619e-02f, -6.92808479e-02f, 7.10064992e-02f, -5.66364639e-02f, -1.16772316e-01f, -3.96774597e-02f, -8.54209512e-02f, -8.09304118e-02f, -1.00898571e-01f,
  7.84186944e-02f, 5.15287891e-02f, -4.38364781e-02f, 8.11969265e-02f, -1.28521994e-01f, -9.46238860e-02f, 2.56123785e-02f, 4.70239446e-02f, 3.13165151e-02f, -7.55552202e-02f,
  -1.20189801e-01f, 4.79395688e-03f, -7.39172101e-02f, 1.06641382e-01f, 2.96815950e-02f, 1.13141701e-01f, -1.51593136e-02f, -6.98480830e-02f, -1.09832644e-01f, -8.75415504e-02f,
  2.22889595e-02f, 9.23513398e-02f, 4.17980254e-02f, -1.59572680e-02f, -8.26527402e-02f, 1.58419069e-02f, 7.08536282e-02f, -1.14927061e-01f, -4.60978523e-02f, -1.43486679e-01f,
  -1.27789393e-01f, -2.50321090e-01f, -3.72446775e-01f, 1.57431856e-01f, -1.16797574e-01f, -6.18937947e-02f, 1.08907491e-01f, 9.22395587e-02f, 4.10927385e-02f, 1.68184265e-01f,
  -1.18871935e-01f, 2.11206198e-01f, -1.83932051e-01f, 1.60194844e-01f, -1.06290132e-01f, 9.55313593e-02f, 2.22919375e-01f, -1.28918767e-01f, 2.90470749e-01f, 1.25131801e-01f,
  1.06558144e-01f, 4.18115288e-01f, -9.36780050e-02f, 1.03242444e-02f, 1.94263801e-01f, -1.53282816e-02f, 2.51800299e-01f, -2.72200610e-02f, -3.56356949e-02f, 2.24865705e-01f,
  6.86194152e-02f, -1.01904124e-01f, -8.15394223e-02f, 1.15135379e-01f, 1.02406345e-01f, -1.13486975e-01f, 2.12323979e-01f, 2.36738920e-01f, 1.94893897e-01f, -1.17230695e-02f,
  -3.09316944e-02f, 1.24856889e-01f, -6.50381148e-02f, 3.14831212e-02f, -1.37360707e-01f, -3.02944124e-01f, -1.91729772e-03f, 6.60405159e-02f, 8.29296038e-02f, 1.75430954e-01f,
  -2.33418167e-01f, 1.07348152e-01f, 7.33925402e-03f, -1.15271630e-02f, -1.58832505e-01f, -2.32150733e-01f, 1.14299990e-01f, 2.99663395e-01f, 1.88615963e-01f, 1.42420515e-01f,
  8.55397359e-02f, -2.22043060e-02f, 6.91178441e-02f, -3.14120278e-02f, -2.14147717e-01f, 1.20555401e-01f, 1.25731498e-01f, 2.35571396e-02f, -6.63027540e-02f, 2.82670110e-01f,
  1.92359120e-01f, -2.33413070e-01f, -1.15424260e-01f, 1.78962484e-01f, 2.34258309e-01f, -6.22599386e-02f, 1.55407060e-02f, 7.10058361e-02f, -2.13849008e-01f, 2.96402164e-02f,
  2.65918374e-01f, -1.60719473e-02f, 1.86946318e-02f, -2.55451649e-01f, -6.93760999e-03f, 1.44660920e-01f, 2.52646267e-01f, 9.94855911e-02f, -2.22692356e-01f, 1.24277361e-01f,
  1.47797003e-01f, 3.15484703e-01f, 9.45319980e-02f, -3.60436225e-03f, -1.12791069e-01f, 3.13712627e-01f, -6.96313828e-02f, 7.48216212e-02f, -5.97681552e-02f, -7.26852119e-02f,
  8.87900367e-02f, 2.00562216e-02f, -2.97108255e-02f, 1.28536165e-01f, -1.20563924e-01f, -6.16090256e-04f, 2.63719801e-02f, -5.87056875e-02f, 1.94848791e-01f, 1.46111012e-01f,
  -2.50793174e-02f, 1.56703994e-01f, 2.81044766e-02f, 5.46538383e-02f, 1.51118040e-01f, -1.45613238e-01f, 4.01969962e-02f, -2.01618001e-01f, -1.00692935e-01f, 2.31395498e-01f,
  -7.87963569e-02f, 1.48394451e-01f, 4.56061214e-02f, -1.06491983e-01f, -8.06797892e-02f, -1.21496275e-01f, 6.37830049e-02f, 3.18913162e-02f, -4.22538370e-02f, 1.11741826e-01f,
  2.32927799e-02f, -1.09499693e-02f, 6.39980882e-02f, 5.90046495e-02f, -8.40774775e-02f, -4.25136834e-02f, 1.87695175e-02f, -1.18289039e-01f, 8.21785182e-02f, -4.00458127e-02f,
  -1.13610327e-01f, 1.23206541e-01f, 4.20430601e-02f, -4.69986796e-02f, 5.40181696e-02f, 2.41719931e-02f, -9.51737463e-02f, -1.63555145e-03f, -3.04281414e-02f, 7.62373209e-04f,
  2.21129805e-02f, -4.88774329e-02f, 3.27762216e-02f, 1.41694844e-02f, -1.03402764e-01f, -9.18635428e-02f, -1.11065194e-01f, -7.63409287e-02f, -1.52457058e-02f, 9.97019857e-02f,
  -1.93194151e-02f, -1.58161819e-02f, -9.99215990e-02f, -3.95856053e-02f, -6.74300045e-02f, -8.02229196e-02f, -9.39835608e-03f, -2.26009637e-02f, 7.71292746e-02f, -5.35321385e-02f,
  4.64307964e-02f, -1.04151860e-01f, 1.57252550e-02f, -6.61508143e-02f, -5.40212840e-02f, -1.19132340e-01f, 5.77623397e-02f, 9.16050076e-02f, 1.98107958e-03f, -1.04325622e-01f,
  9.56058502e-05f, 6.59957081e-02f, 3.44523638e-02f, 1.63446814e-02f, -1.02479339e-01f, 9.91508216e-02f, 1.14024349e-01f, 1.65333092e-01f, 2.01860815e-01f, 5.07794842e-02f,
  3.07757650e-02f, -6.11504614e-02f, -1.64588526e-01f, -2.30822489e-01f, 1.63589772e-02f, -8.57393369e-02f, -9.74962264e-02f, 1.23510420e-01f, -1.83524236e-01f, 1.28540307e-01f,
  1.20514333e-01f, -1.20354272e-01f, 3.96111272e-02f, 8.25859681e-02f, 2.23620877e-01f, -1.70310557e-01f, 8.63534585e-02f, -8.14943686e-02f, -1.34629846e-01f, 3.44261900e-02f,
  1.79135595e-02f, 1.31108031e-01f, 1.98734134e-01f, -1.68825686e-02f, 4.18833792e-02f, 4.76981327e-02f, 1.81382596e-01f, 7.10799098e-02f, -1.83582846e-02f, -2.16638997e-01f,
  4.61979248e-02f, 1.49139166e-01f, -2.14140043e-02f, -6.85666129e-02f, 7.37128481e-02f, 2.47623056e-01f, -1.25514716e-01f, 7.36262426e-02f, -1.00141436e-01f, 9.52587500e-02f,
  1.24575160e-01f, -3.88670266e-02f, 1.93518952e-01f, 5.41407913e-02f, 1.64404079e-01f, 7.44810142e-03f, 2.66754888e-02f, 6.25219643e-01f, 1.27199829e-01f, -5.46474047e-02f,
  -1.03513122e-01f, -9.63248312e-02f, -1.75909877e-01f, 1.39689848e-01f, 5.49646048e-03f, -6.07981645e-02f, 3.04214627e-01f, -1.37153894e-01f, -1.05251342e-01f, -1.61110818e-01f,
  1.78926542e-01f, 1.51926562e-01f, -9.36893467e-03f, 1.46831632e-01f, 1.26200512e-01f, 9.49200541e-02f, -3.57782930e-01f, 2.67407954e-01f, 2.69886971e-01f, 8.05814750e-03f,
  -1.36351794e-01f, 2.88557321e-01f, 6.03077114e-02f, -9.85650718e-02f, 2.32294165e-02f, 2.81419575e-01f, 2.11762965e-01f, 1.42550528e-01f, 8.66838917e-02f, -4.19864133e-02f,
  -5.11304336e-03f, 2.69364953e-01f, 2.48202518e-01f, 3.01091578e-02f, -1.15879532e-02f, 8.13329890e-02f, 4.55811955e-02f, 2.41771340e-01f, 8.73155072e-02f, -8.28122497e-02f,
  -1.38549119e-01f, 6.74007386e-02f, 1.37506396e-01f, 1.39323780e-02f, 7.13220015e-02f, 1.04970232e-01f, -4.89530712e-02f, 9.53829885e-02f, -1.09932303e-01f, -9.15971547e-02f,
  -1.22154370e-01f, 1.41756162e-01f, -1.15627032e-02f, 1.09747738e-01f, 3.23234536e-02f, 7.89294466e-02f, 2.42900327e-02f, 2.43280128e-01f, -1.72412530e-01f, 1.89523455e-02f,
  5.87380938e-02f, -6.98630288e-02f, 1.56280011e-01f, 9.19751674e-02f, 2.08491236e-01f, 9.70720500e-02f, 1.12045445e-01f, -2.55144089e-01f, -3.43725383e-02f, -8.28990638e-02f,
  -6.94692880e-02f, 1.09349638e-01f, -1.34029195e-01f, 2.71192104e-01f, -9.42042843e-02f, 1.46602258e-01f, 2.81014144e-02f, 8.09145272e-02f, 8.46399367e-02f, 2.36994233e-02f,
  -2.32835300e-02f, 1.93148091e-01f, 1.15221456e-01f, 1.72616482e-01f, 3.29009295e-02f, 6.97336495e-02f, 9.79129821e-02f, -2.04314634e-01f, 1.29844531e-01f, -6.09867275e-02f,
  -4.75584790e-02f, -1.12825753e-02f, 1.24115869e-01f, 6.68196306e-02f, -7.55111128e-02f, 2.64965802e-01f, 2.54097015e-01f, -2.98691448e-02f, -7.63878003e-02f, -1.35402590e-01f,
  1.15024067e-01f, 1.95277378e-01f, -4.46179509e-02f, 2.03003213e-01f, -9.73631367e-02f, 1.67502373e-01f, 3.58655117e-02f, 4.33795452e-02f, 6.56045452e-02f, -1.52372360e-01f,
  1.28235340e-01f, 8.37037489e-02f, 6.59747347e-02f, 2.28513390e-01f, -2.22334713e-01f, 1.35652842e-02f, 1.44032434e-01f, 1.92368329e-01f, -1.15941074e-02f, -3.94657291e-02f,
  -2.47780252e-02f, 2.73264855e-01f, 1.91781878e-01f, -2.33931735e-01f, 6.94998354e-02f, 2.71066353e-02f, -3.76669019e-02f, 2.14471444e-01f, -3.43952253e-02f, -1.94085211e-01f,
  2.57670462e-01f, 1.67640641e-01f, 1.65075630e-01f, -1.25261098e-01f, 7.05871657e-02f, -5.76381683e-02f, 1.81969963e-02f, 3.48942757e-01f, 7.41415918e-02f, -4.22978476e-02f,
  1.17915906e-02f, 9.76764038e-02f, -6.86613992e-02f, 7.14919120e-02f, 2.12653890e-01f, -3.00164502e-02f, 1.86540082e-01f, -2.32604161e-01f, -2.45001540e-01f, -1.15853526e-01f,
  3.01826626e-01f, 1.94724321e-01f, 1.79057717e-01f, -5.83779141e-02f, 1.14370964e-01f, -1.00592799e-01f, -4.77948822e-02f, 3.90781164e-01f, 3.33520383e-01f, -8.73764083e-02f,
  -1.85219437e-01f, 3.30067456e-01f, 2.15289444e-01f, 5.65941855e-02f, -1.98619694e-01f, -1.88926421e-02f, -1.70775056e-01f, -1.13906292e-03f, -6.87708780e-02f, 2.25785864e-03f,
  -2.06342191e-02f, 2.62171507e-01f, 2.00499162e-01f, 1.34064510e-01f, 1.20506287e-01f, -8.39069337e-02f, 2.73800224e-01f, 5.65975457e-02f, 2.27760077e-01f, 1.27084866e-01f,
  1.20589331e-01f, -1.65675640e-01f, -1.46042004e-01f, 3.39194328e-01f, 1.44817486e-01f, -1.66138306e-01f, -1.16883263e-01f, 2.33349770e-01f, 1.72709346e-01f, 2.35307470e-01f,
  -1.64662153e-02f, 2.77742408e-02f, 4.47688252e-02f, 1.01420462e-01f, 1.93099335e-01f, 1.94526613e-01f, 3.32889974e-01f, 2.62737870e-01f, -1.15139782e-01f, -7.78586417e-02f,
  3.57642084e-01f, -1.33662105e-01f, 1.48996934e-01f, 9.65437293e-02f, 1.51907846e-01f, 1.00863818e-02f, -4.57561621e-03f, 9.22220275e-02f, 2.58537769e-01f, 1.38384938e-01f,
  2.52316475e-01f, 1.90986872e-01f, -2.35494047e-01f, -3.76379080e-02f, 1.84774488e-01f, -8.71358290e-02f, 6.42924160e-02f, 1.32818567e-02f, 1.00167818e-01f, -1.04049452e-01f,
  -1.58029255e-02f, 1.58377647e-01f, -6.24676608e-02f, -1.35463491e-01f, 5.32191657e-02f, 2.99888372e-01f, -8.10717493e-02f, -2.85507888e-01f, 1.56523287e-01f, 2.41406024e-01f,
  7.35329986e-02f, 1.81474704e-02f, -1.53974041e-01f, -1.76980672e-03f, -2.28526387e-02f, 2.70759523e-01f, -1.58138067e-01f, 2.67354786e-01f, -2.01084882e-01f, 1.27460137e-02f,
  3.25213782e-02f, -1.86400801e-01f, -1.75276220e-01f, -1.11700617e-01f, 2.11856231e-01f, -2.72466373e-02f, -2.08603893e-03f, 1.27084494e-01f, -5.28757013e-02f, 9.56507772e-02f,
  -2.22865611e-01f, 2.38668010e-01f, -1.01327956e-01f, -1.68702289e-01f, -5.20748310e-02f, -1.30692631e-01f, 3.17999840e-01f, 2.00809225e-01f, 2.16979459e-01f, -1.95687562e-02f,
  3.19897950e-01f, 2.32398331e-01f, 8.24142098e-02f, -8.92672390e-02f, 4.33959290e-02f, -8.25005621e-02f, -9.30676237e-03f, -9.06577483e-02f, -7.52887726e-02f, -9.78927314e-02f,
  3.91054749e-02f, 1.09990910e-01f, -4.15610783e-02f, 4.89026587e-03f, -1.83077045e-02f, -1.00736067e-01f, 8.21334422e-02f, 2.72573368e-03f, 5.43949604e-02f, 7.92870522e-02f,
  2.52484623e-02f, 9.20245647e-02f, -4.85474691e-02f, -5.81202433e-02f, -9.76132900e-02f, -8.33941400e-02f, 1.61843468e-02f, -3.14451642e-02f, 1.02444604e-01f, -1.34867674e-03f,
  -8.52632299e-02f, -2.99397539e-02f, -2.07623839e-03f, -1.24568239e-01f, 2.67103836e-02f, -1.14017546e-01f, 9.47670192e-02f, -7.16215977e-03f, -5.55283874e-02f, 3.00530251e-02f,
  5.06634600e-02f, -1.16892375e-01f, 6.26397878e-02f, -1.15848966e-01f, 4.46895659e-02f, -1.18552893e-01f, -5.67559004e-02f, 9.01994109e-02f, -5.03989346e-02f, 6.38922155e-02f,
  3.10686808e-02f, 5.89075014e-02f, 5.20247072e-02f, 7.07434416e-02f, -1.19554400e-01f, -4.76087295e-02f, -4.71329316e-02f, 1.91984922e-02f, -4.82796393e-02f, -4.12648916e-03f,
  5.10130040e-02f, 6.31979704e-02f, -9.61935371e-02f, 3.64765227e-02f, -2.48091295e-02f, -9.05851722e-02f, -2.54840851e-02f, -4.73701255e-03f, 1.83748752e-02f, 6.85833395e-03f,
  -1.07827812e-01f, 8.21576640e-02f, 9.91104096e-02f, -1.14000462e-01f, -9.93188396e-02f, -6.93254098e-02f, 4.27091569e-02f, 5.44659086e-02f, 3.41313984e-03f, -1.09620757e-01f,
  3.03274505e-02f, 5.97529337e-02f, -2.25108974e-02f, -7.78852180e-02f, -7.67364204e-02f, 1.93799008e-02f, -8.42907652e-02f, 5.93277812e-03f, -1.04299895e-01f, -1.16024494e-01f,
  -8.56871009e-02f, 3.67052592e-02f, -7.89742470e-02f, -5.92903085e-02f, 1.07869834e-01f, -6.35214373e-02f, 1.01828858e-01f, 9.40065831e-02f, 2.48980708e-03f, 3.23868468e-02f,
  6.76799268e-02f, -2.66438648e-02f, 3.85393277e-02f, -1.29131019e-01f, -9.36916694e-02f, -2.19512619e-02f, -5.45551553e-02f, -5.71068935e-02f, -1.36263132e-01f, -3.45372260e-02f,
  5.36103882e-02f, -1.11087427e-01f, 9.75460783e-02f, -1.39545709e-01f, 5.41544519e-03f, 1.05395630e-01f, -9.48198959e-02f, -9.67668667e-02f, 3.11159603e-02f, 3.64772379e-02f,
  -4.60675284e-02f, 1.01154380e-01f, -8.76943320e-02f, -8.35246518e-02f, 9.48670134e-02f, -8.11229795e-02f, 2.68477984e-02f, 3.10465060e-02f, -2.94424295e-02f, 1.01457082e-01f,
  4.44136560e-02f, 1.11132078e-01f, 8.34328234e-02f, -1.45921800e-02f, 4.03246097e-02f, 5.59653249e-03f, -6.22248277e-02f, -1.08018965e-01f, 5.24652712e-02f, 2.85564512e-02f,
  6.71599358e-02f, 1.07531130e-01f, -7.88733736e-02f, -4.70993333e-02f, 1.25993758e-01f, 3.38467839e-03f, 7.73920789e-02f, -7.14860260e-02f, 8.14726949e-02f, 6.84732795e-02f,
  -1.08613357e-01f, -4.75400724e-02f, -3.52061004e-03f, -6.98944693e-03f, 2.59794928e-02f, -1.37116399e-03f, -4.74203452e-02f, 2.86531914e-02f, -1.02198169e-01f, -3.26453932e-02f,
  1.76165607e-02f, 1.47698792e-02f, 4.63567078e-02f, -7.14321509e-02f, -1.04058757e-01f, -1.77481622e-02f, -1.23513006e-01f, -1.24671437e-01f, 3.25483829e-02f, -1.47621587e-01f,
  -7.86679760e-02f, 4.17491309e-02f, 8.27328190e-02f, -7.15522468e-02f, -1.11601926e-01f, -1.45912781e-01f, -1.08307503e-01f, 5.46893897e-03f, -1.25512823e-01f, 1.08149899e-02f,
  -6.80582598e-02f, 3.09093352e-02f, 1.12014621e-01f, -3.85993309e-02f, -7.49548674e-02f, -6.49950132e-02f, 5.84657826e-02f, 2.41969465e-04f, 6.96796030e-02f, -4.24699746e-02f,
  7.93262571e-02f, -1.38298184e-01f, -8.59525502e-02f, -5.68341743e-03f, 6.44394234e-02f, -4.53613102e-02f, 9.04392228e-02f, -7.13886097e-02f, -5.99976033e-02f, -4.88157310e-02f,
  -1.04105197e-01f, 2.49544028e-02f, 1.24913126e-01f, 1.03473507e-01f, -2.39847768e-02f, 1.16637550e-01f, -1.07370332e-01f, -2.18904451e-01f, -1.49684265e-01f, 6.10645190e-02f,
  5.73117211e-02f, 1.86781645e-01f, 2.79722959e-01f, 2.60023288e-02f, 1.29618004e-01f, -4.49038818e-02f, 1.33649915e-01f, 5.63146658e-02f, 1.75168753e-01f, 1.44146636e-01f,
  8.38152021e-02f, -6.61752149e-02f, -4.50508073e-02f, 2.87732661e-01f, -1.75751761e-01f, 1.86049327e-01f, 4.23833951e-02f, 1.33327439e-01f, -4.76592816e-02f, 1.84565216e-01f,
  -1.23251915e-01f, -1.99784636e-01f, 3.05941045e-01f, -6.94318339e-02f, -7.35916346e-02f, -9.06621590e-02f, 2.13291988e-01f, -3.31631340e-02f, 7.56458715e-02f, 7.87982047e-02f,
  -2.37576380e-01f, -4.50307131e-02f, 1.14095159e-01f, 1.48555234e-01f, 3.52911046e-03f, -1.89114273e-01f, -6.58519343e-02f, 1.24618217e-01f, 1.86973706e-01f, 1.63616970e-01f,
  1.34473115e-01f, -9.35555473e-02f, -1.71276212e-01f, -4.17356845e-03f, 3.95409763e-02f, 1.54523939e-01f, 3.67877856e-02f, 6.28854260e-02f, -2.74139792e-02f, -4.90699522e-02f,
  6.72476590e-02f, 1.14016593e-01f, 2.99575180e-02f, 8.07393491e-02f, -4.77791838e-02f, 1.90236773e-02f, 1.28420860e-01f, 7.57674053e-02f, -1.17781423e-01f, -1.79482356e-01f,
  2.54015595e-01f, 1.67018220e-01f, 5.18394634e-02f, -3.21909875e-01f, 2.80442089e-02f, 1.53958634e-01f, -2.23275989e-01f, 1.23173922e-01f, 1.50858030e-01f, 2.28124205e-02f,
  -8.14889371e-03f, -1.26043618e-01f, -1.86610192e-01f, -1.29413694e-01f, -3.46099585e-01f, 9.21758264e-03f, 9.02398601e-02f, 1.16027165e-02f, 3.06454450e-01f, -5.34544624e-02f,
  2.00882375e-01f, 7.20294490e-02f, 2.63230838e-02f, -1.57833576e-01f, 1.43290222e-01f, 1.51386857e-01f, -1.70491949e-01f, 2.51348644e-01f, 1.84851140e-01f, 2.60862231e-01f,
  -2.29421593e-02f, -9.72402841e-02f, 1.33075386e-01f, 2.05101483e-02f, 1.02476403e-01f, 1.58250034e-01f, 2.21299380e-01f, -1.30520582e-01f, -2.61936747e-02f, 8.92636180e-02f,
  8.16107094e-02f, 1.07040152e-01f, 2.60512829e-02f, -8.50327164e-02f, 6.76190183e-02f, -2.71521546e-02f, 2.49512628e-01f, 2.40448147e-01f, 1.09033860e-01f, 1.12866968e-01f,
  -1.57720417e-01f, 2.34975293e-02f, 1.00125104e-01f, 3.02589417e-01f, -1.37755036e-01f, -2.56313801e-01f, 3.16449627e-02f, 1.13479018e-01f, 9.95314792e-02f, 1.35027289e-01f,
  -5.04792407e-02f, 1.09876215e-01f, -7.58321583e-02f, 7.54748937e-03f, 2.70843692e-02f, 7.01480806e-02f, -1.76778510e-01f, -1.85573712e-01f, 1.57990918e-01f, 2.37875327e-01f,
  -4.54064496e-02f, 1.07249461e-01f, 1.41872346e-01f, -1.23697586e-01f, -2.92763114e-01f, 2.77365237e-01f, -6.05860017e-02f, -1.73121959e-01f, 2.02280626e-01f, 1.31086171e-01f,
  2.29876742e-01f, -7.19320029e-02f, -1.31787909e-02f, 3.48643541e-01f, 1.15553848e-01f, 1.91229880e-01f, 1.03335418e-01f, -2.13245191e-02f, -6.62520081e-02f, 1.08371936e-01f,
  -1.32346347e-01f, 1.92113087e-01f, 2.64723152e-02f, 2.08510071e-01f, -2.57014874e-02f, 5.80037497e-02f, -1.08002938e-01f, -2.44903877e-01f, 2.27360189e-01f, 2.40742475e-01f,
  4.68077473e-02f, -5.50637953e-03f, 1.22735254e-01f, -1.23042032e-01f, -4.36972342e-02f, 1.48819506e-01f, 4.87969555e-02f, -1.01942018e-01f, 1.73249766e-01f, -2.24564493e-01f,
  2.24666134e-01f, 3.12362224e-01f, -8.57407972e-02f, 1.51755232e-02f, 1.02979198e-01f, 2.57032573e-01f, -2.40067154e-01f, -3.93554233e-02f, 6.91245869e-02f, -5.54504879e-02f,
  -4.21631746e-02f, 1.86368361e-01f, -7.73054957e-02f, 3.89500149e-03f, -8.05092044e-03f, 4.29203734e-02f, -3.48050296e-02f, -2.32617378e-01f, 9.62085575e-02f, 3.58106233e-02f,
  2.66146958e-02f, -4.63692518e-03f, 9.51546058e-02f, 1.82942614e-01f, 4.69590351e-02f, 7.56976828e-02f, 2.06392601e-01f, 1.29145637e-01f, 3.20502259e-02f, 2.50438660e-01f,
  3.89871076e-02f, -1.29260197e-01f, -1.34594589e-01f, 2.33784392e-01f, 1.13225199e-01f, -3.13750282e-02f, 1.15254603e-01f, -1.05448440e-01f, 4.55588512e-02f, -8.76251683e-02f,
  -5.59839532e-02f, -2.21859321e-01f, -3.62591036e-02f, 3.20417613e-01f, -9.30592045e-02f, 1.09980561e-01f, 6.57254085e-02f, 2.36127958e-01f, 2.46173013e-02f, -1.00820540e-02f,
  1.21899068e-01f, -1.46153018e-01f, 1.54992389e-02f, 2.30878592e-02f, 8.04416612e-02f, 2.34710693e-01f, 4.16072235e-02f, -1.17827490e-01f, -3.38814817e-02f, 2.58154631e-01f,
  4.69218753e-02f, -8.69373754e-02f, 1.81100983e-02f, -3.34660895e-02f, 8.02566856e-02f, 2.57041872e-01f, 1.44421384e-01f, -3.47112268e-02f, 4.61631343e-02f, -1.42412484e-02f,
  -1.37358189e-01f, 3.00873458e-01f, 3.54693025e-01f, -2.26944327e-01f, 1.64503500e-01f, 3.83575857e-02f, 8.80494863e-02f, -3.02290916e-02f, 1.18545994e-01f, 1.37145445e-01f,
  4.93373582e-03f, -2.99712066e-02f, 1.50545239e-01f, 3.11236978e-01f, -1.35629937e-01f, -1.99440002e-01f, 2.87715867e-02f, -5.99212423e-02f, -1.77972957e-01f, 1.69911387e-03f,
  -9.92618576e-02f, -1.57864079e-01f, 6.97260797e-02f, 1.42067280e-02f, -2.03746811e-01f, 5.23658702e-03f, 3.27826083e-01f, -1.74000803e-02f, 4.33412418e-02f, -2.75399715e-01f,
  3.58094037e-01f, 2.48737708e-01f, 6.14083111e-02f, 3.50597850e-03f, 1.88271567e-01f, 1.16906971e-01f, 8.12687352e-02f, -8.17104336e-03f, -2.04922199e-01f, 2.28434503e-01f,
  1.65118784e-01f, 1.22964211e-01f, -7.58517981e-02f, 5.61971813e-02f, -1.55645251e-01f, -1.11364894e-01f, 3.12429011e-01f, 2.95454025e-01f, -2.01804955e-02f, -1.38500407e-01f,
  -6.19644187e-02f, 2.43925542e-01f, 1.77300155e-01f, -4.34942059e-02f, -2.13291079e-01f, -2.15048522e-01f, -2.24934176e-01f, 9.16728824e-02f, 1.43059358e-01f, 2.13918492e-01f,
  2.17626065e-01f, 1.44546926e-02f, 1.41583547e-01f, 9.37002227e-02f, 1.65994167e-02f, 5.70921376e-02f, 3.30984034e-02f, 1.26857245e-02f, -1.37964431e-02f, 6.90580308e-02f,
  5.95143065e-02f, 1.49905801e-01f, -4.59183194e-02f, 8.36384222e-02f, -1.06578693e-01f, 2.25704182e-02f, -1.05224224e-02f, -2.54079610e-01f, -1.37253121e-01f, 1.55317321e-01f,
  -2.08826020e-01f, -2.36062314e-02f, 1.01375699e-01f, -3.94764990e-02f, 7.45208114e-02f, 5.53231686e-02f, 1.31661341e-01f, -1.11645587e-01f, 2.89286435e-01f, 1.47658676e-01f,
  1.61743760e-02f, -3.81836966e-02f, 3.49918641e-02f, 1.42051637e-01f, -7.46039599e-02f, -6.03307039e-02f, -1.14072427e-01f, 2.78407391e-02f, -3.66077200e-02f, 2.25448325e-01f,
  -9.23794657e-02f, -1.16485029e-01f, 3.02371562e-01f, -1.51828319e-01f, 1.38599589e-01f, -1.05435252e-01f, 8.04464296e-02f, 7.58825690e-02f, -9.48110372e-02f, 1.26782194e-01f,
  -1.62000865e-01f, 4.88813734e-03f, -7.48364069e-03f, 6.08404391e-02f, 1.81232467e-01f, -1.77913785e-01f, -4.79354039e-02f, 1.48477584e-01f, 1.56732887e-01f, 2.72273391e-01f,
  1.35294557e-01f, 8.10011551e-02f, -3.51730026e-02f, -2.88715232e-02f, -6.83366656e-02f, 1.59365863e-01f, -5.91757558e-02f, 1.30922392e-01f, -6.20019063e-02f, 2.31072828e-02f,
  3.48277278e-02f, -5.58962747e-02f, -8.04901775e-03f, 7.26989582e-02f, 1.45182744e-01f, -3.42262723e-02f, 1.08496420e-01f, 2.32727788e-02f, -2.97540128e-01f, -1.96915179e-01f,
  -2.29102820e-01f, -1.00061506e-01f, 8.94533321e-02f, 1.94791421e-01f, -1.02968745e-01f, 1.13936044e-01f, -1.42788151e-02f, 1.74774416e-02f, 1.47887185e-01f, 2.61310756e-01f,
  1.94576740e-01f, -2.26707339e-01f, 1.67045426e-02f, 1.00984603e-01f, 2.35068232e-01f, -1.53497502e-01f, 1.03413410e-01f, 1.89935863e-01f, 1.81227066e-02f, 1.18305467e-01f,
  1.11692145e-01f, 2.94194192e-01f, 3.25693101e-01f, 2.59197444e-01f, 3.71587753e-01f, -4.96324264e-02f, 2.43016973e-01f, 7.82258734e-02f, 3.18432778e-01f, 1.95950910e-01f,
  1.87208980e-01f, 1.04424395e-01f, -3.57562378e-02f, 4.64802533e-02f, -1.42589554e-01f, 3.07621509e-01f, 1.57934725e-01f, -6.70253932e-02f, 1.21618798e-02f, 2.29682282e-01f,
  1.95112467e-01f, 1.13931866e-02f, 1.66146800e-01f, 3.88038188e-01f, 1.78562880e-01f, 1.89434662e-01f, -1.66158170e-01f, -1.57935187e-01f, -2.12774351e-01f, 2.13809788e-01f,
  -1.84524983e-01f, 6.17893972e-02f, -4.05504666e-02f, -1.12724029e-01f, -9.27401930e-02f, 2.22603768e-01f, -6.36444390e-02f, -6.85631670e-03f, -5.13884164e-02f, -7.61280283e-02f,
  3.96597870e-02f, -1.41518861e-01f, -2.68452279e-02f, 1.36566326e-01f, 1.18332162e-01f, -1.06176384e-01f, 1.21145383e-01f, 1.27482027e-01f, -8.76201019e-02f, 6.02581427e-02f,
  1.12781696e-01f, 1.74707383e-01f, 2.03996986e-01f, 2.30051115e-01f, 1.57876298e-01f, 1.93725511e-01f, 1.66218624e-01f, 1.87834159e-01f, -1.94859371e-01f, -5.94346598e-02f,
  1.76221520e-01f, 1.12463199e-01f, -2.50596911e-01f, 1.11803622e-03f, 1.21898964e-01f, -3.35060507e-02f, -3.99154983e-02f, 3.33081335e-02f, 1.09095745e-01f, -4.51726541e-02f,
  3.00014317e-01f, -1.58172071e-01f, 1.09309852e-01f, -5.86974509e-02f, 6.16381504e-02f, -9.45614800e-02f, 3.40008408e-01f, 1.97009861e-01f, -1.50694072e-01f, -4.64319550e-02f,
  5.73752299e-02f, 1.19742319e-01f, -2.31048651e-02f, -1.02480315e-01f, -1.09626025e-01f, -1.11194156e-01f, 1.06549747e-01f, 1.02308773e-01f, 2.27987394e-01f, -1.57373808e-02f,
  9.89199355e-02f, -2.42156774e-01f, 1.42993018e-01f, 2.90653179e-03f, 1.76555738e-02f, 8.29396546e-02f, -1.17657095e-01f, 1.68574035e-01f, 2.04910785e-01f, -1.20578453e-01f,
  -1.74113616e-01f, -8.77766758e-02f, -1.13544501e-01f, -8.71527717e-02f, -1.89520091e-01f, -1.91635728e-01f, 2.56775498e-01f, -1.21810287e-01f, -1.48372144e-01f, 9.65218395e-02f,
  6.67549893e-02f, -2.86759287e-01f, 1.13978669e-01f, 1.51553228e-01f, -4.80273068e-02f, -3.93508896e-02f, 7.49442652e-02f, 8.94718394e-02f, -2.41808176e-01f, 2.36100852e-01f,
  -5.00019193e-02f, -1.67399973e-01f, 2.20321059e-01f, 2.17421204e-01f, 1.06178164e-01f, -3.00518586e-03f, 4.75203851e-03f, 2.50995487e-01f, 1.62547484e-01f, 1.67219769e-02f,
  1.18778557e-01f, 3.70572358e-02f, 2.01370344e-02f, 2.03577891e-01f, -2.14076072e-01f, 2.00317204e-01f, 1.96544871e-01f, 4.94249761e-02f, 6.11388125e-02f, -1.25161693e-01f,
  4.89785187e-02f, -2.78554320e-01f, 1.96949184e-01f, 5.22138923e-02f, 8.84635299e-02f, -5.57475651e-05f, -2.20866082e-03f, 9.99265537e-02f, -1.44264027e-01f, 1.14814796e-01f,
  -1.03093982e-01f, 1.18427705e-02f, 5.82376234e-02f, 2.07367856e-02f, 7.34751299e-02f, 4.34653163e-02f, -6.35095611e-02f, 1.22641250e-01f, 1.61831692e-01f, -6.98822066e-02f,
  -2.17339307e-01f, 4.39550541e-02f, 1.90295920e-01f, 1.07523240e-01f, 5.61894849e-02f, -9.91276428e-02f, -9.38932076e-02f, -9.61211100e-02f, 1.00812912e-01f, 1.30142987e-01f,
  -1.35996431e-01f, -2.93436162e-02f, 2.98974544e-01f, 1.52199185e-02f, 1.29461870e-01f, -1.42055616e-01f, 1.69346690e-01f, -5.56645580e-02f, -1.79715827e-01f, 2.05227733e-01f,
  2.48239547e-01f, 1.72952548e-01f, -7.82833099e-02f, 3.02817207e-02f, -4.10664491e-02f, 4.50776368e-02f, -1.00573294e-01f, 1.53672501e-01f, 1.43278629e-01f, 2.58916453e-03f,
  -5.69955958e-03f, -4.70039621e-02f, 2.11817831e-01f, -6.39874935e-02f, 1.42067462e-01f, -2.86739189e-02f, 9.86911058e-02f, 2.63984036e-02f, -1.22471146e-01f, 2.11617380e-01f,
  1.36271447e-01f, 2.76404381e-01f, -2.27876455e-01f, -3.34134489e-01f, -1.83472969e-02f, -1.23402536e-01f, 1.23392798e-01f, -7.90423453e-02f, 1.54505059e-01f, 7.91204944e-02f,
  8.07285979e-02f, 1.14845792e-02f, -1.85457859e-02f, -4.79394980e-02f, 9.00232270e-02f, -1.84155211e-01f, 2.14556560e-01f, -4.58909161e-02f, 2.34863862e-01f, 1.79246426e-01f,
  2.68233091e-01f, -1.64829254e-01f, -1.58751771e-01f, -1.45240247e-01f, -2.31203064e-02f, 3.33882779e-01f, 8.95424280e-03f, -9.43901911e-02f, 1.77228495e-01f, 8.96138325e-02f,
  4.88471165e-02f, 1.84416264e-01f, 2.01771751e-01f, 6.24672920e-02f, -1.79539457e-01f, -1.45438269e-01f, -1.21590711e-01f, 1.64997637e-01f, 1.04705058e-02f, -2.38241434e-01f,
  -1.64625198e-01f, 1.13927566e-01f, 1.35656446e-01f, -2.52179019e-02f, -1.55085415e-01f, -1.55682907e-01f, 1.75444514e-01f, -1.73754897e-02f, -1.66478112e-01f, 1.53164178e-01f,
  1.29351290e-02f, -1.18291177e-01f, -1.62237793e-01f, 7.20190480e-02f, 2.66362876e-01f, 1.27714291e-01f, -4.88911383e-02f, 1.02014728e-01f, 1.67029083e-01f, 1.62066016e-02f,
  6.75436705e-02f, -1.04448676e-01f, 4.54079024e-02f, 2.04108059e-01f, 1.46291047e-01f, -3.14848498e-02f, 1.57184288e-01f, 2.00266689e-01f, -5.64535148e-02f, 4.27843407e-02f,
  1.85898080e-01f, 2.63155729e-01f, 1.08385526e-01f, -1.77796543e-01f, 1.36060312e-01f, 2.79067636e-01f, 2.77177274e-01f, 4.89775650e-02f, -1.86078683e-01f, -4.15405184e-02f,
  -1.97684512e-01f, 5.37590645e-02f, 2.95973904e-02f, 5.09793349e-02f, 4.81047444e-02f, 1.27117142e-01f, -2.03074086e-02f, 6.20470643e-02f, 1.63030148e-01f, -6.23677634e-02f,
  -1.26713037e-01f, 3.17402147e-02f, -8.67974907e-02f, 6.84152767e-02f, 1.19353004e-01f, 3.56500968e-02f, 1.55820981e-01f, 1.14543922e-01f, -2.22477004e-01f, -1.36695564e-01f,
  -1.35084182e-01f, 1.15784176e-01f, -2.22042367e-01f, 2.60657579e-01f, -7.61515573e-02f, 2.80960292e-01f, 1.23584084e-01f, 7.56511912e-02f, -7.31642246e-02f, 9.68965217e-02f,
  -1.92471027e-01f, 8.30567721e-03f, -2.86013493e-03f, 5.14552593e-02f, 1.63921326e-01f, -1.15570992e-01f, 1.49232030e-01f, 1.15210414e-01f, 1.19225949e-01f, 1.54023254e-02f,
  -3.47855908e-04f, 1.98200881e-01f, 2.57580578e-01f, 1.08517911e-02f, 1.95414457e-03f, -8.45582932e-02f, 4.51839622e-03f, 1.83275819e-01f, 1.83859333e-01f, -2.27616038e-02f,
  1.42585725e-01f, 3.08705330e-01f, -1.48656562e-01f, -7.76994452e-02f, -9.20657367e-02f, 2.94339329e-01f, 2.95949310e-01f, -1.86365336e-01f, 1.06398299e-01f, 9.93521661e-02f,
  2.78589785e-01f, 2.30415523e-01f, -1.80526376e-01f, 1.53977543e-01f, -7.30744153e-02f, -4.54997085e-02f, -3.03617239e-01f, -5.75159416e-02f, -1.80450171e-01f, 2.38137022e-01f,
  -5.93739115e-02f, 6.57654926e-02f, 8.01296830e-02f, -7.14562982e-02f, -4.08704691e-02f, 2.49756083e-01f, 2.20705196e-02f, -1.41867012e-01f, 7.62326345e-02f, -7.18736351e-02f,
  7.30271190e-02f, -3.91829722e-02f, -4.56755050e-02f, -3.09200734e-01f, 4.53943126e-02f, 9.53694060e-02f, 1.05811037e-01f, -2.07573980e-01f, 5.42256832e-02f, 1.37394071e-01f,
  -6.88198507e-02f, -1.05472445e-01f, -1.71140030e-01f, 3.17119621e-02f, -1.65479660e-01f, 4.26106900e-02f, -2.26229459e-01f, -1.02207758e-01f, 1.01460412e-01f, 4.84161116e-02f,
  1.44778758e-01f, -5.86452745e-02f, 1.19503744e-01f, 7.49841258e-02f, 1.13203712e-02f, 2.31229469e-01f, 1.98755175e-01f, 2.73581352e-02f, 1.34552777e-01f, -1.39302239e-01f,
  -2.98059314e-01f, 1.15378119e-01f, -2.01751366e-02f, 4.54602875e-02f, -3.15390155e-02f, 1.17009223e-01f, -2.62605667e-01f, -2.11162180e-01f, 2.11585760e-01f, 2.37956986e-01f,
  2.68807281e-02f, -9.06834379e-02f, 1.89602464e-01f, 1.78655788e-01f, 9.97512192e-02f, 2.05882620e-02f, -1.42561272e-01f, -4.28471155e-02f, -9.66405645e-02f, 2.93400399e-02f,
  9.91585329e-02f, 1.44936547e-01f, -5.01596853e-02f, 3.44020277e-02f, -4.12733816e-02f, 1.18391179e-01f, 7.06869885e-02f, -1.94365278e-01f, -8.01675990e-02f, 1.55637460e-02f,
  -1.86393652e-02f, 1.47670537e-01f, -1.45226538e-01f, -3.96434590e-02f, 1.66757584e-01f, 9.02750120e-02f, 5.94358779e-02f, 4.26861644e-02f, 2.41287440e-01f, 1.12278581e-01f,
  -2.76865028e-02f, 7.15572620e-03f, 1.09561972e-01f, -1.77966133e-01f, 5.28087318e-02f, 2.37508163e-01f, 2.48670325e-01f, 1.12358913e-01f, 1.90578744e-01f, 1.64608225e-01f,
  -9.03725550e-02f, 8.92851725e-02f, -3.54746506e-02f, 1.14679284e-01f, -3.89974788e-02f, -1.34737208e-01f, -1.69068873e-01f, -1.25116318e-01f, 2.10492149e-01f, -2.43380323e-01f,
  -1.35512829e-01f, -9.06796381e-02f, 1.04467683e-01f, 1.78344235e-01f, 2.11486682e-01f, -2.81895734e-02f, 1.24110110e-01f, 2.64044762e-01f, -4.51599360e-02f, -3.20848465e-01f,
  2.69760996e-01f, 2.05064863e-01f, 1.40066966e-01f, -2.75413752e-01f, -5.66976480e-02f, 7.21474290e-02f, -7.61655867e-02f, -8.57465267e-02f, -7.37548918e-02f, -5.47464751e-02f,
  2.97988713e-01f, -6.59287325e-04f, 2.32224822e-01f, 1.16071545e-01f, 2.44579703e-01f, 8.69463459e-02f, 2.27350354e-01f, -1.41436264e-01f, 5.09267161e-03f, -1.05965443e-01f,
  1.03101112e-01f, 3.15662682e-01f, 8.42132270e-02f, -9.09950733e-02f, -2.59596854e-02f, 7.35193565e-02f, 6.76629245e-02f, 1.83421522e-01f, -5.58476858e-02f, 1.48587912e-01f,
  1.45159632e-01f, -1.74225662e-02f, 2.47996133e-02f, -1.27834395e-01f, -2.54766762e-01f, -9.11857858e-02f, 6.34982884e-02f, 1.87955558e-01f, 1.54818594e-01f, 3.17208134e-02f,
  1.24070868e-01f, 3.56963240e-02f, -2.16937035e-01f, 1.48277953e-01f, 1.32869676e-01f, 1.54362600e-02f, -1.66589186e-01f, 2.37681344e-01f, 3.17358106e-01f, 2.43599162e-01f,
  1.67790577e-02f, -4.20917664e-03f, 3.01100332e-02f, -1.13359854e-01f, 1.74504146e-01f, -1.24616837e-02f, -2.71628760e-02f, 7.76307583e-02f, 2.64681093e-02f, 2.16793150e-01f,
  -1.07700333e-01f, -9.34115201e-02f, 1.99586496e-01f, -8.81554410e-02f, 3.18889171e-02f, -5.61507493e-02f, 1.31192626e-02f, 4.44853604e-02f, 1.89219698e-01f, 9.42807272e-03f,
  1.96669251e-01f, -7.21016005e-02f, -2.12415352e-01f, 1.61241114e-01f, -1.24480519e-02f, -2.10014507e-01f, 2.71145433e-01f, -2.36584648e-01f, 1.49788260e-01f, 2.08670527e-01f,
  -1.06804803e-01f, 8.73192996e-02f, 7.46838823e-02f, 2.92589962e-01f, -2.30758898e-02f, -1.22127915e-02f, -1.02248788e-02f, -1.59577921e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.67122766e-01f, -2.98535749e-02f, -1.49118543e-01f, -6.19112700e-02f, 1.10945277e-01f, 1.75671399e-01f, 6.00683577e-02f, 6.76395372e-02f, 2.28761472e-02f, -3.40254791e-02f,
  1.29704267e-01f, -9.53778476e-02f, 8.01724046e-02f, 1.04394354e-01f, 5.39930444e-03f, 2.26956587e-02f, -7.66983852e-02f, -3.70376594e-02f, -1.12115592e-01f, -5.91171198e-02f,
  -7.12006465e-02f, 1.34139612e-01f, 1.51828989e-01f, 1.29997730e-01f, -2.56446074e-03f, -2.68793404e-02f, 1.78333670e-01f, 1.15356445e-01f, 4.19822335e-02f, 1.06644310e-01f,
  5.05668931e-02f, -1.20683610e-02f, -5.58526479e-02f, 1.63502783e-01f, -1.13447428e-01f, 3.23477127e-02f, -3.35465111e-02f, -1.01215087e-01f, 5.44354320e-02f, -5.53700514e-02f,
  8.08254704e-02f, 1.51765674e-01f, -8.85909721e-02f, 1.04851015e-01f, 6.64569661e-02f, 3.56653184e-02f, 1.25043631e-01f, 1.06414266e-01f, 2.10631657e-02f, -8.96633714e-02f,
  2.09673867e-02f, -6.36075810e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -6.79366803e-03f, -6.34113029e-02f, -1.35215148e-01f, 2.10439805e-02f, -1.36946544e-01f, 1.10184647e-01f, 1.98938906e-01f, 1.20570026e-01f, -2.09892765e-01f, 1.19289709e-03f,
  1.66339979e-01f, -1.84052706e-01f, -1.69314101e-01f, -6.25393772e-03f, -3.36126655e-01f, 2.30366901e-01f, 1.50283471e-01f, -3.39233249e-01f, 1.59313828e-01f, -2.91547447e-01f,
  1.99766055e-01f, 1.16866186e-01f, -2.11917281e-01f, -1.48445498e-02f, -8.54776278e-02f, -2.49536727e-02f, 9.80886742e-02f, -2.98976719e-01f, 4.87011783e-02f, 2.08405063e-01f,
  -4.57790345e-02f, -2.05178037e-01f, 1.69901848e-02f, 1.28987968e-01f, -4.65204604e-02f, -6.01786980e-03f, 2.40277097e-01f, 1.12863883e-01f, -3.92556012e-01f, -1.52072564e-01f,
  -1.11779422e-01f, -2.20712975e-01f, -6.91138953e-02f, 1.45264745e-01f, 1.62069872e-01f, 4.59985994e-02f, 1.06986456e-01f, -1.13181397e-02f, -1.06571950e-01f, 9.34235305e-02f,
  -2.84253269e-01f, -1.39905259e-01f, -1.31005973e-01f, -1.36867896e-01f, 4.27916981e-02f, -2.43780360e-01f, 7.69958720e-02f, -1.77798271e-01f, -2.45238140e-01f, -8.31013098e-02f,
  -3.46018136e-01f, -1.78197533e-01f, 1.37810469e-01f, 8.14978704e-02f, 3.56982555e-03f, -1.41895097e-02f, -1.50728365e-02f, 2.16281358e-02f, -1.40407935e-01f, 1.26148805e-01f,
  3.04799765e-01f, 9.70652476e-02f, 2.32251346e-01f, -1.03767894e-01f, 7.51967058e-02f, 3.06432843e-01f, 3.70830745e-01f, -3.07191730e-01f, -1.17030285e-01f, 1.47548676e-01f,
  -2.02026084e-01f, -2.51595955e-03f, -4.07234654e-02f, 9.16456804e-02f, -6.19043000e-02f, 2.02945992e-03f, -1.65322110e-01f, -8.67828727e-02f, -5.58321811e-02f, 1.00056648e-01f,
  -2.24272966e-01f, -5.21441139e-02f, 8.68096389e-03f, 4.58786160e-01f, -1.24288522e-01f, 9.98081453e-03f, -7.90174723e-01f, -2.34028533e-01f, 1.97960392e-01f, 2.96805147e-02f,
  7.03196451e-02f, 8.63273814e-02f, -1.61738500e-01f, 1.70330986e-01f, -1.21997997e-01f, -3.15331146e-02f, 1.99554801e-01f, 8.88928771e-02f, 4.08122018e-02f, -2.14021713e-01f,
  -4.30639461e-02f, 1.06748544e-01f, -7.35818222e-02f, 1.60950035e-01f, -3.11663389e-01f, -2.92985082e-01f, -1.70239314e-01f, -2.65938789e-01f, 1.56049341e-01f, 1.29437432e-01f,
  1.92853287e-01f, -3.96430045e-01f, -9.37023237e-02f, -2.14013755e-01f, -2.14171156e-01f, -5.43311052e-02f, 7.26039037e-02f, -2.15291500e-01f, -1.38209268e-01f, 8.12507421e-02f,
  -1.26825154e-01f, -1.12488784e-01f, 4.84502986e-02f, -1.92087010e-01f, -1.34524807e-01f, 2.10949540e-01f, 3.70587446e-02f, -1.70028389e-01f, 2.63629444e-02f, 9.01787281e-02f,
  -6.24667928e-02f, -1.59888566e-01f, 1.14819989e-01f, 4.65169325e-02f, 1.64855286e-01f, 1.46342576e-01f, -4.93775681e-02f, 1.70550361e-01f, -3.10514808e-01f, -1.02443956e-01f,
  1.71552211e-01f, 4.24011685e-02f, 2.54562404e-02f, 9.91360322e-02f, -3.64227474e-01f, -3.72073054e-01f, -2.70243496e-01f, -5.06567240e-01f, 2.02119902e-01f, -5.50517261e-01f,
  -1.53801426e-01f, -2.14323923e-01f, 6.84852004e-02f, 1.15084678e-01f, 1.25762939e-01f, 2.08819751e-02f, -6.09903224e-03f, 1.25475660e-01f, -1.64588094e-02f, -2.99035519e-01f,
  1.89613521e-01f, 2.36046895e-01f, -3.49218220e-01f, 6.56979978e-02f, -7.45470896e-02f, -1.10698014e-01f, -1.15353763e-01f, -1.93252951e-01f, -3.26098837e-02f, -2.18450695e-01f,
  -7.50390515e-02f, 9.72890258e-02f, -2.39017546e-01f, 3.37754376e-02f, -6.02624640e-02f, -5.05766347e-02f, 1.86092034e-01f, -7.79581591e-02f, -2.20802441e-01f, -1.87920436e-01f,
  2.59052385e-02f, -3.36450666e-01f, 2.67104805e-02f, 3.20929326e-02f, -2.16342956e-01f, -2.83687729e-02f, 2.87445430e-02f, -1.40820816e-01f, 2.11093828e-01f, -1.65846035e-01f,
  -8.79933164e-02f, -8.06843489e-02f, -1.68056160e-01f, -9.94200166e-03f, -1.34995669e-01f, 1.16741858e-01f, 4.57696281e-02f, 7.18299076e-02f, 2.73973793e-02f, -5.73166832e-02f,
  -2.65114337e-01f, -1.36189565e-01f, -1.79941431e-01f, -2.58478433e-01f, 1.10968523e-01f, -7.10949674e-02f, -3.63084108e-01f, -4.13181037e-01f, 1.48740903e-01f, 1.13949224e-01f,
  1.64871514e-01f, -5.84202766e-01f, -1.68467283e-01f, 1.35648847e-01f, 3.93832684e-01f, 1.65979385e-01f, -4.04840052e-01f, -4.24383789e-01f, -2.76328623e-01f, 1.16577938e-01f,
  6.82073310e-02f, -2.50030160e-01f, 4.78527099e-02f, -1.71404183e-01f, -3.48873347e-01f, -2.58226544e-01f, 2.40794376e-01f, 1.29378021e-01f, -4.37132567e-02f, 3.18134949e-02f,
  3.33673172e-02f, -5.05671501e-02f, -1.41942129e-01f, 7.93485343e-02f, 1.05515920e-01f, -8.25491995e-02f, -1.90008059e-01f, -3.66839647e-01f, -7.63277337e-02f, 1.52024657e-01f,
  -1.13488488e-01f, -1.54047385e-01f, -7.32816160e-02f, 6.02048859e-02f, -1.80075690e-01f, 1.71193704e-01f, 9.47500616e-02f, 6.97007552e-02f, -2.88984161e-02f, -1.63364872e-01f,
  -3.53880934e-02f, -1.19740903e-01f, -2.10934177e-01f, -2.52704561e-01f, -1.79994643e-01f, 2.23501414e-01f, -4.42507416e-02f, -2.26172104e-01f, -1.00799076e-01f, 1.17382012e-01f,
  5.91882281e-02f, -1.77251533e-01f, 6.41843528e-02f, 5.15786298e-02f, 1.23846252e-02f, -2.70480037e-01f, 1.38546109e-01f, 2.22989753e-01f, -2.51409039e-02f, -5.43688945e-02f,
  -2.03759283e-01f, 8.34942535e-02f, 1.66915238e-01f, 1.59048036e-01f, -7.62013122e-02f, -1.00429678e+00f, -2.46897846e-01f, -2.78890759e-01f, 1.47817090e-01f, 2.14426637e-01f,
  -7.72696584e-02f, -4.38875630e-02f, 8.18785354e-02f, 9.39836651e-02f, 1.17664769e-01f, 9.28322226e-02f, -1.30810291e-02f, -2.61013154e-02f, -1.21001631e-01f, 4.25948463e-02f,
  9.78206992e-02f, 1.37742221e-01f, -4.14536037e-02f, 9.97141935e-03f, -1.44546151e-01f, -8.00711587e-02f, -1.39571950e-02f, 1.11878820e-01f, 3.11708357e-03f, 1.81083247e-01f,
  -8.45700130e-02f, -1.49141997e-01f, -1.61852032e-01f, -5.84848933e-02f, -2.53363729e-01f, 1.02013253e-01f, -7.30018169e-02f, 3.14986072e-02f, -8.60211104e-02f, -9.76211727e-02f,
  -3.64734083e-02f, 5.02534360e-02f, 1.09708317e-01f, 1.61429271e-01f, 8.22553188e-02f, -1.36653222e-02f, 3.08712900e-01f, 2.82618791e-01f, -1.77457228e-01f, -1.58286959e-01f,
  1.71861887e-01f, 3.89519930e-02f, -2.75590748e-01f, 1.50089473e-01f, -3.23733628e-01f, -8.62669274e-02f, 5.04479371e-02f, 1.52968824e-01f, -1.46798864e-01f, 4.93504480e-02f,
  1.83918238e-01f, -3.72826569e-02f, -2.77760893e-01f, 4.14092988e-02f, 2.99082994e-01f, -8.66850000e-03f, 1.21530727e-01f, -3.08666587e-01f, 1.56351030e-01f, -5.36442399e-01f,
  -1.99520335e-01f, -1.89251170e-01f, -9.53117132e-01f, 3.39507535e-02f, -1.04470961e-01f, 1.62454739e-01f, -9.81666818e-02f, -9.28632692e-02f, 1.34756953e-01f, -2.17232928e-01f,
  -9.55827683e-02f, 1.69906452e-01f, 3.96322757e-02f, -1.44041285e-01f, -1.99893899e-02f, -2.61492014e-01f, -5.37081584e-02f, 1.85261853e-02f, -3.50376256e-02f, 1.18966073e-01f,
  -1.95713431e-01f, -1.07712045e-01f, -1.20040707e-01f, -1.81804061e-01f, 1.86484680e-01f, 1.66948557e-01f, 1.41495569e-02f, -4.36783820e-01f, -1.64590076e-01f, 7.26799145e-02f,
  1.86014965e-01f, -4.10794288e-01f, -1.85019940e-01f, 1.39049962e-01f, -6.63766339e-02f, 1.96399853e-01f, 3.48262116e-02f, 1.48905009e-01f, 5.78926643e-03f, 9.91370976e-02f,
  -2.09328026e-01f, -1.25256432e-02f, 2.14271933e-01f, 2.13316724e-01f, 8.34026113e-02f, 2.02937335e-01f, -2.30688259e-01f, 8.71522129e-02f, -1.57372281e-01f, -3.85187238e-01f,
  -5.29797226e-02f, 1.29757553e-01f, -2.70865023e-01f, 9.56882760e-02f, -4.58649099e-02f, -2.26026028e-01f, 5.35579138e-02f, -1.06952839e-01f, -5.24493903e-02f, 2.48101786e-01f,
  -3.88208896e-01f, 2.11499944e-01f, -7.55249150e-03f, -2.76903957e-01f, 2.84056485e-01f, -1.79937199e-01f, -3.10991436e-01f, -2.30638683e-02f, -8.72127246e-03f, 1.20185494e-01f,
  -3.57226461e-01f, 3.49353962e-02f, 2.41443262e-01f, 5.75783141e-02f, -1.04304865e-01f, -1.07226737e-01f, -1.70122366e-02f, 1.89965323e-01f, -3.75027031e-01f, -2.64119029e-01f,
  4.56840657e-02f, 1.03997968e-01f, -5.99469952e-02f, -1.02647305e-01f, -1.57000050e-01f, -1.04684532e-02f, -2.84371644e-01f, 3.32349129e-02f, -2.13497564e-01f, 1.71233118e-01f,
  -1.99785933e-01f, 3.51201296e-02f, -2.03531802e-01f, 4.46191691e-02f, 2.64595181e-01f, 1.70398802e-01f, -2.39952818e-01f, -1.40302762e-01f, 9.48553607e-02f, -8.20482522e-02f,
  -1.41539961e-01f, -5.47043346e-02f, 6.20363168e-02f, -1.09200738e-01f, -2.24537984e-01f, -4.63798729e-04f, 4.03581448e-02f, 2.69518606e-02f, 5.62979355e-02f, -1.10715993e-01f,
  -5.87832369e-02f, 2.03914210e-01f, 1.50567740e-01f, -2.51854569e-01f, -2.30454147e-01f, -2.93204188e-01f, 1.29392296e-01f, -8.11951235e-02f, -3.24266821e-01f, 1.08830575e-02f,
  -2.87040383e-01f, -9.77637544e-02f, -1.51277304e-01f, -2.11991593e-01f, 1.26564741e-01f, 1.34641394e-01f, 2.20740825e-01f, -7.06386626e-01f, -1.22091174e-01f, 2.80002028e-01f,
  -3.28837097e-01f, -4.07867320e-02f, -1.06002122e-01f, -1.65081277e-01f, -7.99544342e-03f, 1.05844311e-01f, -1.81010857e-01f, -1.05163306e-01f, -1.99951679e-02f, 1.20705344e-01f,
  -2.83572555e-01f, -1.59285471e-01f, 1.49627745e-01f, -2.36794427e-01f, -2.38590017e-02f, -3.20733413e-02f, -8.23784471e-02f, 2.16464788e-01f, -1.32758528e-01f, 5.86265624e-02f,
  -1.27577235e-03f, -2.04610616e-01f, 1.94764704e-01f, 1.71842337e-01f, 8.95929616e-03f, -1.00463592e-01f, -1.59542009e-01f, -7.93837458e-02f, 1.76615208e-01f, -1.60613418e-01f,
  -1.66960210e-01f, 8.42129216e-02f, 2.42269337e-02f, -1.48025053e-02f, -1.18562721e-01f, -8.75757262e-02f, 9.21860412e-02f, -1.72086015e-01f, -2.12066516e-01f, -2.89427419e-03f,
  1.33543715e-01f, -1.40349530e-02f, -5.00697903e-02f, 1.32106647e-01f, -1.61143810e-01f, 7.46814013e-02f, 1.34721592e-01f, 1.82100713e-01f, -1.28399983e-01f, 1.05795421e-01f,
  -2.56031662e-01f, -1.32273048e-01f, -3.35923910e-01f, -1.85435191e-01f, -2.75871605e-01f, -1.26433983e-01f, 3.37677915e-03f, -6.90275133e-02f, 4.52737920e-02f, 1.18862316e-01f,
  -1.79155841e-01f, -3.04195315e-01f, 1.90264601e-02f, 2.39621297e-01f, -7.05092609e-01f, -2.72866607e-01f, 1.34828120e-01f, 1.17555320e-01f, -1.80398554e-01f, -9.08644125e-02f,
  -1.92108583e-02f, -2.04574876e-02f, 9.86955613e-02f, -1.90976486e-01f, -2.01963615e-02f, -1.12346627e-01f, -3.99424508e-02f, -3.27979028e-01f, 1.00431845e-01f, -7.22394660e-02f,
  -2.47542616e-02f, -1.09605893e-01f, 1.71175063e-01f, -1.31260008e-01f, 2.24057466e-01f, -1.72710955e-01f, -1.59373000e-01f, 1.14088561e-02f, 1.76220343e-01f, 3.32283676e-02f,
  2.08150044e-01f, -2.50064522e-01f, -2.29607254e-01f, -1.43081665e-01f, 2.20330521e-01f, -9.97020155e-02f, -1.92048680e-02f, 8.41544010e-03f, -3.62024829e-02f, 1.84662849e-01f,
  8.71996731e-02f, 4.58406657e-02f, -2.25378573e-01f, -2.16507629e-01f, 1.52663305e-01f, 2.68066805e-02f, -2.57384241e-01f, -8.29133317e-02f, -1.99306712e-01f, 1.41433939e-01f,
  9.94133800e-02f, -1.73488799e-02f, 1.78020954e-01f, -1.52217150e-01f, 3.09539080e-01f, 1.47713244e-01f, 2.44255617e-01f, 3.35155070e-01f, 1.37583658e-01f, -7.31089711e-02f,
  -6.36387244e-02f, 6.93345740e-02f, -1.43889219e-01f, -1.48154125e-01f, -2.69559681e-01f, -5.29842198e-01f, -1.69738486e-01f, -1.25861987e-01f, -1.07940781e+00f, 1.01384386e-01f,
  -9.95830446e-02f, 5.70734218e-02f, -1.13590350e-02f, 5.23122028e-02f, -1.96301565e-01f, -1.55834094e-01f, 2.54299790e-02f, 2.01591849e-01f, -1.24355167e-01f, 1.00557148e-01f,
  -3.50547016e-01f, -1.75184518e-01f, 8.07004720e-02f, 1.42309573e-02f, -1.15263805e-01f, -2.51943082e-01f, 1.67339817e-01f, -3.02784532e-01f, -2.88497984e-01f, 4.25229296e-02f,
  -1.50608078e-01f, 3.96123677e-02f, -2.51508206e-01f, -3.67981344e-01f, -7.27715762e-03f, 2.24818677e-01f, 5.61925992e-02f, 1.18180119e-01f, -2.31650054e-01f, -1.83520272e-01f,
  8.53970572e-02f, 1.50852799e-01f, 9.65127349e-03f, 3.17763723e-02f, 7.75242001e-02f, 1.02248393e-01f, 1.12081118e-01f, 1.51361898e-01f, 1.76033117e-02f, 2.62012869e-01f,
  1.25986665e-01f, 5.52268736e-02f, -7.44482353e-02f, -7.73569643e-02f, 4.32447977e-02f, 1.22223767e-02f, -1.40912443e-01f, 1.03631109e-01f, -1.14972740e-01f, -1.73221171e-01f,
  -1.87287256e-01f, -3.50111276e-01f, 2.01347083e-01f, -1.17343716e-01f, -1.86429888e-01f, -4.12617475e-01f, -8.53361282e-03f, -2.34971732e-01f, -4.91188355e-02f, 1.46463856e-01f,
  -3.86997074e-01f, -1.69342086e-01f, 1.95405930e-01f, 1.49438102e-02f, 7.44006708e-02f, -1.05589293e-01f, 3.13907824e-02f, -1.82990711e-02f, -2.38302782e-01f, 2.58606881e-01f,
  -9.71118212e-02f, -4.15551662e-02f, 1.81254387e-01f, -2.82909423e-01f, 6.81747869e-02f, 2.41534293e-01f, 2.15427093e-02f, -7.38949254e-02f, 7.58375302e-02f, -7.45301247e-02f,
  1.44715905e-01f, 1.79405883e-01f, 2.01588348e-01f, -2.57118884e-02f, -1.76102668e-01f, -3.14088941e-01f, -1.05045751e-01f, -8.23607817e-02f, 2.09361792e-01f, -2.30035722e-01f,
  -1.35799900e-01f, -2.53538996e-01f, 1.78788066e-01f, 1.13198385e-01f, -8.22951421e-02f, -1.62529096e-01f, 1.28845081e-01f, -5.80301695e-03f, -1.11489378e-01f, 5.91119900e-02f,
  -1.73561841e-01f, -2.24039361e-01f, -2.21471041e-02f, -1.32211924e-01f, -2.33623907e-01f, -1.79952726e-01f, -2.07890481e-01f, 1.22382432e-01f, 1.07829548e-01f, -2.79018551e-01f,
  1.04268201e-01f, 7.54886046e-02f, -1.83347881e-01f, 6.52311323e-03f, -2.61898309e-01f, -2.58578509e-01f, -1.71310484e-01f, -6.16696989e-03f, 3.09944183e-01f, -2.38831028e-01f,
  8.83122087e-02f, -8.85726810e-02f, -9.92532447e-03f, -3.02583247e-01f, -3.00720464e-02f, -2.54104376e-01f, -5.65164149e-01f, -4.64140736e-02f, -2.40375042e-01f, -1.48629114e-01f,
  -1.79286823e-01f, -9.67773795e-02f, 1.93764150e-01f, -1.16369128e-01f, 1.04945883e-01f, 2.59976387e-02f, 4.64822277e-02f, -2.85790622e-01f, -1.70398027e-01f, 9.45063084e-02f,
  -4.37217988e-02f, -9.90342870e-02f, -4.86240126e-02f, -5.21245040e-02f, 2.37869591e-01f, 2.25373432e-01f, -6.78548440e-02f, 5.27797937e-02f, -8.93482193e-02f, 4.69803587e-02f,
  -8.78411233e-02f, 1.02188632e-01f, 1.44190967e-01f, 1.27172284e-02f, 6.45805150e-03f, 2.75063038e-01f, -8.88030753e-02f, 1.83491021e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -6.67709783e-02f, 1.18731201e-01f, -1.26023188e-01f, 5.09534106e-02f, -6.16911724e-02f, 7.44710490e-02f, 1.18273415e-01f, -1.30732507e-01f, -2.58335751e-03f, -4.29346561e-02f,
  -8.57567564e-02f, -1.34548724e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    