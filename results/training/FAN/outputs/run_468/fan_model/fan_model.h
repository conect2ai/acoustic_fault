/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.30231101e-02f, 1.81461975e-01f, 9.16809961e-02f, -4.07186858e-02f, 1.54349983e-01f, -1.48834020e-01f, -2.60736853e-01f, 1.32468745e-01f, 9.07213464e-02f, -1.34750798e-01f,
  -1.66732505e-01f, 1.76291659e-01f, -1.24639990e-02f, -1.60036221e-01f, -1.03374116e-01f, -1.09628983e-01f, -2.06368327e-01f, -1.29400074e-01f, 1.33837491e-01f, -3.79860178e-02f,
  1.07218377e-01f, -1.92430615e-01f, 7.61756375e-02f, 1.16894394e-01f, 4.84850742e-02f, 1.40202492e-01f, -1.23991864e-02f, 4.91983593e-02f, -1.90153234e-02f, 2.30641682e-02f,
  -5.99202141e-03f, 1.96919478e-02f, 2.78107030e-03f, 9.36563686e-02f, -6.41928986e-02f, -1.08327955e-01f, -4.27678972e-02f, 9.69115831e-03f, 5.27787730e-02f, -2.51195990e-02f,
  5.86325116e-03f, 4.45909500e-02f, 6.63715452e-02f, 8.80732164e-02f, 8.87985751e-02f, 1.55295551e-01f, 4.54479232e-02f, 1.26039116e-02f, 6.50350079e-02f, 1.04108736e-01f,
  4.90582660e-02f, 1.82459019e-02f, -1.59030613e-02f, -1.26932375e-02f, 1.19160451e-01f, -2.69904919e-02f, -1.38592497e-02f, -7.06186891e-03f, -7.94662815e-03f, 5.96470125e-02f,
  6.37246587e-04f, -2.97555719e-02f, -2.39040479e-02f, -3.32630053e-03f, -3.22744548e-02f, -3.01248040e-02f, 2.79371534e-03f, -3.18397470e-02f, 1.96090736e-03f, -5.22215851e-02f,
  -1.11491896e-01f, 3.42321508e-02f, 7.74561614e-03f, 2.30710506e-02f, -7.80299902e-02f, -2.56435219e-02f, -4.89336103e-02f, 4.42166813e-02f, -3.26642171e-02f, -5.00718392e-02f,
  1.97134353e-02f, -2.94509884e-02f, 1.32118845e-02f, -8.69265199e-02f, 2.63882801e-03f, 1.35968823e-03f, 5.33648208e-02f, 7.46652856e-02f, -4.46377322e-03f, -3.01756524e-02f,
  -1.97946340e-01f, -2.60230643e-03f, 9.83731169e-03f, 4.79305573e-02f, -6.68377951e-02f, 4.45751175e-02f, 2.49973871e-02f, 9.30754468e-02f, 8.92861839e-03f, 8.43804702e-03f,
  8.78382400e-02f, -5.80136813e-02f, -6.30508810e-02f, -2.43024174e-02f, -3.12196128e-02f, -1.04016714e-01f, -1.16102532e-01f, -4.72336672e-02f, -6.65641129e-02f, 1.81118976e-02f,
  -5.19941449e-02f, -4.55183946e-02f, -9.29924846e-03f, -4.14503887e-02f, -2.33179498e-02f, -3.82349337e-03f, -2.56765746e-02f, -3.67079824e-02f, -6.40425086e-02f, -5.98087488e-03f,
  -3.48893225e-01f, -1.50899351e-01f, -8.42273682e-02f, -4.23507392e-02f, 1.22208521e-02f, 2.52314378e-02f, 1.72670528e-01f, -1.98586360e-02f, -9.90797579e-02f, 9.55862179e-02f,
  1.56026363e-01f, -2.05741510e-01f, 4.62965071e-02f, 1.89162508e-01f, -1.35302410e-01f, -3.39948386e-02f, 5.04749231e-02f, -3.06475698e-03f, -5.52149639e-02f, -4.66177911e-02f,
  -6.70182109e-02f, 1.59762844e-01f, 1.08940303e-01f, 2.46984754e-02f, 2.17755139e-02f, -4.31699529e-02f, 1.70821607e-01f, 3.66716832e-02f, 6.77747130e-02f, 4.82901074e-02f,
  -4.21621930e-03f, -5.68956882e-02f, 3.73118185e-02f, -3.51285785e-02f, 4.55115475e-02f, 1.14384508e-02f, 1.59374177e-02f, -2.03984994e-02f, 1.09520853e-02f, 3.94842066e-02f,
  -4.15986963e-02f, -1.88540127e-02f, 4.41672839e-02f, -4.60561886e-02f, 7.52241444e-03f, 4.36625481e-02f, -8.56523812e-02f, 3.16024125e-02f, -1.83113590e-02f, -2.82664336e-02f,
  -8.50447193e-02f, -4.57944684e-02f, 1.45006850e-02f, 1.70466285e-02f, 1.85907371e-02f, -5.00996932e-02f, 2.23296303e-02f, -2.55774856e-02f, -4.22642902e-02f, -3.70687693e-02f,
  -9.22629535e-02f, -4.58432399e-02f, -6.92427903e-02f, 6.70520887e-02f, -3.94418463e-02f, 3.87906879e-02f, -3.12358718e-02f, 3.44073102e-02f, -3.78070958e-02f, 2.12112051e-02f,
  9.94301867e-03f, -3.26678716e-02f, 4.99483906e-02f, -3.73963118e-02f, -3.43620367e-02f, 4.82912138e-02f, -4.58422042e-02f, 6.14568852e-02f, -5.55168428e-02f, 5.10067381e-02f,
  1.12677058e-02f, 6.49930397e-03f, 4.64410195e-03f, 1.09595796e-02f, 4.31036204e-02f, -1.30299348e-02f, 2.82570850e-02f, -2.80996319e-02f, 6.51141778e-02f, -1.35452999e-02f,
  -1.00780092e-02f, -2.88935844e-02f, 5.64471483e-02f, -1.28272651e-02f, 1.53049175e-02f, -1.20971994e-02f, -3.18734348e-03f, 3.60046402e-02f, -2.09403187e-02f, -6.39961436e-02f,
  2.19460800e-02f, 1.17680589e-02f, -7.03025162e-02f, 8.33031014e-02f, 3.57699720e-03f, 2.25897646e-03f, 4.41872217e-02f, -1.40951527e-03f, 4.32389528e-02f, -2.79537868e-02f,
  2.69618444e-02f, -2.57566925e-02f, 5.18351942e-02f, 6.40529692e-02f, 2.57125590e-02f, 3.54889929e-02f, 3.39270825e-03f, -8.06600824e-02f, 6.94381967e-02f, -1.15311490e-02f,
  -5.73554598e-02f, 1.29959375e-01f, -1.88281104e-01f, 1.93614922e-02f, -1.82520196e-01f, 2.91682053e-02f, 9.01529863e-02f, -7.49209896e-02f, -7.53967464e-02f, 1.29860327e-01f,
  2.23303773e-03f, -9.99606401e-02f, 8.77650082e-02f, 7.82678723e-02f, 5.46081690e-03f, 1.85129955e-01f, 7.66869187e-02f, 9.73519534e-02f, 3.15868333e-02f, 9.32951178e-03f,
  2.67131142e-02f, 1.12606563e-01f, -2.41773557e-02f, -6.92850575e-02f, -1.38141274e-01f, -6.38565645e-02f, 4.84748110e-02f, -1.61194783e-02f, -4.39294949e-02f, -4.44851862e-03f,
  3.37901488e-02f, -1.96083430e-02f, -1.14781752e-01f, -7.69846216e-02f, -5.73504530e-02f, -1.02606982e-01f, -3.81823629e-02f, -1.97080988e-02f, -6.55289888e-02f, -4.48379479e-03f,
  -2.82449443e-02f, -8.06051940e-02f, 5.07596396e-02f, 3.22227143e-02f, -6.76980764e-02f, -2.84147672e-02f, 2.40618223e-03f, -4.25192378e-02f, -1.48354173e-01f, -3.63127701e-02f,
  -7.42652267e-02f, -3.10599431e-02f, -5.06644472e-02f, 2.87478082e-02f, -8.11054185e-02f, -2.05480829e-02f, -4.61827926e-02f, -3.01615000e-02f, -1.22259753e-02f, -1.84241142e-02f,
  1.27302976e-02f, 1.46710305e-02f, 1.22963525e-02f, 3.78166744e-03f, 6.14264831e-02f, -6.65722007e-04f, 6.91849068e-02f, 3.84452380e-03f, 2.62617897e-02f, 1.94657613e-02f,
  -1.44665474e-02f, 3.52539644e-02f, 7.19444733e-03f, 1.04488861e-02f, 4.48711365e-02f, 5.85038550e-02f, -5.20654097e-02f, 1.98662281e-02f, -1.58743020e-02f, 2.51208595e-03f,
  2.84189321e-02f, 1.23421988e-02f, -5.58705954e-03f, -3.17768455e-02f, 3.61103341e-02f, -2.76835393e-02f, -2.08999198e-02f, -4.11244482e-02f, -2.69234180e-02f, 5.75235635e-02f,
  1.24106213e-01f, 2.52483964e-01f, 2.58183628e-02f, -5.18299602e-02f, 1.46832943e-01f, 4.93929870e-02f, 1.80173479e-02f, 4.47979476e-03f, 9.64520499e-02f, 4.10703570e-02f,
  -6.08422384e-02f, 3.67982648e-02f, -1.28747476e-02f, 1.99108217e-02f, -1.78572871e-02f, 1.48900645e-02f, 3.99017287e-03f, -1.60341039e-02f, 7.98692368e-03f, -2.74601635e-02f,
  3.69717218e-02f, 2.19428502e-02f, 3.17988768e-02f, -7.80889243e-02f, -4.57399786e-02f, 5.45206014e-04f, 3.69690210e-02f, 4.63141799e-02f, -1.23703731e-02f, -2.60015801e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.86333850e-02f, -5.80464602e-02f, -1.42186582e-01f, -1.02917135e-01f, -5.19276857e-02f, -1.94536179e-01f, -1.11722678e-01f, -7.48959882e-03f, -1.48338661e-01f, 1.72673330e-01f,
  3.63251008e-02f, -2.47446802e-02f, 9.90194902e-02f, -1.63718052e-02f, -3.99639636e-01f, -1.30553432e-02f, -1.42569512e-01f, -3.95347085e-03f, -3.08977300e-03f, 1.30213037e-01f,
  -1.74398392e-01f, 1.65739395e-02f, -4.20622937e-02f, 9.64706987e-02f, 7.01936409e-02f, 1.25854582e-01f, 6.09883144e-02f, -4.36267676e-03f, 1.01166844e-01f, 1.36985397e-02f,
  5.08898124e-02f, 1.41520545e-01f, 5.80331758e-02f, -4.46763635e-02f, 2.78535150e-02f, 4.73997183e-03f, -3.25486902e-03f, -3.08418609e-02f, -2.21170913e-02f, -7.53043965e-03f,
  3.16992700e-02f, -6.04292601e-02f, -1.40072750e-02f, -1.53608369e-02f, -6.07559197e-02f, 1.42245609e-02f, -1.18800566e-01f, -4.81216125e-02f, -6.30234554e-02f, 4.53525921e-03f,
  1.16980635e-02f, -4.61487509e-02f, -1.11843541e-01f, -6.41187876e-02f, -7.11110011e-02f, 4.45919409e-02f, -4.15158905e-02f, 5.13792485e-02f, 1.12865828e-02f, -5.10781184e-02f,
  9.17145535e-02f, 1.10263847e-01f, -2.83470750e-02f, -4.83306795e-02f, -1.06806219e-01f, 4.98463660e-02f, 5.58818541e-02f, 7.14592487e-02f, -1.42182922e-03f, -3.45122404e-02f,
  -5.78132607e-02f, -3.43941301e-02f, 1.10885851e-01f, 6.86908066e-02f, 4.32789698e-03f, 5.38368523e-02f, 1.08297132e-01f, -3.65081728e-02f, -1.77569985e-01f, 1.37082320e-02f,
  2.12449227e-02f, 1.63340252e-02f, -8.53034481e-02f, 1.59729198e-02f, 7.42362067e-02f, 2.46433392e-02f, -4.50370908e-02f, 7.22628981e-02f, -7.29503855e-02f, -5.83348647e-02f,
  4.67084087e-02f, 1.08953141e-01f, -4.32023332e-02f, -1.20651694e-02f, -1.75485723e-02f, 1.55133074e-02f, -1.77963637e-02f, -4.39361446e-02f, 1.88844167e-02f, 4.13878411e-02f,
  6.89626709e-02f, -3.91576439e-02f, 2.05388293e-02f, -8.09602961e-02f, -1.47647753e-01f, 2.47911327e-02f, -8.84870589e-02f, -7.79204303e-03f, 1.54391099e-02f, -8.56544599e-02f,
  -1.08102383e-03f, 2.61784680e-02f, -6.88507929e-02f, -4.81275916e-02f, -5.44854812e-02f, 7.59303793e-02f, 6.67922646e-02f, 7.13927448e-02f, 3.41223814e-02f, 1.99563764e-02f,
  -1.53338864e-01f, -2.88094170e-02f, -1.90526620e-01f, -1.73690304e-01f, 1.66644052e-01f, -1.56341180e-01f, -1.58110186e-01f, 1.24497011e-01f, -1.77312344e-01f, 1.85695976e-01f,
  -3.47956084e-02f, -1.77963421e-01f, -1.96552470e-01f, -3.10518563e-01f, -3.87453765e-01f, -2.00801507e-01f, -2.76068598e-01f, -2.66035765e-01f, -3.97538841e-02f, 1.50591042e-02f,
  -1.38876155e-01f, -6.38359711e-02f, -1.69623151e-01f, 2.41161376e-01f, 4.20665033e-02f, 2.30707064e-01f, 2.50269979e-01f, 1.18992075e-01f, 7.51285180e-02f, -2.83417851e-02f,
  -7.94007815e-03f, -3.59028648e-03f, -3.33179906e-02f, -1.21880449e-01f, 2.91451886e-02f, 4.12646122e-02f, -2.34328397e-03f, 1.90676022e-02f, -1.92873627e-02f, -3.26316543e-02f,
  -9.42680389e-02f, -7.53533319e-02f, -5.29440269e-02f, 1.10941038e-01f, -7.40107819e-02f, -1.01344891e-01f, -6.31733239e-02f, -7.96777532e-02f, -1.43089965e-01f, -1.34544298e-01f,
  -1.37479827e-01f, 3.97857511e-03f, -7.05270097e-02f, -2.64733881e-02f, -6.10879958e-02f, 2.33699437e-02f, 3.05243488e-02f, -1.68035412e-03f, -2.18179096e-02f, -7.39664808e-02f,
  6.71347529e-02f, -3.15904021e-02f, -1.19185150e-02f, -7.68767297e-02f, -7.17212260e-02f, -1.32910907e-02f, 4.90066456e-03f, -4.72581238e-02f, -1.36220217e-04f, 6.92601055e-02f,
  -3.16028185e-02f, -6.87408298e-02f, 5.50856330e-02f, 3.33245732e-02f, 7.65667930e-02f, -1.86544955e-02f, 2.58469526e-02f, 3.94622609e-02f, 1.69709772e-02f, 4.63199392e-02f,
  8.84249061e-03f, 7.88020343e-02f, 5.78206871e-03f, 1.22214340e-01f, -4.25585099e-02f, 6.39677048e-02f, 1.12610638e-01f, 1.44788800e-02f, 2.07964256e-02f, 9.28494800e-03f,
  1.10433079e-01f, 6.52550012e-02f, 3.86697389e-02f, -1.61961075e-02f, 5.66807762e-02f, -3.67215537e-02f, -6.54199272e-02f, -9.62542519e-02f, -3.14605944e-02f, 7.65520036e-02f,
  2.23554242e-02f, 3.86847705e-02f, 1.11347452e-01f, -8.99336040e-02f, -2.14460157e-02f, 6.75309151e-02f, 1.01405300e-01f, 1.56695202e-01f, -1.66678112e-02f, -3.01931743e-02f,
  1.05274931e-01f, -6.52407408e-02f, 3.95032763e-02f, -9.15919244e-03f, 6.35138303e-02f, 9.49444100e-02f, 1.64806634e-01f, -4.72100601e-02f, -1.58507638e-02f, -6.20469600e-02f,
  2.31635094e-01f, -3.46861124e-01f, -1.23673948e-02f, 2.18561158e-01f, 1.94790393e-01f, 6.29077256e-02f, 2.75564164e-01f, -1.16940625e-01f, -1.27274528e-01f, -3.11183512e-01f,
  2.74831317e-02f, -1.53036360e-02f, -1.63244158e-02f, -7.86535442e-02f, 3.31757128e-01f, -1.38657585e-01f, 5.19512817e-02f, 4.52524796e-02f, -3.28944288e-02f, -7.46487156e-02f,
  8.74346644e-02f, 1.92450151e-01f, 3.27082239e-02f, -1.20484874e-01f, -4.13983092e-02f, -1.09247386e-01f, 1.33914083e-01f, 7.64390454e-02f, -3.56443003e-02f, 8.33771452e-02f,
  6.15174919e-02f, -8.56247321e-02f, 8.07800591e-02f, -5.58684813e-03f, -1.13937333e-01f, -4.93338592e-02f, 7.50011653e-02f, 1.65054351e-01f, 1.36813387e-01f, -5.61002530e-02f,
  -1.21026840e-02f, -5.70753366e-02f, -3.81887630e-02f, 1.49650171e-01f, -2.82838941e-02f, -1.01008900e-02f, -5.19586466e-02f, -2.32372433e-02f, -1.27808660e-01f, -3.26075256e-02f,
  -3.57320793e-02f, -5.37458174e-02f, 5.33715263e-02f, -4.48647626e-02f, -2.19420660e-02f, -2.53559854e-02f, -5.47104999e-02f, 3.46017405e-02f, -5.65727055e-02f, -4.37349081e-02f,
  -7.50290751e-02f, -3.02755809e-03f, -7.89389759e-02f, -8.09730496e-03f, 4.52127494e-02f, 3.99705991e-02f, 1.24192443e-02f, 2.52178889e-02f, 5.00261784e-02f, -4.17707786e-02f,
  3.13837007e-02f, 7.00770468e-02f, -2.74520973e-03f, 7.50294402e-02f, 8.01425651e-02f, -3.39356903e-03f, 9.03367028e-02f, 3.90758030e-02f, -4.47174422e-02f, 3.77612859e-02f,
  4.35151812e-03f, 1.99549031e-02f, 3.81044559e-02f, -8.23392272e-02f, 7.80781126e-03f, 2.88309460e-03f, -5.17294146e-02f, 3.21229659e-02f, 5.17294407e-02f, 4.31881361e-02f,
  -6.15745112e-02f, -2.63667136e-01f, -2.22123172e-02f, 8.24957117e-02f, -2.22142711e-02f, -3.08961351e-03f, -5.84435426e-02f, -6.15762398e-02f, 8.36913660e-02f, 2.51281373e-02f,
  2.59541143e-02f, 1.01824664e-02f, 1.69285890e-02f, -3.36790719e-04f, 8.13345518e-03f, 9.23344959e-03f, -2.11437866e-02f, 1.31914513e-02f, -3.90380323e-02f, -3.37650366e-02f,
  -4.68797572e-02f, 9.10376851e-03f, 3.85384895e-02f, -4.01518270e-02f, 1.52009353e-02f, -5.41042164e-02f, 1.25699220e-02f, -3.39742638e-02f, 3.08471043e-02f, 1.21435169e-02f,
  -8.97967368e-02f, 2.59225890e-02f, -3.06262881e-01f, 2.37945065e-01f, -1.69966176e-01f, 7.85993412e-02f, -4.24110815e-02f, 6.85730726e-02f, -2.26950958e-01f, 2.77128845e-01f,
  2.73538440e-01f, -4.50439267e-02f, -1.17513828e-01f, 5.28601050e-01f, 9.64008719e-02f, 6.91542849e-02f, 3.49657923e-01f, 2.18750119e-01f, 8.64259154e-02f, 1.06855929e-01f,
  2.41280392e-01f, 4.63126779e-01f, 1.99209556e-01f, 2.03149274e-01f, 1.41352907e-01f, -7.88569730e-03f, 2.09742367e-01f, -1.13828376e-01f, 3.70579064e-01f, 7.96678513e-02f,
  -1.13348477e-03f, -6.24256395e-02f, -3.25287506e-02f, -6.97611645e-02f, -6.75725862e-02f, -7.11421520e-02f, -3.10275070e-02f, -7.21137896e-02f, -8.93561263e-03f, 4.90895435e-02f,
  -1.35456383e-01f, 7.83136208e-03f, -4.14713770e-02f, 8.98667052e-03f, 3.85854356e-02f, -6.06869347e-02f, 3.46800685e-02f, -5.42711504e-02f, -1.04355767e-01f, -4.84408960e-02f,
  -5.32586016e-02f, 1.80018675e-02f, 7.72304181e-03f, -3.26215550e-02f, 5.95560521e-02f, 7.63837621e-02f, 1.64650138e-02f, -1.86331030e-02f, -5.02950847e-02f, 9.51267183e-02f,
  5.72189204e-02f, -7.43875653e-02f, 9.46682096e-02f, 6.80663995e-03f, 1.92582663e-02f, 5.51688187e-02f, 8.19429681e-02f, 6.50662035e-02f, 2.83988770e-02f, 5.85536771e-02f,
  1.50320390e-02f, -2.38539465e-02f, 4.53683063e-02f, 8.49874504e-03f, 1.23740055e-01f, -7.34644458e-02f, 3.80653678e-03f, 2.98721306e-02f, -6.40156865e-02f, 5.11146896e-02f,
  1.04788989e-01f, 4.58429419e-02f, 2.00856905e-02f, 1.83550995e-02f, -4.46384624e-02f, -3.28590237e-02f, 5.04811555e-02f, 4.98960279e-02f, -8.08923990e-02f, -3.04085426e-02f,
  1.82103857e-01f, 4.50994968e-02f, -4.42099907e-02f, 7.30890129e-03f, -8.31300616e-02f, 1.89013209e-03f, -5.68254367e-02f, 9.23239440e-03f, 4.31512222e-02f, -5.93124367e-02f,
  -5.23269847e-02f, -1.53790573e-02f, -4.17332016e-02f, -1.94872729e-02f, -5.05711697e-02f, 9.07867961e-03f, 4.76710200e-02f, -4.31948490e-02f, 1.00751005e-01f, 9.26687121e-02f,
  -6.27542287e-02f, -1.27541304e-01f, -1.05109356e-01f, -6.07839189e-02f, 3.82605419e-02f, 3.59114297e-02f, -2.74879895e-02f, -1.43344045e-01f, -4.27515358e-02f, 4.78933342e-02f,
  1.86475649e-01f, -9.87691060e-02f, -3.65575790e-01f, -2.03024253e-01f, -1.83555465e-02f, 1.57147095e-01f, 1.88275903e-01f, -3.48116420e-02f, 1.86046609e-03f, 1.03180416e-01f,
  3.48950289e-02f, -1.13225505e-01f, -1.42498378e-04f, 1.32862061e-01f, 2.17408419e-01f, -1.05486676e-01f, 1.54436335e-01f, 9.96461511e-03f, -6.79398030e-02f, 1.50056466e-01f,
  -2.38848813e-02f, 2.61815727e-01f, -1.33259714e-01f, -1.15062241e-02f, 1.17945082e-01f, -5.31061627e-02f, -8.32086802e-02f, -8.56515393e-02f, -3.97954881e-02f, 1.10730305e-01f,
  4.95822169e-02f, -1.90603975e-02f, -1.08937547e-01f, -6.82189837e-02f, 1.20134495e-01f, -7.10628256e-02f, -4.11472879e-02f, 2.26943493e-02f, -3.91845703e-02f, 3.15642799e-03f,
  -6.13598153e-03f, -7.71371201e-02f, 4.86912355e-02f, 4.65338491e-02f, 7.65011683e-02f, -8.67768750e-02f, -3.15085202e-02f, -1.07019521e-01f, -5.50956689e-02f, 2.16634721e-02f,
  -6.95246011e-02f, -1.04881316e-01f, 1.18835503e-02f, -2.18694225e-01f, -2.02731043e-02f, 1.88080855e-02f, -2.04448085e-02f, -1.05725035e-01f, 2.95279436e-02f, -2.66538765e-02f,
  4.98376181e-03f, -1.74141079e-02f, 6.83307350e-02f, 2.89121177e-02f, 4.39868905e-02f, -2.60045584e-02f, -2.06456054e-02f, -3.96208167e-02f, 7.68061131e-02f, -5.41726127e-02f,
  -5.41186519e-02f, -5.06675951e-02f, -3.58961001e-02f, 2.14640703e-02f, 9.98429731e-02f, 9.52795297e-02f, 3.38416770e-02f, -4.79937578e-03f, -2.85807764e-03f, -4.94801253e-02f,
  -1.49507031e-01f, -1.92289595e-02f, 2.89225075e-02f, -1.99234067e-03f, -5.61158843e-02f, -6.90689310e-02f, -2.28013508e-02f, -1.21095334e-03f, -8.93766657e-02f, 9.04506370e-02f,
  1.24584362e-01f, 4.12422009e-02f, 2.33195536e-03f, 2.34276187e-02f, -1.41253974e-02f, 2.39609107e-02f, 5.40648811e-02f, 7.39544109e-02f, -4.79872078e-02f, 1.70076564e-02f,
  3.49965505e-02f, 4.13339660e-02f, 3.09368987e-02f, -8.38273391e-02f, -1.07414812e-01f, 1.19085573e-01f, -7.77299702e-02f, -8.15291479e-02f, -9.07748193e-02f, 3.07684634e-02f,
  4.47155647e-02f, 1.17304340e-01f, 4.17530304e-03f, -5.56335747e-02f, -4.94256169e-02f, 3.84979472e-02f, 7.48472884e-02f, -9.82995853e-02f, 1.40433898e-02f, -6.22211583e-02f,
  2.86138773e-01f, -3.02818894e-01f, 7.36589208e-02f, 3.14577699e-01f, 2.31880859e-01f, 9.31135416e-02f, 1.65082529e-01f, 8.49453807e-02f, 1.25219271e-01f, -1.87274396e-01f,
  -7.97767949e-04f, -7.11989328e-02f, -3.27676296e-01f, 2.13699825e-02f, 2.07271814e-01f, -1.92576021e-01f, 6.10561483e-02f, -8.27776566e-02f, -1.71856638e-02f, 7.66856037e-03f,
  1.76289007e-01f, 1.04401097e-01f, 1.72945913e-02f, -1.58084333e-01f, 7.28614405e-02f, 6.19234070e-02f, 5.97913750e-02f, -8.25755820e-02f, -1.46848246e-01f, 2.07655272e-03f,
  -5.47038689e-02f, 8.73196125e-02f, -3.60966250e-02f, -6.01872392e-02f, 4.70607616e-02f, -9.46124643e-03f, -1.03387885e-01f, 7.99898803e-02f, 9.17836055e-02f, -2.17794776e-02f,
  -1.46482006e-01f, -3.88862342e-02f, 1.02203593e-01f, -7.11190477e-02f, 7.18315840e-02f, -2.20006201e-02f, 3.09363045e-02f, -6.70389533e-02f, 1.54406829e-02f, -2.00449321e-02f,
  -1.33763975e-03f, -5.36008514e-02f, 4.55976464e-02f, 2.49939924e-03f, 6.30879849e-02f, 1.70482490e-02f, 4.00957018e-02f, -2.12409198e-02f, -2.19914201e-03f, 1.28309028e-02f,
  3.36511545e-02f, 2.04498358e-02f, 1.30528472e-02f, -6.41896501e-02f, 5.55521734e-02f, -4.03406238e-03f, 5.15716225e-02f, -2.13523023e-03f, -3.90386805e-02f, -5.61180823e-02f,
  4.26993892e-03f, -3.78727056e-02f, 4.53531072e-02f, -3.35123725e-02f, 8.11380148e-02f, 7.04201981e-02f, 4.05529961e-02f, -1.12005129e-01f, -5.25294011e-03f, -2.91282833e-02f,
  -5.59402592e-02f, 2.68654954e-02f, -4.86644618e-02f, 4.64062244e-02f, -3.42903249e-02f, -1.67513248e-02f, -5.19844480e-02f, 4.55007739e-02f, -3.62902172e-02f, -1.08255132e-03f,
  -3.82771283e-01f, -2.98608243e-01f, 2.38738512e-03f, -1.24089673e-01f, -8.84565637e-02f, -6.65471479e-02f, -6.57913387e-02f, 1.42711296e-03f, -3.64778675e-02f, -4.51863185e-02f,
  -2.71220077e-02f, 2.32512318e-02f, -4.22931686e-02f, 1.43989585e-02f, -7.68269226e-02f, -2.72094198e-02f, 6.60042018e-02f, -1.13485873e-01f, 1.18939914e-02f, -8.59510060e-03f,
  -6.22570924e-02f, -5.68237789e-02f, -6.51186984e-03f, 4.34646867e-02f, -3.86385433e-02f, 8.46842155e-02f, 7.78792202e-02f, -3.50014470e-03f, -9.90493074e-02f, -2.40913723e-02f,
  -5.33079766e-02f, -2.86711335e-01f, 1.51425198e-01f, -1.95763424e-01f, 2.04066500e-01f, 2.18119934e-01f, 1.70535281e-01f, -1.02853492e-01f, -3.22676301e-01f, -1.70979366e-01f,
  1.15411513e-01f, 1.34030238e-01f, 1.92403421e-01f, -2.07150757e-01f, 3.58290136e-01f, 1.17774911e-01f, -7.09275305e-02f, -1.27522601e-02f, -5.00623509e-03f, -3.81045439e-03f,
  3.75215039e-02f, -2.99416911e-02f, 1.26009315e-01f, -4.73335870e-02f, 2.59022061e-02f, -1.19681088e-02f, 6.06730990e-02f, 1.78609535e-01f, -5.85491844e-02f, 2.07826406e-01f,
  -2.50690244e-02f, -2.35799253e-01f, -4.00499180e-02f, -3.17847021e-02f, -1.15707684e-02f, 2.50984207e-02f, 9.62535199e-03f, 1.32353917e-01f, -1.76162757e-02f, -6.57540141e-03f,
  5.01212813e-02f, -2.31180005e-02f, -6.54362813e-02f, 4.98806313e-02f, -1.33829683e-01f, -1.16815418e-01f, 1.43564045e-02f, 2.53223050e-02f, -9.08567756e-02f, 1.64258122e-01f,
  3.83872539e-02f, -2.66511906e-02f, -1.88403018e-03f, 7.57632107e-02f, -4.63180151e-03f, -4.53519337e-02f, 3.03457063e-02f, 1.92296654e-01f, 9.52464640e-02f, -5.51324412e-02f,
  1.00026801e-01f, 2.29302421e-02f, -3.35182548e-02f, -8.22842941e-02f, -4.99734655e-02f, -5.87044135e-02f, -5.30337468e-02f, 6.88908324e-02f, 1.91299710e-02f, -6.24182411e-02f,
  6.24995641e-02f, -1.02424130e-01f, -1.33136168e-01f, -8.62785429e-02f, -4.63254228e-02f, -6.76246434e-02f, 8.02914873e-02f, -7.33207688e-02f, -4.96758102e-03f, -1.32316826e-02f,
  1.32676801e-02f, 3.00107989e-02f, -2.38553397e-02f, -5.74395235e-04f, -5.58355413e-02f, 4.47422527e-02f, -4.74977382e-02f, -6.03862572e-04f, -5.04143983e-02f, 3.44463587e-02f,
  -1.56899244e-02f, -2.65107423e-01f, -3.11537124e-02f, 1.00891571e-02f, 3.05265337e-02f, 1.85652226e-02f, -8.54488686e-02f, -1.16916470e-01f, 2.69523878e-02f, -7.05008060e-02f,
  -3.68959755e-02f, 3.79576907e-02f, -1.26362443e-01f, -2.05909926e-02f, 5.85553721e-02f, -1.32001366e-03f, -1.14747253e-03f, 1.70421135e-02f, -2.01629531e-02f, -5.12998104e-02f,
  -2.97404323e-02f, 3.78654711e-02f, 1.51933342e-01f, -1.21702693e-01f, -3.87623683e-02f, 4.21296731e-02f, -7.66260177e-02f, 5.49937859e-02f, 7.69300014e-02f, 4.58471552e-02f,
  -2.23795429e-01f, -1.49141029e-01f, -3.24333698e-01f, -1.07401043e-01f, 1.98272556e-01f, 1.78885341e-01f, 1.87188517e-02f, 2.13313871e-03f, -1.46040753e-01f, 1.24166161e-01f,
  1.41159087e-01f, -4.23721448e-02f, -3.22560035e-02f, 7.01668113e-02f, 5.78376502e-02f, -6.73736930e-02f, 3.34571600e-02f, 2.68381480e-02f, -1.16376266e-01f, 2.57350598e-02f,
  4.39286092e-03f, 1.19975038e-01f, -1.18921146e-01f, 4.91376966e-04f, 1.86454430e-01f, -1.82281416e-02f, 1.42227694e-01f, -2.02740096e-02f, 1.82192847e-01f, -1.54154394e-02f,
  7.80769438e-02f, -8.21672976e-02f, -9.12124142e-02f, -1.26358464e-01f, -9.16372985e-03f, -3.16925198e-02f, -8.12319219e-02f, 7.59788528e-02f, 5.36619052e-02f, 4.69157621e-02f,
  5.85291982e-02f, 6.05314644e-03f, -2.58517154e-02f, -9.62200761e-02f, -2.24229675e-02f, -1.30403815e-02f, 1.14839815e-01f, -2.17658337e-02f, 1.29276946e-01f, 4.45477255e-02f,
  -7.42234811e-02f, 4.60995315e-03f, -1.43341705e-01f, 5.68621513e-03f, 6.94896281e-02f, 2.83444412e-02f, 1.32163120e-02f, -9.07362439e-04f, 5.60990013e-02f, 7.80328438e-02f,
  1.27192676e-01f, -1.71972085e-02f, 7.03387335e-02f, -5.38033433e-02f, -3.05067804e-02f, 8.13093688e-03f, -4.62331139e-02f, 4.06756140e-02f, -4.46637645e-02f, 4.77659404e-02f,
  5.89690916e-02f, 3.38677540e-02f, 2.25495305e-02f, -1.91266891e-02f, -5.22397831e-02f, -7.44157657e-02f, -1.01220176e-01f, 6.34465516e-02f, 6.60735965e-02f, -9.94125009e-03f,
  -4.93697524e-02f, -1.00901715e-01f, 1.77733749e-01f, -6.39137626e-02f, 6.00168742e-02f, -3.86753716e-02f, -3.92797068e-02f, -5.61662503e-02f, -1.54967368e-01f, -6.89747110e-02f,
  1.23329759e-02f, 5.87942898e-02f, -1.32860094e-02f, 2.29542796e-02f, 2.73677651e-02f, 1.86487526e-01f, -1.30717605e-01f, -3.31835374e-02f, 1.82540417e-02f, 9.25943069e-03f,
  1.05334766e-01f, -2.82185115e-02f, -5.44175785e-03f, 8.01993087e-02f, -4.01493162e-02f, 2.07663588e-02f, 2.86684260e-02f, 5.36455363e-02f, 1.39467940e-01f, 1.14085622e-01f,
  2.05762102e-03f, 1.40221491e-01f, -6.55454621e-02f, 8.50683600e-02f, 3.66841964e-02f, 1.43867629e-02f, 3.13751325e-02f, 7.33634681e-02f, 1.07492963e-02f, -5.14971167e-02f,
  9.66646746e-02f, 2.73102224e-01f, 1.45179451e-01f, 2.02266067e-01f, -8.87568071e-02f, -1.53608173e-01f, -1.48242027e-01f, -7.21705556e-02f, 7.65600130e-02f, 4.55634370e-02f,
  -1.31611437e-01f, 1.94724426e-01f, 1.60271898e-02f, 8.37568715e-02f, 1.66881129e-01f, 6.36660233e-02f, 1.61501259e-01f, -2.06679776e-02f, 1.44603133e-01f, 1.38110831e-01f,
  1.19977526e-01f, 1.08668104e-01f, 2.13168755e-01f, 1.03634872e-01f, 7.56286830e-02f, 9.99155641e-03f, 2.78493822e-01f, 2.20739245e-02f, -3.96634731e-03f, -3.80044095e-02f,
  -4.19715084e-02f, 1.32593373e-02f, 3.99190448e-02f, 2.18995847e-02f, 6.17297925e-02f, -8.51356983e-02f, -7.81083331e-02f, -6.77532032e-02f, -3.13993497e-03f, -6.01744913e-02f,
  1.21410847e-01f, 2.51252372e-02f, 6.06077053e-02f, 5.89825921e-02f, -5.51880747e-02f, 1.22966446e-01f, 4.66553569e-02f, 3.96875963e-02f, 6.57833591e-02f, -1.47619983e-02f,
  1.27686858e-01f, -9.14443359e-02f, 1.79382022e-02f, 5.36300316e-02f, 2.01757345e-02f, 1.11835510e-01f, 3.13280262e-02f, 4.42219265e-02f, 6.90139160e-02f, 6.20607436e-02f,
  -6.91832160e-04f, -1.84798166e-02f, -6.33106232e-02f, -1.07927956e-01f, 2.78689321e-02f, -6.08969070e-02f, -4.16956767e-02f, 6.56762943e-02f, 3.73538323e-02f, 2.85657891e-03f,
  -7.49965059e-03f, -6.72463551e-02f, -6.67455718e-02f, -5.63015649e-03f, 3.27418670e-02f, 4.93941233e-02f, -7.55376518e-02f, -6.49434179e-02f, 4.24752869e-02f, 5.78075275e-02f,
  7.50238970e-02f, 3.71274166e-02f, -8.61677621e-03f, -2.45962664e-03f, 1.83161236e-02f, -6.09531775e-02f, 5.85337877e-02f, -2.04399740e-03f, 2.86963228e-02f, -3.21318321e-02f,
  9.47544798e-02f, 2.78415054e-01f, -3.02743521e-02f, 7.02039376e-02f, 4.64167893e-02f, 2.08473187e-02f, 6.25750422e-02f, -1.42032458e-02f, 1.66516602e-01f, 4.22881953e-02f,
  2.24983431e-02f, -1.07808262e-02f, -3.78703736e-02f, -2.41024606e-02f, -5.96429557e-02f, 1.12421894e-02f, 7.53729567e-02f, 1.36748120e-01f, 8.53751674e-02f, 2.93733142e-02f,
  -7.14623109e-02f, -2.88683120e-02f, -4.22795378e-02f, 1.27579854e-03f, 3.41746248e-02f, 4.78113592e-02f, -6.65073320e-02f, -8.61174613e-02f, 3.86910327e-02f, 6.99962154e-02f,
  -3.91869098e-01f, 2.33004801e-02f, -9.71677750e-02f, -2.05895022e-01f, 1.97267771e-01f, -8.01305771e-02f, -1.56682938e-01f, 2.03786403e-01f, -8.00353214e-02f, 1.35559276e-01f,
  8.63524526e-02f, -7.96385705e-02f, 9.36067477e-02f, -1.18657641e-01f, -4.62758303e-01f, -2.57209837e-01f, -3.78414452e-01f, -1.73044518e-01f, -9.82939154e-02f, 2.03311518e-02f,
  -2.07101688e-01f, 9.97899286e-03f, -2.19769523e-01f, 2.19514385e-01f, 6.92518353e-02f, 7.23510906e-02f, 7.91157261e-02f, 2.68804014e-01f, -1.01645309e-02f, -4.14691456e-02f,
  1.74110103e-03f, 1.34643659e-01f, -4.78093103e-02f, 9.29808021e-02f, 3.28838676e-02f, -5.50997676e-03f, 6.58159852e-02f, -1.88219582e-03f, 3.66656892e-02f, -5.29518425e-02f,
  2.27169134e-02f, -4.45100330e-02f, 1.63419042e-02f, 3.13984193e-02f, 1.10592499e-01f, 5.25225289e-02f, 5.58424275e-03f, -1.03236586e-01f, -5.13521060e-02f, 1.90200657e-02f,
  -1.26962818e-03f, -2.98261419e-02f, -1.09126732e-01f, -3.60261649e-02f, -6.58848584e-02f, -4.93523059e-03f, -1.36515960e-01f, 1.61818322e-02f, 2.36967653e-02f, -2.77426075e-02f,
  -4.76882122e-02f, 8.52257088e-02f, -5.93459904e-02f, 6.46329001e-02f, -2.59497222e-02f, 7.22694322e-02f, 5.06890863e-02f, 4.73916531e-02f, -3.05740479e-02f, -5.70373610e-03f,
  -7.04697520e-02f, 8.25561732e-02f, -4.98334877e-02f, -1.58355281e-01f, -8.11424293e-03f, -9.94859114e-02f, -3.60969231e-02f, -1.36182718e-02f, -4.82916506e-03f, -4.44616452e-02f,
  8.17859620e-02f, -2.83283833e-02f, -4.09688689e-02f, -2.51161028e-02f, 4.90096733e-02f, 2.00540689e-03f, -9.54187475e-03f, -5.54984920e-02f, -4.25180867e-02f, 1.09582376e-02f,
  2.04248913e-02f, 5.72723709e-02f, -5.32871597e-02f, 9.27478448e-02f, -1.69414449e-02f, -3.53125557e-02f, -5.17697074e-02f, -3.73885036e-02f, 1.60466079e-02f, -5.55464579e-03f,
  2.81245075e-02f, -2.33264323e-02f, -6.63500605e-03f, -8.16131383e-02f, -6.43354803e-02f, -2.56344844e-02f, 7.44574144e-02f, 6.56420216e-02f, 4.44909483e-02f, 3.53775732e-02f,
  -2.30003968e-02f, 3.30850035e-02f, -1.79446433e-02f, -1.29983239e-02f, -3.43476757e-02f, -1.97408684e-02f, -4.52318415e-02f, 7.38448724e-02f, 3.70480008e-02f, 6.72316402e-02f,
  -1.29598036e-01f, -2.26193690e-03f, -2.51412809e-01f, -2.13944316e-01f, -2.33216062e-01f, -3.06175441e-01f, -2.88298994e-01f, -1.51858762e-01f, 3.64882201e-02f, 2.86009610e-01f,
  1.05480030e-01f, 1.62028987e-02f, 2.58392990e-01f, -1.17408037e-01f, -1.08320033e-02f, 2.62116939e-01f, -2.55161226e-01f, -1.14467911e-01f, -2.68690251e-02f, -3.14688414e-01f,
  -1.53322116e-01f, -1.47792757e-01f, -1.46536589e-01f, -1.75692469e-01f, -2.76208699e-01f, -4.33869250e-02f, 1.29890023e-02f, -1.92618459e-01f, -9.28904861e-02f, -9.94538814e-02f,
  -5.62959351e-02f, -4.24439739e-03f, -1.25434265e-01f, 9.15466901e-03f, -1.30160898e-01f, -9.32936519e-02f, -1.23916902e-01f, -5.00178672e-02f, -3.08660418e-02f, 1.80094112e-02f,
  8.26979429e-03f, -3.29517312e-02f, -9.78151336e-03f, 6.60838634e-02f, -4.62054461e-02f, -9.05672163e-02f, -1.96769182e-02f, -8.20154250e-02f, 1.02030598e-02f, -7.82656372e-02f,
  -1.32417262e-01f, -8.99433270e-02f, -8.69618505e-02f, 7.63513893e-02f, -5.24694249e-02f, -6.31436706e-02f, 5.03475294e-02f, -5.07778637e-02f, -5.26774451e-02f, -5.73105924e-02f,
  -5.11938073e-02f, -1.05837665e-01f, -2.87621077e-02f, 4.12070565e-03f, 4.14893311e-03f, -2.28315853e-02f, -4.08503264e-02f, -3.26357000e-02f, -4.69568819e-02f, -9.51348022e-02f,
  1.41924322e-02f, -7.11197406e-02f, 3.18083540e-02f, -8.71802866e-02f, 2.11308729e-02f, 6.49533346e-02f, 6.48065060e-02f, -1.59613118e-02f, 1.29392045e-02f, 4.84650582e-02f,
  1.51788606e-03f, -4.77522276e-02f, 1.07503803e-02f, -7.51422392e-03f, -6.10263683e-02f, 1.02790996e-01f, -4.23649848e-02f, 7.45655671e-02f, -1.54336251e-03f, 9.27324221e-03f,
  -8.70071128e-02f, -1.92227140e-01f, -8.89281090e-03f, -1.06098719e-01f, -1.35328406e-02f, -4.89491411e-02f, 5.06029613e-02f, -3.95154767e-02f, -4.86200489e-02f, -1.24708764e-01f,
  -4.78191748e-02f, -4.36601304e-02f, -6.59807026e-02f, 1.28435090e-01f, 1.21560432e-01f, 8.88223946e-03f, -4.53274371e-03f, 5.90807498e-02f, -8.33986998e-02f, -6.51208013e-02f,
  -7.62535855e-02f, 5.60038015e-02f, 4.56870645e-02f, -4.34456766e-03f, -1.09346546e-02f, 7.22987577e-02f, 2.50748564e-02f, -3.37582305e-02f, -2.49533486e-02f, -5.73807135e-02f,
  2.00096905e-01f, -2.65710950e-01f, 1.36021316e-01f, -6.59478158e-02f, 2.77162552e-01f, 2.33449176e-01f, 2.76651621e-01f, 1.80600673e-01f, -1.14508076e-02f, -2.45713159e-01f,
  -6.10368177e-02f, -2.86592841e-01f, -6.66568661e-03f, -2.23575994e-01f, 1.44906864e-01f, -3.72535959e-02f, -4.03242484e-02f, -1.71500564e-01f, 1.37218431e-01f, -9.40220878e-02f,
  -1.64458305e-02f, -2.58821361e-02f, 2.26178274e-01f, -1.38997003e-01f, 1.02477677e-01f, -2.10758932e-02f, -3.07861511e-02f, 1.92677647e-01f, -1.70806289e-01f, 6.63259253e-02f,
  -7.08271191e-02f, -1.39253601e-01f, -2.94796831e-04f, -1.02748238e-01f, -3.28179710e-02f, -1.89616978e-02f, -4.91697043e-02f, -1.40560698e-02f, -1.93544906e-02f, 3.60908732e-02f,
  -3.13441530e-02f, -1.19724032e-02f, 3.70152923e-03f, 7.26125538e-02f, 8.46122205e-03f, 3.28284204e-02f, 3.96831445e-02f, 2.12525744e-02f, 4.68837097e-03f, -2.26695612e-02f,
  2.51607853e-03f, 5.62345190e-03f, -1.97119471e-02f, -5.76127432e-02f, 1.88871957e-02f, 5.59511147e-02f, -2.34386884e-02f, -1.14314027e-01f, -2.57883966e-02f, 2.71128565e-02f,
  2.30407994e-02f, 8.96500796e-02f, 2.92073339e-02f, 1.08539825e-02f, -9.96930152e-02f, 3.44462832e-03f, 1.95427872e-02f, -2.95421778e-04f, -3.10036018e-02f, -6.06453344e-02f,
  -6.39282614e-02f, 3.09664644e-02f, 5.00397831e-02f, 6.92509189e-02f, 3.64404880e-02f, -2.84515489e-02f, -4.76595983e-02f, -9.46904719e-03f, -2.25452278e-02f, 4.05833051e-02f,
  6.65445626e-02f, -7.61715695e-02f, -2.22267527e-02f, 4.20244932e-02f, -1.04718685e-01f, -2.63165459e-02f, 1.06749339e-02f, -8.30984861e-02f, 4.65275347e-02f, 3.38377804e-02f,
  -2.21471235e-01f, -3.44096750e-01f, -2.89530363e-02f, -7.53975138e-02f, -2.70723384e-02f, -1.45914659e-01f, -1.68150011e-02f, -1.35073457e-02f, -9.97607186e-02f, 2.73992401e-02f,
  -9.53247175e-02f, -8.20711926e-02f, 6.61040246e-02f, 3.89004350e-02f, -5.31615354e-02f, 8.41444060e-02f, -7.66447410e-02f, -1.21871956e-01f, 6.48179650e-02f, -9.99697000e-02f,
  -3.20290811e-02f, -1.79911144e-02f, -4.48505096e-02f, 5.07925674e-02f, -1.22261226e-01f, -3.72529542e-03f, 6.28950968e-02f, 1.46396048e-02f, 3.18582430e-02f, -1.60106439e-02f,
  -1.88758578e-02f, -2.39537045e-01f, -8.59132130e-03f, -5.37361056e-02f, 1.18814483e-02f, 1.21097535e-01f, 1.14620127e-01f, -1.86862990e-01f, -3.78669441e-01f, -1.45534456e-01f,
  1.73127860e-01f, -4.92673293e-02f, -5.85897304e-02f, -2.43657857e-01f, -2.07830835e-02f, -5.16439714e-02f, -1.88658163e-01f, 7.54551068e-02f, -4.02510241e-02f, 6.70040697e-02f,
  5.37945814e-02f, 3.96861285e-02f, 4.36275825e-02f, -7.74338469e-02f, 2.46651527e-02f, -9.43036973e-02f, 1.44462481e-01f, 2.33485267e-01f, -2.92043481e-03f, -2.11800821e-02f,
  1.58400815e-02f, -2.16926001e-02f, -1.80942903e-03f, -1.07379310e-01f, 1.42878234e-01f, 4.89380099e-02f, 6.99341297e-02f, 9.42118987e-02f, -1.08583003e-01f, -5.41790798e-02f,
  7.55292848e-02f, 4.35248055e-02f, -1.48805022e-01f, -5.94485626e-02f, -6.54874966e-02f, -3.28794010e-02f, -4.36314680e-02f, -1.59581780e-01f, -7.37983435e-02f, -8.29942748e-02f,
  -7.30598941e-02f, -3.44682224e-02f, -8.15156624e-02f, 9.57615674e-03f, -1.03541829e-01f, -3.71389352e-02f, 6.19015098e-03f, 6.90984651e-02f, -8.47925991e-02f, 7.36233220e-02f,
  4.96815108e-02f, -3.00789364e-02f, 5.66970333e-02f, -7.73815811e-02f, 6.93370029e-02f, -8.52059498e-02f, -9.55771953e-02f, -4.35181968e-02f, 8.74384958e-03f, 8.57370347e-03f,
  -7.95792863e-02f, -3.46330479e-02f, -4.85588498e-02f, 1.86729748e-02f, 7.46853575e-02f, 3.99142923e-03f, 6.36376813e-02f, -9.11147892e-02f, -4.49005328e-02f, -4.87814844e-02f,
  -1.15921393e-01f, -1.85565539e-02f, -2.12251171e-02f, 3.82624082e-02f, -4.78803068e-02f, -1.63228884e-02f, -2.41402686e-02f, 4.22809646e-02f, 4.82712202e-02f, 6.41893670e-02f,
  -6.19596289e-03f, -6.16847314e-02f, -1.94085129e-02f, 2.04177499e-02f, -1.25782918e-02f, 3.64654139e-02f, 6.51025921e-02f, -2.91867163e-02f, 4.71429713e-02f, -6.51757233e-03f,
  1.65331230e-01f, -7.00325817e-02f, 1.10301629e-01f, 1.13835586e-02f, -2.23806091e-02f, -2.72172522e-02f, 6.32821694e-02f, 4.44360487e-02f, 2.88708061e-02f, 6.43321499e-02f,
  8.22855234e-02f, -4.16552946e-02f, -7.04009235e-02f, -8.47785175e-02f, -1.80896446e-02f, -4.24737157e-03f, -6.92951009e-02f, 6.27378176e-04f, -1.11510806e-01f, -4.83453162e-02f,
  -1.08425781e-01f, 1.66472986e-01f, -1.89254116e-02f, 7.63123557e-02f, 2.14761347e-01f, 5.18784344e-01f, 5.35807908e-01f, 1.45681456e-01f, 3.91343296e-01f, 3.32376361e-01f,
  8.95580500e-02f, 1.94753274e-01f, 8.60533211e-03f, 1.62224829e-01f, 5.98414503e-02f, 1.32356182e-01f, 2.26240277e-01f, 2.05033123e-01f, 3.54015678e-02f, 3.24778184e-02f,
  -7.43824020e-02f, 1.19605914e-01f, -2.43376464e-01f, -1.31210536e-01f, -9.05902982e-02f, -2.12895632e-01f, -2.73320645e-01f, -2.58716904e-02f, -8.27049017e-02f, 1.36454061e-01f,
  4.34581153e-02f, 4.30279970e-02f, -5.76291420e-02f, -1.22546386e-02f, -7.78493956e-02f, -1.55384503e-02f, -1.20335631e-02f, 7.46692484e-03f, -3.19070974e-03f, 1.04202636e-01f,
  -4.58282791e-02f, -3.97485122e-02f, 6.06266893e-02f, -3.92537145e-03f, 1.08960003e-01f, 2.42350325e-02f, -1.20499685e-01f, -2.06008986e-01f, 6.21532388e-02f, -7.20152110e-02f,
  -7.82016218e-02f, -6.26384467e-02f, -2.53011901e-02f, 1.03678241e-01f, -4.78174053e-02f, 3.16335186e-02f, 3.80354561e-02f, -2.06906404e-02f, 2.22277455e-02f, 8.08020234e-02f,
  6.21418692e-02f, 9.84771624e-02f, -3.06282975e-02f, -5.45311160e-02f, -4.93526310e-02f, -1.00159287e-01f, -4.70794737e-02f, -3.82727534e-02f, -5.44788316e-02f, -9.28148255e-02f,
  5.69323823e-02f, -6.48115501e-02f, -2.34864699e-03f, -8.71491432e-02f, 9.44181532e-02f, 2.06868406e-02f, 5.33333234e-03f, 2.41142698e-02f, 2.91135460e-02f, -5.28282486e-02f,
  1.55334789e-02f, 4.50382344e-02f, -5.73917367e-02f, -4.48184460e-02f, -7.74919521e-03f, -2.74115484e-02f, 1.09186796e-02f, 1.12749487e-01f, -2.57755164e-02f, -5.35286330e-02f,
  1.78069472e-01f, 3.00233692e-01f, -9.16496757e-03f, -4.66974825e-02f, -2.39630397e-02f, -1.20220557e-02f, -8.66089307e-04f, 2.66988110e-02f, 7.65483007e-02f, 3.46026309e-02f,
  4.03497294e-02f, -5.58333322e-02f, 4.07042652e-02f, -2.04546414e-02f, 8.12414587e-02f, 5.83437346e-02f, 1.25686914e-01f, 5.82037866e-02f, 2.38597151e-02f, -8.18459019e-02f,
  -1.05734803e-01f, 4.51141223e-02f, -2.61576269e-02f, -1.85543820e-02f, -9.30002034e-02f, 3.03030591e-02f, 1.07053764e-01f, -7.06110289e-03f, -1.28160426e-02f, 1.51971122e-02f,
  -3.56058888e-02f, -1.48849890e-01f, 5.20201474e-02f, 3.38367164e-01f, 5.66430539e-02f, -2.41379440e-01f, -1.54729754e-01f, 1.43622786e-01f, -1.34140626e-01f, -1.18798569e-01f,
  6.00578152e-02f, -9.97083727e-03f, -2.41993293e-01f, -3.05596497e-02f, 7.68277869e-02f, -3.59474599e-01f, 1.09556830e-02f, -1.24426670e-02f, -3.47679220e-02f, 1.26219273e-01f,
  8.11809003e-02f, 8.06777403e-02f, 2.98478782e-01f, 2.91274726e-01f, -9.68350843e-02f, 3.64012122e-01f, 2.51900703e-01f, 1.68561846e-01f, 2.43598789e-01f, 8.66415203e-02f,
  -5.38437963e-02f, -9.34909359e-02f, 4.43273261e-02f, -1.23442084e-01f, 5.30765243e-02f, 1.23294301e-01f, 3.48015800e-02f, 1.91906188e-02f, -5.49727045e-02f, 2.93012359e-04f,
  -1.33797273e-01f, 1.09487616e-01f, 1.33210570e-01f, 2.56040134e-02f, 1.29028261e-01f, 2.67879083e-03f, -1.37055382e-01f, 5.92242479e-02f, -1.07733391e-01f, -9.98949558e-02f,
  -2.84362994e-02f, 1.48291970e-02f, 1.01245895e-01f, -2.30823569e-02f, 5.41518815e-02f, -5.69472164e-02f, 2.97856219e-02f, -2.97788009e-02f, 2.31046733e-02f, 1.10960126e-01f,
  -7.46777579e-02f, 2.23793481e-02f, 7.63158947e-02f, 3.83148380e-02f, -4.52457853e-02f, 3.05492207e-02f, -8.51985291e-02f, -3.89549583e-02f, 1.51448557e-02f, -5.71917258e-02f,
  -8.80045444e-03f, -2.15393398e-02f, -1.05616756e-01f, -5.32067195e-02f, -1.16860375e-01f, -5.60861789e-02f, 1.59806475e-01f, 9.14242342e-02f, 4.79257442e-02f, -5.74152768e-02f,
  -4.34566364e-02f, 2.62546595e-02f, 3.33778672e-02f, -8.02401230e-02f, -5.78802228e-02f, -1.33335562e-02f, -7.31520131e-02f, -1.15130067e-01f, -3.24423462e-02f, 3.26520875e-02f,
  3.33294347e-02f, 7.23451823e-02f, -5.09940982e-02f, -5.91762289e-02f, 2.73061451e-02f, 1.82724092e-02f, -7.48986006e-02f, 1.26599092e-02f, -1.51813077e-02f, 7.54399747e-02f,
  3.83590460e-02f, 1.36563271e-01f, 1.84806213e-02f, 4.74145226e-02f, 9.49651655e-03f, 5.12916036e-02f, 1.10544831e-01f, 8.11833218e-02f, 1.63409427e-01f, 1.58663224e-02f,
  1.27077261e-02f, -3.47672477e-02f, 7.32630044e-02f, 5.83164059e-02f, -2.22450364e-02f, -6.75133988e-03f, 8.60349610e-02f, 1.11475512e-01f, 4.01704200e-02f, -8.41048062e-02f,
  -1.85892731e-01f, 1.50292628e-02f, -2.76973605e-01f, -3.83243733e-03f, 2.24551409e-01f, 1.71043009e-01f, -1.27589583e-01f, 4.25388590e-02f, -2.57523447e-01f, 1.14469074e-01f,
  6.87225685e-02f, -2.30885744e-01f, -2.87020743e-01f, 8.55674073e-02f, -5.85739780e-03f, -1.78718939e-01f, 2.40581915e-01f, 5.80003560e-02f, -2.12370783e-01f, -1.70019791e-02f,
  -6.05007000e-02f, 1.70412734e-01f, -2.28799984e-01f, 2.35230580e-01f, 1.78906664e-01f, -4.07084897e-02f, 2.04249069e-01f, -1.70897275e-01f, 2.53858805e-01f, 5.02144136e-02f,
  -6.33851439e-02f, -3.32445763e-02f, -1.37632161e-01f, -5.47513627e-02f, -1.67447925e-02f, 1.43394217e-01f, 3.29911970e-02f, -1.82979107e-02f, -1.13532506e-01f, -6.71528578e-02f,
  7.69573599e-02f, -4.39398624e-02f, 4.95747961e-02f, 2.89459387e-03f, -1.15590412e-02f, -5.39764110e-03f, -1.44585893e-01f, -8.57630074e-02f, -4.97268625e-02f, -2.14937404e-02f,
  -4.96927537e-02f, 1.05213441e-01f, 8.56274441e-02f, 5.84581979e-02f, -3.18340361e-02f, -2.26902347e-02f, 4.52382676e-02f, -1.04364790e-01f, 7.72923306e-02f, -3.82396877e-02f,
  6.40945509e-02f, 6.75603300e-02f, -2.02703085e-02f, 7.04761455e-03f, -4.16827574e-02f, -2.92316005e-02f, 3.20427120e-02f, -1.71386600e-02f, -7.63108730e-02f, -2.41634157e-02f,
  -2.48412043e-02f, 6.09084824e-03f, 4.31888737e-02f, 9.34406891e-02f, 2.44944692e-02f, 7.03630447e-02f, -1.96390245e-02f, 1.39115257e-02f, 5.59461676e-03f, 5.73718660e-02f,
  2.48471517e-02f, -3.40640247e-02f, -1.01067543e-01f, 8.31142813e-03f, 2.21963134e-02f, -6.29432946e-02f, 9.62679088e-02f, -8.36016238e-02f, 6.73700944e-02f, 1.31285608e-01f,
  1.68306112e-01f, 1.33341655e-01f, -2.68751793e-02f, 1.04708374e-01f, -2.45858338e-02f, 3.07812896e-02f, -6.69120103e-02f, 3.50944400e-02f, -3.45975049e-02f, -4.13428955e-02f,
  9.72942337e-02f, -5.79396612e-04f, 4.39791307e-02f, 4.19542659e-03f, 5.84202819e-02f, 7.68960267e-02f, 7.52341971e-02f, 6.04231097e-02f, 1.56165501e-02f, 5.03386483e-02f,
  6.99031204e-02f, 2.14907620e-02f, 3.69545184e-02f, 5.45894466e-02f, 5.95059805e-02f, 1.01202857e-02f, -5.15817106e-02f, -3.92309390e-02f, 7.10240901e-02f, 3.53681971e-04f,
  2.04168618e-01f, 1.67827263e-01f, 1.78388432e-01f, 1.98458165e-01f, -1.87474608e-01f, -1.71117693e-01f, -1.45920619e-01f, 1.53366327e-01f, -1.12358987e-01f, -1.20992184e-01f,
  7.48817297e-03f, 3.85610312e-02f, 1.99793354e-02f, 1.24280713e-01f, 8.19760561e-02f, -7.51149431e-02f, 1.36320308e-01f, -4.10760418e-02f, -8.13553259e-02f, 8.05802345e-02f,
  8.15049633e-02f, 1.09526768e-01f, 1.65039152e-01f, 3.68866846e-02f, 1.14733748e-01f, 1.42114311e-01f, 1.78217068e-01f, -7.88907707e-03f, 2.19138432e-02f, -1.07778557e-01f,
  7.29624033e-02f, 6.54328540e-02f, 2.76112501e-02f, 1.30774705e-02f, 5.08279055e-02f, -7.53687918e-02f, -3.78617682e-02f, 7.43983826e-03f, -1.11702077e-01f, 1.92797035e-02f,
  -2.83902194e-02f, -6.29971102e-02f, 3.09920814e-02f, 5.76227382e-02f, -4.41054553e-02f, 6.15692623e-02f, 4.33066227e-02f, -1.87157243e-02f, -4.28132005e-02f, 2.67900657e-02f,
  6.09281249e-02f, -6.75136447e-02f, 1.24210678e-02f, -5.43035902e-02f, -3.42624523e-02f, -2.34804414e-02f, -3.95807773e-02f, 8.16695839e-02f, 9.14538801e-02f, -1.60127855e-03f,
  -3.03207487e-02f, 2.24924535e-02f, -1.55935558e-02f, 2.96041090e-02f, -4.23284471e-02f, -2.89542601e-03f, -1.37972487e-02f, -7.07090348e-02f, 6.25408441e-02f, -3.16922814e-02f,
  6.49996847e-02f, 7.93973624e-04f, -3.64251062e-02f, -9.49909985e-02f, -2.07231212e-02f, 1.08951509e-01f, -2.53618769e-02f, -1.64749864e-02f, -1.37417149e-02f, 8.33922327e-02f,
  -1.16827516e-02f, -7.18406066e-02f, 3.35206725e-02f, 3.48962657e-02f, -9.81367603e-02f, 9.62879974e-03f, 9.95642021e-02f, 4.22571935e-02f, -1.08352691e-01f, -4.90161730e-03f,
  5.54150566e-02f, 1.67954087e-01f, -6.95504108e-03f, -4.97235395e-02f, 6.19017743e-02f, 2.83585209e-03f, -3.74847203e-02f, 1.05304360e-01f, 9.49589834e-02f, 4.53032600e-03f,
  -2.70373058e-02f, -1.44098297e-01f, 1.28881000e-02f, -1.22230267e-02f, -1.96650699e-02f, 3.24367322e-02f, 7.97690228e-02f, -5.27752265e-02f, 4.74621058e-02f, 1.31844223e-01f,
  -1.58486534e-02f, 2.23614983e-02f, 5.96197881e-02f, -8.76051337e-02f, 4.47379192e-03f, 2.71459147e-02f, -3.60273197e-02f, 1.43979480e-02f, -8.31879303e-03f, 8.58501047e-02f,
  -9.56610590e-03f, -2.53444642e-01f, -2.85938352e-01f, -1.29451975e-01f, -2.43062302e-01f, -3.86672348e-01f, -2.93436170e-01f, -1.23657458e-01f, -1.36173874e-01f, 1.33609608e-01f,
  -5.60091101e-02f, -2.14984030e-01f, 2.07821324e-01f, -2.00300664e-01f, -9.76867676e-02f, 2.56049782e-01f, -3.18679035e-01f, -3.97730879e-02f, -5.57288304e-02f, -1.18464924e-01f,
  6.57120571e-02f, -1.21445447e-01f, -1.85306236e-01f, -4.05547060e-02f, -2.85645157e-01f, 9.77729633e-02f, 2.54381567e-01f, -7.00262263e-02f, -1.23280212e-01f, -1.21228196e-01f,
  -4.73854728e-02f, 2.13224739e-02f, -1.27786184e-02f, -7.25839287e-02f, 7.67053366e-02f, 5.18641956e-02f, -2.96473578e-02f, 6.06617443e-02f, 3.45351286e-02f, -5.36496527e-02f,
  2.35327240e-02f, 1.07109368e-01f, 1.31842811e-02f, -7.36410394e-02f, -7.68386498e-02f, -1.06194012e-01f, -1.30488444e-02f, -5.06798774e-02f, -1.39352322e-01f, 3.71173546e-02f,
  -1.46448448e-01f, 1.91410892e-02f, -1.62738170e-02f, 6.56247884e-02f, -6.51024431e-02f, -4.92409281e-02f, 3.51977423e-02f, 1.32636717e-02f, 1.33725051e-02f, -2.17326861e-02f,
  4.93041873e-02f, 3.42051275e-02f, -2.57989615e-02f, 3.61491963e-02f, -2.03041639e-02f, 1.94961186e-02f, -8.28972384e-02f, 8.65420252e-02f, -7.47400522e-02f, 7.27895647e-02f,
  -6.89125061e-02f, -6.14996068e-03f, -3.26126888e-02f, -3.18814139e-03f, -4.53344584e-02f, 6.66944832e-02f, -1.08530067e-01f, -4.92170732e-03f, -1.71169221e-01f, -4.62467782e-02f,
  5.78076728e-02f, -6.26630262e-02f, 6.26626983e-02f, 2.63422094e-02f, -3.72218564e-02f, -5.84455347e-03f, -4.22931351e-02f, -7.30958208e-02f, -2.67987419e-03f, -9.37168226e-02f,
  7.63578853e-03f, 1.02525033e-01f, 9.85527560e-02f, 8.22282881e-02f, 5.80458231e-02f, -7.78816640e-02f, -9.11921263e-02f, 2.85493676e-02f, -1.20365292e-01f, 7.33031258e-02f,
  2.05800477e-02f, -2.96325851e-02f, -7.12180883e-02f, 3.52277122e-02f, -1.09718274e-02f, 1.93669982e-02f, 1.03679691e-02f, -8.30384530e-03f, -4.04839823e-03f, 3.53078879e-02f,
  9.06331092e-02f, -7.12581277e-02f, 1.97224505e-02f, 1.35634476e-02f, -3.66785340e-02f, -6.24698251e-02f, -2.32473947e-02f, 1.29469737e-01f, 1.04542091e-01f, -2.07563695e-02f,
  7.77734146e-02f, 5.62353339e-03f, -1.39240891e-01f, 1.75444469e-01f, 6.40577264e-03f, -1.91212371e-01f, -2.98364669e-01f, 2.30732802e-02f, -2.39474684e-01f, -1.92494746e-02f,
  5.54471500e-02f, -2.11514402e-02f, -1.33624762e-01f, 1.41510993e-01f, 2.78545916e-01f, -2.85612702e-01f, 2.31099024e-01f, 1.84855587e-03f, 4.36603837e-03f, 2.19066560e-01f,
  1.13842197e-01f, 3.14817399e-01f, 1.46315157e-01f, 2.83708930e-01f, 1.41807094e-01f, 2.22288862e-01f, 4.36115384e-01f, -6.13154061e-02f, 3.70710701e-01f, 1.16660848e-01f,
  -3.36098000e-02f, 5.71710095e-02f, -5.43622486e-02f, -6.70970380e-02f, 5.53438365e-02f, 2.96908384e-03f, 2.32704841e-02f, 5.14576472e-02f, 1.96945872e-02f, -2.65509933e-02f,
  -6.68006465e-02f, 1.29399486e-02f, 4.95713465e-02f, -5.80660067e-02f, -1.60627663e-02f, 1.22663982e-01f, -8.44778214e-03f, -7.80817717e-02f, 5.72784506e-02f, 8.25588629e-02f,
  -1.58755735e-01f, -1.14273429e-02f, -2.91239899e-02f, -1.69553576e-04f, 6.85467497e-02f, 6.12001903e-02f, -1.21094525e-01f, -4.81229722e-02f, -8.64028409e-02f, 7.81212840e-03f,
  6.05987944e-02f, -5.48582934e-02f, -1.15657255e-01f, -5.11236675e-02f, -6.29468560e-02f, 3.29645947e-02f, -1.12248072e-02f, -1.96966119e-02f, -4.30067740e-02f, -1.76277645e-02f,
  8.25167224e-02f, 3.68012749e-02f, 4.18551229e-02f, -5.70681505e-03f, -1.61751341e-02f, -3.49481776e-02f, -1.07606659e-02f, -7.43349129e-03f, -6.20093150e-03f, 2.32116859e-02f,
  -2.79249251e-02f, 8.00109059e-02f, -7.75103364e-03f, -3.61750685e-02f, -4.33730409e-02f, 1.61210343e-01f, 7.64006674e-02f, 3.84364165e-02f, -5.79521470e-02f, 1.58519074e-02f,
  6.38711080e-02f, 1.52700335e-01f, -9.50174853e-02f, -3.58751044e-02f, -5.21022603e-02f, 3.33227254e-02f, 1.73682608e-02f, 2.74783354e-02f, 8.86367485e-02f, 7.57597312e-02f,
  1.23543948e-01f, -3.69952507e-02f, 1.90668497e-02f, 8.73176083e-02f, 1.14415422e-01f, 1.10487469e-01f, -1.74591336e-02f, -5.71926869e-02f, 1.41096935e-01f, 5.07056303e-02f,
  5.84034957e-02f, -1.02295652e-01f, -4.98984344e-02f, -9.21285823e-02f, 8.41819718e-02f, 4.17370442e-03f, 3.27857770e-02f, 4.97742407e-02f, 2.78609581e-02f, -5.07202633e-02f,
  -8.18541646e-01f, 3.73160303e-01f, -1.18000582e-01f, -6.15480728e-02f, -2.42543928e-02f, -2.78864708e-02f, 5.53689487e-02f, -5.43169416e-02f, -2.14676619e-01f, 9.07363668e-02f,
  3.51559334e-02f, -2.51642615e-01f, 1.66580126e-01f, 1.65723920e-01f, -2.18537286e-01f, 1.42057970e-01f, 3.19621414e-02f, -4.46744915e-03f, 1.59334838e-01f, 3.09712067e-02f,
  -1.00938372e-01f, 9.59260091e-02f, 6.73415586e-02f, 2.82461286e-01f, -5.14027663e-02f, -6.02557734e-02f, -1.31090209e-01f, 1.41781136e-01f, -1.34615511e-01f, 2.99404003e-02f,
  -2.78989077e-01f, -2.65160739e-01f, -2.56679021e-02f, -7.55387694e-02f, -1.56117454e-01f, -2.09921375e-02f, -7.40686804e-02f, 3.21790576e-02f, -4.13674004e-02f, -2.74823979e-02f,
  -6.02250248e-02f, -2.11741105e-02f, -3.87023352e-02f, 5.54382131e-02f, -6.61763102e-02f, -7.64504448e-02f, 2.35403888e-02f, -4.44832109e-02f, 1.33382082e-02f, 9.43720788e-02f,
  6.01670109e-02f, 1.91648845e-02f, 2.27856934e-02f, 3.37683992e-03f, 1.49297458e-03f, 5.31668775e-02f, 2.79294737e-02f, -3.45140919e-02f, -2.92064399e-02f, -3.28640789e-02f,
  2.43511312e-02f, -3.94704007e-02f, 8.75698626e-02f, -1.93197131e-02f, 1.71781890e-02f, 5.04054725e-02f, 2.73178052e-02f, -8.03413913e-02f, 1.83464326e-02f, 2.63414960e-02f,
  -4.31127362e-02f, -1.27853351e-02f, 8.80942494e-03f, 4.04556915e-02f, 1.77939571e-02f, -1.03643328e-01f, 1.17040724e-02f, -6.83063641e-02f, 4.33490388e-02f, -3.73641811e-02f,
  -2.33778469e-02f, 1.93419605e-02f, -2.90886761e-04f, 1.53937330e-02f, -3.87460962e-02f, -1.97770633e-02f, 1.65729541e-02f, 6.28742278e-02f, 6.45641312e-02f, -2.24145856e-02f,
  -2.63662845e-01f, -3.89714271e-01f, 2.15807725e-02f, -4.41467352e-02f, -3.26758064e-02f, -5.47146751e-03f, 1.86153799e-02f, -5.98342679e-02f, -6.55798987e-02f, -4.55729254e-02f,
  -3.08524887e-03f, -4.50253533e-03f, -1.17697902e-01f, -7.93665722e-02f, 1.76758934e-02f, 6.90769255e-02f, 4.83740717e-02f, -2.29216293e-02f, -9.48202536e-02f, 9.31221235e-04f,
  4.77660485e-02f, 9.88111459e-03f, -4.97405455e-02f, -3.12741362e-02f, 1.48488432e-02f, -4.28006835e-02f, -1.42614007e-01f, -4.18191701e-02f, -7.58927241e-02f, 4.22383193e-03f,
  2.75958389e-01f, 1.02099091e-01f, 1.83709055e-01f, 4.23843056e-01f, 1.55418620e-01f, 1.47696901e-02f, -4.45906483e-02f, 1.87466606e-01f, 3.18269640e-01f, -1.66696668e-01f,
  1.19156934e-01f, -1.17295116e-01f, -1.70180678e-01f, 2.09383488e-01f, 2.86271684e-02f, -8.59704241e-02f, 2.27516651e-01f, 2.94931931e-03f, 1.56618461e-01f, 1.99657649e-01f,
  2.91871637e-01f, -1.59371865e-03f, -3.18591786e-03f, -3.10471933e-02f, 2.38512725e-01f, 1.40485168e-01f, 2.24572551e-02f, 4.85047102e-02f, -2.82307472e-02f, -1.56930298e-01f,
  -3.21278386e-02f, 1.11516640e-01f, 4.20952626e-02f, 1.91936027e-02f, 5.20294569e-02f, 4.64662584e-03f, -1.15616508e-01f, -1.72772363e-01f, 7.09236041e-02f, -4.69379723e-02f,
  1.51937334e-02f, -8.35058391e-02f, -6.10130094e-02f, -1.03063263e-01f, -1.86590682e-04f, 8.02026093e-02f, 6.88517466e-02f, 8.71965960e-02f, -2.31843367e-02f, 5.14713153e-02f,
  2.49723494e-02f, 8.08873922e-02f, 2.38389671e-02f, -4.22684215e-02f, 5.16652036e-03f, 2.42816992e-02f, -3.88283245e-02f, -7.50382766e-02f, -8.74400418e-03f, -2.18122974e-02f,
  2.48222314e-02f, 3.04583646e-02f, -1.17828175e-02f, -6.17164094e-03f, 7.98091665e-02f, 8.50058571e-02f, 3.85776535e-02f, 3.69237959e-02f, 1.34741202e-01f, 4.42998968e-02f,
  2.64473390e-02f, 4.15008068e-02f, 4.25249301e-02f, -4.10561971e-02f, 5.94075397e-02f, -1.01431370e-01f, -1.04484364e-01f, -6.44243285e-02f, -1.99255515e-02f, 5.60783073e-02f,
  -2.41649151e-02f, 6.53715283e-02f, 6.42139018e-02f, -1.64172351e-02f, -2.86676548e-03f, -5.71713485e-02f, -1.74001660e-02f, -3.29757156e-03f, 6.05479553e-02f, 5.96926995e-02f,
  -9.57015995e-03f, 2.74523944e-02f, -3.48663656e-03f, -1.25944456e-02f, -7.04600140e-02f, 5.95820472e-02f, -2.05638376e-03f, -1.40820649e-02f, -1.38580697e-02f, -3.57263461e-02f,
  6.45145215e-03f, 4.37322259e-02f, -9.81479064e-02f, 2.86658406e-02f, -5.69529757e-02f, 9.44508165e-02f, 1.03025790e-02f, 1.00242145e-01f, -1.30622461e-01f, 2.53945906e-02f,
  -3.50553021e-02f, -1.87124237e-02f, 5.28009236e-02f, 5.42349229e-03f, 9.47403628e-03f, -1.38816312e-01f, -8.17657709e-02f, -7.01583996e-02f, 2.39807870e-02f, 9.01447609e-02f,
  1.91900998e-01f, 2.24906981e-01f, 1.99467152e-01f, 3.02587092e-01f, 3.86041477e-02f, -2.30432078e-01f, -3.44216228e-02f, 5.96223660e-02f, -1.28625557e-01f, 1.03163138e-01f,
  -1.34169638e-01f, 2.13561520e-01f, -1.10636547e-01f, 1.42067924e-01f, -2.23665357e-01f, -2.89069653e-01f, -3.10050715e-02f, -1.78908352e-02f, -9.48607400e-02f, 2.05302507e-01f,
  -3.78296711e-02f, 6.47686329e-03f, 6.43571019e-02f, -3.35392430e-02f, 1.86847642e-01f, 1.93969056e-01f, 2.51880232e-02f, -1.39122099e-01f, 2.14586854e-01f, -5.75996824e-02f,
  -1.25041410e-01f, 5.00003733e-02f, 1.20906428e-01f, 2.55570728e-02f, 7.09407255e-02f, -3.35233063e-02f, 1.04344841e-02f, -9.96891633e-02f, -6.98578805e-02f, 2.39028828e-03f,
  -9.65286326e-03f, -5.03207371e-02f, 2.44254898e-02f, -9.59646702e-03f, -9.21439752e-03f, -3.11596245e-02f, 4.26550135e-02f, 3.10799778e-02f, 3.24088968e-02f, 8.27944428e-02f,
  3.13703418e-02f, 3.62426005e-02f, -8.22306871e-02f, 9.65121016e-03f, -3.15881073e-02f, -2.08757333e-02f, -2.76950896e-02f, 1.32813245e-01f, 4.71641310e-02f, 7.49202669e-02f,
  3.80765162e-02f, -7.76361302e-02f, -4.61783707e-02f, -9.34323594e-02f, -9.38328356e-02f, 1.87787414e-02f, -2.21761838e-02f, -8.22065920e-02f, -6.67903051e-02f, -8.15754607e-02f,
  6.56323927e-03f, 3.26970555e-02f, -6.18646154e-03f, -1.57345943e-02f, 8.11055154e-02f, -1.20009389e-02f, 7.91934058e-02f, 5.74398637e-02f, 8.54204223e-02f, 6.44855723e-02f,
  -7.07390765e-03f, -1.54493794e-01f, 3.96152772e-02f, 3.89127769e-02f, -9.45318490e-02f, -1.12711238e-02f, 4.00561616e-02f, -2.91532893e-02f, -2.18531713e-02f, -1.23283220e-03f,
  -4.61169844e-03f, 9.86922532e-02f, 1.12701304e-01f, -4.74811494e-02f, 8.24865885e-03f, -5.47976270e-02f, -7.70262554e-02f, -4.32237657e-03f, -2.96287369e-02f, -1.65863764e-02f,
  7.83099160e-02f, -1.09579964e-02f, -7.76363490e-03f, 6.75594900e-03f, 2.12725885e-02f, -3.27729508e-02f, -2.20290720e-02f, 3.01296338e-02f, 8.89658481e-02f, 1.15732610e-01f,
  2.60473639e-02f, -1.86821749e-03f, -6.78119715e-03f, -1.24615422e-02f, 9.82998163e-02f, 1.23535410e-01f, -2.20786463e-02f, 1.40589565e-01f, 3.97100188e-02f, -5.24786748e-02f,
  -3.44146371e-01f, 1.53177738e-01f, -2.41182327e-01f, -5.70217296e-02f, 8.90023857e-02f, -4.42091823e-02f, -1.88320801e-01f, 5.92567585e-02f, 3.81645025e-03f, 2.17392206e-01f,
  2.29177102e-02f, -4.89475243e-02f, -1.12632699e-01f, -7.80110881e-02f, -3.61635685e-01f, -2.32800424e-01f, -1.80069268e-01f, -4.88689542e-02f, -3.57394828e-03f, 2.77922247e-02f,
  -5.92531897e-02f, 5.12452684e-02f, -2.12673590e-01f, 1.54580995e-01f, 4.85717095e-02f, 9.95166302e-02f, 1.29471764e-01f, 1.38041779e-01f, -4.62755300e-02f, -5.86423539e-02f,
  -1.50636388e-02f, -8.32419395e-02f, 3.27220745e-02f, -7.10912980e-03f, -3.50375175e-02f, 4.60400656e-02f, -7.07280561e-02f, -4.50853147e-02f, -4.40895520e-02f, -9.18887369e-03f,
  -5.97441345e-02f, 8.06432031e-03f, 7.66007463e-03f, -1.77943483e-02f, 7.33780265e-02f, -8.91185645e-03f, 6.07255735e-02f, 8.39973986e-02f, 9.90696177e-02f, -4.75206263e-02f,
  -1.69983998e-01f, 1.51650384e-02f, 4.43001831e-04f, -8.07067752e-02f, -4.58742380e-02f, -3.24564092e-02f, 4.29061661e-03f, 8.66930466e-04f, -8.48140381e-03f, -3.37445387e-03f,
  1.09679950e-02f, 4.19644676e-02f, 3.68797369e-02f, -1.32917371e-02f, 4.61812951e-02f, 1.05060086e-01f, -7.80575052e-02f, -1.06395660e-02f, -2.55509410e-02f, 9.94595815e-04f,
  3.22437547e-02f, -5.07593267e-02f, 8.46433267e-02f, -7.18362257e-02f, -1.26709081e-02f, 6.31891564e-02f, 1.20218154e-02f, 5.26238345e-02f, -3.48822810e-02f, 2.42919307e-02f,
  6.98595569e-02f, -1.40664335e-02f, 8.62383693e-02f, 7.11757839e-02f, 1.61387026e-02f, -9.04281363e-02f, 7.13493973e-02f, 1.65687818e-02f, -2.39722896e-02f, -1.49281928e-02f,
  7.76466057e-02f, 1.60457328e-01f, 5.95052727e-02f, -9.01579559e-02f, 1.52948005e-02f, -3.51348929e-02f, -1.06139975e-02f, 3.91362272e-02f, -6.43397868e-02f, 4.66609225e-02f,
  -4.32983227e-02f, 3.05592138e-02f, 1.20623529e-01f, 1.38818622e-02f, -1.42927421e-02f, 1.50768444e-01f, 2.78380234e-02f, 2.94914078e-02f, -2.10744143e-03f, -4.84583229e-02f,
  1.31138593e-01f, 5.09009399e-02f, -9.67289954e-02f, -4.66841459e-02f, 4.42027710e-02f, 1.45801440e-01f, 2.86828652e-02f, -3.05717494e-02f, 7.76902288e-02f, 2.29886901e-02f,
  2.68458039e-01f, -3.69493902e-01f, 8.73452500e-02f, 3.06481063e-01f, 1.54386193e-01f, -7.13088065e-02f, 1.35413945e-01f, -6.92079067e-02f, -9.33421403e-02f, -2.62292325e-01f,
  7.43805468e-02f, -9.34162140e-02f, -1.46272510e-01f, 1.20303191e-01f, 4.49142456e-01f, -1.67941436e-01f, 3.82649153e-02f, -4.77022566e-02f, 1.45332022e-02f, 1.94558650e-01f,
  2.06845164e-01f, 2.70864815e-01f, 7.25367665e-02f, 3.43200676e-02f, 5.00630550e-02f, -1.12809256e-01f, 7.17561245e-02f, -1.27272382e-01f, 1.31798491e-01f, 1.09709777e-01f,
  -1.26337484e-02f, -4.36996929e-02f, 6.94643483e-02f, 2.35633887e-02f, -8.52709338e-02f, -1.09308377e-01f, 3.86014804e-02f, 4.61575924e-04f, 1.70776136e-02f, -8.47624093e-02f,
  -1.05013683e-01f, 3.81789133e-02f, -2.74563152e-02f, 1.01880521e-01f, 5.20650782e-02f, 2.26543960e-03f, -7.98884630e-02f, -5.61237745e-02f, -1.34978322e-02f, -4.02584746e-02f,
  -1.01660103e-01f, -4.96600978e-02f, -8.10915306e-02f, -1.95130259e-02f, -2.37220377e-02f, 2.79061683e-02f, -1.68814193e-02f, 4.48009707e-02f, -1.27334058e-01f, -4.31431159e-02f,
  -4.64023687e-02f, -1.02913612e-03f, -5.75922616e-02f, -1.38296327e-02f, 4.19166386e-02f, 7.65622929e-02f, -4.96914834e-02f, -5.66288605e-02f, -1.42051131e-02f, 1.59116890e-02f,
  2.72058845e-02f, 2.64268145e-02f, -7.38892108e-02f, -2.98524648e-02f, 1.45366024e-02f, -9.53553393e-02f, -6.83268011e-02f, 3.80612649e-02f, -1.01317376e-01f, -4.96984199e-02f,
  3.71004604e-02f, -5.77634983e-02f, 1.11924857e-02f, -7.91004896e-02f, 3.55866775e-02f, 1.37607073e-02f, 6.66397959e-02f, -1.79845206e-02f, -1.50542632e-02f, -7.66530186e-02f,
  -1.29780009e-01f, -2.23649107e-02f, 2.15530768e-02f, 3.64754573e-02f, -9.96843725e-02f, -1.17362611e-01f, 6.42097816e-02f, -2.35454198e-02f, -5.94143085e-02f, -6.21928051e-02f,
  6.73681274e-02f, -7.50080962e-03f, -6.56962022e-02f, -5.79645261e-02f, 5.62427193e-02f, -4.42449264e-02f, 1.17494732e-01f, -8.45958814e-02f, 5.01268916e-02f, -1.86897442e-02f,
  -4.36339006e-02f, -9.69965756e-02f, -3.17633897e-02f, -1.54057555e-02f, -1.32708242e-02f, -6.29186630e-02f, -6.83532059e-02f, -4.07778583e-02f, -1.03153614e-02f, -3.05838510e-02f,
  1.78890139e-01f, -2.49910578e-01f, 2.78793126e-02f, 1.38788119e-01f, 5.12379929e-02f, -1.42609239e-01f, -2.67955512e-01f, 1.86564531e-02f, -6.19751886e-02f, -3.58888090e-01f,
  -7.18875006e-02f, -1.86079659e-03f, -2.60830551e-01f, 2.13709220e-01f, 2.75715411e-01f, -1.02460004e-01f, 9.57752392e-02f, 3.39679196e-02f, 8.28356221e-02f, 9.84409600e-02f,
  3.13544393e-01f, 1.73674732e-01f, 1.32068902e-01f, 1.34753749e-01f, 2.52498716e-01f, 7.85894170e-02f, 2.36810610e-01f, 1.09653614e-01f, 2.94854999e-01f, 1.73494264e-01f,
  5.77740185e-02f, 2.60413587e-02f, 3.74386050e-02f, 8.67973492e-02f, -7.11870342e-02f, -2.05730274e-02f, -2.22965493e-03f, 8.97297189e-02f, 8.09800718e-03f, -4.56646420e-02f,
  -9.45863798e-02f, 9.71584544e-02f, 1.19248861e-02f, 1.52054995e-01f, 6.05248585e-02f, 1.53008727e-02f, -5.22817299e-02f, 5.99456131e-02f, -1.00783721e-01f, 4.88132723e-02f,
  -8.49969462e-02f, 2.38479078e-02f, 7.74914026e-02f, -2.30737384e-02f, 7.46801645e-02f, -1.44767738e-03f, 4.84219147e-03f, -1.35744125e-01f, -2.38717459e-02f, -2.38096286e-02f,
  -2.12287102e-02f, 5.03334180e-02f, 6.63380250e-02f, -8.77794474e-02f, 9.34644267e-02f, -6.70968518e-02f, -3.63911241e-02f, -4.22597490e-02f, -1.08742721e-01f, -5.96700981e-02f,
  -8.97250697e-02f, -1.02929339e-01f, 4.32554781e-02f, -1.05994798e-01f, -4.87445071e-02f, 3.33308913e-02f, 3.59605923e-02f, 2.54491903e-03f, -1.01001747e-03f, -8.44036862e-02f,
  -6.31308034e-02f, 4.38839057e-03f, -1.16213553e-01f, 1.51221093e-03f, 2.98041999e-02f, -3.21133584e-02f, 5.78820668e-02f, -7.68432999e-03f, 7.22719654e-02f, -6.67661130e-02f,
  2.92186253e-03f, -1.70415100e-02f, -5.48959859e-02f, 6.21313304e-02f, -5.45840943e-03f, -5.99838682e-02f, 4.04223148e-03f, 8.49281326e-02f, 1.28670111e-01f, 1.39601752e-01f,
  -1.73284132e-02f, 1.42896660e-02f, -5.44081768e-03f, 1.29681796e-01f, 8.01380873e-02f, 7.17753693e-02f, -1.93358846e-02f, -4.07094620e-02f, 2.27498598e-02f, -9.82365832e-02f,
  6.74750730e-02f, -6.95139021e-02f, -1.65263005e-02f, -8.63541067e-02f, 2.36592796e-02f, 3.76414172e-02f, -6.59244508e-02f, -2.18520891e-02f, -8.13036039e-03f, -9.86516401e-02f,
  3.67742747e-01f, 1.86913028e-01f, 1.76835492e-01f, 3.25199664e-01f, 6.66393638e-02f, -1.23682946e-01f, -2.63694767e-03f, 1.31922364e-01f, 1.64768487e-01f, 4.60186899e-02f,
  -1.12270780e-01f, 1.89259574e-01f, -2.74785787e-01f, 3.93387638e-02f, -4.59015787e-01f, -4.58121449e-01f, -7.14176595e-02f, 2.32934933e-02f, -9.82834324e-02f, 1.36368394e-01f,
  -1.58546790e-02f, -2.17400268e-01f, -1.02412410e-01f, -1.09799922e-01f, 3.36052954e-01f, 3.09577227e-01f, -7.97483549e-02f, -2.62370277e-02f, 1.21466123e-01f, -1.49951220e-01f,
  8.55631588e-05f, -9.91040990e-02f, 9.56603810e-02f, -4.57197130e-02f, 4.80781645e-02f, 1.46588266e-01f, 1.45825192e-01f, -1.09895274e-01f, 1.46343457e-02f, -5.63732125e-02f,
  -4.17599604e-02f, -5.11942618e-02f, 1.19454646e-03f, -4.23908867e-02f, 9.40797031e-02f, 1.67525001e-02f, -5.11430651e-02f, 1.35429233e-01f, -5.53933159e-03f, 1.96573734e-02f,
  2.90334448e-02f, -1.11853238e-02f, 6.11277670e-02f, 1.90920755e-02f, -4.21467870e-02f, -2.02415753e-02f, 8.15703496e-02f, 1.79414209e-02f, 9.81602147e-02f, 5.64191006e-02f,
  -1.11101992e-01f, -4.35569771e-02f, 6.69573946e-03f, 9.85360704e-03f, 5.23853861e-02f, -6.74925148e-02f, -4.75648977e-02f, -2.99006775e-02f, -1.99058149e-02f, 1.04406495e-02f,
  4.05005068e-02f, 9.79860723e-02f, -9.69665423e-02f, 4.13336009e-02f, -3.20375189e-02f, 1.00494921e-01f, 3.88088003e-02f, -5.65049835e-02f, 3.71190608e-02f, 1.46310180e-02f,
  -5.12423227e-03f, 4.00804132e-02f, -3.70293073e-02f, 2.67217848e-02f, -2.47114971e-02f, -4.06723283e-02f, -3.61509025e-02f, 1.25032336e-01f, -4.57723765e-03f, 4.11475413e-02f,
  -5.54519370e-02f, -1.88186914e-01f, -3.69171277e-02f, 3.49593759e-02f, -1.80685092e-02f, 1.03519887e-01f, -9.68358666e-02f, 3.36200111e-02f, 2.03360314e-03f, -1.20070472e-01f,
  1.05080195e-01f, 8.79141837e-02f, -6.48773136e-03f, 1.78705752e-02f, -8.12162086e-02f, 1.01800123e-02f, -7.98069984e-02f, -1.99807938e-02f, 5.08804992e-02f, -2.06434224e-02f,
  1.46559983e-01f, 4.04001819e-03f, -4.09256183e-02f, -2.80532427e-02f, 5.47362678e-02f, -1.65381643e-03f, 2.39943396e-02f, 2.00935416e-02f, -1.05236359e-02f, -1.01778552e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.90719134e-02f, 2.00455502e-01f, 1.70404136e-01f, 3.12713653e-01f, 1.86340168e-01f, 1.70379460e-01f, 3.74059826e-01f, -2.40989514e-02f, 7.06772283e-02f, 1.29027978e-01f,
  5.21810306e-03f, 3.30598801e-01f, 2.15639740e-01f, 3.73109519e-01f, 1.05965897e-01f, 1.17465876e-01f, -7.35488907e-02f, 6.68203086e-02f, 8.58469754e-02f, 2.55822271e-01f,
  3.17589283e-01f, 2.11733416e-01f, 1.59560755e-01f, 2.17295006e-01f, 2.80078292e-01f, 2.59779781e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.50312179e-01f, -3.27375740e-01f, -2.11663634e-01f, -6.00588247e-02f, 2.95803070e-01f, 4.18467633e-02f, 2.82777846e-01f, 2.50278860e-01f, -9.71780345e-02f, 2.31368437e-01f,
  6.22136183e-02f, -6.11114241e-02f, -3.46794963e-01f, 9.65070948e-02f, -1.92168579e-01f, 1.98532581e-01f, -1.59417335e-02f, -2.45254785e-01f, -4.18595262e-02f, -4.59519215e-02f,
  -1.17588900e-01f, 2.87185013e-01f, 1.07617844e-02f, 2.78170913e-01f, -1.83448970e-01f, 1.28169417e-01f, -5.44162095e-02f, 1.67762846e-01f, 1.73145086e-01f, -2.63853580e-01f,
  8.45837891e-02f, 2.04939589e-01f, -8.75027925e-02f, -8.57875273e-02f, -6.55472418e-03f, -1.72098681e-01f, 1.67797610e-01f, 5.21767465e-03f, 2.32977301e-01f, 5.24731241e-02f,
  -1.17424086e-01f, 4.51051258e-03f, 1.93087861e-01f, -1.70748308e-01f, -1.11393500e-02f, 1.59916684e-01f, 2.77666207e-02f, 1.71228185e-01f, -1.45177230e-01f, 6.44564852e-02f,
  2.46481776e-01f, 4.52070981e-02f, -8.35654140e-02f, 1.70525178e-01f, -1.86619475e-01f, -1.97838619e-01f, -2.66822994e-01f, 1.32601976e-01f, -5.91381900e-02f, -1.37944687e-02f,
  2.55594671e-01f, -1.49026766e-01f, -6.96635172e-02f, 5.12113087e-02f, -1.40126804e-02f, -1.54801952e-02f, 9.15480927e-02f, -1.33111209e-01f, 2.52057195e-01f, 1.72180027e-01f,
  -7.87405297e-04f, 1.05984338e-01f, 5.56583479e-02f, 3.66331726e-01f, -6.97472394e-02f, -8.38463753e-02f, -5.73070254e-03f, 2.29311347e-01f, 1.75458834e-01f, 1.82423562e-01f,
  1.11650363e-01f, -1.18037209e-01f, 1.36608735e-01f, -2.16759354e-01f, 2.54585385e-01f, 3.25324029e-01f, -1.50081530e-01f, -5.45383580e-02f, 1.90761074e-01f, 1.33434758e-01f,
  -3.02084982e-01f, -1.30093411e-01f, 1.68278500e-01f, 2.06119329e-01f, 1.13699533e-01f, -2.68449545e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.94777171e-02f, 6.40496314e-02f, 1.38797879e-01f, -3.84882629e-01f, -1.40268818e-01f, 4.57301378e-01f, 5.08953482e-02f, -1.46314874e-01f, -1.63642511e-01f, 4.08220321e-01f,
  2.13855535e-01f, -3.09733272e-01f, -2.69489408e-01f, 8.67640972e-02f, 3.44699651e-01f, -4.75439817e-01f, 1.73231736e-01f, -1.05234757e-01f, 3.04995738e-02f, 3.62812042e-01f,
  2.10204512e-01f, 1.71874240e-01f, 2.68405288e-01f, 2.98568249e-01f, 1.34206235e-01f, 9.87686291e-02f, 2.95414358e-01f, -8.09666067e-02f, -3.06503356e-01f, 1.64394617e-01f,
  2.69484401e-01f, -2.15941161e-01f, 5.74641190e-02f, 2.45457694e-01f, 1.77116498e-01f, 2.07070962e-01f, 2.51721200e-02f, 8.71279165e-02f, 3.46248627e-01f, 3.74005944e-01f,
  9.65788662e-02f, 2.77366251e-01f, -8.30581561e-02f, -2.53806591e-01f, 3.28708529e-01f, 2.88315326e-01f, 6.28743544e-02f, 5.10400891e-01f, 2.67566204e-01f, 1.68810308e-01f,
  2.32646093e-01f, 1.56361878e-01f, -5.80061004e-02f, 8.24021325e-02f, -9.24716964e-02f, 3.24237525e-01f, 7.56949857e-02f, 3.50583881e-01f, 4.17348929e-02f, 8.91991109e-02f,
  4.45651531e-01f, -1.41735777e-01f, -8.59428123e-02f, 1.22556679e-01f, 1.01401769e-01f, 2.58804411e-01f, 1.24321453e-01f, -1.81690231e-01f, 1.54116467e-01f, 4.02837068e-01f,
  1.44911513e-01f, 5.64470217e-02f, -7.58843273e-02f, 2.87111580e-01f, 3.11668515e-01f, -1.95293128e-01f, 2.55253464e-01f, 2.40531325e-01f, -8.78675282e-02f, -1.05734341e-01f,
  2.88710624e-01f, -9.03483778e-02f, 3.07524651e-01f, 5.40814161e-01f, -1.30495355e-01f, 2.78541207e-01f, 5.60184158e-02f, 6.34589931e-03f, 1.57287166e-01f, 5.62338650e-01f,
  -1.12001151e-01f, -1.33648306e-01f, 1.06544130e-01f, -2.14431603e-02f, 1.58763304e-01f, 4.13697585e-02f, 2.04129919e-01f, 3.67720366e-01f, 1.59577280e-01f, -2.84788758e-01f,
  -9.83146951e-02f, 2.37308607e-01f, 8.87865126e-02f, 9.81130600e-02f, 3.03201437e-01f, 2.89007962e-01f, 3.74282241e-01f, 3.54610570e-02f, 1.72261924e-01f, 2.85327822e-01f,
  4.08008927e-03f, -3.53693038e-01f, -6.83913901e-02f, 4.44906540e-02f, 1.59391850e-01f, 4.22854692e-01f, 1.14064261e-01f, 2.69725382e-01f, 4.93385643e-02f, -3.82036567e-02f,
  3.73971283e-01f, -3.03528219e-01f, 9.40789133e-02f, -7.98188150e-02f, 9.32986960e-02f, 4.38159555e-01f, 2.87887901e-01f, -1.71769932e-01f, 3.63516986e-01f, 4.42993432e-01f,
  2.53971517e-01f, 2.33508140e-01f, -3.75445098e-01f, -1.96374163e-01f, -1.47027895e-01f, 4.53571044e-03f, -9.03589767e-04f, -2.47088492e-01f, 5.61023876e-02f, 1.52720332e-01f,
  4.17856015e-02f, -2.93608665e-01f, 2.12138355e-01f, 3.04747730e-01f, 3.23795050e-01f, 4.26826984e-01f, -1.65076256e-01f, 3.69149119e-01f, 2.23428793e-02f, -4.42396581e-01f,
  -2.90982693e-01f, 2.64446773e-02f, -2.37614334e-01f, 2.95008510e-01f, 2.52887338e-01f, -4.06040326e-02f, -1.45630166e-01f, 6.53327852e-02f, 6.61091805e-02f, -4.62373197e-02f,
  1.02767758e-01f, 4.27783221e-01f, 3.40197444e-01f, 4.21574205e-01f, 1.35284126e-01f, -1.06925815e-01f, 2.63695568e-01f, 4.10089880e-01f, 1.20716445e-01f, -3.44983563e-02f,
  9.41139907e-02f, 4.93103974e-02f, 5.00915766e-01f, 1.45091191e-01f, -2.43227184e-01f, 5.59397399e-01f, 3.29939604e-01f, 3.09677243e-01f, 2.02225983e-01f, -1.05127752e-01f,
  -5.23666926e-02f, -8.79850313e-02f, 5.56984060e-02f, 3.69878322e-01f, -1.42352968e-01f, 5.64515173e-01f, -2.78862149e-01f, -8.33513662e-02f, 2.93372393e-01f, -1.23722129e-01f,
  2.12222099e-01f, -7.71705061e-02f, 1.55588418e-01f, 3.11929290e-03f, 1.60225347e-01f, 2.15351447e-01f, -2.57085979e-01f, -2.86882252e-01f, 2.06724256e-02f, -2.85154879e-02f,
  3.68529931e-02f, 2.36509070e-01f, -2.71834701e-01f, 2.58910835e-01f, -7.19702840e-02f, -6.59182742e-02f, 2.35866085e-01f, -1.08229756e-01f, -1.57880619e-01f, -6.04096204e-02f,
  -1.72993213e-01f, -1.61666185e-01f, 3.55000079e-01f, 1.52351126e-01f, 1.14355423e-01f, -2.04773024e-02f, 1.92911297e-01f, -3.84515166e-01f, 6.31310567e-02f, 4.57482040e-01f,
  1.70178756e-01f, -6.62416592e-02f, 2.20064461e-01f, 3.78131986e-01f, 2.08337724e-01f, 3.84379894e-01f, 3.22333395e-01f, -2.68296272e-01f, 7.91466087e-02f, -1.30388379e-01f,
  -1.23416081e-01f, 1.15581036e-01f, 3.83744925e-01f, 1.53645307e-01f, 2.13214293e-01f, 1.82199359e-01f, 3.99314821e-01f, 1.52815640e-01f, 1.55264493e-02f, 3.38371284e-02f,
  -1.66761145e-01f, 2.14385867e-01f, 2.63985366e-01f, 1.60654292e-01f, 2.20800415e-01f, 2.82145292e-01f, -4.16809320e-02f, 7.41589814e-02f, 2.12129936e-01f, -2.57614791e-01f,
  -5.09029031e-02f, 4.78633717e-02f, 1.58532616e-02f, 2.36959800e-01f, 2.90429711e-01f, -7.62173012e-02f, -1.41564931e-03f, 3.48424464e-01f, 3.71435434e-02f, 6.13365695e-02f,
  8.73470604e-02f, 3.71157020e-01f, -2.51487028e-02f, -1.79358765e-01f, -2.81160623e-01f, 3.70887041e-01f, 2.17917655e-02f, -8.00284222e-02f, 2.08191857e-01f, 6.49014041e-02f,
  1.33415744e-01f, 2.04201937e-01f, 3.95085394e-01f, 2.61799358e-02f, -1.40335232e-01f, 3.68031055e-01f, -2.35518798e-01f, -4.15697843e-02f, -7.64245018e-02f, 2.43889078e-01f,
  -5.27291335e-02f, 3.90286386e-01f, 1.37335718e-01f, -9.62408185e-02f, -1.44693539e-01f, -2.05286816e-01f, 1.78144202e-01f, -2.23709688e-01f, 1.50534645e-01f, 1.79136753e-01f,
  4.18121256e-02f, -2.80497730e-01f, 1.09976672e-01f, -3.06107540e-04f, -4.11450192e-02f, 2.67302632e-01f, 4.10467535e-01f, 2.25865200e-01f, 2.00022176e-01f, 2.27086961e-01f,
  1.93748608e-01f, 3.28254521e-01f, 2.38102693e-02f, 5.75510822e-02f, -2.99056083e-01f, 2.64687091e-01f, 1.62837103e-01f, -2.06957996e-01f, 4.30666119e-01f, 1.93754971e-01f,
  -8.52470845e-02f, 1.82321407e-02f, 3.35299939e-01f, -3.58300060e-01f, 2.79194117e-01f, 2.38844659e-02f, 3.19022276e-02f, 2.67572582e-01f, 2.99332976e-01f, -3.52506712e-02f,
  4.22167987e-01f, 4.67093676e-01f, 2.87846118e-01f, 1.02645503e-02f, -2.44621579e-02f, -1.21859342e-01f, -1.16926610e-01f, -1.76082611e-01f, 3.61613363e-01f, -4.38372977e-02f,
  3.79747711e-02f, 4.00636613e-01f, 2.41301432e-01f, -1.36263505e-01f, 3.07573397e-02f, -4.61549759e-02f, -4.13111523e-02f, 4.99757588e-01f, 9.35731828e-02f, 8.53815973e-02f,
  2.13009015e-01f, -2.50052840e-01f, -2.26663798e-02f, -3.86135101e-01f, -3.93874459e-02f, -2.59637423e-02f, 3.19951177e-01f, -1.78344846e-01f, -1.80895522e-01f, 2.32239217e-01f,
  2.26958245e-01f, 1.64513245e-01f, -2.51290817e-02f, 7.14244694e-02f, -4.68392335e-02f, 4.29524966e-02f, 7.21574621e-03f, -3.18538576e-01f, 6.80102184e-02f, 3.90575081e-02f,
  1.23073570e-01f, -8.64690468e-02f, 1.61183048e-02f, 2.35508323e-01f, -2.72413969e-01f, -6.37807325e-02f, 1.27691418e-01f, -9.63492468e-02f, -2.52860248e-01f, 1.58998311e-01f,
  -2.08504796e-01f, 7.44106993e-02f, 1.24307990e-01f, -2.03066558e-01f, 2.08782524e-01f, -1.51667759e-01f, -1.86318848e-02f, -1.85257211e-01f, 3.41843486e-01f, 3.61760497e-01f,
  -6.08494915e-02f, 3.20935816e-01f, 8.57976675e-02f, 4.18447495e-01f, 2.37456456e-01f, 8.62751305e-02f, 3.48577112e-01f, -2.24258795e-01f, -1.63014084e-01f, -2.10589662e-01f,
  -8.59808922e-02f, 1.45857885e-01f, 4.31760579e-01f, -1.40521061e-02f, 5.09978198e-02f, 2.71883190e-01f, 3.61092210e-01f, 5.22406809e-02f, -2.32067868e-01f, 2.06330985e-01f,
  -1.51132435e-01f, 1.13341242e-01f, 3.62032533e-01f, -2.38072708e-01f, 1.49991913e-02f, 2.24243358e-01f, -2.43644323e-02f, -3.54144834e-02f, 1.98377624e-01f, 1.10657528e-01f,
  1.14999287e-01f, -2.27564443e-02f, 1.91541001e-01f, 3.67388517e-01f, 1.10357709e-01f, -1.19272396e-01f, 4.04445231e-01f, 2.81791419e-01f, 2.83393890e-01f, -2.17924893e-01f,
  -1.88825801e-01f, -1.63797438e-01f, 6.35920689e-02f, 1.79968104e-01f, 3.45790029e-01f, 1.53331116e-01f, 2.78448731e-01f, 2.86644578e-01f, 3.21796626e-01f, 2.95953631e-01f,
  1.85094699e-02f, -9.72392634e-02f, -1.35418355e-01f, 1.21080935e-01f, 1.70046106e-01f, -1.04851365e-01f, 2.60359962e-02f, 3.71839225e-01f, -8.69284421e-02f, -3.61642465e-02f,
  9.11059976e-02f, -3.02640855e-01f, 2.22399712e-01f, 1.35919660e-01f, 2.69984782e-01f, 3.08442086e-01f, 1.42342210e-01f, 3.50951254e-01f, 3.48089278e-01f, 4.32990402e-01f,
  3.46566856e-01f, 4.41755652e-02f, 2.85363533e-02f, -2.09748209e-01f, -3.79212201e-01f, 1.37589371e-03f, 3.28390777e-01f, 7.68248215e-02f, -6.11765776e-03f, 1.98154956e-01f,
  1.85882345e-01f, -9.38839540e-02f, 3.21928442e-01f, -1.23624258e-01f, -8.81871879e-02f, 5.37219346e-01f, 3.80904935e-02f, -1.98960572e-01f, 1.26848295e-01f, -2.43953183e-01f,
  2.04516158e-01f, -3.15724701e-01f, 1.39316320e-01f, 1.37270495e-01f, 4.04287457e-01f, 9.37794223e-02f, -1.78303868e-01f, 1.61032543e-01f, 1.55626431e-01f, -2.20024735e-01f,
  2.57520139e-01f, -1.29792970e-02f, 8.60576779e-02f, 2.07972690e-01f, 2.69622505e-01f, 2.41740718e-01f, 1.40594780e-01f, -2.15044823e-02f, -2.61685640e-01f, 2.64660865e-01f,
  -1.15537807e-01f, -1.35241449e-02f, 1.20649852e-01f, 1.08540310e-02f, 3.16469878e-01f, 2.68927038e-01f, 3.18608105e-01f, -8.16594902e-03f, 3.74393202e-02f, 1.61146566e-01f,
  -3.84188928e-02f, 4.10800148e-03f, 2.94174440e-02f, 2.96923637e-01f, 1.40813723e-01f, 5.62995613e-01f, 2.82890737e-01f, -2.73098908e-02f, 1.81426495e-01f, -6.54290393e-02f,
  2.26549461e-01f, -7.17342347e-02f, 1.16542079e-01f, -2.06387416e-01f, -8.64353031e-03f, 6.79014549e-02f, -3.14056464e-02f, -1.21221691e-01f, 9.33898911e-02f, -1.09219998e-01f,
  -2.50775576e-01f, 1.66202396e-01f, -1.42777815e-01f, -7.52251595e-02f, -8.74666646e-02f, -2.11265817e-01f, 5.25285453e-02f, -3.91579308e-02f, -2.82226354e-01f, -1.81095570e-01f,
  2.29668757e-03f, -1.43970937e-01f, 3.47768255e-02f, -1.56805500e-01f, 2.66191930e-01f, -6.33646846e-02f, 1.80510774e-01f, -2.07607225e-01f, 1.41510323e-01f, 2.77911365e-01f,
  1.05937295e-01f, -1.53135777e-01f, -1.18217014e-01f, 1.13960266e-01f, 3.87119874e-02f, -7.01677203e-02f, 2.35021468e-02f, 3.93444061e-01f, 2.36394897e-01f, 6.72216192e-02f,
  2.13433325e-01f, 3.26069862e-01f, -5.37482509e-03f, 4.65545394e-02f, -6.35261238e-02f, 6.69474946e-03f, -6.13502674e-02f, 5.86571842e-02f, -1.03465160e-02f, 4.83017892e-01f,
  4.29997861e-01f, -9.63690653e-02f, 2.05839917e-01f, -1.31950393e-01f, 7.29364753e-02f, 2.20765889e-01f, -2.15662822e-01f, 2.64216483e-01f, 2.40969375e-01f, 1.70957476e-01f,
  1.98781048e-03f, -3.96808423e-02f, 3.69690418e-01f, -9.11904722e-02f, 2.06792980e-01f, -5.29584438e-02f, 2.07936957e-01f, 1.31619439e-01f, 6.21582083e-02f, -4.34249878e-01f,
  -8.93528014e-02f, -1.07615009e-01f, 2.18048003e-02f, 1.85178533e-01f, 2.14935064e-01f, 6.24489486e-02f, 2.67101467e-01f, 3.32723737e-01f, 3.40658307e-01f, 2.89321810e-01f,
  -3.36460583e-02f, 4.71369252e-02f, -9.27162096e-02f, 1.97249293e-01f, -6.76624998e-02f, 1.15386933e-01f, 2.14488879e-01f, 3.73744875e-01f, -2.39026845e-01f, 1.67711675e-02f,
  9.30296630e-02f, -3.75464380e-01f, 2.02522278e-02f, 5.31932861e-02f, -8.89244082e-04f, 1.83909595e-01f, 2.55799349e-02f, 7.72387953e-04f, -7.20534772e-02f, -1.69550255e-02f,
  -2.42888797e-02f, 1.96583346e-01f, -9.69636813e-02f, 2.49694660e-01f, 1.37641221e-01f, -2.35818941e-02f, -4.31331210e-02f, 4.27191466e-01f, -2.38697559e-01f, 1.09934136e-01f,
  4.62804958e-02f, -7.05057681e-02f, 2.32302532e-01f, -2.95390517e-01f, 3.03332061e-01f, -2.21562624e-01f, -1.74599066e-02f, -1.74636945e-01f, 4.09894079e-01f, 2.46314377e-01f,
  1.43579617e-01f, 2.32932210e-01f, 2.75201052e-01f, 8.42413604e-02f, 1.86000645e-01f, 1.18464135e-01f, -2.12667957e-01f, 1.79369003e-01f, 3.50815833e-01f, 4.53863814e-02f,
  1.51428565e-01f, 1.61679849e-01f, 8.96057710e-02f, 9.05347392e-02f, -2.33784303e-01f, -8.65486711e-02f, 9.15503874e-02f, 1.71960853e-02f, -1.38074607e-01f, -3.62824239e-02f,
  4.29177061e-02f, 3.59898120e-01f, -2.25722134e-01f, -1.80718511e-01f, 1.09803438e-01f, -2.64587015e-01f, 2.63770610e-01f, -8.18359759e-03f, 9.13875774e-02f, 6.29557893e-02f,
  5.10929041e-02f, -2.51613855e-01f, 9.87269804e-02f, 1.15922868e-01f, 1.20769374e-01f, -2.48676818e-02f, 3.49814385e-01f, 3.94092470e-01f, -1.61642700e-01f, -2.53300229e-03f,
  3.49506474e-04f, 4.43673283e-01f, 1.77840084e-01f, 3.42015386e-01f, 2.67605096e-01f, 3.85681652e-02f, -2.62466460e-01f, 3.68983507e-01f, 1.47377953e-01f, -2.59340554e-01f,
  -1.00483797e-01f, 6.63181245e-02f, 2.09283128e-01f, 3.20314467e-02f, -1.41161129e-01f, -1.21988177e-01f, 2.94553488e-01f, 9.42678563e-03f, 1.16786398e-01f, -2.04503089e-02f,
  -1.64375976e-01f, 4.36242372e-01f, 1.69795647e-01f, 6.40295893e-02f, 2.66897261e-01f, 1.83132693e-01f, 8.65025967e-02f, 2.96030521e-01f, 4.04115468e-01f, 2.01872036e-01f,
  1.21827389e-03f, -3.41242850e-02f, 1.76087767e-01f, 9.59363952e-02f, -6.20062128e-02f, 1.26979887e-01f, 2.75433902e-02f, 4.11919039e-03f, -5.06471515e-01f, 1.64555386e-01f,
  2.16641836e-02f, 9.43698809e-02f, -1.25749961e-01f, -8.18480849e-02f, -9.92631540e-02f, -7.89815262e-02f, -1.83291897e-01f, -4.74051744e-01f, 2.20602706e-01f, -3.34150791e-01f,
  3.20505232e-01f, 6.52827844e-02f, 1.23765811e-01f, 3.66142809e-01f, 1.61290511e-01f, -1.42671943e-01f, 2.00834244e-01f, 4.22178447e-01f, 1.93408504e-01f, -3.31375182e-01f,
  2.80221224e-01f, 3.41373593e-01f, -1.26126722e-01f, -1.40927419e-01f, 1.77042365e-01f, 4.31243284e-03f, -1.73579559e-01f, -1.41080707e-01f, 2.66102124e-02f, 3.26977491e-01f,
  -2.98806757e-01f, 1.01499697e-02f, -7.37440065e-02f, 2.08024103e-02f, -1.09257720e-01f, 1.33396491e-01f, -3.21346492e-01f, -5.93371466e-02f, 9.72268954e-02f, -7.25875124e-02f,
  -4.98400582e-03f, 4.94756550e-02f, 3.65991384e-01f, 1.57015011e-01f, -4.61191237e-02f, -2.84031004e-01f, 4.98142429e-02f, -3.93096030e-01f, -1.53557584e-01f, 3.97295833e-01f,
  -5.87032270e-03f, -2.24274501e-01f, -1.46285266e-01f, -1.38429657e-01f, -7.28459731e-02f, -2.07375497e-01f, 3.17770362e-01f, -2.79092461e-01f, -2.51637958e-02f, -4.71092314e-02f,
  1.72886059e-01f, 2.56542772e-01f, -1.91204235e-01f, 1.28863789e-02f, -1.04485489e-01f, 4.72603291e-02f, -1.14799768e-01f, 1.74845546e-01f, 6.58615977e-02f, 2.06466898e-01f,
  -1.18541420e-01f, -2.54047543e-01f, 1.28267080e-01f, -1.71894580e-01f, 1.04570098e-01f, 1.12146556e-01f, -1.09678008e-01f, 1.03505708e-01f, 1.13353938e-01f, 1.84299760e-02f,
  1.74661815e-01f, 3.18469346e-01f, 2.28929669e-01f, -2.22280920e-01f, 3.95400733e-01f, 3.30535203e-01f, -2.47653559e-01f, 2.40217209e-01f, 1.81194127e-01f, 3.55840474e-01f,
  3.28526378e-01f, 6.71500899e-03f, 1.77710205e-01f, -2.08820105e-01f, 3.31078291e-01f, 1.40379950e-01f, 2.25558430e-01f, 1.75098702e-01f, -1.25582874e-01f, 4.50660795e-01f,
  -1.48267463e-01f, -1.29899472e-01f, -9.46879387e-02f, 9.47587937e-02f, 6.54411211e-04f, 2.51198739e-01f, 8.91668275e-02f, 8.12737122e-02f, 6.34201663e-03f, 7.30833784e-03f,
  4.46201861e-01f, 4.26795363e-01f, 5.37340641e-02f, 1.27233058e-01f, 3.82041901e-01f, 1.53157741e-01f, 3.15090358e-01f, 4.81625497e-01f, 2.76980788e-01f, 2.63180017e-01f,
  1.45322131e-03f, 4.43570167e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.44899228e-01f, 2.03031391e-01f, 3.42046589e-01f, 2.59346902e-01f, 2.40982965e-01f, 3.26367766e-01f, 1.00325898e-03f, 1.90317452e-01f, 2.16744572e-01f, 4.90849540e-02f,
  2.69642144e-01f, -4.29314375e-02f, 1.29367307e-01f, 6.29646331e-02f, 2.58733481e-01f, 9.19555128e-02f, 1.96438447e-01f, 2.61643320e-01f, -1.52912997e-02f, -9.42949951e-02f,
  1.10223122e-01f, 2.38373905e-01f, 6.93645775e-02f, -1.25797287e-01f, -3.53270140e-03f, 8.30666944e-02f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  6.87289238e-02f, -1.76640581e-02f, 8.63637775e-03f, 1.94399357e-01f, 9.81044695e-02f, 3.41557622e-01f, 2.43362829e-01f, 1.95322819e-02f, -6.24259561e-03f, -8.09911564e-02f,
  -1.39898673e-01f, 2.61003189e-02f, -1.36769950e-01f, -1.47968113e-01f, -5.07447012e-02f, 1.52525026e-03f, -2.06522241e-01f, 7.80627057e-02f, -9.62789506e-02f, -1.87583596e-01f,
  2.69841496e-02f, -2.37945467e-03f, 2.69235045e-01f, 1.55804917e-01f, -1.16612047e-01f, -9.91053954e-02f, -1.38356790e-01f, 1.18095934e-01f, -6.26466349e-02f, 1.67701989e-01f,
  1.65364951e-01f, 3.44143182e-01f, -1.27987012e-01f, -2.11404562e-01f, -1.65174186e-01f, -2.10543007e-01f, 2.89357323e-02f, -5.63556589e-02f, 1.81909055e-01f, -2.35337272e-01f,
  -8.89607668e-02f, 3.09546292e-01f, 6.94232136e-02f, -2.64751494e-01f, -2.23764613e-01f, -2.58985739e-02f, 6.94985688e-02f, 1.78645149e-01f, 6.48801252e-02f, -5.36018014e-02f,
  -1.10986538e-01f, 1.17523894e-01f, 1.67427972e-01f, -1.39899150e-01f, -2.23775394e-02f, -1.68460637e-01f, -1.67183410e-02f, -3.82829905e-02f, -1.18077524e-01f, 1.09629057e-01f,
  1.53746679e-01f, -2.11803854e-01f, -1.20584229e-02f, -2.56261643e-04f, -2.23029591e-02f, -3.54082733e-02f, -3.41432124e-01f, 6.15543276e-02f, -5.44903129e-02f, -1.95063710e-01f,
  -3.12198456e-02f, -2.35274255e-01f, -1.97085992e-01f, -2.83068921e-02f, -9.81932953e-02f, -2.05498546e-01f, 5.16896695e-02f, -1.92275718e-02f, 4.79708761e-02f, 2.00049385e-01f,
  1.32806048e-01f, 2.54151016e-01f, -1.05011635e-01f, 4.06246260e-02f, -5.33821024e-02f, -1.07310988e-01f, -4.02908251e-02f, -1.35585770e-01f, -1.90900955e-02f, 1.04010381e-01f,
  1.27429679e-01f, -9.41802748e-03f, 6.03083335e-02f, 3.58926356e-02f, 1.14629105e-01f, 1.30835906e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -6.22767173e-02f, 1.58329859e-01f, 3.06912184e-01f, -3.03743154e-01f, -3.22798565e-02f, 3.44471961e-01f, -2.75757402e-01f, -8.78198594e-02f, 1.79707006e-01f, 1.17327750e-01f,
  -3.29400529e-03f, 2.79558182e-01f, -2.17878222e-01f, 3.05370420e-01f, -1.88989118e-02f, 2.36589625e-01f, 2.25972995e-01f, -1.07093915e-01f, 3.29762697e-01f, 3.12414855e-01f,
  3.33225489e-01f, -9.24284831e-02f, -2.51609504e-01f, -2.83590127e-02f, 2.35659212e-01f, -1.16576187e-01f, -2.08232448e-01f, -2.54097641e-01f, -2.43612841e-01f, -1.64273396e-01f,
  -1.74086884e-01f, -3.81700881e-02f, 2.10344531e-02f, 1.73848748e-01f, 2.31237069e-01f, -3.17034513e-01f, 3.87760513e-02f, -4.05152999e-02f, -3.63019198e-01f, 3.76408994e-02f,
  -6.36300370e-02f, 1.75142214e-02f, 7.89907724e-02f, 3.46456558e-01f, -1.62304357e-01f, 3.82846624e-01f, -1.09271750e-04f, 3.87832761e-01f, 1.52737215e-01f, 1.14034794e-01f,
  3.50933105e-01f, 6.11072183e-02f, 3.98895144e-01f, 1.47549346e-01f, -4.84414965e-01f, 2.24206090e-01f, 1.91631168e-01f, -2.19219863e-01f, -1.22558326e-01f, -2.73556858e-01f,
  -3.78271520e-01f, -2.89834261e-01f, -8.61767083e-02f, -1.56057149e-01f, -1.32787049e-01f, 1.44556552e-01f, -8.44891369e-02f, 4.19042856e-01f, -4.14532498e-02f, 4.04725730e-01f,
  6.63045868e-02f, 2.92636395e-01f, 2.30786931e-02f, 6.15062192e-03f, -3.71838301e-01f, 3.20827872e-01f, -9.67582688e-02f, 7.55815580e-02f, -2.45596580e-02f, 1.75572470e-01f,
  5.42993061e-02f, -7.63542503e-02f, -2.36442685e-02f, 4.85989973e-02f, 5.88514358e-02f, 2.63452262e-01f, -1.10257402e-01f, 1.38206840e-01f, 1.71510980e-01f, 2.38102004e-01f,
  -2.55535901e-01f, 9.78202652e-03f, -2.58119017e-01f, -2.30442524e-01f, -1.97643489e-01f, 3.71877581e-01f, -3.54186669e-02f, 8.62108916e-02f, 2.79909391e-02f, -3.50673437e-01f,
  -3.81649703e-01f, -1.56681269e-01f, 3.52973312e-01f, -1.16215155e-01f, -9.79736894e-02f, 2.70037413e-01f, 2.14979902e-01f, 6.53094649e-02f, 8.21855757e-03f, 2.97765583e-01f,
  6.16441332e-02f, 3.05154383e-01f, 3.18842888e-01f, 2.59606808e-01f, 3.39894861e-01f, 3.05610329e-01f, 4.96583015e-01f, -5.02844565e-02f, -1.45576090e-01f, -1.02840096e-01f,
  2.24079743e-01f, 3.73955041e-01f, 3.29119414e-01f, 2.59704947e-01f, 1.48043111e-01f, 1.72294036e-01f, 4.15472299e-01f, -4.70576324e-02f, -8.15469995e-02f, 1.18684433e-01f,
  3.97907406e-01f, -4.79808003e-01f, 4.13680971e-02f, -9.28416923e-02f, 2.22002149e-01f, -1.42040506e-01f, 2.60482460e-01f, 1.64464921e-01f, 4.64028418e-01f, -1.04324400e-01f,
  -3.39666784e-01f, 1.67975411e-01f, 2.83978999e-01f, 1.01057380e-01f, 3.41413975e-01f, -6.97803572e-02f, 1.13215975e-01f, -4.97555882e-02f, 2.75365502e-01f, -1.47142082e-01f,
  -3.10661077e-01f, -3.56066495e-01f, 2.21751392e-01f, -3.85491222e-01f, 5.95261194e-02f, 3.43948156e-01f, 2.76688129e-01f, -4.58182245e-01f, -2.11443707e-01f, -6.36701509e-02f,
  -1.26947433e-01f, -1.57241493e-01f, 4.84984778e-02f, 3.55059206e-01f, 7.24936128e-02f, 3.43864352e-01f, -2.86067635e-01f, 2.94190794e-01f, -7.50413835e-02f, 2.11671740e-01f,
  -1.73789695e-01f, 9.63970423e-02f, 1.60933718e-01f, 1.67203903e-01f, -1.66401923e-01f, 2.63883859e-01f, -9.50283483e-02f, -3.01323801e-01f, 3.42745870e-01f, 3.39643836e-01f,
  -2.34899789e-01f, -2.08685789e-02f, -1.57895431e-01f, 3.44733596e-01f, 2.60307342e-01f, 6.92827255e-02f, -2.05239236e-01f, 2.55225245e-02f, -3.29649597e-01f, -7.16072693e-02f,
  -1.84206530e-01f, 3.39315146e-01f, 1.53609440e-01f, 1.44595876e-01f, 1.30345449e-01f, -2.94889539e-01f, -2.88327903e-01f, -3.64452690e-01f, -1.41982108e-01f, 2.11569056e-01f,
  -1.63399912e-02f, -4.05631393e-01f, 2.25568071e-01f, 4.46088165e-02f, 2.47552693e-01f, -2.18230397e-01f, -2.69118752e-02f, 9.46838111e-02f, 2.52870888e-01f, 3.38448733e-01f,
  6.20865785e-02f, -3.55824865e-02f, 3.41227859e-01f, 1.23273388e-01f, 3.40161711e-01f, -9.51604396e-02f, -2.58778870e-01f, 2.88408667e-01f, 4.18077976e-01f, 6.19303770e-02f,
  1.70217305e-01f, 2.53212303e-01f, 3.23395431e-01f, 2.09672198e-01f, 2.82181948e-01f, 1.73224106e-01f, 3.73597085e-01f, -4.73063767e-01f, -1.08367823e-01f, -4.69635665e-01f,
  4.49809544e-02f, 1.36112124e-01f, -3.93424556e-02f, 3.29465717e-02f, 1.76184610e-01f, -3.11569758e-02f, 2.50172317e-01f, 1.47389680e-01f, 2.73678936e-02f, -5.21676764e-02f,
  1.96175531e-01f, 9.32216272e-02f, -1.28267869e-01f, 1.35543481e-01f, 2.70468712e-01f, 4.55097742e-02f, 1.26381859e-01f, -8.74249116e-02f, 3.14926691e-02f, -4.36826460e-02f,
  5.44051290e-01f, 1.77081123e-01f, 5.25110245e-01f, -3.02710477e-02f, 4.08553958e-01f, -8.96457434e-02f, -2.79867589e-01f, -2.93856055e-01f, -2.86408573e-01f, -1.11148812e-01f,
  -2.49136463e-02f, 7.65448585e-02f, -8.12751725e-02f, 7.22872242e-02f, -2.13815629e-01f, 2.72444755e-01f, -2.81161189e-01f, -5.88370627e-03f, -4.51497734e-02f, 2.88989723e-01f,
  -1.88035041e-01f, 3.81373912e-01f, 2.61956304e-01f, 1.72156781e-01f, 3.70653421e-01f, 7.10922256e-02f, 1.24500625e-01f, -1.73699614e-02f, -2.20714241e-01f, 1.30057827e-01f,
  5.06599009e-01f, 2.05309793e-01f, -1.56231346e-02f, -1.81595907e-02f, -6.20551668e-02f, -7.97071680e-02f, 6.64694682e-02f, -4.26984858e-03f, 1.60811350e-01f, 4.44554090e-01f,
  1.21207446e-01f, -2.48369481e-02f, 3.45862284e-02f, -1.76087141e-01f, 3.67485546e-02f, 2.07481876e-01f, 1.16878793e-01f, -1.78617314e-01f, 4.96879488e-01f, 3.65241885e-01f,
  3.13230097e-01f, -6.77371398e-02f, 3.47594172e-01f, -1.99262604e-01f, 1.74420580e-01f, 2.43941635e-01f, -2.91808307e-01f, -4.75809053e-02f, -7.80571550e-02f, 3.42075467e-01f,
  -3.49935181e-02f, 9.23176557e-02f, -4.14415509e-01f, 1.56834379e-01f, 3.37365776e-01f, 4.07725662e-01f, 3.73992592e-01f, 1.19767226e-01f, 9.01382193e-02f, 1.06780224e-01f,
  2.81846046e-01f, 1.40724361e-01f, 8.40128213e-02f, 2.92061687e-01f, 2.39804700e-01f, 2.63758034e-01f, 5.00432014e-01f, -5.47223315e-02f, 3.57880145e-01f, 4.98131245e-01f,
  -4.50215161e-01f, -1.37748569e-01f, -1.89082399e-01f, 3.90466928e-01f, 2.46007428e-01f, 3.99744272e-01f, 3.99314724e-02f, -1.78054377e-01f, 2.86954612e-01f, 1.89115182e-01f,
  5.62616028e-02f, -3.65364365e-02f, -8.84827524e-02f, -1.02052696e-01f, 3.70267272e-01f, 2.63980210e-01f, -6.32645264e-02f, 1.57692209e-01f, -2.03774288e-01f, -4.41308975e-01f,
  3.31371538e-02f, 7.07882792e-02f, -6.98034093e-03f, 3.09115630e-02f, -3.06880742e-01f, 1.46160826e-01f, -2.35079080e-01f, -3.46638262e-01f, -4.40883785e-01f, 1.00874849e-01f,
  -1.59980416e-01f, -1.47224829e-01f, 1.52980667e-02f, -2.15296857e-02f, 4.11299050e-01f, 2.13034794e-01f, -3.95648211e-01f, 3.02729696e-01f, 8.36908445e-02f, 2.83710539e-01f,
  3.35249722e-01f, 3.48465711e-01f, 7.03447983e-02f, -2.78875977e-01f, 5.90163097e-03f, 9.40961018e-03f, 3.60978991e-01f, -7.37731531e-02f, 1.67533144e-01f, -1.25172451e-01f,
  -1.83323428e-01f, -2.57360786e-01f, 3.32684666e-02f, 2.35549480e-01f, 2.75443226e-01f, 2.22279564e-01f, 1.77411258e-01f, -3.49908292e-01f, 7.50917718e-02f, -5.21390915e-01f,
  -1.26457348e-01f, -3.58253568e-02f, 6.44575730e-02f, 7.08306134e-02f, 4.62323040e-01f, 2.82313138e-01f, -1.13904543e-01f, 2.11740192e-02f, -1.32249460e-01f, 2.39168815e-02f,
  3.01952600e-01f, 1.37200624e-01f, -9.63231921e-02f, 3.29143643e-01f, -1.85944396e-03f, -2.36253694e-01f, -2.58947790e-01f, -1.36262193e-01f, 2.08916873e-01f, -3.72758031e-01f,
  2.58704036e-01f, 2.79868513e-01f, 2.23103464e-01f, -6.47685230e-01f, -2.75965333e-02f, -2.95494460e-02f, -1.53215498e-01f, 1.10669479e-01f, 1.22070335e-01f, -3.88607919e-01f,
  -2.42418677e-01f, -3.23313296e-01f, 3.18658464e-02f, -3.83473709e-02f, -4.65284474e-03f, 2.01149717e-01f, 1.39944643e-01f, 1.13999702e-01f, 2.74780214e-01f, 2.67458320e-01f,
  -3.41993511e-01f, 2.95126796e-01f, 1.59578547e-01f, 3.04971576e-01f, 3.10326427e-01f, 2.78942347e-01f, 3.52613837e-01f, 6.86200112e-02f, 1.88813195e-01f, -1.60847828e-01f,
  2.09861740e-01f, 9.31806024e-03f, 3.79141420e-01f, 2.59970993e-01f, 2.73392528e-01f, -2.19056934e-01f, 3.30071062e-01f, 1.23247407e-01f, 2.11675748e-01f, 3.62393260e-01f,
  8.16150531e-02f, 4.12459552e-01f, 1.50087401e-01f, 3.91012132e-01f, -2.13675518e-02f, 1.57728747e-01f, 4.16581094e-01f, 3.41034919e-01f, -1.25343561e-01f, 2.81717181e-02f,
  -1.00670055e-01f, 2.05343068e-01f, 3.09384644e-01f, -2.57113688e-02f, 1.75593019e-01f, -3.25075001e-01f, 2.62929082e-01f, 1.56245738e-01f, 1.58302858e-01f, 1.35501355e-01f,
  -1.64612606e-01f, -1.32377073e-01f, 1.40284747e-01f, -1.61735475e-01f, -3.67464393e-01f, 1.85173720e-01f, -3.66815269e-01f, -2.56462336e-01f, -2.16698378e-01f, 1.95013165e-01f,
  2.92045295e-01f, 5.94775528e-02f, -1.39580891e-01f, 1.39963374e-01f, 9.33402311e-03f, 4.25883494e-02f, 4.07774299e-01f, -1.08161539e-01f, 1.67799935e-01f, 8.76145214e-02f,
  -9.96464416e-02f, -3.32559943e-01f, 3.59419405e-01f, 1.28234535e-01f, 2.74550885e-01f, 2.97741205e-01f, -7.00130453e-03f, 3.06512356e-01f, 3.45788692e-04f, 6.46088123e-02f,
  2.26964295e-01f, 2.15923399e-01f, 1.76367462e-01f, 3.44723500e-02f, 1.09997466e-02f, 3.24869394e-01f, 1.67392731e-01f, 3.37198168e-01f, 2.29001135e-01f, 2.37121016e-01f,
  3.88823956e-01f, 3.93132508e-01f, 2.07263276e-01f, 2.84799784e-01f, 1.67247027e-01f, 3.56891066e-01f, 4.24963504e-01f, 2.86745936e-01f, 6.81918636e-02f, 4.53425944e-01f,
  3.40194434e-01f, -9.86436605e-02f, 2.71193266e-01f, 4.26954001e-01f, -1.78959861e-01f, -7.56970793e-02f, 2.85962552e-01f, -5.51042520e-02f, -5.13941944e-02f, 1.69984894e-04f,
  1.55345410e-01f, 2.65708324e-02f, -1.32613778e-01f, 4.83715594e-01f, -1.90446749e-01f, 1.22982837e-01f, -1.18795820e-01f, -1.00533254e-01f, 4.15729126e-03f, 9.38762203e-02f,
  -1.89665660e-01f, -2.09527090e-02f, -1.50830284e-01f, 2.06341267e-01f, 2.11151809e-01f, 3.79678518e-01f, 3.01211059e-01f, -4.66882616e-01f, -1.10138640e-01f, 2.04057649e-01f,
  1.58723637e-01f, 1.17468357e-01f, 2.94949472e-01f, 3.50398421e-01f, 3.30148786e-01f, -5.46183400e-02f, -3.67723286e-01f, 1.97407290e-01f, 1.60892487e-01f, -4.89933342e-02f,
  3.11207861e-01f, -6.25090078e-02f, -4.22051456e-03f, 6.99647292e-02f, 6.98980764e-02f, 9.02493671e-02f, -2.96697199e-01f, -3.49287599e-01f, 1.09929420e-01f, -2.35370919e-01f,
  -1.46413609e-01f, 3.01548004e-01f, -1.69985354e-01f, -5.90189159e-01f, -1.40414611e-01f, -6.82589784e-02f, -1.48917466e-01f, -6.16768077e-02f, 1.72418788e-01f, -3.98420870e-01f,
  -2.51021683e-01f, -1.49918392e-01f, -2.21523046e-01f, -2.05877140e-01f, -2.51762390e-01f, 1.43622458e-01f, 3.09188873e-01f, 2.89077640e-01f, 1.08988568e-01f, 3.11263502e-01f,
  3.70889641e-02f, 2.62803346e-01f, 4.43554103e-01f, 2.98559278e-01f, 2.46141255e-01f, 1.63077991e-02f, 4.53807145e-01f, -4.50163009e-03f, -2.88738515e-02f, -8.90422761e-02f,
  1.74417403e-02f, 1.74403246e-02f, -4.29288670e-02f, 1.02369562e-02f, -3.17621201e-01f, -2.18942776e-01f, 1.45088330e-01f, -1.76942170e-01f, -1.55018836e-01f, 1.51290700e-01f,
  -3.41386683e-02f, -3.96615922e-01f, -2.38746122e-01f, 2.90014207e-01f, 4.58212078e-01f, -1.38026282e-01f, 6.11455971e-03f, 4.81979728e-01f, -5.52970767e-02f, -4.16900337e-01f,
  1.99549705e-01f, 2.74751574e-01f, 3.60739306e-02f, 3.75003576e-01f, 2.14903668e-01f, 2.20648069e-02f, 2.42093317e-02f, 1.95490047e-01f, 1.13101825e-01f, 4.09641415e-02f,
  -3.50623056e-02f, -1.88849181e-01f, 1.28249228e-01f, 1.29280835e-01f, -2.01019406e-01f, 1.02545761e-01f, 1.05265424e-01f, -3.88958454e-01f, 2.09724396e-01f, 1.68581903e-01f,
  2.56614685e-01f, 1.83527932e-01f, 2.02435091e-01f, 2.89133787e-01f, 2.07983911e-01f, 5.18942297e-01f, 3.23869109e-01f, 3.88861299e-01f, 3.16834599e-01f, 2.16407374e-01f,
  4.94628586e-03f, 3.39912355e-01f, -2.25559160e-01f, 1.70258999e-01f, 3.30294579e-01f, 1.14526764e-01f, -2.18530551e-01f, -3.60611230e-01f, -4.38936846e-03f, 2.23487064e-01f,
  -1.20342113e-01f, 3.26477140e-01f, -9.41290334e-02f, 3.31653714e-01f, 1.14850275e-01f, 2.50281721e-01f, 1.09137883e-02f, 4.04907107e-01f, 2.58876741e-01f, 4.02343929e-01f,
  1.26114815e-01f, 2.55466282e-01f, -7.34020472e-02f, 1.27337426e-01f, 3.65576267e-01f, -5.86952735e-03f, 2.34120652e-01f, 2.19543919e-01f, -4.37662452e-01f, 2.84166396e-01f,
  -1.05777092e-01f, -1.60853922e-01f, 2.07138389e-01f, 4.52156007e-01f, -3.31223547e-01f, 4.84684035e-02f, 1.00523131e-02f, -2.03710757e-02f, 1.05567135e-01f, -8.36346298e-02f,
  3.58612299e-01f, 5.84091879e-02f, 3.78325671e-01f, 7.59589672e-02f, -7.77887851e-02f, 3.85539651e-01f, -1.04597062e-01f, -3.84821236e-01f, 1.98797472e-02f, -1.19202677e-02f,
  -2.09823623e-01f, -5.41852355e-01f, -3.16308349e-01f, -3.39040998e-03f, 8.29540193e-02f, 1.09052733e-01f, -5.31328171e-02f, 1.90720931e-01f, 2.84519941e-01f, 4.01786834e-01f,
  -1.97849303e-01f, 3.86187494e-01f, 2.69011825e-01f, 1.38856739e-01f, 1.15505360e-01f, 4.81774598e-01f, -1.57476366e-01f, 3.47211659e-01f, -1.92673668e-01f, 2.56360918e-01f,
  4.04411815e-02f, -1.57570958e-01f, 3.83005202e-01f, 2.84321874e-01f, 1.00771129e-01f, -1.02829263e-02f, -2.33798981e-01f, 1.39279723e-01f, -2.59591732e-02f, -1.56821162e-01f,
  -3.35382283e-01f, -1.69351712e-01f, -3.42310905e-01f, -1.16328970e-01f, -2.01943353e-01f, 1.23219594e-01f, 2.00090539e-02f, -6.21146671e-02f, 3.59657794e-01f, -1.16286956e-01f,
  -3.47707957e-01f, 3.70752871e-01f, 3.86929363e-01f, 1.79055586e-01f, 2.08981037e-01f, 4.57068160e-02f, 3.62162441e-01f, 2.25644946e-01f, -1.13711596e-01f, -9.69870687e-02f,
  4.89748299e-01f, -1.74225673e-01f, 4.30650860e-02f, -2.61418194e-01f, -1.82354778e-01f, -4.14103270e-01f, 3.01596016e-01f, 3.67279023e-01f, -2.42600381e-01f, 4.09610301e-01f,
  -4.51889664e-01f, 3.65055978e-01f, 1.33384824e-01f, 2.76856780e-01f, 4.00458425e-01f, 1.91373035e-01f, 1.50735423e-01f, -5.57071641e-02f, 2.64647633e-01f, 8.41267705e-02f,
  -2.10751936e-01f, 3.41863215e-01f, 2.67014980e-01f, -1.92916896e-02f, -2.78164595e-01f, 1.48607194e-01f, 5.15427254e-02f, 1.89288169e-01f, -1.61431581e-01f, -5.09336293e-02f,
  2.69275993e-01f, 2.54707873e-01f, -2.80657291e-01f, 2.64580637e-01f, 8.81215632e-02f, 2.19820157e-01f, 4.92080040e-02f, 2.82703876e-01f, -2.19537422e-01f, 1.49199963e-01f,
  7.19854385e-02f, 1.74715370e-01f, 1.69631138e-01f, 1.27110690e-01f, 2.94710308e-01f, 8.77242610e-02f, 2.10105702e-02f, -4.29061115e-01f, 2.60995656e-01f, 4.11658049e-01f,
  2.59586394e-01f, 2.08810017e-01f, -1.55761227e-01f, -2.28612810e-01f, -1.86740533e-01f, -4.63548779e-01f, 1.85587913e-01f, -6.99551329e-02f, 7.90081173e-02f, 5.82990497e-02f,
  -2.20816769e-02f, -7.29658082e-02f, 3.92098516e-01f, -3.60456556e-02f, -3.34570467e-01f, -1.64368488e-02f, 4.38720956e-02f, 3.77364129e-01f, 1.41801581e-01f, 2.45839521e-01f,
  2.56213874e-01f, -8.11898708e-02f, 3.17563623e-01f, -8.28120112e-02f, 1.47906274e-01f, 2.90167723e-02f, 5.21951735e-01f, 1.75571993e-01f, 1.01713054e-01f, -3.77652138e-01f,
  4.55901474e-01f, 1.99451074e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.11947797e-01f, 2.47315317e-02f, -3.97195332e-02f, 6.55370355e-02f, 1.62805662e-01f, 1.14408374e-01f, 1.25658751e-01f, 1.10556349e-01f, -1.92543164e-01f, 4.12850231e-01f,
  1.75472721e-01f, 6.72941878e-02f, 1.94852844e-01f, -4.92583811e-02f, 9.51798186e-02f, -3.76162231e-02f, 3.26740772e-01f, 3.68604094e-01f, 2.70716250e-01f, -7.32422173e-02f,
  5.43259233e-02f, 2.28227481e-01f, 9.95468721e-02f, 3.10025573e-01f, 1.75889760e-01f, -2.01269444e-02f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -8.57486448e-04f, -1.65599674e-01f, 1.49677441e-01f, -1.46498531e-01f, -7.70387203e-02f, -4.22040522e-02f, 8.78463238e-02f, 1.06173962e-01f, 1.89205885e-01f, 4.64015827e-02f,
  -2.11399347e-02f, 1.55174956e-01f, -4.45743203e-02f, -1.03865668e-01f, -8.01341832e-02f, -1.86895311e-01f, -2.94297263e-02f, 1.38346225e-01f, -1.95707232e-01f, -1.62907898e-01f,
  -8.75199661e-02f, 8.63877833e-02f, -8.06075409e-02f, 6.98349401e-02f, -1.54778212e-01f, 6.24712035e-02f, -1.93924122e-02f, -6.64078295e-02f, 4.60719764e-02f, -7.05645457e-02f,
  1.94037586e-01f, -5.93832582e-02f, -2.32803404e-01f, -9.08276141e-02f, -1.65127069e-01f, -1.83289438e-01f, 1.84098005e-01f, 3.35816473e-01f, 6.70373142e-02f, 9.35814455e-02f,
  -1.37445748e-01f, -1.07920296e-01f, -1.96324319e-01f, 2.11495593e-01f, 1.87206827e-02f, -8.20622742e-02f, 1.49667934e-01f, 1.65781751e-01f, -1.90115616e-01f, 9.03850943e-02f,
  5.43127656e-02f, -7.56251672e-03f, 1.12498246e-01f, -1.24820411e-01f, 2.36532856e-02f, 6.75060675e-02f, 1.71055302e-01f, -3.70459929e-02f, -2.63436995e-02f, -1.00072235e-01f,
  -2.51475871e-02f, -2.13935643e-01f, 1.17059916e-01f, 1.36178181e-01f, 1.40371889e-01f, 6.09580688e-02f, 1.11340113e-01f, 2.10303023e-01f, -1.62043702e-02f, -7.34426379e-02f,
  2.02802122e-01f, -1.99193373e-01f, 2.66608268e-01f, -1.26540303e-01f, 8.16245936e-03f, 6.21031001e-02f, 3.79491113e-02f, 4.29226495e-02f, -1.74076423e-01f, 1.78873576e-02f,
  2.09306747e-01f, 1.55359255e-02f, -2.55546063e-01f, 1.28965572e-01f, -8.45208764e-03f, 1.01283625e-01f, -6.54489398e-02f, 1.36643976e-01f, -1.38957918e-01f, 1.33452773e-01f,
  -1.35413215e-01f, -8.07545334e-02f, 1.14190251e-01f, -1.00114018e-01f, 2.33662222e-02f, -1.13272391e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  8.24794024e-02f, 9.67810899e-02f, 4.63188551e-02f, -1.24417022e-01f, 3.40058029e-01f, -2.51082242e-01f, 4.00099277e-01f, 4.11236167e-01f, -1.31139100e-01f, 2.94076204e-01f,
  5.05004585e-01f, -3.09174042e-02f, -1.97238952e-01f, 9.47164819e-02f, 4.26587164e-02f, -2.94203699e-01f, 1.99448407e-01f, 5.75122647e-02f, 2.34412149e-01f, 2.53154878e-02f,
  2.20567182e-01f, -7.01743811e-02f, -2.35233366e-01f, 5.27569771e-01f, 1.57512486e-01f, 3.60563815e-01f, 5.76620623e-02f, -4.82358783e-02f, 2.34331191e-01f, 6.85483217e-02f,
  -1.81825772e-01f, 5.74366860e-02f, 3.00003022e-01f, 3.16185430e-02f, -5.10683283e-02f, -1.73600186e-02f, -3.56813133e-01f, -4.38442200e-01f, 3.08404654e-01f, 1.56941026e-01f,
  9.55222026e-02f, 1.42209306e-01f, 2.51457263e-02f, -9.16352868e-02f, -3.54507454e-02f, -1.83285281e-01f, -1.50996581e-01f, 2.49644727e-01f, 4.39103618e-02f, -2.75565058e-01f,
  -4.44149338e-02f, -1.70871243e-01f, 1.53465524e-01f, -3.09535749e-02f, 4.85301107e-01f, 3.10736716e-01f, 6.40456975e-02f, -1.16516449e-01f, 1.85454816e-01f, 5.36736250e-01f,
  1.10531688e-01f, 2.88802773e-01f, -3.78971845e-02f, -3.47683161e-01f, -9.77927297e-02f, 2.83153486e-02f, 6.23487942e-02f, 2.37994552e-01f, -6.88380077e-02f, -2.16756508e-01f,
  -1.59340963e-01f, 3.57206725e-02f, 4.57583874e-01f, -4.04036433e-01f, -3.97315502e-01f, 3.73883337e-01f, -1.38910338e-01f, -4.05903041e-01f, -2.47790977e-01f, 2.05529824e-01f,
  -3.68642122e-01f, -6.84973150e-02f, -3.99690717e-01f, -3.08972448e-01f, 2.43196040e-01f, 1.46498114e-01f, 4.40125823e-01f, -1.15689687e-01f, -2.63194293e-01f, -3.13940287e-01f,
  3.05187404e-01f, 1.93503067e-01f, 3.15790117e-01f, 3.17261100e-01f, 1.15072377e-01f, -3.48853469e-01f, -9.39882174e-02f, -1.99770823e-01f, -2.06137300e-01f, 1.81468442e-01f,
  -1.91497341e-01f, -3.01574320e-01f, 1.88385785e-01f, 7.52631053e-02f, 1.94091350e-01f, -1.33251920e-01f, -2.63958365e-01f, 3.78823787e-01f, 8.27660784e-02f, -4.98492047e-02f,
  1.89454585e-01f, 2.25515515e-01f, -2.28935346e-01f, -3.67029421e-02f, -1.67847231e-01f, 2.85724495e-02f, 2.53566265e-01f, 3.26402187e-02f, 2.22625509e-01f, -1.68834373e-01f,
  5.19625731e-02f, -1.26844749e-01f, 2.54527777e-01f, 4.58831221e-01f, 2.84098446e-01f, 3.77929568e-01f, 9.81730968e-02f, -6.20409586e-02f, 7.10413083e-02f, 1.44594938e-01f,
  7.84076452e-02f, -3.10880244e-01f, 5.46825454e-02f, 6.54833019e-02f, -4.26858366e-02f, 3.29743713e-01f, -1.73719689e-01f, 2.27883179e-02f, 1.65645614e-01f, -1.40957877e-01f,
  2.93694586e-01f, 4.62630421e-01f, -2.67820179e-01f, 2.72841334e-01f, -2.91074812e-01f, -3.21901172e-01f, 4.62060392e-01f, 2.94164896e-01f, -2.65892595e-01f, -1.45779744e-01f,
  1.65925860e-01f, -8.80232267e-03f, 1.87127382e-01f, 8.06951746e-02f, 5.31296842e-02f, 3.88488203e-01f, 1.39455467e-01f, 2.86256582e-01f, -1.41092688e-01f, 1.10335656e-01f,
  -1.29030813e-02f, 8.97146203e-03f, 3.54040638e-02f, 3.65014941e-01f, 5.89530841e-02f, 1.57977775e-01f, -4.34110761e-02f, -1.21821105e-01f, -1.17849760e-01f, 2.84459472e-01f,
  -2.56640345e-01f, -6.61156252e-02f, 2.96186388e-01f, 7.63992816e-02f, 8.31092820e-02f, -3.96187976e-03f, 3.62307489e-01f, -1.69969782e-01f, -4.58761692e-01f, 5.64932525e-02f,
  1.20102651e-01f, 4.00867492e-01f, 1.75212603e-02f, -2.59473324e-01f, 1.02626435e-01f, 2.32371777e-01f, 2.46460244e-01f, -4.71896023e-01f, -1.25428677e-01f, 3.07261795e-01f,
  6.31289482e-02f, 1.34510189e-01f, 1.05668582e-01f, -1.21090636e-01f, -4.10418846e-02f, -1.32759392e-01f, -9.12683085e-02f, 5.04281819e-02f, 4.21320759e-02f, -1.30992025e-01f,
  3.97371827e-03f, -4.92187543e-03f, -1.49566919e-01f, 5.09251878e-02f, 5.94943874e-02f, 7.74130002e-02f, 8.01667422e-02f, 7.77520910e-02f, 2.36589402e-01f, 4.93546724e-01f,
  2.47603878e-02f, -7.20772445e-02f, 1.43603414e-01f, 3.08289349e-01f, -1.20861456e-01f, -9.20136198e-02f, -6.70339614e-02f, -6.65509775e-02f, 9.51235145e-02f, -2.28991523e-01f,
  1.91163376e-01f, -2.47895688e-01f, 3.20563197e-01f, 2.29848865e-02f, 1.63340464e-01f, -8.00329670e-02f, -1.49401259e-02f, -2.74212122e-01f, -6.93944022e-02f, 2.82328606e-01f,
  1.43747598e-01f, 7.75363594e-02f, 7.29556661e-03f, 1.59659609e-01f, -1.06220149e-01f, -8.69529322e-02f, 4.33925569e-01f, 3.73842806e-01f, -2.76500452e-02f, 2.16703430e-01f,
  -5.28845191e-02f, -3.52789871e-02f, 4.00408685e-01f, 1.97697133e-01f, 5.79041541e-02f, -2.61580050e-02f, -6.30783960e-02f, 1.71142325e-01f, 1.14804015e-01f, 5.26553392e-02f,
  -8.85097980e-02f, 2.63557643e-01f, -1.39706388e-01f, 3.17283459e-02f, 1.41823009e-01f, 4.09553409e-01f, 3.69368792e-02f, -1.56934842e-01f, 2.38106102e-02f, -4.35455292e-02f,
  4.61478420e-02f, 1.54317126e-01f, -1.75731167e-01f, -1.39145732e-01f, -1.73413828e-02f, 1.59689322e-01f, -3.69067550e-01f, 5.30838482e-02f, 1.69179186e-01f, 1.96080133e-01f,
  1.78588286e-01f, 2.30206728e-01f, -2.95490563e-01f, -3.74692887e-01f, -2.78747499e-01f, 1.28419504e-01f, -4.19174433e-01f, -2.74482463e-02f, -4.24010642e-02f, -5.38842440e-01f,
  -5.31210564e-02f, 2.47510195e-01f, 3.90990436e-01f, 1.01618797e-01f, 9.95608270e-02f, 4.32559997e-01f, -6.53262138e-02f, -1.98442228e-02f, 7.63610825e-02f, 1.04546130e-01f,
  1.37959525e-01f, 2.76752025e-01f, -2.32705280e-01f, -2.58019835e-01f, -1.30547822e-01f, -6.74150288e-02f, 3.33881676e-01f, -1.22708753e-01f, -8.28602165e-02f, 1.73603117e-01f,
  -1.53302968e-01f, -3.56150836e-01f, -8.76433253e-02f, 1.28448695e-01f, 2.50978142e-01f, 5.05299345e-02f, -1.34300217e-02f, -2.31675327e-01f, 2.29069322e-01f, 5.97992614e-02f,
  4.10301775e-01f, 1.73112359e-02f, -3.63636941e-01f, -1.07475281e-01f, 3.39056641e-01f, 3.83420020e-01f, 2.22022817e-01f, -2.89884210e-01f, 2.90975511e-01f, -8.45310539e-02f,
  3.21407020e-01f, 2.38404259e-01f, 2.48590156e-01f, 1.64830014e-01f, 2.23425161e-02f, -3.32362890e-01f, 7.08890930e-02f, -2.95458108e-01f, -8.46001729e-02f, -1.05295114e-01f,
  2.87877113e-01f, -1.62469506e-01f, -2.47564584e-01f, -1.12858787e-02f, -3.72154951e-01f, 3.55151445e-01f, 3.13673228e-01f, -5.48073590e-01f, 1.00819573e-01f, -1.64799854e-01f,
  2.26256356e-01f, 7.88608566e-02f, 2.39520252e-01f, 4.84086871e-01f, -1.51935950e-01f, 3.75697836e-02f, 3.24874222e-01f, 9.10251737e-02f, 1.81791604e-01f, 3.33129704e-01f,
  -7.67643303e-02f, -8.22859854e-02f, -2.34661698e-01f, 3.37012708e-01f, -7.72433402e-03f, 4.68593985e-02f, 2.97879912e-02f, -2.91397423e-01f, 1.37019139e-02f, -1.19791821e-01f,
  3.20472091e-01f, -2.12354795e-03f, 1.22649148e-01f, -5.75944334e-02f, -3.80125642e-01f, -2.40508541e-01f, 1.50169447e-01f, -2.18264803e-01f, 3.77341747e-01f, 7.05289014e-04f,
  -1.37228742e-01f, -2.44683679e-03f, 3.38312596e-01f, 2.37432376e-01f, 1.50380209e-01f, 2.18049854e-01f, -5.24858572e-03f, 4.49217051e-01f, 1.29758105e-01f, -4.31713015e-01f,
  -5.75677084e-04f, 4.80564237e-02f, 1.71963200e-01f, -7.38649070e-02f, 7.42461383e-02f, -1.29660219e-02f, -9.09719802e-03f, -1.03405081e-01f, 1.08259745e-01f, 4.69406724e-01f,
  -5.25042675e-02f, 3.31296921e-01f, 3.27026367e-01f, 1.40130565e-01f, -2.88763016e-01f, 2.38106623e-01f, 6.87371939e-02f, -1.27023431e-02f, 3.22710395e-01f, -1.15995735e-01f,
  2.05874696e-01f, 4.55917537e-01f, 1.75232738e-01f, 2.69829363e-01f, 9.31237638e-02f, 1.36835009e-01f, -7.72129223e-02f, -1.56031877e-01f, 1.85257524e-01f, 2.44146422e-01f,
  -3.33421193e-02f, 1.08498096e-01f, 2.81212687e-01f, -3.63386154e-01f, 3.55837584e-01f, 2.92982042e-01f, -3.48179996e-01f, 6.59639686e-02f, -1.70249432e-01f, -5.81504554e-02f,
  2.83688873e-01f, 2.78333455e-01f, 2.79946595e-01f, 3.06549162e-01f, -2.11660042e-02f, 1.69764161e-01f, 2.75729746e-01f, 7.81376883e-02f, -1.46530479e-01f, -9.96327922e-02f,
  3.76393944e-01f, -1.05396867e-01f, -1.14642814e-01f, 2.12392867e-01f, 1.27888368e-02f, 2.59630203e-01f, -1.12660855e-01f, 1.55561000e-01f, -1.12238079e-02f, 2.14096904e-01f,
  3.62754524e-01f, 6.69046193e-02f, -1.75455973e-01f, 2.86625028e-01f, -4.47375933e-05f, 9.00752023e-02f, 1.28617883e-01f, -1.07320696e-01f, 1.07268430e-01f, -2.46524096e-01f,
  -1.64846212e-01f, -7.96795040e-02f, 4.12392318e-02f, -1.36376098e-01f, 3.24047327e-01f, 2.07139373e-01f, 1.87911674e-01f, 2.17631593e-01f, -2.65194029e-01f, 3.88910800e-01f,
  -8.22470859e-02f, -1.93003580e-01f, 3.54119718e-01f, -2.36732394e-01f, 2.04440922e-01f, 1.44758165e-01f, -3.17833722e-01f, 2.78823078e-01f, 1.46389186e-01f, -9.73357111e-02f,
  1.49450507e-02f, -1.80803567e-01f, 3.03555191e-01f, -2.37664990e-02f, 2.42188811e-01f, 1.92078993e-01f, 2.86660910e-01f, 1.03556246e-01f, 9.68630314e-02f, 6.44391254e-02f,
  6.96690232e-02f, 2.29158640e-01f, 8.51853713e-02f, -2.78235644e-01f, -4.98436779e-01f, 1.84184954e-01f, 1.48854405e-01f, 5.03471419e-02f, -3.49829018e-01f, 5.23591936e-02f,
  2.72702903e-01f, -2.09023029e-01f, 4.19262618e-01f, 2.30056673e-01f, -1.03331171e-01f, 1.48867488e-01f, 3.99780571e-02f, 8.93380567e-02f, 3.10098827e-01f, 2.96012431e-01f,
  -3.34223211e-02f, 8.33685026e-02f, 1.99387539e-02f, 1.51184633e-01f, 4.54742849e-01f, -1.94809005e-01f, -1.91751733e-01f, 3.00103307e-01f, 2.85514463e-02f, -1.20591268e-01f,
  2.44068000e-02f, 1.76238313e-01f, 1.31287679e-01f, -9.47924107e-02f, 2.80789405e-01f, -1.24242395e-01f, 5.63765056e-02f, -3.14120948e-01f, 2.45038375e-01f, 1.98587656e-01f,
  7.88783096e-03f, -3.14785503e-02f, 2.24667713e-01f, 3.50745797e-01f, -2.65731215e-01f, -2.43900307e-02f, 9.52282250e-02f, -1.51621982e-01f, 3.77795309e-01f, -5.10132778e-03f,
  1.87376380e-01f, 1.29767179e-01f, 2.06458166e-01f, -1.79195791e-01f, 1.20006084e-01f, 1.17336035e-01f, -2.59343266e-01f, -2.66230404e-02f, 2.12084755e-01f, 1.32946119e-01f,
  2.22340971e-01f, -2.82478482e-01f, 2.11328611e-01f, -1.91042513e-01f, 6.60902560e-02f, 2.40015402e-01f, 6.26005791e-03f, -5.43258227e-02f, -5.40778875e-01f, -5.61597459e-02f,
  -2.48748317e-01f, -1.03913493e-01f, 1.04928702e-01f, 1.70708343e-01f, -8.14718008e-02f, -3.65313113e-01f, 4.75709140e-01f, 3.79916191e-01f, -1.73259854e-01f, 3.66561025e-01f,
  -5.60172722e-02f, -2.92949155e-02f, -4.26176339e-02f, 2.65583426e-01f, -3.61595973e-02f, 2.25777328e-01f, 1.36542290e-01f, -8.90913419e-03f, 1.07838586e-02f, -1.12346150e-01f,
  1.17050536e-01f, -7.15101957e-02f, -1.22918807e-01f, 4.63942289e-01f, -6.07392797e-03f, 2.93021917e-01f, 1.31792650e-01f, 1.25600114e-01f, 7.17012361e-02f, -9.75902379e-02f,
  -6.38894290e-02f, 9.25747529e-02f, -3.56104285e-01f, -4.40288693e-01f, -1.84570178e-01f, 6.73250854e-02f, 2.31803507e-01f, -1.79385081e-01f, 5.63974082e-02f, 8.79922509e-02f,
  -2.46368200e-01f, 3.73557359e-01f, 1.09717332e-01f, 4.39017326e-01f, 1.56606317e-01f, 6.43121228e-02f, 1.19837917e-01f, 1.24167010e-01f, 1.94653213e-01f, 8.46833661e-02f,
  1.60542592e-01f, 8.67929235e-02f, 1.89213246e-01f, -2.46893808e-01f, -3.13300371e-01f, -2.66727805e-02f, -7.83064067e-02f, 2.57269412e-01f, 3.58063549e-01f, 5.34720495e-02f,
  1.64475173e-01f, -1.51577890e-01f, 2.48965070e-01f, 1.15695193e-01f, -3.51582497e-01f, -4.00958657e-01f, -9.43508968e-02f, 2.81185597e-01f, -6.93347724e-03f, 7.53078386e-02f,
  1.08686760e-01f, 4.03889298e-01f, -1.29773557e-01f, 3.23587120e-01f, 1.04494125e-01f, -1.57867819e-02f, 4.07906994e-02f, 3.53781581e-01f, -1.62803262e-01f, 4.97864395e-01f,
  -2.40071103e-01f, 9.45464671e-02f, -6.98101744e-02f, 3.72961313e-01f, 4.94939014e-02f, -4.88747030e-01f, -3.35506171e-01f, 2.28626385e-01f, 3.77332002e-01f, 3.58020753e-01f,
  -1.16082177e-01f, 9.76876915e-02f, 1.27040848e-01f, -2.06404001e-01f, 2.11079702e-01f, 2.69754212e-02f, 3.71790349e-01f, 4.68802273e-01f, 5.73326759e-02f, 1.83802754e-01f,
  5.33593833e-01f, -8.30681622e-02f, -1.05537564e-01f, 2.29562521e-02f, 3.45070571e-01f, -8.05697218e-02f, 2.19458356e-01f, 1.08174596e-03f, 1.91172987e-01f, 1.03701502e-01f,
  1.18910015e-01f, 8.43853429e-02f, -2.83204526e-01f, 3.04749131e-01f, 3.11989993e-01f, 2.53030270e-01f, 2.47908402e-02f, 2.22775899e-02f, 1.17640421e-01f, -6.20339401e-02f,
  -1.06558807e-01f, -4.35931422e-02f, 2.76245147e-01f, 2.36912072e-01f, -7.49995857e-02f, -2.99930155e-01f, -3.70884985e-01f, -7.28956163e-02f, 3.96820039e-01f, 2.86018312e-01f,
  -2.46432588e-01f, -3.45701305e-03f, 8.83635655e-02f, -3.17332894e-02f, 2.04157382e-01f, 2.21244156e-01f, 1.32218853e-03f, 1.02659784e-01f, -1.04585364e-01f, 2.59384692e-01f,
  5.95086098e-01f, 1.69145882e-01f, 2.09156454e-01f, -1.39395386e-01f, 2.65707728e-02f, 3.24400902e-01f, 3.65489870e-01f, -3.14768881e-01f, -3.22348446e-01f, 3.47300917e-01f,
  1.74431205e-01f, -8.10096338e-02f, 2.21175939e-01f, 1.20453224e-01f, 4.51720923e-01f, 3.54615867e-01f, 7.05368146e-02f, -1.77102387e-01f, -4.57746416e-01f, -3.66504729e-01f,
  -9.32895094e-02f, -4.58169989e-02f, -1.24874286e-01f, 1.45458639e-01f, 2.16666520e-01f, -2.46460855e-01f, -4.86932881e-02f, 3.24289680e-01f, -2.12780237e-01f, 4.76574719e-01f,
  -2.97820587e-02f, -2.92675078e-01f, 1.63808148e-02f, -1.82076097e-01f, 9.79387015e-02f, -1.02869920e-01f, 1.74736351e-01f, 3.34758967e-01f, -6.59698769e-02f, -1.36085883e-01f,
  2.30904087e-01f, -1.13658525e-01f, -1.01651192e-01f, 4.87291753e-01f, -1.40282558e-02f, -1.57933921e-01f, -2.48637684e-02f, -2.07185417e-01f, -3.03996280e-02f, 9.35903266e-02f,
  -4.20633495e-01f, -6.17896058e-02f, 2.32431769e-01f, 3.33756626e-01f, 3.33938897e-01f, -6.92379102e-02f, -1.78234115e-01f, 2.03526348e-01f, 2.83732623e-01f, -2.40822583e-01f,
  3.22501734e-02f, 8.13488886e-02f, 1.22934662e-01f, 1.24292314e-01f, -6.47724606e-03f, -2.40597844e-01f, -3.12481448e-02f, 2.96629127e-02f, 1.77719519e-01f, 2.96781393e-04f,
  1.42438978e-01f, -1.00233257e-01f, 1.04529344e-01f, 1.84916392e-01f, 3.28474164e-01f, 3.00669879e-01f, 4.34884764e-02f, -3.06769013e-01f, 5.40152192e-02f, 9.48431045e-02f,
  5.57640418e-02f, 3.33288193e-01f, -2.02865601e-01f, -2.81994939e-01f, 1.01135299e-01f, 6.70838431e-02f, 1.68712437e-01f, -1.26477763e-01f, -1.53758720e-01f, 3.06126148e-01f,
  -3.17061216e-01f, -1.19211644e-01f, -9.53087509e-02f, 1.80858657e-01f, 3.17264974e-01f, -2.58719593e-01f, 6.77496791e-02f, -5.64870648e-02f, 4.43681240e-01f, -7.27974698e-02f,
  2.66675651e-01f, 4.65892106e-01f, -2.39664465e-01f, -2.24814448e-03f, 1.76267713e-01f, 3.01187456e-01f, 3.12679201e-01f, -4.63016555e-02f, 1.60882488e-01f, 1.56283844e-02f,
  -2.55715340e-01f, -7.84922466e-02f, -8.85544121e-02f, -1.51572913e-01f, 8.01769376e-01f, -2.07389835e-02f, 1.05872182e-02f, -1.36323441e-02f, -3.86808962e-01f, 9.90215018e-02f,
  4.90465730e-01f, -1.80490404e-01f, -7.08995536e-02f, 2.06219748e-01f, 2.00800419e-01f, -1.71526894e-02f, 1.94058985e-01f, -1.10392839e-01f, 9.26481858e-02f, 6.80189282e-02f,
  -5.95795624e-02f, 2.54192412e-01f, -3.13798308e-01f, 1.67120457e-01f, 1.81797668e-01f, 1.81131259e-01f, 1.52662350e-02f, -1.29553035e-01f, -2.03661859e-01f, 1.45685032e-01f,
  -5.68844639e-02f, 4.04174961e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  2.23740816e-01f, 2.68680334e-01f, 2.40005389e-01f, 1.53321736e-02f, -6.90021738e-02f, 8.03484172e-02f, 2.80810922e-01f, 3.15004662e-02f, 1.27829770e-02f, 2.55703658e-01f,
  7.65788555e-02f, 1.96780991e-02f, 1.24110661e-01f, 2.55921241e-02f, 6.29524291e-02f, 2.94279248e-01f, -2.61702668e-02f, 2.46137783e-01f, 4.40637879e-02f, -2.08135359e-02f,
  4.70031053e-02f, 2.07161948e-01f, 9.84594226e-02f, 8.21264759e-02f, 9.09489989e-02f, -1.92469850e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -3.76819372e-02f, -2.13674635e-01f, 7.11136386e-02f, -7.52147958e-02f, -1.69362172e-01f, 2.31369063e-01f, -1.99128851e-01f, 3.36495847e-01f, 2.09147274e-01f, 2.90178508e-02f,
  -5.19338727e-01f, 1.83355853e-01f, 1.37827906e-03f, -5.42985499e-01f, -3.04555744e-01f, 2.10732341e-01f, 1.98368445e-01f, 2.85921127e-01f, -3.91340017e-01f, -2.99066514e-01f,
  -2.44720653e-01f, -3.81915689e-01f, -1.88496172e-01f, 6.41927645e-02f, 2.19542205e-01f, -3.39754641e-01f, -1.29805282e-01f, -2.82209724e-01f, 2.25730628e-01f, 1.29545033e-01f,
  1.64197311e-01f, -4.40140396e-01f, 1.63883001e-01f, -1.83345199e-01f, -7.70531520e-02f, 4.77278978e-02f, 3.73386592e-02f, 6.91758096e-02f, 2.60969996e-01f, -3.15660313e-02f,
  -3.07910532e-01f, -1.95512339e-01f, -2.38791227e-01f, 2.46462688e-01f, 1.21052131e-01f, -1.99692562e-01f, -4.39023525e-02f, 1.32456258e-01f, 1.76050782e-01f, 1.81210726e-01f,
  1.08462265e-02f, -2.99926043e-01f, -2.96856314e-02f, -3.85964185e-01f, 2.17616335e-01f, -2.08424956e-01f, -1.72827139e-01f, 2.03983802e-02f, 7.31276795e-02f, -1.04861192e-01f,
  -1.27910778e-01f, -1.71945795e-01f, 1.78922623e-01f, -6.83539659e-02f, -9.79383364e-02f, -9.00386572e-02f, -2.56138414e-01f, 2.37513274e-01f, 2.53905714e-01f, 1.41676888e-01f,
  4.84701172e-02f, -4.01694745e-01f, -1.94468603e-01f, -1.22811221e-01f, -4.60439563e-01f, -6.23078384e-02f, 1.58682615e-01f, -2.73078978e-02f, -2.36186340e-01f, -3.42323124e-01f,
  -3.57373655e-01f, 1.09778240e-01f, 2.79211581e-01f, 1.26375198e-01f, 2.57521152e-01f, -1.41397476e-01f, -1.79962650e-01f, -2.29096696e-01f, -2.29563028e-01f, 1.78791545e-02f,
  2.31661215e-01f, -4.66814451e-02f, -1.37916028e-01f, -5.77170849e-02f, -9.74118486e-02f, -1.33500516e-01f, 6.82100132e-02f, 6.42920062e-02f, 1.69977710e-01f, -1.71753228e-01f,
  8.13550800e-02f, -3.16477209e-01f, -5.50853968e-01f, 2.61302829e-01f, 3.27892810e-01f, 1.60452336e-01f, 2.00372577e-01f, -3.16066235e-01f, -5.80151320e-01f, -1.02804482e-01f,
  2.25422859e-01f, 1.17166668e-01f, 1.77369818e-01f, -2.79685259e-01f, -8.48001912e-02f, -3.50867608e-03f, -5.93550093e-02f, -5.28850555e-01f, -7.50446022e-02f, -1.83768794e-01f,
  -4.22729135e-01f, -4.90647972e-01f, -3.02253544e-01f, -1.38902158e-01f, -5.60334809e-02f, 1.06899887e-02f, 2.63285905e-01f, 9.81433690e-02f, 1.06084067e-02f, 2.59796288e-02f,
  1.31632015e-01f, -1.35156438e-01f, -2.63143361e-01f, -5.66252060e-02f, 1.13673531e-01f, 3.50661129e-01f, -2.59690642e-01f, 4.15044427e-02f, 2.45359078e-01f, -1.55772433e-01f,
  -1.71632677e-01f, 1.30318433e-01f, -1.43491447e-01f, 3.56135629e-02f, 1.09888641e-02f, -3.38653862e-01f, -1.84501275e-01f, -1.88676387e-01f, 1.16996402e-02f, 1.61427364e-01f,
  -1.46914631e-01f, 3.73747833e-02f, -3.38265121e-01f, -3.72860879e-01f, 1.15882106e-01f, 2.60798573e-01f, 2.26732761e-01f, 1.36092111e-01f, 6.04576916e-02f, -3.90579462e-01f,
  8.98544192e-02f, 1.17181232e-02f, 2.10592553e-01f, -1.63440108e-01f, -1.92264423e-01f, 2.27082267e-01f, 1.94028109e-01f, -1.02283722e-02f, -1.55457005e-01f, -3.07121754e-01f,
  1.76526695e-01f, -2.01674938e-01f, -2.20656976e-01f, 2.12792610e-03f, -1.19915061e-01f, -2.06209809e-01f, 2.50264317e-01f, -1.07917719e-01f, -3.60930949e-01f, -2.00839508e-02f,
  -4.47745562e-01f, -6.14142679e-02f, 4.22452502e-02f, -3.00666820e-02f, 1.74807072e-01f, 2.90262312e-01f, 1.19075321e-01f, -7.08870515e-02f, 2.91510910e-01f, -5.96060216e-01f,
  5.51406778e-02f, 2.61934996e-01f, -9.89865810e-02f, 1.13468662e-01f, 2.96178106e-02f, -1.12880550e-01f, 7.34094381e-02f, -2.03246593e-01f, 1.69411495e-01f, -3.12312782e-01f,
  -1.66003391e-01f, -4.22916979e-01f, 1.43162906e-01f, -8.97360146e-02f, -3.51308174e-02f, 2.65912991e-03f, -3.18502724e-01f, -1.34689629e-01f, -1.37980551e-01f, -3.15870792e-01f,
  1.21857479e-01f, 2.37758696e-01f, -1.72149599e-01f, 1.02449939e-01f, -2.07462981e-01f, -8.81859437e-02f, -3.15143587e-03f, -2.80262623e-02f, 2.16182873e-01f, 2.18355820e-01f,
  -4.08179402e-01f, -2.81741500e-01f, -3.79240334e-01f, 2.28114486e-01f, -3.30251455e-02f, -1.53837875e-01f, 1.08714156e-01f, -1.04719967e-01f, 4.82803360e-02f, -3.07200074e-01f,
  -3.54380339e-01f, 9.97156501e-02f, 1.47101253e-01f, 8.41433406e-02f, 1.60549104e-01f, 2.59545147e-01f, -2.14304432e-01f, -2.50899076e-01f, 4.04079467e-01f, -2.28153124e-01f,
  4.65114489e-02f, -2.95861483e-01f, -2.47519806e-01f, -2.48745352e-01f, 4.12357179e-03f, -2.11095020e-01f, -2.83673912e-01f, 1.80933073e-01f, 4.73402580e-03f, 3.83161716e-02f,
  -2.92637438e-01f, -3.21513951e-01f, 2.17059836e-01f, 1.28040418e-01f, -2.01042771e-01f, -1.40518591e-01f, -1.36798203e-01f, -2.27738451e-02f, -2.59835631e-01f, -1.56373918e-01f,
  -2.07669020e-01f, -4.80640344e-02f, -2.57257134e-01f, -3.10617059e-01f, -2.65340716e-01f, -2.74541173e-02f, 8.92301351e-02f, 3.07851464e-01f, -1.32101670e-01f, 1.81397554e-02f,
  2.86692649e-01f, -1.04474939e-01f, -3.30176413e-01f, -5.02559207e-02f, -2.53336057e-02f, 1.75104365e-01f, -1.71529315e-02f, 3.42219323e-02f, -2.74647862e-01f, 1.02117606e-01f,
  9.39689856e-03f, 2.57943451e-01f, -4.05371800e-04f, -5.86910009e-01f, -3.41799170e-01f, -1.41118065e-01f, -1.74525857e-01f, 1.30607411e-01f, 1.99494094e-01f, 3.42992470e-02f,
  1.73416480e-01f, -1.24358356e-01f, 2.36652866e-01f, 2.35912740e-01f, 2.99670756e-01f, 8.99523944e-02f, -3.13406378e-01f, -1.49368152e-01f, 1.20708823e-01f, -4.30325598e-01f,
  -1.80221528e-01f, -1.38306275e-01f, -1.76743940e-01f, -3.12381774e-01f, -3.56745958e-01f, -1.70677304e-02f, 2.57802196e-03f, 2.43978024e-01f, 1.21286914e-01f, 1.29397497e-01f,
  1.83906630e-01f, -5.87498844e-01f, -5.13264477e-01f, -4.64625388e-01f, 1.98959678e-01f, 2.01295242e-01f, -3.68791133e-01f, -1.65548958e-02f, -3.73699777e-02f, -3.64141464e-02f,
  -1.74329832e-01f, 2.29933374e-02f, -1.08728923e-01f, 2.64753193e-01f, -3.00904792e-02f, 1.30839899e-01f, -2.89970815e-01f, 1.31138703e-02f, 1.24501035e-01f, 1.72136188e-01f,
  -3.24920803e-01f, -3.27759355e-01f, 2.00664088e-01f, -2.41783172e-01f, -2.54609317e-01f, 2.85924107e-01f, -1.52570471e-01f, -9.59849954e-02f, 9.51036140e-02f, 2.57392344e-03f,
  2.73706675e-01f, -3.60715598e-01f, 2.71419257e-01f, -3.79815102e-01f, 8.66942704e-02f, -1.74055636e-01f, -7.76799247e-02f, -4.43825386e-02f, -4.30796683e-01f, 1.78656936e-01f,
  1.13894053e-01f, 2.19357032e-02f, 3.83416414e-02f, 2.46997595e-01f, 2.80871391e-01f, -2.46166065e-01f, 3.15248489e-01f, -1.71820417e-01f, -3.86559278e-01f, -2.53562152e-01f,
  -1.40573442e-01f, -1.62124470e-01f, 1.37864828e-01f, -3.82658802e-02f, 2.24148259e-01f, 8.96699652e-02f, -6.46291003e-02f, 5.24004735e-02f, -2.72226304e-01f, -2.72444844e-01f,
  5.94799854e-02f, -2.63404936e-01f, -3.98947686e-01f, 2.93434262e-01f, -1.76241472e-01f, 1.62764460e-01f, 2.70518601e-01f, 2.79534400e-01f, -2.35573709e-01f, 2.52757818e-01f,
  1.81472721e-03f, -2.00281590e-01f, -1.56700864e-01f, -3.93940002e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.27897903e-01f, -1.79049715e-01f, -1.12989888e-01f, -1.51364923e-01f, 1.17066257e-01f, 1.93981931e-01f, 8.83733109e-02f, -3.66990045e-02f, -1.74633786e-02f, -1.90835252e-01f,
  -1.90379322e-01f, 1.01094529e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    