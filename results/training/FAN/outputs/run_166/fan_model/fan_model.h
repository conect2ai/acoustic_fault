/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.01259433e-01f, 8.28681365e-02f, -5.00730127e-02f, -1.98423490e-01f, 2.48137563e-01f, 1.27909184e-01f, -1.13847315e-01f, 4.61086854e-02f, -9.39591695e-03f, -1.90917552e-01f,
  -2.53640413e-01f, 2.35579103e-01f, -4.47769463e-02f, -1.95349216e-01f, 8.32454264e-02f, -1.06641211e-01f, -1.45320088e-01f, -5.44402748e-02f, 2.08282769e-01f, 4.82155867e-02f,
  -1.17828213e-02f, -1.22584432e-01f, -9.09228474e-02f, 4.47349995e-02f, 4.01964262e-02f, 3.85610610e-02f, 1.41924769e-02f, 6.51172996e-02f, 2.47062580e-03f, 1.97044685e-01f,
  1.49363503e-02f, -5.48883304e-02f, 3.59630324e-02f, 7.16962889e-02f, -9.35289487e-02f, -4.74409871e-02f, -4.88496423e-02f, 1.26453027e-01f, -5.47649413e-02f, 2.33743321e-02f,
  5.37206456e-02f, -1.31892217e-02f, 5.20738140e-02f, -8.45494792e-02f, 4.82113771e-02f, 1.86283700e-02f, 6.03001751e-02f, 2.14580093e-02f, 6.12218305e-02f, -8.60279147e-03f,
  -1.15279280e-01f, 3.26889157e-02f, -6.20135404e-02f, 1.69214964e-01f, 6.58407062e-02f, -4.82396446e-02f, 1.41379936e-02f, 1.72470078e-01f, 1.12258084e-01f, 7.61518031e-02f,
  7.61802644e-02f, -9.80680287e-02f, -6.52730018e-02f, 7.65144452e-03f, -5.63979931e-02f, -2.09163837e-02f, -3.83345261e-02f, -5.46590686e-02f, 1.78671780e-03f, -8.89860466e-02f,
  1.66003048e-01f, 5.94304875e-02f, -5.51143289e-02f, -3.07176411e-02f, -8.99804309e-02f, -6.76310509e-02f, -8.45136046e-02f, 6.36030138e-02f, 6.46722391e-02f, 9.02805701e-02f,
  -6.50221184e-02f, -1.27120866e-02f, 9.22077820e-02f, 1.11011729e-01f, 4.85026352e-02f, 2.10301839e-02f, -1.19589865e-01f, -1.62317567e-02f, -1.27233416e-01f, -4.62497175e-02f,
  1.54803053e-01f, 6.08930476e-02f, 2.81408448e-02f, 1.62955761e-01f, -4.95473966e-02f, 7.88648203e-02f, -6.61503077e-02f, 1.08824745e-01f, -5.62353767e-02f, 8.42223614e-02f,
  -2.74828020e-02f, 5.85614368e-02f, 1.06150925e-01f, 5.32592051e-02f, -2.30934210e-02f, -1.43109322e-01f, -6.59457073e-02f, -6.17032833e-02f, 7.10875317e-02f, 6.80530965e-02f,
  -7.94715211e-02f, 4.51911874e-02f, -1.16677983e-02f, -9.30642616e-03f, -1.28146768e-01f, 7.93288834e-03f, -3.16684991e-02f, 1.40344635e-01f, 1.05867237e-01f, -1.27743771e-02f,
  -9.83501896e-02f, 1.64458632e-01f, 9.97121260e-02f, 2.29724683e-02f, 4.76030931e-02f, -2.56474972e-01f, -1.52317986e-01f, 9.63986106e-03f, -9.70087051e-02f, 1.04971759e-01f,
  -1.13412842e-01f, 1.07709698e-01f, -4.69814725e-02f, -5.15665561e-02f, -3.00222814e-01f, -1.00307822e-01f, -1.44755572e-01f, -5.14600016e-02f, 3.82245779e-02f, 1.47782892e-01f,
  4.85913567e-02f, -9.74579602e-02f, 1.07083935e-02f, 8.71940702e-02f, 2.08144203e-01f, 1.77235335e-01f, 7.27601175e-04f, 5.72378896e-02f, 1.21973552e-01f, -1.31332070e-01f,
  5.44257313e-02f, 6.79133926e-03f, 7.11169019e-02f, -9.08519141e-03f, -2.05548871e-02f, 9.56814811e-02f, -3.84244107e-04f, -7.22878128e-02f, 5.45557328e-02f, -3.17525826e-02f,
  -3.58039215e-02f, 8.39647725e-02f, -6.43337741e-02f, 2.67797634e-02f, 4.25937176e-02f, 9.15778503e-02f, 1.29423916e-01f, 4.46673930e-02f, 4.04034816e-02f, -1.52915751e-03f,
  2.24772729e-02f, 2.65939143e-02f, 5.07884752e-03f, -1.93231739e-02f, 1.20161781e-02f, -2.64422745e-02f, -1.02717519e-01f, -6.88072741e-02f, 5.90355508e-02f, -5.59967943e-02f,
  -6.03447855e-02f, 4.24548015e-02f, -5.34171537e-02f, 1.16841123e-01f, 1.00624748e-02f, -2.56057805e-03f, 1.58145707e-02f, -9.21541080e-02f, -1.02318905e-01f, 1.07089262e-02f,
  6.94958270e-02f, 1.65861230e-02f, -1.00451007e-01f, 3.37992981e-02f, 3.40218619e-02f, -1.15803974e-02f, -6.31608292e-02f, 9.39820260e-02f, 6.52353987e-02f, -7.43182749e-02f,
  -1.90239830e-03f, 1.07893243e-03f, 5.82503080e-02f, -3.59920263e-02f, -5.53871244e-02f, 2.88634952e-02f, 5.22476882e-02f, 1.20264918e-01f, 6.16006507e-03f, -1.67917069e-02f,
  -1.32411405e-01f, -1.09183803e-01f, 4.84840237e-02f, -3.41891847e-03f, -5.03322743e-02f, 1.15206145e-01f, -6.72224462e-02f, -1.00430563e-01f, 5.87446019e-02f, 2.78253611e-02f,
  -2.54139118e-02f, 4.62557115e-02f, 3.67132314e-02f, 5.32754883e-02f, -5.43731414e-02f, -4.66568768e-02f, 2.90329326e-02f, 1.57144517e-02f, -3.44620310e-02f, -1.09948173e-01f,
  3.72558199e-02f, -7.02898577e-02f, 3.42639424e-02f, -9.38774869e-02f, -9.24344212e-02f, -9.92133375e-03f, -6.57752603e-02f, 1.08871860e-02f, 4.65143323e-02f, -2.57022399e-02f,
  -4.90366817e-01f, 1.23122856e-01f, -2.45297290e-02f, -1.94005445e-01f, -9.72935930e-02f, -9.02510136e-02f, 6.18238859e-02f, 2.98392363e-02f, -4.93600219e-02f, 6.19728677e-02f,
  3.01898029e-02f, -1.31676614e-01f, 2.43992209e-01f, -2.63067037e-02f, 3.04336771e-02f, 2.21187919e-01f, -2.29497418e-01f, -5.18003032e-02f, 4.96900231e-02f, -1.86080500e-01f,
  -2.90166270e-02f, 5.16836578e-03f, 1.14683583e-01f, 4.21665460e-02f, -2.33030230e-01f, -8.77439044e-04f, 3.06996889e-02f, 2.99518798e-02f, -1.75536871e-01f, -1.62879955e-02f,
  -1.43064577e-02f, 6.41174763e-02f, -1.77368168e-02f, -2.96475533e-02f, -3.65889519e-02f, 3.09144612e-02f, 4.11576265e-03f, -3.10657620e-02f, -5.95764183e-02f, -7.66087091e-03f,
  -4.82771620e-02f, 4.49017528e-03f, 3.95608880e-03f, -3.36291902e-02f, -1.87699810e-01f, -4.13884521e-02f, 2.23146901e-02f, -1.02457620e-01f, 1.31256515e-02f, -1.43622244e-02f,
  1.02911452e-02f, -6.41380711e-06f, -9.95554999e-02f, -6.92650676e-02f, -2.30547115e-02f, 3.61129381e-02f, -2.11158190e-02f, -4.87694591e-02f, -3.82983685e-02f, -1.36463672e-01f,
  4.19975892e-02f, 1.14188835e-01f, 1.37854535e-02f, 5.53148128e-02f, 4.38269088e-03f, 1.04259476e-01f, -3.82847749e-02f, 3.36675830e-02f, -9.87839028e-02f, 3.39582674e-02f,
  2.72085071e-02f, -7.19015598e-02f, -1.26868561e-02f, -7.27306232e-02f, -5.50581701e-02f, 1.04752192e-02f, -4.04735794e-03f, 1.77338012e-02f, -5.49078621e-02f, 3.24531049e-02f,
  9.42013711e-02f, 4.37223613e-02f, 9.33151543e-02f, 6.11301698e-03f, 6.41546398e-02f, -8.51456150e-02f, -3.16577218e-02f, -4.80340905e-02f, 6.21300749e-02f, -1.21013187e-01f,
  3.83554921e-02f, 3.26050557e-02f, 9.07592177e-02f, 4.44359519e-02f, 2.45242640e-02f, -1.42655924e-01f, 2.06352528e-02f, -6.24662973e-02f, -2.06353720e-02f, -3.21919359e-02f,
  -4.33262996e-02f, -1.45479981e-02f, -4.60167080e-02f, -4.32685502e-02f, -2.84505635e-02f, 1.31756112e-01f, 4.65834327e-02f, -3.48410979e-02f, -3.41794342e-02f, -2.03305054e-02f,
  2.73813736e-02f, -6.16119476e-03f, 5.88043369e-02f, -1.52514195e-02f, -8.35005790e-02f, 1.32423695e-02f, -5.81539944e-02f, 7.26917982e-02f, -2.49824282e-02f, 5.04590832e-02f,
  -3.88471156e-01f, 2.10504398e-01f, -3.32245976e-02f, -1.99954763e-01f, -2.03920931e-01f, -8.59934166e-02f, 2.06233542e-02f, -9.46186557e-02f, 7.61326551e-02f, 2.31400356e-01f,
  -1.14271872e-01f, -1.10494360e-01f, 1.42577365e-01f, -1.26940748e-02f, -2.37469733e-01f, 2.45219648e-01f, -2.50806063e-02f, 7.55520537e-02f, -1.64101906e-02f, -1.66937247e-01f,
  -1.28942907e-01f, -1.39421269e-01f, -3.13481428e-02f, -1.17595587e-02f, -1.62118822e-01f, -8.99177566e-02f, -6.19613081e-02f, -2.92385314e-02f, -8.30447078e-02f, -9.39277634e-02f,
  -1.07004225e-01f, -7.94556271e-03f, 6.25252351e-02f, 5.84113337e-02f, -6.77743852e-02f, 2.28990987e-02f, 2.35181190e-02f, -2.46834308e-02f, -9.56204087e-02f, -7.97649994e-02f,
  5.83925657e-03f, -2.84349862e-02f, -1.13404319e-02f, -2.45490465e-02f, -3.32527012e-02f, -2.20071990e-02f, 1.16018755e-02f, 2.91760918e-03f, 6.29483089e-02f, 1.20680137e-02f,
  7.97524303e-02f, 3.26467562e-04f, 2.54723174e-03f, 2.13077776e-02f, 4.93571982e-02f, 7.51098469e-02f, 6.43841252e-02f, -2.49819681e-02f, 8.98932666e-03f, -6.20239526e-02f,
  1.31387531e-03f, 9.31493193e-02f, 2.59736218e-02f, 9.15063266e-03f, 4.97109769e-03f, 9.61248763e-03f, 9.92537513e-02f, 5.99943958e-02f, -1.12457676e-02f, 8.80399272e-02f,
  -1.06938735e-01f, -2.48134900e-02f, 1.75165702e-02f, 7.70006329e-02f, 5.04906364e-02f, 2.28470229e-02f, 5.23273535e-02f, -4.17868979e-02f, -6.30298927e-02f, 8.59595612e-02f,
  8.91656280e-02f, 9.98522937e-02f, -1.98346307e-03f, 4.40981239e-02f, -6.40649274e-02f, 9.69578046e-03f, 1.12545773e-01f, 7.60787204e-02f, 4.37978245e-02f, -1.38708144e-01f,
  -9.20875743e-02f, -1.00981832e-01f, -1.86321896e-03f, 5.19839907e-03f, 8.40309560e-02f, -7.47809708e-02f, 1.50327891e-01f, 7.42369518e-02f, -5.57207838e-02f, -5.17610647e-02f,
  -1.65823139e-02f, -7.85202533e-03f, 7.71657526e-02f, 3.54632735e-02f, 1.19652683e-02f, 1.09331377e-01f, 2.90390439e-02f, -2.13752072e-02f, 2.18773708e-02f, -2.35357620e-02f,
  1.99819803e-02f, -4.98843379e-02f, 6.12913184e-02f, -1.23252282e-02f, 8.33066478e-02f, 2.49194494e-03f, -6.72167912e-02f, 2.04506703e-02f, -1.90921053e-02f, 1.15448095e-01f,
  1.65382177e-01f, -2.61772186e-01f, -8.96288306e-02f, 5.07862084e-02f, 2.59686202e-01f, 2.99841315e-01f, 1.72931314e-01f, -1.16082065e-01f, -1.87680483e-01f, -8.09107497e-02f,
  7.47956336e-02f, -8.61794408e-03f, -1.13815531e-01f, -8.98079108e-03f, 2.00431794e-01f, -2.35698149e-01f, 1.67510271e-01f, 8.41616094e-02f, -1.49009034e-01f, 1.24451749e-01f,
  3.49552706e-02f, 6.16706610e-02f, -4.80348617e-02f, 2.07813904e-02f, 9.79385376e-02f, -3.32601108e-02f, 7.98246562e-02f, 1.27650261e-01f, 2.20444486e-01f, 8.87364000e-02f,
  2.43332926e-02f, -9.67087373e-02f, -6.30656853e-02f, -1.10323029e-02f, 8.08065981e-02f, 1.89227074e-01f, 9.49220657e-02f, 9.08139274e-02f, 6.76557496e-02f, -1.48685533e-03f,
  9.10420269e-02f, -4.34828037e-03f, -1.82059687e-02f, 7.04726204e-02f, 8.95887017e-02f, -5.11340536e-02f, 5.49120409e-03f, -3.59470211e-02f, -1.13923013e-01f, -4.95793261e-02f,
  -4.44781967e-02f, -5.79038262e-02f, 6.18471205e-02f, -3.82999741e-02f, 7.89596811e-02f, -5.94539419e-02f, -8.27401057e-02f, 5.73977306e-02f, 6.71183839e-02f, 7.02700438e-03f,
  2.37422925e-03f, 1.52378120e-02f, 4.47677076e-02f, -3.83663848e-02f, 5.32749947e-03f, -9.91484150e-02f, 1.22919800e-02f, -1.71235576e-02f, 7.65164047e-02f, -7.88875297e-02f,
  1.77958718e-04f, 5.78844827e-03f, 1.03177968e-02f, 1.31402329e-01f, 6.32294640e-02f, -5.71103245e-02f, 6.40930468e-03f, 2.96646580e-02f, -7.82839605e-04f, 1.69642437e-02f,
  -7.16907904e-03f, 4.93486300e-02f, -5.63648343e-02f, -3.02351527e-02f, -1.53342113e-01f, 4.59945463e-02f, -4.35954556e-02f, 1.46044763e-02f, 8.60116724e-03f, 1.53573617e-01f,
  -2.09457241e-03f, -1.07345238e-01f, -1.22118935e-01f, -1.24222729e-02f, -9.08378884e-02f, 6.38099760e-02f, 8.60404689e-03f, -4.44552153e-02f, 9.75812823e-02f, 3.26047316e-02f,
  1.56247497e-01f, 1.66803356e-02f, 5.89870699e-02f, 9.95314494e-02f, -5.86481728e-02f, -9.11364704e-02f, 6.82917535e-02f, 1.00687332e-02f, 7.77952895e-02f, -1.64226722e-02f,
  4.11343612e-02f, 9.16489139e-02f, 6.06295420e-03f, 7.54294470e-02f, 6.26338422e-02f, 9.77784209e-03f, -7.17280805e-03f, -4.02776077e-02f, 2.36865412e-02f, -2.66279262e-02f,
  1.97959766e-01f, -7.33884349e-02f, 1.92640796e-01f, 3.94590646e-02f, 5.61935119e-02f, -1.15754396e-01f, -8.35584179e-02f, 4.55661230e-02f, 4.02584463e-01f, -2.64342874e-02f,
  -2.79606935e-02f, -1.64177790e-01f, 1.12541988e-02f, -3.67009729e-01f, -9.64583158e-02f, -4.72933650e-02f, -2.30317414e-01f, -2.02023655e-01f, -5.46224490e-02f, 8.66263360e-03f,
  -6.87428713e-02f, -3.40852410e-01f, -2.05104053e-01f, -1.53513432e-01f, -7.96235278e-02f, 3.92137617e-02f, -2.30482653e-01f, -6.47275895e-02f, -4.21526700e-01f, -2.01149449e-01f,
  -1.79301072e-02f, 9.78274941e-02f, 9.56265181e-02f, 6.91323653e-02f, -1.90036325e-03f, -4.38257270e-02f, -1.67092122e-02f, -1.64436966e-01f, -2.01425888e-02f, -1.46086039e-02f,
  -6.11503832e-02f, -3.30157615e-02f, 3.36960354e-03f, -7.40995556e-02f, 5.69827259e-02f, 6.54719919e-02f, 4.29828186e-03f, 8.04087967e-02f, -2.22438648e-02f, 1.44532276e-02f,
  1.57364421e-02f, 6.10808134e-02f, 5.22043630e-02f, -1.14801507e-02f, 8.54644999e-02f, 8.10560808e-02f, 7.98185766e-02f, -1.05098926e-01f, -4.72980514e-02f, -3.27799469e-02f,
  -2.66605616e-02f, -2.08640043e-02f, -1.81923836e-01f, 2.49782372e-02f, -2.50987653e-02f, 1.51516065e-01f, 1.09118801e-02f, -7.66069116e-03f, 1.72103290e-02f, -5.38375741e-03f,
  1.25041634e-01f, -1.59962010e-02f, -1.35076344e-02f, 5.52090369e-02f, -7.92970508e-02f, 8.98977593e-02f, -2.04539448e-02f, -9.84739289e-02f, 2.25973018e-02f, 6.06069453e-02f,
  2.80174743e-02f, 1.44961115e-03f, 4.17055450e-02f, 7.21299797e-02f, 4.44438756e-02f, 1.53200282e-02f, 2.69810366e-03f, -1.24214077e-02f, 2.42417622e-02f, -1.03775963e-01f,
  -5.53362109e-02f, -1.52996719e-01f, 3.71638685e-02f, -2.69380603e-02f, 4.45220917e-02f, -5.68320528e-02f, -2.63458933e-03f, -6.48049936e-02f, -1.13917984e-01f, -6.75197467e-02f,
  -4.86524105e-02f, 5.52915148e-02f, 1.10090159e-01f, 1.10540092e-01f, -1.85545962e-02f, 7.03330114e-02f, -6.81699961e-02f, 6.10288121e-02f, -3.38416994e-02f, 4.87549603e-02f,
  -2.77918931e-02f, 4.57785279e-02f, -2.19343305e-02f, -4.08521630e-02f, 5.77494167e-02f, 3.58120315e-02f, 1.83575926e-03f, -3.85093503e-02f, -6.87657297e-02f, -2.28982586e-02f,
  1.48737520e-01f, -8.35168548e-03f, -1.37544572e-01f, -4.24428061e-02f, 1.06417812e-01f, -4.98218201e-02f, -2.36707345e-01f, 7.48823509e-02f, -1.24908768e-01f, -1.02756850e-01f,
  -4.88003194e-02f, -6.90826923e-02f, -1.76406637e-01f, -1.19210687e-02f, 2.35588253e-01f, -1.45107657e-01f, 3.03121842e-02f, -9.05944258e-02f, -1.10668287e-01f, 1.15673700e-02f,
  1.51206600e-02f, 1.57586724e-01f, 2.89565083e-02f, 1.27149835e-01f, 2.10604444e-02f, -9.12803225e-03f, 2.79440463e-01f, -7.45990947e-02f, 1.06983036e-01f, 6.22674786e-02f,
  1.57487113e-02f, 5.68116177e-03f, -1.42799601e-01f, -7.79619962e-02f, 1.23713855e-02f, -1.07042186e-01f, -1.55468553e-01f, -1.99065655e-01f, -1.59739122e-01f, -1.61282048e-02f,
  -2.44538691e-02f, 8.38822275e-02f, 3.71069200e-02f, -8.37861449e-02f, 3.55010554e-02f, -7.11252540e-02f, 4.10552435e-02f, 3.05901677e-03f, -9.05860811e-02f, -4.40371372e-02f,
  -4.73942384e-02f, -1.33853434e-02f, -2.84790974e-02f, 1.86029598e-02f, -3.83551791e-02f, -2.22921185e-02f, -2.91560516e-02f, -2.42825374e-02f, 8.34191125e-03f, 2.07186583e-02f,
  -9.93927792e-02f, -1.71946827e-02f, 1.16393259e-02f, 5.43579683e-02f, 2.36156657e-02f, 3.21877934e-02f, 5.59758581e-03f, 2.84253825e-02f, 8.79222006e-02f, 1.15870200e-01f,
  1.79431394e-01f, 8.94089323e-03f, 8.49587545e-02f, -1.27269968e-01f, 2.91821230e-02f, 4.72535100e-03f, -8.27347580e-03f, 9.16312858e-02f, -1.98153574e-02f, 3.25048976e-02f,
  -1.57832652e-02f, -5.70946708e-02f, 1.32682547e-01f, -1.04265884e-02f, 3.15727815e-02f, -5.27660847e-02f, 4.62192930e-02f, -5.09602353e-02f, -8.99204239e-02f, -2.33233962e-02f,
  2.45143071e-01f, 2.27310300e-01f, 3.78226116e-02f, 1.19268656e-01f, 3.88240218e-02f, -2.82027088e-02f, -2.03512341e-01f, 2.78741606e-02f, -3.16057429e-02f, -5.69124939e-03f,
  -9.16021466e-02f, 4.21272404e-02f, 1.46739855e-01f, 3.28653753e-02f, 5.73999435e-02f, 1.33937851e-01f, -7.93589652e-03f, 2.97145620e-02f, 3.82050239e-02f, 1.13505885e-01f,
  1.25540420e-01f, 2.07422934e-02f, -7.58585855e-02f, 2.93135159e-02f, -5.58675937e-02f, 7.06034228e-02f, 5.10898270e-02f, -8.29233080e-02f, 3.11202798e-02f, -1.80232655e-02f,
  -2.05754966e-01f, -3.01721781e-01f, 4.72040474e-02f, -2.70885736e-01f, 1.39381200e-01f, 2.03166064e-02f, 1.09286137e-01f, -1.38082862e-01f, -2.85497010e-01f, -1.43065795e-01f,
  -4.71022241e-02f, -1.08020164e-01f, 7.86791369e-02f, -1.21335916e-01f, 1.81263387e-01f, 2.92292424e-02f, -1.34414628e-01f, -1.11460961e-01f, 2.40854081e-02f, -3.08121629e-02f,
  -3.02196871e-02f, 1.09508482e-03f, 2.10971504e-01f, 1.08558744e-01f, 1.52844482e-03f, 3.35749076e-03f, 4.87835966e-02f, 1.61082342e-01f, 2.36072093e-02f, 6.09163158e-02f,
  -1.79299414e-01f, -1.49320334e-01f, -2.09608674e-03f, 2.25587711e-02f, -2.38263104e-02f, 7.74237439e-02f, 7.64153078e-02f, 1.20184898e-01f, 4.90966104e-02f, 7.89183751e-02f,
  3.60342860e-02f, -1.64045654e-02f, 1.71747559e-03f, 3.39995287e-02f, 2.86510610e-03f, -1.52119314e-02f, -5.59580699e-02f, -5.49001992e-02f, -4.45346534e-02f, 1.05892882e-01f,
  -3.34980823e-02f, -3.59899960e-02f, 2.94023268e-02f, 1.47430245e-02f, 6.29543886e-02f, -6.04679100e-02f, -2.73433700e-02f, 1.19324848e-01f, -4.26476263e-02f, -4.48763818e-02f,
  9.49919000e-02f, 6.21719435e-02f, 5.66955805e-02f, -1.81376692e-02f, -2.98261829e-02f, -3.84481885e-02f, -3.73105817e-02f, -6.76995888e-02f, -7.43452534e-02f, -7.27081597e-02f,
  5.16337296e-03f, -4.18380499e-02f, -5.26268817e-02f, 7.72051746e-03f, -7.96109512e-02f, -9.08418372e-02f, -9.85036418e-02f, 4.80766892e-02f, -2.68606991e-02f, -3.79045121e-03f,
  -2.25412566e-02f, 9.50627495e-03f, 2.61430955e-03f, 3.73966433e-02f, -1.64067715e-01f, -9.52519383e-03f, -8.08250681e-02f, -1.28592715e-01f, -5.44432029e-02f, 1.50842994e-01f,
  -2.70414323e-01f, -1.26413196e-01f, 9.43250663e-04f, -8.65429342e-02f, -4.39120717e-02f, 1.02357052e-01f, 2.79217549e-02f, -1.58912092e-02f, -5.08715101e-02f, 9.33083668e-02f,
  8.39951932e-02f, -3.17224115e-02f, 5.90068800e-03f, 6.46474306e-03f, -1.09508792e-02f, -8.89423266e-02f, 7.15249591e-03f, -8.71223658e-02f, 2.11974476e-02f, -7.44185224e-02f,
  -8.03070329e-03f, -1.71959810e-02f, 4.62253354e-02f, 4.47930060e-02f, 1.10768951e-01f, 3.97155918e-02f, -5.67543693e-02f, -2.04485822e-02f, 1.12239957e-01f, 2.53017396e-02f,
  2.10613340e-01f, -2.52533287e-01f, -7.64672831e-02f, -1.19405590e-01f, 6.76066056e-02f, 4.25114520e-02f, 2.24482760e-01f, -7.33990520e-02f, 1.51931465e-01f, -1.27549931e-01f,
  1.80189341e-01f, -5.08630089e-02f, 1.59634128e-01f, -9.98966768e-02f, 8.08691531e-02f, 8.27844292e-02f, 4.92369011e-02f, 4.03981991e-02f, -1.41587006e-02f, -7.36048743e-02f,
  -6.15165606e-02f, 3.82278040e-02f, -5.36977611e-02f, -1.37316987e-01f, 8.37370902e-02f, -1.38826951e-01f, -1.47685125e-01f, -2.38113198e-03f, -1.29837483e-01f, 4.32626866e-02f,
  5.97829558e-02f, 1.30315974e-01f, -5.10248467e-02f, 1.37880826e-02f, 2.47942470e-03f, 1.66354422e-02f, -6.33618981e-02f, 4.02862541e-02f, 1.75867341e-02f, -7.13923248e-03f,
  6.82183132e-02f, -4.24216799e-02f, 1.31643310e-01f, 1.02630757e-01f, 2.73191128e-02f, 1.25309220e-03f, 3.19786742e-02f, -4.11952622e-02f, -3.83858532e-02f, 1.98111515e-02f,
  1.10554226e-01f, -3.35925892e-02f, 5.76010533e-02f, 1.01511121e-01f, 8.32054242e-02f, 5.08284606e-02f, -6.72286004e-02f, -2.87978742e-02f, -7.73828523e-03f, -9.36428905e-02f,
  1.39724731e-01f, 2.42300294e-02f, 1.63721964e-02f, -3.43435146e-02f, -1.35020884e-02f, -1.50116915e-02f, -4.83306237e-02f, -1.33034503e-02f, 1.51743721e-02f, -6.18038215e-02f,
  -6.97692782e-02f, -6.52562603e-02f, -1.84577424e-04f, -1.85954124e-02f, -4.16945070e-02f, -5.19004427e-02f, 6.76416932e-03f, -7.00696036e-02f, 7.15856701e-02f, -3.56010417e-03f,
  5.50527796e-02f, -1.36849880e-01f, -6.88068941e-02f, -4.69177216e-02f, -4.20085937e-02f, 4.41152640e-02f, -7.90620744e-02f, -5.50091267e-02f, -4.51749228e-02f, -2.38111001e-02f,
  2.20042486e-02f, -1.67789295e-01f, 1.00814272e-02f, -8.00127909e-03f, -2.15240363e-02f, -6.58947136e-03f, 1.68748386e-02f, -2.84423400e-02f, 3.84027883e-02f, -4.77963127e-02f,
  -5.87402284e-02f, 3.11238859e-02f, -2.03203075e-02f, 1.11453190e-01f, -2.96448823e-02f, -2.28314456e-02f, -9.71179977e-02f, -5.82987480e-02f, -8.24540574e-03f, -6.99918643e-02f,
  -1.01590045e-01f, 3.69090140e-02f, 5.50461709e-02f, 1.30799457e-01f, 9.36803371e-02f, 6.35522380e-02f, -8.11086074e-02f, -3.68403713e-03f, 1.37639465e-02f, -7.43475705e-02f,
  2.84579039e-01f, 1.92619249e-01f, -1.52093381e-01f, 1.60623804e-01f, -8.32408369e-02f, 3.13099883e-02f, -5.57950931e-03f, -1.15603264e-02f, 1.18504480e-01f, 2.51497239e-01f,
  -3.86329298e-03f, 1.30626261e-01f, -1.52880073e-01f, 2.80710965e-01f, -2.11292624e-01f, -7.05549866e-02f, 2.51903325e-01f, 2.14960977e-01f, 4.74263914e-02f, 3.05965003e-02f,
  1.76416300e-02f, 1.79950401e-01f, -1.68903261e-01f, -2.09327880e-02f, 4.19902690e-02f, -8.93261433e-02f, -5.28684035e-02f, -2.10486606e-01f, 4.14528362e-02f, 1.88573275e-03f,
  -6.95708394e-02f, 1.45505160e-01f, 3.54019590e-02f, -2.84272246e-02f, 1.57532822e-02f, 9.02432725e-02f, 3.14508677e-02f, -1.94680877e-02f, -3.20084915e-02f, 2.11790130e-02f,
  6.05983324e-02f, 2.89346930e-02f, 1.65966600e-02f, 3.27339321e-02f, 2.76692342e-02f, 5.10658957e-02f, 5.04274406e-02f, -4.43060435e-02f, -1.44295441e-02f, 4.47085947e-02f,
  -1.41554279e-02f, -5.67253027e-03f, -4.50942572e-03f, 3.68838087e-02f, 2.83761770e-02f, 1.10557461e-02f, -2.47312374e-02f, -1.06670551e-01f, 4.07121181e-02f, 6.68275803e-02f,
  1.30927607e-01f, 2.80730426e-03f, -7.57772401e-02f, 1.45544540e-02f, -1.73964202e-02f, 1.79078095e-02f, -9.38500389e-02f, 5.41899307e-03f, 5.91298053e-03f, -2.63210088e-02f,
  -2.41345959e-03f, -2.31768563e-02f, -7.94921536e-04f, 3.17035019e-02f, 3.43816704e-03f, 7.72837996e-02f, -5.10049835e-02f, -8.03211331e-03f, 2.06358600e-02f, -1.00126967e-01f,
  -1.60242431e-02f, -6.87410831e-02f, -6.45620376e-02f, 1.88593809e-02f, 3.87483574e-02f, 1.89494807e-02f, -4.12355363e-03f, 5.08944457e-03f, -6.08175397e-02f, -9.10931528e-02f,
  6.97406083e-02f, 1.52843043e-01f, -3.98135521e-02f, 2.38641612e-02f, 1.03985444e-01f, 1.61344275e-01f, 1.37336983e-03f, -3.49785062e-03f, -1.11656850e-02f, 8.24895129e-02f,
  2.19601765e-02f, -3.23611721e-02f, -9.26016923e-03f, 3.72453146e-02f, -1.93792060e-01f, -7.23593161e-02f, 1.13664912e-02f, -9.09214914e-02f, 4.51749451e-02f, 3.90476361e-02f,
  -1.55530758e-02f, 6.82885349e-02f, 9.48374420e-02f, 1.05335424e-02f, 4.75795940e-02f, -6.30131969e-03f, -7.43311867e-02f, 6.53372481e-02f, -5.64065762e-02f, 9.47981179e-02f,
  3.01015049e-01f, -2.61125535e-01f, -2.58297622e-01f, 1.23631962e-01f, 8.12472031e-02f, 2.77422100e-01f, 1.88726872e-01f, -4.09410298e-02f, 4.73736078e-02f, -5.24949245e-02f,
  1.82591155e-01f, -1.41717970e-01f, -1.63963646e-01f, 2.39883065e-01f, 2.00925767e-01f, -3.51639092e-02f, 1.97469905e-01f, 2.05339998e-01f, 2.07788739e-02f, -2.58015562e-03f,
  1.40362844e-01f, 2.42843211e-01f, -8.14905986e-02f, -1.17744304e-01f, 1.05689667e-01f, -1.73970520e-01f, -1.78657770e-01f, -1.09875865e-01f, 1.47160754e-01f, 1.95546588e-03f,
  9.18974131e-02f, -1.90595444e-02f, -1.31838145e-02f, -3.76080386e-02f, -2.25224458e-02f, 3.94689851e-02f, 2.58426555e-03f, -1.45801865e-02f, 8.89874250e-02f, 1.02189742e-02f,
  1.61611959e-02f, -1.64282061e-02f, -3.29339877e-02f, 1.15067631e-01f, 1.16289020e-01f, -3.17246979e-03f, -6.40863553e-02f, 6.02053199e-03f, -5.21616749e-02f, -5.43587580e-02f,
  -1.00244448e-01f, -5.22991046e-02f, 7.06120953e-02f, -3.29740420e-02f, -2.02911254e-02f, 3.05889882e-02f, -4.71090823e-02f, -1.42673314e-01f, 4.80112322e-02f, -8.50173831e-03f,
  -2.05735955e-02f, -1.40008517e-02f, 5.48585132e-03f, 3.33167985e-02f, -8.87095463e-03f, 2.51794178e-02f, 7.15846717e-02f, -5.61879203e-02f, -4.55623493e-03f, 5.29530123e-02f,
  4.23019268e-02f, -3.45058553e-02f, 7.78409764e-02f, 1.44888656e-02f, 4.29066680e-02f, 6.09981902e-02f, -2.45915987e-02f, -8.98344815e-03f, -2.04441249e-02f, -5.36146760e-02f,
  -1.45267956e-02f, 6.54279292e-02f, -1.36169136e-01f, 1.72792207e-02f, 3.09738214e-03f, -7.22688958e-02f, 1.79402647e-03f, 7.42728114e-02f, -4.11363207e-02f, 4.24179062e-02f,
  -6.22593537e-02f, -1.56929314e-01f, -6.12458065e-02f, 5.62339984e-02f, -9.11677182e-02f, 4.32684738e-03f, 4.05383222e-02f, -2.03404669e-02f, -1.05915889e-02f, 4.77412157e-02f,
  -9.90507379e-03f, -4.84122373e-02f, -1.37786195e-02f, 4.48068269e-02f, -1.01880051e-01f, -4.67619896e-02f, -4.03739028e-02f, -1.77454147e-02f, -1.96114015e-02f, -7.19401613e-02f,
  -7.18645528e-02f, -1.77018866e-02f, 7.95853208e-04f, -1.10877873e-02f, 1.64823160e-02f, -5.88949099e-02f, -3.01002916e-02f, -1.39177218e-02f, 1.37781976e-02f, -6.72240257e-02f,
  -3.25645596e-01f, -1.69704154e-01f, -2.33397961e-01f, -1.63621679e-01f, 6.07863106e-02f, 2.01481506e-01f, 2.12810021e-02f, 3.36189615e-03f, -3.42738330e-02f, 4.31404747e-02f,
  9.74654034e-02f, -1.30298436e-01f, -1.13937361e-02f, 1.21779285e-01f, 2.18823999e-02f, 9.16561782e-02f, 9.25928727e-02f, 2.55320016e-02f, -1.24344341e-02f, -5.62156178e-02f,
  -9.11828279e-02f, 9.94888619e-02f, -1.10950433e-01f, 3.92044894e-02f, -3.13809142e-02f, -1.62420198e-01f, -1.40351370e-01f, 4.05142233e-02f, 3.43552567e-02f, 6.86794743e-02f,
  7.81211630e-02f, 6.05198136e-03f, 1.88471600e-02f, 4.68361042e-02f, -5.75588755e-02f, -7.15658860e-03f, -8.26033279e-02f, -4.11456032e-03f, -7.64084421e-03f, -3.69339399e-02f,
  -1.02242433e-01f, -8.15661103e-02f, 9.85272750e-02f, 7.01564848e-02f, 9.77258384e-03f, -1.22204991e-02f, 1.71189886e-02f, 4.20748536e-03f, -6.97654635e-02f, -9.17055309e-02f,
  -5.16324416e-02f, 4.95519750e-02f, -8.48088413e-02f, -3.32268253e-02f, -1.46889955e-01f, 2.50773057e-02f, 4.90090698e-02f, -4.00617309e-02f, -7.79581070e-02f, -5.92573062e-02f,
  -5.71048968e-02f, -1.49869591e-01f, 2.21479423e-02f, 8.23776275e-02f, 3.23824696e-02f, 5.40366061e-02f, 8.45593065e-02f, 5.75281419e-02f, -2.01902185e-02f, 4.82454710e-02f,
  5.98676736e-03f, 1.07295038e-02f, 4.95458841e-02f, -3.20408083e-02f, -8.08102638e-02f, -3.02169677e-02f, -1.23148216e-02f, 3.06140203e-02f, 4.52826992e-02f, 1.06057627e-02f,
  -1.06773525e-01f, 3.43794487e-02f, 6.27375692e-02f, 7.24424003e-03f, 5.14986143e-02f, -1.96982728e-04f, -4.73864973e-02f, -4.30100486e-02f, 1.67425442e-02f, -9.50342342e-02f,
  -6.68328404e-02f, -1.64178953e-01f, 1.22927785e-01f, 1.26774698e-01f, 6.73421174e-02f, 5.64478710e-02f, -2.89559993e-03f, 2.26965006e-02f, -2.27539334e-02f, -9.92084444e-02f,
  -6.67234734e-02f, 5.57987876e-02f, 1.45857120e-02f, 2.94972938e-02f, 7.52322525e-02f, 7.46121258e-02f, -1.33947313e-01f, 4.49092872e-02f, -4.37438972e-02f, -1.14725180e-01f,
  -7.61637688e-02f, 1.66104957e-02f, -1.18243070e-02f, -1.26387794e-02f, 1.76932402e-02f, -2.37734448e-02f, 8.76468420e-02f, -9.64990817e-03f, -3.02289389e-02f, -1.19481888e-02f,
  1.03506751e-01f, -2.09220961e-01f, -1.96364999e-01f, -6.62027225e-02f, -1.06469542e-01f, 7.86564648e-02f, 2.23177031e-01f, -1.80390671e-01f, -2.38105491e-01f, 7.09316432e-02f,
  1.10062689e-01f, 4.63851914e-02f, 8.54716599e-02f, 2.71549821e-01f, 1.31223574e-01f, 9.04035345e-02f, 1.08808964e-01f, 4.79968861e-02f, -3.14314872e-01f, 4.59627695e-02f,
  -3.67791466e-02f, 2.28833690e-01f, 1.49622470e-01f, -1.33196503e-01f, 3.92823592e-02f, -1.33425951e-01f, 1.69387251e-01f, -8.87574330e-02f, 2.05964983e-01f, 2.51611732e-02f,
  5.28033152e-02f, -8.48741531e-02f, -4.70512398e-02f, -3.56784835e-02f, -1.83110125e-02f, 1.19020008e-01f, 9.71431658e-02f, 8.00874829e-02f, 3.08856405e-02f, 4.60780412e-02f,
  1.28128275e-01f, 3.17851640e-02f, -6.95203245e-02f, -6.37542782e-03f, -7.20173270e-02f, -5.63361757e-02f, 1.03863012e-02f, 7.70509290e-03f, -1.26663208e-01f, 4.41166647e-02f,
  -7.12178648e-02f, -7.36525729e-02f, -1.78412418e-03f, 1.35522271e-02f, -6.28981367e-03f, -6.13057651e-02f, -5.26622161e-02f, -5.32980338e-02f, 3.80808115e-02f, -7.14859292e-02f,
  3.82938329e-03f, 6.31075278e-02f, 1.35264650e-01f, 8.87299180e-02f, 7.69357458e-02f, -2.67877150e-02f, -4.47381623e-02f, 2.75127981e-02f, 3.74783166e-02f, 3.12535577e-02f,
  3.59554067e-02f, -4.48076753e-03f, 1.64613370e-02f, 8.92288312e-02f, 1.33166360e-02f, -2.15762225e-03f, -3.20752747e-02f, 5.77005707e-02f, 4.39404547e-02f, -5.00194877e-02f,
  1.60600208e-02f, -2.66710557e-02f, 4.05808538e-02f, -8.21501091e-02f, -1.56068597e-02f, -1.50077818e-02f, -6.34560175e-03f, 5.33027649e-02f, -2.22332273e-02f, -1.12054008e-03f,
  5.65637201e-02f, -3.22202407e-02f, -6.91319257e-02f, 1.16508957e-02f, -6.39314204e-02f, 7.04337060e-02f, 2.90692542e-02f, -5.82341924e-02f, -6.25054352e-03f, -8.94008204e-03f,
  3.30657437e-02f, 2.98941624e-03f, 7.21746236e-02f, 8.79762918e-02f, -7.77316317e-02f, 9.91426855e-02f, 5.24440371e-02f, -1.12066373e-01f, -1.19929306e-01f, -7.10777193e-02f,
  7.34859854e-02f, -5.64263165e-02f, 5.63077182e-02f, -6.70875832e-02f, -6.31002197e-03f, 2.38720849e-02f, -7.23871142e-02f, 7.90866837e-03f, -4.31567021e-02f, -7.76403919e-02f,
  1.50248617e-01f, 1.63458571e-01f, -2.59491447e-02f, -4.92051244e-02f, 1.61017366e-02f, 6.67861030e-02f, -2.35628337e-02f, -3.23931612e-02f, -1.79865271e-01f, -1.88559596e-03f,
  7.17300549e-02f, 5.26885949e-02f, 9.08051804e-02f, 1.00396112e-01f, 1.78009138e-01f, -2.76320819e-02f, 1.20027184e-01f, 3.38287875e-02f, -4.29655891e-03f, 8.47361386e-02f,
  -1.59624871e-03f, 1.29688513e-02f, 4.34648655e-02f, -7.85135627e-02f, -1.72085073e-02f, -1.30420655e-01f, 4.10911813e-02f, -1.08788133e-01f, 4.55228314e-02f, -8.56465027e-02f,
  6.54077902e-02f, -6.71757618e-03f, 9.58776474e-02f, 6.92473575e-02f, 3.60746831e-02f, -1.13508441e-01f, -1.37265753e-02f, -7.66690895e-02f, -1.05553240e-01f, -3.67292613e-02f,
  2.83933897e-02f, -8.23369548e-02f, 3.17932479e-02f, -1.22958846e-01f, -3.32932211e-02f, -3.67822312e-02f, -3.29141431e-02f, 1.46932974e-01f, -7.10762246e-03f, 1.94547325e-02f,
  3.50472666e-02f, 8.56326371e-02f, 6.58037215e-02f, -6.40953258e-02f, -1.61030833e-02f, 8.21159780e-02f, -4.60134558e-02f, -1.94645599e-02f, -1.83746796e-02f, -6.99938908e-02f,
  -7.29828849e-02f, -2.14050133e-02f, 7.37519423e-03f, 8.25974271e-02f, 1.42712723e-02f, 9.02025681e-03f, 5.70743755e-02f, 1.02083974e-01f, -1.21799298e-03f, 7.76263028e-02f,
  6.69681951e-02f, 1.65145274e-03f, 3.01675610e-02f, -4.64666337e-02f, -1.06184475e-01f, -3.84363867e-02f, 6.10824414e-02f, -1.12093263e-03f, 6.54994091e-03f, 1.42425264e-03f,
  -5.41947745e-02f, 5.33474889e-03f, 1.97556093e-01f, -1.40305879e-02f, -6.91623911e-02f, -1.80085171e-02f, -2.15142500e-02f, -1.29223675e-01f, 2.46334262e-02f, -4.84785363e-02f,
  2.22794712e-01f, 6.18773736e-02f, 8.00927803e-02f, 1.17082953e-01f, 4.88109738e-02f, -8.46126452e-02f, -7.00916275e-02f, -4.65433933e-02f, -4.29908969e-02f, -5.31652756e-02f,
  4.43731993e-02f, 6.87790290e-02f, 4.85003255e-02f, -2.12567858e-02f, 6.36394694e-02f, -4.19040862e-03f, 1.87942851e-02f, 1.06402196e-01f, 4.88600619e-02f, 1.52881324e-01f,
  6.18714429e-02f, 9.41528752e-02f, -7.87884444e-02f, -6.45297095e-02f, -4.22710516e-02f, 1.35403723e-01f, -9.81921852e-02f, -1.86189450e-02f, -1.27354309e-01f, -3.94480005e-02f,
  -3.42079818e-01f, 1.93825930e-01f, 5.61007261e-02f, -1.58542886e-01f, -1.23519428e-01f, -1.61177114e-01f, -1.64199695e-02f, -1.49496347e-01f, -2.13933572e-01f, 2.11277202e-01f,
  -1.16224788e-01f, 7.24993497e-02f, 9.73457098e-02f, -1.34415969e-01f, -2.85656542e-01f, 1.09067291e-01f, -1.72303915e-01f, 2.14460655e-03f, -9.78073850e-02f, -1.42580807e-01f,
  -1.48248062e-01f, -2.56669462e-01f, -8.15952756e-03f, 4.69583645e-02f, -7.57939219e-02f, 9.56774727e-02f, 4.74188961e-02f, 6.35612085e-02f, 7.03480141e-03f, -7.09668025e-02f,
  5.03444932e-02f, -4.85643707e-02f, -4.65388224e-03f, 2.78687794e-02f, -2.48760520e-03f, 1.20930504e-02f, 7.65364692e-02f, 3.49931940e-02f, -6.30566999e-02f, 1.82654057e-02f,
  3.12410039e-03f, -4.76069786e-02f, -3.72749269e-02f, -1.01107679e-01f, -7.61596262e-02f, -4.83184308e-02f, 1.57270394e-02f, 4.18786146e-02f, 5.06003313e-02f, 3.26321162e-02f,
  6.57519512e-03f, 8.63158032e-02f, -5.13065755e-02f, 4.47567701e-02f, 3.33566479e-02f, -2.55238079e-02f, 9.01714787e-02f, 9.50332135e-02f, 2.58933380e-02f, -3.25775594e-02f,
  5.98351285e-02f, 3.29727978e-02f, -4.29782867e-02f, 3.37885320e-02f, -4.03428124e-03f, -1.87971052e-02f, -5.08642383e-02f, 8.39431658e-02f, 1.52848670e-02f, 1.65164340e-02f,
  1.45260878e-02f, 2.02418142e-03f, 1.92394163e-02f, -7.62835816e-02f, -9.84704792e-02f, -3.19253318e-02f, 4.89472691e-03f, 4.46819933e-03f, 1.26321893e-02f, 5.20790294e-02f,
  6.31105825e-02f, -8.54681805e-02f, 8.08181986e-02f, 4.53628302e-02f, -1.84810013e-02f, -6.64932504e-02f, -7.83980563e-02f, -8.43172520e-03f, 1.87228695e-02f, -6.98354766e-02f,
  -6.41657114e-02f, -3.37839648e-02f, 4.92585786e-02f, -1.97888706e-02f, 6.85557798e-02f, -1.09624630e-03f, -2.90444568e-02f, -3.80816571e-02f, -2.90906262e-02f, -6.37909248e-02f,
  6.01550750e-02f, -1.15264617e-02f, 2.42602043e-02f, -4.49811630e-02f, -4.77717370e-02f, 1.10027239e-01f, 3.73888500e-02f, 5.75561859e-02f, -5.80309816e-02f, -6.80202525e-03f,
  8.96325037e-02f, 2.22952478e-02f, -1.43365348e-02f, 4.19451669e-02f, -8.58954061e-03f, 1.10856608e-01f, 5.35584316e-02f, 3.85772847e-02f, -2.09109057e-02f, -2.48659955e-04f,
  1.03393689e-01f, -7.39807487e-02f, 7.28985295e-02f, 9.16001946e-02f, -2.36983374e-01f, 7.27089867e-02f, 1.50269389e-01f, -2.68513948e-01f, -3.52339953e-01f, 1.26560166e-01f,
  6.80111768e-03f, 2.06939176e-01f, 3.75360399e-02f, 3.42192590e-01f, 1.96668074e-01f, -3.44640878e-03f, 1.67023659e-01f, 1.90130919e-01f, -1.97659805e-01f, 6.19055629e-02f,
  -8.24585110e-02f, 2.29937851e-01f, 1.55559093e-01f, 5.72297117e-03f, 1.03713222e-01f, -9.48431790e-02f, 1.04710989e-01f, -6.38346449e-02f, 3.46179634e-01f, 6.61040619e-02f,
  1.37363309e-02f, -1.05587848e-01f, -1.67410485e-02f, 5.90927638e-02f, -2.36830190e-02f, 2.86430623e-02f, 7.83392638e-02f, 1.06355079e-01f, -6.78693131e-02f, -2.18948461e-02f,
  1.55488551e-01f, 2.05741096e-02f, 2.21695062e-02f, -1.58157796e-02f, -1.85085014e-02f, -2.70700436e-02f, -7.89532363e-02f, -1.03721365e-01f, -2.03007031e-02f, 3.62341031e-02f,
  -5.92918620e-02f, 1.53270727e-02f, 6.81287646e-02f, 4.33645770e-02f, -9.70886846e-04f, -5.41509353e-02f, -2.89684255e-02f, 2.53830031e-02f, 4.91959304e-02f, -4.97316048e-02f,
  -2.58751605e-02f, -3.42764221e-02f, 1.11800190e-02f, 5.77310100e-02f, -2.35461034e-02f, -8.90299231e-02f, -2.00344212e-02f, -3.96821313e-02f, -3.96137275e-02f, 7.09657520e-02f,
  -2.29539908e-02f, -8.16797372e-03f, -5.38281016e-02f, -8.04451182e-02f, 1.02824252e-02f, -4.30565290e-02f, -1.09020546e-02f, 2.88635176e-02f, 3.71553376e-02f, -7.25252181e-03f,
  4.68551321e-03f, 2.32673921e-02f, 2.81955954e-02f, 5.36065828e-03f, -4.41060178e-02f, -3.99250574e-02f, -5.75982109e-02f, 1.58123020e-02f, -4.13644500e-02f, 5.21514267e-02f,
  -2.93835457e-02f, -8.46190006e-02f, -8.43912587e-02f, 9.86167639e-02f, -3.23605053e-02f, 1.89189892e-02f, -1.39096752e-02f, -4.16174019e-03f, 4.74300086e-02f, 1.96373165e-02f,
  1.07754864e-01f, -5.65460045e-03f, 3.30008231e-02f, -2.16181502e-02f, -4.42884862e-02f, -7.56476447e-02f, 7.55184516e-02f, -5.11418842e-02f, -2.43552569e-02f, -7.53747299e-02f,
  7.64763132e-02f, 1.75889805e-02f, 5.93225621e-02f, -5.95455728e-02f, 2.53058365e-03f, 4.85092029e-02f, -8.95530544e-03f, 8.60479102e-02f, -3.29925865e-02f, -1.96605474e-02f,
  4.74439889e-01f, -4.11008954e-01f, -1.17926411e-01f, 1.02696262e-01f, 2.11616293e-01f, -1.51092529e-01f, -8.16368088e-02f, -1.09575137e-01f, -1.77467212e-01f, -2.21126035e-01f,
  5.34640178e-02f, -6.86377799e-03f, -4.08609882e-02f, -3.80794071e-02f, 1.17253691e-01f, -2.66051561e-01f, 1.12426765e-01f, 6.25439659e-02f, -4.21935767e-02f, 1.84959859e-01f,
  8.14596638e-02f, -5.34573644e-02f, -1.36022354e-02f, 7.15621607e-03f, 1.02342032e-01f, 6.41045868e-02f, 2.57100433e-01f, 1.98874529e-03f, 1.43517032e-01f, -6.33222163e-02f,
  -5.00740930e-02f, -6.46949932e-02f, -1.01422453e-02f, -5.84605299e-02f, 3.09595373e-04f, -7.51674548e-03f, -9.07207727e-02f, 2.56868210e-02f, 1.11969680e-01f, -8.13153982e-02f,
  -4.35589477e-02f, 1.81219224e-02f, 1.08146239e-02f, 4.29489883e-03f, 9.78914648e-02f, -1.10610966e-02f, 3.03207673e-02f, -1.20938933e-02f, -6.13706522e-02f, -3.76619175e-02f,
  3.25201638e-02f, 2.40107179e-02f, -5.88744320e-02f, -4.21241149e-02f, 9.13537070e-02f, 2.69811265e-02f, -8.45113071e-04f, 1.31972134e-01f, -1.05784833e-01f, -1.68485120e-02f,
  3.67609337e-02f, -3.69495414e-02f, -3.19140665e-02f, -7.55478516e-02f, 5.55181503e-02f, -1.15679115e-01f, -3.58882919e-02f, 7.78453285e-03f, 3.75343077e-02f, 3.13022025e-02f,
  8.36089328e-02f, 4.36055772e-02f, -7.79213309e-02f, 5.21367975e-02f, 6.20166957e-02f, -3.98116857e-02f, -7.14905635e-02f, -6.42706826e-02f, 8.81111547e-02f, -3.70952375e-02f,
  3.73507173e-05f, -3.38178463e-02f, 7.32211471e-02f, 4.43243943e-02f, -9.56899673e-02f, 1.35921836e-01f, 1.59159247e-02f, -1.02905415e-01f, 1.36747602e-02f, 7.58444667e-02f,
  -2.98754536e-02f, -1.10250033e-01f, -6.69757184e-03f, -2.79871952e-02f, -9.18315575e-02f, 7.29753599e-02f, -5.95160834e-02f, -3.36516388e-02f, 1.34768132e-02f, -5.79852536e-02f,
  4.46399264e-02f, 3.26144658e-02f, -6.31218851e-02f, 6.57554492e-02f, 4.80913483e-02f, -3.53257805e-02f, 4.24642377e-02f, 1.73436683e-02f, -2.58282702e-02f, -2.37568840e-02f,
  5.28420992e-02f, 8.16436261e-02f, -9.50867534e-02f, 1.23071466e-02f, 5.99092878e-02f, 2.19618473e-02f, 1.49703175e-01f, 8.68641585e-02f, -1.14719175e-01f, -8.19337815e-02f,
  -4.24868882e-01f, 1.80522174e-01f, -1.38797343e-01f, -6.20390736e-02f, -1.48665518e-01f, -2.01986298e-01f, -1.43523842e-01f, -1.59278810e-01f, -1.01744510e-01f, 5.93934357e-02f,
  2.16272064e-02f, -7.11899325e-02f, 5.50125688e-02f, 1.20095767e-01f, -5.17680272e-02f, 1.68414578e-01f, -7.56570604e-03f, 2.27984581e-02f, 1.38172179e-01f, -7.06917048e-02f,
  -9.02323797e-02f, 1.47474617e-01f, -2.62578577e-03f, 8.67351368e-02f, -1.07535601e-01f, -7.14043230e-02f, -5.82439192e-02f, 9.47090834e-02f, 8.29092711e-02f, 1.66727044e-02f,
  -6.82314858e-03f, -2.84202367e-01f, -9.01721790e-02f, -7.85267502e-02f, -1.32374112e-02f, -9.06016752e-02f, -1.57404199e-01f, -1.00556677e-02f, 6.70821220e-02f, -2.97090560e-02f,
  -2.83194855e-02f, -6.72979951e-02f, -7.47944489e-02f, 1.06339149e-01f, -2.25371253e-02f, 3.19536291e-02f, 7.38505274e-02f, 4.03192006e-02f, -2.40112506e-02f, -3.89577486e-02f,
  6.53791055e-02f, 5.29711060e-02f, 4.18673875e-03f, 4.27356362e-02f, -6.12351624e-03f, 6.06526397e-02f, 3.86423022e-02f, -5.67725524e-02f, -3.55774052e-02f, -1.26889482e-01f,
  -1.44731486e-03f, 3.67603414e-02f, 1.07167836e-03f, 5.73519766e-02f, 1.22239791e-01f, -2.46436354e-02f, -1.38678355e-03f, 1.96054410e-02f, -6.63394807e-03f, 4.10273820e-02f,
  3.80261578e-02f, -1.59227829e-02f, -3.90081406e-02f, 3.29265259e-02f, -6.33747205e-02f, -1.00826360e-01f, 1.07637011e-01f, -3.99131188e-03f, 1.63068883e-02f, 2.93696788e-03f,
  1.96052473e-02f, -7.10173845e-02f, -9.02345777e-02f, -8.53266120e-02f, -7.17677027e-02f, 1.33050859e-01f, -2.65892744e-02f, -5.39333560e-02f, -6.91429973e-02f, 1.75750535e-02f,
  -1.25455901e-01f, -2.50773996e-01f, 3.92291658e-02f, -1.20988108e-01f, 4.06492986e-02f, -7.67776594e-02f, 1.48820281e-02f, 3.02064922e-02f, -1.30236819e-02f, -1.28690496e-01f,
  8.05908523e-04f, -5.12459986e-02f, 7.31461421e-02f, -2.15781853e-03f, 9.63361487e-02f, -7.65893376e-03f, 4.24818359e-02f, 1.75965242e-02f, -8.45663399e-02f, -2.04335116e-02f,
  -4.21834700e-02f, 6.11710213e-02f, 1.38220340e-01f, -2.83109844e-02f, 6.35823086e-02f, -6.95364252e-02f, -1.20599128e-04f, 9.01749134e-02f, -4.03254926e-02f, 7.16095185e-03f,
  -2.27171406e-01f, 2.37098351e-01f, 1.03604473e-01f, 1.45698085e-01f, -2.56387025e-01f, -3.24368775e-01f, -7.51069784e-02f, -1.39307275e-01f, -5.10856137e-02f, 2.15224043e-01f,
  -1.31146191e-02f, 3.26601982e-01f, 5.23780100e-02f, 1.92980424e-01f, -2.84641296e-01f, 1.02781206e-01f, 1.04355533e-02f, 1.67941034e-01f, -2.54229959e-02f, -4.57582138e-02f,
  -1.00510791e-01f, -2.15442553e-01f, 9.83742848e-02f, 2.31945012e-02f, 1.52757429e-02f, 1.39896646e-01f, 5.16846916e-03f, 1.15103982e-01f, 6.16314299e-02f, 2.10395101e-02f,
  -1.51693821e-01f, 2.94928420e-02f, 2.05014851e-02f, -1.30042071e-02f, -1.10607378e-01f, 3.18956897e-02f, 5.54161370e-02f, 2.97437403e-02f, 2.31771264e-02f, -5.40210791e-02f,
  1.97707731e-02f, -6.64714128e-02f, -4.85543422e-02f, 2.08618529e-02f, -4.03631963e-02f, -4.99778576e-02f, -2.89179161e-02f, -7.01989979e-02f, 3.26721333e-02f, 3.79470848e-02f,
  1.92068517e-02f, -9.86280665e-02f, -1.01478025e-01f, 4.16510291e-02f, -1.96264312e-02f, 3.91722955e-02f, 8.95722285e-02f, -3.83437262e-03f, -4.19505462e-02f, 3.52169853e-03f,
  -7.20990077e-02f, 3.87293398e-02f, 2.65260637e-02f, -9.60681122e-03f, -1.66758224e-02f, -9.43937525e-02f, 1.05232298e-01f, -4.66087647e-03f, -1.76398549e-03f, -2.40283925e-03f,
  -1.24369279e-01f, 1.35832772e-01f, 8.75750706e-02f, 4.83596399e-02f, 6.33721352e-02f, 1.06614955e-01f, -1.06844725e-03f, -1.06218755e-02f, 2.58232225e-02f, 8.37362856e-02f,
  7.71392286e-02f, -2.75584366e-02f, -7.44101256e-02f, 1.76054593e-02f, 1.50249188e-03f, -7.96268582e-02f, 8.26996658e-03f, 4.18351628e-02f, 7.45799094e-02f, -1.25532359e-01f,
  -6.26690313e-02f, 7.44732022e-02f, -3.70527767e-02f, -5.43921925e-02f, 5.71829155e-02f, 3.04582696e-02f, 4.88014072e-02f, 6.35810345e-02f, -2.68589742e-02f, -6.84671476e-02f,
  -3.62934694e-02f, -2.31792070e-02f, -1.84071630e-01f, 2.80745551e-02f, -9.54416487e-03f, -9.85532030e-02f, 2.05565505e-02f, -5.69837876e-02f, -3.35759595e-02f, 1.75537821e-02f,
  -5.28361686e-02f, -1.51879162e-01f, -1.08273014e-01f, -5.75025007e-02f, -2.59147417e-02f, -1.77061558e-03f, 1.54416025e-01f, 5.59972823e-02f, -6.87351301e-02f, 7.60437362e-03f,
  3.46306264e-01f, -6.96619153e-02f, 1.31916851e-01f, 1.51977777e-01f, 4.26862277e-02f, 1.25657236e-02f, 6.72946200e-02f, -1.82803627e-02f, 1.48801506e-01f, -2.15480193e-01f,
  3.56891416e-02f, 1.06485941e-01f, -1.97623372e-02f, 1.28753245e-01f, 3.70189428e-01f, -7.01473877e-02f, 1.78189486e-01f, -7.67216610e-04f, -4.73293709e-03f, 5.71071506e-02f,
  8.45110789e-02f, -1.00915069e-02f, 1.86364681e-01f, -7.85049200e-02f, 1.63924828e-01f, 6.26178533e-02f, -4.08877945e-03f, 5.02827428e-02f, 3.78691480e-02f, 1.29641309e-01f,
  6.26613051e-02f, -4.90394980e-02f, -1.68143585e-02f, -4.58822325e-02f, 4.64081801e-02f, -4.11450900e-02f, -3.89016233e-02f, 7.55593404e-02f, 7.01207593e-02f, -9.99786258e-02f,
  -4.08951305e-02f, 1.21388407e-02f, -1.92858931e-02f, 5.05213775e-02f, 1.83875337e-02f, -3.64177674e-02f, -2.09410191e-02f, -7.71453530e-02f, -3.11718434e-02f, 1.25918959e-04f,
  -5.44319395e-03f, -7.05136955e-02f, -4.51528169e-02f, -6.76927045e-02f, 7.20765889e-02f, -7.93591291e-02f, 2.58227792e-02f, -4.85800058e-02f, -8.69843811e-02f, -4.12479565e-02f,
  -2.29465459e-02f, -4.87921610e-02f, -4.64869589e-02f, -2.45592128e-02f, 9.85905901e-02f, -6.50854930e-02f, -5.45921130e-03f, -1.78159531e-02f, 5.85877486e-02f, 5.32482900e-02f,
  -5.42347170e-02f, 6.79892004e-02f, 3.26798037e-02f, -3.67595181e-02f, 1.57461688e-03f, -9.20540020e-02f, -5.73240854e-02f, -1.70033947e-02f, 1.79634355e-02f, -6.53792992e-02f,
  -1.89268924e-02f, -2.84465309e-03f, 1.53275076e-02f, -3.62811647e-02f, -5.26066758e-02f, 1.18927304e-02f, -2.41079107e-02f, -2.79516354e-02f, 6.72905287e-03f, 6.57907575e-02f,
  4.88298386e-03f, 1.80428792e-02f, -3.42431813e-02f, 1.18507992e-03f, -5.79097643e-02f, 5.57450056e-02f, -1.99611168e-02f, 6.29538745e-02f, 4.01320718e-02f, -2.79813027e-03f,
  -4.88605499e-02f, 5.66130653e-02f, -2.30782144e-02f, -1.21768089e-02f, -3.84856155e-03f, -1.07748896e-01f, 2.76084580e-02f, -6.93872869e-02f, 2.90920511e-02f, -5.56127876e-02f,
  -5.19427396e-02f, -6.08771630e-02f, -9.30136591e-02f, 2.00164821e-02f, -3.08689196e-04f, 3.60897370e-02f, 1.08169459e-01f, -4.65001874e-02f, -1.08312666e-02f, -7.54771978e-02f,
  2.52127230e-01f, -3.67586821e-01f, -2.28731960e-01f, 2.21972503e-02f, 2.07481518e-01f, -4.27778997e-02f, -1.02891892e-01f, -7.52004515e-03f, 2.00162023e-01f, -1.50757387e-01f,
  -7.44642690e-02f, -1.84117973e-01f, -1.73722923e-01f, -1.76339984e-01f, 1.28330559e-01f, -1.09154977e-01f, -2.25146096e-02f, -6.71379119e-02f, -7.08388863e-04f, -7.66771287e-02f,
  3.19121554e-02f, 3.62298973e-02f, -1.74254939e-01f, -6.22663833e-03f, 1.98992267e-02f, -7.39387274e-02f, 3.30038108e-02f, -4.64115292e-02f, 1.26290601e-02f, 9.85839963e-03f,
  6.38047978e-03f, -4.62527014e-02f, 8.06046091e-03f, 1.58180701e-04f, -4.97692041e-02f, -2.80105043e-02f, -7.61121362e-02f, -6.61768094e-02f, 7.50394836e-02f, 1.31252101e-02f,
  -4.88929264e-02f, -1.88497659e-02f, -6.46291301e-03f, 1.06197096e-01f, 1.80077463e-01f, 1.64800175e-02f, 4.26570177e-02f, 1.31204545e-01f, 2.58031171e-02f, -1.15405262e-01f,
  -3.40576991e-02f, -7.73207704e-03f, -1.24838809e-02f, -3.02432589e-02f, -3.83034758e-02f, 1.99873988e-02f, 1.08973775e-03f, -8.84941034e-03f, -2.55382806e-02f, 1.11914268e-02f,
  -2.33230293e-02f, -1.38714723e-02f, -2.56786048e-02f, -2.92374436e-02f, 3.57126817e-02f, -3.25745866e-02f, 2.61815805e-02f, -7.42562786e-02f, -7.14974329e-02f, 5.08736596e-02f,
  4.80788238e-02f, -2.94575430e-02f, 3.32867680e-03f, 6.95209159e-03f, 1.07925953e-02f, -4.54173237e-02f, 1.14935590e-02f, -4.20018546e-02f, -1.16947060e-02f, -3.40735056e-02f,
  -6.25928938e-02f, 1.31104859e-02f, -1.69268027e-02f, -3.37225981e-02f, 4.62866202e-02f, 5.10874987e-02f, 6.77208975e-02f, 5.27865905e-03f, -3.58726867e-02f, -2.91229989e-02f,
  -4.22129780e-02f, -2.15457261e-01f, -7.46703967e-02f, -3.58236656e-02f, -6.95604831e-02f, 4.04216759e-02f, -4.76074517e-02f, -8.26248080e-02f, -4.51486781e-02f, -6.18920773e-02f,
  -4.22943011e-02f, 3.91712710e-02f, 7.41386786e-02f, -1.83161367e-02f, 5.53899519e-02f, -5.79498373e-02f, -6.23201765e-03f, 9.57023203e-02f, 7.40656257e-02f, -6.09096251e-02f,
  4.76726964e-02f, 4.27618511e-02f, -1.70124080e-02f, 5.43962680e-02f, -2.67301593e-02f, 2.77101286e-02f, 5.17775211e-03f, -1.46485148e-02f, -7.82827437e-02f, 9.49963275e-03f,
  2.64106482e-01f, 3.02239619e-02f, -4.94171493e-02f, 1.85632914e-01f, 9.14704055e-02f, -1.84628546e-01f, -1.73321560e-01f, 8.02939385e-02f, 1.07328139e-01f, -7.13920817e-02f,
  -9.75628197e-02f, 1.03511430e-01f, -3.09288621e-01f, 6.92370012e-02f, 9.51393545e-02f, -2.72170246e-01f, 8.46832469e-02f, 2.63962820e-02f, -1.88238844e-02f, 9.16082412e-02f,
  1.91177785e-01f, 2.29157671e-01f, 5.69410697e-02f, 1.60900623e-01f, 1.05540998e-01f, 6.96563050e-02f, 3.02714884e-01f, -1.66765019e-01f, 1.75367787e-01f, 1.52033120e-02f,
  9.95665044e-02f, 2.92298272e-02f, -1.81122869e-03f, -4.21727970e-02f, 8.83978903e-02f, -7.70750269e-02f, 1.39638921e-02f, -1.44985422e-01f, -8.55682492e-02f, -1.63901914e-02f,
  -8.62860233e-02f, 2.47980934e-02f, 9.80627611e-02f, -1.43019333e-01f, -8.48826766e-03f, 3.05646025e-02f, -4.71504517e-02f, 8.24322253e-02f, -1.20617906e-02f, 7.30103208e-03f,
  -3.05267479e-02f, -1.53786875e-02f, 1.30497739e-01f, -2.62804870e-02f, -4.92003597e-02f, -5.10097854e-03f, 6.18192367e-02f, -1.98592860e-02f, 2.09548557e-03f, 1.16015770e-01f,
  -4.39703576e-02f, -3.60071622e-02f, -2.42005996e-02f, -2.52645127e-02f, -3.22878622e-02f, 1.33581072e-01f, 3.73940542e-02f, 5.53216599e-02f, 4.08382565e-02f, 4.86339107e-02f,
  3.35590541e-02f, -2.29430534e-02f, 6.40018582e-02f, -6.11462630e-02f, 7.46453628e-02f, 5.05171232e-02f, 2.34708842e-02f, 7.52398465e-03f, 3.66817378e-02f, 5.30191176e-02f,
  -4.19510752e-02f, -3.26319635e-02f, 8.25967416e-02f, 1.99874490e-03f, -1.76375993e-02f, -9.26192552e-02f, 4.77370732e-02f, 2.06067096e-02f, -3.29118893e-02f, -1.14241047e-02f,
  1.73045650e-01f, 3.02163988e-01f, -3.68295014e-02f, 3.50043550e-02f, 3.52948867e-02f, -4.93933000e-02f, -8.11887160e-02f, -1.18003651e-01f, -3.69467847e-02f, -1.75670849e-03f,
  -1.18472995e-02f, 2.55076010e-02f, 2.10630391e-02f, 6.78378530e-03f, 2.68044565e-02f, 1.60893872e-01f, 6.64234534e-02f, -8.09543766e-03f, 9.98203009e-02f, 1.07977323e-01f,
  8.57309923e-02f, -1.11898087e-01f, -3.42597030e-02f, 7.24296868e-02f, -3.00052576e-02f, -4.20493912e-03f, 3.37595791e-02f, -6.19604662e-02f, -7.91156963e-02f, 7.05209672e-02f,
  -2.02837765e-01f, 6.04127832e-02f, -8.19671303e-02f, 8.97752047e-02f, 4.94270399e-02f, 3.17817181e-01f, 1.32416382e-01f, 4.15956154e-02f, 9.91137996e-02f, 6.15934096e-02f,
  2.50418991e-01f, 1.08764451e-02f, 1.61269799e-01f, 3.34064662e-01f, 2.15191066e-01f, 1.92937687e-01f, 2.20105797e-01f, 1.05261624e-01f, -2.81769522e-02f, -1.76356849e-03f,
  8.28084350e-02f, 2.44621471e-01f, 5.41882217e-02f, -1.40883327e-01f, 5.93560897e-02f, -2.27821499e-01f, -1.09265648e-01f, -1.15802057e-01f, 1.66335795e-02f, 1.22483084e-02f,
  3.09326109e-02f, -2.84460615e-02f, -9.27944630e-02f, -2.87058000e-02f, -3.25673223e-02f, -6.74707294e-02f, -8.60739797e-02f, -1.34706246e-02f, 4.55965623e-02f, 1.56904627e-02f,
  1.38575107e-01f, 2.93567479e-02f, -5.39487712e-02f, 9.73578393e-02f, 4.91754934e-02f, 2.32016835e-02f, 1.40247643e-01f, 5.54918908e-02f, 9.32002589e-02f, -1.76264923e-02f,
  7.33906552e-02f, 3.41536999e-02f, 5.06056584e-02f, 3.55532095e-02f, -5.15085869e-02f, 1.06885776e-01f, -9.72121656e-02f, 9.53410938e-03f, -2.93845106e-02f, 4.40792143e-02f,
  4.77867573e-02f, 1.03993649e-02f, -9.62821487e-03f, 5.11208409e-03f, 3.26592326e-02f, -6.62633926e-02f, 7.53986239e-02f, -3.74934226e-02f, -8.44355747e-02f, 1.13721229e-01f,
  1.72961764e-02f, -4.73029502e-02f, 2.72399210e-03f, -5.97246923e-02f, -9.36339349e-02f, -1.53102903e-02f, -1.28933312e-02f, -1.73654165e-02f, 8.74685645e-02f, -7.90346190e-02f,
  2.02835780e-02f, 9.98719782e-03f, 4.81158048e-02f, -5.37201874e-02f, 1.36062518e-01f, 3.01294383e-02f, 7.24765882e-02f, 3.76633257e-02f, -1.50111504e-03f, -5.35485186e-02f,
  -3.99247510e-03f, -1.19851761e-01f, -7.42421150e-02f, 5.73547743e-02f, -5.66240139e-02f, 5.51821180e-02f, -1.52612338e-02f, -5.20879179e-02f, -4.37036678e-02f, -1.91735271e-02f,
  3.44675919e-03f, -4.73471098e-02f, -3.35372388e-02f, 4.33858335e-02f, -1.65603310e-02f, 1.06460694e-02f, 6.05033785e-02f, -3.80262993e-02f, 6.85770139e-02f, 9.72064398e-03f,
  1.90312490e-02f, 1.00244656e-02f, 5.40280864e-02f, -6.77907392e-02f, -8.24541152e-02f, 5.09953164e-02f, -8.85719582e-02f, -5.43627813e-02f, -5.34361564e-02f, -4.94943149e-02f,
  -3.27369303e-01f, -1.76106110e-01f, 1.51430398e-01f, -1.24337964e-01f, -2.05664620e-01f, -4.84943911e-02f, -1.00191776e-03f, -2.07430974e-01f, -1.24737971e-01f, -9.23623517e-02f,
  -1.05699457e-01f, 1.14486646e-02f, 1.62468910e-01f, 4.65811342e-02f, 3.87891144e-01f, 3.58505666e-01f, 1.08952872e-01f, -1.65448170e-02f, 8.13371018e-02f, -4.82104681e-02f,
  -5.51565513e-02f, -4.08662930e-02f, 2.68061310e-01f, -1.15915135e-01f, -9.87626240e-02f, -1.89575210e-01f, 6.95439130e-02f, -2.78594010e-02f, 5.68714179e-02f, -5.01290001e-02f,
  -9.28480178e-02f, -3.00531834e-01f, -1.78337898e-02f, 2.89669633e-02f, -1.07111474e-02f, -1.91645734e-02f, -6.94577917e-02f, 9.30282753e-03f, 1.23167574e-01f, 2.33520512e-02f,
  5.16364770e-03f, -3.11065721e-03f, -4.87651341e-02f, 1.46698564e-01f, -3.19461226e-02f, -6.99808449e-03f, 6.68555126e-02f, -1.09388856e-02f, -7.54169524e-02f, -5.46080619e-02f,
  -7.97377061e-03f, 2.88574193e-02f, 9.59525332e-02f, 8.73022079e-02f, 7.17098713e-02f, -9.30923074e-02f, 1.06488988e-01f, -4.04692292e-02f, -3.48857269e-02f, -8.22172463e-02f,
  -2.67060082e-02f, 2.05198284e-02f, 1.43878926e-02f, -2.46394444e-02f, 7.01834727e-03f, -1.09028161e-01f, 7.78702274e-02f, -9.40189436e-02f, -2.01518508e-03f, -1.24960780e-01f,
  -3.70168053e-02f, 1.57155357e-02f, -9.15988013e-02f, 1.97304878e-02f, 1.80024803e-02f, -1.62656114e-01f, -1.53664744e-03f, 3.41275427e-03f, -7.56512396e-03f, -7.68078566e-02f,
  -2.59830039e-02f, -8.55741724e-02f, 2.09697224e-02f, -3.03666927e-02f, 3.34780402e-02f, 6.81148544e-02f, 5.62597997e-03f, 3.26400809e-02f, -8.41283351e-02f, 4.86313179e-02f,
  -6.59348071e-02f, -1.24122612e-01f, -2.66618654e-02f, -3.94760855e-02f, 2.36817189e-02f, 7.58482656e-03f, 6.48252480e-03f, -1.03652224e-01f, 6.57696426e-02f, -1.01215057e-02f,
  -1.01202607e-01f, 3.72716822e-02f, 1.12627916e-01f, -1.93928778e-02f, 6.55926317e-02f, 1.79644395e-03f, 8.36696401e-02f, 8.70343745e-02f, -1.05432488e-01f, -9.03054997e-02f,
  -2.44196933e-02f, 7.87056237e-03f, 1.03748264e-02f, -1.56633072e-02f, 1.67781021e-02f, 1.31164929e-02f, -5.23191988e-02f, -6.76681697e-02f, -3.11306119e-02f, 7.88615122e-02f,
  1.73965782e-01f, -1.63956538e-01f, -2.26551257e-02f, 3.68975163e-01f, -1.41698450e-01f, 1.28231004e-01f, 9.68802720e-02f, -8.60718638e-02f, 9.07202363e-02f, -2.11915839e-03f,
  9.17927697e-02f, -6.45886883e-02f, -5.77601790e-02f, 3.23074251e-01f, 2.92320192e-01f, 1.64180622e-01f, 4.05253291e-01f, 1.66357651e-01f, 1.96034983e-02f, 8.68232995e-02f,
  1.09723732e-01f, 1.46435410e-01f, -2.99709514e-02f, -9.05974582e-02f, -1.92918807e-01f, -1.85525492e-01f, 5.47259189e-02f, -1.84427947e-01f, 1.08751088e-01f, -3.17237787e-02f,
  -5.46280071e-02f, 5.13986545e-03f, -1.04041398e-01f, 5.01186075e-03f, 7.24822283e-02f, 2.17440771e-03f, -1.33719258e-02f, -4.00240235e-02f, 4.57500555e-02f, -8.09923187e-03f,
  9.34004597e-03f, 1.84425786e-02f, 2.68384330e-02f, -4.40440178e-02f, 2.19158106e-03f, 2.81537548e-02f, -3.63827422e-02f, -4.13824152e-03f, 2.09241100e-02f, -4.77832882e-03f,
  -2.44668480e-02f, 4.13893983e-02f, 1.07040167e-01f, 1.32575005e-01f, 5.28883114e-02f, -3.43132056e-02f, 6.03188165e-02f, -1.90730288e-03f, 2.30867583e-02f, 6.03436567e-02f,
  -2.37103691e-03f, 6.23470284e-02f, -2.49959622e-02f, -5.23754247e-02f, 5.75388223e-02f, -4.99550439e-03f, -3.70747820e-02f, -1.15128733e-01f, -6.18444942e-02f, -1.57269128e-02f,
  4.90096845e-02f, -4.85092774e-02f, -6.40224293e-02f, 2.27126218e-02f, 6.72252569e-03f, -4.65007499e-02f, -1.34521527e-02f, -1.65234227e-02f, 7.56638199e-02f, -2.70924214e-02f,
  1.79015324e-02f, -3.64605803e-03f, -1.16563268e-01f, 5.09111844e-02f, 2.17241589e-02f, -2.33297814e-02f, 7.92186800e-03f, 7.04265572e-03f, -4.52445820e-02f, 5.31158373e-02f,
  5.36327995e-02f, 1.44921198e-01f, -6.40416741e-02f, 5.22163557e-03f, -3.55235934e-02f, 4.34618369e-02f, 2.65614782e-02f, -2.80162487e-02f, 6.65735826e-02f, 1.27772018e-01f,
  4.49338853e-02f, 5.77650033e-04f, 6.53958246e-02f, -2.11871066e-03f, -3.30963917e-02f, -3.39685194e-02f, 5.69915734e-02f, -6.12664456e-03f, 9.81162488e-02f, 2.51700915e-02f,
  3.62021476e-02f, 1.02362730e-01f, 3.05641256e-02f, 7.67724821e-03f, 7.99347758e-02f, -1.38807260e-02f, -4.83744293e-02f, 2.12186817e-02f, 1.02717848e-02f, 8.59189108e-02f,
  -1.34446770e-01f, 3.16051066e-01f, 7.82152987e-04f, 1.38758510e-01f, -1.30209953e-01f, -1.90308467e-01f, -1.59898691e-03f, -9.98865291e-02f, 9.42656323e-02f, 3.17435861e-01f,
  3.25340070e-02f, 1.98895901e-01f, 2.14565665e-01f, 7.32274055e-02f, -2.63623416e-01f, 1.43718198e-01f, -2.51451358e-02f, 1.19931407e-01f, 4.61865477e-02f, -3.44544314e-02f,
  -5.05827107e-02f, -4.40065190e-02f, -7.37210512e-02f, -7.27797151e-02f, -2.46605035e-02f, 6.19947985e-02f, 3.84662375e-02f, -2.46062353e-02f, 3.48984599e-02f, -2.21307632e-02f,
  -3.81374359e-02f, 1.28424749e-01f, 5.61854010e-03f, -1.75000448e-02f, -8.24098215e-02f, -6.62859604e-02f, -6.91345632e-02f, -9.14051011e-02f, -6.91310316e-02f, 9.03318226e-02f,
  1.02284886e-01f, 7.51448348e-02f, -1.85229890e-02f, -7.53789861e-03f, 3.63555327e-02f, 6.75786883e-02f, 2.58042086e-02f, 4.49732207e-02f, -7.25863054e-02f, 3.41210105e-02f,
  -1.53681291e-02f, 2.08764523e-02f, 4.73142229e-02f, -7.32303876e-03f, -7.69930109e-02f, 6.03340939e-02f, 6.89933030e-03f, 8.47187042e-02f, 1.04704410e-01f, 3.87879205e-03f,
  7.84365460e-02f, 2.50288732e-02f, -8.45807120e-02f, 1.27569735e-02f, -1.28591331e-02f, -1.56794563e-02f, 6.49441704e-02f, -1.28379487e-03f, 2.40393300e-02f, 2.19050050e-02f,
  1.65611833e-01f, -9.71353147e-03f, 3.64448279e-02f, 4.62158397e-02f, -4.09512445e-02f, -5.62552586e-02f, 3.34376022e-02f, 1.87945608e-02f, 3.45170274e-02f, -6.58409223e-02f,
  -1.24487240e-04f, -3.70372869e-02f, 6.15175515e-02f, 1.83202103e-02f, -2.90258825e-02f, 6.28419667e-02f, 6.81771263e-02f, 1.12979196e-01f, 2.68661864e-02f, 3.66590805e-02f,
  1.31799191e-01f, 1.77646235e-01f, 4.03774157e-02f, 5.48076741e-02f, 5.29159121e-02f, -9.08095166e-02f, -1.37196615e-01f, -9.92885232e-02f, 6.41741231e-02f, 4.56350297e-03f,
  -3.82675268e-02f, 5.91679886e-02f, 1.26135468e-01f, -8.25880542e-02f, 2.88195349e-02f, 6.34926707e-02f, -1.57264213e-03f, 1.14693239e-01f, 2.62368228e-02f, -3.57838161e-02f,
  7.96414316e-02f, 1.52669579e-01f, 8.18592831e-02f, -4.86787409e-02f, 3.92298214e-02f, 6.84395880e-02f, -4.91796657e-02f, 4.62054312e-02f, 1.11362249e-01f, 5.64385019e-02f,
  -1.67680606e-01f, 1.48839250e-01f, -7.72588402e-02f, -9.16130692e-02f, -2.99521208e-01f, -2.08713561e-01f, -8.36270973e-02f, -1.70521066e-01f, -1.95927218e-01f, 2.64474116e-02f,
  -1.03880823e-01f, 1.91187471e-01f, 2.07120344e-01f, 4.37494032e-02f, 1.32169649e-01f, 8.63311067e-02f, 5.85974231e-02f, 1.42772958e-01f, 8.41265246e-02f, -3.78335044e-02f,
  -1.68856993e-01f, -4.75662649e-02f, 4.89036031e-02f, 2.66076047e-02f, -1.64122894e-01f, -1.05479977e-03f, 8.14272091e-03f, 6.14385232e-02f, -5.84283024e-02f, 7.94830471e-02f,
  8.44899043e-02f, 7.39771128e-02f, 3.83367576e-02f, 6.88894913e-02f, -4.17042002e-02f, 8.46171007e-02f, 6.42036572e-02f, -6.85295612e-02f, 1.15886755e-01f, -1.15534790e-01f,
  5.42656779e-02f, 7.10847927e-03f, -8.66929740e-02f, 9.92288440e-02f, -5.40077919e-03f, -6.99291900e-02f, -1.47669882e-01f, -2.34738700e-02f, -7.87775442e-02f, -1.37720898e-01f,
  -1.07666776e-01f, -1.52489822e-02f, 1.52962795e-03f, 3.15108476e-03f, 7.42648765e-02f, -1.61127690e-02f, -8.64919275e-02f, 4.10458744e-02f, -2.50379704e-02f, 6.00660918e-03f,
  -1.25420410e-02f, 3.94510627e-02f, -4.93019372e-02f, 1.52212242e-02f, 1.24424584e-01f, -1.32898353e-02f, 2.46515833e-02f, 5.65699898e-02f, 1.30761946e-02f, 1.12275966e-03f,
  -5.08655496e-02f, 1.35344304e-02f, 1.03987910e-01f, -1.42681133e-02f, 6.05855584e-02f, -1.08921528e-01f, 4.06851694e-02f, -4.72941361e-02f, 5.29699698e-02f, -2.42284685e-02f,
  4.74579521e-02f, 5.48513457e-02f, 1.38091147e-01f, -1.09246127e-01f, 1.31658569e-01f, -2.21150159e-03f, 2.93346271e-02f, -4.74107526e-02f, -9.16892216e-02f, -4.33604419e-02f,
  2.31800482e-01f, 1.60212636e-01f, 8.79799277e-02f, -2.75229048e-02f, 5.55698313e-02f, -4.96584661e-02f, 3.01965494e-02f, -1.53003991e-01f, 1.17481947e-01f, -1.32859662e-01f,
  -4.37044017e-02f, 4.94063497e-02f, 4.20176797e-02f, -1.92471705e-02f, 1.37280524e-01f, -1.82490483e-01f, -4.82948050e-02f, 1.36456817e-01f, -7.76234716e-02f, 6.01862483e-02f,
  2.49921642e-02f, 7.79276788e-02f, 3.59556191e-02f, 1.72603577e-02f, 5.09297699e-02f, -1.39806187e-02f, 5.70329800e-02f, -4.87816557e-02f, -1.02876395e-01f, 1.12626091e-01f,
  -3.20073366e-01f, -4.58294488e-02f, -3.61234128e-01f, -2.25534916e-01f, 1.08901896e-01f, -1.68179348e-02f, -1.63784757e-01f, -1.26837522e-01f, -3.88178110e-01f, 1.08829914e-02f,
  1.59079105e-01f, -1.22276314e-01f, 3.60334516e-02f, 2.02728692e-03f, -9.78043154e-02f, -1.15935683e-01f, -9.73396525e-02f, -9.35070589e-03f, -1.60657652e-02f, -1.01045400e-01f,
  1.24675054e-02f, 2.79480517e-01f, -5.66087700e-02f, 1.41255811e-01f, -1.05478436e-01f, -1.26456529e-01f, 1.04996890e-01f, 3.71207446e-02f, 4.12222408e-02f, 5.56153245e-02f,
  -3.01790088e-02f, 2.93839406e-02f, 8.22355896e-02f, -2.50446983e-02f, -6.29072934e-02f, 9.34032947e-02f, 3.81753338e-03f, 1.04099885e-02f, 4.20095921e-02f, -8.40961263e-02f,
  -1.58470981e-02f, -2.83143111e-02f, -7.11139739e-02f, 7.02229589e-02f, -5.28547242e-02f, -1.31452322e-01f, -5.77664338e-02f, -1.17493875e-01f, -4.26389985e-02f, -5.10361381e-02f,
  -4.62078564e-02f, -3.25830206e-02f, -5.39121078e-03f, -8.72035399e-02f, -8.20231736e-02f, -2.33342703e-02f, -1.24262638e-01f, -6.30712360e-02f, -6.97502717e-02f, -8.89440998e-02f,
  1.51574582e-01f, 1.66786537e-02f, 4.86827269e-03f, -3.28928381e-02f, -2.94671804e-02f, -3.21933739e-02f, -5.01402281e-02f, 6.97394740e-03f, -1.31490946e-01f, 1.15121752e-02f,
  -8.88819434e-03f, -7.82074109e-02f, -3.94346640e-02f, -1.94527972e-02f, -7.56685212e-02f, -2.37093102e-02f, -6.83919387e-03f, -1.24889398e-02f, -2.09584553e-02f, -9.64873731e-02f,
  7.95136318e-02f, 1.45234633e-02f, 2.99399327e-02f, 8.71592108e-03f, 3.14174257e-02f, -3.48044909e-03f, -8.68795812e-02f, -6.85290471e-02f, -4.38103527e-02f, -3.19984481e-02f,
  8.68802667e-02f, -2.80946400e-02f, 6.35915697e-02f, 2.64767613e-02f, -2.47437600e-02f, 1.14826430e-02f, 2.15346050e-02f, 3.62880691e-03f, -4.71166298e-02f, -9.31405425e-02f,
  -2.19392218e-03f, -1.51997969e-01f, 8.54198039e-02f, 5.17802164e-02f, 7.92220021e-07f, -9.82831568e-02f, -1.78768896e-02f, 1.08190300e-02f, -8.88741855e-03f, 8.08788370e-03f,
  2.74523944e-02f, -9.67490077e-02f, -2.16395352e-02f, -2.65293680e-02f, -5.65658249e-02f, 1.01700716e-01f, -9.24825817e-02f, 1.58359949e-02f, 1.71422539e-03f, -4.90857139e-02f,
  -1.32310912e-01f, 3.96405123e-02f, -2.22932950e-01f, -9.27438214e-02f, -1.90112874e-01f, -2.39192322e-01f, -1.27949640e-01f, -1.13192424e-01f, -2.68612921e-01f, 3.17607671e-01f,
  1.38048649e-01f, 2.16426134e-01f, -4.95464616e-02f, 1.59396052e-01f, -3.81963462e-01f, -2.53347307e-01f, -1.69650484e-02f, 1.94689557e-02f, -1.13304034e-01f, 1.95063397e-01f,
  5.50889485e-02f, 2.51562357e-01f, 4.92917886e-03f, 1.13527901e-01f, 9.97791439e-02f, 6.18211478e-02f, 2.00162515e-01f, -1.00695461e-01f, 1.97163403e-01f, -3.79269267e-03f,
  -1.00934185e-01f, 4.35122922e-02f, -1.41524067e-02f, 3.16287391e-02f, -4.36025932e-02f, 6.67370157e-04f, -2.53123435e-04f, -6.24346659e-02f, -1.48691228e-02f, 8.66091773e-02f,
  1.50709316e-01f, 3.03207128e-03f, -3.49418372e-02f, 7.05948472e-02f, -9.57170352e-02f, -1.40622724e-03f, -2.99127605e-02f, 7.30495006e-02f, 3.71421017e-02f, -2.53605284e-02f,
  -3.29542207e-03f, -5.22913150e-02f, 5.64130023e-02f, 6.00168854e-02f, 3.37020904e-02f, 6.28864840e-02f, -5.69516420e-02f, -1.16821304e-01f, 1.12779979e-02f, -5.96833527e-02f,
  2.17020605e-02f, -7.20390975e-02f, 1.22358091e-02f, 5.99685386e-02f, 7.59794097e-03f, -1.43364631e-02f, 1.14895869e-03f, 2.23077536e-02f, -2.58486830e-02f, -5.71510866e-02f,
  7.41717890e-02f, 6.95214570e-02f, -1.52943268e-01f, 4.96804640e-02f, 2.72108857e-02f, 2.05916422e-03f, -1.16372099e-02f, 5.14374785e-02f, 7.01459199e-02f, -4.68019247e-02f,
  -5.88167496e-02f, -6.94697723e-02f, 9.17861685e-02f, 3.88451628e-02f, 4.45344811e-03f, 3.78427878e-02f, 4.80188765e-02f, 3.28765884e-02f, -3.68866399e-02f, 1.47837624e-02f,
  -6.09371476e-02f, 6.10557757e-02f, 4.05345522e-02f, 2.93245986e-02f, -4.74361070e-02f, 8.83705541e-02f, -1.12152159e-01f, 4.69708815e-02f, -1.67255364e-02f, 5.86339086e-02f,
  9.81830359e-02f, 3.30725987e-03f, 5.03709503e-02f, -1.87714975e-02f, -4.00646590e-02f, 1.17828986e-02f, 5.74033260e-02f, 3.00798239e-03f, -2.56304424e-02f, -1.05087005e-04f,
  1.07016347e-01f, 4.70079370e-02f, 5.79611175e-02f, 5.29725216e-02f, -3.38213518e-03f, -1.64091140e-02f, -1.87398791e-02f, -3.83114554e-02f, 2.85532493e-02f, -3.33518125e-02f,
  1.08297216e-02f, -4.52062041e-02f, -2.04537660e-01f, 8.77251700e-02f, -6.42777532e-02f, 2.55530119e-01f, 1.72143012e-01f, -1.87365673e-02f, -1.21398065e-02f, 1.10377632e-01f,
  2.01730803e-01f, -2.15223521e-01f, -6.28952384e-02f, 3.17176223e-01f, 2.82862961e-01f, 2.14042708e-01f, 2.70278692e-01f, 9.52821225e-02f, 6.03413805e-02f, -5.83369918e-02f,
  7.66768456e-02f, 2.77288258e-01f, 1.12346753e-01f, 4.08279672e-02f, 2.50616502e-02f, -1.52561307e-01f, -1.15090005e-01f, -6.32624477e-02f, 1.76434293e-01f, -2.16362830e-02f,
  9.41667259e-02f, 3.14872013e-03f, -4.66497876e-02f, 5.97674400e-02f, 2.91085243e-02f, -9.18359756e-02f, -2.06478424e-02f, -8.51919726e-02f, 3.92214488e-03f, 3.51930596e-02f,
  -1.21802330e-01f, -3.66269201e-02f, -1.16274834e-01f, -6.71876781e-03f, 3.06169502e-02f, 3.22119109e-02f, 6.06931895e-02f, 5.01668341e-02f, 2.35122051e-02f, -8.07154924e-02f,
  -8.52091461e-02f, 5.04734777e-02f, 3.53357708e-03f, 4.82925326e-02f, -2.12423448e-02f, 7.36765936e-02f, 2.87545789e-02f, -9.75248516e-02f, -4.32375222e-02f, 3.48494165e-02f,
  -1.00812085e-01f, -8.81355628e-02f, -4.52231430e-02f, 9.68123972e-02f, 4.27816808e-02f, 8.12621117e-02f, 8.80808458e-02f, 5.81081882e-02f, 7.80670298e-03f, 8.08261856e-02f,
  9.96154323e-02f, -5.15673868e-02f, 3.87431048e-02f, -7.07634762e-02f, 7.74052218e-02f, -9.76956338e-02f, -7.31800823e-03f, 5.93663752e-02f, 3.33038159e-02f, 3.15159857e-02f,
  -1.16682358e-01f, 5.69943711e-02f, -7.62556493e-03f, 1.07773162e-01f, 1.82451550e-02f, -5.82544832e-03f, 1.01258270e-01f, 1.30237443e-02f, -3.16711850e-02f, -9.18725878e-02f,
  7.79227838e-02f, -1.14574261e-01f, 8.25224593e-02f, 6.80283681e-02f, 5.65657578e-02f, -4.30780202e-02f, 1.39703434e-02f, 2.94730105e-02f, 4.94088745e-04f, -1.24265179e-01f,
  -1.01264790e-01f, 4.50284919e-04f, 1.28754735e-01f, -5.27801402e-02f, 1.39281675e-01f, 9.44239423e-02f, -2.17091721e-02f, 2.87662018e-02f, -1.73038003e-04f, -3.61257754e-02f,
  -8.60765949e-02f, 6.94933087e-02f, -4.60860841e-02f, -7.57589191e-02f, 3.17257531e-02f, -2.27731392e-02f, 3.53175178e-02f, -7.57974526e-03f, -3.21610318e-03f, 1.14671951e-02f,
  -2.23618254e-01f, -1.81220144e-01f, -2.38670200e-01f, -2.84272432e-01f, -7.22858235e-02f, 2.67882317e-01f, 1.62771359e-01f, -1.47782236e-01f, -2.18588784e-01f, 1.24402940e-01f,
  1.12868622e-01f, -6.59877211e-02f, 1.49277419e-01f, -5.66425100e-02f, 1.34966373e-01f, 1.40862837e-01f, 9.64224637e-02f, 7.02379346e-02f, -9.75115150e-02f, -1.07677206e-01f,
  6.96061039e-03f, 1.28808141e-01f, -2.46101543e-02f, -1.60048574e-01f, -1.95119187e-01f, -1.66125700e-01f, -5.69235235e-02f, -1.15990743e-01f, -9.58173051e-02f, 1.02670342e-01f,
  -1.20498957e-02f, -9.33732912e-02f, -1.24597371e-01f, -5.28903417e-02f, 1.80454124e-02f, 1.39945239e-01f, 1.03285246e-01f, 8.43360201e-02f, -9.48409666e-04f, 2.52697878e-02f,
  9.86545905e-02f, 1.41375840e-01f, -5.16865104e-02f, 3.33258845e-02f, 1.67923793e-02f, -5.22434600e-02f, -1.04894377e-02f, -7.46726617e-02f, -4.81808186e-02f, 2.18461882e-02f,
  -8.31178203e-02f, -4.29999605e-02f, -8.26263800e-03f, 6.53367266e-02f, 3.47934067e-02f, -1.16428785e-01f, -3.40511277e-02f, 3.27206329e-02f, -3.99070568e-02f, -1.70030780e-02f,
  9.84878391e-02f, 2.71695349e-02f, -8.23367853e-03f, -3.56967337e-02f, -9.01690274e-02f, -3.84075232e-02f, -1.75082423e-02f, 6.28778040e-02f, -6.44091964e-02f, 3.67265493e-02f,
  -2.46710349e-02f, -9.77159292e-02f, -3.44788246e-02f, -3.57078165e-02f, 5.63379517e-03f, -5.59211895e-02f, 6.43831044e-02f, 2.81976592e-02f, 3.41274915e-03f, -1.44258991e-01f,
  1.29257375e-03f, 1.40395597e-01f, -8.49995911e-02f, 2.69389618e-02f, 1.20943664e-02f, -3.92667949e-02f, -7.01378332e-03f, -8.04161374e-03f, -7.61678517e-02f, 2.44537052e-02f,
  1.30193546e-01f, -1.74562149e-02f, 3.09699588e-02f, 7.33520612e-02f, -6.28936589e-02f, 3.69754210e-02f, 3.10655441e-02f, -2.88300961e-03f, 2.99557541e-02f, 1.38004003e-02f,
  7.15820119e-02f, -5.08241095e-02f, 6.26145378e-02f, 4.93181590e-03f, -7.02382177e-02f, -6.43450469e-02f, 1.12195559e-01f, -2.45511625e-02f, 4.75638285e-02f, 1.34608345e-02f,
  2.72458866e-02f, 8.76544043e-02f, 2.87545379e-02f, -5.14910333e-02f, 3.75067331e-02f, 1.33111224e-01f, -3.88835184e-02f, -4.35718745e-02f, -2.48938650e-02f, 7.68576795e-03f,
  4.17931408e-01f, -1.08266138e-02f, 1.52005404e-01f, 1.42907396e-01f, 2.97015999e-02f, -1.23947181e-01f, -4.84130569e-02f, -5.21985069e-02f, 9.52604488e-02f, -2.55162597e-01f,
  -1.56527042e-01f, 2.05484658e-01f, -1.36230126e-01f, -9.99839902e-02f, 3.01863223e-01f, -6.08672164e-02f, -2.22014673e-02f, -1.67007037e-02f, -5.45432279e-03f, 5.68280555e-02f,
  1.05617069e-01f, -1.53921172e-01f, 7.83433765e-02f, -1.40291363e-01f, 6.56823814e-02f, 1.10055812e-01f, 5.53174689e-02f, -5.02985679e-02f, -2.28428934e-02f, -1.71805546e-02f,
  1.43772913e-02f, 2.65707020e-02f, 2.79089827e-02f, -5.74104004e-02f, -1.81970540e-02f, 5.04582338e-02f, 2.98155355e-03f, 2.08066474e-03f, -2.00110441e-03f, -5.96631132e-03f,
  1.22949846e-01f, 2.64424719e-02f, -2.03394778e-02f, 2.71666795e-02f, 2.45248005e-02f, 2.53195106e-03f, 7.86218643e-02f, 8.77338462e-03f, -6.06232584e-02f, 1.19410612e-01f,
  5.50805964e-02f, 3.63918580e-02f, -3.90222557e-02f, -3.52320746e-02f, -1.58840846e-02f, 2.44091861e-02f, -1.93426795e-02f, 9.52422395e-02f, 1.87954977e-02f, 6.70105293e-02f,
  2.15536430e-02f, 2.02977899e-02f, -7.98528194e-02f, -6.59546480e-02f, -7.11318180e-02f, -4.13139574e-02f, 2.73080133e-02f, -5.79660498e-02f, -4.29849960e-02f, -5.85836545e-02f,
  -4.34774049e-02f, 3.02564241e-02f, -1.93428397e-02f, -1.90296639e-02f, 6.83978125e-02f, 9.85787734e-02f, 8.12468976e-02f, -2.97891852e-02f, -3.93899791e-02f, 2.00332515e-02f,
  9.11278743e-03f, 7.98636228e-02f, 1.05619123e-02f, 4.04880047e-02f, -2.62331143e-02f, -9.25701633e-02f, -3.56884324e-03f, 3.56970467e-02f, 5.03543057e-02f, 5.64854443e-02f,
  -1.74653023e-01f, -1.52135178e-01f, 4.35253931e-03f, -7.91375414e-02f, -3.76877785e-02f, 2.76351571e-02f, -3.07050347e-02f, -3.16107385e-02f, -1.37500558e-03f, 2.44344883e-02f,
  5.49668027e-03f, -1.47207398e-02f, -9.71301571e-02f, 5.76626183e-03f, -3.33626084e-02f, -3.24107409e-02f, -4.39093523e-02f, -3.01584546e-02f, 2.86136474e-02f, 4.94224690e-02f,
  3.71213183e-02f, -1.18461952e-01f, 2.27297284e-03f, 4.31637140e-03f, -2.36998708e-03f, 6.89420030e-02f, -4.08988073e-02f, -2.10036784e-02f, 1.81195289e-02f, -3.70707293e-03f,
  -8.27242881e-02f, 2.21791208e-01f, 5.63086532e-02f, -1.11750074e-01f, 5.44777662e-02f, -1.21478759e-01f, -1.96882486e-01f, 5.59788309e-02f, -1.29620165e-01f, 7.04521388e-02f,
  -2.08057955e-01f, 4.68901321e-02f, -1.40402079e-01f, -1.41926721e-01f, -3.34352106e-01f, -1.29770920e-01f, -9.06415954e-02f, -1.31163463e-01f, -8.70558526e-03f, 4.96551320e-02f,
  -1.05275281e-01f, -1.13535397e-01f, 3.18152234e-02f, 8.23562592e-02f, 1.28046840e-01f, 1.75325781e-01f, 1.14904037e-02f, 1.00174695e-01f, 5.62161654e-02f, 4.82819490e-02f,
  -6.54119179e-02f, 6.96320310e-02f, 2.47323122e-02f, -1.69437360e-02f, 1.80492587e-02f, 6.43283650e-02f, -2.99054962e-02f, -5.27164601e-02f, 4.58746366e-02f, 9.03935134e-02f,
  -5.77382976e-03f, 3.04608606e-02f, -4.79464717e-02f, 9.84817557e-03f, 6.49791807e-02f, 4.92686927e-02f, 5.55284880e-02f, 3.38878706e-02f, 5.25234938e-02f, 4.05547284e-02f,
  -1.91273428e-02f, -3.17113958e-02f, 4.95316833e-02f, 1.12530170e-02f, 1.48293944e-02f, -5.42902481e-03f, -4.05619889e-02f, 4.84029017e-02f, 1.75029319e-02f, -6.73466995e-02f,
  2.12769974e-02f, -9.51040071e-03f, -3.74334641e-02f, -6.50271773e-02f, -3.05920132e-02f, -9.52037424e-02f, -5.63748740e-02f, -2.08111946e-02f, 8.81662369e-02f, -5.39151998e-03f,
  2.58506481e-02f, -2.73560882e-02f, -9.48878645e-04f, 2.21157470e-03f, -8.98247361e-02f, 3.81266698e-02f, 3.55266258e-02f, 7.33161420e-02f, 1.46591179e-02f, 1.76170450e-02f,
  1.45621262e-02f, -1.35042652e-01f, -3.56622762e-03f, 3.74489576e-02f, -1.17042430e-01f, -7.89374206e-03f, 3.07250135e-02f, 6.82426542e-02f, -2.73896120e-02f, 4.37661000e-02f,
  -3.65483910e-02f, 7.69234300e-02f, 3.08110211e-02f, 8.80051032e-03f, -7.89701659e-03f, 3.07085980e-02f, 5.10081276e-03f, 6.34582341e-02f, 3.73157524e-02f, -2.43599210e-02f,
  9.39194188e-02f, -2.95409355e-02f, 6.98410571e-02f, -9.69035830e-03f, 6.27395660e-02f, -8.30221921e-03f, -8.03769603e-02f, 6.66640624e-02f, 6.77621588e-02f, -1.04209743e-02f,
  1.09671727e-01f, 8.86146948e-02f, -2.10623965e-02f, 1.02668792e-01f, 2.00436804e-02f, 6.71190470e-02f, -1.97001118e-02f, 3.29077579e-02f, 4.94819656e-02f, 8.53190850e-03f,
  -4.19097170e-02f, 7.23448545e-02f, -1.62313402e-01f, -7.66125247e-02f, -1.86448678e-01f, -6.25604950e-03f, 1.73031703e-01f, -3.20105366e-02f, -1.74091935e-01f, 2.25206450e-01f,
  5.64035848e-02f, 1.04800820e-01f, 1.64627388e-01f, -7.44878948e-02f, -3.54017839e-02f, -8.31834376e-02f, 6.03031255e-02f, 7.44858533e-02f, -1.38637647e-01f, 5.98703437e-02f,
  -2.59881079e-01f, 4.12034206e-02f, -1.24252498e-01f, -2.28019636e-02f, -1.24515355e-01f, -5.23968264e-02f, 2.42358044e-01f, -4.11176309e-02f, 1.90001894e-02f, 1.03970677e-01f,
  -3.12064309e-02f, -3.02949082e-02f, -1.03863493e-01f, -3.29591185e-02f, 3.17981355e-02f, -1.28750145e-01f, 2.75416393e-03f, -2.87388507e-02f, -8.73370841e-02f, -2.16617957e-02f,
  4.27920893e-02f, 9.84659139e-03f, 1.10576786e-01f, -7.19407052e-02f, -1.16199933e-01f, -5.57747371e-02f, -9.89665538e-02f, -1.22223268e-04f, -6.19609468e-02f, -3.26983072e-02f,
  -1.32406741e-01f, -9.45813507e-02f, -1.62569974e-02f, 8.00137296e-02f, -3.56418975e-02f, 2.44662203e-02f, 4.01570313e-02f, 1.17812201e-01f, -5.29953539e-02f, -7.94302523e-02f,
  -2.40589138e-02f, -9.77019966e-02f, 3.02177556e-02f, -2.62206960e-02f, 2.36644149e-02f, 4.34874615e-04f, -1.13926856e-02f, 1.10618830e-01f, 4.23922315e-02f, 6.02915026e-02f,
  6.14656359e-02f, 7.83261359e-02f, -6.82706386e-03f, -1.18412115e-01f, 1.55753437e-02f, 7.25241974e-02f, 1.06833279e-01f, 3.98536250e-02f, -9.83433351e-02f, 4.92368676e-02f,
  2.39405241e-02f, -9.07346755e-02f, 3.97378253e-03f, -6.83074072e-02f, -1.54815959e-02f, -2.91277990e-02f, -1.08520657e-01f, -5.87713718e-02f, 7.16970339e-02f, -9.13362671e-03f,
  1.03477731e-01f, 2.35191151e-01f, 6.01685718e-02f, 1.00434069e-02f, 5.02754822e-02f, -2.38204729e-02f, -4.97320890e-02f, 4.82581221e-02f, 6.15007570e-03f, -1.76650230e-02f,
  -6.80032000e-02f, 5.07657118e-02f, 5.04417047e-02f, -3.85339968e-02f, 2.57394295e-02f, 8.21503252e-02f, 8.26602280e-02f, 9.95961577e-02f, 3.34285796e-02f, 8.96883532e-02f,
  4.37306128e-02f, 1.18915103e-01f, -2.41246377e-03f, 3.38480733e-02f, 5.56476265e-02f, 4.82857078e-02f, 7.69362226e-02f, 3.43228616e-02f, -2.36411039e-02f, -3.05721117e-03f,
  -2.46798605e-01f, -1.88035637e-01f, 1.06302337e-04f, -1.16694152e-01f, 2.47712120e-01f, -3.28696340e-01f, -2.63267308e-01f, 9.62192193e-02f, 9.93685573e-02f, -1.77468076e-01f,
  -3.29698622e-02f, 6.34407625e-02f, 7.40146115e-02f, -2.25299135e-01f, 1.29846528e-01f, -7.13442639e-02f, -2.55255908e-01f, -3.04949105e-01f, 1.07875921e-01f, -5.66859692e-02f,
  1.41125903e-01f, -5.75663783e-02f, -7.55467862e-02f, 1.42581090e-01f, -4.67846841e-02f, 4.78344001e-02f, 1.94332987e-01f, 2.38164768e-01f, -2.07404390e-01f, 7.51599818e-02f,
  -7.89149553e-02f, 1.27471849e-01f, 1.32450592e-02f, 1.31532522e-02f, -1.00522049e-01f, -9.50587988e-02f, -7.71405697e-02f, 1.30816057e-01f, 1.48259029e-01f, -8.56019408e-02f,
  -7.79832304e-02f, 4.43649068e-02f, -2.64548380e-02f, 1.60048604e-01f, 4.64949682e-02f, 2.43261382e-02f, -6.64417446e-02f, -9.93473455e-02f, 5.83852679e-02f, 2.39863656e-02f,
  3.79851758e-02f, -5.20984270e-02f, -3.74142602e-02f, -6.34420961e-02f, -1.34239374e-02f, -6.66119680e-02f, -2.42124144e-02f, -4.26268727e-02f, -1.33546144e-01f, -2.39812173e-02f,
  -7.65795037e-02f, 9.09806928e-04f, 3.81245762e-02f, -2.62026582e-03f, -6.23434037e-03f, 3.25272679e-02f, 1.53279856e-01f, -2.52866955e-03f, 6.88573644e-02f, -3.28022391e-02f,
  -7.09325224e-02f, -2.15158872e-02f, 5.06158471e-02f, -2.38559321e-02f, -1.27115190e-01f, 5.95288798e-02f, 4.28180508e-02f, -6.14420744e-03f, -4.86819185e-02f, -1.39105301e-02f,
  5.20822629e-02f, 5.87908961e-02f, -1.61901172e-02f, -3.07993777e-02f, 3.64089943e-02f, 1.78847779e-02f, -7.07958313e-03f, 3.63610238e-02f, -5.66413021e-03f, 8.00128281e-02f,
  -7.09839761e-02f, -3.90657857e-02f, 2.52288450e-02f, -3.12435883e-03f, -2.08598515e-03f, 1.90592371e-02f, 4.60646860e-02f, -5.34809493e-02f, 7.59883027e-04f, -7.82691613e-02f,
  -2.07915548e-02f, -5.50859496e-02f, -1.88620046e-01f, 5.47149293e-02f, 7.79275447e-02f, 1.86544321e-02f, -2.16987301e-02f, 9.91488546e-02f, 7.19091669e-02f, 9.07674432e-02f,
  1.74447447e-02f, -9.50825587e-03f, -9.26335827e-02f, 1.99517719e-02f, -1.03270456e-01f, 1.84302609e-02f, -3.20430398e-02f, -1.39162511e-01f, 2.77056685e-03f, 7.61678722e-03f,
  -2.50601292e-01f, 2.62809634e-01f, -2.20905602e-01f, 8.45702142e-02f, 1.70735940e-01f, 2.24371273e-02f, 7.42053688e-02f, 1.41556069e-01f, -1.36232227e-01f, 3.23342055e-01f,
  1.87444538e-01f, -8.36593434e-02f, 4.81805429e-02f, 2.03852177e-01f, -3.10931116e-01f, -5.78967594e-02f, 1.71887770e-01f, 1.00254370e-02f, 2.68213358e-02f, 8.25934634e-02f,
  -2.80428939e-02f, 2.26268142e-01f, -6.26341477e-02f, 1.59155667e-01f, 1.55226901e-01f, -1.27382904e-01f, 5.89447916e-02f, 2.95155551e-02f, 1.02848560e-01f, 7.14761615e-02f,
  -6.56581670e-02f, -5.01416959e-02f, -3.72728668e-02f, -1.81954384e-01f, -2.30171885e-02f, 2.10518371e-02f, -7.36111328e-02f, -1.40734300e-01f, -1.17682882e-01f, -2.66395584e-02f,
  -6.53970391e-02f, -3.31258774e-02f, 7.42394803e-03f, -2.93079335e-02f, 9.91677940e-02f, -9.57760289e-02f, 5.57607822e-02f, 2.04314422e-02f, 2.80148499e-02f, 6.26569539e-02f,
  6.71265880e-03f, 3.40480469e-02f, 5.37199862e-02f, -5.67684919e-02f, -4.10768203e-02f, 1.14608206e-01f, -2.04077307e-02f, 5.71877174e-02f, 4.65580747e-02f, 2.86563449e-02f,
  6.53719455e-02f, -7.54825398e-02f, -7.94576667e-03f, -2.84778755e-02f, -6.66797757e-02f, -5.21123149e-02f, 7.08409213e-03f, 2.44682468e-02f, -1.79460093e-01f, 7.61336535e-02f,
  7.67577365e-02f, -8.74555185e-02f, 6.87625259e-02f, 2.69266590e-02f, 6.55808821e-02f, 4.01776358e-02f, 3.18108350e-02f, -3.52564640e-03f, -3.18683125e-02f, -4.41797003e-02f,
  -2.48800870e-02f, -3.03024030e-03f, -7.58175796e-04f, 4.81107794e-02f, -3.04420553e-02f, 2.30201501e-02f, 3.82646061e-02f, 5.26001714e-02f, 8.68978947e-02f, -7.17418566e-02f,
  1.97012443e-02f, -7.58610815e-02f, -7.58163184e-02f, -1.23664238e-01f, -4.04658280e-02f, 3.02765146e-02f, -6.06317595e-02f, -1.21118724e-01f, -4.61770445e-02f, -9.41312388e-02f,
  -9.12550837e-02f, 7.97729865e-02f, 7.87697285e-02f, -6.69959048e-03f, 1.09947426e-02f, 9.51863767e-04f, 2.16813199e-02f, -1.57505355e-03f, -1.51403025e-02f, 5.43796942e-02f,
  3.55206355e-02f, 5.63593023e-02f, -3.14578079e-02f, 2.01809481e-02f, 2.95321308e-02f, 4.90089208e-02f, 5.36865089e-03f, 1.93110909e-02f, -4.12378311e-02f, 3.91284227e-02f,
  -7.83643052e-02f, -5.04275933e-02f, -7.79059762e-03f, 3.06786537e-01f, -1.86193660e-02f, -3.57594937e-01f, -1.52951851e-01f, -1.14957998e-02f, -8.77891779e-02f, 9.64957476e-02f,
  3.39906178e-02f, -4.70579416e-02f, -8.77256095e-02f, 3.03245604e-01f, -1.10261470e-01f, 1.11152112e-01f, 1.16657726e-01f, 1.14621378e-01f, -8.81748497e-02f, 1.59591913e-01f,
  6.23582937e-02f, 2.58510768e-01f, 1.80543244e-01f, 3.84092480e-02f, 1.22076325e-01f, 2.56883260e-02f, 1.29599318e-01f, -5.91659844e-02f, 1.69627771e-01f, -1.26680747e-01f,
  -1.42047063e-01f, 2.50273049e-02f, 6.51903152e-02f, -7.85822943e-02f, 7.84712378e-03f, 3.14575620e-02f, 2.66667102e-02f, -7.51880258e-02f, -1.03647066e-02f, -6.48955703e-02f,
  -6.30269647e-02f, 4.26144414e-02f, -1.94262771e-03f, 4.94420752e-02f, -1.45844340e-01f, 2.16867905e-02f, 4.21961509e-02f, -1.01899780e-01f, 4.98512201e-02f, -1.18192136e-02f,
  7.50145242e-02f, -8.53130221e-02f, 3.49789746e-02f, 2.96413992e-02f, -5.74380681e-02f, -6.77299872e-02f, 1.91271305e-02f, 6.09823782e-03f, 3.41440402e-02f, 2.06805430e-02f,
  1.26700774e-02f, 8.34221914e-02f, 6.95261434e-02f, 7.12093338e-02f, 3.05213351e-02f, 5.25009707e-02f, 1.72741078e-02f, -1.28385976e-01f, -1.22187376e-01f, -1.41868759e-02f,
  6.26644567e-02f, 6.41603246e-02f, 2.52303900e-03f, -2.05476601e-02f, 1.13513358e-01f, 9.59566310e-02f, 4.91236821e-02f, 5.97794317e-02f, -6.47931313e-03f, 1.14558069e-02f,
  -2.05068607e-02f, -2.12588720e-02f, 1.96178611e-02f, 5.76208420e-02f, -1.20899409e-01f, -1.23157268e-02f, 3.15386765e-02f, 1.30686956e-02f, 1.28594805e-02f, 8.48708078e-02f,
  -1.59651697e-01f, 2.33399998e-02f, -1.25310365e-02f, -8.36772323e-02f, 5.60682714e-02f, 1.16756156e-01f, 3.38662742e-03f, -4.46544774e-02f, -8.20079148e-02f, 6.57017976e-02f,
  6.52265772e-02f, 1.99906528e-02f, -1.21761113e-01f, -2.39903629e-02f, -8.52723345e-02f, -6.24454021e-02f, -3.76065560e-02f, -8.99809450e-02f, -3.13043259e-02f, -8.85802209e-02f,
  -6.32121265e-02f, -1.49806160e-02f, 1.46041721e-01f, 1.31917847e-02f, 4.52196971e-02f, -9.79887843e-02f, -1.04794940e-02f, -5.52518740e-02f, 5.43843172e-02f, 2.76512988e-02f,
  1.00746006e-01f, -1.63481802e-01f, -1.45494834e-01f, -8.68383870e-02f, 8.31120610e-02f, 4.79958020e-02f, 2.76545193e-02f, -7.08308592e-02f, -1.93649381e-01f, -1.03755772e-01f,
  1.94246829e-01f, -1.21282473e-01f, 1.88766699e-02f, -1.56879369e-02f, 2.24148631e-01f, -3.02478168e-02f, 7.94212595e-02f, 2.86829472e-02f, -2.03335658e-02f, -1.13667607e-01f,
  -1.94501560e-02f, 6.32574037e-02f, 7.83510953e-02f, -8.11435878e-02f, -1.28529534e-01f, -1.93107009e-01f, 2.68174082e-01f, -4.59720977e-02f, 1.89165398e-02f, 1.48541495e-01f,
  -1.26314154e-02f, -8.96146521e-02f, -3.31050646e-03f, -1.28373176e-01f, 1.17710836e-01f, 6.09994829e-02f, 1.76887196e-02f, 6.50211647e-02f, -5.63489012e-02f, -7.15338364e-02f,
  -3.00752446e-02f, -1.05507962e-01f, -7.75545537e-02f, -5.83033599e-02f, -5.75089641e-02f, -1.58567458e-01f, -3.69186588e-02f, -5.80666810e-02f, -3.54592502e-02f, -8.26405454e-03f,
  -3.69396582e-02f, -6.21215440e-03f, -6.67747036e-02f, 5.03619714e-03f, -4.07340862e-02f, -1.10925488e-01f, -3.48291844e-02f, 5.99158667e-02f, -2.11773757e-02f, 1.13921147e-02f,
  5.88046424e-02f, -1.17485650e-01f, -1.64335724e-02f, -8.33445862e-02f, -1.42794745e-02f, 4.98537160e-02f, -7.29621127e-02f, 5.18081114e-02f, -8.71967990e-03f, 3.51663195e-02f,
  -2.64434852e-02f, 9.85257253e-02f, 1.23142093e-01f, -1.30277514e-01f, 2.38408707e-02f, 1.46154109e-02f, -2.61464231e-02f, -1.50526255e-01f, -6.23926409e-02f, 5.70768341e-02f,
  7.63735846e-02f, -3.27515788e-02f, -3.60303894e-02f, -3.07225846e-02f, -5.22637442e-02f, -1.53955758e-01f, -3.24743800e-02f, -1.36389703e-01f, 6.46500662e-02f, -3.25400271e-02f,
  9.36371833e-02f, -7.31638148e-02f, 3.79575938e-02f, -3.18327546e-02f, 5.62016517e-02f, -9.69066005e-03f, 3.46801355e-02f, -2.83148419e-02f, -3.65310684e-02f, -7.82760754e-02f,
  5.32878516e-03f, -5.04864827e-02f, -4.38235067e-02f, -2.33690497e-02f, 1.18368663e-01f, 3.20754535e-02f, -4.17422839e-02f, 8.63225013e-02f, 8.58292803e-02f, 8.93291458e-02f,
  -1.60741489e-02f, -5.04220426e-02f, -7.70918503e-02f, -1.80031527e-02f, -1.99109428e-02f, 2.76574865e-02f, 8.97883400e-02f, 6.80145249e-02f, -7.22521171e-02f, 3.19197513e-02f,
  -5.61558157e-02f, 2.20604286e-01f, -5.06951883e-02f, -1.87051132e-01f, 6.36235774e-02f, 7.60672614e-02f, -1.58276305e-01f, 2.34623745e-01f, -8.98195207e-02f, -3.38840298e-02f,
  -3.73802260e-02f, -1.33766517e-01f, 6.44383719e-03f, -1.75566636e-02f, -4.77188975e-02f, 8.17621499e-03f, -6.89270534e-03f, -6.18672408e-02f, 6.84949383e-02f, 6.06789738e-02f,
  -6.03729300e-03f, 1.08080350e-01f, -1.61191128e-04f, 1.82453781e-01f, 1.78385779e-01f, -4.25131693e-02f, -4.22867667e-03f, 1.15446039e-02f, 6.18017104e-04f, -1.13020344e-02f,
  6.44403324e-02f, 1.07052820e-02f, 4.53568064e-02f, 5.31248888e-03f, 3.02405041e-02f, -1.63682431e-01f, -8.29780400e-02f, -5.06987385e-02f, -6.69342354e-02f, -8.58170837e-02f,
  -3.94148305e-02f, 2.80536506e-02f, 7.92357549e-02f, -5.70120737e-02f, -6.71563344e-03f, 2.03395374e-02f, 1.87685098e-02f, 7.98405483e-02f, -1.11128157e-02f, -7.36252889e-02f,
  2.70409342e-02f, -3.46770138e-02f, 4.49266657e-02f, -5.28446250e-02f, -1.65745113e-02f, 4.88891266e-03f, -9.07311961e-02f, -6.00856952e-02f, 1.59845613e-02f, -1.37220070e-01f,
  9.89593565e-03f, 8.11358243e-02f, -1.23848533e-02f, 1.33044854e-01f, -6.30894117e-03f, -8.75310693e-03f, -5.86376041e-02f, 2.81189922e-02f, 3.74539532e-02f, 7.04172924e-02f,
  7.78409764e-02f, -1.99882742e-02f, 2.09798571e-02f, -3.97121347e-02f, -2.36527156e-02f, -5.15521318e-02f, -6.28675297e-02f, 2.63055530e-03f, 3.64420488e-02f, 1.72612686e-02f,
  4.21688482e-02f, -1.38539150e-02f, 1.84563190e-01f, -1.44105762e-01f, 2.13596970e-02f, 1.53917354e-02f, -4.09890823e-02f, -6.68464303e-02f, -6.34922832e-02f, 1.76125430e-02f,
  2.15607792e-01f, 1.06101960e-01f, 5.41809872e-02f, 6.02717213e-02f, 5.40684760e-02f, -2.44590007e-02f, -4.99041826e-02f, 2.11251210e-02f, 1.57145113e-02f, -1.41539201e-01f,
  -1.94264427e-02f, -1.04368273e-02f, -5.27070537e-02f, 4.30469252e-02f, 7.17008784e-02f, 2.30134167e-02f, -1.51088685e-01f, -4.99972068e-02f, -1.78739540e-02f, 9.11112130e-02f,
  -1.09524392e-02f, 7.94366822e-02f, -1.71897351e-03f, -3.76867950e-02f, -5.70875853e-02f, 1.71729047e-02f, -1.34812612e-02f, 9.92390700e-03f, -2.90690921e-02f, -1.35148307e-02f,
  -6.51813745e-02f, -2.86845751e-02f, 1.77976172e-02f, -8.18962231e-02f, 3.75270359e-02f, 3.31409454e-01f, 1.55899003e-01f, 2.92667970e-02f, -3.06762725e-01f, 6.48513436e-02f,
  2.15326443e-01f, -2.22224936e-01f, -1.30521432e-02f, 2.13276818e-01f, -3.10121998e-02f, 7.11755678e-02f, 1.21901557e-01f, 9.69474912e-02f, -1.73316464e-01f, 5.80632277e-02f,
  4.35356759e-02f, 1.84325904e-01f, 1.72755808e-01f, -2.30164770e-02f, 1.88265279e-01f, -1.33545861e-01f, -6.77810470e-03f, -3.36721092e-02f, 6.81540743e-02f, -2.78349984e-02f,
  5.28866276e-02f, -1.02745287e-01f, 2.40659323e-02f, -1.81658808e-02f, 7.25044236e-02f, 1.02821887e-01f, 5.29162735e-02f, 1.10102128e-02f, 1.30369999e-02f, 4.40422334e-02f,
  -1.90447550e-02f, 4.58590165e-02f, -9.42093506e-02f, 4.51898351e-02f, -7.03852400e-02f, 5.65494783e-02f, -5.25900237e-02f, 8.63501709e-03f, 7.80485943e-02f, 1.44932285e-01f,
  1.01784326e-01f, 4.97940509e-03f, 9.88362879e-02f, -1.25387475e-01f, 4.45816629e-02f, -6.53565079e-02f, -3.32551412e-02f, 3.96331251e-02f, 2.24332362e-02f, -1.12014145e-01f,
  3.52523848e-02f, 8.31759442e-03f, 4.36198637e-02f, -3.41200642e-03f, 1.56214237e-02f, 1.05434898e-02f, -1.91098079e-02f, -5.68314195e-02f, -1.04345761e-01f, 9.84333083e-02f,
  -4.61069830e-02f, -9.31870639e-02f, -2.18721349e-02f, 6.50281534e-02f, -4.78463359e-02f, -7.21271783e-02f, -1.21408142e-02f, 8.86076242e-02f, -6.46098405e-02f, -9.68990549e-02f,
  3.29668149e-02f, 8.10801461e-02f, -4.12651198e-03f, 8.79459828e-02f, 6.34837821e-02f, -6.61583021e-02f, -2.54684351e-02f, 1.02537610e-01f, 3.28997634e-02f, 1.24797985e-01f,
  -5.93491755e-02f, -1.07409328e-01f, -3.54018435e-02f, -7.03620762e-02f, 8.91258940e-03f, 1.51357666e-01f, 8.42773169e-02f, 6.13776073e-02f, 5.45047782e-02f, 4.30898368e-02f,
  3.67573649e-03f, -6.30251616e-02f, -1.59543622e-02f, -4.33346443e-02f, -1.28318787e-01f, 2.54720598e-02f, -1.33520156e-01f, -5.30272201e-02f, -3.36243249e-02f, -1.99260972e-02f,
  1.33427307e-01f, -3.96361351e-02f, 3.25663947e-02f, -2.99606696e-02f, 6.01457655e-02f, 1.70754287e-02f, -2.97246333e-02f, 1.50177609e-02f, -3.96703593e-02f, -6.34053499e-02f,
  4.76366997e-01f, 7.69391805e-02f, 1.04909837e-01f, 1.04840063e-01f, -1.42266050e-01f, 9.28924456e-02f, 1.61931828e-01f, -3.06190830e-02f, 1.53702751e-01f, -7.10578486e-02f,
  1.90502126e-02f, 7.82682598e-02f, -3.14461328e-02f, 2.57583469e-01f, 6.11613551e-03f, 2.09558792e-02f, 2.07573205e-01f, 1.37848586e-01f, -9.40073654e-03f, 1.00740820e-01f,
  8.44640508e-02f, -3.51536125e-02f, 9.99068990e-02f, -2.25860134e-01f, 2.69563258e-01f, 4.64124642e-02f, -2.98813790e-01f, -1.70242246e-02f, 5.51978424e-02f, -7.54034892e-02f,
  1.63302794e-01f, 1.30507082e-01f, 9.37882140e-02f, 9.06876326e-02f, 1.94463469e-02f, 5.63454702e-02f, 1.77367274e-02f, -1.12341736e-02f, 6.86325356e-02f, 5.94856143e-02f,
  8.62485263e-03f, 3.33041064e-02f, 1.77411200e-03f, 9.97289419e-02f, 6.24791868e-02f, 3.56186889e-02f, 7.13837892e-02f, 1.15196019e-01f, 2.57174578e-02f, 6.51936904e-02f,
  2.46268064e-02f, 2.80303098e-02f, -7.80763254e-02f, -4.05958258e-02f, -2.54890844e-02f, 4.63317195e-03f, -4.94408375e-03f, 1.99993867e-02f, -5.42873181e-02f, 2.56771352e-02f,
  -1.19030267e-01f, 3.95384151e-03f, 2.33808849e-02f, 5.20393550e-02f, 9.26209763e-02f, 1.63435638e-02f, 9.57941338e-02f, -3.07460707e-02f, 1.32978158e-02f, 8.44452381e-02f,
  1.17460201e-02f, -2.80400651e-04f, -5.25351241e-02f, 1.69827715e-02f, 8.39770213e-02f, -4.21811007e-02f, -6.52089640e-02f, 4.38256785e-02f, 2.51053204e-03f, -6.14568815e-02f,
  -4.87352051e-02f, 3.66960391e-02f, 3.10435556e-02f, -1.37244770e-02f, -7.58025125e-02f, 8.33810195e-02f, 2.66028326e-02f, 1.08359277e-01f, -6.11352287e-02f, 8.89208447e-03f,
  1.22967735e-02f, -9.90144163e-02f, 7.20499502e-03f, -1.71384811e-02f, 1.02982838e-02f, 6.88057840e-02f, -2.10041553e-02f, -3.84726711e-02f, -2.80646067e-02f, -3.38366181e-02f,
  -2.41609141e-02f, 5.10415994e-03f, -4.22879346e-02f, 1.76274385e-02f, -8.14633071e-02f, -1.05737597e-01f, -9.71965119e-02f, -3.51724774e-02f, -6.20247312e-02f, -7.80272260e-02f,
  -2.92584226e-02f, 2.85220635e-03f, -7.67600909e-02f, -5.25248721e-02f, -5.33944368e-02f, -3.64085026e-02f, 2.47229859e-02f, 2.25121547e-02f, 3.63526237e-03f, -3.06890458e-02f,
  3.68967682e-01f, -2.30574042e-01f, -7.37580331e-03f, 1.12847328e-01f, 2.95725092e-02f, -5.84052317e-02f, 7.77956843e-03f, -2.39968766e-03f, 1.06909059e-01f, -2.04653829e-01f,
  3.47978137e-02f, -2.20508594e-02f, 4.90625538e-02f, -5.42862760e-03f, 2.97817230e-01f, -3.23703662e-02f, 9.60669741e-02f, -5.21285972e-03f, 8.37457851e-02f, 2.05079690e-01f,
  4.19386439e-02f, -4.66718758e-03f, 8.86268020e-02f, -4.52192090e-02f, 1.92087647e-02f, -7.48071223e-02f, -1.46068931e-01f, -4.28034700e-02f, -2.94664893e-02f, -4.49699834e-02f,
  4.27507758e-02f, 2.61026621e-02f, -6.21346931e-04f, 2.07752082e-02f, 3.69365513e-02f, 7.34929964e-02f, -1.00833632e-01f, -4.60181870e-02f, 3.96590829e-02f, -6.04545288e-02f,
  -1.08367577e-01f, -2.38094688e-03f, -7.25657567e-02f, 8.46738815e-02f, -3.19045074e-02f, -3.11471839e-02f, -3.46660465e-02f, -1.02477908e-01f, -8.86898860e-02f, -1.25022801e-02f,
  4.23720106e-02f, -1.46903485e-01f, -3.29339691e-02f, -1.94884874e-02f, -1.89763568e-02f, -5.63090965e-02f, -6.97822720e-02f, -1.71355084e-01f, -1.33423135e-01f, -1.00199193e-01f,
  7.23754568e-03f, -2.49007717e-04f, -7.02321008e-02f, 2.10533887e-02f, 8.30520540e-02f, 4.20403443e-02f, 2.00515762e-02f, -2.45422423e-02f, -2.78945616e-03f, -5.16538955e-02f,
  -1.22177834e-02f, 6.27725944e-02f, 7.78836384e-02f, 2.35579014e-02f, -6.31907731e-02f, -1.45172011e-02f, 4.87961397e-02f, -5.19215316e-02f, 8.67034048e-02f, -2.27826815e-02f,
  -1.34011004e-02f, 3.03564277e-02f, -7.83262551e-02f, -1.04074568e-01f, 2.94499639e-02f, -2.58051399e-02f, -4.07809615e-02f, 4.57700156e-02f, 7.58358091e-02f, 3.73261273e-02f,
  -5.54426573e-02f, 1.69299282e-02f, -7.35928118e-02f, -1.07083255e-02f, 4.83400412e-02f, 7.64664710e-02f, 3.39428410e-02f, -1.04015805e-01f, -8.48689955e-03f, -1.51432604e-02f,
  1.36239929e-02f, 1.29937967e-02f, 7.97346176e-04f, 8.88798311e-02f, -8.02217349e-02f, -1.50431514e-01f, 3.76859233e-02f, -4.05881628e-02f, -1.29274741e-01f, -3.07078026e-02f,
  -1.22607373e-01f, -1.07410349e-01f, -1.01435278e-02f, 1.72333047e-02f, -6.88314587e-02f, -5.95478863e-02f, -1.11999549e-02f, -4.22592908e-02f, -1.72358394e-01f, -7.56918192e-02f,
  -4.84767333e-02f, 3.82212967e-01f, 1.61800057e-01f, 2.02728972e-01f, 3.28254551e-02f, -4.91318181e-02f, -2.06054360e-01f, 9.84323621e-02f, 5.99854290e-02f, -6.31123632e-02f,
  -9.56413150e-02f, 2.12619137e-02f, -1.48789153e-01f, 1.62597030e-01f, -2.08739638e-01f, -5.08842319e-02f, 1.25644460e-01f, -9.13589448e-02f, -2.52321381e-02f, 6.70667589e-02f,
  1.80822834e-02f, 1.31802544e-01f, 1.15314899e-02f, 6.32923096e-02f, 1.03196844e-01f, 5.91921955e-02f, 1.96089763e-02f, -3.66728492e-02f, 2.12226897e-01f, 3.04893218e-02f,
  -4.21511754e-02f, 3.39788832e-02f, 6.63110688e-02f, -2.49324832e-02f, 1.78853348e-02f, 3.09074223e-02f, -3.03556137e-02f, -1.16787866e-01f, 4.67246808e-02f, 9.37478021e-02f,
  -3.38216452e-03f, 8.06283429e-02f, -7.93731883e-02f, -1.70350187e-02f, 1.21289164e-01f, 5.53280264e-02f, -4.58394177e-02f, 5.69242872e-02f, 6.77281320e-02f, 1.05439097e-01f,
  5.89814596e-02f, 7.28865340e-02f, 6.71116635e-02f, 2.68175695e-02f, 3.75851281e-02f, 8.13746229e-02f, 8.93033016e-03f, 5.59035838e-02f, 9.21902135e-02f, 1.11532874e-01f,
  4.30085137e-02f, -8.75430033e-02f, 2.86282152e-02f, -3.22558992e-02f, 3.94127816e-02f, -1.15326354e-02f, -4.86337999e-03f, -1.40662909e-01f, -8.44830740e-03f, -2.50795893e-02f,
  1.59957651e-02f, 2.36913264e-02f, 1.42121287e-02f, 9.41219926e-03f, 1.51777584e-02f, 4.47017737e-02f, -4.29534055e-02f, 8.69166851e-02f, 6.28394932e-02f, 3.40423137e-02f,
  -3.35736945e-02f, -5.52086420e-02f, -8.33221674e-02f, 7.98219256e-03f, -6.04925901e-02f, -5.21828756e-02f, 1.61840677e-01f, 5.68660535e-02f, -4.08708751e-02f, -1.18096136e-02f,
  1.57623336e-01f, 1.92013964e-01f, -1.01045221e-01f, 7.25693032e-02f, 2.29862016e-02f, 1.80240404e-02f, -6.55061081e-02f, 1.65413603e-01f, 1.50975630e-01f, 9.57233459e-02f,
  9.93910208e-02f, -3.77415866e-02f, 4.07066494e-02f, 1.53956115e-02f, 8.46673548e-02f, 7.08535835e-02f, -1.47662759e-01f, -4.36719358e-02f, 8.95841941e-02f, 6.83282912e-02f,
  1.82093144e-03f, 3.89304943e-02f, -7.78547451e-02f, -5.27026653e-02f, 2.83381692e-03f, -6.47321641e-02f, 1.77566558e-02f, 8.65147561e-02f, 8.13446790e-02f, 2.22515389e-02f,
  -2.27166101e-01f, 2.34593511e-01f, -2.92140543e-01f, 1.57873109e-01f, -4.21868451e-02f, 7.42584541e-02f, -2.76212618e-02f, 1.32838368e-01f, 4.54687700e-02f, 2.73112595e-01f,
  1.24562301e-01f, -1.60115272e-01f, -8.01211670e-02f, 2.98270553e-01f, 6.58490742e-03f, 1.46907970e-01f, 2.41662607e-01f, 4.07969616e-02f, 9.31643769e-02f, 1.39455780e-01f,
  6.08881712e-02f, 4.09882605e-01f, -1.78703181e-02f, 2.77157485e-01f, 3.93408723e-02f, -1.31654039e-01f, 3.67584676e-02f, -1.87777609e-01f, 1.95864558e-01f, 5.34881875e-02f,
  5.69188111e-02f, -1.48643116e-02f, -5.70696034e-02f, 6.03008037e-03f, -2.65338495e-02f, -2.99321096e-02f, -7.63234049e-02f, -7.48906285e-02f, -1.17832355e-01f, 9.03405156e-03f,
  -5.68026938e-02f, 1.94319300e-02f, 1.01151183e-01f, 1.48052452e-02f, 6.95798919e-02f, -2.63038855e-02f, 2.88578328e-02f, 1.61971053e-04f, 3.51582505e-02f, -6.09868877e-02f,
  -4.02431488e-02f, 6.12482382e-03f, 3.67028639e-02f, 6.79144189e-02f, 4.69818246e-03f, 9.64845419e-02f, 1.00806430e-01f, -7.06543177e-02f, -6.46177083e-02f, 1.30417392e-01f,
  1.95046533e-02f, -1.87071599e-02f, -5.50069474e-02f, 2.46405229e-03f, 4.93359677e-02f, -2.81493571e-02f, 6.16347417e-02f, -1.80151314e-03f, -1.04996271e-01f, 1.72453132e-02f,
  3.47982049e-02f, -1.85998324e-02f, 1.23128705e-01f, -2.24290453e-02f, 9.13626626e-02f, 1.37656908e-02f, -2.37758979e-02f, 3.05453148e-02f, 4.60880809e-02f, -1.29648507e-01f,
  -1.01687238e-01f, 4.69565317e-02f, 2.40874272e-02f, 1.03188217e-01f, -1.37642976e-02f, -1.54434890e-02f, 2.00452209e-01f, 1.22178849e-02f, 1.16281249e-02f, -2.06553228e-02f,
  1.65404886e-01f, 1.64473623e-01f, 2.60638222e-02f, 8.39869529e-02f, -1.28702903e-02f, 6.08554780e-02f, 2.73062545e-03f, 2.28468645e-02f, -1.53358588e-02f, -1.11969197e-02f,
  -1.87254399e-02f, 7.25527704e-02f, 4.94218245e-02f, 5.08095557e-03f, 1.04769558e-01f, 5.23869358e-02f, 7.94071332e-02f, 3.96671221e-02f, 1.04648143e-01f, -1.14683937e-02f,
  -4.67202626e-02f, 1.51377935e-02f, -4.97835204e-02f, 6.49368465e-02f, 4.71017063e-02f, -2.14071721e-02f, -1.92881543e-02f, -3.58766727e-02f, 1.53814927e-02f, 1.26927746e-02f,
  1.82551965e-01f, -1.03540465e-01f, -2.37572223e-01f, 8.54705274e-03f, 6.11418039e-02f, -1.92718670e-01f, -1.40812263e-01f, -2.99361311e-02f, 1.56377107e-01f, 2.64817774e-02f,
  -7.87128508e-02f, -9.37674120e-02f, 7.50993490e-02f, -1.14982218e-01f, -9.41629056e-03f, 2.76606083e-02f, -8.28948915e-02f, -8.52996409e-02f, 1.03247732e-01f, 1.02532059e-01f,
  5.07591553e-02f, 8.12515765e-02f, -2.00215369e-01f, 1.94872804e-02f, -1.17413551e-01f, -5.27420603e-02f, 6.82006925e-02f, -3.67397293e-02f, -1.13033086e-01f, -9.64511558e-02f,
  -3.27074453e-02f, 1.75363749e-01f, -3.39125879e-02f, 1.60886142e-02f, 3.41650583e-02f, 5.62341623e-02f, -1.28861074e-03f, -5.74741624e-02f, 4.93674129e-02f, -7.38368705e-02f,
  6.23303391e-02f, 8.80751200e-03f, -5.03720865e-02f, 5.58409430e-02f, -2.18815897e-02f, -3.68876196e-02f, -1.34509511e-03f, -1.06665298e-01f, -7.25214779e-02f, -7.17691556e-02f,
  -3.93598452e-02f, -1.65792495e-01f, -7.65079111e-02f, -6.16618358e-02f, -3.08774840e-02f, -2.75647994e-02f, -8.69894028e-02f, -1.44464925e-01f, -1.42708840e-02f, 5.56948110e-02f,
  6.87457388e-03f, 4.87440266e-02f, -2.58322489e-02f, -4.95170662e-03f, 3.85117307e-02f, -2.46098675e-02f, 2.44612843e-02f, -2.16610469e-02f, -3.32913473e-02f, -4.90337573e-02f,
  1.17622409e-02f, -3.59347388e-02f, -8.55091736e-02f, 4.20301780e-02f, 8.69002938e-02f, 1.71355233e-02f, -7.44181946e-02f, 7.38617554e-02f, 1.78139303e-02f, -6.83608875e-02f,
  -5.94072929e-03f, -4.73094842e-04f, -3.81218866e-02f, 4.34194691e-02f, 4.79418319e-03f, 4.13204096e-02f, 4.72175144e-02f, 1.64309293e-02f, -4.10030894e-02f, 1.84738208e-02f,
  1.14610277e-01f, 3.13592315e-01f, 4.50496991e-05f, 3.64030339e-02f, 3.37570533e-02f, 3.16701941e-02f, 1.12659615e-02f, -5.33457175e-02f, 9.85739678e-02f, 4.18603942e-02f,
  5.53291552e-02f, -5.26997112e-02f, 7.18006194e-02f, -7.71775935e-03f, -9.23658721e-03f, -5.14804572e-02f, 9.05276313e-02f, 1.08690830e-02f, -1.07082184e-02f, -4.15623412e-02f,
  -6.87360913e-02f, 2.13173460e-02f, 1.01976935e-02f, -5.84795512e-02f, -4.57333680e-03f, -1.22709461e-02f, -3.26613113e-02f, -7.73879141e-02f, -1.88596994e-02f, 1.42021617e-02f,
  -4.78597218e-03f, -2.16289818e-01f, 1.64945144e-02f, -2.09498808e-01f, -1.08405784e-01f, 2.58397818e-01f, 1.78718463e-01f, -1.78468287e-01f, -3.14406395e-01f, -7.70411417e-02f,
  -9.93922702e-04f, -9.79263149e-03f, 8.32735747e-02f, -1.62881538e-02f, 2.07479239e-01f, 6.21443912e-02f, 9.08597410e-02f, 1.43725991e-01f, -1.11633547e-01f, -1.63199320e-01f,
  3.85193080e-02f, 5.30738868e-02f, 6.45847768e-02f, -1.18587300e-01f, -6.16077632e-02f, -9.86227393e-02f, 3.79970893e-02f, -4.87486869e-02f, 3.57275307e-02f, 7.46060759e-02f,
  4.98884991e-02f, -1.51567817e-01f, -4.65455502e-02f, -3.04882228e-03f, 2.97567230e-02f, 1.03363700e-01f, 1.77850381e-01f, 5.80639876e-02f, -1.29424594e-02f, -3.94155644e-02f,
  3.15441526e-02f, -8.69991779e-02f, -1.24031655e-01f, -2.85917707e-02f, -1.53855830e-01f, -1.25201583e-01f, -1.09710075e-01f, -1.73257999e-02f, -1.91204011e-01f, 5.81747033e-02f,
  -1.39208451e-01f, 2.90370584e-02f, -1.06399521e-01f, 2.79942974e-02f, 9.31998366e-04f, -1.05696224e-01f, 3.95432040e-02f, 8.75812173e-02f, 4.48853038e-02f, -1.58639863e-01f,
  7.04199448e-02f, 1.13358691e-01f, 1.76634789e-02f, 2.58148480e-02f, 1.25708245e-02f, -3.45671400e-02f, -1.39625892e-01f, -2.21888460e-02f, -1.00117745e-02f, -4.44140024e-02f,
  -3.77399586e-02f, -7.66406581e-02f, -9.82440785e-02f, 3.01314220e-02f, 1.87206827e-02f, -4.07911353e-02f, -6.84886612e-03f, 9.94424336e-03f, -4.23136242e-02f, 1.03880860e-01f,
  1.09796114e-01f, 2.19278876e-02f, 3.77974138e-02f, 3.89745981e-02f, -3.28953825e-02f, -4.04467173e-02f, -6.18643314e-02f, 1.81432534e-02f, 4.41910774e-02f, 8.99733007e-02f,
  1.11918271e-01f, 3.85357067e-02f, -3.75443138e-02f, 3.54609340e-02f, 4.04043496e-02f, -1.38157802e-02f, 1.47081062e-01f, -2.00933665e-02f, 9.29199234e-02f, 6.63600639e-02f,
  8.22042897e-02f, -1.09474562e-01f, -2.61417702e-02f, -1.09957255e-01f, -1.17893614e-01f, 3.87389287e-02f, 3.94467004e-02f, -4.44476753e-02f, -6.95464686e-02f, 1.71745718e-02f,
  7.17304572e-02f, 1.58061944e-02f, -9.28137004e-02f, 1.93041340e-02f, 5.96211366e-02f, -7.65534565e-02f, 3.04308869e-02f, -4.17170003e-02f, 1.15895551e-02f, 7.94530939e-03f,
  1.96598113e-01f, -2.03950226e-01f, -1.87100708e-01f, 1.07406192e-01f, 1.73405707e-01f, -7.03222975e-02f, -2.41761848e-01f, 1.97755709e-01f, -1.18466981e-01f, -6.02770410e-02f,
  1.24460720e-02f, -2.65234917e-01f, -2.20572993e-01f, 9.83450213e-04f, 2.65360978e-02f, -2.19480440e-01f, 6.43118620e-02f, -1.30657420e-01f, -4.25711796e-02f, 4.04286794e-02f,
  2.17545345e-01f, 3.44004810e-01f, -1.18022850e-02f, 2.37562075e-01f, 1.61554694e-01f, 1.29651517e-01f, 2.34482437e-01f, -1.01341002e-01f, 1.77714750e-01f, 4.13132384e-02f,
  -1.08929358e-01f, 5.42606860e-02f, -4.79660966e-02f, -6.03165813e-02f, 4.80126478e-02f, 1.09110624e-01f, -6.23260401e-02f, 5.98091595e-02f, -9.06795114e-02f, -4.05326523e-02f,
  6.44383254e-03f, 6.05148189e-02f, 5.82143962e-02f, 1.05636902e-01f, 4.19994071e-02f, -4.82632825e-03f, -3.31787765e-03f, -8.80787149e-02f, -5.80504350e-02f, 4.26964508e-03f,
  -1.06465295e-01f, -2.35966444e-02f, 3.54329534e-02f, -4.19992581e-02f, 3.94739881e-02f, -3.63302119e-02f, -2.34316569e-02f, -1.03908964e-01f, 4.49572839e-02f, 3.42848450e-02f,
  9.29344594e-02f, 6.38396963e-02f, 2.08895355e-02f, -4.62352857e-02f, 1.45342732e-02f, 1.01370513e-02f, -4.24623340e-02f, -4.79877554e-02f, -6.23954870e-02f, -1.71553548e-02f,
  2.08727941e-02f, 1.08949924e-02f, -5.10292500e-02f, 5.04744165e-02f, 7.16908425e-02f, 1.77808702e-02f, -5.96616678e-02f, 4.09083143e-02f, 2.25953665e-02f, -4.51348796e-02f,
  -3.72595377e-02f, 5.23310043e-02f, -1.81925952e-01f, 2.86650583e-02f, -8.16657245e-02f, -7.50019550e-02f, 9.99928936e-02f, -1.48477070e-02f, -5.06485626e-02f, 7.97092915e-02f,
  -5.05651422e-02f, 1.26382217e-01f, -4.88939956e-02f, -5.42820618e-02f, -6.75353631e-02f, 1.43328160e-01f, -2.35964712e-02f, 5.54423928e-02f, 7.46203680e-03f, 9.64698866e-02f,
  1.74470142e-01f, -2.05407385e-02f, -1.22837340e-02f, 4.41696979e-02f, -1.90347880e-02f, -3.49863768e-02f, 5.19114062e-02f, -8.83273333e-02f, 6.92199841e-02f, -2.06659120e-02f,
  5.72079234e-02f, -6.81544319e-02f, 1.61027387e-02f, 8.31421390e-02f, 1.03974387e-01f, -6.34505302e-02f, 2.71495115e-02f, -4.21785749e-02f, 6.13031760e-02f, 5.94150624e-04f,
  2.95241296e-01f, 1.14735194e-01f, -1.19379781e-01f, -1.36055918e-02f, 7.50317425e-02f, 7.21605569e-02f, -7.58577287e-02f, 6.88221455e-02f, 2.61499912e-01f, -1.14948004e-01f,
  -1.22792535e-01f, 5.56361377e-02f, -7.38661736e-02f, -2.19047323e-01f, 1.19964100e-01f, -5.36624379e-02f, 6.72971690e-03f, 6.51096702e-02f, 4.48942883e-03f, 2.55513042e-02f,
  -1.69448014e-02f, -1.95984133e-02f, -1.87500581e-01f, -8.10997039e-02f, -9.21990499e-02f, -8.92394856e-02f, -5.52108809e-02f, -1.78309917e-01f, -9.39889178e-02f, -4.03589047e-02f,
  1.36827052e-01f, -4.21306901e-02f, -1.63140818e-01f, -4.75624064e-03f, -4.83499914e-02f, -1.43776655e-01f, -8.67811888e-02f, -1.73647746e-01f, -1.10326543e-01f, -4.21111658e-02f,
  3.98982838e-02f, -1.38019153e-03f, -2.28831475e-03f, -2.05657743e-02f, 7.40391985e-02f, -4.41740155e-02f, -4.27022129e-02f, -1.41005395e-02f, -5.29553033e-02f, -2.30923034e-02f,
  -9.57712531e-03f, -4.29233983e-02f, -4.42019664e-02f, 6.62522798e-05f, -4.42445204e-02f, 7.91738182e-03f, 7.05489237e-03f, -6.16568923e-02f, 1.51271736e-02f, -1.12307481e-01f,
  -7.68083483e-02f, 5.13953716e-02f, 2.25662552e-02f, 9.98819545e-02f, 9.00741573e-03f, -7.98661485e-02f, -1.85795221e-02f, 3.19630466e-02f, -2.28506252e-02f, 1.23719268e-01f,
  3.37188095e-02f, 7.93461800e-02f, 3.55777480e-02f, 1.37453657e-02f, 8.82951822e-03f, 8.71743113e-02f, 2.86799781e-02f, -6.09503128e-02f, 8.00607428e-02f, 3.94676141e-02f,
  3.57129090e-02f, -6.82368428e-02f, -5.61382510e-02f, -1.44609576e-02f, 4.23392616e-02f, -3.84225026e-02f, -8.67092162e-02f, -3.78438570e-02f, -4.57507856e-02f, -1.18018582e-01f,
  2.25672796e-01f, 9.74150747e-02f, -1.24709802e-02f, 2.79582012e-02f, -2.75705811e-02f, -9.46843326e-02f, -2.30612569e-02f, -2.98441537e-02f, 2.30615237e-03f, 5.15361875e-02f,
  3.05580478e-02f, 1.04486711e-01f, 7.33907297e-02f, 1.02687642e-01f, -8.13928898e-03f, 9.06382352e-02f, -7.51745105e-02f, 3.57228853e-02f, 2.17030793e-02f, 7.81160295e-02f,
  -6.33840039e-02f, -1.71216484e-02f, -1.43877700e-01f, -1.02607489e-01f, -9.54470858e-02f, -3.86514366e-02f, 1.21040553e-01f, -1.06812799e-02f, 1.53585225e-02f, -1.25654116e-01f,
  -3.74261916e-01f, -1.05813637e-01f, -1.94568232e-01f, -1.93729043e-01f, 1.58362910e-02f, 1.24042295e-02f, -2.86862571e-02f, -1.44372195e-01f, -3.98855656e-01f, 8.67034495e-02f,
  1.30408660e-01f, -9.91103277e-02f, 5.83887771e-02f, 1.40470564e-01f, 5.67374565e-02f, 5.74637158e-03f, -3.89438285e-03f, 7.66569823e-02f, -9.40217152e-02f, -1.41453370e-01f,
  -3.31967622e-02f, 1.74992085e-01f, 1.56007394e-01f, 1.42839313e-01f, 2.19778661e-02f, 8.16691443e-02f, 2.59936750e-01f, 1.34524196e-01f, 2.31128171e-01f, 2.16182306e-01f,
  -4.58619595e-02f, -7.72406161e-02f, 8.60554725e-03f, -5.27119040e-02f, 5.24138995e-02f, 1.13476247e-01f, 1.24765731e-01f, 1.55212209e-01f, 1.20257009e-02f, 3.02406587e-02f,
  4.49505746e-02f, 8.58486220e-02f, -4.89942469e-02f, 6.81132972e-02f, -9.65170488e-02f, -8.31869319e-02f, -1.48476243e-01f, -1.42540485e-01f, -6.17713854e-02f, -5.25814779e-02f,
  -1.01116017e-01f, 1.76824033e-02f, 1.30949058e-02f, 1.05935028e-02f, -7.63735995e-02f, -8.83912295e-02f, -2.47334260e-02f, 6.94279149e-02f, 1.19893523e-02f, -5.54133207e-02f,
  -2.25393865e-02f, 3.35088708e-02f, 1.15986057e-01f, 5.45675382e-02f, -1.72471534e-02f, -4.82167415e-02f, -3.59559767e-02f, 5.67604266e-02f, 3.87319289e-02f, -9.18498076e-03f,
  -2.49706116e-02f, -9.48871002e-02f, -3.63605563e-03f, -9.93420333e-02f, -7.84822926e-02f, 2.42729783e-02f, -7.11386185e-03f, 1.16957650e-01f, -1.51301268e-02f, -1.49468323e-02f,
  4.08645682e-02f, 7.32400939e-02f, -9.85478237e-03f, 3.89267839e-02f, 7.09168911e-02f, -6.09712489e-02f, -1.00587286e-01f, -2.10849345e-02f, -7.25879287e-03f, 9.79912579e-02f,
  -2.89073642e-02f, 9.27200019e-02f, -3.14448215e-02f, -8.93109757e-03f, -2.39899978e-02f, 7.36331288e-03f, -1.33306393e-03f, -3.78835388e-02f, 5.81409074e-02f, -1.21146571e-02f,
  1.57459583e-02f, -9.73086432e-03f, 2.06063893e-02f, -1.28448475e-02f, -2.81084310e-02f, 3.90588562e-03f, 1.14649579e-01f, 3.34366178e-03f, -1.16312196e-02f, -1.59647372e-02f,
  3.32750119e-02f, 4.07268479e-02f, 3.33453366e-03f, 1.65962297e-02f, -1.17923521e-01f, 3.46462913e-02f, -6.20934293e-02f, -2.91236844e-02f, 8.08115005e-02f, 1.95066761e-02f,
  7.76810274e-02f, -1.02541782e-02f, -7.02889040e-02f, 6.46942183e-02f, -1.48985028e-01f, -9.88001376e-02f, -1.44914046e-01f, -1.36853486e-01f, 2.12537095e-01f, 5.43560833e-02f,
  -6.09447658e-02f, -1.16045224e-02f, 1.54814541e-01f, 2.82387696e-02f, 2.28025392e-01f, 1.40099138e-01f, -9.17727277e-02f, -1.47282436e-01f, 5.32685127e-03f, 2.98031233e-02f,
  5.04777692e-02f, 7.45766833e-02f, -3.50189768e-02f, -1.46658376e-01f, -1.46929860e-01f, -6.25940487e-02f, -1.05767123e-01f, -8.08829293e-02f, -1.83862567e-01f, -5.74247986e-02f,
  4.79307175e-02f, 2.00893253e-01f, -2.18620151e-02f, 1.23566091e-01f, 8.57347399e-02f, -1.00097492e-01f, -2.98801251e-02f, 1.01338737e-01f, 3.16107124e-02f, 4.25400548e-02f,
  -7.01267570e-02f, 2.27522090e-04f, 7.99745694e-02f, 1.22010753e-01f, -7.12791458e-02f, 5.56610152e-02f, 8.12677667e-03f, -8.94617885e-02f, -1.05433010e-01f, -1.26899714e-02f,
  -7.57876933e-02f, -1.33528421e-02f, -6.48736283e-02f, -4.15832661e-02f, 1.63648725e-02f, 4.44095060e-02f, -6.26968145e-02f, -7.69459009e-02f, -1.05233610e-01f, -1.78229790e-02f,
  -7.66029879e-02f, 4.09869757e-03f, 8.19051862e-02f, 1.49189411e-02f, 1.11107878e-01f, 1.43012673e-01f, 7.62376040e-02f, -2.72973850e-02f, 4.74004261e-02f, -2.21276619e-02f,
  -1.98098551e-02f, -6.20817672e-03f, -1.64372753e-02f, 3.82719599e-02f, -6.66502789e-02f, 9.67996493e-02f, -3.46077681e-02f, 5.27359359e-02f, 9.13734082e-03f, -5.51176481e-02f,
  6.01866953e-02f, 3.04989759e-02f, 4.06874865e-02f, -6.89546093e-02f, -2.16686539e-02f, 6.93092942e-02f, -3.52371335e-02f, -8.20953213e-03f, 4.89739934e-03f, -6.50313273e-02f,
  1.47531286e-01f, 2.10238159e-01f, 1.06137939e-01f, 1.22607268e-01f, 5.08471727e-02f, -9.69667137e-02f, 5.50783277e-02f, 8.40367284e-03f, -3.63880694e-02f, 7.61764199e-02f,
  -2.11416129e-02f, -6.01039343e-02f, 1.18633710e-01f, 2.39900097e-01f, -1.00761391e-02f, 6.20498545e-02f, 5.23263030e-02f, 2.10215729e-02f, -9.43403617e-02f, 6.46118447e-03f,
  -1.31936550e-01f, 1.33978471e-01f, -2.34259553e-02f, -8.92291740e-02f, -1.09138377e-01f, -4.22607958e-02f, -2.39543617e-02f, -7.23703392e-03f, -7.42719769e-02f, -6.37006992e-03f,
  8.09343085e-02f, -2.00423449e-01f, 1.27293631e-01f, 1.44064233e-01f, -2.65028059e-01f, -2.57678509e-01f, 1.55760217e-02f, -1.80319160e-01f, 8.15346017e-02f, -9.95939001e-02f,
  6.16317540e-02f, 1.30914718e-01f, 2.68845230e-01f, -1.35439485e-01f, 2.77171552e-01f, 2.59540856e-01f, -1.83869973e-01f, -1.26484901e-01f, 1.46518126e-01f, 3.90171148e-02f,
  7.08876997e-02f, -2.13554680e-01f, -2.64700013e-03f, -2.97475368e-01f, -1.69034839e-01f, -4.79520112e-02f, -3.54043022e-02f, 6.91683590e-02f, -1.78711951e-01f, -4.76740301e-02f,
  -5.60603812e-02f, 9.13072675e-02f, 6.99522719e-02f, 3.68303470e-02f, -1.68248676e-02f, -4.01515402e-02f, -2.61014979e-02f, 1.69504415e-02f, 5.36863580e-02f, 4.79254080e-03f,
  -1.06911972e-01f, 1.43051464e-02f, -4.27477434e-02f, 6.67952746e-02f, -9.77205709e-02f, -7.96849802e-02f, -3.98361087e-02f, -1.55790627e-01f, -1.30318165e-01f, 1.66885197e-01f,
  3.78093421e-02f, -1.28976583e-01f, -1.47417292e-01f, -1.31587848e-01f, 2.41724513e-02f, -5.44874668e-02f, -7.86143839e-02f, -5.84656224e-02f, -1.29352108e-01f, -1.89945683e-01f,
  1.48860747e-02f, -5.18838018e-02f, -9.34487805e-02f, 3.18107493e-02f, 7.93724805e-02f, 1.03788771e-01f, -5.06152548e-02f, -1.71440188e-02f, 9.51994136e-02f, 5.56348003e-02f,
  4.87962440e-02f, 7.17136338e-02f, 3.24525125e-03f, -1.40485251e-02f, -1.24208838e-01f, 1.88768227e-02f, 2.91599315e-02f, 8.16784129e-02f, 1.20468222e-01f, 7.12171793e-02f,
  9.50598046e-02f, 4.78472188e-03f, 7.43173063e-02f, -1.38572231e-01f, -6.11076504e-02f, -1.27130030e-02f, -4.17064317e-02f, 7.00468477e-03f, -5.97606879e-03f, -8.64177197e-02f,
  -3.53185833e-02f, 4.23341393e-02f, 1.70693193e-02f, -7.05328435e-02f, 7.86482766e-02f, -6.47178292e-02f, -1.82032846e-02f, -9.32662785e-02f, -1.22867450e-02f, -7.81334471e-03f,
  -8.23019072e-02f, -8.16670135e-02f, -2.85556093e-02f, 1.04533583e-01f, -1.28131717e-01f, -4.89754938e-02f, 5.16063049e-02f, 1.82459969e-03f, -8.66397992e-02f, 1.71331838e-01f,
  -1.37738675e-01f, -1.09238699e-01f, -1.81179002e-01f, -1.63773909e-01f, -1.14134826e-01f, -2.00068466e-02f, -6.70202971e-02f, -8.66585746e-02f, -1.48795703e-02f, -7.88916349e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.20489888e-01f, -1.72033191e-01f, 1.38807252e-01f, -8.89120400e-02f, 8.39554593e-02f, -6.53499439e-02f, 8.86124000e-02f, -1.61310703e-01f, -2.72971243e-01f, -2.53688097e-01f,
  6.28814921e-02f, 1.74024999e-01f, 2.20778763e-01f, -1.70171097e-01f, 4.02674824e-01f, 1.09022297e-01f, -1.80878758e-01f, 1.39623880e-02f, -6.53931424e-02f, -7.55522922e-02f,
  -7.35146329e-02f, -2.09118024e-01f, 1.68676913e-01f, -1.93354085e-01f, -9.96109098e-02f, -1.37277186e-01f, 1.28185004e-01f, 7.89302737e-02f, -1.05702080e-01f, 5.44221699e-02f,
  5.90471877e-03f, -2.00405851e-01f, 1.35159679e-02f, 3.75533104e-02f, -1.29890844e-01f, 2.81601259e-03f, 7.62051940e-02f, 8.00855756e-02f, 4.26320955e-02f, -1.45567879e-02f,
  -1.23105682e-02f, -2.08284650e-02f, -8.62272233e-02f, 6.43752515e-02f, -5.35987392e-02f, -5.38296513e-02f, -7.20760077e-02f, -3.47460583e-02f, 6.36661611e-03f, 5.78890853e-02f,
  5.48455911e-03f, 5.57593219e-02f, -1.31785236e-02f, 3.64084244e-02f, 2.84835324e-02f, -1.20568862e-02f, 5.12686223e-02f, 1.28670216e-01f, -3.66238728e-02f, -8.40614513e-02f,
  -1.43928707e-01f, -2.71325931e-02f, 1.37604750e-03f, 7.79570937e-02f, -2.17400584e-02f, -2.38659978e-02f, 3.71491648e-02f, 1.00963503e-01f, -6.21565953e-02f, 1.32866465e-02f,
  -4.85585816e-02f, 7.14121014e-02f, 4.28019427e-02f, -4.15341072e-02f, -1.28619000e-01f, -2.37993896e-02f, 6.59604520e-02f, 1.06847666e-01f, -6.96361586e-02f, 3.05373520e-02f,
  1.25760689e-01f, 6.92294165e-02f, -6.50670379e-02f, 9.37871784e-02f, -5.31313717e-02f, -9.30083450e-03f, -1.52326487e-02f, -8.52194503e-02f, 6.89836890e-02f, 2.68935654e-02f,
  5.86080998e-02f, -2.11668819e-01f, 5.10342829e-02f, 6.93326592e-02f, 6.24332018e-02f, -5.21121398e-02f, -5.42085618e-02f, -3.66981104e-02f, 8.81928205e-03f, -8.39734748e-02f,
  2.20683515e-02f, 8.26189946e-03f, -7.89777860e-02f, 1.44704692e-02f, 2.27665696e-02f, 6.36931062e-02f, 2.90415268e-02f, 1.41136885e-01f, 6.89399242e-02f, 6.98769987e-02f,
  -2.39028293e-03f, -6.61501288e-02f, -1.39329862e-02f, -1.41026154e-01f, -1.05232894e-02f, 9.39409807e-02f, 3.64466794e-02f, -3.57300825e-02f, -5.20995166e-03f, -3.18364911e-02f,
  1.79735661e-01f, -4.61710274e-01f, -9.97715667e-02f, 1.00235857e-01f, 2.79529303e-01f, 1.67348124e-02f, 8.08779895e-02f, -4.04291078e-02f, -1.30785733e-01f, -2.21831962e-01f,
  -4.70408387e-02f, 9.79910865e-02f, -1.70472473e-01f, -5.84086925e-02f, 2.54255444e-01f, -1.70707062e-01f, 3.39888372e-02f, 5.05759344e-02f, -7.27947382e-03f, -3.66010070e-02f,
  9.86299068e-02f, 1.84520096e-01f, 7.80010447e-02f, -6.83376342e-02f, 1.39276395e-02f, -3.73127982e-02f, 4.50858399e-02f, 4.98461463e-02f, 1.45709828e-01f, 1.78425208e-01f,
  -4.78732996e-02f, -1.32928696e-02f, 6.93026334e-02f, -3.35558169e-02f, -3.05760931e-02f, -7.81589895e-02f, -3.88780572e-02f, 8.32086951e-02f, 7.55659416e-02f, 1.42434118e-02f,
  -1.14495661e-02f, 7.04057366e-02f, 3.92198414e-02f, -1.10119823e-02f, -3.78485471e-02f, -4.35628742e-02f, 6.23559393e-02f, 1.26439612e-02f, -4.40415367e-02f, -3.92570272e-02f,
  3.60912606e-02f, -1.48428269e-02f, -1.55724064e-02f, 4.31290269e-02f, -3.09304247e-04f, 7.79639706e-02f, 3.36108916e-02f, 6.04850538e-02f, -4.89623323e-02f, 5.50066829e-02f,
  -3.49753816e-03f, 5.92622273e-02f, 6.56197313e-03f, 3.54418484e-03f, -8.79855901e-02f, -9.00935456e-02f, -4.54415493e-02f, -2.97848582e-02f, -8.99600238e-02f, -1.08370535e-01f,
  -5.26639558e-02f, 5.98015748e-02f, 2.81878952e-02f, 1.34016257e-02f, 7.63399899e-02f, 7.08500594e-02f, -1.35553600e-02f, -1.61514641e-03f, -1.02098100e-01f, -4.68500331e-02f,
  5.98406792e-03f, -9.30000693e-02f, -1.10703476e-01f, 9.35854986e-02f, 6.53794408e-03f, 5.14168739e-02f, -7.94131160e-02f, -1.08083390e-01f, -1.47330696e-02f, 7.17211980e-03f,
  -3.03488314e-01f, -3.12028289e-01f, 1.16799692e-05f, 5.09475134e-02f, -3.09091974e-02f, -9.11637172e-02f, 5.49989566e-03f, -1.26075710e-03f, -5.28070889e-02f, 6.61044046e-02f,
  1.82141468e-03f, 1.17707979e-02f, -9.28339511e-02f, 2.78217886e-02f, 1.36157110e-01f, -4.99888742e-03f, 7.93109909e-02f, 1.82628687e-02f, -2.20761765e-02f, -1.51162758e-01f,
  -4.18068469e-02f, -3.30030322e-02f, 6.20611794e-02f, 2.40512216e-03f, 9.54710878e-03f, 3.47167850e-02f, 9.70594399e-03f, 2.09910795e-02f, -1.97647978e-02f, -5.75683676e-02f,
  -6.24710441e-01f, 2.94697553e-01f, -1.04769118e-01f, -1.77432865e-01f, 2.85241511e-02f, -2.56222755e-01f, -1.87977225e-01f, 8.00017864e-02f, 1.13700628e-01f, 1.03204243e-01f,
  2.77341087e-03f, 3.21520381e-02f, 1.37085006e-01f, -1.31122442e-02f, -2.03377917e-01f, 1.25322253e-01f, -2.06874803e-01f, -1.55142751e-02f, 4.47058585e-03f, -6.94004819e-02f,
  2.70717759e-02f, -5.09565659e-02f, -1.05682746e-01f, 6.49577454e-02f, -4.77844551e-02f, -9.66373086e-02f, -1.68303385e-01f, 5.56649491e-02f, -1.49288684e-01f, 1.11029334e-01f,
  -2.36474618e-01f, -1.27159864e-01f, -5.27985208e-02f, -1.33235976e-01f, -2.06334338e-01f, -1.17763869e-01f, 2.98256911e-02f, -8.41516331e-02f, 5.49051426e-02f, 5.07157072e-02f,
  -5.22004105e-02f, 5.76525852e-02f, -1.79219041e-02f, 6.22287616e-02f, -7.36438408e-02f, 7.53583834e-02f, -5.37827201e-02f, -5.45629188e-02f, -3.71253528e-02f, 1.43360496e-01f,
  6.68250248e-02f, 5.38571514e-02f, -6.64331615e-02f, -2.16233004e-02f, -4.67819944e-02f, -3.96267287e-02f, -1.18436970e-01f, -1.03886731e-01f, -5.26380017e-02f, -5.18495291e-02f,
  2.82654557e-02f, -7.89006501e-02f, 1.00495783e-03f, 3.20862979e-02f, 1.05871193e-01f, 1.51487857e-01f, 4.41994006e-03f, -6.35242742e-03f, -1.06388122e-01f, -8.41918215e-02f,
  2.38882285e-02f, -5.87275289e-02f, -1.03838317e-01f, -1.17393501e-01f, -1.81178357e-02f, 4.11729217e-02f, -4.33561951e-02f, -1.92887913e-02f, -1.34675084e-02f, -5.92627227e-02f,
  6.22366704e-02f, 1.57314911e-02f, 5.41136088e-03f, -5.41557260e-02f, 2.91147884e-02f, -2.28827987e-02f, 6.35411069e-02f, -1.46006774e-02f, 6.62913686e-03f, -7.14964494e-02f,
  -4.84118432e-01f, -4.38836277e-01f, -7.05939159e-02f, -6.05959743e-02f, 9.22047868e-02f, -7.80687332e-02f, -1.74071249e-02f, -5.79938777e-02f, -5.75347617e-02f, -5.95560037e-02f,
  -1.08350247e-01f, -5.53532280e-02f, -7.94097036e-02f, -6.20014630e-02f, 1.06415369e-01f, -3.04144528e-02f, -6.19250163e-02f, 3.41906436e-02f, -1.02528758e-01f, 3.67145613e-02f,
  3.15901265e-02f, 1.16200119e-01f, -2.55139098e-02f, -3.08803823e-02f, -2.24499535e-02f, -1.16207287e-01f, -2.61204969e-02f, 5.67221418e-02f, -1.75261542e-01f, -4.70874757e-02f,
  -3.38252842e-01f, -3.88567448e-02f, -1.05238371e-01f, -2.56410837e-01f, 1.81451276e-01f, 8.90066996e-02f, -6.38076439e-02f, 9.97988731e-02f, -9.02667195e-02f, 9.32015106e-02f,
  7.09059089e-02f, -2.16237396e-01f, 4.86157462e-02f, -3.17019135e-01f, -3.21483493e-01f, -2.92740673e-01f, -3.78191829e-01f, -1.66850179e-01f, -1.60297289e-01f, -5.32091334e-02f,
  -1.61741883e-01f, -2.38425061e-02f, -2.01030120e-01f, 1.97562695e-01f, 3.53062414e-02f, 1.00248434e-01f, 1.41085550e-01f, 1.86448827e-01f, -9.77896377e-02f, -8.69750511e-03f,
  -4.85112630e-02f, 1.96169466e-02f, 8.60910714e-02f, -2.59122979e-02f, 5.31704761e-02f, 8.12235102e-02f, 3.67291719e-02f, 1.30938273e-02f, -1.36490902e-02f, -7.47627541e-02f,
  -5.49914204e-02f, 2.28213798e-02f, 2.49090735e-02f, -1.15001798e-02f, 5.57212457e-02f, -6.73603192e-02f, -8.24081376e-02f, -3.61427367e-02f, 2.11067200e-02f, -1.15249939e-01f,
  -6.74425811e-02f, -9.90166664e-02f, -1.21000350e-01f, -7.30978847e-02f, -3.99883315e-02f, 2.70290417e-03f, -6.70751780e-02f, -1.73473395e-02f, -5.66104725e-02f, -4.32931408e-02f,
  -2.34530307e-02f, 1.05014071e-01f, -1.40097737e-01f, -4.33635600e-02f, -2.85280272e-02f, 2.03846097e-02f, 1.48065807e-02f, 6.39900044e-02f, 4.79725219e-04f, 7.21225282e-03f,
  -4.01149057e-02f, 1.17257116e-02f, 5.39760813e-02f, -5.35163237e-03f, -3.39630656e-02f, 7.87040591e-02f, 3.40640806e-02f, -9.10190716e-02f, -2.90066400e-03f, -2.02376917e-02f,
  8.14392865e-02f, 2.33518891e-02f, -9.73719172e-03f, -7.79918060e-02f, 5.89140467e-02f, -2.75164917e-02f, -9.09612235e-03f, -2.75382176e-02f, 6.62811399e-02f, -5.46691082e-02f,
  4.80016731e-02f, 8.29581693e-02f, 2.75983289e-02f, 6.47419423e-04f, 2.40564737e-02f, -3.13107371e-02f, -2.93696206e-02f, -1.62823573e-01f, 1.68447737e-02f, 6.76387921e-02f,
  1.16664777e-03f, -9.70281474e-03f, -1.86819918e-02f, 2.70362031e-02f, 3.00956294e-02f, 6.02946468e-02f, 4.66893502e-02f, -2.86637135e-02f, 2.83949710e-02f, 4.47815284e-02f,
  6.66511208e-02f, -8.72246698e-02f, -1.87024266e-01f, -4.18595411e-02f, 1.89321712e-02f, 1.14074619e-02f, 5.94347417e-02f, 1.48821678e-02f, -8.84680077e-02f, -4.43618931e-02f,
  1.71805874e-01f, -1.42551735e-01f, -1.64526358e-01f, -1.44128442e-01f, -5.10251857e-02f, -6.12690188e-02f, -1.98720858e-01f, -5.73936030e-02f, -1.12089820e-01f, 6.64313734e-02f,
  -3.14632319e-02f, -4.28013206e-02f, -1.40390679e-01f, -2.31899340e-02f, -1.00813061e-01f, -4.31430973e-02f, -6.54046759e-02f, 1.52743449e-02f, 6.88289404e-02f, 1.86360888e-02f,
  1.73644096e-01f, 3.75794210e-02f, -2.16304827e-02f, 6.04643300e-02f, -1.62032768e-02f, 9.08379853e-02f, 8.28301832e-02f, -1.85571983e-02f, 1.03214324e-01f, 1.20217316e-02f,
  2.81847436e-02f, -2.77773943e-02f, -7.60974586e-02f, 2.15376355e-02f, -3.71164717e-02f, 4.70293872e-02f, 1.61543023e-03f, -5.08253882e-03f, 1.34636099e-02f, -1.19643621e-02f,
  -8.83285031e-02f, 5.10333180e-02f, -5.41434772e-02f, -2.37461496e-02f, 1.25674251e-02f, -4.66038473e-02f, 4.04036716e-02f, -8.35812762e-02f, -8.46040100e-02f, -2.02920716e-02f,
  -1.04977474e-01f, -5.93591668e-02f, 6.59984276e-02f, -8.63644555e-02f, -3.49053070e-02f, -3.97567563e-02f, -4.80580181e-02f, -5.05157523e-02f, -3.04847136e-02f, 1.27506536e-02f,
  5.36484681e-02f, 1.18473329e-01f, -1.68385040e-02f, -6.54955953e-02f, 7.70444935e-03f, -1.07255392e-02f, -8.17404035e-03f, -4.17723767e-02f, -2.95286346e-02f, -6.51195422e-02f,
  5.52453138e-02f, -5.60634993e-02f, -1.72267258e-02f, 1.26726270e-01f, 8.67729187e-02f, 3.43927182e-02f, -6.94021629e-03f, 4.16710339e-02f, -2.35737488e-03f, -8.89832377e-02f,
  -3.97383794e-03f, 1.06153272e-01f, -3.35654095e-02f, -1.33894950e-01f, 3.42963710e-02f, 6.30158707e-02f, 1.38992846e-01f, 9.46864709e-02f, 4.65689115e-02f, 1.35781867e-02f,
  -5.60616776e-02f, 2.84321606e-03f, -5.24694324e-02f, -3.10553163e-02f, -1.10364959e-01f, 1.69835631e-02f, -1.11800328e-01f, -2.46062428e-02f, 3.79796773e-02f, 3.75567451e-02f,
  3.70718017e-02f, -2.23278143e-02f, 4.65460215e-03f, 7.33526275e-02f, -8.14930126e-02f, -4.80023362e-02f, 1.44529581e-01f, -5.33137321e-02f, -7.28348270e-02f, 3.88551541e-02f,
  -4.53762673e-02f, -2.84679160e-02f, -1.16204703e-02f, -1.78267196e-01f, -4.24247533e-02f, -8.22504684e-02f, 1.59301283e-03f, 4.18877266e-02f, -1.16061121e-02f, -4.12888788e-02f,
  -1.83390975e-01f, -5.73857315e-02f, -2.79782265e-01f, -1.16532728e-01f, -6.75752433e-03f, -3.29509944e-01f, -1.68591425e-01f, -1.32089317e-01f, 9.48229507e-02f, 2.44050309e-01f,
  5.18493019e-02f, -6.72182962e-02f, 2.65865296e-01f, -1.10623792e-01f, -3.09153289e-01f, 1.59325108e-01f, -1.70968637e-01f, -9.93476063e-02f, 1.16189115e-01f, -3.63424644e-02f,
  -1.45600587e-01f, 3.75725403e-02f, -1.87845901e-01f, 1.29095599e-01f, -1.04757376e-01f, -2.71908902e-02f, 1.31714672e-01f, -5.38897589e-02f, -2.12919384e-01f, -6.28258511e-02f,
  -1.70707792e-01f, -1.38350762e-02f, -4.78558540e-02f, -1.06399633e-01f, -1.56488180e-01f, -2.51357500e-02f, -8.46954063e-02f, -2.09789965e-02f, 8.22098255e-02f, -6.69981986e-02f,
  3.16182375e-02f, 1.38075441e-01f, -2.02112831e-02f, 1.62023768e-01f, 4.05201837e-02f, 3.34059820e-02f, 8.44290247e-04f, -2.07702629e-02f, -1.52644617e-02f, -1.17827788e-01f,
  -1.01894259e-01f, -1.11562453e-01f, -1.18080592e-02f, 4.87043895e-02f, -5.53435721e-02f, -2.47954316e-02f, -5.85192069e-02f, -8.07536468e-02f, -7.68465102e-02f, -4.30743173e-02f,
  1.69414636e-02f, -4.57879603e-02f, -1.32467046e-01f, 3.16022821e-02f, -3.88258696e-03f, -2.18840167e-02f, -6.85299933e-02f, -5.48145398e-02f, 2.69521400e-03f, 1.32397460e-02f,
  -4.40391421e-04f, -1.66770071e-02f, -2.14059670e-02f, -2.66604908e-02f, 1.55911585e-02f, 3.40711251e-02f, -4.71838489e-02f, 2.88676308e-03f, -3.60374362e-03f, -1.24290995e-01f,
  1.58859566e-02f, -5.00121601e-02f, 1.86167646e-03f, 5.89241348e-02f, 2.98811030e-02f, -5.54805622e-03f, 8.30753241e-03f, -3.80741768e-02f, -1.89780146e-02f, 3.55099477e-02f,
  -9.21808779e-02f, -1.65254876e-01f, 1.15070492e-02f, -1.37678180e-02f, 7.11737666e-03f, 2.17816215e-02f, -5.94760515e-02f, -2.27467529e-02f, 2.88969986e-02f, -4.84767789e-03f,
  -3.66403982e-02f, 7.29205012e-02f, 1.65827889e-02f, 8.71233866e-02f, 1.10529542e-01f, -1.06502414e-01f, 1.00242287e-01f, 5.01379855e-02f, -8.49445909e-02f, -1.11686379e-01f,
  -8.10823441e-02f, 3.59434187e-02f, 1.58014551e-01f, 3.61004472e-02f, 5.20554297e-02f, 5.46377413e-02f, -2.60790326e-02f, 1.59875471e-02f, 4.35818080e-03f, -1.90234017e-02f,
  1.69986725e-01f, -2.69951880e-01f, -8.61345232e-02f, -2.06848159e-01f, 2.44668368e-02f, -1.60174012e-01f, -1.22385018e-01f, -2.45854646e-01f, -1.87366411e-01f, -2.15270624e-01f,
  -1.35672227e-01f, 7.98569769e-02f, 7.76923522e-02f, -2.15798095e-01f, 3.60988140e-01f, 1.08434483e-01f, -1.85393497e-01f, 1.30845020e-02f, 4.11697477e-02f, -2.32799679e-01f,
  3.23541015e-02f, -1.37358159e-01f, -4.19876399e-03f, -2.33656511e-01f, -2.84142494e-01f, -1.89868733e-01f, 1.58252180e-01f, -2.06749537e-03f, -3.72299887e-02f, 1.09818272e-01f,
  -9.96056125e-02f, -7.29193119e-03f, -6.11567497e-02f, 6.99276626e-02f, -3.94196585e-02f, 6.43071113e-03f, 3.37125510e-02f, 8.41304585e-02f, 4.88844514e-02f, 7.61391371e-02f,
  3.91913578e-02f, 8.90897065e-02f, -6.51302114e-02f, 2.17498187e-02f, -6.83824793e-02f, 2.80256812e-02f, 3.19453031e-02f, 1.95603855e-02f, -5.49296141e-02f, 3.21453065e-02f,
  -1.05014350e-02f, 5.99138923e-02f, -4.02508378e-02f, 9.16100740e-02f, 4.00502197e-02f, -1.16526820e-02f, 6.20217575e-03f, 2.69085970e-02f, 5.10013439e-02f, 6.82040006e-02f,
  -4.03939225e-02f, 4.73059975e-02f, 5.64991916e-03f, 1.73586402e-02f, -3.32780741e-02f, -1.07878998e-01f, -2.49244813e-02f, -6.76563978e-02f, -2.30366122e-02f, 2.47770231e-02f,
  -4.38870117e-02f, -1.95216611e-02f, -6.61230162e-02f, -7.40650222e-02f, 5.79080544e-02f, -3.59457103e-03f, 4.93962765e-02f, 2.01987680e-02f, -7.39593059e-02f, 6.29680976e-02f,
  1.07242562e-01f, -2.26666150e-03f, -2.21182499e-02f, 1.37126716e-02f, -7.03554153e-02f, -4.07639071e-02f, 1.53043484e-02f, 1.16665345e-02f, 2.82814670e-02f, 6.62378073e-02f,
  -6.23896606e-02f, -8.86601061e-02f, -1.07671775e-01f, -3.05804759e-02f, -2.01622527e-02f, 9.51939821e-03f, -1.33105526e-02f, -4.30552289e-02f, 7.23723555e-03f, -6.92172348e-02f,
  7.38293678e-03f, -4.49943133e-02f, 2.62774713e-02f, -6.14645928e-02f, 8.04397464e-03f, -1.09238386e-01f, 6.28033802e-02f, 3.93783413e-02f, 2.35427804e-02f, -2.17139814e-02f,
  5.61399199e-02f, 4.40762052e-03f, 7.10584000e-02f, 5.17713791e-03f, -1.20429201e-02f, 1.25308946e-01f, 6.30722614e-03f, 1.43640265e-02f, 7.82487690e-02f, 1.76527817e-02f,
  -2.21521452e-01f, 3.28913212e-01f, -1.46079853e-01f, 1.13730095e-01f, -1.43052027e-01f, 3.57375711e-01f, 4.08501893e-01f, -6.39888868e-02f, 1.68294892e-01f, 3.53177279e-01f,
  1.09860472e-01f, 7.98276290e-02f, 1.47439718e-01f, 2.34139428e-01f, -1.70907360e-02f, 1.74820155e-01f, 2.07346916e-01f, 2.62532324e-01f, -1.53588783e-02f, -4.46393676e-02f,
  -4.66013364e-02f, 1.90654188e-01f, -4.80040982e-02f, -1.01699486e-01f, -1.25729218e-01f, -1.66507483e-01f, -1.30947143e-01f, -1.85784668e-01f, 6.84560910e-02f, 5.80106229e-02f,
  4.93972264e-02f, -4.85752486e-02f, 5.57150412e-03f, -3.54418829e-02f, -4.89997081e-02f, 3.79134715e-02f, 8.08192715e-02f, -1.62170395e-01f, -9.74186361e-02f, 2.70539313e-03f,
  7.52669154e-03f, -1.56484451e-02f, 8.21913034e-02f, -4.04421426e-02f, -1.10169865e-01f, -6.54736757e-02f, -2.23726127e-02f, -7.83259198e-02f, -2.81673446e-02f, -7.37302825e-02f,
  -1.12123251e-01f, -1.05306499e-01f, -5.08404970e-02f, 7.48508796e-02f, -5.28678112e-02f, 3.34257595e-02f, 3.56854126e-02f, -1.23102013e-02f, 4.88441028e-02f, 2.04680078e-02f,
  3.97560969e-02f, 7.39575699e-02f, -4.08843253e-03f, 3.12554762e-02f, 7.26926839e-03f, -1.23072453e-02f, -3.44915874e-02f, -2.09453199e-02f, -9.72315436e-04f, -2.50462573e-02f,
  1.96390040e-02f, 2.33355556e-02f, -2.76457481e-02f, -1.06115155e-02f, 7.25465119e-02f, 7.37933442e-02f, -6.70247972e-02f, 7.18796849e-02f, 4.74638641e-02f, 5.09302830e-03f,
  3.87304202e-02f, 1.01771235e-01f, 6.17386252e-02f, 5.02314530e-02f, -1.41784446e-02f, -4.20904718e-02f, -4.96753026e-03f, -5.07466085e-02f, 1.12046666e-01f, -5.20778820e-02f,
  1.97570324e-01f, 2.06701770e-01f, 9.81788710e-02f, 6.86842576e-02f, -3.50115895e-02f, -1.55337647e-01f, -5.55245802e-02f, -3.03469989e-02f, 1.21574074e-01f, 7.42447283e-03f,
  -4.64563407e-02f, 9.59013477e-02f, 7.14934291e-03f, -1.96704548e-03f, -6.10947460e-02f, 1.18756972e-01f, 8.32983702e-02f, 7.72545263e-02f, 4.23184261e-02f, -6.63983682e-03f,
  -9.39433873e-02f, -3.53303887e-02f, -2.12683827e-02f, 3.63210998e-02f, -9.65874083e-03f, -7.17619285e-02f, 8.79818797e-02f, -5.17755374e-02f, -1.10275887e-01f, 2.68303063e-02f,
  1.13394886e-01f, -2.49972433e-01f, 1.44616850e-02f, 3.40407073e-01f, 2.04496011e-01f, -2.20158786e-01f, -9.57587063e-02f, 1.65297449e-01f, 1.91424891e-01f, -1.81234792e-01f,
  1.24033336e-02f, -2.34290838e-01f, -2.19515607e-01f, 6.57653436e-02f, 9.71490219e-02f, -1.00127108e-01f, 9.40509513e-02f, -6.87614977e-02f, 1.16582803e-01f, 6.03969432e-02f,
  2.42537200e-01f, 1.47563577e-01f, 2.54210029e-02f, 9.79771465e-02f, 1.21241830e-01f, 1.73893124e-01f, 1.84435487e-01f, -1.06087029e-01f, 1.21031933e-01f, -1.87690839e-01f,
  -5.10023758e-02f, 1.13762058e-01f, 2.09644269e-02f, -2.24849745e-03f, 3.09178270e-02f, -3.65065895e-02f, -2.49401033e-02f, -4.28677388e-02f, 1.22753894e-02f, -3.29112215e-03f,
  -4.92768809e-02f, 6.61140457e-02f, 7.80281201e-02f, 3.54175363e-03f, 1.83981732e-02f, 1.22806825e-01f, 1.35083959e-01f, 1.38240591e-01f, 4.60566655e-02f, -9.71532147e-03f,
  9.80548486e-02f, 4.29140171e-03f, -2.97920350e-02f, -6.31553645e-04f, -7.83676002e-03f, 2.12336052e-02f, 3.05290129e-02f, -6.18314222e-02f, -1.45862456e-02f, 8.99600089e-02f,
  -1.02334425e-01f, -8.77452493e-02f, -6.76753148e-02f, 4.05687420e-03f, -2.19216030e-02f, 8.95643309e-02f, 1.20951552e-02f, 2.99157575e-03f, -5.24632595e-02f, -2.78666560e-02f,
  9.95774753e-03f, -9.76681523e-03f, 5.06616198e-02f, 2.17747968e-02f, 2.80326307e-02f, 1.27375036e-01f, -5.01372777e-02f, 7.45914644e-03f, 3.64520289e-02f, -8.76425654e-02f,
  -1.58845969e-02f, 5.09148389e-02f, -1.37434155e-01f, 5.22650080e-03f, -5.31807430e-02f, -1.42047442e-02f, 6.78500086e-02f, -2.14884914e-02f, 5.44283688e-02f, -5.93785662e-04f,
  -1.37159213e-01f, -3.56485955e-02f, -1.10344484e-01f, -4.94358968e-03f, 4.40549515e-02f, 9.45071578e-02f, 3.50839384e-02f, -8.94999038e-03f, -8.87033045e-02f, 8.85628089e-02f,
  1.61770247e-02f, 8.45884308e-02f, -8.66169706e-02f, 1.66637748e-02f, -6.75019920e-02f, 7.42009133e-02f, 8.81611183e-03f, -2.11338941e-02f, -1.15348874e-02f, 5.09613603e-02f,
  -3.79115716e-02f, -1.29930645e-01f, 6.31950200e-02f, 8.47336650e-02f, 4.60358188e-02f, -7.29743987e-02f, -3.90670933e-02f, -3.30194123e-02f, 5.17205261e-02f, 5.57702631e-02f,
  2.46138781e-01f, -2.05496922e-01f, -1.10569395e-01f, -6.22264594e-02f, -6.04346506e-02f, -1.57864466e-01f, -7.50664622e-02f, -2.09725097e-01f, 6.34717122e-02f, -1.47288293e-01f,
  6.52120262e-03f, 2.00940609e-01f, 2.41081282e-01f, -2.17831224e-01f, 3.63054335e-01f, 1.50019035e-01f, -7.86258802e-02f, 4.83152978e-02f, 9.41815972e-02f, -4.76830900e-02f,
  6.37073210e-03f, -2.13373557e-01f, -1.04393058e-01f, -2.32047349e-01f, -2.67378181e-01f, -2.56242096e-01f, 1.09717986e-02f, 3.66673991e-02f, -2.40286127e-01f, -1.23883290e-02f,
  -5.16578034e-02f, -6.21770881e-03f, -8.96316245e-02f, 5.53216301e-02f, 3.63163315e-02f, -1.20599745e-02f, -9.32686627e-02f, 4.98950519e-02f, 1.01315208e-01f, 6.91485107e-02f,
  2.23960094e-02f, 1.39251677e-02f, -1.35007426e-01f, -1.03979530e-02f, 6.21599630e-02f, -1.20470086e-02f, 4.17001359e-02f, 1.44684045e-02f, -4.95341457e-02f, 5.74132465e-02f,
  6.87368661e-02f, 9.36610997e-02f, 5.17003238e-02f, -1.26365032e-02f, -1.55079248e-03f, -4.66162944e-03f, -3.93949300e-02f, 7.45515749e-02f, 5.79009354e-02f, 3.87126841e-02f,
  -2.31505409e-02f, 2.72879563e-02f, 1.16796196e-01f, -1.07411012e-01f, 3.58173475e-02f, -9.27225053e-02f, 4.29550707e-02f, -6.30646273e-02f, 6.89442009e-02f, 2.83099357e-02f,
  3.37439813e-02f, 2.50843912e-03f, -1.89850312e-02f, 3.75030078e-02f, -4.01904481e-03f, -2.65293829e-02f, 8.50270465e-02f, -1.61186717e-02f, 1.76057946e-02f, 1.07915578e-02f,
  -2.63518672e-02f, 1.36566628e-02f, 6.26880974e-02f, -8.81456733e-02f, 2.47783046e-02f, 5.07148840e-02f, -4.91161045e-05f, 3.34592387e-02f, -6.26922026e-02f, 5.19920066e-02f,
  -2.50812471e-02f, -4.97164987e-02f, 2.06873212e-02f, -4.04385757e-03f, -8.81912839e-03f, -3.67949307e-02f, -1.03099853e-01f, -6.01749830e-02f, 2.55898144e-02f, -6.76707178e-02f,
  -6.90743327e-02f, 2.22462397e-02f, 3.85700576e-02f, -3.87513638e-02f, 2.11103577e-02f, -1.10343680e-01f, 4.14818265e-02f, 1.13904402e-01f, 5.38128521e-03f, 3.16381902e-02f,
  8.53729323e-02f, 8.91976580e-02f, 9.10654441e-02f, 2.91517694e-02f, -1.94837302e-02f, 9.29092243e-02f, -4.94481996e-02f, 5.64590804e-02f, 9.34372321e-02f, -2.50805239e-03f,
  -1.23070166e-01f, 2.65360087e-01f, 2.23150313e-01f, 1.54833337e-02f, 1.07665882e-01f, 6.09184094e-02f, 2.19151601e-01f, -1.17800936e-01f, 2.15897545e-01f, -1.73410133e-01f,
  -1.85174391e-01f, -4.84534279e-02f, 4.88482509e-03f, 4.50178683e-02f, -6.04294287e-03f, 2.15831697e-01f, 1.26038730e-01f, 2.83676083e-03f, 2.65757442e-01f, 9.81123839e-03f,
  5.53887710e-02f, -2.09890142e-01f, -1.28694512e-02f, -4.76741344e-02f, -5.81844226e-02f, 8.45189765e-02f, -1.34635553e-01f, 3.10483217e-01f, -1.34541407e-01f, 1.74632758e-01f,
  -4.36032936e-02f, 1.19951695e-01f, -1.45825207e-01f, -8.71554241e-02f, -1.41455784e-01f, -3.05746719e-02f, -2.70477738e-02f, -9.44942888e-03f, 8.88763145e-02f, -3.74321900e-02f,
  -3.90471704e-02f, -1.64308354e-01f, 2.90534589e-02f, -9.47978720e-02f, 1.17911786e-01f, -4.16753553e-02f, 2.23545954e-02f, 6.68237582e-02f, -4.36008908e-02f, 4.88150269e-02f,
  -4.65122052e-02f, -5.15868403e-02f, -2.89927050e-02f, 6.76553026e-02f, 1.17583526e-02f, 7.89892823e-02f, 1.58408418e-01f, 4.77709956e-02f, -7.91455358e-02f, 1.44997299e-01f,
  9.93434787e-02f, 2.52895858e-02f, -6.90101385e-02f, -6.60439432e-02f, -3.53115425e-02f, -1.87132299e-01f, -1.45022094e-01f, -8.48697349e-02f, 5.25971316e-02f, -4.42249514e-02f,
  -9.34773907e-02f, -2.47359797e-02f, 1.80441365e-01f, -3.05255316e-02f, 2.58732066e-02f, -7.41927549e-02f, 3.13927582e-03f, -7.57584572e-02f, 1.22278318e-01f, -9.12676975e-02f,
  -1.07443118e-02f, 9.26762894e-02f, -5.27880900e-02f, 4.09067143e-04f, 1.08390123e-01f, 9.05329585e-02f, -6.88421801e-02f, -9.76520181e-02f, 4.00507264e-02f, -7.70902145e-04f,
  8.55235532e-02f, 2.69140214e-01f, -7.13556856e-02f, -1.85893357e-01f, -7.08160028e-02f, -8.26422274e-02f, -4.72716667e-04f, -5.69472872e-02f, 5.41499667e-02f, -7.51622468e-02f,
  5.58627620e-02f, -1.59588814e-01f, -1.49638522e-02f, -9.54328850e-03f, -3.40542309e-02f, -2.05143139e-01f, 7.13745952e-02f, 1.40948340e-01f, -9.96400788e-03f, 3.33390757e-02f,
  -1.47121489e-01f, -4.32548486e-02f, -1.57970428e-01f, -6.69894665e-02f, -6.09356537e-02f, 1.00969328e-02f, 4.60188948e-02f, 2.77483230e-03f, 6.66285958e-03f, 4.02734354e-02f,
  4.15709205e-02f, -6.52325675e-02f, -2.80183613e-01f, -1.21893905e-01f, -1.90299913e-01f, -3.44955653e-01f, -1.49365574e-01f, -8.03379193e-02f, 8.59627351e-02f, 1.99346095e-01f,
  9.00051743e-02f, 1.19495027e-01f, 3.05068940e-01f, -6.03845827e-02f, -7.07776472e-02f, 2.99040079e-01f, -2.54703939e-01f, -8.40147361e-02f, 9.25937891e-02f, -1.43611047e-03f,
  -4.34320495e-02f, 1.06861219e-01f, -6.06555268e-02f, 4.20766100e-02f, -1.55614376e-01f, -1.37877449e-01f, -2.23874860e-02f, -1.35771960e-01f, -1.93546340e-01f, -8.14939663e-02f,
  -5.10451980e-02f, 1.72743082e-01f, -8.13773647e-02f, 9.19427052e-02f, -6.84916899e-02f, -1.10253766e-01f, -1.53203741e-01f, -6.06882386e-03f, 7.81314597e-02f, 5.36612328e-03f,
  -2.18184723e-05f, 1.76612407e-01f, -8.21093023e-02f, 5.17164208e-02f, -5.67847230e-02f, -8.50767549e-03f, 7.06468076e-02f, -6.37501329e-02f, 5.04298620e-02f, -6.26585558e-02f,
  -4.82583512e-03f, -3.57487760e-02f, -1.91645753e-02f, 1.56439692e-01f, 1.89992264e-02f, 5.05773127e-02f, -1.79881454e-02f, -1.06523119e-01f, -6.18877448e-03f, -5.94554283e-02f,
  -4.05595265e-02f, 9.29749664e-03f, 1.70028284e-02f, 3.12152822e-02f, 3.07517424e-02f, -3.18013597e-03f, 9.82207619e-03f, -7.01492419e-03f, -7.17925373e-03f, -7.45426789e-02f,
  1.48534179e-01f, -1.61661357e-02f, -4.56646308e-02f, -4.34321873e-02f, -5.13858423e-02f, 7.75738433e-02f, -4.09679115e-03f, 4.33682911e-02f, -4.42627631e-03f, -1.11274682e-01f,
  -1.78772584e-02f, -7.91858658e-02f, 6.57441616e-02f, 8.47156867e-02f, -1.34207740e-01f, 5.33127636e-02f, -5.70051894e-02f, 6.81919381e-02f, -4.05515842e-02f, -1.58527959e-02f,
  -4.48146053e-02f, 5.22667989e-02f, -1.18248621e-02f, 8.30844864e-02f, -2.87325750e-03f, 2.18970031e-02f, -6.65239319e-02f, -5.47523834e-02f, -8.11637565e-02f, 4.89117280e-02f,
  -3.50408331e-02f, 8.54259729e-02f, 3.26917954e-02f, 2.15643570e-02f, 1.99460164e-02f, -1.19683549e-01f, 6.77670017e-02f, 5.34337126e-02f, -2.24858802e-02f, -1.98367417e-01f,
  3.60397026e-02f, 3.68950740e-02f, 2.02321991e-01f, 1.16829462e-01f, 7.43270218e-02f, 8.94445367e-03f, -1.59879997e-01f, 9.26496554e-03f, 2.86214147e-02f, -2.94410866e-02f,
  1.34678811e-01f, -2.09774319e-02f, -8.52332637e-02f, 7.91834388e-03f, -5.07616773e-02f, -8.75615627e-02f, -1.94548160e-01f, 2.43879091e-02f, -2.01793686e-01f, -4.21147794e-03f,
  -1.54905962e-02f, -9.58971307e-02f, 1.47053488e-02f, -2.40533985e-03f, -2.89757792e-02f, -1.15645133e-01f, 1.22898370e-02f, -5.41911386e-02f, -2.63570659e-02f, 2.55887747e-01f,
  1.88644409e-01f, 1.81931496e-01f, 1.14757590e-01f, 1.78897053e-01f, 7.99992457e-02f, 1.36295855e-01f, 2.45741695e-01f, 3.99051979e-02f, 1.33089975e-01f, 8.22668057e-03f,
  -9.66591984e-02f, 3.23920548e-02f, -5.55190668e-02f, -8.42453986e-02f, 1.58275142e-01f, 1.79616854e-01f, 1.17593423e-01f, -3.14578563e-02f, -7.31819794e-02f, -2.83866543e-02f,
  3.49880867e-02f, -6.98228702e-02f, -1.45711243e-01f, 1.51629755e-02f, -2.91451216e-02f, -3.29612307e-02f, -8.44460055e-02f, -2.49643959e-02f, -5.31219244e-02f, 1.03188287e-02f,
  -4.25105840e-02f, -1.53478652e-01f, -6.68603629e-02f, -6.72555808e-03f, 4.58762050e-02f, 1.87263219e-03f, -2.58208849e-02f, 4.39807512e-02f, -7.42861256e-02f, 4.87912111e-02f,
  9.43883583e-02f, 2.46044565e-02f, 2.02339720e-02f, -7.08763823e-02f, 2.51786932e-02f, 1.00978166e-02f, -1.32971600e-01f, -8.29394162e-03f, -4.82302764e-03f, -1.66342054e-02f,
  -5.33148944e-02f, 3.23187187e-02f, -4.59189676e-02f, 4.72975001e-02f, 8.33583251e-02f, -4.14258391e-02f, -8.26218873e-02f, 1.78210437e-02f, 1.25174507e-01f, -8.75849798e-02f,
  -6.90371990e-02f, 6.18985519e-02f, -1.24099210e-03f, -7.55186155e-02f, -4.50077094e-02f, 5.05673029e-02f, 8.33650231e-02f, 7.08440021e-02f, -2.69112550e-02f, -1.08188480e-01f,
  1.13821767e-01f, 1.44133657e-01f, -2.65103485e-02f, -8.99199694e-02f, -2.75714993e-02f, 1.38668135e-01f, -5.87453181e-03f, -5.49745560e-03f, 5.16705438e-02f, 6.74628988e-02f,
  1.65449843e-01f, -1.53657109e-01f, 1.46309547e-02f, 7.65807405e-02f, -2.96379533e-02f, 6.47298899e-03f, 7.65874237e-02f, -3.90255265e-02f, 5.21369241e-02f, 3.41020040e-02f,
  5.31967022e-02f, -1.15342408e-01f, -8.57762713e-03f, -9.66188982e-02f, 3.07891425e-02f, 4.74104956e-02f, 2.75558960e-02f, 4.47397046e-02f, -1.06833808e-01f, -3.59396785e-02f,
  -1.18108653e-01f, 1.07668549e-01f, -1.06844909e-01f, -1.81243196e-01f, 9.49808285e-02f, -1.01773664e-01f, -1.87687770e-01f, -7.94187188e-02f, -9.35585946e-02f, -1.83629140e-01f,
  -1.61403596e-01f, -8.39175098e-03f, 1.36366397e-01f, -1.63010463e-01f, 1.26565799e-01f, 2.04066828e-01f, -1.54258758e-01f, -1.17918983e-01f, -5.44821797e-03f, -1.30185589e-01f,
  -3.50127071e-02f, -1.29874781e-01f, 4.35231030e-02f, -7.04263747e-02f, -2.61213362e-01f, -1.74862191e-01f, 6.89036176e-02f, -1.24910600e-01f, -1.95267215e-01f, -8.38098973e-02f,
  -2.03624777e-02f, -2.13780493e-01f, -8.31061900e-02f, -5.69112450e-02f, -1.59547821e-01f, 4.10650577e-03f, -1.53025821e-01f, -7.29121789e-02f, 1.30465226e-02f, 1.01166643e-01f,
  -6.64377213e-02f, 7.52124488e-02f, -1.53375983e-01f, 6.11419138e-03f, 7.42282420e-02f, -9.32851527e-03f, -1.30750902e-03f, 2.49634846e-03f, 4.01819125e-02f, 3.99590880e-02f,
  -2.87439674e-02f, 2.62110159e-02f, -4.96758483e-02f, 4.10372242e-02f, 4.11757007e-02f, -7.69814178e-02f, 5.67755550e-02f, 8.48441944e-02f, 4.97825928e-02f, 4.62010428e-02f,
  -4.66932431e-02f, -2.50899717e-02f, 1.88263133e-02f, 2.69452743e-02f, -1.32862628e-01f, -9.44399536e-02f, -1.38042187e-02f, -9.93843377e-03f, -3.67096961e-02f, 8.32368061e-02f,
  6.63365796e-02f, 7.99565762e-02f, -2.24552583e-02f, -9.47207864e-03f, -2.45724153e-02f, -4.67065535e-02f, -8.16421025e-03f, 7.02985898e-02f, 3.14263701e-02f, -1.72903854e-02f,
  -6.00140821e-03f, 8.58430751e-03f, -4.40117829e-02f, 3.77358384e-02f, -7.36960545e-02f, 3.86994146e-02f, -3.45023721e-02f, 7.19045475e-02f, -3.20848115e-02f, 5.13023362e-02f,
  -6.45977259e-02f, -1.95936635e-01f, -3.23320180e-02f, -1.01787828e-01f, 7.57594630e-02f, -2.85102539e-02f, -7.05386922e-02f, -2.50941422e-02f, 5.03700413e-02f, -1.13709427e-01f,
  -1.36832714e-01f, 2.14264784e-02f, 1.21961068e-02f, -7.26754218e-02f, 6.28124923e-02f, 1.65543575e-02f, -1.07506290e-01f, 1.46883596e-02f, 1.57832243e-02f, -1.21109858e-02f,
  7.24128187e-02f, 3.98028754e-02f, 4.43878490e-03f, -4.28588837e-02f, 8.17654580e-02f, 3.38270366e-02f, -1.04645668e-02f, 4.49967384e-03f, 7.21440464e-02f, 3.34468707e-02f,
  2.45498970e-01f, -4.60871197e-02f, 1.09279258e-02f, 1.26470655e-01f, 1.03717387e-01f, 1.33836374e-01f, 2.36603603e-01f, -1.14255883e-01f, 1.73161626e-01f, -1.94607452e-01f,
  9.39947441e-02f, 1.40973283e-02f, 2.02411518e-01f, 9.15624052e-02f, 1.18239872e-01f, 1.16870165e-01f, 9.94100794e-02f, 1.52547389e-01f, 4.78738844e-02f, 4.34186682e-02f,
  -3.23683396e-02f, -5.44349477e-02f, -1.06807694e-01f, -1.92000687e-01f, 3.49094495e-02f, -1.79094821e-01f, -1.33784920e-01f, 9.64319780e-02f, -1.55914590e-01f, 8.86776522e-02f,
  6.41853437e-02f, 1.14244752e-01f, -2.47535054e-02f, -1.04159340e-02f, 1.77624673e-02f, -9.05502364e-02f, -1.32826626e-01f, 3.40981521e-02f, 8.76928046e-02f, 1.32737840e-02f,
  -9.80219431e-03f, 6.59675747e-02f, -1.62590593e-02f, 6.29725978e-02f, 2.35046279e-02f, 1.43489409e-02f, 6.11014590e-02f, 7.22088013e-03f, -9.75681841e-02f, 8.05687085e-02f,
  4.46529202e-02f, 1.26194313e-01f, 8.70973319e-02f, -2.49422975e-02f, 7.61072636e-02f, -3.10769007e-02f, -2.97833662e-02f, 3.02915256e-02f, 1.28672412e-02f, 1.15985274e-02f,
  -4.97511066e-02f, 1.95122752e-02f, 2.79583186e-02f, -4.60674278e-02f, 4.71958853e-02f, -2.90093361e-03f, 3.35136354e-02f, -2.89470572e-02f, 8.00250545e-02f, 1.14589363e-01f,
  1.02422044e-01f, 1.04261339e-02f, 7.79711232e-02f, 3.64947207e-02f, -5.53711690e-02f, -1.16681129e-01f, -2.25653667e-02f, -1.49354544e-02f, -4.73768152e-02f, -4.28073741e-02f,
  -4.13966216e-02f, -1.61800832e-02f, -5.08452673e-03f, -1.08978800e-01f, 8.49035010e-03f, 9.72230360e-02f, -1.79718081e-02f, 8.62510502e-02f, -2.21974831e-02f, 1.11816704e-01f,
  -3.77983637e-02f, 3.80018763e-02f, 1.39073115e-02f, -2.66608130e-02f, -6.48120046e-03f, -1.93932408e-03f, -1.80926658e-02f, -8.93264040e-02f, -1.05103655e-02f, 1.24973394e-02f,
  -1.05523586e-01f, 9.97907743e-02f, 2.32726652e-02f, 2.43510678e-03f, 1.70871764e-02f, -7.35773221e-02f, -1.68243684e-02f, 1.06784003e-03f, -7.50506744e-02f, -6.79233372e-02f,
  5.34219667e-02f, 1.18409291e-01f, 1.43863425e-01f, -1.04324203e-02f, 1.47397211e-02f, 5.49559779e-02f, -6.05527125e-02f, 3.91269987e-03f, 1.73102859e-02f, 1.98786184e-02f,
  1.67737633e-01f, -2.37217396e-01f, -8.54883641e-02f, -2.27364317e-01f, 7.15494379e-02f, 6.71356991e-02f, -8.13038126e-02f, -2.48789608e-01f, -3.50641370e-01f, -6.05382137e-02f,
  -5.54630160e-02f, 6.73173293e-02f, 4.29989211e-02f, -1.93116233e-01f, -8.87053311e-02f, -7.86347091e-02f, -9.42720175e-02f, -4.32702228e-02f, 1.55054275e-02f, 4.82005030e-02f,
  6.08497374e-02f, 7.63617735e-03f, -8.98828544e-03f, -9.32399649e-03f, -2.47909948e-02f, 5.20369271e-03f, 1.42000556e-01f, 3.84785570e-02f, -4.35658395e-02f, 6.16566762e-02f,
  -6.01920635e-02f, -7.79962074e-03f, 5.40761231e-03f, -2.99146120e-02f, 1.12880990e-02f, 1.82725161e-01f, 1.92522809e-01f, 1.24342196e-01f, -8.32917467e-02f, 1.67951901e-02f,
  3.87929715e-02f, -2.27985177e-02f, -7.76837841e-02f, 3.37014198e-02f, -7.01484233e-02f, -1.03922769e-01f, -1.50691569e-01f, -7.50842318e-02f, -4.54455167e-02f, -7.31491297e-03f,
  -5.55398576e-02f, 1.69946104e-02f, -1.64792668e-02f, -1.00860037e-01f, 4.11983654e-02f, -8.20632651e-02f, 1.34523083e-02f, 1.60075516e-01f, -2.27926429e-02f, 2.30791774e-02f,
  2.26323884e-02f, 1.96308374e-01f, 1.52614266e-01f, 5.68389893e-03f, -9.16439667e-03f, -3.51519622e-02f, 1.06514816e-03f, -4.33272719e-02f, 2.69826408e-02f, -9.19100270e-02f,
  -2.66054980e-02f, -7.14871436e-02f, -1.78177245e-02f, 6.40075281e-02f, 1.58415269e-02f, 5.38175739e-02f, 6.98402748e-02f, 1.20158847e-02f, 3.72125092e-03f, -2.74648890e-02f,
  6.38644816e-03f, 3.42781916e-02f, -9.27974954e-02f, -4.44497541e-03f, 3.44756222e-03f, -5.85355163e-02f, 6.63418397e-02f, 5.04405722e-02f, -5.13289794e-02f, 1.54312238e-01f,
  -5.45104928e-02f, 7.46894404e-02f, -4.88371924e-02f, 5.08218724e-03f, -2.68476252e-02f, 6.57883659e-02f, 6.55114129e-02f, 9.73542500e-03f, -5.80715686e-02f, -3.53797153e-02f,
  5.87637499e-02f, -1.49295539e-01f, 9.07343030e-02f, -9.81191993e-02f, -1.17709666e-01f, -1.36462048e-01f, 9.92875397e-02f, -3.26941907e-02f, -3.93773764e-02f, -8.59945938e-02f,
  1.34198032e-02f, -4.54662815e-02f, 5.04983403e-03f, -2.36009564e-02f, -4.76092994e-02f, 5.89262787e-03f, 4.53157499e-02f, -2.54853107e-02f, -8.87029991e-02f, -1.53227776e-01f,
  3.18341963e-02f, 2.17213795e-01f, -1.47869736e-01f, 8.34096316e-03f, 3.11495904e-02f, -3.62544864e-01f, -2.47091353e-01f, -4.82442603e-02f, 8.60249698e-02f, 1.21764734e-01f,
  -1.80698916e-01f, 3.71705890e-01f, 3.39790806e-02f, -1.76025584e-01f, -3.13262373e-01f, -1.52905241e-01f, -3.28347802e-01f, 4.24288632e-03f, 1.96753517e-01f, -8.18809867e-02f,
  -7.78627172e-02f, -1.64891303e-01f, -2.14736208e-01f, -1.51274744e-02f, -7.19101983e-04f, 3.39882821e-02f, -9.22008008e-02f, 7.07074488e-03f, -3.09959594e-02f, 1.00101326e-02f,
  -3.77542004e-02f, 1.41498148e-01f, 5.19952290e-02f, 7.87577182e-02f, -1.47528857e-01f, -5.65309115e-02f, 9.16466396e-03f, -8.56263470e-03f, -3.76495905e-02f, 1.16073499e-02f,
  6.01838566e-02f, 6.88024536e-02f, 3.69149297e-02f, 5.80394752e-02f, 7.52775371e-02f, 6.81063235e-02f, -6.96153333e-03f, -3.46711688e-02f, 4.05088738e-02f, 2.39007398e-02f,
  1.02940770e-02f, 9.55993980e-02f, -8.18850696e-02f, -3.69024314e-02f, -6.88738525e-02f, -9.79540031e-03f, 3.13516930e-02f, -4.35349680e-02f, 6.61955774e-03f, 1.27088360e-03f,
  2.40457244e-03f, -7.58035481e-02f, -3.06917392e-02f, 7.22147524e-02f, 1.32455770e-02f, 4.51305769e-02f, -2.94811861e-03f, -1.35712782e-02f, 7.34408796e-02f, -5.51352696e-03f,
  -3.11941374e-02f, 1.14346825e-01f, -3.59822735e-02f, -5.45452051e-02f, -3.33404206e-02f, 9.57025662e-02f, -1.21838069e-02f, 3.04643530e-02f, -2.73067877e-02f, -2.63948943e-02f,
  7.57305473e-02f, -1.06830813e-01f, 1.74343269e-02f, -3.60687496e-04f, -8.47790465e-02f, 5.18719591e-02f, 7.11674020e-02f, -3.61301890e-03f, 7.04069287e-02f, -8.92863572e-02f,
  -8.89210030e-02f, -1.04995482e-01f, -9.66432784e-03f, 1.11426920e-01f, 4.31617573e-02f, -3.03942151e-02f, -4.55898270e-02f, -5.39733917e-02f, -6.98446035e-02f, -5.96520118e-02f,
  -5.12559637e-02f, 8.43992457e-02f, 1.81160104e-02f, 3.93069685e-02f, 2.36883853e-02f, -1.36320844e-01f, 1.15935160e-02f, 1.04357339e-02f, -5.68433478e-02f, 2.51658820e-02f,
  6.43415600e-02f, 9.06509534e-02f, 1.78519487e-02f, 3.59592512e-02f, 4.24143597e-02f, 5.40779606e-02f, 4.60669957e-03f, 1.01752013e-01f, 2.64080055e-02f, -1.62646465e-03f,
  -2.05766752e-01f, -9.32584703e-02f, 1.21574692e-01f, 3.10466975e-01f, -1.36528298e-01f, -3.43905002e-01f, -3.66220206e-01f, 8.83718431e-02f, -7.75786340e-02f, -2.18145937e-01f,
  -8.47048014e-02f, -7.03586116e-02f, -6.67037815e-02f, 1.47113606e-01f, 3.24331403e-01f, 8.54885355e-02f, 2.11263314e-01f, 3.01559269e-02f, 3.68797667e-02f, 1.11402057e-01f,
  1.84702769e-01f, 1.94553137e-01f, 3.38465691e-01f, 1.48724943e-01f, 4.94063646e-03f, 1.17884330e-01f, 2.13324338e-01f, -7.88387880e-02f, 2.33817115e-01f, 4.96257329e-04f,
  -9.03587639e-02f, 9.41593274e-02f, 6.91517815e-02f, -2.67194659e-02f, 4.09831181e-02f, -1.22619875e-01f, 1.14456732e-02f, -3.45625691e-02f, 4.29489389e-02f, 3.35220248e-02f,
  1.68455802e-02f, 2.44814884e-02f, 1.00621268e-01f, -8.84735733e-02f, -1.31536834e-02f, 2.88856961e-02f, -1.00716844e-01f, -6.82369843e-02f, 1.07452506e-02f, 2.38848999e-02f,
  1.96159557e-02f, 1.14022024e-01f, 3.63096781e-02f, 1.13403179e-01f, 2.57462505e-02f, -1.93307903e-02f, -1.96320359e-02f, 2.07426418e-02f, 2.70582680e-02f, 6.33993074e-02f,
  4.38514054e-02f, -6.26143292e-02f, -5.46334423e-02f, -8.09383616e-02f, -5.40999956e-02f, 7.63607817e-03f, -7.11924955e-02f, 2.04098858e-02f, -9.35369283e-02f, -2.64076516e-02f,
  7.32205138e-02f, 8.69232193e-02f, 5.16690407e-03f, 9.49347857e-04f, 2.92360503e-03f, 2.92234402e-02f, 1.62724836e-03f, 2.61363145e-02f, 2.31809765e-02f, 3.44823375e-02f,
  -1.02326907e-02f, -8.61273929e-02f, -9.42710340e-02f, 1.17831960e-01f, -2.50003301e-02f, -1.01908036e-01f, 5.04005626e-02f, -4.86771502e-02f, -3.04329470e-02f, 1.50420126e-02f,
  -2.69082771e-03f, 2.22415000e-01f, 1.23779522e-02f, -5.56594431e-02f, 5.19381128e-02f, -6.93824664e-02f, 9.16237906e-02f, 5.84319755e-02f, -9.52819083e-03f, -1.87696256e-02f,
  7.79576451e-02f, -2.55570877e-02f, -5.34073189e-02f, 2.39097215e-02f, 1.88137442e-01f, -1.53870322e-02f, -7.11271241e-02f, -4.64324765e-02f, 1.51702255e-01f, 1.28152326e-01f,
  -6.98638558e-02f, -4.43353392e-02f, 7.98792541e-02f, -4.91917655e-02f, 1.16875462e-01f, 8.70581158e-03f, -5.91762997e-02f, -1.65495649e-02f, 1.84558660e-01f, 3.13722976e-02f,
  1.89736411e-01f, 1.22590683e-01f, -3.45845185e-02f, 3.55321690e-02f, -8.74536764e-03f, 6.14081603e-03f, -5.75415827e-02f, 2.25642659e-02f, -1.27562173e-02f, 1.05357505e-01f,
  1.22081533e-01f, -8.76907818e-03f, -1.01995453e-01f, 1.23440750e-01f, -2.02518627e-01f, -4.85619865e-02f, -8.45265090e-02f, 7.74528412e-03f, -4.99719568e-02f, 9.82249677e-02f,
  2.10722908e-02f, 2.23711461e-01f, -8.97709653e-02f, 4.65952680e-02f, 2.36069798e-01f, -8.60532001e-02f, -1.30950987e-01f, -9.29601416e-02f, 1.43771991e-01f, 4.46532900e-03f,
  2.92227641e-02f, 1.35786623e-01f, 1.87465381e-02f, 2.01411210e-02f, -2.90561672e-02f, 1.74192086e-01f, 8.27081278e-02f, -2.75406763e-02f, -4.56674621e-02f, -3.09039745e-02f,
  1.30938413e-02f, 1.43663213e-02f, 5.27123399e-02f, 9.54057798e-02f, 1.76289584e-02f, 9.10990406e-03f, 6.07523471e-02f, -7.27690756e-02f, -3.98742445e-02f, 4.70967032e-02f,
  7.89409876e-03f, -6.68782517e-02f, -7.20217079e-02f, -5.42384833e-02f, -6.66849092e-02f, -6.62268400e-02f, -5.31161502e-02f, -3.85958999e-02f, -1.90853924e-02f, -1.60504822e-02f,
  9.30319801e-02f, 4.55999710e-02f, -1.84628870e-02f, 7.90140256e-02f, 1.30330533e-01f, -2.44928394e-02f, -9.80584323e-02f, -9.35503393e-02f, -7.21969754e-02f, -2.17230972e-02f,
  -5.53762205e-02f, 1.41468812e-02f, 1.73546188e-02f, 8.89306739e-02f, 1.12142619e-02f, -3.15260666e-04f, -3.51139270e-02f, 2.90400442e-02f, -4.13154485e-03f, 2.04444584e-02f,
  1.01219349e-01f, 1.36188474e-02f, -5.36351316e-02f, -4.82813194e-02f, 1.98747553e-02f, -1.98533777e-02f, 7.48769194e-02f, 8.85636583e-02f, -3.33285108e-02f, -3.80767025e-02f,
  4.09229100e-03f, -7.38793164e-02f, -6.90351725e-02f, -8.16673860e-02f, -7.80792534e-02f, 1.71250999e-01f, 1.54406661e-02f, -5.76264635e-02f, 5.58801666e-02f, 5.76328561e-02f,
  -7.12633075e-04f, -9.31321532e-02f, 3.80688794e-02f, 7.30946064e-02f, -1.82109550e-01f, -6.72002435e-02f, -2.73879636e-02f, -1.58690244e-01f, -1.08666196e-01f, -2.32322291e-02f,
  3.40619385e-02f, 3.53247509e-03f, -6.11065924e-02f, -1.26089454e-02f, -8.48449767e-02f, -6.16345182e-02f, -4.38918807e-02f, 6.15347512e-02f, -1.54223898e-02f, -1.01392820e-01f,
  -5.53016327e-02f, -5.02251267e-01f, -1.25964172e-02f, 1.18212573e-01f, 1.96487337e-01f, -9.40184668e-02f, 2.60093827e-02f, -1.14451289e-01f, -1.74779981e-01f, -2.35147342e-01f,
  -1.77546307e-01f, 7.24468678e-02f, -3.22816193e-01f, -2.06016470e-02f, 3.15722436e-01f, -1.29163206e-01f, -1.43197905e-02f, 3.99923101e-02f, -3.43618952e-02f, -9.35714915e-02f,
  3.73140238e-02f, 6.75144121e-02f, 2.67433655e-02f, 2.94429213e-02f, -7.65952915e-02f, 4.48065065e-02f, 1.05156109e-01f, 7.56660253e-02f, 2.57955462e-01f, 1.05576158e-01f,
  6.71565086e-02f, -4.35066270e-03f, 6.24742173e-02f, 2.97490507e-03f, -1.14221245e-01f, -6.94349930e-02f, -6.15107641e-02f, 5.02973869e-02f, 1.13186151e-01f, 2.05341112e-02f,
  -4.17562085e-04f, 6.18153112e-03f, 1.14503451e-01f, 7.08314404e-02f, -3.08066402e-02f, 2.87277531e-02f, -7.88930804e-03f, -5.63236587e-02f, 5.59349637e-03f, -1.54920503e-01f,
  -1.54132113e-01f, 6.07350618e-02f, -6.39473647e-02f, 6.03492297e-02f, -5.04841693e-02f, -5.35340868e-02f, 7.67896790e-03f, -6.10177889e-02f, -2.73105074e-02f, 9.08504147e-03f,
  -1.85922720e-02f, -2.39608157e-03f, -5.68991974e-02f, 1.70514137e-02f, -6.28814623e-02f, 1.42605966e-02f, 2.67660413e-02f, -7.45742470e-02f, -2.11892966e-02f, -6.43141046e-02f,
  -5.35396002e-02f, 3.12526152e-02f, -3.53728258e-03f, 5.03782965e-02f, 2.54933666e-02f, 9.99860689e-02f, 1.40889809e-02f, 4.10522856e-02f, -9.30469185e-02f, -3.33820358e-02f,
  1.08520628e-03f, -8.42512101e-02f, -1.24459729e-01f, 1.28089577e-01f, 2.34983000e-03f, -1.57275330e-02f, -6.41689301e-02f, -3.64926197e-02f, -7.86610134e-03f, -4.70446534e-02f,
  -2.26576775e-01f, -2.06065625e-01f, -4.44801562e-02f, -1.06509114e-02f, 6.75775930e-02f, -2.34087706e-02f, 7.28456452e-02f, -5.55970110e-02f, -5.03906757e-02f, -6.41430914e-02f,
  -1.63622033e-02f, 9.13823023e-02f, -1.57512631e-02f, 1.10802874e-02f, 2.71126758e-02f, 6.10060175e-04f, -1.68866403e-02f, 6.75973892e-02f, 1.74722224e-02f, -1.32715255e-01f,
  -6.98608859e-03f, -1.19474031e-01f, 4.45730872e-02f, 3.98014262e-02f, 9.04576704e-02f, 1.14173880e-02f, -7.60194147e-03f, -4.22459058e-02f, 4.01420631e-02f, -1.63813084e-02f,
  -2.58813221e-02f, -1.73279807e-01f, -1.65903494e-01f, -1.21972740e-01f, 7.06403852e-02f, 1.94483057e-01f, 2.11857811e-01f, -2.07284540e-01f, -2.50871390e-01f, 3.31779607e-02f,
  1.07346870e-01f, -1.21809512e-01f, 5.90542182e-02f, -1.94437087e-01f, 9.99695249e-03f, -1.61066279e-01f, -1.22859910e-01f, 9.20902938e-02f, -1.73308358e-01f, 1.29129916e-01f,
  1.48533553e-01f, 3.79610322e-02f, -6.00872189e-02f, -2.59863343e-02f, -4.31892350e-02f, 1.54778138e-02f, 2.23654866e-01f, 6.08342849e-02f, 6.37481064e-02f, -1.28581049e-03f,
  -7.11282045e-02f, -7.82761872e-02f, -3.43405344e-02f, -6.73588738e-02f, 7.59829655e-02f, 1.17091015e-01f, 1.48400411e-01f, 3.65468524e-02f, 1.78340375e-02f, 4.81402921e-03f,
  7.65561759e-02f, 3.17304581e-02f, -1.46896660e-01f, -3.92132588e-02f, -2.90742069e-02f, -5.49076647e-02f, -1.54471293e-01f, -4.56885956e-02f, -1.43919680e-02f, 2.05818992e-02f,
  3.40097584e-02f, 9.54270922e-03f, 1.06350765e-01f, -1.55308302e-02f, 3.28180157e-02f, 2.26444012e-04f, 1.00869067e-01f, 1.44210279e-01f, -1.53323701e-02f, -1.51574407e-02f,
  2.47703474e-02f, 1.72880188e-01f, 4.12253514e-02f, -5.45504875e-02f, -2.40460243e-02f, -5.60749173e-02f, -1.31846234e-01f, -3.72244865e-02f, 4.56203055e-03f, -8.85600075e-02f,
  -4.87917662e-02f, -3.57064866e-02f, -3.87841873e-02f, 7.41390437e-02f, -2.07334291e-02f, 7.09073916e-02f, 9.31956619e-02f, 2.10185405e-02f, 1.48424774e-01f, 5.43366745e-02f,
  5.52720483e-03f, -6.82306197e-03f, 2.24891379e-02f, -1.82365086e-02f, 1.87068768e-02f, 1.07312053e-02f, -1.20407254e-01f, 1.66389765e-03f, 2.03696713e-02f, 1.43326998e-01f,
  1.75754447e-02f, -5.97064942e-03f, -6.82551339e-02f, -1.96011830e-02f, -4.63682674e-02f, 7.71227628e-02f, -1.23287566e-01f, -2.15814132e-02f, 5.07651754e-02f, -2.50293799e-02f,
  8.20321292e-02f, 5.57995737e-02f, -2.82738004e-02f, 8.28002393e-02f, -7.90883601e-02f, -6.91010384e-03f, 7.39363432e-02f, -5.48418574e-02f, -9.46852416e-02f, 1.97169501e-02f,
  1.05069153e-01f, 8.21966454e-02f, -2.22222321e-03f, 4.07400057e-02f, -1.21936025e-02f, 2.45349631e-02f, 2.96448544e-02f, -2.70853210e-02f, -7.57243633e-02f, -5.77779301e-02f,
  -2.02105135e-01f, -9.60917175e-02f, -2.35132381e-01f, -2.56865799e-01f, 1.49425909e-01f, 1.63040251e-01f, -9.47911590e-02f, 4.79102097e-02f, -5.77403493e-02f, 1.76843017e-01f,
  3.77905220e-02f, -1.94365814e-01f, -8.08275491e-03f, -3.15261215e-01f, -3.59859258e-01f, -2.01088265e-01f, -1.56259224e-01f, -6.47966787e-02f, -7.65181333e-02f, -3.77298258e-02f,
  -4.40368764e-02f, 1.96141843e-02f, -1.54818520e-01f, 1.25050470e-01f, 2.42030732e-02f, 5.13542667e-02f, 2.47020796e-01f, 1.41283110e-01f, -1.36352296e-03f, 2.94731017e-02f,
  -1.60760462e-01f, -5.68475574e-02f, 4.75810356e-02f, -8.42039064e-02f, 6.75196201e-02f, 1.99509904e-01f, -1.05085745e-02f, -4.39936481e-02f, 6.09230287e-02f, 5.25402948e-02f,
  1.76607724e-02f, 4.58904169e-02f, -2.40214448e-02f, 2.42149574e-03f, 4.97447141e-02f, 1.08287055e-02f, -8.35907683e-02f, 4.22105156e-02f, -1.82191413e-02f, -4.71416153e-02f,
  -7.42969513e-02f, -2.42086928e-02f, 7.47711957e-02f, -5.30011505e-02f, 7.09988847e-02f, 2.16344208e-03f, -5.54432236e-02f, 1.10986456e-01f, 6.31925985e-02f, -1.85778346e-02f,
  -1.57307666e-02f, 2.81116180e-02f, -3.91594619e-02f, -4.21310440e-02f, 4.33591940e-02f, -9.00364481e-03f, -7.04474673e-02f, -2.94141825e-02f, 1.47926593e-02f, 8.92196670e-02f,
  1.20770186e-01f, -7.74808154e-02f, -8.70932117e-02f, 8.84432346e-02f, 5.33482917e-02f, -6.36087880e-02f, -5.43331653e-02f, 4.69963513e-02f, 3.07118185e-02f, -2.88525987e-02f,
  1.94639210e-02f, 5.54109775e-02f, 7.22585386e-03f, -5.52156419e-02f, -3.17750163e-02f, 9.13616195e-02f, 1.09744199e-01f, -4.81181219e-02f, -1.00735717e-01f, 4.72622477e-02f,
  -2.80914903e-02f, 1.29374608e-01f, 3.69861275e-02f, -2.93121506e-02f, 5.89352474e-02f, 1.71868220e-01f, -9.23713520e-02f, 1.89745389e-02f, 2.33022589e-02f, 1.17657579e-01f,
  1.15007252e-01f, 3.68952006e-02f, 2.54233032e-01f, 3.10516041e-02f, 8.39640200e-02f, 6.66268691e-02f, 3.04135848e-02f, 6.08809926e-02f, 5.87690920e-02f, -6.61412999e-02f,
  1.32105365e-01f, 1.37733653e-01f, -9.34236404e-03f, 5.32266349e-02f, 1.04287140e-01f, 1.11440986e-01f, 1.15285411e-01f, 1.18678533e-01f, 5.76340547e-03f, 3.67929675e-02f,
  -6.12377763e-01f, 1.61470324e-01f, 4.36070114e-01f, -4.18434381e-01f, -4.20193793e-03f, 3.04712266e-01f, 1.30335644e-01f, 2.75743101e-02f, -2.17115700e-01f, -6.44342825e-02f,
  -4.52473648e-02f, 6.13819249e-02f, 2.05071732e-01f, -9.94150415e-02f, 3.00784677e-01f, 1.29120693e-01f, -1.77139044e-01f, -3.68717425e-02f, -9.84114129e-03f, -1.85869157e-01f,
  -6.46591783e-02f, -1.70849293e-01f, 1.54974163e-01f, -5.91234826e-02f, 4.89153862e-02f, -7.29066208e-02f, -1.48101091e-01f, 1.56844959e-01f, 5.97049855e-02f, 1.30030379e-01f,
  -1.72747642e-01f, -2.97824144e-01f, -1.86543643e-01f, 6.41674325e-02f, 7.82795399e-02f, -3.35317664e-02f, -5.50637990e-02f, 3.90697755e-02f, -1.04727201e-01f, 8.93338304e-03f,
  -4.57231402e-02f, 6.49630651e-02f, -1.33515924e-01f, 3.28330882e-02f, -1.45428762e-01f, -2.63048578e-02f, 2.02822387e-01f, 6.92519993e-02f, 3.76409292e-02f, 1.02166116e-01f,
  1.60652384e-01f, 1.77046489e-02f, 3.16297039e-02f, -2.64731376e-03f, 1.65775448e-01f, -3.11445165e-03f, 1.59706734e-02f, 3.01864613e-02f, -3.73836537e-03f, -1.68904085e-02f,
  1.33154362e-01f, 8.16616639e-02f, 6.66293576e-02f, 7.29600489e-02f, -1.04254074e-02f, -6.42459840e-03f, -5.98639213e-02f, -2.64447015e-02f, -4.35770154e-02f, 2.08293181e-02f,
  -2.29788255e-02f, 1.60404725e-03f, -3.52215953e-02f, -1.96955632e-02f, 1.59169566e-02f, -5.90674318e-02f, -5.59959859e-02f, -1.73437931e-02f, 3.23367454e-02f, 7.35656247e-02f,
  -4.75296266e-02f, 1.09571368e-01f, -4.02645487e-03f, -7.35748410e-02f, 4.17972952e-02f, -4.41440102e-03f, -1.64613649e-02f, 5.66281378e-02f, -1.52518094e-01f, 7.56911412e-02f,
  -2.73222119e-01f, -1.94810063e-01f, -1.62027240e-01f, -6.02147467e-02f, -3.48157855e-03f, -4.48144451e-02f, -6.00744747e-02f, -4.54939976e-02f, -9.56389308e-02f, 4.33616117e-02f,
  -5.81652392e-04f, 7.24317739e-03f, 1.81472711e-02f, 4.94633950e-02f, 4.56849970e-02f, -2.88307983e-02f, -5.46000339e-02f, -1.33552372e-01f, -1.55240551e-01f, -3.33867818e-02f,
  -1.55707961e-02f, -4.76176515e-02f, 1.24032944e-01f, -8.75462592e-02f, -4.16021468e-03f, -1.07110059e-02f, -4.98350486e-02f, 1.37978252e-02f, 5.11343405e-02f, 2.76787616e-02f,
  -1.10690206e-01f, 5.26863746e-02f, -1.83826193e-01f, 1.27398357e-01f, -2.41395435e-03f, 1.28921177e-02f, -1.94596704e-02f, 1.36646882e-01f, -5.44093996e-02f, 9.69860926e-02f,
  2.46356979e-01f, 2.14655194e-02f, 2.23515674e-01f, 4.53169256e-01f, 1.61599636e-01f, 1.48099810e-01f, 1.43123046e-01f, 1.69080406e-01f, 5.12385927e-02f, 1.77166894e-01f,
  1.61692545e-01f, 2.71440655e-01f, 2.21919969e-01f, 1.53119594e-01f, 1.56911090e-01f, 9.44835544e-02f, 2.05212578e-01f, -9.32862610e-03f, 2.79859662e-01f, 5.36962748e-02f,
  6.60379454e-02f, 3.70403938e-02f, -5.06078675e-02f, -1.29390955e-01f, 6.94445595e-02f, -3.63616683e-02f, -2.60684006e-02f, 5.60784303e-02f, -1.90773159e-02f, -3.94171700e-02f,
  1.34669291e-03f, -4.28362265e-02f, 1.71281360e-02f, -6.21855026e-03f, 5.02518052e-03f, -5.77510931e-02f, 1.75594573e-03f, -7.72815719e-02f, 1.40606770e-02f, 6.58791289e-02f,
  -5.63537553e-02f, 4.02254835e-02f, -6.59699664e-02f, -9.87136082e-05f, 2.58431621e-02f, -5.80927767e-02f, -3.34564261e-02f, 2.39265077e-02f, -3.59192304e-02f, 2.09515262e-02f,
  9.58932713e-02f, -5.87383471e-02f, 5.57310209e-02f, 6.15617894e-02f, 8.94575343e-02f, -4.19937819e-02f, -9.15200077e-03f, 4.08844762e-02f, -8.53270758e-03f, 6.75348565e-02f,
  -4.32921089e-02f, -7.49466792e-02f, -4.78206575e-02f, -1.14525529e-02f, -1.17815314e-02f, 2.78856345e-02f, -5.28724082e-02f, 8.20166245e-02f, -5.52903973e-02f, 5.55382818e-02f,
  7.16112927e-02f, 8.95704255e-02f, 5.81359863e-02f, -8.01144615e-02f, -2.53690928e-02f, -9.27300286e-03f, -3.21038663e-02f, -2.72584651e-02f, -8.40347931e-02f, -5.61345480e-02f,
  1.19569525e-01f, 1.32955596e-01f, 3.46925147e-02f, -8.41848105e-02f, -1.21719643e-01f, -2.83674318e-02f, -5.22158258e-02f, 1.39668465e-01f, 2.37214249e-02f, -9.44024920e-02f,
  -6.99059619e-03f, -9.64437202e-02f, 6.53200448e-02f, 7.80997649e-02f, 4.76600640e-02f, 4.22586612e-02f, 1.02422871e-02f, -7.97077864e-02f, 1.65192690e-02f, 1.49723515e-02f,
  -1.09442305e-02f, -1.08466521e-02f, -5.89599200e-02f, -5.85672036e-02f, -8.22381675e-02f, -7.98540562e-02f, -4.31761742e-02f, -4.94192913e-02f, 2.29865350e-02f, 8.03572685e-02f,
  4.31787670e-01f, -3.50416005e-02f, 1.97312459e-01f, 1.65697306e-01f, 1.28079668e-01f, 8.12472403e-02f, 7.65930489e-02f, -8.36841464e-02f, -3.57867517e-02f, -1.69781864e-01f,
  -6.39298260e-02f, 1.39449298e-01f, -1.55901641e-01f, 1.23932846e-01f, -2.76460886e-01f, -2.00475156e-01f, -5.49579896e-02f, 1.12220988e-01f, -6.08018078e-02f, 8.50275233e-02f,
  3.16179395e-02f, -1.69490039e-01f, -9.93616134e-02f, -1.24827795e-01f, 2.16265723e-01f, 1.16875373e-01f, -1.02512576e-01f, -4.82449010e-02f, 2.84031983e-02f, -9.17811170e-02f,
  1.08947763e-02f, 2.87106610e-03f, -2.72712763e-02f, -9.44835395e-02f, 2.70153638e-02f, 9.67242867e-02f, 6.98716342e-02f, 4.64926660e-03f, 5.57591692e-02f, -5.69246039e-02f,
  1.37917876e-01f, -3.49149182e-02f, 3.45922522e-02f, 1.30984164e-03f, -6.92830980e-02f, -1.21516801e-01f, 3.77142243e-02f, 5.16891740e-02f, 2.23643389e-02f, 1.18141010e-01f,
  8.27350318e-02f, 1.19277380e-01f, 3.01938802e-02f, 3.20058763e-02f, 9.37429890e-02f, 1.31493695e-02f, -3.61869414e-03f, 8.22914988e-02f, 6.27503842e-02f, -3.48657034e-02f,
  2.28625834e-02f, 1.12110330e-02f, -3.87083665e-02f, -9.13551152e-02f, 1.97383128e-02f, 3.81746739e-02f, -2.86859702e-02f, -1.21045355e-02f, -9.07565374e-03f, 2.04203743e-02f,
  -6.17557354e-02f, 2.89322529e-02f, 3.18315588e-02f, -1.28121697e-04f, 6.69392869e-02f, 1.25470147e-01f, -1.77834313e-02f, 3.61837819e-02f, 3.40996161e-02f, 3.83371785e-02f,
  2.55127139e-02f, 4.48457003e-02f, -2.32911594e-02f, 1.13112433e-02f, 5.86462431e-02f, -6.10418655e-02f, -8.00406262e-02f, 1.67967286e-02f, -6.35068119e-02f, -1.23698093e-01f,
  -1.40467837e-01f, -1.89639360e-01f, -6.33007362e-02f, -6.62956983e-02f, -2.22958662e-02f, 9.73523259e-02f, 2.70286519e-02f, -5.79320528e-02f, -4.31495681e-02f, 1.21195093e-02f,
  1.70717105e-01f, -6.26919270e-02f, -2.22035460e-02f, 7.61672854e-02f, -8.29126313e-02f, -2.18721807e-01f, -5.29089523e-03f, -7.77707547e-02f, 8.34138691e-02f, 1.02890665e-02f,
  1.24484532e-01f, -2.81239375e-02f, -8.73588696e-02f, -1.09688919e-02f, 1.36713115e-02f, 4.85429093e-02f, -2.58717593e-03f, 3.51852477e-02f, 1.51748089e-02f, -9.57442299e-02f,
  1.40611455e-01f, 3.11887711e-01f, 4.72415686e-02f, 2.15523869e-01f, 4.37730104e-02f, 2.84851104e-01f, 2.15101570e-01f, 9.65640843e-02f, 3.87047797e-01f, 1.60644770e-01f,
  -1.08600318e-01f, 2.91460633e-01f, -8.07654783e-02f, 9.84417275e-02f, 4.86492217e-02f, -7.25429580e-02f, 2.45601535e-01f, 1.52041510e-01f, 1.18531443e-01f, 8.39786232e-02f,
  5.83400428e-02f, 1.70120567e-01f, -1.51054502e-01f, -1.75847802e-02f, -4.56359312e-02f, -1.59125671e-01f, -3.94828141e-01f, -1.15172222e-01f, -2.99061295e-02f, 3.61726955e-02f,
  -4.10957204e-04f, 5.70078157e-02f, -4.53593135e-02f, -9.58975311e-03f, 3.93258035e-02f, 1.47714540e-02f, 5.03464863e-02f, -3.10859010e-02f, 2.29142848e-02f, 1.04643077e-01f,
  9.15527120e-02f, 2.76433099e-02f, 4.75024506e-02f, -4.08380385e-03f, 7.18331188e-02f, 1.05484776e-01f, 1.39220534e-02f, -2.18305383e-02f, -4.18357402e-02f, -4.97493073e-02f,
  5.18332496e-02f, -4.27718908e-02f, 8.65094960e-02f, -2.89919060e-02f, 6.47344515e-02f, 6.61526769e-02f, 9.15148705e-02f, -4.02121544e-02f, 1.06612384e-01f, 1.12507105e-01f,
  5.29679470e-02f, 1.13029093e-01f, -4.42859307e-02f, -1.22876137e-01f, 7.41671994e-02f, -1.13010094e-01f, 5.99493943e-02f, 1.41511532e-02f, 4.89222370e-02f, -3.55874584e-03f,
  3.83353531e-02f, -9.19546485e-02f, -1.08354250e-02f, 5.59206940e-02f, 1.51703700e-01f, -6.77959919e-02f, 5.56886867e-02f, 2.94119231e-02f, 6.22499771e-02f, -2.82748230e-02f,
  -4.85107079e-02f, -2.70907655e-02f, -3.09175309e-02f, -1.16686195e-01f, -2.80202279e-04f, 5.34379333e-02f, -2.30503548e-03f, 3.66296656e-02f, -2.33542137e-02f, 3.79063152e-02f,
  1.18365355e-01f, 2.27358967e-01f, 2.82984935e-02f, 5.03153279e-02f, 7.19599500e-02f, 1.12138450e-01f, 1.84885133e-02f, 1.14843369e-01f, 1.35396212e-01f, 1.28677249e-01f,
  1.40654355e-01f, -9.87023674e-03f, 2.09194478e-02f, -3.09937615e-02f, 2.35031429e-03f, -2.78472919e-02f, 9.64150019e-03f, 5.05399192e-03f, 7.40795732e-02f, -7.57369176e-02f,
  6.46938086e-02f, 1.84500709e-01f, 1.95180267e-01f, 4.56948243e-02f, 6.32352009e-02f, -3.82483490e-02f, 6.43545911e-02f, -4.09020595e-02f, -3.15419747e-03f, 1.75198957e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.15156847e-02f, 3.58296707e-02f, 7.86659122e-02f, 1.44296244e-01f, 5.34282252e-02f, 7.03481138e-02f, 1.09181866e-01f, 1.42911226e-01f, 1.27657622e-01f, 1.26404718e-01f,
  8.56611058e-02f, 5.62511124e-02f, 3.38316523e-02f, 9.72511433e-03f, 9.80182216e-02f, 9.56127569e-02f, 1.10720314e-01f, 7.72190988e-02f, 1.32441238e-01f, -1.23455822e-02f,
  1.57759681e-01f, 6.78958669e-02f, 9.03076753e-02f, 8.09918419e-02f, 1.28992125e-01f, 8.51972178e-02f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  -2.17508478e-03f, 2.75474973e-02f, -2.74967663e-02f, -1.88702568e-02f, -4.93917726e-02f, 1.01450838e-01f, 9.57469866e-02f, -5.71606383e-02f, 7.41047710e-02f, 2.30632722e-03f,
  3.63915637e-02f, 5.91814853e-02f, 5.38583063e-02f, 2.25079227e-02f, 3.84844765e-02f, 3.21332850e-02f, 3.47249955e-02f, -3.13141234e-02f, 3.92724108e-03f, -5.13718184e-03f,
  8.32357816e-03f, 1.33981910e-02f, 4.64570038e-02f, -6.23205751e-02f, 2.35586390e-02f, 4.55291159e-02f, 1.31102830e-01f, 6.71543330e-02f, 1.24759331e-01f, -6.17725626e-02f,
  6.39081076e-02f, 3.02985664e-02f, -3.42444144e-03f, 8.24634954e-02f, 1.68039966e-02f, -5.01025543e-02f, 1.08334936e-01f, 3.50400619e-02f, 2.55986508e-02f, 3.41293588e-02f,
  -1.40906628e-02f, -2.48209629e-02f, -1.59243960e-02f, -2.91205524e-03f, 9.03510675e-03f, 6.36659935e-02f, -3.25832772e-03f, 5.02640679e-02f, 7.60569647e-02f, 8.10683221e-02f,
  1.03283515e-02f, 8.58679116e-02f, 2.97588222e-02f, 1.06934786e-01f, 1.73887134e-01f, -6.82820845e-03f, -1.00795805e-01f, -9.29671749e-02f, 1.94061980e-01f, -4.58189957e-02f,
  -7.40032271e-02f, -2.62420960e-02f, 6.89435154e-02f, 5.71242534e-02f, 2.83221882e-02f, 1.38799891e-01f, 9.53308195e-02f, -5.00355475e-02f, 1.30594715e-01f, 6.93211183e-02f,
  -1.06031984e-01f, -5.91266947e-03f, -2.04323009e-01f, -4.50677797e-02f, 1.52009636e-01f, -7.78227448e-02f, 5.03335632e-02f, -3.29133794e-02f, 1.26041934e-01f, 3.42355892e-02f,
  8.38259142e-03f, 1.49696141e-01f, -9.41282213e-02f, 8.37815255e-02f, 4.18883152e-02f, 2.25413665e-02f, 4.44097593e-02f, -8.12106803e-02f, 3.26326899e-02f, -2.73119472e-02f,
  4.88739200e-02f, -5.62014244e-03f, -1.85763821e-01f, -4.43925522e-02f, -8.98545831e-02f, -7.22817481e-02f, 3.72047313e-02f, -1.27841100e-01f, -1.33134335e-01f, 1.55897245e-01f,
  -1.22568540e-01f, -1.12023875e-01f, 1.77416354e-01f, 1.69889703e-02f, 1.48379624e-01f, 9.16188583e-02f, -6.14949083e-03f, 6.40881211e-02f, 3.35236937e-02f, 1.84477365e-03f,
  -1.64465621e-01f, -4.24213484e-02f, -2.93323454e-02f, -6.81966990e-02f, -8.40079039e-02f, 1.00348130e-01f, -8.08912516e-02f, 7.09559321e-02f, 1.79996178e-01f, -5.68004325e-03f,
  -8.49844292e-02f, 6.87537864e-02f, 1.28042281e-01f, 1.96877137e-01f, 2.49522775e-01f, -2.11205892e-02f, 2.13084929e-02f, -1.59977332e-01f, -1.38587564e-01f, -3.20849977e-02f,
  1.39694512e-02f, -4.08917181e-02f, -6.62874989e-03f, 1.10273987e-01f, 8.66186526e-03f, -3.49494517e-02f, 5.65964123e-03f, 9.27496236e-03f, 5.85899130e-02f, 7.94363022e-02f,
  6.92116246e-02f, 2.40649991e-02f, 1.09406665e-01f, 5.60032986e-02f, 1.40039977e-02f, -2.27888171e-02f, -1.78018963e-04f, -3.60338055e-02f, 6.22226670e-02f, 5.50353564e-02f,
  4.74206805e-02f, -1.04831345e-01f, -5.48986308e-02f, 5.31230010e-02f, 8.29374865e-02f, 3.82223390e-02f, 8.99396911e-02f, -6.28259927e-02f, 4.87050451e-02f, -2.63289101e-02f,
  3.24670598e-02f, -7.28049427e-02f, -4.73808795e-02f, -2.91718468e-02f, -4.26184796e-02f, -7.94410519e-03f, 9.90372524e-02f, -3.96289006e-02f, -4.04693522e-02f, 1.43041927e-02f,
  -7.88417533e-02f, 5.57689741e-03f, 4.51640449e-02f, -4.19388711e-02f, 1.01589389e-01f, 8.79307464e-03f, 6.00188859e-02f, 4.31994647e-02f, 4.69565541e-02f, 2.53453013e-02f,
  1.47993729e-01f, 3.01230643e-02f, 1.85856700e-01f, -7.56218210e-02f, -4.24525216e-02f, -5.16626090e-02f, -3.62465419e-02f, -5.04533574e-02f, 8.17679018e-02f, -1.29276216e-01f,
  2.65888721e-02f, -8.47519040e-02f, -4.02728617e-02f, 2.02465817e-01f, 1.31507544e-02f, -1.32719502e-01f, 2.19488844e-01f, 2.16851845e-01f, -1.48972332e-01f, -5.22148162e-02f,
  -5.88012114e-02f, -1.94357298e-02f, 2.72840075e-02f, -8.96712095e-02f, 1.71564475e-01f, 6.90605864e-02f, 7.04166666e-02f, 7.95136094e-02f, -1.28829509e-01f, -1.43828569e-04f,
  -1.08125053e-01f, 8.67850780e-02f, -5.87470783e-03f, 3.77073362e-02f, 3.88307385e-02f, -1.04403375e-02f, -1.05676040e-01f, 3.36822011e-02f, -2.81008072e-02f, -8.69884491e-02f,
  -1.43183365e-01f, 4.26447019e-02f, 3.05681955e-02f, -1.96929481e-02f, -3.94499395e-03f, -1.68645352e-01f, -7.87660927e-02f, 5.78130819e-02f, -7.05031157e-02f, -1.26284167e-01f,
  -3.08941351e-03f, -1.04549631e-01f, 2.54350007e-01f, 1.56686351e-01f, 8.53174180e-02f, 1.68895006e-01f, -1.93815362e-02f, 4.76936698e-02f, -6.71441555e-02f, -2.74914876e-02f,
  4.56173122e-02f, 9.58569124e-02f, 2.67738476e-02f, 9.97353420e-02f, -9.48511884e-02f, 8.55147094e-03f, 1.99648052e-01f, -1.90982204e-02f, 5.50621152e-02f, -9.55519006e-02f,
  6.25545979e-02f, 1.23175934e-01f, 1.16404220e-01f, 9.21942014e-03f, -5.39546236e-02f, 1.80415008e-02f, -2.10780017e-02f, 9.32691321e-02f, 2.49996465e-02f, 3.84873012e-03f,
  -6.27422705e-02f, 1.03779376e-01f, 1.11515179e-01f, -7.48868585e-02f, 8.76529068e-02f, -3.37082669e-02f, 8.45129564e-02f, 7.07824305e-02f, -7.19331019e-03f, 4.68779355e-02f,
  6.29237667e-02f, 1.17125809e-02f, 1.12299640e-02f, 1.08914480e-01f, 4.52524684e-02f, 1.54142454e-02f, -2.63887625e-02f, -4.37428243e-03f, 3.63233499e-02f, 8.06424394e-02f,
  6.75206780e-02f, 1.10956445e-01f, 1.36339590e-01f, 4.57355678e-02f, -6.84531704e-02f, 4.59162295e-02f, -1.18632112e-02f, 8.39191601e-02f, 1.75417420e-02f, 4.72089760e-02f,
  4.10175212e-02f, 1.08749829e-01f, 9.26181972e-02f, 1.14139184e-01f, 7.46950656e-02f, 3.57253589e-02f, 1.64014138e-02f, 3.05536892e-02f, -1.51289431e-02f, 1.74780469e-02f,
  2.58428827e-02f, 5.44166900e-02f, -3.08328327e-02f, 2.10919995e-02f, 5.87994680e-02f, -1.43027650e-02f, -5.18308505e-02f, -2.60590706e-02f, -8.49997178e-02f, 1.15298137e-01f,
  1.14232399e-01f, 6.56835958e-02f, -7.43921846e-02f, -8.60893056e-02f, 2.35942811e-01f, 1.93703435e-02f, -1.22510821e-01f, -2.20734943e-02f, -5.17841242e-02f, -3.38073857e-02f,
  -5.87043501e-02f, 4.78060097e-02f, -4.22478691e-02f, 5.26485965e-02f, -8.75163227e-02f, -2.23279782e-02f, -1.06213398e-01f, 1.46983098e-02f, -7.33990967e-02f, -1.19695747e-02f,
  1.41855374e-01f, 7.37302452e-02f, 8.54727030e-02f, 8.07329491e-02f, 4.69059050e-02f, -6.46500066e-02f, 2.99614966e-02f, 1.82075873e-01f, 3.19513418e-02f, -2.55962908e-02f,
  1.00302108e-01f, 7.87129104e-02f, -9.83133689e-02f, -1.43815175e-01f, 1.42495632e-01f, -1.54702321e-01f, -1.57163478e-02f, -7.93842822e-02f, -5.49975261e-02f, -9.64972302e-02f,
  -4.20557559e-02f, 1.41887680e-01f, 1.33144125e-01f, -8.96674842e-02f, -3.03453058e-02f, 8.86480138e-02f, -3.31998467e-02f, 2.90963594e-02f, 1.17675066e-01f, -6.59364462e-02f,
  -1.04473412e-01f, -4.21439447e-02f, -8.53538066e-02f, 2.90319528e-02f, 7.78330788e-02f, 1.85456537e-02f, -1.06370188e-01f, 7.68417716e-02f, 9.98605341e-02f, -6.01463811e-03f,
  -2.30545551e-02f, 7.11804628e-02f, 1.03032570e-02f, 3.80998403e-02f, -1.04459397e-01f, -1.73940554e-01f, -1.98862955e-01f, -9.52392351e-03f, 1.56450659e-01f, 6.47226274e-02f,
  7.78682828e-02f, -1.15202107e-01f, -5.67622036e-02f, -4.38290052e-02f, -4.70057018e-02f, 1.00443780e-01f, -6.29566386e-02f, -1.89758409e-02f, -2.67008580e-02f, 1.52936829e-02f,
  1.84387714e-01f, 6.60390407e-02f, 1.45615181e-02f, -4.94395457e-02f, 1.20751709e-01f, 8.73679817e-02f, -2.45281262e-03f, 1.07073791e-01f, 3.60567495e-02f, -4.12585661e-02f,
  -1.16670854e-01f, -8.36945772e-02f, 5.98019250e-02f, -7.69792646e-02f, 3.49334739e-02f, -6.60767313e-03f, 1.05828837e-01f, 3.77310552e-02f, -6.26295879e-02f, 8.27783197e-02f,
  -2.48919874e-02f, -3.06621864e-02f, -1.26389027e-01f, 1.21236041e-01f, 1.56512633e-02f, 1.49759902e-02f, 1.99598316e-02f, 1.19423188e-01f, -4.81632873e-02f, -6.88053807e-03f,
  -2.77161617e-02f, 1.41409412e-01f, -8.80446751e-03f, -8.68804157e-02f, 1.07059009e-01f, -9.76437610e-03f, -6.66422993e-02f, 4.60027717e-02f, -1.00575618e-01f, 4.71619563e-03f,
  1.90156158e-02f, 3.49685289e-02f, 6.46127090e-02f, 3.07134204e-02f, 8.89535099e-02f, -3.80661450e-02f, -1.09425880e-01f, 1.62257969e-01f, 7.04923943e-02f, -7.50608966e-02f,
  8.74819085e-02f, -1.48466796e-01f, 7.54921064e-02f, 1.71984751e-02f, -9.42620412e-02f, -2.29284782e-02f, -5.17182387e-02f, -8.11301693e-02f, -1.00896411e-01f, 2.08041444e-02f,
  -3.82037573e-02f, -1.54175386e-01f, 9.74463746e-02f, 8.14479291e-02f, -2.84624845e-02f, -1.76558048e-02f, -2.10550338e-01f, 3.58819366e-02f, 1.53163299e-01f, 7.29446858e-02f,
  4.02680635e-02f, 4.15747911e-02f, -2.10520290e-02f, -1.41489521e-01f, -6.68772459e-02f, 6.67721927e-02f, 3.96602834e-03f, -1.68482631e-01f, -1.42784114e-03f, 1.80342510e-01f,
  -8.02235678e-02f, -6.27230927e-02f, -8.97446573e-02f, -7.14511275e-02f, -3.59178111e-02f, -3.85293476e-02f, 1.21053346e-02f, -6.86743408e-02f, -5.41231260e-02f, 7.08798468e-02f,
  -3.58406082e-02f, -1.12677827e-01f, 1.71957240e-02f, 2.31262259e-02f, 1.02121525e-01f, 1.73916534e-01f, 6.31539151e-02f, -6.99771866e-02f, 2.75272965e-01f, -1.14373498e-01f,
  -1.27114221e-01f, 6.83266521e-02f, 2.59886626e-02f, 2.63591632e-02f, -7.65758473e-03f, 6.60057738e-02f, 2.33077332e-01f, 6.21261038e-02f, -1.63891062e-01f, 1.35375962e-01f,
  -1.93557106e-02f, -1.10553622e-01f, -5.85889956e-03f, 7.85124395e-03f, -1.69451118e-01f, -5.74689964e-03f, -4.59409393e-02f, -6.65458813e-02f, 2.10857004e-01f, -4.98203449e-02f,
  -1.25599474e-01f, 5.02345525e-02f, 2.18125999e-01f, 8.41363668e-02f, 7.05897063e-02f, 5.23798391e-02f, 1.97181012e-03f, -1.36486083e-01f, -1.57373771e-03f, 2.79455576e-02f,
  -2.13367492e-02f, 6.67262152e-02f, -8.80048200e-02f, 7.07147457e-03f, 2.92304680e-02f, -2.77806981e-03f, -8.61962792e-03f, 6.12910427e-02f, 2.12048814e-02f, 5.99996485e-02f,
  2.68578846e-02f, 3.63734886e-02f, -9.53088608e-03f, 4.83649485e-02f, -1.72018949e-02f, 4.99638915e-02f, 1.50769487e-01f, -9.05104131e-02f, 4.14980538e-02f, 1.12562358e-01f,
  9.80026126e-02f, 9.14255157e-03f, 8.03136826e-02f, -3.40135247e-02f, 6.95823804e-02f, 8.33637640e-02f, 1.63532734e-01f, 2.95373276e-02f, -3.42605333e-03f, -2.07908172e-03f,
  8.66542533e-02f, 1.76664293e-01f, 8.17262083e-02f, -6.54891040e-03f, 1.76375836e-01f, -6.92849010e-02f, 4.04478647e-02f, 3.98868620e-02f, -4.40977402e-02f, 5.04306890e-03f,
  -3.29286233e-02f, 6.48558140e-02f, -5.38199469e-02f, 5.72245680e-02f, 6.72129169e-02f, -6.16028011e-02f, -9.23490375e-02f, 1.33802637e-01f, -5.56632876e-02f, 2.34429523e-01f,
  -1.57214850e-02f, -5.69732189e-02f, -1.32055819e-01f, 5.01018539e-02f, -5.97856799e-03f, 4.83496636e-02f, 2.20468491e-01f, -7.63675058e-03f, -1.20556895e-02f, 7.27540851e-02f,
  -6.06402010e-02f, -2.46875241e-01f, 5.80015779e-02f, 3.47069167e-02f, 1.41459033e-01f, 2.60912981e-02f, -4.07865904e-02f, -1.65038258e-01f, -1.20283179e-01f, -3.88402939e-02f,
  3.93056981e-02f, -2.63190009e-02f, 4.33497876e-02f, 7.29197413e-02f, -2.35445295e-02f, 4.13720682e-02f, 1.82558019e-02f, -1.24427497e-01f, 5.49356155e-02f, -1.01770252e-01f,
  8.52588331e-04f, 1.93205521e-01f, 1.13727897e-01f, 1.09544761e-01f, -5.09204641e-02f, 1.73179489e-02f, -8.10860470e-03f, -1.13684773e-01f, -1.46673946e-02f, 1.54348955e-01f,
  7.40169212e-02f, 1.62153002e-02f, -1.53743336e-02f, -7.17223063e-02f, 8.58074650e-02f, 1.52886301e-01f, -6.52367175e-02f, -4.24873643e-02f, 5.48928529e-02f, -1.43838853e-01f,
  7.01234937e-02f, -1.26687214e-01f, 7.44476765e-02f, 2.58541293e-02f, -1.89720213e-01f, -1.68510616e-01f, 1.22852348e-01f, -3.12857218e-02f, 7.94376805e-03f, 8.63208324e-02f,
  -4.20632921e-02f, 9.59012061e-02f, 1.96720730e-03f, 4.08073887e-02f, 7.21034769e-04f, 3.42894420e-02f, 1.22483015e-01f, 1.46746546e-01f, 1.35667011e-01f, -6.12993687e-02f,
  -1.44293010e-01f, -5.13961986e-02f, -6.53732046e-02f, 1.94601920e-02f, 8.53414908e-02f, 1.31126240e-01f, 3.91754247e-02f, 5.12139574e-02f, -7.00691715e-03f, 2.13601124e-02f,
  1.12956181e-01f, 4.35989127e-02f, 5.96553134e-03f, 9.85200629e-02f, 6.26330003e-02f, 3.80067900e-02f, 1.23120509e-02f, -6.63847476e-02f, 2.50260327e-02f, -1.26543678e-02f,
  3.89468819e-02f, 9.74644795e-02f, -5.57736866e-02f, -3.38385515e-02f, -3.13009694e-02f, 7.43433833e-02f, 4.70055826e-02f, -4.13608961e-02f, -2.57131159e-02f, -5.49406037e-02f,
  -6.59413729e-03f, -5.33926561e-02f, 1.28958831e-02f, -9.66174826e-02f, -1.84413210e-01f, -4.09304500e-02f, -7.22602159e-02f, -8.71262625e-02f, 8.61393064e-02f, -1.36954516e-01f,
  -1.29900604e-01f, -6.68616267e-03f, -9.89958942e-02f, -1.45232342e-02f, 3.34894061e-02f, -2.99231596e-02f, 1.36284575e-01f, 4.51418608e-02f, 2.63008624e-02f, -1.19418930e-02f,
  1.19422548e-01f, -6.30821735e-02f, 1.37173131e-01f, 4.15571481e-02f, 1.66539177e-01f, -1.27474263e-01f, 1.07984737e-01f, -1.21040642e-01f, -1.32268429e-01f, 8.14289600e-03f,
  1.54997975e-01f, -1.16979077e-01f, -9.02519673e-02f, -9.58212018e-02f, -1.00366727e-01f, 1.92019165e-01f, -8.12899098e-02f, -1.23808481e-01f, 9.52788964e-02f, 2.63967067e-01f,
  -1.44834369e-01f, -1.14042953e-01f, -6.29661381e-02f, -4.53784131e-02f, -9.66149755e-03f, -7.01489970e-02f, 2.30192319e-01f, 1.10762008e-01f, 1.99715570e-02f, 6.40772656e-02f,
  -2.02185273e-01f, -1.22226961e-02f, -8.88034627e-02f, 2.38117147e-02f, -1.38033573e-02f, 7.74275418e-03f, 4.05477062e-02f, 4.38037366e-02f, -1.40126571e-01f, -7.03672916e-02f,
  -7.33671635e-02f, -7.49510378e-02f, -1.05748355e-01f, 5.50399488e-03f, -3.29473130e-02f, 4.82989997e-02f, -1.86964814e-02f, -1.36016607e-01f, -6.04120158e-02f, -1.57790992e-03f,
  5.96106313e-02f, -1.17440638e-03f, -2.16590852e-01f, -1.83846056e-01f, 1.60193488e-01f, 6.99251965e-02f, 1.77425221e-02f, 1.91773072e-01f, -4.58104797e-02f, 6.09500110e-02f,
  -2.35211533e-02f, -1.12353172e-02f, 1.33703381e-01f, 1.40696824e-01f, -3.38703990e-02f, 7.84404874e-02f, -7.76750371e-02f, 5.09579433e-03f, 1.82832837e-01f, -1.13262579e-01f,
  3.46295093e-03f, -1.89267576e-01f, 9.50197056e-02f, 8.94035846e-02f, 1.78920291e-02f, -3.41484472e-02f, -2.48238519e-02f, -3.47346696e-03f, 2.15001568e-01f, -4.70297076e-02f,
  4.12663929e-02f, 1.69363037e-01f, 9.32562947e-02f, -5.44678755e-02f, -1.85433812e-02f, 3.09982598e-02f, 2.78013404e-02f, -4.28954288e-02f, -1.93741582e-02f, 1.97624583e-02f,
  7.59979058e-03f, 1.28385108e-02f, -5.53409429e-03f, 4.63633128e-02f, -9.61988606e-03f, -4.99999747e-02f, 1.67789552e-02f, 3.19049656e-02f, 4.04045824e-03f, 1.16371185e-01f,
  4.57071997e-02f, 2.44603530e-02f, 9.43274051e-02f, -2.40011550e-02f, -4.10459302e-02f, 3.18782032e-03f, 3.59422751e-02f, 8.53487402e-02f, 2.65347883e-02f, -1.56299043e-02f,
  6.51936978e-02f, -5.43718152e-02f, -1.10960258e-02f, 4.92190868e-02f, 5.34476340e-02f, -5.49950786e-02f, 5.18722348e-02f, 2.64397301e-02f, -3.69725488e-02f, -6.37148991e-02f,
  -2.19843499e-02f, 4.13029864e-02f, 2.71617603e-02f, -8.54176432e-02f, 1.25103712e-01f, 5.14054298e-03f, -1.74147505e-02f, 3.54300924e-02f, 3.09378821e-02f, 5.60663864e-02f,
  -1.00206612e-02f, -4.06998321e-02f, -6.82182834e-02f, 5.80864102e-02f, 8.99515226e-02f, 8.58059898e-02f, -1.02932379e-01f, 1.06573589e-01f, 3.17127407e-02f, 8.52963850e-02f,
  -2.25329418e-02f, -8.38664919e-02f, 1.03778392e-01f, -1.25145493e-02f, -1.51286349e-01f, -3.27863009e-03f, -7.52864266e-03f, -1.69684321e-01f, 2.00761799e-02f, 2.80937552e-02f,
  9.50028151e-02f, 1.98451862e-01f, -1.44636288e-01f, -2.33088762e-01f, -4.91102412e-03f, -9.13558751e-02f, -3.04601695e-02f, -1.97962478e-01f, 4.26212959e-02f, 2.78278459e-02f,
  -6.90798163e-02f, -3.90919559e-02f, -1.31390527e-01f, -1.20228969e-01f, 1.19877897e-01f, -2.61967599e-01f, -6.09510802e-02f, 1.97223157e-01f, 9.65380482e-03f, 9.84775051e-02f,
  -9.41112451e-03f, -4.42558601e-02f, 2.03372668e-02f, -1.35114580e-01f, 4.35927846e-02f, 2.52027269e-02f, 1.70115471e-01f, -1.46520510e-01f, -1.14547582e-02f, -3.30090895e-02f,
  -1.45499811e-01f, -8.75917822e-02f, -4.96006384e-02f, -3.82315367e-02f, 3.48281139e-03f, -1.56775773e-01f, -5.85995577e-02f, 3.95360738e-02f, -8.07125568e-02f, -2.95445248e-02f,
  9.90455598e-02f, -8.37287456e-02f, 1.37714483e-03f, 1.19535336e-02f, 5.32099269e-02f, 1.22503154e-01f, -6.48746789e-02f, -2.24414751e-01f, 6.64004385e-02f, -1.40390143e-01f,
  4.95406389e-02f, -2.58619133e-02f, 1.36992782e-01f, -5.56246261e-04f, 8.56616721e-02f, 7.10498020e-02f, -5.60556762e-02f, 1.00038573e-01f, -2.92718905e-04f, -1.36956260e-01f,
  5.53351939e-02f, 5.33542112e-02f, -6.33308059e-03f, 2.24500801e-02f, 5.88443428e-02f, 4.88176523e-03f, 1.25071079e-01f, -1.65864918e-02f, 9.67539698e-02f, -4.82419394e-02f,
  9.04831439e-02f, -3.88915539e-02f, 1.04285532e-03f, -5.38274348e-02f, -4.72097769e-02f, 9.75304004e-03f, -2.28814147e-02f, -1.90841749e-01f, 3.40048559e-02f, 4.03192602e-02f,
  4.85071279e-02f, 7.21127763e-02f, -1.11063071e-01f, 1.08564489e-01f, -1.28500266e-02f, 1.00375816e-01f, 9.11425613e-03f, 5.65513298e-02f, -2.93445345e-02f, 9.19299491e-04f,
  1.45521481e-02f, 1.19927491e-03f, -9.56639498e-02f, 7.42019936e-02f, -4.96037789e-02f, 4.29565310e-02f, 1.83023974e-01f, -1.05188023e-02f, 1.66184027e-02f, 1.68663673e-02f,
  5.71060181e-02f, 5.11463694e-02f, -6.29517511e-02f, -4.04823273e-02f, 1.35962591e-02f, 2.40087938e-02f, -4.29601707e-02f, -7.43460879e-02f, -1.66062370e-01f, -3.80033185e-03f,
  1.81872267e-02f, -3.02892700e-02f, -1.32327084e-03f, -2.38633811e-01f, 4.25334424e-02f, 7.73810223e-03f, -3.83278867e-03f, 1.11282580e-01f, 5.83108775e-02f, -1.73691064e-02f,
  -4.70286533e-02f, -1.68698624e-01f, 4.81447875e-02f, -1.20031144e-02f, 1.33912181e-02f, 2.81334911e-02f, 1.16501808e-01f, -6.60068467e-02f, -1.06123976e-01f, 8.06384906e-02f,
  1.59602031e-01f, 2.31193632e-01f, -5.63670620e-02f, -4.36407253e-02f, -1.60505623e-01f, -1.34604275e-01f, 6.97287694e-02f, 8.02278966e-02f, 1.84739202e-01f, -1.52713537e-01f,
  -4.23422130e-03f, -7.42218867e-02f, -1.79765835e-01f, 1.01211131e-01f, 9.91971567e-02f, -2.55901009e-01f, -6.06231168e-02f, 4.74665798e-02f, 1.60565972e-01f, -3.33274156e-02f,
  -1.45440102e-02f, -3.92298633e-03f, 9.54547673e-02f, -1.08731769e-01f, -2.86835004e-02f, -5.98236658e-02f, 1.14640631e-01f, 1.33022472e-01f, 1.92524925e-01f, 4.05488312e-02f,
  1.70634724e-02f, -1.07390821e-01f, 4.64610616e-03f, -4.69109155e-02f, 7.51407668e-02f, 1.16310135e-01f, 7.64537379e-02f, 1.35463461e-01f, 7.13080168e-02f, 7.70638958e-02f,
  3.12535018e-02f, 2.87477933e-02f, 1.27789631e-01f, -2.25684959e-02f, -8.96409750e-02f, 1.83290601e-01f, 9.59386677e-03f, 9.42239761e-02f, -4.50693965e-02f, -2.23415494e-01f,
  -3.50344717e-03f, 4.68373261e-02f, -5.78091927e-02f, 1.04308590e-01f, -1.15390152e-01f, -3.21226045e-02f, 5.12862317e-02f, -5.28265897e-04f, 6.55963644e-02f, 2.18901951e-02f,
  7.39225745e-03f, -8.46347772e-03f, 3.40420902e-02f, -1.14356950e-02f, 7.19107836e-02f, -7.08162338e-02f, 1.64269544e-02f, -6.11547790e-02f, 1.04010820e-01f, 2.37464458e-02f,
  7.19725341e-02f, -2.10078154e-02f, 4.55748998e-02f, 5.62330661e-03f, 7.55724460e-02f, -5.93850762e-02f, 5.21247052e-02f, -9.29825604e-02f, 1.16621023e-02f, 5.93253076e-02f,
  4.00259644e-02f, 5.19356206e-02f, 5.31549267e-02f, -8.67506787e-02f, 3.61585733e-03f, 2.55986098e-02f, 6.87162951e-02f, -2.27299082e-04f, -1.20375186e-01f, -7.74932839e-03f,
  -3.93420942e-02f, 9.52553283e-03f, 5.62668890e-02f, -6.55186400e-02f, -5.82439005e-02f, 2.33204942e-02f, -3.90110463e-02f, -2.68293507e-02f, -3.47116590e-02f, -2.84281326e-03f,
  7.47488067e-02f, -3.23485434e-02f, -1.66291147e-02f, 6.91642389e-02f, -5.39835952e-02f, -5.94814904e-02f, 5.80618009e-02f, 1.51822820e-01f, 1.36296958e-01f, -1.56205893e-01f,
  -1.27546385e-01f, 3.04524377e-02f, -8.46717134e-02f, -5.31896427e-02f, -5.03221527e-02f, -2.38854095e-01f, 8.49534497e-02f, 1.13764117e-02f, 1.06388278e-01f, 9.61119831e-02f,
  -3.00226435e-02f, -1.56308189e-01f, 1.02389127e-01f, 1.32193476e-01f, -1.40004009e-01f, -5.04799820e-02f, -7.66931521e-03f, -2.41181068e-02f, 2.78706122e-02f, -1.12509124e-01f,
  5.83190396e-02f, 1.17147602e-01f, 1.57152191e-01f, 2.20161140e-01f, -5.63076362e-02f, -3.94642279e-02f, -1.65984377e-01f, 1.21785857e-01f, 8.69022533e-02f, 1.33211121e-01f,
  1.10429220e-01f, 5.97872436e-02f, -3.57637033e-02f, 1.55102581e-01f, 4.95351525e-03f, -8.39034691e-02f, -7.47416168e-02f, 8.38720873e-02f, 1.15552165e-01f, 6.59669787e-02f,
  -1.26886114e-01f, 4.65163141e-02f, -9.92854834e-02f, 1.31411806e-01f, -1.22392206e-02f, -3.89638208e-02f, -2.57227477e-02f, -9.52100158e-02f, 1.69044614e-01f, 1.90489724e-01f,
  7.24178106e-02f, 1.96551725e-01f, 5.18236868e-02f, 2.69992836e-02f, -8.00314099e-02f, -9.24147889e-02f, -6.50206134e-02f, 1.53699875e-01f, 5.99229783e-02f, 1.19986422e-01f,
  -8.69066343e-02f, 6.66857064e-02f, 1.31272331e-01f, 1.38017997e-01f, 9.09898356e-02f, -1.25823751e-01f, -4.99735102e-02f, 1.11262336e-01f, 1.09528052e-02f, 7.47717842e-02f,
  -1.55234858e-01f, -7.09679350e-02f, 1.00228980e-01f, 6.60506496e-03f, 9.46522951e-02f, -2.99055427e-02f, -3.96796316e-02f, -3.04823387e-02f, -2.85292473e-02f, 5.09671010e-02f,
  -6.23624176e-02f, 3.88417467e-02f, 3.33972573e-02f, -1.25719666e-01f, -3.47827357e-04f, -4.08151140e-03f, 1.09397441e-01f, 7.95161352e-03f, -8.74243602e-02f, 6.39814809e-02f,
  5.62807918e-02f, 5.15274182e-02f, 5.95675558e-02f, 1.08030974e-03f, -8.45322832e-02f, -3.95310484e-02f, 1.12839386e-01f, -1.41613968e-02f, 4.90197241e-02f, 1.24114469e-01f,
  3.31223048e-02f, 2.21480858e-02f, 4.07157131e-02f, -3.33871953e-02f, 3.27600166e-02f, 3.48220915e-02f, -1.62193533e-02f, -9.42112040e-03f, 2.08874643e-02f, 3.26015726e-02f,
  8.77015069e-02f, 2.66546682e-02f, 1.15312785e-01f, 1.11640608e-02f, -3.43107954e-02f, -1.13434412e-01f, 4.12531197e-02f, -3.37782539e-02f, -5.18644229e-02f, -2.81373840e-02f,
  1.14073880e-01f, 6.55408204e-02f, -4.18621972e-02f, -5.70482276e-02f, -5.50064966e-02f, 8.56674686e-02f, 6.68736128e-03f, 5.85752800e-02f, -1.12973489e-01f, 1.80188447e-01f,
  -1.25367403e-01f, -4.95922640e-02f, -1.08644068e-02f, 2.35413969e-03f, -2.20202468e-02f, 1.10692233e-01f, 1.80473015e-01f, -2.51365080e-02f, 1.27820581e-01f, -1.04914069e-01f,
  1.22948155e-01f, -1.30688086e-01f, 2.13710349e-02f, -7.70449266e-02f, 2.05984563e-02f, 1.70405269e-01f, 1.51204079e-01f, 1.06124081e-01f, 3.15227872e-03f, 5.06709889e-02f,
  -9.74643901e-02f, -5.94858862e-02f, 6.13189042e-02f, 1.21564634e-01f, -1.54923826e-01f, -1.37731910e-01f, 1.46393389e-01f, -2.72031147e-02f, 9.37495381e-02f, -3.75853367e-02f,
  6.13764720e-03f, 7.52194449e-02f, 1.02632485e-01f, 1.35453045e-02f, -4.76160683e-02f, -4.82971892e-02f, 1.31164163e-01f, -5.41540645e-02f, 1.81093253e-02f, -1.03303995e-02f,
  4.73100692e-02f, 7.91360885e-02f, 5.91416843e-02f, 5.47891520e-02f, 3.51736210e-02f, -1.94949154e-02f, -2.39622016e-02f, -9.94291231e-02f, -3.49027989e-03f, -7.81327412e-02f,
  4.06535715e-02f, 2.07863286e-01f, -7.22881779e-02f, 3.54737528e-02f, -3.39983664e-02f, -4.48484123e-02f, 1.25592798e-01f, 4.38040011e-02f, 4.55531739e-02f, 6.41741455e-02f,
  -1.48245260e-01f, 1.06504053e-01f, -3.46138142e-02f, -1.01436630e-01f, 1.17642777e-02f, -8.66285115e-02f, 1.30740345e-01f, 1.91247374e-01f, -9.00142342e-02f, 9.67010204e-03f,
  1.17959611e-01f, 3.25112753e-02f, 6.15692101e-02f, 6.16314933e-02f, -7.69916596e-03f, 8.67566280e-03f, 1.44154420e-02f, 7.11638629e-02f, -4.94325496e-02f, 2.40498781e-02f,
  -8.59364122e-02f, -3.84557922e-03f, -6.99155778e-02f, -4.03750241e-02f, -4.05022800e-02f, 3.45039926e-02f, -1.12923712e-03f, -5.72288595e-02f, 4.41426411e-03f, -1.84000637e-02f,
  -6.47723377e-02f, 1.12236403e-01f, -1.16208024e-01f, -4.71318811e-02f, 8.48082155e-02f, -3.06251645e-02f, -8.65271762e-02f, 9.67689008e-02f, -1.77798141e-02f, -4.50094417e-02f,
  -3.10603529e-03f, -8.70583504e-02f, -4.45189327e-02f, 8.81060585e-02f, 1.08330294e-01f, -1.14176817e-01f, 1.34099960e-01f, -2.92508453e-02f, 2.44325642e-02f, 1.08816601e-01f,
  8.30541477e-02f, -1.84557140e-02f, 1.13939524e-01f, -9.46435407e-02f, -5.20334542e-02f, 7.15463655e-03f, -8.47580954e-02f, -1.34199103e-02f, 8.54882672e-02f, -5.42265959e-02f,
  -1.01883709e-01f, -2.88703162e-02f, -3.67094725e-02f, -8.46176315e-03f, -6.51949644e-02f, 1.58793449e-01f, -4.74758707e-02f, 1.26775026e-01f, -8.79369583e-03f, 6.55916929e-02f,
  -4.80332151e-02f, 2.06078812e-01f, -6.92520011e-03f, 1.11590222e-01f, 1.14682570e-01f, -5.71335964e-02f, 6.56442121e-02f, 6.09782487e-02f, -6.14452176e-02f, -2.54196167e-01f,
  7.46026263e-02f, 6.46897266e-03f, 4.46034931e-02f, -1.01219289e-01f, -8.86683986e-02f, -3.42933051e-02f, -1.60610124e-01f, -1.63420945e-01f, 4.80780192e-02f, 1.01776673e-02f,
  8.56420547e-02f, 1.20801024e-01f, -5.45935482e-02f, -8.50655138e-02f, 9.36841369e-02f, -1.41767204e-01f, 5.59701510e-02f, -5.33344187e-02f, 1.02720849e-01f, 1.68502424e-02f,
  1.12993516e-01f, 5.05884513e-02f, 2.98051201e-02f, -1.01250581e-01f, -1.17920756e-01f, -7.21377805e-02f, 9.41448510e-02f, 1.39728352e-01f, 3.67840193e-02f, 1.14483275e-01f,
  -2.64314134e-02f, -3.79208736e-02f, 1.26002714e-01f, 1.71127096e-01f, -2.77350843e-01f, 3.62316109e-02f, -1.13702780e-02f, -1.22619443e-01f, 1.33912666e-02f, -3.15494202e-02f,
  -4.20523947e-03f, -1.66318193e-02f, -1.81812242e-01f, -1.87134907e-01f, -6.43054303e-03f, -6.68788329e-02f, 9.51017253e-03f, 7.17257485e-02f, -9.19312984e-02f, -6.32760376e-02f,
  -7.01137725e-03f, 6.68282211e-02f, 8.24960470e-02f, -1.01089235e-02f, -8.00153017e-02f, 1.50486203e-02f, 1.58511922e-01f, -1.10254325e-01f, -8.04243907e-02f, 2.83618346e-02f,
  -3.80003713e-02f, 7.87955970e-02f, 5.17527312e-02f, 1.00348741e-01f, 6.57679364e-02f, 8.73415619e-02f, 5.97460270e-02f, 1.56109473e-02f, 8.98282602e-02f, 2.70520896e-02f,
  -3.82981822e-02f, 1.28266856e-01f, 2.59312186e-02f, 2.88913790e-02f, -2.75340024e-02f, -9.23789516e-02f, 6.91929087e-02f, 3.15231606e-02f, 2.47735400e-02f, -1.12178214e-02f,
  1.64858580e-01f, 5.06999232e-02f, -8.59399885e-02f, 5.66114821e-02f, 1.63731426e-02f, -1.02125466e-01f, -7.02455491e-02f, 9.57553759e-02f, -3.18947397e-02f, -4.77615595e-02f,
  8.80108327e-02f, 1.14160189e-02f, -7.48021528e-02f, -3.14176525e-03f, 5.35700470e-02f, 5.82013652e-02f, -6.56930208e-02f, 2.98868604e-02f, 4.01353650e-02f, 6.58632219e-02f,
  6.73713535e-02f, 1.05760358e-01f, 7.38755018e-02f, -1.54823007e-03f, 1.75877812e-03f, 8.76849964e-02f, 4.97247614e-02f, 2.57350598e-03f, 2.53262937e-01f, -5.25774024e-02f,
  1.52571991e-01f, -1.72450766e-02f, -2.92654522e-02f, -1.20395370e-01f, 1.86516851e-01f, -2.53563434e-01f, -5.88852689e-02f, 5.40047921e-02f, 1.47525519e-02f, 5.13870362e-03f,
  3.41326557e-02f, -7.49707893e-02f, -8.43930393e-02f, -1.77962109e-02f, -2.95972191e-02f, -1.31683022e-01f, 8.80907178e-02f, 1.37238920e-01f, 3.45364995e-02f, -7.26511329e-02f,
  -2.38494515e-01f, 2.52999477e-02f, -1.11074205e-02f, 2.95675639e-02f, 9.38999206e-02f, -1.55766038e-02f, -1.97922319e-01f, -9.20383558e-02f, -3.23555171e-02f, -1.72255874e-01f,
  2.51624864e-02f, -2.45194659e-02f, -9.26012173e-02f, 5.91969453e-02f, -3.02267652e-02f, 3.91776785e-02f, -2.61990309e-01f, -8.40241015e-02f, -1.55260423e-02f, 9.75194499e-02f,
  2.90288310e-02f, 2.82385554e-02f, -2.09485423e-02f, -5.31497523e-02f, -1.73961565e-01f, -1.55165657e-01f, -1.85073521e-02f, -8.47436488e-02f, 2.88388990e-02f, 1.02920696e-01f,
  -1.00555196e-01f, -8.87933448e-02f, 1.88632667e-01f, -6.96889907e-02f, -1.92571506e-01f, 1.86062288e-02f, -2.06029698e-01f, 7.09518045e-02f, -1.49052162e-02f, -1.09367587e-01f,
  2.18299955e-01f, 4.13550958e-02f, -1.45235345e-01f, -7.95482695e-02f, 6.20111749e-02f, -2.30260074e-01f, 3.29662003e-02f, -2.89527252e-02f, -2.13607885e-02f, -1.13344975e-01f,
  -1.32907435e-01f, -8.71324465e-02f, 8.96924138e-02f, -6.01518005e-02f, 1.51394326e-02f, 1.59924001e-01f, -2.83374991e-02f, 1.16391122e-01f, -8.92314240e-02f, 1.02494163e-02f,
  -4.77605350e-02f, 2.46959422e-02f, 1.50563642e-01f, 6.50430918e-02f, 3.90211493e-02f, -1.33027975e-02f, 3.57388519e-02f, 9.31369662e-02f, -1.92468800e-02f, 2.83356812e-02f,
  1.42878713e-02f, -2.67601516e-02f, -2.94022225e-02f, -8.90686661e-02f, -1.91036724e-02f, 1.72100104e-02f, -8.00670907e-02f, -5.47668710e-02f, 1.02415211e-01f, -9.41944681e-03f,
  7.08349561e-03f, 4.14864607e-02f, -1.25743877e-02f, -3.56570296e-02f, -1.42101228e-01f, 1.30332410e-01f, -2.40714140e-02f, 4.40411158e-02f, -2.99432054e-02f, 6.00795150e-02f,
  2.12009512e-02f, 1.15971556e-02f, -7.84876850e-03f, 1.28002852e-01f, -8.34148824e-02f, -2.13786168e-03f, 8.43748972e-02f, 3.87113653e-02f, 5.59688397e-02f, 1.12064034e-01f,
  1.86663435e-03f, 7.23826215e-02f, -3.65824141e-02f, 9.08403844e-02f, -3.29405740e-02f, -4.08721827e-02f, 6.24468699e-02f, -5.82763106e-02f, -9.19783562e-02f, 1.30203635e-01f,
  1.25462949e-01f, -8.60365704e-02f, 1.53837651e-01f, -2.48780772e-01f, 1.47160158e-01f, 9.48408470e-02f, -1.43662333e-01f, 1.86112169e-02f, 6.20630607e-02f, -4.98003848e-02f,
  -1.65442631e-01f, -3.25406082e-02f, -1.12609267e-01f, -5.92241436e-02f, 1.68313608e-02f, -3.35692731e-03f, -4.49437834e-03f, 6.03067763e-02f, -1.56057686e-01f, 9.77292843e-03f,
  1.24759272e-01f, -2.41168588e-02f, -5.78862727e-02f, -1.15506083e-01f, -1.26084819e-01f, -1.56620920e-01f, 2.14092545e-02f, 2.09556650e-02f, 4.84353118e-02f, -1.28641382e-01f,
  -1.55655622e-01f, 1.03058107e-01f, -9.07498002e-02f, 5.69727793e-02f, -4.78295684e-02f, -1.71120420e-01f, 1.75812114e-02f, 3.45408805e-02f, 7.12433234e-02f, -1.03092320e-01f,
  -1.00540891e-01f, -2.44319811e-02f, 2.02776957e-02f, -1.05017401e-01f, -2.25019734e-02f, -1.29828840e-01f, 1.20938204e-01f, 6.11747243e-02f, 5.59680164e-02f, 5.37323430e-02f,
  1.21449448e-01f, -1.15041398e-01f, -1.08846739e-01f, -5.23951650e-02f, 5.39406091e-02f, 3.36891250e-03f, 1.06781557e-01f, 1.18137494e-01f, 1.27396628e-01f, 7.04244301e-02f,
  -1.62893802e-01f, 7.34189749e-02f, 6.67341873e-02f, -1.16681248e-01f, -2.79796664e-02f, -1.60035808e-02f, -1.15435511e-01f, 7.84879923e-02f, -5.10212518e-02f, -1.03027031e-01f,
  2.28304639e-01f, -1.15613975e-01f, -5.30098937e-02f, 5.99617895e-04f, 7.49166906e-02f, 3.93027626e-02f, -6.77225962e-02f, 1.09855197e-01f, 6.22915151e-03f, 8.66606683e-02f,
  6.20015599e-02f, -2.47083288e-02f, 5.98497577e-02f, 3.24866623e-02f, 5.06547578e-02f, -6.04828410e-02f, 2.99579017e-02f, 8.43363479e-02f, -1.95725001e-02f, 4.49620821e-02f,
  -1.74201764e-02f, 2.12872289e-02f, 3.61576490e-02f, -6.86398670e-02f, -6.25167936e-02f, 1.39498319e-02f, 1.05230331e-01f, -3.82205620e-02f, 3.62025797e-02f, 3.57377157e-02f,
  -7.86628649e-02f, -7.44170025e-02f, -8.66079181e-02f, 8.34888220e-02f, -9.16524082e-02f, -1.25284260e-03f, -3.28059644e-02f, 2.87706330e-02f, 2.36058328e-02f, 6.86358064e-02f,
  7.89557695e-02f, -8.02643970e-02f, 1.04148397e-02f, 5.95215484e-02f, -7.28781074e-02f, 3.35643850e-02f, -4.07507904e-02f, 6.64660409e-02f, 5.90764430e-05f, -1.79653447e-02f,
  3.05324178e-02f, 6.14573285e-02f, -1.00504242e-01f, 6.27966076e-02f, 3.19734737e-02f, -5.48684448e-02f, 6.52748272e-02f, -4.07956205e-02f, -1.63942873e-02f, 1.21833542e-02f,
  1.20911598e-01f, -1.86122045e-01f, 2.60000434e-02f, 7.16228560e-02f, -6.94961697e-02f, -1.94654092e-02f, -1.74271047e-01f, -7.38043338e-03f, -1.24100363e-02f, 8.22983235e-02f,
  2.00865734e-02f, 3.44907194e-02f, -1.88222200e-01f, 1.14738986e-01f, 1.18351191e-01f, -2.51427609e-02f, -1.05411008e-01f, -1.14774100e-01f, -3.53691466e-02f, -8.33141133e-02f,
  7.86869302e-02f, 9.17162150e-02f, -1.67509660e-01f, -1.54836446e-01f, -1.23342432e-01f, -1.84884846e-01f, 1.93751723e-01f, 3.36608738e-02f, -8.91160667e-02f, 1.00095887e-02f,
  -1.93748981e-01f, -8.71657431e-02f, -1.12257928e-01f, -1.07092209e-01f, -6.37916550e-02f, 1.13575682e-01f, 1.09842911e-01f, -3.03624533e-02f, -1.74680367e-01f, -9.35844053e-03f,
  5.88761317e-03f, -4.65318412e-02f, -1.23916334e-02f, -1.35824442e-01f, 8.89429674e-02f, 1.42806754e-01f, 9.68290493e-02f, -5.66994287e-02f, -4.78764763e-03f, -5.69383986e-02f,
  -7.05511309e-03f, 6.68577179e-02f, 1.94738597e-01f, -8.92323479e-02f, -6.62564263e-02f, 1.95163861e-01f, 1.56176686e-01f, 4.44858074e-02f, -8.23562518e-02f, 2.46570036e-02f,
  1.17209971e-01f, 8.52052718e-02f, 1.18982919e-01f, -1.06518693e-01f, -2.53338274e-02f, -5.30843448e-04f, 8.19513202e-02f, 3.47758010e-02f, -1.63643435e-02f, -1.28714859e-01f,
  1.95297197e-01f, 2.33863927e-02f, -2.23944075e-02f, -5.19773774e-02f, -6.43940037e-03f, 3.97949219e-02f, 3.26454788e-02f, 6.73785955e-02f, 6.63580224e-02f, -6.16489165e-02f,
  8.86058062e-02f, -3.14676948e-02f, 3.63635682e-02f, 1.50801048e-01f, 3.02261044e-03f, 6.86082942e-03f, -6.05680235e-02f, -5.14929369e-02f, 8.09370577e-02f, 8.28573182e-02f,
  -2.58090291e-02f, -3.10136937e-02f, -8.87101609e-03f, 5.25763929e-02f, 1.38074547e-01f, 8.62702653e-02f, -9.76176783e-02f, 1.36348203e-01f, -2.16735415e-02f, -1.24187596e-01f,
  -6.79500476e-02f, 8.63903537e-02f, -1.23360576e-02f, 6.21019192e-02f, -2.19439957e-02f, 6.75513148e-02f, 1.32313043e-01f, 7.82026798e-02f, 8.12189877e-02f, 2.67487783e-02f,
  -5.28436229e-02f, 2.24225176e-03f, -5.84655069e-02f, 1.02668993e-01f, 1.02989897e-01f, 1.10166065e-01f, 1.00457504e-01f, 4.00698632e-02f, 4.51402925e-02f, -6.17822539e-03f,
  -3.14644054e-02f, -5.86424842e-02f, 9.78405774e-02f, 9.39417705e-02f, -4.85352166e-02f, -1.11536287e-01f, -2.98174750e-02f, -1.67061146e-02f, 1.56304523e-01f, -1.38658047e-01f,
  1.28424734e-01f, 5.97637855e-02f, -2.80043688e-02f, 4.52855341e-02f, -1.88410264e-02f, -1.79101110e-01f, -1.18253611e-01f, -4.99045774e-02f, -7.10329637e-02f, 1.44438356e-01f,
  -1.77442521e-01f, 3.16552743e-02f, 6.28585964e-02f, 7.63853863e-02f, -4.66247685e-02f, -1.95483446e-01f, -7.10613877e-02f, -2.47041322e-03f, -5.02385534e-02f, -1.33609222e-02f,
  -1.94269624e-02f, -5.75778075e-02f, -9.25353542e-02f, -2.75968406e-02f, 1.66514188e-01f, 6.72268728e-03f, -6.73604533e-02f, 8.56793374e-02f, -1.47244737e-01f, -3.58545855e-02f,
  -2.57405583e-02f, -1.49329811e-01f, -1.17179945e-01f, 6.37974683e-03f, 1.12777531e-01f, -4.66363095e-02f, -1.39076293e-01f, 1.14690766e-01f, -7.85118863e-02f, -9.81636867e-02f,
  5.04913814e-02f, -1.09947875e-01f, 4.07058746e-02f, 3.46340612e-02f, 1.00893699e-01f, 2.35985722e-02f, -5.90963848e-03f, 4.13799435e-02f, -6.98525161e-02f, 2.54459828e-02f,
  -1.03809135e-02f, -1.50196686e-01f, 3.08940988e-02f, 2.09224559e-02f, 2.16263160e-01f, 6.99467212e-02f, -1.63816199e-01f, -3.66798230e-02f, 7.38204867e-02f, -8.70668516e-02f,
  9.64974463e-02f, -1.78539440e-01f, -8.68910030e-02f, 1.33036509e-01f, 6.59711240e-03f, 3.40438783e-02f, -1.52336404e-01f, -1.97874889e-01f, 8.21860135e-02f, 8.36981535e-02f,
  -1.95291284e-02f, -1.53589528e-02f, -6.05389737e-02f, 1.34612732e-02f, 2.00027674e-02f, 3.94260883e-02f, 2.63506137e-02f, -2.28814296e-02f, 7.16287643e-02f, -1.09143052e-02f,
  5.57832373e-03f, 9.09512267e-02f, 3.23579334e-05f, -9.87001415e-03f, -1.65835135e-02f, -3.24423313e-02f, 4.39110585e-03f, 7.82985464e-02f, -7.63123333e-02f, -3.63973752e-02f,
  -5.93198463e-02f, 7.64104119e-03f, 7.60585964e-02f, 1.11832358e-01f, 1.16179474e-02f, 7.70867541e-02f, -6.61283061e-02f, -5.91584146e-02f, -4.70175333e-02f, 6.01792336e-02f,
  -4.01667319e-02f, 6.88794926e-02f, -9.08390619e-03f, 2.76162811e-02f, 1.02745615e-01f, 4.77930345e-02f, 5.70438616e-02f, 5.42064831e-02f, -1.38494208e-01f, -7.65345013e-03f,
  1.54556874e-02f, 1.66285038e-02f, 5.14260344e-02f, 2.85702199e-02f, -6.43759314e-03f, 2.32606176e-02f, 5.46810441e-02f, 5.34382975e-03f, -7.04810098e-02f, -1.45013072e-02f,
  8.07992816e-02f, 3.55457850e-02f, -1.04939274e-01f, -8.48907456e-02f, -6.97841644e-02f, -7.12704472e-03f, 1.34633943e-01f, -2.08281547e-01f, 7.26593435e-02f, 8.07904154e-02f,
  9.10236873e-03f, 8.23786855e-02f, -4.72827628e-02f, -1.27012044e-01f, -1.13746598e-01f, -6.65211678e-02f, -4.54667285e-02f, 9.41429064e-02f, -1.64792806e-01f, -9.99979023e-03f,
  1.07185625e-01f, 5.46279587e-02f, -4.35551777e-02f, -4.20961343e-02f, 2.84860339e-02f, 1.91088766e-02f, -9.56310797e-03f, -5.78773394e-02f, -8.13655108e-02f, -1.06113158e-01f,
  -5.47735281e-02f, -2.00010389e-02f, 2.49463141e-01f, -3.51152681e-02f, -9.76599157e-02f, 2.35622525e-02f, -1.70887053e-01f, -7.47869611e-02f, 1.11363232e-02f, -1.54539898e-01f,
  -9.58926082e-02f, 6.61987364e-02f, 1.42575622e-01f, -2.10791938e-02f, -1.79937452e-01f, 4.09870856e-02f, -4.61810306e-02f, -1.29533604e-01f, 7.01790601e-02f, -1.16073303e-01f,
  1.40342414e-01f, 9.76108834e-02f, 6.70143291e-02f, 1.65486224e-02f, -1.15291774e-02f, -1.54409364e-01f, -9.57931951e-02f, -1.35836732e-02f, 6.57116175e-02f, -8.76419768e-02f,
  1.06324935e-02f, 1.05719574e-01f, 1.71481803e-01f, 7.30548650e-02f, -1.61225542e-01f, 1.26504572e-02f, 1.16354689e-01f, -9.82708111e-02f, 1.14185721e-01f, -1.62507132e-01f,
  -7.12000430e-02f, 5.98674342e-02f, -4.53794263e-02f, -1.10272214e-01f, -8.49465430e-02f, -1.92748114e-01f, 1.26491666e-01f, 1.17939837e-01f, 1.19726909e-02f, -1.41703680e-01f,
  6.06473833e-02f, 8.80049840e-02f, 2.14139856e-02f, -2.47764029e-03f, -2.00752631e-01f, -8.29051137e-02f, 3.33740795e-03f, 5.24810366e-02f, 4.92686294e-02f, -6.36987761e-02f,
  4.67751324e-02f, -3.40177752e-02f, 1.97462495e-02f, 2.27760244e-02f, 1.31797409e-02f, 1.03951268e-01f, -2.56992467e-02f, 9.21048447e-02f, -3.23249176e-02f, -6.88505843e-02f,
  -7.76796490e-02f, 1.50908867e-03f, 7.13070631e-02f, 7.30926869e-04f, -1.25729352e-01f, -2.16452349e-02f, 6.96243867e-02f, 6.27837284e-03f, -5.85817024e-02f, 5.49716577e-02f,
  -3.46416086e-02f, -1.13595009e-01f, -2.27777828e-02f, 1.09360293e-01f, -3.73127088e-02f, -1.04644917e-01f, 2.13505160e-02f, 5.02455868e-02f, -1.03621474e-02f, 8.24200362e-02f,
  -4.87062559e-02f, -2.56285071e-02f, 3.94312218e-02f, 3.08968453e-03f, 2.16514356e-02f, -6.06079400e-02f, -7.85428211e-02f, -8.89891535e-02f, -9.57223121e-03f, 5.04571274e-02f,
  2.65753549e-02f, -1.68886259e-01f, -1.80607140e-01f, 6.44756109e-02f, 1.22143961e-02f, 9.08172727e-02f, -1.90053672e-01f, -2.07871348e-02f, 2.15168923e-01f, 4.62118238e-02f,
  -2.78489590e-02f, -4.80754505e-04f, 2.11701319e-02f, -1.76351413e-01f, 1.21951057e-03f, 1.00173764e-01f, -1.20195515e-01f, -4.29017320e-02f, 1.56818822e-01f, 2.03298368e-02f,
  2.72916287e-01f, 9.77370217e-02f, -2.32162431e-01f, 1.19333379e-01f, 1.35822976e-02f, -6.51681051e-02f, -1.03849821e-01f, 6.09194599e-02f, 6.27403185e-02f, -9.69290212e-02f,
  1.47565722e-01f, 9.38082114e-02f, -5.30232936e-02f, -1.52308926e-01f, -1.01439163e-01f, 2.77640913e-02f, -4.79019806e-02f, 5.05796298e-02f, -6.12098444e-03f, 6.80984035e-02f,
  1.01648815e-01f, 9.44780931e-02f, 1.09022453e-01f, 3.91306207e-02f, 2.07389574e-02f, 5.30902296e-02f, 1.19874202e-01f, -2.14769378e-01f, 2.14031786e-02f, -3.87173407e-02f,
  -1.28420711e-01f, 3.78040806e-03f, -2.49973401e-01f, -1.43653825e-01f, 7.52867460e-02f, -1.82325974e-01f, -4.43393923e-02f, 3.84503305e-02f, 6.77245036e-02f, -6.74086483e-03f,
  2.14230753e-02f, 3.86191756e-02f, 1.65277451e-01f, -1.87873229e-01f, 9.21198204e-02f, -2.88398825e-02f, -3.53351166e-03f, 2.61551086e-02f, 1.60787195e-01f, 1.25839855e-04f,
  -9.71680582e-02f, -1.26920298e-01f, -2.10404873e-01f, -2.80832276e-02f, 8.95055085e-02f, 2.51297742e-01f, -1.11035787e-01f, 6.76191004e-04f, 5.98702244e-02f, -6.22350089e-02f,
  -5.69075830e-02f, 1.38709359e-02f, -3.05777863e-02f, 1.08945987e-03f, -6.81204125e-02f, -3.22997756e-02f, 3.21762986e-03f, -2.24797260e-02f, 3.10060717e-02f, 3.33354101e-02f,
  2.27242392e-02f, -9.01809987e-03f, 2.51520239e-02f, 7.06723630e-02f, 6.72857687e-02f, -2.94055995e-02f, -3.47863277e-03f, 8.65139626e-03f, -5.54410331e-02f, -9.01455358e-02f,
  4.08441238e-02f, -7.72067392e-03f, 1.42862767e-01f, 2.63024122e-02f, 1.19481822e-02f, -1.52600929e-01f, -5.10012880e-02f, -3.86043936e-02f, 1.40116764e-02f, -1.84002966e-02f,
  -4.94826846e-02f, -8.85353610e-02f, 6.16778471e-02f, -3.45075466e-02f, 7.37581551e-02f, -5.00268191e-02f, -1.33974567e-01f, -3.52573432e-02f, -1.15601033e-01f, -1.74505770e-01f,
  -5.15967570e-02f, -1.65161397e-02f, -3.48215252e-02f, -6.25207126e-02f, 6.51802272e-02f, 1.78849753e-02f, -1.27737701e-01f, -2.14583799e-02f, 1.99531056e-02f, 2.83034518e-02f,
  1.00376688e-01f, 1.32892728e-02f, -1.78660676e-01f, 1.34901792e-01f, -6.07688688e-02f, -1.15442634e-01f, 3.30581330e-02f, -8.54173079e-02f, -9.50643197e-02f, 1.24405205e-01f,
  1.41064420e-01f, 9.70580503e-02f, 1.15357682e-01f, -1.77758839e-02f, 4.21441123e-02f, 9.08672065e-02f, -1.05295911e-01f, -2.24649888e-02f, 7.76499063e-02f, -5.95374219e-02f,
  7.72829354e-02f, 1.57451499e-02f, 1.33286551e-01f, 1.57275617e-01f, 6.70899972e-02f, 1.87931702e-01f, -6.21712543e-02f, 3.39919999e-02f, -1.03761695e-01f, 4.07066084e-02f,
  1.74409106e-01f, -7.97303207e-03f, 6.81836009e-02f, 4.94881067e-03f, 7.81786591e-02f, 7.86850154e-02f, 1.04694460e-02f, -1.02000266e-01f, -1.60304964e-01f, 2.35207025e-02f,
  8.37429538e-02f, 1.09411357e-02f, -1.27251325e-02f, 4.39559631e-02f, -6.03222735e-02f, 2.00194836e-01f, 2.42344923e-02f, -3.59141082e-02f, -1.34298187e-02f, -4.22269180e-02f,
  -2.25336268e-03f, 2.32695788e-02f, 5.30318469e-02f, 1.98288977e-01f, 1.20370254e-01f, -3.81400320e-03f, -1.20784648e-01f, 2.06705201e-02f, -1.51354179e-01f, 1.73128452e-02f,
  1.39937237e-01f, 1.23810001e-01f, -1.78466439e-01f, 8.06762204e-02f, 4.54599075e-02f, 8.73360559e-02f, 1.04871606e-02f, -9.53636914e-02f, 1.52724624e-01f, 1.59741387e-01f,
  -2.39152033e-02f, 1.03320748e-01f, -5.43433800e-02f, -1.34710953e-01f, -1.37665153e-01f, 7.96241537e-02f, -1.21320680e-01f, -1.35950327e-01f, -3.73637676e-02f, 4.47434112e-02f,
  2.67952997e-02f, 1.29578292e-01f, 3.52474339e-02f, 3.38035412e-02f, 8.70747343e-02f, 7.39917904e-03f, 1.12705557e-02f, 9.04048979e-02f, -3.21836099e-02f, -9.25390124e-02f,
  -1.39194921e-01f, -9.60571170e-02f, 1.07854158e-02f, -1.60965025e-02f, -6.43207133e-02f, -6.38792813e-02f, 4.34603766e-02f, -3.67370620e-02f, -6.83969110e-02f, -5.40838316e-02f,
  -4.04013135e-02f, -7.63673112e-02f, -6.10350966e-02f, 8.34615752e-02f, 1.48906475e-02f, 3.16165411e-03f, -3.12853940e-02f, -4.60967771e-04f, 2.97815669e-02f, 3.21129560e-02f,
  -6.15758337e-02f, 6.94227666e-02f, -4.78572808e-02f, 3.37639712e-02f, 1.36676937e-01f, 6.48888946e-03f, 1.46420626e-02f, 1.12179540e-01f, -1.51354196e-02f, 3.83835211e-02f,
  -1.21809304e-01f, 7.64677823e-02f, -2.30035628e-03f, -5.53701147e-02f, 1.06365591e-01f, -6.81165606e-02f, -5.55221252e-02f, 8.63247439e-02f, 8.91753510e-02f, -1.05283171e-01f,
  1.14496931e-01f, -2.33715206e-01f, 4.03998010e-02f, -2.71719396e-02f, -7.33466223e-02f, 6.12455308e-02f, 1.24854892e-01f, 3.95659208e-02f, -8.98538977e-02f, -9.77594499e-03f,
  1.93362199e-02f, -1.13375805e-01f, 1.31473556e-01f, 1.42113697e-02f, 8.21681973e-03f, 2.60168016e-02f, -2.02353418e-01f, 1.37323529e-01f, 1.73819810e-01f, 1.24909498e-01f,
  2.94647776e-02f, -9.57610086e-02f, -1.57271549e-01f, -1.25782192e-01f, 9.75533277e-02f, -7.36070098e-03f, -4.86431941e-02f, -1.15898550e-01f, -1.23716213e-01f, 7.93537721e-02f,
  -6.75899535e-02f, 1.12084888e-01f, -1.23211965e-01f, -1.84470922e-01f, 6.39965758e-02f, 6.82484061e-02f, 4.67019230e-02f, 4.11601155e-04f, 4.19018939e-02f, -8.24894905e-02f,
  -1.49087766e-02f, -1.30361006e-01f, -3.53288352e-02f, -4.46587913e-02f, 6.43287227e-02f, 7.75965005e-02f, 3.58187556e-02f, 4.88877408e-02f, 1.81933731e-01f, -7.38750547e-02f,
  -6.17527589e-02f, -7.53321052e-02f, -7.77144656e-02f, 4.15085107e-02f, 1.09150834e-01f, -7.58673921e-02f, 1.63509816e-01f, 4.89801690e-02f, -1.44381106e-01f, -5.48180528e-02f,
  4.24042456e-02f, -1.77983761e-01f, -8.89721960e-02f, 8.36455002e-02f, -1.03239045e-01f, 1.55678540e-01f, -1.11723565e-01f, -1.67318851e-01f, 1.77677646e-01f, -1.11544669e-01f,
  -1.30614355e-01f, -9.11364798e-04f, -2.66935490e-02f, 9.24380682e-03f, -4.76354025e-02f, -4.33442555e-02f, -1.03455499e-01f, -1.43344298e-01f, -8.93590525e-02f, -6.20274767e-02f,
  -2.12426074e-02f, -7.88782388e-02f, -1.86320767e-01f, -6.31251112e-02f, -2.61288299e-03f, -6.48042187e-02f, -9.86322686e-02f, -5.13220429e-02f, -3.70228700e-02f, 5.53561896e-02f,
  -7.90350139e-02f, -5.42321615e-02f, -1.20628320e-01f, -2.97813974e-02f, 1.10071458e-01f, 3.53414528e-02f, -1.07287072e-01f, -9.69044790e-02f, 4.58310731e-03f, -2.72911023e-02f,
  2.13455670e-02f, -5.61552718e-02f, -3.58446464e-02f, 3.06085050e-02f, -5.82937747e-02f, 4.93293218e-02f, 4.45269747e-03f, -3.06159165e-02f, -9.22548845e-02f, -1.56519953e-02f,
  -2.81658862e-02f, 2.38393359e-02f, -9.32012219e-03f, -1.02639623e-01f, -1.93126537e-02f, -5.39975166e-02f, -9.28053781e-02f, -9.94492248e-02f, -6.03985302e-02f, 5.22945775e-03f,
  -9.85578597e-02f, -4.21331339e-02f, -1.20655969e-01f, 5.65875210e-02f, 2.96794400e-02f, -1.29700340e-02f, -3.60039622e-02f, 2.89952978e-02f, -4.29858454e-02f, 1.63722560e-01f,
  -2.31550597e-02f, -1.06528118e-01f, -1.18090101e-01f, 4.15259004e-02f, 5.87127917e-02f, 6.93574324e-02f, 1.17683634e-02f, -4.58962396e-02f, 6.92271218e-02f, -2.00444367e-03f,
  -1.86650474e-02f, -2.48358343e-02f, 1.04157768e-01f, 3.83316241e-02f, 4.52425182e-02f, -9.61877033e-03f, 1.28004044e-01f, -1.04436502e-01f, -9.78149399e-02f, 4.87829465e-03f,
  -3.36391367e-02f, 5.04274480e-02f, 7.02407584e-02f, -1.14366360e-01f, 2.21754797e-02f, 4.98369746e-02f, -2.00000539e-01f, 5.26212715e-02f, 5.03827371e-02f, 8.67549181e-02f,
  -4.88037504e-02f, 1.49438918e-01f, 7.28462338e-02f, 8.12823698e-02f, 1.44426115e-02f, 8.69054496e-02f, 9.37784538e-02f, -3.29957493e-02f, -6.26101568e-02f, 1.05950810e-01f,
  -4.10381705e-03f, 3.01777814e-02f, -3.85827310e-02f, -1.45958448e-02f, 4.95679211e-03f, 9.10737664e-02f, -9.81722996e-02f, -5.05301096e-02f, 6.19663410e-02f, -1.07165620e-01f,
  9.73140262e-03f, -1.64865747e-01f, 1.35677248e-01f, -1.03790276e-01f, -1.10932119e-01f, -1.26220599e-01f, 2.33320929e-02f, -4.40959036e-02f, -8.85490999e-02f, 1.06745800e-02f,
  -5.63177057e-02f, 1.81460276e-01f, 3.85785066e-02f, 1.38007969e-01f, -1.13197289e-01f, -1.60451099e-01f, -3.58348936e-02f, 2.56784279e-02f, 2.56783571e-02f, -1.26966596e-01f,
  8.73908401e-02f, -1.11798182e-01f, 6.34858832e-02f, -6.03043288e-02f, 1.81529373e-02f, 4.00280021e-02f, -4.40510288e-02f, -4.00432572e-02f, -4.99080261e-03f, -4.88354033e-03f,
  1.89184591e-01f, -1.12066895e-01f, 4.57171164e-02f, -1.27072796e-01f, 1.03786178e-01f, 1.55505296e-02f, -4.69892621e-02f, 3.19722779e-02f, 4.48414683e-02f, 7.45294318e-02f,
  6.83108345e-02f, -1.32688567e-01f, -1.40157919e-02f, -3.22418287e-02f, 9.87316296e-02f, 3.01381107e-02f, -1.40448418e-02f, 1.23472184e-01f, 8.48768055e-02f, 5.94882071e-02f,
  5.31142652e-02f, 8.46076235e-02f, 4.74046357e-02f, -4.93435934e-02f, -5.36842272e-02f, 7.13539943e-02f, -1.04442462e-01f, 1.57501083e-02f, 2.29621083e-02f, 4.86673862e-02f,
  1.64620593e-01f, 5.71890473e-02f, -9.54220667e-02f, -1.06611840e-01f, 4.38850075e-02f, 2.61383951e-02f, 3.36309671e-02f, -1.22566722e-01f, 1.27100766e-01f, 8.72609317e-02f,
  -6.56773057e-03f, 3.28746699e-02f, -1.29920691e-01f, 2.76746764e-03f, 1.94755420e-02f, 3.81748602e-02f, -2.37323731e-01f, 1.82431247e-02f, -7.26878047e-02f, -1.41051337e-02f,
  2.67695393e-02f, -3.93037423e-02f, -3.38573530e-02f, 5.82365245e-02f, 1.48990512e-01f, -4.76187021e-02f, 6.65938631e-02f, -1.11660883e-01f, 1.08482786e-01f, -3.66549864e-02f,
  9.37318131e-02f, -8.56421590e-02f, -3.47494483e-02f, 2.95202047e-01f, 1.47112831e-01f, 1.08448252e-01f, -9.37310234e-03f, 4.60345112e-02f, -7.60170221e-02f, -1.25939906e-01f,
  7.78652132e-02f, 1.47205219e-01f, 1.88774019e-02f, -5.61941564e-02f, 1.06816791e-01f, -1.18606269e-01f, -2.14234665e-02f, -6.57732189e-02f, 9.14026946e-02f, 3.43311504e-02f,
  6.83312044e-02f, 9.11451802e-02f, -7.35982182e-03f, 1.10030204e-01f, 1.24714792e-01f, -4.05734144e-02f, 8.86662230e-02f, -6.99977726e-02f, 6.67673573e-02f, 3.19804773e-02f,
  1.80954598e-02f, 3.08184475e-02f, 9.94531885e-02f, -3.73779945e-02f, 5.79176135e-02f, -1.46571726e-01f, 5.43599278e-02f, -1.04131714e-01f, 1.48693368e-01f, 2.03501672e-01f,
  -1.52383447e-01f, 1.03293277e-01f, 8.16467777e-02f, 1.07583225e-01f, 4.64488640e-02f, 1.00663714e-01f, 6.39041960e-02f, 1.39268935e-01f, -8.19570422e-02f, 6.62515387e-02f,
  -1.91938207e-02f, -8.47714022e-02f, -5.48752584e-02f, -1.44545257e-01f, 1.15244359e-01f, 1.90460369e-01f, -8.55901986e-02f, 6.10293746e-02f, -6.34262189e-02f, 2.21140310e-02f,
  -4.70496826e-02f, 6.38620630e-02f, 1.11575119e-01f, 2.93878186e-02f, 4.27216366e-02f, 3.52641456e-02f, 2.21387222e-02f, -2.62953211e-02f, 9.45822150e-02f, 2.69611012e-02f,
  -5.66557422e-02f, -5.39866947e-02f, 4.63595912e-02f, -4.20114882e-02f, 1.03834355e-02f, -1.06626384e-01f, 5.95009066e-02f, -2.51790285e-02f, 6.31988943e-02f, -4.39434908e-02f,
  -2.52983067e-02f, -3.88253443e-02f, -2.79337429e-02f, 4.65281606e-02f, -1.44648895e-01f, -1.18064210e-01f, -4.92779166e-02f, 5.53721450e-02f, -5.08744940e-02f, -2.92282868e-02f,
  2.46448768e-03f, -8.78393054e-02f, -6.33692071e-02f, -9.89090465e-03f, 1.31867975e-02f, -3.42489444e-02f, -1.30990088e-01f, -1.24096029e-01f, 5.83733432e-02f, 4.54446971e-02f,
  6.65199831e-02f, 1.58571154e-01f, 4.55425642e-02f, 1.95932463e-02f, 1.84033450e-03f, 6.15367517e-02f, 6.20517805e-02f, -1.05424397e-01f, 1.23744205e-01f, -8.02665427e-02f,
  -2.05523185e-02f, 1.47769272e-01f, 6.62662834e-02f, -1.75391912e-01f, 1.27930552e-01f, -7.93742687e-02f, 2.62652654e-02f, 1.97350413e-01f, 8.09579566e-02f, -4.75056143e-03f,
  4.35665920e-02f, -3.19873206e-02f, -1.23053238e-01f, -1.66292712e-02f, -1.65976405e-01f, -9.48305726e-02f, -9.14863683e-03f, -7.97976181e-02f, -2.61400267e-02f, 4.28687446e-02f,
  -8.63962434e-03f, 3.90200391e-02f, -1.06181294e-01f, 2.17453111e-02f, -2.92078853e-02f, -7.18887597e-02f, 1.49558019e-02f, -1.12932079e-01f, -3.29178646e-02f, -2.29907222e-02f,
  -3.89312878e-02f, -9.09012109e-02f, -5.11487722e-02f, 5.47165759e-02f, -7.12898374e-03f, 1.59439445e-02f, -6.44008443e-02f, -2.67212018e-02f, -9.95519161e-02f, -1.12714969e-01f,
  4.31482606e-02f, -1.26916543e-01f, -2.64401715e-02f, 1.79776803e-01f, -6.64275438e-02f, 5.03200106e-02f, 4.90537435e-02f, -7.20980167e-02f, 1.91313237e-01f, -9.47134860e-04f,
  -1.12991117e-01f, -7.78253376e-02f, 7.84748718e-02f, 8.83377343e-02f, 6.40707556e-03f, 1.27983704e-01f, -9.21459049e-02f, 2.52590235e-02f, -1.31170545e-02f, 9.74228382e-02f,
  9.78429392e-02f, 1.79426685e-01f, -9.90252495e-02f, 7.94650167e-02f, 6.57738298e-02f, -6.70141950e-02f, -3.95223824e-03f, -1.72741070e-01f, -2.46264059e-02f, -6.37470633e-02f,
  -2.96347328e-02f, -1.78101994e-02f, -3.89668420e-02f, -1.31813869e-01f, -1.73488408e-01f, 7.61328936e-02f, 8.83963257e-02f, 2.03708615e-02f, 5.28762452e-02f, 5.91871701e-02f,
  8.39049146e-02f, -4.61632684e-02f, 3.46483253e-02f, -1.07473852e-02f, 2.27789278e-03f, -6.53846636e-02f, 7.01213554e-02f, 2.79918481e-02f, -1.61704682e-02f, 2.44558956e-02f,
  4.23464216e-02f, 8.15184880e-03f, 9.65764523e-02f, 7.25506768e-02f, -7.19471946e-02f, 2.77295355e-02f, 3.67904943e-03f, -9.27183498e-03f, 2.09504999e-02f, 5.49757741e-02f,
  1.60355285e-01f, 6.19416945e-02f, 7.34325076e-05f, -7.62276258e-03f, -1.02147616e-01f, 1.19972572e-01f, 5.12465164e-02f, 1.13672111e-02f, 5.11296540e-02f, -4.80004959e-03f,
  1.46136194e-01f, 7.98470378e-02f, 1.00027084e-01f, -4.28045318e-02f, -6.53255954e-02f, -1.01670092e-02f, -1.44121768e-02f, -1.31353782e-02f, 5.14435247e-02f, -3.17303538e-02f,
  1.57893803e-02f, 8.51452202e-02f, 5.26748337e-02f, 6.29030913e-02f, 1.19433571e-02f, 3.69408983e-03f, -4.62107621e-02f, -5.97946625e-03f, -5.49706891e-02f, 4.28469740e-02f,
  -6.54387772e-02f, 5.92679456e-02f, 8.46767575e-02f, -7.80275688e-02f, 2.47634739e-01f, 2.35951334e-01f, -7.88881481e-02f, 4.14574072e-02f, -5.23920879e-02f, 3.82949249e-03f,
  -4.81248088e-02f, -4.60572839e-02f, -1.13100521e-01f, 1.17892846e-01f, -1.29334971e-01f, -1.65687397e-01f, 1.80416629e-02f, 4.12701145e-02f, -4.24106754e-02f, 5.72718643e-02f,
  7.75114540e-03f, -5.20521142e-02f, -1.03420757e-01f, -1.19069658e-01f, -4.54044901e-02f, -1.50440097e-01f, -3.27067077e-02f, 7.00093657e-02f, 1.65790781e-01f, -3.90522704e-02f,
  -3.36427502e-02f, -3.56341898e-02f, -7.25359917e-02f, -1.38868436e-01f, 5.12202419e-02f, -7.82614723e-02f, -1.65693350e-02f, 1.58243137e-03f, 7.16692060e-02f, -1.52410075e-01f,
  -2.00383782e-01f, 1.08006671e-01f, 1.13088958e-01f, -4.08385618e-04f, 1.82736516e-02f, -7.27377906e-02f, 1.09874848e-02f, 2.00337227e-02f, 1.02053054e-01f, 2.02237833e-02f,
  -8.71315897e-02f, -6.98378086e-02f, -4.55962531e-02f, -6.08193204e-02f, 8.96841139e-02f, -9.45505947e-02f, -5.19365892e-02f, 1.60666078e-01f, 1.29167910e-03f, 8.43454897e-02f,
  -4.33749147e-02f, 9.29636732e-02f, 1.33445442e-01f, 1.37313753e-01f, -4.29486409e-02f, -2.77695537e-01f, -7.29665607e-02f, -3.89536470e-02f, 8.66429806e-02f, 2.43019825e-03f,
  1.23095140e-01f, -1.07498951e-01f, 5.47853559e-02f, -6.36091828e-02f, 1.38925225e-01f, 8.44085515e-02f, 3.32779549e-02f, -6.68896884e-02f, -6.46299049e-02f, -1.64970726e-01f,
  -3.08907423e-02f, -1.75255071e-02f, 2.10523456e-02f, -5.19676544e-02f, -2.09618613e-01f, -4.57246415e-02f, 2.08834205e-02f, -7.41358697e-02f, -1.08741887e-01f, -1.61886252e-02f,
  -2.90056989e-02f, 5.89885041e-02f, -9.20328684e-03f, 2.95144580e-02f, -1.00153461e-01f, -1.50809977e-02f, 5.02568968e-02f, 1.30789012e-01f, 2.55864095e-02f, -3.01617067e-02f,
  4.15457934e-02f, 7.16955736e-02f, -1.98879857e-02f, 7.62367621e-03f, 3.37722362e-04f, 7.08546191e-02f, 4.17445116e-02f, 7.58542344e-02f, 1.19797260e-01f, 5.18232696e-02f,
  -5.26251383e-02f, 4.10575159e-02f, -4.73565869e-02f, 9.83296111e-02f, 9.13729593e-02f, -1.22018447e-02f, 7.18227103e-02f, 6.00485224e-03f, -5.94217479e-02f, 3.87172028e-02f,
  -8.05543661e-02f, 7.47933844e-03f, -9.82913598e-02f, 1.85100418e-02f, -1.24252439e-01f, 7.93693066e-02f, -5.67244403e-02f, 1.09400079e-02f, -1.42688408e-01f, 9.87319052e-02f,
  -9.52838063e-02f, 2.45854080e-01f, 5.07890731e-02f, -6.27675746e-03f, -2.08336070e-01f, 4.19068225e-02f, 9.83167887e-02f, 8.46956894e-02f, 1.28244698e-01f, -1.19544990e-01f,
  3.44931078e-03f, 1.15340509e-01f, -1.39678717e-01f, -2.03086182e-01f, 1.24252819e-01f, 1.15479879e-01f, 4.25680839e-02f, 8.59953761e-02f, 6.29157200e-02f, -2.87826937e-02f,
  -1.58411026e-01f, -5.37778065e-02f, 1.40746348e-02f, -3.51736620e-02f, 1.67833596e-01f, -4.33922336e-02f, -9.55565542e-04f, 6.30022120e-03f, -8.73084739e-02f, 2.52092723e-02f,
  3.34184207e-02f, 2.08564084e-02f, 8.61011669e-02f, 2.05130458e-01f, 1.05543725e-01f, 3.01547591e-02f, 4.92991246e-02f, 1.03078056e-02f, 8.66734833e-02f, -1.65882416e-03f,
  -4.02527153e-02f, 1.65973619e-01f, 3.79547440e-02f, 1.95869710e-02f, -1.02560081e-01f, -5.97968251e-02f, 1.05094060e-01f, 1.65077418e-01f, -1.47275776e-01f, -4.52060960e-02f,
  -9.95817012e-04f, -1.80175334e-01f, 1.05496906e-01f, -1.34387702e-01f, 9.32794139e-02f, 4.81700897e-03f, -1.73145071e-01f, -4.94556315e-02f, 4.17569987e-02f, -1.04450788e-02f,
  3.24138254e-02f, 6.74743131e-02f, -1.65876880e-01f, 1.31335512e-01f, 7.64452200e-03f, 1.41347647e-01f, -1.33016750e-01f, -3.19576561e-02f, 4.81483415e-02f, 1.09752685e-01f,
  -6.25804299e-03f, -1.21876009e-01f, -3.93818878e-02f, 3.27329189e-02f, 4.41069677e-02f, 1.44522246e-02f, 4.71151108e-03f, 1.28831789e-01f, 6.56631589e-02f, 1.03151277e-01f,
  7.46200830e-02f, 2.02594493e-02f, 2.93359137e-03f, 7.11712614e-02f, -5.48026189e-02f, 1.00001447e-01f, 2.09314395e-02f, -6.90832287e-02f, 5.46435404e-05f, -2.09314134e-02f,
  -7.60977762e-03f, -2.14281920e-02f, -9.83377453e-03f, 1.09705016e-01f, -1.10739917e-01f, -6.96190074e-02f, -1.90675743e-02f, 1.35793546e-02f, -9.34274048e-02f, -1.90711915e-02f,
  -6.29559606e-02f, 5.95977530e-02f, -4.09070402e-02f, -1.60835497e-02f, -6.89434037e-02f, 5.37191965e-02f, -3.62325050e-02f, -4.83615287e-02f, 1.53255939e-01f, 6.14628717e-02f,
  1.30613912e-02f, -5.47211841e-02f, 5.22330552e-02f, -5.19584538e-03f, -3.04262154e-02f, -9.15834159e-02f, -1.79536808e-02f, -1.44129507e-02f, -1.23136630e-02f, -8.56310874e-03f,
  1.27225757e-01f, -1.76595040e-02f, 1.20579591e-02f, -7.08835945e-02f, -4.81784306e-02f, -1.71433168e-03f, -2.21534558e-02f, 7.61363357e-02f, 5.91646954e-02f, -1.00534230e-01f,
  3.20648476e-02f, 1.02084368e-01f, 3.45310494e-02f, 1.61277145e-01f, -5.35686128e-02f, 1.29003301e-01f, -2.06131563e-02f, 1.37633150e-02f, 6.87926486e-02f, -3.40781286e-02f,
  -7.75301680e-02f, -4.70599681e-02f, -1.87002812e-02f, -6.29267097e-02f, -1.50307983e-01f, -6.97381571e-02f, -2.94139683e-02f, 1.58197135e-01f, 3.31896059e-02f, 3.31410095e-02f,
  1.34515036e-02f, 3.15205976e-02f, -9.75421146e-02f, 9.18211341e-02f, -2.73589492e-02f, -9.33758989e-02f, 2.85051674e-01f, -3.13681997e-02f, -4.77311201e-02f, -2.85527036e-02f,
  3.88653129e-02f, -1.43728003e-01f, -1.99027359e-03f, -4.49557230e-02f, 2.23136842e-02f, -1.64253488e-01f, -1.89989999e-01f, -9.84679349e-03f, 4.63186614e-02f, -5.39827859e-03f,
  6.78382814e-02f, 1.21838413e-01f, 2.98641678e-02f, 1.00393280e-01f, 8.09063762e-02f, 5.94346821e-02f, -3.91596444e-02f, 3.48533168e-02f, -3.99174429e-02f, 1.27205580e-01f,
  -2.45486740e-02f, 1.06106274e-01f, -1.47773415e-01f, 8.32017660e-02f, -7.35118706e-03f, 3.42861190e-02f, -1.28223777e-01f, -2.83261407e-02f, 1.04160845e-01f, 6.91617653e-03f,
  3.65537964e-02f, -1.89663485e-01f, -7.99623653e-02f, 6.45223446e-03f, 1.64230481e-01f, 2.27510091e-02f, -1.23187914e-01f, -4.63242643e-02f, 4.93933111e-02f, 1.24970814e-02f,
  -2.61369757e-02f, 7.01953173e-02f, 1.83417313e-02f, -1.56271026e-01f, -7.51526058e-02f, -3.73716913e-02f, 1.89956240e-02f, -2.13730037e-02f, -3.94836590e-02f, 8.44977610e-03f,
  -1.25250705e-02f, 2.17964370e-02f, 3.16136144e-02f, 2.70488672e-02f, -7.50787230e-03f, 1.33966422e-02f, -3.94612260e-04f, 1.06808394e-01f, 2.21421514e-02f, -6.36009825e-03f,
  -3.80704999e-02f, -3.56618315e-02f, -2.82688178e-02f, 5.00328690e-02f, 1.00368029e-02f, 4.05102745e-02f, 1.42468482e-01f, 7.00653717e-02f, 3.83329727e-02f, -6.28709197e-02f,
  -3.98375131e-02f, 5.48872985e-02f, -6.58542216e-02f, 1.09009586e-01f, 5.74324802e-02f, 4.79069017e-02f, 1.00202434e-01f, 1.05383016e-01f, 6.18764572e-02f, 1.89829040e-02f,
  -5.58110420e-04f, -6.58992380e-02f, -2.18796283e-02f, -2.24569421e-02f, -5.43343872e-02f, 4.06963169e-04f, -6.91721216e-02f, -7.92373717e-03f, -4.21805643e-02f, 3.11945565e-02f,
  -1.43666893e-01f, 5.94517887e-02f, -6.39234707e-02f, 2.84050517e-02f, 5.95417023e-02f, 7.16152322e-03f, -1.45275757e-01f, 1.26602441e-01f, 1.50937498e-01f, -1.51707828e-01f,
  -1.35297105e-01f, -2.10183430e-02f, 2.72206180e-02f, 7.84679279e-02f, 6.44344315e-02f, 2.12416966e-02f, 4.60482314e-02f, 7.68031105e-02f, -2.84298696e-02f, -3.42356861e-02f,
  -6.43449426e-02f, 1.23500889e-02f, 7.45464861e-03f, -5.28363287e-02f, 1.81023613e-01f, 6.49558902e-02f, 2.42889747e-02f, 1.26057729e-01f, 3.37935314e-02f, 2.59090718e-02f,
  9.23514739e-02f, 1.14546373e-01f, -8.16288292e-02f, -3.64277624e-02f, 1.15487508e-01f, 6.26240745e-02f, 2.34419480e-02f, -4.43819771e-03f, 1.09379664e-01f, -3.22742388e-03f,
  2.43544504e-02f, -7.47884214e-02f, -1.17802754e-01f, -9.32441745e-03f, 8.24206471e-02f, 9.59192663e-02f, 6.70567676e-02f, 3.96642238e-02f, 9.74508654e-03f, 1.63667545e-01f,
  2.31445432e-02f, -2.14340235e-03f, 9.22188759e-02f, 4.24001589e-02f, -1.13843083e-01f, -1.85021963e-02f, -2.51867715e-02f, -5.93959987e-02f, 3.29010822e-02f, -1.39036439e-02f,
  3.24703706e-03f, 3.41961570e-02f, -9.62842032e-02f, -1.29350662e-01f, 3.54819000e-02f, 6.59835637e-02f, -1.20995246e-01f, -2.86440440e-02f, -1.18459702e-01f, 1.51698619e-01f,
  -1.43772393e-01f, 8.82516280e-02f, 9.83177423e-02f, 1.16459422e-01f, 6.58950433e-02f, 6.04903549e-02f, -1.18183605e-01f, -1.30212918e-01f, -7.03031495e-02f, -3.61111388e-02f,
  -1.30845495e-02f, -4.76004332e-02f, -1.13238350e-01f, 3.88400676e-03f, -7.92394355e-02f, -9.78559814e-03f, 1.93217918e-02f, 2.07671728e-02f, -2.85281502e-02f, -6.04787618e-02f,
  3.22482474e-02f, -1.06356204e-01f, 4.65220585e-02f, 6.82765665e-03f, -5.64259291e-02f, -1.14142217e-01f, 6.81109875e-02f, -2.54048575e-02f, 5.19424723e-03f, -4.71447073e-02f,
  -2.53539011e-02f, -1.45041808e-01f, -7.92073756e-02f, -8.97960290e-02f, 3.79477218e-02f, 4.68996493e-03f, 7.51120597e-02f, -1.61227465e-01f, 1.00073166e-01f, -6.03031320e-03f,
  6.63344143e-03f, -3.24805826e-02f, -6.74678460e-02f, -7.84245804e-02f, -1.07470997e-01f, -4.20207307e-02f, 7.01499432e-02f, -2.10001711e-02f, -1.41701065e-02f, -8.20315927e-02f,
  -3.25611681e-02f, -1.86381675e-02f, -9.30587295e-03f, -7.16194734e-02f, -4.33164556e-03f, -8.01505148e-02f, 6.95849657e-02f, 3.96774113e-02f, -3.39554101e-02f, 1.97534934e-02f,
  -2.24029608e-02f, 1.20201312e-01f, 9.78906527e-02f, -2.55098213e-02f, -1.28465533e-01f, 1.27241284e-01f, 2.72871796e-02f, -7.63082802e-02f, 4.08527628e-02f, -6.68519959e-02f,
  1.17249243e-01f, 1.24081066e-02f, 3.51831205e-02f, 6.26555234e-02f, 2.06847191e-02f, -8.93334299e-02f, 1.83459550e-01f, -1.46185262e-02f, -7.32558444e-02f, 8.39738771e-02f,
  6.34453893e-02f, 7.40040615e-02f, -7.70119112e-03f, -6.56441227e-02f, -8.57583955e-02f, -4.20607999e-03f, 1.86096072e-01f, 6.74549788e-02f, -3.00955423e-03f, 1.09147564e-01f,
  -2.34504431e-01f, 1.15280747e-02f, 1.38267595e-02f, 5.07815182e-02f, 1.01275779e-01f, 6.96779415e-03f, 9.06911045e-02f, 1.71208531e-01f, 5.33274263e-02f, -1.07147373e-01f,
  -7.54164904e-02f, -4.36852388e-02f, 1.47148654e-01f, -3.08740959e-02f, 1.59709789e-02f, 1.24016710e-01f, -5.10237738e-02f, 9.53948498e-02f, -5.81875406e-02f, -1.32464960e-01f,
  8.48152384e-04f, 4.98909466e-02f, 1.84530497e-01f, 2.11669713e-01f, 1.26219928e-01f, 1.39167175e-01f, 7.08294734e-02f, 4.04583998e-02f, -4.55903374e-02f, -7.92456493e-02f,
  -1.07097864e-01f, 6.83330148e-02f, 4.01448309e-02f, 1.09356180e-01f, -1.30921841e-01f, 1.80794541e-02f, -7.06064701e-02f, 1.09058507e-01f, 6.20492063e-02f, 1.00797370e-01f,
  -2.18344163e-02f, 9.10849795e-02f, 6.33596480e-02f, 4.54937927e-02f, -1.65118560e-01f, -1.03676096e-01f, 8.14845711e-02f, -5.65417297e-03f, -4.10279296e-02f, 5.26248142e-02f,
  -4.85408269e-02f, 3.28262858e-02f, 4.87548597e-02f, -1.16538942e-01f, 2.41719317e-02f, 1.03195524e-02f, -4.85802703e-02f, 7.22688064e-02f, 2.80430689e-02f, 3.92850488e-02f,
  -6.99173734e-02f, 1.28308320e-02f, -1.52934249e-02f, 6.81828633e-02f, -1.08437859e-01f, 6.81036944e-03f, -6.90827221e-02f, 2.95513347e-02f, 1.04645208e-01f, -1.15415426e-02f,
  6.92892596e-02f, 2.72310916e-02f, -3.60818654e-02f, -4.11371291e-02f, 7.04979897e-03f, 4.61332127e-02f, 4.99092899e-02f, 3.21969874e-02f, 1.51339192e-02f, 4.39755991e-02f,
  1.72573715e-01f, 7.33743012e-02f, -1.50503812e-03f, -7.53069147e-02f, -6.56604767e-02f, 8.76020640e-02f, 1.43013531e-02f, -5.64432740e-02f, 8.61430317e-02f, 1.90850664e-02f,
  2.75887027e-02f, -7.74150342e-03f, 6.91641960e-03f, 4.46110293e-02f, -6.22946061e-02f, -1.60786081e-02f, -3.90887670e-02f, 1.39597179e-02f, 7.20901266e-02f, -5.76910675e-02f,
  1.07430983e-02f, 7.51042590e-02f, 1.21032961e-01f, -1.16508543e-01f, 2.51711875e-01f, 8.75368044e-02f, -1.68479696e-01f, 5.40351197e-02f, 3.41787525e-02f, -2.85838312e-03f,
  -6.66577220e-02f, 4.67171855e-02f, -3.50115746e-02f, 1.54493615e-01f, -9.73116979e-02f, -1.08112827e-01f, 1.58514045e-02f, 4.94236387e-02f, -3.12059205e-02f, -5.15683480e-02f,
  1.43122608e-02f, -2.04565704e-01f, -1.13393396e-01f, -1.61849201e-01f, -2.92345025e-02f, -1.29262716e-01f, -6.56572985e-04f, 6.19434416e-02f, 1.41856641e-01f, 5.05285077e-02f,
  -2.26300821e-01f, -6.28262386e-02f, -1.24869764e-01f, -9.91398618e-02f, -2.37707384e-02f, -6.23069778e-02f, 5.67423366e-02f, 1.50673345e-01f, 4.27695140e-02f, -8.36401731e-02f,
  -2.20438883e-01f, -3.81799527e-02f, 2.98620984e-02f, -5.86387701e-02f, -6.69690147e-02f, -7.58580789e-02f, -5.55245578e-02f, -4.67514340e-03f, 1.59329966e-01f, 1.22100614e-01f,
  -1.07988596e-01f, -5.99036179e-02f, -8.79031643e-02f, -2.11653903e-01f, -3.90357822e-02f, -2.48184130e-01f, 1.39510334e-02f, -9.18718055e-03f, -4.80074100e-02f, -1.91038802e-01f,
  -9.80791748e-02f, -9.78650302e-02f, 5.62553219e-02f, -8.32997914e-03f, -3.74907441e-02f, -1.26984805e-01f, -2.43202019e-02f, 1.17909044e-01f, 9.85049736e-03f, -4.03271951e-02f,
  1.57621831e-01f, -1.59534872e-01f, 1.46094516e-01f, -1.53110117e-01f, -9.18249339e-02f, 6.79665580e-02f, -1.14529496e-02f, -4.23626453e-02f, 1.40657937e-02f, 6.76742569e-02f,
  2.14670300e-02f, -5.55506758e-02f, 5.18756695e-02f, 5.56450002e-02f, 4.41956334e-02f, -2.18885969e-02f, 3.66414487e-02f, 3.44047807e-02f, 2.07084138e-02f, 9.93081834e-04f,
  3.02585796e-03f, -7.43272826e-02f, 6.37396146e-03f, -2.03657476e-03f, -3.22492048e-03f, -9.49935764e-02f, 1.91634044e-01f, -4.12267953e-04f, -3.83239239e-02f, -3.18708569e-02f,
  9.87296253e-02f, 1.43211512e-02f, 7.67153427e-02f, -9.67808533e-03f, 3.32747325e-02f, 2.16097869e-02f, 5.82508110e-02f, -4.49514687e-02f, 9.55881458e-03f, 7.36272661e-03f,
  -1.38871238e-01f, -3.79657410e-02f, 5.73301921e-03f, 6.13752864e-02f, 4.77352925e-02f, -3.33851390e-02f, -6.66259229e-03f, 1.28730610e-01f, -1.89313162e-02f, 1.93871632e-02f,
  7.92318117e-03f, 7.37681165e-02f, -2.50990726e-02f, -6.49217051e-03f, 7.81289190e-02f, -5.30408323e-02f, 9.23904553e-02f, 1.11009024e-01f, 1.74743384e-01f, -1.12581782e-01f,
  1.82066839e-02f, -8.06705952e-02f, 8.14352259e-02f, -8.08370039e-02f, -1.94418147e-01f, -1.91616565e-01f, 9.39114317e-02f, -8.27042907e-02f, -1.06111184e-01f, 6.76721781e-02f,
  -7.34192953e-02f, -9.00481045e-02f, 3.87982689e-02f, 1.54992133e-01f, -3.94462533e-02f, -6.09296635e-02f, -1.08235344e-01f, -7.49465972e-02f, 1.14004083e-01f, -1.10510588e-01f,
  2.14655558e-03f, 7.67719820e-02f, 1.19591624e-01f, 1.44141912e-01f, 1.74484652e-04f, -1.41053081e-01f, -9.58421230e-02f, 1.13385201e-01f, -1.01798251e-01f, 1.42630801e-01f,
  2.29782481e-02f, 1.40679747e-01f, -9.34434980e-02f, 8.12748447e-02f, 2.82925796e-02f, -7.76444301e-02f, -2.88215727e-02f, 3.69374789e-02f, 2.81413291e-02f, 4.50700112e-02f,
  -1.07358187e-01f, -1.06830262e-02f, -2.13105395e-01f, 4.80559468e-02f, -1.14928804e-01f, -3.00743729e-02f, -9.73068271e-03f, -4.15946953e-02f, 1.41003951e-01f, 1.27979010e-01f,
  -2.88886596e-02f, 4.53237928e-02f, -1.52956143e-01f, -1.36950359e-01f, 1.12148240e-01f, -2.21610308e-01f, 3.56564857e-02f, -4.53979671e-02f, 1.63873695e-02f, -3.85870598e-02f,
  -1.04701348e-01f, -3.78782451e-02f, 2.35990141e-04f, 2.29404241e-01f, 5.10210581e-02f, 1.00652695e-01f, -4.11086045e-02f, 1.14225626e-01f, 1.29850566e-01f, 3.08619365e-02f,
  -1.31251007e-01f, -1.60212517e-01f, -1.96281858e-02f, 2.83749681e-02f, -3.77116874e-02f, -2.79842447e-02f, 1.97425392e-02f, -1.48714092e-02f, 6.21393956e-02f, 1.00574560e-01f,
  9.11589433e-03f, 3.24792266e-02f, -8.25004727e-02f, 9.84465145e-03f, -8.43575001e-02f, 4.59373333e-02f, -2.65815873e-02f, -3.72450054e-02f, 1.16041005e-01f, 1.03791185e-01f,
  -6.20345138e-02f, 6.98474795e-02f, -2.30655950e-02f, 6.07760437e-02f, -9.49294716e-02f, 5.92662171e-02f, 1.14389705e-02f, 7.98806995e-02f, 1.86295472e-02f, -1.06932409e-01f,
  -7.03654289e-02f, -4.43083085e-02f, -1.34414151e-01f, -1.81061290e-02f, -8.34212005e-02f, 7.10683465e-02f, 9.25606769e-03f, 9.28818733e-02f, 1.93249837e-01f, 4.26882766e-02f,
  2.55163983e-02f, 4.75453271e-04f, -5.82742579e-02f, 4.35542800e-02f, 1.06421649e-01f, -2.00612284e-02f, 6.35556430e-02f, 6.72412217e-02f, -6.66713119e-02f, 1.24377564e-01f,
  -8.65246132e-02f, -1.04929335e-01f, 8.43138248e-02f, 5.24547091e-03f, 3.16287987e-02f, -1.31347358e-01f, -8.46555531e-02f, 1.25101476e-03f, 9.45202187e-02f, -4.21411246e-02f,
  -9.40398648e-02f, -4.34553400e-02f, 1.21549681e-01f, 2.19078258e-01f, 8.90909508e-02f, 2.53452901e-02f, -5.72820939e-02f, -9.61830691e-02f, 5.56568727e-02f, 3.01294122e-02f,
  -4.53976728e-02f, 3.30704600e-02f, 2.86072623e-02f, 1.38122763e-03f, 8.42416137e-02f, -9.28280503e-02f, -1.14430428e-01f, 1.36130631e-01f, 8.02729949e-02f, -1.38984323e-01f,
  -1.14850506e-01f, 3.66726182e-02f, 1.17842145e-01f, -1.04789108e-01f, 7.07212910e-02f, -1.76532008e-02f, 1.63362734e-02f, -1.60045147e-01f, 3.04848291e-02f, 1.13578372e-01f,
  -2.11496488e-03f, -1.46241367e-01f, 1.64908823e-02f, 1.20447025e-01f, 1.23805855e-03f, 2.60773227e-02f, 5.80098778e-02f, -7.84781575e-02f, -6.64823502e-02f, -3.68816331e-02f,
  7.95263872e-02f, -2.05609705e-02f, 1.02505470e-02f, -1.74093276e-01f, -1.59938186e-01f, 1.98105294e-02f, -1.52947649e-01f, -1.52008101e-01f, -9.17364359e-02f, -1.11037552e-01f,
  -2.27139696e-01f, 1.93210632e-01f, 1.47075683e-01f, -7.18231574e-02f, 3.38315852e-02f, -8.66578519e-02f, -6.01873584e-02f, -1.54765144e-01f, -3.40001704e-03f, -2.37560481e-01f,
  7.49835670e-02f, -3.96549441e-02f, 4.64521125e-02f, 4.19888236e-02f, 2.05191839e-02f, -6.47089928e-02f, -1.55210748e-01f, 8.60584900e-03f, 1.40215248e-01f, 2.31682241e-01f,
  -1.21207528e-01f, -1.08002603e-01f, 5.19109555e-02f, -8.88947034e-05f, 5.06632309e-03f, 1.29942730e-01f, -1.35299519e-01f, -4.46329042e-02f, -2.22780034e-02f, -5.20372810e-03f,
  9.56764221e-02f, -4.14742008e-02f, -2.27681939e-02f, -1.32834211e-01f, 1.02563083e-01f, -6.11912683e-02f, 5.01955068e-03f, -1.69462040e-01f, -1.95035990e-03f, -2.44535459e-03f,
  3.13667511e-03f, -1.06943510e-01f, -1.97103262e-01f, -1.37716383e-01f, 3.97689119e-02f, -3.18963751e-02f, -1.14979379e-01f, 5.93912415e-02f, 6.49187481e-03f, -1.14364102e-01f,
  3.32145230e-03f, -1.61605760e-01f, -1.03110150e-02f, -1.49900764e-01f, -1.57410130e-01f, -9.73499343e-02f, -8.08728561e-02f, -1.65064514e-01f, 8.69632233e-03f, -7.11545125e-02f,
  9.21673025e-04f, -5.34686958e-03f, -5.26769049e-02f, -1.42344698e-01f, -1.31380614e-02f, -4.32674028e-02f, -1.40833855e-02f, -2.04374373e-01f, 5.43550216e-02f, 6.50096685e-02f,
  -6.22259900e-02f, -1.32389933e-01f, 4.11137845e-03f, 7.43753389e-02f, 9.92783904e-02f, 3.37362327e-02f, -1.34391159e-01f, -4.88112569e-02f, -1.12943381e-01f, 4.28383313e-02f,
  1.42263204e-01f, 4.40046601e-02f, 3.70510221e-02f, 8.26043542e-03f, 1.11186765e-02f, -1.92674939e-02f, 8.45106319e-02f, -1.05338179e-01f, 1.75910100e-01f, 8.85519758e-02f,
  2.01773420e-02f, -5.21424152e-02f, -3.71220596e-02f, 7.91177079e-02f, -3.45220752e-02f, 8.90201330e-02f, 3.53450142e-02f, 3.81901227e-02f, 7.41884932e-02f, 3.19043943e-03f,
  -2.15266850e-02f, 1.29949942e-01f, -4.16015182e-03f, -8.27339888e-02f, 1.44716412e-01f, -1.09317042e-01f, -1.07457235e-01f, -3.73245105e-02f, 9.42681357e-02f, -7.33907521e-02f,
  -7.13347048e-02f, -6.42174780e-02f, 2.88663581e-02f, -3.07378154e-02f, 9.07708611e-03f, -7.96386078e-02f, 9.28256810e-02f, -4.75867577e-02f, -5.93485199e-02f, 3.36712301e-02f,
  5.03820330e-02f, 4.03356664e-02f, 7.13107884e-02f, -5.62628061e-02f, 1.17618171e-02f, -3.82516645e-02f, 6.49655983e-02f, 1.03864744e-01f, 9.94361043e-02f, 1.33503467e-01f,
  -2.16612026e-01f, 7.84293041e-02f, -6.88129291e-02f, 1.13566384e-01f, -4.62986343e-02f, -7.76261510e-03f, 6.54889792e-02f, 7.69822970e-02f, -2.00326089e-03f, -8.39820355e-02f,
  3.70197482e-02f, -3.69438566e-02f, 3.93027589e-02f, -1.00906760e-01f, -1.17676832e-01f, 2.56811567e-02f, -5.20253666e-02f, 5.37366094e-03f, 1.82059985e-02f, -5.16545139e-02f,
  6.25526533e-02f, 2.68865544e-02f, -1.93503350e-02f, 5.90960123e-02f, 1.11439470e-02f, 5.00293113e-02f, 3.68194352e-03f, 2.05065068e-02f, 4.16603237e-02f, 1.56269944e-03f,
  -8.57289582e-02f, 5.43155074e-02f, 2.41239462e-02f, -4.33609746e-02f, 2.55288072e-02f, 1.63014177e-02f, 6.77532330e-02f, -6.67701103e-03f, 4.04563919e-02f, 7.54499361e-02f,
  -2.35411793e-01f, -8.68234038e-02f, 4.21977751e-02f, 2.87570469e-02f, -3.21264751e-02f, 1.17443511e-02f, -8.88209604e-03f, -7.48688728e-02f, -9.79992561e-04f, -8.68739039e-02f,
  -1.99143719e-02f, -2.88383700e-02f, -6.43419921e-02f, -3.27308699e-02f, 1.02551647e-01f, 1.31342523e-02f, 1.01220958e-01f, -1.07181713e-01f, -3.25524658e-02f, -2.42506228e-02f,
  -1.02974378e-01f, -1.24640986e-01f, -3.75431217e-02f, 9.09773749e-04f, 1.71687920e-02f, -4.78180945e-02f, 6.34238571e-02f, -2.78284331e-03f, -1.97905712e-02f, -1.04850659e-03f,
  -9.97200906e-02f, 6.96467534e-02f, 3.89383323e-02f, 2.58264653e-02f, -1.12982102e-01f, 1.69678167e-01f, -7.25744888e-02f, 1.98957790e-02f, 1.62117928e-01f, 1.09929256e-01f,
  3.02715972e-03f, 5.37149161e-02f, 1.40382707e-01f, 2.07433775e-02f, 2.99963467e-02f, -7.96622187e-02f, 5.53722829e-02f, -4.79660258e-02f, -5.57446033e-02f, 1.82551444e-02f,
  9.89441052e-02f, 7.21920878e-02f, -6.39523566e-02f, 6.43962100e-02f, 8.72703865e-02f, 9.24179554e-02f, 9.36743617e-03f, 7.50636756e-02f, 2.62727309e-02f, 1.61476955e-01f,
  -2.10718378e-01f, -5.95736839e-02f, 2.72272617e-01f, -4.57295701e-02f, 1.13346040e-01f, -1.46756902e-01f, 1.24330580e-01f, 1.11166183e-02f, 3.88398999e-03f, -1.45748049e-01f,
  -9.30189043e-02f, -5.34553826e-02f, 1.07371405e-01f, -1.83502045e-02f, 9.19204503e-02f, 4.35313880e-02f, 1.16953254e-01f, 9.50180441e-02f, 6.23579733e-02f, -6.52628466e-02f,
  -3.20077091e-02f, -4.45484892e-02f, -8.39557592e-03f, 5.86889274e-02f, 6.55394495e-02f, 1.81686133e-01f, 5.99642098e-02f, 2.39072293e-01f, -1.38723820e-01f, 3.76074873e-02f,
  -1.69945769e-02f, 9.74329039e-02f, 1.52042909e-02f, 8.04027468e-02f, 2.74218954e-02f, 3.70438360e-02f, -3.99319604e-02f, -1.73349395e-01f, 4.56580380e-03f, -8.86400715e-02f,
  1.45404130e-01f, 1.48764610e-01f, -9.89287496e-02f, 3.06420568e-02f, -9.81150419e-02f, 9.41727012e-02f, 5.47166727e-02f, -3.83619629e-02f, 5.67687675e-02f, 6.31574243e-02f,
  5.29337451e-02f, 8.38025808e-02f, 1.55873355e-02f, -2.50923391e-02f, 2.96383761e-02f, -1.99497249e-02f, 1.13601185e-01f, -5.65797463e-02f, -5.37252687e-02f, 1.97069868e-02f,
  9.96250138e-02f, 4.80564833e-02f, -2.30971556e-02f, -6.68669259e-03f, 6.15612976e-02f, -2.81263795e-02f, 1.02195859e-01f, 1.04988344e-01f, -5.47138117e-02f, -1.26119897e-01f,
  7.46678635e-02f, 4.46534269e-02f, 7.96958432e-02f, 6.67922199e-02f, 8.72029439e-02f, -4.80248686e-03f, 5.98439947e-02f, -2.08368395e-02f, 5.02108671e-02f, -6.80678040e-02f,
  -9.45633426e-02f, -8.86068866e-03f, 8.17455351e-03f, 6.31624982e-02f, 9.50324610e-02f, 2.62830853e-02f, -2.60704104e-02f, 1.65202450e-02f, -6.81362152e-02f, -1.13427900e-01f,
  2.46583261e-02f, -5.22293635e-02f, 5.57129569e-02f, -5.29817194e-02f, 5.85286207e-02f, 5.94734438e-02f, -5.20723648e-02f, 1.43290749e-02f, 3.51078203e-03f, 1.04605421e-01f,
  1.02028690e-01f, 3.47477831e-02f, -1.91486999e-01f, 1.32933721e-01f, -7.95151740e-02f, -4.16952670e-02f, 1.46596609e-02f, -3.71261314e-02f, 5.15327789e-02f, 4.13452536e-02f,
  1.68858215e-01f, 9.06732082e-02f, -4.63399198e-03f, -1.67602032e-01f, 1.88103229e-01f, -1.68823060e-02f, -1.21487118e-01f, -1.05772138e-01f, -6.21795990e-02f, 2.50891954e-01f,
  3.43349315e-02f, -2.57598534e-02f, 9.91652533e-02f, 8.96725655e-02f, 1.14267930e-01f, 2.13917177e-02f, 2.22898815e-02f, 1.95006311e-01f, -2.36959010e-01f, 3.19177806e-02f,
  1.59136444e-01f, -3.36623266e-02f, 1.24848232e-01f, -2.18046904e-01f, 3.10183801e-02f, 1.62346125e-01f, 7.62834400e-02f, -1.06348872e-01f, -1.80273861e-01f, 1.47025138e-02f,
  1.62923366e-01f, -1.64881889e-02f, 1.08759061e-01f, -7.20623359e-02f, 4.29330068e-03f, 1.06241867e-01f, -3.51038240e-02f, -1.12119310e-01f, -6.52485900e-03f, -1.39430836e-01f,
  2.58039832e-02f, 4.89811674e-02f, 4.18624021e-02f, -2.30068397e-02f, -3.87375690e-02f, 2.14734852e-01f, -2.13935524e-01f, -6.68158978e-02f, 3.68585251e-02f, -4.22723144e-02f,
  6.73268661e-02f, -6.59254845e-03f, -5.40822819e-02f, 1.22893281e-01f, -1.24793112e-01f, -1.54569447e-01f, -1.91388391e-02f, -1.85347572e-01f, 1.39132902e-01f, 1.50216371e-01f,
  1.93995193e-01f, 1.12461142e-01f, -1.13318570e-01f, 6.45930395e-02f, 6.10633045e-02f, 3.21495682e-02f, -2.21633893e-02f, -5.73487841e-02f, 2.43673974e-04f, 2.20015887e-02f,
  9.73318294e-02f, -5.36335865e-03f, 5.23159616e-02f, 1.47914393e-02f, 1.21520527e-01f, 6.63724989e-02f, 7.31231719e-02f, -2.22655758e-02f, 3.38431187e-02f, -3.34633142e-02f,
  -2.13792548e-02f, -2.79928073e-02f, -8.53070021e-02f, 4.19837162e-02f, -2.17479300e-02f, -6.87322915e-02f, 6.00931309e-02f, 4.82022315e-02f, 1.46338465e-02f, -2.92957702e-04f,
  -4.99659479e-02f, -2.99664699e-02f, -7.20920116e-02f, 1.82372689e-01f, 4.84844781e-02f, 4.34432775e-02f, -8.22051335e-03f, 1.84418559e-02f, 6.76547736e-02f, 2.87535544e-02f,
  3.64781730e-03f, 7.49024823e-02f, -1.02511987e-01f, -1.97270215e-02f, 1.58968374e-01f, -1.39171621e-02f, -3.92747996e-03f, 8.81322473e-02f, 1.63685810e-02f, 5.87373935e-02f,
  -2.47998796e-02f, 6.72310144e-02f, 7.40386546e-02f, -6.19797967e-02f, 2.08233949e-02f, 6.39329553e-02f, -1.73790887e-01f, 6.12527989e-02f, -1.60277281e-02f, -4.87644598e-02f,
  5.79597950e-02f, -2.33199313e-01f, 1.84349418e-01f, 1.34500548e-01f, -6.57747015e-02f, 9.65242311e-02f, 5.41774631e-02f, -8.97970870e-02f, -8.83417428e-02f, -1.45421773e-01f,
  -4.74565253e-02f, 3.26736867e-02f, 5.35799842e-03f, -1.00381784e-01f, 7.78656304e-02f, 8.48348960e-02f, -9.64759141e-02f, 1.44155607e-01f, 1.07621036e-01f, 4.88366000e-02f,
  -1.17334761e-01f, -1.39065593e-01f, -1.26006305e-01f, -1.91106096e-01f, 5.38318120e-02f, 8.41713026e-02f, 1.42578334e-01f, -1.40019789e-01f, -1.66008949e-01f, 1.09514482e-01f,
  -1.54337659e-01f, -6.19678199e-02f, 2.67415843e-03f, -1.06738396e-01f, -2.58616935e-02f, 6.39467910e-02f, 1.07180394e-01f, -6.89290464e-02f, -5.64135984e-02f, 8.26140046e-02f,
  4.61065769e-02f, -1.42436191e-01f, 1.76849943e-02f, -1.09970033e-01f, 1.01329856e-01f, 1.03256486e-01f, 1.02838054e-01f, 7.90454373e-02f, 8.01374316e-02f, -1.10621579e-01f,
  -8.57627466e-02f, -6.98894933e-02f, 9.94592756e-02f, 1.89163592e-02f, 1.39953839e-02f, 1.07390419e-01f, 2.22844645e-01f, 1.29975811e-01f, -1.37801886e-01f, 8.65991414e-02f,
  1.25019878e-01f, -5.83515577e-02f, -6.51643723e-02f, -7.81819820e-02f, -9.12681371e-02f, 1.15414925e-01f, -1.16008818e-01f, -1.46523297e-01f, 1.05978504e-01f, -1.23729095e-01f,
  -1.15706362e-01f, 5.64530492e-02f, 4.45378292e-03f, 4.46868278e-02f, -2.50485633e-02f, -9.21097398e-03f, -2.29817517e-02f, -6.71820641e-02f, 5.13662118e-03f, -3.26042660e-02f,
  4.56650145e-02f, 2.23371238e-02f, -5.78758866e-02f, 6.53345883e-03f, 1.53618241e-02f, -1.96263772e-02f, 2.35331450e-02f, -4.51722974e-03f, 6.54710922e-03f, 7.22565269e-03f,
  -2.59058666e-03f, -1.09527716e-02f, -1.40239084e-02f, -8.29254314e-02f, 2.09008574e-01f, -6.89027584e-05f, -4.79704812e-02f, -5.56546748e-02f, 8.17475766e-02f, -1.94459539e-02f,
  5.78318648e-02f, 1.81206982e-04f, 3.28091457e-02f, 1.30735502e-01f, 5.40158078e-02f, 2.26149969e-02f, 4.86919023e-02f, 5.39547764e-02f, -1.18722074e-01f, 3.37913297e-02f,
  3.46862734e-03f, 4.87317108e-02f, 6.28997833e-02f, -3.65705788e-02f, 4.34452854e-02f, 1.23702005e-01f, -8.94988794e-03f, 4.29747887e-02f, -2.72699390e-02f, 1.33580729e-01f,
  -5.62986284e-02f, 1.59599669e-02f, 1.08543970e-02f, -2.07845196e-02f, 4.12351303e-02f, 1.59325510e-01f, 5.71508445e-02f, -7.31014535e-02f, 6.21541999e-02f, 7.90029392e-02f,
  1.63245201e-01f, -3.88831086e-02f, -1.93337157e-01f, -1.04216859e-01f, 1.48315132e-01f, -1.35814935e-01f, -1.53105170e-01f, 7.56966248e-02f, -1.79658368e-01f, 6.27206117e-02f,
  -2.16033924e-02f, 2.80535351e-02f, -6.67519048e-02f, 8.40402618e-02f, 1.30834365e-02f, -1.35727435e-01f, -1.57234147e-02f, -2.33732253e-01f, -6.73326924e-02f, 1.80519260e-02f,
  1.34500802e-01f, 7.61020184e-02f, -1.38308508e-02f, -1.17811717e-01f, -1.15778841e-01f, 1.51993200e-01f, -1.44221365e-01f, 2.27601260e-01f, 9.90027413e-02f, 4.77013588e-02f,
  -2.04088148e-02f, 1.99764565e-01f, 5.70263304e-02f, -1.02405958e-01f, -6.08529635e-02f, 3.77942920e-02f, 6.29815832e-02f, 8.23359638e-02f, -8.33112150e-02f, 1.12659484e-01f,
  -1.49847299e-01f, 2.53456403e-02f, -8.51517469e-02f, -1.35499388e-01f, -5.04786409e-02f, 2.38524727e-03f, 9.34519172e-02f, 1.92079410e-01f, 2.33846512e-02f, 4.99316305e-02f,
  -8.94920155e-02f, -2.18708023e-01f, 1.94140896e-01f, -1.79156348e-01f, 2.60587856e-02f, -1.69737712e-02f, 6.44760281e-02f, 2.23559923e-02f, -1.79400563e-01f, -3.35520855e-03f,
  -1.40230004e-02f, 1.36993676e-01f, 1.20910471e-02f, 1.29054680e-01f, -1.96526349e-02f, 1.62695527e-01f, 5.15104271e-02f, -2.02315748e-02f, -2.02004492e-01f, -1.60312191e-01f,
  6.60727099e-02f, -5.19079939e-02f, -8.42035264e-02f, 8.27391967e-02f, -2.81141065e-02f, 5.86344860e-02f, 1.84097085e-02f, -5.50408363e-02f, -8.81631449e-02f, -1.15798311e-02f,
  -5.22896834e-02f, -7.64209554e-02f, 5.08720838e-02f, -2.98320446e-02f, 4.30927658e-03f, 3.01848333e-02f, -1.19330406e-01f, -6.59150928e-02f, 7.96426088e-02f, -5.65315709e-02f,
  3.16630863e-02f, -2.55848514e-03f, 1.26896262e-01f, -1.27394795e-01f, 5.37263416e-02f, -1.17093921e-01f, -1.67447373e-01f, 2.77064834e-02f, -5.89506365e-02f, 8.69314224e-02f,
  -7.21154502e-03f, -6.99551478e-02f, -1.71840526e-02f, 1.24696195e-02f, 3.31843346e-02f, -8.09002742e-02f, -5.02295457e-02f, -1.32324442e-01f, -2.92459652e-02f, 3.30975652e-02f,
  -2.52168290e-02f, -8.98680314e-02f, 1.39687303e-02f, -6.31826520e-02f, -2.77246311e-02f, -5.34038767e-02f, -3.83742750e-02f, -5.70693351e-02f, -5.09984456e-02f, 6.93492219e-02f,
  -2.56753899e-02f, -8.12366232e-02f, 5.34000248e-02f, -8.35762322e-02f, 1.25232302e-02f, 8.73899311e-02f, 1.64637014e-01f, -1.44259244e-01f, 2.20213272e-02f, 6.81382790e-02f,
  -4.43370529e-02f, -1.97229329e-02f, -1.12166785e-01f, -1.04393968e-02f, 3.20250392e-02f, 1.01537183e-01f, 2.28511146e-03f, 7.20532425e-03f, -1.37842864e-01f, 1.00404713e-02f,
  1.08126968e-01f, 1.35951504e-01f, -3.24315648e-03f, -1.96602587e-02f, -3.37361209e-02f, -2.11490586e-01f, -6.54992834e-02f, 1.81544926e-02f, -9.97978151e-02f, -1.51689962e-01f,
  -2.01717556e-01f, -1.24078572e-01f, 1.07826926e-01f, 2.90825032e-02f, -1.49472177e-01f, -2.11494952e-03f, -1.82824716e-01f, -1.60277545e-01f, -1.04558043e-01f, -5.03749102e-02f,
  -2.93834833e-03f, 1.20079562e-01f, 1.13157466e-01f, -5.24231233e-02f, -2.20044360e-01f, -1.08505651e-01f, 5.86592928e-02f, -6.25287965e-02f, -6.00685319e-03f, -1.39513180e-01f,
  -8.45241942e-04f, 1.06373057e-01f, 1.17267475e-01f, 4.02168147e-02f, 4.65639681e-02f, 2.95020919e-02f, 1.06598698e-01f, 1.03894353e-01f, 2.18227372e-01f, -2.32119858e-01f,
  -3.15910354e-02f, 1.18251041e-01f, -2.36912761e-02f, 9.07871872e-02f, -3.72261591e-02f, 3.80601431e-03f, 5.30281290e-02f, 1.63831949e-01f, 1.36864319e-01f, -1.58064291e-01f,
  -4.02749004e-03f, 5.03543839e-02f, -2.98003457e-03f, 1.40759349e-02f, 9.06534716e-02f, -2.38404900e-01f, 1.70488790e-01f, -1.39691606e-01f, 8.96377787e-02f, 9.51933414e-02f,
  -9.02241692e-02f, -2.09347811e-02f, -5.58660589e-02f, -6.39535338e-02f, 5.61687052e-02f, 7.44803697e-02f, 2.43195966e-02f, 3.03208940e-02f, -1.38020486e-01f, 2.09492706e-02f,
  3.48155983e-02f, -2.76233722e-03f, -1.24256402e-01f, -1.53006718e-03f, -2.52215117e-02f, 9.12280660e-03f, -5.01812920e-02f, 5.04234470e-02f, -7.33447969e-02f, -6.05041720e-03f,
  4.49778959e-02f, 9.71446484e-02f, -6.76572397e-02f, 3.06065399e-02f, -4.55472916e-02f, -1.54983616e-02f, -1.76063254e-02f, 5.72206080e-02f, 4.26791497e-02f, 5.67293540e-02f,
  1.89030878e-02f, 1.58714205e-02f, 1.73447818e-01f, 9.36853141e-02f, 1.24947028e-02f, 3.43931913e-02f, -6.81884289e-02f, 1.43679446e-02f, 2.91195288e-02f, -4.96637300e-02f,
  1.71064600e-01f, 1.82531789e-01f, -7.93126225e-03f, 7.18768612e-02f, -5.05472571e-02f, 7.52609000e-02f, -1.64131641e-01f, -7.75297582e-02f, -2.21718801e-03f, 1.02912329e-01f,
  -1.00304574e-01f, -4.86511029e-02f, -4.46193144e-02f, 1.26741845e-02f, 1.18666694e-01f, -3.83788943e-02f, 1.53868049e-01f, 3.84254344e-02f, -1.04898736e-01f, 3.35897505e-02f,
  1.64643049e-01f, -1.18520066e-01f, -9.04849023e-02f, -7.97109604e-02f, -1.48844853e-01f, 1.52889714e-01f, -9.44793075e-02f, -2.09858015e-01f, -5.38539095e-03f, 1.44629166e-01f,
  2.09981352e-02f, -5.60972048e-03f, 3.65672596e-02f, -6.90742731e-02f, -1.81186602e-01f, -1.65677324e-01f, -4.68675494e-02f, -8.97767022e-02f, 1.52279988e-01f, 3.19198743e-02f,
  7.25920200e-02f, -4.76775281e-02f, -2.45613500e-01f, 5.25442772e-02f, -3.68643366e-02f, -4.38828319e-02f, -7.41592655e-03f, -2.52385251e-02f, 1.25048077e-02f, 2.16698423e-02f,
  8.93513337e-02f, -1.87263172e-02f, 1.03843573e-03f, 3.22640687e-02f, 2.31958553e-02f, 3.56780551e-02f, 2.21845396e-02f, -1.38343930e-01f, -6.15953170e-02f, -7.95240253e-02f,
  -9.73971654e-03f, 8.44596997e-02f, -8.32299739e-02f, 4.56678160e-02f, -7.03086853e-02f, -2.00762063e-01f, -5.80222942e-02f, -1.41756549e-01f, 1.80169478e-01f, -8.25003609e-02f,
  9.28665996e-02f, -1.52435511e-01f, -7.30887726e-02f, -7.36927688e-02f, 3.41445543e-02f, -7.88060352e-02f, -1.02267273e-01f, -1.70004293e-02f, -8.86219367e-02f, 1.57460883e-01f,
  -9.55453143e-02f, 2.61770515e-03f, 4.79080789e-02f, -1.90088466e-01f, -7.06690773e-02f, -5.74749988e-03f, -4.59657200e-02f, 1.98905673e-02f, -3.91187817e-02f, -7.19080213e-03f,
  -4.78433305e-03f, 9.55968648e-02f, 9.30674523e-02f, -1.78780407e-02f, 2.25908849e-02f, -4.79049124e-02f, 9.18431208e-02f, 8.36919248e-02f, -4.00629565e-02f, 9.21670049e-02f,
  7.19408467e-02f, -3.93263511e-02f, -4.61813807e-02f, -3.18226106e-02f, 3.33637893e-02f, -1.88297145e-02f, 6.41362071e-02f, 8.54338184e-02f, -3.17543969e-02f, -6.74670115e-02f,
  3.85206845e-03f, 1.08739197e-01f, 6.34602010e-02f, 4.85978351e-04f, 6.22294843e-02f, -5.03401570e-02f, 8.10623169e-02f, -4.16070931e-02f, 6.99023679e-02f, 4.01335582e-02f,
  -9.17254016e-02f, -4.24621031e-02f, 2.31369622e-02f, 2.52796728e-02f, 6.91011325e-02f, -4.45922352e-02f, -4.54347804e-02f, -5.66949369e-03f, -3.48502360e-02f, -3.60898972e-02f,
  -3.82150784e-02f, -7.81398863e-02f, 8.40649605e-02f, 3.51379596e-04f, 1.33827969e-01f, 3.22971120e-02f, 8.15458000e-02f, 4.62567620e-02f, 4.68202680e-02f, 1.24453560e-01f,
  1.64493918e-01f, -6.84249178e-02f, -7.68704489e-02f, -2.01628935e-02f, -1.23179378e-02f, 4.48169969e-02f, 2.56218445e-02f, -1.57314986e-02f, 1.39600621e-03f, -5.45346364e-03f,
  -5.84689761e-03f, 1.39574647e-01f, 2.99046598e-02f, -1.47001311e-01f, 2.24195883e-01f, 8.89192075e-02f, -1.00047179e-01f, -8.25338289e-02f, -1.33841142e-01f, 1.18733019e-01f,
  6.75273687e-02f, -6.76289350e-02f, 1.31679028e-01f, 9.04206634e-02f, 6.22828268e-02f, -1.17188774e-01f, -4.80805337e-02f, 9.86904576e-02f, -1.72729164e-01f, 1.09036146e-02f,
  7.42709562e-02f, 2.30798125e-02f, 7.57499859e-02f, -1.21775173e-01f, -5.86620159e-02f, 3.41520794e-02f, -1.36684207e-03f, -8.46807361e-02f, -1.54308036e-01f, -3.17599066e-02f,
  -4.02984535e-03f, -1.63421445e-02f, 2.42473558e-02f, -1.48896962e-01f, -1.94623787e-02f, 1.17850788e-01f, -4.74530905e-02f, -3.55800018e-02f, -4.13883384e-03f, -1.07154980e-01f,
  2.70035207e-01f, 6.50940239e-02f, -9.43404436e-03f, 1.07121371e-01f, 2.71946099e-02f, 1.04968064e-01f, -1.75696790e-01f, 4.27111834e-02f, 8.36536139e-02f, 2.26967558e-02f,
  -9.62842554e-02f, 1.56868875e-01f, -3.26201133e-02f, 4.69148941e-02f, 8.22831094e-02f, -1.74742609e-01f, 7.77270785e-03f, -1.32391036e-01f, 9.61671919e-02f, 7.89976642e-02f,
  2.09799960e-01f, 1.61185674e-02f, -6.26675487e-02f, -8.90408680e-02f, -5.80634165e-04f, 5.95232099e-03f, 3.83864902e-02f, 7.22544193e-02f, 9.75671634e-02f, -4.27089296e-02f,
  -8.12109113e-02f, -1.30321074e-03f, -2.88387910e-02f, 7.54816458e-02f, -6.27477989e-02f, -9.52647775e-02f, 7.01804385e-02f, -1.90188847e-02f, -1.89321283e-02f, 4.20499928e-02f,
  3.32239456e-02f, 4.07285243e-02f, -2.15279497e-02f, -5.13087073e-03f, -4.00733426e-02f, -1.82811283e-02f, 4.59177494e-02f, 2.70715952e-02f, 1.75823048e-02f, -4.82005142e-02f,
  -9.09722298e-02f, -5.99399954e-02f, -5.12365736e-02f, 5.18776439e-02f, -2.32507680e-02f, -5.80781279e-03f, -5.83282895e-02f, -8.20143968e-02f, -7.63511052e-03f, 3.49415131e-02f,
  -5.77979051e-02f, -7.47346282e-02f, -2.98137423e-02f, -1.44160644e-03f, 1.24917254e-02f, 3.25441137e-02f, 8.35817754e-02f, 6.05786592e-02f, 6.42087460e-02f, 3.55548263e-02f,
  1.33020410e-04f, 4.52055633e-02f, -1.42943040e-01f, -8.70132670e-02f, 2.20872704e-02f, -8.64635184e-02f, 6.91780150e-02f, -1.40555128e-01f, -1.11392178e-01f, -4.46400270e-02f,
  1.35961726e-01f, 1.98541004e-02f, -1.37780160e-01f, -7.34932721e-02f, 6.42366037e-02f, -3.63606922e-02f, -9.07697305e-02f, -4.54353690e-02f, -4.42597345e-02f, -1.22087568e-01f,
  -6.35140687e-02f, 1.36642188e-01f, -1.78330988e-01f, 4.12508380e-03f, 1.25929967e-01f, 4.25127409e-02f, 1.82397485e-01f, -1.30151063e-01f, -1.21393040e-01f, 1.01457564e-02f,
  -8.92838836e-02f, -3.70144993e-02f, -1.35279506e-01f, 5.83350137e-02f, 1.36422217e-02f, -2.26323679e-01f, 1.82918340e-01f, 2.19127722e-02f, -6.35069907e-02f, -8.34176391e-02f,
  -5.22179864e-02f, 1.69967681e-01f, -2.06557103e-02f, -3.16703431e-02f, -5.40450253e-02f, 3.23764719e-02f, 1.69395179e-01f, 5.74678965e-02f, 3.32129351e-03f, -9.82278120e-03f,
  -1.21575326e-01f, 8.89800638e-02f, -1.47717074e-02f, -1.39186323e-01f, 3.25059406e-02f, 3.10850460e-02f, -1.30276963e-01f, 2.26032790e-02f, -1.56404704e-01f, -5.69798686e-02f,
  7.66023993e-02f, -1.05909288e-01f, -2.14730389e-02f, -9.91259664e-02f, 2.20072031e-01f, -2.59342548e-02f, -4.34231944e-02f, 7.75013044e-02f, 1.59494534e-01f, -1.46622121e-01f,
  1.63779184e-02f, -3.90877835e-02f, 1.10099176e-02f, 1.08143382e-01f, 1.02585420e-01f, 3.25294733e-02f, -1.07482322e-01f, -2.18101650e-01f, -2.30408549e-01f, -1.41817387e-02f,
  1.11981943e-01f, 1.14382729e-01f, -1.17939264e-01f, 1.13034897e-01f, -4.07809019e-02f, -1.47815898e-01f, -5.97061962e-02f, -2.67402213e-02f, -1.19835334e-02f, -3.87127772e-02f,
  3.02357897e-02f, -2.21165828e-02f, -4.37232703e-02f, -2.13136487e-02f, 6.62859455e-02f, 7.68348351e-02f, 2.00397987e-03f, 1.91137642e-02f, -3.89102921e-02f, -2.14753766e-02f,
  -8.77077430e-02f, 5.28166220e-02f, -3.27046178e-02f, -6.52710646e-02f, 1.14770055e-01f, -5.40282093e-02f, 5.66313043e-03f, -3.23216319e-02f, 7.15506300e-02f, 5.07165641e-02f,
  7.34822974e-02f, -6.50416017e-02f, -6.21750094e-02f, 4.98564960e-03f, -4.05450948e-02f, 3.73286903e-02f, 6.65939599e-02f, -1.36964843e-02f, -2.96151382e-03f, -1.99241489e-02f,
  2.27431618e-02f, 1.04440071e-01f, -6.98146038e-03f, -2.32101679e-02f, 1.31411413e-02f, 1.78031772e-02f, 1.73124466e-02f, 2.60637663e-02f, -1.02560334e-01f, 4.50200122e-03f,
  -1.15527153e-01f, -2.83078738e-02f, -1.03242807e-01f, -3.90975028e-02f, 1.30714640e-01f, 1.08812191e-02f, 6.01584762e-02f, -5.35041615e-02f, -6.66776374e-02f, -1.90090686e-01f,
  1.32420123e-01f, -1.43588200e-01f, -1.59408942e-01f, -2.03172639e-02f, 7.72804990e-02f, 7.20513687e-02f, -5.60948551e-02f, 4.49554026e-02f, 1.49128065e-01f, 1.05043163e-03f,
  -3.95897999e-02f, 1.46728888e-01f, -1.00534875e-02f, -3.90491821e-03f, -1.03196330e-01f, -1.11455977e-01f, 1.85289964e-01f, -4.48854975e-02f, -1.36009222e-02f, -6.72529042e-02f,
  7.36541823e-02f, 9.74255651e-02f, 8.79347026e-02f, -1.84265915e-02f, 2.94792801e-02f, 7.10348412e-02f, -1.48477405e-01f, -3.03253569e-02f, -6.21466003e-02f, 1.75491661e-01f,
  -3.94265763e-02f, -1.14290088e-01f, 6.61566481e-02f, 8.54278728e-02f, -2.12688111e-02f, 3.33809406e-02f, -3.19335423e-02f, -4.49204184e-02f, -8.08327496e-02f, -8.11581165e-02f,
  -1.82836220e-01f, 9.98866707e-02f, -8.18321332e-02f, -2.34454628e-02f, 1.25040889e-01f, 1.07741475e-01f, 1.34863444e-02f, -1.05988041e-01f, -3.91385369e-02f, -1.34047985e-01f,
  -2.50989422e-02f, -9.00262222e-02f, 6.55512586e-02f, -1.11757606e-01f, -1.32216439e-01f, -1.92234188e-01f, 3.40950047e-03f, -1.18226893e-01f, -7.57852495e-02f, -1.03273705e-01f,
  -4.47787764e-03f, 2.00447574e-01f, -4.32752520e-02f, 1.26356706e-01f, -7.92689398e-02f, -9.01103318e-02f, 1.41758114e-01f, 4.07738239e-03f, 4.57380824e-02f, -1.79346830e-01f,
  8.52091908e-02f, 1.10773314e-02f, 1.12105414e-01f, -5.98947108e-02f, 2.54284963e-02f, -4.89772446e-02f, 2.40338128e-02f, 7.78331161e-02f, -4.01623510e-02f, -2.38145199e-02f,
  -2.88783312e-02f, 1.05547644e-02f, -4.12963890e-02f, -3.49436887e-02f, -7.23825023e-03f, -1.87674239e-02f, 4.71094577e-03f, 6.45862818e-02f, 3.62592116e-02f, -1.38359563e-02f,
  2.99636405e-02f, -1.69088803e-02f, -1.70783713e-01f, 4.38602306e-02f, -3.82853821e-02f, 7.65225962e-02f, -1.00942731e-01f, 8.52823853e-02f, -5.44149578e-02f, 9.96977985e-02f,
  4.68408316e-02f, 4.38639782e-02f, 1.31088765e-02f, 2.46704854e-02f, 9.07569155e-02f, -2.04845630e-02f, 1.02258667e-01f, 5.31745367e-02f, -1.03361048e-02f, 2.65455414e-02f,
  1.01347476e-01f, 1.31112002e-02f, -2.10667253e-02f, -1.39727876e-01f, 8.95946994e-02f, 5.69431186e-02f, -3.41268256e-02f, -8.54508355e-02f, 1.44404560e-01f, 4.01680954e-02f,
  -1.25709269e-02f, 2.44732518e-02f, -1.58710286e-01f, -2.76760627e-02f, -9.93168876e-02f, 5.72159551e-02f, -1.09982237e-01f, 9.25133005e-02f, -8.42778236e-02f, 4.35753353e-02f,
  1.17630169e-01f, 1.60919696e-01f, -3.62585522e-02f, 6.01224676e-02f, 1.14811420e-01f, -1.19107567e-01f, 7.27695301e-02f, 4.65082889e-03f, -2.00433061e-02f, -1.41639873e-01f,
  5.38426563e-02f, -2.93512102e-02f, 6.97874557e-03f, 7.10574016e-02f, 5.70895597e-02f, 2.60428041e-01f, 9.63794068e-03f, 1.79038802e-03f, -8.25128406e-02f, -1.18141599e-01f,
  5.89003302e-02f, 1.63500607e-01f, 2.85717845e-02f, -1.77371860e-01f, 1.50265321e-01f, -6.89176768e-02f, -4.42734286e-02f, 6.75778510e-03f, 1.17150158e-01f, -6.39783815e-02f,
  -1.50323780e-02f, -3.61206606e-02f, 4.82719205e-02f, -4.48923707e-02f, 1.28202429e-02f, 4.34359238e-02f, 5.24869189e-02f, 5.68216294e-02f, 1.77991569e-01f, 6.99271485e-02f,
  1.34185031e-01f, 7.56491274e-02f, 9.43563133e-02f, 9.10076723e-02f, -4.75618653e-02f, -8.70842710e-02f, 1.31191779e-03f, -4.16259505e-02f, 9.31112617e-02f, 1.59289911e-01f,
  -1.99012039e-03f, 2.27380976e-01f, -3.24552953e-02f, 6.59249648e-02f, 7.43251592e-02f, 4.09959368e-02f, 1.28974810e-01f, 8.05713795e-03f, -7.50703514e-02f, 6.68778941e-02f,
  -5.01541607e-02f, -3.47087719e-02f, 2.54217815e-02f, -9.47184861e-02f, -7.98023269e-02f, 1.62032247e-01f, 1.15045102e-03f, 1.20187514e-01f, 2.61531826e-02f, -7.11655468e-02f,
  1.31484326e-02f, 9.37679783e-02f, 4.53494787e-02f, 1.47787333e-01f, -2.63420008e-02f, -3.08636799e-02f, -3.05326730e-02f, 4.51416224e-02f, 8.83501843e-02f, -5.23837730e-02f,
  4.12291437e-02f, -7.20029920e-02f, 5.89844026e-02f, 7.26914257e-02f, -1.97990593e-02f, -1.35913596e-03f, -3.47155891e-02f, 1.02288358e-01f, 6.43647239e-02f, 5.10486141e-02f,
  -1.19524121e-01f, 2.10816022e-02f, 9.31686237e-02f, 8.63621086e-02f, -2.14133978e-01f, 4.52191010e-02f, -7.01271184e-03f, 1.07483342e-01f, -6.17399905e-03f, -1.01121575e-01f,
  1.08553199e-02f, -1.05105124e-01f, -1.71190314e-02f, 1.22897560e-02f, 4.02973406e-02f, -3.55795436e-02f, -7.07062632e-02f, 2.83202101e-02f, 8.93779248e-02f, 7.98055604e-02f,
  2.19628960e-02f, -3.15459631e-02f, 7.17177168e-02f, -9.48351063e-03f, -1.83895864e-02f, -1.14948437e-01f, -9.78563633e-03f, 1.35731688e-02f, 8.48766789e-02f, -6.44964501e-02f,
  -5.68809807e-02f, -1.68275267e-01f, -1.42638132e-01f, 1.25364929e-01f, -2.67565623e-02f, -1.63401410e-01f, -2.00007379e-01f, 9.67135131e-02f, 1.53237388e-01f, 7.57075325e-02f,
  -1.20276824e-01f, 5.16722165e-02f, 1.10372826e-01f, -1.12794153e-01f, 1.06331147e-01f, -5.08831181e-02f, -8.81413743e-02f, -9.50977504e-02f, 1.28179744e-01f, -9.07835215e-02f,
  -1.37240812e-02f, 1.30968496e-01f, -4.35481891e-02f, 1.73929915e-01f, -2.88696047e-02f, -1.21074572e-01f, -1.41430587e-01f, -7.09012970e-02f, 1.10236499e-02f, 8.50718915e-02f,
  1.32530466e-01f, -1.28391474e-01f, 1.21741906e-01f, -2.26213232e-01f, -1.58909142e-01f, -7.39291906e-02f, 1.94326323e-02f, -1.68678671e-01f, -2.39400025e-02f, 1.11340776e-01f,
  1.23880804e-01f, -4.79447953e-02f, -4.85030152e-02f, -1.01210818e-01f, 9.56057906e-02f, -1.07142292e-01f, 5.11533134e-02f, -8.32812190e-02f, 8.37747380e-02f, 1.15128107e-01f,
  6.56596348e-02f, -5.86328954e-02f, -1.59607545e-01f, -1.55489653e-01f, -2.84208469e-02f, -7.31947571e-02f, -4.16036788e-03f, 1.61718726e-01f, -1.16676897e-01f, 1.29564032e-01f,
  4.36901674e-02f, 1.35009252e-02f, -4.53417078e-02f, -1.06309749e-01f, 1.67860374e-01f, 4.43031220e-03f, -6.42015338e-02f, -1.45364404e-01f, 7.18077470e-04f, -1.83156922e-01f,
  2.07273867e-02f, -1.46586850e-01f, -3.68348248e-02f, -1.15196258e-02f, 1.39580816e-01f, 2.16145709e-01f, -3.38224992e-02f, -2.40306389e-02f, -7.83465132e-02f, -5.65478839e-02f,
  -1.35338172e-01f, 4.70891446e-02f, 1.30070299e-02f, -2.87026297e-02f, -7.91898146e-02f, 3.94645520e-02f, -1.04683258e-01f, 4.16331105e-02f, 1.13513721e-02f, 7.35220015e-02f,
  -3.27938497e-02f, -2.75741518e-02f, -4.14099544e-02f, 1.27049163e-01f, -2.77898386e-02f, -2.76893303e-02f, 5.54196499e-02f, 9.45464149e-02f, 5.42389788e-02f, -1.81246009e-02f,
  -6.62180483e-02f, 1.28424047e-02f, 8.75263587e-02f, -2.67405938e-02f, -1.23558939e-02f, -6.71277046e-02f, -6.00806549e-02f, 1.50049608e-02f, -9.99406874e-02f, 1.81682125e-01f,
  4.62116674e-02f, -8.95049721e-02f, 1.48880959e-01f, -8.00165441e-03f, 5.46538606e-02f, -3.03563904e-02f, -1.06355309e-01f, 3.29967146e-03f, -4.73940633e-02f, -1.26030311e-01f,
  -8.38242769e-02f, -4.27145660e-02f, -6.30058944e-02f, 4.08294983e-02f, 4.62482050e-02f, 5.17456234e-02f, -4.04762775e-02f, 6.96343780e-02f, 6.52481765e-02f, -1.78580377e-02f,
  3.33159193e-02f, 5.32783456e-02f, -5.53334951e-02f, 5.53163178e-02f, 1.37565330e-01f, -8.06271657e-02f, -6.19166866e-02f, -1.89486369e-02f, -3.66542563e-02f, 1.90405309e-01f,
  8.30108076e-02f, 8.43657255e-02f, 2.42141515e-01f, 6.26737326e-02f, -3.37422416e-02f, 1.23301506e-01f, -8.62127692e-02f, 5.27388155e-02f, -5.79199493e-02f, -2.55333126e-01f,
  7.57349804e-02f, -3.86448763e-02f, 2.25642920e-02f, 8.99849087e-02f, 1.41899213e-01f, 1.82158694e-01f, -1.27570510e-01f, 1.98101159e-02f, 4.40228507e-02f, 6.99737519e-02f,
  1.15486607e-01f, 5.33699766e-02f, 1.36647401e-02f, 9.22001153e-02f, 4.68227593e-03f, -3.20858844e-02f, 8.52118582e-02f, 3.98777574e-02f, -1.55099943e-01f, 7.20694289e-02f,
  -8.43782648e-02f, 3.08955908e-02f, -6.49040416e-02f, 4.89922427e-02f, -3.67150865e-02f, 1.59883454e-01f, -4.84099761e-02f, -1.81385875e-02f, 1.66296214e-01f, 1.79056257e-01f,
  2.45604236e-02f, 3.84873375e-02f, 6.26729280e-02f, 1.64552718e-01f, 1.51286721e-01f, -1.53514296e-01f, -3.21169011e-02f, 6.49463236e-02f, -1.81947798e-01f, -4.92349602e-02f,
  -4.50033695e-02f, 5.84893078e-02f, -5.41738160e-02f, 9.66007039e-02f, 1.34848908e-01f, 6.18734062e-02f, -4.24937010e-02f, 1.43220305e-01f, 6.35805354e-02f, 7.73986429e-02f,
  -1.04748020e-02f, 1.19191092e-02f, 1.04279518e-01f, -1.75828069e-01f, 6.34342283e-02f, 1.13737330e-01f, 3.75641324e-02f, -2.11320724e-02f, 3.15455757e-02f, 4.61580604e-02f,
  4.55998480e-02f, -5.17371595e-02f, -3.40689383e-02f, 4.27303128e-02f, 6.75968081e-02f, 5.52511103e-02f, 1.46554083e-01f, 1.06212543e-02f, 5.14141209e-02f, 6.15230910e-02f,
  -2.17059404e-02f, 1.34070858e-01f, 2.65467539e-02f, 2.63618189e-03f, 1.58538539e-02f, -6.34533539e-02f, 7.99535811e-02f, 8.46774951e-02f, 1.20107599e-01f, 3.72067690e-02f,
  1.11009948e-01f, 8.90566781e-02f, 9.94477794e-03f, 5.49135841e-02f, 5.41997030e-02f, 6.21635802e-02f, 1.46861644e-02f, -1.25648808e-02f, 1.52981848e-01f, 9.69395116e-02f,
  -3.40792835e-02f, 5.05579449e-02f, 3.60168032e-02f, 6.46943599e-02f, 1.78409982e-02f, -7.81173538e-03f, 4.99670990e-02f, 5.71798086e-02f, 6.25758171e-02f, 5.16137294e-02f,
  -1.83040351e-02f, 5.44852130e-02f, -4.00795490e-02f, 2.48923358e-02f, -9.81838480e-02f, -7.90900365e-03f, 3.77775095e-02f, 4.37310189e-02f, 3.99134196e-02f, 1.64507292e-02f,
  8.68114233e-02f, -5.98602444e-02f, 2.60898381e-01f, 1.56420954e-02f, -1.67911321e-01f, -1.06066614e-01f, -1.54814972e-02f, -1.15436492e-02f, -5.63373826e-02f, 5.92279844e-02f,
  -1.08735189e-01f, 1.71057075e-01f, -1.19571187e-01f, -7.67294392e-02f, -1.53231220e-02f, 7.03459382e-02f, -5.01515344e-02f, -5.21957986e-02f, 1.00464158e-01f, -1.41738757e-01f,
  -6.23972975e-02f, -1.41061572e-02f, -2.25482658e-02f, -1.33441702e-01f, -3.28928232e-02f, 6.30684122e-02f, 1.29840568e-01f, -7.40124797e-03f, -1.40315756e-01f, 4.52793799e-02f,
  -1.39972329e-01f, -3.57944034e-02f, 3.08103878e-02f, -5.98354973e-02f, -3.08982711e-02f, -2.56950986e-02f, 7.90239777e-03f, -8.24361220e-02f, -1.20551936e-01f, 8.18417445e-02f,
  8.34020600e-02f, -2.31919736e-02f, -1.37291446e-01f, -5.56059703e-02f, 1.29541960e-02f, 1.64663289e-02f, 1.78604409e-01f, 5.13239205e-02f, -9.25708562e-02f, -4.16868739e-02f,
  8.24659877e-03f, -6.20261580e-02f, 1.21046141e-01f, -2.24369720e-01f, 5.24329804e-02f, 1.77415043e-01f, -1.19177159e-02f, 5.35137579e-03f, 6.21800087e-02f, 3.13215218e-02f,
  2.06555314e-02f, 6.32326528e-02f, -4.08793241e-02f, -1.13088414e-02f, -9.15698335e-02f, 8.45147222e-02f, 7.95199722e-02f, 5.94505109e-02f, 1.89388111e-01f, -7.37379491e-02f,
  6.99134031e-03f, -1.91982806e-01f, -4.06498685e-02f, 3.20432745e-02f, 5.40992916e-02f, -8.81605968e-02f, 5.60960546e-03f, 1.19033732e-01f, 3.35456096e-02f, -7.18254270e-03f,
  -1.44053940e-02f, 2.55651772e-02f, 9.93588120e-02f, -1.89815310e-03f, 3.86268497e-02f, -7.88424388e-02f, 5.48360944e-02f, 5.09611256e-02f, 6.08157590e-02f, 3.24583761e-02f,
  2.81752534e-02f, 1.42900785e-03f, 9.16004479e-02f, 1.26766937e-03f, 8.22742470e-03f, -2.51443107e-02f, 2.50681695e-02f, 7.91812539e-02f, 7.25088045e-02f, 1.33828744e-01f,
  8.02608207e-02f, -1.09029934e-02f, 6.09283857e-02f, 5.06276600e-02f, 1.15871066e-02f, 5.02319075e-02f, -2.18030699e-02f, -7.01741055e-02f, 1.25980878e-03f, -4.56591079e-04f,
  4.61194851e-02f, 9.38332290e-04f, 5.12366816e-02f, 3.29247713e-02f, -4.19622883e-02f, -1.31025374e-01f, -4.66655754e-02f, 3.93772312e-02f, 8.74613225e-02f, -4.22008149e-02f,
  1.15704097e-01f, 1.10102348e-01f, -5.42659611e-02f, -1.19590461e-02f, -6.46551028e-02f, 5.08810878e-02f, -2.89327378e-04f, -7.73313781e-03f, -1.54332116e-01f, 1.87046826e-02f,
  4.42394763e-02f, 2.66674180e-02f, -1.71754565e-02f, -9.71206054e-02f, -2.94804983e-02f, 9.69756320e-02f, 1.09367467e-01f, 3.71850133e-02f, 1.20716073e-01f, -9.07535851e-03f,
  4.89105359e-02f, 7.73020685e-02f, -3.67313549e-02f, -4.83428799e-02f, -8.17993805e-02f, 2.92511620e-02f, 1.01683855e-01f, 7.55110681e-02f, 3.43617350e-02f, 1.26324460e-01f,
  1.35171100e-01f, 1.07735403e-01f, -8.67535248e-02f, 8.73508975e-02f, -3.80327478e-02f, 2.65013967e-02f, 1.38416722e-01f, 1.42516624e-02f, 2.80979532e-03f, -4.87187831e-03f,
  9.40328389e-02f, 5.55964261e-02f, 3.32948156e-02f, -6.12305366e-02f, -6.51315004e-02f, 3.31678763e-02f, -3.14890370e-02f, 8.58017206e-02f, 1.70574579e-02f, -6.96411915e-03f,
  -5.05097583e-02f, 1.67457551e-01f, 1.45587493e-02f, 5.63459508e-02f, 9.29764584e-02f, 6.56815693e-02f, 1.09100915e-01f, 1.19155189e-02f, 7.33297691e-02f, 1.25989765e-01f,
  9.56036225e-02f, 7.96182156e-02f, -1.36182174e-01f, 5.40731698e-02f, -1.91963138e-03f, 1.11354992e-01f, 1.47935441e-02f, 1.40951633e-01f, -4.60789837e-02f, 1.37008905e-01f,
  5.46747185e-02f, 7.82171562e-02f, 4.01229337e-02f, -1.38363317e-02f, 6.96272925e-02f, 2.06024349e-02f, 7.91560784e-02f, 1.77367285e-01f, -2.40671877e-02f, -1.19776189e-01f,
  -3.52025069e-02f, 5.39128669e-02f, -1.21717136e-02f, -1.81126788e-01f, -1.43567592e-01f, -1.15032256e-01f, -6.24620058e-02f, -9.87576023e-02f, -5.76096661e-02f, -3.97347696e-02f,
  2.12313444e-03f, -2.66538914e-02f, -1.34113710e-02f, -1.02884069e-01f, -1.38350306e-02f, -3.47172581e-02f, -3.40947732e-02f, -1.31705613e-03f, -4.55232300e-02f, -3.26295570e-02f,
  -8.01571086e-03f, -7.66559616e-02f, -7.14636594e-02f, -7.57340118e-02f, 4.47746888e-02f, -1.14296310e-01f, 6.34918883e-02f, 1.61220416e-01f, 1.24324597e-01f, -5.33839501e-02f,
  -9.31355264e-03f, -1.98927838e-02f, -7.74239078e-02f, 1.02088675e-01f, -2.42422335e-02f, -7.79353157e-02f, -9.86423790e-02f, 4.98078205e-02f, -3.69566679e-02f, -2.95587839e-03f,
  1.06732935e-01f, -1.12780936e-01f, -3.68466973e-02f, -1.38568223e-01f, -4.61061411e-02f, -7.44606648e-03f, -5.02416864e-02f, -9.29645821e-02f, 7.78873488e-02f, 8.64607692e-02f,
  -1.82970271e-01f, 8.21101069e-02f, -7.36031979e-02f, 7.26865754e-02f, 8.69887844e-02f, 8.40739459e-02f, -1.38425529e-01f, 1.48210898e-01f, 6.56241179e-02f, -1.08716227e-01f,
  -7.47447535e-02f, 1.36994859e-02f, 5.63257001e-02f, 1.55480459e-01f, 1.14081942e-01f, 3.33739328e-03f, 1.64042398e-01f, 4.68870699e-02f, 9.28143859e-02f, -5.53319305e-02f,
  3.74441631e-02f, 1.03129139e-02f, 1.47817424e-02f, 1.90022457e-02f, 2.30976373e-01f, -1.32950991e-02f, -6.06404245e-02f, -9.70288273e-03f, 1.19456992e-01f, 2.10323613e-02f,
  5.27353399e-02f, 1.29811808e-01f, -4.68101315e-02f, -2.91796811e-02f, 2.80945543e-02f, 3.19213676e-03f, 4.42171842e-02f, 4.19411696e-02f, 9.12388861e-02f, 5.90569004e-02f,
  1.02631368e-01f, 9.97939147e-03f, -8.97154659e-02f, -7.04721641e-03f, 3.59619153e-03f, -2.80770715e-02f, 8.41563568e-02f, 8.63670185e-02f, 1.20674567e-02f, 1.73404902e-01f,
  -3.80433165e-02f, -3.42630222e-02f, 1.59829929e-01f, 1.59499273e-01f, -3.30382772e-02f, -5.12478203e-02f, 7.43626133e-02f, -1.54723804e-02f, 1.88086838e-01f, -6.14882819e-02f,
  -4.39795405e-02f, 3.39028500e-02f, -1.25134841e-01f, -1.02597605e-02f, 2.58085448e-02f, 1.16139874e-01f, -9.78228301e-02f, 9.39131826e-02f, -8.09775591e-02f, 1.42256871e-01f,
  -5.31485192e-02f, 1.20813407e-01f, -5.73211312e-02f, -1.12090155e-01f, 7.64179677e-02f, 1.41800761e-01f, -5.23595922e-02f, -1.41344622e-01f, -2.70431321e-02f, -5.20263836e-02f,
  -8.29102937e-03f, -4.09142161e-03f, -3.22589800e-02f, 1.27493054e-01f, 1.42187580e-01f, 7.22981468e-02f, 1.15114106e-02f, -3.29277441e-02f, 7.09831640e-02f, 7.84353092e-02f,
  -9.64065492e-02f, 1.36397332e-01f, 9.01640132e-02f, 2.28660349e-02f, -4.37661223e-02f, -9.37770307e-02f, 3.90631966e-02f, -1.44151552e-02f, 9.00262967e-02f, 8.81523341e-02f,
  4.04459573e-02f, -1.35356978e-01f, -4.20496464e-02f, 4.20595147e-02f, 4.45760190e-02f, 2.66938377e-03f, 2.86019430e-03f, -2.39003580e-02f, 2.45912727e-02f, -7.02994242e-02f,
  1.29097085e-02f, 1.06544308e-01f, -1.04103543e-01f, -4.49987948e-02f, 7.81116411e-02f, 6.40003607e-02f, 7.79850259e-02f, -5.03405184e-03f, -8.80516600e-03f, -2.48591360e-02f,
  -1.87120121e-02f, -1.62293185e-02f, -8.49469751e-02f, -4.97670248e-02f, 8.09957180e-03f, 5.75303612e-03f, 5.98961785e-02f, 4.21958230e-02f, 6.83734044e-02f, -2.74128951e-02f,
  5.24443500e-02f, 1.39240250e-01f, 1.94937810e-01f, -5.59095964e-02f, -2.77448446e-02f, -8.91690403e-02f, -5.57162426e-02f, -2.49201767e-02f, 2.47691735e-03f, -1.65712403e-03f,
  2.97004767e-02f, 4.53810357e-02f, 1.19795099e-01f, 1.26251549e-01f, 6.90516606e-02f, -2.01004028e-01f, 1.59533903e-01f, 1.74071819e-01f, -8.23758841e-02f, -1.43675864e-01f,
  -1.78833798e-01f, 1.17449015e-01f, 5.09238839e-02f, 8.33437406e-03f, 1.97056025e-01f, 6.61562681e-02f, 1.84003450e-02f, -2.98832823e-02f, -3.46558094e-02f, 5.12298234e-02f,
  -1.89897478e-01f, 1.74095761e-02f, 1.05591498e-01f, 4.43853550e-02f, 8.05920959e-02f, -1.51482642e-01f, -8.03857893e-02f, 3.41631770e-02f, 3.85725312e-02f, -9.22998134e-03f,
  -1.49223730e-01f, 2.53660176e-02f, 1.92751307e-02f, -1.03524901e-01f, 1.10406233e-02f, -1.49365425e-01f, 1.64647994e-04f, 1.32815242e-01f, -5.34335263e-02f, -7.07694003e-03f,
  1.79141928e-02f, -9.15969685e-02f, 1.62999436e-01f, 1.53024234e-02f, -6.43094033e-02f, 1.05169062e-02f, -1.14848025e-01f, 1.08169124e-01f, -1.51755527e-01f, -1.56417131e-01f,
  1.12501793e-01f, -8.89196172e-02f, -1.02758929e-01f, -1.03001110e-01f, -4.20354865e-02f, -6.34354129e-02f, 5.63551150e-02f, -8.40469450e-02f, -7.74035929e-03f, -1.16254337e-01f,
  3.91793251e-02f, 6.00197054e-02f, 2.00741142e-01f, 4.84622046e-02f, -9.17241573e-02f, -6.77233040e-02f, 7.85188563e-03f, -2.98934039e-02f, -1.02697998e-01f, -1.27114244e-02f,
  3.02244052e-02f, 4.16956507e-02f, -4.11615893e-02f, -6.32919222e-02f, 6.63106814e-02f, 4.60885726e-02f, 1.04249851e-03f, 2.75626350e-02f, 2.59970054e-02f, 6.83324635e-02f,
  -2.63344236e-02f, 3.60325463e-02f, -3.71813513e-02f, 8.94121304e-02f, 5.97495469e-04f, 5.51579222e-02f, -5.16910218e-02f, -4.33650203e-02f, 2.05399454e-01f, 1.07860200e-01f,
  -4.71256860e-02f, 8.32492337e-02f, 9.62524023e-03f, -8.45082253e-02f, -2.21993960e-02f, 6.73917830e-02f, -6.42733723e-02f, 1.04173511e-01f, -1.43189356e-02f, 3.21454257e-02f,
  1.11406751e-01f, 1.63514867e-01f, 5.61302481e-03f, 5.04873581e-02f, -9.88857523e-02f, 1.08775198e-01f, 6.17290586e-02f, 8.01663548e-02f, 3.84896062e-02f, 1.30958989e-01f,
  5.72195649e-02f, 6.31465018e-02f, -4.55926470e-02f, 1.95820481e-02f, -3.42715494e-02f, 3.66238295e-03f, 1.01945594e-01f, 1.19401485e-01f, -6.68623392e-03f, -1.39306620e-01f,
  -4.52795103e-02f, 2.69532278e-02f, 8.60284492e-02f, -1.14828393e-01f, 5.84596172e-02f, -6.46913946e-02f, -7.72235617e-02f, -8.04861635e-02f, -7.42557645e-03f, -9.94170979e-02f,
  -7.64711201e-02f, -3.41623984e-02f, 9.57795326e-03f, 9.35861617e-02f, -1.03211738e-01f, 7.72285238e-02f, 8.20270851e-02f, 8.07998423e-03f, -3.91352810e-02f, -7.31192455e-02f,
  3.69915850e-02f, 3.36688310e-02f, -1.10823223e-02f, 3.99250761e-02f, -1.37434930e-01f, -5.82460910e-02f, -1.78111978e-02f, -1.37874871e-01f, 2.40885869e-01f, 9.67751518e-02f,
  -1.62979141e-01f, 7.82562513e-03f, -1.31279886e-01f, 5.29206693e-02f, -1.20722301e-01f, -5.07444963e-02f, -7.75121674e-02f, 1.30407676e-01f, 1.09245718e-01f, 1.46421999e-01f,
  1.76945720e-02f, 4.82319295e-02f, -5.87703735e-02f, -6.53527230e-02f, -8.01777281e-03f, -1.21818185e-01f, -2.22576652e-02f, 1.13870511e-02f, 3.77473496e-02f, 9.47594759e-04f,
  -4.09622267e-02f, -1.28537923e-01f, -6.30210415e-02f, -1.39515549e-01f, -6.68406412e-02f, -1.50072798e-01f, 1.10153750e-01f, -1.72613800e-04f, 1.90159976e-01f, -3.28021348e-02f,
  -2.78031304e-02f, -1.23330094e-01f, -1.06867617e-02f, -7.43157715e-02f, 4.87487465e-02f, 1.00767091e-01f, -3.75507995e-02f, 8.08278248e-02f, -1.25804171e-01f, -5.63675985e-02f,
  5.72777838e-02f, -1.25847220e-01f, 1.03339128e-01f, 1.12339079e-01f, -7.47528374e-02f, 2.43092910e-03f, -3.84415151e-04f, 8.01933836e-03f, 1.07463844e-01f, -4.66432981e-02f,
  -2.72396859e-02f, -1.10332713e-01f, -1.37918517e-02f, -1.21856583e-02f, 2.50115581e-02f, -2.49191541e-02f, 4.54024319e-03f, -9.70644206e-02f, 3.60205397e-02f, 1.89331993e-02f,
  7.03230053e-02f, -5.82617149e-02f, -4.04954441e-02f, -6.91741109e-02f, 1.77222025e-02f, -7.97287747e-02f, 9.26600471e-02f, 6.99914917e-02f, -1.07528873e-01f, 4.51237196e-03f,
  -6.32065013e-02f, -9.22263563e-02f, -6.06914572e-02f, 3.34842205e-02f, -2.25107800e-02f, 3.74797508e-02f, 9.04280841e-02f, -1.23321757e-01f, -5.95012456e-02f, 6.62468746e-03f,
  -1.90713137e-01f, -3.76033038e-02f, -4.93346564e-02f, -9.63340402e-02f, -2.36006957e-02f, 1.94300357e-02f, -9.10774618e-02f, 1.21459045e-01f, 1.59621313e-02f, -9.48256254e-03f,
  1.09594867e-01f, -5.45714097e-03f, -1.27831340e-01f, -5.69769181e-02f, 7.76061863e-02f, -2.85885688e-02f, 1.10990216e-03f, 9.09386054e-02f, 2.56706439e-02f, -1.80158719e-01f,
  7.73099065e-02f, -8.87776092e-02f, -4.85998988e-02f, 3.90954167e-02f, -3.46689187e-02f, -1.96617931e-01f, 2.89903558e-03f, -1.13551445e-01f, -1.22170687e-01f, -2.43551433e-02f,
  -1.73029184e-01f, -5.42084351e-02f, -7.51798376e-02f, 1.20807201e-01f, -1.10501340e-02f, -2.75431555e-02f, 1.70454700e-02f, 9.63522773e-03f, -4.00404669e-02f, -5.59858568e-02f,
  1.58544164e-02f, 8.29501078e-02f, 7.00402632e-02f, 8.64333361e-02f, -4.37685363e-02f, -1.55508846e-01f, 1.97935402e-02f, 9.48319659e-02f, -1.21066876e-01f, 1.32477656e-01f,
  -1.10163754e-02f, 4.26953658e-02f, -2.91856304e-02f, 9.68535766e-02f, -1.10255755e-01f, -1.15476727e-01f, 5.78819215e-02f, 1.07201058e-02f, 4.34855931e-02f, 1.88232377e-01f,
  -1.03532426e-01f, 8.29227343e-02f, -7.09116310e-02f, -9.37434062e-02f, 1.97396856e-02f, 2.19498482e-02f, -9.68019068e-02f, -1.13057360e-01f, 1.37177259e-01f, 1.29751295e-01f,
  6.49797078e-03f, 1.49159551e-01f, -3.51804532e-02f, -1.05852872e-01f, 9.78872851e-02f, -5.40989824e-03f, 8.11801627e-02f, 1.71988323e-01f, 6.94476143e-02f, 4.31404896e-02f,
  -1.18455663e-02f, -1.39196627e-02f, 7.01532289e-02f, 8.41961876e-02f, 3.79400216e-02f, -1.21595345e-01f, -9.73383412e-02f, 4.50260425e-03f, -5.18452153e-02f, -3.53479481e-05f,
  -1.51953042e-01f, 1.40744932e-02f, 1.81029156e-01f, -8.09260681e-02f, 8.13372284e-02f, 3.54046449e-02f, -1.05842724e-01f, 6.36474714e-02f, -3.04154214e-02f, -5.72823845e-02f,
  -4.57212105e-02f, -2.22493969e-02f, -1.23125240e-02f, 2.73505915e-02f, 2.89790239e-03f, 6.06350042e-03f, 4.44512405e-02f, 4.87230420e-02f, -5.02264425e-02f, 1.33725464e-01f,
  1.85416657e-02f, -3.69079486e-02f, 8.33147317e-02f, 6.79040700e-02f, -2.20008157e-02f, -8.41577444e-03f, 8.52976814e-02f, -4.15869914e-02f, 1.25157461e-01f, 8.77221078e-02f,
  6.85171410e-02f, 1.27843646e-02f, 6.06190749e-02f, -3.70970108e-02f, -3.69634330e-02f, 1.05814293e-01f, 1.26519740e-01f, -8.26424211e-02f, 9.73328725e-02f, -8.02347809e-03f,
  -5.89427073e-03f, 8.96725282e-02f, 1.79669366e-03f, -2.24426892e-02f, -1.22004224e-03f, -9.55385342e-02f, -3.06577850e-02f, -3.35336216e-02f, 2.39390656e-02f, -7.66856670e-02f,
  1.54803917e-01f, 2.79741883e-02f, -4.70647663e-02f, 2.04602584e-01f, -1.54213542e-02f, -9.48100388e-02f, -8.59754533e-02f, 2.08398238e-01f, -1.73407167e-01f, 2.50741154e-01f,
  7.46376514e-02f, -8.80225822e-02f, -5.26448153e-03f, 1.03339143e-01f, -2.42995620e-02f, 6.49585351e-02f, 1.43143758e-01f, -6.70807064e-02f, 9.72845107e-02f, 8.04552436e-02f,
  -5.86077608e-02f, -1.70805469e-01f, 5.75033436e-03f, -4.31450829e-02f, 7.04859048e-02f, -9.40726232e-03f, -5.98986112e-02f, -5.88425733e-02f, -6.65784702e-02f, 5.38663231e-02f,
  1.10953994e-01f, 5.39289648e-03f, -2.38394104e-02f, 1.68698415e-01f, -3.67217548e-02f, 8.15565214e-02f, 1.56471074e-01f, -1.24134406e-01f, 3.35224494e-02f, -1.70964524e-01f,
  6.97334707e-02f, 1.03346840e-01f, 4.04332094e-02f, 3.65004539e-02f, -5.41636981e-02f, 2.25979947e-02f, -2.70711374e-03f, -4.66200076e-02f, 1.52122542e-01f, 6.64708167e-02f,
  9.42184180e-02f, 1.08336911e-01f, -3.14407013e-02f, -6.06026500e-02f, 1.23944476e-01f, 1.06403887e-01f, -1.96053043e-01f, -1.08180102e-02f, -1.90428402e-02f, -1.66888997e-01f,
  4.39613499e-03f, -1.38444370e-02f, -1.99810892e-01f, -3.22142988e-02f, -1.09845802e-01f, -1.78539947e-01f, 4.75591421e-02f, -2.83192173e-02f, -5.93536012e-02f, 1.54937878e-01f,
  -8.12350959e-02f, -1.44752592e-01f, -4.80353758e-02f, 6.05041310e-02f, 8.66997913e-02f, 1.04723439e-01f, 2.64386162e-02f, 1.71161555e-02f, 9.64489728e-02f, -4.62117419e-03f,
  1.59386903e-01f, -3.96664068e-02f, 8.47936943e-02f, 1.11682147e-01f, -1.19246822e-03f, -5.39159440e-02f, 2.17813663e-02f, -5.66560309e-04f, -6.41484857e-02f, -9.39175952e-03f,
  -9.03236270e-02f, 1.32763712e-02f, -2.06835959e-02f, -8.44226629e-02f, -4.45848592e-02f, 4.36351784e-02f, 6.99743181e-02f, 1.05453040e-02f, -2.51033213e-02f, 1.14230183e-03f,
  5.52383997e-03f, 1.26448110e-01f, -1.93705365e-01f, -1.85831869e-03f, 7.96582848e-02f, 7.70051847e-04f, -5.29523641e-02f, 9.47397053e-02f, -1.53678926e-02f, -1.15616131e-03f,
  6.50008842e-02f, -1.41324475e-02f, -2.36855876e-02f, 8.83495528e-03f, 1.04781181e-01f, -7.13683367e-02f, 1.14445582e-01f, -3.44866961e-02f, 1.11190714e-02f, 3.13622667e-03f,
  -6.09672368e-02f, 2.57877284e-03f, 9.43213552e-02f, -3.09585873e-02f, -1.26572996e-02f, 3.38649675e-02f, 1.96598787e-02f, -3.68168694e-03f, -4.19292878e-03f, -2.50570793e-02f,
  -1.18125968e-01f, -9.93307214e-03f, -3.88616361e-02f, -3.21144387e-02f, -1.34268448e-01f, 1.72414511e-01f, -1.89956464e-02f, 1.46094874e-01f, 4.52557765e-02f, 1.59808993e-01f,
  -1.63819715e-02f, 1.36669204e-01f, -1.22962244e-01f, 6.03367575e-02f, 1.25557065e-01f, -5.65505885e-02f, -5.69963381e-02f, 1.37024477e-01f, -1.69756219e-01f, -2.82065839e-01f,
  -1.98757034e-02f, 3.71110030e-02f, 1.59318745e-01f, -9.75204259e-02f, -1.14082292e-01f, -3.89829725e-02f, -1.57320112e-01f, -9.92750898e-02f, 1.09223798e-01f, 2.20829640e-02f,
  2.03565285e-02f, 1.20372564e-01f, 3.53444070e-02f, -2.68788971e-02f, 1.47532657e-01f, -6.38139844e-02f, 3.77397090e-02f, -1.52147755e-01f, 1.76135123e-01f, 9.32503026e-03f,
  3.54862474e-02f, -6.79733083e-02f, 1.68094318e-02f, -1.59618199e-01f, -1.44117564e-01f, 1.03087120e-01f, 1.12858072e-01f, 2.01669186e-01f, 9.61824283e-02f, 4.23285291e-02f,
  -2.69920789e-02f, 4.27465932e-03f, 4.12406363e-02f, 7.65925199e-02f, -2.96958625e-01f, 8.60402510e-02f, 3.95158716e-02f, -3.73652130e-02f, 7.59163648e-02f, -5.76538518e-02f,
  -1.06469698e-01f, 6.20888807e-02f, -2.05533847e-01f, -1.11044489e-01f, 5.69964834e-02f, 8.53448361e-02f, 9.11878496e-02f, 1.37847781e-01f, -7.12192580e-02f, -2.36869112e-01f,
  -2.03652810e-02f, -5.94946481e-02f, 1.27170384e-01f, 5.51902205e-02f, -1.80824861e-01f, -1.58248979e-04f, 1.11784726e-01f, -7.83448592e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  1.04010090e-01f, 6.86717704e-02f, 2.87505370e-02f, -1.67386029e-02f, -7.37603754e-02f, -3.94306593e-02f, 4.05541509e-02f, 8.55859891e-02f, 8.84537771e-03f, 3.43066566e-02f,
  -1.48888022e-01f, 9.44044963e-02f, -1.40912309e-02f, 9.60200932e-03f, -9.47813690e-02f, 4.13012598e-03f, 7.70875737e-02f, 8.41301307e-02f, 3.72401699e-02f, -5.61612984e-03f,
  2.68293284e-02f, 1.02595516e-01f, -9.44454968e-02f, 8.04148316e-02f, 5.87377399e-02f, 4.72564902e-03f, -1.07470797e-02f, 5.36083654e-02f, -3.38659734e-02f, 3.28512751e-02f,
  -2.44168267e-02f, 4.47920971e-02f, -6.25107214e-02f, 1.60627455e-01f, 2.03566283e-01f, -3.44383414e-03f, 2.24783018e-01f, 4.37227041e-02f, -1.99160259e-02f, -1.20508550e-02f,
  2.07835645e-03f, 4.84401844e-02f, 9.72577482e-02f, -1.00654066e-01f, 4.63602953e-02f, 6.06998503e-02f, -9.46516395e-02f, 6.88807741e-02f, 8.15170482e-02f, 4.70847413e-02f,
  -1.13365293e-01f, -2.30469443e-02f, -8.46678838e-02f, -6.04420193e-02f, -1.78499311e-01f, 1.51702091e-01f, 7.20734075e-02f, 1.57891721e-01f, 3.63331474e-02f, 1.13402560e-01f,
  -1.11786006e-02f, 1.83534190e-01f, -5.65700345e-02f, 1.20373942e-01f, 3.26254778e-02f, -6.63431883e-02f, 1.06945813e-01f, 1.96569785e-01f, -1.90066710e-01f, -1.63931936e-01f,
  7.56824538e-02f, 1.43034577e-01f, 9.96447653e-02f, -1.46173209e-01f, -8.52598846e-02f, 8.07109103e-02f, -1.10516936e-01f, -9.80864614e-02f, 4.42505404e-02f, 7.20703742e-03f,
  -2.41319574e-02f, 4.78293039e-02f, 7.83215463e-02f, -1.04886644e-01f, 1.68088421e-01f, 8.73442460e-03f, -6.39112219e-02f, 7.60582695e-03f, 1.72198206e-01f, -8.28511864e-02f,
  6.01151139e-02f, -1.73596095e-03f, 2.22298950e-02f, -1.33207723e-01f, -1.76765934e-01f, 7.07003288e-03f, 4.56687175e-02f, 1.74615204e-01f, 1.15505464e-01f, 7.01146051e-02f,
  3.79764400e-02f, 9.05766115e-02f, 1.54246733e-01f, 2.72952974e-01f, -1.87590018e-01f, 5.23171797e-02f, 9.09859464e-02f, 1.37879197e-02f, 2.16990694e-01f, 4.08403855e-03f,
  7.95225948e-02f, 1.75775349e-01f, -2.06268087e-01f, 8.29327758e-03f, -2.14307401e-02f, 5.83126303e-03f, 1.21677577e-01f, 9.81959999e-02f, 2.04692073e-02f, 6.05127541e-03f,
  -1.77056082e-02f, 1.82620987e-01f, 1.50846764e-01f, 4.25905921e-02f, -1.31850705e-01f, 4.82413843e-02f, 1.65698677e-01f, -9.62827504e-02f, 7.34838098e-02f, -7.57740140e-02f,
  2.62722597e-02f, 8.46670270e-02f, 6.62674159e-02f, 4.40538749e-02f, -4.00660411e-02f, 6.58171475e-02f, 1.38674036e-03f, 8.18158761e-02f, 1.00748532e-01f, -7.05815628e-02f,
  -4.14386537e-04f, 6.62125871e-02f, 1.65448770e-01f, 6.00175671e-02f, -3.06002181e-02f, -8.27162489e-02f, -5.44066541e-03f, 1.36875898e-01f, 2.40815692e-02f, 1.49120986e-01f,
  7.16398750e-03f, -8.38091448e-02f, 1.36039943e-01f, 2.72254329e-02f, -8.26441720e-02f, 6.73848018e-02f, 7.38157555e-02f, 1.18441200e-02f, 4.31688875e-02f, -2.17145402e-02f,
  5.69682792e-02f, 2.85416301e-02f, -1.38888448e-01f, 4.47886288e-02f, -1.56424232e-02f, -4.42623720e-02f, 9.30359140e-02f, -1.24261621e-02f, 2.42956020e-02f, 1.16566136e-01f,
  -4.25496139e-02f, -6.01136982e-02f, 7.18936026e-02f, -7.68943084e-03f, 7.87138715e-02f, -2.67752465e-02f, 7.81421363e-02f, 7.02419505e-02f, 2.26150472e-02f, -3.12339757e-02f,
  2.59026960e-02f, -6.37738705e-02f, 7.02151805e-02f, -2.26441715e-02f, -1.47286043e-01f, -6.17955588e-02f, -2.28135437e-01f, -3.54826413e-02f, 1.87862173e-01f, 3.42066176e-02f,
  -2.05823928e-02f, 6.15702383e-02f, 1.54656619e-01f, 4.16529924e-02f, 1.18129060e-01f, -2.10609123e-01f, 1.82392821e-01f, 1.28440216e-01f, 9.72691365e-03f, -1.31060898e-01f,
  -1.67767871e-02f, 2.26418778e-01f, -6.37805760e-02f, 1.06588295e-02f, 1.30207390e-01f, -4.18573469e-02f, -6.53606951e-02f, 2.50438228e-02f, -1.77217554e-02f, 7.42500126e-02f,
  -1.02221876e-01f, 1.55064845e-02f, 2.78984811e-02f, -2.31334493e-01f, 1.41063869e-01f, -8.28869715e-02f, -9.31264237e-02f, 5.91325946e-02f, 5.72877750e-02f, 1.94529742e-01f,
  -8.07019994e-02f, 8.66322145e-02f, 1.17031172e-01f, -2.92645991e-01f, -6.60971226e-03f, -1.83354482e-01f, 3.32446136e-02f, -4.01821323e-02f, -3.49427462e-02f, -9.38017219e-02f,
  -9.77547988e-02f, -1.16465375e-01f, 2.09051266e-01f, -1.37345448e-01f, 9.91080403e-02f, -9.91432089e-03f, -2.24490296e-02f, 2.53745764e-01f, -1.48625568e-01f, -2.30526384e-02f,
  6.90321699e-02f, 8.12812820e-02f, 1.98556632e-02f, 2.90944353e-02f, 2.06126925e-02f, 8.77405927e-02f, 1.56588092e-01f, -7.05283731e-02f, 1.89593390e-01f, -1.96582749e-01f,
  -4.28343900e-02f, -1.00320965e-01f, 1.59625515e-01f, 9.21596885e-02f, 1.42465264e-01f, 1.94495454e-01f, -1.08000919e-01f, 1.24500349e-01f, 4.70351754e-03f, -9.62958932e-02f,
  5.09704687e-02f, 8.16661268e-02f, -3.01973764e-02f, -6.41983375e-02f, 9.17592868e-02f, 8.92819390e-02f, 3.79077494e-02f, -7.61687681e-02f, 9.42259058e-02f, 5.35454936e-02f,
  8.97999033e-02f, 1.23271190e-01f, 3.57264653e-02f, -3.59082855e-02f, 6.72414433e-03f, 5.40071614e-02f, 8.19298998e-02f, -2.00184256e-01f, 2.36649826e-01f, -4.47905138e-02f,
  5.49146719e-02f, 3.60663980e-02f, 1.67208418e-01f, 7.18806982e-02f, 1.63258895e-01f, 4.87051234e-02f, 9.66175050e-02f, 1.36923296e-02f, 4.11540531e-02f, 2.33717598e-02f,
  -2.67791506e-02f, 2.99425274e-02f, -1.47067890e-01f, 4.07791212e-02f, 9.33319852e-02f, 1.37012094e-01f, 1.47881374e-01f, 6.18008971e-02f, 2.59664189e-02f, 1.21044002e-01f,
  3.79080139e-02f, -1.58759225e-02f, 4.02015597e-02f, 3.45571227e-02f, -4.11211513e-02f, 8.38247910e-02f, -5.54979630e-02f, -3.61113362e-02f, 1.00146152e-01f, 1.79222748e-01f,
  1.24961846e-01f, -1.18447289e-01f, -2.04857916e-01f, -5.06537519e-02f, 1.26842424e-01f, -1.43917561e-01f, -2.44181097e-01f, -1.95673570e-01f, 1.41242474e-01f, 2.51270849e-02f,
  -1.90877002e-02f, 6.08131625e-02f, 9.94214714e-02f, -9.65429246e-02f, 1.83927506e-01f, 1.87921315e-01f, -1.94654949e-02f, -1.38674363e-01f, -2.20901132e-01f, 1.11370794e-01f,
  1.93266481e-01f, -5.45941889e-02f, -9.57674254e-03f, 7.51720220e-02f, 1.65413871e-01f, 9.16847512e-02f, 1.36916712e-01f, -6.92977682e-02f, -1.26056716e-01f, 6.05537668e-02f,
  -1.13499194e-01f, 1.13528475e-01f, 7.04411045e-02f, 2.06603840e-01f, -2.14312691e-03f, 1.28535360e-01f, 9.31951031e-02f, -4.08713035e-02f, -1.06922857e-01f, 9.56763625e-02f,
  1.62806928e-01f, -8.52109492e-02f, -6.42826706e-02f, -1.75144114e-02f, -2.65170604e-01f, 1.87711120e-01f, -1.00731939e-01f, -8.35229270e-03f, 1.52646288e-01f, 6.07137606e-02f,
  2.86743701e-01f, 1.26305312e-01f, -2.61884518e-02f, -6.55711815e-03f, -7.24316910e-02f, -3.82052772e-02f, 1.19069271e-01f, -1.75558150e-01f, 3.64792198e-02f, -5.46307601e-02f,
  1.07860737e-01f, -1.18027171e-02f, -5.92542738e-02f, -4.02881205e-02f, -9.30164158e-02f, 3.20526779e-01f, 3.85089926e-02f, 1.23629861e-01f, -1.09606057e-01f, 8.30099825e-03f,
  3.56388271e-01f, 2.37923130e-01f, -1.70093894e-01f, -1.70383364e-01f, 2.27971837e-01f, 1.26740392e-02f, 1.31451949e-01f, 8.03126693e-02f, 6.67922422e-02f, -2.62422413e-02f,
  5.47307730e-02f, 1.70581073e-01f, -8.23179036e-02f, 5.97646721e-02f, -5.08136153e-02f, -4.54970077e-02f, -2.63033491e-02f, 5.18289134e-02f, -3.00171655e-02f, 5.89795373e-02f,
  1.16099291e-01f, 3.98576483e-02f, 1.01765878e-01f, 5.40254526e-02f, 4.56274003e-02f, 1.22535892e-01f, -1.90260321e-01f, 3.10631450e-02f, 1.15471609e-01f, 5.22692576e-02f,
  -2.40303241e-02f, 2.16487106e-02f, -7.43598565e-02f, 7.22795650e-02f, 5.99199869e-02f, -1.16994297e-02f, 1.51950167e-02f, -4.73193675e-02f, -9.13146883e-03f, 5.69203161e-02f,
  9.95762944e-02f, 4.64076959e-02f, 1.03414789e-01f, 4.08946685e-02f, -2.36368310e-02f, -4.13301736e-02f, 5.47592156e-02f, 2.83667855e-02f, 6.53743371e-02f, -1.00441482e-02f,
  6.02788515e-02f, 2.03248672e-02f, 3.23170573e-02f, 8.47571623e-03f, -1.03785051e-03f, -8.05983543e-02f, -5.68018071e-02f, -6.97860792e-02f, -1.38870001e-01f, 1.48563832e-01f,
  5.52830026e-02f, 2.22937331e-01f, -1.79604515e-01f, 3.27488221e-02f, 1.29488796e-01f, 9.25935656e-02f, -8.00323039e-02f, 1.70267909e-03f, 1.73717633e-01f, -7.77973309e-02f,
  -1.78383991e-01f, 3.56731825e-02f, -7.76066482e-02f, -2.25279003e-01f, -1.03786528e-01f, -1.01524210e-02f, 2.30262786e-01f, 4.52819504e-02f, -1.97409064e-01f, 3.62679809e-02f,
  1.63596720e-02f, -1.71380043e-02f, -5.71165755e-02f, -1.36734759e-02f, 4.96266820e-02f, 7.29307532e-02f, -1.45330161e-01f, -9.35780928e-02f, 1.63481414e-01f, -1.32410929e-01f,
  1.39004499e-01f, -1.54257655e-01f, 6.62455112e-02f, 1.41209558e-01f, -2.95466103e-04f, -8.57917815e-02f, -1.96355730e-02f, -1.87068563e-02f, 7.68382549e-02f, -2.15208158e-02f,
  6.60268366e-02f, 2.09237620e-01f, 2.01277688e-01f, -1.44026568e-02f, -1.21843219e-02f, -3.17510292e-02f, -1.42733291e-01f, -7.67435953e-02f, -3.00488204e-01f, 1.48792580e-01f,
  1.13405652e-01f, -7.66923055e-02f, -1.66928060e-02f, 1.18498921e-01f, 5.15704826e-02f, 4.10761870e-02f, -7.65026435e-02f, -8.25427324e-02f, 2.03608185e-01f, -1.02803364e-01f,
  9.01630297e-02f, 8.32394436e-02f, -1.45516381e-01f, -8.30901191e-02f, 2.33738348e-02f, -2.11758256e-01f, 2.02889159e-01f, 8.73773545e-02f, -1.84988603e-01f, 8.41038972e-02f,
  4.57450040e-02f, 1.41036272e-01f, -5.35592772e-02f, 6.91050366e-02f, 1.07482299e-02f, 3.71384658e-02f, 1.19046949e-01f, 1.64626651e-02f, 6.38212636e-02f, 1.92507952e-02f,
  7.85723850e-02f, 8.55595022e-02f, 8.53567012e-03f, 3.48275155e-02f, 7.38678798e-02f, 6.40893355e-02f, 5.56895994e-02f, 1.53145408e-02f, 1.22194596e-01f, -3.32541987e-02f,
  1.28740901e-02f, 2.11791489e-02f, 9.30578187e-02f, -3.74911837e-02f, 9.88835916e-02f, 4.36021574e-02f, -2.07692874e-03f, 1.38637260e-01f, 5.27690984e-02f, 4.33904827e-02f,
  6.73186779e-02f, -1.15901614e-02f, 8.37819949e-02f, 9.90400910e-02f, 5.85115515e-02f, 3.81547473e-02f, 3.26947086e-02f, 7.80261233e-02f, -4.23478894e-02f, 1.09087839e-03f,
  2.77805272e-02f, -7.23604299e-03f, -1.76387541e-02f, 5.34934290e-02f, 1.39728978e-01f, 1.61719695e-01f, 6.91753924e-02f, 9.12842527e-02f, 1.12415127e-01f, 1.71254754e-01f,
  -3.53281200e-02f, 4.50858623e-02f, 5.35601415e-02f, -7.09894672e-02f, 1.06691204e-01f, 1.20241605e-01f, 1.58806249e-01f, -2.15966627e-01f, 1.29422218e-01f, -1.81858569e-01f,
  1.00338861e-01f, 6.61108121e-02f, -8.17942396e-02f, -1.51976526e-01f, 1.26257151e-01f, -1.39197990e-01f, -2.17272177e-01f, 1.66894794e-01f, -1.76115155e-01f, -3.05506829e-02f,
  6.78651705e-02f, 1.81039199e-01f, -1.44501880e-01f, 5.55637740e-02f, -6.39201701e-02f, -1.01231895e-01f, -3.37404944e-02f, -2.01538160e-01f, 5.87167293e-02f, -1.01422116e-01f,
  1.13026947e-01f, 5.62215038e-02f, -9.24698114e-02f, -1.49557263e-01f, -1.63283013e-02f, 1.06414899e-01f, -1.58644006e-01f, 1.47798464e-01f, 1.55702038e-02f, 1.34597540e-01f,
  -9.55274105e-02f, -4.64101508e-02f, -5.73218428e-02f, -1.09162554e-01f, -5.45660667e-02f, -2.20803805e-02f, -1.01138912e-01f, 1.16786852e-01f, -1.69615507e-01f, -7.79988095e-02f,
  -1.46671534e-01f, -3.82541232e-02f, -1.27077685e-03f, -7.41069913e-02f, -5.06681092e-02f, -5.23569211e-02f, 3.13450575e-01f, 2.23978639e-01f, 1.19788488e-02f, 1.61634699e-01f,
  5.14615960e-02f, -8.93218741e-02f, 1.27070755e-01f, -4.14122688e-03f, 2.03607213e-02f, 1.83897018e-01f, 2.24392712e-02f, 1.08628869e-01f, 1.19905348e-03f, -3.22979502e-02f,
  2.59878516e-01f, 4.48652543e-02f, 9.62532610e-02f, -2.89959647e-03f, -2.31866483e-02f, 1.73097655e-01f, 1.34042248e-01f, -1.30932294e-02f, -2.05958765e-02f, -3.41525599e-02f,
  2.30062455e-01f, 2.22114623e-02f, 6.15018569e-02f, 1.60275355e-01f, 2.40607057e-02f, -4.49904427e-02f, 1.08014084e-01f, 1.11231916e-01f, 1.22975428e-02f, 8.92612711e-02f,
  -1.01417109e-01f, 4.35157865e-02f, -3.11067291e-02f, 6.37077689e-02f, -6.39626905e-02f, 1.77187249e-02f, 1.09046899e-01f, 8.59437138e-02f, 5.39286807e-02f, 9.93876532e-02f,
  5.22858426e-02f, 1.95314929e-01f, 1.93891935e-02f, 1.10662803e-01f, 1.97299756e-02f, 2.64965259e-02f, -3.86490114e-02f, -5.41361384e-02f, -2.71896478e-02f, 7.23125339e-02f,
  3.10550127e-02f, 2.08614264e-02f, 1.26805054e-02f, 6.10164925e-02f, 1.54555216e-01f, 8.36499110e-02f, 1.96039498e-01f, 3.19368429e-02f, 3.62487026e-02f, 3.92162949e-02f,
  -6.91623837e-02f, 3.23821865e-02f, 1.47493318e-01f, 7.37631600e-03f, 1.17337301e-01f, 1.06742010e-01f, 5.22126211e-03f, 1.40628174e-01f, 8.49038828e-03f, 1.70686319e-02f,
  9.76562575e-02f, 2.20113136e-02f, 3.49038877e-02f, -2.00780556e-01f, -2.04806402e-01f, 1.30158514e-01f, 1.90009475e-01f, 1.09035566e-01f, -1.37262240e-01f, 1.01688921e-01f,
  8.51022080e-02f, 1.84716672e-01f, -8.49434808e-02f, 7.44233467e-03f, 1.06766643e-02f, -4.74202409e-02f, -7.34739974e-02f, 1.42710760e-01f, -2.22338572e-01f, -1.85627177e-01f,
  3.53413373e-02f, 1.01856716e-01f, 2.25681305e-01f, -9.71661434e-02f, -2.16661006e-01f, -5.26015125e-02f, -5.83152249e-02f, -9.01324302e-02f, -6.70335963e-02f, 1.36773009e-02f,
  -1.20195597e-02f, -1.00900203e-01f, 8.44593719e-02f, 2.18046196e-02f, -7.39973458e-03f, -1.07371897e-01f, 3.78079675e-02f, -1.00274764e-01f, -3.79235335e-02f, 4.59216870e-02f,
  3.00485175e-02f, 1.39436275e-01f, 4.75504473e-02f, -7.52909156e-03f, -8.38215873e-02f, -3.07944193e-02f, -4.20934930e-02f, 1.15594886e-01f, 1.77351713e-01f, -1.31435350e-01f,
  -2.90027745e-02f, -5.11942506e-02f, -8.30463171e-02f, 1.26448825e-01f, -2.22025767e-01f, 8.15997869e-02f, 8.08169693e-03f, -3.15987356e-02f, -5.19199530e-03f, -4.04621735e-02f,
  1.08211227e-01f, 4.37370054e-02f, -4.53764275e-02f, -4.77736108e-02f, -3.66275720e-02f, -1.14574842e-01f, 1.12286426e-01f, 3.86204161e-02f, 9.53772366e-02f, -1.68427169e-01f,
  8.78414735e-02f, 2.58883182e-03f, 1.07787579e-01f, 1.33264497e-01f, -2.15399846e-01f, -5.46462275e-02f, 2.99522758e-01f, 8.89738724e-02f, 1.49436528e-02f, -2.85547785e-02f,
  -1.21054286e-03f, -5.47588393e-02f, -5.40337376e-02f, 4.38954681e-03f, -8.90161321e-02f, 1.05283640e-01f, 9.38223079e-02f, 2.59109270e-02f, 1.08408099e-02f, -9.41152778e-03f,
  -1.27435112e-02f, 3.91110033e-02f, 6.02886975e-02f, -6.19700886e-02f, -6.80225641e-02f, -7.25555941e-02f, 2.67568398e-02f, 6.04267046e-02f, 2.60636471e-02f, -2.61484794e-02f,
  -6.98656812e-02f, -8.69848058e-02f, 2.95079555e-02f, -1.33730350e-02f, -3.98368761e-02f, 2.70214155e-02f, 6.43956214e-02f, -1.15328953e-01f, 5.63771988e-04f, 2.70708632e-02f,
  -1.49336094e-02f, 7.19391480e-02f, -6.36086166e-02f, -2.95949299e-02f, 5.93221039e-02f, 4.73541431e-02f, 8.85404423e-02f, 8.46409984e-03f, 1.19275682e-01f, 5.68433516e-02f,
  -3.21894772e-02f, -1.26220122e-01f, 3.29996347e-02f, -2.73022074e-02f, -9.84072015e-02f, -1.29238605e-01f, 1.50512934e-01f, 3.35631929e-02f, 1.33097766e-03f, 9.12577659e-02f,
  -1.32991150e-01f, -2.19359640e-02f, -3.28615606e-02f, 7.39237890e-02f, -2.57425487e-01f, 1.46889046e-01f, -1.38582692e-01f, -1.08287781e-01f, 2.17987850e-01f, 1.81736067e-01f,
  1.55223429e-01f, 1.73484031e-02f, 1.15616880e-01f, -5.79182431e-02f, 1.45214245e-01f, -9.89238545e-02f, 1.82302147e-01f, -3.49879526e-02f, 8.90764594e-03f, 2.05081776e-02f,
  1.24566846e-01f, 1.04771361e-01f, 3.72927301e-02f, 2.52336502e-01f, 1.07168686e-02f, 5.93121126e-02f, 1.01947315e-01f, 6.83813319e-02f, 1.65971264e-01f, 1.51987314e-01f,
  -1.76736206e-01f, -8.05483013e-02f, 1.87425911e-01f, -8.65434259e-02f, 6.95521384e-02f, -2.91083232e-02f, 4.11982909e-02f, 4.03395258e-02f, 3.79365757e-02f, 1.53120495e-02f,
  -7.14239627e-02f, 5.95664345e-02f, 2.65511155e-01f, -1.59266606e-01f, 4.21205796e-02f, -2.76218466e-02f, 1.21601000e-01f, 1.55746311e-01f, 4.09640782e-02f, -1.24244943e-01f,
  -4.79699671e-02f, 8.35122615e-02f, 4.28320467e-02f, -4.43981811e-02f, 7.03450069e-02f, 1.71222072e-02f, -1.29527627e-02f, 3.47715586e-01f, -1.80249289e-02f, -5.28222807e-02f,
  5.91235720e-02f, 6.82528690e-02f, -2.75211241e-02f, -6.56593964e-02f, -8.69956091e-02f, 7.47738779e-03f, -5.38847297e-02f, 7.52578974e-02f, 5.87060973e-02f, 1.95630148e-01f,
  -4.28063609e-02f, -9.29173976e-02f, -1.33050904e-01f, 8.65186527e-02f, -8.63535404e-02f, 1.94327295e-01f, 1.03728563e-01f, 4.26489860e-02f, -3.75050673e-04f, 1.18076749e-01f,
  9.75814834e-02f, 7.33866394e-02f, 9.24281627e-02f, -4.13608812e-02f, 1.47492021e-01f, 1.85265858e-02f, 7.73215294e-02f, 8.77243504e-02f, 7.01892748e-02f, 3.51454653e-02f,
  8.99142921e-02f, 6.21881410e-02f, 5.39705418e-02f, 7.02660307e-02f, 7.95327798e-02f, 6.80886284e-02f, 9.56598893e-02f, 5.09593114e-02f, 1.77495942e-01f, 1.30659848e-01f,
  1.33407954e-02f, 1.69684976e-01f, 6.35956004e-02f, -6.74649924e-02f, 2.04960909e-02f, 1.07229948e-01f, 9.68650505e-02f, 1.34926125e-01f, 1.44644067e-01f, 8.20098594e-02f,
  1.03817075e-01f, 1.37471288e-01f, -3.57085466e-03f, 7.76514634e-02f, -4.49468270e-02f, 2.12478894e-03f, 8.36894810e-02f, 1.25573516e-01f, 1.04124650e-01f, 1.68805376e-01f,
  6.37156740e-02f, 1.33378163e-01f, 1.45513698e-01f, 1.26926363e-01f, -2.46519479e-03f, 2.78485361e-02f, 2.07427323e-01f, 1.61974758e-01f, -1.85109600e-02f, 4.42797355e-02f,
  1.08357795e-01f, -1.69920489e-01f, 1.53411970e-01f, -1.54465705e-01f, 1.48757175e-01f, 7.94990808e-02f, -3.47999074e-02f, -1.95594534e-01f, 1.21463845e-02f, -2.39696324e-01f,
  -1.69536427e-01f, 7.22571239e-02f, -2.28390649e-01f, -3.64132077e-02f, 1.14094978e-03f, 3.29011902e-02f, -6.83246106e-02f, 7.23498836e-02f, -1.39418572e-01f, 5.41931242e-02f,
  -4.32580821e-02f, -1.78046450e-01f, 2.42727604e-02f, -3.12419813e-02f, -4.28888649e-02f, -2.03435972e-01f, -1.41294852e-01f, -2.72829551e-02f, 2.69033723e-02f, 8.99436921e-02f,
  -2.05750316e-01f, 1.09840237e-01f, -1.02425665e-01f, -1.90293819e-01f, -1.89076051e-01f, 5.44711575e-02f, -1.34514034e-01f, -5.43448795e-03f, -7.91698694e-03f, 2.47719605e-02f,
  -5.22416234e-02f, 1.42060533e-01f, -5.45928814e-02f, -8.47476944e-02f, -1.10836988e-02f, -1.84238970e-01f, 2.17726585e-02f, -9.76698007e-03f, -2.35689362e-03f, -7.03814775e-02f,
  2.14333802e-01f, 1.41482651e-01f, -4.39244024e-02f, 1.09686464e-01f, 2.07912456e-03f, -3.59833837e-02f, -1.58729479e-02f, 9.37900692e-02f, 3.34981263e-01f, 1.80601239e-01f,
  -6.55396953e-02f, 1.66688383e-01f, 6.99393824e-02f, 2.42596455e-02f, 2.16878265e-01f, -1.76499322e-01f, -6.19935046e-04f, -2.35924516e-02f, -5.05511910e-02f, 1.31641835e-01f,
  2.39539221e-01f, -2.47906014e-01f, -5.54627478e-02f, 1.31176740e-01f, 2.22812310e-01f, 1.38177469e-01f, 1.41218618e-01f, 1.60984639e-02f, 5.47192730e-02f, -1.54014351e-02f,
  9.77436900e-02f, 1.55168906e-01f, 7.04947561e-02f, 8.25991035e-02f, -4.83398214e-02f, 1.11200511e-01f, 4.81611416e-02f, 5.95546514e-02f, -4.69394997e-02f, 6.97649717e-02f,
  5.69200702e-02f, 1.28620118e-01f, 5.00649139e-02f, -5.51139899e-02f, -3.37816076e-03f, 5.77121712e-02f, -3.81098911e-02f, 2.34952882e-01f, 5.89166656e-02f, 3.20396479e-03f,
  1.96490511e-02f, -1.02177998e-02f, -1.18520655e-01f, 1.54382780e-01f, 9.85730737e-02f, 7.72822946e-02f, 3.51274610e-02f, 6.54383823e-02f, 1.90579429e-01f, 1.23855457e-01f,
  2.09761024e-01f, 1.55743927e-01f, 5.05907163e-02f, 1.51609704e-01f, 6.36728108e-02f, -1.76546387e-02f, 1.56110972e-01f, 8.61164853e-02f, 9.72566232e-02f, 1.22025102e-01f,
  1.77045520e-02f, 1.18255027e-01f, 7.97878206e-02f, -1.85052678e-02f, 6.55944273e-02f, 1.32286851e-03f, -1.53247118e-01f, -9.83259827e-02f, -1.73612878e-01f, 1.55559704e-01f,
  1.70466185e-01f, 1.84224457e-01f, 7.02226683e-02f, 4.21760678e-02f, -5.15880175e-02f, 1.91300005e-01f, -7.99635351e-02f, -4.25139591e-02f, -5.51334918e-02f, -1.58999011e-01f,
  -1.62050501e-01f, 1.54537752e-01f, -2.01316625e-01f, -2.84031272e-01f, 6.01276793e-02f, 4.74224612e-02f, 1.26821592e-01f, -2.88397223e-02f, -1.13856770e-01f, 1.29608959e-01f,
  -1.29544094e-01f, -2.72872467e-02f, -7.75401369e-02f, -1.65661469e-01f, 7.55351335e-02f, -2.39180941e-02f, 7.87755251e-02f, -1.05561897e-01f, 3.11149396e-02f, 6.45402595e-02f,
  -3.59358490e-02f, -9.57238004e-02f, 8.03413689e-02f, -1.90764982e-02f, -4.87738661e-02f, -5.86978160e-02f, 8.76786932e-02f, -7.33021721e-02f, -2.92510781e-02f, 1.13533661e-01f,
  6.27499446e-02f, 1.83985204e-01f, 2.20056385e-01f, -4.78289239e-02f, 5.04107773e-02f, 4.56247516e-02f, 1.95753779e-02f, 1.81458995e-01f, -2.37744674e-01f, 8.35658386e-02f,
  -5.85531890e-02f, -1.22563668e-01f, 5.29156008e-04f, 7.59803597e-03f, 1.96487993e-01f, 8.06089491e-02f, 1.12927437e-01f, -1.20296247e-01f, 7.35942945e-02f, -1.11553952e-01f,
  1.56384930e-01f, 4.96257702e-03f, -2.11461991e-01f, 1.43795635e-03f, -8.21769983e-02f, 1.12289593e-01f, 1.38351589e-01f, 1.08137704e-01f, -1.24557242e-01f, 4.09340113e-02f,
  3.72415558e-02f, 1.29418612e-01f, 7.73205459e-02f, 1.61711559e-01f, 4.69014272e-02f, -9.07420218e-02f, -5.02585173e-02f, -2.26217676e-02f, 1.05794750e-01f, 3.46154608e-02f,
  1.74357109e-02f, 3.94926377e-04f, 7.82319233e-02f, 1.73943937e-01f, 1.25327185e-01f, 3.62320766e-02f, -2.67159822e-03f, 5.79552762e-02f, 2.27132700e-02f, 3.49731684e-01f,
  9.93324593e-02f, 2.27145273e-02f, 5.47280908e-02f, -1.08662032e-01f, -3.59515063e-02f, 2.32116446e-01f, 2.47573312e-02f, 1.14924565e-01f, 2.23920882e-01f, 6.85812235e-02f,
  -6.21773116e-02f, 7.40205348e-02f, -5.23848012e-02f, 1.39009163e-01f, 1.09884506e-02f, 1.53775841e-01f, 2.82787651e-01f, 1.01806983e-01f, 1.57067105e-01f, 1.66192606e-01f,
  -1.32073816e-02f, 3.05495057e-02f, 5.75175732e-02f, 1.13796040e-01f, -1.79910827e-02f, -8.42704531e-03f, 8.38763490e-02f, 9.21868384e-02f, -1.31207025e-02f, 4.48069647e-02f,
  8.15740526e-02f, -4.09310032e-03f, 1.51802972e-02f, 1.77987710e-01f, -2.03818470e-01f, -7.16028959e-02f, -9.54903364e-02f, 6.89783022e-02f, -1.13355778e-01f, 2.09964067e-01f,
  2.42618233e-01f, -1.63623258e-01f, -8.81367102e-02f, -5.44876829e-02f, -1.39065132e-01f, -1.07126711e-02f, -6.22529499e-02f, -1.03163548e-01f, 6.18066490e-02f, 2.10022911e-01f,
  -1.55991808e-01f, -1.18312754e-01f, -4.47203889e-02f, 9.33420882e-02f, 1.10173918e-01f, -1.32366776e-01f, 1.49611413e-01f, 2.18971997e-01f, -3.41955274e-02f, 2.05507964e-01f,
  -6.18607365e-02f, -9.80869122e-03f, -1.85005832e-02f, 7.66395032e-02f, 1.38699338e-01f, -6.54570982e-02f, 1.86551675e-01f, 1.35652661e-01f, -1.47855759e-01f, -1.50117539e-02f,
  1.92054912e-01f, -1.35647044e-01f, -1.04920805e-01f, -2.19762385e-01f, -1.77382901e-02f, -3.05971950e-02f, 3.60903814e-02f, 2.50264525e-01f, 6.24086000e-02f, 1.05089843e-01f,
  1.40916422e-01f, 1.22267827e-01f, 1.05840303e-01f, 6.04966357e-02f, 1.43614098e-01f, 1.24224685e-01f, -2.08376467e-01f, -1.02788899e-02f, -8.39182548e-03f, 3.38817500e-02f,
  1.83144450e-01f, -1.00955881e-01f, 1.02134943e-01f, 2.30009899e-01f, 3.53012271e-02f, 4.97578159e-02f, 7.98527449e-02f, 1.20968610e-01f, -6.79985732e-02f, 8.66139531e-02f,
  -1.04982488e-01f, 1.38074964e-01f, -2.40234271e-01f, 2.42104024e-01f, 1.23836331e-01f, 1.50598645e-01f, -5.32148480e-02f, -2.47164238e-02f, -6.98214620e-02f, 6.77112564e-02f,
  1.07484803e-01f, 9.35445279e-02f, 1.08622178e-01f, 2.89095305e-02f, 1.29650861e-01f, -5.70051223e-02f, 1.26443233e-03f, 1.32354617e-01f, -2.25975048e-02f, 7.36311823e-02f,
  -1.85537916e-02f, -4.21112105e-02f, -3.91440000e-03f, -1.98021792e-02f, -4.22166362e-02f, 4.81304117e-02f, 9.73023921e-02f, 6.02176525e-02f, 4.64900807e-02f, 9.75739677e-03f,
  3.99028137e-02f, -7.25116655e-02f, -1.16522843e-02f, 1.70510203e-01f, 3.00047509e-02f, 2.58214376e-03f, -8.45284909e-02f, -6.29018014e-03f, -1.41470239e-01f, 9.92998108e-02f,
  -3.97820473e-02f, 2.16045007e-02f, 3.42236944e-02f, -4.21858802e-02f, 5.97323775e-02f, 6.93717971e-02f, -1.18366024e-02f, 1.13006800e-01f, -4.75317091e-02f, 2.59965826e-02f,
  4.11440209e-02f, 1.84647385e-02f, 1.30174085e-01f, 9.72796306e-02f, 1.02910571e-01f, 5.77321723e-02f, -4.76148129e-02f, 9.44151953e-02f, 6.70364359e-03f, -1.54658863e-02f,
  6.32384568e-02f, -1.10132501e-01f, -6.47951663e-02f, -1.07258201e-01f, -2.39564240e-01f, -1.48907686e-02f, 1.79432273e-01f, 8.37375000e-02f, -2.55754650e-01f, 3.26871723e-02f,
  1.04953818e-01f, 1.23860084e-01f, -1.03985198e-01f, -4.31377441e-02f, -2.13862006e-02f, -1.82887837e-01f, -1.18955627e-01f, 5.59526645e-02f, -1.46547332e-01f, -1.13415651e-01f,
  1.45615906e-01f, -2.24537347e-02f, 1.76638082e-01f, 5.30848168e-02f, -1.10346273e-01f, 2.21778542e-01f, -8.80733728e-02f, -3.09892576e-02f, -2.25286186e-01f, -8.73041302e-02f,
  7.97360241e-02f, -2.10904852e-01f, 1.11190334e-01f, -1.37831911e-01f, 1.24606937e-02f, 9.74141713e-03f, -2.83513553e-02f, 1.14790455e-01f, -9.32168029e-03f, 5.06707840e-03f,
  -4.88143042e-02f, 2.34751087e-02f, 1.67219207e-01f, 2.48462036e-02f, 2.41530668e-02f, 6.72612414e-02f, -1.00653008e-01f, 1.65759921e-01f, 2.00456277e-01f, -1.52406394e-01f,
  1.40540183e-01f, 1.41989872e-01f, -1.72041982e-01f, 6.63262680e-02f, -1.50952429e-01f, -6.04033805e-02f, 1.43788792e-02f, -1.02768600e-01f, -1.11694038e-01f, 1.01801984e-01f,
  2.56074756e-01f, 4.78913821e-02f, 1.22849263e-01f, 2.33148877e-02f, 1.47956878e-01f, -1.52989835e-01f, 1.80226594e-01f, -1.10963620e-01f, -1.95268452e-01f, 1.96834490e-01f,
  9.52888653e-02f, -2.77940799e-02f, -9.98760313e-02f, -1.58526033e-01f, -2.39194080e-01f, 1.49426445e-01f, 1.49931489e-02f, 2.37672910e-01f, 4.37331051e-02f, -5.38928881e-02f,
  -1.51604600e-02f, 9.71520469e-02f, -4.21455987e-02f, 1.68274194e-02f, 1.45096648e-02f, 5.54093309e-02f, 7.34210014e-02f, 9.18864086e-02f, -7.35325925e-03f, -3.98666016e-04f,
  1.86942387e-02f, 6.01368397e-02f, 7.45865479e-02f, 7.44603127e-02f, 6.14115931e-02f, -3.52703109e-02f, 8.15853104e-02f, 1.31100431e-01f, 6.66411966e-02f, 1.10787421e-01f,
  1.07118294e-01f, -9.13707241e-02f, 5.20553328e-02f, -6.82417005e-02f, 5.80932051e-02f, 4.71478067e-02f, 1.46209866e-01f, -7.63682351e-02f, 1.55752763e-01f, -3.24332938e-02f,
  4.49085422e-02f, 5.03770970e-02f, 5.98626621e-02f, 4.73866351e-02f, 3.48200202e-02f, -1.05753034e-01f, 1.69020310e-01f, 1.09945774e-01f, -3.39458860e-03f, 2.41156723e-02f,
  1.49646372e-01f, 7.98023269e-02f, 2.46968661e-02f, 5.18827848e-02f, 3.88612077e-02f, 8.69068056e-02f, -8.05308670e-02f, 7.01582283e-02f, 1.14956144e-02f, -1.79376416e-02f,
  2.79180229e-01f, -3.86184379e-02f, 1.46180108e-01f, 6.21350780e-02f, -3.97236273e-02f, 3.33178267e-02f, -1.83602665e-02f, -5.53630367e-02f, -3.06758564e-02f, -1.62910856e-02f,
  1.05042033e-01f, -3.48807797e-02f, 2.72980686e-02f, 2.33263105e-01f, -1.89063419e-02f, -5.40345944e-02f, 8.08379054e-02f, 8.12235475e-03f, -1.49180651e-01f, 1.31090302e-02f,
  6.03268854e-02f, -1.01759508e-01f, -1.73528194e-01f, -3.53606045e-01f, -2.94516748e-03f, -1.56686753e-01f, 1.79257900e-01f, 1.89390451e-01f, 2.45025996e-02f, 2.48595104e-02f,
  -1.66479781e-01f, 2.25258574e-01f, -9.48537290e-02f, -8.98945332e-02f, 1.61698669e-01f, -6.59495667e-02f, -1.68702051e-01f, 1.68541729e-01f, 8.08965936e-02f, 6.89669326e-02f,
  -1.40729934e-01f, 9.32309963e-03f, 5.55778481e-03f, -1.85952708e-01f, -1.96581203e-02f, -8.21697246e-03f, -1.79491237e-01f, -1.52037817e-03f, -2.20133379e-01f, -3.23479474e-01f,
  -2.15608953e-03f, 2.60833986e-02f, 5.93838356e-02f, 2.96558827e-01f, 5.22701405e-02f, 2.09909901e-02f, -9.75109115e-02f, -8.04975554e-02f, -2.98124384e-02f, -1.54248893e-01f,
  -1.75072387e-01f, -1.21113591e-01f, -1.52273867e-02f, -7.69741312e-02f, -6.81842640e-02f, 8.38526189e-02f, 2.05933064e-01f, -1.06013693e-01f, 1.88806757e-01f, 7.00862035e-02f,
  1.34144649e-01f, 3.06253165e-01f, 1.61462069e-01f, -4.97534126e-02f, 1.38628960e-01f, 3.14815110e-03f, -2.08264306e-01f, 2.71822084e-02f, 7.69455871e-03f, -2.61815116e-02f,
  6.97075650e-02f, 1.49709851e-01f, 2.00432632e-02f, 4.92406785e-02f, 1.38945729e-01f, 2.54927464e-02f, 1.49725348e-01f, 6.86330646e-02f, 2.20060050e-02f, 6.16968498e-02f,
  1.27762929e-01f, -1.79888844e-03f, -4.47537564e-03f, -1.13454908e-01f, 4.49751057e-02f, -1.89111661e-02f, 7.81019703e-02f, -3.35413776e-02f, 9.40001458e-02f, -5.19013964e-02f,
  -1.02439180e-01f, 7.43388757e-02f, 5.32135405e-02f, 5.36726639e-02f, 5.79894818e-02f, 2.63963360e-04f, 4.36999723e-02f, 2.60817893e-02f, 8.47098231e-02f, 9.38900746e-03f,
  -1.98363319e-01f, 4.21152860e-02f, -1.03581667e-01f, 1.27483398e-01f, 7.29219243e-02f, -4.74719703e-02f, 1.50924727e-01f, 4.48708944e-02f, -1.89934447e-02f, 7.65633881e-02f,
  -2.96091307e-02f, -1.36671541e-02f, 9.65414643e-02f, -1.01609537e-02f, 1.22218348e-01f, 8.08897465e-02f, 2.01070935e-01f, -9.04922411e-02f, -8.21240842e-02f, 1.99265957e-01f,
  1.87513709e-01f, -1.77877799e-01f, -1.18403025e-01f, -1.31425589e-01f, -1.77367672e-01f, -6.12634979e-02f, 1.38238624e-01f, -1.24180028e-02f, 1.63956225e-01f, -3.45511697e-02f,
  -3.38877961e-02f, -1.92081705e-02f, 1.94573458e-02f, -3.18822950e-01f, 2.89827347e-01f, 2.37129882e-01f, -9.20698643e-02f, -1.31694421e-01f, -1.83370784e-01f, 1.93563700e-01f,
  1.12698756e-01f, 2.05560088e-01f, 1.66612893e-01f, 1.29706576e-01f, 7.03507066e-02f, 6.03597499e-02f, 2.20937505e-02f, 1.37389200e-02f, -3.12790215e-01f, -6.73456267e-02f,
  3.99924181e-02f, 1.22795321e-01f, 9.02749375e-02f, 7.60948882e-02f, -9.27159488e-02f, 6.67270347e-02f, -4.27240767e-02f, -7.42357671e-02f, -5.44692688e-02f, 6.30017817e-02f,
  3.10849041e-01f, 4.20951657e-02f, -4.94421944e-02f, -1.42228901e-01f, -8.28060731e-02f, 1.00022115e-01f, 8.77541155e-02f, 1.30764237e-02f, -7.83755928e-02f, -1.48969203e-01f,
  2.82903075e-01f, 7.54896998e-02f, -5.24582192e-02f, 1.75935015e-01f, -2.66617328e-01f, 3.57935637e-01f, -3.58736031e-02f, -1.39418334e-01f, 3.12022001e-01f, 2.43328109e-01f,
  -4.09460180e-02f, 3.89648415e-03f, -1.67215485e-02f, -2.35129043e-01f, -5.69271520e-02f, 1.34926945e-01f, 3.74741703e-02f, -9.95977074e-02f, -1.07206047e-01f, -8.85190442e-02f,
  4.29153740e-02f, 1.73322171e-01f, -2.58137912e-01f, 2.06302345e-01f, -3.17161642e-02f, 5.94346300e-02f, -3.73461703e-03f, -6.97738901e-02f, -5.94542101e-02f, -6.39413763e-03f,
  -4.21309955e-02f, 1.43532827e-01f, 6.45804331e-02f, 8.89878049e-02f, -5.97277172e-02f, 5.73810786e-02f, -1.09584695e-02f, 2.87882630e-02f, 2.84960400e-02f, -7.20102116e-02f,
  -3.92999649e-02f, -2.98903305e-02f, 1.52981495e-02f, 8.76433104e-02f, 2.72755548e-02f, -2.87075080e-02f, -1.15156464e-01f, -7.73209557e-02f, 3.58540937e-02f, -3.95686030e-02f,
  -3.04848887e-02f, 1.88148599e-02f, 3.97149175e-02f, -1.04439013e-01f, 2.14481018e-02f, 3.52640115e-02f, -2.63584834e-02f, 8.43821093e-02f, -2.01844387e-02f, 4.81031253e-04f,
  3.13830115e-02f, 6.06970638e-02f, 9.06310976e-02f, 3.86846922e-02f, 1.37310192e-01f, 7.93789849e-02f, 5.76643227e-03f, -4.34164666e-02f, 2.04637405e-02f, 3.44622880e-02f,
  -9.57042053e-02f, -8.37749839e-02f, 8.70600864e-02f, 5.86810196e-03f, -9.01908707e-03f, 3.37051637e-02f, -9.77108032e-02f, -3.46326232e-02f, 9.75788012e-03f, 5.55564240e-02f,
  -1.56037793e-01f, 1.12254046e-01f, -1.64289176e-01f, -1.53967902e-01f, 2.49409810e-01f, 2.04589263e-01f, 1.51587397e-01f, 2.36020237e-03f, 7.25135803e-02f, -5.70215359e-02f,
  1.05240248e-01f, -4.96825650e-02f, 1.32677168e-01f, -4.03666720e-02f, -3.33783925e-02f, 4.56894487e-02f, 1.61840707e-01f, 7.36015439e-02f, 3.71623114e-02f, 2.40072086e-01f,
  4.60818643e-03f, 4.11648639e-02f, 8.23236480e-02f, 4.51278202e-02f, 1.80296853e-01f, 1.46346062e-01f, -2.08431080e-01f, -6.21141419e-02f, 1.26041308e-01f, -1.40952080e-01f,
  7.51958564e-02f, 8.78722146e-02f, 7.12422058e-02f, -1.95953473e-02f, 3.50465551e-02f, -2.31950656e-02f, -6.51787743e-02f, 7.34807998e-02f, 2.42743567e-01f, -1.61127344e-01f,
  4.80949804e-02f, 1.49506591e-02f, 8.68349448e-02f, 1.44569218e-01f, 4.64007482e-02f, -1.21806547e-01f, -7.04670101e-02f, 1.20786838e-01f, -6.88997433e-02f, -7.94759206e-03f,
  7.08623827e-02f, 8.75561032e-03f, 2.11969614e-02f, 2.42467955e-01f, 6.43538162e-02f, -5.36019653e-02f, -2.54484043e-02f, -3.84819834e-03f, 3.91659886e-02f, -8.82049575e-02f,
  -6.26828596e-02f, -5.84267750e-02f, -8.10636505e-02f, 1.07909523e-01f, 2.75805779e-02f, 1.86644375e-01f, -2.97309528e-03f, -1.57509185e-02f, -1.03597574e-01f, 1.01211503e-01f,
  -3.60534564e-02f, 1.37577116e-01f, -1.27418622e-01f, 1.22771360e-01f, 5.16145900e-02f, -3.19525860e-02f, 4.00615819e-02f, 5.72536476e-02f, 7.21005201e-02f, 1.41227886e-01f,
  4.48935032e-02f, 1.15803808e-01f, -2.31547300e-02f, -4.57601324e-02f, 8.15438665e-03f, 1.35176301e-01f, 2.76177656e-02f, 1.59939658e-02f, 5.92285097e-02f, -2.99600400e-02f,
  6.77471086e-02f, 6.79909345e-03f, 6.18274789e-05f, 1.18806120e-02f, 4.69790325e-02f, -2.39604004e-02f, -3.15328799e-02f, 5.65921962e-02f, 9.79287550e-02f, 3.71792652e-02f,
  -7.51730811e-04f, -1.18867289e-02f, -9.36706550e-03f, -1.24016812e-03f, -4.83267792e-02f, 9.56185162e-02f, -1.04450211e-01f, -4.44892868e-02f, 3.26525560e-03f, 1.25344306e-01f,
  1.37160346e-01f, 1.95943713e-02f, -3.47662084e-02f, 3.74103077e-02f, 6.88094040e-03f, 7.40463510e-02f, -1.20319100e-02f, -7.84382131e-03f, -4.43197461e-03f, 1.32800460e-01f,
  -5.41281216e-02f, 5.51863983e-02f, -8.17889497e-02f, -2.86888391e-01f, 1.30666614e-01f, 1.30534589e-01f, 1.64294437e-01f, -1.44475639e-01f, 2.76160482e-02f, -7.99859241e-02f,
  -7.66200870e-02f, -1.59298882e-01f, -1.10409804e-01f, -8.61930400e-02f, 3.49674933e-02f, 8.16358253e-02f, -1.21659534e-02f, 1.65367335e-01f, 6.15128838e-02f, -1.48781717e-01f,
  3.22836339e-02f, 2.43711814e-01f, -1.66768387e-01f, -1.24598742e-01f, -5.87814376e-02f, -1.89881146e-01f, 6.70743138e-02f, 3.33297364e-02f, 2.05633372e-01f, 1.94390804e-01f,
  1.01922147e-01f, 2.59694517e-01f, -6.05340376e-02f, -9.99557450e-02f, -2.25853160e-01f, 2.42575426e-02f, 1.93064302e-01f, 6.23862296e-02f, 1.03328347e-01f, 2.63255507e-01f,
  5.50646149e-03f, -5.05685695e-02f, 4.19356711e-02f, -1.08589083e-01f, -9.60270688e-02f, 5.63092269e-02f, 6.14322573e-02f, -3.73264449e-03f, -1.57661870e-01f, 5.39890938e-02f,
  -2.21053153e-01f, 1.86869264e-01f, -2.91380826e-02f, 4.37523872e-02f, 2.00964548e-02f, -5.77111542e-02f, 1.68525912e-02f, 1.78762123e-01f, 1.94880925e-02f, 1.99349433e-01f,
  -1.35085404e-01f, 6.65207207e-02f, 4.21799980e-02f, -1.60882667e-01f, -1.46754578e-01f, -5.79870529e-02f, 9.76986289e-02f, -8.95720869e-02f, -1.10774539e-01f, -1.73704177e-01f,
  2.37250216e-02f, 2.27901369e-01f, -1.30877560e-02f, -6.31590262e-02f, 9.62145627e-02f, 1.64746359e-01f, -1.26886323e-01f, 9.68869701e-02f, -9.18906480e-02f, -1.36112571e-01f,
  6.63074628e-02f, -2.18369383e-02f, 1.24282464e-02f, 1.26234725e-01f, 7.98357278e-02f, 1.66999325e-02f, 7.84513354e-02f, 9.34531838e-02f, 5.68000339e-02f, 8.04735646e-02f,
  -1.45369191e-02f, 1.00136995e-01f, 4.09497647e-03f, 7.77423307e-02f, -6.11352250e-02f, 6.65283725e-02f, 8.38218555e-02f, 1.32956043e-01f, 8.14813152e-02f, 3.23461071e-02f,
  6.43485859e-02f, 1.21502422e-01f, -3.53572741e-02f, 8.80288705e-02f, -4.66574356e-02f, 4.36008014e-02f, 9.08439383e-02f, -1.03469744e-01f, -6.56628683e-02f, 1.20951217e-02f,
  -2.22885590e-02f, 6.10868484e-02f, 1.20325619e-02f, 5.14182821e-02f, 8.23431909e-02f, 1.06371135e-01f, 1.55143499e-01f, 1.03561826e-01f, 5.65678328e-02f, 1.24339916e-01f,
  -8.20693150e-02f, 6.06545880e-02f, 7.26418421e-02f, 5.75830042e-02f, 8.14718232e-02f, 6.84032664e-02f, 4.75127362e-02f, 6.40208945e-02f, 5.05256886e-03f, 2.27000490e-02f,
  1.38880268e-01f, 1.14419870e-01f, 1.38878673e-02f, -1.18638098e-01f, -6.76693842e-02f, -3.64132077e-02f, 1.68044075e-01f, 8.35492462e-02f, -2.08361089e-01f, -1.45877451e-01f,
  2.01158002e-01f, -2.92208884e-02f, -3.13126035e-02f, -1.82329372e-01f, -8.23809803e-02f, 2.51754597e-02f, -1.13926694e-01f, 5.44062890e-02f, -1.46946654e-01f, -2.68283542e-02f,
  -5.74634187e-02f, 4.97816056e-02f, 2.14701965e-01f, -8.86859298e-02f, -2.46274278e-01f, -5.34820184e-02f, 1.80137381e-02f, -2.56182477e-02f, -9.67122391e-02f, 5.72311506e-02f,
  -9.10707377e-03f, -1.89665169e-01f, -1.15022901e-02f, 4.43565995e-02f, -1.81476921e-02f, -3.52001609e-03f, -2.00828519e-02f, -3.06137856e-02f, -1.42157555e-01f, 4.55684178e-02f,
  -1.36744544e-01f, 2.00654548e-02f, -5.29258698e-02f, 7.15876520e-02f, 1.03738867e-01f, 2.65278909e-02f, -1.70662254e-01f, 7.98347890e-02f, 1.72245145e-01f, -1.20235108e-01f,
  4.12626192e-02f, -1.01571597e-01f, -1.72712162e-01f, -4.79414500e-02f, -8.81044716e-02f, 8.96105841e-02f, -4.70022373e-02f, 6.67163208e-02f, -1.27498046e-01f, 9.49596893e-03f,
  2.15288118e-01f, -1.08041495e-01f, 8.61457139e-02f, 2.95029413e-02f, 3.95459384e-02f, -1.56976849e-01f, -3.86747569e-02f, -1.00816838e-01f, 1.61457047e-01f, -4.46745008e-02f,
  4.34737355e-02f, -1.92390177e-02f, -1.15577867e-02f, 1.06986150e-01f, -1.94992542e-01f, -1.09029926e-01f, 1.42348215e-01f, 2.42863074e-01f, 9.35465097e-03f, 7.29066432e-02f,
  -1.67599320e-02f, -7.17548355e-02f, -9.11013335e-02f, -6.49914369e-02f, 6.57130778e-03f, 7.34759271e-02f, 4.43644822e-02f, 2.78016161e-02f, -7.99700543e-02f, 7.56636709e-02f,
  1.31792501e-02f, -1.65622327e-02f, -4.43224832e-02f, -1.16636097e-01f, 4.27851230e-02f, -4.59915400e-02f, -6.80033118e-02f, 6.25071675e-02f, -3.47762965e-02f, -6.37537800e-04f,
  -2.03698605e-01f, -4.58417535e-02f, 1.39317930e-01f, -3.35209072e-02f, -1.13010727e-01f, 1.22854508e-01f, 9.07974690e-02f, -5.50274253e-02f, 6.26302361e-02f, 1.53156668e-02f,
  -4.81791496e-02f, 1.01161577e-01f, 6.47254214e-02f, -8.05826038e-02f, 9.36226323e-02f, -4.38983068e-02f, 1.17698805e-02f, -9.77670327e-02f, 7.61692375e-02f, 3.24449390e-02f,
  -3.23311910e-02f, -1.81292504e-01f, -2.02914365e-02f, 4.89785150e-02f, -1.07358426e-01f, 3.47671732e-02f, 1.14072256e-01f, 3.14626135e-02f, -1.47826627e-01f, 2.22308245e-02f,
  -1.14708550e-01f, 7.07779750e-02f, -1.29516134e-02f, 2.79146489e-02f, -1.00692168e-01f, 1.07206805e-02f, 2.62866206e-02f, 1.33557245e-01f, 1.55222997e-01f, 2.48236239e-01f,
  6.17591441e-02f, 2.01052576e-01f, -9.60513391e-03f, 2.02445616e-03f, 2.13650689e-01f, 4.35429551e-02f, 4.77129146e-02f, -1.29179403e-01f, 6.41490594e-02f, 1.67092055e-01f,
  5.80415428e-02f, -2.34933477e-02f, 2.91519538e-02f, 2.60317270e-02f, -9.14081708e-02f, -2.39897043e-01f, 6.61613569e-02f, -1.74128916e-02f, 6.35489225e-02f, 1.87142387e-01f,
  9.09543410e-03f, -1.38721809e-01f, 7.82371610e-02f, -1.64400995e-01f, -4.26544510e-02f, 8.13571140e-02f, 1.62613347e-01f, -2.03037933e-01f, 7.09253699e-02f, 4.18724306e-02f,
  1.78612508e-02f, -2.14058354e-01f, -2.04359785e-01f, -2.04512149e-01f, 1.00086458e-01f, -7.42414147e-02f, 4.29104157e-02f, 7.87884519e-02f, 7.63887987e-02f, 8.52067303e-03f,
  1.74180895e-01f, 2.78658688e-01f, 9.57716852e-02f, -8.94221589e-02f, 1.04431391e-01f, 1.39654696e-01f, 2.69379377e-01f, 9.75272059e-02f, 1.63968112e-02f, 2.81527072e-01f,
  -2.06055269e-01f, 1.85401127e-01f, 1.27313072e-02f, 1.92491442e-01f, 1.73796147e-01f, 1.32841438e-01f, 1.61879316e-01f, -5.79481386e-02f, 9.46383402e-02f, 2.56862998e-01f,
  3.78495716e-02f, -1.76209971e-01f, 9.14110616e-03f, 7.27776960e-02f, 1.75855175e-01f, -1.31157726e-01f, 1.41097367e-01f, 1.76970586e-01f, 4.24399190e-02f, -5.81352599e-02f,
  -2.44953893e-02f, -5.05278967e-02f, 7.95553029e-02f, -1.27588034e-01f, 5.40994741e-02f, -6.14939956e-03f, 8.94768983e-02f, 5.21811433e-02f, 1.62707403e-01f, 1.98870245e-02f,
  9.92403850e-02f, 9.39269885e-02f, -1.14524700e-01f, 5.72711378e-02f, 7.39236400e-02f, 4.16670479e-02f, 1.89521592e-02f, -2.01573983e-01f, 3.26219797e-01f, 1.13503255e-01f,
  1.00694329e-01f, 1.46774063e-02f, 1.06805809e-01f, 9.87354368e-02f, 6.91759288e-02f, 1.75121307e-01f, 1.37139499e-01f, 1.57472238e-01f, 1.64562553e-01f, 2.37777177e-02f,
  2.95042723e-01f, 1.01936854e-01f, -1.70084745e-01f, 4.87762205e-02f, -1.02277555e-01f, 1.32723272e-01f, 2.41789117e-01f, 2.16130707e-02f, 1.05629101e-01f, 1.65472284e-01f,
  5.13172671e-02f, 7.29461312e-02f, 2.55118348e-02f, 7.32895061e-02f, -6.29011244e-02f, 9.79951769e-02f, 4.54510488e-02f, 1.66465461e-01f, -4.71531637e-02f, 8.79965425e-02f,
  -8.91306158e-03f, -6.76925154e-03f, -5.91746718e-02f, -9.08668786e-02f, 3.72177839e-01f, -2.96546984e-02f, -3.86351228e-01f, -1.45054549e-01f, 8.12824219e-02f, -4.13655899e-02f,
  -1.34722322e-01f, -5.28077632e-02f, -8.66144970e-02f, 1.54580742e-01f, -5.06233908e-02f, -1.21358603e-01f, 1.01931117e-01f, 1.22771427e-01f, -1.93288028e-01f, 8.96873996e-02f,
  3.11846346e-01f, -1.89746991e-01f, -2.47493505e-01f, -9.29086208e-02f, 2.57292241e-02f, -2.52849936e-01f, 1.51188606e-02f, 1.41075645e-02f, 1.41280785e-01f, -2.43776795e-02f,
  -3.20213705e-01f, 1.99935421e-01f, -2.35417143e-01f, 6.47460297e-03f, 4.08811793e-02f, -3.63613442e-02f, 3.57798040e-02f, 1.57980563e-03f, 2.54541710e-02f, -8.40673074e-02f,
  -1.12543970e-01f, 1.35772247e-02f, 1.07844464e-01f, -8.26707110e-02f, -1.77133098e-01f, -6.37240289e-03f, -5.03790118e-02f, 7.54648894e-02f, 3.32599342e-01f, 2.10587382e-01f,
  1.51621163e-01f, 9.94894188e-03f, -5.81959412e-02f, -2.65590519e-01f, 1.82863161e-01f, -2.97531337e-01f, 1.31626591e-01f, 9.14098099e-02f, 1.31766915e-01f, -1.26478627e-01f,
  1.73565224e-02f, 1.68227151e-01f, -1.20575344e-02f, 7.98508599e-02f, -1.56266570e-01f, 2.97271639e-01f, -1.29255921e-01f, 2.90641636e-01f, -7.73130134e-02f, -6.98462203e-02f,
  5.62678993e-01f, -6.27063308e-03f, -1.22896604e-01f, -2.38534778e-01f, -3.35326456e-02f, -2.40958631e-02f, -1.39187658e-02f, 3.95644233e-02f, 1.35366932e-01f, 6.59849644e-02f,
  1.40951434e-02f, -9.95759815e-02f, 5.81616387e-02f, 1.81421861e-02f, 1.90742105e-01f, 1.18927481e-02f, 9.68701616e-02f, 1.22783132e-01f, 1.29747003e-01f, 1.25053182e-01f,
  1.22049488e-01f, 2.75252074e-01f, 4.02354337e-02f, 1.18876532e-01f, 8.18054974e-02f, -6.80703297e-02f, 2.11420953e-01f, 1.86382666e-01f, 6.28206553e-03f, 2.10804909e-01f,
  1.45626426e-01f, -2.85945255e-02f, -4.77404846e-03f, 1.33263066e-01f, -1.96478203e-01f, 1.39361441e-01f, 2.58368086e-02f, 6.70510232e-02f, 2.54337266e-02f, 2.14206412e-01f,
  -2.79045552e-02f, 2.31799893e-02f, -4.75146016e-03f, 6.58278093e-02f, -1.78434849e-02f, 2.43564099e-01f, -8.02779496e-02f, 5.16606830e-02f, 6.92665204e-02f, 5.14490902e-02f,
  4.92125787e-02f, 4.51940624e-03f, -2.30896194e-02f, 2.75611747e-02f, 9.68276262e-02f, 2.89204083e-02f, 1.11764647e-01f, -2.26199925e-01f, -3.29312235e-02f, -1.16335809e-01f,
  5.81624396e-02f, -2.17559978e-01f, -1.08308837e-01f, -2.44334951e-01f, 1.14838257e-02f, -3.46206158e-01f, -3.29007417e-01f, -1.03114776e-01f, 4.13445607e-02f, 5.18538207e-02f,
  1.74670219e-01f, 3.47300656e-02f, -1.83063641e-01f, 4.39526230e-01f, 1.10757358e-01f, -1.74152464e-01f, -2.24469826e-02f, -1.85860977e-01f, 1.12499960e-01f, 1.18539095e-01f,
  2.74896353e-01f, 2.75072694e-01f, -3.75387967e-01f, 8.79199654e-02f, -1.92934901e-01f, -3.27946782e-01f, 3.88641059e-01f, 1.26220673e-01f, -1.24402496e-03f, -3.27713117e-02f,
  -2.20792085e-01f, 1.53391436e-01f, -1.57861263e-01f, -1.43779188e-01f, -2.12211758e-01f, 1.32131785e-01f, 3.96597497e-02f, 2.73851007e-01f, -1.15968864e-02f, 5.15906103e-02f,
  -1.48661599e-01f, -1.82500675e-01f, -2.23069880e-02f, -1.56335935e-01f, 1.34083167e-01f, 1.28763974e-01f, 1.26591483e-02f, -2.58505315e-01f, -5.05316406e-02f, -3.08465660e-01f,
  -4.52303626e-02f, -1.51457293e-02f, 9.02841464e-02f, -5.84308915e-02f, 3.31022218e-02f, 1.53652936e-01f, 1.79508507e-01f, 1.15533665e-01f, 1.11323602e-01f, 1.75155662e-02f,
  -7.90499821e-02f, -2.77327970e-02f, 3.12659234e-01f, 2.69065648e-01f, -1.48463426e-02f, -1.89246684e-01f, -8.58384594e-02f, -1.26286626e-01f, -9.17102545e-02f, 9.38443989e-02f,
  2.02874511e-01f, 2.43293524e-01f, 2.11887248e-03f, -6.39474839e-02f, 3.87955122e-02f, 2.50852965e-02f, 3.54485698e-02f, 4.02163304e-02f, 2.41830796e-02f, -6.05059229e-02f,
  5.17113693e-02f, 3.25226635e-02f, 1.60838395e-01f, -9.78392176e-03f, 8.62673223e-02f, -3.13812569e-02f, 1.54123649e-01f, 3.77919748e-02f, 4.99917082e-02f, -1.58629101e-03f,
  1.88095365e-02f, 1.07561938e-01f, 1.21753357e-01f, -6.56312630e-02f, 1.13008134e-02f, -5.15405871e-02f, 1.55718744e-01f, 6.19373247e-02f, 9.05000344e-02f, 1.25188485e-01f,
  1.46663740e-01f, 3.12464274e-02f, 4.22108099e-02f, 3.40881161e-02f, 9.40636322e-02f, 9.09582805e-03f, -5.06242961e-02f, 1.25624808e-02f, -6.75282627e-02f, 1.52599430e-02f,
  1.20161697e-01f, -5.88797964e-02f, 6.03222325e-02f, 4.97534573e-02f, -5.96337132e-02f, -9.26765651e-02f, 1.43353157e-02f, 2.18366943e-02f, 1.26446694e-01f, -5.06630056e-02f,
  7.69100487e-02f, 1.40411675e-01f, -2.96691861e-02f, 6.35837018e-02f, 4.54972452e-03f, 1.02481999e-01f, 1.33578151e-01f, -9.03898627e-02f, -2.00790167e-01f, -6.64262623e-02f,
  8.84898752e-02f, 6.68887049e-02f, 1.33121768e-02f, -1.71548665e-01f, 1.13283200e-02f, 2.24762522e-02f, 3.58692072e-02f, 1.10086560e-01f, 7.06743896e-02f, -1.06823236e-01f,
  1.32175371e-01f, 1.02628157e-01f, -7.10017011e-02f, -5.59476502e-02f, -1.25532031e-01f, 1.47745237e-01f, 1.27313912e-01f, -9.67293307e-02f, 3.74298356e-02f, -5.70501061e-03f,
  7.21155927e-02f, 7.84357369e-04f, -1.34819699e-02f, 1.14582017e-01f, -1.60561819e-02f, 5.29883839e-02f, 1.01969717e-02f, -2.54889932e-02f, 2.88917273e-02f, -5.52415699e-02f,
  5.85059449e-02f, 3.26081403e-02f, 9.18629020e-02f, 4.95358109e-02f, -1.08216159e-01f, -1.06150273e-03f, -1.88351441e-02f, -1.05833495e-02f, 3.47272381e-02f, -1.23785168e-01f,
  -8.06591213e-02f, 4.92298603e-02f, -2.64957361e-02f, -4.45930734e-02f, 1.08862035e-01f, -1.23043053e-01f, 3.10280532e-01f, -1.97874829e-02f, 1.18175395e-01f, 5.27589545e-02f,
  1.86999738e-01f, 1.42633379e-01f, -1.72673151e-01f, 1.47540167e-01f, 3.78679559e-02f, 2.34717682e-01f, 4.75120097e-02f, 2.57934421e-01f, 4.34351452e-02f, 1.77014977e-01f,
  1.91628709e-01f, -4.88846302e-02f, 6.82118684e-02f, -1.27786696e-01f, 2.95600630e-02f, -3.33408639e-02f, 2.91673094e-01f, 9.28814411e-02f, -5.06777130e-02f, -5.78091890e-02f,
  1.88264757e-01f, -6.42414987e-02f, 1.06922813e-01f, 5.90237714e-02f, 7.77482092e-02f, 2.04464979e-02f, 2.34824382e-02f, -1.20622449e-01f, -8.65239557e-03f, -2.16372404e-02f,
  1.83837324e-01f, -6.50321022e-02f, 3.39369699e-02f, 4.17267997e-03f, 1.44440755e-01f, 1.32737309e-01f, 5.76738417e-02f, 1.62838638e-01f, 1.21308649e-02f, 1.29719108e-01f,
  7.12217838e-02f, 4.75699939e-02f, 1.11107528e-01f, 9.26242694e-02f, 1.53015435e-01f, 1.16921134e-01f, 1.08417757e-01f, 1.36571527e-01f, 9.16218311e-02f, 1.64372221e-01f,
  2.05535665e-02f, 1.48553997e-01f, 1.08679406e-01f, 9.10935700e-02f, 6.44546896e-02f, 1.82319865e-01f, 3.91011266e-03f, 3.75503488e-02f, 6.45208582e-02f, 1.82785884e-01f,
  8.79190415e-02f, 1.14572130e-01f, -1.74591783e-02f, -5.29866964e-02f, 2.53544655e-02f, 2.10188366e-02f, 8.01459178e-02f, -5.47163077e-02f, 1.09503038e-01f, 1.68852225e-01f,
  3.27046700e-02f, 1.61591500e-01f, -3.87671366e-02f, -8.75642300e-02f, -4.65580113e-02f, 9.40225646e-02f, -1.90745533e-01f, 7.69968405e-02f, -5.64585365e-02f, -7.19788224e-02f,
  -3.87380347e-02f, -1.51135743e-01f, -1.49458840e-01f, 3.17299105e-02f, 3.20056409e-01f, -3.93620552e-03f, 1.29119992e-01f, -6.54994175e-02f, -7.32880039e-03f, -2.49146372e-02f,
  8.59101117e-02f, -2.18272641e-01f, -2.65095346e-02f, 2.01300114e-01f, 9.17776227e-02f, -2.11740881e-02f, 7.36964047e-02f, 1.26297697e-01f, -5.73474541e-02f, -2.34796945e-02f,
  -3.71773690e-02f, 3.87932695e-02f, 1.05676502e-01f, 1.28404155e-01f, 9.07703117e-02f, -1.49986908e-01f, 7.18550831e-02f, -2.02876151e-01f, -4.40794788e-02f, 2.41730124e-01f,
  9.35364664e-02f, 1.94990069e-01f, -6.76600188e-02f, 1.52874544e-01f, 2.82888208e-02f, -8.95559695e-03f, 4.06062193e-02f, -5.47742061e-02f, 9.53466594e-02f, -1.71667419e-03f,
  -7.63123631e-02f, -4.12904238e-03f, 1.03046335e-01f, -1.66496620e-01f, -2.39395611e-02f, -1.89774930e-01f, -1.52187310e-02f, -2.01383695e-01f, 5.55299893e-02f, 5.23574278e-02f,
  -2.33250543e-01f, 7.91134033e-03f, 1.01444595e-01f, -7.76756033e-02f, 1.72556669e-01f, 3.06301843e-02f, 8.32303464e-02f, 2.19694912e-01f, -1.02322511e-02f, -3.59683000e-02f,
  9.32939500e-02f, -2.17320815e-01f, 7.93407951e-03f, 1.69932749e-02f, 2.56894261e-01f, 1.69887677e-01f, 5.55547476e-02f, 1.27114102e-01f, 1.09188236e-01f, 3.15003544e-02f,
  5.38164526e-02f, 2.86528431e-02f, 1.73952058e-02f, -2.89531853e-02f, -5.45681007e-02f, 1.16507657e-01f, 1.72208305e-02f, 4.42191362e-02f, -3.35323252e-02f, 7.41247833e-02f,
  3.98003794e-02f, -7.90577158e-02f, -2.76086926e-02f, -2.63473485e-02f, 1.43180368e-02f, 8.27043578e-02f, 5.32923602e-02f, -1.64313300e-03f, 4.61040363e-02f, 6.02370501e-02f,
  -1.01565793e-01f, 1.01758473e-01f, -5.50341904e-02f, -3.65087613e-02f, -3.37259471e-02f, 3.30544682e-03f, -4.28960361e-02f, 3.50796059e-03f, 6.88361377e-02f, 8.63942653e-02f,
  9.14113075e-02f, -1.12564322e-02f, 1.69232080e-03f, 1.27931517e-02f, 1.25097871e-01f, 7.33537748e-02f, 1.43577922e-02f, -4.23956513e-02f, -1.82634331e-02f, 3.29789780e-02f,
  4.10496779e-02f, 8.32565129e-03f, 5.79497404e-02f, 8.00502598e-02f, 3.99718098e-02f, -5.54764010e-02f, 7.19548762e-02f, -1.52126970e-02f, 7.00579882e-02f, 1.16632171e-01f,
  -1.49275124e-01f, -5.98983765e-02f, -1.89374268e-01f, 3.56876925e-02f, -1.74461957e-02f, 3.40016544e-01f, -9.50229913e-02f, 4.47845683e-02f, 2.68323809e-01f, 1.00336783e-01f,
  -5.21258637e-03f, -3.51388119e-02f, 1.66014291e-03f, -8.74561667e-02f, -9.30826440e-02f, 6.36785626e-02f, 6.61081049e-06f, -2.02244148e-01f, 2.22535748e-02f, 1.80692807e-01f,
  2.87450105e-01f, 3.68384197e-02f, -1.83505982e-01f, 1.01669841e-01f, -5.11357524e-02f, 5.47855459e-02f, 2.27164049e-02f, -3.96908913e-03f, -1.93479075e-03f, 3.06594335e-02f,
  -9.70824361e-02f, -4.64751348e-02f, 8.56650993e-02f, 5.97913973e-02f, 3.31065841e-02f, -1.13999352e-01f, 5.80391847e-02f, 1.29286498e-01f, -9.44813639e-02f, -1.16743147e-01f,
  6.48733974e-02f, -1.95551198e-02f, 1.63818404e-01f, 1.00725405e-01f, 1.41038410e-02f, 2.08857641e-01f, 2.62723267e-01f, -8.60747173e-02f, 1.24720402e-01f, -1.68008488e-02f,
  -1.50270820e-01f, 7.10910782e-02f, 3.23157734e-03f, 1.94305897e-01f, 1.57618940e-01f, 2.08040029e-01f, 1.68584049e-01f, 1.08520418e-01f, 1.14713684e-01f, 1.30796894e-01f,
  8.30591768e-02f, 2.55567044e-01f, 5.26189543e-02f, 9.69608799e-02f, 3.66606116e-02f, 8.81630033e-02f, -1.01980381e-03f, -4.46925983e-02f, 1.18823111e-01f, 7.42622167e-02f,
  3.16209905e-02f, 1.09900177e-01f, -2.67188162e-01f, -2.70642657e-02f, -7.30051398e-02f, 2.52049923e-01f, 1.20097101e-01f, 9.67709254e-03f, 3.13123465e-02f, 4.59046327e-02f,
  1.02432609e-01f, -9.87088531e-02f, -2.52956748e-02f, 1.24822170e-01f, -5.03311083e-02f, 8.92217308e-02f, -7.67300352e-02f, -4.61680666e-02f, 9.04044975e-03f, 6.86290395e-03f,
  -1.11977495e-02f, 6.57588318e-02f, 7.09839314e-02f, 9.25580710e-02f, 6.66172281e-02f, 6.64526820e-02f, 3.66259441e-02f, 9.70550403e-02f, -3.28974016e-02f, 2.11161301e-02f,
  6.24088496e-02f, -1.35010267e-02f, 8.94554611e-03f, -3.09449388e-03f, 1.19071249e-02f, 2.84430329e-02f, 2.01380048e-02f, 3.98820676e-02f, -7.51620345e-03f, -1.58225521e-02f,
  1.99381430e-02f, -9.24171973e-03f, 1.01464584e-01f, -1.40455738e-02f, 6.72628433e-02f, 2.96186171e-02f, -3.38165164e-02f, 1.99120748e-03f, 8.80307481e-02f, -4.60536182e-02f,
  7.07784742e-02f, 4.90969345e-02f, -1.79621503e-02f, 5.73078170e-02f, -3.69236879e-02f, 4.36032377e-02f, -2.70239078e-02f, -2.56606229e-02f, 6.69207498e-02f, -2.11470932e-01f,
  -1.81301415e-01f, 8.82980302e-02f, 5.93485869e-02f, 2.19677716e-01f, -2.71292776e-01f, -5.35654090e-02f, 1.53448209e-01f, 6.04594946e-02f, -9.51676518e-02f, 5.13183065e-02f,
  1.32305473e-01f, -4.35185805e-02f, -2.86100432e-02f, 5.68871945e-02f, -1.27841964e-01f, -6.28291219e-02f, 3.98448370e-02f, 2.83596683e-02f, 2.57500112e-01f, -1.67446900e-02f,
  -2.12422118e-01f, -8.56476929e-03f, -6.46440685e-03f, -3.08454242e-02f, -1.33701935e-01f, 3.74538861e-02f, 6.62477454e-03f, -1.34032920e-01f, 5.50111709e-03f, -7.30887009e-03f,
  1.24522327e-02f, -1.67571396e-01f, 8.52704942e-02f, 3.66362818e-02f, -5.23810610e-02f, 1.61619782e-01f, 5.15912659e-02f, 1.33405998e-01f, 6.77563846e-02f, 8.59224424e-02f,
  5.38217835e-02f, -1.43200010e-01f, -9.78798568e-02f, 1.05310015e-01f, 1.46620989e-01f, -1.08253404e-01f, -2.04915982e-02f, -5.63331433e-02f, -1.71364933e-01f, 4.10586037e-03f,
  -1.92882299e-01f, 1.32994528e-03f, 1.50083557e-01f, -5.19408695e-02f, -3.86084206e-02f, 1.93008389e-02f, 1.70510143e-01f, 1.93370469e-02f, -1.20379180e-01f, -5.75879775e-02f,
  1.59940168e-01f, -9.80089903e-02f, 4.19895072e-03f, 5.35381101e-02f, 9.26395059e-02f, 9.37171057e-02f, 1.91233769e-01f, -7.20415339e-02f, 1.53785571e-02f, 3.78897041e-02f,
  -1.61826372e-01f, 1.23279721e-01f, 1.63689002e-01f, 1.08810142e-01f, 2.36099645e-01f, 6.82537584e-03f, 7.40387589e-02f, 1.00607052e-01f, 4.33997661e-02f, 9.37547535e-02f,
  7.21509233e-02f, 8.16810206e-02f, 9.77229029e-02f, 6.14879131e-02f, 3.29959355e-02f, 8.97846147e-02f, 5.51226959e-02f, 1.15229167e-01f, 8.36276859e-02f, 9.04497206e-02f,
  5.58711067e-02f, -5.78675233e-03f, 2.21105032e-02f, 1.03864327e-01f, 4.95036133e-02f, 1.87004983e-01f, 3.54416408e-02f, 3.66780907e-02f, 1.98120803e-01f, 1.36584267e-01f,
  1.11088203e-02f, 4.85890880e-02f, 5.25287688e-02f, 1.38586238e-01f, 1.35352612e-01f, 3.16757597e-02f, 8.44893306e-02f, 4.90786582e-02f, 6.15001209e-02f, 2.04020187e-01f,
  1.46041721e-01f, 2.48791203e-02f, 1.22630991e-01f, 1.60688683e-01f, 1.16502784e-01f, 7.71573512e-03f, 1.74070522e-01f, 7.95853361e-02f, 1.16342977e-01f, 6.98507205e-02f,
  3.19106616e-02f, 8.95727575e-02f, 6.96947472e-03f, 1.19880751e-01f, 4.46890071e-02f, 2.41299625e-03f, -9.11887512e-02f, 3.30243143e-03f, -6.03676308e-03f, 1.57459170e-01f,
  -1.10384198e-02f, -5.97681850e-02f, 3.88871767e-02f, 6.29211366e-02f, -7.99676403e-04f, 9.30735543e-02f, 4.39171791e-02f, -2.47027632e-02f, 8.68400410e-02f, 1.63316298e-02f,
  -1.53268740e-01f, 4.92001474e-02f, -5.33645749e-02f, -1.99955717e-01f, 9.10529401e-03f, -2.25990955e-02f, -1.88967101e-02f, 1.86010897e-01f, -4.55275327e-02f, -4.74897511e-02f,
  -6.03823140e-02f, -1.74072459e-01f, -1.25884926e-02f, -2.00165570e-01f, 1.42212570e-01f, 2.09687993e-01f, -2.25456078e-02f, 2.19938122e-02f, -1.07301377e-01f, -1.54419333e-01f,
  -1.91488769e-02f, -2.89344609e-01f, 2.98098102e-03f, 2.51930021e-02f, 6.27594516e-02f, 1.35337323e-01f, 2.10574400e-02f, -2.01037452e-02f, 5.00981435e-02f, -9.17067155e-02f,
  1.51945382e-01f, -4.63128760e-02f, 6.49556369e-02f, -1.03220992e-01f, -9.57490206e-02f, -1.75708234e-01f, -4.83333394e-02f, -2.12161262e-02f, -1.02758311e-01f, -7.05436543e-02f,
  -5.96403256e-02f, -2.02672809e-01f, -1.09976038e-01f, 1.04297318e-01f, -1.00855283e-01f, -8.02745372e-02f, 1.52430028e-01f, -1.30474776e-01f, 1.42618185e-02f, -8.30666572e-02f,
  9.95614156e-02f, 9.12937075e-02f, -1.38427183e-01f, -1.87803730e-01f, 5.26498538e-03f, -1.09755196e-01f, 5.33664748e-02f, 2.11400278e-02f, 2.33518139e-01f, -4.27449718e-02f,
  3.50512639e-02f, 7.03921765e-02f, -3.40841748e-02f, 8.14916492e-02f, 6.73866570e-02f, -1.07584357e-01f, -1.13716004e-02f, -4.36222106e-02f, 5.21661229e-02f, 6.11880459e-02f,
  -5.80608360e-02f, 1.93541385e-02f, 1.70298817e-03f, 3.76760550e-02f, 4.83294316e-02f, -1.83350183e-02f, -9.01234057e-03f, -1.91894211e-02f, 5.55802658e-02f, 1.33772165e-01f,
  1.09083243e-01f, -6.94317445e-02f, 3.67562920e-02f, -6.59493431e-02f, 6.03494095e-03f, 4.43081781e-02f, -1.03072502e-01f, -1.65132955e-02f, 1.02301359e-01f, -3.00616696e-02f,
  -5.06687649e-02f, -4.56099845e-02f, -1.85722224e-02f, 4.21692096e-02f, 2.16869470e-02f, 7.93577954e-02f, 3.99832949e-02f, -6.66958615e-02f, 8.14770907e-02f, 6.08170740e-02f,
  -1.98903903e-02f, -7.63965473e-02f, -3.41896117e-02f, -9.27878451e-03f, 1.87154971e-02f, 4.54964908e-03f, 9.58151091e-03f, 5.55041395e-02f, 2.06812993e-02f, 8.20318535e-02f,
  -2.65050889e-03f, -3.48141114e-03f, -5.23584560e-02f, -7.90492818e-03f, 1.88457835e-02f, 4.58529145e-02f, -2.40783710e-02f, -2.20048316e-02f, 5.41039370e-02f, 2.21880317e-01f,
  5.80804236e-02f, -1.00913636e-01f, 1.99966077e-02f, -5.82238287e-02f, -3.00375167e-02f, -5.51466830e-02f, -1.11042477e-01f, 5.80621026e-02f, -9.71077159e-02f, 1.45645082e-01f,
  -7.26165920e-02f, 4.38218303e-02f, -1.18303582e-01f, 1.42258197e-01f, 1.61356106e-01f, -2.87241906e-01f, -4.00216989e-02f, -1.06496746e-02f, -4.07501347e-02f, 1.71191305e-01f,
  1.19215541e-01f, 1.90279931e-01f, -1.00449078e-01f, -1.05323017e-01f, -8.15342441e-02f, 2.03250293e-02f, 6.44386262e-02f, 2.45394662e-01f, -1.99038871e-02f, 1.48897171e-01f,
  6.71746656e-02f, -4.22437256e-03f, -1.18667193e-01f, -2.64226973e-01f, -4.34083231e-02f, -3.03029735e-02f, -2.95919436e-03f, 1.82466954e-01f, -8.34236071e-02f, 2.32158467e-01f,
  1.49364686e-02f, 1.28437296e-01f, 1.16928421e-01f, 1.12916343e-02f, -1.90631244e-02f, 9.61998031e-02f, -1.06583200e-02f, 2.43433461e-01f, 8.56327266e-02f, 2.65748531e-01f,
  1.11976519e-01f, -1.68346435e-01f, 2.22708538e-01f, 9.83602032e-02f, -5.63633293e-02f, 1.08392976e-01f, 1.00116894e-01f, 1.06543213e-01f, -1.18390955e-01f, 1.74230023e-03f,
  5.88765517e-02f, 2.01416895e-01f, -2.22254321e-02f, 2.09513247e-01f, 9.05031115e-02f, 2.07497045e-01f, -2.23128781e-01f, -2.76341382e-03f, -1.50171846e-01f, -1.12021558e-01f,
  7.03683347e-02f, -3.32400436e-03f, 8.54511932e-02f, 3.63982618e-02f, -3.17725278e-02f, 8.94203037e-02f, 5.17723821e-02f, 5.21900877e-02f, 5.22200540e-02f, 1.89586189e-02f,
  3.87351997e-02f, 2.62770914e-02f, -1.05893342e-02f, 1.02255702e-01f, 2.74297465e-02f, 4.42325836e-03f, -4.49942723e-02f, 1.44187324e-02f, 9.55865607e-02f, 3.40504050e-02f,
  8.38413164e-02f, 1.11330129e-01f, -3.48874778e-02f, -2.39636116e-02f, 7.95550719e-02f, 2.68765781e-02f, -3.50907631e-02f, 1.38343185e-01f, 8.05240870e-02f, 5.12724221e-02f,
  1.04047768e-01f, -1.61926672e-02f, -2.82434151e-02f, 1.59242019e-01f, 5.61107416e-03f, 5.43365488e-04f, 1.66747183e-01f, 1.09535836e-01f, 1.38479888e-01f, 9.16734934e-02f,
  1.23717137e-01f, 5.32982387e-02f, 6.69382364e-02f, -5.44409975e-02f, 4.86769713e-02f, 5.07197231e-02f, -4.17906120e-02f, -4.34333552e-03f, 1.67528033e-01f, 8.79474431e-02f,
  -3.23422588e-02f, -2.36793496e-02f, -1.50556222e-01f, 7.13613108e-02f, 2.69994065e-02f, 1.33674800e-01f, -1.36214659e-01f, 7.97076821e-02f, -2.37592552e-02f, 3.14085111e-02f,
  2.79573165e-02f, 2.01774508e-01f, 5.62957525e-02f, 1.65515929e-01f, 1.68143004e-01f, -4.11445126e-02f, 2.03775957e-01f, -9.78759825e-02f, 7.06862882e-02f, -1.20328061e-01f,
  3.13478932e-02f, -8.81366804e-02f, -8.33037719e-02f, 9.07515436e-02f, 8.02075043e-02f, 1.19155541e-01f, 2.11365186e-02f, 8.94442853e-03f, 3.66442837e-02f, -1.06615350e-01f,
  1.10001318e-01f, 2.39339933e-01f, -1.25705019e-01f, -9.42976028e-02f, 2.03355446e-01f, -1.68521464e-01f, 1.55281629e-02f, -1.28024206e-01f, 8.72822776e-02f, -3.17586176e-02f,
  1.59831792e-01f, 5.04430942e-02f, -5.13195209e-02f, -7.88327157e-02f, 4.18623798e-02f, -9.97659490e-02f, 1.62703916e-01f, -1.00341961e-01f, 9.92922485e-02f, 1.59451440e-01f,
  -2.05227081e-03f, -2.24680942e-03f, 1.02942392e-01f, 4.11041602e-02f, -5.73824719e-02f, -1.15820564e-01f, -7.37523735e-02f, -7.57946447e-02f, 1.16022835e-02f, 2.41246030e-01f,
  -1.97809353e-01f, -6.16938481e-03f, 3.05857211e-02f, -9.48449448e-02f, -2.06929329e-03f, -3.89518403e-02f, 8.38263482e-02f, 5.51318750e-02f, -1.51552513e-01f, -1.03425957e-01f,
  -9.03641880e-02f, -2.29573455e-02f, 8.45876187e-02f, -3.46464776e-02f, 7.74298906e-02f, 9.65065137e-02f, 8.27432901e-04f, 3.51457335e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  7.42084384e-02f, 7.48910829e-02f, 5.08041494e-02f, 1.64594650e-02f, 1.09591573e-01f, 7.45519772e-02f, 5.12457043e-02f, 1.32219568e-02f, 9.02754068e-02f, 3.95528339e-02f,
  3.93846445e-02f, 9.33723226e-02f, 4.70614992e-02f, 7.60836676e-02f, 4.84227091e-02f, 4.79044430e-02f, 9.45893452e-02f, 5.72385974e-02f, 8.11131448e-02f, 9.27836671e-02f,
  7.17735887e-02f, 7.39797354e-02f, 6.28897995e-02f, 6.40403405e-02f, 4.86110896e-02f, 1.72002502e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  -2.27309823e-01f, -1.29218742e-01f, -1.36918686e-02f, 1.36834517e-01f, 6.15216419e-02f, 1.42991664e-02f, 4.34114113e-02f, -8.85861218e-02f, -8.38842168e-02f, -1.57600269e-01f,
  2.25079097e-02f, 8.02868381e-02f, 1.02192275e-01f, -1.01938238e-02f, -1.16278946e-01f, -2.03795843e-02f, -1.34079933e-01f, 8.52610692e-02f, 1.05888080e-02f, -1.02227308e-01f,
  -1.29207164e-01f, 2.45153010e-02f, -6.61060661e-02f, -1.29746636e-02f, -1.26093030e-01f, -4.83042225e-02f, -6.79250062e-03f, -1.08184859e-01f, 1.27100915e-01f, 6.72188476e-02f,
  5.79523034e-02f, -1.61055312e-01f, -9.00229290e-02f, 1.09083928e-01f, 5.16476296e-02f, -1.44557416e-01f, -9.47160274e-02f, -1.55668527e-01f, -1.62890077e-01f, 1.36639789e-01f,
  6.25073537e-02f, 8.21688399e-02f, 9.45132822e-02f, 8.30115154e-02f, -6.34627193e-02f, 6.44490942e-02f, -1.97569907e-01f, -1.57042682e-01f, -7.10812435e-02f, -7.25939423e-02f,
  3.80899757e-02f, 9.75801721e-02f, 3.62053327e-02f, 4.56779189e-02f, 1.36665612e-01f, -2.18413502e-01f, 2.45234430e-01f, -2.06446528e-01f, 1.29429564e-01f, 1.57443002e-01f,
  4.20412421e-02f, 8.88894647e-02f, 3.76865342e-02f, 1.05184481e-01f, -2.03527167e-01f, -2.34847739e-01f, -1.91158667e-01f, -3.28943878e-01f, 1.71279073e-01f, 2.92977065e-01f,
  -4.83700968e-02f, 1.30571797e-01f, -8.25588554e-02f, -1.97166830e-01f, -3.12275410e-01f, 1.07039914e-01f, -7.08330236e-03f, 1.82631254e-01f, -1.25027195e-01f, 6.76336288e-02f,
  3.64628285e-02f, 4.13530856e-01f, 1.45078331e-01f, 6.11502975e-02f, 2.46868265e-04f, -1.88946232e-01f, -1.10854402e-01f, -2.30383188e-01f, 8.44046324e-02f, -1.63797557e-01f,
  1.28321454e-01f, 1.50832787e-01f, 1.83267981e-01f, -1.64871410e-01f, -1.98899820e-01f, 8.11847821e-02f, 1.15598686e-01f, 2.11499572e-01f, -2.37317935e-01f, -1.39774650e-01f,
  -1.72273695e-01f, -1.21320471e-01f, -1.27167746e-01f, 2.25118250e-01f, 1.56975091e-01f, -1.21179335e-02f, -7.31178150e-02f, -4.73150074e-01f, 2.03017667e-01f, -2.90435106e-01f,
  -3.81278485e-01f, -4.45359021e-01f, -2.42546156e-01f, 6.04924746e-03f, 3.81965697e-01f, 1.94955066e-01f, 2.72713631e-01f, -3.15065235e-01f, 1.46942720e-01f, -3.97696346e-01f,
  -3.67233455e-01f, 1.13586634e-01f, -1.65444583e-01f, -3.57437640e-01f, -7.51769692e-02f, 2.88651753e-02f, -2.03046441e-01f, 1.68520212e-01f, 1.75667137e-01f, 1.76052555e-01f,
  1.14632651e-01f, 7.65684694e-02f, -5.30033112e-02f, -1.22478111e-02f, -3.38408500e-02f, 1.91945270e-01f, 1.26687422e-01f, -2.33125597e-01f, -1.70211866e-02f, -2.85614673e-02f,
  -3.09574604e-02f, -1.81643024e-01f, 4.17408682e-02f, 2.89605353e-02f, 2.25059269e-03f, 4.62051593e-02f, -7.06376333e-04f, 1.59297779e-01f, -1.28164038e-01f, 8.62387270e-02f,
  5.54906838e-02f, 1.51536480e-01f, 1.08780516e-02f, 2.17664447e-02f, 5.75600825e-02f, -8.84578228e-02f, -1.05996862e-01f, -1.43516734e-01f, 1.53542131e-01f, -2.26395309e-01f,
  -1.64207313e-02f, 1.79405108e-01f, 8.02956223e-02f, -2.74348199e-01f, -3.94383026e-03f, 1.65301353e-01f, 1.19894117e-01f, -1.22344658e-01f, -6.11027591e-02f, 5.66380247e-02f,
  2.30707792e-05f, -3.54901999e-02f, 5.76902181e-02f, 4.04773951e-02f, 2.30251655e-01f, 4.72844094e-02f, -8.65138248e-02f, -4.83388035e-03f, -6.92149159e-03f, -1.17014088e-02f,
  -9.11319107e-02f, -1.04350984e-01f, -3.38968188e-01f, 1.47597700e-01f, -3.48079830e-01f, 1.82911292e-01f, 1.18167281e-01f, 1.14781640e-01f, 3.25201191e-02f, 2.41031259e-01f,
  -1.17582768e-01f, -3.63883376e-01f, -2.16412261e-01f, -3.96893889e-01f, -2.79214293e-01f, 2.05755919e-01f, 8.39259401e-02f, -2.59164780e-01f, -5.65221242e-04f, 1.39202327e-01f,
  -2.38033220e-01f, -5.21465316e-02f, 3.09598267e-01f, 5.84870502e-02f, 3.43388058e-02f, 1.13092512e-01f, -1.46757782e-01f, -1.87983409e-01f, 8.61509237e-03f, 1.18875587e-02f,
  1.27987668e-01f, 3.30524802e-01f, -1.39131933e-01f, -1.56082660e-01f, 2.09805164e-02f, -2.00149804e-01f, 4.79129478e-02f, -9.39013138e-02f, -1.84316039e-01f, -8.42708424e-02f,
  8.65930915e-02f, -4.92053553e-02f, -2.00831279e-01f, 1.06832735e-01f, 1.68916151e-01f, -4.56763469e-02f, -2.63974845e-01f, -9.03353840e-02f, 3.37575674e-01f, 3.03872019e-01f,
  1.65461987e-01f, 1.41897604e-01f, -2.31094569e-01f, 2.50464559e-01f, -4.45525080e-01f, 7.01258183e-02f, 2.14622840e-01f, -3.63001019e-01f, -1.65828876e-02f, -1.06564775e-01f,
  5.81023283e-02f, -5.33245020e-02f, -6.30599558e-02f, 1.70133799e-01f, -1.76768720e-01f, 1.72902569e-02f, 1.31711900e-01f, -7.57276416e-01f, -4.35774267e-01f, -2.45127697e-02f,
  1.46773279e-01f, 2.33153075e-01f, 2.20495909e-01f, 5.18476479e-02f, -1.10238992e-01f, 1.73082426e-01f, 3.67952771e-02f, 4.58191298e-02f, 8.75113234e-02f, -4.68864888e-02f,
  -1.13777556e-01f, -1.64585248e-01f, -1.54831167e-02f, -1.22868612e-01f, 5.10268025e-02f, 1.70767635e-01f, -3.62890251e-02f, -1.23005934e-01f, 1.96852908e-01f, 1.22920863e-01f,
  1.31924421e-01f, 1.46412984e-01f, 2.50359420e-02f, 1.47063494e-01f, 1.23102129e-01f, -2.09432170e-02f, 9.85219255e-02f, -1.50386319e-01f, 1.60025254e-01f, -1.08224690e-01f,
  1.32846117e-01f, -5.05438335e-02f, 4.95956140e-03f, 1.50703162e-01f, 6.96675330e-02f, 6.44725710e-02f, -1.19886724e-02f, 1.10557228e-01f, -8.23205337e-02f, 1.04388267e-01f,
  -9.23392847e-02f, 1.32564545e-01f, -1.15983821e-01f, -2.10819870e-01f, 3.46554480e-02f, -5.05044051e-02f, 4.79599461e-02f, -3.91366892e-02f, -1.28994614e-01f, -6.10802919e-02f,
  1.35874808e-01f, -2.19649523e-01f, -1.55751243e-01f, -3.87906563e-03f, -1.03388540e-01f, -6.26323223e-02f, 1.99204728e-01f, 4.76357937e-02f, -5.80163263e-02f, -2.38283828e-01f,
  -2.20140621e-01f, 4.39875089e-02f, 1.60502747e-01f, -4.54271436e-01f, -3.31281722e-02f, -3.10632616e-01f, -8.01871121e-02f, 2.42699429e-01f, -2.86972802e-02f, -1.17576294e-01f,
  -3.40993136e-01f, 1.34128019e-01f, -4.92679067e-02f, 1.62158519e-01f, -2.07141578e-01f, 2.13607967e-01f, 3.81487280e-01f, -2.13132858e-01f, -1.84472457e-01f, -2.68080473e-01f,
  -2.14770138e-02f, -1.55695230e-01f, 1.40531167e-01f, 2.39315048e-01f, 2.69732684e-01f, 1.02632053e-01f, 2.05830514e-01f, -5.09810448e-02f, -2.72526354e-01f, -3.71475071e-01f,
  7.01636076e-02f, 8.09888393e-02f, -1.65274158e-01f, 2.61611611e-01f, -2.11822852e-01f, 1.62392721e-01f, 3.73060107e-01f, -8.36414620e-02f, -1.85145587e-01f, 2.13538647e-01f,
  6.74624816e-02f, -5.17363250e-02f, 2.90565997e-01f, -2.04490796e-01f, 2.06820488e-01f, -2.19378486e-01f, 2.46220842e-01f, 3.19360718e-02f, 2.27997720e-01f, -4.26588446e-01f,
  7.96744898e-02f, -2.69687235e-01f, -1.96308270e-01f, -1.42067089e-03f, 1.88442752e-01f, -4.69010562e-01f, 6.13744520e-02f, 1.98431820e-01f, -4.14990708e-02f, 7.92424828e-02f,
  -3.59683096e-01f, 2.66762108e-01f, -1.12638779e-01f, 2.84198206e-02f, 1.92351505e-01f, 1.85049370e-01f, -5.09564519e-01f, -4.58835304e-01f, -3.78437787e-01f, 9.65648443e-02f,
  2.35433485e-02f, -1.77272573e-01f, 1.98941559e-01f, -6.18841313e-03f, -4.76816259e-02f, 5.97456172e-02f, 1.16695009e-01f, 3.16599719e-02f, -8.95626992e-02f, -1.75872639e-01f,
  1.20204836e-01f, 7.18438923e-02f, -2.29138583e-01f, -8.28155354e-02f, -1.18659526e-01f, -3.47108990e-02f, 1.65420875e-01f, 1.29452422e-01f, -1.29140094e-01f, 2.05367338e-03f,
  -1.12324268e-01f, 7.12388530e-02f, 1.57463625e-01f, -9.51397121e-02f, 1.25193419e-02f, 1.07165016e-02f, 5.72619028e-02f, -1.39308393e-01f, -1.05518296e-01f, -3.09359259e-03f,
  -1.22931950e-01f, -6.88228607e-02f, -2.08353952e-01f, -1.34745583e-01f, 7.85451755e-02f, -3.21021900e-02f, 9.81807411e-02f, 1.33526921e-01f, -1.70488477e-01f, 1.51314333e-01f,
  -9.03357863e-02f, -1.31948754e-01f, 4.32086103e-02f, 1.90933570e-02f, -1.89435836e-02f, -1.51537880e-01f, -1.80968642e-02f, 1.12474695e-01f, -9.67767388e-02f, -1.63368046e-01f,
  -1.54131636e-01f, 2.34279502e-02f, -2.33861238e-01f, -1.32355154e-01f, 3.65321860e-02f, 1.38954157e-02f, -1.14647493e-01f, -2.37285476e-02f, 2.62670696e-01f, -3.13345760e-01f,
  -5.74056618e-02f, -2.04691425e-01f, -2.93619573e-01f, -2.02786207e-01f, -2.01922327e-01f, -2.02678517e-01f, 2.78761476e-01f, -2.38235872e-02f, -5.23803430e-03f, 6.09137639e-02f,
  -1.91721216e-01f, 5.71407825e-02f, 8.27349424e-02f, -3.11480135e-01f, -6.50873482e-02f, -3.39030236e-01f, 2.48751551e-01f, -2.02099487e-01f, -1.10892393e-01f, 5.42111658e-02f,
  -1.51264295e-01f, 7.87658989e-02f, -1.62043437e-01f, 1.12295188e-01f, -1.54682830e-01f, -1.08927876e-01f, -3.34983133e-02f, 6.30336627e-02f, -2.29276881e-01f, 1.47110179e-01f,
  -5.15879318e-02f, -1.62347063e-01f, -4.90164869e-02f, -1.30398139e-01f, -1.41821787e-01f, -2.39289626e-01f, -9.23663080e-02f, 2.53988057e-01f, -1.86709762e-01f, 9.33727324e-02f,
  -1.21517234e-01f, 9.95787680e-02f, -1.13973886e-01f, 2.52394289e-01f, -2.81834394e-01f, -2.78706849e-01f, -2.78078943e-01f, -1.40635505e-01f, 1.84556112e-01f, -2.53114432e-01f,
  2.80327976e-01f, -1.26058564e-01f, -1.63927287e-01f, 2.02381715e-01f, -3.77644718e-01f, -3.66980731e-01f, -1.14000179e-01f, 1.53497308e-01f, 3.60185862e-01f, -3.07518601e-01f,
  1.98925704e-01f, 1.49476854e-02f, -4.68259573e-01f, -2.69607514e-01f, -2.62497693e-01f, 2.65428573e-02f, -3.91526520e-01f, -6.32404303e-03f, -2.80404121e-01f, -3.74519706e-01f,
  1.46382198e-01f, -4.11703557e-01f, -1.86711431e-01f, -2.16857955e-01f, 8.91956687e-02f, -1.65939361e-01f, -3.00690643e-02f, 1.26452774e-01f, -8.19716752e-02f, 3.20541292e-01f,
  1.42927676e-01f, 1.69972286e-01f, -1.86257437e-02f, -2.28693727e-02f, -1.63040012e-01f, 1.49971202e-01f, 1.07643567e-01f, 7.76435211e-02f, -2.28594720e-01f, 1.33404031e-01f,
  -4.02824068e-03f, 1.54407069e-01f, 1.23079702e-01f, -9.87180229e-03f, 1.22018516e-01f, 3.78991403e-02f, 1.22182854e-01f, 7.39433020e-02f, 1.76544279e-01f, 1.48852319e-01f,
  -7.22261369e-02f, -8.88024196e-02f, -1.47645369e-01f, 1.09070197e-01f, -5.19763045e-02f, -6.81577250e-03f, -4.08709701e-03f, 1.41157582e-01f, -6.59525767e-02f, -1.55597061e-01f,
  -4.36834209e-02f, 7.57617950e-02f, 1.72926575e-01f, 2.56329983e-01f, 1.91030115e-01f, -7.88974911e-02f, 9.55025330e-02f, 1.30359456e-01f, -2.17860918e-02f, 2.89671887e-02f,
  1.62788957e-01f, 2.40732413e-02f, -7.67875910e-02f, 2.00582221e-02f, 1.22434519e-01f, 1.99325997e-02f, 2.42734533e-02f, 1.60218477e-01f, 1.11798987e-01f, 3.10727298e-01f,
  1.77965239e-01f, 3.13197464e-01f, 1.84058920e-01f, -7.38441870e-02f, -1.45144444e-02f, 1.70341030e-01f, -1.92138001e-01f, -1.05756842e-01f, -1.38566002e-01f, -1.74856082e-01f,
  -1.86537743e-01f, 1.52243465e-01f, 1.05416298e-01f, 1.73883736e-01f, 1.41548300e-02f, 1.92551956e-01f, 1.83270097e-01f, -2.82048404e-01f, -1.43968463e-02f, 1.34397477e-01f,
  2.38592669e-01f, 3.08291137e-01f, -3.17626953e-01f, -1.95185959e-01f, -1.54115960e-01f, 1.15489885e-01f, 2.53636658e-01f, 4.12135810e-01f, -9.39186960e-02f, 2.50237882e-01f,
  5.73289469e-02f, -1.13753289e-01f, 1.10849924e-02f, -1.14085414e-01f, -3.65939230e-01f, -2.14338303e-01f, 1.70790941e-01f, -4.71202731e-02f, 3.87905017e-02f, 3.44991498e-02f,
  1.64771080e-02f, 1.07135914e-01f, -1.11558074e-02f, -7.10172504e-02f, -3.44823927e-01f, 5.28922491e-02f, 2.62853950e-01f, -1.07331164e-01f, 1.01227790e-01f, -2.09640205e-01f,
  -2.09257618e-01f, 1.98024288e-01f, -1.68373138e-01f, -2.51997769e-01f, -3.08710188e-01f, 1.56917214e-01f, -1.20101236e-02f, -1.72247186e-01f, -2.33561426e-01f, -1.42535776e-01f,
  -2.20398679e-01f, 6.80641472e-01f, -3.80204022e-01f, 1.23578608e-01f, 1.13655649e-01f, -2.85608411e-01f, -1.09268211e-01f, 1.61749437e-01f, -2.70262688e-01f, -8.34218413e-02f,
  1.62200913e-01f, 1.35678723e-01f, -1.30993679e-01f, -1.37471601e-01f, 1.36656418e-01f, 1.93861425e-01f, -1.01380445e-01f, -1.46978676e-01f, 1.83597907e-01f, 4.50171158e-02f,
  1.23915605e-01f, 3.49987671e-02f, 2.45688632e-02f, 1.96024582e-01f, 4.68053296e-02f, 1.39565676e-01f, 5.09972721e-02f, -1.11723520e-01f, -1.43291231e-03f, -1.82572976e-01f,
  -2.42142782e-01f, -1.21553048e-01f, 2.13370785e-01f, 3.30630541e-02f, -7.60705471e-02f, 3.43600549e-02f, -5.05324975e-02f, 1.36818528e-01f, -2.02074684e-02f, 4.25661691e-02f,
  5.94933145e-02f, -4.94774617e-02f, 1.03005186e-01f, -1.67780474e-01f, 8.75870511e-03f, -3.16839740e-02f, 7.37737939e-02f, 3.61529626e-02f, 9.10012349e-02f, -2.56260574e-01f,
  -2.40483731e-01f, -2.25210756e-01f, -2.86837071e-01f, 1.65796950e-01f, 3.81916836e-02f, -1.68597877e-01f, 8.02608430e-02f, -5.98477647e-02f, 1.21469244e-01f, 9.63322073e-02f,
  4.99354228e-02f, -1.67785555e-01f, 1.27105415e-01f, 7.23180324e-02f, 2.39622667e-01f, -2.25556582e-01f, 1.93591118e-01f, 1.61582053e-01f, 1.26017362e-01f, -2.05829993e-01f,
  2.45847672e-01f, -3.23279083e-01f, 3.00813437e-01f, 1.35079980e-01f, 1.54549152e-01f, 3.62948626e-01f, 3.77398640e-01f, 2.23544061e-01f, -2.72195280e-01f, 2.47188747e-01f,
  5.69995008e-02f, 6.81330040e-02f, 1.83679000e-01f, 1.50577649e-01f, -3.87022525e-01f, 3.32630351e-02f, -1.79621920e-01f, -1.41325027e-01f, -3.49229574e-01f, -3.20791274e-01f,
  1.99603006e-01f, 1.46257887e-02f, 2.19239846e-01f, 2.56388485e-01f, 2.24851266e-01f, -3.11566889e-01f, -3.09296995e-01f, -1.13197546e-02f, 1.61339909e-01f, 5.94641024e-05f,
  -1.79373235e-01f, 1.65644467e-01f, 2.07068756e-01f, -2.00327441e-01f, -9.84266102e-02f, -1.15908034e-01f, -2.08248362e-01f, 1.06697366e-01f, 1.56298757e-01f, -3.39948796e-02f,
  -8.58580396e-02f, -2.82072783e-01f, -2.41841793e-01f, 1.48718476e-01f, -3.78001362e-01f, 1.56815201e-02f, -2.57675111e-01f, -6.89336136e-02f, 1.53733701e-01f, 1.84157178e-01f,
  5.44844642e-02f, 5.92067689e-02f, 1.32708102e-01f, -3.77946287e-01f, 3.13443244e-01f, 1.08478911e-01f, -4.07568991e-01f, 1.88223734e-01f, -2.63208896e-01f, -3.37848216e-01f,
  2.02852786e-01f, -1.04711637e-01f, 9.27584022e-02f, 1.78877726e-01f, -5.04179969e-02f, 1.44974306e-01f, -2.51997471e-01f, 9.34239626e-02f, 9.22559723e-02f, 5.72716370e-02f,
  2.14076370e-01f, 1.14328116e-01f, -8.32128618e-03f, 7.84822926e-02f, -8.20264593e-02f, -8.95936415e-02f, -9.40254629e-02f, 5.91589734e-02f, 4.83001471e-02f, 2.03088745e-01f,
  -1.73446968e-01f, -4.60265949e-02f, -7.55119100e-02f, -4.41093892e-02f, 1.67625576e-01f, -2.68410176e-01f, 5.48773073e-03f, 1.07496247e-01f, 1.10303886e-01f, -3.60242836e-02f,
  -1.65640727e-01f, 4.56583723e-02f, 3.82434502e-02f, 4.99442741e-02f, -1.62146479e-01f, -7.27640390e-02f, 7.03957491e-03f, -3.15428413e-02f, -1.35414436e-01f, 1.00263827e-01f,
  -2.31292784e-01f, -7.92603865e-02f, -7.49550834e-02f, 1.73639119e-01f, -2.25106090e-01f, 5.24493568e-02f, -1.86276715e-02f, 1.03363514e-01f, -2.30589304e-02f, 5.37026972e-02f,
  7.18756318e-02f, -9.90959555e-02f, -8.66024867e-02f, 1.02488831e-01f, -6.87091574e-02f, 2.65403502e-02f, 8.64717886e-02f, 6.01714887e-02f, 3.26952431e-03f, -2.68972069e-01f,
  -2.59493291e-01f, 1.21575707e-04f, 1.27689943e-01f, 1.50506645e-01f, -2.72748321e-01f, 2.05654189e-01f, 1.36757493e-01f, -1.38219431e-01f, -1.47514507e-01f, 1.90763026e-01f,
  -1.21684687e-03f, 2.54352510e-01f, 1.63189456e-01f, 1.09255947e-01f, 1.64019570e-01f, 1.66791201e-01f, -7.31299222e-02f, 2.41757244e-01f, -4.23661992e-02f, -2.34022677e-01f,
  3.61369342e-01f, 2.54786700e-01f, 1.86231866e-01f, 1.07489899e-01f, -9.67378244e-02f, -8.78287107e-02f, 2.40846306e-01f, -9.91114229e-03f, 2.71603912e-01f, -4.58595455e-02f,
  -2.09376082e-01f, -3.30472231e-01f, 1.98360771e-01f, 7.29637742e-02f, 1.96978569e-01f, 1.82857424e-01f, -2.05071494e-01f, 3.27052355e-01f, -1.18337840e-01f, -2.98677552e-02f,
  7.05225393e-02f, -3.10530752e-01f, 1.85009882e-01f, -2.08847761e-01f, -3.97401989e-01f, -2.91136742e-01f, 1.70294344e-01f, 4.99319211e-02f, -3.05693895e-01f, 2.29530856e-01f,
  1.67891979e-01f, -2.13397190e-01f, -4.04882789e-01f, 1.31931961e-01f, 4.39121611e-02f, 2.73615539e-01f, -4.45311159e-01f, -5.41772554e-03f, 2.72562385e-01f, -9.80031043e-02f,
  3.55676591e-01f, -1.07005283e-01f, -4.30742085e-01f, -1.71900541e-01f, -1.13312051e-01f, 1.45993128e-01f, 2.49163993e-02f, -4.91003916e-02f, -2.33844936e-01f, -4.30819154e-01f,
  -2.65692115e-01f, 7.01404363e-02f, 1.59652174e-01f, 1.45189166e-01f, -2.87355552e-03f, -9.66809988e-02f, 4.97743627e-03f, -1.10641345e-01f, -1.07557438e-01f, -1.09210655e-01f,
  7.67631829e-02f, -9.61938128e-03f, -9.24435537e-03f, 5.37649691e-02f, -9.68184173e-02f, 1.09898746e-01f, -7.50819817e-02f, -1.14961863e-01f, -9.03790593e-02f, -9.42744687e-02f,
  -1.88452136e-02f, -2.04567425e-02f, -5.92160374e-02f, -1.04309186e-01f, -1.09112114e-01f, -1.03277080e-01f, 8.44337046e-03f, -2.34411005e-02f, -1.52796909e-01f, 8.22163299e-02f,
  5.64303510e-02f, 1.31285074e-03f, 4.96269129e-02f, -1.78402849e-02f, -6.40152693e-02f, -5.16234934e-02f, 8.69945511e-02f, -1.18500501e-01f, -5.18922880e-03f, -9.57563445e-02f,
  1.25397127e-02f, -1.10269368e-01f, -2.09770687e-02f, -9.97384489e-02f, -1.65430270e-02f, -1.74101293e-01f, -7.41998181e-02f, -4.72745374e-02f, -6.57215640e-02f, -8.76161382e-02f,
  -1.18815817e-01f, 1.45966634e-02f, 3.73984315e-02f, -5.76763116e-02f, -4.36744764e-02f, -1.19882613e-01f, 6.76538274e-02f, 1.24785127e-02f, 4.21001874e-02f, -1.58642177e-02f,
  -2.51876377e-02f, -1.64615065e-01f, 2.01230109e-01f, -1.29300043e-01f, 1.68493569e-01f, 1.05958812e-01f, -9.07917172e-02f, -2.19506770e-01f, -2.12928757e-01f, 5.18557951e-02f,
  5.01755886e-02f, 1.61465853e-01f, 1.82603985e-01f, 4.33812737e-02f, 1.75018638e-01f, -1.39929697e-01f, -1.43856276e-02f, 1.38475642e-01f, 1.86958775e-01f, 4.74009179e-02f,
  -1.11235484e-01f, 6.89412877e-02f, 1.51096461e-02f, 1.49166882e-01f, -1.90890282e-01f, -2.02338219e-01f, -1.90249011e-02f, 1.91867426e-01f, 1.14550821e-01f, -1.54237270e-01f,
  1.36990383e-01f, -4.70734723e-02f, 1.65078536e-01f, -1.49535954e-01f, 6.08725473e-02f, 6.02114834e-02f, -1.11620627e-01f, 1.08892724e-01f, -2.08086789e-01f, 4.20402512e-02f,
  6.66449592e-02f, 3.92104983e-02f, 1.22997157e-01f, -2.31637657e-01f, -1.59532368e-01f, 1.52388886e-01f, -1.60926014e-01f, 7.33593404e-02f, 1.32121161e-01f, -1.38398290e-01f,
  -3.36454690e-01f, -1.75598189e-01f, 2.18793049e-01f, -2.02858612e-01f, -1.86041772e-01f, 1.29314512e-01f, -2.11901993e-01f, 2.23159701e-01f, -1.90245748e-01f, -2.64300793e-01f,
  -2.94401646e-01f, -1.47452310e-01f, -2.44042262e-01f, -3.14247280e-01f, 2.87289083e-01f, 7.96120092e-02f, 9.27787051e-02f, 2.31654763e-01f, -2.61312157e-01f, 2.10958734e-01f,
  -1.30364001e-01f, -3.54696721e-01f, 2.43810669e-01f, -2.82264233e-01f, 8.23563114e-02f, 5.61866574e-02f, 6.19210079e-02f, 1.52641207e-01f, 5.09121493e-02f, 1.34024814e-01f,
  -6.18329756e-02f, -1.20495990e-01f, -1.10157087e-01f, -1.57540366e-01f, 3.51305529e-02f, 1.19873159e-01f, 1.26465329e-03f, 7.93265998e-02f, -6.91454187e-02f, -8.14389661e-02f,
  9.85858869e-03f, 5.80868572e-02f, 6.16830494e-03f, 8.06839690e-02f, -9.43482816e-02f, -1.52605325e-01f, -9.61350650e-02f, 1.07005639e-02f, -9.69911590e-02f, -6.72354549e-02f,
  6.76363558e-02f, -1.36397466e-01f, -4.50701676e-02f, 1.81192849e-02f, -1.23978354e-01f, 1.13317855e-01f, 7.25701749e-02f, -4.53839228e-02f, -3.51140425e-02f, -1.88623875e-01f,
  1.72490068e-02f, -2.04921812e-02f, -2.09732682e-01f, 5.16856201e-02f, -1.69727567e-03f, -7.40902126e-03f, 3.57432999e-02f, -2.16116980e-02f, 2.48923823e-02f, 2.03759894e-02f,
  2.90616270e-04f, 2.58245412e-02f, 1.18739335e-02f, -2.00922284e-02f, -1.06929295e-01f, -2.49039590e-01f, -7.48274196e-03f, -1.75892949e-01f, 6.16134005e-03f, 1.40703872e-01f,
  -1.94278106e-01f, -2.76411027e-01f, 1.50989383e-01f, 2.06287876e-01f, 1.58758789e-01f, -2.47339860e-01f, -2.77890377e-02f, -7.76312649e-02f, -1.34137515e-02f, -1.56050876e-01f,
  -9.38175842e-02f, 1.65529460e-01f, 1.75373092e-01f, 2.01991498e-02f, 1.82472169e-01f, 1.46222934e-01f, -5.27402610e-02f, -1.97764546e-01f, 1.62087768e-01f, -2.21098199e-01f,
  6.97327778e-02f, -6.84622675e-02f, -2.52212048e-01f, 2.80630529e-01f, -5.80479652e-02f, -3.09492182e-02f, -2.36381873e-01f, -1.66513696e-01f, -9.75823849e-02f, 1.43218517e-01f,
  -1.08696662e-01f, -2.34299064e-01f, -2.46312380e-01f, 2.09086493e-01f, 1.85368598e-01f, 1.54850736e-01f, -1.41275227e-01f, 4.54893187e-02f, 5.73200025e-02f, 1.22291222e-01f,
  9.17024240e-02f, -1.87397495e-01f, 1.84396550e-01f, 3.31714541e-01f, -2.15095431e-01f, -2.40088880e-01f, -9.63315815e-02f, -1.26860455e-01f, 2.84474671e-01f, -1.36714950e-02f,
  -1.16947055e-01f, -2.46432722e-01f, -1.65647119e-01f, -2.90829957e-01f, -5.36077358e-02f, 1.56678140e-01f, 2.37304926e-01f, -4.12996143e-01f, 6.05324544e-02f, -7.93692917e-02f,
  2.14310482e-01f, -2.53661517e-02f, -4.44295615e-01f, 1.41566610e-02f, 5.95045090e-01f, -8.44463482e-02f, 1.76140919e-01f, -1.55082405e-01f, 1.38794765e-01f, -3.49015146e-01f,
  1.01433009e-01f, -2.10579768e-01f, -1.45020202e-01f, 1.25101060e-01f, -3.19959432e-01f, -1.60215944e-01f, -7.87600502e-02f, -1.53389707e-01f, 1.22310612e-02f, -2.04385296e-01f,
  2.71475129e-02f, 3.49521488e-02f, -8.65003243e-02f, -2.92298514e-02f, -1.23777114e-01f, -1.35510474e-01f, -1.55165553e-01f, -1.79195702e-01f, 6.22750707e-02f, -3.01466826e-02f,
  5.58078988e-04f, 2.41723988e-04f, -8.82941112e-02f, 3.63550298e-02f, -1.64424241e-01f, -2.25526914e-02f, -2.32066989e-01f, 4.44031432e-02f, -1.01016715e-01f, -1.75119340e-01f,
  1.14064254e-02f, 1.06496789e-01f, 1.03532203e-01f, 8.30062628e-02f, 1.46388456e-01f, -2.14663848e-01f, 4.15430255e-02f, 7.85858035e-02f, 8.65731388e-02f, 1.61211580e-01f,
  4.67699394e-02f, 6.47143573e-02f, -2.20744744e-01f, -1.09942421e-01f, 1.36314221e-02f, -2.10104108e-01f, 3.10216006e-02f, 6.11887090e-02f, 8.16969424e-02f, 5.68892807e-02f,
  -1.05621316e-01f, -1.25000412e-02f, -1.60729036e-01f, 1.62565023e-01f, -1.85566083e-01f, 6.69069812e-02f, 2.01765418e-01f, 1.50589928e-01f, -1.93971619e-01f, 1.82905979e-02f,
  -3.10173444e-02f, -3.02449882e-01f, 8.77535641e-02f, 2.28215098e-01f, -1.68073505e-01f, 1.33247063e-01f, 2.40336984e-01f, 2.46258304e-01f, 1.97308809e-01f, -3.52822155e-01f,
  -2.23083854e-01f, 9.20951217e-02f, -6.23906143e-02f, 8.52940455e-02f, -2.22521927e-02f, 7.37075880e-03f, 8.97308886e-02f, 2.05866486e-01f, 9.94894579e-02f, -2.70214975e-01f,
  1.15901440e-01f, -1.98001146e-01f, -4.16496962e-01f, -1.22802436e-01f, -3.65613820e-03f, -7.65297711e-02f, 5.62733272e-03f, -3.24265212e-01f, 2.41992205e-01f, 1.21104762e-01f,
  1.09592684e-01f, -2.84906447e-01f, 7.15750903e-02f, 2.42738239e-02f, 2.79431939e-01f, 1.20044962e-01f, -7.12796748e-02f, 1.68386340e-01f, 2.63255984e-01f, 8.85180533e-02f,
  9.06725824e-02f, -2.50234157e-01f, 2.87259519e-01f, 1.70201167e-01f, 2.23050818e-01f, -1.79636270e-01f, -1.44062921e-01f, -2.31119469e-01f, -2.39324242e-01f, -6.42177537e-02f,
  -2.80576974e-01f, -8.26910958e-02f, 9.78484675e-02f, 1.63247719e-01f, -2.29493409e-01f, -2.13589057e-01f, -4.03161407e-01f, -2.61358500e-01f, -1.78029254e-01f, -3.59802037e-01f,
  1.55089766e-01f, 4.31522369e-01f, -1.69818327e-01f, -2.45998707e-02f, 1.74982965e-01f, -3.92459780e-01f, -3.48481417e-01f, 1.12224281e-01f, -2.26727515e-01f, 2.27539241e-01f,
  -2.17790976e-01f, -2.88621932e-01f, -2.43426651e-01f, 1.87350273e-01f, 9.16460082e-02f, 1.20046996e-02f, 4.07769158e-02f, -2.18623117e-01f, -1.42146766e-01f, 7.47359842e-02f,
  1.38001233e-01f, 1.90744922e-01f, -3.29840905e-03f, -4.33317795e-02f, -3.00571043e-02f, -1.14942625e-01f, -1.20506184e-02f, -1.76150620e-01f, -2.58092821e-01f, -1.56146660e-01f,
  -8.57531354e-02f, 7.46078417e-02f, 6.28250539e-02f, 2.02477068e-01f, -4.03794972e-03f, -1.72046840e-01f, 7.90478513e-02f, 2.03364976e-02f, 2.35284939e-02f, 9.21366736e-02f,
  -1.31431952e-01f, -1.33903995e-01f, -1.67827070e-01f, -1.69943631e-01f, -2.07961321e-01f, 8.91562831e-03f, 9.74075720e-02f, -1.04347780e-01f, 5.43279350e-02f, -2.25159246e-02f,
  4.18890156e-02f, -2.22385883e-01f, -1.18018001e-01f, -5.53654619e-02f, 3.74279842e-02f, -1.24887064e-01f, 1.33827716e-01f, -3.03798281e-02f, 6.31950796e-02f, 3.05694155e-02f,
  -7.55329058e-02f, 2.41432898e-02f, 9.48088244e-03f, 1.99613869e-01f, -2.58912355e-01f, 1.30237490e-01f, 2.50077963e-01f, -3.32580693e-02f, -2.86620796e-01f, 1.34980395e-01f,
  -1.28201261e-01f, -1.46762410e-03f, -2.21878499e-01f, -2.56328464e-01f, -5.53875864e-02f, 1.51622891e-01f, -8.12193453e-02f, -3.32387149e-01f, 2.01967597e-01f, -5.89330010e-02f,
  -4.46437486e-02f, -3.61262739e-01f, -1.43237904e-01f, 1.94362679e-03f, -1.09252959e-01f, 1.21839605e-01f, 2.43400767e-01f, 5.65721318e-02f, -8.06686375e-03f, 2.10488871e-01f,
  -1.38735965e-01f, -1.92642897e-01f, 1.61679745e-01f, 2.29829118e-01f, -1.69573352e-01f, 9.07814279e-02f, -2.44288966e-01f, 5.80197833e-02f, 2.33907625e-01f, -2.28737622e-01f,
  -9.80426222e-02f, -1.41813412e-01f, -1.92217514e-01f, 7.01915473e-02f, 1.49725899e-01f, 9.66599956e-02f, -2.85027236e-01f, 2.46711656e-01f, -6.69215918e-02f, -6.67115152e-02f,
  2.99579054e-01f, 2.95235425e-01f, 5.20477034e-02f, -3.49678814e-01f, -8.24283138e-02f, 3.00077856e-01f, -3.68740642e-03f, 1.59420535e-01f, -1.55816704e-01f, -1.58141982e-02f,
  1.14349358e-01f, 2.76752591e-01f, -3.25454056e-01f, 2.57491589e-01f, -2.49356523e-01f, -1.62650086e-02f, 2.29879305e-01f, 2.38776907e-01f, -5.80832958e-01f, -3.04256141e-01f,
  -2.22308740e-01f, -1.86595708e-01f, -1.10297911e-01f, 7.10889697e-02f, 7.79858902e-02f, 4.70558964e-02f, 2.52084672e-01f, -5.65408468e-02f, 2.38485802e-02f, -8.48635584e-02f,
  2.87802480e-02f, 5.33237457e-02f, 1.17512815e-01f, -1.71023365e-02f, 3.67438246e-04f, 1.07597210e-01f, 1.27537951e-01f, -3.03893425e-02f, 1.50858508e-02f, 4.67126397e-03f,
  1.46782771e-01f, -3.37058693e-01f, -1.44448057e-01f, -8.57923701e-02f, 8.37205797e-02f, 3.66364866e-02f, 8.07782635e-02f, 5.66939712e-02f, 5.45756593e-02f, 6.02783300e-02f,
  4.62661982e-02f, -6.49073049e-02f, -3.59432660e-02f, -1.18614314e-02f, -2.82301724e-01f, 1.30061628e-02f, 1.16206013e-01f, -1.10342845e-01f, -3.50426622e-02f, 5.16623408e-02f,
  -2.49935370e-02f, 9.32017788e-02f, 1.05890468e-01f, 6.09115586e-02f, 5.47304526e-02f, 8.40963572e-02f, -7.20235845e-03f, 1.25602618e-01f, 1.14308536e-01f, 5.60683087e-02f,
  -2.84713251e-03f, 4.06333730e-02f, 7.21844658e-03f, -1.42401442e-01f, 1.01201102e-01f, -2.09664598e-01f, -6.99422210e-02f, 3.87682803e-02f, -7.50430450e-02f, 9.19677764e-02f,
  1.41480118e-01f, -2.61612922e-01f, -9.53086838e-02f, 1.57712504e-01f, 2.24319071e-01f, 1.06847346e-01f, -1.84499502e-01f, -4.19555884e-03f, -2.55435020e-01f, -6.99233934e-02f,
  2.75780767e-01f, -4.73820083e-02f, 1.71306998e-01f, 1.79790810e-01f, 1.57503232e-01f, 2.21562818e-01f, -1.22353412e-01f, -2.08136037e-01f, -1.08964322e-02f, -2.09267944e-01f,
  -2.27904961e-01f, -2.06759013e-02f, -3.31556708e-01f, -5.99268377e-02f, -2.44905710e-01f, -1.82221100e-01f, 2.52683759e-01f, -1.44609530e-02f, 3.68379503e-01f, -2.35813469e-01f,
  -2.91788548e-01f, -2.55436808e-01f, -2.26078644e-01f, -1.47821888e-01f, 3.32381278e-01f, -2.10347280e-01f, 6.08812012e-02f, 2.01941803e-01f, 1.94922432e-01f, -3.32902521e-01f,
  1.11125968e-01f, 3.60582829e-01f, -1.08449999e-03f, -1.34584576e-01f, -1.00836888e-01f, 1.09903246e-01f, 2.15930715e-01f, -7.88151026e-02f, 3.64430100e-02f, -1.71596467e-01f,
  -1.04800500e-01f, 2.91457146e-01f, -2.40238175e-01f, -3.26380849e-01f, 8.17788541e-02f, 1.92907557e-01f, -2.54603952e-01f, 8.89121220e-02f, -3.62230450e-01f, -3.81020367e-01f,
  -2.39627331e-01f, 2.54869282e-01f, -4.03684646e-01f, -3.19787651e-01f, -8.22906122e-02f, 2.31361747e-01f, -1.18644029e-01f, -3.82316023e-01f, 6.98406041e-01f, -2.69116201e-02f,
  1.74704567e-01f, -4.48666275e-01f, 1.74967110e-01f, 4.78483066e-02f, -3.32671762e-01f, -1.81995884e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.09120728e-02f, -3.74870524e-02f, 4.87215221e-02f, -6.96097910e-02f, -2.06956342e-02f, 1.18301054e-02f, 1.37194828e-03f, -7.10425957e-04f, -9.18346737e-03f, -7.51921954e-03f,
  -5.38803637e-02f, 2.72679441e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    